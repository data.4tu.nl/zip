61991, 2.1130434782609, 1.1413043478261, 0.38888888888889
61992, 2.1130434782609, 1.1413043478261, 0.33333333333333
61993, 2.1130434782609, 1.1413043478261, 0.27777777777778
61994, 2.1130434782609, 1.1413043478261, 0.22222222222222
61995, 2.1130434782609, 1.1413043478261, 0.16666666666667
61996, 2.1130434782609, 1.1413043478261, 0.11111111111111
61997, 2.1130434782609, 1.1413043478261, 0.055555555555556
61998, 2.1565217391304, 1.1413043478261, 0.44444444444444
61999, 2.1565217391304, 1.1413043478261, 0.38888888888889
62000, 2.1565217391304, 1.1413043478261, 0.33333333333333
62001, 2.1565217391304, 1.1413043478261, 0.27777777777778
62002, 2.1565217391304, 1.1413043478261, 0.22222222222222
62003, 2.1565217391304, 1.1413043478261, 0.16666666666667
62004, 2.1565217391304, 1.1413043478261, 0.11111111111111
62005, 2.1565217391304, 1.1413043478261, 0.055555555555556
62006, 1.2434782608696, 1.0891304347826, 0.44444444444444
62007, 1.2434782608696, 1.0891304347826, 0.38888888888889
62008, 1.2434782608696, 1.0891304347826, 0.33333333333333
62009, 1.2434782608696, 1.0891304347826, 0.27777777777778
62010, 1.2434782608696, 1.0891304347826, 0.22222222222222
62011, 1.2434782608696, 1.0891304347826, 0.16666666666667
62012, 1.2434782608696, 1.0891304347826, 0.11111111111111
62013, 1.2434782608696, 1.0891304347826, 0.055555555555556
62014, 1.2869565217391, 1.0891304347826, 0.44444444444444
62015, 1.2869565217391, 1.0891304347826, 0.38888888888889
62016, 1.2869565217391, 1.0891304347826, 0.33333333333333
62017, 1.2869565217391, 1.0891304347826, 0.27777777777778
62018, 1.2869565217391, 1.0891304347826, 0.22222222222222
62019, 1.2869565217391, 1.0891304347826, 0.16666666666667
62020, 1.2869565217391, 1.0891304347826, 0.11111111111111
62021, 1.2869565217391, 1.0891304347826, 0.055555555555556
62022, 1.3304347826087, 1.0891304347826, 0.44444444444444
62023, 1.3304347826087, 1.0891304347826, 0.38888888888889
62024, 1.3304347826087, 1.0891304347826, 0.33333333333333
62025, 1.3304347826087, 1.0891304347826, 0.27777777777778
62026, 1.3304347826087, 1.0891304347826, 0.22222222222222
62027, 1.3304347826087, 1.0891304347826, 0.16666666666667
62028, 1.3304347826087, 1.0891304347826, 0.11111111111111
62029, 1.3304347826087, 1.0891304347826, 0.055555555555556
62030, 1.3739130434783, 1.0891304347826, 0.44444444444444
62031, 1.3739130434783, 1.0891304347826, 0.38888888888889
62032, 1.3739130434783, 1.0891304347826, 0.33333333333333
62033, 1.3739130434783, 1.0891304347826, 0.27777777777778
62034, 1.3739130434783, 1.0891304347826, 0.22222222222222
62035, 1.3739130434783, 1.0891304347826, 0.16666666666667
62036, 1.3739130434783, 1.0891304347826, 0.11111111111111
62037, 1.3739130434783, 1.0891304347826, 0.055555555555556
62038, 1.4173913043478, 1.0891304347826, 0.44444444444444
62039, 1.4173913043478, 1.0891304347826, 0.38888888888889
62040, 1.4173913043478, 1.0891304347826, 0.33333333333333
62041, 1.4173913043478, 1.0891304347826, 0.27777777777778
62042, 1.4173913043478, 1.0891304347826, 0.22222222222222
62043, 1.4173913043478, 1.0891304347826, 0.16666666666667
62044, 1.4173913043478, 1.0891304347826, 0.11111111111111
62045, 1.4173913043478, 1.0891304347826, 0.055555555555556
62046, 1.4608695652174, 1.0891304347826, 0.44444444444444
62047, 1.4608695652174, 1.0891304347826, 0.38888888888889
62048, 1.4608695652174, 1.0891304347826, 0.33333333333333
62049, 1.4608695652174, 1.0891304347826, 0.27777777777778
62050, 1.4608695652174, 1.0891304347826, 0.22222222222222
62051, 1.4608695652174, 1.0891304347826, 0.16666666666667
62052, 1.4608695652174, 1.0891304347826, 0.11111111111111
62053, 1.4608695652174, 1.0891304347826, 0.055555555555556
62054, 1.504347826087, 1.0891304347826, 0.44444444444444
62055, 1.504347826087, 1.0891304347826, 0.38888888888889
62056, 1.504347826087, 1.0891304347826, 0.33333333333333
62057, 1.504347826087, 1.0891304347826, 0.27777777777778
62058, 1.504347826087, 1.0891304347826, 0.22222222222222
62059, 1.504347826087, 1.0891304347826, 0.16666666666667
62060, 1.504347826087, 1.0891304347826, 0.11111111111111
62061, 1.504347826087, 1.0891304347826, 0.055555555555556
62062, 1.5478260869565, 1.0891304347826, 0.44444444444444
62063, 1.5478260869565, 1.0891304347826, 0.38888888888889
62064, 1.5478260869565, 1.0891304347826, 0.33333333333333
62065, 1.5478260869565, 1.0891304347826, 0.27777777777778
62066, 1.5478260869565, 1.0891304347826, 0.22222222222222
62067, 1.5478260869565, 1.0891304347826, 0.16666666666667
62068, 1.5478260869565, 1.0891304347826, 0.11111111111111
62069, 1.5478260869565, 1.0891304347826, 0.055555555555556
62070, 1.5913043478261, 1.0891304347826, 0.44444444444444
62071, 1.5913043478261, 1.0891304347826, 0.38888888888889
62072, 1.5913043478261, 1.0891304347826, 0.33333333333333
62073, 1.5913043478261, 1.0891304347826, 0.27777777777778
62074, 1.5913043478261, 1.0891304347826, 0.22222222222222
62075, 1.5913043478261, 1.0891304347826, 0.16666666666667
62076, 1.5913043478261, 1.0891304347826, 0.11111111111111
62077, 1.5913043478261, 1.0891304347826, 0.055555555555556
62078, 1.6347826086957, 1.0891304347826, 0.44444444444444
62079, 1.6347826086957, 1.0891304347826, 0.38888888888889
62080, 1.6347826086957, 1.0891304347826, 0.33333333333333
62081, 1.6347826086957, 1.0891304347826, 0.27777777777778
62082, 1.6347826086957, 1.0891304347826, 0.22222222222222
62083, 1.6347826086957, 1.0891304347826, 0.16666666666667
62084, 1.6347826086957, 1.0891304347826, 0.11111111111111
62085, 1.6347826086957, 1.0891304347826, 0.055555555555556
62086, 1.6782608695652, 1.0891304347826, 0.44444444444444
62087, 1.6782608695652, 1.0891304347826, 0.38888888888889
62088, 1.6782608695652, 1.0891304347826, 0.33333333333333
62089, 1.6782608695652, 1.0891304347826, 0.27777777777778
62090, 1.6782608695652, 1.0891304347826, 0.22222222222222
62091, 1.6782608695652, 1.0891304347826, 0.16666666666667
62092, 1.6782608695652, 1.0891304347826, 0.11111111111111
62093, 1.6782608695652, 1.0891304347826, 0.055555555555556
62094, 1.7217391304348, 1.0891304347826, 0.44444444444444
62095, 1.7217391304348, 1.0891304347826, 0.38888888888889
62096, 1.7217391304348, 1.0891304347826, 0.33333333333333
62097, 1.7217391304348, 1.0891304347826, 0.27777777777778
62098, 1.7217391304348, 1.0891304347826, 0.22222222222222
62099, 1.7217391304348, 1.0891304347826, 0.16666666666667
62100, 1.7217391304348, 1.0891304347826, 0.11111111111111
62101, 1.7217391304348, 1.0891304347826, 0.055555555555556
62102, 1.7652173913043, 1.0891304347826, 0.44444444444444
62103, 1.7652173913043, 1.0891304347826, 0.38888888888889
62104, 1.7652173913043, 1.0891304347826, 0.33333333333333
62105, 1.7652173913043, 1.0891304347826, 0.27777777777778
62106, 1.7652173913043, 1.0891304347826, 0.22222222222222
62107, 1.7652173913043, 1.0891304347826, 0.16666666666667
62108, 1.7652173913043, 1.0891304347826, 0.11111111111111
62109, 1.7652173913043, 1.0891304347826, 0.055555555555556
62110, 1.8086956521739, 1.0891304347826, 0.44444444444444
62111, 1.8086956521739, 1.0891304347826, 0.38888888888889
62112, 1.8086956521739, 1.0891304347826, 0.33333333333333
62113, 1.8086956521739, 1.0891304347826, 0.27777777777778
62114, 1.8086956521739, 1.0891304347826, 0.22222222222222
62115, 1.8086956521739, 1.0891304347826, 0.16666666666667
62116, 1.8086956521739, 1.0891304347826, 0.11111111111111
62117, 1.8086956521739, 1.0891304347826, 0.055555555555556
62118, 1.8521739130435, 1.0891304347826, 0.44444444444444
62119, 1.8521739130435, 1.0891304347826, 0.38888888888889
62120, 1.8521739130435, 1.0891304347826, 0.33333333333333
62121, 1.8521739130435, 1.0891304347826, 0.27777777777778
62122, 1.8521739130435, 1.0891304347826, 0.22222222222222
62123, 1.8521739130435, 1.0891304347826, 0.16666666666667
62124, 1.8521739130435, 1.0891304347826, 0.11111111111111
62125, 1.8521739130435, 1.0891304347826, 0.055555555555556
62126, 1.895652173913, 1.0891304347826, 0.44444444444444
62127, 1.895652173913, 1.0891304347826, 0.38888888888889
62128, 1.895652173913, 1.0891304347826, 0.33333333333333
62129, 1.895652173913, 1.0891304347826, 0.27777777777778
62130, 1.895652173913, 1.0891304347826, 0.22222222222222
62131, 1.895652173913, 1.0891304347826, 0.16666666666667
62132, 1.895652173913, 1.0891304347826, 0.11111111111111
62133, 1.895652173913, 1.0891304347826, 0.055555555555556
62134, 1.9391304347826, 1.0891304347826, 0.44444444444444
62135, 1.9391304347826, 1.0891304347826, 0.38888888888889
62136, 1.9391304347826, 1.0891304347826, 0.33333333333333
62137, 1.9391304347826, 1.0891304347826, 0.27777777777778
62138, 1.9391304347826, 1.0891304347826, 0.22222222222222
62139, 1.9391304347826, 1.0891304347826, 0.16666666666667
62140, 1.9391304347826, 1.0891304347826, 0.11111111111111
62141, 1.9391304347826, 1.0891304347826, 0.055555555555556
62142, 1.9826086956522, 1.0891304347826, 0.44444444444444
62143, 1.9826086956522, 1.0891304347826, 0.38888888888889
62144, 1.9826086956522, 1.0891304347826, 0.33333333333333
62145, 1.9826086956522, 1.0891304347826, 0.27777777777778
62146, 1.9826086956522, 1.0891304347826, 0.22222222222222
62147, 1.9826086956522, 1.0891304347826, 0.16666666666667
62148, 1.9826086956522, 1.0891304347826, 0.11111111111111
62149, 1.9826086956522, 1.0891304347826, 0.055555555555556
62150, 2.0260869565217, 1.0891304347826, 0.44444444444444
62151, 2.0260869565217, 1.0891304347826, 0.38888888888889
62152, 2.0260869565217, 1.0891304347826, 0.33333333333333
62153, 2.0260869565217, 1.0891304347826, 0.27777777777778
62154, 2.0260869565217, 1.0891304347826, 0.22222222222222
62155, 2.0260869565217, 1.0891304347826, 0.16666666666667
62156, 2.0260869565217, 1.0891304347826, 0.11111111111111
62157, 2.0260869565217, 1.0891304347826, 0.055555555555556
62158, 2.0695652173913, 1.0891304347826, 0.44444444444444
62159, 2.0695652173913, 1.0891304347826, 0.38888888888889
62160, 2.0695652173913, 1.0891304347826, 0.33333333333333
62161, 2.0695652173913, 1.0891304347826, 0.27777777777778
62162, 2.0695652173913, 1.0891304347826, 0.22222222222222
62163, 2.0695652173913, 1.0891304347826, 0.16666666666667
62164, 2.0695652173913, 1.0891304347826, 0.11111111111111
62165, 2.0695652173913, 1.0891304347826, 0.055555555555556
62166, 2.1130434782609, 1.0891304347826, 0.44444444444444
62167, 2.1130434782609, 1.0891304347826, 0.38888888888889
62168, 2.1130434782609, 1.0891304347826, 0.33333333333333
62169, 2.1130434782609, 1.0891304347826, 0.27777777777778
62170, 2.1130434782609, 1.0891304347826, 0.22222222222222
62171, 2.1130434782609, 1.0891304347826, 0.16666666666667
62172, 2.1130434782609, 1.0891304347826, 0.11111111111111
62173, 2.1130434782609, 1.0891304347826, 0.055555555555556
62174, 2.1565217391304, 1.0891304347826, 0.44444444444444
62175, 2.1565217391304, 1.0891304347826, 0.38888888888889
62176, 2.1565217391304, 1.0891304347826, 0.33333333333333
62177, 2.1565217391304, 1.0891304347826, 0.27777777777778
62178, 2.1565217391304, 1.0891304347826, 0.22222222222222
62179, 2.1565217391304, 1.0891304347826, 0.16666666666667
62180, 2.1565217391304, 1.0891304347826, 0.11111111111111
62181, 2.1565217391304, 1.0891304347826, 0.055555555555556
62182, 1.2434782608696, 1.0369565217391, 0.44444444444444
62183, 1.2434782608696, 1.0369565217391, 0.38888888888889
62184, 1.2434782608696, 1.0369565217391, 0.33333333333333
62185, 1.2434782608696, 1.0369565217391, 0.27777777777778
62186, 1.2434782608696, 1.0369565217391, 0.22222222222222
62187, 1.2434782608696, 1.0369565217391, 0.16666666666667
62188, 1.2434782608696, 1.0369565217391, 0.11111111111111
62189, 1.2434782608696, 1.0369565217391, 0.055555555555556
62190, 1.2869565217391, 1.0369565217391, 0.44444444444444
62191, 1.2869565217391, 1.0369565217391, 0.38888888888889
62192, 1.2869565217391, 1.0369565217391, 0.33333333333333
62193, 1.2869565217391, 1.0369565217391, 0.27777777777778
62194, 1.2869565217391, 1.0369565217391, 0.22222222222222
62195, 1.2869565217391, 1.0369565217391, 0.16666666666667
62196, 1.2869565217391, 1.0369565217391, 0.11111111111111
62197, 1.2869565217391, 1.0369565217391, 0.055555555555556
62198, 1.3304347826087, 1.0369565217391, 0.44444444444444
62199, 1.3304347826087, 1.0369565217391, 0.38888888888889
62200, 1.3304347826087, 1.0369565217391, 0.33333333333333
62201, 1.3304347826087, 1.0369565217391, 0.27777777777778
62202, 1.3304347826087, 1.0369565217391, 0.22222222222222
62203, 1.3304347826087, 1.0369565217391, 0.16666666666667
62204, 1.3304347826087, 1.0369565217391, 0.11111111111111
62205, 1.3304347826087, 1.0369565217391, 0.055555555555556
62206, 1.3739130434783, 1.0369565217391, 0.44444444444444
62207, 1.3739130434783, 1.0369565217391, 0.38888888888889
62208, 1.3739130434783, 1.0369565217391, 0.33333333333333
62209, 1.3739130434783, 1.0369565217391, 0.27777777777778
62210, 1.3739130434783, 1.0369565217391, 0.22222222222222
62211, 1.3739130434783, 1.0369565217391, 0.16666666666667
62212, 1.3739130434783, 1.0369565217391, 0.11111111111111
62213, 1.3739130434783, 1.0369565217391, 0.055555555555556
62214, 1.4173913043478, 1.0369565217391, 0.44444444444444
62215, 1.4173913043478, 1.0369565217391, 0.38888888888889
62216, 1.4173913043478, 1.0369565217391, 0.33333333333333
62217, 1.4173913043478, 1.0369565217391, 0.27777777777778
62218, 1.4173913043478, 1.0369565217391, 0.22222222222222
62219, 1.4173913043478, 1.0369565217391, 0.16666666666667
62220, 1.4173913043478, 1.0369565217391, 0.11111111111111
62221, 1.4173913043478, 1.0369565217391, 0.055555555555556
62222, 1.4608695652174, 1.0369565217391, 0.44444444444444
62223, 1.4608695652174, 1.0369565217391, 0.38888888888889
62224, 1.4608695652174, 1.0369565217391, 0.33333333333333
62225, 1.4608695652174, 1.0369565217391, 0.27777777777778
62226, 1.4608695652174, 1.0369565217391, 0.22222222222222
62227, 1.4608695652174, 1.0369565217391, 0.16666666666667
62228, 1.4608695652174, 1.0369565217391, 0.11111111111111
62229, 1.4608695652174, 1.0369565217391, 0.055555555555556
62230, 1.504347826087, 1.0369565217391, 0.44444444444444
62231, 1.504347826087, 1.0369565217391, 0.38888888888889
62232, 1.504347826087, 1.0369565217391, 0.33333333333333
62233, 1.504347826087, 1.0369565217391, 0.27777777777778
62234, 1.504347826087, 1.0369565217391, 0.22222222222222
62235, 1.504347826087, 1.0369565217391, 0.16666666666667
62236, 1.504347826087, 1.0369565217391, 0.11111111111111
62237, 1.504347826087, 1.0369565217391, 0.055555555555556
62238, 1.5478260869565, 1.0369565217391, 0.44444444444444
62239, 1.5478260869565, 1.0369565217391, 0.38888888888889
62240, 1.5478260869565, 1.0369565217391, 0.33333333333333
62241, 1.5478260869565, 1.0369565217391, 0.27777777777778
62242, 1.5478260869565, 1.0369565217391, 0.22222222222222
62243, 1.5478260869565, 1.0369565217391, 0.16666666666667
62244, 1.5478260869565, 1.0369565217391, 0.11111111111111
62245, 1.5478260869565, 1.0369565217391, 0.055555555555556
62246, 1.5913043478261, 1.0369565217391, 0.44444444444444
62247, 1.5913043478261, 1.0369565217391, 0.38888888888889
62248, 1.5913043478261, 1.0369565217391, 0.33333333333333
62249, 1.5913043478261, 1.0369565217391, 0.27777777777778
62250, 1.5913043478261, 1.0369565217391, 0.22222222222222
62251, 1.5913043478261, 1.0369565217391, 0.16666666666667
62252, 1.5913043478261, 1.0369565217391, 0.11111111111111
62253, 1.5913043478261, 1.0369565217391, 0.055555555555556
62254, 1.6347826086957, 1.0369565217391, 0.44444444444444
62255, 1.6347826086957, 1.0369565217391, 0.38888888888889
62256, 1.6347826086957, 1.0369565217391, 0.33333333333333
62257, 1.6347826086957, 1.0369565217391, 0.27777777777778
62258, 1.6347826086957, 1.0369565217391, 0.22222222222222
62259, 1.6347826086957, 1.0369565217391, 0.16666666666667
62260, 1.6347826086957, 1.0369565217391, 0.11111111111111
62261, 1.6347826086957, 1.0369565217391, 0.055555555555556
62262, 1.6782608695652, 1.0369565217391, 0.44444444444444
62263, 1.6782608695652, 1.0369565217391, 0.38888888888889
62264, 1.6782608695652, 1.0369565217391, 0.33333333333333
62265, 1.6782608695652, 1.0369565217391, 0.27777777777778
62266, 1.6782608695652, 1.0369565217391, 0.22222222222222
62267, 1.6782608695652, 1.0369565217391, 0.16666666666667
62268, 1.6782608695652, 1.0369565217391, 0.11111111111111
62269, 1.6782608695652, 1.0369565217391, 0.055555555555556
62270, 1.7217391304348, 1.0369565217391, 0.44444444444444
62271, 1.7217391304348, 1.0369565217391, 0.38888888888889
62272, 1.7217391304348, 1.0369565217391, 0.33333333333333
62273, 1.7217391304348, 1.0369565217391, 0.27777777777778
62274, 1.7217391304348, 1.0369565217391, 0.22222222222222
62275, 1.7217391304348, 1.0369565217391, 0.16666666666667
62276, 1.7217391304348, 1.0369565217391, 0.11111111111111
62277, 1.7217391304348, 1.0369565217391, 0.055555555555556
62278, 1.7652173913043, 1.0369565217391, 0.44444444444444
62279, 1.7652173913043, 1.0369565217391, 0.38888888888889
62280, 1.7652173913043, 1.0369565217391, 0.33333333333333
62281, 1.7652173913043, 1.0369565217391, 0.27777777777778
62282, 1.7652173913043, 1.0369565217391, 0.22222222222222
62283, 1.7652173913043, 1.0369565217391, 0.16666666666667
62284, 1.7652173913043, 1.0369565217391, 0.11111111111111
62285, 1.7652173913043, 1.0369565217391, 0.055555555555556
62286, 1.8086956521739, 1.0369565217391, 0.44444444444444
62287, 1.8086956521739, 1.0369565217391, 0.38888888888889
62288, 1.8086956521739, 1.0369565217391, 0.33333333333333
62289, 1.8086956521739, 1.0369565217391, 0.27777777777778
62290, 1.8086956521739, 1.0369565217391, 0.22222222222222
62291, 1.8086956521739, 1.0369565217391, 0.16666666666667
62292, 1.8086956521739, 1.0369565217391, 0.11111111111111
62293, 1.8086956521739, 1.0369565217391, 0.055555555555556
62294, 1.8521739130435, 1.0369565217391, 0.44444444444444
62295, 1.8521739130435, 1.0369565217391, 0.38888888888889
62296, 1.8521739130435, 1.0369565217391, 0.33333333333333
62297, 1.8521739130435, 1.0369565217391, 0.27777777777778
62298, 1.8521739130435, 1.0369565217391, 0.22222222222222
62299, 1.8521739130435, 1.0369565217391, 0.16666666666667
62300, 1.8521739130435, 1.0369565217391, 0.11111111111111
62301, 1.8521739130435, 1.0369565217391, 0.055555555555556
62302, 1.895652173913, 1.0369565217391, 0.44444444444444
62303, 1.895652173913, 1.0369565217391, 0.38888888888889
62304, 1.895652173913, 1.0369565217391, 0.33333333333333
62305, 1.895652173913, 1.0369565217391, 0.27777777777778
62306, 1.895652173913, 1.0369565217391, 0.22222222222222
62307, 1.895652173913, 1.0369565217391, 0.16666666666667
62308, 1.895652173913, 1.0369565217391, 0.11111111111111
62309, 1.895652173913, 1.0369565217391, 0.055555555555556
62310, 1.9391304347826, 1.0369565217391, 0.44444444444444
62311, 1.9391304347826, 1.0369565217391, 0.38888888888889
62312, 1.9391304347826, 1.0369565217391, 0.33333333333333
62313, 1.9391304347826, 1.0369565217391, 0.27777777777778
62314, 1.9391304347826, 1.0369565217391, 0.22222222222222
62315, 1.9391304347826, 1.0369565217391, 0.16666666666667
62316, 1.9391304347826, 1.0369565217391, 0.11111111111111
62317, 1.9391304347826, 1.0369565217391, 0.055555555555556
62318, 1.9826086956522, 1.0369565217391, 0.44444444444444
62319, 1.9826086956522, 1.0369565217391, 0.38888888888889
62320, 1.9826086956522, 1.0369565217391, 0.33333333333333
62321, 1.9826086956522, 1.0369565217391, 0.27777777777778
62322, 1.9826086956522, 1.0369565217391, 0.22222222222222
62323, 1.9826086956522, 1.0369565217391, 0.16666666666667
62324, 1.9826086956522, 1.0369565217391, 0.11111111111111
62325, 1.9826086956522, 1.0369565217391, 0.055555555555556
62326, 2.0260869565217, 1.0369565217391, 0.44444444444444
62327, 2.0260869565217, 1.0369565217391, 0.38888888888889
62328, 2.0260869565217, 1.0369565217391, 0.33333333333333
62329, 2.0260869565217, 1.0369565217391, 0.27777777777778
62330, 2.0260869565217, 1.0369565217391, 0.22222222222222
62331, 2.0260869565217, 1.0369565217391, 0.16666666666667
62332, 2.0260869565217, 1.0369565217391, 0.11111111111111
62333, 2.0260869565217, 1.0369565217391, 0.055555555555556
62334, 2.0695652173913, 1.0369565217391, 0.44444444444444
62335, 2.0695652173913, 1.0369565217391, 0.38888888888889
62336, 2.0695652173913, 1.0369565217391, 0.33333333333333
62337, 2.0695652173913, 1.0369565217391, 0.27777777777778
62338, 2.0695652173913, 1.0369565217391, 0.22222222222222
62339, 2.0695652173913, 1.0369565217391, 0.16666666666667
62340, 2.0695652173913, 1.0369565217391, 0.11111111111111
62341, 2.0695652173913, 1.0369565217391, 0.055555555555556
62342, 2.1130434782609, 1.0369565217391, 0.44444444444444
62343, 2.1130434782609, 1.0369565217391, 0.38888888888889
62344, 2.1130434782609, 1.0369565217391, 0.33333333333333
62345, 2.1130434782609, 1.0369565217391, 0.27777777777778
62346, 2.1130434782609, 1.0369565217391, 0.22222222222222
62347, 2.1130434782609, 1.0369565217391, 0.16666666666667
62348, 2.1130434782609, 1.0369565217391, 0.11111111111111
62349, 2.1130434782609, 1.0369565217391, 0.055555555555556
62350, 2.1565217391304, 1.0369565217391, 0.44444444444444
62351, 2.1565217391304, 1.0369565217391, 0.38888888888889
62352, 2.1565217391304, 1.0369565217391, 0.33333333333333
62353, 2.1565217391304, 1.0369565217391, 0.27777777777778
62354, 2.1565217391304, 1.0369565217391, 0.22222222222222
62355, 2.1565217391304, 1.0369565217391, 0.16666666666667
62356, 2.1565217391304, 1.0369565217391, 0.11111111111111
62357, 2.1565217391304, 1.0369565217391, 0.055555555555556
62358, 1.2434782608696, 0.98478260869565, 0.44444444444444
62359, 1.2434782608696, 0.98478260869565, 0.38888888888889
62360, 1.2434782608696, 0.98478260869565, 0.33333333333333
62361, 1.2434782608696, 0.98478260869565, 0.27777777777778
62362, 1.2434782608696, 0.98478260869565, 0.22222222222222
62363, 1.2434782608696, 0.98478260869565, 0.16666666666667
62364, 1.2434782608696, 0.98478260869565, 0.11111111111111
62365, 1.2434782608696, 0.98478260869565, 0.055555555555556
62366, 1.2869565217391, 0.98478260869565, 0.44444444444444
62367, 1.2869565217391, 0.98478260869565, 0.38888888888889
62368, 1.2869565217391, 0.98478260869565, 0.33333333333333
62369, 1.2869565217391, 0.98478260869565, 0.27777777777778
62370, 1.2869565217391, 0.98478260869565, 0.22222222222222
62371, 1.2869565217391, 0.98478260869565, 0.16666666666667
62372, 1.2869565217391, 0.98478260869565, 0.11111111111111
62373, 1.2869565217391, 0.98478260869565, 0.055555555555556
62374, 1.3304347826087, 0.98478260869565, 0.44444444444444
62375, 1.3304347826087, 0.98478260869565, 0.38888888888889
62376, 1.3304347826087, 0.98478260869565, 0.33333333333333
62377, 1.3304347826087, 0.98478260869565, 0.27777777777778
62378, 1.3304347826087, 0.98478260869565, 0.22222222222222
62379, 1.3304347826087, 0.98478260869565, 0.16666666666667
62380, 1.3304347826087, 0.98478260869565, 0.11111111111111
62381, 1.3304347826087, 0.98478260869565, 0.055555555555556
62382, 1.3739130434783, 0.98478260869565, 0.44444444444444
62383, 1.3739130434783, 0.98478260869565, 0.38888888888889
62384, 1.3739130434783, 0.98478260869565, 0.33333333333333
62385, 1.3739130434783, 0.98478260869565, 0.27777777777778
62386, 1.3739130434783, 0.98478260869565, 0.22222222222222
62387, 1.3739130434783, 0.98478260869565, 0.16666666666667
62388, 1.3739130434783, 0.98478260869565, 0.11111111111111
62389, 1.3739130434783, 0.98478260869565, 0.055555555555556
62390, 1.4173913043478, 0.98478260869565, 0.44444444444444
62391, 1.4173913043478, 0.98478260869565, 0.38888888888889
62392, 1.4173913043478, 0.98478260869565, 0.33333333333333
62393, 1.4173913043478, 0.98478260869565, 0.27777777777778
62394, 1.4173913043478, 0.98478260869565, 0.22222222222222
62395, 1.4173913043478, 0.98478260869565, 0.16666666666667
62396, 1.4173913043478, 0.98478260869565, 0.11111111111111
62397, 1.4173913043478, 0.98478260869565, 0.055555555555556
62398, 1.4608695652174, 0.98478260869565, 0.44444444444444
62399, 1.4608695652174, 0.98478260869565, 0.38888888888889
62400, 1.4608695652174, 0.98478260869565, 0.33333333333333
62401, 1.4608695652174, 0.98478260869565, 0.27777777777778
62402, 1.4608695652174, 0.98478260869565, 0.22222222222222
62403, 1.4608695652174, 0.98478260869565, 0.16666666666667
62404, 1.4608695652174, 0.98478260869565, 0.11111111111111
62405, 1.4608695652174, 0.98478260869565, 0.055555555555556
62406, 1.504347826087, 0.98478260869565, 0.44444444444444
62407, 1.504347826087, 0.98478260869565, 0.38888888888889
62408, 1.504347826087, 0.98478260869565, 0.33333333333333
62409, 1.504347826087, 0.98478260869565, 0.27777777777778
62410, 1.504347826087, 0.98478260869565, 0.22222222222222
62411, 1.504347826087, 0.98478260869565, 0.16666666666667
62412, 1.504347826087, 0.98478260869565, 0.11111111111111
62413, 1.504347826087, 0.98478260869565, 0.055555555555556
62414, 1.5478260869565, 0.98478260869565, 0.44444444444444
62415, 1.5478260869565, 0.98478260869565, 0.38888888888889
62416, 1.5478260869565, 0.98478260869565, 0.33333333333333
62417, 1.5478260869565, 0.98478260869565, 0.27777777777778
62418, 1.5478260869565, 0.98478260869565, 0.22222222222222
62419, 1.5478260869565, 0.98478260869565, 0.16666666666667
62420, 1.5478260869565, 0.98478260869565, 0.11111111111111
62421, 1.5478260869565, 0.98478260869565, 0.055555555555556
62422, 1.5913043478261, 0.98478260869565, 0.44444444444444
62423, 1.5913043478261, 0.98478260869565, 0.38888888888889
62424, 1.5913043478261, 0.98478260869565, 0.33333333333333
62425, 1.5913043478261, 0.98478260869565, 0.27777777777778
62426, 1.5913043478261, 0.98478260869565, 0.22222222222222
62427, 1.5913043478261, 0.98478260869565, 0.16666666666667
62428, 1.5913043478261, 0.98478260869565, 0.11111111111111
62429, 1.5913043478261, 0.98478260869565, 0.055555555555556
62430, 1.6347826086957, 0.98478260869565, 0.44444444444444
62431, 1.6347826086957, 0.98478260869565, 0.38888888888889
62432, 1.6347826086957, 0.98478260869565, 0.33333333333333
62433, 1.6347826086957, 0.98478260869565, 0.27777777777778
62434, 1.6347826086957, 0.98478260869565, 0.22222222222222
62435, 1.6347826086957, 0.98478260869565, 0.16666666666667
62436, 1.6347826086957, 0.98478260869565, 0.11111111111111
62437, 1.6347826086957, 0.98478260869565, 0.055555555555556
62438, 1.6782608695652, 0.98478260869565, 0.44444444444444
62439, 1.6782608695652, 0.98478260869565, 0.38888888888889
62440, 1.6782608695652, 0.98478260869565, 0.33333333333333
62441, 1.6782608695652, 0.98478260869565, 0.27777777777778
62442, 1.6782608695652, 0.98478260869565, 0.22222222222222
62443, 1.6782608695652, 0.98478260869565, 0.16666666666667
62444, 1.6782608695652, 0.98478260869565, 0.11111111111111
62445, 1.6782608695652, 0.98478260869565, 0.055555555555556
62446, 1.7217391304348, 0.98478260869565, 0.44444444444444
62447, 1.7217391304348, 0.98478260869565, 0.38888888888889
62448, 1.7217391304348, 0.98478260869565, 0.33333333333333
62449, 1.7217391304348, 0.98478260869565, 0.27777777777778
62450, 1.7217391304348, 0.98478260869565, 0.22222222222222
62451, 1.7217391304348, 0.98478260869565, 0.16666666666667
62452, 1.7217391304348, 0.98478260869565, 0.11111111111111
62453, 1.7217391304348, 0.98478260869565, 0.055555555555556
62454, 1.7652173913043, 0.98478260869565, 0.44444444444444
62455, 1.7652173913043, 0.98478260869565, 0.38888888888889
62456, 1.7652173913043, 0.98478260869565, 0.33333333333333
62457, 1.7652173913043, 0.98478260869565, 0.27777777777778
62458, 1.7652173913043, 0.98478260869565, 0.22222222222222
62459, 1.7652173913043, 0.98478260869565, 0.16666666666667
62460, 1.7652173913043, 0.98478260869565, 0.11111111111111
62461, 1.7652173913043, 0.98478260869565, 0.055555555555556
62462, 1.8086956521739, 0.98478260869565, 0.44444444444444
62463, 1.8086956521739, 0.98478260869565, 0.38888888888889
62464, 1.8086956521739, 0.98478260869565, 0.33333333333333
62465, 1.8086956521739, 0.98478260869565, 0.27777777777778
62466, 1.8086956521739, 0.98478260869565, 0.22222222222222
62467, 1.8086956521739, 0.98478260869565, 0.16666666666667
62468, 1.8086956521739, 0.98478260869565, 0.11111111111111
62469, 1.8086956521739, 0.98478260869565, 0.055555555555556
62470, 1.8521739130435, 0.98478260869565, 0.44444444444444
62471, 1.8521739130435, 0.98478260869565, 0.38888888888889
62472, 1.8521739130435, 0.98478260869565, 0.33333333333333
62473, 1.8521739130435, 0.98478260869565, 0.27777777777778
62474, 1.8521739130435, 0.98478260869565, 0.22222222222222
62475, 1.8521739130435, 0.98478260869565, 0.16666666666667
62476, 1.8521739130435, 0.98478260869565, 0.11111111111111
62477, 1.8521739130435, 0.98478260869565, 0.055555555555556
62478, 1.895652173913, 0.98478260869565, 0.44444444444444
62479, 1.895652173913, 0.98478260869565, 0.38888888888889
62480, 1.895652173913, 0.98478260869565, 0.33333333333333
62481, 1.895652173913, 0.98478260869565, 0.27777777777778
62482, 1.895652173913, 0.98478260869565, 0.22222222222222
62483, 1.895652173913, 0.98478260869565, 0.16666666666667
62484, 1.895652173913, 0.98478260869565, 0.11111111111111
62485, 1.895652173913, 0.98478260869565, 0.055555555555556
62486, 1.9391304347826, 0.98478260869565, 0.44444444444444
62487, 1.9391304347826, 0.98478260869565, 0.38888888888889
62488, 1.9391304347826, 0.98478260869565, 0.33333333333333
62489, 1.9391304347826, 0.98478260869565, 0.27777777777778
62490, 1.9391304347826, 0.98478260869565, 0.22222222222222
62491, 1.9391304347826, 0.98478260869565, 0.16666666666667
62492, 1.9391304347826, 0.98478260869565, 0.11111111111111
62493, 1.9391304347826, 0.98478260869565, 0.055555555555556
62494, 1.9826086956522, 0.98478260869565, 0.44444444444444
62495, 1.9826086956522, 0.98478260869565, 0.38888888888889
62496, 1.9826086956522, 0.98478260869565, 0.33333333333333
62497, 1.9826086956522, 0.98478260869565, 0.27777777777778
62498, 1.9826086956522, 0.98478260869565, 0.22222222222222
62499, 1.9826086956522, 0.98478260869565, 0.16666666666667
62500, 1.9826086956522, 0.98478260869565, 0.11111111111111
62501, 1.9826086956522, 0.98478260869565, 0.055555555555556
62502, 2.0260869565217, 0.98478260869565, 0.44444444444444
62503, 2.0260869565217, 0.98478260869565, 0.38888888888889
62504, 2.0260869565217, 0.98478260869565, 0.33333333333333
62505, 2.0260869565217, 0.98478260869565, 0.27777777777778
62506, 2.0260869565217, 0.98478260869565, 0.22222222222222
62507, 2.0260869565217, 0.98478260869565, 0.16666666666667
62508, 2.0260869565217, 0.98478260869565, 0.11111111111111
62509, 2.0260869565217, 0.98478260869565, 0.055555555555556
62510, 2.0695652173913, 0.98478260869565, 0.44444444444444
62511, 2.0695652173913, 0.98478260869565, 0.38888888888889
62512, 2.0695652173913, 0.98478260869565, 0.33333333333333
62513, 2.0695652173913, 0.98478260869565, 0.27777777777778
62514, 2.0695652173913, 0.98478260869565, 0.22222222222222
62515, 2.0695652173913, 0.98478260869565, 0.16666666666667
62516, 2.0695652173913, 0.98478260869565, 0.11111111111111
62517, 2.0695652173913, 0.98478260869565, 0.055555555555556
62518, 2.1130434782609, 0.98478260869565, 0.44444444444444
62519, 2.1130434782609, 0.98478260869565, 0.38888888888889
62520, 2.1130434782609, 0.98478260869565, 0.33333333333333
62521, 2.1130434782609, 0.98478260869565, 0.27777777777778
62522, 2.1130434782609, 0.98478260869565, 0.22222222222222
62523, 2.1130434782609, 0.98478260869565, 0.16666666666667
62524, 2.1130434782609, 0.98478260869565, 0.11111111111111
62525, 2.1130434782609, 0.98478260869565, 0.055555555555556
62526, 2.1565217391304, 0.98478260869565, 0.44444444444444
62527, 2.1565217391304, 0.98478260869565, 0.38888888888889
62528, 2.1565217391304, 0.98478260869565, 0.33333333333333
62529, 2.1565217391304, 0.98478260869565, 0.27777777777778
62530, 2.1565217391304, 0.98478260869565, 0.22222222222222
62531, 2.1565217391304, 0.98478260869565, 0.16666666666667
62532, 2.1565217391304, 0.98478260869565, 0.11111111111111
62533, 2.1565217391304, 0.98478260869565, 0.055555555555556
62534, 1.2434782608696, 0.93260869565218, 0.44444444444444
62535, 1.2434782608696, 0.93260869565217, 0.38888888888889
62536, 1.2434782608696, 0.93260869565217, 0.33333333333333
62537, 1.2434782608696, 0.93260869565218, 0.27777777777778
62538, 1.2434782608696, 0.93260869565217, 0.22222222222222
62539, 1.2434782608696, 0.93260869565217, 0.16666666666667
62540, 1.2434782608696, 0.93260869565217, 0.11111111111111
62541, 1.2434782608696, 0.93260869565217, 0.055555555555556
62542, 1.2869565217391, 0.93260869565218, 0.44444444444444
62543, 1.2869565217391, 0.93260869565217, 0.38888888888889
62544, 1.2869565217391, 0.93260869565217, 0.33333333333333
62545, 1.2869565217391, 0.93260869565217, 0.27777777777778
62546, 1.2869565217391, 0.93260869565217, 0.22222222222222
62547, 1.2869565217391, 0.93260869565217, 0.16666666666667
62548, 1.2869565217391, 0.93260869565217, 0.11111111111111
62549, 1.2869565217391, 0.93260869565217, 0.055555555555556
62550, 1.3304347826087, 0.93260869565218, 0.44444444444444
62551, 1.3304347826087, 0.93260869565217, 0.38888888888889
62552, 1.3304347826087, 0.93260869565217, 0.33333333333333
62553, 1.3304347826087, 0.93260869565218, 0.27777777777778
62554, 1.3304347826087, 0.93260869565217, 0.22222222222222
62555, 1.3304347826087, 0.93260869565217, 0.16666666666667
62556, 1.3304347826087, 0.93260869565218, 0.11111111111111
62557, 1.3304347826087, 0.93260869565218, 0.055555555555556
62558, 1.3739130434783, 0.93260869565218, 0.44444444444444
62559, 1.3739130434783, 0.93260869565217, 0.38888888888889
62560, 1.3739130434783, 0.93260869565217, 0.33333333333333
62561, 1.3739130434783, 0.93260869565218, 0.27777777777778
62562, 1.3739130434783, 0.93260869565217, 0.22222222222222
62563, 1.3739130434783, 0.93260869565217, 0.16666666666667
62564, 1.3739130434783, 0.93260869565217, 0.11111111111111
62565, 1.3739130434783, 0.93260869565217, 0.055555555555556
62566, 1.4173913043478, 0.93260869565218, 0.44444444444444
62567, 1.4173913043478, 0.93260869565217, 0.38888888888889
62568, 1.4173913043478, 0.93260869565217, 0.33333333333333
62569, 1.4173913043478, 0.93260869565218, 0.27777777777778
62570, 1.4173913043478, 0.93260869565217, 0.22222222222222
62571, 1.4173913043478, 0.93260869565217, 0.16666666666667
62572, 1.4173913043478, 0.93260869565217, 0.11111111111111
62573, 1.4173913043478, 0.93260869565217, 0.055555555555556
62574, 1.4608695652174, 0.93260869565218, 0.44444444444444
62575, 1.4608695652174, 0.93260869565217, 0.38888888888889
62576, 1.4608695652174, 0.93260869565217, 0.33333333333333
62577, 1.4608695652174, 0.93260869565218, 0.27777777777778
62578, 1.4608695652174, 0.93260869565217, 0.22222222222222
62579, 1.4608695652174, 0.93260869565217, 0.16666666666667
62580, 1.4608695652174, 0.93260869565217, 0.11111111111111
62581, 1.4608695652174, 0.93260869565217, 0.055555555555556
62582, 1.504347826087, 0.93260869565217, 0.44444444444444
62583, 1.504347826087, 0.93260869565217, 0.38888888888889
62584, 1.504347826087, 0.93260869565217, 0.33333333333333
62585, 1.504347826087, 0.93260869565217, 0.27777777777778
62586, 1.504347826087, 0.93260869565217, 0.22222222222222
62587, 1.504347826087, 0.93260869565217, 0.16666666666667
62588, 1.504347826087, 0.93260869565217, 0.11111111111111
62589, 1.504347826087, 0.93260869565217, 0.055555555555556
62590, 1.5478260869565, 0.93260869565218, 0.44444444444444
62591, 1.5478260869565, 0.93260869565217, 0.38888888888889
62592, 1.5478260869565, 0.93260869565217, 0.33333333333333
62593, 1.5478260869565, 0.93260869565218, 0.27777777777778
62594, 1.5478260869565, 0.93260869565217, 0.22222222222222
62595, 1.5478260869565, 0.93260869565218, 0.16666666666667
62596, 1.5478260869565, 0.93260869565218, 0.11111111111111
62597, 1.5478260869565, 0.93260869565217, 0.055555555555556
62598, 1.5913043478261, 0.93260869565218, 0.44444444444444
62599, 1.5913043478261, 0.93260869565217, 0.38888888888889
62600, 1.5913043478261, 0.93260869565217, 0.33333333333333
62601, 1.5913043478261, 0.93260869565218, 0.27777777777778
62602, 1.5913043478261, 0.93260869565218, 0.22222222222222
62603, 1.5913043478261, 0.93260869565217, 0.16666666666667
62604, 1.5913043478261, 0.93260869565218, 0.11111111111111
62605, 1.5913043478261, 0.93260869565217, 0.055555555555556
62606, 1.6347826086957, 0.93260869565218, 0.44444444444444
62607, 1.6347826086957, 0.93260869565217, 0.38888888888889
62608, 1.6347826086957, 0.93260869565217, 0.33333333333333
62609, 1.6347826086957, 0.93260869565218, 0.27777777777778
62610, 1.6347826086957, 0.93260869565217, 0.22222222222222
62611, 1.6347826086957, 0.93260869565217, 0.16666666666667
62612, 1.6347826086957, 0.93260869565218, 0.11111111111111
62613, 1.6347826086957, 0.93260869565218, 0.055555555555556
62614, 1.6782608695652, 0.93260869565218, 0.44444444444444
62615, 1.6782608695652, 0.93260869565217, 0.38888888888889
62616, 1.6782608695652, 0.93260869565217, 0.33333333333333
62617, 1.6782608695652, 0.93260869565218, 0.27777777777778
62618, 1.6782608695652, 0.93260869565217, 0.22222222222222
62619, 1.6782608695652, 0.93260869565217, 0.16666666666667
62620, 1.6782608695652, 0.93260869565217, 0.11111111111111
62621, 1.6782608695652, 0.93260869565217, 0.055555555555556
62622, 1.7217391304348, 0.93260869565218, 0.44444444444444
62623, 1.7217391304348, 0.93260869565217, 0.38888888888889
62624, 1.7217391304348, 0.93260869565217, 0.33333333333333
62625, 1.7217391304348, 0.93260869565218, 0.27777777777778
62626, 1.7217391304348, 0.93260869565217, 0.22222222222222
62627, 1.7217391304348, 0.93260869565217, 0.16666666666667
62628, 1.7217391304348, 0.93260869565217, 0.11111111111111
62629, 1.7217391304348, 0.93260869565217, 0.055555555555556
62630, 1.7652173913043, 0.93260869565218, 0.44444444444444
62631, 1.7652173913043, 0.93260869565217, 0.38888888888889
62632, 1.7652173913043, 0.93260869565217, 0.33333333333333
62633, 1.7652173913043, 0.93260869565218, 0.27777777777778
62634, 1.7652173913043, 0.93260869565217, 0.22222222222222
62635, 1.7652173913043, 0.93260869565217, 0.16666666666667
62636, 1.7652173913043, 0.93260869565217, 0.11111111111111
62637, 1.7652173913043, 0.93260869565217, 0.055555555555556
62638, 1.8086956521739, 0.93260869565218, 0.44444444444444
62639, 1.8086956521739, 0.93260869565217, 0.38888888888889
62640, 1.8086956521739, 0.93260869565217, 0.33333333333333
62641, 1.8086956521739, 0.93260869565218, 0.27777777777778
62642, 1.8086956521739, 0.93260869565217, 0.22222222222222
62643, 1.8086956521739, 0.93260869565217, 0.16666666666667
62644, 1.8086956521739, 0.93260869565218, 0.11111111111111
62645, 1.8086956521739, 0.93260869565217, 0.055555555555556
62646, 1.8521739130435, 0.93260869565217, 0.44444444444444
62647, 1.8521739130435, 0.93260869565217, 0.38888888888889
62648, 1.8521739130435, 0.93260869565217, 0.33333333333333
62649, 1.8521739130435, 0.93260869565217, 0.27777777777778
62650, 1.8521739130435, 0.93260869565217, 0.22222222222222
62651, 1.8521739130435, 0.93260869565218, 0.16666666666667
62652, 1.8521739130435, 0.93260869565218, 0.11111111111111
62653, 1.8521739130435, 0.93260869565217, 0.055555555555556
62654, 1.895652173913, 0.93260869565218, 0.44444444444444
62655, 1.895652173913, 0.93260869565217, 0.38888888888889
62656, 1.895652173913, 0.93260869565217, 0.33333333333333
62657, 1.895652173913, 0.93260869565218, 0.27777777777778
62658, 1.895652173913, 0.93260869565217, 0.22222222222222
62659, 1.895652173913, 0.93260869565217, 0.16666666666667
62660, 1.895652173913, 0.93260869565217, 0.11111111111111
62661, 1.895652173913, 0.93260869565217, 0.055555555555556
62662, 1.9391304347826, 0.93260869565217, 0.44444444444444
62663, 1.9391304347826, 0.93260869565217, 0.38888888888889
62664, 1.9391304347826, 0.93260869565217, 0.33333333333333
62665, 1.9391304347826, 0.93260869565218, 0.27777777777778
62666, 1.9391304347826, 0.93260869565217, 0.22222222222222
62667, 1.9391304347826, 0.93260869565218, 0.16666666666667
62668, 1.9391304347826, 0.93260869565217, 0.11111111111111
62669, 1.9391304347826, 0.93260869565218, 0.055555555555556
62670, 1.9826086956522, 0.93260869565218, 0.44444444444444
62671, 1.9826086956522, 0.93260869565217, 0.38888888888889
62672, 1.9826086956522, 0.93260869565217, 0.33333333333333
62673, 1.9826086956522, 0.93260869565217, 0.27777777777778
62674, 1.9826086956522, 0.93260869565217, 0.22222222222222
62675, 1.9826086956522, 0.93260869565217, 0.16666666666667
62676, 1.9826086956522, 0.93260869565217, 0.11111111111111
62677, 1.9826086956522, 0.93260869565217, 0.055555555555556
62678, 2.0260869565217, 0.93260869565218, 0.44444444444444
62679, 2.0260869565217, 0.93260869565217, 0.38888888888889
62680, 2.0260869565217, 0.93260869565217, 0.33333333333333
62681, 2.0260869565217, 0.93260869565218, 0.27777777777778
62682, 2.0260869565217, 0.93260869565217, 0.22222222222222
62683, 2.0260869565217, 0.93260869565217, 0.16666666666667
62684, 2.0260869565217, 0.93260869565217, 0.11111111111111
62685, 2.0260869565217, 0.93260869565217, 0.055555555555556
62686, 2.0695652173913, 0.93260869565218, 0.44444444444444
62687, 2.0695652173913, 0.93260869565217, 0.38888888888889
62688, 2.0695652173913, 0.93260869565217, 0.33333333333333
62689, 2.0695652173913, 0.93260869565218, 0.27777777777778
62690, 2.0695652173913, 0.93260869565217, 0.22222222222222
62691, 2.0695652173913, 0.93260869565217, 0.16666666666667
62692, 2.0695652173913, 0.93260869565218, 0.11111111111111
62693, 2.0695652173913, 0.93260869565217, 0.055555555555556
62694, 2.1130434782609, 0.93260869565218, 0.44444444444444
62695, 2.1130434782609, 0.93260869565217, 0.38888888888889
62696, 2.1130434782609, 0.93260869565217, 0.33333333333333
62697, 2.1130434782609, 0.93260869565218, 0.27777777777778
62698, 2.1130434782609, 0.93260869565217, 0.22222222222222
62699, 2.1130434782609, 0.93260869565217, 0.16666666666667
62700, 2.1130434782609, 0.93260869565217, 0.11111111111111
62701, 2.1130434782609, 0.93260869565217, 0.055555555555556
62702, 2.1565217391304, 0.93260869565218, 0.44444444444444
62703, 2.1565217391304, 0.93260869565217, 0.38888888888889
62704, 2.1565217391304, 0.93260869565217, 0.33333333333333
62705, 2.1565217391304, 0.93260869565218, 0.27777777777778
62706, 2.1565217391304, 0.93260869565217, 0.22222222222222
62707, 2.1565217391304, 0.93260869565217, 0.16666666666667
62708, 2.1565217391304, 0.93260869565217, 0.11111111111111
62709, 2.1565217391304, 0.93260869565217, 0.055555555555556
62710, 1.2434782608696, 0.8804347826087, 0.44444444444444
62711, 1.2434782608696, 0.8804347826087, 0.38888888888889
62712, 1.2434782608696, 0.8804347826087, 0.33333333333333
62713, 1.2434782608696, 0.8804347826087, 0.27777777777778
62714, 1.2434782608696, 0.8804347826087, 0.22222222222222
62715, 1.2434782608696, 0.8804347826087, 0.16666666666667
62716, 1.2434782608696, 0.8804347826087, 0.11111111111111
62717, 1.2434782608696, 0.8804347826087, 0.055555555555556
62718, 1.2869565217391, 0.8804347826087, 0.44444444444444
62719, 1.2869565217391, 0.8804347826087, 0.38888888888889
62720, 1.2869565217391, 0.8804347826087, 0.33333333333333
62721, 1.2869565217391, 0.8804347826087, 0.27777777777778
62722, 1.2869565217391, 0.8804347826087, 0.22222222222222
62723, 1.2869565217391, 0.8804347826087, 0.16666666666667
62724, 1.2869565217391, 0.8804347826087, 0.11111111111111
62725, 1.2869565217391, 0.8804347826087, 0.055555555555556
62726, 1.3304347826087, 0.8804347826087, 0.44444444444444
62727, 1.3304347826087, 0.8804347826087, 0.38888888888889
62728, 1.3304347826087, 0.8804347826087, 0.33333333333333
62729, 1.3304347826087, 0.8804347826087, 0.27777777777778
62730, 1.3304347826087, 0.8804347826087, 0.22222222222222
62731, 1.3304347826087, 0.8804347826087, 0.16666666666667
62732, 1.3304347826087, 0.8804347826087, 0.11111111111111
62733, 1.3304347826087, 0.8804347826087, 0.055555555555556
62734, 1.3739130434783, 0.8804347826087, 0.44444444444444
62735, 1.3739130434783, 0.8804347826087, 0.38888888888889
62736, 1.3739130434783, 0.8804347826087, 0.33333333333333
62737, 1.3739130434783, 0.8804347826087, 0.27777777777778
62738, 1.3739130434783, 0.8804347826087, 0.22222222222222
62739, 1.3739130434783, 0.8804347826087, 0.16666666666667
62740, 1.3739130434783, 0.8804347826087, 0.11111111111111
62741, 1.3739130434783, 0.8804347826087, 0.055555555555556
62742, 1.4173913043478, 0.8804347826087, 0.44444444444444
62743, 1.4173913043478, 0.8804347826087, 0.38888888888889
62744, 1.4173913043478, 0.8804347826087, 0.33333333333333
62745, 1.4173913043478, 0.8804347826087, 0.27777777777778
62746, 1.4173913043478, 0.8804347826087, 0.22222222222222
62747, 1.4173913043478, 0.8804347826087, 0.16666666666667
62748, 1.4173913043478, 0.8804347826087, 0.11111111111111
62749, 1.4173913043478, 0.8804347826087, 0.055555555555556
62750, 1.4608695652174, 0.8804347826087, 0.44444444444444
62751, 1.4608695652174, 0.8804347826087, 0.38888888888889
62752, 1.4608695652174, 0.8804347826087, 0.33333333333333
62753, 1.4608695652174, 0.8804347826087, 0.27777777777778
62754, 1.4608695652174, 0.8804347826087, 0.22222222222222
62755, 1.4608695652174, 0.8804347826087, 0.16666666666667
62756, 1.4608695652174, 0.8804347826087, 0.11111111111111
62757, 1.4608695652174, 0.8804347826087, 0.055555555555556
62758, 1.504347826087, 0.8804347826087, 0.44444444444444
62759, 1.504347826087, 0.8804347826087, 0.38888888888889
62760, 1.504347826087, 0.8804347826087, 0.33333333333333
62761, 1.504347826087, 0.8804347826087, 0.27777777777778
62762, 1.504347826087, 0.8804347826087, 0.22222222222222
62763, 1.504347826087, 0.8804347826087, 0.16666666666667
62764, 1.504347826087, 0.8804347826087, 0.11111111111111
62765, 1.504347826087, 0.8804347826087, 0.055555555555556
62766, 1.5478260869565, 0.8804347826087, 0.44444444444444
62767, 1.5478260869565, 0.8804347826087, 0.38888888888889
62768, 1.5478260869565, 0.8804347826087, 0.33333333333333
62769, 1.5478260869565, 0.8804347826087, 0.27777777777778
62770, 1.5478260869565, 0.8804347826087, 0.22222222222222
62771, 1.5478260869565, 0.8804347826087, 0.16666666666667
62772, 1.5478260869565, 0.8804347826087, 0.11111111111111
62773, 1.5478260869565, 0.8804347826087, 0.055555555555556
62774, 1.5913043478261, 0.8804347826087, 0.44444444444444
62775, 1.5913043478261, 0.8804347826087, 0.38888888888889
62776, 1.5913043478261, 0.8804347826087, 0.33333333333333
62777, 1.5913043478261, 0.8804347826087, 0.27777777777778
62778, 1.5913043478261, 0.8804347826087, 0.22222222222222
62779, 1.5913043478261, 0.8804347826087, 0.16666666666667
62780, 1.5913043478261, 0.8804347826087, 0.11111111111111
62781, 1.5913043478261, 0.8804347826087, 0.055555555555556
62782, 1.6347826086957, 0.8804347826087, 0.44444444444444
62783, 1.6347826086957, 0.8804347826087, 0.38888888888889
62784, 1.6347826086957, 0.8804347826087, 0.33333333333333
62785, 1.6347826086957, 0.8804347826087, 0.27777777777778
62786, 1.6347826086957, 0.8804347826087, 0.22222222222222
62787, 1.6347826086957, 0.8804347826087, 0.16666666666667
62788, 1.6347826086957, 0.8804347826087, 0.11111111111111
62789, 1.6347826086957, 0.8804347826087, 0.055555555555556
62790, 1.6782608695652, 0.8804347826087, 0.44444444444444
62791, 1.6782608695652, 0.8804347826087, 0.38888888888889
62792, 1.6782608695652, 0.8804347826087, 0.33333333333333
62793, 1.6782608695652, 0.8804347826087, 0.27777777777778
62794, 1.6782608695652, 0.8804347826087, 0.22222222222222
62795, 1.6782608695652, 0.8804347826087, 0.16666666666667
62796, 1.6782608695652, 0.8804347826087, 0.11111111111111
62797, 1.6782608695652, 0.8804347826087, 0.055555555555556
62798, 1.7217391304348, 0.8804347826087, 0.44444444444444
62799, 1.7217391304348, 0.8804347826087, 0.38888888888889
62800, 1.7217391304348, 0.8804347826087, 0.33333333333333
62801, 1.7217391304348, 0.8804347826087, 0.27777777777778
62802, 1.7217391304348, 0.8804347826087, 0.22222222222222
62803, 1.7217391304348, 0.8804347826087, 0.16666666666667
62804, 1.7217391304348, 0.8804347826087, 0.11111111111111
62805, 1.7217391304348, 0.8804347826087, 0.055555555555556
62806, 1.7652173913043, 0.8804347826087, 0.44444444444444
62807, 1.7652173913043, 0.8804347826087, 0.38888888888889
62808, 1.7652173913043, 0.8804347826087, 0.33333333333333
62809, 1.7652173913043, 0.8804347826087, 0.27777777777778
62810, 1.7652173913043, 0.8804347826087, 0.22222222222222
62811, 1.7652173913043, 0.8804347826087, 0.16666666666667
62812, 1.7652173913043, 0.8804347826087, 0.11111111111111
62813, 1.7652173913043, 0.8804347826087, 0.055555555555556
62814, 1.8086956521739, 0.8804347826087, 0.44444444444444
62815, 1.8086956521739, 0.8804347826087, 0.38888888888889
62816, 1.8086956521739, 0.8804347826087, 0.33333333333333
62817, 1.8086956521739, 0.8804347826087, 0.27777777777778
62818, 1.8086956521739, 0.8804347826087, 0.22222222222222
62819, 1.8086956521739, 0.8804347826087, 0.16666666666667
62820, 1.8086956521739, 0.8804347826087, 0.11111111111111
62821, 1.8086956521739, 0.8804347826087, 0.055555555555556
62822, 1.8521739130435, 0.8804347826087, 0.44444444444444
62823, 1.8521739130435, 0.8804347826087, 0.38888888888889
62824, 1.8521739130435, 0.8804347826087, 0.33333333333333
62825, 1.8521739130435, 0.8804347826087, 0.27777777777778
62826, 1.8521739130435, 0.8804347826087, 0.22222222222222
62827, 1.8521739130435, 0.8804347826087, 0.16666666666667
62828, 1.8521739130435, 0.8804347826087, 0.11111111111111
62829, 1.8521739130435, 0.8804347826087, 0.055555555555556
62830, 1.895652173913, 0.8804347826087, 0.44444444444444
62831, 1.895652173913, 0.8804347826087, 0.38888888888889
62832, 1.895652173913, 0.8804347826087, 0.33333333333333
62833, 1.895652173913, 0.8804347826087, 0.27777777777778
62834, 1.895652173913, 0.8804347826087, 0.22222222222222
62835, 1.895652173913, 0.8804347826087, 0.16666666666667
62836, 1.895652173913, 0.8804347826087, 0.11111111111111
62837, 1.895652173913, 0.8804347826087, 0.055555555555556
62838, 1.9391304347826, 0.8804347826087, 0.44444444444444
62839, 1.9391304347826, 0.8804347826087, 0.38888888888889
62840, 1.9391304347826, 0.8804347826087, 0.33333333333333
62841, 1.9391304347826, 0.8804347826087, 0.27777777777778
62842, 1.9391304347826, 0.8804347826087, 0.22222222222222
62843, 1.9391304347826, 0.8804347826087, 0.16666666666667
62844, 1.9391304347826, 0.8804347826087, 0.11111111111111
62845, 1.9391304347826, 0.8804347826087, 0.055555555555556
62846, 1.9826086956522, 0.8804347826087, 0.44444444444444
62847, 1.9826086956522, 0.8804347826087, 0.38888888888889
62848, 1.9826086956522, 0.8804347826087, 0.33333333333333
62849, 1.9826086956522, 0.8804347826087, 0.27777777777778
62850, 1.9826086956522, 0.8804347826087, 0.22222222222222
62851, 1.9826086956522, 0.8804347826087, 0.16666666666667
62852, 1.9826086956522, 0.8804347826087, 0.11111111111111
62853, 1.9826086956522, 0.8804347826087, 0.055555555555556
62854, 2.0260869565217, 0.8804347826087, 0.44444444444444
62855, 2.0260869565217, 0.8804347826087, 0.38888888888889
62856, 2.0260869565217, 0.8804347826087, 0.33333333333333
62857, 2.0260869565217, 0.8804347826087, 0.27777777777778
62858, 2.0260869565217, 0.8804347826087, 0.22222222222222
62859, 2.0260869565217, 0.8804347826087, 0.16666666666667
62860, 2.0260869565217, 0.8804347826087, 0.11111111111111
62861, 2.0260869565217, 0.8804347826087, 0.055555555555556
62862, 2.0695652173913, 0.8804347826087, 0.44444444444444
62863, 2.0695652173913, 0.8804347826087, 0.38888888888889
62864, 2.0695652173913, 0.8804347826087, 0.33333333333333
62865, 2.0695652173913, 0.8804347826087, 0.27777777777778
62866, 2.0695652173913, 0.8804347826087, 0.22222222222222
62867, 2.0695652173913, 0.8804347826087, 0.16666666666667
62868, 2.0695652173913, 0.8804347826087, 0.11111111111111
62869, 2.0695652173913, 0.8804347826087, 0.055555555555556
62870, 2.1130434782609, 0.8804347826087, 0.44444444444444
62871, 2.1130434782609, 0.8804347826087, 0.38888888888889
62872, 2.1130434782609, 0.8804347826087, 0.33333333333333
62873, 2.1130434782609, 0.8804347826087, 0.27777777777778
62874, 2.1130434782609, 0.8804347826087, 0.22222222222222
62875, 2.1130434782609, 0.8804347826087, 0.16666666666667
62876, 2.1130434782609, 0.8804347826087, 0.11111111111111
62877, 2.1130434782609, 0.8804347826087, 0.055555555555556
62878, 2.1565217391304, 0.8804347826087, 0.44444444444444
62879, 2.1565217391304, 0.8804347826087, 0.38888888888889
62880, 2.1565217391304, 0.8804347826087, 0.33333333333333
62881, 2.1565217391304, 0.8804347826087, 0.27777777777778
62882, 2.1565217391304, 0.8804347826087, 0.22222222222222
62883, 2.1565217391304, 0.8804347826087, 0.16666666666667
62884, 2.1565217391304, 0.8804347826087, 0.11111111111111
62885, 2.1565217391304, 0.8804347826087, 0.055555555555556
62886, 1.2434782608696, 0.82826086956522, 0.44444444444444
62887, 1.2434782608696, 0.82826086956522, 0.38888888888889
62888, 1.2434782608696, 0.82826086956522, 0.33333333333333
62889, 1.2434782608696, 0.82826086956522, 0.27777777777778
62890, 1.2434782608696, 0.82826086956522, 0.22222222222222
62891, 1.2434782608696, 0.82826086956522, 0.16666666666667
62892, 1.2434782608696, 0.82826086956522, 0.11111111111111
62893, 1.2434782608696, 0.82826086956522, 0.055555555555556
62894, 1.2869565217391, 0.82826086956522, 0.44444444444444
62895, 1.2869565217391, 0.82826086956522, 0.38888888888889
62896, 1.2869565217391, 0.82826086956522, 0.33333333333333
62897, 1.2869565217391, 0.82826086956522, 0.27777777777778
62898, 1.2869565217391, 0.82826086956522, 0.22222222222222
62899, 1.2869565217391, 0.82826086956522, 0.16666666666667
62900, 1.2869565217391, 0.82826086956522, 0.11111111111111
62901, 1.2869565217391, 0.82826086956522, 0.055555555555556
62902, 1.3304347826087, 0.82826086956522, 0.44444444444444
62903, 1.3304347826087, 0.82826086956522, 0.38888888888889
62904, 1.3304347826087, 0.82826086956522, 0.33333333333333
62905, 1.3304347826087, 0.82826086956522, 0.27777777777778
62906, 1.3304347826087, 0.82826086956522, 0.22222222222222
62907, 1.3304347826087, 0.82826086956522, 0.16666666666667
62908, 1.3304347826087, 0.82826086956522, 0.11111111111111
62909, 1.3304347826087, 0.82826086956522, 0.055555555555556
62910, 1.3739130434783, 0.82826086956522, 0.44444444444444
62911, 1.3739130434783, 0.82826086956522, 0.38888888888889
62912, 1.3739130434783, 0.82826086956522, 0.33333333333333
62913, 1.3739130434783, 0.82826086956522, 0.27777777777778
62914, 1.3739130434783, 0.82826086956522, 0.22222222222222
62915, 1.3739130434783, 0.82826086956522, 0.16666666666667
62916, 1.3739130434783, 0.82826086956522, 0.11111111111111
62917, 1.3739130434783, 0.82826086956522, 0.055555555555556
62918, 1.4173913043478, 0.82826086956522, 0.44444444444444
62919, 1.4173913043478, 0.82826086956522, 0.38888888888889
62920, 1.4173913043478, 0.82826086956522, 0.33333333333333
62921, 1.4173913043478, 0.82826086956522, 0.27777777777778
62922, 1.4173913043478, 0.82826086956522, 0.22222222222222
62923, 1.4173913043478, 0.82826086956522, 0.16666666666667
62924, 1.4173913043478, 0.82826086956522, 0.11111111111111
62925, 1.4173913043478, 0.82826086956522, 0.055555555555556
62926, 1.4608695652174, 0.82826086956522, 0.44444444444444
62927, 1.4608695652174, 0.82826086956522, 0.38888888888889
62928, 1.4608695652174, 0.82826086956522, 0.33333333333333
62929, 1.4608695652174, 0.82826086956522, 0.27777777777778
62930, 1.4608695652174, 0.82826086956522, 0.22222222222222
62931, 1.4608695652174, 0.82826086956522, 0.16666666666667
62932, 1.4608695652174, 0.82826086956522, 0.11111111111111
62933, 1.4608695652174, 0.82826086956522, 0.055555555555556
62934, 1.504347826087, 0.82826086956522, 0.44444444444444
62935, 1.504347826087, 0.82826086956522, 0.38888888888889
62936, 1.504347826087, 0.82826086956522, 0.33333333333333
62937, 1.504347826087, 0.82826086956522, 0.27777777777778
62938, 1.504347826087, 0.82826086956522, 0.22222222222222
62939, 1.504347826087, 0.82826086956522, 0.16666666666667
62940, 1.504347826087, 0.82826086956522, 0.11111111111111
62941, 1.504347826087, 0.82826086956522, 0.055555555555556
62942, 1.5478260869565, 0.82826086956522, 0.44444444444444
62943, 1.5478260869565, 0.82826086956522, 0.38888888888889
62944, 1.5478260869565, 0.82826086956522, 0.33333333333333
62945, 1.5478260869565, 0.82826086956522, 0.27777777777778
62946, 1.5478260869565, 0.82826086956522, 0.22222222222222
62947, 1.5478260869565, 0.82826086956522, 0.16666666666667
62948, 1.5478260869565, 0.82826086956522, 0.11111111111111
62949, 1.5478260869565, 0.82826086956522, 0.055555555555556
62950, 1.5913043478261, 0.82826086956522, 0.44444444444444
62951, 1.5913043478261, 0.82826086956522, 0.38888888888889
62952, 1.5913043478261, 0.82826086956522, 0.33333333333333
62953, 1.5913043478261, 0.82826086956522, 0.27777777777778
62954, 1.5913043478261, 0.82826086956522, 0.22222222222222
62955, 1.5913043478261, 0.82826086956522, 0.16666666666667
62956, 1.5913043478261, 0.82826086956522, 0.11111111111111
62957, 1.5913043478261, 0.82826086956522, 0.055555555555556
62958, 1.6347826086957, 0.82826086956522, 0.44444444444444
62959, 1.6347826086957, 0.82826086956522, 0.38888888888889
62960, 1.6347826086957, 0.82826086956522, 0.33333333333333
62961, 1.6347826086957, 0.82826086956522, 0.27777777777778
62962, 1.6347826086957, 0.82826086956522, 0.22222222222222
62963, 1.6347826086957, 0.82826086956522, 0.16666666666667
62964, 1.6347826086957, 0.82826086956522, 0.11111111111111
62965, 1.6347826086957, 0.82826086956522, 0.055555555555556
62966, 1.6782608695652, 0.82826086956522, 0.44444444444444
62967, 1.6782608695652, 0.82826086956522, 0.38888888888889
62968, 1.6782608695652, 0.82826086956522, 0.33333333333333
62969, 1.6782608695652, 0.82826086956522, 0.27777777777778
62970, 1.6782608695652, 0.82826086956522, 0.22222222222222
62971, 1.6782608695652, 0.82826086956522, 0.16666666666667
62972, 1.6782608695652, 0.82826086956522, 0.11111111111111
62973, 1.6782608695652, 0.82826086956522, 0.055555555555556
62974, 1.7217391304348, 0.82826086956522, 0.44444444444444
62975, 1.7217391304348, 0.82826086956522, 0.38888888888889
62976, 1.7217391304348, 0.82826086956522, 0.33333333333333
62977, 1.7217391304348, 0.82826086956522, 0.27777777777778
62978, 1.7217391304348, 0.82826086956522, 0.22222222222222
62979, 1.7217391304348, 0.82826086956522, 0.16666666666667
62980, 1.7217391304348, 0.82826086956522, 0.11111111111111
62981, 1.7217391304348, 0.82826086956522, 0.055555555555556
62982, 1.7652173913043, 0.82826086956522, 0.44444444444444
62983, 1.7652173913043, 0.82826086956522, 0.38888888888889
62984, 1.7652173913043, 0.82826086956522, 0.33333333333333
62985, 1.7652173913043, 0.82826086956522, 0.27777777777778
62986, 1.7652173913043, 0.82826086956522, 0.22222222222222
62987, 1.7652173913043, 0.82826086956522, 0.16666666666667
62988, 1.7652173913043, 0.82826086956522, 0.11111111111111
62989, 1.7652173913043, 0.82826086956522, 0.055555555555556
62990, 1.8086956521739, 0.82826086956522, 0.44444444444444
62991, 1.8086956521739, 0.82826086956522, 0.38888888888889
62992, 1.8086956521739, 0.82826086956522, 0.33333333333333
62993, 1.8086956521739, 0.82826086956522, 0.27777777777778
62994, 1.8086956521739, 0.82826086956522, 0.22222222222222
62995, 1.8086956521739, 0.82826086956522, 0.16666666666667
62996, 1.8086956521739, 0.82826086956522, 0.11111111111111
62997, 1.8086956521739, 0.82826086956522, 0.055555555555556
62998, 1.8521739130435, 0.82826086956522, 0.44444444444444
62999, 1.8521739130435, 0.82826086956522, 0.38888888888889
63000, 1.8521739130435, 0.82826086956522, 0.33333333333333
63001, 1.8521739130435, 0.82826086956522, 0.27777777777778
63002, 1.8521739130435, 0.82826086956522, 0.22222222222222
63003, 1.8521739130435, 0.82826086956522, 0.16666666666667
63004, 1.8521739130435, 0.82826086956522, 0.11111111111111
63005, 1.8521739130435, 0.82826086956522, 0.055555555555556
63006, 1.895652173913, 0.82826086956522, 0.44444444444444
63007, 1.895652173913, 0.82826086956522, 0.38888888888889
63008, 1.895652173913, 0.82826086956522, 0.33333333333333
63009, 1.895652173913, 0.82826086956522, 0.27777777777778
63010, 1.895652173913, 0.82826086956522, 0.22222222222222
63011, 1.895652173913, 0.82826086956522, 0.16666666666667
63012, 1.895652173913, 0.82826086956522, 0.11111111111111
63013, 1.895652173913, 0.82826086956522, 0.055555555555556
63014, 1.9391304347826, 0.82826086956522, 0.44444444444444
63015, 1.9391304347826, 0.82826086956522, 0.38888888888889
63016, 1.9391304347826, 0.82826086956522, 0.33333333333333
63017, 1.9391304347826, 0.82826086956522, 0.27777777777778
63018, 1.9391304347826, 0.82826086956522, 0.22222222222222
63019, 1.9391304347826, 0.82826086956522, 0.16666666666667
63020, 1.9391304347826, 0.82826086956522, 0.11111111111111
63021, 1.9391304347826, 0.82826086956522, 0.055555555555556
63022, 1.9826086956522, 0.82826086956522, 0.44444444444444
63023, 1.9826086956522, 0.82826086956522, 0.38888888888889
63024, 1.9826086956522, 0.82826086956522, 0.33333333333333
63025, 1.9826086956522, 0.82826086956522, 0.27777777777778
63026, 1.9826086956522, 0.82826086956522, 0.22222222222222
63027, 1.9826086956522, 0.82826086956522, 0.16666666666667
63028, 1.9826086956522, 0.82826086956522, 0.11111111111111
63029, 1.9826086956522, 0.82826086956522, 0.055555555555556
63030, 2.0260869565217, 0.82826086956522, 0.44444444444444
63031, 2.0260869565217, 0.82826086956522, 0.38888888888889
63032, 2.0260869565217, 0.82826086956522, 0.33333333333333
63033, 2.0260869565217, 0.82826086956522, 0.27777777777778
63034, 2.0260869565217, 0.82826086956522, 0.22222222222222
63035, 2.0260869565217, 0.82826086956522, 0.16666666666667
63036, 2.0260869565217, 0.82826086956522, 0.11111111111111
63037, 2.0260869565217, 0.82826086956522, 0.055555555555556
63038, 2.0695652173913, 0.82826086956522, 0.44444444444444
63039, 2.0695652173913, 0.82826086956522, 0.38888888888889
63040, 2.0695652173913, 0.82826086956522, 0.33333333333333
63041, 2.0695652173913, 0.82826086956522, 0.27777777777778
63042, 2.0695652173913, 0.82826086956522, 0.22222222222222
63043, 2.0695652173913, 0.82826086956522, 0.16666666666667
63044, 2.0695652173913, 0.82826086956522, 0.11111111111111
63045, 2.0695652173913, 0.82826086956522, 0.055555555555556
63046, 2.1130434782609, 0.82826086956522, 0.44444444444444
63047, 2.1130434782609, 0.82826086956522, 0.38888888888889
63048, 2.1130434782609, 0.82826086956522, 0.33333333333333
63049, 2.1130434782609, 0.82826086956522, 0.27777777777778
63050, 2.1130434782609, 0.82826086956522, 0.22222222222222
63051, 2.1130434782609, 0.82826086956522, 0.16666666666667
63052, 2.1130434782609, 0.82826086956522, 0.11111111111111
63053, 2.1130434782609, 0.82826086956522, 0.055555555555556
63054, 2.1565217391304, 0.82826086956522, 0.44444444444444
63055, 2.1565217391304, 0.82826086956522, 0.38888888888889
63056, 2.1565217391304, 0.82826086956522, 0.33333333333333
63057, 2.1565217391304, 0.82826086956522, 0.27777777777778
63058, 2.1565217391304, 0.82826086956522, 0.22222222222222
63059, 2.1565217391304, 0.82826086956522, 0.16666666666667
63060, 2.1565217391304, 0.82826086956522, 0.11111111111111
63061, 2.1565217391304, 0.82826086956522, 0.055555555555556
63062, 1.2434782608696, 0.77608695652174, 0.44444444444444
63063, 1.2434782608696, 0.77608695652174, 0.38888888888889
63064, 1.2434782608696, 0.77608695652174, 0.33333333333333
63065, 1.2434782608696, 0.77608695652174, 0.27777777777778
63066, 1.2434782608696, 0.77608695652174, 0.22222222222222
63067, 1.2434782608696, 0.77608695652174, 0.16666666666667
63068, 1.2434782608696, 0.77608695652174, 0.11111111111111
63069, 1.2434782608696, 0.77608695652174, 0.055555555555556
63070, 1.2869565217391, 0.77608695652174, 0.44444444444444
63071, 1.2869565217391, 0.77608695652174, 0.38888888888889
63072, 1.2869565217391, 0.77608695652174, 0.33333333333333
63073, 1.2869565217391, 0.77608695652174, 0.27777777777778
63074, 1.2869565217391, 0.77608695652174, 0.22222222222222
63075, 1.2869565217391, 0.77608695652174, 0.16666666666667
63076, 1.2869565217391, 0.77608695652174, 0.11111111111111
63077, 1.2869565217391, 0.77608695652174, 0.055555555555556
63078, 1.3304347826087, 0.77608695652174, 0.44444444444444
63079, 1.3304347826087, 0.77608695652174, 0.38888888888889
63080, 1.3304347826087, 0.77608695652174, 0.33333333333333
63081, 1.3304347826087, 0.77608695652174, 0.27777777777778
63082, 1.3304347826087, 0.77608695652174, 0.22222222222222
63083, 1.3304347826087, 0.77608695652174, 0.16666666666667
63084, 1.3304347826087, 0.77608695652174, 0.11111111111111
63085, 1.3304347826087, 0.77608695652174, 0.055555555555556
63086, 1.3739130434783, 0.77608695652174, 0.44444444444444
63087, 1.3739130434783, 0.77608695652174, 0.38888888888889
63088, 1.3739130434783, 0.77608695652174, 0.33333333333333
63089, 1.3739130434783, 0.77608695652174, 0.27777777777778
63090, 1.3739130434783, 0.77608695652174, 0.22222222222222
63091, 1.3739130434783, 0.77608695652174, 0.16666666666667
63092, 1.3739130434783, 0.77608695652174, 0.11111111111111
63093, 1.3739130434783, 0.77608695652174, 0.055555555555556
63094, 1.4173913043478, 0.77608695652174, 0.44444444444444
63095, 1.4173913043478, 0.77608695652174, 0.38888888888889
63096, 1.4173913043478, 0.77608695652174, 0.33333333333333
63097, 1.4173913043478, 0.77608695652174, 0.27777777777778
63098, 1.4173913043478, 0.77608695652174, 0.22222222222222
63099, 1.4173913043478, 0.77608695652174, 0.16666666666667
63100, 1.4173913043478, 0.77608695652174, 0.11111111111111
63101, 1.4173913043478, 0.77608695652174, 0.055555555555556
63102, 1.4608695652174, 0.77608695652174, 0.44444444444444
63103, 1.4608695652174, 0.77608695652174, 0.38888888888889
63104, 1.4608695652174, 0.77608695652174, 0.33333333333333
63105, 1.4608695652174, 0.77608695652174, 0.27777777777778
63106, 1.4608695652174, 0.77608695652174, 0.22222222222222
63107, 1.4608695652174, 0.77608695652174, 0.16666666666667
63108, 1.4608695652174, 0.77608695652174, 0.11111111111111
63109, 1.4608695652174, 0.77608695652174, 0.055555555555556
63110, 1.504347826087, 0.77608695652174, 0.44444444444444
63111, 1.504347826087, 0.77608695652174, 0.38888888888889
63112, 1.504347826087, 0.77608695652174, 0.33333333333333
63113, 1.504347826087, 0.77608695652174, 0.27777777777778
63114, 1.504347826087, 0.77608695652174, 0.22222222222222
63115, 1.504347826087, 0.77608695652174, 0.16666666666667
63116, 1.504347826087, 0.77608695652174, 0.11111111111111
63117, 1.504347826087, 0.77608695652174, 0.055555555555556
63118, 1.5478260869565, 0.77608695652174, 0.44444444444444
63119, 1.5478260869565, 0.77608695652174, 0.38888888888889
63120, 1.5478260869565, 0.77608695652174, 0.33333333333333
63121, 1.5478260869565, 0.77608695652174, 0.27777777777778
63122, 1.5478260869565, 0.77608695652174, 0.22222222222222
63123, 1.5478260869565, 0.77608695652174, 0.16666666666667
63124, 1.5478260869565, 0.77608695652174, 0.11111111111111
63125, 1.5478260869565, 0.77608695652174, 0.055555555555556
63126, 1.5913043478261, 0.77608695652174, 0.44444444444444
63127, 1.5913043478261, 0.77608695652174, 0.38888888888889
63128, 1.5913043478261, 0.77608695652174, 0.33333333333333
63129, 1.5913043478261, 0.77608695652174, 0.27777777777778
63130, 1.5913043478261, 0.77608695652174, 0.22222222222222
63131, 1.5913043478261, 0.77608695652174, 0.16666666666667
63132, 1.5913043478261, 0.77608695652174, 0.11111111111111
63133, 1.5913043478261, 0.77608695652174, 0.055555555555556
63134, 1.6347826086957, 0.77608695652174, 0.44444444444444
63135, 1.6347826086957, 0.77608695652174, 0.38888888888889
63136, 1.6347826086957, 0.77608695652174, 0.33333333333333
63137, 1.6347826086957, 0.77608695652174, 0.27777777777778
63138, 1.6347826086957, 0.77608695652174, 0.22222222222222
63139, 1.6347826086957, 0.77608695652174, 0.16666666666667
63140, 1.6347826086957, 0.77608695652174, 0.11111111111111
63141, 1.6347826086957, 0.77608695652174, 0.055555555555556
63142, 1.6782608695652, 0.77608695652174, 0.44444444444444
63143, 1.6782608695652, 0.77608695652174, 0.38888888888889
63144, 1.6782608695652, 0.77608695652174, 0.33333333333333
63145, 1.6782608695652, 0.77608695652174, 0.27777777777778
63146, 1.6782608695652, 0.77608695652174, 0.22222222222222
63147, 1.6782608695652, 0.77608695652174, 0.16666666666667
63148, 1.6782608695652, 0.77608695652174, 0.11111111111111
63149, 1.6782608695652, 0.77608695652174, 0.055555555555556
63150, 1.7217391304348, 0.77608695652174, 0.44444444444444
63151, 1.7217391304348, 0.77608695652174, 0.38888888888889
63152, 1.7217391304348, 0.77608695652174, 0.33333333333333
63153, 1.7217391304348, 0.77608695652174, 0.27777777777778
63154, 1.7217391304348, 0.77608695652174, 0.22222222222222
63155, 1.7217391304348, 0.77608695652174, 0.16666666666667
63156, 1.7217391304348, 0.77608695652174, 0.11111111111111
63157, 1.7217391304348, 0.77608695652174, 0.055555555555556
63158, 1.7652173913043, 0.77608695652174, 0.44444444444444
63159, 1.7652173913043, 0.77608695652174, 0.38888888888889
63160, 1.7652173913043, 0.77608695652174, 0.33333333333333
63161, 1.7652173913043, 0.77608695652174, 0.27777777777778
63162, 1.7652173913043, 0.77608695652174, 0.22222222222222
63163, 1.7652173913043, 0.77608695652174, 0.16666666666667
63164, 1.7652173913043, 0.77608695652174, 0.11111111111111
63165, 1.7652173913043, 0.77608695652174, 0.055555555555556
63166, 1.8086956521739, 0.77608695652174, 0.44444444444444
63167, 1.8086956521739, 0.77608695652174, 0.38888888888889
63168, 1.8086956521739, 0.77608695652174, 0.33333333333333
63169, 1.8086956521739, 0.77608695652174, 0.27777777777778
63170, 1.8086956521739, 0.77608695652174, 0.22222222222222
63171, 1.8086956521739, 0.77608695652174, 0.16666666666667
63172, 1.8086956521739, 0.77608695652174, 0.11111111111111
63173, 1.8086956521739, 0.77608695652174, 0.055555555555556
63174, 1.8521739130435, 0.77608695652174, 0.44444444444444
63175, 1.8521739130435, 0.77608695652174, 0.38888888888889
63176, 1.8521739130435, 0.77608695652174, 0.33333333333333
63177, 1.8521739130435, 0.77608695652174, 0.27777777777778
63178, 1.8521739130435, 0.77608695652174, 0.22222222222222
63179, 1.8521739130435, 0.77608695652174, 0.16666666666667
63180, 1.8521739130435, 0.77608695652174, 0.11111111111111
63181, 1.8521739130435, 0.77608695652174, 0.055555555555556
63182, 1.895652173913, 0.77608695652174, 0.44444444444444
63183, 1.895652173913, 0.77608695652174, 0.38888888888889
63184, 1.895652173913, 0.77608695652174, 0.33333333333333
63185, 1.895652173913, 0.77608695652174, 0.27777777777778
63186, 1.895652173913, 0.77608695652174, 0.22222222222222
63187, 1.895652173913, 0.77608695652174, 0.16666666666667
63188, 1.895652173913, 0.77608695652174, 0.11111111111111
63189, 1.895652173913, 0.77608695652174, 0.055555555555556
63190, 1.9391304347826, 0.77608695652174, 0.44444444444444
63191, 1.9391304347826, 0.77608695652174, 0.38888888888889
63192, 1.9391304347826, 0.77608695652174, 0.33333333333333
63193, 1.9391304347826, 0.77608695652174, 0.27777777777778
63194, 1.9391304347826, 0.77608695652174, 0.22222222222222
63195, 1.9391304347826, 0.77608695652174, 0.16666666666667
63196, 1.9391304347826, 0.77608695652174, 0.11111111111111
63197, 1.9391304347826, 0.77608695652174, 0.055555555555556
63198, 1.9826086956522, 0.77608695652174, 0.44444444444444
63199, 1.9826086956522, 0.77608695652174, 0.38888888888889
63200, 1.9826086956522, 0.77608695652174, 0.33333333333333
63201, 1.9826086956522, 0.77608695652174, 0.27777777777778
63202, 1.9826086956522, 0.77608695652174, 0.22222222222222
63203, 1.9826086956522, 0.77608695652174, 0.16666666666667
63204, 1.9826086956522, 0.77608695652174, 0.11111111111111
63205, 1.9826086956522, 0.77608695652174, 0.055555555555556
63206, 2.0260869565217, 0.77608695652174, 0.44444444444444
63207, 2.0260869565217, 0.77608695652174, 0.38888888888889
63208, 2.0260869565217, 0.77608695652174, 0.33333333333333
63209, 2.0260869565217, 0.77608695652174, 0.27777777777778
63210, 2.0260869565217, 0.77608695652174, 0.22222222222222
63211, 2.0260869565217, 0.77608695652174, 0.16666666666667
63212, 2.0260869565217, 0.77608695652174, 0.11111111111111
63213, 2.0260869565217, 0.77608695652174, 0.055555555555556
63214, 2.0695652173913, 0.77608695652174, 0.44444444444444
63215, 2.0695652173913, 0.77608695652174, 0.38888888888889
63216, 2.0695652173913, 0.77608695652174, 0.33333333333333
63217, 2.0695652173913, 0.77608695652174, 0.27777777777778
63218, 2.0695652173913, 0.77608695652174, 0.22222222222222
63219, 2.0695652173913, 0.77608695652174, 0.16666666666667
63220, 2.0695652173913, 0.77608695652174, 0.11111111111111
63221, 2.0695652173913, 0.77608695652174, 0.055555555555556
63222, 2.1130434782609, 0.77608695652174, 0.44444444444444
63223, 2.1130434782609, 0.77608695652174, 0.38888888888889
63224, 2.1130434782609, 0.77608695652174, 0.33333333333333
63225, 2.1130434782609, 0.77608695652174, 0.27777777777778
63226, 2.1130434782609, 0.77608695652174, 0.22222222222222
63227, 2.1130434782609, 0.77608695652174, 0.16666666666667
63228, 2.1130434782609, 0.77608695652174, 0.11111111111111
63229, 2.1130434782609, 0.77608695652174, 0.055555555555556
63230, 2.1565217391304, 0.77608695652174, 0.44444444444444
63231, 2.1565217391304, 0.77608695652174, 0.38888888888889
63232, 2.1565217391304, 0.77608695652174, 0.33333333333333
63233, 2.1565217391304, 0.77608695652174, 0.27777777777778
63234, 2.1565217391304, 0.77608695652174, 0.22222222222222
63235, 2.1565217391304, 0.77608695652174, 0.16666666666667
63236, 2.1565217391304, 0.77608695652174, 0.11111111111111
63237, 2.1565217391304, 0.77608695652174, 0.055555555555556
63238, 1.2434782608696, 0.72391304347826, 0.44444444444444
63239, 1.2434782608696, 0.72391304347826, 0.38888888888889
63240, 1.2434782608696, 0.72391304347826, 0.33333333333333
63241, 1.2434782608696, 0.72391304347826, 0.27777777777778
63242, 1.2434782608696, 0.72391304347826, 0.22222222222222
63243, 1.2434782608696, 0.72391304347826, 0.16666666666667
63244, 1.2434782608696, 0.72391304347826, 0.11111111111111
63245, 1.2434782608696, 0.72391304347826, 0.055555555555556
63246, 1.2869565217391, 0.72391304347826, 0.44444444444444
63247, 1.2869565217391, 0.72391304347826, 0.38888888888889
63248, 1.2869565217391, 0.72391304347826, 0.33333333333333
63249, 1.2869565217391, 0.72391304347826, 0.27777777777778
63250, 1.2869565217391, 0.72391304347826, 0.22222222222222
63251, 1.2869565217391, 0.72391304347826, 0.16666666666667
63252, 1.2869565217391, 0.72391304347826, 0.11111111111111
63253, 1.2869565217391, 0.72391304347826, 0.055555555555556
63254, 1.3304347826087, 0.72391304347826, 0.44444444444444
63255, 1.3304347826087, 0.72391304347826, 0.38888888888889
63256, 1.3304347826087, 0.72391304347826, 0.33333333333333
63257, 1.3304347826087, 0.72391304347826, 0.27777777777778
63258, 1.3304347826087, 0.72391304347826, 0.22222222222222
63259, 1.3304347826087, 0.72391304347826, 0.16666666666667
63260, 1.3304347826087, 0.72391304347826, 0.11111111111111
63261, 1.3304347826087, 0.72391304347826, 0.055555555555556
63262, 1.3739130434783, 0.72391304347826, 0.44444444444444
63263, 1.3739130434783, 0.72391304347826, 0.38888888888889
63264, 1.3739130434783, 0.72391304347826, 0.33333333333333
63265, 1.3739130434783, 0.72391304347826, 0.27777777777778
63266, 1.3739130434783, 0.72391304347826, 0.22222222222222
63267, 1.3739130434783, 0.72391304347826, 0.16666666666667
63268, 1.3739130434783, 0.72391304347826, 0.11111111111111
63269, 1.3739130434783, 0.72391304347826, 0.055555555555556
63270, 1.4173913043478, 0.72391304347826, 0.44444444444444
63271, 1.4173913043478, 0.72391304347826, 0.38888888888889
63272, 1.4173913043478, 0.72391304347826, 0.33333333333333
63273, 1.4173913043478, 0.72391304347826, 0.27777777777778
63274, 1.4173913043478, 0.72391304347826, 0.22222222222222
63275, 1.4173913043478, 0.72391304347826, 0.16666666666667
63276, 1.4173913043478, 0.72391304347826, 0.11111111111111
63277, 1.4173913043478, 0.72391304347826, 0.055555555555556
63278, 1.4608695652174, 0.72391304347826, 0.44444444444444
63279, 1.4608695652174, 0.72391304347826, 0.38888888888889
63280, 1.4608695652174, 0.72391304347826, 0.33333333333333
63281, 1.4608695652174, 0.72391304347826, 0.27777777777778
63282, 1.4608695652174, 0.72391304347826, 0.22222222222222
63283, 1.4608695652174, 0.72391304347826, 0.16666666666667
63284, 1.4608695652174, 0.72391304347826, 0.11111111111111
63285, 1.4608695652174, 0.72391304347826, 0.055555555555556
63286, 1.504347826087, 0.72391304347826, 0.44444444444444
63287, 1.504347826087, 0.72391304347826, 0.38888888888889
63288, 1.504347826087, 0.72391304347826, 0.33333333333333
63289, 1.504347826087, 0.72391304347826, 0.27777777777778
63290, 1.504347826087, 0.72391304347826, 0.22222222222222
63291, 1.504347826087, 0.72391304347826, 0.16666666666667
63292, 1.504347826087, 0.72391304347826, 0.11111111111111
63293, 1.504347826087, 0.72391304347826, 0.055555555555556
63294, 1.5478260869565, 0.72391304347826, 0.44444444444444
63295, 1.5478260869565, 0.72391304347826, 0.38888888888889
63296, 1.5478260869565, 0.72391304347826, 0.33333333333333
63297, 1.5478260869565, 0.72391304347826, 0.27777777777778
63298, 1.5478260869565, 0.72391304347826, 0.22222222222222
63299, 1.5478260869565, 0.72391304347826, 0.16666666666667
63300, 1.5478260869565, 0.72391304347826, 0.11111111111111
63301, 1.5478260869565, 0.72391304347826, 0.055555555555556
63302, 1.5913043478261, 0.72391304347826, 0.44444444444444
63303, 1.5913043478261, 0.72391304347826, 0.38888888888889
63304, 1.5913043478261, 0.72391304347826, 0.33333333333333
63305, 1.5913043478261, 0.72391304347826, 0.27777777777778
63306, 1.5913043478261, 0.72391304347826, 0.22222222222222
63307, 1.5913043478261, 0.72391304347826, 0.16666666666667
63308, 1.5913043478261, 0.72391304347826, 0.11111111111111
63309, 1.5913043478261, 0.72391304347826, 0.055555555555556
63310, 1.6347826086957, 0.72391304347826, 0.44444444444444
63311, 1.6347826086957, 0.72391304347826, 0.38888888888889
63312, 1.6347826086957, 0.72391304347826, 0.33333333333333
63313, 1.6347826086957, 0.72391304347826, 0.27777777777778
63314, 1.6347826086957, 0.72391304347826, 0.22222222222222
63315, 1.6347826086957, 0.72391304347826, 0.16666666666667
63316, 1.6347826086957, 0.72391304347826, 0.11111111111111
63317, 1.6347826086957, 0.72391304347826, 0.055555555555556
63318, 1.6782608695652, 0.72391304347826, 0.44444444444444
63319, 1.6782608695652, 0.72391304347826, 0.38888888888889
63320, 1.6782608695652, 0.72391304347826, 0.33333333333333
63321, 1.6782608695652, 0.72391304347826, 0.27777777777778
63322, 1.6782608695652, 0.72391304347826, 0.22222222222222
63323, 1.6782608695652, 0.72391304347826, 0.16666666666667
63324, 1.6782608695652, 0.72391304347826, 0.11111111111111
63325, 1.6782608695652, 0.72391304347826, 0.055555555555556
63326, 1.7217391304348, 0.72391304347826, 0.44444444444444
63327, 1.7217391304348, 0.72391304347826, 0.38888888888889
63328, 1.7217391304348, 0.72391304347826, 0.33333333333333
63329, 1.7217391304348, 0.72391304347826, 0.27777777777778
63330, 1.7217391304348, 0.72391304347826, 0.22222222222222
63331, 1.7217391304348, 0.72391304347826, 0.16666666666667
63332, 1.7217391304348, 0.72391304347826, 0.11111111111111
63333, 1.7217391304348, 0.72391304347826, 0.055555555555556
63334, 1.7652173913043, 0.72391304347826, 0.44444444444444
63335, 1.7652173913043, 0.72391304347826, 0.38888888888889
63336, 1.7652173913043, 0.72391304347826, 0.33333333333333
63337, 1.7652173913043, 0.72391304347826, 0.27777777777778
63338, 1.7652173913043, 0.72391304347826, 0.22222222222222
63339, 1.7652173913043, 0.72391304347826, 0.16666666666667
63340, 1.7652173913043, 0.72391304347826, 0.11111111111111
63341, 1.7652173913043, 0.72391304347826, 0.055555555555556
63342, 1.8086956521739, 0.72391304347826, 0.44444444444444
63343, 1.8086956521739, 0.72391304347826, 0.38888888888889
63344, 1.8086956521739, 0.72391304347826, 0.33333333333333
63345, 1.8086956521739, 0.72391304347826, 0.27777777777778
63346, 1.8086956521739, 0.72391304347826, 0.22222222222222
63347, 1.8086956521739, 0.72391304347826, 0.16666666666667
63348, 1.8086956521739, 0.72391304347826, 0.11111111111111
63349, 1.8086956521739, 0.72391304347826, 0.055555555555556
63350, 1.8521739130435, 0.72391304347826, 0.44444444444444
63351, 1.8521739130435, 0.72391304347826, 0.38888888888889
63352, 1.8521739130435, 0.72391304347826, 0.33333333333333
63353, 1.8521739130435, 0.72391304347826, 0.27777777777778
63354, 1.8521739130435, 0.72391304347826, 0.22222222222222
63355, 1.8521739130435, 0.72391304347826, 0.16666666666667
63356, 1.8521739130435, 0.72391304347826, 0.11111111111111
63357, 1.8521739130435, 0.72391304347826, 0.055555555555556
63358, 1.895652173913, 0.72391304347826, 0.44444444444444
63359, 1.895652173913, 0.72391304347826, 0.38888888888889
63360, 1.895652173913, 0.72391304347826, 0.33333333333333
63361, 1.895652173913, 0.72391304347826, 0.27777777777778
63362, 1.895652173913, 0.72391304347826, 0.22222222222222
63363, 1.895652173913, 0.72391304347826, 0.16666666666667
63364, 1.895652173913, 0.72391304347826, 0.11111111111111
63365, 1.895652173913, 0.72391304347826, 0.055555555555556
63366, 1.9391304347826, 0.72391304347826, 0.44444444444444
63367, 1.9391304347826, 0.72391304347826, 0.38888888888889
63368, 1.9391304347826, 0.72391304347826, 0.33333333333333
63369, 1.9391304347826, 0.72391304347826, 0.27777777777778
63370, 1.9391304347826, 0.72391304347826, 0.22222222222222
63371, 1.9391304347826, 0.72391304347826, 0.16666666666667
63372, 1.9391304347826, 0.72391304347826, 0.11111111111111
63373, 1.9391304347826, 0.72391304347826, 0.055555555555556
63374, 1.9826086956522, 0.72391304347826, 0.44444444444444
63375, 1.9826086956522, 0.72391304347826, 0.38888888888889
63376, 1.9826086956522, 0.72391304347826, 0.33333333333333
63377, 1.9826086956522, 0.72391304347826, 0.27777777777778
63378, 1.9826086956522, 0.72391304347826, 0.22222222222222
63379, 1.9826086956522, 0.72391304347826, 0.16666666666667
63380, 1.9826086956522, 0.72391304347826, 0.11111111111111
63381, 1.9826086956522, 0.72391304347826, 0.055555555555556
63382, 2.0260869565217, 0.72391304347826, 0.44444444444444
63383, 2.0260869565217, 0.72391304347826, 0.38888888888889
63384, 2.0260869565217, 0.72391304347826, 0.33333333333333
63385, 2.0260869565217, 0.72391304347826, 0.27777777777778
63386, 2.0260869565217, 0.72391304347826, 0.22222222222222
63387, 2.0260869565217, 0.72391304347826, 0.16666666666667
63388, 2.0260869565217, 0.72391304347826, 0.11111111111111
63389, 2.0260869565217, 0.72391304347826, 0.055555555555556
63390, 2.0695652173913, 0.72391304347826, 0.44444444444444
63391, 2.0695652173913, 0.72391304347826, 0.38888888888889
63392, 2.0695652173913, 0.72391304347826, 0.33333333333333
63393, 2.0695652173913, 0.72391304347826, 0.27777777777778
63394, 2.0695652173913, 0.72391304347826, 0.22222222222222
63395, 2.0695652173913, 0.72391304347826, 0.16666666666667
63396, 2.0695652173913, 0.72391304347826, 0.11111111111111
63397, 2.0695652173913, 0.72391304347826, 0.055555555555556
63398, 2.1130434782609, 0.72391304347826, 0.44444444444444
63399, 2.1130434782609, 0.72391304347826, 0.38888888888889
63400, 2.1130434782609, 0.72391304347826, 0.33333333333333
63401, 2.1130434782609, 0.72391304347826, 0.27777777777778
63402, 2.1130434782609, 0.72391304347826, 0.22222222222222
63403, 2.1130434782609, 0.72391304347826, 0.16666666666667
63404, 2.1130434782609, 0.72391304347826, 0.11111111111111
63405, 2.1130434782609, 0.72391304347826, 0.055555555555556
63406, 2.1565217391304, 0.72391304347826, 0.44444444444444
63407, 2.1565217391304, 0.72391304347826, 0.38888888888889
63408, 2.1565217391304, 0.72391304347826, 0.33333333333333
63409, 2.1565217391304, 0.72391304347826, 0.27777777777778
63410, 2.1565217391304, 0.72391304347826, 0.22222222222222
63411, 2.1565217391304, 0.72391304347826, 0.16666666666667
63412, 2.1565217391304, 0.72391304347826, 0.11111111111111
63413, 2.1565217391304, 0.72391304347826, 0.055555555555556
63414, 1.2434782608696, 0.67173913043478, 0.44444444444444
63415, 1.2434782608696, 0.67173913043478, 0.38888888888889
63416, 1.2434782608696, 0.67173913043478, 0.33333333333333
63417, 1.2434782608696, 0.67173913043478, 0.27777777777778
63418, 1.2434782608696, 0.67173913043478, 0.22222222222222
63419, 1.2434782608696, 0.67173913043478, 0.16666666666667
63420, 1.2434782608696, 0.67173913043478, 0.11111111111111
63421, 1.2434782608696, 0.67173913043478, 0.055555555555556
63422, 1.2869565217391, 0.67173913043478, 0.44444444444444
63423, 1.2869565217391, 0.67173913043478, 0.38888888888889
63424, 1.2869565217391, 0.67173913043478, 0.33333333333333
63425, 1.2869565217391, 0.67173913043478, 0.27777777777778
63426, 1.2869565217391, 0.67173913043478, 0.22222222222222
63427, 1.2869565217391, 0.67173913043478, 0.16666666666667
63428, 1.2869565217391, 0.67173913043478, 0.11111111111111
63429, 1.2869565217391, 0.67173913043478, 0.055555555555556
63430, 1.3304347826087, 0.67173913043478, 0.44444444444444
63431, 1.3304347826087, 0.67173913043478, 0.38888888888889
63432, 1.3304347826087, 0.67173913043478, 0.33333333333333
63433, 1.3304347826087, 0.67173913043478, 0.27777777777778
63434, 1.3304347826087, 0.67173913043478, 0.22222222222222
63435, 1.3304347826087, 0.67173913043478, 0.16666666666667
63436, 1.3304347826087, 0.67173913043478, 0.11111111111111
63437, 1.3304347826087, 0.67173913043478, 0.055555555555556
63438, 1.3739130434783, 0.67173913043478, 0.44444444444444
63439, 1.3739130434783, 0.67173913043478, 0.38888888888889
63440, 1.3739130434783, 0.67173913043478, 0.33333333333333
63441, 1.3739130434783, 0.67173913043478, 0.27777777777778
63442, 1.3739130434783, 0.67173913043478, 0.22222222222222
63443, 1.3739130434783, 0.67173913043478, 0.16666666666667
63444, 1.3739130434783, 0.67173913043478, 0.11111111111111
63445, 1.3739130434783, 0.67173913043478, 0.055555555555556
63446, 1.4173913043478, 0.67173913043478, 0.44444444444444
63447, 1.4173913043478, 0.67173913043478, 0.38888888888889
63448, 1.4173913043478, 0.67173913043478, 0.33333333333333
63449, 1.4173913043478, 0.67173913043478, 0.27777777777778
63450, 1.4173913043478, 0.67173913043478, 0.22222222222222
63451, 1.4173913043478, 0.67173913043478, 0.16666666666667
63452, 1.4173913043478, 0.67173913043478, 0.11111111111111
63453, 1.4173913043478, 0.67173913043478, 0.055555555555556
63454, 1.4608695652174, 0.67173913043478, 0.44444444444444
63455, 1.4608695652174, 0.67173913043478, 0.38888888888889
63456, 1.4608695652174, 0.67173913043478, 0.33333333333333
63457, 1.4608695652174, 0.67173913043478, 0.27777777777778
63458, 1.4608695652174, 0.67173913043478, 0.22222222222222
63459, 1.4608695652174, 0.67173913043478, 0.16666666666667
63460, 1.4608695652174, 0.67173913043478, 0.11111111111111
63461, 1.4608695652174, 0.67173913043478, 0.055555555555556
63462, 1.504347826087, 0.67173913043478, 0.44444444444444
63463, 1.504347826087, 0.67173913043478, 0.38888888888889
63464, 1.504347826087, 0.67173913043478, 0.33333333333333
63465, 1.504347826087, 0.67173913043478, 0.27777777777778
63466, 1.504347826087, 0.67173913043478, 0.22222222222222
63467, 1.504347826087, 0.67173913043478, 0.16666666666667
63468, 1.504347826087, 0.67173913043478, 0.11111111111111
63469, 1.504347826087, 0.67173913043478, 0.055555555555556
63470, 1.5478260869565, 0.67173913043478, 0.44444444444444
63471, 1.5478260869565, 0.67173913043478, 0.38888888888889
63472, 1.5478260869565, 0.67173913043478, 0.33333333333333
63473, 1.5478260869565, 0.67173913043478, 0.27777777777778
63474, 1.5478260869565, 0.67173913043478, 0.22222222222222
63475, 1.5478260869565, 0.67173913043478, 0.16666666666667
63476, 1.5478260869565, 0.67173913043478, 0.11111111111111
63477, 1.5478260869565, 0.67173913043478, 0.055555555555556
63478, 1.5913043478261, 0.67173913043478, 0.44444444444444
63479, 1.5913043478261, 0.67173913043478, 0.38888888888889
63480, 1.5913043478261, 0.67173913043478, 0.33333333333333
63481, 1.5913043478261, 0.67173913043478, 0.27777777777778
63482, 1.5913043478261, 0.67173913043478, 0.22222222222222
63483, 1.5913043478261, 0.67173913043478, 0.16666666666667
63484, 1.5913043478261, 0.67173913043478, 0.11111111111111
63485, 1.5913043478261, 0.67173913043478, 0.055555555555556
63486, 1.6347826086957, 0.67173913043478, 0.44444444444444
63487, 1.6347826086957, 0.67173913043478, 0.38888888888889
63488, 1.6347826086957, 0.67173913043478, 0.33333333333333
63489, 1.6347826086957, 0.67173913043478, 0.27777777777778
63490, 1.6347826086957, 0.67173913043478, 0.22222222222222
63491, 1.6347826086957, 0.67173913043478, 0.16666666666667
63492, 1.6347826086957, 0.67173913043478, 0.11111111111111
63493, 1.6347826086957, 0.67173913043478, 0.055555555555556
63494, 1.6782608695652, 0.67173913043478, 0.44444444444444
63495, 1.6782608695652, 0.67173913043478, 0.38888888888889
63496, 1.6782608695652, 0.67173913043478, 0.33333333333333
63497, 1.6782608695652, 0.67173913043478, 0.27777777777778
63498, 1.6782608695652, 0.67173913043478, 0.22222222222222
63499, 1.6782608695652, 0.67173913043478, 0.16666666666667
63500, 1.6782608695652, 0.67173913043478, 0.11111111111111
63501, 1.6782608695652, 0.67173913043478, 0.055555555555556
63502, 1.7217391304348, 0.67173913043478, 0.44444444444444
63503, 1.7217391304348, 0.67173913043478, 0.38888888888889
63504, 1.7217391304348, 0.67173913043478, 0.33333333333333
63505, 1.7217391304348, 0.67173913043478, 0.27777777777778
63506, 1.7217391304348, 0.67173913043478, 0.22222222222222
63507, 1.7217391304348, 0.67173913043478, 0.16666666666667
63508, 1.7217391304348, 0.67173913043478, 0.11111111111111
63509, 1.7217391304348, 0.67173913043478, 0.055555555555556
63510, 1.7652173913043, 0.67173913043478, 0.44444444444444
63511, 1.7652173913043, 0.67173913043478, 0.38888888888889
63512, 1.7652173913043, 0.67173913043478, 0.33333333333333
63513, 1.7652173913043, 0.67173913043478, 0.27777777777778
63514, 1.7652173913043, 0.67173913043478, 0.22222222222222
63515, 1.7652173913043, 0.67173913043478, 0.16666666666667
63516, 1.7652173913043, 0.67173913043478, 0.11111111111111
63517, 1.7652173913043, 0.67173913043478, 0.055555555555556
63518, 1.8086956521739, 0.67173913043478, 0.44444444444444
63519, 1.8086956521739, 0.67173913043478, 0.38888888888889
63520, 1.8086956521739, 0.67173913043478, 0.33333333333333
63521, 1.8086956521739, 0.67173913043478, 0.27777777777778
63522, 1.8086956521739, 0.67173913043478, 0.22222222222222
63523, 1.8086956521739, 0.67173913043478, 0.16666666666667
63524, 1.8086956521739, 0.67173913043478, 0.11111111111111
63525, 1.8086956521739, 0.67173913043478, 0.055555555555556
63526, 1.8521739130435, 0.67173913043478, 0.44444444444444
63527, 1.8521739130435, 0.67173913043478, 0.38888888888889
63528, 1.8521739130435, 0.67173913043478, 0.33333333333333
63529, 1.8521739130435, 0.67173913043478, 0.27777777777778
63530, 1.8521739130435, 0.67173913043478, 0.22222222222222
63531, 1.8521739130435, 0.67173913043478, 0.16666666666667
63532, 1.8521739130435, 0.67173913043478, 0.11111111111111
63533, 1.8521739130435, 0.67173913043478, 0.055555555555556
63534, 1.895652173913, 0.67173913043478, 0.44444444444444
63535, 1.895652173913, 0.67173913043478, 0.38888888888889
63536, 1.895652173913, 0.67173913043478, 0.33333333333333
63537, 1.895652173913, 0.67173913043478, 0.27777777777778
63538, 1.895652173913, 0.67173913043478, 0.22222222222222
63539, 1.895652173913, 0.67173913043478, 0.16666666666667
63540, 1.895652173913, 0.67173913043478, 0.11111111111111
63541, 1.895652173913, 0.67173913043478, 0.055555555555556
63542, 1.9391304347826, 0.67173913043478, 0.44444444444444
63543, 1.9391304347826, 0.67173913043478, 0.38888888888889
63544, 1.9391304347826, 0.67173913043478, 0.33333333333333
63545, 1.9391304347826, 0.67173913043478, 0.27777777777778
63546, 1.9391304347826, 0.67173913043478, 0.22222222222222
63547, 1.9391304347826, 0.67173913043478, 0.16666666666667
63548, 1.9391304347826, 0.67173913043478, 0.11111111111111
63549, 1.9391304347826, 0.67173913043478, 0.055555555555556
63550, 1.9826086956522, 0.67173913043478, 0.44444444444444
63551, 1.9826086956522, 0.67173913043478, 0.38888888888889
63552, 1.9826086956522, 0.67173913043478, 0.33333333333333
63553, 1.9826086956522, 0.67173913043478, 0.27777777777778
63554, 1.9826086956522, 0.67173913043478, 0.22222222222222
63555, 1.9826086956522, 0.67173913043478, 0.16666666666667
63556, 1.9826086956522, 0.67173913043478, 0.11111111111111
63557, 1.9826086956522, 0.67173913043478, 0.055555555555556
63558, 2.0260869565217, 0.67173913043478, 0.44444444444444
63559, 2.0260869565217, 0.67173913043478, 0.38888888888889
63560, 2.0260869565217, 0.67173913043478, 0.33333333333333
63561, 2.0260869565217, 0.67173913043478, 0.27777777777778
63562, 2.0260869565217, 0.67173913043478, 0.22222222222222
63563, 2.0260869565217, 0.67173913043478, 0.16666666666667
63564, 2.0260869565217, 0.67173913043478, 0.11111111111111
63565, 2.0260869565217, 0.67173913043478, 0.055555555555556
63566, 2.0695652173913, 0.67173913043478, 0.44444444444444
63567, 2.0695652173913, 0.67173913043478, 0.38888888888889
63568, 2.0695652173913, 0.67173913043478, 0.33333333333333
63569, 2.0695652173913, 0.67173913043478, 0.27777777777778
63570, 2.0695652173913, 0.67173913043478, 0.22222222222222
63571, 2.0695652173913, 0.67173913043478, 0.16666666666667
63572, 2.0695652173913, 0.67173913043478, 0.11111111111111
63573, 2.0695652173913, 0.67173913043478, 0.055555555555556
63574, 2.1130434782609, 0.67173913043478, 0.44444444444444
63575, 2.1130434782609, 0.67173913043478, 0.38888888888889
63576, 2.1130434782609, 0.67173913043478, 0.33333333333333
63577, 2.1130434782609, 0.67173913043478, 0.27777777777778
63578, 2.1130434782609, 0.67173913043478, 0.22222222222222
63579, 2.1130434782609, 0.67173913043478, 0.16666666666667
63580, 2.1130434782609, 0.67173913043478, 0.11111111111111
63581, 2.1130434782609, 0.67173913043478, 0.055555555555556
63582, 2.1565217391304, 0.67173913043478, 0.44444444444444
63583, 2.1565217391304, 0.67173913043478, 0.38888888888889
63584, 2.1565217391304, 0.67173913043478, 0.33333333333333
63585, 2.1565217391304, 0.67173913043478, 0.27777777777778
63586, 2.1565217391304, 0.67173913043478, 0.22222222222222
63587, 2.1565217391304, 0.67173913043478, 0.16666666666667
63588, 2.1565217391304, 0.67173913043478, 0.11111111111111
63589, 2.1565217391304, 0.67173913043478, 0.055555555555556
63590, 1.2434782608696, 0.61956521739131, 0.44444444444444
63591, 1.2434782608696, 0.61956521739131, 0.38888888888889
63592, 1.2434782608696, 0.61956521739131, 0.33333333333333
63593, 1.2434782608696, 0.6195652173913, 0.27777777777778
63594, 1.2434782608696, 0.61956521739131, 0.22222222222222
63595, 1.2434782608696, 0.61956521739131, 0.16666666666667
63596, 1.2434782608696, 0.61956521739131, 0.11111111111111
63597, 1.2434782608696, 0.61956521739131, 0.055555555555556
63598, 1.2869565217391, 0.61956521739131, 0.44444444444444
63599, 1.2869565217391, 0.61956521739131, 0.38888888888889
63600, 1.2869565217391, 0.61956521739131, 0.33333333333333
63601, 1.2869565217391, 0.61956521739131, 0.27777777777778
63602, 1.2869565217391, 0.61956521739131, 0.22222222222222
63603, 1.2869565217391, 0.6195652173913, 0.16666666666667
63604, 1.2869565217391, 0.61956521739131, 0.11111111111111
63605, 1.2869565217391, 0.61956521739131, 0.055555555555556
63606, 1.3304347826087, 0.61956521739131, 0.44444444444444
63607, 1.3304347826087, 0.61956521739131, 0.38888888888889
63608, 1.3304347826087, 0.61956521739131, 0.33333333333333
63609, 1.3304347826087, 0.61956521739131, 0.27777777777778
63610, 1.3304347826087, 0.61956521739131, 0.22222222222222
63611, 1.3304347826087, 0.61956521739131, 0.16666666666667
63612, 1.3304347826087, 0.61956521739131, 0.11111111111111
63613, 1.3304347826087, 0.61956521739131, 0.055555555555556
63614, 1.3739130434783, 0.61956521739131, 0.44444444444444
63615, 1.3739130434783, 0.61956521739131, 0.38888888888889
63616, 1.3739130434783, 0.61956521739131, 0.33333333333333
63617, 1.3739130434783, 0.61956521739131, 0.27777777777778
63618, 1.3739130434783, 0.61956521739131, 0.22222222222222
63619, 1.3739130434783, 0.61956521739131, 0.16666666666667
63620, 1.3739130434783, 0.61956521739131, 0.11111111111111
63621, 1.3739130434783, 0.61956521739131, 0.055555555555556
63622, 1.4173913043478, 0.61956521739131, 0.44444444444444
63623, 1.4173913043478, 0.61956521739131, 0.38888888888889
63624, 1.4173913043478, 0.61956521739131, 0.33333333333333
63625, 1.4173913043478, 0.61956521739131, 0.27777777777778
63626, 1.4173913043478, 0.61956521739131, 0.22222222222222
63627, 1.4173913043478, 0.61956521739131, 0.16666666666667
63628, 1.4173913043478, 0.61956521739131, 0.11111111111111
63629, 1.4173913043478, 0.61956521739131, 0.055555555555556
63630, 1.4608695652174, 0.61956521739131, 0.44444444444444
63631, 1.4608695652174, 0.61956521739131, 0.38888888888889
63632, 1.4608695652174, 0.61956521739131, 0.33333333333333
63633, 1.4608695652174, 0.6195652173913, 0.27777777777778
63634, 1.4608695652174, 0.61956521739131, 0.22222222222222
63635, 1.4608695652174, 0.6195652173913, 0.16666666666667
63636, 1.4608695652174, 0.61956521739131, 0.11111111111111
63637, 1.4608695652174, 0.61956521739131, 0.055555555555556
63638, 1.504347826087, 0.61956521739131, 0.44444444444444
63639, 1.504347826087, 0.6195652173913, 0.38888888888889
63640, 1.504347826087, 0.6195652173913, 0.33333333333333
63641, 1.504347826087, 0.6195652173913, 0.27777777777778
63642, 1.504347826087, 0.6195652173913, 0.22222222222222
63643, 1.504347826087, 0.6195652173913, 0.16666666666667
63644, 1.504347826087, 0.6195652173913, 0.11111111111111
63645, 1.504347826087, 0.6195652173913, 0.055555555555556
63646, 1.5478260869565, 0.61956521739131, 0.44444444444444
63647, 1.5478260869565, 0.61956521739131, 0.38888888888889
63648, 1.5478260869565, 0.61956521739131, 0.33333333333333
63649, 1.5478260869565, 0.61956521739131, 0.27777777777778
63650, 1.5478260869565, 0.61956521739131, 0.22222222222222
63651, 1.5478260869565, 0.6195652173913, 0.16666666666667
63652, 1.5478260869565, 0.61956521739131, 0.11111111111111
63653, 1.5478260869565, 0.61956521739131, 0.055555555555556
63654, 1.5913043478261, 0.61956521739131, 0.44444444444444
63655, 1.5913043478261, 0.61956521739131, 0.38888888888889
63656, 1.5913043478261, 0.6195652173913, 0.33333333333333
63657, 1.5913043478261, 0.6195652173913, 0.27777777777778
63658, 1.5913043478261, 0.6195652173913, 0.22222222222222
63659, 1.5913043478261, 0.6195652173913, 0.16666666666667
63660, 1.5913043478261, 0.6195652173913, 0.11111111111111
63661, 1.5913043478261, 0.6195652173913, 0.055555555555556
63662, 1.6347826086957, 0.61956521739131, 0.44444444444444
63663, 1.6347826086957, 0.61956521739131, 0.38888888888889
63664, 1.6347826086957, 0.61956521739131, 0.33333333333333
63665, 1.6347826086957, 0.61956521739131, 0.27777777777778
63666, 1.6347826086957, 0.61956521739131, 0.22222222222222
63667, 1.6347826086957, 0.61956521739131, 0.16666666666667
63668, 1.6347826086957, 0.61956521739131, 0.11111111111111
63669, 1.6347826086957, 0.61956521739131, 0.055555555555556
63670, 1.6782608695652, 0.61956521739131, 0.44444444444444
63671, 1.6782608695652, 0.61956521739131, 0.38888888888889
63672, 1.6782608695652, 0.61956521739131, 0.33333333333333
63673, 1.6782608695652, 0.6195652173913, 0.27777777777778
63674, 1.6782608695652, 0.61956521739131, 0.22222222222222
63675, 1.6782608695652, 0.61956521739131, 0.16666666666667
63676, 1.6782608695652, 0.61956521739131, 0.11111111111111
63677, 1.6782608695652, 0.61956521739131, 0.055555555555556
63678, 1.7217391304348, 0.61956521739131, 0.44444444444444
63679, 1.7217391304348, 0.61956521739131, 0.38888888888889
63680, 1.7217391304348, 0.61956521739131, 0.33333333333333
63681, 1.7217391304348, 0.6195652173913, 0.27777777777778
63682, 1.7217391304348, 0.61956521739131, 0.22222222222222
63683, 1.7217391304348, 0.61956521739131, 0.16666666666667
63684, 1.7217391304348, 0.61956521739131, 0.11111111111111
63685, 1.7217391304348, 0.61956521739131, 0.055555555555556
63686, 1.7652173913043, 0.61956521739131, 0.44444444444444
63687, 1.7652173913043, 0.61956521739131, 0.38888888888889
63688, 1.7652173913043, 0.61956521739131, 0.33333333333333
63689, 1.7652173913043, 0.61956521739131, 0.27777777777778
63690, 1.7652173913043, 0.61956521739131, 0.22222222222222
63691, 1.7652173913043, 0.61956521739131, 0.16666666666667
63692, 1.7652173913043, 0.61956521739131, 0.11111111111111
63693, 1.7652173913043, 0.61956521739131, 0.055555555555556
