96049, 1.6347826086957, 1.375, 0.25
96050, 1.6130434782609, 1.375, 0.22222222222222
96051, 1.6347826086957, 1.3875, 0.22222222222222
96052, 1.6347826086957, 1.375, 0.19444444444444
96053, 1.6130434782609, 1.375, 0.16666666666667
96054, 1.6347826086957, 1.3875, 0.16666666666667
96055, 1.6347826086957, 1.375, 0.13888888888889
96056, 1.6130434782609, 1.375, 0.11111111111111
96057, 1.6347826086957, 1.3875, 0.11111111111111
96058, 1.6347826086957, 1.375, 0.083333333333333
96059, 1.6130434782609, 1.375, 0.055555555555556
96060, 1.6347826086957, 1.3875, 0.055555555555556
96061, 1.6347826086957, 1.375, 0.027777777777778
96062, 1.6782608695652, 1.375, 0.47222222222222
96063, 1.6565217391304, 1.375, 0.44444444444444
96064, 1.6782608695652, 1.3875, 0.44444444444444
96065, 1.6782608695652, 1.375, 0.41666666666667
96066, 1.6565217391304, 1.375, 0.38888888888889
96067, 1.6782608695652, 1.3875, 0.38888888888889
96068, 1.6782608695652, 1.375, 0.36111111111111
96069, 1.6565217391304, 1.375, 0.33333333333333
96070, 1.6782608695652, 1.3875, 0.33333333333333
96071, 1.6782608695652, 1.375, 0.30555555555556
96072, 1.6565217391304, 1.375, 0.27777777777778
96073, 1.6782608695652, 1.3875, 0.27777777777778
96074, 1.6782608695652, 1.375, 0.25
96075, 1.6565217391304, 1.375, 0.22222222222222
96076, 1.6782608695652, 1.3875, 0.22222222222222
96077, 1.6782608695652, 1.375, 0.19444444444444
96078, 1.6565217391304, 1.375, 0.16666666666667
96079, 1.6782608695652, 1.3875, 0.16666666666667
96080, 1.6782608695652, 1.375, 0.13888888888889
96081, 1.6565217391304, 1.375, 0.11111111111111
96082, 1.6782608695652, 1.3875, 0.11111111111111
96083, 1.6782608695652, 1.375, 0.083333333333333
96084, 1.6565217391304, 1.375, 0.055555555555556
96085, 1.6782608695652, 1.3875, 0.055555555555556
96086, 1.6782608695652, 1.375, 0.027777777777778
96087, 1.7217391304348, 1.375, 0.47222222222222
96088, 1.7, 1.375, 0.44444444444444
96089, 1.7217391304348, 1.3875, 0.44444444444444
96090, 1.7217391304348, 1.375, 0.41666666666667
96091, 1.7, 1.375, 0.38888888888889
96092, 1.7217391304348, 1.3875, 0.38888888888889
96093, 1.7217391304348, 1.375, 0.36111111111111
96094, 1.7, 1.375, 0.33333333333333
96095, 1.7217391304348, 1.3875, 0.33333333333333
96096, 1.7217391304348, 1.375, 0.30555555555556
96097, 1.7, 1.375, 0.27777777777778
96098, 1.7217391304348, 1.3875, 0.27777777777778
96099, 1.7217391304348, 1.375, 0.25
96100, 1.7, 1.375, 0.22222222222222
96101, 1.7217391304348, 1.3875, 0.22222222222222
96102, 1.7217391304348, 1.375, 0.19444444444444
96103, 1.7, 1.375, 0.16666666666667
96104, 1.7217391304348, 1.3875, 0.16666666666667
96105, 1.7217391304348, 1.375, 0.13888888888889
96106, 1.7, 1.375, 0.11111111111111
96107, 1.7217391304348, 1.3875, 0.11111111111111
96108, 1.7217391304348, 1.375, 0.083333333333333
96109, 1.7, 1.375, 0.055555555555556
96110, 1.7217391304348, 1.3875, 0.055555555555556
96111, 1.7217391304348, 1.375, 0.027777777777778
96112, 1.7652173913043, 1.375, 0.47222222222222
96113, 1.7434782608696, 1.375, 0.44444444444444
96114, 1.7652173913043, 1.3875, 0.44444444444444
96115, 1.7652173913043, 1.375, 0.41666666666667
96116, 1.7434782608696, 1.375, 0.38888888888889
96117, 1.7652173913043, 1.3875, 0.38888888888889
96118, 1.7652173913043, 1.375, 0.36111111111111
96119, 1.7434782608696, 1.375, 0.33333333333333
96120, 1.7652173913043, 1.3875, 0.33333333333333
96121, 1.7652173913043, 1.375, 0.30555555555556
96122, 1.7434782608696, 1.375, 0.27777777777778
96123, 1.7652173913043, 1.3875, 0.27777777777778
96124, 1.7652173913043, 1.375, 0.25
96125, 1.7434782608696, 1.375, 0.22222222222222
96126, 1.7652173913043, 1.3875, 0.22222222222222
96127, 1.7652173913043, 1.375, 0.19444444444444
96128, 1.7434782608696, 1.375, 0.16666666666667
96129, 1.7652173913043, 1.3875, 0.16666666666667
96130, 1.7652173913043, 1.375, 0.13888888888889
96131, 1.7434782608696, 1.375, 0.11111111111111
96132, 1.7652173913043, 1.3875, 0.11111111111111
96133, 1.7652173913043, 1.375, 0.083333333333333
96134, 1.7434782608696, 1.375, 0.055555555555556
96135, 1.7652173913043, 1.3875, 0.055555555555556
96136, 1.7652173913043, 1.375, 0.027777777777778
96137, 1.8086956521739, 1.375, 0.47222222222222
96138, 1.7869565217391, 1.375, 0.44444444444444
96139, 1.8086956521739, 1.3875, 0.44444444444444
96140, 1.8086956521739, 1.375, 0.41666666666667
96141, 1.7869565217391, 1.375, 0.38888888888889
96142, 1.8086956521739, 1.3875, 0.38888888888889
96143, 1.8086956521739, 1.375, 0.36111111111111
96144, 1.7869565217391, 1.375, 0.33333333333333
96145, 1.8086956521739, 1.3875, 0.33333333333333
96146, 1.8086956521739, 1.375, 0.30555555555556
96147, 1.7869565217391, 1.375, 0.27777777777778
96148, 1.8086956521739, 1.3875, 0.27777777777778
96149, 1.8086956521739, 1.375, 0.25
96150, 1.7869565217391, 1.375, 0.22222222222222
96151, 1.8086956521739, 1.3875, 0.22222222222222
96152, 1.8086956521739, 1.375, 0.19444444444444
96153, 1.7869565217391, 1.375, 0.16666666666667
96154, 1.8086956521739, 1.3875, 0.16666666666667
96155, 1.8086956521739, 1.375, 0.13888888888889
96156, 1.7869565217391, 1.375, 0.11111111111111
96157, 1.8086956521739, 1.3875, 0.11111111111111
96158, 1.8086956521739, 1.375, 0.083333333333333
96159, 1.7869565217391, 1.375, 0.055555555555556
96160, 1.8086956521739, 1.3875, 0.055555555555556
96161, 1.8086956521739, 1.375, 0.027777777777778
96162, 1.8521739130435, 1.375, 0.47222222222222
96163, 1.8304347826087, 1.375, 0.44444444444444
96164, 1.8521739130435, 1.3875, 0.44444444444444
96165, 1.8521739130435, 1.375, 0.41666666666667
96166, 1.8304347826087, 1.375, 0.38888888888889
96167, 1.8521739130435, 1.3875, 0.38888888888889
96168, 1.8521739130435, 1.375, 0.36111111111111
96169, 1.8304347826087, 1.375, 0.33333333333333
96170, 1.8521739130435, 1.3875, 0.33333333333333
96171, 1.8521739130435, 1.375, 0.30555555555556
96172, 1.8304347826087, 1.375, 0.27777777777778
96173, 1.8521739130435, 1.3875, 0.27777777777778
96174, 1.8521739130435, 1.375, 0.25
96175, 1.8304347826087, 1.375, 0.22222222222222
96176, 1.8521739130435, 1.3875, 0.22222222222222
96177, 1.8521739130435, 1.375, 0.19444444444444
96178, 1.8304347826087, 1.375, 0.16666666666667
96179, 1.8521739130435, 1.3875, 0.16666666666667
96180, 1.8521739130435, 1.375, 0.13888888888889
96181, 1.8304347826087, 1.375, 0.11111111111111
96182, 1.8521739130435, 1.3875, 0.11111111111111
96183, 1.8521739130435, 1.375, 0.083333333333333
96184, 1.8304347826087, 1.375, 0.055555555555556
96185, 1.8521739130435, 1.3875, 0.055555555555556
96186, 1.8521739130435, 1.375, 0.027777777777778
96187, 1.895652173913, 1.375, 0.47222222222222
96188, 1.8739130434783, 1.375, 0.44444444444444
96189, 1.895652173913, 1.3875, 0.44444444444444
96190, 1.895652173913, 1.375, 0.41666666666667
96191, 1.8739130434783, 1.375, 0.38888888888889
96192, 1.895652173913, 1.3875, 0.38888888888889
96193, 1.895652173913, 1.375, 0.36111111111111
96194, 1.8739130434783, 1.375, 0.33333333333333
96195, 1.895652173913, 1.3875, 0.33333333333333
96196, 1.895652173913, 1.375, 0.30555555555556
96197, 1.8739130434783, 1.375, 0.27777777777778
96198, 1.895652173913, 1.3875, 0.27777777777778
96199, 1.895652173913, 1.375, 0.25
96200, 1.8739130434783, 1.375, 0.22222222222222
96201, 1.895652173913, 1.3875, 0.22222222222222
96202, 1.895652173913, 1.375, 0.19444444444444
96203, 1.8739130434783, 1.375, 0.16666666666667
96204, 1.895652173913, 1.3875, 0.16666666666667
96205, 1.895652173913, 1.375, 0.13888888888889
96206, 1.8739130434783, 1.375, 0.11111111111111
96207, 1.895652173913, 1.3875, 0.11111111111111
96208, 1.895652173913, 1.375, 0.083333333333333
96209, 1.8739130434783, 1.375, 0.055555555555556
96210, 1.895652173913, 1.3875, 0.055555555555556
96211, 1.895652173913, 1.375, 0.027777777777778
96212, 1.9391304347826, 1.375, 0.47222222222222
96213, 1.9173913043478, 1.375, 0.44444444444444
96214, 1.9391304347826, 1.3875, 0.44444444444444
96215, 1.9391304347826, 1.375, 0.41666666666667
96216, 1.9173913043478, 1.375, 0.38888888888889
96217, 1.9391304347826, 1.3875, 0.38888888888889
96218, 1.9391304347826, 1.375, 0.36111111111111
96219, 1.9173913043478, 1.375, 0.33333333333333
96220, 1.9391304347826, 1.3875, 0.33333333333333
96221, 1.9391304347826, 1.375, 0.30555555555556
96222, 1.9173913043478, 1.375, 0.27777777777778
96223, 1.9391304347826, 1.3875, 0.27777777777778
96224, 1.9391304347826, 1.375, 0.25
96225, 1.9173913043478, 1.375, 0.22222222222222
96226, 1.9391304347826, 1.3875, 0.22222222222222
96227, 1.9391304347826, 1.375, 0.19444444444444
96228, 1.9173913043478, 1.375, 0.16666666666667
96229, 1.9391304347826, 1.3875, 0.16666666666667
96230, 1.9391304347826, 1.375, 0.13888888888889
96231, 1.9173913043478, 1.375, 0.11111111111111
96232, 1.9391304347826, 1.3875, 0.11111111111111
96233, 1.9391304347826, 1.375, 0.083333333333333
96234, 1.9173913043478, 1.375, 0.055555555555556
96235, 1.9391304347826, 1.3875, 0.055555555555556
96236, 1.9391304347826, 1.375, 0.027777777777778
96237, 1.9826086956522, 1.375, 0.47222222222222
96238, 1.9608695652174, 1.375, 0.44444444444444
96239, 1.9826086956522, 1.3875, 0.44444444444444
96240, 1.9826086956522, 1.375, 0.41666666666667
96241, 1.9608695652174, 1.375, 0.38888888888889
96242, 1.9826086956522, 1.3875, 0.38888888888889
96243, 1.9826086956522, 1.375, 0.36111111111111
96244, 1.9608695652174, 1.375, 0.33333333333333
96245, 1.9826086956522, 1.3875, 0.33333333333333
96246, 1.9826086956522, 1.375, 0.30555555555556
96247, 1.9608695652174, 1.375, 0.27777777777778
96248, 1.9826086956522, 1.3875, 0.27777777777778
96249, 1.9826086956522, 1.375, 0.25
96250, 1.9608695652174, 1.375, 0.22222222222222
96251, 1.9826086956522, 1.3875, 0.22222222222222
96252, 1.9826086956522, 1.375, 0.19444444444444
96253, 1.9608695652174, 1.375, 0.16666666666667
96254, 1.9826086956522, 1.3875, 0.16666666666667
96255, 1.9826086956522, 1.375, 0.13888888888889
96256, 1.9608695652174, 1.375, 0.11111111111111
96257, 1.9826086956522, 1.3875, 0.11111111111111
96258, 1.9826086956522, 1.375, 0.083333333333333
96259, 1.9608695652174, 1.375, 0.055555555555556
96260, 1.9826086956522, 1.3875, 0.055555555555556
96261, 1.9826086956522, 1.375, 0.027777777777778
96262, 2.0260869565217, 1.375, 0.47222222222222
96263, 2.004347826087, 1.375, 0.44444444444444
96264, 2.0260869565217, 1.3875, 0.44444444444444
96265, 2.0260869565217, 1.375, 0.41666666666667
96266, 2.004347826087, 1.375, 0.38888888888889
96267, 2.0260869565217, 1.3875, 0.38888888888889
96268, 2.0260869565217, 1.375, 0.36111111111111
96269, 2.004347826087, 1.375, 0.33333333333333
96270, 2.0260869565217, 1.3875, 0.33333333333333
96271, 2.0260869565217, 1.375, 0.30555555555556
96272, 2.004347826087, 1.375, 0.27777777777778
96273, 2.0260869565217, 1.3875, 0.27777777777778
96274, 2.0260869565217, 1.375, 0.25
96275, 2.004347826087, 1.375, 0.22222222222222
96276, 2.0260869565217, 1.3875, 0.22222222222222
96277, 2.0260869565217, 1.375, 0.19444444444444
96278, 2.004347826087, 1.375, 0.16666666666667
96279, 2.0260869565217, 1.3875, 0.16666666666667
96280, 2.0260869565217, 1.375, 0.13888888888889
96281, 2.004347826087, 1.375, 0.11111111111111
96282, 2.0260869565217, 1.3875, 0.11111111111111
96283, 2.0260869565217, 1.375, 0.083333333333333
96284, 2.004347826087, 1.375, 0.055555555555556
96285, 2.0260869565217, 1.3875, 0.055555555555556
96286, 2.0260869565217, 1.375, 0.027777777777778
96287, 2.0695652173913, 1.375, 0.47222222222222
96288, 2.0478260869565, 1.375, 0.44444444444444
96289, 2.0695652173913, 1.3875, 0.44444444444444
96290, 2.0695652173913, 1.375, 0.41666666666667
96291, 2.0478260869565, 1.375, 0.38888888888889
96292, 2.0695652173913, 1.3875, 0.38888888888889
96293, 2.0695652173913, 1.375, 0.36111111111111
96294, 2.0478260869565, 1.375, 0.33333333333333
96295, 2.0695652173913, 1.3875, 0.33333333333333
96296, 2.0695652173913, 1.375, 0.30555555555556
96297, 2.0478260869565, 1.375, 0.27777777777778
96298, 2.0695652173913, 1.3875, 0.27777777777778
96299, 2.0695652173913, 1.375, 0.25
96300, 2.0478260869565, 1.375, 0.22222222222222
96301, 2.0695652173913, 1.3875, 0.22222222222222
96302, 2.0695652173913, 1.375, 0.19444444444444
96303, 2.0478260869565, 1.375, 0.16666666666667
96304, 2.0695652173913, 1.3875, 0.16666666666667
96305, 2.0695652173913, 1.375, 0.13888888888889
96306, 2.0478260869565, 1.375, 0.11111111111111
96307, 2.0695652173913, 1.3875, 0.11111111111111
96308, 2.0695652173913, 1.375, 0.083333333333333
96309, 2.0478260869565, 1.375, 0.055555555555556
96310, 2.0695652173913, 1.3875, 0.055555555555556
96311, 2.0695652173913, 1.375, 0.027777777777778
96312, 2.1130434782609, 1.375, 0.47222222222222
96313, 2.0913043478261, 1.375, 0.44444444444444
96314, 2.1130434782609, 1.3875, 0.44444444444444
96315, 2.1130434782609, 1.375, 0.41666666666667
96316, 2.0913043478261, 1.375, 0.38888888888889
96317, 2.1130434782609, 1.3875, 0.38888888888889
96318, 2.1130434782609, 1.375, 0.36111111111111
96319, 2.0913043478261, 1.375, 0.33333333333333
96320, 2.1130434782609, 1.3875, 0.33333333333333
96321, 2.1130434782609, 1.375, 0.30555555555556
96322, 2.0913043478261, 1.375, 0.27777777777778
96323, 2.1130434782609, 1.3875, 0.27777777777778
96324, 2.1130434782609, 1.375, 0.25
96325, 2.0913043478261, 1.375, 0.22222222222222
96326, 2.1130434782609, 1.3875, 0.22222222222222
96327, 2.1130434782609, 1.375, 0.19444444444444
96328, 2.0913043478261, 1.375, 0.16666666666667
96329, 2.1130434782609, 1.3875, 0.16666666666667
96330, 2.1130434782609, 1.375, 0.13888888888889
96331, 2.0913043478261, 1.375, 0.11111111111111
96332, 2.1130434782609, 1.3875, 0.11111111111111
96333, 2.1130434782609, 1.375, 0.083333333333333
96334, 2.0913043478261, 1.375, 0.055555555555556
96335, 2.1130434782609, 1.3875, 0.055555555555556
96336, 2.1130434782609, 1.375, 0.027777777777778
96337, 2.1565217391304, 1.375, 0.47222222222222
96338, 2.1347826086957, 1.375, 0.44444444444444
96339, 2.1565217391304, 1.3875, 0.44444444444444
96340, 2.1565217391304, 1.375, 0.41666666666667
96341, 2.1347826086957, 1.375, 0.38888888888889
96342, 2.1565217391304, 1.3875, 0.38888888888889
96343, 2.1565217391304, 1.375, 0.36111111111111
96344, 2.1347826086957, 1.375, 0.33333333333333
96345, 2.1565217391304, 1.3875, 0.33333333333333
96346, 2.1565217391304, 1.375, 0.30555555555556
96347, 2.1347826086957, 1.375, 0.27777777777778
96348, 2.1565217391304, 1.3875, 0.27777777777778
96349, 2.1565217391304, 1.375, 0.25
96350, 2.1347826086957, 1.375, 0.22222222222222
96351, 2.1565217391304, 1.3875, 0.22222222222222
96352, 2.1565217391304, 1.375, 0.19444444444444
96353, 2.1347826086957, 1.375, 0.16666666666667
96354, 2.1565217391304, 1.3875, 0.16666666666667
96355, 2.1565217391304, 1.375, 0.13888888888889
96356, 2.1347826086957, 1.375, 0.11111111111111
96357, 2.1565217391304, 1.3875, 0.11111111111111
96358, 2.1565217391304, 1.375, 0.083333333333333
96359, 2.1347826086957, 1.375, 0.055555555555556
96360, 2.1565217391304, 1.3875, 0.055555555555556
96361, 2.1565217391304, 1.375, 0.027777777777778
96362, 2.1782608695652, 1.375, 0.44444444444444
96363, 2.1782608695652, 1.375, 0.38888888888889
96364, 2.1782608695652, 1.375, 0.33333333333333
96365, 2.1782608695652, 1.375, 0.27777777777778
96366, 2.1782608695652, 1.375, 0.22222222222222
96367, 2.1782608695652, 1.375, 0.16666666666667
96368, 2.1782608695652, 1.375, 0.11111111111111
96369, 2.1782608695652, 1.375, 0.055555555555556
96370, 1.2434782608696, 1.3625, 0.44444444444444
96371, 1.2434782608696, 1.3625, 0.38888888888889
96372, 1.2434782608696, 1.3625, 0.33333333333333
96373, 1.2434782608696, 1.3625, 0.27777777777778
96374, 1.2434782608696, 1.3625, 0.22222222222222
96375, 1.2434782608696, 1.3625, 0.16666666666667
96376, 1.2434782608696, 1.3625, 0.11111111111111
96377, 1.2434782608696, 1.3625, 0.055555555555556
96378, 1.2869565217391, 1.3625, 0.44444444444444
96379, 1.2869565217391, 1.3625, 0.38888888888889
96380, 1.2869565217391, 1.3625, 0.33333333333333
96381, 1.2869565217391, 1.3625, 0.27777777777778
96382, 1.2869565217391, 1.3625, 0.22222222222222
96383, 1.2869565217391, 1.3625, 0.16666666666667
96384, 1.2869565217391, 1.3625, 0.11111111111111
96385, 1.2869565217391, 1.3625, 0.055555555555556
96386, 1.3304347826087, 1.3625, 0.44444444444444
96387, 1.3304347826087, 1.3625, 0.38888888888889
96388, 1.3304347826087, 1.3625, 0.33333333333333
96389, 1.3304347826087, 1.3625, 0.27777777777778
96390, 1.3304347826087, 1.3625, 0.22222222222222
96391, 1.3304347826087, 1.3625, 0.16666666666667
96392, 1.3304347826087, 1.3625, 0.11111111111111
96393, 1.3304347826087, 1.3625, 0.055555555555556
96394, 1.3739130434783, 1.3625, 0.44444444444444
96395, 1.3739130434783, 1.3625, 0.38888888888889
96396, 1.3739130434783, 1.3625, 0.33333333333333
96397, 1.3739130434783, 1.3625, 0.27777777777778
96398, 1.3739130434783, 1.3625, 0.22222222222222
96399, 1.3739130434783, 1.3625, 0.16666666666667
96400, 1.3739130434783, 1.3625, 0.11111111111111
96401, 1.3739130434783, 1.3625, 0.055555555555556
96402, 1.4173913043478, 1.3625, 0.44444444444444
96403, 1.4173913043478, 1.3625, 0.38888888888889
96404, 1.4173913043478, 1.3625, 0.33333333333333
96405, 1.4173913043478, 1.3625, 0.27777777777778
96406, 1.4173913043478, 1.3625, 0.22222222222222
96407, 1.4173913043478, 1.3625, 0.16666666666667
96408, 1.4173913043478, 1.3625, 0.11111111111111
96409, 1.4173913043478, 1.3625, 0.055555555555556
96410, 1.4608695652174, 1.3625, 0.44444444444444
96411, 1.4608695652174, 1.3625, 0.38888888888889
96412, 1.4608695652174, 1.3625, 0.33333333333333
96413, 1.4608695652174, 1.3625, 0.27777777777778
96414, 1.4608695652174, 1.3625, 0.22222222222222
96415, 1.4608695652174, 1.3625, 0.16666666666667
96416, 1.4608695652174, 1.3625, 0.11111111111111
96417, 1.4608695652174, 1.3625, 0.055555555555556
96418, 1.504347826087, 1.3625, 0.44444444444444
96419, 1.504347826087, 1.3625, 0.38888888888889
96420, 1.504347826087, 1.3625, 0.33333333333333
96421, 1.504347826087, 1.3625, 0.27777777777778
96422, 1.504347826087, 1.3625, 0.22222222222222
96423, 1.504347826087, 1.3625, 0.16666666666667
96424, 1.504347826087, 1.3625, 0.11111111111111
96425, 1.504347826087, 1.3625, 0.055555555555556
96426, 1.5478260869565, 1.3625, 0.44444444444444
96427, 1.5478260869565, 1.3625, 0.38888888888889
96428, 1.5478260869565, 1.3625, 0.33333333333333
96429, 1.5478260869565, 1.3625, 0.27777777777778
96430, 1.5478260869565, 1.3625, 0.22222222222222
96431, 1.5478260869565, 1.3625, 0.16666666666667
96432, 1.5478260869565, 1.3625, 0.11111111111111
96433, 1.5478260869565, 1.3625, 0.055555555555556
96434, 1.5913043478261, 1.3625, 0.44444444444444
96435, 1.5913043478261, 1.3625, 0.38888888888889
96436, 1.5913043478261, 1.3625, 0.33333333333333
96437, 1.5913043478261, 1.3625, 0.27777777777778
96438, 1.5913043478261, 1.3625, 0.22222222222222
96439, 1.5913043478261, 1.3625, 0.16666666666667
96440, 1.5913043478261, 1.3625, 0.11111111111111
96441, 1.5913043478261, 1.3625, 0.055555555555556
96442, 1.6347826086957, 1.3625, 0.44444444444444
96443, 1.6347826086957, 1.3625, 0.38888888888889
96444, 1.6347826086957, 1.3625, 0.33333333333333
96445, 1.6347826086957, 1.3625, 0.27777777777778
96446, 1.6347826086957, 1.3625, 0.22222222222222
96447, 1.6347826086957, 1.3625, 0.16666666666667
96448, 1.6347826086957, 1.3625, 0.11111111111111
96449, 1.6347826086957, 1.3625, 0.055555555555556
96450, 1.6782608695652, 1.3625, 0.44444444444444
96451, 1.6782608695652, 1.3625, 0.38888888888889
96452, 1.6782608695652, 1.3625, 0.33333333333333
96453, 1.6782608695652, 1.3625, 0.27777777777778
96454, 1.6782608695652, 1.3625, 0.22222222222222
96455, 1.6782608695652, 1.3625, 0.16666666666667
96456, 1.6782608695652, 1.3625, 0.11111111111111
96457, 1.6782608695652, 1.3625, 0.055555555555556
96458, 1.7217391304348, 1.3625, 0.44444444444444
96459, 1.7217391304348, 1.3625, 0.38888888888889
96460, 1.7217391304348, 1.3625, 0.33333333333333
96461, 1.7217391304348, 1.3625, 0.27777777777778
96462, 1.7217391304348, 1.3625, 0.22222222222222
96463, 1.7217391304348, 1.3625, 0.16666666666667
96464, 1.7217391304348, 1.3625, 0.11111111111111
96465, 1.7217391304348, 1.3625, 0.055555555555556
96466, 1.7652173913043, 1.3625, 0.44444444444444
96467, 1.7652173913043, 1.3625, 0.38888888888889
96468, 1.7652173913043, 1.3625, 0.33333333333333
96469, 1.7652173913043, 1.3625, 0.27777777777778
96470, 1.7652173913043, 1.3625, 0.22222222222222
96471, 1.7652173913043, 1.3625, 0.16666666666667
96472, 1.7652173913043, 1.3625, 0.11111111111111
96473, 1.7652173913043, 1.3625, 0.055555555555556
96474, 1.8086956521739, 1.3625, 0.44444444444444
96475, 1.8086956521739, 1.3625, 0.38888888888889
96476, 1.8086956521739, 1.3625, 0.33333333333333
96477, 1.8086956521739, 1.3625, 0.27777777777778
96478, 1.8086956521739, 1.3625, 0.22222222222222
96479, 1.8086956521739, 1.3625, 0.16666666666667
96480, 1.8086956521739, 1.3625, 0.11111111111111
96481, 1.8086956521739, 1.3625, 0.055555555555556
96482, 1.8521739130435, 1.3625, 0.44444444444444
96483, 1.8521739130435, 1.3625, 0.38888888888889
96484, 1.8521739130435, 1.3625, 0.33333333333333
96485, 1.8521739130435, 1.3625, 0.27777777777778
96486, 1.8521739130435, 1.3625, 0.22222222222222
96487, 1.8521739130435, 1.3625, 0.16666666666667
96488, 1.8521739130435, 1.3625, 0.11111111111111
96489, 1.8521739130435, 1.3625, 0.055555555555556
96490, 1.895652173913, 1.3625, 0.44444444444444
96491, 1.895652173913, 1.3625, 0.38888888888889
96492, 1.895652173913, 1.3625, 0.33333333333333
96493, 1.895652173913, 1.3625, 0.27777777777778
96494, 1.895652173913, 1.3625, 0.22222222222222
96495, 1.895652173913, 1.3625, 0.16666666666667
96496, 1.895652173913, 1.3625, 0.11111111111111
96497, 1.895652173913, 1.3625, 0.055555555555556
96498, 1.9391304347826, 1.3625, 0.44444444444444
96499, 1.9391304347826, 1.3625, 0.38888888888889
96500, 1.9391304347826, 1.3625, 0.33333333333333
96501, 1.9391304347826, 1.3625, 0.27777777777778
96502, 1.9391304347826, 1.3625, 0.22222222222222
96503, 1.9391304347826, 1.3625, 0.16666666666667
96504, 1.9391304347826, 1.3625, 0.11111111111111
96505, 1.9391304347826, 1.3625, 0.055555555555556
96506, 1.9826086956522, 1.3625, 0.44444444444444
96507, 1.9826086956522, 1.3625, 0.38888888888889
96508, 1.9826086956522, 1.3625, 0.33333333333333
96509, 1.9826086956522, 1.3625, 0.27777777777778
96510, 1.9826086956522, 1.3625, 0.22222222222222
96511, 1.9826086956522, 1.3625, 0.16666666666667
96512, 1.9826086956522, 1.3625, 0.11111111111111
96513, 1.9826086956522, 1.3625, 0.055555555555556
96514, 2.0260869565217, 1.3625, 0.44444444444444
96515, 2.0260869565217, 1.3625, 0.38888888888889
96516, 2.0260869565217, 1.3625, 0.33333333333333
96517, 2.0260869565217, 1.3625, 0.27777777777778
96518, 2.0260869565217, 1.3625, 0.22222222222222
96519, 2.0260869565217, 1.3625, 0.16666666666667
96520, 2.0260869565217, 1.3625, 0.11111111111111
96521, 2.0260869565217, 1.3625, 0.055555555555556
96522, 2.0695652173913, 1.3625, 0.44444444444444
96523, 2.0695652173913, 1.3625, 0.38888888888889
96524, 2.0695652173913, 1.3625, 0.33333333333333
96525, 2.0695652173913, 1.3625, 0.27777777777778
96526, 2.0695652173913, 1.3625, 0.22222222222222
96527, 2.0695652173913, 1.3625, 0.16666666666667
96528, 2.0695652173913, 1.3625, 0.11111111111111
96529, 2.0695652173913, 1.3625, 0.055555555555556
96530, 2.1130434782609, 1.3625, 0.44444444444444
96531, 2.1130434782609, 1.3625, 0.38888888888889
96532, 2.1130434782609, 1.3625, 0.33333333333333
96533, 2.1130434782609, 1.3625, 0.27777777777778
96534, 2.1130434782609, 1.3625, 0.22222222222222
96535, 2.1130434782609, 1.3625, 0.16666666666667
96536, 2.1130434782609, 1.3625, 0.11111111111111
96537, 2.1130434782609, 1.3625, 0.055555555555556
96538, 2.1565217391304, 1.3625, 0.44444444444444
96539, 2.1565217391304, 1.3625, 0.38888888888889
96540, 2.1565217391304, 1.3625, 0.33333333333333
96541, 2.1565217391304, 1.3625, 0.27777777777778
96542, 2.1565217391304, 1.3625, 0.22222222222222
96543, 2.1565217391304, 1.3625, 0.16666666666667
96544, 2.1565217391304, 1.3625, 0.11111111111111
96545, 2.1565217391304, 1.3625, 0.055555555555556
96546, 0.95652173913044, 0.20217391304348, -0.0375
96547, 0.91304347826087, 0.20217391304348, -0.0375
96548, 0.8695652173913, 0.20217391304348, -0.0375
96549, 0.82608695652174, 0.20217391304348, -0.0375
96550, 0.78260869565217, 0.20217391304348, -0.0375
96551, 0.73913043478261, 0.20217391304348, -0.0375
96552, 0.69565217391304, 0.20217391304348, -0.0375
96553, 0.65217391304348, 0.20217391304348, -0.0375
96554, 0.60869565217391, 0.20217391304348, -0.0375
96555, 0.56521739130435, 0.20217391304348, -0.0375
96556, 0.52173913043478, 0.20217391304348, -0.0375
96557, 0.47826086956522, 0.20217391304348, -0.0375
96558, 0.43478260869565, 0.20217391304348, -0.0375
96559, 0.39130434782609, 0.20217391304348, -0.0375
96560, 0.34782608695652, 0.20217391304348, -0.0375
96561, 0.30434782608696, 0.20217391304348, -0.0375
96562, 0.26086956521739, 0.20217391304348, -0.0375
96563, 0.21739130434783, 0.20217391304348, -0.0375
96564, 0.17391304347826, 0.20217391304348, -0.0375
96565, 0.1304347826087, 0.20217391304348, -0.0375
96566, 0.08695652173913, 0.20217391304348, -0.0375
96567, 0.043478260869565, 0.20217391304348, -0.0375
96568, 0.95652173913043, 0.25434782608696, -0.0375
96569, 0.91304347826087, 0.25434782608696, -0.0375
96570, 0.8695652173913, 0.25434782608696, -0.0375
96571, 0.82608695652174, 0.25434782608696, -0.0375
96572, 0.78260869565217, 0.25434782608696, -0.0375
96573, 0.73913043478261, 0.25434782608696, -0.0375
96574, 0.69565217391304, 0.25434782608696, -0.0375
96575, 0.65217391304348, 0.25434782608696, -0.0375
96576, 0.60869565217391, 0.25434782608696, -0.0375
96577, 0.56521739130435, 0.25434782608696, -0.0375
96578, 0.52173913043478, 0.25434782608696, -0.0375
96579, 0.47826086956522, 0.25434782608696, -0.0375
96580, 0.43478260869565, 0.25434782608696, -0.0375
96581, 0.39130434782609, 0.25434782608696, -0.0375
96582, 0.34782608695652, 0.25434782608696, -0.0375
96583, 0.30434782608696, 0.25434782608696, -0.0375
96584, 0.26086956521739, 0.25434782608696, -0.0375
96585, 0.21739130434783, 0.25434782608696, -0.0375
96586, 0.17391304347826, 0.25434782608696, -0.0375
96587, 0.1304347826087, 0.25434782608696, -0.0375
96588, 0.08695652173913, 0.25434782608696, -0.0375
96589, 0.043478260869565, 0.25434782608696, -0.0375
96590, 0.95652173913044, 0.30652173913043, -0.0375
96591, 0.91304347826087, 0.30652173913043, -0.0375
96592, 0.8695652173913, 0.30652173913043, -0.0375
96593, 0.82608695652174, 0.30652173913043, -0.0375
96594, 0.78260869565217, 0.30652173913043, -0.0375
96595, 0.73913043478261, 0.30652173913043, -0.0375
96596, 0.69565217391304, 0.30652173913043, -0.0375
96597, 0.65217391304348, 0.30652173913043, -0.0375
96598, 0.60869565217391, 0.30652173913043, -0.0375
96599, 0.56521739130435, 0.30652173913043, -0.0375
96600, 0.52173913043478, 0.30652173913043, -0.0375
96601, 0.47826086956522, 0.30652173913043, -0.0375
96602, 0.43478260869565, 0.30652173913043, -0.0375
96603, 0.39130434782609, 0.30652173913043, -0.0375
96604, 0.34782608695652, 0.30652173913043, -0.0375
96605, 0.30434782608696, 0.30652173913043, -0.0375
96606, 0.26086956521739, 0.30652173913043, -0.0375
96607, 0.21739130434783, 0.30652173913043, -0.0375
96608, 0.17391304347826, 0.30652173913043, -0.0375
96609, 0.1304347826087, 0.30652173913043, -0.0375
96610, 0.08695652173913, 0.30652173913043, -0.0375
96611, 0.043478260869565, 0.30652173913043, -0.0375
96612, 0.95652173913043, 0.35869565217391, -0.0375
96613, 0.91304347826087, 0.35869565217391, -0.0375
96614, 0.8695652173913, 0.35869565217391, -0.0375
96615, 0.82608695652174, 0.35869565217391, -0.0375
96616, 0.78260869565217, 0.35869565217391, -0.0375
96617, 0.73913043478261, 0.35869565217391, -0.0375
96618, 0.69565217391304, 0.35869565217391, -0.0375
96619, 0.65217391304348, 0.35869565217391, -0.0375
96620, 0.60869565217391, 0.35869565217391, -0.0375
96621, 0.56521739130435, 0.35869565217391, -0.0375
96622, 0.52173913043478, 0.35869565217391, -0.0375
96623, 0.47826086956522, 0.35869565217391, -0.0375
96624, 0.43478260869565, 0.35869565217391, -0.0375
96625, 0.39130434782609, 0.35869565217391, -0.0375
96626, 0.34782608695652, 0.35869565217391, -0.0375
96627, 0.30434782608696, 0.35869565217391, -0.0375
96628, 0.26086956521739, 0.35869565217391, -0.0375
96629, 0.21739130434783, 0.35869565217391, -0.0375
96630, 0.17391304347826, 0.35869565217391, -0.0375
96631, 0.1304347826087, 0.35869565217391, -0.0375
96632, 0.08695652173913, 0.35869565217391, -0.0375
96633, 0.043478260869565, 0.35869565217391, -0.0375
96634, 0.95652173913043, 0.41086956521739, -0.0375
96635, 0.91304347826087, 0.41086956521739, -0.0375
96636, 0.8695652173913, 0.41086956521739, -0.0375
96637, 0.82608695652174, 0.41086956521739, -0.0375
96638, 0.78260869565217, 0.41086956521739, -0.0375
96639, 0.73913043478261, 0.41086956521739, -0.0375
96640, 0.69565217391304, 0.41086956521739, -0.0375
96641, 0.65217391304348, 0.41086956521739, -0.0375
96642, 0.60869565217391, 0.41086956521739, -0.0375
96643, 0.56521739130435, 0.41086956521739, -0.0375
96644, 0.52173913043478, 0.41086956521739, -0.0375
96645, 0.47826086956522, 0.41086956521739, -0.0375
96646, 0.43478260869565, 0.41086956521739, -0.0375
96647, 0.39130434782609, 0.41086956521739, -0.0375
96648, 0.34782608695652, 0.41086956521739, -0.0375
96649, 0.30434782608696, 0.41086956521739, -0.0375
96650, 0.26086956521739, 0.41086956521739, -0.0375
96651, 0.21739130434783, 0.41086956521739, -0.0375
96652, 0.17391304347826, 0.41086956521739, -0.0375
96653, 0.1304347826087, 0.41086956521739, -0.0375
96654, 0.08695652173913, 0.41086956521739, -0.0375
96655, 0.043478260869565, 0.41086956521739, -0.0375
96656, 0.95652173913043, 0.46304347826087, -0.0375
96657, 0.91304347826087, 0.46304347826087, -0.0375
96658, 0.8695652173913, 0.46304347826087, -0.0375
96659, 0.82608695652174, 0.46304347826087, -0.0375
96660, 0.78260869565217, 0.46304347826087, -0.0375
96661, 0.73913043478261, 0.46304347826087, -0.0375
96662, 0.69565217391304, 0.46304347826087, -0.0375
96663, 0.65217391304348, 0.46304347826087, -0.0375
96664, 0.60869565217391, 0.46304347826087, -0.0375
96665, 0.56521739130435, 0.46304347826087, -0.0375
96666, 0.52173913043478, 0.46304347826087, -0.0375
96667, 0.47826086956522, 0.46304347826087, -0.0375
96668, 0.43478260869565, 0.46304347826087, -0.0375
96669, 0.39130434782609, 0.46304347826087, -0.0375
96670, 0.34782608695652, 0.46304347826087, -0.0375
96671, 0.30434782608696, 0.46304347826087, -0.0375
96672, 0.26086956521739, 0.46304347826087, -0.0375
96673, 0.21739130434783, 0.46304347826087, -0.0375
96674, 0.17391304347826, 0.46304347826087, -0.0375
96675, 0.1304347826087, 0.46304347826087, -0.0375
96676, 0.08695652173913, 0.46304347826087, -0.0375
96677, 0.043478260869565, 0.46304347826087, -0.0375
96678, 0.95652173913044, 0.51521739130435, -0.0375
96679, 0.91304347826087, 0.51521739130435, -0.0375
96680, 0.8695652173913, 0.51521739130435, -0.0375
96681, 0.82608695652174, 0.51521739130435, -0.0375
96682, 0.78260869565217, 0.51521739130435, -0.0375
96683, 0.73913043478261, 0.51521739130435, -0.0375
96684, 0.69565217391304, 0.51521739130435, -0.0375
96685, 0.65217391304348, 0.51521739130435, -0.0375
96686, 0.60869565217391, 0.51521739130435, -0.0375
96687, 0.56521739130435, 0.51521739130435, -0.0375
96688, 0.52173913043478, 0.51521739130435, -0.0375
96689, 0.47826086956522, 0.51521739130435, -0.0375
96690, 0.43478260869565, 0.51521739130435, -0.0375
96691, 0.39130434782609, 0.51521739130435, -0.0375
96692, 0.34782608695652, 0.51521739130435, -0.0375
96693, 0.30434782608696, 0.51521739130435, -0.0375
96694, 0.26086956521739, 0.51521739130435, -0.0375
96695, 0.21739130434783, 0.51521739130435, -0.0375
96696, 0.17391304347826, 0.51521739130435, -0.0375
96697, 0.1304347826087, 0.51521739130435, -0.0375
96698, 0.08695652173913, 0.51521739130435, -0.0375
96699, 0.043478260869565, 0.51521739130435, -0.0375
96700, 0.95652173913044, 0.56739130434783, -0.0375
96701, 0.91304347826087, 0.56739130434783, -0.0375
96702, 0.8695652173913, 0.56739130434783, -0.0375
96703, 0.82608695652174, 0.56739130434783, -0.0375
96704, 0.78260869565217, 0.56739130434783, -0.0375
96705, 0.73913043478261, 0.56739130434783, -0.0375
96706, 0.69565217391304, 0.56739130434783, -0.0375
96707, 0.65217391304348, 0.56739130434783, -0.0375
96708, 0.60869565217391, 0.56739130434783, -0.0375
96709, 0.56521739130435, 0.56739130434783, -0.0375
96710, 0.52173913043478, 0.56739130434783, -0.0375
96711, 0.47826086956522, 0.56739130434783, -0.0375
96712, 0.43478260869565, 0.56739130434783, -0.0375
96713, 0.39130434782609, 0.56739130434783, -0.0375
96714, 0.34782608695652, 0.56739130434783, -0.0375
96715, 0.30434782608696, 0.56739130434783, -0.0375
96716, 0.26086956521739, 0.56739130434783, -0.0375
96717, 0.21739130434783, 0.56739130434783, -0.0375
96718, 0.17391304347826, 0.56739130434783, -0.0375
96719, 0.1304347826087, 0.56739130434783, -0.0375
96720, 0.08695652173913, 0.56739130434783, -0.0375
96721, 0.043478260869565, 0.56739130434783, -0.0375
96722, 0.95652173913044, 0.6195652173913, -0.0375
96723, 0.91304347826087, 0.6195652173913, -0.0375
96724, 0.8695652173913, 0.6195652173913, -0.0375
96725, 0.82608695652174, 0.6195652173913, -0.0375
96726, 0.78260869565217, 0.6195652173913, -0.0375
96727, 0.73913043478261, 0.6195652173913, -0.0375
96728, 0.69565217391304, 0.6195652173913, -0.0375
96729, 0.65217391304348, 0.6195652173913, -0.0375
96730, 0.60869565217391, 0.6195652173913, -0.0375
96731, 0.56521739130435, 0.6195652173913, -0.0375
96732, 0.52173913043478, 0.6195652173913, -0.0375
96733, 0.47826086956522, 0.6195652173913, -0.0375
96734, 0.43478260869565, 0.6195652173913, -0.0375
96735, 0.39130434782609, 0.6195652173913, -0.0375
96736, 0.34782608695652, 0.6195652173913, -0.0375
96737, 0.30434782608696, 0.6195652173913, -0.0375
96738, 0.26086956521739, 0.6195652173913, -0.0375
96739, 0.21739130434783, 0.6195652173913, -0.0375
96740, 0.17391304347826, 0.6195652173913, -0.0375
96741, 0.1304347826087, 0.6195652173913, -0.0375
96742, 0.08695652173913, 0.6195652173913, -0.0375
96743, 0.043478260869565, 0.6195652173913, -0.0375
96744, 0.95652173913044, 0.67173913043478, -0.0375
96745, 0.91304347826087, 0.67173913043478, -0.0375
96746, 0.8695652173913, 0.67173913043478, -0.0375
96747, 0.82608695652174, 0.67173913043478, -0.0375
96748, 0.78260869565217, 0.67173913043478, -0.0375
96749, 0.73913043478261, 0.67173913043478, -0.0375
96750, 0.69565217391304, 0.67173913043478, -0.0375
96751, 0.65217391304348, 0.67173913043478, -0.0375
96752, 0.60869565217391, 0.67173913043478, -0.0375
96753, 0.56521739130435, 0.67173913043478, -0.0375
96754, 0.52173913043478, 0.67173913043478, -0.0375
96755, 0.47826086956522, 0.67173913043478, -0.0375
96756, 0.43478260869565, 0.67173913043478, -0.0375
96757, 0.39130434782609, 0.67173913043478, -0.0375
96758, 0.34782608695652, 0.67173913043478, -0.0375
96759, 0.30434782608696, 0.67173913043478, -0.0375
96760, 0.26086956521739, 0.67173913043478, -0.0375
96761, 0.21739130434783, 0.67173913043478, -0.0375
96762, 0.17391304347826, 0.67173913043478, -0.0375
96763, 0.1304347826087, 0.67173913043478, -0.0375
96764, 0.08695652173913, 0.67173913043478, -0.0375
96765, 0.043478260869565, 0.67173913043478, -0.0375
96766, 0.95652173913044, 0.72391304347826, -0.0375
96767, 0.91304347826087, 0.72391304347826, -0.0375
96768, 0.8695652173913, 0.72391304347826, -0.0375
96769, 0.82608695652174, 0.72391304347826, -0.0375
96770, 0.78260869565217, 0.72391304347826, -0.0375
96771, 0.73913043478261, 0.72391304347826, -0.0375
96772, 0.69565217391304, 0.72391304347826, -0.0375
96773, 0.65217391304348, 0.72391304347826, -0.0375
96774, 0.60869565217391, 0.72391304347826, -0.0375
96775, 0.56521739130435, 0.72391304347826, -0.0375
96776, 0.52173913043478, 0.72391304347826, -0.0375
96777, 0.47826086956522, 0.72391304347826, -0.0375
96778, 0.43478260869565, 0.72391304347826, -0.0375
96779, 0.39130434782609, 0.72391304347826, -0.0375
96780, 0.34782608695652, 0.72391304347826, -0.0375
96781, 0.30434782608696, 0.72391304347826, -0.0375
96782, 0.26086956521739, 0.72391304347826, -0.0375
96783, 0.21739130434783, 0.72391304347826, -0.0375
96784, 0.17391304347826, 0.72391304347826, -0.0375
96785, 0.1304347826087, 0.72391304347826, -0.0375
96786, 0.08695652173913, 0.72391304347826, -0.0375
96787, 0.043478260869565, 0.72391304347826, -0.0375
96788, 0.95652173913044, 0.77608695652174, -0.0375
96789, 0.91304347826087, 0.77608695652174, -0.0375
96790, 0.8695652173913, 0.77608695652174, -0.0375
96791, 0.82608695652174, 0.77608695652174, -0.0375
96792, 0.78260869565217, 0.77608695652174, -0.0375
96793, 0.73913043478261, 0.77608695652174, -0.0375
96794, 0.69565217391304, 0.77608695652174, -0.0375
96795, 0.65217391304348, 0.77608695652174, -0.0375
96796, 0.60869565217391, 0.77608695652174, -0.0375
96797, 0.56521739130435, 0.77608695652174, -0.0375
96798, 0.52173913043478, 0.77608695652174, -0.0375
96799, 0.47826086956522, 0.77608695652174, -0.0375
96800, 0.43478260869565, 0.77608695652174, -0.0375
96801, 0.39130434782609, 0.77608695652174, -0.0375
96802, 0.34782608695652, 0.77608695652174, -0.0375
96803, 0.30434782608696, 0.77608695652174, -0.0375
96804, 0.26086956521739, 0.77608695652174, -0.0375
96805, 0.21739130434783, 0.77608695652174, -0.0375
96806, 0.17391304347826, 0.77608695652174, -0.0375
96807, 0.1304347826087, 0.77608695652174, -0.0375
96808, 0.08695652173913, 0.77608695652174, -0.0375
96809, 0.043478260869565, 0.77608695652174, -0.0375
96810, 0.95652173913044, 0.82826086956522, -0.0375
96811, 0.91304347826087, 0.82826086956522, -0.0375
96812, 0.8695652173913, 0.82826086956522, -0.0375
96813, 0.82608695652174, 0.82826086956522, -0.0375
96814, 0.78260869565217, 0.82826086956522, -0.0375
96815, 0.73913043478261, 0.82826086956522, -0.0375
96816, 0.69565217391304, 0.82826086956522, -0.0375
96817, 0.65217391304348, 0.82826086956522, -0.0375
96818, 0.60869565217391, 0.82826086956522, -0.0375
96819, 0.56521739130435, 0.82826086956522, -0.0375
96820, 0.52173913043478, 0.82826086956522, -0.0375
96821, 0.47826086956522, 0.82826086956522, -0.0375
96822, 0.43478260869565, 0.82826086956522, -0.0375
96823, 0.39130434782609, 0.82826086956522, -0.0375
96824, 0.34782608695652, 0.82826086956522, -0.0375
96825, 0.30434782608696, 0.82826086956522, -0.0375
96826, 0.26086956521739, 0.82826086956522, -0.0375
96827, 0.21739130434783, 0.82826086956522, -0.0375
96828, 0.17391304347826, 0.82826086956522, -0.0375
96829, 0.1304347826087, 0.82826086956522, -0.0375
96830, 0.08695652173913, 0.82826086956522, -0.0375
96831, 0.043478260869565, 0.82826086956522, -0.0375
96832, 0.95652173913043, 0.88043478260869, -0.0375
96833, 0.91304347826087, 0.8804347826087, -0.0375
96834, 0.8695652173913, 0.8804347826087, -0.0375
96835, 0.82608695652174, 0.8804347826087, -0.0375
96836, 0.78260869565217, 0.8804347826087, -0.0375
96837, 0.73913043478261, 0.88043478260869, -0.0375
96838, 0.69565217391304, 0.8804347826087, -0.0375
96839, 0.65217391304348, 0.8804347826087, -0.0375
96840, 0.60869565217391, 0.8804347826087, -0.0375
96841, 0.56521739130435, 0.88043478260869, -0.0375
96842, 0.52173913043478, 0.8804347826087, -0.0375
96843, 0.47826086956522, 0.88043478260869, -0.0375
96844, 0.43478260869565, 0.8804347826087, -0.0375
96845, 0.39130434782609, 0.8804347826087, -0.0375
96846, 0.34782608695652, 0.8804347826087, -0.0375
96847, 0.30434782608696, 0.88043478260869, -0.0375
96848, 0.26086956521739, 0.8804347826087, -0.0375
96849, 0.21739130434783, 0.8804347826087, -0.0375
96850, 0.17391304347826, 0.8804347826087, -0.0375
96851, 0.1304347826087, 0.8804347826087, -0.0375
96852, 0.08695652173913, 0.8804347826087, -0.0375
96853, 0.043478260869565, 0.8804347826087, -0.0375
96854, 0.95652173913043, 0.93260869565217, -0.0375
96855, 0.91304347826087, 0.93260869565217, -0.0375
96856, 0.8695652173913, 0.93260869565217, -0.0375
96857, 0.82608695652174, 0.93260869565217, -0.0375
96858, 0.78260869565217, 0.93260869565217, -0.0375
96859, 0.73913043478261, 0.93260869565217, -0.0375
96860, 0.69565217391304, 0.93260869565217, -0.0375
96861, 0.65217391304348, 0.93260869565217, -0.0375
96862, 0.60869565217391, 0.93260869565217, -0.0375
96863, 0.56521739130435, 0.93260869565217, -0.0375
96864, 0.52173913043478, 0.93260869565217, -0.0375
96865, 0.47826086956522, 0.93260869565217, -0.0375
96866, 0.43478260869565, 0.93260869565217, -0.0375
96867, 0.39130434782609, 0.93260869565217, -0.0375
96868, 0.34782608695652, 0.93260869565217, -0.0375
96869, 0.30434782608696, 0.93260869565217, -0.0375
96870, 0.26086956521739, 0.93260869565217, -0.0375
96871, 0.21739130434783, 0.93260869565217, -0.0375
96872, 0.17391304347826, 0.93260869565217, -0.0375
96873, 0.1304347826087, 0.93260869565217, -0.0375
96874, 0.08695652173913, 0.93260869565217, -0.0375
96875, 0.043478260869565, 0.93260869565217, -0.0375
96876, 0.95652173913044, 0.98478260869565, -0.0375
96877, 0.91304347826087, 0.98478260869565, -0.0375
96878, 0.8695652173913, 0.98478260869565, -0.0375
96879, 0.82608695652174, 0.98478260869565, -0.0375
96880, 0.78260869565217, 0.98478260869565, -0.0375
96881, 0.73913043478261, 0.98478260869565, -0.0375
96882, 0.69565217391304, 0.98478260869565, -0.0375
96883, 0.65217391304348, 0.98478260869565, -0.0375
96884, 0.60869565217391, 0.98478260869565, -0.0375
96885, 0.56521739130435, 0.98478260869565, -0.0375
96886, 0.52173913043478, 0.98478260869565, -0.0375
96887, 0.47826086956522, 0.98478260869565, -0.0375
96888, 0.43478260869565, 0.98478260869565, -0.0375
96889, 0.39130434782609, 0.98478260869565, -0.0375
96890, 0.34782608695652, 0.98478260869565, -0.0375
96891, 0.30434782608696, 0.98478260869565, -0.0375
96892, 0.26086956521739, 0.98478260869565, -0.0375
96893, 0.21739130434783, 0.98478260869565, -0.0375
96894, 0.17391304347826, 0.98478260869565, -0.0375
96895, 0.1304347826087, 0.98478260869565, -0.0375
96896, 0.08695652173913, 0.98478260869565, -0.0375
96897, 0.043478260869565, 0.98478260869565, -0.0375
96898, 0.95652173913043, 1.0369565217391, -0.0375
96899, 0.91304347826087, 1.0369565217391, -0.0375
96900, 0.8695652173913, 1.0369565217391, -0.0375
96901, 0.82608695652174, 1.0369565217391, -0.0375
96902, 0.78260869565217, 1.0369565217391, -0.0375
96903, 0.73913043478261, 1.0369565217391, -0.0375
96904, 0.69565217391304, 1.0369565217391, -0.0375
96905, 0.65217391304348, 1.0369565217391, -0.0375
96906, 0.60869565217391, 1.0369565217391, -0.0375
96907, 0.56521739130435, 1.0369565217391, -0.0375
96908, 0.52173913043478, 1.0369565217391, -0.0375
96909, 0.47826086956522, 1.0369565217391, -0.0375
96910, 0.43478260869565, 1.0369565217391, -0.0375
96911, 0.39130434782609, 1.0369565217391, -0.0375
96912, 0.34782608695652, 1.0369565217391, -0.0375
96913, 0.30434782608696, 1.0369565217391, -0.0375
96914, 0.26086956521739, 1.0369565217391, -0.0375
96915, 0.21739130434783, 1.0369565217391, -0.0375
96916, 0.17391304347826, 1.0369565217391, -0.0375
96917, 0.1304347826087, 1.0369565217391, -0.0375
96918, 0.08695652173913, 1.0369565217391, -0.0375
96919, 0.043478260869565, 1.0369565217391, -0.0375
96920, 0.95652173913044, 1.0891304347826, -0.0375
96921, 0.91304347826087, 1.0891304347826, -0.0375
96922, 0.8695652173913, 1.0891304347826, -0.0375
96923, 0.82608695652174, 1.0891304347826, -0.0375
96924, 0.78260869565217, 1.0891304347826, -0.0375
96925, 0.73913043478261, 1.0891304347826, -0.0375
96926, 0.69565217391304, 1.0891304347826, -0.0375
96927, 0.65217391304348, 1.0891304347826, -0.0375
96928, 0.60869565217391, 1.0891304347826, -0.0375
96929, 0.56521739130435, 1.0891304347826, -0.0375
96930, 0.52173913043478, 1.0891304347826, -0.0375
96931, 0.47826086956522, 1.0891304347826, -0.0375
96932, 0.43478260869565, 1.0891304347826, -0.0375
96933, 0.39130434782609, 1.0891304347826, -0.0375
96934, 0.34782608695652, 1.0891304347826, -0.0375
96935, 0.30434782608696, 1.0891304347826, -0.0375
96936, 0.26086956521739, 1.0891304347826, -0.0375
96937, 0.21739130434783, 1.0891304347826, -0.0375
96938, 0.17391304347826, 1.0891304347826, -0.0375
96939, 0.1304347826087, 1.0891304347826, -0.0375
96940, 0.08695652173913, 1.0891304347826, -0.0375
96941, 0.043478260869565, 1.0891304347826, -0.0375
96942, 0.95652173913044, 1.1413043478261, -0.0375
96943, 0.91304347826087, 1.1413043478261, -0.0375
96944, 0.8695652173913, 1.1413043478261, -0.0375
96945, 0.82608695652174, 1.1413043478261, -0.0375
96946, 0.78260869565217, 1.1413043478261, -0.0375
96947, 0.73913043478261, 1.1413043478261, -0.0375
96948, 0.69565217391304, 1.1413043478261, -0.0375
96949, 0.65217391304348, 1.1413043478261, -0.0375
96950, 0.60869565217391, 1.1413043478261, -0.0375
96951, 0.56521739130435, 1.1413043478261, -0.0375
96952, 0.52173913043478, 1.1413043478261, -0.0375
96953, 0.47826086956522, 1.1413043478261, -0.0375
96954, 0.43478260869565, 1.1413043478261, -0.0375
96955, 0.39130434782609, 1.1413043478261, -0.0375
96956, 0.34782608695652, 1.1413043478261, -0.0375
96957, 0.30434782608696, 1.1413043478261, -0.0375
96958, 0.26086956521739, 1.1413043478261, -0.0375
96959, 0.21739130434783, 1.1413043478261, -0.0375
96960, 0.17391304347826, 1.1413043478261, -0.0375
96961, 0.1304347826087, 1.1413043478261, -0.0375
96962, 0.08695652173913, 1.1413043478261, -0.0375
96963, 0.043478260869565, 1.1413043478261, -0.0375
96964, 0.95652173913044, 1.1934782608696, -0.0375
96965, 0.91304347826087, 1.1934782608696, -0.0375
96966, 0.8695652173913, 1.1934782608696, -0.0375
96967, 0.82608695652174, 1.1934782608696, -0.0375
96968, 0.78260869565217, 1.1934782608696, -0.0375
96969, 0.73913043478261, 1.1934782608696, -0.0375
96970, 0.69565217391304, 1.1934782608696, -0.0375
96971, 0.65217391304348, 1.1934782608696, -0.0375
96972, 0.60869565217391, 1.1934782608696, -0.0375
96973, 0.56521739130435, 1.1934782608696, -0.0375
96974, 0.52173913043478, 1.1934782608696, -0.0375
96975, 0.47826086956522, 1.1934782608696, -0.0375
96976, 0.43478260869565, 1.1934782608696, -0.0375
96977, 0.39130434782609, 1.1934782608696, -0.0375
96978, 0.34782608695652, 1.1934782608696, -0.0375
96979, 0.30434782608696, 1.1934782608696, -0.0375
96980, 0.26086956521739, 1.1934782608696, -0.0375
96981, 0.21739130434783, 1.1934782608696, -0.0375
96982, 0.17391304347826, 1.1934782608696, -0.0375
96983, 0.1304347826087, 1.1934782608696, -0.0375
96984, 0.08695652173913, 1.1934782608696, -0.0375
96985, 0.043478260869565, 1.1934782608696, -0.0375
96986, 0.95652173913043, 1.245652173913, -0.0375
96987, 0.91304347826087, 1.245652173913, -0.0375
96988, 0.8695652173913, 1.245652173913, -0.0375
96989, 0.82608695652174, 1.245652173913, -0.0375
96990, 0.78260869565217, 1.245652173913, -0.0375
96991, 0.73913043478261, 1.245652173913, -0.0375
96992, 0.69565217391304, 1.245652173913, -0.0375
96993, 0.65217391304348, 1.245652173913, -0.0375
96994, 0.60869565217391, 1.245652173913, -0.0375
96995, 0.56521739130435, 1.245652173913, -0.0375
96996, 0.52173913043478, 1.245652173913, -0.0375
96997, 0.47826086956522, 1.245652173913, -0.0375
96998, 0.43478260869565, 1.245652173913, -0.0375
96999, 0.39130434782609, 1.245652173913, -0.0375
97000, 0.34782608695652, 1.245652173913, -0.0375
97001, 0.30434782608696, 1.245652173913, -0.0375
97002, 0.26086956521739, 1.245652173913, -0.0375
97003, 0.21739130434783, 1.245652173913, -0.0375
97004, 0.17391304347826, 1.245652173913, -0.0375
97005, 0.1304347826087, 1.245652173913, -0.0375
97006, 0.08695652173913, 1.245652173913, -0.0375
97007, 0.043478260869565, 1.245652173913, -0.0375
97008, 0.95652173913044, 1.2978260869565, -0.0375
97009, 0.91304347826087, 1.2978260869565, -0.0375
97010, 0.8695652173913, 1.2978260869565, -0.0375
97011, 0.82608695652174, 1.2978260869565, -0.0375
97012, 0.78260869565217, 1.2978260869565, -0.0375
97013, 0.73913043478261, 1.2978260869565, -0.0375
97014, 0.69565217391304, 1.2978260869565, -0.0375
97015, 0.65217391304348, 1.2978260869565, -0.0375
97016, 0.60869565217391, 1.2978260869565, -0.0375
97017, 0.56521739130435, 1.2978260869565, -0.0375
97018, 0.52173913043478, 1.2978260869565, -0.0375
97019, 0.47826086956522, 1.2978260869565, -0.0375
97020, 0.43478260869565, 1.2978260869565, -0.0375
97021, 0.39130434782609, 1.2978260869565, -0.0375
97022, 0.34782608695652, 1.2978260869565, -0.0375
97023, 0.30434782608696, 1.2978260869565, -0.0375
97024, 0.26086956521739, 1.2978260869565, -0.0375
97025, 0.21739130434783, 1.2978260869565, -0.0375
97026, 0.17391304347826, 1.2978260869565, -0.0375
97027, 0.1304347826087, 1.2978260869565, -0.0375
97028, 0.08695652173913, 1.2978260869565, -0.0375
97029, 0.043478260869565, 1.2978260869565, -0.0375
97030, 0.97826086956522, 0.20217391304348, -0.0375
97031, 0.95652173913043, 0.17608695652174, -0.0375
97032, 0.95652173913043, 0.20217391304348, -0.01875
97033, 0.93478260869565, 0.20217391304348, -0.0375
97034, 0.91304347826087, 0.17608695652174, -0.0375
97035, 0.91304347826087, 0.20217391304348, -0.01875
97036, 0.89130434782609, 0.20217391304348, -0.0375
97037, 0.8695652173913, 0.17608695652174, -0.0375
97038, 0.8695652173913, 0.20217391304348, -0.01875
97039, 0.84782608695652, 0.20217391304348, -0.0375
97040, 0.82608695652174, 0.17608695652174, -0.0375
97041, 0.82608695652174, 0.20217391304348, -0.01875
97042, 0.80434782608696, 0.20217391304348, -0.0375
97043, 0.78260869565217, 0.17608695652174, -0.0375
97044, 0.78260869565217, 0.20217391304348, -0.01875
97045, 0.76086956521739, 0.20217391304348, -0.0375
97046, 0.73913043478261, 0.17608695652174, -0.0375
97047, 0.73913043478261, 0.20217391304348, -0.01875
97048, 0.71739130434783, 0.20217391304348, -0.0375
97049, 0.69565217391304, 0.17608695652174, -0.0375
97050, 0.69565217391304, 0.20217391304348, -0.01875
97051, 0.67391304347826, 0.20217391304348, -0.0375
97052, 0.65217391304348, 0.17608695652174, -0.0375
97053, 0.65217391304348, 0.20217391304348, -0.01875
97054, 0.6304347826087, 0.20217391304348, -0.0375
97055, 0.60869565217391, 0.17608695652174, -0.0375
97056, 0.60869565217391, 0.20217391304348, -0.01875
97057, 0.58695652173913, 0.20217391304348, -0.0375
97058, 0.56521739130435, 0.17608695652174, -0.0375
97059, 0.56521739130435, 0.20217391304348, -0.01875
97060, 0.54347826086957, 0.20217391304348, -0.0375
97061, 0.52173913043478, 0.17608695652174, -0.0375
97062, 0.52173913043478, 0.20217391304348, -0.01875
97063, 0.5, 0.20217391304348, -0.0375
97064, 0.47826086956522, 0.17608695652174, -0.0375
97065, 0.47826086956522, 0.20217391304348, -0.01875
97066, 0.45652173913043, 0.20217391304348, -0.0375
97067, 0.43478260869565, 0.17608695652174, -0.0375
97068, 0.43478260869565, 0.20217391304348, -0.01875
97069, 0.41304347826087, 0.20217391304348, -0.0375
97070, 0.39130434782609, 0.17608695652174, -0.0375
97071, 0.39130434782609, 0.20217391304348, -0.01875
97072, 0.3695652173913, 0.20217391304348, -0.0375
97073, 0.34782608695652, 0.17608695652174, -0.0375
97074, 0.34782608695652, 0.20217391304348, -0.01875
97075, 0.32608695652174, 0.20217391304348, -0.0375
97076, 0.30434782608696, 0.17608695652174, -0.0375
97077, 0.30434782608696, 0.20217391304348, -0.01875
97078, 0.28260869565217, 0.20217391304348, -0.0375
97079, 0.26086956521739, 0.17608695652174, -0.0375
97080, 0.26086956521739, 0.20217391304348, -0.01875
97081, 0.23913043478261, 0.20217391304348, -0.0375
97082, 0.21739130434783, 0.17608695652174, -0.0375
97083, 0.21739130434783, 0.20217391304348, -0.01875
97084, 0.19565217391304, 0.20217391304348, -0.0375
97085, 0.17391304347826, 0.17608695652174, -0.0375
97086, 0.17391304347826, 0.20217391304348, -0.01875
97087, 0.15217391304348, 0.20217391304348, -0.0375
97088, 0.1304347826087, 0.17608695652174, -0.0375
97089, 0.1304347826087, 0.20217391304348, -0.01875
97090, 0.10869565217391, 0.20217391304348, -0.0375
97091, 0.08695652173913, 0.17608695652174, -0.0375
97092, 0.08695652173913, 0.20217391304348, -0.01875
97093, 0.065217391304348, 0.20217391304348, -0.0375
97094, 0.043478260869565, 0.17608695652174, -0.0375
97095, 0.043478260869565, 0.20217391304348, -0.01875
97096, 0.021739130434783, 0.20217391304348, -0.0375
97097, 0.97826086956522, 0.25434782608696, -0.0375
97098, 0.95652173913043, 0.22826086956522, -0.0375
97099, 0.95652173913043, 0.25434782608696, -0.01875
97100, 0.93478260869565, 0.25434782608696, -0.0375
97101, 0.91304347826087, 0.22826086956522, -0.0375
97102, 0.91304347826087, 0.25434782608696, -0.01875
97103, 0.89130434782609, 0.25434782608696, -0.0375
97104, 0.8695652173913, 0.22826086956522, -0.0375
97105, 0.8695652173913, 0.25434782608696, -0.01875
97106, 0.84782608695652, 0.25434782608696, -0.0375
97107, 0.82608695652174, 0.22826086956522, -0.0375
97108, 0.82608695652174, 0.25434782608696, -0.01875
97109, 0.80434782608696, 0.25434782608696, -0.0375
97110, 0.78260869565217, 0.22826086956522, -0.0375
97111, 0.78260869565217, 0.25434782608696, -0.01875
97112, 0.76086956521739, 0.25434782608696, -0.0375
97113, 0.73913043478261, 0.22826086956522, -0.0375
97114, 0.73913043478261, 0.25434782608696, -0.01875
97115, 0.71739130434783, 0.25434782608696, -0.0375
97116, 0.69565217391304, 0.22826086956522, -0.0375
97117, 0.69565217391304, 0.25434782608696, -0.01875
97118, 0.67391304347826, 0.25434782608696, -0.0375
97119, 0.65217391304348, 0.22826086956522, -0.0375
97120, 0.65217391304348, 0.25434782608696, -0.01875
97121, 0.6304347826087, 0.25434782608696, -0.0375
97122, 0.60869565217391, 0.22826086956522, -0.0375
97123, 0.60869565217391, 0.25434782608696, -0.01875
97124, 0.58695652173913, 0.25434782608696, -0.0375
97125, 0.56521739130435, 0.22826086956522, -0.0375
97126, 0.56521739130435, 0.25434782608696, -0.01875
97127, 0.54347826086956, 0.25434782608696, -0.0375
97128, 0.52173913043478, 0.22826086956522, -0.0375
97129, 0.52173913043478, 0.25434782608696, -0.01875
97130, 0.5, 0.25434782608696, -0.0375
97131, 0.47826086956522, 0.22826086956522, -0.0375
97132, 0.47826086956522, 0.25434782608696, -0.01875
97133, 0.45652173913043, 0.25434782608696, -0.0375
97134, 0.43478260869565, 0.22826086956522, -0.0375
97135, 0.43478260869565, 0.25434782608696, -0.01875
97136, 0.41304347826087, 0.25434782608696, -0.0375
97137, 0.39130434782609, 0.22826086956522, -0.0375
97138, 0.39130434782609, 0.25434782608696, -0.01875
97139, 0.3695652173913, 0.25434782608696, -0.0375
97140, 0.34782608695652, 0.22826086956522, -0.0375
97141, 0.34782608695652, 0.25434782608696, -0.01875
97142, 0.32608695652174, 0.25434782608696, -0.0375
97143, 0.30434782608696, 0.22826086956522, -0.0375
97144, 0.30434782608696, 0.25434782608696, -0.01875
97145, 0.28260869565217, 0.25434782608696, -0.0375
97146, 0.26086956521739, 0.22826086956522, -0.0375
97147, 0.26086956521739, 0.25434782608696, -0.01875
97148, 0.23913043478261, 0.25434782608696, -0.0375
97149, 0.21739130434783, 0.22826086956522, -0.0375
97150, 0.21739130434783, 0.25434782608696, -0.01875
97151, 0.19565217391304, 0.25434782608696, -0.0375
97152, 0.17391304347826, 0.22826086956522, -0.0375
97153, 0.17391304347826, 0.25434782608696, -0.01875
97154, 0.15217391304348, 0.25434782608696, -0.0375
97155, 0.1304347826087, 0.22826086956522, -0.0375
97156, 0.1304347826087, 0.25434782608696, -0.01875
97157, 0.10869565217391, 0.25434782608696, -0.0375
97158, 0.08695652173913, 0.22826086956522, -0.0375
97159, 0.08695652173913, 0.25434782608696, -0.01875
97160, 0.065217391304348, 0.25434782608696, -0.0375
97161, 0.043478260869565, 0.22826086956522, -0.0375
97162, 0.043478260869565, 0.25434782608696, -0.01875
97163, 0.021739130434783, 0.25434782608696, -0.0375
97164, 0.97826086956522, 0.30652173913043, -0.0375
97165, 0.95652173913044, 0.2804347826087, -0.0375
97166, 0.95652173913044, 0.30652173913043, -0.01875
97167, 0.93478260869565, 0.30652173913043, -0.0375
97168, 0.91304347826087, 0.2804347826087, -0.0375
97169, 0.91304347826087, 0.30652173913043, -0.01875
97170, 0.89130434782609, 0.30652173913043, -0.0375
97171, 0.8695652173913, 0.2804347826087, -0.0375
97172, 0.8695652173913, 0.30652173913043, -0.01875
97173, 0.84782608695652, 0.30652173913043, -0.0375
97174, 0.82608695652174, 0.2804347826087, -0.0375
97175, 0.82608695652174, 0.30652173913043, -0.01875
97176, 0.80434782608696, 0.30652173913043, -0.0375
97177, 0.78260869565217, 0.2804347826087, -0.0375
97178, 0.78260869565217, 0.30652173913043, -0.01875
97179, 0.76086956521739, 0.30652173913043, -0.0375
97180, 0.73913043478261, 0.2804347826087, -0.0375
97181, 0.73913043478261, 0.30652173913043, -0.01875
97182, 0.71739130434783, 0.30652173913043, -0.0375
97183, 0.69565217391304, 0.2804347826087, -0.0375
97184, 0.69565217391304, 0.30652173913043, -0.01875
97185, 0.67391304347826, 0.30652173913043, -0.0375
97186, 0.65217391304348, 0.2804347826087, -0.0375
97187, 0.65217391304348, 0.30652173913043, -0.01875
97188, 0.6304347826087, 0.30652173913043, -0.0375
97189, 0.60869565217391, 0.2804347826087, -0.0375
97190, 0.60869565217391, 0.30652173913043, -0.01875
97191, 0.58695652173913, 0.30652173913043, -0.0375
97192, 0.56521739130435, 0.2804347826087, -0.0375
97193, 0.56521739130435, 0.30652173913043, -0.01875
97194, 0.54347826086956, 0.30652173913043, -0.0375
97195, 0.52173913043478, 0.2804347826087, -0.0375
97196, 0.52173913043478, 0.30652173913043, -0.01875
97197, 0.5, 0.30652173913043, -0.0375
97198, 0.47826086956522, 0.2804347826087, -0.0375
97199, 0.47826086956522, 0.30652173913043, -0.01875
97200, 0.45652173913043, 0.30652173913043, -0.0375
97201, 0.43478260869565, 0.2804347826087, -0.0375
97202, 0.43478260869565, 0.30652173913043, -0.01875
97203, 0.41304347826087, 0.30652173913043, -0.0375
97204, 0.39130434782609, 0.2804347826087, -0.0375
97205, 0.39130434782609, 0.30652173913043, -0.01875
97206, 0.3695652173913, 0.30652173913043, -0.0375
97207, 0.34782608695652, 0.2804347826087, -0.0375
97208, 0.34782608695652, 0.30652173913043, -0.01875
97209, 0.32608695652174, 0.30652173913043, -0.0375
97210, 0.30434782608696, 0.2804347826087, -0.0375
97211, 0.30434782608696, 0.30652173913043, -0.01875
97212, 0.28260869565217, 0.30652173913043, -0.0375
97213, 0.26086956521739, 0.2804347826087, -0.0375
97214, 0.26086956521739, 0.30652173913043, -0.01875
97215, 0.23913043478261, 0.30652173913043, -0.0375
97216, 0.21739130434783, 0.2804347826087, -0.0375
97217, 0.21739130434783, 0.30652173913043, -0.01875
97218, 0.19565217391304, 0.30652173913043, -0.0375
97219, 0.17391304347826, 0.2804347826087, -0.0375
97220, 0.17391304347826, 0.30652173913043, -0.01875
97221, 0.15217391304348, 0.30652173913043, -0.0375
97222, 0.1304347826087, 0.2804347826087, -0.0375
97223, 0.1304347826087, 0.30652173913043, -0.01875
97224, 0.10869565217391, 0.30652173913043, -0.0375
97225, 0.08695652173913, 0.2804347826087, -0.0375
97226, 0.08695652173913, 0.30652173913043, -0.01875
97227, 0.065217391304348, 0.30652173913043, -0.0375
97228, 0.043478260869565, 0.2804347826087, -0.0375
97229, 0.043478260869565, 0.30652173913043, -0.01875
97230, 0.021739130434783, 0.30652173913043, -0.0375
97231, 0.97826086956522, 0.35869565217391, -0.0375
97232, 0.95652173913044, 0.33260869565217, -0.0375
97233, 0.95652173913043, 0.35869565217391, -0.01875
97234, 0.93478260869565, 0.35869565217391, -0.0375
97235, 0.91304347826087, 0.33260869565217, -0.0375
97236, 0.91304347826087, 0.35869565217391, -0.01875
97237, 0.89130434782609, 0.35869565217391, -0.0375
97238, 0.8695652173913, 0.33260869565217, -0.0375
97239, 0.8695652173913, 0.35869565217391, -0.01875
97240, 0.84782608695652, 0.35869565217391, -0.0375
97241, 0.82608695652174, 0.33260869565217, -0.0375
97242, 0.82608695652174, 0.35869565217391, -0.01875
97243, 0.80434782608696, 0.35869565217391, -0.0375
97244, 0.78260869565217, 0.33260869565217, -0.0375
97245, 0.78260869565217, 0.35869565217391, -0.01875
97246, 0.76086956521739, 0.35869565217391, -0.0375
97247, 0.73913043478261, 0.33260869565217, -0.0375
97248, 0.73913043478261, 0.35869565217391, -0.01875
97249, 0.71739130434783, 0.35869565217391, -0.0375
97250, 0.69565217391304, 0.33260869565217, -0.0375
97251, 0.69565217391304, 0.35869565217391, -0.01875
97252, 0.67391304347826, 0.35869565217391, -0.0375
97253, 0.65217391304348, 0.33260869565217, -0.0375
97254, 0.65217391304348, 0.35869565217391, -0.01875
97255, 0.6304347826087, 0.35869565217391, -0.0375
97256, 0.60869565217391, 0.33260869565217, -0.0375
97257, 0.60869565217391, 0.35869565217391, -0.01875
97258, 0.58695652173913, 0.35869565217391, -0.0375
97259, 0.56521739130435, 0.33260869565217, -0.0375
97260, 0.56521739130435, 0.35869565217391, -0.01875
97261, 0.54347826086957, 0.35869565217391, -0.0375
97262, 0.52173913043478, 0.33260869565217, -0.0375
97263, 0.52173913043478, 0.35869565217391, -0.01875
97264, 0.5, 0.35869565217391, -0.0375
97265, 0.47826086956522, 0.33260869565217, -0.0375
97266, 0.47826086956522, 0.35869565217391, -0.01875
97267, 0.45652173913043, 0.35869565217391, -0.0375
97268, 0.43478260869565, 0.33260869565217, -0.0375
97269, 0.43478260869565, 0.35869565217391, -0.01875
97270, 0.41304347826087, 0.35869565217391, -0.0375
97271, 0.39130434782609, 0.33260869565217, -0.0375
97272, 0.39130434782609, 0.35869565217391, -0.01875
97273, 0.3695652173913, 0.35869565217391, -0.0375
97274, 0.34782608695652, 0.33260869565217, -0.0375
97275, 0.34782608695652, 0.35869565217391, -0.01875
97276, 0.32608695652174, 0.35869565217391, -0.0375
97277, 0.30434782608696, 0.33260869565217, -0.0375
97278, 0.30434782608696, 0.35869565217391, -0.01875
97279, 0.28260869565217, 0.35869565217391, -0.0375
97280, 0.26086956521739, 0.33260869565217, -0.0375
97281, 0.26086956521739, 0.35869565217391, -0.01875
97282, 0.23913043478261, 0.35869565217391, -0.0375
97283, 0.21739130434783, 0.33260869565217, -0.0375
97284, 0.21739130434783, 0.35869565217391, -0.01875
97285, 0.19565217391304, 0.35869565217391, -0.0375
97286, 0.17391304347826, 0.33260869565217, -0.0375
97287, 0.17391304347826, 0.35869565217391, -0.01875
97288, 0.15217391304348, 0.35869565217391, -0.0375
97289, 0.1304347826087, 0.33260869565217, -0.0375
97290, 0.1304347826087, 0.35869565217391, -0.01875
97291, 0.10869565217391, 0.35869565217391, -0.0375
97292, 0.08695652173913, 0.33260869565217, -0.0375
97293, 0.08695652173913, 0.35869565217391, -0.01875
97294, 0.065217391304348, 0.35869565217391, -0.0375
97295, 0.043478260869565, 0.33260869565217, -0.0375
97296, 0.043478260869565, 0.35869565217391, -0.01875
97297, 0.021739130434783, 0.35869565217391, -0.0375
97298, 0.97826086956522, 0.41086956521739, -0.0375
97299, 0.95652173913043, 0.38478260869565, -0.0375
97300, 0.95652173913043, 0.41086956521739, -0.01875
97301, 0.93478260869565, 0.41086956521739, -0.0375
97302, 0.91304347826087, 0.38478260869565, -0.0375
97303, 0.91304347826087, 0.41086956521739, -0.01875
97304, 0.89130434782609, 0.41086956521739, -0.0375
97305, 0.8695652173913, 0.38478260869565, -0.0375
97306, 0.8695652173913, 0.41086956521739, -0.01875
97307, 0.84782608695652, 0.41086956521739, -0.0375
97308, 0.82608695652174, 0.38478260869565, -0.0375
97309, 0.82608695652174, 0.41086956521739, -0.01875
97310, 0.80434782608696, 0.41086956521739, -0.0375
97311, 0.78260869565217, 0.38478260869565, -0.0375
97312, 0.78260869565217, 0.41086956521739, -0.01875
97313, 0.76086956521739, 0.41086956521739, -0.0375
97314, 0.73913043478261, 0.38478260869565, -0.0375
97315, 0.73913043478261, 0.41086956521739, -0.01875
97316, 0.71739130434783, 0.41086956521739, -0.0375
97317, 0.69565217391304, 0.38478260869565, -0.0375
97318, 0.69565217391304, 0.41086956521739, -0.01875
97319, 0.67391304347826, 0.41086956521739, -0.0375
97320, 0.65217391304348, 0.38478260869565, -0.0375
97321, 0.65217391304348, 0.41086956521739, -0.01875
97322, 0.6304347826087, 0.41086956521739, -0.0375
97323, 0.60869565217391, 0.38478260869565, -0.0375
97324, 0.60869565217391, 0.41086956521739, -0.01875
97325, 0.58695652173913, 0.41086956521739, -0.0375
97326, 0.56521739130435, 0.38478260869565, -0.0375
97327, 0.56521739130435, 0.41086956521739, -0.01875
97328, 0.54347826086956, 0.41086956521739, -0.0375
97329, 0.52173913043478, 0.38478260869565, -0.0375
97330, 0.52173913043478, 0.41086956521739, -0.01875
97331, 0.5, 0.41086956521739, -0.0375
97332, 0.47826086956522, 0.38478260869565, -0.0375
97333, 0.47826086956522, 0.41086956521739, -0.01875
97334, 0.45652173913043, 0.41086956521739, -0.0375
97335, 0.43478260869565, 0.38478260869565, -0.0375
97336, 0.43478260869565, 0.41086956521739, -0.01875
97337, 0.41304347826087, 0.41086956521739, -0.0375
97338, 0.39130434782609, 0.38478260869565, -0.0375
97339, 0.39130434782609, 0.41086956521739, -0.01875
97340, 0.3695652173913, 0.41086956521739, -0.0375
97341, 0.34782608695652, 0.38478260869565, -0.0375
97342, 0.34782608695652, 0.41086956521739, -0.01875
97343, 0.32608695652174, 0.41086956521739, -0.0375
97344, 0.30434782608696, 0.38478260869565, -0.0375
97345, 0.30434782608696, 0.41086956521739, -0.01875
97346, 0.28260869565217, 0.41086956521739, -0.0375
97347, 0.26086956521739, 0.38478260869565, -0.0375
97348, 0.26086956521739, 0.41086956521739, -0.01875
97349, 0.23913043478261, 0.41086956521739, -0.0375
97350, 0.21739130434783, 0.38478260869565, -0.0375
97351, 0.21739130434783, 0.41086956521739, -0.01875
97352, 0.19565217391304, 0.41086956521739, -0.0375
97353, 0.17391304347826, 0.38478260869565, -0.0375
97354, 0.17391304347826, 0.41086956521739, -0.01875
97355, 0.15217391304348, 0.41086956521739, -0.0375
97356, 0.1304347826087, 0.38478260869565, -0.0375
97357, 0.1304347826087, 0.41086956521739, -0.01875
97358, 0.10869565217391, 0.41086956521739, -0.0375
97359, 0.08695652173913, 0.38478260869565, -0.0375
97360, 0.08695652173913, 0.41086956521739, -0.01875
97361, 0.065217391304348, 0.41086956521739, -0.0375
97362, 0.043478260869565, 0.38478260869565, -0.0375
97363, 0.043478260869565, 0.41086956521739, -0.01875
97364, 0.021739130434783, 0.41086956521739, -0.0375
97365, 0.97826086956522, 0.46304347826087, -0.0375
97366, 0.95652173913043, 0.43695652173913, -0.0375
97367, 0.95652173913043, 0.46304347826087, -0.01875
97368, 0.93478260869565, 0.46304347826087, -0.0375
97369, 0.91304347826087, 0.43695652173913, -0.0375
97370, 0.91304347826087, 0.46304347826087, -0.01875
97371, 0.89130434782609, 0.46304347826087, -0.0375
97372, 0.8695652173913, 0.43695652173913, -0.0375
97373, 0.8695652173913, 0.46304347826087, -0.01875
97374, 0.84782608695652, 0.46304347826087, -0.0375
97375, 0.82608695652174, 0.43695652173913, -0.0375
97376, 0.82608695652174, 0.46304347826087, -0.01875
97377, 0.80434782608696, 0.46304347826087, -0.0375
97378, 0.78260869565217, 0.43695652173913, -0.0375
97379, 0.78260869565217, 0.46304347826087, -0.01875
97380, 0.76086956521739, 0.46304347826087, -0.0375
97381, 0.73913043478261, 0.43695652173913, -0.0375
97382, 0.73913043478261, 0.46304347826087, -0.01875
97383, 0.71739130434783, 0.46304347826087, -0.0375
97384, 0.69565217391304, 0.43695652173913, -0.0375
97385, 0.69565217391304, 0.46304347826087, -0.01875
97386, 0.67391304347826, 0.46304347826087, -0.0375
97387, 0.65217391304348, 0.43695652173913, -0.0375
97388, 0.65217391304348, 0.46304347826087, -0.01875
97389, 0.6304347826087, 0.46304347826087, -0.0375
97390, 0.60869565217391, 0.43695652173913, -0.0375
97391, 0.60869565217391, 0.46304347826087, -0.01875
97392, 0.58695652173913, 0.46304347826087, -0.0375
97393, 0.56521739130435, 0.43695652173913, -0.0375
97394, 0.56521739130435, 0.46304347826087, -0.01875
97395, 0.54347826086957, 0.46304347826087, -0.0375
97396, 0.52173913043478, 0.43695652173913, -0.0375
97397, 0.52173913043478, 0.46304347826087, -0.01875
97398, 0.5, 0.46304347826087, -0.0375
97399, 0.47826086956522, 0.43695652173913, -0.0375
97400, 0.47826086956522, 0.46304347826087, -0.01875
97401, 0.45652173913043, 0.46304347826087, -0.0375
97402, 0.43478260869565, 0.43695652173913, -0.0375
97403, 0.43478260869565, 0.46304347826087, -0.01875
97404, 0.41304347826087, 0.46304347826087, -0.0375
97405, 0.39130434782609, 0.43695652173913, -0.0375
97406, 0.39130434782609, 0.46304347826087, -0.01875
97407, 0.3695652173913, 0.46304347826087, -0.0375
97408, 0.34782608695652, 0.43695652173913, -0.0375
97409, 0.34782608695652, 0.46304347826087, -0.01875
97410, 0.32608695652174, 0.46304347826087, -0.0375
97411, 0.30434782608696, 0.43695652173913, -0.0375
97412, 0.30434782608696, 0.46304347826087, -0.01875
97413, 0.28260869565217, 0.46304347826087, -0.0375
97414, 0.26086956521739, 0.43695652173913, -0.0375
97415, 0.26086956521739, 0.46304347826087, -0.01875
97416, 0.23913043478261, 0.46304347826087, -0.0375
97417, 0.21739130434783, 0.43695652173913, -0.0375
97418, 0.21739130434783, 0.46304347826087, -0.01875
97419, 0.19565217391304, 0.46304347826087, -0.0375
97420, 0.17391304347826, 0.43695652173913, -0.0375
97421, 0.17391304347826, 0.46304347826087, -0.01875
97422, 0.15217391304348, 0.46304347826087, -0.0375
97423, 0.1304347826087, 0.43695652173913, -0.0375
97424, 0.1304347826087, 0.46304347826087, -0.01875
97425, 0.10869565217391, 0.46304347826087, -0.0375
97426, 0.08695652173913, 0.43695652173913, -0.0375
97427, 0.08695652173913, 0.46304347826087, -0.01875
97428, 0.065217391304348, 0.46304347826087, -0.0375
97429, 0.043478260869565, 0.43695652173913, -0.0375
97430, 0.043478260869565, 0.46304347826087, -0.01875
97431, 0.021739130434783, 0.46304347826087, -0.0375
97432, 0.97826086956522, 0.51521739130435, -0.0375
97433, 0.95652173913044, 0.48913043478261, -0.0375
97434, 0.95652173913043, 0.51521739130435, -0.01875
97435, 0.93478260869565, 0.51521739130435, -0.0375
97436, 0.91304347826087, 0.48913043478261, -0.0375
97437, 0.91304347826087, 0.51521739130435, -0.01875
97438, 0.89130434782609, 0.51521739130435, -0.0375
97439, 0.8695652173913, 0.48913043478261, -0.0375
97440, 0.8695652173913, 0.51521739130435, -0.01875
97441, 0.84782608695652, 0.51521739130435, -0.0375
97442, 0.82608695652174, 0.48913043478261, -0.0375
97443, 0.82608695652174, 0.51521739130435, -0.01875
97444, 0.80434782608696, 0.51521739130435, -0.0375
97445, 0.78260869565217, 0.48913043478261, -0.0375
97446, 0.78260869565217, 0.51521739130435, -0.01875
97447, 0.76086956521739, 0.51521739130435, -0.0375
97448, 0.73913043478261, 0.48913043478261, -0.0375
97449, 0.73913043478261, 0.51521739130435, -0.01875
97450, 0.71739130434783, 0.51521739130435, -0.0375
97451, 0.69565217391304, 0.48913043478261, -0.0375
97452, 0.69565217391304, 0.51521739130435, -0.01875
97453, 0.67391304347826, 0.51521739130435, -0.0375
97454, 0.65217391304348, 0.48913043478261, -0.0375
97455, 0.65217391304348, 0.51521739130435, -0.01875
97456, 0.6304347826087, 0.51521739130435, -0.0375
97457, 0.60869565217391, 0.48913043478261, -0.0375
97458, 0.60869565217391, 0.51521739130435, -0.01875
97459, 0.58695652173913, 0.51521739130435, -0.0375
97460, 0.56521739130435, 0.48913043478261, -0.0375
97461, 0.56521739130435, 0.51521739130435, -0.01875
97462, 0.54347826086956, 0.51521739130435, -0.0375
97463, 0.52173913043478, 0.48913043478261, -0.0375
97464, 0.52173913043478, 0.51521739130435, -0.01875
97465, 0.5, 0.51521739130435, -0.0375
97466, 0.47826086956522, 0.48913043478261, -0.0375
97467, 0.47826086956522, 0.51521739130435, -0.01875
97468, 0.45652173913044, 0.51521739130435, -0.0375
97469, 0.43478260869565, 0.48913043478261, -0.0375
97470, 0.43478260869565, 0.51521739130435, -0.01875
97471, 0.41304347826087, 0.51521739130435, -0.0375
97472, 0.39130434782609, 0.48913043478261, -0.0375
97473, 0.39130434782609, 0.51521739130435, -0.01875
97474, 0.3695652173913, 0.51521739130435, -0.0375
97475, 0.34782608695652, 0.48913043478261, -0.0375
97476, 0.34782608695652, 0.51521739130435, -0.01875
97477, 0.32608695652174, 0.51521739130435, -0.0375
97478, 0.30434782608696, 0.48913043478261, -0.0375
97479, 0.30434782608696, 0.51521739130435, -0.01875
97480, 0.28260869565217, 0.51521739130435, -0.0375
97481, 0.26086956521739, 0.48913043478261, -0.0375
97482, 0.26086956521739, 0.51521739130435, -0.01875
97483, 0.23913043478261, 0.51521739130435, -0.0375
97484, 0.21739130434783, 0.48913043478261, -0.0375
97485, 0.21739130434783, 0.51521739130435, -0.01875
97486, 0.19565217391304, 0.51521739130435, -0.0375
97487, 0.17391304347826, 0.48913043478261, -0.0375
97488, 0.17391304347826, 0.51521739130435, -0.01875
97489, 0.15217391304348, 0.51521739130435, -0.0375
97490, 0.1304347826087, 0.48913043478261, -0.0375
97491, 0.1304347826087, 0.51521739130435, -0.01875
97492, 0.10869565217391, 0.51521739130435, -0.0375
97493, 0.08695652173913, 0.48913043478261, -0.0375
97494, 0.08695652173913, 0.51521739130435, -0.01875
97495, 0.065217391304348, 0.51521739130435, -0.0375
97496, 0.043478260869565, 0.48913043478261, -0.0375
97497, 0.043478260869565, 0.51521739130435, -0.01875
97498, 0.021739130434783, 0.51521739130435, -0.0375
97499, 0.97826086956522, 0.56739130434783, -0.0375
97500, 0.95652173913044, 0.54130434782609, -0.0375
97501, 0.95652173913043, 0.56739130434783, -0.01875
97502, 0.93478260869565, 0.56739130434783, -0.0375
97503, 0.91304347826087, 0.54130434782609, -0.0375
97504, 0.91304347826087, 0.56739130434783, -0.01875
97505, 0.89130434782609, 0.56739130434783, -0.0375
97506, 0.8695652173913, 0.54130434782609, -0.0375
97507, 0.8695652173913, 0.56739130434783, -0.01875
97508, 0.84782608695652, 0.56739130434783, -0.0375
97509, 0.82608695652174, 0.54130434782609, -0.0375
97510, 0.82608695652174, 0.56739130434783, -0.01875
97511, 0.80434782608696, 0.56739130434783, -0.0375
97512, 0.78260869565217, 0.54130434782609, -0.0375
97513, 0.78260869565217, 0.56739130434783, -0.01875
97514, 0.76086956521739, 0.56739130434783, -0.0375
97515, 0.73913043478261, 0.54130434782609, -0.0375
97516, 0.73913043478261, 0.56739130434783, -0.01875
97517, 0.71739130434783, 0.56739130434783, -0.0375
97518, 0.69565217391304, 0.54130434782609, -0.0375
97519, 0.69565217391304, 0.56739130434783, -0.01875
97520, 0.67391304347826, 0.56739130434783, -0.0375
97521, 0.65217391304348, 0.54130434782609, -0.0375
97522, 0.65217391304348, 0.56739130434783, -0.01875
97523, 0.6304347826087, 0.56739130434783, -0.0375
97524, 0.60869565217391, 0.54130434782609, -0.0375
97525, 0.60869565217391, 0.56739130434783, -0.01875
97526, 0.58695652173913, 0.56739130434783, -0.0375
97527, 0.56521739130435, 0.54130434782609, -0.0375
97528, 0.56521739130435, 0.56739130434783, -0.01875
97529, 0.54347826086956, 0.56739130434783, -0.0375
97530, 0.52173913043478, 0.54130434782609, -0.0375
97531, 0.52173913043478, 0.56739130434783, -0.01875
97532, 0.5, 0.56739130434783, -0.0375
97533, 0.47826086956522, 0.54130434782609, -0.0375
97534, 0.47826086956522, 0.56739130434783, -0.01875
97535, 0.45652173913043, 0.56739130434783, -0.0375
97536, 0.43478260869565, 0.54130434782609, -0.0375
97537, 0.43478260869565, 0.56739130434783, -0.01875
97538, 0.41304347826087, 0.56739130434783, -0.0375
97539, 0.39130434782609, 0.54130434782609, -0.0375
97540, 0.39130434782609, 0.56739130434783, -0.01875
97541, 0.3695652173913, 0.56739130434783, -0.0375
97542, 0.34782608695652, 0.54130434782609, -0.0375
97543, 0.34782608695652, 0.56739130434783, -0.01875
97544, 0.32608695652174, 0.56739130434783, -0.0375
97545, 0.30434782608696, 0.54130434782609, -0.0375
97546, 0.30434782608696, 0.56739130434783, -0.01875
97547, 0.28260869565217, 0.56739130434783, -0.0375
97548, 0.26086956521739, 0.54130434782609, -0.0375
97549, 0.26086956521739, 0.56739130434783, -0.01875
97550, 0.23913043478261, 0.56739130434783, -0.0375
97551, 0.21739130434783, 0.54130434782609, -0.0375
97552, 0.21739130434783, 0.56739130434783, -0.01875
97553, 0.19565217391304, 0.56739130434783, -0.0375
97554, 0.17391304347826, 0.54130434782609, -0.0375
97555, 0.17391304347826, 0.56739130434783, -0.01875
97556, 0.15217391304348, 0.56739130434783, -0.0375
97557, 0.1304347826087, 0.54130434782609, -0.0375
97558, 0.1304347826087, 0.56739130434783, -0.01875
97559, 0.10869565217391, 0.56739130434783, -0.0375
97560, 0.08695652173913, 0.54130434782609, -0.0375
97561, 0.08695652173913, 0.56739130434783, -0.01875
97562, 0.065217391304348, 0.56739130434783, -0.0375
97563, 0.043478260869565, 0.54130434782609, -0.0375
97564, 0.043478260869565, 0.56739130434783, -0.01875
97565, 0.021739130434783, 0.56739130434783, -0.0375
97566, 0.97826086956522, 0.6195652173913, -0.0375
97567, 0.95652173913044, 0.59347826086956, -0.0375
97568, 0.95652173913043, 0.6195652173913, -0.01875
97569, 0.93478260869565, 0.6195652173913, -0.0375
97570, 0.91304347826087, 0.59347826086956, -0.0375
97571, 0.91304347826087, 0.6195652173913, -0.01875
97572, 0.89130434782609, 0.6195652173913, -0.0375
97573, 0.8695652173913, 0.59347826086956, -0.0375
97574, 0.8695652173913, 0.6195652173913, -0.01875
97575, 0.84782608695652, 0.6195652173913, -0.0375
97576, 0.82608695652174, 0.59347826086956, -0.0375
97577, 0.82608695652174, 0.6195652173913, -0.01875
97578, 0.80434782608696, 0.6195652173913, -0.0375
97579, 0.78260869565217, 0.59347826086956, -0.0375
97580, 0.78260869565217, 0.6195652173913, -0.01875
97581, 0.76086956521739, 0.6195652173913, -0.0375
97582, 0.73913043478261, 0.59347826086956, -0.0375
97583, 0.73913043478261, 0.6195652173913, -0.01875
97584, 0.71739130434783, 0.6195652173913, -0.0375
97585, 0.69565217391304, 0.59347826086956, -0.0375
97586, 0.69565217391304, 0.6195652173913, -0.01875
97587, 0.67391304347826, 0.6195652173913, -0.0375
97588, 0.65217391304348, 0.59347826086956, -0.0375
97589, 0.65217391304348, 0.6195652173913, -0.01875
97590, 0.6304347826087, 0.6195652173913, -0.0375
97591, 0.60869565217391, 0.59347826086956, -0.0375
97592, 0.60869565217391, 0.6195652173913, -0.01875
97593, 0.58695652173913, 0.6195652173913, -0.0375
97594, 0.56521739130435, 0.59347826086956, -0.0375
97595, 0.56521739130435, 0.6195652173913, -0.01875
97596, 0.54347826086957, 0.6195652173913, -0.0375
97597, 0.52173913043478, 0.59347826086956, -0.0375
97598, 0.52173913043478, 0.6195652173913, -0.01875
97599, 0.5, 0.6195652173913, -0.0375
97600, 0.47826086956522, 0.59347826086956, -0.0375
97601, 0.47826086956522, 0.6195652173913, -0.01875
97602, 0.45652173913043, 0.6195652173913, -0.0375
97603, 0.43478260869565, 0.59347826086956, -0.0375
97604, 0.43478260869565, 0.6195652173913, -0.01875
97605, 0.41304347826087, 0.6195652173913, -0.0375
97606, 0.39130434782609, 0.59347826086956, -0.0375
97607, 0.39130434782609, 0.6195652173913, -0.01875
97608, 0.3695652173913, 0.6195652173913, -0.0375
97609, 0.34782608695652, 0.59347826086956, -0.0375
97610, 0.34782608695652, 0.6195652173913, -0.01875
97611, 0.32608695652174, 0.6195652173913, -0.0375
97612, 0.30434782608696, 0.59347826086956, -0.0375
97613, 0.30434782608696, 0.6195652173913, -0.01875
97614, 0.28260869565217, 0.6195652173913, -0.0375
97615, 0.26086956521739, 0.59347826086956, -0.0375
97616, 0.26086956521739, 0.6195652173913, -0.01875
97617, 0.23913043478261, 0.6195652173913, -0.0375
97618, 0.21739130434783, 0.59347826086956, -0.0375
97619, 0.21739130434783, 0.6195652173913, -0.01875
97620, 0.19565217391304, 0.6195652173913, -0.0375
97621, 0.17391304347826, 0.59347826086956, -0.0375
97622, 0.17391304347826, 0.6195652173913, -0.01875
97623, 0.15217391304348, 0.6195652173913, -0.0375
97624, 0.1304347826087, 0.59347826086956, -0.0375
97625, 0.1304347826087, 0.6195652173913, -0.01875
97626, 0.10869565217391, 0.6195652173913, -0.0375
97627, 0.08695652173913, 0.59347826086956, -0.0375
97628, 0.08695652173913, 0.6195652173913, -0.01875
97629, 0.065217391304348, 0.6195652173913, -0.0375
97630, 0.043478260869565, 0.59347826086956, -0.0375
97631, 0.043478260869565, 0.6195652173913, -0.01875
97632, 0.021739130434783, 0.6195652173913, -0.0375
97633, 0.97826086956522, 0.67173913043478, -0.0375
97634, 0.95652173913044, 0.64565217391304, -0.0375
97635, 0.95652173913043, 0.67173913043478, -0.01875
97636, 0.93478260869565, 0.67173913043478, -0.0375
97637, 0.91304347826087, 0.64565217391304, -0.0375
97638, 0.91304347826087, 0.67173913043478, -0.01875
97639, 0.89130434782609, 0.67173913043478, -0.0375
97640, 0.8695652173913, 0.64565217391304, -0.0375
97641, 0.8695652173913, 0.67173913043478, -0.01875
97642, 0.84782608695652, 0.67173913043478, -0.0375
97643, 0.82608695652174, 0.64565217391304, -0.0375
97644, 0.82608695652174, 0.67173913043478, -0.01875
97645, 0.80434782608696, 0.67173913043478, -0.0375
97646, 0.78260869565217, 0.64565217391304, -0.0375
97647, 0.78260869565217, 0.67173913043478, -0.01875
97648, 0.76086956521739, 0.67173913043478, -0.0375
97649, 0.73913043478261, 0.64565217391304, -0.0375
97650, 0.73913043478261, 0.67173913043478, -0.01875
97651, 0.71739130434783, 0.67173913043478, -0.0375
97652, 0.69565217391304, 0.64565217391304, -0.0375
97653, 0.69565217391304, 0.67173913043478, -0.01875
97654, 0.67391304347826, 0.67173913043478, -0.0375
97655, 0.65217391304348, 0.64565217391304, -0.0375
97656, 0.65217391304348, 0.67173913043478, -0.01875
97657, 0.6304347826087, 0.67173913043478, -0.0375
97658, 0.60869565217391, 0.64565217391304, -0.0375
97659, 0.60869565217391, 0.67173913043478, -0.01875
97660, 0.58695652173913, 0.67173913043478, -0.0375
97661, 0.56521739130435, 0.64565217391304, -0.0375
97662, 0.56521739130435, 0.67173913043478, -0.01875
97663, 0.54347826086957, 0.67173913043478, -0.0375
97664, 0.52173913043478, 0.64565217391304, -0.0375
97665, 0.52173913043478, 0.67173913043478, -0.01875
97666, 0.5, 0.67173913043478, -0.0375
97667, 0.47826086956522, 0.64565217391304, -0.0375
97668, 0.47826086956522, 0.67173913043478, -0.01875
97669, 0.45652173913043, 0.67173913043478, -0.0375
97670, 0.43478260869565, 0.64565217391304, -0.0375
97671, 0.43478260869565, 0.67173913043478, -0.01875
97672, 0.41304347826087, 0.67173913043478, -0.0375
97673, 0.39130434782609, 0.64565217391304, -0.0375
97674, 0.39130434782609, 0.67173913043478, -0.01875
97675, 0.3695652173913, 0.67173913043478, -0.0375
97676, 0.34782608695652, 0.64565217391304, -0.0375
97677, 0.34782608695652, 0.67173913043478, -0.01875
97678, 0.32608695652174, 0.67173913043478, -0.0375
97679, 0.30434782608696, 0.64565217391304, -0.0375
97680, 0.30434782608696, 0.67173913043478, -0.01875
97681, 0.28260869565217, 0.67173913043478, -0.0375
97682, 0.26086956521739, 0.64565217391304, -0.0375
97683, 0.26086956521739, 0.67173913043478, -0.01875
97684, 0.23913043478261, 0.67173913043478, -0.0375
97685, 0.21739130434783, 0.64565217391304, -0.0375
97686, 0.21739130434783, 0.67173913043478, -0.01875
97687, 0.19565217391304, 0.67173913043478, -0.0375
97688, 0.17391304347826, 0.64565217391304, -0.0375
97689, 0.17391304347826, 0.67173913043478, -0.01875
97690, 0.15217391304348, 0.67173913043478, -0.0375
97691, 0.1304347826087, 0.64565217391304, -0.0375
97692, 0.1304347826087, 0.67173913043478, -0.01875
97693, 0.10869565217391, 0.67173913043478, -0.0375
97694, 0.08695652173913, 0.64565217391304, -0.0375
97695, 0.08695652173913, 0.67173913043478, -0.01875
97696, 0.065217391304348, 0.67173913043478, -0.0375
97697, 0.043478260869565, 0.64565217391304, -0.0375
97698, 0.043478260869565, 0.67173913043478, -0.01875
97699, 0.021739130434783, 0.67173913043478, -0.0375
97700, 0.97826086956522, 0.72391304347826, -0.0375
97701, 0.95652173913044, 0.69782608695652, -0.0375
97702, 0.95652173913043, 0.72391304347826, -0.01875
97703, 0.93478260869565, 0.72391304347826, -0.0375
97704, 0.91304347826087, 0.69782608695652, -0.0375
97705, 0.91304347826087, 0.72391304347826, -0.01875
97706, 0.89130434782609, 0.72391304347826, -0.0375
97707, 0.8695652173913, 0.69782608695652, -0.0375
97708, 0.8695652173913, 0.72391304347826, -0.01875
97709, 0.84782608695652, 0.72391304347826, -0.0375
97710, 0.82608695652174, 0.69782608695652, -0.0375
97711, 0.82608695652174, 0.72391304347826, -0.01875
97712, 0.80434782608696, 0.72391304347826, -0.0375
97713, 0.78260869565217, 0.69782608695652, -0.0375
97714, 0.78260869565217, 0.72391304347826, -0.01875
97715, 0.76086956521739, 0.72391304347826, -0.0375
97716, 0.73913043478261, 0.69782608695652, -0.0375
97717, 0.73913043478261, 0.72391304347826, -0.01875
97718, 0.71739130434783, 0.72391304347826, -0.0375
97719, 0.69565217391304, 0.69782608695652, -0.0375
97720, 0.69565217391304, 0.72391304347826, -0.01875
97721, 0.67391304347826, 0.72391304347826, -0.0375
97722, 0.65217391304348, 0.69782608695652, -0.0375
97723, 0.65217391304348, 0.72391304347826, -0.01875
97724, 0.6304347826087, 0.72391304347826, -0.0375
97725, 0.60869565217391, 0.69782608695652, -0.0375
97726, 0.60869565217391, 0.72391304347826, -0.01875
97727, 0.58695652173913, 0.72391304347826, -0.0375
97728, 0.56521739130435, 0.69782608695652, -0.0375
97729, 0.56521739130435, 0.72391304347826, -0.01875
97730, 0.54347826086957, 0.72391304347826, -0.0375
97731, 0.52173913043478, 0.69782608695652, -0.0375
97732, 0.52173913043478, 0.72391304347826, -0.01875
97733, 0.5, 0.72391304347826, -0.0375
97734, 0.47826086956522, 0.69782608695652, -0.0375
97735, 0.47826086956522, 0.72391304347826, -0.01875
97736, 0.45652173913043, 0.72391304347826, -0.0375
97737, 0.43478260869565, 0.69782608695652, -0.0375
97738, 0.43478260869565, 0.72391304347826, -0.01875
97739, 0.41304347826087, 0.72391304347826, -0.0375
97740, 0.39130434782609, 0.69782608695652, -0.0375
97741, 0.39130434782609, 0.72391304347826, -0.01875
97742, 0.3695652173913, 0.72391304347826, -0.0375
97743, 0.34782608695652, 0.69782608695652, -0.0375
97744, 0.34782608695652, 0.72391304347826, -0.01875
97745, 0.32608695652174, 0.72391304347826, -0.0375
97746, 0.30434782608696, 0.69782608695652, -0.0375
97747, 0.30434782608696, 0.72391304347826, -0.01875
97748, 0.28260869565217, 0.72391304347826, -0.0375
97749, 0.26086956521739, 0.69782608695652, -0.0375
97750, 0.26086956521739, 0.72391304347826, -0.01875
97751, 0.23913043478261, 0.72391304347826, -0.0375
97752, 0.21739130434783, 0.69782608695652, -0.0375
97753, 0.21739130434783, 0.72391304347826, -0.01875
97754, 0.19565217391304, 0.72391304347826, -0.0375
97755, 0.17391304347826, 0.69782608695652, -0.0375
97756, 0.17391304347826, 0.72391304347826, -0.01875
97757, 0.15217391304348, 0.72391304347826, -0.0375
97758, 0.1304347826087, 0.69782608695652, -0.0375
97759, 0.1304347826087, 0.72391304347826, -0.01875
97760, 0.10869565217391, 0.72391304347826, -0.0375
97761, 0.08695652173913, 0.69782608695652, -0.0375
97762, 0.08695652173913, 0.72391304347826, -0.01875
97763, 0.065217391304348, 0.72391304347826, -0.0375
97764, 0.043478260869565, 0.69782608695652, -0.0375
97765, 0.043478260869565, 0.72391304347826, -0.01875
97766, 0.021739130434783, 0.72391304347826, -0.0375
97767, 0.97826086956522, 0.77608695652174, -0.0375
97768, 0.95652173913044, 0.75, -0.0375
97769, 0.95652173913043, 0.77608695652174, -0.01875
97770, 0.93478260869565, 0.77608695652174, -0.0375
97771, 0.91304347826087, 0.75, -0.0375
97772, 0.91304347826087, 0.77608695652174, -0.01875
97773, 0.89130434782609, 0.77608695652174, -0.0375
97774, 0.8695652173913, 0.75, -0.0375
97775, 0.8695652173913, 0.77608695652174, -0.01875
97776, 0.84782608695652, 0.77608695652174, -0.0375
97777, 0.82608695652174, 0.75, -0.0375
97778, 0.82608695652174, 0.77608695652174, -0.01875
97779, 0.80434782608696, 0.77608695652174, -0.0375
97780, 0.78260869565217, 0.75, -0.0375
97781, 0.78260869565217, 0.77608695652174, -0.01875
97782, 0.76086956521739, 0.77608695652174, -0.0375
97783, 0.73913043478261, 0.75, -0.0375
97784, 0.73913043478261, 0.77608695652174, -0.01875
97785, 0.71739130434783, 0.77608695652174, -0.0375
97786, 0.69565217391304, 0.75, -0.0375
97787, 0.69565217391304, 0.77608695652174, -0.01875
97788, 0.67391304347826, 0.77608695652174, -0.0375
97789, 0.65217391304348, 0.75, -0.0375
97790, 0.65217391304348, 0.77608695652174, -0.01875
97791, 0.6304347826087, 0.77608695652174, -0.0375
97792, 0.60869565217391, 0.75, -0.0375
97793, 0.60869565217391, 0.77608695652174, -0.01875
97794, 0.58695652173913, 0.77608695652174, -0.0375
97795, 0.56521739130435, 0.75, -0.0375
97796, 0.56521739130435, 0.77608695652174, -0.01875
97797, 0.54347826086957, 0.77608695652174, -0.0375
97798, 0.52173913043478, 0.75, -0.0375
97799, 0.52173913043478, 0.77608695652174, -0.01875
97800, 0.5, 0.77608695652174, -0.0375
97801, 0.47826086956522, 0.75, -0.0375
97802, 0.47826086956522, 0.77608695652174, -0.01875
97803, 0.45652173913043, 0.77608695652174, -0.0375
97804, 0.43478260869565, 0.75, -0.0375
97805, 0.43478260869565, 0.77608695652174, -0.01875
97806, 0.41304347826087, 0.77608695652174, -0.0375
97807, 0.39130434782609, 0.75, -0.0375
97808, 0.39130434782609, 0.77608695652174, -0.01875
97809, 0.3695652173913, 0.77608695652174, -0.0375
97810, 0.34782608695652, 0.75, -0.0375
97811, 0.34782608695652, 0.77608695652174, -0.01875
97812, 0.32608695652174, 0.77608695652174, -0.0375
97813, 0.30434782608696, 0.75, -0.0375
97814, 0.30434782608696, 0.77608695652174, -0.01875
97815, 0.28260869565217, 0.77608695652174, -0.0375
97816, 0.26086956521739, 0.75, -0.0375
97817, 0.26086956521739, 0.77608695652174, -0.01875
97818, 0.23913043478261, 0.77608695652174, -0.0375
97819, 0.21739130434783, 0.75, -0.0375
97820, 0.21739130434783, 0.77608695652174, -0.01875
97821, 0.19565217391304, 0.77608695652174, -0.0375
97822, 0.17391304347826, 0.75, -0.0375
97823, 0.17391304347826, 0.77608695652174, -0.01875
97824, 0.15217391304348, 0.77608695652174, -0.0375
97825, 0.1304347826087, 0.75, -0.0375
97826, 0.1304347826087, 0.77608695652174, -0.01875
97827, 0.10869565217391, 0.77608695652174, -0.0375
97828, 0.08695652173913, 0.75, -0.0375
97829, 0.08695652173913, 0.77608695652174, -0.01875
97830, 0.065217391304348, 0.77608695652174, -0.0375
97831, 0.043478260869565, 0.75, -0.0375
97832, 0.043478260869565, 0.77608695652174, -0.01875
97833, 0.021739130434783, 0.77608695652174, -0.0375
97834, 0.97826086956522, 0.82826086956522, -0.0375
97835, 0.95652173913044, 0.80217391304348, -0.0375
97836, 0.95652173913043, 0.82826086956522, -0.01875
97837, 0.93478260869565, 0.82826086956522, -0.0375
97838, 0.91304347826087, 0.80217391304348, -0.0375
97839, 0.91304347826087, 0.82826086956522, -0.01875
97840, 0.89130434782609, 0.82826086956522, -0.0375
97841, 0.8695652173913, 0.80217391304348, -0.0375
97842, 0.8695652173913, 0.82826086956522, -0.01875
97843, 0.84782608695652, 0.82826086956522, -0.0375
97844, 0.82608695652174, 0.80217391304348, -0.0375
97845, 0.82608695652174, 0.82826086956522, -0.01875
97846, 0.80434782608696, 0.82826086956522, -0.0375
97847, 0.78260869565217, 0.80217391304348, -0.0375
97848, 0.78260869565217, 0.82826086956522, -0.01875
97849, 0.76086956521739, 0.82826086956522, -0.0375
97850, 0.73913043478261, 0.80217391304348, -0.0375
97851, 0.73913043478261, 0.82826086956522, -0.01875
97852, 0.71739130434783, 0.82826086956522, -0.0375
97853, 0.69565217391304, 0.80217391304348, -0.0375
97854, 0.69565217391304, 0.82826086956522, -0.01875
97855, 0.67391304347826, 0.82826086956522, -0.0375
97856, 0.65217391304348, 0.80217391304348, -0.0375
97857, 0.65217391304348, 0.82826086956522, -0.01875
97858, 0.6304347826087, 0.82826086956522, -0.0375
97859, 0.60869565217391, 0.80217391304348, -0.0375
97860, 0.60869565217391, 0.82826086956522, -0.01875
97861, 0.58695652173913, 0.82826086956522, -0.0375
97862, 0.56521739130435, 0.80217391304348, -0.0375
97863, 0.56521739130435, 0.82826086956522, -0.01875
97864, 0.54347826086957, 0.82826086956522, -0.0375
97865, 0.52173913043478, 0.80217391304348, -0.0375
97866, 0.52173913043478, 0.82826086956522, -0.01875
97867, 0.5, 0.82826086956522, -0.0375
97868, 0.47826086956522, 0.80217391304348, -0.0375
97869, 0.47826086956522, 0.82826086956522, -0.01875
97870, 0.45652173913043, 0.82826086956522, -0.0375
97871, 0.43478260869565, 0.80217391304348, -0.0375
97872, 0.43478260869565, 0.82826086956522, -0.01875
97873, 0.41304347826087, 0.82826086956522, -0.0375
97874, 0.39130434782609, 0.80217391304348, -0.0375
97875, 0.39130434782609, 0.82826086956522, -0.01875
97876, 0.3695652173913, 0.82826086956522, -0.0375
97877, 0.34782608695652, 0.80217391304348, -0.0375
97878, 0.34782608695652, 0.82826086956522, -0.01875
97879, 0.32608695652174, 0.82826086956522, -0.0375
97880, 0.30434782608696, 0.80217391304348, -0.0375
97881, 0.30434782608696, 0.82826086956522, -0.01875
97882, 0.28260869565217, 0.82826086956522, -0.0375
97883, 0.26086956521739, 0.80217391304348, -0.0375
97884, 0.26086956521739, 0.82826086956522, -0.01875
97885, 0.23913043478261, 0.82826086956522, -0.0375
97886, 0.21739130434783, 0.80217391304348, -0.0375
97887, 0.21739130434783, 0.82826086956522, -0.01875
97888, 0.19565217391304, 0.82826086956522, -0.0375
97889, 0.17391304347826, 0.80217391304348, -0.0375
97890, 0.17391304347826, 0.82826086956522, -0.01875
97891, 0.15217391304348, 0.82826086956522, -0.0375
97892, 0.1304347826087, 0.80217391304348, -0.0375
97893, 0.1304347826087, 0.82826086956522, -0.01875
97894, 0.10869565217391, 0.82826086956522, -0.0375
97895, 0.08695652173913, 0.80217391304348, -0.0375
97896, 0.08695652173913, 0.82826086956522, -0.01875
97897, 0.065217391304348, 0.82826086956522, -0.0375
97898, 0.043478260869565, 0.80217391304348, -0.0375
97899, 0.043478260869565, 0.82826086956522, -0.01875
97900, 0.021739130434783, 0.82826086956522, -0.0375
97901, 0.97826086956522, 0.8804347826087, -0.0375
97902, 0.95652173913044, 0.85434782608696, -0.0375
97903, 0.95652173913043, 0.88043478260869, -0.01875
97904, 0.93478260869565, 0.88043478260869, -0.0375
97905, 0.91304347826087, 0.85434782608696, -0.0375
97906, 0.91304347826087, 0.8804347826087, -0.01875
97907, 0.89130434782609, 0.8804347826087, -0.0375
97908, 0.8695652173913, 0.85434782608696, -0.0375
97909, 0.8695652173913, 0.8804347826087, -0.01875
97910, 0.84782608695652, 0.8804347826087, -0.0375
97911, 0.82608695652174, 0.85434782608696, -0.0375
97912, 0.82608695652174, 0.8804347826087, -0.01875
97913, 0.80434782608696, 0.8804347826087, -0.0375
97914, 0.78260869565217, 0.85434782608696, -0.0375
97915, 0.78260869565217, 0.8804347826087, -0.01875
97916, 0.76086956521739, 0.8804347826087, -0.0375
97917, 0.73913043478261, 0.85434782608696, -0.0375
97918, 0.73913043478261, 0.88043478260869, -0.01875
97919, 0.71739130434783, 0.8804347826087, -0.0375
97920, 0.69565217391304, 0.85434782608696, -0.0375
97921, 0.69565217391304, 0.8804347826087, -0.01875
97922, 0.67391304347826, 0.8804347826087, -0.0375
97923, 0.65217391304348, 0.85434782608696, -0.0375
97924, 0.65217391304348, 0.8804347826087, -0.01875
97925, 0.6304347826087, 0.8804347826087, -0.0375
97926, 0.60869565217391, 0.85434782608696, -0.0375
97927, 0.60869565217391, 0.8804347826087, -0.01875
97928, 0.58695652173913, 0.8804347826087, -0.0375
97929, 0.56521739130435, 0.85434782608696, -0.0375
97930, 0.56521739130435, 0.88043478260869, -0.01875
97931, 0.54347826086957, 0.8804347826087, -0.0375
97932, 0.52173913043478, 0.85434782608696, -0.0375
97933, 0.52173913043478, 0.8804347826087, -0.01875
97934, 0.5, 0.8804347826087, -0.0375
97935, 0.47826086956522, 0.85434782608696, -0.0375
97936, 0.47826086956522, 0.88043478260869, -0.01875
97937, 0.45652173913043, 0.8804347826087, -0.0375
97938, 0.43478260869565, 0.85434782608696, -0.0375
97939, 0.43478260869565, 0.8804347826087, -0.01875
97940, 0.41304347826087, 0.8804347826087, -0.0375
97941, 0.39130434782609, 0.85434782608696, -0.0375
97942, 0.39130434782609, 0.8804347826087, -0.01875
97943, 0.3695652173913, 0.8804347826087, -0.0375
97944, 0.34782608695652, 0.85434782608696, -0.0375
97945, 0.34782608695652, 0.8804347826087, -0.01875
97946, 0.32608695652174, 0.8804347826087, -0.0375
97947, 0.30434782608696, 0.85434782608696, -0.0375
97948, 0.30434782608696, 0.88043478260869, -0.01875
97949, 0.28260869565217, 0.8804347826087, -0.0375
97950, 0.26086956521739, 0.85434782608696, -0.0375
97951, 0.26086956521739, 0.8804347826087, -0.01875
97952, 0.23913043478261, 0.8804347826087, -0.0375
97953, 0.21739130434783, 0.85434782608696, -0.0375
97954, 0.21739130434783, 0.8804347826087, -0.01875
97955, 0.19565217391304, 0.8804347826087, -0.0375
97956, 0.17391304347826, 0.85434782608696, -0.0375
97957, 0.17391304347826, 0.8804347826087, -0.01875
97958, 0.15217391304348, 0.8804347826087, -0.0375
97959, 0.1304347826087, 0.85434782608696, -0.0375
97960, 0.1304347826087, 0.8804347826087, -0.01875
97961, 0.10869565217391, 0.8804347826087, -0.0375
97962, 0.08695652173913, 0.85434782608696, -0.0375
97963, 0.08695652173913, 0.8804347826087, -0.01875
97964, 0.065217391304348, 0.8804347826087, -0.0375
97965, 0.043478260869565, 0.85434782608696, -0.0375
97966, 0.043478260869565, 0.8804347826087, -0.01875
97967, 0.021739130434783, 0.8804347826087, -0.0375
97968, 0.97826086956522, 0.93260869565217, -0.0375
97969, 0.95652173913043, 0.90652173913043, -0.0375
97970, 0.95652173913043, 0.93260869565217, -0.01875
97971, 0.93478260869565, 0.93260869565217, -0.0375
97972, 0.91304347826087, 0.90652173913043, -0.0375
97973, 0.91304347826087, 0.93260869565217, -0.01875
97974, 0.89130434782609, 0.93260869565217, -0.0375
97975, 0.8695652173913, 0.90652173913043, -0.0375
97976, 0.8695652173913, 0.93260869565217, -0.01875
97977, 0.84782608695652, 0.93260869565217, -0.0375
97978, 0.82608695652174, 0.90652173913043, -0.0375
97979, 0.82608695652174, 0.93260869565217, -0.01875
97980, 0.80434782608696, 0.93260869565217, -0.0375
97981, 0.78260869565217, 0.90652173913043, -0.0375
97982, 0.78260869565217, 0.93260869565217, -0.01875
97983, 0.76086956521739, 0.93260869565217, -0.0375
97984, 0.73913043478261, 0.90652173913043, -0.0375
97985, 0.73913043478261, 0.93260869565217, -0.01875
97986, 0.71739130434783, 0.93260869565217, -0.0375
97987, 0.69565217391304, 0.90652173913043, -0.0375
97988, 0.69565217391304, 0.93260869565217, -0.01875
97989, 0.67391304347826, 0.93260869565217, -0.0375
97990, 0.65217391304348, 0.90652173913043, -0.0375
97991, 0.65217391304348, 0.93260869565217, -0.01875
97992, 0.6304347826087, 0.93260869565217, -0.0375
97993, 0.60869565217391, 0.90652173913043, -0.0375
97994, 0.60869565217391, 0.93260869565217, -0.01875
97995, 0.58695652173913, 0.93260869565217, -0.0375
97996, 0.56521739130435, 0.90652173913043, -0.0375
97997, 0.56521739130435, 0.93260869565217, -0.01875
97998, 0.54347826086956, 0.93260869565217, -0.0375
97999, 0.52173913043478, 0.90652173913043, -0.0375
98000, 0.52173913043478, 0.93260869565217, -0.01875
98001, 0.5, 0.93260869565217, -0.0375
98002, 0.47826086956522, 0.90652173913043, -0.0375
98003, 0.47826086956522, 0.93260869565217, -0.01875
98004, 0.45652173913043, 0.93260869565217, -0.0375
98005, 0.43478260869565, 0.90652173913043, -0.0375
98006, 0.43478260869565, 0.93260869565217, -0.01875
98007, 0.41304347826087, 0.93260869565217, -0.0375
98008, 0.39130434782609, 0.90652173913043, -0.0375
98009, 0.39130434782609, 0.93260869565217, -0.01875
98010, 0.3695652173913, 0.93260869565217, -0.0375
98011, 0.34782608695652, 0.90652173913043, -0.0375
98012, 0.34782608695652, 0.93260869565217, -0.01875
98013, 0.32608695652174, 0.93260869565217, -0.0375
98014, 0.30434782608696, 0.90652173913043, -0.0375
98015, 0.30434782608696, 0.93260869565217, -0.01875
98016, 0.28260869565217, 0.93260869565217, -0.0375
98017, 0.26086956521739, 0.90652173913043, -0.0375
98018, 0.26086956521739, 0.93260869565217, -0.01875
98019, 0.23913043478261, 0.93260869565217, -0.0375
98020, 0.21739130434783, 0.90652173913043, -0.0375
98021, 0.21739130434783, 0.93260869565217, -0.01875
98022, 0.19565217391304, 0.93260869565217, -0.0375
98023, 0.17391304347826, 0.90652173913043, -0.0375
98024, 0.17391304347826, 0.93260869565217, -0.01875
98025, 0.15217391304348, 0.93260869565217, -0.0375
98026, 0.1304347826087, 0.90652173913043, -0.0375
98027, 0.1304347826087, 0.93260869565217, -0.01875
98028, 0.10869565217391, 0.93260869565217, -0.0375
98029, 0.08695652173913, 0.90652173913043, -0.0375
98030, 0.08695652173913, 0.93260869565217, -0.01875
98031, 0.065217391304348, 0.93260869565217, -0.0375
98032, 0.043478260869565, 0.90652173913043, -0.0375
98033, 0.043478260869565, 0.93260869565217, -0.01875
98034, 0.021739130434783, 0.93260869565217, -0.0375
98035, 0.97826086956522, 0.98478260869565, -0.0375
98036, 0.95652173913043, 0.95869565217391, -0.0375
98037, 0.95652173913043, 0.98478260869565, -0.01875
98038, 0.93478260869565, 0.98478260869565, -0.0375
98039, 0.91304347826087, 0.95869565217391, -0.0375
98040, 0.91304347826087, 0.98478260869565, -0.01875
98041, 0.89130434782609, 0.98478260869565, -0.0375
98042, 0.8695652173913, 0.95869565217391, -0.0375
98043, 0.8695652173913, 0.98478260869565, -0.01875
98044, 0.84782608695652, 0.98478260869565, -0.0375
98045, 0.82608695652174, 0.95869565217391, -0.0375
98046, 0.82608695652174, 0.98478260869565, -0.01875
