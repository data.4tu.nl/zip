17533, 1.5913043478261, 1.4666666666667, 0
17534, 1.5695652173913, 1.5166666666667, 0
17535, 1.5913043478261, 1.5, 0
17536, 1.5913043478261, 1.5333333333333, 0
17537, 1.6130434782609, 1.4833333333333, 0
17538, 1.6347826086957, 1.4666666666667, 0
17539, 1.6130434782609, 1.5166666666667, 0
17540, 1.6347826086957, 1.5, 0
17541, 1.6347826086957, 1.5333333333333, 0
17542, 1.6565217391304, 1.4833333333333, 0
17543, 1.6782608695652, 1.4666666666667, 0
17544, 1.6565217391304, 1.5166666666667, 0
17545, 1.6782608695652, 1.5, 0
17546, 1.6782608695652, 1.5333333333333, 0
17547, 1.7, 1.4833333333333, 0
17548, 1.7217391304348, 1.4666666666667, 0
17549, 1.7, 1.5166666666667, 0
17550, 1.7217391304348, 1.5, 0
17551, 1.7217391304348, 1.5333333333333, 0
17552, 1.7434782608696, 1.4833333333333, 0
17553, 1.7652173913043, 1.4666666666667, 0
17554, 1.7434782608696, 1.5166666666667, 0
17555, 1.7652173913043, 1.5, 0
17556, 1.7652173913043, 1.5333333333333, 0
17557, 1.7869565217391, 1.4833333333333, 0
17558, 1.8086956521739, 1.4666666666667, 0
17559, 1.7869565217391, 1.5166666666667, 0
17560, 1.8086956521739, 1.5, 0
17561, 1.8086956521739, 1.5333333333333, 0
17562, 1.8304347826087, 1.4833333333333, 0
17563, 1.8521739130435, 1.4666666666667, 0
17564, 1.8304347826087, 1.5166666666667, 0
17565, 1.8521739130435, 1.5, 0
17566, 1.8521739130435, 1.5333333333333, 0
17567, 1.8739130434783, 1.4833333333333, 0
17568, 1.895652173913, 1.4666666666667, 0
17569, 1.8739130434783, 1.5166666666667, 0
17570, 1.895652173913, 1.5, 0
17571, 1.895652173913, 1.5333333333333, 0
17572, 1.9173913043478, 1.4833333333333, 0
17573, 1.9391304347826, 1.4666666666667, 0
17574, 1.9173913043478, 1.5166666666667, 0
17575, 1.9391304347826, 1.5, 0
17576, 1.9391304347826, 1.5333333333333, 0
17577, 1.9608695652174, 1.4833333333333, 0
17578, 1.9826086956522, 1.4666666666667, 0
17579, 1.9608695652174, 1.5166666666667, 0
17580, 1.9826086956522, 1.5, 0
17581, 1.9826086956522, 1.5333333333333, 0
17582, 2.004347826087, 1.4833333333333, 0
17583, 2.0260869565217, 1.4666666666667, 0
17584, 2.004347826087, 1.5166666666667, 0
17585, 2.0260869565217, 1.5, 0
17586, 2.0260869565217, 1.5333333333333, 0
17587, 2.0478260869565, 1.4833333333333, 0
17588, 2.0695652173913, 1.4666666666667, 0
17589, 2.0478260869565, 1.5166666666667, 0
17590, 2.0695652173913, 1.5, 0
17591, 2.0695652173913, 1.5333333333333, 0
17592, 2.0913043478261, 1.4833333333333, 0
17593, 2.1130434782609, 1.4666666666667, 0
17594, 2.0913043478261, 1.5166666666667, 0
17595, 2.1130434782609, 1.5, 0
17596, 2.1130434782609, 1.5333333333333, 0
17597, 2.1347826086957, 1.4833333333333, 0
17598, 2.1565217391304, 1.4666666666667, 0
17599, 2.1347826086957, 1.5166666666667, 0
17600, 2.1565217391304, 1.5, 0
17601, 2.1565217391304, 1.5333333333333, 0
17602, 2.1782608695652, 1.4833333333333, 0
17603, 2.1782608695652, 1.5166666666667, 0
17604, 1.2434782608696, 1.55, 0.44444444444444
17605, 1.2434782608696, 1.55, 0.38888888888889
17606, 1.2434782608696, 1.55, 0.33333333333333
17607, 1.2434782608696, 1.55, 0.27777777777778
17608, 1.2434782608696, 1.55, 0.22222222222222
17609, 1.2434782608696, 1.55, 0.16666666666667
17610, 1.2434782608696, 1.55, 0.11111111111111
17611, 1.2434782608696, 1.55, 0.055555555555556
17612, 1.2869565217391, 1.55, 0.44444444444444
17613, 1.2869565217391, 1.55, 0.38888888888889
17614, 1.2869565217391, 1.55, 0.33333333333333
17615, 1.2869565217391, 1.55, 0.27777777777778
17616, 1.2869565217391, 1.55, 0.22222222222222
17617, 1.2869565217391, 1.55, 0.16666666666667
17618, 1.2869565217391, 1.55, 0.11111111111111
17619, 1.2869565217391, 1.55, 0.055555555555556
17620, 1.3304347826087, 1.55, 0.44444444444444
17621, 1.3304347826087, 1.55, 0.38888888888889
17622, 1.3304347826087, 1.55, 0.33333333333333
17623, 1.3304347826087, 1.55, 0.27777777777778
17624, 1.3304347826087, 1.55, 0.22222222222222
17625, 1.3304347826087, 1.55, 0.16666666666667
17626, 1.3304347826087, 1.55, 0.11111111111111
17627, 1.3304347826087, 1.55, 0.055555555555556
17628, 1.3739130434783, 1.55, 0.44444444444444
17629, 1.3739130434783, 1.55, 0.38888888888889
17630, 1.3739130434783, 1.55, 0.33333333333333
17631, 1.3739130434783, 1.55, 0.27777777777778
17632, 1.3739130434783, 1.55, 0.22222222222222
17633, 1.3739130434783, 1.55, 0.16666666666667
17634, 1.3739130434783, 1.55, 0.11111111111111
17635, 1.3739130434783, 1.55, 0.055555555555556
17636, 1.4173913043478, 1.55, 0.44444444444444
17637, 1.4173913043478, 1.55, 0.38888888888889
17638, 1.4173913043478, 1.55, 0.33333333333333
17639, 1.4173913043478, 1.55, 0.27777777777778
17640, 1.4173913043478, 1.55, 0.22222222222222
17641, 1.4173913043478, 1.55, 0.16666666666667
17642, 1.4173913043478, 1.55, 0.11111111111111
17643, 1.4173913043478, 1.55, 0.055555555555556
17644, 1.4608695652174, 1.55, 0.44444444444444
17645, 1.4608695652174, 1.55, 0.38888888888889
17646, 1.4608695652174, 1.55, 0.33333333333333
17647, 1.4608695652174, 1.55, 0.27777777777778
17648, 1.4608695652174, 1.55, 0.22222222222222
17649, 1.4608695652174, 1.55, 0.16666666666667
17650, 1.4608695652174, 1.55, 0.11111111111111
17651, 1.4608695652174, 1.55, 0.055555555555556
17652, 1.504347826087, 1.55, 0.44444444444444
17653, 1.504347826087, 1.55, 0.38888888888889
17654, 1.504347826087, 1.55, 0.33333333333333
17655, 1.504347826087, 1.55, 0.27777777777778
17656, 1.504347826087, 1.55, 0.22222222222222
17657, 1.504347826087, 1.55, 0.16666666666667
17658, 1.504347826087, 1.55, 0.11111111111111
17659, 1.504347826087, 1.55, 0.055555555555556
17660, 1.5478260869565, 1.55, 0.44444444444444
17661, 1.5478260869565, 1.55, 0.38888888888889
17662, 1.5478260869565, 1.55, 0.33333333333333
17663, 1.5478260869565, 1.55, 0.27777777777778
17664, 1.5478260869565, 1.55, 0.22222222222222
17665, 1.5478260869565, 1.55, 0.16666666666667
17666, 1.5478260869565, 1.55, 0.11111111111111
17667, 1.5478260869565, 1.55, 0.055555555555556
17668, 1.5913043478261, 1.55, 0.44444444444444
17669, 1.5913043478261, 1.55, 0.38888888888889
17670, 1.5913043478261, 1.55, 0.33333333333333
17671, 1.5913043478261, 1.55, 0.27777777777778
17672, 1.5913043478261, 1.55, 0.22222222222222
17673, 1.5913043478261, 1.55, 0.16666666666667
17674, 1.5913043478261, 1.55, 0.11111111111111
17675, 1.5913043478261, 1.55, 0.055555555555556
17676, 1.6347826086957, 1.55, 0.44444444444444
17677, 1.6347826086957, 1.55, 0.38888888888889
17678, 1.6347826086957, 1.55, 0.33333333333333
17679, 1.6347826086957, 1.55, 0.27777777777778
17680, 1.6347826086957, 1.55, 0.22222222222222
17681, 1.6347826086957, 1.55, 0.16666666666667
17682, 1.6347826086957, 1.55, 0.11111111111111
17683, 1.6347826086957, 1.55, 0.055555555555556
17684, 1.6782608695652, 1.55, 0.44444444444444
17685, 1.6782608695652, 1.55, 0.38888888888889
17686, 1.6782608695652, 1.55, 0.33333333333333
17687, 1.6782608695652, 1.55, 0.27777777777778
17688, 1.6782608695652, 1.55, 0.22222222222222
17689, 1.6782608695652, 1.55, 0.16666666666667
17690, 1.6782608695652, 1.55, 0.11111111111111
17691, 1.6782608695652, 1.55, 0.055555555555556
17692, 1.7217391304348, 1.55, 0.44444444444444
17693, 1.7217391304348, 1.55, 0.38888888888889
17694, 1.7217391304348, 1.55, 0.33333333333333
17695, 1.7217391304348, 1.55, 0.27777777777778
17696, 1.7217391304348, 1.55, 0.22222222222222
17697, 1.7217391304348, 1.55, 0.16666666666667
17698, 1.7217391304348, 1.55, 0.11111111111111
17699, 1.7217391304348, 1.55, 0.055555555555556
17700, 1.7652173913043, 1.55, 0.44444444444444
17701, 1.7652173913043, 1.55, 0.38888888888889
17702, 1.7652173913043, 1.55, 0.33333333333333
17703, 1.7652173913043, 1.55, 0.27777777777778
17704, 1.7652173913043, 1.55, 0.22222222222222
17705, 1.7652173913043, 1.55, 0.16666666666667
17706, 1.7652173913043, 1.55, 0.11111111111111
17707, 1.7652173913043, 1.55, 0.055555555555556
17708, 1.8086956521739, 1.55, 0.44444444444444
17709, 1.8086956521739, 1.55, 0.38888888888889
17710, 1.8086956521739, 1.55, 0.33333333333333
17711, 1.8086956521739, 1.55, 0.27777777777778
17712, 1.8086956521739, 1.55, 0.22222222222222
17713, 1.8086956521739, 1.55, 0.16666666666667
17714, 1.8086956521739, 1.55, 0.11111111111111
17715, 1.8086956521739, 1.55, 0.055555555555556
17716, 1.8521739130435, 1.55, 0.44444444444444
17717, 1.8521739130435, 1.55, 0.38888888888889
17718, 1.8521739130435, 1.55, 0.33333333333333
17719, 1.8521739130435, 1.55, 0.27777777777778
17720, 1.8521739130435, 1.55, 0.22222222222222
17721, 1.8521739130435, 1.55, 0.16666666666667
17722, 1.8521739130435, 1.55, 0.11111111111111
17723, 1.8521739130435, 1.55, 0.055555555555556
17724, 1.895652173913, 1.55, 0.44444444444444
17725, 1.895652173913, 1.55, 0.38888888888889
17726, 1.895652173913, 1.55, 0.33333333333333
17727, 1.895652173913, 1.55, 0.27777777777778
17728, 1.895652173913, 1.55, 0.22222222222222
17729, 1.895652173913, 1.55, 0.16666666666667
17730, 1.895652173913, 1.55, 0.11111111111111
17731, 1.895652173913, 1.55, 0.055555555555556
17732, 1.9391304347826, 1.55, 0.44444444444444
17733, 1.9391304347826, 1.55, 0.38888888888889
17734, 1.9391304347826, 1.55, 0.33333333333333
17735, 1.9391304347826, 1.55, 0.27777777777778
17736, 1.9391304347826, 1.55, 0.22222222222222
17737, 1.9391304347826, 1.55, 0.16666666666667
17738, 1.9391304347826, 1.55, 0.11111111111111
17739, 1.9391304347826, 1.55, 0.055555555555556
17740, 1.9826086956522, 1.55, 0.44444444444444
17741, 1.9826086956522, 1.55, 0.38888888888889
17742, 1.9826086956522, 1.55, 0.33333333333333
17743, 1.9826086956522, 1.55, 0.27777777777778
17744, 1.9826086956522, 1.55, 0.22222222222222
17745, 1.9826086956522, 1.55, 0.16666666666667
17746, 1.9826086956522, 1.55, 0.11111111111111
17747, 1.9826086956522, 1.55, 0.055555555555556
17748, 2.0260869565217, 1.55, 0.44444444444444
17749, 2.0260869565217, 1.55, 0.38888888888889
17750, 2.0260869565217, 1.55, 0.33333333333333
17751, 2.0260869565217, 1.55, 0.27777777777778
17752, 2.0260869565217, 1.55, 0.22222222222222
17753, 2.0260869565217, 1.55, 0.16666666666667
17754, 2.0260869565217, 1.55, 0.11111111111111
17755, 2.0260869565217, 1.55, 0.055555555555556
17756, 2.0695652173913, 1.55, 0.44444444444444
17757, 2.0695652173913, 1.55, 0.38888888888889
17758, 2.0695652173913, 1.55, 0.33333333333333
17759, 2.0695652173913, 1.55, 0.27777777777778
17760, 2.0695652173913, 1.55, 0.22222222222222
17761, 2.0695652173913, 1.55, 0.16666666666667
17762, 2.0695652173913, 1.55, 0.11111111111111
17763, 2.0695652173913, 1.55, 0.055555555555556
17764, 2.1130434782609, 1.55, 0.44444444444444
17765, 2.1130434782609, 1.55, 0.38888888888889
17766, 2.1130434782609, 1.55, 0.33333333333333
17767, 2.1130434782609, 1.55, 0.27777777777778
17768, 2.1130434782609, 1.55, 0.22222222222222
17769, 2.1130434782609, 1.55, 0.16666666666667
17770, 2.1130434782609, 1.55, 0.11111111111111
17771, 2.1130434782609, 1.55, 0.055555555555556
17772, 2.1565217391304, 1.55, 0.44444444444444
17773, 2.1565217391304, 1.55, 0.38888888888889
17774, 2.1565217391304, 1.55, 0.33333333333333
17775, 2.1565217391304, 1.55, 0.27777777777778
17776, 2.1565217391304, 1.55, 0.22222222222222
17777, 2.1565217391304, 1.55, 0.16666666666667
17778, 2.1565217391304, 1.55, 0.11111111111111
17779, 2.1565217391304, 1.55, 0.055555555555556
17780, 1.2434782608696, 1.55, 0.47222222222222
17781, 1.2217391304348, 1.55, 0.44444444444444
17782, 1.2434782608696, 1.55, 0.41666666666667
17783, 1.2217391304348, 1.55, 0.38888888888889
17784, 1.2434782608696, 1.55, 0.36111111111111
17785, 1.2217391304348, 1.55, 0.33333333333333
17786, 1.2434782608696, 1.55, 0.30555555555556
17787, 1.2217391304348, 1.55, 0.27777777777778
17788, 1.2434782608696, 1.55, 0.25
17789, 1.2217391304348, 1.55, 0.22222222222222
17790, 1.2434782608696, 1.55, 0.19444444444444
17791, 1.2217391304348, 1.55, 0.16666666666667
17792, 1.2434782608696, 1.55, 0.13888888888889
17793, 1.2217391304348, 1.55, 0.11111111111111
17794, 1.2434782608696, 1.55, 0.083333333333333
17795, 1.2217391304348, 1.55, 0.055555555555556
17796, 1.2434782608696, 1.55, 0.027777777777778
17797, 1.2869565217391, 1.55, 0.47222222222222
17798, 1.2652173913043, 1.55, 0.44444444444444
17799, 1.2869565217391, 1.55, 0.41666666666667
17800, 1.2652173913043, 1.55, 0.38888888888889
17801, 1.2869565217391, 1.55, 0.36111111111111
17802, 1.2652173913043, 1.55, 0.33333333333333
17803, 1.2869565217391, 1.55, 0.30555555555556
17804, 1.2652173913043, 1.55, 0.27777777777778
17805, 1.2869565217391, 1.55, 0.25
17806, 1.2652173913043, 1.55, 0.22222222222222
17807, 1.2869565217391, 1.55, 0.19444444444444
17808, 1.2652173913043, 1.55, 0.16666666666667
17809, 1.2869565217391, 1.55, 0.13888888888889
17810, 1.2652173913043, 1.55, 0.11111111111111
17811, 1.2869565217391, 1.55, 0.083333333333333
17812, 1.2652173913043, 1.55, 0.055555555555556
17813, 1.2869565217391, 1.55, 0.027777777777778
17814, 1.3304347826087, 1.55, 0.47222222222222
17815, 1.3086956521739, 1.55, 0.44444444444444
17816, 1.3304347826087, 1.55, 0.41666666666667
17817, 1.3086956521739, 1.55, 0.38888888888889
17818, 1.3304347826087, 1.55, 0.36111111111111
17819, 1.3086956521739, 1.55, 0.33333333333333
17820, 1.3304347826087, 1.55, 0.30555555555556
17821, 1.3086956521739, 1.55, 0.27777777777778
17822, 1.3304347826087, 1.55, 0.25
17823, 1.3086956521739, 1.55, 0.22222222222222
17824, 1.3304347826087, 1.55, 0.19444444444444
17825, 1.3086956521739, 1.55, 0.16666666666667
17826, 1.3304347826087, 1.55, 0.13888888888889
17827, 1.3086956521739, 1.55, 0.11111111111111
17828, 1.3304347826087, 1.55, 0.083333333333333
17829, 1.3086956521739, 1.55, 0.055555555555556
17830, 1.3304347826087, 1.55, 0.027777777777778
17831, 1.3739130434783, 1.55, 0.47222222222222
17832, 1.3521739130435, 1.55, 0.44444444444444
17833, 1.3739130434783, 1.55, 0.41666666666667
17834, 1.3521739130435, 1.55, 0.38888888888889
17835, 1.3739130434783, 1.55, 0.36111111111111
17836, 1.3521739130435, 1.55, 0.33333333333333
17837, 1.3739130434783, 1.55, 0.30555555555556
17838, 1.3521739130435, 1.55, 0.27777777777778
17839, 1.3739130434783, 1.55, 0.25
17840, 1.3521739130435, 1.55, 0.22222222222222
17841, 1.3739130434783, 1.55, 0.19444444444444
17842, 1.3521739130435, 1.55, 0.16666666666667
17843, 1.3739130434783, 1.55, 0.13888888888889
17844, 1.3521739130435, 1.55, 0.11111111111111
17845, 1.3739130434783, 1.55, 0.083333333333333
17846, 1.3521739130435, 1.55, 0.055555555555556
17847, 1.3739130434783, 1.55, 0.027777777777778
17848, 1.4173913043478, 1.55, 0.47222222222222
17849, 1.395652173913, 1.55, 0.44444444444444
17850, 1.4173913043478, 1.55, 0.41666666666667
17851, 1.395652173913, 1.55, 0.38888888888889
17852, 1.4173913043478, 1.55, 0.36111111111111
17853, 1.395652173913, 1.55, 0.33333333333333
17854, 1.4173913043478, 1.55, 0.30555555555556
17855, 1.395652173913, 1.55, 0.27777777777778
17856, 1.4173913043478, 1.55, 0.25
17857, 1.395652173913, 1.55, 0.22222222222222
17858, 1.4173913043478, 1.55, 0.19444444444444
17859, 1.395652173913, 1.55, 0.16666666666667
17860, 1.4173913043478, 1.55, 0.13888888888889
17861, 1.395652173913, 1.55, 0.11111111111111
17862, 1.4173913043478, 1.55, 0.083333333333333
17863, 1.395652173913, 1.55, 0.055555555555556
17864, 1.4173913043478, 1.55, 0.027777777777778
17865, 1.4608695652174, 1.55, 0.47222222222222
17866, 1.4391304347826, 1.55, 0.44444444444444
17867, 1.4608695652174, 1.55, 0.41666666666667
17868, 1.4391304347826, 1.55, 0.38888888888889
17869, 1.4608695652174, 1.55, 0.36111111111111
17870, 1.4391304347826, 1.55, 0.33333333333333
17871, 1.4608695652174, 1.55, 0.30555555555556
17872, 1.4391304347826, 1.55, 0.27777777777778
17873, 1.4608695652174, 1.55, 0.25
17874, 1.4391304347826, 1.55, 0.22222222222222
17875, 1.4608695652174, 1.55, 0.19444444444444
17876, 1.4391304347826, 1.55, 0.16666666666667
17877, 1.4608695652174, 1.55, 0.13888888888889
17878, 1.4391304347826, 1.55, 0.11111111111111
17879, 1.4608695652174, 1.55, 0.083333333333333
17880, 1.4391304347826, 1.55, 0.055555555555556
17881, 1.4608695652174, 1.55, 0.027777777777778
17882, 1.504347826087, 1.55, 0.47222222222222
17883, 1.4826086956522, 1.55, 0.44444444444444
17884, 1.504347826087, 1.55, 0.41666666666667
17885, 1.4826086956522, 1.55, 0.38888888888889
17886, 1.504347826087, 1.55, 0.36111111111111
17887, 1.4826086956522, 1.55, 0.33333333333333
17888, 1.504347826087, 1.55, 0.30555555555556
17889, 1.4826086956522, 1.55, 0.27777777777778
17890, 1.504347826087, 1.55, 0.25
17891, 1.4826086956522, 1.55, 0.22222222222222
17892, 1.504347826087, 1.55, 0.19444444444444
17893, 1.4826086956522, 1.55, 0.16666666666667
17894, 1.504347826087, 1.55, 0.13888888888889
17895, 1.4826086956522, 1.55, 0.11111111111111
17896, 1.504347826087, 1.55, 0.083333333333333
17897, 1.4826086956522, 1.55, 0.055555555555556
17898, 1.504347826087, 1.55, 0.027777777777778
17899, 1.5478260869565, 1.55, 0.47222222222222
17900, 1.5260869565217, 1.55, 0.44444444444444
17901, 1.5478260869565, 1.55, 0.41666666666667
17902, 1.5260869565217, 1.55, 0.38888888888889
17903, 1.5478260869565, 1.55, 0.36111111111111
17904, 1.5260869565217, 1.55, 0.33333333333333
17905, 1.5478260869565, 1.55, 0.30555555555556
17906, 1.5260869565217, 1.55, 0.27777777777778
17907, 1.5478260869565, 1.55, 0.25
17908, 1.5260869565217, 1.55, 0.22222222222222
17909, 1.5478260869565, 1.55, 0.19444444444444
17910, 1.5260869565217, 1.55, 0.16666666666667
17911, 1.5478260869565, 1.55, 0.13888888888889
17912, 1.5260869565217, 1.55, 0.11111111111111
17913, 1.5478260869565, 1.55, 0.083333333333333
17914, 1.5260869565217, 1.55, 0.055555555555556
17915, 1.5478260869565, 1.55, 0.027777777777778
17916, 1.5913043478261, 1.55, 0.47222222222222
17917, 1.5695652173913, 1.55, 0.44444444444444
17918, 1.5913043478261, 1.55, 0.41666666666667
17919, 1.5695652173913, 1.55, 0.38888888888889
17920, 1.5913043478261, 1.55, 0.36111111111111
17921, 1.5695652173913, 1.55, 0.33333333333333
17922, 1.5913043478261, 1.55, 0.30555555555556
17923, 1.5695652173913, 1.55, 0.27777777777778
17924, 1.5913043478261, 1.55, 0.25
17925, 1.5695652173913, 1.55, 0.22222222222222
17926, 1.5913043478261, 1.55, 0.19444444444444
17927, 1.5695652173913, 1.55, 0.16666666666667
17928, 1.5913043478261, 1.55, 0.13888888888889
17929, 1.5695652173913, 1.55, 0.11111111111111
17930, 1.5913043478261, 1.55, 0.083333333333333
17931, 1.5695652173913, 1.55, 0.055555555555556
17932, 1.5913043478261, 1.55, 0.027777777777778
17933, 1.6347826086957, 1.55, 0.47222222222222
17934, 1.6130434782609, 1.55, 0.44444444444444
17935, 1.6347826086957, 1.55, 0.41666666666667
17936, 1.6130434782609, 1.55, 0.38888888888889
17937, 1.6347826086957, 1.55, 0.36111111111111
17938, 1.6130434782609, 1.55, 0.33333333333333
17939, 1.6347826086957, 1.55, 0.30555555555556
17940, 1.6130434782609, 1.55, 0.27777777777778
17941, 1.6347826086957, 1.55, 0.25
17942, 1.6130434782609, 1.55, 0.22222222222222
17943, 1.6347826086957, 1.55, 0.19444444444444
17944, 1.6130434782609, 1.55, 0.16666666666667
17945, 1.6347826086957, 1.55, 0.13888888888889
17946, 1.6130434782609, 1.55, 0.11111111111111
17947, 1.6347826086957, 1.55, 0.083333333333333
17948, 1.6130434782609, 1.55, 0.055555555555556
17949, 1.6347826086957, 1.55, 0.027777777777778
17950, 1.6782608695652, 1.55, 0.47222222222222
17951, 1.6565217391304, 1.55, 0.44444444444444
17952, 1.6782608695652, 1.55, 0.41666666666667
17953, 1.6565217391304, 1.55, 0.38888888888889
17954, 1.6782608695652, 1.55, 0.36111111111111
17955, 1.6565217391304, 1.55, 0.33333333333333
17956, 1.6782608695652, 1.55, 0.30555555555556
17957, 1.6565217391304, 1.55, 0.27777777777778
17958, 1.6782608695652, 1.55, 0.25
17959, 1.6565217391304, 1.55, 0.22222222222222
17960, 1.6782608695652, 1.55, 0.19444444444444
17961, 1.6565217391304, 1.55, 0.16666666666667
17962, 1.6782608695652, 1.55, 0.13888888888889
17963, 1.6565217391304, 1.55, 0.11111111111111
17964, 1.6782608695652, 1.55, 0.083333333333333
17965, 1.6565217391304, 1.55, 0.055555555555556
17966, 1.6782608695652, 1.55, 0.027777777777778
17967, 1.7217391304348, 1.55, 0.47222222222222
17968, 1.7, 1.55, 0.44444444444444
17969, 1.7217391304348, 1.55, 0.41666666666667
17970, 1.7, 1.55, 0.38888888888889
17971, 1.7217391304348, 1.55, 0.36111111111111
17972, 1.7, 1.55, 0.33333333333333
17973, 1.7217391304348, 1.55, 0.30555555555556
17974, 1.7, 1.55, 0.27777777777778
17975, 1.7217391304348, 1.55, 0.25
17976, 1.7, 1.55, 0.22222222222222
17977, 1.7217391304348, 1.55, 0.19444444444444
17978, 1.7, 1.55, 0.16666666666667
17979, 1.7217391304348, 1.55, 0.13888888888889
17980, 1.7, 1.55, 0.11111111111111
17981, 1.7217391304348, 1.55, 0.083333333333333
17982, 1.7, 1.55, 0.055555555555556
17983, 1.7217391304348, 1.55, 0.027777777777778
17984, 1.7652173913043, 1.55, 0.47222222222222
17985, 1.7434782608696, 1.55, 0.44444444444444
17986, 1.7652173913043, 1.55, 0.41666666666667
17987, 1.7434782608696, 1.55, 0.38888888888889
17988, 1.7652173913043, 1.55, 0.36111111111111
17989, 1.7434782608696, 1.55, 0.33333333333333
17990, 1.7652173913043, 1.55, 0.30555555555556
17991, 1.7434782608696, 1.55, 0.27777777777778
17992, 1.7652173913043, 1.55, 0.25
17993, 1.7434782608696, 1.55, 0.22222222222222
17994, 1.7652173913043, 1.55, 0.19444444444444
17995, 1.7434782608696, 1.55, 0.16666666666667
17996, 1.7652173913043, 1.55, 0.13888888888889
17997, 1.7434782608696, 1.55, 0.11111111111111
17998, 1.7652173913043, 1.55, 0.083333333333333
17999, 1.7434782608696, 1.55, 0.055555555555556
18000, 1.7652173913043, 1.55, 0.027777777777778
18001, 1.8086956521739, 1.55, 0.47222222222222
18002, 1.7869565217391, 1.55, 0.44444444444444
18003, 1.8086956521739, 1.55, 0.41666666666667
18004, 1.7869565217391, 1.55, 0.38888888888889
18005, 1.8086956521739, 1.55, 0.36111111111111
18006, 1.7869565217391, 1.55, 0.33333333333333
18007, 1.8086956521739, 1.55, 0.30555555555556
18008, 1.7869565217391, 1.55, 0.27777777777778
18009, 1.8086956521739, 1.55, 0.25
18010, 1.7869565217391, 1.55, 0.22222222222222
18011, 1.8086956521739, 1.55, 0.19444444444444
18012, 1.7869565217391, 1.55, 0.16666666666667
18013, 1.8086956521739, 1.55, 0.13888888888889
18014, 1.7869565217391, 1.55, 0.11111111111111
18015, 1.8086956521739, 1.55, 0.083333333333333
18016, 1.7869565217391, 1.55, 0.055555555555556
18017, 1.8086956521739, 1.55, 0.027777777777778
18018, 1.8521739130435, 1.55, 0.47222222222222
18019, 1.8304347826087, 1.55, 0.44444444444444
18020, 1.8521739130435, 1.55, 0.41666666666667
18021, 1.8304347826087, 1.55, 0.38888888888889
18022, 1.8521739130435, 1.55, 0.36111111111111
18023, 1.8304347826087, 1.55, 0.33333333333333
18024, 1.8521739130435, 1.55, 0.30555555555556
18025, 1.8304347826087, 1.55, 0.27777777777778
18026, 1.8521739130435, 1.55, 0.25
18027, 1.8304347826087, 1.55, 0.22222222222222
18028, 1.8521739130435, 1.55, 0.19444444444444
18029, 1.8304347826087, 1.55, 0.16666666666667
18030, 1.8521739130435, 1.55, 0.13888888888889
18031, 1.8304347826087, 1.55, 0.11111111111111
18032, 1.8521739130435, 1.55, 0.083333333333333
18033, 1.8304347826087, 1.55, 0.055555555555556
18034, 1.8521739130435, 1.55, 0.027777777777778
18035, 1.895652173913, 1.55, 0.47222222222222
18036, 1.8739130434783, 1.55, 0.44444444444444
18037, 1.895652173913, 1.55, 0.41666666666667
18038, 1.8739130434783, 1.55, 0.38888888888889
18039, 1.895652173913, 1.55, 0.36111111111111
18040, 1.8739130434783, 1.55, 0.33333333333333
18041, 1.895652173913, 1.55, 0.30555555555556
18042, 1.8739130434783, 1.55, 0.27777777777778
18043, 1.895652173913, 1.55, 0.25
18044, 1.8739130434783, 1.55, 0.22222222222222
18045, 1.895652173913, 1.55, 0.19444444444444
18046, 1.8739130434783, 1.55, 0.16666666666667
18047, 1.895652173913, 1.55, 0.13888888888889
18048, 1.8739130434783, 1.55, 0.11111111111111
18049, 1.895652173913, 1.55, 0.083333333333333
18050, 1.8739130434783, 1.55, 0.055555555555556
18051, 1.895652173913, 1.55, 0.027777777777778
18052, 1.9391304347826, 1.55, 0.47222222222222
18053, 1.9173913043478, 1.55, 0.44444444444444
18054, 1.9391304347826, 1.55, 0.41666666666667
18055, 1.9173913043478, 1.55, 0.38888888888889
18056, 1.9391304347826, 1.55, 0.36111111111111
18057, 1.9173913043478, 1.55, 0.33333333333333
18058, 1.9391304347826, 1.55, 0.30555555555556
18059, 1.9173913043478, 1.55, 0.27777777777778
18060, 1.9391304347826, 1.55, 0.25
18061, 1.9173913043478, 1.55, 0.22222222222222
18062, 1.9391304347826, 1.55, 0.19444444444444
18063, 1.9173913043478, 1.55, 0.16666666666667
18064, 1.9391304347826, 1.55, 0.13888888888889
18065, 1.9173913043478, 1.55, 0.11111111111111
18066, 1.9391304347826, 1.55, 0.083333333333333
18067, 1.9173913043478, 1.55, 0.055555555555556
18068, 1.9391304347826, 1.55, 0.027777777777778
18069, 1.9826086956522, 1.55, 0.47222222222222
18070, 1.9608695652174, 1.55, 0.44444444444444
18071, 1.9826086956522, 1.55, 0.41666666666667
18072, 1.9608695652174, 1.55, 0.38888888888889
18073, 1.9826086956522, 1.55, 0.36111111111111
18074, 1.9608695652174, 1.55, 0.33333333333333
18075, 1.9826086956522, 1.55, 0.30555555555556
18076, 1.9608695652174, 1.55, 0.27777777777778
18077, 1.9826086956522, 1.55, 0.25
18078, 1.9608695652174, 1.55, 0.22222222222222
18079, 1.9826086956522, 1.55, 0.19444444444444
18080, 1.9608695652174, 1.55, 0.16666666666667
18081, 1.9826086956522, 1.55, 0.13888888888889
18082, 1.9608695652174, 1.55, 0.11111111111111
18083, 1.9826086956522, 1.55, 0.083333333333333
18084, 1.9608695652174, 1.55, 0.055555555555556
18085, 1.9826086956522, 1.55, 0.027777777777778
18086, 2.0260869565217, 1.55, 0.47222222222222
18087, 2.004347826087, 1.55, 0.44444444444444
18088, 2.0260869565217, 1.55, 0.41666666666667
18089, 2.004347826087, 1.55, 0.38888888888889
18090, 2.0260869565217, 1.55, 0.36111111111111
18091, 2.004347826087, 1.55, 0.33333333333333
18092, 2.0260869565217, 1.55, 0.30555555555556
18093, 2.004347826087, 1.55, 0.27777777777778
18094, 2.0260869565217, 1.55, 0.25
18095, 2.004347826087, 1.55, 0.22222222222222
18096, 2.0260869565217, 1.55, 0.19444444444444
18097, 2.004347826087, 1.55, 0.16666666666667
18098, 2.0260869565217, 1.55, 0.13888888888889
18099, 2.004347826087, 1.55, 0.11111111111111
18100, 2.0260869565217, 1.55, 0.083333333333333
18101, 2.004347826087, 1.55, 0.055555555555556
18102, 2.0260869565217, 1.55, 0.027777777777778
18103, 2.0695652173913, 1.55, 0.47222222222222
18104, 2.0478260869565, 1.55, 0.44444444444444
18105, 2.0695652173913, 1.55, 0.41666666666667
18106, 2.0478260869565, 1.55, 0.38888888888889
18107, 2.0695652173913, 1.55, 0.36111111111111
18108, 2.0478260869565, 1.55, 0.33333333333333
18109, 2.0695652173913, 1.55, 0.30555555555556
18110, 2.0478260869565, 1.55, 0.27777777777778
18111, 2.0695652173913, 1.55, 0.25
18112, 2.0478260869565, 1.55, 0.22222222222222
18113, 2.0695652173913, 1.55, 0.19444444444444
18114, 2.0478260869565, 1.55, 0.16666666666667
18115, 2.0695652173913, 1.55, 0.13888888888889
18116, 2.0478260869565, 1.55, 0.11111111111111
18117, 2.0695652173913, 1.55, 0.083333333333333
18118, 2.0478260869565, 1.55, 0.055555555555556
18119, 2.0695652173913, 1.55, 0.027777777777778
18120, 2.1130434782609, 1.55, 0.47222222222222
18121, 2.0913043478261, 1.55, 0.44444444444444
18122, 2.1130434782609, 1.55, 0.41666666666667
18123, 2.0913043478261, 1.55, 0.38888888888889
18124, 2.1130434782609, 1.55, 0.36111111111111
18125, 2.0913043478261, 1.55, 0.33333333333333
18126, 2.1130434782609, 1.55, 0.30555555555556
18127, 2.0913043478261, 1.55, 0.27777777777778
18128, 2.1130434782609, 1.55, 0.25
18129, 2.0913043478261, 1.55, 0.22222222222222
18130, 2.1130434782609, 1.55, 0.19444444444444
18131, 2.0913043478261, 1.55, 0.16666666666667
18132, 2.1130434782609, 1.55, 0.13888888888889
18133, 2.0913043478261, 1.55, 0.11111111111111
18134, 2.1130434782609, 1.55, 0.083333333333333
18135, 2.0913043478261, 1.55, 0.055555555555556
18136, 2.1130434782609, 1.55, 0.027777777777778
18137, 2.1565217391304, 1.55, 0.47222222222222
18138, 2.1347826086957, 1.55, 0.44444444444444
18139, 2.1565217391304, 1.55, 0.41666666666667
18140, 2.1347826086957, 1.55, 0.38888888888889
18141, 2.1565217391304, 1.55, 0.36111111111111
18142, 2.1347826086957, 1.55, 0.33333333333333
18143, 2.1565217391304, 1.55, 0.30555555555556
18144, 2.1347826086957, 1.55, 0.27777777777778
18145, 2.1565217391304, 1.55, 0.25
18146, 2.1347826086957, 1.55, 0.22222222222222
18147, 2.1565217391304, 1.55, 0.19444444444444
18148, 2.1347826086957, 1.55, 0.16666666666667
18149, 2.1565217391304, 1.55, 0.13888888888889
18150, 2.1347826086957, 1.55, 0.11111111111111
18151, 2.1565217391304, 1.55, 0.083333333333333
18152, 2.1347826086957, 1.55, 0.055555555555556
18153, 2.1565217391304, 1.55, 0.027777777777778
18154, 2.1782608695652, 1.55, 0.44444444444444
18155, 2.1782608695652, 1.55, 0.38888888888889
18156, 2.1782608695652, 1.55, 0.33333333333333
18157, 2.1782608695652, 1.55, 0.27777777777778
18158, 2.1782608695652, 1.55, 0.22222222222222
18159, 2.1782608695652, 1.55, 0.16666666666667
18160, 2.1782608695652, 1.55, 0.11111111111111
18161, 2.1782608695652, 1.55, 0.055555555555556
18162, 2.2, 1.4833333333333, 0.44444444444444
18163, 2.2, 1.4833333333333, 0.38888888888889
18164, 2.2, 1.4833333333333, 0.33333333333333
18165, 2.2, 1.4833333333333, 0.27777777777778
18166, 2.2, 1.4833333333333, 0.22222222222222
18167, 2.2, 1.4833333333333, 0.16666666666667
18168, 2.2, 1.4833333333333, 0.11111111111111
18169, 2.2, 1.4833333333333, 0.055555555555556
18170, 2.2, 1.5166666666667, 0.44444444444444
18171, 2.2, 1.5166666666667, 0.38888888888889
18172, 2.2, 1.5166666666667, 0.33333333333333
18173, 2.2, 1.5166666666667, 0.27777777777778
18174, 2.2, 1.5166666666667, 0.22222222222222
18175, 2.2, 1.5166666666667, 0.16666666666667
18176, 2.2, 1.5166666666667, 0.11111111111111
18177, 2.2, 1.5166666666667, 0.055555555555556
18178, 2.2, 1.4666666666667, 0.44444444444444
18179, 2.2, 1.4833333333333, 0.47222222222222
18180, 2.2, 1.4666666666667, 0.38888888888889
18181, 2.2, 1.4833333333333, 0.41666666666667
18182, 2.2, 1.4666666666667, 0.33333333333333
18183, 2.2, 1.4833333333333, 0.36111111111111
18184, 2.2, 1.4666666666667, 0.27777777777778
18185, 2.2, 1.4833333333333, 0.30555555555556
18186, 2.2, 1.4666666666667, 0.22222222222222
18187, 2.2, 1.4833333333333, 0.25
18188, 2.2, 1.4666666666667, 0.16666666666667
18189, 2.2, 1.4833333333333, 0.19444444444444
18190, 2.2, 1.4666666666667, 0.11111111111111
18191, 2.2, 1.4833333333333, 0.13888888888889
18192, 2.2, 1.4666666666667, 0.055555555555556
18193, 2.2, 1.4833333333333, 0.083333333333333
18194, 2.2, 1.4833333333333, 0.027777777777778
18195, 2.2, 1.5, 0.44444444444444
18196, 2.2, 1.5166666666667, 0.47222222222222
18197, 2.2, 1.5, 0.38888888888889
18198, 2.2, 1.5166666666667, 0.41666666666667
18199, 2.2, 1.5, 0.33333333333333
18200, 2.2, 1.5166666666667, 0.36111111111111
18201, 2.2, 1.5, 0.27777777777778
18202, 2.2, 1.5166666666667, 0.30555555555556
18203, 2.2, 1.5, 0.22222222222222
18204, 2.2, 1.5166666666667, 0.25
18205, 2.2, 1.5, 0.16666666666667
18206, 2.2, 1.5166666666667, 0.19444444444444
18207, 2.2, 1.5, 0.11111111111111
18208, 2.2, 1.5166666666667, 0.13888888888889
18209, 2.2, 1.5, 0.055555555555556
18210, 2.2, 1.5166666666667, 0.083333333333333
18211, 2.2, 1.5166666666667, 0.027777777777778
18212, 2.2, 1.5333333333333, 0.44444444444444
18213, 2.2, 1.5333333333333, 0.38888888888889
18214, 2.2, 1.5333333333333, 0.33333333333333
18215, 2.2, 1.5333333333333, 0.27777777777778
18216, 2.2, 1.5333333333333, 0.22222222222222
18217, 2.2, 1.5333333333333, 0.16666666666667
18218, 2.2, 1.5333333333333, 0.11111111111111
18219, 2.2, 1.5333333333333, 0.055555555555556
18220, 1.2434782608696, 1.6, 0.5
18221, 1.2869565217391, 1.6, 0.5
18222, 1.3304347826087, 1.6, 0.5
18223, 1.3739130434783, 1.6, 0.5
18224, 1.4173913043478, 1.6, 0.5
18225, 1.4608695652174, 1.6, 0.5
18226, 1.504347826087, 1.6, 0.5
18227, 1.5478260869565, 1.6, 0.5
18228, 1.5913043478261, 1.6, 0.5
18229, 1.6347826086957, 1.6, 0.5
18230, 1.6782608695652, 1.6, 0.5
18231, 1.7217391304348, 1.6, 0.5
18232, 1.7652173913043, 1.6, 0.5
18233, 1.8086956521739, 1.6, 0.5
18234, 1.8521739130435, 1.6, 0.5
18235, 1.895652173913, 1.6, 0.5
18236, 1.9391304347826, 1.6, 0.5
18237, 1.9826086956522, 1.6, 0.5
18238, 2.0260869565217, 1.6, 0.5
18239, 2.0695652173913, 1.6, 0.5
18240, 2.1130434782609, 1.6, 0.5
18241, 2.1565217391304, 1.6, 0.5
18242, 1.2434782608696, 1.65, 0.5
18243, 1.2869565217391, 1.65, 0.5
18244, 1.3304347826087, 1.65, 0.5
18245, 1.3739130434783, 1.65, 0.5
18246, 1.4173913043478, 1.65, 0.5
18247, 1.4608695652174, 1.65, 0.5
18248, 1.504347826087, 1.65, 0.5
18249, 1.5478260869565, 1.65, 0.5
18250, 1.5913043478261, 1.65, 0.5
18251, 1.6347826086957, 1.65, 0.5
18252, 1.6782608695652, 1.65, 0.5
18253, 1.7217391304348, 1.65, 0.5
18254, 1.7652173913043, 1.65, 0.5
18255, 1.8086956521739, 1.65, 0.5
18256, 1.8521739130435, 1.65, 0.5
18257, 1.895652173913, 1.65, 0.5
18258, 1.9391304347826, 1.65, 0.5
18259, 1.9826086956522, 1.65, 0.5
18260, 2.0260869565217, 1.65, 0.5
18261, 2.0695652173913, 1.65, 0.5
18262, 2.1130434782609, 1.65, 0.5
18263, 2.1565217391304, 1.65, 0.5
18264, 1.2434782608696, 1.7, 0.5
18265, 1.2869565217391, 1.7, 0.5
18266, 1.3304347826087, 1.7, 0.5
18267, 1.3739130434783, 1.7, 0.5
18268, 1.4173913043478, 1.7, 0.5
18269, 1.4608695652174, 1.7, 0.5
18270, 1.504347826087, 1.7, 0.5
18271, 1.5478260869565, 1.7, 0.5
18272, 1.5913043478261, 1.7, 0.5
18273, 1.6347826086957, 1.7, 0.5
18274, 1.6782608695652, 1.7, 0.5
18275, 1.7217391304348, 1.7, 0.5
18276, 1.7652173913043, 1.7, 0.5
18277, 1.8086956521739, 1.7, 0.5
18278, 1.8521739130435, 1.7, 0.5
18279, 1.895652173913, 1.7, 0.5
18280, 1.9391304347826, 1.7, 0.5
18281, 1.9826086956522, 1.7, 0.5
18282, 2.0260869565217, 1.7, 0.5
18283, 2.0695652173913, 1.7, 0.5
18284, 2.1130434782609, 1.7, 0.5
18285, 2.1565217391304, 1.7, 0.5
18286, 1.2434782608696, 1.575, 0.5
18287, 1.2217391304348, 1.6, 0.5
18288, 1.2869565217391, 1.575, 0.5
18289, 1.2652173913043, 1.6, 0.5
18290, 1.3304347826087, 1.575, 0.5
18291, 1.3086956521739, 1.6, 0.5
18292, 1.3739130434783, 1.575, 0.5
18293, 1.3521739130435, 1.6, 0.5
18294, 1.4173913043478, 1.575, 0.5
18295, 1.395652173913, 1.6, 0.5
18296, 1.4608695652174, 1.575, 0.5
18297, 1.4391304347826, 1.6, 0.5
18298, 1.504347826087, 1.575, 0.5
18299, 1.4826086956522, 1.6, 0.5
18300, 1.5478260869565, 1.575, 0.5
18301, 1.5260869565217, 1.6, 0.5
18302, 1.5913043478261, 1.575, 0.5
18303, 1.5695652173913, 1.6, 0.5
18304, 1.6347826086957, 1.575, 0.5
18305, 1.6130434782609, 1.6, 0.5
18306, 1.6782608695652, 1.575, 0.5
18307, 1.6565217391304, 1.6, 0.5
18308, 1.7217391304348, 1.575, 0.5
18309, 1.7, 1.6, 0.5
18310, 1.7652173913043, 1.575, 0.5
18311, 1.7434782608696, 1.6, 0.5
18312, 1.8086956521739, 1.575, 0.5
18313, 1.7869565217391, 1.6, 0.5
18314, 1.8521739130435, 1.575, 0.5
18315, 1.8304347826087, 1.6, 0.5
18316, 1.895652173913, 1.575, 0.5
18317, 1.8739130434783, 1.6, 0.5
18318, 1.9391304347826, 1.575, 0.5
18319, 1.9173913043478, 1.6, 0.5
18320, 1.9826086956522, 1.575, 0.5
18321, 1.9608695652174, 1.6, 0.5
18322, 2.0260869565217, 1.575, 0.5
18323, 2.004347826087, 1.6, 0.5
18324, 2.0695652173913, 1.575, 0.5
18325, 2.0478260869565, 1.6, 0.5
18326, 2.1130434782609, 1.575, 0.5
18327, 2.0913043478261, 1.6, 0.5
18328, 2.1565217391304, 1.575, 0.5
18329, 2.1347826086957, 1.6, 0.5
18330, 2.1782608695652, 1.6, 0.5
18331, 1.2434782608696, 1.625, 0.5
18332, 1.2217391304348, 1.65, 0.5
18333, 1.2869565217391, 1.625, 0.5
18334, 1.2652173913043, 1.65, 0.5
18335, 1.3304347826087, 1.625, 0.5
18336, 1.3086956521739, 1.65, 0.5
18337, 1.3739130434783, 1.625, 0.5
18338, 1.3521739130435, 1.65, 0.5
18339, 1.4173913043478, 1.625, 0.5
18340, 1.395652173913, 1.65, 0.5
18341, 1.4608695652174, 1.625, 0.5
18342, 1.4391304347826, 1.65, 0.5
18343, 1.504347826087, 1.625, 0.5
18344, 1.4826086956522, 1.65, 0.5
18345, 1.5478260869565, 1.625, 0.5
18346, 1.5260869565217, 1.65, 0.5
18347, 1.5913043478261, 1.625, 0.5
18348, 1.5695652173913, 1.65, 0.5
18349, 1.6347826086957, 1.625, 0.5
18350, 1.6130434782609, 1.65, 0.5
18351, 1.6782608695652, 1.625, 0.5
18352, 1.6565217391304, 1.65, 0.5
18353, 1.7217391304348, 1.625, 0.5
18354, 1.7, 1.65, 0.5
18355, 1.7652173913043, 1.625, 0.5
18356, 1.7434782608696, 1.65, 0.5
18357, 1.8086956521739, 1.625, 0.5
18358, 1.7869565217391, 1.65, 0.5
18359, 1.8521739130435, 1.625, 0.5
18360, 1.8304347826087, 1.65, 0.5
18361, 1.895652173913, 1.625, 0.5
18362, 1.8739130434783, 1.65, 0.5
18363, 1.9391304347826, 1.625, 0.5
18364, 1.9173913043478, 1.65, 0.5
18365, 1.9826086956522, 1.625, 0.5
18366, 1.9608695652174, 1.65, 0.5
18367, 2.0260869565217, 1.625, 0.5
18368, 2.004347826087, 1.65, 0.5
18369, 2.0695652173913, 1.625, 0.5
18370, 2.0478260869565, 1.65, 0.5
18371, 2.1130434782609, 1.625, 0.5
18372, 2.0913043478261, 1.65, 0.5
18373, 2.1565217391304, 1.625, 0.5
18374, 2.1347826086957, 1.65, 0.5
18375, 2.1782608695652, 1.65, 0.5
18376, 1.2434782608696, 1.675, 0.5
18377, 1.2217391304348, 1.7, 0.5
18378, 1.2869565217391, 1.675, 0.5
18379, 1.2652173913043, 1.7, 0.5
18380, 1.3304347826087, 1.675, 0.5
18381, 1.3086956521739, 1.7, 0.5
18382, 1.3739130434783, 1.675, 0.5
18383, 1.3521739130435, 1.7, 0.5
18384, 1.4173913043478, 1.675, 0.5
18385, 1.395652173913, 1.7, 0.5
18386, 1.4608695652174, 1.675, 0.5
18387, 1.4391304347826, 1.7, 0.5
18388, 1.504347826087, 1.675, 0.5
18389, 1.4826086956522, 1.7, 0.5
18390, 1.5478260869565, 1.675, 0.5
18391, 1.5260869565217, 1.7, 0.5
18392, 1.5913043478261, 1.675, 0.5
18393, 1.5695652173913, 1.7, 0.5
18394, 1.6347826086957, 1.675, 0.5
18395, 1.6130434782609, 1.7, 0.5
18396, 1.6782608695652, 1.675, 0.5
18397, 1.6565217391304, 1.7, 0.5
18398, 1.7217391304348, 1.675, 0.5
18399, 1.7, 1.7, 0.5
18400, 1.7652173913043, 1.675, 0.5
18401, 1.7434782608696, 1.7, 0.5
18402, 1.8086956521739, 1.675, 0.5
18403, 1.7869565217391, 1.7, 0.5
18404, 1.8521739130435, 1.675, 0.5
18405, 1.8304347826087, 1.7, 0.5
18406, 1.895652173913, 1.675, 0.5
18407, 1.8739130434783, 1.7, 0.5
18408, 1.9391304347826, 1.675, 0.5
18409, 1.9173913043478, 1.7, 0.5
18410, 1.9826086956522, 1.675, 0.5
18411, 1.9608695652174, 1.7, 0.5
18412, 2.0260869565217, 1.675, 0.5
18413, 2.004347826087, 1.7, 0.5
18414, 2.0695652173913, 1.675, 0.5
18415, 2.0478260869565, 1.7, 0.5
18416, 2.1130434782609, 1.675, 0.5
18417, 2.0913043478261, 1.7, 0.5
18418, 2.1565217391304, 1.675, 0.5
18419, 2.1347826086957, 1.7, 0.5
18420, 2.1782608695652, 1.7, 0.5
18421, 1.2434782608696, 1.725, 0.5
18422, 1.2869565217391, 1.725, 0.5
18423, 1.3304347826087, 1.725, 0.5
18424, 1.3739130434783, 1.725, 0.5
18425, 1.4173913043478, 1.725, 0.5
18426, 1.4608695652174, 1.725, 0.5
18427, 1.504347826087, 1.725, 0.5
18428, 1.5478260869565, 1.725, 0.5
18429, 1.5913043478261, 1.725, 0.5
18430, 1.6347826086957, 1.725, 0.5
18431, 1.6782608695652, 1.725, 0.5
18432, 1.7217391304348, 1.725, 0.5
18433, 1.7652173913043, 1.725, 0.5
18434, 1.8086956521739, 1.725, 0.5
18435, 1.8521739130435, 1.725, 0.5
18436, 1.895652173913, 1.725, 0.5
18437, 1.9391304347826, 1.725, 0.5
18438, 1.9826086956522, 1.725, 0.5
18439, 2.0260869565217, 1.725, 0.5
18440, 2.0695652173913, 1.725, 0.5
18441, 2.1130434782609, 1.725, 0.5
18442, 2.1565217391304, 1.725, 0.5
18443, 1.2434782608696, 1.6, 0
18444, 1.2869565217391, 1.6, 0
18445, 1.3304347826087, 1.6, 0
18446, 1.3739130434783, 1.6, 0
18447, 1.4173913043478, 1.6, 0
18448, 1.4608695652174, 1.6, 0
18449, 1.504347826087, 1.6, 0
18450, 1.5478260869565, 1.6, 0
18451, 1.5913043478261, 1.6, 0
18452, 1.6347826086957, 1.6, 0
18453, 1.6782608695652, 1.6, 0
18454, 1.7217391304348, 1.6, 0
18455, 1.7652173913043, 1.6, 0
18456, 1.8086956521739, 1.6, 0
18457, 1.8521739130435, 1.6, 0
18458, 1.895652173913, 1.6, 0
18459, 1.9391304347826, 1.6, 0
18460, 1.9826086956522, 1.6, 0
18461, 2.0260869565217, 1.6, 0
18462, 2.0695652173913, 1.6, 0
18463, 2.1130434782609, 1.6, 0
18464, 2.1565217391304, 1.6, 0
18465, 1.2434782608696, 1.65, 0
18466, 1.2869565217391, 1.65, 0
18467, 1.3304347826087, 1.65, 0
18468, 1.3739130434783, 1.65, 0
18469, 1.4173913043478, 1.65, 0
18470, 1.4608695652174, 1.65, 0
18471, 1.504347826087, 1.65, 0
18472, 1.5478260869565, 1.65, 0
18473, 1.5913043478261, 1.65, 0
18474, 1.6347826086957, 1.65, 0
18475, 1.6782608695652, 1.65, 0
18476, 1.7217391304348, 1.65, 0
18477, 1.7652173913043, 1.65, 0
18478, 1.8086956521739, 1.65, 0
18479, 1.8521739130435, 1.65, 0
18480, 1.895652173913, 1.65, 0
18481, 1.9391304347826, 1.65, 0
18482, 1.9826086956522, 1.65, 0
18483, 2.0260869565217, 1.65, 0
18484, 2.0695652173913, 1.65, 0
18485, 2.1130434782609, 1.65, 0
18486, 2.1565217391304, 1.65, 0
18487, 1.2434782608696, 1.7, 0
18488, 1.2869565217391, 1.7, 0
18489, 1.3304347826087, 1.7, 0
18490, 1.3739130434783, 1.7, 0
18491, 1.4173913043478, 1.7, 0
18492, 1.4608695652174, 1.7, 0
18493, 1.504347826087, 1.7, 0
18494, 1.5478260869565, 1.7, 0
18495, 1.5913043478261, 1.7, 0
18496, 1.6347826086957, 1.7, 0
18497, 1.6782608695652, 1.7, 0
18498, 1.7217391304348, 1.7, 0
18499, 1.7652173913043, 1.7, 0
18500, 1.8086956521739, 1.7, 0
18501, 1.8521739130435, 1.7, 0
18502, 1.895652173913, 1.7, 0
18503, 1.9391304347826, 1.7, 0
18504, 1.9826086956522, 1.7, 0
18505, 2.0260869565217, 1.7, 0
18506, 2.0695652173913, 1.7, 0
18507, 2.1130434782609, 1.7, 0
18508, 2.1565217391304, 1.7, 0
18509, 1.2217391304348, 1.6, 0
18510, 1.2434782608696, 1.575, 0
18511, 1.2652173913043, 1.6, 0
18512, 1.2869565217391, 1.575, 0
18513, 1.3086956521739, 1.6, 0
18514, 1.3304347826087, 1.575, 0
18515, 1.3521739130435, 1.6, 0
18516, 1.3739130434783, 1.575, 0
18517, 1.395652173913, 1.6, 0
18518, 1.4173913043478, 1.575, 0
18519, 1.4391304347826, 1.6, 0
18520, 1.4608695652174, 1.575, 0
18521, 1.4826086956522, 1.6, 0
18522, 1.504347826087, 1.575, 0
18523, 1.5260869565217, 1.6, 0
18524, 1.5478260869565, 1.575, 0
18525, 1.5695652173913, 1.6, 0
18526, 1.5913043478261, 1.575, 0
18527, 1.6130434782609, 1.6, 0
18528, 1.6347826086957, 1.575, 0
18529, 1.6565217391304, 1.6, 0
18530, 1.6782608695652, 1.575, 0
18531, 1.7, 1.6, 0
18532, 1.7217391304348, 1.575, 0
18533, 1.7434782608696, 1.6, 0
18534, 1.7652173913043, 1.575, 0
18535, 1.7869565217391, 1.6, 0
18536, 1.8086956521739, 1.575, 0
18537, 1.8304347826087, 1.6, 0
18538, 1.8521739130435, 1.575, 0
18539, 1.8739130434783, 1.6, 0
18540, 1.895652173913, 1.575, 0
18541, 1.9173913043478, 1.6, 0
18542, 1.9391304347826, 1.575, 0
18543, 1.9608695652174, 1.6, 0
18544, 1.9826086956522, 1.575, 0
18545, 2.004347826087, 1.6, 0
18546, 2.0260869565217, 1.575, 0
18547, 2.0478260869565, 1.6, 0
18548, 2.0695652173913, 1.575, 0
18549, 2.0913043478261, 1.6, 0
18550, 2.1130434782609, 1.575, 0
18551, 2.1347826086957, 1.6, 0
18552, 2.1565217391304, 1.575, 0
18553, 2.1782608695652, 1.6, 0
18554, 1.2217391304348, 1.65, 0
18555, 1.2434782608696, 1.625, 0
18556, 1.2652173913043, 1.65, 0
18557, 1.2869565217391, 1.625, 0
18558, 1.3086956521739, 1.65, 0
18559, 1.3304347826087, 1.625, 0
18560, 1.3521739130435, 1.65, 0
18561, 1.3739130434783, 1.625, 0
18562, 1.395652173913, 1.65, 0
18563, 1.4173913043478, 1.625, 0
18564, 1.4391304347826, 1.65, 0
18565, 1.4608695652174, 1.625, 0
18566, 1.4826086956522, 1.65, 0
18567, 1.504347826087, 1.625, 0
18568, 1.5260869565217, 1.65, 0
18569, 1.5478260869565, 1.625, 0
18570, 1.5695652173913, 1.65, 0
18571, 1.5913043478261, 1.625, 0
18572, 1.6130434782609, 1.65, 0
18573, 1.6347826086957, 1.625, 0
18574, 1.6565217391304, 1.65, 0
18575, 1.6782608695652, 1.625, 0
18576, 1.7, 1.65, 0
18577, 1.7217391304348, 1.625, 0
18578, 1.7434782608696, 1.65, 0
18579, 1.7652173913043, 1.625, 0
18580, 1.7869565217391, 1.65, 0
18581, 1.8086956521739, 1.625, 0
18582, 1.8304347826087, 1.65, 0
18583, 1.8521739130435, 1.625, 0
18584, 1.8739130434783, 1.65, 0
18585, 1.895652173913, 1.625, 0
18586, 1.9173913043478, 1.65, 0
18587, 1.9391304347826, 1.625, 0
18588, 1.9608695652174, 1.65, 0
18589, 1.9826086956522, 1.625, 0
18590, 2.004347826087, 1.65, 0
18591, 2.0260869565217, 1.625, 0
18592, 2.0478260869565, 1.65, 0
18593, 2.0695652173913, 1.625, 0
18594, 2.0913043478261, 1.65, 0
18595, 2.1130434782609, 1.625, 0
18596, 2.1347826086957, 1.65, 0
18597, 2.1565217391304, 1.625, 0
18598, 2.1782608695652, 1.65, 0
18599, 1.2217391304348, 1.7, 0
18600, 1.2434782608696, 1.675, 0
18601, 1.2652173913043, 1.7, 0
18602, 1.2869565217391, 1.675, 0
18603, 1.3086956521739, 1.7, 0
18604, 1.3304347826087, 1.675, 0
18605, 1.3521739130435, 1.7, 0
18606, 1.3739130434783, 1.675, 0
18607, 1.395652173913, 1.7, 0
18608, 1.4173913043478, 1.675, 0
18609, 1.4391304347826, 1.7, 0
18610, 1.4608695652174, 1.675, 0
18611, 1.4826086956522, 1.7, 0
18612, 1.504347826087, 1.675, 0
18613, 1.5260869565217, 1.7, 0
18614, 1.5478260869565, 1.675, 0
18615, 1.5695652173913, 1.7, 0
18616, 1.5913043478261, 1.675, 0
18617, 1.6130434782609, 1.7, 0
18618, 1.6347826086957, 1.675, 0
18619, 1.6565217391304, 1.7, 0
18620, 1.6782608695652, 1.675, 0
18621, 1.7, 1.7, 0
18622, 1.7217391304348, 1.675, 0
18623, 1.7434782608696, 1.7, 0
18624, 1.7652173913043, 1.675, 0
18625, 1.7869565217391, 1.7, 0
18626, 1.8086956521739, 1.675, 0
18627, 1.8304347826087, 1.7, 0
18628, 1.8521739130435, 1.675, 0
18629, 1.8739130434783, 1.7, 0
18630, 1.895652173913, 1.675, 0
18631, 1.9173913043478, 1.7, 0
18632, 1.9391304347826, 1.675, 0
18633, 1.9608695652174, 1.7, 0
18634, 1.9826086956522, 1.675, 0
18635, 2.004347826087, 1.7, 0
18636, 2.0260869565217, 1.675, 0
18637, 2.0478260869565, 1.7, 0
18638, 2.0695652173913, 1.675, 0
18639, 2.0913043478261, 1.7, 0
18640, 2.1130434782609, 1.675, 0
18641, 2.1347826086957, 1.7, 0
18642, 2.1565217391304, 1.675, 0
18643, 2.1782608695652, 1.7, 0
18644, 1.2434782608696, 1.725, 0
18645, 1.2869565217391, 1.725, 0
18646, 1.3304347826087, 1.725, 0
18647, 1.3739130434783, 1.725, 0
18648, 1.4173913043478, 1.725, 0
18649, 1.4608695652174, 1.725, 0
18650, 1.504347826087, 1.725, 0
18651, 1.5478260869565, 1.725, 0
18652, 1.5913043478261, 1.725, 0
18653, 1.6347826086957, 1.725, 0
18654, 1.6782608695652, 1.725, 0
18655, 1.7217391304348, 1.725, 0
18656, 1.7652173913043, 1.725, 0
18657, 1.8086956521739, 1.725, 0
18658, 1.8521739130435, 1.725, 0
18659, 1.895652173913, 1.725, 0
18660, 1.9391304347826, 1.725, 0
18661, 1.9826086956522, 1.725, 0
18662, 2.0260869565217, 1.725, 0
18663, 2.0695652173913, 1.725, 0
18664, 2.1130434782609, 1.725, 0
18665, 2.1565217391304, 1.725, 0
18666, 2.2, 1.6, 0.44444444444444
18667, 2.2, 1.6, 0.38888888888889
18668, 2.2, 1.6, 0.33333333333333
18669, 2.2, 1.6, 0.27777777777778
18670, 2.2, 1.6, 0.22222222222222
18671, 2.2, 1.6, 0.16666666666667
18672, 2.2, 1.6, 0.11111111111111
18673, 2.2, 1.6, 0.055555555555556
18674, 2.2, 1.65, 0.44444444444444
18675, 2.2, 1.65, 0.38888888888889
18676, 2.2, 1.65, 0.33333333333333
18677, 2.2, 1.65, 0.27777777777778
18678, 2.2, 1.65, 0.22222222222222
18679, 2.2, 1.65, 0.16666666666667
18680, 2.2, 1.65, 0.11111111111111
18681, 2.2, 1.65, 0.055555555555556
18682, 2.2, 1.7, 0.44444444444444
18683, 2.2, 1.7, 0.38888888888889
18684, 2.2, 1.7, 0.33333333333333
18685, 2.2, 1.7, 0.27777777777778
18686, 2.2, 1.7, 0.22222222222222
18687, 2.2, 1.7, 0.16666666666667
18688, 2.2, 1.7, 0.11111111111111
18689, 2.2, 1.7, 0.055555555555556
18690, 2.2, 1.575, 0.44444444444444
18691, 2.2, 1.6, 0.47222222222222
18692, 2.2, 1.575, 0.38888888888889
18693, 2.2, 1.6, 0.41666666666667
18694, 2.2, 1.575, 0.33333333333333
18695, 2.2, 1.6, 0.36111111111111
18696, 2.2, 1.575, 0.27777777777778
18697, 2.2, 1.6, 0.30555555555556
18698, 2.2, 1.575, 0.22222222222222
18699, 2.2, 1.6, 0.25
18700, 2.2, 1.575, 0.16666666666667
18701, 2.2, 1.6, 0.19444444444444
18702, 2.2, 1.575, 0.11111111111111
18703, 2.2, 1.6, 0.13888888888889
18704, 2.2, 1.575, 0.055555555555556
18705, 2.2, 1.6, 0.083333333333333
18706, 2.2, 1.6, 0.027777777777778
18707, 2.2, 1.625, 0.44444444444444
18708, 2.2, 1.65, 0.47222222222222
18709, 2.2, 1.625, 0.38888888888889
18710, 2.2, 1.65, 0.41666666666667
18711, 2.2, 1.625, 0.33333333333333
18712, 2.2, 1.65, 0.36111111111111
18713, 2.2, 1.625, 0.27777777777778
18714, 2.2, 1.65, 0.30555555555556
18715, 2.2, 1.625, 0.22222222222222
18716, 2.2, 1.65, 0.25
18717, 2.2, 1.625, 0.16666666666667
18718, 2.2, 1.65, 0.19444444444444
18719, 2.2, 1.625, 0.11111111111111
18720, 2.2, 1.65, 0.13888888888889
18721, 2.2, 1.625, 0.055555555555556
18722, 2.2, 1.65, 0.083333333333333
18723, 2.2, 1.65, 0.027777777777778
18724, 2.2, 1.675, 0.44444444444444
18725, 2.2, 1.7, 0.47222222222222
18726, 2.2, 1.675, 0.38888888888889
18727, 2.2, 1.7, 0.41666666666667
18728, 2.2, 1.675, 0.33333333333333
18729, 2.2, 1.7, 0.36111111111111
18730, 2.2, 1.675, 0.27777777777778
18731, 2.2, 1.7, 0.30555555555556
18732, 2.2, 1.675, 0.22222222222222
18733, 2.2, 1.7, 0.25
18734, 2.2, 1.675, 0.16666666666667
18735, 2.2, 1.7, 0.19444444444444
18736, 2.2, 1.675, 0.11111111111111
18737, 2.2, 1.7, 0.13888888888889
18738, 2.2, 1.675, 0.055555555555556
18739, 2.2, 1.7, 0.083333333333333
18740, 2.2, 1.7, 0.027777777777778
18741, 2.2, 1.725, 0.44444444444444
18742, 2.2, 1.725, 0.38888888888889
18743, 2.2, 1.725, 0.33333333333333
18744, 2.2, 1.725, 0.27777777777778
18745, 2.2, 1.725, 0.22222222222222
18746, 2.2, 1.725, 0.16666666666667
18747, 2.2, 1.725, 0.11111111111111
18748, 2.2, 1.725, 0.055555555555556
18749, 1.2434782608696, 1.75, 0.44444444444444
18750, 1.2434782608696, 1.75, 0.38888888888889
18751, 1.2434782608696, 1.75, 0.33333333333333
18752, 1.2434782608696, 1.75, 0.27777777777778
18753, 1.2434782608696, 1.75, 0.22222222222222
18754, 1.2434782608696, 1.75, 0.16666666666667
18755, 1.2434782608696, 1.75, 0.11111111111111
18756, 1.2434782608696, 1.75, 0.055555555555556
18757, 1.2869565217391, 1.75, 0.44444444444444
18758, 1.2869565217391, 1.75, 0.38888888888889
18759, 1.2869565217391, 1.75, 0.33333333333333
18760, 1.2869565217391, 1.75, 0.27777777777778
18761, 1.2869565217391, 1.75, 0.22222222222222
18762, 1.2869565217391, 1.75, 0.16666666666667
18763, 1.2869565217391, 1.75, 0.11111111111111
18764, 1.2869565217391, 1.75, 0.055555555555556
18765, 1.3304347826087, 1.75, 0.44444444444444
18766, 1.3304347826087, 1.75, 0.38888888888889
18767, 1.3304347826087, 1.75, 0.33333333333333
18768, 1.3304347826087, 1.75, 0.27777777777778
18769, 1.3304347826087, 1.75, 0.22222222222222
18770, 1.3304347826087, 1.75, 0.16666666666667
18771, 1.3304347826087, 1.75, 0.11111111111111
18772, 1.3304347826087, 1.75, 0.055555555555556
18773, 1.3739130434783, 1.75, 0.44444444444444
18774, 1.3739130434783, 1.75, 0.38888888888889
18775, 1.3739130434783, 1.75, 0.33333333333333
18776, 1.3739130434783, 1.75, 0.27777777777778
18777, 1.3739130434783, 1.75, 0.22222222222222
18778, 1.3739130434783, 1.75, 0.16666666666667
18779, 1.3739130434783, 1.75, 0.11111111111111
18780, 1.3739130434783, 1.75, 0.055555555555556
18781, 1.4173913043478, 1.75, 0.44444444444444
18782, 1.4173913043478, 1.75, 0.38888888888889
18783, 1.4173913043478, 1.75, 0.33333333333333
18784, 1.4173913043478, 1.75, 0.27777777777778
18785, 1.4173913043478, 1.75, 0.22222222222222
18786, 1.4173913043478, 1.75, 0.16666666666667
18787, 1.4173913043478, 1.75, 0.11111111111111
18788, 1.4173913043478, 1.75, 0.055555555555556
18789, 1.4608695652174, 1.75, 0.44444444444444
18790, 1.4608695652174, 1.75, 0.38888888888889
18791, 1.4608695652174, 1.75, 0.33333333333333
18792, 1.4608695652174, 1.75, 0.27777777777778
18793, 1.4608695652174, 1.75, 0.22222222222222
18794, 1.4608695652174, 1.75, 0.16666666666667
18795, 1.4608695652174, 1.75, 0.11111111111111
18796, 1.4608695652174, 1.75, 0.055555555555556
18797, 1.504347826087, 1.75, 0.44444444444444
18798, 1.504347826087, 1.75, 0.38888888888889
18799, 1.504347826087, 1.75, 0.33333333333333
18800, 1.504347826087, 1.75, 0.27777777777778
18801, 1.504347826087, 1.75, 0.22222222222222
18802, 1.504347826087, 1.75, 0.16666666666667
18803, 1.504347826087, 1.75, 0.11111111111111
18804, 1.504347826087, 1.75, 0.055555555555556
18805, 1.5478260869565, 1.75, 0.44444444444444
18806, 1.5478260869565, 1.75, 0.38888888888889
18807, 1.5478260869565, 1.75, 0.33333333333333
18808, 1.5478260869565, 1.75, 0.27777777777778
18809, 1.5478260869565, 1.75, 0.22222222222222
18810, 1.5478260869565, 1.75, 0.16666666666667
18811, 1.5478260869565, 1.75, 0.11111111111111
18812, 1.5478260869565, 1.75, 0.055555555555556
18813, 1.5913043478261, 1.75, 0.44444444444444
18814, 1.5913043478261, 1.75, 0.38888888888889
18815, 1.5913043478261, 1.75, 0.33333333333333
18816, 1.5913043478261, 1.75, 0.27777777777778
18817, 1.5913043478261, 1.75, 0.22222222222222
18818, 1.5913043478261, 1.75, 0.16666666666667
18819, 1.5913043478261, 1.75, 0.11111111111111
18820, 1.5913043478261, 1.75, 0.055555555555556
18821, 1.6347826086957, 1.75, 0.44444444444444
18822, 1.6347826086957, 1.75, 0.38888888888889
18823, 1.6347826086957, 1.75, 0.33333333333333
18824, 1.6347826086957, 1.75, 0.27777777777778
18825, 1.6347826086957, 1.75, 0.22222222222222
18826, 1.6347826086957, 1.75, 0.16666666666667
18827, 1.6347826086957, 1.75, 0.11111111111111
18828, 1.6347826086957, 1.75, 0.055555555555556
18829, 1.6782608695652, 1.75, 0.44444444444444
18830, 1.6782608695652, 1.75, 0.38888888888889
18831, 1.6782608695652, 1.75, 0.33333333333333
18832, 1.6782608695652, 1.75, 0.27777777777778
18833, 1.6782608695652, 1.75, 0.22222222222222
18834, 1.6782608695652, 1.75, 0.16666666666667
18835, 1.6782608695652, 1.75, 0.11111111111111
18836, 1.6782608695652, 1.75, 0.055555555555556
18837, 1.7217391304348, 1.75, 0.44444444444444
18838, 1.7217391304348, 1.75, 0.38888888888889
18839, 1.7217391304348, 1.75, 0.33333333333333
18840, 1.7217391304348, 1.75, 0.27777777777778
18841, 1.7217391304348, 1.75, 0.22222222222222
18842, 1.7217391304348, 1.75, 0.16666666666667
18843, 1.7217391304348, 1.75, 0.11111111111111
18844, 1.7217391304348, 1.75, 0.055555555555556
18845, 1.7652173913043, 1.75, 0.44444444444444
18846, 1.7652173913043, 1.75, 0.38888888888889
18847, 1.7652173913043, 1.75, 0.33333333333333
18848, 1.7652173913043, 1.75, 0.27777777777778
18849, 1.7652173913043, 1.75, 0.22222222222222
18850, 1.7652173913043, 1.75, 0.16666666666667
18851, 1.7652173913043, 1.75, 0.11111111111111
18852, 1.7652173913043, 1.75, 0.055555555555556
18853, 1.8086956521739, 1.75, 0.44444444444444
18854, 1.8086956521739, 1.75, 0.38888888888889
18855, 1.8086956521739, 1.75, 0.33333333333333
18856, 1.8086956521739, 1.75, 0.27777777777778
18857, 1.8086956521739, 1.75, 0.22222222222222
18858, 1.8086956521739, 1.75, 0.16666666666667
18859, 1.8086956521739, 1.75, 0.11111111111111
18860, 1.8086956521739, 1.75, 0.055555555555556
18861, 1.8521739130435, 1.75, 0.44444444444444
18862, 1.8521739130435, 1.75, 0.38888888888889
18863, 1.8521739130435, 1.75, 0.33333333333333
18864, 1.8521739130435, 1.75, 0.27777777777778
18865, 1.8521739130435, 1.75, 0.22222222222222
18866, 1.8521739130435, 1.75, 0.16666666666667
18867, 1.8521739130435, 1.75, 0.11111111111111
18868, 1.8521739130435, 1.75, 0.055555555555556
18869, 1.895652173913, 1.75, 0.44444444444444
18870, 1.895652173913, 1.75, 0.38888888888889
18871, 1.895652173913, 1.75, 0.33333333333333
18872, 1.895652173913, 1.75, 0.27777777777778
18873, 1.895652173913, 1.75, 0.22222222222222
18874, 1.895652173913, 1.75, 0.16666666666667
18875, 1.895652173913, 1.75, 0.11111111111111
18876, 1.895652173913, 1.75, 0.055555555555556
18877, 1.9391304347826, 1.75, 0.44444444444444
18878, 1.9391304347826, 1.75, 0.38888888888889
18879, 1.9391304347826, 1.75, 0.33333333333333
18880, 1.9391304347826, 1.75, 0.27777777777778
18881, 1.9391304347826, 1.75, 0.22222222222222
18882, 1.9391304347826, 1.75, 0.16666666666667
18883, 1.9391304347826, 1.75, 0.11111111111111
18884, 1.9391304347826, 1.75, 0.055555555555556
18885, 1.9826086956522, 1.75, 0.44444444444444
18886, 1.9826086956522, 1.75, 0.38888888888889
18887, 1.9826086956522, 1.75, 0.33333333333333
18888, 1.9826086956522, 1.75, 0.27777777777778
18889, 1.9826086956522, 1.75, 0.22222222222222
18890, 1.9826086956522, 1.75, 0.16666666666667
18891, 1.9826086956522, 1.75, 0.11111111111111
18892, 1.9826086956522, 1.75, 0.055555555555556
18893, 2.0260869565217, 1.75, 0.44444444444444
18894, 2.0260869565217, 1.75, 0.38888888888889
18895, 2.0260869565217, 1.75, 0.33333333333333
18896, 2.0260869565217, 1.75, 0.27777777777778
18897, 2.0260869565217, 1.75, 0.22222222222222
18898, 2.0260869565217, 1.75, 0.16666666666667
18899, 2.0260869565217, 1.75, 0.11111111111111
18900, 2.0260869565217, 1.75, 0.055555555555556
18901, 2.0695652173913, 1.75, 0.44444444444444
18902, 2.0695652173913, 1.75, 0.38888888888889
18903, 2.0695652173913, 1.75, 0.33333333333333
18904, 2.0695652173913, 1.75, 0.27777777777778
18905, 2.0695652173913, 1.75, 0.22222222222222
18906, 2.0695652173913, 1.75, 0.16666666666667
18907, 2.0695652173913, 1.75, 0.11111111111111
18908, 2.0695652173913, 1.75, 0.055555555555556
18909, 2.1130434782609, 1.75, 0.44444444444444
18910, 2.1130434782609, 1.75, 0.38888888888889
18911, 2.1130434782609, 1.75, 0.33333333333333
18912, 2.1130434782609, 1.75, 0.27777777777778
18913, 2.1130434782609, 1.75, 0.22222222222222
18914, 2.1130434782609, 1.75, 0.16666666666667
18915, 2.1130434782609, 1.75, 0.11111111111111
18916, 2.1130434782609, 1.75, 0.055555555555556
18917, 2.1565217391304, 1.75, 0.44444444444444
18918, 2.1565217391304, 1.75, 0.38888888888889
18919, 2.1565217391304, 1.75, 0.33333333333333
18920, 2.1565217391304, 1.75, 0.27777777777778
18921, 2.1565217391304, 1.75, 0.22222222222222
18922, 2.1565217391304, 1.75, 0.16666666666667
18923, 2.1565217391304, 1.75, 0.11111111111111
18924, 2.1565217391304, 1.75, 0.055555555555556
18925, 1.2434782608696, 1.75, 0.47222222222222
18926, 1.2217391304348, 1.75, 0.44444444444444
18927, 1.2434782608696, 1.75, 0.41666666666667
18928, 1.2217391304348, 1.75, 0.38888888888889
18929, 1.2434782608696, 1.75, 0.36111111111111
18930, 1.2217391304348, 1.75, 0.33333333333333
18931, 1.2434782608696, 1.75, 0.30555555555556
18932, 1.2217391304348, 1.75, 0.27777777777778
18933, 1.2434782608696, 1.75, 0.25
18934, 1.2217391304348, 1.75, 0.22222222222222
18935, 1.2434782608696, 1.75, 0.19444444444444
18936, 1.2217391304348, 1.75, 0.16666666666667
18937, 1.2434782608696, 1.75, 0.13888888888889
18938, 1.2217391304348, 1.75, 0.11111111111111
18939, 1.2434782608696, 1.75, 0.083333333333333
18940, 1.2217391304348, 1.75, 0.055555555555556
18941, 1.2434782608696, 1.75, 0.027777777777778
18942, 1.2869565217391, 1.75, 0.47222222222222
18943, 1.2652173913043, 1.75, 0.44444444444444
18944, 1.2869565217391, 1.75, 0.41666666666667
18945, 1.2652173913043, 1.75, 0.38888888888889
18946, 1.2869565217391, 1.75, 0.36111111111111
18947, 1.2652173913043, 1.75, 0.33333333333333
18948, 1.2869565217391, 1.75, 0.30555555555556
18949, 1.2652173913043, 1.75, 0.27777777777778
18950, 1.2869565217391, 1.75, 0.25
18951, 1.2652173913043, 1.75, 0.22222222222222
18952, 1.2869565217391, 1.75, 0.19444444444444
18953, 1.2652173913043, 1.75, 0.16666666666667
18954, 1.2869565217391, 1.75, 0.13888888888889
18955, 1.2652173913043, 1.75, 0.11111111111111
18956, 1.2869565217391, 1.75, 0.083333333333333
18957, 1.2652173913043, 1.75, 0.055555555555556
18958, 1.2869565217391, 1.75, 0.027777777777778
18959, 1.3304347826087, 1.75, 0.47222222222222
18960, 1.3086956521739, 1.75, 0.44444444444444
18961, 1.3304347826087, 1.75, 0.41666666666667
18962, 1.3086956521739, 1.75, 0.38888888888889
18963, 1.3304347826087, 1.75, 0.36111111111111
18964, 1.3086956521739, 1.75, 0.33333333333333
18965, 1.3304347826087, 1.75, 0.30555555555556
18966, 1.3086956521739, 1.75, 0.27777777777778
18967, 1.3304347826087, 1.75, 0.25
18968, 1.3086956521739, 1.75, 0.22222222222222
18969, 1.3304347826087, 1.75, 0.19444444444444
18970, 1.3086956521739, 1.75, 0.16666666666667
18971, 1.3304347826087, 1.75, 0.13888888888889
18972, 1.3086956521739, 1.75, 0.11111111111111
18973, 1.3304347826087, 1.75, 0.083333333333333
18974, 1.3086956521739, 1.75, 0.055555555555556
18975, 1.3304347826087, 1.75, 0.027777777777778
18976, 1.3739130434783, 1.75, 0.47222222222222
18977, 1.3521739130435, 1.75, 0.44444444444444
18978, 1.3739130434783, 1.75, 0.41666666666667
18979, 1.3521739130435, 1.75, 0.38888888888889
18980, 1.3739130434783, 1.75, 0.36111111111111
18981, 1.3521739130435, 1.75, 0.33333333333333
18982, 1.3739130434783, 1.75, 0.30555555555556
18983, 1.3521739130435, 1.75, 0.27777777777778
18984, 1.3739130434783, 1.75, 0.25
18985, 1.3521739130435, 1.75, 0.22222222222222
18986, 1.3739130434783, 1.75, 0.19444444444444
18987, 1.3521739130435, 1.75, 0.16666666666667
18988, 1.3739130434783, 1.75, 0.13888888888889
18989, 1.3521739130435, 1.75, 0.11111111111111
18990, 1.3739130434783, 1.75, 0.083333333333333
18991, 1.3521739130435, 1.75, 0.055555555555556
18992, 1.3739130434783, 1.75, 0.027777777777778
18993, 1.4173913043478, 1.75, 0.47222222222222
18994, 1.395652173913, 1.75, 0.44444444444444
18995, 1.4173913043478, 1.75, 0.41666666666667
18996, 1.395652173913, 1.75, 0.38888888888889
18997, 1.4173913043478, 1.75, 0.36111111111111
18998, 1.395652173913, 1.75, 0.33333333333333
18999, 1.4173913043478, 1.75, 0.30555555555556
19000, 1.395652173913, 1.75, 0.27777777777778
19001, 1.4173913043478, 1.75, 0.25
19002, 1.395652173913, 1.75, 0.22222222222222
19003, 1.4173913043478, 1.75, 0.19444444444444
19004, 1.395652173913, 1.75, 0.16666666666667
19005, 1.4173913043478, 1.75, 0.13888888888889
19006, 1.395652173913, 1.75, 0.11111111111111
19007, 1.4173913043478, 1.75, 0.083333333333333
19008, 1.395652173913, 1.75, 0.055555555555556
19009, 1.4173913043478, 1.75, 0.027777777777778
19010, 1.4608695652174, 1.75, 0.47222222222222
19011, 1.4391304347826, 1.75, 0.44444444444444
19012, 1.4608695652174, 1.75, 0.41666666666667
19013, 1.4391304347826, 1.75, 0.38888888888889
19014, 1.4608695652174, 1.75, 0.36111111111111
19015, 1.4391304347826, 1.75, 0.33333333333333
19016, 1.4608695652174, 1.75, 0.30555555555556
19017, 1.4391304347826, 1.75, 0.27777777777778
19018, 1.4608695652174, 1.75, 0.25
19019, 1.4391304347826, 1.75, 0.22222222222222
19020, 1.4608695652174, 1.75, 0.19444444444444
19021, 1.4391304347826, 1.75, 0.16666666666667
19022, 1.4608695652174, 1.75, 0.13888888888889
19023, 1.4391304347826, 1.75, 0.11111111111111
19024, 1.4608695652174, 1.75, 0.083333333333333
19025, 1.4391304347826, 1.75, 0.055555555555556
19026, 1.4608695652174, 1.75, 0.027777777777778
19027, 1.504347826087, 1.75, 0.47222222222222
19028, 1.4826086956522, 1.75, 0.44444444444444
19029, 1.504347826087, 1.75, 0.41666666666667
19030, 1.4826086956522, 1.75, 0.38888888888889
19031, 1.504347826087, 1.75, 0.36111111111111
19032, 1.4826086956522, 1.75, 0.33333333333333
19033, 1.504347826087, 1.75, 0.30555555555556
19034, 1.4826086956522, 1.75, 0.27777777777778
19035, 1.504347826087, 1.75, 0.25
19036, 1.4826086956522, 1.75, 0.22222222222222
19037, 1.504347826087, 1.75, 0.19444444444444
19038, 1.4826086956522, 1.75, 0.16666666666667
19039, 1.504347826087, 1.75, 0.13888888888889
19040, 1.4826086956522, 1.75, 0.11111111111111
19041, 1.504347826087, 1.75, 0.083333333333333
19042, 1.4826086956522, 1.75, 0.055555555555556
19043, 1.504347826087, 1.75, 0.027777777777778
19044, 1.5478260869565, 1.75, 0.47222222222222
19045, 1.5260869565217, 1.75, 0.44444444444444
19046, 1.5478260869565, 1.75, 0.41666666666667
19047, 1.5260869565217, 1.75, 0.38888888888889
19048, 1.5478260869565, 1.75, 0.36111111111111
19049, 1.5260869565217, 1.75, 0.33333333333333
19050, 1.5478260869565, 1.75, 0.30555555555556
19051, 1.5260869565217, 1.75, 0.27777777777778
19052, 1.5478260869565, 1.75, 0.25
19053, 1.5260869565217, 1.75, 0.22222222222222
19054, 1.5478260869565, 1.75, 0.19444444444444
19055, 1.5260869565217, 1.75, 0.16666666666667
19056, 1.5478260869565, 1.75, 0.13888888888889
19057, 1.5260869565217, 1.75, 0.11111111111111
19058, 1.5478260869565, 1.75, 0.083333333333333
19059, 1.5260869565217, 1.75, 0.055555555555556
19060, 1.5478260869565, 1.75, 0.027777777777778
19061, 1.5913043478261, 1.75, 0.47222222222222
19062, 1.5695652173913, 1.75, 0.44444444444444
19063, 1.5913043478261, 1.75, 0.41666666666667
19064, 1.5695652173913, 1.75, 0.38888888888889
19065, 1.5913043478261, 1.75, 0.36111111111111
19066, 1.5695652173913, 1.75, 0.33333333333333
19067, 1.5913043478261, 1.75, 0.30555555555556
19068, 1.5695652173913, 1.75, 0.27777777777778
19069, 1.5913043478261, 1.75, 0.25
19070, 1.5695652173913, 1.75, 0.22222222222222
19071, 1.5913043478261, 1.75, 0.19444444444444
19072, 1.5695652173913, 1.75, 0.16666666666667
19073, 1.5913043478261, 1.75, 0.13888888888889
19074, 1.5695652173913, 1.75, 0.11111111111111
19075, 1.5913043478261, 1.75, 0.083333333333333
19076, 1.5695652173913, 1.75, 0.055555555555556
19077, 1.5913043478261, 1.75, 0.027777777777778
19078, 1.6347826086957, 1.75, 0.47222222222222
19079, 1.6130434782609, 1.75, 0.44444444444444
19080, 1.6347826086957, 1.75, 0.41666666666667
19081, 1.6130434782609, 1.75, 0.38888888888889
19082, 1.6347826086957, 1.75, 0.36111111111111
19083, 1.6130434782609, 1.75, 0.33333333333333
19084, 1.6347826086957, 1.75, 0.30555555555556
19085, 1.6130434782609, 1.75, 0.27777777777778
19086, 1.6347826086957, 1.75, 0.25
19087, 1.6130434782609, 1.75, 0.22222222222222
19088, 1.6347826086957, 1.75, 0.19444444444444
19089, 1.6130434782609, 1.75, 0.16666666666667
19090, 1.6347826086957, 1.75, 0.13888888888889
19091, 1.6130434782609, 1.75, 0.11111111111111
19092, 1.6347826086957, 1.75, 0.083333333333333
19093, 1.6130434782609, 1.75, 0.055555555555556
19094, 1.6347826086957, 1.75, 0.027777777777778
19095, 1.6782608695652, 1.75, 0.47222222222222
19096, 1.6565217391304, 1.75, 0.44444444444444
19097, 1.6782608695652, 1.75, 0.41666666666667
19098, 1.6565217391304, 1.75, 0.38888888888889
19099, 1.6782608695652, 1.75, 0.36111111111111
19100, 1.6565217391304, 1.75, 0.33333333333333
19101, 1.6782608695652, 1.75, 0.30555555555556
19102, 1.6565217391304, 1.75, 0.27777777777778
19103, 1.6782608695652, 1.75, 0.25
19104, 1.6565217391304, 1.75, 0.22222222222222
19105, 1.6782608695652, 1.75, 0.19444444444444
19106, 1.6565217391304, 1.75, 0.16666666666667
19107, 1.6782608695652, 1.75, 0.13888888888889
19108, 1.6565217391304, 1.75, 0.11111111111111
19109, 1.6782608695652, 1.75, 0.083333333333333
19110, 1.6565217391304, 1.75, 0.055555555555556
19111, 1.6782608695652, 1.75, 0.027777777777778
19112, 1.7217391304348, 1.75, 0.47222222222222
19113, 1.7, 1.75, 0.44444444444444
19114, 1.7217391304348, 1.75, 0.41666666666667
19115, 1.7, 1.75, 0.38888888888889
19116, 1.7217391304348, 1.75, 0.36111111111111
19117, 1.7, 1.75, 0.33333333333333
19118, 1.7217391304348, 1.75, 0.30555555555556
19119, 1.7, 1.75, 0.27777777777778
19120, 1.7217391304348, 1.75, 0.25
19121, 1.7, 1.75, 0.22222222222222
19122, 1.7217391304348, 1.75, 0.19444444444444
19123, 1.7, 1.75, 0.16666666666667
19124, 1.7217391304348, 1.75, 0.13888888888889
19125, 1.7, 1.75, 0.11111111111111
19126, 1.7217391304348, 1.75, 0.083333333333333
19127, 1.7, 1.75, 0.055555555555556
19128, 1.7217391304348, 1.75, 0.027777777777778
19129, 1.7652173913043, 1.75, 0.47222222222222
19130, 1.7434782608696, 1.75, 0.44444444444444
19131, 1.7652173913043, 1.75, 0.41666666666667
19132, 1.7434782608696, 1.75, 0.38888888888889
19133, 1.7652173913043, 1.75, 0.36111111111111
19134, 1.7434782608696, 1.75, 0.33333333333333
19135, 1.7652173913043, 1.75, 0.30555555555556
19136, 1.7434782608696, 1.75, 0.27777777777778
19137, 1.7652173913043, 1.75, 0.25
19138, 1.7434782608696, 1.75, 0.22222222222222
19139, 1.7652173913043, 1.75, 0.19444444444444
19140, 1.7434782608696, 1.75, 0.16666666666667
19141, 1.7652173913043, 1.75, 0.13888888888889
19142, 1.7434782608696, 1.75, 0.11111111111111
19143, 1.7652173913043, 1.75, 0.083333333333333
19144, 1.7434782608696, 1.75, 0.055555555555556
19145, 1.7652173913043, 1.75, 0.027777777777778
19146, 1.8086956521739, 1.75, 0.47222222222222
19147, 1.7869565217391, 1.75, 0.44444444444444
19148, 1.8086956521739, 1.75, 0.41666666666667
19149, 1.7869565217391, 1.75, 0.38888888888889
19150, 1.8086956521739, 1.75, 0.36111111111111
19151, 1.7869565217391, 1.75, 0.33333333333333
19152, 1.8086956521739, 1.75, 0.30555555555556
19153, 1.7869565217391, 1.75, 0.27777777777778
19154, 1.8086956521739, 1.75, 0.25
19155, 1.7869565217391, 1.75, 0.22222222222222
19156, 1.8086956521739, 1.75, 0.19444444444444
19157, 1.7869565217391, 1.75, 0.16666666666667
19158, 1.8086956521739, 1.75, 0.13888888888889
19159, 1.7869565217391, 1.75, 0.11111111111111
19160, 1.8086956521739, 1.75, 0.083333333333333
19161, 1.7869565217391, 1.75, 0.055555555555556
19162, 1.8086956521739, 1.75, 0.027777777777778
19163, 1.8521739130435, 1.75, 0.47222222222222
19164, 1.8304347826087, 1.75, 0.44444444444444
19165, 1.8521739130435, 1.75, 0.41666666666667
19166, 1.8304347826087, 1.75, 0.38888888888889
19167, 1.8521739130435, 1.75, 0.36111111111111
19168, 1.8304347826087, 1.75, 0.33333333333333
19169, 1.8521739130435, 1.75, 0.30555555555556
19170, 1.8304347826087, 1.75, 0.27777777777778
19171, 1.8521739130435, 1.75, 0.25
19172, 1.8304347826087, 1.75, 0.22222222222222
19173, 1.8521739130435, 1.75, 0.19444444444444
19174, 1.8304347826087, 1.75, 0.16666666666667
19175, 1.8521739130435, 1.75, 0.13888888888889
19176, 1.8304347826087, 1.75, 0.11111111111111
19177, 1.8521739130435, 1.75, 0.083333333333333
19178, 1.8304347826087, 1.75, 0.055555555555556
19179, 1.8521739130435, 1.75, 0.027777777777778
19180, 1.895652173913, 1.75, 0.47222222222222
19181, 1.8739130434783, 1.75, 0.44444444444444
19182, 1.895652173913, 1.75, 0.41666666666667
19183, 1.8739130434783, 1.75, 0.38888888888889
19184, 1.895652173913, 1.75, 0.36111111111111
19185, 1.8739130434783, 1.75, 0.33333333333333
19186, 1.895652173913, 1.75, 0.30555555555556
19187, 1.8739130434783, 1.75, 0.27777777777778
19188, 1.895652173913, 1.75, 0.25
19189, 1.8739130434783, 1.75, 0.22222222222222
19190, 1.895652173913, 1.75, 0.19444444444444
19191, 1.8739130434783, 1.75, 0.16666666666667
19192, 1.895652173913, 1.75, 0.13888888888889
19193, 1.8739130434783, 1.75, 0.11111111111111
19194, 1.895652173913, 1.75, 0.083333333333333
19195, 1.8739130434783, 1.75, 0.055555555555556
19196, 1.895652173913, 1.75, 0.027777777777778
19197, 1.9391304347826, 1.75, 0.47222222222222
19198, 1.9173913043478, 1.75, 0.44444444444444
19199, 1.9391304347826, 1.75, 0.41666666666667
19200, 1.9173913043478, 1.75, 0.38888888888889
19201, 1.9391304347826, 1.75, 0.36111111111111
19202, 1.9173913043478, 1.75, 0.33333333333333
19203, 1.9391304347826, 1.75, 0.30555555555556
19204, 1.9173913043478, 1.75, 0.27777777777778
19205, 1.9391304347826, 1.75, 0.25
19206, 1.9173913043478, 1.75, 0.22222222222222
19207, 1.9391304347826, 1.75, 0.19444444444444
19208, 1.9173913043478, 1.75, 0.16666666666667
19209, 1.9391304347826, 1.75, 0.13888888888889
19210, 1.9173913043478, 1.75, 0.11111111111111
19211, 1.9391304347826, 1.75, 0.083333333333333
19212, 1.9173913043478, 1.75, 0.055555555555556
19213, 1.9391304347826, 1.75, 0.027777777777778
19214, 1.9826086956522, 1.75, 0.47222222222222
19215, 1.9608695652174, 1.75, 0.44444444444444
19216, 1.9826086956522, 1.75, 0.41666666666667
19217, 1.9608695652174, 1.75, 0.38888888888889
19218, 1.9826086956522, 1.75, 0.36111111111111
19219, 1.9608695652174, 1.75, 0.33333333333333
19220, 1.9826086956522, 1.75, 0.30555555555556
19221, 1.9608695652174, 1.75, 0.27777777777778
19222, 1.9826086956522, 1.75, 0.25
19223, 1.9608695652174, 1.75, 0.22222222222222
19224, 1.9826086956522, 1.75, 0.19444444444444
19225, 1.9608695652174, 1.75, 0.16666666666667
19226, 1.9826086956522, 1.75, 0.13888888888889
19227, 1.9608695652174, 1.75, 0.11111111111111
19228, 1.9826086956522, 1.75, 0.083333333333333
19229, 1.9608695652174, 1.75, 0.055555555555556
19230, 1.9826086956522, 1.75, 0.027777777777778
19231, 2.0260869565217, 1.75, 0.47222222222222
19232, 2.004347826087, 1.75, 0.44444444444444
19233, 2.0260869565217, 1.75, 0.41666666666667
19234, 2.004347826087, 1.75, 0.38888888888889
19235, 2.0260869565217, 1.75, 0.36111111111111
19236, 2.004347826087, 1.75, 0.33333333333333
19237, 2.0260869565217, 1.75, 0.30555555555556
19238, 2.004347826087, 1.75, 0.27777777777778
19239, 2.0260869565217, 1.75, 0.25
19240, 2.004347826087, 1.75, 0.22222222222222
19241, 2.0260869565217, 1.75, 0.19444444444444
19242, 2.004347826087, 1.75, 0.16666666666667
19243, 2.0260869565217, 1.75, 0.13888888888889
19244, 2.004347826087, 1.75, 0.11111111111111
19245, 2.0260869565217, 1.75, 0.083333333333333
19246, 2.004347826087, 1.75, 0.055555555555556
19247, 2.0260869565217, 1.75, 0.027777777777778
19248, 2.0695652173913, 1.75, 0.47222222222222
19249, 2.0478260869565, 1.75, 0.44444444444444
19250, 2.0695652173913, 1.75, 0.41666666666667
19251, 2.0478260869565, 1.75, 0.38888888888889
19252, 2.0695652173913, 1.75, 0.36111111111111
19253, 2.0478260869565, 1.75, 0.33333333333333
19254, 2.0695652173913, 1.75, 0.30555555555556
19255, 2.0478260869565, 1.75, 0.27777777777778
19256, 2.0695652173913, 1.75, 0.25
19257, 2.0478260869565, 1.75, 0.22222222222222
19258, 2.0695652173913, 1.75, 0.19444444444444
19259, 2.0478260869565, 1.75, 0.16666666666667
19260, 2.0695652173913, 1.75, 0.13888888888889
19261, 2.0478260869565, 1.75, 0.11111111111111
19262, 2.0695652173913, 1.75, 0.083333333333333
19263, 2.0478260869565, 1.75, 0.055555555555556
19264, 2.0695652173913, 1.75, 0.027777777777778
19265, 2.1130434782609, 1.75, 0.47222222222222
19266, 2.0913043478261, 1.75, 0.44444444444444
19267, 2.1130434782609, 1.75, 0.41666666666667
19268, 2.0913043478261, 1.75, 0.38888888888889
19269, 2.1130434782609, 1.75, 0.36111111111111
19270, 2.0913043478261, 1.75, 0.33333333333333
19271, 2.1130434782609, 1.75, 0.30555555555556
19272, 2.0913043478261, 1.75, 0.27777777777778
19273, 2.1130434782609, 1.75, 0.25
19274, 2.0913043478261, 1.75, 0.22222222222222
19275, 2.1130434782609, 1.75, 0.19444444444444
19276, 2.0913043478261, 1.75, 0.16666666666667
19277, 2.1130434782609, 1.75, 0.13888888888889
19278, 2.0913043478261, 1.75, 0.11111111111111
19279, 2.1130434782609, 1.75, 0.083333333333333
19280, 2.0913043478261, 1.75, 0.055555555555556
19281, 2.1130434782609, 1.75, 0.027777777777778
19282, 2.1565217391304, 1.75, 0.47222222222222
19283, 2.1347826086957, 1.75, 0.44444444444444
19284, 2.1565217391304, 1.75, 0.41666666666667
19285, 2.1347826086957, 1.75, 0.38888888888889
19286, 2.1565217391304, 1.75, 0.36111111111111
19287, 2.1347826086957, 1.75, 0.33333333333333
19288, 2.1565217391304, 1.75, 0.30555555555556
19289, 2.1347826086957, 1.75, 0.27777777777778
19290, 2.1565217391304, 1.75, 0.25
19291, 2.1347826086957, 1.75, 0.22222222222222
19292, 2.1565217391304, 1.75, 0.19444444444444
19293, 2.1347826086957, 1.75, 0.16666666666667
19294, 2.1565217391304, 1.75, 0.13888888888889
19295, 2.1347826086957, 1.75, 0.11111111111111
19296, 2.1565217391304, 1.75, 0.083333333333333
19297, 2.1347826086957, 1.75, 0.055555555555556
19298, 2.1565217391304, 1.75, 0.027777777777778
19299, 2.1782608695652, 1.75, 0.44444444444444
19300, 2.1782608695652, 1.75, 0.38888888888889
19301, 2.1782608695652, 1.75, 0.33333333333333
19302, 2.1782608695652, 1.75, 0.27777777777778
19303, 2.1782608695652, 1.75, 0.22222222222222
19304, 2.1782608695652, 1.75, 0.16666666666667
19305, 2.1782608695652, 1.75, 0.11111111111111
19306, 2.1782608695652, 1.75, 0.055555555555556
19307, 2.25, 1.6, 0.5
19308, 2.25, 1.65, 0.5
19309, 2.25, 1.7, 0.5
19310, 2.25, 1.575, 0.5
19311, 2.225, 1.6, 0.5
19312, 2.25, 1.625, 0.5
19313, 2.225, 1.65, 0.5
19314, 2.25, 1.675, 0.5
19315, 2.225, 1.7, 0.5
19316, 2.25, 1.725, 0.5
19317, 2.275, 1.6, 0.5
19318, 2.275, 1.65, 0.5
19319, 2.275, 1.7, 0.5
19320, 2.25, 1.6, 0
19321, 2.25, 1.65, 0
19322, 2.25, 1.7, 0
19323, 2.225, 1.6, 0
19324, 2.25, 1.575, 0
19325, 2.225, 1.65, 0
19326, 2.25, 1.625, 0
19327, 2.225, 1.7, 0
19328, 2.25, 1.675, 0
19329, 2.25, 1.725, 0
19330, 2.275, 1.6, 0
19331, 2.275, 1.65, 0
19332, 2.275, 1.7, 0
19333, 2.25, 1.55, 0.44444444444444
19334, 2.25, 1.55, 0.38888888888889
19335, 2.25, 1.55, 0.33333333333333
19336, 2.25, 1.55, 0.27777777777778
19337, 2.25, 1.55, 0.22222222222222
19338, 2.25, 1.55, 0.16666666666667
19339, 2.25, 1.55, 0.11111111111111
19340, 2.25, 1.55, 0.055555555555556
19341, 2.225, 1.55, 0.44444444444444
19342, 2.25, 1.55, 0.47222222222222
19343, 2.225, 1.55, 0.38888888888889
19344, 2.25, 1.55, 0.41666666666667
19345, 2.225, 1.55, 0.33333333333333
19346, 2.25, 1.55, 0.36111111111111
19347, 2.225, 1.55, 0.27777777777778
19348, 2.25, 1.55, 0.30555555555556
19349, 2.225, 1.55, 0.22222222222222
19350, 2.25, 1.55, 0.25
19351, 2.225, 1.55, 0.16666666666667
19352, 2.25, 1.55, 0.19444444444444
19353, 2.225, 1.55, 0.11111111111111
19354, 2.25, 1.55, 0.13888888888889
19355, 2.225, 1.55, 0.055555555555556
19356, 2.25, 1.55, 0.083333333333333
19357, 2.25, 1.55, 0.027777777777778
19358, 2.275, 1.55, 0.44444444444444
19359, 2.275, 1.55, 0.38888888888889
19360, 2.275, 1.55, 0.33333333333333
19361, 2.275, 1.55, 0.27777777777778
19362, 2.275, 1.55, 0.22222222222222
19363, 2.275, 1.55, 0.16666666666667
19364, 2.275, 1.55, 0.11111111111111
19365, 2.275, 1.55, 0.055555555555556
19366, 2.25, 1.75, 0.44444444444444
19367, 2.25, 1.75, 0.38888888888889
19368, 2.25, 1.75, 0.33333333333333
19369, 2.25, 1.75, 0.27777777777778
19370, 2.25, 1.75, 0.22222222222222
19371, 2.25, 1.75, 0.16666666666667
19372, 2.25, 1.75, 0.11111111111111
19373, 2.25, 1.75, 0.055555555555556
19374, 2.25, 1.75, 0.47222222222222
19375, 2.225, 1.75, 0.44444444444444
19376, 2.25, 1.75, 0.41666666666667
19377, 2.225, 1.75, 0.38888888888889
19378, 2.25, 1.75, 0.36111111111111
19379, 2.225, 1.75, 0.33333333333333
19380, 2.25, 1.75, 0.30555555555556
19381, 2.225, 1.75, 0.27777777777778
19382, 2.25, 1.75, 0.25
19383, 2.225, 1.75, 0.22222222222222
19384, 2.25, 1.75, 0.19444444444444
19385, 2.225, 1.75, 0.16666666666667
19386, 2.25, 1.75, 0.13888888888889
19387, 2.225, 1.75, 0.11111111111111
19388, 2.25, 1.75, 0.083333333333333
19389, 2.225, 1.75, 0.055555555555556
19390, 2.25, 1.75, 0.027777777777778
19391, 2.275, 1.75, 0.44444444444444
19392, 2.275, 1.75, 0.38888888888889
19393, 2.275, 1.75, 0.33333333333333
19394, 2.275, 1.75, 0.27777777777778
19395, 2.275, 1.75, 0.22222222222222
19396, 2.275, 1.75, 0.16666666666667
19397, 2.275, 1.75, 0.11111111111111
19398, 2.275, 1.75, 0.055555555555556
19399, 2.3, 1.6, 0.44444444444444
19400, 2.3, 1.6, 0.38888888888889
19401, 2.3, 1.6, 0.33333333333333
19402, 2.3, 1.6, 0.27777777777778
19403, 2.3, 1.6, 0.22222222222222
19404, 2.3, 1.6, 0.16666666666667
19405, 2.3, 1.6, 0.11111111111111
19406, 2.3, 1.6, 0.055555555555556
19407, 2.3, 1.65, 0.44444444444444
19408, 2.3, 1.65, 0.38888888888889
19409, 2.3, 1.65, 0.33333333333333
19410, 2.3, 1.65, 0.27777777777778
19411, 2.3, 1.65, 0.22222222222222
19412, 2.3, 1.65, 0.16666666666667
19413, 2.3, 1.65, 0.11111111111111
19414, 2.3, 1.65, 0.055555555555556
19415, 2.3, 1.7, 0.44444444444444
19416, 2.3, 1.7, 0.38888888888889
19417, 2.3, 1.7, 0.33333333333333
19418, 2.3, 1.7, 0.27777777777778
19419, 2.3, 1.7, 0.22222222222222
19420, 2.3, 1.7, 0.16666666666667
19421, 2.3, 1.7, 0.11111111111111
19422, 2.3, 1.7, 0.055555555555556
19423, 2.3, 1.575, 0.44444444444444
19424, 2.3, 1.6, 0.47222222222222
19425, 2.3, 1.575, 0.38888888888889
19426, 2.3, 1.6, 0.41666666666667
19427, 2.3, 1.575, 0.33333333333333
19428, 2.3, 1.6, 0.36111111111111
19429, 2.3, 1.575, 0.27777777777778
19430, 2.3, 1.6, 0.30555555555556
19431, 2.3, 1.575, 0.22222222222222
19432, 2.3, 1.6, 0.25
19433, 2.3, 1.575, 0.16666666666667
19434, 2.3, 1.6, 0.19444444444444
19435, 2.3, 1.575, 0.11111111111111
19436, 2.3, 1.6, 0.13888888888889
19437, 2.3, 1.575, 0.055555555555556
19438, 2.3, 1.6, 0.083333333333333
19439, 2.3, 1.6, 0.027777777777778
19440, 2.3, 1.625, 0.44444444444444
19441, 2.3, 1.65, 0.47222222222222
19442, 2.3, 1.625, 0.38888888888889
19443, 2.3, 1.65, 0.41666666666667
19444, 2.3, 1.625, 0.33333333333333
19445, 2.3, 1.65, 0.36111111111111
19446, 2.3, 1.625, 0.27777777777778
19447, 2.3, 1.65, 0.30555555555556
19448, 2.3, 1.625, 0.22222222222222
19449, 2.3, 1.65, 0.25
19450, 2.3, 1.625, 0.16666666666667
19451, 2.3, 1.65, 0.19444444444444
19452, 2.3, 1.625, 0.11111111111111
19453, 2.3, 1.65, 0.13888888888889
19454, 2.3, 1.625, 0.055555555555556
19455, 2.3, 1.65, 0.083333333333333
19456, 2.3, 1.65, 0.027777777777778
19457, 2.3, 1.675, 0.44444444444444
19458, 2.3, 1.7, 0.47222222222222
19459, 2.3, 1.675, 0.38888888888889
19460, 2.3, 1.7, 0.41666666666667
19461, 2.3, 1.675, 0.33333333333333
19462, 2.3, 1.7, 0.36111111111111
19463, 2.3, 1.675, 0.27777777777778
19464, 2.3, 1.7, 0.30555555555556
19465, 2.3, 1.675, 0.22222222222222
19466, 2.3, 1.7, 0.25
19467, 2.3, 1.675, 0.16666666666667
19468, 2.3, 1.7, 0.19444444444444
19469, 2.3, 1.675, 0.11111111111111
19470, 2.3, 1.7, 0.13888888888889
19471, 2.3, 1.675, 0.055555555555556
19472, 2.3, 1.7, 0.083333333333333
19473, 2.3, 1.7, 0.027777777777778
19474, 2.3, 1.725, 0.44444444444444
19475, 2.3, 1.725, 0.38888888888889
19476, 2.3, 1.725, 0.33333333333333
19477, 2.3, 1.725, 0.27777777777778
19478, 2.3, 1.725, 0.22222222222222
19479, 2.3, 1.725, 0.16666666666667
19480, 2.3, 1.725, 0.11111111111111
19481, 2.3, 1.725, 0.055555555555556
19482, 0.95652173913043, 0.125, 0
19483, 0.91304347826087, 0.125, 0
19484, 0.8695652173913, 0.125, 0
19485, 0.82608695652174, 0.125, 0
19486, 0.78260869565217, 0.125, 0
19487, 0.73913043478261, 0.125, 0
19488, 0.69565217391304, 0.125, 0
19489, 0.65217391304348, 0.125, 0
19490, 0.60869565217391, 0.125, 0
19491, 0.56521739130435, 0.125, 0
19492, 0.52173913043478, 0.125, 0
19493, 0.47826086956522, 0.125, 0
19494, 0.43478260869565, 0.125, 0
19495, 0.39130434782609, 0.125, 0
19496, 0.34782608695652, 0.125, 0
19497, 0.30434782608696, 0.125, 0
19498, 0.26086956521739, 0.125, 0
19499, 0.21739130434783, 0.125, 0
19500, 0.17391304347826, 0.125, 0
19501, 0.1304347826087, 0.125, 0
19502, 0.08695652173913, 0.125, 0
19503, 0.043478260869565, 0.125, 0
19504, 0.95652173913043, 0.1125, 0
19505, 0.97826086956522, 0.125, 0
19506, 0.91304347826087, 0.1125, 0
19507, 0.93478260869565, 0.125, 0
19508, 0.8695652173913, 0.1125, 0
19509, 0.89130434782609, 0.125, 0
19510, 0.82608695652174, 0.1125, 0
19511, 0.84782608695652, 0.125, 0
19512, 0.78260869565217, 0.1125, 0
19513, 0.80434782608696, 0.125, 0
19514, 0.73913043478261, 0.1125, 0
19515, 0.76086956521739, 0.125, 0
19516, 0.69565217391304, 0.1125, 0
19517, 0.71739130434783, 0.125, 0
19518, 0.65217391304348, 0.1125, 0
19519, 0.67391304347826, 0.125, 0
19520, 0.60869565217391, 0.1125, 0
19521, 0.6304347826087, 0.125, 0
19522, 0.56521739130435, 0.1125, 0
19523, 0.58695652173913, 0.125, 0
19524, 0.52173913043478, 0.1125, 0
19525, 0.54347826086957, 0.125, 0
19526, 0.47826086956522, 0.1125, 0
19527, 0.5, 0.125, 0
19528, 0.43478260869565, 0.1125, 0
19529, 0.45652173913043, 0.125, 0
19530, 0.39130434782609, 0.1125, 0
19531, 0.41304347826087, 0.125, 0
19532, 0.34782608695652, 0.1125, 0
19533, 0.3695652173913, 0.125, 0
19534, 0.30434782608696, 0.1125, 0
19535, 0.32608695652174, 0.125, 0
19536, 0.26086956521739, 0.1125, 0
19537, 0.28260869565217, 0.125, 0
19538, 0.21739130434783, 0.1125, 0
19539, 0.23913043478261, 0.125, 0
19540, 0.17391304347826, 0.1125, 0
19541, 0.19565217391304, 0.125, 0
19542, 0.1304347826087, 0.1125, 0
19543, 0.15217391304348, 0.125, 0
19544, 0.08695652173913, 0.1125, 0
19545, 0.10869565217391, 0.125, 0
19546, 0.043478260869565, 0.1125, 0
19547, 0.065217391304348, 0.125, 0
19548, 0.021739130434783, 0.125, 0
19549, 0.95652173913043, 0.1375, 0
19550, 0.91304347826087, 0.1375, 0
19551, 0.8695652173913, 0.1375, 0
19552, 0.82608695652174, 0.1375, 0
19553, 0.78260869565217, 0.1375, 0
19554, 0.73913043478261, 0.1375, 0
19555, 0.69565217391304, 0.1375, 0
19556, 0.65217391304348, 0.1375, 0
19557, 0.60869565217391, 0.1375, 0
19558, 0.56521739130435, 0.1375, 0
19559, 0.52173913043478, 0.1375, 0
19560, 0.47826086956522, 0.1375, 0
19561, 0.43478260869565, 0.1375, 0
19562, 0.39130434782609, 0.1375, 0
19563, 0.34782608695652, 0.1375, 0
19564, 0.30434782608696, 0.1375, 0
19565, 0.26086956521739, 0.1375, 0
19566, 0.21739130434783, 0.1375, 0
19567, 0.17391304347826, 0.1375, 0
19568, 0.1304347826087, 0.1375, 0
19569, 0.08695652173913, 0.1375, 0
19570, 0.043478260869565, 0.1375, 0
19571, 1, 0.125, 0.44444444444444
19572, 1, 0.125, 0.38888888888889
19573, 1, 0.125, 0.33333333333333
19574, 1, 0.125, 0.27777777777778
19575, 1, 0.125, 0.22222222222222
19576, 1, 0.125, 0.16666666666667
19577, 1, 0.125, 0.11111111111111
19578, 1, 0.125, 0.055555555555556
19579, 1, 0.1125, 0.44444444444444
19580, 1, 0.125, 0.47222222222222
19581, 1, 0.1125, 0.38888888888889
19582, 1, 0.125, 0.41666666666667
19583, 1, 0.1125, 0.33333333333333
19584, 1, 0.125, 0.36111111111111
19585, 1, 0.1125, 0.27777777777778
19586, 1, 0.125, 0.30555555555556
19587, 1, 0.1125, 0.22222222222222
19588, 1, 0.125, 0.25
19589, 1, 0.1125, 0.16666666666667
19590, 1, 0.125, 0.19444444444444
19591, 1, 0.1125, 0.11111111111111
19592, 1, 0.125, 0.13888888888889
19593, 1, 0.1125, 0.055555555555556
19594, 1, 0.125, 0.083333333333333
19595, 1, 0.125, 0.027777777777778
19596, 1, 0.1375, 0.44444444444444
19597, 1, 0.1375, 0.38888888888889
19598, 1, 0.1375, 0.33333333333333
19599, 1, 0.1375, 0.27777777777778
19600, 1, 0.1375, 0.22222222222222
19601, 1, 0.1375, 0.16666666666667
19602, 1, 0.1375, 0.11111111111111
19603, 1, 0.1375, 0.055555555555556
19604, 0.95652173913043, 0.125, 0.5
19605, 0.91304347826087, 0.125, 0.5
19606, 0.8695652173913, 0.125, 0.5
19607, 0.82608695652174, 0.125, 0.5
19608, 0.78260869565217, 0.125, 0.5
19609, 0.73913043478261, 0.125, 0.5
19610, 0.69565217391304, 0.125, 0.5
19611, 0.65217391304348, 0.125, 0.5
19612, 0.60869565217391, 0.125, 0.5
19613, 0.56521739130435, 0.125, 0.5
19614, 0.52173913043478, 0.125, 0.5
19615, 0.47826086956522, 0.125, 0.5
19616, 0.43478260869565, 0.125, 0.5
19617, 0.39130434782609, 0.125, 0.5
19618, 0.34782608695652, 0.125, 0.5
19619, 0.30434782608696, 0.125, 0.5
19620, 0.26086956521739, 0.125, 0.5
19621, 0.21739130434783, 0.125, 0.5
19622, 0.17391304347826, 0.125, 0.5
19623, 0.1304347826087, 0.125, 0.5
19624, 0.08695652173913, 0.125, 0.5
19625, 0.043478260869565, 0.125, 0.5
19626, 0.97826086956522, 0.125, 0.5
19627, 0.95652173913043, 0.1125, 0.5
19628, 0.93478260869565, 0.125, 0.5
19629, 0.91304347826087, 0.1125, 0.5
19630, 0.89130434782609, 0.125, 0.5
19631, 0.8695652173913, 0.1125, 0.5
19632, 0.84782608695652, 0.125, 0.5
19633, 0.82608695652174, 0.1125, 0.5
19634, 0.80434782608696, 0.125, 0.5
19635, 0.78260869565217, 0.1125, 0.5
19636, 0.76086956521739, 0.125, 0.5
19637, 0.73913043478261, 0.1125, 0.5
19638, 0.71739130434783, 0.125, 0.5
19639, 0.69565217391304, 0.1125, 0.5
19640, 0.67391304347826, 0.125, 0.5
19641, 0.65217391304348, 0.1125, 0.5
19642, 0.6304347826087, 0.125, 0.5
19643, 0.60869565217391, 0.1125, 0.5
19644, 0.58695652173913, 0.125, 0.5
19645, 0.56521739130435, 0.1125, 0.5
19646, 0.54347826086957, 0.125, 0.5
19647, 0.52173913043478, 0.1125, 0.5
19648, 0.5, 0.125, 0.5
19649, 0.47826086956522, 0.1125, 0.5
19650, 0.45652173913043, 0.125, 0.5
19651, 0.43478260869565, 0.1125, 0.5
19652, 0.41304347826087, 0.125, 0.5
19653, 0.39130434782609, 0.1125, 0.5
19654, 0.3695652173913, 0.125, 0.5
19655, 0.34782608695652, 0.1125, 0.5
19656, 0.32608695652174, 0.125, 0.5
19657, 0.30434782608696, 0.1125, 0.5
19658, 0.28260869565217, 0.125, 0.5
19659, 0.26086956521739, 0.1125, 0.5
19660, 0.23913043478261, 0.125, 0.5
19661, 0.21739130434783, 0.1125, 0.5
19662, 0.19565217391304, 0.125, 0.5
19663, 0.17391304347826, 0.1125, 0.5
19664, 0.15217391304348, 0.125, 0.5
19665, 0.1304347826087, 0.1125, 0.5
19666, 0.10869565217391, 0.125, 0.5
19667, 0.08695652173913, 0.1125, 0.5
19668, 0.065217391304348, 0.125, 0.5
19669, 0.043478260869565, 0.1125, 0.5
19670, 0.021739130434783, 0.125, 0.5
19671, 0.95652173913043, 0.1375, 0.5
19672, 0.91304347826087, 0.1375, 0.5
19673, 0.8695652173913, 0.1375, 0.5
19674, 0.82608695652174, 0.1375, 0.5
19675, 0.78260869565217, 0.1375, 0.5
19676, 0.73913043478261, 0.1375, 0.5
19677, 0.69565217391304, 0.1375, 0.5
19678, 0.65217391304348, 0.1375, 0.5
19679, 0.60869565217391, 0.1375, 0.5
19680, 0.56521739130435, 0.1375, 0.5
19681, 0.52173913043478, 0.1375, 0.5
19682, 0.47826086956522, 0.1375, 0.5
19683, 0.43478260869565, 0.1375, 0.5
19684, 0.39130434782609, 0.1375, 0.5
19685, 0.34782608695652, 0.1375, 0.5
19686, 0.30434782608696, 0.1375, 0.5
19687, 0.26086956521739, 0.1375, 0.5
19688, 0.21739130434783, 0.1375, 0.5
19689, 0.17391304347826, 0.1375, 0.5
19690, 0.1304347826087, 0.1375, 0.5
19691, 0.08695652173913, 0.1375, 0.5
19692, 0.043478260869565, 0.1375, 0.5
19693, 0, 0.125, 0.44444444444444
19694, 0, 0.125, 0.38888888888889
19695, 0, 0.125, 0.33333333333333
19696, 0, 0.125, 0.27777777777778
19697, 0, 0.125, 0.22222222222222
19698, 0, 0.125, 0.16666666666667
19699, 0, 0.125, 0.11111111111111
19700, 0, 0.125, 0.055555555555556
19701, 0, 0.125, 0.47222222222222
19702, 0, 0.1125, 0.44444444444444
19703, 0, 0.125, 0.41666666666667
19704, 0, 0.1125, 0.38888888888889
19705, 0, 0.125, 0.36111111111111
19706, 0, 0.1125, 0.33333333333333
19707, 0, 0.125, 0.30555555555556
19708, 0, 0.1125, 0.27777777777778
19709, 0, 0.125, 0.25
19710, 0, 0.1125, 0.22222222222222
19711, 0, 0.125, 0.19444444444444
19712, 0, 0.1125, 0.16666666666667
19713, 0, 0.125, 0.13888888888889
19714, 0, 0.1125, 0.11111111111111
19715, 0, 0.125, 0.083333333333333
19716, 0, 0.1125, 0.055555555555556
19717, 0, 0.125, 0.027777777777778
19718, 0, 0.1375, 0.44444444444444
19719, 0, 0.1375, 0.38888888888889
19720, 0, 0.1375, 0.33333333333333
19721, 0, 0.1375, 0.27777777777778
19722, 0, 0.1375, 0.22222222222222
19723, 0, 0.1375, 0.16666666666667
19724, 0, 0.1375, 0.11111111111111
19725, 0, 0.1375, 0.055555555555556
19726, 0.043478260869565, 0.1, 0.055555555555556
19727, 0.043478260869565, 0.1, 0.11111111111111
19728, 0.043478260869565, 0.1, 0.16666666666667
19729, 0.043478260869565, 0.1, 0.22222222222222
19730, 0.043478260869565, 0.1, 0.27777777777778
19731, 0.043478260869565, 0.1, 0.33333333333333
19732, 0.043478260869565, 0.1, 0.38888888888889
19733, 0.043478260869565, 0.1, 0.44444444444444
19734, 0.08695652173913, 0.1, 0.055555555555556
19735, 0.08695652173913, 0.1, 0.11111111111111
19736, 0.08695652173913, 0.1, 0.16666666666667
19737, 0.08695652173913, 0.1, 0.22222222222222
19738, 0.08695652173913, 0.1, 0.27777777777778
19739, 0.08695652173913, 0.1, 0.33333333333333
19740, 0.08695652173913, 0.1, 0.38888888888889
19741, 0.08695652173913, 0.1, 0.44444444444444
19742, 0.1304347826087, 0.1, 0.055555555555556
19743, 0.1304347826087, 0.1, 0.11111111111111
19744, 0.1304347826087, 0.1, 0.16666666666667
19745, 0.1304347826087, 0.1, 0.22222222222222
19746, 0.1304347826087, 0.1, 0.27777777777778
19747, 0.1304347826087, 0.1, 0.33333333333333
19748, 0.1304347826087, 0.1, 0.38888888888889
19749, 0.1304347826087, 0.1, 0.44444444444444
19750, 0.17391304347826, 0.1, 0.055555555555556
19751, 0.17391304347826, 0.1, 0.11111111111111
19752, 0.17391304347826, 0.1, 0.16666666666667
19753, 0.17391304347826, 0.1, 0.22222222222222
19754, 0.17391304347826, 0.1, 0.27777777777778
19755, 0.17391304347826, 0.1, 0.33333333333333
19756, 0.17391304347826, 0.1, 0.38888888888889
19757, 0.17391304347826, 0.1, 0.44444444444444
19758, 0.21739130434783, 0.1, 0.055555555555556
19759, 0.21739130434783, 0.1, 0.11111111111111
19760, 0.21739130434783, 0.1, 0.16666666666667
19761, 0.21739130434783, 0.1, 0.22222222222222
19762, 0.21739130434783, 0.1, 0.27777777777778
19763, 0.21739130434783, 0.1, 0.33333333333333
19764, 0.21739130434783, 0.1, 0.38888888888889
19765, 0.21739130434783, 0.1, 0.44444444444444
19766, 0.26086956521739, 0.1, 0.055555555555556
19767, 0.26086956521739, 0.1, 0.11111111111111
19768, 0.26086956521739, 0.1, 0.16666666666667
19769, 0.26086956521739, 0.1, 0.22222222222222
19770, 0.26086956521739, 0.1, 0.27777777777778
19771, 0.26086956521739, 0.1, 0.33333333333333
19772, 0.26086956521739, 0.1, 0.38888888888889
19773, 0.26086956521739, 0.1, 0.44444444444444
19774, 0.30434782608696, 0.1, 0.055555555555556
19775, 0.30434782608696, 0.1, 0.11111111111111
19776, 0.30434782608696, 0.1, 0.16666666666667
19777, 0.30434782608696, 0.1, 0.22222222222222
19778, 0.30434782608696, 0.1, 0.27777777777778
19779, 0.30434782608696, 0.1, 0.33333333333333
19780, 0.30434782608696, 0.1, 0.38888888888889
19781, 0.30434782608696, 0.1, 0.44444444444444
19782, 0.34782608695652, 0.1, 0.055555555555556
19783, 0.34782608695652, 0.1, 0.11111111111111
19784, 0.34782608695652, 0.1, 0.16666666666667
19785, 0.34782608695652, 0.1, 0.22222222222222
19786, 0.34782608695652, 0.1, 0.27777777777778
19787, 0.34782608695652, 0.1, 0.33333333333333
19788, 0.34782608695652, 0.1, 0.38888888888889
19789, 0.34782608695652, 0.1, 0.44444444444444
19790, 0.39130434782609, 0.1, 0.055555555555556
19791, 0.39130434782609, 0.1, 0.11111111111111
19792, 0.39130434782609, 0.1, 0.16666666666667
19793, 0.39130434782609, 0.1, 0.22222222222222
19794, 0.39130434782609, 0.1, 0.27777777777778
19795, 0.39130434782609, 0.1, 0.33333333333333
19796, 0.39130434782609, 0.1, 0.38888888888889
19797, 0.39130434782609, 0.1, 0.44444444444444
19798, 0.43478260869565, 0.1, 0.055555555555556
19799, 0.43478260869565, 0.1, 0.11111111111111
19800, 0.43478260869565, 0.1, 0.16666666666667
19801, 0.43478260869565, 0.1, 0.22222222222222
19802, 0.43478260869565, 0.1, 0.27777777777778
19803, 0.43478260869565, 0.1, 0.33333333333333
19804, 0.43478260869565, 0.1, 0.38888888888889
19805, 0.43478260869565, 0.1, 0.44444444444444
19806, 0.47826086956522, 0.1, 0.055555555555556
19807, 0.47826086956522, 0.1, 0.11111111111111
19808, 0.47826086956522, 0.1, 0.16666666666667
19809, 0.47826086956522, 0.1, 0.22222222222222
19810, 0.47826086956522, 0.1, 0.27777777777778
19811, 0.47826086956522, 0.1, 0.33333333333333
19812, 0.47826086956522, 0.1, 0.38888888888889
19813, 0.47826086956522, 0.1, 0.44444444444444
19814, 0.52173913043478, 0.1, 0.055555555555556
19815, 0.52173913043478, 0.1, 0.11111111111111
19816, 0.52173913043478, 0.1, 0.16666666666667
19817, 0.52173913043478, 0.1, 0.22222222222222
19818, 0.52173913043478, 0.1, 0.27777777777778
19819, 0.52173913043478, 0.1, 0.33333333333333
19820, 0.52173913043478, 0.1, 0.38888888888889
19821, 0.52173913043478, 0.1, 0.44444444444444
19822, 0.56521739130435, 0.1, 0.055555555555556
19823, 0.56521739130435, 0.1, 0.11111111111111
19824, 0.56521739130435, 0.1, 0.16666666666667
19825, 0.56521739130435, 0.1, 0.22222222222222
19826, 0.56521739130435, 0.1, 0.27777777777778
19827, 0.56521739130435, 0.1, 0.33333333333333
19828, 0.56521739130435, 0.1, 0.38888888888889
19829, 0.56521739130435, 0.1, 0.44444444444444
19830, 0.60869565217391, 0.1, 0.055555555555556
19831, 0.60869565217391, 0.1, 0.11111111111111
19832, 0.60869565217391, 0.1, 0.16666666666667
19833, 0.60869565217391, 0.1, 0.22222222222222
19834, 0.60869565217391, 0.1, 0.27777777777778
19835, 0.60869565217391, 0.1, 0.33333333333333
19836, 0.60869565217391, 0.1, 0.38888888888889
19837, 0.60869565217391, 0.1, 0.44444444444444
19838, 0.65217391304348, 0.1, 0.055555555555556
19839, 0.65217391304348, 0.1, 0.11111111111111
19840, 0.65217391304348, 0.1, 0.16666666666667
19841, 0.65217391304348, 0.1, 0.22222222222222
19842, 0.65217391304348, 0.1, 0.27777777777778
19843, 0.65217391304348, 0.1, 0.33333333333333
19844, 0.65217391304348, 0.1, 0.38888888888889
19845, 0.65217391304348, 0.1, 0.44444444444444
19846, 0.69565217391304, 0.1, 0.055555555555556
19847, 0.69565217391304, 0.1, 0.11111111111111
19848, 0.69565217391304, 0.1, 0.16666666666667
19849, 0.69565217391304, 0.1, 0.22222222222222
19850, 0.69565217391304, 0.1, 0.27777777777778
19851, 0.69565217391304, 0.1, 0.33333333333333
19852, 0.69565217391304, 0.1, 0.38888888888889
19853, 0.69565217391304, 0.1, 0.44444444444444
19854, 0.73913043478261, 0.1, 0.055555555555556
19855, 0.73913043478261, 0.1, 0.11111111111111
19856, 0.73913043478261, 0.1, 0.16666666666667
19857, 0.73913043478261, 0.1, 0.22222222222222
19858, 0.73913043478261, 0.1, 0.27777777777778
19859, 0.73913043478261, 0.1, 0.33333333333333
19860, 0.73913043478261, 0.1, 0.38888888888889
19861, 0.73913043478261, 0.1, 0.44444444444444
19862, 0.78260869565217, 0.1, 0.055555555555556
19863, 0.78260869565217, 0.1, 0.11111111111111
19864, 0.78260869565217, 0.1, 0.16666666666667
19865, 0.78260869565217, 0.1, 0.22222222222222
19866, 0.78260869565217, 0.1, 0.27777777777778
19867, 0.78260869565217, 0.1, 0.33333333333333
19868, 0.78260869565217, 0.1, 0.38888888888889
19869, 0.78260869565217, 0.1, 0.44444444444444
19870, 0.82608695652174, 0.1, 0.055555555555556
19871, 0.82608695652174, 0.1, 0.11111111111111
19872, 0.82608695652174, 0.1, 0.16666666666667
19873, 0.82608695652174, 0.1, 0.22222222222222
19874, 0.82608695652174, 0.1, 0.27777777777778
19875, 0.82608695652174, 0.1, 0.33333333333333
19876, 0.82608695652174, 0.1, 0.38888888888889
19877, 0.82608695652174, 0.1, 0.44444444444444
19878, 0.8695652173913, 0.1, 0.055555555555556
19879, 0.8695652173913, 0.1, 0.11111111111111
19880, 0.8695652173913, 0.1, 0.16666666666667
19881, 0.8695652173913, 0.1, 0.22222222222222
19882, 0.8695652173913, 0.1, 0.27777777777778
19883, 0.8695652173913, 0.1, 0.33333333333333
19884, 0.8695652173913, 0.1, 0.38888888888889
19885, 0.8695652173913, 0.1, 0.44444444444444
19886, 0.91304347826087, 0.1, 0.055555555555556
19887, 0.91304347826087, 0.1, 0.11111111111111
19888, 0.91304347826087, 0.1, 0.16666666666667
19889, 0.91304347826087, 0.1, 0.22222222222222
19890, 0.91304347826087, 0.1, 0.27777777777778
19891, 0.91304347826087, 0.1, 0.33333333333333
19892, 0.91304347826087, 0.1, 0.38888888888889
19893, 0.91304347826087, 0.1, 0.44444444444444
19894, 0.95652173913043, 0.1, 0.055555555555556
19895, 0.95652173913043, 0.1, 0.11111111111111
19896, 0.95652173913043, 0.1, 0.16666666666667
19897, 0.95652173913043, 0.1, 0.22222222222222
19898, 0.95652173913043, 0.1, 0.27777777777778
19899, 0.95652173913043, 0.1, 0.33333333333333
19900, 0.95652173913043, 0.1, 0.38888888888889
19901, 0.95652173913043, 0.1, 0.44444444444444
19902, 0.043478260869565, 0.1, 0.027777777777778
19903, 0.021739130434783, 0.1, 0.055555555555556
19904, 0.043478260869565, 0.1, 0.083333333333333
19905, 0.021739130434783, 0.1, 0.11111111111111
19906, 0.043478260869565, 0.1, 0.13888888888889
19907, 0.021739130434783, 0.1, 0.16666666666667
19908, 0.043478260869565, 0.1, 0.19444444444444
19909, 0.021739130434783, 0.1, 0.22222222222222
19910, 0.043478260869565, 0.1, 0.25
19911, 0.021739130434783, 0.1, 0.27777777777778
19912, 0.043478260869565, 0.1, 0.30555555555556
19913, 0.021739130434783, 0.1, 0.33333333333333
19914, 0.043478260869565, 0.1, 0.36111111111111
19915, 0.021739130434783, 0.1, 0.38888888888889
19916, 0.043478260869565, 0.1, 0.41666666666667
19917, 0.021739130434783, 0.1, 0.44444444444444
19918, 0.043478260869565, 0.1, 0.47222222222222
19919, 0.08695652173913, 0.1, 0.027777777777778
19920, 0.065217391304348, 0.1, 0.055555555555556
19921, 0.08695652173913, 0.1, 0.083333333333333
19922, 0.065217391304348, 0.1, 0.11111111111111
19923, 0.08695652173913, 0.1, 0.13888888888889
19924, 0.065217391304348, 0.1, 0.16666666666667
19925, 0.08695652173913, 0.1, 0.19444444444444
19926, 0.065217391304348, 0.1, 0.22222222222222
19927, 0.08695652173913, 0.1, 0.25
19928, 0.065217391304348, 0.1, 0.27777777777778
19929, 0.08695652173913, 0.1, 0.30555555555556
19930, 0.065217391304348, 0.1, 0.33333333333333
19931, 0.08695652173913, 0.1, 0.36111111111111
19932, 0.065217391304348, 0.1, 0.38888888888889
19933, 0.08695652173913, 0.1, 0.41666666666667
19934, 0.065217391304348, 0.1, 0.44444444444444
19935, 0.08695652173913, 0.1, 0.47222222222222
19936, 0.1304347826087, 0.1, 0.027777777777778
19937, 0.10869565217391, 0.1, 0.055555555555556
19938, 0.1304347826087, 0.1, 0.083333333333333
19939, 0.10869565217391, 0.1, 0.11111111111111
19940, 0.1304347826087, 0.1, 0.13888888888889
19941, 0.10869565217391, 0.1, 0.16666666666667
19942, 0.1304347826087, 0.1, 0.19444444444444
19943, 0.10869565217391, 0.1, 0.22222222222222
19944, 0.1304347826087, 0.1, 0.25
19945, 0.10869565217391, 0.1, 0.27777777777778
19946, 0.1304347826087, 0.1, 0.30555555555556
19947, 0.10869565217391, 0.1, 0.33333333333333
19948, 0.1304347826087, 0.1, 0.36111111111111
19949, 0.10869565217391, 0.1, 0.38888888888889
19950, 0.1304347826087, 0.1, 0.41666666666667
19951, 0.10869565217391, 0.1, 0.44444444444444
19952, 0.1304347826087, 0.1, 0.47222222222222
19953, 0.17391304347826, 0.1, 0.027777777777778
19954, 0.15217391304348, 0.1, 0.055555555555556
19955, 0.17391304347826, 0.1, 0.083333333333333
19956, 0.15217391304348, 0.1, 0.11111111111111
