49569, 0.15217391304348, 0.72391304347826, 0.22222222222222
49570, 0.1304347826087, 0.69782608695652, 0.22222222222222
49571, 0.1304347826087, 0.72391304347826, 0.25
49572, 0.15217391304348, 0.72391304347826, 0.27777777777778
49573, 0.1304347826087, 0.69782608695652, 0.27777777777778
49574, 0.1304347826087, 0.72391304347826, 0.30555555555556
49575, 0.15217391304348, 0.72391304347826, 0.33333333333333
49576, 0.1304347826087, 0.69782608695652, 0.33333333333333
49577, 0.1304347826087, 0.72391304347826, 0.36111111111111
49578, 0.15217391304348, 0.72391304347826, 0.38888888888889
49579, 0.1304347826087, 0.69782608695652, 0.38888888888889
49580, 0.1304347826087, 0.72391304347826, 0.41666666666667
49581, 0.15217391304348, 0.72391304347826, 0.44444444444444
49582, 0.1304347826087, 0.69782608695652, 0.44444444444444
49583, 0.1304347826087, 0.72391304347826, 0.47222222222222
49584, 0.08695652173913, 0.72391304347826, 0.027777777777778
49585, 0.10869565217391, 0.72391304347826, 0.055555555555556
49586, 0.08695652173913, 0.69782608695652, 0.055555555555556
49587, 0.08695652173913, 0.72391304347826, 0.083333333333333
49588, 0.10869565217391, 0.72391304347826, 0.11111111111111
49589, 0.08695652173913, 0.69782608695652, 0.11111111111111
49590, 0.08695652173913, 0.72391304347826, 0.13888888888889
49591, 0.10869565217391, 0.72391304347826, 0.16666666666667
49592, 0.08695652173913, 0.69782608695652, 0.16666666666667
49593, 0.08695652173913, 0.72391304347826, 0.19444444444444
49594, 0.10869565217391, 0.72391304347826, 0.22222222222222
49595, 0.08695652173913, 0.69782608695652, 0.22222222222222
49596, 0.08695652173913, 0.72391304347826, 0.25
49597, 0.10869565217391, 0.72391304347826, 0.27777777777778
49598, 0.08695652173913, 0.69782608695652, 0.27777777777778
49599, 0.08695652173913, 0.72391304347826, 0.30555555555556
49600, 0.10869565217391, 0.72391304347826, 0.33333333333333
49601, 0.08695652173913, 0.69782608695652, 0.33333333333333
49602, 0.08695652173913, 0.72391304347826, 0.36111111111111
49603, 0.10869565217391, 0.72391304347826, 0.38888888888889
49604, 0.08695652173913, 0.69782608695652, 0.38888888888889
49605, 0.08695652173913, 0.72391304347826, 0.41666666666667
49606, 0.10869565217391, 0.72391304347826, 0.44444444444444
49607, 0.08695652173913, 0.69782608695652, 0.44444444444444
49608, 0.08695652173913, 0.72391304347826, 0.47222222222222
49609, 0.043478260869565, 0.72391304347826, 0.027777777777778
49610, 0.065217391304348, 0.72391304347826, 0.055555555555556
49611, 0.043478260869565, 0.69782608695652, 0.055555555555556
49612, 0.043478260869565, 0.72391304347826, 0.083333333333333
49613, 0.065217391304348, 0.72391304347826, 0.11111111111111
49614, 0.043478260869565, 0.69782608695652, 0.11111111111111
49615, 0.043478260869565, 0.72391304347826, 0.13888888888889
49616, 0.065217391304348, 0.72391304347826, 0.16666666666667
49617, 0.043478260869565, 0.69782608695652, 0.16666666666667
49618, 0.043478260869565, 0.72391304347826, 0.19444444444444
49619, 0.065217391304348, 0.72391304347826, 0.22222222222222
49620, 0.043478260869565, 0.69782608695652, 0.22222222222222
49621, 0.043478260869565, 0.72391304347826, 0.25
49622, 0.065217391304348, 0.72391304347826, 0.27777777777778
49623, 0.043478260869565, 0.69782608695652, 0.27777777777778
49624, 0.043478260869565, 0.72391304347826, 0.30555555555556
49625, 0.065217391304348, 0.72391304347826, 0.33333333333333
49626, 0.043478260869565, 0.69782608695652, 0.33333333333333
49627, 0.043478260869565, 0.72391304347826, 0.36111111111111
49628, 0.065217391304348, 0.72391304347826, 0.38888888888889
49629, 0.043478260869565, 0.69782608695652, 0.38888888888889
49630, 0.043478260869565, 0.72391304347826, 0.41666666666667
49631, 0.065217391304348, 0.72391304347826, 0.44444444444444
49632, 0.043478260869565, 0.69782608695652, 0.44444444444444
49633, 0.043478260869565, 0.72391304347826, 0.47222222222222
49634, 0.021739130434783, 0.72391304347826, 0.055555555555556
49635, 0.021739130434783, 0.72391304347826, 0.11111111111111
49636, 0.021739130434783, 0.72391304347826, 0.16666666666667
49637, 0.021739130434783, 0.72391304347826, 0.22222222222222
49638, 0.021739130434783, 0.72391304347826, 0.27777777777778
49639, 0.021739130434783, 0.72391304347826, 0.33333333333333
49640, 0.021739130434783, 0.72391304347826, 0.38888888888889
49641, 0.021739130434783, 0.72391304347826, 0.44444444444444
49642, 0.95652173913043, 0.77608695652174, 0.027777777777778
49643, 0.97826086956522, 0.77608695652174, 0.055555555555556
49644, 0.95652173913043, 0.75, 0.055555555555556
49645, 0.95652173913043, 0.77608695652174, 0.083333333333333
49646, 0.97826086956522, 0.77608695652174, 0.11111111111111
49647, 0.95652173913044, 0.75, 0.11111111111111
49648, 0.95652173913044, 0.77608695652174, 0.13888888888889
49649, 0.97826086956522, 0.77608695652174, 0.16666666666667
49650, 0.95652173913044, 0.75, 0.16666666666667
49651, 0.95652173913044, 0.77608695652174, 0.19444444444444
49652, 0.97826086956522, 0.77608695652174, 0.22222222222222
49653, 0.95652173913044, 0.75, 0.22222222222222
49654, 0.95652173913044, 0.77608695652174, 0.25
49655, 0.97826086956522, 0.77608695652174, 0.27777777777778
49656, 0.95652173913044, 0.75, 0.27777777777778
49657, 0.95652173913044, 0.77608695652174, 0.30555555555556
49658, 0.97826086956522, 0.77608695652174, 0.33333333333333
49659, 0.95652173913044, 0.75, 0.33333333333333
49660, 0.95652173913044, 0.77608695652174, 0.36111111111111
49661, 0.97826086956522, 0.77608695652174, 0.38888888888889
49662, 0.95652173913044, 0.75, 0.38888888888889
49663, 0.95652173913044, 0.77608695652174, 0.41666666666667
49664, 0.97826086956522, 0.77608695652174, 0.44444444444444
49665, 0.95652173913044, 0.75, 0.44444444444444
49666, 0.95652173913043, 0.77608695652174, 0.47222222222222
49667, 0.91304347826087, 0.77608695652174, 0.027777777777778
49668, 0.93478260869565, 0.77608695652174, 0.055555555555556
49669, 0.91304347826087, 0.75, 0.055555555555556
49670, 0.91304347826087, 0.77608695652174, 0.083333333333333
49671, 0.93478260869565, 0.77608695652174, 0.11111111111111
49672, 0.91304347826087, 0.75, 0.11111111111111
49673, 0.91304347826087, 0.77608695652174, 0.13888888888889
49674, 0.93478260869565, 0.77608695652174, 0.16666666666667
49675, 0.91304347826087, 0.75, 0.16666666666667
49676, 0.91304347826087, 0.77608695652174, 0.19444444444444
49677, 0.93478260869565, 0.77608695652174, 0.22222222222222
49678, 0.91304347826087, 0.75, 0.22222222222222
49679, 0.91304347826087, 0.77608695652174, 0.25
49680, 0.93478260869565, 0.77608695652174, 0.27777777777778
49681, 0.91304347826087, 0.75, 0.27777777777778
49682, 0.91304347826087, 0.77608695652174, 0.30555555555556
49683, 0.93478260869565, 0.77608695652174, 0.33333333333333
49684, 0.91304347826087, 0.75, 0.33333333333333
49685, 0.91304347826087, 0.77608695652174, 0.36111111111111
49686, 0.93478260869565, 0.77608695652174, 0.38888888888889
49687, 0.91304347826087, 0.75, 0.38888888888889
49688, 0.91304347826087, 0.77608695652174, 0.41666666666667
49689, 0.93478260869565, 0.77608695652174, 0.44444444444444
49690, 0.91304347826087, 0.75, 0.44444444444444
49691, 0.91304347826087, 0.77608695652174, 0.47222222222222
49692, 0.8695652173913, 0.77608695652174, 0.027777777777778
49693, 0.89130434782609, 0.77608695652174, 0.055555555555556
49694, 0.8695652173913, 0.75, 0.055555555555556
49695, 0.8695652173913, 0.77608695652174, 0.083333333333333
49696, 0.89130434782609, 0.77608695652174, 0.11111111111111
49697, 0.8695652173913, 0.75, 0.11111111111111
49698, 0.8695652173913, 0.77608695652174, 0.13888888888889
49699, 0.89130434782609, 0.77608695652174, 0.16666666666667
49700, 0.8695652173913, 0.75, 0.16666666666667
49701, 0.8695652173913, 0.77608695652174, 0.19444444444444
49702, 0.89130434782609, 0.77608695652174, 0.22222222222222
49703, 0.8695652173913, 0.75, 0.22222222222222
49704, 0.8695652173913, 0.77608695652174, 0.25
49705, 0.89130434782609, 0.77608695652174, 0.27777777777778
49706, 0.8695652173913, 0.75, 0.27777777777778
49707, 0.8695652173913, 0.77608695652174, 0.30555555555556
49708, 0.89130434782609, 0.77608695652174, 0.33333333333333
49709, 0.8695652173913, 0.75, 0.33333333333333
49710, 0.8695652173913, 0.77608695652174, 0.36111111111111
49711, 0.89130434782609, 0.77608695652174, 0.38888888888889
49712, 0.8695652173913, 0.75, 0.38888888888889
49713, 0.8695652173913, 0.77608695652174, 0.41666666666667
49714, 0.89130434782609, 0.77608695652174, 0.44444444444444
49715, 0.8695652173913, 0.75, 0.44444444444444
49716, 0.8695652173913, 0.77608695652174, 0.47222222222222
49717, 0.82608695652174, 0.77608695652174, 0.027777777777778
49718, 0.84782608695652, 0.77608695652174, 0.055555555555556
49719, 0.82608695652174, 0.75, 0.055555555555556
49720, 0.82608695652174, 0.77608695652174, 0.083333333333333
49721, 0.84782608695652, 0.77608695652174, 0.11111111111111
49722, 0.82608695652174, 0.75, 0.11111111111111
49723, 0.82608695652174, 0.77608695652174, 0.13888888888889
49724, 0.84782608695652, 0.77608695652174, 0.16666666666667
49725, 0.82608695652174, 0.75, 0.16666666666667
49726, 0.82608695652174, 0.77608695652174, 0.19444444444444
49727, 0.84782608695652, 0.77608695652174, 0.22222222222222
49728, 0.82608695652174, 0.75, 0.22222222222222
49729, 0.82608695652174, 0.77608695652174, 0.25
49730, 0.84782608695652, 0.77608695652174, 0.27777777777778
49731, 0.82608695652174, 0.75, 0.27777777777778
49732, 0.82608695652174, 0.77608695652174, 0.30555555555556
49733, 0.84782608695652, 0.77608695652174, 0.33333333333333
49734, 0.82608695652174, 0.75, 0.33333333333333
49735, 0.82608695652174, 0.77608695652174, 0.36111111111111
49736, 0.84782608695652, 0.77608695652174, 0.38888888888889
49737, 0.82608695652174, 0.75, 0.38888888888889
49738, 0.82608695652174, 0.77608695652174, 0.41666666666667
49739, 0.84782608695652, 0.77608695652174, 0.44444444444444
49740, 0.82608695652174, 0.75, 0.44444444444444
49741, 0.82608695652174, 0.77608695652174, 0.47222222222222
49742, 0.78260869565217, 0.77608695652174, 0.027777777777778
49743, 0.80434782608696, 0.77608695652174, 0.055555555555556
49744, 0.78260869565217, 0.75, 0.055555555555556
49745, 0.78260869565217, 0.77608695652174, 0.083333333333333
49746, 0.80434782608696, 0.77608695652174, 0.11111111111111
49747, 0.78260869565217, 0.75, 0.11111111111111
49748, 0.78260869565217, 0.77608695652174, 0.13888888888889
49749, 0.80434782608696, 0.77608695652174, 0.16666666666667
49750, 0.78260869565217, 0.75, 0.16666666666667
49751, 0.78260869565217, 0.77608695652174, 0.19444444444444
49752, 0.80434782608696, 0.77608695652174, 0.22222222222222
49753, 0.78260869565217, 0.75, 0.22222222222222
49754, 0.78260869565217, 0.77608695652174, 0.25
49755, 0.80434782608696, 0.77608695652174, 0.27777777777778
49756, 0.78260869565217, 0.75, 0.27777777777778
49757, 0.78260869565217, 0.77608695652174, 0.30555555555556
49758, 0.80434782608696, 0.77608695652174, 0.33333333333333
49759, 0.78260869565217, 0.75, 0.33333333333333
49760, 0.78260869565217, 0.77608695652174, 0.36111111111111
49761, 0.80434782608696, 0.77608695652174, 0.38888888888889
49762, 0.78260869565217, 0.75, 0.38888888888889
49763, 0.78260869565217, 0.77608695652174, 0.41666666666667
49764, 0.80434782608696, 0.77608695652174, 0.44444444444444
49765, 0.78260869565217, 0.75, 0.44444444444444
49766, 0.78260869565217, 0.77608695652174, 0.47222222222222
49767, 0.73913043478261, 0.77608695652174, 0.027777777777778
49768, 0.76086956521739, 0.77608695652174, 0.055555555555556
49769, 0.73913043478261, 0.75, 0.055555555555556
49770, 0.73913043478261, 0.77608695652174, 0.083333333333333
49771, 0.76086956521739, 0.77608695652174, 0.11111111111111
49772, 0.73913043478261, 0.75, 0.11111111111111
49773, 0.73913043478261, 0.77608695652174, 0.13888888888889
49774, 0.76086956521739, 0.77608695652174, 0.16666666666667
49775, 0.73913043478261, 0.75, 0.16666666666667
49776, 0.73913043478261, 0.77608695652174, 0.19444444444444
49777, 0.76086956521739, 0.77608695652174, 0.22222222222222
49778, 0.73913043478261, 0.75, 0.22222222222222
49779, 0.73913043478261, 0.77608695652174, 0.25
49780, 0.76086956521739, 0.77608695652174, 0.27777777777778
49781, 0.73913043478261, 0.75, 0.27777777777778
49782, 0.73913043478261, 0.77608695652174, 0.30555555555556
49783, 0.76086956521739, 0.77608695652174, 0.33333333333333
49784, 0.73913043478261, 0.75, 0.33333333333333
49785, 0.73913043478261, 0.77608695652174, 0.36111111111111
49786, 0.76086956521739, 0.77608695652174, 0.38888888888889
49787, 0.73913043478261, 0.75, 0.38888888888889
49788, 0.73913043478261, 0.77608695652174, 0.41666666666667
49789, 0.76086956521739, 0.77608695652174, 0.44444444444444
49790, 0.73913043478261, 0.75, 0.44444444444444
49791, 0.73913043478261, 0.77608695652174, 0.47222222222222
49792, 0.69565217391304, 0.77608695652174, 0.027777777777778
49793, 0.71739130434783, 0.77608695652174, 0.055555555555556
49794, 0.69565217391304, 0.75, 0.055555555555556
49795, 0.69565217391304, 0.77608695652174, 0.083333333333333
49796, 0.71739130434783, 0.77608695652174, 0.11111111111111
49797, 0.69565217391304, 0.75, 0.11111111111111
49798, 0.69565217391304, 0.77608695652174, 0.13888888888889
49799, 0.71739130434783, 0.77608695652174, 0.16666666666667
49800, 0.69565217391304, 0.75, 0.16666666666667
49801, 0.69565217391304, 0.77608695652174, 0.19444444444444
49802, 0.71739130434783, 0.77608695652174, 0.22222222222222
49803, 0.69565217391304, 0.75, 0.22222222222222
49804, 0.69565217391304, 0.77608695652174, 0.25
49805, 0.71739130434783, 0.77608695652174, 0.27777777777778
49806, 0.69565217391304, 0.75, 0.27777777777778
49807, 0.69565217391304, 0.77608695652174, 0.30555555555556
49808, 0.71739130434783, 0.77608695652174, 0.33333333333333
49809, 0.69565217391304, 0.75, 0.33333333333333
49810, 0.69565217391304, 0.77608695652174, 0.36111111111111
49811, 0.71739130434783, 0.77608695652174, 0.38888888888889
49812, 0.69565217391304, 0.75, 0.38888888888889
49813, 0.69565217391304, 0.77608695652174, 0.41666666666667
49814, 0.71739130434783, 0.77608695652174, 0.44444444444444
49815, 0.69565217391304, 0.75, 0.44444444444444
49816, 0.69565217391304, 0.77608695652174, 0.47222222222222
49817, 0.65217391304348, 0.77608695652174, 0.027777777777778
49818, 0.67391304347826, 0.77608695652174, 0.055555555555556
49819, 0.65217391304348, 0.75, 0.055555555555556
49820, 0.65217391304348, 0.77608695652174, 0.083333333333333
49821, 0.67391304347826, 0.77608695652174, 0.11111111111111
49822, 0.65217391304348, 0.75, 0.11111111111111
49823, 0.65217391304348, 0.77608695652174, 0.13888888888889
49824, 0.67391304347826, 0.77608695652174, 0.16666666666667
49825, 0.65217391304348, 0.75, 0.16666666666667
49826, 0.65217391304348, 0.77608695652174, 0.19444444444444
49827, 0.67391304347826, 0.77608695652174, 0.22222222222222
49828, 0.65217391304348, 0.75, 0.22222222222222
49829, 0.65217391304348, 0.77608695652174, 0.25
49830, 0.67391304347826, 0.77608695652174, 0.27777777777778
49831, 0.65217391304348, 0.75, 0.27777777777778
49832, 0.65217391304348, 0.77608695652174, 0.30555555555556
49833, 0.67391304347826, 0.77608695652174, 0.33333333333333
49834, 0.65217391304348, 0.75, 0.33333333333333
49835, 0.65217391304348, 0.77608695652174, 0.36111111111111
49836, 0.67391304347826, 0.77608695652174, 0.38888888888889
49837, 0.65217391304348, 0.75, 0.38888888888889
49838, 0.65217391304348, 0.77608695652174, 0.41666666666667
49839, 0.67391304347826, 0.77608695652174, 0.44444444444444
49840, 0.65217391304348, 0.75, 0.44444444444444
49841, 0.65217391304348, 0.77608695652174, 0.47222222222222
49842, 0.60869565217391, 0.77608695652174, 0.027777777777778
49843, 0.6304347826087, 0.77608695652174, 0.055555555555556
49844, 0.60869565217391, 0.75, 0.055555555555556
49845, 0.60869565217391, 0.77608695652174, 0.083333333333333
49846, 0.6304347826087, 0.77608695652174, 0.11111111111111
49847, 0.60869565217391, 0.75, 0.11111111111111
49848, 0.60869565217391, 0.77608695652174, 0.13888888888889
49849, 0.6304347826087, 0.77608695652174, 0.16666666666667
49850, 0.60869565217391, 0.75, 0.16666666666667
49851, 0.60869565217391, 0.77608695652174, 0.19444444444444
49852, 0.6304347826087, 0.77608695652174, 0.22222222222222
49853, 0.60869565217391, 0.75, 0.22222222222222
49854, 0.60869565217391, 0.77608695652174, 0.25
49855, 0.6304347826087, 0.77608695652174, 0.27777777777778
49856, 0.60869565217391, 0.75, 0.27777777777778
49857, 0.60869565217391, 0.77608695652174, 0.30555555555556
49858, 0.6304347826087, 0.77608695652174, 0.33333333333333
49859, 0.60869565217391, 0.75, 0.33333333333333
49860, 0.60869565217391, 0.77608695652174, 0.36111111111111
49861, 0.6304347826087, 0.77608695652174, 0.38888888888889
49862, 0.60869565217391, 0.75, 0.38888888888889
49863, 0.60869565217391, 0.77608695652174, 0.41666666666667
49864, 0.6304347826087, 0.77608695652174, 0.44444444444444
49865, 0.60869565217391, 0.75, 0.44444444444444
49866, 0.60869565217391, 0.77608695652174, 0.47222222222222
49867, 0.56521739130435, 0.77608695652174, 0.027777777777778
49868, 0.58695652173913, 0.77608695652174, 0.055555555555556
49869, 0.56521739130435, 0.75, 0.055555555555556
49870, 0.56521739130435, 0.77608695652174, 0.083333333333333
49871, 0.58695652173913, 0.77608695652174, 0.11111111111111
49872, 0.56521739130435, 0.75, 0.11111111111111
49873, 0.56521739130435, 0.77608695652174, 0.13888888888889
49874, 0.58695652173913, 0.77608695652174, 0.16666666666667
49875, 0.56521739130435, 0.75, 0.16666666666667
49876, 0.56521739130435, 0.77608695652174, 0.19444444444444
49877, 0.58695652173913, 0.77608695652174, 0.22222222222222
49878, 0.56521739130435, 0.75, 0.22222222222222
49879, 0.56521739130435, 0.77608695652174, 0.25
49880, 0.58695652173913, 0.77608695652174, 0.27777777777778
49881, 0.56521739130435, 0.75, 0.27777777777778
49882, 0.56521739130435, 0.77608695652174, 0.30555555555556
49883, 0.58695652173913, 0.77608695652174, 0.33333333333333
49884, 0.56521739130435, 0.75, 0.33333333333333
49885, 0.56521739130435, 0.77608695652174, 0.36111111111111
49886, 0.58695652173913, 0.77608695652174, 0.38888888888889
49887, 0.56521739130435, 0.75, 0.38888888888889
49888, 0.56521739130435, 0.77608695652174, 0.41666666666667
49889, 0.58695652173913, 0.77608695652174, 0.44444444444444
49890, 0.56521739130435, 0.75, 0.44444444444444
49891, 0.56521739130435, 0.77608695652174, 0.47222222222222
49892, 0.52173913043478, 0.77608695652174, 0.027777777777778
49893, 0.54347826086957, 0.77608695652174, 0.055555555555556
49894, 0.52173913043478, 0.75, 0.055555555555556
49895, 0.52173913043478, 0.77608695652174, 0.083333333333333
49896, 0.54347826086956, 0.77608695652174, 0.11111111111111
49897, 0.52173913043478, 0.75, 0.11111111111111
49898, 0.52173913043478, 0.77608695652174, 0.13888888888889
49899, 0.54347826086957, 0.77608695652174, 0.16666666666667
49900, 0.52173913043478, 0.75, 0.16666666666667
49901, 0.52173913043478, 0.77608695652174, 0.19444444444444
49902, 0.54347826086956, 0.77608695652174, 0.22222222222222
49903, 0.52173913043478, 0.75, 0.22222222222222
49904, 0.52173913043478, 0.77608695652174, 0.25
49905, 0.54347826086956, 0.77608695652174, 0.27777777777778
49906, 0.52173913043478, 0.75, 0.27777777777778
49907, 0.52173913043478, 0.77608695652174, 0.30555555555556
49908, 0.54347826086956, 0.77608695652174, 0.33333333333333
49909, 0.52173913043478, 0.75, 0.33333333333333
49910, 0.52173913043478, 0.77608695652174, 0.36111111111111
49911, 0.54347826086956, 0.77608695652174, 0.38888888888889
49912, 0.52173913043478, 0.75, 0.38888888888889
49913, 0.52173913043478, 0.77608695652174, 0.41666666666667
49914, 0.54347826086956, 0.77608695652174, 0.44444444444444
49915, 0.52173913043478, 0.75, 0.44444444444444
49916, 0.52173913043478, 0.77608695652174, 0.47222222222222
49917, 0.47826086956522, 0.77608695652174, 0.027777777777778
49918, 0.5, 0.77608695652174, 0.055555555555556
49919, 0.47826086956522, 0.75, 0.055555555555556
49920, 0.47826086956522, 0.77608695652174, 0.083333333333333
49921, 0.5, 0.77608695652174, 0.11111111111111
49922, 0.47826086956522, 0.75, 0.11111111111111
49923, 0.47826086956522, 0.77608695652174, 0.13888888888889
49924, 0.5, 0.77608695652174, 0.16666666666667
49925, 0.47826086956522, 0.75, 0.16666666666667
49926, 0.47826086956522, 0.77608695652174, 0.19444444444444
49927, 0.5, 0.77608695652174, 0.22222222222222
49928, 0.47826086956522, 0.75, 0.22222222222222
49929, 0.47826086956522, 0.77608695652174, 0.25
49930, 0.5, 0.77608695652174, 0.27777777777778
49931, 0.47826086956522, 0.75, 0.27777777777778
49932, 0.47826086956522, 0.77608695652174, 0.30555555555556
49933, 0.5, 0.77608695652174, 0.33333333333333
49934, 0.47826086956522, 0.75, 0.33333333333333
49935, 0.47826086956522, 0.77608695652174, 0.36111111111111
49936, 0.5, 0.77608695652174, 0.38888888888889
49937, 0.47826086956522, 0.75, 0.38888888888889
49938, 0.47826086956522, 0.77608695652174, 0.41666666666667
49939, 0.5, 0.77608695652174, 0.44444444444444
49940, 0.47826086956522, 0.75, 0.44444444444444
49941, 0.47826086956522, 0.77608695652174, 0.47222222222222
49942, 0.43478260869565, 0.77608695652174, 0.027777777777778
49943, 0.45652173913043, 0.77608695652174, 0.055555555555556
49944, 0.43478260869565, 0.75, 0.055555555555556
49945, 0.43478260869565, 0.77608695652174, 0.083333333333333
49946, 0.45652173913043, 0.77608695652174, 0.11111111111111
49947, 0.43478260869565, 0.75, 0.11111111111111
49948, 0.43478260869565, 0.77608695652174, 0.13888888888889
49949, 0.45652173913043, 0.77608695652174, 0.16666666666667
49950, 0.43478260869565, 0.75, 0.16666666666667
49951, 0.43478260869565, 0.77608695652174, 0.19444444444444
49952, 0.45652173913043, 0.77608695652174, 0.22222222222222
49953, 0.43478260869565, 0.75, 0.22222222222222
49954, 0.43478260869565, 0.77608695652174, 0.25
49955, 0.45652173913043, 0.77608695652174, 0.27777777777778
49956, 0.43478260869565, 0.75, 0.27777777777778
49957, 0.43478260869565, 0.77608695652174, 0.30555555555556
49958, 0.45652173913043, 0.77608695652174, 0.33333333333333
49959, 0.43478260869565, 0.75, 0.33333333333333
49960, 0.43478260869565, 0.77608695652174, 0.36111111111111
49961, 0.45652173913043, 0.77608695652174, 0.38888888888889
49962, 0.43478260869565, 0.75, 0.38888888888889
49963, 0.43478260869565, 0.77608695652174, 0.41666666666667
49964, 0.45652173913043, 0.77608695652174, 0.44444444444444
49965, 0.43478260869565, 0.75, 0.44444444444444
49966, 0.43478260869565, 0.77608695652174, 0.47222222222222
49967, 0.39130434782609, 0.77608695652174, 0.027777777777778
49968, 0.41304347826087, 0.77608695652174, 0.055555555555556
49969, 0.39130434782609, 0.75, 0.055555555555556
49970, 0.39130434782609, 0.77608695652174, 0.083333333333333
49971, 0.41304347826087, 0.77608695652174, 0.11111111111111
49972, 0.39130434782609, 0.75, 0.11111111111111
49973, 0.39130434782609, 0.77608695652174, 0.13888888888889
49974, 0.41304347826087, 0.77608695652174, 0.16666666666667
49975, 0.39130434782609, 0.75, 0.16666666666667
49976, 0.39130434782609, 0.77608695652174, 0.19444444444444
49977, 0.41304347826087, 0.77608695652174, 0.22222222222222
49978, 0.39130434782609, 0.75, 0.22222222222222
49979, 0.39130434782609, 0.77608695652174, 0.25
49980, 0.41304347826087, 0.77608695652174, 0.27777777777778
49981, 0.39130434782609, 0.75, 0.27777777777778
49982, 0.39130434782609, 0.77608695652174, 0.30555555555556
49983, 0.41304347826087, 0.77608695652174, 0.33333333333333
49984, 0.39130434782609, 0.75, 0.33333333333333
49985, 0.39130434782609, 0.77608695652174, 0.36111111111111
49986, 0.41304347826087, 0.77608695652174, 0.38888888888889
49987, 0.39130434782609, 0.75, 0.38888888888889
49988, 0.39130434782609, 0.77608695652174, 0.41666666666667
49989, 0.41304347826087, 0.77608695652174, 0.44444444444444
49990, 0.39130434782609, 0.75, 0.44444444444444
49991, 0.39130434782609, 0.77608695652174, 0.47222222222222
49992, 0.34782608695652, 0.77608695652174, 0.027777777777778
49993, 0.3695652173913, 0.77608695652174, 0.055555555555556
49994, 0.34782608695652, 0.75, 0.055555555555556
49995, 0.34782608695652, 0.77608695652174, 0.083333333333333
49996, 0.3695652173913, 0.77608695652174, 0.11111111111111
49997, 0.34782608695652, 0.75, 0.11111111111111
49998, 0.34782608695652, 0.77608695652174, 0.13888888888889
49999, 0.3695652173913, 0.77608695652174, 0.16666666666667
50000, 0.34782608695652, 0.75, 0.16666666666667
50001, 0.34782608695652, 0.77608695652174, 0.19444444444444
50002, 0.3695652173913, 0.77608695652174, 0.22222222222222
50003, 0.34782608695652, 0.75, 0.22222222222222
50004, 0.34782608695652, 0.77608695652174, 0.25
50005, 0.3695652173913, 0.77608695652174, 0.27777777777778
50006, 0.34782608695652, 0.75, 0.27777777777778
50007, 0.34782608695652, 0.77608695652174, 0.30555555555556
50008, 0.3695652173913, 0.77608695652174, 0.33333333333333
50009, 0.34782608695652, 0.75, 0.33333333333333
50010, 0.34782608695652, 0.77608695652174, 0.36111111111111
50011, 0.3695652173913, 0.77608695652174, 0.38888888888889
50012, 0.34782608695652, 0.75, 0.38888888888889
50013, 0.34782608695652, 0.77608695652174, 0.41666666666667
50014, 0.3695652173913, 0.77608695652174, 0.44444444444444
50015, 0.34782608695652, 0.75, 0.44444444444444
50016, 0.34782608695652, 0.77608695652174, 0.47222222222222
50017, 0.30434782608696, 0.77608695652174, 0.027777777777778
50018, 0.32608695652174, 0.77608695652174, 0.055555555555556
50019, 0.30434782608696, 0.75, 0.055555555555556
50020, 0.30434782608696, 0.77608695652174, 0.083333333333333
50021, 0.32608695652174, 0.77608695652174, 0.11111111111111
50022, 0.30434782608696, 0.75, 0.11111111111111
50023, 0.30434782608696, 0.77608695652174, 0.13888888888889
50024, 0.32608695652174, 0.77608695652174, 0.16666666666667
50025, 0.30434782608696, 0.75, 0.16666666666667
50026, 0.30434782608696, 0.77608695652174, 0.19444444444444
50027, 0.32608695652174, 0.77608695652174, 0.22222222222222
50028, 0.30434782608696, 0.75, 0.22222222222222
50029, 0.30434782608696, 0.77608695652174, 0.25
50030, 0.32608695652174, 0.77608695652174, 0.27777777777778
50031, 0.30434782608696, 0.75, 0.27777777777778
50032, 0.30434782608696, 0.77608695652174, 0.30555555555556
50033, 0.32608695652174, 0.77608695652174, 0.33333333333333
50034, 0.30434782608696, 0.75, 0.33333333333333
50035, 0.30434782608696, 0.77608695652174, 0.36111111111111
50036, 0.32608695652174, 0.77608695652174, 0.38888888888889
50037, 0.30434782608696, 0.75, 0.38888888888889
50038, 0.30434782608696, 0.77608695652174, 0.41666666666667
50039, 0.32608695652174, 0.77608695652174, 0.44444444444444
50040, 0.30434782608696, 0.75, 0.44444444444444
50041, 0.30434782608696, 0.77608695652174, 0.47222222222222
50042, 0.26086956521739, 0.77608695652174, 0.027777777777778
50043, 0.28260869565217, 0.77608695652174, 0.055555555555556
50044, 0.26086956521739, 0.75, 0.055555555555556
50045, 0.26086956521739, 0.77608695652174, 0.083333333333333
50046, 0.28260869565217, 0.77608695652174, 0.11111111111111
50047, 0.26086956521739, 0.75, 0.11111111111111
50048, 0.26086956521739, 0.77608695652174, 0.13888888888889
50049, 0.28260869565217, 0.77608695652174, 0.16666666666667
50050, 0.26086956521739, 0.75, 0.16666666666667
50051, 0.26086956521739, 0.77608695652174, 0.19444444444444
50052, 0.28260869565217, 0.77608695652174, 0.22222222222222
50053, 0.26086956521739, 0.75, 0.22222222222222
50054, 0.26086956521739, 0.77608695652174, 0.25
50055, 0.28260869565217, 0.77608695652174, 0.27777777777778
50056, 0.26086956521739, 0.75, 0.27777777777778
50057, 0.26086956521739, 0.77608695652174, 0.30555555555556
50058, 0.28260869565217, 0.77608695652174, 0.33333333333333
50059, 0.26086956521739, 0.75, 0.33333333333333
50060, 0.26086956521739, 0.77608695652174, 0.36111111111111
50061, 0.28260869565217, 0.77608695652174, 0.38888888888889
50062, 0.26086956521739, 0.75, 0.38888888888889
50063, 0.26086956521739, 0.77608695652174, 0.41666666666667
50064, 0.28260869565217, 0.77608695652174, 0.44444444444444
50065, 0.26086956521739, 0.75, 0.44444444444444
50066, 0.26086956521739, 0.77608695652174, 0.47222222222222
50067, 0.21739130434783, 0.77608695652174, 0.027777777777778
50068, 0.23913043478261, 0.77608695652174, 0.055555555555556
50069, 0.21739130434783, 0.75, 0.055555555555556
50070, 0.21739130434783, 0.77608695652174, 0.083333333333333
50071, 0.23913043478261, 0.77608695652174, 0.11111111111111
50072, 0.21739130434783, 0.75, 0.11111111111111
50073, 0.21739130434783, 0.77608695652174, 0.13888888888889
50074, 0.23913043478261, 0.77608695652174, 0.16666666666667
50075, 0.21739130434783, 0.75, 0.16666666666667
50076, 0.21739130434783, 0.77608695652174, 0.19444444444444
50077, 0.23913043478261, 0.77608695652174, 0.22222222222222
50078, 0.21739130434783, 0.75, 0.22222222222222
50079, 0.21739130434783, 0.77608695652174, 0.25
50080, 0.23913043478261, 0.77608695652174, 0.27777777777778
50081, 0.21739130434783, 0.75, 0.27777777777778
50082, 0.21739130434783, 0.77608695652174, 0.30555555555556
50083, 0.23913043478261, 0.77608695652174, 0.33333333333333
50084, 0.21739130434783, 0.75, 0.33333333333333
50085, 0.21739130434783, 0.77608695652174, 0.36111111111111
50086, 0.23913043478261, 0.77608695652174, 0.38888888888889
50087, 0.21739130434783, 0.75, 0.38888888888889
50088, 0.21739130434783, 0.77608695652174, 0.41666666666667
50089, 0.23913043478261, 0.77608695652174, 0.44444444444444
50090, 0.21739130434783, 0.75, 0.44444444444444
50091, 0.21739130434783, 0.77608695652174, 0.47222222222222
50092, 0.17391304347826, 0.77608695652174, 0.027777777777778
50093, 0.19565217391304, 0.77608695652174, 0.055555555555556
50094, 0.17391304347826, 0.75, 0.055555555555556
50095, 0.17391304347826, 0.77608695652174, 0.083333333333333
50096, 0.19565217391304, 0.77608695652174, 0.11111111111111
50097, 0.17391304347826, 0.75, 0.11111111111111
50098, 0.17391304347826, 0.77608695652174, 0.13888888888889
50099, 0.19565217391304, 0.77608695652174, 0.16666666666667
50100, 0.17391304347826, 0.75, 0.16666666666667
50101, 0.17391304347826, 0.77608695652174, 0.19444444444444
50102, 0.19565217391304, 0.77608695652174, 0.22222222222222
50103, 0.17391304347826, 0.75, 0.22222222222222
50104, 0.17391304347826, 0.77608695652174, 0.25
50105, 0.19565217391304, 0.77608695652174, 0.27777777777778
50106, 0.17391304347826, 0.75, 0.27777777777778
50107, 0.17391304347826, 0.77608695652174, 0.30555555555556
50108, 0.19565217391304, 0.77608695652174, 0.33333333333333
50109, 0.17391304347826, 0.75, 0.33333333333333
50110, 0.17391304347826, 0.77608695652174, 0.36111111111111
50111, 0.19565217391304, 0.77608695652174, 0.38888888888889
50112, 0.17391304347826, 0.75, 0.38888888888889
50113, 0.17391304347826, 0.77608695652174, 0.41666666666667
50114, 0.19565217391304, 0.77608695652174, 0.44444444444444
50115, 0.17391304347826, 0.75, 0.44444444444444
50116, 0.17391304347826, 0.77608695652174, 0.47222222222222
50117, 0.1304347826087, 0.77608695652174, 0.027777777777778
50118, 0.15217391304348, 0.77608695652174, 0.055555555555556
50119, 0.1304347826087, 0.75, 0.055555555555556
50120, 0.1304347826087, 0.77608695652174, 0.083333333333333
50121, 0.15217391304348, 0.77608695652174, 0.11111111111111
50122, 0.1304347826087, 0.75, 0.11111111111111
50123, 0.1304347826087, 0.77608695652174, 0.13888888888889
50124, 0.15217391304348, 0.77608695652174, 0.16666666666667
50125, 0.1304347826087, 0.75, 0.16666666666667
50126, 0.1304347826087, 0.77608695652174, 0.19444444444444
50127, 0.15217391304348, 0.77608695652174, 0.22222222222222
50128, 0.1304347826087, 0.75, 0.22222222222222
50129, 0.1304347826087, 0.77608695652174, 0.25
50130, 0.15217391304348, 0.77608695652174, 0.27777777777778
50131, 0.1304347826087, 0.75, 0.27777777777778
50132, 0.1304347826087, 0.77608695652174, 0.30555555555556
50133, 0.15217391304348, 0.77608695652174, 0.33333333333333
50134, 0.1304347826087, 0.75, 0.33333333333333
50135, 0.1304347826087, 0.77608695652174, 0.36111111111111
50136, 0.15217391304348, 0.77608695652174, 0.38888888888889
50137, 0.1304347826087, 0.75, 0.38888888888889
50138, 0.1304347826087, 0.77608695652174, 0.41666666666667
50139, 0.15217391304348, 0.77608695652174, 0.44444444444444
50140, 0.1304347826087, 0.75, 0.44444444444444
50141, 0.1304347826087, 0.77608695652174, 0.47222222222222
50142, 0.08695652173913, 0.77608695652174, 0.027777777777778
50143, 0.10869565217391, 0.77608695652174, 0.055555555555556
50144, 0.08695652173913, 0.75, 0.055555555555556
50145, 0.08695652173913, 0.77608695652174, 0.083333333333333
50146, 0.10869565217391, 0.77608695652174, 0.11111111111111
50147, 0.08695652173913, 0.75, 0.11111111111111
50148, 0.08695652173913, 0.77608695652174, 0.13888888888889
50149, 0.10869565217391, 0.77608695652174, 0.16666666666667
50150, 0.08695652173913, 0.75, 0.16666666666667
50151, 0.08695652173913, 0.77608695652174, 0.19444444444444
50152, 0.10869565217391, 0.77608695652174, 0.22222222222222
50153, 0.08695652173913, 0.75, 0.22222222222222
50154, 0.08695652173913, 0.77608695652174, 0.25
50155, 0.10869565217391, 0.77608695652174, 0.27777777777778
50156, 0.08695652173913, 0.75, 0.27777777777778
50157, 0.08695652173913, 0.77608695652174, 0.30555555555556
50158, 0.10869565217391, 0.77608695652174, 0.33333333333333
50159, 0.08695652173913, 0.75, 0.33333333333333
50160, 0.08695652173913, 0.77608695652174, 0.36111111111111
50161, 0.10869565217391, 0.77608695652174, 0.38888888888889
50162, 0.08695652173913, 0.75, 0.38888888888889
50163, 0.08695652173913, 0.77608695652174, 0.41666666666667
50164, 0.10869565217391, 0.77608695652174, 0.44444444444444
50165, 0.08695652173913, 0.75, 0.44444444444444
50166, 0.08695652173913, 0.77608695652174, 0.47222222222222
50167, 0.043478260869565, 0.77608695652174, 0.027777777777778
50168, 0.065217391304348, 0.77608695652174, 0.055555555555556
50169, 0.043478260869565, 0.75, 0.055555555555556
50170, 0.043478260869565, 0.77608695652174, 0.083333333333333
50171, 0.065217391304348, 0.77608695652174, 0.11111111111111
50172, 0.043478260869565, 0.75, 0.11111111111111
50173, 0.043478260869565, 0.77608695652174, 0.13888888888889
50174, 0.065217391304348, 0.77608695652174, 0.16666666666667
50175, 0.043478260869565, 0.75, 0.16666666666667
50176, 0.043478260869565, 0.77608695652174, 0.19444444444444
50177, 0.065217391304348, 0.77608695652174, 0.22222222222222
50178, 0.043478260869565, 0.75, 0.22222222222222
50179, 0.043478260869565, 0.77608695652174, 0.25
50180, 0.065217391304348, 0.77608695652174, 0.27777777777778
50181, 0.043478260869565, 0.75, 0.27777777777778
50182, 0.043478260869565, 0.77608695652174, 0.30555555555556
50183, 0.065217391304348, 0.77608695652174, 0.33333333333333
50184, 0.043478260869565, 0.75, 0.33333333333333
50185, 0.043478260869565, 0.77608695652174, 0.36111111111111
50186, 0.065217391304348, 0.77608695652174, 0.38888888888889
50187, 0.043478260869565, 0.75, 0.38888888888889
50188, 0.043478260869565, 0.77608695652174, 0.41666666666667
50189, 0.065217391304348, 0.77608695652174, 0.44444444444444
50190, 0.043478260869565, 0.75, 0.44444444444444
50191, 0.043478260869565, 0.77608695652174, 0.47222222222222
50192, 0.021739130434783, 0.77608695652174, 0.055555555555556
50193, 0.021739130434783, 0.77608695652174, 0.11111111111111
50194, 0.021739130434783, 0.77608695652174, 0.16666666666667
50195, 0.021739130434783, 0.77608695652174, 0.22222222222222
50196, 0.021739130434783, 0.77608695652174, 0.27777777777778
50197, 0.021739130434783, 0.77608695652174, 0.33333333333333
50198, 0.021739130434783, 0.77608695652174, 0.38888888888889
50199, 0.021739130434783, 0.77608695652174, 0.44444444444444
50200, 0.95652173913043, 0.82826086956522, 0.027777777777778
50201, 0.97826086956522, 0.82826086956522, 0.055555555555556
50202, 0.95652173913043, 0.80217391304348, 0.055555555555556
50203, 0.95652173913043, 0.82826086956522, 0.083333333333333
50204, 0.97826086956522, 0.82826086956522, 0.11111111111111
50205, 0.95652173913044, 0.80217391304348, 0.11111111111111
50206, 0.95652173913044, 0.82826086956522, 0.13888888888889
50207, 0.97826086956522, 0.82826086956522, 0.16666666666667
50208, 0.95652173913044, 0.80217391304348, 0.16666666666667
50209, 0.95652173913044, 0.82826086956522, 0.19444444444444
50210, 0.97826086956522, 0.82826086956522, 0.22222222222222
50211, 0.95652173913044, 0.80217391304348, 0.22222222222222
50212, 0.95652173913044, 0.82826086956522, 0.25
50213, 0.97826086956522, 0.82826086956522, 0.27777777777778
50214, 0.95652173913044, 0.80217391304348, 0.27777777777778
50215, 0.95652173913044, 0.82826086956522, 0.30555555555556
50216, 0.97826086956522, 0.82826086956522, 0.33333333333333
50217, 0.95652173913044, 0.80217391304348, 0.33333333333333
50218, 0.95652173913044, 0.82826086956522, 0.36111111111111
50219, 0.97826086956522, 0.82826086956522, 0.38888888888889
50220, 0.95652173913044, 0.80217391304348, 0.38888888888889
50221, 0.95652173913044, 0.82826086956522, 0.41666666666667
50222, 0.97826086956522, 0.82826086956522, 0.44444444444444
50223, 0.95652173913044, 0.80217391304348, 0.44444444444444
50224, 0.95652173913043, 0.82826086956522, 0.47222222222222
50225, 0.91304347826087, 0.82826086956522, 0.027777777777778
50226, 0.93478260869565, 0.82826086956522, 0.055555555555556
50227, 0.91304347826087, 0.80217391304348, 0.055555555555556
50228, 0.91304347826087, 0.82826086956522, 0.083333333333333
50229, 0.93478260869565, 0.82826086956522, 0.11111111111111
50230, 0.91304347826087, 0.80217391304348, 0.11111111111111
50231, 0.91304347826087, 0.82826086956522, 0.13888888888889
50232, 0.93478260869565, 0.82826086956522, 0.16666666666667
50233, 0.91304347826087, 0.80217391304348, 0.16666666666667
50234, 0.91304347826087, 0.82826086956522, 0.19444444444444
50235, 0.93478260869565, 0.82826086956522, 0.22222222222222
50236, 0.91304347826087, 0.80217391304348, 0.22222222222222
50237, 0.91304347826087, 0.82826086956522, 0.25
50238, 0.93478260869565, 0.82826086956522, 0.27777777777778
50239, 0.91304347826087, 0.80217391304348, 0.27777777777778
50240, 0.91304347826087, 0.82826086956522, 0.30555555555556
50241, 0.93478260869565, 0.82826086956522, 0.33333333333333
50242, 0.91304347826087, 0.80217391304348, 0.33333333333333
50243, 0.91304347826087, 0.82826086956522, 0.36111111111111
50244, 0.93478260869565, 0.82826086956522, 0.38888888888889
50245, 0.91304347826087, 0.80217391304348, 0.38888888888889
50246, 0.91304347826087, 0.82826086956522, 0.41666666666667
50247, 0.93478260869565, 0.82826086956522, 0.44444444444444
50248, 0.91304347826087, 0.80217391304348, 0.44444444444444
50249, 0.91304347826087, 0.82826086956522, 0.47222222222222
50250, 0.8695652173913, 0.82826086956522, 0.027777777777778
50251, 0.89130434782609, 0.82826086956522, 0.055555555555556
50252, 0.8695652173913, 0.80217391304348, 0.055555555555556
50253, 0.8695652173913, 0.82826086956522, 0.083333333333333
50254, 0.89130434782609, 0.82826086956522, 0.11111111111111
50255, 0.8695652173913, 0.80217391304348, 0.11111111111111
50256, 0.8695652173913, 0.82826086956522, 0.13888888888889
50257, 0.89130434782609, 0.82826086956522, 0.16666666666667
50258, 0.8695652173913, 0.80217391304348, 0.16666666666667
50259, 0.8695652173913, 0.82826086956522, 0.19444444444444
50260, 0.89130434782609, 0.82826086956522, 0.22222222222222
50261, 0.8695652173913, 0.80217391304348, 0.22222222222222
50262, 0.8695652173913, 0.82826086956522, 0.25
50263, 0.89130434782609, 0.82826086956522, 0.27777777777778
50264, 0.8695652173913, 0.80217391304348, 0.27777777777778
50265, 0.8695652173913, 0.82826086956522, 0.30555555555556
50266, 0.89130434782609, 0.82826086956522, 0.33333333333333
50267, 0.8695652173913, 0.80217391304348, 0.33333333333333
50268, 0.8695652173913, 0.82826086956522, 0.36111111111111
50269, 0.89130434782609, 0.82826086956522, 0.38888888888889
50270, 0.8695652173913, 0.80217391304348, 0.38888888888889
50271, 0.8695652173913, 0.82826086956522, 0.41666666666667
50272, 0.89130434782609, 0.82826086956522, 0.44444444444444
50273, 0.8695652173913, 0.80217391304348, 0.44444444444444
50274, 0.8695652173913, 0.82826086956522, 0.47222222222222
50275, 0.82608695652174, 0.82826086956522, 0.027777777777778
50276, 0.84782608695652, 0.82826086956522, 0.055555555555556
50277, 0.82608695652174, 0.80217391304348, 0.055555555555556
50278, 0.82608695652174, 0.82826086956522, 0.083333333333333
50279, 0.84782608695652, 0.82826086956522, 0.11111111111111
50280, 0.82608695652174, 0.80217391304348, 0.11111111111111
50281, 0.82608695652174, 0.82826086956522, 0.13888888888889
50282, 0.84782608695652, 0.82826086956522, 0.16666666666667
50283, 0.82608695652174, 0.80217391304348, 0.16666666666667
50284, 0.82608695652174, 0.82826086956522, 0.19444444444444
50285, 0.84782608695652, 0.82826086956522, 0.22222222222222
50286, 0.82608695652174, 0.80217391304348, 0.22222222222222
50287, 0.82608695652174, 0.82826086956522, 0.25
50288, 0.84782608695652, 0.82826086956522, 0.27777777777778
50289, 0.82608695652174, 0.80217391304348, 0.27777777777778
50290, 0.82608695652174, 0.82826086956522, 0.30555555555556
50291, 0.84782608695652, 0.82826086956522, 0.33333333333333
50292, 0.82608695652174, 0.80217391304348, 0.33333333333333
50293, 0.82608695652174, 0.82826086956522, 0.36111111111111
50294, 0.84782608695652, 0.82826086956522, 0.38888888888889
50295, 0.82608695652174, 0.80217391304348, 0.38888888888889
50296, 0.82608695652174, 0.82826086956522, 0.41666666666667
50297, 0.84782608695652, 0.82826086956522, 0.44444444444444
50298, 0.82608695652174, 0.80217391304348, 0.44444444444444
50299, 0.82608695652174, 0.82826086956522, 0.47222222222222
50300, 0.78260869565217, 0.82826086956522, 0.027777777777778
50301, 0.80434782608696, 0.82826086956522, 0.055555555555556
50302, 0.78260869565217, 0.80217391304348, 0.055555555555556
50303, 0.78260869565217, 0.82826086956522, 0.083333333333333
50304, 0.80434782608696, 0.82826086956522, 0.11111111111111
50305, 0.78260869565217, 0.80217391304348, 0.11111111111111
50306, 0.78260869565217, 0.82826086956522, 0.13888888888889
50307, 0.80434782608696, 0.82826086956522, 0.16666666666667
50308, 0.78260869565217, 0.80217391304348, 0.16666666666667
50309, 0.78260869565217, 0.82826086956522, 0.19444444444444
50310, 0.80434782608696, 0.82826086956522, 0.22222222222222
50311, 0.78260869565217, 0.80217391304348, 0.22222222222222
50312, 0.78260869565217, 0.82826086956522, 0.25
50313, 0.80434782608696, 0.82826086956522, 0.27777777777778
50314, 0.78260869565217, 0.80217391304348, 0.27777777777778
50315, 0.78260869565217, 0.82826086956522, 0.30555555555556
50316, 0.80434782608696, 0.82826086956522, 0.33333333333333
50317, 0.78260869565217, 0.80217391304348, 0.33333333333333
50318, 0.78260869565217, 0.82826086956522, 0.36111111111111
50319, 0.80434782608696, 0.82826086956522, 0.38888888888889
50320, 0.78260869565217, 0.80217391304348, 0.38888888888889
50321, 0.78260869565217, 0.82826086956522, 0.41666666666667
50322, 0.80434782608696, 0.82826086956522, 0.44444444444444
50323, 0.78260869565217, 0.80217391304348, 0.44444444444444
50324, 0.78260869565217, 0.82826086956522, 0.47222222222222
50325, 0.73913043478261, 0.82826086956522, 0.027777777777778
50326, 0.76086956521739, 0.82826086956522, 0.055555555555556
50327, 0.73913043478261, 0.80217391304348, 0.055555555555556
50328, 0.73913043478261, 0.82826086956522, 0.083333333333333
50329, 0.76086956521739, 0.82826086956522, 0.11111111111111
50330, 0.73913043478261, 0.80217391304348, 0.11111111111111
50331, 0.73913043478261, 0.82826086956522, 0.13888888888889
50332, 0.76086956521739, 0.82826086956522, 0.16666666666667
50333, 0.73913043478261, 0.80217391304348, 0.16666666666667
50334, 0.73913043478261, 0.82826086956522, 0.19444444444444
50335, 0.76086956521739, 0.82826086956522, 0.22222222222222
50336, 0.73913043478261, 0.80217391304348, 0.22222222222222
50337, 0.73913043478261, 0.82826086956522, 0.25
50338, 0.76086956521739, 0.82826086956522, 0.27777777777778
50339, 0.73913043478261, 0.80217391304348, 0.27777777777778
50340, 0.73913043478261, 0.82826086956522, 0.30555555555556
50341, 0.76086956521739, 0.82826086956522, 0.33333333333333
50342, 0.73913043478261, 0.80217391304348, 0.33333333333333
50343, 0.73913043478261, 0.82826086956522, 0.36111111111111
50344, 0.76086956521739, 0.82826086956522, 0.38888888888889
50345, 0.73913043478261, 0.80217391304348, 0.38888888888889
50346, 0.73913043478261, 0.82826086956522, 0.41666666666667
50347, 0.76086956521739, 0.82826086956522, 0.44444444444444
50348, 0.73913043478261, 0.80217391304348, 0.44444444444444
50349, 0.73913043478261, 0.82826086956522, 0.47222222222222
50350, 0.69565217391304, 0.82826086956522, 0.027777777777778
50351, 0.71739130434783, 0.82826086956522, 0.055555555555556
50352, 0.69565217391304, 0.80217391304348, 0.055555555555556
50353, 0.69565217391304, 0.82826086956522, 0.083333333333333
50354, 0.71739130434783, 0.82826086956522, 0.11111111111111
50355, 0.69565217391304, 0.80217391304348, 0.11111111111111
50356, 0.69565217391304, 0.82826086956522, 0.13888888888889
50357, 0.71739130434783, 0.82826086956522, 0.16666666666667
50358, 0.69565217391304, 0.80217391304348, 0.16666666666667
50359, 0.69565217391304, 0.82826086956522, 0.19444444444444
50360, 0.71739130434783, 0.82826086956522, 0.22222222222222
50361, 0.69565217391304, 0.80217391304348, 0.22222222222222
50362, 0.69565217391304, 0.82826086956522, 0.25
50363, 0.71739130434783, 0.82826086956522, 0.27777777777778
50364, 0.69565217391304, 0.80217391304348, 0.27777777777778
50365, 0.69565217391304, 0.82826086956522, 0.30555555555556
50366, 0.71739130434783, 0.82826086956522, 0.33333333333333
50367, 0.69565217391304, 0.80217391304348, 0.33333333333333
50368, 0.69565217391304, 0.82826086956522, 0.36111111111111
50369, 0.71739130434783, 0.82826086956522, 0.38888888888889
50370, 0.69565217391304, 0.80217391304348, 0.38888888888889
50371, 0.69565217391304, 0.82826086956522, 0.41666666666667
50372, 0.71739130434783, 0.82826086956522, 0.44444444444444
50373, 0.69565217391304, 0.80217391304348, 0.44444444444444
50374, 0.69565217391304, 0.82826086956522, 0.47222222222222
50375, 0.65217391304348, 0.82826086956522, 0.027777777777778
50376, 0.67391304347826, 0.82826086956522, 0.055555555555556
50377, 0.65217391304348, 0.80217391304348, 0.055555555555556
50378, 0.65217391304348, 0.82826086956522, 0.083333333333333
50379, 0.67391304347826, 0.82826086956522, 0.11111111111111
50380, 0.65217391304348, 0.80217391304348, 0.11111111111111
50381, 0.65217391304348, 0.82826086956522, 0.13888888888889
50382, 0.67391304347826, 0.82826086956522, 0.16666666666667
50383, 0.65217391304348, 0.80217391304348, 0.16666666666667
50384, 0.65217391304348, 0.82826086956522, 0.19444444444444
50385, 0.67391304347826, 0.82826086956522, 0.22222222222222
50386, 0.65217391304348, 0.80217391304348, 0.22222222222222
50387, 0.65217391304348, 0.82826086956522, 0.25
50388, 0.67391304347826, 0.82826086956522, 0.27777777777778
50389, 0.65217391304348, 0.80217391304348, 0.27777777777778
50390, 0.65217391304348, 0.82826086956522, 0.30555555555556
50391, 0.67391304347826, 0.82826086956522, 0.33333333333333
50392, 0.65217391304348, 0.80217391304348, 0.33333333333333
50393, 0.65217391304348, 0.82826086956522, 0.36111111111111
50394, 0.67391304347826, 0.82826086956522, 0.38888888888889
50395, 0.65217391304348, 0.80217391304348, 0.38888888888889
50396, 0.65217391304348, 0.82826086956522, 0.41666666666667
50397, 0.67391304347826, 0.82826086956522, 0.44444444444444
50398, 0.65217391304348, 0.80217391304348, 0.44444444444444
50399, 0.65217391304348, 0.82826086956522, 0.47222222222222
50400, 0.60869565217391, 0.82826086956522, 0.027777777777778
50401, 0.6304347826087, 0.82826086956522, 0.055555555555556
50402, 0.60869565217391, 0.80217391304348, 0.055555555555556
50403, 0.60869565217391, 0.82826086956522, 0.083333333333333
50404, 0.6304347826087, 0.82826086956522, 0.11111111111111
50405, 0.60869565217391, 0.80217391304348, 0.11111111111111
50406, 0.60869565217391, 0.82826086956522, 0.13888888888889
50407, 0.6304347826087, 0.82826086956522, 0.16666666666667
50408, 0.60869565217391, 0.80217391304348, 0.16666666666667
50409, 0.60869565217391, 0.82826086956522, 0.19444444444444
50410, 0.6304347826087, 0.82826086956522, 0.22222222222222
50411, 0.60869565217391, 0.80217391304348, 0.22222222222222
50412, 0.60869565217391, 0.82826086956522, 0.25
50413, 0.6304347826087, 0.82826086956522, 0.27777777777778
50414, 0.60869565217391, 0.80217391304348, 0.27777777777778
50415, 0.60869565217391, 0.82826086956522, 0.30555555555556
50416, 0.6304347826087, 0.82826086956522, 0.33333333333333
50417, 0.60869565217391, 0.80217391304348, 0.33333333333333
50418, 0.60869565217391, 0.82826086956522, 0.36111111111111
50419, 0.6304347826087, 0.82826086956522, 0.38888888888889
50420, 0.60869565217391, 0.80217391304348, 0.38888888888889
50421, 0.60869565217391, 0.82826086956522, 0.41666666666667
50422, 0.6304347826087, 0.82826086956522, 0.44444444444444
50423, 0.60869565217391, 0.80217391304348, 0.44444444444444
50424, 0.60869565217391, 0.82826086956522, 0.47222222222222
50425, 0.56521739130435, 0.82826086956522, 0.027777777777778
50426, 0.58695652173913, 0.82826086956522, 0.055555555555556
50427, 0.56521739130435, 0.80217391304348, 0.055555555555556
50428, 0.56521739130435, 0.82826086956522, 0.083333333333333
50429, 0.58695652173913, 0.82826086956522, 0.11111111111111
50430, 0.56521739130435, 0.80217391304348, 0.11111111111111
50431, 0.56521739130435, 0.82826086956522, 0.13888888888889
50432, 0.58695652173913, 0.82826086956522, 0.16666666666667
50433, 0.56521739130435, 0.80217391304348, 0.16666666666667
50434, 0.56521739130435, 0.82826086956522, 0.19444444444444
50435, 0.58695652173913, 0.82826086956522, 0.22222222222222
50436, 0.56521739130435, 0.80217391304348, 0.22222222222222
50437, 0.56521739130435, 0.82826086956522, 0.25
50438, 0.58695652173913, 0.82826086956522, 0.27777777777778
50439, 0.56521739130435, 0.80217391304348, 0.27777777777778
50440, 0.56521739130435, 0.82826086956522, 0.30555555555556
50441, 0.58695652173913, 0.82826086956522, 0.33333333333333
50442, 0.56521739130435, 0.80217391304348, 0.33333333333333
50443, 0.56521739130435, 0.82826086956522, 0.36111111111111
50444, 0.58695652173913, 0.82826086956522, 0.38888888888889
50445, 0.56521739130435, 0.80217391304348, 0.38888888888889
50446, 0.56521739130435, 0.82826086956522, 0.41666666666667
50447, 0.58695652173913, 0.82826086956522, 0.44444444444444
50448, 0.56521739130435, 0.80217391304348, 0.44444444444444
50449, 0.56521739130435, 0.82826086956522, 0.47222222222222
50450, 0.52173913043478, 0.82826086956522, 0.027777777777778
50451, 0.54347826086957, 0.82826086956522, 0.055555555555556
50452, 0.52173913043478, 0.80217391304348, 0.055555555555556
50453, 0.52173913043478, 0.82826086956522, 0.083333333333333
50454, 0.54347826086957, 0.82826086956522, 0.11111111111111
50455, 0.52173913043478, 0.80217391304348, 0.11111111111111
50456, 0.52173913043478, 0.82826086956522, 0.13888888888889
50457, 0.54347826086957, 0.82826086956522, 0.16666666666667
50458, 0.52173913043478, 0.80217391304348, 0.16666666666667
50459, 0.52173913043478, 0.82826086956522, 0.19444444444444
50460, 0.54347826086956, 0.82826086956522, 0.22222222222222
50461, 0.52173913043478, 0.80217391304348, 0.22222222222222
50462, 0.52173913043478, 0.82826086956522, 0.25
50463, 0.54347826086956, 0.82826086956522, 0.27777777777778
50464, 0.52173913043478, 0.80217391304348, 0.27777777777778
50465, 0.52173913043478, 0.82826086956522, 0.30555555555556
50466, 0.54347826086956, 0.82826086956522, 0.33333333333333
50467, 0.52173913043478, 0.80217391304348, 0.33333333333333
50468, 0.52173913043478, 0.82826086956522, 0.36111111111111
50469, 0.54347826086956, 0.82826086956522, 0.38888888888889
50470, 0.52173913043478, 0.80217391304348, 0.38888888888889
50471, 0.52173913043478, 0.82826086956522, 0.41666666666667
50472, 0.54347826086956, 0.82826086956522, 0.44444444444444
50473, 0.52173913043478, 0.80217391304348, 0.44444444444444
50474, 0.52173913043478, 0.82826086956522, 0.47222222222222
50475, 0.47826086956522, 0.82826086956522, 0.027777777777778
50476, 0.5, 0.82826086956522, 0.055555555555556
50477, 0.47826086956522, 0.80217391304348, 0.055555555555556
50478, 0.47826086956522, 0.82826086956522, 0.083333333333333
50479, 0.5, 0.82826086956522, 0.11111111111111
50480, 0.47826086956522, 0.80217391304348, 0.11111111111111
50481, 0.47826086956522, 0.82826086956522, 0.13888888888889
50482, 0.5, 0.82826086956522, 0.16666666666667
50483, 0.47826086956522, 0.80217391304348, 0.16666666666667
50484, 0.47826086956522, 0.82826086956522, 0.19444444444444
50485, 0.5, 0.82826086956522, 0.22222222222222
50486, 0.47826086956522, 0.80217391304348, 0.22222222222222
50487, 0.47826086956522, 0.82826086956522, 0.25
50488, 0.5, 0.82826086956522, 0.27777777777778
50489, 0.47826086956522, 0.80217391304348, 0.27777777777778
50490, 0.47826086956522, 0.82826086956522, 0.30555555555556
50491, 0.5, 0.82826086956522, 0.33333333333333
50492, 0.47826086956522, 0.80217391304348, 0.33333333333333
50493, 0.47826086956522, 0.82826086956522, 0.36111111111111
50494, 0.5, 0.82826086956522, 0.38888888888889
50495, 0.47826086956522, 0.80217391304348, 0.38888888888889
50496, 0.47826086956522, 0.82826086956522, 0.41666666666667
50497, 0.5, 0.82826086956522, 0.44444444444444
50498, 0.47826086956522, 0.80217391304348, 0.44444444444444
50499, 0.47826086956522, 0.82826086956522, 0.47222222222222
50500, 0.43478260869565, 0.82826086956522, 0.027777777777778
50501, 0.45652173913043, 0.82826086956522, 0.055555555555556
50502, 0.43478260869565, 0.80217391304348, 0.055555555555556
50503, 0.43478260869565, 0.82826086956522, 0.083333333333333
50504, 0.45652173913043, 0.82826086956522, 0.11111111111111
50505, 0.43478260869565, 0.80217391304348, 0.11111111111111
50506, 0.43478260869565, 0.82826086956522, 0.13888888888889
50507, 0.45652173913043, 0.82826086956522, 0.16666666666667
50508, 0.43478260869565, 0.80217391304348, 0.16666666666667
50509, 0.43478260869565, 0.82826086956522, 0.19444444444444
50510, 0.45652173913043, 0.82826086956522, 0.22222222222222
50511, 0.43478260869565, 0.80217391304348, 0.22222222222222
50512, 0.43478260869565, 0.82826086956522, 0.25
50513, 0.45652173913043, 0.82826086956522, 0.27777777777778
50514, 0.43478260869565, 0.80217391304348, 0.27777777777778
50515, 0.43478260869565, 0.82826086956522, 0.30555555555556
50516, 0.45652173913043, 0.82826086956522, 0.33333333333333
50517, 0.43478260869565, 0.80217391304348, 0.33333333333333
50518, 0.43478260869565, 0.82826086956522, 0.36111111111111
50519, 0.45652173913044, 0.82826086956522, 0.38888888888889
50520, 0.43478260869565, 0.80217391304348, 0.38888888888889
50521, 0.43478260869565, 0.82826086956522, 0.41666666666667
50522, 0.45652173913043, 0.82826086956522, 0.44444444444444
50523, 0.43478260869565, 0.80217391304348, 0.44444444444444
50524, 0.43478260869565, 0.82826086956522, 0.47222222222222
50525, 0.39130434782609, 0.82826086956522, 0.027777777777778
50526, 0.41304347826087, 0.82826086956522, 0.055555555555556
50527, 0.39130434782609, 0.80217391304348, 0.055555555555556
50528, 0.39130434782609, 0.82826086956522, 0.083333333333333
50529, 0.41304347826087, 0.82826086956522, 0.11111111111111
50530, 0.39130434782609, 0.80217391304348, 0.11111111111111
50531, 0.39130434782609, 0.82826086956522, 0.13888888888889
50532, 0.41304347826087, 0.82826086956522, 0.16666666666667
50533, 0.39130434782609, 0.80217391304348, 0.16666666666667
50534, 0.39130434782609, 0.82826086956522, 0.19444444444444
50535, 0.41304347826087, 0.82826086956522, 0.22222222222222
50536, 0.39130434782609, 0.80217391304348, 0.22222222222222
50537, 0.39130434782609, 0.82826086956522, 0.25
50538, 0.41304347826087, 0.82826086956522, 0.27777777777778
50539, 0.39130434782609, 0.80217391304348, 0.27777777777778
50540, 0.39130434782609, 0.82826086956522, 0.30555555555556
50541, 0.41304347826087, 0.82826086956522, 0.33333333333333
50542, 0.39130434782609, 0.80217391304348, 0.33333333333333
50543, 0.39130434782609, 0.82826086956522, 0.36111111111111
50544, 0.41304347826087, 0.82826086956522, 0.38888888888889
50545, 0.39130434782609, 0.80217391304348, 0.38888888888889
50546, 0.39130434782609, 0.82826086956522, 0.41666666666667
50547, 0.41304347826087, 0.82826086956522, 0.44444444444444
50548, 0.39130434782609, 0.80217391304348, 0.44444444444444
50549, 0.39130434782609, 0.82826086956522, 0.47222222222222
50550, 0.34782608695652, 0.82826086956522, 0.027777777777778
50551, 0.3695652173913, 0.82826086956522, 0.055555555555556
50552, 0.34782608695652, 0.80217391304348, 0.055555555555556
50553, 0.34782608695652, 0.82826086956522, 0.083333333333333
50554, 0.3695652173913, 0.82826086956522, 0.11111111111111
50555, 0.34782608695652, 0.80217391304348, 0.11111111111111
50556, 0.34782608695652, 0.82826086956522, 0.13888888888889
50557, 0.3695652173913, 0.82826086956522, 0.16666666666667
50558, 0.34782608695652, 0.80217391304348, 0.16666666666667
50559, 0.34782608695652, 0.82826086956522, 0.19444444444444
50560, 0.3695652173913, 0.82826086956522, 0.22222222222222
50561, 0.34782608695652, 0.80217391304348, 0.22222222222222
50562, 0.34782608695652, 0.82826086956522, 0.25
50563, 0.3695652173913, 0.82826086956522, 0.27777777777778
50564, 0.34782608695652, 0.80217391304348, 0.27777777777778
50565, 0.34782608695652, 0.82826086956522, 0.30555555555556
50566, 0.3695652173913, 0.82826086956522, 0.33333333333333
50567, 0.34782608695652, 0.80217391304348, 0.33333333333333
50568, 0.34782608695652, 0.82826086956522, 0.36111111111111
50569, 0.3695652173913, 0.82826086956522, 0.38888888888889
50570, 0.34782608695652, 0.80217391304348, 0.38888888888889
50571, 0.34782608695652, 0.82826086956522, 0.41666666666667
50572, 0.3695652173913, 0.82826086956522, 0.44444444444444
50573, 0.34782608695652, 0.80217391304348, 0.44444444444444
50574, 0.34782608695652, 0.82826086956522, 0.47222222222222
50575, 0.30434782608696, 0.82826086956522, 0.027777777777778
50576, 0.32608695652174, 0.82826086956522, 0.055555555555556
50577, 0.30434782608696, 0.80217391304348, 0.055555555555556
50578, 0.30434782608696, 0.82826086956522, 0.083333333333333
50579, 0.32608695652174, 0.82826086956522, 0.11111111111111
50580, 0.30434782608696, 0.80217391304348, 0.11111111111111
50581, 0.30434782608696, 0.82826086956522, 0.13888888888889
50582, 0.32608695652174, 0.82826086956522, 0.16666666666667
50583, 0.30434782608696, 0.80217391304348, 0.16666666666667
50584, 0.30434782608696, 0.82826086956522, 0.19444444444444
50585, 0.32608695652174, 0.82826086956522, 0.22222222222222
50586, 0.30434782608696, 0.80217391304348, 0.22222222222222
50587, 0.30434782608696, 0.82826086956522, 0.25
50588, 0.32608695652174, 0.82826086956522, 0.27777777777778
50589, 0.30434782608696, 0.80217391304348, 0.27777777777778
50590, 0.30434782608696, 0.82826086956522, 0.30555555555556
50591, 0.32608695652174, 0.82826086956522, 0.33333333333333
50592, 0.30434782608696, 0.80217391304348, 0.33333333333333
50593, 0.30434782608696, 0.82826086956522, 0.36111111111111
50594, 0.32608695652174, 0.82826086956522, 0.38888888888889
50595, 0.30434782608696, 0.80217391304348, 0.38888888888889
50596, 0.30434782608696, 0.82826086956522, 0.41666666666667
50597, 0.32608695652174, 0.82826086956522, 0.44444444444444
50598, 0.30434782608696, 0.80217391304348, 0.44444444444444
50599, 0.30434782608696, 0.82826086956522, 0.47222222222222
50600, 0.26086956521739, 0.82826086956522, 0.027777777777778
50601, 0.28260869565217, 0.82826086956522, 0.055555555555556
50602, 0.26086956521739, 0.80217391304348, 0.055555555555556
50603, 0.26086956521739, 0.82826086956522, 0.083333333333333
50604, 0.28260869565217, 0.82826086956522, 0.11111111111111
50605, 0.26086956521739, 0.80217391304348, 0.11111111111111
50606, 0.26086956521739, 0.82826086956522, 0.13888888888889
50607, 0.28260869565217, 0.82826086956522, 0.16666666666667
50608, 0.26086956521739, 0.80217391304348, 0.16666666666667
50609, 0.26086956521739, 0.82826086956522, 0.19444444444444
50610, 0.28260869565217, 0.82826086956522, 0.22222222222222
50611, 0.26086956521739, 0.80217391304348, 0.22222222222222
50612, 0.26086956521739, 0.82826086956522, 0.25
50613, 0.28260869565217, 0.82826086956522, 0.27777777777778
50614, 0.26086956521739, 0.80217391304348, 0.27777777777778
50615, 0.26086956521739, 0.82826086956522, 0.30555555555556
50616, 0.28260869565217, 0.82826086956522, 0.33333333333333
50617, 0.26086956521739, 0.80217391304348, 0.33333333333333
50618, 0.26086956521739, 0.82826086956522, 0.36111111111111
50619, 0.28260869565217, 0.82826086956522, 0.38888888888889
50620, 0.26086956521739, 0.80217391304348, 0.38888888888889
50621, 0.26086956521739, 0.82826086956522, 0.41666666666667
50622, 0.28260869565217, 0.82826086956522, 0.44444444444444
50623, 0.26086956521739, 0.80217391304348, 0.44444444444444
50624, 0.26086956521739, 0.82826086956522, 0.47222222222222
50625, 0.21739130434783, 0.82826086956522, 0.027777777777778
50626, 0.23913043478261, 0.82826086956522, 0.055555555555556
50627, 0.21739130434783, 0.80217391304348, 0.055555555555556
50628, 0.21739130434783, 0.82826086956522, 0.083333333333333
50629, 0.23913043478261, 0.82826086956522, 0.11111111111111
50630, 0.21739130434783, 0.80217391304348, 0.11111111111111
50631, 0.21739130434783, 0.82826086956522, 0.13888888888889
50632, 0.23913043478261, 0.82826086956522, 0.16666666666667
50633, 0.21739130434783, 0.80217391304348, 0.16666666666667
50634, 0.21739130434783, 0.82826086956522, 0.19444444444444
50635, 0.23913043478261, 0.82826086956522, 0.22222222222222
50636, 0.21739130434783, 0.80217391304348, 0.22222222222222
50637, 0.21739130434783, 0.82826086956522, 0.25
50638, 0.23913043478261, 0.82826086956522, 0.27777777777778
50639, 0.21739130434783, 0.80217391304348, 0.27777777777778
50640, 0.21739130434783, 0.82826086956522, 0.30555555555556
50641, 0.23913043478261, 0.82826086956522, 0.33333333333333
50642, 0.21739130434783, 0.80217391304348, 0.33333333333333
50643, 0.21739130434783, 0.82826086956522, 0.36111111111111
50644, 0.23913043478261, 0.82826086956522, 0.38888888888889
50645, 0.21739130434783, 0.80217391304348, 0.38888888888889
50646, 0.21739130434783, 0.82826086956522, 0.41666666666667
50647, 0.23913043478261, 0.82826086956522, 0.44444444444444
50648, 0.21739130434783, 0.80217391304348, 0.44444444444444
50649, 0.21739130434783, 0.82826086956522, 0.47222222222222
50650, 0.17391304347826, 0.82826086956522, 0.027777777777778
50651, 0.19565217391304, 0.82826086956522, 0.055555555555556
50652, 0.17391304347826, 0.80217391304348, 0.055555555555556
50653, 0.17391304347826, 0.82826086956522, 0.083333333333333
50654, 0.19565217391304, 0.82826086956522, 0.11111111111111
50655, 0.17391304347826, 0.80217391304348, 0.11111111111111
50656, 0.17391304347826, 0.82826086956522, 0.13888888888889
50657, 0.19565217391304, 0.82826086956522, 0.16666666666667
50658, 0.17391304347826, 0.80217391304348, 0.16666666666667
50659, 0.17391304347826, 0.82826086956522, 0.19444444444444
50660, 0.19565217391304, 0.82826086956522, 0.22222222222222
50661, 0.17391304347826, 0.80217391304348, 0.22222222222222
50662, 0.17391304347826, 0.82826086956522, 0.25
50663, 0.19565217391304, 0.82826086956522, 0.27777777777778
50664, 0.17391304347826, 0.80217391304348, 0.27777777777778
50665, 0.17391304347826, 0.82826086956522, 0.30555555555556
50666, 0.19565217391304, 0.82826086956522, 0.33333333333333
50667, 0.17391304347826, 0.80217391304348, 0.33333333333333
50668, 0.17391304347826, 0.82826086956522, 0.36111111111111
50669, 0.19565217391304, 0.82826086956522, 0.38888888888889
50670, 0.17391304347826, 0.80217391304348, 0.38888888888889
50671, 0.17391304347826, 0.82826086956522, 0.41666666666667
50672, 0.19565217391304, 0.82826086956522, 0.44444444444444
50673, 0.17391304347826, 0.80217391304348, 0.44444444444444
50674, 0.17391304347826, 0.82826086956522, 0.47222222222222
50675, 0.1304347826087, 0.82826086956522, 0.027777777777778
50676, 0.15217391304348, 0.82826086956522, 0.055555555555556
50677, 0.1304347826087, 0.80217391304348, 0.055555555555556
50678, 0.1304347826087, 0.82826086956522, 0.083333333333333
50679, 0.15217391304348, 0.82826086956522, 0.11111111111111
50680, 0.1304347826087, 0.80217391304348, 0.11111111111111
50681, 0.1304347826087, 0.82826086956522, 0.13888888888889
50682, 0.15217391304348, 0.82826086956522, 0.16666666666667
50683, 0.1304347826087, 0.80217391304348, 0.16666666666667
50684, 0.1304347826087, 0.82826086956522, 0.19444444444444
50685, 0.15217391304348, 0.82826086956522, 0.22222222222222
50686, 0.1304347826087, 0.80217391304348, 0.22222222222222
50687, 0.1304347826087, 0.82826086956522, 0.25
50688, 0.15217391304348, 0.82826086956522, 0.27777777777778
50689, 0.1304347826087, 0.80217391304348, 0.27777777777778
50690, 0.1304347826087, 0.82826086956522, 0.30555555555556
50691, 0.15217391304348, 0.82826086956522, 0.33333333333333
50692, 0.1304347826087, 0.80217391304348, 0.33333333333333
50693, 0.1304347826087, 0.82826086956522, 0.36111111111111
50694, 0.15217391304348, 0.82826086956522, 0.38888888888889
50695, 0.1304347826087, 0.80217391304348, 0.38888888888889
50696, 0.1304347826087, 0.82826086956522, 0.41666666666667
50697, 0.15217391304348, 0.82826086956522, 0.44444444444444
50698, 0.1304347826087, 0.80217391304348, 0.44444444444444
50699, 0.1304347826087, 0.82826086956522, 0.47222222222222
50700, 0.08695652173913, 0.82826086956522, 0.027777777777778
50701, 0.10869565217391, 0.82826086956522, 0.055555555555556
50702, 0.08695652173913, 0.80217391304348, 0.055555555555556
50703, 0.08695652173913, 0.82826086956522, 0.083333333333333
50704, 0.10869565217391, 0.82826086956522, 0.11111111111111
50705, 0.08695652173913, 0.80217391304348, 0.11111111111111
50706, 0.08695652173913, 0.82826086956522, 0.13888888888889
50707, 0.10869565217391, 0.82826086956522, 0.16666666666667
50708, 0.08695652173913, 0.80217391304348, 0.16666666666667
50709, 0.08695652173913, 0.82826086956522, 0.19444444444444
50710, 0.10869565217391, 0.82826086956522, 0.22222222222222
50711, 0.08695652173913, 0.80217391304348, 0.22222222222222
50712, 0.08695652173913, 0.82826086956522, 0.25
50713, 0.10869565217391, 0.82826086956522, 0.27777777777778
50714, 0.08695652173913, 0.80217391304348, 0.27777777777778
50715, 0.08695652173913, 0.82826086956522, 0.30555555555556
50716, 0.10869565217391, 0.82826086956522, 0.33333333333333
50717, 0.08695652173913, 0.80217391304348, 0.33333333333333
50718, 0.08695652173913, 0.82826086956522, 0.36111111111111
50719, 0.10869565217391, 0.82826086956522, 0.38888888888889
50720, 0.08695652173913, 0.80217391304348, 0.38888888888889
50721, 0.08695652173913, 0.82826086956522, 0.41666666666667
50722, 0.10869565217391, 0.82826086956522, 0.44444444444444
50723, 0.08695652173913, 0.80217391304348, 0.44444444444444
50724, 0.08695652173913, 0.82826086956522, 0.47222222222222
50725, 0.043478260869565, 0.82826086956522, 0.027777777777778
50726, 0.065217391304348, 0.82826086956522, 0.055555555555556
50727, 0.043478260869565, 0.80217391304348, 0.055555555555556
50728, 0.043478260869565, 0.82826086956522, 0.083333333333333
50729, 0.065217391304348, 0.82826086956522, 0.11111111111111
50730, 0.043478260869565, 0.80217391304348, 0.11111111111111
50731, 0.043478260869565, 0.82826086956522, 0.13888888888889
50732, 0.065217391304348, 0.82826086956522, 0.16666666666667
50733, 0.043478260869565, 0.80217391304348, 0.16666666666667
50734, 0.043478260869565, 0.82826086956522, 0.19444444444444
50735, 0.065217391304348, 0.82826086956522, 0.22222222222222
50736, 0.043478260869565, 0.80217391304348, 0.22222222222222
50737, 0.043478260869565, 0.82826086956522, 0.25
50738, 0.065217391304348, 0.82826086956522, 0.27777777777778
50739, 0.043478260869565, 0.80217391304348, 0.27777777777778
50740, 0.043478260869565, 0.82826086956522, 0.30555555555556
50741, 0.065217391304348, 0.82826086956522, 0.33333333333333
50742, 0.043478260869565, 0.80217391304348, 0.33333333333333
50743, 0.043478260869565, 0.82826086956522, 0.36111111111111
50744, 0.065217391304348, 0.82826086956522, 0.38888888888889
50745, 0.043478260869565, 0.80217391304348, 0.38888888888889
50746, 0.043478260869565, 0.82826086956522, 0.41666666666667
50747, 0.065217391304348, 0.82826086956522, 0.44444444444444
50748, 0.043478260869565, 0.80217391304348, 0.44444444444444
50749, 0.043478260869565, 0.82826086956522, 0.47222222222222
50750, 0.021739130434783, 0.82826086956522, 0.055555555555556
50751, 0.021739130434783, 0.82826086956522, 0.11111111111111
50752, 0.021739130434783, 0.82826086956522, 0.16666666666667
50753, 0.021739130434783, 0.82826086956522, 0.22222222222222
50754, 0.021739130434783, 0.82826086956522, 0.27777777777778
50755, 0.021739130434783, 0.82826086956522, 0.33333333333333
50756, 0.021739130434783, 0.82826086956522, 0.38888888888889
50757, 0.021739130434783, 0.82826086956522, 0.44444444444444
50758, 0.95652173913043, 0.88043478260869, 0.027777777777778
50759, 0.97826086956522, 0.88043478260869, 0.055555555555556
50760, 0.95652173913043, 0.85434782608696, 0.055555555555556
50761, 0.95652173913043, 0.88043478260869, 0.083333333333333
50762, 0.97826086956522, 0.88043478260869, 0.11111111111111
50763, 0.95652173913044, 0.85434782608696, 0.11111111111111
50764, 0.95652173913044, 0.8804347826087, 0.13888888888889
50765, 0.97826086956522, 0.8804347826087, 0.16666666666667
50766, 0.95652173913044, 0.85434782608696, 0.16666666666667
50767, 0.95652173913044, 0.8804347826087, 0.19444444444444
50768, 0.97826086956522, 0.8804347826087, 0.22222222222222
50769, 0.95652173913044, 0.85434782608696, 0.22222222222222
50770, 0.95652173913044, 0.88043478260869, 0.25
50771, 0.97826086956522, 0.88043478260869, 0.27777777777778
50772, 0.95652173913044, 0.85434782608696, 0.27777777777778
50773, 0.95652173913044, 0.8804347826087, 0.30555555555556
50774, 0.97826086956522, 0.8804347826087, 0.33333333333333
50775, 0.95652173913044, 0.85434782608696, 0.33333333333333
50776, 0.95652173913044, 0.8804347826087, 0.36111111111111
50777, 0.97826086956522, 0.88043478260869, 0.38888888888889
50778, 0.95652173913044, 0.85434782608696, 0.38888888888889
50779, 0.95652173913044, 0.88043478260869, 0.41666666666667
50780, 0.97826086956522, 0.88043478260869, 0.44444444444444
50781, 0.95652173913044, 0.85434782608696, 0.44444444444444
50782, 0.95652173913043, 0.88043478260869, 0.47222222222222
50783, 0.91304347826087, 0.8804347826087, 0.027777777777778
50784, 0.93478260869565, 0.88043478260869, 0.055555555555556
50785, 0.91304347826087, 0.85434782608696, 0.055555555555556
50786, 0.91304347826087, 0.88043478260869, 0.083333333333333
50787, 0.93478260869565, 0.88043478260869, 0.11111111111111
50788, 0.91304347826087, 0.85434782608696, 0.11111111111111
50789, 0.91304347826087, 0.88043478260869, 0.13888888888889
50790, 0.93478260869565, 0.8804347826087, 0.16666666666667
50791, 0.91304347826087, 0.85434782608696, 0.16666666666667
50792, 0.91304347826087, 0.8804347826087, 0.19444444444444
50793, 0.93478260869565, 0.8804347826087, 0.22222222222222
50794, 0.91304347826087, 0.85434782608696, 0.22222222222222
50795, 0.91304347826087, 0.8804347826087, 0.25
50796, 0.93478260869565, 0.88043478260869, 0.27777777777778
50797, 0.91304347826087, 0.85434782608696, 0.27777777777778
50798, 0.91304347826087, 0.88043478260869, 0.30555555555556
50799, 0.93478260869565, 0.8804347826087, 0.33333333333333
50800, 0.91304347826087, 0.85434782608696, 0.33333333333333
50801, 0.91304347826087, 0.88043478260869, 0.36111111111111
50802, 0.93478260869565, 0.88043478260869, 0.38888888888889
50803, 0.91304347826087, 0.85434782608696, 0.38888888888889
50804, 0.91304347826087, 0.88043478260869, 0.41666666666667
50805, 0.93478260869565, 0.88043478260869, 0.44444444444444
50806, 0.91304347826087, 0.85434782608696, 0.44444444444444
50807, 0.91304347826087, 0.8804347826087, 0.47222222222222
50808, 0.8695652173913, 0.88043478260869, 0.027777777777778
50809, 0.89130434782609, 0.88043478260869, 0.055555555555556
50810, 0.8695652173913, 0.85434782608696, 0.055555555555556
50811, 0.8695652173913, 0.88043478260869, 0.083333333333333
50812, 0.89130434782609, 0.88043478260869, 0.11111111111111
50813, 0.8695652173913, 0.85434782608696, 0.11111111111111
50814, 0.8695652173913, 0.8804347826087, 0.13888888888889
50815, 0.89130434782609, 0.8804347826087, 0.16666666666667
50816, 0.8695652173913, 0.85434782608696, 0.16666666666667
50817, 0.8695652173913, 0.88043478260869, 0.19444444444444
50818, 0.89130434782609, 0.88043478260869, 0.22222222222222
50819, 0.8695652173913, 0.85434782608696, 0.22222222222222
50820, 0.8695652173913, 0.88043478260869, 0.25
50821, 0.89130434782609, 0.8804347826087, 0.27777777777778
50822, 0.8695652173913, 0.85434782608696, 0.27777777777778
50823, 0.8695652173913, 0.8804347826087, 0.30555555555556
50824, 0.89130434782609, 0.88043478260869, 0.33333333333333
50825, 0.8695652173913, 0.85434782608696, 0.33333333333333
50826, 0.8695652173913, 0.8804347826087, 0.36111111111111
50827, 0.89130434782609, 0.88043478260869, 0.38888888888889
50828, 0.8695652173913, 0.85434782608696, 0.38888888888889
50829, 0.8695652173913, 0.88043478260869, 0.41666666666667
50830, 0.89130434782609, 0.88043478260869, 0.44444444444444
50831, 0.8695652173913, 0.85434782608696, 0.44444444444444
50832, 0.8695652173913, 0.88043478260869, 0.47222222222222
50833, 0.82608695652174, 0.8804347826087, 0.027777777777778
50834, 0.84782608695652, 0.88043478260869, 0.055555555555556
50835, 0.82608695652174, 0.85434782608696, 0.055555555555556
50836, 0.82608695652174, 0.8804347826087, 0.083333333333333
50837, 0.84782608695652, 0.8804347826087, 0.11111111111111
50838, 0.82608695652174, 0.85434782608696, 0.11111111111111
50839, 0.82608695652174, 0.8804347826087, 0.13888888888889
50840, 0.84782608695652, 0.8804347826087, 0.16666666666667
50841, 0.82608695652174, 0.85434782608696, 0.16666666666667
50842, 0.82608695652174, 0.8804347826087, 0.19444444444444
50843, 0.84782608695652, 0.8804347826087, 0.22222222222222
50844, 0.82608695652174, 0.85434782608696, 0.22222222222222
50845, 0.82608695652174, 0.8804347826087, 0.25
50846, 0.84782608695652, 0.8804347826087, 0.27777777777778
50847, 0.82608695652174, 0.85434782608696, 0.27777777777778
50848, 0.82608695652174, 0.8804347826087, 0.30555555555556
50849, 0.84782608695652, 0.8804347826087, 0.33333333333333
50850, 0.82608695652174, 0.85434782608696, 0.33333333333333
50851, 0.82608695652174, 0.8804347826087, 0.36111111111111
50852, 0.84782608695652, 0.8804347826087, 0.38888888888889
50853, 0.82608695652174, 0.85434782608696, 0.38888888888889
50854, 0.82608695652174, 0.8804347826087, 0.41666666666667
50855, 0.84782608695652, 0.8804347826087, 0.44444444444444
50856, 0.82608695652174, 0.85434782608696, 0.44444444444444
50857, 0.82608695652174, 0.8804347826087, 0.47222222222222
50858, 0.78260869565217, 0.88043478260869, 0.027777777777778
50859, 0.80434782608696, 0.88043478260869, 0.055555555555556
50860, 0.78260869565217, 0.85434782608696, 0.055555555555556
50861, 0.78260869565217, 0.88043478260869, 0.083333333333333
50862, 0.80434782608696, 0.8804347826087, 0.11111111111111
50863, 0.78260869565217, 0.85434782608696, 0.11111111111111
50864, 0.78260869565217, 0.88043478260869, 0.13888888888889
50865, 0.80434782608696, 0.88043478260869, 0.16666666666667
50866, 0.78260869565217, 0.85434782608696, 0.16666666666667
50867, 0.78260869565217, 0.88043478260869, 0.19444444444444
50868, 0.80434782608696, 0.8804347826087, 0.22222222222222
50869, 0.78260869565217, 0.85434782608696, 0.22222222222222
50870, 0.78260869565217, 0.88043478260869, 0.25
50871, 0.80434782608696, 0.8804347826087, 0.27777777777778
50872, 0.78260869565217, 0.85434782608696, 0.27777777777778
50873, 0.78260869565217, 0.88043478260869, 0.30555555555556
50874, 0.80434782608696, 0.8804347826087, 0.33333333333333
50875, 0.78260869565217, 0.85434782608696, 0.33333333333333
50876, 0.78260869565217, 0.88043478260869, 0.36111111111111
50877, 0.80434782608696, 0.8804347826087, 0.38888888888889
50878, 0.78260869565217, 0.85434782608696, 0.38888888888889
50879, 0.78260869565217, 0.88043478260869, 0.41666666666667
50880, 0.80434782608696, 0.8804347826087, 0.44444444444444
50881, 0.78260869565217, 0.85434782608696, 0.44444444444444
50882, 0.78260869565217, 0.88043478260869, 0.47222222222222
50883, 0.73913043478261, 0.8804347826087, 0.027777777777778
50884, 0.76086956521739, 0.88043478260869, 0.055555555555556
50885, 0.73913043478261, 0.85434782608696, 0.055555555555556
50886, 0.73913043478261, 0.8804347826087, 0.083333333333333
50887, 0.76086956521739, 0.88043478260869, 0.11111111111111
50888, 0.73913043478261, 0.85434782608696, 0.11111111111111
50889, 0.73913043478261, 0.88043478260869, 0.13888888888889
50890, 0.76086956521739, 0.88043478260869, 0.16666666666667
50891, 0.73913043478261, 0.85434782608696, 0.16666666666667
50892, 0.73913043478261, 0.88043478260869, 0.19444444444444
50893, 0.76086956521739, 0.88043478260869, 0.22222222222222
50894, 0.73913043478261, 0.85434782608696, 0.22222222222222
50895, 0.73913043478261, 0.88043478260869, 0.25
50896, 0.76086956521739, 0.88043478260869, 0.27777777777778
50897, 0.73913043478261, 0.85434782608696, 0.27777777777778
50898, 0.73913043478261, 0.88043478260869, 0.30555555555556
50899, 0.76086956521739, 0.88043478260869, 0.33333333333333
50900, 0.73913043478261, 0.85434782608696, 0.33333333333333
50901, 0.73913043478261, 0.88043478260869, 0.36111111111111
50902, 0.76086956521739, 0.88043478260869, 0.38888888888889
50903, 0.73913043478261, 0.85434782608696, 0.38888888888889
50904, 0.73913043478261, 0.88043478260869, 0.41666666666667
50905, 0.76086956521739, 0.88043478260869, 0.44444444444444
50906, 0.73913043478261, 0.85434782608696, 0.44444444444444
50907, 0.73913043478261, 0.8804347826087, 0.47222222222222
50908, 0.69565217391304, 0.88043478260869, 0.027777777777778
50909, 0.71739130434783, 0.88043478260869, 0.055555555555556
50910, 0.69565217391304, 0.85434782608696, 0.055555555555556
50911, 0.69565217391304, 0.88043478260869, 0.083333333333333
50912, 0.71739130434783, 0.88043478260869, 0.11111111111111
50913, 0.69565217391304, 0.85434782608696, 0.11111111111111
50914, 0.69565217391304, 0.88043478260869, 0.13888888888889
50915, 0.71739130434783, 0.88043478260869, 0.16666666666667
50916, 0.69565217391304, 0.85434782608696, 0.16666666666667
50917, 0.69565217391304, 0.88043478260869, 0.19444444444444
50918, 0.71739130434783, 0.88043478260869, 0.22222222222222
50919, 0.69565217391304, 0.85434782608696, 0.22222222222222
50920, 0.69565217391304, 0.8804347826087, 0.25
50921, 0.71739130434783, 0.88043478260869, 0.27777777777778
50922, 0.69565217391304, 0.85434782608696, 0.27777777777778
50923, 0.69565217391304, 0.8804347826087, 0.30555555555556
50924, 0.71739130434783, 0.8804347826087, 0.33333333333333
50925, 0.69565217391304, 0.85434782608696, 0.33333333333333
50926, 0.69565217391304, 0.88043478260869, 0.36111111111111
50927, 0.71739130434783, 0.88043478260869, 0.38888888888889
50928, 0.69565217391304, 0.85434782608696, 0.38888888888889
50929, 0.69565217391304, 0.88043478260869, 0.41666666666667
50930, 0.71739130434783, 0.88043478260869, 0.44444444444444
50931, 0.69565217391304, 0.85434782608696, 0.44444444444444
50932, 0.69565217391304, 0.88043478260869, 0.47222222222222
50933, 0.65217391304348, 0.8804347826087, 0.027777777777778
50934, 0.67391304347826, 0.88043478260869, 0.055555555555556
50935, 0.65217391304348, 0.85434782608696, 0.055555555555556
50936, 0.65217391304348, 0.8804347826087, 0.083333333333333
50937, 0.67391304347826, 0.8804347826087, 0.11111111111111
50938, 0.65217391304348, 0.85434782608696, 0.11111111111111
50939, 0.65217391304348, 0.8804347826087, 0.13888888888889
50940, 0.67391304347826, 0.8804347826087, 0.16666666666667
50941, 0.65217391304348, 0.85434782608696, 0.16666666666667
50942, 0.65217391304348, 0.8804347826087, 0.19444444444444
50943, 0.67391304347826, 0.8804347826087, 0.22222222222222
50944, 0.65217391304348, 0.85434782608696, 0.22222222222222
50945, 0.65217391304348, 0.8804347826087, 0.25
50946, 0.67391304347826, 0.8804347826087, 0.27777777777778
50947, 0.65217391304348, 0.85434782608696, 0.27777777777778
50948, 0.65217391304348, 0.8804347826087, 0.30555555555556
50949, 0.67391304347826, 0.8804347826087, 0.33333333333333
50950, 0.65217391304348, 0.85434782608696, 0.33333333333333
50951, 0.65217391304348, 0.8804347826087, 0.36111111111111
50952, 0.67391304347826, 0.8804347826087, 0.38888888888889
50953, 0.65217391304348, 0.85434782608696, 0.38888888888889
50954, 0.65217391304348, 0.8804347826087, 0.41666666666667
50955, 0.67391304347826, 0.8804347826087, 0.44444444444444
50956, 0.65217391304348, 0.85434782608696, 0.44444444444444
50957, 0.65217391304348, 0.8804347826087, 0.47222222222222
50958, 0.60869565217391, 0.8804347826087, 0.027777777777778
50959, 0.6304347826087, 0.8804347826087, 0.055555555555556
50960, 0.60869565217391, 0.85434782608696, 0.055555555555556
50961, 0.60869565217391, 0.8804347826087, 0.083333333333333
50962, 0.6304347826087, 0.8804347826087, 0.11111111111111
50963, 0.60869565217391, 0.85434782608696, 0.11111111111111
50964, 0.60869565217391, 0.8804347826087, 0.13888888888889
50965, 0.6304347826087, 0.8804347826087, 0.16666666666667
50966, 0.60869565217391, 0.85434782608696, 0.16666666666667
50967, 0.60869565217391, 0.8804347826087, 0.19444444444444
50968, 0.6304347826087, 0.8804347826087, 0.22222222222222
50969, 0.60869565217391, 0.85434782608696, 0.22222222222222
50970, 0.60869565217391, 0.8804347826087, 0.25
50971, 0.6304347826087, 0.8804347826087, 0.27777777777778
50972, 0.60869565217391, 0.85434782608696, 0.27777777777778
50973, 0.60869565217391, 0.8804347826087, 0.30555555555556
50974, 0.6304347826087, 0.8804347826087, 0.33333333333333
50975, 0.60869565217391, 0.85434782608696, 0.33333333333333
50976, 0.60869565217391, 0.8804347826087, 0.36111111111111
50977, 0.6304347826087, 0.8804347826087, 0.38888888888889
50978, 0.60869565217391, 0.85434782608696, 0.38888888888889
50979, 0.60869565217391, 0.8804347826087, 0.41666666666667
50980, 0.6304347826087, 0.8804347826087, 0.44444444444444
50981, 0.60869565217391, 0.85434782608696, 0.44444444444444
50982, 0.60869565217391, 0.8804347826087, 0.47222222222222
50983, 0.56521739130435, 0.88043478260869, 0.027777777777778
50984, 0.58695652173913, 0.88043478260869, 0.055555555555556
50985, 0.56521739130435, 0.85434782608696, 0.055555555555556
50986, 0.56521739130435, 0.88043478260869, 0.083333333333333
50987, 0.58695652173913, 0.8804347826087, 0.11111111111111
50988, 0.56521739130435, 0.85434782608696, 0.11111111111111
50989, 0.56521739130435, 0.88043478260869, 0.13888888888889
50990, 0.58695652173913, 0.8804347826087, 0.16666666666667
50991, 0.56521739130435, 0.85434782608696, 0.16666666666667
50992, 0.56521739130435, 0.88043478260869, 0.19444444444444
50993, 0.58695652173913, 0.88043478260869, 0.22222222222222
50994, 0.56521739130435, 0.85434782608696, 0.22222222222222
50995, 0.56521739130435, 0.88043478260869, 0.25
50996, 0.58695652173913, 0.8804347826087, 0.27777777777778
50997, 0.56521739130435, 0.85434782608696, 0.27777777777778
50998, 0.56521739130435, 0.88043478260869, 0.30555555555556
50999, 0.58695652173913, 0.8804347826087, 0.33333333333333
51000, 0.56521739130435, 0.85434782608696, 0.33333333333333
51001, 0.56521739130435, 0.88043478260869, 0.36111111111111
51002, 0.58695652173913, 0.88043478260869, 0.38888888888889
51003, 0.56521739130435, 0.85434782608696, 0.38888888888889
51004, 0.56521739130435, 0.88043478260869, 0.41666666666667
51005, 0.58695652173913, 0.88043478260869, 0.44444444444444
51006, 0.56521739130435, 0.85434782608696, 0.44444444444444
51007, 0.56521739130435, 0.88043478260869, 0.47222222222222
51008, 0.52173913043478, 0.88043478260869, 0.027777777777778
51009, 0.54347826086957, 0.88043478260869, 0.055555555555556
51010, 0.52173913043478, 0.85434782608696, 0.055555555555556
51011, 0.52173913043478, 0.88043478260869, 0.083333333333333
51012, 0.54347826086957, 0.88043478260869, 0.11111111111111
51013, 0.52173913043478, 0.85434782608696, 0.11111111111111
51014, 0.52173913043478, 0.88043478260869, 0.13888888888889
51015, 0.54347826086957, 0.88043478260869, 0.16666666666667
51016, 0.52173913043478, 0.85434782608696, 0.16666666666667
51017, 0.52173913043478, 0.88043478260869, 0.19444444444444
51018, 0.54347826086956, 0.88043478260869, 0.22222222222222
51019, 0.52173913043478, 0.85434782608696, 0.22222222222222
51020, 0.52173913043478, 0.88043478260869, 0.25
51021, 0.54347826086956, 0.88043478260869, 0.27777777777778
51022, 0.52173913043478, 0.85434782608696, 0.27777777777778
51023, 0.52173913043478, 0.88043478260869, 0.30555555555556
51024, 0.54347826086956, 0.8804347826087, 0.33333333333333
51025, 0.52173913043478, 0.85434782608696, 0.33333333333333
51026, 0.52173913043478, 0.88043478260869, 0.36111111111111
51027, 0.54347826086956, 0.88043478260869, 0.38888888888889
51028, 0.52173913043478, 0.85434782608696, 0.38888888888889
51029, 0.52173913043478, 0.88043478260869, 0.41666666666667
51030, 0.54347826086956, 0.88043478260869, 0.44444444444444
51031, 0.52173913043478, 0.85434782608696, 0.44444444444444
51032, 0.52173913043478, 0.88043478260869, 0.47222222222222
51033, 0.47826086956522, 0.88043478260869, 0.027777777777778
51034, 0.5, 0.88043478260869, 0.055555555555556
51035, 0.47826086956522, 0.85434782608696, 0.055555555555556
51036, 0.47826086956522, 0.88043478260869, 0.083333333333333
51037, 0.5, 0.88043478260869, 0.11111111111111
51038, 0.47826086956522, 0.85434782608696, 0.11111111111111
51039, 0.47826086956522, 0.88043478260869, 0.13888888888889
51040, 0.5, 0.88043478260869, 0.16666666666667
51041, 0.47826086956522, 0.85434782608696, 0.16666666666667
51042, 0.47826086956522, 0.88043478260869, 0.19444444444444
51043, 0.5, 0.88043478260869, 0.22222222222222
51044, 0.47826086956522, 0.85434782608696, 0.22222222222222
51045, 0.47826086956522, 0.88043478260869, 0.25
51046, 0.5, 0.88043478260869, 0.27777777777778
51047, 0.47826086956522, 0.85434782608696, 0.27777777777778
51048, 0.47826086956522, 0.88043478260869, 0.30555555555556
51049, 0.5, 0.88043478260869, 0.33333333333333
51050, 0.47826086956522, 0.85434782608696, 0.33333333333333
51051, 0.47826086956522, 0.88043478260869, 0.36111111111111
51052, 0.5, 0.88043478260869, 0.38888888888889
51053, 0.47826086956522, 0.85434782608696, 0.38888888888889
51054, 0.47826086956522, 0.88043478260869, 0.41666666666667
51055, 0.5, 0.88043478260869, 0.44444444444444
51056, 0.47826086956522, 0.85434782608696, 0.44444444444444
51057, 0.47826086956522, 0.88043478260869, 0.47222222222222
51058, 0.43478260869565, 0.88043478260869, 0.027777777777778
51059, 0.45652173913043, 0.88043478260869, 0.055555555555556
51060, 0.43478260869565, 0.85434782608696, 0.055555555555556
51061, 0.43478260869565, 0.88043478260869, 0.083333333333333
51062, 0.45652173913043, 0.88043478260869, 0.11111111111111
51063, 0.43478260869565, 0.85434782608696, 0.11111111111111
51064, 0.43478260869565, 0.88043478260869, 0.13888888888889
51065, 0.45652173913043, 0.88043478260869, 0.16666666666667
51066, 0.43478260869565, 0.85434782608696, 0.16666666666667
51067, 0.43478260869565, 0.88043478260869, 0.19444444444444
51068, 0.45652173913043, 0.88043478260869, 0.22222222222222
51069, 0.43478260869565, 0.85434782608696, 0.22222222222222
51070, 0.43478260869565, 0.88043478260869, 0.25
51071, 0.45652173913043, 0.88043478260869, 0.27777777777778
51072, 0.43478260869565, 0.85434782608696, 0.27777777777778
51073, 0.43478260869565, 0.88043478260869, 0.30555555555556
51074, 0.45652173913043, 0.88043478260869, 0.33333333333333
51075, 0.43478260869565, 0.85434782608696, 0.33333333333333
51076, 0.43478260869565, 0.88043478260869, 0.36111111111111
51077, 0.45652173913044, 0.88043478260869, 0.38888888888889
51078, 0.43478260869565, 0.85434782608696, 0.38888888888889
51079, 0.43478260869565, 0.88043478260869, 0.41666666666667
51080, 0.45652173913043, 0.88043478260869, 0.44444444444444
51081, 0.43478260869565, 0.85434782608696, 0.44444444444444
51082, 0.43478260869565, 0.88043478260869, 0.47222222222222
51083, 0.39130434782609, 0.88043478260869, 0.027777777777778
51084, 0.41304347826087, 0.88043478260869, 0.055555555555556
51085, 0.39130434782609, 0.85434782608696, 0.055555555555556
51086, 0.39130434782609, 0.88043478260869, 0.083333333333333
51087, 0.41304347826087, 0.88043478260869, 0.11111111111111
51088, 0.39130434782609, 0.85434782608696, 0.11111111111111
51089, 0.39130434782609, 0.8804347826087, 0.13888888888889
51090, 0.41304347826087, 0.8804347826087, 0.16666666666667
51091, 0.39130434782609, 0.85434782608696, 0.16666666666667
51092, 0.39130434782609, 0.8804347826087, 0.19444444444444
51093, 0.41304347826087, 0.88043478260869, 0.22222222222222
51094, 0.39130434782609, 0.85434782608696, 0.22222222222222
51095, 0.39130434782609, 0.88043478260869, 0.25
51096, 0.41304347826087, 0.88043478260869, 0.27777777777778
51097, 0.39130434782609, 0.85434782608696, 0.27777777777778
51098, 0.39130434782609, 0.88043478260869, 0.30555555555556
51099, 0.41304347826087, 0.88043478260869, 0.33333333333333
51100, 0.39130434782609, 0.85434782608696, 0.33333333333333
51101, 0.39130434782609, 0.88043478260869, 0.36111111111111
51102, 0.41304347826087, 0.88043478260869, 0.38888888888889
51103, 0.39130434782609, 0.85434782608696, 0.38888888888889
51104, 0.39130434782609, 0.88043478260869, 0.41666666666667
51105, 0.41304347826087, 0.88043478260869, 0.44444444444444
51106, 0.39130434782609, 0.85434782608696, 0.44444444444444
51107, 0.39130434782609, 0.88043478260869, 0.47222222222222
51108, 0.34782608695652, 0.8804347826087, 0.027777777777778
51109, 0.3695652173913, 0.88043478260869, 0.055555555555556
51110, 0.34782608695652, 0.85434782608696, 0.055555555555556
51111, 0.34782608695652, 0.8804347826087, 0.083333333333333
51112, 0.3695652173913, 0.88043478260869, 0.11111111111111
51113, 0.34782608695652, 0.85434782608696, 0.11111111111111
51114, 0.34782608695652, 0.8804347826087, 0.13888888888889
51115, 0.3695652173913, 0.8804347826087, 0.16666666666667
51116, 0.34782608695652, 0.85434782608696, 0.16666666666667
51117, 0.34782608695652, 0.8804347826087, 0.19444444444444
51118, 0.3695652173913, 0.8804347826087, 0.22222222222222
51119, 0.34782608695652, 0.85434782608696, 0.22222222222222
51120, 0.34782608695652, 0.8804347826087, 0.25
51121, 0.3695652173913, 0.8804347826087, 0.27777777777778
51122, 0.34782608695652, 0.85434782608696, 0.27777777777778
51123, 0.34782608695652, 0.8804347826087, 0.30555555555556
51124, 0.3695652173913, 0.88043478260869, 0.33333333333333
51125, 0.34782608695652, 0.85434782608696, 0.33333333333333
51126, 0.34782608695652, 0.8804347826087, 0.36111111111111
51127, 0.3695652173913, 0.8804347826087, 0.38888888888889
51128, 0.34782608695652, 0.85434782608696, 0.38888888888889
51129, 0.34782608695652, 0.88043478260869, 0.41666666666667
51130, 0.3695652173913, 0.88043478260869, 0.44444444444444
51131, 0.34782608695652, 0.85434782608696, 0.44444444444444
51132, 0.34782608695652, 0.88043478260869, 0.47222222222222
51133, 0.30434782608696, 0.88043478260869, 0.027777777777778
51134, 0.32608695652174, 0.88043478260869, 0.055555555555556
51135, 0.30434782608696, 0.85434782608696, 0.055555555555556
51136, 0.30434782608696, 0.88043478260869, 0.083333333333333
51137, 0.32608695652174, 0.8804347826087, 0.11111111111111
51138, 0.30434782608696, 0.85434782608696, 0.11111111111111
51139, 0.30434782608696, 0.88043478260869, 0.13888888888889
51140, 0.32608695652174, 0.88043478260869, 0.16666666666667
51141, 0.30434782608696, 0.85434782608696, 0.16666666666667
51142, 0.30434782608696, 0.88043478260869, 0.19444444444444
51143, 0.32608695652174, 0.8804347826087, 0.22222222222222
51144, 0.30434782608696, 0.85434782608696, 0.22222222222222
51145, 0.30434782608696, 0.88043478260869, 0.25
51146, 0.32608695652174, 0.8804347826087, 0.27777777777778
51147, 0.30434782608696, 0.85434782608696, 0.27777777777778
51148, 0.30434782608696, 0.88043478260869, 0.30555555555556
51149, 0.32608695652174, 0.88043478260869, 0.33333333333333
51150, 0.30434782608696, 0.85434782608696, 0.33333333333333
51151, 0.30434782608696, 0.88043478260869, 0.36111111111111
51152, 0.32608695652174, 0.8804347826087, 0.38888888888889
51153, 0.30434782608696, 0.85434782608696, 0.38888888888889
51154, 0.30434782608696, 0.88043478260869, 0.41666666666667
51155, 0.32608695652174, 0.88043478260869, 0.44444444444444
51156, 0.30434782608696, 0.85434782608696, 0.44444444444444
51157, 0.30434782608696, 0.88043478260869, 0.47222222222222
51158, 0.26086956521739, 0.88043478260869, 0.027777777777778
51159, 0.28260869565217, 0.88043478260869, 0.055555555555556
51160, 0.26086956521739, 0.85434782608696, 0.055555555555556
51161, 0.26086956521739, 0.88043478260869, 0.083333333333333
51162, 0.28260869565217, 0.88043478260869, 0.11111111111111
51163, 0.26086956521739, 0.85434782608696, 0.11111111111111
51164, 0.26086956521739, 0.88043478260869, 0.13888888888889
51165, 0.28260869565217, 0.88043478260869, 0.16666666666667
51166, 0.26086956521739, 0.85434782608696, 0.16666666666667
51167, 0.26086956521739, 0.88043478260869, 0.19444444444444
51168, 0.28260869565217, 0.88043478260869, 0.22222222222222
51169, 0.26086956521739, 0.85434782608696, 0.22222222222222
51170, 0.26086956521739, 0.88043478260869, 0.25
51171, 0.28260869565217, 0.88043478260869, 0.27777777777778
51172, 0.26086956521739, 0.85434782608696, 0.27777777777778
51173, 0.26086956521739, 0.88043478260869, 0.30555555555556
51174, 0.28260869565217, 0.8804347826087, 0.33333333333333
51175, 0.26086956521739, 0.85434782608696, 0.33333333333333
51176, 0.26086956521739, 0.88043478260869, 0.36111111111111
51177, 0.28260869565217, 0.88043478260869, 0.38888888888889
51178, 0.26086956521739, 0.85434782608696, 0.38888888888889
51179, 0.26086956521739, 0.88043478260869, 0.41666666666667
51180, 0.28260869565217, 0.88043478260869, 0.44444444444444
51181, 0.26086956521739, 0.85434782608696, 0.44444444444444
51182, 0.26086956521739, 0.88043478260869, 0.47222222222222
51183, 0.21739130434783, 0.88043478260869, 0.027777777777778
51184, 0.23913043478261, 0.88043478260869, 0.055555555555556
51185, 0.21739130434783, 0.85434782608696, 0.055555555555556
51186, 0.21739130434783, 0.88043478260869, 0.083333333333333
51187, 0.23913043478261, 0.88043478260869, 0.11111111111111
51188, 0.21739130434783, 0.85434782608696, 0.11111111111111
51189, 0.21739130434783, 0.88043478260869, 0.13888888888889
51190, 0.23913043478261, 0.88043478260869, 0.16666666666667
51191, 0.21739130434783, 0.85434782608696, 0.16666666666667
51192, 0.21739130434783, 0.88043478260869, 0.19444444444444
51193, 0.23913043478261, 0.88043478260869, 0.22222222222222
51194, 0.21739130434783, 0.85434782608696, 0.22222222222222
51195, 0.21739130434783, 0.88043478260869, 0.25
51196, 0.23913043478261, 0.88043478260869, 0.27777777777778
51197, 0.21739130434783, 0.85434782608696, 0.27777777777778
51198, 0.21739130434783, 0.88043478260869, 0.30555555555556
51199, 0.23913043478261, 0.88043478260869, 0.33333333333333
51200, 0.21739130434783, 0.85434782608696, 0.33333333333333
51201, 0.21739130434783, 0.88043478260869, 0.36111111111111
51202, 0.23913043478261, 0.88043478260869, 0.38888888888889
51203, 0.21739130434783, 0.85434782608696, 0.38888888888889
51204, 0.21739130434783, 0.88043478260869, 0.41666666666667
51205, 0.23913043478261, 0.88043478260869, 0.44444444444444
51206, 0.21739130434783, 0.85434782608696, 0.44444444444444
51207, 0.21739130434783, 0.88043478260869, 0.47222222222222
51208, 0.17391304347826, 0.8804347826087, 0.027777777777778
51209, 0.19565217391304, 0.88043478260869, 0.055555555555556
51210, 0.17391304347826, 0.85434782608696, 0.055555555555556
51211, 0.17391304347826, 0.88043478260869, 0.083333333333333
51212, 0.19565217391304, 0.88043478260869, 0.11111111111111
51213, 0.17391304347826, 0.85434782608696, 0.11111111111111
51214, 0.17391304347826, 0.88043478260869, 0.13888888888889
51215, 0.19565217391304, 0.88043478260869, 0.16666666666667
51216, 0.17391304347826, 0.85434782608696, 0.16666666666667
51217, 0.17391304347826, 0.88043478260869, 0.19444444444444
51218, 0.19565217391304, 0.88043478260869, 0.22222222222222
51219, 0.17391304347826, 0.85434782608696, 0.22222222222222
51220, 0.17391304347826, 0.88043478260869, 0.25
51221, 0.19565217391304, 0.88043478260869, 0.27777777777778
51222, 0.17391304347826, 0.85434782608696, 0.27777777777778
51223, 0.17391304347826, 0.88043478260869, 0.30555555555556
51224, 0.19565217391304, 0.88043478260869, 0.33333333333333
51225, 0.17391304347826, 0.85434782608696, 0.33333333333333
51226, 0.17391304347826, 0.88043478260869, 0.36111111111111
51227, 0.19565217391304, 0.88043478260869, 0.38888888888889
51228, 0.17391304347826, 0.85434782608696, 0.38888888888889
51229, 0.17391304347826, 0.88043478260869, 0.41666666666667
51230, 0.19565217391304, 0.88043478260869, 0.44444444444444
51231, 0.17391304347826, 0.85434782608696, 0.44444444444444
51232, 0.17391304347826, 0.88043478260869, 0.47222222222222
51233, 0.1304347826087, 0.8804347826087, 0.027777777777778
51234, 0.15217391304348, 0.8804347826087, 0.055555555555556
51235, 0.1304347826087, 0.85434782608696, 0.055555555555556
51236, 0.1304347826087, 0.88043478260869, 0.083333333333333
51237, 0.15217391304348, 0.88043478260869, 0.11111111111111
51238, 0.1304347826087, 0.85434782608696, 0.11111111111111
51239, 0.1304347826087, 0.88043478260869, 0.13888888888889
51240, 0.15217391304348, 0.8804347826087, 0.16666666666667
51241, 0.1304347826087, 0.85434782608696, 0.16666666666667
51242, 0.1304347826087, 0.88043478260869, 0.19444444444444
51243, 0.15217391304348, 0.88043478260869, 0.22222222222222
51244, 0.1304347826087, 0.85434782608696, 0.22222222222222
51245, 0.1304347826087, 0.88043478260869, 0.25
51246, 0.15217391304348, 0.88043478260869, 0.27777777777778
51247, 0.1304347826087, 0.85434782608696, 0.27777777777778
51248, 0.1304347826087, 0.88043478260869, 0.30555555555556
51249, 0.15217391304348, 0.88043478260869, 0.33333333333333
51250, 0.1304347826087, 0.85434782608696, 0.33333333333333
51251, 0.1304347826087, 0.88043478260869, 0.36111111111111
51252, 0.15217391304348, 0.88043478260869, 0.38888888888889
51253, 0.1304347826087, 0.85434782608696, 0.38888888888889
51254, 0.1304347826087, 0.88043478260869, 0.41666666666667
51255, 0.15217391304348, 0.88043478260869, 0.44444444444444
51256, 0.1304347826087, 0.85434782608696, 0.44444444444444
51257, 0.1304347826087, 0.88043478260869, 0.47222222222222
51258, 0.08695652173913, 0.8804347826087, 0.027777777777778
51259, 0.10869565217391, 0.8804347826087, 0.055555555555556
51260, 0.08695652173913, 0.85434782608696, 0.055555555555556
51261, 0.08695652173913, 0.8804347826087, 0.083333333333333
51262, 0.10869565217391, 0.88043478260869, 0.11111111111111
51263, 0.08695652173913, 0.85434782608696, 0.11111111111111
51264, 0.08695652173913, 0.8804347826087, 0.13888888888889
51265, 0.10869565217391, 0.8804347826087, 0.16666666666667
51266, 0.08695652173913, 0.85434782608696, 0.16666666666667
51267, 0.08695652173913, 0.8804347826087, 0.19444444444444
51268, 0.10869565217391, 0.88043478260869, 0.22222222222222
51269, 0.08695652173913, 0.85434782608696, 0.22222222222222
51270, 0.08695652173913, 0.8804347826087, 0.25
51271, 0.10869565217391, 0.88043478260869, 0.27777777777778
51272, 0.08695652173913, 0.85434782608696, 0.27777777777778
51273, 0.08695652173913, 0.8804347826087, 0.30555555555556
51274, 0.10869565217391, 0.8804347826087, 0.33333333333333
51275, 0.08695652173913, 0.85434782608696, 0.33333333333333
51276, 0.08695652173913, 0.8804347826087, 0.36111111111111
51277, 0.10869565217391, 0.88043478260869, 0.38888888888889
51278, 0.08695652173913, 0.85434782608696, 0.38888888888889
51279, 0.08695652173913, 0.8804347826087, 0.41666666666667
51280, 0.10869565217391, 0.88043478260869, 0.44444444444444
51281, 0.08695652173913, 0.85434782608696, 0.44444444444444
51282, 0.08695652173913, 0.8804347826087, 0.47222222222222
51283, 0.043478260869565, 0.88043478260869, 0.027777777777778
51284, 0.065217391304348, 0.8804347826087, 0.055555555555556
51285, 0.043478260869565, 0.85434782608696, 0.055555555555556
51286, 0.043478260869565, 0.88043478260869, 0.083333333333333
51287, 0.065217391304348, 0.88043478260869, 0.11111111111111
