31238, 1.075, 0.77608695652174, 0.44444444444444
31239, 1.075, 0.77608695652174, 0.38888888888889
31240, 1.075, 0.77608695652174, 0.33333333333333
31241, 1.075, 0.77608695652174, 0.27777777777778
31242, 1.075, 0.77608695652174, 0.22222222222222
31243, 1.075, 0.77608695652174, 0.16666666666667
31244, 1.075, 0.77608695652174, 0.11111111111111
31245, 1.075, 0.77608695652174, 0.055555555555556
31246, 1.075, 0.82826086956522, 0.44444444444444
31247, 1.075, 0.82826086956522, 0.38888888888889
31248, 1.075, 0.82826086956522, 0.33333333333333
31249, 1.075, 0.82826086956522, 0.27777777777778
31250, 1.075, 0.82826086956522, 0.22222222222222
31251, 1.075, 0.82826086956522, 0.16666666666667
31252, 1.075, 0.82826086956522, 0.11111111111111
31253, 1.075, 0.82826086956522, 0.055555555555556
31254, 1.075, 0.88043478260869, 0.44444444444444
31255, 1.075, 0.8804347826087, 0.38888888888889
31256, 1.075, 0.8804347826087, 0.33333333333333
31257, 1.075, 0.8804347826087, 0.27777777777778
31258, 1.075, 0.8804347826087, 0.22222222222222
31259, 1.075, 0.8804347826087, 0.16666666666667
31260, 1.075, 0.8804347826087, 0.11111111111111
31261, 1.075, 0.8804347826087, 0.055555555555556
31262, 1.075, 0.93260869565217, 0.44444444444444
31263, 1.075, 0.93260869565217, 0.38888888888889
31264, 1.075, 0.93260869565217, 0.33333333333333
31265, 1.075, 0.93260869565217, 0.27777777777778
31266, 1.075, 0.93260869565217, 0.22222222222222
31267, 1.075, 0.93260869565217, 0.16666666666667
31268, 1.075, 0.93260869565217, 0.11111111111111
31269, 1.075, 0.93260869565217, 0.055555555555556
31270, 1.075, 0.98478260869565, 0.44444444444444
31271, 1.075, 0.98478260869565, 0.38888888888889
31272, 1.075, 0.98478260869565, 0.33333333333333
31273, 1.075, 0.98478260869565, 0.27777777777778
31274, 1.075, 0.98478260869565, 0.22222222222222
31275, 1.075, 0.98478260869565, 0.16666666666667
31276, 1.075, 0.98478260869565, 0.11111111111111
31277, 1.075, 0.98478260869565, 0.055555555555556
31278, 1.075, 1.0369565217391, 0.44444444444444
31279, 1.075, 1.0369565217391, 0.38888888888889
31280, 1.075, 1.0369565217391, 0.33333333333333
31281, 1.075, 1.0369565217391, 0.27777777777778
31282, 1.075, 1.0369565217391, 0.22222222222222
31283, 1.075, 1.0369565217391, 0.16666666666667
31284, 1.075, 1.0369565217391, 0.11111111111111
31285, 1.075, 1.0369565217391, 0.055555555555556
31286, 1.075, 1.0891304347826, 0.44444444444444
31287, 1.075, 1.0891304347826, 0.38888888888889
31288, 1.075, 1.0891304347826, 0.33333333333333
31289, 1.075, 1.0891304347826, 0.27777777777778
31290, 1.075, 1.0891304347826, 0.22222222222222
31291, 1.075, 1.0891304347826, 0.16666666666667
31292, 1.075, 1.0891304347826, 0.11111111111111
31293, 1.075, 1.0891304347826, 0.055555555555556
31294, 1.075, 1.1413043478261, 0.44444444444444
31295, 1.075, 1.1413043478261, 0.38888888888889
31296, 1.075, 1.1413043478261, 0.33333333333333
31297, 1.075, 1.1413043478261, 0.27777777777778
31298, 1.075, 1.1413043478261, 0.22222222222222
31299, 1.075, 1.1413043478261, 0.16666666666667
31300, 1.075, 1.1413043478261, 0.11111111111111
31301, 1.075, 1.1413043478261, 0.055555555555556
31302, 1.075, 1.1934782608696, 0.44444444444444
31303, 1.075, 1.1934782608696, 0.38888888888889
31304, 1.075, 1.1934782608696, 0.33333333333333
31305, 1.075, 1.1934782608696, 0.27777777777778
31306, 1.075, 1.1934782608696, 0.22222222222222
31307, 1.075, 1.1934782608696, 0.16666666666667
31308, 1.075, 1.1934782608696, 0.11111111111111
31309, 1.075, 1.1934782608696, 0.055555555555556
31310, 1.075, 1.245652173913, 0.44444444444444
31311, 1.075, 1.245652173913, 0.38888888888889
31312, 1.075, 1.245652173913, 0.33333333333333
31313, 1.075, 1.245652173913, 0.27777777777778
31314, 1.075, 1.245652173913, 0.22222222222222
31315, 1.075, 1.245652173913, 0.16666666666667
31316, 1.075, 1.245652173913, 0.11111111111111
31317, 1.075, 1.245652173913, 0.055555555555556
31318, 1.075, 1.2978260869565, 0.44444444444444
31319, 1.075, 1.2978260869565, 0.38888888888889
31320, 1.075, 1.2978260869565, 0.33333333333333
31321, 1.075, 1.2978260869565, 0.27777777777778
31322, 1.075, 1.2978260869565, 0.22222222222222
31323, 1.075, 1.2978260869565, 0.16666666666667
31324, 1.075, 1.2978260869565, 0.11111111111111
31325, 1.075, 1.2978260869565, 0.055555555555556
31326, 1.075, 0.17608695652174, 0.44444444444444
31327, 1.075, 0.20217391304348, 0.47222222222222
31328, 1.075, 0.17608695652174, 0.38888888888889
31329, 1.075, 0.20217391304348, 0.41666666666667
31330, 1.075, 0.17608695652174, 0.33333333333333
31331, 1.075, 0.20217391304348, 0.36111111111111
31332, 1.075, 0.17608695652174, 0.27777777777778
31333, 1.075, 0.20217391304348, 0.30555555555556
31334, 1.075, 0.17608695652174, 0.22222222222222
31335, 1.075, 0.20217391304348, 0.25
31336, 1.075, 0.17608695652174, 0.16666666666667
31337, 1.075, 0.20217391304348, 0.19444444444444
31338, 1.075, 0.17608695652174, 0.11111111111111
31339, 1.075, 0.20217391304348, 0.13888888888889
31340, 1.075, 0.17608695652174, 0.055555555555556
31341, 1.075, 0.20217391304348, 0.083333333333333
31342, 1.075, 0.20217391304348, 0.027777777777778
31343, 1.075, 0.22826086956522, 0.44444444444444
31344, 1.075, 0.25434782608696, 0.47222222222222
31345, 1.075, 0.22826086956522, 0.38888888888889
31346, 1.075, 0.25434782608696, 0.41666666666667
31347, 1.075, 0.22826086956522, 0.33333333333333
31348, 1.075, 0.25434782608696, 0.36111111111111
31349, 1.075, 0.22826086956522, 0.27777777777778
31350, 1.075, 0.25434782608696, 0.30555555555556
31351, 1.075, 0.22826086956522, 0.22222222222222
31352, 1.075, 0.25434782608696, 0.25
31353, 1.075, 0.22826086956522, 0.16666666666667
31354, 1.075, 0.25434782608696, 0.19444444444444
31355, 1.075, 0.22826086956522, 0.11111111111111
31356, 1.075, 0.25434782608696, 0.13888888888889
31357, 1.075, 0.22826086956522, 0.055555555555556
31358, 1.075, 0.25434782608696, 0.083333333333333
31359, 1.075, 0.25434782608696, 0.027777777777778
31360, 1.075, 0.2804347826087, 0.44444444444444
31361, 1.075, 0.30652173913043, 0.47222222222222
31362, 1.075, 0.2804347826087, 0.38888888888889
31363, 1.075, 0.30652173913043, 0.41666666666667
31364, 1.075, 0.2804347826087, 0.33333333333333
31365, 1.075, 0.30652173913043, 0.36111111111111
31366, 1.075, 0.2804347826087, 0.27777777777778
31367, 1.075, 0.30652173913043, 0.30555555555556
31368, 1.075, 0.2804347826087, 0.22222222222222
31369, 1.075, 0.30652173913043, 0.25
31370, 1.075, 0.2804347826087, 0.16666666666667
31371, 1.075, 0.30652173913043, 0.19444444444444
31372, 1.075, 0.2804347826087, 0.11111111111111
31373, 1.075, 0.30652173913043, 0.13888888888889
31374, 1.075, 0.2804347826087, 0.055555555555556
31375, 1.075, 0.30652173913043, 0.083333333333333
31376, 1.075, 0.30652173913043, 0.027777777777778
31377, 1.075, 0.33260869565217, 0.44444444444444
31378, 1.075, 0.35869565217391, 0.47222222222222
31379, 1.075, 0.33260869565217, 0.38888888888889
31380, 1.075, 0.35869565217391, 0.41666666666667
31381, 1.075, 0.33260869565217, 0.33333333333333
31382, 1.075, 0.35869565217391, 0.36111111111111
31383, 1.075, 0.33260869565217, 0.27777777777778
31384, 1.075, 0.35869565217391, 0.30555555555556
31385, 1.075, 0.33260869565217, 0.22222222222222
31386, 1.075, 0.35869565217391, 0.25
31387, 1.075, 0.33260869565217, 0.16666666666667
31388, 1.075, 0.35869565217391, 0.19444444444444
31389, 1.075, 0.33260869565217, 0.11111111111111
31390, 1.075, 0.35869565217391, 0.13888888888889
31391, 1.075, 0.33260869565217, 0.055555555555556
31392, 1.075, 0.35869565217391, 0.083333333333333
31393, 1.075, 0.35869565217391, 0.027777777777778
31394, 1.075, 0.38478260869565, 0.44444444444444
31395, 1.075, 0.41086956521739, 0.47222222222222
31396, 1.075, 0.38478260869565, 0.38888888888889
31397, 1.075, 0.41086956521739, 0.41666666666667
31398, 1.075, 0.38478260869565, 0.33333333333333
31399, 1.075, 0.41086956521739, 0.36111111111111
31400, 1.075, 0.38478260869565, 0.27777777777778
31401, 1.075, 0.41086956521739, 0.30555555555556
31402, 1.075, 0.38478260869565, 0.22222222222222
31403, 1.075, 0.41086956521739, 0.25
31404, 1.075, 0.38478260869565, 0.16666666666667
31405, 1.075, 0.41086956521739, 0.19444444444444
31406, 1.075, 0.38478260869565, 0.11111111111111
31407, 1.075, 0.41086956521739, 0.13888888888889
31408, 1.075, 0.38478260869565, 0.055555555555556
31409, 1.075, 0.41086956521739, 0.083333333333333
31410, 1.075, 0.41086956521739, 0.027777777777778
31411, 1.075, 0.43695652173913, 0.44444444444444
31412, 1.075, 0.46304347826087, 0.47222222222222
31413, 1.075, 0.43695652173913, 0.38888888888889
31414, 1.075, 0.46304347826087, 0.41666666666667
31415, 1.075, 0.43695652173913, 0.33333333333333
31416, 1.075, 0.46304347826087, 0.36111111111111
31417, 1.075, 0.43695652173913, 0.27777777777778
31418, 1.075, 0.46304347826087, 0.30555555555556
31419, 1.075, 0.43695652173913, 0.22222222222222
31420, 1.075, 0.46304347826087, 0.25
31421, 1.075, 0.43695652173913, 0.16666666666667
31422, 1.075, 0.46304347826087, 0.19444444444444
31423, 1.075, 0.43695652173913, 0.11111111111111
31424, 1.075, 0.46304347826087, 0.13888888888889
31425, 1.075, 0.43695652173913, 0.055555555555556
31426, 1.075, 0.46304347826087, 0.083333333333333
31427, 1.075, 0.46304347826087, 0.027777777777778
31428, 1.075, 0.48913043478261, 0.44444444444444
31429, 1.075, 0.51521739130435, 0.47222222222222
31430, 1.075, 0.48913043478261, 0.38888888888889
31431, 1.075, 0.51521739130435, 0.41666666666667
31432, 1.075, 0.48913043478261, 0.33333333333333
31433, 1.075, 0.51521739130435, 0.36111111111111
31434, 1.075, 0.48913043478261, 0.27777777777778
31435, 1.075, 0.51521739130435, 0.30555555555556
31436, 1.075, 0.48913043478261, 0.22222222222222
31437, 1.075, 0.51521739130435, 0.25
31438, 1.075, 0.48913043478261, 0.16666666666667
31439, 1.075, 0.51521739130435, 0.19444444444444
31440, 1.075, 0.48913043478261, 0.11111111111111
31441, 1.075, 0.51521739130435, 0.13888888888889
31442, 1.075, 0.48913043478261, 0.055555555555556
31443, 1.075, 0.51521739130435, 0.083333333333333
31444, 1.075, 0.51521739130435, 0.027777777777778
31445, 1.075, 0.54130434782609, 0.44444444444444
31446, 1.075, 0.56739130434783, 0.47222222222222
31447, 1.075, 0.54130434782609, 0.38888888888889
31448, 1.075, 0.56739130434783, 0.41666666666667
31449, 1.075, 0.54130434782609, 0.33333333333333
31450, 1.075, 0.56739130434783, 0.36111111111111
31451, 1.075, 0.54130434782609, 0.27777777777778
31452, 1.075, 0.56739130434783, 0.30555555555556
31453, 1.075, 0.54130434782609, 0.22222222222222
31454, 1.075, 0.56739130434783, 0.25
31455, 1.075, 0.54130434782609, 0.16666666666667
31456, 1.075, 0.56739130434783, 0.19444444444444
31457, 1.075, 0.54130434782609, 0.11111111111111
31458, 1.075, 0.56739130434783, 0.13888888888889
31459, 1.075, 0.54130434782609, 0.055555555555556
31460, 1.075, 0.56739130434783, 0.083333333333333
31461, 1.075, 0.56739130434783, 0.027777777777778
31462, 1.075, 0.59347826086956, 0.44444444444444
31463, 1.075, 0.6195652173913, 0.47222222222222
31464, 1.075, 0.59347826086956, 0.38888888888889
31465, 1.075, 0.6195652173913, 0.41666666666667
31466, 1.075, 0.59347826086956, 0.33333333333333
31467, 1.075, 0.6195652173913, 0.36111111111111
31468, 1.075, 0.59347826086956, 0.27777777777778
31469, 1.075, 0.6195652173913, 0.30555555555556
31470, 1.075, 0.59347826086956, 0.22222222222222
31471, 1.075, 0.6195652173913, 0.25
31472, 1.075, 0.59347826086956, 0.16666666666667
31473, 1.075, 0.6195652173913, 0.19444444444444
31474, 1.075, 0.59347826086956, 0.11111111111111
31475, 1.075, 0.6195652173913, 0.13888888888889
31476, 1.075, 0.59347826086956, 0.055555555555556
31477, 1.075, 0.6195652173913, 0.083333333333333
31478, 1.075, 0.6195652173913, 0.027777777777778
31479, 1.075, 0.64565217391304, 0.44444444444444
31480, 1.075, 0.67173913043478, 0.47222222222222
31481, 1.075, 0.64565217391304, 0.38888888888889
31482, 1.075, 0.67173913043478, 0.41666666666667
31483, 1.075, 0.64565217391304, 0.33333333333333
31484, 1.075, 0.67173913043478, 0.36111111111111
31485, 1.075, 0.64565217391304, 0.27777777777778
31486, 1.075, 0.67173913043478, 0.30555555555556
31487, 1.075, 0.64565217391304, 0.22222222222222
31488, 1.075, 0.67173913043478, 0.25
31489, 1.075, 0.64565217391304, 0.16666666666667
31490, 1.075, 0.67173913043478, 0.19444444444444
31491, 1.075, 0.64565217391304, 0.11111111111111
31492, 1.075, 0.67173913043478, 0.13888888888889
31493, 1.075, 0.64565217391304, 0.055555555555556
31494, 1.075, 0.67173913043478, 0.083333333333333
31495, 1.075, 0.67173913043478, 0.027777777777778
31496, 1.075, 0.69782608695652, 0.44444444444444
31497, 1.075, 0.72391304347826, 0.47222222222222
31498, 1.075, 0.69782608695652, 0.38888888888889
31499, 1.075, 0.72391304347826, 0.41666666666667
31500, 1.075, 0.69782608695652, 0.33333333333333
31501, 1.075, 0.72391304347826, 0.36111111111111
31502, 1.075, 0.69782608695652, 0.27777777777778
31503, 1.075, 0.72391304347826, 0.30555555555556
31504, 1.075, 0.69782608695652, 0.22222222222222
31505, 1.075, 0.72391304347826, 0.25
31506, 1.075, 0.69782608695652, 0.16666666666667
31507, 1.075, 0.72391304347826, 0.19444444444444
31508, 1.075, 0.69782608695652, 0.11111111111111
31509, 1.075, 0.72391304347826, 0.13888888888889
31510, 1.075, 0.69782608695652, 0.055555555555556
31511, 1.075, 0.72391304347826, 0.083333333333333
31512, 1.075, 0.72391304347826, 0.027777777777778
31513, 1.075, 0.75, 0.44444444444444
31514, 1.075, 0.77608695652174, 0.47222222222222
31515, 1.075, 0.75, 0.38888888888889
31516, 1.075, 0.77608695652174, 0.41666666666667
31517, 1.075, 0.75, 0.33333333333333
31518, 1.075, 0.77608695652174, 0.36111111111111
31519, 1.075, 0.75, 0.27777777777778
31520, 1.075, 0.77608695652174, 0.30555555555556
31521, 1.075, 0.75, 0.22222222222222
31522, 1.075, 0.77608695652174, 0.25
31523, 1.075, 0.75, 0.16666666666667
31524, 1.075, 0.77608695652174, 0.19444444444444
31525, 1.075, 0.75, 0.11111111111111
31526, 1.075, 0.77608695652174, 0.13888888888889
31527, 1.075, 0.75, 0.055555555555556
31528, 1.075, 0.77608695652174, 0.083333333333333
31529, 1.075, 0.77608695652174, 0.027777777777778
31530, 1.075, 0.80217391304348, 0.44444444444444
31531, 1.075, 0.82826086956522, 0.47222222222222
31532, 1.075, 0.80217391304348, 0.38888888888889
31533, 1.075, 0.82826086956522, 0.41666666666667
31534, 1.075, 0.80217391304348, 0.33333333333333
31535, 1.075, 0.82826086956522, 0.36111111111111
31536, 1.075, 0.80217391304348, 0.27777777777778
31537, 1.075, 0.82826086956522, 0.30555555555556
31538, 1.075, 0.80217391304348, 0.22222222222222
31539, 1.075, 0.82826086956522, 0.25
31540, 1.075, 0.80217391304348, 0.16666666666667
31541, 1.075, 0.82826086956522, 0.19444444444444
31542, 1.075, 0.80217391304348, 0.11111111111111
31543, 1.075, 0.82826086956522, 0.13888888888889
31544, 1.075, 0.80217391304348, 0.055555555555556
31545, 1.075, 0.82826086956522, 0.083333333333333
31546, 1.075, 0.82826086956522, 0.027777777777778
31547, 1.075, 0.85434782608696, 0.44444444444444
31548, 1.075, 0.88043478260869, 0.47222222222222
31549, 1.075, 0.85434782608696, 0.38888888888889
31550, 1.075, 0.88043478260869, 0.41666666666667
31551, 1.075, 0.85434782608696, 0.33333333333333
31552, 1.075, 0.8804347826087, 0.36111111111111
31553, 1.075, 0.85434782608696, 0.27777777777778
31554, 1.075, 0.8804347826087, 0.30555555555556
31555, 1.075, 0.85434782608696, 0.22222222222222
31556, 1.075, 0.8804347826087, 0.25
31557, 1.075, 0.85434782608696, 0.16666666666667
31558, 1.075, 0.8804347826087, 0.19444444444444
31559, 1.075, 0.85434782608696, 0.11111111111111
31560, 1.075, 0.8804347826087, 0.13888888888889
31561, 1.075, 0.85434782608696, 0.055555555555556
31562, 1.075, 0.8804347826087, 0.083333333333333
31563, 1.075, 0.8804347826087, 0.027777777777778
31564, 1.075, 0.90652173913043, 0.44444444444444
31565, 1.075, 0.93260869565217, 0.47222222222222
31566, 1.075, 0.90652173913043, 0.38888888888889
31567, 1.075, 0.93260869565217, 0.41666666666667
31568, 1.075, 0.90652173913043, 0.33333333333333
31569, 1.075, 0.93260869565217, 0.36111111111111
31570, 1.075, 0.90652173913043, 0.27777777777778
31571, 1.075, 0.93260869565217, 0.30555555555556
31572, 1.075, 0.90652173913043, 0.22222222222222
31573, 1.075, 0.93260869565217, 0.25
31574, 1.075, 0.90652173913043, 0.16666666666667
31575, 1.075, 0.93260869565217, 0.19444444444444
31576, 1.075, 0.90652173913043, 0.11111111111111
31577, 1.075, 0.93260869565217, 0.13888888888889
31578, 1.075, 0.90652173913043, 0.055555555555556
31579, 1.075, 0.93260869565217, 0.083333333333333
31580, 1.075, 0.93260869565217, 0.027777777777778
31581, 1.075, 0.95869565217391, 0.44444444444444
31582, 1.075, 0.98478260869565, 0.47222222222222
31583, 1.075, 0.95869565217391, 0.38888888888889
31584, 1.075, 0.98478260869565, 0.41666666666667
31585, 1.075, 0.95869565217391, 0.33333333333333
31586, 1.075, 0.98478260869565, 0.36111111111111
31587, 1.075, 0.95869565217391, 0.27777777777778
31588, 1.075, 0.98478260869565, 0.30555555555556
31589, 1.075, 0.95869565217391, 0.22222222222222
31590, 1.075, 0.98478260869565, 0.25
31591, 1.075, 0.95869565217391, 0.16666666666667
31592, 1.075, 0.98478260869565, 0.19444444444444
31593, 1.075, 0.95869565217391, 0.11111111111111
31594, 1.075, 0.98478260869565, 0.13888888888889
31595, 1.075, 0.95869565217391, 0.055555555555556
31596, 1.075, 0.98478260869565, 0.083333333333333
31597, 1.075, 0.98478260869565, 0.027777777777778
31598, 1.075, 1.0108695652174, 0.44444444444444
31599, 1.075, 1.0369565217391, 0.47222222222222
31600, 1.075, 1.0108695652174, 0.38888888888889
31601, 1.075, 1.0369565217391, 0.41666666666667
31602, 1.075, 1.0108695652174, 0.33333333333333
31603, 1.075, 1.0369565217391, 0.36111111111111
31604, 1.075, 1.0108695652174, 0.27777777777778
31605, 1.075, 1.0369565217391, 0.30555555555556
31606, 1.075, 1.0108695652174, 0.22222222222222
31607, 1.075, 1.0369565217391, 0.25
31608, 1.075, 1.0108695652174, 0.16666666666667
31609, 1.075, 1.0369565217391, 0.19444444444444
31610, 1.075, 1.0108695652174, 0.11111111111111
31611, 1.075, 1.0369565217391, 0.13888888888889
31612, 1.075, 1.0108695652174, 0.055555555555556
31613, 1.075, 1.0369565217391, 0.083333333333333
31614, 1.075, 1.0369565217391, 0.027777777777778
31615, 1.075, 1.0630434782609, 0.44444444444444
31616, 1.075, 1.0891304347826, 0.47222222222222
31617, 1.075, 1.0630434782609, 0.38888888888889
31618, 1.075, 1.0891304347826, 0.41666666666667
31619, 1.075, 1.0630434782609, 0.33333333333333
31620, 1.075, 1.0891304347826, 0.36111111111111
31621, 1.075, 1.0630434782609, 0.27777777777778
31622, 1.075, 1.0891304347826, 0.30555555555556
31623, 1.075, 1.0630434782609, 0.22222222222222
31624, 1.075, 1.0891304347826, 0.25
31625, 1.075, 1.0630434782609, 0.16666666666667
31626, 1.075, 1.0891304347826, 0.19444444444444
31627, 1.075, 1.0630434782609, 0.11111111111111
31628, 1.075, 1.0891304347826, 0.13888888888889
31629, 1.075, 1.0630434782609, 0.055555555555556
31630, 1.075, 1.0891304347826, 0.083333333333333
31631, 1.075, 1.0891304347826, 0.027777777777778
31632, 1.075, 1.1152173913043, 0.44444444444444
31633, 1.075, 1.1413043478261, 0.47222222222222
31634, 1.075, 1.1152173913043, 0.38888888888889
31635, 1.075, 1.1413043478261, 0.41666666666667
31636, 1.075, 1.1152173913043, 0.33333333333333
31637, 1.075, 1.1413043478261, 0.36111111111111
31638, 1.075, 1.1152173913043, 0.27777777777778
31639, 1.075, 1.1413043478261, 0.30555555555556
31640, 1.075, 1.1152173913043, 0.22222222222222
31641, 1.075, 1.1413043478261, 0.25
31642, 1.075, 1.1152173913043, 0.16666666666667
31643, 1.075, 1.1413043478261, 0.19444444444444
31644, 1.075, 1.1152173913043, 0.11111111111111
31645, 1.075, 1.1413043478261, 0.13888888888889
31646, 1.075, 1.1152173913043, 0.055555555555556
31647, 1.075, 1.1413043478261, 0.083333333333333
31648, 1.075, 1.1413043478261, 0.027777777777778
31649, 1.075, 1.1673913043478, 0.44444444444444
31650, 1.075, 1.1934782608696, 0.47222222222222
31651, 1.075, 1.1673913043478, 0.38888888888889
31652, 1.075, 1.1934782608696, 0.41666666666667
31653, 1.075, 1.1673913043478, 0.33333333333333
31654, 1.075, 1.1934782608696, 0.36111111111111
31655, 1.075, 1.1673913043478, 0.27777777777778
31656, 1.075, 1.1934782608696, 0.30555555555556
31657, 1.075, 1.1673913043478, 0.22222222222222
31658, 1.075, 1.1934782608696, 0.25
31659, 1.075, 1.1673913043478, 0.16666666666667
31660, 1.075, 1.1934782608696, 0.19444444444444
31661, 1.075, 1.1673913043478, 0.11111111111111
31662, 1.075, 1.1934782608696, 0.13888888888889
31663, 1.075, 1.1673913043478, 0.055555555555556
31664, 1.075, 1.1934782608696, 0.083333333333333
31665, 1.075, 1.1934782608696, 0.027777777777778
31666, 1.075, 1.2195652173913, 0.44444444444444
31667, 1.075, 1.245652173913, 0.47222222222222
31668, 1.075, 1.2195652173913, 0.38888888888889
31669, 1.075, 1.245652173913, 0.41666666666667
31670, 1.075, 1.2195652173913, 0.33333333333333
31671, 1.075, 1.245652173913, 0.36111111111111
31672, 1.075, 1.2195652173913, 0.27777777777778
31673, 1.075, 1.245652173913, 0.30555555555556
31674, 1.075, 1.2195652173913, 0.22222222222222
31675, 1.075, 1.245652173913, 0.25
31676, 1.075, 1.2195652173913, 0.16666666666667
31677, 1.075, 1.245652173913, 0.19444444444444
31678, 1.075, 1.2195652173913, 0.11111111111111
31679, 1.075, 1.245652173913, 0.13888888888889
31680, 1.075, 1.2195652173913, 0.055555555555556
31681, 1.075, 1.245652173913, 0.083333333333333
31682, 1.075, 1.245652173913, 0.027777777777778
31683, 1.075, 1.2717391304348, 0.44444444444444
31684, 1.075, 1.2978260869565, 0.47222222222222
31685, 1.075, 1.2717391304348, 0.38888888888889
31686, 1.075, 1.2978260869565, 0.41666666666667
31687, 1.075, 1.2717391304348, 0.33333333333333
31688, 1.075, 1.2978260869565, 0.36111111111111
31689, 1.075, 1.2717391304348, 0.27777777777778
31690, 1.075, 1.2978260869565, 0.30555555555556
31691, 1.075, 1.2717391304348, 0.22222222222222
31692, 1.075, 1.2978260869565, 0.25
31693, 1.075, 1.2717391304348, 0.16666666666667
31694, 1.075, 1.2978260869565, 0.19444444444444
31695, 1.075, 1.2717391304348, 0.11111111111111
31696, 1.075, 1.2978260869565, 0.13888888888889
31697, 1.075, 1.2717391304348, 0.055555555555556
31698, 1.075, 1.2978260869565, 0.083333333333333
31699, 1.075, 1.2978260869565, 0.027777777777778
31700, 1.075, 1.3239130434783, 0.44444444444444
31701, 1.075, 1.3239130434783, 0.38888888888889
31702, 1.075, 1.3239130434783, 0.33333333333333
31703, 1.075, 1.3239130434783, 0.27777777777778
31704, 1.075, 1.3239130434783, 0.22222222222222
31705, 1.075, 1.3239130434783, 0.16666666666667
31706, 1.075, 1.3239130434783, 0.11111111111111
31707, 1.075, 1.3239130434783, 0.055555555555556
31708, 1.1625, 1.2978260869565, 0.5
31709, 1.1625, 1.245652173913, 0.5
31710, 1.1625, 1.1934782608696, 0.5
31711, 1.1625, 1.1413043478261, 0.5
31712, 1.1625, 1.0891304347826, 0.5
31713, 1.1625, 1.0369565217391, 0.5
31714, 1.1625, 0.98478260869565, 0.5
31715, 1.1625, 0.93260869565217, 0.5
31716, 1.1625, 0.8804347826087, 0.5
31717, 1.1625, 0.82826086956522, 0.5
31718, 1.1625, 0.77608695652174, 0.5
31719, 1.1625, 0.72391304347826, 0.5
31720, 1.1625, 0.67173913043478, 0.5
31721, 1.1625, 0.61956521739131, 0.5
31722, 1.1625, 0.56739130434783, 0.5
31723, 1.1625, 0.51521739130435, 0.5
31724, 1.1625, 0.46304347826087, 0.5
31725, 1.1625, 0.41086956521739, 0.5
31726, 1.1625, 0.35869565217391, 0.5
31727, 1.1625, 0.30652173913044, 0.5
31728, 1.1625, 0.25434782608696, 0.5
31729, 1.1625, 0.20217391304348, 0.5
31730, 1.1625, 1.3239130434783, 0.5
31731, 1.18125, 1.2978260869565, 0.5
31732, 1.1625, 1.2717391304348, 0.5
31733, 1.18125, 1.245652173913, 0.5
31734, 1.1625, 1.2195652173913, 0.5
31735, 1.18125, 1.1934782608696, 0.5
31736, 1.1625, 1.1673913043478, 0.5
31737, 1.18125, 1.1413043478261, 0.5
31738, 1.1625, 1.1152173913043, 0.5
31739, 1.18125, 1.0891304347826, 0.5
31740, 1.1625, 1.0630434782609, 0.5
31741, 1.18125, 1.0369565217391, 0.5
31742, 1.1625, 1.0108695652174, 0.5
31743, 1.18125, 0.98478260869565, 0.5
31744, 1.1625, 0.95869565217391, 0.5
31745, 1.18125, 0.93260869565217, 0.5
31746, 1.1625, 0.90652173913044, 0.5
31747, 1.18125, 0.8804347826087, 0.5
31748, 1.1625, 0.85434782608696, 0.5
31749, 1.18125, 0.82826086956522, 0.5
31750, 1.1625, 0.80217391304348, 0.5
31751, 1.18125, 0.77608695652174, 0.5
31752, 1.1625, 0.75, 0.5
31753, 1.18125, 0.72391304347826, 0.5
31754, 1.1625, 0.69782608695652, 0.5
31755, 1.18125, 0.67173913043478, 0.5
31756, 1.1625, 0.64565217391304, 0.5
31757, 1.18125, 0.61956521739131, 0.5
31758, 1.1625, 0.59347826086957, 0.5
31759, 1.18125, 0.56739130434783, 0.5
31760, 1.1625, 0.54130434782609, 0.5
31761, 1.18125, 0.51521739130435, 0.5
31762, 1.1625, 0.48913043478261, 0.5
31763, 1.18125, 0.46304347826087, 0.5
31764, 1.1625, 0.43695652173913, 0.5
31765, 1.18125, 0.41086956521739, 0.5
31766, 1.1625, 0.38478260869565, 0.5
31767, 1.18125, 0.35869565217391, 0.5
31768, 1.1625, 0.33260869565217, 0.5
31769, 1.18125, 0.30652173913044, 0.5
31770, 1.1625, 0.2804347826087, 0.5
31771, 1.18125, 0.25434782608696, 0.5
31772, 1.1625, 0.22826086956522, 0.5
31773, 1.18125, 0.20217391304348, 0.5
31774, 1.1625, 0.17608695652174, 0.5
31775, 1.14375, 1.2978260869565, 0.5
31776, 1.14375, 1.245652173913, 0.5
31777, 1.14375, 1.1934782608696, 0.5
31778, 1.14375, 1.1413043478261, 0.5
31779, 1.14375, 1.0891304347826, 0.5
31780, 1.14375, 1.0369565217391, 0.5
31781, 1.14375, 0.98478260869565, 0.5
31782, 1.14375, 0.93260869565217, 0.5
31783, 1.14375, 0.8804347826087, 0.5
31784, 1.14375, 0.82826086956522, 0.5
31785, 1.14375, 0.77608695652174, 0.5
31786, 1.14375, 0.72391304347826, 0.5
31787, 1.14375, 0.67173913043478, 0.5
31788, 1.14375, 0.61956521739131, 0.5
31789, 1.14375, 0.56739130434783, 0.5
31790, 1.14375, 0.51521739130435, 0.5
31791, 1.14375, 0.46304347826087, 0.5
31792, 1.14375, 0.41086956521739, 0.5
31793, 1.14375, 0.35869565217391, 0.5
31794, 1.14375, 0.30652173913044, 0.5
31795, 1.14375, 0.25434782608696, 0.5
31796, 1.14375, 0.20217391304348, 0.5
31797, 1.1625, 1.2978260869565, 0
31798, 1.1625, 1.245652173913, 0
31799, 1.1625, 1.1934782608696, 0
31800, 1.1625, 1.1413043478261, 0
31801, 1.1625, 1.0891304347826, 0
31802, 1.1625, 1.0369565217391, 0
31803, 1.1625, 0.98478260869565, 0
31804, 1.1625, 0.93260869565217, 0
31805, 1.1625, 0.8804347826087, 0
31806, 1.1625, 0.82826086956522, 0
31807, 1.1625, 0.77608695652174, 0
31808, 1.1625, 0.72391304347826, 0
31809, 1.1625, 0.67173913043478, 0
31810, 1.1625, 0.61956521739131, 0
31811, 1.1625, 0.56739130434783, 0
31812, 1.1625, 0.51521739130435, 0
31813, 1.1625, 0.46304347826087, 0
31814, 1.1625, 0.41086956521739, 0
31815, 1.1625, 0.35869565217391, 0
31816, 1.1625, 0.30652173913044, 0
31817, 1.1625, 0.25434782608696, 0
31818, 1.1625, 0.20217391304348, 0
31819, 1.18125, 1.2978260869565, 0
31820, 1.1625, 1.3239130434783, 0
31821, 1.18125, 1.245652173913, 0
31822, 1.1625, 1.2717391304348, 0
31823, 1.18125, 1.1934782608696, 0
31824, 1.1625, 1.2195652173913, 0
31825, 1.18125, 1.1413043478261, 0
31826, 1.1625, 1.1673913043478, 0
31827, 1.18125, 1.0891304347826, 0
31828, 1.1625, 1.1152173913043, 0
31829, 1.18125, 1.0369565217391, 0
31830, 1.1625, 1.0630434782609, 0
31831, 1.18125, 0.98478260869565, 0
31832, 1.1625, 1.0108695652174, 0
31833, 1.18125, 0.93260869565217, 0
31834, 1.1625, 0.95869565217391, 0
31835, 1.18125, 0.8804347826087, 0
31836, 1.1625, 0.90652173913044, 0
31837, 1.18125, 0.82826086956522, 0
31838, 1.1625, 0.85434782608696, 0
31839, 1.18125, 0.77608695652174, 0
31840, 1.1625, 0.80217391304348, 0
31841, 1.18125, 0.72391304347826, 0
31842, 1.1625, 0.75, 0
31843, 1.18125, 0.67173913043478, 0
31844, 1.1625, 0.69782608695652, 0
31845, 1.18125, 0.61956521739131, 0
31846, 1.1625, 0.64565217391304, 0
31847, 1.18125, 0.56739130434783, 0
31848, 1.1625, 0.59347826086957, 0
31849, 1.18125, 0.51521739130435, 0
31850, 1.1625, 0.54130434782609, 0
31851, 1.18125, 0.46304347826087, 0
31852, 1.1625, 0.48913043478261, 0
31853, 1.18125, 0.41086956521739, 0
31854, 1.1625, 0.43695652173913, 0
31855, 1.18125, 0.35869565217391, 0
31856, 1.1625, 0.38478260869565, 0
31857, 1.18125, 0.30652173913044, 0
31858, 1.1625, 0.33260869565217, 0
31859, 1.18125, 0.25434782608696, 0
31860, 1.1625, 0.2804347826087, 0
31861, 1.18125, 0.20217391304348, 0
31862, 1.1625, 0.22826086956522, 0
31863, 1.1625, 0.17608695652174, 0
31864, 1.14375, 1.2978260869565, 0
31865, 1.14375, 1.245652173913, 0
31866, 1.14375, 1.1934782608696, 0
31867, 1.14375, 1.1413043478261, 0
31868, 1.14375, 1.0891304347826, 0
31869, 1.14375, 1.0369565217391, 0
31870, 1.14375, 0.98478260869565, 0
31871, 1.14375, 0.93260869565217, 0
31872, 1.14375, 0.8804347826087, 0
31873, 1.14375, 0.82826086956522, 0
31874, 1.14375, 0.77608695652174, 0
31875, 1.14375, 0.72391304347826, 0
31876, 1.14375, 0.67173913043478, 0
31877, 1.14375, 0.61956521739131, 0
31878, 1.14375, 0.56739130434783, 0
31879, 1.14375, 0.51521739130435, 0
31880, 1.14375, 0.46304347826087, 0
31881, 1.14375, 0.41086956521739, 0
31882, 1.14375, 0.35869565217391, 0
31883, 1.14375, 0.30652173913044, 0
31884, 1.14375, 0.25434782608696, 0
31885, 1.14375, 0.20217391304348, 0
31886, 1.1625, 1.35, 0.44444444444444
31887, 1.1625, 1.35, 0.38888888888889
31888, 1.1625, 1.35, 0.33333333333333
31889, 1.1625, 1.35, 0.27777777777778
31890, 1.1625, 1.35, 0.22222222222222
31891, 1.1625, 1.35, 0.16666666666667
31892, 1.1625, 1.35, 0.11111111111111
31893, 1.1625, 1.35, 0.055555555555556
31894, 1.18125, 1.35, 0.44444444444444
31895, 1.1625, 1.35, 0.47222222222222
31896, 1.18125, 1.35, 0.38888888888889
31897, 1.1625, 1.35, 0.41666666666667
31898, 1.18125, 1.35, 0.33333333333333
31899, 1.1625, 1.35, 0.36111111111111
31900, 1.18125, 1.35, 0.27777777777778
31901, 1.1625, 1.35, 0.30555555555556
31902, 1.18125, 1.35, 0.22222222222222
31903, 1.1625, 1.35, 0.25
31904, 1.18125, 1.35, 0.16666666666667
31905, 1.1625, 1.35, 0.19444444444444
31906, 1.18125, 1.35, 0.11111111111111
31907, 1.1625, 1.35, 0.13888888888889
31908, 1.18125, 1.35, 0.055555555555556
31909, 1.1625, 1.35, 0.083333333333333
31910, 1.1625, 1.35, 0.027777777777778
31911, 1.14375, 1.35, 0.44444444444444
31912, 1.14375, 1.35, 0.38888888888889
31913, 1.14375, 1.35, 0.33333333333333
31914, 1.14375, 1.35, 0.27777777777778
31915, 1.14375, 1.35, 0.22222222222222
31916, 1.14375, 1.35, 0.16666666666667
31917, 1.14375, 1.35, 0.11111111111111
31918, 1.14375, 1.35, 0.055555555555556
31919, 1.1625, 0.15, 0.44444444444444
31920, 1.1625, 0.15, 0.38888888888889
31921, 1.1625, 0.15, 0.33333333333333
31922, 1.1625, 0.15, 0.27777777777778
31923, 1.1625, 0.15, 0.22222222222222
31924, 1.1625, 0.15, 0.16666666666667
31925, 1.1625, 0.15, 0.11111111111111
31926, 1.1625, 0.15, 0.055555555555556
31927, 1.1625, 0.15, 0.47222222222222
31928, 1.18125, 0.15, 0.44444444444444
31929, 1.1625, 0.15, 0.41666666666667
31930, 1.18125, 0.15, 0.38888888888889
31931, 1.1625, 0.15, 0.36111111111111
31932, 1.18125, 0.15, 0.33333333333333
31933, 1.1625, 0.15, 0.30555555555556
31934, 1.18125, 0.15, 0.27777777777778
31935, 1.1625, 0.15, 0.25
31936, 1.18125, 0.15, 0.22222222222222
31937, 1.1625, 0.15, 0.19444444444444
31938, 1.18125, 0.15, 0.16666666666667
31939, 1.1625, 0.15, 0.13888888888889
31940, 1.18125, 0.15, 0.11111111111111
31941, 1.1625, 0.15, 0.083333333333333
31942, 1.18125, 0.15, 0.055555555555556
31943, 1.1625, 0.15, 0.027777777777778
31944, 1.14375, 0.15, 0.44444444444444
31945, 1.14375, 0.15, 0.38888888888889
31946, 1.14375, 0.15, 0.33333333333333
31947, 1.14375, 0.15, 0.27777777777778
31948, 1.14375, 0.15, 0.22222222222222
31949, 1.14375, 0.15, 0.16666666666667
31950, 1.14375, 0.15, 0.11111111111111
31951, 1.14375, 0.15, 0.055555555555556
31952, 1.125, 1.2978260869565, 0.44444444444444
31953, 1.125, 1.2978260869565, 0.38888888888889
31954, 1.125, 1.2978260869565, 0.33333333333333
31955, 1.125, 1.2978260869565, 0.27777777777778
31956, 1.125, 1.2978260869565, 0.22222222222222
31957, 1.125, 1.2978260869565, 0.16666666666667
31958, 1.125, 1.2978260869565, 0.11111111111111
31959, 1.125, 1.2978260869565, 0.055555555555556
31960, 1.125, 1.245652173913, 0.44444444444444
31961, 1.125, 1.245652173913, 0.38888888888889
31962, 1.125, 1.245652173913, 0.33333333333333
31963, 1.125, 1.245652173913, 0.27777777777778
31964, 1.125, 1.245652173913, 0.22222222222222
31965, 1.125, 1.245652173913, 0.16666666666667
31966, 1.125, 1.245652173913, 0.11111111111111
31967, 1.125, 1.245652173913, 0.055555555555556
31968, 1.125, 1.1934782608696, 0.44444444444444
31969, 1.125, 1.1934782608696, 0.38888888888889
31970, 1.125, 1.1934782608696, 0.33333333333333
31971, 1.125, 1.1934782608696, 0.27777777777778
31972, 1.125, 1.1934782608696, 0.22222222222222
31973, 1.125, 1.1934782608696, 0.16666666666667
31974, 1.125, 1.1934782608696, 0.11111111111111
31975, 1.125, 1.1934782608696, 0.055555555555556
31976, 1.125, 1.1413043478261, 0.44444444444444
31977, 1.125, 1.1413043478261, 0.38888888888889
31978, 1.125, 1.1413043478261, 0.33333333333333
31979, 1.125, 1.1413043478261, 0.27777777777778
31980, 1.125, 1.1413043478261, 0.22222222222222
31981, 1.125, 1.1413043478261, 0.16666666666667
31982, 1.125, 1.1413043478261, 0.11111111111111
31983, 1.125, 1.1413043478261, 0.055555555555556
31984, 1.125, 1.0891304347826, 0.44444444444444
31985, 1.125, 1.0891304347826, 0.38888888888889
31986, 1.125, 1.0891304347826, 0.33333333333333
31987, 1.125, 1.0891304347826, 0.27777777777778
31988, 1.125, 1.0891304347826, 0.22222222222222
31989, 1.125, 1.0891304347826, 0.16666666666667
31990, 1.125, 1.0891304347826, 0.11111111111111
31991, 1.125, 1.0891304347826, 0.055555555555556
31992, 1.125, 1.0369565217391, 0.44444444444444
31993, 1.125, 1.0369565217391, 0.38888888888889
31994, 1.125, 1.0369565217391, 0.33333333333333
31995, 1.125, 1.0369565217391, 0.27777777777778
31996, 1.125, 1.0369565217391, 0.22222222222222
31997, 1.125, 1.0369565217391, 0.16666666666667
31998, 1.125, 1.0369565217391, 0.11111111111111
31999, 1.125, 1.0369565217391, 0.055555555555556
32000, 1.125, 0.98478260869565, 0.44444444444444
32001, 1.125, 0.98478260869565, 0.38888888888889
32002, 1.125, 0.98478260869565, 0.33333333333333
32003, 1.125, 0.98478260869565, 0.27777777777778
32004, 1.125, 0.98478260869565, 0.22222222222222
32005, 1.125, 0.98478260869565, 0.16666666666667
32006, 1.125, 0.98478260869565, 0.11111111111111
32007, 1.125, 0.98478260869565, 0.055555555555556
32008, 1.125, 0.93260869565217, 0.44444444444444
32009, 1.125, 0.93260869565217, 0.38888888888889
32010, 1.125, 0.93260869565217, 0.33333333333333
32011, 1.125, 0.93260869565217, 0.27777777777778
32012, 1.125, 0.93260869565217, 0.22222222222222
32013, 1.125, 0.93260869565217, 0.16666666666667
32014, 1.125, 0.93260869565217, 0.11111111111111
32015, 1.125, 0.93260869565217, 0.055555555555556
32016, 1.125, 0.8804347826087, 0.44444444444444
32017, 1.125, 0.8804347826087, 0.38888888888889
32018, 1.125, 0.8804347826087, 0.33333333333333
32019, 1.125, 0.8804347826087, 0.27777777777778
32020, 1.125, 0.8804347826087, 0.22222222222222
32021, 1.125, 0.8804347826087, 0.16666666666667
32022, 1.125, 0.8804347826087, 0.11111111111111
32023, 1.125, 0.8804347826087, 0.055555555555556
32024, 1.125, 0.82826086956522, 0.44444444444444
32025, 1.125, 0.82826086956522, 0.38888888888889
32026, 1.125, 0.82826086956522, 0.33333333333333
32027, 1.125, 0.82826086956522, 0.27777777777778
32028, 1.125, 0.82826086956522, 0.22222222222222
32029, 1.125, 0.82826086956522, 0.16666666666667
32030, 1.125, 0.82826086956522, 0.11111111111111
32031, 1.125, 0.82826086956522, 0.055555555555556
32032, 1.125, 0.77608695652174, 0.44444444444444
32033, 1.125, 0.77608695652174, 0.38888888888889
32034, 1.125, 0.77608695652174, 0.33333333333333
32035, 1.125, 0.77608695652174, 0.27777777777778
32036, 1.125, 0.77608695652174, 0.22222222222222
32037, 1.125, 0.77608695652174, 0.16666666666667
32038, 1.125, 0.77608695652174, 0.11111111111111
32039, 1.125, 0.77608695652174, 0.055555555555556
32040, 1.125, 0.72391304347826, 0.44444444444444
32041, 1.125, 0.72391304347826, 0.38888888888889
32042, 1.125, 0.72391304347826, 0.33333333333333
32043, 1.125, 0.72391304347826, 0.27777777777778
32044, 1.125, 0.72391304347826, 0.22222222222222
32045, 1.125, 0.72391304347826, 0.16666666666667
32046, 1.125, 0.72391304347826, 0.11111111111111
32047, 1.125, 0.72391304347826, 0.055555555555556
32048, 1.125, 0.67173913043478, 0.44444444444444
32049, 1.125, 0.67173913043478, 0.38888888888889
32050, 1.125, 0.67173913043478, 0.33333333333333
32051, 1.125, 0.67173913043478, 0.27777777777778
32052, 1.125, 0.67173913043478, 0.22222222222222
32053, 1.125, 0.67173913043478, 0.16666666666667
32054, 1.125, 0.67173913043478, 0.11111111111111
32055, 1.125, 0.67173913043478, 0.055555555555556
32056, 1.125, 0.61956521739131, 0.44444444444444
32057, 1.125, 0.61956521739131, 0.38888888888889
32058, 1.125, 0.61956521739131, 0.33333333333333
32059, 1.125, 0.61956521739131, 0.27777777777778
32060, 1.125, 0.61956521739131, 0.22222222222222
32061, 1.125, 0.61956521739131, 0.16666666666667
32062, 1.125, 0.61956521739131, 0.11111111111111
32063, 1.125, 0.61956521739131, 0.055555555555556
32064, 1.125, 0.56739130434783, 0.44444444444444
32065, 1.125, 0.56739130434783, 0.38888888888889
32066, 1.125, 0.56739130434783, 0.33333333333333
32067, 1.125, 0.56739130434783, 0.27777777777778
32068, 1.125, 0.56739130434783, 0.22222222222222
32069, 1.125, 0.56739130434783, 0.16666666666667
32070, 1.125, 0.56739130434783, 0.11111111111111
32071, 1.125, 0.56739130434783, 0.055555555555556
32072, 1.125, 0.51521739130435, 0.44444444444444
32073, 1.125, 0.51521739130435, 0.38888888888889
32074, 1.125, 0.51521739130435, 0.33333333333333
32075, 1.125, 0.51521739130435, 0.27777777777778
32076, 1.125, 0.51521739130435, 0.22222222222222
32077, 1.125, 0.51521739130435, 0.16666666666667
32078, 1.125, 0.51521739130435, 0.11111111111111
32079, 1.125, 0.51521739130435, 0.055555555555556
32080, 1.125, 0.46304347826087, 0.44444444444444
32081, 1.125, 0.46304347826087, 0.38888888888889
32082, 1.125, 0.46304347826087, 0.33333333333333
32083, 1.125, 0.46304347826087, 0.27777777777778
32084, 1.125, 0.46304347826087, 0.22222222222222
32085, 1.125, 0.46304347826087, 0.16666666666667
32086, 1.125, 0.46304347826087, 0.11111111111111
32087, 1.125, 0.46304347826087, 0.055555555555556
32088, 1.125, 0.41086956521739, 0.44444444444444
32089, 1.125, 0.41086956521739, 0.38888888888889
32090, 1.125, 0.41086956521739, 0.33333333333333
32091, 1.125, 0.41086956521739, 0.27777777777778
32092, 1.125, 0.41086956521739, 0.22222222222222
32093, 1.125, 0.41086956521739, 0.16666666666667
32094, 1.125, 0.41086956521739, 0.11111111111111
32095, 1.125, 0.41086956521739, 0.055555555555556
32096, 1.125, 0.35869565217391, 0.44444444444444
32097, 1.125, 0.35869565217391, 0.38888888888889
32098, 1.125, 0.35869565217391, 0.33333333333333
32099, 1.125, 0.35869565217391, 0.27777777777778
32100, 1.125, 0.35869565217391, 0.22222222222222
32101, 1.125, 0.35869565217391, 0.16666666666667
32102, 1.125, 0.35869565217391, 0.11111111111111
32103, 1.125, 0.35869565217391, 0.055555555555556
32104, 1.125, 0.30652173913043, 0.44444444444444
32105, 1.125, 0.30652173913043, 0.38888888888889
32106, 1.125, 0.30652173913043, 0.33333333333333
32107, 1.125, 0.30652173913043, 0.27777777777778
32108, 1.125, 0.30652173913043, 0.22222222222222
32109, 1.125, 0.30652173913043, 0.16666666666667
32110, 1.125, 0.30652173913043, 0.11111111111111
32111, 1.125, 0.30652173913043, 0.055555555555556
32112, 1.125, 0.25434782608696, 0.44444444444444
32113, 1.125, 0.25434782608696, 0.38888888888889
32114, 1.125, 0.25434782608696, 0.33333333333333
32115, 1.125, 0.25434782608696, 0.27777777777778
32116, 1.125, 0.25434782608696, 0.22222222222222
32117, 1.125, 0.25434782608696, 0.16666666666667
32118, 1.125, 0.25434782608696, 0.11111111111111
32119, 1.125, 0.25434782608696, 0.055555555555556
32120, 1.125, 0.20217391304348, 0.44444444444444
32121, 1.125, 0.20217391304348, 0.38888888888889
32122, 1.125, 0.20217391304348, 0.33333333333333
32123, 1.125, 0.20217391304348, 0.27777777777778
32124, 1.125, 0.20217391304348, 0.22222222222222
32125, 1.125, 0.20217391304348, 0.16666666666667
32126, 1.125, 0.20217391304348, 0.11111111111111
32127, 1.125, 0.20217391304348, 0.055555555555556
32128, 1.125, 1.3239130434783, 0.44444444444444
32129, 1.125, 1.2978260869565, 0.47222222222222
32130, 1.125, 1.3239130434783, 0.38888888888889
32131, 1.125, 1.2978260869565, 0.41666666666667
32132, 1.125, 1.3239130434783, 0.33333333333333
32133, 1.125, 1.2978260869565, 0.36111111111111
32134, 1.125, 1.3239130434783, 0.27777777777778
32135, 1.125, 1.2978260869565, 0.30555555555556
32136, 1.125, 1.3239130434783, 0.22222222222222
32137, 1.125, 1.2978260869565, 0.25
32138, 1.125, 1.3239130434783, 0.16666666666667
32139, 1.125, 1.2978260869565, 0.19444444444444
32140, 1.125, 1.3239130434783, 0.11111111111111
32141, 1.125, 1.2978260869565, 0.13888888888889
32142, 1.125, 1.3239130434783, 0.055555555555556
32143, 1.125, 1.2978260869565, 0.083333333333333
32144, 1.125, 1.2978260869565, 0.027777777777778
32145, 1.125, 1.2717391304348, 0.44444444444444
32146, 1.125, 1.245652173913, 0.47222222222222
32147, 1.125, 1.2717391304348, 0.38888888888889
32148, 1.125, 1.245652173913, 0.41666666666667
32149, 1.125, 1.2717391304348, 0.33333333333333
32150, 1.125, 1.245652173913, 0.36111111111111
32151, 1.125, 1.2717391304348, 0.27777777777778
32152, 1.125, 1.245652173913, 0.30555555555556
32153, 1.125, 1.2717391304348, 0.22222222222222
32154, 1.125, 1.245652173913, 0.25
32155, 1.125, 1.2717391304348, 0.16666666666667
32156, 1.125, 1.245652173913, 0.19444444444444
32157, 1.125, 1.2717391304348, 0.11111111111111
32158, 1.125, 1.245652173913, 0.13888888888889
32159, 1.125, 1.2717391304348, 0.055555555555556
32160, 1.125, 1.245652173913, 0.083333333333333
32161, 1.125, 1.245652173913, 0.027777777777778
32162, 1.125, 1.2195652173913, 0.44444444444444
32163, 1.125, 1.1934782608696, 0.47222222222222
32164, 1.125, 1.2195652173913, 0.38888888888889
32165, 1.125, 1.1934782608696, 0.41666666666667
32166, 1.125, 1.2195652173913, 0.33333333333333
32167, 1.125, 1.1934782608696, 0.36111111111111
32168, 1.125, 1.2195652173913, 0.27777777777778
32169, 1.125, 1.1934782608696, 0.30555555555556
32170, 1.125, 1.2195652173913, 0.22222222222222
32171, 1.125, 1.1934782608696, 0.25
32172, 1.125, 1.2195652173913, 0.16666666666667
32173, 1.125, 1.1934782608696, 0.19444444444444
32174, 1.125, 1.2195652173913, 0.11111111111111
32175, 1.125, 1.1934782608696, 0.13888888888889
32176, 1.125, 1.2195652173913, 0.055555555555556
32177, 1.125, 1.1934782608696, 0.083333333333333
32178, 1.125, 1.1934782608696, 0.027777777777778
32179, 1.125, 1.1673913043478, 0.44444444444444
32180, 1.125, 1.1413043478261, 0.47222222222222
32181, 1.125, 1.1673913043478, 0.38888888888889
32182, 1.125, 1.1413043478261, 0.41666666666667
32183, 1.125, 1.1673913043478, 0.33333333333333
32184, 1.125, 1.1413043478261, 0.36111111111111
32185, 1.125, 1.1673913043478, 0.27777777777778
32186, 1.125, 1.1413043478261, 0.30555555555556
32187, 1.125, 1.1673913043478, 0.22222222222222
32188, 1.125, 1.1413043478261, 0.25
32189, 1.125, 1.1673913043478, 0.16666666666667
32190, 1.125, 1.1413043478261, 0.19444444444444
32191, 1.125, 1.1673913043478, 0.11111111111111
32192, 1.125, 1.1413043478261, 0.13888888888889
32193, 1.125, 1.1673913043478, 0.055555555555556
32194, 1.125, 1.1413043478261, 0.083333333333333
32195, 1.125, 1.1413043478261, 0.027777777777778
32196, 1.125, 1.1152173913043, 0.44444444444444
32197, 1.125, 1.0891304347826, 0.47222222222222
32198, 1.125, 1.1152173913043, 0.38888888888889
32199, 1.125, 1.0891304347826, 0.41666666666667
32200, 1.125, 1.1152173913043, 0.33333333333333
32201, 1.125, 1.0891304347826, 0.36111111111111
32202, 1.125, 1.1152173913043, 0.27777777777778
32203, 1.125, 1.0891304347826, 0.30555555555556
32204, 1.125, 1.1152173913043, 0.22222222222222
32205, 1.125, 1.0891304347826, 0.25
32206, 1.125, 1.1152173913043, 0.16666666666667
32207, 1.125, 1.0891304347826, 0.19444444444444
32208, 1.125, 1.1152173913043, 0.11111111111111
32209, 1.125, 1.0891304347826, 0.13888888888889
32210, 1.125, 1.1152173913043, 0.055555555555556
32211, 1.125, 1.0891304347826, 0.083333333333333
32212, 1.125, 1.0891304347826, 0.027777777777778
32213, 1.125, 1.0630434782609, 0.44444444444444
32214, 1.125, 1.0369565217391, 0.47222222222222
32215, 1.125, 1.0630434782609, 0.38888888888889
32216, 1.125, 1.0369565217391, 0.41666666666667
32217, 1.125, 1.0630434782609, 0.33333333333333
32218, 1.125, 1.0369565217391, 0.36111111111111
32219, 1.125, 1.0630434782609, 0.27777777777778
32220, 1.125, 1.0369565217391, 0.30555555555556
32221, 1.125, 1.0630434782609, 0.22222222222222
32222, 1.125, 1.0369565217391, 0.25
32223, 1.125, 1.0630434782609, 0.16666666666667
32224, 1.125, 1.0369565217391, 0.19444444444444
32225, 1.125, 1.0630434782609, 0.11111111111111
32226, 1.125, 1.0369565217391, 0.13888888888889
32227, 1.125, 1.0630434782609, 0.055555555555556
32228, 1.125, 1.0369565217391, 0.083333333333333
32229, 1.125, 1.0369565217391, 0.027777777777778
32230, 1.125, 1.0108695652174, 0.44444444444444
32231, 1.125, 0.98478260869565, 0.47222222222222
32232, 1.125, 1.0108695652174, 0.38888888888889
32233, 1.125, 0.98478260869565, 0.41666666666667
32234, 1.125, 1.0108695652174, 0.33333333333333
32235, 1.125, 0.98478260869565, 0.36111111111111
32236, 1.125, 1.0108695652174, 0.27777777777778
32237, 1.125, 0.98478260869565, 0.30555555555556
32238, 1.125, 1.0108695652174, 0.22222222222222
32239, 1.125, 0.98478260869565, 0.25
32240, 1.125, 1.0108695652174, 0.16666666666667
32241, 1.125, 0.98478260869565, 0.19444444444444
32242, 1.125, 1.0108695652174, 0.11111111111111
32243, 1.125, 0.98478260869565, 0.13888888888889
32244, 1.125, 1.0108695652174, 0.055555555555556
32245, 1.125, 0.98478260869565, 0.083333333333333
32246, 1.125, 0.98478260869565, 0.027777777777778
32247, 1.125, 0.95869565217391, 0.44444444444444
32248, 1.125, 0.93260869565217, 0.47222222222222
32249, 1.125, 0.95869565217391, 0.38888888888889
32250, 1.125, 0.93260869565217, 0.41666666666667
32251, 1.125, 0.95869565217391, 0.33333333333333
32252, 1.125, 0.93260869565217, 0.36111111111111
32253, 1.125, 0.95869565217391, 0.27777777777778
32254, 1.125, 0.93260869565217, 0.30555555555556
32255, 1.125, 0.95869565217391, 0.22222222222222
32256, 1.125, 0.93260869565217, 0.25
32257, 1.125, 0.95869565217391, 0.16666666666667
32258, 1.125, 0.93260869565217, 0.19444444444444
32259, 1.125, 0.95869565217391, 0.11111111111111
32260, 1.125, 0.93260869565217, 0.13888888888889
32261, 1.125, 0.95869565217391, 0.055555555555556
32262, 1.125, 0.93260869565217, 0.083333333333333
32263, 1.125, 0.93260869565217, 0.027777777777778
32264, 1.125, 0.90652173913044, 0.44444444444444
32265, 1.125, 0.8804347826087, 0.47222222222222
32266, 1.125, 0.90652173913044, 0.38888888888889
32267, 1.125, 0.8804347826087, 0.41666666666667
32268, 1.125, 0.90652173913044, 0.33333333333333
32269, 1.125, 0.8804347826087, 0.36111111111111
32270, 1.125, 0.90652173913044, 0.27777777777778
32271, 1.125, 0.8804347826087, 0.30555555555556
32272, 1.125, 0.90652173913044, 0.22222222222222
32273, 1.125, 0.8804347826087, 0.25
32274, 1.125, 0.90652173913044, 0.16666666666667
32275, 1.125, 0.8804347826087, 0.19444444444444
32276, 1.125, 0.90652173913044, 0.11111111111111
32277, 1.125, 0.8804347826087, 0.13888888888889
32278, 1.125, 0.90652173913044, 0.055555555555556
32279, 1.125, 0.8804347826087, 0.083333333333333
32280, 1.125, 0.8804347826087, 0.027777777777778
32281, 1.125, 0.85434782608696, 0.44444444444444
32282, 1.125, 0.82826086956522, 0.47222222222222
32283, 1.125, 0.85434782608696, 0.38888888888889
32284, 1.125, 0.82826086956522, 0.41666666666667
32285, 1.125, 0.85434782608696, 0.33333333333333
32286, 1.125, 0.82826086956522, 0.36111111111111
32287, 1.125, 0.85434782608696, 0.27777777777778
32288, 1.125, 0.82826086956522, 0.30555555555556
32289, 1.125, 0.85434782608696, 0.22222222222222
32290, 1.125, 0.82826086956522, 0.25
32291, 1.125, 0.85434782608696, 0.16666666666667
32292, 1.125, 0.82826086956522, 0.19444444444444
32293, 1.125, 0.85434782608696, 0.11111111111111
32294, 1.125, 0.82826086956522, 0.13888888888889
32295, 1.125, 0.85434782608696, 0.055555555555556
32296, 1.125, 0.82826086956522, 0.083333333333333
32297, 1.125, 0.82826086956522, 0.027777777777778
32298, 1.125, 0.80217391304348, 0.44444444444444
32299, 1.125, 0.77608695652174, 0.47222222222222
32300, 1.125, 0.80217391304348, 0.38888888888889
32301, 1.125, 0.77608695652174, 0.41666666666667
32302, 1.125, 0.80217391304348, 0.33333333333333
32303, 1.125, 0.77608695652174, 0.36111111111111
32304, 1.125, 0.80217391304348, 0.27777777777778
32305, 1.125, 0.77608695652174, 0.30555555555556
32306, 1.125, 0.80217391304348, 0.22222222222222
32307, 1.125, 0.77608695652174, 0.25
32308, 1.125, 0.80217391304348, 0.16666666666667
32309, 1.125, 0.77608695652174, 0.19444444444444
32310, 1.125, 0.80217391304348, 0.11111111111111
32311, 1.125, 0.77608695652174, 0.13888888888889
32312, 1.125, 0.80217391304348, 0.055555555555556
32313, 1.125, 0.77608695652174, 0.083333333333333
32314, 1.125, 0.77608695652174, 0.027777777777778
32315, 1.125, 0.75, 0.44444444444444
32316, 1.125, 0.72391304347826, 0.47222222222222
32317, 1.125, 0.75, 0.38888888888889
32318, 1.125, 0.72391304347826, 0.41666666666667
32319, 1.125, 0.75, 0.33333333333333
32320, 1.125, 0.72391304347826, 0.36111111111111
32321, 1.125, 0.75, 0.27777777777778
32322, 1.125, 0.72391304347826, 0.30555555555556
32323, 1.125, 0.75, 0.22222222222222
32324, 1.125, 0.72391304347826, 0.25
32325, 1.125, 0.75, 0.16666666666667
32326, 1.125, 0.72391304347826, 0.19444444444444
32327, 1.125, 0.75, 0.11111111111111
32328, 1.125, 0.72391304347826, 0.13888888888889
32329, 1.125, 0.75, 0.055555555555556
32330, 1.125, 0.72391304347826, 0.083333333333333
32331, 1.125, 0.72391304347826, 0.027777777777778
32332, 1.125, 0.69782608695652, 0.44444444444444
32333, 1.125, 0.67173913043478, 0.47222222222222
32334, 1.125, 0.69782608695652, 0.38888888888889
32335, 1.125, 0.67173913043478, 0.41666666666667
32336, 1.125, 0.69782608695652, 0.33333333333333
32337, 1.125, 0.67173913043478, 0.36111111111111
32338, 1.125, 0.69782608695652, 0.27777777777778
32339, 1.125, 0.67173913043478, 0.30555555555556
32340, 1.125, 0.69782608695652, 0.22222222222222
32341, 1.125, 0.67173913043478, 0.25
32342, 1.125, 0.69782608695652, 0.16666666666667
32343, 1.125, 0.67173913043478, 0.19444444444444
32344, 1.125, 0.69782608695652, 0.11111111111111
32345, 1.125, 0.67173913043478, 0.13888888888889
32346, 1.125, 0.69782608695652, 0.055555555555556
32347, 1.125, 0.67173913043478, 0.083333333333333
32348, 1.125, 0.67173913043478, 0.027777777777778
32349, 1.125, 0.64565217391304, 0.44444444444444
32350, 1.125, 0.61956521739131, 0.47222222222222
32351, 1.125, 0.64565217391304, 0.38888888888889
32352, 1.125, 0.61956521739131, 0.41666666666667
32353, 1.125, 0.64565217391304, 0.33333333333333
32354, 1.125, 0.61956521739131, 0.36111111111111
32355, 1.125, 0.64565217391304, 0.27777777777778
32356, 1.125, 0.61956521739131, 0.30555555555556
32357, 1.125, 0.64565217391304, 0.22222222222222
32358, 1.125, 0.61956521739131, 0.25
32359, 1.125, 0.64565217391304, 0.16666666666667
32360, 1.125, 0.61956521739131, 0.19444444444444
32361, 1.125, 0.64565217391304, 0.11111111111111
32362, 1.125, 0.61956521739131, 0.13888888888889
32363, 1.125, 0.64565217391304, 0.055555555555556
32364, 1.125, 0.61956521739131, 0.083333333333333
32365, 1.125, 0.61956521739131, 0.027777777777778
32366, 1.125, 0.59347826086957, 0.44444444444444
32367, 1.125, 0.56739130434783, 0.47222222222222
32368, 1.125, 0.59347826086957, 0.38888888888889
32369, 1.125, 0.56739130434783, 0.41666666666667
32370, 1.125, 0.59347826086957, 0.33333333333333
32371, 1.125, 0.56739130434783, 0.36111111111111
32372, 1.125, 0.59347826086957, 0.27777777777778
32373, 1.125, 0.56739130434783, 0.30555555555556
32374, 1.125, 0.59347826086957, 0.22222222222222
32375, 1.125, 0.56739130434783, 0.25
32376, 1.125, 0.59347826086957, 0.16666666666667
32377, 1.125, 0.56739130434783, 0.19444444444444
32378, 1.125, 0.59347826086957, 0.11111111111111
32379, 1.125, 0.56739130434783, 0.13888888888889
32380, 1.125, 0.59347826086957, 0.055555555555556
32381, 1.125, 0.56739130434783, 0.083333333333333
32382, 1.125, 0.56739130434783, 0.027777777777778
32383, 1.125, 0.54130434782609, 0.44444444444444
32384, 1.125, 0.51521739130435, 0.47222222222222
32385, 1.125, 0.54130434782609, 0.38888888888889
32386, 1.125, 0.51521739130435, 0.41666666666667
32387, 1.125, 0.54130434782609, 0.33333333333333
32388, 1.125, 0.51521739130435, 0.36111111111111
32389, 1.125, 0.54130434782609, 0.27777777777778
32390, 1.125, 0.51521739130435, 0.30555555555556
32391, 1.125, 0.54130434782609, 0.22222222222222
32392, 1.125, 0.51521739130435, 0.25
32393, 1.125, 0.54130434782609, 0.16666666666667
32394, 1.125, 0.51521739130435, 0.19444444444444
32395, 1.125, 0.54130434782609, 0.11111111111111
32396, 1.125, 0.51521739130435, 0.13888888888889
32397, 1.125, 0.54130434782609, 0.055555555555556
32398, 1.125, 0.51521739130435, 0.083333333333333
32399, 1.125, 0.51521739130435, 0.027777777777778
32400, 1.125, 0.48913043478261, 0.44444444444444
32401, 1.125, 0.46304347826087, 0.47222222222222
32402, 1.125, 0.48913043478261, 0.38888888888889
32403, 1.125, 0.46304347826087, 0.41666666666667
32404, 1.125, 0.48913043478261, 0.33333333333333
32405, 1.125, 0.46304347826087, 0.36111111111111
32406, 1.125, 0.48913043478261, 0.27777777777778
32407, 1.125, 0.46304347826087, 0.30555555555556
32408, 1.125, 0.48913043478261, 0.22222222222222
32409, 1.125, 0.46304347826087, 0.25
32410, 1.125, 0.48913043478261, 0.16666666666667
32411, 1.125, 0.46304347826087, 0.19444444444444
32412, 1.125, 0.48913043478261, 0.11111111111111
32413, 1.125, 0.46304347826087, 0.13888888888889
32414, 1.125, 0.48913043478261, 0.055555555555556
32415, 1.125, 0.46304347826087, 0.083333333333333
32416, 1.125, 0.46304347826087, 0.027777777777778
32417, 1.125, 0.43695652173913, 0.44444444444444
32418, 1.125, 0.41086956521739, 0.47222222222222
32419, 1.125, 0.43695652173913, 0.38888888888889
32420, 1.125, 0.41086956521739, 0.41666666666667
32421, 1.125, 0.43695652173913, 0.33333333333333
32422, 1.125, 0.41086956521739, 0.36111111111111
32423, 1.125, 0.43695652173913, 0.27777777777778
32424, 1.125, 0.41086956521739, 0.30555555555556
32425, 1.125, 0.43695652173913, 0.22222222222222
32426, 1.125, 0.41086956521739, 0.25
32427, 1.125, 0.43695652173913, 0.16666666666667
32428, 1.125, 0.41086956521739, 0.19444444444444
32429, 1.125, 0.43695652173913, 0.11111111111111
32430, 1.125, 0.41086956521739, 0.13888888888889
32431, 1.125, 0.43695652173913, 0.055555555555556
32432, 1.125, 0.41086956521739, 0.083333333333333
32433, 1.125, 0.41086956521739, 0.027777777777778
32434, 1.125, 0.38478260869565, 0.44444444444444
32435, 1.125, 0.35869565217391, 0.47222222222222
32436, 1.125, 0.38478260869565, 0.38888888888889
32437, 1.125, 0.35869565217391, 0.41666666666667
32438, 1.125, 0.38478260869565, 0.33333333333333
32439, 1.125, 0.35869565217391, 0.36111111111111
32440, 1.125, 0.38478260869565, 0.27777777777778
32441, 1.125, 0.35869565217391, 0.30555555555556
32442, 1.125, 0.38478260869565, 0.22222222222222
32443, 1.125, 0.35869565217391, 0.25
32444, 1.125, 0.38478260869565, 0.16666666666667
32445, 1.125, 0.35869565217391, 0.19444444444444
32446, 1.125, 0.38478260869565, 0.11111111111111
32447, 1.125, 0.35869565217391, 0.13888888888889
32448, 1.125, 0.38478260869565, 0.055555555555556
32449, 1.125, 0.35869565217391, 0.083333333333333
32450, 1.125, 0.35869565217391, 0.027777777777778
32451, 1.125, 0.33260869565217, 0.44444444444444
32452, 1.125, 0.30652173913044, 0.47222222222222
32453, 1.125, 0.33260869565217, 0.38888888888889
32454, 1.125, 0.30652173913043, 0.41666666666667
32455, 1.125, 0.33260869565217, 0.33333333333333
32456, 1.125, 0.30652173913043, 0.36111111111111
32457, 1.125, 0.33260869565217, 0.27777777777778
32458, 1.125, 0.30652173913043, 0.30555555555556
32459, 1.125, 0.33260869565217, 0.22222222222222
32460, 1.125, 0.30652173913043, 0.25
32461, 1.125, 0.33260869565217, 0.16666666666667
32462, 1.125, 0.30652173913043, 0.19444444444444
32463, 1.125, 0.33260869565217, 0.11111111111111
32464, 1.125, 0.30652173913043, 0.13888888888889
32465, 1.125, 0.33260869565217, 0.055555555555556
32466, 1.125, 0.30652173913043, 0.083333333333333
32467, 1.125, 0.30652173913044, 0.027777777777778
32468, 1.125, 0.2804347826087, 0.44444444444444
32469, 1.125, 0.25434782608696, 0.47222222222222
32470, 1.125, 0.2804347826087, 0.38888888888889
32471, 1.125, 0.25434782608696, 0.41666666666667
32472, 1.125, 0.2804347826087, 0.33333333333333
32473, 1.125, 0.25434782608696, 0.36111111111111
32474, 1.125, 0.2804347826087, 0.27777777777778
32475, 1.125, 0.25434782608696, 0.30555555555556
32476, 1.125, 0.2804347826087, 0.22222222222222
32477, 1.125, 0.25434782608696, 0.25
32478, 1.125, 0.2804347826087, 0.16666666666667
32479, 1.125, 0.25434782608696, 0.19444444444444
32480, 1.125, 0.2804347826087, 0.11111111111111
32481, 1.125, 0.25434782608696, 0.13888888888889
32482, 1.125, 0.2804347826087, 0.055555555555556
32483, 1.125, 0.25434782608696, 0.083333333333333
32484, 1.125, 0.25434782608696, 0.027777777777778
32485, 1.125, 0.22826086956522, 0.44444444444444
32486, 1.125, 0.20217391304348, 0.47222222222222
32487, 1.125, 0.22826086956522, 0.38888888888889
32488, 1.125, 0.20217391304348, 0.41666666666667
32489, 1.125, 0.22826086956522, 0.33333333333333
32490, 1.125, 0.20217391304348, 0.36111111111111
32491, 1.125, 0.22826086956522, 0.27777777777778
32492, 1.125, 0.20217391304348, 0.30555555555556
32493, 1.125, 0.22826086956522, 0.22222222222222
32494, 1.125, 0.20217391304348, 0.25
32495, 1.125, 0.22826086956522, 0.16666666666667
32496, 1.125, 0.20217391304348, 0.19444444444444
32497, 1.125, 0.22826086956522, 0.11111111111111
32498, 1.125, 0.20217391304348, 0.13888888888889
32499, 1.125, 0.22826086956522, 0.055555555555556
32500, 1.125, 0.20217391304348, 0.083333333333333
32501, 1.125, 0.20217391304348, 0.027777777777778
32502, 1.125, 0.17608695652174, 0.44444444444444
32503, 1.125, 0.17608695652174, 0.38888888888889
32504, 1.125, 0.17608695652174, 0.33333333333333
32505, 1.125, 0.17608695652174, 0.27777777777778
32506, 1.125, 0.17608695652174, 0.22222222222222
32507, 1.125, 0.17608695652174, 0.16666666666667
32508, 1.125, 0.17608695652174, 0.11111111111111
32509, 1.125, 0.17608695652174, 0.055555555555556
32510, 0.95652173913043, 1.375, 0
32511, 0.91304347826087, 1.375, 0
32512, 0.8695652173913, 1.375, 0
32513, 0.82608695652174, 1.375, 0
32514, 0.78260869565217, 1.375, 0
32515, 0.73913043478261, 1.375, 0
32516, 0.69565217391304, 1.375, 0
32517, 0.65217391304348, 1.375, 0
32518, 0.60869565217391, 1.375, 0
32519, 0.56521739130435, 1.375, 0
32520, 0.52173913043478, 1.375, 0
32521, 0.47826086956522, 1.375, 0
32522, 0.43478260869565, 1.375, 0
32523, 0.39130434782609, 1.375, 0
32524, 0.34782608695652, 1.375, 0
32525, 0.30434782608696, 1.375, 0
32526, 0.26086956521739, 1.375, 0
32527, 0.21739130434783, 1.375, 0
32528, 0.17391304347826, 1.375, 0
32529, 0.1304347826087, 1.375, 0
32530, 0.08695652173913, 1.375, 0
32531, 0.043478260869565, 1.375, 0
32532, 0.97826086956522, 1.375, 0
32533, 0.95652173913043, 1.3875, 0
32534, 0.93478260869565, 1.375, 0
32535, 0.91304347826087, 1.3875, 0
32536, 0.89130434782609, 1.375, 0
32537, 0.8695652173913, 1.3875, 0
32538, 0.84782608695652, 1.375, 0
32539, 0.82608695652174, 1.3875, 0
32540, 0.80434782608696, 1.375, 0
32541, 0.78260869565217, 1.3875, 0
32542, 0.76086956521739, 1.375, 0
32543, 0.73913043478261, 1.3875, 0
32544, 0.71739130434783, 1.375, 0
32545, 0.69565217391304, 1.3875, 0
32546, 0.67391304347826, 1.375, 0
32547, 0.65217391304348, 1.3875, 0
32548, 0.6304347826087, 1.375, 0
32549, 0.60869565217391, 1.3875, 0
32550, 0.58695652173913, 1.375, 0
32551, 0.56521739130435, 1.3875, 0
32552, 0.54347826086957, 1.375, 0
32553, 0.52173913043478, 1.3875, 0
32554, 0.5, 1.375, 0
32555, 0.47826086956522, 1.3875, 0
32556, 0.45652173913043, 1.375, 0
32557, 0.43478260869565, 1.3875, 0
32558, 0.41304347826087, 1.375, 0
32559, 0.39130434782609, 1.3875, 0
32560, 0.3695652173913, 1.375, 0
32561, 0.34782608695652, 1.3875, 0
32562, 0.32608695652174, 1.375, 0
32563, 0.30434782608696, 1.3875, 0
32564, 0.28260869565217, 1.375, 0
32565, 0.26086956521739, 1.3875, 0
32566, 0.23913043478261, 1.375, 0
32567, 0.21739130434783, 1.3875, 0
32568, 0.19565217391304, 1.375, 0
32569, 0.17391304347826, 1.3875, 0
32570, 0.15217391304348, 1.375, 0
32571, 0.1304347826087, 1.3875, 0
32572, 0.10869565217391, 1.375, 0
32573, 0.08695652173913, 1.3875, 0
32574, 0.065217391304348, 1.375, 0
32575, 0.043478260869565, 1.3875, 0
32576, 0.021739130434783, 1.375, 0
32577, 0.95652173913043, 1.3625, 0
32578, 0.91304347826087, 1.3625, 0
32579, 0.8695652173913, 1.3625, 0
32580, 0.82608695652174, 1.3625, 0
32581, 0.78260869565217, 1.3625, 0
32582, 0.73913043478261, 1.3625, 0
32583, 0.69565217391304, 1.3625, 0
32584, 0.65217391304348, 1.3625, 0
32585, 0.60869565217391, 1.3625, 0
32586, 0.56521739130435, 1.3625, 0
32587, 0.52173913043478, 1.3625, 0
32588, 0.47826086956522, 1.3625, 0
32589, 0.43478260869565, 1.3625, 0
32590, 0.39130434782609, 1.3625, 0
32591, 0.34782608695652, 1.3625, 0
32592, 0.30434782608696, 1.3625, 0
32593, 0.26086956521739, 1.3625, 0
32594, 0.21739130434783, 1.3625, 0
32595, 0.17391304347826, 1.3625, 0
32596, 0.1304347826087, 1.3625, 0
32597, 0.08695652173913, 1.3625, 0
32598, 0.043478260869565, 1.3625, 0
32599, 1, 1.375, 0.44444444444444
32600, 1, 1.375, 0.38888888888889
32601, 1, 1.375, 0.33333333333333
32602, 1, 1.375, 0.27777777777778
32603, 1, 1.375, 0.22222222222222
32604, 1, 1.375, 0.16666666666667
32605, 1, 1.375, 0.11111111111111
32606, 1, 1.375, 0.055555555555556
32607, 1, 1.375, 0.47222222222222
32608, 1, 1.3875, 0.44444444444444
32609, 1, 1.375, 0.41666666666667
32610, 1, 1.3875, 0.38888888888889
32611, 1, 1.375, 0.36111111111111
32612, 1, 1.3875, 0.33333333333333
32613, 1, 1.375, 0.30555555555556
32614, 1, 1.3875, 0.27777777777778
32615, 1, 1.375, 0.25
32616, 1, 1.3875, 0.22222222222222
32617, 1, 1.375, 0.19444444444444
32618, 1, 1.3875, 0.16666666666667
32619, 1, 1.375, 0.13888888888889
32620, 1, 1.3875, 0.11111111111111
32621, 1, 1.375, 0.083333333333333
32622, 1, 1.3875, 0.055555555555556
32623, 1, 1.375, 0.027777777777778
32624, 1, 1.3625, 0.44444444444444
32625, 1, 1.3625, 0.38888888888889
32626, 1, 1.3625, 0.33333333333333
32627, 1, 1.3625, 0.27777777777778
32628, 1, 1.3625, 0.22222222222222
32629, 1, 1.3625, 0.16666666666667
32630, 1, 1.3625, 0.11111111111111
32631, 1, 1.3625, 0.055555555555556
32632, 0.95652173913043, 1.375, 0.5
32633, 0.91304347826087, 1.375, 0.5
32634, 0.8695652173913, 1.375, 0.5
32635, 0.82608695652174, 1.375, 0.5
32636, 0.78260869565217, 1.375, 0.5
32637, 0.73913043478261, 1.375, 0.5
32638, 0.69565217391304, 1.375, 0.5
32639, 0.65217391304348, 1.375, 0.5
32640, 0.60869565217391, 1.375, 0.5
32641, 0.56521739130435, 1.375, 0.5
32642, 0.52173913043478, 1.375, 0.5
32643, 0.47826086956522, 1.375, 0.5
32644, 0.43478260869565, 1.375, 0.5
32645, 0.39130434782609, 1.375, 0.5
32646, 0.34782608695652, 1.375, 0.5
32647, 0.30434782608696, 1.375, 0.5
32648, 0.26086956521739, 1.375, 0.5
32649, 0.21739130434783, 1.375, 0.5
32650, 0.17391304347826, 1.375, 0.5
32651, 0.1304347826087, 1.375, 0.5
32652, 0.08695652173913, 1.375, 0.5
32653, 0.043478260869565, 1.375, 0.5
32654, 0.95652173913043, 1.3875, 0.5
32655, 0.97826086956522, 1.375, 0.5
32656, 0.91304347826087, 1.3875, 0.5
32657, 0.93478260869565, 1.375, 0.5
32658, 0.8695652173913, 1.3875, 0.5
32659, 0.89130434782609, 1.375, 0.5
32660, 0.82608695652174, 1.3875, 0.5
32661, 0.84782608695652, 1.375, 0.5
32662, 0.78260869565217, 1.3875, 0.5
32663, 0.80434782608696, 1.375, 0.5
32664, 0.73913043478261, 1.3875, 0.5
32665, 0.76086956521739, 1.375, 0.5
32666, 0.69565217391304, 1.3875, 0.5
32667, 0.71739130434783, 1.375, 0.5
32668, 0.65217391304348, 1.3875, 0.5
32669, 0.67391304347826, 1.375, 0.5
32670, 0.60869565217391, 1.3875, 0.5
32671, 0.6304347826087, 1.375, 0.5
32672, 0.56521739130435, 1.3875, 0.5
32673, 0.58695652173913, 1.375, 0.5
32674, 0.52173913043478, 1.3875, 0.5
32675, 0.54347826086957, 1.375, 0.5
32676, 0.47826086956522, 1.3875, 0.5
32677, 0.5, 1.375, 0.5
32678, 0.43478260869565, 1.3875, 0.5
32679, 0.45652173913043, 1.375, 0.5
32680, 0.39130434782609, 1.3875, 0.5
32681, 0.41304347826087, 1.375, 0.5
32682, 0.34782608695652, 1.3875, 0.5
32683, 0.3695652173913, 1.375, 0.5
32684, 0.30434782608696, 1.3875, 0.5
32685, 0.32608695652174, 1.375, 0.5
32686, 0.26086956521739, 1.3875, 0.5
32687, 0.28260869565217, 1.375, 0.5
32688, 0.21739130434783, 1.3875, 0.5
32689, 0.23913043478261, 1.375, 0.5
32690, 0.17391304347826, 1.3875, 0.5
32691, 0.19565217391304, 1.375, 0.5
32692, 0.1304347826087, 1.3875, 0.5
32693, 0.15217391304348, 1.375, 0.5
32694, 0.08695652173913, 1.3875, 0.5
32695, 0.10869565217391, 1.375, 0.5
32696, 0.043478260869565, 1.3875, 0.5
32697, 0.065217391304348, 1.375, 0.5
32698, 0.021739130434783, 1.375, 0.5
32699, 0.95652173913043, 1.3625, 0.5
32700, 0.91304347826087, 1.3625, 0.5
32701, 0.8695652173913, 1.3625, 0.5
32702, 0.82608695652174, 1.3625, 0.5
32703, 0.78260869565217, 1.3625, 0.5
32704, 0.73913043478261, 1.3625, 0.5
32705, 0.69565217391304, 1.3625, 0.5
32706, 0.65217391304348, 1.3625, 0.5
32707, 0.60869565217391, 1.3625, 0.5
32708, 0.56521739130435, 1.3625, 0.5
32709, 0.52173913043478, 1.3625, 0.5
32710, 0.47826086956522, 1.3625, 0.5
32711, 0.43478260869565, 1.3625, 0.5
32712, 0.39130434782609, 1.3625, 0.5
32713, 0.34782608695652, 1.3625, 0.5
32714, 0.30434782608696, 1.3625, 0.5
32715, 0.26086956521739, 1.3625, 0.5
32716, 0.21739130434783, 1.3625, 0.5
32717, 0.17391304347826, 1.3625, 0.5
32718, 0.1304347826087, 1.3625, 0.5
32719, 0.08695652173913, 1.3625, 0.5
32720, 0.043478260869565, 1.3625, 0.5
32721, 0, 1.375, 0.44444444444444
32722, 0, 1.375, 0.38888888888889
32723, 0, 1.375, 0.33333333333333
32724, 0, 1.375, 0.27777777777778
32725, 0, 1.375, 0.22222222222222
32726, 0, 1.375, 0.16666666666667
32727, 0, 1.375, 0.11111111111111
32728, 0, 1.375, 0.055555555555556
32729, 0, 1.3875, 0.44444444444444
32730, 0, 1.375, 0.47222222222222
32731, 0, 1.3875, 0.38888888888889
32732, 0, 1.375, 0.41666666666667
32733, 0, 1.3875, 0.33333333333333
32734, 0, 1.375, 0.36111111111111
32735, 0, 1.3875, 0.27777777777778
32736, 0, 1.375, 0.30555555555556
32737, 0, 1.3875, 0.22222222222222
32738, 0, 1.375, 0.25
32739, 0, 1.3875, 0.16666666666667
32740, 0, 1.375, 0.19444444444444
32741, 0, 1.3875, 0.11111111111111
32742, 0, 1.375, 0.13888888888889
32743, 0, 1.3875, 0.055555555555556
32744, 0, 1.375, 0.083333333333333
32745, 0, 1.375, 0.027777777777778
32746, 0, 1.3625, 0.44444444444444
32747, 0, 1.3625, 0.38888888888889
32748, 0, 1.3625, 0.33333333333333
32749, 0, 1.3625, 0.27777777777778
32750, 0, 1.3625, 0.22222222222222
32751, 0, 1.3625, 0.16666666666667
32752, 0, 1.3625, 0.11111111111111
32753, 0, 1.3625, 0.055555555555556
32754, 1.2434782608696, 1.375, 0.5
32755, 1.2869565217391, 1.375, 0.5
32756, 1.3304347826087, 1.375, 0.5
32757, 1.3739130434783, 1.375, 0.5
32758, 1.4173913043478, 1.375, 0.5
32759, 1.4608695652174, 1.375, 0.5
32760, 1.504347826087, 1.375, 0.5
32761, 1.5478260869565, 1.375, 0.5
32762, 1.5913043478261, 1.375, 0.5
32763, 1.6347826086957, 1.375, 0.5
32764, 1.6782608695652, 1.375, 0.5
32765, 1.7217391304348, 1.375, 0.5
32766, 1.7652173913043, 1.375, 0.5
32767, 1.8086956521739, 1.375, 0.5
32768, 1.8521739130435, 1.375, 0.5
32769, 1.895652173913, 1.375, 0.5
32770, 1.9391304347826, 1.375, 0.5
32771, 1.9826086956522, 1.375, 0.5
32772, 2.0260869565217, 1.375, 0.5
32773, 2.0695652173913, 1.375, 0.5
32774, 2.1130434782609, 1.375, 0.5
32775, 2.1565217391304, 1.375, 0.5
32776, 1.2217391304348, 1.375, 0.5
32777, 1.2434782608696, 1.3875, 0.5
32778, 1.2652173913043, 1.375, 0.5
32779, 1.2869565217391, 1.3875, 0.5
32780, 1.3086956521739, 1.375, 0.5
32781, 1.3304347826087, 1.3875, 0.5
32782, 1.3521739130435, 1.375, 0.5
32783, 1.3739130434783, 1.3875, 0.5
32784, 1.395652173913, 1.375, 0.5
32785, 1.4173913043478, 1.3875, 0.5
32786, 1.4391304347826, 1.375, 0.5
32787, 1.4608695652174, 1.3875, 0.5
32788, 1.4826086956522, 1.375, 0.5
32789, 1.504347826087, 1.3875, 0.5
32790, 1.5260869565217, 1.375, 0.5
32791, 1.5478260869565, 1.3875, 0.5
32792, 1.5695652173913, 1.375, 0.5
32793, 1.5913043478261, 1.3875, 0.5
32794, 1.6130434782609, 1.375, 0.5
32795, 1.6347826086957, 1.3875, 0.5
32796, 1.6565217391304, 1.375, 0.5
32797, 1.6782608695652, 1.3875, 0.5
32798, 1.7, 1.375, 0.5
32799, 1.7217391304348, 1.3875, 0.5
32800, 1.7434782608696, 1.375, 0.5
32801, 1.7652173913043, 1.3875, 0.5
32802, 1.7869565217391, 1.375, 0.5
32803, 1.8086956521739, 1.3875, 0.5
32804, 1.8304347826087, 1.375, 0.5
32805, 1.8521739130435, 1.3875, 0.5
32806, 1.8739130434783, 1.375, 0.5
32807, 1.895652173913, 1.3875, 0.5
32808, 1.9173913043478, 1.375, 0.5
32809, 1.9391304347826, 1.3875, 0.5
32810, 1.9608695652174, 1.375, 0.5
32811, 1.9826086956522, 1.3875, 0.5
32812, 2.004347826087, 1.375, 0.5
32813, 2.0260869565217, 1.3875, 0.5
32814, 2.0478260869565, 1.375, 0.5
32815, 2.0695652173913, 1.3875, 0.5
32816, 2.0913043478261, 1.375, 0.5
32817, 2.1130434782609, 1.3875, 0.5
32818, 2.1347826086957, 1.375, 0.5
32819, 2.1565217391304, 1.3875, 0.5
32820, 2.1782608695652, 1.375, 0.5
32821, 1.2434782608696, 1.3625, 0.5
32822, 1.2869565217391, 1.3625, 0.5
32823, 1.3304347826087, 1.3625, 0.5
32824, 1.3739130434783, 1.3625, 0.5
32825, 1.4173913043478, 1.3625, 0.5
32826, 1.4608695652174, 1.3625, 0.5
32827, 1.504347826087, 1.3625, 0.5
32828, 1.5478260869565, 1.3625, 0.5
32829, 1.5913043478261, 1.3625, 0.5
32830, 1.6347826086957, 1.3625, 0.5
32831, 1.6782608695652, 1.3625, 0.5
32832, 1.7217391304348, 1.3625, 0.5
32833, 1.7652173913043, 1.3625, 0.5
32834, 1.8086956521739, 1.3625, 0.5
32835, 1.8521739130435, 1.3625, 0.5
32836, 1.895652173913, 1.3625, 0.5
32837, 1.9391304347826, 1.3625, 0.5
32838, 1.9826086956522, 1.3625, 0.5
32839, 2.0260869565217, 1.3625, 0.5
32840, 2.0695652173913, 1.3625, 0.5
32841, 2.1130434782609, 1.3625, 0.5
32842, 2.1565217391304, 1.3625, 0.5
32843, 1.2434782608696, 1.375, 0
32844, 1.2869565217391, 1.375, 0
32845, 1.3304347826087, 1.375, 0
32846, 1.3739130434783, 1.375, 0
32847, 1.4173913043478, 1.375, 0
32848, 1.4608695652174, 1.375, 0
32849, 1.504347826087, 1.375, 0
32850, 1.5478260869565, 1.375, 0
32851, 1.5913043478261, 1.375, 0
32852, 1.6347826086957, 1.375, 0
32853, 1.6782608695652, 1.375, 0
32854, 1.7217391304348, 1.375, 0
32855, 1.7652173913043, 1.375, 0
32856, 1.8086956521739, 1.375, 0
32857, 1.8521739130435, 1.375, 0
32858, 1.895652173913, 1.375, 0
32859, 1.9391304347826, 1.375, 0
32860, 1.9826086956522, 1.375, 0
32861, 2.0260869565217, 1.375, 0
32862, 2.0695652173913, 1.375, 0
32863, 2.1130434782609, 1.375, 0
32864, 2.1565217391304, 1.375, 0
32865, 1.2434782608696, 1.3875, 0
32866, 1.2217391304348, 1.375, 0
32867, 1.2869565217391, 1.3875, 0
32868, 1.2652173913043, 1.375, 0
32869, 1.3304347826087, 1.3875, 0
32870, 1.3086956521739, 1.375, 0
32871, 1.3739130434783, 1.3875, 0
32872, 1.3521739130435, 1.375, 0
32873, 1.4173913043478, 1.3875, 0
32874, 1.395652173913, 1.375, 0
32875, 1.4608695652174, 1.3875, 0
32876, 1.4391304347826, 1.375, 0
32877, 1.504347826087, 1.3875, 0
32878, 1.4826086956522, 1.375, 0
32879, 1.5478260869565, 1.3875, 0
32880, 1.5260869565217, 1.375, 0
32881, 1.5913043478261, 1.3875, 0
32882, 1.5695652173913, 1.375, 0
32883, 1.6347826086957, 1.3875, 0
32884, 1.6130434782609, 1.375, 0
32885, 1.6782608695652, 1.3875, 0
32886, 1.6565217391304, 1.375, 0
32887, 1.7217391304348, 1.3875, 0
32888, 1.7, 1.375, 0
32889, 1.7652173913043, 1.3875, 0
32890, 1.7434782608696, 1.375, 0
32891, 1.8086956521739, 1.3875, 0
32892, 1.7869565217391, 1.375, 0
32893, 1.8521739130435, 1.3875, 0
32894, 1.8304347826087, 1.375, 0
32895, 1.895652173913, 1.3875, 0
32896, 1.8739130434783, 1.375, 0
32897, 1.9391304347826, 1.3875, 0
32898, 1.9173913043478, 1.375, 0
32899, 1.9826086956522, 1.3875, 0
32900, 1.9608695652174, 1.375, 0
32901, 2.0260869565217, 1.3875, 0
32902, 2.004347826087, 1.375, 0
32903, 2.0695652173913, 1.3875, 0
32904, 2.0478260869565, 1.375, 0
32905, 2.1130434782609, 1.3875, 0
32906, 2.0913043478261, 1.375, 0
32907, 2.1565217391304, 1.3875, 0
32908, 2.1347826086957, 1.375, 0
32909, 2.1782608695652, 1.375, 0
32910, 1.2434782608696, 1.3625, 0
32911, 1.2869565217391, 1.3625, 0
32912, 1.3304347826087, 1.3625, 0
32913, 1.3739130434783, 1.3625, 0
32914, 1.4173913043478, 1.3625, 0
32915, 1.4608695652174, 1.3625, 0
32916, 1.504347826087, 1.3625, 0
32917, 1.5478260869565, 1.3625, 0
32918, 1.5913043478261, 1.3625, 0
32919, 1.6347826086957, 1.3625, 0
32920, 1.6782608695652, 1.3625, 0
32921, 1.7217391304348, 1.3625, 0
32922, 1.7652173913043, 1.3625, 0
32923, 1.8086956521739, 1.3625, 0
32924, 1.8521739130435, 1.3625, 0
32925, 1.895652173913, 1.3625, 0
32926, 1.9391304347826, 1.3625, 0
32927, 1.9826086956522, 1.3625, 0
32928, 2.0260869565217, 1.3625, 0
32929, 2.0695652173913, 1.3625, 0
32930, 2.1130434782609, 1.3625, 0
32931, 2.1565217391304, 1.3625, 0
32932, 1.2, 1.375, 0.44444444444444
32933, 1.2, 1.375, 0.38888888888889
32934, 1.2, 1.375, 0.33333333333333
32935, 1.2, 1.375, 0.27777777777778
32936, 1.2, 1.375, 0.22222222222222
32937, 1.2, 1.375, 0.16666666666667
32938, 1.2, 1.375, 0.11111111111111
32939, 1.2, 1.375, 0.055555555555556
32940, 1.2, 1.3875, 0.44444444444444
32941, 1.2, 1.375, 0.47222222222222
32942, 1.2, 1.3875, 0.38888888888889
32943, 1.2, 1.375, 0.41666666666667
32944, 1.2, 1.3875, 0.33333333333333
32945, 1.2, 1.375, 0.36111111111111
32946, 1.2, 1.3875, 0.27777777777778
32947, 1.2, 1.375, 0.30555555555556
32948, 1.2, 1.3875, 0.22222222222222
32949, 1.2, 1.375, 0.25
32950, 1.2, 1.3875, 0.16666666666667
32951, 1.2, 1.375, 0.19444444444444
32952, 1.2, 1.3875, 0.11111111111111
32953, 1.2, 1.375, 0.13888888888889
32954, 1.2, 1.3875, 0.055555555555556
32955, 1.2, 1.375, 0.083333333333333
32956, 1.2, 1.375, 0.027777777777778
32957, 1.2, 1.3625, 0.44444444444444
32958, 1.2, 1.3625, 0.38888888888889
32959, 1.2, 1.3625, 0.33333333333333
32960, 1.2, 1.3625, 0.27777777777778
32961, 1.2, 1.3625, 0.22222222222222
32962, 1.2, 1.3625, 0.16666666666667
32963, 1.2, 1.3625, 0.11111111111111
32964, 1.2, 1.3625, 0.055555555555556
32965, 2.2, 1.375, 0.44444444444444
32966, 2.2, 1.375, 0.38888888888889
32967, 2.2, 1.375, 0.33333333333333
32968, 2.2, 1.375, 0.27777777777778
32969, 2.2, 1.375, 0.22222222222222
32970, 2.2, 1.375, 0.16666666666667
32971, 2.2, 1.375, 0.11111111111111
32972, 2.2, 1.375, 0.055555555555556
32973, 2.2, 1.375, 0.47222222222222
32974, 2.2, 1.3875, 0.44444444444444
32975, 2.2, 1.375, 0.41666666666667
32976, 2.2, 1.3875, 0.38888888888889
32977, 2.2, 1.375, 0.36111111111111
32978, 2.2, 1.3875, 0.33333333333333
32979, 2.2, 1.375, 0.30555555555556
32980, 2.2, 1.3875, 0.27777777777778
32981, 2.2, 1.375, 0.25
32982, 2.2, 1.3875, 0.22222222222222
32983, 2.2, 1.375, 0.19444444444444
32984, 2.2, 1.3875, 0.16666666666667
32985, 2.2, 1.375, 0.13888888888889
32986, 2.2, 1.3875, 0.11111111111111
32987, 2.2, 1.375, 0.083333333333333
32988, 2.2, 1.3875, 0.055555555555556
32989, 2.2, 1.375, 0.027777777777778
32990, 2.2, 1.3625, 0.44444444444444
32991, 2.2, 1.3625, 0.38888888888889
32992, 2.2, 1.3625, 0.33333333333333
32993, 2.2, 1.3625, 0.27777777777778
32994, 2.2, 1.3625, 0.22222222222222
32995, 2.2, 1.3625, 0.16666666666667
32996, 2.2, 1.3625, 0.11111111111111
32997, 2.2, 1.3625, 0.055555555555556
32998, 1, 0.20217391304348, -0.0375
32999, 1, 0.25434782608696, -0.0375
33000, 1, 0.30652173913043, -0.0375
33001, 1, 0.35869565217391, -0.0375
33002, 1, 0.41086956521739, -0.0375
33003, 1, 0.46304347826087, -0.0375
33004, 1, 0.51521739130435, -0.0375
33005, 1, 0.56739130434783, -0.0375
33006, 1, 0.6195652173913, -0.0375
33007, 1, 0.67173913043478, -0.0375
33008, 1, 0.72391304347826, -0.0375
33009, 1, 0.77608695652174, -0.0375
33010, 1, 0.82826086956522, -0.0375
33011, 1, 0.8804347826087, -0.0375
33012, 1, 0.93260869565217, -0.0375
33013, 1, 0.98478260869565, -0.0375
33014, 1, 1.0369565217391, -0.0375
33015, 1, 1.0891304347826, -0.0375
33016, 1, 1.1413043478261, -0.0375
33017, 1, 1.1934782608696, -0.0375
33018, 1, 1.245652173913, -0.0375
33019, 1, 1.2978260869565, -0.0375
33020, 1, 0.17608695652174, -0.0375
33021, 1, 0.20217391304348, -0.01875
33022, 1, 0.22826086956522, -0.0375
33023, 1, 0.25434782608696, -0.01875
33024, 1, 0.2804347826087, -0.0375
33025, 1, 0.30652173913043, -0.01875
33026, 1, 0.33260869565217, -0.0375
33027, 1, 0.35869565217391, -0.01875
33028, 1, 0.38478260869565, -0.0375
33029, 1, 0.41086956521739, -0.01875
33030, 1, 0.43695652173913, -0.0375
33031, 1, 0.46304347826087, -0.01875
33032, 1, 0.48913043478261, -0.0375
33033, 1, 0.51521739130435, -0.01875
33034, 1, 0.54130434782609, -0.0375
33035, 1, 0.56739130434783, -0.01875
33036, 1, 0.59347826086956, -0.0375
33037, 1, 0.6195652173913, -0.01875
33038, 1, 0.64565217391304, -0.0375
33039, 1, 0.67173913043478, -0.01875
33040, 1, 0.69782608695652, -0.0375
33041, 1, 0.72391304347826, -0.01875
33042, 1, 0.75, -0.0375
33043, 1, 0.77608695652174, -0.01875
33044, 1, 0.80217391304348, -0.0375
33045, 1, 0.82826086956522, -0.01875
33046, 1, 0.85434782608696, -0.0375
33047, 1, 0.8804347826087, -0.01875
33048, 1, 0.90652173913043, -0.0375
33049, 1, 0.93260869565217, -0.01875
33050, 1, 0.95869565217391, -0.0375
33051, 1, 0.98478260869565, -0.01875
33052, 1, 1.0108695652174, -0.0375
33053, 1, 1.0369565217391, -0.01875
33054, 1, 1.0630434782609, -0.0375
33055, 1, 1.0891304347826, -0.01875
33056, 1, 1.1152173913043, -0.0375
33057, 1, 1.1413043478261, -0.01875
33058, 1, 1.1673913043478, -0.0375
33059, 1, 1.1934782608696, -0.01875
33060, 1, 1.2195652173913, -0.0375
33061, 1, 1.245652173913, -0.01875
33062, 1, 1.2717391304348, -0.0375
33063, 1, 1.2978260869565, -0.01875
33064, 1, 1.3239130434783, -0.0375
33065, 1, 0.20217391304348, -0.05625
33066, 1, 0.25434782608696, -0.05625
33067, 1, 0.30652173913043, -0.05625
33068, 1, 0.35869565217391, -0.05625
33069, 1, 0.41086956521739, -0.05625
33070, 1, 0.46304347826087, -0.05625
33071, 1, 0.51521739130435, -0.05625
33072, 1, 0.56739130434783, -0.05625
33073, 1, 0.6195652173913, -0.05625
33074, 1, 0.67173913043478, -0.05625
33075, 1, 0.72391304347826, -0.05625
33076, 1, 0.77608695652174, -0.05625
33077, 1, 0.82826086956522, -0.05625
33078, 1, 0.8804347826087, -0.05625
33079, 1, 0.93260869565217, -0.05625
33080, 1, 0.98478260869565, -0.05625
33081, 1, 1.0369565217391, -0.05625
33082, 1, 1.0891304347826, -0.05625
33083, 1, 1.1413043478261, -0.05625
33084, 1, 1.1934782608696, -0.05625
33085, 1, 1.245652173913, -0.05625
33086, 1, 1.2978260869565, -0.05625
33087, 0, 0.20217391304348, -0.0375
33088, 0, 0.25434782608696, -0.0375
33089, 0, 0.30652173913043, -0.0375
33090, 0, 0.35869565217391, -0.0375
33091, 0, 0.41086956521739, -0.0375
33092, 0, 0.46304347826087, -0.0375
33093, 0, 0.51521739130435, -0.0375
33094, 0, 0.56739130434783, -0.0375
33095, 0, 0.6195652173913, -0.0375
33096, 0, 0.67173913043478, -0.0375
33097, 0, 0.72391304347826, -0.0375
33098, 0, 0.77608695652174, -0.0375
33099, 0, 0.82826086956522, -0.0375
33100, 0, 0.8804347826087, -0.0375
33101, 0, 0.93260869565217, -0.0375
33102, 0, 0.98478260869565, -0.0375
33103, 0, 1.0369565217391, -0.0375
33104, 0, 1.0891304347826, -0.0375
33105, 0, 1.1413043478261, -0.0375
33106, 0, 1.1934782608696, -0.0375
33107, 0, 1.245652173913, -0.0375
33108, 0, 1.2978260869565, -0.0375
33109, 0, 0.20217391304348, -0.01875
33110, 0, 0.17608695652174, -0.0375
33111, 0, 0.25434782608696, -0.01875
33112, 0, 0.22826086956522, -0.0375
33113, 0, 0.30652173913043, -0.01875
33114, 0, 0.2804347826087, -0.0375
33115, 0, 0.35869565217391, -0.01875
33116, 0, 0.33260869565217, -0.0375
33117, 0, 0.41086956521739, -0.01875
33118, 0, 0.38478260869565, -0.0375
33119, 0, 0.46304347826087, -0.01875
33120, 0, 0.43695652173913, -0.0375
33121, 0, 0.51521739130435, -0.01875
33122, 0, 0.48913043478261, -0.0375
33123, 0, 0.56739130434783, -0.01875
33124, 0, 0.54130434782609, -0.0375
33125, 0, 0.6195652173913, -0.01875
33126, 0, 0.59347826086956, -0.0375
33127, 0, 0.67173913043478, -0.01875
33128, 0, 0.64565217391304, -0.0375
33129, 0, 0.72391304347826, -0.01875
33130, 0, 0.69782608695652, -0.0375
33131, 0, 0.77608695652174, -0.01875
33132, 0, 0.75, -0.0375
33133, 0, 0.82826086956522, -0.01875
33134, 0, 0.80217391304348, -0.0375
33135, 0, 0.8804347826087, -0.01875
33136, 0, 0.85434782608696, -0.0375
33137, 0, 0.93260869565217, -0.01875
33138, 0, 0.90652173913043, -0.0375
33139, 0, 0.98478260869565, -0.01875
33140, 0, 0.95869565217391, -0.0375
33141, 0, 1.0369565217391, -0.01875
33142, 0, 1.0108695652174, -0.0375
33143, 0, 1.0891304347826, -0.01875
33144, 0, 1.0630434782609, -0.0375
33145, 0, 1.1413043478261, -0.01875
33146, 0, 1.1152173913043, -0.0375
33147, 0, 1.1934782608696, -0.01875
33148, 0, 1.1673913043478, -0.0375
33149, 0, 1.245652173913, -0.01875
33150, 0, 1.2195652173913, -0.0375
33151, 0, 1.2978260869565, -0.01875
33152, 0, 1.2717391304348, -0.0375
33153, 0, 1.3239130434783, -0.0375
33154, 0, 0.20217391304348, -0.05625
33155, 0, 0.25434782608696, -0.05625
33156, 0, 0.30652173913043, -0.05625
33157, 0, 0.35869565217391, -0.05625
33158, 0, 0.41086956521739, -0.05625
33159, 0, 0.46304347826087, -0.05625
33160, 0, 0.51521739130435, -0.05625
33161, 0, 0.56739130434783, -0.05625
33162, 0, 0.6195652173913, -0.05625
33163, 0, 0.67173913043478, -0.05625
33164, 0, 0.72391304347826, -0.05625
33165, 0, 0.77608695652174, -0.05625
33166, 0, 0.82826086956522, -0.05625
33167, 0, 0.8804347826087, -0.05625
33168, 0, 0.93260869565217, -0.05625
33169, 0, 0.98478260869565, -0.05625
33170, 0, 1.0369565217391, -0.05625
33171, 0, 1.0891304347826, -0.05625
33172, 0, 1.1413043478261, -0.05625
33173, 0, 1.1934782608696, -0.05625
33174, 0, 1.245652173913, -0.05625
33175, 0, 1.2978260869565, -0.05625
33176, 0.95652173913043, 0.15, -0.0375
33177, 0.91304347826087, 0.15, -0.0375
33178, 0.8695652173913, 0.15, -0.0375
33179, 0.82608695652174, 0.15, -0.0375
33180, 0.78260869565217, 0.15, -0.0375
33181, 0.73913043478261, 0.15, -0.0375
33182, 0.69565217391304, 0.15, -0.0375
33183, 0.65217391304348, 0.15, -0.0375
33184, 0.60869565217391, 0.15, -0.0375
33185, 0.56521739130435, 0.15, -0.0375
33186, 0.52173913043478, 0.15, -0.0375
33187, 0.47826086956522, 0.15, -0.0375
33188, 0.43478260869565, 0.15, -0.0375
33189, 0.39130434782609, 0.15, -0.0375
33190, 0.34782608695652, 0.15, -0.0375
33191, 0.30434782608696, 0.15, -0.0375
33192, 0.26086956521739, 0.15, -0.0375
33193, 0.21739130434783, 0.15, -0.0375
33194, 0.17391304347826, 0.15, -0.0375
33195, 0.1304347826087, 0.15, -0.0375
33196, 0.08695652173913, 0.15, -0.0375
33197, 0.043478260869565, 0.15, -0.0375
33198, 0.95652173913043, 0.15, -0.01875
33199, 0.97826086956522, 0.15, -0.0375
33200, 0.91304347826087, 0.15, -0.01875
33201, 0.93478260869565, 0.15, -0.0375
33202, 0.8695652173913, 0.15, -0.01875
33203, 0.89130434782609, 0.15, -0.0375
33204, 0.82608695652174, 0.15, -0.01875
33205, 0.84782608695652, 0.15, -0.0375
33206, 0.78260869565217, 0.15, -0.01875
33207, 0.80434782608696, 0.15, -0.0375
33208, 0.73913043478261, 0.15, -0.01875
33209, 0.76086956521739, 0.15, -0.0375
33210, 0.69565217391304, 0.15, -0.01875
33211, 0.71739130434783, 0.15, -0.0375
33212, 0.65217391304348, 0.15, -0.01875
33213, 0.67391304347826, 0.15, -0.0375
33214, 0.60869565217391, 0.15, -0.01875
33215, 0.6304347826087, 0.15, -0.0375
33216, 0.56521739130435, 0.15, -0.01875
33217, 0.58695652173913, 0.15, -0.0375
33218, 0.52173913043478, 0.15, -0.01875
33219, 0.54347826086957, 0.15, -0.0375
33220, 0.47826086956522, 0.15, -0.01875
33221, 0.5, 0.15, -0.0375
33222, 0.43478260869565, 0.15, -0.01875
33223, 0.45652173913043, 0.15, -0.0375
33224, 0.39130434782609, 0.15, -0.01875
33225, 0.41304347826087, 0.15, -0.0375
33226, 0.34782608695652, 0.15, -0.01875
33227, 0.3695652173913, 0.15, -0.0375
33228, 0.30434782608696, 0.15, -0.01875
33229, 0.32608695652174, 0.15, -0.0375
33230, 0.26086956521739, 0.15, -0.01875
33231, 0.28260869565217, 0.15, -0.0375
33232, 0.21739130434783, 0.15, -0.01875
33233, 0.23913043478261, 0.15, -0.0375
33234, 0.17391304347826, 0.15, -0.01875
33235, 0.19565217391304, 0.15, -0.0375
33236, 0.1304347826087, 0.15, -0.01875
33237, 0.15217391304348, 0.15, -0.0375
33238, 0.08695652173913, 0.15, -0.01875
33239, 0.10869565217391, 0.15, -0.0375
33240, 0.043478260869565, 0.15, -0.01875
33241, 0.065217391304348, 0.15, -0.0375
33242, 0.021739130434783, 0.15, -0.0375
33243, 0.95652173913043, 0.15, -0.05625
33244, 0.91304347826087, 0.15, -0.05625
33245, 0.8695652173913, 0.15, -0.05625
33246, 0.82608695652174, 0.15, -0.05625
33247, 0.78260869565217, 0.15, -0.05625
33248, 0.73913043478261, 0.15, -0.05625
33249, 0.69565217391304, 0.15, -0.05625
33250, 0.65217391304348, 0.15, -0.05625
33251, 0.60869565217391, 0.15, -0.05625
33252, 0.56521739130435, 0.15, -0.05625
33253, 0.52173913043478, 0.15, -0.05625
33254, 0.47826086956522, 0.15, -0.05625
33255, 0.43478260869565, 0.15, -0.05625
33256, 0.39130434782609, 0.15, -0.05625
33257, 0.34782608695652, 0.15, -0.05625
33258, 0.30434782608696, 0.15, -0.05625
33259, 0.26086956521739, 0.15, -0.05625
33260, 0.21739130434783, 0.15, -0.05625
33261, 0.17391304347826, 0.15, -0.05625
33262, 0.1304347826087, 0.15, -0.05625
33263, 0.08695652173913, 0.15, -0.05625
33264, 0.043478260869565, 0.15, -0.05625
33265, 0.043478260869565, 1.35, -0.0375
33266, 0.08695652173913, 1.35, -0.0375
33267, 0.1304347826087, 1.35, -0.0375
33268, 0.17391304347826, 1.35, -0.0375
33269, 0.21739130434783, 1.35, -0.0375
33270, 0.26086956521739, 1.35, -0.0375
33271, 0.30434782608696, 1.35, -0.0375
33272, 0.34782608695652, 1.35, -0.0375
33273, 0.39130434782609, 1.35, -0.0375
33274, 0.43478260869565, 1.35, -0.0375
33275, 0.47826086956522, 1.35, -0.0375
33276, 0.52173913043478, 1.35, -0.0375
33277, 0.56521739130435, 1.35, -0.0375
33278, 0.60869565217391, 1.35, -0.0375
33279, 0.65217391304348, 1.35, -0.0375
33280, 0.69565217391304, 1.35, -0.0375
33281, 0.73913043478261, 1.35, -0.0375
33282, 0.78260869565217, 1.35, -0.0375
33283, 0.82608695652174, 1.35, -0.0375
33284, 0.8695652173913, 1.35, -0.0375
33285, 0.91304347826087, 1.35, -0.0375
33286, 0.95652173913043, 1.35, -0.0375
33287, 0.043478260869565, 1.35, -0.01875
33288, 0.021739130434783, 1.35, -0.0375
33289, 0.08695652173913, 1.35, -0.01875
33290, 0.065217391304348, 1.35, -0.0375
33291, 0.1304347826087, 1.35, -0.01875
33292, 0.10869565217391, 1.35, -0.0375
33293, 0.17391304347826, 1.35, -0.01875
33294, 0.15217391304348, 1.35, -0.0375
33295, 0.21739130434783, 1.35, -0.01875
33296, 0.19565217391304, 1.35, -0.0375
33297, 0.26086956521739, 1.35, -0.01875
33298, 0.23913043478261, 1.35, -0.0375
33299, 0.30434782608696, 1.35, -0.01875
33300, 0.28260869565217, 1.35, -0.0375
33301, 0.34782608695652, 1.35, -0.01875
33302, 0.32608695652174, 1.35, -0.0375
33303, 0.39130434782609, 1.35, -0.01875
33304, 0.3695652173913, 1.35, -0.0375
33305, 0.43478260869565, 1.35, -0.01875
33306, 0.41304347826087, 1.35, -0.0375
33307, 0.47826086956522, 1.35, -0.01875
33308, 0.45652173913043, 1.35, -0.0375
33309, 0.52173913043478, 1.35, -0.01875
33310, 0.5, 1.35, -0.0375
33311, 0.56521739130435, 1.35, -0.01875
33312, 0.54347826086957, 1.35, -0.0375
33313, 0.60869565217391, 1.35, -0.01875
33314, 0.58695652173913, 1.35, -0.0375
33315, 0.65217391304348, 1.35, -0.01875
33316, 0.6304347826087, 1.35, -0.0375
33317, 0.69565217391304, 1.35, -0.01875
33318, 0.67391304347826, 1.35, -0.0375
33319, 0.73913043478261, 1.35, -0.01875
33320, 0.71739130434783, 1.35, -0.0375
33321, 0.78260869565217, 1.35, -0.01875
33322, 0.76086956521739, 1.35, -0.0375
33323, 0.82608695652174, 1.35, -0.01875
33324, 0.80434782608696, 1.35, -0.0375
33325, 0.8695652173913, 1.35, -0.01875
33326, 0.84782608695652, 1.35, -0.0375
33327, 0.91304347826087, 1.35, -0.01875
33328, 0.89130434782609, 1.35, -0.0375
33329, 0.95652173913043, 1.35, -0.01875
33330, 0.93478260869565, 1.35, -0.0375
33331, 0.97826086956522, 1.35, -0.0375
33332, 0.043478260869565, 1.35, -0.05625
33333, 0.08695652173913, 1.35, -0.05625
33334, 0.1304347826087, 1.35, -0.05625
33335, 0.17391304347826, 1.35, -0.05625
33336, 0.21739130434783, 1.35, -0.05625
33337, 0.26086956521739, 1.35, -0.05625
33338, 0.30434782608696, 1.35, -0.05625
33339, 0.34782608695652, 1.35, -0.05625
33340, 0.39130434782609, 1.35, -0.05625
33341, 0.43478260869565, 1.35, -0.05625
33342, 0.47826086956522, 1.35, -0.05625
33343, 0.52173913043478, 1.35, -0.05625
33344, 0.56521739130435, 1.35, -0.05625
33345, 0.60869565217391, 1.35, -0.05625
33346, 0.65217391304348, 1.35, -0.05625
33347, 0.69565217391304, 1.35, -0.05625
33348, 0.73913043478261, 1.35, -0.05625
33349, 0.78260869565217, 1.35, -0.05625
33350, 0.82608695652174, 1.35, -0.05625
33351, 0.8695652173913, 1.35, -0.05625
33352, 0.91304347826087, 1.35, -0.05625
33353, 0.95652173913043, 1.35, -0.05625
33354, 0.95652173913043, 0.20217391304348, -0.075
33355, 0.91304347826087, 0.20217391304348, -0.075
33356, 0.8695652173913, 0.20217391304348, -0.075
33357, 0.82608695652174, 0.20217391304348, -0.075
33358, 0.78260869565217, 0.20217391304348, -0.075
33359, 0.73913043478261, 0.20217391304348, -0.075
33360, 0.69565217391304, 0.20217391304348, -0.075
33361, 0.65217391304348, 0.20217391304348, -0.075
33362, 0.60869565217391, 0.20217391304348, -0.075
33363, 0.56521739130435, 0.20217391304348, -0.075
33364, 0.52173913043478, 0.20217391304348, -0.075
33365, 0.47826086956522, 0.20217391304348, -0.075
33366, 0.43478260869565, 0.20217391304348, -0.075
33367, 0.39130434782609, 0.20217391304348, -0.075
33368, 0.34782608695652, 0.20217391304348, -0.075
33369, 0.30434782608696, 0.20217391304348, -0.075
33370, 0.26086956521739, 0.20217391304348, -0.075
33371, 0.21739130434783, 0.20217391304348, -0.075
33372, 0.17391304347826, 0.20217391304348, -0.075
33373, 0.1304347826087, 0.20217391304348, -0.075
33374, 0.08695652173913, 0.20217391304348, -0.075
33375, 0.043478260869565, 0.20217391304348, -0.075
33376, 0.95652173913043, 0.25434782608696, -0.075
33377, 0.91304347826087, 0.25434782608696, -0.075
33378, 0.8695652173913, 0.25434782608696, -0.075
33379, 0.82608695652174, 0.25434782608696, -0.075
33380, 0.78260869565217, 0.25434782608696, -0.075
33381, 0.73913043478261, 0.25434782608696, -0.075
33382, 0.69565217391304, 0.25434782608696, -0.075
33383, 0.65217391304348, 0.25434782608696, -0.075
33384, 0.60869565217391, 0.25434782608696, -0.075
33385, 0.56521739130435, 0.25434782608696, -0.075
33386, 0.52173913043478, 0.25434782608696, -0.075
33387, 0.47826086956522, 0.25434782608696, -0.075
33388, 0.43478260869565, 0.25434782608696, -0.075
33389, 0.39130434782609, 0.25434782608696, -0.075
33390, 0.34782608695652, 0.25434782608696, -0.075
33391, 0.30434782608696, 0.25434782608696, -0.075
33392, 0.26086956521739, 0.25434782608696, -0.075
33393, 0.21739130434783, 0.25434782608696, -0.075
33394, 0.17391304347826, 0.25434782608696, -0.075
33395, 0.1304347826087, 0.25434782608696, -0.075
33396, 0.08695652173913, 0.25434782608696, -0.075
33397, 0.043478260869565, 0.25434782608696, -0.075
33398, 0.95652173913043, 0.30652173913043, -0.075
33399, 0.91304347826087, 0.30652173913043, -0.075
33400, 0.8695652173913, 0.30652173913043, -0.075
33401, 0.82608695652174, 0.30652173913043, -0.075
33402, 0.78260869565217, 0.30652173913043, -0.075
33403, 0.73913043478261, 0.30652173913043, -0.075
33404, 0.69565217391304, 0.30652173913043, -0.075
33405, 0.65217391304348, 0.30652173913043, -0.075
33406, 0.60869565217391, 0.30652173913043, -0.075
33407, 0.56521739130435, 0.30652173913043, -0.075
33408, 0.52173913043478, 0.30652173913043, -0.075
33409, 0.47826086956522, 0.30652173913043, -0.075
33410, 0.43478260869565, 0.30652173913043, -0.075
33411, 0.39130434782609, 0.30652173913043, -0.075
33412, 0.34782608695652, 0.30652173913043, -0.075
33413, 0.30434782608696, 0.30652173913043, -0.075
33414, 0.26086956521739, 0.30652173913043, -0.075
33415, 0.21739130434783, 0.30652173913043, -0.075
33416, 0.17391304347826, 0.30652173913043, -0.075
33417, 0.1304347826087, 0.30652173913043, -0.075
33418, 0.08695652173913, 0.30652173913043, -0.075
33419, 0.043478260869565, 0.30652173913043, -0.075
33420, 0.95652173913043, 0.35869565217391, -0.075
33421, 0.91304347826087, 0.35869565217391, -0.075
33422, 0.8695652173913, 0.35869565217391, -0.075
33423, 0.82608695652174, 0.35869565217391, -0.075
33424, 0.78260869565217, 0.35869565217391, -0.075
33425, 0.73913043478261, 0.35869565217391, -0.075
33426, 0.69565217391304, 0.35869565217391, -0.075
33427, 0.65217391304348, 0.35869565217391, -0.075
33428, 0.60869565217391, 0.35869565217391, -0.075
33429, 0.56521739130435, 0.35869565217391, -0.075
33430, 0.52173913043478, 0.35869565217391, -0.075
33431, 0.47826086956522, 0.35869565217391, -0.075
33432, 0.43478260869565, 0.35869565217391, -0.075
33433, 0.39130434782609, 0.35869565217391, -0.075
33434, 0.34782608695652, 0.35869565217391, -0.075
33435, 0.30434782608696, 0.35869565217391, -0.075
33436, 0.26086956521739, 0.35869565217391, -0.075
33437, 0.21739130434783, 0.35869565217391, -0.075
33438, 0.17391304347826, 0.35869565217391, -0.075
33439, 0.1304347826087, 0.35869565217391, -0.075
33440, 0.08695652173913, 0.35869565217391, -0.075
33441, 0.043478260869565, 0.35869565217391, -0.075
33442, 0.95652173913043, 0.41086956521739, -0.075
33443, 0.91304347826087, 0.41086956521739, -0.075
33444, 0.8695652173913, 0.41086956521739, -0.075
33445, 0.82608695652174, 0.41086956521739, -0.075
33446, 0.78260869565217, 0.41086956521739, -0.075
33447, 0.73913043478261, 0.41086956521739, -0.075
33448, 0.69565217391304, 0.41086956521739, -0.075
33449, 0.65217391304348, 0.41086956521739, -0.075
33450, 0.60869565217391, 0.41086956521739, -0.075
33451, 0.56521739130435, 0.41086956521739, -0.075
33452, 0.52173913043478, 0.41086956521739, -0.075
33453, 0.47826086956522, 0.41086956521739, -0.075
33454, 0.43478260869565, 0.41086956521739, -0.075
33455, 0.39130434782609, 0.41086956521739, -0.075
33456, 0.34782608695652, 0.41086956521739, -0.075
33457, 0.30434782608696, 0.41086956521739, -0.075
33458, 0.26086956521739, 0.41086956521739, -0.075
33459, 0.21739130434783, 0.41086956521739, -0.075
33460, 0.17391304347826, 0.41086956521739, -0.075
33461, 0.1304347826087, 0.41086956521739, -0.075
33462, 0.08695652173913, 0.41086956521739, -0.075
33463, 0.043478260869565, 0.41086956521739, -0.075
33464, 0.95652173913043, 0.46304347826087, -0.075
33465, 0.91304347826087, 0.46304347826087, -0.075
33466, 0.8695652173913, 0.46304347826087, -0.075
33467, 0.82608695652174, 0.46304347826087, -0.075
33468, 0.78260869565217, 0.46304347826087, -0.075
33469, 0.73913043478261, 0.46304347826087, -0.075
33470, 0.69565217391304, 0.46304347826087, -0.075
33471, 0.65217391304348, 0.46304347826087, -0.075
33472, 0.60869565217391, 0.46304347826087, -0.075
33473, 0.56521739130435, 0.46304347826087, -0.075
33474, 0.52173913043478, 0.46304347826087, -0.075
33475, 0.47826086956522, 0.46304347826087, -0.075
33476, 0.43478260869565, 0.46304347826087, -0.075
33477, 0.39130434782609, 0.46304347826087, -0.075
33478, 0.34782608695652, 0.46304347826087, -0.075
33479, 0.30434782608696, 0.46304347826087, -0.075
33480, 0.26086956521739, 0.46304347826087, -0.075
33481, 0.21739130434783, 0.46304347826087, -0.075
33482, 0.17391304347826, 0.46304347826087, -0.075
33483, 0.1304347826087, 0.46304347826087, -0.075
33484, 0.08695652173913, 0.46304347826087, -0.075
33485, 0.043478260869565, 0.46304347826087, -0.075
33486, 0.95652173913043, 0.51521739130435, -0.075
33487, 0.91304347826087, 0.51521739130435, -0.075
33488, 0.8695652173913, 0.51521739130435, -0.075
33489, 0.82608695652174, 0.51521739130435, -0.075
33490, 0.78260869565217, 0.51521739130435, -0.075
33491, 0.73913043478261, 0.51521739130435, -0.075
33492, 0.69565217391304, 0.51521739130435, -0.075
33493, 0.65217391304348, 0.51521739130435, -0.075
33494, 0.60869565217391, 0.51521739130435, -0.075
33495, 0.56521739130435, 0.51521739130435, -0.075
33496, 0.52173913043478, 0.51521739130435, -0.075
33497, 0.47826086956522, 0.51521739130435, -0.075
33498, 0.43478260869565, 0.51521739130435, -0.075
33499, 0.39130434782609, 0.51521739130435, -0.075
33500, 0.34782608695652, 0.51521739130435, -0.075
33501, 0.30434782608696, 0.51521739130435, -0.075
33502, 0.26086956521739, 0.51521739130435, -0.075
33503, 0.21739130434783, 0.51521739130435, -0.075
33504, 0.17391304347826, 0.51521739130435, -0.075
33505, 0.1304347826087, 0.51521739130435, -0.075
33506, 0.08695652173913, 0.51521739130435, -0.075
33507, 0.043478260869565, 0.51521739130435, -0.075
33508, 0.95652173913043, 0.56739130434783, -0.075
33509, 0.91304347826087, 0.56739130434783, -0.075
33510, 0.8695652173913, 0.56739130434783, -0.075
33511, 0.82608695652174, 0.56739130434783, -0.075
33512, 0.78260869565217, 0.56739130434783, -0.075
33513, 0.73913043478261, 0.56739130434783, -0.075
33514, 0.69565217391304, 0.56739130434783, -0.075
33515, 0.65217391304348, 0.56739130434783, -0.075
33516, 0.60869565217391, 0.56739130434783, -0.075
33517, 0.56521739130435, 0.56739130434783, -0.075
33518, 0.52173913043478, 0.56739130434783, -0.075
33519, 0.47826086956522, 0.56739130434783, -0.075
33520, 0.43478260869565, 0.56739130434783, -0.075
33521, 0.39130434782609, 0.56739130434783, -0.075
33522, 0.34782608695652, 0.56739130434783, -0.075
33523, 0.30434782608696, 0.56739130434783, -0.075
33524, 0.26086956521739, 0.56739130434783, -0.075
33525, 0.21739130434783, 0.56739130434783, -0.075
33526, 0.17391304347826, 0.56739130434783, -0.075
33527, 0.1304347826087, 0.56739130434783, -0.075
33528, 0.08695652173913, 0.56739130434783, -0.075
33529, 0.043478260869565, 0.56739130434783, -0.075
33530, 0.95652173913043, 0.6195652173913, -0.075
33531, 0.91304347826087, 0.6195652173913, -0.075
33532, 0.8695652173913, 0.6195652173913, -0.075
33533, 0.82608695652174, 0.6195652173913, -0.075
33534, 0.78260869565217, 0.6195652173913, -0.075
33535, 0.73913043478261, 0.6195652173913, -0.075
33536, 0.69565217391304, 0.6195652173913, -0.075
33537, 0.65217391304348, 0.6195652173913, -0.075
33538, 0.60869565217391, 0.6195652173913, -0.075
33539, 0.56521739130435, 0.6195652173913, -0.075
33540, 0.52173913043478, 0.6195652173913, -0.075
33541, 0.47826086956522, 0.6195652173913, -0.075
33542, 0.43478260869565, 0.6195652173913, -0.075
33543, 0.39130434782609, 0.6195652173913, -0.075
33544, 0.34782608695652, 0.6195652173913, -0.075
33545, 0.30434782608696, 0.6195652173913, -0.075
33546, 0.26086956521739, 0.6195652173913, -0.075
33547, 0.21739130434783, 0.6195652173913, -0.075
33548, 0.17391304347826, 0.6195652173913, -0.075
33549, 0.1304347826087, 0.6195652173913, -0.075
33550, 0.08695652173913, 0.6195652173913, -0.075
33551, 0.043478260869565, 0.6195652173913, -0.075
33552, 0.95652173913043, 0.67173913043478, -0.075
33553, 0.91304347826087, 0.67173913043478, -0.075
33554, 0.8695652173913, 0.67173913043478, -0.075
33555, 0.82608695652174, 0.67173913043478, -0.075
33556, 0.78260869565217, 0.67173913043478, -0.075
33557, 0.73913043478261, 0.67173913043478, -0.075
33558, 0.69565217391304, 0.67173913043478, -0.075
33559, 0.65217391304348, 0.67173913043478, -0.075
33560, 0.60869565217391, 0.67173913043478, -0.075
33561, 0.56521739130435, 0.67173913043478, -0.075
33562, 0.52173913043478, 0.67173913043478, -0.075
33563, 0.47826086956522, 0.67173913043478, -0.075
33564, 0.43478260869565, 0.67173913043478, -0.075
33565, 0.39130434782609, 0.67173913043478, -0.075
33566, 0.34782608695652, 0.67173913043478, -0.075
33567, 0.30434782608696, 0.67173913043478, -0.075
33568, 0.26086956521739, 0.67173913043478, -0.075
33569, 0.21739130434783, 0.67173913043478, -0.075
33570, 0.17391304347826, 0.67173913043478, -0.075
33571, 0.1304347826087, 0.67173913043478, -0.075
33572, 0.08695652173913, 0.67173913043478, -0.075
33573, 0.043478260869565, 0.67173913043478, -0.075
33574, 0.95652173913043, 0.72391304347826, -0.075
33575, 0.91304347826087, 0.72391304347826, -0.075
33576, 0.8695652173913, 0.72391304347826, -0.075
33577, 0.82608695652174, 0.72391304347826, -0.075
