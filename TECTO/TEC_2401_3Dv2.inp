*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_2401_3Dv2.inp
*NODE
1, 1, 0.15, 0
2, 0, 0.15, 0
3, 1, 0.15, 0.5
4, 0, 0.15, 0.5
5, 1.2, 0.15, 0.5
6, 2.2, 0.15, 0.5
7, 1.2, 0.15, 0
8, 2.2, 0.15, 0
9, 0, 0.05, 0.5
10, -0.1, 0.05, 0.5
11, 0, -0.05, 0.5
12, -0.1, -0.05, 0.5
13, 0, -0.05, 0
14, -0.1, -0.05, 0
15, 0, 0.05, 0
16, -0.1, 0.05, 0
17, 0, -0.25, 0.5
18, -0.1, -0.25, 0.5
19, 0, -0.25, 0
20, -0.1, -0.25, 0
21, 1, -0.05, 0.5
22, 1, -0.05, 0
23, 1, 0.05, 0.5
24, 1, 0.05, 0
25, 1, -0.25, 0
26, 1, -0.25, 0.5
27, 1.2, -0.05, 0.5
28, 1.2, -0.25, 0.5
29, 1.2, -0.05, 0
30, 1.2, -0.25, 0
31, 2.2, -0.05, 0.5
32, 2.2, -0.25, 0.5
33, 2.2, -0.05, 0
34, 2.2, -0.25, 0
35, 1.2, 0.05, 0.5
36, 2.2, 0.05, 0.5
37, 1.2, 0.05, 0
38, 2.2, 0.05, 0
39, 2.3, 0.05, 0.5
40, 2.3, -0.05, 0.5
41, 2.3, 0.05, 0
42, 2.3, -0.05, 0
43, 2.3, -0.25, 0.5
44, 2.3, -0.25, 0
45, 1, 1.45, 0
46, 1, 1.55, 0
47, 0, 1.45, 0
48, 0, 1.55, 0
49, 1, 1.45, 0.5
50, 1, 1.55, 0.5
51, 0, 1.45, 0.5
52, 0, 1.55, 0.5
53, 1.2, 1.45, 0.5
54, 1.2, 1.55, 0.5
55, 1.2, 1.45, 0
56, 1.2, 1.55, 0
57, 1, 1.75, 0.5
58, 1.2, 1.75, 0.5
59, 1, 1.75, 0
60, 1.2, 1.75, 0
61, 0, 1.75, 0
62, 0, 1.75, 0.5
63, -0.1, 1.55, 0.5
64, -0.1, 1.75, 0.5
65, -0.1, 1.55, 0
66, -0.1, 1.75, 0
67, 1, 1.4, 0
68, 0, 1.4, 0
69, 1, 1.4, 0.5
70, 0, 1.4, 0.5
71, 1.2, 1.4, 0.5
72, 2.2, 1.45, 0.5
73, 2.2, 1.4, 0.5
74, 1.2, 1.4, 0
75, 2.2, 1.45, 0
76, 2.2, 1.4, 0
77, 2.2, 1.55, 0.5
78, 2.2, 1.55, 0
79, 2.2, 1.75, 0.5
80, 2.2, 1.75, 0
81, 2.3, 1.55, 0.5
82, 2.3, 1.75, 0.5
83, 2.3, 1.55, 0
84, 2.3, 1.75, 0
85, 1, 0.1, 0
86, 0, 0.1, 0
87, 1, 0.1, 0.5
88, 0, 0.1, 0.5
89, 1, 1.35, 0
90, 0, 1.35, 0
91, 1, 1.35, 0.5
92, 0, 1.35, 0.5
93, 1.2, 1.35, 0.5
94, 2.2, 1.35, 0.5
95, 1.2, 1.35, 0
96, 2.2, 1.35, 0
97, 1.2, 0.1, 0.5
98, 2.2, 0.1, 0.5
99, 1.2, 0.1, 0
100, 2.2, 0.1, 0
101, 1.075, 0.15, 0.5
102, 1.075, 1.35, 0.5
103, 1.075, 0.15, 0
104, 1.075, 1.35, 0
105, 1.125, 1.35, 0.5
106, 1.125, 0.15, 0.5
107, 1.125, 1.35, 0
108, 1.125, 0.15, 0
109, 1, 0.15, -0.075
110, 1, 1.35, -0.075
111, 0, 0.15, -0.075
112, 0, 1.35, -0.075
113, 1.075, 0.15, -0.075
114, 1.075, 1.35, -0.075
115, 1.2, 1.35, -0.075
116, 1.125, 1.35, -0.075
117, 1.2, 0.15, -0.075
118, 1.125, 0.15, -0.075
119, 2.2, 1.35, -0.075
120, 2.2, 0.15, -0.075
121, 0.043478260869565, 0.15, 0
122, 0.08695652173913, 0.15, 0
123, 0.1304347826087, 0.15, 0
124, 0.17391304347826, 0.15, 0
125, 0.21739130434783, 0.15, 0
126, 0.26086956521739, 0.15, 0
127, 0.30434782608696, 0.15, 0
128, 0.34782608695652, 0.15, 0
129, 0.39130434782609, 0.15, 0
130, 0.43478260869565, 0.15, 0
131, 0.47826086956522, 0.15, 0
132, 0.52173913043478, 0.15, 0
133, 0.56521739130435, 0.15, 0
134, 0.60869565217391, 0.15, 0
135, 0.65217391304348, 0.15, 0
136, 0.69565217391304, 0.15, 0
137, 0.73913043478261, 0.15, 0
138, 0.78260869565217, 0.15, 0
139, 0.82608695652174, 0.15, 0
140, 0.8695652173913, 0.15, 0
141, 0.91304347826087, 0.15, 0
142, 0.95652173913043, 0.15, 0
143, 0.021739130434783, 0.15, 0
144, 0.065217391304348, 0.15, 0
145, 0.10869565217391, 0.15, 0
146, 0.15217391304348, 0.15, 0
147, 0.19565217391304, 0.15, 0
148, 0.23913043478261, 0.15, 0
149, 0.28260869565217, 0.15, 0
150, 0.32608695652174, 0.15, 0
151, 0.3695652173913, 0.15, 0
152, 0.41304347826087, 0.15, 0
153, 0.45652173913043, 0.15, 0
154, 0.5, 0.15, 0
155, 0.54347826086957, 0.15, 0
156, 0.58695652173913, 0.15, 0
157, 0.6304347826087, 0.15, 0
158, 0.67391304347826, 0.15, 0
159, 0.71739130434783, 0.15, 0
160, 0.76086956521739, 0.15, 0
161, 0.80434782608696, 0.15, 0
162, 0.84782608695652, 0.15, 0
163, 0.89130434782609, 0.15, 0
164, 0.93478260869565, 0.15, 0
165, 0.97826086956522, 0.15, 0
166, 1, 0.15, 0.055555555555556
167, 1, 0.15, 0.11111111111111
168, 1, 0.15, 0.16666666666667
169, 1, 0.15, 0.22222222222222
170, 1, 0.15, 0.27777777777778
171, 1, 0.15, 0.33333333333333
172, 1, 0.15, 0.38888888888889
173, 1, 0.15, 0.44444444444444
174, 1, 0.15, 0.027777777777778
175, 1, 0.15, 0.083333333333333
176, 1, 0.15, 0.13888888888889
177, 1, 0.15, 0.19444444444444
178, 1, 0.15, 0.25
179, 1, 0.15, 0.30555555555556
180, 1, 0.15, 0.36111111111111
181, 1, 0.15, 0.41666666666667
182, 1, 0.15, 0.47222222222222
183, 0.043478260869565, 0.15, 0.5
184, 0.08695652173913, 0.15, 0.5
185, 0.1304347826087, 0.15, 0.5
186, 0.17391304347826, 0.15, 0.5
187, 0.21739130434783, 0.15, 0.5
188, 0.26086956521739, 0.15, 0.5
189, 0.30434782608696, 0.15, 0.5
190, 0.34782608695652, 0.15, 0.5
191, 0.39130434782609, 0.15, 0.5
192, 0.43478260869565, 0.15, 0.5
193, 0.47826086956522, 0.15, 0.5
194, 0.52173913043478, 0.15, 0.5
195, 0.56521739130435, 0.15, 0.5
196, 0.60869565217391, 0.15, 0.5
197, 0.65217391304348, 0.15, 0.5
198, 0.69565217391304, 0.15, 0.5
199, 0.73913043478261, 0.15, 0.5
200, 0.78260869565217, 0.15, 0.5
201, 0.82608695652174, 0.15, 0.5
202, 0.8695652173913, 0.15, 0.5
203, 0.91304347826087, 0.15, 0.5
204, 0.95652173913043, 0.15, 0.5
205, 0.021739130434783, 0.15, 0.5
206, 0.065217391304348, 0.15, 0.5
207, 0.10869565217391, 0.15, 0.5
208, 0.15217391304348, 0.15, 0.5
209, 0.19565217391304, 0.15, 0.5
210, 0.23913043478261, 0.15, 0.5
211, 0.28260869565217, 0.15, 0.5
212, 0.32608695652174, 0.15, 0.5
213, 0.3695652173913, 0.15, 0.5
214, 0.41304347826087, 0.15, 0.5
215, 0.45652173913043, 0.15, 0.5
216, 0.5, 0.15, 0.5
217, 0.54347826086957, 0.15, 0.5
218, 0.58695652173913, 0.15, 0.5
219, 0.6304347826087, 0.15, 0.5
220, 0.67391304347826, 0.15, 0.5
221, 0.71739130434783, 0.15, 0.5
222, 0.76086956521739, 0.15, 0.5
223, 0.80434782608696, 0.15, 0.5
224, 0.84782608695652, 0.15, 0.5
225, 0.89130434782609, 0.15, 0.5
226, 0.93478260869565, 0.15, 0.5
227, 0.97826086956522, 0.15, 0.5
228, 0, 0.15, 0.055555555555556
229, 0, 0.15, 0.11111111111111
230, 0, 0.15, 0.16666666666667
231, 0, 0.15, 0.22222222222222
232, 0, 0.15, 0.27777777777778
233, 0, 0.15, 0.33333333333333
234, 0, 0.15, 0.38888888888889
235, 0, 0.15, 0.44444444444444
236, 0, 0.15, 0.027777777777778
237, 0, 0.15, 0.083333333333333
238, 0, 0.15, 0.13888888888889
239, 0, 0.15, 0.19444444444444
240, 0, 0.15, 0.25
241, 0, 0.15, 0.30555555555556
242, 0, 0.15, 0.36111111111111
243, 0, 0.15, 0.41666666666667
244, 0, 0.15, 0.47222222222222
245, 1.2434782608696, 0.15, 0.5
246, 1.2869565217391, 0.15, 0.5
247, 1.3304347826087, 0.15, 0.5
248, 1.3739130434783, 0.15, 0.5
249, 1.4173913043478, 0.15, 0.5
250, 1.4608695652174, 0.15, 0.5
251, 1.504347826087, 0.15, 0.5
252, 1.5478260869565, 0.15, 0.5
253, 1.5913043478261, 0.15, 0.5
254, 1.6347826086957, 0.15, 0.5
255, 1.6782608695652, 0.15, 0.5
256, 1.7217391304348, 0.15, 0.5
257, 1.7652173913043, 0.15, 0.5
258, 1.8086956521739, 0.15, 0.5
259, 1.8521739130435, 0.15, 0.5
260, 1.895652173913, 0.15, 0.5
261, 1.9391304347826, 0.15, 0.5
262, 1.9826086956522, 0.15, 0.5
263, 2.0260869565217, 0.15, 0.5
264, 2.0695652173913, 0.15, 0.5
265, 2.1130434782609, 0.15, 0.5
266, 2.1565217391304, 0.15, 0.5
267, 1.2217391304348, 0.15, 0.5
268, 1.2652173913043, 0.15, 0.5
269, 1.3086956521739, 0.15, 0.5
270, 1.3521739130435, 0.15, 0.5
271, 1.395652173913, 0.15, 0.5
272, 1.4391304347826, 0.15, 0.5
273, 1.4826086956522, 0.15, 0.5
274, 1.5260869565217, 0.15, 0.5
275, 1.5695652173913, 0.15, 0.5
276, 1.6130434782609, 0.15, 0.5
277, 1.6565217391304, 0.15, 0.5
278, 1.7, 0.15, 0.5
279, 1.7434782608696, 0.15, 0.5
280, 1.7869565217391, 0.15, 0.5
281, 1.8304347826087, 0.15, 0.5
282, 1.8739130434783, 0.15, 0.5
283, 1.9173913043478, 0.15, 0.5
284, 1.9608695652174, 0.15, 0.5
285, 2.004347826087, 0.15, 0.5
286, 2.0478260869565, 0.15, 0.5
287, 2.0913043478261, 0.15, 0.5
288, 2.1347826086957, 0.15, 0.5
289, 2.1782608695652, 0.15, 0.5
290, 1.2434782608696, 0.15, 0
291, 1.2869565217391, 0.15, 0
292, 1.3304347826087, 0.15, 0
293, 1.3739130434783, 0.15, 0
294, 1.4173913043478, 0.15, 0
295, 1.4608695652174, 0.15, 0
296, 1.504347826087, 0.15, 0
297, 1.5478260869565, 0.15, 0
298, 1.5913043478261, 0.15, 0
299, 1.6347826086957, 0.15, 0
300, 1.6782608695652, 0.15, 0
301, 1.7217391304348, 0.15, 0
302, 1.7652173913043, 0.15, 0
303, 1.8086956521739, 0.15, 0
304, 1.8521739130435, 0.15, 0
305, 1.895652173913, 0.15, 0
306, 1.9391304347826, 0.15, 0
307, 1.9826086956522, 0.15, 0
308, 2.0260869565217, 0.15, 0
309, 2.0695652173913, 0.15, 0
310, 2.1130434782609, 0.15, 0
311, 2.1565217391304, 0.15, 0
312, 1.2217391304348, 0.15, 0
313, 1.2652173913043, 0.15, 0
314, 1.3086956521739, 0.15, 0
315, 1.3521739130435, 0.15, 0
316, 1.395652173913, 0.15, 0
317, 1.4391304347826, 0.15, 0
318, 1.4826086956522, 0.15, 0
319, 1.5260869565217, 0.15, 0
320, 1.5695652173913, 0.15, 0
321, 1.6130434782609, 0.15, 0
322, 1.6565217391304, 0.15, 0
323, 1.7, 0.15, 0
324, 1.7434782608696, 0.15, 0
325, 1.7869565217391, 0.15, 0
326, 1.8304347826087, 0.15, 0
327, 1.8739130434783, 0.15, 0
328, 1.9173913043478, 0.15, 0
329, 1.9608695652174, 0.15, 0
330, 2.004347826087, 0.15, 0
331, 2.0478260869565, 0.15, 0
332, 2.0913043478261, 0.15, 0
333, 2.1347826086957, 0.15, 0
334, 2.1782608695652, 0.15, 0
335, 1.2, 0.15, 0.055555555555556
336, 1.2, 0.15, 0.11111111111111
337, 1.2, 0.15, 0.16666666666667
338, 1.2, 0.15, 0.22222222222222
339, 1.2, 0.15, 0.27777777777778
340, 1.2, 0.15, 0.33333333333333
341, 1.2, 0.15, 0.38888888888889
342, 1.2, 0.15, 0.44444444444444
343, 1.2, 0.15, 0.027777777777778
344, 1.2, 0.15, 0.083333333333333
345, 1.2, 0.15, 0.13888888888889
346, 1.2, 0.15, 0.19444444444444
347, 1.2, 0.15, 0.25
348, 1.2, 0.15, 0.30555555555556
349, 1.2, 0.15, 0.36111111111111
350, 1.2, 0.15, 0.41666666666667
351, 1.2, 0.15, 0.47222222222222
352, 2.2, 0.15, 0.055555555555556
353, 2.2, 0.15, 0.11111111111111
354, 2.2, 0.15, 0.16666666666667
355, 2.2, 0.15, 0.22222222222222
356, 2.2, 0.15, 0.27777777777778
357, 2.2, 0.15, 0.33333333333333
358, 2.2, 0.15, 0.38888888888889
359, 2.2, 0.15, 0.44444444444444
360, 2.2, 0.15, 0.027777777777778
361, 2.2, 0.15, 0.083333333333333
362, 2.2, 0.15, 0.13888888888889
363, 2.2, 0.15, 0.19444444444444
364, 2.2, 0.15, 0.25
365, 2.2, 0.15, 0.30555555555556
366, 2.2, 0.15, 0.36111111111111
367, 2.2, 0.15, 0.41666666666667
368, 2.2, 0.15, 0.47222222222222
369, -0.05, 0.05, 0.5
370, -0.025, 0.05, 0.5
371, -0.075, 0.05, 0.5
372, -0.05, -0.05, 0.5
373, -0.025, -0.05, 0.5
374, -0.075, -0.05, 0.5
375, 0, -0.016666666666667, 0.5
376, 0, 0.016666666666667, 0.5
377, 0, -0.033333333333333, 0.5
378, 0, 5.5511151231258e-17, 0.5
379, 0, 0.033333333333333, 0.5
380, -0.1, -0.016666666666667, 0.5
381, -0.1, 0.016666666666667, 0.5
382, -0.1, -0.033333333333333, 0.5
383, -0.1, 5.5511151231258e-17, 0.5
384, -0.1, 0.033333333333333, 0.5
385, -0.05, -0.05, 0
386, -0.025, -0.05, 0
387, -0.075, -0.05, 0
388, 0, -0.05, 0.055555555555556
389, 0, -0.05, 0.11111111111111
390, 0, -0.05, 0.16666666666667
391, 0, -0.05, 0.22222222222222
392, 0, -0.05, 0.27777777777778
393, 0, -0.05, 0.33333333333333
394, 0, -0.05, 0.38888888888889
395, 0, -0.05, 0.44444444444444
396, 0, -0.05, 0.027777777777778
397, 0, -0.05, 0.083333333333333
398, 0, -0.05, 0.13888888888889
399, 0, -0.05, 0.19444444444444
400, 0, -0.05, 0.25
401, 0, -0.05, 0.30555555555556
402, 0, -0.05, 0.36111111111111
403, 0, -0.05, 0.41666666666667
404, 0, -0.05, 0.47222222222222
405, -0.1, -0.05, 0.055555555555556
406, -0.1, -0.05, 0.11111111111111
407, -0.1, -0.05, 0.16666666666667
408, -0.1, -0.05, 0.22222222222222
409, -0.1, -0.05, 0.27777777777778
410, -0.1, -0.05, 0.33333333333333
411, -0.1, -0.05, 0.38888888888889
412, -0.1, -0.05, 0.44444444444444
413, -0.1, -0.05, 0.027777777777778
414, -0.1, -0.05, 0.083333333333333
415, -0.1, -0.05, 0.13888888888889
416, -0.1, -0.05, 0.19444444444444
417, -0.1, -0.05, 0.25
418, -0.1, -0.05, 0.30555555555556
419, -0.1, -0.05, 0.36111111111111
420, -0.1, -0.05, 0.41666666666667
421, -0.1, -0.05, 0.47222222222222
422, -0.05, 0.05, 0
423, -0.025, 0.05, 0
424, -0.075, 0.05, 0
425, 0, 0.05, 0.055555555555556
426, 0, 0.05, 0.11111111111111
427, 0, 0.05, 0.16666666666667
428, 0, 0.05, 0.22222222222222
429, 0, 0.05, 0.27777777777778
430, 0, 0.05, 0.33333333333333
431, 0, 0.05, 0.38888888888889
432, 0, 0.05, 0.44444444444444
433, 0, 0.05, 0.027777777777778
434, 0, 0.05, 0.083333333333333
435, 0, 0.05, 0.13888888888889
436, 0, 0.05, 0.19444444444444
437, 0, 0.05, 0.25
438, 0, 0.05, 0.30555555555556
439, 0, 0.05, 0.36111111111111
440, 0, 0.05, 0.41666666666667
441, 0, 0.05, 0.47222222222222
442, -0.1, 0.05, 0.055555555555556
443, -0.1, 0.05, 0.11111111111111
444, -0.1, 0.05, 0.16666666666667
445, -0.1, 0.05, 0.22222222222222
446, -0.1, 0.05, 0.27777777777778
447, -0.1, 0.05, 0.33333333333333
448, -0.1, 0.05, 0.38888888888889
449, -0.1, 0.05, 0.44444444444444
450, -0.1, 0.05, 0.027777777777778
451, -0.1, 0.05, 0.083333333333333
452, -0.1, 0.05, 0.13888888888889
453, -0.1, 0.05, 0.19444444444444
454, -0.1, 0.05, 0.25
455, -0.1, 0.05, 0.30555555555556
456, -0.1, 0.05, 0.36111111111111
457, -0.1, 0.05, 0.41666666666667
458, -0.1, 0.05, 0.47222222222222
459, 0, -0.016666666666667, 0
460, 0, 0.016666666666667, 0
461, 0, -0.033333333333333, 0
462, 0, 5.5511151231258e-17, 0
463, 0, 0.033333333333333, 0
464, -0.1, -0.016666666666667, 0
465, -0.1, 0.016666666666667, 0
466, -0.1, -0.033333333333333, 0
467, -0.1, 5.5511151231258e-17, 0
468, -0.1, 0.033333333333333, 0
469, 0, -0.1, 0.5
470, 0, -0.15, 0.5
471, 0, -0.2, 0.5
472, 0, -0.075, 0.5
473, 0, -0.125, 0.5
474, 0, -0.175, 0.5
475, 0, -0.225, 0.5
476, -0.1, -0.1, 0.5
477, -0.1, -0.15, 0.5
478, -0.1, -0.2, 0.5
479, -0.1, -0.075, 0.5
480, -0.1, -0.125, 0.5
481, -0.1, -0.175, 0.5
482, -0.1, -0.225, 0.5
483, -0.05, -0.25, 0.5
484, -0.025, -0.25, 0.5
485, -0.075, -0.25, 0.5
486, 0, -0.1, 0
487, 0, -0.15, 0
488, 0, -0.2, 0
489, 0, -0.075, 0
490, 0, -0.125, 0
491, 0, -0.175, 0
492, 0, -0.225, 0
493, -0.1, -0.1, 0
494, -0.1, -0.15, 0
495, -0.1, -0.2, 0
496, -0.1, -0.075, 0
497, -0.1, -0.125, 0
498, -0.1, -0.175, 0
499, -0.1, -0.225, 0
500, -0.05, -0.25, 0
501, -0.025, -0.25, 0
502, -0.075, -0.25, 0
503, 0, -0.25, 0.055555555555556
504, 0, -0.25, 0.11111111111111
505, 0, -0.25, 0.16666666666667
506, 0, -0.25, 0.22222222222222
507, 0, -0.25, 0.27777777777778
508, 0, -0.25, 0.33333333333333
509, 0, -0.25, 0.38888888888889
510, 0, -0.25, 0.44444444444444
511, 0, -0.25, 0.027777777777778
512, 0, -0.25, 0.083333333333333
513, 0, -0.25, 0.13888888888889
514, 0, -0.25, 0.19444444444444
515, 0, -0.25, 0.25
516, 0, -0.25, 0.30555555555556
517, 0, -0.25, 0.36111111111111
518, 0, -0.25, 0.41666666666667
519, 0, -0.25, 0.47222222222222
520, -0.1, -0.25, 0.055555555555556
521, -0.1, -0.25, 0.11111111111111
522, -0.1, -0.25, 0.16666666666667
523, -0.1, -0.25, 0.22222222222222
524, -0.1, -0.25, 0.27777777777778
525, -0.1, -0.25, 0.33333333333333
526, -0.1, -0.25, 0.38888888888889
527, -0.1, -0.25, 0.44444444444444
528, -0.1, -0.25, 0.027777777777778
529, -0.1, -0.25, 0.083333333333333
530, -0.1, -0.25, 0.13888888888889
531, -0.1, -0.25, 0.19444444444444
532, -0.1, -0.25, 0.25
533, -0.1, -0.25, 0.30555555555556
534, -0.1, -0.25, 0.36111111111111
535, -0.1, -0.25, 0.41666666666667
536, -0.1, -0.25, 0.47222222222222
537, 1, -0.05, 0.055555555555556
538, 1, -0.05, 0.11111111111111
539, 1, -0.05, 0.16666666666667
540, 1, -0.05, 0.22222222222222
541, 1, -0.05, 0.27777777777778
542, 1, -0.05, 0.33333333333333
543, 1, -0.05, 0.38888888888889
544, 1, -0.05, 0.44444444444444
545, 1, -0.05, 0.027777777777778
546, 1, -0.05, 0.083333333333333
547, 1, -0.05, 0.13888888888889
548, 1, -0.05, 0.19444444444444
549, 1, -0.05, 0.25
550, 1, -0.05, 0.30555555555556
551, 1, -0.05, 0.36111111111111
552, 1, -0.05, 0.41666666666667
553, 1, -0.05, 0.47222222222222
554, 1, -0.016666666666667, 0.5
555, 1, 0.016666666666667, 0.5
556, 1, -0.033333333333333, 0.5
557, 1, 5.5511151231258e-17, 0.5
558, 1, 0.033333333333333, 0.5
559, 1, 0.05, 0.055555555555556
560, 1, 0.05, 0.11111111111111
561, 1, 0.05, 0.16666666666667
562, 1, 0.05, 0.22222222222222
563, 1, 0.05, 0.27777777777778
564, 1, 0.05, 0.33333333333333
565, 1, 0.05, 0.38888888888889
566, 1, 0.05, 0.44444444444444
567, 1, 0.05, 0.027777777777778
568, 1, 0.05, 0.083333333333333
569, 1, 0.05, 0.13888888888889
570, 1, 0.05, 0.19444444444444
571, 1, 0.05, 0.25
572, 1, 0.05, 0.30555555555556
573, 1, 0.05, 0.36111111111111
574, 1, 0.05, 0.41666666666667
575, 1, 0.05, 0.47222222222222
576, 1, -0.016666666666667, 0
577, 1, 0.016666666666667, 0
578, 1, -0.033333333333333, 0
579, 1, 5.5511151231258e-17, 0
580, 1, 0.033333333333333, 0
581, 0.043478260869565, -0.05, 0
582, 0.08695652173913, -0.05, 0
583, 0.1304347826087, -0.05, 0
584, 0.17391304347826, -0.05, 0
585, 0.21739130434783, -0.05, 0
586, 0.26086956521739, -0.05, 0
587, 0.30434782608696, -0.05, 0
588, 0.34782608695652, -0.05, 0
589, 0.39130434782609, -0.05, 0
590, 0.43478260869565, -0.05, 0
591, 0.47826086956522, -0.05, 0
592, 0.52173913043478, -0.05, 0
593, 0.56521739130435, -0.05, 0
594, 0.60869565217391, -0.05, 0
595, 0.65217391304348, -0.05, 0
596, 0.69565217391304, -0.05, 0
597, 0.73913043478261, -0.05, 0
598, 0.78260869565217, -0.05, 0
599, 0.82608695652174, -0.05, 0
600, 0.8695652173913, -0.05, 0
601, 0.91304347826087, -0.05, 0
602, 0.95652173913043, -0.05, 0
603, 0.021739130434783, -0.05, 0
604, 0.065217391304348, -0.05, 0
605, 0.10869565217391, -0.05, 0
606, 0.15217391304348, -0.05, 0
607, 0.19565217391304, -0.05, 0
608, 0.23913043478261, -0.05, 0
609, 0.28260869565217, -0.05, 0
610, 0.32608695652174, -0.05, 0
611, 0.3695652173913, -0.05, 0
612, 0.41304347826087, -0.05, 0
613, 0.45652173913043, -0.05, 0
614, 0.5, -0.05, 0
615, 0.54347826086957, -0.05, 0
616, 0.58695652173913, -0.05, 0
617, 0.6304347826087, -0.05, 0
618, 0.67391304347826, -0.05, 0
619, 0.71739130434783, -0.05, 0
620, 0.76086956521739, -0.05, 0
621, 0.80434782608696, -0.05, 0
622, 0.84782608695652, -0.05, 0
623, 0.89130434782609, -0.05, 0
624, 0.93478260869565, -0.05, 0
625, 0.97826086956522, -0.05, 0
626, 0.043478260869565, -0.05, 0.5
627, 0.08695652173913, -0.05, 0.5
628, 0.1304347826087, -0.05, 0.5
629, 0.17391304347826, -0.05, 0.5
630, 0.21739130434783, -0.05, 0.5
631, 0.26086956521739, -0.05, 0.5
632, 0.30434782608696, -0.05, 0.5
633, 0.34782608695652, -0.05, 0.5
634, 0.39130434782609, -0.05, 0.5
635, 0.43478260869565, -0.05, 0.5
636, 0.47826086956522, -0.05, 0.5
637, 0.52173913043478, -0.05, 0.5
638, 0.56521739130435, -0.05, 0.5
639, 0.60869565217391, -0.05, 0.5
640, 0.65217391304348, -0.05, 0.5
641, 0.69565217391304, -0.05, 0.5
642, 0.73913043478261, -0.05, 0.5
643, 0.78260869565217, -0.05, 0.5
644, 0.82608695652174, -0.05, 0.5
645, 0.8695652173913, -0.05, 0.5
646, 0.91304347826087, -0.05, 0.5
647, 0.95652173913043, -0.05, 0.5
648, 0.021739130434783, -0.05, 0.5
649, 0.065217391304348, -0.05, 0.5
650, 0.10869565217391, -0.05, 0.5
651, 0.15217391304348, -0.05, 0.5
652, 0.19565217391304, -0.05, 0.5
653, 0.23913043478261, -0.05, 0.5
654, 0.28260869565217, -0.05, 0.5
655, 0.32608695652174, -0.05, 0.5
656, 0.3695652173913, -0.05, 0.5
657, 0.41304347826087, -0.05, 0.5
658, 0.45652173913043, -0.05, 0.5
659, 0.5, -0.05, 0.5
660, 0.54347826086957, -0.05, 0.5
661, 0.58695652173913, -0.05, 0.5
662, 0.6304347826087, -0.05, 0.5
663, 0.67391304347826, -0.05, 0.5
664, 0.71739130434783, -0.05, 0.5
665, 0.76086956521739, -0.05, 0.5
666, 0.80434782608696, -0.05, 0.5
667, 0.84782608695652, -0.05, 0.5
668, 0.89130434782609, -0.05, 0.5
669, 0.93478260869565, -0.05, 0.5
670, 0.97826086956522, -0.05, 0.5
671, 0.043478260869565, 0.05, 0
672, 0.08695652173913, 0.05, 0
673, 0.1304347826087, 0.05, 0
674, 0.17391304347826, 0.05, 0
675, 0.21739130434783, 0.05, 0
676, 0.26086956521739, 0.05, 0
677, 0.30434782608696, 0.05, 0
678, 0.34782608695652, 0.05, 0
679, 0.39130434782609, 0.05, 0
680, 0.43478260869565, 0.05, 0
681, 0.47826086956522, 0.05, 0
682, 0.52173913043478, 0.05, 0
683, 0.56521739130435, 0.05, 0
684, 0.60869565217391, 0.05, 0
685, 0.65217391304348, 0.05, 0
686, 0.69565217391304, 0.05, 0
687, 0.73913043478261, 0.05, 0
688, 0.78260869565217, 0.05, 0
689, 0.82608695652174, 0.05, 0
690, 0.8695652173913, 0.05, 0
691, 0.91304347826087, 0.05, 0
692, 0.95652173913043, 0.05, 0
693, 0.021739130434783, 0.05, 0
694, 0.065217391304348, 0.05, 0
695, 0.10869565217391, 0.05, 0
696, 0.15217391304348, 0.05, 0
697, 0.19565217391304, 0.05, 0
698, 0.23913043478261, 0.05, 0
699, 0.28260869565217, 0.05, 0
700, 0.32608695652174, 0.05, 0
701, 0.3695652173913, 0.05, 0
702, 0.41304347826087, 0.05, 0
703, 0.45652173913043, 0.05, 0
704, 0.5, 0.05, 0
705, 0.54347826086957, 0.05, 0
706, 0.58695652173913, 0.05, 0
707, 0.6304347826087, 0.05, 0
708, 0.67391304347826, 0.05, 0
709, 0.71739130434783, 0.05, 0
710, 0.76086956521739, 0.05, 0
711, 0.80434782608696, 0.05, 0
712, 0.84782608695652, 0.05, 0
713, 0.89130434782609, 0.05, 0
714, 0.93478260869565, 0.05, 0
715, 0.97826086956522, 0.05, 0
716, 0.043478260869565, 0.05, 0.5
717, 0.08695652173913, 0.05, 0.5
718, 0.1304347826087, 0.05, 0.5
719, 0.17391304347826, 0.05, 0.5
720, 0.21739130434783, 0.05, 0.5
721, 0.26086956521739, 0.05, 0.5
722, 0.30434782608696, 0.05, 0.5
723, 0.34782608695652, 0.05, 0.5
724, 0.39130434782609, 0.05, 0.5
725, 0.43478260869565, 0.05, 0.5
726, 0.47826086956522, 0.05, 0.5
727, 0.52173913043478, 0.05, 0.5
728, 0.56521739130435, 0.05, 0.5
729, 0.60869565217391, 0.05, 0.5
730, 0.65217391304348, 0.05, 0.5
731, 0.69565217391304, 0.05, 0.5
732, 0.73913043478261, 0.05, 0.5
733, 0.78260869565217, 0.05, 0.5
734, 0.82608695652174, 0.05, 0.5
735, 0.8695652173913, 0.05, 0.5
736, 0.91304347826087, 0.05, 0.5
737, 0.95652173913043, 0.05, 0.5
738, 0.021739130434783, 0.05, 0.5
739, 0.065217391304348, 0.05, 0.5
740, 0.10869565217391, 0.05, 0.5
741, 0.15217391304348, 0.05, 0.5
742, 0.19565217391304, 0.05, 0.5
743, 0.23913043478261, 0.05, 0.5
744, 0.28260869565217, 0.05, 0.5
745, 0.32608695652174, 0.05, 0.5
746, 0.3695652173913, 0.05, 0.5
747, 0.41304347826087, 0.05, 0.5
748, 0.45652173913043, 0.05, 0.5
749, 0.5, 0.05, 0.5
750, 0.54347826086957, 0.05, 0.5
751, 0.58695652173913, 0.05, 0.5
752, 0.6304347826087, 0.05, 0.5
753, 0.67391304347826, 0.05, 0.5
754, 0.71739130434783, 0.05, 0.5
755, 0.76086956521739, 0.05, 0.5
756, 0.80434782608696, 0.05, 0.5
757, 0.84782608695652, 0.05, 0.5
758, 0.89130434782609, 0.05, 0.5
759, 0.93478260869565, 0.05, 0.5
760, 0.97826086956522, 0.05, 0.5
761, 1, -0.1, 0
762, 1, -0.15, 0
763, 1, -0.2, 0
764, 1, -0.075, 0
765, 1, -0.125, 0
766, 1, -0.175, 0
767, 1, -0.225, 0
768, 0.043478260869565, -0.25, 0
769, 0.08695652173913, -0.25, 0
770, 0.1304347826087, -0.25, 0
771, 0.17391304347826, -0.25, 0
772, 0.21739130434783, -0.25, 0
773, 0.26086956521739, -0.25, 0
774, 0.30434782608696, -0.25, 0
775, 0.34782608695652, -0.25, 0
776, 0.39130434782609, -0.25, 0
777, 0.43478260869565, -0.25, 0
778, 0.47826086956522, -0.25, 0
779, 0.52173913043478, -0.25, 0
780, 0.56521739130435, -0.25, 0
781, 0.60869565217391, -0.25, 0
782, 0.65217391304348, -0.25, 0
783, 0.69565217391304, -0.25, 0
784, 0.73913043478261, -0.25, 0
785, 0.78260869565217, -0.25, 0
786, 0.82608695652174, -0.25, 0
787, 0.8695652173913, -0.25, 0
788, 0.91304347826087, -0.25, 0
789, 0.95652173913043, -0.25, 0
790, 0.021739130434783, -0.25, 0
791, 0.065217391304348, -0.25, 0
792, 0.10869565217391, -0.25, 0
793, 0.15217391304348, -0.25, 0
794, 0.19565217391304, -0.25, 0
795, 0.23913043478261, -0.25, 0
796, 0.28260869565217, -0.25, 0
797, 0.32608695652174, -0.25, 0
798, 0.3695652173913, -0.25, 0
799, 0.41304347826087, -0.25, 0
800, 0.45652173913043, -0.25, 0
801, 0.5, -0.25, 0
802, 0.54347826086957, -0.25, 0
803, 0.58695652173913, -0.25, 0
804, 0.6304347826087, -0.25, 0
805, 0.67391304347826, -0.25, 0
806, 0.71739130434783, -0.25, 0
807, 0.76086956521739, -0.25, 0
808, 0.80434782608696, -0.25, 0
809, 0.84782608695652, -0.25, 0
810, 0.89130434782609, -0.25, 0
811, 0.93478260869565, -0.25, 0
812, 0.97826086956522, -0.25, 0
813, 1, -0.1, 0.5
814, 1, -0.15, 0.5
815, 1, -0.2, 0.5
816, 1, -0.075, 0.5
817, 1, -0.125, 0.5
818, 1, -0.175, 0.5
819, 1, -0.225, 0.5
820, 1, -0.25, 0.055555555555556
821, 1, -0.25, 0.11111111111111
822, 1, -0.25, 0.16666666666667
823, 1, -0.25, 0.22222222222222
824, 1, -0.25, 0.27777777777778
825, 1, -0.25, 0.33333333333333
826, 1, -0.25, 0.38888888888889
827, 1, -0.25, 0.44444444444444
828, 1, -0.25, 0.027777777777778
829, 1, -0.25, 0.083333333333333
830, 1, -0.25, 0.13888888888889
831, 1, -0.25, 0.19444444444444
832, 1, -0.25, 0.25
833, 1, -0.25, 0.30555555555556
834, 1, -0.25, 0.36111111111111
835, 1, -0.25, 0.41666666666667
836, 1, -0.25, 0.47222222222222
837, 0.043478260869565, -0.25, 0.5
838, 0.08695652173913, -0.25, 0.5
839, 0.1304347826087, -0.25, 0.5
840, 0.17391304347826, -0.25, 0.5
841, 0.21739130434783, -0.25, 0.5
842, 0.26086956521739, -0.25, 0.5
843, 0.30434782608696, -0.25, 0.5
844, 0.34782608695652, -0.25, 0.5
845, 0.39130434782609, -0.25, 0.5
846, 0.43478260869565, -0.25, 0.5
847, 0.47826086956522, -0.25, 0.5
848, 0.52173913043478, -0.25, 0.5
849, 0.56521739130435, -0.25, 0.5
850, 0.60869565217391, -0.25, 0.5
851, 0.65217391304348, -0.25, 0.5
852, 0.69565217391304, -0.25, 0.5
853, 0.73913043478261, -0.25, 0.5
854, 0.78260869565217, -0.25, 0.5
855, 0.82608695652174, -0.25, 0.5
856, 0.8695652173913, -0.25, 0.5
857, 0.91304347826087, -0.25, 0.5
858, 0.95652173913043, -0.25, 0.5
859, 0.021739130434783, -0.25, 0.5
860, 0.065217391304348, -0.25, 0.5
861, 0.10869565217391, -0.25, 0.5
862, 0.15217391304348, -0.25, 0.5
863, 0.19565217391304, -0.25, 0.5
864, 0.23913043478261, -0.25, 0.5
865, 0.28260869565217, -0.25, 0.5
866, 0.32608695652174, -0.25, 0.5
867, 0.3695652173913, -0.25, 0.5
868, 0.41304347826087, -0.25, 0.5
869, 0.45652173913043, -0.25, 0.5
870, 0.5, -0.25, 0.5
871, 0.54347826086957, -0.25, 0.5
872, 0.58695652173913, -0.25, 0.5
873, 0.6304347826087, -0.25, 0.5
874, 0.67391304347826, -0.25, 0.5
875, 0.71739130434783, -0.25, 0.5
876, 0.76086956521739, -0.25, 0.5
877, 0.80434782608696, -0.25, 0.5
878, 0.84782608695652, -0.25, 0.5
879, 0.89130434782609, -0.25, 0.5
880, 0.93478260869565, -0.25, 0.5
881, 0.97826086956522, -0.25, 0.5
882, 1.05, -0.05, 0.5
883, 1.1, -0.05, 0.5
884, 1.15, -0.05, 0.5
885, 1.025, -0.05, 0.5
886, 1.075, -0.05, 0.5
887, 1.125, -0.05, 0.5
888, 1.175, -0.05, 0.5
889, 1.05, -0.25, 0.5
890, 1.1, -0.25, 0.5
891, 1.15, -0.25, 0.5
892, 1.025, -0.25, 0.5
893, 1.075, -0.25, 0.5
894, 1.125, -0.25, 0.5
895, 1.175, -0.25, 0.5
896, 1.2, -0.1, 0.5
897, 1.2, -0.15, 0.5
898, 1.2, -0.2, 0.5
899, 1.2, -0.075, 0.5
900, 1.2, -0.125, 0.5
901, 1.2, -0.175, 0.5
902, 1.2, -0.225, 0.5
903, 1.05, -0.05, 0
904, 1.1, -0.05, 0
905, 1.15, -0.05, 0
906, 1.025, -0.05, 0
907, 1.075, -0.05, 0
908, 1.125, -0.05, 0
909, 1.175, -0.05, 0
910, 1.05, -0.25, 0
911, 1.1, -0.25, 0
912, 1.15, -0.25, 0
913, 1.025, -0.25, 0
914, 1.075, -0.25, 0
915, 1.125, -0.25, 0
916, 1.175, -0.25, 0
917, 1.2, -0.1, 0
918, 1.2, -0.15, 0
919, 1.2, -0.2, 0
920, 1.2, -0.075, 0
921, 1.2, -0.125, 0
922, 1.2, -0.175, 0
923, 1.2, -0.225, 0
924, 1.2, -0.05, 0.055555555555556
925, 1.2, -0.05, 0.11111111111111
926, 1.2, -0.05, 0.16666666666667
927, 1.2, -0.05, 0.22222222222222
928, 1.2, -0.05, 0.27777777777778
929, 1.2, -0.05, 0.33333333333333
930, 1.2, -0.05, 0.38888888888889
931, 1.2, -0.05, 0.44444444444444
932, 1.2, -0.05, 0.027777777777778
933, 1.2, -0.05, 0.083333333333333
934, 1.2, -0.05, 0.13888888888889
935, 1.2, -0.05, 0.19444444444444
936, 1.2, -0.05, 0.25
937, 1.2, -0.05, 0.30555555555556
938, 1.2, -0.05, 0.36111111111111
939, 1.2, -0.05, 0.41666666666667
940, 1.2, -0.05, 0.47222222222222
941, 1.2, -0.25, 0.055555555555556
942, 1.2, -0.25, 0.11111111111111
943, 1.2, -0.25, 0.16666666666667
944, 1.2, -0.25, 0.22222222222222
945, 1.2, -0.25, 0.27777777777778
946, 1.2, -0.25, 0.33333333333333
947, 1.2, -0.25, 0.38888888888889
948, 1.2, -0.25, 0.44444444444444
949, 1.2, -0.25, 0.027777777777778
950, 1.2, -0.25, 0.083333333333333
951, 1.2, -0.25, 0.13888888888889
952, 1.2, -0.25, 0.19444444444444
953, 1.2, -0.25, 0.25
954, 1.2, -0.25, 0.30555555555556
955, 1.2, -0.25, 0.36111111111111
956, 1.2, -0.25, 0.41666666666667
957, 1.2, -0.25, 0.47222222222222
958, 2.2, -0.1, 0.5
959, 2.2, -0.15, 0.5
960, 2.2, -0.2, 0.5
961, 2.2, -0.075, 0.5
962, 2.2, -0.125, 0.5
963, 2.2, -0.175, 0.5
964, 2.2, -0.225, 0.5
965, 1.2434782608696, -0.05, 0.5
966, 1.2869565217391, -0.05, 0.5
967, 1.3304347826087, -0.05, 0.5
968, 1.3739130434783, -0.05, 0.5
969, 1.4173913043478, -0.05, 0.5
970, 1.4608695652174, -0.05, 0.5
971, 1.504347826087, -0.05, 0.5
972, 1.5478260869565, -0.05, 0.5
973, 1.5913043478261, -0.05, 0.5
974, 1.6347826086957, -0.05, 0.5
975, 1.6782608695652, -0.05, 0.5
976, 1.7217391304348, -0.05, 0.5
977, 1.7652173913043, -0.05, 0.5
978, 1.8086956521739, -0.05, 0.5
979, 1.8521739130435, -0.05, 0.5
980, 1.895652173913, -0.05, 0.5
981, 1.9391304347826, -0.05, 0.5
982, 1.9826086956522, -0.05, 0.5
983, 2.0260869565217, -0.05, 0.5
984, 2.0695652173913, -0.05, 0.5
985, 2.1130434782609, -0.05, 0.5
986, 2.1565217391304, -0.05, 0.5
987, 1.2217391304348, -0.05, 0.5
988, 1.2652173913043, -0.05, 0.5
989, 1.3086956521739, -0.05, 0.5
990, 1.3521739130435, -0.05, 0.5
991, 1.395652173913, -0.05, 0.5
992, 1.4391304347826, -0.05, 0.5
993, 1.4826086956522, -0.05, 0.5
994, 1.5260869565217, -0.05, 0.5
995, 1.5695652173913, -0.05, 0.5
996, 1.6130434782609, -0.05, 0.5
997, 1.6565217391304, -0.05, 0.5
998, 1.7, -0.05, 0.5
999, 1.7434782608696, -0.05, 0.5
1000, 1.7869565217391, -0.05, 0.5
1001, 1.8304347826087, -0.05, 0.5
1002, 1.8739130434783, -0.05, 0.5
1003, 1.9173913043478, -0.05, 0.5
1004, 1.9608695652174, -0.05, 0.5
1005, 2.004347826087, -0.05, 0.5
1006, 2.0478260869565, -0.05, 0.5
1007, 2.0913043478261, -0.05, 0.5
1008, 2.1347826086957, -0.05, 0.5
1009, 2.1782608695652, -0.05, 0.5
1010, 1.2434782608696, -0.25, 0.5
1011, 1.2869565217391, -0.25, 0.5
1012, 1.3304347826087, -0.25, 0.5
1013, 1.3739130434783, -0.25, 0.5
1014, 1.4173913043478, -0.25, 0.5
1015, 1.4608695652174, -0.25, 0.5
1016, 1.504347826087, -0.25, 0.5
1017, 1.5478260869565, -0.25, 0.5
1018, 1.5913043478261, -0.25, 0.5
1019, 1.6347826086957, -0.25, 0.5
1020, 1.6782608695652, -0.25, 0.5
1021, 1.7217391304348, -0.25, 0.5
1022, 1.7652173913043, -0.25, 0.5
1023, 1.8086956521739, -0.25, 0.5
1024, 1.8521739130435, -0.25, 0.5
1025, 1.895652173913, -0.25, 0.5
1026, 1.9391304347826, -0.25, 0.5
1027, 1.9826086956522, -0.25, 0.5
1028, 2.0260869565217, -0.25, 0.5
1029, 2.0695652173913, -0.25, 0.5
1030, 2.1130434782609, -0.25, 0.5
1031, 2.1565217391304, -0.25, 0.5
1032, 1.2217391304348, -0.25, 0.5
1033, 1.2652173913043, -0.25, 0.5
1034, 1.3086956521739, -0.25, 0.5
1035, 1.3521739130435, -0.25, 0.5
1036, 1.395652173913, -0.25, 0.5
1037, 1.4391304347826, -0.25, 0.5
1038, 1.4826086956522, -0.25, 0.5
1039, 1.5260869565217, -0.25, 0.5
1040, 1.5695652173913, -0.25, 0.5
1041, 1.6130434782609, -0.25, 0.5
1042, 1.6565217391304, -0.25, 0.5
1043, 1.7, -0.25, 0.5
1044, 1.7434782608696, -0.25, 0.5
1045, 1.7869565217391, -0.25, 0.5
1046, 1.8304347826087, -0.25, 0.5
1047, 1.8739130434783, -0.25, 0.5
1048, 1.9173913043478, -0.25, 0.5
1049, 1.9608695652174, -0.25, 0.5
1050, 2.004347826087, -0.25, 0.5
1051, 2.0478260869565, -0.25, 0.5
1052, 2.0913043478261, -0.25, 0.5
1053, 2.1347826086957, -0.25, 0.5
1054, 2.1782608695652, -0.25, 0.5
1055, 2.2, -0.1, 0
1056, 2.2, -0.15, 0
1057, 2.2, -0.2, 0
1058, 2.2, -0.075, 0
1059, 2.2, -0.125, 0
1060, 2.2, -0.175, 0
1061, 2.2, -0.225, 0
1062, 1.2434782608696, -0.05, 0
1063, 1.2869565217391, -0.05, 0
1064, 1.3304347826087, -0.05, 0
1065, 1.3739130434783, -0.05, 0
1066, 1.4173913043478, -0.05, 0
1067, 1.4608695652174, -0.05, 0
1068, 1.504347826087, -0.05, 0
1069, 1.5478260869565, -0.05, 0
1070, 1.5913043478261, -0.05, 0
1071, 1.6347826086957, -0.05, 0
1072, 1.6782608695652, -0.05, 0
1073, 1.7217391304348, -0.05, 0
1074, 1.7652173913043, -0.05, 0
1075, 1.8086956521739, -0.05, 0
1076, 1.8521739130435, -0.05, 0
1077, 1.895652173913, -0.05, 0
1078, 1.9391304347826, -0.05, 0
1079, 1.9826086956522, -0.05, 0
1080, 2.0260869565217, -0.05, 0
1081, 2.0695652173913, -0.05, 0
1082, 2.1130434782609, -0.05, 0
1083, 2.1565217391304, -0.05, 0
1084, 1.2217391304348, -0.05, 0
1085, 1.2652173913043, -0.05, 0
1086, 1.3086956521739, -0.05, 0
1087, 1.3521739130435, -0.05, 0
1088, 1.395652173913, -0.05, 0
1089, 1.4391304347826, -0.05, 0
1090, 1.4826086956522, -0.05, 0
1091, 1.5260869565217, -0.05, 0
1092, 1.5695652173913, -0.05, 0
1093, 1.6130434782609, -0.05, 0
1094, 1.6565217391304, -0.05, 0
1095, 1.7, -0.05, 0
1096, 1.7434782608696, -0.05, 0
1097, 1.7869565217391, -0.05, 0
1098, 1.8304347826087, -0.05, 0
1099, 1.8739130434783, -0.05, 0
1100, 1.9173913043478, -0.05, 0
1101, 1.9608695652174, -0.05, 0
1102, 2.004347826087, -0.05, 0
1103, 2.0478260869565, -0.05, 0
1104, 2.0913043478261, -0.05, 0
1105, 2.1347826086957, -0.05, 0
1106, 2.1782608695652, -0.05, 0
1107, 1.2434782608696, -0.25, 0
1108, 1.2869565217391, -0.25, 0
1109, 1.3304347826087, -0.25, 0
1110, 1.3739130434783, -0.25, 0
1111, 1.4173913043478, -0.25, 0
1112, 1.4608695652174, -0.25, 0
1113, 1.504347826087, -0.25, 0
1114, 1.5478260869565, -0.25, 0
1115, 1.5913043478261, -0.25, 0
1116, 1.6347826086957, -0.25, 0
1117, 1.6782608695652, -0.25, 0
1118, 1.7217391304348, -0.25, 0
1119, 1.7652173913043, -0.25, 0
1120, 1.8086956521739, -0.25, 0
1121, 1.8521739130435, -0.25, 0
1122, 1.895652173913, -0.25, 0
1123, 1.9391304347826, -0.25, 0
1124, 1.9826086956522, -0.25, 0
1125, 2.0260869565217, -0.25, 0
1126, 2.0695652173913, -0.25, 0
1127, 2.1130434782609, -0.25, 0
1128, 2.1565217391304, -0.25, 0
1129, 1.2217391304348, -0.25, 0
1130, 1.2652173913043, -0.25, 0
1131, 1.3086956521739, -0.25, 0
1132, 1.3521739130435, -0.25, 0
1133, 1.395652173913, -0.25, 0
1134, 1.4391304347826, -0.25, 0
1135, 1.4826086956522, -0.25, 0
1136, 1.5260869565217, -0.25, 0
1137, 1.5695652173913, -0.25, 0
1138, 1.6130434782609, -0.25, 0
1139, 1.6565217391304, -0.25, 0
1140, 1.7, -0.25, 0
1141, 1.7434782608696, -0.25, 0
1142, 1.7869565217391, -0.25, 0
1143, 1.8304347826087, -0.25, 0
1144, 1.8739130434783, -0.25, 0
1145, 1.9173913043478, -0.25, 0
1146, 1.9608695652174, -0.25, 0
1147, 2.004347826087, -0.25, 0
1148, 2.0478260869565, -0.25, 0
1149, 2.0913043478261, -0.25, 0
1150, 2.1347826086957, -0.25, 0
1151, 2.1782608695652, -0.25, 0
1152, 2.2, -0.05, 0.055555555555556
1153, 2.2, -0.05, 0.11111111111111
1154, 2.2, -0.05, 0.16666666666667
1155, 2.2, -0.05, 0.22222222222222
1156, 2.2, -0.05, 0.27777777777778
1157, 2.2, -0.05, 0.33333333333333
1158, 2.2, -0.05, 0.38888888888889
1159, 2.2, -0.05, 0.44444444444444
1160, 2.2, -0.05, 0.027777777777778
1161, 2.2, -0.05, 0.083333333333333
1162, 2.2, -0.05, 0.13888888888889
1163, 2.2, -0.05, 0.19444444444444
1164, 2.2, -0.05, 0.25
1165, 2.2, -0.05, 0.30555555555556
1166, 2.2, -0.05, 0.36111111111111
1167, 2.2, -0.05, 0.41666666666667
1168, 2.2, -0.05, 0.47222222222222
1169, 2.2, -0.25, 0.055555555555556
1170, 2.2, -0.25, 0.11111111111111
1171, 2.2, -0.25, 0.16666666666667
1172, 2.2, -0.25, 0.22222222222222
1173, 2.2, -0.25, 0.27777777777778
1174, 2.2, -0.25, 0.33333333333333
1175, 2.2, -0.25, 0.38888888888889
1176, 2.2, -0.25, 0.44444444444444
1177, 2.2, -0.25, 0.027777777777778
1178, 2.2, -0.25, 0.083333333333333
1179, 2.2, -0.25, 0.13888888888889
1180, 2.2, -0.25, 0.19444444444444
1181, 2.2, -0.25, 0.25
1182, 2.2, -0.25, 0.30555555555556
1183, 2.2, -0.25, 0.36111111111111
1184, 2.2, -0.25, 0.41666666666667
1185, 2.2, -0.25, 0.47222222222222
1186, 1.2, 0.016666666666667, 0.5
1187, 1.2, -0.016666666666667, 0.5
1188, 1.2, 0.033333333333333, 0.5
1189, 1.2, -9.7144514654701e-17, 0.5
1190, 1.2, -0.033333333333333, 0.5
1191, 2.2, 0.016666666666667, 0.5
1192, 2.2, -0.016666666666667, 0.5
1193, 2.2, 0.033333333333333, 0.5
1194, 2.2, -9.7144514654701e-17, 0.5
1195, 2.2, -0.033333333333333, 0.5
1196, 1.2434782608696, 0.05, 0.5
1197, 1.2869565217391, 0.05, 0.5
1198, 1.3304347826087, 0.05, 0.5
1199, 1.3739130434783, 0.05, 0.5
1200, 1.4173913043478, 0.05, 0.5
1201, 1.4608695652174, 0.05, 0.5
1202, 1.504347826087, 0.05, 0.5
1203, 1.5478260869565, 0.05, 0.5
1204, 1.5913043478261, 0.05, 0.5
1205, 1.6347826086957, 0.05, 0.5
1206, 1.6782608695652, 0.05, 0.5
1207, 1.7217391304348, 0.05, 0.5
1208, 1.7652173913043, 0.05, 0.5
1209, 1.8086956521739, 0.05, 0.5
1210, 1.8521739130435, 0.05, 0.5
1211, 1.895652173913, 0.05, 0.5
1212, 1.9391304347826, 0.05, 0.5
1213, 1.9826086956522, 0.05, 0.5
1214, 2.0260869565217, 0.05, 0.5
1215, 2.0695652173913, 0.05, 0.5
1216, 2.1130434782609, 0.05, 0.5
1217, 2.1565217391304, 0.05, 0.5
1218, 1.2217391304348, 0.05, 0.5
1219, 1.2652173913043, 0.05, 0.5
1220, 1.3086956521739, 0.05, 0.5
1221, 1.3521739130435, 0.05, 0.5
1222, 1.395652173913, 0.05, 0.5
1223, 1.4391304347826, 0.05, 0.5
1224, 1.4826086956522, 0.05, 0.5
1225, 1.5260869565217, 0.05, 0.5
1226, 1.5695652173913, 0.05, 0.5
1227, 1.6130434782609, 0.05, 0.5
1228, 1.6565217391304, 0.05, 0.5
1229, 1.7, 0.05, 0.5
1230, 1.7434782608696, 0.05, 0.5
1231, 1.7869565217391, 0.05, 0.5
1232, 1.8304347826087, 0.05, 0.5
1233, 1.8739130434783, 0.05, 0.5
1234, 1.9173913043478, 0.05, 0.5
1235, 1.9608695652174, 0.05, 0.5
1236, 2.004347826087, 0.05, 0.5
1237, 2.0478260869565, 0.05, 0.5
1238, 2.0913043478261, 0.05, 0.5
1239, 2.1347826086957, 0.05, 0.5
1240, 2.1782608695652, 0.05, 0.5
1241, 1.2, 0.016666666666667, 0
1242, 1.2, -0.016666666666667, 0
1243, 1.2, 0.033333333333333, 0
1244, 1.2, -9.7144514654701e-17, 0
1245, 1.2, -0.033333333333333, 0
1246, 2.2, 0.016666666666667, 0
1247, 2.2, -0.016666666666667, 0
1248, 2.2, 0.033333333333333, 0
1249, 2.2, -9.7144514654701e-17, 0
1250, 2.2, -0.033333333333333, 0
1251, 1.2434782608696, 0.05, 0
1252, 1.2869565217391, 0.05, 0
1253, 1.3304347826087, 0.05, 0
1254, 1.3739130434783, 0.05, 0
1255, 1.4173913043478, 0.05, 0
1256, 1.4608695652174, 0.05, 0
1257, 1.504347826087, 0.05, 0
1258, 1.5478260869565, 0.05, 0
1259, 1.5913043478261, 0.05, 0
1260, 1.6347826086957, 0.05, 0
1261, 1.6782608695652, 0.05, 0
1262, 1.7217391304348, 0.05, 0
1263, 1.7652173913043, 0.05, 0
1264, 1.8086956521739, 0.05, 0
1265, 1.8521739130435, 0.05, 0
1266, 1.895652173913, 0.05, 0
1267, 1.9391304347826, 0.05, 0
1268, 1.9826086956522, 0.05, 0
1269, 2.0260869565217, 0.05, 0
1270, 2.0695652173913, 0.05, 0
1271, 2.1130434782609, 0.05, 0
1272, 2.1565217391304, 0.05, 0
1273, 1.2217391304348, 0.05, 0
1274, 1.2652173913043, 0.05, 0
1275, 1.3086956521739, 0.05, 0
1276, 1.3521739130435, 0.05, 0
1277, 1.395652173913, 0.05, 0
1278, 1.4391304347826, 0.05, 0
1279, 1.4826086956522, 0.05, 0
1280, 1.5260869565217, 0.05, 0
1281, 1.5695652173913, 0.05, 0
1282, 1.6130434782609, 0.05, 0
1283, 1.6565217391304, 0.05, 0
1284, 1.7, 0.05, 0
1285, 1.7434782608696, 0.05, 0
1286, 1.7869565217391, 0.05, 0
1287, 1.8304347826087, 0.05, 0
1288, 1.8739130434783, 0.05, 0
1289, 1.9173913043478, 0.05, 0
1290, 1.9608695652174, 0.05, 0
1291, 2.004347826087, 0.05, 0
1292, 2.0478260869565, 0.05, 0
1293, 2.0913043478261, 0.05, 0
1294, 2.1347826086957, 0.05, 0
1295, 2.1782608695652, 0.05, 0
1296, 1.2, 0.05, 0.055555555555556
1297, 1.2, 0.05, 0.11111111111111
1298, 1.2, 0.05, 0.16666666666667
1299, 1.2, 0.05, 0.22222222222222
1300, 1.2, 0.05, 0.27777777777778
1301, 1.2, 0.05, 0.33333333333333
1302, 1.2, 0.05, 0.38888888888889
1303, 1.2, 0.05, 0.44444444444444
1304, 1.2, 0.05, 0.027777777777778
1305, 1.2, 0.05, 0.083333333333333
1306, 1.2, 0.05, 0.13888888888889
1307, 1.2, 0.05, 0.19444444444444
1308, 1.2, 0.05, 0.25
1309, 1.2, 0.05, 0.30555555555556
1310, 1.2, 0.05, 0.36111111111111
1311, 1.2, 0.05, 0.41666666666667
1312, 1.2, 0.05, 0.47222222222222
1313, 2.2, 0.05, 0.055555555555556
1314, 2.2, 0.05, 0.11111111111111
1315, 2.2, 0.05, 0.16666666666667
1316, 2.2, 0.05, 0.22222222222222
1317, 2.2, 0.05, 0.27777777777778
1318, 2.2, 0.05, 0.33333333333333
1319, 2.2, 0.05, 0.38888888888889
1320, 2.2, 0.05, 0.44444444444444
1321, 2.2, 0.05, 0.027777777777778
1322, 2.2, 0.05, 0.083333333333333
1323, 2.2, 0.05, 0.13888888888889
1324, 2.2, 0.05, 0.19444444444444
1325, 2.2, 0.05, 0.25
1326, 2.2, 0.05, 0.30555555555556
1327, 2.2, 0.05, 0.36111111111111
1328, 2.2, 0.05, 0.41666666666667
1329, 2.2, 0.05, 0.47222222222222
1330, 2.25, 0.05, 0.5
1331, 2.225, 0.05, 0.5
1332, 2.275, 0.05, 0.5
1333, 2.25, -0.05, 0.5
1334, 2.225, -0.05, 0.5
1335, 2.275, -0.05, 0.5
1336, 2.3, 0.016666666666667, 0.5
1337, 2.3, -0.016666666666667, 0.5
1338, 2.3, 0.033333333333333, 0.5
1339, 2.3, -9.7144514654701e-17, 0.5
1340, 2.3, -0.033333333333333, 0.5
1341, 2.25, 0.05, 0
1342, 2.225, 0.05, 0
1343, 2.275, 0.05, 0
1344, 2.25, -0.05, 0
1345, 2.225, -0.05, 0
1346, 2.275, -0.05, 0
1347, 2.3, 0.016666666666667, 0
1348, 2.3, -0.016666666666667, 0
1349, 2.3, 0.033333333333333, 0
1350, 2.3, -9.7144514654701e-17, 0
1351, 2.3, -0.033333333333333, 0
1352, 2.3, 0.05, 0.055555555555556
1353, 2.3, 0.05, 0.11111111111111
1354, 2.3, 0.05, 0.16666666666667
1355, 2.3, 0.05, 0.22222222222222
1356, 2.3, 0.05, 0.27777777777778
1357, 2.3, 0.05, 0.33333333333333
1358, 2.3, 0.05, 0.38888888888889
1359, 2.3, 0.05, 0.44444444444444
1360, 2.3, 0.05, 0.027777777777778
1361, 2.3, 0.05, 0.083333333333333
1362, 2.3, 0.05, 0.13888888888889
1363, 2.3, 0.05, 0.19444444444444
1364, 2.3, 0.05, 0.25
1365, 2.3, 0.05, 0.30555555555556
1366, 2.3, 0.05, 0.36111111111111
1367, 2.3, 0.05, 0.41666666666667
1368, 2.3, 0.05, 0.47222222222222
1369, 2.3, -0.05, 0.055555555555556
1370, 2.3, -0.05, 0.11111111111111
1371, 2.3, -0.05, 0.16666666666667
1372, 2.3, -0.05, 0.22222222222222
1373, 2.3, -0.05, 0.27777777777778
1374, 2.3, -0.05, 0.33333333333333
1375, 2.3, -0.05, 0.38888888888889
1376, 2.3, -0.05, 0.44444444444444
1377, 2.3, -0.05, 0.027777777777778
1378, 2.3, -0.05, 0.083333333333333
1379, 2.3, -0.05, 0.13888888888889
1380, 2.3, -0.05, 0.19444444444444
1381, 2.3, -0.05, 0.25
1382, 2.3, -0.05, 0.30555555555556
1383, 2.3, -0.05, 0.36111111111111
1384, 2.3, -0.05, 0.41666666666667
1385, 2.3, -0.05, 0.47222222222222
1386, 2.3, -0.1, 0.5
1387, 2.3, -0.15, 0.5
1388, 2.3, -0.2, 0.5
1389, 2.3, -0.075, 0.5
1390, 2.3, -0.125, 0.5
1391, 2.3, -0.175, 0.5
1392, 2.3, -0.225, 0.5
1393, 2.25, -0.25, 0.5
1394, 2.225, -0.25, 0.5
1395, 2.275, -0.25, 0.5
1396, 2.3, -0.1, 0
1397, 2.3, -0.15, 0
1398, 2.3, -0.2, 0
1399, 2.3, -0.075, 0
1400, 2.3, -0.125, 0
1401, 2.3, -0.175, 0
1402, 2.3, -0.225, 0
1403, 2.25, -0.25, 0
1404, 2.225, -0.25, 0
1405, 2.275, -0.25, 0
1406, 2.3, -0.25, 0.055555555555556
1407, 2.3, -0.25, 0.11111111111111
1408, 2.3, -0.25, 0.16666666666667
1409, 2.3, -0.25, 0.22222222222222
1410, 2.3, -0.25, 0.27777777777778
1411, 2.3, -0.25, 0.33333333333333
1412, 2.3, -0.25, 0.38888888888889
1413, 2.3, -0.25, 0.44444444444444
1414, 2.3, -0.25, 0.027777777777778
1415, 2.3, -0.25, 0.083333333333333
1416, 2.3, -0.25, 0.13888888888889
1417, 2.3, -0.25, 0.19444444444444
1418, 2.3, -0.25, 0.25
1419, 2.3, -0.25, 0.30555555555556
1420, 2.3, -0.25, 0.36111111111111
1421, 2.3, -0.25, 0.41666666666667
1422, 2.3, -0.25, 0.47222222222222
1423, 1, 1.4833333333333, 0
1424, 1, 1.5166666666667, 0
1425, 1, 1.4666666666667, 0
1426, 1, 1.5, 0
1427, 1, 1.5333333333333, 0
1428, 0, 1.4833333333333, 0
1429, 0, 1.5166666666667, 0
1430, 0, 1.4666666666667, 0
1431, 0, 1.5, 0
1432, 0, 1.5333333333333, 0
1433, 0.043478260869565, 1.45, 0
1434, 0.08695652173913, 1.45, 0
1435, 0.1304347826087, 1.45, 0
1436, 0.17391304347826, 1.45, 0
1437, 0.21739130434783, 1.45, 0
1438, 0.26086956521739, 1.45, 0
1439, 0.30434782608696, 1.45, 0
1440, 0.34782608695652, 1.45, 0
1441, 0.39130434782609, 1.45, 0
1442, 0.43478260869565, 1.45, 0
1443, 0.47826086956522, 1.45, 0
1444, 0.52173913043478, 1.45, 0
1445, 0.56521739130435, 1.45, 0
1446, 0.60869565217391, 1.45, 0
1447, 0.65217391304348, 1.45, 0
1448, 0.69565217391304, 1.45, 0
1449, 0.73913043478261, 1.45, 0
1450, 0.78260869565217, 1.45, 0
1451, 0.82608695652174, 1.45, 0
1452, 0.8695652173913, 1.45, 0
1453, 0.91304347826087, 1.45, 0
1454, 0.95652173913043, 1.45, 0
1455, 0.021739130434783, 1.45, 0
1456, 0.065217391304348, 1.45, 0
1457, 0.10869565217391, 1.45, 0
1458, 0.15217391304348, 1.45, 0
1459, 0.19565217391304, 1.45, 0
1460, 0.23913043478261, 1.45, 0
1461, 0.28260869565217, 1.45, 0
1462, 0.32608695652174, 1.45, 0
1463, 0.3695652173913, 1.45, 0
1464, 0.41304347826087, 1.45, 0
1465, 0.45652173913043, 1.45, 0
1466, 0.5, 1.45, 0
1467, 0.54347826086957, 1.45, 0
1468, 0.58695652173913, 1.45, 0
1469, 0.6304347826087, 1.45, 0
1470, 0.67391304347826, 1.45, 0
1471, 0.71739130434783, 1.45, 0
1472, 0.76086956521739, 1.45, 0
1473, 0.80434782608696, 1.45, 0
1474, 0.84782608695652, 1.45, 0
1475, 0.89130434782609, 1.45, 0
1476, 0.93478260869565, 1.45, 0
1477, 0.97826086956522, 1.45, 0
1478, 0.043478260869565, 1.55, 0
1479, 0.08695652173913, 1.55, 0
1480, 0.1304347826087, 1.55, 0
1481, 0.17391304347826, 1.55, 0
1482, 0.21739130434783, 1.55, 0
1483, 0.26086956521739, 1.55, 0
1484, 0.30434782608696, 1.55, 0
1485, 0.34782608695652, 1.55, 0
1486, 0.39130434782609, 1.55, 0
1487, 0.43478260869565, 1.55, 0
1488, 0.47826086956522, 1.55, 0
1489, 0.52173913043478, 1.55, 0
1490, 0.56521739130435, 1.55, 0
1491, 0.60869565217391, 1.55, 0
1492, 0.65217391304348, 1.55, 0
1493, 0.69565217391304, 1.55, 0
1494, 0.73913043478261, 1.55, 0
1495, 0.78260869565217, 1.55, 0
1496, 0.82608695652174, 1.55, 0
1497, 0.8695652173913, 1.55, 0
1498, 0.91304347826087, 1.55, 0
1499, 0.95652173913043, 1.55, 0
1500, 0.021739130434783, 1.55, 0
1501, 0.065217391304348, 1.55, 0
1502, 0.10869565217391, 1.55, 0
1503, 0.15217391304348, 1.55, 0
1504, 0.19565217391304, 1.55, 0
1505, 0.23913043478261, 1.55, 0
1506, 0.28260869565217, 1.55, 0
1507, 0.32608695652174, 1.55, 0
1508, 0.3695652173913, 1.55, 0
1509, 0.41304347826087, 1.55, 0
1510, 0.45652173913043, 1.55, 0
1511, 0.5, 1.55, 0
1512, 0.54347826086957, 1.55, 0
1513, 0.58695652173913, 1.55, 0
1514, 0.6304347826087, 1.55, 0
1515, 0.67391304347826, 1.55, 0
1516, 0.71739130434783, 1.55, 0
1517, 0.76086956521739, 1.55, 0
1518, 0.80434782608696, 1.55, 0
1519, 0.84782608695652, 1.55, 0
1520, 0.89130434782609, 1.55, 0
1521, 0.93478260869565, 1.55, 0
1522, 0.97826086956522, 1.55, 0
1523, 1, 1.4833333333333, 0.5
1524, 1, 1.5166666666667, 0.5
1525, 1, 1.4666666666667, 0.5
1526, 1, 1.5, 0.5
1527, 1, 1.5333333333333, 0.5
1528, 1, 1.45, 0.055555555555556
1529, 1, 1.45, 0.11111111111111
1530, 1, 1.45, 0.16666666666667
1531, 1, 1.45, 0.22222222222222
1532, 1, 1.45, 0.27777777777778
1533, 1, 1.45, 0.33333333333333
1534, 1, 1.45, 0.38888888888889
1535, 1, 1.45, 0.44444444444444
1536, 1, 1.45, 0.027777777777778
1537, 1, 1.45, 0.083333333333333
1538, 1, 1.45, 0.13888888888889
1539, 1, 1.45, 0.19444444444444
1540, 1, 1.45, 0.25
1541, 1, 1.45, 0.30555555555556
1542, 1, 1.45, 0.36111111111111
1543, 1, 1.45, 0.41666666666667
1544, 1, 1.45, 0.47222222222222
1545, 1, 1.55, 0.055555555555556
1546, 1, 1.55, 0.11111111111111
1547, 1, 1.55, 0.16666666666667
1548, 1, 1.55, 0.22222222222222
1549, 1, 1.55, 0.27777777777778
1550, 1, 1.55, 0.33333333333333
1551, 1, 1.55, 0.38888888888889
1552, 1, 1.55, 0.44444444444444
1553, 1, 1.55, 0.027777777777778
1554, 1, 1.55, 0.083333333333333
1555, 1, 1.55, 0.13888888888889
1556, 1, 1.55, 0.19444444444444
1557, 1, 1.55, 0.25
1558, 1, 1.55, 0.30555555555556
1559, 1, 1.55, 0.36111111111111
1560, 1, 1.55, 0.41666666666667
1561, 1, 1.55, 0.47222222222222
1562, 0, 1.4833333333333, 0.5
1563, 0, 1.5166666666667, 0.5
1564, 0, 1.4666666666667, 0.5
1565, 0, 1.5, 0.5
1566, 0, 1.5333333333333, 0.5
1567, 0.043478260869565, 1.45, 0.5
1568, 0.08695652173913, 1.45, 0.5
1569, 0.1304347826087, 1.45, 0.5
1570, 0.17391304347826, 1.45, 0.5
1571, 0.21739130434783, 1.45, 0.5
1572, 0.26086956521739, 1.45, 0.5
1573, 0.30434782608696, 1.45, 0.5
1574, 0.34782608695652, 1.45, 0.5
1575, 0.39130434782609, 1.45, 0.5
1576, 0.43478260869565, 1.45, 0.5
1577, 0.47826086956522, 1.45, 0.5
1578, 0.52173913043478, 1.45, 0.5
1579, 0.56521739130435, 1.45, 0.5
1580, 0.60869565217391, 1.45, 0.5
1581, 0.65217391304348, 1.45, 0.5
1582, 0.69565217391304, 1.45, 0.5
1583, 0.73913043478261, 1.45, 0.5
1584, 0.78260869565217, 1.45, 0.5
1585, 0.82608695652174, 1.45, 0.5
1586, 0.8695652173913, 1.45, 0.5
1587, 0.91304347826087, 1.45, 0.5
1588, 0.95652173913043, 1.45, 0.5
1589, 0.021739130434783, 1.45, 0.5
1590, 0.065217391304348, 1.45, 0.5
1591, 0.10869565217391, 1.45, 0.5
1592, 0.15217391304348, 1.45, 0.5
1593, 0.19565217391304, 1.45, 0.5
1594, 0.23913043478261, 1.45, 0.5
1595, 0.28260869565217, 1.45, 0.5
1596, 0.32608695652174, 1.45, 0.5
1597, 0.3695652173913, 1.45, 0.5
1598, 0.41304347826087, 1.45, 0.5
1599, 0.45652173913043, 1.45, 0.5
1600, 0.5, 1.45, 0.5
1601, 0.54347826086957, 1.45, 0.5
1602, 0.58695652173913, 1.45, 0.5
1603, 0.6304347826087, 1.45, 0.5
1604, 0.67391304347826, 1.45, 0.5
1605, 0.71739130434783, 1.45, 0.5
1606, 0.76086956521739, 1.45, 0.5
1607, 0.80434782608696, 1.45, 0.5
1608, 0.84782608695652, 1.45, 0.5
1609, 0.89130434782609, 1.45, 0.5
1610, 0.93478260869565, 1.45, 0.5
1611, 0.97826086956522, 1.45, 0.5
1612, 0.043478260869565, 1.55, 0.5
1613, 0.08695652173913, 1.55, 0.5
1614, 0.1304347826087, 1.55, 0.5
1615, 0.17391304347826, 1.55, 0.5
1616, 0.21739130434783, 1.55, 0.5
1617, 0.26086956521739, 1.55, 0.5
1618, 0.30434782608696, 1.55, 0.5
1619, 0.34782608695652, 1.55, 0.5
1620, 0.39130434782609, 1.55, 0.5
1621, 0.43478260869565, 1.55, 0.5
1622, 0.47826086956522, 1.55, 0.5
1623, 0.52173913043478, 1.55, 0.5
1624, 0.56521739130435, 1.55, 0.5
1625, 0.60869565217391, 1.55, 0.5
1626, 0.65217391304348, 1.55, 0.5
1627, 0.69565217391304, 1.55, 0.5
1628, 0.73913043478261, 1.55, 0.5
1629, 0.78260869565217, 1.55, 0.5
1630, 0.82608695652174, 1.55, 0.5
1631, 0.8695652173913, 1.55, 0.5
1632, 0.91304347826087, 1.55, 0.5
1633, 0.95652173913043, 1.55, 0.5
1634, 0.021739130434783, 1.55, 0.5
1635, 0.065217391304348, 1.55, 0.5
1636, 0.10869565217391, 1.55, 0.5
1637, 0.15217391304348, 1.55, 0.5
1638, 0.19565217391304, 1.55, 0.5
1639, 0.23913043478261, 1.55, 0.5
1640, 0.28260869565217, 1.55, 0.5
1641, 0.32608695652174, 1.55, 0.5
1642, 0.3695652173913, 1.55, 0.5
1643, 0.41304347826087, 1.55, 0.5
1644, 0.45652173913043, 1.55, 0.5
1645, 0.5, 1.55, 0.5
1646, 0.54347826086957, 1.55, 0.5
1647, 0.58695652173913, 1.55, 0.5
1648, 0.6304347826087, 1.55, 0.5
1649, 0.67391304347826, 1.55, 0.5
1650, 0.71739130434783, 1.55, 0.5
1651, 0.76086956521739, 1.55, 0.5
1652, 0.80434782608696, 1.55, 0.5
1653, 0.84782608695652, 1.55, 0.5
1654, 0.89130434782609, 1.55, 0.5
1655, 0.93478260869565, 1.55, 0.5
1656, 0.97826086956522, 1.55, 0.5
1657, 0, 1.45, 0.055555555555556
1658, 0, 1.45, 0.11111111111111
1659, 0, 1.45, 0.16666666666667
1660, 0, 1.45, 0.22222222222222
1661, 0, 1.45, 0.27777777777778
1662, 0, 1.45, 0.33333333333333
1663, 0, 1.45, 0.38888888888889
1664, 0, 1.45, 0.44444444444444
1665, 0, 1.45, 0.027777777777778
1666, 0, 1.45, 0.083333333333333
1667, 0, 1.45, 0.13888888888889
1668, 0, 1.45, 0.19444444444444
1669, 0, 1.45, 0.25
1670, 0, 1.45, 0.30555555555556
1671, 0, 1.45, 0.36111111111111
1672, 0, 1.45, 0.41666666666667
1673, 0, 1.45, 0.47222222222222
1674, 0, 1.55, 0.055555555555556
1675, 0, 1.55, 0.11111111111111
1676, 0, 1.55, 0.16666666666667
1677, 0, 1.55, 0.22222222222222
1678, 0, 1.55, 0.27777777777778
1679, 0, 1.55, 0.33333333333333
1680, 0, 1.55, 0.38888888888889
1681, 0, 1.55, 0.44444444444444
1682, 0, 1.55, 0.027777777777778
1683, 0, 1.55, 0.083333333333333
1684, 0, 1.55, 0.13888888888889
1685, 0, 1.55, 0.19444444444444
1686, 0, 1.55, 0.25
1687, 0, 1.55, 0.30555555555556
1688, 0, 1.55, 0.36111111111111
1689, 0, 1.55, 0.41666666666667
1690, 0, 1.55, 0.47222222222222
1691, 1.05, 1.45, 0.5
1692, 1.1, 1.45, 0.5
1693, 1.15, 1.45, 0.5
1694, 1.025, 1.45, 0.5
1695, 1.075, 1.45, 0.5
1696, 1.125, 1.45, 0.5
1697, 1.175, 1.45, 0.5
1698, 1.05, 1.55, 0.5
1699, 1.1, 1.55, 0.5
1700, 1.15, 1.55, 0.5
1701, 1.025, 1.55, 0.5
1702, 1.075, 1.55, 0.5
1703, 1.125, 1.55, 0.5
1704, 1.175, 1.55, 0.5
1705, 1.2, 1.4833333333333, 0.5
1706, 1.2, 1.5166666666667, 0.5
1707, 1.2, 1.4666666666667, 0.5
1708, 1.2, 1.5, 0.5
1709, 1.2, 1.5333333333333, 0.5
1710, 1.05, 1.45, 0
1711, 1.1, 1.45, 0
1712, 1.15, 1.45, 0
1713, 1.025, 1.45, 0
1714, 1.075, 1.45, 0
1715, 1.125, 1.45, 0
1716, 1.175, 1.45, 0
1717, 1.05, 1.55, 0
1718, 1.1, 1.55, 0
1719, 1.15, 1.55, 0
1720, 1.025, 1.55, 0
1721, 1.075, 1.55, 0
1722, 1.125, 1.55, 0
1723, 1.175, 1.55, 0
1724, 1.2, 1.4833333333333, 0
1725, 1.2, 1.5166666666667, 0
1726, 1.2, 1.4666666666667, 0
1727, 1.2, 1.5, 0
1728, 1.2, 1.5333333333333, 0
1729, 1.2, 1.45, 0.055555555555556
1730, 1.2, 1.45, 0.11111111111111
1731, 1.2, 1.45, 0.16666666666667
1732, 1.2, 1.45, 0.22222222222222
1733, 1.2, 1.45, 0.27777777777778
1734, 1.2, 1.45, 0.33333333333333
1735, 1.2, 1.45, 0.38888888888889
1736, 1.2, 1.45, 0.44444444444444
1737, 1.2, 1.45, 0.027777777777778
1738, 1.2, 1.45, 0.083333333333333
1739, 1.2, 1.45, 0.13888888888889
1740, 1.2, 1.45, 0.19444444444444
1741, 1.2, 1.45, 0.25
1742, 1.2, 1.45, 0.30555555555556
1743, 1.2, 1.45, 0.36111111111111
1744, 1.2, 1.45, 0.41666666666667
1745, 1.2, 1.45, 0.47222222222222
1746, 1.2, 1.55, 0.055555555555556
1747, 1.2, 1.55, 0.11111111111111
1748, 1.2, 1.55, 0.16666666666667
1749, 1.2, 1.55, 0.22222222222222
1750, 1.2, 1.55, 0.27777777777778
1751, 1.2, 1.55, 0.33333333333333
1752, 1.2, 1.55, 0.38888888888889
1753, 1.2, 1.55, 0.44444444444444
1754, 1.2, 1.55, 0.027777777777778
1755, 1.2, 1.55, 0.083333333333333
1756, 1.2, 1.55, 0.13888888888889
1757, 1.2, 1.55, 0.19444444444444
1758, 1.2, 1.55, 0.25
1759, 1.2, 1.55, 0.30555555555556
1760, 1.2, 1.55, 0.36111111111111
1761, 1.2, 1.55, 0.41666666666667
1762, 1.2, 1.55, 0.47222222222222
1763, 1, 1.6, 0.5
1764, 1, 1.65, 0.5
1765, 1, 1.7, 0.5
1766, 1, 1.575, 0.5
1767, 1, 1.625, 0.5
1768, 1, 1.675, 0.5
1769, 1, 1.725, 0.5
1770, 1.2, 1.6, 0.5
1771, 1.2, 1.65, 0.5
1772, 1.2, 1.7, 0.5
1773, 1.2, 1.575, 0.5
1774, 1.2, 1.625, 0.5
1775, 1.2, 1.675, 0.5
1776, 1.2, 1.725, 0.5
1777, 1.05, 1.75, 0.5
1778, 1.1, 1.75, 0.5
1779, 1.15, 1.75, 0.5
1780, 1.025, 1.75, 0.5
1781, 1.075, 1.75, 0.5
1782, 1.125, 1.75, 0.5
1783, 1.175, 1.75, 0.5
1784, 1, 1.6, 0
1785, 1, 1.65, 0
1786, 1, 1.7, 0
1787, 1, 1.575, 0
1788, 1, 1.625, 0
1789, 1, 1.675, 0
1790, 1, 1.725, 0
1791, 1.2, 1.6, 0
1792, 1.2, 1.65, 0
1793, 1.2, 1.7, 0
1794, 1.2, 1.575, 0
1795, 1.2, 1.625, 0
1796, 1.2, 1.675, 0
1797, 1.2, 1.725, 0
1798, 1.05, 1.75, 0
1799, 1.1, 1.75, 0
1800, 1.15, 1.75, 0
1801, 1.025, 1.75, 0
1802, 1.075, 1.75, 0
1803, 1.125, 1.75, 0
1804, 1.175, 1.75, 0
1805, 1, 1.75, 0.055555555555556
1806, 1, 1.75, 0.11111111111111
1807, 1, 1.75, 0.16666666666667
1808, 1, 1.75, 0.22222222222222
1809, 1, 1.75, 0.27777777777778
1810, 1, 1.75, 0.33333333333333
1811, 1, 1.75, 0.38888888888889
1812, 1, 1.75, 0.44444444444444
1813, 1, 1.75, 0.027777777777778
1814, 1, 1.75, 0.083333333333333
1815, 1, 1.75, 0.13888888888889
1816, 1, 1.75, 0.19444444444444
1817, 1, 1.75, 0.25
1818, 1, 1.75, 0.30555555555556
1819, 1, 1.75, 0.36111111111111
1820, 1, 1.75, 0.41666666666667
1821, 1, 1.75, 0.47222222222222
1822, 1.2, 1.75, 0.055555555555556
1823, 1.2, 1.75, 0.11111111111111
1824, 1.2, 1.75, 0.16666666666667
1825, 1.2, 1.75, 0.22222222222222
1826, 1.2, 1.75, 0.27777777777778
1827, 1.2, 1.75, 0.33333333333333
1828, 1.2, 1.75, 0.38888888888889
1829, 1.2, 1.75, 0.44444444444444
1830, 1.2, 1.75, 0.027777777777778
1831, 1.2, 1.75, 0.083333333333333
1832, 1.2, 1.75, 0.13888888888889
1833, 1.2, 1.75, 0.19444444444444
1834, 1.2, 1.75, 0.25
1835, 1.2, 1.75, 0.30555555555556
1836, 1.2, 1.75, 0.36111111111111
1837, 1.2, 1.75, 0.41666666666667
1838, 1.2, 1.75, 0.47222222222222
1839, 0, 1.6, 0
1840, 0, 1.65, 0
1841, 0, 1.7, 0
1842, 0, 1.575, 0
1843, 0, 1.625, 0
1844, 0, 1.675, 0
1845, 0, 1.725, 0
1846, 0.043478260869565, 1.75, 0
1847, 0.08695652173913, 1.75, 0
1848, 0.1304347826087, 1.75, 0
1849, 0.17391304347826, 1.75, 0
1850, 0.21739130434783, 1.75, 0
1851, 0.26086956521739, 1.75, 0
1852, 0.30434782608696, 1.75, 0
1853, 0.34782608695652, 1.75, 0
1854, 0.39130434782609, 1.75, 0
1855, 0.43478260869565, 1.75, 0
1856, 0.47826086956522, 1.75, 0
1857, 0.52173913043478, 1.75, 0
1858, 0.56521739130435, 1.75, 0
1859, 0.60869565217391, 1.75, 0
1860, 0.65217391304348, 1.75, 0
1861, 0.69565217391304, 1.75, 0
1862, 0.73913043478261, 1.75, 0
1863, 0.78260869565217, 1.75, 0
1864, 0.82608695652174, 1.75, 0
1865, 0.8695652173913, 1.75, 0
1866, 0.91304347826087, 1.75, 0
1867, 0.95652173913043, 1.75, 0
1868, 0.021739130434783, 1.75, 0
1869, 0.065217391304348, 1.75, 0
1870, 0.10869565217391, 1.75, 0
1871, 0.15217391304348, 1.75, 0
1872, 0.19565217391304, 1.75, 0
1873, 0.23913043478261, 1.75, 0
1874, 0.28260869565217, 1.75, 0
1875, 0.32608695652174, 1.75, 0
1876, 0.3695652173913, 1.75, 0
1877, 0.41304347826087, 1.75, 0
1878, 0.45652173913043, 1.75, 0
1879, 0.5, 1.75, 0
1880, 0.54347826086957, 1.75, 0
1881, 0.58695652173913, 1.75, 0
1882, 0.6304347826087, 1.75, 0
1883, 0.67391304347826, 1.75, 0
1884, 0.71739130434783, 1.75, 0
1885, 0.76086956521739, 1.75, 0
1886, 0.80434782608696, 1.75, 0
1887, 0.84782608695652, 1.75, 0
1888, 0.89130434782609, 1.75, 0
1889, 0.93478260869565, 1.75, 0
1890, 0.97826086956522, 1.75, 0
1891, 0, 1.6, 0.5
1892, 0, 1.65, 0.5
1893, 0, 1.7, 0.5
1894, 0, 1.575, 0.5
1895, 0, 1.625, 0.5
1896, 0, 1.675, 0.5
1897, 0, 1.725, 0.5
1898, 0.043478260869565, 1.75, 0.5
1899, 0.08695652173913, 1.75, 0.5
1900, 0.1304347826087, 1.75, 0.5
1901, 0.17391304347826, 1.75, 0.5
1902, 0.21739130434783, 1.75, 0.5
1903, 0.26086956521739, 1.75, 0.5
1904, 0.30434782608696, 1.75, 0.5
1905, 0.34782608695652, 1.75, 0.5
1906, 0.39130434782609, 1.75, 0.5
1907, 0.43478260869565, 1.75, 0.5
1908, 0.47826086956522, 1.75, 0.5
1909, 0.52173913043478, 1.75, 0.5
1910, 0.56521739130435, 1.75, 0.5
1911, 0.60869565217391, 1.75, 0.5
1912, 0.65217391304348, 1.75, 0.5
1913, 0.69565217391304, 1.75, 0.5
1914, 0.73913043478261, 1.75, 0.5
1915, 0.78260869565217, 1.75, 0.5
1916, 0.82608695652174, 1.75, 0.5
1917, 0.8695652173913, 1.75, 0.5
1918, 0.91304347826087, 1.75, 0.5
1919, 0.95652173913043, 1.75, 0.5
1920, 0.021739130434783, 1.75, 0.5
1921, 0.065217391304348, 1.75, 0.5
1922, 0.10869565217391, 1.75, 0.5
1923, 0.15217391304348, 1.75, 0.5
1924, 0.19565217391304, 1.75, 0.5
1925, 0.23913043478261, 1.75, 0.5
1926, 0.28260869565217, 1.75, 0.5
1927, 0.32608695652174, 1.75, 0.5
1928, 0.3695652173913, 1.75, 0.5
1929, 0.41304347826087, 1.75, 0.5
1930, 0.45652173913043, 1.75, 0.5
1931, 0.5, 1.75, 0.5
1932, 0.54347826086957, 1.75, 0.5
1933, 0.58695652173913, 1.75, 0.5
1934, 0.6304347826087, 1.75, 0.5
1935, 0.67391304347826, 1.75, 0.5
1936, 0.71739130434783, 1.75, 0.5
1937, 0.76086956521739, 1.75, 0.5
1938, 0.80434782608696, 1.75, 0.5
1939, 0.84782608695652, 1.75, 0.5
1940, 0.89130434782609, 1.75, 0.5
1941, 0.93478260869565, 1.75, 0.5
1942, 0.97826086956522, 1.75, 0.5
1943, 0, 1.75, 0.055555555555556
1944, 0, 1.75, 0.11111111111111
1945, 0, 1.75, 0.16666666666667
1946, 0, 1.75, 0.22222222222222
1947, 0, 1.75, 0.27777777777778
1948, 0, 1.75, 0.33333333333333
1949, 0, 1.75, 0.38888888888889
1950, 0, 1.75, 0.44444444444444
1951, 0, 1.75, 0.027777777777778
1952, 0, 1.75, 0.083333333333333
1953, 0, 1.75, 0.13888888888889
1954, 0, 1.75, 0.19444444444444
1955, 0, 1.75, 0.25
1956, 0, 1.75, 0.30555555555556
1957, 0, 1.75, 0.36111111111111
1958, 0, 1.75, 0.41666666666667
1959, 0, 1.75, 0.47222222222222
1960, -0.05, 1.55, 0.5
1961, -0.025, 1.55, 0.5
1962, -0.075, 1.55, 0.5
1963, -0.05, 1.75, 0.5
1964, -0.025, 1.75, 0.5
1965, -0.075, 1.75, 0.5
1966, -0.1, 1.6, 0.5
1967, -0.1, 1.65, 0.5
1968, -0.1, 1.7, 0.5
1969, -0.1, 1.575, 0.5
1970, -0.1, 1.625, 0.5
1971, -0.1, 1.675, 0.5
1972, -0.1, 1.725, 0.5
1973, -0.05, 1.55, 0
1974, -0.025, 1.55, 0
1975, -0.075, 1.55, 0
1976, -0.05, 1.75, 0
1977, -0.025, 1.75, 0
1978, -0.075, 1.75, 0
1979, -0.1, 1.6, 0
1980, -0.1, 1.65, 0
1981, -0.1, 1.7, 0
1982, -0.1, 1.575, 0
1983, -0.1, 1.625, 0
1984, -0.1, 1.675, 0
1985, -0.1, 1.725, 0
1986, -0.1, 1.55, 0.055555555555556
1987, -0.1, 1.55, 0.11111111111111
1988, -0.1, 1.55, 0.16666666666667
1989, -0.1, 1.55, 0.22222222222222
1990, -0.1, 1.55, 0.27777777777778
1991, -0.1, 1.55, 0.33333333333333
1992, -0.1, 1.55, 0.38888888888889
1993, -0.1, 1.55, 0.44444444444444
1994, -0.1, 1.55, 0.027777777777778
1995, -0.1, 1.55, 0.083333333333333
1996, -0.1, 1.55, 0.13888888888889
1997, -0.1, 1.55, 0.19444444444444
1998, -0.1, 1.55, 0.25
1999, -0.1, 1.55, 0.30555555555556
2000, -0.1, 1.55, 0.36111111111111
2001, -0.1, 1.55, 0.41666666666667
2002, -0.1, 1.55, 0.47222222222222
2003, -0.1, 1.75, 0.055555555555556
2004, -0.1, 1.75, 0.11111111111111
2005, -0.1, 1.75, 0.16666666666667
2006, -0.1, 1.75, 0.22222222222222
2007, -0.1, 1.75, 0.27777777777778
2008, -0.1, 1.75, 0.33333333333333
2009, -0.1, 1.75, 0.38888888888889
2010, -0.1, 1.75, 0.44444444444444
2011, -0.1, 1.75, 0.027777777777778
2012, -0.1, 1.75, 0.083333333333333
2013, -0.1, 1.75, 0.13888888888889
2014, -0.1, 1.75, 0.19444444444444
2015, -0.1, 1.75, 0.25
2016, -0.1, 1.75, 0.30555555555556
2017, -0.1, 1.75, 0.36111111111111
2018, -0.1, 1.75, 0.41666666666667
2019, -0.1, 1.75, 0.47222222222222
2020, 1, 1.425, 0
2021, 1, 1.4125, 0
2022, 1, 1.4375, 0
2023, 0, 1.425, 0
2024, 0, 1.4125, 0
2025, 0, 1.4375, 0
2026, 0.043478260869565, 1.4, 0
2027, 0.08695652173913, 1.4, 0
2028, 0.1304347826087, 1.4, 0
2029, 0.17391304347826, 1.4, 0
2030, 0.21739130434783, 1.4, 0
2031, 0.26086956521739, 1.4, 0
2032, 0.30434782608696, 1.4, 0
2033, 0.34782608695652, 1.4, 0
2034, 0.39130434782609, 1.4, 0
2035, 0.43478260869565, 1.4, 0
2036, 0.47826086956522, 1.4, 0
2037, 0.52173913043478, 1.4, 0
2038, 0.56521739130435, 1.4, 0
2039, 0.60869565217391, 1.4, 0
2040, 0.65217391304348, 1.4, 0
2041, 0.69565217391304, 1.4, 0
2042, 0.73913043478261, 1.4, 0
2043, 0.78260869565217, 1.4, 0
2044, 0.82608695652174, 1.4, 0
2045, 0.8695652173913, 1.4, 0
2046, 0.91304347826087, 1.4, 0
2047, 0.95652173913043, 1.4, 0
2048, 0.021739130434783, 1.4, 0
2049, 0.065217391304348, 1.4, 0
2050, 0.10869565217391, 1.4, 0
2051, 0.15217391304348, 1.4, 0
2052, 0.19565217391304, 1.4, 0
2053, 0.23913043478261, 1.4, 0
2054, 0.28260869565217, 1.4, 0
2055, 0.32608695652174, 1.4, 0
2056, 0.3695652173913, 1.4, 0
2057, 0.41304347826087, 1.4, 0
2058, 0.45652173913043, 1.4, 0
2059, 0.5, 1.4, 0
2060, 0.54347826086957, 1.4, 0
2061, 0.58695652173913, 1.4, 0
2062, 0.6304347826087, 1.4, 0
2063, 0.67391304347826, 1.4, 0
2064, 0.71739130434783, 1.4, 0
2065, 0.76086956521739, 1.4, 0
2066, 0.80434782608696, 1.4, 0
2067, 0.84782608695652, 1.4, 0
2068, 0.89130434782609, 1.4, 0
2069, 0.93478260869565, 1.4, 0
2070, 0.97826086956522, 1.4, 0
2071, 1, 1.425, 0.5
2072, 1, 1.4125, 0.5
2073, 1, 1.4375, 0.5
2074, 1, 1.4, 0.055555555555556
2075, 1, 1.4, 0.11111111111111
2076, 1, 1.4, 0.16666666666667
2077, 1, 1.4, 0.22222222222222
2078, 1, 1.4, 0.27777777777778
2079, 1, 1.4, 0.33333333333333
2080, 1, 1.4, 0.38888888888889
2081, 1, 1.4, 0.44444444444444
2082, 1, 1.4, 0.027777777777778
2083, 1, 1.4, 0.083333333333333
2084, 1, 1.4, 0.13888888888889
2085, 1, 1.4, 0.19444444444444
2086, 1, 1.4, 0.25
2087, 1, 1.4, 0.30555555555556
2088, 1, 1.4, 0.36111111111111
2089, 1, 1.4, 0.41666666666667
2090, 1, 1.4, 0.47222222222222
2091, 0, 1.425, 0.5
2092, 0, 1.4125, 0.5
2093, 0, 1.4375, 0.5
2094, 0.043478260869565, 1.4, 0.5
2095, 0.08695652173913, 1.4, 0.5
2096, 0.1304347826087, 1.4, 0.5
2097, 0.17391304347826, 1.4, 0.5
2098, 0.21739130434783, 1.4, 0.5
2099, 0.26086956521739, 1.4, 0.5
2100, 0.30434782608696, 1.4, 0.5
2101, 0.34782608695652, 1.4, 0.5
2102, 0.39130434782609, 1.4, 0.5
2103, 0.43478260869565, 1.4, 0.5
2104, 0.47826086956522, 1.4, 0.5
2105, 0.52173913043478, 1.4, 0.5
2106, 0.56521739130435, 1.4, 0.5
2107, 0.60869565217391, 1.4, 0.5
2108, 0.65217391304348, 1.4, 0.5
2109, 0.69565217391304, 1.4, 0.5
2110, 0.73913043478261, 1.4, 0.5
2111, 0.78260869565217, 1.4, 0.5
2112, 0.82608695652174, 1.4, 0.5
2113, 0.8695652173913, 1.4, 0.5
2114, 0.91304347826087, 1.4, 0.5
2115, 0.95652173913043, 1.4, 0.5
2116, 0.021739130434783, 1.4, 0.5
2117, 0.065217391304348, 1.4, 0.5
2118, 0.10869565217391, 1.4, 0.5
2119, 0.15217391304348, 1.4, 0.5
2120, 0.19565217391304, 1.4, 0.5
2121, 0.23913043478261, 1.4, 0.5
2122, 0.28260869565217, 1.4, 0.5
2123, 0.32608695652174, 1.4, 0.5
2124, 0.3695652173913, 1.4, 0.5
2125, 0.41304347826087, 1.4, 0.5
2126, 0.45652173913043, 1.4, 0.5
2127, 0.5, 1.4, 0.5
2128, 0.54347826086957, 1.4, 0.5
2129, 0.58695652173913, 1.4, 0.5
2130, 0.6304347826087, 1.4, 0.5
2131, 0.67391304347826, 1.4, 0.5
2132, 0.71739130434783, 1.4, 0.5
2133, 0.76086956521739, 1.4, 0.5
2134, 0.80434782608696, 1.4, 0.5
2135, 0.84782608695652, 1.4, 0.5
2136, 0.89130434782609, 1.4, 0.5
2137, 0.93478260869565, 1.4, 0.5
2138, 0.97826086956522, 1.4, 0.5
2139, 0, 1.4, 0.055555555555556
2140, 0, 1.4, 0.11111111111111
2141, 0, 1.4, 0.16666666666667
2142, 0, 1.4, 0.22222222222222
2143, 0, 1.4, 0.27777777777778
2144, 0, 1.4, 0.33333333333333
2145, 0, 1.4, 0.38888888888889
2146, 0, 1.4, 0.44444444444444
2147, 0, 1.4, 0.027777777777778
2148, 0, 1.4, 0.083333333333333
2149, 0, 1.4, 0.13888888888889
2150, 0, 1.4, 0.19444444444444
2151, 0, 1.4, 0.25
2152, 0, 1.4, 0.30555555555556
2153, 0, 1.4, 0.36111111111111
2154, 0, 1.4, 0.41666666666667
2155, 0, 1.4, 0.47222222222222
2156, 1.2, 1.425, 0.5
2157, 1.2, 1.4375, 0.5
2158, 1.2, 1.4125, 0.5
2159, 2.2, 1.425, 0.5
2160, 2.2, 1.4375, 0.5
2161, 2.2, 1.4125, 0.5
2162, 1.2434782608696, 1.45, 0.5
2163, 1.2869565217391, 1.45, 0.5
2164, 1.3304347826087, 1.45, 0.5
2165, 1.3739130434783, 1.45, 0.5
2166, 1.4173913043478, 1.45, 0.5
2167, 1.4608695652174, 1.45, 0.5
2168, 1.504347826087, 1.45, 0.5
2169, 1.5478260869565, 1.45, 0.5
2170, 1.5913043478261, 1.45, 0.5
2171, 1.6347826086957, 1.45, 0.5
2172, 1.6782608695652, 1.45, 0.5
2173, 1.7217391304348, 1.45, 0.5
2174, 1.7652173913043, 1.45, 0.5
2175, 1.8086956521739, 1.45, 0.5
2176, 1.8521739130435, 1.45, 0.5
2177, 1.895652173913, 1.45, 0.5
2178, 1.9391304347826, 1.45, 0.5
2179, 1.9826086956522, 1.45, 0.5
2180, 2.0260869565217, 1.45, 0.5
2181, 2.0695652173913, 1.45, 0.5
2182, 2.1130434782609, 1.45, 0.5
2183, 2.1565217391304, 1.45, 0.5
2184, 1.2217391304348, 1.45, 0.5
2185, 1.2652173913043, 1.45, 0.5
2186, 1.3086956521739, 1.45, 0.5
2187, 1.3521739130435, 1.45, 0.5
2188, 1.395652173913, 1.45, 0.5
2189, 1.4391304347826, 1.45, 0.5
2190, 1.4826086956522, 1.45, 0.5
2191, 1.5260869565217, 1.45, 0.5
2192, 1.5695652173913, 1.45, 0.5
2193, 1.6130434782609, 1.45, 0.5
2194, 1.6565217391304, 1.45, 0.5
2195, 1.7, 1.45, 0.5
2196, 1.7434782608696, 1.45, 0.5
2197, 1.7869565217391, 1.45, 0.5
2198, 1.8304347826087, 1.45, 0.5
2199, 1.8739130434783, 1.45, 0.5
2200, 1.9173913043478, 1.45, 0.5
2201, 1.9608695652174, 1.45, 0.5
2202, 2.004347826087, 1.45, 0.5
2203, 2.0478260869565, 1.45, 0.5
2204, 2.0913043478261, 1.45, 0.5
2205, 2.1347826086957, 1.45, 0.5
2206, 2.1782608695652, 1.45, 0.5
2207, 1.2434782608696, 1.4, 0.5
2208, 1.2869565217391, 1.4, 0.5
2209, 1.3304347826087, 1.4, 0.5
2210, 1.3739130434783, 1.4, 0.5
2211, 1.4173913043478, 1.4, 0.5
2212, 1.4608695652174, 1.4, 0.5
2213, 1.504347826087, 1.4, 0.5
2214, 1.5478260869565, 1.4, 0.5
2215, 1.5913043478261, 1.4, 0.5
2216, 1.6347826086957, 1.4, 0.5
2217, 1.6782608695652, 1.4, 0.5
2218, 1.7217391304348, 1.4, 0.5
2219, 1.7652173913043, 1.4, 0.5
2220, 1.8086956521739, 1.4, 0.5
2221, 1.8521739130435, 1.4, 0.5
2222, 1.895652173913, 1.4, 0.5
2223, 1.9391304347826, 1.4, 0.5
2224, 1.9826086956522, 1.4, 0.5
2225, 2.0260869565217, 1.4, 0.5
2226, 2.0695652173913, 1.4, 0.5
2227, 2.1130434782609, 1.4, 0.5
2228, 2.1565217391304, 1.4, 0.5
2229, 1.2217391304348, 1.4, 0.5
2230, 1.2652173913043, 1.4, 0.5
2231, 1.3086956521739, 1.4, 0.5
2232, 1.3521739130435, 1.4, 0.5
2233, 1.395652173913, 1.4, 0.5
2234, 1.4391304347826, 1.4, 0.5
2235, 1.4826086956522, 1.4, 0.5
2236, 1.5260869565217, 1.4, 0.5
2237, 1.5695652173913, 1.4, 0.5
2238, 1.6130434782609, 1.4, 0.5
2239, 1.6565217391304, 1.4, 0.5
2240, 1.7, 1.4, 0.5
2241, 1.7434782608696, 1.4, 0.5
2242, 1.7869565217391, 1.4, 0.5
2243, 1.8304347826087, 1.4, 0.5
2244, 1.8739130434783, 1.4, 0.5
2245, 1.9173913043478, 1.4, 0.5
2246, 1.9608695652174, 1.4, 0.5
2247, 2.004347826087, 1.4, 0.5
2248, 2.0478260869565, 1.4, 0.5
2249, 2.0913043478261, 1.4, 0.5
2250, 2.1347826086957, 1.4, 0.5
2251, 2.1782608695652, 1.4, 0.5
2252, 1.2, 1.425, 0
2253, 1.2, 1.4375, 0
2254, 1.2, 1.4125, 0
2255, 2.2, 1.425, 0
2256, 2.2, 1.4375, 0
2257, 2.2, 1.4125, 0
2258, 1.2434782608696, 1.45, 0
2259, 1.2869565217391, 1.45, 0
2260, 1.3304347826087, 1.45, 0
2261, 1.3739130434783, 1.45, 0
2262, 1.4173913043478, 1.45, 0
2263, 1.4608695652174, 1.45, 0
2264, 1.504347826087, 1.45, 0
2265, 1.5478260869565, 1.45, 0
2266, 1.5913043478261, 1.45, 0
2267, 1.6347826086957, 1.45, 0
2268, 1.6782608695652, 1.45, 0
2269, 1.7217391304348, 1.45, 0
2270, 1.7652173913043, 1.45, 0
2271, 1.8086956521739, 1.45, 0
2272, 1.8521739130435, 1.45, 0
2273, 1.895652173913, 1.45, 0
2274, 1.9391304347826, 1.45, 0
2275, 1.9826086956522, 1.45, 0
2276, 2.0260869565217, 1.45, 0
2277, 2.0695652173913, 1.45, 0
2278, 2.1130434782609, 1.45, 0
2279, 2.1565217391304, 1.45, 0
2280, 1.2217391304348, 1.45, 0
2281, 1.2652173913043, 1.45, 0
2282, 1.3086956521739, 1.45, 0
2283, 1.3521739130435, 1.45, 0
2284, 1.395652173913, 1.45, 0
2285, 1.4391304347826, 1.45, 0
2286, 1.4826086956522, 1.45, 0
2287, 1.5260869565217, 1.45, 0
2288, 1.5695652173913, 1.45, 0
2289, 1.6130434782609, 1.45, 0
2290, 1.6565217391304, 1.45, 0
2291, 1.7, 1.45, 0
2292, 1.7434782608696, 1.45, 0
2293, 1.7869565217391, 1.45, 0
2294, 1.8304347826087, 1.45, 0
2295, 1.8739130434783, 1.45, 0
2296, 1.9173913043478, 1.45, 0
2297, 1.9608695652174, 1.45, 0
2298, 2.004347826087, 1.45, 0
2299, 2.0478260869565, 1.45, 0
2300, 2.0913043478261, 1.45, 0
2301, 2.1347826086957, 1.45, 0
2302, 2.1782608695652, 1.45, 0
2303, 1.2434782608696, 1.4, 0
2304, 1.2869565217391, 1.4, 0
2305, 1.3304347826087, 1.4, 0
2306, 1.3739130434783, 1.4, 0
2307, 1.4173913043478, 1.4, 0
2308, 1.4608695652174, 1.4, 0
2309, 1.504347826087, 1.4, 0
2310, 1.5478260869565, 1.4, 0
2311, 1.5913043478261, 1.4, 0
2312, 1.6347826086957, 1.4, 0
2313, 1.6782608695652, 1.4, 0
2314, 1.7217391304348, 1.4, 0
2315, 1.7652173913043, 1.4, 0
2316, 1.8086956521739, 1.4, 0
2317, 1.8521739130435, 1.4, 0
2318, 1.895652173913, 1.4, 0
2319, 1.9391304347826, 1.4, 0
2320, 1.9826086956522, 1.4, 0
2321, 2.0260869565217, 1.4, 0
2322, 2.0695652173913, 1.4, 0
2323, 2.1130434782609, 1.4, 0
2324, 2.1565217391304, 1.4, 0
2325, 1.2217391304348, 1.4, 0
2326, 1.2652173913043, 1.4, 0
2327, 1.3086956521739, 1.4, 0
2328, 1.3521739130435, 1.4, 0
2329, 1.395652173913, 1.4, 0
2330, 1.4391304347826, 1.4, 0
2331, 1.4826086956522, 1.4, 0
2332, 1.5260869565217, 1.4, 0
2333, 1.5695652173913, 1.4, 0
2334, 1.6130434782609, 1.4, 0
2335, 1.6565217391304, 1.4, 0
2336, 1.7, 1.4, 0
2337, 1.7434782608696, 1.4, 0
2338, 1.7869565217391, 1.4, 0
2339, 1.8304347826087, 1.4, 0
2340, 1.8739130434783, 1.4, 0
2341, 1.9173913043478, 1.4, 0
2342, 1.9608695652174, 1.4, 0
2343, 2.004347826087, 1.4, 0
2344, 2.0478260869565, 1.4, 0
2345, 2.0913043478261, 1.4, 0
2346, 2.1347826086957, 1.4, 0
2347, 2.1782608695652, 1.4, 0
2348, 1.2, 1.4, 0.055555555555556
2349, 1.2, 1.4, 0.11111111111111
2350, 1.2, 1.4, 0.16666666666667
2351, 1.2, 1.4, 0.22222222222222
2352, 1.2, 1.4, 0.27777777777778
2353, 1.2, 1.4, 0.33333333333333
2354, 1.2, 1.4, 0.38888888888889
2355, 1.2, 1.4, 0.44444444444444
2356, 1.2, 1.4, 0.027777777777778
2357, 1.2, 1.4, 0.083333333333333
2358, 1.2, 1.4, 0.13888888888889
2359, 1.2, 1.4, 0.19444444444444
2360, 1.2, 1.4, 0.25
2361, 1.2, 1.4, 0.30555555555556
2362, 1.2, 1.4, 0.36111111111111
2363, 1.2, 1.4, 0.41666666666667
2364, 1.2, 1.4, 0.47222222222222
2365, 2.2, 1.45, 0.055555555555556
2366, 2.2, 1.45, 0.11111111111111
2367, 2.2, 1.45, 0.16666666666667
2368, 2.2, 1.45, 0.22222222222222
2369, 2.2, 1.45, 0.27777777777778
2370, 2.2, 1.45, 0.33333333333333
2371, 2.2, 1.45, 0.38888888888889
2372, 2.2, 1.45, 0.44444444444444
2373, 2.2, 1.45, 0.027777777777778
2374, 2.2, 1.45, 0.083333333333333
2375, 2.2, 1.45, 0.13888888888889
2376, 2.2, 1.45, 0.19444444444444
2377, 2.2, 1.45, 0.25
2378, 2.2, 1.45, 0.30555555555556
2379, 2.2, 1.45, 0.36111111111111
2380, 2.2, 1.45, 0.41666666666667
2381, 2.2, 1.45, 0.47222222222222
2382, 2.2, 1.4, 0.055555555555556
2383, 2.2, 1.4, 0.11111111111111
2384, 2.2, 1.4, 0.16666666666667
2385, 2.2, 1.4, 0.22222222222222
2386, 2.2, 1.4, 0.27777777777778
2387, 2.2, 1.4, 0.33333333333333
2388, 2.2, 1.4, 0.38888888888889
2389, 2.2, 1.4, 0.44444444444444
2390, 2.2, 1.4, 0.027777777777778
2391, 2.2, 1.4, 0.083333333333333
2392, 2.2, 1.4, 0.13888888888889
2393, 2.2, 1.4, 0.19444444444444
2394, 2.2, 1.4, 0.25
2395, 2.2, 1.4, 0.30555555555556
2396, 2.2, 1.4, 0.36111111111111
2397, 2.2, 1.4, 0.41666666666667
2398, 2.2, 1.4, 0.47222222222222
2399, 1.2434782608696, 1.55, 0.5
2400, 1.2869565217391, 1.55, 0.5
2401, 1.3304347826087, 1.55, 0.5
2402, 1.3739130434783, 1.55, 0.5
2403, 1.4173913043478, 1.55, 0.5
2404, 1.4608695652174, 1.55, 0.5
2405, 1.504347826087, 1.55, 0.5
2406, 1.5478260869565, 1.55, 0.5
2407, 1.5913043478261, 1.55, 0.5
2408, 1.6347826086957, 1.55, 0.5
2409, 1.6782608695652, 1.55, 0.5
2410, 1.7217391304348, 1.55, 0.5
2411, 1.7652173913043, 1.55, 0.5
2412, 1.8086956521739, 1.55, 0.5
2413, 1.8521739130435, 1.55, 0.5
2414, 1.895652173913, 1.55, 0.5
2415, 1.9391304347826, 1.55, 0.5
2416, 1.9826086956522, 1.55, 0.5
2417, 2.0260869565217, 1.55, 0.5
2418, 2.0695652173913, 1.55, 0.5
2419, 2.1130434782609, 1.55, 0.5
2420, 2.1565217391304, 1.55, 0.5
2421, 1.2217391304348, 1.55, 0.5
2422, 1.2652173913043, 1.55, 0.5
2423, 1.3086956521739, 1.55, 0.5
2424, 1.3521739130435, 1.55, 0.5
2425, 1.395652173913, 1.55, 0.5
2426, 1.4391304347826, 1.55, 0.5
2427, 1.4826086956522, 1.55, 0.5
2428, 1.5260869565217, 1.55, 0.5
2429, 1.5695652173913, 1.55, 0.5
2430, 1.6130434782609, 1.55, 0.5
2431, 1.6565217391304, 1.55, 0.5
2432, 1.7, 1.55, 0.5
2433, 1.7434782608696, 1.55, 0.5
2434, 1.7869565217391, 1.55, 0.5
2435, 1.8304347826087, 1.55, 0.5
2436, 1.8739130434783, 1.55, 0.5
2437, 1.9173913043478, 1.55, 0.5
2438, 1.9608695652174, 1.55, 0.5
2439, 2.004347826087, 1.55, 0.5
2440, 2.0478260869565, 1.55, 0.5
2441, 2.0913043478261, 1.55, 0.5
2442, 2.1347826086957, 1.55, 0.5
2443, 2.1782608695652, 1.55, 0.5
2444, 2.2, 1.4833333333333, 0.5
2445, 2.2, 1.5166666666667, 0.5
2446, 2.2, 1.4666666666667, 0.5
2447, 2.2, 1.5, 0.5
2448, 2.2, 1.5333333333333, 0.5
2449, 1.2434782608696, 1.55, 0
2450, 1.2869565217391, 1.55, 0
2451, 1.3304347826087, 1.55, 0
2452, 1.3739130434783, 1.55, 0
2453, 1.4173913043478, 1.55, 0
2454, 1.4608695652174, 1.55, 0
2455, 1.504347826087, 1.55, 0
2456, 1.5478260869565, 1.55, 0
2457, 1.5913043478261, 1.55, 0
2458, 1.6347826086957, 1.55, 0
2459, 1.6782608695652, 1.55, 0
2460, 1.7217391304348, 1.55, 0
2461, 1.7652173913043, 1.55, 0
2462, 1.8086956521739, 1.55, 0
2463, 1.8521739130435, 1.55, 0
2464, 1.895652173913, 1.55, 0
2465, 1.9391304347826, 1.55, 0
2466, 1.9826086956522, 1.55, 0
2467, 2.0260869565217, 1.55, 0
2468, 2.0695652173913, 1.55, 0
2469, 2.1130434782609, 1.55, 0
2470, 2.1565217391304, 1.55, 0
2471, 1.2217391304348, 1.55, 0
2472, 1.2652173913043, 1.55, 0
2473, 1.3086956521739, 1.55, 0
2474, 1.3521739130435, 1.55, 0
2475, 1.395652173913, 1.55, 0
2476, 1.4391304347826, 1.55, 0
2477, 1.4826086956522, 1.55, 0
2478, 1.5260869565217, 1.55, 0
2479, 1.5695652173913, 1.55, 0
2480, 1.6130434782609, 1.55, 0
2481, 1.6565217391304, 1.55, 0
2482, 1.7, 1.55, 0
2483, 1.7434782608696, 1.55, 0
2484, 1.7869565217391, 1.55, 0
2485, 1.8304347826087, 1.55, 0
2486, 1.8739130434783, 1.55, 0
2487, 1.9173913043478, 1.55, 0
2488, 1.9608695652174, 1.55, 0
2489, 2.004347826087, 1.55, 0
2490, 2.0478260869565, 1.55, 0
2491, 2.0913043478261, 1.55, 0
2492, 2.1347826086957, 1.55, 0
2493, 2.1782608695652, 1.55, 0
2494, 2.2, 1.4833333333333, 0
2495, 2.2, 1.5166666666667, 0
2496, 2.2, 1.4666666666667, 0
2497, 2.2, 1.5, 0
2498, 2.2, 1.5333333333333, 0
2499, 2.2, 1.55, 0.055555555555556
2500, 2.2, 1.55, 0.11111111111111
2501, 2.2, 1.55, 0.16666666666667
2502, 2.2, 1.55, 0.22222222222222
2503, 2.2, 1.55, 0.27777777777778
2504, 2.2, 1.55, 0.33333333333333
2505, 2.2, 1.55, 0.38888888888889
2506, 2.2, 1.55, 0.44444444444444
2507, 2.2, 1.55, 0.027777777777778
2508, 2.2, 1.55, 0.083333333333333
2509, 2.2, 1.55, 0.13888888888889
2510, 2.2, 1.55, 0.19444444444444
2511, 2.2, 1.55, 0.25
2512, 2.2, 1.55, 0.30555555555556
2513, 2.2, 1.55, 0.36111111111111
2514, 2.2, 1.55, 0.41666666666667
2515, 2.2, 1.55, 0.47222222222222
2516, 2.2, 1.6, 0.5
2517, 2.2, 1.65, 0.5
2518, 2.2, 1.7, 0.5
2519, 2.2, 1.575, 0.5
2520, 2.2, 1.625, 0.5
2521, 2.2, 1.675, 0.5
2522, 2.2, 1.725, 0.5
2523, 1.2434782608696, 1.75, 0.5
2524, 1.2869565217391, 1.75, 0.5
2525, 1.3304347826087, 1.75, 0.5
2526, 1.3739130434783, 1.75, 0.5
2527, 1.4173913043478, 1.75, 0.5
2528, 1.4608695652174, 1.75, 0.5
2529, 1.504347826087, 1.75, 0.5
2530, 1.5478260869565, 1.75, 0.5
2531, 1.5913043478261, 1.75, 0.5
2532, 1.6347826086957, 1.75, 0.5
2533, 1.6782608695652, 1.75, 0.5
2534, 1.7217391304348, 1.75, 0.5
2535, 1.7652173913043, 1.75, 0.5
2536, 1.8086956521739, 1.75, 0.5
2537, 1.8521739130435, 1.75, 0.5
2538, 1.895652173913, 1.75, 0.5
2539, 1.9391304347826, 1.75, 0.5
2540, 1.9826086956522, 1.75, 0.5
2541, 2.0260869565217, 1.75, 0.5
2542, 2.0695652173913, 1.75, 0.5
2543, 2.1130434782609, 1.75, 0.5
2544, 2.1565217391304, 1.75, 0.5
2545, 1.2217391304348, 1.75, 0.5
2546, 1.2652173913043, 1.75, 0.5
2547, 1.3086956521739, 1.75, 0.5
2548, 1.3521739130435, 1.75, 0.5
2549, 1.395652173913, 1.75, 0.5
2550, 1.4391304347826, 1.75, 0.5
2551, 1.4826086956522, 1.75, 0.5
2552, 1.5260869565217, 1.75, 0.5
2553, 1.5695652173913, 1.75, 0.5
2554, 1.6130434782609, 1.75, 0.5
2555, 1.6565217391304, 1.75, 0.5
2556, 1.7, 1.75, 0.5
2557, 1.7434782608696, 1.75, 0.5
2558, 1.7869565217391, 1.75, 0.5
2559, 1.8304347826087, 1.75, 0.5
2560, 1.8739130434783, 1.75, 0.5
2561, 1.9173913043478, 1.75, 0.5
2562, 1.9608695652174, 1.75, 0.5
2563, 2.004347826087, 1.75, 0.5
2564, 2.0478260869565, 1.75, 0.5
2565, 2.0913043478261, 1.75, 0.5
2566, 2.1347826086957, 1.75, 0.5
2567, 2.1782608695652, 1.75, 0.5
2568, 2.2, 1.6, 0
2569, 2.2, 1.65, 0
2570, 2.2, 1.7, 0
2571, 2.2, 1.575, 0
2572, 2.2, 1.625, 0
2573, 2.2, 1.675, 0
2574, 2.2, 1.725, 0
2575, 1.2434782608696, 1.75, 0
2576, 1.2869565217391, 1.75, 0
2577, 1.3304347826087, 1.75, 0
2578, 1.3739130434783, 1.75, 0
2579, 1.4173913043478, 1.75, 0
2580, 1.4608695652174, 1.75, 0
2581, 1.504347826087, 1.75, 0
2582, 1.5478260869565, 1.75, 0
2583, 1.5913043478261, 1.75, 0
2584, 1.6347826086957, 1.75, 0
2585, 1.6782608695652, 1.75, 0
2586, 1.7217391304348, 1.75, 0
2587, 1.7652173913043, 1.75, 0
2588, 1.8086956521739, 1.75, 0
2589, 1.8521739130435, 1.75, 0
2590, 1.895652173913, 1.75, 0
2591, 1.9391304347826, 1.75, 0
2592, 1.9826086956522, 1.75, 0
2593, 2.0260869565217, 1.75, 0
2594, 2.0695652173913, 1.75, 0
2595, 2.1130434782609, 1.75, 0
2596, 2.1565217391304, 1.75, 0
2597, 1.2217391304348, 1.75, 0
2598, 1.2652173913043, 1.75, 0
2599, 1.3086956521739, 1.75, 0
2600, 1.3521739130435, 1.75, 0
2601, 1.395652173913, 1.75, 0
2602, 1.4391304347826, 1.75, 0
2603, 1.4826086956522, 1.75, 0
2604, 1.5260869565217, 1.75, 0
2605, 1.5695652173913, 1.75, 0
2606, 1.6130434782609, 1.75, 0
2607, 1.6565217391304, 1.75, 0
2608, 1.7, 1.75, 0
2609, 1.7434782608696, 1.75, 0
2610, 1.7869565217391, 1.75, 0
2611, 1.8304347826087, 1.75, 0
2612, 1.8739130434783, 1.75, 0
2613, 1.9173913043478, 1.75, 0
2614, 1.9608695652174, 1.75, 0
2615, 2.004347826087, 1.75, 0
2616, 2.0478260869565, 1.75, 0
2617, 2.0913043478261, 1.75, 0
2618, 2.1347826086957, 1.75, 0
2619, 2.1782608695652, 1.75, 0
2620, 2.2, 1.75, 0.055555555555556
2621, 2.2, 1.75, 0.11111111111111
2622, 2.2, 1.75, 0.16666666666667
2623, 2.2, 1.75, 0.22222222222222
2624, 2.2, 1.75, 0.27777777777778
2625, 2.2, 1.75, 0.33333333333333
2626, 2.2, 1.75, 0.38888888888889
2627, 2.2, 1.75, 0.44444444444444
2628, 2.2, 1.75, 0.027777777777778
2629, 2.2, 1.75, 0.083333333333333
2630, 2.2, 1.75, 0.13888888888889
2631, 2.2, 1.75, 0.19444444444444
2632, 2.2, 1.75, 0.25
2633, 2.2, 1.75, 0.30555555555556
2634, 2.2, 1.75, 0.36111111111111
2635, 2.2, 1.75, 0.41666666666667
2636, 2.2, 1.75, 0.47222222222222
2637, 2.25, 1.55, 0.5
2638, 2.225, 1.55, 0.5
2639, 2.275, 1.55, 0.5
2640, 2.25, 1.75, 0.5
2641, 2.225, 1.75, 0.5
2642, 2.275, 1.75, 0.5
2643, 2.3, 1.6, 0.5
2644, 2.3, 1.65, 0.5
2645, 2.3, 1.7, 0.5
2646, 2.3, 1.575, 0.5
2647, 2.3, 1.625, 0.5
2648, 2.3, 1.675, 0.5
2649, 2.3, 1.725, 0.5
2650, 2.25, 1.55, 0
2651, 2.225, 1.55, 0
2652, 2.275, 1.55, 0
2653, 2.25, 1.75, 0
2654, 2.225, 1.75, 0
2655, 2.275, 1.75, 0
2656, 2.3, 1.6, 0
2657, 2.3, 1.65, 0
2658, 2.3, 1.7, 0
2659, 2.3, 1.575, 0
2660, 2.3, 1.625, 0
2661, 2.3, 1.675, 0
2662, 2.3, 1.725, 0
2663, 2.3, 1.55, 0.055555555555556
2664, 2.3, 1.55, 0.11111111111111
2665, 2.3, 1.55, 0.16666666666667
2666, 2.3, 1.55, 0.22222222222222
2667, 2.3, 1.55, 0.27777777777778
2668, 2.3, 1.55, 0.33333333333333
2669, 2.3, 1.55, 0.38888888888889
2670, 2.3, 1.55, 0.44444444444444
2671, 2.3, 1.55, 0.027777777777778
2672, 2.3, 1.55, 0.083333333333333
2673, 2.3, 1.55, 0.13888888888889
2674, 2.3, 1.55, 0.19444444444444
2675, 2.3, 1.55, 0.25
2676, 2.3, 1.55, 0.30555555555556
2677, 2.3, 1.55, 0.36111111111111
2678, 2.3, 1.55, 0.41666666666667
2679, 2.3, 1.55, 0.47222222222222
2680, 2.3, 1.75, 0.055555555555556
2681, 2.3, 1.75, 0.11111111111111
2682, 2.3, 1.75, 0.16666666666667
2683, 2.3, 1.75, 0.22222222222222
2684, 2.3, 1.75, 0.27777777777778
2685, 2.3, 1.75, 0.33333333333333
2686, 2.3, 1.75, 0.38888888888889
2687, 2.3, 1.75, 0.44444444444444
2688, 2.3, 1.75, 0.027777777777778
2689, 2.3, 1.75, 0.083333333333333
2690, 2.3, 1.75, 0.13888888888889
2691, 2.3, 1.75, 0.19444444444444
2692, 2.3, 1.75, 0.25
2693, 2.3, 1.75, 0.30555555555556
2694, 2.3, 1.75, 0.36111111111111
2695, 2.3, 1.75, 0.41666666666667
2696, 2.3, 1.75, 0.47222222222222
2697, 1, 0.125, 0
2698, 1, 0.1125, 0
2699, 1, 0.1375, 0
2700, 0, 0.125, 0
2701, 0, 0.1125, 0
2702, 0, 0.1375, 0
2703, 0.043478260869565, 0.1, 0
2704, 0.08695652173913, 0.1, 0
2705, 0.1304347826087, 0.1, 0
2706, 0.17391304347826, 0.1, 0
2707, 0.21739130434783, 0.1, 0
2708, 0.26086956521739, 0.1, 0
2709, 0.30434782608696, 0.1, 0
2710, 0.34782608695652, 0.1, 0
2711, 0.39130434782609, 0.1, 0
2712, 0.43478260869565, 0.1, 0
2713, 0.47826086956522, 0.1, 0
2714, 0.52173913043478, 0.1, 0
2715, 0.56521739130435, 0.1, 0
2716, 0.60869565217391, 0.1, 0
2717, 0.65217391304348, 0.1, 0
2718, 0.69565217391304, 0.1, 0
2719, 0.73913043478261, 0.1, 0
2720, 0.78260869565217, 0.1, 0
2721, 0.82608695652174, 0.1, 0
2722, 0.8695652173913, 0.1, 0
2723, 0.91304347826087, 0.1, 0
2724, 0.95652173913043, 0.1, 0
2725, 0.021739130434783, 0.1, 0
2726, 0.065217391304348, 0.1, 0
2727, 0.10869565217391, 0.1, 0
2728, 0.15217391304348, 0.1, 0
2729, 0.19565217391304, 0.1, 0
2730, 0.23913043478261, 0.1, 0
2731, 0.28260869565217, 0.1, 0
2732, 0.32608695652174, 0.1, 0
2733, 0.3695652173913, 0.1, 0
2734, 0.41304347826087, 0.1, 0
2735, 0.45652173913043, 0.1, 0
2736, 0.5, 0.1, 0
2737, 0.54347826086957, 0.1, 0
2738, 0.58695652173913, 0.1, 0
2739, 0.6304347826087, 0.1, 0
2740, 0.67391304347826, 0.1, 0
2741, 0.71739130434783, 0.1, 0
2742, 0.76086956521739, 0.1, 0
2743, 0.80434782608696, 0.1, 0
2744, 0.84782608695652, 0.1, 0
2745, 0.89130434782609, 0.1, 0
2746, 0.93478260869565, 0.1, 0
2747, 0.97826086956522, 0.1, 0
2748, 1, 0.125, 0.5
2749, 1, 0.1125, 0.5
2750, 1, 0.1375, 0.5
2751, 1, 0.1, 0.055555555555556
2752, 1, 0.1, 0.11111111111111
2753, 1, 0.1, 0.16666666666667
2754, 1, 0.1, 0.22222222222222
2755, 1, 0.1, 0.27777777777778
2756, 1, 0.1, 0.33333333333333
2757, 1, 0.1, 0.38888888888889
2758, 1, 0.1, 0.44444444444444
2759, 1, 0.1, 0.027777777777778
2760, 1, 0.1, 0.083333333333333
2761, 1, 0.1, 0.13888888888889
2762, 1, 0.1, 0.19444444444444
2763, 1, 0.1, 0.25
2764, 1, 0.1, 0.30555555555556
2765, 1, 0.1, 0.36111111111111
2766, 1, 0.1, 0.41666666666667
2767, 1, 0.1, 0.47222222222222
2768, 0, 0.125, 0.5
2769, 0, 0.1125, 0.5
2770, 0, 0.1375, 0.5
2771, 0.043478260869565, 0.1, 0.5
2772, 0.08695652173913, 0.1, 0.5
2773, 0.1304347826087, 0.1, 0.5
2774, 0.17391304347826, 0.1, 0.5
2775, 0.21739130434783, 0.1, 0.5
2776, 0.26086956521739, 0.1, 0.5
2777, 0.30434782608696, 0.1, 0.5
2778, 0.34782608695652, 0.1, 0.5
2779, 0.39130434782609, 0.1, 0.5
2780, 0.43478260869565, 0.1, 0.5
2781, 0.47826086956522, 0.1, 0.5
2782, 0.52173913043478, 0.1, 0.5
2783, 0.56521739130435, 0.1, 0.5
2784, 0.60869565217391, 0.1, 0.5
2785, 0.65217391304348, 0.1, 0.5
2786, 0.69565217391304, 0.1, 0.5
2787, 0.73913043478261, 0.1, 0.5
2788, 0.78260869565217, 0.1, 0.5
2789, 0.82608695652174, 0.1, 0.5
2790, 0.8695652173913, 0.1, 0.5
2791, 0.91304347826087, 0.1, 0.5
2792, 0.95652173913043, 0.1, 0.5
2793, 0.021739130434783, 0.1, 0.5
2794, 0.065217391304348, 0.1, 0.5
2795, 0.10869565217391, 0.1, 0.5
2796, 0.15217391304348, 0.1, 0.5
2797, 0.19565217391304, 0.1, 0.5
2798, 0.23913043478261, 0.1, 0.5
2799, 0.28260869565217, 0.1, 0.5
2800, 0.32608695652174, 0.1, 0.5
2801, 0.3695652173913, 0.1, 0.5
2802, 0.41304347826087, 0.1, 0.5
2803, 0.45652173913043, 0.1, 0.5
2804, 0.5, 0.1, 0.5
2805, 0.54347826086957, 0.1, 0.5
2806, 0.58695652173913, 0.1, 0.5
2807, 0.6304347826087, 0.1, 0.5
2808, 0.67391304347826, 0.1, 0.5
2809, 0.71739130434783, 0.1, 0.5
2810, 0.76086956521739, 0.1, 0.5
2811, 0.80434782608696, 0.1, 0.5
2812, 0.84782608695652, 0.1, 0.5
2813, 0.89130434782609, 0.1, 0.5
2814, 0.93478260869565, 0.1, 0.5
2815, 0.97826086956522, 0.1, 0.5
2816, 0, 0.1, 0.055555555555556
2817, 0, 0.1, 0.11111111111111
2818, 0, 0.1, 0.16666666666667
2819, 0, 0.1, 0.22222222222222
2820, 0, 0.1, 0.27777777777778
2821, 0, 0.1, 0.33333333333333
2822, 0, 0.1, 0.38888888888889
2823, 0, 0.1, 0.44444444444444
2824, 0, 0.1, 0.027777777777778
2825, 0, 0.1, 0.083333333333333
2826, 0, 0.1, 0.13888888888889
2827, 0, 0.1, 0.19444444444444
2828, 0, 0.1, 0.25
2829, 0, 0.1, 0.30555555555556
2830, 0, 0.1, 0.36111111111111
2831, 0, 0.1, 0.41666666666667
2832, 0, 0.1, 0.47222222222222
2833, 1, 0.20217391304348, 0
2834, 1, 0.25434782608696, 0
2835, 1, 0.30652173913043, 0
2836, 1, 0.35869565217391, 0
2837, 1, 0.41086956521739, 0
2838, 1, 0.46304347826087, 0
2839, 1, 0.51521739130435, 0
2840, 1, 0.56739130434783, 0
2841, 1, 0.6195652173913, 0
2842, 1, 0.67173913043478, 0
2843, 1, 0.72391304347826, 0
2844, 1, 0.77608695652174, 0
2845, 1, 0.82826086956522, 0
2846, 1, 0.88043478260869, 0
2847, 1, 0.93260869565217, 0
2848, 1, 0.98478260869565, 0
2849, 1, 1.0369565217391, 0
2850, 1, 1.0891304347826, 0
2851, 1, 1.1413043478261, 0
2852, 1, 1.1934782608696, 0
2853, 1, 1.245652173913, 0
2854, 1, 1.2978260869565, 0
2855, 1, 0.17608695652174, 0
2856, 1, 0.22826086956522, 0
2857, 1, 0.2804347826087, 0
2858, 1, 0.33260869565217, 0
2859, 1, 0.38478260869565, 0
2860, 1, 0.43695652173913, 0
2861, 1, 0.48913043478261, 0
2862, 1, 0.54130434782609, 0
2863, 1, 0.59347826086956, 0
2864, 1, 0.64565217391304, 0
2865, 1, 0.69782608695652, 0
2866, 1, 0.75, 0
2867, 1, 0.80217391304348, 0
2868, 1, 0.85434782608696, 0
2869, 1, 0.90652173913043, 0
2870, 1, 0.95869565217391, 0
2871, 1, 1.0108695652174, 0
2872, 1, 1.0630434782609, 0
2873, 1, 1.1152173913043, 0
2874, 1, 1.1673913043478, 0
2875, 1, 1.2195652173913, 0
2876, 1, 1.2717391304348, 0
2877, 1, 1.3239130434783, 0
2878, 0, 0.20217391304348, 0
2879, 0, 0.25434782608696, 0
2880, 0, 0.30652173913043, 0
2881, 0, 0.35869565217391, 0
2882, 0, 0.41086956521739, 0
2883, 0, 0.46304347826087, 0
2884, 0, 0.51521739130435, 0
2885, 0, 0.56739130434783, 0
2886, 0, 0.6195652173913, 0
2887, 0, 0.67173913043478, 0
2888, 0, 0.72391304347826, 0
2889, 0, 0.77608695652174, 0
2890, 0, 0.82826086956522, 0
2891, 0, 0.88043478260869, 0
2892, 0, 0.93260869565217, 0
2893, 0, 0.98478260869565, 0
2894, 0, 1.0369565217391, 0
2895, 0, 1.0891304347826, 0
2896, 0, 1.1413043478261, 0
2897, 0, 1.1934782608696, 0
2898, 0, 1.245652173913, 0
2899, 0, 1.2978260869565, 0
2900, 0, 0.17608695652174, 0
2901, 0, 0.22826086956522, 0
2902, 0, 0.2804347826087, 0
2903, 0, 0.33260869565217, 0
2904, 0, 0.38478260869565, 0
2905, 0, 0.43695652173913, 0
2906, 0, 0.48913043478261, 0
2907, 0, 0.54130434782609, 0
2908, 0, 0.59347826086956, 0
2909, 0, 0.64565217391304, 0
2910, 0, 0.69782608695652, 0
2911, 0, 0.75, 0
2912, 0, 0.80217391304348, 0
2913, 0, 0.85434782608696, 0
2914, 0, 0.90652173913043, 0
2915, 0, 0.95869565217391, 0
2916, 0, 1.0108695652174, 0
2917, 0, 1.0630434782609, 0
2918, 0, 1.1152173913043, 0
2919, 0, 1.1673913043478, 0
2920, 0, 1.2195652173913, 0
2921, 0, 1.2717391304348, 0
2922, 0, 1.3239130434783, 0
2923, 0.043478260869565, 1.35, 0
2924, 0.08695652173913, 1.35, 0
2925, 0.1304347826087, 1.35, 0
2926, 0.17391304347826, 1.35, 0
2927, 0.21739130434783, 1.35, 0
2928, 0.26086956521739, 1.35, 0
2929, 0.30434782608696, 1.35, 0
2930, 0.34782608695652, 1.35, 0
2931, 0.39130434782609, 1.35, 0
2932, 0.43478260869565, 1.35, 0
2933, 0.47826086956522, 1.35, 0
2934, 0.52173913043478, 1.35, 0
2935, 0.56521739130435, 1.35, 0
2936, 0.60869565217391, 1.35, 0
2937, 0.65217391304348, 1.35, 0
2938, 0.69565217391304, 1.35, 0
2939, 0.73913043478261, 1.35, 0
2940, 0.78260869565217, 1.35, 0
2941, 0.82608695652174, 1.35, 0
2942, 0.8695652173913, 1.35, 0
2943, 0.91304347826087, 1.35, 0
2944, 0.95652173913043, 1.35, 0
2945, 0.021739130434783, 1.35, 0
2946, 0.065217391304348, 1.35, 0
2947, 0.10869565217391, 1.35, 0
2948, 0.15217391304348, 1.35, 0
2949, 0.19565217391304, 1.35, 0
2950, 0.23913043478261, 1.35, 0
2951, 0.28260869565217, 1.35, 0
2952, 0.32608695652174, 1.35, 0
2953, 0.3695652173913, 1.35, 0
2954, 0.41304347826087, 1.35, 0
2955, 0.45652173913043, 1.35, 0
2956, 0.5, 1.35, 0
2957, 0.54347826086957, 1.35, 0
2958, 0.58695652173913, 1.35, 0
2959, 0.6304347826087, 1.35, 0
2960, 0.67391304347826, 1.35, 0
2961, 0.71739130434783, 1.35, 0
2962, 0.76086956521739, 1.35, 0
2963, 0.80434782608696, 1.35, 0
2964, 0.84782608695652, 1.35, 0
2965, 0.89130434782609, 1.35, 0
2966, 0.93478260869565, 1.35, 0
2967, 0.97826086956522, 1.35, 0
2968, 1, 0.20217391304348, 0.5
2969, 1, 0.25434782608696, 0.5
2970, 1, 0.30652173913043, 0.5
2971, 1, 0.35869565217391, 0.5
2972, 1, 0.41086956521739, 0.5
2973, 1, 0.46304347826087, 0.5
2974, 1, 0.51521739130435, 0.5
2975, 1, 0.56739130434783, 0.5
2976, 1, 0.6195652173913, 0.5
2977, 1, 0.67173913043478, 0.5
2978, 1, 0.72391304347826, 0.5
2979, 1, 0.77608695652174, 0.5
2980, 1, 0.82826086956522, 0.5
2981, 1, 0.88043478260869, 0.5
2982, 1, 0.93260869565217, 0.5
2983, 1, 0.98478260869565, 0.5
2984, 1, 1.0369565217391, 0.5
2985, 1, 1.0891304347826, 0.5
2986, 1, 1.1413043478261, 0.5
2987, 1, 1.1934782608696, 0.5
2988, 1, 1.245652173913, 0.5
2989, 1, 1.2978260869565, 0.5
2990, 1, 0.17608695652174, 0.5
2991, 1, 0.22826086956522, 0.5
2992, 1, 0.2804347826087, 0.5
2993, 1, 0.33260869565217, 0.5
2994, 1, 0.38478260869565, 0.5
2995, 1, 0.43695652173913, 0.5
2996, 1, 0.48913043478261, 0.5
2997, 1, 0.54130434782609, 0.5
2998, 1, 0.59347826086956, 0.5
2999, 1, 0.64565217391304, 0.5
3000, 1, 0.69782608695652, 0.5
3001, 1, 0.75, 0.5
3002, 1, 0.80217391304348, 0.5
3003, 1, 0.85434782608696, 0.5
3004, 1, 0.90652173913043, 0.5
3005, 1, 0.95869565217391, 0.5
3006, 1, 1.0108695652174, 0.5
3007, 1, 1.0630434782609, 0.5
3008, 1, 1.1152173913043, 0.5
3009, 1, 1.1673913043478, 0.5
3010, 1, 1.2195652173913, 0.5
3011, 1, 1.2717391304348, 0.5
3012, 1, 1.3239130434783, 0.5
3013, 1, 1.35, 0.055555555555556
3014, 1, 1.35, 0.11111111111111
3015, 1, 1.35, 0.16666666666667
3016, 1, 1.35, 0.22222222222222
3017, 1, 1.35, 0.27777777777778
3018, 1, 1.35, 0.33333333333333
3019, 1, 1.35, 0.38888888888889
3020, 1, 1.35, 0.44444444444444
3021, 1, 1.35, 0.027777777777778
3022, 1, 1.35, 0.083333333333333
3023, 1, 1.35, 0.13888888888889
3024, 1, 1.35, 0.19444444444444
3025, 1, 1.35, 0.25
3026, 1, 1.35, 0.30555555555556
3027, 1, 1.35, 0.36111111111111
3028, 1, 1.35, 0.41666666666667
3029, 1, 1.35, 0.47222222222222
3030, 0, 0.20217391304348, 0.5
3031, 0, 0.25434782608696, 0.5
3032, 0, 0.30652173913043, 0.5
3033, 0, 0.35869565217391, 0.5
3034, 0, 0.41086956521739, 0.5
3035, 0, 0.46304347826087, 0.5
3036, 0, 0.51521739130435, 0.5
3037, 0, 0.56739130434783, 0.5
3038, 0, 0.6195652173913, 0.5
3039, 0, 0.67173913043478, 0.5
3040, 0, 0.72391304347826, 0.5
3041, 0, 0.77608695652174, 0.5
3042, 0, 0.82826086956522, 0.5
3043, 0, 0.88043478260869, 0.5
3044, 0, 0.93260869565217, 0.5
3045, 0, 0.98478260869565, 0.5
3046, 0, 1.0369565217391, 0.5
3047, 0, 1.0891304347826, 0.5
3048, 0, 1.1413043478261, 0.5
3049, 0, 1.1934782608696, 0.5
3050, 0, 1.245652173913, 0.5
3051, 0, 1.2978260869565, 0.5
3052, 0, 0.17608695652174, 0.5
3053, 0, 0.22826086956522, 0.5
3054, 0, 0.2804347826087, 0.5
3055, 0, 0.33260869565217, 0.5
3056, 0, 0.38478260869565, 0.5
3057, 0, 0.43695652173913, 0.5
3058, 0, 0.48913043478261, 0.5
3059, 0, 0.54130434782609, 0.5
3060, 0, 0.59347826086956, 0.5
3061, 0, 0.64565217391304, 0.5
3062, 0, 0.69782608695652, 0.5
3063, 0, 0.75, 0.5
3064, 0, 0.80217391304348, 0.5
3065, 0, 0.85434782608696, 0.5
3066, 0, 0.90652173913043, 0.5
3067, 0, 0.95869565217391, 0.5
3068, 0, 1.0108695652174, 0.5
3069, 0, 1.0630434782609, 0.5
3070, 0, 1.1152173913043, 0.5
3071, 0, 1.1673913043478, 0.5
3072, 0, 1.2195652173913, 0.5
3073, 0, 1.2717391304348, 0.5
3074, 0, 1.3239130434783, 0.5
3075, 0.043478260869565, 1.35, 0.5
3076, 0.08695652173913, 1.35, 0.5
3077, 0.1304347826087, 1.35, 0.5
3078, 0.17391304347826, 1.35, 0.5
3079, 0.21739130434783, 1.35, 0.5
3080, 0.26086956521739, 1.35, 0.5
3081, 0.30434782608696, 1.35, 0.5
3082, 0.34782608695652, 1.35, 0.5
3083, 0.39130434782609, 1.35, 0.5
3084, 0.43478260869565, 1.35, 0.5
3085, 0.47826086956522, 1.35, 0.5
3086, 0.52173913043478, 1.35, 0.5
3087, 0.56521739130435, 1.35, 0.5
3088, 0.60869565217391, 1.35, 0.5
3089, 0.65217391304348, 1.35, 0.5
3090, 0.69565217391304, 1.35, 0.5
3091, 0.73913043478261, 1.35, 0.5
3092, 0.78260869565217, 1.35, 0.5
3093, 0.82608695652174, 1.35, 0.5
3094, 0.8695652173913, 1.35, 0.5
3095, 0.91304347826087, 1.35, 0.5
3096, 0.95652173913043, 1.35, 0.5
3097, 0.021739130434783, 1.35, 0.5
3098, 0.065217391304348, 1.35, 0.5
3099, 0.10869565217391, 1.35, 0.5
3100, 0.15217391304348, 1.35, 0.5
3101, 0.19565217391304, 1.35, 0.5
3102, 0.23913043478261, 1.35, 0.5
3103, 0.28260869565217, 1.35, 0.5
3104, 0.32608695652174, 1.35, 0.5
3105, 0.3695652173913, 1.35, 0.5
3106, 0.41304347826087, 1.35, 0.5
3107, 0.45652173913043, 1.35, 0.5
3108, 0.5, 1.35, 0.5
3109, 0.54347826086957, 1.35, 0.5
3110, 0.58695652173913, 1.35, 0.5
3111, 0.6304347826087, 1.35, 0.5
3112, 0.67391304347826, 1.35, 0.5
3113, 0.71739130434783, 1.35, 0.5
3114, 0.76086956521739, 1.35, 0.5
3115, 0.80434782608696, 1.35, 0.5
3116, 0.84782608695652, 1.35, 0.5
3117, 0.89130434782609, 1.35, 0.5
3118, 0.93478260869565, 1.35, 0.5
3119, 0.97826086956522, 1.35, 0.5
3120, 0, 1.35, 0.055555555555556
3121, 0, 1.35, 0.11111111111111
3122, 0, 1.35, 0.16666666666667
3123, 0, 1.35, 0.22222222222222
3124, 0, 1.35, 0.27777777777778
3125, 0, 1.35, 0.33333333333333
3126, 0, 1.35, 0.38888888888889
3127, 0, 1.35, 0.44444444444444
3128, 0, 1.35, 0.027777777777778
3129, 0, 1.35, 0.083333333333333
3130, 0, 1.35, 0.13888888888889
3131, 0, 1.35, 0.19444444444444
3132, 0, 1.35, 0.25
3133, 0, 1.35, 0.30555555555556
3134, 0, 1.35, 0.36111111111111
3135, 0, 1.35, 0.41666666666667
3136, 0, 1.35, 0.47222222222222
3137, 1.2, 1.2978260869565, 0.5
3138, 1.2, 1.245652173913, 0.5
3139, 1.2, 1.1934782608696, 0.5
3140, 1.2, 1.1413043478261, 0.5
3141, 1.2, 1.0891304347826, 0.5
3142, 1.2, 1.0369565217391, 0.5
3143, 1.2, 0.98478260869565, 0.5
3144, 1.2, 0.93260869565217, 0.5
3145, 1.2, 0.8804347826087, 0.5
3146, 1.2, 0.82826086956522, 0.5
3147, 1.2, 0.77608695652174, 0.5
3148, 1.2, 0.72391304347826, 0.5
3149, 1.2, 0.67173913043478, 0.5
3150, 1.2, 0.61956521739131, 0.5
3151, 1.2, 0.56739130434783, 0.5
3152, 1.2, 0.51521739130435, 0.5
3153, 1.2, 0.46304347826087, 0.5
3154, 1.2, 0.41086956521739, 0.5
3155, 1.2, 0.35869565217391, 0.5
3156, 1.2, 0.30652173913044, 0.5
3157, 1.2, 0.25434782608696, 0.5
3158, 1.2, 0.20217391304348, 0.5
3159, 1.2, 1.3239130434783, 0.5
3160, 1.2, 1.2717391304348, 0.5
3161, 1.2, 1.2195652173913, 0.5
3162, 1.2, 1.1673913043478, 0.5
3163, 1.2, 1.1152173913043, 0.5
3164, 1.2, 1.0630434782609, 0.5
3165, 1.2, 1.0108695652174, 0.5
3166, 1.2, 0.95869565217391, 0.5
3167, 1.2, 0.90652173913044, 0.5
3168, 1.2, 0.85434782608696, 0.5
3169, 1.2, 0.80217391304348, 0.5
3170, 1.2, 0.75, 0.5
3171, 1.2, 0.69782608695652, 0.5
3172, 1.2, 0.64565217391304, 0.5
3173, 1.2, 0.59347826086957, 0.5
3174, 1.2, 0.54130434782609, 0.5
3175, 1.2, 0.48913043478261, 0.5
3176, 1.2, 0.43695652173913, 0.5
3177, 1.2, 0.38478260869565, 0.5
3178, 1.2, 0.33260869565217, 0.5
3179, 1.2, 0.2804347826087, 0.5
3180, 1.2, 0.22826086956522, 0.5
3181, 1.2, 0.17608695652174, 0.5
3182, 2.2, 1.2978260869565, 0.5
3183, 2.2, 1.245652173913, 0.5
3184, 2.2, 1.1934782608696, 0.5
3185, 2.2, 1.1413043478261, 0.5
3186, 2.2, 1.0891304347826, 0.5
3187, 2.2, 1.0369565217391, 0.5
3188, 2.2, 0.98478260869565, 0.5
3189, 2.2, 0.93260869565217, 0.5
3190, 2.2, 0.8804347826087, 0.5
3191, 2.2, 0.82826086956522, 0.5
3192, 2.2, 0.77608695652174, 0.5
3193, 2.2, 0.72391304347826, 0.5
3194, 2.2, 0.67173913043478, 0.5
3195, 2.2, 0.61956521739131, 0.5
3196, 2.2, 0.56739130434783, 0.5
3197, 2.2, 0.51521739130435, 0.5
3198, 2.2, 0.46304347826087, 0.5
3199, 2.2, 0.41086956521739, 0.5
3200, 2.2, 0.35869565217391, 0.5
3201, 2.2, 0.30652173913044, 0.5
3202, 2.2, 0.25434782608696, 0.5
3203, 2.2, 0.20217391304348, 0.5
3204, 2.2, 1.3239130434783, 0.5
3205, 2.2, 1.2717391304348, 0.5
3206, 2.2, 1.2195652173913, 0.5
3207, 2.2, 1.1673913043478, 0.5
3208, 2.2, 1.1152173913043, 0.5
3209, 2.2, 1.0630434782609, 0.5
3210, 2.2, 1.0108695652174, 0.5
3211, 2.2, 0.95869565217391, 0.5
3212, 2.2, 0.90652173913044, 0.5
3213, 2.2, 0.85434782608696, 0.5
3214, 2.2, 0.80217391304348, 0.5
3215, 2.2, 0.75, 0.5
3216, 2.2, 0.69782608695652, 0.5
3217, 2.2, 0.64565217391304, 0.5
3218, 2.2, 0.59347826086957, 0.5
3219, 2.2, 0.54130434782609, 0.5
3220, 2.2, 0.48913043478261, 0.5
3221, 2.2, 0.43695652173913, 0.5
3222, 2.2, 0.38478260869565, 0.5
3223, 2.2, 0.33260869565217, 0.5
3224, 2.2, 0.2804347826087, 0.5
3225, 2.2, 0.22826086956522, 0.5
3226, 2.2, 0.17608695652174, 0.5
3227, 1.2434782608696, 1.35, 0.5
3228, 1.2869565217391, 1.35, 0.5
3229, 1.3304347826087, 1.35, 0.5
3230, 1.3739130434783, 1.35, 0.5
3231, 1.4173913043478, 1.35, 0.5
3232, 1.4608695652174, 1.35, 0.5
3233, 1.504347826087, 1.35, 0.5
3234, 1.5478260869565, 1.35, 0.5
3235, 1.5913043478261, 1.35, 0.5
3236, 1.6347826086957, 1.35, 0.5
3237, 1.6782608695652, 1.35, 0.5
3238, 1.7217391304348, 1.35, 0.5
3239, 1.7652173913043, 1.35, 0.5
3240, 1.8086956521739, 1.35, 0.5
3241, 1.8521739130435, 1.35, 0.5
3242, 1.895652173913, 1.35, 0.5
3243, 1.9391304347826, 1.35, 0.5
3244, 1.9826086956522, 1.35, 0.5
3245, 2.0260869565217, 1.35, 0.5
3246, 2.0695652173913, 1.35, 0.5
3247, 2.1130434782609, 1.35, 0.5
3248, 2.1565217391304, 1.35, 0.5
3249, 1.2217391304348, 1.35, 0.5
3250, 1.2652173913043, 1.35, 0.5
3251, 1.3086956521739, 1.35, 0.5
3252, 1.3521739130435, 1.35, 0.5
3253, 1.395652173913, 1.35, 0.5
3254, 1.4391304347826, 1.35, 0.5
3255, 1.4826086956522, 1.35, 0.5
3256, 1.5260869565217, 1.35, 0.5
3257, 1.5695652173913, 1.35, 0.5
3258, 1.6130434782609, 1.35, 0.5
3259, 1.6565217391304, 1.35, 0.5
3260, 1.7, 1.35, 0.5
3261, 1.7434782608696, 1.35, 0.5
3262, 1.7869565217391, 1.35, 0.5
3263, 1.8304347826087, 1.35, 0.5
3264, 1.8739130434783, 1.35, 0.5
3265, 1.9173913043478, 1.35, 0.5
3266, 1.9608695652174, 1.35, 0.5
3267, 2.004347826087, 1.35, 0.5
3268, 2.0478260869565, 1.35, 0.5
3269, 2.0913043478261, 1.35, 0.5
3270, 2.1347826086957, 1.35, 0.5
3271, 2.1782608695652, 1.35, 0.5
3272, 1.2, 1.2978260869565, 0
3273, 1.2, 1.245652173913, 0
3274, 1.2, 1.1934782608696, 0
3275, 1.2, 1.1413043478261, 0
3276, 1.2, 1.0891304347826, 0
3277, 1.2, 1.0369565217391, 0
3278, 1.2, 0.98478260869565, 0
3279, 1.2, 0.93260869565217, 0
3280, 1.2, 0.8804347826087, 0
3281, 1.2, 0.82826086956522, 0
3282, 1.2, 0.77608695652174, 0
3283, 1.2, 0.72391304347826, 0
3284, 1.2, 0.67173913043478, 0
3285, 1.2, 0.61956521739131, 0
3286, 1.2, 0.56739130434783, 0
3287, 1.2, 0.51521739130435, 0
3288, 1.2, 0.46304347826087, 0
3289, 1.2, 0.41086956521739, 0
3290, 1.2, 0.35869565217391, 0
3291, 1.2, 0.30652173913044, 0
3292, 1.2, 0.25434782608696, 0
3293, 1.2, 0.20217391304348, 0
3294, 1.2, 1.3239130434783, 0
3295, 1.2, 1.2717391304348, 0
3296, 1.2, 1.2195652173913, 0
3297, 1.2, 1.1673913043478, 0
3298, 1.2, 1.1152173913043, 0
