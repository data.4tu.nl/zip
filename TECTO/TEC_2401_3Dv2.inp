67141, 1.7217391304348, 1.1413043478261, 0.13888888888889
67142, 1.7, 1.1413043478261, 0.11111111111111
67143, 1.7217391304348, 1.1673913043478, 0.11111111111111
67144, 1.7217391304348, 1.1413043478261, 0.083333333333333
67145, 1.7, 1.1413043478261, 0.055555555555556
67146, 1.7217391304348, 1.1673913043478, 0.055555555555556
67147, 1.7217391304348, 1.1413043478261, 0.027777777777778
67148, 1.7652173913043, 1.1413043478261, 0.47222222222222
67149, 1.7434782608696, 1.1413043478261, 0.44444444444444
67150, 1.7652173913043, 1.1673913043478, 0.44444444444444
67151, 1.7652173913043, 1.1413043478261, 0.41666666666667
67152, 1.7434782608696, 1.1413043478261, 0.38888888888889
67153, 1.7652173913043, 1.1673913043478, 0.38888888888889
67154, 1.7652173913043, 1.1413043478261, 0.36111111111111
67155, 1.7434782608696, 1.1413043478261, 0.33333333333333
67156, 1.7652173913043, 1.1673913043478, 0.33333333333333
67157, 1.7652173913043, 1.1413043478261, 0.30555555555556
67158, 1.7434782608696, 1.1413043478261, 0.27777777777778
67159, 1.7652173913043, 1.1673913043478, 0.27777777777778
67160, 1.7652173913043, 1.1413043478261, 0.25
67161, 1.7434782608696, 1.1413043478261, 0.22222222222222
67162, 1.7652173913043, 1.1673913043478, 0.22222222222222
67163, 1.7652173913043, 1.1413043478261, 0.19444444444444
67164, 1.7434782608696, 1.1413043478261, 0.16666666666667
67165, 1.7652173913043, 1.1673913043478, 0.16666666666667
67166, 1.7652173913043, 1.1413043478261, 0.13888888888889
67167, 1.7434782608696, 1.1413043478261, 0.11111111111111
67168, 1.7652173913043, 1.1673913043478, 0.11111111111111
67169, 1.7652173913043, 1.1413043478261, 0.083333333333333
67170, 1.7434782608696, 1.1413043478261, 0.055555555555556
67171, 1.7652173913043, 1.1673913043478, 0.055555555555556
67172, 1.7652173913043, 1.1413043478261, 0.027777777777778
67173, 1.8086956521739, 1.1413043478261, 0.47222222222222
67174, 1.7869565217391, 1.1413043478261, 0.44444444444444
67175, 1.8086956521739, 1.1673913043478, 0.44444444444444
67176, 1.8086956521739, 1.1413043478261, 0.41666666666667
67177, 1.7869565217391, 1.1413043478261, 0.38888888888889
67178, 1.8086956521739, 1.1673913043478, 0.38888888888889
67179, 1.8086956521739, 1.1413043478261, 0.36111111111111
67180, 1.7869565217391, 1.1413043478261, 0.33333333333333
67181, 1.8086956521739, 1.1673913043478, 0.33333333333333
67182, 1.8086956521739, 1.1413043478261, 0.30555555555556
67183, 1.7869565217391, 1.1413043478261, 0.27777777777778
67184, 1.8086956521739, 1.1673913043478, 0.27777777777778
67185, 1.8086956521739, 1.1413043478261, 0.25
67186, 1.7869565217391, 1.1413043478261, 0.22222222222222
67187, 1.8086956521739, 1.1673913043478, 0.22222222222222
67188, 1.8086956521739, 1.1413043478261, 0.19444444444444
67189, 1.7869565217391, 1.1413043478261, 0.16666666666667
67190, 1.8086956521739, 1.1673913043478, 0.16666666666667
67191, 1.8086956521739, 1.1413043478261, 0.13888888888889
67192, 1.7869565217391, 1.1413043478261, 0.11111111111111
67193, 1.8086956521739, 1.1673913043478, 0.11111111111111
67194, 1.8086956521739, 1.1413043478261, 0.083333333333333
67195, 1.7869565217391, 1.1413043478261, 0.055555555555556
67196, 1.8086956521739, 1.1673913043478, 0.055555555555556
67197, 1.8086956521739, 1.1413043478261, 0.027777777777778
67198, 1.8521739130435, 1.1413043478261, 0.47222222222222
67199, 1.8304347826087, 1.1413043478261, 0.44444444444444
67200, 1.8521739130435, 1.1673913043478, 0.44444444444444
67201, 1.8521739130435, 1.1413043478261, 0.41666666666667
67202, 1.8304347826087, 1.1413043478261, 0.38888888888889
67203, 1.8521739130435, 1.1673913043478, 0.38888888888889
67204, 1.8521739130435, 1.1413043478261, 0.36111111111111
67205, 1.8304347826087, 1.1413043478261, 0.33333333333333
67206, 1.8521739130435, 1.1673913043478, 0.33333333333333
67207, 1.8521739130435, 1.1413043478261, 0.30555555555556
67208, 1.8304347826087, 1.1413043478261, 0.27777777777778
67209, 1.8521739130435, 1.1673913043478, 0.27777777777778
67210, 1.8521739130435, 1.1413043478261, 0.25
67211, 1.8304347826087, 1.1413043478261, 0.22222222222222
67212, 1.8521739130435, 1.1673913043478, 0.22222222222222
67213, 1.8521739130435, 1.1413043478261, 0.19444444444444
67214, 1.8304347826087, 1.1413043478261, 0.16666666666667
67215, 1.8521739130435, 1.1673913043478, 0.16666666666667
67216, 1.8521739130435, 1.1413043478261, 0.13888888888889
67217, 1.8304347826087, 1.1413043478261, 0.11111111111111
67218, 1.8521739130435, 1.1673913043478, 0.11111111111111
67219, 1.8521739130435, 1.1413043478261, 0.083333333333333
67220, 1.8304347826087, 1.1413043478261, 0.055555555555556
67221, 1.8521739130435, 1.1673913043478, 0.055555555555556
67222, 1.8521739130435, 1.1413043478261, 0.027777777777778
67223, 1.895652173913, 1.1413043478261, 0.47222222222222
67224, 1.8739130434783, 1.1413043478261, 0.44444444444444
67225, 1.895652173913, 1.1673913043478, 0.44444444444444
67226, 1.895652173913, 1.1413043478261, 0.41666666666667
67227, 1.8739130434783, 1.1413043478261, 0.38888888888889
67228, 1.895652173913, 1.1673913043478, 0.38888888888889
67229, 1.895652173913, 1.1413043478261, 0.36111111111111
67230, 1.8739130434783, 1.1413043478261, 0.33333333333333
67231, 1.895652173913, 1.1673913043478, 0.33333333333333
67232, 1.895652173913, 1.1413043478261, 0.30555555555556
67233, 1.8739130434783, 1.1413043478261, 0.27777777777778
67234, 1.895652173913, 1.1673913043478, 0.27777777777778
67235, 1.895652173913, 1.1413043478261, 0.25
67236, 1.8739130434783, 1.1413043478261, 0.22222222222222
67237, 1.895652173913, 1.1673913043478, 0.22222222222222
67238, 1.895652173913, 1.1413043478261, 0.19444444444444
67239, 1.8739130434783, 1.1413043478261, 0.16666666666667
67240, 1.895652173913, 1.1673913043478, 0.16666666666667
67241, 1.895652173913, 1.1413043478261, 0.13888888888889
67242, 1.8739130434783, 1.1413043478261, 0.11111111111111
67243, 1.895652173913, 1.1673913043478, 0.11111111111111
67244, 1.895652173913, 1.1413043478261, 0.083333333333333
67245, 1.8739130434783, 1.1413043478261, 0.055555555555556
67246, 1.895652173913, 1.1673913043478, 0.055555555555556
67247, 1.895652173913, 1.1413043478261, 0.027777777777778
67248, 1.9391304347826, 1.1413043478261, 0.47222222222222
67249, 1.9173913043478, 1.1413043478261, 0.44444444444444
67250, 1.9391304347826, 1.1673913043478, 0.44444444444444
67251, 1.9391304347826, 1.1413043478261, 0.41666666666667
67252, 1.9173913043478, 1.1413043478261, 0.38888888888889
67253, 1.9391304347826, 1.1673913043478, 0.38888888888889
67254, 1.9391304347826, 1.1413043478261, 0.36111111111111
67255, 1.9173913043478, 1.1413043478261, 0.33333333333333
67256, 1.9391304347826, 1.1673913043478, 0.33333333333333
67257, 1.9391304347826, 1.1413043478261, 0.30555555555556
67258, 1.9173913043478, 1.1413043478261, 0.27777777777778
67259, 1.9391304347826, 1.1673913043478, 0.27777777777778
67260, 1.9391304347826, 1.1413043478261, 0.25
67261, 1.9173913043478, 1.1413043478261, 0.22222222222222
67262, 1.9391304347826, 1.1673913043478, 0.22222222222222
67263, 1.9391304347826, 1.1413043478261, 0.19444444444444
67264, 1.9173913043478, 1.1413043478261, 0.16666666666667
67265, 1.9391304347826, 1.1673913043478, 0.16666666666667
67266, 1.9391304347826, 1.1413043478261, 0.13888888888889
67267, 1.9173913043478, 1.1413043478261, 0.11111111111111
67268, 1.9391304347826, 1.1673913043478, 0.11111111111111
67269, 1.9391304347826, 1.1413043478261, 0.083333333333333
67270, 1.9173913043478, 1.1413043478261, 0.055555555555556
67271, 1.9391304347826, 1.1673913043478, 0.055555555555556
67272, 1.9391304347826, 1.1413043478261, 0.027777777777778
67273, 1.9826086956522, 1.1413043478261, 0.47222222222222
67274, 1.9608695652174, 1.1413043478261, 0.44444444444444
67275, 1.9826086956522, 1.1673913043478, 0.44444444444444
67276, 1.9826086956522, 1.1413043478261, 0.41666666666667
67277, 1.9608695652174, 1.1413043478261, 0.38888888888889
67278, 1.9826086956522, 1.1673913043478, 0.38888888888889
67279, 1.9826086956522, 1.1413043478261, 0.36111111111111
67280, 1.9608695652174, 1.1413043478261, 0.33333333333333
67281, 1.9826086956522, 1.1673913043478, 0.33333333333333
67282, 1.9826086956522, 1.1413043478261, 0.30555555555556
67283, 1.9608695652174, 1.1413043478261, 0.27777777777778
67284, 1.9826086956522, 1.1673913043478, 0.27777777777778
67285, 1.9826086956522, 1.1413043478261, 0.25
67286, 1.9608695652174, 1.1413043478261, 0.22222222222222
67287, 1.9826086956522, 1.1673913043478, 0.22222222222222
67288, 1.9826086956522, 1.1413043478261, 0.19444444444444
67289, 1.9608695652174, 1.1413043478261, 0.16666666666667
67290, 1.9826086956522, 1.1673913043478, 0.16666666666667
67291, 1.9826086956522, 1.1413043478261, 0.13888888888889
67292, 1.9608695652174, 1.1413043478261, 0.11111111111111
67293, 1.9826086956522, 1.1673913043478, 0.11111111111111
67294, 1.9826086956522, 1.1413043478261, 0.083333333333333
67295, 1.9608695652174, 1.1413043478261, 0.055555555555556
67296, 1.9826086956522, 1.1673913043478, 0.055555555555556
67297, 1.9826086956522, 1.1413043478261, 0.027777777777778
67298, 2.0260869565217, 1.1413043478261, 0.47222222222222
67299, 2.004347826087, 1.1413043478261, 0.44444444444444
67300, 2.0260869565217, 1.1673913043478, 0.44444444444444
67301, 2.0260869565217, 1.1413043478261, 0.41666666666667
67302, 2.004347826087, 1.1413043478261, 0.38888888888889
67303, 2.0260869565217, 1.1673913043478, 0.38888888888889
67304, 2.0260869565217, 1.1413043478261, 0.36111111111111
67305, 2.004347826087, 1.1413043478261, 0.33333333333333
67306, 2.0260869565217, 1.1673913043478, 0.33333333333333
67307, 2.0260869565217, 1.1413043478261, 0.30555555555556
67308, 2.004347826087, 1.1413043478261, 0.27777777777778
67309, 2.0260869565217, 1.1673913043478, 0.27777777777778
67310, 2.0260869565217, 1.1413043478261, 0.25
67311, 2.004347826087, 1.1413043478261, 0.22222222222222
67312, 2.0260869565217, 1.1673913043478, 0.22222222222222
67313, 2.0260869565217, 1.1413043478261, 0.19444444444444
67314, 2.004347826087, 1.1413043478261, 0.16666666666667
67315, 2.0260869565217, 1.1673913043478, 0.16666666666667
67316, 2.0260869565217, 1.1413043478261, 0.13888888888889
67317, 2.004347826087, 1.1413043478261, 0.11111111111111
67318, 2.0260869565217, 1.1673913043478, 0.11111111111111
67319, 2.0260869565217, 1.1413043478261, 0.083333333333333
67320, 2.004347826087, 1.1413043478261, 0.055555555555556
67321, 2.0260869565217, 1.1673913043478, 0.055555555555556
67322, 2.0260869565217, 1.1413043478261, 0.027777777777778
67323, 2.0695652173913, 1.1413043478261, 0.47222222222222
67324, 2.0478260869565, 1.1413043478261, 0.44444444444444
67325, 2.0695652173913, 1.1673913043478, 0.44444444444444
67326, 2.0695652173913, 1.1413043478261, 0.41666666666667
67327, 2.0478260869565, 1.1413043478261, 0.38888888888889
67328, 2.0695652173913, 1.1673913043478, 0.38888888888889
67329, 2.0695652173913, 1.1413043478261, 0.36111111111111
67330, 2.0478260869565, 1.1413043478261, 0.33333333333333
67331, 2.0695652173913, 1.1673913043478, 0.33333333333333
67332, 2.0695652173913, 1.1413043478261, 0.30555555555556
67333, 2.0478260869565, 1.1413043478261, 0.27777777777778
67334, 2.0695652173913, 1.1673913043478, 0.27777777777778
67335, 2.0695652173913, 1.1413043478261, 0.25
67336, 2.0478260869565, 1.1413043478261, 0.22222222222222
67337, 2.0695652173913, 1.1673913043478, 0.22222222222222
67338, 2.0695652173913, 1.1413043478261, 0.19444444444444
67339, 2.0478260869565, 1.1413043478261, 0.16666666666667
67340, 2.0695652173913, 1.1673913043478, 0.16666666666667
67341, 2.0695652173913, 1.1413043478261, 0.13888888888889
67342, 2.0478260869565, 1.1413043478261, 0.11111111111111
67343, 2.0695652173913, 1.1673913043478, 0.11111111111111
67344, 2.0695652173913, 1.1413043478261, 0.083333333333333
67345, 2.0478260869565, 1.1413043478261, 0.055555555555556
67346, 2.0695652173913, 1.1673913043478, 0.055555555555556
67347, 2.0695652173913, 1.1413043478261, 0.027777777777778
67348, 2.1130434782609, 1.1413043478261, 0.47222222222222
67349, 2.0913043478261, 1.1413043478261, 0.44444444444444
67350, 2.1130434782609, 1.1673913043478, 0.44444444444444
67351, 2.1130434782609, 1.1413043478261, 0.41666666666667
67352, 2.0913043478261, 1.1413043478261, 0.38888888888889
67353, 2.1130434782609, 1.1673913043478, 0.38888888888889
67354, 2.1130434782609, 1.1413043478261, 0.36111111111111
67355, 2.0913043478261, 1.1413043478261, 0.33333333333333
67356, 2.1130434782609, 1.1673913043478, 0.33333333333333
67357, 2.1130434782609, 1.1413043478261, 0.30555555555556
67358, 2.0913043478261, 1.1413043478261, 0.27777777777778
67359, 2.1130434782609, 1.1673913043478, 0.27777777777778
67360, 2.1130434782609, 1.1413043478261, 0.25
67361, 2.0913043478261, 1.1413043478261, 0.22222222222222
67362, 2.1130434782609, 1.1673913043478, 0.22222222222222
67363, 2.1130434782609, 1.1413043478261, 0.19444444444444
67364, 2.0913043478261, 1.1413043478261, 0.16666666666667
67365, 2.1130434782609, 1.1673913043478, 0.16666666666667
67366, 2.1130434782609, 1.1413043478261, 0.13888888888889
67367, 2.0913043478261, 1.1413043478261, 0.11111111111111
67368, 2.1130434782609, 1.1673913043478, 0.11111111111111
67369, 2.1130434782609, 1.1413043478261, 0.083333333333333
67370, 2.0913043478261, 1.1413043478261, 0.055555555555556
67371, 2.1130434782609, 1.1673913043478, 0.055555555555556
67372, 2.1130434782609, 1.1413043478261, 0.027777777777778
67373, 2.1565217391304, 1.1413043478261, 0.47222222222222
67374, 2.1347826086957, 1.1413043478261, 0.44444444444444
67375, 2.1565217391304, 1.1673913043478, 0.44444444444444
67376, 2.1565217391304, 1.1413043478261, 0.41666666666667
67377, 2.1347826086957, 1.1413043478261, 0.38888888888889
67378, 2.1565217391304, 1.1673913043478, 0.38888888888889
67379, 2.1565217391304, 1.1413043478261, 0.36111111111111
67380, 2.1347826086957, 1.1413043478261, 0.33333333333333
67381, 2.1565217391304, 1.1673913043478, 0.33333333333333
67382, 2.1565217391304, 1.1413043478261, 0.30555555555556
67383, 2.1347826086957, 1.1413043478261, 0.27777777777778
67384, 2.1565217391304, 1.1673913043478, 0.27777777777778
67385, 2.1565217391304, 1.1413043478261, 0.25
67386, 2.1347826086957, 1.1413043478261, 0.22222222222222
67387, 2.1565217391304, 1.1673913043478, 0.22222222222222
67388, 2.1565217391304, 1.1413043478261, 0.19444444444444
67389, 2.1347826086957, 1.1413043478261, 0.16666666666667
67390, 2.1565217391304, 1.1673913043478, 0.16666666666667
67391, 2.1565217391304, 1.1413043478261, 0.13888888888889
67392, 2.1347826086957, 1.1413043478261, 0.11111111111111
67393, 2.1565217391304, 1.1673913043478, 0.11111111111111
67394, 2.1565217391304, 1.1413043478261, 0.083333333333333
67395, 2.1347826086957, 1.1413043478261, 0.055555555555556
67396, 2.1565217391304, 1.1673913043478, 0.055555555555556
67397, 2.1565217391304, 1.1413043478261, 0.027777777777778
67398, 2.1782608695652, 1.1413043478261, 0.44444444444444
67399, 2.1782608695652, 1.1413043478261, 0.38888888888889
67400, 2.1782608695652, 1.1413043478261, 0.33333333333333
67401, 2.1782608695652, 1.1413043478261, 0.27777777777778
67402, 2.1782608695652, 1.1413043478261, 0.22222222222222
67403, 2.1782608695652, 1.1413043478261, 0.16666666666667
67404, 2.1782608695652, 1.1413043478261, 0.11111111111111
67405, 2.1782608695652, 1.1413043478261, 0.055555555555556
67406, 1.2434782608696, 1.0891304347826, 0.47222222222222
67407, 1.2217391304348, 1.0891304347826, 0.44444444444444
67408, 1.2434782608696, 1.1152173913043, 0.44444444444444
67409, 1.2434782608696, 1.0891304347826, 0.41666666666667
67410, 1.2217391304348, 1.0891304347826, 0.38888888888889
67411, 1.2434782608696, 1.1152173913043, 0.38888888888889
67412, 1.2434782608696, 1.0891304347826, 0.36111111111111
67413, 1.2217391304348, 1.0891304347826, 0.33333333333333
67414, 1.2434782608696, 1.1152173913043, 0.33333333333333
67415, 1.2434782608696, 1.0891304347826, 0.30555555555556
67416, 1.2217391304348, 1.0891304347826, 0.27777777777778
67417, 1.2434782608696, 1.1152173913043, 0.27777777777778
67418, 1.2434782608696, 1.0891304347826, 0.25
67419, 1.2217391304348, 1.0891304347826, 0.22222222222222
67420, 1.2434782608696, 1.1152173913043, 0.22222222222222
67421, 1.2434782608696, 1.0891304347826, 0.19444444444444
67422, 1.2217391304348, 1.0891304347826, 0.16666666666667
67423, 1.2434782608696, 1.1152173913043, 0.16666666666667
67424, 1.2434782608696, 1.0891304347826, 0.13888888888889
67425, 1.2217391304348, 1.0891304347826, 0.11111111111111
67426, 1.2434782608696, 1.1152173913043, 0.11111111111111
67427, 1.2434782608696, 1.0891304347826, 0.083333333333333
67428, 1.2217391304348, 1.0891304347826, 0.055555555555556
67429, 1.2434782608696, 1.1152173913043, 0.055555555555556
67430, 1.2434782608696, 1.0891304347826, 0.027777777777778
67431, 1.2869565217391, 1.0891304347826, 0.47222222222222
67432, 1.2652173913043, 1.0891304347826, 0.44444444444444
67433, 1.2869565217391, 1.1152173913043, 0.44444444444444
67434, 1.2869565217391, 1.0891304347826, 0.41666666666667
67435, 1.2652173913043, 1.0891304347826, 0.38888888888889
67436, 1.2869565217391, 1.1152173913043, 0.38888888888889
67437, 1.2869565217391, 1.0891304347826, 0.36111111111111
67438, 1.2652173913043, 1.0891304347826, 0.33333333333333
67439, 1.2869565217391, 1.1152173913043, 0.33333333333333
67440, 1.2869565217391, 1.0891304347826, 0.30555555555556
67441, 1.2652173913043, 1.0891304347826, 0.27777777777778
67442, 1.2869565217391, 1.1152173913043, 0.27777777777778
67443, 1.2869565217391, 1.0891304347826, 0.25
67444, 1.2652173913043, 1.0891304347826, 0.22222222222222
67445, 1.2869565217391, 1.1152173913043, 0.22222222222222
67446, 1.2869565217391, 1.0891304347826, 0.19444444444444
67447, 1.2652173913043, 1.0891304347826, 0.16666666666667
67448, 1.2869565217391, 1.1152173913043, 0.16666666666667
67449, 1.2869565217391, 1.0891304347826, 0.13888888888889
67450, 1.2652173913043, 1.0891304347826, 0.11111111111111
67451, 1.2869565217391, 1.1152173913043, 0.11111111111111
67452, 1.2869565217391, 1.0891304347826, 0.083333333333333
67453, 1.2652173913043, 1.0891304347826, 0.055555555555556
67454, 1.2869565217391, 1.1152173913043, 0.055555555555556
67455, 1.2869565217391, 1.0891304347826, 0.027777777777778
67456, 1.3304347826087, 1.0891304347826, 0.47222222222222
67457, 1.3086956521739, 1.0891304347826, 0.44444444444444
67458, 1.3304347826087, 1.1152173913043, 0.44444444444444
67459, 1.3304347826087, 1.0891304347826, 0.41666666666667
67460, 1.3086956521739, 1.0891304347826, 0.38888888888889
67461, 1.3304347826087, 1.1152173913043, 0.38888888888889
67462, 1.3304347826087, 1.0891304347826, 0.36111111111111
67463, 1.3086956521739, 1.0891304347826, 0.33333333333333
67464, 1.3304347826087, 1.1152173913043, 0.33333333333333
67465, 1.3304347826087, 1.0891304347826, 0.30555555555556
67466, 1.3086956521739, 1.0891304347826, 0.27777777777778
67467, 1.3304347826087, 1.1152173913043, 0.27777777777778
67468, 1.3304347826087, 1.0891304347826, 0.25
67469, 1.3086956521739, 1.0891304347826, 0.22222222222222
67470, 1.3304347826087, 1.1152173913043, 0.22222222222222
67471, 1.3304347826087, 1.0891304347826, 0.19444444444444
67472, 1.3086956521739, 1.0891304347826, 0.16666666666667
67473, 1.3304347826087, 1.1152173913043, 0.16666666666667
67474, 1.3304347826087, 1.0891304347826, 0.13888888888889
67475, 1.3086956521739, 1.0891304347826, 0.11111111111111
67476, 1.3304347826087, 1.1152173913043, 0.11111111111111
67477, 1.3304347826087, 1.0891304347826, 0.083333333333333
67478, 1.3086956521739, 1.0891304347826, 0.055555555555556
67479, 1.3304347826087, 1.1152173913043, 0.055555555555556
67480, 1.3304347826087, 1.0891304347826, 0.027777777777778
67481, 1.3739130434783, 1.0891304347826, 0.47222222222222
67482, 1.3521739130435, 1.0891304347826, 0.44444444444444
67483, 1.3739130434783, 1.1152173913043, 0.44444444444444
67484, 1.3739130434783, 1.0891304347826, 0.41666666666667
67485, 1.3521739130435, 1.0891304347826, 0.38888888888889
67486, 1.3739130434783, 1.1152173913043, 0.38888888888889
67487, 1.3739130434783, 1.0891304347826, 0.36111111111111
67488, 1.3521739130435, 1.0891304347826, 0.33333333333333
67489, 1.3739130434783, 1.1152173913043, 0.33333333333333
67490, 1.3739130434783, 1.0891304347826, 0.30555555555556
67491, 1.3521739130435, 1.0891304347826, 0.27777777777778
67492, 1.3739130434783, 1.1152173913043, 0.27777777777778
67493, 1.3739130434783, 1.0891304347826, 0.25
67494, 1.3521739130435, 1.0891304347826, 0.22222222222222
67495, 1.3739130434783, 1.1152173913043, 0.22222222222222
67496, 1.3739130434783, 1.0891304347826, 0.19444444444444
67497, 1.3521739130435, 1.0891304347826, 0.16666666666667
67498, 1.3739130434783, 1.1152173913043, 0.16666666666667
67499, 1.3739130434783, 1.0891304347826, 0.13888888888889
67500, 1.3521739130435, 1.0891304347826, 0.11111111111111
67501, 1.3739130434783, 1.1152173913043, 0.11111111111111
67502, 1.3739130434783, 1.0891304347826, 0.083333333333333
67503, 1.3521739130435, 1.0891304347826, 0.055555555555556
67504, 1.3739130434783, 1.1152173913043, 0.055555555555556
67505, 1.3739130434783, 1.0891304347826, 0.027777777777778
67506, 1.4173913043478, 1.0891304347826, 0.47222222222222
67507, 1.395652173913, 1.0891304347826, 0.44444444444444
67508, 1.4173913043478, 1.1152173913043, 0.44444444444444
67509, 1.4173913043478, 1.0891304347826, 0.41666666666667
67510, 1.395652173913, 1.0891304347826, 0.38888888888889
67511, 1.4173913043478, 1.1152173913043, 0.38888888888889
67512, 1.4173913043478, 1.0891304347826, 0.36111111111111
67513, 1.395652173913, 1.0891304347826, 0.33333333333333
67514, 1.4173913043478, 1.1152173913043, 0.33333333333333
67515, 1.4173913043478, 1.0891304347826, 0.30555555555556
67516, 1.395652173913, 1.0891304347826, 0.27777777777778
67517, 1.4173913043478, 1.1152173913043, 0.27777777777778
67518, 1.4173913043478, 1.0891304347826, 0.25
67519, 1.395652173913, 1.0891304347826, 0.22222222222222
67520, 1.4173913043478, 1.1152173913043, 0.22222222222222
67521, 1.4173913043478, 1.0891304347826, 0.19444444444444
67522, 1.395652173913, 1.0891304347826, 0.16666666666667
67523, 1.4173913043478, 1.1152173913043, 0.16666666666667
67524, 1.4173913043478, 1.0891304347826, 0.13888888888889
67525, 1.395652173913, 1.0891304347826, 0.11111111111111
67526, 1.4173913043478, 1.1152173913043, 0.11111111111111
67527, 1.4173913043478, 1.0891304347826, 0.083333333333333
67528, 1.395652173913, 1.0891304347826, 0.055555555555556
67529, 1.4173913043478, 1.1152173913043, 0.055555555555556
67530, 1.4173913043478, 1.0891304347826, 0.027777777777778
67531, 1.4608695652174, 1.0891304347826, 0.47222222222222
67532, 1.4391304347826, 1.0891304347826, 0.44444444444444
67533, 1.4608695652174, 1.1152173913043, 0.44444444444444
67534, 1.4608695652174, 1.0891304347826, 0.41666666666667
67535, 1.4391304347826, 1.0891304347826, 0.38888888888889
67536, 1.4608695652174, 1.1152173913043, 0.38888888888889
67537, 1.4608695652174, 1.0891304347826, 0.36111111111111
67538, 1.4391304347826, 1.0891304347826, 0.33333333333333
67539, 1.4608695652174, 1.1152173913043, 0.33333333333333
67540, 1.4608695652174, 1.0891304347826, 0.30555555555556
67541, 1.4391304347826, 1.0891304347826, 0.27777777777778
67542, 1.4608695652174, 1.1152173913043, 0.27777777777778
67543, 1.4608695652174, 1.0891304347826, 0.25
67544, 1.4391304347826, 1.0891304347826, 0.22222222222222
67545, 1.4608695652174, 1.1152173913043, 0.22222222222222
67546, 1.4608695652174, 1.0891304347826, 0.19444444444444
67547, 1.4391304347826, 1.0891304347826, 0.16666666666667
67548, 1.4608695652174, 1.1152173913043, 0.16666666666667
67549, 1.4608695652174, 1.0891304347826, 0.13888888888889
67550, 1.4391304347826, 1.0891304347826, 0.11111111111111
67551, 1.4608695652174, 1.1152173913043, 0.11111111111111
67552, 1.4608695652174, 1.0891304347826, 0.083333333333333
67553, 1.4391304347826, 1.0891304347826, 0.055555555555556
67554, 1.4608695652174, 1.1152173913043, 0.055555555555556
67555, 1.4608695652174, 1.0891304347826, 0.027777777777778
67556, 1.504347826087, 1.0891304347826, 0.47222222222222
67557, 1.4826086956522, 1.0891304347826, 0.44444444444444
67558, 1.504347826087, 1.1152173913043, 0.44444444444444
67559, 1.504347826087, 1.0891304347826, 0.41666666666667
67560, 1.4826086956522, 1.0891304347826, 0.38888888888889
67561, 1.504347826087, 1.1152173913043, 0.38888888888889
67562, 1.504347826087, 1.0891304347826, 0.36111111111111
67563, 1.4826086956522, 1.0891304347826, 0.33333333333333
67564, 1.504347826087, 1.1152173913043, 0.33333333333333
67565, 1.504347826087, 1.0891304347826, 0.30555555555556
67566, 1.4826086956522, 1.0891304347826, 0.27777777777778
67567, 1.504347826087, 1.1152173913043, 0.27777777777778
67568, 1.504347826087, 1.0891304347826, 0.25
67569, 1.4826086956522, 1.0891304347826, 0.22222222222222
67570, 1.504347826087, 1.1152173913043, 0.22222222222222
67571, 1.504347826087, 1.0891304347826, 0.19444444444444
67572, 1.4826086956522, 1.0891304347826, 0.16666666666667
67573, 1.504347826087, 1.1152173913043, 0.16666666666667
67574, 1.504347826087, 1.0891304347826, 0.13888888888889
67575, 1.4826086956522, 1.0891304347826, 0.11111111111111
67576, 1.504347826087, 1.1152173913043, 0.11111111111111
67577, 1.504347826087, 1.0891304347826, 0.083333333333333
67578, 1.4826086956522, 1.0891304347826, 0.055555555555556
67579, 1.504347826087, 1.1152173913043, 0.055555555555556
67580, 1.504347826087, 1.0891304347826, 0.027777777777778
67581, 1.5478260869565, 1.0891304347826, 0.47222222222222
67582, 1.5260869565217, 1.0891304347826, 0.44444444444444
67583, 1.5478260869565, 1.1152173913043, 0.44444444444444
67584, 1.5478260869565, 1.0891304347826, 0.41666666666667
67585, 1.5260869565217, 1.0891304347826, 0.38888888888889
67586, 1.5478260869565, 1.1152173913043, 0.38888888888889
67587, 1.5478260869565, 1.0891304347826, 0.36111111111111
67588, 1.5260869565217, 1.0891304347826, 0.33333333333333
67589, 1.5478260869565, 1.1152173913043, 0.33333333333333
67590, 1.5478260869565, 1.0891304347826, 0.30555555555556
67591, 1.5260869565217, 1.0891304347826, 0.27777777777778
67592, 1.5478260869565, 1.1152173913043, 0.27777777777778
67593, 1.5478260869565, 1.0891304347826, 0.25
67594, 1.5260869565217, 1.0891304347826, 0.22222222222222
67595, 1.5478260869565, 1.1152173913043, 0.22222222222222
67596, 1.5478260869565, 1.0891304347826, 0.19444444444444
67597, 1.5260869565217, 1.0891304347826, 0.16666666666667
67598, 1.5478260869565, 1.1152173913043, 0.16666666666667
67599, 1.5478260869565, 1.0891304347826, 0.13888888888889
67600, 1.5260869565217, 1.0891304347826, 0.11111111111111
67601, 1.5478260869565, 1.1152173913043, 0.11111111111111
67602, 1.5478260869565, 1.0891304347826, 0.083333333333333
67603, 1.5260869565217, 1.0891304347826, 0.055555555555556
67604, 1.5478260869565, 1.1152173913043, 0.055555555555556
67605, 1.5478260869565, 1.0891304347826, 0.027777777777778
67606, 1.5913043478261, 1.0891304347826, 0.47222222222222
67607, 1.5695652173913, 1.0891304347826, 0.44444444444444
67608, 1.5913043478261, 1.1152173913043, 0.44444444444444
67609, 1.5913043478261, 1.0891304347826, 0.41666666666667
67610, 1.5695652173913, 1.0891304347826, 0.38888888888889
67611, 1.5913043478261, 1.1152173913043, 0.38888888888889
67612, 1.5913043478261, 1.0891304347826, 0.36111111111111
67613, 1.5695652173913, 1.0891304347826, 0.33333333333333
67614, 1.5913043478261, 1.1152173913043, 0.33333333333333
67615, 1.5913043478261, 1.0891304347826, 0.30555555555556
67616, 1.5695652173913, 1.0891304347826, 0.27777777777778
67617, 1.5913043478261, 1.1152173913043, 0.27777777777778
67618, 1.5913043478261, 1.0891304347826, 0.25
67619, 1.5695652173913, 1.0891304347826, 0.22222222222222
67620, 1.5913043478261, 1.1152173913043, 0.22222222222222
67621, 1.5913043478261, 1.0891304347826, 0.19444444444444
67622, 1.5695652173913, 1.0891304347826, 0.16666666666667
67623, 1.5913043478261, 1.1152173913043, 0.16666666666667
67624, 1.5913043478261, 1.0891304347826, 0.13888888888889
67625, 1.5695652173913, 1.0891304347826, 0.11111111111111
67626, 1.5913043478261, 1.1152173913043, 0.11111111111111
67627, 1.5913043478261, 1.0891304347826, 0.083333333333333
67628, 1.5695652173913, 1.0891304347826, 0.055555555555556
67629, 1.5913043478261, 1.1152173913043, 0.055555555555556
67630, 1.5913043478261, 1.0891304347826, 0.027777777777778
67631, 1.6347826086957, 1.0891304347826, 0.47222222222222
67632, 1.6130434782609, 1.0891304347826, 0.44444444444444
67633, 1.6347826086957, 1.1152173913043, 0.44444444444444
67634, 1.6347826086957, 1.0891304347826, 0.41666666666667
67635, 1.6130434782609, 1.0891304347826, 0.38888888888889
67636, 1.6347826086957, 1.1152173913043, 0.38888888888889
67637, 1.6347826086957, 1.0891304347826, 0.36111111111111
67638, 1.6130434782609, 1.0891304347826, 0.33333333333333
67639, 1.6347826086957, 1.1152173913043, 0.33333333333333
67640, 1.6347826086957, 1.0891304347826, 0.30555555555556
67641, 1.6130434782609, 1.0891304347826, 0.27777777777778
67642, 1.6347826086957, 1.1152173913043, 0.27777777777778
67643, 1.6347826086957, 1.0891304347826, 0.25
67644, 1.6130434782609, 1.0891304347826, 0.22222222222222
67645, 1.6347826086957, 1.1152173913043, 0.22222222222222
67646, 1.6347826086957, 1.0891304347826, 0.19444444444444
67647, 1.6130434782609, 1.0891304347826, 0.16666666666667
67648, 1.6347826086957, 1.1152173913043, 0.16666666666667
67649, 1.6347826086957, 1.0891304347826, 0.13888888888889
67650, 1.6130434782609, 1.0891304347826, 0.11111111111111
67651, 1.6347826086957, 1.1152173913043, 0.11111111111111
67652, 1.6347826086957, 1.0891304347826, 0.083333333333333
67653, 1.6130434782609, 1.0891304347826, 0.055555555555556
67654, 1.6347826086957, 1.1152173913043, 0.055555555555556
67655, 1.6347826086957, 1.0891304347826, 0.027777777777778
67656, 1.6782608695652, 1.0891304347826, 0.47222222222222
67657, 1.6565217391304, 1.0891304347826, 0.44444444444444
67658, 1.6782608695652, 1.1152173913043, 0.44444444444444
67659, 1.6782608695652, 1.0891304347826, 0.41666666666667
67660, 1.6565217391304, 1.0891304347826, 0.38888888888889
67661, 1.6782608695652, 1.1152173913043, 0.38888888888889
67662, 1.6782608695652, 1.0891304347826, 0.36111111111111
67663, 1.6565217391304, 1.0891304347826, 0.33333333333333
67664, 1.6782608695652, 1.1152173913043, 0.33333333333333
67665, 1.6782608695652, 1.0891304347826, 0.30555555555556
67666, 1.6565217391304, 1.0891304347826, 0.27777777777778
67667, 1.6782608695652, 1.1152173913043, 0.27777777777778
67668, 1.6782608695652, 1.0891304347826, 0.25
67669, 1.6565217391304, 1.0891304347826, 0.22222222222222
67670, 1.6782608695652, 1.1152173913043, 0.22222222222222
67671, 1.6782608695652, 1.0891304347826, 0.19444444444444
67672, 1.6565217391304, 1.0891304347826, 0.16666666666667
67673, 1.6782608695652, 1.1152173913043, 0.16666666666667
67674, 1.6782608695652, 1.0891304347826, 0.13888888888889
67675, 1.6565217391304, 1.0891304347826, 0.11111111111111
67676, 1.6782608695652, 1.1152173913043, 0.11111111111111
67677, 1.6782608695652, 1.0891304347826, 0.083333333333333
67678, 1.6565217391304, 1.0891304347826, 0.055555555555556
67679, 1.6782608695652, 1.1152173913043, 0.055555555555556
67680, 1.6782608695652, 1.0891304347826, 0.027777777777778
67681, 1.7217391304348, 1.0891304347826, 0.47222222222222
67682, 1.7, 1.0891304347826, 0.44444444444444
67683, 1.7217391304348, 1.1152173913043, 0.44444444444444
67684, 1.7217391304348, 1.0891304347826, 0.41666666666667
67685, 1.7, 1.0891304347826, 0.38888888888889
67686, 1.7217391304348, 1.1152173913043, 0.38888888888889
67687, 1.7217391304348, 1.0891304347826, 0.36111111111111
67688, 1.7, 1.0891304347826, 0.33333333333333
67689, 1.7217391304348, 1.1152173913043, 0.33333333333333
67690, 1.7217391304348, 1.0891304347826, 0.30555555555556
67691, 1.7, 1.0891304347826, 0.27777777777778
67692, 1.7217391304348, 1.1152173913043, 0.27777777777778
67693, 1.7217391304348, 1.0891304347826, 0.25
67694, 1.7, 1.0891304347826, 0.22222222222222
67695, 1.7217391304348, 1.1152173913043, 0.22222222222222
67696, 1.7217391304348, 1.0891304347826, 0.19444444444444
67697, 1.7, 1.0891304347826, 0.16666666666667
67698, 1.7217391304348, 1.1152173913043, 0.16666666666667
67699, 1.7217391304348, 1.0891304347826, 0.13888888888889
67700, 1.7, 1.0891304347826, 0.11111111111111
67701, 1.7217391304348, 1.1152173913043, 0.11111111111111
67702, 1.7217391304348, 1.0891304347826, 0.083333333333333
67703, 1.7, 1.0891304347826, 0.055555555555556
67704, 1.7217391304348, 1.1152173913043, 0.055555555555556
67705, 1.7217391304348, 1.0891304347826, 0.027777777777778
67706, 1.7652173913043, 1.0891304347826, 0.47222222222222
67707, 1.7434782608696, 1.0891304347826, 0.44444444444444
67708, 1.7652173913043, 1.1152173913043, 0.44444444444444
67709, 1.7652173913043, 1.0891304347826, 0.41666666666667
67710, 1.7434782608696, 1.0891304347826, 0.38888888888889
67711, 1.7652173913043, 1.1152173913043, 0.38888888888889
67712, 1.7652173913043, 1.0891304347826, 0.36111111111111
67713, 1.7434782608696, 1.0891304347826, 0.33333333333333
67714, 1.7652173913043, 1.1152173913043, 0.33333333333333
67715, 1.7652173913043, 1.0891304347826, 0.30555555555556
67716, 1.7434782608696, 1.0891304347826, 0.27777777777778
67717, 1.7652173913043, 1.1152173913043, 0.27777777777778
67718, 1.7652173913043, 1.0891304347826, 0.25
67719, 1.7434782608696, 1.0891304347826, 0.22222222222222
67720, 1.7652173913043, 1.1152173913043, 0.22222222222222
67721, 1.7652173913043, 1.0891304347826, 0.19444444444444
67722, 1.7434782608696, 1.0891304347826, 0.16666666666667
67723, 1.7652173913043, 1.1152173913043, 0.16666666666667
67724, 1.7652173913043, 1.0891304347826, 0.13888888888889
67725, 1.7434782608696, 1.0891304347826, 0.11111111111111
67726, 1.7652173913043, 1.1152173913043, 0.11111111111111
67727, 1.7652173913043, 1.0891304347826, 0.083333333333333
67728, 1.7434782608696, 1.0891304347826, 0.055555555555556
67729, 1.7652173913043, 1.1152173913043, 0.055555555555556
67730, 1.7652173913043, 1.0891304347826, 0.027777777777778
67731, 1.8086956521739, 1.0891304347826, 0.47222222222222
67732, 1.7869565217391, 1.0891304347826, 0.44444444444444
67733, 1.8086956521739, 1.1152173913043, 0.44444444444444
67734, 1.8086956521739, 1.0891304347826, 0.41666666666667
67735, 1.7869565217391, 1.0891304347826, 0.38888888888889
67736, 1.8086956521739, 1.1152173913043, 0.38888888888889
67737, 1.8086956521739, 1.0891304347826, 0.36111111111111
67738, 1.7869565217391, 1.0891304347826, 0.33333333333333
67739, 1.8086956521739, 1.1152173913043, 0.33333333333333
67740, 1.8086956521739, 1.0891304347826, 0.30555555555556
67741, 1.7869565217391, 1.0891304347826, 0.27777777777778
67742, 1.8086956521739, 1.1152173913043, 0.27777777777778
67743, 1.8086956521739, 1.0891304347826, 0.25
67744, 1.7869565217391, 1.0891304347826, 0.22222222222222
67745, 1.8086956521739, 1.1152173913043, 0.22222222222222
67746, 1.8086956521739, 1.0891304347826, 0.19444444444444
67747, 1.7869565217391, 1.0891304347826, 0.16666666666667
67748, 1.8086956521739, 1.1152173913043, 0.16666666666667
67749, 1.8086956521739, 1.0891304347826, 0.13888888888889
67750, 1.7869565217391, 1.0891304347826, 0.11111111111111
67751, 1.8086956521739, 1.1152173913043, 0.11111111111111
67752, 1.8086956521739, 1.0891304347826, 0.083333333333333
67753, 1.7869565217391, 1.0891304347826, 0.055555555555556
67754, 1.8086956521739, 1.1152173913043, 0.055555555555556
67755, 1.8086956521739, 1.0891304347826, 0.027777777777778
67756, 1.8521739130435, 1.0891304347826, 0.47222222222222
67757, 1.8304347826087, 1.0891304347826, 0.44444444444444
67758, 1.8521739130435, 1.1152173913043, 0.44444444444444
67759, 1.8521739130435, 1.0891304347826, 0.41666666666667
67760, 1.8304347826087, 1.0891304347826, 0.38888888888889
67761, 1.8521739130435, 1.1152173913043, 0.38888888888889
67762, 1.8521739130435, 1.0891304347826, 0.36111111111111
67763, 1.8304347826087, 1.0891304347826, 0.33333333333333
67764, 1.8521739130435, 1.1152173913043, 0.33333333333333
67765, 1.8521739130435, 1.0891304347826, 0.30555555555556
67766, 1.8304347826087, 1.0891304347826, 0.27777777777778
67767, 1.8521739130435, 1.1152173913043, 0.27777777777778
67768, 1.8521739130435, 1.0891304347826, 0.25
67769, 1.8304347826087, 1.0891304347826, 0.22222222222222
67770, 1.8521739130435, 1.1152173913043, 0.22222222222222
67771, 1.8521739130435, 1.0891304347826, 0.19444444444444
67772, 1.8304347826087, 1.0891304347826, 0.16666666666667
67773, 1.8521739130435, 1.1152173913043, 0.16666666666667
67774, 1.8521739130435, 1.0891304347826, 0.13888888888889
67775, 1.8304347826087, 1.0891304347826, 0.11111111111111
67776, 1.8521739130435, 1.1152173913043, 0.11111111111111
67777, 1.8521739130435, 1.0891304347826, 0.083333333333333
67778, 1.8304347826087, 1.0891304347826, 0.055555555555556
67779, 1.8521739130435, 1.1152173913043, 0.055555555555556
67780, 1.8521739130435, 1.0891304347826, 0.027777777777778
67781, 1.895652173913, 1.0891304347826, 0.47222222222222
67782, 1.8739130434783, 1.0891304347826, 0.44444444444444
67783, 1.895652173913, 1.1152173913043, 0.44444444444444
67784, 1.895652173913, 1.0891304347826, 0.41666666666667
67785, 1.8739130434783, 1.0891304347826, 0.38888888888889
67786, 1.895652173913, 1.1152173913043, 0.38888888888889
67787, 1.895652173913, 1.0891304347826, 0.36111111111111
67788, 1.8739130434783, 1.0891304347826, 0.33333333333333
67789, 1.895652173913, 1.1152173913043, 0.33333333333333
67790, 1.895652173913, 1.0891304347826, 0.30555555555556
67791, 1.8739130434783, 1.0891304347826, 0.27777777777778
67792, 1.895652173913, 1.1152173913043, 0.27777777777778
67793, 1.895652173913, 1.0891304347826, 0.25
67794, 1.8739130434783, 1.0891304347826, 0.22222222222222
67795, 1.895652173913, 1.1152173913043, 0.22222222222222
67796, 1.895652173913, 1.0891304347826, 0.19444444444444
67797, 1.8739130434783, 1.0891304347826, 0.16666666666667
67798, 1.895652173913, 1.1152173913043, 0.16666666666667
67799, 1.895652173913, 1.0891304347826, 0.13888888888889
67800, 1.8739130434783, 1.0891304347826, 0.11111111111111
67801, 1.895652173913, 1.1152173913043, 0.11111111111111
67802, 1.895652173913, 1.0891304347826, 0.083333333333333
67803, 1.8739130434783, 1.0891304347826, 0.055555555555556
67804, 1.895652173913, 1.1152173913043, 0.055555555555556
67805, 1.895652173913, 1.0891304347826, 0.027777777777778
67806, 1.9391304347826, 1.0891304347826, 0.47222222222222
67807, 1.9173913043478, 1.0891304347826, 0.44444444444444
67808, 1.9391304347826, 1.1152173913043, 0.44444444444444
67809, 1.9391304347826, 1.0891304347826, 0.41666666666667
67810, 1.9173913043478, 1.0891304347826, 0.38888888888889
67811, 1.9391304347826, 1.1152173913043, 0.38888888888889
67812, 1.9391304347826, 1.0891304347826, 0.36111111111111
67813, 1.9173913043478, 1.0891304347826, 0.33333333333333
67814, 1.9391304347826, 1.1152173913043, 0.33333333333333
67815, 1.9391304347826, 1.0891304347826, 0.30555555555556
67816, 1.9173913043478, 1.0891304347826, 0.27777777777778
67817, 1.9391304347826, 1.1152173913043, 0.27777777777778
67818, 1.9391304347826, 1.0891304347826, 0.25
67819, 1.9173913043478, 1.0891304347826, 0.22222222222222
67820, 1.9391304347826, 1.1152173913043, 0.22222222222222
67821, 1.9391304347826, 1.0891304347826, 0.19444444444444
67822, 1.9173913043478, 1.0891304347826, 0.16666666666667
67823, 1.9391304347826, 1.1152173913043, 0.16666666666667
67824, 1.9391304347826, 1.0891304347826, 0.13888888888889
67825, 1.9173913043478, 1.0891304347826, 0.11111111111111
67826, 1.9391304347826, 1.1152173913043, 0.11111111111111
67827, 1.9391304347826, 1.0891304347826, 0.083333333333333
67828, 1.9173913043478, 1.0891304347826, 0.055555555555556
67829, 1.9391304347826, 1.1152173913043, 0.055555555555556
67830, 1.9391304347826, 1.0891304347826, 0.027777777777778
67831, 1.9826086956522, 1.0891304347826, 0.47222222222222
67832, 1.9608695652174, 1.0891304347826, 0.44444444444444
67833, 1.9826086956522, 1.1152173913043, 0.44444444444444
67834, 1.9826086956522, 1.0891304347826, 0.41666666666667
67835, 1.9608695652174, 1.0891304347826, 0.38888888888889
67836, 1.9826086956522, 1.1152173913043, 0.38888888888889
67837, 1.9826086956522, 1.0891304347826, 0.36111111111111
67838, 1.9608695652174, 1.0891304347826, 0.33333333333333
67839, 1.9826086956522, 1.1152173913043, 0.33333333333333
67840, 1.9826086956522, 1.0891304347826, 0.30555555555556
67841, 1.9608695652174, 1.0891304347826, 0.27777777777778
67842, 1.9826086956522, 1.1152173913043, 0.27777777777778
67843, 1.9826086956522, 1.0891304347826, 0.25
67844, 1.9608695652174, 1.0891304347826, 0.22222222222222
67845, 1.9826086956522, 1.1152173913043, 0.22222222222222
67846, 1.9826086956522, 1.0891304347826, 0.19444444444444
67847, 1.9608695652174, 1.0891304347826, 0.16666666666667
67848, 1.9826086956522, 1.1152173913043, 0.16666666666667
67849, 1.9826086956522, 1.0891304347826, 0.13888888888889
67850, 1.9608695652174, 1.0891304347826, 0.11111111111111
67851, 1.9826086956522, 1.1152173913043, 0.11111111111111
67852, 1.9826086956522, 1.0891304347826, 0.083333333333333
67853, 1.9608695652174, 1.0891304347826, 0.055555555555556
67854, 1.9826086956522, 1.1152173913043, 0.055555555555556
67855, 1.9826086956522, 1.0891304347826, 0.027777777777778
67856, 2.0260869565217, 1.0891304347826, 0.47222222222222
67857, 2.004347826087, 1.0891304347826, 0.44444444444444
67858, 2.0260869565217, 1.1152173913043, 0.44444444444444
67859, 2.0260869565217, 1.0891304347826, 0.41666666666667
67860, 2.004347826087, 1.0891304347826, 0.38888888888889
67861, 2.0260869565217, 1.1152173913043, 0.38888888888889
67862, 2.0260869565217, 1.0891304347826, 0.36111111111111
67863, 2.004347826087, 1.0891304347826, 0.33333333333333
67864, 2.0260869565217, 1.1152173913043, 0.33333333333333
67865, 2.0260869565217, 1.0891304347826, 0.30555555555556
67866, 2.004347826087, 1.0891304347826, 0.27777777777778
67867, 2.0260869565217, 1.1152173913043, 0.27777777777778
67868, 2.0260869565217, 1.0891304347826, 0.25
67869, 2.004347826087, 1.0891304347826, 0.22222222222222
67870, 2.0260869565217, 1.1152173913043, 0.22222222222222
67871, 2.0260869565217, 1.0891304347826, 0.19444444444444
67872, 2.004347826087, 1.0891304347826, 0.16666666666667
67873, 2.0260869565217, 1.1152173913043, 0.16666666666667
67874, 2.0260869565217, 1.0891304347826, 0.13888888888889
67875, 2.004347826087, 1.0891304347826, 0.11111111111111
67876, 2.0260869565217, 1.1152173913043, 0.11111111111111
67877, 2.0260869565217, 1.0891304347826, 0.083333333333333
67878, 2.004347826087, 1.0891304347826, 0.055555555555556
67879, 2.0260869565217, 1.1152173913043, 0.055555555555556
67880, 2.0260869565217, 1.0891304347826, 0.027777777777778
67881, 2.0695652173913, 1.0891304347826, 0.47222222222222
67882, 2.0478260869565, 1.0891304347826, 0.44444444444444
67883, 2.0695652173913, 1.1152173913043, 0.44444444444444
67884, 2.0695652173913, 1.0891304347826, 0.41666666666667
67885, 2.0478260869565, 1.0891304347826, 0.38888888888889
67886, 2.0695652173913, 1.1152173913043, 0.38888888888889
67887, 2.0695652173913, 1.0891304347826, 0.36111111111111
67888, 2.0478260869565, 1.0891304347826, 0.33333333333333
67889, 2.0695652173913, 1.1152173913043, 0.33333333333333
67890, 2.0695652173913, 1.0891304347826, 0.30555555555556
67891, 2.0478260869565, 1.0891304347826, 0.27777777777778
67892, 2.0695652173913, 1.1152173913043, 0.27777777777778
67893, 2.0695652173913, 1.0891304347826, 0.25
67894, 2.0478260869565, 1.0891304347826, 0.22222222222222
67895, 2.0695652173913, 1.1152173913043, 0.22222222222222
67896, 2.0695652173913, 1.0891304347826, 0.19444444444444
67897, 2.0478260869565, 1.0891304347826, 0.16666666666667
67898, 2.0695652173913, 1.1152173913043, 0.16666666666667
67899, 2.0695652173913, 1.0891304347826, 0.13888888888889
67900, 2.0478260869565, 1.0891304347826, 0.11111111111111
67901, 2.0695652173913, 1.1152173913043, 0.11111111111111
67902, 2.0695652173913, 1.0891304347826, 0.083333333333333
67903, 2.0478260869565, 1.0891304347826, 0.055555555555556
67904, 2.0695652173913, 1.1152173913043, 0.055555555555556
67905, 2.0695652173913, 1.0891304347826, 0.027777777777778
67906, 2.1130434782609, 1.0891304347826, 0.47222222222222
67907, 2.0913043478261, 1.0891304347826, 0.44444444444444
67908, 2.1130434782609, 1.1152173913043, 0.44444444444444
67909, 2.1130434782609, 1.0891304347826, 0.41666666666667
67910, 2.0913043478261, 1.0891304347826, 0.38888888888889
67911, 2.1130434782609, 1.1152173913043, 0.38888888888889
67912, 2.1130434782609, 1.0891304347826, 0.36111111111111
67913, 2.0913043478261, 1.0891304347826, 0.33333333333333
67914, 2.1130434782609, 1.1152173913043, 0.33333333333333
67915, 2.1130434782609, 1.0891304347826, 0.30555555555556
67916, 2.0913043478261, 1.0891304347826, 0.27777777777778
67917, 2.1130434782609, 1.1152173913043, 0.27777777777778
67918, 2.1130434782609, 1.0891304347826, 0.25
67919, 2.0913043478261, 1.0891304347826, 0.22222222222222
67920, 2.1130434782609, 1.1152173913043, 0.22222222222222
67921, 2.1130434782609, 1.0891304347826, 0.19444444444444
67922, 2.0913043478261, 1.0891304347826, 0.16666666666667
67923, 2.1130434782609, 1.1152173913043, 0.16666666666667
67924, 2.1130434782609, 1.0891304347826, 0.13888888888889
67925, 2.0913043478261, 1.0891304347826, 0.11111111111111
67926, 2.1130434782609, 1.1152173913043, 0.11111111111111
67927, 2.1130434782609, 1.0891304347826, 0.083333333333333
67928, 2.0913043478261, 1.0891304347826, 0.055555555555556
67929, 2.1130434782609, 1.1152173913043, 0.055555555555556
67930, 2.1130434782609, 1.0891304347826, 0.027777777777778
67931, 2.1565217391304, 1.0891304347826, 0.47222222222222
67932, 2.1347826086957, 1.0891304347826, 0.44444444444444
67933, 2.1565217391304, 1.1152173913043, 0.44444444444444
67934, 2.1565217391304, 1.0891304347826, 0.41666666666667
67935, 2.1347826086957, 1.0891304347826, 0.38888888888889
67936, 2.1565217391304, 1.1152173913043, 0.38888888888889
67937, 2.1565217391304, 1.0891304347826, 0.36111111111111
67938, 2.1347826086957, 1.0891304347826, 0.33333333333333
67939, 2.1565217391304, 1.1152173913043, 0.33333333333333
67940, 2.1565217391304, 1.0891304347826, 0.30555555555556
67941, 2.1347826086957, 1.0891304347826, 0.27777777777778
67942, 2.1565217391304, 1.1152173913043, 0.27777777777778
67943, 2.1565217391304, 1.0891304347826, 0.25
67944, 2.1347826086957, 1.0891304347826, 0.22222222222222
67945, 2.1565217391304, 1.1152173913043, 0.22222222222222
67946, 2.1565217391304, 1.0891304347826, 0.19444444444444
67947, 2.1347826086957, 1.0891304347826, 0.16666666666667
67948, 2.1565217391304, 1.1152173913043, 0.16666666666667
67949, 2.1565217391304, 1.0891304347826, 0.13888888888889
67950, 2.1347826086957, 1.0891304347826, 0.11111111111111
67951, 2.1565217391304, 1.1152173913043, 0.11111111111111
67952, 2.1565217391304, 1.0891304347826, 0.083333333333333
67953, 2.1347826086957, 1.0891304347826, 0.055555555555556
67954, 2.1565217391304, 1.1152173913043, 0.055555555555556
67955, 2.1565217391304, 1.0891304347826, 0.027777777777778
67956, 2.1782608695652, 1.0891304347826, 0.44444444444444
67957, 2.1782608695652, 1.0891304347826, 0.38888888888889
67958, 2.1782608695652, 1.0891304347826, 0.33333333333333
67959, 2.1782608695652, 1.0891304347826, 0.27777777777778
67960, 2.1782608695652, 1.0891304347826, 0.22222222222222
67961, 2.1782608695652, 1.0891304347826, 0.16666666666667
67962, 2.1782608695652, 1.0891304347826, 0.11111111111111
67963, 2.1782608695652, 1.0891304347826, 0.055555555555556
67964, 1.2434782608696, 1.0369565217391, 0.47222222222222
67965, 1.2217391304348, 1.0369565217391, 0.44444444444444
67966, 1.2434782608696, 1.0630434782609, 0.44444444444444
67967, 1.2434782608696, 1.0369565217391, 0.41666666666667
67968, 1.2217391304348, 1.0369565217391, 0.38888888888889
67969, 1.2434782608696, 1.0630434782609, 0.38888888888889
67970, 1.2434782608696, 1.0369565217391, 0.36111111111111
67971, 1.2217391304348, 1.0369565217391, 0.33333333333333
67972, 1.2434782608696, 1.0630434782609, 0.33333333333333
67973, 1.2434782608696, 1.0369565217391, 0.30555555555556
67974, 1.2217391304348, 1.0369565217391, 0.27777777777778
67975, 1.2434782608696, 1.0630434782609, 0.27777777777778
67976, 1.2434782608696, 1.0369565217391, 0.25
67977, 1.2217391304348, 1.0369565217391, 0.22222222222222
67978, 1.2434782608696, 1.0630434782609, 0.22222222222222
67979, 1.2434782608696, 1.0369565217391, 0.19444444444444
67980, 1.2217391304348, 1.0369565217391, 0.16666666666667
67981, 1.2434782608696, 1.0630434782609, 0.16666666666667
67982, 1.2434782608696, 1.0369565217391, 0.13888888888889
67983, 1.2217391304348, 1.0369565217391, 0.11111111111111
67984, 1.2434782608696, 1.0630434782609, 0.11111111111111
67985, 1.2434782608696, 1.0369565217391, 0.083333333333333
67986, 1.2217391304348, 1.0369565217391, 0.055555555555556
67987, 1.2434782608696, 1.0630434782609, 0.055555555555556
67988, 1.2434782608696, 1.0369565217391, 0.027777777777778
67989, 1.2869565217391, 1.0369565217391, 0.47222222222222
67990, 1.2652173913043, 1.0369565217391, 0.44444444444444
67991, 1.2869565217391, 1.0630434782609, 0.44444444444444
67992, 1.2869565217391, 1.0369565217391, 0.41666666666667
67993, 1.2652173913043, 1.0369565217391, 0.38888888888889
67994, 1.2869565217391, 1.0630434782609, 0.38888888888889
67995, 1.2869565217391, 1.0369565217391, 0.36111111111111
67996, 1.2652173913043, 1.0369565217391, 0.33333333333333
67997, 1.2869565217391, 1.0630434782609, 0.33333333333333
67998, 1.2869565217391, 1.0369565217391, 0.30555555555556
67999, 1.2652173913043, 1.0369565217391, 0.27777777777778
68000, 1.2869565217391, 1.0630434782609, 0.27777777777778
68001, 1.2869565217391, 1.0369565217391, 0.25
68002, 1.2652173913043, 1.0369565217391, 0.22222222222222
68003, 1.2869565217391, 1.0630434782609, 0.22222222222222
68004, 1.2869565217391, 1.0369565217391, 0.19444444444444
68005, 1.2652173913043, 1.0369565217391, 0.16666666666667
68006, 1.2869565217391, 1.0630434782609, 0.16666666666667
68007, 1.2869565217391, 1.0369565217391, 0.13888888888889
68008, 1.2652173913043, 1.0369565217391, 0.11111111111111
68009, 1.2869565217391, 1.0630434782609, 0.11111111111111
68010, 1.2869565217391, 1.0369565217391, 0.083333333333333
68011, 1.2652173913043, 1.0369565217391, 0.055555555555556
68012, 1.2869565217391, 1.0630434782609, 0.055555555555556
68013, 1.2869565217391, 1.0369565217391, 0.027777777777778
68014, 1.3304347826087, 1.0369565217391, 0.47222222222222
68015, 1.3086956521739, 1.0369565217391, 0.44444444444444
68016, 1.3304347826087, 1.0630434782609, 0.44444444444444
68017, 1.3304347826087, 1.0369565217391, 0.41666666666667
68018, 1.3086956521739, 1.0369565217391, 0.38888888888889
68019, 1.3304347826087, 1.0630434782609, 0.38888888888889
68020, 1.3304347826087, 1.0369565217391, 0.36111111111111
68021, 1.3086956521739, 1.0369565217391, 0.33333333333333
68022, 1.3304347826087, 1.0630434782609, 0.33333333333333
68023, 1.3304347826087, 1.0369565217391, 0.30555555555556
68024, 1.3086956521739, 1.0369565217391, 0.27777777777778
68025, 1.3304347826087, 1.0630434782609, 0.27777777777778
68026, 1.3304347826087, 1.0369565217391, 0.25
68027, 1.3086956521739, 1.0369565217391, 0.22222222222222
68028, 1.3304347826087, 1.0630434782609, 0.22222222222222
68029, 1.3304347826087, 1.0369565217391, 0.19444444444444
68030, 1.3086956521739, 1.0369565217391, 0.16666666666667
68031, 1.3304347826087, 1.0630434782609, 0.16666666666667
68032, 1.3304347826087, 1.0369565217391, 0.13888888888889
68033, 1.3086956521739, 1.0369565217391, 0.11111111111111
68034, 1.3304347826087, 1.0630434782609, 0.11111111111111
68035, 1.3304347826087, 1.0369565217391, 0.083333333333333
68036, 1.3086956521739, 1.0369565217391, 0.055555555555556
68037, 1.3304347826087, 1.0630434782609, 0.055555555555556
68038, 1.3304347826087, 1.0369565217391, 0.027777777777778
68039, 1.3739130434783, 1.0369565217391, 0.47222222222222
68040, 1.3521739130435, 1.0369565217391, 0.44444444444444
68041, 1.3739130434783, 1.0630434782609, 0.44444444444444
68042, 1.3739130434783, 1.0369565217391, 0.41666666666667
68043, 1.3521739130435, 1.0369565217391, 0.38888888888889
68044, 1.3739130434783, 1.0630434782609, 0.38888888888889
68045, 1.3739130434783, 1.0369565217391, 0.36111111111111
68046, 1.3521739130435, 1.0369565217391, 0.33333333333333
68047, 1.3739130434783, 1.0630434782609, 0.33333333333333
68048, 1.3739130434783, 1.0369565217391, 0.30555555555556
68049, 1.3521739130435, 1.0369565217391, 0.27777777777778
68050, 1.3739130434783, 1.0630434782609, 0.27777777777778
68051, 1.3739130434783, 1.0369565217391, 0.25
68052, 1.3521739130435, 1.0369565217391, 0.22222222222222
68053, 1.3739130434783, 1.0630434782609, 0.22222222222222
68054, 1.3739130434783, 1.0369565217391, 0.19444444444444
68055, 1.3521739130435, 1.0369565217391, 0.16666666666667
68056, 1.3739130434783, 1.0630434782609, 0.16666666666667
68057, 1.3739130434783, 1.0369565217391, 0.13888888888889
68058, 1.3521739130435, 1.0369565217391, 0.11111111111111
68059, 1.3739130434783, 1.0630434782609, 0.11111111111111
68060, 1.3739130434783, 1.0369565217391, 0.083333333333333
68061, 1.3521739130435, 1.0369565217391, 0.055555555555556
68062, 1.3739130434783, 1.0630434782609, 0.055555555555556
68063, 1.3739130434783, 1.0369565217391, 0.027777777777778
68064, 1.4173913043478, 1.0369565217391, 0.47222222222222
68065, 1.395652173913, 1.0369565217391, 0.44444444444444
68066, 1.4173913043478, 1.0630434782609, 0.44444444444444
68067, 1.4173913043478, 1.0369565217391, 0.41666666666667
68068, 1.395652173913, 1.0369565217391, 0.38888888888889
68069, 1.4173913043478, 1.0630434782609, 0.38888888888889
68070, 1.4173913043478, 1.0369565217391, 0.36111111111111
68071, 1.395652173913, 1.0369565217391, 0.33333333333333
68072, 1.4173913043478, 1.0630434782609, 0.33333333333333
68073, 1.4173913043478, 1.0369565217391, 0.30555555555556
68074, 1.395652173913, 1.0369565217391, 0.27777777777778
68075, 1.4173913043478, 1.0630434782609, 0.27777777777778
68076, 1.4173913043478, 1.0369565217391, 0.25
68077, 1.395652173913, 1.0369565217391, 0.22222222222222
68078, 1.4173913043478, 1.0630434782609, 0.22222222222222
68079, 1.4173913043478, 1.0369565217391, 0.19444444444444
68080, 1.395652173913, 1.0369565217391, 0.16666666666667
68081, 1.4173913043478, 1.0630434782609, 0.16666666666667
68082, 1.4173913043478, 1.0369565217391, 0.13888888888889
68083, 1.395652173913, 1.0369565217391, 0.11111111111111
68084, 1.4173913043478, 1.0630434782609, 0.11111111111111
68085, 1.4173913043478, 1.0369565217391, 0.083333333333333
68086, 1.395652173913, 1.0369565217391, 0.055555555555556
68087, 1.4173913043478, 1.0630434782609, 0.055555555555556
68088, 1.4173913043478, 1.0369565217391, 0.027777777777778
68089, 1.4608695652174, 1.0369565217391, 0.47222222222222
68090, 1.4391304347826, 1.0369565217391, 0.44444444444444
68091, 1.4608695652174, 1.0630434782609, 0.44444444444444
68092, 1.4608695652174, 1.0369565217391, 0.41666666666667
68093, 1.4391304347826, 1.0369565217391, 0.38888888888889
68094, 1.4608695652174, 1.0630434782609, 0.38888888888889
68095, 1.4608695652174, 1.0369565217391, 0.36111111111111
68096, 1.4391304347826, 1.0369565217391, 0.33333333333333
68097, 1.4608695652174, 1.0630434782609, 0.33333333333333
68098, 1.4608695652174, 1.0369565217391, 0.30555555555556
68099, 1.4391304347826, 1.0369565217391, 0.27777777777778
68100, 1.4608695652174, 1.0630434782609, 0.27777777777778
68101, 1.4608695652174, 1.0369565217391, 0.25
68102, 1.4391304347826, 1.0369565217391, 0.22222222222222
68103, 1.4608695652174, 1.0630434782609, 0.22222222222222
68104, 1.4608695652174, 1.0369565217391, 0.19444444444444
68105, 1.4391304347826, 1.0369565217391, 0.16666666666667
68106, 1.4608695652174, 1.0630434782609, 0.16666666666667
68107, 1.4608695652174, 1.0369565217391, 0.13888888888889
68108, 1.4391304347826, 1.0369565217391, 0.11111111111111
68109, 1.4608695652174, 1.0630434782609, 0.11111111111111
68110, 1.4608695652174, 1.0369565217391, 0.083333333333333
68111, 1.4391304347826, 1.0369565217391, 0.055555555555556
68112, 1.4608695652174, 1.0630434782609, 0.055555555555556
68113, 1.4608695652174, 1.0369565217391, 0.027777777777778
68114, 1.504347826087, 1.0369565217391, 0.47222222222222
68115, 1.4826086956522, 1.0369565217391, 0.44444444444444
68116, 1.504347826087, 1.0630434782609, 0.44444444444444
68117, 1.504347826087, 1.0369565217391, 0.41666666666667
68118, 1.4826086956522, 1.0369565217391, 0.38888888888889
68119, 1.504347826087, 1.0630434782609, 0.38888888888889
68120, 1.504347826087, 1.0369565217391, 0.36111111111111
68121, 1.4826086956522, 1.0369565217391, 0.33333333333333
68122, 1.504347826087, 1.0630434782609, 0.33333333333333
68123, 1.504347826087, 1.0369565217391, 0.30555555555556
68124, 1.4826086956522, 1.0369565217391, 0.27777777777778
68125, 1.504347826087, 1.0630434782609, 0.27777777777778
68126, 1.504347826087, 1.0369565217391, 0.25
68127, 1.4826086956522, 1.0369565217391, 0.22222222222222
68128, 1.504347826087, 1.0630434782609, 0.22222222222222
68129, 1.504347826087, 1.0369565217391, 0.19444444444444
68130, 1.4826086956522, 1.0369565217391, 0.16666666666667
68131, 1.504347826087, 1.0630434782609, 0.16666666666667
68132, 1.504347826087, 1.0369565217391, 0.13888888888889
68133, 1.4826086956522, 1.0369565217391, 0.11111111111111
68134, 1.504347826087, 1.0630434782609, 0.11111111111111
68135, 1.504347826087, 1.0369565217391, 0.083333333333333
68136, 1.4826086956522, 1.0369565217391, 0.055555555555556
68137, 1.504347826087, 1.0630434782609, 0.055555555555556
68138, 1.504347826087, 1.0369565217391, 0.027777777777778
68139, 1.5478260869565, 1.0369565217391, 0.47222222222222
68140, 1.5260869565217, 1.0369565217391, 0.44444444444444
68141, 1.5478260869565, 1.0630434782609, 0.44444444444444
68142, 1.5478260869565, 1.0369565217391, 0.41666666666667
68143, 1.5260869565217, 1.0369565217391, 0.38888888888889
68144, 1.5478260869565, 1.0630434782609, 0.38888888888889
68145, 1.5478260869565, 1.0369565217391, 0.36111111111111
68146, 1.5260869565217, 1.0369565217391, 0.33333333333333
68147, 1.5478260869565, 1.0630434782609, 0.33333333333333
68148, 1.5478260869565, 1.0369565217391, 0.30555555555556
68149, 1.5260869565217, 1.0369565217391, 0.27777777777778
68150, 1.5478260869565, 1.0630434782609, 0.27777777777778
68151, 1.5478260869565, 1.0369565217391, 0.25
68152, 1.5260869565217, 1.0369565217391, 0.22222222222222
68153, 1.5478260869565, 1.0630434782609, 0.22222222222222
68154, 1.5478260869565, 1.0369565217391, 0.19444444444444
68155, 1.5260869565217, 1.0369565217391, 0.16666666666667
68156, 1.5478260869565, 1.0630434782609, 0.16666666666667
68157, 1.5478260869565, 1.0369565217391, 0.13888888888889
68158, 1.5260869565217, 1.0369565217391, 0.11111111111111
68159, 1.5478260869565, 1.0630434782609, 0.11111111111111
68160, 1.5478260869565, 1.0369565217391, 0.083333333333333
68161, 1.5260869565217, 1.0369565217391, 0.055555555555556
68162, 1.5478260869565, 1.0630434782609, 0.055555555555556
68163, 1.5478260869565, 1.0369565217391, 0.027777777777778
68164, 1.5913043478261, 1.0369565217391, 0.47222222222222
68165, 1.5695652173913, 1.0369565217391, 0.44444444444444
68166, 1.5913043478261, 1.0630434782609, 0.44444444444444
68167, 1.5913043478261, 1.0369565217391, 0.41666666666667
68168, 1.5695652173913, 1.0369565217391, 0.38888888888889
68169, 1.5913043478261, 1.0630434782609, 0.38888888888889
68170, 1.5913043478261, 1.0369565217391, 0.36111111111111
68171, 1.5695652173913, 1.0369565217391, 0.33333333333333
68172, 1.5913043478261, 1.0630434782609, 0.33333333333333
68173, 1.5913043478261, 1.0369565217391, 0.30555555555556
68174, 1.5695652173913, 1.0369565217391, 0.27777777777778
68175, 1.5913043478261, 1.0630434782609, 0.27777777777778
68176, 1.5913043478261, 1.0369565217391, 0.25
68177, 1.5695652173913, 1.0369565217391, 0.22222222222222
68178, 1.5913043478261, 1.0630434782609, 0.22222222222222
68179, 1.5913043478261, 1.0369565217391, 0.19444444444444
68180, 1.5695652173913, 1.0369565217391, 0.16666666666667
68181, 1.5913043478261, 1.0630434782609, 0.16666666666667
68182, 1.5913043478261, 1.0369565217391, 0.13888888888889
68183, 1.5695652173913, 1.0369565217391, 0.11111111111111
68184, 1.5913043478261, 1.0630434782609, 0.11111111111111
68185, 1.5913043478261, 1.0369565217391, 0.083333333333333
68186, 1.5695652173913, 1.0369565217391, 0.055555555555556
68187, 1.5913043478261, 1.0630434782609, 0.055555555555556
68188, 1.5913043478261, 1.0369565217391, 0.027777777777778
68189, 1.6347826086957, 1.0369565217391, 0.47222222222222
68190, 1.6130434782609, 1.0369565217391, 0.44444444444444
68191, 1.6347826086957, 1.0630434782609, 0.44444444444444
68192, 1.6347826086957, 1.0369565217391, 0.41666666666667
68193, 1.6130434782609, 1.0369565217391, 0.38888888888889
68194, 1.6347826086957, 1.0630434782609, 0.38888888888889
68195, 1.6347826086957, 1.0369565217391, 0.36111111111111
68196, 1.6130434782609, 1.0369565217391, 0.33333333333333
68197, 1.6347826086957, 1.0630434782609, 0.33333333333333
68198, 1.6347826086957, 1.0369565217391, 0.30555555555556
68199, 1.6130434782609, 1.0369565217391, 0.27777777777778
68200, 1.6347826086957, 1.0630434782609, 0.27777777777778
68201, 1.6347826086957, 1.0369565217391, 0.25
68202, 1.6130434782609, 1.0369565217391, 0.22222222222222
68203, 1.6347826086957, 1.0630434782609, 0.22222222222222
68204, 1.6347826086957, 1.0369565217391, 0.19444444444444
68205, 1.6130434782609, 1.0369565217391, 0.16666666666667
68206, 1.6347826086957, 1.0630434782609, 0.16666666666667
68207, 1.6347826086957, 1.0369565217391, 0.13888888888889
68208, 1.6130434782609, 1.0369565217391, 0.11111111111111
68209, 1.6347826086957, 1.0630434782609, 0.11111111111111
68210, 1.6347826086957, 1.0369565217391, 0.083333333333333
68211, 1.6130434782609, 1.0369565217391, 0.055555555555556
68212, 1.6347826086957, 1.0630434782609, 0.055555555555556
68213, 1.6347826086957, 1.0369565217391, 0.027777777777778
68214, 1.6782608695652, 1.0369565217391, 0.47222222222222
68215, 1.6565217391304, 1.0369565217391, 0.44444444444444
68216, 1.6782608695652, 1.0630434782609, 0.44444444444444
68217, 1.6782608695652, 1.0369565217391, 0.41666666666667
68218, 1.6565217391304, 1.0369565217391, 0.38888888888889
68219, 1.6782608695652, 1.0630434782609, 0.38888888888889
68220, 1.6782608695652, 1.0369565217391, 0.36111111111111
68221, 1.6565217391304, 1.0369565217391, 0.33333333333333
68222, 1.6782608695652, 1.0630434782609, 0.33333333333333
68223, 1.6782608695652, 1.0369565217391, 0.30555555555556
68224, 1.6565217391304, 1.0369565217391, 0.27777777777778
68225, 1.6782608695652, 1.0630434782609, 0.27777777777778
68226, 1.6782608695652, 1.0369565217391, 0.25
68227, 1.6565217391304, 1.0369565217391, 0.22222222222222
68228, 1.6782608695652, 1.0630434782609, 0.22222222222222
68229, 1.6782608695652, 1.0369565217391, 0.19444444444444
68230, 1.6565217391304, 1.0369565217391, 0.16666666666667
68231, 1.6782608695652, 1.0630434782609, 0.16666666666667
68232, 1.6782608695652, 1.0369565217391, 0.13888888888889
68233, 1.6565217391304, 1.0369565217391, 0.11111111111111
68234, 1.6782608695652, 1.0630434782609, 0.11111111111111
68235, 1.6782608695652, 1.0369565217391, 0.083333333333333
68236, 1.6565217391304, 1.0369565217391, 0.055555555555556
68237, 1.6782608695652, 1.0630434782609, 0.055555555555556
68238, 1.6782608695652, 1.0369565217391, 0.027777777777778
68239, 1.7217391304348, 1.0369565217391, 0.47222222222222
68240, 1.7, 1.0369565217391, 0.44444444444444
68241, 1.7217391304348, 1.0630434782609, 0.44444444444444
68242, 1.7217391304348, 1.0369565217391, 0.41666666666667
68243, 1.7, 1.0369565217391, 0.38888888888889
68244, 1.7217391304348, 1.0630434782609, 0.38888888888889
68245, 1.7217391304348, 1.0369565217391, 0.36111111111111
68246, 1.7, 1.0369565217391, 0.33333333333333
68247, 1.7217391304348, 1.0630434782609, 0.33333333333333
68248, 1.7217391304348, 1.0369565217391, 0.30555555555556
68249, 1.7, 1.0369565217391, 0.27777777777778
68250, 1.7217391304348, 1.0630434782609, 0.27777777777778
68251, 1.7217391304348, 1.0369565217391, 0.25
68252, 1.7, 1.0369565217391, 0.22222222222222
68253, 1.7217391304348, 1.0630434782609, 0.22222222222222
68254, 1.7217391304348, 1.0369565217391, 0.19444444444444
68255, 1.7, 1.0369565217391, 0.16666666666667
68256, 1.7217391304348, 1.0630434782609, 0.16666666666667
68257, 1.7217391304348, 1.0369565217391, 0.13888888888889
68258, 1.7, 1.0369565217391, 0.11111111111111
68259, 1.7217391304348, 1.0630434782609, 0.11111111111111
68260, 1.7217391304348, 1.0369565217391, 0.083333333333333
68261, 1.7, 1.0369565217391, 0.055555555555556
68262, 1.7217391304348, 1.0630434782609, 0.055555555555556
68263, 1.7217391304348, 1.0369565217391, 0.027777777777778
68264, 1.7652173913043, 1.0369565217391, 0.47222222222222
68265, 1.7434782608696, 1.0369565217391, 0.44444444444444
68266, 1.7652173913043, 1.0630434782609, 0.44444444444444
68267, 1.7652173913043, 1.0369565217391, 0.41666666666667
68268, 1.7434782608696, 1.0369565217391, 0.38888888888889
68269, 1.7652173913043, 1.0630434782609, 0.38888888888889
68270, 1.7652173913043, 1.0369565217391, 0.36111111111111
68271, 1.7434782608696, 1.0369565217391, 0.33333333333333
68272, 1.7652173913043, 1.0630434782609, 0.33333333333333
68273, 1.7652173913043, 1.0369565217391, 0.30555555555556
68274, 1.7434782608696, 1.0369565217391, 0.27777777777778
68275, 1.7652173913043, 1.0630434782609, 0.27777777777778
68276, 1.7652173913043, 1.0369565217391, 0.25
68277, 1.7434782608696, 1.0369565217391, 0.22222222222222
68278, 1.7652173913043, 1.0630434782609, 0.22222222222222
68279, 1.7652173913043, 1.0369565217391, 0.19444444444444
68280, 1.7434782608696, 1.0369565217391, 0.16666666666667
68281, 1.7652173913043, 1.0630434782609, 0.16666666666667
68282, 1.7652173913043, 1.0369565217391, 0.13888888888889
68283, 1.7434782608696, 1.0369565217391, 0.11111111111111
68284, 1.7652173913043, 1.0630434782609, 0.11111111111111
68285, 1.7652173913043, 1.0369565217391, 0.083333333333333
68286, 1.7434782608696, 1.0369565217391, 0.055555555555556
68287, 1.7652173913043, 1.0630434782609, 0.055555555555556
68288, 1.7652173913043, 1.0369565217391, 0.027777777777778
68289, 1.8086956521739, 1.0369565217391, 0.47222222222222
68290, 1.7869565217391, 1.0369565217391, 0.44444444444444
68291, 1.8086956521739, 1.0630434782609, 0.44444444444444
68292, 1.8086956521739, 1.0369565217391, 0.41666666666667
68293, 1.7869565217391, 1.0369565217391, 0.38888888888889
68294, 1.8086956521739, 1.0630434782609, 0.38888888888889
68295, 1.8086956521739, 1.0369565217391, 0.36111111111111
68296, 1.7869565217391, 1.0369565217391, 0.33333333333333
68297, 1.8086956521739, 1.0630434782609, 0.33333333333333
68298, 1.8086956521739, 1.0369565217391, 0.30555555555556
68299, 1.7869565217391, 1.0369565217391, 0.27777777777778
68300, 1.8086956521739, 1.0630434782609, 0.27777777777778
68301, 1.8086956521739, 1.0369565217391, 0.25
68302, 1.7869565217391, 1.0369565217391, 0.22222222222222
68303, 1.8086956521739, 1.0630434782609, 0.22222222222222
68304, 1.8086956521739, 1.0369565217391, 0.19444444444444
68305, 1.7869565217391, 1.0369565217391, 0.16666666666667
68306, 1.8086956521739, 1.0630434782609, 0.16666666666667
68307, 1.8086956521739, 1.0369565217391, 0.13888888888889
68308, 1.7869565217391, 1.0369565217391, 0.11111111111111
68309, 1.8086956521739, 1.0630434782609, 0.11111111111111
68310, 1.8086956521739, 1.0369565217391, 0.083333333333333
68311, 1.7869565217391, 1.0369565217391, 0.055555555555556
68312, 1.8086956521739, 1.0630434782609, 0.055555555555556
68313, 1.8086956521739, 1.0369565217391, 0.027777777777778
68314, 1.8521739130435, 1.0369565217391, 0.47222222222222
68315, 1.8304347826087, 1.0369565217391, 0.44444444444444
68316, 1.8521739130435, 1.0630434782609, 0.44444444444444
68317, 1.8521739130435, 1.0369565217391, 0.41666666666667
68318, 1.8304347826087, 1.0369565217391, 0.38888888888889
68319, 1.8521739130435, 1.0630434782609, 0.38888888888889
68320, 1.8521739130435, 1.0369565217391, 0.36111111111111
68321, 1.8304347826087, 1.0369565217391, 0.33333333333333
68322, 1.8521739130435, 1.0630434782609, 0.33333333333333
68323, 1.8521739130435, 1.0369565217391, 0.30555555555556
68324, 1.8304347826087, 1.0369565217391, 0.27777777777778
68325, 1.8521739130435, 1.0630434782609, 0.27777777777778
68326, 1.8521739130435, 1.0369565217391, 0.25
68327, 1.8304347826087, 1.0369565217391, 0.22222222222222
68328, 1.8521739130435, 1.0630434782609, 0.22222222222222
68329, 1.8521739130435, 1.0369565217391, 0.19444444444444
68330, 1.8304347826087, 1.0369565217391, 0.16666666666667
68331, 1.8521739130435, 1.0630434782609, 0.16666666666667
68332, 1.8521739130435, 1.0369565217391, 0.13888888888889
68333, 1.8304347826087, 1.0369565217391, 0.11111111111111
68334, 1.8521739130435, 1.0630434782609, 0.11111111111111
68335, 1.8521739130435, 1.0369565217391, 0.083333333333333
68336, 1.8304347826087, 1.0369565217391, 0.055555555555556
68337, 1.8521739130435, 1.0630434782609, 0.055555555555556
68338, 1.8521739130435, 1.0369565217391, 0.027777777777778
68339, 1.895652173913, 1.0369565217391, 0.47222222222222
68340, 1.8739130434783, 1.0369565217391, 0.44444444444444
68341, 1.895652173913, 1.0630434782609, 0.44444444444444
68342, 1.895652173913, 1.0369565217391, 0.41666666666667
68343, 1.8739130434783, 1.0369565217391, 0.38888888888889
68344, 1.895652173913, 1.0630434782609, 0.38888888888889
68345, 1.895652173913, 1.0369565217391, 0.36111111111111
68346, 1.8739130434783, 1.0369565217391, 0.33333333333333
68347, 1.895652173913, 1.0630434782609, 0.33333333333333
68348, 1.895652173913, 1.0369565217391, 0.30555555555556
68349, 1.8739130434783, 1.0369565217391, 0.27777777777778
68350, 1.895652173913, 1.0630434782609, 0.27777777777778
68351, 1.895652173913, 1.0369565217391, 0.25
68352, 1.8739130434783, 1.0369565217391, 0.22222222222222
68353, 1.895652173913, 1.0630434782609, 0.22222222222222
68354, 1.895652173913, 1.0369565217391, 0.19444444444444
68355, 1.8739130434783, 1.0369565217391, 0.16666666666667
68356, 1.895652173913, 1.0630434782609, 0.16666666666667
68357, 1.895652173913, 1.0369565217391, 0.13888888888889
68358, 1.8739130434783, 1.0369565217391, 0.11111111111111
68359, 1.895652173913, 1.0630434782609, 0.11111111111111
68360, 1.895652173913, 1.0369565217391, 0.083333333333333
68361, 1.8739130434783, 1.0369565217391, 0.055555555555556
68362, 1.895652173913, 1.0630434782609, 0.055555555555556
68363, 1.895652173913, 1.0369565217391, 0.027777777777778
68364, 1.9391304347826, 1.0369565217391, 0.47222222222222
68365, 1.9173913043478, 1.0369565217391, 0.44444444444444
68366, 1.9391304347826, 1.0630434782609, 0.44444444444444
68367, 1.9391304347826, 1.0369565217391, 0.41666666666667
68368, 1.9173913043478, 1.0369565217391, 0.38888888888889
68369, 1.9391304347826, 1.0630434782609, 0.38888888888889
68370, 1.9391304347826, 1.0369565217391, 0.36111111111111
68371, 1.9173913043478, 1.0369565217391, 0.33333333333333
68372, 1.9391304347826, 1.0630434782609, 0.33333333333333
68373, 1.9391304347826, 1.0369565217391, 0.30555555555556
68374, 1.9173913043478, 1.0369565217391, 0.27777777777778
68375, 1.9391304347826, 1.0630434782609, 0.27777777777778
68376, 1.9391304347826, 1.0369565217391, 0.25
68377, 1.9173913043478, 1.0369565217391, 0.22222222222222
68378, 1.9391304347826, 1.0630434782609, 0.22222222222222
68379, 1.9391304347826, 1.0369565217391, 0.19444444444444
68380, 1.9173913043478, 1.0369565217391, 0.16666666666667
68381, 1.9391304347826, 1.0630434782609, 0.16666666666667
68382, 1.9391304347826, 1.0369565217391, 0.13888888888889
68383, 1.9173913043478, 1.0369565217391, 0.11111111111111
68384, 1.9391304347826, 1.0630434782609, 0.11111111111111
68385, 1.9391304347826, 1.0369565217391, 0.083333333333333
68386, 1.9173913043478, 1.0369565217391, 0.055555555555556
68387, 1.9391304347826, 1.0630434782609, 0.055555555555556
68388, 1.9391304347826, 1.0369565217391, 0.027777777777778
68389, 1.9826086956522, 1.0369565217391, 0.47222222222222
68390, 1.9608695652174, 1.0369565217391, 0.44444444444444
68391, 1.9826086956522, 1.0630434782609, 0.44444444444444
68392, 1.9826086956522, 1.0369565217391, 0.41666666666667
68393, 1.9608695652174, 1.0369565217391, 0.38888888888889
68394, 1.9826086956522, 1.0630434782609, 0.38888888888889
68395, 1.9826086956522, 1.0369565217391, 0.36111111111111
68396, 1.9608695652174, 1.0369565217391, 0.33333333333333
68397, 1.9826086956522, 1.0630434782609, 0.33333333333333
68398, 1.9826086956522, 1.0369565217391, 0.30555555555556
68399, 1.9608695652174, 1.0369565217391, 0.27777777777778
68400, 1.9826086956522, 1.0630434782609, 0.27777777777778
68401, 1.9826086956522, 1.0369565217391, 0.25
68402, 1.9608695652174, 1.0369565217391, 0.22222222222222
68403, 1.9826086956522, 1.0630434782609, 0.22222222222222
68404, 1.9826086956522, 1.0369565217391, 0.19444444444444
68405, 1.9608695652174, 1.0369565217391, 0.16666666666667
68406, 1.9826086956522, 1.0630434782609, 0.16666666666667
68407, 1.9826086956522, 1.0369565217391, 0.13888888888889
68408, 1.9608695652174, 1.0369565217391, 0.11111111111111
68409, 1.9826086956522, 1.0630434782609, 0.11111111111111
68410, 1.9826086956522, 1.0369565217391, 0.083333333333333
68411, 1.9608695652174, 1.0369565217391, 0.055555555555556
68412, 1.9826086956522, 1.0630434782609, 0.055555555555556
68413, 1.9826086956522, 1.0369565217391, 0.027777777777778
68414, 2.0260869565217, 1.0369565217391, 0.47222222222222
68415, 2.004347826087, 1.0369565217391, 0.44444444444444
68416, 2.0260869565217, 1.0630434782609, 0.44444444444444
68417, 2.0260869565217, 1.0369565217391, 0.41666666666667
68418, 2.004347826087, 1.0369565217391, 0.38888888888889
68419, 2.0260869565217, 1.0630434782609, 0.38888888888889
68420, 2.0260869565217, 1.0369565217391, 0.36111111111111
68421, 2.004347826087, 1.0369565217391, 0.33333333333333
68422, 2.0260869565217, 1.0630434782609, 0.33333333333333
68423, 2.0260869565217, 1.0369565217391, 0.30555555555556
68424, 2.004347826087, 1.0369565217391, 0.27777777777778
68425, 2.0260869565217, 1.0630434782609, 0.27777777777778
68426, 2.0260869565217, 1.0369565217391, 0.25
68427, 2.004347826087, 1.0369565217391, 0.22222222222222
68428, 2.0260869565217, 1.0630434782609, 0.22222222222222
68429, 2.0260869565217, 1.0369565217391, 0.19444444444444
68430, 2.004347826087, 1.0369565217391, 0.16666666666667
68431, 2.0260869565217, 1.0630434782609, 0.16666666666667
68432, 2.0260869565217, 1.0369565217391, 0.13888888888889
68433, 2.004347826087, 1.0369565217391, 0.11111111111111
68434, 2.0260869565217, 1.0630434782609, 0.11111111111111
68435, 2.0260869565217, 1.0369565217391, 0.083333333333333
68436, 2.004347826087, 1.0369565217391, 0.055555555555556
68437, 2.0260869565217, 1.0630434782609, 0.055555555555556
68438, 2.0260869565217, 1.0369565217391, 0.027777777777778
68439, 2.0695652173913, 1.0369565217391, 0.47222222222222
68440, 2.0478260869565, 1.0369565217391, 0.44444444444444
68441, 2.0695652173913, 1.0630434782609, 0.44444444444444
68442, 2.0695652173913, 1.0369565217391, 0.41666666666667
68443, 2.0478260869565, 1.0369565217391, 0.38888888888889
68444, 2.0695652173913, 1.0630434782609, 0.38888888888889
68445, 2.0695652173913, 1.0369565217391, 0.36111111111111
68446, 2.0478260869565, 1.0369565217391, 0.33333333333333
68447, 2.0695652173913, 1.0630434782609, 0.33333333333333
68448, 2.0695652173913, 1.0369565217391, 0.30555555555556
68449, 2.0478260869565, 1.0369565217391, 0.27777777777778
68450, 2.0695652173913, 1.0630434782609, 0.27777777777778
68451, 2.0695652173913, 1.0369565217391, 0.25
68452, 2.0478260869565, 1.0369565217391, 0.22222222222222
68453, 2.0695652173913, 1.0630434782609, 0.22222222222222
68454, 2.0695652173913, 1.0369565217391, 0.19444444444444
68455, 2.0478260869565, 1.0369565217391, 0.16666666666667
68456, 2.0695652173913, 1.0630434782609, 0.16666666666667
68457, 2.0695652173913, 1.0369565217391, 0.13888888888889
68458, 2.0478260869565, 1.0369565217391, 0.11111111111111
68459, 2.0695652173913, 1.0630434782609, 0.11111111111111
68460, 2.0695652173913, 1.0369565217391, 0.083333333333333
68461, 2.0478260869565, 1.0369565217391, 0.055555555555556
68462, 2.0695652173913, 1.0630434782609, 0.055555555555556
68463, 2.0695652173913, 1.0369565217391, 0.027777777777778
68464, 2.1130434782609, 1.0369565217391, 0.47222222222222
68465, 2.0913043478261, 1.0369565217391, 0.44444444444444
68466, 2.1130434782609, 1.0630434782609, 0.44444444444444
68467, 2.1130434782609, 1.0369565217391, 0.41666666666667
68468, 2.0913043478261, 1.0369565217391, 0.38888888888889
68469, 2.1130434782609, 1.0630434782609, 0.38888888888889
68470, 2.1130434782609, 1.0369565217391, 0.36111111111111
68471, 2.0913043478261, 1.0369565217391, 0.33333333333333
68472, 2.1130434782609, 1.0630434782609, 0.33333333333333
68473, 2.1130434782609, 1.0369565217391, 0.30555555555556
68474, 2.0913043478261, 1.0369565217391, 0.27777777777778
68475, 2.1130434782609, 1.0630434782609, 0.27777777777778
68476, 2.1130434782609, 1.0369565217391, 0.25
68477, 2.0913043478261, 1.0369565217391, 0.22222222222222
68478, 2.1130434782609, 1.0630434782609, 0.22222222222222
68479, 2.1130434782609, 1.0369565217391, 0.19444444444444
68480, 2.0913043478261, 1.0369565217391, 0.16666666666667
68481, 2.1130434782609, 1.0630434782609, 0.16666666666667
68482, 2.1130434782609, 1.0369565217391, 0.13888888888889
68483, 2.0913043478261, 1.0369565217391, 0.11111111111111
68484, 2.1130434782609, 1.0630434782609, 0.11111111111111
68485, 2.1130434782609, 1.0369565217391, 0.083333333333333
68486, 2.0913043478261, 1.0369565217391, 0.055555555555556
68487, 2.1130434782609, 1.0630434782609, 0.055555555555556
68488, 2.1130434782609, 1.0369565217391, 0.027777777777778
68489, 2.1565217391304, 1.0369565217391, 0.47222222222222
68490, 2.1347826086957, 1.0369565217391, 0.44444444444444
68491, 2.1565217391304, 1.0630434782609, 0.44444444444444
68492, 2.1565217391304, 1.0369565217391, 0.41666666666667
68493, 2.1347826086957, 1.0369565217391, 0.38888888888889
68494, 2.1565217391304, 1.0630434782609, 0.38888888888889
68495, 2.1565217391304, 1.0369565217391, 0.36111111111111
68496, 2.1347826086957, 1.0369565217391, 0.33333333333333
68497, 2.1565217391304, 1.0630434782609, 0.33333333333333
68498, 2.1565217391304, 1.0369565217391, 0.30555555555556
68499, 2.1347826086957, 1.0369565217391, 0.27777777777778
68500, 2.1565217391304, 1.0630434782609, 0.27777777777778
68501, 2.1565217391304, 1.0369565217391, 0.25
68502, 2.1347826086957, 1.0369565217391, 0.22222222222222
68503, 2.1565217391304, 1.0630434782609, 0.22222222222222
68504, 2.1565217391304, 1.0369565217391, 0.19444444444444
68505, 2.1347826086957, 1.0369565217391, 0.16666666666667
68506, 2.1565217391304, 1.0630434782609, 0.16666666666667
68507, 2.1565217391304, 1.0369565217391, 0.13888888888889
68508, 2.1347826086957, 1.0369565217391, 0.11111111111111
68509, 2.1565217391304, 1.0630434782609, 0.11111111111111
68510, 2.1565217391304, 1.0369565217391, 0.083333333333333
68511, 2.1347826086957, 1.0369565217391, 0.055555555555556
68512, 2.1565217391304, 1.0630434782609, 0.055555555555556
68513, 2.1565217391304, 1.0369565217391, 0.027777777777778
68514, 2.1782608695652, 1.0369565217391, 0.44444444444444
68515, 2.1782608695652, 1.0369565217391, 0.38888888888889
68516, 2.1782608695652, 1.0369565217391, 0.33333333333333
68517, 2.1782608695652, 1.0369565217391, 0.27777777777778
68518, 2.1782608695652, 1.0369565217391, 0.22222222222222
68519, 2.1782608695652, 1.0369565217391, 0.16666666666667
68520, 2.1782608695652, 1.0369565217391, 0.11111111111111
68521, 2.1782608695652, 1.0369565217391, 0.055555555555556
68522, 1.2434782608696, 0.98478260869565, 0.47222222222222
68523, 1.2217391304348, 0.98478260869565, 0.44444444444444
68524, 1.2434782608696, 1.0108695652174, 0.44444444444444
68525, 1.2434782608696, 0.98478260869565, 0.41666666666667
68526, 1.2217391304348, 0.98478260869565, 0.38888888888889
68527, 1.2434782608696, 1.0108695652174, 0.38888888888889
68528, 1.2434782608696, 0.98478260869565, 0.36111111111111
68529, 1.2217391304348, 0.98478260869565, 0.33333333333333
68530, 1.2434782608696, 1.0108695652174, 0.33333333333333
68531, 1.2434782608696, 0.98478260869565, 0.30555555555556
68532, 1.2217391304348, 0.98478260869565, 0.27777777777778
68533, 1.2434782608696, 1.0108695652174, 0.27777777777778
68534, 1.2434782608696, 0.98478260869565, 0.25
68535, 1.2217391304348, 0.98478260869565, 0.22222222222222
68536, 1.2434782608696, 1.0108695652174, 0.22222222222222
68537, 1.2434782608696, 0.98478260869565, 0.19444444444444
68538, 1.2217391304348, 0.98478260869565, 0.16666666666667
68539, 1.2434782608696, 1.0108695652174, 0.16666666666667
68540, 1.2434782608696, 0.98478260869565, 0.13888888888889
68541, 1.2217391304348, 0.98478260869565, 0.11111111111111
68542, 1.2434782608696, 1.0108695652174, 0.11111111111111
68543, 1.2434782608696, 0.98478260869565, 0.083333333333333
68544, 1.2217391304348, 0.98478260869565, 0.055555555555556
68545, 1.2434782608696, 1.0108695652174, 0.055555555555556
68546, 1.2434782608696, 0.98478260869565, 0.027777777777778
68547, 1.2869565217391, 0.98478260869565, 0.47222222222222
68548, 1.2652173913043, 0.98478260869565, 0.44444444444444
68549, 1.2869565217391, 1.0108695652174, 0.44444444444444
68550, 1.2869565217391, 0.98478260869565, 0.41666666666667
68551, 1.2652173913043, 0.98478260869565, 0.38888888888889
68552, 1.2869565217391, 1.0108695652174, 0.38888888888889
68553, 1.2869565217391, 0.98478260869565, 0.36111111111111
68554, 1.2652173913043, 0.98478260869565, 0.33333333333333
68555, 1.2869565217391, 1.0108695652174, 0.33333333333333
68556, 1.2869565217391, 0.98478260869565, 0.30555555555556
68557, 1.2652173913043, 0.98478260869565, 0.27777777777778
68558, 1.2869565217391, 1.0108695652174, 0.27777777777778
68559, 1.2869565217391, 0.98478260869565, 0.25
68560, 1.2652173913043, 0.98478260869565, 0.22222222222222
68561, 1.2869565217391, 1.0108695652174, 0.22222222222222
68562, 1.2869565217391, 0.98478260869565, 0.19444444444444
68563, 1.2652173913043, 0.98478260869565, 0.16666666666667
68564, 1.2869565217391, 1.0108695652174, 0.16666666666667
68565, 1.2869565217391, 0.98478260869565, 0.13888888888889
68566, 1.2652173913043, 0.98478260869565, 0.11111111111111
68567, 1.2869565217391, 1.0108695652174, 0.11111111111111
68568, 1.2869565217391, 0.98478260869565, 0.083333333333333
68569, 1.2652173913043, 0.98478260869565, 0.055555555555556
68570, 1.2869565217391, 1.0108695652174, 0.055555555555556
68571, 1.2869565217391, 0.98478260869565, 0.027777777777778
68572, 1.3304347826087, 0.98478260869565, 0.47222222222222
68573, 1.3086956521739, 0.98478260869565, 0.44444444444444
68574, 1.3304347826087, 1.0108695652174, 0.44444444444444
68575, 1.3304347826087, 0.98478260869565, 0.41666666666667
68576, 1.3086956521739, 0.98478260869565, 0.38888888888889
68577, 1.3304347826087, 1.0108695652174, 0.38888888888889
68578, 1.3304347826087, 0.98478260869565, 0.36111111111111
68579, 1.3086956521739, 0.98478260869565, 0.33333333333333
68580, 1.3304347826087, 1.0108695652174, 0.33333333333333
68581, 1.3304347826087, 0.98478260869565, 0.30555555555556
68582, 1.3086956521739, 0.98478260869565, 0.27777777777778
68583, 1.3304347826087, 1.0108695652174, 0.27777777777778
68584, 1.3304347826087, 0.98478260869565, 0.25
68585, 1.3086956521739, 0.98478260869565, 0.22222222222222
68586, 1.3304347826087, 1.0108695652174, 0.22222222222222
68587, 1.3304347826087, 0.98478260869565, 0.19444444444444
68588, 1.3086956521739, 0.98478260869565, 0.16666666666667
68589, 1.3304347826087, 1.0108695652174, 0.16666666666667
68590, 1.3304347826087, 0.98478260869565, 0.13888888888889
68591, 1.3086956521739, 0.98478260869565, 0.11111111111111
68592, 1.3304347826087, 1.0108695652174, 0.11111111111111
68593, 1.3304347826087, 0.98478260869565, 0.083333333333333
68594, 1.3086956521739, 0.98478260869565, 0.055555555555556
68595, 1.3304347826087, 1.0108695652174, 0.055555555555556
68596, 1.3304347826087, 0.98478260869565, 0.027777777777778
68597, 1.3739130434783, 0.98478260869565, 0.47222222222222
68598, 1.3521739130435, 0.98478260869565, 0.44444444444444
68599, 1.3739130434783, 1.0108695652174, 0.44444444444444
68600, 1.3739130434783, 0.98478260869565, 0.41666666666667
68601, 1.3521739130435, 0.98478260869565, 0.38888888888889
68602, 1.3739130434783, 1.0108695652174, 0.38888888888889
68603, 1.3739130434783, 0.98478260869565, 0.36111111111111
68604, 1.3521739130435, 0.98478260869565, 0.33333333333333
68605, 1.3739130434783, 1.0108695652174, 0.33333333333333
68606, 1.3739130434783, 0.98478260869565, 0.30555555555556
68607, 1.3521739130435, 0.98478260869565, 0.27777777777778
68608, 1.3739130434783, 1.0108695652174, 0.27777777777778
68609, 1.3739130434783, 0.98478260869565, 0.25
68610, 1.3521739130435, 0.98478260869565, 0.22222222222222
68611, 1.3739130434783, 1.0108695652174, 0.22222222222222
68612, 1.3739130434783, 0.98478260869565, 0.19444444444444
68613, 1.3521739130435, 0.98478260869565, 0.16666666666667
68614, 1.3739130434783, 1.0108695652174, 0.16666666666667
68615, 1.3739130434783, 0.98478260869565, 0.13888888888889
68616, 1.3521739130435, 0.98478260869565, 0.11111111111111
68617, 1.3739130434783, 1.0108695652174, 0.11111111111111
68618, 1.3739130434783, 0.98478260869565, 0.083333333333333
68619, 1.3521739130435, 0.98478260869565, 0.055555555555556
68620, 1.3739130434783, 1.0108695652174, 0.055555555555556
68621, 1.3739130434783, 0.98478260869565, 0.027777777777778
68622, 1.4173913043478, 0.98478260869565, 0.47222222222222
68623, 1.395652173913, 0.98478260869565, 0.44444444444444
68624, 1.4173913043478, 1.0108695652174, 0.44444444444444
68625, 1.4173913043478, 0.98478260869565, 0.41666666666667
68626, 1.395652173913, 0.98478260869565, 0.38888888888889
68627, 1.4173913043478, 1.0108695652174, 0.38888888888889
68628, 1.4173913043478, 0.98478260869565, 0.36111111111111
68629, 1.395652173913, 0.98478260869565, 0.33333333333333
68630, 1.4173913043478, 1.0108695652174, 0.33333333333333
68631, 1.4173913043478, 0.98478260869565, 0.30555555555556
68632, 1.395652173913, 0.98478260869565, 0.27777777777778
68633, 1.4173913043478, 1.0108695652174, 0.27777777777778
68634, 1.4173913043478, 0.98478260869565, 0.25
68635, 1.395652173913, 0.98478260869565, 0.22222222222222
68636, 1.4173913043478, 1.0108695652174, 0.22222222222222
68637, 1.4173913043478, 0.98478260869565, 0.19444444444444
68638, 1.395652173913, 0.98478260869565, 0.16666666666667
68639, 1.4173913043478, 1.0108695652174, 0.16666666666667
68640, 1.4173913043478, 0.98478260869565, 0.13888888888889
68641, 1.395652173913, 0.98478260869565, 0.11111111111111
68642, 1.4173913043478, 1.0108695652174, 0.11111111111111
68643, 1.4173913043478, 0.98478260869565, 0.083333333333333
68644, 1.395652173913, 0.98478260869565, 0.055555555555556
68645, 1.4173913043478, 1.0108695652174, 0.055555555555556
68646, 1.4173913043478, 0.98478260869565, 0.027777777777778
68647, 1.4608695652174, 0.98478260869565, 0.47222222222222
68648, 1.4391304347826, 0.98478260869565, 0.44444444444444
68649, 1.4608695652174, 1.0108695652174, 0.44444444444444
68650, 1.4608695652174, 0.98478260869565, 0.41666666666667
68651, 1.4391304347826, 0.98478260869565, 0.38888888888889
68652, 1.4608695652174, 1.0108695652174, 0.38888888888889
68653, 1.4608695652174, 0.98478260869565, 0.36111111111111
68654, 1.4391304347826, 0.98478260869565, 0.33333333333333
68655, 1.4608695652174, 1.0108695652174, 0.33333333333333
68656, 1.4608695652174, 0.98478260869565, 0.30555555555556
68657, 1.4391304347826, 0.98478260869565, 0.27777777777778
68658, 1.4608695652174, 1.0108695652174, 0.27777777777778
68659, 1.4608695652174, 0.98478260869565, 0.25
68660, 1.4391304347826, 0.98478260869565, 0.22222222222222
68661, 1.4608695652174, 1.0108695652174, 0.22222222222222
68662, 1.4608695652174, 0.98478260869565, 0.19444444444444
68663, 1.4391304347826, 0.98478260869565, 0.16666666666667
68664, 1.4608695652174, 1.0108695652174, 0.16666666666667
68665, 1.4608695652174, 0.98478260869565, 0.13888888888889
68666, 1.4391304347826, 0.98478260869565, 0.11111111111111
68667, 1.4608695652174, 1.0108695652174, 0.11111111111111
68668, 1.4608695652174, 0.98478260869565, 0.083333333333333
68669, 1.4391304347826, 0.98478260869565, 0.055555555555556
68670, 1.4608695652174, 1.0108695652174, 0.055555555555556
68671, 1.4608695652174, 0.98478260869565, 0.027777777777778
68672, 1.504347826087, 0.98478260869565, 0.47222222222222
68673, 1.4826086956522, 0.98478260869565, 0.44444444444444
68674, 1.504347826087, 1.0108695652174, 0.44444444444444
68675, 1.504347826087, 0.98478260869565, 0.41666666666667
68676, 1.4826086956522, 0.98478260869565, 0.38888888888889
68677, 1.504347826087, 1.0108695652174, 0.38888888888889
68678, 1.504347826087, 0.98478260869565, 0.36111111111111
68679, 1.4826086956522, 0.98478260869565, 0.33333333333333
68680, 1.504347826087, 1.0108695652174, 0.33333333333333
68681, 1.504347826087, 0.98478260869565, 0.30555555555556
68682, 1.4826086956522, 0.98478260869565, 0.27777777777778
68683, 1.504347826087, 1.0108695652174, 0.27777777777778
68684, 1.504347826087, 0.98478260869565, 0.25
68685, 1.4826086956522, 0.98478260869565, 0.22222222222222
68686, 1.504347826087, 1.0108695652174, 0.22222222222222
68687, 1.504347826087, 0.98478260869565, 0.19444444444444
68688, 1.4826086956522, 0.98478260869565, 0.16666666666667
68689, 1.504347826087, 1.0108695652174, 0.16666666666667
68690, 1.504347826087, 0.98478260869565, 0.13888888888889
68691, 1.4826086956522, 0.98478260869565, 0.11111111111111
68692, 1.504347826087, 1.0108695652174, 0.11111111111111
68693, 1.504347826087, 0.98478260869565, 0.083333333333333
68694, 1.4826086956522, 0.98478260869565, 0.055555555555556
68695, 1.504347826087, 1.0108695652174, 0.055555555555556
68696, 1.504347826087, 0.98478260869565, 0.027777777777778
68697, 1.5478260869565, 0.98478260869565, 0.47222222222222
68698, 1.5260869565217, 0.98478260869565, 0.44444444444444
68699, 1.5478260869565, 1.0108695652174, 0.44444444444444
68700, 1.5478260869565, 0.98478260869565, 0.41666666666667
68701, 1.5260869565217, 0.98478260869565, 0.38888888888889
68702, 1.5478260869565, 1.0108695652174, 0.38888888888889
68703, 1.5478260869565, 0.98478260869565, 0.36111111111111
68704, 1.5260869565217, 0.98478260869565, 0.33333333333333
68705, 1.5478260869565, 1.0108695652174, 0.33333333333333
68706, 1.5478260869565, 0.98478260869565, 0.30555555555556
68707, 1.5260869565217, 0.98478260869565, 0.27777777777778
68708, 1.5478260869565, 1.0108695652174, 0.27777777777778
68709, 1.5478260869565, 0.98478260869565, 0.25
68710, 1.5260869565217, 0.98478260869565, 0.22222222222222
68711, 1.5478260869565, 1.0108695652174, 0.22222222222222
68712, 1.5478260869565, 0.98478260869565, 0.19444444444444
68713, 1.5260869565217, 0.98478260869565, 0.16666666666667
68714, 1.5478260869565, 1.0108695652174, 0.16666666666667
68715, 1.5478260869565, 0.98478260869565, 0.13888888888889
68716, 1.5260869565217, 0.98478260869565, 0.11111111111111
68717, 1.5478260869565, 1.0108695652174, 0.11111111111111
68718, 1.5478260869565, 0.98478260869565, 0.083333333333333
68719, 1.5260869565217, 0.98478260869565, 0.055555555555556
68720, 1.5478260869565, 1.0108695652174, 0.055555555555556
68721, 1.5478260869565, 0.98478260869565, 0.027777777777778
68722, 1.5913043478261, 0.98478260869565, 0.47222222222222
68723, 1.5695652173913, 0.98478260869565, 0.44444444444444
68724, 1.5913043478261, 1.0108695652174, 0.44444444444444
68725, 1.5913043478261, 0.98478260869565, 0.41666666666667
68726, 1.5695652173913, 0.98478260869565, 0.38888888888889
68727, 1.5913043478261, 1.0108695652174, 0.38888888888889
68728, 1.5913043478261, 0.98478260869565, 0.36111111111111
68729, 1.5695652173913, 0.98478260869565, 0.33333333333333
68730, 1.5913043478261, 1.0108695652174, 0.33333333333333
68731, 1.5913043478261, 0.98478260869565, 0.30555555555556
68732, 1.5695652173913, 0.98478260869565, 0.27777777777778
68733, 1.5913043478261, 1.0108695652174, 0.27777777777778
68734, 1.5913043478261, 0.98478260869565, 0.25
68735, 1.5695652173913, 0.98478260869565, 0.22222222222222
68736, 1.5913043478261, 1.0108695652174, 0.22222222222222
68737, 1.5913043478261, 0.98478260869565, 0.19444444444444
68738, 1.5695652173913, 0.98478260869565, 0.16666666666667
68739, 1.5913043478261, 1.0108695652174, 0.16666666666667
68740, 1.5913043478261, 0.98478260869565, 0.13888888888889
68741, 1.5695652173913, 0.98478260869565, 0.11111111111111
68742, 1.5913043478261, 1.0108695652174, 0.11111111111111
68743, 1.5913043478261, 0.98478260869565, 0.083333333333333
68744, 1.5695652173913, 0.98478260869565, 0.055555555555556
68745, 1.5913043478261, 1.0108695652174, 0.055555555555556
68746, 1.5913043478261, 0.98478260869565, 0.027777777777778
68747, 1.6347826086957, 0.98478260869565, 0.47222222222222
68748, 1.6130434782609, 0.98478260869565, 0.44444444444444
68749, 1.6347826086957, 1.0108695652174, 0.44444444444444
68750, 1.6347826086957, 0.98478260869565, 0.41666666666667
68751, 1.6130434782609, 0.98478260869565, 0.38888888888889
68752, 1.6347826086957, 1.0108695652174, 0.38888888888889
68753, 1.6347826086957, 0.98478260869565, 0.36111111111111
68754, 1.6130434782609, 0.98478260869565, 0.33333333333333
68755, 1.6347826086957, 1.0108695652174, 0.33333333333333
68756, 1.6347826086957, 0.98478260869565, 0.30555555555556
68757, 1.6130434782609, 0.98478260869565, 0.27777777777778
68758, 1.6347826086957, 1.0108695652174, 0.27777777777778
68759, 1.6347826086957, 0.98478260869565, 0.25
68760, 1.6130434782609, 0.98478260869565, 0.22222222222222
68761, 1.6347826086957, 1.0108695652174, 0.22222222222222
68762, 1.6347826086957, 0.98478260869565, 0.19444444444444
68763, 1.6130434782609, 0.98478260869565, 0.16666666666667
68764, 1.6347826086957, 1.0108695652174, 0.16666666666667
68765, 1.6347826086957, 0.98478260869565, 0.13888888888889
68766, 1.6130434782609, 0.98478260869565, 0.11111111111111
68767, 1.6347826086957, 1.0108695652174, 0.11111111111111
68768, 1.6347826086957, 0.98478260869565, 0.083333333333333
68769, 1.6130434782609, 0.98478260869565, 0.055555555555556
68770, 1.6347826086957, 1.0108695652174, 0.055555555555556
68771, 1.6347826086957, 0.98478260869565, 0.027777777777778
68772, 1.6782608695652, 0.98478260869565, 0.47222222222222
68773, 1.6565217391304, 0.98478260869565, 0.44444444444444
68774, 1.6782608695652, 1.0108695652174, 0.44444444444444
68775, 1.6782608695652, 0.98478260869565, 0.41666666666667
68776, 1.6565217391304, 0.98478260869565, 0.38888888888889
68777, 1.6782608695652, 1.0108695652174, 0.38888888888889
68778, 1.6782608695652, 0.98478260869565, 0.36111111111111
68779, 1.6565217391304, 0.98478260869565, 0.33333333333333
68780, 1.6782608695652, 1.0108695652174, 0.33333333333333
68781, 1.6782608695652, 0.98478260869565, 0.30555555555556
68782, 1.6565217391304, 0.98478260869565, 0.27777777777778
68783, 1.6782608695652, 1.0108695652174, 0.27777777777778
68784, 1.6782608695652, 0.98478260869565, 0.25
68785, 1.6565217391304, 0.98478260869565, 0.22222222222222
68786, 1.6782608695652, 1.0108695652174, 0.22222222222222
68787, 1.6782608695652, 0.98478260869565, 0.19444444444444
68788, 1.6565217391304, 0.98478260869565, 0.16666666666667
68789, 1.6782608695652, 1.0108695652174, 0.16666666666667
68790, 1.6782608695652, 0.98478260869565, 0.13888888888889
68791, 1.6565217391304, 0.98478260869565, 0.11111111111111
68792, 1.6782608695652, 1.0108695652174, 0.11111111111111
68793, 1.6782608695652, 0.98478260869565, 0.083333333333333
68794, 1.6565217391304, 0.98478260869565, 0.055555555555556
68795, 1.6782608695652, 1.0108695652174, 0.055555555555556
68796, 1.6782608695652, 0.98478260869565, 0.027777777777778
68797, 1.7217391304348, 0.98478260869565, 0.47222222222222
68798, 1.7, 0.98478260869565, 0.44444444444444
68799, 1.7217391304348, 1.0108695652174, 0.44444444444444
68800, 1.7217391304348, 0.98478260869565, 0.41666666666667
68801, 1.7, 0.98478260869565, 0.38888888888889
68802, 1.7217391304348, 1.0108695652174, 0.38888888888889
68803, 1.7217391304348, 0.98478260869565, 0.36111111111111
68804, 1.7, 0.98478260869565, 0.33333333333333
68805, 1.7217391304348, 1.0108695652174, 0.33333333333333
68806, 1.7217391304348, 0.98478260869565, 0.30555555555556
68807, 1.7, 0.98478260869565, 0.27777777777778
68808, 1.7217391304348, 1.0108695652174, 0.27777777777778
68809, 1.7217391304348, 0.98478260869565, 0.25
68810, 1.7, 0.98478260869565, 0.22222222222222
68811, 1.7217391304348, 1.0108695652174, 0.22222222222222
68812, 1.7217391304348, 0.98478260869565, 0.19444444444444
68813, 1.7, 0.98478260869565, 0.16666666666667
68814, 1.7217391304348, 1.0108695652174, 0.16666666666667
68815, 1.7217391304348, 0.98478260869565, 0.13888888888889
68816, 1.7, 0.98478260869565, 0.11111111111111
68817, 1.7217391304348, 1.0108695652174, 0.11111111111111
68818, 1.7217391304348, 0.98478260869565, 0.083333333333333
68819, 1.7, 0.98478260869565, 0.055555555555556
68820, 1.7217391304348, 1.0108695652174, 0.055555555555556
68821, 1.7217391304348, 0.98478260869565, 0.027777777777778
68822, 1.7652173913043, 0.98478260869565, 0.47222222222222
68823, 1.7434782608696, 0.98478260869565, 0.44444444444444
68824, 1.7652173913043, 1.0108695652174, 0.44444444444444
68825, 1.7652173913043, 0.98478260869565, 0.41666666666667
68826, 1.7434782608696, 0.98478260869565, 0.38888888888889
68827, 1.7652173913043, 1.0108695652174, 0.38888888888889
68828, 1.7652173913043, 0.98478260869565, 0.36111111111111
68829, 1.7434782608696, 0.98478260869565, 0.33333333333333
68830, 1.7652173913043, 1.0108695652174, 0.33333333333333
68831, 1.7652173913043, 0.98478260869565, 0.30555555555556
68832, 1.7434782608696, 0.98478260869565, 0.27777777777778
68833, 1.7652173913043, 1.0108695652174, 0.27777777777778
68834, 1.7652173913043, 0.98478260869565, 0.25
68835, 1.7434782608696, 0.98478260869565, 0.22222222222222
68836, 1.7652173913043, 1.0108695652174, 0.22222222222222
68837, 1.7652173913043, 0.98478260869565, 0.19444444444444
68838, 1.7434782608696, 0.98478260869565, 0.16666666666667
68839, 1.7652173913043, 1.0108695652174, 0.16666666666667
68840, 1.7652173913043, 0.98478260869565, 0.13888888888889
68841, 1.7434782608696, 0.98478260869565, 0.11111111111111
68842, 1.7652173913043, 1.0108695652174, 0.11111111111111
68843, 1.7652173913043, 0.98478260869565, 0.083333333333333
68844, 1.7434782608696, 0.98478260869565, 0.055555555555556
68845, 1.7652173913043, 1.0108695652174, 0.055555555555556
68846, 1.7652173913043, 0.98478260869565, 0.027777777777778
68847, 1.8086956521739, 0.98478260869565, 0.47222222222222
68848, 1.7869565217391, 0.98478260869565, 0.44444444444444
68849, 1.8086956521739, 1.0108695652174, 0.44444444444444
68850, 1.8086956521739, 0.98478260869565, 0.41666666666667
68851, 1.7869565217391, 0.98478260869565, 0.38888888888889
68852, 1.8086956521739, 1.0108695652174, 0.38888888888889
68853, 1.8086956521739, 0.98478260869565, 0.36111111111111
68854, 1.7869565217391, 0.98478260869565, 0.33333333333333
68855, 1.8086956521739, 1.0108695652174, 0.33333333333333
68856, 1.8086956521739, 0.98478260869565, 0.30555555555556
68857, 1.7869565217391, 0.98478260869565, 0.27777777777778
68858, 1.8086956521739, 1.0108695652174, 0.27777777777778
68859, 1.8086956521739, 0.98478260869565, 0.25
68860, 1.7869565217391, 0.98478260869565, 0.22222222222222
68861, 1.8086956521739, 1.0108695652174, 0.22222222222222
68862, 1.8086956521739, 0.98478260869565, 0.19444444444444
68863, 1.7869565217391, 0.98478260869565, 0.16666666666667
68864, 1.8086956521739, 1.0108695652174, 0.16666666666667
68865, 1.8086956521739, 0.98478260869565, 0.13888888888889
68866, 1.7869565217391, 0.98478260869565, 0.11111111111111
68867, 1.8086956521739, 1.0108695652174, 0.11111111111111
68868, 1.8086956521739, 0.98478260869565, 0.083333333333333
68869, 1.7869565217391, 0.98478260869565, 0.055555555555556
68870, 1.8086956521739, 1.0108695652174, 0.055555555555556
68871, 1.8086956521739, 0.98478260869565, 0.027777777777778
68872, 1.8521739130435, 0.98478260869565, 0.47222222222222
68873, 1.8304347826087, 0.98478260869565, 0.44444444444444
68874, 1.8521739130435, 1.0108695652174, 0.44444444444444
68875, 1.8521739130435, 0.98478260869565, 0.41666666666667
68876, 1.8304347826087, 0.98478260869565, 0.38888888888889
68877, 1.8521739130435, 1.0108695652174, 0.38888888888889
