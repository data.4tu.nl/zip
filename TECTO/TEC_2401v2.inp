3819, 8177, 8216, 8217, 8178, 10727, 10728, 10729, 10649
3820, 8178, 8217, 8218, 8179, 10729, 10730, 10731, 10651
3821, 8179, 8218, 8219, 8180, 10731, 10732, 10733, 10653
3822, 8180, 8219, 8220, 8181, 10733, 10734, 10735, 10655
3823, 8181, 8220, 8221, 8182, 10735, 10736, 10737, 10657
3824, 8182, 8221, 8222, 8183, 10737, 10738, 10739, 10659
3825, 8183, 8222, 8223, 8184, 10739, 10740, 10741, 10661
3826, 8184, 8223, 8224, 8185, 10741, 10742, 10743, 10663
3827, 8185, 8224, 8225, 8186, 10743, 10744, 10745, 10665
3828, 8186, 8225, 626, 625, 10745, 10746, 665, 10667
3829, 547, 548, 8226, 8187, 587, 10747, 10748, 10668
3830, 8187, 8226, 8227, 8188, 10748, 10749, 10750, 10670
3831, 8188, 8227, 8228, 8189, 10750, 10751, 10752, 10672
3832, 8189, 8228, 8229, 8190, 10752, 10753, 10754, 10674
3833, 8190, 8229, 8230, 8191, 10754, 10755, 10756, 10676
3834, 8191, 8230, 8231, 8192, 10756, 10757, 10758, 10678
3835, 8192, 8231, 8232, 8193, 10758, 10759, 10760, 10680
3836, 8193, 8232, 8233, 8194, 10760, 10761, 10762, 10682
3837, 8194, 8233, 8234, 8195, 10762, 10763, 10764, 10684
3838, 8195, 8234, 8235, 8196, 10764, 10765, 10766, 10686
3839, 8196, 8235, 8236, 8197, 10766, 10767, 10768, 10688
3840, 8197, 8236, 8237, 8198, 10768, 10769, 10770, 10690
3841, 8198, 8237, 8238, 8199, 10770, 10771, 10772, 10692
3842, 8199, 8238, 8239, 8200, 10772, 10773, 10774, 10694
3843, 8200, 8239, 8240, 8201, 10774, 10775, 10776, 10696
3844, 8201, 8240, 8241, 8202, 10776, 10777, 10778, 10698
3845, 8202, 8241, 8242, 8203, 10778, 10779, 10780, 10700
3846, 8203, 8242, 8243, 8204, 10780, 10781, 10782, 10702
3847, 8204, 8243, 8244, 8205, 10782, 10783, 10784, 10704
3848, 8205, 8244, 8245, 8206, 10784, 10785, 10786, 10706
3849, 8206, 8245, 8246, 8207, 10786, 10787, 10788, 10708
3850, 8207, 8246, 8247, 8208, 10788, 10789, 10790, 10710
3851, 8208, 8247, 8248, 8209, 10790, 10791, 10792, 10712
3852, 8209, 8248, 8249, 8210, 10792, 10793, 10794, 10714
3853, 8210, 8249, 8250, 8211, 10794, 10795, 10796, 10716
3854, 8211, 8250, 8251, 8212, 10796, 10797, 10798, 10718
3855, 8212, 8251, 8252, 8213, 10798, 10799, 10800, 10720
3856, 8213, 8252, 8253, 8214, 10800, 10801, 10802, 10722
3857, 8214, 8253, 8254, 8215, 10802, 10803, 10804, 10724
3858, 8215, 8254, 8255, 8216, 10804, 10805, 10806, 10726
3859, 8216, 8255, 8256, 8217, 10806, 10807, 10808, 10728
3860, 8217, 8256, 8257, 8218, 10808, 10809, 10810, 10730
3861, 8218, 8257, 8258, 8219, 10810, 10811, 10812, 10732
3862, 8219, 8258, 8259, 8220, 10812, 10813, 10814, 10734
3863, 8220, 8259, 8260, 8221, 10814, 10815, 10816, 10736
3864, 8221, 8260, 8261, 8222, 10816, 10817, 10818, 10738
3865, 8222, 8261, 8262, 8223, 10818, 10819, 10820, 10740
3866, 8223, 8262, 8263, 8224, 10820, 10821, 10822, 10742
3867, 8224, 8263, 8264, 8225, 10822, 10823, 10824, 10744
3868, 8225, 8264, 627, 626, 10824, 10825, 666, 10746
3869, 548, 549, 8265, 8226, 588, 10826, 10827, 10747
3870, 8226, 8265, 8266, 8227, 10827, 10828, 10829, 10749
3871, 8227, 8266, 8267, 8228, 10829, 10830, 10831, 10751
3872, 8228, 8267, 8268, 8229, 10831, 10832, 10833, 10753
3873, 8229, 8268, 8269, 8230, 10833, 10834, 10835, 10755
3874, 8230, 8269, 8270, 8231, 10835, 10836, 10837, 10757
3875, 8231, 8270, 8271, 8232, 10837, 10838, 10839, 10759
3876, 8232, 8271, 8272, 8233, 10839, 10840, 10841, 10761
3877, 8233, 8272, 8273, 8234, 10841, 10842, 10843, 10763
3878, 8234, 8273, 8274, 8235, 10843, 10844, 10845, 10765
3879, 8235, 8274, 8275, 8236, 10845, 10846, 10847, 10767
3880, 8236, 8275, 8276, 8237, 10847, 10848, 10849, 10769
3881, 8237, 8276, 8277, 8238, 10849, 10850, 10851, 10771
3882, 8238, 8277, 8278, 8239, 10851, 10852, 10853, 10773
3883, 8239, 8278, 8279, 8240, 10853, 10854, 10855, 10775
3884, 8240, 8279, 8280, 8241, 10855, 10856, 10857, 10777
3885, 8241, 8280, 8281, 8242, 10857, 10858, 10859, 10779
3886, 8242, 8281, 8282, 8243, 10859, 10860, 10861, 10781
3887, 8243, 8282, 8283, 8244, 10861, 10862, 10863, 10783
3888, 8244, 8283, 8284, 8245, 10863, 10864, 10865, 10785
3889, 8245, 8284, 8285, 8246, 10865, 10866, 10867, 10787
3890, 8246, 8285, 8286, 8247, 10867, 10868, 10869, 10789
3891, 8247, 8286, 8287, 8248, 10869, 10870, 10871, 10791
3892, 8248, 8287, 8288, 8249, 10871, 10872, 10873, 10793
3893, 8249, 8288, 8289, 8250, 10873, 10874, 10875, 10795
3894, 8250, 8289, 8290, 8251, 10875, 10876, 10877, 10797
3895, 8251, 8290, 8291, 8252, 10877, 10878, 10879, 10799
3896, 8252, 8291, 8292, 8253, 10879, 10880, 10881, 10801
3897, 8253, 8292, 8293, 8254, 10881, 10882, 10883, 10803
3898, 8254, 8293, 8294, 8255, 10883, 10884, 10885, 10805
3899, 8255, 8294, 8295, 8256, 10885, 10886, 10887, 10807
3900, 8256, 8295, 8296, 8257, 10887, 10888, 10889, 10809
3901, 8257, 8296, 8297, 8258, 10889, 10890, 10891, 10811
3902, 8258, 8297, 8298, 8259, 10891, 10892, 10893, 10813
3903, 8259, 8298, 8299, 8260, 10893, 10894, 10895, 10815
3904, 8260, 8299, 8300, 8261, 10895, 10896, 10897, 10817
3905, 8261, 8300, 8301, 8262, 10897, 10898, 10899, 10819
3906, 8262, 8301, 8302, 8263, 10899, 10900, 10901, 10821
3907, 8263, 8302, 8303, 8264, 10901, 10902, 10903, 10823
3908, 8264, 8303, 628, 627, 10903, 10904, 667, 10825
3909, 549, 550, 8304, 8265, 589, 10905, 10906, 10826
3910, 8265, 8304, 8305, 8266, 10906, 10907, 10908, 10828
3911, 8266, 8305, 8306, 8267, 10908, 10909, 10910, 10830
3912, 8267, 8306, 8307, 8268, 10910, 10911, 10912, 10832
3913, 8268, 8307, 8308, 8269, 10912, 10913, 10914, 10834
3914, 8269, 8308, 8309, 8270, 10914, 10915, 10916, 10836
3915, 8270, 8309, 8310, 8271, 10916, 10917, 10918, 10838
3916, 8271, 8310, 8311, 8272, 10918, 10919, 10920, 10840
3917, 8272, 8311, 8312, 8273, 10920, 10921, 10922, 10842
3918, 8273, 8312, 8313, 8274, 10922, 10923, 10924, 10844
3919, 8274, 8313, 8314, 8275, 10924, 10925, 10926, 10846
3920, 8275, 8314, 8315, 8276, 10926, 10927, 10928, 10848
3921, 8276, 8315, 8316, 8277, 10928, 10929, 10930, 10850
3922, 8277, 8316, 8317, 8278, 10930, 10931, 10932, 10852
3923, 8278, 8317, 8318, 8279, 10932, 10933, 10934, 10854
3924, 8279, 8318, 8319, 8280, 10934, 10935, 10936, 10856
3925, 8280, 8319, 8320, 8281, 10936, 10937, 10938, 10858
3926, 8281, 8320, 8321, 8282, 10938, 10939, 10940, 10860
3927, 8282, 8321, 8322, 8283, 10940, 10941, 10942, 10862
3928, 8283, 8322, 8323, 8284, 10942, 10943, 10944, 10864
3929, 8284, 8323, 8324, 8285, 10944, 10945, 10946, 10866
3930, 8285, 8324, 8325, 8286, 10946, 10947, 10948, 10868
3931, 8286, 8325, 8326, 8287, 10948, 10949, 10950, 10870
3932, 8287, 8326, 8327, 8288, 10950, 10951, 10952, 10872
3933, 8288, 8327, 8328, 8289, 10952, 10953, 10954, 10874
3934, 8289, 8328, 8329, 8290, 10954, 10955, 10956, 10876
3935, 8290, 8329, 8330, 8291, 10956, 10957, 10958, 10878
3936, 8291, 8330, 8331, 8292, 10958, 10959, 10960, 10880
3937, 8292, 8331, 8332, 8293, 10960, 10961, 10962, 10882
3938, 8293, 8332, 8333, 8294, 10962, 10963, 10964, 10884
3939, 8294, 8333, 8334, 8295, 10964, 10965, 10966, 10886
3940, 8295, 8334, 8335, 8296, 10966, 10967, 10968, 10888
3941, 8296, 8335, 8336, 8297, 10968, 10969, 10970, 10890
3942, 8297, 8336, 8337, 8298, 10970, 10971, 10972, 10892
3943, 8298, 8337, 8338, 8299, 10972, 10973, 10974, 10894
3944, 8299, 8338, 8339, 8300, 10974, 10975, 10976, 10896
3945, 8300, 8339, 8340, 8301, 10976, 10977, 10978, 10898
3946, 8301, 8340, 8341, 8302, 10978, 10979, 10980, 10900
3947, 8302, 8341, 8342, 8303, 10980, 10981, 10982, 10902
3948, 8303, 8342, 629, 628, 10982, 10983, 668, 10904
3949, 550, 551, 8343, 8304, 590, 10984, 10985, 10905
3950, 8304, 8343, 8344, 8305, 10985, 10986, 10987, 10907
3951, 8305, 8344, 8345, 8306, 10987, 10988, 10989, 10909
3952, 8306, 8345, 8346, 8307, 10989, 10990, 10991, 10911
3953, 8307, 8346, 8347, 8308, 10991, 10992, 10993, 10913
3954, 8308, 8347, 8348, 8309, 10993, 10994, 10995, 10915
3955, 8309, 8348, 8349, 8310, 10995, 10996, 10997, 10917
3956, 8310, 8349, 8350, 8311, 10997, 10998, 10999, 10919
3957, 8311, 8350, 8351, 8312, 10999, 11000, 11001, 10921
3958, 8312, 8351, 8352, 8313, 11001, 11002, 11003, 10923
3959, 8313, 8352, 8353, 8314, 11003, 11004, 11005, 10925
3960, 8314, 8353, 8354, 8315, 11005, 11006, 11007, 10927
3961, 8315, 8354, 8355, 8316, 11007, 11008, 11009, 10929
3962, 8316, 8355, 8356, 8317, 11009, 11010, 11011, 10931
3963, 8317, 8356, 8357, 8318, 11011, 11012, 11013, 10933
3964, 8318, 8357, 8358, 8319, 11013, 11014, 11015, 10935
3965, 8319, 8358, 8359, 8320, 11015, 11016, 11017, 10937
3966, 8320, 8359, 8360, 8321, 11017, 11018, 11019, 10939
3967, 8321, 8360, 8361, 8322, 11019, 11020, 11021, 10941
3968, 8322, 8361, 8362, 8323, 11021, 11022, 11023, 10943
3969, 8323, 8362, 8363, 8324, 11023, 11024, 11025, 10945
3970, 8324, 8363, 8364, 8325, 11025, 11026, 11027, 10947
3971, 8325, 8364, 8365, 8326, 11027, 11028, 11029, 10949
3972, 8326, 8365, 8366, 8327, 11029, 11030, 11031, 10951
3973, 8327, 8366, 8367, 8328, 11031, 11032, 11033, 10953
3974, 8328, 8367, 8368, 8329, 11033, 11034, 11035, 10955
3975, 8329, 8368, 8369, 8330, 11035, 11036, 11037, 10957
3976, 8330, 8369, 8370, 8331, 11037, 11038, 11039, 10959
3977, 8331, 8370, 8371, 8332, 11039, 11040, 11041, 10961
3978, 8332, 8371, 8372, 8333, 11041, 11042, 11043, 10963
3979, 8333, 8372, 8373, 8334, 11043, 11044, 11045, 10965
3980, 8334, 8373, 8374, 8335, 11045, 11046, 11047, 10967
3981, 8335, 8374, 8375, 8336, 11047, 11048, 11049, 10969
3982, 8336, 8375, 8376, 8337, 11049, 11050, 11051, 10971
3983, 8337, 8376, 8377, 8338, 11051, 11052, 11053, 10973
3984, 8338, 8377, 8378, 8339, 11053, 11054, 11055, 10975
3985, 8339, 8378, 8379, 8340, 11055, 11056, 11057, 10977
3986, 8340, 8379, 8380, 8341, 11057, 11058, 11059, 10979
3987, 8341, 8380, 8381, 8342, 11059, 11060, 11061, 10981
3988, 8342, 8381, 630, 629, 11061, 11062, 669, 10983
3989, 551, 552, 8382, 8343, 591, 11063, 11064, 10984
3990, 8343, 8382, 8383, 8344, 11064, 11065, 11066, 10986
3991, 8344, 8383, 8384, 8345, 11066, 11067, 11068, 10988
3992, 8345, 8384, 8385, 8346, 11068, 11069, 11070, 10990
3993, 8346, 8385, 8386, 8347, 11070, 11071, 11072, 10992
3994, 8347, 8386, 8387, 8348, 11072, 11073, 11074, 10994
3995, 8348, 8387, 8388, 8349, 11074, 11075, 11076, 10996
3996, 8349, 8388, 8389, 8350, 11076, 11077, 11078, 10998
3997, 8350, 8389, 8390, 8351, 11078, 11079, 11080, 11000
3998, 8351, 8390, 8391, 8352, 11080, 11081, 11082, 11002
3999, 8352, 8391, 8392, 8353, 11082, 11083, 11084, 11004
4000, 8353, 8392, 8393, 8354, 11084, 11085, 11086, 11006
4001, 8354, 8393, 8394, 8355, 11086, 11087, 11088, 11008
4002, 8355, 8394, 8395, 8356, 11088, 11089, 11090, 11010
4003, 8356, 8395, 8396, 8357, 11090, 11091, 11092, 11012
4004, 8357, 8396, 8397, 8358, 11092, 11093, 11094, 11014
4005, 8358, 8397, 8398, 8359, 11094, 11095, 11096, 11016
4006, 8359, 8398, 8399, 8360, 11096, 11097, 11098, 11018
4007, 8360, 8399, 8400, 8361, 11098, 11099, 11100, 11020
4008, 8361, 8400, 8401, 8362, 11100, 11101, 11102, 11022
4009, 8362, 8401, 8402, 8363, 11102, 11103, 11104, 11024
4010, 8363, 8402, 8403, 8364, 11104, 11105, 11106, 11026
4011, 8364, 8403, 8404, 8365, 11106, 11107, 11108, 11028
4012, 8365, 8404, 8405, 8366, 11108, 11109, 11110, 11030
4013, 8366, 8405, 8406, 8367, 11110, 11111, 11112, 11032
4014, 8367, 8406, 8407, 8368, 11112, 11113, 11114, 11034
4015, 8368, 8407, 8408, 8369, 11114, 11115, 11116, 11036
4016, 8369, 8408, 8409, 8370, 11116, 11117, 11118, 11038
4017, 8370, 8409, 8410, 8371, 11118, 11119, 11120, 11040
4018, 8371, 8410, 8411, 8372, 11120, 11121, 11122, 11042
4019, 8372, 8411, 8412, 8373, 11122, 11123, 11124, 11044
4020, 8373, 8412, 8413, 8374, 11124, 11125, 11126, 11046
4021, 8374, 8413, 8414, 8375, 11126, 11127, 11128, 11048
4022, 8375, 8414, 8415, 8376, 11128, 11129, 11130, 11050
4023, 8376, 8415, 8416, 8377, 11130, 11131, 11132, 11052
4024, 8377, 8416, 8417, 8378, 11132, 11133, 11134, 11054
4025, 8378, 8417, 8418, 8379, 11134, 11135, 11136, 11056
4026, 8379, 8418, 8419, 8380, 11136, 11137, 11138, 11058
4027, 8380, 8419, 8420, 8381, 11138, 11139, 11140, 11060
4028, 8381, 8420, 631, 630, 11140, 11141, 670, 11062
4029, 552, 553, 8421, 8382, 592, 11142, 11143, 11063
4030, 8382, 8421, 8422, 8383, 11143, 11144, 11145, 11065
4031, 8383, 8422, 8423, 8384, 11145, 11146, 11147, 11067
4032, 8384, 8423, 8424, 8385, 11147, 11148, 11149, 11069
4033, 8385, 8424, 8425, 8386, 11149, 11150, 11151, 11071
4034, 8386, 8425, 8426, 8387, 11151, 11152, 11153, 11073
4035, 8387, 8426, 8427, 8388, 11153, 11154, 11155, 11075
4036, 8388, 8427, 8428, 8389, 11155, 11156, 11157, 11077
4037, 8389, 8428, 8429, 8390, 11157, 11158, 11159, 11079
4038, 8390, 8429, 8430, 8391, 11159, 11160, 11161, 11081
4039, 8391, 8430, 8431, 8392, 11161, 11162, 11163, 11083
4040, 8392, 8431, 8432, 8393, 11163, 11164, 11165, 11085
4041, 8393, 8432, 8433, 8394, 11165, 11166, 11167, 11087
4042, 8394, 8433, 8434, 8395, 11167, 11168, 11169, 11089
4043, 8395, 8434, 8435, 8396, 11169, 11170, 11171, 11091
4044, 8396, 8435, 8436, 8397, 11171, 11172, 11173, 11093
4045, 8397, 8436, 8437, 8398, 11173, 11174, 11175, 11095
4046, 8398, 8437, 8438, 8399, 11175, 11176, 11177, 11097
4047, 8399, 8438, 8439, 8400, 11177, 11178, 11179, 11099
4048, 8400, 8439, 8440, 8401, 11179, 11180, 11181, 11101
4049, 8401, 8440, 8441, 8402, 11181, 11182, 11183, 11103
4050, 8402, 8441, 8442, 8403, 11183, 11184, 11185, 11105
4051, 8403, 8442, 8443, 8404, 11185, 11186, 11187, 11107
4052, 8404, 8443, 8444, 8405, 11187, 11188, 11189, 11109
4053, 8405, 8444, 8445, 8406, 11189, 11190, 11191, 11111
4054, 8406, 8445, 8446, 8407, 11191, 11192, 11193, 11113
4055, 8407, 8446, 8447, 8408, 11193, 11194, 11195, 11115
4056, 8408, 8447, 8448, 8409, 11195, 11196, 11197, 11117
4057, 8409, 8448, 8449, 8410, 11197, 11198, 11199, 11119
4058, 8410, 8449, 8450, 8411, 11199, 11200, 11201, 11121
4059, 8411, 8450, 8451, 8412, 11201, 11202, 11203, 11123
4060, 8412, 8451, 8452, 8413, 11203, 11204, 11205, 11125
4061, 8413, 8452, 8453, 8414, 11205, 11206, 11207, 11127
4062, 8414, 8453, 8454, 8415, 11207, 11208, 11209, 11129
4063, 8415, 8454, 8455, 8416, 11209, 11210, 11211, 11131
4064, 8416, 8455, 8456, 8417, 11211, 11212, 11213, 11133
4065, 8417, 8456, 8457, 8418, 11213, 11214, 11215, 11135
4066, 8418, 8457, 8458, 8419, 11215, 11216, 11217, 11137
4067, 8419, 8458, 8459, 8420, 11217, 11218, 11219, 11139
4068, 8420, 8459, 632, 631, 11219, 11220, 671, 11141
4069, 553, 554, 8460, 8421, 593, 11221, 11222, 11142
4070, 8421, 8460, 8461, 8422, 11222, 11223, 11224, 11144
4071, 8422, 8461, 8462, 8423, 11224, 11225, 11226, 11146
4072, 8423, 8462, 8463, 8424, 11226, 11227, 11228, 11148
4073, 8424, 8463, 8464, 8425, 11228, 11229, 11230, 11150
4074, 8425, 8464, 8465, 8426, 11230, 11231, 11232, 11152
4075, 8426, 8465, 8466, 8427, 11232, 11233, 11234, 11154
4076, 8427, 8466, 8467, 8428, 11234, 11235, 11236, 11156
4077, 8428, 8467, 8468, 8429, 11236, 11237, 11238, 11158
4078, 8429, 8468, 8469, 8430, 11238, 11239, 11240, 11160
4079, 8430, 8469, 8470, 8431, 11240, 11241, 11242, 11162
4080, 8431, 8470, 8471, 8432, 11242, 11243, 11244, 11164
4081, 8432, 8471, 8472, 8433, 11244, 11245, 11246, 11166
4082, 8433, 8472, 8473, 8434, 11246, 11247, 11248, 11168
4083, 8434, 8473, 8474, 8435, 11248, 11249, 11250, 11170
4084, 8435, 8474, 8475, 8436, 11250, 11251, 11252, 11172
4085, 8436, 8475, 8476, 8437, 11252, 11253, 11254, 11174
4086, 8437, 8476, 8477, 8438, 11254, 11255, 11256, 11176
4087, 8438, 8477, 8478, 8439, 11256, 11257, 11258, 11178
4088, 8439, 8478, 8479, 8440, 11258, 11259, 11260, 11180
4089, 8440, 8479, 8480, 8441, 11260, 11261, 11262, 11182
4090, 8441, 8480, 8481, 8442, 11262, 11263, 11264, 11184
4091, 8442, 8481, 8482, 8443, 11264, 11265, 11266, 11186
4092, 8443, 8482, 8483, 8444, 11266, 11267, 11268, 11188
4093, 8444, 8483, 8484, 8445, 11268, 11269, 11270, 11190
4094, 8445, 8484, 8485, 8446, 11270, 11271, 11272, 11192
4095, 8446, 8485, 8486, 8447, 11272, 11273, 11274, 11194
4096, 8447, 8486, 8487, 8448, 11274, 11275, 11276, 11196
4097, 8448, 8487, 8488, 8449, 11276, 11277, 11278, 11198
4098, 8449, 8488, 8489, 8450, 11278, 11279, 11280, 11200
4099, 8450, 8489, 8490, 8451, 11280, 11281, 11282, 11202
4100, 8451, 8490, 8491, 8452, 11282, 11283, 11284, 11204
4101, 8452, 8491, 8492, 8453, 11284, 11285, 11286, 11206
4102, 8453, 8492, 8493, 8454, 11286, 11287, 11288, 11208
4103, 8454, 8493, 8494, 8455, 11288, 11289, 11290, 11210
4104, 8455, 8494, 8495, 8456, 11290, 11291, 11292, 11212
4105, 8456, 8495, 8496, 8457, 11292, 11293, 11294, 11214
4106, 8457, 8496, 8497, 8458, 11294, 11295, 11296, 11216
4107, 8458, 8497, 8498, 8459, 11296, 11297, 11298, 11218
4108, 8459, 8498, 633, 632, 11298, 11299, 672, 11220
4109, 554, 555, 8499, 8460, 594, 11300, 11301, 11221
4110, 8460, 8499, 8500, 8461, 11301, 11302, 11303, 11223
4111, 8461, 8500, 8501, 8462, 11303, 11304, 11305, 11225
4112, 8462, 8501, 8502, 8463, 11305, 11306, 11307, 11227
4113, 8463, 8502, 8503, 8464, 11307, 11308, 11309, 11229
4114, 8464, 8503, 8504, 8465, 11309, 11310, 11311, 11231
4115, 8465, 8504, 8505, 8466, 11311, 11312, 11313, 11233
4116, 8466, 8505, 8506, 8467, 11313, 11314, 11315, 11235
4117, 8467, 8506, 8507, 8468, 11315, 11316, 11317, 11237
4118, 8468, 8507, 8508, 8469, 11317, 11318, 11319, 11239
4119, 8469, 8508, 8509, 8470, 11319, 11320, 11321, 11241
4120, 8470, 8509, 8510, 8471, 11321, 11322, 11323, 11243
4121, 8471, 8510, 8511, 8472, 11323, 11324, 11325, 11245
4122, 8472, 8511, 8512, 8473, 11325, 11326, 11327, 11247
4123, 8473, 8512, 8513, 8474, 11327, 11328, 11329, 11249
4124, 8474, 8513, 8514, 8475, 11329, 11330, 11331, 11251
4125, 8475, 8514, 8515, 8476, 11331, 11332, 11333, 11253
4126, 8476, 8515, 8516, 8477, 11333, 11334, 11335, 11255
4127, 8477, 8516, 8517, 8478, 11335, 11336, 11337, 11257
4128, 8478, 8517, 8518, 8479, 11337, 11338, 11339, 11259
4129, 8479, 8518, 8519, 8480, 11339, 11340, 11341, 11261
4130, 8480, 8519, 8520, 8481, 11341, 11342, 11343, 11263
4131, 8481, 8520, 8521, 8482, 11343, 11344, 11345, 11265
4132, 8482, 8521, 8522, 8483, 11345, 11346, 11347, 11267
4133, 8483, 8522, 8523, 8484, 11347, 11348, 11349, 11269
4134, 8484, 8523, 8524, 8485, 11349, 11350, 11351, 11271
4135, 8485, 8524, 8525, 8486, 11351, 11352, 11353, 11273
4136, 8486, 8525, 8526, 8487, 11353, 11354, 11355, 11275
4137, 8487, 8526, 8527, 8488, 11355, 11356, 11357, 11277
4138, 8488, 8527, 8528, 8489, 11357, 11358, 11359, 11279
4139, 8489, 8528, 8529, 8490, 11359, 11360, 11361, 11281
4140, 8490, 8529, 8530, 8491, 11361, 11362, 11363, 11283
4141, 8491, 8530, 8531, 8492, 11363, 11364, 11365, 11285
4142, 8492, 8531, 8532, 8493, 11365, 11366, 11367, 11287
4143, 8493, 8532, 8533, 8494, 11367, 11368, 11369, 11289
4144, 8494, 8533, 8534, 8495, 11369, 11370, 11371, 11291
4145, 8495, 8534, 8535, 8496, 11371, 11372, 11373, 11293
4146, 8496, 8535, 8536, 8497, 11373, 11374, 11375, 11295
4147, 8497, 8536, 8537, 8498, 11375, 11376, 11377, 11297
4148, 8498, 8537, 634, 633, 11377, 11378, 673, 11299
4149, 555, 556, 8538, 8499, 595, 11379, 11380, 11300
4150, 8499, 8538, 8539, 8500, 11380, 11381, 11382, 11302
4151, 8500, 8539, 8540, 8501, 11382, 11383, 11384, 11304
4152, 8501, 8540, 8541, 8502, 11384, 11385, 11386, 11306
4153, 8502, 8541, 8542, 8503, 11386, 11387, 11388, 11308
4154, 8503, 8542, 8543, 8504, 11388, 11389, 11390, 11310
4155, 8504, 8543, 8544, 8505, 11390, 11391, 11392, 11312
4156, 8505, 8544, 8545, 8506, 11392, 11393, 11394, 11314
4157, 8506, 8545, 8546, 8507, 11394, 11395, 11396, 11316
4158, 8507, 8546, 8547, 8508, 11396, 11397, 11398, 11318
4159, 8508, 8547, 8548, 8509, 11398, 11399, 11400, 11320
4160, 8509, 8548, 8549, 8510, 11400, 11401, 11402, 11322
4161, 8510, 8549, 8550, 8511, 11402, 11403, 11404, 11324
4162, 8511, 8550, 8551, 8512, 11404, 11405, 11406, 11326
4163, 8512, 8551, 8552, 8513, 11406, 11407, 11408, 11328
4164, 8513, 8552, 8553, 8514, 11408, 11409, 11410, 11330
4165, 8514, 8553, 8554, 8515, 11410, 11411, 11412, 11332
4166, 8515, 8554, 8555, 8516, 11412, 11413, 11414, 11334
4167, 8516, 8555, 8556, 8517, 11414, 11415, 11416, 11336
4168, 8517, 8556, 8557, 8518, 11416, 11417, 11418, 11338
4169, 8518, 8557, 8558, 8519, 11418, 11419, 11420, 11340
4170, 8519, 8558, 8559, 8520, 11420, 11421, 11422, 11342
4171, 8520, 8559, 8560, 8521, 11422, 11423, 11424, 11344
4172, 8521, 8560, 8561, 8522, 11424, 11425, 11426, 11346
4173, 8522, 8561, 8562, 8523, 11426, 11427, 11428, 11348
4174, 8523, 8562, 8563, 8524, 11428, 11429, 11430, 11350
4175, 8524, 8563, 8564, 8525, 11430, 11431, 11432, 11352
4176, 8525, 8564, 8565, 8526, 11432, 11433, 11434, 11354
4177, 8526, 8565, 8566, 8527, 11434, 11435, 11436, 11356
4178, 8527, 8566, 8567, 8528, 11436, 11437, 11438, 11358
4179, 8528, 8567, 8568, 8529, 11438, 11439, 11440, 11360
4180, 8529, 8568, 8569, 8530, 11440, 11441, 11442, 11362
4181, 8530, 8569, 8570, 8531, 11442, 11443, 11444, 11364
4182, 8531, 8570, 8571, 8532, 11444, 11445, 11446, 11366
4183, 8532, 8571, 8572, 8533, 11446, 11447, 11448, 11368
4184, 8533, 8572, 8573, 8534, 11448, 11449, 11450, 11370
4185, 8534, 8573, 8574, 8535, 11450, 11451, 11452, 11372
4186, 8535, 8574, 8575, 8536, 11452, 11453, 11454, 11374
4187, 8536, 8575, 8576, 8537, 11454, 11455, 11456, 11376
4188, 8537, 8576, 635, 634, 11456, 11457, 674, 11378
4189, 556, 557, 8577, 8538, 596, 11458, 11459, 11379
4190, 8538, 8577, 8578, 8539, 11459, 11460, 11461, 11381
4191, 8539, 8578, 8579, 8540, 11461, 11462, 11463, 11383
4192, 8540, 8579, 8580, 8541, 11463, 11464, 11465, 11385
4193, 8541, 8580, 8581, 8542, 11465, 11466, 11467, 11387
4194, 8542, 8581, 8582, 8543, 11467, 11468, 11469, 11389
4195, 8543, 8582, 8583, 8544, 11469, 11470, 11471, 11391
4196, 8544, 8583, 8584, 8545, 11471, 11472, 11473, 11393
4197, 8545, 8584, 8585, 8546, 11473, 11474, 11475, 11395
4198, 8546, 8585, 8586, 8547, 11475, 11476, 11477, 11397
4199, 8547, 8586, 8587, 8548, 11477, 11478, 11479, 11399
4200, 8548, 8587, 8588, 8549, 11479, 11480, 11481, 11401
4201, 8549, 8588, 8589, 8550, 11481, 11482, 11483, 11403
4202, 8550, 8589, 8590, 8551, 11483, 11484, 11485, 11405
4203, 8551, 8590, 8591, 8552, 11485, 11486, 11487, 11407
4204, 8552, 8591, 8592, 8553, 11487, 11488, 11489, 11409
4205, 8553, 8592, 8593, 8554, 11489, 11490, 11491, 11411
4206, 8554, 8593, 8594, 8555, 11491, 11492, 11493, 11413
4207, 8555, 8594, 8595, 8556, 11493, 11494, 11495, 11415
4208, 8556, 8595, 8596, 8557, 11495, 11496, 11497, 11417
4209, 8557, 8596, 8597, 8558, 11497, 11498, 11499, 11419
4210, 8558, 8597, 8598, 8559, 11499, 11500, 11501, 11421
4211, 8559, 8598, 8599, 8560, 11501, 11502, 11503, 11423
4212, 8560, 8599, 8600, 8561, 11503, 11504, 11505, 11425
4213, 8561, 8600, 8601, 8562, 11505, 11506, 11507, 11427
4214, 8562, 8601, 8602, 8563, 11507, 11508, 11509, 11429
4215, 8563, 8602, 8603, 8564, 11509, 11510, 11511, 11431
4216, 8564, 8603, 8604, 8565, 11511, 11512, 11513, 11433
4217, 8565, 8604, 8605, 8566, 11513, 11514, 11515, 11435
4218, 8566, 8605, 8606, 8567, 11515, 11516, 11517, 11437
4219, 8567, 8606, 8607, 8568, 11517, 11518, 11519, 11439
4220, 8568, 8607, 8608, 8569, 11519, 11520, 11521, 11441
4221, 8569, 8608, 8609, 8570, 11521, 11522, 11523, 11443
4222, 8570, 8609, 8610, 8571, 11523, 11524, 11525, 11445
4223, 8571, 8610, 8611, 8572, 11525, 11526, 11527, 11447
4224, 8572, 8611, 8612, 8573, 11527, 11528, 11529, 11449
4225, 8573, 8612, 8613, 8574, 11529, 11530, 11531, 11451
4226, 8574, 8613, 8614, 8575, 11531, 11532, 11533, 11453
4227, 8575, 8614, 8615, 8576, 11533, 11534, 11535, 11455
4228, 8576, 8615, 636, 635, 11535, 11536, 675, 11457
4229, 557, 558, 8616, 8577, 597, 11537, 11538, 11458
4230, 8577, 8616, 8617, 8578, 11538, 11539, 11540, 11460
4231, 8578, 8617, 8618, 8579, 11540, 11541, 11542, 11462
4232, 8579, 8618, 8619, 8580, 11542, 11543, 11544, 11464
4233, 8580, 8619, 8620, 8581, 11544, 11545, 11546, 11466
4234, 8581, 8620, 8621, 8582, 11546, 11547, 11548, 11468
4235, 8582, 8621, 8622, 8583, 11548, 11549, 11550, 11470
4236, 8583, 8622, 8623, 8584, 11550, 11551, 11552, 11472
4237, 8584, 8623, 8624, 8585, 11552, 11553, 11554, 11474
4238, 8585, 8624, 8625, 8586, 11554, 11555, 11556, 11476
4239, 8586, 8625, 8626, 8587, 11556, 11557, 11558, 11478
4240, 8587, 8626, 8627, 8588, 11558, 11559, 11560, 11480
4241, 8588, 8627, 8628, 8589, 11560, 11561, 11562, 11482
4242, 8589, 8628, 8629, 8590, 11562, 11563, 11564, 11484
4243, 8590, 8629, 8630, 8591, 11564, 11565, 11566, 11486
4244, 8591, 8630, 8631, 8592, 11566, 11567, 11568, 11488
4245, 8592, 8631, 8632, 8593, 11568, 11569, 11570, 11490
4246, 8593, 8632, 8633, 8594, 11570, 11571, 11572, 11492
4247, 8594, 8633, 8634, 8595, 11572, 11573, 11574, 11494
4248, 8595, 8634, 8635, 8596, 11574, 11575, 11576, 11496
4249, 8596, 8635, 8636, 8597, 11576, 11577, 11578, 11498
4250, 8597, 8636, 8637, 8598, 11578, 11579, 11580, 11500
4251, 8598, 8637, 8638, 8599, 11580, 11581, 11582, 11502
4252, 8599, 8638, 8639, 8600, 11582, 11583, 11584, 11504
4253, 8600, 8639, 8640, 8601, 11584, 11585, 11586, 11506
4254, 8601, 8640, 8641, 8602, 11586, 11587, 11588, 11508
4255, 8602, 8641, 8642, 8603, 11588, 11589, 11590, 11510
4256, 8603, 8642, 8643, 8604, 11590, 11591, 11592, 11512
4257, 8604, 8643, 8644, 8605, 11592, 11593, 11594, 11514
4258, 8605, 8644, 8645, 8606, 11594, 11595, 11596, 11516
4259, 8606, 8645, 8646, 8607, 11596, 11597, 11598, 11518
4260, 8607, 8646, 8647, 8608, 11598, 11599, 11600, 11520
4261, 8608, 8647, 8648, 8609, 11600, 11601, 11602, 11522
4262, 8609, 8648, 8649, 8610, 11602, 11603, 11604, 11524
4263, 8610, 8649, 8650, 8611, 11604, 11605, 11606, 11526
4264, 8611, 8650, 8651, 8612, 11606, 11607, 11608, 11528
4265, 8612, 8651, 8652, 8613, 11608, 11609, 11610, 11530
4266, 8613, 8652, 8653, 8614, 11610, 11611, 11612, 11532
4267, 8614, 8653, 8654, 8615, 11612, 11613, 11614, 11534
4268, 8615, 8654, 637, 636, 11614, 11615, 676, 11536
4269, 558, 559, 8655, 8616, 598, 11616, 11617, 11537
4270, 8616, 8655, 8656, 8617, 11617, 11618, 11619, 11539
4271, 8617, 8656, 8657, 8618, 11619, 11620, 11621, 11541
4272, 8618, 8657, 8658, 8619, 11621, 11622, 11623, 11543
4273, 8619, 8658, 8659, 8620, 11623, 11624, 11625, 11545
4274, 8620, 8659, 8660, 8621, 11625, 11626, 11627, 11547
4275, 8621, 8660, 8661, 8622, 11627, 11628, 11629, 11549
4276, 8622, 8661, 8662, 8623, 11629, 11630, 11631, 11551
4277, 8623, 8662, 8663, 8624, 11631, 11632, 11633, 11553
4278, 8624, 8663, 8664, 8625, 11633, 11634, 11635, 11555
4279, 8625, 8664, 8665, 8626, 11635, 11636, 11637, 11557
4280, 8626, 8665, 8666, 8627, 11637, 11638, 11639, 11559
4281, 8627, 8666, 8667, 8628, 11639, 11640, 11641, 11561
4282, 8628, 8667, 8668, 8629, 11641, 11642, 11643, 11563
4283, 8629, 8668, 8669, 8630, 11643, 11644, 11645, 11565
4284, 8630, 8669, 8670, 8631, 11645, 11646, 11647, 11567
4285, 8631, 8670, 8671, 8632, 11647, 11648, 11649, 11569
4286, 8632, 8671, 8672, 8633, 11649, 11650, 11651, 11571
4287, 8633, 8672, 8673, 8634, 11651, 11652, 11653, 11573
4288, 8634, 8673, 8674, 8635, 11653, 11654, 11655, 11575
4289, 8635, 8674, 8675, 8636, 11655, 11656, 11657, 11577
4290, 8636, 8675, 8676, 8637, 11657, 11658, 11659, 11579
4291, 8637, 8676, 8677, 8638, 11659, 11660, 11661, 11581
4292, 8638, 8677, 8678, 8639, 11661, 11662, 11663, 11583
4293, 8639, 8678, 8679, 8640, 11663, 11664, 11665, 11585
4294, 8640, 8679, 8680, 8641, 11665, 11666, 11667, 11587
4295, 8641, 8680, 8681, 8642, 11667, 11668, 11669, 11589
4296, 8642, 8681, 8682, 8643, 11669, 11670, 11671, 11591
4297, 8643, 8682, 8683, 8644, 11671, 11672, 11673, 11593
4298, 8644, 8683, 8684, 8645, 11673, 11674, 11675, 11595
4299, 8645, 8684, 8685, 8646, 11675, 11676, 11677, 11597
4300, 8646, 8685, 8686, 8647, 11677, 11678, 11679, 11599
4301, 8647, 8686, 8687, 8648, 11679, 11680, 11681, 11601
4302, 8648, 8687, 8688, 8649, 11681, 11682, 11683, 11603
4303, 8649, 8688, 8689, 8650, 11683, 11684, 11685, 11605
4304, 8650, 8689, 8690, 8651, 11685, 11686, 11687, 11607
4305, 8651, 8690, 8691, 8652, 11687, 11688, 11689, 11609
4306, 8652, 8691, 8692, 8653, 11689, 11690, 11691, 11611
4307, 8653, 8692, 8693, 8654, 11691, 11692, 11693, 11613
4308, 8654, 8693, 638, 637, 11693, 11694, 677, 11615
4309, 559, 560, 8694, 8655, 599, 11695, 11696, 11616
4310, 8655, 8694, 8695, 8656, 11696, 11697, 11698, 11618
4311, 8656, 8695, 8696, 8657, 11698, 11699, 11700, 11620
4312, 8657, 8696, 8697, 8658, 11700, 11701, 11702, 11622
4313, 8658, 8697, 8698, 8659, 11702, 11703, 11704, 11624
4314, 8659, 8698, 8699, 8660, 11704, 11705, 11706, 11626
4315, 8660, 8699, 8700, 8661, 11706, 11707, 11708, 11628
4316, 8661, 8700, 8701, 8662, 11708, 11709, 11710, 11630
4317, 8662, 8701, 8702, 8663, 11710, 11711, 11712, 11632
4318, 8663, 8702, 8703, 8664, 11712, 11713, 11714, 11634
4319, 8664, 8703, 8704, 8665, 11714, 11715, 11716, 11636
4320, 8665, 8704, 8705, 8666, 11716, 11717, 11718, 11638
4321, 8666, 8705, 8706, 8667, 11718, 11719, 11720, 11640
4322, 8667, 8706, 8707, 8668, 11720, 11721, 11722, 11642
4323, 8668, 8707, 8708, 8669, 11722, 11723, 11724, 11644
4324, 8669, 8708, 8709, 8670, 11724, 11725, 11726, 11646
4325, 8670, 8709, 8710, 8671, 11726, 11727, 11728, 11648
4326, 8671, 8710, 8711, 8672, 11728, 11729, 11730, 11650
4327, 8672, 8711, 8712, 8673, 11730, 11731, 11732, 11652
4328, 8673, 8712, 8713, 8674, 11732, 11733, 11734, 11654
4329, 8674, 8713, 8714, 8675, 11734, 11735, 11736, 11656
4330, 8675, 8714, 8715, 8676, 11736, 11737, 11738, 11658
4331, 8676, 8715, 8716, 8677, 11738, 11739, 11740, 11660
4332, 8677, 8716, 8717, 8678, 11740, 11741, 11742, 11662
4333, 8678, 8717, 8718, 8679, 11742, 11743, 11744, 11664
4334, 8679, 8718, 8719, 8680, 11744, 11745, 11746, 11666
4335, 8680, 8719, 8720, 8681, 11746, 11747, 11748, 11668
4336, 8681, 8720, 8721, 8682, 11748, 11749, 11750, 11670
4337, 8682, 8721, 8722, 8683, 11750, 11751, 11752, 11672
4338, 8683, 8722, 8723, 8684, 11752, 11753, 11754, 11674
4339, 8684, 8723, 8724, 8685, 11754, 11755, 11756, 11676
4340, 8685, 8724, 8725, 8686, 11756, 11757, 11758, 11678
4341, 8686, 8725, 8726, 8687, 11758, 11759, 11760, 11680
4342, 8687, 8726, 8727, 8688, 11760, 11761, 11762, 11682
4343, 8688, 8727, 8728, 8689, 11762, 11763, 11764, 11684
4344, 8689, 8728, 8729, 8690, 11764, 11765, 11766, 11686
4345, 8690, 8729, 8730, 8691, 11766, 11767, 11768, 11688
4346, 8691, 8730, 8731, 8692, 11768, 11769, 11770, 11690
4347, 8692, 8731, 8732, 8693, 11770, 11771, 11772, 11692
4348, 8693, 8732, 639, 638, 11772, 11773, 678, 11694
4349, 560, 561, 8733, 8694, 600, 11774, 11775, 11695
4350, 8694, 8733, 8734, 8695, 11775, 11776, 11777, 11697
4351, 8695, 8734, 8735, 8696, 11777, 11778, 11779, 11699
4352, 8696, 8735, 8736, 8697, 11779, 11780, 11781, 11701
4353, 8697, 8736, 8737, 8698, 11781, 11782, 11783, 11703
4354, 8698, 8737, 8738, 8699, 11783, 11784, 11785, 11705
4355, 8699, 8738, 8739, 8700, 11785, 11786, 11787, 11707
4356, 8700, 8739, 8740, 8701, 11787, 11788, 11789, 11709
4357, 8701, 8740, 8741, 8702, 11789, 11790, 11791, 11711
4358, 8702, 8741, 8742, 8703, 11791, 11792, 11793, 11713
4359, 8703, 8742, 8743, 8704, 11793, 11794, 11795, 11715
4360, 8704, 8743, 8744, 8705, 11795, 11796, 11797, 11717
4361, 8705, 8744, 8745, 8706, 11797, 11798, 11799, 11719
4362, 8706, 8745, 8746, 8707, 11799, 11800, 11801, 11721
4363, 8707, 8746, 8747, 8708, 11801, 11802, 11803, 11723
4364, 8708, 8747, 8748, 8709, 11803, 11804, 11805, 11725
4365, 8709, 8748, 8749, 8710, 11805, 11806, 11807, 11727
4366, 8710, 8749, 8750, 8711, 11807, 11808, 11809, 11729
4367, 8711, 8750, 8751, 8712, 11809, 11810, 11811, 11731
4368, 8712, 8751, 8752, 8713, 11811, 11812, 11813, 11733
4369, 8713, 8752, 8753, 8714, 11813, 11814, 11815, 11735
4370, 8714, 8753, 8754, 8715, 11815, 11816, 11817, 11737
4371, 8715, 8754, 8755, 8716, 11817, 11818, 11819, 11739
4372, 8716, 8755, 8756, 8717, 11819, 11820, 11821, 11741
4373, 8717, 8756, 8757, 8718, 11821, 11822, 11823, 11743
4374, 8718, 8757, 8758, 8719, 11823, 11824, 11825, 11745
4375, 8719, 8758, 8759, 8720, 11825, 11826, 11827, 11747
4376, 8720, 8759, 8760, 8721, 11827, 11828, 11829, 11749
4377, 8721, 8760, 8761, 8722, 11829, 11830, 11831, 11751
4378, 8722, 8761, 8762, 8723, 11831, 11832, 11833, 11753
4379, 8723, 8762, 8763, 8724, 11833, 11834, 11835, 11755
4380, 8724, 8763, 8764, 8725, 11835, 11836, 11837, 11757
4381, 8725, 8764, 8765, 8726, 11837, 11838, 11839, 11759
4382, 8726, 8765, 8766, 8727, 11839, 11840, 11841, 11761
4383, 8727, 8766, 8767, 8728, 11841, 11842, 11843, 11763
4384, 8728, 8767, 8768, 8729, 11843, 11844, 11845, 11765
4385, 8729, 8768, 8769, 8730, 11845, 11846, 11847, 11767
4386, 8730, 8769, 8770, 8731, 11847, 11848, 11849, 11769
4387, 8731, 8770, 8771, 8732, 11849, 11850, 11851, 11771
4388, 8732, 8771, 640, 639, 11851, 11852, 679, 11773
4389, 561, 9, 681, 8733, 601, 720, 11853, 11774
4390, 8733, 681, 682, 8734, 11853, 721, 11854, 11776
4391, 8734, 682, 683, 8735, 11854, 722, 11855, 11778
4392, 8735, 683, 684, 8736, 11855, 723, 11856, 11780
4393, 8736, 684, 685, 8737, 11856, 724, 11857, 11782
4394, 8737, 685, 686, 8738, 11857, 725, 11858, 11784
4395, 8738, 686, 687, 8739, 11858, 726, 11859, 11786
4396, 8739, 687, 688, 8740, 11859, 727, 11860, 11788
4397, 8740, 688, 689, 8741, 11860, 728, 11861, 11790
4398, 8741, 689, 690, 8742, 11861, 729, 11862, 11792
4399, 8742, 690, 691, 8743, 11862, 730, 11863, 11794
4400, 8743, 691, 692, 8744, 11863, 731, 11864, 11796
4401, 8744, 692, 693, 8745, 11864, 732, 11865, 11798
4402, 8745, 693, 694, 8746, 11865, 733, 11866, 11800
4403, 8746, 694, 695, 8747, 11866, 734, 11867, 11802
4404, 8747, 695, 696, 8748, 11867, 735, 11868, 11804
4405, 8748, 696, 697, 8749, 11868, 736, 11869, 11806
4406, 8749, 697, 698, 8750, 11869, 737, 11870, 11808
4407, 8750, 698, 699, 8751, 11870, 738, 11871, 11810
4408, 8751, 699, 700, 8752, 11871, 739, 11872, 11812
4409, 8752, 700, 701, 8753, 11872, 740, 11873, 11814
4410, 8753, 701, 702, 8754, 11873, 741, 11874, 11816
4411, 8754, 702, 703, 8755, 11874, 742, 11875, 11818
4412, 8755, 703, 704, 8756, 11875, 743, 11876, 11820
4413, 8756, 704, 705, 8757, 11876, 744, 11877, 11822
4414, 8757, 705, 706, 8758, 11877, 745, 11878, 11824
4415, 8758, 706, 707, 8759, 11878, 746, 11879, 11826
4416, 8759, 707, 708, 8760, 11879, 747, 11880, 11828
4417, 8760, 708, 709, 8761, 11880, 748, 11881, 11830
4418, 8761, 709, 710, 8762, 11881, 749, 11882, 11832
4419, 8762, 710, 711, 8763, 11882, 750, 11883, 11834
4420, 8763, 711, 712, 8764, 11883, 751, 11884, 11836
4421, 8764, 712, 713, 8765, 11884, 752, 11885, 11838
4422, 8765, 713, 714, 8766, 11885, 753, 11886, 11840
4423, 8766, 714, 715, 8767, 11886, 754, 11887, 11842
4424, 8767, 715, 716, 8768, 11887, 755, 11888, 11844
4425, 8768, 716, 717, 8769, 11888, 756, 11889, 11846
4426, 8769, 717, 718, 8770, 11889, 757, 11890, 11848
4427, 8770, 718, 719, 8771, 11890, 758, 11891, 11850
4428, 8771, 719, 10, 640, 11891, 759, 680, 11852
*ELEMENT, type=CPS8, ELSET=Surface6
4429, 9, 972, 11892, 681, 976, 12048, 12049, 720
4430, 681, 11892, 11893, 682, 12049, 12050, 12051, 721
4431, 682, 11893, 11894, 683, 12051, 12052, 12053, 722
4432, 683, 11894, 11895, 684, 12053, 12054, 12055, 723
4433, 684, 11895, 11896, 685, 12055, 12056, 12057, 724
4434, 685, 11896, 11897, 686, 12057, 12058, 12059, 725
4435, 686, 11897, 11898, 687, 12059, 12060, 12061, 726
4436, 687, 11898, 11899, 688, 12061, 12062, 12063, 727
4437, 688, 11899, 11900, 689, 12063, 12064, 12065, 728
4438, 689, 11900, 11901, 690, 12065, 12066, 12067, 729
4439, 690, 11901, 11902, 691, 12067, 12068, 12069, 730
4440, 691, 11902, 11903, 692, 12069, 12070, 12071, 731
4441, 692, 11903, 11904, 693, 12071, 12072, 12073, 732
4442, 693, 11904, 11905, 694, 12073, 12074, 12075, 733
4443, 694, 11905, 11906, 695, 12075, 12076, 12077, 734
4444, 695, 11906, 11907, 696, 12077, 12078, 12079, 735
4445, 696, 11907, 11908, 697, 12079, 12080, 12081, 736
4446, 697, 11908, 11909, 698, 12081, 12082, 12083, 737
4447, 698, 11909, 11910, 699, 12083, 12084, 12085, 738
4448, 699, 11910, 11911, 700, 12085, 12086, 12087, 739
4449, 700, 11911, 11912, 701, 12087, 12088, 12089, 740
4450, 701, 11912, 11913, 702, 12089, 12090, 12091, 741
4451, 702, 11913, 11914, 703, 12091, 12092, 12093, 742
4452, 703, 11914, 11915, 704, 12093, 12094, 12095, 743
4453, 704, 11915, 11916, 705, 12095, 12096, 12097, 744
4454, 705, 11916, 11917, 706, 12097, 12098, 12099, 745
4455, 706, 11917, 11918, 707, 12099, 12100, 12101, 746
4456, 707, 11918, 11919, 708, 12101, 12102, 12103, 747
4457, 708, 11919, 11920, 709, 12103, 12104, 12105, 748
4458, 709, 11920, 11921, 710, 12105, 12106, 12107, 749
4459, 710, 11921, 11922, 711, 12107, 12108, 12109, 750
4460, 711, 11922, 11923, 712, 12109, 12110, 12111, 751
4461, 712, 11923, 11924, 713, 12111, 12112, 12113, 752
4462, 713, 11924, 11925, 714, 12113, 12114, 12115, 753
4463, 714, 11925, 11926, 715, 12115, 12116, 12117, 754
4464, 715, 11926, 11927, 716, 12117, 12118, 12119, 755
4465, 716, 11927, 11928, 717, 12119, 12120, 12121, 756
4466, 717, 11928, 11929, 718, 12121, 12122, 12123, 757
4467, 718, 11929, 11930, 719, 12123, 12124, 12125, 758
4468, 719, 11930, 981, 10, 12125, 12126, 985, 759
4469, 972, 973, 11931, 11892, 977, 12127, 12128, 12048
4470, 11892, 11931, 11932, 11893, 12128, 12129, 12130, 12050
4471, 11893, 11932, 11933, 11894, 12130, 12131, 12132, 12052
4472, 11894, 11933, 11934, 11895, 12132, 12133, 12134, 12054
4473, 11895, 11934, 11935, 11896, 12134, 12135, 12136, 12056
4474, 11896, 11935, 11936, 11897, 12136, 12137, 12138, 12058
4475, 11897, 11936, 11937, 11898, 12138, 12139, 12140, 12060
4476, 11898, 11937, 11938, 11899, 12140, 12141, 12142, 12062
4477, 11899, 11938, 11939, 11900, 12142, 12143, 12144, 12064
4478, 11900, 11939, 11940, 11901, 12144, 12145, 12146, 12066
4479, 11901, 11940, 11941, 11902, 12146, 12147, 12148, 12068
4480, 11902, 11941, 11942, 11903, 12148, 12149, 12150, 12070
4481, 11903, 11942, 11943, 11904, 12150, 12151, 12152, 12072
4482, 11904, 11943, 11944, 11905, 12152, 12153, 12154, 12074
4483, 11905, 11944, 11945, 11906, 12154, 12155, 12156, 12076
4484, 11906, 11945, 11946, 11907, 12156, 12157, 12158, 12078
4485, 11907, 11946, 11947, 11908, 12158, 12159, 12160, 12080
4486, 11908, 11947, 11948, 11909, 12160, 12161, 12162, 12082
4487, 11909, 11948, 11949, 11910, 12162, 12163, 12164, 12084
4488, 11910, 11949, 11950, 11911, 12164, 12165, 12166, 12086
4489, 11911, 11950, 11951, 11912, 12166, 12167, 12168, 12088
4490, 11912, 11951, 11952, 11913, 12168, 12169, 12170, 12090
4491, 11913, 11952, 11953, 11914, 12170, 12171, 12172, 12092
4492, 11914, 11953, 11954, 11915, 12172, 12173, 12174, 12094
4493, 11915, 11954, 11955, 11916, 12174, 12175, 12176, 12096
4494, 11916, 11955, 11956, 11917, 12176, 12177, 12178, 12098
4495, 11917, 11956, 11957, 11918, 12178, 12179, 12180, 12100
4496, 11918, 11957, 11958, 11919, 12180, 12181, 12182, 12102
4497, 11919, 11958, 11959, 11920, 12182, 12183, 12184, 12104
4498, 11920, 11959, 11960, 11921, 12184, 12185, 12186, 12106
4499, 11921, 11960, 11961, 11922, 12186, 12187, 12188, 12108
4500, 11922, 11961, 11962, 11923, 12188, 12189, 12190, 12110
4501, 11923, 11962, 11963, 11924, 12190, 12191, 12192, 12112
4502, 11924, 11963, 11964, 11925, 12192, 12193, 12194, 12114
4503, 11925, 11964, 11965, 11926, 12194, 12195, 12196, 12116
4504, 11926, 11965, 11966, 11927, 12196, 12197, 12198, 12118
4505, 11927, 11966, 11967, 11928, 12198, 12199, 12200, 12120
4506, 11928, 11967, 11968, 11929, 12200, 12201, 12202, 12122
4507, 11929, 11968, 11969, 11930, 12202, 12203, 12204, 12124
4508, 11930, 11969, 982, 981, 12204, 12205, 986, 12126
4509, 973, 974, 11970, 11931, 978, 12206, 12207, 12127
4510, 11931, 11970, 11971, 11932, 12207, 12208, 12209, 12129
4511, 11932, 11971, 11972, 11933, 12209, 12210, 12211, 12131
4512, 11933, 11972, 11973, 11934, 12211, 12212, 12213, 12133
4513, 11934, 11973, 11974, 11935, 12213, 12214, 12215, 12135
4514, 11935, 11974, 11975, 11936, 12215, 12216, 12217, 12137
4515, 11936, 11975, 11976, 11937, 12217, 12218, 12219, 12139
4516, 11937, 11976, 11977, 11938, 12219, 12220, 12221, 12141
4517, 11938, 11977, 11978, 11939, 12221, 12222, 12223, 12143
4518, 11939, 11978, 11979, 11940, 12223, 12224, 12225, 12145
4519, 11940, 11979, 11980, 11941, 12225, 12226, 12227, 12147
4520, 11941, 11980, 11981, 11942, 12227, 12228, 12229, 12149
4521, 11942, 11981, 11982, 11943, 12229, 12230, 12231, 12151
4522, 11943, 11982, 11983, 11944, 12231, 12232, 12233, 12153
4523, 11944, 11983, 11984, 11945, 12233, 12234, 12235, 12155
4524, 11945, 11984, 11985, 11946, 12235, 12236, 12237, 12157
4525, 11946, 11985, 11986, 11947, 12237, 12238, 12239, 12159
4526, 11947, 11986, 11987, 11948, 12239, 12240, 12241, 12161
4527, 11948, 11987, 11988, 11949, 12241, 12242, 12243, 12163
4528, 11949, 11988, 11989, 11950, 12243, 12244, 12245, 12165
4529, 11950, 11989, 11990, 11951, 12245, 12246, 12247, 12167
4530, 11951, 11990, 11991, 11952, 12247, 12248, 12249, 12169
4531, 11952, 11991, 11992, 11953, 12249, 12250, 12251, 12171
4532, 11953, 11992, 11993, 11954, 12251, 12252, 12253, 12173
4533, 11954, 11993, 11994, 11955, 12253, 12254, 12255, 12175
4534, 11955, 11994, 11995, 11956, 12255, 12256, 12257, 12177
4535, 11956, 11995, 11996, 11957, 12257, 12258, 12259, 12179
4536, 11957, 11996, 11997, 11958, 12259, 12260, 12261, 12181
4537, 11958, 11997, 11998, 11959, 12261, 12262, 12263, 12183
4538, 11959, 11998, 11999, 11960, 12263, 12264, 12265, 12185
4539, 11960, 11999, 12000, 11961, 12265, 12266, 12267, 12187
4540, 11961, 12000, 12001, 11962, 12267, 12268, 12269, 12189
4541, 11962, 12001, 12002, 11963, 12269, 12270, 12271, 12191
4542, 11963, 12002, 12003, 11964, 12271, 12272, 12273, 12193
4543, 11964, 12003, 12004, 11965, 12273, 12274, 12275, 12195
4544, 11965, 12004, 12005, 11966, 12275, 12276, 12277, 12197
4545, 11966, 12005, 12006, 11967, 12277, 12278, 12279, 12199
4546, 11967, 12006, 12007, 11968, 12279, 12280, 12281, 12201
4547, 11968, 12007, 12008, 11969, 12281, 12282, 12283, 12203
4548, 11969, 12008, 983, 982, 12283, 12284, 987, 12205
4549, 974, 975, 12009, 11970, 979, 12285, 12286, 12206
4550, 11970, 12009, 12010, 11971, 12286, 12287, 12288, 12208
4551, 11971, 12010, 12011, 11972, 12288, 12289, 12290, 12210
4552, 11972, 12011, 12012, 11973, 12290, 12291, 12292, 12212
4553, 11973, 12012, 12013, 11974, 12292, 12293, 12294, 12214
4554, 11974, 12013, 12014, 11975, 12294, 12295, 12296, 12216
4555, 11975, 12014, 12015, 11976, 12296, 12297, 12298, 12218
4556, 11976, 12015, 12016, 11977, 12298, 12299, 12300, 12220
4557, 11977, 12016, 12017, 11978, 12300, 12301, 12302, 12222
4558, 11978, 12017, 12018, 11979, 12302, 12303, 12304, 12224
4559, 11979, 12018, 12019, 11980, 12304, 12305, 12306, 12226
4560, 11980, 12019, 12020, 11981, 12306, 12307, 12308, 12228
4561, 11981, 12020, 12021, 11982, 12308, 12309, 12310, 12230
4562, 11982, 12021, 12022, 11983, 12310, 12311, 12312, 12232
4563, 11983, 12022, 12023, 11984, 12312, 12313, 12314, 12234
4564, 11984, 12023, 12024, 11985, 12314, 12315, 12316, 12236
4565, 11985, 12024, 12025, 11986, 12316, 12317, 12318, 12238
4566, 11986, 12025, 12026, 11987, 12318, 12319, 12320, 12240
4567, 11987, 12026, 12027, 11988, 12320, 12321, 12322, 12242
4568, 11988, 12027, 12028, 11989, 12322, 12323, 12324, 12244
4569, 11989, 12028, 12029, 11990, 12324, 12325, 12326, 12246
4570, 11990, 12029, 12030, 11991, 12326, 12327, 12328, 12248
4571, 11991, 12030, 12031, 11992, 12328, 12329, 12330, 12250
4572, 11992, 12031, 12032, 11993, 12330, 12331, 12332, 12252
4573, 11993, 12032, 12033, 11994, 12332, 12333, 12334, 12254
4574, 11994, 12033, 12034, 11995, 12334, 12335, 12336, 12256
4575, 11995, 12034, 12035, 11996, 12336, 12337, 12338, 12258
4576, 11996, 12035, 12036, 11997, 12338, 12339, 12340, 12260
4577, 11997, 12036, 12037, 11998, 12340, 12341, 12342, 12262
4578, 11998, 12037, 12038, 11999, 12342, 12343, 12344, 12264
4579, 11999, 12038, 12039, 12000, 12344, 12345, 12346, 12266
4580, 12000, 12039, 12040, 12001, 12346, 12347, 12348, 12268
4581, 12001, 12040, 12041, 12002, 12348, 12349, 12350, 12270
4582, 12002, 12041, 12042, 12003, 12350, 12351, 12352, 12272
4583, 12003, 12042, 12043, 12004, 12352, 12353, 12354, 12274
4584, 12004, 12043, 12044, 12005, 12354, 12355, 12356, 12276
4585, 12005, 12044, 12045, 12006, 12356, 12357, 12358, 12278
4586, 12006, 12045, 12046, 12007, 12358, 12359, 12360, 12280
4587, 12007, 12046, 12047, 12008, 12360, 12361, 12362, 12282
4588, 12008, 12047, 984, 983, 12362, 12363, 988, 12284
4589, 975, 15, 990, 12009, 980, 1029, 12364, 12285
4590, 12009, 990, 991, 12010, 12364, 1030, 12365, 12287
4591, 12010, 991, 992, 12011, 12365, 1031, 12366, 12289
4592, 12011, 992, 993, 12012, 12366, 1032, 12367, 12291
4593, 12012, 993, 994, 12013, 12367, 1033, 12368, 12293
4594, 12013, 994, 995, 12014, 12368, 1034, 12369, 12295
4595, 12014, 995, 996, 12015, 12369, 1035, 12370, 12297
4596, 12015, 996, 997, 12016, 12370, 1036, 12371, 12299
4597, 12016, 997, 998, 12017, 12371, 1037, 12372, 12301
4598, 12017, 998, 999, 12018, 12372, 1038, 12373, 12303
4599, 12018, 999, 1000, 12019, 12373, 1039, 12374, 12305
4600, 12019, 1000, 1001, 12020, 12374, 1040, 12375, 12307
4601, 12020, 1001, 1002, 12021, 12375, 1041, 12376, 12309
4602, 12021, 1002, 1003, 12022, 12376, 1042, 12377, 12311
4603, 12022, 1003, 1004, 12023, 12377, 1043, 12378, 12313
4604, 12023, 1004, 1005, 12024, 12378, 1044, 12379, 12315
4605, 12024, 1005, 1006, 12025, 12379, 1045, 12380, 12317
4606, 12025, 1006, 1007, 12026, 12380, 1046, 12381, 12319
4607, 12026, 1007, 1008, 12027, 12381, 1047, 12382, 12321
4608, 12027, 1008, 1009, 12028, 12382, 1048, 12383, 12323
4609, 12028, 1009, 1010, 12029, 12383, 1049, 12384, 12325
4610, 12029, 1010, 1011, 12030, 12384, 1050, 12385, 12327
4611, 12030, 1011, 1012, 12031, 12385, 1051, 12386, 12329
4612, 12031, 1012, 1013, 12032, 12386, 1052, 12387, 12331
4613, 12032, 1013, 1014, 12033, 12387, 1053, 12388, 12333
4614, 12033, 1014, 1015, 12034, 12388, 1054, 12389, 12335
4615, 12034, 1015, 1016, 12035, 12389, 1055, 12390, 12337
4616, 12035, 1016, 1017, 12036, 12390, 1056, 12391, 12339
4617, 12036, 1017, 1018, 12037, 12391, 1057, 12392, 12341
4618, 12037, 1018, 1019, 12038, 12392, 1058, 12393, 12343
4619, 12038, 1019, 1020, 12039, 12393, 1059, 12394, 12345
4620, 12039, 1020, 1021, 12040, 12394, 1060, 12395, 12347
4621, 12040, 1021, 1022, 12041, 12395, 1061, 12396, 12349
4622, 12041, 1022, 1023, 12042, 12396, 1062, 12397, 12351
4623, 12042, 1023, 1024, 12043, 12397, 1063, 12398, 12353
4624, 12043, 1024, 1025, 12044, 12398, 1064, 12399, 12355
4625, 12044, 1025, 1026, 12045, 12399, 1065, 12400, 12357
4626, 12045, 1026, 1027, 12046, 12400, 1066, 12401, 12359
4627, 12046, 1027, 1028, 12047, 12401, 1067, 12402, 12361
4628, 12047, 1028, 16, 984, 12402, 1068, 989, 12363
*ELEMENT, type=CPS8, ELSET=Surface7
4629, 1, 1069, 12403, 31, 1073, 12559, 12560, 70
4630, 31, 12403, 12404, 32, 12560, 12561, 12562, 71
4631, 32, 12404, 12405, 33, 12562, 12563, 12564, 72
4632, 33, 12405, 12406, 34, 12564, 12565, 12566, 73
4633, 34, 12406, 12407, 35, 12566, 12567, 12568, 74
4634, 35, 12407, 12408, 36, 12568, 12569, 12570, 75
4635, 36, 12408, 12409, 37, 12570, 12571, 12572, 76
4636, 37, 12409, 12410, 38, 12572, 12573, 12574, 77
4637, 38, 12410, 12411, 39, 12574, 12575, 12576, 78
4638, 39, 12411, 12412, 40, 12576, 12577, 12578, 79
4639, 40, 12412, 12413, 41, 12578, 12579, 12580, 80
4640, 41, 12413, 12414, 42, 12580, 12581, 12582, 81
4641, 42, 12414, 12415, 43, 12582, 12583, 12584, 82
4642, 43, 12415, 12416, 44, 12584, 12585, 12586, 83
4643, 44, 12416, 12417, 45, 12586, 12587, 12588, 84
4644, 45, 12417, 12418, 46, 12588, 12589, 12590, 85
4645, 46, 12418, 12419, 47, 12590, 12591, 12592, 86
4646, 47, 12419, 12420, 48, 12592, 12593, 12594, 87
4647, 48, 12420, 12421, 49, 12594, 12595, 12596, 88
4648, 49, 12421, 12422, 50, 12596, 12597, 12598, 89
4649, 50, 12422, 12423, 51, 12598, 12599, 12600, 90
4650, 51, 12423, 12424, 52, 12600, 12601, 12602, 91
4651, 52, 12424, 12425, 53, 12602, 12603, 12604, 92
4652, 53, 12425, 12426, 54, 12604, 12605, 12606, 93
4653, 54, 12426, 12427, 55, 12606, 12607, 12608, 94
4654, 55, 12427, 12428, 56, 12608, 12609, 12610, 95
4655, 56, 12428, 12429, 57, 12610, 12611, 12612, 96
4656, 57, 12429, 12430, 58, 12612, 12613, 12614, 97
4657, 58, 12430, 12431, 59, 12614, 12615, 12616, 98
4658, 59, 12431, 12432, 60, 12616, 12617, 12618, 99
4659, 60, 12432, 12433, 61, 12618, 12619, 12620, 100
4660, 61, 12433, 12434, 62, 12620, 12621, 12622, 101
4661, 62, 12434, 12435, 63, 12622, 12623, 12624, 102
4662, 63, 12435, 12436, 64, 12624, 12625, 12626, 103
4663, 64, 12436, 12437, 65, 12626, 12627, 12628, 104
4664, 65, 12437, 12438, 66, 12628, 12629, 12630, 105
4665, 66, 12438, 12439, 67, 12630, 12631, 12632, 106
4666, 67, 12439, 12440, 68, 12632, 12633, 12634, 107
4667, 68, 12440, 12441, 69, 12634, 12635, 12636, 108
4668, 69, 12441, 1078, 2, 12636, 12637, 1082, 109
4669, 1069, 1070, 12442, 12403, 1074, 12638, 12639, 12559
4670, 12403, 12442, 12443, 12404, 12639, 12640, 12641, 12561
4671, 12404, 12443, 12444, 12405, 12641, 12642, 12643, 12563
4672, 12405, 12444, 12445, 12406, 12643, 12644, 12645, 12565
4673, 12406, 12445, 12446, 12407, 12645, 12646, 12647, 12567
4674, 12407, 12446, 12447, 12408, 12647, 12648, 12649, 12569
4675, 12408, 12447, 12448, 12409, 12649, 12650, 12651, 12571
4676, 12409, 12448, 12449, 12410, 12651, 12652, 12653, 12573
4677, 12410, 12449, 12450, 12411, 12653, 12654, 12655, 12575
4678, 12411, 12450, 12451, 12412, 12655, 12656, 12657, 12577
4679, 12412, 12451, 12452, 12413, 12657, 12658, 12659, 12579
4680, 12413, 12452, 12453, 12414, 12659, 12660, 12661, 12581
4681, 12414, 12453, 12454, 12415, 12661, 12662, 12663, 12583
4682, 12415, 12454, 12455, 12416, 12663, 12664, 12665, 12585
4683, 12416, 12455, 12456, 12417, 12665, 12666, 12667, 12587
4684, 12417, 12456, 12457, 12418, 12667, 12668, 12669, 12589
4685, 12418, 12457, 12458, 12419, 12669, 12670, 12671, 12591
4686, 12419, 12458, 12459, 12420, 12671, 12672, 12673, 12593
4687, 12420, 12459, 12460, 12421, 12673, 12674, 12675, 12595
4688, 12421, 12460, 12461, 12422, 12675, 12676, 12677, 12597
4689, 12422, 12461, 12462, 12423, 12677, 12678, 12679, 12599
4690, 12423, 12462, 12463, 12424, 12679, 12680, 12681, 12601
4691, 12424, 12463, 12464, 12425, 12681, 12682, 12683, 12603
4692, 12425, 12464, 12465, 12426, 12683, 12684, 12685, 12605
4693, 12426, 12465, 12466, 12427, 12685, 12686, 12687, 12607
4694, 12427, 12466, 12467, 12428, 12687, 12688, 12689, 12609
4695, 12428, 12467, 12468, 12429, 12689, 12690, 12691, 12611
4696, 12429, 12468, 12469, 12430, 12691, 12692, 12693, 12613
4697, 12430, 12469, 12470, 12431, 12693, 12694, 12695, 12615
4698, 12431, 12470, 12471, 12432, 12695, 12696, 12697, 12617
4699, 12432, 12471, 12472, 12433, 12697, 12698, 12699, 12619
4700, 12433, 12472, 12473, 12434, 12699, 12700, 12701, 12621
4701, 12434, 12473, 12474, 12435, 12701, 12702, 12703, 12623
4702, 12435, 12474, 12475, 12436, 12703, 12704, 12705, 12625
4703, 12436, 12475, 12476, 12437, 12705, 12706, 12707, 12627
4704, 12437, 12476, 12477, 12438, 12707, 12708, 12709, 12629
4705, 12438, 12477, 12478, 12439, 12709, 12710, 12711, 12631
4706, 12439, 12478, 12479, 12440, 12711, 12712, 12713, 12633
4707, 12440, 12479, 12480, 12441, 12713, 12714, 12715, 12635
4708, 12441, 12480, 1079, 1078, 12715, 12716, 1083, 12637
4709, 1070, 1071, 12481, 12442, 1075, 12717, 12718, 12638
4710, 12442, 12481, 12482, 12443, 12718, 12719, 12720, 12640
4711, 12443, 12482, 12483, 12444, 12720, 12721, 12722, 12642
4712, 12444, 12483, 12484, 12445, 12722, 12723, 12724, 12644
4713, 12445, 12484, 12485, 12446, 12724, 12725, 12726, 12646
4714, 12446, 12485, 12486, 12447, 12726, 12727, 12728, 12648
4715, 12447, 12486, 12487, 12448, 12728, 12729, 12730, 12650
4716, 12448, 12487, 12488, 12449, 12730, 12731, 12732, 12652
4717, 12449, 12488, 12489, 12450, 12732, 12733, 12734, 12654
4718, 12450, 12489, 12490, 12451, 12734, 12735, 12736, 12656
4719, 12451, 12490, 12491, 12452, 12736, 12737, 12738, 12658
4720, 12452, 12491, 12492, 12453, 12738, 12739, 12740, 12660
4721, 12453, 12492, 12493, 12454, 12740, 12741, 12742, 12662
4722, 12454, 12493, 12494, 12455, 12742, 12743, 12744, 12664
4723, 12455, 12494, 12495, 12456, 12744, 12745, 12746, 12666
4724, 12456, 12495, 12496, 12457, 12746, 12747, 12748, 12668
4725, 12457, 12496, 12497, 12458, 12748, 12749, 12750, 12670
4726, 12458, 12497, 12498, 12459, 12750, 12751, 12752, 12672
4727, 12459, 12498, 12499, 12460, 12752, 12753, 12754, 12674
4728, 12460, 12499, 12500, 12461, 12754, 12755, 12756, 12676
4729, 12461, 12500, 12501, 12462, 12756, 12757, 12758, 12678
4730, 12462, 12501, 12502, 12463, 12758, 12759, 12760, 12680
4731, 12463, 12502, 12503, 12464, 12760, 12761, 12762, 12682
4732, 12464, 12503, 12504, 12465, 12762, 12763, 12764, 12684
4733, 12465, 12504, 12505, 12466, 12764, 12765, 12766, 12686
4734, 12466, 12505, 12506, 12467, 12766, 12767, 12768, 12688
4735, 12467, 12506, 12507, 12468, 12768, 12769, 12770, 12690
4736, 12468, 12507, 12508, 12469, 12770, 12771, 12772, 12692
4737, 12469, 12508, 12509, 12470, 12772, 12773, 12774, 12694
4738, 12470, 12509, 12510, 12471, 12774, 12775, 12776, 12696
4739, 12471, 12510, 12511, 12472, 12776, 12777, 12778, 12698
4740, 12472, 12511, 12512, 12473, 12778, 12779, 12780, 12700
4741, 12473, 12512, 12513, 12474, 12780, 12781, 12782, 12702
4742, 12474, 12513, 12514, 12475, 12782, 12783, 12784, 12704
4743, 12475, 12514, 12515, 12476, 12784, 12785, 12786, 12706
4744, 12476, 12515, 12516, 12477, 12786, 12787, 12788, 12708
4745, 12477, 12516, 12517, 12478, 12788, 12789, 12790, 12710
4746, 12478, 12517, 12518, 12479, 12790, 12791, 12792, 12712
4747, 12479, 12518, 12519, 12480, 12792, 12793, 12794, 12714
4748, 12480, 12519, 1080, 1079, 12794, 12795, 1084, 12716
4749, 1071, 1072, 12520, 12481, 1076, 12796, 12797, 12717
4750, 12481, 12520, 12521, 12482, 12797, 12798, 12799, 12719
4751, 12482, 12521, 12522, 12483, 12799, 12800, 12801, 12721
4752, 12483, 12522, 12523, 12484, 12801, 12802, 12803, 12723
4753, 12484, 12523, 12524, 12485, 12803, 12804, 12805, 12725
4754, 12485, 12524, 12525, 12486, 12805, 12806, 12807, 12727
4755, 12486, 12525, 12526, 12487, 12807, 12808, 12809, 12729
4756, 12487, 12526, 12527, 12488, 12809, 12810, 12811, 12731
4757, 12488, 12527, 12528, 12489, 12811, 12812, 12813, 12733
4758, 12489, 12528, 12529, 12490, 12813, 12814, 12815, 12735
4759, 12490, 12529, 12530, 12491, 12815, 12816, 12817, 12737
4760, 12491, 12530, 12531, 12492, 12817, 12818, 12819, 12739
4761, 12492, 12531, 12532, 12493, 12819, 12820, 12821, 12741
4762, 12493, 12532, 12533, 12494, 12821, 12822, 12823, 12743
4763, 12494, 12533, 12534, 12495, 12823, 12824, 12825, 12745
4764, 12495, 12534, 12535, 12496, 12825, 12826, 12827, 12747
4765, 12496, 12535, 12536, 12497, 12827, 12828, 12829, 12749
4766, 12497, 12536, 12537, 12498, 12829, 12830, 12831, 12751
4767, 12498, 12537, 12538, 12499, 12831, 12832, 12833, 12753
4768, 12499, 12538, 12539, 12500, 12833, 12834, 12835, 12755
4769, 12500, 12539, 12540, 12501, 12835, 12836, 12837, 12757
4770, 12501, 12540, 12541, 12502, 12837, 12838, 12839, 12759
4771, 12502, 12541, 12542, 12503, 12839, 12840, 12841, 12761
4772, 12503, 12542, 12543, 12504, 12841, 12842, 12843, 12763
4773, 12504, 12543, 12544, 12505, 12843, 12844, 12845, 12765
4774, 12505, 12544, 12545, 12506, 12845, 12846, 12847, 12767
4775, 12506, 12545, 12546, 12507, 12847, 12848, 12849, 12769
4776, 12507, 12546, 12547, 12508, 12849, 12850, 12851, 12771
4777, 12508, 12547, 12548, 12509, 12851, 12852, 12853, 12773
4778, 12509, 12548, 12549, 12510, 12853, 12854, 12855, 12775
4779, 12510, 12549, 12550, 12511, 12855, 12856, 12857, 12777
4780, 12511, 12550, 12551, 12512, 12857, 12858, 12859, 12779
4781, 12512, 12551, 12552, 12513, 12859, 12860, 12861, 12781
4782, 12513, 12552, 12553, 12514, 12861, 12862, 12863, 12783
4783, 12514, 12553, 12554, 12515, 12863, 12864, 12865, 12785
4784, 12515, 12554, 12555, 12516, 12865, 12866, 12867, 12787
4785, 12516, 12555, 12556, 12517, 12867, 12868, 12869, 12789
4786, 12517, 12556, 12557, 12518, 12869, 12870, 12871, 12791
4787, 12518, 12557, 12558, 12519, 12871, 12872, 12873, 12793
4788, 12519, 12558, 1081, 1080, 12873, 12874, 1085, 12795
4789, 1072, 17, 1087, 12520, 1077, 1126, 12875, 12796
4790, 12520, 1087, 1088, 12521, 12875, 1127, 12876, 12798
4791, 12521, 1088, 1089, 12522, 12876, 1128, 12877, 12800
4792, 12522, 1089, 1090, 12523, 12877, 1129, 12878, 12802
4793, 12523, 1090, 1091, 12524, 12878, 1130, 12879, 12804
4794, 12524, 1091, 1092, 12525, 12879, 1131, 12880, 12806
4795, 12525, 1092, 1093, 12526, 12880, 1132, 12881, 12808
4796, 12526, 1093, 1094, 12527, 12881, 1133, 12882, 12810
4797, 12527, 1094, 1095, 12528, 12882, 1134, 12883, 12812
4798, 12528, 1095, 1096, 12529, 12883, 1135, 12884, 12814
4799, 12529, 1096, 1097, 12530, 12884, 1136, 12885, 12816
4800, 12530, 1097, 1098, 12531, 12885, 1137, 12886, 12818
4801, 12531, 1098, 1099, 12532, 12886, 1138, 12887, 12820
4802, 12532, 1099, 1100, 12533, 12887, 1139, 12888, 12822
4803, 12533, 1100, 1101, 12534, 12888, 1140, 12889, 12824
4804, 12534, 1101, 1102, 12535, 12889, 1141, 12890, 12826
4805, 12535, 1102, 1103, 12536, 12890, 1142, 12891, 12828
4806, 12536, 1103, 1104, 12537, 12891, 1143, 12892, 12830
4807, 12537, 1104, 1105, 12538, 12892, 1144, 12893, 12832
4808, 12538, 1105, 1106, 12539, 12893, 1145, 12894, 12834
4809, 12539, 1106, 1107, 12540, 12894, 1146, 12895, 12836
4810, 12540, 1107, 1108, 12541, 12895, 1147, 12896, 12838
4811, 12541, 1108, 1109, 12542, 12896, 1148, 12897, 12840
4812, 12542, 1109, 1110, 12543, 12897, 1149, 12898, 12842
4813, 12543, 1110, 1111, 12544, 12898, 1150, 12899, 12844
4814, 12544, 1111, 1112, 12545, 12899, 1151, 12900, 12846
4815, 12545, 1112, 1113, 12546, 12900, 1152, 12901, 12848
4816, 12546, 1113, 1114, 12547, 12901, 1153, 12902, 12850
4817, 12547, 1114, 1115, 12548, 12902, 1154, 12903, 12852
4818, 12548, 1115, 1116, 12549, 12903, 1155, 12904, 12854
4819, 12549, 1116, 1117, 12550, 12904, 1156, 12905, 12856
4820, 12550, 1117, 1118, 12551, 12905, 1157, 12906, 12858
4821, 12551, 1118, 1119, 12552, 12906, 1158, 12907, 12860
4822, 12552, 1119, 1120, 12553, 12907, 1159, 12908, 12862
4823, 12553, 1120, 1121, 12554, 12908, 1160, 12909, 12864
4824, 12554, 1121, 1122, 12555, 12909, 1161, 12910, 12866
4825, 12555, 1122, 1123, 12556, 12910, 1162, 12911, 12868
4826, 12556, 1123, 1124, 12557, 12911, 1163, 12912, 12870
4827, 12557, 1124, 1125, 12558, 12912, 1164, 12913, 12872
4828, 12558, 1125, 18, 1081, 12913, 1165, 1086, 12874
*ELEMENT, type=CPS8, ELSET=Surface9
4829, 1, 1166, 12914, 1069, 1168, 12922, 12923, 1073
4830, 1069, 12914, 12915, 1070, 12923, 12924, 12925, 1074
4831, 1070, 12915, 12916, 1071, 12925, 12926, 12927, 1075
4832, 1071, 12916, 12917, 1072, 12927, 12928, 12929, 1076
4833, 1072, 12917, 1171, 17, 12929, 12930, 1173, 1077
4834, 1166, 1167, 12918, 12914, 1169, 12931, 12932, 12922
4835, 12914, 12918, 12919, 12915, 12932, 12933, 12934, 12924
4836, 12915, 12919, 12920, 12916, 12934, 12935, 12936, 12926
4837, 12916, 12920, 12921, 12917, 12936, 12937, 12938, 12928
4838, 12917, 12921, 1172, 1171, 12938, 12939, 1174, 12930
4839, 1167, 19, 1176, 12918, 1170, 1180, 12940, 12931
4840, 12918, 1176, 1177, 12919, 12940, 1181, 12941, 12933
4841, 12919, 1177, 1178, 12920, 12941, 1182, 12942, 12935
4842, 12920, 1178, 1179, 12921, 12942, 1183, 12943, 12937
4843, 12921, 1179, 20, 1172, 12943, 1184, 1175, 12939
*ELEMENT, type=CPS8, ELSET=Surface10
4844, 17, 1185, 12944, 1087, 1189, 13100, 13101, 1126
4845, 1087, 12944, 12945, 1088, 13101, 13102, 13103, 1127
4846, 1088, 12945, 12946, 1089, 13103, 13104, 13105, 1128
4847, 1089, 12946, 12947, 1090, 13105, 13106, 13107, 1129
4848, 1090, 12947, 12948, 1091, 13107, 13108, 13109, 1130
4849, 1091, 12948, 12949, 1092, 13109, 13110, 13111, 1131
4850, 1092, 12949, 12950, 1093, 13111, 13112, 13113, 1132
4851, 1093, 12950, 12951, 1094, 13113, 13114, 13115, 1133
4852, 1094, 12951, 12952, 1095, 13115, 13116, 13117, 1134
4853, 1095, 12952, 12953, 1096, 13117, 13118, 13119, 1135
4854, 1096, 12953, 12954, 1097, 13119, 13120, 13121, 1136
4855, 1097, 12954, 12955, 1098, 13121, 13122, 13123, 1137
4856, 1098, 12955, 12956, 1099, 13123, 13124, 13125, 1138
4857, 1099, 12956, 12957, 1100, 13125, 13126, 13127, 1139
4858, 1100, 12957, 12958, 1101, 13127, 13128, 13129, 1140
4859, 1101, 12958, 12959, 1102, 13129, 13130, 13131, 1141
4860, 1102, 12959, 12960, 1103, 13131, 13132, 13133, 1142
4861, 1103, 12960, 12961, 1104, 13133, 13134, 13135, 1143
4862, 1104, 12961, 12962, 1105, 13135, 13136, 13137, 1144
4863, 1105, 12962, 12963, 1106, 13137, 13138, 13139, 1145
4864, 1106, 12963, 12964, 1107, 13139, 13140, 13141, 1146
4865, 1107, 12964, 12965, 1108, 13141, 13142, 13143, 1147
4866, 1108, 12965, 12966, 1109, 13143, 13144, 13145, 1148
4867, 1109, 12966, 12967, 1110, 13145, 13146, 13147, 1149
4868, 1110, 12967, 12968, 1111, 13147, 13148, 13149, 1150
4869, 1111, 12968, 12969, 1112, 13149, 13150, 13151, 1151
4870, 1112, 12969, 12970, 1113, 13151, 13152, 13153, 1152
4871, 1113, 12970, 12971, 1114, 13153, 13154, 13155, 1153
4872, 1114, 12971, 12972, 1115, 13155, 13156, 13157, 1154
4873, 1115, 12972, 12973, 1116, 13157, 13158, 13159, 1155
4874, 1116, 12973, 12974, 1117, 13159, 13160, 13161, 1156
4875, 1117, 12974, 12975, 1118, 13161, 13162, 13163, 1157
4876, 1118, 12975, 12976, 1119, 13163, 13164, 13165, 1158
4877, 1119, 12976, 12977, 1120, 13165, 13166, 13167, 1159
4878, 1120, 12977, 12978, 1121, 13167, 13168, 13169, 1160
4879, 1121, 12978, 12979, 1122, 13169, 13170, 13171, 1161
4880, 1122, 12979, 12980, 1123, 13171, 13172, 13173, 1162
4881, 1123, 12980, 12981, 1124, 13173, 13174, 13175, 1163
4882, 1124, 12981, 12982, 1125, 13175, 13176, 13177, 1164
4883, 1125, 12982, 1194, 18, 13177, 13178, 1198, 1165
4884, 1185, 1186, 12983, 12944, 1190, 13179, 13180, 13100
4885, 12944, 12983, 12984, 12945, 13180, 13181, 13182, 13102
4886, 12945, 12984, 12985, 12946, 13182, 13183, 13184, 13104
4887, 12946, 12985, 12986, 12947, 13184, 13185, 13186, 13106
4888, 12947, 12986, 12987, 12948, 13186, 13187, 13188, 13108
4889, 12948, 12987, 12988, 12949, 13188, 13189, 13190, 13110
4890, 12949, 12988, 12989, 12950, 13190, 13191, 13192, 13112
4891, 12950, 12989, 12990, 12951, 13192, 13193, 13194, 13114
4892, 12951, 12990, 12991, 12952, 13194, 13195, 13196, 13116
4893, 12952, 12991, 12992, 12953, 13196, 13197, 13198, 13118
4894, 12953, 12992, 12993, 12954, 13198, 13199, 13200, 13120
4895, 12954, 12993, 12994, 12955, 13200, 13201, 13202, 13122
4896, 12955, 12994, 12995, 12956, 13202, 13203, 13204, 13124
4897, 12956, 12995, 12996, 12957, 13204, 13205, 13206, 13126
4898, 12957, 12996, 12997, 12958, 13206, 13207, 13208, 13128
4899, 12958, 12997, 12998, 12959, 13208, 13209, 13210, 13130
4900, 12959, 12998, 12999, 12960, 13210, 13211, 13212, 13132
4901, 12960, 12999, 13000, 12961, 13212, 13213, 13214, 13134
4902, 12961, 13000, 13001, 12962, 13214, 13215, 13216, 13136
4903, 12962, 13001, 13002, 12963, 13216, 13217, 13218, 13138
4904, 12963, 13002, 13003, 12964, 13218, 13219, 13220, 13140
4905, 12964, 13003, 13004, 12965, 13220, 13221, 13222, 13142
4906, 12965, 13004, 13005, 12966, 13222, 13223, 13224, 13144
4907, 12966, 13005, 13006, 12967, 13224, 13225, 13226, 13146
4908, 12967, 13006, 13007, 12968, 13226, 13227, 13228, 13148
4909, 12968, 13007, 13008, 12969, 13228, 13229, 13230, 13150
4910, 12969, 13008, 13009, 12970, 13230, 13231, 13232, 13152
4911, 12970, 13009, 13010, 12971, 13232, 13233, 13234, 13154
4912, 12971, 13010, 13011, 12972, 13234, 13235, 13236, 13156
4913, 12972, 13011, 13012, 12973, 13236, 13237, 13238, 13158
4914, 12973, 13012, 13013, 12974, 13238, 13239, 13240, 13160
4915, 12974, 13013, 13014, 12975, 13240, 13241, 13242, 13162
4916, 12975, 13014, 13015, 12976, 13242, 13243, 13244, 13164
4917, 12976, 13015, 13016, 12977, 13244, 13245, 13246, 13166
4918, 12977, 13016, 13017, 12978, 13246, 13247, 13248, 13168
4919, 12978, 13017, 13018, 12979, 13248, 13249, 13250, 13170
4920, 12979, 13018, 13019, 12980, 13250, 13251, 13252, 13172
4921, 12980, 13019, 13020, 12981, 13252, 13253, 13254, 13174
4922, 12981, 13020, 13021, 12982, 13254, 13255, 13256, 13176
4923, 12982, 13021, 1195, 1194, 13256, 13257, 1199, 13178
4924, 1186, 1187, 13022, 12983, 1191, 13258, 13259, 13179
4925, 12983, 13022, 13023, 12984, 13259, 13260, 13261, 13181
4926, 12984, 13023, 13024, 12985, 13261, 13262, 13263, 13183
4927, 12985, 13024, 13025, 12986, 13263, 13264, 13265, 13185
4928, 12986, 13025, 13026, 12987, 13265, 13266, 13267, 13187
4929, 12987, 13026, 13027, 12988, 13267, 13268, 13269, 13189
4930, 12988, 13027, 13028, 12989, 13269, 13270, 13271, 13191
4931, 12989, 13028, 13029, 12990, 13271, 13272, 13273, 13193
4932, 12990, 13029, 13030, 12991, 13273, 13274, 13275, 13195
4933, 12991, 13030, 13031, 12992, 13275, 13276, 13277, 13197
4934, 12992, 13031, 13032, 12993, 13277, 13278, 13279, 13199
4935, 12993, 13032, 13033, 12994, 13279, 13280, 13281, 13201
4936, 12994, 13033, 13034, 12995, 13281, 13282, 13283, 13203
4937, 12995, 13034, 13035, 12996, 13283, 13284, 13285, 13205
4938, 12996, 13035, 13036, 12997, 13285, 13286, 13287, 13207
4939, 12997, 13036, 13037, 12998, 13287, 13288, 13289, 13209
4940, 12998, 13037, 13038, 12999, 13289, 13290, 13291, 13211
4941, 12999, 13038, 13039, 13000, 13291, 13292, 13293, 13213
4942, 13000, 13039, 13040, 13001, 13293, 13294, 13295, 13215
4943, 13001, 13040, 13041, 13002, 13295, 13296, 13297, 13217
4944, 13002, 13041, 13042, 13003, 13297, 13298, 13299, 13219
4945, 13003, 13042, 13043, 13004, 13299, 13300, 13301, 13221
4946, 13004, 13043, 13044, 13005, 13301, 13302, 13303, 13223
4947, 13005, 13044, 13045, 13006, 13303, 13304, 13305, 13225
4948, 13006, 13045, 13046, 13007, 13305, 13306, 13307, 13227
4949, 13007, 13046, 13047, 13008, 13307, 13308, 13309, 13229
4950, 13008, 13047, 13048, 13009, 13309, 13310, 13311, 13231
4951, 13009, 13048, 13049, 13010, 13311, 13312, 13313, 13233
4952, 13010, 13049, 13050, 13011, 13313, 13314, 13315, 13235
4953, 13011, 13050, 13051, 13012, 13315, 13316, 13317, 13237
4954, 13012, 13051, 13052, 13013, 13317, 13318, 13319, 13239
4955, 13013, 13052, 13053, 13014, 13319, 13320, 13321, 13241
4956, 13014, 13053, 13054, 13015, 13321, 13322, 13323, 13243
4957, 13015, 13054, 13055, 13016, 13323, 13324, 13325, 13245
4958, 13016, 13055, 13056, 13017, 13325, 13326, 13327, 13247
4959, 13017, 13056, 13057, 13018, 13327, 13328, 13329, 13249
4960, 13018, 13057, 13058, 13019, 13329, 13330, 13331, 13251
4961, 13019, 13058, 13059, 13020, 13331, 13332, 13333, 13253
4962, 13020, 13059, 13060, 13021, 13333, 13334, 13335, 13255
4963, 13021, 13060, 1196, 1195, 13335, 13336, 1200, 13257
4964, 1187, 1188, 13061, 13022, 1192, 13337, 13338, 13258
4965, 13022, 13061, 13062, 13023, 13338, 13339, 13340, 13260
4966, 13023, 13062, 13063, 13024, 13340, 13341, 13342, 13262
4967, 13024, 13063, 13064, 13025, 13342, 13343, 13344, 13264
4968, 13025, 13064, 13065, 13026, 13344, 13345, 13346, 13266
4969, 13026, 13065, 13066, 13027, 13346, 13347, 13348, 13268
4970, 13027, 13066, 13067, 13028, 13348, 13349, 13350, 13270
4971, 13028, 13067, 13068, 13029, 13350, 13351, 13352, 13272
4972, 13029, 13068, 13069, 13030, 13352, 13353, 13354, 13274
4973, 13030, 13069, 13070, 13031, 13354, 13355, 13356, 13276
4974, 13031, 13070, 13071, 13032, 13356, 13357, 13358, 13278
4975, 13032, 13071, 13072, 13033, 13358, 13359, 13360, 13280
4976, 13033, 13072, 13073, 13034, 13360, 13361, 13362, 13282
4977, 13034, 13073, 13074, 13035, 13362, 13363, 13364, 13284
4978, 13035, 13074, 13075, 13036, 13364, 13365, 13366, 13286
4979, 13036, 13075, 13076, 13037, 13366, 13367, 13368, 13288
4980, 13037, 13076, 13077, 13038, 13368, 13369, 13370, 13290
4981, 13038, 13077, 13078, 13039, 13370, 13371, 13372, 13292
4982, 13039, 13078, 13079, 13040, 13372, 13373, 13374, 13294
4983, 13040, 13079, 13080, 13041, 13374, 13375, 13376, 13296
4984, 13041, 13080, 13081, 13042, 13376, 13377, 13378, 13298
4985, 13042, 13081, 13082, 13043, 13378, 13379, 13380, 13300
4986, 13043, 13082, 13083, 13044, 13380, 13381, 13382, 13302
4987, 13044, 13083, 13084, 13045, 13382, 13383, 13384, 13304
4988, 13045, 13084, 13085, 13046, 13384, 13385, 13386, 13306
4989, 13046, 13085, 13086, 13047, 13386, 13387, 13388, 13308
4990, 13047, 13086, 13087, 13048, 13388, 13389, 13390, 13310
4991, 13048, 13087, 13088, 13049, 13390, 13391, 13392, 13312
4992, 13049, 13088, 13089, 13050, 13392, 13393, 13394, 13314
4993, 13050, 13089, 13090, 13051, 13394, 13395, 13396, 13316
4994, 13051, 13090, 13091, 13052, 13396, 13397, 13398, 13318
4995, 13052, 13091, 13092, 13053, 13398, 13399, 13400, 13320
4996, 13053, 13092, 13093, 13054, 13400, 13401, 13402, 13322
4997, 13054, 13093, 13094, 13055, 13402, 13403, 13404, 13324
4998, 13055, 13094, 13095, 13056, 13404, 13405, 13406, 13326
4999, 13056, 13095, 13096, 13057, 13406, 13407, 13408, 13328
5000, 13057, 13096, 13097, 13058, 13408, 13409, 13410, 13330
5001, 13058, 13097, 13098, 13059, 13410, 13411, 13412, 13332
5002, 13059, 13098, 13099, 13060, 13412, 13413, 13414, 13334
5003, 13060, 13099, 1197, 1196, 13414, 13415, 1201, 13336
5004, 1188, 21, 1203, 13061, 1193, 1242, 13416, 13337
5005, 13061, 1203, 1204, 13062, 13416, 1243, 13417, 13339
5006, 13062, 1204, 1205, 13063, 13417, 1244, 13418, 13341
5007, 13063, 1205, 1206, 13064, 13418, 1245, 13419, 13343
5008, 13064, 1206, 1207, 13065, 13419, 1246, 13420, 13345
5009, 13065, 1207, 1208, 13066, 13420, 1247, 13421, 13347
5010, 13066, 1208, 1209, 13067, 13421, 1248, 13422, 13349
5011, 13067, 1209, 1210, 13068, 13422, 1249, 13423, 13351
5012, 13068, 1210, 1211, 13069, 13423, 1250, 13424, 13353
5013, 13069, 1211, 1212, 13070, 13424, 1251, 13425, 13355
5014, 13070, 1212, 1213, 13071, 13425, 1252, 13426, 13357
5015, 13071, 1213, 1214, 13072, 13426, 1253, 13427, 13359
5016, 13072, 1214, 1215, 13073, 13427, 1254, 13428, 13361
5017, 13073, 1215, 1216, 13074, 13428, 1255, 13429, 13363
5018, 13074, 1216, 1217, 13075, 13429, 1256, 13430, 13365
5019, 13075, 1217, 1218, 13076, 13430, 1257, 13431, 13367
5020, 13076, 1218, 1219, 13077, 13431, 1258, 13432, 13369
5021, 13077, 1219, 1220, 13078, 13432, 1259, 13433, 13371
5022, 13078, 1220, 1221, 13079, 13433, 1260, 13434, 13373
5023, 13079, 1221, 1222, 13080, 13434, 1261, 13435, 13375
5024, 13080, 1222, 1223, 13081, 13435, 1262, 13436, 13377
5025, 13081, 1223, 1224, 13082, 13436, 1263, 13437, 13379
5026, 13082, 1224, 1225, 13083, 13437, 1264, 13438, 13381
5027, 13083, 1225, 1226, 13084, 13438, 1265, 13439, 13383
5028, 13084, 1226, 1227, 13085, 13439, 1266, 13440, 13385
5029, 13085, 1227, 1228, 13086, 13440, 1267, 13441, 13387
5030, 13086, 1228, 1229, 13087, 13441, 1268, 13442, 13389
5031, 13087, 1229, 1230, 13088, 13442, 1269, 13443, 13391
5032, 13088, 1230, 1231, 13089, 13443, 1270, 13444, 13393
5033, 13089, 1231, 1232, 13090, 13444, 1271, 13445, 13395
5034, 13090, 1232, 1233, 13091, 13445, 1272, 13446, 13397
5035, 13091, 1233, 1234, 13092, 13446, 1273, 13447, 13399
5036, 13092, 1234, 1235, 13093, 13447, 1274, 13448, 13401
5037, 13093, 1235, 1236, 13094, 13448, 1275, 13449, 13403
5038, 13094, 1236, 1237, 13095, 13449, 1276, 13450, 13405
5039, 13095, 1237, 1238, 13096, 13450, 1277, 13451, 13407
5040, 13096, 1238, 1239, 13097, 13451, 1278, 13452, 13409
5041, 13097, 1239, 1240, 13098, 13452, 1279, 13453, 13411
5042, 13098, 1240, 1241, 13099, 13453, 1280, 13454, 13413
5043, 13099, 1241, 22, 1197, 13454, 1281, 1202, 13415
*ELEMENT, type=CPS8, ELSET=Surface12
5044, 15, 1282, 13455, 990, 1286, 13611, 13612, 1029
5045, 990, 13455, 13456, 991, 13612, 13613, 13614, 1030
5046, 991, 13456, 13457, 992, 13614, 13615, 13616, 1031
5047, 992, 13457, 13458, 993, 13616, 13617, 13618, 1032
5048, 993, 13458, 13459, 994, 13618, 13619, 13620, 1033
5049, 994, 13459, 13460, 995, 13620, 13621, 13622, 1034
5050, 995, 13460, 13461, 996, 13622, 13623, 13624, 1035
5051, 996, 13461, 13462, 997, 13624, 13625, 13626, 1036
5052, 997, 13462, 13463, 998, 13626, 13627, 13628, 1037
5053, 998, 13463, 13464, 999, 13628, 13629, 13630, 1038
5054, 999, 13464, 13465, 1000, 13630, 13631, 13632, 1039
5055, 1000, 13465, 13466, 1001, 13632, 13633, 13634, 1040
5056, 1001, 13466, 13467, 1002, 13634, 13635, 13636, 1041
5057, 1002, 13467, 13468, 1003, 13636, 13637, 13638, 1042
5058, 1003, 13468, 13469, 1004, 13638, 13639, 13640, 1043
5059, 1004, 13469, 13470, 1005, 13640, 13641, 13642, 1044
5060, 1005, 13470, 13471, 1006, 13642, 13643, 13644, 1045
5061, 1006, 13471, 13472, 1007, 13644, 13645, 13646, 1046
5062, 1007, 13472, 13473, 1008, 13646, 13647, 13648, 1047
5063, 1008, 13473, 13474, 1009, 13648, 13649, 13650, 1048
5064, 1009, 13474, 13475, 1010, 13650, 13651, 13652, 1049
5065, 1010, 13475, 13476, 1011, 13652, 13653, 13654, 1050
5066, 1011, 13476, 13477, 1012, 13654, 13655, 13656, 1051
5067, 1012, 13477, 13478, 1013, 13656, 13657, 13658, 1052
5068, 1013, 13478, 13479, 1014, 13658, 13659, 13660, 1053
5069, 1014, 13479, 13480, 1015, 13660, 13661, 13662, 1054
5070, 1015, 13480, 13481, 1016, 13662, 13663, 13664, 1055
5071, 1016, 13481, 13482, 1017, 13664, 13665, 13666, 1056
5072, 1017, 13482, 13483, 1018, 13666, 13667, 13668, 1057
5073, 1018, 13483, 13484, 1019, 13668, 13669, 13670, 1058
5074, 1019, 13484, 13485, 1020, 13670, 13671, 13672, 1059
5075, 1020, 13485, 13486, 1021, 13672, 13673, 13674, 1060
5076, 1021, 13486, 13487, 1022, 13674, 13675, 13676, 1061
5077, 1022, 13487, 13488, 1023, 13676, 13677, 13678, 1062
5078, 1023, 13488, 13489, 1024, 13678, 13679, 13680, 1063
5079, 1024, 13489, 13490, 1025, 13680, 13681, 13682, 1064
5080, 1025, 13490, 13491, 1026, 13682, 13683, 13684, 1065
5081, 1026, 13491, 13492, 1027, 13684, 13685, 13686, 1066
5082, 1027, 13492, 13493, 1028, 13686, 13687, 13688, 1067
5083, 1028, 13493, 1291, 16, 13688, 13689, 1295, 1068
5084, 1282, 1283, 13494, 13455, 1287, 13690, 13691, 13611
5085, 13455, 13494, 13495, 13456, 13691, 13692, 13693, 13613
5086, 13456, 13495, 13496, 13457, 13693, 13694, 13695, 13615
5087, 13457, 13496, 13497, 13458, 13695, 13696, 13697, 13617
5088, 13458, 13497, 13498, 13459, 13697, 13698, 13699, 13619
5089, 13459, 13498, 13499, 13460, 13699, 13700, 13701, 13621
5090, 13460, 13499, 13500, 13461, 13701, 13702, 13703, 13623
5091, 13461, 13500, 13501, 13462, 13703, 13704, 13705, 13625
5092, 13462, 13501, 13502, 13463, 13705, 13706, 13707, 13627
5093, 13463, 13502, 13503, 13464, 13707, 13708, 13709, 13629
5094, 13464, 13503, 13504, 13465, 13709, 13710, 13711, 13631
5095, 13465, 13504, 13505, 13466, 13711, 13712, 13713, 13633
5096, 13466, 13505, 13506, 13467, 13713, 13714, 13715, 13635
5097, 13467, 13506, 13507, 13468, 13715, 13716, 13717, 13637
5098, 13468, 13507, 13508, 13469, 13717, 13718, 13719, 13639
5099, 13469, 13508, 13509, 13470, 13719, 13720, 13721, 13641
5100, 13470, 13509, 13510, 13471, 13721, 13722, 13723, 13643
5101, 13471, 13510, 13511, 13472, 13723, 13724, 13725, 13645
5102, 13472, 13511, 13512, 13473, 13725, 13726, 13727, 13647
5103, 13473, 13512, 13513, 13474, 13727, 13728, 13729, 13649
5104, 13474, 13513, 13514, 13475, 13729, 13730, 13731, 13651
5105, 13475, 13514, 13515, 13476, 13731, 13732, 13733, 13653
5106, 13476, 13515, 13516, 13477, 13733, 13734, 13735, 13655
5107, 13477, 13516, 13517, 13478, 13735, 13736, 13737, 13657
5108, 13478, 13517, 13518, 13479, 13737, 13738, 13739, 13659
5109, 13479, 13518, 13519, 13480, 13739, 13740, 13741, 13661
5110, 13480, 13519, 13520, 13481, 13741, 13742, 13743, 13663
5111, 13481, 13520, 13521, 13482, 13743, 13744, 13745, 13665
5112, 13482, 13521, 13522, 13483, 13745, 13746, 13747, 13667
5113, 13483, 13522, 13523, 13484, 13747, 13748, 13749, 13669
5114, 13484, 13523, 13524, 13485, 13749, 13750, 13751, 13671
5115, 13485, 13524, 13525, 13486, 13751, 13752, 13753, 13673
5116, 13486, 13525, 13526, 13487, 13753, 13754, 13755, 13675
5117, 13487, 13526, 13527, 13488, 13755, 13756, 13757, 13677
5118, 13488, 13527, 13528, 13489, 13757, 13758, 13759, 13679
5119, 13489, 13528, 13529, 13490, 13759, 13760, 13761, 13681
5120, 13490, 13529, 13530, 13491, 13761, 13762, 13763, 13683
5121, 13491, 13530, 13531, 13492, 13763, 13764, 13765, 13685
5122, 13492, 13531, 13532, 13493, 13765, 13766, 13767, 13687
5123, 13493, 13532, 1292, 1291, 13767, 13768, 1296, 13689
5124, 1283, 1284, 13533, 13494, 1288, 13769, 13770, 13690
5125, 13494, 13533, 13534, 13495, 13770, 13771, 13772, 13692
5126, 13495, 13534, 13535, 13496, 13772, 13773, 13774, 13694
5127, 13496, 13535, 13536, 13497, 13774, 13775, 13776, 13696
5128, 13497, 13536, 13537, 13498, 13776, 13777, 13778, 13698
5129, 13498, 13537, 13538, 13499, 13778, 13779, 13780, 13700
5130, 13499, 13538, 13539, 13500, 13780, 13781, 13782, 13702
5131, 13500, 13539, 13540, 13501, 13782, 13783, 13784, 13704
5132, 13501, 13540, 13541, 13502, 13784, 13785, 13786, 13706
5133, 13502, 13541, 13542, 13503, 13786, 13787, 13788, 13708
5134, 13503, 13542, 13543, 13504, 13788, 13789, 13790, 13710
5135, 13504, 13543, 13544, 13505, 13790, 13791, 13792, 13712
5136, 13505, 13544, 13545, 13506, 13792, 13793, 13794, 13714
5137, 13506, 13545, 13546, 13507, 13794, 13795, 13796, 13716
5138, 13507, 13546, 13547, 13508, 13796, 13797, 13798, 13718
5139, 13508, 13547, 13548, 13509, 13798, 13799, 13800, 13720
5140, 13509, 13548, 13549, 13510, 13800, 13801, 13802, 13722
5141, 13510, 13549, 13550, 13511, 13802, 13803, 13804, 13724
5142, 13511, 13550, 13551, 13512, 13804, 13805, 13806, 13726
5143, 13512, 13551, 13552, 13513, 13806, 13807, 13808, 13728
5144, 13513, 13552, 13553, 13514, 13808, 13809, 13810, 13730
5145, 13514, 13553, 13554, 13515, 13810, 13811, 13812, 13732
5146, 13515, 13554, 13555, 13516, 13812, 13813, 13814, 13734
5147, 13516, 13555, 13556, 13517, 13814, 13815, 13816, 13736
5148, 13517, 13556, 13557, 13518, 13816, 13817, 13818, 13738
5149, 13518, 13557, 13558, 13519, 13818, 13819, 13820, 13740
5150, 13519, 13558, 13559, 13520, 13820, 13821, 13822, 13742
5151, 13520, 13559, 13560, 13521, 13822, 13823, 13824, 13744
5152, 13521, 13560, 13561, 13522, 13824, 13825, 13826, 13746
5153, 13522, 13561, 13562, 13523, 13826, 13827, 13828, 13748
5154, 13523, 13562, 13563, 13524, 13828, 13829, 13830, 13750
5155, 13524, 13563, 13564, 13525, 13830, 13831, 13832, 13752
5156, 13525, 13564, 13565, 13526, 13832, 13833, 13834, 13754
5157, 13526, 13565, 13566, 13527, 13834, 13835, 13836, 13756
5158, 13527, 13566, 13567, 13528, 13836, 13837, 13838, 13758
5159, 13528, 13567, 13568, 13529, 13838, 13839, 13840, 13760
5160, 13529, 13568, 13569, 13530, 13840, 13841, 13842, 13762
5161, 13530, 13569, 13570, 13531, 13842, 13843, 13844, 13764
5162, 13531, 13570, 13571, 13532, 13844, 13845, 13846, 13766
5163, 13532, 13571, 1293, 1292, 13846, 13847, 1297, 13768
5164, 1284, 1285, 13572, 13533, 1289, 13848, 13849, 13769
5165, 13533, 13572, 13573, 13534, 13849, 13850, 13851, 13771
5166, 13534, 13573, 13574, 13535, 13851, 13852, 13853, 13773
5167, 13535, 13574, 13575, 13536, 13853, 13854, 13855, 13775
5168, 13536, 13575, 13576, 13537, 13855, 13856, 13857, 13777
5169, 13537, 13576, 13577, 13538, 13857, 13858, 13859, 13779
5170, 13538, 13577, 13578, 13539, 13859, 13860, 13861, 13781
5171, 13539, 13578, 13579, 13540, 13861, 13862, 13863, 13783
5172, 13540, 13579, 13580, 13541, 13863, 13864, 13865, 13785
5173, 13541, 13580, 13581, 13542, 13865, 13866, 13867, 13787
5174, 13542, 13581, 13582, 13543, 13867, 13868, 13869, 13789
5175, 13543, 13582, 13583, 13544, 13869, 13870, 13871, 13791
5176, 13544, 13583, 13584, 13545, 13871, 13872, 13873, 13793
5177, 13545, 13584, 13585, 13546, 13873, 13874, 13875, 13795
5178, 13546, 13585, 13586, 13547, 13875, 13876, 13877, 13797
5179, 13547, 13586, 13587, 13548, 13877, 13878, 13879, 13799
5180, 13548, 13587, 13588, 13549, 13879, 13880, 13881, 13801
5181, 13549, 13588, 13589, 13550, 13881, 13882, 13883, 13803
5182, 13550, 13589, 13590, 13551, 13883, 13884, 13885, 13805
5183, 13551, 13590, 13591, 13552, 13885, 13886, 13887, 13807
5184, 13552, 13591, 13592, 13553, 13887, 13888, 13889, 13809
5185, 13553, 13592, 13593, 13554, 13889, 13890, 13891, 13811
5186, 13554, 13593, 13594, 13555, 13891, 13892, 13893, 13813
5187, 13555, 13594, 13595, 13556, 13893, 13894, 13895, 13815
5188, 13556, 13595, 13596, 13557, 13895, 13896, 13897, 13817
5189, 13557, 13596, 13597, 13558, 13897, 13898, 13899, 13819
5190, 13558, 13597, 13598, 13559, 13899, 13900, 13901, 13821
5191, 13559, 13598, 13599, 13560, 13901, 13902, 13903, 13823
5192, 13560, 13599, 13600, 13561, 13903, 13904, 13905, 13825
5193, 13561, 13600, 13601, 13562, 13905, 13906, 13907, 13827
5194, 13562, 13601, 13602, 13563, 13907, 13908, 13909, 13829
5195, 13563, 13602, 13603, 13564, 13909, 13910, 13911, 13831
5196, 13564, 13603, 13604, 13565, 13911, 13912, 13913, 13833
5197, 13565, 13604, 13605, 13566, 13913, 13914, 13915, 13835
5198, 13566, 13605, 13606, 13567, 13915, 13916, 13917, 13837
5199, 13567, 13606, 13607, 13568, 13917, 13918, 13919, 13839
5200, 13568, 13607, 13608, 13569, 13919, 13920, 13921, 13841
5201, 13569, 13608, 13609, 13570, 13921, 13922, 13923, 13843
5202, 13570, 13609, 13610, 13571, 13923, 13924, 13925, 13845
5203, 13571, 13610, 1294, 1293, 13925, 13926, 1298, 13847
5204, 1285, 23, 1300, 13572, 1290, 1339, 13927, 13848
5205, 13572, 1300, 1301, 13573, 13927, 1340, 13928, 13850
5206, 13573, 1301, 1302, 13574, 13928, 1341, 13929, 13852
5207, 13574, 1302, 1303, 13575, 13929, 1342, 13930, 13854
5208, 13575, 1303, 1304, 13576, 13930, 1343, 13931, 13856
5209, 13576, 1304, 1305, 13577, 13931, 1344, 13932, 13858
5210, 13577, 1305, 1306, 13578, 13932, 1345, 13933, 13860
5211, 13578, 1306, 1307, 13579, 13933, 1346, 13934, 13862
5212, 13579, 1307, 1308, 13580, 13934, 1347, 13935, 13864
5213, 13580, 1308, 1309, 13581, 13935, 1348, 13936, 13866
5214, 13581, 1309, 1310, 13582, 13936, 1349, 13937, 13868
5215, 13582, 1310, 1311, 13583, 13937, 1350, 13938, 13870
5216, 13583, 1311, 1312, 13584, 13938, 1351, 13939, 13872
5217, 13584, 1312, 1313, 13585, 13939, 1352, 13940, 13874
5218, 13585, 1313, 1314, 13586, 13940, 1353, 13941, 13876
5219, 13586, 1314, 1315, 13587, 13941, 1354, 13942, 13878
5220, 13587, 1315, 1316, 13588, 13942, 1355, 13943, 13880
5221, 13588, 1316, 1317, 13589, 13943, 1356, 13944, 13882
5222, 13589, 1317, 1318, 13590, 13944, 1357, 13945, 13884
5223, 13590, 1318, 1319, 13591, 13945, 1358, 13946, 13886
5224, 13591, 1319, 1320, 13592, 13946, 1359, 13947, 13888
5225, 13592, 1320, 1321, 13593, 13947, 1360, 13948, 13890
5226, 13593, 1321, 1322, 13594, 13948, 1361, 13949, 13892
5227, 13594, 1322, 1323, 13595, 13949, 1362, 13950, 13894
5228, 13595, 1323, 1324, 13596, 13950, 1363, 13951, 13896
5229, 13596, 1324, 1325, 13597, 13951, 1364, 13952, 13898
5230, 13597, 1325, 1326, 13598, 13952, 1365, 13953, 13900
5231, 13598, 1326, 1327, 13599, 13953, 1366, 13954, 13902
5232, 13599, 1327, 1328, 13600, 13954, 1367, 13955, 13904
5233, 13600, 1328, 1329, 13601, 13955, 1368, 13956, 13906
5234, 13601, 1329, 1330, 13602, 13956, 1369, 13957, 13908
5235, 13602, 1330, 1331, 13603, 13957, 1370, 13958, 13910
5236, 13603, 1331, 1332, 13604, 13958, 1371, 13959, 13912
5237, 13604, 1332, 1333, 13605, 13959, 1372, 13960, 13914
5238, 13605, 1333, 1334, 13606, 13960, 1373, 13961, 13916
5239, 13606, 1334, 1335, 13607, 13961, 1374, 13962, 13918
5240, 13607, 1335, 1336, 13608, 13962, 1375, 13963, 13920
5241, 13608, 1336, 1337, 13609, 13963, 1376, 13964, 13922
5242, 13609, 1337, 1338, 13610, 13964, 1377, 13965, 13924
5243, 13610, 1338, 24, 1294, 13965, 1378, 1299, 13926
*ELEMENT, type=CPS8, ELSET=Surface13
5244, 16, 1291, 13966, 1388, 1295, 13974, 13975, 1390
5245, 1388, 13966, 13967, 1389, 13975, 13976, 13977, 1391
5246, 1389, 13967, 1379, 25, 13977, 13978, 1383, 1392
5247, 1291, 1292, 13968, 13966, 1296, 13979, 13980, 13974
5248, 13966, 13968, 13969, 13967, 13980, 13981, 13982, 13976
5249, 13967, 13969, 1380, 1379, 13982, 13983, 1384, 13978
5250, 1292, 1293, 13970, 13968, 1297, 13984, 13985, 13979
5251, 13968, 13970, 13971, 13969, 13985, 13986, 13987, 13981
5252, 13969, 13971, 1381, 1380, 13987, 13988, 1385, 13983
5253, 1293, 1294, 13972, 13970, 1298, 13989, 13990, 13984
5254, 13970, 13972, 13973, 13971, 13990, 13991, 13992, 13986
5255, 13971, 13973, 1382, 1381, 13992, 13993, 1386, 13988
5256, 1294, 24, 1393, 13972, 1299, 1395, 13994, 13989
5257, 13972, 1393, 1394, 13973, 13994, 1396, 13995, 13991
5258, 13973, 1394, 26, 1382, 13995, 1397, 1387, 13993
*ELEMENT, type=CPS8, ELSET=Surface14
5259, 5, 760, 13996, 365, 764, 14152, 14153, 404
5260, 365, 13996, 13997, 366, 14153, 14154, 14155, 405
5261, 366, 13997, 13998, 367, 14155, 14156, 14157, 406
5262, 367, 13998, 13999, 368, 14157, 14158, 14159, 407
5263, 368, 13999, 14000, 369, 14159, 14160, 14161, 408
5264, 369, 14000, 14001, 370, 14161, 14162, 14163, 409
5265, 370, 14001, 14002, 371, 14163, 14164, 14165, 410
5266, 371, 14002, 14003, 372, 14165, 14166, 14167, 411
5267, 372, 14003, 14004, 373, 14167, 14168, 14169, 412
5268, 373, 14004, 14005, 374, 14169, 14170, 14171, 413
5269, 374, 14005, 14006, 375, 14171, 14172, 14173, 414
5270, 375, 14006, 14007, 376, 14173, 14174, 14175, 415
5271, 376, 14007, 14008, 377, 14175, 14176, 14177, 416
5272, 377, 14008, 14009, 378, 14177, 14178, 14179, 417
5273, 378, 14009, 14010, 379, 14179, 14180, 14181, 418
5274, 379, 14010, 14011, 380, 14181, 14182, 14183, 419
5275, 380, 14011, 14012, 381, 14183, 14184, 14185, 420
5276, 381, 14012, 14013, 382, 14185, 14186, 14187, 421
5277, 382, 14013, 14014, 383, 14187, 14188, 14189, 422
5278, 383, 14014, 14015, 384, 14189, 14190, 14191, 423
5279, 384, 14015, 14016, 385, 14191, 14192, 14193, 424
5280, 385, 14016, 14017, 386, 14193, 14194, 14195, 425
5281, 386, 14017, 14018, 387, 14195, 14196, 14197, 426
5282, 387, 14018, 14019, 388, 14197, 14198, 14199, 427
5283, 388, 14019, 14020, 389, 14199, 14200, 14201, 428
5284, 389, 14020, 14021, 390, 14201, 14202, 14203, 429
5285, 390, 14021, 14022, 391, 14203, 14204, 14205, 430
5286, 391, 14022, 14023, 392, 14205, 14206, 14207, 431
5287, 392, 14023, 14024, 393, 14207, 14208, 14209, 432
5288, 393, 14024, 14025, 394, 14209, 14210, 14211, 433
5289, 394, 14025, 14026, 395, 14211, 14212, 14213, 434
5290, 395, 14026, 14027, 396, 14213, 14214, 14215, 435
5291, 396, 14027, 14028, 397, 14215, 14216, 14217, 436
5292, 397, 14028, 14029, 398, 14217, 14218, 14219, 437
5293, 398, 14029, 14030, 399, 14219, 14220, 14221, 438
5294, 399, 14030, 14031, 400, 14221, 14222, 14223, 439
5295, 400, 14031, 14032, 401, 14223, 14224, 14225, 440
5296, 401, 14032, 14033, 402, 14225, 14226, 14227, 441
5297, 402, 14033, 14034, 403, 14227, 14228, 14229, 442
5298, 403, 14034, 769, 6, 14229, 14230, 773, 443
5299, 760, 761, 14035, 13996, 765, 14231, 14232, 14152
5300, 13996, 14035, 14036, 13997, 14232, 14233, 14234, 14154
5301, 13997, 14036, 14037, 13998, 14234, 14235, 14236, 14156
5302, 13998, 14037, 14038, 13999, 14236, 14237, 14238, 14158
5303, 13999, 14038, 14039, 14000, 14238, 14239, 14240, 14160
5304, 14000, 14039, 14040, 14001, 14240, 14241, 14242, 14162
5305, 14001, 14040, 14041, 14002, 14242, 14243, 14244, 14164
5306, 14002, 14041, 14042, 14003, 14244, 14245, 14246, 14166
5307, 14003, 14042, 14043, 14004, 14246, 14247, 14248, 14168
5308, 14004, 14043, 14044, 14005, 14248, 14249, 14250, 14170
5309, 14005, 14044, 14045, 14006, 14250, 14251, 14252, 14172
5310, 14006, 14045, 14046, 14007, 14252, 14253, 14254, 14174
5311, 14007, 14046, 14047, 14008, 14254, 14255, 14256, 14176
5312, 14008, 14047, 14048, 14009, 14256, 14257, 14258, 14178
5313, 14009, 14048, 14049, 14010, 14258, 14259, 14260, 14180
5314, 14010, 14049, 14050, 14011, 14260, 14261, 14262, 14182
5315, 14011, 14050, 14051, 14012, 14262, 14263, 14264, 14184
5316, 14012, 14051, 14052, 14013, 14264, 14265, 14266, 14186
5317, 14013, 14052, 14053, 14014, 14266, 14267, 14268, 14188
5318, 14014, 14053, 14054, 14015, 14268, 14269, 14270, 14190
5319, 14015, 14054, 14055, 14016, 14270, 14271, 14272, 14192
5320, 14016, 14055, 14056, 14017, 14272, 14273, 14274, 14194
5321, 14017, 14056, 14057, 14018, 14274, 14275, 14276, 14196
5322, 14018, 14057, 14058, 14019, 14276, 14277, 14278, 14198
5323, 14019, 14058, 14059, 14020, 14278, 14279, 14280, 14200
5324, 14020, 14059, 14060, 14021, 14280, 14281, 14282, 14202
5325, 14021, 14060, 14061, 14022, 14282, 14283, 14284, 14204
5326, 14022, 14061, 14062, 14023, 14284, 14285, 14286, 14206
5327, 14023, 14062, 14063, 14024, 14286, 14287, 14288, 14208
5328, 14024, 14063, 14064, 14025, 14288, 14289, 14290, 14210
5329, 14025, 14064, 14065, 14026, 14290, 14291, 14292, 14212
5330, 14026, 14065, 14066, 14027, 14292, 14293, 14294, 14214
5331, 14027, 14066, 14067, 14028, 14294, 14295, 14296, 14216
5332, 14028, 14067, 14068, 14029, 14296, 14297, 14298, 14218
5333, 14029, 14068, 14069, 14030, 14298, 14299, 14300, 14220
5334, 14030, 14069, 14070, 14031, 14300, 14301, 14302, 14222
5335, 14031, 14070, 14071, 14032, 14302, 14303, 14304, 14224
5336, 14032, 14071, 14072, 14033, 14304, 14305, 14306, 14226
5337, 14033, 14072, 14073, 14034, 14306, 14307, 14308, 14228
5338, 14034, 14073, 770, 769, 14308, 14309, 774, 14230
5339, 761, 762, 14074, 14035, 766, 14310, 14311, 14231
5340, 14035, 14074, 14075, 14036, 14311, 14312, 14313, 14233
5341, 14036, 14075, 14076, 14037, 14313, 14314, 14315, 14235
5342, 14037, 14076, 14077, 14038, 14315, 14316, 14317, 14237
5343, 14038, 14077, 14078, 14039, 14317, 14318, 14319, 14239
5344, 14039, 14078, 14079, 14040, 14319, 14320, 14321, 14241
5345, 14040, 14079, 14080, 14041, 14321, 14322, 14323, 14243
5346, 14041, 14080, 14081, 14042, 14323, 14324, 14325, 14245
5347, 14042, 14081, 14082, 14043, 14325, 14326, 14327, 14247
5348, 14043, 14082, 14083, 14044, 14327, 14328, 14329, 14249
5349, 14044, 14083, 14084, 14045, 14329, 14330, 14331, 14251
5350, 14045, 14084, 14085, 14046, 14331, 14332, 14333, 14253
5351, 14046, 14085, 14086, 14047, 14333, 14334, 14335, 14255
5352, 14047, 14086, 14087, 14048, 14335, 14336, 14337, 14257
5353, 14048, 14087, 14088, 14049, 14337, 14338, 14339, 14259
5354, 14049, 14088, 14089, 14050, 14339, 14340, 14341, 14261
5355, 14050, 14089, 14090, 14051, 14341, 14342, 14343, 14263
5356, 14051, 14090, 14091, 14052, 14343, 14344, 14345, 14265
5357, 14052, 14091, 14092, 14053, 14345, 14346, 14347, 14267
5358, 14053, 14092, 14093, 14054, 14347, 14348, 14349, 14269
5359, 14054, 14093, 14094, 14055, 14349, 14350, 14351, 14271
5360, 14055, 14094, 14095, 14056, 14351, 14352, 14353, 14273
5361, 14056, 14095, 14096, 14057, 14353, 14354, 14355, 14275
5362, 14057, 14096, 14097, 14058, 14355, 14356, 14357, 14277
5363, 14058, 14097, 14098, 14059, 14357, 14358, 14359, 14279
5364, 14059, 14098, 14099, 14060, 14359, 14360, 14361, 14281
5365, 14060, 14099, 14100, 14061, 14361, 14362, 14363, 14283
5366, 14061, 14100, 14101, 14062, 14363, 14364, 14365, 14285
5367, 14062, 14101, 14102, 14063, 14365, 14366, 14367, 14287
5368, 14063, 14102, 14103, 14064, 14367, 14368, 14369, 14289
5369, 14064, 14103, 14104, 14065, 14369, 14370, 14371, 14291
5370, 14065, 14104, 14105, 14066, 14371, 14372, 14373, 14293
5371, 14066, 14105, 14106, 14067, 14373, 14374, 14375, 14295
5372, 14067, 14106, 14107, 14068, 14375, 14376, 14377, 14297
5373, 14068, 14107, 14108, 14069, 14377, 14378, 14379, 14299
5374, 14069, 14108, 14109, 14070, 14379, 14380, 14381, 14301
5375, 14070, 14109, 14110, 14071, 14381, 14382, 14383, 14303
5376, 14071, 14110, 14111, 14072, 14383, 14384, 14385, 14305
5377, 14072, 14111, 14112, 14073, 14385, 14386, 14387, 14307
5378, 14073, 14112, 771, 770, 14387, 14388, 775, 14309
5379, 762, 763, 14113, 14074, 767, 14389, 14390, 14310
5380, 14074, 14113, 14114, 14075, 14390, 14391, 14392, 14312
5381, 14075, 14114, 14115, 14076, 14392, 14393, 14394, 14314
5382, 14076, 14115, 14116, 14077, 14394, 14395, 14396, 14316
5383, 14077, 14116, 14117, 14078, 14396, 14397, 14398, 14318
5384, 14078, 14117, 14118, 14079, 14398, 14399, 14400, 14320
5385, 14079, 14118, 14119, 14080, 14400, 14401, 14402, 14322
5386, 14080, 14119, 14120, 14081, 14402, 14403, 14404, 14324
5387, 14081, 14120, 14121, 14082, 14404, 14405, 14406, 14326
5388, 14082, 14121, 14122, 14083, 14406, 14407, 14408, 14328
5389, 14083, 14122, 14123, 14084, 14408, 14409, 14410, 14330
5390, 14084, 14123, 14124, 14085, 14410, 14411, 14412, 14332
5391, 14085, 14124, 14125, 14086, 14412, 14413, 14414, 14334
5392, 14086, 14125, 14126, 14087, 14414, 14415, 14416, 14336
5393, 14087, 14126, 14127, 14088, 14416, 14417, 14418, 14338
5394, 14088, 14127, 14128, 14089, 14418, 14419, 14420, 14340
5395, 14089, 14128, 14129, 14090, 14420, 14421, 14422, 14342
5396, 14090, 14129, 14130, 14091, 14422, 14423, 14424, 14344
5397, 14091, 14130, 14131, 14092, 14424, 14425, 14426, 14346
5398, 14092, 14131, 14132, 14093, 14426, 14427, 14428, 14348
5399, 14093, 14132, 14133, 14094, 14428, 14429, 14430, 14350
5400, 14094, 14133, 14134, 14095, 14430, 14431, 14432, 14352
5401, 14095, 14134, 14135, 14096, 14432, 14433, 14434, 14354
5402, 14096, 14135, 14136, 14097, 14434, 14435, 14436, 14356
5403, 14097, 14136, 14137, 14098, 14436, 14437, 14438, 14358
5404, 14098, 14137, 14138, 14099, 14438, 14439, 14440, 14360
5405, 14099, 14138, 14139, 14100, 14440, 14441, 14442, 14362
5406, 14100, 14139, 14140, 14101, 14442, 14443, 14444, 14364
5407, 14101, 14140, 14141, 14102, 14444, 14445, 14446, 14366
5408, 14102, 14141, 14142, 14103, 14446, 14447, 14448, 14368
5409, 14103, 14142, 14143, 14104, 14448, 14449, 14450, 14370
5410, 14104, 14143, 14144, 14105, 14450, 14451, 14452, 14372
5411, 14105, 14144, 14145, 14106, 14452, 14453, 14454, 14374
5412, 14106, 14145, 14146, 14107, 14454, 14455, 14456, 14376
5413, 14107, 14146, 14147, 14108, 14456, 14457, 14458, 14378
5414, 14108, 14147, 14148, 14109, 14458, 14459, 14460, 14380
5415, 14109, 14148, 14149, 14110, 14460, 14461, 14462, 14382
5416, 14110, 14149, 14150, 14111, 14462, 14463, 14464, 14384
5417, 14111, 14150, 14151, 14112, 14464, 14465, 14466, 14386
5418, 14112, 14151, 772, 771, 14466, 14467, 776, 14388
5419, 763, 11, 778, 14113, 768, 817, 14468, 14389
5420, 14113, 778, 779, 14114, 14468, 818, 14469, 14391
5421, 14114, 779, 780, 14115, 14469, 819, 14470, 14393
5422, 14115, 780, 781, 14116, 14470, 820, 14471, 14395
5423, 14116, 781, 782, 14117, 14471, 821, 14472, 14397
5424, 14117, 782, 783, 14118, 14472, 822, 14473, 14399
5425, 14118, 783, 784, 14119, 14473, 823, 14474, 14401
5426, 14119, 784, 785, 14120, 14474, 824, 14475, 14403
5427, 14120, 785, 786, 14121, 14475, 825, 14476, 14405
5428, 14121, 786, 787, 14122, 14476, 826, 14477, 14407
5429, 14122, 787, 788, 14123, 14477, 827, 14478, 14409
5430, 14123, 788, 789, 14124, 14478, 828, 14479, 14411
5431, 14124, 789, 790, 14125, 14479, 829, 14480, 14413
5432, 14125, 790, 791, 14126, 14480, 830, 14481, 14415
5433, 14126, 791, 792, 14127, 14481, 831, 14482, 14417
5434, 14127, 792, 793, 14128, 14482, 832, 14483, 14419
5435, 14128, 793, 794, 14129, 14483, 833, 14484, 14421
5436, 14129, 794, 795, 14130, 14484, 834, 14485, 14423
5437, 14130, 795, 796, 14131, 14485, 835, 14486, 14425
5438, 14131, 796, 797, 14132, 14486, 836, 14487, 14427
5439, 14132, 797, 798, 14133, 14487, 837, 14488, 14429
5440, 14133, 798, 799, 14134, 14488, 838, 14489, 14431
5441, 14134, 799, 800, 14135, 14489, 839, 14490, 14433
5442, 14135, 800, 801, 14136, 14490, 840, 14491, 14435
5443, 14136, 801, 802, 14137, 14491, 841, 14492, 14437
5444, 14137, 802, 803, 14138, 14492, 842, 14493, 14439
5445, 14138, 803, 804, 14139, 14493, 843, 14494, 14441
5446, 14139, 804, 805, 14140, 14494, 844, 14495, 14443
5447, 14140, 805, 806, 14141, 14495, 845, 14496, 14445
5448, 14141, 806, 807, 14142, 14496, 846, 14497, 14447
5449, 14142, 807, 808, 14143, 14497, 847, 14498, 14449
5450, 14143, 808, 809, 14144, 14498, 848, 14499, 14451
5451, 14144, 809, 810, 14145, 14499, 849, 14500, 14453
5452, 14145, 810, 811, 14146, 14500, 850, 14501, 14455
5453, 14146, 811, 812, 14147, 14501, 851, 14502, 14457
5454, 14147, 812, 813, 14148, 14502, 852, 14503, 14459
5455, 14148, 813, 814, 14149, 14503, 853, 14504, 14461
5456, 14149, 814, 815, 14150, 14504, 854, 14505, 14463
5457, 14150, 815, 816, 14151, 14505, 855, 14506, 14465
5458, 14151, 816, 12, 772, 14506, 856, 777, 14467
*ELEMENT, type=CPS8, ELSET=Surface17
5459, 5, 866, 14507, 760, 870, 14523, 14524, 764
5460, 760, 14507, 14508, 761, 14524, 14525, 14526, 765
5461, 761, 14508, 14509, 762, 14526, 14527, 14528, 766
5462, 762, 14509, 14510, 763, 14528, 14529, 14530, 767
5463, 763, 14510, 1398, 11, 14530, 14531, 1402, 768
5464, 866, 867, 14511, 14507, 871, 14532, 14533, 14523
5465, 14507, 14511, 14512, 14508, 14533, 14534, 14535, 14525
5466, 14508, 14512, 14513, 14509, 14535, 14536, 14537, 14527
5467, 14509, 14513, 14514, 14510, 14537, 14538, 14539, 14529
5468, 14510, 14514, 1399, 1398, 14539, 14540, 1403, 14531
5469, 867, 868, 14515, 14511, 872, 14541, 14542, 14532
5470, 14511, 14515, 14516, 14512, 14542, 14543, 14544, 14534
5471, 14512, 14516, 14517, 14513, 14544, 14545, 14546, 14536
5472, 14513, 14517, 14518, 14514, 14546, 14547, 14548, 14538
5473, 14514, 14518, 1400, 1399, 14548, 14549, 1404, 14540
5474, 868, 869, 14519, 14515, 873, 14550, 14551, 14541
5475, 14515, 14519, 14520, 14516, 14551, 14552, 14553, 14543
5476, 14516, 14520, 14521, 14517, 14553, 14554, 14555, 14545
5477, 14517, 14521, 14522, 14518, 14555, 14556, 14557, 14547
5478, 14518, 14522, 1401, 1400, 14557, 14558, 1405, 14549
5479, 869, 13, 1407, 14519, 874, 1411, 14559, 14550
5480, 14519, 1407, 1408, 14520, 14559, 1412, 14560, 14552
5481, 14520, 1408, 1409, 14521, 14560, 1413, 14561, 14554
5482, 14521, 1409, 1410, 14522, 14561, 1414, 14562, 14556
5483, 14522, 1410, 27, 1401, 14562, 1415, 1406, 14558
*ELEMENT, type=CPS8, ELSET=Surface18
5484, 10, 981, 14563, 1425, 985, 14571, 14572, 1427
5485, 1425, 14563, 14564, 1426, 14572, 14573, 14574, 1428
5486, 1426, 14564, 1416, 28, 14574, 14575, 1420, 1429
5487, 981, 982, 14565, 14563, 986, 14576, 14577, 14571
5488, 14563, 14565, 14566, 14564, 14577, 14578, 14579, 14573
5489, 14564, 14566, 1417, 1416, 14579, 14580, 1421, 14575
5490, 982, 983, 14567, 14565, 987, 14581, 14582, 14576
5491, 14565, 14567, 14568, 14566, 14582, 14583, 14584, 14578
5492, 14566, 14568, 1418, 1417, 14584, 14585, 1422, 14580
5493, 983, 984, 14569, 14567, 988, 14586, 14587, 14581
5494, 14567, 14569, 14570, 14568, 14587, 14588, 14589, 14583
5495, 14568, 14570, 1419, 1418, 14589, 14590, 1423, 14585
5496, 984, 16, 1388, 14569, 989, 1390, 14591, 14586
5497, 14569, 1388, 1389, 14570, 14591, 1391, 14592, 14588
5498, 14570, 1389, 25, 1419, 14592, 1392, 1424, 14590
*ELEMENT, type=CPS8, ELSET=Surface19
5499, 17, 1171, 14593, 1185, 1173, 14601, 14602, 1189
5500, 1171, 1172, 14594, 14593, 1174, 14603, 14604, 14601
5501, 1172, 20, 1433, 14594, 1175, 1438, 14605, 14603
5502, 1185, 14593, 14595, 1186, 14602, 14606, 14607, 1190
5503, 14593, 14594, 14596, 14595, 14604, 14608, 14609, 14606
5504, 14594, 1433, 1432, 14596, 14605, 1437, 14610, 14608
5505, 1186, 14595, 14597, 1187, 14607, 14611, 14612, 1191
5506, 14595, 14596, 14598, 14597, 14609, 14613, 14614, 14611
5507, 14596, 1432, 1431, 14598, 14610, 1436, 14615, 14613
5508, 1187, 14597, 14599, 1188, 14612, 14616, 14617, 1192
5509, 14597, 14598, 14600, 14599, 14614, 14618, 14619, 14616
5510, 14598, 1431, 1430, 14600, 14615, 1435, 14620, 14618
5511, 1188, 14599, 1439, 21, 14617, 14621, 1441, 1193
5512, 14599, 14600, 1440, 1439, 14619, 14622, 1442, 14621
5513, 14600, 1430, 29, 1440, 14620, 1434, 1443, 14622
*ELEMENT, type=CPS8, ELSET=Surface20
5514, 13, 884, 14623, 1407, 923, 14779, 14780, 1411
5515, 884, 885, 14624, 14623, 924, 14781, 14782, 14779
5516, 885, 886, 14625, 14624, 925, 14783, 14784, 14781
5517, 886, 887, 14626, 14625, 926, 14785, 14786, 14783
5518, 887, 888, 14627, 14626, 927, 14787, 14788, 14785
5519, 888, 889, 14628, 14627, 928, 14789, 14790, 14787
5520, 889, 890, 14629, 14628, 929, 14791, 14792, 14789
5521, 890, 891, 14630, 14629, 930, 14793, 14794, 14791
5522, 891, 892, 14631, 14630, 931, 14795, 14796, 14793
5523, 892, 893, 14632, 14631, 932, 14797, 14798, 14795
5524, 893, 894, 14633, 14632, 933, 14799, 14800, 14797
5525, 894, 895, 14634, 14633, 934, 14801, 14802, 14799
5526, 895, 896, 14635, 14634, 935, 14803, 14804, 14801
5527, 896, 897, 14636, 14635, 936, 14805, 14806, 14803
5528, 897, 898, 14637, 14636, 937, 14807, 14808, 14805
5529, 898, 899, 14638, 14637, 938, 14809, 14810, 14807
5530, 899, 900, 14639, 14638, 939, 14811, 14812, 14809
5531, 900, 901, 14640, 14639, 940, 14813, 14814, 14811
5532, 901, 902, 14641, 14640, 941, 14815, 14816, 14813
5533, 902, 903, 14642, 14641, 942, 14817, 14818, 14815
5534, 903, 904, 14643, 14642, 943, 14819, 14820, 14817
5535, 904, 905, 14644, 14643, 944, 14821, 14822, 14819
5536, 905, 906, 14645, 14644, 945, 14823, 14824, 14821
