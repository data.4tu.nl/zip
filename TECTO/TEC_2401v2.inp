4908, 0.6, 0.585, 0
4909, 0.5875, 0.6, 0
4910, 0.6, 0.615, 0
4911, 0.5875, 0.63, 0
4912, 0.6, 0.645, 0
4913, 0.5875, 0.66, 0
4914, 0.6, 0.675, 0
4915, 0.5875, 0.69, 0
4916, 0.6, 0.705, 0
4917, 0.5875, 0.72, 0
4918, 0.6, 0.735, 0
4919, 0.5875, 0.75, 0
4920, 0.6, 0.765, 0
4921, 0.5875, 0.78, 0
4922, 0.6, 0.795, 0
4923, 0.5875, 0.81, 0
4924, 0.6, 0.825, 0
4925, 0.5875, 0.84, 0
4926, 0.6, 0.855, 0
4927, 0.5875, 0.87, 0
4928, 0.6, 0.885, 0
4929, 0.5875, 0.9, 0
4930, 0.6, 0.915, 0
4931, 0.5875, 0.93, 0
4932, 0.6, 0.945, 0
4933, 0.5875, 0.96, 0
4934, 0.6, 0.975, 0
4935, 0.5875, 0.99, 0
4936, 0.6, 1.005, 0
4937, 0.5875, 1.02, 0
4938, 0.6, 1.035, 0
4939, 0.5875, 1.05, 0
4940, 0.6, 1.065, 0
4941, 0.5875, 1.08, 0
4942, 0.6, 1.095, 0
4943, 0.5875, 1.11, 0
4944, 0.6, 1.125, 0
4945, 0.5875, 1.14, 0
4946, 0.6, 1.155, 0
4947, 0.5875, 1.17, 0
4948, 0.6, 1.185, 0
4949, 0.625, 0.015, 0
4950, 0.6125, 0.03, 0
4951, 0.625, 0.045, 0
4952, 0.6125, 0.06, 0
4953, 0.625, 0.075, 0
4954, 0.6125, 0.09, 0
4955, 0.625, 0.105, 0
4956, 0.6125, 0.12, 0
4957, 0.625, 0.135, 0
4958, 0.6125, 0.15, 0
4959, 0.625, 0.165, 0
4960, 0.6125, 0.18, 0
4961, 0.625, 0.195, 0
4962, 0.6125, 0.21, 0
4963, 0.625, 0.225, 0
4964, 0.6125, 0.24, 0
4965, 0.625, 0.255, 0
4966, 0.6125, 0.27, 0
4967, 0.625, 0.285, 0
4968, 0.6125, 0.3, 0
4969, 0.625, 0.315, 0
4970, 0.6125, 0.33, 0
4971, 0.625, 0.345, 0
4972, 0.6125, 0.36, 0
4973, 0.625, 0.375, 0
4974, 0.6125, 0.39, 0
4975, 0.625, 0.405, 0
4976, 0.6125, 0.42, 0
4977, 0.625, 0.435, 0
4978, 0.6125, 0.45, 0
4979, 0.625, 0.465, 0
4980, 0.6125, 0.48, 0
4981, 0.625, 0.495, 0
4982, 0.6125, 0.51, 0
4983, 0.625, 0.525, 0
4984, 0.6125, 0.54, 0
4985, 0.625, 0.555, 0
4986, 0.6125, 0.57, 0
4987, 0.625, 0.585, 0
4988, 0.6125, 0.6, 0
4989, 0.625, 0.615, 0
4990, 0.6125, 0.63, 0
4991, 0.625, 0.645, 0
4992, 0.6125, 0.66, 0
4993, 0.625, 0.675, 0
4994, 0.6125, 0.69, 0
4995, 0.625, 0.705, 0
4996, 0.6125, 0.72, 0
4997, 0.625, 0.735, 0
4998, 0.6125, 0.75, 0
4999, 0.625, 0.765, 0
5000, 0.6125, 0.78, 0
5001, 0.625, 0.795, 0
5002, 0.6125, 0.81, 0
5003, 0.625, 0.825, 0
5004, 0.6125, 0.84, 0
5005, 0.625, 0.855, 0
5006, 0.6125, 0.87, 0
5007, 0.625, 0.885, 0
5008, 0.6125, 0.9, 0
5009, 0.625, 0.915, 0
5010, 0.6125, 0.93, 0
5011, 0.625, 0.945, 0
5012, 0.6125, 0.96, 0
5013, 0.625, 0.975, 0
5014, 0.6125, 0.99, 0
5015, 0.625, 1.005, 0
5016, 0.6125, 1.02, 0
5017, 0.625, 1.035, 0
5018, 0.6125, 1.05, 0
5019, 0.625, 1.065, 0
5020, 0.6125, 1.08, 0
5021, 0.625, 1.095, 0
5022, 0.6125, 1.11, 0
5023, 0.625, 1.125, 0
5024, 0.6125, 1.14, 0
5025, 0.625, 1.155, 0
5026, 0.6125, 1.17, 0
5027, 0.625, 1.185, 0
5028, 0.65, 0.015, 0
5029, 0.6375, 0.03, 0
5030, 0.65, 0.045, 0
5031, 0.6375, 0.06, 0
5032, 0.65, 0.075, 0
5033, 0.6375, 0.09, 0
5034, 0.65, 0.105, 0
5035, 0.6375, 0.12, 0
5036, 0.65, 0.135, 0
5037, 0.6375, 0.15, 0
5038, 0.65, 0.165, 0
5039, 0.6375, 0.18, 0
5040, 0.65, 0.195, 0
5041, 0.6375, 0.21, 0
5042, 0.65, 0.225, 0
5043, 0.6375, 0.24, 0
5044, 0.65, 0.255, 0
5045, 0.6375, 0.27, 0
5046, 0.65, 0.285, 0
5047, 0.6375, 0.3, 0
5048, 0.65, 0.315, 0
5049, 0.6375, 0.33, 0
5050, 0.65, 0.345, 0
5051, 0.6375, 0.36, 0
5052, 0.65, 0.375, 0
5053, 0.6375, 0.39, 0
5054, 0.65, 0.405, 0
5055, 0.6375, 0.42, 0
5056, 0.65, 0.435, 0
5057, 0.6375, 0.45, 0
5058, 0.65, 0.465, 0
5059, 0.6375, 0.48, 0
5060, 0.65, 0.495, 0
5061, 0.6375, 0.51, 0
5062, 0.65, 0.525, 0
5063, 0.6375, 0.54, 0
5064, 0.65, 0.555, 0
5065, 0.6375, 0.57, 0
5066, 0.65, 0.585, 0
5067, 0.6375, 0.6, 0
5068, 0.65, 0.615, 0
5069, 0.6375, 0.63, 0
5070, 0.65, 0.645, 0
5071, 0.6375, 0.66, 0
5072, 0.65, 0.675, 0
5073, 0.6375, 0.69, 0
5074, 0.65, 0.705, 0
5075, 0.6375, 0.72, 0
5076, 0.65, 0.735, 0
5077, 0.6375, 0.75, 0
5078, 0.65, 0.765, 0
5079, 0.6375, 0.78, 0
5080, 0.65, 0.795, 0
5081, 0.6375, 0.81, 0
5082, 0.65, 0.825, 0
5083, 0.6375, 0.84, 0
5084, 0.65, 0.855, 0
5085, 0.6375, 0.87, 0
5086, 0.65, 0.885, 0
5087, 0.6375, 0.9, 0
5088, 0.65, 0.915, 0
5089, 0.6375, 0.93, 0
5090, 0.65, 0.945, 0
5091, 0.6375, 0.96, 0
5092, 0.65, 0.975, 0
5093, 0.6375, 0.99, 0
5094, 0.65, 1.005, 0
5095, 0.6375, 1.02, 0
5096, 0.65, 1.035, 0
5097, 0.6375, 1.05, 0
5098, 0.65, 1.065, 0
5099, 0.6375, 1.08, 0
5100, 0.65, 1.095, 0
5101, 0.6375, 1.11, 0
5102, 0.65, 1.125, 0
5103, 0.6375, 1.14, 0
5104, 0.65, 1.155, 0
5105, 0.6375, 1.17, 0
5106, 0.65, 1.185, 0
5107, 0.675, 0.015, 0
5108, 0.6625, 0.03, 0
5109, 0.675, 0.045, 0
5110, 0.6625, 0.06, 0
5111, 0.675, 0.075, 0
5112, 0.6625, 0.09, 0
5113, 0.675, 0.105, 0
5114, 0.6625, 0.12, 0
5115, 0.675, 0.135, 0
5116, 0.6625, 0.15, 0
5117, 0.675, 0.165, 0
5118, 0.6625, 0.18, 0
5119, 0.675, 0.195, 0
5120, 0.6625, 0.21, 0
5121, 0.675, 0.225, 0
5122, 0.6625, 0.24, 0
5123, 0.675, 0.255, 0
5124, 0.6625, 0.27, 0
5125, 0.675, 0.285, 0
5126, 0.6625, 0.3, 0
5127, 0.675, 0.315, 0
5128, 0.6625, 0.33, 0
5129, 0.675, 0.345, 0
5130, 0.6625, 0.36, 0
5131, 0.675, 0.375, 0
5132, 0.6625, 0.39, 0
5133, 0.675, 0.405, 0
5134, 0.6625, 0.42, 0
5135, 0.675, 0.435, 0
5136, 0.6625, 0.45, 0
5137, 0.675, 0.465, 0
5138, 0.6625, 0.48, 0
5139, 0.675, 0.495, 0
5140, 0.6625, 0.51, 0
5141, 0.675, 0.525, 0
5142, 0.6625, 0.54, 0
5143, 0.675, 0.555, 0
5144, 0.6625, 0.57, 0
5145, 0.675, 0.585, 0
5146, 0.6625, 0.6, 0
5147, 0.675, 0.615, 0
5148, 0.6625, 0.63, 0
5149, 0.675, 0.645, 0
5150, 0.6625, 0.66, 0
5151, 0.675, 0.675, 0
5152, 0.6625, 0.69, 0
5153, 0.675, 0.705, 0
5154, 0.6625, 0.72, 0
5155, 0.675, 0.735, 0
5156, 0.6625, 0.75, 0
5157, 0.675, 0.765, 0
5158, 0.6625, 0.78, 0
5159, 0.675, 0.795, 0
5160, 0.6625, 0.81, 0
5161, 0.675, 0.825, 0
5162, 0.6625, 0.84, 0
5163, 0.675, 0.855, 0
5164, 0.6625, 0.87, 0
5165, 0.675, 0.885, 0
5166, 0.6625, 0.9, 0
5167, 0.675, 0.915, 0
5168, 0.6625, 0.93, 0
5169, 0.675, 0.945, 0
5170, 0.6625, 0.96, 0
5171, 0.675, 0.975, 0
5172, 0.6625, 0.99, 0
5173, 0.675, 1.005, 0
5174, 0.6625, 1.02, 0
5175, 0.675, 1.035, 0
5176, 0.6625, 1.05, 0
5177, 0.675, 1.065, 0
5178, 0.6625, 1.08, 0
5179, 0.675, 1.095, 0
5180, 0.6625, 1.11, 0
5181, 0.675, 1.125, 0
5182, 0.6625, 1.14, 0
5183, 0.675, 1.155, 0
5184, 0.6625, 1.17, 0
5185, 0.675, 1.185, 0
5186, 0.7, 0.015, 0
5187, 0.6875, 0.03, 0
5188, 0.7, 0.045, 0
5189, 0.6875, 0.06, 0
5190, 0.7, 0.075, 0
5191, 0.6875, 0.09, 0
5192, 0.7, 0.105, 0
5193, 0.6875, 0.12, 0
5194, 0.7, 0.135, 0
5195, 0.6875, 0.15, 0
5196, 0.7, 0.165, 0
5197, 0.6875, 0.18, 0
5198, 0.7, 0.195, 0
5199, 0.6875, 0.21, 0
5200, 0.7, 0.225, 0
5201, 0.6875, 0.24, 0
5202, 0.7, 0.255, 0
5203, 0.6875, 0.27, 0
5204, 0.7, 0.285, 0
5205, 0.6875, 0.3, 0
5206, 0.7, 0.315, 0
5207, 0.6875, 0.33, 0
5208, 0.7, 0.345, 0
5209, 0.6875, 0.36, 0
5210, 0.7, 0.375, 0
5211, 0.6875, 0.39, 0
5212, 0.7, 0.405, 0
5213, 0.6875, 0.42, 0
5214, 0.7, 0.435, 0
5215, 0.6875, 0.45, 0
5216, 0.7, 0.465, 0
5217, 0.6875, 0.48, 0
5218, 0.7, 0.495, 0
5219, 0.6875, 0.51, 0
5220, 0.7, 0.525, 0
5221, 0.6875, 0.54, 0
5222, 0.7, 0.555, 0
5223, 0.6875, 0.57, 0
5224, 0.7, 0.585, 0
5225, 0.6875, 0.6, 0
5226, 0.7, 0.615, 0
5227, 0.6875, 0.63, 0
5228, 0.7, 0.645, 0
5229, 0.6875, 0.66, 0
5230, 0.7, 0.675, 0
5231, 0.6875, 0.69, 0
5232, 0.7, 0.705, 0
5233, 0.6875, 0.72, 0
5234, 0.7, 0.735, 0
5235, 0.6875, 0.75, 0
5236, 0.7, 0.765, 0
5237, 0.6875, 0.78, 0
5238, 0.7, 0.795, 0
5239, 0.6875, 0.81, 0
5240, 0.7, 0.825, 0
5241, 0.6875, 0.84, 0
5242, 0.7, 0.855, 0
5243, 0.6875, 0.87, 0
5244, 0.7, 0.885, 0
5245, 0.6875, 0.9, 0
5246, 0.7, 0.915, 0
5247, 0.6875, 0.93, 0
5248, 0.7, 0.945, 0
5249, 0.6875, 0.96, 0
5250, 0.7, 0.975, 0
5251, 0.6875, 0.99, 0
5252, 0.7, 1.005, 0
5253, 0.6875, 1.02, 0
5254, 0.7, 1.035, 0
5255, 0.6875, 1.05, 0
5256, 0.7, 1.065, 0
5257, 0.6875, 1.08, 0
5258, 0.7, 1.095, 0
5259, 0.6875, 1.11, 0
5260, 0.7, 1.125, 0
5261, 0.6875, 1.14, 0
5262, 0.7, 1.155, 0
5263, 0.6875, 1.17, 0
5264, 0.7, 1.185, 0
5265, 0.725, 0.015, 0
5266, 0.7125, 0.03, 0
5267, 0.725, 0.045, 0
5268, 0.7125, 0.06, 0
5269, 0.725, 0.075, 0
5270, 0.7125, 0.09, 0
5271, 0.725, 0.105, 0
5272, 0.7125, 0.12, 0
5273, 0.725, 0.135, 0
5274, 0.7125, 0.15, 0
5275, 0.725, 0.165, 0
5276, 0.7125, 0.18, 0
5277, 0.725, 0.195, 0
5278, 0.7125, 0.21, 0
5279, 0.725, 0.225, 0
5280, 0.7125, 0.24, 0
5281, 0.725, 0.255, 0
5282, 0.7125, 0.27, 0
5283, 0.725, 0.285, 0
5284, 0.7125, 0.3, 0
5285, 0.725, 0.315, 0
5286, 0.7125, 0.33, 0
5287, 0.725, 0.345, 0
5288, 0.7125, 0.36, 0
5289, 0.725, 0.375, 0
5290, 0.7125, 0.39, 0
5291, 0.725, 0.405, 0
5292, 0.7125, 0.42, 0
5293, 0.725, 0.435, 0
5294, 0.7125, 0.45, 0
5295, 0.725, 0.465, 0
5296, 0.7125, 0.48, 0
5297, 0.725, 0.495, 0
5298, 0.7125, 0.51, 0
5299, 0.725, 0.525, 0
5300, 0.7125, 0.54, 0
5301, 0.725, 0.555, 0
5302, 0.7125, 0.57, 0
5303, 0.725, 0.585, 0
5304, 0.7125, 0.6, 0
5305, 0.725, 0.615, 0
5306, 0.7125, 0.63, 0
5307, 0.725, 0.645, 0
5308, 0.7125, 0.66, 0
5309, 0.725, 0.675, 0
5310, 0.7125, 0.69, 0
5311, 0.725, 0.705, 0
5312, 0.7125, 0.72, 0
5313, 0.725, 0.735, 0
5314, 0.7125, 0.75, 0
5315, 0.725, 0.765, 0
5316, 0.7125, 0.78, 0
5317, 0.725, 0.795, 0
5318, 0.7125, 0.81, 0
5319, 0.725, 0.825, 0
5320, 0.7125, 0.84, 0
5321, 0.725, 0.855, 0
5322, 0.7125, 0.87, 0
5323, 0.725, 0.885, 0
5324, 0.7125, 0.9, 0
5325, 0.725, 0.915, 0
5326, 0.7125, 0.93, 0
5327, 0.725, 0.945, 0
5328, 0.7125, 0.96, 0
5329, 0.725, 0.975, 0
5330, 0.7125, 0.99, 0
5331, 0.725, 1.005, 0
5332, 0.7125, 1.02, 0
5333, 0.725, 1.035, 0
5334, 0.7125, 1.05, 0
5335, 0.725, 1.065, 0
5336, 0.7125, 1.08, 0
5337, 0.725, 1.095, 0
5338, 0.7125, 1.11, 0
5339, 0.725, 1.125, 0
5340, 0.7125, 1.14, 0
5341, 0.725, 1.155, 0
5342, 0.7125, 1.17, 0
5343, 0.725, 1.185, 0
5344, 0.75, 0.015, 0
5345, 0.7375, 0.03, 0
5346, 0.75, 0.045, 0
5347, 0.7375, 0.06, 0
5348, 0.75, 0.075, 0
5349, 0.7375, 0.09, 0
5350, 0.75, 0.105, 0
5351, 0.7375, 0.12, 0
5352, 0.75, 0.135, 0
5353, 0.7375, 0.15, 0
5354, 0.75, 0.165, 0
5355, 0.7375, 0.18, 0
5356, 0.75, 0.195, 0
5357, 0.7375, 0.21, 0
5358, 0.75, 0.225, 0
5359, 0.7375, 0.24, 0
5360, 0.75, 0.255, 0
5361, 0.7375, 0.27, 0
5362, 0.75, 0.285, 0
5363, 0.7375, 0.3, 0
5364, 0.75, 0.315, 0
5365, 0.7375, 0.33, 0
5366, 0.75, 0.345, 0
5367, 0.7375, 0.36, 0
5368, 0.75, 0.375, 0
5369, 0.7375, 0.39, 0
5370, 0.75, 0.405, 0
5371, 0.7375, 0.42, 0
5372, 0.75, 0.435, 0
5373, 0.7375, 0.45, 0
5374, 0.75, 0.465, 0
5375, 0.7375, 0.48, 0
5376, 0.75, 0.495, 0
5377, 0.7375, 0.51, 0
5378, 0.75, 0.525, 0
5379, 0.7375, 0.54, 0
5380, 0.75, 0.555, 0
5381, 0.7375, 0.57, 0
5382, 0.75, 0.585, 0
5383, 0.7375, 0.6, 0
5384, 0.75, 0.615, 0
5385, 0.7375, 0.63, 0
5386, 0.75, 0.645, 0
5387, 0.7375, 0.66, 0
5388, 0.75, 0.675, 0
5389, 0.7375, 0.69, 0
5390, 0.75, 0.705, 0
5391, 0.7375, 0.72, 0
5392, 0.75, 0.735, 0
5393, 0.7375, 0.75, 0
5394, 0.75, 0.765, 0
5395, 0.7375, 0.78, 0
5396, 0.75, 0.795, 0
5397, 0.7375, 0.81, 0
5398, 0.75, 0.825, 0
5399, 0.7375, 0.84, 0
5400, 0.75, 0.855, 0
5401, 0.7375, 0.87, 0
5402, 0.75, 0.885, 0
5403, 0.7375, 0.9, 0
5404, 0.75, 0.915, 0
5405, 0.7375, 0.93, 0
5406, 0.75, 0.945, 0
5407, 0.7375, 0.96, 0
5408, 0.75, 0.975, 0
5409, 0.7375, 0.99, 0
5410, 0.75, 1.005, 0
5411, 0.7375, 1.02, 0
5412, 0.75, 1.035, 0
5413, 0.7375, 1.05, 0
5414, 0.75, 1.065, 0
5415, 0.7375, 1.08, 0
5416, 0.75, 1.095, 0
5417, 0.7375, 1.11, 0
5418, 0.75, 1.125, 0
5419, 0.7375, 1.14, 0
5420, 0.75, 1.155, 0
5421, 0.7375, 1.17, 0
5422, 0.75, 1.185, 0
5423, 0.775, 0.015, 0
5424, 0.7625, 0.03, 0
5425, 0.775, 0.045, 0
5426, 0.7625, 0.06, 0
5427, 0.775, 0.075, 0
5428, 0.7625, 0.09, 0
5429, 0.775, 0.105, 0
5430, 0.7625, 0.12, 0
5431, 0.775, 0.135, 0
5432, 0.7625, 0.15, 0
5433, 0.775, 0.165, 0
5434, 0.7625, 0.18, 0
5435, 0.775, 0.195, 0
5436, 0.7625, 0.21, 0
5437, 0.775, 0.225, 0
5438, 0.7625, 0.24, 0
5439, 0.775, 0.255, 0
5440, 0.7625, 0.27, 0
5441, 0.775, 0.285, 0
5442, 0.7625, 0.3, 0
5443, 0.775, 0.315, 0
5444, 0.7625, 0.33, 0
5445, 0.775, 0.345, 0
5446, 0.7625, 0.36, 0
5447, 0.775, 0.375, 0
5448, 0.7625, 0.39, 0
5449, 0.775, 0.405, 0
5450, 0.7625, 0.42, 0
5451, 0.775, 0.435, 0
5452, 0.7625, 0.45, 0
5453, 0.775, 0.465, 0
5454, 0.7625, 0.48, 0
5455, 0.775, 0.495, 0
5456, 0.7625, 0.51, 0
5457, 0.775, 0.525, 0
5458, 0.7625, 0.54, 0
5459, 0.775, 0.555, 0
5460, 0.7625, 0.57, 0
5461, 0.775, 0.585, 0
5462, 0.7625, 0.6, 0
5463, 0.775, 0.615, 0
5464, 0.7625, 0.63, 0
5465, 0.775, 0.645, 0
5466, 0.7625, 0.66, 0
5467, 0.775, 0.675, 0
5468, 0.7625, 0.69, 0
5469, 0.775, 0.705, 0
5470, 0.7625, 0.72, 0
5471, 0.775, 0.735, 0
5472, 0.7625, 0.75, 0
5473, 0.775, 0.765, 0
5474, 0.7625, 0.78, 0
5475, 0.775, 0.795, 0
5476, 0.7625, 0.81, 0
5477, 0.775, 0.825, 0
5478, 0.7625, 0.84, 0
5479, 0.775, 0.855, 0
5480, 0.7625, 0.87, 0
5481, 0.775, 0.885, 0
5482, 0.7625, 0.9, 0
5483, 0.775, 0.915, 0
5484, 0.7625, 0.93, 0
5485, 0.775, 0.945, 0
5486, 0.7625, 0.96, 0
5487, 0.775, 0.975, 0
5488, 0.7625, 0.99, 0
5489, 0.775, 1.005, 0
5490, 0.7625, 1.02, 0
5491, 0.775, 1.035, 0
5492, 0.7625, 1.05, 0
5493, 0.775, 1.065, 0
5494, 0.7625, 1.08, 0
5495, 0.775, 1.095, 0
5496, 0.7625, 1.11, 0
5497, 0.775, 1.125, 0
5498, 0.7625, 1.14, 0
5499, 0.775, 1.155, 0
5500, 0.7625, 1.17, 0
5501, 0.775, 1.185, 0
5502, 0.8, 0.015, 0
5503, 0.7875, 0.03, 0
5504, 0.8, 0.045, 0
5505, 0.7875, 0.06, 0
5506, 0.8, 0.075, 0
5507, 0.7875, 0.09, 0
5508, 0.8, 0.105, 0
5509, 0.7875, 0.12, 0
5510, 0.8, 0.135, 0
5511, 0.7875, 0.15, 0
5512, 0.8, 0.165, 0
5513, 0.7875, 0.18, 0
5514, 0.8, 0.195, 0
5515, 0.7875, 0.21, 0
5516, 0.8, 0.225, 0
5517, 0.7875, 0.24, 0
5518, 0.8, 0.255, 0
5519, 0.7875, 0.27, 0
5520, 0.8, 0.285, 0
5521, 0.7875, 0.3, 0
5522, 0.8, 0.315, 0
5523, 0.7875, 0.33, 0
5524, 0.8, 0.345, 0
5525, 0.7875, 0.36, 0
5526, 0.8, 0.375, 0
5527, 0.7875, 0.39, 0
5528, 0.8, 0.405, 0
5529, 0.7875, 0.42, 0
5530, 0.8, 0.435, 0
5531, 0.7875, 0.45, 0
5532, 0.8, 0.465, 0
5533, 0.7875, 0.48, 0
5534, 0.8, 0.495, 0
5535, 0.7875, 0.51, 0
5536, 0.8, 0.525, 0
5537, 0.7875, 0.54, 0
5538, 0.8, 0.555, 0
5539, 0.7875, 0.57, 0
5540, 0.8, 0.585, 0
5541, 0.7875, 0.6, 0
5542, 0.8, 0.615, 0
5543, 0.7875, 0.63, 0
5544, 0.8, 0.645, 0
5545, 0.7875, 0.66, 0
5546, 0.8, 0.675, 0
5547, 0.7875, 0.69, 0
5548, 0.8, 0.705, 0
5549, 0.7875, 0.72, 0
5550, 0.8, 0.735, 0
5551, 0.7875, 0.75, 0
5552, 0.8, 0.765, 0
5553, 0.7875, 0.78, 0
5554, 0.8, 0.795, 0
5555, 0.7875, 0.81, 0
5556, 0.8, 0.825, 0
5557, 0.7875, 0.84, 0
5558, 0.8, 0.855, 0
5559, 0.7875, 0.87, 0
5560, 0.8, 0.885, 0
5561, 0.7875, 0.9, 0
5562, 0.8, 0.915, 0
5563, 0.7875, 0.93, 0
5564, 0.8, 0.945, 0
5565, 0.7875, 0.96, 0
5566, 0.8, 0.975, 0
5567, 0.7875, 0.99, 0
5568, 0.8, 1.005, 0
5569, 0.7875, 1.02, 0
5570, 0.8, 1.035, 0
5571, 0.7875, 1.05, 0
5572, 0.8, 1.065, 0
5573, 0.7875, 1.08, 0
5574, 0.8, 1.095, 0
5575, 0.7875, 1.11, 0
5576, 0.8, 1.125, 0
5577, 0.7875, 1.14, 0
5578, 0.8, 1.155, 0
5579, 0.7875, 1.17, 0
5580, 0.8, 1.185, 0
5581, 0.825, 0.015, 0
5582, 0.8125, 0.03, 0
5583, 0.825, 0.045, 0
5584, 0.8125, 0.06, 0
5585, 0.825, 0.075, 0
5586, 0.8125, 0.09, 0
5587, 0.825, 0.105, 0
5588, 0.8125, 0.12, 0
5589, 0.825, 0.135, 0
5590, 0.8125, 0.15, 0
5591, 0.825, 0.165, 0
5592, 0.8125, 0.18, 0
5593, 0.825, 0.195, 0
5594, 0.8125, 0.21, 0
5595, 0.825, 0.225, 0
5596, 0.8125, 0.24, 0
5597, 0.825, 0.255, 0
5598, 0.8125, 0.27, 0
5599, 0.825, 0.285, 0
5600, 0.8125, 0.3, 0
5601, 0.825, 0.315, 0
5602, 0.8125, 0.33, 0
5603, 0.825, 0.345, 0
5604, 0.8125, 0.36, 0
5605, 0.825, 0.375, 0
5606, 0.8125, 0.39, 0
5607, 0.825, 0.405, 0
5608, 0.8125, 0.42, 0
5609, 0.825, 0.435, 0
5610, 0.8125, 0.45, 0
5611, 0.825, 0.465, 0
5612, 0.8125, 0.48, 0
5613, 0.825, 0.495, 0
5614, 0.8125, 0.51, 0
5615, 0.825, 0.525, 0
5616, 0.8125, 0.54, 0
5617, 0.825, 0.555, 0
5618, 0.8125, 0.57, 0
5619, 0.825, 0.585, 0
5620, 0.8125, 0.6, 0
5621, 0.825, 0.615, 0
5622, 0.8125, 0.63, 0
5623, 0.825, 0.645, 0
5624, 0.8125, 0.66, 0
5625, 0.825, 0.675, 0
5626, 0.8125, 0.69, 0
5627, 0.825, 0.705, 0
5628, 0.8125, 0.72, 0
5629, 0.825, 0.735, 0
5630, 0.8125, 0.75, 0
5631, 0.825, 0.765, 0
5632, 0.8125, 0.78, 0
5633, 0.825, 0.795, 0
5634, 0.8125, 0.81, 0
5635, 0.825, 0.825, 0
5636, 0.8125, 0.84, 0
5637, 0.825, 0.855, 0
5638, 0.8125, 0.87, 0
5639, 0.825, 0.885, 0
5640, 0.8125, 0.9, 0
5641, 0.825, 0.915, 0
5642, 0.8125, 0.93, 0
5643, 0.825, 0.945, 0
5644, 0.8125, 0.96, 0
5645, 0.825, 0.975, 0
5646, 0.8125, 0.99, 0
5647, 0.825, 1.005, 0
5648, 0.8125, 1.02, 0
5649, 0.825, 1.035, 0
5650, 0.8125, 1.05, 0
5651, 0.825, 1.065, 0
5652, 0.8125, 1.08, 0
5653, 0.825, 1.095, 0
5654, 0.8125, 1.11, 0
5655, 0.825, 1.125, 0
5656, 0.8125, 1.14, 0
5657, 0.825, 1.155, 0
5658, 0.8125, 1.17, 0
5659, 0.825, 1.185, 0
5660, 0.85, 0.015, 0
5661, 0.8375, 0.03, 0
5662, 0.85, 0.045, 0
5663, 0.8375, 0.06, 0
5664, 0.85, 0.075, 0
5665, 0.8375, 0.09, 0
5666, 0.85, 0.105, 0
5667, 0.8375, 0.12, 0
5668, 0.85, 0.135, 0
5669, 0.8375, 0.15, 0
5670, 0.85, 0.165, 0
5671, 0.8375, 0.18, 0
5672, 0.85, 0.195, 0
5673, 0.8375, 0.21, 0
5674, 0.85, 0.225, 0
5675, 0.8375, 0.24, 0
5676, 0.85, 0.255, 0
5677, 0.8375, 0.27, 0
5678, 0.85, 0.285, 0
5679, 0.8375, 0.3, 0
5680, 0.85, 0.315, 0
5681, 0.8375, 0.33, 0
5682, 0.85, 0.345, 0
5683, 0.8375, 0.36, 0
5684, 0.85, 0.375, 0
5685, 0.8375, 0.39, 0
5686, 0.85, 0.405, 0
5687, 0.8375, 0.42, 0
5688, 0.85, 0.435, 0
5689, 0.8375, 0.45, 0
5690, 0.85, 0.465, 0
5691, 0.8375, 0.48, 0
5692, 0.85, 0.495, 0
5693, 0.8375, 0.51, 0
5694, 0.85, 0.525, 0
5695, 0.8375, 0.54, 0
5696, 0.85, 0.555, 0
5697, 0.8375, 0.57, 0
5698, 0.85, 0.585, 0
5699, 0.8375, 0.6, 0
5700, 0.85, 0.615, 0
5701, 0.8375, 0.63, 0
5702, 0.85, 0.645, 0
5703, 0.8375, 0.66, 0
5704, 0.85, 0.675, 0
5705, 0.8375, 0.69, 0
5706, 0.85, 0.705, 0
5707, 0.8375, 0.72, 0
5708, 0.85, 0.735, 0
5709, 0.8375, 0.75, 0
5710, 0.85, 0.765, 0
5711, 0.8375, 0.78, 0
5712, 0.85, 0.795, 0
5713, 0.8375, 0.81, 0
5714, 0.85, 0.825, 0
5715, 0.8375, 0.84, 0
5716, 0.85, 0.855, 0
5717, 0.8375, 0.87, 0
5718, 0.85, 0.885, 0
5719, 0.8375, 0.9, 0
5720, 0.85, 0.915, 0
5721, 0.8375, 0.93, 0
5722, 0.85, 0.945, 0
5723, 0.8375, 0.96, 0
5724, 0.85, 0.975, 0
5725, 0.8375, 0.99, 0
5726, 0.85, 1.005, 0
5727, 0.8375, 1.02, 0
5728, 0.85, 1.035, 0
5729, 0.8375, 1.05, 0
5730, 0.85, 1.065, 0
5731, 0.8375, 1.08, 0
5732, 0.85, 1.095, 0
5733, 0.8375, 1.11, 0
5734, 0.85, 1.125, 0
5735, 0.8375, 1.14, 0
5736, 0.85, 1.155, 0
5737, 0.8375, 1.17, 0
5738, 0.85, 1.185, 0
5739, 0.875, 0.015, 0
5740, 0.8625, 0.03, 0
5741, 0.875, 0.045, 0
5742, 0.8625, 0.06, 0
5743, 0.875, 0.075, 0
5744, 0.8625, 0.09, 0
5745, 0.875, 0.105, 0
5746, 0.8625, 0.12, 0
5747, 0.875, 0.135, 0
5748, 0.8625, 0.15, 0
5749, 0.875, 0.165, 0
5750, 0.8625, 0.18, 0
5751, 0.875, 0.195, 0
5752, 0.8625, 0.21, 0
5753, 0.875, 0.225, 0
5754, 0.8625, 0.24, 0
5755, 0.875, 0.255, 0
5756, 0.8625, 0.27, 0
5757, 0.875, 0.285, 0
5758, 0.8625, 0.3, 0
5759, 0.875, 0.315, 0
5760, 0.8625, 0.33, 0
5761, 0.875, 0.345, 0
5762, 0.8625, 0.36, 0
5763, 0.875, 0.375, 0
5764, 0.8625, 0.39, 0
5765, 0.875, 0.405, 0
5766, 0.8625, 0.42, 0
5767, 0.875, 0.435, 0
5768, 0.8625, 0.45, 0
5769, 0.875, 0.465, 0
5770, 0.8625, 0.48, 0
5771, 0.875, 0.495, 0
5772, 0.8625, 0.51, 0
5773, 0.875, 0.525, 0
5774, 0.8625, 0.54, 0
5775, 0.875, 0.555, 0
5776, 0.8625, 0.57, 0
5777, 0.875, 0.585, 0
5778, 0.8625, 0.6, 0
5779, 0.875, 0.615, 0
5780, 0.8625, 0.63, 0
5781, 0.875, 0.645, 0
5782, 0.8625, 0.66, 0
5783, 0.875, 0.675, 0
5784, 0.8625, 0.69, 0
5785, 0.875, 0.705, 0
5786, 0.8625, 0.72, 0
5787, 0.875, 0.735, 0
5788, 0.8625, 0.75, 0
5789, 0.875, 0.765, 0
5790, 0.8625, 0.78, 0
5791, 0.875, 0.795, 0
5792, 0.8625, 0.81, 0
5793, 0.875, 0.825, 0
5794, 0.8625, 0.84, 0
5795, 0.875, 0.855, 0
5796, 0.8625, 0.87, 0
5797, 0.875, 0.885, 0
5798, 0.8625, 0.9, 0
5799, 0.875, 0.915, 0
5800, 0.8625, 0.93, 0
5801, 0.875, 0.945, 0
5802, 0.8625, 0.96, 0
5803, 0.875, 0.975, 0
5804, 0.8625, 0.99, 0
5805, 0.875, 1.005, 0
5806, 0.8625, 1.02, 0
5807, 0.875, 1.035, 0
5808, 0.8625, 1.05, 0
5809, 0.875, 1.065, 0
5810, 0.8625, 1.08, 0
5811, 0.875, 1.095, 0
5812, 0.8625, 1.11, 0
5813, 0.875, 1.125, 0
5814, 0.8625, 1.14, 0
5815, 0.875, 1.155, 0
5816, 0.8625, 1.17, 0
5817, 0.875, 1.185, 0
5818, 0.9, 0.015, 0
5819, 0.8875, 0.03, 0
5820, 0.9, 0.045, 0
5821, 0.8875, 0.06, 0
5822, 0.9, 0.075, 0
5823, 0.8875, 0.09, 0
5824, 0.9, 0.105, 0
5825, 0.8875, 0.12, 0
5826, 0.9, 0.135, 0
5827, 0.8875, 0.15, 0
5828, 0.9, 0.165, 0
5829, 0.8875, 0.18, 0
5830, 0.9, 0.195, 0
5831, 0.8875, 0.21, 0
5832, 0.9, 0.225, 0
5833, 0.8875, 0.24, 0
5834, 0.9, 0.255, 0
5835, 0.8875, 0.27, 0
5836, 0.9, 0.285, 0
5837, 0.8875, 0.3, 0
5838, 0.9, 0.315, 0
5839, 0.8875, 0.33, 0
5840, 0.9, 0.345, 0
5841, 0.8875, 0.36, 0
5842, 0.9, 0.375, 0
5843, 0.8875, 0.39, 0
5844, 0.9, 0.405, 0
5845, 0.8875, 0.42, 0
5846, 0.9, 0.435, 0
5847, 0.8875, 0.45, 0
5848, 0.9, 0.465, 0
5849, 0.8875, 0.48, 0
5850, 0.9, 0.495, 0
5851, 0.8875, 0.51, 0
5852, 0.9, 0.525, 0
5853, 0.8875, 0.54, 0
5854, 0.9, 0.555, 0
5855, 0.8875, 0.57, 0
5856, 0.9, 0.585, 0
5857, 0.8875, 0.6, 0
5858, 0.9, 0.615, 0
5859, 0.8875, 0.63, 0
5860, 0.9, 0.645, 0
5861, 0.8875, 0.66, 0
5862, 0.9, 0.675, 0
5863, 0.8875, 0.69, 0
5864, 0.9, 0.705, 0
5865, 0.8875, 0.72, 0
5866, 0.9, 0.735, 0
5867, 0.8875, 0.75, 0
5868, 0.9, 0.765, 0
5869, 0.8875, 0.78, 0
5870, 0.9, 0.795, 0
5871, 0.8875, 0.81, 0
5872, 0.9, 0.825, 0
5873, 0.8875, 0.84, 0
5874, 0.9, 0.855, 0
5875, 0.8875, 0.87, 0
5876, 0.9, 0.885, 0
5877, 0.8875, 0.9, 0
5878, 0.9, 0.915, 0
5879, 0.8875, 0.93, 0
5880, 0.9, 0.945, 0
5881, 0.8875, 0.96, 0
5882, 0.9, 0.975, 0
5883, 0.8875, 0.99, 0
5884, 0.9, 1.005, 0
5885, 0.8875, 1.02, 0
5886, 0.9, 1.035, 0
5887, 0.8875, 1.05, 0
5888, 0.9, 1.065, 0
5889, 0.8875, 1.08, 0
5890, 0.9, 1.095, 0
5891, 0.8875, 1.11, 0
5892, 0.9, 1.125, 0
5893, 0.8875, 1.14, 0
5894, 0.9, 1.155, 0
5895, 0.8875, 1.17, 0
5896, 0.9, 1.185, 0
5897, 0.925, 0.015, 0
5898, 0.9125, 0.03, 0
5899, 0.925, 0.045, 0
5900, 0.9125, 0.06, 0
5901, 0.925, 0.075, 0
5902, 0.9125, 0.09, 0
5903, 0.925, 0.105, 0
5904, 0.9125, 0.12, 0
5905, 0.925, 0.135, 0
5906, 0.9125, 0.15, 0
5907, 0.925, 0.165, 0
5908, 0.9125, 0.18, 0
5909, 0.925, 0.195, 0
5910, 0.9125, 0.21, 0
5911, 0.925, 0.225, 0
5912, 0.9125, 0.24, 0
5913, 0.925, 0.255, 0
5914, 0.9125, 0.27, 0
5915, 0.925, 0.285, 0
5916, 0.9125, 0.3, 0
5917, 0.925, 0.315, 0
5918, 0.9125, 0.33, 0
5919, 0.925, 0.345, 0
5920, 0.9125, 0.36, 0
5921, 0.925, 0.375, 0
5922, 0.9125, 0.39, 0
5923, 0.925, 0.405, 0
5924, 0.9125, 0.42, 0
5925, 0.925, 0.435, 0
5926, 0.9125, 0.45, 0
5927, 0.925, 0.465, 0
5928, 0.9125, 0.48, 0
5929, 0.925, 0.495, 0
5930, 0.9125, 0.51, 0
5931, 0.925, 0.525, 0
5932, 0.9125, 0.54, 0
5933, 0.925, 0.555, 0
5934, 0.9125, 0.57, 0
5935, 0.925, 0.585, 0
5936, 0.9125, 0.6, 0
5937, 0.925, 0.615, 0
5938, 0.9125, 0.63, 0
5939, 0.925, 0.645, 0
5940, 0.9125, 0.66, 0
5941, 0.925, 0.675, 0
5942, 0.9125, 0.69, 0
5943, 0.925, 0.705, 0
5944, 0.9125, 0.72, 0
5945, 0.925, 0.735, 0
5946, 0.9125, 0.75, 0
5947, 0.925, 0.765, 0
5948, 0.9125, 0.78, 0
5949, 0.925, 0.795, 0
5950, 0.9125, 0.81, 0
5951, 0.925, 0.825, 0
5952, 0.9125, 0.84, 0
5953, 0.925, 0.855, 0
5954, 0.9125, 0.87, 0
5955, 0.925, 0.885, 0
5956, 0.9125, 0.9, 0
5957, 0.925, 0.915, 0
5958, 0.9125, 0.93, 0
5959, 0.925, 0.945, 0
5960, 0.9125, 0.96, 0
5961, 0.925, 0.975, 0
5962, 0.9125, 0.99, 0
5963, 0.925, 1.005, 0
5964, 0.9125, 1.02, 0
5965, 0.925, 1.035, 0
5966, 0.9125, 1.05, 0
5967, 0.925, 1.065, 0
5968, 0.9125, 1.08, 0
5969, 0.925, 1.095, 0
5970, 0.9125, 1.11, 0
5971, 0.925, 1.125, 0
5972, 0.9125, 1.14, 0
5973, 0.925, 1.155, 0
5974, 0.9125, 1.17, 0
5975, 0.925, 1.185, 0
5976, 0.95, 0.015, 0
5977, 0.9375, 0.03, 0
5978, 0.95, 0.045, 0
5979, 0.9375, 0.06, 0
5980, 0.95, 0.075, 0
5981, 0.9375, 0.09, 0
5982, 0.95, 0.105, 0
5983, 0.9375, 0.12, 0
5984, 0.95, 0.135, 0
5985, 0.9375, 0.15, 0
5986, 0.95, 0.165, 0
5987, 0.9375, 0.18, 0
5988, 0.95, 0.195, 0
5989, 0.9375, 0.21, 0
5990, 0.95, 0.225, 0
5991, 0.9375, 0.24, 0
5992, 0.95, 0.255, 0
5993, 0.9375, 0.27, 0
5994, 0.95, 0.285, 0
5995, 0.9375, 0.3, 0
5996, 0.95, 0.315, 0
5997, 0.9375, 0.33, 0
5998, 0.95, 0.345, 0
5999, 0.9375, 0.36, 0
6000, 0.95, 0.375, 0
6001, 0.9375, 0.39, 0
6002, 0.95, 0.405, 0
6003, 0.9375, 0.42, 0
6004, 0.95, 0.435, 0
6005, 0.9375, 0.45, 0
6006, 0.95, 0.465, 0
6007, 0.9375, 0.48, 0
6008, 0.95, 0.495, 0
6009, 0.9375, 0.51, 0
6010, 0.95, 0.525, 0
6011, 0.9375, 0.54, 0
6012, 0.95, 0.555, 0
6013, 0.9375, 0.57, 0
6014, 0.95, 0.585, 0
6015, 0.9375, 0.6, 0
6016, 0.95, 0.615, 0
6017, 0.9375, 0.63, 0
6018, 0.95, 0.645, 0
6019, 0.9375, 0.66, 0
6020, 0.95, 0.675, 0
6021, 0.9375, 0.69, 0
6022, 0.95, 0.705, 0
6023, 0.9375, 0.72, 0
6024, 0.95, 0.735, 0
6025, 0.9375, 0.75, 0
6026, 0.95, 0.765, 0
6027, 0.9375, 0.78, 0
6028, 0.95, 0.795, 0
6029, 0.9375, 0.81, 0
6030, 0.95, 0.825, 0
6031, 0.9375, 0.84, 0
6032, 0.95, 0.855, 0
6033, 0.9375, 0.87, 0
6034, 0.95, 0.885, 0
6035, 0.9375, 0.9, 0
6036, 0.95, 0.915, 0
6037, 0.9375, 0.93, 0
6038, 0.95, 0.945, 0
6039, 0.9375, 0.96, 0
6040, 0.95, 0.975, 0
6041, 0.9375, 0.99, 0
6042, 0.95, 1.005, 0
6043, 0.9375, 1.02, 0
6044, 0.95, 1.035, 0
6045, 0.9375, 1.05, 0
6046, 0.95, 1.065, 0
6047, 0.9375, 1.08, 0
6048, 0.95, 1.095, 0
6049, 0.9375, 1.11, 0
6050, 0.95, 1.125, 0
6051, 0.9375, 1.14, 0
6052, 0.95, 1.155, 0
6053, 0.9375, 1.17, 0
6054, 0.95, 1.185, 0
6055, 0.975, 0.015, 0
6056, 0.9625, 0.03, 0
6057, 0.975, 0.045, 0
6058, 0.9625, 0.06, 0
6059, 0.975, 0.075, 0
6060, 0.9625, 0.09, 0
6061, 0.975, 0.105, 0
6062, 0.9625, 0.12, 0
6063, 0.975, 0.135, 0
6064, 0.9625, 0.15, 0
6065, 0.975, 0.165, 0
6066, 0.9625, 0.18, 0
6067, 0.975, 0.195, 0
6068, 0.9625, 0.21, 0
6069, 0.975, 0.225, 0
6070, 0.9625, 0.24, 0
6071, 0.975, 0.255, 0
6072, 0.9625, 0.27, 0
6073, 0.975, 0.285, 0
6074, 0.9625, 0.3, 0
6075, 0.975, 0.315, 0
6076, 0.9625, 0.33, 0
6077, 0.975, 0.345, 0
6078, 0.9625, 0.36, 0
6079, 0.975, 0.375, 0
6080, 0.9625, 0.39, 0
6081, 0.975, 0.405, 0
6082, 0.9625, 0.42, 0
6083, 0.975, 0.435, 0
6084, 0.9625, 0.45, 0
6085, 0.975, 0.465, 0
6086, 0.9625, 0.48, 0
6087, 0.975, 0.495, 0
6088, 0.9625, 0.51, 0
6089, 0.975, 0.525, 0
6090, 0.9625, 0.54, 0
6091, 0.975, 0.555, 0
6092, 0.9625, 0.57, 0
6093, 0.975, 0.585, 0
6094, 0.9625, 0.6, 0
6095, 0.975, 0.615, 0
6096, 0.9625, 0.63, 0
6097, 0.975, 0.645, 0
6098, 0.9625, 0.66, 0
6099, 0.975, 0.675, 0
6100, 0.9625, 0.69, 0
6101, 0.975, 0.705, 0
6102, 0.9625, 0.72, 0
6103, 0.975, 0.735, 0
6104, 0.9625, 0.75, 0
6105, 0.975, 0.765, 0
6106, 0.9625, 0.78, 0
6107, 0.975, 0.795, 0
6108, 0.9625, 0.81, 0
6109, 0.975, 0.825, 0
6110, 0.9625, 0.84, 0
6111, 0.975, 0.855, 0
6112, 0.9625, 0.87, 0
6113, 0.975, 0.885, 0
6114, 0.9625, 0.9, 0
6115, 0.975, 0.915, 0
6116, 0.9625, 0.93, 0
6117, 0.975, 0.945, 0
6118, 0.9625, 0.96, 0
6119, 0.975, 0.975, 0
6120, 0.9625, 0.99, 0
6121, 0.975, 1.005, 0
6122, 0.9625, 1.02, 0
6123, 0.975, 1.035, 0
6124, 0.9625, 1.05, 0
6125, 0.975, 1.065, 0
6126, 0.9625, 1.08, 0
6127, 0.975, 1.095, 0
6128, 0.9625, 1.11, 0
6129, 0.975, 1.125, 0
6130, 0.9625, 1.14, 0
6131, 0.975, 1.155, 0
6132, 0.9625, 1.17, 0
6133, 0.975, 1.185, 0
6134, 0.9875, 0.03, 0
6135, 0.9875, 0.06, 0
6136, 0.9875, 0.09, 0
6137, 0.9875, 0.12, 0
6138, 0.9875, 0.15, 0
6139, 0.9875, 0.18, 0
6140, 0.9875, 0.21, 0
6141, 0.9875, 0.24, 0
6142, 0.9875, 0.27, 0
6143, 0.9875, 0.3, 0
6144, 0.9875, 0.33, 0
6145, 0.9875, 0.36, 0
6146, 0.9875, 0.39, 0
6147, 0.9875, 0.42, 0
6148, 0.9875, 0.45, 0
6149, 0.9875, 0.48, 0
6150, 0.9875, 0.51, 0
6151, 0.9875, 0.54, 0
6152, 0.9875, 0.57, 0
6153, 0.9875, 0.6, 0
6154, 0.9875, 0.63, 0
6155, 0.9875, 0.66, 0
6156, 0.9875, 0.69, 0
6157, 0.9875, 0.72, 0
6158, 0.9875, 0.75, 0
6159, 0.9875, 0.78, 0
6160, 0.9875, 0.81, 0
6161, 0.9875, 0.84, 0
6162, 0.9875, 0.87, 0
6163, 0.9875, 0.9, 0
6164, 0.9875, 0.93, 0
6165, 0.9875, 0.96, 0
6166, 0.9875, 0.99, 0
6167, 0.9875, 1.02, 0
6168, 0.9875, 1.05, 0
6169, 0.9875, 1.08, 0
6170, 0.9875, 1.11, 0
6171, 0.9875, 1.14, 0
6172, 0.9875, 1.17, 0
6173, 0.975, 1.22, 0
6174, 0.95, 1.22, 0
6175, 0.925, 1.22, 0
6176, 0.9, 1.22, 0
6177, 0.875, 1.22, 0
6178, 0.85, 1.22, 0
6179, 0.825, 1.22, 0
6180, 0.8, 1.22, 0
6181, 0.775, 1.22, 0
6182, 0.75, 1.22, 0
6183, 0.725, 1.22, 0
6184, 0.7, 1.22, 0
6185, 0.675, 1.22, 0
6186, 0.65, 1.22, 0
6187, 0.625, 1.22, 0
6188, 0.6, 1.22, 0
6189, 0.575, 1.22, 0
6190, 0.55, 1.22, 0
6191, 0.525, 1.22, 0
6192, 0.5, 1.22, 0
6193, 0.475, 1.22, 0
6194, 0.45, 1.22, 0
6195, 0.425, 1.22, 0
6196, 0.4, 1.22, 0
6197, 0.375, 1.22, 0
6198, 0.35, 1.22, 0
6199, 0.325, 1.22, 0
6200, 0.3, 1.22, 0
6201, 0.275, 1.22, 0
6202, 0.25, 1.22, 0
6203, 0.225, 1.22, 0
6204, 0.2, 1.22, 0
6205, 0.175, 1.22, 0
6206, 0.15, 1.22, 0
6207, 0.125, 1.22, 0
6208, 0.1, 1.22, 0
6209, 0.075, 1.22, 0
6210, 0.05, 1.22, 0
6211, 0.025, 1.22, 0
6212, 0.975, 1.24, 0
6213, 0.95, 1.24, 0
6214, 0.925, 1.24, 0
6215, 0.9, 1.24, 0
6216, 0.875, 1.24, 0
6217, 0.85, 1.24, 0
6218, 0.825, 1.24, 0
6219, 0.8, 1.24, 0
6220, 0.775, 1.24, 0
6221, 0.75, 1.24, 0
6222, 0.725, 1.24, 0
6223, 0.7, 1.24, 0
6224, 0.675, 1.24, 0
6225, 0.65, 1.24, 0
6226, 0.625, 1.24, 0
6227, 0.6, 1.24, 0
6228, 0.575, 1.24, 0
6229, 0.55, 1.24, 0
6230, 0.525, 1.24, 0
6231, 0.5, 1.24, 0
6232, 0.475, 1.24, 0
6233, 0.45, 1.24, 0
6234, 0.425, 1.24, 0
6235, 0.4, 1.24, 0
6236, 0.375, 1.24, 0
6237, 0.35, 1.24, 0
6238, 0.325, 1.24, 0
6239, 0.3, 1.24, 0
6240, 0.275, 1.24, 0
6241, 0.25, 1.24, 0
6242, 0.225, 1.24, 0
6243, 0.2, 1.24, 0
6244, 0.175, 1.24, 0
6245, 0.15, 1.24, 0
6246, 0.125, 1.24, 0
6247, 0.1, 1.24, 0
6248, 0.075, 1.24, 0
6249, 0.05, 1.24, 0
6250, 0.025, 1.24, 0
6251, 0.975, 1.26, 0
6252, 0.95, 1.26, 0
6253, 0.925, 1.26, 0
6254, 0.9, 1.26, 0
6255, 0.875, 1.26, 0
6256, 0.85, 1.26, 0
6257, 0.825, 1.26, 0
6258, 0.8, 1.26, 0
6259, 0.775, 1.26, 0
6260, 0.75, 1.26, 0
6261, 0.725, 1.26, 0
6262, 0.7, 1.26, 0
6263, 0.675, 1.26, 0
6264, 0.65, 1.26, 0
6265, 0.625, 1.26, 0
6266, 0.6, 1.26, 0
6267, 0.575, 1.26, 0
6268, 0.55, 1.26, 0
6269, 0.525, 1.26, 0
6270, 0.5, 1.26, 0
6271, 0.475, 1.26, 0
6272, 0.45, 1.26, 0
6273, 0.425, 1.26, 0
6274, 0.4, 1.26, 0
6275, 0.375, 1.26, 0
6276, 0.35, 1.26, 0
6277, 0.325, 1.26, 0
6278, 0.3, 1.26, 0
6279, 0.275, 1.26, 0
6280, 0.25, 1.26, 0
6281, 0.225, 1.26, 0
6282, 0.2, 1.26, 0
6283, 0.175, 1.26, 0
6284, 0.15, 1.26, 0
6285, 0.125, 1.26, 0
6286, 0.1, 1.26, 0
6287, 0.075, 1.26, 0
6288, 0.05, 1.26, 0
6289, 0.025, 1.26, 0
6290, 0.975, 1.28, 0
6291, 0.95, 1.28, 0
6292, 0.925, 1.28, 0
6293, 0.9, 1.28, 0
6294, 0.875, 1.28, 0
6295, 0.85, 1.28, 0
6296, 0.825, 1.28, 0
6297, 0.8, 1.28, 0
6298, 0.775, 1.28, 0
6299, 0.75, 1.28, 0
6300, 0.725, 1.28, 0
6301, 0.7, 1.28, 0
6302, 0.675, 1.28, 0
6303, 0.65, 1.28, 0
6304, 0.625, 1.28, 0
6305, 0.6, 1.28, 0
6306, 0.575, 1.28, 0
6307, 0.55, 1.28, 0
6308, 0.525, 1.28, 0
6309, 0.5, 1.28, 0
6310, 0.475, 1.28, 0
6311, 0.45, 1.28, 0
6312, 0.425, 1.28, 0
6313, 0.4, 1.28, 0
6314, 0.375, 1.28, 0
6315, 0.35, 1.28, 0
6316, 0.325, 1.28, 0
6317, 0.3, 1.28, 0
6318, 0.275, 1.28, 0
6319, 0.25, 1.28, 0
6320, 0.225, 1.28, 0
6321, 0.2, 1.28, 0
6322, 0.175, 1.28, 0
6323, 0.15, 1.28, 0
6324, 0.125, 1.28, 0
6325, 0.1, 1.28, 0
6326, 0.075, 1.28, 0
6327, 0.05, 1.28, 0
6328, 0.025, 1.28, 0
6329, 0.9875, 1.22, 0
6330, 0.975, 1.21, 0
6331, 0.9625, 1.22, 0
6332, 0.95, 1.21, 0
6333, 0.9375, 1.22, 0
6334, 0.925, 1.21, 0
6335, 0.9125, 1.22, 0
6336, 0.9, 1.21, 0
6337, 0.8875, 1.22, 0
6338, 0.875, 1.21, 0
6339, 0.8625, 1.22, 0
6340, 0.85, 1.21, 0
6341, 0.8375, 1.22, 0
6342, 0.825, 1.21, 0
6343, 0.8125, 1.22, 0
6344, 0.8, 1.21, 0
6345, 0.7875, 1.22, 0
6346, 0.775, 1.21, 0
6347, 0.7625, 1.22, 0
6348, 0.75, 1.21, 0
6349, 0.7375, 1.22, 0
6350, 0.725, 1.21, 0
6351, 0.7125, 1.22, 0
6352, 0.7, 1.21, 0
6353, 0.6875, 1.22, 0
6354, 0.675, 1.21, 0
6355, 0.6625, 1.22, 0
6356, 0.65, 1.21, 0
6357, 0.6375, 1.22, 0
6358, 0.625, 1.21, 0
6359, 0.6125, 1.22, 0
6360, 0.6, 1.21, 0
6361, 0.5875, 1.22, 0
6362, 0.575, 1.21, 0
6363, 0.5625, 1.22, 0
6364, 0.55, 1.21, 0
6365, 0.5375, 1.22, 0
6366, 0.525, 1.21, 0
6367, 0.5125, 1.22, 0
6368, 0.5, 1.21, 0
6369, 0.4875, 1.22, 0
6370, 0.475, 1.21, 0
6371, 0.4625, 1.22, 0
6372, 0.45, 1.21, 0
6373, 0.4375, 1.22, 0
6374, 0.425, 1.21, 0
6375, 0.4125, 1.22, 0
6376, 0.4, 1.21, 0
6377, 0.3875, 1.22, 0
6378, 0.375, 1.21, 0
6379, 0.3625, 1.22, 0
6380, 0.35, 1.21, 0
6381, 0.3375, 1.22, 0
6382, 0.325, 1.21, 0
6383, 0.3125, 1.22, 0
6384, 0.3, 1.21, 0
6385, 0.2875, 1.22, 0
6386, 0.275, 1.21, 0
6387, 0.2625, 1.22, 0
6388, 0.25, 1.21, 0
6389, 0.2375, 1.22, 0
6390, 0.225, 1.21, 0
6391, 0.2125, 1.22, 0
6392, 0.2, 1.21, 0
6393, 0.1875, 1.22, 0
6394, 0.175, 1.21, 0
6395, 0.1625, 1.22, 0
6396, 0.15, 1.21, 0
6397, 0.1375, 1.22, 0
6398, 0.125, 1.21, 0
6399, 0.1125, 1.22, 0
6400, 0.1, 1.21, 0
6401, 0.0875, 1.22, 0
6402, 0.075, 1.21, 0
6403, 0.0625, 1.22, 0
6404, 0.05, 1.21, 0
6405, 0.0375, 1.22, 0
6406, 0.025, 1.21, 0
6407, 0.0125, 1.22, 0
6408, 0.9875, 1.24, 0
6409, 0.975, 1.23, 0
6410, 0.9625, 1.24, 0
6411, 0.95, 1.23, 0
6412, 0.9375, 1.24, 0
6413, 0.925, 1.23, 0
6414, 0.9125, 1.24, 0
6415, 0.9, 1.23, 0
6416, 0.8875, 1.24, 0
6417, 0.875, 1.23, 0
6418, 0.8625, 1.24, 0
6419, 0.85, 1.23, 0
6420, 0.8375, 1.24, 0
6421, 0.825, 1.23, 0
6422, 0.8125, 1.24, 0
6423, 0.8, 1.23, 0
6424, 0.7875, 1.24, 0
6425, 0.775, 1.23, 0
6426, 0.7625, 1.24, 0
6427, 0.75, 1.23, 0
6428, 0.7375, 1.24, 0
6429, 0.725, 1.23, 0
6430, 0.7125, 1.24, 0
6431, 0.7, 1.23, 0
6432, 0.6875, 1.24, 0
6433, 0.675, 1.23, 0
6434, 0.6625, 1.24, 0
6435, 0.65, 1.23, 0
6436, 0.6375, 1.24, 0
6437, 0.625, 1.23, 0
6438, 0.6125, 1.24, 0
6439, 0.6, 1.23, 0
6440, 0.5875, 1.24, 0
6441, 0.575, 1.23, 0
6442, 0.5625, 1.24, 0
6443, 0.55, 1.23, 0
6444, 0.5375, 1.24, 0
6445, 0.525, 1.23, 0
6446, 0.5125, 1.24, 0
6447, 0.5, 1.23, 0
6448, 0.4875, 1.24, 0
6449, 0.475, 1.23, 0
6450, 0.4625, 1.24, 0
6451, 0.45, 1.23, 0
6452, 0.4375, 1.24, 0
6453, 0.425, 1.23, 0
6454, 0.4125, 1.24, 0
6455, 0.4, 1.23, 0
6456, 0.3875, 1.24, 0
6457, 0.375, 1.23, 0
6458, 0.3625, 1.24, 0
6459, 0.35, 1.23, 0
6460, 0.3375, 1.24, 0
6461, 0.325, 1.23, 0
6462, 0.3125, 1.24, 0
6463, 0.3, 1.23, 0
6464, 0.2875, 1.24, 0
6465, 0.275, 1.23, 0
6466, 0.2625, 1.24, 0
6467, 0.25, 1.23, 0
6468, 0.2375, 1.24, 0
6469, 0.225, 1.23, 0
6470, 0.2125, 1.24, 0
6471, 0.2, 1.23, 0
6472, 0.1875, 1.24, 0
6473, 0.175, 1.23, 0
6474, 0.1625, 1.24, 0
6475, 0.15, 1.23, 0
6476, 0.1375, 1.24, 0
6477, 0.125, 1.23, 0
6478, 0.1125, 1.24, 0
6479, 0.1, 1.23, 0
6480, 0.0875, 1.24, 0
6481, 0.075, 1.23, 0
6482, 0.0625, 1.24, 0
6483, 0.05, 1.23, 0
6484, 0.0375, 1.24, 0
6485, 0.025, 1.23, 0
6486, 0.0125, 1.24, 0
6487, 0.9875, 1.26, 0
6488, 0.975, 1.25, 0
6489, 0.9625, 1.26, 0
6490, 0.95, 1.25, 0
6491, 0.9375, 1.26, 0
6492, 0.925, 1.25, 0
6493, 0.9125, 1.26, 0
6494, 0.9, 1.25, 0
6495, 0.8875, 1.26, 0
6496, 0.875, 1.25, 0
6497, 0.8625, 1.26, 0
6498, 0.85, 1.25, 0
6499, 0.8375, 1.26, 0
6500, 0.825, 1.25, 0
6501, 0.8125, 1.26, 0
6502, 0.8, 1.25, 0
6503, 0.7875, 1.26, 0
6504, 0.775, 1.25, 0
6505, 0.7625, 1.26, 0
6506, 0.75, 1.25, 0
6507, 0.7375, 1.26, 0
6508, 0.725, 1.25, 0
6509, 0.7125, 1.26, 0
6510, 0.7, 1.25, 0
6511, 0.6875, 1.26, 0
6512, 0.675, 1.25, 0
6513, 0.6625, 1.26, 0
6514, 0.65, 1.25, 0
6515, 0.6375, 1.26, 0
6516, 0.625, 1.25, 0
6517, 0.6125, 1.26, 0
6518, 0.6, 1.25, 0
6519, 0.5875, 1.26, 0
6520, 0.575, 1.25, 0
6521, 0.5625, 1.26, 0
6522, 0.55, 1.25, 0
6523, 0.5375, 1.26, 0
6524, 0.525, 1.25, 0
6525, 0.5125, 1.26, 0
6526, 0.5, 1.25, 0
6527, 0.4875, 1.26, 0
6528, 0.475, 1.25, 0
6529, 0.4625, 1.26, 0
6530, 0.45, 1.25, 0
6531, 0.4375, 1.26, 0
6532, 0.425, 1.25, 0
6533, 0.4125, 1.26, 0
6534, 0.4, 1.25, 0
6535, 0.3875, 1.26, 0
6536, 0.375, 1.25, 0
6537, 0.3625, 1.26, 0
6538, 0.35, 1.25, 0
6539, 0.3375, 1.26, 0
6540, 0.325, 1.25, 0
6541, 0.3125, 1.26, 0
6542, 0.3, 1.25, 0
6543, 0.2875, 1.26, 0
6544, 0.275, 1.25, 0
6545, 0.2625, 1.26, 0
6546, 0.25, 1.25, 0
6547, 0.2375, 1.26, 0
6548, 0.225, 1.25, 0
6549, 0.2125, 1.26, 0
6550, 0.2, 1.25, 0
6551, 0.1875, 1.26, 0
6552, 0.175, 1.25, 0
6553, 0.1625, 1.26, 0
6554, 0.15, 1.25, 0
6555, 0.1375, 1.26, 0
6556, 0.125, 1.25, 0
6557, 0.1125, 1.26, 0
6558, 0.1, 1.25, 0
6559, 0.0875, 1.26, 0
6560, 0.075, 1.25, 0
6561, 0.0625, 1.26, 0
6562, 0.05, 1.25, 0
6563, 0.0375, 1.26, 0
6564, 0.025, 1.25, 0
6565, 0.0125, 1.26, 0
6566, 0.9875, 1.28, 0
6567, 0.975, 1.27, 0
6568, 0.9625, 1.28, 0
6569, 0.95, 1.27, 0
6570, 0.9375, 1.28, 0
6571, 0.925, 1.27, 0
6572, 0.9125, 1.28, 0
6573, 0.9, 1.27, 0
6574, 0.8875, 1.28, 0
6575, 0.875, 1.27, 0
6576, 0.8625, 1.28, 0
6577, 0.85, 1.27, 0
6578, 0.8375, 1.28, 0
6579, 0.825, 1.27, 0
6580, 0.8125, 1.28, 0
6581, 0.8, 1.27, 0
6582, 0.7875, 1.28, 0
6583, 0.775, 1.27, 0
6584, 0.7625, 1.28, 0
6585, 0.75, 1.27, 0
6586, 0.7375, 1.28, 0
6587, 0.725, 1.27, 0
6588, 0.7125, 1.28, 0
6589, 0.7, 1.27, 0
6590, 0.6875, 1.28, 0
6591, 0.675, 1.27, 0
6592, 0.6625, 1.28, 0
6593, 0.65, 1.27, 0
6594, 0.6375, 1.28, 0
6595, 0.625, 1.27, 0
6596, 0.6125, 1.28, 0
6597, 0.6, 1.27, 0
6598, 0.5875, 1.28, 0
6599, 0.575, 1.27, 0
6600, 0.5625, 1.28, 0
6601, 0.55, 1.27, 0
6602, 0.5375, 1.28, 0
6603, 0.525, 1.27, 0
6604, 0.5125, 1.28, 0
6605, 0.5, 1.27, 0
6606, 0.4875, 1.28, 0
6607, 0.475, 1.27, 0
6608, 0.4625, 1.28, 0
6609, 0.45, 1.27, 0
6610, 0.4375, 1.28, 0
6611, 0.425, 1.27, 0
6612, 0.4125, 1.28, 0
6613, 0.4, 1.27, 0
6614, 0.3875, 1.28, 0
6615, 0.375, 1.27, 0
6616, 0.3625, 1.28, 0
6617, 0.35, 1.27, 0
6618, 0.3375, 1.28, 0
6619, 0.325, 1.27, 0
6620, 0.3125, 1.28, 0
6621, 0.3, 1.27, 0
6622, 0.2875, 1.28, 0
6623, 0.275, 1.27, 0
6624, 0.2625, 1.28, 0
6625, 0.25, 1.27, 0
6626, 0.2375, 1.28, 0
6627, 0.225, 1.27, 0
6628, 0.2125, 1.28, 0
6629, 0.2, 1.27, 0
6630, 0.1875, 1.28, 0
6631, 0.175, 1.27, 0
6632, 0.1625, 1.28, 0
6633, 0.15, 1.27, 0
6634, 0.1375, 1.28, 0
6635, 0.125, 1.27, 0
6636, 0.1125, 1.28, 0
6637, 0.1, 1.27, 0
6638, 0.0875, 1.28, 0
6639, 0.075, 1.27, 0
6640, 0.0625, 1.28, 0
6641, 0.05, 1.27, 0
6642, 0.0375, 1.28, 0
6643, 0.025, 1.27, 0
6644, 0.0125, 1.28, 0
6645, 0.975, 1.29, 0
6646, 0.95, 1.29, 0
6647, 0.925, 1.29, 0
6648, 0.9, 1.29, 0
6649, 0.875, 1.29, 0
6650, 0.85, 1.29, 0
6651, 0.825, 1.29, 0
6652, 0.8, 1.29, 0
6653, 0.775, 1.29, 0
6654, 0.75, 1.29, 0
6655, 0.725, 1.29, 0
6656, 0.7, 1.29, 0
6657, 0.675, 1.29, 0
6658, 0.65, 1.29, 0
6659, 0.625, 1.29, 0
6660, 0.6, 1.29, 0
6661, 0.575, 1.29, 0
6662, 0.55, 1.29, 0
6663, 0.525, 1.29, 0
6664, 0.5, 1.29, 0
6665, 0.475, 1.29, 0
6666, 0.45, 1.29, 0
6667, 0.425, 1.29, 0
6668, 0.4, 1.29, 0
6669, 0.375, 1.29, 0
6670, 0.35, 1.29, 0
6671, 0.325, 1.29, 0
6672, 0.3, 1.29, 0
6673, 0.275, 1.29, 0
6674, 0.25, 1.29, 0
6675, 0.225, 1.29, 0
6676, 0.2, 1.29, 0
6677, 0.175, 1.29, 0
6678, 0.15, 1.29, 0
6679, 0.125, 1.29, 0
6680, 0.1, 1.29, 0
6681, 0.075, 1.29, 0
6682, 0.05, 1.29, 0
6683, 0.025, 1.29, 0
6684, 1.04, 1.22, 0
6685, 1.04, 1.24, 0
6686, 1.04, 1.26, 0
6687, 1.04, 1.28, 0
6688, 1.08, 1.22, 0
6689, 1.08, 1.24, 0
6690, 1.08, 1.26, 0
6691, 1.08, 1.28, 0
6692, 1.12, 1.22, 0
6693, 1.12, 1.24, 0
6694, 1.12, 1.26, 0
6695, 1.12, 1.28, 0
6696, 1.16, 1.22, 0
6697, 1.16, 1.24, 0
6698, 1.16, 1.26, 0
6699, 1.16, 1.28, 0
6700, 1.04, 1.21, 0
6701, 1.02, 1.22, 0
6702, 1.04, 1.23, 0
6703, 1.02, 1.24, 0
6704, 1.04, 1.25, 0
6705, 1.02, 1.26, 0
6706, 1.04, 1.27, 0
6707, 1.02, 1.28, 0
6708, 1.04, 1.29, 0
6709, 1.08, 1.21, 0
6710, 1.06, 1.22, 0
6711, 1.08, 1.23, 0
6712, 1.06, 1.24, 0
6713, 1.08, 1.25, 0
6714, 1.06, 1.26, 0
6715, 1.08, 1.27, 0
6716, 1.06, 1.28, 0
6717, 1.08, 1.29, 0
6718, 1.12, 1.21, 0
6719, 1.1, 1.22, 0
6720, 1.12, 1.23, 0
6721, 1.1, 1.24, 0
6722, 1.12, 1.25, 0
6723, 1.1, 1.26, 0
6724, 1.12, 1.27, 0
6725, 1.1, 1.28, 0
6726, 1.12, 1.29, 0
6727, 1.16, 1.21, 0
6728, 1.14, 1.22, 0
6729, 1.16, 1.23, 0
6730, 1.14, 1.24, 0
6731, 1.16, 1.25, 0
6732, 1.14, 1.26, 0
6733, 1.16, 1.27, 0
6734, 1.14, 1.28, 0
6735, 1.16, 1.29, 0
6736, 1.18, 1.22, 0
6737, 1.18, 1.24, 0
6738, 1.18, 1.26, 0
6739, 1.18, 1.28, 0
6740, 1.225, 1.22, 0
6741, 1.225, 1.24, 0
6742, 1.225, 1.26, 0
6743, 1.225, 1.28, 0
6744, 1.25, 1.22, 0
6745, 1.25, 1.24, 0
6746, 1.25, 1.26, 0
6747, 1.25, 1.28, 0
6748, 1.275, 1.22, 0
6749, 1.275, 1.24, 0
6750, 1.275, 1.26, 0
6751, 1.275, 1.28, 0
6752, 1.3, 1.22, 0
6753, 1.3, 1.24, 0
6754, 1.3, 1.26, 0
6755, 1.3, 1.28, 0
6756, 1.325, 1.22, 0
6757, 1.325, 1.24, 0
6758, 1.325, 1.26, 0
6759, 1.325, 1.28, 0
6760, 1.35, 1.22, 0
6761, 1.35, 1.24, 0
6762, 1.35, 1.26, 0
6763, 1.35, 1.28, 0
6764, 1.375, 1.22, 0
6765, 1.375, 1.24, 0
6766, 1.375, 1.26, 0
6767, 1.375, 1.28, 0
6768, 1.4, 1.22, 0
6769, 1.4, 1.24, 0
6770, 1.4, 1.26, 0
6771, 1.4, 1.28, 0
6772, 1.425, 1.22, 0
6773, 1.425, 1.24, 0
6774, 1.425, 1.26, 0
6775, 1.425, 1.28, 0
6776, 1.45, 1.22, 0
6777, 1.45, 1.24, 0
6778, 1.45, 1.26, 0
6779, 1.45, 1.28, 0
6780, 1.475, 1.22, 0
6781, 1.475, 1.24, 0
6782, 1.475, 1.26, 0
6783, 1.475, 1.28, 0
6784, 1.5, 1.22, 0
6785, 1.5, 1.24, 0
6786, 1.5, 1.26, 0
6787, 1.5, 1.28, 0
6788, 1.525, 1.22, 0
6789, 1.525, 1.24, 0
6790, 1.525, 1.26, 0
6791, 1.525, 1.28, 0
6792, 1.55, 1.22, 0
6793, 1.55, 1.24, 0
6794, 1.55, 1.26, 0
6795, 1.55, 1.28, 0
6796, 1.575, 1.22, 0
6797, 1.575, 1.24, 0
6798, 1.575, 1.26, 0
6799, 1.575, 1.28, 0
6800, 1.6, 1.22, 0
6801, 1.6, 1.24, 0
6802, 1.6, 1.26, 0
6803, 1.6, 1.28, 0
6804, 1.625, 1.22, 0
6805, 1.625, 1.24, 0
6806, 1.625, 1.26, 0
6807, 1.625, 1.28, 0
6808, 1.65, 1.22, 0
6809, 1.65, 1.24, 0
6810, 1.65, 1.26, 0
6811, 1.65, 1.28, 0
6812, 1.675, 1.22, 0
6813, 1.675, 1.24, 0
6814, 1.675, 1.26, 0
6815, 1.675, 1.28, 0
6816, 1.7, 1.22, 0
6817, 1.7, 1.24, 0
6818, 1.7, 1.26, 0
6819, 1.7, 1.28, 0
6820, 1.725, 1.22, 0
6821, 1.725, 1.24, 0
6822, 1.725, 1.26, 0
6823, 1.725, 1.28, 0
6824, 1.75, 1.22, 0
6825, 1.75, 1.24, 0
6826, 1.75, 1.26, 0
6827, 1.75, 1.28, 0
6828, 1.775, 1.22, 0
6829, 1.775, 1.24, 0
6830, 1.775, 1.26, 0
6831, 1.775, 1.28, 0
6832, 1.8, 1.22, 0
6833, 1.8, 1.24, 0
6834, 1.8, 1.26, 0
6835, 1.8, 1.28, 0
6836, 1.825, 1.22, 0
6837, 1.825, 1.24, 0
6838, 1.825, 1.26, 0
6839, 1.825, 1.28, 0
6840, 1.85, 1.22, 0
6841, 1.85, 1.24, 0
6842, 1.85, 1.26, 0
6843, 1.85, 1.28, 0
6844, 1.875, 1.22, 0
6845, 1.875, 1.24, 0
6846, 1.875, 1.26, 0
6847, 1.875, 1.28, 0
6848, 1.9, 1.22, 0
6849, 1.9, 1.24, 0
6850, 1.9, 1.26, 0
6851, 1.9, 1.28, 0
6852, 1.925, 1.22, 0
6853, 1.925, 1.24, 0
6854, 1.925, 1.26, 0
6855, 1.925, 1.28, 0
6856, 1.95, 1.22, 0
6857, 1.95, 1.24, 0
6858, 1.95, 1.26, 0
6859, 1.95, 1.28, 0
6860, 1.975, 1.22, 0
6861, 1.975, 1.24, 0
6862, 1.975, 1.26, 0
6863, 1.975, 1.28, 0
6864, 2, 1.22, 0
6865, 2, 1.24, 0
6866, 2, 1.26, 0
6867, 2, 1.28, 0
6868, 2.025, 1.22, 0
6869, 2.025, 1.24, 0
6870, 2.025, 1.26, 0
6871, 2.025, 1.28, 0
6872, 2.05, 1.22, 0
6873, 2.05, 1.24, 0
6874, 2.05, 1.26, 0
6875, 2.05, 1.28, 0
6876, 2.075, 1.22, 0
6877, 2.075, 1.24, 0
6878, 2.075, 1.26, 0
6879, 2.075, 1.28, 0
6880, 2.1, 1.22, 0
6881, 2.1, 1.24, 0
6882, 2.1, 1.26, 0
6883, 2.1, 1.28, 0
6884, 2.125, 1.22, 0
6885, 2.125, 1.24, 0
6886, 2.125, 1.26, 0
6887, 2.125, 1.28, 0
6888, 2.15, 1.22, 0
6889, 2.15, 1.24, 0
6890, 2.15, 1.26, 0
6891, 2.15, 1.28, 0
6892, 2.175, 1.22, 0
6893, 2.175, 1.24, 0
6894, 2.175, 1.26, 0
6895, 2.175, 1.28, 0
6896, 1.225, 1.21, 0
6897, 1.2125, 1.22, 0
6898, 1.225, 1.23, 0
6899, 1.2125, 1.24, 0
6900, 1.225, 1.25, 0
6901, 1.2125, 1.26, 0
6902, 1.225, 1.27, 0
6903, 1.2125, 1.28, 0
6904, 1.225, 1.29, 0
6905, 1.25, 1.21, 0
6906, 1.2375, 1.22, 0
6907, 1.25, 1.23, 0
6908, 1.2375, 1.24, 0
6909, 1.25, 1.25, 0
6910, 1.2375, 1.26, 0
6911, 1.25, 1.27, 0
6912, 1.2375, 1.28, 0
6913, 1.25, 1.29, 0
6914, 1.275, 1.21, 0
6915, 1.2625, 1.22, 0
6916, 1.275, 1.23, 0
6917, 1.2625, 1.24, 0
6918, 1.275, 1.25, 0
6919, 1.2625, 1.26, 0
6920, 1.275, 1.27, 0
6921, 1.2625, 1.28, 0
6922, 1.275, 1.29, 0
6923, 1.3, 1.21, 0
6924, 1.2875, 1.22, 0
6925, 1.3, 1.23, 0
6926, 1.2875, 1.24, 0
6927, 1.3, 1.25, 0
6928, 1.2875, 1.26, 0
6929, 1.3, 1.27, 0
6930, 1.2875, 1.28, 0
6931, 1.3, 1.29, 0
6932, 1.325, 1.21, 0
6933, 1.3125, 1.22, 0
6934, 1.325, 1.23, 0
6935, 1.3125, 1.24, 0
6936, 1.325, 1.25, 0
6937, 1.3125, 1.26, 0
6938, 1.325, 1.27, 0
6939, 1.3125, 1.28, 0
6940, 1.325, 1.29, 0
6941, 1.35, 1.21, 0
6942, 1.3375, 1.22, 0
6943, 1.35, 1.23, 0
6944, 1.3375, 1.24, 0
6945, 1.35, 1.25, 0
6946, 1.3375, 1.26, 0
6947, 1.35, 1.27, 0
6948, 1.3375, 1.28, 0
6949, 1.35, 1.29, 0
6950, 1.375, 1.21, 0
6951, 1.3625, 1.22, 0
6952, 1.375, 1.23, 0
6953, 1.3625, 1.24, 0
6954, 1.375, 1.25, 0
6955, 1.3625, 1.26, 0
6956, 1.375, 1.27, 0
6957, 1.3625, 1.28, 0
6958, 1.375, 1.29, 0
6959, 1.4, 1.21, 0
6960, 1.3875, 1.22, 0
6961, 1.4, 1.23, 0
6962, 1.3875, 1.24, 0
6963, 1.4, 1.25, 0
6964, 1.3875, 1.26, 0
6965, 1.4, 1.27, 0
6966, 1.3875, 1.28, 0
6967, 1.4, 1.29, 0
6968, 1.425, 1.21, 0
6969, 1.4125, 1.22, 0
6970, 1.425, 1.23, 0
6971, 1.4125, 1.24, 0
6972, 1.425, 1.25, 0
6973, 1.4125, 1.26, 0
6974, 1.425, 1.27, 0
6975, 1.4125, 1.28, 0
6976, 1.425, 1.29, 0
6977, 1.45, 1.21, 0
6978, 1.4375, 1.22, 0
6979, 1.45, 1.23, 0
6980, 1.4375, 1.24, 0
6981, 1.45, 1.25, 0
6982, 1.4375, 1.26, 0
6983, 1.45, 1.27, 0
6984, 1.4375, 1.28, 0
6985, 1.45, 1.29, 0
6986, 1.475, 1.21, 0
6987, 1.4625, 1.22, 0
6988, 1.475, 1.23, 0
6989, 1.4625, 1.24, 0
6990, 1.475, 1.25, 0
6991, 1.4625, 1.26, 0
6992, 1.475, 1.27, 0
6993, 1.4625, 1.28, 0
6994, 1.475, 1.29, 0
6995, 1.5, 1.21, 0
6996, 1.4875, 1.22, 0
6997, 1.5, 1.23, 0
6998, 1.4875, 1.24, 0
6999, 1.5, 1.25, 0
7000, 1.4875, 1.26, 0
7001, 1.5, 1.27, 0
7002, 1.4875, 1.28, 0
7003, 1.5, 1.29, 0
7004, 1.525, 1.21, 0
7005, 1.5125, 1.22, 0
7006, 1.525, 1.23, 0
7007, 1.5125, 1.24, 0
7008, 1.525, 1.25, 0
7009, 1.5125, 1.26, 0
7010, 1.525, 1.27, 0
7011, 1.5125, 1.28, 0
7012, 1.525, 1.29, 0
7013, 1.55, 1.21, 0
7014, 1.5375, 1.22, 0
7015, 1.55, 1.23, 0
7016, 1.5375, 1.24, 0
7017, 1.55, 1.25, 0
7018, 1.5375, 1.26, 0
7019, 1.55, 1.27, 0
7020, 1.5375, 1.28, 0
7021, 1.55, 1.29, 0
7022, 1.575, 1.21, 0
7023, 1.5625, 1.22, 0
7024, 1.575, 1.23, 0
7025, 1.5625, 1.24, 0
7026, 1.575, 1.25, 0
7027, 1.5625, 1.26, 0
7028, 1.575, 1.27, 0
7029, 1.5625, 1.28, 0
7030, 1.575, 1.29, 0
7031, 1.6, 1.21, 0
7032, 1.5875, 1.22, 0
7033, 1.6, 1.23, 0
7034, 1.5875, 1.24, 0
7035, 1.6, 1.25, 0
7036, 1.5875, 1.26, 0
7037, 1.6, 1.27, 0
7038, 1.5875, 1.28, 0
7039, 1.6, 1.29, 0
7040, 1.625, 1.21, 0
7041, 1.6125, 1.22, 0
7042, 1.625, 1.23, 0
7043, 1.6125, 1.24, 0
7044, 1.625, 1.25, 0
7045, 1.6125, 1.26, 0
7046, 1.625, 1.27, 0
7047, 1.6125, 1.28, 0
7048, 1.625, 1.29, 0
7049, 1.65, 1.21, 0
7050, 1.6375, 1.22, 0
7051, 1.65, 1.23, 0
7052, 1.6375, 1.24, 0
7053, 1.65, 1.25, 0
7054, 1.6375, 1.26, 0
7055, 1.65, 1.27, 0
7056, 1.6375, 1.28, 0
7057, 1.65, 1.29, 0
7058, 1.675, 1.21, 0
7059, 1.6625, 1.22, 0
7060, 1.675, 1.23, 0
7061, 1.6625, 1.24, 0
7062, 1.675, 1.25, 0
7063, 1.6625, 1.26, 0
7064, 1.675, 1.27, 0
7065, 1.6625, 1.28, 0
7066, 1.675, 1.29, 0
7067, 1.7, 1.21, 0
7068, 1.6875, 1.22, 0
7069, 1.7, 1.23, 0
7070, 1.6875, 1.24, 0
7071, 1.7, 1.25, 0
7072, 1.6875, 1.26, 0
7073, 1.7, 1.27, 0
7074, 1.6875, 1.28, 0
7075, 1.7, 1.29, 0
7076, 1.725, 1.21, 0
7077, 1.7125, 1.22, 0
7078, 1.725, 1.23, 0
7079, 1.7125, 1.24, 0
7080, 1.725, 1.25, 0
7081, 1.7125, 1.26, 0
7082, 1.725, 1.27, 0
7083, 1.7125, 1.28, 0
7084, 1.725, 1.29, 0
7085, 1.75, 1.21, 0
7086, 1.7375, 1.22, 0
7087, 1.75, 1.23, 0
7088, 1.7375, 1.24, 0
7089, 1.75, 1.25, 0
7090, 1.7375, 1.26, 0
7091, 1.75, 1.27, 0
7092, 1.7375, 1.28, 0
7093, 1.75, 1.29, 0
7094, 1.775, 1.21, 0
7095, 1.7625, 1.22, 0
7096, 1.775, 1.23, 0
7097, 1.7625, 1.24, 0
7098, 1.775, 1.25, 0
7099, 1.7625, 1.26, 0
7100, 1.775, 1.27, 0
7101, 1.7625, 1.28, 0
7102, 1.775, 1.29, 0
7103, 1.8, 1.21, 0
7104, 1.7875, 1.22, 0
7105, 1.8, 1.23, 0
7106, 1.7875, 1.24, 0
7107, 1.8, 1.25, 0
7108, 1.7875, 1.26, 0
7109, 1.8, 1.27, 0
7110, 1.7875, 1.28, 0
7111, 1.8, 1.29, 0
7112, 1.825, 1.21, 0
7113, 1.8125, 1.22, 0
7114, 1.825, 1.23, 0
7115, 1.8125, 1.24, 0
7116, 1.825, 1.25, 0
7117, 1.8125, 1.26, 0
7118, 1.825, 1.27, 0
7119, 1.8125, 1.28, 0
7120, 1.825, 1.29, 0
7121, 1.85, 1.21, 0
7122, 1.8375, 1.22, 0
7123, 1.85, 1.23, 0
7124, 1.8375, 1.24, 0
7125, 1.85, 1.25, 0
7126, 1.8375, 1.26, 0
7127, 1.85, 1.27, 0
7128, 1.8375, 1.28, 0
7129, 1.85, 1.29, 0
7130, 1.875, 1.21, 0
7131, 1.8625, 1.22, 0
7132, 1.875, 1.23, 0
7133, 1.8625, 1.24, 0
7134, 1.875, 1.25, 0
7135, 1.8625, 1.26, 0
7136, 1.875, 1.27, 0
7137, 1.8625, 1.28, 0
7138, 1.875, 1.29, 0
7139, 1.9, 1.21, 0
7140, 1.8875, 1.22, 0
7141, 1.9, 1.23, 0
7142, 1.8875, 1.24, 0
7143, 1.9, 1.25, 0
7144, 1.8875, 1.26, 0
7145, 1.9, 1.27, 0
7146, 1.8875, 1.28, 0
7147, 1.9, 1.29, 0
7148, 1.925, 1.21, 0
7149, 1.9125, 1.22, 0
7150, 1.925, 1.23, 0
7151, 1.9125, 1.24, 0
7152, 1.925, 1.25, 0
7153, 1.9125, 1.26, 0
7154, 1.925, 1.27, 0
7155, 1.9125, 1.28, 0
7156, 1.925, 1.29, 0
7157, 1.95, 1.21, 0
7158, 1.9375, 1.22, 0
7159, 1.95, 1.23, 0
7160, 1.9375, 1.24, 0
7161, 1.95, 1.25, 0
7162, 1.9375, 1.26, 0
7163, 1.95, 1.27, 0
7164, 1.9375, 1.28, 0
7165, 1.95, 1.29, 0
7166, 1.975, 1.21, 0
7167, 1.9625, 1.22, 0
7168, 1.975, 1.23, 0
7169, 1.9625, 1.24, 0
7170, 1.975, 1.25, 0
7171, 1.9625, 1.26, 0
7172, 1.975, 1.27, 0
7173, 1.9625, 1.28, 0
7174, 1.975, 1.29, 0
7175, 2, 1.21, 0
7176, 1.9875, 1.22, 0
7177, 2, 1.23, 0
7178, 1.9875, 1.24, 0
7179, 2, 1.25, 0
7180, 1.9875, 1.26, 0
7181, 2, 1.27, 0
7182, 1.9875, 1.28, 0
7183, 2, 1.29, 0
7184, 2.025, 1.21, 0
7185, 2.0125, 1.22, 0
7186, 2.025, 1.23, 0
7187, 2.0125, 1.24, 0
7188, 2.025, 1.25, 0
7189, 2.0125, 1.26, 0
7190, 2.025, 1.27, 0
7191, 2.0125, 1.28, 0
7192, 2.025, 1.29, 0
7193, 2.05, 1.21, 0
7194, 2.0375, 1.22, 0
7195, 2.05, 1.23, 0
7196, 2.0375, 1.24, 0
7197, 2.05, 1.25, 0
7198, 2.0375, 1.26, 0
7199, 2.05, 1.27, 0
7200, 2.0375, 1.28, 0
7201, 2.05, 1.29, 0
7202, 2.075, 1.21, 0
7203, 2.0625, 1.22, 0
7204, 2.075, 1.23, 0
7205, 2.0625, 1.24, 0
7206, 2.075, 1.25, 0
7207, 2.0625, 1.26, 0
7208, 2.075, 1.27, 0
7209, 2.0625, 1.28, 0
7210, 2.075, 1.29, 0
7211, 2.1, 1.21, 0
7212, 2.0875, 1.22, 0
7213, 2.1, 1.23, 0
7214, 2.0875, 1.24, 0
7215, 2.1, 1.25, 0
7216, 2.0875, 1.26, 0
7217, 2.1, 1.27, 0
7218, 2.0875, 1.28, 0
7219, 2.1, 1.29, 0
7220, 2.125, 1.21, 0
7221, 2.1125, 1.22, 0
7222, 2.125, 1.23, 0
7223, 2.1125, 1.24, 0
7224, 2.125, 1.25, 0
7225, 2.1125, 1.26, 0
7226, 2.125, 1.27, 0
7227, 2.1125, 1.28, 0
7228, 2.125, 1.29, 0
7229, 2.15, 1.21, 0
7230, 2.1375, 1.22, 0
7231, 2.15, 1.23, 0
7232, 2.1375, 1.24, 0
7233, 2.15, 1.25, 0
7234, 2.1375, 1.26, 0
7235, 2.15, 1.27, 0
7236, 2.1375, 1.28, 0
7237, 2.15, 1.29, 0
7238, 2.175, 1.21, 0
7239, 2.1625, 1.22, 0
7240, 2.175, 1.23, 0
7241, 2.1625, 1.24, 0
7242, 2.175, 1.25, 0
7243, 2.1625, 1.26, 0
7244, 2.175, 1.27, 0
7245, 2.1625, 1.28, 0
7246, 2.175, 1.29, 0
7247, 2.1875, 1.22, 0
7248, 2.1875, 1.24, 0
7249, 2.1875, 1.26, 0
7250, 2.1875, 1.28, 0
7251, 1.225, 1.17, 0
7252, 1.25, 1.17, 0
7253, 1.275, 1.17, 0
7254, 1.3, 1.17, 0
7255, 1.325, 1.17, 0
7256, 1.35, 1.17, 0
7257, 1.375, 1.17, 0
7258, 1.4, 1.17, 0
7259, 1.425, 1.17, 0
7260, 1.45, 1.17, 0
7261, 1.475, 1.17, 0
7262, 1.5, 1.17, 0
7263, 1.525, 1.17, 0
7264, 1.55, 1.17, 0
7265, 1.575, 1.17, 0
7266, 1.6, 1.17, 0
7267, 1.625, 1.17, 0
7268, 1.65, 1.17, 0
7269, 1.675, 1.17, 0
7270, 1.7, 1.17, 0
7271, 1.725, 1.17, 0
7272, 1.75, 1.17, 0
7273, 1.775, 1.17, 0
7274, 1.8, 1.17, 0
7275, 1.825, 1.17, 0
7276, 1.85, 1.17, 0
7277, 1.875, 1.17, 0
7278, 1.9, 1.17, 0
7279, 1.925, 1.17, 0
7280, 1.95, 1.17, 0
7281, 1.975, 1.17, 0
7282, 2, 1.17, 0
7283, 2.025, 1.17, 0
7284, 2.05, 1.17, 0
7285, 2.075, 1.17, 0
7286, 2.1, 1.17, 0
7287, 2.125, 1.17, 0
7288, 2.15, 1.17, 0
7289, 2.175, 1.17, 0
7290, 1.225, 1.14, 0
7291, 1.25, 1.14, 0
7292, 1.275, 1.14, 0
7293, 1.3, 1.14, 0
7294, 1.325, 1.14, 0
7295, 1.35, 1.14, 0
7296, 1.375, 1.14, 0
7297, 1.4, 1.14, 0
7298, 1.425, 1.14, 0
7299, 1.45, 1.14, 0
7300, 1.475, 1.14, 0
7301, 1.5, 1.14, 0
7302, 1.525, 1.14, 0
7303, 1.55, 1.14, 0
7304, 1.575, 1.14, 0
7305, 1.6, 1.14, 0
7306, 1.625, 1.14, 0
7307, 1.65, 1.14, 0
7308, 1.675, 1.14, 0
7309, 1.7, 1.14, 0
7310, 1.725, 1.14, 0
7311, 1.75, 1.14, 0
7312, 1.775, 1.14, 0
7313, 1.8, 1.14, 0
7314, 1.825, 1.14, 0
7315, 1.85, 1.14, 0
7316, 1.875, 1.14, 0
7317, 1.9, 1.14, 0
7318, 1.925, 1.14, 0
7319, 1.95, 1.14, 0
7320, 1.975, 1.14, 0
7321, 2, 1.14, 0
7322, 2.025, 1.14, 0
7323, 2.05, 1.14, 0
7324, 2.075, 1.14, 0
7325, 2.1, 1.14, 0
7326, 2.125, 1.14, 0
7327, 2.15, 1.14, 0
7328, 2.175, 1.14, 0
7329, 1.225, 1.11, 0
7330, 1.25, 1.11, 0
7331, 1.275, 1.11, 0
7332, 1.3, 1.11, 0
7333, 1.325, 1.11, 0
7334, 1.35, 1.11, 0
7335, 1.375, 1.11, 0
7336, 1.4, 1.11, 0
7337, 1.425, 1.11, 0
7338, 1.45, 1.11, 0
7339, 1.475, 1.11, 0
7340, 1.5, 1.11, 0
7341, 1.525, 1.11, 0
7342, 1.55, 1.11, 0
7343, 1.575, 1.11, 0
7344, 1.6, 1.11, 0
7345, 1.625, 1.11, 0
7346, 1.65, 1.11, 0
7347, 1.675, 1.11, 0
7348, 1.7, 1.11, 0
7349, 1.725, 1.11, 0
7350, 1.75, 1.11, 0
7351, 1.775, 1.11, 0
7352, 1.8, 1.11, 0
7353, 1.825, 1.11, 0
7354, 1.85, 1.11, 0
7355, 1.875, 1.11, 0
7356, 1.9, 1.11, 0
7357, 1.925, 1.11, 0
7358, 1.95, 1.11, 0
7359, 1.975, 1.11, 0
7360, 2, 1.11, 0
7361, 2.025, 1.11, 0
7362, 2.05, 1.11, 0
7363, 2.075, 1.11, 0
7364, 2.1, 1.11, 0
7365, 2.125, 1.11, 0
7366, 2.15, 1.11, 0
7367, 2.175, 1.11, 0
7368, 1.225, 1.08, 0
7369, 1.25, 1.08, 0
7370, 1.275, 1.08, 0
7371, 1.3, 1.08, 0
7372, 1.325, 1.08, 0
7373, 1.35, 1.08, 0
7374, 1.375, 1.08, 0
7375, 1.4, 1.08, 0
7376, 1.425, 1.08, 0
7377, 1.45, 1.08, 0
7378, 1.475, 1.08, 0
7379, 1.5, 1.08, 0
7380, 1.525, 1.08, 0
7381, 1.55, 1.08, 0
7382, 1.575, 1.08, 0
7383, 1.6, 1.08, 0
7384, 1.625, 1.08, 0
7385, 1.65, 1.08, 0
7386, 1.675, 1.08, 0
7387, 1.7, 1.08, 0
7388, 1.725, 1.08, 0
7389, 1.75, 1.08, 0
7390, 1.775, 1.08, 0
7391, 1.8, 1.08, 0
7392, 1.825, 1.08, 0
7393, 1.85, 1.08, 0
7394, 1.875, 1.08, 0
7395, 1.9, 1.08, 0
7396, 1.925, 1.08, 0
7397, 1.95, 1.08, 0
7398, 1.975, 1.08, 0
7399, 2, 1.08, 0
7400, 2.025, 1.08, 0
7401, 2.05, 1.08, 0
7402, 2.075, 1.08, 0
7403, 2.1, 1.08, 0
7404, 2.125, 1.08, 0
7405, 2.15, 1.08, 0
7406, 2.175, 1.08, 0
7407, 1.225, 1.05, 0
7408, 1.25, 1.05, 0
7409, 1.275, 1.05, 0
7410, 1.3, 1.05, 0
7411, 1.325, 1.05, 0
7412, 1.35, 1.05, 0
7413, 1.375, 1.05, 0
7414, 1.4, 1.05, 0
7415, 1.425, 1.05, 0
7416, 1.45, 1.05, 0
7417, 1.475, 1.05, 0
7418, 1.5, 1.05, 0
7419, 1.525, 1.05, 0
7420, 1.55, 1.05, 0
7421, 1.575, 1.05, 0
7422, 1.6, 1.05, 0
7423, 1.625, 1.05, 0
7424, 1.65, 1.05, 0
7425, 1.675, 1.05, 0
7426, 1.7, 1.05, 0
7427, 1.725, 1.05, 0
7428, 1.75, 1.05, 0
7429, 1.775, 1.05, 0
7430, 1.8, 1.05, 0
7431, 1.825, 1.05, 0
7432, 1.85, 1.05, 0
7433, 1.875, 1.05, 0
7434, 1.9, 1.05, 0
7435, 1.925, 1.05, 0
7436, 1.95, 1.05, 0
7437, 1.975, 1.05, 0
7438, 2, 1.05, 0
7439, 2.025, 1.05, 0
7440, 2.05, 1.05, 0
7441, 2.075, 1.05, 0
7442, 2.1, 1.05, 0
7443, 2.125, 1.05, 0
7444, 2.15, 1.05, 0
7445, 2.175, 1.05, 0
7446, 1.225, 1.02, 0
7447, 1.25, 1.02, 0
7448, 1.275, 1.02, 0
7449, 1.3, 1.02, 0
7450, 1.325, 1.02, 0
7451, 1.35, 1.02, 0
7452, 1.375, 1.02, 0
7453, 1.4, 1.02, 0
7454, 1.425, 1.02, 0
7455, 1.45, 1.02, 0
7456, 1.475, 1.02, 0
7457, 1.5, 1.02, 0
7458, 1.525, 1.02, 0
7459, 1.55, 1.02, 0
7460, 1.575, 1.02, 0
7461, 1.6, 1.02, 0
7462, 1.625, 1.02, 0
7463, 1.65, 1.02, 0
7464, 1.675, 1.02, 0
7465, 1.7, 1.02, 0
7466, 1.725, 1.02, 0
7467, 1.75, 1.02, 0
7468, 1.775, 1.02, 0
7469, 1.8, 1.02, 0
7470, 1.825, 1.02, 0
7471, 1.85, 1.02, 0
7472, 1.875, 1.02, 0
7473, 1.9, 1.02, 0
7474, 1.925, 1.02, 0
7475, 1.95, 1.02, 0
7476, 1.975, 1.02, 0
7477, 2, 1.02, 0
7478, 2.025, 1.02, 0
7479, 2.05, 1.02, 0
7480, 2.075, 1.02, 0
7481, 2.1, 1.02, 0
7482, 2.125, 1.02, 0
7483, 2.15, 1.02, 0
7484, 2.175, 1.02, 0
7485, 1.225, 0.99, 0
7486, 1.25, 0.99, 0
7487, 1.275, 0.99, 0
7488, 1.3, 0.99, 0
7489, 1.325, 0.99, 0
7490, 1.35, 0.99, 0
7491, 1.375, 0.99, 0
7492, 1.4, 0.99, 0
7493, 1.425, 0.99, 0
7494, 1.45, 0.99, 0
7495, 1.475, 0.99, 0
7496, 1.5, 0.99, 0
7497, 1.525, 0.99, 0
7498, 1.55, 0.99, 0
7499, 1.575, 0.99, 0
7500, 1.6, 0.99, 0
7501, 1.625, 0.99, 0
7502, 1.65, 0.99, 0
7503, 1.675, 0.99, 0
7504, 1.7, 0.99, 0
7505, 1.725, 0.99, 0
7506, 1.75, 0.99, 0
7507, 1.775, 0.99, 0
7508, 1.8, 0.99, 0
7509, 1.825, 0.99, 0
7510, 1.85, 0.99, 0
7511, 1.875, 0.99, 0
7512, 1.9, 0.99, 0
7513, 1.925, 0.99, 0
7514, 1.95, 0.99, 0
7515, 1.975, 0.99, 0
7516, 2, 0.99, 0
7517, 2.025, 0.99, 0
7518, 2.05, 0.99, 0
7519, 2.075, 0.99, 0
7520, 2.1, 0.99, 0
7521, 2.125, 0.99, 0
7522, 2.15, 0.99, 0
7523, 2.175, 0.99, 0
7524, 1.225, 0.96, 0
7525, 1.25, 0.96, 0
7526, 1.275, 0.96, 0
7527, 1.3, 0.96, 0
7528, 1.325, 0.96, 0
7529, 1.35, 0.96, 0
7530, 1.375, 0.96, 0
7531, 1.4, 0.96, 0
7532, 1.425, 0.96, 0
7533, 1.45, 0.96, 0
7534, 1.475, 0.96, 0
7535, 1.5, 0.96, 0
7536, 1.525, 0.96, 0
7537, 1.55, 0.96, 0
7538, 1.575, 0.96, 0
7539, 1.6, 0.96, 0
7540, 1.625, 0.96, 0
7541, 1.65, 0.96, 0
7542, 1.675, 0.96, 0
7543, 1.7, 0.96, 0
7544, 1.725, 0.96, 0
7545, 1.75, 0.96, 0
7546, 1.775, 0.96, 0
7547, 1.8, 0.96, 0
7548, 1.825, 0.96, 0
7549, 1.85, 0.96, 0
7550, 1.875, 0.96, 0
7551, 1.9, 0.96, 0
7552, 1.925, 0.96, 0
7553, 1.95, 0.96, 0
7554, 1.975, 0.96, 0
7555, 2, 0.96, 0
7556, 2.025, 0.96, 0
7557, 2.05, 0.96, 0
7558, 2.075, 0.96, 0
7559, 2.1, 0.96, 0
7560, 2.125, 0.96, 0
7561, 2.15, 0.96, 0
7562, 2.175, 0.96, 0
7563, 1.225, 0.93, 0
7564, 1.25, 0.93, 0
7565, 1.275, 0.93, 0
7566, 1.3, 0.93, 0
7567, 1.325, 0.93, 0
7568, 1.35, 0.93, 0
7569, 1.375, 0.93, 0
7570, 1.4, 0.93, 0
7571, 1.425, 0.93, 0
7572, 1.45, 0.93, 0
7573, 1.475, 0.93, 0
7574, 1.5, 0.93, 0
7575, 1.525, 0.93, 0
7576, 1.55, 0.93, 0
7577, 1.575, 0.93, 0
7578, 1.6, 0.93, 0
7579, 1.625, 0.93, 0
7580, 1.65, 0.93, 0
7581, 1.675, 0.93, 0
7582, 1.7, 0.93, 0
7583, 1.725, 0.93, 0
7584, 1.75, 0.93, 0
7585, 1.775, 0.93, 0
7586, 1.8, 0.93, 0
7587, 1.825, 0.93, 0
7588, 1.85, 0.93, 0
7589, 1.875, 0.93, 0
7590, 1.9, 0.93, 0
7591, 1.925, 0.93, 0
7592, 1.95, 0.93, 0
7593, 1.975, 0.93, 0
7594, 2, 0.93, 0
7595, 2.025, 0.93, 0
7596, 2.05, 0.93, 0
7597, 2.075, 0.93, 0
7598, 2.1, 0.93, 0
7599, 2.125, 0.93, 0
7600, 2.15, 0.93, 0
7601, 2.175, 0.93, 0
7602, 1.225, 0.9, 0
7603, 1.25, 0.9, 0
7604, 1.275, 0.9, 0
7605, 1.3, 0.9, 0
7606, 1.325, 0.9, 0
7607, 1.35, 0.9, 0
7608, 1.375, 0.9, 0
7609, 1.4, 0.9, 0
7610, 1.425, 0.9, 0
7611, 1.45, 0.9, 0
7612, 1.475, 0.9, 0
7613, 1.5, 0.9, 0
7614, 1.525, 0.9, 0
7615, 1.55, 0.9, 0
7616, 1.575, 0.9, 0
7617, 1.6, 0.9, 0
7618, 1.625, 0.9, 0
7619, 1.65, 0.9, 0
7620, 1.675, 0.9, 0
7621, 1.7, 0.9, 0
7622, 1.725, 0.9, 0
7623, 1.75, 0.9, 0
7624, 1.775, 0.9, 0
7625, 1.8, 0.9, 0
7626, 1.825, 0.9, 0
7627, 1.85, 0.9, 0
7628, 1.875, 0.9, 0
7629, 1.9, 0.9, 0
7630, 1.925, 0.9, 0
7631, 1.95, 0.9, 0
7632, 1.975, 0.9, 0
7633, 2, 0.9, 0
7634, 2.025, 0.9, 0
7635, 2.05, 0.9, 0
7636, 2.075, 0.9, 0
7637, 2.1, 0.9, 0
7638, 2.125, 0.9, 0
7639, 2.15, 0.9, 0
7640, 2.175, 0.9, 0
7641, 1.225, 0.87, 0
7642, 1.25, 0.87, 0
7643, 1.275, 0.87, 0
7644, 1.3, 0.87, 0
7645, 1.325, 0.87, 0
7646, 1.35, 0.87, 0
7647, 1.375, 0.87, 0
7648, 1.4, 0.87, 0
7649, 1.425, 0.87, 0
7650, 1.45, 0.87, 0
7651, 1.475, 0.87, 0
7652, 1.5, 0.87, 0
7653, 1.525, 0.87, 0
7654, 1.55, 0.87, 0
7655, 1.575, 0.87, 0
7656, 1.6, 0.87, 0
7657, 1.625, 0.87, 0
7658, 1.65, 0.87, 0
7659, 1.675, 0.87, 0
7660, 1.7, 0.87, 0
7661, 1.725, 0.87, 0
7662, 1.75, 0.87, 0
7663, 1.775, 0.87, 0
7664, 1.8, 0.87, 0
7665, 1.825, 0.87, 0
7666, 1.85, 0.87, 0
7667, 1.875, 0.87, 0
7668, 1.9, 0.87, 0
7669, 1.925, 0.87, 0
7670, 1.95, 0.87, 0
7671, 1.975, 0.87, 0
7672, 2, 0.87, 0
7673, 2.025, 0.87, 0
7674, 2.05, 0.87, 0
7675, 2.075, 0.87, 0
7676, 2.1, 0.87, 0
7677, 2.125, 0.87, 0
7678, 2.15, 0.87, 0
7679, 2.175, 0.87, 0
7680, 1.225, 0.84, 0
7681, 1.25, 0.84, 0
7682, 1.275, 0.84, 0
7683, 1.3, 0.84, 0
7684, 1.325, 0.84, 0
7685, 1.35, 0.84, 0
7686, 1.375, 0.84, 0
7687, 1.4, 0.84, 0
7688, 1.425, 0.84, 0
7689, 1.45, 0.84, 0
7690, 1.475, 0.84, 0
7691, 1.5, 0.84, 0
7692, 1.525, 0.84, 0
7693, 1.55, 0.84, 0
7694, 1.575, 0.84, 0
7695, 1.6, 0.84, 0
7696, 1.625, 0.84, 0
7697, 1.65, 0.84, 0
7698, 1.675, 0.84, 0
7699, 1.7, 0.84, 0
7700, 1.725, 0.84, 0
7701, 1.75, 0.84, 0
7702, 1.775, 0.84, 0
7703, 1.8, 0.84, 0
7704, 1.825, 0.84, 0
7705, 1.85, 0.84, 0
7706, 1.875, 0.84, 0
7707, 1.9, 0.84, 0
7708, 1.925, 0.84, 0
7709, 1.95, 0.84, 0
7710, 1.975, 0.84, 0
7711, 2, 0.84, 0
7712, 2.025, 0.84, 0
7713, 2.05, 0.84, 0
7714, 2.075, 0.84, 0
7715, 2.1, 0.84, 0
7716, 2.125, 0.84, 0
7717, 2.15, 0.84, 0
7718, 2.175, 0.84, 0
7719, 1.225, 0.81, 0
7720, 1.25, 0.81, 0
7721, 1.275, 0.81, 0
7722, 1.3, 0.81, 0
7723, 1.325, 0.81, 0
7724, 1.35, 0.81, 0
7725, 1.375, 0.81, 0
7726, 1.4, 0.81, 0
7727, 1.425, 0.81, 0
7728, 1.45, 0.81, 0
7729, 1.475, 0.81, 0
7730, 1.5, 0.81, 0
7731, 1.525, 0.81, 0
7732, 1.55, 0.81, 0
7733, 1.575, 0.81, 0
7734, 1.6, 0.81, 0
7735, 1.625, 0.81, 0
7736, 1.65, 0.81, 0
7737, 1.675, 0.81, 0
7738, 1.7, 0.81, 0
7739, 1.725, 0.81, 0
7740, 1.75, 0.81, 0
7741, 1.775, 0.81, 0
7742, 1.8, 0.81, 0
7743, 1.825, 0.81, 0
7744, 1.85, 0.81, 0
7745, 1.875, 0.81, 0
7746, 1.9, 0.81, 0
7747, 1.925, 0.81, 0
7748, 1.95, 0.81, 0
7749, 1.975, 0.81, 0
7750, 2, 0.81, 0
7751, 2.025, 0.81, 0
7752, 2.05, 0.81, 0
7753, 2.075, 0.81, 0
7754, 2.1, 0.81, 0
7755, 2.125, 0.81, 0
7756, 2.15, 0.81, 0
7757, 2.175, 0.81, 0
7758, 1.225, 0.78, 0
7759, 1.25, 0.78, 0
7760, 1.275, 0.78, 0
7761, 1.3, 0.78, 0
7762, 1.325, 0.78, 0
7763, 1.35, 0.78, 0
7764, 1.375, 0.78, 0
7765, 1.4, 0.78, 0
7766, 1.425, 0.78, 0
7767, 1.45, 0.78, 0
7768, 1.475, 0.78, 0
7769, 1.5, 0.78, 0
7770, 1.525, 0.78, 0
7771, 1.55, 0.78, 0
7772, 1.575, 0.78, 0
7773, 1.6, 0.78, 0
7774, 1.625, 0.78, 0
7775, 1.65, 0.78, 0
7776, 1.675, 0.78, 0
7777, 1.7, 0.78, 0
7778, 1.725, 0.78, 0
7779, 1.75, 0.78, 0
7780, 1.775, 0.78, 0
7781, 1.8, 0.78, 0
7782, 1.825, 0.78, 0
7783, 1.85, 0.78, 0
7784, 1.875, 0.78, 0
7785, 1.9, 0.78, 0
7786, 1.925, 0.78, 0
7787, 1.95, 0.78, 0
7788, 1.975, 0.78, 0
7789, 2, 0.78, 0
7790, 2.025, 0.78, 0
7791, 2.05, 0.78, 0
7792, 2.075, 0.78, 0
7793, 2.1, 0.78, 0
7794, 2.125, 0.78, 0
7795, 2.15, 0.78, 0
7796, 2.175, 0.78, 0
7797, 1.225, 0.75, 0
7798, 1.25, 0.75, 0
7799, 1.275, 0.75, 0
7800, 1.3, 0.75, 0
7801, 1.325, 0.75, 0
7802, 1.35, 0.75, 0
7803, 1.375, 0.75, 0
7804, 1.4, 0.75, 0
7805, 1.425, 0.75, 0
7806, 1.45, 0.75, 0
7807, 1.475, 0.75, 0
7808, 1.5, 0.75, 0
7809, 1.525, 0.75, 0
7810, 1.55, 0.75, 0
7811, 1.575, 0.75, 0
7812, 1.6, 0.75, 0
7813, 1.625, 0.75, 0
7814, 1.65, 0.75, 0
7815, 1.675, 0.75, 0
7816, 1.7, 0.75, 0
7817, 1.725, 0.75, 0
7818, 1.75, 0.75, 0
7819, 1.775, 0.75, 0
7820, 1.8, 0.75, 0
7821, 1.825, 0.75, 0
7822, 1.85, 0.75, 0
7823, 1.875, 0.75, 0
7824, 1.9, 0.75, 0
7825, 1.925, 0.75, 0
7826, 1.95, 0.75, 0
7827, 1.975, 0.75, 0
7828, 2, 0.75, 0
7829, 2.025, 0.75, 0
7830, 2.05, 0.75, 0
7831, 2.075, 0.75, 0
7832, 2.1, 0.75, 0
7833, 2.125, 0.75, 0
7834, 2.15, 0.75, 0
7835, 2.175, 0.75, 0
7836, 1.225, 0.72, 0
7837, 1.25, 0.72, 0
7838, 1.275, 0.72, 0
7839, 1.3, 0.72, 0
7840, 1.325, 0.72, 0
7841, 1.35, 0.72, 0
7842, 1.375, 0.72, 0
7843, 1.4, 0.72, 0
7844, 1.425, 0.72, 0
7845, 1.45, 0.72, 0
7846, 1.475, 0.72, 0
7847, 1.5, 0.72, 0
7848, 1.525, 0.72, 0
7849, 1.55, 0.72, 0
7850, 1.575, 0.72, 0
7851, 1.6, 0.72, 0
7852, 1.625, 0.72, 0
7853, 1.65, 0.72, 0
7854, 1.675, 0.72, 0
7855, 1.7, 0.72, 0
7856, 1.725, 0.72, 0
7857, 1.75, 0.72, 0
7858, 1.775, 0.72, 0
7859, 1.8, 0.72, 0
7860, 1.825, 0.72, 0
7861, 1.85, 0.72, 0
7862, 1.875, 0.72, 0
7863, 1.9, 0.72, 0
7864, 1.925, 0.72, 0
7865, 1.95, 0.72, 0
7866, 1.975, 0.72, 0
7867, 2, 0.72, 0
7868, 2.025, 0.72, 0
7869, 2.05, 0.72, 0
7870, 2.075, 0.72, 0
7871, 2.1, 0.72, 0
7872, 2.125, 0.72, 0
7873, 2.15, 0.72, 0
7874, 2.175, 0.72, 0
7875, 1.225, 0.69, 0
7876, 1.25, 0.69, 0
7877, 1.275, 0.69, 0
7878, 1.3, 0.69, 0
7879, 1.325, 0.69, 0
7880, 1.35, 0.69, 0
7881, 1.375, 0.69, 0
7882, 1.4, 0.69, 0
7883, 1.425, 0.69, 0
7884, 1.45, 0.69, 0
7885, 1.475, 0.69, 0
7886, 1.5, 0.69, 0
7887, 1.525, 0.69, 0
7888, 1.55, 0.69, 0
7889, 1.575, 0.69, 0
7890, 1.6, 0.69, 0
7891, 1.625, 0.69, 0
7892, 1.65, 0.69, 0
7893, 1.675, 0.69, 0
7894, 1.7, 0.69, 0
7895, 1.725, 0.69, 0
7896, 1.75, 0.69, 0
7897, 1.775, 0.69, 0
7898, 1.8, 0.69, 0
7899, 1.825, 0.69, 0
7900, 1.85, 0.69, 0
7901, 1.875, 0.69, 0
7902, 1.9, 0.69, 0
7903, 1.925, 0.69, 0
7904, 1.95, 0.69, 0
7905, 1.975, 0.69, 0
7906, 2, 0.69, 0
7907, 2.025, 0.69, 0
7908, 2.05, 0.69, 0
7909, 2.075, 0.69, 0
7910, 2.1, 0.69, 0
7911, 2.125, 0.69, 0
7912, 2.15, 0.69, 0
7913, 2.175, 0.69, 0
7914, 1.225, 0.66, 0
7915, 1.25, 0.66, 0
7916, 1.275, 0.66, 0
7917, 1.3, 0.66, 0
7918, 1.325, 0.66, 0
7919, 1.35, 0.66, 0
7920, 1.375, 0.66, 0
7921, 1.4, 0.66, 0
7922, 1.425, 0.66, 0
7923, 1.45, 0.66, 0
7924, 1.475, 0.66, 0
7925, 1.5, 0.66, 0
7926, 1.525, 0.66, 0
7927, 1.55, 0.66, 0
7928, 1.575, 0.66, 0
7929, 1.6, 0.66, 0
7930, 1.625, 0.66, 0
7931, 1.65, 0.66, 0
7932, 1.675, 0.66, 0
7933, 1.7, 0.66, 0
7934, 1.725, 0.66, 0
7935, 1.75, 0.66, 0
7936, 1.775, 0.66, 0
7937, 1.8, 0.66, 0
7938, 1.825, 0.66, 0
7939, 1.85, 0.66, 0
7940, 1.875, 0.66, 0
7941, 1.9, 0.66, 0
7942, 1.925, 0.66, 0
7943, 1.95, 0.66, 0
7944, 1.975, 0.66, 0
7945, 2, 0.66, 0
7946, 2.025, 0.66, 0
7947, 2.05, 0.66, 0
7948, 2.075, 0.66, 0
7949, 2.1, 0.66, 0
7950, 2.125, 0.66, 0
7951, 2.15, 0.66, 0
7952, 2.175, 0.66, 0
7953, 1.225, 0.63, 0
7954, 1.25, 0.63, 0
7955, 1.275, 0.63, 0
7956, 1.3, 0.63, 0
7957, 1.325, 0.63, 0
7958, 1.35, 0.63, 0
7959, 1.375, 0.63, 0
7960, 1.4, 0.63, 0
7961, 1.425, 0.63, 0
7962, 1.45, 0.63, 0
7963, 1.475, 0.63, 0
7964, 1.5, 0.63, 0
7965, 1.525, 0.63, 0
7966, 1.55, 0.63, 0
7967, 1.575, 0.63, 0
7968, 1.6, 0.63, 0
7969, 1.625, 0.63, 0
7970, 1.65, 0.63, 0
7971, 1.675, 0.63, 0
7972, 1.7, 0.63, 0
7973, 1.725, 0.63, 0
7974, 1.75, 0.63, 0
7975, 1.775, 0.63, 0
7976, 1.8, 0.63, 0
7977, 1.825, 0.63, 0
7978, 1.85, 0.63, 0
7979, 1.875, 0.63, 0
7980, 1.9, 0.63, 0
7981, 1.925, 0.63, 0
7982, 1.95, 0.63, 0
7983, 1.975, 0.63, 0
7984, 2, 0.63, 0
7985, 2.025, 0.63, 0
7986, 2.05, 0.63, 0
7987, 2.075, 0.63, 0
7988, 2.1, 0.63, 0
7989, 2.125, 0.63, 0
7990, 2.15, 0.63, 0
7991, 2.175, 0.63, 0
7992, 1.225, 0.6, 0
7993, 1.25, 0.6, 0
7994, 1.275, 0.6, 0
7995, 1.3, 0.6, 0
7996, 1.325, 0.6, 0
7997, 1.35, 0.6, 0
7998, 1.375, 0.6, 0
7999, 1.4, 0.6, 0
8000, 1.425, 0.6, 0
8001, 1.45, 0.6, 0
8002, 1.475, 0.6, 0
8003, 1.5, 0.6, 0
8004, 1.525, 0.6, 0
8005, 1.55, 0.6, 0
8006, 1.575, 0.6, 0
8007, 1.6, 0.6, 0
8008, 1.625, 0.6, 0
8009, 1.65, 0.6, 0
8010, 1.675, 0.6, 0
8011, 1.7, 0.6, 0
8012, 1.725, 0.6, 0
8013, 1.75, 0.6, 0
8014, 1.775, 0.6, 0
8015, 1.8, 0.6, 0
8016, 1.825, 0.6, 0
8017, 1.85, 0.6, 0
8018, 1.875, 0.6, 0
8019, 1.9, 0.6, 0
8020, 1.925, 0.6, 0
8021, 1.95, 0.6, 0
8022, 1.975, 0.6, 0
8023, 2, 0.6, 0
8024, 2.025, 0.6, 0
8025, 2.05, 0.6, 0
8026, 2.075, 0.6, 0
8027, 2.1, 0.6, 0
8028, 2.125, 0.6, 0
8029, 2.15, 0.6, 0
8030, 2.175, 0.6, 0
8031, 1.225, 0.57, 0
8032, 1.25, 0.57, 0
8033, 1.275, 0.57, 0
8034, 1.3, 0.57, 0
8035, 1.325, 0.57, 0
8036, 1.35, 0.57, 0
8037, 1.375, 0.57, 0
8038, 1.4, 0.57, 0
8039, 1.425, 0.57, 0
8040, 1.45, 0.57, 0
8041, 1.475, 0.57, 0
8042, 1.5, 0.57, 0
8043, 1.525, 0.57, 0
8044, 1.55, 0.57, 0
8045, 1.575, 0.57, 0
8046, 1.6, 0.57, 0
8047, 1.625, 0.57, 0
8048, 1.65, 0.57, 0
8049, 1.675, 0.57, 0
8050, 1.7, 0.57, 0
8051, 1.725, 0.57, 0
8052, 1.75, 0.57, 0
8053, 1.775, 0.57, 0
8054, 1.8, 0.57, 0
8055, 1.825, 0.57, 0
8056, 1.85, 0.57, 0
8057, 1.875, 0.57, 0
8058, 1.9, 0.57, 0
8059, 1.925, 0.57, 0
8060, 1.95, 0.57, 0
8061, 1.975, 0.57, 0
8062, 2, 0.57, 0
8063, 2.025, 0.57, 0
8064, 2.05, 0.57, 0
8065, 2.075, 0.57, 0
8066, 2.1, 0.57, 0
8067, 2.125, 0.57, 0
8068, 2.15, 0.57, 0
8069, 2.175, 0.57, 0
8070, 1.225, 0.54, 0
8071, 1.25, 0.54, 0
8072, 1.275, 0.54, 0
8073, 1.3, 0.54, 0
8074, 1.325, 0.54, 0
8075, 1.35, 0.54, 0
8076, 1.375, 0.54, 0
8077, 1.4, 0.54, 0
8078, 1.425, 0.54, 0
8079, 1.45, 0.54, 0
8080, 1.475, 0.54, 0
8081, 1.5, 0.54, 0
8082, 1.525, 0.54, 0
8083, 1.55, 0.54, 0
8084, 1.575, 0.54, 0
8085, 1.6, 0.54, 0
8086, 1.625, 0.54, 0
8087, 1.65, 0.54, 0
8088, 1.675, 0.54, 0
8089, 1.7, 0.54, 0
8090, 1.725, 0.54, 0
8091, 1.75, 0.54, 0
8092, 1.775, 0.54, 0
8093, 1.8, 0.54, 0
8094, 1.825, 0.54, 0
8095, 1.85, 0.54, 0
8096, 1.875, 0.54, 0
8097, 1.9, 0.54, 0
8098, 1.925, 0.54, 0
8099, 1.95, 0.54, 0
8100, 1.975, 0.54, 0
8101, 2, 0.54, 0
8102, 2.025, 0.54, 0
8103, 2.05, 0.54, 0
8104, 2.075, 0.54, 0
8105, 2.1, 0.54, 0
8106, 2.125, 0.54, 0
8107, 2.15, 0.54, 0
8108, 2.175, 0.54, 0
8109, 1.225, 0.51, 0
8110, 1.25, 0.51, 0
8111, 1.275, 0.51, 0
8112, 1.3, 0.51, 0
8113, 1.325, 0.51, 0
8114, 1.35, 0.51, 0
8115, 1.375, 0.51, 0
8116, 1.4, 0.51, 0
8117, 1.425, 0.51, 0
8118, 1.45, 0.51, 0
8119, 1.475, 0.51, 0
8120, 1.5, 0.51, 0
8121, 1.525, 0.51, 0
8122, 1.55, 0.51, 0
8123, 1.575, 0.51, 0
8124, 1.6, 0.51, 0
8125, 1.625, 0.51, 0
8126, 1.65, 0.51, 0
8127, 1.675, 0.51, 0
8128, 1.7, 0.51, 0
8129, 1.725, 0.51, 0
8130, 1.75, 0.51, 0
8131, 1.775, 0.51, 0
8132, 1.8, 0.51, 0
8133, 1.825, 0.51, 0
8134, 1.85, 0.51, 0
8135, 1.875, 0.51, 0
8136, 1.9, 0.51, 0
8137, 1.925, 0.51, 0
8138, 1.95, 0.51, 0
8139, 1.975, 0.51, 0
8140, 2, 0.51, 0
8141, 2.025, 0.51, 0
8142, 2.05, 0.51, 0
8143, 2.075, 0.51, 0
8144, 2.1, 0.51, 0
8145, 2.125, 0.51, 0
8146, 2.15, 0.51, 0
8147, 2.175, 0.51, 0
8148, 1.225, 0.48, 0
8149, 1.25, 0.48, 0
8150, 1.275, 0.48, 0
8151, 1.3, 0.48, 0
8152, 1.325, 0.48, 0
8153, 1.35, 0.48, 0
8154, 1.375, 0.48, 0
8155, 1.4, 0.48, 0
8156, 1.425, 0.48, 0
8157, 1.45, 0.48, 0
8158, 1.475, 0.48, 0
8159, 1.5, 0.48, 0
8160, 1.525, 0.48, 0
8161, 1.55, 0.48, 0
8162, 1.575, 0.48, 0
8163, 1.6, 0.48, 0
8164, 1.625, 0.48, 0
8165, 1.65, 0.48, 0
8166, 1.675, 0.48, 0
8167, 1.7, 0.48, 0
8168, 1.725, 0.48, 0
8169, 1.75, 0.48, 0
8170, 1.775, 0.48, 0
8171, 1.8, 0.48, 0
8172, 1.825, 0.48, 0
8173, 1.85, 0.48, 0
8174, 1.875, 0.48, 0
8175, 1.9, 0.48, 0
8176, 1.925, 0.48, 0
8177, 1.95, 0.48, 0
8178, 1.975, 0.48, 0
8179, 2, 0.48, 0
8180, 2.025, 0.48, 0
8181, 2.05, 0.48, 0
8182, 2.075, 0.48, 0
8183, 2.1, 0.48, 0
8184, 2.125, 0.48, 0
8185, 2.15, 0.48, 0
8186, 2.175, 0.48, 0
8187, 1.225, 0.45, 0
8188, 1.25, 0.45, 0
8189, 1.275, 0.45, 0
8190, 1.3, 0.45, 0
8191, 1.325, 0.45, 0
8192, 1.35, 0.45, 0
8193, 1.375, 0.45, 0
8194, 1.4, 0.45, 0
8195, 1.425, 0.45, 0
8196, 1.45, 0.45, 0
8197, 1.475, 0.45, 0
8198, 1.5, 0.45, 0
8199, 1.525, 0.45, 0
8200, 1.55, 0.45, 0
8201, 1.575, 0.45, 0
8202, 1.6, 0.45, 0
8203, 1.625, 0.45, 0
8204, 1.65, 0.45, 0
8205, 1.675, 0.45, 0
8206, 1.7, 0.45, 0
8207, 1.725, 0.45, 0
8208, 1.75, 0.45, 0
8209, 1.775, 0.45, 0
8210, 1.8, 0.45, 0
8211, 1.825, 0.45, 0
8212, 1.85, 0.45, 0
8213, 1.875, 0.45, 0
8214, 1.9, 0.45, 0
8215, 1.925, 0.45, 0
8216, 1.95, 0.45, 0
8217, 1.975, 0.45, 0
8218, 2, 0.45, 0
8219, 2.025, 0.45, 0
8220, 2.05, 0.45, 0
8221, 2.075, 0.45, 0
8222, 2.1, 0.45, 0
8223, 2.125, 0.45, 0
8224, 2.15, 0.45, 0
8225, 2.175, 0.45, 0
8226, 1.225, 0.42, 0
8227, 1.25, 0.42, 0
8228, 1.275, 0.42, 0
8229, 1.3, 0.42, 0
8230, 1.325, 0.42, 0
8231, 1.35, 0.42, 0
8232, 1.375, 0.42, 0
8233, 1.4, 0.42, 0
8234, 1.425, 0.42, 0
8235, 1.45, 0.42, 0
8236, 1.475, 0.42, 0
8237, 1.5, 0.42, 0
8238, 1.525, 0.42, 0
8239, 1.55, 0.42, 0
8240, 1.575, 0.42, 0
8241, 1.6, 0.42, 0
8242, 1.625, 0.42, 0
8243, 1.65, 0.42, 0
8244, 1.675, 0.42, 0
8245, 1.7, 0.42, 0
8246, 1.725, 0.42, 0
8247, 1.75, 0.42, 0
8248, 1.775, 0.42, 0
8249, 1.8, 0.42, 0
8250, 1.825, 0.42, 0
8251, 1.85, 0.42, 0
8252, 1.875, 0.42, 0
8253, 1.9, 0.42, 0
8254, 1.925, 0.42, 0
8255, 1.95, 0.42, 0
8256, 1.975, 0.42, 0
8257, 2, 0.42, 0
8258, 2.025, 0.42, 0
8259, 2.05, 0.42, 0
8260, 2.075, 0.42, 0
8261, 2.1, 0.42, 0
8262, 2.125, 0.42, 0
8263, 2.15, 0.42, 0
8264, 2.175, 0.42, 0
8265, 1.225, 0.39, 0
8266, 1.25, 0.39, 0
8267, 1.275, 0.39, 0
8268, 1.3, 0.39, 0
8269, 1.325, 0.39, 0
8270, 1.35, 0.39, 0
8271, 1.375, 0.39, 0
8272, 1.4, 0.39, 0
8273, 1.425, 0.39, 0
8274, 1.45, 0.39, 0
8275, 1.475, 0.39, 0
8276, 1.5, 0.39, 0
8277, 1.525, 0.39, 0
8278, 1.55, 0.39, 0
8279, 1.575, 0.39, 0
8280, 1.6, 0.39, 0
8281, 1.625, 0.39, 0
8282, 1.65, 0.39, 0
8283, 1.675, 0.39, 0
8284, 1.7, 0.39, 0
8285, 1.725, 0.39, 0
8286, 1.75, 0.39, 0
8287, 1.775, 0.39, 0
8288, 1.8, 0.39, 0
8289, 1.825, 0.39, 0
8290, 1.85, 0.39, 0
8291, 1.875, 0.39, 0
8292, 1.9, 0.39, 0
8293, 1.925, 0.39, 0
8294, 1.95, 0.39, 0
8295, 1.975, 0.39, 0
8296, 2, 0.39, 0
8297, 2.025, 0.39, 0
8298, 2.05, 0.39, 0
8299, 2.075, 0.39, 0
8300, 2.1, 0.39, 0
8301, 2.125, 0.39, 0
8302, 2.15, 0.39, 0
8303, 2.175, 0.39, 0
8304, 1.225, 0.36, 0
8305, 1.25, 0.36, 0
8306, 1.275, 0.36, 0
8307, 1.3, 0.36, 0
8308, 1.325, 0.36, 0
8309, 1.35, 0.36, 0
8310, 1.375, 0.36, 0
8311, 1.4, 0.36, 0
8312, 1.425, 0.36, 0
8313, 1.45, 0.36, 0
8314, 1.475, 0.36, 0
8315, 1.5, 0.36, 0
8316, 1.525, 0.36, 0
8317, 1.55, 0.36, 0
8318, 1.575, 0.36, 0
8319, 1.6, 0.36, 0
8320, 1.625, 0.36, 0
8321, 1.65, 0.36, 0
8322, 1.675, 0.36, 0
8323, 1.7, 0.36, 0
8324, 1.725, 0.36, 0
8325, 1.75, 0.36, 0
8326, 1.775, 0.36, 0
8327, 1.8, 0.36, 0
8328, 1.825, 0.36, 0
8329, 1.85, 0.36, 0
8330, 1.875, 0.36, 0
8331, 1.9, 0.36, 0
8332, 1.925, 0.36, 0
8333, 1.95, 0.36, 0
8334, 1.975, 0.36, 0
8335, 2, 0.36, 0
8336, 2.025, 0.36, 0
8337, 2.05, 0.36, 0
8338, 2.075, 0.36, 0
8339, 2.1, 0.36, 0
8340, 2.125, 0.36, 0
8341, 2.15, 0.36, 0
8342, 2.175, 0.36, 0
8343, 1.225, 0.33, 0
8344, 1.25, 0.33, 0
8345, 1.275, 0.33, 0
8346, 1.3, 0.33, 0
8347, 1.325, 0.33, 0
8348, 1.35, 0.33, 0
8349, 1.375, 0.33, 0
8350, 1.4, 0.33, 0
8351, 1.425, 0.33, 0
8352, 1.45, 0.33, 0
8353, 1.475, 0.33, 0
8354, 1.5, 0.33, 0
8355, 1.525, 0.33, 0
8356, 1.55, 0.33, 0
8357, 1.575, 0.33, 0
8358, 1.6, 0.33, 0
8359, 1.625, 0.33, 0
8360, 1.65, 0.33, 0
8361, 1.675, 0.33, 0
8362, 1.7, 0.33, 0
8363, 1.725, 0.33, 0
8364, 1.75, 0.33, 0
8365, 1.775, 0.33, 0
8366, 1.8, 0.33, 0
8367, 1.825, 0.33, 0
8368, 1.85, 0.33, 0
8369, 1.875, 0.33, 0
8370, 1.9, 0.33, 0
8371, 1.925, 0.33, 0
8372, 1.95, 0.33, 0
8373, 1.975, 0.33, 0
8374, 2, 0.33, 0
8375, 2.025, 0.33, 0
8376, 2.05, 0.33, 0
8377, 2.075, 0.33, 0
8378, 2.1, 0.33, 0
8379, 2.125, 0.33, 0
8380, 2.15, 0.33, 0
8381, 2.175, 0.33, 0
8382, 1.225, 0.3, 0
8383, 1.25, 0.3, 0
8384, 1.275, 0.3, 0
8385, 1.3, 0.3, 0
8386, 1.325, 0.3, 0
8387, 1.35, 0.3, 0
8388, 1.375, 0.3, 0
8389, 1.4, 0.3, 0
8390, 1.425, 0.3, 0
8391, 1.45, 0.3, 0
8392, 1.475, 0.3, 0
8393, 1.5, 0.3, 0
8394, 1.525, 0.3, 0
8395, 1.55, 0.3, 0
8396, 1.575, 0.3, 0
8397, 1.6, 0.3, 0
8398, 1.625, 0.3, 0
8399, 1.65, 0.3, 0
8400, 1.675, 0.3, 0
8401, 1.7, 0.3, 0
8402, 1.725, 0.3, 0
8403, 1.75, 0.3, 0
8404, 1.775, 0.3, 0
8405, 1.8, 0.3, 0
8406, 1.825, 0.3, 0
8407, 1.85, 0.3, 0
8408, 1.875, 0.3, 0
8409, 1.9, 0.3, 0
8410, 1.925, 0.3, 0
8411, 1.95, 0.3, 0
8412, 1.975, 0.3, 0
8413, 2, 0.3, 0
8414, 2.025, 0.3, 0
8415, 2.05, 0.3, 0
8416, 2.075, 0.3, 0
8417, 2.1, 0.3, 0
8418, 2.125, 0.3, 0
8419, 2.15, 0.3, 0
8420, 2.175, 0.3, 0
8421, 1.225, 0.27, 0
8422, 1.25, 0.27, 0
8423, 1.275, 0.27, 0
8424, 1.3, 0.27, 0
8425, 1.325, 0.27, 0
8426, 1.35, 0.27, 0
8427, 1.375, 0.27, 0
8428, 1.4, 0.27, 0
8429, 1.425, 0.27, 0
8430, 1.45, 0.27, 0
8431, 1.475, 0.27, 0
8432, 1.5, 0.27, 0
8433, 1.525, 0.27, 0
8434, 1.55, 0.27, 0
8435, 1.575, 0.27, 0
8436, 1.6, 0.27, 0
8437, 1.625, 0.27, 0
8438, 1.65, 0.27, 0
8439, 1.675, 0.27, 0
8440, 1.7, 0.27, 0
8441, 1.725, 0.27, 0
8442, 1.75, 0.27, 0
8443, 1.775, 0.27, 0
8444, 1.8, 0.27, 0
8445, 1.825, 0.27, 0
8446, 1.85, 0.27, 0
8447, 1.875, 0.27, 0
8448, 1.9, 0.27, 0
8449, 1.925, 0.27, 0
8450, 1.95, 0.27, 0
8451, 1.975, 0.27, 0
8452, 2, 0.27, 0
8453, 2.025, 0.27, 0
8454, 2.05, 0.27, 0
8455, 2.075, 0.27, 0
8456, 2.1, 0.27, 0
8457, 2.125, 0.27, 0
8458, 2.15, 0.27, 0
8459, 2.175, 0.27, 0
8460, 1.225, 0.24, 0
8461, 1.25, 0.24, 0
8462, 1.275, 0.24, 0
8463, 1.3, 0.24, 0
8464, 1.325, 0.24, 0
8465, 1.35, 0.24, 0
8466, 1.375, 0.24, 0
8467, 1.4, 0.24, 0
8468, 1.425, 0.24, 0
8469, 1.45, 0.24, 0
8470, 1.475, 0.24, 0
8471, 1.5, 0.24, 0
8472, 1.525, 0.24, 0
8473, 1.55, 0.24, 0
8474, 1.575, 0.24, 0
8475, 1.6, 0.24, 0
8476, 1.625, 0.24, 0
8477, 1.65, 0.24, 0
8478, 1.675, 0.24, 0
8479, 1.7, 0.24, 0
8480, 1.725, 0.24, 0
8481, 1.75, 0.24, 0
8482, 1.775, 0.24, 0
8483, 1.8, 0.24, 0
8484, 1.825, 0.24, 0
8485, 1.85, 0.24, 0
8486, 1.875, 0.24, 0
8487, 1.9, 0.24, 0
8488, 1.925, 0.24, 0
8489, 1.95, 0.24, 0
8490, 1.975, 0.24, 0
8491, 2, 0.24, 0
8492, 2.025, 0.24, 0
8493, 2.05, 0.24, 0
8494, 2.075, 0.24, 0
8495, 2.1, 0.24, 0
8496, 2.125, 0.24, 0
8497, 2.15, 0.24, 0
8498, 2.175, 0.24, 0
8499, 1.225, 0.21, 0
8500, 1.25, 0.21, 0
8501, 1.275, 0.21, 0
8502, 1.3, 0.21, 0
8503, 1.325, 0.21, 0
8504, 1.35, 0.21, 0
8505, 1.375, 0.21, 0
8506, 1.4, 0.21, 0
8507, 1.425, 0.21, 0
8508, 1.45, 0.21, 0
8509, 1.475, 0.21, 0
8510, 1.5, 0.21, 0
8511, 1.525, 0.21, 0
8512, 1.55, 0.21, 0
8513, 1.575, 0.21, 0
8514, 1.6, 0.21, 0
8515, 1.625, 0.21, 0
8516, 1.65, 0.21, 0
8517, 1.675, 0.21, 0
8518, 1.7, 0.21, 0
8519, 1.725, 0.21, 0
8520, 1.75, 0.21, 0
8521, 1.775, 0.21, 0
8522, 1.8, 0.21, 0
8523, 1.825, 0.21, 0
8524, 1.85, 0.21, 0
8525, 1.875, 0.21, 0
8526, 1.9, 0.21, 0
8527, 1.925, 0.21, 0
8528, 1.95, 0.21, 0
8529, 1.975, 0.21, 0
8530, 2, 0.21, 0
8531, 2.025, 0.21, 0
8532, 2.05, 0.21, 0
8533, 2.075, 0.21, 0
8534, 2.1, 0.21, 0
8535, 2.125, 0.21, 0
8536, 2.15, 0.21, 0
8537, 2.175, 0.21, 0
8538, 1.225, 0.18, 0
8539, 1.25, 0.18, 0
8540, 1.275, 0.18, 0
8541, 1.3, 0.18, 0
8542, 1.325, 0.18, 0
8543, 1.35, 0.18, 0
8544, 1.375, 0.18, 0
8545, 1.4, 0.18, 0
8546, 1.425, 0.18, 0
8547, 1.45, 0.18, 0
8548, 1.475, 0.18, 0
8549, 1.5, 0.18, 0
8550, 1.525, 0.18, 0
8551, 1.55, 0.18, 0
8552, 1.575, 0.18, 0
8553, 1.6, 0.18, 0
8554, 1.625, 0.18, 0
8555, 1.65, 0.18, 0
8556, 1.675, 0.18, 0
8557, 1.7, 0.18, 0
8558, 1.725, 0.18, 0
8559, 1.75, 0.18, 0
8560, 1.775, 0.18, 0
8561, 1.8, 0.18, 0
8562, 1.825, 0.18, 0
8563, 1.85, 0.18, 0
8564, 1.875, 0.18, 0
8565, 1.9, 0.18, 0
8566, 1.925, 0.18, 0
8567, 1.95, 0.18, 0
8568, 1.975, 0.18, 0
8569, 2, 0.18, 0
8570, 2.025, 0.18, 0
8571, 2.05, 0.18, 0
8572, 2.075, 0.18, 0
8573, 2.1, 0.18, 0
8574, 2.125, 0.18, 0
8575, 2.15, 0.18, 0
8576, 2.175, 0.18, 0
8577, 1.225, 0.15, 0
8578, 1.25, 0.15, 0
8579, 1.275, 0.15, 0
8580, 1.3, 0.15, 0
8581, 1.325, 0.15, 0
8582, 1.35, 0.15, 0
8583, 1.375, 0.15, 0
8584, 1.4, 0.15, 0
8585, 1.425, 0.15, 0
8586, 1.45, 0.15, 0
8587, 1.475, 0.15, 0
8588, 1.5, 0.15, 0
8589, 1.525, 0.15, 0
8590, 1.55, 0.15, 0
8591, 1.575, 0.15, 0
8592, 1.6, 0.15, 0
8593, 1.625, 0.15, 0
8594, 1.65, 0.15, 0
8595, 1.675, 0.15, 0
8596, 1.7, 0.15, 0
8597, 1.725, 0.15, 0
8598, 1.75, 0.15, 0
8599, 1.775, 0.15, 0
8600, 1.8, 0.15, 0
8601, 1.825, 0.15, 0
8602, 1.85, 0.15, 0
8603, 1.875, 0.15, 0
8604, 1.9, 0.15, 0
8605, 1.925, 0.15, 0
8606, 1.95, 0.15, 0
8607, 1.975, 0.15, 0
8608, 2, 0.15, 0
8609, 2.025, 0.15, 0
8610, 2.05, 0.15, 0
8611, 2.075, 0.15, 0
8612, 2.1, 0.15, 0
8613, 2.125, 0.15, 0
8614, 2.15, 0.15, 0
8615, 2.175, 0.15, 0
8616, 1.225, 0.12, 0
8617, 1.25, 0.12, 0
8618, 1.275, 0.12, 0
8619, 1.3, 0.12, 0
8620, 1.325, 0.12, 0
8621, 1.35, 0.12, 0
8622, 1.375, 0.12, 0
8623, 1.4, 0.12, 0
8624, 1.425, 0.12, 0
8625, 1.45, 0.12, 0
8626, 1.475, 0.12, 0
8627, 1.5, 0.12, 0
8628, 1.525, 0.12, 0
8629, 1.55, 0.12, 0
8630, 1.575, 0.12, 0
8631, 1.6, 0.12, 0
8632, 1.625, 0.12, 0
8633, 1.65, 0.12, 0
8634, 1.675, 0.12, 0
8635, 1.7, 0.12, 0
8636, 1.725, 0.12, 0
8637, 1.75, 0.12, 0
8638, 1.775, 0.12, 0
8639, 1.8, 0.12, 0
8640, 1.825, 0.12, 0
8641, 1.85, 0.12, 0
8642, 1.875, 0.12, 0
8643, 1.9, 0.12, 0
8644, 1.925, 0.12, 0
8645, 1.95, 0.12, 0
8646, 1.975, 0.12, 0
8647, 2, 0.12, 0
8648, 2.025, 0.12, 0
8649, 2.05, 0.12, 0
8650, 2.075, 0.12, 0
8651, 2.1, 0.12, 0
8652, 2.125, 0.12, 0
8653, 2.15, 0.12, 0
8654, 2.175, 0.12, 0
8655, 1.225, 0.09, 0
8656, 1.25, 0.09, 0
8657, 1.275, 0.09, 0
8658, 1.3, 0.09, 0
8659, 1.325, 0.09, 0
8660, 1.35, 0.09, 0
8661, 1.375, 0.09, 0
8662, 1.4, 0.09, 0
8663, 1.425, 0.09, 0
8664, 1.45, 0.09, 0
8665, 1.475, 0.09, 0
8666, 1.5, 0.09, 0
8667, 1.525, 0.09, 0
8668, 1.55, 0.09, 0
8669, 1.575, 0.09, 0
8670, 1.6, 0.09, 0
8671, 1.625, 0.09, 0
8672, 1.65, 0.09, 0
8673, 1.675, 0.09, 0
8674, 1.7, 0.09, 0
8675, 1.725, 0.09, 0
8676, 1.75, 0.09, 0
8677, 1.775, 0.09, 0
8678, 1.8, 0.09, 0
8679, 1.825, 0.09, 0
8680, 1.85, 0.09, 0
8681, 1.875, 0.09, 0
8682, 1.9, 0.09, 0
8683, 1.925, 0.09, 0
8684, 1.95, 0.09, 0
8685, 1.975, 0.09, 0
8686, 2, 0.09, 0
8687, 2.025, 0.09, 0
8688, 2.05, 0.09, 0
8689, 2.075, 0.09, 0
8690, 2.1, 0.09, 0
8691, 2.125, 0.09, 0
8692, 2.15, 0.09, 0
8693, 2.175, 0.09, 0
8694, 1.225, 0.06, 0
8695, 1.25, 0.06, 0
8696, 1.275, 0.06, 0
8697, 1.3, 0.06, 0
8698, 1.325, 0.06, 0
8699, 1.35, 0.06, 0
8700, 1.375, 0.06, 0
8701, 1.4, 0.06, 0
8702, 1.425, 0.06, 0
8703, 1.45, 0.06, 0
8704, 1.475, 0.06, 0
8705, 1.5, 0.06, 0
8706, 1.525, 0.06, 0
8707, 1.55, 0.06, 0
8708, 1.575, 0.06, 0
8709, 1.6, 0.06, 0
8710, 1.625, 0.06, 0
8711, 1.65, 0.06, 0
8712, 1.675, 0.06, 0
8713, 1.7, 0.06, 0
8714, 1.725, 0.06, 0
8715, 1.75, 0.06, 0
8716, 1.775, 0.06, 0
8717, 1.8, 0.06, 0
8718, 1.825, 0.06, 0
8719, 1.85, 0.06, 0
8720, 1.875, 0.06, 0
8721, 1.9, 0.06, 0
8722, 1.925, 0.06, 0
8723, 1.95, 0.06, 0
8724, 1.975, 0.06, 0
8725, 2, 0.06, 0
8726, 2.025, 0.06, 0
8727, 2.05, 0.06, 0
8728, 2.075, 0.06, 0
8729, 2.1, 0.06, 0
8730, 2.125, 0.06, 0
8731, 2.15, 0.06, 0
8732, 2.175, 0.06, 0
8733, 1.225, 0.03, 0
8734, 1.25, 0.03, 0
8735, 1.275, 0.03, 0
8736, 1.3, 0.03, 0
8737, 1.325, 0.03, 0
8738, 1.35, 0.03, 0
8739, 1.375, 0.03, 0
8740, 1.4, 0.03, 0
8741, 1.425, 0.03, 0
8742, 1.45, 0.03, 0
8743, 1.475, 0.03, 0
8744, 1.5, 0.03, 0
8745, 1.525, 0.03, 0
8746, 1.55, 0.03, 0
8747, 1.575, 0.03, 0
8748, 1.6, 0.03, 0
8749, 1.625, 0.03, 0
8750, 1.65, 0.03, 0
8751, 1.675, 0.03, 0
8752, 1.7, 0.03, 0
8753, 1.725, 0.03, 0
8754, 1.75, 0.03, 0
8755, 1.775, 0.03, 0
8756, 1.8, 0.03, 0
8757, 1.825, 0.03, 0
8758, 1.85, 0.03, 0
8759, 1.875, 0.03, 0
8760, 1.9, 0.03, 0
8761, 1.925, 0.03, 0
8762, 1.95, 0.03, 0
8763, 1.975, 0.03, 0
8764, 2, 0.03, 0
8765, 2.025, 0.03, 0
8766, 2.05, 0.03, 0
8767, 2.075, 0.03, 0
8768, 2.1, 0.03, 0
8769, 2.125, 0.03, 0
8770, 2.15, 0.03, 0
8771, 2.175, 0.03, 0
8772, 1.2125, 1.17, 0
8773, 1.225, 1.185, 0
8774, 1.2375, 1.17, 0
8775, 1.25, 1.185, 0
8776, 1.2625, 1.17, 0
8777, 1.275, 1.185, 0
8778, 1.2875, 1.17, 0
8779, 1.3, 1.185, 0
8780, 1.3125, 1.17, 0
8781, 1.325, 1.185, 0
8782, 1.3375, 1.17, 0
8783, 1.35, 1.185, 0
8784, 1.3625, 1.17, 0
8785, 1.375, 1.185, 0
8786, 1.3875, 1.17, 0
8787, 1.4, 1.185, 0
8788, 1.4125, 1.17, 0
8789, 1.425, 1.185, 0
8790, 1.4375, 1.17, 0
8791, 1.45, 1.185, 0
8792, 1.4625, 1.17, 0
8793, 1.475, 1.185, 0
8794, 1.4875, 1.17, 0
8795, 1.5, 1.185, 0
8796, 1.5125, 1.17, 0
8797, 1.525, 1.185, 0
8798, 1.5375, 1.17, 0
8799, 1.55, 1.185, 0
8800, 1.5625, 1.17, 0
8801, 1.575, 1.185, 0
8802, 1.5875, 1.17, 0
8803, 1.6, 1.185, 0
8804, 1.6125, 1.17, 0
8805, 1.625, 1.185, 0
8806, 1.6375, 1.17, 0
8807, 1.65, 1.185, 0
8808, 1.6625, 1.17, 0
8809, 1.675, 1.185, 0
8810, 1.6875, 1.17, 0
8811, 1.7, 1.185, 0
8812, 1.7125, 1.17, 0
8813, 1.725, 1.185, 0
8814, 1.7375, 1.17, 0
8815, 1.75, 1.185, 0
8816, 1.7625, 1.17, 0
8817, 1.775, 1.185, 0
8818, 1.7875, 1.17, 0
8819, 1.8, 1.185, 0
8820, 1.8125, 1.17, 0
8821, 1.825, 1.185, 0
8822, 1.8375, 1.17, 0
8823, 1.85, 1.185, 0
8824, 1.8625, 1.17, 0
8825, 1.875, 1.185, 0
8826, 1.8875, 1.17, 0
8827, 1.9, 1.185, 0
8828, 1.9125, 1.17, 0
8829, 1.925, 1.185, 0
8830, 1.9375, 1.17, 0
8831, 1.95, 1.185, 0
8832, 1.9625, 1.17, 0
8833, 1.975, 1.185, 0
8834, 1.9875, 1.17, 0
8835, 2, 1.185, 0
8836, 2.0125, 1.17, 0
8837, 2.025, 1.185, 0
8838, 2.0375, 1.17, 0
8839, 2.05, 1.185, 0
8840, 2.0625, 1.17, 0
8841, 2.075, 1.185, 0
8842, 2.0875, 1.17, 0
8843, 2.1, 1.185, 0
8844, 2.1125, 1.17, 0
8845, 2.125, 1.185, 0
8846, 2.1375, 1.17, 0
8847, 2.15, 1.185, 0
8848, 2.1625, 1.17, 0
8849, 2.175, 1.185, 0
8850, 2.1875, 1.17, 0
8851, 1.2125, 1.14, 0
8852, 1.225, 1.155, 0
8853, 1.2375, 1.14, 0
8854, 1.25, 1.155, 0
8855, 1.2625, 1.14, 0
8856, 1.275, 1.155, 0
8857, 1.2875, 1.14, 0
8858, 1.3, 1.155, 0
8859, 1.3125, 1.14, 0
8860, 1.325, 1.155, 0
8861, 1.3375, 1.14, 0
8862, 1.35, 1.155, 0
8863, 1.3625, 1.14, 0
8864, 1.375, 1.155, 0
8865, 1.3875, 1.14, 0
8866, 1.4, 1.155, 0
8867, 1.4125, 1.14, 0
8868, 1.425, 1.155, 0
8869, 1.4375, 1.14, 0
8870, 1.45, 1.155, 0
8871, 1.4625, 1.14, 0
8872, 1.475, 1.155, 0
8873, 1.4875, 1.14, 0
8874, 1.5, 1.155, 0
8875, 1.5125, 1.14, 0
8876, 1.525, 1.155, 0
8877, 1.5375, 1.14, 0
8878, 1.55, 1.155, 0
8879, 1.5625, 1.14, 0
8880, 1.575, 1.155, 0
8881, 1.5875, 1.14, 0
8882, 1.6, 1.155, 0
8883, 1.6125, 1.14, 0
8884, 1.625, 1.155, 0
8885, 1.6375, 1.14, 0
8886, 1.65, 1.155, 0
8887, 1.6625, 1.14, 0
8888, 1.675, 1.155, 0
8889, 1.6875, 1.14, 0
8890, 1.7, 1.155, 0
8891, 1.7125, 1.14, 0
8892, 1.725, 1.155, 0
8893, 1.7375, 1.14, 0
8894, 1.75, 1.155, 0
8895, 1.7625, 1.14, 0
8896, 1.775, 1.155, 0
8897, 1.7875, 1.14, 0
8898, 1.8, 1.155, 0
8899, 1.8125, 1.14, 0
8900, 1.825, 1.155, 0
8901, 1.8375, 1.14, 0
8902, 1.85, 1.155, 0
8903, 1.8625, 1.14, 0
8904, 1.875, 1.155, 0
8905, 1.8875, 1.14, 0
8906, 1.9, 1.155, 0
8907, 1.9125, 1.14, 0
8908, 1.925, 1.155, 0
8909, 1.9375, 1.14, 0
8910, 1.95, 1.155, 0
8911, 1.9625, 1.14, 0
8912, 1.975, 1.155, 0
8913, 1.9875, 1.14, 0
8914, 2, 1.155, 0
8915, 2.0125, 1.14, 0
8916, 2.025, 1.155, 0
8917, 2.0375, 1.14, 0
8918, 2.05, 1.155, 0
8919, 2.0625, 1.14, 0
8920, 2.075, 1.155, 0
8921, 2.0875, 1.14, 0
8922, 2.1, 1.155, 0
8923, 2.1125, 1.14, 0
8924, 2.125, 1.155, 0
8925, 2.1375, 1.14, 0
8926, 2.15, 1.155, 0
8927, 2.1625, 1.14, 0
8928, 2.175, 1.155, 0
8929, 2.1875, 1.14, 0
8930, 1.2125, 1.11, 0
8931, 1.225, 1.125, 0
8932, 1.2375, 1.11, 0
8933, 1.25, 1.125, 0
8934, 1.2625, 1.11, 0
8935, 1.275, 1.125, 0
8936, 1.2875, 1.11, 0
8937, 1.3, 1.125, 0
8938, 1.3125, 1.11, 0
8939, 1.325, 1.125, 0
8940, 1.3375, 1.11, 0
8941, 1.35, 1.125, 0
8942, 1.3625, 1.11, 0
8943, 1.375, 1.125, 0
8944, 1.3875, 1.11, 0
8945, 1.4, 1.125, 0
8946, 1.4125, 1.11, 0
8947, 1.425, 1.125, 0
8948, 1.4375, 1.11, 0
8949, 1.45, 1.125, 0
8950, 1.4625, 1.11, 0
8951, 1.475, 1.125, 0
8952, 1.4875, 1.11, 0
8953, 1.5, 1.125, 0
8954, 1.5125, 1.11, 0
8955, 1.525, 1.125, 0
8956, 1.5375, 1.11, 0
8957, 1.55, 1.125, 0
8958, 1.5625, 1.11, 0
8959, 1.575, 1.125, 0
8960, 1.5875, 1.11, 0
8961, 1.6, 1.125, 0
8962, 1.6125, 1.11, 0
8963, 1.625, 1.125, 0
8964, 1.6375, 1.11, 0
8965, 1.65, 1.125, 0
8966, 1.6625, 1.11, 0
8967, 1.675, 1.125, 0
8968, 1.6875, 1.11, 0
8969, 1.7, 1.125, 0
8970, 1.7125, 1.11, 0
8971, 1.725, 1.125, 0
8972, 1.7375, 1.11, 0
8973, 1.75, 1.125, 0
8974, 1.7625, 1.11, 0
8975, 1.775, 1.125, 0
8976, 1.7875, 1.11, 0
8977, 1.8, 1.125, 0
8978, 1.8125, 1.11, 0
8979, 1.825, 1.125, 0
8980, 1.8375, 1.11, 0
8981, 1.85, 1.125, 0
8982, 1.8625, 1.11, 0
8983, 1.875, 1.125, 0
8984, 1.8875, 1.11, 0
8985, 1.9, 1.125, 0
8986, 1.9125, 1.11, 0
8987, 1.925, 1.125, 0
8988, 1.9375, 1.11, 0
8989, 1.95, 1.125, 0
8990, 1.9625, 1.11, 0
8991, 1.975, 1.125, 0
8992, 1.9875, 1.11, 0
8993, 2, 1.125, 0
8994, 2.0125, 1.11, 0
8995, 2.025, 1.125, 0
8996, 2.0375, 1.11, 0
8997, 2.05, 1.125, 0
8998, 2.0625, 1.11, 0
8999, 2.075, 1.125, 0
9000, 2.0875, 1.11, 0
9001, 2.1, 1.125, 0
9002, 2.1125, 1.11, 0
9003, 2.125, 1.125, 0
9004, 2.1375, 1.11, 0
9005, 2.15, 1.125, 0
9006, 2.1625, 1.11, 0
9007, 2.175, 1.125, 0
9008, 2.1875, 1.11, 0
9009, 1.2125, 1.08, 0
9010, 1.225, 1.095, 0
9011, 1.2375, 1.08, 0
9012, 1.25, 1.095, 0
9013, 1.2625, 1.08, 0
9014, 1.275, 1.095, 0
9015, 1.2875, 1.08, 0
9016, 1.3, 1.095, 0
9017, 1.3125, 1.08, 0
9018, 1.325, 1.095, 0
9019, 1.3375, 1.08, 0
9020, 1.35, 1.095, 0
9021, 1.3625, 1.08, 0
9022, 1.375, 1.095, 0
9023, 1.3875, 1.08, 0
9024, 1.4, 1.095, 0
9025, 1.4125, 1.08, 0
9026, 1.425, 1.095, 0
9027, 1.4375, 1.08, 0
9028, 1.45, 1.095, 0
9029, 1.4625, 1.08, 0
9030, 1.475, 1.095, 0
9031, 1.4875, 1.08, 0
9032, 1.5, 1.095, 0
9033, 1.5125, 1.08, 0
9034, 1.525, 1.095, 0
9035, 1.5375, 1.08, 0
9036, 1.55, 1.095, 0
9037, 1.5625, 1.08, 0
9038, 1.575, 1.095, 0
9039, 1.5875, 1.08, 0
9040, 1.6, 1.095, 0
9041, 1.6125, 1.08, 0
9042, 1.625, 1.095, 0
9043, 1.6375, 1.08, 0
9044, 1.65, 1.095, 0
9045, 1.6625, 1.08, 0
9046, 1.675, 1.095, 0
9047, 1.6875, 1.08, 0
9048, 1.7, 1.095, 0
9049, 1.7125, 1.08, 0
9050, 1.725, 1.095, 0
9051, 1.7375, 1.08, 0
9052, 1.75, 1.095, 0
9053, 1.7625, 1.08, 0
9054, 1.775, 1.095, 0
9055, 1.7875, 1.08, 0
9056, 1.8, 1.095, 0
9057, 1.8125, 1.08, 0
9058, 1.825, 1.095, 0
9059, 1.8375, 1.08, 0
9060, 1.85, 1.095, 0
9061, 1.8625, 1.08, 0
9062, 1.875, 1.095, 0
9063, 1.8875, 1.08, 0
9064, 1.9, 1.095, 0
9065, 1.9125, 1.08, 0
9066, 1.925, 1.095, 0
9067, 1.9375, 1.08, 0
9068, 1.95, 1.095, 0
9069, 1.9625, 1.08, 0
9070, 1.975, 1.095, 0
9071, 1.9875, 1.08, 0
9072, 2, 1.095, 0
9073, 2.0125, 1.08, 0
9074, 2.025, 1.095, 0
9075, 2.0375, 1.08, 0
9076, 2.05, 1.095, 0
9077, 2.0625, 1.08, 0
9078, 2.075, 1.095, 0
9079, 2.0875, 1.08, 0
9080, 2.1, 1.095, 0
9081, 2.1125, 1.08, 0
9082, 2.125, 1.095, 0
9083, 2.1375, 1.08, 0
9084, 2.15, 1.095, 0
9085, 2.1625, 1.08, 0
9086, 2.175, 1.095, 0
9087, 2.1875, 1.08, 0
9088, 1.2125, 1.05, 0
9089, 1.225, 1.065, 0
9090, 1.2375, 1.05, 0
9091, 1.25, 1.065, 0
9092, 1.2625, 1.05, 0
9093, 1.275, 1.065, 0
9094, 1.2875, 1.05, 0
9095, 1.3, 1.065, 0
9096, 1.3125, 1.05, 0
9097, 1.325, 1.065, 0
9098, 1.3375, 1.05, 0
9099, 1.35, 1.065, 0
9100, 1.3625, 1.05, 0
9101, 1.375, 1.065, 0
9102, 1.3875, 1.05, 0
9103, 1.4, 1.065, 0
9104, 1.4125, 1.05, 0
9105, 1.425, 1.065, 0
9106, 1.4375, 1.05, 0
9107, 1.45, 1.065, 0
9108, 1.4625, 1.05, 0
9109, 1.475, 1.065, 0
9110, 1.4875, 1.05, 0
9111, 1.5, 1.065, 0
9112, 1.5125, 1.05, 0
9113, 1.525, 1.065, 0
9114, 1.5375, 1.05, 0
9115, 1.55, 1.065, 0
9116, 1.5625, 1.05, 0
9117, 1.575, 1.065, 0
9118, 1.5875, 1.05, 0
9119, 1.6, 1.065, 0
9120, 1.6125, 1.05, 0
9121, 1.625, 1.065, 0
9122, 1.6375, 1.05, 0
9123, 1.65, 1.065, 0
9124, 1.6625, 1.05, 0
9125, 1.675, 1.065, 0
9126, 1.6875, 1.05, 0
9127, 1.7, 1.065, 0
9128, 1.7125, 1.05, 0
9129, 1.725, 1.065, 0
9130, 1.7375, 1.05, 0
9131, 1.75, 1.065, 0
9132, 1.7625, 1.05, 0
9133, 1.775, 1.065, 0
9134, 1.7875, 1.05, 0
9135, 1.8, 1.065, 0
9136, 1.8125, 1.05, 0
9137, 1.825, 1.065, 0
9138, 1.8375, 1.05, 0
9139, 1.85, 1.065, 0
9140, 1.8625, 1.05, 0
9141, 1.875, 1.065, 0
9142, 1.8875, 1.05, 0
9143, 1.9, 1.065, 0
9144, 1.9125, 1.05, 0
9145, 1.925, 1.065, 0
9146, 1.9375, 1.05, 0
9147, 1.95, 1.065, 0
9148, 1.9625, 1.05, 0
9149, 1.975, 1.065, 0
9150, 1.9875, 1.05, 0
9151, 2, 1.065, 0
9152, 2.0125, 1.05, 0
9153, 2.025, 1.065, 0
9154, 2.0375, 1.05, 0
9155, 2.05, 1.065, 0
9156, 2.0625, 1.05, 0
9157, 2.075, 1.065, 0
9158, 2.0875, 1.05, 0
9159, 2.1, 1.065, 0
9160, 2.1125, 1.05, 0
9161, 2.125, 1.065, 0
9162, 2.1375, 1.05, 0
9163, 2.15, 1.065, 0
9164, 2.1625, 1.05, 0
9165, 2.175, 1.065, 0
9166, 2.1875, 1.05, 0
9167, 1.2125, 1.02, 0
9168, 1.225, 1.035, 0
9169, 1.2375, 1.02, 0
9170, 1.25, 1.035, 0
9171, 1.2625, 1.02, 0
9172, 1.275, 1.035, 0
9173, 1.2875, 1.02, 0
9174, 1.3, 1.035, 0
9175, 1.3125, 1.02, 0
9176, 1.325, 1.035, 0
9177, 1.3375, 1.02, 0
9178, 1.35, 1.035, 0
9179, 1.3625, 1.02, 0
9180, 1.375, 1.035, 0
9181, 1.3875, 1.02, 0
9182, 1.4, 1.035, 0
9183, 1.4125, 1.02, 0
9184, 1.425, 1.035, 0
9185, 1.4375, 1.02, 0
9186, 1.45, 1.035, 0
9187, 1.4625, 1.02, 0
9188, 1.475, 1.035, 0
9189, 1.4875, 1.02, 0
9190, 1.5, 1.035, 0
9191, 1.5125, 1.02, 0
9192, 1.525, 1.035, 0
9193, 1.5375, 1.02, 0
9194, 1.55, 1.035, 0
9195, 1.5625, 1.02, 0
9196, 1.575, 1.035, 0
9197, 1.5875, 1.02, 0
9198, 1.6, 1.035, 0
9199, 1.6125, 1.02, 0
9200, 1.625, 1.035, 0
9201, 1.6375, 1.02, 0
9202, 1.65, 1.035, 0
9203, 1.6625, 1.02, 0
9204, 1.675, 1.035, 0
9205, 1.6875, 1.02, 0
9206, 1.7, 1.035, 0
9207, 1.7125, 1.02, 0
9208, 1.725, 1.035, 0
9209, 1.7375, 1.02, 0
9210, 1.75, 1.035, 0
9211, 1.7625, 1.02, 0
9212, 1.775, 1.035, 0
9213, 1.7875, 1.02, 0
9214, 1.8, 1.035, 0
9215, 1.8125, 1.02, 0
9216, 1.825, 1.035, 0
9217, 1.8375, 1.02, 0
9218, 1.85, 1.035, 0
9219, 1.8625, 1.02, 0
9220, 1.875, 1.035, 0
9221, 1.8875, 1.02, 0
9222, 1.9, 1.035, 0
9223, 1.9125, 1.02, 0
9224, 1.925, 1.035, 0
9225, 1.9375, 1.02, 0
9226, 1.95, 1.035, 0
9227, 1.9625, 1.02, 0
9228, 1.975, 1.035, 0
9229, 1.9875, 1.02, 0
9230, 2, 1.035, 0
9231, 2.0125, 1.02, 0
9232, 2.025, 1.035, 0
9233, 2.0375, 1.02, 0
9234, 2.05, 1.035, 0
9235, 2.0625, 1.02, 0
9236, 2.075, 1.035, 0
9237, 2.0875, 1.02, 0
9238, 2.1, 1.035, 0
9239, 2.1125, 1.02, 0
9240, 2.125, 1.035, 0
9241, 2.1375, 1.02, 0
9242, 2.15, 1.035, 0
9243, 2.1625, 1.02, 0
9244, 2.175, 1.035, 0
9245, 2.1875, 1.02, 0
9246, 1.2125, 0.99, 0
9247, 1.225, 1.005, 0
9248, 1.2375, 0.99, 0
9249, 1.25, 1.005, 0
9250, 1.2625, 0.99, 0
9251, 1.275, 1.005, 0
9252, 1.2875, 0.99, 0
9253, 1.3, 1.005, 0
9254, 1.3125, 0.99, 0
9255, 1.325, 1.005, 0
9256, 1.3375, 0.99, 0
9257, 1.35, 1.005, 0
9258, 1.3625, 0.99, 0
9259, 1.375, 1.005, 0
9260, 1.3875, 0.99, 0
9261, 1.4, 1.005, 0
9262, 1.4125, 0.99, 0
9263, 1.425, 1.005, 0
9264, 1.4375, 0.99, 0
9265, 1.45, 1.005, 0
9266, 1.4625, 0.99, 0
9267, 1.475, 1.005, 0
9268, 1.4875, 0.99, 0
9269, 1.5, 1.005, 0
9270, 1.5125, 0.99, 0
9271, 1.525, 1.005, 0
9272, 1.5375, 0.99, 0
9273, 1.55, 1.005, 0
9274, 1.5625, 0.99, 0
9275, 1.575, 1.005, 0
9276, 1.5875, 0.99, 0
9277, 1.6, 1.005, 0
9278, 1.6125, 0.99, 0
9279, 1.625, 1.005, 0
9280, 1.6375, 0.99, 0
9281, 1.65, 1.005, 0
9282, 1.6625, 0.99, 0
9283, 1.675, 1.005, 0
9284, 1.6875, 0.99, 0
9285, 1.7, 1.005, 0
9286, 1.7125, 0.99, 0
9287, 1.725, 1.005, 0
9288, 1.7375, 0.99, 0
9289, 1.75, 1.005, 0
9290, 1.7625, 0.99, 0
9291, 1.775, 1.005, 0
9292, 1.7875, 0.99, 0
9293, 1.8, 1.005, 0
9294, 1.8125, 0.99, 0
9295, 1.825, 1.005, 0
9296, 1.8375, 0.99, 0
9297, 1.85, 1.005, 0
9298, 1.8625, 0.99, 0
9299, 1.875, 1.005, 0
9300, 1.8875, 0.99, 0
9301, 1.9, 1.005, 0
9302, 1.9125, 0.99, 0
9303, 1.925, 1.005, 0
9304, 1.9375, 0.99, 0
9305, 1.95, 1.005, 0
9306, 1.9625, 0.99, 0
9307, 1.975, 1.005, 0
9308, 1.9875, 0.99, 0
9309, 2, 1.005, 0
9310, 2.0125, 0.99, 0
9311, 2.025, 1.005, 0
9312, 2.0375, 0.99, 0
9313, 2.05, 1.005, 0
9314, 2.0625, 0.99, 0
9315, 2.075, 1.005, 0
9316, 2.0875, 0.99, 0
9317, 2.1, 1.005, 0
9318, 2.1125, 0.99, 0
9319, 2.125, 1.005, 0
9320, 2.1375, 0.99, 0
9321, 2.15, 1.005, 0
9322, 2.1625, 0.99, 0
9323, 2.175, 1.005, 0
9324, 2.1875, 0.99, 0
9325, 1.2125, 0.96, 0
9326, 1.225, 0.975, 0
9327, 1.2375, 0.96, 0
9328, 1.25, 0.975, 0
9329, 1.2625, 0.96, 0
9330, 1.275, 0.975, 0
9331, 1.2875, 0.96, 0
9332, 1.3, 0.975, 0
9333, 1.3125, 0.96, 0
9334, 1.325, 0.975, 0
9335, 1.3375, 0.96, 0
9336, 1.35, 0.975, 0
9337, 1.3625, 0.96, 0
9338, 1.375, 0.975, 0
9339, 1.3875, 0.96, 0
9340, 1.4, 0.975, 0
9341, 1.4125, 0.96, 0
9342, 1.425, 0.975, 0
9343, 1.4375, 0.96, 0
9344, 1.45, 0.975, 0
9345, 1.4625, 0.96, 0
9346, 1.475, 0.975, 0
9347, 1.4875, 0.96, 0
9348, 1.5, 0.975, 0
9349, 1.5125, 0.96, 0
9350, 1.525, 0.975, 0
9351, 1.5375, 0.96, 0
9352, 1.55, 0.975, 0
9353, 1.5625, 0.96, 0
9354, 1.575, 0.975, 0
9355, 1.5875, 0.96, 0
9356, 1.6, 0.975, 0
9357, 1.6125, 0.96, 0
9358, 1.625, 0.975, 0
9359, 1.6375, 0.96, 0
9360, 1.65, 0.975, 0
9361, 1.6625, 0.96, 0
9362, 1.675, 0.975, 0
9363, 1.6875, 0.96, 0
9364, 1.7, 0.975, 0
9365, 1.7125, 0.96, 0
9366, 1.725, 0.975, 0
9367, 1.7375, 0.96, 0
9368, 1.75, 0.975, 0
9369, 1.7625, 0.96, 0
9370, 1.775, 0.975, 0
9371, 1.7875, 0.96, 0
9372, 1.8, 0.975, 0
9373, 1.8125, 0.96, 0
9374, 1.825, 0.975, 0
9375, 1.8375, 0.96, 0
9376, 1.85, 0.975, 0
9377, 1.8625, 0.96, 0
9378, 1.875, 0.975, 0
9379, 1.8875, 0.96, 0
9380, 1.9, 0.975, 0
9381, 1.9125, 0.96, 0
9382, 1.925, 0.975, 0
9383, 1.9375, 0.96, 0
9384, 1.95, 0.975, 0
9385, 1.9625, 0.96, 0
9386, 1.975, 0.975, 0
9387, 1.9875, 0.96, 0
9388, 2, 0.975, 0
9389, 2.0125, 0.96, 0
9390, 2.025, 0.975, 0
9391, 2.0375, 0.96, 0
9392, 2.05, 0.975, 0
9393, 2.0625, 0.96, 0
9394, 2.075, 0.975, 0
9395, 2.0875, 0.96, 0
9396, 2.1, 0.975, 0
9397, 2.1125, 0.96, 0
9398, 2.125, 0.975, 0
9399, 2.1375, 0.96, 0
9400, 2.15, 0.975, 0
9401, 2.1625, 0.96, 0
9402, 2.175, 0.975, 0
9403, 2.1875, 0.96, 0
9404, 1.2125, 0.93, 0
9405, 1.225, 0.945, 0
9406, 1.2375, 0.93, 0
9407, 1.25, 0.945, 0
9408, 1.2625, 0.93, 0
9409, 1.275, 0.945, 0
9410, 1.2875, 0.93, 0
9411, 1.3, 0.945, 0
9412, 1.3125, 0.93, 0
9413, 1.325, 0.945, 0
9414, 1.3375, 0.93, 0
9415, 1.35, 0.945, 0
9416, 1.3625, 0.93, 0
9417, 1.375, 0.945, 0
9418, 1.3875, 0.93, 0
9419, 1.4, 0.945, 0
9420, 1.4125, 0.93, 0
9421, 1.425, 0.945, 0
9422, 1.4375, 0.93, 0
9423, 1.45, 0.945, 0
9424, 1.4625, 0.93, 0
9425, 1.475, 0.945, 0
9426, 1.4875, 0.93, 0
9427, 1.5, 0.945, 0
9428, 1.5125, 0.93, 0
9429, 1.525, 0.945, 0
9430, 1.5375, 0.93, 0
9431, 1.55, 0.945, 0
9432, 1.5625, 0.93, 0
9433, 1.575, 0.945, 0
9434, 1.5875, 0.93, 0
9435, 1.6, 0.945, 0
9436, 1.6125, 0.93, 0
9437, 1.625, 0.945, 0
9438, 1.6375, 0.93, 0
9439, 1.65, 0.945, 0
9440, 1.6625, 0.93, 0
9441, 1.675, 0.945, 0
9442, 1.6875, 0.93, 0
9443, 1.7, 0.945, 0
9444, 1.7125, 0.93, 0
9445, 1.725, 0.945, 0
9446, 1.7375, 0.93, 0
9447, 1.75, 0.945, 0
9448, 1.7625, 0.93, 0
9449, 1.775, 0.945, 0
9450, 1.7875, 0.93, 0
9451, 1.8, 0.945, 0
9452, 1.8125, 0.93, 0
9453, 1.825, 0.945, 0
9454, 1.8375, 0.93, 0
9455, 1.85, 0.945, 0
9456, 1.8625, 0.93, 0
9457, 1.875, 0.945, 0
9458, 1.8875, 0.93, 0
9459, 1.9, 0.945, 0
9460, 1.9125, 0.93, 0
9461, 1.925, 0.945, 0
9462, 1.9375, 0.93, 0
9463, 1.95, 0.945, 0
9464, 1.9625, 0.93, 0
9465, 1.975, 0.945, 0
9466, 1.9875, 0.93, 0
9467, 2, 0.945, 0
9468, 2.0125, 0.93, 0
9469, 2.025, 0.945, 0
9470, 2.0375, 0.93, 0
9471, 2.05, 0.945, 0
9472, 2.0625, 0.93, 0
9473, 2.075, 0.945, 0
9474, 2.0875, 0.93, 0
9475, 2.1, 0.945, 0
9476, 2.1125, 0.93, 0
9477, 2.125, 0.945, 0
9478, 2.1375, 0.93, 0
9479, 2.15, 0.945, 0
9480, 2.1625, 0.93, 0
9481, 2.175, 0.945, 0
9482, 2.1875, 0.93, 0
9483, 1.2125, 0.9, 0
9484, 1.225, 0.915, 0
9485, 1.2375, 0.9, 0
9486, 1.25, 0.915, 0
9487, 1.2625, 0.9, 0
9488, 1.275, 0.915, 0
9489, 1.2875, 0.9, 0
9490, 1.3, 0.915, 0
9491, 1.3125, 0.9, 0
9492, 1.325, 0.915, 0
9493, 1.3375, 0.9, 0
9494, 1.35, 0.915, 0
9495, 1.3625, 0.9, 0
9496, 1.375, 0.915, 0
9497, 1.3875, 0.9, 0
9498, 1.4, 0.915, 0
9499, 1.4125, 0.9, 0
9500, 1.425, 0.915, 0
9501, 1.4375, 0.9, 0
9502, 1.45, 0.915, 0
9503, 1.4625, 0.9, 0
9504, 1.475, 0.915, 0
9505, 1.4875, 0.9, 0
9506, 1.5, 0.915, 0
9507, 1.5125, 0.9, 0
9508, 1.525, 0.915, 0
9509, 1.5375, 0.9, 0
9510, 1.55, 0.915, 0
9511, 1.5625, 0.9, 0
9512, 1.575, 0.915, 0
9513, 1.5875, 0.9, 0
9514, 1.6, 0.915, 0
9515, 1.6125, 0.9, 0
9516, 1.625, 0.915, 0
9517, 1.6375, 0.9, 0
9518, 1.65, 0.915, 0
9519, 1.6625, 0.9, 0
9520, 1.675, 0.915, 0
9521, 1.6875, 0.9, 0
9522, 1.7, 0.915, 0
9523, 1.7125, 0.9, 0
9524, 1.725, 0.915, 0
9525, 1.7375, 0.9, 0
9526, 1.75, 0.915, 0
9527, 1.7625, 0.9, 0
9528, 1.775, 0.915, 0
9529, 1.7875, 0.9, 0
9530, 1.8, 0.915, 0
9531, 1.8125, 0.9, 0
9532, 1.825, 0.915, 0
9533, 1.8375, 0.9, 0
9534, 1.85, 0.915, 0
9535, 1.8625, 0.9, 0
9536, 1.875, 0.915, 0
9537, 1.8875, 0.9, 0
9538, 1.9, 0.915, 0
9539, 1.9125, 0.9, 0
9540, 1.925, 0.915, 0
9541, 1.9375, 0.9, 0
9542, 1.95, 0.915, 0
9543, 1.9625, 0.9, 0
9544, 1.975, 0.915, 0
9545, 1.9875, 0.9, 0
9546, 2, 0.915, 0
9547, 2.0125, 0.9, 0
9548, 2.025, 0.915, 0
9549, 2.0375, 0.9, 0
9550, 2.05, 0.915, 0
9551, 2.0625, 0.9, 0
9552, 2.075, 0.915, 0
9553, 2.0875, 0.9, 0
9554, 2.1, 0.915, 0
9555, 2.1125, 0.9, 0
9556, 2.125, 0.915, 0
9557, 2.1375, 0.9, 0
9558, 2.15, 0.915, 0
9559, 2.1625, 0.9, 0
9560, 2.175, 0.915, 0
9561, 2.1875, 0.9, 0
9562, 1.2125, 0.87, 0
9563, 1.225, 0.885, 0
9564, 1.2375, 0.87, 0
9565, 1.25, 0.885, 0
9566, 1.2625, 0.87, 0
9567, 1.275, 0.885, 0
9568, 1.2875, 0.87, 0
9569, 1.3, 0.885, 0
9570, 1.3125, 0.87, 0
9571, 1.325, 0.885, 0
9572, 1.3375, 0.87, 0
9573, 1.35, 0.885, 0
9574, 1.3625, 0.87, 0
9575, 1.375, 0.885, 0
9576, 1.3875, 0.87, 0
9577, 1.4, 0.885, 0
9578, 1.4125, 0.87, 0
9579, 1.425, 0.885, 0
9580, 1.4375, 0.87, 0
9581, 1.45, 0.885, 0
9582, 1.4625, 0.87, 0
9583, 1.475, 0.885, 0
9584, 1.4875, 0.87, 0
9585, 1.5, 0.885, 0
9586, 1.5125, 0.87, 0
9587, 1.525, 0.885, 0
9588, 1.5375, 0.87, 0
9589, 1.55, 0.885, 0
9590, 1.5625, 0.87, 0
9591, 1.575, 0.885, 0
9592, 1.5875, 0.87, 0
9593, 1.6, 0.885, 0
9594, 1.6125, 0.87, 0
9595, 1.625, 0.885, 0
9596, 1.6375, 0.87, 0
9597, 1.65, 0.885, 0
9598, 1.6625, 0.87, 0
9599, 1.675, 0.885, 0
9600, 1.6875, 0.87, 0
9601, 1.7, 0.885, 0
9602, 1.7125, 0.87, 0
9603, 1.725, 0.885, 0
9604, 1.7375, 0.87, 0
9605, 1.75, 0.885, 0
9606, 1.7625, 0.87, 0
9607, 1.775, 0.885, 0
9608, 1.7875, 0.87, 0
9609, 1.8, 0.885, 0
9610, 1.8125, 0.87, 0
9611, 1.825, 0.885, 0
9612, 1.8375, 0.87, 0
9613, 1.85, 0.885, 0
9614, 1.8625, 0.87, 0
9615, 1.875, 0.885, 0
9616, 1.8875, 0.87, 0
9617, 1.9, 0.885, 0
9618, 1.9125, 0.87, 0
9619, 1.925, 0.885, 0
9620, 1.9375, 0.87, 0
9621, 1.95, 0.885, 0
9622, 1.9625, 0.87, 0
9623, 1.975, 0.885, 0
9624, 1.9875, 0.87, 0
9625, 2, 0.885, 0
9626, 2.0125, 0.87, 0
9627, 2.025, 0.885, 0
9628, 2.0375, 0.87, 0
9629, 2.05, 0.885, 0
9630, 2.0625, 0.87, 0
9631, 2.075, 0.885, 0
9632, 2.0875, 0.87, 0
9633, 2.1, 0.885, 0
9634, 2.1125, 0.87, 0
9635, 2.125, 0.885, 0
9636, 2.1375, 0.87, 0
9637, 2.15, 0.885, 0
9638, 2.1625, 0.87, 0
9639, 2.175, 0.885, 0
9640, 2.1875, 0.87, 0
9641, 1.2125, 0.84, 0
9642, 1.225, 0.855, 0
9643, 1.2375, 0.84, 0
9644, 1.25, 0.855, 0
9645, 1.2625, 0.84, 0
9646, 1.275, 0.855, 0
9647, 1.2875, 0.84, 0
9648, 1.3, 0.855, 0
9649, 1.3125, 0.84, 0
9650, 1.325, 0.855, 0
9651, 1.3375, 0.84, 0
9652, 1.35, 0.855, 0
9653, 1.3625, 0.84, 0
9654, 1.375, 0.855, 0
9655, 1.3875, 0.84, 0
9656, 1.4, 0.855, 0
9657, 1.4125, 0.84, 0
9658, 1.425, 0.855, 0
9659, 1.4375, 0.84, 0
9660, 1.45, 0.855, 0
9661, 1.4625, 0.84, 0
9662, 1.475, 0.855, 0
9663, 1.4875, 0.84, 0
9664, 1.5, 0.855, 0
9665, 1.5125, 0.84, 0
9666, 1.525, 0.855, 0
9667, 1.5375, 0.84, 0
9668, 1.55, 0.855, 0
9669, 1.5625, 0.84, 0
9670, 1.575, 0.855, 0
9671, 1.5875, 0.84, 0
9672, 1.6, 0.855, 0
9673, 1.6125, 0.84, 0
9674, 1.625, 0.855, 0
9675, 1.6375, 0.84, 0
9676, 1.65, 0.855, 0
9677, 1.6625, 0.84, 0
9678, 1.675, 0.855, 0
9679, 1.6875, 0.84, 0
9680, 1.7, 0.855, 0
