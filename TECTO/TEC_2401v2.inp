9681, 1.7125, 0.84, 0
9682, 1.725, 0.855, 0
9683, 1.7375, 0.84, 0
9684, 1.75, 0.855, 0
9685, 1.7625, 0.84, 0
9686, 1.775, 0.855, 0
9687, 1.7875, 0.84, 0
9688, 1.8, 0.855, 0
9689, 1.8125, 0.84, 0
9690, 1.825, 0.855, 0
9691, 1.8375, 0.84, 0
9692, 1.85, 0.855, 0
9693, 1.8625, 0.84, 0
9694, 1.875, 0.855, 0
9695, 1.8875, 0.84, 0
9696, 1.9, 0.855, 0
9697, 1.9125, 0.84, 0
9698, 1.925, 0.855, 0
9699, 1.9375, 0.84, 0
9700, 1.95, 0.855, 0
9701, 1.9625, 0.84, 0
9702, 1.975, 0.855, 0
9703, 1.9875, 0.84, 0
9704, 2, 0.855, 0
9705, 2.0125, 0.84, 0
9706, 2.025, 0.855, 0
9707, 2.0375, 0.84, 0
9708, 2.05, 0.855, 0
9709, 2.0625, 0.84, 0
9710, 2.075, 0.855, 0
9711, 2.0875, 0.84, 0
9712, 2.1, 0.855, 0
9713, 2.1125, 0.84, 0
9714, 2.125, 0.855, 0
9715, 2.1375, 0.84, 0
9716, 2.15, 0.855, 0
9717, 2.1625, 0.84, 0
9718, 2.175, 0.855, 0
9719, 2.1875, 0.84, 0
9720, 1.2125, 0.81, 0
9721, 1.225, 0.825, 0
9722, 1.2375, 0.81, 0
9723, 1.25, 0.825, 0
9724, 1.2625, 0.81, 0
9725, 1.275, 0.825, 0
9726, 1.2875, 0.81, 0
9727, 1.3, 0.825, 0
9728, 1.3125, 0.81, 0
9729, 1.325, 0.825, 0
9730, 1.3375, 0.81, 0
9731, 1.35, 0.825, 0
9732, 1.3625, 0.81, 0
9733, 1.375, 0.825, 0
9734, 1.3875, 0.81, 0
9735, 1.4, 0.825, 0
9736, 1.4125, 0.81, 0
9737, 1.425, 0.825, 0
9738, 1.4375, 0.81, 0
9739, 1.45, 0.825, 0
9740, 1.4625, 0.81, 0
9741, 1.475, 0.825, 0
9742, 1.4875, 0.81, 0
9743, 1.5, 0.825, 0
9744, 1.5125, 0.81, 0
9745, 1.525, 0.825, 0
9746, 1.5375, 0.81, 0
9747, 1.55, 0.825, 0
9748, 1.5625, 0.81, 0
9749, 1.575, 0.825, 0
9750, 1.5875, 0.81, 0
9751, 1.6, 0.825, 0
9752, 1.6125, 0.81, 0
9753, 1.625, 0.825, 0
9754, 1.6375, 0.81, 0
9755, 1.65, 0.825, 0
9756, 1.6625, 0.81, 0
9757, 1.675, 0.825, 0
9758, 1.6875, 0.81, 0
9759, 1.7, 0.825, 0
9760, 1.7125, 0.81, 0
9761, 1.725, 0.825, 0
9762, 1.7375, 0.81, 0
9763, 1.75, 0.825, 0
9764, 1.7625, 0.81, 0
9765, 1.775, 0.825, 0
9766, 1.7875, 0.81, 0
9767, 1.8, 0.825, 0
9768, 1.8125, 0.81, 0
9769, 1.825, 0.825, 0
9770, 1.8375, 0.81, 0
9771, 1.85, 0.825, 0
9772, 1.8625, 0.81, 0
9773, 1.875, 0.825, 0
9774, 1.8875, 0.81, 0
9775, 1.9, 0.825, 0
9776, 1.9125, 0.81, 0
9777, 1.925, 0.825, 0
9778, 1.9375, 0.81, 0
9779, 1.95, 0.825, 0
9780, 1.9625, 0.81, 0
9781, 1.975, 0.825, 0
9782, 1.9875, 0.81, 0
9783, 2, 0.825, 0
9784, 2.0125, 0.81, 0
9785, 2.025, 0.825, 0
9786, 2.0375, 0.81, 0
9787, 2.05, 0.825, 0
9788, 2.0625, 0.81, 0
9789, 2.075, 0.825, 0
9790, 2.0875, 0.81, 0
9791, 2.1, 0.825, 0
9792, 2.1125, 0.81, 0
9793, 2.125, 0.825, 0
9794, 2.1375, 0.81, 0
9795, 2.15, 0.825, 0
9796, 2.1625, 0.81, 0
9797, 2.175, 0.825, 0
9798, 2.1875, 0.81, 0
9799, 1.2125, 0.78, 0
9800, 1.225, 0.795, 0
9801, 1.2375, 0.78, 0
9802, 1.25, 0.795, 0
9803, 1.2625, 0.78, 0
9804, 1.275, 0.795, 0
9805, 1.2875, 0.78, 0
9806, 1.3, 0.795, 0
9807, 1.3125, 0.78, 0
9808, 1.325, 0.795, 0
9809, 1.3375, 0.78, 0
9810, 1.35, 0.795, 0
9811, 1.3625, 0.78, 0
9812, 1.375, 0.795, 0
9813, 1.3875, 0.78, 0
9814, 1.4, 0.795, 0
9815, 1.4125, 0.78, 0
9816, 1.425, 0.795, 0
9817, 1.4375, 0.78, 0
9818, 1.45, 0.795, 0
9819, 1.4625, 0.78, 0
9820, 1.475, 0.795, 0
9821, 1.4875, 0.78, 0
9822, 1.5, 0.795, 0
9823, 1.5125, 0.78, 0
9824, 1.525, 0.795, 0
9825, 1.5375, 0.78, 0
9826, 1.55, 0.795, 0
9827, 1.5625, 0.78, 0
9828, 1.575, 0.795, 0
9829, 1.5875, 0.78, 0
9830, 1.6, 0.795, 0
9831, 1.6125, 0.78, 0
9832, 1.625, 0.795, 0
9833, 1.6375, 0.78, 0
9834, 1.65, 0.795, 0
9835, 1.6625, 0.78, 0
9836, 1.675, 0.795, 0
9837, 1.6875, 0.78, 0
9838, 1.7, 0.795, 0
9839, 1.7125, 0.78, 0
9840, 1.725, 0.795, 0
9841, 1.7375, 0.78, 0
9842, 1.75, 0.795, 0
9843, 1.7625, 0.78, 0
9844, 1.775, 0.795, 0
9845, 1.7875, 0.78, 0
9846, 1.8, 0.795, 0
9847, 1.8125, 0.78, 0
9848, 1.825, 0.795, 0
9849, 1.8375, 0.78, 0
9850, 1.85, 0.795, 0
9851, 1.8625, 0.78, 0
9852, 1.875, 0.795, 0
9853, 1.8875, 0.78, 0
9854, 1.9, 0.795, 0
9855, 1.9125, 0.78, 0
9856, 1.925, 0.795, 0
9857, 1.9375, 0.78, 0
9858, 1.95, 0.795, 0
9859, 1.9625, 0.78, 0
9860, 1.975, 0.795, 0
9861, 1.9875, 0.78, 0
9862, 2, 0.795, 0
9863, 2.0125, 0.78, 0
9864, 2.025, 0.795, 0
9865, 2.0375, 0.78, 0
9866, 2.05, 0.795, 0
9867, 2.0625, 0.78, 0
9868, 2.075, 0.795, 0
9869, 2.0875, 0.78, 0
9870, 2.1, 0.795, 0
9871, 2.1125, 0.78, 0
9872, 2.125, 0.795, 0
9873, 2.1375, 0.78, 0
9874, 2.15, 0.795, 0
9875, 2.1625, 0.78, 0
9876, 2.175, 0.795, 0
9877, 2.1875, 0.78, 0
9878, 1.2125, 0.75, 0
9879, 1.225, 0.765, 0
9880, 1.2375, 0.75, 0
9881, 1.25, 0.765, 0
9882, 1.2625, 0.75, 0
9883, 1.275, 0.765, 0
9884, 1.2875, 0.75, 0
9885, 1.3, 0.765, 0
9886, 1.3125, 0.75, 0
9887, 1.325, 0.765, 0
9888, 1.3375, 0.75, 0
9889, 1.35, 0.765, 0
9890, 1.3625, 0.75, 0
9891, 1.375, 0.765, 0
9892, 1.3875, 0.75, 0
9893, 1.4, 0.765, 0
9894, 1.4125, 0.75, 0
9895, 1.425, 0.765, 0
9896, 1.4375, 0.75, 0
9897, 1.45, 0.765, 0
9898, 1.4625, 0.75, 0
9899, 1.475, 0.765, 0
9900, 1.4875, 0.75, 0
9901, 1.5, 0.765, 0
9902, 1.5125, 0.75, 0
9903, 1.525, 0.765, 0
9904, 1.5375, 0.75, 0
9905, 1.55, 0.765, 0
9906, 1.5625, 0.75, 0
9907, 1.575, 0.765, 0
9908, 1.5875, 0.75, 0
9909, 1.6, 0.765, 0
9910, 1.6125, 0.75, 0
9911, 1.625, 0.765, 0
9912, 1.6375, 0.75, 0
9913, 1.65, 0.765, 0
9914, 1.6625, 0.75, 0
9915, 1.675, 0.765, 0
9916, 1.6875, 0.75, 0
9917, 1.7, 0.765, 0
9918, 1.7125, 0.75, 0
9919, 1.725, 0.765, 0
9920, 1.7375, 0.75, 0
9921, 1.75, 0.765, 0
9922, 1.7625, 0.75, 0
9923, 1.775, 0.765, 0
9924, 1.7875, 0.75, 0
9925, 1.8, 0.765, 0
9926, 1.8125, 0.75, 0
9927, 1.825, 0.765, 0
9928, 1.8375, 0.75, 0
9929, 1.85, 0.765, 0
9930, 1.8625, 0.75, 0
9931, 1.875, 0.765, 0
9932, 1.8875, 0.75, 0
9933, 1.9, 0.765, 0
9934, 1.9125, 0.75, 0
9935, 1.925, 0.765, 0
9936, 1.9375, 0.75, 0
9937, 1.95, 0.765, 0
9938, 1.9625, 0.75, 0
9939, 1.975, 0.765, 0
9940, 1.9875, 0.75, 0
9941, 2, 0.765, 0
9942, 2.0125, 0.75, 0
9943, 2.025, 0.765, 0
9944, 2.0375, 0.75, 0
9945, 2.05, 0.765, 0
9946, 2.0625, 0.75, 0
9947, 2.075, 0.765, 0
9948, 2.0875, 0.75, 0
9949, 2.1, 0.765, 0
9950, 2.1125, 0.75, 0
9951, 2.125, 0.765, 0
9952, 2.1375, 0.75, 0
9953, 2.15, 0.765, 0
9954, 2.1625, 0.75, 0
9955, 2.175, 0.765, 0
9956, 2.1875, 0.75, 0
9957, 1.2125, 0.72, 0
9958, 1.225, 0.735, 0
9959, 1.2375, 0.72, 0
9960, 1.25, 0.735, 0
9961, 1.2625, 0.72, 0
9962, 1.275, 0.735, 0
9963, 1.2875, 0.72, 0
9964, 1.3, 0.735, 0
9965, 1.3125, 0.72, 0
9966, 1.325, 0.735, 0
9967, 1.3375, 0.72, 0
9968, 1.35, 0.735, 0
9969, 1.3625, 0.72, 0
9970, 1.375, 0.735, 0
9971, 1.3875, 0.72, 0
9972, 1.4, 0.735, 0
9973, 1.4125, 0.72, 0
9974, 1.425, 0.735, 0
9975, 1.4375, 0.72, 0
9976, 1.45, 0.735, 0
9977, 1.4625, 0.72, 0
9978, 1.475, 0.735, 0
9979, 1.4875, 0.72, 0
9980, 1.5, 0.735, 0
9981, 1.5125, 0.72, 0
9982, 1.525, 0.735, 0
9983, 1.5375, 0.72, 0
9984, 1.55, 0.735, 0
9985, 1.5625, 0.72, 0
9986, 1.575, 0.735, 0
9987, 1.5875, 0.72, 0
9988, 1.6, 0.735, 0
9989, 1.6125, 0.72, 0
9990, 1.625, 0.735, 0
9991, 1.6375, 0.72, 0
9992, 1.65, 0.735, 0
9993, 1.6625, 0.72, 0
9994, 1.675, 0.735, 0
9995, 1.6875, 0.72, 0
9996, 1.7, 0.735, 0
9997, 1.7125, 0.72, 0
9998, 1.725, 0.735, 0
9999, 1.7375, 0.72, 0
10000, 1.75, 0.735, 0
10001, 1.7625, 0.72, 0
10002, 1.775, 0.735, 0
10003, 1.7875, 0.72, 0
10004, 1.8, 0.735, 0
10005, 1.8125, 0.72, 0
10006, 1.825, 0.735, 0
10007, 1.8375, 0.72, 0
10008, 1.85, 0.735, 0
10009, 1.8625, 0.72, 0
10010, 1.875, 0.735, 0
10011, 1.8875, 0.72, 0
10012, 1.9, 0.735, 0
10013, 1.9125, 0.72, 0
10014, 1.925, 0.735, 0
10015, 1.9375, 0.72, 0
10016, 1.95, 0.735, 0
10017, 1.9625, 0.72, 0
10018, 1.975, 0.735, 0
10019, 1.9875, 0.72, 0
10020, 2, 0.735, 0
10021, 2.0125, 0.72, 0
10022, 2.025, 0.735, 0
10023, 2.0375, 0.72, 0
10024, 2.05, 0.735, 0
10025, 2.0625, 0.72, 0
10026, 2.075, 0.735, 0
10027, 2.0875, 0.72, 0
10028, 2.1, 0.735, 0
10029, 2.1125, 0.72, 0
10030, 2.125, 0.735, 0
10031, 2.1375, 0.72, 0
10032, 2.15, 0.735, 0
10033, 2.1625, 0.72, 0
10034, 2.175, 0.735, 0
10035, 2.1875, 0.72, 0
10036, 1.2125, 0.69, 0
10037, 1.225, 0.705, 0
10038, 1.2375, 0.69, 0
10039, 1.25, 0.705, 0
10040, 1.2625, 0.69, 0
10041, 1.275, 0.705, 0
10042, 1.2875, 0.69, 0
10043, 1.3, 0.705, 0
10044, 1.3125, 0.69, 0
10045, 1.325, 0.705, 0
10046, 1.3375, 0.69, 0
10047, 1.35, 0.705, 0
10048, 1.3625, 0.69, 0
10049, 1.375, 0.705, 0
10050, 1.3875, 0.69, 0
10051, 1.4, 0.705, 0
10052, 1.4125, 0.69, 0
10053, 1.425, 0.705, 0
10054, 1.4375, 0.69, 0
10055, 1.45, 0.705, 0
10056, 1.4625, 0.69, 0
10057, 1.475, 0.705, 0
10058, 1.4875, 0.69, 0
10059, 1.5, 0.705, 0
10060, 1.5125, 0.69, 0
10061, 1.525, 0.705, 0
10062, 1.5375, 0.69, 0
10063, 1.55, 0.705, 0
10064, 1.5625, 0.69, 0
10065, 1.575, 0.705, 0
10066, 1.5875, 0.69, 0
10067, 1.6, 0.705, 0
10068, 1.6125, 0.69, 0
10069, 1.625, 0.705, 0
10070, 1.6375, 0.69, 0
10071, 1.65, 0.705, 0
10072, 1.6625, 0.69, 0
10073, 1.675, 0.705, 0
10074, 1.6875, 0.69, 0
10075, 1.7, 0.705, 0
10076, 1.7125, 0.69, 0
10077, 1.725, 0.705, 0
10078, 1.7375, 0.69, 0
10079, 1.75, 0.705, 0
10080, 1.7625, 0.69, 0
10081, 1.775, 0.705, 0
10082, 1.7875, 0.69, 0
10083, 1.8, 0.705, 0
10084, 1.8125, 0.69, 0
10085, 1.825, 0.705, 0
10086, 1.8375, 0.69, 0
10087, 1.85, 0.705, 0
10088, 1.8625, 0.69, 0
10089, 1.875, 0.705, 0
10090, 1.8875, 0.69, 0
10091, 1.9, 0.705, 0
10092, 1.9125, 0.69, 0
10093, 1.925, 0.705, 0
10094, 1.9375, 0.69, 0
10095, 1.95, 0.705, 0
10096, 1.9625, 0.69, 0
10097, 1.975, 0.705, 0
10098, 1.9875, 0.69, 0
10099, 2, 0.705, 0
10100, 2.0125, 0.69, 0
10101, 2.025, 0.705, 0
10102, 2.0375, 0.69, 0
10103, 2.05, 0.705, 0
10104, 2.0625, 0.69, 0
10105, 2.075, 0.705, 0
10106, 2.0875, 0.69, 0
10107, 2.1, 0.705, 0
10108, 2.1125, 0.69, 0
10109, 2.125, 0.705, 0
10110, 2.1375, 0.69, 0
10111, 2.15, 0.705, 0
10112, 2.1625, 0.69, 0
10113, 2.175, 0.705, 0
10114, 2.1875, 0.69, 0
10115, 1.2125, 0.66, 0
10116, 1.225, 0.675, 0
10117, 1.2375, 0.66, 0
10118, 1.25, 0.675, 0
10119, 1.2625, 0.66, 0
10120, 1.275, 0.675, 0
10121, 1.2875, 0.66, 0
10122, 1.3, 0.675, 0
10123, 1.3125, 0.66, 0
10124, 1.325, 0.675, 0
10125, 1.3375, 0.66, 0
10126, 1.35, 0.675, 0
10127, 1.3625, 0.66, 0
10128, 1.375, 0.675, 0
10129, 1.3875, 0.66, 0
10130, 1.4, 0.675, 0
10131, 1.4125, 0.66, 0
10132, 1.425, 0.675, 0
10133, 1.4375, 0.66, 0
10134, 1.45, 0.675, 0
10135, 1.4625, 0.66, 0
10136, 1.475, 0.675, 0
10137, 1.4875, 0.66, 0
10138, 1.5, 0.675, 0
10139, 1.5125, 0.66, 0
10140, 1.525, 0.675, 0
10141, 1.5375, 0.66, 0
10142, 1.55, 0.675, 0
10143, 1.5625, 0.66, 0
10144, 1.575, 0.675, 0
10145, 1.5875, 0.66, 0
10146, 1.6, 0.675, 0
10147, 1.6125, 0.66, 0
10148, 1.625, 0.675, 0
10149, 1.6375, 0.66, 0
10150, 1.65, 0.675, 0
10151, 1.6625, 0.66, 0
10152, 1.675, 0.675, 0
10153, 1.6875, 0.66, 0
10154, 1.7, 0.675, 0
10155, 1.7125, 0.66, 0
10156, 1.725, 0.675, 0
10157, 1.7375, 0.66, 0
10158, 1.75, 0.675, 0
10159, 1.7625, 0.66, 0
10160, 1.775, 0.675, 0
10161, 1.7875, 0.66, 0
10162, 1.8, 0.675, 0
10163, 1.8125, 0.66, 0
10164, 1.825, 0.675, 0
10165, 1.8375, 0.66, 0
10166, 1.85, 0.675, 0
10167, 1.8625, 0.66, 0
10168, 1.875, 0.675, 0
10169, 1.8875, 0.66, 0
10170, 1.9, 0.675, 0
10171, 1.9125, 0.66, 0
10172, 1.925, 0.675, 0
10173, 1.9375, 0.66, 0
10174, 1.95, 0.675, 0
10175, 1.9625, 0.66, 0
10176, 1.975, 0.675, 0
10177, 1.9875, 0.66, 0
10178, 2, 0.675, 0
10179, 2.0125, 0.66, 0
10180, 2.025, 0.675, 0
10181, 2.0375, 0.66, 0
10182, 2.05, 0.675, 0
10183, 2.0625, 0.66, 0
10184, 2.075, 0.675, 0
10185, 2.0875, 0.66, 0
10186, 2.1, 0.675, 0
10187, 2.1125, 0.66, 0
10188, 2.125, 0.675, 0
10189, 2.1375, 0.66, 0
10190, 2.15, 0.675, 0
10191, 2.1625, 0.66, 0
10192, 2.175, 0.675, 0
10193, 2.1875, 0.66, 0
10194, 1.2125, 0.63, 0
10195, 1.225, 0.645, 0
10196, 1.2375, 0.63, 0
10197, 1.25, 0.645, 0
10198, 1.2625, 0.63, 0
10199, 1.275, 0.645, 0
10200, 1.2875, 0.63, 0
10201, 1.3, 0.645, 0
10202, 1.3125, 0.63, 0
10203, 1.325, 0.645, 0
10204, 1.3375, 0.63, 0
10205, 1.35, 0.645, 0
10206, 1.3625, 0.63, 0
10207, 1.375, 0.645, 0
10208, 1.3875, 0.63, 0
10209, 1.4, 0.645, 0
10210, 1.4125, 0.63, 0
10211, 1.425, 0.645, 0
10212, 1.4375, 0.63, 0
10213, 1.45, 0.645, 0
10214, 1.4625, 0.63, 0
10215, 1.475, 0.645, 0
10216, 1.4875, 0.63, 0
10217, 1.5, 0.645, 0
10218, 1.5125, 0.63, 0
10219, 1.525, 0.645, 0
10220, 1.5375, 0.63, 0
10221, 1.55, 0.645, 0
10222, 1.5625, 0.63, 0
10223, 1.575, 0.645, 0
10224, 1.5875, 0.63, 0
10225, 1.6, 0.645, 0
10226, 1.6125, 0.63, 0
10227, 1.625, 0.645, 0
10228, 1.6375, 0.63, 0
10229, 1.65, 0.645, 0
10230, 1.6625, 0.63, 0
10231, 1.675, 0.645, 0
10232, 1.6875, 0.63, 0
10233, 1.7, 0.645, 0
10234, 1.7125, 0.63, 0
10235, 1.725, 0.645, 0
10236, 1.7375, 0.63, 0
10237, 1.75, 0.645, 0
10238, 1.7625, 0.63, 0
10239, 1.775, 0.645, 0
10240, 1.7875, 0.63, 0
10241, 1.8, 0.645, 0
10242, 1.8125, 0.63, 0
10243, 1.825, 0.645, 0
10244, 1.8375, 0.63, 0
10245, 1.85, 0.645, 0
10246, 1.8625, 0.63, 0
10247, 1.875, 0.645, 0
10248, 1.8875, 0.63, 0
10249, 1.9, 0.645, 0
10250, 1.9125, 0.63, 0
10251, 1.925, 0.645, 0
10252, 1.9375, 0.63, 0
10253, 1.95, 0.645, 0
10254, 1.9625, 0.63, 0
10255, 1.975, 0.645, 0
10256, 1.9875, 0.63, 0
10257, 2, 0.645, 0
10258, 2.0125, 0.63, 0
10259, 2.025, 0.645, 0
10260, 2.0375, 0.63, 0
10261, 2.05, 0.645, 0
10262, 2.0625, 0.63, 0
10263, 2.075, 0.645, 0
10264, 2.0875, 0.63, 0
10265, 2.1, 0.645, 0
10266, 2.1125, 0.63, 0
10267, 2.125, 0.645, 0
10268, 2.1375, 0.63, 0
10269, 2.15, 0.645, 0
10270, 2.1625, 0.63, 0
10271, 2.175, 0.645, 0
10272, 2.1875, 0.63, 0
10273, 1.2125, 0.6, 0
10274, 1.225, 0.615, 0
10275, 1.2375, 0.6, 0
10276, 1.25, 0.615, 0
10277, 1.2625, 0.6, 0
10278, 1.275, 0.615, 0
10279, 1.2875, 0.6, 0
10280, 1.3, 0.615, 0
10281, 1.3125, 0.6, 0
10282, 1.325, 0.615, 0
10283, 1.3375, 0.6, 0
10284, 1.35, 0.615, 0
10285, 1.3625, 0.6, 0
10286, 1.375, 0.615, 0
10287, 1.3875, 0.6, 0
10288, 1.4, 0.615, 0
10289, 1.4125, 0.6, 0
10290, 1.425, 0.615, 0
10291, 1.4375, 0.6, 0
10292, 1.45, 0.615, 0
10293, 1.4625, 0.6, 0
10294, 1.475, 0.615, 0
10295, 1.4875, 0.6, 0
10296, 1.5, 0.615, 0
10297, 1.5125, 0.6, 0
10298, 1.525, 0.615, 0
10299, 1.5375, 0.6, 0
10300, 1.55, 0.615, 0
10301, 1.5625, 0.6, 0
10302, 1.575, 0.615, 0
10303, 1.5875, 0.6, 0
10304, 1.6, 0.615, 0
10305, 1.6125, 0.6, 0
10306, 1.625, 0.615, 0
10307, 1.6375, 0.6, 0
10308, 1.65, 0.615, 0
10309, 1.6625, 0.6, 0
10310, 1.675, 0.615, 0
10311, 1.6875, 0.6, 0
10312, 1.7, 0.615, 0
10313, 1.7125, 0.6, 0
10314, 1.725, 0.615, 0
10315, 1.7375, 0.6, 0
10316, 1.75, 0.615, 0
10317, 1.7625, 0.6, 0
10318, 1.775, 0.615, 0
10319, 1.7875, 0.6, 0
10320, 1.8, 0.615, 0
10321, 1.8125, 0.6, 0
10322, 1.825, 0.615, 0
10323, 1.8375, 0.6, 0
10324, 1.85, 0.615, 0
10325, 1.8625, 0.6, 0
10326, 1.875, 0.615, 0
10327, 1.8875, 0.6, 0
10328, 1.9, 0.615, 0
10329, 1.9125, 0.6, 0
10330, 1.925, 0.615, 0
10331, 1.9375, 0.6, 0
10332, 1.95, 0.615, 0
10333, 1.9625, 0.6, 0
10334, 1.975, 0.615, 0
10335, 1.9875, 0.6, 0
10336, 2, 0.615, 0
10337, 2.0125, 0.6, 0
10338, 2.025, 0.615, 0
10339, 2.0375, 0.6, 0
10340, 2.05, 0.615, 0
10341, 2.0625, 0.6, 0
10342, 2.075, 0.615, 0
10343, 2.0875, 0.6, 0
10344, 2.1, 0.615, 0
10345, 2.1125, 0.6, 0
10346, 2.125, 0.615, 0
10347, 2.1375, 0.6, 0
10348, 2.15, 0.615, 0
10349, 2.1625, 0.6, 0
10350, 2.175, 0.615, 0
10351, 2.1875, 0.6, 0
10352, 1.2125, 0.57, 0
10353, 1.225, 0.585, 0
10354, 1.2375, 0.57, 0
10355, 1.25, 0.585, 0
10356, 1.2625, 0.57, 0
10357, 1.275, 0.585, 0
10358, 1.2875, 0.57, 0
10359, 1.3, 0.585, 0
10360, 1.3125, 0.57, 0
10361, 1.325, 0.585, 0
10362, 1.3375, 0.57, 0
10363, 1.35, 0.585, 0
10364, 1.3625, 0.57, 0
10365, 1.375, 0.585, 0
10366, 1.3875, 0.57, 0
10367, 1.4, 0.585, 0
10368, 1.4125, 0.57, 0
10369, 1.425, 0.585, 0
10370, 1.4375, 0.57, 0
10371, 1.45, 0.585, 0
10372, 1.4625, 0.57, 0
10373, 1.475, 0.585, 0
10374, 1.4875, 0.57, 0
10375, 1.5, 0.585, 0
10376, 1.5125, 0.57, 0
10377, 1.525, 0.585, 0
10378, 1.5375, 0.57, 0
10379, 1.55, 0.585, 0
10380, 1.5625, 0.57, 0
10381, 1.575, 0.585, 0
10382, 1.5875, 0.57, 0
10383, 1.6, 0.585, 0
10384, 1.6125, 0.57, 0
10385, 1.625, 0.585, 0
10386, 1.6375, 0.57, 0
10387, 1.65, 0.585, 0
10388, 1.6625, 0.57, 0
10389, 1.675, 0.585, 0
10390, 1.6875, 0.57, 0
10391, 1.7, 0.585, 0
10392, 1.7125, 0.57, 0
10393, 1.725, 0.585, 0
10394, 1.7375, 0.57, 0
10395, 1.75, 0.585, 0
10396, 1.7625, 0.57, 0
10397, 1.775, 0.585, 0
10398, 1.7875, 0.57, 0
10399, 1.8, 0.585, 0
10400, 1.8125, 0.57, 0
10401, 1.825, 0.585, 0
10402, 1.8375, 0.57, 0
10403, 1.85, 0.585, 0
10404, 1.8625, 0.57, 0
10405, 1.875, 0.585, 0
10406, 1.8875, 0.57, 0
10407, 1.9, 0.585, 0
10408, 1.9125, 0.57, 0
10409, 1.925, 0.585, 0
10410, 1.9375, 0.57, 0
10411, 1.95, 0.585, 0
10412, 1.9625, 0.57, 0
10413, 1.975, 0.585, 0
10414, 1.9875, 0.57, 0
10415, 2, 0.585, 0
10416, 2.0125, 0.57, 0
10417, 2.025, 0.585, 0
10418, 2.0375, 0.57, 0
10419, 2.05, 0.585, 0
10420, 2.0625, 0.57, 0
10421, 2.075, 0.585, 0
10422, 2.0875, 0.57, 0
10423, 2.1, 0.585, 0
10424, 2.1125, 0.57, 0
10425, 2.125, 0.585, 0
10426, 2.1375, 0.57, 0
10427, 2.15, 0.585, 0
10428, 2.1625, 0.57, 0
10429, 2.175, 0.585, 0
10430, 2.1875, 0.57, 0
10431, 1.2125, 0.54, 0
10432, 1.225, 0.555, 0
10433, 1.2375, 0.54, 0
10434, 1.25, 0.555, 0
10435, 1.2625, 0.54, 0
10436, 1.275, 0.555, 0
10437, 1.2875, 0.54, 0
10438, 1.3, 0.555, 0
10439, 1.3125, 0.54, 0
10440, 1.325, 0.555, 0
10441, 1.3375, 0.54, 0
10442, 1.35, 0.555, 0
10443, 1.3625, 0.54, 0
10444, 1.375, 0.555, 0
10445, 1.3875, 0.54, 0
10446, 1.4, 0.555, 0
10447, 1.4125, 0.54, 0
10448, 1.425, 0.555, 0
10449, 1.4375, 0.54, 0
10450, 1.45, 0.555, 0
10451, 1.4625, 0.54, 0
10452, 1.475, 0.555, 0
10453, 1.4875, 0.54, 0
10454, 1.5, 0.555, 0
10455, 1.5125, 0.54, 0
10456, 1.525, 0.555, 0
10457, 1.5375, 0.54, 0
10458, 1.55, 0.555, 0
10459, 1.5625, 0.54, 0
10460, 1.575, 0.555, 0
10461, 1.5875, 0.54, 0
10462, 1.6, 0.555, 0
10463, 1.6125, 0.54, 0
10464, 1.625, 0.555, 0
10465, 1.6375, 0.54, 0
10466, 1.65, 0.555, 0
10467, 1.6625, 0.54, 0
10468, 1.675, 0.555, 0
10469, 1.6875, 0.54, 0
10470, 1.7, 0.555, 0
10471, 1.7125, 0.54, 0
10472, 1.725, 0.555, 0
10473, 1.7375, 0.54, 0
10474, 1.75, 0.555, 0
10475, 1.7625, 0.54, 0
10476, 1.775, 0.555, 0
10477, 1.7875, 0.54, 0
10478, 1.8, 0.555, 0
10479, 1.8125, 0.54, 0
10480, 1.825, 0.555, 0
10481, 1.8375, 0.54, 0
10482, 1.85, 0.555, 0
10483, 1.8625, 0.54, 0
10484, 1.875, 0.555, 0
10485, 1.8875, 0.54, 0
10486, 1.9, 0.555, 0
10487, 1.9125, 0.54, 0
10488, 1.925, 0.555, 0
10489, 1.9375, 0.54, 0
10490, 1.95, 0.555, 0
10491, 1.9625, 0.54, 0
10492, 1.975, 0.555, 0
10493, 1.9875, 0.54, 0
10494, 2, 0.555, 0
10495, 2.0125, 0.54, 0
10496, 2.025, 0.555, 0
10497, 2.0375, 0.54, 0
10498, 2.05, 0.555, 0
10499, 2.0625, 0.54, 0
10500, 2.075, 0.555, 0
10501, 2.0875, 0.54, 0
10502, 2.1, 0.555, 0
10503, 2.1125, 0.54, 0
10504, 2.125, 0.555, 0
10505, 2.1375, 0.54, 0
10506, 2.15, 0.555, 0
10507, 2.1625, 0.54, 0
10508, 2.175, 0.555, 0
10509, 2.1875, 0.54, 0
10510, 1.2125, 0.51, 0
10511, 1.225, 0.525, 0
10512, 1.2375, 0.51, 0
10513, 1.25, 0.525, 0
10514, 1.2625, 0.51, 0
10515, 1.275, 0.525, 0
10516, 1.2875, 0.51, 0
10517, 1.3, 0.525, 0
10518, 1.3125, 0.51, 0
10519, 1.325, 0.525, 0
10520, 1.3375, 0.51, 0
10521, 1.35, 0.525, 0
10522, 1.3625, 0.51, 0
10523, 1.375, 0.525, 0
10524, 1.3875, 0.51, 0
10525, 1.4, 0.525, 0
10526, 1.4125, 0.51, 0
10527, 1.425, 0.525, 0
10528, 1.4375, 0.51, 0
10529, 1.45, 0.525, 0
10530, 1.4625, 0.51, 0
10531, 1.475, 0.525, 0
10532, 1.4875, 0.51, 0
10533, 1.5, 0.525, 0
10534, 1.5125, 0.51, 0
10535, 1.525, 0.525, 0
10536, 1.5375, 0.51, 0
10537, 1.55, 0.525, 0
10538, 1.5625, 0.51, 0
10539, 1.575, 0.525, 0
10540, 1.5875, 0.51, 0
10541, 1.6, 0.525, 0
10542, 1.6125, 0.51, 0
10543, 1.625, 0.525, 0
10544, 1.6375, 0.51, 0
10545, 1.65, 0.525, 0
10546, 1.6625, 0.51, 0
10547, 1.675, 0.525, 0
10548, 1.6875, 0.51, 0
10549, 1.7, 0.525, 0
10550, 1.7125, 0.51, 0
10551, 1.725, 0.525, 0
10552, 1.7375, 0.51, 0
10553, 1.75, 0.525, 0
10554, 1.7625, 0.51, 0
10555, 1.775, 0.525, 0
10556, 1.7875, 0.51, 0
10557, 1.8, 0.525, 0
10558, 1.8125, 0.51, 0
10559, 1.825, 0.525, 0
10560, 1.8375, 0.51, 0
10561, 1.85, 0.525, 0
10562, 1.8625, 0.51, 0
10563, 1.875, 0.525, 0
10564, 1.8875, 0.51, 0
10565, 1.9, 0.525, 0
10566, 1.9125, 0.51, 0
10567, 1.925, 0.525, 0
10568, 1.9375, 0.51, 0
10569, 1.95, 0.525, 0
10570, 1.9625, 0.51, 0
10571, 1.975, 0.525, 0
10572, 1.9875, 0.51, 0
10573, 2, 0.525, 0
10574, 2.0125, 0.51, 0
10575, 2.025, 0.525, 0
10576, 2.0375, 0.51, 0
10577, 2.05, 0.525, 0
10578, 2.0625, 0.51, 0
10579, 2.075, 0.525, 0
10580, 2.0875, 0.51, 0
10581, 2.1, 0.525, 0
10582, 2.1125, 0.51, 0
10583, 2.125, 0.525, 0
10584, 2.1375, 0.51, 0
10585, 2.15, 0.525, 0
10586, 2.1625, 0.51, 0
10587, 2.175, 0.525, 0
10588, 2.1875, 0.51, 0
10589, 1.2125, 0.48, 0
10590, 1.225, 0.495, 0
10591, 1.2375, 0.48, 0
10592, 1.25, 0.495, 0
10593, 1.2625, 0.48, 0
10594, 1.275, 0.495, 0
10595, 1.2875, 0.48, 0
10596, 1.3, 0.495, 0
10597, 1.3125, 0.48, 0
10598, 1.325, 0.495, 0
10599, 1.3375, 0.48, 0
10600, 1.35, 0.495, 0
10601, 1.3625, 0.48, 0
10602, 1.375, 0.495, 0
10603, 1.3875, 0.48, 0
10604, 1.4, 0.495, 0
10605, 1.4125, 0.48, 0
10606, 1.425, 0.495, 0
10607, 1.4375, 0.48, 0
10608, 1.45, 0.495, 0
10609, 1.4625, 0.48, 0
10610, 1.475, 0.495, 0
10611, 1.4875, 0.48, 0
10612, 1.5, 0.495, 0
10613, 1.5125, 0.48, 0
10614, 1.525, 0.495, 0
10615, 1.5375, 0.48, 0
10616, 1.55, 0.495, 0
10617, 1.5625, 0.48, 0
10618, 1.575, 0.495, 0
10619, 1.5875, 0.48, 0
10620, 1.6, 0.495, 0
10621, 1.6125, 0.48, 0
10622, 1.625, 0.495, 0
10623, 1.6375, 0.48, 0
10624, 1.65, 0.495, 0
10625, 1.6625, 0.48, 0
10626, 1.675, 0.495, 0
10627, 1.6875, 0.48, 0
10628, 1.7, 0.495, 0
10629, 1.7125, 0.48, 0
10630, 1.725, 0.495, 0
10631, 1.7375, 0.48, 0
10632, 1.75, 0.495, 0
10633, 1.7625, 0.48, 0
10634, 1.775, 0.495, 0
10635, 1.7875, 0.48, 0
10636, 1.8, 0.495, 0
10637, 1.8125, 0.48, 0
10638, 1.825, 0.495, 0
10639, 1.8375, 0.48, 0
10640, 1.85, 0.495, 0
10641, 1.8625, 0.48, 0
10642, 1.875, 0.495, 0
10643, 1.8875, 0.48, 0
10644, 1.9, 0.495, 0
10645, 1.9125, 0.48, 0
10646, 1.925, 0.495, 0
10647, 1.9375, 0.48, 0
10648, 1.95, 0.495, 0
10649, 1.9625, 0.48, 0
10650, 1.975, 0.495, 0
10651, 1.9875, 0.48, 0
10652, 2, 0.495, 0
10653, 2.0125, 0.48, 0
10654, 2.025, 0.495, 0
10655, 2.0375, 0.48, 0
10656, 2.05, 0.495, 0
10657, 2.0625, 0.48, 0
10658, 2.075, 0.495, 0
10659, 2.0875, 0.48, 0
10660, 2.1, 0.495, 0
10661, 2.1125, 0.48, 0
10662, 2.125, 0.495, 0
10663, 2.1375, 0.48, 0
10664, 2.15, 0.495, 0
10665, 2.1625, 0.48, 0
10666, 2.175, 0.495, 0
10667, 2.1875, 0.48, 0
10668, 1.2125, 0.45, 0
10669, 1.225, 0.465, 0
10670, 1.2375, 0.45, 0
10671, 1.25, 0.465, 0
10672, 1.2625, 0.45, 0
10673, 1.275, 0.465, 0
10674, 1.2875, 0.45, 0
10675, 1.3, 0.465, 0
10676, 1.3125, 0.45, 0
10677, 1.325, 0.465, 0
10678, 1.3375, 0.45, 0
10679, 1.35, 0.465, 0
10680, 1.3625, 0.45, 0
10681, 1.375, 0.465, 0
10682, 1.3875, 0.45, 0
10683, 1.4, 0.465, 0
10684, 1.4125, 0.45, 0
10685, 1.425, 0.465, 0
10686, 1.4375, 0.45, 0
10687, 1.45, 0.465, 0
10688, 1.4625, 0.45, 0
10689, 1.475, 0.465, 0
10690, 1.4875, 0.45, 0
10691, 1.5, 0.465, 0
10692, 1.5125, 0.45, 0
10693, 1.525, 0.465, 0
10694, 1.5375, 0.45, 0
10695, 1.55, 0.465, 0
10696, 1.5625, 0.45, 0
10697, 1.575, 0.465, 0
10698, 1.5875, 0.45, 0
10699, 1.6, 0.465, 0
10700, 1.6125, 0.45, 0
10701, 1.625, 0.465, 0
10702, 1.6375, 0.45, 0
10703, 1.65, 0.465, 0
10704, 1.6625, 0.45, 0
10705, 1.675, 0.465, 0
10706, 1.6875, 0.45, 0
10707, 1.7, 0.465, 0
10708, 1.7125, 0.45, 0
10709, 1.725, 0.465, 0
10710, 1.7375, 0.45, 0
10711, 1.75, 0.465, 0
10712, 1.7625, 0.45, 0
10713, 1.775, 0.465, 0
10714, 1.7875, 0.45, 0
10715, 1.8, 0.465, 0
10716, 1.8125, 0.45, 0
10717, 1.825, 0.465, 0
10718, 1.8375, 0.45, 0
10719, 1.85, 0.465, 0
10720, 1.8625, 0.45, 0
10721, 1.875, 0.465, 0
10722, 1.8875, 0.45, 0
10723, 1.9, 0.465, 0
10724, 1.9125, 0.45, 0
10725, 1.925, 0.465, 0
10726, 1.9375, 0.45, 0
10727, 1.95, 0.465, 0
10728, 1.9625, 0.45, 0
10729, 1.975, 0.465, 0
10730, 1.9875, 0.45, 0
10731, 2, 0.465, 0
10732, 2.0125, 0.45, 0
10733, 2.025, 0.465, 0
10734, 2.0375, 0.45, 0
10735, 2.05, 0.465, 0
10736, 2.0625, 0.45, 0
10737, 2.075, 0.465, 0
10738, 2.0875, 0.45, 0
10739, 2.1, 0.465, 0
10740, 2.1125, 0.45, 0
10741, 2.125, 0.465, 0
10742, 2.1375, 0.45, 0
10743, 2.15, 0.465, 0
10744, 2.1625, 0.45, 0
10745, 2.175, 0.465, 0
10746, 2.1875, 0.45, 0
10747, 1.2125, 0.42, 0
10748, 1.225, 0.435, 0
10749, 1.2375, 0.42, 0
10750, 1.25, 0.435, 0
10751, 1.2625, 0.42, 0
10752, 1.275, 0.435, 0
10753, 1.2875, 0.42, 0
10754, 1.3, 0.435, 0
10755, 1.3125, 0.42, 0
10756, 1.325, 0.435, 0
10757, 1.3375, 0.42, 0
10758, 1.35, 0.435, 0
10759, 1.3625, 0.42, 0
10760, 1.375, 0.435, 0
10761, 1.3875, 0.42, 0
10762, 1.4, 0.435, 0
10763, 1.4125, 0.42, 0
10764, 1.425, 0.435, 0
10765, 1.4375, 0.42, 0
10766, 1.45, 0.435, 0
10767, 1.4625, 0.42, 0
10768, 1.475, 0.435, 0
10769, 1.4875, 0.42, 0
10770, 1.5, 0.435, 0
10771, 1.5125, 0.42, 0
10772, 1.525, 0.435, 0
10773, 1.5375, 0.42, 0
10774, 1.55, 0.435, 0
10775, 1.5625, 0.42, 0
10776, 1.575, 0.435, 0
10777, 1.5875, 0.42, 0
10778, 1.6, 0.435, 0
10779, 1.6125, 0.42, 0
10780, 1.625, 0.435, 0
10781, 1.6375, 0.42, 0
10782, 1.65, 0.435, 0
10783, 1.6625, 0.42, 0
10784, 1.675, 0.435, 0
10785, 1.6875, 0.42, 0
10786, 1.7, 0.435, 0
10787, 1.7125, 0.42, 0
10788, 1.725, 0.435, 0
10789, 1.7375, 0.42, 0
10790, 1.75, 0.435, 0
10791, 1.7625, 0.42, 0
10792, 1.775, 0.435, 0
10793, 1.7875, 0.42, 0
10794, 1.8, 0.435, 0
10795, 1.8125, 0.42, 0
10796, 1.825, 0.435, 0
10797, 1.8375, 0.42, 0
10798, 1.85, 0.435, 0
10799, 1.8625, 0.42, 0
10800, 1.875, 0.435, 0
10801, 1.8875, 0.42, 0
10802, 1.9, 0.435, 0
10803, 1.9125, 0.42, 0
10804, 1.925, 0.435, 0
10805, 1.9375, 0.42, 0
10806, 1.95, 0.435, 0
10807, 1.9625, 0.42, 0
10808, 1.975, 0.435, 0
10809, 1.9875, 0.42, 0
10810, 2, 0.435, 0
10811, 2.0125, 0.42, 0
10812, 2.025, 0.435, 0
10813, 2.0375, 0.42, 0
10814, 2.05, 0.435, 0
10815, 2.0625, 0.42, 0
10816, 2.075, 0.435, 0
10817, 2.0875, 0.42, 0
10818, 2.1, 0.435, 0
10819, 2.1125, 0.42, 0
10820, 2.125, 0.435, 0
10821, 2.1375, 0.42, 0
10822, 2.15, 0.435, 0
10823, 2.1625, 0.42, 0
10824, 2.175, 0.435, 0
10825, 2.1875, 0.42, 0
10826, 1.2125, 0.39, 0
10827, 1.225, 0.405, 0
10828, 1.2375, 0.39, 0
10829, 1.25, 0.405, 0
10830, 1.2625, 0.39, 0
10831, 1.275, 0.405, 0
10832, 1.2875, 0.39, 0
10833, 1.3, 0.405, 0
10834, 1.3125, 0.39, 0
10835, 1.325, 0.405, 0
10836, 1.3375, 0.39, 0
10837, 1.35, 0.405, 0
10838, 1.3625, 0.39, 0
10839, 1.375, 0.405, 0
10840, 1.3875, 0.39, 0
10841, 1.4, 0.405, 0
10842, 1.4125, 0.39, 0
10843, 1.425, 0.405, 0
10844, 1.4375, 0.39, 0
10845, 1.45, 0.405, 0
10846, 1.4625, 0.39, 0
10847, 1.475, 0.405, 0
10848, 1.4875, 0.39, 0
10849, 1.5, 0.405, 0
10850, 1.5125, 0.39, 0
10851, 1.525, 0.405, 0
10852, 1.5375, 0.39, 0
10853, 1.55, 0.405, 0
10854, 1.5625, 0.39, 0
10855, 1.575, 0.405, 0
10856, 1.5875, 0.39, 0
10857, 1.6, 0.405, 0
10858, 1.6125, 0.39, 0
10859, 1.625, 0.405, 0
10860, 1.6375, 0.39, 0
10861, 1.65, 0.405, 0
10862, 1.6625, 0.39, 0
10863, 1.675, 0.405, 0
10864, 1.6875, 0.39, 0
10865, 1.7, 0.405, 0
10866, 1.7125, 0.39, 0
10867, 1.725, 0.405, 0
10868, 1.7375, 0.39, 0
10869, 1.75, 0.405, 0
10870, 1.7625, 0.39, 0
10871, 1.775, 0.405, 0
10872, 1.7875, 0.39, 0
10873, 1.8, 0.405, 0
10874, 1.8125, 0.39, 0
10875, 1.825, 0.405, 0
10876, 1.8375, 0.39, 0
10877, 1.85, 0.405, 0
10878, 1.8625, 0.39, 0
10879, 1.875, 0.405, 0
10880, 1.8875, 0.39, 0
10881, 1.9, 0.405, 0
10882, 1.9125, 0.39, 0
10883, 1.925, 0.405, 0
10884, 1.9375, 0.39, 0
10885, 1.95, 0.405, 0
10886, 1.9625, 0.39, 0
10887, 1.975, 0.405, 0
10888, 1.9875, 0.39, 0
10889, 2, 0.405, 0
10890, 2.0125, 0.39, 0
10891, 2.025, 0.405, 0
10892, 2.0375, 0.39, 0
10893, 2.05, 0.405, 0
10894, 2.0625, 0.39, 0
10895, 2.075, 0.405, 0
10896, 2.0875, 0.39, 0
10897, 2.1, 0.405, 0
10898, 2.1125, 0.39, 0
10899, 2.125, 0.405, 0
10900, 2.1375, 0.39, 0
10901, 2.15, 0.405, 0
10902, 2.1625, 0.39, 0
10903, 2.175, 0.405, 0
10904, 2.1875, 0.39, 0
10905, 1.2125, 0.36, 0
10906, 1.225, 0.375, 0
10907, 1.2375, 0.36, 0
10908, 1.25, 0.375, 0
10909, 1.2625, 0.36, 0
10910, 1.275, 0.375, 0
10911, 1.2875, 0.36, 0
10912, 1.3, 0.375, 0
10913, 1.3125, 0.36, 0
10914, 1.325, 0.375, 0
10915, 1.3375, 0.36, 0
10916, 1.35, 0.375, 0
10917, 1.3625, 0.36, 0
10918, 1.375, 0.375, 0
10919, 1.3875, 0.36, 0
10920, 1.4, 0.375, 0
10921, 1.4125, 0.36, 0
10922, 1.425, 0.375, 0
10923, 1.4375, 0.36, 0
10924, 1.45, 0.375, 0
10925, 1.4625, 0.36, 0
10926, 1.475, 0.375, 0
10927, 1.4875, 0.36, 0
10928, 1.5, 0.375, 0
10929, 1.5125, 0.36, 0
10930, 1.525, 0.375, 0
10931, 1.5375, 0.36, 0
10932, 1.55, 0.375, 0
10933, 1.5625, 0.36, 0
10934, 1.575, 0.375, 0
10935, 1.5875, 0.36, 0
10936, 1.6, 0.375, 0
10937, 1.6125, 0.36, 0
10938, 1.625, 0.375, 0
10939, 1.6375, 0.36, 0
10940, 1.65, 0.375, 0
10941, 1.6625, 0.36, 0
10942, 1.675, 0.375, 0
10943, 1.6875, 0.36, 0
10944, 1.7, 0.375, 0
10945, 1.7125, 0.36, 0
10946, 1.725, 0.375, 0
10947, 1.7375, 0.36, 0
10948, 1.75, 0.375, 0
10949, 1.7625, 0.36, 0
10950, 1.775, 0.375, 0
10951, 1.7875, 0.36, 0
10952, 1.8, 0.375, 0
10953, 1.8125, 0.36, 0
10954, 1.825, 0.375, 0
10955, 1.8375, 0.36, 0
10956, 1.85, 0.375, 0
10957, 1.8625, 0.36, 0
10958, 1.875, 0.375, 0
10959, 1.8875, 0.36, 0
10960, 1.9, 0.375, 0
10961, 1.9125, 0.36, 0
10962, 1.925, 0.375, 0
10963, 1.9375, 0.36, 0
10964, 1.95, 0.375, 0
10965, 1.9625, 0.36, 0
10966, 1.975, 0.375, 0
10967, 1.9875, 0.36, 0
10968, 2, 0.375, 0
10969, 2.0125, 0.36, 0
10970, 2.025, 0.375, 0
10971, 2.0375, 0.36, 0
10972, 2.05, 0.375, 0
10973, 2.0625, 0.36, 0
10974, 2.075, 0.375, 0
10975, 2.0875, 0.36, 0
10976, 2.1, 0.375, 0
10977, 2.1125, 0.36, 0
10978, 2.125, 0.375, 0
10979, 2.1375, 0.36, 0
10980, 2.15, 0.375, 0
10981, 2.1625, 0.36, 0
10982, 2.175, 0.375, 0
10983, 2.1875, 0.36, 0
10984, 1.2125, 0.33, 0
10985, 1.225, 0.345, 0
10986, 1.2375, 0.33, 0
10987, 1.25, 0.345, 0
10988, 1.2625, 0.33, 0
10989, 1.275, 0.345, 0
10990, 1.2875, 0.33, 0
10991, 1.3, 0.345, 0
10992, 1.3125, 0.33, 0
10993, 1.325, 0.345, 0
10994, 1.3375, 0.33, 0
10995, 1.35, 0.345, 0
10996, 1.3625, 0.33, 0
10997, 1.375, 0.345, 0
10998, 1.3875, 0.33, 0
10999, 1.4, 0.345, 0
11000, 1.4125, 0.33, 0
11001, 1.425, 0.345, 0
11002, 1.4375, 0.33, 0
11003, 1.45, 0.345, 0
11004, 1.4625, 0.33, 0
11005, 1.475, 0.345, 0
11006, 1.4875, 0.33, 0
11007, 1.5, 0.345, 0
11008, 1.5125, 0.33, 0
11009, 1.525, 0.345, 0
11010, 1.5375, 0.33, 0
11011, 1.55, 0.345, 0
11012, 1.5625, 0.33, 0
11013, 1.575, 0.345, 0
11014, 1.5875, 0.33, 0
11015, 1.6, 0.345, 0
11016, 1.6125, 0.33, 0
11017, 1.625, 0.345, 0
11018, 1.6375, 0.33, 0
11019, 1.65, 0.345, 0
11020, 1.6625, 0.33, 0
11021, 1.675, 0.345, 0
11022, 1.6875, 0.33, 0
11023, 1.7, 0.345, 0
11024, 1.7125, 0.33, 0
11025, 1.725, 0.345, 0
11026, 1.7375, 0.33, 0
11027, 1.75, 0.345, 0
11028, 1.7625, 0.33, 0
11029, 1.775, 0.345, 0
11030, 1.7875, 0.33, 0
11031, 1.8, 0.345, 0
11032, 1.8125, 0.33, 0
11033, 1.825, 0.345, 0
11034, 1.8375, 0.33, 0
11035, 1.85, 0.345, 0
11036, 1.8625, 0.33, 0
11037, 1.875, 0.345, 0
11038, 1.8875, 0.33, 0
11039, 1.9, 0.345, 0
11040, 1.9125, 0.33, 0
11041, 1.925, 0.345, 0
11042, 1.9375, 0.33, 0
11043, 1.95, 0.345, 0
11044, 1.9625, 0.33, 0
11045, 1.975, 0.345, 0
11046, 1.9875, 0.33, 0
11047, 2, 0.345, 0
11048, 2.0125, 0.33, 0
11049, 2.025, 0.345, 0
11050, 2.0375, 0.33, 0
11051, 2.05, 0.345, 0
11052, 2.0625, 0.33, 0
11053, 2.075, 0.345, 0
11054, 2.0875, 0.33, 0
11055, 2.1, 0.345, 0
11056, 2.1125, 0.33, 0
11057, 2.125, 0.345, 0
11058, 2.1375, 0.33, 0
11059, 2.15, 0.345, 0
11060, 2.1625, 0.33, 0
11061, 2.175, 0.345, 0
11062, 2.1875, 0.33, 0
11063, 1.2125, 0.3, 0
11064, 1.225, 0.315, 0
11065, 1.2375, 0.3, 0
11066, 1.25, 0.315, 0
11067, 1.2625, 0.3, 0
11068, 1.275, 0.315, 0
11069, 1.2875, 0.3, 0
11070, 1.3, 0.315, 0
11071, 1.3125, 0.3, 0
11072, 1.325, 0.315, 0
11073, 1.3375, 0.3, 0
11074, 1.35, 0.315, 0
11075, 1.3625, 0.3, 0
11076, 1.375, 0.315, 0
11077, 1.3875, 0.3, 0
11078, 1.4, 0.315, 0
11079, 1.4125, 0.3, 0
11080, 1.425, 0.315, 0
11081, 1.4375, 0.3, 0
11082, 1.45, 0.315, 0
11083, 1.4625, 0.3, 0
11084, 1.475, 0.315, 0
11085, 1.4875, 0.3, 0
11086, 1.5, 0.315, 0
11087, 1.5125, 0.3, 0
11088, 1.525, 0.315, 0
11089, 1.5375, 0.3, 0
11090, 1.55, 0.315, 0
11091, 1.5625, 0.3, 0
11092, 1.575, 0.315, 0
11093, 1.5875, 0.3, 0
11094, 1.6, 0.315, 0
11095, 1.6125, 0.3, 0
11096, 1.625, 0.315, 0
11097, 1.6375, 0.3, 0
11098, 1.65, 0.315, 0
11099, 1.6625, 0.3, 0
11100, 1.675, 0.315, 0
11101, 1.6875, 0.3, 0
11102, 1.7, 0.315, 0
11103, 1.7125, 0.3, 0
11104, 1.725, 0.315, 0
11105, 1.7375, 0.3, 0
11106, 1.75, 0.315, 0
11107, 1.7625, 0.3, 0
11108, 1.775, 0.315, 0
11109, 1.7875, 0.3, 0
11110, 1.8, 0.315, 0
11111, 1.8125, 0.3, 0
11112, 1.825, 0.315, 0
11113, 1.8375, 0.3, 0
11114, 1.85, 0.315, 0
11115, 1.8625, 0.3, 0
11116, 1.875, 0.315, 0
11117, 1.8875, 0.3, 0
11118, 1.9, 0.315, 0
11119, 1.9125, 0.3, 0
11120, 1.925, 0.315, 0
11121, 1.9375, 0.3, 0
11122, 1.95, 0.315, 0
11123, 1.9625, 0.3, 0
11124, 1.975, 0.315, 0
11125, 1.9875, 0.3, 0
11126, 2, 0.315, 0
11127, 2.0125, 0.3, 0
11128, 2.025, 0.315, 0
11129, 2.0375, 0.3, 0
11130, 2.05, 0.315, 0
11131, 2.0625, 0.3, 0
11132, 2.075, 0.315, 0
11133, 2.0875, 0.3, 0
11134, 2.1, 0.315, 0
11135, 2.1125, 0.3, 0
11136, 2.125, 0.315, 0
11137, 2.1375, 0.3, 0
11138, 2.15, 0.315, 0
11139, 2.1625, 0.3, 0
11140, 2.175, 0.315, 0
11141, 2.1875, 0.3, 0
11142, 1.2125, 0.27, 0
11143, 1.225, 0.285, 0
11144, 1.2375, 0.27, 0
11145, 1.25, 0.285, 0
11146, 1.2625, 0.27, 0
11147, 1.275, 0.285, 0
11148, 1.2875, 0.27, 0
11149, 1.3, 0.285, 0
11150, 1.3125, 0.27, 0
11151, 1.325, 0.285, 0
11152, 1.3375, 0.27, 0
11153, 1.35, 0.285, 0
11154, 1.3625, 0.27, 0
11155, 1.375, 0.285, 0
11156, 1.3875, 0.27, 0
11157, 1.4, 0.285, 0
11158, 1.4125, 0.27, 0
11159, 1.425, 0.285, 0
11160, 1.4375, 0.27, 0
11161, 1.45, 0.285, 0
11162, 1.4625, 0.27, 0
11163, 1.475, 0.285, 0
11164, 1.4875, 0.27, 0
11165, 1.5, 0.285, 0
11166, 1.5125, 0.27, 0
11167, 1.525, 0.285, 0
11168, 1.5375, 0.27, 0
11169, 1.55, 0.285, 0
11170, 1.5625, 0.27, 0
11171, 1.575, 0.285, 0
11172, 1.5875, 0.27, 0
11173, 1.6, 0.285, 0
11174, 1.6125, 0.27, 0
11175, 1.625, 0.285, 0
11176, 1.6375, 0.27, 0
11177, 1.65, 0.285, 0
11178, 1.6625, 0.27, 0
11179, 1.675, 0.285, 0
11180, 1.6875, 0.27, 0
11181, 1.7, 0.285, 0
11182, 1.7125, 0.27, 0
11183, 1.725, 0.285, 0
11184, 1.7375, 0.27, 0
11185, 1.75, 0.285, 0
11186, 1.7625, 0.27, 0
11187, 1.775, 0.285, 0
11188, 1.7875, 0.27, 0
11189, 1.8, 0.285, 0
11190, 1.8125, 0.27, 0
11191, 1.825, 0.285, 0
11192, 1.8375, 0.27, 0
11193, 1.85, 0.285, 0
11194, 1.8625, 0.27, 0
11195, 1.875, 0.285, 0
11196, 1.8875, 0.27, 0
11197, 1.9, 0.285, 0
11198, 1.9125, 0.27, 0
11199, 1.925, 0.285, 0
11200, 1.9375, 0.27, 0
11201, 1.95, 0.285, 0
11202, 1.9625, 0.27, 0
11203, 1.975, 0.285, 0
11204, 1.9875, 0.27, 0
11205, 2, 0.285, 0
11206, 2.0125, 0.27, 0
11207, 2.025, 0.285, 0
11208, 2.0375, 0.27, 0
11209, 2.05, 0.285, 0
11210, 2.0625, 0.27, 0
11211, 2.075, 0.285, 0
11212, 2.0875, 0.27, 0
11213, 2.1, 0.285, 0
11214, 2.1125, 0.27, 0
11215, 2.125, 0.285, 0
11216, 2.1375, 0.27, 0
11217, 2.15, 0.285, 0
11218, 2.1625, 0.27, 0
11219, 2.175, 0.285, 0
11220, 2.1875, 0.27, 0
11221, 1.2125, 0.24, 0
11222, 1.225, 0.255, 0
11223, 1.2375, 0.24, 0
11224, 1.25, 0.255, 0
11225, 1.2625, 0.24, 0
11226, 1.275, 0.255, 0
11227, 1.2875, 0.24, 0
11228, 1.3, 0.255, 0
11229, 1.3125, 0.24, 0
11230, 1.325, 0.255, 0
11231, 1.3375, 0.24, 0
11232, 1.35, 0.255, 0
11233, 1.3625, 0.24, 0
11234, 1.375, 0.255, 0
11235, 1.3875, 0.24, 0
11236, 1.4, 0.255, 0
11237, 1.4125, 0.24, 0
11238, 1.425, 0.255, 0
11239, 1.4375, 0.24, 0
11240, 1.45, 0.255, 0
11241, 1.4625, 0.24, 0
11242, 1.475, 0.255, 0
11243, 1.4875, 0.24, 0
11244, 1.5, 0.255, 0
11245, 1.5125, 0.24, 0
11246, 1.525, 0.255, 0
11247, 1.5375, 0.24, 0
11248, 1.55, 0.255, 0
11249, 1.5625, 0.24, 0
11250, 1.575, 0.255, 0
11251, 1.5875, 0.24, 0
11252, 1.6, 0.255, 0
11253, 1.6125, 0.24, 0
11254, 1.625, 0.255, 0
11255, 1.6375, 0.24, 0
11256, 1.65, 0.255, 0
11257, 1.6625, 0.24, 0
11258, 1.675, 0.255, 0
11259, 1.6875, 0.24, 0
11260, 1.7, 0.255, 0
11261, 1.7125, 0.24, 0
11262, 1.725, 0.255, 0
11263, 1.7375, 0.24, 0
11264, 1.75, 0.255, 0
11265, 1.7625, 0.24, 0
11266, 1.775, 0.255, 0
11267, 1.7875, 0.24, 0
11268, 1.8, 0.255, 0
11269, 1.8125, 0.24, 0
11270, 1.825, 0.255, 0
11271, 1.8375, 0.24, 0
11272, 1.85, 0.255, 0
11273, 1.8625, 0.24, 0
11274, 1.875, 0.255, 0
11275, 1.8875, 0.24, 0
11276, 1.9, 0.255, 0
11277, 1.9125, 0.24, 0
11278, 1.925, 0.255, 0
11279, 1.9375, 0.24, 0
11280, 1.95, 0.255, 0
11281, 1.9625, 0.24, 0
11282, 1.975, 0.255, 0
11283, 1.9875, 0.24, 0
11284, 2, 0.255, 0
11285, 2.0125, 0.24, 0
11286, 2.025, 0.255, 0
11287, 2.0375, 0.24, 0
11288, 2.05, 0.255, 0
11289, 2.0625, 0.24, 0
11290, 2.075, 0.255, 0
11291, 2.0875, 0.24, 0
11292, 2.1, 0.255, 0
11293, 2.1125, 0.24, 0
11294, 2.125, 0.255, 0
11295, 2.1375, 0.24, 0
11296, 2.15, 0.255, 0
11297, 2.1625, 0.24, 0
11298, 2.175, 0.255, 0
11299, 2.1875, 0.24, 0
11300, 1.2125, 0.21, 0
11301, 1.225, 0.225, 0
11302, 1.2375, 0.21, 0
11303, 1.25, 0.225, 0
11304, 1.2625, 0.21, 0
11305, 1.275, 0.225, 0
11306, 1.2875, 0.21, 0
11307, 1.3, 0.225, 0
11308, 1.3125, 0.21, 0
11309, 1.325, 0.225, 0
11310, 1.3375, 0.21, 0
11311, 1.35, 0.225, 0
11312, 1.3625, 0.21, 0
11313, 1.375, 0.225, 0
11314, 1.3875, 0.21, 0
11315, 1.4, 0.225, 0
11316, 1.4125, 0.21, 0
11317, 1.425, 0.225, 0
11318, 1.4375, 0.21, 0
11319, 1.45, 0.225, 0
11320, 1.4625, 0.21, 0
11321, 1.475, 0.225, 0
11322, 1.4875, 0.21, 0
11323, 1.5, 0.225, 0
11324, 1.5125, 0.21, 0
11325, 1.525, 0.225, 0
11326, 1.5375, 0.21, 0
11327, 1.55, 0.225, 0
11328, 1.5625, 0.21, 0
11329, 1.575, 0.225, 0
11330, 1.5875, 0.21, 0
11331, 1.6, 0.225, 0
11332, 1.6125, 0.21, 0
11333, 1.625, 0.225, 0
11334, 1.6375, 0.21, 0
11335, 1.65, 0.225, 0
11336, 1.6625, 0.21, 0
11337, 1.675, 0.225, 0
11338, 1.6875, 0.21, 0
11339, 1.7, 0.225, 0
11340, 1.7125, 0.21, 0
11341, 1.725, 0.225, 0
11342, 1.7375, 0.21, 0
11343, 1.75, 0.225, 0
11344, 1.7625, 0.21, 0
11345, 1.775, 0.225, 0
11346, 1.7875, 0.21, 0
11347, 1.8, 0.225, 0
11348, 1.8125, 0.21, 0
11349, 1.825, 0.225, 0
11350, 1.8375, 0.21, 0
11351, 1.85, 0.225, 0
11352, 1.8625, 0.21, 0
11353, 1.875, 0.225, 0
11354, 1.8875, 0.21, 0
11355, 1.9, 0.225, 0
11356, 1.9125, 0.21, 0
11357, 1.925, 0.225, 0
11358, 1.9375, 0.21, 0
11359, 1.95, 0.225, 0
11360, 1.9625, 0.21, 0
11361, 1.975, 0.225, 0
11362, 1.9875, 0.21, 0
11363, 2, 0.225, 0
11364, 2.0125, 0.21, 0
11365, 2.025, 0.225, 0
11366, 2.0375, 0.21, 0
11367, 2.05, 0.225, 0
11368, 2.0625, 0.21, 0
11369, 2.075, 0.225, 0
11370, 2.0875, 0.21, 0
11371, 2.1, 0.225, 0
11372, 2.1125, 0.21, 0
11373, 2.125, 0.225, 0
11374, 2.1375, 0.21, 0
11375, 2.15, 0.225, 0
11376, 2.1625, 0.21, 0
11377, 2.175, 0.225, 0
11378, 2.1875, 0.21, 0
11379, 1.2125, 0.18, 0
11380, 1.225, 0.195, 0
11381, 1.2375, 0.18, 0
11382, 1.25, 0.195, 0
11383, 1.2625, 0.18, 0
11384, 1.275, 0.195, 0
11385, 1.2875, 0.18, 0
11386, 1.3, 0.195, 0
11387, 1.3125, 0.18, 0
11388, 1.325, 0.195, 0
11389, 1.3375, 0.18, 0
11390, 1.35, 0.195, 0
11391, 1.3625, 0.18, 0
11392, 1.375, 0.195, 0
11393, 1.3875, 0.18, 0
11394, 1.4, 0.195, 0
11395, 1.4125, 0.18, 0
11396, 1.425, 0.195, 0
11397, 1.4375, 0.18, 0
11398, 1.45, 0.195, 0
11399, 1.4625, 0.18, 0
11400, 1.475, 0.195, 0
11401, 1.4875, 0.18, 0
11402, 1.5, 0.195, 0
11403, 1.5125, 0.18, 0
11404, 1.525, 0.195, 0
11405, 1.5375, 0.18, 0
11406, 1.55, 0.195, 0
11407, 1.5625, 0.18, 0
11408, 1.575, 0.195, 0
11409, 1.5875, 0.18, 0
11410, 1.6, 0.195, 0
11411, 1.6125, 0.18, 0
11412, 1.625, 0.195, 0
11413, 1.6375, 0.18, 0
11414, 1.65, 0.195, 0
11415, 1.6625, 0.18, 0
11416, 1.675, 0.195, 0
11417, 1.6875, 0.18, 0
11418, 1.7, 0.195, 0
11419, 1.7125, 0.18, 0
11420, 1.725, 0.195, 0
11421, 1.7375, 0.18, 0
11422, 1.75, 0.195, 0
11423, 1.7625, 0.18, 0
11424, 1.775, 0.195, 0
11425, 1.7875, 0.18, 0
11426, 1.8, 0.195, 0
11427, 1.8125, 0.18, 0
11428, 1.825, 0.195, 0
11429, 1.8375, 0.18, 0
11430, 1.85, 0.195, 0
11431, 1.8625, 0.18, 0
11432, 1.875, 0.195, 0
11433, 1.8875, 0.18, 0
11434, 1.9, 0.195, 0
11435, 1.9125, 0.18, 0
11436, 1.925, 0.195, 0
11437, 1.9375, 0.18, 0
11438, 1.95, 0.195, 0
11439, 1.9625, 0.18, 0
11440, 1.975, 0.195, 0
11441, 1.9875, 0.18, 0
11442, 2, 0.195, 0
11443, 2.0125, 0.18, 0
11444, 2.025, 0.195, 0
11445, 2.0375, 0.18, 0
11446, 2.05, 0.195, 0
11447, 2.0625, 0.18, 0
11448, 2.075, 0.195, 0
11449, 2.0875, 0.18, 0
11450, 2.1, 0.195, 0
11451, 2.1125, 0.18, 0
11452, 2.125, 0.195, 0
11453, 2.1375, 0.18, 0
11454, 2.15, 0.195, 0
11455, 2.1625, 0.18, 0
11456, 2.175, 0.195, 0
11457, 2.1875, 0.18, 0
11458, 1.2125, 0.15, 0
11459, 1.225, 0.165, 0
11460, 1.2375, 0.15, 0
11461, 1.25, 0.165, 0
11462, 1.2625, 0.15, 0
11463, 1.275, 0.165, 0
11464, 1.2875, 0.15, 0
11465, 1.3, 0.165, 0
11466, 1.3125, 0.15, 0
11467, 1.325, 0.165, 0
11468, 1.3375, 0.15, 0
11469, 1.35, 0.165, 0
11470, 1.3625, 0.15, 0
11471, 1.375, 0.165, 0
11472, 1.3875, 0.15, 0
11473, 1.4, 0.165, 0
11474, 1.4125, 0.15, 0
11475, 1.425, 0.165, 0
11476, 1.4375, 0.15, 0
11477, 1.45, 0.165, 0
11478, 1.4625, 0.15, 0
11479, 1.475, 0.165, 0
11480, 1.4875, 0.15, 0
11481, 1.5, 0.165, 0
11482, 1.5125, 0.15, 0
11483, 1.525, 0.165, 0
11484, 1.5375, 0.15, 0
11485, 1.55, 0.165, 0
11486, 1.5625, 0.15, 0
11487, 1.575, 0.165, 0
11488, 1.5875, 0.15, 0
11489, 1.6, 0.165, 0
11490, 1.6125, 0.15, 0
11491, 1.625, 0.165, 0
11492, 1.6375, 0.15, 0
11493, 1.65, 0.165, 0
11494, 1.6625, 0.15, 0
11495, 1.675, 0.165, 0
11496, 1.6875, 0.15, 0
11497, 1.7, 0.165, 0
11498, 1.7125, 0.15, 0
11499, 1.725, 0.165, 0
11500, 1.7375, 0.15, 0
11501, 1.75, 0.165, 0
11502, 1.7625, 0.15, 0
11503, 1.775, 0.165, 0
11504, 1.7875, 0.15, 0
11505, 1.8, 0.165, 0
11506, 1.8125, 0.15, 0
11507, 1.825, 0.165, 0
11508, 1.8375, 0.15, 0
11509, 1.85, 0.165, 0
11510, 1.8625, 0.15, 0
11511, 1.875, 0.165, 0
11512, 1.8875, 0.15, 0
11513, 1.9, 0.165, 0
11514, 1.9125, 0.15, 0
11515, 1.925, 0.165, 0
11516, 1.9375, 0.15, 0
11517, 1.95, 0.165, 0
11518, 1.9625, 0.15, 0
11519, 1.975, 0.165, 0
11520, 1.9875, 0.15, 0
11521, 2, 0.165, 0
11522, 2.0125, 0.15, 0
11523, 2.025, 0.165, 0
11524, 2.0375, 0.15, 0
11525, 2.05, 0.165, 0
11526, 2.0625, 0.15, 0
11527, 2.075, 0.165, 0
11528, 2.0875, 0.15, 0
11529, 2.1, 0.165, 0
11530, 2.1125, 0.15, 0
11531, 2.125, 0.165, 0
11532, 2.1375, 0.15, 0
11533, 2.15, 0.165, 0
11534, 2.1625, 0.15, 0
11535, 2.175, 0.165, 0
11536, 2.1875, 0.15, 0
11537, 1.2125, 0.12, 0
11538, 1.225, 0.135, 0
11539, 1.2375, 0.12, 0
11540, 1.25, 0.135, 0
11541, 1.2625, 0.12, 0
11542, 1.275, 0.135, 0
11543, 1.2875, 0.12, 0
11544, 1.3, 0.135, 0
11545, 1.3125, 0.12, 0
11546, 1.325, 0.135, 0
11547, 1.3375, 0.12, 0
11548, 1.35, 0.135, 0
11549, 1.3625, 0.12, 0
11550, 1.375, 0.135, 0
11551, 1.3875, 0.12, 0
11552, 1.4, 0.135, 0
11553, 1.4125, 0.12, 0
11554, 1.425, 0.135, 0
11555, 1.4375, 0.12, 0
11556, 1.45, 0.135, 0
11557, 1.4625, 0.12, 0
11558, 1.475, 0.135, 0
11559, 1.4875, 0.12, 0
11560, 1.5, 0.135, 0
11561, 1.5125, 0.12, 0
11562, 1.525, 0.135, 0
11563, 1.5375, 0.12, 0
11564, 1.55, 0.135, 0
11565, 1.5625, 0.12, 0
11566, 1.575, 0.135, 0
11567, 1.5875, 0.12, 0
11568, 1.6, 0.135, 0
11569, 1.6125, 0.12, 0
11570, 1.625, 0.135, 0
11571, 1.6375, 0.12, 0
11572, 1.65, 0.135, 0
11573, 1.6625, 0.12, 0
11574, 1.675, 0.135, 0
11575, 1.6875, 0.12, 0
11576, 1.7, 0.135, 0
11577, 1.7125, 0.12, 0
11578, 1.725, 0.135, 0
11579, 1.7375, 0.12, 0
11580, 1.75, 0.135, 0
11581, 1.7625, 0.12, 0
11582, 1.775, 0.135, 0
11583, 1.7875, 0.12, 0
11584, 1.8, 0.135, 0
11585, 1.8125, 0.12, 0
11586, 1.825, 0.135, 0
11587, 1.8375, 0.12, 0
11588, 1.85, 0.135, 0
11589, 1.8625, 0.12, 0
11590, 1.875, 0.135, 0
11591, 1.8875, 0.12, 0
11592, 1.9, 0.135, 0
11593, 1.9125, 0.12, 0
11594, 1.925, 0.135, 0
11595, 1.9375, 0.12, 0
11596, 1.95, 0.135, 0
11597, 1.9625, 0.12, 0
11598, 1.975, 0.135, 0
11599, 1.9875, 0.12, 0
11600, 2, 0.135, 0
11601, 2.0125, 0.12, 0
11602, 2.025, 0.135, 0
11603, 2.0375, 0.12, 0
11604, 2.05, 0.135, 0
11605, 2.0625, 0.12, 0
11606, 2.075, 0.135, 0
11607, 2.0875, 0.12, 0
11608, 2.1, 0.135, 0
11609, 2.1125, 0.12, 0
11610, 2.125, 0.135, 0
11611, 2.1375, 0.12, 0
11612, 2.15, 0.135, 0
11613, 2.1625, 0.12, 0
11614, 2.175, 0.135, 0
11615, 2.1875, 0.12, 0
11616, 1.2125, 0.09, 0
11617, 1.225, 0.105, 0
11618, 1.2375, 0.09, 0
11619, 1.25, 0.105, 0
11620, 1.2625, 0.09, 0
11621, 1.275, 0.105, 0
11622, 1.2875, 0.09, 0
11623, 1.3, 0.105, 0
11624, 1.3125, 0.09, 0
11625, 1.325, 0.105, 0
11626, 1.3375, 0.09, 0
11627, 1.35, 0.105, 0
11628, 1.3625, 0.09, 0
11629, 1.375, 0.105, 0
11630, 1.3875, 0.09, 0
11631, 1.4, 0.105, 0
11632, 1.4125, 0.09, 0
11633, 1.425, 0.105, 0
11634, 1.4375, 0.09, 0
11635, 1.45, 0.105, 0
11636, 1.4625, 0.09, 0
11637, 1.475, 0.105, 0
11638, 1.4875, 0.09, 0
11639, 1.5, 0.105, 0
11640, 1.5125, 0.09, 0
11641, 1.525, 0.105, 0
11642, 1.5375, 0.09, 0
11643, 1.55, 0.105, 0
11644, 1.5625, 0.09, 0
11645, 1.575, 0.105, 0
11646, 1.5875, 0.09, 0
11647, 1.6, 0.105, 0
11648, 1.6125, 0.09, 0
11649, 1.625, 0.105, 0
11650, 1.6375, 0.09, 0
11651, 1.65, 0.105, 0
11652, 1.6625, 0.09, 0
11653, 1.675, 0.105, 0
11654, 1.6875, 0.09, 0
11655, 1.7, 0.105, 0
11656, 1.7125, 0.09, 0
11657, 1.725, 0.105, 0
11658, 1.7375, 0.09, 0
11659, 1.75, 0.105, 0
11660, 1.7625, 0.09, 0
11661, 1.775, 0.105, 0
11662, 1.7875, 0.09, 0
11663, 1.8, 0.105, 0
11664, 1.8125, 0.09, 0
11665, 1.825, 0.105, 0
11666, 1.8375, 0.09, 0
11667, 1.85, 0.105, 0
11668, 1.8625, 0.09, 0
11669, 1.875, 0.105, 0
11670, 1.8875, 0.09, 0
11671, 1.9, 0.105, 0
11672, 1.9125, 0.09, 0
11673, 1.925, 0.105, 0
11674, 1.9375, 0.09, 0
11675, 1.95, 0.105, 0
11676, 1.9625, 0.09, 0
11677, 1.975, 0.105, 0
11678, 1.9875, 0.09, 0
11679, 2, 0.105, 0
11680, 2.0125, 0.09, 0
11681, 2.025, 0.105, 0
11682, 2.0375, 0.09, 0
11683, 2.05, 0.105, 0
11684, 2.0625, 0.09, 0
11685, 2.075, 0.105, 0
11686, 2.0875, 0.09, 0
11687, 2.1, 0.105, 0
11688, 2.1125, 0.09, 0
11689, 2.125, 0.105, 0
11690, 2.1375, 0.09, 0
11691, 2.15, 0.105, 0
11692, 2.1625, 0.09, 0
11693, 2.175, 0.105, 0
11694, 2.1875, 0.09, 0
11695, 1.2125, 0.06, 0
11696, 1.225, 0.075, 0
11697, 1.2375, 0.06, 0
11698, 1.25, 0.075, 0
11699, 1.2625, 0.06, 0
11700, 1.275, 0.075, 0
11701, 1.2875, 0.06, 0
11702, 1.3, 0.075, 0
11703, 1.3125, 0.06, 0
11704, 1.325, 0.075, 0
11705, 1.3375, 0.06, 0
11706, 1.35, 0.075, 0
11707, 1.3625, 0.06, 0
11708, 1.375, 0.075, 0
11709, 1.3875, 0.06, 0
11710, 1.4, 0.075, 0
11711, 1.4125, 0.06, 0
11712, 1.425, 0.075, 0
11713, 1.4375, 0.06, 0
11714, 1.45, 0.075, 0
11715, 1.4625, 0.06, 0
11716, 1.475, 0.075, 0
11717, 1.4875, 0.06, 0
11718, 1.5, 0.075, 0
11719, 1.5125, 0.06, 0
11720, 1.525, 0.075, 0
11721, 1.5375, 0.06, 0
11722, 1.55, 0.075, 0
11723, 1.5625, 0.06, 0
11724, 1.575, 0.075, 0
11725, 1.5875, 0.06, 0
11726, 1.6, 0.075, 0
11727, 1.6125, 0.06, 0
11728, 1.625, 0.075, 0
11729, 1.6375, 0.06, 0
11730, 1.65, 0.075, 0
11731, 1.6625, 0.06, 0
11732, 1.675, 0.075, 0
11733, 1.6875, 0.06, 0
11734, 1.7, 0.075, 0
11735, 1.7125, 0.06, 0
11736, 1.725, 0.075, 0
11737, 1.7375, 0.06, 0
11738, 1.75, 0.075, 0
11739, 1.7625, 0.06, 0
11740, 1.775, 0.075, 0
11741, 1.7875, 0.06, 0
11742, 1.8, 0.075, 0
11743, 1.8125, 0.06, 0
11744, 1.825, 0.075, 0
11745, 1.8375, 0.06, 0
11746, 1.85, 0.075, 0
11747, 1.8625, 0.06, 0
11748, 1.875, 0.075, 0
11749, 1.8875, 0.06, 0
11750, 1.9, 0.075, 0
11751, 1.9125, 0.06, 0
11752, 1.925, 0.075, 0
11753, 1.9375, 0.06, 0
11754, 1.95, 0.075, 0
11755, 1.9625, 0.06, 0
11756, 1.975, 0.075, 0
11757, 1.9875, 0.06, 0
11758, 2, 0.075, 0
11759, 2.0125, 0.06, 0
11760, 2.025, 0.075, 0
11761, 2.0375, 0.06, 0
11762, 2.05, 0.075, 0
11763, 2.0625, 0.06, 0
11764, 2.075, 0.075, 0
11765, 2.0875, 0.06, 0
11766, 2.1, 0.075, 0
11767, 2.1125, 0.06, 0
11768, 2.125, 0.075, 0
11769, 2.1375, 0.06, 0
11770, 2.15, 0.075, 0
11771, 2.1625, 0.06, 0
11772, 2.175, 0.075, 0
11773, 2.1875, 0.06, 0
11774, 1.2125, 0.03, 0
11775, 1.225, 0.045, 0
11776, 1.2375, 0.03, 0
11777, 1.25, 0.045, 0
11778, 1.2625, 0.03, 0
11779, 1.275, 0.045, 0
11780, 1.2875, 0.03, 0
11781, 1.3, 0.045, 0
11782, 1.3125, 0.03, 0
11783, 1.325, 0.045, 0
11784, 1.3375, 0.03, 0
11785, 1.35, 0.045, 0
11786, 1.3625, 0.03, 0
11787, 1.375, 0.045, 0
11788, 1.3875, 0.03, 0
11789, 1.4, 0.045, 0
11790, 1.4125, 0.03, 0
11791, 1.425, 0.045, 0
11792, 1.4375, 0.03, 0
11793, 1.45, 0.045, 0
11794, 1.4625, 0.03, 0
11795, 1.475, 0.045, 0
11796, 1.4875, 0.03, 0
11797, 1.5, 0.045, 0
11798, 1.5125, 0.03, 0
11799, 1.525, 0.045, 0
11800, 1.5375, 0.03, 0
11801, 1.55, 0.045, 0
11802, 1.5625, 0.03, 0
11803, 1.575, 0.045, 0
11804, 1.5875, 0.03, 0
11805, 1.6, 0.045, 0
11806, 1.6125, 0.03, 0
11807, 1.625, 0.045, 0
11808, 1.6375, 0.03, 0
11809, 1.65, 0.045, 0
11810, 1.6625, 0.03, 0
11811, 1.675, 0.045, 0
11812, 1.6875, 0.03, 0
11813, 1.7, 0.045, 0
11814, 1.7125, 0.03, 0
11815, 1.725, 0.045, 0
11816, 1.7375, 0.03, 0
11817, 1.75, 0.045, 0
11818, 1.7625, 0.03, 0
11819, 1.775, 0.045, 0
11820, 1.7875, 0.03, 0
11821, 1.8, 0.045, 0
11822, 1.8125, 0.03, 0
11823, 1.825, 0.045, 0
11824, 1.8375, 0.03, 0
11825, 1.85, 0.045, 0
11826, 1.8625, 0.03, 0
11827, 1.875, 0.045, 0
11828, 1.8875, 0.03, 0
11829, 1.9, 0.045, 0
11830, 1.9125, 0.03, 0
11831, 1.925, 0.045, 0
11832, 1.9375, 0.03, 0
11833, 1.95, 0.045, 0
11834, 1.9625, 0.03, 0
11835, 1.975, 0.045, 0
11836, 1.9875, 0.03, 0
11837, 2, 0.045, 0
11838, 2.0125, 0.03, 0
11839, 2.025, 0.045, 0
11840, 2.0375, 0.03, 0
11841, 2.05, 0.045, 0
11842, 2.0625, 0.03, 0
11843, 2.075, 0.045, 0
11844, 2.0875, 0.03, 0
11845, 2.1, 0.045, 0
11846, 2.1125, 0.03, 0
11847, 2.125, 0.045, 0
11848, 2.1375, 0.03, 0
11849, 2.15, 0.045, 0
11850, 2.1625, 0.03, 0
11851, 2.175, 0.045, 0
11852, 2.1875, 0.03, 0
11853, 1.225, 0.015, 0
11854, 1.25, 0.015, 0
11855, 1.275, 0.015, 0
11856, 1.3, 0.015, 0
11857, 1.325, 0.015, 0
11858, 1.35, 0.015, 0
11859, 1.375, 0.015, 0
11860, 1.4, 0.015, 0
11861, 1.425, 0.015, 0
11862, 1.45, 0.015, 0
11863, 1.475, 0.015, 0
11864, 1.5, 0.015, 0
11865, 1.525, 0.015, 0
11866, 1.55, 0.015, 0
11867, 1.575, 0.015, 0
11868, 1.6, 0.015, 0
11869, 1.625, 0.015, 0
11870, 1.65, 0.015, 0
11871, 1.675, 0.015, 0
11872, 1.7, 0.015, 0
11873, 1.725, 0.015, 0
11874, 1.75, 0.015, 0
11875, 1.775, 0.015, 0
11876, 1.8, 0.015, 0
11877, 1.825, 0.015, 0
11878, 1.85, 0.015, 0
11879, 1.875, 0.015, 0
11880, 1.9, 0.015, 0
11881, 1.925, 0.015, 0
11882, 1.95, 0.015, 0
11883, 1.975, 0.015, 0
11884, 2, 0.015, 0
11885, 2.025, 0.015, 0
11886, 2.05, 0.015, 0
11887, 2.075, 0.015, 0
11888, 2.1, 0.015, 0
11889, 2.125, 0.015, 0
11890, 2.15, 0.015, 0
11891, 2.175, 0.015, 0
11892, 1.225, -0.02, 0
11893, 1.25, -0.02, 0
11894, 1.275, -0.02, 0
11895, 1.3, -0.02, 0
11896, 1.325, -0.02, 0
11897, 1.35, -0.02, 0
11898, 1.375, -0.02, 0
11899, 1.4, -0.02, 0
11900, 1.425, -0.02, 0
11901, 1.45, -0.02, 0
11902, 1.475, -0.02, 0
11903, 1.5, -0.02, 0
11904, 1.525, -0.02, 0
11905, 1.55, -0.02, 0
11906, 1.575, -0.02, 0
11907, 1.6, -0.02, 0
11908, 1.625, -0.02, 0
11909, 1.65, -0.02, 0
11910, 1.675, -0.02, 0
11911, 1.7, -0.02, 0
11912, 1.725, -0.02, 0
11913, 1.75, -0.02, 0
11914, 1.775, -0.02, 0
11915, 1.8, -0.02, 0
11916, 1.825, -0.02, 0
11917, 1.85, -0.02, 0
11918, 1.875, -0.02, 0
11919, 1.9, -0.02, 0
11920, 1.925, -0.02, 0
11921, 1.95, -0.02, 0
11922, 1.975, -0.02, 0
11923, 2, -0.02, 0
11924, 2.025, -0.02, 0
11925, 2.05, -0.02, 0
11926, 2.075, -0.02, 0
11927, 2.1, -0.02, 0
11928, 2.125, -0.02, 0
11929, 2.15, -0.02, 0
11930, 2.175, -0.02, 0
11931, 1.225, -0.04, 0
11932, 1.25, -0.04, 0
11933, 1.275, -0.04, 0
11934, 1.3, -0.04, 0
11935, 1.325, -0.04, 0
11936, 1.35, -0.04, 0
11937, 1.375, -0.04, 0
11938, 1.4, -0.04, 0
11939, 1.425, -0.04, 0
11940, 1.45, -0.04, 0
11941, 1.475, -0.04, 0
11942, 1.5, -0.04, 0
11943, 1.525, -0.04, 0
11944, 1.55, -0.04, 0
11945, 1.575, -0.04, 0
11946, 1.6, -0.04, 0
11947, 1.625, -0.04, 0
11948, 1.65, -0.04, 0
11949, 1.675, -0.04, 0
11950, 1.7, -0.04, 0
11951, 1.725, -0.04, 0
11952, 1.75, -0.04, 0
11953, 1.775, -0.04, 0
11954, 1.8, -0.04, 0
11955, 1.825, -0.04, 0
11956, 1.85, -0.04, 0
11957, 1.875, -0.04, 0
11958, 1.9, -0.04, 0
11959, 1.925, -0.04, 0
11960, 1.95, -0.04, 0
11961, 1.975, -0.04, 0
11962, 2, -0.04, 0
11963, 2.025, -0.04, 0
11964, 2.05, -0.04, 0
11965, 2.075, -0.04, 0
11966, 2.1, -0.04, 0
11967, 2.125, -0.04, 0
11968, 2.15, -0.04, 0
11969, 2.175, -0.04, 0
11970, 1.225, -0.06, 0
11971, 1.25, -0.06, 0
11972, 1.275, -0.06, 0
11973, 1.3, -0.06, 0
11974, 1.325, -0.06, 0
11975, 1.35, -0.06, 0
11976, 1.375, -0.06, 0
11977, 1.4, -0.06, 0
11978, 1.425, -0.06, 0
11979, 1.45, -0.06, 0
11980, 1.475, -0.06, 0
11981, 1.5, -0.06, 0
11982, 1.525, -0.06, 0
11983, 1.55, -0.06, 0
11984, 1.575, -0.06, 0
11985, 1.6, -0.06, 0
11986, 1.625, -0.06, 0
11987, 1.65, -0.06, 0
11988, 1.675, -0.06, 0
11989, 1.7, -0.06, 0
11990, 1.725, -0.06, 0
11991, 1.75, -0.06, 0
11992, 1.775, -0.06, 0
11993, 1.8, -0.06, 0
11994, 1.825, -0.06, 0
11995, 1.85, -0.06, 0
11996, 1.875, -0.06, 0
11997, 1.9, -0.06, 0
11998, 1.925, -0.06, 0
11999, 1.95, -0.06, 0
12000, 1.975, -0.06, 0
12001, 2, -0.06, 0
12002, 2.025, -0.06, 0
12003, 2.05, -0.06, 0
12004, 2.075, -0.06, 0
12005, 2.1, -0.06, 0
12006, 2.125, -0.06, 0
12007, 2.15, -0.06, 0
12008, 2.175, -0.06, 0
12009, 1.225, -0.08, 0
12010, 1.25, -0.08, 0
12011, 1.275, -0.08, 0
12012, 1.3, -0.08, 0
12013, 1.325, -0.08, 0
12014, 1.35, -0.08, 0
12015, 1.375, -0.08, 0
12016, 1.4, -0.08, 0
12017, 1.425, -0.08, 0
12018, 1.45, -0.08, 0
12019, 1.475, -0.08, 0
12020, 1.5, -0.08, 0
12021, 1.525, -0.08, 0
12022, 1.55, -0.08, 0
12023, 1.575, -0.08, 0
12024, 1.6, -0.08, 0
12025, 1.625, -0.08, 0
12026, 1.65, -0.08, 0
12027, 1.675, -0.08, 0
12028, 1.7, -0.08, 0
12029, 1.725, -0.08, 0
12030, 1.75, -0.08, 0
12031, 1.775, -0.08, 0
12032, 1.8, -0.08, 0
12033, 1.825, -0.08, 0
12034, 1.85, -0.08, 0
12035, 1.875, -0.08, 0
12036, 1.9, -0.08, 0
12037, 1.925, -0.08, 0
12038, 1.95, -0.08, 0
12039, 1.975, -0.08, 0
12040, 2, -0.08, 0
12041, 2.025, -0.08, 0
12042, 2.05, -0.08, 0
12043, 2.075, -0.08, 0
12044, 2.1, -0.08, 0
12045, 2.125, -0.08, 0
12046, 2.15, -0.08, 0
12047, 2.175, -0.08, 0
12048, 1.2125, -0.02, 0
12049, 1.225, -0.01, 0
12050, 1.2375, -0.02, 0
12051, 1.25, -0.01, 0
12052, 1.2625, -0.02, 0
12053, 1.275, -0.01, 0
12054, 1.2875, -0.02, 0
12055, 1.3, -0.01, 0
12056, 1.3125, -0.02, 0
12057, 1.325, -0.01, 0
12058, 1.3375, -0.02, 0
12059, 1.35, -0.01, 0
12060, 1.3625, -0.02, 0
12061, 1.375, -0.01, 0
12062, 1.3875, -0.02, 0
12063, 1.4, -0.01, 0
12064, 1.4125, -0.02, 0
12065, 1.425, -0.01, 0
12066, 1.4375, -0.02, 0
12067, 1.45, -0.01, 0
12068, 1.4625, -0.02, 0
12069, 1.475, -0.01, 0
12070, 1.4875, -0.02, 0
12071, 1.5, -0.01, 0
12072, 1.5125, -0.02, 0
12073, 1.525, -0.01, 0
12074, 1.5375, -0.02, 0
12075, 1.55, -0.01, 0
12076, 1.5625, -0.02, 0
12077, 1.575, -0.01, 0
12078, 1.5875, -0.02, 0
12079, 1.6, -0.01, 0
12080, 1.6125, -0.02, 0
12081, 1.625, -0.01, 0
12082, 1.6375, -0.02, 0
12083, 1.65, -0.01, 0
12084, 1.6625, -0.02, 0
12085, 1.675, -0.01, 0
12086, 1.6875, -0.02, 0
12087, 1.7, -0.01, 0
12088, 1.7125, -0.02, 0
12089, 1.725, -0.01, 0
12090, 1.7375, -0.02, 0
12091, 1.75, -0.01, 0
12092, 1.7625, -0.02, 0
12093, 1.775, -0.01, 0
12094, 1.7875, -0.02, 0
12095, 1.8, -0.01, 0
12096, 1.8125, -0.02, 0
12097, 1.825, -0.01, 0
12098, 1.8375, -0.02, 0
12099, 1.85, -0.01, 0
12100, 1.8625, -0.02, 0
12101, 1.875, -0.01, 0
12102, 1.8875, -0.02, 0
12103, 1.9, -0.01, 0
12104, 1.9125, -0.02, 0
12105, 1.925, -0.01, 0
12106, 1.9375, -0.02, 0
12107, 1.95, -0.01, 0
12108, 1.9625, -0.02, 0
12109, 1.975, -0.01, 0
12110, 1.9875, -0.02, 0
12111, 2, -0.01, 0
12112, 2.0125, -0.02, 0
12113, 2.025, -0.01, 0
12114, 2.0375, -0.02, 0
12115, 2.05, -0.01, 0
12116, 2.0625, -0.02, 0
12117, 2.075, -0.01, 0
12118, 2.0875, -0.02, 0
12119, 2.1, -0.01, 0
12120, 2.1125, -0.02, 0
12121, 2.125, -0.01, 0
12122, 2.1375, -0.02, 0
12123, 2.15, -0.01, 0
12124, 2.1625, -0.02, 0
12125, 2.175, -0.01, 0
12126, 2.1875, -0.02, 0
12127, 1.2125, -0.04, 0
12128, 1.225, -0.03, 0
12129, 1.2375, -0.04, 0
12130, 1.25, -0.03, 0
12131, 1.2625, -0.04, 0
12132, 1.275, -0.03, 0
12133, 1.2875, -0.04, 0
12134, 1.3, -0.03, 0
12135, 1.3125, -0.04, 0
12136, 1.325, -0.03, 0
12137, 1.3375, -0.04, 0
12138, 1.35, -0.03, 0
12139, 1.3625, -0.04, 0
12140, 1.375, -0.03, 0
12141, 1.3875, -0.04, 0
12142, 1.4, -0.03, 0
12143, 1.4125, -0.04, 0
12144, 1.425, -0.03, 0
12145, 1.4375, -0.04, 0
12146, 1.45, -0.03, 0
12147, 1.4625, -0.04, 0
12148, 1.475, -0.03, 0
12149, 1.4875, -0.04, 0
12150, 1.5, -0.03, 0
12151, 1.5125, -0.04, 0
12152, 1.525, -0.03, 0
12153, 1.5375, -0.04, 0
12154, 1.55, -0.03, 0
12155, 1.5625, -0.04, 0
12156, 1.575, -0.03, 0
12157, 1.5875, -0.04, 0
12158, 1.6, -0.03, 0
12159, 1.6125, -0.04, 0
12160, 1.625, -0.03, 0
12161, 1.6375, -0.04, 0
12162, 1.65, -0.03, 0
12163, 1.6625, -0.04, 0
12164, 1.675, -0.03, 0
12165, 1.6875, -0.04, 0
12166, 1.7, -0.03, 0
12167, 1.7125, -0.04, 0
12168, 1.725, -0.03, 0
12169, 1.7375, -0.04, 0
12170, 1.75, -0.03, 0
12171, 1.7625, -0.04, 0
12172, 1.775, -0.03, 0
12173, 1.7875, -0.04, 0
12174, 1.8, -0.03, 0
12175, 1.8125, -0.04, 0
12176, 1.825, -0.03, 0
12177, 1.8375, -0.04, 0
12178, 1.85, -0.03, 0
12179, 1.8625, -0.04, 0
12180, 1.875, -0.03, 0
12181, 1.8875, -0.04, 0
12182, 1.9, -0.03, 0
12183, 1.9125, -0.04, 0
12184, 1.925, -0.03, 0
12185, 1.9375, -0.04, 0
12186, 1.95, -0.03, 0
12187, 1.9625, -0.04, 0
12188, 1.975, -0.03, 0
12189, 1.9875, -0.04, 0
12190, 2, -0.03, 0
12191, 2.0125, -0.04, 0
12192, 2.025, -0.03, 0
12193, 2.0375, -0.04, 0
12194, 2.05, -0.03, 0
12195, 2.0625, -0.04, 0
12196, 2.075, -0.03, 0
12197, 2.0875, -0.04, 0
12198, 2.1, -0.03, 0
12199, 2.1125, -0.04, 0
12200, 2.125, -0.03, 0
12201, 2.1375, -0.04, 0
12202, 2.15, -0.03, 0
12203, 2.1625, -0.04, 0
12204, 2.175, -0.03, 0
12205, 2.1875, -0.04, 0
12206, 1.2125, -0.06, 0
12207, 1.225, -0.05, 0
12208, 1.2375, -0.06, 0
12209, 1.25, -0.05, 0
12210, 1.2625, -0.06, 0
12211, 1.275, -0.05, 0
12212, 1.2875, -0.06, 0
12213, 1.3, -0.05, 0
12214, 1.3125, -0.06, 0
12215, 1.325, -0.05, 0
12216, 1.3375, -0.06, 0
12217, 1.35, -0.05, 0
12218, 1.3625, -0.06, 0
12219, 1.375, -0.05, 0
12220, 1.3875, -0.06, 0
12221, 1.4, -0.05, 0
12222, 1.4125, -0.06, 0
12223, 1.425, -0.05, 0
12224, 1.4375, -0.06, 0
12225, 1.45, -0.05, 0
12226, 1.4625, -0.06, 0
12227, 1.475, -0.05, 0
12228, 1.4875, -0.06, 0
12229, 1.5, -0.05, 0
12230, 1.5125, -0.06, 0
12231, 1.525, -0.05, 0
12232, 1.5375, -0.06, 0
12233, 1.55, -0.05, 0
12234, 1.5625, -0.06, 0
12235, 1.575, -0.05, 0
12236, 1.5875, -0.06, 0
12237, 1.6, -0.05, 0
12238, 1.6125, -0.06, 0
12239, 1.625, -0.05, 0
12240, 1.6375, -0.06, 0
12241, 1.65, -0.05, 0
12242, 1.6625, -0.06, 0
12243, 1.675, -0.05, 0
12244, 1.6875, -0.06, 0
12245, 1.7, -0.05, 0
12246, 1.7125, -0.06, 0
12247, 1.725, -0.05, 0
12248, 1.7375, -0.06, 0
12249, 1.75, -0.05, 0
12250, 1.7625, -0.06, 0
12251, 1.775, -0.05, 0
12252, 1.7875, -0.06, 0
12253, 1.8, -0.05, 0
12254, 1.8125, -0.06, 0
12255, 1.825, -0.05, 0
12256, 1.8375, -0.06, 0
12257, 1.85, -0.05, 0
12258, 1.8625, -0.06, 0
12259, 1.875, -0.05, 0
12260, 1.8875, -0.06, 0
12261, 1.9, -0.05, 0
12262, 1.9125, -0.06, 0
12263, 1.925, -0.05, 0
12264, 1.9375, -0.06, 0
12265, 1.95, -0.05, 0
12266, 1.9625, -0.06, 0
12267, 1.975, -0.05, 0
12268, 1.9875, -0.06, 0
12269, 2, -0.05, 0
12270, 2.0125, -0.06, 0
12271, 2.025, -0.05, 0
12272, 2.0375, -0.06, 0
12273, 2.05, -0.05, 0
12274, 2.0625, -0.06, 0
12275, 2.075, -0.05, 0
12276, 2.0875, -0.06, 0
12277, 2.1, -0.05, 0
12278, 2.1125, -0.06, 0
12279, 2.125, -0.05, 0
12280, 2.1375, -0.06, 0
12281, 2.15, -0.05, 0
12282, 2.1625, -0.06, 0
12283, 2.175, -0.05, 0
12284, 2.1875, -0.06, 0
12285, 1.2125, -0.08, 0
12286, 1.225, -0.07, 0
12287, 1.2375, -0.08, 0
12288, 1.25, -0.07, 0
12289, 1.2625, -0.08, 0
12290, 1.275, -0.07, 0
12291, 1.2875, -0.08, 0
12292, 1.3, -0.07, 0
12293, 1.3125, -0.08, 0
12294, 1.325, -0.07, 0
12295, 1.3375, -0.08, 0
12296, 1.35, -0.07, 0
12297, 1.3625, -0.08, 0
12298, 1.375, -0.07, 0
12299, 1.3875, -0.08, 0
12300, 1.4, -0.07, 0
12301, 1.4125, -0.08, 0
12302, 1.425, -0.07, 0
12303, 1.4375, -0.08, 0
12304, 1.45, -0.07, 0
12305, 1.4625, -0.08, 0
12306, 1.475, -0.07, 0
12307, 1.4875, -0.08, 0
12308, 1.5, -0.07, 0
12309, 1.5125, -0.08, 0
12310, 1.525, -0.07, 0
12311, 1.5375, -0.08, 0
12312, 1.55, -0.07, 0
12313, 1.5625, -0.08, 0
12314, 1.575, -0.07, 0
12315, 1.5875, -0.08, 0
12316, 1.6, -0.07, 0
12317, 1.6125, -0.08, 0
12318, 1.625, -0.07, 0
12319, 1.6375, -0.08, 0
12320, 1.65, -0.07, 0
12321, 1.6625, -0.08, 0
12322, 1.675, -0.07, 0
12323, 1.6875, -0.08, 0
12324, 1.7, -0.07, 0
12325, 1.7125, -0.08, 0
12326, 1.725, -0.07, 0
12327, 1.7375, -0.08, 0
12328, 1.75, -0.07, 0
12329, 1.7625, -0.08, 0
12330, 1.775, -0.07, 0
12331, 1.7875, -0.08, 0
12332, 1.8, -0.07, 0
12333, 1.8125, -0.08, 0
12334, 1.825, -0.07, 0
12335, 1.8375, -0.08, 0
12336, 1.85, -0.07, 0
12337, 1.8625, -0.08, 0
12338, 1.875, -0.07, 0
12339, 1.8875, -0.08, 0
12340, 1.9, -0.07, 0
12341, 1.9125, -0.08, 0
12342, 1.925, -0.07, 0
12343, 1.9375, -0.08, 0
12344, 1.95, -0.07, 0
12345, 1.9625, -0.08, 0
12346, 1.975, -0.07, 0
12347, 1.9875, -0.08, 0
12348, 2, -0.07, 0
12349, 2.0125, -0.08, 0
12350, 2.025, -0.07, 0
12351, 2.0375, -0.08, 0
12352, 2.05, -0.07, 0
12353, 2.0625, -0.08, 0
12354, 2.075, -0.07, 0
12355, 2.0875, -0.08, 0
12356, 2.1, -0.07, 0
12357, 2.1125, -0.08, 0
12358, 2.125, -0.07, 0
12359, 2.1375, -0.08, 0
12360, 2.15, -0.07, 0
12361, 2.1625, -0.08, 0
12362, 2.175, -0.07, 0
12363, 2.1875, -0.08, 0
12364, 1.225, -0.09, 0
12365, 1.25, -0.09, 0
12366, 1.275, -0.09, 0
12367, 1.3, -0.09, 0
12368, 1.325, -0.09, 0
12369, 1.35, -0.09, 0
12370, 1.375, -0.09, 0
12371, 1.4, -0.09, 0
12372, 1.425, -0.09, 0
12373, 1.45, -0.09, 0
12374, 1.475, -0.09, 0
12375, 1.5, -0.09, 0
12376, 1.525, -0.09, 0
12377, 1.55, -0.09, 0
12378, 1.575, -0.09, 0
12379, 1.6, -0.09, 0
12380, 1.625, -0.09, 0
12381, 1.65, -0.09, 0
12382, 1.675, -0.09, 0
12383, 1.7, -0.09, 0
12384, 1.725, -0.09, 0
12385, 1.75, -0.09, 0
12386, 1.775, -0.09, 0
12387, 1.8, -0.09, 0
12388, 1.825, -0.09, 0
12389, 1.85, -0.09, 0
12390, 1.875, -0.09, 0
12391, 1.9, -0.09, 0
12392, 1.925, -0.09, 0
12393, 1.95, -0.09, 0
12394, 1.975, -0.09, 0
12395, 2, -0.09, 0
12396, 2.025, -0.09, 0
12397, 2.05, -0.09, 0
12398, 2.075, -0.09, 0
12399, 2.1, -0.09, 0
12400, 2.125, -0.09, 0
12401, 2.15, -0.09, 0
12402, 2.175, -0.09, 0
12403, 0.025, -0.02, 0
12404, 0.05, -0.02, 0
12405, 0.075, -0.02, 0
12406, 0.1, -0.02, 0
12407, 0.125, -0.02, 0
12408, 0.15, -0.02, 0
12409, 0.175, -0.02, 0
12410, 0.2, -0.02, 0
12411, 0.225, -0.02, 0
12412, 0.25, -0.02, 0
12413, 0.275, -0.02, 0
12414, 0.3, -0.02, 0
12415, 0.325, -0.02, 0
12416, 0.35, -0.02, 0
12417, 0.375, -0.02, 0
12418, 0.4, -0.02, 0
12419, 0.425, -0.02, 0
12420, 0.45, -0.02, 0
12421, 0.475, -0.02, 0
12422, 0.5, -0.02, 0
12423, 0.525, -0.02, 0
12424, 0.55, -0.02, 0
12425, 0.575, -0.02, 0
12426, 0.6, -0.02, 0
12427, 0.625, -0.02, 0
12428, 0.65, -0.02, 0
12429, 0.675, -0.02, 0
12430, 0.7, -0.02, 0
12431, 0.725, -0.02, 0
12432, 0.75, -0.02, 0
12433, 0.775, -0.02, 0
12434, 0.8, -0.02, 0
12435, 0.825, -0.02, 0
12436, 0.85, -0.02, 0
12437, 0.875, -0.02, 0
12438, 0.9, -0.02, 0
12439, 0.925, -0.02, 0
12440, 0.95, -0.02, 0
12441, 0.975, -0.02, 0
12442, 0.025, -0.04, 0
12443, 0.05, -0.04, 0
12444, 0.075, -0.04, 0
12445, 0.1, -0.04, 0
12446, 0.125, -0.04, 0
12447, 0.15, -0.04, 0
12448, 0.175, -0.04, 0
12449, 0.2, -0.04, 0
12450, 0.225, -0.04, 0
12451, 0.25, -0.04, 0
12452, 0.275, -0.04, 0
12453, 0.3, -0.04, 0
12454, 0.325, -0.04, 0
12455, 0.35, -0.04, 0
12456, 0.375, -0.04, 0
12457, 0.4, -0.04, 0
12458, 0.425, -0.04, 0
12459, 0.45, -0.04, 0
12460, 0.475, -0.04, 0
12461, 0.5, -0.04, 0
12462, 0.525, -0.04, 0
12463, 0.55, -0.04, 0
12464, 0.575, -0.04, 0
12465, 0.6, -0.04, 0
12466, 0.625, -0.04, 0
12467, 0.65, -0.04, 0
12468, 0.675, -0.04, 0
12469, 0.7, -0.04, 0
12470, 0.725, -0.04, 0
12471, 0.75, -0.04, 0
12472, 0.775, -0.04, 0
12473, 0.8, -0.04, 0
12474, 0.825, -0.04, 0
12475, 0.85, -0.04, 0
12476, 0.875, -0.04, 0
12477, 0.9, -0.04, 0
12478, 0.925, -0.04, 0
12479, 0.95, -0.04, 0
12480, 0.975, -0.04, 0
12481, 0.025, -0.06, 0
12482, 0.05, -0.06, 0
12483, 0.075, -0.06, 0
12484, 0.1, -0.06, 0
12485, 0.125, -0.06, 0
12486, 0.15, -0.06, 0
12487, 0.175, -0.06, 0
12488, 0.2, -0.06, 0
12489, 0.225, -0.06, 0
12490, 0.25, -0.06, 0
12491, 0.275, -0.06, 0
12492, 0.3, -0.06, 0
12493, 0.325, -0.06, 0
12494, 0.35, -0.06, 0
12495, 0.375, -0.06, 0
12496, 0.4, -0.06, 0
12497, 0.425, -0.06, 0
12498, 0.45, -0.06, 0
12499, 0.475, -0.06, 0
12500, 0.5, -0.06, 0
12501, 0.525, -0.06, 0
12502, 0.55, -0.06, 0
12503, 0.575, -0.06, 0
12504, 0.6, -0.06, 0
12505, 0.625, -0.06, 0
12506, 0.65, -0.06, 0
12507, 0.675, -0.06, 0
12508, 0.7, -0.06, 0
12509, 0.725, -0.06, 0
12510, 0.75, -0.06, 0
12511, 0.775, -0.06, 0
12512, 0.8, -0.06, 0
12513, 0.825, -0.06, 0
12514, 0.85, -0.06, 0
12515, 0.875, -0.06, 0
12516, 0.9, -0.06, 0
12517, 0.925, -0.06, 0
12518, 0.95, -0.06, 0
12519, 0.975, -0.06, 0
12520, 0.025, -0.08, 0
12521, 0.05, -0.08, 0
12522, 0.075, -0.08, 0
12523, 0.1, -0.08, 0
12524, 0.125, -0.08, 0
12525, 0.15, -0.08, 0
12526, 0.175, -0.08, 0
12527, 0.2, -0.08, 0
12528, 0.225, -0.08, 0
12529, 0.25, -0.08, 0
12530, 0.275, -0.08, 0
12531, 0.3, -0.08, 0
12532, 0.325, -0.08, 0
12533, 0.35, -0.08, 0
12534, 0.375, -0.08, 0
12535, 0.4, -0.08, 0
12536, 0.425, -0.08, 0
12537, 0.45, -0.08, 0
12538, 0.475, -0.08, 0
12539, 0.5, -0.08, 0
12540, 0.525, -0.08, 0
12541, 0.55, -0.08, 0
12542, 0.575, -0.08, 0
12543, 0.6, -0.08, 0
12544, 0.625, -0.08, 0
12545, 0.65, -0.08, 0
12546, 0.675, -0.08, 0
12547, 0.7, -0.08, 0
12548, 0.725, -0.08, 0
12549, 0.75, -0.08, 0
12550, 0.775, -0.08, 0
12551, 0.8, -0.08, 0
12552, 0.825, -0.08, 0
12553, 0.85, -0.08, 0
12554, 0.875, -0.08, 0
12555, 0.9, -0.08, 0
12556, 0.925, -0.08, 0
12557, 0.95, -0.08, 0
12558, 0.975, -0.08, 0
12559, 0.0125, -0.02, 0
12560, 0.025, -0.01, 0
12561, 0.0375, -0.02, 0
12562, 0.05, -0.01, 0
12563, 0.0625, -0.02, 0
12564, 0.075, -0.01, 0
12565, 0.0875, -0.02, 0
12566, 0.1, -0.01, 0
12567, 0.1125, -0.02, 0
12568, 0.125, -0.01, 0
12569, 0.1375, -0.02, 0
12570, 0.15, -0.01, 0
12571, 0.1625, -0.02, 0
12572, 0.175, -0.01, 0
12573, 0.1875, -0.02, 0
12574, 0.2, -0.01, 0
12575, 0.2125, -0.02, 0
12576, 0.225, -0.01, 0
12577, 0.2375, -0.02, 0
12578, 0.25, -0.01, 0
12579, 0.2625, -0.02, 0
12580, 0.275, -0.01, 0
12581, 0.2875, -0.02, 0
12582, 0.3, -0.01, 0
12583, 0.3125, -0.02, 0
12584, 0.325, -0.01, 0
12585, 0.3375, -0.02, 0
12586, 0.35, -0.01, 0
12587, 0.3625, -0.02, 0
12588, 0.375, -0.01, 0
12589, 0.3875, -0.02, 0
12590, 0.4, -0.01, 0
12591, 0.4125, -0.02, 0
12592, 0.425, -0.01, 0
12593, 0.4375, -0.02, 0
12594, 0.45, -0.01, 0
12595, 0.4625, -0.02, 0
12596, 0.475, -0.01, 0
12597, 0.4875, -0.02, 0
12598, 0.5, -0.01, 0
12599, 0.5125, -0.02, 0
12600, 0.525, -0.01, 0
12601, 0.5375, -0.02, 0
12602, 0.55, -0.01, 0
12603, 0.5625, -0.02, 0
12604, 0.575, -0.01, 0
12605, 0.5875, -0.02, 0
12606, 0.6, -0.01, 0
12607, 0.6125, -0.02, 0
12608, 0.625, -0.01, 0
12609, 0.6375, -0.02, 0
12610, 0.65, -0.01, 0
12611, 0.6625, -0.02, 0
12612, 0.675, -0.01, 0
12613, 0.6875, -0.02, 0
12614, 0.7, -0.01, 0
12615, 0.7125, -0.02, 0
12616, 0.725, -0.01, 0
12617, 0.7375, -0.02, 0
12618, 0.75, -0.01, 0
12619, 0.7625, -0.02, 0
12620, 0.775, -0.01, 0
12621, 0.7875, -0.02, 0
12622, 0.8, -0.01, 0
12623, 0.8125, -0.02, 0
12624, 0.825, -0.01, 0
12625, 0.8375, -0.02, 0
12626, 0.85, -0.01, 0
12627, 0.8625, -0.02, 0
12628, 0.875, -0.01, 0
12629, 0.8875, -0.02, 0
12630, 0.9, -0.01, 0
12631, 0.9125, -0.02, 0
12632, 0.925, -0.01, 0
12633, 0.9375, -0.02, 0
12634, 0.95, -0.01, 0
12635, 0.9625, -0.02, 0
12636, 0.975, -0.01, 0
12637, 0.9875, -0.02, 0
12638, 0.0125, -0.04, 0
12639, 0.025, -0.03, 0
12640, 0.0375, -0.04, 0
12641, 0.05, -0.03, 0
12642, 0.0625, -0.04, 0
12643, 0.075, -0.03, 0
12644, 0.0875, -0.04, 0
12645, 0.1, -0.03, 0
12646, 0.1125, -0.04, 0
12647, 0.125, -0.03, 0
12648, 0.1375, -0.04, 0
12649, 0.15, -0.03, 0
12650, 0.1625, -0.04, 0
12651, 0.175, -0.03, 0
12652, 0.1875, -0.04, 0
12653, 0.2, -0.03, 0
12654, 0.2125, -0.04, 0
12655, 0.225, -0.03, 0
12656, 0.2375, -0.04, 0
12657, 0.25, -0.03, 0
12658, 0.2625, -0.04, 0
12659, 0.275, -0.03, 0
12660, 0.2875, -0.04, 0
12661, 0.3, -0.03, 0
12662, 0.3125, -0.04, 0
12663, 0.325, -0.03, 0
12664, 0.3375, -0.04, 0
12665, 0.35, -0.03, 0
12666, 0.3625, -0.04, 0
12667, 0.375, -0.03, 0
12668, 0.3875, -0.04, 0
12669, 0.4, -0.03, 0
12670, 0.4125, -0.04, 0
12671, 0.425, -0.03, 0
12672, 0.4375, -0.04, 0
12673, 0.45, -0.03, 0
12674, 0.4625, -0.04, 0
12675, 0.475, -0.03, 0
12676, 0.4875, -0.04, 0
12677, 0.5, -0.03, 0
12678, 0.5125, -0.04, 0
12679, 0.525, -0.03, 0
12680, 0.5375, -0.04, 0
12681, 0.55, -0.03, 0
12682, 0.5625, -0.04, 0
12683, 0.575, -0.03, 0
12684, 0.5875, -0.04, 0
12685, 0.6, -0.03, 0
12686, 0.6125, -0.04, 0
12687, 0.625, -0.03, 0
12688, 0.6375, -0.04, 0
12689, 0.65, -0.03, 0
12690, 0.6625, -0.04, 0
12691, 0.675, -0.03, 0
12692, 0.6875, -0.04, 0
12693, 0.7, -0.03, 0
12694, 0.7125, -0.04, 0
12695, 0.725, -0.03, 0
12696, 0.7375, -0.04, 0
12697, 0.75, -0.03, 0
12698, 0.7625, -0.04, 0
12699, 0.775, -0.03, 0
12700, 0.7875, -0.04, 0
12701, 0.8, -0.03, 0
12702, 0.8125, -0.04, 0
12703, 0.825, -0.03, 0
12704, 0.8375, -0.04, 0
12705, 0.85, -0.03, 0
12706, 0.8625, -0.04, 0
12707, 0.875, -0.03, 0
12708, 0.8875, -0.04, 0
12709, 0.9, -0.03, 0
12710, 0.9125, -0.04, 0
12711, 0.925, -0.03, 0
12712, 0.9375, -0.04, 0
12713, 0.95, -0.03, 0
12714, 0.9625, -0.04, 0
12715, 0.975, -0.03, 0
12716, 0.9875, -0.04, 0
12717, 0.0125, -0.06, 0
12718, 0.025, -0.05, 0
12719, 0.0375, -0.06, 0
12720, 0.05, -0.05, 0
12721, 0.0625, -0.06, 0
12722, 0.075, -0.05, 0
12723, 0.0875, -0.06, 0
12724, 0.1, -0.05, 0
12725, 0.1125, -0.06, 0
12726, 0.125, -0.05, 0
12727, 0.1375, -0.06, 0
12728, 0.15, -0.05, 0
12729, 0.1625, -0.06, 0
12730, 0.175, -0.05, 0
12731, 0.1875, -0.06, 0
12732, 0.2, -0.05, 0
12733, 0.2125, -0.06, 0
12734, 0.225, -0.05, 0
12735, 0.2375, -0.06, 0
12736, 0.25, -0.05, 0
12737, 0.2625, -0.06, 0
12738, 0.275, -0.05, 0
12739, 0.2875, -0.06, 0
12740, 0.3, -0.05, 0
12741, 0.3125, -0.06, 0
12742, 0.325, -0.05, 0
12743, 0.3375, -0.06, 0
12744, 0.35, -0.05, 0
12745, 0.3625, -0.06, 0
12746, 0.375, -0.05, 0
12747, 0.3875, -0.06, 0
12748, 0.4, -0.05, 0
12749, 0.4125, -0.06, 0
12750, 0.425, -0.05, 0
12751, 0.4375, -0.06, 0
12752, 0.45, -0.05, 0
12753, 0.4625, -0.06, 0
12754, 0.475, -0.05, 0
12755, 0.4875, -0.06, 0
12756, 0.5, -0.05, 0
12757, 0.5125, -0.06, 0
12758, 0.525, -0.05, 0
12759, 0.5375, -0.06, 0
12760, 0.55, -0.05, 0
12761, 0.5625, -0.06, 0
12762, 0.575, -0.05, 0
12763, 0.5875, -0.06, 0
12764, 0.6, -0.05, 0
12765, 0.6125, -0.06, 0
12766, 0.625, -0.05, 0
12767, 0.6375, -0.06, 0
12768, 0.65, -0.05, 0
12769, 0.6625, -0.06, 0
12770, 0.675, -0.05, 0
12771, 0.6875, -0.06, 0
12772, 0.7, -0.05, 0
12773, 0.7125, -0.06, 0
12774, 0.725, -0.05, 0
12775, 0.7375, -0.06, 0
12776, 0.75, -0.05, 0
12777, 0.7625, -0.06, 0
12778, 0.775, -0.05, 0
12779, 0.7875, -0.06, 0
12780, 0.8, -0.05, 0
12781, 0.8125, -0.06, 0
12782, 0.825, -0.05, 0
12783, 0.8375, -0.06, 0
12784, 0.85, -0.05, 0
12785, 0.8625, -0.06, 0
12786, 0.875, -0.05, 0
12787, 0.8875, -0.06, 0
12788, 0.9, -0.05, 0
12789, 0.9125, -0.06, 0
12790, 0.925, -0.05, 0
12791, 0.9375, -0.06, 0
12792, 0.95, -0.05, 0
12793, 0.9625, -0.06, 0
12794, 0.975, -0.05, 0
12795, 0.9875, -0.06, 0
12796, 0.0125, -0.08, 0
12797, 0.025, -0.07, 0
12798, 0.0375, -0.08, 0
12799, 0.05, -0.07, 0
12800, 0.0625, -0.08, 0
12801, 0.075, -0.07, 0
12802, 0.0875, -0.08, 0
12803, 0.1, -0.07, 0
12804, 0.1125, -0.08, 0
12805, 0.125, -0.07, 0
12806, 0.1375, -0.08, 0
12807, 0.15, -0.07, 0
12808, 0.1625, -0.08, 0
12809, 0.175, -0.07, 0
12810, 0.1875, -0.08, 0
12811, 0.2, -0.07, 0
12812, 0.2125, -0.08, 0
12813, 0.225, -0.07, 0
12814, 0.2375, -0.08, 0
12815, 0.25, -0.07, 0
12816, 0.2625, -0.08, 0
12817, 0.275, -0.07, 0
12818, 0.2875, -0.08, 0
12819, 0.3, -0.07, 0
12820, 0.3125, -0.08, 0
12821, 0.325, -0.07, 0
12822, 0.3375, -0.08, 0
12823, 0.35, -0.07, 0
12824, 0.3625, -0.08, 0
12825, 0.375, -0.07, 0
12826, 0.3875, -0.08, 0
12827, 0.4, -0.07, 0
12828, 0.4125, -0.08, 0
12829, 0.425, -0.07, 0
12830, 0.4375, -0.08, 0
12831, 0.45, -0.07, 0
12832, 0.4625, -0.08, 0
12833, 0.475, -0.07, 0
12834, 0.4875, -0.08, 0
12835, 0.5, -0.07, 0
12836, 0.5125, -0.08, 0
12837, 0.525, -0.07, 0
12838, 0.5375, -0.08, 0
12839, 0.55, -0.07, 0
12840, 0.5625, -0.08, 0
12841, 0.575, -0.07, 0
12842, 0.5875, -0.08, 0
12843, 0.6, -0.07, 0
12844, 0.6125, -0.08, 0
12845, 0.625, -0.07, 0
12846, 0.6375, -0.08, 0
12847, 0.65, -0.07, 0
12848, 0.6625, -0.08, 0
12849, 0.675, -0.07, 0
12850, 0.6875, -0.08, 0
12851, 0.7, -0.07, 0
12852, 0.7125, -0.08, 0
12853, 0.725, -0.07, 0
12854, 0.7375, -0.08, 0
12855, 0.75, -0.07, 0
12856, 0.7625, -0.08, 0
12857, 0.775, -0.07, 0
12858, 0.7875, -0.08, 0
12859, 0.8, -0.07, 0
12860, 0.8125, -0.08, 0
12861, 0.825, -0.07, 0
12862, 0.8375, -0.08, 0
12863, 0.85, -0.07, 0
12864, 0.8625, -0.08, 0
12865, 0.875, -0.07, 0
12866, 0.8875, -0.08, 0
12867, 0.9, -0.07, 0
12868, 0.9125, -0.08, 0
12869, 0.925, -0.07, 0
12870, 0.9375, -0.08, 0
12871, 0.95, -0.07, 0
12872, 0.9625, -0.08, 0
12873, 0.975, -0.07, 0
12874, 0.9875, -0.08, 0
12875, 0.025, -0.09, 0
12876, 0.05, -0.09, 0
12877, 0.075, -0.09, 0
12878, 0.1, -0.09, 0
12879, 0.125, -0.09, 0
12880, 0.15, -0.09, 0
12881, 0.175, -0.09, 0
12882, 0.2, -0.09, 0
12883, 0.225, -0.09, 0
12884, 0.25, -0.09, 0
12885, 0.275, -0.09, 0
12886, 0.3, -0.09, 0
12887, 0.325, -0.09, 0
12888, 0.35, -0.09, 0
12889, 0.375, -0.09, 0
12890, 0.4, -0.09, 0
12891, 0.425, -0.09, 0
12892, 0.45, -0.09, 0
12893, 0.475, -0.09, 0
12894, 0.5, -0.09, 0
12895, 0.525, -0.09, 0
12896, 0.55, -0.09, 0
12897, 0.575, -0.09, 0
12898, 0.6, -0.09, 0
12899, 0.625, -0.09, 0
12900, 0.65, -0.09, 0
12901, 0.675, -0.09, 0
12902, 0.7, -0.09, 0
12903, 0.725, -0.09, 0
12904, 0.75, -0.09, 0
12905, 0.775, -0.09, 0
12906, 0.8, -0.09, 0
12907, 0.825, -0.09, 0
12908, 0.85, -0.09, 0
12909, 0.875, -0.09, 0
12910, 0.9, -0.09, 0
12911, 0.925, -0.09, 0
12912, 0.95, -0.09, 0
12913, 0.975, -0.09, 0
12914, -0.033333333333333, -0.02, 0
12915, -0.033333333333333, -0.04, 0
12916, -0.033333333333333, -0.06, 0
12917, -0.033333333333333, -0.08, 0
12918, -0.066666666666667, -0.02, 0
12919, -0.066666666666667, -0.04, 0
12920, -0.066666666666667, -0.06, 0
12921, -0.066666666666667, -0.08, 0
12922, -0.033333333333333, -0.01, 0
12923, -0.016666666666667, -0.02, 0
12924, -0.033333333333333, -0.03, 0
12925, -0.016666666666667, -0.04, 0
12926, -0.033333333333333, -0.05, 0
12927, -0.016666666666667, -0.06, 0
12928, -0.033333333333333, -0.07, 0
12929, -0.016666666666667, -0.08, 0
12930, -0.033333333333333, -0.09, 0
12931, -0.066666666666667, -0.01, 0
12932, -0.05, -0.02, 0
12933, -0.066666666666667, -0.03, 0
12934, -0.05, -0.04, 0
12935, -0.066666666666667, -0.05, 0
12936, -0.05, -0.06, 0
12937, -0.066666666666667, -0.07, 0
12938, -0.05, -0.08, 0
12939, -0.066666666666667, -0.09, 0
12940, -0.083333333333333, -0.02, 0
12941, -0.083333333333333, -0.04, 0
12942, -0.083333333333333, -0.06, 0
12943, -0.083333333333333, -0.08, 0
12944, 0.025, -0.14, 0
12945, 0.05, -0.14, 0
12946, 0.075, -0.14, 0
12947, 0.1, -0.14, 0
12948, 0.125, -0.14, 0
12949, 0.15, -0.14, 0
12950, 0.175, -0.14, 0
12951, 0.2, -0.14, 0
12952, 0.225, -0.14, 0
12953, 0.25, -0.14, 0
12954, 0.275, -0.14, 0
12955, 0.3, -0.14, 0
12956, 0.325, -0.14, 0
12957, 0.35, -0.14, 0
12958, 0.375, -0.14, 0
12959, 0.4, -0.14, 0
12960, 0.425, -0.14, 0
12961, 0.45, -0.14, 0
12962, 0.475, -0.14, 0
12963, 0.5, -0.14, 0
12964, 0.525, -0.14, 0
12965, 0.55, -0.14, 0
12966, 0.575, -0.14, 0
12967, 0.6, -0.14, 0
12968, 0.625, -0.14, 0
12969, 0.65, -0.14, 0
12970, 0.675, -0.14, 0
12971, 0.7, -0.14, 0
12972, 0.725, -0.14, 0
12973, 0.75, -0.14, 0
12974, 0.775, -0.14, 0
12975, 0.8, -0.14, 0
12976, 0.825, -0.14, 0
12977, 0.85, -0.14, 0
12978, 0.875, -0.14, 0
12979, 0.9, -0.14, 0
12980, 0.925, -0.14, 0
12981, 0.95, -0.14, 0
12982, 0.975, -0.14, 0
12983, 0.025, -0.18, 0
12984, 0.05, -0.18, 0
12985, 0.075, -0.18, 0
12986, 0.1, -0.18, 0
12987, 0.125, -0.18, 0
12988, 0.15, -0.18, 0
12989, 0.175, -0.18, 0
12990, 0.2, -0.18, 0
12991, 0.225, -0.18, 0
12992, 0.25, -0.18, 0
12993, 0.275, -0.18, 0
12994, 0.3, -0.18, 0
12995, 0.325, -0.18, 0
12996, 0.35, -0.18, 0
12997, 0.375, -0.18, 0
12998, 0.4, -0.18, 0
12999, 0.425, -0.18, 0
13000, 0.45, -0.18, 0
13001, 0.475, -0.18, 0
13002, 0.5, -0.18, 0
13003, 0.525, -0.18, 0
13004, 0.55, -0.18, 0
13005, 0.575, -0.18, 0
13006, 0.6, -0.18, 0
13007, 0.625, -0.18, 0
13008, 0.65, -0.18, 0
13009, 0.675, -0.18, 0
13010, 0.7, -0.18, 0
13011, 0.725, -0.18, 0
13012, 0.75, -0.18, 0
13013, 0.775, -0.18, 0
13014, 0.8, -0.18, 0
13015, 0.825, -0.18, 0
13016, 0.85, -0.18, 0
13017, 0.875, -0.18, 0
13018, 0.9, -0.18, 0
13019, 0.925, -0.18, 0
13020, 0.95, -0.18, 0
13021, 0.975, -0.18, 0
13022, 0.025, -0.22, 0
13023, 0.05, -0.22, 0
13024, 0.075, -0.22, 0
13025, 0.1, -0.22, 0
13026, 0.125, -0.22, 0
13027, 0.15, -0.22, 0
13028, 0.175, -0.22, 0
13029, 0.2, -0.22, 0
13030, 0.225, -0.22, 0
13031, 0.25, -0.22, 0
13032, 0.275, -0.22, 0
13033, 0.3, -0.22, 0
13034, 0.325, -0.22, 0
13035, 0.35, -0.22, 0
13036, 0.375, -0.22, 0
13037, 0.4, -0.22, 0
13038, 0.425, -0.22, 0
13039, 0.45, -0.22, 0
13040, 0.475, -0.22, 0
13041, 0.5, -0.22, 0
13042, 0.525, -0.22, 0
13043, 0.55, -0.22, 0
13044, 0.575, -0.22, 0
13045, 0.6, -0.22, 0
13046, 0.625, -0.22, 0
13047, 0.65, -0.22, 0
13048, 0.675, -0.22, 0
13049, 0.7, -0.22, 0
13050, 0.725, -0.22, 0
13051, 0.75, -0.22, 0
13052, 0.775, -0.22, 0
13053, 0.8, -0.22, 0
13054, 0.825, -0.22, 0
13055, 0.85, -0.22, 0
13056, 0.875, -0.22, 0
13057, 0.9, -0.22, 0
13058, 0.925, -0.22, 0
13059, 0.95, -0.22, 0
13060, 0.975, -0.22, 0
13061, 0.025, -0.26, 0
13062, 0.05, -0.26, 0
13063, 0.075, -0.26, 0
13064, 0.1, -0.26, 0
13065, 0.125, -0.26, 0
13066, 0.15, -0.26, 0
13067, 0.175, -0.26, 0
13068, 0.2, -0.26, 0
13069, 0.225, -0.26, 0
13070, 0.25, -0.26, 0
13071, 0.275, -0.26, 0
13072, 0.3, -0.26, 0
13073, 0.325, -0.26, 0
13074, 0.35, -0.26, 0
13075, 0.375, -0.26, 0
13076, 0.4, -0.26, 0
13077, 0.425, -0.26, 0
13078, 0.45, -0.26, 0
13079, 0.475, -0.26, 0
13080, 0.5, -0.26, 0
13081, 0.525, -0.26, 0
13082, 0.55, -0.26, 0
13083, 0.575, -0.26, 0
13084, 0.6, -0.26, 0
13085, 0.625, -0.26, 0
13086, 0.65, -0.26, 0
13087, 0.675, -0.26, 0
13088, 0.7, -0.26, 0
13089, 0.725, -0.26, 0
13090, 0.75, -0.26, 0
13091, 0.775, -0.26, 0
13092, 0.8, -0.26, 0
13093, 0.825, -0.26, 0
13094, 0.85, -0.26, 0
13095, 0.875, -0.26, 0
13096, 0.9, -0.26, 0
13097, 0.925, -0.26, 0
13098, 0.95, -0.26, 0
13099, 0.975, -0.26, 0
13100, 0.0125, -0.14, 0
13101, 0.025, -0.12, 0
13102, 0.0375, -0.14, 0
13103, 0.05, -0.12, 0
13104, 0.0625, -0.14, 0
13105, 0.075, -0.12, 0
13106, 0.0875, -0.14, 0
13107, 0.1, -0.12, 0
13108, 0.1125, -0.14, 0
13109, 0.125, -0.12, 0
13110, 0.1375, -0.14, 0
13111, 0.15, -0.12, 0
13112, 0.1625, -0.14, 0
13113, 0.175, -0.12, 0
13114, 0.1875, -0.14, 0
13115, 0.2, -0.12, 0
13116, 0.2125, -0.14, 0
13117, 0.225, -0.12, 0
13118, 0.2375, -0.14, 0
13119, 0.25, -0.12, 0
13120, 0.2625, -0.14, 0
13121, 0.275, -0.12, 0
13122, 0.2875, -0.14, 0
13123, 0.3, -0.12, 0
13124, 0.3125, -0.14, 0
13125, 0.325, -0.12, 0
13126, 0.3375, -0.14, 0
13127, 0.35, -0.12, 0
13128, 0.3625, -0.14, 0
13129, 0.375, -0.12, 0
13130, 0.3875, -0.14, 0
13131, 0.4, -0.12, 0
13132, 0.4125, -0.14, 0
13133, 0.425, -0.12, 0
13134, 0.4375, -0.14, 0
13135, 0.45, -0.12, 0
13136, 0.4625, -0.14, 0
13137, 0.475, -0.12, 0
13138, 0.4875, -0.14, 0
13139, 0.5, -0.12, 0
13140, 0.5125, -0.14, 0
13141, 0.525, -0.12, 0
13142, 0.5375, -0.14, 0
13143, 0.55, -0.12, 0
13144, 0.5625, -0.14, 0
13145, 0.575, -0.12, 0
13146, 0.5875, -0.14, 0
13147, 0.6, -0.12, 0
13148, 0.6125, -0.14, 0
13149, 0.625, -0.12, 0
13150, 0.6375, -0.14, 0
13151, 0.65, -0.12, 0
13152, 0.6625, -0.14, 0
13153, 0.675, -0.12, 0
13154, 0.6875, -0.14, 0
13155, 0.7, -0.12, 0
13156, 0.7125, -0.14, 0
13157, 0.725, -0.12, 0
13158, 0.7375, -0.14, 0
13159, 0.75, -0.12, 0
13160, 0.7625, -0.14, 0
13161, 0.775, -0.12, 0
13162, 0.7875, -0.14, 0
13163, 0.8, -0.12, 0
13164, 0.8125, -0.14, 0
13165, 0.825, -0.12, 0
13166, 0.8375, -0.14, 0
13167, 0.85, -0.12, 0
13168, 0.8625, -0.14, 0
13169, 0.875, -0.12, 0
13170, 0.8875, -0.14, 0
13171, 0.9, -0.12, 0
13172, 0.9125, -0.14, 0
13173, 0.925, -0.12, 0
13174, 0.9375, -0.14, 0
13175, 0.95, -0.12, 0
13176, 0.9625, -0.14, 0
13177, 0.975, -0.12, 0
13178, 0.9875, -0.14, 0
13179, 0.0125, -0.18, 0
13180, 0.025, -0.16, 0
13181, 0.0375, -0.18, 0
13182, 0.05, -0.16, 0
13183, 0.0625, -0.18, 0
13184, 0.075, -0.16, 0
13185, 0.0875, -0.18, 0
13186, 0.1, -0.16, 0
13187, 0.1125, -0.18, 0
13188, 0.125, -0.16, 0
13189, 0.1375, -0.18, 0
13190, 0.15, -0.16, 0
13191, 0.1625, -0.18, 0
13192, 0.175, -0.16, 0
13193, 0.1875, -0.18, 0
13194, 0.2, -0.16, 0
13195, 0.2125, -0.18, 0
13196, 0.225, -0.16, 0
13197, 0.2375, -0.18, 0
13198, 0.25, -0.16, 0
13199, 0.2625, -0.18, 0
13200, 0.275, -0.16, 0
13201, 0.2875, -0.18, 0
13202, 0.3, -0.16, 0
13203, 0.3125, -0.18, 0
13204, 0.325, -0.16, 0
13205, 0.3375, -0.18, 0
13206, 0.35, -0.16, 0
13207, 0.3625, -0.18, 0
13208, 0.375, -0.16, 0
13209, 0.3875, -0.18, 0
13210, 0.4, -0.16, 0
13211, 0.4125, -0.18, 0
13212, 0.425, -0.16, 0
13213, 0.4375, -0.18, 0
13214, 0.45, -0.16, 0
13215, 0.4625, -0.18, 0
13216, 0.475, -0.16, 0
13217, 0.4875, -0.18, 0
13218, 0.5, -0.16, 0
13219, 0.5125, -0.18, 0
13220, 0.525, -0.16, 0
13221, 0.5375, -0.18, 0
13222, 0.55, -0.16, 0
13223, 0.5625, -0.18, 0
13224, 0.575, -0.16, 0
13225, 0.5875, -0.18, 0
13226, 0.6, -0.16, 0
13227, 0.6125, -0.18, 0
13228, 0.625, -0.16, 0
13229, 0.6375, -0.18, 0
13230, 0.65, -0.16, 0
13231, 0.6625, -0.18, 0
13232, 0.675, -0.16, 0
13233, 0.6875, -0.18, 0
13234, 0.7, -0.16, 0
13235, 0.7125, -0.18, 0
13236, 0.725, -0.16, 0
13237, 0.7375, -0.18, 0
13238, 0.75, -0.16, 0
13239, 0.7625, -0.18, 0
13240, 0.775, -0.16, 0
13241, 0.7875, -0.18, 0
13242, 0.8, -0.16, 0
13243, 0.8125, -0.18, 0
13244, 0.825, -0.16, 0
13245, 0.8375, -0.18, 0
13246, 0.85, -0.16, 0
13247, 0.8625, -0.18, 0
13248, 0.875, -0.16, 0
13249, 0.8875, -0.18, 0
13250, 0.9, -0.16, 0
13251, 0.9125, -0.18, 0
13252, 0.925, -0.16, 0
13253, 0.9375, -0.18, 0
13254, 0.95, -0.16, 0
13255, 0.9625, -0.18, 0
13256, 0.975, -0.16, 0
13257, 0.9875, -0.18, 0
13258, 0.0125, -0.22, 0
13259, 0.025, -0.2, 0
13260, 0.0375, -0.22, 0
13261, 0.05, -0.2, 0
13262, 0.0625, -0.22, 0
13263, 0.075, -0.2, 0
13264, 0.0875, -0.22, 0
13265, 0.1, -0.2, 0
13266, 0.1125, -0.22, 0
13267, 0.125, -0.2, 0
13268, 0.1375, -0.22, 0
13269, 0.15, -0.2, 0
13270, 0.1625, -0.22, 0
13271, 0.175, -0.2, 0
13272, 0.1875, -0.22, 0
13273, 0.2, -0.2, 0
13274, 0.2125, -0.22, 0
13275, 0.225, -0.2, 0
13276, 0.2375, -0.22, 0
13277, 0.25, -0.2, 0
13278, 0.2625, -0.22, 0
13279, 0.275, -0.2, 0
13280, 0.2875, -0.22, 0
13281, 0.3, -0.2, 0
13282, 0.3125, -0.22, 0
13283, 0.325, -0.2, 0
13284, 0.3375, -0.22, 0
13285, 0.35, -0.2, 0
13286, 0.3625, -0.22, 0
13287, 0.375, -0.2, 0
13288, 0.3875, -0.22, 0
13289, 0.4, -0.2, 0
13290, 0.4125, -0.22, 0
13291, 0.425, -0.2, 0
13292, 0.4375, -0.22, 0
13293, 0.45, -0.2, 0
13294, 0.4625, -0.22, 0
13295, 0.475, -0.2, 0
13296, 0.4875, -0.22, 0
13297, 0.5, -0.2, 0
13298, 0.5125, -0.22, 0
13299, 0.525, -0.2, 0
13300, 0.5375, -0.22, 0
13301, 0.55, -0.2, 0
13302, 0.5625, -0.22, 0
13303, 0.575, -0.2, 0
13304, 0.5875, -0.22, 0
13305, 0.6, -0.2, 0
13306, 0.6125, -0.22, 0
13307, 0.625, -0.2, 0
13308, 0.6375, -0.22, 0
13309, 0.65, -0.2, 0
13310, 0.6625, -0.22, 0
13311, 0.675, -0.2, 0
13312, 0.6875, -0.22, 0
13313, 0.7, -0.2, 0
13314, 0.7125, -0.22, 0
13315, 0.725, -0.2, 0
13316, 0.7375, -0.22, 0
13317, 0.75, -0.2, 0
13318, 0.7625, -0.22, 0
13319, 0.775, -0.2, 0
13320, 0.7875, -0.22, 0
13321, 0.8, -0.2, 0
13322, 0.8125, -0.22, 0
13323, 0.825, -0.2, 0
13324, 0.8375, -0.22, 0
13325, 0.85, -0.2, 0
13326, 0.8625, -0.22, 0
13327, 0.875, -0.2, 0
13328, 0.8875, -0.22, 0
13329, 0.9, -0.2, 0
13330, 0.9125, -0.22, 0
13331, 0.925, -0.2, 0
13332, 0.9375, -0.22, 0
13333, 0.95, -0.2, 0
13334, 0.9625, -0.22, 0
13335, 0.975, -0.2, 0
13336, 0.9875, -0.22, 0
13337, 0.0125, -0.26, 0
13338, 0.025, -0.24, 0
13339, 0.0375, -0.26, 0
13340, 0.05, -0.24, 0
13341, 0.0625, -0.26, 0
13342, 0.075, -0.24, 0
13343, 0.0875, -0.26, 0
13344, 0.1, -0.24, 0
13345, 0.1125, -0.26, 0
13346, 0.125, -0.24, 0
13347, 0.1375, -0.26, 0
13348, 0.15, -0.24, 0
13349, 0.1625, -0.26, 0
13350, 0.175, -0.24, 0
13351, 0.1875, -0.26, 0
13352, 0.2, -0.24, 0
13353, 0.2125, -0.26, 0
13354, 0.225, -0.24, 0
13355, 0.2375, -0.26, 0
13356, 0.25, -0.24, 0
13357, 0.2625, -0.26, 0
13358, 0.275, -0.24, 0
13359, 0.2875, -0.26, 0
13360, 0.3, -0.24, 0
13361, 0.3125, -0.26, 0
13362, 0.325, -0.24, 0
13363, 0.3375, -0.26, 0
13364, 0.35, -0.24, 0
13365, 0.3625, -0.26, 0
13366, 0.375, -0.24, 0
13367, 0.3875, -0.26, 0
13368, 0.4, -0.24, 0
13369, 0.4125, -0.26, 0
13370, 0.425, -0.24, 0
13371, 0.4375, -0.26, 0
13372, 0.45, -0.24, 0
13373, 0.4625, -0.26, 0
13374, 0.475, -0.24, 0
13375, 0.4875, -0.26, 0
13376, 0.5, -0.24, 0
13377, 0.5125, -0.26, 0
13378, 0.525, -0.24, 0
13379, 0.5375, -0.26, 0
13380, 0.55, -0.24, 0
13381, 0.5625, -0.26, 0
13382, 0.575, -0.24, 0
13383, 0.5875, -0.26, 0
13384, 0.6, -0.24, 0
13385, 0.6125, -0.26, 0
13386, 0.625, -0.24, 0
13387, 0.6375, -0.26, 0
13388, 0.65, -0.24, 0
13389, 0.6625, -0.26, 0
13390, 0.675, -0.24, 0
13391, 0.6875, -0.26, 0
13392, 0.7, -0.24, 0
13393, 0.7125, -0.26, 0
13394, 0.725, -0.24, 0
13395, 0.7375, -0.26, 0
13396, 0.75, -0.24, 0
13397, 0.7625, -0.26, 0
13398, 0.775, -0.24, 0
13399, 0.7875, -0.26, 0
13400, 0.8, -0.24, 0
13401, 0.8125, -0.26, 0
13402, 0.825, -0.24, 0
13403, 0.8375, -0.26, 0
13404, 0.85, -0.24, 0
13405, 0.8625, -0.26, 0
13406, 0.875, -0.24, 0
13407, 0.8875, -0.26, 0
13408, 0.9, -0.24, 0
13409, 0.9125, -0.26, 0
13410, 0.925, -0.24, 0
13411, 0.9375, -0.26, 0
13412, 0.95, -0.24, 0
13413, 0.9625, -0.26, 0
13414, 0.975, -0.24, 0
13415, 0.9875, -0.26, 0
13416, 0.025, -0.28, 0
13417, 0.05, -0.28, 0
13418, 0.075, -0.28, 0
13419, 0.1, -0.28, 0
13420, 0.125, -0.28, 0
13421, 0.15, -0.28, 0
13422, 0.175, -0.28, 0
13423, 0.2, -0.28, 0
13424, 0.225, -0.28, 0
13425, 0.25, -0.28, 0
13426, 0.275, -0.28, 0
13427, 0.3, -0.28, 0
13428, 0.325, -0.28, 0
13429, 0.35, -0.28, 0
13430, 0.375, -0.28, 0
13431, 0.4, -0.28, 0
13432, 0.425, -0.28, 0
13433, 0.45, -0.28, 0
13434, 0.475, -0.28, 0
13435, 0.5, -0.28, 0
13436, 0.525, -0.28, 0
13437, 0.55, -0.28, 0
13438, 0.575, -0.28, 0
13439, 0.6, -0.28, 0
13440, 0.625, -0.28, 0
13441, 0.65, -0.28, 0
13442, 0.675, -0.28, 0
13443, 0.7, -0.28, 0
13444, 0.725, -0.28, 0
13445, 0.75, -0.28, 0
13446, 0.775, -0.28, 0
13447, 0.8, -0.28, 0
13448, 0.825, -0.28, 0
13449, 0.85, -0.28, 0
13450, 0.875, -0.28, 0
13451, 0.9, -0.28, 0
13452, 0.925, -0.28, 0
13453, 0.95, -0.28, 0
13454, 0.975, -0.28, 0
13455, 1.225, -0.14, 0
13456, 1.25, -0.14, 0
13457, 1.275, -0.14, 0
13458, 1.3, -0.14, 0
13459, 1.325, -0.14, 0
13460, 1.35, -0.14, 0
13461, 1.375, -0.14, 0
13462, 1.4, -0.14, 0
13463, 1.425, -0.14, 0
13464, 1.45, -0.14, 0
13465, 1.475, -0.14, 0
13466, 1.5, -0.14, 0
13467, 1.525, -0.14, 0
13468, 1.55, -0.14, 0
13469, 1.575, -0.14, 0
13470, 1.6, -0.14, 0
13471, 1.625, -0.14, 0
13472, 1.65, -0.14, 0
13473, 1.675, -0.14, 0
13474, 1.7, -0.14, 0
13475, 1.725, -0.14, 0
13476, 1.75, -0.14, 0
13477, 1.775, -0.14, 0
13478, 1.8, -0.14, 0
13479, 1.825, -0.14, 0
13480, 1.85, -0.14, 0
13481, 1.875, -0.14, 0
13482, 1.9, -0.14, 0
13483, 1.925, -0.14, 0
13484, 1.95, -0.14, 0
13485, 1.975, -0.14, 0
13486, 2, -0.14, 0
13487, 2.025, -0.14, 0
13488, 2.05, -0.14, 0
13489, 2.075, -0.14, 0
13490, 2.1, -0.14, 0
13491, 2.125, -0.14, 0
13492, 2.15, -0.14, 0
13493, 2.175, -0.14, 0
13494, 1.225, -0.18, 0
13495, 1.25, -0.18, 0
13496, 1.275, -0.18, 0
13497, 1.3, -0.18, 0
13498, 1.325, -0.18, 0
13499, 1.35, -0.18, 0
13500, 1.375, -0.18, 0
13501, 1.4, -0.18, 0
13502, 1.425, -0.18, 0
13503, 1.45, -0.18, 0
13504, 1.475, -0.18, 0
13505, 1.5, -0.18, 0
13506, 1.525, -0.18, 0
13507, 1.55, -0.18, 0
13508, 1.575, -0.18, 0
13509, 1.6, -0.18, 0
13510, 1.625, -0.18, 0
13511, 1.65, -0.18, 0
13512, 1.675, -0.18, 0
13513, 1.7, -0.18, 0
13514, 1.725, -0.18, 0
13515, 1.75, -0.18, 0
13516, 1.775, -0.18, 0
13517, 1.8, -0.18, 0
13518, 1.825, -0.18, 0
13519, 1.85, -0.18, 0
13520, 1.875, -0.18, 0
13521, 1.9, -0.18, 0
13522, 1.925, -0.18, 0
13523, 1.95, -0.18, 0
13524, 1.975, -0.18, 0
13525, 2, -0.18, 0
13526, 2.025, -0.18, 0
13527, 2.05, -0.18, 0
13528, 2.075, -0.18, 0
13529, 2.1, -0.18, 0
13530, 2.125, -0.18, 0
13531, 2.15, -0.18, 0
13532, 2.175, -0.18, 0
13533, 1.225, -0.22, 0
13534, 1.25, -0.22, 0
13535, 1.275, -0.22, 0
13536, 1.3, -0.22, 0
13537, 1.325, -0.22, 0
13538, 1.35, -0.22, 0
13539, 1.375, -0.22, 0
13540, 1.4, -0.22, 0
13541, 1.425, -0.22, 0
13542, 1.45, -0.22, 0
13543, 1.475, -0.22, 0
13544, 1.5, -0.22, 0
13545, 1.525, -0.22, 0
13546, 1.55, -0.22, 0
13547, 1.575, -0.22, 0
13548, 1.6, -0.22, 0
13549, 1.625, -0.22, 0
13550, 1.65, -0.22, 0
13551, 1.675, -0.22, 0
13552, 1.7, -0.22, 0
13553, 1.725, -0.22, 0
13554, 1.75, -0.22, 0
13555, 1.775, -0.22, 0
13556, 1.8, -0.22, 0
13557, 1.825, -0.22, 0
13558, 1.85, -0.22, 0
13559, 1.875, -0.22, 0
13560, 1.9, -0.22, 0
13561, 1.925, -0.22, 0
13562, 1.95, -0.22, 0
13563, 1.975, -0.22, 0
13564, 2, -0.22, 0
13565, 2.025, -0.22, 0
13566, 2.05, -0.22, 0
13567, 2.075, -0.22, 0
13568, 2.1, -0.22, 0
13569, 2.125, -0.22, 0
13570, 2.15, -0.22, 0
13571, 2.175, -0.22, 0
13572, 1.225, -0.26, 0
13573, 1.25, -0.26, 0
13574, 1.275, -0.26, 0
13575, 1.3, -0.26, 0
13576, 1.325, -0.26, 0
13577, 1.35, -0.26, 0
13578, 1.375, -0.26, 0
13579, 1.4, -0.26, 0
13580, 1.425, -0.26, 0
13581, 1.45, -0.26, 0
13582, 1.475, -0.26, 0
13583, 1.5, -0.26, 0
13584, 1.525, -0.26, 0
13585, 1.55, -0.26, 0
13586, 1.575, -0.26, 0
13587, 1.6, -0.26, 0
13588, 1.625, -0.26, 0
13589, 1.65, -0.26, 0
13590, 1.675, -0.26, 0
13591, 1.7, -0.26, 0
13592, 1.725, -0.26, 0
13593, 1.75, -0.26, 0
13594, 1.775, -0.26, 0
13595, 1.8, -0.26, 0
13596, 1.825, -0.26, 0
13597, 1.85, -0.26, 0
13598, 1.875, -0.26, 0
13599, 1.9, -0.26, 0
13600, 1.925, -0.26, 0
13601, 1.95, -0.26, 0
13602, 1.975, -0.26, 0
13603, 2, -0.26, 0
13604, 2.025, -0.26, 0
13605, 2.05, -0.26, 0
13606, 2.075, -0.26, 0
13607, 2.1, -0.26, 0
13608, 2.125, -0.26, 0
13609, 2.15, -0.26, 0
13610, 2.175, -0.26, 0
13611, 1.2125, -0.14, 0
13612, 1.225, -0.12, 0
13613, 1.2375, -0.14, 0
13614, 1.25, -0.12, 0
13615, 1.2625, -0.14, 0
13616, 1.275, -0.12, 0
13617, 1.2875, -0.14, 0
13618, 1.3, -0.12, 0
13619, 1.3125, -0.14, 0
13620, 1.325, -0.12, 0
13621, 1.3375, -0.14, 0
13622, 1.35, -0.12, 0
13623, 1.3625, -0.14, 0
13624, 1.375, -0.12, 0
13625, 1.3875, -0.14, 0
13626, 1.4, -0.12, 0
13627, 1.4125, -0.14, 0
13628, 1.425, -0.12, 0
13629, 1.4375, -0.14, 0
13630, 1.45, -0.12, 0
13631, 1.4625, -0.14, 0
13632, 1.475, -0.12, 0
13633, 1.4875, -0.14, 0
13634, 1.5, -0.12, 0
13635, 1.5125, -0.14, 0
13636, 1.525, -0.12, 0
13637, 1.5375, -0.14, 0
13638, 1.55, -0.12, 0
13639, 1.5625, -0.14, 0
13640, 1.575, -0.12, 0
13641, 1.5875, -0.14, 0
13642, 1.6, -0.12, 0
13643, 1.6125, -0.14, 0
13644, 1.625, -0.12, 0
13645, 1.6375, -0.14, 0
13646, 1.65, -0.12, 0
13647, 1.6625, -0.14, 0
13648, 1.675, -0.12, 0
13649, 1.6875, -0.14, 0
13650, 1.7, -0.12, 0
13651, 1.7125, -0.14, 0
13652, 1.725, -0.12, 0
13653, 1.7375, -0.14, 0
13654, 1.75, -0.12, 0
13655, 1.7625, -0.14, 0
13656, 1.775, -0.12, 0
13657, 1.7875, -0.14, 0
13658, 1.8, -0.12, 0
13659, 1.8125, -0.14, 0
13660, 1.825, -0.12, 0
13661, 1.8375, -0.14, 0
13662, 1.85, -0.12, 0
13663, 1.8625, -0.14, 0
13664, 1.875, -0.12, 0
13665, 1.8875, -0.14, 0
13666, 1.9, -0.12, 0
13667, 1.9125, -0.14, 0
13668, 1.925, -0.12, 0
13669, 1.9375, -0.14, 0
13670, 1.95, -0.12, 0
13671, 1.9625, -0.14, 0
13672, 1.975, -0.12, 0
13673, 1.9875, -0.14, 0
13674, 2, -0.12, 0
13675, 2.0125, -0.14, 0
13676, 2.025, -0.12, 0
13677, 2.0375, -0.14, 0
13678, 2.05, -0.12, 0
13679, 2.0625, -0.14, 0
13680, 2.075, -0.12, 0
13681, 2.0875, -0.14, 0
13682, 2.1, -0.12, 0
13683, 2.1125, -0.14, 0
13684, 2.125, -0.12, 0
13685, 2.1375, -0.14, 0
13686, 2.15, -0.12, 0
13687, 2.1625, -0.14, 0
13688, 2.175, -0.12, 0
13689, 2.1875, -0.14, 0
13690, 1.2125, -0.18, 0
13691, 1.225, -0.16, 0
13692, 1.2375, -0.18, 0
13693, 1.25, -0.16, 0
13694, 1.2625, -0.18, 0
13695, 1.275, -0.16, 0
13696, 1.2875, -0.18, 0
13697, 1.3, -0.16, 0
13698, 1.3125, -0.18, 0
13699, 1.325, -0.16, 0
13700, 1.3375, -0.18, 0
13701, 1.35, -0.16, 0
13702, 1.3625, -0.18, 0
13703, 1.375, -0.16, 0
13704, 1.3875, -0.18, 0
13705, 1.4, -0.16, 0
13706, 1.4125, -0.18, 0
13707, 1.425, -0.16, 0
13708, 1.4375, -0.18, 0
13709, 1.45, -0.16, 0
13710, 1.4625, -0.18, 0
13711, 1.475, -0.16, 0
13712, 1.4875, -0.18, 0
13713, 1.5, -0.16, 0
13714, 1.5125, -0.18, 0
13715, 1.525, -0.16, 0
13716, 1.5375, -0.18, 0
13717, 1.55, -0.16, 0
13718, 1.5625, -0.18, 0
13719, 1.575, -0.16, 0
13720, 1.5875, -0.18, 0
13721, 1.6, -0.16, 0
13722, 1.6125, -0.18, 0
13723, 1.625, -0.16, 0
13724, 1.6375, -0.18, 0
13725, 1.65, -0.16, 0
13726, 1.6625, -0.18, 0
13727, 1.675, -0.16, 0
13728, 1.6875, -0.18, 0
13729, 1.7, -0.16, 0
13730, 1.7125, -0.18, 0
13731, 1.725, -0.16, 0
13732, 1.7375, -0.18, 0
13733, 1.75, -0.16, 0
13734, 1.7625, -0.18, 0
13735, 1.775, -0.16, 0
13736, 1.7875, -0.18, 0
13737, 1.8, -0.16, 0
13738, 1.8125, -0.18, 0
13739, 1.825, -0.16, 0
13740, 1.8375, -0.18, 0
13741, 1.85, -0.16, 0
13742, 1.8625, -0.18, 0
13743, 1.875, -0.16, 0
13744, 1.8875, -0.18, 0
13745, 1.9, -0.16, 0
13746, 1.9125, -0.18, 0
13747, 1.925, -0.16, 0
13748, 1.9375, -0.18, 0
13749, 1.95, -0.16, 0
13750, 1.9625, -0.18, 0
13751, 1.975, -0.16, 0
13752, 1.9875, -0.18, 0
13753, 2, -0.16, 0
13754, 2.0125, -0.18, 0
13755, 2.025, -0.16, 0
13756, 2.0375, -0.18, 0
13757, 2.05, -0.16, 0
13758, 2.0625, -0.18, 0
13759, 2.075, -0.16, 0
13760, 2.0875, -0.18, 0
13761, 2.1, -0.16, 0
13762, 2.1125, -0.18, 0
13763, 2.125, -0.16, 0
13764, 2.1375, -0.18, 0
13765, 2.15, -0.16, 0
13766, 2.1625, -0.18, 0
13767, 2.175, -0.16, 0
13768, 2.1875, -0.18, 0
13769, 1.2125, -0.22, 0
13770, 1.225, -0.2, 0
13771, 1.2375, -0.22, 0
13772, 1.25, -0.2, 0
13773, 1.2625, -0.22, 0
13774, 1.275, -0.2, 0
13775, 1.2875, -0.22, 0
13776, 1.3, -0.2, 0
13777, 1.3125, -0.22, 0
13778, 1.325, -0.2, 0
13779, 1.3375, -0.22, 0
13780, 1.35, -0.2, 0
13781, 1.3625, -0.22, 0
13782, 1.375, -0.2, 0
13783, 1.3875, -0.22, 0
13784, 1.4, -0.2, 0
13785, 1.4125, -0.22, 0
13786, 1.425, -0.2, 0
13787, 1.4375, -0.22, 0
13788, 1.45, -0.2, 0
13789, 1.4625, -0.22, 0
13790, 1.475, -0.2, 0
13791, 1.4875, -0.22, 0
13792, 1.5, -0.2, 0
13793, 1.5125, -0.22, 0
13794, 1.525, -0.2, 0
13795, 1.5375, -0.22, 0
13796, 1.55, -0.2, 0
13797, 1.5625, -0.22, 0
13798, 1.575, -0.2, 0
13799, 1.5875, -0.22, 0
13800, 1.6, -0.2, 0
13801, 1.6125, -0.22, 0
13802, 1.625, -0.2, 0
13803, 1.6375, -0.22, 0
13804, 1.65, -0.2, 0
13805, 1.6625, -0.22, 0
13806, 1.675, -0.2, 0
13807, 1.6875, -0.22, 0
13808, 1.7, -0.2, 0
13809, 1.7125, -0.22, 0
13810, 1.725, -0.2, 0
13811, 1.7375, -0.22, 0
13812, 1.75, -0.2, 0
13813, 1.7625, -0.22, 0
13814, 1.775, -0.2, 0
13815, 1.7875, -0.22, 0
13816, 1.8, -0.2, 0
13817, 1.8125, -0.22, 0
13818, 1.825, -0.2, 0
13819, 1.8375, -0.22, 0
13820, 1.85, -0.2, 0
13821, 1.8625, -0.22, 0
13822, 1.875, -0.2, 0
13823, 1.8875, -0.22, 0
13824, 1.9, -0.2, 0
13825, 1.9125, -0.22, 0
13826, 1.925, -0.2, 0
13827, 1.9375, -0.22, 0
13828, 1.95, -0.2, 0
13829, 1.9625, -0.22, 0
13830, 1.975, -0.2, 0
13831, 1.9875, -0.22, 0
13832, 2, -0.2, 0
13833, 2.0125, -0.22, 0
13834, 2.025, -0.2, 0
13835, 2.0375, -0.22, 0
13836, 2.05, -0.2, 0
13837, 2.0625, -0.22, 0
13838, 2.075, -0.2, 0
13839, 2.0875, -0.22, 0
13840, 2.1, -0.2, 0
13841, 2.1125, -0.22, 0
13842, 2.125, -0.2, 0
13843, 2.1375, -0.22, 0
13844, 2.15, -0.2, 0
13845, 2.1625, -0.22, 0
13846, 2.175, -0.2, 0
13847, 2.1875, -0.22, 0
13848, 1.2125, -0.26, 0
13849, 1.225, -0.24, 0
13850, 1.2375, -0.26, 0
13851, 1.25, -0.24, 0
13852, 1.2625, -0.26, 0
13853, 1.275, -0.24, 0
13854, 1.2875, -0.26, 0
13855, 1.3, -0.24, 0
13856, 1.3125, -0.26, 0
13857, 1.325, -0.24, 0
13858, 1.3375, -0.26, 0
13859, 1.35, -0.24, 0
13860, 1.3625, -0.26, 0
13861, 1.375, -0.24, 0
13862, 1.3875, -0.26, 0
13863, 1.4, -0.24, 0
13864, 1.4125, -0.26, 0
13865, 1.425, -0.24, 0
13866, 1.4375, -0.26, 0
13867, 1.45, -0.24, 0
13868, 1.4625, -0.26, 0
13869, 1.475, -0.24, 0
13870, 1.4875, -0.26, 0
13871, 1.5, -0.24, 0
13872, 1.5125, -0.26, 0
13873, 1.525, -0.24, 0
13874, 1.5375, -0.26, 0
13875, 1.55, -0.24, 0
13876, 1.5625, -0.26, 0
13877, 1.575, -0.24, 0
13878, 1.5875, -0.26, 0
13879, 1.6, -0.24, 0
13880, 1.6125, -0.26, 0
13881, 1.625, -0.24, 0
13882, 1.6375, -0.26, 0
13883, 1.65, -0.24, 0
13884, 1.6625, -0.26, 0
13885, 1.675, -0.24, 0
13886, 1.6875, -0.26, 0
13887, 1.7, -0.24, 0
13888, 1.7125, -0.26, 0
13889, 1.725, -0.24, 0
13890, 1.7375, -0.26, 0
13891, 1.75, -0.24, 0
13892, 1.7625, -0.26, 0
13893, 1.775, -0.24, 0
13894, 1.7875, -0.26, 0
13895, 1.8, -0.24, 0
13896, 1.8125, -0.26, 0
13897, 1.825, -0.24, 0
13898, 1.8375, -0.26, 0
13899, 1.85, -0.24, 0
13900, 1.8625, -0.26, 0
13901, 1.875, -0.24, 0
13902, 1.8875, -0.26, 0
13903, 1.9, -0.24, 0
13904, 1.9125, -0.26, 0
13905, 1.925, -0.24, 0
13906, 1.9375, -0.26, 0
13907, 1.95, -0.24, 0
13908, 1.9625, -0.26, 0
13909, 1.975, -0.24, 0
13910, 1.9875, -0.26, 0
13911, 2, -0.24, 0
13912, 2.0125, -0.26, 0
13913, 2.025, -0.24, 0
13914, 2.0375, -0.26, 0
13915, 2.05, -0.24, 0
13916, 2.0625, -0.26, 0
13917, 2.075, -0.24, 0
13918, 2.0875, -0.26, 0
13919, 2.1, -0.24, 0
13920, 2.1125, -0.26, 0
13921, 2.125, -0.24, 0
13922, 2.1375, -0.26, 0
13923, 2.15, -0.24, 0
13924, 2.1625, -0.26, 0
13925, 2.175, -0.24, 0
13926, 2.1875, -0.26, 0
13927, 1.225, -0.28, 0
13928, 1.25, -0.28, 0
13929, 1.275, -0.28, 0
13930, 1.3, -0.28, 0
13931, 1.325, -0.28, 0
13932, 1.35, -0.28, 0
13933, 1.375, -0.28, 0
13934, 1.4, -0.28, 0
13935, 1.425, -0.28, 0
13936, 1.45, -0.28, 0
13937, 1.475, -0.28, 0
13938, 1.5, -0.28, 0
13939, 1.525, -0.28, 0
13940, 1.55, -0.28, 0
13941, 1.575, -0.28, 0
13942, 1.6, -0.28, 0
13943, 1.625, -0.28, 0
13944, 1.65, -0.28, 0
13945, 1.675, -0.28, 0
13946, 1.7, -0.28, 0
13947, 1.725, -0.28, 0
13948, 1.75, -0.28, 0
13949, 1.775, -0.28, 0
13950, 1.8, -0.28, 0
13951, 1.825, -0.28, 0
13952, 1.85, -0.28, 0
13953, 1.875, -0.28, 0
13954, 1.9, -0.28, 0
13955, 1.925, -0.28, 0
13956, 1.95, -0.28, 0
13957, 1.975, -0.28, 0
13958, 2, -0.28, 0
13959, 2.025, -0.28, 0
13960, 2.05, -0.28, 0
13961, 2.075, -0.28, 0
13962, 2.1, -0.28, 0
13963, 2.125, -0.28, 0
13964, 2.15, -0.28, 0
13965, 2.175, -0.28, 0
13966, 2.2333333333333, -0.14, 0
13967, 2.2666666666667, -0.14, 0
13968, 2.2333333333333, -0.18, 0
13969, 2.2666666666667, -0.18, 0
13970, 2.2333333333333, -0.22, 0
13971, 2.2666666666667, -0.22, 0
13972, 2.2333333333333, -0.26, 0
13973, 2.2666666666667, -0.26, 0
13974, 2.2166666666667, -0.14, 0
13975, 2.2333333333333, -0.12, 0
13976, 2.25, -0.14, 0
13977, 2.2666666666667, -0.12, 0
13978, 2.2833333333333, -0.14, 0
13979, 2.2166666666667, -0.18, 0
13980, 2.2333333333333, -0.16, 0
13981, 2.25, -0.18, 0
13982, 2.2666666666667, -0.16, 0
13983, 2.2833333333333, -0.18, 0
13984, 2.2166666666667, -0.22, 0
13985, 2.2333333333333, -0.2, 0
13986, 2.25, -0.22, 0
13987, 2.2666666666667, -0.2, 0
13988, 2.2833333333333, -0.22, 0
13989, 2.2166666666667, -0.26, 0
13990, 2.2333333333333, -0.24, 0
13991, 2.25, -0.26, 0
13992, 2.2666666666667, -0.24, 0
13993, 2.2833333333333, -0.26, 0
13994, 2.2333333333333, -0.28, 0
13995, 2.2666666666667, -0.28, 0
13996, 0.975, 1.34, 0
13997, 0.95, 1.34, 0
13998, 0.925, 1.34, 0
13999, 0.9, 1.34, 0
14000, 0.875, 1.34, 0
14001, 0.85, 1.34, 0
14002, 0.825, 1.34, 0
14003, 0.8, 1.34, 0
14004, 0.775, 1.34, 0
14005, 0.75, 1.34, 0
14006, 0.725, 1.34, 0
14007, 0.7, 1.34, 0
14008, 0.675, 1.34, 0
14009, 0.65, 1.34, 0
14010, 0.625, 1.34, 0
14011, 0.6, 1.34, 0
14012, 0.575, 1.34, 0
14013, 0.55, 1.34, 0
14014, 0.525, 1.34, 0
14015, 0.5, 1.34, 0
14016, 0.475, 1.34, 0
14017, 0.45, 1.34, 0
14018, 0.425, 1.34, 0
14019, 0.4, 1.34, 0
14020, 0.375, 1.34, 0
14021, 0.35, 1.34, 0
14022, 0.325, 1.34, 0
14023, 0.3, 1.34, 0
14024, 0.275, 1.34, 0
14025, 0.25, 1.34, 0
14026, 0.225, 1.34, 0
14027, 0.2, 1.34, 0
14028, 0.175, 1.34, 0
14029, 0.15, 1.34, 0
14030, 0.125, 1.34, 0
14031, 0.1, 1.34, 0
14032, 0.075, 1.34, 0
14033, 0.05, 1.34, 0
14034, 0.025, 1.34, 0
14035, 0.975, 1.38, 0
14036, 0.95, 1.38, 0
14037, 0.925, 1.38, 0
14038, 0.9, 1.38, 0
14039, 0.875, 1.38, 0
14040, 0.85, 1.38, 0
14041, 0.825, 1.38, 0
14042, 0.8, 1.38, 0
14043, 0.775, 1.38, 0
14044, 0.75, 1.38, 0
14045, 0.725, 1.38, 0
14046, 0.7, 1.38, 0
14047, 0.675, 1.38, 0
14048, 0.65, 1.38, 0
14049, 0.625, 1.38, 0
14050, 0.6, 1.38, 0
14051, 0.575, 1.38, 0
14052, 0.55, 1.38, 0
14053, 0.525, 1.38, 0
14054, 0.5, 1.38, 0
14055, 0.475, 1.38, 0
14056, 0.45, 1.38, 0
14057, 0.425, 1.38, 0
14058, 0.4, 1.38, 0
14059, 0.375, 1.38, 0
14060, 0.35, 1.38, 0
14061, 0.325, 1.38, 0
14062, 0.3, 1.38, 0
14063, 0.275, 1.38, 0
14064, 0.25, 1.38, 0
14065, 0.225, 1.38, 0
14066, 0.2, 1.38, 0
14067, 0.175, 1.38, 0
14068, 0.15, 1.38, 0
14069, 0.125, 1.38, 0
14070, 0.1, 1.38, 0
14071, 0.075, 1.38, 0
14072, 0.05, 1.38, 0
14073, 0.025, 1.38, 0
14074, 0.975, 1.42, 0
14075, 0.95, 1.42, 0
14076, 0.925, 1.42, 0
14077, 0.9, 1.42, 0
14078, 0.875, 1.42, 0
14079, 0.85, 1.42, 0
14080, 0.825, 1.42, 0
14081, 0.8, 1.42, 0
14082, 0.775, 1.42, 0
14083, 0.75, 1.42, 0
14084, 0.725, 1.42, 0
