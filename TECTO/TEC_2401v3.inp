7429, 0.15833333333333, 0.88, 0
7430, 0.16666666666667, 0.89, 0
7431, 0.15833333333333, 0.9, 0
7432, 0.16666666666667, 0.91, 0
7433, 0.15833333333333, 0.92, 0
7434, 0.16666666666667, 0.93, 0
7435, 0.15833333333333, 0.94, 0
7436, 0.16666666666667, 0.95, 0
7437, 0.15833333333333, 0.96, 0
7438, 0.16666666666667, 0.97, 0
7439, 0.15833333333333, 0.98, 0
7440, 0.16666666666667, 0.99, 0
7441, 0.15833333333333, 1, 0
7442, 0.16666666666667, 1.01, 0
7443, 0.15833333333333, 1.02, 0
7444, 0.16666666666667, 1.03, 0
7445, 0.15833333333333, 1.04, 0
7446, 0.16666666666667, 1.05, 0
7447, 0.15833333333333, 1.06, 0
7448, 0.16666666666667, 1.07, 0
7449, 0.15833333333333, 1.08, 0
7450, 0.16666666666667, 1.09, 0
7451, 0.15833333333333, 1.1, 0
7452, 0.16666666666667, 1.11, 0
7453, 0.15833333333333, 1.12, 0
7454, 0.16666666666667, 1.13, 0
7455, 0.15833333333333, 1.14, 0
7456, 0.16666666666667, 1.15, 0
7457, 0.15833333333333, 1.16, 0
7458, 0.16666666666667, 1.17, 0
7459, 0.15833333333333, 1.18, 0
7460, 0.16666666666667, 1.19, 0
7461, 0.18333333333333, 0.01, 0
7462, 0.175, 0.02, 0
7463, 0.18333333333333, 0.03, 0
7464, 0.175, 0.04, 0
7465, 0.18333333333333, 0.05, 0
7466, 0.175, 0.06, 0
7467, 0.18333333333333, 0.07, 0
7468, 0.175, 0.08, 0
7469, 0.18333333333333, 0.09, 0
7470, 0.175, 0.1, 0
7471, 0.18333333333333, 0.11, 0
7472, 0.175, 0.12, 0
7473, 0.18333333333333, 0.13, 0
7474, 0.175, 0.14, 0
7475, 0.18333333333333, 0.15, 0
7476, 0.175, 0.16, 0
7477, 0.18333333333333, 0.17, 0
7478, 0.175, 0.18, 0
7479, 0.18333333333333, 0.19, 0
7480, 0.175, 0.2, 0
7481, 0.18333333333333, 0.21, 0
7482, 0.175, 0.22, 0
7483, 0.18333333333333, 0.23, 0
7484, 0.175, 0.24, 0
7485, 0.18333333333333, 0.25, 0
7486, 0.175, 0.26, 0
7487, 0.18333333333333, 0.27, 0
7488, 0.175, 0.28, 0
7489, 0.18333333333333, 0.29, 0
7490, 0.175, 0.3, 0
7491, 0.18333333333333, 0.31, 0
7492, 0.175, 0.32, 0
7493, 0.18333333333333, 0.33, 0
7494, 0.175, 0.34, 0
7495, 0.18333333333333, 0.35, 0
7496, 0.175, 0.36, 0
7497, 0.18333333333333, 0.37, 0
7498, 0.175, 0.38, 0
7499, 0.18333333333333, 0.39, 0
7500, 0.175, 0.4, 0
7501, 0.18333333333333, 0.41, 0
7502, 0.175, 0.42, 0
7503, 0.18333333333333, 0.43, 0
7504, 0.175, 0.44, 0
7505, 0.18333333333333, 0.45, 0
7506, 0.175, 0.46, 0
7507, 0.18333333333333, 0.47, 0
7508, 0.175, 0.48, 0
7509, 0.18333333333333, 0.49, 0
7510, 0.175, 0.5, 0
7511, 0.18333333333333, 0.51, 0
7512, 0.175, 0.52, 0
7513, 0.18333333333333, 0.53, 0
7514, 0.175, 0.54, 0
7515, 0.18333333333333, 0.55, 0
7516, 0.175, 0.56, 0
7517, 0.18333333333333, 0.57, 0
7518, 0.175, 0.58, 0
7519, 0.18333333333333, 0.59, 0
7520, 0.175, 0.6, 0
7521, 0.18333333333333, 0.61, 0
7522, 0.175, 0.62, 0
7523, 0.18333333333333, 0.63, 0
7524, 0.175, 0.64, 0
7525, 0.18333333333333, 0.65, 0
7526, 0.175, 0.66, 0
7527, 0.18333333333333, 0.67, 0
7528, 0.175, 0.68, 0
7529, 0.18333333333333, 0.69, 0
7530, 0.175, 0.7, 0
7531, 0.18333333333333, 0.71, 0
7532, 0.175, 0.72, 0
7533, 0.18333333333333, 0.73, 0
7534, 0.175, 0.74, 0
7535, 0.18333333333333, 0.75, 0
7536, 0.175, 0.76, 0
7537, 0.18333333333333, 0.77, 0
7538, 0.175, 0.78, 0
7539, 0.18333333333333, 0.79, 0
7540, 0.175, 0.8, 0
7541, 0.18333333333333, 0.81, 0
7542, 0.175, 0.82, 0
7543, 0.18333333333333, 0.83, 0
7544, 0.175, 0.84, 0
7545, 0.18333333333333, 0.85, 0
7546, 0.175, 0.86, 0
7547, 0.18333333333333, 0.87, 0
7548, 0.175, 0.88, 0
7549, 0.18333333333333, 0.89, 0
7550, 0.175, 0.9, 0
7551, 0.18333333333333, 0.91, 0
7552, 0.175, 0.92, 0
7553, 0.18333333333333, 0.93, 0
7554, 0.175, 0.94, 0
7555, 0.18333333333333, 0.95, 0
7556, 0.175, 0.96, 0
7557, 0.18333333333333, 0.97, 0
7558, 0.175, 0.98, 0
7559, 0.18333333333333, 0.99, 0
7560, 0.175, 1, 0
7561, 0.18333333333333, 1.01, 0
7562, 0.175, 1.02, 0
7563, 0.18333333333333, 1.03, 0
7564, 0.175, 1.04, 0
7565, 0.18333333333333, 1.05, 0
7566, 0.175, 1.06, 0
7567, 0.18333333333333, 1.07, 0
7568, 0.175, 1.08, 0
7569, 0.18333333333333, 1.09, 0
7570, 0.175, 1.1, 0
7571, 0.18333333333333, 1.11, 0
7572, 0.175, 1.12, 0
7573, 0.18333333333333, 1.13, 0
7574, 0.175, 1.14, 0
7575, 0.18333333333333, 1.15, 0
7576, 0.175, 1.16, 0
7577, 0.18333333333333, 1.17, 0
7578, 0.175, 1.18, 0
7579, 0.18333333333333, 1.19, 0
7580, 0.2, 0.01, 0
7581, 0.19166666666667, 0.02, 0
7582, 0.2, 0.03, 0
7583, 0.19166666666667, 0.04, 0
7584, 0.2, 0.05, 0
7585, 0.19166666666667, 0.06, 0
7586, 0.2, 0.07, 0
7587, 0.19166666666667, 0.08, 0
7588, 0.2, 0.09, 0
7589, 0.19166666666667, 0.1, 0
7590, 0.2, 0.11, 0
7591, 0.19166666666667, 0.12, 0
7592, 0.2, 0.13, 0
7593, 0.19166666666667, 0.14, 0
7594, 0.2, 0.15, 0
7595, 0.19166666666667, 0.16, 0
7596, 0.2, 0.17, 0
7597, 0.19166666666667, 0.18, 0
7598, 0.2, 0.19, 0
7599, 0.19166666666667, 0.2, 0
7600, 0.2, 0.21, 0
7601, 0.19166666666667, 0.22, 0
7602, 0.2, 0.23, 0
7603, 0.19166666666667, 0.24, 0
7604, 0.2, 0.25, 0
7605, 0.19166666666667, 0.26, 0
7606, 0.2, 0.27, 0
7607, 0.19166666666667, 0.28, 0
7608, 0.2, 0.29, 0
7609, 0.19166666666667, 0.3, 0
7610, 0.2, 0.31, 0
7611, 0.19166666666667, 0.32, 0
7612, 0.2, 0.33, 0
7613, 0.19166666666667, 0.34, 0
7614, 0.2, 0.35, 0
7615, 0.19166666666667, 0.36, 0
7616, 0.2, 0.37, 0
7617, 0.19166666666667, 0.38, 0
7618, 0.2, 0.39, 0
7619, 0.19166666666667, 0.4, 0
7620, 0.2, 0.41, 0
7621, 0.19166666666667, 0.42, 0
7622, 0.2, 0.43, 0
7623, 0.19166666666667, 0.44, 0
7624, 0.2, 0.45, 0
7625, 0.19166666666667, 0.46, 0
7626, 0.2, 0.47, 0
7627, 0.19166666666667, 0.48, 0
7628, 0.2, 0.49, 0
7629, 0.19166666666667, 0.5, 0
7630, 0.2, 0.51, 0
7631, 0.19166666666667, 0.52, 0
7632, 0.2, 0.53, 0
7633, 0.19166666666667, 0.54, 0
7634, 0.2, 0.55, 0
7635, 0.19166666666667, 0.56, 0
7636, 0.2, 0.57, 0
7637, 0.19166666666667, 0.58, 0
7638, 0.2, 0.59, 0
7639, 0.19166666666667, 0.6, 0
7640, 0.2, 0.61, 0
7641, 0.19166666666667, 0.62, 0
7642, 0.2, 0.63, 0
7643, 0.19166666666667, 0.64, 0
7644, 0.2, 0.65, 0
7645, 0.19166666666667, 0.66, 0
7646, 0.2, 0.67, 0
7647, 0.19166666666667, 0.68, 0
7648, 0.2, 0.69, 0
7649, 0.19166666666667, 0.7, 0
7650, 0.2, 0.71, 0
7651, 0.19166666666667, 0.72, 0
7652, 0.2, 0.73, 0
7653, 0.19166666666667, 0.74, 0
7654, 0.2, 0.75, 0
7655, 0.19166666666667, 0.76, 0
7656, 0.2, 0.77, 0
7657, 0.19166666666667, 0.78, 0
7658, 0.2, 0.79, 0
7659, 0.19166666666667, 0.8, 0
7660, 0.2, 0.81, 0
7661, 0.19166666666667, 0.82, 0
7662, 0.2, 0.83, 0
7663, 0.19166666666667, 0.84, 0
7664, 0.2, 0.85, 0
7665, 0.19166666666667, 0.86, 0
7666, 0.2, 0.87, 0
7667, 0.19166666666667, 0.88, 0
7668, 0.2, 0.89, 0
7669, 0.19166666666667, 0.9, 0
7670, 0.2, 0.91, 0
7671, 0.19166666666667, 0.92, 0
7672, 0.2, 0.93, 0
7673, 0.19166666666667, 0.94, 0
7674, 0.2, 0.95, 0
7675, 0.19166666666667, 0.96, 0
7676, 0.2, 0.97, 0
7677, 0.19166666666667, 0.98, 0
7678, 0.2, 0.99, 0
7679, 0.19166666666667, 1, 0
7680, 0.2, 1.01, 0
7681, 0.19166666666667, 1.02, 0
7682, 0.2, 1.03, 0
7683, 0.19166666666667, 1.04, 0
7684, 0.2, 1.05, 0
7685, 0.19166666666667, 1.06, 0
7686, 0.2, 1.07, 0
7687, 0.19166666666667, 1.08, 0
7688, 0.2, 1.09, 0
7689, 0.19166666666667, 1.1, 0
7690, 0.2, 1.11, 0
7691, 0.19166666666667, 1.12, 0
7692, 0.2, 1.13, 0
7693, 0.19166666666667, 1.14, 0
7694, 0.2, 1.15, 0
7695, 0.19166666666667, 1.16, 0
7696, 0.2, 1.17, 0
7697, 0.19166666666667, 1.18, 0
7698, 0.2, 1.19, 0
7699, 0.21666666666667, 0.01, 0
7700, 0.20833333333333, 0.02, 0
7701, 0.21666666666667, 0.03, 0
7702, 0.20833333333333, 0.04, 0
7703, 0.21666666666667, 0.05, 0
7704, 0.20833333333333, 0.06, 0
7705, 0.21666666666667, 0.07, 0
7706, 0.20833333333333, 0.08, 0
7707, 0.21666666666667, 0.09, 0
7708, 0.20833333333333, 0.1, 0
7709, 0.21666666666667, 0.11, 0
7710, 0.20833333333333, 0.12, 0
7711, 0.21666666666667, 0.13, 0
7712, 0.20833333333333, 0.14, 0
7713, 0.21666666666667, 0.15, 0
7714, 0.20833333333333, 0.16, 0
7715, 0.21666666666667, 0.17, 0
7716, 0.20833333333333, 0.18, 0
7717, 0.21666666666667, 0.19, 0
7718, 0.20833333333333, 0.2, 0
7719, 0.21666666666667, 0.21, 0
7720, 0.20833333333333, 0.22, 0
7721, 0.21666666666667, 0.23, 0
7722, 0.20833333333333, 0.24, 0
7723, 0.21666666666667, 0.25, 0
7724, 0.20833333333333, 0.26, 0
7725, 0.21666666666667, 0.27, 0
7726, 0.20833333333333, 0.28, 0
7727, 0.21666666666667, 0.29, 0
7728, 0.20833333333333, 0.3, 0
7729, 0.21666666666667, 0.31, 0
7730, 0.20833333333333, 0.32, 0
7731, 0.21666666666667, 0.33, 0
7732, 0.20833333333333, 0.34, 0
7733, 0.21666666666667, 0.35, 0
7734, 0.20833333333333, 0.36, 0
7735, 0.21666666666667, 0.37, 0
7736, 0.20833333333333, 0.38, 0
7737, 0.21666666666667, 0.39, 0
7738, 0.20833333333333, 0.4, 0
7739, 0.21666666666667, 0.41, 0
7740, 0.20833333333333, 0.42, 0
7741, 0.21666666666667, 0.43, 0
7742, 0.20833333333333, 0.44, 0
7743, 0.21666666666667, 0.45, 0
7744, 0.20833333333333, 0.46, 0
7745, 0.21666666666667, 0.47, 0
7746, 0.20833333333333, 0.48, 0
7747, 0.21666666666667, 0.49, 0
7748, 0.20833333333333, 0.5, 0
7749, 0.21666666666667, 0.51, 0
7750, 0.20833333333333, 0.52, 0
7751, 0.21666666666667, 0.53, 0
7752, 0.20833333333333, 0.54, 0
7753, 0.21666666666667, 0.55, 0
7754, 0.20833333333333, 0.56, 0
7755, 0.21666666666667, 0.57, 0
7756, 0.20833333333333, 0.58, 0
7757, 0.21666666666667, 0.59, 0
7758, 0.20833333333333, 0.6, 0
7759, 0.21666666666667, 0.61, 0
7760, 0.20833333333333, 0.62, 0
7761, 0.21666666666667, 0.63, 0
7762, 0.20833333333333, 0.64, 0
7763, 0.21666666666667, 0.65, 0
7764, 0.20833333333333, 0.66, 0
7765, 0.21666666666667, 0.67, 0
7766, 0.20833333333333, 0.68, 0
7767, 0.21666666666667, 0.69, 0
7768, 0.20833333333333, 0.7, 0
7769, 0.21666666666667, 0.71, 0
7770, 0.20833333333333, 0.72, 0
7771, 0.21666666666667, 0.73, 0
7772, 0.20833333333333, 0.74, 0
7773, 0.21666666666667, 0.75, 0
7774, 0.20833333333333, 0.76, 0
7775, 0.21666666666667, 0.77, 0
7776, 0.20833333333333, 0.78, 0
7777, 0.21666666666667, 0.79, 0
7778, 0.20833333333333, 0.8, 0
7779, 0.21666666666667, 0.81, 0
7780, 0.20833333333333, 0.82, 0
7781, 0.21666666666667, 0.83, 0
7782, 0.20833333333333, 0.84, 0
7783, 0.21666666666667, 0.85, 0
7784, 0.20833333333333, 0.86, 0
7785, 0.21666666666667, 0.87, 0
7786, 0.20833333333333, 0.88, 0
7787, 0.21666666666667, 0.89, 0
7788, 0.20833333333333, 0.9, 0
7789, 0.21666666666667, 0.91, 0
7790, 0.20833333333333, 0.92, 0
7791, 0.21666666666667, 0.93, 0
7792, 0.20833333333333, 0.94, 0
7793, 0.21666666666667, 0.95, 0
7794, 0.20833333333333, 0.96, 0
7795, 0.21666666666667, 0.97, 0
7796, 0.20833333333333, 0.98, 0
7797, 0.21666666666667, 0.99, 0
7798, 0.20833333333333, 1, 0
7799, 0.21666666666667, 1.01, 0
7800, 0.20833333333333, 1.02, 0
7801, 0.21666666666667, 1.03, 0
7802, 0.20833333333333, 1.04, 0
7803, 0.21666666666667, 1.05, 0
7804, 0.20833333333333, 1.06, 0
7805, 0.21666666666667, 1.07, 0
7806, 0.20833333333333, 1.08, 0
7807, 0.21666666666667, 1.09, 0
7808, 0.20833333333333, 1.1, 0
7809, 0.21666666666667, 1.11, 0
7810, 0.20833333333333, 1.12, 0
7811, 0.21666666666667, 1.13, 0
7812, 0.20833333333333, 1.14, 0
7813, 0.21666666666667, 1.15, 0
7814, 0.20833333333333, 1.16, 0
7815, 0.21666666666667, 1.17, 0
7816, 0.20833333333333, 1.18, 0
7817, 0.21666666666667, 1.19, 0
7818, 0.23333333333333, 0.01, 0
7819, 0.225, 0.02, 0
7820, 0.23333333333333, 0.03, 0
7821, 0.225, 0.04, 0
7822, 0.23333333333333, 0.05, 0
7823, 0.225, 0.06, 0
7824, 0.23333333333333, 0.07, 0
7825, 0.225, 0.08, 0
7826, 0.23333333333333, 0.09, 0
7827, 0.225, 0.1, 0
7828, 0.23333333333333, 0.11, 0
7829, 0.225, 0.12, 0
7830, 0.23333333333333, 0.13, 0
7831, 0.225, 0.14, 0
7832, 0.23333333333333, 0.15, 0
7833, 0.225, 0.16, 0
7834, 0.23333333333333, 0.17, 0
7835, 0.225, 0.18, 0
7836, 0.23333333333333, 0.19, 0
7837, 0.225, 0.2, 0
7838, 0.23333333333333, 0.21, 0
7839, 0.225, 0.22, 0
7840, 0.23333333333333, 0.23, 0
7841, 0.225, 0.24, 0
7842, 0.23333333333333, 0.25, 0
7843, 0.225, 0.26, 0
7844, 0.23333333333333, 0.27, 0
7845, 0.225, 0.28, 0
7846, 0.23333333333333, 0.29, 0
7847, 0.225, 0.3, 0
7848, 0.23333333333333, 0.31, 0
7849, 0.225, 0.32, 0
7850, 0.23333333333333, 0.33, 0
7851, 0.225, 0.34, 0
7852, 0.23333333333333, 0.35, 0
7853, 0.225, 0.36, 0
7854, 0.23333333333333, 0.37, 0
7855, 0.225, 0.38, 0
7856, 0.23333333333333, 0.39, 0
7857, 0.225, 0.4, 0
7858, 0.23333333333333, 0.41, 0
7859, 0.225, 0.42, 0
7860, 0.23333333333333, 0.43, 0
7861, 0.225, 0.44, 0
7862, 0.23333333333333, 0.45, 0
7863, 0.225, 0.46, 0
7864, 0.23333333333333, 0.47, 0
7865, 0.225, 0.48, 0
7866, 0.23333333333333, 0.49, 0
7867, 0.225, 0.5, 0
7868, 0.23333333333333, 0.51, 0
7869, 0.225, 0.52, 0
7870, 0.23333333333333, 0.53, 0
7871, 0.225, 0.54, 0
7872, 0.23333333333333, 0.55, 0
7873, 0.225, 0.56, 0
7874, 0.23333333333333, 0.57, 0
7875, 0.225, 0.58, 0
7876, 0.23333333333333, 0.59, 0
7877, 0.225, 0.6, 0
7878, 0.23333333333333, 0.61, 0
7879, 0.225, 0.62, 0
7880, 0.23333333333333, 0.63, 0
7881, 0.225, 0.64, 0
7882, 0.23333333333333, 0.65, 0
7883, 0.225, 0.66, 0
7884, 0.23333333333333, 0.67, 0
7885, 0.225, 0.68, 0
7886, 0.23333333333333, 0.69, 0
7887, 0.225, 0.7, 0
7888, 0.23333333333333, 0.71, 0
7889, 0.225, 0.72, 0
7890, 0.23333333333333, 0.73, 0
7891, 0.225, 0.74, 0
7892, 0.23333333333333, 0.75, 0
7893, 0.225, 0.76, 0
7894, 0.23333333333333, 0.77, 0
7895, 0.225, 0.78, 0
7896, 0.23333333333333, 0.79, 0
7897, 0.225, 0.8, 0
7898, 0.23333333333333, 0.81, 0
7899, 0.225, 0.82, 0
7900, 0.23333333333333, 0.83, 0
7901, 0.225, 0.84, 0
7902, 0.23333333333333, 0.85, 0
7903, 0.225, 0.86, 0
7904, 0.23333333333333, 0.87, 0
7905, 0.225, 0.88, 0
7906, 0.23333333333333, 0.89, 0
7907, 0.225, 0.9, 0
7908, 0.23333333333333, 0.91, 0
7909, 0.225, 0.92, 0
7910, 0.23333333333333, 0.93, 0
7911, 0.225, 0.94, 0
7912, 0.23333333333333, 0.95, 0
7913, 0.225, 0.96, 0
7914, 0.23333333333333, 0.97, 0
7915, 0.225, 0.98, 0
7916, 0.23333333333333, 0.99, 0
7917, 0.225, 1, 0
7918, 0.23333333333333, 1.01, 0
7919, 0.225, 1.02, 0
7920, 0.23333333333333, 1.03, 0
7921, 0.225, 1.04, 0
7922, 0.23333333333333, 1.05, 0
7923, 0.225, 1.06, 0
7924, 0.23333333333333, 1.07, 0
7925, 0.225, 1.08, 0
7926, 0.23333333333333, 1.09, 0
7927, 0.225, 1.1, 0
7928, 0.23333333333333, 1.11, 0
7929, 0.225, 1.12, 0
7930, 0.23333333333333, 1.13, 0
7931, 0.225, 1.14, 0
7932, 0.23333333333333, 1.15, 0
7933, 0.225, 1.16, 0
7934, 0.23333333333333, 1.17, 0
7935, 0.225, 1.18, 0
7936, 0.23333333333333, 1.19, 0
7937, 0.25, 0.01, 0
7938, 0.24166666666667, 0.02, 0
7939, 0.25, 0.03, 0
7940, 0.24166666666667, 0.04, 0
7941, 0.25, 0.05, 0
7942, 0.24166666666667, 0.06, 0
7943, 0.25, 0.07, 0
7944, 0.24166666666667, 0.08, 0
7945, 0.25, 0.09, 0
7946, 0.24166666666667, 0.1, 0
7947, 0.25, 0.11, 0
7948, 0.24166666666667, 0.12, 0
7949, 0.25, 0.13, 0
7950, 0.24166666666667, 0.14, 0
7951, 0.25, 0.15, 0
7952, 0.24166666666667, 0.16, 0
7953, 0.25, 0.17, 0
7954, 0.24166666666667, 0.18, 0
7955, 0.25, 0.19, 0
7956, 0.24166666666667, 0.2, 0
7957, 0.25, 0.21, 0
7958, 0.24166666666667, 0.22, 0
7959, 0.25, 0.23, 0
7960, 0.24166666666667, 0.24, 0
7961, 0.25, 0.25, 0
7962, 0.24166666666667, 0.26, 0
7963, 0.25, 0.27, 0
7964, 0.24166666666667, 0.28, 0
7965, 0.25, 0.29, 0
7966, 0.24166666666667, 0.3, 0
7967, 0.25, 0.31, 0
7968, 0.24166666666667, 0.32, 0
7969, 0.25, 0.33, 0
7970, 0.24166666666667, 0.34, 0
7971, 0.25, 0.35, 0
7972, 0.24166666666667, 0.36, 0
7973, 0.25, 0.37, 0
7974, 0.24166666666667, 0.38, 0
7975, 0.25, 0.39, 0
7976, 0.24166666666667, 0.4, 0
7977, 0.25, 0.41, 0
7978, 0.24166666666667, 0.42, 0
7979, 0.25, 0.43, 0
7980, 0.24166666666667, 0.44, 0
7981, 0.25, 0.45, 0
7982, 0.24166666666667, 0.46, 0
7983, 0.25, 0.47, 0
7984, 0.24166666666667, 0.48, 0
7985, 0.25, 0.49, 0
7986, 0.24166666666667, 0.5, 0
7987, 0.25, 0.51, 0
7988, 0.24166666666667, 0.52, 0
7989, 0.25, 0.53, 0
7990, 0.24166666666667, 0.54, 0
7991, 0.25, 0.55, 0
7992, 0.24166666666667, 0.56, 0
7993, 0.25, 0.57, 0
7994, 0.24166666666667, 0.58, 0
7995, 0.25, 0.59, 0
7996, 0.24166666666667, 0.6, 0
7997, 0.25, 0.61, 0
7998, 0.24166666666667, 0.62, 0
7999, 0.25, 0.63, 0
8000, 0.24166666666667, 0.64, 0
8001, 0.25, 0.65, 0
8002, 0.24166666666667, 0.66, 0
8003, 0.25, 0.67, 0
8004, 0.24166666666667, 0.68, 0
8005, 0.25, 0.69, 0
8006, 0.24166666666667, 0.7, 0
8007, 0.25, 0.71, 0
8008, 0.24166666666667, 0.72, 0
8009, 0.25, 0.73, 0
8010, 0.24166666666667, 0.74, 0
8011, 0.25, 0.75, 0
8012, 0.24166666666667, 0.76, 0
8013, 0.25, 0.77, 0
8014, 0.24166666666667, 0.78, 0
8015, 0.25, 0.79, 0
8016, 0.24166666666667, 0.8, 0
8017, 0.25, 0.81, 0
8018, 0.24166666666667, 0.82, 0
8019, 0.25, 0.83, 0
8020, 0.24166666666667, 0.84, 0
8021, 0.25, 0.85, 0
8022, 0.24166666666667, 0.86, 0
8023, 0.25, 0.87, 0
8024, 0.24166666666667, 0.88, 0
8025, 0.25, 0.89, 0
8026, 0.24166666666667, 0.9, 0
8027, 0.25, 0.91, 0
8028, 0.24166666666667, 0.92, 0
8029, 0.25, 0.93, 0
8030, 0.24166666666667, 0.94, 0
8031, 0.25, 0.95, 0
8032, 0.24166666666667, 0.96, 0
8033, 0.25, 0.97, 0
8034, 0.24166666666667, 0.98, 0
8035, 0.25, 0.99, 0
8036, 0.24166666666667, 1, 0
8037, 0.25, 1.01, 0
8038, 0.24166666666667, 1.02, 0
8039, 0.25, 1.03, 0
8040, 0.24166666666667, 1.04, 0
8041, 0.25, 1.05, 0
8042, 0.24166666666667, 1.06, 0
8043, 0.25, 1.07, 0
8044, 0.24166666666667, 1.08, 0
8045, 0.25, 1.09, 0
8046, 0.24166666666667, 1.1, 0
8047, 0.25, 1.11, 0
8048, 0.24166666666667, 1.12, 0
8049, 0.25, 1.13, 0
8050, 0.24166666666667, 1.14, 0
8051, 0.25, 1.15, 0
8052, 0.24166666666667, 1.16, 0
8053, 0.25, 1.17, 0
8054, 0.24166666666667, 1.18, 0
8055, 0.25, 1.19, 0
8056, 0.26666666666667, 0.01, 0
8057, 0.25833333333333, 0.02, 0
8058, 0.26666666666667, 0.03, 0
8059, 0.25833333333333, 0.04, 0
8060, 0.26666666666667, 0.05, 0
8061, 0.25833333333333, 0.06, 0
8062, 0.26666666666667, 0.07, 0
8063, 0.25833333333333, 0.08, 0
8064, 0.26666666666667, 0.09, 0
8065, 0.25833333333333, 0.1, 0
8066, 0.26666666666667, 0.11, 0
8067, 0.25833333333333, 0.12, 0
8068, 0.26666666666667, 0.13, 0
8069, 0.25833333333333, 0.14, 0
8070, 0.26666666666667, 0.15, 0
8071, 0.25833333333333, 0.16, 0
8072, 0.26666666666667, 0.17, 0
8073, 0.25833333333333, 0.18, 0
8074, 0.26666666666667, 0.19, 0
8075, 0.25833333333333, 0.2, 0
8076, 0.26666666666667, 0.21, 0
8077, 0.25833333333333, 0.22, 0
8078, 0.26666666666667, 0.23, 0
8079, 0.25833333333333, 0.24, 0
8080, 0.26666666666667, 0.25, 0
8081, 0.25833333333333, 0.26, 0
8082, 0.26666666666667, 0.27, 0
8083, 0.25833333333333, 0.28, 0
8084, 0.26666666666667, 0.29, 0
8085, 0.25833333333333, 0.3, 0
8086, 0.26666666666667, 0.31, 0
8087, 0.25833333333333, 0.32, 0
8088, 0.26666666666667, 0.33, 0
8089, 0.25833333333333, 0.34, 0
8090, 0.26666666666667, 0.35, 0
8091, 0.25833333333333, 0.36, 0
8092, 0.26666666666667, 0.37, 0
8093, 0.25833333333333, 0.38, 0
8094, 0.26666666666667, 0.39, 0
8095, 0.25833333333333, 0.4, 0
8096, 0.26666666666667, 0.41, 0
8097, 0.25833333333333, 0.42, 0
8098, 0.26666666666667, 0.43, 0
8099, 0.25833333333333, 0.44, 0
8100, 0.26666666666667, 0.45, 0
8101, 0.25833333333333, 0.46, 0
8102, 0.26666666666667, 0.47, 0
8103, 0.25833333333333, 0.48, 0
8104, 0.26666666666667, 0.49, 0
8105, 0.25833333333333, 0.5, 0
8106, 0.26666666666667, 0.51, 0
8107, 0.25833333333333, 0.52, 0
8108, 0.26666666666667, 0.53, 0
8109, 0.25833333333333, 0.54, 0
8110, 0.26666666666667, 0.55, 0
8111, 0.25833333333333, 0.56, 0
8112, 0.26666666666667, 0.57, 0
8113, 0.25833333333333, 0.58, 0
8114, 0.26666666666667, 0.59, 0
8115, 0.25833333333333, 0.6, 0
8116, 0.26666666666667, 0.61, 0
8117, 0.25833333333333, 0.62, 0
8118, 0.26666666666667, 0.63, 0
8119, 0.25833333333333, 0.64, 0
8120, 0.26666666666667, 0.65, 0
8121, 0.25833333333333, 0.66, 0
8122, 0.26666666666667, 0.67, 0
8123, 0.25833333333333, 0.68, 0
8124, 0.26666666666667, 0.69, 0
8125, 0.25833333333333, 0.7, 0
8126, 0.26666666666667, 0.71, 0
8127, 0.25833333333333, 0.72, 0
8128, 0.26666666666667, 0.73, 0
8129, 0.25833333333333, 0.74, 0
8130, 0.26666666666667, 0.75, 0
8131, 0.25833333333333, 0.76, 0
8132, 0.26666666666667, 0.77, 0
8133, 0.25833333333333, 0.78, 0
8134, 0.26666666666667, 0.79, 0
8135, 0.25833333333333, 0.8, 0
8136, 0.26666666666667, 0.81, 0
8137, 0.25833333333333, 0.82, 0
8138, 0.26666666666667, 0.83, 0
8139, 0.25833333333333, 0.84, 0
8140, 0.26666666666667, 0.85, 0
8141, 0.25833333333333, 0.86, 0
8142, 0.26666666666667, 0.87, 0
8143, 0.25833333333333, 0.88, 0
8144, 0.26666666666667, 0.89, 0
8145, 0.25833333333333, 0.9, 0
8146, 0.26666666666667, 0.91, 0
8147, 0.25833333333333, 0.92, 0
8148, 0.26666666666667, 0.93, 0
8149, 0.25833333333333, 0.94, 0
8150, 0.26666666666667, 0.95, 0
8151, 0.25833333333333, 0.96, 0
8152, 0.26666666666667, 0.97, 0
8153, 0.25833333333333, 0.98, 0
8154, 0.26666666666667, 0.99, 0
8155, 0.25833333333333, 1, 0
8156, 0.26666666666667, 1.01, 0
8157, 0.25833333333333, 1.02, 0
8158, 0.26666666666667, 1.03, 0
8159, 0.25833333333333, 1.04, 0
8160, 0.26666666666667, 1.05, 0
8161, 0.25833333333333, 1.06, 0
8162, 0.26666666666667, 1.07, 0
8163, 0.25833333333333, 1.08, 0
8164, 0.26666666666667, 1.09, 0
8165, 0.25833333333333, 1.1, 0
8166, 0.26666666666667, 1.11, 0
8167, 0.25833333333333, 1.12, 0
8168, 0.26666666666667, 1.13, 0
8169, 0.25833333333333, 1.14, 0
8170, 0.26666666666667, 1.15, 0
8171, 0.25833333333333, 1.16, 0
8172, 0.26666666666667, 1.17, 0
8173, 0.25833333333333, 1.18, 0
8174, 0.26666666666667, 1.19, 0
8175, 0.28333333333333, 0.01, 0
8176, 0.275, 0.02, 0
8177, 0.28333333333333, 0.03, 0
8178, 0.275, 0.04, 0
8179, 0.28333333333333, 0.05, 0
8180, 0.275, 0.06, 0
8181, 0.28333333333333, 0.07, 0
8182, 0.275, 0.08, 0
8183, 0.28333333333333, 0.09, 0
8184, 0.275, 0.1, 0
8185, 0.28333333333333, 0.11, 0
8186, 0.275, 0.12, 0
8187, 0.28333333333333, 0.13, 0
8188, 0.275, 0.14, 0
8189, 0.28333333333333, 0.15, 0
8190, 0.275, 0.16, 0
8191, 0.28333333333333, 0.17, 0
8192, 0.275, 0.18, 0
8193, 0.28333333333333, 0.19, 0
8194, 0.275, 0.2, 0
8195, 0.28333333333333, 0.21, 0
8196, 0.275, 0.22, 0
8197, 0.28333333333333, 0.23, 0
8198, 0.275, 0.24, 0
8199, 0.28333333333333, 0.25, 0
8200, 0.275, 0.26, 0
8201, 0.28333333333333, 0.27, 0
8202, 0.275, 0.28, 0
8203, 0.28333333333333, 0.29, 0
8204, 0.275, 0.3, 0
8205, 0.28333333333333, 0.31, 0
8206, 0.275, 0.32, 0
8207, 0.28333333333333, 0.33, 0
8208, 0.275, 0.34, 0
8209, 0.28333333333333, 0.35, 0
8210, 0.275, 0.36, 0
8211, 0.28333333333333, 0.37, 0
8212, 0.275, 0.38, 0
8213, 0.28333333333333, 0.39, 0
8214, 0.275, 0.4, 0
8215, 0.28333333333333, 0.41, 0
8216, 0.275, 0.42, 0
8217, 0.28333333333333, 0.43, 0
8218, 0.275, 0.44, 0
8219, 0.28333333333333, 0.45, 0
8220, 0.275, 0.46, 0
8221, 0.28333333333333, 0.47, 0
8222, 0.275, 0.48, 0
8223, 0.28333333333333, 0.49, 0
8224, 0.275, 0.5, 0
8225, 0.28333333333333, 0.51, 0
8226, 0.275, 0.52, 0
8227, 0.28333333333333, 0.53, 0
8228, 0.275, 0.54, 0
8229, 0.28333333333333, 0.55, 0
8230, 0.275, 0.56, 0
8231, 0.28333333333333, 0.57, 0
8232, 0.275, 0.58, 0
8233, 0.28333333333333, 0.59, 0
8234, 0.275, 0.6, 0
8235, 0.28333333333333, 0.61, 0
8236, 0.275, 0.62, 0
8237, 0.28333333333333, 0.63, 0
8238, 0.275, 0.64, 0
8239, 0.28333333333333, 0.65, 0
8240, 0.275, 0.66, 0
8241, 0.28333333333333, 0.67, 0
8242, 0.275, 0.68, 0
8243, 0.28333333333333, 0.69, 0
8244, 0.275, 0.7, 0
8245, 0.28333333333333, 0.71, 0
8246, 0.275, 0.72, 0
8247, 0.28333333333333, 0.73, 0
8248, 0.275, 0.74, 0
8249, 0.28333333333333, 0.75, 0
8250, 0.275, 0.76, 0
8251, 0.28333333333333, 0.77, 0
8252, 0.275, 0.78, 0
8253, 0.28333333333333, 0.79, 0
8254, 0.275, 0.8, 0
8255, 0.28333333333333, 0.81, 0
8256, 0.275, 0.82, 0
8257, 0.28333333333333, 0.83, 0
8258, 0.275, 0.84, 0
8259, 0.28333333333333, 0.85, 0
8260, 0.275, 0.86, 0
8261, 0.28333333333333, 0.87, 0
8262, 0.275, 0.88, 0
8263, 0.28333333333333, 0.89, 0
8264, 0.275, 0.9, 0
8265, 0.28333333333333, 0.91, 0
8266, 0.275, 0.92, 0
8267, 0.28333333333333, 0.93, 0
8268, 0.275, 0.94, 0
8269, 0.28333333333333, 0.95, 0
8270, 0.275, 0.96, 0
8271, 0.28333333333333, 0.97, 0
8272, 0.275, 0.98, 0
8273, 0.28333333333333, 0.99, 0
8274, 0.275, 1, 0
8275, 0.28333333333333, 1.01, 0
8276, 0.275, 1.02, 0
8277, 0.28333333333333, 1.03, 0
8278, 0.275, 1.04, 0
8279, 0.28333333333333, 1.05, 0
8280, 0.275, 1.06, 0
8281, 0.28333333333333, 1.07, 0
8282, 0.275, 1.08, 0
8283, 0.28333333333333, 1.09, 0
8284, 0.275, 1.1, 0
8285, 0.28333333333333, 1.11, 0
8286, 0.275, 1.12, 0
8287, 0.28333333333333, 1.13, 0
8288, 0.275, 1.14, 0
8289, 0.28333333333333, 1.15, 0
8290, 0.275, 1.16, 0
8291, 0.28333333333333, 1.17, 0
8292, 0.275, 1.18, 0
8293, 0.28333333333333, 1.19, 0
8294, 0.3, 0.01, 0
8295, 0.29166666666667, 0.02, 0
8296, 0.3, 0.03, 0
8297, 0.29166666666667, 0.04, 0
8298, 0.3, 0.05, 0
8299, 0.29166666666667, 0.06, 0
8300, 0.3, 0.07, 0
8301, 0.29166666666667, 0.08, 0
8302, 0.3, 0.09, 0
8303, 0.29166666666667, 0.1, 0
8304, 0.3, 0.11, 0
8305, 0.29166666666667, 0.12, 0
8306, 0.3, 0.13, 0
8307, 0.29166666666667, 0.14, 0
8308, 0.3, 0.15, 0
8309, 0.29166666666667, 0.16, 0
8310, 0.3, 0.17, 0
8311, 0.29166666666667, 0.18, 0
8312, 0.3, 0.19, 0
8313, 0.29166666666667, 0.2, 0
8314, 0.3, 0.21, 0
8315, 0.29166666666667, 0.22, 0
8316, 0.3, 0.23, 0
8317, 0.29166666666667, 0.24, 0
8318, 0.3, 0.25, 0
8319, 0.29166666666667, 0.26, 0
8320, 0.3, 0.27, 0
8321, 0.29166666666667, 0.28, 0
8322, 0.3, 0.29, 0
8323, 0.29166666666667, 0.3, 0
8324, 0.3, 0.31, 0
8325, 0.29166666666667, 0.32, 0
8326, 0.3, 0.33, 0
8327, 0.29166666666667, 0.34, 0
8328, 0.3, 0.35, 0
8329, 0.29166666666667, 0.36, 0
8330, 0.3, 0.37, 0
8331, 0.29166666666667, 0.38, 0
8332, 0.3, 0.39, 0
8333, 0.29166666666667, 0.4, 0
8334, 0.3, 0.41, 0
8335, 0.29166666666667, 0.42, 0
8336, 0.3, 0.43, 0
8337, 0.29166666666667, 0.44, 0
8338, 0.3, 0.45, 0
8339, 0.29166666666667, 0.46, 0
8340, 0.3, 0.47, 0
8341, 0.29166666666667, 0.48, 0
8342, 0.3, 0.49, 0
8343, 0.29166666666667, 0.5, 0
8344, 0.3, 0.51, 0
8345, 0.29166666666667, 0.52, 0
8346, 0.3, 0.53, 0
8347, 0.29166666666667, 0.54, 0
8348, 0.3, 0.55, 0
8349, 0.29166666666667, 0.56, 0
8350, 0.3, 0.57, 0
8351, 0.29166666666667, 0.58, 0
8352, 0.3, 0.59, 0
8353, 0.29166666666667, 0.6, 0
8354, 0.3, 0.61, 0
8355, 0.29166666666667, 0.62, 0
8356, 0.3, 0.63, 0
8357, 0.29166666666667, 0.64, 0
8358, 0.3, 0.65, 0
8359, 0.29166666666667, 0.66, 0
8360, 0.3, 0.67, 0
8361, 0.29166666666667, 0.68, 0
8362, 0.3, 0.69, 0
8363, 0.29166666666667, 0.7, 0
8364, 0.3, 0.71, 0
8365, 0.29166666666667, 0.72, 0
8366, 0.3, 0.73, 0
8367, 0.29166666666667, 0.74, 0
8368, 0.3, 0.75, 0
8369, 0.29166666666667, 0.76, 0
8370, 0.3, 0.77, 0
8371, 0.29166666666667, 0.78, 0
8372, 0.3, 0.79, 0
8373, 0.29166666666667, 0.8, 0
8374, 0.3, 0.81, 0
8375, 0.29166666666667, 0.82, 0
8376, 0.3, 0.83, 0
8377, 0.29166666666667, 0.84, 0
8378, 0.3, 0.85, 0
8379, 0.29166666666667, 0.86, 0
8380, 0.3, 0.87, 0
8381, 0.29166666666667, 0.88, 0
8382, 0.3, 0.89, 0
8383, 0.29166666666667, 0.9, 0
8384, 0.3, 0.91, 0
8385, 0.29166666666667, 0.92, 0
8386, 0.3, 0.93, 0
8387, 0.29166666666667, 0.94, 0
8388, 0.3, 0.95, 0
8389, 0.29166666666667, 0.96, 0
8390, 0.3, 0.97, 0
8391, 0.29166666666667, 0.98, 0
8392, 0.3, 0.99, 0
8393, 0.29166666666667, 1, 0
8394, 0.3, 1.01, 0
8395, 0.29166666666667, 1.02, 0
8396, 0.3, 1.03, 0
8397, 0.29166666666667, 1.04, 0
8398, 0.3, 1.05, 0
8399, 0.29166666666667, 1.06, 0
8400, 0.3, 1.07, 0
8401, 0.29166666666667, 1.08, 0
8402, 0.3, 1.09, 0
8403, 0.29166666666667, 1.1, 0
8404, 0.3, 1.11, 0
8405, 0.29166666666667, 1.12, 0
8406, 0.3, 1.13, 0
8407, 0.29166666666667, 1.14, 0
8408, 0.3, 1.15, 0
8409, 0.29166666666667, 1.16, 0
8410, 0.3, 1.17, 0
8411, 0.29166666666667, 1.18, 0
8412, 0.3, 1.19, 0
8413, 0.31666666666667, 0.01, 0
8414, 0.30833333333333, 0.02, 0
8415, 0.31666666666667, 0.03, 0
8416, 0.30833333333333, 0.04, 0
8417, 0.31666666666667, 0.05, 0
8418, 0.30833333333333, 0.06, 0
8419, 0.31666666666667, 0.07, 0
8420, 0.30833333333333, 0.08, 0
8421, 0.31666666666667, 0.09, 0
8422, 0.30833333333333, 0.1, 0
8423, 0.31666666666667, 0.11, 0
8424, 0.30833333333333, 0.12, 0
8425, 0.31666666666667, 0.13, 0
8426, 0.30833333333333, 0.14, 0
8427, 0.31666666666667, 0.15, 0
8428, 0.30833333333333, 0.16, 0
8429, 0.31666666666667, 0.17, 0
8430, 0.30833333333333, 0.18, 0
8431, 0.31666666666667, 0.19, 0
8432, 0.30833333333333, 0.2, 0
8433, 0.31666666666667, 0.21, 0
8434, 0.30833333333333, 0.22, 0
8435, 0.31666666666667, 0.23, 0
8436, 0.30833333333333, 0.24, 0
8437, 0.31666666666667, 0.25, 0
8438, 0.30833333333333, 0.26, 0
8439, 0.31666666666667, 0.27, 0
8440, 0.30833333333333, 0.28, 0
8441, 0.31666666666667, 0.29, 0
8442, 0.30833333333333, 0.3, 0
8443, 0.31666666666667, 0.31, 0
8444, 0.30833333333333, 0.32, 0
8445, 0.31666666666667, 0.33, 0
8446, 0.30833333333333, 0.34, 0
8447, 0.31666666666667, 0.35, 0
8448, 0.30833333333333, 0.36, 0
8449, 0.31666666666667, 0.37, 0
8450, 0.30833333333333, 0.38, 0
8451, 0.31666666666667, 0.39, 0
8452, 0.30833333333333, 0.4, 0
8453, 0.31666666666667, 0.41, 0
8454, 0.30833333333333, 0.42, 0
8455, 0.31666666666667, 0.43, 0
8456, 0.30833333333333, 0.44, 0
8457, 0.31666666666667, 0.45, 0
8458, 0.30833333333333, 0.46, 0
8459, 0.31666666666667, 0.47, 0
8460, 0.30833333333333, 0.48, 0
8461, 0.31666666666667, 0.49, 0
8462, 0.30833333333333, 0.5, 0
8463, 0.31666666666667, 0.51, 0
8464, 0.30833333333333, 0.52, 0
8465, 0.31666666666667, 0.53, 0
8466, 0.30833333333333, 0.54, 0
8467, 0.31666666666667, 0.55, 0
8468, 0.30833333333333, 0.56, 0
8469, 0.31666666666667, 0.57, 0
8470, 0.30833333333333, 0.58, 0
8471, 0.31666666666667, 0.59, 0
8472, 0.30833333333333, 0.6, 0
8473, 0.31666666666667, 0.61, 0
8474, 0.30833333333333, 0.62, 0
8475, 0.31666666666667, 0.63, 0
8476, 0.30833333333333, 0.64, 0
8477, 0.31666666666667, 0.65, 0
8478, 0.30833333333333, 0.66, 0
8479, 0.31666666666667, 0.67, 0
8480, 0.30833333333333, 0.68, 0
8481, 0.31666666666667, 0.69, 0
8482, 0.30833333333333, 0.7, 0
8483, 0.31666666666667, 0.71, 0
8484, 0.30833333333333, 0.72, 0
8485, 0.31666666666667, 0.73, 0
8486, 0.30833333333333, 0.74, 0
8487, 0.31666666666667, 0.75, 0
8488, 0.30833333333333, 0.76, 0
8489, 0.31666666666667, 0.77, 0
8490, 0.30833333333333, 0.78, 0
8491, 0.31666666666667, 0.79, 0
8492, 0.30833333333333, 0.8, 0
8493, 0.31666666666667, 0.81, 0
8494, 0.30833333333333, 0.82, 0
8495, 0.31666666666667, 0.83, 0
8496, 0.30833333333333, 0.84, 0
8497, 0.31666666666667, 0.85, 0
8498, 0.30833333333333, 0.86, 0
8499, 0.31666666666667, 0.87, 0
8500, 0.30833333333333, 0.88, 0
8501, 0.31666666666667, 0.89, 0
8502, 0.30833333333333, 0.9, 0
8503, 0.31666666666667, 0.91, 0
8504, 0.30833333333333, 0.92, 0
8505, 0.31666666666667, 0.93, 0
8506, 0.30833333333333, 0.94, 0
8507, 0.31666666666667, 0.95, 0
8508, 0.30833333333333, 0.96, 0
8509, 0.31666666666667, 0.97, 0
8510, 0.30833333333333, 0.98, 0
8511, 0.31666666666667, 0.99, 0
8512, 0.30833333333333, 1, 0
8513, 0.31666666666667, 1.01, 0
8514, 0.30833333333333, 1.02, 0
8515, 0.31666666666667, 1.03, 0
8516, 0.30833333333333, 1.04, 0
8517, 0.31666666666667, 1.05, 0
8518, 0.30833333333333, 1.06, 0
8519, 0.31666666666667, 1.07, 0
8520, 0.30833333333333, 1.08, 0
8521, 0.31666666666667, 1.09, 0
8522, 0.30833333333333, 1.1, 0
8523, 0.31666666666667, 1.11, 0
8524, 0.30833333333333, 1.12, 0
8525, 0.31666666666667, 1.13, 0
8526, 0.30833333333333, 1.14, 0
8527, 0.31666666666667, 1.15, 0
8528, 0.30833333333333, 1.16, 0
8529, 0.31666666666667, 1.17, 0
8530, 0.30833333333333, 1.18, 0
8531, 0.31666666666667, 1.19, 0
8532, 0.33333333333333, 0.01, 0
8533, 0.325, 0.02, 0
8534, 0.33333333333333, 0.03, 0
8535, 0.325, 0.04, 0
8536, 0.33333333333333, 0.05, 0
8537, 0.325, 0.06, 0
8538, 0.33333333333333, 0.07, 0
8539, 0.325, 0.08, 0
8540, 0.33333333333333, 0.09, 0
8541, 0.325, 0.1, 0
8542, 0.33333333333333, 0.11, 0
8543, 0.325, 0.12, 0
8544, 0.33333333333333, 0.13, 0
8545, 0.325, 0.14, 0
8546, 0.33333333333333, 0.15, 0
8547, 0.325, 0.16, 0
8548, 0.33333333333333, 0.17, 0
8549, 0.325, 0.18, 0
8550, 0.33333333333333, 0.19, 0
8551, 0.325, 0.2, 0
8552, 0.33333333333333, 0.21, 0
8553, 0.325, 0.22, 0
8554, 0.33333333333333, 0.23, 0
8555, 0.325, 0.24, 0
8556, 0.33333333333333, 0.25, 0
8557, 0.325, 0.26, 0
8558, 0.33333333333333, 0.27, 0
8559, 0.325, 0.28, 0
8560, 0.33333333333333, 0.29, 0
8561, 0.325, 0.3, 0
8562, 0.33333333333333, 0.31, 0
8563, 0.325, 0.32, 0
8564, 0.33333333333333, 0.33, 0
8565, 0.325, 0.34, 0
8566, 0.33333333333333, 0.35, 0
8567, 0.325, 0.36, 0
8568, 0.33333333333333, 0.37, 0
8569, 0.325, 0.38, 0
8570, 0.33333333333333, 0.39, 0
8571, 0.325, 0.4, 0
8572, 0.33333333333333, 0.41, 0
8573, 0.325, 0.42, 0
8574, 0.33333333333333, 0.43, 0
8575, 0.325, 0.44, 0
8576, 0.33333333333333, 0.45, 0
8577, 0.325, 0.46, 0
8578, 0.33333333333333, 0.47, 0
8579, 0.325, 0.48, 0
8580, 0.33333333333333, 0.49, 0
8581, 0.325, 0.5, 0
8582, 0.33333333333333, 0.51, 0
8583, 0.325, 0.52, 0
8584, 0.33333333333333, 0.53, 0
8585, 0.325, 0.54, 0
8586, 0.33333333333333, 0.55, 0
8587, 0.325, 0.56, 0
8588, 0.33333333333333, 0.57, 0
8589, 0.325, 0.58, 0
8590, 0.33333333333333, 0.59, 0
8591, 0.325, 0.6, 0
8592, 0.33333333333333, 0.61, 0
8593, 0.325, 0.62, 0
8594, 0.33333333333333, 0.63, 0
8595, 0.325, 0.64, 0
8596, 0.33333333333333, 0.65, 0
8597, 0.325, 0.66, 0
8598, 0.33333333333333, 0.67, 0
8599, 0.325, 0.68, 0
8600, 0.33333333333333, 0.69, 0
8601, 0.325, 0.7, 0
8602, 0.33333333333333, 0.71, 0
8603, 0.325, 0.72, 0
8604, 0.33333333333333, 0.73, 0
8605, 0.325, 0.74, 0
8606, 0.33333333333333, 0.75, 0
8607, 0.325, 0.76, 0
8608, 0.33333333333333, 0.77, 0
8609, 0.325, 0.78, 0
8610, 0.33333333333333, 0.79, 0
8611, 0.325, 0.8, 0
8612, 0.33333333333333, 0.81, 0
8613, 0.325, 0.82, 0
8614, 0.33333333333333, 0.83, 0
8615, 0.325, 0.84, 0
8616, 0.33333333333333, 0.85, 0
8617, 0.325, 0.86, 0
8618, 0.33333333333333, 0.87, 0
8619, 0.325, 0.88, 0
8620, 0.33333333333333, 0.89, 0
8621, 0.325, 0.9, 0
8622, 0.33333333333333, 0.91, 0
8623, 0.325, 0.92, 0
8624, 0.33333333333333, 0.93, 0
8625, 0.325, 0.94, 0
8626, 0.33333333333333, 0.95, 0
8627, 0.325, 0.96, 0
8628, 0.33333333333333, 0.97, 0
8629, 0.325, 0.98, 0
8630, 0.33333333333333, 0.99, 0
8631, 0.325, 1, 0
8632, 0.33333333333333, 1.01, 0
8633, 0.325, 1.02, 0
8634, 0.33333333333333, 1.03, 0
8635, 0.325, 1.04, 0
8636, 0.33333333333333, 1.05, 0
8637, 0.325, 1.06, 0
8638, 0.33333333333333, 1.07, 0
8639, 0.325, 1.08, 0
8640, 0.33333333333333, 1.09, 0
8641, 0.325, 1.1, 0
8642, 0.33333333333333, 1.11, 0
8643, 0.325, 1.12, 0
8644, 0.33333333333333, 1.13, 0
8645, 0.325, 1.14, 0
8646, 0.33333333333333, 1.15, 0
8647, 0.325, 1.16, 0
8648, 0.33333333333333, 1.17, 0
8649, 0.325, 1.18, 0
8650, 0.33333333333333, 1.19, 0
8651, 0.35, 0.01, 0
8652, 0.34166666666667, 0.02, 0
8653, 0.35, 0.03, 0
8654, 0.34166666666667, 0.04, 0
8655, 0.35, 0.05, 0
8656, 0.34166666666667, 0.06, 0
8657, 0.35, 0.07, 0
8658, 0.34166666666667, 0.08, 0
8659, 0.35, 0.09, 0
8660, 0.34166666666667, 0.1, 0
8661, 0.35, 0.11, 0
8662, 0.34166666666667, 0.12, 0
8663, 0.35, 0.13, 0
8664, 0.34166666666667, 0.14, 0
8665, 0.35, 0.15, 0
8666, 0.34166666666667, 0.16, 0
8667, 0.35, 0.17, 0
8668, 0.34166666666667, 0.18, 0
8669, 0.35, 0.19, 0
8670, 0.34166666666667, 0.2, 0
8671, 0.35, 0.21, 0
8672, 0.34166666666667, 0.22, 0
8673, 0.35, 0.23, 0
8674, 0.34166666666667, 0.24, 0
8675, 0.35, 0.25, 0
8676, 0.34166666666667, 0.26, 0
8677, 0.35, 0.27, 0
8678, 0.34166666666667, 0.28, 0
8679, 0.35, 0.29, 0
8680, 0.34166666666667, 0.3, 0
8681, 0.35, 0.31, 0
8682, 0.34166666666667, 0.32, 0
8683, 0.35, 0.33, 0
8684, 0.34166666666667, 0.34, 0
8685, 0.35, 0.35, 0
8686, 0.34166666666667, 0.36, 0
8687, 0.35, 0.37, 0
8688, 0.34166666666667, 0.38, 0
8689, 0.35, 0.39, 0
8690, 0.34166666666667, 0.4, 0
8691, 0.35, 0.41, 0
8692, 0.34166666666667, 0.42, 0
8693, 0.35, 0.43, 0
8694, 0.34166666666667, 0.44, 0
8695, 0.35, 0.45, 0
8696, 0.34166666666667, 0.46, 0
8697, 0.35, 0.47, 0
8698, 0.34166666666667, 0.48, 0
8699, 0.35, 0.49, 0
8700, 0.34166666666667, 0.5, 0
8701, 0.35, 0.51, 0
8702, 0.34166666666667, 0.52, 0
8703, 0.35, 0.53, 0
8704, 0.34166666666667, 0.54, 0
8705, 0.35, 0.55, 0
8706, 0.34166666666667, 0.56, 0
8707, 0.35, 0.57, 0
8708, 0.34166666666667, 0.58, 0
8709, 0.35, 0.59, 0
8710, 0.34166666666667, 0.6, 0
8711, 0.35, 0.61, 0
8712, 0.34166666666667, 0.62, 0
8713, 0.35, 0.63, 0
8714, 0.34166666666667, 0.64, 0
8715, 0.35, 0.65, 0
8716, 0.34166666666667, 0.66, 0
8717, 0.35, 0.67, 0
8718, 0.34166666666667, 0.68, 0
8719, 0.35, 0.69, 0
8720, 0.34166666666667, 0.7, 0
8721, 0.35, 0.71, 0
8722, 0.34166666666667, 0.72, 0
8723, 0.35, 0.73, 0
8724, 0.34166666666667, 0.74, 0
8725, 0.35, 0.75, 0
8726, 0.34166666666667, 0.76, 0
8727, 0.35, 0.77, 0
8728, 0.34166666666667, 0.78, 0
8729, 0.35, 0.79, 0
8730, 0.34166666666667, 0.8, 0
8731, 0.35, 0.81, 0
8732, 0.34166666666667, 0.82, 0
8733, 0.35, 0.83, 0
8734, 0.34166666666667, 0.84, 0
8735, 0.35, 0.85, 0
8736, 0.34166666666667, 0.86, 0
8737, 0.35, 0.87, 0
8738, 0.34166666666667, 0.88, 0
8739, 0.35, 0.89, 0
8740, 0.34166666666667, 0.9, 0
8741, 0.35, 0.91, 0
8742, 0.34166666666667, 0.92, 0
8743, 0.35, 0.93, 0
8744, 0.34166666666667, 0.94, 0
8745, 0.35, 0.95, 0
8746, 0.34166666666667, 0.96, 0
8747, 0.35, 0.97, 0
8748, 0.34166666666667, 0.98, 0
8749, 0.35, 0.99, 0
8750, 0.34166666666667, 1, 0
8751, 0.35, 1.01, 0
8752, 0.34166666666667, 1.02, 0
8753, 0.35, 1.03, 0
8754, 0.34166666666667, 1.04, 0
8755, 0.35, 1.05, 0
8756, 0.34166666666667, 1.06, 0
8757, 0.35, 1.07, 0
8758, 0.34166666666667, 1.08, 0
8759, 0.35, 1.09, 0
8760, 0.34166666666667, 1.1, 0
8761, 0.35, 1.11, 0
8762, 0.34166666666667, 1.12, 0
8763, 0.35, 1.13, 0
8764, 0.34166666666667, 1.14, 0
8765, 0.35, 1.15, 0
8766, 0.34166666666667, 1.16, 0
8767, 0.35, 1.17, 0
8768, 0.34166666666667, 1.18, 0
8769, 0.35, 1.19, 0
8770, 0.36666666666667, 0.01, 0
8771, 0.35833333333333, 0.02, 0
8772, 0.36666666666667, 0.03, 0
8773, 0.35833333333333, 0.04, 0
8774, 0.36666666666667, 0.05, 0
8775, 0.35833333333333, 0.06, 0
8776, 0.36666666666667, 0.07, 0
8777, 0.35833333333333, 0.08, 0
8778, 0.36666666666667, 0.09, 0
8779, 0.35833333333333, 0.1, 0
8780, 0.36666666666667, 0.11, 0
8781, 0.35833333333333, 0.12, 0
8782, 0.36666666666667, 0.13, 0
8783, 0.35833333333333, 0.14, 0
8784, 0.36666666666667, 0.15, 0
8785, 0.35833333333333, 0.16, 0
8786, 0.36666666666667, 0.17, 0
8787, 0.35833333333333, 0.18, 0
8788, 0.36666666666667, 0.19, 0
8789, 0.35833333333333, 0.2, 0
8790, 0.36666666666667, 0.21, 0
8791, 0.35833333333333, 0.22, 0
8792, 0.36666666666667, 0.23, 0
8793, 0.35833333333333, 0.24, 0
8794, 0.36666666666667, 0.25, 0
8795, 0.35833333333333, 0.26, 0
8796, 0.36666666666667, 0.27, 0
8797, 0.35833333333333, 0.28, 0
8798, 0.36666666666667, 0.29, 0
8799, 0.35833333333333, 0.3, 0
8800, 0.36666666666667, 0.31, 0
8801, 0.35833333333333, 0.32, 0
8802, 0.36666666666667, 0.33, 0
8803, 0.35833333333333, 0.34, 0
8804, 0.36666666666667, 0.35, 0
8805, 0.35833333333333, 0.36, 0
8806, 0.36666666666667, 0.37, 0
8807, 0.35833333333333, 0.38, 0
8808, 0.36666666666667, 0.39, 0
8809, 0.35833333333333, 0.4, 0
8810, 0.36666666666667, 0.41, 0
8811, 0.35833333333333, 0.42, 0
8812, 0.36666666666667, 0.43, 0
8813, 0.35833333333333, 0.44, 0
8814, 0.36666666666667, 0.45, 0
8815, 0.35833333333333, 0.46, 0
8816, 0.36666666666667, 0.47, 0
8817, 0.35833333333333, 0.48, 0
8818, 0.36666666666667, 0.49, 0
8819, 0.35833333333333, 0.5, 0
8820, 0.36666666666667, 0.51, 0
8821, 0.35833333333333, 0.52, 0
8822, 0.36666666666667, 0.53, 0
8823, 0.35833333333333, 0.54, 0
8824, 0.36666666666667, 0.55, 0
8825, 0.35833333333333, 0.56, 0
8826, 0.36666666666667, 0.57, 0
8827, 0.35833333333333, 0.58, 0
8828, 0.36666666666667, 0.59, 0
8829, 0.35833333333333, 0.6, 0
8830, 0.36666666666667, 0.61, 0
8831, 0.35833333333333, 0.62, 0
8832, 0.36666666666667, 0.63, 0
8833, 0.35833333333333, 0.64, 0
8834, 0.36666666666667, 0.65, 0
8835, 0.35833333333333, 0.66, 0
8836, 0.36666666666667, 0.67, 0
8837, 0.35833333333333, 0.68, 0
8838, 0.36666666666667, 0.69, 0
8839, 0.35833333333333, 0.7, 0
8840, 0.36666666666667, 0.71, 0
8841, 0.35833333333333, 0.72, 0
8842, 0.36666666666667, 0.73, 0
8843, 0.35833333333333, 0.74, 0
8844, 0.36666666666667, 0.75, 0
8845, 0.35833333333333, 0.76, 0
8846, 0.36666666666667, 0.77, 0
8847, 0.35833333333333, 0.78, 0
8848, 0.36666666666667, 0.79, 0
8849, 0.35833333333333, 0.8, 0
8850, 0.36666666666667, 0.81, 0
8851, 0.35833333333333, 0.82, 0
8852, 0.36666666666667, 0.83, 0
8853, 0.35833333333333, 0.84, 0
8854, 0.36666666666667, 0.85, 0
8855, 0.35833333333333, 0.86, 0
8856, 0.36666666666667, 0.87, 0
8857, 0.35833333333333, 0.88, 0
8858, 0.36666666666667, 0.89, 0
8859, 0.35833333333333, 0.9, 0
8860, 0.36666666666667, 0.91, 0
8861, 0.35833333333333, 0.92, 0
8862, 0.36666666666667, 0.93, 0
8863, 0.35833333333333, 0.94, 0
8864, 0.36666666666667, 0.95, 0
8865, 0.35833333333333, 0.96, 0
8866, 0.36666666666667, 0.97, 0
8867, 0.35833333333333, 0.98, 0
8868, 0.36666666666667, 0.99, 0
8869, 0.35833333333333, 1, 0
8870, 0.36666666666667, 1.01, 0
8871, 0.35833333333333, 1.02, 0
8872, 0.36666666666667, 1.03, 0
8873, 0.35833333333333, 1.04, 0
8874, 0.36666666666667, 1.05, 0
8875, 0.35833333333333, 1.06, 0
8876, 0.36666666666667, 1.07, 0
8877, 0.35833333333333, 1.08, 0
8878, 0.36666666666667, 1.09, 0
8879, 0.35833333333333, 1.1, 0
8880, 0.36666666666667, 1.11, 0
8881, 0.35833333333333, 1.12, 0
8882, 0.36666666666667, 1.13, 0
8883, 0.35833333333333, 1.14, 0
8884, 0.36666666666667, 1.15, 0
8885, 0.35833333333333, 1.16, 0
8886, 0.36666666666667, 1.17, 0
8887, 0.35833333333333, 1.18, 0
8888, 0.36666666666667, 1.19, 0
8889, 0.38333333333333, 0.01, 0
8890, 0.375, 0.02, 0
8891, 0.38333333333333, 0.03, 0
8892, 0.375, 0.04, 0
8893, 0.38333333333333, 0.05, 0
8894, 0.375, 0.06, 0
8895, 0.38333333333333, 0.07, 0
8896, 0.375, 0.08, 0
8897, 0.38333333333333, 0.09, 0
8898, 0.375, 0.1, 0
8899, 0.38333333333333, 0.11, 0
8900, 0.375, 0.12, 0
8901, 0.38333333333333, 0.13, 0
8902, 0.375, 0.14, 0
8903, 0.38333333333333, 0.15, 0
8904, 0.375, 0.16, 0
8905, 0.38333333333333, 0.17, 0
8906, 0.375, 0.18, 0
8907, 0.38333333333333, 0.19, 0
8908, 0.375, 0.2, 0
8909, 0.38333333333333, 0.21, 0
8910, 0.375, 0.22, 0
8911, 0.38333333333333, 0.23, 0
8912, 0.375, 0.24, 0
8913, 0.38333333333333, 0.25, 0
8914, 0.375, 0.26, 0
8915, 0.38333333333333, 0.27, 0
8916, 0.375, 0.28, 0
8917, 0.38333333333333, 0.29, 0
8918, 0.375, 0.3, 0
8919, 0.38333333333333, 0.31, 0
8920, 0.375, 0.32, 0
8921, 0.38333333333333, 0.33, 0
8922, 0.375, 0.34, 0
8923, 0.38333333333333, 0.35, 0
8924, 0.375, 0.36, 0
8925, 0.38333333333333, 0.37, 0
8926, 0.375, 0.38, 0
8927, 0.38333333333333, 0.39, 0
8928, 0.375, 0.4, 0
8929, 0.38333333333333, 0.41, 0
8930, 0.375, 0.42, 0
8931, 0.38333333333333, 0.43, 0
8932, 0.375, 0.44, 0
8933, 0.38333333333333, 0.45, 0
8934, 0.375, 0.46, 0
8935, 0.38333333333333, 0.47, 0
8936, 0.375, 0.48, 0
8937, 0.38333333333333, 0.49, 0
8938, 0.375, 0.5, 0
8939, 0.38333333333333, 0.51, 0
8940, 0.375, 0.52, 0
8941, 0.38333333333333, 0.53, 0
8942, 0.375, 0.54, 0
8943, 0.38333333333333, 0.55, 0
8944, 0.375, 0.56, 0
8945, 0.38333333333333, 0.57, 0
8946, 0.375, 0.58, 0
8947, 0.38333333333333, 0.59, 0
8948, 0.375, 0.6, 0
8949, 0.38333333333333, 0.61, 0
8950, 0.375, 0.62, 0
8951, 0.38333333333333, 0.63, 0
8952, 0.375, 0.64, 0
8953, 0.38333333333333, 0.65, 0
8954, 0.375, 0.66, 0
8955, 0.38333333333333, 0.67, 0
8956, 0.375, 0.68, 0
8957, 0.38333333333333, 0.69, 0
8958, 0.375, 0.7, 0
8959, 0.38333333333333, 0.71, 0
8960, 0.375, 0.72, 0
8961, 0.38333333333333, 0.73, 0
8962, 0.375, 0.74, 0
8963, 0.38333333333333, 0.75, 0
8964, 0.375, 0.76, 0
8965, 0.38333333333333, 0.77, 0
8966, 0.375, 0.78, 0
8967, 0.38333333333333, 0.79, 0
8968, 0.375, 0.8, 0
8969, 0.38333333333333, 0.81, 0
8970, 0.375, 0.82, 0
8971, 0.38333333333333, 0.83, 0
8972, 0.375, 0.84, 0
8973, 0.38333333333333, 0.85, 0
8974, 0.375, 0.86, 0
8975, 0.38333333333333, 0.87, 0
8976, 0.375, 0.88, 0
8977, 0.38333333333333, 0.89, 0
8978, 0.375, 0.9, 0
8979, 0.38333333333333, 0.91, 0
8980, 0.375, 0.92, 0
8981, 0.38333333333333, 0.93, 0
8982, 0.375, 0.94, 0
8983, 0.38333333333333, 0.95, 0
8984, 0.375, 0.96, 0
8985, 0.38333333333333, 0.97, 0
8986, 0.375, 0.98, 0
8987, 0.38333333333333, 0.99, 0
8988, 0.375, 1, 0
8989, 0.38333333333333, 1.01, 0
8990, 0.375, 1.02, 0
8991, 0.38333333333333, 1.03, 0
8992, 0.375, 1.04, 0
8993, 0.38333333333333, 1.05, 0
8994, 0.375, 1.06, 0
8995, 0.38333333333333, 1.07, 0
8996, 0.375, 1.08, 0
8997, 0.38333333333333, 1.09, 0
8998, 0.375, 1.1, 0
8999, 0.38333333333333, 1.11, 0
9000, 0.375, 1.12, 0
9001, 0.38333333333333, 1.13, 0
9002, 0.375, 1.14, 0
9003, 0.38333333333333, 1.15, 0
9004, 0.375, 1.16, 0
9005, 0.38333333333333, 1.17, 0
9006, 0.375, 1.18, 0
9007, 0.38333333333333, 1.19, 0
9008, 0.4, 0.01, 0
9009, 0.39166666666667, 0.02, 0
9010, 0.4, 0.03, 0
9011, 0.39166666666667, 0.04, 0
9012, 0.4, 0.05, 0
9013, 0.39166666666667, 0.06, 0
9014, 0.4, 0.07, 0
9015, 0.39166666666667, 0.08, 0
9016, 0.4, 0.09, 0
9017, 0.39166666666667, 0.1, 0
9018, 0.4, 0.11, 0
9019, 0.39166666666667, 0.12, 0
9020, 0.4, 0.13, 0
9021, 0.39166666666667, 0.14, 0
9022, 0.4, 0.15, 0
9023, 0.39166666666667, 0.16, 0
9024, 0.4, 0.17, 0
9025, 0.39166666666667, 0.18, 0
9026, 0.4, 0.19, 0
9027, 0.39166666666667, 0.2, 0
9028, 0.4, 0.21, 0
9029, 0.39166666666667, 0.22, 0
9030, 0.4, 0.23, 0
9031, 0.39166666666667, 0.24, 0
9032, 0.4, 0.25, 0
9033, 0.39166666666667, 0.26, 0
9034, 0.4, 0.27, 0
9035, 0.39166666666667, 0.28, 0
9036, 0.4, 0.29, 0
9037, 0.39166666666667, 0.3, 0
9038, 0.4, 0.31, 0
9039, 0.39166666666667, 0.32, 0
9040, 0.4, 0.33, 0
9041, 0.39166666666667, 0.34, 0
9042, 0.4, 0.35, 0
9043, 0.39166666666667, 0.36, 0
9044, 0.4, 0.37, 0
9045, 0.39166666666667, 0.38, 0
9046, 0.4, 0.39, 0
9047, 0.39166666666667, 0.4, 0
9048, 0.4, 0.41, 0
9049, 0.39166666666667, 0.42, 0
9050, 0.4, 0.43, 0
9051, 0.39166666666667, 0.44, 0
9052, 0.4, 0.45, 0
9053, 0.39166666666667, 0.46, 0
9054, 0.4, 0.47, 0
9055, 0.39166666666667, 0.48, 0
9056, 0.4, 0.49, 0
9057, 0.39166666666667, 0.5, 0
9058, 0.4, 0.51, 0
9059, 0.39166666666667, 0.52, 0
9060, 0.4, 0.53, 0
9061, 0.39166666666667, 0.54, 0
9062, 0.4, 0.55, 0
9063, 0.39166666666667, 0.56, 0
9064, 0.4, 0.57, 0
9065, 0.39166666666667, 0.58, 0
9066, 0.4, 0.59, 0
9067, 0.39166666666667, 0.6, 0
9068, 0.4, 0.61, 0
9069, 0.39166666666667, 0.62, 0
9070, 0.4, 0.63, 0
9071, 0.39166666666667, 0.64, 0
9072, 0.4, 0.65, 0
9073, 0.39166666666667, 0.66, 0
9074, 0.4, 0.67, 0
9075, 0.39166666666667, 0.68, 0
9076, 0.4, 0.69, 0
9077, 0.39166666666667, 0.7, 0
9078, 0.4, 0.71, 0
9079, 0.39166666666667, 0.72, 0
9080, 0.4, 0.73, 0
9081, 0.39166666666667, 0.74, 0
9082, 0.4, 0.75, 0
9083, 0.39166666666667, 0.76, 0
9084, 0.4, 0.77, 0
9085, 0.39166666666667, 0.78, 0
9086, 0.4, 0.79, 0
9087, 0.39166666666667, 0.8, 0
9088, 0.4, 0.81, 0
9089, 0.39166666666667, 0.82, 0
9090, 0.4, 0.83, 0
9091, 0.39166666666667, 0.84, 0
9092, 0.4, 0.85, 0
9093, 0.39166666666667, 0.86, 0
9094, 0.4, 0.87, 0
9095, 0.39166666666667, 0.88, 0
9096, 0.4, 0.89, 0
9097, 0.39166666666667, 0.9, 0
9098, 0.4, 0.91, 0
9099, 0.39166666666667, 0.92, 0
9100, 0.4, 0.93, 0
9101, 0.39166666666667, 0.94, 0
9102, 0.4, 0.95, 0
9103, 0.39166666666667, 0.96, 0
9104, 0.4, 0.97, 0
9105, 0.39166666666667, 0.98, 0
9106, 0.4, 0.99, 0
9107, 0.39166666666667, 1, 0
9108, 0.4, 1.01, 0
9109, 0.39166666666667, 1.02, 0
9110, 0.4, 1.03, 0
9111, 0.39166666666667, 1.04, 0
9112, 0.4, 1.05, 0
9113, 0.39166666666667, 1.06, 0
9114, 0.4, 1.07, 0
9115, 0.39166666666667, 1.08, 0
9116, 0.4, 1.09, 0
9117, 0.39166666666667, 1.1, 0
9118, 0.4, 1.11, 0
9119, 0.39166666666667, 1.12, 0
9120, 0.4, 1.13, 0
9121, 0.39166666666667, 1.14, 0
9122, 0.4, 1.15, 0
9123, 0.39166666666667, 1.16, 0
9124, 0.4, 1.17, 0
9125, 0.39166666666667, 1.18, 0
9126, 0.4, 1.19, 0
9127, 0.41666666666667, 0.01, 0
9128, 0.40833333333333, 0.02, 0
9129, 0.41666666666667, 0.03, 0
9130, 0.40833333333333, 0.04, 0
9131, 0.41666666666667, 0.05, 0
9132, 0.40833333333333, 0.06, 0
9133, 0.41666666666667, 0.07, 0
9134, 0.40833333333333, 0.08, 0
9135, 0.41666666666667, 0.09, 0
9136, 0.40833333333333, 0.1, 0
9137, 0.41666666666667, 0.11, 0
9138, 0.40833333333333, 0.12, 0
9139, 0.41666666666667, 0.13, 0
9140, 0.40833333333333, 0.14, 0
9141, 0.41666666666667, 0.15, 0
9142, 0.40833333333333, 0.16, 0
9143, 0.41666666666667, 0.17, 0
9144, 0.40833333333333, 0.18, 0
9145, 0.41666666666667, 0.19, 0
9146, 0.40833333333333, 0.2, 0
9147, 0.41666666666667, 0.21, 0
9148, 0.40833333333333, 0.22, 0
9149, 0.41666666666667, 0.23, 0
9150, 0.40833333333333, 0.24, 0
9151, 0.41666666666667, 0.25, 0
9152, 0.40833333333333, 0.26, 0
9153, 0.41666666666667, 0.27, 0
9154, 0.40833333333333, 0.28, 0
9155, 0.41666666666667, 0.29, 0
9156, 0.40833333333333, 0.3, 0
9157, 0.41666666666667, 0.31, 0
9158, 0.40833333333333, 0.32, 0
9159, 0.41666666666667, 0.33, 0
9160, 0.40833333333333, 0.34, 0
9161, 0.41666666666667, 0.35, 0
9162, 0.40833333333333, 0.36, 0
9163, 0.41666666666667, 0.37, 0
9164, 0.40833333333333, 0.38, 0
9165, 0.41666666666667, 0.39, 0
9166, 0.40833333333333, 0.4, 0
9167, 0.41666666666667, 0.41, 0
9168, 0.40833333333333, 0.42, 0
9169, 0.41666666666667, 0.43, 0
9170, 0.40833333333333, 0.44, 0
9171, 0.41666666666667, 0.45, 0
9172, 0.40833333333333, 0.46, 0
9173, 0.41666666666667, 0.47, 0
9174, 0.40833333333333, 0.48, 0
9175, 0.41666666666667, 0.49, 0
9176, 0.40833333333333, 0.5, 0
9177, 0.41666666666667, 0.51, 0
9178, 0.40833333333333, 0.52, 0
9179, 0.41666666666667, 0.53, 0
9180, 0.40833333333333, 0.54, 0
9181, 0.41666666666667, 0.55, 0
9182, 0.40833333333333, 0.56, 0
9183, 0.41666666666667, 0.57, 0
9184, 0.40833333333333, 0.58, 0
9185, 0.41666666666667, 0.59, 0
9186, 0.40833333333333, 0.6, 0
9187, 0.41666666666667, 0.61, 0
9188, 0.40833333333333, 0.62, 0
9189, 0.41666666666667, 0.63, 0
9190, 0.40833333333333, 0.64, 0
9191, 0.41666666666667, 0.65, 0
9192, 0.40833333333333, 0.66, 0
9193, 0.41666666666667, 0.67, 0
9194, 0.40833333333333, 0.68, 0
9195, 0.41666666666667, 0.69, 0
9196, 0.40833333333333, 0.7, 0
9197, 0.41666666666667, 0.71, 0
9198, 0.40833333333333, 0.72, 0
9199, 0.41666666666667, 0.73, 0
9200, 0.40833333333333, 0.74, 0
9201, 0.41666666666667, 0.75, 0
9202, 0.40833333333333, 0.76, 0
9203, 0.41666666666667, 0.77, 0
9204, 0.40833333333333, 0.78, 0
9205, 0.41666666666667, 0.79, 0
9206, 0.40833333333333, 0.8, 0
9207, 0.41666666666667, 0.81, 0
9208, 0.40833333333333, 0.82, 0
9209, 0.41666666666667, 0.83, 0
9210, 0.40833333333333, 0.84, 0
9211, 0.41666666666667, 0.85, 0
9212, 0.40833333333333, 0.86, 0
9213, 0.41666666666667, 0.87, 0
9214, 0.40833333333333, 0.88, 0
9215, 0.41666666666667, 0.89, 0
9216, 0.40833333333333, 0.9, 0
9217, 0.41666666666667, 0.91, 0
9218, 0.40833333333333, 0.92, 0
9219, 0.41666666666667, 0.93, 0
9220, 0.40833333333333, 0.94, 0
9221, 0.41666666666667, 0.95, 0
9222, 0.40833333333333, 0.96, 0
9223, 0.41666666666667, 0.97, 0
9224, 0.40833333333333, 0.98, 0
9225, 0.41666666666667, 0.99, 0
9226, 0.40833333333333, 1, 0
9227, 0.41666666666667, 1.01, 0
9228, 0.40833333333333, 1.02, 0
9229, 0.41666666666667, 1.03, 0
9230, 0.40833333333333, 1.04, 0
9231, 0.41666666666667, 1.05, 0
9232, 0.40833333333333, 1.06, 0
9233, 0.41666666666667, 1.07, 0
9234, 0.40833333333333, 1.08, 0
9235, 0.41666666666667, 1.09, 0
9236, 0.40833333333333, 1.1, 0
9237, 0.41666666666667, 1.11, 0
9238, 0.40833333333333, 1.12, 0
9239, 0.41666666666667, 1.13, 0
9240, 0.40833333333333, 1.14, 0
9241, 0.41666666666667, 1.15, 0
9242, 0.40833333333333, 1.16, 0
9243, 0.41666666666667, 1.17, 0
9244, 0.40833333333333, 1.18, 0
9245, 0.41666666666667, 1.19, 0
9246, 0.43333333333333, 0.01, 0
9247, 0.425, 0.02, 0
9248, 0.43333333333333, 0.03, 0
9249, 0.425, 0.04, 0
9250, 0.43333333333333, 0.05, 0
9251, 0.425, 0.06, 0
9252, 0.43333333333333, 0.07, 0
9253, 0.425, 0.08, 0
9254, 0.43333333333333, 0.09, 0
9255, 0.425, 0.1, 0
9256, 0.43333333333333, 0.11, 0
9257, 0.425, 0.12, 0
9258, 0.43333333333333, 0.13, 0
9259, 0.425, 0.14, 0
9260, 0.43333333333333, 0.15, 0
9261, 0.425, 0.16, 0
9262, 0.43333333333333, 0.17, 0
9263, 0.425, 0.18, 0
9264, 0.43333333333333, 0.19, 0
9265, 0.425, 0.2, 0
9266, 0.43333333333333, 0.21, 0
9267, 0.425, 0.22, 0
9268, 0.43333333333333, 0.23, 0
9269, 0.425, 0.24, 0
9270, 0.43333333333333, 0.25, 0
9271, 0.425, 0.26, 0
9272, 0.43333333333333, 0.27, 0
9273, 0.425, 0.28, 0
9274, 0.43333333333333, 0.29, 0
9275, 0.425, 0.3, 0
9276, 0.43333333333333, 0.31, 0
9277, 0.425, 0.32, 0
9278, 0.43333333333333, 0.33, 0
9279, 0.425, 0.34, 0
9280, 0.43333333333333, 0.35, 0
9281, 0.425, 0.36, 0
9282, 0.43333333333333, 0.37, 0
9283, 0.425, 0.38, 0
9284, 0.43333333333333, 0.39, 0
9285, 0.425, 0.4, 0
9286, 0.43333333333333, 0.41, 0
9287, 0.425, 0.42, 0
9288, 0.43333333333333, 0.43, 0
9289, 0.425, 0.44, 0
9290, 0.43333333333333, 0.45, 0
9291, 0.425, 0.46, 0
9292, 0.43333333333333, 0.47, 0
9293, 0.425, 0.48, 0
9294, 0.43333333333333, 0.49, 0
9295, 0.425, 0.5, 0
9296, 0.43333333333333, 0.51, 0
9297, 0.425, 0.52, 0
9298, 0.43333333333333, 0.53, 0
9299, 0.425, 0.54, 0
9300, 0.43333333333333, 0.55, 0
9301, 0.425, 0.56, 0
9302, 0.43333333333333, 0.57, 0
9303, 0.425, 0.58, 0
9304, 0.43333333333333, 0.59, 0
9305, 0.425, 0.6, 0
9306, 0.43333333333333, 0.61, 0
9307, 0.425, 0.62, 0
9308, 0.43333333333333, 0.63, 0
9309, 0.425, 0.64, 0
9310, 0.43333333333333, 0.65, 0
9311, 0.425, 0.66, 0
9312, 0.43333333333333, 0.67, 0
9313, 0.425, 0.68, 0
9314, 0.43333333333333, 0.69, 0
9315, 0.425, 0.7, 0
9316, 0.43333333333333, 0.71, 0
9317, 0.425, 0.72, 0
9318, 0.43333333333333, 0.73, 0
9319, 0.425, 0.74, 0
9320, 0.43333333333333, 0.75, 0
9321, 0.425, 0.76, 0
9322, 0.43333333333333, 0.77, 0
9323, 0.425, 0.78, 0
9324, 0.43333333333333, 0.79, 0
9325, 0.425, 0.8, 0
9326, 0.43333333333333, 0.81, 0
9327, 0.425, 0.82, 0
9328, 0.43333333333333, 0.83, 0
9329, 0.425, 0.84, 0
9330, 0.43333333333333, 0.85, 0
9331, 0.425, 0.86, 0
9332, 0.43333333333333, 0.87, 0
9333, 0.425, 0.88, 0
9334, 0.43333333333333, 0.89, 0
9335, 0.425, 0.9, 0
9336, 0.43333333333333, 0.91, 0
9337, 0.425, 0.92, 0
9338, 0.43333333333333, 0.93, 0
9339, 0.425, 0.94, 0
9340, 0.43333333333333, 0.95, 0
9341, 0.425, 0.96, 0
9342, 0.43333333333333, 0.97, 0
9343, 0.425, 0.98, 0
9344, 0.43333333333333, 0.99, 0
9345, 0.425, 1, 0
9346, 0.43333333333333, 1.01, 0
9347, 0.425, 1.02, 0
9348, 0.43333333333333, 1.03, 0
9349, 0.425, 1.04, 0
9350, 0.43333333333333, 1.05, 0
9351, 0.425, 1.06, 0
9352, 0.43333333333333, 1.07, 0
9353, 0.425, 1.08, 0
9354, 0.43333333333333, 1.09, 0
9355, 0.425, 1.1, 0
9356, 0.43333333333333, 1.11, 0
9357, 0.425, 1.12, 0
9358, 0.43333333333333, 1.13, 0
9359, 0.425, 1.14, 0
9360, 0.43333333333333, 1.15, 0
9361, 0.425, 1.16, 0
9362, 0.43333333333333, 1.17, 0
9363, 0.425, 1.18, 0
9364, 0.43333333333333, 1.19, 0
9365, 0.45, 0.01, 0
9366, 0.44166666666667, 0.02, 0
9367, 0.45, 0.03, 0
9368, 0.44166666666667, 0.04, 0
9369, 0.45, 0.05, 0
9370, 0.44166666666667, 0.06, 0
9371, 0.45, 0.07, 0
9372, 0.44166666666667, 0.08, 0
9373, 0.45, 0.09, 0
9374, 0.44166666666667, 0.1, 0
9375, 0.45, 0.11, 0
9376, 0.44166666666667, 0.12, 0
9377, 0.45, 0.13, 0
9378, 0.44166666666667, 0.14, 0
9379, 0.45, 0.15, 0
9380, 0.44166666666667, 0.16, 0
9381, 0.45, 0.17, 0
9382, 0.44166666666667, 0.18, 0
9383, 0.45, 0.19, 0
9384, 0.44166666666667, 0.2, 0
9385, 0.45, 0.21, 0
9386, 0.44166666666667, 0.22, 0
9387, 0.45, 0.23, 0
9388, 0.44166666666667, 0.24, 0
9389, 0.45, 0.25, 0
9390, 0.44166666666667, 0.26, 0
9391, 0.45, 0.27, 0
9392, 0.44166666666667, 0.28, 0
9393, 0.45, 0.29, 0
9394, 0.44166666666667, 0.3, 0
9395, 0.45, 0.31, 0
9396, 0.44166666666667, 0.32, 0
9397, 0.45, 0.33, 0
9398, 0.44166666666667, 0.34, 0
9399, 0.45, 0.35, 0
9400, 0.44166666666667, 0.36, 0
9401, 0.45, 0.37, 0
9402, 0.44166666666667, 0.38, 0
9403, 0.45, 0.39, 0
9404, 0.44166666666667, 0.4, 0
9405, 0.45, 0.41, 0
9406, 0.44166666666667, 0.42, 0
9407, 0.45, 0.43, 0
9408, 0.44166666666667, 0.44, 0
9409, 0.45, 0.45, 0
9410, 0.44166666666667, 0.46, 0
9411, 0.45, 0.47, 0
9412, 0.44166666666667, 0.48, 0
9413, 0.45, 0.49, 0
9414, 0.44166666666667, 0.5, 0
9415, 0.45, 0.51, 0
9416, 0.44166666666667, 0.52, 0
9417, 0.45, 0.53, 0
9418, 0.44166666666667, 0.54, 0
9419, 0.45, 0.55, 0
9420, 0.44166666666667, 0.56, 0
9421, 0.45, 0.57, 0
9422, 0.44166666666667, 0.58, 0
9423, 0.45, 0.59, 0
9424, 0.44166666666667, 0.6, 0
9425, 0.45, 0.61, 0
9426, 0.44166666666667, 0.62, 0
9427, 0.45, 0.63, 0
9428, 0.44166666666667, 0.64, 0
9429, 0.45, 0.65, 0
9430, 0.44166666666667, 0.66, 0
9431, 0.45, 0.67, 0
9432, 0.44166666666667, 0.68, 0
9433, 0.45, 0.69, 0
9434, 0.44166666666667, 0.7, 0
9435, 0.45, 0.71, 0
9436, 0.44166666666667, 0.72, 0
9437, 0.45, 0.73, 0
9438, 0.44166666666667, 0.74, 0
9439, 0.45, 0.75, 0
9440, 0.44166666666667, 0.76, 0
9441, 0.45, 0.77, 0
9442, 0.44166666666667, 0.78, 0
9443, 0.45, 0.79, 0
9444, 0.44166666666667, 0.8, 0
9445, 0.45, 0.81, 0
9446, 0.44166666666667, 0.82, 0
9447, 0.45, 0.83, 0
9448, 0.44166666666667, 0.84, 0
9449, 0.45, 0.85, 0
9450, 0.44166666666667, 0.86, 0
9451, 0.45, 0.87, 0
9452, 0.44166666666667, 0.88, 0
9453, 0.45, 0.89, 0
9454, 0.44166666666667, 0.9, 0
9455, 0.45, 0.91, 0
9456, 0.44166666666667, 0.92, 0
9457, 0.45, 0.93, 0
9458, 0.44166666666667, 0.94, 0
9459, 0.45, 0.95, 0
9460, 0.44166666666667, 0.96, 0
9461, 0.45, 0.97, 0
9462, 0.44166666666667, 0.98, 0
9463, 0.45, 0.99, 0
9464, 0.44166666666667, 1, 0
9465, 0.45, 1.01, 0
9466, 0.44166666666667, 1.02, 0
9467, 0.45, 1.03, 0
9468, 0.44166666666667, 1.04, 0
9469, 0.45, 1.05, 0
9470, 0.44166666666667, 1.06, 0
9471, 0.45, 1.07, 0
9472, 0.44166666666667, 1.08, 0
9473, 0.45, 1.09, 0
9474, 0.44166666666667, 1.1, 0
9475, 0.45, 1.11, 0
9476, 0.44166666666667, 1.12, 0
9477, 0.45, 1.13, 0
9478, 0.44166666666667, 1.14, 0
9479, 0.45, 1.15, 0
9480, 0.44166666666667, 1.16, 0
9481, 0.45, 1.17, 0
9482, 0.44166666666667, 1.18, 0
9483, 0.45, 1.19, 0
9484, 0.46666666666667, 0.01, 0
9485, 0.45833333333333, 0.02, 0
9486, 0.46666666666667, 0.03, 0
9487, 0.45833333333333, 0.04, 0
9488, 0.46666666666667, 0.05, 0
9489, 0.45833333333333, 0.06, 0
9490, 0.46666666666667, 0.07, 0
9491, 0.45833333333333, 0.08, 0
9492, 0.46666666666667, 0.09, 0
9493, 0.45833333333333, 0.1, 0
9494, 0.46666666666667, 0.11, 0
9495, 0.45833333333333, 0.12, 0
9496, 0.46666666666667, 0.13, 0
9497, 0.45833333333333, 0.14, 0
9498, 0.46666666666667, 0.15, 0
9499, 0.45833333333333, 0.16, 0
9500, 0.46666666666667, 0.17, 0
9501, 0.45833333333333, 0.18, 0
9502, 0.46666666666667, 0.19, 0
9503, 0.45833333333333, 0.2, 0
9504, 0.46666666666667, 0.21, 0
9505, 0.45833333333333, 0.22, 0
9506, 0.46666666666667, 0.23, 0
9507, 0.45833333333333, 0.24, 0
9508, 0.46666666666667, 0.25, 0
9509, 0.45833333333333, 0.26, 0
9510, 0.46666666666667, 0.27, 0
9511, 0.45833333333333, 0.28, 0
9512, 0.46666666666667, 0.29, 0
9513, 0.45833333333333, 0.3, 0
9514, 0.46666666666667, 0.31, 0
9515, 0.45833333333333, 0.32, 0
9516, 0.46666666666667, 0.33, 0
9517, 0.45833333333333, 0.34, 0
9518, 0.46666666666667, 0.35, 0
9519, 0.45833333333333, 0.36, 0
9520, 0.46666666666667, 0.37, 0
9521, 0.45833333333333, 0.38, 0
9522, 0.46666666666667, 0.39, 0
9523, 0.45833333333333, 0.4, 0
9524, 0.46666666666667, 0.41, 0
9525, 0.45833333333333, 0.42, 0
9526, 0.46666666666667, 0.43, 0
9527, 0.45833333333333, 0.44, 0
9528, 0.46666666666667, 0.45, 0
9529, 0.45833333333333, 0.46, 0
9530, 0.46666666666667, 0.47, 0
9531, 0.45833333333333, 0.48, 0
9532, 0.46666666666667, 0.49, 0
9533, 0.45833333333333, 0.5, 0
9534, 0.46666666666667, 0.51, 0
9535, 0.45833333333333, 0.52, 0
9536, 0.46666666666667, 0.53, 0
9537, 0.45833333333333, 0.54, 0
9538, 0.46666666666667, 0.55, 0
9539, 0.45833333333333, 0.56, 0
9540, 0.46666666666667, 0.57, 0
9541, 0.45833333333333, 0.58, 0
9542, 0.46666666666667, 0.59, 0
9543, 0.45833333333333, 0.6, 0
9544, 0.46666666666667, 0.61, 0
9545, 0.45833333333333, 0.62, 0
9546, 0.46666666666667, 0.63, 0
9547, 0.45833333333333, 0.64, 0
9548, 0.46666666666667, 0.65, 0
9549, 0.45833333333333, 0.66, 0
9550, 0.46666666666667, 0.67, 0
9551, 0.45833333333333, 0.68, 0
9552, 0.46666666666667, 0.69, 0
9553, 0.45833333333333, 0.7, 0
9554, 0.46666666666667, 0.71, 0
9555, 0.45833333333333, 0.72, 0
9556, 0.46666666666667, 0.73, 0
9557, 0.45833333333333, 0.74, 0
9558, 0.46666666666667, 0.75, 0
9559, 0.45833333333333, 0.76, 0
9560, 0.46666666666667, 0.77, 0
9561, 0.45833333333333, 0.78, 0
9562, 0.46666666666667, 0.79, 0
9563, 0.45833333333333, 0.8, 0
9564, 0.46666666666667, 0.81, 0
9565, 0.45833333333333, 0.82, 0
9566, 0.46666666666667, 0.83, 0
9567, 0.45833333333333, 0.84, 0
9568, 0.46666666666667, 0.85, 0
9569, 0.45833333333333, 0.86, 0
9570, 0.46666666666667, 0.87, 0
9571, 0.45833333333333, 0.88, 0
9572, 0.46666666666667, 0.89, 0
9573, 0.45833333333333, 0.9, 0
9574, 0.46666666666667, 0.91, 0
9575, 0.45833333333333, 0.92, 0
9576, 0.46666666666667, 0.93, 0
9577, 0.45833333333333, 0.94, 0
9578, 0.46666666666667, 0.95, 0
9579, 0.45833333333333, 0.96, 0
9580, 0.46666666666667, 0.97, 0
9581, 0.45833333333333, 0.98, 0
9582, 0.46666666666667, 0.99, 0
9583, 0.45833333333333, 1, 0
9584, 0.46666666666667, 1.01, 0
9585, 0.45833333333333, 1.02, 0
9586, 0.46666666666667, 1.03, 0
9587, 0.45833333333333, 1.04, 0
9588, 0.46666666666667, 1.05, 0
9589, 0.45833333333333, 1.06, 0
9590, 0.46666666666667, 1.07, 0
9591, 0.45833333333333, 1.08, 0
9592, 0.46666666666667, 1.09, 0
9593, 0.45833333333333, 1.1, 0
9594, 0.46666666666667, 1.11, 0
9595, 0.45833333333333, 1.12, 0
9596, 0.46666666666667, 1.13, 0
9597, 0.45833333333333, 1.14, 0
9598, 0.46666666666667, 1.15, 0
9599, 0.45833333333333, 1.16, 0
9600, 0.46666666666667, 1.17, 0
9601, 0.45833333333333, 1.18, 0
9602, 0.46666666666667, 1.19, 0
9603, 0.48333333333333, 0.01, 0
9604, 0.475, 0.02, 0
9605, 0.48333333333333, 0.03, 0
9606, 0.475, 0.04, 0
9607, 0.48333333333333, 0.05, 0
9608, 0.475, 0.06, 0
9609, 0.48333333333333, 0.07, 0
9610, 0.475, 0.08, 0
9611, 0.48333333333333, 0.09, 0
9612, 0.475, 0.1, 0
9613, 0.48333333333333, 0.11, 0
9614, 0.475, 0.12, 0
9615, 0.48333333333333, 0.13, 0
9616, 0.475, 0.14, 0
9617, 0.48333333333333, 0.15, 0
9618, 0.475, 0.16, 0
9619, 0.48333333333333, 0.17, 0
9620, 0.475, 0.18, 0
9621, 0.48333333333333, 0.19, 0
9622, 0.475, 0.2, 0
9623, 0.48333333333333, 0.21, 0
9624, 0.475, 0.22, 0
9625, 0.48333333333333, 0.23, 0
9626, 0.475, 0.24, 0
9627, 0.48333333333333, 0.25, 0
9628, 0.475, 0.26, 0
9629, 0.48333333333333, 0.27, 0
9630, 0.475, 0.28, 0
9631, 0.48333333333333, 0.29, 0
9632, 0.475, 0.3, 0
9633, 0.48333333333333, 0.31, 0
9634, 0.475, 0.32, 0
9635, 0.48333333333333, 0.33, 0
9636, 0.475, 0.34, 0
9637, 0.48333333333333, 0.35, 0
9638, 0.475, 0.36, 0
9639, 0.48333333333333, 0.37, 0
9640, 0.475, 0.38, 0
9641, 0.48333333333333, 0.39, 0
9642, 0.475, 0.4, 0
9643, 0.48333333333333, 0.41, 0
9644, 0.475, 0.42, 0
9645, 0.48333333333333, 0.43, 0
9646, 0.475, 0.44, 0
9647, 0.48333333333333, 0.45, 0
9648, 0.475, 0.46, 0
9649, 0.48333333333333, 0.47, 0
9650, 0.475, 0.48, 0
9651, 0.48333333333333, 0.49, 0
9652, 0.475, 0.5, 0
9653, 0.48333333333333, 0.51, 0
9654, 0.475, 0.52, 0
9655, 0.48333333333333, 0.53, 0
9656, 0.475, 0.54, 0
9657, 0.48333333333333, 0.55, 0
9658, 0.475, 0.56, 0
9659, 0.48333333333333, 0.57, 0
9660, 0.475, 0.58, 0
9661, 0.48333333333333, 0.59, 0
9662, 0.475, 0.6, 0
9663, 0.48333333333333, 0.61, 0
9664, 0.475, 0.62, 0
9665, 0.48333333333333, 0.63, 0
9666, 0.475, 0.64, 0
9667, 0.48333333333333, 0.65, 0
9668, 0.475, 0.66, 0
9669, 0.48333333333333, 0.67, 0
9670, 0.475, 0.68, 0
9671, 0.48333333333333, 0.69, 0
9672, 0.475, 0.7, 0
9673, 0.48333333333333, 0.71, 0
9674, 0.475, 0.72, 0
9675, 0.48333333333333, 0.73, 0
9676, 0.475, 0.74, 0
9677, 0.48333333333333, 0.75, 0
9678, 0.475, 0.76, 0
9679, 0.48333333333333, 0.77, 0
9680, 0.475, 0.78, 0
9681, 0.48333333333333, 0.79, 0
9682, 0.475, 0.8, 0
9683, 0.48333333333333, 0.81, 0
9684, 0.475, 0.82, 0
9685, 0.48333333333333, 0.83, 0
9686, 0.475, 0.84, 0
9687, 0.48333333333333, 0.85, 0
9688, 0.475, 0.86, 0
9689, 0.48333333333333, 0.87, 0
9690, 0.475, 0.88, 0
9691, 0.48333333333333, 0.89, 0
9692, 0.475, 0.9, 0
9693, 0.48333333333333, 0.91, 0
9694, 0.475, 0.92, 0
9695, 0.48333333333333, 0.93, 0
9696, 0.475, 0.94, 0
9697, 0.48333333333333, 0.95, 0
9698, 0.475, 0.96, 0
9699, 0.48333333333333, 0.97, 0
9700, 0.475, 0.98, 0
9701, 0.48333333333333, 0.99, 0
9702, 0.475, 1, 0
9703, 0.48333333333333, 1.01, 0
9704, 0.475, 1.02, 0
9705, 0.48333333333333, 1.03, 0
9706, 0.475, 1.04, 0
9707, 0.48333333333333, 1.05, 0
9708, 0.475, 1.06, 0
9709, 0.48333333333333, 1.07, 0
9710, 0.475, 1.08, 0
9711, 0.48333333333333, 1.09, 0
9712, 0.475, 1.1, 0
9713, 0.48333333333333, 1.11, 0
9714, 0.475, 1.12, 0
9715, 0.48333333333333, 1.13, 0
9716, 0.475, 1.14, 0
9717, 0.48333333333333, 1.15, 0
9718, 0.475, 1.16, 0
9719, 0.48333333333333, 1.17, 0
9720, 0.475, 1.18, 0
9721, 0.48333333333333, 1.19, 0
9722, 0.5, 0.01, 0
9723, 0.49166666666667, 0.02, 0
9724, 0.5, 0.03, 0
9725, 0.49166666666667, 0.04, 0
9726, 0.5, 0.05, 0
9727, 0.49166666666667, 0.06, 0
9728, 0.5, 0.07, 0
9729, 0.49166666666667, 0.08, 0
9730, 0.5, 0.09, 0
9731, 0.49166666666667, 0.1, 0
9732, 0.5, 0.11, 0
9733, 0.49166666666667, 0.12, 0
9734, 0.5, 0.13, 0
9735, 0.49166666666667, 0.14, 0
9736, 0.5, 0.15, 0
9737, 0.49166666666667, 0.16, 0
9738, 0.5, 0.17, 0
9739, 0.49166666666667, 0.18, 0
9740, 0.5, 0.19, 0
9741, 0.49166666666667, 0.2, 0
9742, 0.5, 0.21, 0
9743, 0.49166666666667, 0.22, 0
9744, 0.5, 0.23, 0
9745, 0.49166666666667, 0.24, 0
9746, 0.5, 0.25, 0
9747, 0.49166666666667, 0.26, 0
9748, 0.5, 0.27, 0
9749, 0.49166666666667, 0.28, 0
9750, 0.5, 0.29, 0
9751, 0.49166666666667, 0.3, 0
9752, 0.5, 0.31, 0
9753, 0.49166666666667, 0.32, 0
9754, 0.5, 0.33, 0
9755, 0.49166666666667, 0.34, 0
9756, 0.5, 0.35, 0
9757, 0.49166666666667, 0.36, 0
9758, 0.5, 0.37, 0
9759, 0.49166666666667, 0.38, 0
9760, 0.5, 0.39, 0
9761, 0.49166666666667, 0.4, 0
9762, 0.5, 0.41, 0
9763, 0.49166666666667, 0.42, 0
9764, 0.5, 0.43, 0
9765, 0.49166666666667, 0.44, 0
9766, 0.5, 0.45, 0
9767, 0.49166666666667, 0.46, 0
9768, 0.5, 0.47, 0
9769, 0.49166666666667, 0.48, 0
9770, 0.5, 0.49, 0
9771, 0.49166666666667, 0.5, 0
9772, 0.5, 0.51, 0
9773, 0.49166666666667, 0.52, 0
9774, 0.5, 0.53, 0
9775, 0.49166666666667, 0.54, 0
9776, 0.5, 0.55, 0
9777, 0.49166666666667, 0.56, 0
9778, 0.5, 0.57, 0
9779, 0.49166666666667, 0.58, 0
9780, 0.5, 0.59, 0
9781, 0.49166666666667, 0.6, 0
9782, 0.5, 0.61, 0
9783, 0.49166666666667, 0.62, 0
9784, 0.5, 0.63, 0
9785, 0.49166666666667, 0.64, 0
9786, 0.5, 0.65, 0
9787, 0.49166666666667, 0.66, 0
9788, 0.5, 0.67, 0
9789, 0.49166666666667, 0.68, 0
9790, 0.5, 0.69, 0
9791, 0.49166666666667, 0.7, 0
9792, 0.5, 0.71, 0
9793, 0.49166666666667, 0.72, 0
9794, 0.5, 0.73, 0
9795, 0.49166666666667, 0.74, 0
9796, 0.5, 0.75, 0
9797, 0.49166666666667, 0.76, 0
9798, 0.5, 0.77, 0
9799, 0.49166666666667, 0.78, 0
9800, 0.5, 0.79, 0
9801, 0.49166666666667, 0.8, 0
9802, 0.5, 0.81, 0
9803, 0.49166666666667, 0.82, 0
9804, 0.5, 0.83, 0
9805, 0.49166666666667, 0.84, 0
9806, 0.5, 0.85, 0
9807, 0.49166666666667, 0.86, 0
9808, 0.5, 0.87, 0
9809, 0.49166666666667, 0.88, 0
9810, 0.5, 0.89, 0
9811, 0.49166666666667, 0.9, 0
9812, 0.5, 0.91, 0
9813, 0.49166666666667, 0.92, 0
9814, 0.5, 0.93, 0
9815, 0.49166666666667, 0.94, 0
9816, 0.5, 0.95, 0
9817, 0.49166666666667, 0.96, 0
9818, 0.5, 0.97, 0
9819, 0.49166666666667, 0.98, 0
9820, 0.5, 0.99, 0
9821, 0.49166666666667, 1, 0
9822, 0.5, 1.01, 0
9823, 0.49166666666667, 1.02, 0
9824, 0.5, 1.03, 0
9825, 0.49166666666667, 1.04, 0
9826, 0.5, 1.05, 0
9827, 0.49166666666667, 1.06, 0
9828, 0.5, 1.07, 0
9829, 0.49166666666667, 1.08, 0
9830, 0.5, 1.09, 0
9831, 0.49166666666667, 1.1, 0
9832, 0.5, 1.11, 0
9833, 0.49166666666667, 1.12, 0
9834, 0.5, 1.13, 0
9835, 0.49166666666667, 1.14, 0
9836, 0.5, 1.15, 0
9837, 0.49166666666667, 1.16, 0
9838, 0.5, 1.17, 0
9839, 0.49166666666667, 1.18, 0
9840, 0.5, 1.19, 0
9841, 0.51666666666667, 0.01, 0
9842, 0.50833333333333, 0.02, 0
9843, 0.51666666666667, 0.03, 0
9844, 0.50833333333333, 0.04, 0
9845, 0.51666666666667, 0.05, 0
9846, 0.50833333333333, 0.06, 0
9847, 0.51666666666667, 0.07, 0
9848, 0.50833333333333, 0.08, 0
9849, 0.51666666666667, 0.09, 0
9850, 0.50833333333333, 0.1, 0
9851, 0.51666666666667, 0.11, 0
9852, 0.50833333333333, 0.12, 0
9853, 0.51666666666667, 0.13, 0
9854, 0.50833333333333, 0.14, 0
9855, 0.51666666666667, 0.15, 0
9856, 0.50833333333333, 0.16, 0
9857, 0.51666666666667, 0.17, 0
9858, 0.50833333333333, 0.18, 0
9859, 0.51666666666667, 0.19, 0
9860, 0.50833333333333, 0.2, 0
9861, 0.51666666666667, 0.21, 0
9862, 0.50833333333333, 0.22, 0
9863, 0.51666666666667, 0.23, 0
9864, 0.50833333333333, 0.24, 0
9865, 0.51666666666667, 0.25, 0
9866, 0.50833333333333, 0.26, 0
9867, 0.51666666666667, 0.27, 0
9868, 0.50833333333333, 0.28, 0
9869, 0.51666666666667, 0.29, 0
9870, 0.50833333333333, 0.3, 0
9871, 0.51666666666667, 0.31, 0
9872, 0.50833333333333, 0.32, 0
9873, 0.51666666666667, 0.33, 0
9874, 0.50833333333333, 0.34, 0
9875, 0.51666666666667, 0.35, 0
9876, 0.50833333333333, 0.36, 0
9877, 0.51666666666667, 0.37, 0
9878, 0.50833333333333, 0.38, 0
9879, 0.51666666666667, 0.39, 0
9880, 0.50833333333333, 0.4, 0
9881, 0.51666666666667, 0.41, 0
9882, 0.50833333333333, 0.42, 0
9883, 0.51666666666667, 0.43, 0
9884, 0.50833333333333, 0.44, 0
9885, 0.51666666666667, 0.45, 0
9886, 0.50833333333333, 0.46, 0
9887, 0.51666666666667, 0.47, 0
9888, 0.50833333333333, 0.48, 0
9889, 0.51666666666667, 0.49, 0
9890, 0.50833333333333, 0.5, 0
9891, 0.51666666666667, 0.51, 0
9892, 0.50833333333333, 0.52, 0
9893, 0.51666666666667, 0.53, 0
9894, 0.50833333333333, 0.54, 0
9895, 0.51666666666667, 0.55, 0
9896, 0.50833333333333, 0.56, 0
9897, 0.51666666666667, 0.57, 0
9898, 0.50833333333333, 0.58, 0
9899, 0.51666666666667, 0.59, 0
9900, 0.50833333333333, 0.6, 0
9901, 0.51666666666667, 0.61, 0
9902, 0.50833333333333, 0.62, 0
9903, 0.51666666666667, 0.63, 0
9904, 0.50833333333333, 0.64, 0
9905, 0.51666666666667, 0.65, 0
9906, 0.50833333333333, 0.66, 0
9907, 0.51666666666667, 0.67, 0
9908, 0.50833333333333, 0.68, 0
9909, 0.51666666666667, 0.69, 0
9910, 0.50833333333333, 0.7, 0
9911, 0.51666666666667, 0.71, 0
9912, 0.50833333333333, 0.72, 0
9913, 0.51666666666667, 0.73, 0
9914, 0.50833333333333, 0.74, 0
9915, 0.51666666666667, 0.75, 0
9916, 0.50833333333333, 0.76, 0
9917, 0.51666666666667, 0.77, 0
9918, 0.50833333333333, 0.78, 0
9919, 0.51666666666667, 0.79, 0
9920, 0.50833333333333, 0.8, 0
9921, 0.51666666666667, 0.81, 0
9922, 0.50833333333333, 0.82, 0
9923, 0.51666666666667, 0.83, 0
9924, 0.50833333333333, 0.84, 0
9925, 0.51666666666667, 0.85, 0
9926, 0.50833333333333, 0.86, 0
9927, 0.51666666666667, 0.87, 0
9928, 0.50833333333333, 0.88, 0
9929, 0.51666666666667, 0.89, 0
9930, 0.50833333333333, 0.9, 0
9931, 0.51666666666667, 0.91, 0
9932, 0.50833333333333, 0.92, 0
9933, 0.51666666666667, 0.93, 0
9934, 0.50833333333333, 0.94, 0
9935, 0.51666666666667, 0.95, 0
9936, 0.50833333333333, 0.96, 0
9937, 0.51666666666667, 0.97, 0
9938, 0.50833333333333, 0.98, 0
9939, 0.51666666666667, 0.99, 0
9940, 0.50833333333333, 1, 0
9941, 0.51666666666667, 1.01, 0
9942, 0.50833333333333, 1.02, 0
9943, 0.51666666666667, 1.03, 0
9944, 0.50833333333333, 1.04, 0
9945, 0.51666666666667, 1.05, 0
9946, 0.50833333333333, 1.06, 0
9947, 0.51666666666667, 1.07, 0
9948, 0.50833333333333, 1.08, 0
9949, 0.51666666666667, 1.09, 0
9950, 0.50833333333333, 1.1, 0
9951, 0.51666666666667, 1.11, 0
9952, 0.50833333333333, 1.12, 0
9953, 0.51666666666667, 1.13, 0
9954, 0.50833333333333, 1.14, 0
9955, 0.51666666666667, 1.15, 0
9956, 0.50833333333333, 1.16, 0
9957, 0.51666666666667, 1.17, 0
9958, 0.50833333333333, 1.18, 0
9959, 0.51666666666667, 1.19, 0
9960, 0.53333333333333, 0.01, 0
9961, 0.525, 0.02, 0
9962, 0.53333333333333, 0.03, 0
9963, 0.525, 0.04, 0
9964, 0.53333333333333, 0.05, 0
9965, 0.525, 0.06, 0
9966, 0.53333333333333, 0.07, 0
9967, 0.525, 0.08, 0
9968, 0.53333333333333, 0.09, 0
9969, 0.525, 0.1, 0
9970, 0.53333333333333, 0.11, 0
9971, 0.525, 0.12, 0
9972, 0.53333333333333, 0.13, 0
9973, 0.525, 0.14, 0
9974, 0.53333333333333, 0.15, 0
9975, 0.525, 0.16, 0
9976, 0.53333333333333, 0.17, 0
9977, 0.525, 0.18, 0
9978, 0.53333333333333, 0.19, 0
9979, 0.525, 0.2, 0
9980, 0.53333333333333, 0.21, 0
9981, 0.525, 0.22, 0
9982, 0.53333333333333, 0.23, 0
9983, 0.525, 0.24, 0
9984, 0.53333333333333, 0.25, 0
9985, 0.525, 0.26, 0
9986, 0.53333333333333, 0.27, 0
9987, 0.525, 0.28, 0
9988, 0.53333333333333, 0.29, 0
9989, 0.525, 0.3, 0
9990, 0.53333333333333, 0.31, 0
9991, 0.525, 0.32, 0
9992, 0.53333333333333, 0.33, 0
9993, 0.525, 0.34, 0
9994, 0.53333333333333, 0.35, 0
9995, 0.525, 0.36, 0
9996, 0.53333333333333, 0.37, 0
9997, 0.525, 0.38, 0
9998, 0.53333333333333, 0.39, 0
9999, 0.525, 0.4, 0
10000, 0.53333333333333, 0.41, 0
10001, 0.525, 0.42, 0
10002, 0.53333333333333, 0.43, 0
10003, 0.525, 0.44, 0
10004, 0.53333333333333, 0.45, 0
10005, 0.525, 0.46, 0
10006, 0.53333333333333, 0.47, 0
10007, 0.525, 0.48, 0
10008, 0.53333333333333, 0.49, 0
10009, 0.525, 0.5, 0
10010, 0.53333333333333, 0.51, 0
10011, 0.525, 0.52, 0
10012, 0.53333333333333, 0.53, 0
10013, 0.525, 0.54, 0
10014, 0.53333333333333, 0.55, 0
10015, 0.525, 0.56, 0
10016, 0.53333333333333, 0.57, 0
10017, 0.525, 0.58, 0
10018, 0.53333333333333, 0.59, 0
10019, 0.525, 0.6, 0
10020, 0.53333333333333, 0.61, 0
10021, 0.525, 0.62, 0
10022, 0.53333333333333, 0.63, 0
10023, 0.525, 0.64, 0
10024, 0.53333333333333, 0.65, 0
10025, 0.525, 0.66, 0
10026, 0.53333333333333, 0.67, 0
10027, 0.525, 0.68, 0
10028, 0.53333333333333, 0.69, 0
10029, 0.525, 0.7, 0
10030, 0.53333333333333, 0.71, 0
10031, 0.525, 0.72, 0
10032, 0.53333333333333, 0.73, 0
10033, 0.525, 0.74, 0
10034, 0.53333333333333, 0.75, 0
10035, 0.525, 0.76, 0
10036, 0.53333333333333, 0.77, 0
10037, 0.525, 0.78, 0
10038, 0.53333333333333, 0.79, 0
10039, 0.525, 0.8, 0
10040, 0.53333333333333, 0.81, 0
10041, 0.525, 0.82, 0
10042, 0.53333333333333, 0.83, 0
10043, 0.525, 0.84, 0
10044, 0.53333333333333, 0.85, 0
10045, 0.525, 0.86, 0
10046, 0.53333333333333, 0.87, 0
10047, 0.525, 0.88, 0
10048, 0.53333333333333, 0.89, 0
10049, 0.525, 0.9, 0
10050, 0.53333333333333, 0.91, 0
10051, 0.525, 0.92, 0
10052, 0.53333333333333, 0.93, 0
10053, 0.525, 0.94, 0
10054, 0.53333333333333, 0.95, 0
10055, 0.525, 0.96, 0
10056, 0.53333333333333, 0.97, 0
10057, 0.525, 0.98, 0
10058, 0.53333333333333, 0.99, 0
10059, 0.525, 1, 0
10060, 0.53333333333333, 1.01, 0
10061, 0.525, 1.02, 0
10062, 0.53333333333333, 1.03, 0
10063, 0.525, 1.04, 0
10064, 0.53333333333333, 1.05, 0
10065, 0.525, 1.06, 0
10066, 0.53333333333333, 1.07, 0
10067, 0.525, 1.08, 0
10068, 0.53333333333333, 1.09, 0
10069, 0.525, 1.1, 0
10070, 0.53333333333333, 1.11, 0
10071, 0.525, 1.12, 0
10072, 0.53333333333333, 1.13, 0
10073, 0.525, 1.14, 0
10074, 0.53333333333333, 1.15, 0
10075, 0.525, 1.16, 0
10076, 0.53333333333333, 1.17, 0
10077, 0.525, 1.18, 0
10078, 0.53333333333333, 1.19, 0
10079, 0.55, 0.01, 0
10080, 0.54166666666667, 0.02, 0
10081, 0.55, 0.03, 0
10082, 0.54166666666667, 0.04, 0
10083, 0.55, 0.05, 0
10084, 0.54166666666667, 0.06, 0
10085, 0.55, 0.07, 0
10086, 0.54166666666667, 0.08, 0
10087, 0.55, 0.09, 0
10088, 0.54166666666667, 0.1, 0
10089, 0.55, 0.11, 0
10090, 0.54166666666667, 0.12, 0
10091, 0.55, 0.13, 0
10092, 0.54166666666667, 0.14, 0
10093, 0.55, 0.15, 0
10094, 0.54166666666667, 0.16, 0
10095, 0.55, 0.17, 0
10096, 0.54166666666667, 0.18, 0
10097, 0.55, 0.19, 0
10098, 0.54166666666667, 0.2, 0
10099, 0.55, 0.21, 0
10100, 0.54166666666667, 0.22, 0
10101, 0.55, 0.23, 0
10102, 0.54166666666667, 0.24, 0
10103, 0.55, 0.25, 0
10104, 0.54166666666667, 0.26, 0
10105, 0.55, 0.27, 0
10106, 0.54166666666667, 0.28, 0
10107, 0.55, 0.29, 0
10108, 0.54166666666667, 0.3, 0
10109, 0.55, 0.31, 0
10110, 0.54166666666667, 0.32, 0
10111, 0.55, 0.33, 0
10112, 0.54166666666667, 0.34, 0
10113, 0.55, 0.35, 0
10114, 0.54166666666667, 0.36, 0
10115, 0.55, 0.37, 0
10116, 0.54166666666667, 0.38, 0
10117, 0.55, 0.39, 0
10118, 0.54166666666667, 0.4, 0
10119, 0.55, 0.41, 0
10120, 0.54166666666667, 0.42, 0
10121, 0.55, 0.43, 0
10122, 0.54166666666667, 0.44, 0
10123, 0.55, 0.45, 0
10124, 0.54166666666667, 0.46, 0
10125, 0.55, 0.47, 0
10126, 0.54166666666667, 0.48, 0
10127, 0.55, 0.49, 0
10128, 0.54166666666667, 0.5, 0
10129, 0.55, 0.51, 0
10130, 0.54166666666667, 0.52, 0
10131, 0.55, 0.53, 0
10132, 0.54166666666667, 0.54, 0
10133, 0.55, 0.55, 0
10134, 0.54166666666667, 0.56, 0
10135, 0.55, 0.57, 0
10136, 0.54166666666667, 0.58, 0
10137, 0.55, 0.59, 0
10138, 0.54166666666667, 0.6, 0
10139, 0.55, 0.61, 0
10140, 0.54166666666667, 0.62, 0
10141, 0.55, 0.63, 0
10142, 0.54166666666667, 0.64, 0
10143, 0.55, 0.65, 0
10144, 0.54166666666667, 0.66, 0
10145, 0.55, 0.67, 0
10146, 0.54166666666667, 0.68, 0
10147, 0.55, 0.69, 0
10148, 0.54166666666667, 0.7, 0
10149, 0.55, 0.71, 0
10150, 0.54166666666667, 0.72, 0
10151, 0.55, 0.73, 0
10152, 0.54166666666667, 0.74, 0
10153, 0.55, 0.75, 0
10154, 0.54166666666667, 0.76, 0
10155, 0.55, 0.77, 0
10156, 0.54166666666667, 0.78, 0
10157, 0.55, 0.79, 0
10158, 0.54166666666667, 0.8, 0
10159, 0.55, 0.81, 0
10160, 0.54166666666667, 0.82, 0
10161, 0.55, 0.83, 0
10162, 0.54166666666667, 0.84, 0
10163, 0.55, 0.85, 0
10164, 0.54166666666667, 0.86, 0
10165, 0.55, 0.87, 0
10166, 0.54166666666667, 0.88, 0
10167, 0.55, 0.89, 0
10168, 0.54166666666667, 0.9, 0
10169, 0.55, 0.91, 0
10170, 0.54166666666667, 0.92, 0
10171, 0.55, 0.93, 0
10172, 0.54166666666667, 0.94, 0
10173, 0.55, 0.95, 0
10174, 0.54166666666667, 0.96, 0
10175, 0.55, 0.97, 0
10176, 0.54166666666667, 0.98, 0
10177, 0.55, 0.99, 0
10178, 0.54166666666667, 1, 0
10179, 0.55, 1.01, 0
10180, 0.54166666666667, 1.02, 0
10181, 0.55, 1.03, 0
10182, 0.54166666666667, 1.04, 0
10183, 0.55, 1.05, 0
10184, 0.54166666666667, 1.06, 0
10185, 0.55, 1.07, 0
10186, 0.54166666666667, 1.08, 0
10187, 0.55, 1.09, 0
10188, 0.54166666666667, 1.1, 0
10189, 0.55, 1.11, 0
10190, 0.54166666666667, 1.12, 0
10191, 0.55, 1.13, 0
10192, 0.54166666666667, 1.14, 0
10193, 0.55, 1.15, 0
10194, 0.54166666666667, 1.16, 0
10195, 0.55, 1.17, 0
10196, 0.54166666666667, 1.18, 0
10197, 0.55, 1.19, 0
10198, 0.56666666666667, 0.01, 0
10199, 0.55833333333333, 0.02, 0
10200, 0.56666666666667, 0.03, 0
10201, 0.55833333333333, 0.04, 0
10202, 0.56666666666667, 0.05, 0
10203, 0.55833333333333, 0.06, 0
10204, 0.56666666666667, 0.07, 0
10205, 0.55833333333333, 0.08, 0
10206, 0.56666666666667, 0.09, 0
10207, 0.55833333333333, 0.1, 0
10208, 0.56666666666667, 0.11, 0
10209, 0.55833333333333, 0.12, 0
10210, 0.56666666666667, 0.13, 0
10211, 0.55833333333333, 0.14, 0
10212, 0.56666666666667, 0.15, 0
10213, 0.55833333333333, 0.16, 0
10214, 0.56666666666667, 0.17, 0
10215, 0.55833333333333, 0.18, 0
10216, 0.56666666666667, 0.19, 0
10217, 0.55833333333333, 0.2, 0
10218, 0.56666666666667, 0.21, 0
10219, 0.55833333333333, 0.22, 0
10220, 0.56666666666667, 0.23, 0
10221, 0.55833333333333, 0.24, 0
10222, 0.56666666666667, 0.25, 0
10223, 0.55833333333333, 0.26, 0
10224, 0.56666666666667, 0.27, 0
10225, 0.55833333333333, 0.28, 0
10226, 0.56666666666667, 0.29, 0
10227, 0.55833333333333, 0.3, 0
10228, 0.56666666666667, 0.31, 0
10229, 0.55833333333333, 0.32, 0
10230, 0.56666666666667, 0.33, 0
10231, 0.55833333333333, 0.34, 0
10232, 0.56666666666667, 0.35, 0
10233, 0.55833333333333, 0.36, 0
10234, 0.56666666666667, 0.37, 0
10235, 0.55833333333333, 0.38, 0
10236, 0.56666666666667, 0.39, 0
10237, 0.55833333333333, 0.4, 0
10238, 0.56666666666667, 0.41, 0
10239, 0.55833333333333, 0.42, 0
10240, 0.56666666666667, 0.43, 0
10241, 0.55833333333333, 0.44, 0
10242, 0.56666666666667, 0.45, 0
10243, 0.55833333333333, 0.46, 0
10244, 0.56666666666667, 0.47, 0
10245, 0.55833333333333, 0.48, 0
10246, 0.56666666666667, 0.49, 0
10247, 0.55833333333333, 0.5, 0
10248, 0.56666666666667, 0.51, 0
10249, 0.55833333333333, 0.52, 0
10250, 0.56666666666667, 0.53, 0
10251, 0.55833333333333, 0.54, 0
10252, 0.56666666666667, 0.55, 0
10253, 0.55833333333333, 0.56, 0
10254, 0.56666666666667, 0.57, 0
10255, 0.55833333333333, 0.58, 0
10256, 0.56666666666667, 0.59, 0
10257, 0.55833333333333, 0.6, 0
10258, 0.56666666666667, 0.61, 0
10259, 0.55833333333333, 0.62, 0
10260, 0.56666666666667, 0.63, 0
10261, 0.55833333333333, 0.64, 0
10262, 0.56666666666667, 0.65, 0
10263, 0.55833333333333, 0.66, 0
10264, 0.56666666666667, 0.67, 0
10265, 0.55833333333333, 0.68, 0
10266, 0.56666666666667, 0.69, 0
10267, 0.55833333333333, 0.7, 0
10268, 0.56666666666667, 0.71, 0
10269, 0.55833333333333, 0.72, 0
10270, 0.56666666666667, 0.73, 0
10271, 0.55833333333333, 0.74, 0
10272, 0.56666666666667, 0.75, 0
10273, 0.55833333333333, 0.76, 0
10274, 0.56666666666667, 0.77, 0
10275, 0.55833333333333, 0.78, 0
10276, 0.56666666666667, 0.79, 0
10277, 0.55833333333333, 0.8, 0
10278, 0.56666666666667, 0.81, 0
10279, 0.55833333333333, 0.82, 0
10280, 0.56666666666667, 0.83, 0
10281, 0.55833333333333, 0.84, 0
10282, 0.56666666666667, 0.85, 0
10283, 0.55833333333333, 0.86, 0
10284, 0.56666666666667, 0.87, 0
10285, 0.55833333333333, 0.88, 0
10286, 0.56666666666667, 0.89, 0
10287, 0.55833333333333, 0.9, 0
10288, 0.56666666666667, 0.91, 0
10289, 0.55833333333333, 0.92, 0
10290, 0.56666666666667, 0.93, 0
10291, 0.55833333333333, 0.94, 0
10292, 0.56666666666667, 0.95, 0
10293, 0.55833333333333, 0.96, 0
10294, 0.56666666666667, 0.97, 0
10295, 0.55833333333333, 0.98, 0
10296, 0.56666666666667, 0.99, 0
10297, 0.55833333333333, 1, 0
10298, 0.56666666666667, 1.01, 0
10299, 0.55833333333333, 1.02, 0
10300, 0.56666666666667, 1.03, 0
10301, 0.55833333333333, 1.04, 0
10302, 0.56666666666667, 1.05, 0
10303, 0.55833333333333, 1.06, 0
10304, 0.56666666666667, 1.07, 0
10305, 0.55833333333333, 1.08, 0
10306, 0.56666666666667, 1.09, 0
10307, 0.55833333333333, 1.1, 0
10308, 0.56666666666667, 1.11, 0
10309, 0.55833333333333, 1.12, 0
10310, 0.56666666666667, 1.13, 0
10311, 0.55833333333333, 1.14, 0
10312, 0.56666666666667, 1.15, 0
10313, 0.55833333333333, 1.16, 0
10314, 0.56666666666667, 1.17, 0
10315, 0.55833333333333, 1.18, 0
10316, 0.56666666666667, 1.19, 0
10317, 0.58333333333333, 0.01, 0
10318, 0.575, 0.02, 0
10319, 0.58333333333333, 0.03, 0
10320, 0.575, 0.04, 0
10321, 0.58333333333333, 0.05, 0
10322, 0.575, 0.06, 0
10323, 0.58333333333333, 0.07, 0
10324, 0.575, 0.08, 0
10325, 0.58333333333333, 0.09, 0
10326, 0.575, 0.1, 0
10327, 0.58333333333333, 0.11, 0
10328, 0.575, 0.12, 0
10329, 0.58333333333333, 0.13, 0
10330, 0.575, 0.14, 0
10331, 0.58333333333333, 0.15, 0
10332, 0.575, 0.16, 0
10333, 0.58333333333333, 0.17, 0
10334, 0.575, 0.18, 0
10335, 0.58333333333333, 0.19, 0
10336, 0.575, 0.2, 0
10337, 0.58333333333333, 0.21, 0
10338, 0.575, 0.22, 0
10339, 0.58333333333333, 0.23, 0
10340, 0.575, 0.24, 0
10341, 0.58333333333333, 0.25, 0
10342, 0.575, 0.26, 0
10343, 0.58333333333333, 0.27, 0
10344, 0.575, 0.28, 0
10345, 0.58333333333333, 0.29, 0
10346, 0.575, 0.3, 0
10347, 0.58333333333333, 0.31, 0
10348, 0.575, 0.32, 0
10349, 0.58333333333333, 0.33, 0
10350, 0.575, 0.34, 0
10351, 0.58333333333333, 0.35, 0
10352, 0.575, 0.36, 0
10353, 0.58333333333333, 0.37, 0
10354, 0.575, 0.38, 0
10355, 0.58333333333333, 0.39, 0
10356, 0.575, 0.4, 0
10357, 0.58333333333333, 0.41, 0
10358, 0.575, 0.42, 0
10359, 0.58333333333333, 0.43, 0
10360, 0.575, 0.44, 0
10361, 0.58333333333333, 0.45, 0
10362, 0.575, 0.46, 0
10363, 0.58333333333333, 0.47, 0
10364, 0.575, 0.48, 0
10365, 0.58333333333333, 0.49, 0
10366, 0.575, 0.5, 0
10367, 0.58333333333333, 0.51, 0
10368, 0.575, 0.52, 0
10369, 0.58333333333333, 0.53, 0
10370, 0.575, 0.54, 0
10371, 0.58333333333333, 0.55, 0
10372, 0.575, 0.56, 0
10373, 0.58333333333333, 0.57, 0
10374, 0.575, 0.58, 0
10375, 0.58333333333333, 0.59, 0
10376, 0.575, 0.6, 0
10377, 0.58333333333333, 0.61, 0
10378, 0.575, 0.62, 0
10379, 0.58333333333333, 0.63, 0
10380, 0.575, 0.64, 0
10381, 0.58333333333333, 0.65, 0
10382, 0.575, 0.66, 0
10383, 0.58333333333333, 0.67, 0
10384, 0.575, 0.68, 0
10385, 0.58333333333333, 0.69, 0
10386, 0.575, 0.7, 0
10387, 0.58333333333333, 0.71, 0
10388, 0.575, 0.72, 0
10389, 0.58333333333333, 0.73, 0
10390, 0.575, 0.74, 0
10391, 0.58333333333333, 0.75, 0
10392, 0.575, 0.76, 0
10393, 0.58333333333333, 0.77, 0
10394, 0.575, 0.78, 0
10395, 0.58333333333333, 0.79, 0
10396, 0.575, 0.8, 0
10397, 0.58333333333333, 0.81, 0
10398, 0.575, 0.82, 0
10399, 0.58333333333333, 0.83, 0
10400, 0.575, 0.84, 0
10401, 0.58333333333333, 0.85, 0
10402, 0.575, 0.86, 0
10403, 0.58333333333333, 0.87, 0
10404, 0.575, 0.88, 0
10405, 0.58333333333333, 0.89, 0
10406, 0.575, 0.9, 0
10407, 0.58333333333333, 0.91, 0
10408, 0.575, 0.92, 0
10409, 0.58333333333333, 0.93, 0
10410, 0.575, 0.94, 0
10411, 0.58333333333333, 0.95, 0
10412, 0.575, 0.96, 0
10413, 0.58333333333333, 0.97, 0
10414, 0.575, 0.98, 0
10415, 0.58333333333333, 0.99, 0
10416, 0.575, 1, 0
10417, 0.58333333333333, 1.01, 0
10418, 0.575, 1.02, 0
10419, 0.58333333333333, 1.03, 0
10420, 0.575, 1.04, 0
10421, 0.58333333333333, 1.05, 0
10422, 0.575, 1.06, 0
10423, 0.58333333333333, 1.07, 0
10424, 0.575, 1.08, 0
10425, 0.58333333333333, 1.09, 0
10426, 0.575, 1.1, 0
10427, 0.58333333333333, 1.11, 0
10428, 0.575, 1.12, 0
10429, 0.58333333333333, 1.13, 0
10430, 0.575, 1.14, 0
10431, 0.58333333333333, 1.15, 0
10432, 0.575, 1.16, 0
10433, 0.58333333333333, 1.17, 0
10434, 0.575, 1.18, 0
10435, 0.58333333333333, 1.19, 0
10436, 0.6, 0.01, 0
10437, 0.59166666666667, 0.02, 0
10438, 0.6, 0.03, 0
10439, 0.59166666666667, 0.04, 0
10440, 0.6, 0.05, 0
10441, 0.59166666666667, 0.06, 0
10442, 0.6, 0.07, 0
10443, 0.59166666666667, 0.08, 0
10444, 0.6, 0.09, 0
10445, 0.59166666666667, 0.1, 0
10446, 0.6, 0.11, 0
10447, 0.59166666666667, 0.12, 0
10448, 0.6, 0.13, 0
10449, 0.59166666666667, 0.14, 0
10450, 0.6, 0.15, 0
10451, 0.59166666666667, 0.16, 0
10452, 0.6, 0.17, 0
10453, 0.59166666666667, 0.18, 0
10454, 0.6, 0.19, 0
10455, 0.59166666666667, 0.2, 0
10456, 0.6, 0.21, 0
10457, 0.59166666666667, 0.22, 0
10458, 0.6, 0.23, 0
10459, 0.59166666666667, 0.24, 0
10460, 0.6, 0.25, 0
10461, 0.59166666666667, 0.26, 0
10462, 0.6, 0.27, 0
10463, 0.59166666666667, 0.28, 0
10464, 0.6, 0.29, 0
10465, 0.59166666666667, 0.3, 0
10466, 0.6, 0.31, 0
10467, 0.59166666666667, 0.32, 0
10468, 0.6, 0.33, 0
10469, 0.59166666666667, 0.34, 0
10470, 0.6, 0.35, 0
10471, 0.59166666666667, 0.36, 0
10472, 0.6, 0.37, 0
10473, 0.59166666666667, 0.38, 0
10474, 0.6, 0.39, 0
10475, 0.59166666666667, 0.4, 0
10476, 0.6, 0.41, 0
10477, 0.59166666666667, 0.42, 0
10478, 0.6, 0.43, 0
10479, 0.59166666666667, 0.44, 0
10480, 0.6, 0.45, 0
10481, 0.59166666666667, 0.46, 0
10482, 0.6, 0.47, 0
10483, 0.59166666666667, 0.48, 0
10484, 0.6, 0.49, 0
10485, 0.59166666666667, 0.5, 0
10486, 0.6, 0.51, 0
10487, 0.59166666666667, 0.52, 0
10488, 0.6, 0.53, 0
10489, 0.59166666666667, 0.54, 0
10490, 0.6, 0.55, 0
10491, 0.59166666666667, 0.56, 0
10492, 0.6, 0.57, 0
10493, 0.59166666666667, 0.58, 0
10494, 0.6, 0.59, 0
10495, 0.59166666666667, 0.6, 0
10496, 0.6, 0.61, 0
10497, 0.59166666666667, 0.62, 0
10498, 0.6, 0.63, 0
10499, 0.59166666666667, 0.64, 0
10500, 0.6, 0.65, 0
10501, 0.59166666666667, 0.66, 0
10502, 0.6, 0.67, 0
10503, 0.59166666666667, 0.68, 0
10504, 0.6, 0.69, 0
10505, 0.59166666666667, 0.7, 0
10506, 0.6, 0.71, 0
10507, 0.59166666666667, 0.72, 0
10508, 0.6, 0.73, 0
10509, 0.59166666666667, 0.74, 0
10510, 0.6, 0.75, 0
10511, 0.59166666666667, 0.76, 0
10512, 0.6, 0.77, 0
10513, 0.59166666666667, 0.78, 0
10514, 0.6, 0.79, 0
10515, 0.59166666666667, 0.8, 0
10516, 0.6, 0.81, 0
10517, 0.59166666666667, 0.82, 0
10518, 0.6, 0.83, 0
10519, 0.59166666666667, 0.84, 0
10520, 0.6, 0.85, 0
10521, 0.59166666666667, 0.86, 0
10522, 0.6, 0.87, 0
10523, 0.59166666666667, 0.88, 0
10524, 0.6, 0.89, 0
10525, 0.59166666666667, 0.9, 0
10526, 0.6, 0.91, 0
10527, 0.59166666666667, 0.92, 0
10528, 0.6, 0.93, 0
10529, 0.59166666666667, 0.94, 0
10530, 0.6, 0.95, 0
10531, 0.59166666666667, 0.96, 0
10532, 0.6, 0.97, 0
10533, 0.59166666666667, 0.98, 0
10534, 0.6, 0.99, 0
10535, 0.59166666666667, 1, 0
10536, 0.6, 1.01, 0
10537, 0.59166666666667, 1.02, 0
10538, 0.6, 1.03, 0
10539, 0.59166666666667, 1.04, 0
10540, 0.6, 1.05, 0
10541, 0.59166666666667, 1.06, 0
10542, 0.6, 1.07, 0
10543, 0.59166666666667, 1.08, 0
10544, 0.6, 1.09, 0
10545, 0.59166666666667, 1.1, 0
10546, 0.6, 1.11, 0
10547, 0.59166666666667, 1.12, 0
10548, 0.6, 1.13, 0
10549, 0.59166666666667, 1.14, 0
10550, 0.6, 1.15, 0
10551, 0.59166666666667, 1.16, 0
10552, 0.6, 1.17, 0
10553, 0.59166666666667, 1.18, 0
10554, 0.6, 1.19, 0
10555, 0.61666666666667, 0.01, 0
10556, 0.60833333333333, 0.02, 0
10557, 0.61666666666667, 0.03, 0
10558, 0.60833333333333, 0.04, 0
10559, 0.61666666666667, 0.05, 0
10560, 0.60833333333333, 0.06, 0
10561, 0.61666666666667, 0.07, 0
10562, 0.60833333333333, 0.08, 0
10563, 0.61666666666667, 0.09, 0
10564, 0.60833333333333, 0.1, 0
10565, 0.61666666666667, 0.11, 0
10566, 0.60833333333333, 0.12, 0
10567, 0.61666666666667, 0.13, 0
10568, 0.60833333333333, 0.14, 0
10569, 0.61666666666667, 0.15, 0
10570, 0.60833333333333, 0.16, 0
10571, 0.61666666666667, 0.17, 0
10572, 0.60833333333333, 0.18, 0
10573, 0.61666666666667, 0.19, 0
10574, 0.60833333333333, 0.2, 0
10575, 0.61666666666667, 0.21, 0
10576, 0.60833333333333, 0.22, 0
10577, 0.61666666666667, 0.23, 0
10578, 0.60833333333333, 0.24, 0
10579, 0.61666666666667, 0.25, 0
10580, 0.60833333333333, 0.26, 0
10581, 0.61666666666667, 0.27, 0
10582, 0.60833333333333, 0.28, 0
10583, 0.61666666666667, 0.29, 0
10584, 0.60833333333333, 0.3, 0
10585, 0.61666666666667, 0.31, 0
10586, 0.60833333333333, 0.32, 0
10587, 0.61666666666667, 0.33, 0
10588, 0.60833333333333, 0.34, 0
10589, 0.61666666666667, 0.35, 0
10590, 0.60833333333333, 0.36, 0
10591, 0.61666666666667, 0.37, 0
10592, 0.60833333333333, 0.38, 0
10593, 0.61666666666667, 0.39, 0
10594, 0.60833333333333, 0.4, 0
10595, 0.61666666666667, 0.41, 0
10596, 0.60833333333333, 0.42, 0
10597, 0.61666666666667, 0.43, 0
10598, 0.60833333333333, 0.44, 0
10599, 0.61666666666667, 0.45, 0
10600, 0.60833333333333, 0.46, 0
10601, 0.61666666666667, 0.47, 0
10602, 0.60833333333333, 0.48, 0
10603, 0.61666666666667, 0.49, 0
10604, 0.60833333333333, 0.5, 0
10605, 0.61666666666667, 0.51, 0
10606, 0.60833333333333, 0.52, 0
10607, 0.61666666666667, 0.53, 0
10608, 0.60833333333333, 0.54, 0
10609, 0.61666666666667, 0.55, 0
10610, 0.60833333333333, 0.56, 0
10611, 0.61666666666667, 0.57, 0
10612, 0.60833333333333, 0.58, 0
10613, 0.61666666666667, 0.59, 0
10614, 0.60833333333333, 0.6, 0
10615, 0.61666666666667, 0.61, 0
10616, 0.60833333333333, 0.62, 0
10617, 0.61666666666667, 0.63, 0
10618, 0.60833333333333, 0.64, 0
10619, 0.61666666666667, 0.65, 0
10620, 0.60833333333333, 0.66, 0
10621, 0.61666666666667, 0.67, 0
10622, 0.60833333333333, 0.68, 0
10623, 0.61666666666667, 0.69, 0
10624, 0.60833333333333, 0.7, 0
10625, 0.61666666666667, 0.71, 0
10626, 0.60833333333333, 0.72, 0
10627, 0.61666666666667, 0.73, 0
10628, 0.60833333333333, 0.74, 0
10629, 0.61666666666667, 0.75, 0
10630, 0.60833333333333, 0.76, 0
10631, 0.61666666666667, 0.77, 0
10632, 0.60833333333333, 0.78, 0
10633, 0.61666666666667, 0.79, 0
10634, 0.60833333333333, 0.8, 0
10635, 0.61666666666667, 0.81, 0
10636, 0.60833333333333, 0.82, 0
10637, 0.61666666666667, 0.83, 0
10638, 0.60833333333333, 0.84, 0
10639, 0.61666666666667, 0.85, 0
10640, 0.60833333333333, 0.86, 0
10641, 0.61666666666667, 0.87, 0
10642, 0.60833333333333, 0.88, 0
10643, 0.61666666666667, 0.89, 0
10644, 0.60833333333333, 0.9, 0
10645, 0.61666666666667, 0.91, 0
10646, 0.60833333333333, 0.92, 0
10647, 0.61666666666667, 0.93, 0
10648, 0.60833333333333, 0.94, 0
10649, 0.61666666666667, 0.95, 0
10650, 0.60833333333333, 0.96, 0
10651, 0.61666666666667, 0.97, 0
10652, 0.60833333333333, 0.98, 0
10653, 0.61666666666667, 0.99, 0
10654, 0.60833333333333, 1, 0
10655, 0.61666666666667, 1.01, 0
10656, 0.60833333333333, 1.02, 0
10657, 0.61666666666667, 1.03, 0
10658, 0.60833333333333, 1.04, 0
10659, 0.61666666666667, 1.05, 0
10660, 0.60833333333333, 1.06, 0
10661, 0.61666666666667, 1.07, 0
10662, 0.60833333333333, 1.08, 0
10663, 0.61666666666667, 1.09, 0
10664, 0.60833333333333, 1.1, 0
10665, 0.61666666666667, 1.11, 0
10666, 0.60833333333333, 1.12, 0
10667, 0.61666666666667, 1.13, 0
10668, 0.60833333333333, 1.14, 0
10669, 0.61666666666667, 1.15, 0
10670, 0.60833333333333, 1.16, 0
10671, 0.61666666666667, 1.17, 0
10672, 0.60833333333333, 1.18, 0
10673, 0.61666666666667, 1.19, 0
10674, 0.63333333333333, 0.01, 0
10675, 0.625, 0.02, 0
10676, 0.63333333333333, 0.03, 0
10677, 0.625, 0.04, 0
10678, 0.63333333333333, 0.05, 0
10679, 0.625, 0.06, 0
10680, 0.63333333333333, 0.07, 0
10681, 0.625, 0.08, 0
10682, 0.63333333333333, 0.09, 0
10683, 0.625, 0.1, 0
10684, 0.63333333333333, 0.11, 0
10685, 0.625, 0.12, 0
10686, 0.63333333333333, 0.13, 0
10687, 0.625, 0.14, 0
10688, 0.63333333333333, 0.15, 0
10689, 0.625, 0.16, 0
10690, 0.63333333333333, 0.17, 0
10691, 0.625, 0.18, 0
10692, 0.63333333333333, 0.19, 0
10693, 0.625, 0.2, 0
10694, 0.63333333333333, 0.21, 0
10695, 0.625, 0.22, 0
10696, 0.63333333333333, 0.23, 0
10697, 0.625, 0.24, 0
10698, 0.63333333333333, 0.25, 0
10699, 0.625, 0.26, 0
10700, 0.63333333333333, 0.27, 0
10701, 0.625, 0.28, 0
10702, 0.63333333333333, 0.29, 0
10703, 0.625, 0.3, 0
10704, 0.63333333333333, 0.31, 0
10705, 0.625, 0.32, 0
10706, 0.63333333333333, 0.33, 0
10707, 0.625, 0.34, 0
10708, 0.63333333333333, 0.35, 0
10709, 0.625, 0.36, 0
10710, 0.63333333333333, 0.37, 0
10711, 0.625, 0.38, 0
10712, 0.63333333333333, 0.39, 0
10713, 0.625, 0.4, 0
10714, 0.63333333333333, 0.41, 0
10715, 0.625, 0.42, 0
10716, 0.63333333333333, 0.43, 0
10717, 0.625, 0.44, 0
10718, 0.63333333333333, 0.45, 0
10719, 0.625, 0.46, 0
10720, 0.63333333333333, 0.47, 0
10721, 0.625, 0.48, 0
10722, 0.63333333333333, 0.49, 0
10723, 0.625, 0.5, 0
10724, 0.63333333333333, 0.51, 0
10725, 0.625, 0.52, 0
10726, 0.63333333333333, 0.53, 0
10727, 0.625, 0.54, 0
10728, 0.63333333333333, 0.55, 0
10729, 0.625, 0.56, 0
10730, 0.63333333333333, 0.57, 0
10731, 0.625, 0.58, 0
10732, 0.63333333333333, 0.59, 0
10733, 0.625, 0.6, 0
10734, 0.63333333333333, 0.61, 0
10735, 0.625, 0.62, 0
10736, 0.63333333333333, 0.63, 0
10737, 0.625, 0.64, 0
10738, 0.63333333333333, 0.65, 0
10739, 0.625, 0.66, 0
10740, 0.63333333333333, 0.67, 0
10741, 0.625, 0.68, 0
10742, 0.63333333333333, 0.69, 0
10743, 0.625, 0.7, 0
10744, 0.63333333333333, 0.71, 0
10745, 0.625, 0.72, 0
10746, 0.63333333333333, 0.73, 0
10747, 0.625, 0.74, 0
10748, 0.63333333333333, 0.75, 0
10749, 0.625, 0.76, 0
10750, 0.63333333333333, 0.77, 0
10751, 0.625, 0.78, 0
10752, 0.63333333333333, 0.79, 0
10753, 0.625, 0.8, 0
10754, 0.63333333333333, 0.81, 0
10755, 0.625, 0.82, 0
10756, 0.63333333333333, 0.83, 0
10757, 0.625, 0.84, 0
10758, 0.63333333333333, 0.85, 0
10759, 0.625, 0.86, 0
10760, 0.63333333333333, 0.87, 0
10761, 0.625, 0.88, 0
10762, 0.63333333333333, 0.89, 0
10763, 0.625, 0.9, 0
10764, 0.63333333333333, 0.91, 0
10765, 0.625, 0.92, 0
10766, 0.63333333333333, 0.93, 0
10767, 0.625, 0.94, 0
10768, 0.63333333333333, 0.95, 0
10769, 0.625, 0.96, 0
10770, 0.63333333333333, 0.97, 0
10771, 0.625, 0.98, 0
10772, 0.63333333333333, 0.99, 0
10773, 0.625, 1, 0
10774, 0.63333333333333, 1.01, 0
10775, 0.625, 1.02, 0
10776, 0.63333333333333, 1.03, 0
10777, 0.625, 1.04, 0
10778, 0.63333333333333, 1.05, 0
10779, 0.625, 1.06, 0
10780, 0.63333333333333, 1.07, 0
10781, 0.625, 1.08, 0
10782, 0.63333333333333, 1.09, 0
10783, 0.625, 1.1, 0
10784, 0.63333333333333, 1.11, 0
10785, 0.625, 1.12, 0
10786, 0.63333333333333, 1.13, 0
10787, 0.625, 1.14, 0
10788, 0.63333333333333, 1.15, 0
10789, 0.625, 1.16, 0
10790, 0.63333333333333, 1.17, 0
10791, 0.625, 1.18, 0
10792, 0.63333333333333, 1.19, 0
10793, 0.65, 0.01, 0
10794, 0.64166666666667, 0.02, 0
10795, 0.65, 0.03, 0
10796, 0.64166666666667, 0.04, 0
10797, 0.65, 0.05, 0
10798, 0.64166666666667, 0.06, 0
10799, 0.65, 0.07, 0
10800, 0.64166666666667, 0.08, 0
10801, 0.65, 0.09, 0
10802, 0.64166666666667, 0.1, 0
10803, 0.65, 0.11, 0
10804, 0.64166666666667, 0.12, 0
10805, 0.65, 0.13, 0
10806, 0.64166666666667, 0.14, 0
10807, 0.65, 0.15, 0
10808, 0.64166666666667, 0.16, 0
10809, 0.65, 0.17, 0
10810, 0.64166666666667, 0.18, 0
10811, 0.65, 0.19, 0
10812, 0.64166666666667, 0.2, 0
10813, 0.65, 0.21, 0
10814, 0.64166666666667, 0.22, 0
10815, 0.65, 0.23, 0
10816, 0.64166666666667, 0.24, 0
10817, 0.65, 0.25, 0
10818, 0.64166666666667, 0.26, 0
10819, 0.65, 0.27, 0
10820, 0.64166666666667, 0.28, 0
10821, 0.65, 0.29, 0
10822, 0.64166666666667, 0.3, 0
10823, 0.65, 0.31, 0
10824, 0.64166666666667, 0.32, 0
10825, 0.65, 0.33, 0
10826, 0.64166666666667, 0.34, 0
10827, 0.65, 0.35, 0
10828, 0.64166666666667, 0.36, 0
10829, 0.65, 0.37, 0
10830, 0.64166666666667, 0.38, 0
10831, 0.65, 0.39, 0
10832, 0.64166666666667, 0.4, 0
10833, 0.65, 0.41, 0
10834, 0.64166666666667, 0.42, 0
10835, 0.65, 0.43, 0
10836, 0.64166666666667, 0.44, 0
10837, 0.65, 0.45, 0
10838, 0.64166666666667, 0.46, 0
10839, 0.65, 0.47, 0
10840, 0.64166666666667, 0.48, 0
10841, 0.65, 0.49, 0
10842, 0.64166666666667, 0.5, 0
10843, 0.65, 0.51, 0
10844, 0.64166666666667, 0.52, 0
10845, 0.65, 0.53, 0
10846, 0.64166666666667, 0.54, 0
10847, 0.65, 0.55, 0
10848, 0.64166666666667, 0.56, 0
10849, 0.65, 0.57, 0
10850, 0.64166666666667, 0.58, 0
10851, 0.65, 0.59, 0
10852, 0.64166666666667, 0.6, 0
10853, 0.65, 0.61, 0
10854, 0.64166666666667, 0.62, 0
10855, 0.65, 0.63, 0
10856, 0.64166666666667, 0.64, 0
10857, 0.65, 0.65, 0
10858, 0.64166666666667, 0.66, 0
10859, 0.65, 0.67, 0
10860, 0.64166666666667, 0.68, 0
10861, 0.65, 0.69, 0
10862, 0.64166666666667, 0.7, 0
10863, 0.65, 0.71, 0
10864, 0.64166666666667, 0.72, 0
10865, 0.65, 0.73, 0
10866, 0.64166666666667, 0.74, 0
10867, 0.65, 0.75, 0
10868, 0.64166666666667, 0.76, 0
10869, 0.65, 0.77, 0
10870, 0.64166666666667, 0.78, 0
10871, 0.65, 0.79, 0
10872, 0.64166666666667, 0.8, 0
10873, 0.65, 0.81, 0
10874, 0.64166666666667, 0.82, 0
10875, 0.65, 0.83, 0
10876, 0.64166666666667, 0.84, 0
10877, 0.65, 0.85, 0
10878, 0.64166666666667, 0.86, 0
10879, 0.65, 0.87, 0
10880, 0.64166666666667, 0.88, 0
10881, 0.65, 0.89, 0
10882, 0.64166666666667, 0.9, 0
10883, 0.65, 0.91, 0
10884, 0.64166666666667, 0.92, 0
10885, 0.65, 0.93, 0
10886, 0.64166666666667, 0.94, 0
10887, 0.65, 0.95, 0
10888, 0.64166666666667, 0.96, 0
10889, 0.65, 0.97, 0
10890, 0.64166666666667, 0.98, 0
10891, 0.65, 0.99, 0
10892, 0.64166666666667, 1, 0
10893, 0.65, 1.01, 0
10894, 0.64166666666667, 1.02, 0
10895, 0.65, 1.03, 0
10896, 0.64166666666667, 1.04, 0
10897, 0.65, 1.05, 0
10898, 0.64166666666667, 1.06, 0
10899, 0.65, 1.07, 0
10900, 0.64166666666667, 1.08, 0
10901, 0.65, 1.09, 0
10902, 0.64166666666667, 1.1, 0
10903, 0.65, 1.11, 0
10904, 0.64166666666667, 1.12, 0
10905, 0.65, 1.13, 0
10906, 0.64166666666667, 1.14, 0
10907, 0.65, 1.15, 0
10908, 0.64166666666667, 1.16, 0
10909, 0.65, 1.17, 0
10910, 0.64166666666667, 1.18, 0
10911, 0.65, 1.19, 0
10912, 0.66666666666667, 0.01, 0
10913, 0.65833333333333, 0.02, 0
10914, 0.66666666666667, 0.03, 0
10915, 0.65833333333333, 0.04, 0
10916, 0.66666666666667, 0.05, 0
10917, 0.65833333333333, 0.06, 0
10918, 0.66666666666667, 0.07, 0
10919, 0.65833333333333, 0.08, 0
10920, 0.66666666666667, 0.09, 0
10921, 0.65833333333333, 0.1, 0
10922, 0.66666666666667, 0.11, 0
10923, 0.65833333333333, 0.12, 0
10924, 0.66666666666667, 0.13, 0
10925, 0.65833333333333, 0.14, 0
10926, 0.66666666666667, 0.15, 0
10927, 0.65833333333333, 0.16, 0
10928, 0.66666666666667, 0.17, 0
10929, 0.65833333333333, 0.18, 0
10930, 0.66666666666667, 0.19, 0
10931, 0.65833333333333, 0.2, 0
10932, 0.66666666666667, 0.21, 0
10933, 0.65833333333333, 0.22, 0
10934, 0.66666666666667, 0.23, 0
10935, 0.65833333333333, 0.24, 0
10936, 0.66666666666667, 0.25, 0
10937, 0.65833333333333, 0.26, 0
10938, 0.66666666666667, 0.27, 0
10939, 0.65833333333333, 0.28, 0
10940, 0.66666666666667, 0.29, 0
10941, 0.65833333333333, 0.3, 0
10942, 0.66666666666667, 0.31, 0
10943, 0.65833333333333, 0.32, 0
10944, 0.66666666666667, 0.33, 0
10945, 0.65833333333333, 0.34, 0
10946, 0.66666666666667, 0.35, 0
10947, 0.65833333333333, 0.36, 0
10948, 0.66666666666667, 0.37, 0
10949, 0.65833333333333, 0.38, 0
10950, 0.66666666666667, 0.39, 0
10951, 0.65833333333333, 0.4, 0
10952, 0.66666666666667, 0.41, 0
10953, 0.65833333333333, 0.42, 0
10954, 0.66666666666667, 0.43, 0
10955, 0.65833333333333, 0.44, 0
10956, 0.66666666666667, 0.45, 0
10957, 0.65833333333333, 0.46, 0
10958, 0.66666666666667, 0.47, 0
10959, 0.65833333333333, 0.48, 0
10960, 0.66666666666667, 0.49, 0
10961, 0.65833333333333, 0.5, 0
10962, 0.66666666666667, 0.51, 0
10963, 0.65833333333333, 0.52, 0
10964, 0.66666666666667, 0.53, 0
10965, 0.65833333333333, 0.54, 0
10966, 0.66666666666667, 0.55, 0
10967, 0.65833333333333, 0.56, 0
10968, 0.66666666666667, 0.57, 0
10969, 0.65833333333333, 0.58, 0
10970, 0.66666666666667, 0.59, 0
10971, 0.65833333333333, 0.6, 0
