20936, 1.7583333333333, 0.84, 0
20937, 1.7666666666667, 0.85, 0
20938, 1.775, 0.84, 0
20939, 1.7833333333333, 0.85, 0
20940, 1.7916666666667, 0.84, 0
20941, 1.8, 0.85, 0
20942, 1.8083333333333, 0.84, 0
20943, 1.8166666666667, 0.85, 0
20944, 1.825, 0.84, 0
20945, 1.8333333333333, 0.85, 0
20946, 1.8416666666667, 0.84, 0
20947, 1.85, 0.85, 0
20948, 1.8583333333333, 0.84, 0
20949, 1.8666666666667, 0.85, 0
20950, 1.875, 0.84, 0
20951, 1.8833333333333, 0.85, 0
20952, 1.8916666666667, 0.84, 0
20953, 1.9, 0.85, 0
20954, 1.9083333333333, 0.84, 0
20955, 1.9166666666667, 0.85, 0
20956, 1.925, 0.84, 0
20957, 1.9333333333333, 0.85, 0
20958, 1.9416666666667, 0.84, 0
20959, 1.95, 0.85, 0
20960, 1.9583333333333, 0.84, 0
20961, 1.9666666666667, 0.85, 0
20962, 1.975, 0.84, 0
20963, 1.9833333333333, 0.85, 0
20964, 1.9916666666667, 0.84, 0
20965, 2, 0.85, 0
20966, 2.0083333333333, 0.84, 0
20967, 2.0166666666667, 0.85, 0
20968, 2.025, 0.84, 0
20969, 2.0333333333333, 0.85, 0
20970, 2.0416666666667, 0.84, 0
20971, 2.05, 0.85, 0
20972, 2.0583333333333, 0.84, 0
20973, 2.0666666666667, 0.85, 0
20974, 2.075, 0.84, 0
20975, 2.0833333333333, 0.85, 0
20976, 2.0916666666667, 0.84, 0
20977, 2.1, 0.85, 0
20978, 2.1083333333333, 0.84, 0
20979, 2.1166666666667, 0.85, 0
20980, 2.125, 0.84, 0
20981, 2.1333333333333, 0.85, 0
20982, 2.1416666666667, 0.84, 0
20983, 2.15, 0.85, 0
20984, 2.1583333333333, 0.84, 0
20985, 2.1666666666667, 0.85, 0
20986, 2.175, 0.84, 0
20987, 2.1833333333333, 0.85, 0
20988, 2.1916666666667, 0.84, 0
20989, 1.2083333333333, 0.82, 0
20990, 1.2166666666667, 0.83, 0
20991, 1.225, 0.82, 0
20992, 1.2333333333333, 0.83, 0
20993, 1.2416666666667, 0.82, 0
20994, 1.25, 0.83, 0
20995, 1.2583333333333, 0.82, 0
20996, 1.2666666666667, 0.83, 0
20997, 1.275, 0.82, 0
20998, 1.2833333333333, 0.83, 0
20999, 1.2916666666667, 0.82, 0
21000, 1.3, 0.83, 0
21001, 1.3083333333333, 0.82, 0
21002, 1.3166666666667, 0.83, 0
21003, 1.325, 0.82, 0
21004, 1.3333333333333, 0.83, 0
21005, 1.3416666666667, 0.82, 0
21006, 1.35, 0.83, 0
21007, 1.3583333333333, 0.82, 0
21008, 1.3666666666667, 0.83, 0
21009, 1.375, 0.82, 0
21010, 1.3833333333333, 0.83, 0
21011, 1.3916666666667, 0.82, 0
21012, 1.4, 0.83, 0
21013, 1.4083333333333, 0.82, 0
21014, 1.4166666666667, 0.83, 0
21015, 1.425, 0.82, 0
21016, 1.4333333333333, 0.83, 0
21017, 1.4416666666667, 0.82, 0
21018, 1.45, 0.83, 0
21019, 1.4583333333333, 0.82, 0
21020, 1.4666666666667, 0.83, 0
21021, 1.475, 0.82, 0
21022, 1.4833333333333, 0.83, 0
21023, 1.4916666666667, 0.82, 0
21024, 1.5, 0.83, 0
21025, 1.5083333333333, 0.82, 0
21026, 1.5166666666667, 0.83, 0
21027, 1.525, 0.82, 0
21028, 1.5333333333333, 0.83, 0
21029, 1.5416666666667, 0.82, 0
21030, 1.55, 0.83, 0
21031, 1.5583333333333, 0.82, 0
21032, 1.5666666666667, 0.83, 0
21033, 1.575, 0.82, 0
21034, 1.5833333333333, 0.83, 0
21035, 1.5916666666667, 0.82, 0
21036, 1.6, 0.83, 0
21037, 1.6083333333333, 0.82, 0
21038, 1.6166666666667, 0.83, 0
21039, 1.625, 0.82, 0
21040, 1.6333333333333, 0.83, 0
21041, 1.6416666666667, 0.82, 0
21042, 1.65, 0.83, 0
21043, 1.6583333333333, 0.82, 0
21044, 1.6666666666667, 0.83, 0
21045, 1.675, 0.82, 0
21046, 1.6833333333333, 0.83, 0
21047, 1.6916666666667, 0.82, 0
21048, 1.7, 0.83, 0
21049, 1.7083333333333, 0.82, 0
21050, 1.7166666666667, 0.83, 0
21051, 1.725, 0.82, 0
21052, 1.7333333333333, 0.83, 0
21053, 1.7416666666667, 0.82, 0
21054, 1.75, 0.83, 0
21055, 1.7583333333333, 0.82, 0
21056, 1.7666666666667, 0.83, 0
21057, 1.775, 0.82, 0
21058, 1.7833333333333, 0.83, 0
21059, 1.7916666666667, 0.82, 0
21060, 1.8, 0.83, 0
21061, 1.8083333333333, 0.82, 0
21062, 1.8166666666667, 0.83, 0
21063, 1.825, 0.82, 0
21064, 1.8333333333333, 0.83, 0
21065, 1.8416666666667, 0.82, 0
21066, 1.85, 0.83, 0
21067, 1.8583333333333, 0.82, 0
21068, 1.8666666666667, 0.83, 0
21069, 1.875, 0.82, 0
21070, 1.8833333333333, 0.83, 0
21071, 1.8916666666667, 0.82, 0
21072, 1.9, 0.83, 0
21073, 1.9083333333333, 0.82, 0
21074, 1.9166666666667, 0.83, 0
21075, 1.925, 0.82, 0
21076, 1.9333333333333, 0.83, 0
21077, 1.9416666666667, 0.82, 0
21078, 1.95, 0.83, 0
21079, 1.9583333333333, 0.82, 0
21080, 1.9666666666667, 0.83, 0
21081, 1.975, 0.82, 0
21082, 1.9833333333333, 0.83, 0
21083, 1.9916666666667, 0.82, 0
21084, 2, 0.83, 0
21085, 2.0083333333333, 0.82, 0
21086, 2.0166666666667, 0.83, 0
21087, 2.025, 0.82, 0
21088, 2.0333333333333, 0.83, 0
21089, 2.0416666666667, 0.82, 0
21090, 2.05, 0.83, 0
21091, 2.0583333333333, 0.82, 0
21092, 2.0666666666667, 0.83, 0
21093, 2.075, 0.82, 0
21094, 2.0833333333333, 0.83, 0
21095, 2.0916666666667, 0.82, 0
21096, 2.1, 0.83, 0
21097, 2.1083333333333, 0.82, 0
21098, 2.1166666666667, 0.83, 0
21099, 2.125, 0.82, 0
21100, 2.1333333333333, 0.83, 0
21101, 2.1416666666667, 0.82, 0
21102, 2.15, 0.83, 0
21103, 2.1583333333333, 0.82, 0
21104, 2.1666666666667, 0.83, 0
21105, 2.175, 0.82, 0
21106, 2.1833333333333, 0.83, 0
21107, 2.1916666666667, 0.82, 0
21108, 1.2083333333333, 0.8, 0
21109, 1.2166666666667, 0.81, 0
21110, 1.225, 0.8, 0
21111, 1.2333333333333, 0.81, 0
21112, 1.2416666666667, 0.8, 0
21113, 1.25, 0.81, 0
21114, 1.2583333333333, 0.8, 0
21115, 1.2666666666667, 0.81, 0
21116, 1.275, 0.8, 0
21117, 1.2833333333333, 0.81, 0
21118, 1.2916666666667, 0.8, 0
21119, 1.3, 0.81, 0
21120, 1.3083333333333, 0.8, 0
21121, 1.3166666666667, 0.81, 0
21122, 1.325, 0.8, 0
21123, 1.3333333333333, 0.81, 0
21124, 1.3416666666667, 0.8, 0
21125, 1.35, 0.81, 0
21126, 1.3583333333333, 0.8, 0
21127, 1.3666666666667, 0.81, 0
21128, 1.375, 0.8, 0
21129, 1.3833333333333, 0.81, 0
21130, 1.3916666666667, 0.8, 0
21131, 1.4, 0.81, 0
21132, 1.4083333333333, 0.8, 0
21133, 1.4166666666667, 0.81, 0
21134, 1.425, 0.8, 0
21135, 1.4333333333333, 0.81, 0
21136, 1.4416666666667, 0.8, 0
21137, 1.45, 0.81, 0
21138, 1.4583333333333, 0.8, 0
21139, 1.4666666666667, 0.81, 0
21140, 1.475, 0.8, 0
21141, 1.4833333333333, 0.81, 0
21142, 1.4916666666667, 0.8, 0
21143, 1.5, 0.81, 0
21144, 1.5083333333333, 0.8, 0
21145, 1.5166666666667, 0.81, 0
21146, 1.525, 0.8, 0
21147, 1.5333333333333, 0.81, 0
21148, 1.5416666666667, 0.8, 0
21149, 1.55, 0.81, 0
21150, 1.5583333333333, 0.8, 0
21151, 1.5666666666667, 0.81, 0
21152, 1.575, 0.8, 0
21153, 1.5833333333333, 0.81, 0
21154, 1.5916666666667, 0.8, 0
21155, 1.6, 0.81, 0
21156, 1.6083333333333, 0.8, 0
21157, 1.6166666666667, 0.81, 0
21158, 1.625, 0.8, 0
21159, 1.6333333333333, 0.81, 0
21160, 1.6416666666667, 0.8, 0
21161, 1.65, 0.81, 0
21162, 1.6583333333333, 0.8, 0
21163, 1.6666666666667, 0.81, 0
21164, 1.675, 0.8, 0
21165, 1.6833333333333, 0.81, 0
21166, 1.6916666666667, 0.8, 0
21167, 1.7, 0.81, 0
21168, 1.7083333333333, 0.8, 0
21169, 1.7166666666667, 0.81, 0
21170, 1.725, 0.8, 0
21171, 1.7333333333333, 0.81, 0
21172, 1.7416666666667, 0.8, 0
21173, 1.75, 0.81, 0
21174, 1.7583333333333, 0.8, 0
21175, 1.7666666666667, 0.81, 0
21176, 1.775, 0.8, 0
21177, 1.7833333333333, 0.81, 0
21178, 1.7916666666667, 0.8, 0
21179, 1.8, 0.81, 0
21180, 1.8083333333333, 0.8, 0
21181, 1.8166666666667, 0.81, 0
21182, 1.825, 0.8, 0
21183, 1.8333333333333, 0.81, 0
21184, 1.8416666666667, 0.8, 0
21185, 1.85, 0.81, 0
21186, 1.8583333333333, 0.8, 0
21187, 1.8666666666667, 0.81, 0
21188, 1.875, 0.8, 0
21189, 1.8833333333333, 0.81, 0
21190, 1.8916666666667, 0.8, 0
21191, 1.9, 0.81, 0
21192, 1.9083333333333, 0.8, 0
21193, 1.9166666666667, 0.81, 0
21194, 1.925, 0.8, 0
21195, 1.9333333333333, 0.81, 0
21196, 1.9416666666667, 0.8, 0
21197, 1.95, 0.81, 0
21198, 1.9583333333333, 0.8, 0
21199, 1.9666666666667, 0.81, 0
21200, 1.975, 0.8, 0
21201, 1.9833333333333, 0.81, 0
21202, 1.9916666666667, 0.8, 0
21203, 2, 0.81, 0
21204, 2.0083333333333, 0.8, 0
21205, 2.0166666666667, 0.81, 0
21206, 2.025, 0.8, 0
21207, 2.0333333333333, 0.81, 0
21208, 2.0416666666667, 0.8, 0
21209, 2.05, 0.81, 0
21210, 2.0583333333333, 0.8, 0
21211, 2.0666666666667, 0.81, 0
21212, 2.075, 0.8, 0
21213, 2.0833333333333, 0.81, 0
21214, 2.0916666666667, 0.8, 0
21215, 2.1, 0.81, 0
21216, 2.1083333333333, 0.8, 0
21217, 2.1166666666667, 0.81, 0
21218, 2.125, 0.8, 0
21219, 2.1333333333333, 0.81, 0
21220, 2.1416666666667, 0.8, 0
21221, 2.15, 0.81, 0
21222, 2.1583333333333, 0.8, 0
21223, 2.1666666666667, 0.81, 0
21224, 2.175, 0.8, 0
21225, 2.1833333333333, 0.81, 0
21226, 2.1916666666667, 0.8, 0
21227, 1.2083333333333, 0.78, 0
21228, 1.2166666666667, 0.79, 0
21229, 1.225, 0.78, 0
21230, 1.2333333333333, 0.79, 0
21231, 1.2416666666667, 0.78, 0
21232, 1.25, 0.79, 0
21233, 1.2583333333333, 0.78, 0
21234, 1.2666666666667, 0.79, 0
21235, 1.275, 0.78, 0
21236, 1.2833333333333, 0.79, 0
21237, 1.2916666666667, 0.78, 0
21238, 1.3, 0.79, 0
21239, 1.3083333333333, 0.78, 0
21240, 1.3166666666667, 0.79, 0
21241, 1.325, 0.78, 0
21242, 1.3333333333333, 0.79, 0
21243, 1.3416666666667, 0.78, 0
21244, 1.35, 0.79, 0
21245, 1.3583333333333, 0.78, 0
21246, 1.3666666666667, 0.79, 0
21247, 1.375, 0.78, 0
21248, 1.3833333333333, 0.79, 0
21249, 1.3916666666667, 0.78, 0
21250, 1.4, 0.79, 0
21251, 1.4083333333333, 0.78, 0
21252, 1.4166666666667, 0.79, 0
21253, 1.425, 0.78, 0
21254, 1.4333333333333, 0.79, 0
21255, 1.4416666666667, 0.78, 0
21256, 1.45, 0.79, 0
21257, 1.4583333333333, 0.78, 0
21258, 1.4666666666667, 0.79, 0
21259, 1.475, 0.78, 0
21260, 1.4833333333333, 0.79, 0
21261, 1.4916666666667, 0.78, 0
21262, 1.5, 0.79, 0
21263, 1.5083333333333, 0.78, 0
21264, 1.5166666666667, 0.79, 0
21265, 1.525, 0.78, 0
21266, 1.5333333333333, 0.79, 0
21267, 1.5416666666667, 0.78, 0
21268, 1.55, 0.79, 0
21269, 1.5583333333333, 0.78, 0
21270, 1.5666666666667, 0.79, 0
21271, 1.575, 0.78, 0
21272, 1.5833333333333, 0.79, 0
21273, 1.5916666666667, 0.78, 0
21274, 1.6, 0.79, 0
21275, 1.6083333333333, 0.78, 0
21276, 1.6166666666667, 0.79, 0
21277, 1.625, 0.78, 0
21278, 1.6333333333333, 0.79, 0
21279, 1.6416666666667, 0.78, 0
21280, 1.65, 0.79, 0
21281, 1.6583333333333, 0.78, 0
21282, 1.6666666666667, 0.79, 0
21283, 1.675, 0.78, 0
21284, 1.6833333333333, 0.79, 0
21285, 1.6916666666667, 0.78, 0
21286, 1.7, 0.79, 0
21287, 1.7083333333333, 0.78, 0
21288, 1.7166666666667, 0.79, 0
21289, 1.725, 0.78, 0
21290, 1.7333333333333, 0.79, 0
21291, 1.7416666666667, 0.78, 0
21292, 1.75, 0.79, 0
21293, 1.7583333333333, 0.78, 0
21294, 1.7666666666667, 0.79, 0
21295, 1.775, 0.78, 0
21296, 1.7833333333333, 0.79, 0
21297, 1.7916666666667, 0.78, 0
21298, 1.8, 0.79, 0
21299, 1.8083333333333, 0.78, 0
21300, 1.8166666666667, 0.79, 0
21301, 1.825, 0.78, 0
21302, 1.8333333333333, 0.79, 0
21303, 1.8416666666667, 0.78, 0
21304, 1.85, 0.79, 0
21305, 1.8583333333333, 0.78, 0
21306, 1.8666666666667, 0.79, 0
21307, 1.875, 0.78, 0
21308, 1.8833333333333, 0.79, 0
21309, 1.8916666666667, 0.78, 0
21310, 1.9, 0.79, 0
21311, 1.9083333333333, 0.78, 0
21312, 1.9166666666667, 0.79, 0
21313, 1.925, 0.78, 0
21314, 1.9333333333333, 0.79, 0
21315, 1.9416666666667, 0.78, 0
21316, 1.95, 0.79, 0
21317, 1.9583333333333, 0.78, 0
21318, 1.9666666666667, 0.79, 0
21319, 1.975, 0.78, 0
21320, 1.9833333333333, 0.79, 0
21321, 1.9916666666667, 0.78, 0
21322, 2, 0.79, 0
21323, 2.0083333333333, 0.78, 0
21324, 2.0166666666667, 0.79, 0
21325, 2.025, 0.78, 0
21326, 2.0333333333333, 0.79, 0
21327, 2.0416666666667, 0.78, 0
21328, 2.05, 0.79, 0
21329, 2.0583333333333, 0.78, 0
21330, 2.0666666666667, 0.79, 0
21331, 2.075, 0.78, 0
21332, 2.0833333333333, 0.79, 0
21333, 2.0916666666667, 0.78, 0
21334, 2.1, 0.79, 0
21335, 2.1083333333333, 0.78, 0
21336, 2.1166666666667, 0.79, 0
21337, 2.125, 0.78, 0
21338, 2.1333333333333, 0.79, 0
21339, 2.1416666666667, 0.78, 0
21340, 2.15, 0.79, 0
21341, 2.1583333333333, 0.78, 0
21342, 2.1666666666667, 0.79, 0
21343, 2.175, 0.78, 0
21344, 2.1833333333333, 0.79, 0
21345, 2.1916666666667, 0.78, 0
21346, 1.2083333333333, 0.76, 0
21347, 1.2166666666667, 0.77, 0
21348, 1.225, 0.76, 0
21349, 1.2333333333333, 0.77, 0
21350, 1.2416666666667, 0.76, 0
21351, 1.25, 0.77, 0
21352, 1.2583333333333, 0.76, 0
21353, 1.2666666666667, 0.77, 0
21354, 1.275, 0.76, 0
21355, 1.2833333333333, 0.77, 0
21356, 1.2916666666667, 0.76, 0
21357, 1.3, 0.77, 0
21358, 1.3083333333333, 0.76, 0
21359, 1.3166666666667, 0.77, 0
21360, 1.325, 0.76, 0
21361, 1.3333333333333, 0.77, 0
21362, 1.3416666666667, 0.76, 0
21363, 1.35, 0.77, 0
21364, 1.3583333333333, 0.76, 0
21365, 1.3666666666667, 0.77, 0
21366, 1.375, 0.76, 0
21367, 1.3833333333333, 0.77, 0
21368, 1.3916666666667, 0.76, 0
21369, 1.4, 0.77, 0
21370, 1.4083333333333, 0.76, 0
21371, 1.4166666666667, 0.77, 0
21372, 1.425, 0.76, 0
21373, 1.4333333333333, 0.77, 0
21374, 1.4416666666667, 0.76, 0
21375, 1.45, 0.77, 0
21376, 1.4583333333333, 0.76, 0
21377, 1.4666666666667, 0.77, 0
21378, 1.475, 0.76, 0
21379, 1.4833333333333, 0.77, 0
21380, 1.4916666666667, 0.76, 0
21381, 1.5, 0.77, 0
21382, 1.5083333333333, 0.76, 0
21383, 1.5166666666667, 0.77, 0
21384, 1.525, 0.76, 0
21385, 1.5333333333333, 0.77, 0
21386, 1.5416666666667, 0.76, 0
21387, 1.55, 0.77, 0
21388, 1.5583333333333, 0.76, 0
21389, 1.5666666666667, 0.77, 0
21390, 1.575, 0.76, 0
21391, 1.5833333333333, 0.77, 0
21392, 1.5916666666667, 0.76, 0
21393, 1.6, 0.77, 0
21394, 1.6083333333333, 0.76, 0
21395, 1.6166666666667, 0.77, 0
21396, 1.625, 0.76, 0
21397, 1.6333333333333, 0.77, 0
21398, 1.6416666666667, 0.76, 0
21399, 1.65, 0.77, 0
21400, 1.6583333333333, 0.76, 0
21401, 1.6666666666667, 0.77, 0
21402, 1.675, 0.76, 0
21403, 1.6833333333333, 0.77, 0
21404, 1.6916666666667, 0.76, 0
21405, 1.7, 0.77, 0
21406, 1.7083333333333, 0.76, 0
21407, 1.7166666666667, 0.77, 0
21408, 1.725, 0.76, 0
21409, 1.7333333333333, 0.77, 0
21410, 1.7416666666667, 0.76, 0
21411, 1.75, 0.77, 0
21412, 1.7583333333333, 0.76, 0
21413, 1.7666666666667, 0.77, 0
21414, 1.775, 0.76, 0
21415, 1.7833333333333, 0.77, 0
21416, 1.7916666666667, 0.76, 0
21417, 1.8, 0.77, 0
21418, 1.8083333333333, 0.76, 0
21419, 1.8166666666667, 0.77, 0
21420, 1.825, 0.76, 0
21421, 1.8333333333333, 0.77, 0
21422, 1.8416666666667, 0.76, 0
21423, 1.85, 0.77, 0
21424, 1.8583333333333, 0.76, 0
21425, 1.8666666666667, 0.77, 0
21426, 1.875, 0.76, 0
21427, 1.8833333333333, 0.77, 0
21428, 1.8916666666667, 0.76, 0
21429, 1.9, 0.77, 0
21430, 1.9083333333333, 0.76, 0
21431, 1.9166666666667, 0.77, 0
21432, 1.925, 0.76, 0
21433, 1.9333333333333, 0.77, 0
21434, 1.9416666666667, 0.76, 0
21435, 1.95, 0.77, 0
21436, 1.9583333333333, 0.76, 0
21437, 1.9666666666667, 0.77, 0
21438, 1.975, 0.76, 0
21439, 1.9833333333333, 0.77, 0
21440, 1.9916666666667, 0.76, 0
21441, 2, 0.77, 0
21442, 2.0083333333333, 0.76, 0
21443, 2.0166666666667, 0.77, 0
21444, 2.025, 0.76, 0
21445, 2.0333333333333, 0.77, 0
21446, 2.0416666666667, 0.76, 0
21447, 2.05, 0.77, 0
21448, 2.0583333333333, 0.76, 0
21449, 2.0666666666667, 0.77, 0
21450, 2.075, 0.76, 0
21451, 2.0833333333333, 0.77, 0
21452, 2.0916666666667, 0.76, 0
21453, 2.1, 0.77, 0
21454, 2.1083333333333, 0.76, 0
21455, 2.1166666666667, 0.77, 0
21456, 2.125, 0.76, 0
21457, 2.1333333333333, 0.77, 0
21458, 2.1416666666667, 0.76, 0
21459, 2.15, 0.77, 0
21460, 2.1583333333333, 0.76, 0
21461, 2.1666666666667, 0.77, 0
21462, 2.175, 0.76, 0
21463, 2.1833333333333, 0.77, 0
21464, 2.1916666666667, 0.76, 0
21465, 1.2083333333333, 0.74, 0
21466, 1.2166666666667, 0.75, 0
21467, 1.225, 0.74, 0
21468, 1.2333333333333, 0.75, 0
21469, 1.2416666666667, 0.74, 0
21470, 1.25, 0.75, 0
21471, 1.2583333333333, 0.74, 0
21472, 1.2666666666667, 0.75, 0
21473, 1.275, 0.74, 0
21474, 1.2833333333333, 0.75, 0
21475, 1.2916666666667, 0.74, 0
21476, 1.3, 0.75, 0
21477, 1.3083333333333, 0.74, 0
21478, 1.3166666666667, 0.75, 0
21479, 1.325, 0.74, 0
21480, 1.3333333333333, 0.75, 0
21481, 1.3416666666667, 0.74, 0
21482, 1.35, 0.75, 0
21483, 1.3583333333333, 0.74, 0
21484, 1.3666666666667, 0.75, 0
21485, 1.375, 0.74, 0
21486, 1.3833333333333, 0.75, 0
21487, 1.3916666666667, 0.74, 0
21488, 1.4, 0.75, 0
21489, 1.4083333333333, 0.74, 0
21490, 1.4166666666667, 0.75, 0
21491, 1.425, 0.74, 0
21492, 1.4333333333333, 0.75, 0
21493, 1.4416666666667, 0.74, 0
21494, 1.45, 0.75, 0
21495, 1.4583333333333, 0.74, 0
21496, 1.4666666666667, 0.75, 0
21497, 1.475, 0.74, 0
21498, 1.4833333333333, 0.75, 0
21499, 1.4916666666667, 0.74, 0
21500, 1.5, 0.75, 0
21501, 1.5083333333333, 0.74, 0
21502, 1.5166666666667, 0.75, 0
21503, 1.525, 0.74, 0
21504, 1.5333333333333, 0.75, 0
21505, 1.5416666666667, 0.74, 0
21506, 1.55, 0.75, 0
21507, 1.5583333333333, 0.74, 0
21508, 1.5666666666667, 0.75, 0
21509, 1.575, 0.74, 0
21510, 1.5833333333333, 0.75, 0
21511, 1.5916666666667, 0.74, 0
21512, 1.6, 0.75, 0
21513, 1.6083333333333, 0.74, 0
21514, 1.6166666666667, 0.75, 0
21515, 1.625, 0.74, 0
21516, 1.6333333333333, 0.75, 0
21517, 1.6416666666667, 0.74, 0
21518, 1.65, 0.75, 0
21519, 1.6583333333333, 0.74, 0
21520, 1.6666666666667, 0.75, 0
21521, 1.675, 0.74, 0
21522, 1.6833333333333, 0.75, 0
21523, 1.6916666666667, 0.74, 0
21524, 1.7, 0.75, 0
21525, 1.7083333333333, 0.74, 0
21526, 1.7166666666667, 0.75, 0
21527, 1.725, 0.74, 0
21528, 1.7333333333333, 0.75, 0
21529, 1.7416666666667, 0.74, 0
21530, 1.75, 0.75, 0
21531, 1.7583333333333, 0.74, 0
21532, 1.7666666666667, 0.75, 0
21533, 1.775, 0.74, 0
21534, 1.7833333333333, 0.75, 0
21535, 1.7916666666667, 0.74, 0
21536, 1.8, 0.75, 0
21537, 1.8083333333333, 0.74, 0
21538, 1.8166666666667, 0.75, 0
21539, 1.825, 0.74, 0
21540, 1.8333333333333, 0.75, 0
21541, 1.8416666666667, 0.74, 0
21542, 1.85, 0.75, 0
21543, 1.8583333333333, 0.74, 0
21544, 1.8666666666667, 0.75, 0
21545, 1.875, 0.74, 0
21546, 1.8833333333333, 0.75, 0
21547, 1.8916666666667, 0.74, 0
21548, 1.9, 0.75, 0
21549, 1.9083333333333, 0.74, 0
21550, 1.9166666666667, 0.75, 0
21551, 1.925, 0.74, 0
21552, 1.9333333333333, 0.75, 0
21553, 1.9416666666667, 0.74, 0
21554, 1.95, 0.75, 0
21555, 1.9583333333333, 0.74, 0
21556, 1.9666666666667, 0.75, 0
21557, 1.975, 0.74, 0
21558, 1.9833333333333, 0.75, 0
21559, 1.9916666666667, 0.74, 0
21560, 2, 0.75, 0
21561, 2.0083333333333, 0.74, 0
21562, 2.0166666666667, 0.75, 0
21563, 2.025, 0.74, 0
21564, 2.0333333333333, 0.75, 0
21565, 2.0416666666667, 0.74, 0
21566, 2.05, 0.75, 0
21567, 2.0583333333333, 0.74, 0
21568, 2.0666666666667, 0.75, 0
21569, 2.075, 0.74, 0
21570, 2.0833333333333, 0.75, 0
21571, 2.0916666666667, 0.74, 0
21572, 2.1, 0.75, 0
21573, 2.1083333333333, 0.74, 0
21574, 2.1166666666667, 0.75, 0
21575, 2.125, 0.74, 0
21576, 2.1333333333333, 0.75, 0
21577, 2.1416666666667, 0.74, 0
21578, 2.15, 0.75, 0
21579, 2.1583333333333, 0.74, 0
21580, 2.1666666666667, 0.75, 0
21581, 2.175, 0.74, 0
21582, 2.1833333333333, 0.75, 0
21583, 2.1916666666667, 0.74, 0
21584, 1.2083333333333, 0.72, 0
21585, 1.2166666666667, 0.73, 0
21586, 1.225, 0.72, 0
21587, 1.2333333333333, 0.73, 0
21588, 1.2416666666667, 0.72, 0
21589, 1.25, 0.73, 0
21590, 1.2583333333333, 0.72, 0
21591, 1.2666666666667, 0.73, 0
21592, 1.275, 0.72, 0
21593, 1.2833333333333, 0.73, 0
21594, 1.2916666666667, 0.72, 0
21595, 1.3, 0.73, 0
21596, 1.3083333333333, 0.72, 0
21597, 1.3166666666667, 0.73, 0
21598, 1.325, 0.72, 0
21599, 1.3333333333333, 0.73, 0
21600, 1.3416666666667, 0.72, 0
21601, 1.35, 0.73, 0
21602, 1.3583333333333, 0.72, 0
21603, 1.3666666666667, 0.73, 0
21604, 1.375, 0.72, 0
21605, 1.3833333333333, 0.73, 0
21606, 1.3916666666667, 0.72, 0
21607, 1.4, 0.73, 0
21608, 1.4083333333333, 0.72, 0
21609, 1.4166666666667, 0.73, 0
21610, 1.425, 0.72, 0
21611, 1.4333333333333, 0.73, 0
21612, 1.4416666666667, 0.72, 0
21613, 1.45, 0.73, 0
21614, 1.4583333333333, 0.72, 0
21615, 1.4666666666667, 0.73, 0
21616, 1.475, 0.72, 0
21617, 1.4833333333333, 0.73, 0
21618, 1.4916666666667, 0.72, 0
21619, 1.5, 0.73, 0
21620, 1.5083333333333, 0.72, 0
21621, 1.5166666666667, 0.73, 0
21622, 1.525, 0.72, 0
21623, 1.5333333333333, 0.73, 0
21624, 1.5416666666667, 0.72, 0
21625, 1.55, 0.73, 0
21626, 1.5583333333333, 0.72, 0
21627, 1.5666666666667, 0.73, 0
21628, 1.575, 0.72, 0
21629, 1.5833333333333, 0.73, 0
21630, 1.5916666666667, 0.72, 0
21631, 1.6, 0.73, 0
21632, 1.6083333333333, 0.72, 0
21633, 1.6166666666667, 0.73, 0
21634, 1.625, 0.72, 0
21635, 1.6333333333333, 0.73, 0
21636, 1.6416666666667, 0.72, 0
21637, 1.65, 0.73, 0
21638, 1.6583333333333, 0.72, 0
21639, 1.6666666666667, 0.73, 0
21640, 1.675, 0.72, 0
21641, 1.6833333333333, 0.73, 0
21642, 1.6916666666667, 0.72, 0
21643, 1.7, 0.73, 0
21644, 1.7083333333333, 0.72, 0
21645, 1.7166666666667, 0.73, 0
21646, 1.725, 0.72, 0
21647, 1.7333333333333, 0.73, 0
21648, 1.7416666666667, 0.72, 0
21649, 1.75, 0.73, 0
21650, 1.7583333333333, 0.72, 0
21651, 1.7666666666667, 0.73, 0
21652, 1.775, 0.72, 0
21653, 1.7833333333333, 0.73, 0
21654, 1.7916666666667, 0.72, 0
21655, 1.8, 0.73, 0
21656, 1.8083333333333, 0.72, 0
21657, 1.8166666666667, 0.73, 0
21658, 1.825, 0.72, 0
21659, 1.8333333333333, 0.73, 0
21660, 1.8416666666667, 0.72, 0
21661, 1.85, 0.73, 0
21662, 1.8583333333333, 0.72, 0
21663, 1.8666666666667, 0.73, 0
21664, 1.875, 0.72, 0
21665, 1.8833333333333, 0.73, 0
21666, 1.8916666666667, 0.72, 0
21667, 1.9, 0.73, 0
21668, 1.9083333333333, 0.72, 0
21669, 1.9166666666667, 0.73, 0
21670, 1.925, 0.72, 0
21671, 1.9333333333333, 0.73, 0
21672, 1.9416666666667, 0.72, 0
21673, 1.95, 0.73, 0
21674, 1.9583333333333, 0.72, 0
21675, 1.9666666666667, 0.73, 0
21676, 1.975, 0.72, 0
21677, 1.9833333333333, 0.73, 0
21678, 1.9916666666667, 0.72, 0
21679, 2, 0.73, 0
21680, 2.0083333333333, 0.72, 0
21681, 2.0166666666667, 0.73, 0
21682, 2.025, 0.72, 0
21683, 2.0333333333333, 0.73, 0
21684, 2.0416666666667, 0.72, 0
21685, 2.05, 0.73, 0
21686, 2.0583333333333, 0.72, 0
21687, 2.0666666666667, 0.73, 0
21688, 2.075, 0.72, 0
21689, 2.0833333333333, 0.73, 0
21690, 2.0916666666667, 0.72, 0
21691, 2.1, 0.73, 0
21692, 2.1083333333333, 0.72, 0
21693, 2.1166666666667, 0.73, 0
21694, 2.125, 0.72, 0
21695, 2.1333333333333, 0.73, 0
21696, 2.1416666666667, 0.72, 0
21697, 2.15, 0.73, 0
21698, 2.1583333333333, 0.72, 0
21699, 2.1666666666667, 0.73, 0
21700, 2.175, 0.72, 0
21701, 2.1833333333333, 0.73, 0
21702, 2.1916666666667, 0.72, 0
21703, 1.2083333333333, 0.7, 0
21704, 1.2166666666667, 0.71, 0
21705, 1.225, 0.7, 0
21706, 1.2333333333333, 0.71, 0
21707, 1.2416666666667, 0.7, 0
21708, 1.25, 0.71, 0
21709, 1.2583333333333, 0.7, 0
21710, 1.2666666666667, 0.71, 0
21711, 1.275, 0.7, 0
21712, 1.2833333333333, 0.71, 0
21713, 1.2916666666667, 0.7, 0
21714, 1.3, 0.71, 0
21715, 1.3083333333333, 0.7, 0
21716, 1.3166666666667, 0.71, 0
21717, 1.325, 0.7, 0
21718, 1.3333333333333, 0.71, 0
21719, 1.3416666666667, 0.7, 0
21720, 1.35, 0.71, 0
21721, 1.3583333333333, 0.7, 0
21722, 1.3666666666667, 0.71, 0
21723, 1.375, 0.7, 0
21724, 1.3833333333333, 0.71, 0
21725, 1.3916666666667, 0.7, 0
21726, 1.4, 0.71, 0
21727, 1.4083333333333, 0.7, 0
21728, 1.4166666666667, 0.71, 0
21729, 1.425, 0.7, 0
21730, 1.4333333333333, 0.71, 0
21731, 1.4416666666667, 0.7, 0
21732, 1.45, 0.71, 0
21733, 1.4583333333333, 0.7, 0
21734, 1.4666666666667, 0.71, 0
21735, 1.475, 0.7, 0
21736, 1.4833333333333, 0.71, 0
21737, 1.4916666666667, 0.7, 0
21738, 1.5, 0.71, 0
21739, 1.5083333333333, 0.7, 0
21740, 1.5166666666667, 0.71, 0
21741, 1.525, 0.7, 0
21742, 1.5333333333333, 0.71, 0
21743, 1.5416666666667, 0.7, 0
21744, 1.55, 0.71, 0
21745, 1.5583333333333, 0.7, 0
21746, 1.5666666666667, 0.71, 0
21747, 1.575, 0.7, 0
21748, 1.5833333333333, 0.71, 0
21749, 1.5916666666667, 0.7, 0
21750, 1.6, 0.71, 0
21751, 1.6083333333333, 0.7, 0
21752, 1.6166666666667, 0.71, 0
21753, 1.625, 0.7, 0
21754, 1.6333333333333, 0.71, 0
21755, 1.6416666666667, 0.7, 0
21756, 1.65, 0.71, 0
21757, 1.6583333333333, 0.7, 0
21758, 1.6666666666667, 0.71, 0
21759, 1.675, 0.7, 0
21760, 1.6833333333333, 0.71, 0
21761, 1.6916666666667, 0.7, 0
21762, 1.7, 0.71, 0
21763, 1.7083333333333, 0.7, 0
21764, 1.7166666666667, 0.71, 0
21765, 1.725, 0.7, 0
21766, 1.7333333333333, 0.71, 0
21767, 1.7416666666667, 0.7, 0
21768, 1.75, 0.71, 0
21769, 1.7583333333333, 0.7, 0
21770, 1.7666666666667, 0.71, 0
21771, 1.775, 0.7, 0
21772, 1.7833333333333, 0.71, 0
21773, 1.7916666666667, 0.7, 0
21774, 1.8, 0.71, 0
21775, 1.8083333333333, 0.7, 0
21776, 1.8166666666667, 0.71, 0
21777, 1.825, 0.7, 0
21778, 1.8333333333333, 0.71, 0
21779, 1.8416666666667, 0.7, 0
21780, 1.85, 0.71, 0
21781, 1.8583333333333, 0.7, 0
21782, 1.8666666666667, 0.71, 0
21783, 1.875, 0.7, 0
21784, 1.8833333333333, 0.71, 0
21785, 1.8916666666667, 0.7, 0
21786, 1.9, 0.71, 0
21787, 1.9083333333333, 0.7, 0
21788, 1.9166666666667, 0.71, 0
21789, 1.925, 0.7, 0
21790, 1.9333333333333, 0.71, 0
21791, 1.9416666666667, 0.7, 0
21792, 1.95, 0.71, 0
21793, 1.9583333333333, 0.7, 0
21794, 1.9666666666667, 0.71, 0
21795, 1.975, 0.7, 0
21796, 1.9833333333333, 0.71, 0
21797, 1.9916666666667, 0.7, 0
21798, 2, 0.71, 0
21799, 2.0083333333333, 0.7, 0
21800, 2.0166666666667, 0.71, 0
21801, 2.025, 0.7, 0
21802, 2.0333333333333, 0.71, 0
21803, 2.0416666666667, 0.7, 0
21804, 2.05, 0.71, 0
21805, 2.0583333333333, 0.7, 0
21806, 2.0666666666667, 0.71, 0
21807, 2.075, 0.7, 0
21808, 2.0833333333333, 0.71, 0
21809, 2.0916666666667, 0.7, 0
21810, 2.1, 0.71, 0
21811, 2.1083333333333, 0.7, 0
21812, 2.1166666666667, 0.71, 0
21813, 2.125, 0.7, 0
21814, 2.1333333333333, 0.71, 0
21815, 2.1416666666667, 0.7, 0
21816, 2.15, 0.71, 0
21817, 2.1583333333333, 0.7, 0
21818, 2.1666666666667, 0.71, 0
21819, 2.175, 0.7, 0
21820, 2.1833333333333, 0.71, 0
21821, 2.1916666666667, 0.7, 0
21822, 1.2083333333333, 0.68, 0
21823, 1.2166666666667, 0.69, 0
21824, 1.225, 0.68, 0
21825, 1.2333333333333, 0.69, 0
21826, 1.2416666666667, 0.68, 0
21827, 1.25, 0.69, 0
21828, 1.2583333333333, 0.68, 0
21829, 1.2666666666667, 0.69, 0
21830, 1.275, 0.68, 0
21831, 1.2833333333333, 0.69, 0
21832, 1.2916666666667, 0.68, 0
21833, 1.3, 0.69, 0
21834, 1.3083333333333, 0.68, 0
21835, 1.3166666666667, 0.69, 0
21836, 1.325, 0.68, 0
21837, 1.3333333333333, 0.69, 0
21838, 1.3416666666667, 0.68, 0
21839, 1.35, 0.69, 0
21840, 1.3583333333333, 0.68, 0
21841, 1.3666666666667, 0.69, 0
21842, 1.375, 0.68, 0
21843, 1.3833333333333, 0.69, 0
21844, 1.3916666666667, 0.68, 0
21845, 1.4, 0.69, 0
21846, 1.4083333333333, 0.68, 0
21847, 1.4166666666667, 0.69, 0
21848, 1.425, 0.68, 0
21849, 1.4333333333333, 0.69, 0
21850, 1.4416666666667, 0.68, 0
21851, 1.45, 0.69, 0
21852, 1.4583333333333, 0.68, 0
21853, 1.4666666666667, 0.69, 0
21854, 1.475, 0.68, 0
21855, 1.4833333333333, 0.69, 0
21856, 1.4916666666667, 0.68, 0
21857, 1.5, 0.69, 0
21858, 1.5083333333333, 0.68, 0
21859, 1.5166666666667, 0.69, 0
21860, 1.525, 0.68, 0
21861, 1.5333333333333, 0.69, 0
21862, 1.5416666666667, 0.68, 0
21863, 1.55, 0.69, 0
21864, 1.5583333333333, 0.68, 0
21865, 1.5666666666667, 0.69, 0
21866, 1.575, 0.68, 0
21867, 1.5833333333333, 0.69, 0
21868, 1.5916666666667, 0.68, 0
21869, 1.6, 0.69, 0
21870, 1.6083333333333, 0.68, 0
21871, 1.6166666666667, 0.69, 0
21872, 1.625, 0.68, 0
21873, 1.6333333333333, 0.69, 0
21874, 1.6416666666667, 0.68, 0
21875, 1.65, 0.69, 0
21876, 1.6583333333333, 0.68, 0
21877, 1.6666666666667, 0.69, 0
21878, 1.675, 0.68, 0
21879, 1.6833333333333, 0.69, 0
21880, 1.6916666666667, 0.68, 0
21881, 1.7, 0.69, 0
21882, 1.7083333333333, 0.68, 0
21883, 1.7166666666667, 0.69, 0
21884, 1.725, 0.68, 0
21885, 1.7333333333333, 0.69, 0
21886, 1.7416666666667, 0.68, 0
21887, 1.75, 0.69, 0
21888, 1.7583333333333, 0.68, 0
21889, 1.7666666666667, 0.69, 0
21890, 1.775, 0.68, 0
21891, 1.7833333333333, 0.69, 0
21892, 1.7916666666667, 0.68, 0
21893, 1.8, 0.69, 0
21894, 1.8083333333333, 0.68, 0
21895, 1.8166666666667, 0.69, 0
21896, 1.825, 0.68, 0
21897, 1.8333333333333, 0.69, 0
21898, 1.8416666666667, 0.68, 0
21899, 1.85, 0.69, 0
21900, 1.8583333333333, 0.68, 0
21901, 1.8666666666667, 0.69, 0
21902, 1.875, 0.68, 0
21903, 1.8833333333333, 0.69, 0
21904, 1.8916666666667, 0.68, 0
21905, 1.9, 0.69, 0
21906, 1.9083333333333, 0.68, 0
21907, 1.9166666666667, 0.69, 0
21908, 1.925, 0.68, 0
21909, 1.9333333333333, 0.69, 0
21910, 1.9416666666667, 0.68, 0
21911, 1.95, 0.69, 0
21912, 1.9583333333333, 0.68, 0
21913, 1.9666666666667, 0.69, 0
21914, 1.975, 0.68, 0
21915, 1.9833333333333, 0.69, 0
21916, 1.9916666666667, 0.68, 0
21917, 2, 0.69, 0
21918, 2.0083333333333, 0.68, 0
21919, 2.0166666666667, 0.69, 0
21920, 2.025, 0.68, 0
21921, 2.0333333333333, 0.69, 0
21922, 2.0416666666667, 0.68, 0
21923, 2.05, 0.69, 0
21924, 2.0583333333333, 0.68, 0
21925, 2.0666666666667, 0.69, 0
21926, 2.075, 0.68, 0
21927, 2.0833333333333, 0.69, 0
21928, 2.0916666666667, 0.68, 0
21929, 2.1, 0.69, 0
21930, 2.1083333333333, 0.68, 0
21931, 2.1166666666667, 0.69, 0
21932, 2.125, 0.68, 0
21933, 2.1333333333333, 0.69, 0
21934, 2.1416666666667, 0.68, 0
21935, 2.15, 0.69, 0
21936, 2.1583333333333, 0.68, 0
21937, 2.1666666666667, 0.69, 0
21938, 2.175, 0.68, 0
21939, 2.1833333333333, 0.69, 0
21940, 2.1916666666667, 0.68, 0
21941, 1.2083333333333, 0.66, 0
21942, 1.2166666666667, 0.67, 0
21943, 1.225, 0.66, 0
21944, 1.2333333333333, 0.67, 0
21945, 1.2416666666667, 0.66, 0
21946, 1.25, 0.67, 0
21947, 1.2583333333333, 0.66, 0
21948, 1.2666666666667, 0.67, 0
21949, 1.275, 0.66, 0
21950, 1.2833333333333, 0.67, 0
21951, 1.2916666666667, 0.66, 0
21952, 1.3, 0.67, 0
21953, 1.3083333333333, 0.66, 0
21954, 1.3166666666667, 0.67, 0
21955, 1.325, 0.66, 0
21956, 1.3333333333333, 0.67, 0
21957, 1.3416666666667, 0.66, 0
21958, 1.35, 0.67, 0
21959, 1.3583333333333, 0.66, 0
21960, 1.3666666666667, 0.67, 0
21961, 1.375, 0.66, 0
21962, 1.3833333333333, 0.67, 0
21963, 1.3916666666667, 0.66, 0
21964, 1.4, 0.67, 0
21965, 1.4083333333333, 0.66, 0
21966, 1.4166666666667, 0.67, 0
21967, 1.425, 0.66, 0
21968, 1.4333333333333, 0.67, 0
21969, 1.4416666666667, 0.66, 0
21970, 1.45, 0.67, 0
21971, 1.4583333333333, 0.66, 0
21972, 1.4666666666667, 0.67, 0
21973, 1.475, 0.66, 0
21974, 1.4833333333333, 0.67, 0
21975, 1.4916666666667, 0.66, 0
21976, 1.5, 0.67, 0
21977, 1.5083333333333, 0.66, 0
21978, 1.5166666666667, 0.67, 0
21979, 1.525, 0.66, 0
21980, 1.5333333333333, 0.67, 0
21981, 1.5416666666667, 0.66, 0
21982, 1.55, 0.67, 0
21983, 1.5583333333333, 0.66, 0
21984, 1.5666666666667, 0.67, 0
21985, 1.575, 0.66, 0
21986, 1.5833333333333, 0.67, 0
21987, 1.5916666666667, 0.66, 0
21988, 1.6, 0.67, 0
21989, 1.6083333333333, 0.66, 0
21990, 1.6166666666667, 0.67, 0
21991, 1.625, 0.66, 0
21992, 1.6333333333333, 0.67, 0
21993, 1.6416666666667, 0.66, 0
21994, 1.65, 0.67, 0
21995, 1.6583333333333, 0.66, 0
21996, 1.6666666666667, 0.67, 0
21997, 1.675, 0.66, 0
21998, 1.6833333333333, 0.67, 0
21999, 1.6916666666667, 0.66, 0
22000, 1.7, 0.67, 0
22001, 1.7083333333333, 0.66, 0
22002, 1.7166666666667, 0.67, 0
22003, 1.725, 0.66, 0
22004, 1.7333333333333, 0.67, 0
22005, 1.7416666666667, 0.66, 0
22006, 1.75, 0.67, 0
22007, 1.7583333333333, 0.66, 0
22008, 1.7666666666667, 0.67, 0
22009, 1.775, 0.66, 0
22010, 1.7833333333333, 0.67, 0
22011, 1.7916666666667, 0.66, 0
22012, 1.8, 0.67, 0
22013, 1.8083333333333, 0.66, 0
22014, 1.8166666666667, 0.67, 0
22015, 1.825, 0.66, 0
22016, 1.8333333333333, 0.67, 0
22017, 1.8416666666667, 0.66, 0
22018, 1.85, 0.67, 0
22019, 1.8583333333333, 0.66, 0
22020, 1.8666666666667, 0.67, 0
22021, 1.875, 0.66, 0
22022, 1.8833333333333, 0.67, 0
22023, 1.8916666666667, 0.66, 0
22024, 1.9, 0.67, 0
22025, 1.9083333333333, 0.66, 0
22026, 1.9166666666667, 0.67, 0
22027, 1.925, 0.66, 0
22028, 1.9333333333333, 0.67, 0
22029, 1.9416666666667, 0.66, 0
22030, 1.95, 0.67, 0
22031, 1.9583333333333, 0.66, 0
22032, 1.9666666666667, 0.67, 0
22033, 1.975, 0.66, 0
22034, 1.9833333333333, 0.67, 0
22035, 1.9916666666667, 0.66, 0
22036, 2, 0.67, 0
22037, 2.0083333333333, 0.66, 0
22038, 2.0166666666667, 0.67, 0
22039, 2.025, 0.66, 0
22040, 2.0333333333333, 0.67, 0
22041, 2.0416666666667, 0.66, 0
22042, 2.05, 0.67, 0
22043, 2.0583333333333, 0.66, 0
22044, 2.0666666666667, 0.67, 0
22045, 2.075, 0.66, 0
22046, 2.0833333333333, 0.67, 0
22047, 2.0916666666667, 0.66, 0
22048, 2.1, 0.67, 0
22049, 2.1083333333333, 0.66, 0
22050, 2.1166666666667, 0.67, 0
22051, 2.125, 0.66, 0
22052, 2.1333333333333, 0.67, 0
22053, 2.1416666666667, 0.66, 0
22054, 2.15, 0.67, 0
22055, 2.1583333333333, 0.66, 0
22056, 2.1666666666667, 0.67, 0
22057, 2.175, 0.66, 0
22058, 2.1833333333333, 0.67, 0
22059, 2.1916666666667, 0.66, 0
22060, 1.2083333333333, 0.64, 0
22061, 1.2166666666667, 0.65, 0
22062, 1.225, 0.64, 0
22063, 1.2333333333333, 0.65, 0
22064, 1.2416666666667, 0.64, 0
22065, 1.25, 0.65, 0
22066, 1.2583333333333, 0.64, 0
22067, 1.2666666666667, 0.65, 0
22068, 1.275, 0.64, 0
22069, 1.2833333333333, 0.65, 0
22070, 1.2916666666667, 0.64, 0
22071, 1.3, 0.65, 0
22072, 1.3083333333333, 0.64, 0
22073, 1.3166666666667, 0.65, 0
22074, 1.325, 0.64, 0
22075, 1.3333333333333, 0.65, 0
22076, 1.3416666666667, 0.64, 0
22077, 1.35, 0.65, 0
22078, 1.3583333333333, 0.64, 0
22079, 1.3666666666667, 0.65, 0
22080, 1.375, 0.64, 0
22081, 1.3833333333333, 0.65, 0
22082, 1.3916666666667, 0.64, 0
22083, 1.4, 0.65, 0
22084, 1.4083333333333, 0.64, 0
22085, 1.4166666666667, 0.65, 0
22086, 1.425, 0.64, 0
22087, 1.4333333333333, 0.65, 0
22088, 1.4416666666667, 0.64, 0
22089, 1.45, 0.65, 0
22090, 1.4583333333333, 0.64, 0
22091, 1.4666666666667, 0.65, 0
22092, 1.475, 0.64, 0
22093, 1.4833333333333, 0.65, 0
22094, 1.4916666666667, 0.64, 0
22095, 1.5, 0.65, 0
22096, 1.5083333333333, 0.64, 0
22097, 1.5166666666667, 0.65, 0
22098, 1.525, 0.64, 0
22099, 1.5333333333333, 0.65, 0
22100, 1.5416666666667, 0.64, 0
22101, 1.55, 0.65, 0
22102, 1.5583333333333, 0.64, 0
22103, 1.5666666666667, 0.65, 0
22104, 1.575, 0.64, 0
22105, 1.5833333333333, 0.65, 0
22106, 1.5916666666667, 0.64, 0
22107, 1.6, 0.65, 0
22108, 1.6083333333333, 0.64, 0
22109, 1.6166666666667, 0.65, 0
22110, 1.625, 0.64, 0
22111, 1.6333333333333, 0.65, 0
22112, 1.6416666666667, 0.64, 0
22113, 1.65, 0.65, 0
22114, 1.6583333333333, 0.64, 0
22115, 1.6666666666667, 0.65, 0
22116, 1.675, 0.64, 0
22117, 1.6833333333333, 0.65, 0
22118, 1.6916666666667, 0.64, 0
22119, 1.7, 0.65, 0
22120, 1.7083333333333, 0.64, 0
22121, 1.7166666666667, 0.65, 0
22122, 1.725, 0.64, 0
22123, 1.7333333333333, 0.65, 0
22124, 1.7416666666667, 0.64, 0
22125, 1.75, 0.65, 0
22126, 1.7583333333333, 0.64, 0
22127, 1.7666666666667, 0.65, 0
22128, 1.775, 0.64, 0
22129, 1.7833333333333, 0.65, 0
22130, 1.7916666666667, 0.64, 0
22131, 1.8, 0.65, 0
22132, 1.8083333333333, 0.64, 0
22133, 1.8166666666667, 0.65, 0
22134, 1.825, 0.64, 0
22135, 1.8333333333333, 0.65, 0
22136, 1.8416666666667, 0.64, 0
22137, 1.85, 0.65, 0
22138, 1.8583333333333, 0.64, 0
22139, 1.8666666666667, 0.65, 0
22140, 1.875, 0.64, 0
22141, 1.8833333333333, 0.65, 0
22142, 1.8916666666667, 0.64, 0
22143, 1.9, 0.65, 0
22144, 1.9083333333333, 0.64, 0
22145, 1.9166666666667, 0.65, 0
22146, 1.925, 0.64, 0
22147, 1.9333333333333, 0.65, 0
22148, 1.9416666666667, 0.64, 0
22149, 1.95, 0.65, 0
22150, 1.9583333333333, 0.64, 0
22151, 1.9666666666667, 0.65, 0
22152, 1.975, 0.64, 0
22153, 1.9833333333333, 0.65, 0
22154, 1.9916666666667, 0.64, 0
22155, 2, 0.65, 0
22156, 2.0083333333333, 0.64, 0
22157, 2.0166666666667, 0.65, 0
22158, 2.025, 0.64, 0
22159, 2.0333333333333, 0.65, 0
22160, 2.0416666666667, 0.64, 0
22161, 2.05, 0.65, 0
22162, 2.0583333333333, 0.64, 0
22163, 2.0666666666667, 0.65, 0
22164, 2.075, 0.64, 0
22165, 2.0833333333333, 0.65, 0
22166, 2.0916666666667, 0.64, 0
22167, 2.1, 0.65, 0
22168, 2.1083333333333, 0.64, 0
22169, 2.1166666666667, 0.65, 0
22170, 2.125, 0.64, 0
22171, 2.1333333333333, 0.65, 0
22172, 2.1416666666667, 0.64, 0
22173, 2.15, 0.65, 0
22174, 2.1583333333333, 0.64, 0
22175, 2.1666666666667, 0.65, 0
22176, 2.175, 0.64, 0
22177, 2.1833333333333, 0.65, 0
22178, 2.1916666666667, 0.64, 0
22179, 1.2083333333333, 0.62, 0
22180, 1.2166666666667, 0.63, 0
22181, 1.225, 0.62, 0
22182, 1.2333333333333, 0.63, 0
22183, 1.2416666666667, 0.62, 0
22184, 1.25, 0.63, 0
22185, 1.2583333333333, 0.62, 0
22186, 1.2666666666667, 0.63, 0
22187, 1.275, 0.62, 0
22188, 1.2833333333333, 0.63, 0
22189, 1.2916666666667, 0.62, 0
22190, 1.3, 0.63, 0
22191, 1.3083333333333, 0.62, 0
22192, 1.3166666666667, 0.63, 0
22193, 1.325, 0.62, 0
22194, 1.3333333333333, 0.63, 0
22195, 1.3416666666667, 0.62, 0
22196, 1.35, 0.63, 0
22197, 1.3583333333333, 0.62, 0
22198, 1.3666666666667, 0.63, 0
22199, 1.375, 0.62, 0
22200, 1.3833333333333, 0.63, 0
22201, 1.3916666666667, 0.62, 0
22202, 1.4, 0.63, 0
22203, 1.4083333333333, 0.62, 0
22204, 1.4166666666667, 0.63, 0
22205, 1.425, 0.62, 0
22206, 1.4333333333333, 0.63, 0
22207, 1.4416666666667, 0.62, 0
22208, 1.45, 0.63, 0
22209, 1.4583333333333, 0.62, 0
22210, 1.4666666666667, 0.63, 0
22211, 1.475, 0.62, 0
22212, 1.4833333333333, 0.63, 0
22213, 1.4916666666667, 0.62, 0
22214, 1.5, 0.63, 0
22215, 1.5083333333333, 0.62, 0
22216, 1.5166666666667, 0.63, 0
22217, 1.525, 0.62, 0
22218, 1.5333333333333, 0.63, 0
22219, 1.5416666666667, 0.62, 0
22220, 1.55, 0.63, 0
22221, 1.5583333333333, 0.62, 0
22222, 1.5666666666667, 0.63, 0
22223, 1.575, 0.62, 0
22224, 1.5833333333333, 0.63, 0
22225, 1.5916666666667, 0.62, 0
22226, 1.6, 0.63, 0
22227, 1.6083333333333, 0.62, 0
22228, 1.6166666666667, 0.63, 0
22229, 1.625, 0.62, 0
22230, 1.6333333333333, 0.63, 0
22231, 1.6416666666667, 0.62, 0
22232, 1.65, 0.63, 0
22233, 1.6583333333333, 0.62, 0
22234, 1.6666666666667, 0.63, 0
22235, 1.675, 0.62, 0
22236, 1.6833333333333, 0.63, 0
22237, 1.6916666666667, 0.62, 0
22238, 1.7, 0.63, 0
22239, 1.7083333333333, 0.62, 0
22240, 1.7166666666667, 0.63, 0
22241, 1.725, 0.62, 0
22242, 1.7333333333333, 0.63, 0
22243, 1.7416666666667, 0.62, 0
22244, 1.75, 0.63, 0
22245, 1.7583333333333, 0.62, 0
22246, 1.7666666666667, 0.63, 0
22247, 1.775, 0.62, 0
22248, 1.7833333333333, 0.63, 0
22249, 1.7916666666667, 0.62, 0
22250, 1.8, 0.63, 0
22251, 1.8083333333333, 0.62, 0
22252, 1.8166666666667, 0.63, 0
22253, 1.825, 0.62, 0
22254, 1.8333333333333, 0.63, 0
22255, 1.8416666666667, 0.62, 0
22256, 1.85, 0.63, 0
22257, 1.8583333333333, 0.62, 0
22258, 1.8666666666667, 0.63, 0
22259, 1.875, 0.62, 0
22260, 1.8833333333333, 0.63, 0
22261, 1.8916666666667, 0.62, 0
22262, 1.9, 0.63, 0
22263, 1.9083333333333, 0.62, 0
22264, 1.9166666666667, 0.63, 0
22265, 1.925, 0.62, 0
22266, 1.9333333333333, 0.63, 0
22267, 1.9416666666667, 0.62, 0
22268, 1.95, 0.63, 0
22269, 1.9583333333333, 0.62, 0
22270, 1.9666666666667, 0.63, 0
22271, 1.975, 0.62, 0
22272, 1.9833333333333, 0.63, 0
22273, 1.9916666666667, 0.62, 0
22274, 2, 0.63, 0
22275, 2.0083333333333, 0.62, 0
22276, 2.0166666666667, 0.63, 0
22277, 2.025, 0.62, 0
22278, 2.0333333333333, 0.63, 0
22279, 2.0416666666667, 0.62, 0
22280, 2.05, 0.63, 0
22281, 2.0583333333333, 0.62, 0
22282, 2.0666666666667, 0.63, 0
22283, 2.075, 0.62, 0
22284, 2.0833333333333, 0.63, 0
22285, 2.0916666666667, 0.62, 0
22286, 2.1, 0.63, 0
22287, 2.1083333333333, 0.62, 0
22288, 2.1166666666667, 0.63, 0
22289, 2.125, 0.62, 0
22290, 2.1333333333333, 0.63, 0
22291, 2.1416666666667, 0.62, 0
22292, 2.15, 0.63, 0
22293, 2.1583333333333, 0.62, 0
22294, 2.1666666666667, 0.63, 0
22295, 2.175, 0.62, 0
22296, 2.1833333333333, 0.63, 0
22297, 2.1916666666667, 0.62, 0
22298, 1.2083333333333, 0.6, 0
22299, 1.2166666666667, 0.61, 0
22300, 1.225, 0.6, 0
22301, 1.2333333333333, 0.61, 0
22302, 1.2416666666667, 0.6, 0
22303, 1.25, 0.61, 0
22304, 1.2583333333333, 0.6, 0
22305, 1.2666666666667, 0.61, 0
22306, 1.275, 0.6, 0
22307, 1.2833333333333, 0.61, 0
22308, 1.2916666666667, 0.6, 0
22309, 1.3, 0.61, 0
22310, 1.3083333333333, 0.6, 0
22311, 1.3166666666667, 0.61, 0
22312, 1.325, 0.6, 0
22313, 1.3333333333333, 0.61, 0
22314, 1.3416666666667, 0.6, 0
22315, 1.35, 0.61, 0
22316, 1.3583333333333, 0.6, 0
22317, 1.3666666666667, 0.61, 0
22318, 1.375, 0.6, 0
22319, 1.3833333333333, 0.61, 0
22320, 1.3916666666667, 0.6, 0
22321, 1.4, 0.61, 0
22322, 1.4083333333333, 0.6, 0
22323, 1.4166666666667, 0.61, 0
22324, 1.425, 0.6, 0
22325, 1.4333333333333, 0.61, 0
22326, 1.4416666666667, 0.6, 0
22327, 1.45, 0.61, 0
22328, 1.4583333333333, 0.6, 0
22329, 1.4666666666667, 0.61, 0
22330, 1.475, 0.6, 0
22331, 1.4833333333333, 0.61, 0
22332, 1.4916666666667, 0.6, 0
22333, 1.5, 0.61, 0
22334, 1.5083333333333, 0.6, 0
22335, 1.5166666666667, 0.61, 0
22336, 1.525, 0.6, 0
22337, 1.5333333333333, 0.61, 0
22338, 1.5416666666667, 0.6, 0
22339, 1.55, 0.61, 0
22340, 1.5583333333333, 0.6, 0
22341, 1.5666666666667, 0.61, 0
22342, 1.575, 0.6, 0
22343, 1.5833333333333, 0.61, 0
22344, 1.5916666666667, 0.6, 0
22345, 1.6, 0.61, 0
22346, 1.6083333333333, 0.6, 0
22347, 1.6166666666667, 0.61, 0
22348, 1.625, 0.6, 0
22349, 1.6333333333333, 0.61, 0
22350, 1.6416666666667, 0.6, 0
22351, 1.65, 0.61, 0
22352, 1.6583333333333, 0.6, 0
22353, 1.6666666666667, 0.61, 0
22354, 1.675, 0.6, 0
22355, 1.6833333333333, 0.61, 0
22356, 1.6916666666667, 0.6, 0
22357, 1.7, 0.61, 0
22358, 1.7083333333333, 0.6, 0
22359, 1.7166666666667, 0.61, 0
22360, 1.725, 0.6, 0
22361, 1.7333333333333, 0.61, 0
22362, 1.7416666666667, 0.6, 0
22363, 1.75, 0.61, 0
22364, 1.7583333333333, 0.6, 0
22365, 1.7666666666667, 0.61, 0
22366, 1.775, 0.6, 0
22367, 1.7833333333333, 0.61, 0
22368, 1.7916666666667, 0.6, 0
22369, 1.8, 0.61, 0
22370, 1.8083333333333, 0.6, 0
22371, 1.8166666666667, 0.61, 0
22372, 1.825, 0.6, 0
22373, 1.8333333333333, 0.61, 0
22374, 1.8416666666667, 0.6, 0
22375, 1.85, 0.61, 0
22376, 1.8583333333333, 0.6, 0
22377, 1.8666666666667, 0.61, 0
22378, 1.875, 0.6, 0
22379, 1.8833333333333, 0.61, 0
22380, 1.8916666666667, 0.6, 0
22381, 1.9, 0.61, 0
22382, 1.9083333333333, 0.6, 0
22383, 1.9166666666667, 0.61, 0
22384, 1.925, 0.6, 0
22385, 1.9333333333333, 0.61, 0
22386, 1.9416666666667, 0.6, 0
22387, 1.95, 0.61, 0
22388, 1.9583333333333, 0.6, 0
22389, 1.9666666666667, 0.61, 0
22390, 1.975, 0.6, 0
22391, 1.9833333333333, 0.61, 0
22392, 1.9916666666667, 0.6, 0
22393, 2, 0.61, 0
22394, 2.0083333333333, 0.6, 0
22395, 2.0166666666667, 0.61, 0
22396, 2.025, 0.6, 0
22397, 2.0333333333333, 0.61, 0
22398, 2.0416666666667, 0.6, 0
22399, 2.05, 0.61, 0
22400, 2.0583333333333, 0.6, 0
22401, 2.0666666666667, 0.61, 0
22402, 2.075, 0.6, 0
22403, 2.0833333333333, 0.61, 0
22404, 2.0916666666667, 0.6, 0
22405, 2.1, 0.61, 0
22406, 2.1083333333333, 0.6, 0
22407, 2.1166666666667, 0.61, 0
22408, 2.125, 0.6, 0
22409, 2.1333333333333, 0.61, 0
22410, 2.1416666666667, 0.6, 0
22411, 2.15, 0.61, 0
22412, 2.1583333333333, 0.6, 0
22413, 2.1666666666667, 0.61, 0
22414, 2.175, 0.6, 0
22415, 2.1833333333333, 0.61, 0
22416, 2.1916666666667, 0.6, 0
22417, 1.2083333333333, 0.58, 0
22418, 1.2166666666667, 0.59, 0
22419, 1.225, 0.58, 0
22420, 1.2333333333333, 0.59, 0
22421, 1.2416666666667, 0.58, 0
22422, 1.25, 0.59, 0
22423, 1.2583333333333, 0.58, 0
22424, 1.2666666666667, 0.59, 0
22425, 1.275, 0.58, 0
22426, 1.2833333333333, 0.59, 0
22427, 1.2916666666667, 0.58, 0
22428, 1.3, 0.59, 0
22429, 1.3083333333333, 0.58, 0
22430, 1.3166666666667, 0.59, 0
22431, 1.325, 0.58, 0
22432, 1.3333333333333, 0.59, 0
22433, 1.3416666666667, 0.58, 0
22434, 1.35, 0.59, 0
22435, 1.3583333333333, 0.58, 0
22436, 1.3666666666667, 0.59, 0
22437, 1.375, 0.58, 0
22438, 1.3833333333333, 0.59, 0
22439, 1.3916666666667, 0.58, 0
22440, 1.4, 0.59, 0
22441, 1.4083333333333, 0.58, 0
22442, 1.4166666666667, 0.59, 0
22443, 1.425, 0.58, 0
22444, 1.4333333333333, 0.59, 0
22445, 1.4416666666667, 0.58, 0
22446, 1.45, 0.59, 0
22447, 1.4583333333333, 0.58, 0
22448, 1.4666666666667, 0.59, 0
22449, 1.475, 0.58, 0
22450, 1.4833333333333, 0.59, 0
22451, 1.4916666666667, 0.58, 0
22452, 1.5, 0.59, 0
22453, 1.5083333333333, 0.58, 0
22454, 1.5166666666667, 0.59, 0
22455, 1.525, 0.58, 0
22456, 1.5333333333333, 0.59, 0
22457, 1.5416666666667, 0.58, 0
22458, 1.55, 0.59, 0
22459, 1.5583333333333, 0.58, 0
22460, 1.5666666666667, 0.59, 0
22461, 1.575, 0.58, 0
22462, 1.5833333333333, 0.59, 0
22463, 1.5916666666667, 0.58, 0
22464, 1.6, 0.59, 0
22465, 1.6083333333333, 0.58, 0
22466, 1.6166666666667, 0.59, 0
22467, 1.625, 0.58, 0
22468, 1.6333333333333, 0.59, 0
22469, 1.6416666666667, 0.58, 0
22470, 1.65, 0.59, 0
22471, 1.6583333333333, 0.58, 0
22472, 1.6666666666667, 0.59, 0
22473, 1.675, 0.58, 0
22474, 1.6833333333333, 0.59, 0
22475, 1.6916666666667, 0.58, 0
22476, 1.7, 0.59, 0
22477, 1.7083333333333, 0.58, 0
22478, 1.7166666666667, 0.59, 0
22479, 1.725, 0.58, 0
22480, 1.7333333333333, 0.59, 0
22481, 1.7416666666667, 0.58, 0
22482, 1.75, 0.59, 0
22483, 1.7583333333333, 0.58, 0
22484, 1.7666666666667, 0.59, 0
22485, 1.775, 0.58, 0
22486, 1.7833333333333, 0.59, 0
22487, 1.7916666666667, 0.58, 0
22488, 1.8, 0.59, 0
22489, 1.8083333333333, 0.58, 0
22490, 1.8166666666667, 0.59, 0
22491, 1.825, 0.58, 0
22492, 1.8333333333333, 0.59, 0
22493, 1.8416666666667, 0.58, 0
22494, 1.85, 0.59, 0
22495, 1.8583333333333, 0.58, 0
22496, 1.8666666666667, 0.59, 0
22497, 1.875, 0.58, 0
22498, 1.8833333333333, 0.59, 0
22499, 1.8916666666667, 0.58, 0
22500, 1.9, 0.59, 0
22501, 1.9083333333333, 0.58, 0
22502, 1.9166666666667, 0.59, 0
22503, 1.925, 0.58, 0
22504, 1.9333333333333, 0.59, 0
22505, 1.9416666666667, 0.58, 0
22506, 1.95, 0.59, 0
22507, 1.9583333333333, 0.58, 0
22508, 1.9666666666667, 0.59, 0
22509, 1.975, 0.58, 0
22510, 1.9833333333333, 0.59, 0
22511, 1.9916666666667, 0.58, 0
22512, 2, 0.59, 0
22513, 2.0083333333333, 0.58, 0
22514, 2.0166666666667, 0.59, 0
22515, 2.025, 0.58, 0
22516, 2.0333333333333, 0.59, 0
22517, 2.0416666666667, 0.58, 0
22518, 2.05, 0.59, 0
22519, 2.0583333333333, 0.58, 0
22520, 2.0666666666667, 0.59, 0
22521, 2.075, 0.58, 0
22522, 2.0833333333333, 0.59, 0
22523, 2.0916666666667, 0.58, 0
22524, 2.1, 0.59, 0
22525, 2.1083333333333, 0.58, 0
22526, 2.1166666666667, 0.59, 0
22527, 2.125, 0.58, 0
22528, 2.1333333333333, 0.59, 0
22529, 2.1416666666667, 0.58, 0
22530, 2.15, 0.59, 0
22531, 2.1583333333333, 0.58, 0
22532, 2.1666666666667, 0.59, 0
22533, 2.175, 0.58, 0
22534, 2.1833333333333, 0.59, 0
22535, 2.1916666666667, 0.58, 0
22536, 1.2083333333333, 0.56, 0
22537, 1.2166666666667, 0.57, 0
22538, 1.225, 0.56, 0
22539, 1.2333333333333, 0.57, 0
22540, 1.2416666666667, 0.56, 0
22541, 1.25, 0.57, 0
22542, 1.2583333333333, 0.56, 0
22543, 1.2666666666667, 0.57, 0
22544, 1.275, 0.56, 0
22545, 1.2833333333333, 0.57, 0
22546, 1.2916666666667, 0.56, 0
22547, 1.3, 0.57, 0
22548, 1.3083333333333, 0.56, 0
22549, 1.3166666666667, 0.57, 0
22550, 1.325, 0.56, 0
22551, 1.3333333333333, 0.57, 0
22552, 1.3416666666667, 0.56, 0
22553, 1.35, 0.57, 0
22554, 1.3583333333333, 0.56, 0
22555, 1.3666666666667, 0.57, 0
22556, 1.375, 0.56, 0
22557, 1.3833333333333, 0.57, 0
22558, 1.3916666666667, 0.56, 0
22559, 1.4, 0.57, 0
22560, 1.4083333333333, 0.56, 0
22561, 1.4166666666667, 0.57, 0
22562, 1.425, 0.56, 0
22563, 1.4333333333333, 0.57, 0
22564, 1.4416666666667, 0.56, 0
22565, 1.45, 0.57, 0
22566, 1.4583333333333, 0.56, 0
22567, 1.4666666666667, 0.57, 0
22568, 1.475, 0.56, 0
22569, 1.4833333333333, 0.57, 0
22570, 1.4916666666667, 0.56, 0
22571, 1.5, 0.57, 0
22572, 1.5083333333333, 0.56, 0
22573, 1.5166666666667, 0.57, 0
22574, 1.525, 0.56, 0
22575, 1.5333333333333, 0.57, 0
22576, 1.5416666666667, 0.56, 0
22577, 1.55, 0.57, 0
22578, 1.5583333333333, 0.56, 0
22579, 1.5666666666667, 0.57, 0
22580, 1.575, 0.56, 0
22581, 1.5833333333333, 0.57, 0
22582, 1.5916666666667, 0.56, 0
22583, 1.6, 0.57, 0
22584, 1.6083333333333, 0.56, 0
22585, 1.6166666666667, 0.57, 0
22586, 1.625, 0.56, 0
22587, 1.6333333333333, 0.57, 0
22588, 1.6416666666667, 0.56, 0
22589, 1.65, 0.57, 0
22590, 1.6583333333333, 0.56, 0
22591, 1.6666666666667, 0.57, 0
22592, 1.675, 0.56, 0
22593, 1.6833333333333, 0.57, 0
22594, 1.6916666666667, 0.56, 0
22595, 1.7, 0.57, 0
22596, 1.7083333333333, 0.56, 0
22597, 1.7166666666667, 0.57, 0
22598, 1.725, 0.56, 0
22599, 1.7333333333333, 0.57, 0
22600, 1.7416666666667, 0.56, 0
22601, 1.75, 0.57, 0
22602, 1.7583333333333, 0.56, 0
22603, 1.7666666666667, 0.57, 0
22604, 1.775, 0.56, 0
22605, 1.7833333333333, 0.57, 0
22606, 1.7916666666667, 0.56, 0
22607, 1.8, 0.57, 0
22608, 1.8083333333333, 0.56, 0
22609, 1.8166666666667, 0.57, 0
22610, 1.825, 0.56, 0
22611, 1.8333333333333, 0.57, 0
22612, 1.8416666666667, 0.56, 0
22613, 1.85, 0.57, 0
22614, 1.8583333333333, 0.56, 0
22615, 1.8666666666667, 0.57, 0
22616, 1.875, 0.56, 0
22617, 1.8833333333333, 0.57, 0
22618, 1.8916666666667, 0.56, 0
22619, 1.9, 0.57, 0
22620, 1.9083333333333, 0.56, 0
22621, 1.9166666666667, 0.57, 0
22622, 1.925, 0.56, 0
22623, 1.9333333333333, 0.57, 0
22624, 1.9416666666667, 0.56, 0
22625, 1.95, 0.57, 0
22626, 1.9583333333333, 0.56, 0
22627, 1.9666666666667, 0.57, 0
22628, 1.975, 0.56, 0
22629, 1.9833333333333, 0.57, 0
22630, 1.9916666666667, 0.56, 0
22631, 2, 0.57, 0
22632, 2.0083333333333, 0.56, 0
22633, 2.0166666666667, 0.57, 0
22634, 2.025, 0.56, 0
22635, 2.0333333333333, 0.57, 0
22636, 2.0416666666667, 0.56, 0
22637, 2.05, 0.57, 0
22638, 2.0583333333333, 0.56, 0
22639, 2.0666666666667, 0.57, 0
22640, 2.075, 0.56, 0
22641, 2.0833333333333, 0.57, 0
22642, 2.0916666666667, 0.56, 0
22643, 2.1, 0.57, 0
22644, 2.1083333333333, 0.56, 0
22645, 2.1166666666667, 0.57, 0
22646, 2.125, 0.56, 0
22647, 2.1333333333333, 0.57, 0
22648, 2.1416666666667, 0.56, 0
22649, 2.15, 0.57, 0
22650, 2.1583333333333, 0.56, 0
22651, 2.1666666666667, 0.57, 0
22652, 2.175, 0.56, 0
22653, 2.1833333333333, 0.57, 0
22654, 2.1916666666667, 0.56, 0
22655, 1.2083333333333, 0.54, 0
22656, 1.2166666666667, 0.55, 0
22657, 1.225, 0.54, 0
22658, 1.2333333333333, 0.55, 0
22659, 1.2416666666667, 0.54, 0
22660, 1.25, 0.55, 0
22661, 1.2583333333333, 0.54, 0
22662, 1.2666666666667, 0.55, 0
22663, 1.275, 0.54, 0
22664, 1.2833333333333, 0.55, 0
22665, 1.2916666666667, 0.54, 0
22666, 1.3, 0.55, 0
22667, 1.3083333333333, 0.54, 0
22668, 1.3166666666667, 0.55, 0
22669, 1.325, 0.54, 0
22670, 1.3333333333333, 0.55, 0
22671, 1.3416666666667, 0.54, 0
22672, 1.35, 0.55, 0
22673, 1.3583333333333, 0.54, 0
22674, 1.3666666666667, 0.55, 0
22675, 1.375, 0.54, 0
22676, 1.3833333333333, 0.55, 0
22677, 1.3916666666667, 0.54, 0
22678, 1.4, 0.55, 0
22679, 1.4083333333333, 0.54, 0
22680, 1.4166666666667, 0.55, 0
22681, 1.425, 0.54, 0
22682, 1.4333333333333, 0.55, 0
22683, 1.4416666666667, 0.54, 0
22684, 1.45, 0.55, 0
22685, 1.4583333333333, 0.54, 0
22686, 1.4666666666667, 0.55, 0
22687, 1.475, 0.54, 0
22688, 1.4833333333333, 0.55, 0
22689, 1.4916666666667, 0.54, 0
22690, 1.5, 0.55, 0
22691, 1.5083333333333, 0.54, 0
22692, 1.5166666666667, 0.55, 0
22693, 1.525, 0.54, 0
22694, 1.5333333333333, 0.55, 0
22695, 1.5416666666667, 0.54, 0
22696, 1.55, 0.55, 0
22697, 1.5583333333333, 0.54, 0
22698, 1.5666666666667, 0.55, 0
22699, 1.575, 0.54, 0
22700, 1.5833333333333, 0.55, 0
22701, 1.5916666666667, 0.54, 0
22702, 1.6, 0.55, 0
22703, 1.6083333333333, 0.54, 0
22704, 1.6166666666667, 0.55, 0
22705, 1.625, 0.54, 0
22706, 1.6333333333333, 0.55, 0
22707, 1.6416666666667, 0.54, 0
22708, 1.65, 0.55, 0
22709, 1.6583333333333, 0.54, 0
22710, 1.6666666666667, 0.55, 0
22711, 1.675, 0.54, 0
22712, 1.6833333333333, 0.55, 0
22713, 1.6916666666667, 0.54, 0
22714, 1.7, 0.55, 0
22715, 1.7083333333333, 0.54, 0
22716, 1.7166666666667, 0.55, 0
22717, 1.725, 0.54, 0
22718, 1.7333333333333, 0.55, 0
22719, 1.7416666666667, 0.54, 0
22720, 1.75, 0.55, 0
22721, 1.7583333333333, 0.54, 0
22722, 1.7666666666667, 0.55, 0
22723, 1.775, 0.54, 0
22724, 1.7833333333333, 0.55, 0
22725, 1.7916666666667, 0.54, 0
22726, 1.8, 0.55, 0
22727, 1.8083333333333, 0.54, 0
22728, 1.8166666666667, 0.55, 0
22729, 1.825, 0.54, 0
22730, 1.8333333333333, 0.55, 0
22731, 1.8416666666667, 0.54, 0
22732, 1.85, 0.55, 0
22733, 1.8583333333333, 0.54, 0
22734, 1.8666666666667, 0.55, 0
22735, 1.875, 0.54, 0
22736, 1.8833333333333, 0.55, 0
22737, 1.8916666666667, 0.54, 0
22738, 1.9, 0.55, 0
22739, 1.9083333333333, 0.54, 0
22740, 1.9166666666667, 0.55, 0
22741, 1.925, 0.54, 0
22742, 1.9333333333333, 0.55, 0
22743, 1.9416666666667, 0.54, 0
22744, 1.95, 0.55, 0
22745, 1.9583333333333, 0.54, 0
22746, 1.9666666666667, 0.55, 0
22747, 1.975, 0.54, 0
22748, 1.9833333333333, 0.55, 0
22749, 1.9916666666667, 0.54, 0
22750, 2, 0.55, 0
22751, 2.0083333333333, 0.54, 0
22752, 2.0166666666667, 0.55, 0
22753, 2.025, 0.54, 0
22754, 2.0333333333333, 0.55, 0
22755, 2.0416666666667, 0.54, 0
22756, 2.05, 0.55, 0
22757, 2.0583333333333, 0.54, 0
22758, 2.0666666666667, 0.55, 0
22759, 2.075, 0.54, 0
22760, 2.0833333333333, 0.55, 0
22761, 2.0916666666667, 0.54, 0
22762, 2.1, 0.55, 0
22763, 2.1083333333333, 0.54, 0
22764, 2.1166666666667, 0.55, 0
22765, 2.125, 0.54, 0
22766, 2.1333333333333, 0.55, 0
22767, 2.1416666666667, 0.54, 0
22768, 2.15, 0.55, 0
22769, 2.1583333333333, 0.54, 0
22770, 2.1666666666667, 0.55, 0
22771, 2.175, 0.54, 0
22772, 2.1833333333333, 0.55, 0
22773, 2.1916666666667, 0.54, 0
22774, 1.2083333333333, 0.52, 0
22775, 1.2166666666667, 0.53, 0
22776, 1.225, 0.52, 0
22777, 1.2333333333333, 0.53, 0
22778, 1.2416666666667, 0.52, 0
22779, 1.25, 0.53, 0
22780, 1.2583333333333, 0.52, 0
22781, 1.2666666666667, 0.53, 0
22782, 1.275, 0.52, 0
22783, 1.2833333333333, 0.53, 0
22784, 1.2916666666667, 0.52, 0
22785, 1.3, 0.53, 0
22786, 1.3083333333333, 0.52, 0
22787, 1.3166666666667, 0.53, 0
22788, 1.325, 0.52, 0
22789, 1.3333333333333, 0.53, 0
22790, 1.3416666666667, 0.52, 0
22791, 1.35, 0.53, 0
22792, 1.3583333333333, 0.52, 0
22793, 1.3666666666667, 0.53, 0
22794, 1.375, 0.52, 0
22795, 1.3833333333333, 0.53, 0
22796, 1.3916666666667, 0.52, 0
22797, 1.4, 0.53, 0
22798, 1.4083333333333, 0.52, 0
22799, 1.4166666666667, 0.53, 0
22800, 1.425, 0.52, 0
22801, 1.4333333333333, 0.53, 0
22802, 1.4416666666667, 0.52, 0
22803, 1.45, 0.53, 0
22804, 1.4583333333333, 0.52, 0
22805, 1.4666666666667, 0.53, 0
22806, 1.475, 0.52, 0
22807, 1.4833333333333, 0.53, 0
22808, 1.4916666666667, 0.52, 0
22809, 1.5, 0.53, 0
22810, 1.5083333333333, 0.52, 0
22811, 1.5166666666667, 0.53, 0
22812, 1.525, 0.52, 0
22813, 1.5333333333333, 0.53, 0
22814, 1.5416666666667, 0.52, 0
22815, 1.55, 0.53, 0
22816, 1.5583333333333, 0.52, 0
22817, 1.5666666666667, 0.53, 0
22818, 1.575, 0.52, 0
22819, 1.5833333333333, 0.53, 0
22820, 1.5916666666667, 0.52, 0
22821, 1.6, 0.53, 0
22822, 1.6083333333333, 0.52, 0
22823, 1.6166666666667, 0.53, 0
22824, 1.625, 0.52, 0
22825, 1.6333333333333, 0.53, 0
22826, 1.6416666666667, 0.52, 0
22827, 1.65, 0.53, 0
22828, 1.6583333333333, 0.52, 0
22829, 1.6666666666667, 0.53, 0
22830, 1.675, 0.52, 0
22831, 1.6833333333333, 0.53, 0
22832, 1.6916666666667, 0.52, 0
22833, 1.7, 0.53, 0
22834, 1.7083333333333, 0.52, 0
22835, 1.7166666666667, 0.53, 0
22836, 1.725, 0.52, 0
22837, 1.7333333333333, 0.53, 0
22838, 1.7416666666667, 0.52, 0
22839, 1.75, 0.53, 0
22840, 1.7583333333333, 0.52, 0
22841, 1.7666666666667, 0.53, 0
22842, 1.775, 0.52, 0
22843, 1.7833333333333, 0.53, 0
22844, 1.7916666666667, 0.52, 0
22845, 1.8, 0.53, 0
22846, 1.8083333333333, 0.52, 0
22847, 1.8166666666667, 0.53, 0
22848, 1.825, 0.52, 0
22849, 1.8333333333333, 0.53, 0
22850, 1.8416666666667, 0.52, 0
22851, 1.85, 0.53, 0
22852, 1.8583333333333, 0.52, 0
22853, 1.8666666666667, 0.53, 0
22854, 1.875, 0.52, 0
22855, 1.8833333333333, 0.53, 0
22856, 1.8916666666667, 0.52, 0
22857, 1.9, 0.53, 0
22858, 1.9083333333333, 0.52, 0
22859, 1.9166666666667, 0.53, 0
22860, 1.925, 0.52, 0
22861, 1.9333333333333, 0.53, 0
22862, 1.9416666666667, 0.52, 0
22863, 1.95, 0.53, 0
22864, 1.9583333333333, 0.52, 0
22865, 1.9666666666667, 0.53, 0
22866, 1.975, 0.52, 0
22867, 1.9833333333333, 0.53, 0
22868, 1.9916666666667, 0.52, 0
22869, 2, 0.53, 0
22870, 2.0083333333333, 0.52, 0
22871, 2.0166666666667, 0.53, 0
22872, 2.025, 0.52, 0
22873, 2.0333333333333, 0.53, 0
22874, 2.0416666666667, 0.52, 0
22875, 2.05, 0.53, 0
22876, 2.0583333333333, 0.52, 0
22877, 2.0666666666667, 0.53, 0
22878, 2.075, 0.52, 0
22879, 2.0833333333333, 0.53, 0
22880, 2.0916666666667, 0.52, 0
22881, 2.1, 0.53, 0
22882, 2.1083333333333, 0.52, 0
22883, 2.1166666666667, 0.53, 0
22884, 2.125, 0.52, 0
22885, 2.1333333333333, 0.53, 0
22886, 2.1416666666667, 0.52, 0
22887, 2.15, 0.53, 0
22888, 2.1583333333333, 0.52, 0
22889, 2.1666666666667, 0.53, 0
22890, 2.175, 0.52, 0
22891, 2.1833333333333, 0.53, 0
22892, 2.1916666666667, 0.52, 0
22893, 1.2083333333333, 0.5, 0
22894, 1.2166666666667, 0.51, 0
22895, 1.225, 0.5, 0
22896, 1.2333333333333, 0.51, 0
22897, 1.2416666666667, 0.5, 0
22898, 1.25, 0.51, 0
22899, 1.2583333333333, 0.5, 0
22900, 1.2666666666667, 0.51, 0
22901, 1.275, 0.5, 0
22902, 1.2833333333333, 0.51, 0
22903, 1.2916666666667, 0.5, 0
22904, 1.3, 0.51, 0
22905, 1.3083333333333, 0.5, 0
22906, 1.3166666666667, 0.51, 0
22907, 1.325, 0.5, 0
22908, 1.3333333333333, 0.51, 0
22909, 1.3416666666667, 0.5, 0
22910, 1.35, 0.51, 0
22911, 1.3583333333333, 0.5, 0
22912, 1.3666666666667, 0.51, 0
22913, 1.375, 0.5, 0
22914, 1.3833333333333, 0.51, 0
22915, 1.3916666666667, 0.5, 0
22916, 1.4, 0.51, 0
22917, 1.4083333333333, 0.5, 0
22918, 1.4166666666667, 0.51, 0
22919, 1.425, 0.5, 0
22920, 1.4333333333333, 0.51, 0
22921, 1.4416666666667, 0.5, 0
22922, 1.45, 0.51, 0
22923, 1.4583333333333, 0.5, 0
22924, 1.4666666666667, 0.51, 0
22925, 1.475, 0.5, 0
22926, 1.4833333333333, 0.51, 0
22927, 1.4916666666667, 0.5, 0
22928, 1.5, 0.51, 0
22929, 1.5083333333333, 0.5, 0
22930, 1.5166666666667, 0.51, 0
22931, 1.525, 0.5, 0
22932, 1.5333333333333, 0.51, 0
22933, 1.5416666666667, 0.5, 0
22934, 1.55, 0.51, 0
22935, 1.5583333333333, 0.5, 0
22936, 1.5666666666667, 0.51, 0
22937, 1.575, 0.5, 0
22938, 1.5833333333333, 0.51, 0
22939, 1.5916666666667, 0.5, 0
22940, 1.6, 0.51, 0
22941, 1.6083333333333, 0.5, 0
22942, 1.6166666666667, 0.51, 0
22943, 1.625, 0.5, 0
22944, 1.6333333333333, 0.51, 0
22945, 1.6416666666667, 0.5, 0
22946, 1.65, 0.51, 0
22947, 1.6583333333333, 0.5, 0
22948, 1.6666666666667, 0.51, 0
22949, 1.675, 0.5, 0
22950, 1.6833333333333, 0.51, 0
22951, 1.6916666666667, 0.5, 0
22952, 1.7, 0.51, 0
22953, 1.7083333333333, 0.5, 0
22954, 1.7166666666667, 0.51, 0
22955, 1.725, 0.5, 0
22956, 1.7333333333333, 0.51, 0
22957, 1.7416666666667, 0.5, 0
22958, 1.75, 0.51, 0
22959, 1.7583333333333, 0.5, 0
22960, 1.7666666666667, 0.51, 0
22961, 1.775, 0.5, 0
22962, 1.7833333333333, 0.51, 0
22963, 1.7916666666667, 0.5, 0
22964, 1.8, 0.51, 0
22965, 1.8083333333333, 0.5, 0
22966, 1.8166666666667, 0.51, 0
22967, 1.825, 0.5, 0
22968, 1.8333333333333, 0.51, 0
22969, 1.8416666666667, 0.5, 0
22970, 1.85, 0.51, 0
22971, 1.8583333333333, 0.5, 0
22972, 1.8666666666667, 0.51, 0
22973, 1.875, 0.5, 0
22974, 1.8833333333333, 0.51, 0
22975, 1.8916666666667, 0.5, 0
22976, 1.9, 0.51, 0
22977, 1.9083333333333, 0.5, 0
22978, 1.9166666666667, 0.51, 0
22979, 1.925, 0.5, 0
22980, 1.9333333333333, 0.51, 0
22981, 1.9416666666667, 0.5, 0
22982, 1.95, 0.51, 0
22983, 1.9583333333333, 0.5, 0
22984, 1.9666666666667, 0.51, 0
22985, 1.975, 0.5, 0
22986, 1.9833333333333, 0.51, 0
22987, 1.9916666666667, 0.5, 0
22988, 2, 0.51, 0
22989, 2.0083333333333, 0.5, 0
22990, 2.0166666666667, 0.51, 0
22991, 2.025, 0.5, 0
22992, 2.0333333333333, 0.51, 0
22993, 2.0416666666667, 0.5, 0
22994, 2.05, 0.51, 0
22995, 2.0583333333333, 0.5, 0
22996, 2.0666666666667, 0.51, 0
22997, 2.075, 0.5, 0
22998, 2.0833333333333, 0.51, 0
22999, 2.0916666666667, 0.5, 0
23000, 2.1, 0.51, 0
23001, 2.1083333333333, 0.5, 0
23002, 2.1166666666667, 0.51, 0
23003, 2.125, 0.5, 0
23004, 2.1333333333333, 0.51, 0
23005, 2.1416666666667, 0.5, 0
23006, 2.15, 0.51, 0
23007, 2.1583333333333, 0.5, 0
23008, 2.1666666666667, 0.51, 0
23009, 2.175, 0.5, 0
23010, 2.1833333333333, 0.51, 0
23011, 2.1916666666667, 0.5, 0
23012, 1.2083333333333, 0.48, 0
23013, 1.2166666666667, 0.49, 0
23014, 1.225, 0.48, 0
23015, 1.2333333333333, 0.49, 0
23016, 1.2416666666667, 0.48, 0
23017, 1.25, 0.49, 0
23018, 1.2583333333333, 0.48, 0
23019, 1.2666666666667, 0.49, 0
23020, 1.275, 0.48, 0
23021, 1.2833333333333, 0.49, 0
23022, 1.2916666666667, 0.48, 0
23023, 1.3, 0.49, 0
23024, 1.3083333333333, 0.48, 0
23025, 1.3166666666667, 0.49, 0
23026, 1.325, 0.48, 0
23027, 1.3333333333333, 0.49, 0
23028, 1.3416666666667, 0.48, 0
23029, 1.35, 0.49, 0
23030, 1.3583333333333, 0.48, 0
23031, 1.3666666666667, 0.49, 0
23032, 1.375, 0.48, 0
23033, 1.3833333333333, 0.49, 0
23034, 1.3916666666667, 0.48, 0
23035, 1.4, 0.49, 0
23036, 1.4083333333333, 0.48, 0
23037, 1.4166666666667, 0.49, 0
23038, 1.425, 0.48, 0
23039, 1.4333333333333, 0.49, 0
23040, 1.4416666666667, 0.48, 0
23041, 1.45, 0.49, 0
23042, 1.4583333333333, 0.48, 0
23043, 1.4666666666667, 0.49, 0
23044, 1.475, 0.48, 0
23045, 1.4833333333333, 0.49, 0
23046, 1.4916666666667, 0.48, 0
23047, 1.5, 0.49, 0
23048, 1.5083333333333, 0.48, 0
23049, 1.5166666666667, 0.49, 0
23050, 1.525, 0.48, 0
23051, 1.5333333333333, 0.49, 0
23052, 1.5416666666667, 0.48, 0
23053, 1.55, 0.49, 0
23054, 1.5583333333333, 0.48, 0
23055, 1.5666666666667, 0.49, 0
23056, 1.575, 0.48, 0
23057, 1.5833333333333, 0.49, 0
23058, 1.5916666666667, 0.48, 0
23059, 1.6, 0.49, 0
23060, 1.6083333333333, 0.48, 0
23061, 1.6166666666667, 0.49, 0
23062, 1.625, 0.48, 0
23063, 1.6333333333333, 0.49, 0
23064, 1.6416666666667, 0.48, 0
23065, 1.65, 0.49, 0
23066, 1.6583333333333, 0.48, 0
23067, 1.6666666666667, 0.49, 0
23068, 1.675, 0.48, 0
23069, 1.6833333333333, 0.49, 0
23070, 1.6916666666667, 0.48, 0
23071, 1.7, 0.49, 0
23072, 1.7083333333333, 0.48, 0
23073, 1.7166666666667, 0.49, 0
23074, 1.725, 0.48, 0
23075, 1.7333333333333, 0.49, 0
23076, 1.7416666666667, 0.48, 0
23077, 1.75, 0.49, 0
23078, 1.7583333333333, 0.48, 0
23079, 1.7666666666667, 0.49, 0
23080, 1.775, 0.48, 0
23081, 1.7833333333333, 0.49, 0
23082, 1.7916666666667, 0.48, 0
23083, 1.8, 0.49, 0
23084, 1.8083333333333, 0.48, 0
23085, 1.8166666666667, 0.49, 0
23086, 1.825, 0.48, 0
23087, 1.8333333333333, 0.49, 0
23088, 1.8416666666667, 0.48, 0
23089, 1.85, 0.49, 0
23090, 1.8583333333333, 0.48, 0
23091, 1.8666666666667, 0.49, 0
23092, 1.875, 0.48, 0
23093, 1.8833333333333, 0.49, 0
23094, 1.8916666666667, 0.48, 0
23095, 1.9, 0.49, 0
23096, 1.9083333333333, 0.48, 0
23097, 1.9166666666667, 0.49, 0
23098, 1.925, 0.48, 0
23099, 1.9333333333333, 0.49, 0
23100, 1.9416666666667, 0.48, 0
23101, 1.95, 0.49, 0
23102, 1.9583333333333, 0.48, 0
23103, 1.9666666666667, 0.49, 0
23104, 1.975, 0.48, 0
23105, 1.9833333333333, 0.49, 0
23106, 1.9916666666667, 0.48, 0
23107, 2, 0.49, 0
23108, 2.0083333333333, 0.48, 0
23109, 2.0166666666667, 0.49, 0
23110, 2.025, 0.48, 0
23111, 2.0333333333333, 0.49, 0
23112, 2.0416666666667, 0.48, 0
23113, 2.05, 0.49, 0
23114, 2.0583333333333, 0.48, 0
23115, 2.0666666666667, 0.49, 0
23116, 2.075, 0.48, 0
23117, 2.0833333333333, 0.49, 0
23118, 2.0916666666667, 0.48, 0
23119, 2.1, 0.49, 0
23120, 2.1083333333333, 0.48, 0
23121, 2.1166666666667, 0.49, 0
23122, 2.125, 0.48, 0
23123, 2.1333333333333, 0.49, 0
23124, 2.1416666666667, 0.48, 0
23125, 2.15, 0.49, 0
23126, 2.1583333333333, 0.48, 0
23127, 2.1666666666667, 0.49, 0
23128, 2.175, 0.48, 0
23129, 2.1833333333333, 0.49, 0
23130, 2.1916666666667, 0.48, 0
23131, 1.2083333333333, 0.46, 0
23132, 1.2166666666667, 0.47, 0
23133, 1.225, 0.46, 0
23134, 1.2333333333333, 0.47, 0
23135, 1.2416666666667, 0.46, 0
23136, 1.25, 0.47, 0
23137, 1.2583333333333, 0.46, 0
23138, 1.2666666666667, 0.47, 0
23139, 1.275, 0.46, 0
23140, 1.2833333333333, 0.47, 0
23141, 1.2916666666667, 0.46, 0
23142, 1.3, 0.47, 0
23143, 1.3083333333333, 0.46, 0
23144, 1.3166666666667, 0.47, 0
23145, 1.325, 0.46, 0
23146, 1.3333333333333, 0.47, 0
23147, 1.3416666666667, 0.46, 0
23148, 1.35, 0.47, 0
23149, 1.3583333333333, 0.46, 0
23150, 1.3666666666667, 0.47, 0
23151, 1.375, 0.46, 0
23152, 1.3833333333333, 0.47, 0
23153, 1.3916666666667, 0.46, 0
23154, 1.4, 0.47, 0
23155, 1.4083333333333, 0.46, 0
23156, 1.4166666666667, 0.47, 0
23157, 1.425, 0.46, 0
23158, 1.4333333333333, 0.47, 0
23159, 1.4416666666667, 0.46, 0
23160, 1.45, 0.47, 0
23161, 1.4583333333333, 0.46, 0
23162, 1.4666666666667, 0.47, 0
23163, 1.475, 0.46, 0
23164, 1.4833333333333, 0.47, 0
23165, 1.4916666666667, 0.46, 0
23166, 1.5, 0.47, 0
23167, 1.5083333333333, 0.46, 0
23168, 1.5166666666667, 0.47, 0
23169, 1.525, 0.46, 0
23170, 1.5333333333333, 0.47, 0
23171, 1.5416666666667, 0.46, 0
23172, 1.55, 0.47, 0
23173, 1.5583333333333, 0.46, 0
23174, 1.5666666666667, 0.47, 0
23175, 1.575, 0.46, 0
23176, 1.5833333333333, 0.47, 0
23177, 1.5916666666667, 0.46, 0
23178, 1.6, 0.47, 0
23179, 1.6083333333333, 0.46, 0
23180, 1.6166666666667, 0.47, 0
23181, 1.625, 0.46, 0
23182, 1.6333333333333, 0.47, 0
23183, 1.6416666666667, 0.46, 0
23184, 1.65, 0.47, 0
23185, 1.6583333333333, 0.46, 0
23186, 1.6666666666667, 0.47, 0
23187, 1.675, 0.46, 0
23188, 1.6833333333333, 0.47, 0
23189, 1.6916666666667, 0.46, 0
23190, 1.7, 0.47, 0
23191, 1.7083333333333, 0.46, 0
23192, 1.7166666666667, 0.47, 0
23193, 1.725, 0.46, 0
23194, 1.7333333333333, 0.47, 0
23195, 1.7416666666667, 0.46, 0
23196, 1.75, 0.47, 0
23197, 1.7583333333333, 0.46, 0
23198, 1.7666666666667, 0.47, 0
23199, 1.775, 0.46, 0
23200, 1.7833333333333, 0.47, 0
23201, 1.7916666666667, 0.46, 0
23202, 1.8, 0.47, 0
23203, 1.8083333333333, 0.46, 0
23204, 1.8166666666667, 0.47, 0
23205, 1.825, 0.46, 0
23206, 1.8333333333333, 0.47, 0
23207, 1.8416666666667, 0.46, 0
23208, 1.85, 0.47, 0
23209, 1.8583333333333, 0.46, 0
23210, 1.8666666666667, 0.47, 0
23211, 1.875, 0.46, 0
23212, 1.8833333333333, 0.47, 0
23213, 1.8916666666667, 0.46, 0
23214, 1.9, 0.47, 0
23215, 1.9083333333333, 0.46, 0
23216, 1.9166666666667, 0.47, 0
23217, 1.925, 0.46, 0
23218, 1.9333333333333, 0.47, 0
23219, 1.9416666666667, 0.46, 0
23220, 1.95, 0.47, 0
23221, 1.9583333333333, 0.46, 0
23222, 1.9666666666667, 0.47, 0
23223, 1.975, 0.46, 0
23224, 1.9833333333333, 0.47, 0
23225, 1.9916666666667, 0.46, 0
23226, 2, 0.47, 0
23227, 2.0083333333333, 0.46, 0
23228, 2.0166666666667, 0.47, 0
23229, 2.025, 0.46, 0
23230, 2.0333333333333, 0.47, 0
23231, 2.0416666666667, 0.46, 0
23232, 2.05, 0.47, 0
23233, 2.0583333333333, 0.46, 0
23234, 2.0666666666667, 0.47, 0
23235, 2.075, 0.46, 0
23236, 2.0833333333333, 0.47, 0
23237, 2.0916666666667, 0.46, 0
23238, 2.1, 0.47, 0
23239, 2.1083333333333, 0.46, 0
23240, 2.1166666666667, 0.47, 0
23241, 2.125, 0.46, 0
23242, 2.1333333333333, 0.47, 0
23243, 2.1416666666667, 0.46, 0
23244, 2.15, 0.47, 0
23245, 2.1583333333333, 0.46, 0
23246, 2.1666666666667, 0.47, 0
23247, 2.175, 0.46, 0
23248, 2.1833333333333, 0.47, 0
23249, 2.1916666666667, 0.46, 0
23250, 1.2083333333333, 0.44, 0
23251, 1.2166666666667, 0.45, 0
23252, 1.225, 0.44, 0
23253, 1.2333333333333, 0.45, 0
23254, 1.2416666666667, 0.44, 0
23255, 1.25, 0.45, 0
23256, 1.2583333333333, 0.44, 0
23257, 1.2666666666667, 0.45, 0
23258, 1.275, 0.44, 0
23259, 1.2833333333333, 0.45, 0
23260, 1.2916666666667, 0.44, 0
23261, 1.3, 0.45, 0
23262, 1.3083333333333, 0.44, 0
23263, 1.3166666666667, 0.45, 0
23264, 1.325, 0.44, 0
23265, 1.3333333333333, 0.45, 0
23266, 1.3416666666667, 0.44, 0
23267, 1.35, 0.45, 0
23268, 1.3583333333333, 0.44, 0
23269, 1.3666666666667, 0.45, 0
23270, 1.375, 0.44, 0
23271, 1.3833333333333, 0.45, 0
23272, 1.3916666666667, 0.44, 0
23273, 1.4, 0.45, 0
23274, 1.4083333333333, 0.44, 0
23275, 1.4166666666667, 0.45, 0
23276, 1.425, 0.44, 0
23277, 1.4333333333333, 0.45, 0
23278, 1.4416666666667, 0.44, 0
23279, 1.45, 0.45, 0
23280, 1.4583333333333, 0.44, 0
23281, 1.4666666666667, 0.45, 0
23282, 1.475, 0.44, 0
23283, 1.4833333333333, 0.45, 0
23284, 1.4916666666667, 0.44, 0
23285, 1.5, 0.45, 0
23286, 1.5083333333333, 0.44, 0
23287, 1.5166666666667, 0.45, 0
23288, 1.525, 0.44, 0
23289, 1.5333333333333, 0.45, 0
23290, 1.5416666666667, 0.44, 0
23291, 1.55, 0.45, 0
23292, 1.5583333333333, 0.44, 0
23293, 1.5666666666667, 0.45, 0
23294, 1.575, 0.44, 0
23295, 1.5833333333333, 0.45, 0
23296, 1.5916666666667, 0.44, 0
23297, 1.6, 0.45, 0
23298, 1.6083333333333, 0.44, 0
23299, 1.6166666666667, 0.45, 0
23300, 1.625, 0.44, 0
23301, 1.6333333333333, 0.45, 0
23302, 1.6416666666667, 0.44, 0
23303, 1.65, 0.45, 0
23304, 1.6583333333333, 0.44, 0
23305, 1.6666666666667, 0.45, 0
23306, 1.675, 0.44, 0
23307, 1.6833333333333, 0.45, 0
23308, 1.6916666666667, 0.44, 0
23309, 1.7, 0.45, 0
23310, 1.7083333333333, 0.44, 0
23311, 1.7166666666667, 0.45, 0
23312, 1.725, 0.44, 0
23313, 1.7333333333333, 0.45, 0
23314, 1.7416666666667, 0.44, 0
23315, 1.75, 0.45, 0
23316, 1.7583333333333, 0.44, 0
23317, 1.7666666666667, 0.45, 0
23318, 1.775, 0.44, 0
23319, 1.7833333333333, 0.45, 0
23320, 1.7916666666667, 0.44, 0
23321, 1.8, 0.45, 0
23322, 1.8083333333333, 0.44, 0
23323, 1.8166666666667, 0.45, 0
23324, 1.825, 0.44, 0
23325, 1.8333333333333, 0.45, 0
23326, 1.8416666666667, 0.44, 0
23327, 1.85, 0.45, 0
23328, 1.8583333333333, 0.44, 0
23329, 1.8666666666667, 0.45, 0
23330, 1.875, 0.44, 0
23331, 1.8833333333333, 0.45, 0
23332, 1.8916666666667, 0.44, 0
23333, 1.9, 0.45, 0
23334, 1.9083333333333, 0.44, 0
23335, 1.9166666666667, 0.45, 0
23336, 1.925, 0.44, 0
23337, 1.9333333333333, 0.45, 0
23338, 1.9416666666667, 0.44, 0
23339, 1.95, 0.45, 0
23340, 1.9583333333333, 0.44, 0
23341, 1.9666666666667, 0.45, 0
23342, 1.975, 0.44, 0
23343, 1.9833333333333, 0.45, 0
23344, 1.9916666666667, 0.44, 0
23345, 2, 0.45, 0
23346, 2.0083333333333, 0.44, 0
23347, 2.0166666666667, 0.45, 0
23348, 2.025, 0.44, 0
23349, 2.0333333333333, 0.45, 0
23350, 2.0416666666667, 0.44, 0
23351, 2.05, 0.45, 0
23352, 2.0583333333333, 0.44, 0
23353, 2.0666666666667, 0.45, 0
23354, 2.075, 0.44, 0
23355, 2.0833333333333, 0.45, 0
23356, 2.0916666666667, 0.44, 0
23357, 2.1, 0.45, 0
23358, 2.1083333333333, 0.44, 0
23359, 2.1166666666667, 0.45, 0
23360, 2.125, 0.44, 0
23361, 2.1333333333333, 0.45, 0
23362, 2.1416666666667, 0.44, 0
23363, 2.15, 0.45, 0
23364, 2.1583333333333, 0.44, 0
23365, 2.1666666666667, 0.45, 0
23366, 2.175, 0.44, 0
23367, 2.1833333333333, 0.45, 0
23368, 2.1916666666667, 0.44, 0
23369, 1.2083333333333, 0.42, 0
23370, 1.2166666666667, 0.43, 0
23371, 1.225, 0.42, 0
23372, 1.2333333333333, 0.43, 0
23373, 1.2416666666667, 0.42, 0
23374, 1.25, 0.43, 0
23375, 1.2583333333333, 0.42, 0
23376, 1.2666666666667, 0.43, 0
23377, 1.275, 0.42, 0
23378, 1.2833333333333, 0.43, 0
23379, 1.2916666666667, 0.42, 0
23380, 1.3, 0.43, 0
23381, 1.3083333333333, 0.42, 0
23382, 1.3166666666667, 0.43, 0
23383, 1.325, 0.42, 0
23384, 1.3333333333333, 0.43, 0
23385, 1.3416666666667, 0.42, 0
23386, 1.35, 0.43, 0
23387, 1.3583333333333, 0.42, 0
23388, 1.3666666666667, 0.43, 0
23389, 1.375, 0.42, 0
23390, 1.3833333333333, 0.43, 0
23391, 1.3916666666667, 0.42, 0
23392, 1.4, 0.43, 0
23393, 1.4083333333333, 0.42, 0
23394, 1.4166666666667, 0.43, 0
23395, 1.425, 0.42, 0
23396, 1.4333333333333, 0.43, 0
23397, 1.4416666666667, 0.42, 0
23398, 1.45, 0.43, 0
23399, 1.4583333333333, 0.42, 0
23400, 1.4666666666667, 0.43, 0
23401, 1.475, 0.42, 0
23402, 1.4833333333333, 0.43, 0
23403, 1.4916666666667, 0.42, 0
23404, 1.5, 0.43, 0
23405, 1.5083333333333, 0.42, 0
23406, 1.5166666666667, 0.43, 0
23407, 1.525, 0.42, 0
23408, 1.5333333333333, 0.43, 0
23409, 1.5416666666667, 0.42, 0
23410, 1.55, 0.43, 0
23411, 1.5583333333333, 0.42, 0
23412, 1.5666666666667, 0.43, 0
23413, 1.575, 0.42, 0
23414, 1.5833333333333, 0.43, 0
23415, 1.5916666666667, 0.42, 0
23416, 1.6, 0.43, 0
23417, 1.6083333333333, 0.42, 0
23418, 1.6166666666667, 0.43, 0
23419, 1.625, 0.42, 0
23420, 1.6333333333333, 0.43, 0
23421, 1.6416666666667, 0.42, 0
23422, 1.65, 0.43, 0
23423, 1.6583333333333, 0.42, 0
23424, 1.6666666666667, 0.43, 0
23425, 1.675, 0.42, 0
23426, 1.6833333333333, 0.43, 0
23427, 1.6916666666667, 0.42, 0
23428, 1.7, 0.43, 0
23429, 1.7083333333333, 0.42, 0
23430, 1.7166666666667, 0.43, 0
23431, 1.725, 0.42, 0
23432, 1.7333333333333, 0.43, 0
23433, 1.7416666666667, 0.42, 0
23434, 1.75, 0.43, 0
23435, 1.7583333333333, 0.42, 0
23436, 1.7666666666667, 0.43, 0
23437, 1.775, 0.42, 0
23438, 1.7833333333333, 0.43, 0
23439, 1.7916666666667, 0.42, 0
23440, 1.8, 0.43, 0
23441, 1.8083333333333, 0.42, 0
23442, 1.8166666666667, 0.43, 0
23443, 1.825, 0.42, 0
23444, 1.8333333333333, 0.43, 0
23445, 1.8416666666667, 0.42, 0
23446, 1.85, 0.43, 0
23447, 1.8583333333333, 0.42, 0
23448, 1.8666666666667, 0.43, 0
23449, 1.875, 0.42, 0
23450, 1.8833333333333, 0.43, 0
23451, 1.8916666666667, 0.42, 0
23452, 1.9, 0.43, 0
23453, 1.9083333333333, 0.42, 0
23454, 1.9166666666667, 0.43, 0
23455, 1.925, 0.42, 0
23456, 1.9333333333333, 0.43, 0
23457, 1.9416666666667, 0.42, 0
23458, 1.95, 0.43, 0
23459, 1.9583333333333, 0.42, 0
23460, 1.9666666666667, 0.43, 0
23461, 1.975, 0.42, 0
23462, 1.9833333333333, 0.43, 0
23463, 1.9916666666667, 0.42, 0
23464, 2, 0.43, 0
23465, 2.0083333333333, 0.42, 0
23466, 2.0166666666667, 0.43, 0
23467, 2.025, 0.42, 0
23468, 2.0333333333333, 0.43, 0
23469, 2.0416666666667, 0.42, 0
23470, 2.05, 0.43, 0
23471, 2.0583333333333, 0.42, 0
23472, 2.0666666666667, 0.43, 0
23473, 2.075, 0.42, 0
23474, 2.0833333333333, 0.43, 0
23475, 2.0916666666667, 0.42, 0
23476, 2.1, 0.43, 0
23477, 2.1083333333333, 0.42, 0
23478, 2.1166666666667, 0.43, 0
23479, 2.125, 0.42, 0
23480, 2.1333333333333, 0.43, 0
23481, 2.1416666666667, 0.42, 0
23482, 2.15, 0.43, 0
23483, 2.1583333333333, 0.42, 0
23484, 2.1666666666667, 0.43, 0
23485, 2.175, 0.42, 0
23486, 2.1833333333333, 0.43, 0
23487, 2.1916666666667, 0.42, 0
23488, 1.2083333333333, 0.4, 0
23489, 1.2166666666667, 0.41, 0
23490, 1.225, 0.4, 0
23491, 1.2333333333333, 0.41, 0
23492, 1.2416666666667, 0.4, 0
23493, 1.25, 0.41, 0
23494, 1.2583333333333, 0.4, 0
23495, 1.2666666666667, 0.41, 0
23496, 1.275, 0.4, 0
23497, 1.2833333333333, 0.41, 0
23498, 1.2916666666667, 0.4, 0
23499, 1.3, 0.41, 0
23500, 1.3083333333333, 0.4, 0
23501, 1.3166666666667, 0.41, 0
23502, 1.325, 0.4, 0
23503, 1.3333333333333, 0.41, 0
23504, 1.3416666666667, 0.4, 0
23505, 1.35, 0.41, 0
23506, 1.3583333333333, 0.4, 0
23507, 1.3666666666667, 0.41, 0
23508, 1.375, 0.4, 0
23509, 1.3833333333333, 0.41, 0
23510, 1.3916666666667, 0.4, 0
23511, 1.4, 0.41, 0
23512, 1.4083333333333, 0.4, 0
23513, 1.4166666666667, 0.41, 0
23514, 1.425, 0.4, 0
23515, 1.4333333333333, 0.41, 0
23516, 1.4416666666667, 0.4, 0
23517, 1.45, 0.41, 0
23518, 1.4583333333333, 0.4, 0
23519, 1.4666666666667, 0.41, 0
23520, 1.475, 0.4, 0
23521, 1.4833333333333, 0.41, 0
23522, 1.4916666666667, 0.4, 0
23523, 1.5, 0.41, 0
23524, 1.5083333333333, 0.4, 0
23525, 1.5166666666667, 0.41, 0
23526, 1.525, 0.4, 0
23527, 1.5333333333333, 0.41, 0
23528, 1.5416666666667, 0.4, 0
23529, 1.55, 0.41, 0
23530, 1.5583333333333, 0.4, 0
23531, 1.5666666666667, 0.41, 0
23532, 1.575, 0.4, 0
23533, 1.5833333333333, 0.41, 0
23534, 1.5916666666667, 0.4, 0
23535, 1.6, 0.41, 0
23536, 1.6083333333333, 0.4, 0
23537, 1.6166666666667, 0.41, 0
23538, 1.625, 0.4, 0
23539, 1.6333333333333, 0.41, 0
23540, 1.6416666666667, 0.4, 0
23541, 1.65, 0.41, 0
23542, 1.6583333333333, 0.4, 0
23543, 1.6666666666667, 0.41, 0
23544, 1.675, 0.4, 0
23545, 1.6833333333333, 0.41, 0
23546, 1.6916666666667, 0.4, 0
23547, 1.7, 0.41, 0
23548, 1.7083333333333, 0.4, 0
23549, 1.7166666666667, 0.41, 0
23550, 1.725, 0.4, 0
23551, 1.7333333333333, 0.41, 0
23552, 1.7416666666667, 0.4, 0
23553, 1.75, 0.41, 0
23554, 1.7583333333333, 0.4, 0
23555, 1.7666666666667, 0.41, 0
23556, 1.775, 0.4, 0
23557, 1.7833333333333, 0.41, 0
23558, 1.7916666666667, 0.4, 0
23559, 1.8, 0.41, 0
23560, 1.8083333333333, 0.4, 0
23561, 1.8166666666667, 0.41, 0
23562, 1.825, 0.4, 0
23563, 1.8333333333333, 0.41, 0
23564, 1.8416666666667, 0.4, 0
23565, 1.85, 0.41, 0
23566, 1.8583333333333, 0.4, 0
23567, 1.8666666666667, 0.41, 0
23568, 1.875, 0.4, 0
23569, 1.8833333333333, 0.41, 0
23570, 1.8916666666667, 0.4, 0
23571, 1.9, 0.41, 0
23572, 1.9083333333333, 0.4, 0
23573, 1.9166666666667, 0.41, 0
23574, 1.925, 0.4, 0
23575, 1.9333333333333, 0.41, 0
23576, 1.9416666666667, 0.4, 0
23577, 1.95, 0.41, 0
23578, 1.9583333333333, 0.4, 0
23579, 1.9666666666667, 0.41, 0
23580, 1.975, 0.4, 0
23581, 1.9833333333333, 0.41, 0
23582, 1.9916666666667, 0.4, 0
23583, 2, 0.41, 0
23584, 2.0083333333333, 0.4, 0
23585, 2.0166666666667, 0.41, 0
23586, 2.025, 0.4, 0
23587, 2.0333333333333, 0.41, 0
23588, 2.0416666666667, 0.4, 0
23589, 2.05, 0.41, 0
23590, 2.0583333333333, 0.4, 0
23591, 2.0666666666667, 0.41, 0
23592, 2.075, 0.4, 0
23593, 2.0833333333333, 0.41, 0
23594, 2.0916666666667, 0.4, 0
23595, 2.1, 0.41, 0
23596, 2.1083333333333, 0.4, 0
23597, 2.1166666666667, 0.41, 0
23598, 2.125, 0.4, 0
23599, 2.1333333333333, 0.41, 0
23600, 2.1416666666667, 0.4, 0
23601, 2.15, 0.41, 0
23602, 2.1583333333333, 0.4, 0
23603, 2.1666666666667, 0.41, 0
23604, 2.175, 0.4, 0
23605, 2.1833333333333, 0.41, 0
23606, 2.1916666666667, 0.4, 0
23607, 1.2083333333333, 0.38, 0
23608, 1.2166666666667, 0.39, 0
23609, 1.225, 0.38, 0
23610, 1.2333333333333, 0.39, 0
23611, 1.2416666666667, 0.38, 0
23612, 1.25, 0.39, 0
23613, 1.2583333333333, 0.38, 0
23614, 1.2666666666667, 0.39, 0
23615, 1.275, 0.38, 0
23616, 1.2833333333333, 0.39, 0
23617, 1.2916666666667, 0.38, 0
23618, 1.3, 0.39, 0
23619, 1.3083333333333, 0.38, 0
23620, 1.3166666666667, 0.39, 0
23621, 1.325, 0.38, 0
23622, 1.3333333333333, 0.39, 0
23623, 1.3416666666667, 0.38, 0
23624, 1.35, 0.39, 0
23625, 1.3583333333333, 0.38, 0
23626, 1.3666666666667, 0.39, 0
23627, 1.375, 0.38, 0
23628, 1.3833333333333, 0.39, 0
23629, 1.3916666666667, 0.38, 0
23630, 1.4, 0.39, 0
23631, 1.4083333333333, 0.38, 0
23632, 1.4166666666667, 0.39, 0
23633, 1.425, 0.38, 0
23634, 1.4333333333333, 0.39, 0
23635, 1.4416666666667, 0.38, 0
23636, 1.45, 0.39, 0
23637, 1.4583333333333, 0.38, 0
23638, 1.4666666666667, 0.39, 0
23639, 1.475, 0.38, 0
23640, 1.4833333333333, 0.39, 0
23641, 1.4916666666667, 0.38, 0
23642, 1.5, 0.39, 0
23643, 1.5083333333333, 0.38, 0
23644, 1.5166666666667, 0.39, 0
23645, 1.525, 0.38, 0
23646, 1.5333333333333, 0.39, 0
23647, 1.5416666666667, 0.38, 0
23648, 1.55, 0.39, 0
23649, 1.5583333333333, 0.38, 0
23650, 1.5666666666667, 0.39, 0
23651, 1.575, 0.38, 0
23652, 1.5833333333333, 0.39, 0
23653, 1.5916666666667, 0.38, 0
23654, 1.6, 0.39, 0
23655, 1.6083333333333, 0.38, 0
23656, 1.6166666666667, 0.39, 0
23657, 1.625, 0.38, 0
23658, 1.6333333333333, 0.39, 0
23659, 1.6416666666667, 0.38, 0
23660, 1.65, 0.39, 0
23661, 1.6583333333333, 0.38, 0
23662, 1.6666666666667, 0.39, 0
23663, 1.675, 0.38, 0
23664, 1.6833333333333, 0.39, 0
23665, 1.6916666666667, 0.38, 0
23666, 1.7, 0.39, 0
23667, 1.7083333333333, 0.38, 0
23668, 1.7166666666667, 0.39, 0
23669, 1.725, 0.38, 0
23670, 1.7333333333333, 0.39, 0
23671, 1.7416666666667, 0.38, 0
23672, 1.75, 0.39, 0
23673, 1.7583333333333, 0.38, 0
23674, 1.7666666666667, 0.39, 0
23675, 1.775, 0.38, 0
23676, 1.7833333333333, 0.39, 0
23677, 1.7916666666667, 0.38, 0
23678, 1.8, 0.39, 0
23679, 1.8083333333333, 0.38, 0
23680, 1.8166666666667, 0.39, 0
23681, 1.825, 0.38, 0
23682, 1.8333333333333, 0.39, 0
23683, 1.8416666666667, 0.38, 0
23684, 1.85, 0.39, 0
23685, 1.8583333333333, 0.38, 0
23686, 1.8666666666667, 0.39, 0
23687, 1.875, 0.38, 0
23688, 1.8833333333333, 0.39, 0
23689, 1.8916666666667, 0.38, 0
23690, 1.9, 0.39, 0
23691, 1.9083333333333, 0.38, 0
23692, 1.9166666666667, 0.39, 0
23693, 1.925, 0.38, 0
23694, 1.9333333333333, 0.39, 0
23695, 1.9416666666667, 0.38, 0
23696, 1.95, 0.39, 0
23697, 1.9583333333333, 0.38, 0
23698, 1.9666666666667, 0.39, 0
23699, 1.975, 0.38, 0
23700, 1.9833333333333, 0.39, 0
23701, 1.9916666666667, 0.38, 0
23702, 2, 0.39, 0
23703, 2.0083333333333, 0.38, 0
23704, 2.0166666666667, 0.39, 0
23705, 2.025, 0.38, 0
23706, 2.0333333333333, 0.39, 0
23707, 2.0416666666667, 0.38, 0
23708, 2.05, 0.39, 0
23709, 2.0583333333333, 0.38, 0
23710, 2.0666666666667, 0.39, 0
23711, 2.075, 0.38, 0
23712, 2.0833333333333, 0.39, 0
23713, 2.0916666666667, 0.38, 0
23714, 2.1, 0.39, 0
23715, 2.1083333333333, 0.38, 0
23716, 2.1166666666667, 0.39, 0
23717, 2.125, 0.38, 0
23718, 2.1333333333333, 0.39, 0
23719, 2.1416666666667, 0.38, 0
23720, 2.15, 0.39, 0
23721, 2.1583333333333, 0.38, 0
23722, 2.1666666666667, 0.39, 0
23723, 2.175, 0.38, 0
23724, 2.1833333333333, 0.39, 0
23725, 2.1916666666667, 0.38, 0
23726, 1.2083333333333, 0.36, 0
23727, 1.2166666666667, 0.37, 0
23728, 1.225, 0.36, 0
23729, 1.2333333333333, 0.37, 0
23730, 1.2416666666667, 0.36, 0
23731, 1.25, 0.37, 0
23732, 1.2583333333333, 0.36, 0
23733, 1.2666666666667, 0.37, 0
23734, 1.275, 0.36, 0
23735, 1.2833333333333, 0.37, 0
23736, 1.2916666666667, 0.36, 0
23737, 1.3, 0.37, 0
23738, 1.3083333333333, 0.36, 0
23739, 1.3166666666667, 0.37, 0
23740, 1.325, 0.36, 0
23741, 1.3333333333333, 0.37, 0
23742, 1.3416666666667, 0.36, 0
23743, 1.35, 0.37, 0
23744, 1.3583333333333, 0.36, 0
23745, 1.3666666666667, 0.37, 0
23746, 1.375, 0.36, 0
23747, 1.3833333333333, 0.37, 0
23748, 1.3916666666667, 0.36, 0
23749, 1.4, 0.37, 0
23750, 1.4083333333333, 0.36, 0
23751, 1.4166666666667, 0.37, 0
23752, 1.425, 0.36, 0
23753, 1.4333333333333, 0.37, 0
23754, 1.4416666666667, 0.36, 0
23755, 1.45, 0.37, 0
23756, 1.4583333333333, 0.36, 0
23757, 1.4666666666667, 0.37, 0
23758, 1.475, 0.36, 0
23759, 1.4833333333333, 0.37, 0
23760, 1.4916666666667, 0.36, 0
23761, 1.5, 0.37, 0
23762, 1.5083333333333, 0.36, 0
23763, 1.5166666666667, 0.37, 0
23764, 1.525, 0.36, 0
23765, 1.5333333333333, 0.37, 0
23766, 1.5416666666667, 0.36, 0
23767, 1.55, 0.37, 0
23768, 1.5583333333333, 0.36, 0
23769, 1.5666666666667, 0.37, 0
23770, 1.575, 0.36, 0
23771, 1.5833333333333, 0.37, 0
23772, 1.5916666666667, 0.36, 0
23773, 1.6, 0.37, 0
23774, 1.6083333333333, 0.36, 0
23775, 1.6166666666667, 0.37, 0
23776, 1.625, 0.36, 0
23777, 1.6333333333333, 0.37, 0
23778, 1.6416666666667, 0.36, 0
23779, 1.65, 0.37, 0
23780, 1.6583333333333, 0.36, 0
23781, 1.6666666666667, 0.37, 0
23782, 1.675, 0.36, 0
23783, 1.6833333333333, 0.37, 0
23784, 1.6916666666667, 0.36, 0
23785, 1.7, 0.37, 0
23786, 1.7083333333333, 0.36, 0
23787, 1.7166666666667, 0.37, 0
23788, 1.725, 0.36, 0
23789, 1.7333333333333, 0.37, 0
23790, 1.7416666666667, 0.36, 0
23791, 1.75, 0.37, 0
23792, 1.7583333333333, 0.36, 0
23793, 1.7666666666667, 0.37, 0
23794, 1.775, 0.36, 0
23795, 1.7833333333333, 0.37, 0
23796, 1.7916666666667, 0.36, 0
23797, 1.8, 0.37, 0
23798, 1.8083333333333, 0.36, 0
23799, 1.8166666666667, 0.37, 0
23800, 1.825, 0.36, 0
23801, 1.8333333333333, 0.37, 0
23802, 1.8416666666667, 0.36, 0
23803, 1.85, 0.37, 0
23804, 1.8583333333333, 0.36, 0
23805, 1.8666666666667, 0.37, 0
23806, 1.875, 0.36, 0
23807, 1.8833333333333, 0.37, 0
23808, 1.8916666666667, 0.36, 0
23809, 1.9, 0.37, 0
23810, 1.9083333333333, 0.36, 0
23811, 1.9166666666667, 0.37, 0
23812, 1.925, 0.36, 0
23813, 1.9333333333333, 0.37, 0
23814, 1.9416666666667, 0.36, 0
23815, 1.95, 0.37, 0
23816, 1.9583333333333, 0.36, 0
23817, 1.9666666666667, 0.37, 0
23818, 1.975, 0.36, 0
23819, 1.9833333333333, 0.37, 0
23820, 1.9916666666667, 0.36, 0
23821, 2, 0.37, 0
23822, 2.0083333333333, 0.36, 0
23823, 2.0166666666667, 0.37, 0
23824, 2.025, 0.36, 0
23825, 2.0333333333333, 0.37, 0
23826, 2.0416666666667, 0.36, 0
23827, 2.05, 0.37, 0
23828, 2.0583333333333, 0.36, 0
23829, 2.0666666666667, 0.37, 0
23830, 2.075, 0.36, 0
23831, 2.0833333333333, 0.37, 0
23832, 2.0916666666667, 0.36, 0
23833, 2.1, 0.37, 0
23834, 2.1083333333333, 0.36, 0
23835, 2.1166666666667, 0.37, 0
23836, 2.125, 0.36, 0
23837, 2.1333333333333, 0.37, 0
23838, 2.1416666666667, 0.36, 0
23839, 2.15, 0.37, 0
23840, 2.1583333333333, 0.36, 0
23841, 2.1666666666667, 0.37, 0
23842, 2.175, 0.36, 0
23843, 2.1833333333333, 0.37, 0
23844, 2.1916666666667, 0.36, 0
23845, 1.2083333333333, 0.34, 0
23846, 1.2166666666667, 0.35, 0
23847, 1.225, 0.34, 0
23848, 1.2333333333333, 0.35, 0
23849, 1.2416666666667, 0.34, 0
23850, 1.25, 0.35, 0
23851, 1.2583333333333, 0.34, 0
23852, 1.2666666666667, 0.35, 0
23853, 1.275, 0.34, 0
23854, 1.2833333333333, 0.35, 0
23855, 1.2916666666667, 0.34, 0
23856, 1.3, 0.35, 0
23857, 1.3083333333333, 0.34, 0
23858, 1.3166666666667, 0.35, 0
23859, 1.325, 0.34, 0
23860, 1.3333333333333, 0.35, 0
23861, 1.3416666666667, 0.34, 0
23862, 1.35, 0.35, 0
23863, 1.3583333333333, 0.34, 0
23864, 1.3666666666667, 0.35, 0
23865, 1.375, 0.34, 0
23866, 1.3833333333333, 0.35, 0
23867, 1.3916666666667, 0.34, 0
23868, 1.4, 0.35, 0
23869, 1.4083333333333, 0.34, 0
23870, 1.4166666666667, 0.35, 0
23871, 1.425, 0.34, 0
23872, 1.4333333333333, 0.35, 0
23873, 1.4416666666667, 0.34, 0
23874, 1.45, 0.35, 0
23875, 1.4583333333333, 0.34, 0
23876, 1.4666666666667, 0.35, 0
23877, 1.475, 0.34, 0
23878, 1.4833333333333, 0.35, 0
23879, 1.4916666666667, 0.34, 0
23880, 1.5, 0.35, 0
23881, 1.5083333333333, 0.34, 0
23882, 1.5166666666667, 0.35, 0
23883, 1.525, 0.34, 0
23884, 1.5333333333333, 0.35, 0
23885, 1.5416666666667, 0.34, 0
23886, 1.55, 0.35, 0
23887, 1.5583333333333, 0.34, 0
23888, 1.5666666666667, 0.35, 0
23889, 1.575, 0.34, 0
23890, 1.5833333333333, 0.35, 0
23891, 1.5916666666667, 0.34, 0
23892, 1.6, 0.35, 0
23893, 1.6083333333333, 0.34, 0
23894, 1.6166666666667, 0.35, 0
23895, 1.625, 0.34, 0
23896, 1.6333333333333, 0.35, 0
23897, 1.6416666666667, 0.34, 0
23898, 1.65, 0.35, 0
23899, 1.6583333333333, 0.34, 0
23900, 1.6666666666667, 0.35, 0
23901, 1.675, 0.34, 0
23902, 1.6833333333333, 0.35, 0
23903, 1.6916666666667, 0.34, 0
23904, 1.7, 0.35, 0
23905, 1.7083333333333, 0.34, 0
23906, 1.7166666666667, 0.35, 0
23907, 1.725, 0.34, 0
23908, 1.7333333333333, 0.35, 0
23909, 1.7416666666667, 0.34, 0
23910, 1.75, 0.35, 0
23911, 1.7583333333333, 0.34, 0
23912, 1.7666666666667, 0.35, 0
23913, 1.775, 0.34, 0
23914, 1.7833333333333, 0.35, 0
23915, 1.7916666666667, 0.34, 0
23916, 1.8, 0.35, 0
23917, 1.8083333333333, 0.34, 0
23918, 1.8166666666667, 0.35, 0
23919, 1.825, 0.34, 0
23920, 1.8333333333333, 0.35, 0
23921, 1.8416666666667, 0.34, 0
23922, 1.85, 0.35, 0
23923, 1.8583333333333, 0.34, 0
23924, 1.8666666666667, 0.35, 0
23925, 1.875, 0.34, 0
23926, 1.8833333333333, 0.35, 0
23927, 1.8916666666667, 0.34, 0
23928, 1.9, 0.35, 0
23929, 1.9083333333333, 0.34, 0
23930, 1.9166666666667, 0.35, 0
23931, 1.925, 0.34, 0
23932, 1.9333333333333, 0.35, 0
23933, 1.9416666666667, 0.34, 0
23934, 1.95, 0.35, 0
23935, 1.9583333333333, 0.34, 0
23936, 1.9666666666667, 0.35, 0
23937, 1.975, 0.34, 0
23938, 1.9833333333333, 0.35, 0
23939, 1.9916666666667, 0.34, 0
23940, 2, 0.35, 0
23941, 2.0083333333333, 0.34, 0
23942, 2.0166666666667, 0.35, 0
23943, 2.025, 0.34, 0
23944, 2.0333333333333, 0.35, 0
23945, 2.0416666666667, 0.34, 0
23946, 2.05, 0.35, 0
23947, 2.0583333333333, 0.34, 0
23948, 2.0666666666667, 0.35, 0
23949, 2.075, 0.34, 0
23950, 2.0833333333333, 0.35, 0
23951, 2.0916666666667, 0.34, 0
23952, 2.1, 0.35, 0
23953, 2.1083333333333, 0.34, 0
23954, 2.1166666666667, 0.35, 0
23955, 2.125, 0.34, 0
23956, 2.1333333333333, 0.35, 0
23957, 2.1416666666667, 0.34, 0
23958, 2.15, 0.35, 0
23959, 2.1583333333333, 0.34, 0
23960, 2.1666666666667, 0.35, 0
23961, 2.175, 0.34, 0
23962, 2.1833333333333, 0.35, 0
23963, 2.1916666666667, 0.34, 0
23964, 1.2083333333333, 0.32, 0
23965, 1.2166666666667, 0.33, 0
23966, 1.225, 0.32, 0
23967, 1.2333333333333, 0.33, 0
23968, 1.2416666666667, 0.32, 0
23969, 1.25, 0.33, 0
23970, 1.2583333333333, 0.32, 0
23971, 1.2666666666667, 0.33, 0
23972, 1.275, 0.32, 0
23973, 1.2833333333333, 0.33, 0
23974, 1.2916666666667, 0.32, 0
23975, 1.3, 0.33, 0
23976, 1.3083333333333, 0.32, 0
23977, 1.3166666666667, 0.33, 0
23978, 1.325, 0.32, 0
23979, 1.3333333333333, 0.33, 0
23980, 1.3416666666667, 0.32, 0
23981, 1.35, 0.33, 0
23982, 1.3583333333333, 0.32, 0
23983, 1.3666666666667, 0.33, 0
23984, 1.375, 0.32, 0
23985, 1.3833333333333, 0.33, 0
23986, 1.3916666666667, 0.32, 0
23987, 1.4, 0.33, 0
23988, 1.4083333333333, 0.32, 0
23989, 1.4166666666667, 0.33, 0
23990, 1.425, 0.32, 0
23991, 1.4333333333333, 0.33, 0
23992, 1.4416666666667, 0.32, 0
23993, 1.45, 0.33, 0
23994, 1.4583333333333, 0.32, 0
23995, 1.4666666666667, 0.33, 0
23996, 1.475, 0.32, 0
23997, 1.4833333333333, 0.33, 0
23998, 1.4916666666667, 0.32, 0
23999, 1.5, 0.33, 0
24000, 1.5083333333333, 0.32, 0
24001, 1.5166666666667, 0.33, 0
24002, 1.525, 0.32, 0
24003, 1.5333333333333, 0.33, 0
24004, 1.5416666666667, 0.32, 0
24005, 1.55, 0.33, 0
24006, 1.5583333333333, 0.32, 0
24007, 1.5666666666667, 0.33, 0
24008, 1.575, 0.32, 0
24009, 1.5833333333333, 0.33, 0
24010, 1.5916666666667, 0.32, 0
24011, 1.6, 0.33, 0
24012, 1.6083333333333, 0.32, 0
24013, 1.6166666666667, 0.33, 0
24014, 1.625, 0.32, 0
24015, 1.6333333333333, 0.33, 0
24016, 1.6416666666667, 0.32, 0
24017, 1.65, 0.33, 0
24018, 1.6583333333333, 0.32, 0
24019, 1.6666666666667, 0.33, 0
24020, 1.675, 0.32, 0
24021, 1.6833333333333, 0.33, 0
24022, 1.6916666666667, 0.32, 0
24023, 1.7, 0.33, 0
24024, 1.7083333333333, 0.32, 0
24025, 1.7166666666667, 0.33, 0
24026, 1.725, 0.32, 0
24027, 1.7333333333333, 0.33, 0
24028, 1.7416666666667, 0.32, 0
24029, 1.75, 0.33, 0
24030, 1.7583333333333, 0.32, 0
24031, 1.7666666666667, 0.33, 0
24032, 1.775, 0.32, 0
24033, 1.7833333333333, 0.33, 0
24034, 1.7916666666667, 0.32, 0
24035, 1.8, 0.33, 0
24036, 1.8083333333333, 0.32, 0
24037, 1.8166666666667, 0.33, 0
24038, 1.825, 0.32, 0
24039, 1.8333333333333, 0.33, 0
24040, 1.8416666666667, 0.32, 0
24041, 1.85, 0.33, 0
24042, 1.8583333333333, 0.32, 0
24043, 1.8666666666667, 0.33, 0
24044, 1.875, 0.32, 0
24045, 1.8833333333333, 0.33, 0
24046, 1.8916666666667, 0.32, 0
24047, 1.9, 0.33, 0
24048, 1.9083333333333, 0.32, 0
24049, 1.9166666666667, 0.33, 0
24050, 1.925, 0.32, 0
24051, 1.9333333333333, 0.33, 0
24052, 1.9416666666667, 0.32, 0
24053, 1.95, 0.33, 0
24054, 1.9583333333333, 0.32, 0
24055, 1.9666666666667, 0.33, 0
24056, 1.975, 0.32, 0
24057, 1.9833333333333, 0.33, 0
24058, 1.9916666666667, 0.32, 0
24059, 2, 0.33, 0
24060, 2.0083333333333, 0.32, 0
24061, 2.0166666666667, 0.33, 0
24062, 2.025, 0.32, 0
24063, 2.0333333333333, 0.33, 0
24064, 2.0416666666667, 0.32, 0
24065, 2.05, 0.33, 0
24066, 2.0583333333333, 0.32, 0
24067, 2.0666666666667, 0.33, 0
24068, 2.075, 0.32, 0
24069, 2.0833333333333, 0.33, 0
24070, 2.0916666666667, 0.32, 0
24071, 2.1, 0.33, 0
24072, 2.1083333333333, 0.32, 0
24073, 2.1166666666667, 0.33, 0
24074, 2.125, 0.32, 0
24075, 2.1333333333333, 0.33, 0
24076, 2.1416666666667, 0.32, 0
24077, 2.15, 0.33, 0
24078, 2.1583333333333, 0.32, 0
24079, 2.1666666666667, 0.33, 0
24080, 2.175, 0.32, 0
24081, 2.1833333333333, 0.33, 0
24082, 2.1916666666667, 0.32, 0
24083, 1.2083333333333, 0.3, 0
24084, 1.2166666666667, 0.31, 0
24085, 1.225, 0.3, 0
24086, 1.2333333333333, 0.31, 0
24087, 1.2416666666667, 0.3, 0
24088, 1.25, 0.31, 0
24089, 1.2583333333333, 0.3, 0
24090, 1.2666666666667, 0.31, 0
24091, 1.275, 0.3, 0
24092, 1.2833333333333, 0.31, 0
24093, 1.2916666666667, 0.3, 0
24094, 1.3, 0.31, 0
24095, 1.3083333333333, 0.3, 0
24096, 1.3166666666667, 0.31, 0
24097, 1.325, 0.3, 0
24098, 1.3333333333333, 0.31, 0
24099, 1.3416666666667, 0.3, 0
24100, 1.35, 0.31, 0
24101, 1.3583333333333, 0.3, 0
24102, 1.3666666666667, 0.31, 0
24103, 1.375, 0.3, 0
24104, 1.3833333333333, 0.31, 0
24105, 1.3916666666667, 0.3, 0
24106, 1.4, 0.31, 0
24107, 1.4083333333333, 0.3, 0
24108, 1.4166666666667, 0.31, 0
24109, 1.425, 0.3, 0
24110, 1.4333333333333, 0.31, 0
24111, 1.4416666666667, 0.3, 0
24112, 1.45, 0.31, 0
24113, 1.4583333333333, 0.3, 0
24114, 1.4666666666667, 0.31, 0
24115, 1.475, 0.3, 0
24116, 1.4833333333333, 0.31, 0
24117, 1.4916666666667, 0.3, 0
24118, 1.5, 0.31, 0
24119, 1.5083333333333, 0.3, 0
24120, 1.5166666666667, 0.31, 0
24121, 1.525, 0.3, 0
24122, 1.5333333333333, 0.31, 0
24123, 1.5416666666667, 0.3, 0
24124, 1.55, 0.31, 0
24125, 1.5583333333333, 0.3, 0
24126, 1.5666666666667, 0.31, 0
24127, 1.575, 0.3, 0
24128, 1.5833333333333, 0.31, 0
24129, 1.5916666666667, 0.3, 0
24130, 1.6, 0.31, 0
24131, 1.6083333333333, 0.3, 0
24132, 1.6166666666667, 0.31, 0
24133, 1.625, 0.3, 0
24134, 1.6333333333333, 0.31, 0
24135, 1.6416666666667, 0.3, 0
24136, 1.65, 0.31, 0
24137, 1.6583333333333, 0.3, 0
24138, 1.6666666666667, 0.31, 0
24139, 1.675, 0.3, 0
24140, 1.6833333333333, 0.31, 0
24141, 1.6916666666667, 0.3, 0
24142, 1.7, 0.31, 0
24143, 1.7083333333333, 0.3, 0
24144, 1.7166666666667, 0.31, 0
24145, 1.725, 0.3, 0
24146, 1.7333333333333, 0.31, 0
24147, 1.7416666666667, 0.3, 0
24148, 1.75, 0.31, 0
24149, 1.7583333333333, 0.3, 0
24150, 1.7666666666667, 0.31, 0
24151, 1.775, 0.3, 0
24152, 1.7833333333333, 0.31, 0
24153, 1.7916666666667, 0.3, 0
24154, 1.8, 0.31, 0
24155, 1.8083333333333, 0.3, 0
24156, 1.8166666666667, 0.31, 0
24157, 1.825, 0.3, 0
24158, 1.8333333333333, 0.31, 0
24159, 1.8416666666667, 0.3, 0
24160, 1.85, 0.31, 0
24161, 1.8583333333333, 0.3, 0
24162, 1.8666666666667, 0.31, 0
24163, 1.875, 0.3, 0
24164, 1.8833333333333, 0.31, 0
24165, 1.8916666666667, 0.3, 0
24166, 1.9, 0.31, 0
24167, 1.9083333333333, 0.3, 0
24168, 1.9166666666667, 0.31, 0
24169, 1.925, 0.3, 0
24170, 1.9333333333333, 0.31, 0
24171, 1.9416666666667, 0.3, 0
24172, 1.95, 0.31, 0
24173, 1.9583333333333, 0.3, 0
24174, 1.9666666666667, 0.31, 0
24175, 1.975, 0.3, 0
24176, 1.9833333333333, 0.31, 0
24177, 1.9916666666667, 0.3, 0
24178, 2, 0.31, 0
24179, 2.0083333333333, 0.3, 0
24180, 2.0166666666667, 0.31, 0
24181, 2.025, 0.3, 0
24182, 2.0333333333333, 0.31, 0
24183, 2.0416666666667, 0.3, 0
24184, 2.05, 0.31, 0
24185, 2.0583333333333, 0.3, 0
24186, 2.0666666666667, 0.31, 0
24187, 2.075, 0.3, 0
24188, 2.0833333333333, 0.31, 0
24189, 2.0916666666667, 0.3, 0
24190, 2.1, 0.31, 0
24191, 2.1083333333333, 0.3, 0
24192, 2.1166666666667, 0.31, 0
24193, 2.125, 0.3, 0
24194, 2.1333333333333, 0.31, 0
24195, 2.1416666666667, 0.3, 0
24196, 2.15, 0.31, 0
24197, 2.1583333333333, 0.3, 0
24198, 2.1666666666667, 0.31, 0
24199, 2.175, 0.3, 0
24200, 2.1833333333333, 0.31, 0
24201, 2.1916666666667, 0.3, 0
24202, 1.2083333333333, 0.28, 0
24203, 1.2166666666667, 0.29, 0
24204, 1.225, 0.28, 0
24205, 1.2333333333333, 0.29, 0
24206, 1.2416666666667, 0.28, 0
24207, 1.25, 0.29, 0
24208, 1.2583333333333, 0.28, 0
24209, 1.2666666666667, 0.29, 0
24210, 1.275, 0.28, 0
24211, 1.2833333333333, 0.29, 0
24212, 1.2916666666667, 0.28, 0
24213, 1.3, 0.29, 0
24214, 1.3083333333333, 0.28, 0
24215, 1.3166666666667, 0.29, 0
24216, 1.325, 0.28, 0
24217, 1.3333333333333, 0.29, 0
24218, 1.3416666666667, 0.28, 0
24219, 1.35, 0.29, 0
24220, 1.3583333333333, 0.28, 0
24221, 1.3666666666667, 0.29, 0
24222, 1.375, 0.28, 0
24223, 1.3833333333333, 0.29, 0
24224, 1.3916666666667, 0.28, 0
24225, 1.4, 0.29, 0
24226, 1.4083333333333, 0.28, 0
24227, 1.4166666666667, 0.29, 0
24228, 1.425, 0.28, 0
24229, 1.4333333333333, 0.29, 0
24230, 1.4416666666667, 0.28, 0
24231, 1.45, 0.29, 0
24232, 1.4583333333333, 0.28, 0
24233, 1.4666666666667, 0.29, 0
24234, 1.475, 0.28, 0
24235, 1.4833333333333, 0.29, 0
24236, 1.4916666666667, 0.28, 0
24237, 1.5, 0.29, 0
24238, 1.5083333333333, 0.28, 0
24239, 1.5166666666667, 0.29, 0
24240, 1.525, 0.28, 0
24241, 1.5333333333333, 0.29, 0
24242, 1.5416666666667, 0.28, 0
24243, 1.55, 0.29, 0
24244, 1.5583333333333, 0.28, 0
24245, 1.5666666666667, 0.29, 0
24246, 1.575, 0.28, 0
24247, 1.5833333333333, 0.29, 0
24248, 1.5916666666667, 0.28, 0
24249, 1.6, 0.29, 0
24250, 1.6083333333333, 0.28, 0
24251, 1.6166666666667, 0.29, 0
24252, 1.625, 0.28, 0
24253, 1.6333333333333, 0.29, 0
24254, 1.6416666666667, 0.28, 0
24255, 1.65, 0.29, 0
24256, 1.6583333333333, 0.28, 0
24257, 1.6666666666667, 0.29, 0
24258, 1.675, 0.28, 0
24259, 1.6833333333333, 0.29, 0
24260, 1.6916666666667, 0.28, 0
24261, 1.7, 0.29, 0
24262, 1.7083333333333, 0.28, 0
24263, 1.7166666666667, 0.29, 0
24264, 1.725, 0.28, 0
24265, 1.7333333333333, 0.29, 0
24266, 1.7416666666667, 0.28, 0
24267, 1.75, 0.29, 0
24268, 1.7583333333333, 0.28, 0
24269, 1.7666666666667, 0.29, 0
24270, 1.775, 0.28, 0
24271, 1.7833333333333, 0.29, 0
24272, 1.7916666666667, 0.28, 0
24273, 1.8, 0.29, 0
24274, 1.8083333333333, 0.28, 0
24275, 1.8166666666667, 0.29, 0
24276, 1.825, 0.28, 0
24277, 1.8333333333333, 0.29, 0
24278, 1.8416666666667, 0.28, 0
24279, 1.85, 0.29, 0
24280, 1.8583333333333, 0.28, 0
24281, 1.8666666666667, 0.29, 0
24282, 1.875, 0.28, 0
24283, 1.8833333333333, 0.29, 0
24284, 1.8916666666667, 0.28, 0
24285, 1.9, 0.29, 0
24286, 1.9083333333333, 0.28, 0
24287, 1.9166666666667, 0.29, 0
24288, 1.925, 0.28, 0
24289, 1.9333333333333, 0.29, 0
24290, 1.9416666666667, 0.28, 0
24291, 1.95, 0.29, 0
24292, 1.9583333333333, 0.28, 0
24293, 1.9666666666667, 0.29, 0
24294, 1.975, 0.28, 0
24295, 1.9833333333333, 0.29, 0
24296, 1.9916666666667, 0.28, 0
24297, 2, 0.29, 0
24298, 2.0083333333333, 0.28, 0
24299, 2.0166666666667, 0.29, 0
24300, 2.025, 0.28, 0
24301, 2.0333333333333, 0.29, 0
24302, 2.0416666666667, 0.28, 0
24303, 2.05, 0.29, 0
24304, 2.0583333333333, 0.28, 0
24305, 2.0666666666667, 0.29, 0
24306, 2.075, 0.28, 0
24307, 2.0833333333333, 0.29, 0
24308, 2.0916666666667, 0.28, 0
24309, 2.1, 0.29, 0
24310, 2.1083333333333, 0.28, 0
24311, 2.1166666666667, 0.29, 0
24312, 2.125, 0.28, 0
24313, 2.1333333333333, 0.29, 0
24314, 2.1416666666667, 0.28, 0
24315, 2.15, 0.29, 0
24316, 2.1583333333333, 0.28, 0
24317, 2.1666666666667, 0.29, 0
24318, 2.175, 0.28, 0
24319, 2.1833333333333, 0.29, 0
24320, 2.1916666666667, 0.28, 0
24321, 1.2083333333333, 0.26, 0
24322, 1.2166666666667, 0.27, 0
24323, 1.225, 0.26, 0
24324, 1.2333333333333, 0.27, 0
24325, 1.2416666666667, 0.26, 0
24326, 1.25, 0.27, 0
24327, 1.2583333333333, 0.26, 0
24328, 1.2666666666667, 0.27, 0
24329, 1.275, 0.26, 0
24330, 1.2833333333333, 0.27, 0
24331, 1.2916666666667, 0.26, 0
24332, 1.3, 0.27, 0
24333, 1.3083333333333, 0.26, 0
24334, 1.3166666666667, 0.27, 0
24335, 1.325, 0.26, 0
24336, 1.3333333333333, 0.27, 0
24337, 1.3416666666667, 0.26, 0
24338, 1.35, 0.27, 0
24339, 1.3583333333333, 0.26, 0
24340, 1.3666666666667, 0.27, 0
24341, 1.375, 0.26, 0
24342, 1.3833333333333, 0.27, 0
24343, 1.3916666666667, 0.26, 0
24344, 1.4, 0.27, 0
24345, 1.4083333333333, 0.26, 0
24346, 1.4166666666667, 0.27, 0
24347, 1.425, 0.26, 0
24348, 1.4333333333333, 0.27, 0
24349, 1.4416666666667, 0.26, 0
24350, 1.45, 0.27, 0
24351, 1.4583333333333, 0.26, 0
24352, 1.4666666666667, 0.27, 0
24353, 1.475, 0.26, 0
24354, 1.4833333333333, 0.27, 0
24355, 1.4916666666667, 0.26, 0
24356, 1.5, 0.27, 0
24357, 1.5083333333333, 0.26, 0
24358, 1.5166666666667, 0.27, 0
24359, 1.525, 0.26, 0
24360, 1.5333333333333, 0.27, 0
24361, 1.5416666666667, 0.26, 0
24362, 1.55, 0.27, 0
24363, 1.5583333333333, 0.26, 0
24364, 1.5666666666667, 0.27, 0
24365, 1.575, 0.26, 0
24366, 1.5833333333333, 0.27, 0
24367, 1.5916666666667, 0.26, 0
24368, 1.6, 0.27, 0
24369, 1.6083333333333, 0.26, 0
24370, 1.6166666666667, 0.27, 0
24371, 1.625, 0.26, 0
24372, 1.6333333333333, 0.27, 0
24373, 1.6416666666667, 0.26, 0
24374, 1.65, 0.27, 0
24375, 1.6583333333333, 0.26, 0
24376, 1.6666666666667, 0.27, 0
24377, 1.675, 0.26, 0
24378, 1.6833333333333, 0.27, 0
24379, 1.6916666666667, 0.26, 0
24380, 1.7, 0.27, 0
24381, 1.7083333333333, 0.26, 0
24382, 1.7166666666667, 0.27, 0
24383, 1.725, 0.26, 0
24384, 1.7333333333333, 0.27, 0
24385, 1.7416666666667, 0.26, 0
24386, 1.75, 0.27, 0
24387, 1.7583333333333, 0.26, 0
24388, 1.7666666666667, 0.27, 0
24389, 1.775, 0.26, 0
24390, 1.7833333333333, 0.27, 0
24391, 1.7916666666667, 0.26, 0
24392, 1.8, 0.27, 0
24393, 1.8083333333333, 0.26, 0
24394, 1.8166666666667, 0.27, 0
24395, 1.825, 0.26, 0
24396, 1.8333333333333, 0.27, 0
24397, 1.8416666666667, 0.26, 0
24398, 1.85, 0.27, 0
24399, 1.8583333333333, 0.26, 0
24400, 1.8666666666667, 0.27, 0
24401, 1.875, 0.26, 0
24402, 1.8833333333333, 0.27, 0
24403, 1.8916666666667, 0.26, 0
24404, 1.9, 0.27, 0
24405, 1.9083333333333, 0.26, 0
24406, 1.9166666666667, 0.27, 0
24407, 1.925, 0.26, 0
24408, 1.9333333333333, 0.27, 0
24409, 1.9416666666667, 0.26, 0
24410, 1.95, 0.27, 0
24411, 1.9583333333333, 0.26, 0
24412, 1.9666666666667, 0.27, 0
24413, 1.975, 0.26, 0
24414, 1.9833333333333, 0.27, 0
24415, 1.9916666666667, 0.26, 0
24416, 2, 0.27, 0
24417, 2.0083333333333, 0.26, 0
24418, 2.0166666666667, 0.27, 0
24419, 2.025, 0.26, 0
24420, 2.0333333333333, 0.27, 0
24421, 2.0416666666667, 0.26, 0
24422, 2.05, 0.27, 0
24423, 2.0583333333333, 0.26, 0
24424, 2.0666666666667, 0.27, 0
24425, 2.075, 0.26, 0
24426, 2.0833333333333, 0.27, 0
24427, 2.0916666666667, 0.26, 0
24428, 2.1, 0.27, 0
24429, 2.1083333333333, 0.26, 0
24430, 2.1166666666667, 0.27, 0
24431, 2.125, 0.26, 0
24432, 2.1333333333333, 0.27, 0
24433, 2.1416666666667, 0.26, 0
24434, 2.15, 0.27, 0
24435, 2.1583333333333, 0.26, 0
24436, 2.1666666666667, 0.27, 0
24437, 2.175, 0.26, 0
24438, 2.1833333333333, 0.27, 0
24439, 2.1916666666667, 0.26, 0
24440, 1.2083333333333, 0.24, 0
24441, 1.2166666666667, 0.25, 0
24442, 1.225, 0.24, 0
24443, 1.2333333333333, 0.25, 0
24444, 1.2416666666667, 0.24, 0
24445, 1.25, 0.25, 0
24446, 1.2583333333333, 0.24, 0
24447, 1.2666666666667, 0.25, 0
24448, 1.275, 0.24, 0
24449, 1.2833333333333, 0.25, 0
24450, 1.2916666666667, 0.24, 0
24451, 1.3, 0.25, 0
24452, 1.3083333333333, 0.24, 0
24453, 1.3166666666667, 0.25, 0
24454, 1.325, 0.24, 0
24455, 1.3333333333333, 0.25, 0
24456, 1.3416666666667, 0.24, 0
24457, 1.35, 0.25, 0
24458, 1.3583333333333, 0.24, 0
24459, 1.3666666666667, 0.25, 0
