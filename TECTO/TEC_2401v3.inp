10972, 0.66666666666667, 0.61, 0
10973, 0.65833333333333, 0.62, 0
10974, 0.66666666666667, 0.63, 0
10975, 0.65833333333333, 0.64, 0
10976, 0.66666666666667, 0.65, 0
10977, 0.65833333333333, 0.66, 0
10978, 0.66666666666667, 0.67, 0
10979, 0.65833333333333, 0.68, 0
10980, 0.66666666666667, 0.69, 0
10981, 0.65833333333333, 0.7, 0
10982, 0.66666666666667, 0.71, 0
10983, 0.65833333333333, 0.72, 0
10984, 0.66666666666667, 0.73, 0
10985, 0.65833333333333, 0.74, 0
10986, 0.66666666666667, 0.75, 0
10987, 0.65833333333333, 0.76, 0
10988, 0.66666666666667, 0.77, 0
10989, 0.65833333333333, 0.78, 0
10990, 0.66666666666667, 0.79, 0
10991, 0.65833333333333, 0.8, 0
10992, 0.66666666666667, 0.81, 0
10993, 0.65833333333333, 0.82, 0
10994, 0.66666666666667, 0.83, 0
10995, 0.65833333333333, 0.84, 0
10996, 0.66666666666667, 0.85, 0
10997, 0.65833333333333, 0.86, 0
10998, 0.66666666666667, 0.87, 0
10999, 0.65833333333333, 0.88, 0
11000, 0.66666666666667, 0.89, 0
11001, 0.65833333333333, 0.9, 0
11002, 0.66666666666667, 0.91, 0
11003, 0.65833333333333, 0.92, 0
11004, 0.66666666666667, 0.93, 0
11005, 0.65833333333333, 0.94, 0
11006, 0.66666666666667, 0.95, 0
11007, 0.65833333333333, 0.96, 0
11008, 0.66666666666667, 0.97, 0
11009, 0.65833333333333, 0.98, 0
11010, 0.66666666666667, 0.99, 0
11011, 0.65833333333333, 1, 0
11012, 0.66666666666667, 1.01, 0
11013, 0.65833333333333, 1.02, 0
11014, 0.66666666666667, 1.03, 0
11015, 0.65833333333333, 1.04, 0
11016, 0.66666666666667, 1.05, 0
11017, 0.65833333333333, 1.06, 0
11018, 0.66666666666667, 1.07, 0
11019, 0.65833333333333, 1.08, 0
11020, 0.66666666666667, 1.09, 0
11021, 0.65833333333333, 1.1, 0
11022, 0.66666666666667, 1.11, 0
11023, 0.65833333333333, 1.12, 0
11024, 0.66666666666667, 1.13, 0
11025, 0.65833333333333, 1.14, 0
11026, 0.66666666666667, 1.15, 0
11027, 0.65833333333333, 1.16, 0
11028, 0.66666666666667, 1.17, 0
11029, 0.65833333333333, 1.18, 0
11030, 0.66666666666667, 1.19, 0
11031, 0.68333333333333, 0.01, 0
11032, 0.675, 0.02, 0
11033, 0.68333333333333, 0.03, 0
11034, 0.675, 0.04, 0
11035, 0.68333333333333, 0.05, 0
11036, 0.675, 0.06, 0
11037, 0.68333333333333, 0.07, 0
11038, 0.675, 0.08, 0
11039, 0.68333333333333, 0.09, 0
11040, 0.675, 0.1, 0
11041, 0.68333333333333, 0.11, 0
11042, 0.675, 0.12, 0
11043, 0.68333333333333, 0.13, 0
11044, 0.675, 0.14, 0
11045, 0.68333333333333, 0.15, 0
11046, 0.675, 0.16, 0
11047, 0.68333333333333, 0.17, 0
11048, 0.675, 0.18, 0
11049, 0.68333333333333, 0.19, 0
11050, 0.675, 0.2, 0
11051, 0.68333333333333, 0.21, 0
11052, 0.675, 0.22, 0
11053, 0.68333333333333, 0.23, 0
11054, 0.675, 0.24, 0
11055, 0.68333333333333, 0.25, 0
11056, 0.675, 0.26, 0
11057, 0.68333333333333, 0.27, 0
11058, 0.675, 0.28, 0
11059, 0.68333333333333, 0.29, 0
11060, 0.675, 0.3, 0
11061, 0.68333333333333, 0.31, 0
11062, 0.675, 0.32, 0
11063, 0.68333333333333, 0.33, 0
11064, 0.675, 0.34, 0
11065, 0.68333333333333, 0.35, 0
11066, 0.675, 0.36, 0
11067, 0.68333333333333, 0.37, 0
11068, 0.675, 0.38, 0
11069, 0.68333333333333, 0.39, 0
11070, 0.675, 0.4, 0
11071, 0.68333333333333, 0.41, 0
11072, 0.675, 0.42, 0
11073, 0.68333333333333, 0.43, 0
11074, 0.675, 0.44, 0
11075, 0.68333333333333, 0.45, 0
11076, 0.675, 0.46, 0
11077, 0.68333333333333, 0.47, 0
11078, 0.675, 0.48, 0
11079, 0.68333333333333, 0.49, 0
11080, 0.675, 0.5, 0
11081, 0.68333333333333, 0.51, 0
11082, 0.675, 0.52, 0
11083, 0.68333333333333, 0.53, 0
11084, 0.675, 0.54, 0
11085, 0.68333333333333, 0.55, 0
11086, 0.675, 0.56, 0
11087, 0.68333333333333, 0.57, 0
11088, 0.675, 0.58, 0
11089, 0.68333333333333, 0.59, 0
11090, 0.675, 0.6, 0
11091, 0.68333333333333, 0.61, 0
11092, 0.675, 0.62, 0
11093, 0.68333333333333, 0.63, 0
11094, 0.675, 0.64, 0
11095, 0.68333333333333, 0.65, 0
11096, 0.675, 0.66, 0
11097, 0.68333333333333, 0.67, 0
11098, 0.675, 0.68, 0
11099, 0.68333333333333, 0.69, 0
11100, 0.675, 0.7, 0
11101, 0.68333333333333, 0.71, 0
11102, 0.675, 0.72, 0
11103, 0.68333333333333, 0.73, 0
11104, 0.675, 0.74, 0
11105, 0.68333333333333, 0.75, 0
11106, 0.675, 0.76, 0
11107, 0.68333333333333, 0.77, 0
11108, 0.675, 0.78, 0
11109, 0.68333333333333, 0.79, 0
11110, 0.675, 0.8, 0
11111, 0.68333333333333, 0.81, 0
11112, 0.675, 0.82, 0
11113, 0.68333333333333, 0.83, 0
11114, 0.675, 0.84, 0
11115, 0.68333333333333, 0.85, 0
11116, 0.675, 0.86, 0
11117, 0.68333333333333, 0.87, 0
11118, 0.675, 0.88, 0
11119, 0.68333333333333, 0.89, 0
11120, 0.675, 0.9, 0
11121, 0.68333333333333, 0.91, 0
11122, 0.675, 0.92, 0
11123, 0.68333333333333, 0.93, 0
11124, 0.675, 0.94, 0
11125, 0.68333333333333, 0.95, 0
11126, 0.675, 0.96, 0
11127, 0.68333333333333, 0.97, 0
11128, 0.675, 0.98, 0
11129, 0.68333333333333, 0.99, 0
11130, 0.675, 1, 0
11131, 0.68333333333333, 1.01, 0
11132, 0.675, 1.02, 0
11133, 0.68333333333333, 1.03, 0
11134, 0.675, 1.04, 0
11135, 0.68333333333333, 1.05, 0
11136, 0.675, 1.06, 0
11137, 0.68333333333333, 1.07, 0
11138, 0.675, 1.08, 0
11139, 0.68333333333333, 1.09, 0
11140, 0.675, 1.1, 0
11141, 0.68333333333333, 1.11, 0
11142, 0.675, 1.12, 0
11143, 0.68333333333333, 1.13, 0
11144, 0.675, 1.14, 0
11145, 0.68333333333333, 1.15, 0
11146, 0.675, 1.16, 0
11147, 0.68333333333333, 1.17, 0
11148, 0.675, 1.18, 0
11149, 0.68333333333333, 1.19, 0
11150, 0.7, 0.01, 0
11151, 0.69166666666667, 0.02, 0
11152, 0.7, 0.03, 0
11153, 0.69166666666667, 0.04, 0
11154, 0.7, 0.05, 0
11155, 0.69166666666667, 0.06, 0
11156, 0.7, 0.07, 0
11157, 0.69166666666667, 0.08, 0
11158, 0.7, 0.09, 0
11159, 0.69166666666667, 0.1, 0
11160, 0.7, 0.11, 0
11161, 0.69166666666667, 0.12, 0
11162, 0.7, 0.13, 0
11163, 0.69166666666667, 0.14, 0
11164, 0.7, 0.15, 0
11165, 0.69166666666667, 0.16, 0
11166, 0.7, 0.17, 0
11167, 0.69166666666667, 0.18, 0
11168, 0.7, 0.19, 0
11169, 0.69166666666667, 0.2, 0
11170, 0.7, 0.21, 0
11171, 0.69166666666667, 0.22, 0
11172, 0.7, 0.23, 0
11173, 0.69166666666667, 0.24, 0
11174, 0.7, 0.25, 0
11175, 0.69166666666667, 0.26, 0
11176, 0.7, 0.27, 0
11177, 0.69166666666667, 0.28, 0
11178, 0.7, 0.29, 0
11179, 0.69166666666667, 0.3, 0
11180, 0.7, 0.31, 0
11181, 0.69166666666667, 0.32, 0
11182, 0.7, 0.33, 0
11183, 0.69166666666667, 0.34, 0
11184, 0.7, 0.35, 0
11185, 0.69166666666667, 0.36, 0
11186, 0.7, 0.37, 0
11187, 0.69166666666667, 0.38, 0
11188, 0.7, 0.39, 0
11189, 0.69166666666667, 0.4, 0
11190, 0.7, 0.41, 0
11191, 0.69166666666667, 0.42, 0
11192, 0.7, 0.43, 0
11193, 0.69166666666667, 0.44, 0
11194, 0.7, 0.45, 0
11195, 0.69166666666667, 0.46, 0
11196, 0.7, 0.47, 0
11197, 0.69166666666667, 0.48, 0
11198, 0.7, 0.49, 0
11199, 0.69166666666667, 0.5, 0
11200, 0.7, 0.51, 0
11201, 0.69166666666667, 0.52, 0
11202, 0.7, 0.53, 0
11203, 0.69166666666667, 0.54, 0
11204, 0.7, 0.55, 0
11205, 0.69166666666667, 0.56, 0
11206, 0.7, 0.57, 0
11207, 0.69166666666667, 0.58, 0
11208, 0.7, 0.59, 0
11209, 0.69166666666667, 0.6, 0
11210, 0.7, 0.61, 0
11211, 0.69166666666667, 0.62, 0
11212, 0.7, 0.63, 0
11213, 0.69166666666667, 0.64, 0
11214, 0.7, 0.65, 0
11215, 0.69166666666667, 0.66, 0
11216, 0.7, 0.67, 0
11217, 0.69166666666667, 0.68, 0
11218, 0.7, 0.69, 0
11219, 0.69166666666667, 0.7, 0
11220, 0.7, 0.71, 0
11221, 0.69166666666667, 0.72, 0
11222, 0.7, 0.73, 0
11223, 0.69166666666667, 0.74, 0
11224, 0.7, 0.75, 0
11225, 0.69166666666667, 0.76, 0
11226, 0.7, 0.77, 0
11227, 0.69166666666667, 0.78, 0
11228, 0.7, 0.79, 0
11229, 0.69166666666667, 0.8, 0
11230, 0.7, 0.81, 0
11231, 0.69166666666667, 0.82, 0
11232, 0.7, 0.83, 0
11233, 0.69166666666667, 0.84, 0
11234, 0.7, 0.85, 0
11235, 0.69166666666667, 0.86, 0
11236, 0.7, 0.87, 0
11237, 0.69166666666667, 0.88, 0
11238, 0.7, 0.89, 0
11239, 0.69166666666667, 0.9, 0
11240, 0.7, 0.91, 0
11241, 0.69166666666667, 0.92, 0
11242, 0.7, 0.93, 0
11243, 0.69166666666667, 0.94, 0
11244, 0.7, 0.95, 0
11245, 0.69166666666667, 0.96, 0
11246, 0.7, 0.97, 0
11247, 0.69166666666667, 0.98, 0
11248, 0.7, 0.99, 0
11249, 0.69166666666667, 1, 0
11250, 0.7, 1.01, 0
11251, 0.69166666666667, 1.02, 0
11252, 0.7, 1.03, 0
11253, 0.69166666666667, 1.04, 0
11254, 0.7, 1.05, 0
11255, 0.69166666666667, 1.06, 0
11256, 0.7, 1.07, 0
11257, 0.69166666666667, 1.08, 0
11258, 0.7, 1.09, 0
11259, 0.69166666666667, 1.1, 0
11260, 0.7, 1.11, 0
11261, 0.69166666666667, 1.12, 0
11262, 0.7, 1.13, 0
11263, 0.69166666666667, 1.14, 0
11264, 0.7, 1.15, 0
11265, 0.69166666666667, 1.16, 0
11266, 0.7, 1.17, 0
11267, 0.69166666666667, 1.18, 0
11268, 0.7, 1.19, 0
11269, 0.71666666666667, 0.01, 0
11270, 0.70833333333333, 0.02, 0
11271, 0.71666666666667, 0.03, 0
11272, 0.70833333333333, 0.04, 0
11273, 0.71666666666667, 0.05, 0
11274, 0.70833333333333, 0.06, 0
11275, 0.71666666666667, 0.07, 0
11276, 0.70833333333333, 0.08, 0
11277, 0.71666666666667, 0.09, 0
11278, 0.70833333333333, 0.1, 0
11279, 0.71666666666667, 0.11, 0
11280, 0.70833333333333, 0.12, 0
11281, 0.71666666666667, 0.13, 0
11282, 0.70833333333333, 0.14, 0
11283, 0.71666666666667, 0.15, 0
11284, 0.70833333333333, 0.16, 0
11285, 0.71666666666667, 0.17, 0
11286, 0.70833333333333, 0.18, 0
11287, 0.71666666666667, 0.19, 0
11288, 0.70833333333333, 0.2, 0
11289, 0.71666666666667, 0.21, 0
11290, 0.70833333333333, 0.22, 0
11291, 0.71666666666667, 0.23, 0
11292, 0.70833333333333, 0.24, 0
11293, 0.71666666666667, 0.25, 0
11294, 0.70833333333333, 0.26, 0
11295, 0.71666666666667, 0.27, 0
11296, 0.70833333333333, 0.28, 0
11297, 0.71666666666667, 0.29, 0
11298, 0.70833333333333, 0.3, 0
11299, 0.71666666666667, 0.31, 0
11300, 0.70833333333333, 0.32, 0
11301, 0.71666666666667, 0.33, 0
11302, 0.70833333333333, 0.34, 0
11303, 0.71666666666667, 0.35, 0
11304, 0.70833333333333, 0.36, 0
11305, 0.71666666666667, 0.37, 0
11306, 0.70833333333333, 0.38, 0
11307, 0.71666666666667, 0.39, 0
11308, 0.70833333333333, 0.4, 0
11309, 0.71666666666667, 0.41, 0
11310, 0.70833333333333, 0.42, 0
11311, 0.71666666666667, 0.43, 0
11312, 0.70833333333333, 0.44, 0
11313, 0.71666666666667, 0.45, 0
11314, 0.70833333333333, 0.46, 0
11315, 0.71666666666667, 0.47, 0
11316, 0.70833333333333, 0.48, 0
11317, 0.71666666666667, 0.49, 0
11318, 0.70833333333333, 0.5, 0
11319, 0.71666666666667, 0.51, 0
11320, 0.70833333333333, 0.52, 0
11321, 0.71666666666667, 0.53, 0
11322, 0.70833333333333, 0.54, 0
11323, 0.71666666666667, 0.55, 0
11324, 0.70833333333333, 0.56, 0
11325, 0.71666666666667, 0.57, 0
11326, 0.70833333333333, 0.58, 0
11327, 0.71666666666667, 0.59, 0
11328, 0.70833333333333, 0.6, 0
11329, 0.71666666666667, 0.61, 0
11330, 0.70833333333333, 0.62, 0
11331, 0.71666666666667, 0.63, 0
11332, 0.70833333333333, 0.64, 0
11333, 0.71666666666667, 0.65, 0
11334, 0.70833333333333, 0.66, 0
11335, 0.71666666666667, 0.67, 0
11336, 0.70833333333333, 0.68, 0
11337, 0.71666666666667, 0.69, 0
11338, 0.70833333333333, 0.7, 0
11339, 0.71666666666667, 0.71, 0
11340, 0.70833333333333, 0.72, 0
11341, 0.71666666666667, 0.73, 0
11342, 0.70833333333333, 0.74, 0
11343, 0.71666666666667, 0.75, 0
11344, 0.70833333333333, 0.76, 0
11345, 0.71666666666667, 0.77, 0
11346, 0.70833333333333, 0.78, 0
11347, 0.71666666666667, 0.79, 0
11348, 0.70833333333333, 0.8, 0
11349, 0.71666666666667, 0.81, 0
11350, 0.70833333333333, 0.82, 0
11351, 0.71666666666667, 0.83, 0
11352, 0.70833333333333, 0.84, 0
11353, 0.71666666666667, 0.85, 0
11354, 0.70833333333333, 0.86, 0
11355, 0.71666666666667, 0.87, 0
11356, 0.70833333333333, 0.88, 0
11357, 0.71666666666667, 0.89, 0
11358, 0.70833333333333, 0.9, 0
11359, 0.71666666666667, 0.91, 0
11360, 0.70833333333333, 0.92, 0
11361, 0.71666666666667, 0.93, 0
11362, 0.70833333333333, 0.94, 0
11363, 0.71666666666667, 0.95, 0
11364, 0.70833333333333, 0.96, 0
11365, 0.71666666666667, 0.97, 0
11366, 0.70833333333333, 0.98, 0
11367, 0.71666666666667, 0.99, 0
11368, 0.70833333333333, 1, 0
11369, 0.71666666666667, 1.01, 0
11370, 0.70833333333333, 1.02, 0
11371, 0.71666666666667, 1.03, 0
11372, 0.70833333333333, 1.04, 0
11373, 0.71666666666667, 1.05, 0
11374, 0.70833333333333, 1.06, 0
11375, 0.71666666666667, 1.07, 0
11376, 0.70833333333333, 1.08, 0
11377, 0.71666666666667, 1.09, 0
11378, 0.70833333333333, 1.1, 0
11379, 0.71666666666667, 1.11, 0
11380, 0.70833333333333, 1.12, 0
11381, 0.71666666666667, 1.13, 0
11382, 0.70833333333333, 1.14, 0
11383, 0.71666666666667, 1.15, 0
11384, 0.70833333333333, 1.16, 0
11385, 0.71666666666667, 1.17, 0
11386, 0.70833333333333, 1.18, 0
11387, 0.71666666666667, 1.19, 0
11388, 0.73333333333333, 0.01, 0
11389, 0.725, 0.02, 0
11390, 0.73333333333333, 0.03, 0
11391, 0.725, 0.04, 0
11392, 0.73333333333333, 0.05, 0
11393, 0.725, 0.06, 0
11394, 0.73333333333333, 0.07, 0
11395, 0.725, 0.08, 0
11396, 0.73333333333333, 0.09, 0
11397, 0.725, 0.1, 0
11398, 0.73333333333333, 0.11, 0
11399, 0.725, 0.12, 0
11400, 0.73333333333333, 0.13, 0
11401, 0.725, 0.14, 0
11402, 0.73333333333333, 0.15, 0
11403, 0.725, 0.16, 0
11404, 0.73333333333333, 0.17, 0
11405, 0.725, 0.18, 0
11406, 0.73333333333333, 0.19, 0
11407, 0.725, 0.2, 0
11408, 0.73333333333333, 0.21, 0
11409, 0.725, 0.22, 0
11410, 0.73333333333333, 0.23, 0
11411, 0.725, 0.24, 0
11412, 0.73333333333333, 0.25, 0
11413, 0.725, 0.26, 0
11414, 0.73333333333333, 0.27, 0
11415, 0.725, 0.28, 0
11416, 0.73333333333333, 0.29, 0
11417, 0.725, 0.3, 0
11418, 0.73333333333333, 0.31, 0
11419, 0.725, 0.32, 0
11420, 0.73333333333333, 0.33, 0
11421, 0.725, 0.34, 0
11422, 0.73333333333333, 0.35, 0
11423, 0.725, 0.36, 0
11424, 0.73333333333333, 0.37, 0
11425, 0.725, 0.38, 0
11426, 0.73333333333333, 0.39, 0
11427, 0.725, 0.4, 0
11428, 0.73333333333333, 0.41, 0
11429, 0.725, 0.42, 0
11430, 0.73333333333333, 0.43, 0
11431, 0.725, 0.44, 0
11432, 0.73333333333333, 0.45, 0
11433, 0.725, 0.46, 0
11434, 0.73333333333333, 0.47, 0
11435, 0.725, 0.48, 0
11436, 0.73333333333333, 0.49, 0
11437, 0.725, 0.5, 0
11438, 0.73333333333333, 0.51, 0
11439, 0.725, 0.52, 0
11440, 0.73333333333333, 0.53, 0
11441, 0.725, 0.54, 0
11442, 0.73333333333333, 0.55, 0
11443, 0.725, 0.56, 0
11444, 0.73333333333333, 0.57, 0
11445, 0.725, 0.58, 0
11446, 0.73333333333333, 0.59, 0
11447, 0.725, 0.6, 0
11448, 0.73333333333333, 0.61, 0
11449, 0.725, 0.62, 0
11450, 0.73333333333333, 0.63, 0
11451, 0.725, 0.64, 0
11452, 0.73333333333333, 0.65, 0
11453, 0.725, 0.66, 0
11454, 0.73333333333333, 0.67, 0
11455, 0.725, 0.68, 0
11456, 0.73333333333333, 0.69, 0
11457, 0.725, 0.7, 0
11458, 0.73333333333333, 0.71, 0
11459, 0.725, 0.72, 0
11460, 0.73333333333333, 0.73, 0
11461, 0.725, 0.74, 0
11462, 0.73333333333333, 0.75, 0
11463, 0.725, 0.76, 0
11464, 0.73333333333333, 0.77, 0
11465, 0.725, 0.78, 0
11466, 0.73333333333333, 0.79, 0
11467, 0.725, 0.8, 0
11468, 0.73333333333333, 0.81, 0
11469, 0.725, 0.82, 0
11470, 0.73333333333333, 0.83, 0
11471, 0.725, 0.84, 0
11472, 0.73333333333333, 0.85, 0
11473, 0.725, 0.86, 0
11474, 0.73333333333333, 0.87, 0
11475, 0.725, 0.88, 0
11476, 0.73333333333333, 0.89, 0
11477, 0.725, 0.9, 0
11478, 0.73333333333333, 0.91, 0
11479, 0.725, 0.92, 0
11480, 0.73333333333333, 0.93, 0
11481, 0.725, 0.94, 0
11482, 0.73333333333333, 0.95, 0
11483, 0.725, 0.96, 0
11484, 0.73333333333333, 0.97, 0
11485, 0.725, 0.98, 0
11486, 0.73333333333333, 0.99, 0
11487, 0.725, 1, 0
11488, 0.73333333333333, 1.01, 0
11489, 0.725, 1.02, 0
11490, 0.73333333333333, 1.03, 0
11491, 0.725, 1.04, 0
11492, 0.73333333333333, 1.05, 0
11493, 0.725, 1.06, 0
11494, 0.73333333333333, 1.07, 0
11495, 0.725, 1.08, 0
11496, 0.73333333333333, 1.09, 0
11497, 0.725, 1.1, 0
11498, 0.73333333333333, 1.11, 0
11499, 0.725, 1.12, 0
11500, 0.73333333333333, 1.13, 0
11501, 0.725, 1.14, 0
11502, 0.73333333333333, 1.15, 0
11503, 0.725, 1.16, 0
11504, 0.73333333333333, 1.17, 0
11505, 0.725, 1.18, 0
11506, 0.73333333333333, 1.19, 0
11507, 0.75, 0.01, 0
11508, 0.74166666666667, 0.02, 0
11509, 0.75, 0.03, 0
11510, 0.74166666666667, 0.04, 0
11511, 0.75, 0.05, 0
11512, 0.74166666666667, 0.06, 0
11513, 0.75, 0.07, 0
11514, 0.74166666666667, 0.08, 0
11515, 0.75, 0.09, 0
11516, 0.74166666666667, 0.1, 0
11517, 0.75, 0.11, 0
11518, 0.74166666666667, 0.12, 0
11519, 0.75, 0.13, 0
11520, 0.74166666666667, 0.14, 0
11521, 0.75, 0.15, 0
11522, 0.74166666666667, 0.16, 0
11523, 0.75, 0.17, 0
11524, 0.74166666666667, 0.18, 0
11525, 0.75, 0.19, 0
11526, 0.74166666666667, 0.2, 0
11527, 0.75, 0.21, 0
11528, 0.74166666666667, 0.22, 0
11529, 0.75, 0.23, 0
11530, 0.74166666666667, 0.24, 0
11531, 0.75, 0.25, 0
11532, 0.74166666666667, 0.26, 0
11533, 0.75, 0.27, 0
11534, 0.74166666666667, 0.28, 0
11535, 0.75, 0.29, 0
11536, 0.74166666666667, 0.3, 0
11537, 0.75, 0.31, 0
11538, 0.74166666666667, 0.32, 0
11539, 0.75, 0.33, 0
11540, 0.74166666666667, 0.34, 0
11541, 0.75, 0.35, 0
11542, 0.74166666666667, 0.36, 0
11543, 0.75, 0.37, 0
11544, 0.74166666666667, 0.38, 0
11545, 0.75, 0.39, 0
11546, 0.74166666666667, 0.4, 0
11547, 0.75, 0.41, 0
11548, 0.74166666666667, 0.42, 0
11549, 0.75, 0.43, 0
11550, 0.74166666666667, 0.44, 0
11551, 0.75, 0.45, 0
11552, 0.74166666666667, 0.46, 0
11553, 0.75, 0.47, 0
11554, 0.74166666666667, 0.48, 0
11555, 0.75, 0.49, 0
11556, 0.74166666666667, 0.5, 0
11557, 0.75, 0.51, 0
11558, 0.74166666666667, 0.52, 0
11559, 0.75, 0.53, 0
11560, 0.74166666666667, 0.54, 0
11561, 0.75, 0.55, 0
11562, 0.74166666666667, 0.56, 0
11563, 0.75, 0.57, 0
11564, 0.74166666666667, 0.58, 0
11565, 0.75, 0.59, 0
11566, 0.74166666666667, 0.6, 0
11567, 0.75, 0.61, 0
11568, 0.74166666666667, 0.62, 0
11569, 0.75, 0.63, 0
11570, 0.74166666666667, 0.64, 0
11571, 0.75, 0.65, 0
11572, 0.74166666666667, 0.66, 0
11573, 0.75, 0.67, 0
11574, 0.74166666666667, 0.68, 0
11575, 0.75, 0.69, 0
11576, 0.74166666666667, 0.7, 0
11577, 0.75, 0.71, 0
11578, 0.74166666666667, 0.72, 0
11579, 0.75, 0.73, 0
11580, 0.74166666666667, 0.74, 0
11581, 0.75, 0.75, 0
11582, 0.74166666666667, 0.76, 0
11583, 0.75, 0.77, 0
11584, 0.74166666666667, 0.78, 0
11585, 0.75, 0.79, 0
11586, 0.74166666666667, 0.8, 0
11587, 0.75, 0.81, 0
11588, 0.74166666666667, 0.82, 0
11589, 0.75, 0.83, 0
11590, 0.74166666666667, 0.84, 0
11591, 0.75, 0.85, 0
11592, 0.74166666666667, 0.86, 0
11593, 0.75, 0.87, 0
11594, 0.74166666666667, 0.88, 0
11595, 0.75, 0.89, 0
11596, 0.74166666666667, 0.9, 0
11597, 0.75, 0.91, 0
11598, 0.74166666666667, 0.92, 0
11599, 0.75, 0.93, 0
11600, 0.74166666666667, 0.94, 0
11601, 0.75, 0.95, 0
11602, 0.74166666666667, 0.96, 0
11603, 0.75, 0.97, 0
11604, 0.74166666666667, 0.98, 0
11605, 0.75, 0.99, 0
11606, 0.74166666666667, 1, 0
11607, 0.75, 1.01, 0
11608, 0.74166666666667, 1.02, 0
11609, 0.75, 1.03, 0
11610, 0.74166666666667, 1.04, 0
11611, 0.75, 1.05, 0
11612, 0.74166666666667, 1.06, 0
11613, 0.75, 1.07, 0
11614, 0.74166666666667, 1.08, 0
11615, 0.75, 1.09, 0
11616, 0.74166666666667, 1.1, 0
11617, 0.75, 1.11, 0
11618, 0.74166666666667, 1.12, 0
11619, 0.75, 1.13, 0
11620, 0.74166666666667, 1.14, 0
11621, 0.75, 1.15, 0
11622, 0.74166666666667, 1.16, 0
11623, 0.75, 1.17, 0
11624, 0.74166666666667, 1.18, 0
11625, 0.75, 1.19, 0
11626, 0.76666666666667, 0.01, 0
11627, 0.75833333333333, 0.02, 0
11628, 0.76666666666667, 0.03, 0
11629, 0.75833333333333, 0.04, 0
11630, 0.76666666666667, 0.05, 0
11631, 0.75833333333333, 0.06, 0
11632, 0.76666666666667, 0.07, 0
11633, 0.75833333333333, 0.08, 0
11634, 0.76666666666667, 0.09, 0
11635, 0.75833333333333, 0.1, 0
11636, 0.76666666666667, 0.11, 0
11637, 0.75833333333333, 0.12, 0
11638, 0.76666666666667, 0.13, 0
11639, 0.75833333333333, 0.14, 0
11640, 0.76666666666667, 0.15, 0
11641, 0.75833333333333, 0.16, 0
11642, 0.76666666666667, 0.17, 0
11643, 0.75833333333333, 0.18, 0
11644, 0.76666666666667, 0.19, 0
11645, 0.75833333333333, 0.2, 0
11646, 0.76666666666667, 0.21, 0
11647, 0.75833333333333, 0.22, 0
11648, 0.76666666666667, 0.23, 0
11649, 0.75833333333333, 0.24, 0
11650, 0.76666666666667, 0.25, 0
11651, 0.75833333333333, 0.26, 0
11652, 0.76666666666667, 0.27, 0
11653, 0.75833333333333, 0.28, 0
11654, 0.76666666666667, 0.29, 0
11655, 0.75833333333333, 0.3, 0
11656, 0.76666666666667, 0.31, 0
11657, 0.75833333333333, 0.32, 0
11658, 0.76666666666667, 0.33, 0
11659, 0.75833333333333, 0.34, 0
11660, 0.76666666666667, 0.35, 0
11661, 0.75833333333333, 0.36, 0
11662, 0.76666666666667, 0.37, 0
11663, 0.75833333333333, 0.38, 0
11664, 0.76666666666667, 0.39, 0
11665, 0.75833333333333, 0.4, 0
11666, 0.76666666666667, 0.41, 0
11667, 0.75833333333333, 0.42, 0
11668, 0.76666666666667, 0.43, 0
11669, 0.75833333333333, 0.44, 0
11670, 0.76666666666667, 0.45, 0
11671, 0.75833333333333, 0.46, 0
11672, 0.76666666666667, 0.47, 0
11673, 0.75833333333333, 0.48, 0
11674, 0.76666666666667, 0.49, 0
11675, 0.75833333333333, 0.5, 0
11676, 0.76666666666667, 0.51, 0
11677, 0.75833333333333, 0.52, 0
11678, 0.76666666666667, 0.53, 0
11679, 0.75833333333333, 0.54, 0
11680, 0.76666666666667, 0.55, 0
11681, 0.75833333333333, 0.56, 0
11682, 0.76666666666667, 0.57, 0
11683, 0.75833333333333, 0.58, 0
11684, 0.76666666666667, 0.59, 0
11685, 0.75833333333333, 0.6, 0
11686, 0.76666666666667, 0.61, 0
11687, 0.75833333333333, 0.62, 0
11688, 0.76666666666667, 0.63, 0
11689, 0.75833333333333, 0.64, 0
11690, 0.76666666666667, 0.65, 0
11691, 0.75833333333333, 0.66, 0
11692, 0.76666666666667, 0.67, 0
11693, 0.75833333333333, 0.68, 0
11694, 0.76666666666667, 0.69, 0
11695, 0.75833333333333, 0.7, 0
11696, 0.76666666666667, 0.71, 0
11697, 0.75833333333333, 0.72, 0
11698, 0.76666666666667, 0.73, 0
11699, 0.75833333333333, 0.74, 0
11700, 0.76666666666667, 0.75, 0
11701, 0.75833333333333, 0.76, 0
11702, 0.76666666666667, 0.77, 0
11703, 0.75833333333333, 0.78, 0
11704, 0.76666666666667, 0.79, 0
11705, 0.75833333333333, 0.8, 0
11706, 0.76666666666667, 0.81, 0
11707, 0.75833333333333, 0.82, 0
11708, 0.76666666666667, 0.83, 0
11709, 0.75833333333333, 0.84, 0
11710, 0.76666666666667, 0.85, 0
11711, 0.75833333333333, 0.86, 0
11712, 0.76666666666667, 0.87, 0
11713, 0.75833333333333, 0.88, 0
11714, 0.76666666666667, 0.89, 0
11715, 0.75833333333333, 0.9, 0
11716, 0.76666666666667, 0.91, 0
11717, 0.75833333333333, 0.92, 0
11718, 0.76666666666667, 0.93, 0
11719, 0.75833333333333, 0.94, 0
11720, 0.76666666666667, 0.95, 0
11721, 0.75833333333333, 0.96, 0
11722, 0.76666666666667, 0.97, 0
11723, 0.75833333333333, 0.98, 0
11724, 0.76666666666667, 0.99, 0
11725, 0.75833333333333, 1, 0
11726, 0.76666666666667, 1.01, 0
11727, 0.75833333333333, 1.02, 0
11728, 0.76666666666667, 1.03, 0
11729, 0.75833333333333, 1.04, 0
11730, 0.76666666666667, 1.05, 0
11731, 0.75833333333333, 1.06, 0
11732, 0.76666666666667, 1.07, 0
11733, 0.75833333333333, 1.08, 0
11734, 0.76666666666667, 1.09, 0
11735, 0.75833333333333, 1.1, 0
11736, 0.76666666666667, 1.11, 0
11737, 0.75833333333333, 1.12, 0
11738, 0.76666666666667, 1.13, 0
11739, 0.75833333333333, 1.14, 0
11740, 0.76666666666667, 1.15, 0
11741, 0.75833333333333, 1.16, 0
11742, 0.76666666666667, 1.17, 0
11743, 0.75833333333333, 1.18, 0
11744, 0.76666666666667, 1.19, 0
11745, 0.78333333333333, 0.01, 0
11746, 0.775, 0.02, 0
11747, 0.78333333333333, 0.03, 0
11748, 0.775, 0.04, 0
11749, 0.78333333333333, 0.05, 0
11750, 0.775, 0.06, 0
11751, 0.78333333333333, 0.07, 0
11752, 0.775, 0.08, 0
11753, 0.78333333333333, 0.09, 0
11754, 0.775, 0.1, 0
11755, 0.78333333333333, 0.11, 0
11756, 0.775, 0.12, 0
11757, 0.78333333333333, 0.13, 0
11758, 0.775, 0.14, 0
11759, 0.78333333333333, 0.15, 0
11760, 0.775, 0.16, 0
11761, 0.78333333333333, 0.17, 0
11762, 0.775, 0.18, 0
11763, 0.78333333333333, 0.19, 0
11764, 0.775, 0.2, 0
11765, 0.78333333333333, 0.21, 0
11766, 0.775, 0.22, 0
11767, 0.78333333333333, 0.23, 0
11768, 0.775, 0.24, 0
11769, 0.78333333333333, 0.25, 0
11770, 0.775, 0.26, 0
11771, 0.78333333333333, 0.27, 0
11772, 0.775, 0.28, 0
11773, 0.78333333333333, 0.29, 0
11774, 0.775, 0.3, 0
11775, 0.78333333333333, 0.31, 0
11776, 0.775, 0.32, 0
11777, 0.78333333333333, 0.33, 0
11778, 0.775, 0.34, 0
11779, 0.78333333333333, 0.35, 0
11780, 0.775, 0.36, 0
11781, 0.78333333333333, 0.37, 0
11782, 0.775, 0.38, 0
11783, 0.78333333333333, 0.39, 0
11784, 0.775, 0.4, 0
11785, 0.78333333333333, 0.41, 0
11786, 0.775, 0.42, 0
11787, 0.78333333333333, 0.43, 0
11788, 0.775, 0.44, 0
11789, 0.78333333333333, 0.45, 0
11790, 0.775, 0.46, 0
11791, 0.78333333333333, 0.47, 0
11792, 0.775, 0.48, 0
11793, 0.78333333333333, 0.49, 0
11794, 0.775, 0.5, 0
11795, 0.78333333333333, 0.51, 0
11796, 0.775, 0.52, 0
11797, 0.78333333333333, 0.53, 0
11798, 0.775, 0.54, 0
11799, 0.78333333333333, 0.55, 0
11800, 0.775, 0.56, 0
11801, 0.78333333333333, 0.57, 0
11802, 0.775, 0.58, 0
11803, 0.78333333333333, 0.59, 0
11804, 0.775, 0.6, 0
11805, 0.78333333333333, 0.61, 0
11806, 0.775, 0.62, 0
11807, 0.78333333333333, 0.63, 0
11808, 0.775, 0.64, 0
11809, 0.78333333333333, 0.65, 0
11810, 0.775, 0.66, 0
11811, 0.78333333333333, 0.67, 0
11812, 0.775, 0.68, 0
11813, 0.78333333333333, 0.69, 0
11814, 0.775, 0.7, 0
11815, 0.78333333333333, 0.71, 0
11816, 0.775, 0.72, 0
11817, 0.78333333333333, 0.73, 0
11818, 0.775, 0.74, 0
11819, 0.78333333333333, 0.75, 0
11820, 0.775, 0.76, 0
11821, 0.78333333333333, 0.77, 0
11822, 0.775, 0.78, 0
11823, 0.78333333333333, 0.79, 0
11824, 0.775, 0.8, 0
11825, 0.78333333333333, 0.81, 0
11826, 0.775, 0.82, 0
11827, 0.78333333333333, 0.83, 0
11828, 0.775, 0.84, 0
11829, 0.78333333333333, 0.85, 0
11830, 0.775, 0.86, 0
11831, 0.78333333333333, 0.87, 0
11832, 0.775, 0.88, 0
11833, 0.78333333333333, 0.89, 0
11834, 0.775, 0.9, 0
11835, 0.78333333333333, 0.91, 0
11836, 0.775, 0.92, 0
11837, 0.78333333333333, 0.93, 0
11838, 0.775, 0.94, 0
11839, 0.78333333333333, 0.95, 0
11840, 0.775, 0.96, 0
11841, 0.78333333333333, 0.97, 0
11842, 0.775, 0.98, 0
11843, 0.78333333333333, 0.99, 0
11844, 0.775, 1, 0
11845, 0.78333333333333, 1.01, 0
11846, 0.775, 1.02, 0
11847, 0.78333333333333, 1.03, 0
11848, 0.775, 1.04, 0
11849, 0.78333333333333, 1.05, 0
11850, 0.775, 1.06, 0
11851, 0.78333333333333, 1.07, 0
11852, 0.775, 1.08, 0
11853, 0.78333333333333, 1.09, 0
11854, 0.775, 1.1, 0
11855, 0.78333333333333, 1.11, 0
11856, 0.775, 1.12, 0
11857, 0.78333333333333, 1.13, 0
11858, 0.775, 1.14, 0
11859, 0.78333333333333, 1.15, 0
11860, 0.775, 1.16, 0
11861, 0.78333333333333, 1.17, 0
11862, 0.775, 1.18, 0
11863, 0.78333333333333, 1.19, 0
11864, 0.8, 0.01, 0
11865, 0.79166666666667, 0.02, 0
11866, 0.8, 0.03, 0
11867, 0.79166666666667, 0.04, 0
11868, 0.8, 0.05, 0
11869, 0.79166666666667, 0.06, 0
11870, 0.8, 0.07, 0
11871, 0.79166666666667, 0.08, 0
11872, 0.8, 0.09, 0
11873, 0.79166666666667, 0.1, 0
11874, 0.8, 0.11, 0
11875, 0.79166666666667, 0.12, 0
11876, 0.8, 0.13, 0
11877, 0.79166666666667, 0.14, 0
11878, 0.8, 0.15, 0
11879, 0.79166666666667, 0.16, 0
11880, 0.8, 0.17, 0
11881, 0.79166666666667, 0.18, 0
11882, 0.8, 0.19, 0
11883, 0.79166666666667, 0.2, 0
11884, 0.8, 0.21, 0
11885, 0.79166666666667, 0.22, 0
11886, 0.8, 0.23, 0
11887, 0.79166666666667, 0.24, 0
11888, 0.8, 0.25, 0
11889, 0.79166666666667, 0.26, 0
11890, 0.8, 0.27, 0
11891, 0.79166666666667, 0.28, 0
11892, 0.8, 0.29, 0
11893, 0.79166666666667, 0.3, 0
11894, 0.8, 0.31, 0
11895, 0.79166666666667, 0.32, 0
11896, 0.8, 0.33, 0
11897, 0.79166666666667, 0.34, 0
11898, 0.8, 0.35, 0
11899, 0.79166666666667, 0.36, 0
11900, 0.8, 0.37, 0
11901, 0.79166666666667, 0.38, 0
11902, 0.8, 0.39, 0
11903, 0.79166666666667, 0.4, 0
11904, 0.8, 0.41, 0
11905, 0.79166666666667, 0.42, 0
11906, 0.8, 0.43, 0
11907, 0.79166666666667, 0.44, 0
11908, 0.8, 0.45, 0
11909, 0.79166666666667, 0.46, 0
11910, 0.8, 0.47, 0
11911, 0.79166666666667, 0.48, 0
11912, 0.8, 0.49, 0
11913, 0.79166666666667, 0.5, 0
11914, 0.8, 0.51, 0
11915, 0.79166666666667, 0.52, 0
11916, 0.8, 0.53, 0
11917, 0.79166666666667, 0.54, 0
11918, 0.8, 0.55, 0
11919, 0.79166666666667, 0.56, 0
11920, 0.8, 0.57, 0
11921, 0.79166666666667, 0.58, 0
11922, 0.8, 0.59, 0
11923, 0.79166666666667, 0.6, 0
11924, 0.8, 0.61, 0
11925, 0.79166666666667, 0.62, 0
11926, 0.8, 0.63, 0
11927, 0.79166666666667, 0.64, 0
11928, 0.8, 0.65, 0
11929, 0.79166666666667, 0.66, 0
11930, 0.8, 0.67, 0
11931, 0.79166666666667, 0.68, 0
11932, 0.8, 0.69, 0
11933, 0.79166666666667, 0.7, 0
11934, 0.8, 0.71, 0
11935, 0.79166666666667, 0.72, 0
11936, 0.8, 0.73, 0
11937, 0.79166666666667, 0.74, 0
11938, 0.8, 0.75, 0
11939, 0.79166666666667, 0.76, 0
11940, 0.8, 0.77, 0
11941, 0.79166666666667, 0.78, 0
11942, 0.8, 0.79, 0
11943, 0.79166666666667, 0.8, 0
11944, 0.8, 0.81, 0
11945, 0.79166666666667, 0.82, 0
11946, 0.8, 0.83, 0
11947, 0.79166666666667, 0.84, 0
11948, 0.8, 0.85, 0
11949, 0.79166666666667, 0.86, 0
11950, 0.8, 0.87, 0
11951, 0.79166666666667, 0.88, 0
11952, 0.8, 0.89, 0
11953, 0.79166666666667, 0.9, 0
11954, 0.8, 0.91, 0
11955, 0.79166666666667, 0.92, 0
11956, 0.8, 0.93, 0
11957, 0.79166666666667, 0.94, 0
11958, 0.8, 0.95, 0
11959, 0.79166666666667, 0.96, 0
11960, 0.8, 0.97, 0
11961, 0.79166666666667, 0.98, 0
11962, 0.8, 0.99, 0
11963, 0.79166666666667, 1, 0
11964, 0.8, 1.01, 0
11965, 0.79166666666667, 1.02, 0
11966, 0.8, 1.03, 0
11967, 0.79166666666667, 1.04, 0
11968, 0.8, 1.05, 0
11969, 0.79166666666667, 1.06, 0
11970, 0.8, 1.07, 0
11971, 0.79166666666667, 1.08, 0
11972, 0.8, 1.09, 0
11973, 0.79166666666667, 1.1, 0
11974, 0.8, 1.11, 0
11975, 0.79166666666667, 1.12, 0
11976, 0.8, 1.13, 0
11977, 0.79166666666667, 1.14, 0
11978, 0.8, 1.15, 0
11979, 0.79166666666667, 1.16, 0
11980, 0.8, 1.17, 0
11981, 0.79166666666667, 1.18, 0
11982, 0.8, 1.19, 0
11983, 0.81666666666667, 0.01, 0
11984, 0.80833333333333, 0.02, 0
11985, 0.81666666666667, 0.03, 0
11986, 0.80833333333333, 0.04, 0
11987, 0.81666666666667, 0.05, 0
11988, 0.80833333333333, 0.06, 0
11989, 0.81666666666667, 0.07, 0
11990, 0.80833333333333, 0.08, 0
11991, 0.81666666666667, 0.09, 0
11992, 0.80833333333333, 0.1, 0
11993, 0.81666666666667, 0.11, 0
11994, 0.80833333333333, 0.12, 0
11995, 0.81666666666667, 0.13, 0
11996, 0.80833333333333, 0.14, 0
11997, 0.81666666666667, 0.15, 0
11998, 0.80833333333333, 0.16, 0
11999, 0.81666666666667, 0.17, 0
12000, 0.80833333333333, 0.18, 0
12001, 0.81666666666667, 0.19, 0
12002, 0.80833333333333, 0.2, 0
12003, 0.81666666666667, 0.21, 0
12004, 0.80833333333333, 0.22, 0
12005, 0.81666666666667, 0.23, 0
12006, 0.80833333333333, 0.24, 0
12007, 0.81666666666667, 0.25, 0
12008, 0.80833333333333, 0.26, 0
12009, 0.81666666666667, 0.27, 0
12010, 0.80833333333333, 0.28, 0
12011, 0.81666666666667, 0.29, 0
12012, 0.80833333333333, 0.3, 0
12013, 0.81666666666667, 0.31, 0
12014, 0.80833333333333, 0.32, 0
12015, 0.81666666666667, 0.33, 0
12016, 0.80833333333333, 0.34, 0
12017, 0.81666666666667, 0.35, 0
12018, 0.80833333333333, 0.36, 0
12019, 0.81666666666667, 0.37, 0
12020, 0.80833333333333, 0.38, 0
12021, 0.81666666666667, 0.39, 0
12022, 0.80833333333333, 0.4, 0
12023, 0.81666666666667, 0.41, 0
12024, 0.80833333333333, 0.42, 0
12025, 0.81666666666667, 0.43, 0
12026, 0.80833333333333, 0.44, 0
12027, 0.81666666666667, 0.45, 0
12028, 0.80833333333333, 0.46, 0
12029, 0.81666666666667, 0.47, 0
12030, 0.80833333333333, 0.48, 0
12031, 0.81666666666667, 0.49, 0
12032, 0.80833333333333, 0.5, 0
12033, 0.81666666666667, 0.51, 0
12034, 0.80833333333333, 0.52, 0
12035, 0.81666666666667, 0.53, 0
12036, 0.80833333333333, 0.54, 0
12037, 0.81666666666667, 0.55, 0
12038, 0.80833333333333, 0.56, 0
12039, 0.81666666666667, 0.57, 0
12040, 0.80833333333333, 0.58, 0
12041, 0.81666666666667, 0.59, 0
12042, 0.80833333333333, 0.6, 0
12043, 0.81666666666667, 0.61, 0
12044, 0.80833333333333, 0.62, 0
12045, 0.81666666666667, 0.63, 0
12046, 0.80833333333333, 0.64, 0
12047, 0.81666666666667, 0.65, 0
12048, 0.80833333333333, 0.66, 0
12049, 0.81666666666667, 0.67, 0
12050, 0.80833333333333, 0.68, 0
12051, 0.81666666666667, 0.69, 0
12052, 0.80833333333333, 0.7, 0
12053, 0.81666666666667, 0.71, 0
12054, 0.80833333333333, 0.72, 0
12055, 0.81666666666667, 0.73, 0
12056, 0.80833333333333, 0.74, 0
12057, 0.81666666666667, 0.75, 0
12058, 0.80833333333333, 0.76, 0
12059, 0.81666666666667, 0.77, 0
12060, 0.80833333333333, 0.78, 0
12061, 0.81666666666667, 0.79, 0
12062, 0.80833333333333, 0.8, 0
12063, 0.81666666666667, 0.81, 0
12064, 0.80833333333333, 0.82, 0
12065, 0.81666666666667, 0.83, 0
12066, 0.80833333333333, 0.84, 0
12067, 0.81666666666667, 0.85, 0
12068, 0.80833333333333, 0.86, 0
12069, 0.81666666666667, 0.87, 0
12070, 0.80833333333333, 0.88, 0
12071, 0.81666666666667, 0.89, 0
12072, 0.80833333333333, 0.9, 0
12073, 0.81666666666667, 0.91, 0
12074, 0.80833333333333, 0.92, 0
12075, 0.81666666666667, 0.93, 0
12076, 0.80833333333333, 0.94, 0
12077, 0.81666666666667, 0.95, 0
12078, 0.80833333333333, 0.96, 0
12079, 0.81666666666667, 0.97, 0
12080, 0.80833333333333, 0.98, 0
12081, 0.81666666666667, 0.99, 0
12082, 0.80833333333333, 1, 0
12083, 0.81666666666667, 1.01, 0
12084, 0.80833333333333, 1.02, 0
12085, 0.81666666666667, 1.03, 0
12086, 0.80833333333333, 1.04, 0
12087, 0.81666666666667, 1.05, 0
12088, 0.80833333333333, 1.06, 0
12089, 0.81666666666667, 1.07, 0
12090, 0.80833333333333, 1.08, 0
12091, 0.81666666666667, 1.09, 0
12092, 0.80833333333333, 1.1, 0
12093, 0.81666666666667, 1.11, 0
12094, 0.80833333333333, 1.12, 0
12095, 0.81666666666667, 1.13, 0
12096, 0.80833333333333, 1.14, 0
12097, 0.81666666666667, 1.15, 0
12098, 0.80833333333333, 1.16, 0
12099, 0.81666666666667, 1.17, 0
12100, 0.80833333333333, 1.18, 0
12101, 0.81666666666667, 1.19, 0
12102, 0.83333333333333, 0.01, 0
12103, 0.825, 0.02, 0
12104, 0.83333333333333, 0.03, 0
12105, 0.825, 0.04, 0
12106, 0.83333333333333, 0.05, 0
12107, 0.825, 0.06, 0
12108, 0.83333333333333, 0.07, 0
12109, 0.825, 0.08, 0
12110, 0.83333333333333, 0.09, 0
12111, 0.825, 0.1, 0
12112, 0.83333333333333, 0.11, 0
12113, 0.825, 0.12, 0
12114, 0.83333333333333, 0.13, 0
12115, 0.825, 0.14, 0
12116, 0.83333333333333, 0.15, 0
12117, 0.825, 0.16, 0
12118, 0.83333333333333, 0.17, 0
12119, 0.825, 0.18, 0
12120, 0.83333333333333, 0.19, 0
12121, 0.825, 0.2, 0
12122, 0.83333333333333, 0.21, 0
12123, 0.825, 0.22, 0
12124, 0.83333333333333, 0.23, 0
12125, 0.825, 0.24, 0
12126, 0.83333333333333, 0.25, 0
12127, 0.825, 0.26, 0
12128, 0.83333333333333, 0.27, 0
12129, 0.825, 0.28, 0
12130, 0.83333333333333, 0.29, 0
12131, 0.825, 0.3, 0
12132, 0.83333333333333, 0.31, 0
12133, 0.825, 0.32, 0
12134, 0.83333333333333, 0.33, 0
12135, 0.825, 0.34, 0
12136, 0.83333333333333, 0.35, 0
12137, 0.825, 0.36, 0
12138, 0.83333333333333, 0.37, 0
12139, 0.825, 0.38, 0
12140, 0.83333333333333, 0.39, 0
12141, 0.825, 0.4, 0
12142, 0.83333333333333, 0.41, 0
12143, 0.825, 0.42, 0
12144, 0.83333333333333, 0.43, 0
12145, 0.825, 0.44, 0
12146, 0.83333333333333, 0.45, 0
12147, 0.825, 0.46, 0
12148, 0.83333333333333, 0.47, 0
12149, 0.825, 0.48, 0
12150, 0.83333333333333, 0.49, 0
12151, 0.825, 0.5, 0
12152, 0.83333333333333, 0.51, 0
12153, 0.825, 0.52, 0
12154, 0.83333333333333, 0.53, 0
12155, 0.825, 0.54, 0
12156, 0.83333333333333, 0.55, 0
12157, 0.825, 0.56, 0
12158, 0.83333333333333, 0.57, 0
12159, 0.825, 0.58, 0
12160, 0.83333333333333, 0.59, 0
12161, 0.825, 0.6, 0
12162, 0.83333333333333, 0.61, 0
12163, 0.825, 0.62, 0
12164, 0.83333333333333, 0.63, 0
12165, 0.825, 0.64, 0
12166, 0.83333333333333, 0.65, 0
12167, 0.825, 0.66, 0
12168, 0.83333333333333, 0.67, 0
12169, 0.825, 0.68, 0
12170, 0.83333333333333, 0.69, 0
12171, 0.825, 0.7, 0
12172, 0.83333333333333, 0.71, 0
12173, 0.825, 0.72, 0
12174, 0.83333333333333, 0.73, 0
12175, 0.825, 0.74, 0
12176, 0.83333333333333, 0.75, 0
12177, 0.825, 0.76, 0
12178, 0.83333333333333, 0.77, 0
12179, 0.825, 0.78, 0
12180, 0.83333333333333, 0.79, 0
12181, 0.825, 0.8, 0
12182, 0.83333333333333, 0.81, 0
12183, 0.825, 0.82, 0
12184, 0.83333333333333, 0.83, 0
12185, 0.825, 0.84, 0
12186, 0.83333333333333, 0.85, 0
12187, 0.825, 0.86, 0
12188, 0.83333333333333, 0.87, 0
12189, 0.825, 0.88, 0
12190, 0.83333333333333, 0.89, 0
12191, 0.825, 0.9, 0
12192, 0.83333333333333, 0.91, 0
12193, 0.825, 0.92, 0
12194, 0.83333333333333, 0.93, 0
12195, 0.825, 0.94, 0
12196, 0.83333333333333, 0.95, 0
12197, 0.825, 0.96, 0
12198, 0.83333333333333, 0.97, 0
12199, 0.825, 0.98, 0
12200, 0.83333333333333, 0.99, 0
12201, 0.825, 1, 0
12202, 0.83333333333333, 1.01, 0
12203, 0.825, 1.02, 0
12204, 0.83333333333333, 1.03, 0
12205, 0.825, 1.04, 0
12206, 0.83333333333333, 1.05, 0
12207, 0.825, 1.06, 0
12208, 0.83333333333333, 1.07, 0
12209, 0.825, 1.08, 0
12210, 0.83333333333333, 1.09, 0
12211, 0.825, 1.1, 0
12212, 0.83333333333333, 1.11, 0
12213, 0.825, 1.12, 0
12214, 0.83333333333333, 1.13, 0
12215, 0.825, 1.14, 0
12216, 0.83333333333333, 1.15, 0
12217, 0.825, 1.16, 0
12218, 0.83333333333333, 1.17, 0
12219, 0.825, 1.18, 0
12220, 0.83333333333333, 1.19, 0
12221, 0.85, 0.01, 0
12222, 0.84166666666667, 0.02, 0
12223, 0.85, 0.03, 0
12224, 0.84166666666667, 0.04, 0
12225, 0.85, 0.05, 0
12226, 0.84166666666667, 0.06, 0
12227, 0.85, 0.07, 0
12228, 0.84166666666667, 0.08, 0
12229, 0.85, 0.09, 0
12230, 0.84166666666667, 0.1, 0
12231, 0.85, 0.11, 0
12232, 0.84166666666667, 0.12, 0
12233, 0.85, 0.13, 0
12234, 0.84166666666667, 0.14, 0
12235, 0.85, 0.15, 0
12236, 0.84166666666667, 0.16, 0
12237, 0.85, 0.17, 0
12238, 0.84166666666667, 0.18, 0
12239, 0.85, 0.19, 0
12240, 0.84166666666667, 0.2, 0
12241, 0.85, 0.21, 0
12242, 0.84166666666667, 0.22, 0
12243, 0.85, 0.23, 0
12244, 0.84166666666667, 0.24, 0
12245, 0.85, 0.25, 0
12246, 0.84166666666667, 0.26, 0
12247, 0.85, 0.27, 0
12248, 0.84166666666667, 0.28, 0
12249, 0.85, 0.29, 0
12250, 0.84166666666667, 0.3, 0
12251, 0.85, 0.31, 0
12252, 0.84166666666667, 0.32, 0
12253, 0.85, 0.33, 0
12254, 0.84166666666667, 0.34, 0
12255, 0.85, 0.35, 0
12256, 0.84166666666667, 0.36, 0
12257, 0.85, 0.37, 0
12258, 0.84166666666667, 0.38, 0
12259, 0.85, 0.39, 0
12260, 0.84166666666667, 0.4, 0
12261, 0.85, 0.41, 0
12262, 0.84166666666667, 0.42, 0
12263, 0.85, 0.43, 0
12264, 0.84166666666667, 0.44, 0
12265, 0.85, 0.45, 0
12266, 0.84166666666667, 0.46, 0
12267, 0.85, 0.47, 0
12268, 0.84166666666667, 0.48, 0
12269, 0.85, 0.49, 0
12270, 0.84166666666667, 0.5, 0
12271, 0.85, 0.51, 0
12272, 0.84166666666667, 0.52, 0
12273, 0.85, 0.53, 0
12274, 0.84166666666667, 0.54, 0
12275, 0.85, 0.55, 0
12276, 0.84166666666667, 0.56, 0
12277, 0.85, 0.57, 0
12278, 0.84166666666667, 0.58, 0
12279, 0.85, 0.59, 0
12280, 0.84166666666667, 0.6, 0
12281, 0.85, 0.61, 0
12282, 0.84166666666667, 0.62, 0
12283, 0.85, 0.63, 0
12284, 0.84166666666667, 0.64, 0
12285, 0.85, 0.65, 0
12286, 0.84166666666667, 0.66, 0
12287, 0.85, 0.67, 0
12288, 0.84166666666667, 0.68, 0
12289, 0.85, 0.69, 0
12290, 0.84166666666667, 0.7, 0
12291, 0.85, 0.71, 0
12292, 0.84166666666667, 0.72, 0
12293, 0.85, 0.73, 0
12294, 0.84166666666667, 0.74, 0
12295, 0.85, 0.75, 0
12296, 0.84166666666667, 0.76, 0
12297, 0.85, 0.77, 0
12298, 0.84166666666667, 0.78, 0
12299, 0.85, 0.79, 0
12300, 0.84166666666667, 0.8, 0
12301, 0.85, 0.81, 0
12302, 0.84166666666667, 0.82, 0
12303, 0.85, 0.83, 0
12304, 0.84166666666667, 0.84, 0
12305, 0.85, 0.85, 0
12306, 0.84166666666667, 0.86, 0
12307, 0.85, 0.87, 0
12308, 0.84166666666667, 0.88, 0
12309, 0.85, 0.89, 0
12310, 0.84166666666667, 0.9, 0
12311, 0.85, 0.91, 0
12312, 0.84166666666667, 0.92, 0
12313, 0.85, 0.93, 0
12314, 0.84166666666667, 0.94, 0
12315, 0.85, 0.95, 0
12316, 0.84166666666667, 0.96, 0
12317, 0.85, 0.97, 0
12318, 0.84166666666667, 0.98, 0
12319, 0.85, 0.99, 0
12320, 0.84166666666667, 1, 0
12321, 0.85, 1.01, 0
12322, 0.84166666666667, 1.02, 0
12323, 0.85, 1.03, 0
12324, 0.84166666666667, 1.04, 0
12325, 0.85, 1.05, 0
12326, 0.84166666666667, 1.06, 0
12327, 0.85, 1.07, 0
12328, 0.84166666666667, 1.08, 0
12329, 0.85, 1.09, 0
12330, 0.84166666666667, 1.1, 0
12331, 0.85, 1.11, 0
12332, 0.84166666666667, 1.12, 0
12333, 0.85, 1.13, 0
12334, 0.84166666666667, 1.14, 0
12335, 0.85, 1.15, 0
12336, 0.84166666666667, 1.16, 0
12337, 0.85, 1.17, 0
12338, 0.84166666666667, 1.18, 0
12339, 0.85, 1.19, 0
12340, 0.86666666666667, 0.01, 0
12341, 0.85833333333333, 0.02, 0
12342, 0.86666666666667, 0.03, 0
12343, 0.85833333333333, 0.04, 0
12344, 0.86666666666667, 0.05, 0
12345, 0.85833333333333, 0.06, 0
12346, 0.86666666666667, 0.07, 0
12347, 0.85833333333333, 0.08, 0
12348, 0.86666666666667, 0.09, 0
12349, 0.85833333333333, 0.1, 0
12350, 0.86666666666667, 0.11, 0
12351, 0.85833333333333, 0.12, 0
12352, 0.86666666666667, 0.13, 0
12353, 0.85833333333333, 0.14, 0
12354, 0.86666666666667, 0.15, 0
12355, 0.85833333333333, 0.16, 0
12356, 0.86666666666667, 0.17, 0
12357, 0.85833333333333, 0.18, 0
12358, 0.86666666666667, 0.19, 0
12359, 0.85833333333333, 0.2, 0
12360, 0.86666666666667, 0.21, 0
12361, 0.85833333333333, 0.22, 0
12362, 0.86666666666667, 0.23, 0
12363, 0.85833333333333, 0.24, 0
12364, 0.86666666666667, 0.25, 0
12365, 0.85833333333333, 0.26, 0
12366, 0.86666666666667, 0.27, 0
12367, 0.85833333333333, 0.28, 0
12368, 0.86666666666667, 0.29, 0
12369, 0.85833333333333, 0.3, 0
12370, 0.86666666666667, 0.31, 0
12371, 0.85833333333333, 0.32, 0
12372, 0.86666666666667, 0.33, 0
12373, 0.85833333333333, 0.34, 0
12374, 0.86666666666667, 0.35, 0
12375, 0.85833333333333, 0.36, 0
12376, 0.86666666666667, 0.37, 0
12377, 0.85833333333333, 0.38, 0
12378, 0.86666666666667, 0.39, 0
12379, 0.85833333333333, 0.4, 0
12380, 0.86666666666667, 0.41, 0
12381, 0.85833333333333, 0.42, 0
12382, 0.86666666666667, 0.43, 0
12383, 0.85833333333333, 0.44, 0
12384, 0.86666666666667, 0.45, 0
12385, 0.85833333333333, 0.46, 0
12386, 0.86666666666667, 0.47, 0
12387, 0.85833333333333, 0.48, 0
12388, 0.86666666666667, 0.49, 0
12389, 0.85833333333333, 0.5, 0
12390, 0.86666666666667, 0.51, 0
12391, 0.85833333333333, 0.52, 0
12392, 0.86666666666667, 0.53, 0
12393, 0.85833333333333, 0.54, 0
12394, 0.86666666666667, 0.55, 0
12395, 0.85833333333333, 0.56, 0
12396, 0.86666666666667, 0.57, 0
12397, 0.85833333333333, 0.58, 0
12398, 0.86666666666667, 0.59, 0
12399, 0.85833333333333, 0.6, 0
12400, 0.86666666666667, 0.61, 0
12401, 0.85833333333333, 0.62, 0
12402, 0.86666666666667, 0.63, 0
12403, 0.85833333333333, 0.64, 0
12404, 0.86666666666667, 0.65, 0
12405, 0.85833333333333, 0.66, 0
12406, 0.86666666666667, 0.67, 0
12407, 0.85833333333333, 0.68, 0
12408, 0.86666666666667, 0.69, 0
12409, 0.85833333333333, 0.7, 0
12410, 0.86666666666667, 0.71, 0
12411, 0.85833333333333, 0.72, 0
12412, 0.86666666666667, 0.73, 0
12413, 0.85833333333333, 0.74, 0
12414, 0.86666666666667, 0.75, 0
12415, 0.85833333333333, 0.76, 0
12416, 0.86666666666667, 0.77, 0
12417, 0.85833333333333, 0.78, 0
12418, 0.86666666666667, 0.79, 0
12419, 0.85833333333333, 0.8, 0
12420, 0.86666666666667, 0.81, 0
12421, 0.85833333333333, 0.82, 0
12422, 0.86666666666667, 0.83, 0
12423, 0.85833333333333, 0.84, 0
12424, 0.86666666666667, 0.85, 0
12425, 0.85833333333333, 0.86, 0
12426, 0.86666666666667, 0.87, 0
12427, 0.85833333333333, 0.88, 0
12428, 0.86666666666667, 0.89, 0
12429, 0.85833333333333, 0.9, 0
12430, 0.86666666666667, 0.91, 0
12431, 0.85833333333333, 0.92, 0
12432, 0.86666666666667, 0.93, 0
12433, 0.85833333333333, 0.94, 0
12434, 0.86666666666667, 0.95, 0
12435, 0.85833333333333, 0.96, 0
12436, 0.86666666666667, 0.97, 0
12437, 0.85833333333333, 0.98, 0
12438, 0.86666666666667, 0.99, 0
12439, 0.85833333333333, 1, 0
12440, 0.86666666666667, 1.01, 0
12441, 0.85833333333333, 1.02, 0
12442, 0.86666666666667, 1.03, 0
12443, 0.85833333333333, 1.04, 0
12444, 0.86666666666667, 1.05, 0
12445, 0.85833333333333, 1.06, 0
12446, 0.86666666666667, 1.07, 0
12447, 0.85833333333333, 1.08, 0
12448, 0.86666666666667, 1.09, 0
12449, 0.85833333333333, 1.1, 0
12450, 0.86666666666667, 1.11, 0
12451, 0.85833333333333, 1.12, 0
12452, 0.86666666666667, 1.13, 0
12453, 0.85833333333333, 1.14, 0
12454, 0.86666666666667, 1.15, 0
12455, 0.85833333333333, 1.16, 0
12456, 0.86666666666667, 1.17, 0
12457, 0.85833333333333, 1.18, 0
12458, 0.86666666666667, 1.19, 0
12459, 0.88333333333333, 0.01, 0
12460, 0.875, 0.02, 0
12461, 0.88333333333333, 0.03, 0
12462, 0.875, 0.04, 0
12463, 0.88333333333333, 0.05, 0
12464, 0.875, 0.06, 0
12465, 0.88333333333333, 0.07, 0
12466, 0.875, 0.08, 0
12467, 0.88333333333333, 0.09, 0
12468, 0.875, 0.1, 0
12469, 0.88333333333333, 0.11, 0
12470, 0.875, 0.12, 0
12471, 0.88333333333333, 0.13, 0
12472, 0.875, 0.14, 0
12473, 0.88333333333333, 0.15, 0
12474, 0.875, 0.16, 0
12475, 0.88333333333333, 0.17, 0
12476, 0.875, 0.18, 0
12477, 0.88333333333333, 0.19, 0
12478, 0.875, 0.2, 0
12479, 0.88333333333333, 0.21, 0
12480, 0.875, 0.22, 0
12481, 0.88333333333333, 0.23, 0
12482, 0.875, 0.24, 0
12483, 0.88333333333333, 0.25, 0
12484, 0.875, 0.26, 0
12485, 0.88333333333333, 0.27, 0
12486, 0.875, 0.28, 0
12487, 0.88333333333333, 0.29, 0
12488, 0.875, 0.3, 0
12489, 0.88333333333333, 0.31, 0
12490, 0.875, 0.32, 0
12491, 0.88333333333333, 0.33, 0
12492, 0.875, 0.34, 0
12493, 0.88333333333333, 0.35, 0
12494, 0.875, 0.36, 0
12495, 0.88333333333333, 0.37, 0
12496, 0.875, 0.38, 0
12497, 0.88333333333333, 0.39, 0
12498, 0.875, 0.4, 0
12499, 0.88333333333333, 0.41, 0
12500, 0.875, 0.42, 0
12501, 0.88333333333333, 0.43, 0
12502, 0.875, 0.44, 0
12503, 0.88333333333333, 0.45, 0
12504, 0.875, 0.46, 0
12505, 0.88333333333333, 0.47, 0
12506, 0.875, 0.48, 0
12507, 0.88333333333333, 0.49, 0
12508, 0.875, 0.5, 0
12509, 0.88333333333333, 0.51, 0
12510, 0.875, 0.52, 0
12511, 0.88333333333333, 0.53, 0
12512, 0.875, 0.54, 0
12513, 0.88333333333333, 0.55, 0
12514, 0.875, 0.56, 0
12515, 0.88333333333333, 0.57, 0
12516, 0.875, 0.58, 0
12517, 0.88333333333333, 0.59, 0
12518, 0.875, 0.6, 0
12519, 0.88333333333333, 0.61, 0
12520, 0.875, 0.62, 0
12521, 0.88333333333333, 0.63, 0
12522, 0.875, 0.64, 0
12523, 0.88333333333333, 0.65, 0
12524, 0.875, 0.66, 0
12525, 0.88333333333333, 0.67, 0
12526, 0.875, 0.68, 0
12527, 0.88333333333333, 0.69, 0
12528, 0.875, 0.7, 0
12529, 0.88333333333333, 0.71, 0
12530, 0.875, 0.72, 0
12531, 0.88333333333333, 0.73, 0
12532, 0.875, 0.74, 0
12533, 0.88333333333333, 0.75, 0
12534, 0.875, 0.76, 0
12535, 0.88333333333333, 0.77, 0
12536, 0.875, 0.78, 0
12537, 0.88333333333333, 0.79, 0
12538, 0.875, 0.8, 0
12539, 0.88333333333333, 0.81, 0
12540, 0.875, 0.82, 0
12541, 0.88333333333333, 0.83, 0
12542, 0.875, 0.84, 0
12543, 0.88333333333333, 0.85, 0
12544, 0.875, 0.86, 0
12545, 0.88333333333333, 0.87, 0
12546, 0.875, 0.88, 0
12547, 0.88333333333333, 0.89, 0
12548, 0.875, 0.9, 0
12549, 0.88333333333333, 0.91, 0
12550, 0.875, 0.92, 0
12551, 0.88333333333333, 0.93, 0
12552, 0.875, 0.94, 0
12553, 0.88333333333333, 0.95, 0
12554, 0.875, 0.96, 0
12555, 0.88333333333333, 0.97, 0
12556, 0.875, 0.98, 0
12557, 0.88333333333333, 0.99, 0
12558, 0.875, 1, 0
12559, 0.88333333333333, 1.01, 0
12560, 0.875, 1.02, 0
12561, 0.88333333333333, 1.03, 0
12562, 0.875, 1.04, 0
12563, 0.88333333333333, 1.05, 0
12564, 0.875, 1.06, 0
12565, 0.88333333333333, 1.07, 0
12566, 0.875, 1.08, 0
12567, 0.88333333333333, 1.09, 0
12568, 0.875, 1.1, 0
12569, 0.88333333333333, 1.11, 0
12570, 0.875, 1.12, 0
12571, 0.88333333333333, 1.13, 0
12572, 0.875, 1.14, 0
12573, 0.88333333333333, 1.15, 0
12574, 0.875, 1.16, 0
12575, 0.88333333333333, 1.17, 0
12576, 0.875, 1.18, 0
12577, 0.88333333333333, 1.19, 0
12578, 0.9, 0.01, 0
12579, 0.89166666666667, 0.02, 0
12580, 0.9, 0.03, 0
12581, 0.89166666666667, 0.04, 0
12582, 0.9, 0.05, 0
12583, 0.89166666666667, 0.06, 0
12584, 0.9, 0.07, 0
12585, 0.89166666666667, 0.08, 0
12586, 0.9, 0.09, 0
12587, 0.89166666666667, 0.1, 0
12588, 0.9, 0.11, 0
12589, 0.89166666666667, 0.12, 0
12590, 0.9, 0.13, 0
12591, 0.89166666666667, 0.14, 0
12592, 0.9, 0.15, 0
12593, 0.89166666666667, 0.16, 0
12594, 0.9, 0.17, 0
12595, 0.89166666666667, 0.18, 0
12596, 0.9, 0.19, 0
12597, 0.89166666666667, 0.2, 0
12598, 0.9, 0.21, 0
12599, 0.89166666666667, 0.22, 0
12600, 0.9, 0.23, 0
12601, 0.89166666666667, 0.24, 0
12602, 0.9, 0.25, 0
12603, 0.89166666666667, 0.26, 0
12604, 0.9, 0.27, 0
12605, 0.89166666666667, 0.28, 0
12606, 0.9, 0.29, 0
12607, 0.89166666666667, 0.3, 0
12608, 0.9, 0.31, 0
12609, 0.89166666666667, 0.32, 0
12610, 0.9, 0.33, 0
12611, 0.89166666666667, 0.34, 0
12612, 0.9, 0.35, 0
12613, 0.89166666666667, 0.36, 0
12614, 0.9, 0.37, 0
12615, 0.89166666666667, 0.38, 0
12616, 0.9, 0.39, 0
12617, 0.89166666666667, 0.4, 0
12618, 0.9, 0.41, 0
12619, 0.89166666666667, 0.42, 0
12620, 0.9, 0.43, 0
12621, 0.89166666666667, 0.44, 0
12622, 0.9, 0.45, 0
12623, 0.89166666666667, 0.46, 0
12624, 0.9, 0.47, 0
12625, 0.89166666666667, 0.48, 0
12626, 0.9, 0.49, 0
12627, 0.89166666666667, 0.5, 0
12628, 0.9, 0.51, 0
12629, 0.89166666666667, 0.52, 0
12630, 0.9, 0.53, 0
12631, 0.89166666666667, 0.54, 0
12632, 0.9, 0.55, 0
12633, 0.89166666666667, 0.56, 0
12634, 0.9, 0.57, 0
12635, 0.89166666666667, 0.58, 0
12636, 0.9, 0.59, 0
12637, 0.89166666666667, 0.6, 0
12638, 0.9, 0.61, 0
12639, 0.89166666666667, 0.62, 0
12640, 0.9, 0.63, 0
12641, 0.89166666666667, 0.64, 0
12642, 0.9, 0.65, 0
12643, 0.89166666666667, 0.66, 0
12644, 0.9, 0.67, 0
12645, 0.89166666666667, 0.68, 0
12646, 0.9, 0.69, 0
12647, 0.89166666666667, 0.7, 0
12648, 0.9, 0.71, 0
12649, 0.89166666666667, 0.72, 0
12650, 0.9, 0.73, 0
12651, 0.89166666666667, 0.74, 0
12652, 0.9, 0.75, 0
12653, 0.89166666666667, 0.76, 0
12654, 0.9, 0.77, 0
12655, 0.89166666666667, 0.78, 0
12656, 0.9, 0.79, 0
12657, 0.89166666666667, 0.8, 0
12658, 0.9, 0.81, 0
12659, 0.89166666666667, 0.82, 0
12660, 0.9, 0.83, 0
12661, 0.89166666666667, 0.84, 0
12662, 0.9, 0.85, 0
12663, 0.89166666666667, 0.86, 0
12664, 0.9, 0.87, 0
12665, 0.89166666666667, 0.88, 0
12666, 0.9, 0.89, 0
12667, 0.89166666666667, 0.9, 0
12668, 0.9, 0.91, 0
12669, 0.89166666666667, 0.92, 0
12670, 0.9, 0.93, 0
12671, 0.89166666666667, 0.94, 0
12672, 0.9, 0.95, 0
12673, 0.89166666666667, 0.96, 0
12674, 0.9, 0.97, 0
12675, 0.89166666666667, 0.98, 0
12676, 0.9, 0.99, 0
12677, 0.89166666666667, 1, 0
12678, 0.9, 1.01, 0
12679, 0.89166666666667, 1.02, 0
12680, 0.9, 1.03, 0
12681, 0.89166666666667, 1.04, 0
12682, 0.9, 1.05, 0
12683, 0.89166666666667, 1.06, 0
12684, 0.9, 1.07, 0
12685, 0.89166666666667, 1.08, 0
12686, 0.9, 1.09, 0
12687, 0.89166666666667, 1.1, 0
12688, 0.9, 1.11, 0
12689, 0.89166666666667, 1.12, 0
12690, 0.9, 1.13, 0
12691, 0.89166666666667, 1.14, 0
12692, 0.9, 1.15, 0
12693, 0.89166666666667, 1.16, 0
12694, 0.9, 1.17, 0
12695, 0.89166666666667, 1.18, 0
12696, 0.9, 1.19, 0
12697, 0.91666666666667, 0.01, 0
12698, 0.90833333333333, 0.02, 0
12699, 0.91666666666667, 0.03, 0
12700, 0.90833333333333, 0.04, 0
12701, 0.91666666666667, 0.05, 0
12702, 0.90833333333333, 0.06, 0
12703, 0.91666666666667, 0.07, 0
12704, 0.90833333333333, 0.08, 0
12705, 0.91666666666667, 0.09, 0
12706, 0.90833333333333, 0.1, 0
12707, 0.91666666666667, 0.11, 0
12708, 0.90833333333333, 0.12, 0
12709, 0.91666666666667, 0.13, 0
12710, 0.90833333333333, 0.14, 0
12711, 0.91666666666667, 0.15, 0
12712, 0.90833333333333, 0.16, 0
12713, 0.91666666666667, 0.17, 0
12714, 0.90833333333333, 0.18, 0
12715, 0.91666666666667, 0.19, 0
12716, 0.90833333333333, 0.2, 0
12717, 0.91666666666667, 0.21, 0
12718, 0.90833333333333, 0.22, 0
12719, 0.91666666666667, 0.23, 0
12720, 0.90833333333333, 0.24, 0
12721, 0.91666666666667, 0.25, 0
12722, 0.90833333333333, 0.26, 0
12723, 0.91666666666667, 0.27, 0
12724, 0.90833333333333, 0.28, 0
12725, 0.91666666666667, 0.29, 0
12726, 0.90833333333333, 0.3, 0
12727, 0.91666666666667, 0.31, 0
12728, 0.90833333333333, 0.32, 0
12729, 0.91666666666667, 0.33, 0
12730, 0.90833333333333, 0.34, 0
12731, 0.91666666666667, 0.35, 0
12732, 0.90833333333333, 0.36, 0
12733, 0.91666666666667, 0.37, 0
12734, 0.90833333333333, 0.38, 0
12735, 0.91666666666667, 0.39, 0
12736, 0.90833333333333, 0.4, 0
12737, 0.91666666666667, 0.41, 0
12738, 0.90833333333333, 0.42, 0
12739, 0.91666666666667, 0.43, 0
12740, 0.90833333333333, 0.44, 0
12741, 0.91666666666667, 0.45, 0
12742, 0.90833333333333, 0.46, 0
12743, 0.91666666666667, 0.47, 0
12744, 0.90833333333333, 0.48, 0
12745, 0.91666666666667, 0.49, 0
12746, 0.90833333333333, 0.5, 0
12747, 0.91666666666667, 0.51, 0
12748, 0.90833333333333, 0.52, 0
12749, 0.91666666666667, 0.53, 0
12750, 0.90833333333333, 0.54, 0
12751, 0.91666666666667, 0.55, 0
12752, 0.90833333333333, 0.56, 0
12753, 0.91666666666667, 0.57, 0
12754, 0.90833333333333, 0.58, 0
12755, 0.91666666666667, 0.59, 0
12756, 0.90833333333333, 0.6, 0
12757, 0.91666666666667, 0.61, 0
12758, 0.90833333333333, 0.62, 0
12759, 0.91666666666667, 0.63, 0
12760, 0.90833333333333, 0.64, 0
12761, 0.91666666666667, 0.65, 0
12762, 0.90833333333333, 0.66, 0
12763, 0.91666666666667, 0.67, 0
12764, 0.90833333333333, 0.68, 0
12765, 0.91666666666667, 0.69, 0
12766, 0.90833333333333, 0.7, 0
12767, 0.91666666666667, 0.71, 0
12768, 0.90833333333333, 0.72, 0
12769, 0.91666666666667, 0.73, 0
12770, 0.90833333333333, 0.74, 0
12771, 0.91666666666667, 0.75, 0
12772, 0.90833333333333, 0.76, 0
12773, 0.91666666666667, 0.77, 0
12774, 0.90833333333333, 0.78, 0
12775, 0.91666666666667, 0.79, 0
12776, 0.90833333333333, 0.8, 0
12777, 0.91666666666667, 0.81, 0
12778, 0.90833333333333, 0.82, 0
12779, 0.91666666666667, 0.83, 0
12780, 0.90833333333333, 0.84, 0
12781, 0.91666666666667, 0.85, 0
12782, 0.90833333333333, 0.86, 0
12783, 0.91666666666667, 0.87, 0
12784, 0.90833333333333, 0.88, 0
12785, 0.91666666666667, 0.89, 0
12786, 0.90833333333333, 0.9, 0
12787, 0.91666666666667, 0.91, 0
12788, 0.90833333333333, 0.92, 0
12789, 0.91666666666667, 0.93, 0
12790, 0.90833333333333, 0.94, 0
12791, 0.91666666666667, 0.95, 0
12792, 0.90833333333333, 0.96, 0
12793, 0.91666666666667, 0.97, 0
12794, 0.90833333333333, 0.98, 0
12795, 0.91666666666667, 0.99, 0
12796, 0.90833333333333, 1, 0
12797, 0.91666666666667, 1.01, 0
12798, 0.90833333333333, 1.02, 0
12799, 0.91666666666667, 1.03, 0
12800, 0.90833333333333, 1.04, 0
12801, 0.91666666666667, 1.05, 0
12802, 0.90833333333333, 1.06, 0
12803, 0.91666666666667, 1.07, 0
12804, 0.90833333333333, 1.08, 0
12805, 0.91666666666667, 1.09, 0
12806, 0.90833333333333, 1.1, 0
12807, 0.91666666666667, 1.11, 0
12808, 0.90833333333333, 1.12, 0
12809, 0.91666666666667, 1.13, 0
12810, 0.90833333333333, 1.14, 0
12811, 0.91666666666667, 1.15, 0
12812, 0.90833333333333, 1.16, 0
12813, 0.91666666666667, 1.17, 0
12814, 0.90833333333333, 1.18, 0
12815, 0.91666666666667, 1.19, 0
12816, 0.93333333333333, 0.01, 0
12817, 0.925, 0.02, 0
12818, 0.93333333333333, 0.03, 0
12819, 0.925, 0.04, 0
12820, 0.93333333333333, 0.05, 0
12821, 0.925, 0.06, 0
12822, 0.93333333333333, 0.07, 0
12823, 0.925, 0.08, 0
12824, 0.93333333333333, 0.09, 0
12825, 0.925, 0.1, 0
12826, 0.93333333333333, 0.11, 0
12827, 0.925, 0.12, 0
12828, 0.93333333333333, 0.13, 0
12829, 0.925, 0.14, 0
12830, 0.93333333333333, 0.15, 0
12831, 0.925, 0.16, 0
12832, 0.93333333333333, 0.17, 0
12833, 0.925, 0.18, 0
12834, 0.93333333333333, 0.19, 0
12835, 0.925, 0.2, 0
12836, 0.93333333333333, 0.21, 0
12837, 0.925, 0.22, 0
12838, 0.93333333333333, 0.23, 0
12839, 0.925, 0.24, 0
12840, 0.93333333333333, 0.25, 0
12841, 0.925, 0.26, 0
12842, 0.93333333333333, 0.27, 0
12843, 0.925, 0.28, 0
12844, 0.93333333333333, 0.29, 0
12845, 0.925, 0.3, 0
12846, 0.93333333333333, 0.31, 0
12847, 0.925, 0.32, 0
12848, 0.93333333333333, 0.33, 0
12849, 0.925, 0.34, 0
12850, 0.93333333333333, 0.35, 0
12851, 0.925, 0.36, 0
12852, 0.93333333333333, 0.37, 0
12853, 0.925, 0.38, 0
12854, 0.93333333333333, 0.39, 0
12855, 0.925, 0.4, 0
12856, 0.93333333333333, 0.41, 0
12857, 0.925, 0.42, 0
12858, 0.93333333333333, 0.43, 0
12859, 0.925, 0.44, 0
12860, 0.93333333333333, 0.45, 0
12861, 0.925, 0.46, 0
12862, 0.93333333333333, 0.47, 0
12863, 0.925, 0.48, 0
12864, 0.93333333333333, 0.49, 0
12865, 0.925, 0.5, 0
12866, 0.93333333333333, 0.51, 0
12867, 0.925, 0.52, 0
12868, 0.93333333333333, 0.53, 0
12869, 0.925, 0.54, 0
12870, 0.93333333333333, 0.55, 0
12871, 0.925, 0.56, 0
12872, 0.93333333333333, 0.57, 0
12873, 0.925, 0.58, 0
12874, 0.93333333333333, 0.59, 0
12875, 0.925, 0.6, 0
12876, 0.93333333333333, 0.61, 0
12877, 0.925, 0.62, 0
12878, 0.93333333333333, 0.63, 0
12879, 0.925, 0.64, 0
12880, 0.93333333333333, 0.65, 0
12881, 0.925, 0.66, 0
12882, 0.93333333333333, 0.67, 0
12883, 0.925, 0.68, 0
12884, 0.93333333333333, 0.69, 0
12885, 0.925, 0.7, 0
12886, 0.93333333333333, 0.71, 0
12887, 0.925, 0.72, 0
12888, 0.93333333333333, 0.73, 0
12889, 0.925, 0.74, 0
12890, 0.93333333333333, 0.75, 0
12891, 0.925, 0.76, 0
12892, 0.93333333333333, 0.77, 0
12893, 0.925, 0.78, 0
12894, 0.93333333333333, 0.79, 0
12895, 0.925, 0.8, 0
12896, 0.93333333333333, 0.81, 0
12897, 0.925, 0.82, 0
12898, 0.93333333333333, 0.83, 0
12899, 0.925, 0.84, 0
12900, 0.93333333333333, 0.85, 0
12901, 0.925, 0.86, 0
12902, 0.93333333333333, 0.87, 0
12903, 0.925, 0.88, 0
12904, 0.93333333333333, 0.89, 0
12905, 0.925, 0.9, 0
12906, 0.93333333333333, 0.91, 0
12907, 0.925, 0.92, 0
12908, 0.93333333333333, 0.93, 0
12909, 0.925, 0.94, 0
12910, 0.93333333333333, 0.95, 0
12911, 0.925, 0.96, 0
12912, 0.93333333333333, 0.97, 0
12913, 0.925, 0.98, 0
12914, 0.93333333333333, 0.99, 0
12915, 0.925, 1, 0
12916, 0.93333333333333, 1.01, 0
12917, 0.925, 1.02, 0
12918, 0.93333333333333, 1.03, 0
12919, 0.925, 1.04, 0
12920, 0.93333333333333, 1.05, 0
12921, 0.925, 1.06, 0
12922, 0.93333333333333, 1.07, 0
12923, 0.925, 1.08, 0
12924, 0.93333333333333, 1.09, 0
12925, 0.925, 1.1, 0
12926, 0.93333333333333, 1.11, 0
12927, 0.925, 1.12, 0
12928, 0.93333333333333, 1.13, 0
12929, 0.925, 1.14, 0
12930, 0.93333333333333, 1.15, 0
12931, 0.925, 1.16, 0
12932, 0.93333333333333, 1.17, 0
12933, 0.925, 1.18, 0
12934, 0.93333333333333, 1.19, 0
12935, 0.95, 0.01, 0
12936, 0.94166666666667, 0.02, 0
12937, 0.95, 0.03, 0
12938, 0.94166666666667, 0.04, 0
12939, 0.95, 0.05, 0
12940, 0.94166666666667, 0.06, 0
12941, 0.95, 0.07, 0
12942, 0.94166666666667, 0.08, 0
12943, 0.95, 0.09, 0
12944, 0.94166666666667, 0.1, 0
12945, 0.95, 0.11, 0
12946, 0.94166666666667, 0.12, 0
12947, 0.95, 0.13, 0
12948, 0.94166666666667, 0.14, 0
12949, 0.95, 0.15, 0
12950, 0.94166666666667, 0.16, 0
12951, 0.95, 0.17, 0
12952, 0.94166666666667, 0.18, 0
12953, 0.95, 0.19, 0
12954, 0.94166666666667, 0.2, 0
12955, 0.95, 0.21, 0
12956, 0.94166666666667, 0.22, 0
12957, 0.95, 0.23, 0
12958, 0.94166666666667, 0.24, 0
12959, 0.95, 0.25, 0
12960, 0.94166666666667, 0.26, 0
12961, 0.95, 0.27, 0
12962, 0.94166666666667, 0.28, 0
12963, 0.95, 0.29, 0
12964, 0.94166666666667, 0.3, 0
12965, 0.95, 0.31, 0
12966, 0.94166666666667, 0.32, 0
12967, 0.95, 0.33, 0
12968, 0.94166666666667, 0.34, 0
12969, 0.95, 0.35, 0
12970, 0.94166666666667, 0.36, 0
12971, 0.95, 0.37, 0
12972, 0.94166666666667, 0.38, 0
12973, 0.95, 0.39, 0
12974, 0.94166666666667, 0.4, 0
12975, 0.95, 0.41, 0
12976, 0.94166666666667, 0.42, 0
12977, 0.95, 0.43, 0
12978, 0.94166666666667, 0.44, 0
12979, 0.95, 0.45, 0
12980, 0.94166666666667, 0.46, 0
12981, 0.95, 0.47, 0
12982, 0.94166666666667, 0.48, 0
12983, 0.95, 0.49, 0
12984, 0.94166666666667, 0.5, 0
12985, 0.95, 0.51, 0
12986, 0.94166666666667, 0.52, 0
12987, 0.95, 0.53, 0
12988, 0.94166666666667, 0.54, 0
12989, 0.95, 0.55, 0
12990, 0.94166666666667, 0.56, 0
12991, 0.95, 0.57, 0
12992, 0.94166666666667, 0.58, 0
12993, 0.95, 0.59, 0
12994, 0.94166666666667, 0.6, 0
12995, 0.95, 0.61, 0
12996, 0.94166666666667, 0.62, 0
12997, 0.95, 0.63, 0
12998, 0.94166666666667, 0.64, 0
12999, 0.95, 0.65, 0
13000, 0.94166666666667, 0.66, 0
13001, 0.95, 0.67, 0
13002, 0.94166666666667, 0.68, 0
13003, 0.95, 0.69, 0
13004, 0.94166666666667, 0.7, 0
13005, 0.95, 0.71, 0
13006, 0.94166666666667, 0.72, 0
13007, 0.95, 0.73, 0
13008, 0.94166666666667, 0.74, 0
13009, 0.95, 0.75, 0
13010, 0.94166666666667, 0.76, 0
13011, 0.95, 0.77, 0
13012, 0.94166666666667, 0.78, 0
13013, 0.95, 0.79, 0
13014, 0.94166666666667, 0.8, 0
13015, 0.95, 0.81, 0
13016, 0.94166666666667, 0.82, 0
13017, 0.95, 0.83, 0
13018, 0.94166666666667, 0.84, 0
13019, 0.95, 0.85, 0
13020, 0.94166666666667, 0.86, 0
13021, 0.95, 0.87, 0
13022, 0.94166666666667, 0.88, 0
13023, 0.95, 0.89, 0
13024, 0.94166666666667, 0.9, 0
13025, 0.95, 0.91, 0
13026, 0.94166666666667, 0.92, 0
13027, 0.95, 0.93, 0
13028, 0.94166666666667, 0.94, 0
13029, 0.95, 0.95, 0
13030, 0.94166666666667, 0.96, 0
13031, 0.95, 0.97, 0
13032, 0.94166666666667, 0.98, 0
13033, 0.95, 0.99, 0
13034, 0.94166666666667, 1, 0
13035, 0.95, 1.01, 0
13036, 0.94166666666667, 1.02, 0
13037, 0.95, 1.03, 0
13038, 0.94166666666667, 1.04, 0
13039, 0.95, 1.05, 0
13040, 0.94166666666667, 1.06, 0
13041, 0.95, 1.07, 0
13042, 0.94166666666667, 1.08, 0
13043, 0.95, 1.09, 0
13044, 0.94166666666667, 1.1, 0
13045, 0.95, 1.11, 0
13046, 0.94166666666667, 1.12, 0
13047, 0.95, 1.13, 0
13048, 0.94166666666667, 1.14, 0
13049, 0.95, 1.15, 0
13050, 0.94166666666667, 1.16, 0
13051, 0.95, 1.17, 0
13052, 0.94166666666667, 1.18, 0
13053, 0.95, 1.19, 0
13054, 0.96666666666667, 0.01, 0
13055, 0.95833333333333, 0.02, 0
13056, 0.96666666666667, 0.03, 0
13057, 0.95833333333333, 0.04, 0
13058, 0.96666666666667, 0.05, 0
13059, 0.95833333333333, 0.06, 0
13060, 0.96666666666667, 0.07, 0
13061, 0.95833333333333, 0.08, 0
13062, 0.96666666666667, 0.09, 0
13063, 0.95833333333333, 0.1, 0
13064, 0.96666666666667, 0.11, 0
13065, 0.95833333333333, 0.12, 0
13066, 0.96666666666667, 0.13, 0
13067, 0.95833333333333, 0.14, 0
13068, 0.96666666666667, 0.15, 0
13069, 0.95833333333333, 0.16, 0
13070, 0.96666666666667, 0.17, 0
13071, 0.95833333333333, 0.18, 0
13072, 0.96666666666667, 0.19, 0
13073, 0.95833333333333, 0.2, 0
13074, 0.96666666666667, 0.21, 0
13075, 0.95833333333333, 0.22, 0
13076, 0.96666666666667, 0.23, 0
13077, 0.95833333333333, 0.24, 0
13078, 0.96666666666667, 0.25, 0
13079, 0.95833333333333, 0.26, 0
13080, 0.96666666666667, 0.27, 0
13081, 0.95833333333333, 0.28, 0
13082, 0.96666666666667, 0.29, 0
13083, 0.95833333333333, 0.3, 0
13084, 0.96666666666667, 0.31, 0
13085, 0.95833333333333, 0.32, 0
13086, 0.96666666666667, 0.33, 0
13087, 0.95833333333333, 0.34, 0
13088, 0.96666666666667, 0.35, 0
13089, 0.95833333333333, 0.36, 0
13090, 0.96666666666667, 0.37, 0
13091, 0.95833333333333, 0.38, 0
13092, 0.96666666666667, 0.39, 0
13093, 0.95833333333333, 0.4, 0
13094, 0.96666666666667, 0.41, 0
13095, 0.95833333333333, 0.42, 0
13096, 0.96666666666667, 0.43, 0
13097, 0.95833333333333, 0.44, 0
13098, 0.96666666666667, 0.45, 0
13099, 0.95833333333333, 0.46, 0
13100, 0.96666666666667, 0.47, 0
13101, 0.95833333333333, 0.48, 0
13102, 0.96666666666667, 0.49, 0
13103, 0.95833333333333, 0.5, 0
13104, 0.96666666666667, 0.51, 0
13105, 0.95833333333333, 0.52, 0
13106, 0.96666666666667, 0.53, 0
13107, 0.95833333333333, 0.54, 0
13108, 0.96666666666667, 0.55, 0
13109, 0.95833333333333, 0.56, 0
13110, 0.96666666666667, 0.57, 0
13111, 0.95833333333333, 0.58, 0
13112, 0.96666666666667, 0.59, 0
13113, 0.95833333333333, 0.6, 0
13114, 0.96666666666667, 0.61, 0
13115, 0.95833333333333, 0.62, 0
13116, 0.96666666666667, 0.63, 0
13117, 0.95833333333333, 0.64, 0
13118, 0.96666666666667, 0.65, 0
13119, 0.95833333333333, 0.66, 0
13120, 0.96666666666667, 0.67, 0
13121, 0.95833333333333, 0.68, 0
13122, 0.96666666666667, 0.69, 0
13123, 0.95833333333333, 0.7, 0
13124, 0.96666666666667, 0.71, 0
13125, 0.95833333333333, 0.72, 0
13126, 0.96666666666667, 0.73, 0
13127, 0.95833333333333, 0.74, 0
13128, 0.96666666666667, 0.75, 0
13129, 0.95833333333333, 0.76, 0
13130, 0.96666666666667, 0.77, 0
13131, 0.95833333333333, 0.78, 0
13132, 0.96666666666667, 0.79, 0
13133, 0.95833333333333, 0.8, 0
13134, 0.96666666666667, 0.81, 0
13135, 0.95833333333333, 0.82, 0
13136, 0.96666666666667, 0.83, 0
13137, 0.95833333333333, 0.84, 0
13138, 0.96666666666667, 0.85, 0
13139, 0.95833333333333, 0.86, 0
13140, 0.96666666666667, 0.87, 0
13141, 0.95833333333333, 0.88, 0
13142, 0.96666666666667, 0.89, 0
13143, 0.95833333333333, 0.9, 0
13144, 0.96666666666667, 0.91, 0
13145, 0.95833333333333, 0.92, 0
13146, 0.96666666666667, 0.93, 0
13147, 0.95833333333333, 0.94, 0
13148, 0.96666666666667, 0.95, 0
13149, 0.95833333333333, 0.96, 0
13150, 0.96666666666667, 0.97, 0
13151, 0.95833333333333, 0.98, 0
13152, 0.96666666666667, 0.99, 0
13153, 0.95833333333333, 1, 0
13154, 0.96666666666667, 1.01, 0
13155, 0.95833333333333, 1.02, 0
13156, 0.96666666666667, 1.03, 0
13157, 0.95833333333333, 1.04, 0
13158, 0.96666666666667, 1.05, 0
13159, 0.95833333333333, 1.06, 0
13160, 0.96666666666667, 1.07, 0
13161, 0.95833333333333, 1.08, 0
13162, 0.96666666666667, 1.09, 0
13163, 0.95833333333333, 1.1, 0
13164, 0.96666666666667, 1.11, 0
13165, 0.95833333333333, 1.12, 0
13166, 0.96666666666667, 1.13, 0
13167, 0.95833333333333, 1.14, 0
13168, 0.96666666666667, 1.15, 0
13169, 0.95833333333333, 1.16, 0
13170, 0.96666666666667, 1.17, 0
13171, 0.95833333333333, 1.18, 0
13172, 0.96666666666667, 1.19, 0
13173, 0.98333333333333, 0.01, 0
13174, 0.975, 0.02, 0
13175, 0.98333333333333, 0.03, 0
13176, 0.975, 0.04, 0
13177, 0.98333333333333, 0.05, 0
13178, 0.975, 0.06, 0
13179, 0.98333333333333, 0.07, 0
13180, 0.975, 0.08, 0
13181, 0.98333333333333, 0.09, 0
13182, 0.975, 0.1, 0
13183, 0.98333333333333, 0.11, 0
13184, 0.975, 0.12, 0
13185, 0.98333333333333, 0.13, 0
13186, 0.975, 0.14, 0
13187, 0.98333333333333, 0.15, 0
13188, 0.975, 0.16, 0
13189, 0.98333333333333, 0.17, 0
13190, 0.975, 0.18, 0
13191, 0.98333333333333, 0.19, 0
13192, 0.975, 0.2, 0
13193, 0.98333333333333, 0.21, 0
13194, 0.975, 0.22, 0
13195, 0.98333333333333, 0.23, 0
13196, 0.975, 0.24, 0
13197, 0.98333333333333, 0.25, 0
13198, 0.975, 0.26, 0
13199, 0.98333333333333, 0.27, 0
13200, 0.975, 0.28, 0
13201, 0.98333333333333, 0.29, 0
13202, 0.975, 0.3, 0
13203, 0.98333333333333, 0.31, 0
13204, 0.975, 0.32, 0
13205, 0.98333333333333, 0.33, 0
13206, 0.975, 0.34, 0
13207, 0.98333333333333, 0.35, 0
13208, 0.975, 0.36, 0
13209, 0.98333333333333, 0.37, 0
13210, 0.975, 0.38, 0
13211, 0.98333333333333, 0.39, 0
13212, 0.975, 0.4, 0
13213, 0.98333333333333, 0.41, 0
13214, 0.975, 0.42, 0
13215, 0.98333333333333, 0.43, 0
13216, 0.975, 0.44, 0
13217, 0.98333333333333, 0.45, 0
13218, 0.975, 0.46, 0
13219, 0.98333333333333, 0.47, 0
13220, 0.975, 0.48, 0
13221, 0.98333333333333, 0.49, 0
13222, 0.975, 0.5, 0
13223, 0.98333333333333, 0.51, 0
13224, 0.975, 0.52, 0
13225, 0.98333333333333, 0.53, 0
13226, 0.975, 0.54, 0
13227, 0.98333333333333, 0.55, 0
13228, 0.975, 0.56, 0
13229, 0.98333333333333, 0.57, 0
13230, 0.975, 0.58, 0
13231, 0.98333333333333, 0.59, 0
13232, 0.975, 0.6, 0
13233, 0.98333333333333, 0.61, 0
13234, 0.975, 0.62, 0
13235, 0.98333333333333, 0.63, 0
13236, 0.975, 0.64, 0
13237, 0.98333333333333, 0.65, 0
13238, 0.975, 0.66, 0
13239, 0.98333333333333, 0.67, 0
13240, 0.975, 0.68, 0
13241, 0.98333333333333, 0.69, 0
13242, 0.975, 0.7, 0
13243, 0.98333333333333, 0.71, 0
13244, 0.975, 0.72, 0
13245, 0.98333333333333, 0.73, 0
13246, 0.975, 0.74, 0
13247, 0.98333333333333, 0.75, 0
13248, 0.975, 0.76, 0
13249, 0.98333333333333, 0.77, 0
13250, 0.975, 0.78, 0
13251, 0.98333333333333, 0.79, 0
13252, 0.975, 0.8, 0
13253, 0.98333333333333, 0.81, 0
13254, 0.975, 0.82, 0
13255, 0.98333333333333, 0.83, 0
13256, 0.975, 0.84, 0
13257, 0.98333333333333, 0.85, 0
13258, 0.975, 0.86, 0
13259, 0.98333333333333, 0.87, 0
13260, 0.975, 0.88, 0
13261, 0.98333333333333, 0.89, 0
13262, 0.975, 0.9, 0
13263, 0.98333333333333, 0.91, 0
13264, 0.975, 0.92, 0
13265, 0.98333333333333, 0.93, 0
13266, 0.975, 0.94, 0
13267, 0.98333333333333, 0.95, 0
13268, 0.975, 0.96, 0
13269, 0.98333333333333, 0.97, 0
13270, 0.975, 0.98, 0
13271, 0.98333333333333, 0.99, 0
13272, 0.975, 1, 0
13273, 0.98333333333333, 1.01, 0
13274, 0.975, 1.02, 0
13275, 0.98333333333333, 1.03, 0
13276, 0.975, 1.04, 0
13277, 0.98333333333333, 1.05, 0
13278, 0.975, 1.06, 0
13279, 0.98333333333333, 1.07, 0
13280, 0.975, 1.08, 0
13281, 0.98333333333333, 1.09, 0
13282, 0.975, 1.1, 0
13283, 0.98333333333333, 1.11, 0
13284, 0.975, 1.12, 0
13285, 0.98333333333333, 1.13, 0
13286, 0.975, 1.14, 0
13287, 0.98333333333333, 1.15, 0
13288, 0.975, 1.16, 0
13289, 0.98333333333333, 1.17, 0
13290, 0.975, 1.18, 0
13291, 0.98333333333333, 1.19, 0
13292, 0.99166666666667, 0.02, 0
13293, 0.99166666666667, 0.04, 0
13294, 0.99166666666667, 0.06, 0
13295, 0.99166666666667, 0.08, 0
13296, 0.99166666666667, 0.1, 0
13297, 0.99166666666667, 0.12, 0
13298, 0.99166666666667, 0.14, 0
13299, 0.99166666666667, 0.16, 0
13300, 0.99166666666667, 0.18, 0
13301, 0.99166666666667, 0.2, 0
13302, 0.99166666666667, 0.22, 0
13303, 0.99166666666667, 0.24, 0
13304, 0.99166666666667, 0.26, 0
13305, 0.99166666666667, 0.28, 0
13306, 0.99166666666667, 0.3, 0
13307, 0.99166666666667, 0.32, 0
13308, 0.99166666666667, 0.34, 0
13309, 0.99166666666667, 0.36, 0
13310, 0.99166666666667, 0.38, 0
13311, 0.99166666666667, 0.4, 0
13312, 0.99166666666667, 0.42, 0
13313, 0.99166666666667, 0.44, 0
13314, 0.99166666666667, 0.46, 0
13315, 0.99166666666667, 0.48, 0
13316, 0.99166666666667, 0.5, 0
13317, 0.99166666666667, 0.52, 0
13318, 0.99166666666667, 0.54, 0
13319, 0.99166666666667, 0.56, 0
13320, 0.99166666666667, 0.58, 0
13321, 0.99166666666667, 0.6, 0
13322, 0.99166666666667, 0.62, 0
13323, 0.99166666666667, 0.64, 0
13324, 0.99166666666667, 0.66, 0
13325, 0.99166666666667, 0.68, 0
13326, 0.99166666666667, 0.7, 0
13327, 0.99166666666667, 0.72, 0
13328, 0.99166666666667, 0.74, 0
13329, 0.99166666666667, 0.76, 0
13330, 0.99166666666667, 0.78, 0
13331, 0.99166666666667, 0.8, 0
13332, 0.99166666666667, 0.82, 0
13333, 0.99166666666667, 0.84, 0
13334, 0.99166666666667, 0.86, 0
13335, 0.99166666666667, 0.88, 0
13336, 0.99166666666667, 0.9, 0
13337, 0.99166666666667, 0.92, 0
13338, 0.99166666666667, 0.94, 0
13339, 0.99166666666667, 0.96, 0
13340, 0.99166666666667, 0.98, 0
13341, 0.99166666666667, 1, 0
13342, 0.99166666666667, 1.02, 0
13343, 0.99166666666667, 1.04, 0
13344, 0.99166666666667, 1.06, 0
13345, 0.99166666666667, 1.08, 0
13346, 0.99166666666667, 1.1, 0
13347, 0.99166666666667, 1.12, 0
13348, 0.99166666666667, 1.14, 0
13349, 0.99166666666667, 1.16, 0
13350, 0.99166666666667, 1.18, 0
13351, 0.98333333333333, 1.2666666666667, 0
13352, 0.96666666666667, 1.2666666666667, 0
13353, 0.95, 1.2666666666667, 0
13354, 0.93333333333333, 1.2666666666667, 0
13355, 0.91666666666667, 1.2666666666667, 0
13356, 0.9, 1.2666666666667, 0
13357, 0.88333333333333, 1.2666666666667, 0
13358, 0.86666666666667, 1.2666666666667, 0
13359, 0.85, 1.2666666666667, 0
13360, 0.83333333333333, 1.2666666666667, 0
13361, 0.81666666666667, 1.2666666666667, 0
13362, 0.8, 1.2666666666667, 0
13363, 0.78333333333333, 1.2666666666667, 0
13364, 0.76666666666667, 1.2666666666667, 0
13365, 0.75, 1.2666666666667, 0
13366, 0.73333333333333, 1.2666666666667, 0
13367, 0.71666666666667, 1.2666666666667, 0
13368, 0.7, 1.2666666666667, 0
13369, 0.68333333333333, 1.2666666666667, 0
13370, 0.66666666666667, 1.2666666666667, 0
13371, 0.65, 1.2666666666667, 0
13372, 0.63333333333333, 1.2666666666667, 0
13373, 0.61666666666667, 1.2666666666667, 0
13374, 0.6, 1.2666666666667, 0
13375, 0.58333333333333, 1.2666666666667, 0
13376, 0.56666666666667, 1.2666666666667, 0
13377, 0.55, 1.2666666666667, 0
13378, 0.53333333333333, 1.2666666666667, 0
13379, 0.51666666666667, 1.2666666666667, 0
13380, 0.5, 1.2666666666667, 0
13381, 0.48333333333333, 1.2666666666667, 0
13382, 0.46666666666667, 1.2666666666667, 0
13383, 0.45, 1.2666666666667, 0
13384, 0.43333333333333, 1.2666666666667, 0
13385, 0.41666666666667, 1.2666666666667, 0
13386, 0.4, 1.2666666666667, 0
13387, 0.38333333333333, 1.2666666666667, 0
13388, 0.36666666666667, 1.2666666666667, 0
13389, 0.35, 1.2666666666667, 0
13390, 0.33333333333333, 1.2666666666667, 0
13391, 0.31666666666667, 1.2666666666667, 0
13392, 0.3, 1.2666666666667, 0
13393, 0.28333333333333, 1.2666666666667, 0
13394, 0.26666666666667, 1.2666666666667, 0
13395, 0.25, 1.2666666666667, 0
13396, 0.23333333333333, 1.2666666666667, 0
13397, 0.21666666666667, 1.2666666666667, 0
13398, 0.2, 1.2666666666667, 0
13399, 0.18333333333333, 1.2666666666667, 0
13400, 0.16666666666667, 1.2666666666667, 0
13401, 0.15, 1.2666666666667, 0
13402, 0.13333333333333, 1.2666666666667, 0
13403, 0.11666666666667, 1.2666666666667, 0
13404, 0.1, 1.2666666666667, 0
13405, 0.083333333333333, 1.2666666666667, 0
13406, 0.066666666666667, 1.2666666666667, 0
13407, 0.05, 1.2666666666667, 0
13408, 0.033333333333333, 1.2666666666667, 0
13409, 0.016666666666667, 1.2666666666667, 0
13410, 0.98333333333333, 1.2833333333333, 0
13411, 0.96666666666667, 1.2833333333333, 0
13412, 0.95, 1.2833333333333, 0
13413, 0.93333333333333, 1.2833333333333, 0
13414, 0.91666666666667, 1.2833333333333, 0
13415, 0.9, 1.2833333333333, 0
13416, 0.88333333333333, 1.2833333333333, 0
13417, 0.86666666666667, 1.2833333333333, 0
13418, 0.85, 1.2833333333333, 0
13419, 0.83333333333333, 1.2833333333333, 0
13420, 0.81666666666667, 1.2833333333333, 0
13421, 0.8, 1.2833333333333, 0
13422, 0.78333333333333, 1.2833333333333, 0
13423, 0.76666666666667, 1.2833333333333, 0
13424, 0.75, 1.2833333333333, 0
13425, 0.73333333333333, 1.2833333333333, 0
13426, 0.71666666666667, 1.2833333333333, 0
13427, 0.7, 1.2833333333333, 0
13428, 0.68333333333333, 1.2833333333333, 0
13429, 0.66666666666667, 1.2833333333333, 0
13430, 0.65, 1.2833333333333, 0
13431, 0.63333333333333, 1.2833333333333, 0
13432, 0.61666666666667, 1.2833333333333, 0
13433, 0.6, 1.2833333333333, 0
13434, 0.58333333333333, 1.2833333333333, 0
13435, 0.56666666666667, 1.2833333333333, 0
13436, 0.55, 1.2833333333333, 0
13437, 0.53333333333333, 1.2833333333333, 0
13438, 0.51666666666667, 1.2833333333333, 0
13439, 0.5, 1.2833333333333, 0
13440, 0.48333333333333, 1.2833333333333, 0
13441, 0.46666666666667, 1.2833333333333, 0
13442, 0.45, 1.2833333333333, 0
13443, 0.43333333333333, 1.2833333333333, 0
13444, 0.41666666666667, 1.2833333333333, 0
13445, 0.4, 1.2833333333333, 0
13446, 0.38333333333333, 1.2833333333333, 0
13447, 0.36666666666667, 1.2833333333333, 0
13448, 0.35, 1.2833333333333, 0
13449, 0.33333333333333, 1.2833333333333, 0
13450, 0.31666666666667, 1.2833333333333, 0
13451, 0.3, 1.2833333333333, 0
13452, 0.28333333333333, 1.2833333333333, 0
13453, 0.26666666666667, 1.2833333333333, 0
13454, 0.25, 1.2833333333333, 0
13455, 0.23333333333333, 1.2833333333333, 0
13456, 0.21666666666667, 1.2833333333333, 0
13457, 0.2, 1.2833333333333, 0
13458, 0.18333333333333, 1.2833333333333, 0
13459, 0.16666666666667, 1.2833333333333, 0
13460, 0.15, 1.2833333333333, 0
13461, 0.13333333333333, 1.2833333333333, 0
13462, 0.11666666666667, 1.2833333333333, 0
13463, 0.1, 1.2833333333333, 0
13464, 0.083333333333333, 1.2833333333333, 0
13465, 0.066666666666667, 1.2833333333333, 0
13466, 0.05, 1.2833333333333, 0
13467, 0.033333333333333, 1.2833333333333, 0
13468, 0.016666666666667, 1.2833333333333, 0
13469, 0.98333333333333, 1.3, 0
13470, 0.96666666666667, 1.3, 0
13471, 0.95, 1.3, 0
13472, 0.93333333333333, 1.3, 0
13473, 0.91666666666667, 1.3, 0
13474, 0.9, 1.3, 0
13475, 0.88333333333333, 1.3, 0
13476, 0.86666666666667, 1.3, 0
13477, 0.85, 1.3, 0
13478, 0.83333333333333, 1.3, 0
13479, 0.81666666666667, 1.3, 0
13480, 0.8, 1.3, 0
13481, 0.78333333333333, 1.3, 0
13482, 0.76666666666667, 1.3, 0
13483, 0.75, 1.3, 0
13484, 0.73333333333333, 1.3, 0
13485, 0.71666666666667, 1.3, 0
13486, 0.7, 1.3, 0
13487, 0.68333333333333, 1.3, 0
13488, 0.66666666666667, 1.3, 0
13489, 0.65, 1.3, 0
13490, 0.63333333333333, 1.3, 0
13491, 0.61666666666667, 1.3, 0
13492, 0.6, 1.3, 0
13493, 0.58333333333333, 1.3, 0
13494, 0.56666666666667, 1.3, 0
13495, 0.55, 1.3, 0
13496, 0.53333333333333, 1.3, 0
13497, 0.51666666666667, 1.3, 0
13498, 0.5, 1.3, 0
13499, 0.48333333333333, 1.3, 0
13500, 0.46666666666667, 1.3, 0
13501, 0.45, 1.3, 0
13502, 0.43333333333333, 1.3, 0
13503, 0.41666666666667, 1.3, 0
13504, 0.4, 1.3, 0
13505, 0.38333333333333, 1.3, 0
13506, 0.36666666666667, 1.3, 0
13507, 0.35, 1.3, 0
13508, 0.33333333333333, 1.3, 0
13509, 0.31666666666667, 1.3, 0
13510, 0.3, 1.3, 0
13511, 0.28333333333333, 1.3, 0
13512, 0.26666666666667, 1.3, 0
13513, 0.25, 1.3, 0
13514, 0.23333333333333, 1.3, 0
13515, 0.21666666666667, 1.3, 0
13516, 0.2, 1.3, 0
13517, 0.18333333333333, 1.3, 0
13518, 0.16666666666667, 1.3, 0
13519, 0.15, 1.3, 0
13520, 0.13333333333333, 1.3, 0
13521, 0.11666666666667, 1.3, 0
13522, 0.1, 1.3, 0
13523, 0.083333333333333, 1.3, 0
13524, 0.066666666666667, 1.3, 0
13525, 0.05, 1.3, 0
13526, 0.033333333333333, 1.3, 0
13527, 0.016666666666667, 1.3, 0
13528, 0.98333333333333, 1.3166666666667, 0
13529, 0.96666666666667, 1.3166666666667, 0
13530, 0.95, 1.3166666666667, 0
13531, 0.93333333333333, 1.3166666666667, 0
13532, 0.91666666666667, 1.3166666666667, 0
13533, 0.9, 1.3166666666667, 0
13534, 0.88333333333333, 1.3166666666667, 0
13535, 0.86666666666667, 1.3166666666667, 0
13536, 0.85, 1.3166666666667, 0
13537, 0.83333333333333, 1.3166666666667, 0
13538, 0.81666666666667, 1.3166666666667, 0
13539, 0.8, 1.3166666666667, 0
13540, 0.78333333333333, 1.3166666666667, 0
13541, 0.76666666666667, 1.3166666666667, 0
13542, 0.75, 1.3166666666667, 0
13543, 0.73333333333333, 1.3166666666667, 0
13544, 0.71666666666667, 1.3166666666667, 0
13545, 0.7, 1.3166666666667, 0
13546, 0.68333333333333, 1.3166666666667, 0
13547, 0.66666666666667, 1.3166666666667, 0
13548, 0.65, 1.3166666666667, 0
13549, 0.63333333333333, 1.3166666666667, 0
13550, 0.61666666666667, 1.3166666666667, 0
13551, 0.6, 1.3166666666667, 0
13552, 0.58333333333333, 1.3166666666667, 0
13553, 0.56666666666667, 1.3166666666667, 0
13554, 0.55, 1.3166666666667, 0
13555, 0.53333333333333, 1.3166666666667, 0
13556, 0.51666666666667, 1.3166666666667, 0
13557, 0.5, 1.3166666666667, 0
13558, 0.48333333333333, 1.3166666666667, 0
13559, 0.46666666666667, 1.3166666666667, 0
13560, 0.45, 1.3166666666667, 0
13561, 0.43333333333333, 1.3166666666667, 0
13562, 0.41666666666667, 1.3166666666667, 0
13563, 0.4, 1.3166666666667, 0
13564, 0.38333333333333, 1.3166666666667, 0
13565, 0.36666666666667, 1.3166666666667, 0
13566, 0.35, 1.3166666666667, 0
13567, 0.33333333333333, 1.3166666666667, 0
13568, 0.31666666666667, 1.3166666666667, 0
13569, 0.3, 1.3166666666667, 0
13570, 0.28333333333333, 1.3166666666667, 0
13571, 0.26666666666667, 1.3166666666667, 0
13572, 0.25, 1.3166666666667, 0
13573, 0.23333333333333, 1.3166666666667, 0
13574, 0.21666666666667, 1.3166666666667, 0
13575, 0.2, 1.3166666666667, 0
13576, 0.18333333333333, 1.3166666666667, 0
13577, 0.16666666666667, 1.3166666666667, 0
13578, 0.15, 1.3166666666667, 0
13579, 0.13333333333333, 1.3166666666667, 0
13580, 0.11666666666667, 1.3166666666667, 0
13581, 0.1, 1.3166666666667, 0
13582, 0.083333333333333, 1.3166666666667, 0
13583, 0.066666666666667, 1.3166666666667, 0
13584, 0.05, 1.3166666666667, 0
13585, 0.033333333333333, 1.3166666666667, 0
13586, 0.016666666666667, 1.3166666666667, 0
13587, 0.98333333333333, 1.3333333333333, 0
13588, 0.96666666666667, 1.3333333333333, 0
13589, 0.95, 1.3333333333333, 0
13590, 0.93333333333333, 1.3333333333333, 0
13591, 0.91666666666667, 1.3333333333333, 0
13592, 0.9, 1.3333333333333, 0
13593, 0.88333333333333, 1.3333333333333, 0
13594, 0.86666666666667, 1.3333333333333, 0
13595, 0.85, 1.3333333333333, 0
13596, 0.83333333333333, 1.3333333333333, 0
13597, 0.81666666666667, 1.3333333333333, 0
13598, 0.8, 1.3333333333333, 0
13599, 0.78333333333333, 1.3333333333333, 0
13600, 0.76666666666667, 1.3333333333333, 0
13601, 0.75, 1.3333333333333, 0
13602, 0.73333333333333, 1.3333333333333, 0
13603, 0.71666666666667, 1.3333333333333, 0
13604, 0.7, 1.3333333333333, 0
13605, 0.68333333333333, 1.3333333333333, 0
13606, 0.66666666666667, 1.3333333333333, 0
13607, 0.65, 1.3333333333333, 0
13608, 0.63333333333333, 1.3333333333333, 0
13609, 0.61666666666667, 1.3333333333333, 0
13610, 0.6, 1.3333333333333, 0
13611, 0.58333333333333, 1.3333333333333, 0
13612, 0.56666666666667, 1.3333333333333, 0
13613, 0.55, 1.3333333333333, 0
13614, 0.53333333333333, 1.3333333333333, 0
13615, 0.51666666666667, 1.3333333333333, 0
13616, 0.5, 1.3333333333333, 0
13617, 0.48333333333333, 1.3333333333333, 0
13618, 0.46666666666667, 1.3333333333333, 0
13619, 0.45, 1.3333333333333, 0
13620, 0.43333333333333, 1.3333333333333, 0
13621, 0.41666666666667, 1.3333333333333, 0
13622, 0.4, 1.3333333333333, 0
13623, 0.38333333333333, 1.3333333333333, 0
13624, 0.36666666666667, 1.3333333333333, 0
13625, 0.35, 1.3333333333333, 0
13626, 0.33333333333333, 1.3333333333333, 0
13627, 0.31666666666667, 1.3333333333333, 0
13628, 0.3, 1.3333333333333, 0
13629, 0.28333333333333, 1.3333333333333, 0
13630, 0.26666666666667, 1.3333333333333, 0
13631, 0.25, 1.3333333333333, 0
13632, 0.23333333333333, 1.3333333333333, 0
13633, 0.21666666666667, 1.3333333333333, 0
13634, 0.2, 1.3333333333333, 0
13635, 0.18333333333333, 1.3333333333333, 0
13636, 0.16666666666667, 1.3333333333333, 0
13637, 0.15, 1.3333333333333, 0
13638, 0.13333333333333, 1.3333333333333, 0
13639, 0.11666666666667, 1.3333333333333, 0
13640, 0.1, 1.3333333333333, 0
13641, 0.083333333333333, 1.3333333333333, 0
13642, 0.066666666666667, 1.3333333333333, 0
13643, 0.05, 1.3333333333333, 0
13644, 0.033333333333333, 1.3333333333333, 0
13645, 0.016666666666667, 1.3333333333333, 0
13646, 0.99166666666667, 1.2666666666667, 0
13647, 0.98333333333333, 1.2583333333333, 0
13648, 0.975, 1.2666666666667, 0
13649, 0.96666666666667, 1.2583333333333, 0
13650, 0.95833333333333, 1.2666666666667, 0
13651, 0.95, 1.2583333333333, 0
13652, 0.94166666666667, 1.2666666666667, 0
13653, 0.93333333333333, 1.2583333333333, 0
13654, 0.925, 1.2666666666667, 0
13655, 0.91666666666667, 1.2583333333333, 0
13656, 0.90833333333333, 1.2666666666667, 0
13657, 0.9, 1.2583333333333, 0
13658, 0.89166666666667, 1.2666666666667, 0
13659, 0.88333333333333, 1.2583333333333, 0
13660, 0.875, 1.2666666666667, 0
13661, 0.86666666666667, 1.2583333333333, 0
13662, 0.85833333333333, 1.2666666666667, 0
13663, 0.85, 1.2583333333333, 0
13664, 0.84166666666667, 1.2666666666667, 0
13665, 0.83333333333333, 1.2583333333333, 0
13666, 0.825, 1.2666666666667, 0
13667, 0.81666666666667, 1.2583333333333, 0
13668, 0.80833333333333, 1.2666666666667, 0
13669, 0.8, 1.2583333333333, 0
13670, 0.79166666666667, 1.2666666666667, 0
13671, 0.78333333333333, 1.2583333333333, 0
13672, 0.775, 1.2666666666667, 0
13673, 0.76666666666667, 1.2583333333333, 0
13674, 0.75833333333333, 1.2666666666667, 0
13675, 0.75, 1.2583333333333, 0
13676, 0.74166666666667, 1.2666666666667, 0
13677, 0.73333333333333, 1.2583333333333, 0
13678, 0.725, 1.2666666666667, 0
13679, 0.71666666666667, 1.2583333333333, 0
13680, 0.70833333333333, 1.2666666666667, 0
13681, 0.7, 1.2583333333333, 0
13682, 0.69166666666667, 1.2666666666667, 0
13683, 0.68333333333333, 1.2583333333333, 0
13684, 0.675, 1.2666666666667, 0
13685, 0.66666666666667, 1.2583333333333, 0
13686, 0.65833333333333, 1.2666666666667, 0
13687, 0.65, 1.2583333333333, 0
13688, 0.64166666666667, 1.2666666666667, 0
13689, 0.63333333333333, 1.2583333333333, 0
13690, 0.625, 1.2666666666667, 0
13691, 0.61666666666667, 1.2583333333333, 0
13692, 0.60833333333333, 1.2666666666667, 0
13693, 0.6, 1.2583333333333, 0
13694, 0.59166666666667, 1.2666666666667, 0
13695, 0.58333333333333, 1.2583333333333, 0
13696, 0.575, 1.2666666666667, 0
13697, 0.56666666666667, 1.2583333333333, 0
13698, 0.55833333333333, 1.2666666666667, 0
13699, 0.55, 1.2583333333333, 0
13700, 0.54166666666667, 1.2666666666667, 0
13701, 0.53333333333333, 1.2583333333333, 0
13702, 0.525, 1.2666666666667, 0
13703, 0.51666666666667, 1.2583333333333, 0
13704, 0.50833333333333, 1.2666666666667, 0
13705, 0.5, 1.2583333333333, 0
13706, 0.49166666666667, 1.2666666666667, 0
13707, 0.48333333333333, 1.2583333333333, 0
13708, 0.475, 1.2666666666667, 0
13709, 0.46666666666667, 1.2583333333333, 0
13710, 0.45833333333333, 1.2666666666667, 0
13711, 0.45, 1.2583333333333, 0
13712, 0.44166666666667, 1.2666666666667, 0
13713, 0.43333333333333, 1.2583333333333, 0
13714, 0.425, 1.2666666666667, 0
13715, 0.41666666666667, 1.2583333333333, 0
13716, 0.40833333333333, 1.2666666666667, 0
13717, 0.4, 1.2583333333333, 0
13718, 0.39166666666667, 1.2666666666667, 0
13719, 0.38333333333333, 1.2583333333333, 0
13720, 0.375, 1.2666666666667, 0
13721, 0.36666666666667, 1.2583333333333, 0
13722, 0.35833333333333, 1.2666666666667, 0
13723, 0.35, 1.2583333333333, 0
13724, 0.34166666666667, 1.2666666666667, 0
13725, 0.33333333333333, 1.2583333333333, 0
13726, 0.325, 1.2666666666667, 0
13727, 0.31666666666667, 1.2583333333333, 0
13728, 0.30833333333333, 1.2666666666667, 0
13729, 0.3, 1.2583333333333, 0
13730, 0.29166666666667, 1.2666666666667, 0
13731, 0.28333333333333, 1.2583333333333, 0
13732, 0.275, 1.2666666666667, 0
13733, 0.26666666666667, 1.2583333333333, 0
13734, 0.25833333333333, 1.2666666666667, 0
13735, 0.25, 1.2583333333333, 0
13736, 0.24166666666667, 1.2666666666667, 0
13737, 0.23333333333333, 1.2583333333333, 0
13738, 0.225, 1.2666666666667, 0
13739, 0.21666666666667, 1.2583333333333, 0
13740, 0.20833333333333, 1.2666666666667, 0
13741, 0.2, 1.2583333333333, 0
13742, 0.19166666666667, 1.2666666666667, 0
13743, 0.18333333333333, 1.2583333333333, 0
13744, 0.175, 1.2666666666667, 0
13745, 0.16666666666667, 1.2583333333333, 0
13746, 0.15833333333333, 1.2666666666667, 0
13747, 0.15, 1.2583333333333, 0
13748, 0.14166666666667, 1.2666666666667, 0
13749, 0.13333333333333, 1.2583333333333, 0
13750, 0.125, 1.2666666666667, 0
13751, 0.11666666666667, 1.2583333333333, 0
13752, 0.10833333333333, 1.2666666666667, 0
13753, 0.1, 1.2583333333333, 0
13754, 0.091666666666667, 1.2666666666667, 0
13755, 0.083333333333333, 1.2583333333333, 0
13756, 0.075, 1.2666666666667, 0
13757, 0.066666666666667, 1.2583333333333, 0
13758, 0.058333333333333, 1.2666666666667, 0
13759, 0.05, 1.2583333333333, 0
13760, 0.041666666666667, 1.2666666666667, 0
13761, 0.033333333333333, 1.2583333333333, 0
13762, 0.025, 1.2666666666667, 0
13763, 0.016666666666667, 1.2583333333333, 0
13764, 0.0083333333333333, 1.2666666666667, 0
13765, 0.99166666666667, 1.2833333333333, 0
13766, 0.98333333333333, 1.275, 0
13767, 0.975, 1.2833333333333, 0
13768, 0.96666666666667, 1.275, 0
13769, 0.95833333333333, 1.2833333333333, 0
13770, 0.95, 1.275, 0
13771, 0.94166666666667, 1.2833333333333, 0
13772, 0.93333333333333, 1.275, 0
13773, 0.925, 1.2833333333333, 0
13774, 0.91666666666667, 1.275, 0
13775, 0.90833333333333, 1.2833333333333, 0
13776, 0.9, 1.275, 0
13777, 0.89166666666667, 1.2833333333333, 0
13778, 0.88333333333333, 1.275, 0
13779, 0.875, 1.2833333333333, 0
13780, 0.86666666666667, 1.275, 0
13781, 0.85833333333333, 1.2833333333333, 0
13782, 0.85, 1.275, 0
13783, 0.84166666666667, 1.2833333333333, 0
13784, 0.83333333333333, 1.275, 0
13785, 0.825, 1.2833333333333, 0
13786, 0.81666666666667, 1.275, 0
13787, 0.80833333333333, 1.2833333333333, 0
13788, 0.8, 1.275, 0
13789, 0.79166666666667, 1.2833333333333, 0
13790, 0.78333333333333, 1.275, 0
13791, 0.775, 1.2833333333333, 0
13792, 0.76666666666667, 1.275, 0
13793, 0.75833333333333, 1.2833333333333, 0
13794, 0.75, 1.275, 0
13795, 0.74166666666667, 1.2833333333333, 0
13796, 0.73333333333333, 1.275, 0
13797, 0.725, 1.2833333333333, 0
13798, 0.71666666666667, 1.275, 0
13799, 0.70833333333333, 1.2833333333333, 0
13800, 0.7, 1.275, 0
13801, 0.69166666666667, 1.2833333333333, 0
13802, 0.68333333333333, 1.275, 0
13803, 0.675, 1.2833333333333, 0
13804, 0.66666666666667, 1.275, 0
13805, 0.65833333333333, 1.2833333333333, 0
13806, 0.65, 1.275, 0
13807, 0.64166666666667, 1.2833333333333, 0
13808, 0.63333333333333, 1.275, 0
13809, 0.625, 1.2833333333333, 0
13810, 0.61666666666667, 1.275, 0
13811, 0.60833333333333, 1.2833333333333, 0
13812, 0.6, 1.275, 0
13813, 0.59166666666667, 1.2833333333333, 0
13814, 0.58333333333333, 1.275, 0
13815, 0.575, 1.2833333333333, 0
13816, 0.56666666666667, 1.275, 0
13817, 0.55833333333333, 1.2833333333333, 0
13818, 0.55, 1.275, 0
13819, 0.54166666666667, 1.2833333333333, 0
13820, 0.53333333333333, 1.275, 0
13821, 0.525, 1.2833333333333, 0
13822, 0.51666666666667, 1.275, 0
13823, 0.50833333333333, 1.2833333333333, 0
13824, 0.5, 1.275, 0
13825, 0.49166666666667, 1.2833333333333, 0
13826, 0.48333333333333, 1.275, 0
13827, 0.475, 1.2833333333333, 0
13828, 0.46666666666667, 1.275, 0
13829, 0.45833333333333, 1.2833333333333, 0
13830, 0.45, 1.275, 0
13831, 0.44166666666667, 1.2833333333333, 0
13832, 0.43333333333333, 1.275, 0
13833, 0.425, 1.2833333333333, 0
13834, 0.41666666666667, 1.275, 0
13835, 0.40833333333333, 1.2833333333333, 0
13836, 0.4, 1.275, 0
13837, 0.39166666666667, 1.2833333333333, 0
13838, 0.38333333333333, 1.275, 0
13839, 0.375, 1.2833333333333, 0
13840, 0.36666666666667, 1.275, 0
13841, 0.35833333333333, 1.2833333333333, 0
13842, 0.35, 1.275, 0
13843, 0.34166666666667, 1.2833333333333, 0
13844, 0.33333333333333, 1.275, 0
13845, 0.325, 1.2833333333333, 0
13846, 0.31666666666667, 1.275, 0
13847, 0.30833333333333, 1.2833333333333, 0
13848, 0.3, 1.275, 0
13849, 0.29166666666667, 1.2833333333333, 0
13850, 0.28333333333333, 1.275, 0
13851, 0.275, 1.2833333333333, 0
13852, 0.26666666666667, 1.275, 0
13853, 0.25833333333333, 1.2833333333333, 0
13854, 0.25, 1.275, 0
13855, 0.24166666666667, 1.2833333333333, 0
13856, 0.23333333333333, 1.275, 0
13857, 0.225, 1.2833333333333, 0
13858, 0.21666666666667, 1.275, 0
13859, 0.20833333333333, 1.2833333333333, 0
13860, 0.2, 1.275, 0
13861, 0.19166666666667, 1.2833333333333, 0
13862, 0.18333333333333, 1.275, 0
13863, 0.175, 1.2833333333333, 0
13864, 0.16666666666667, 1.275, 0
13865, 0.15833333333333, 1.2833333333333, 0
13866, 0.15, 1.275, 0
13867, 0.14166666666667, 1.2833333333333, 0
13868, 0.13333333333333, 1.275, 0
13869, 0.125, 1.2833333333333, 0
13870, 0.11666666666667, 1.275, 0
13871, 0.10833333333333, 1.2833333333333, 0
13872, 0.1, 1.275, 0
13873, 0.091666666666667, 1.2833333333333, 0
13874, 0.083333333333333, 1.275, 0
13875, 0.075, 1.2833333333333, 0
13876, 0.066666666666667, 1.275, 0
13877, 0.058333333333333, 1.2833333333333, 0
13878, 0.05, 1.275, 0
13879, 0.041666666666667, 1.2833333333333, 0
13880, 0.033333333333333, 1.275, 0
13881, 0.025, 1.2833333333333, 0
13882, 0.016666666666667, 1.275, 0
13883, 0.0083333333333334, 1.2833333333333, 0
13884, 0.99166666666667, 1.3, 0
13885, 0.98333333333333, 1.2916666666667, 0
13886, 0.975, 1.3, 0
13887, 0.96666666666667, 1.2916666666667, 0
13888, 0.95833333333333, 1.3, 0
13889, 0.95, 1.2916666666667, 0
13890, 0.94166666666667, 1.3, 0
13891, 0.93333333333333, 1.2916666666667, 0
13892, 0.925, 1.3, 0
13893, 0.91666666666667, 1.2916666666667, 0
13894, 0.90833333333333, 1.3, 0
13895, 0.9, 1.2916666666667, 0
13896, 0.89166666666667, 1.3, 0
13897, 0.88333333333333, 1.2916666666667, 0
13898, 0.875, 1.3, 0
13899, 0.86666666666667, 1.2916666666667, 0
13900, 0.85833333333333, 1.3, 0
13901, 0.85, 1.2916666666667, 0
13902, 0.84166666666667, 1.3, 0
13903, 0.83333333333333, 1.2916666666667, 0
13904, 0.825, 1.3, 0
13905, 0.81666666666667, 1.2916666666667, 0
13906, 0.80833333333333, 1.3, 0
13907, 0.8, 1.2916666666667, 0
13908, 0.79166666666667, 1.3, 0
13909, 0.78333333333333, 1.2916666666667, 0
13910, 0.775, 1.3, 0
13911, 0.76666666666667, 1.2916666666667, 0
13912, 0.75833333333333, 1.3, 0
13913, 0.75, 1.2916666666667, 0
13914, 0.74166666666667, 1.3, 0
13915, 0.73333333333333, 1.2916666666667, 0
13916, 0.725, 1.3, 0
13917, 0.71666666666667, 1.2916666666667, 0
13918, 0.70833333333333, 1.3, 0
13919, 0.7, 1.2916666666667, 0
13920, 0.69166666666667, 1.3, 0
13921, 0.68333333333333, 1.2916666666667, 0
13922, 0.675, 1.3, 0
13923, 0.66666666666667, 1.2916666666667, 0
13924, 0.65833333333333, 1.3, 0
13925, 0.65, 1.2916666666667, 0
13926, 0.64166666666667, 1.3, 0
13927, 0.63333333333333, 1.2916666666667, 0
13928, 0.625, 1.3, 0
13929, 0.61666666666667, 1.2916666666667, 0
13930, 0.60833333333333, 1.3, 0
13931, 0.6, 1.2916666666667, 0
13932, 0.59166666666667, 1.3, 0
13933, 0.58333333333333, 1.2916666666667, 0
13934, 0.575, 1.3, 0
13935, 0.56666666666667, 1.2916666666667, 0
13936, 0.55833333333333, 1.3, 0
13937, 0.55, 1.2916666666667, 0
13938, 0.54166666666667, 1.3, 0
13939, 0.53333333333333, 1.2916666666667, 0
13940, 0.525, 1.3, 0
13941, 0.51666666666667, 1.2916666666667, 0
13942, 0.50833333333333, 1.3, 0
13943, 0.5, 1.2916666666667, 0
13944, 0.49166666666667, 1.3, 0
13945, 0.48333333333333, 1.2916666666667, 0
13946, 0.475, 1.3, 0
13947, 0.46666666666667, 1.2916666666667, 0
13948, 0.45833333333333, 1.3, 0
13949, 0.45, 1.2916666666667, 0
13950, 0.44166666666667, 1.3, 0
13951, 0.43333333333333, 1.2916666666667, 0
13952, 0.425, 1.3, 0
13953, 0.41666666666667, 1.2916666666667, 0
13954, 0.40833333333333, 1.3, 0
13955, 0.4, 1.2916666666667, 0
13956, 0.39166666666667, 1.3, 0
13957, 0.38333333333333, 1.2916666666667, 0
13958, 0.375, 1.3, 0
13959, 0.36666666666667, 1.2916666666667, 0
13960, 0.35833333333333, 1.3, 0
13961, 0.35, 1.2916666666667, 0
13962, 0.34166666666667, 1.3, 0
13963, 0.33333333333333, 1.2916666666667, 0
13964, 0.325, 1.3, 0
13965, 0.31666666666667, 1.2916666666667, 0
13966, 0.30833333333333, 1.3, 0
13967, 0.3, 1.2916666666667, 0
13968, 0.29166666666667, 1.3, 0
13969, 0.28333333333333, 1.2916666666667, 0
13970, 0.275, 1.3, 0
13971, 0.26666666666667, 1.2916666666667, 0
13972, 0.25833333333333, 1.3, 0
13973, 0.25, 1.2916666666667, 0
13974, 0.24166666666667, 1.3, 0
13975, 0.23333333333333, 1.2916666666667, 0
13976, 0.225, 1.3, 0
13977, 0.21666666666667, 1.2916666666667, 0
13978, 0.20833333333333, 1.3, 0
13979, 0.2, 1.2916666666667, 0
13980, 0.19166666666667, 1.3, 0
13981, 0.18333333333333, 1.2916666666667, 0
13982, 0.175, 1.3, 0
13983, 0.16666666666667, 1.2916666666667, 0
13984, 0.15833333333333, 1.3, 0
13985, 0.15, 1.2916666666667, 0
13986, 0.14166666666667, 1.3, 0
13987, 0.13333333333333, 1.2916666666667, 0
13988, 0.125, 1.3, 0
13989, 0.11666666666667, 1.2916666666667, 0
13990, 0.10833333333333, 1.3, 0
13991, 0.1, 1.2916666666667, 0
13992, 0.091666666666667, 1.3, 0
13993, 0.083333333333333, 1.2916666666667, 0
13994, 0.075, 1.3, 0
13995, 0.066666666666667, 1.2916666666667, 0
13996, 0.058333333333333, 1.3, 0
13997, 0.05, 1.2916666666667, 0
13998, 0.041666666666667, 1.3, 0
13999, 0.033333333333333, 1.2916666666667, 0
14000, 0.025, 1.3, 0
14001, 0.016666666666667, 1.2916666666667, 0
14002, 0.0083333333333333, 1.3, 0
14003, 0.99166666666667, 1.3166666666667, 0
14004, 0.98333333333333, 1.3083333333333, 0
14005, 0.975, 1.3166666666667, 0
14006, 0.96666666666667, 1.3083333333333, 0
14007, 0.95833333333333, 1.3166666666667, 0
14008, 0.95, 1.3083333333333, 0
14009, 0.94166666666667, 1.3166666666667, 0
14010, 0.93333333333333, 1.3083333333333, 0
14011, 0.925, 1.3166666666667, 0
14012, 0.91666666666667, 1.3083333333333, 0
14013, 0.90833333333333, 1.3166666666667, 0
14014, 0.9, 1.3083333333333, 0
14015, 0.89166666666667, 1.3166666666667, 0
14016, 0.88333333333333, 1.3083333333333, 0
14017, 0.875, 1.3166666666667, 0
14018, 0.86666666666667, 1.3083333333333, 0
14019, 0.85833333333333, 1.3166666666667, 0
14020, 0.85, 1.3083333333333, 0
14021, 0.84166666666667, 1.3166666666667, 0
14022, 0.83333333333333, 1.3083333333333, 0
14023, 0.825, 1.3166666666667, 0
14024, 0.81666666666667, 1.3083333333333, 0
14025, 0.80833333333333, 1.3166666666667, 0
14026, 0.8, 1.3083333333333, 0
14027, 0.79166666666667, 1.3166666666667, 0
14028, 0.78333333333333, 1.3083333333333, 0
14029, 0.775, 1.3166666666667, 0
14030, 0.76666666666667, 1.3083333333333, 0
14031, 0.75833333333333, 1.3166666666667, 0
14032, 0.75, 1.3083333333333, 0
14033, 0.74166666666667, 1.3166666666667, 0
14034, 0.73333333333333, 1.3083333333333, 0
14035, 0.725, 1.3166666666667, 0
14036, 0.71666666666667, 1.3083333333333, 0
14037, 0.70833333333333, 1.3166666666667, 0
14038, 0.7, 1.3083333333333, 0
14039, 0.69166666666667, 1.3166666666667, 0
14040, 0.68333333333333, 1.3083333333333, 0
14041, 0.675, 1.3166666666667, 0
14042, 0.66666666666667, 1.3083333333333, 0
14043, 0.65833333333333, 1.3166666666667, 0
14044, 0.65, 1.3083333333333, 0
14045, 0.64166666666667, 1.3166666666667, 0
14046, 0.63333333333333, 1.3083333333333, 0
14047, 0.625, 1.3166666666667, 0
14048, 0.61666666666667, 1.3083333333333, 0
14049, 0.60833333333333, 1.3166666666667, 0
14050, 0.6, 1.3083333333333, 0
14051, 0.59166666666667, 1.3166666666667, 0
14052, 0.58333333333333, 1.3083333333333, 0
14053, 0.575, 1.3166666666667, 0
14054, 0.56666666666667, 1.3083333333333, 0
14055, 0.55833333333333, 1.3166666666667, 0
14056, 0.55, 1.3083333333333, 0
14057, 0.54166666666667, 1.3166666666667, 0
14058, 0.53333333333333, 1.3083333333333, 0
14059, 0.525, 1.3166666666667, 0
14060, 0.51666666666667, 1.3083333333333, 0
14061, 0.50833333333333, 1.3166666666667, 0
14062, 0.5, 1.3083333333333, 0
14063, 0.49166666666667, 1.3166666666667, 0
14064, 0.48333333333333, 1.3083333333333, 0
14065, 0.475, 1.3166666666667, 0
14066, 0.46666666666667, 1.3083333333333, 0
14067, 0.45833333333333, 1.3166666666667, 0
14068, 0.45, 1.3083333333333, 0
14069, 0.44166666666667, 1.3166666666667, 0
14070, 0.43333333333333, 1.3083333333333, 0
14071, 0.425, 1.3166666666667, 0
14072, 0.41666666666667, 1.3083333333333, 0
14073, 0.40833333333333, 1.3166666666667, 0
14074, 0.4, 1.3083333333333, 0
14075, 0.39166666666667, 1.3166666666667, 0
14076, 0.38333333333333, 1.3083333333333, 0
14077, 0.375, 1.3166666666667, 0
14078, 0.36666666666667, 1.3083333333333, 0
14079, 0.35833333333333, 1.3166666666667, 0
14080, 0.35, 1.3083333333333, 0
14081, 0.34166666666667, 1.3166666666667, 0
14082, 0.33333333333333, 1.3083333333333, 0
14083, 0.325, 1.3166666666667, 0
14084, 0.31666666666667, 1.3083333333333, 0
14085, 0.30833333333333, 1.3166666666667, 0
14086, 0.3, 1.3083333333333, 0
14087, 0.29166666666667, 1.3166666666667, 0
14088, 0.28333333333333, 1.3083333333333, 0
14089, 0.275, 1.3166666666667, 0
14090, 0.26666666666667, 1.3083333333333, 0
14091, 0.25833333333333, 1.3166666666667, 0
14092, 0.25, 1.3083333333333, 0
14093, 0.24166666666667, 1.3166666666667, 0
14094, 0.23333333333333, 1.3083333333333, 0
14095, 0.225, 1.3166666666667, 0
14096, 0.21666666666667, 1.3083333333333, 0
14097, 0.20833333333333, 1.3166666666667, 0
14098, 0.2, 1.3083333333333, 0
14099, 0.19166666666667, 1.3166666666667, 0
14100, 0.18333333333333, 1.3083333333333, 0
14101, 0.175, 1.3166666666667, 0
14102, 0.16666666666667, 1.3083333333333, 0
14103, 0.15833333333333, 1.3166666666667, 0
14104, 0.15, 1.3083333333333, 0
14105, 0.14166666666667, 1.3166666666667, 0
14106, 0.13333333333333, 1.3083333333333, 0
14107, 0.125, 1.3166666666667, 0
14108, 0.11666666666667, 1.3083333333333, 0
14109, 0.10833333333333, 1.3166666666667, 0
14110, 0.1, 1.3083333333333, 0
14111, 0.091666666666667, 1.3166666666667, 0
14112, 0.083333333333333, 1.3083333333333, 0
14113, 0.075, 1.3166666666667, 0
14114, 0.066666666666667, 1.3083333333333, 0
14115, 0.058333333333333, 1.3166666666667, 0
14116, 0.05, 1.3083333333333, 0
14117, 0.041666666666667, 1.3166666666667, 0
14118, 0.033333333333333, 1.3083333333333, 0
14119, 0.025, 1.3166666666667, 0
14120, 0.016666666666667, 1.3083333333333, 0
14121, 0.0083333333333334, 1.3166666666667, 0
14122, 0.99166666666667, 1.3333333333333, 0
14123, 0.98333333333333, 1.325, 0
14124, 0.975, 1.3333333333333, 0
14125, 0.96666666666667, 1.325, 0
14126, 0.95833333333333, 1.3333333333333, 0
14127, 0.95, 1.325, 0
14128, 0.94166666666667, 1.3333333333333, 0
14129, 0.93333333333333, 1.325, 0
14130, 0.925, 1.3333333333333, 0
14131, 0.91666666666667, 1.325, 0
14132, 0.90833333333333, 1.3333333333333, 0
14133, 0.9, 1.325, 0
14134, 0.89166666666667, 1.3333333333333, 0
14135, 0.88333333333333, 1.325, 0
14136, 0.875, 1.3333333333333, 0
14137, 0.86666666666667, 1.325, 0
14138, 0.85833333333333, 1.3333333333333, 0
14139, 0.85, 1.325, 0
14140, 0.84166666666667, 1.3333333333333, 0
14141, 0.83333333333333, 1.325, 0
14142, 0.825, 1.3333333333333, 0
14143, 0.81666666666667, 1.325, 0
14144, 0.80833333333333, 1.3333333333333, 0
14145, 0.8, 1.325, 0
14146, 0.79166666666667, 1.3333333333333, 0
14147, 0.78333333333333, 1.325, 0
14148, 0.775, 1.3333333333333, 0
14149, 0.76666666666667, 1.325, 0
14150, 0.75833333333333, 1.3333333333333, 0
14151, 0.75, 1.325, 0
14152, 0.74166666666667, 1.3333333333333, 0
14153, 0.73333333333333, 1.325, 0
14154, 0.725, 1.3333333333333, 0
14155, 0.71666666666667, 1.325, 0
14156, 0.70833333333333, 1.3333333333333, 0
14157, 0.7, 1.325, 0
14158, 0.69166666666667, 1.3333333333333, 0
14159, 0.68333333333333, 1.325, 0
14160, 0.675, 1.3333333333333, 0
14161, 0.66666666666667, 1.325, 0
14162, 0.65833333333333, 1.3333333333333, 0
14163, 0.65, 1.325, 0
14164, 0.64166666666667, 1.3333333333333, 0
14165, 0.63333333333333, 1.325, 0
14166, 0.625, 1.3333333333333, 0
14167, 0.61666666666667, 1.325, 0
14168, 0.60833333333333, 1.3333333333333, 0
14169, 0.6, 1.325, 0
14170, 0.59166666666667, 1.3333333333333, 0
14171, 0.58333333333333, 1.325, 0
14172, 0.575, 1.3333333333333, 0
14173, 0.56666666666667, 1.325, 0
