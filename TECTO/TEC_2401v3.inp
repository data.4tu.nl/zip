3872, 0.31666666666667, 0.42, 0
3873, 0.31666666666667, 0.44, 0
3874, 0.31666666666667, 0.46, 0
3875, 0.31666666666667, 0.48, 0
3876, 0.31666666666667, 0.5, 0
3877, 0.31666666666667, 0.52, 0
3878, 0.31666666666667, 0.54, 0
3879, 0.31666666666667, 0.56, 0
3880, 0.31666666666667, 0.58, 0
3881, 0.31666666666667, 0.6, 0
3882, 0.31666666666667, 0.62, 0
3883, 0.31666666666667, 0.64, 0
3884, 0.31666666666667, 0.66, 0
3885, 0.31666666666667, 0.68, 0
3886, 0.31666666666667, 0.7, 0
3887, 0.31666666666667, 0.72, 0
3888, 0.31666666666667, 0.74, 0
3889, 0.31666666666667, 0.76, 0
3890, 0.31666666666667, 0.78, 0
3891, 0.31666666666667, 0.8, 0
3892, 0.31666666666667, 0.82, 0
3893, 0.31666666666667, 0.84, 0
3894, 0.31666666666667, 0.86, 0
3895, 0.31666666666667, 0.88, 0
3896, 0.31666666666667, 0.9, 0
3897, 0.31666666666667, 0.92, 0
3898, 0.31666666666667, 0.94, 0
3899, 0.31666666666667, 0.96, 0
3900, 0.31666666666667, 0.98, 0
3901, 0.31666666666667, 1, 0
3902, 0.31666666666667, 1.02, 0
3903, 0.31666666666667, 1.04, 0
3904, 0.31666666666667, 1.06, 0
3905, 0.31666666666667, 1.08, 0
3906, 0.31666666666667, 1.1, 0
3907, 0.31666666666667, 1.12, 0
3908, 0.31666666666667, 1.14, 0
3909, 0.31666666666667, 1.16, 0
3910, 0.31666666666667, 1.18, 0
3911, 0.33333333333333, 0.02, 0
3912, 0.33333333333333, 0.04, 0
3913, 0.33333333333333, 0.06, 0
3914, 0.33333333333333, 0.08, 0
3915, 0.33333333333333, 0.1, 0
3916, 0.33333333333333, 0.12, 0
3917, 0.33333333333333, 0.14, 0
3918, 0.33333333333333, 0.16, 0
3919, 0.33333333333333, 0.18, 0
3920, 0.33333333333333, 0.2, 0
3921, 0.33333333333333, 0.22, 0
3922, 0.33333333333333, 0.24, 0
3923, 0.33333333333333, 0.26, 0
3924, 0.33333333333333, 0.28, 0
3925, 0.33333333333333, 0.3, 0
3926, 0.33333333333333, 0.32, 0
3927, 0.33333333333333, 0.34, 0
3928, 0.33333333333333, 0.36, 0
3929, 0.33333333333333, 0.38, 0
3930, 0.33333333333333, 0.4, 0
3931, 0.33333333333333, 0.42, 0
3932, 0.33333333333333, 0.44, 0
3933, 0.33333333333333, 0.46, 0
3934, 0.33333333333333, 0.48, 0
3935, 0.33333333333333, 0.5, 0
3936, 0.33333333333333, 0.52, 0
3937, 0.33333333333333, 0.54, 0
3938, 0.33333333333333, 0.56, 0
3939, 0.33333333333333, 0.58, 0
3940, 0.33333333333333, 0.6, 0
3941, 0.33333333333333, 0.62, 0
3942, 0.33333333333333, 0.64, 0
3943, 0.33333333333333, 0.66, 0
3944, 0.33333333333333, 0.68, 0
3945, 0.33333333333333, 0.7, 0
3946, 0.33333333333333, 0.72, 0
3947, 0.33333333333333, 0.74, 0
3948, 0.33333333333333, 0.76, 0
3949, 0.33333333333333, 0.78, 0
3950, 0.33333333333333, 0.8, 0
3951, 0.33333333333333, 0.82, 0
3952, 0.33333333333333, 0.84, 0
3953, 0.33333333333333, 0.86, 0
3954, 0.33333333333333, 0.88, 0
3955, 0.33333333333333, 0.9, 0
3956, 0.33333333333333, 0.92, 0
3957, 0.33333333333333, 0.94, 0
3958, 0.33333333333333, 0.96, 0
3959, 0.33333333333333, 0.98, 0
3960, 0.33333333333333, 1, 0
3961, 0.33333333333333, 1.02, 0
3962, 0.33333333333333, 1.04, 0
3963, 0.33333333333333, 1.06, 0
3964, 0.33333333333333, 1.08, 0
3965, 0.33333333333333, 1.1, 0
3966, 0.33333333333333, 1.12, 0
3967, 0.33333333333333, 1.14, 0
3968, 0.33333333333333, 1.16, 0
3969, 0.33333333333333, 1.18, 0
3970, 0.35, 0.02, 0
3971, 0.35, 0.04, 0
3972, 0.35, 0.06, 0
3973, 0.35, 0.08, 0
3974, 0.35, 0.1, 0
3975, 0.35, 0.12, 0
3976, 0.35, 0.14, 0
3977, 0.35, 0.16, 0
3978, 0.35, 0.18, 0
3979, 0.35, 0.2, 0
3980, 0.35, 0.22, 0
3981, 0.35, 0.24, 0
3982, 0.35, 0.26, 0
3983, 0.35, 0.28, 0
3984, 0.35, 0.3, 0
3985, 0.35, 0.32, 0
3986, 0.35, 0.34, 0
3987, 0.35, 0.36, 0
3988, 0.35, 0.38, 0
3989, 0.35, 0.4, 0
3990, 0.35, 0.42, 0
3991, 0.35, 0.44, 0
3992, 0.35, 0.46, 0
3993, 0.35, 0.48, 0
3994, 0.35, 0.5, 0
3995, 0.35, 0.52, 0
3996, 0.35, 0.54, 0
3997, 0.35, 0.56, 0
3998, 0.35, 0.58, 0
3999, 0.35, 0.6, 0
4000, 0.35, 0.62, 0
4001, 0.35, 0.64, 0
4002, 0.35, 0.66, 0
4003, 0.35, 0.68, 0
4004, 0.35, 0.7, 0
4005, 0.35, 0.72, 0
4006, 0.35, 0.74, 0
4007, 0.35, 0.76, 0
4008, 0.35, 0.78, 0
4009, 0.35, 0.8, 0
4010, 0.35, 0.82, 0
4011, 0.35, 0.84, 0
4012, 0.35, 0.86, 0
4013, 0.35, 0.88, 0
4014, 0.35, 0.9, 0
4015, 0.35, 0.92, 0
4016, 0.35, 0.94, 0
4017, 0.35, 0.96, 0
4018, 0.35, 0.98, 0
4019, 0.35, 1, 0
4020, 0.35, 1.02, 0
4021, 0.35, 1.04, 0
4022, 0.35, 1.06, 0
4023, 0.35, 1.08, 0
4024, 0.35, 1.1, 0
4025, 0.35, 1.12, 0
4026, 0.35, 1.14, 0
4027, 0.35, 1.16, 0
4028, 0.35, 1.18, 0
4029, 0.36666666666667, 0.02, 0
4030, 0.36666666666667, 0.04, 0
4031, 0.36666666666667, 0.06, 0
4032, 0.36666666666667, 0.08, 0
4033, 0.36666666666667, 0.1, 0
4034, 0.36666666666667, 0.12, 0
4035, 0.36666666666667, 0.14, 0
4036, 0.36666666666667, 0.16, 0
4037, 0.36666666666667, 0.18, 0
4038, 0.36666666666667, 0.2, 0
4039, 0.36666666666667, 0.22, 0
4040, 0.36666666666667, 0.24, 0
4041, 0.36666666666667, 0.26, 0
4042, 0.36666666666667, 0.28, 0
4043, 0.36666666666667, 0.3, 0
4044, 0.36666666666667, 0.32, 0
4045, 0.36666666666667, 0.34, 0
4046, 0.36666666666667, 0.36, 0
4047, 0.36666666666667, 0.38, 0
4048, 0.36666666666667, 0.4, 0
4049, 0.36666666666667, 0.42, 0
4050, 0.36666666666667, 0.44, 0
4051, 0.36666666666667, 0.46, 0
4052, 0.36666666666667, 0.48, 0
4053, 0.36666666666667, 0.5, 0
4054, 0.36666666666667, 0.52, 0
4055, 0.36666666666667, 0.54, 0
4056, 0.36666666666667, 0.56, 0
4057, 0.36666666666667, 0.58, 0
4058, 0.36666666666667, 0.6, 0
4059, 0.36666666666667, 0.62, 0
4060, 0.36666666666667, 0.64, 0
4061, 0.36666666666667, 0.66, 0
4062, 0.36666666666667, 0.68, 0
4063, 0.36666666666667, 0.7, 0
4064, 0.36666666666667, 0.72, 0
4065, 0.36666666666667, 0.74, 0
4066, 0.36666666666667, 0.76, 0
4067, 0.36666666666667, 0.78, 0
4068, 0.36666666666667, 0.8, 0
4069, 0.36666666666667, 0.82, 0
4070, 0.36666666666667, 0.84, 0
4071, 0.36666666666667, 0.86, 0
4072, 0.36666666666667, 0.88, 0
4073, 0.36666666666667, 0.9, 0
4074, 0.36666666666667, 0.92, 0
4075, 0.36666666666667, 0.94, 0
4076, 0.36666666666667, 0.96, 0
4077, 0.36666666666667, 0.98, 0
4078, 0.36666666666667, 1, 0
4079, 0.36666666666667, 1.02, 0
4080, 0.36666666666667, 1.04, 0
4081, 0.36666666666667, 1.06, 0
4082, 0.36666666666667, 1.08, 0
4083, 0.36666666666667, 1.1, 0
4084, 0.36666666666667, 1.12, 0
4085, 0.36666666666667, 1.14, 0
4086, 0.36666666666667, 1.16, 0
4087, 0.36666666666667, 1.18, 0
4088, 0.38333333333333, 0.02, 0
4089, 0.38333333333333, 0.04, 0
4090, 0.38333333333333, 0.06, 0
4091, 0.38333333333333, 0.08, 0
4092, 0.38333333333333, 0.1, 0
4093, 0.38333333333333, 0.12, 0
4094, 0.38333333333333, 0.14, 0
4095, 0.38333333333333, 0.16, 0
4096, 0.38333333333333, 0.18, 0
4097, 0.38333333333333, 0.2, 0
4098, 0.38333333333333, 0.22, 0
4099, 0.38333333333333, 0.24, 0
4100, 0.38333333333333, 0.26, 0
4101, 0.38333333333333, 0.28, 0
4102, 0.38333333333333, 0.3, 0
4103, 0.38333333333333, 0.32, 0
4104, 0.38333333333333, 0.34, 0
4105, 0.38333333333333, 0.36, 0
4106, 0.38333333333333, 0.38, 0
4107, 0.38333333333333, 0.4, 0
4108, 0.38333333333333, 0.42, 0
4109, 0.38333333333333, 0.44, 0
4110, 0.38333333333333, 0.46, 0
4111, 0.38333333333333, 0.48, 0
4112, 0.38333333333333, 0.5, 0
4113, 0.38333333333333, 0.52, 0
4114, 0.38333333333333, 0.54, 0
4115, 0.38333333333333, 0.56, 0
4116, 0.38333333333333, 0.58, 0
4117, 0.38333333333333, 0.6, 0
4118, 0.38333333333333, 0.62, 0
4119, 0.38333333333333, 0.64, 0
4120, 0.38333333333333, 0.66, 0
4121, 0.38333333333333, 0.68, 0
4122, 0.38333333333333, 0.7, 0
4123, 0.38333333333333, 0.72, 0
4124, 0.38333333333333, 0.74, 0
4125, 0.38333333333333, 0.76, 0
4126, 0.38333333333333, 0.78, 0
4127, 0.38333333333333, 0.8, 0
4128, 0.38333333333333, 0.82, 0
4129, 0.38333333333333, 0.84, 0
4130, 0.38333333333333, 0.86, 0
4131, 0.38333333333333, 0.88, 0
4132, 0.38333333333333, 0.9, 0
4133, 0.38333333333333, 0.92, 0
4134, 0.38333333333333, 0.94, 0
4135, 0.38333333333333, 0.96, 0
4136, 0.38333333333333, 0.98, 0
4137, 0.38333333333333, 1, 0
4138, 0.38333333333333, 1.02, 0
4139, 0.38333333333333, 1.04, 0
4140, 0.38333333333333, 1.06, 0
4141, 0.38333333333333, 1.08, 0
4142, 0.38333333333333, 1.1, 0
4143, 0.38333333333333, 1.12, 0
4144, 0.38333333333333, 1.14, 0
4145, 0.38333333333333, 1.16, 0
4146, 0.38333333333333, 1.18, 0
4147, 0.4, 0.02, 0
4148, 0.4, 0.04, 0
4149, 0.4, 0.06, 0
4150, 0.4, 0.08, 0
4151, 0.4, 0.1, 0
4152, 0.4, 0.12, 0
4153, 0.4, 0.14, 0
4154, 0.4, 0.16, 0
4155, 0.4, 0.18, 0
4156, 0.4, 0.2, 0
4157, 0.4, 0.22, 0
4158, 0.4, 0.24, 0
4159, 0.4, 0.26, 0
4160, 0.4, 0.28, 0
4161, 0.4, 0.3, 0
4162, 0.4, 0.32, 0
4163, 0.4, 0.34, 0
4164, 0.4, 0.36, 0
4165, 0.4, 0.38, 0
4166, 0.4, 0.4, 0
4167, 0.4, 0.42, 0
4168, 0.4, 0.44, 0
4169, 0.4, 0.46, 0
4170, 0.4, 0.48, 0
4171, 0.4, 0.5, 0
4172, 0.4, 0.52, 0
4173, 0.4, 0.54, 0
4174, 0.4, 0.56, 0
4175, 0.4, 0.58, 0
4176, 0.4, 0.6, 0
4177, 0.4, 0.62, 0
4178, 0.4, 0.64, 0
4179, 0.4, 0.66, 0
4180, 0.4, 0.68, 0
4181, 0.4, 0.7, 0
4182, 0.4, 0.72, 0
4183, 0.4, 0.74, 0
4184, 0.4, 0.76, 0
4185, 0.4, 0.78, 0
4186, 0.4, 0.8, 0
4187, 0.4, 0.82, 0
4188, 0.4, 0.84, 0
4189, 0.4, 0.86, 0
4190, 0.4, 0.88, 0
4191, 0.4, 0.9, 0
4192, 0.4, 0.92, 0
4193, 0.4, 0.94, 0
4194, 0.4, 0.96, 0
4195, 0.4, 0.98, 0
4196, 0.4, 1, 0
4197, 0.4, 1.02, 0
4198, 0.4, 1.04, 0
4199, 0.4, 1.06, 0
4200, 0.4, 1.08, 0
4201, 0.4, 1.1, 0
4202, 0.4, 1.12, 0
4203, 0.4, 1.14, 0
4204, 0.4, 1.16, 0
4205, 0.4, 1.18, 0
4206, 0.41666666666667, 0.02, 0
4207, 0.41666666666667, 0.04, 0
4208, 0.41666666666667, 0.06, 0
4209, 0.41666666666667, 0.08, 0
4210, 0.41666666666667, 0.1, 0
4211, 0.41666666666667, 0.12, 0
4212, 0.41666666666667, 0.14, 0
4213, 0.41666666666667, 0.16, 0
4214, 0.41666666666667, 0.18, 0
4215, 0.41666666666667, 0.2, 0
4216, 0.41666666666667, 0.22, 0
4217, 0.41666666666667, 0.24, 0
4218, 0.41666666666667, 0.26, 0
4219, 0.41666666666667, 0.28, 0
4220, 0.41666666666667, 0.3, 0
4221, 0.41666666666667, 0.32, 0
4222, 0.41666666666667, 0.34, 0
4223, 0.41666666666667, 0.36, 0
4224, 0.41666666666667, 0.38, 0
4225, 0.41666666666667, 0.4, 0
4226, 0.41666666666667, 0.42, 0
4227, 0.41666666666667, 0.44, 0
4228, 0.41666666666667, 0.46, 0
4229, 0.41666666666667, 0.48, 0
4230, 0.41666666666667, 0.5, 0
4231, 0.41666666666667, 0.52, 0
4232, 0.41666666666667, 0.54, 0
4233, 0.41666666666667, 0.56, 0
4234, 0.41666666666667, 0.58, 0
4235, 0.41666666666667, 0.6, 0
4236, 0.41666666666667, 0.62, 0
4237, 0.41666666666667, 0.64, 0
4238, 0.41666666666667, 0.66, 0
4239, 0.41666666666667, 0.68, 0
4240, 0.41666666666667, 0.7, 0
4241, 0.41666666666667, 0.72, 0
4242, 0.41666666666667, 0.74, 0
4243, 0.41666666666667, 0.76, 0
4244, 0.41666666666667, 0.78, 0
4245, 0.41666666666667, 0.8, 0
4246, 0.41666666666667, 0.82, 0
4247, 0.41666666666667, 0.84, 0
4248, 0.41666666666667, 0.86, 0
4249, 0.41666666666667, 0.88, 0
4250, 0.41666666666667, 0.9, 0
4251, 0.41666666666667, 0.92, 0
4252, 0.41666666666667, 0.94, 0
4253, 0.41666666666667, 0.96, 0
4254, 0.41666666666667, 0.98, 0
4255, 0.41666666666667, 1, 0
4256, 0.41666666666667, 1.02, 0
4257, 0.41666666666667, 1.04, 0
4258, 0.41666666666667, 1.06, 0
4259, 0.41666666666667, 1.08, 0
4260, 0.41666666666667, 1.1, 0
4261, 0.41666666666667, 1.12, 0
4262, 0.41666666666667, 1.14, 0
4263, 0.41666666666667, 1.16, 0
4264, 0.41666666666667, 1.18, 0
4265, 0.43333333333333, 0.02, 0
4266, 0.43333333333333, 0.04, 0
4267, 0.43333333333333, 0.06, 0
4268, 0.43333333333333, 0.08, 0
4269, 0.43333333333333, 0.1, 0
4270, 0.43333333333333, 0.12, 0
4271, 0.43333333333333, 0.14, 0
4272, 0.43333333333333, 0.16, 0
4273, 0.43333333333333, 0.18, 0
4274, 0.43333333333333, 0.2, 0
4275, 0.43333333333333, 0.22, 0
4276, 0.43333333333333, 0.24, 0
4277, 0.43333333333333, 0.26, 0
4278, 0.43333333333333, 0.28, 0
4279, 0.43333333333333, 0.3, 0
4280, 0.43333333333333, 0.32, 0
4281, 0.43333333333333, 0.34, 0
4282, 0.43333333333333, 0.36, 0
4283, 0.43333333333333, 0.38, 0
4284, 0.43333333333333, 0.4, 0
4285, 0.43333333333333, 0.42, 0
4286, 0.43333333333333, 0.44, 0
4287, 0.43333333333333, 0.46, 0
4288, 0.43333333333333, 0.48, 0
4289, 0.43333333333333, 0.5, 0
4290, 0.43333333333333, 0.52, 0
4291, 0.43333333333333, 0.54, 0
4292, 0.43333333333333, 0.56, 0
4293, 0.43333333333333, 0.58, 0
4294, 0.43333333333333, 0.6, 0
4295, 0.43333333333333, 0.62, 0
4296, 0.43333333333333, 0.64, 0
4297, 0.43333333333333, 0.66, 0
4298, 0.43333333333333, 0.68, 0
4299, 0.43333333333333, 0.7, 0
4300, 0.43333333333333, 0.72, 0
4301, 0.43333333333333, 0.74, 0
4302, 0.43333333333333, 0.76, 0
4303, 0.43333333333333, 0.78, 0
4304, 0.43333333333333, 0.8, 0
4305, 0.43333333333333, 0.82, 0
4306, 0.43333333333333, 0.84, 0
4307, 0.43333333333333, 0.86, 0
4308, 0.43333333333333, 0.88, 0
4309, 0.43333333333333, 0.9, 0
4310, 0.43333333333333, 0.92, 0
4311, 0.43333333333333, 0.94, 0
4312, 0.43333333333333, 0.96, 0
4313, 0.43333333333333, 0.98, 0
4314, 0.43333333333333, 1, 0
4315, 0.43333333333333, 1.02, 0
4316, 0.43333333333333, 1.04, 0
4317, 0.43333333333333, 1.06, 0
4318, 0.43333333333333, 1.08, 0
4319, 0.43333333333333, 1.1, 0
4320, 0.43333333333333, 1.12, 0
4321, 0.43333333333333, 1.14, 0
4322, 0.43333333333333, 1.16, 0
4323, 0.43333333333333, 1.18, 0
4324, 0.45, 0.02, 0
4325, 0.45, 0.04, 0
4326, 0.45, 0.06, 0
4327, 0.45, 0.08, 0
4328, 0.45, 0.1, 0
4329, 0.45, 0.12, 0
4330, 0.45, 0.14, 0
4331, 0.45, 0.16, 0
4332, 0.45, 0.18, 0
4333, 0.45, 0.2, 0
4334, 0.45, 0.22, 0
4335, 0.45, 0.24, 0
4336, 0.45, 0.26, 0
4337, 0.45, 0.28, 0
4338, 0.45, 0.3, 0
4339, 0.45, 0.32, 0
4340, 0.45, 0.34, 0
4341, 0.45, 0.36, 0
4342, 0.45, 0.38, 0
4343, 0.45, 0.4, 0
4344, 0.45, 0.42, 0
4345, 0.45, 0.44, 0
4346, 0.45, 0.46, 0
4347, 0.45, 0.48, 0
4348, 0.45, 0.5, 0
4349, 0.45, 0.52, 0
4350, 0.45, 0.54, 0
4351, 0.45, 0.56, 0
4352, 0.45, 0.58, 0
4353, 0.45, 0.6, 0
4354, 0.45, 0.62, 0
4355, 0.45, 0.64, 0
4356, 0.45, 0.66, 0
4357, 0.45, 0.68, 0
4358, 0.45, 0.7, 0
4359, 0.45, 0.72, 0
4360, 0.45, 0.74, 0
4361, 0.45, 0.76, 0
4362, 0.45, 0.78, 0
4363, 0.45, 0.8, 0
4364, 0.45, 0.82, 0
4365, 0.45, 0.84, 0
4366, 0.45, 0.86, 0
4367, 0.45, 0.88, 0
4368, 0.45, 0.9, 0
4369, 0.45, 0.92, 0
4370, 0.45, 0.94, 0
4371, 0.45, 0.96, 0
4372, 0.45, 0.98, 0
4373, 0.45, 1, 0
4374, 0.45, 1.02, 0
4375, 0.45, 1.04, 0
4376, 0.45, 1.06, 0
4377, 0.45, 1.08, 0
4378, 0.45, 1.1, 0
4379, 0.45, 1.12, 0
4380, 0.45, 1.14, 0
4381, 0.45, 1.16, 0
4382, 0.45, 1.18, 0
4383, 0.46666666666667, 0.02, 0
4384, 0.46666666666667, 0.04, 0
4385, 0.46666666666667, 0.06, 0
4386, 0.46666666666667, 0.08, 0
4387, 0.46666666666667, 0.1, 0
4388, 0.46666666666667, 0.12, 0
4389, 0.46666666666667, 0.14, 0
4390, 0.46666666666667, 0.16, 0
4391, 0.46666666666667, 0.18, 0
4392, 0.46666666666667, 0.2, 0
4393, 0.46666666666667, 0.22, 0
4394, 0.46666666666667, 0.24, 0
4395, 0.46666666666667, 0.26, 0
4396, 0.46666666666667, 0.28, 0
4397, 0.46666666666667, 0.3, 0
4398, 0.46666666666667, 0.32, 0
4399, 0.46666666666667, 0.34, 0
4400, 0.46666666666667, 0.36, 0
4401, 0.46666666666667, 0.38, 0
4402, 0.46666666666667, 0.4, 0
4403, 0.46666666666667, 0.42, 0
4404, 0.46666666666667, 0.44, 0
4405, 0.46666666666667, 0.46, 0
4406, 0.46666666666667, 0.48, 0
4407, 0.46666666666667, 0.5, 0
4408, 0.46666666666667, 0.52, 0
4409, 0.46666666666667, 0.54, 0
4410, 0.46666666666667, 0.56, 0
4411, 0.46666666666667, 0.58, 0
4412, 0.46666666666667, 0.6, 0
4413, 0.46666666666667, 0.62, 0
4414, 0.46666666666667, 0.64, 0
4415, 0.46666666666667, 0.66, 0
4416, 0.46666666666667, 0.68, 0
4417, 0.46666666666667, 0.7, 0
4418, 0.46666666666667, 0.72, 0
4419, 0.46666666666667, 0.74, 0
4420, 0.46666666666667, 0.76, 0
4421, 0.46666666666667, 0.78, 0
4422, 0.46666666666667, 0.8, 0
4423, 0.46666666666667, 0.82, 0
4424, 0.46666666666667, 0.84, 0
4425, 0.46666666666667, 0.86, 0
4426, 0.46666666666667, 0.88, 0
4427, 0.46666666666667, 0.9, 0
4428, 0.46666666666667, 0.92, 0
4429, 0.46666666666667, 0.94, 0
4430, 0.46666666666667, 0.96, 0
4431, 0.46666666666667, 0.98, 0
4432, 0.46666666666667, 1, 0
4433, 0.46666666666667, 1.02, 0
4434, 0.46666666666667, 1.04, 0
4435, 0.46666666666667, 1.06, 0
4436, 0.46666666666667, 1.08, 0
4437, 0.46666666666667, 1.1, 0
4438, 0.46666666666667, 1.12, 0
4439, 0.46666666666667, 1.14, 0
4440, 0.46666666666667, 1.16, 0
4441, 0.46666666666667, 1.18, 0
4442, 0.48333333333333, 0.02, 0
4443, 0.48333333333333, 0.04, 0
4444, 0.48333333333333, 0.06, 0
4445, 0.48333333333333, 0.08, 0
4446, 0.48333333333333, 0.1, 0
4447, 0.48333333333333, 0.12, 0
4448, 0.48333333333333, 0.14, 0
4449, 0.48333333333333, 0.16, 0
4450, 0.48333333333333, 0.18, 0
4451, 0.48333333333333, 0.2, 0
4452, 0.48333333333333, 0.22, 0
4453, 0.48333333333333, 0.24, 0
4454, 0.48333333333333, 0.26, 0
4455, 0.48333333333333, 0.28, 0
4456, 0.48333333333333, 0.3, 0
4457, 0.48333333333333, 0.32, 0
4458, 0.48333333333333, 0.34, 0
4459, 0.48333333333333, 0.36, 0
4460, 0.48333333333333, 0.38, 0
4461, 0.48333333333333, 0.4, 0
4462, 0.48333333333333, 0.42, 0
4463, 0.48333333333333, 0.44, 0
4464, 0.48333333333333, 0.46, 0
4465, 0.48333333333333, 0.48, 0
4466, 0.48333333333333, 0.5, 0
4467, 0.48333333333333, 0.52, 0
4468, 0.48333333333333, 0.54, 0
4469, 0.48333333333333, 0.56, 0
4470, 0.48333333333333, 0.58, 0
4471, 0.48333333333333, 0.6, 0
4472, 0.48333333333333, 0.62, 0
4473, 0.48333333333333, 0.64, 0
4474, 0.48333333333333, 0.66, 0
4475, 0.48333333333333, 0.68, 0
4476, 0.48333333333333, 0.7, 0
4477, 0.48333333333333, 0.72, 0
4478, 0.48333333333333, 0.74, 0
4479, 0.48333333333333, 0.76, 0
4480, 0.48333333333333, 0.78, 0
4481, 0.48333333333333, 0.8, 0
4482, 0.48333333333333, 0.82, 0
4483, 0.48333333333333, 0.84, 0
4484, 0.48333333333333, 0.86, 0
4485, 0.48333333333333, 0.88, 0
4486, 0.48333333333333, 0.9, 0
4487, 0.48333333333333, 0.92, 0
4488, 0.48333333333333, 0.94, 0
4489, 0.48333333333333, 0.96, 0
4490, 0.48333333333333, 0.98, 0
4491, 0.48333333333333, 1, 0
4492, 0.48333333333333, 1.02, 0
4493, 0.48333333333333, 1.04, 0
4494, 0.48333333333333, 1.06, 0
4495, 0.48333333333333, 1.08, 0
4496, 0.48333333333333, 1.1, 0
4497, 0.48333333333333, 1.12, 0
4498, 0.48333333333333, 1.14, 0
4499, 0.48333333333333, 1.16, 0
4500, 0.48333333333333, 1.18, 0
4501, 0.5, 0.02, 0
4502, 0.5, 0.04, 0
4503, 0.5, 0.06, 0
4504, 0.5, 0.08, 0
4505, 0.5, 0.1, 0
4506, 0.5, 0.12, 0
4507, 0.5, 0.14, 0
4508, 0.5, 0.16, 0
4509, 0.5, 0.18, 0
4510, 0.5, 0.2, 0
4511, 0.5, 0.22, 0
4512, 0.5, 0.24, 0
4513, 0.5, 0.26, 0
4514, 0.5, 0.28, 0
4515, 0.5, 0.3, 0
4516, 0.5, 0.32, 0
4517, 0.5, 0.34, 0
4518, 0.5, 0.36, 0
4519, 0.5, 0.38, 0
4520, 0.5, 0.4, 0
4521, 0.5, 0.42, 0
4522, 0.5, 0.44, 0
4523, 0.5, 0.46, 0
4524, 0.5, 0.48, 0
4525, 0.5, 0.5, 0
4526, 0.5, 0.52, 0
4527, 0.5, 0.54, 0
4528, 0.5, 0.56, 0
4529, 0.5, 0.58, 0
4530, 0.5, 0.6, 0
4531, 0.5, 0.62, 0
4532, 0.5, 0.64, 0
4533, 0.5, 0.66, 0
4534, 0.5, 0.68, 0
4535, 0.5, 0.7, 0
4536, 0.5, 0.72, 0
4537, 0.5, 0.74, 0
4538, 0.5, 0.76, 0
4539, 0.5, 0.78, 0
4540, 0.5, 0.8, 0
4541, 0.5, 0.82, 0
4542, 0.5, 0.84, 0
4543, 0.5, 0.86, 0
4544, 0.5, 0.88, 0
4545, 0.5, 0.9, 0
4546, 0.5, 0.92, 0
4547, 0.5, 0.94, 0
4548, 0.5, 0.96, 0
4549, 0.5, 0.98, 0
4550, 0.5, 1, 0
4551, 0.5, 1.02, 0
4552, 0.5, 1.04, 0
4553, 0.5, 1.06, 0
4554, 0.5, 1.08, 0
4555, 0.5, 1.1, 0
4556, 0.5, 1.12, 0
4557, 0.5, 1.14, 0
4558, 0.5, 1.16, 0
4559, 0.5, 1.18, 0
4560, 0.51666666666667, 0.02, 0
4561, 0.51666666666667, 0.04, 0
4562, 0.51666666666667, 0.06, 0
4563, 0.51666666666667, 0.08, 0
4564, 0.51666666666667, 0.1, 0
4565, 0.51666666666667, 0.12, 0
4566, 0.51666666666667, 0.14, 0
4567, 0.51666666666667, 0.16, 0
4568, 0.51666666666667, 0.18, 0
4569, 0.51666666666667, 0.2, 0
4570, 0.51666666666667, 0.22, 0
4571, 0.51666666666667, 0.24, 0
4572, 0.51666666666667, 0.26, 0
4573, 0.51666666666667, 0.28, 0
4574, 0.51666666666667, 0.3, 0
4575, 0.51666666666667, 0.32, 0
4576, 0.51666666666667, 0.34, 0
4577, 0.51666666666667, 0.36, 0
4578, 0.51666666666667, 0.38, 0
4579, 0.51666666666667, 0.4, 0
4580, 0.51666666666667, 0.42, 0
4581, 0.51666666666667, 0.44, 0
4582, 0.51666666666667, 0.46, 0
4583, 0.51666666666667, 0.48, 0
4584, 0.51666666666667, 0.5, 0
4585, 0.51666666666667, 0.52, 0
4586, 0.51666666666667, 0.54, 0
4587, 0.51666666666667, 0.56, 0
4588, 0.51666666666667, 0.58, 0
4589, 0.51666666666667, 0.6, 0
4590, 0.51666666666667, 0.62, 0
4591, 0.51666666666667, 0.64, 0
4592, 0.51666666666667, 0.66, 0
4593, 0.51666666666667, 0.68, 0
4594, 0.51666666666667, 0.7, 0
4595, 0.51666666666667, 0.72, 0
4596, 0.51666666666667, 0.74, 0
4597, 0.51666666666667, 0.76, 0
4598, 0.51666666666667, 0.78, 0
4599, 0.51666666666667, 0.8, 0
4600, 0.51666666666667, 0.82, 0
4601, 0.51666666666667, 0.84, 0
4602, 0.51666666666667, 0.86, 0
4603, 0.51666666666667, 0.88, 0
4604, 0.51666666666667, 0.9, 0
4605, 0.51666666666667, 0.92, 0
4606, 0.51666666666667, 0.94, 0
4607, 0.51666666666667, 0.96, 0
4608, 0.51666666666667, 0.98, 0
4609, 0.51666666666667, 1, 0
4610, 0.51666666666667, 1.02, 0
4611, 0.51666666666667, 1.04, 0
4612, 0.51666666666667, 1.06, 0
4613, 0.51666666666667, 1.08, 0
4614, 0.51666666666667, 1.1, 0
4615, 0.51666666666667, 1.12, 0
4616, 0.51666666666667, 1.14, 0
4617, 0.51666666666667, 1.16, 0
4618, 0.51666666666667, 1.18, 0
4619, 0.53333333333333, 0.02, 0
4620, 0.53333333333333, 0.04, 0
4621, 0.53333333333333, 0.06, 0
4622, 0.53333333333333, 0.08, 0
4623, 0.53333333333333, 0.1, 0
4624, 0.53333333333333, 0.12, 0
4625, 0.53333333333333, 0.14, 0
4626, 0.53333333333333, 0.16, 0
4627, 0.53333333333333, 0.18, 0
4628, 0.53333333333333, 0.2, 0
4629, 0.53333333333333, 0.22, 0
4630, 0.53333333333333, 0.24, 0
4631, 0.53333333333333, 0.26, 0
4632, 0.53333333333333, 0.28, 0
4633, 0.53333333333333, 0.3, 0
4634, 0.53333333333333, 0.32, 0
4635, 0.53333333333333, 0.34, 0
4636, 0.53333333333333, 0.36, 0
4637, 0.53333333333333, 0.38, 0
4638, 0.53333333333333, 0.4, 0
4639, 0.53333333333333, 0.42, 0
4640, 0.53333333333333, 0.44, 0
4641, 0.53333333333333, 0.46, 0
4642, 0.53333333333333, 0.48, 0
4643, 0.53333333333333, 0.5, 0
4644, 0.53333333333333, 0.52, 0
4645, 0.53333333333333, 0.54, 0
4646, 0.53333333333333, 0.56, 0
4647, 0.53333333333333, 0.58, 0
4648, 0.53333333333333, 0.6, 0
4649, 0.53333333333333, 0.62, 0
4650, 0.53333333333333, 0.64, 0
4651, 0.53333333333333, 0.66, 0
4652, 0.53333333333333, 0.68, 0
4653, 0.53333333333333, 0.7, 0
4654, 0.53333333333333, 0.72, 0
4655, 0.53333333333333, 0.74, 0
4656, 0.53333333333333, 0.76, 0
4657, 0.53333333333333, 0.78, 0
4658, 0.53333333333333, 0.8, 0
4659, 0.53333333333333, 0.82, 0
4660, 0.53333333333333, 0.84, 0
4661, 0.53333333333333, 0.86, 0
4662, 0.53333333333333, 0.88, 0
4663, 0.53333333333333, 0.9, 0
4664, 0.53333333333333, 0.92, 0
4665, 0.53333333333333, 0.94, 0
4666, 0.53333333333333, 0.96, 0
4667, 0.53333333333333, 0.98, 0
4668, 0.53333333333333, 1, 0
4669, 0.53333333333333, 1.02, 0
4670, 0.53333333333333, 1.04, 0
4671, 0.53333333333333, 1.06, 0
4672, 0.53333333333333, 1.08, 0
4673, 0.53333333333333, 1.1, 0
4674, 0.53333333333333, 1.12, 0
4675, 0.53333333333333, 1.14, 0
4676, 0.53333333333333, 1.16, 0
4677, 0.53333333333333, 1.18, 0
4678, 0.55, 0.02, 0
4679, 0.55, 0.04, 0
4680, 0.55, 0.06, 0
4681, 0.55, 0.08, 0
4682, 0.55, 0.1, 0
4683, 0.55, 0.12, 0
4684, 0.55, 0.14, 0
4685, 0.55, 0.16, 0
4686, 0.55, 0.18, 0
4687, 0.55, 0.2, 0
4688, 0.55, 0.22, 0
4689, 0.55, 0.24, 0
4690, 0.55, 0.26, 0
4691, 0.55, 0.28, 0
4692, 0.55, 0.3, 0
4693, 0.55, 0.32, 0
4694, 0.55, 0.34, 0
4695, 0.55, 0.36, 0
4696, 0.55, 0.38, 0
4697, 0.55, 0.4, 0
4698, 0.55, 0.42, 0
4699, 0.55, 0.44, 0
4700, 0.55, 0.46, 0
4701, 0.55, 0.48, 0
4702, 0.55, 0.5, 0
4703, 0.55, 0.52, 0
4704, 0.55, 0.54, 0
4705, 0.55, 0.56, 0
4706, 0.55, 0.58, 0
4707, 0.55, 0.6, 0
4708, 0.55, 0.62, 0
4709, 0.55, 0.64, 0
4710, 0.55, 0.66, 0
4711, 0.55, 0.68, 0
4712, 0.55, 0.7, 0
4713, 0.55, 0.72, 0
4714, 0.55, 0.74, 0
4715, 0.55, 0.76, 0
4716, 0.55, 0.78, 0
4717, 0.55, 0.8, 0
4718, 0.55, 0.82, 0
4719, 0.55, 0.84, 0
4720, 0.55, 0.86, 0
4721, 0.55, 0.88, 0
4722, 0.55, 0.9, 0
4723, 0.55, 0.92, 0
4724, 0.55, 0.94, 0
4725, 0.55, 0.96, 0
4726, 0.55, 0.98, 0
4727, 0.55, 1, 0
4728, 0.55, 1.02, 0
4729, 0.55, 1.04, 0
4730, 0.55, 1.06, 0
4731, 0.55, 1.08, 0
4732, 0.55, 1.1, 0
4733, 0.55, 1.12, 0
4734, 0.55, 1.14, 0
4735, 0.55, 1.16, 0
4736, 0.55, 1.18, 0
4737, 0.56666666666667, 0.02, 0
4738, 0.56666666666667, 0.04, 0
4739, 0.56666666666667, 0.06, 0
4740, 0.56666666666667, 0.08, 0
4741, 0.56666666666667, 0.1, 0
4742, 0.56666666666667, 0.12, 0
4743, 0.56666666666667, 0.14, 0
4744, 0.56666666666667, 0.16, 0
4745, 0.56666666666667, 0.18, 0
4746, 0.56666666666667, 0.2, 0
4747, 0.56666666666667, 0.22, 0
4748, 0.56666666666667, 0.24, 0
4749, 0.56666666666667, 0.26, 0
4750, 0.56666666666667, 0.28, 0
4751, 0.56666666666667, 0.3, 0
4752, 0.56666666666667, 0.32, 0
4753, 0.56666666666667, 0.34, 0
4754, 0.56666666666667, 0.36, 0
4755, 0.56666666666667, 0.38, 0
4756, 0.56666666666667, 0.4, 0
4757, 0.56666666666667, 0.42, 0
4758, 0.56666666666667, 0.44, 0
4759, 0.56666666666667, 0.46, 0
4760, 0.56666666666667, 0.48, 0
4761, 0.56666666666667, 0.5, 0
4762, 0.56666666666667, 0.52, 0
4763, 0.56666666666667, 0.54, 0
4764, 0.56666666666667, 0.56, 0
4765, 0.56666666666667, 0.58, 0
4766, 0.56666666666667, 0.6, 0
4767, 0.56666666666667, 0.62, 0
4768, 0.56666666666667, 0.64, 0
4769, 0.56666666666667, 0.66, 0
4770, 0.56666666666667, 0.68, 0
4771, 0.56666666666667, 0.7, 0
4772, 0.56666666666667, 0.72, 0
4773, 0.56666666666667, 0.74, 0
4774, 0.56666666666667, 0.76, 0
4775, 0.56666666666667, 0.78, 0
4776, 0.56666666666667, 0.8, 0
4777, 0.56666666666667, 0.82, 0
4778, 0.56666666666667, 0.84, 0
4779, 0.56666666666667, 0.86, 0
4780, 0.56666666666667, 0.88, 0
4781, 0.56666666666667, 0.9, 0
4782, 0.56666666666667, 0.92, 0
4783, 0.56666666666667, 0.94, 0
4784, 0.56666666666667, 0.96, 0
4785, 0.56666666666667, 0.98, 0
4786, 0.56666666666667, 1, 0
4787, 0.56666666666667, 1.02, 0
4788, 0.56666666666667, 1.04, 0
4789, 0.56666666666667, 1.06, 0
4790, 0.56666666666667, 1.08, 0
4791, 0.56666666666667, 1.1, 0
4792, 0.56666666666667, 1.12, 0
4793, 0.56666666666667, 1.14, 0
4794, 0.56666666666667, 1.16, 0
4795, 0.56666666666667, 1.18, 0
4796, 0.58333333333333, 0.02, 0
4797, 0.58333333333333, 0.04, 0
4798, 0.58333333333333, 0.06, 0
4799, 0.58333333333333, 0.08, 0
4800, 0.58333333333333, 0.1, 0
4801, 0.58333333333333, 0.12, 0
4802, 0.58333333333333, 0.14, 0
4803, 0.58333333333333, 0.16, 0
4804, 0.58333333333333, 0.18, 0
4805, 0.58333333333333, 0.2, 0
4806, 0.58333333333333, 0.22, 0
4807, 0.58333333333333, 0.24, 0
4808, 0.58333333333333, 0.26, 0
4809, 0.58333333333333, 0.28, 0
4810, 0.58333333333333, 0.3, 0
4811, 0.58333333333333, 0.32, 0
4812, 0.58333333333333, 0.34, 0
4813, 0.58333333333333, 0.36, 0
4814, 0.58333333333333, 0.38, 0
4815, 0.58333333333333, 0.4, 0
4816, 0.58333333333333, 0.42, 0
4817, 0.58333333333333, 0.44, 0
4818, 0.58333333333333, 0.46, 0
4819, 0.58333333333333, 0.48, 0
4820, 0.58333333333333, 0.5, 0
4821, 0.58333333333333, 0.52, 0
4822, 0.58333333333333, 0.54, 0
4823, 0.58333333333333, 0.56, 0
4824, 0.58333333333333, 0.58, 0
4825, 0.58333333333333, 0.6, 0
4826, 0.58333333333333, 0.62, 0
4827, 0.58333333333333, 0.64, 0
4828, 0.58333333333333, 0.66, 0
4829, 0.58333333333333, 0.68, 0
4830, 0.58333333333333, 0.7, 0
4831, 0.58333333333333, 0.72, 0
4832, 0.58333333333333, 0.74, 0
4833, 0.58333333333333, 0.76, 0
4834, 0.58333333333333, 0.78, 0
4835, 0.58333333333333, 0.8, 0
4836, 0.58333333333333, 0.82, 0
4837, 0.58333333333333, 0.84, 0
4838, 0.58333333333333, 0.86, 0
4839, 0.58333333333333, 0.88, 0
4840, 0.58333333333333, 0.9, 0
4841, 0.58333333333333, 0.92, 0
4842, 0.58333333333333, 0.94, 0
4843, 0.58333333333333, 0.96, 0
4844, 0.58333333333333, 0.98, 0
4845, 0.58333333333333, 1, 0
4846, 0.58333333333333, 1.02, 0
4847, 0.58333333333333, 1.04, 0
4848, 0.58333333333333, 1.06, 0
4849, 0.58333333333333, 1.08, 0
4850, 0.58333333333333, 1.1, 0
4851, 0.58333333333333, 1.12, 0
4852, 0.58333333333333, 1.14, 0
4853, 0.58333333333333, 1.16, 0
4854, 0.58333333333333, 1.18, 0
4855, 0.6, 0.02, 0
4856, 0.6, 0.04, 0
4857, 0.6, 0.06, 0
4858, 0.6, 0.08, 0
4859, 0.6, 0.1, 0
4860, 0.6, 0.12, 0
4861, 0.6, 0.14, 0
4862, 0.6, 0.16, 0
4863, 0.6, 0.18, 0
4864, 0.6, 0.2, 0
4865, 0.6, 0.22, 0
4866, 0.6, 0.24, 0
4867, 0.6, 0.26, 0
4868, 0.6, 0.28, 0
4869, 0.6, 0.3, 0
4870, 0.6, 0.32, 0
4871, 0.6, 0.34, 0
4872, 0.6, 0.36, 0
4873, 0.6, 0.38, 0
4874, 0.6, 0.4, 0
4875, 0.6, 0.42, 0
4876, 0.6, 0.44, 0
4877, 0.6, 0.46, 0
4878, 0.6, 0.48, 0
4879, 0.6, 0.5, 0
4880, 0.6, 0.52, 0
4881, 0.6, 0.54, 0
4882, 0.6, 0.56, 0
4883, 0.6, 0.58, 0
4884, 0.6, 0.6, 0
4885, 0.6, 0.62, 0
4886, 0.6, 0.64, 0
4887, 0.6, 0.66, 0
4888, 0.6, 0.68, 0
4889, 0.6, 0.7, 0
4890, 0.6, 0.72, 0
4891, 0.6, 0.74, 0
4892, 0.6, 0.76, 0
4893, 0.6, 0.78, 0
4894, 0.6, 0.8, 0
4895, 0.6, 0.82, 0
4896, 0.6, 0.84, 0
4897, 0.6, 0.86, 0
4898, 0.6, 0.88, 0
4899, 0.6, 0.9, 0
4900, 0.6, 0.92, 0
4901, 0.6, 0.94, 0
4902, 0.6, 0.96, 0
4903, 0.6, 0.98, 0
4904, 0.6, 1, 0
4905, 0.6, 1.02, 0
4906, 0.6, 1.04, 0
4907, 0.6, 1.06, 0
4908, 0.6, 1.08, 0
4909, 0.6, 1.1, 0
4910, 0.6, 1.12, 0
4911, 0.6, 1.14, 0
4912, 0.6, 1.16, 0
4913, 0.6, 1.18, 0
4914, 0.61666666666667, 0.02, 0
4915, 0.61666666666667, 0.04, 0
4916, 0.61666666666667, 0.06, 0
4917, 0.61666666666667, 0.08, 0
4918, 0.61666666666667, 0.1, 0
4919, 0.61666666666667, 0.12, 0
4920, 0.61666666666667, 0.14, 0
4921, 0.61666666666667, 0.16, 0
4922, 0.61666666666667, 0.18, 0
4923, 0.61666666666667, 0.2, 0
4924, 0.61666666666667, 0.22, 0
4925, 0.61666666666667, 0.24, 0
4926, 0.61666666666667, 0.26, 0
4927, 0.61666666666667, 0.28, 0
4928, 0.61666666666667, 0.3, 0
4929, 0.61666666666667, 0.32, 0
4930, 0.61666666666667, 0.34, 0
4931, 0.61666666666667, 0.36, 0
4932, 0.61666666666667, 0.38, 0
4933, 0.61666666666667, 0.4, 0
4934, 0.61666666666667, 0.42, 0
4935, 0.61666666666667, 0.44, 0
4936, 0.61666666666667, 0.46, 0
4937, 0.61666666666667, 0.48, 0
4938, 0.61666666666667, 0.5, 0
4939, 0.61666666666667, 0.52, 0
4940, 0.61666666666667, 0.54, 0
4941, 0.61666666666667, 0.56, 0
4942, 0.61666666666667, 0.58, 0
4943, 0.61666666666667, 0.6, 0
4944, 0.61666666666667, 0.62, 0
4945, 0.61666666666667, 0.64, 0
4946, 0.61666666666667, 0.66, 0
4947, 0.61666666666667, 0.68, 0
4948, 0.61666666666667, 0.7, 0
4949, 0.61666666666667, 0.72, 0
4950, 0.61666666666667, 0.74, 0
4951, 0.61666666666667, 0.76, 0
4952, 0.61666666666667, 0.78, 0
4953, 0.61666666666667, 0.8, 0
4954, 0.61666666666667, 0.82, 0
4955, 0.61666666666667, 0.84, 0
4956, 0.61666666666667, 0.86, 0
4957, 0.61666666666667, 0.88, 0
4958, 0.61666666666667, 0.9, 0
4959, 0.61666666666667, 0.92, 0
4960, 0.61666666666667, 0.94, 0
4961, 0.61666666666667, 0.96, 0
4962, 0.61666666666667, 0.98, 0
4963, 0.61666666666667, 1, 0
4964, 0.61666666666667, 1.02, 0
4965, 0.61666666666667, 1.04, 0
4966, 0.61666666666667, 1.06, 0
4967, 0.61666666666667, 1.08, 0
4968, 0.61666666666667, 1.1, 0
4969, 0.61666666666667, 1.12, 0
4970, 0.61666666666667, 1.14, 0
4971, 0.61666666666667, 1.16, 0
4972, 0.61666666666667, 1.18, 0
4973, 0.63333333333333, 0.02, 0
4974, 0.63333333333333, 0.04, 0
4975, 0.63333333333333, 0.06, 0
4976, 0.63333333333333, 0.08, 0
4977, 0.63333333333333, 0.1, 0
4978, 0.63333333333333, 0.12, 0
4979, 0.63333333333333, 0.14, 0
4980, 0.63333333333333, 0.16, 0
4981, 0.63333333333333, 0.18, 0
4982, 0.63333333333333, 0.2, 0
4983, 0.63333333333333, 0.22, 0
4984, 0.63333333333333, 0.24, 0
4985, 0.63333333333333, 0.26, 0
4986, 0.63333333333333, 0.28, 0
4987, 0.63333333333333, 0.3, 0
4988, 0.63333333333333, 0.32, 0
4989, 0.63333333333333, 0.34, 0
4990, 0.63333333333333, 0.36, 0
4991, 0.63333333333333, 0.38, 0
4992, 0.63333333333333, 0.4, 0
4993, 0.63333333333333, 0.42, 0
4994, 0.63333333333333, 0.44, 0
4995, 0.63333333333333, 0.46, 0
4996, 0.63333333333333, 0.48, 0
4997, 0.63333333333333, 0.5, 0
4998, 0.63333333333333, 0.52, 0
4999, 0.63333333333333, 0.54, 0
5000, 0.63333333333333, 0.56, 0
5001, 0.63333333333333, 0.58, 0
5002, 0.63333333333333, 0.6, 0
5003, 0.63333333333333, 0.62, 0
5004, 0.63333333333333, 0.64, 0
5005, 0.63333333333333, 0.66, 0
5006, 0.63333333333333, 0.68, 0
5007, 0.63333333333333, 0.7, 0
5008, 0.63333333333333, 0.72, 0
5009, 0.63333333333333, 0.74, 0
5010, 0.63333333333333, 0.76, 0
5011, 0.63333333333333, 0.78, 0
5012, 0.63333333333333, 0.8, 0
5013, 0.63333333333333, 0.82, 0
5014, 0.63333333333333, 0.84, 0
5015, 0.63333333333333, 0.86, 0
5016, 0.63333333333333, 0.88, 0
5017, 0.63333333333333, 0.9, 0
5018, 0.63333333333333, 0.92, 0
5019, 0.63333333333333, 0.94, 0
5020, 0.63333333333333, 0.96, 0
5021, 0.63333333333333, 0.98, 0
5022, 0.63333333333333, 1, 0
5023, 0.63333333333333, 1.02, 0
5024, 0.63333333333333, 1.04, 0
5025, 0.63333333333333, 1.06, 0
5026, 0.63333333333333, 1.08, 0
5027, 0.63333333333333, 1.1, 0
5028, 0.63333333333333, 1.12, 0
5029, 0.63333333333333, 1.14, 0
5030, 0.63333333333333, 1.16, 0
5031, 0.63333333333333, 1.18, 0
5032, 0.65, 0.02, 0
5033, 0.65, 0.04, 0
5034, 0.65, 0.06, 0
5035, 0.65, 0.08, 0
5036, 0.65, 0.1, 0
5037, 0.65, 0.12, 0
5038, 0.65, 0.14, 0
5039, 0.65, 0.16, 0
5040, 0.65, 0.18, 0
5041, 0.65, 0.2, 0
5042, 0.65, 0.22, 0
5043, 0.65, 0.24, 0
5044, 0.65, 0.26, 0
5045, 0.65, 0.28, 0
5046, 0.65, 0.3, 0
5047, 0.65, 0.32, 0
5048, 0.65, 0.34, 0
5049, 0.65, 0.36, 0
5050, 0.65, 0.38, 0
5051, 0.65, 0.4, 0
5052, 0.65, 0.42, 0
5053, 0.65, 0.44, 0
5054, 0.65, 0.46, 0
5055, 0.65, 0.48, 0
5056, 0.65, 0.5, 0
5057, 0.65, 0.52, 0
5058, 0.65, 0.54, 0
5059, 0.65, 0.56, 0
5060, 0.65, 0.58, 0
5061, 0.65, 0.6, 0
5062, 0.65, 0.62, 0
5063, 0.65, 0.64, 0
5064, 0.65, 0.66, 0
5065, 0.65, 0.68, 0
5066, 0.65, 0.7, 0
5067, 0.65, 0.72, 0
5068, 0.65, 0.74, 0
5069, 0.65, 0.76, 0
5070, 0.65, 0.78, 0
5071, 0.65, 0.8, 0
5072, 0.65, 0.82, 0
5073, 0.65, 0.84, 0
5074, 0.65, 0.86, 0
5075, 0.65, 0.88, 0
5076, 0.65, 0.9, 0
5077, 0.65, 0.92, 0
5078, 0.65, 0.94, 0
5079, 0.65, 0.96, 0
5080, 0.65, 0.98, 0
5081, 0.65, 1, 0
5082, 0.65, 1.02, 0
5083, 0.65, 1.04, 0
5084, 0.65, 1.06, 0
5085, 0.65, 1.08, 0
5086, 0.65, 1.1, 0
5087, 0.65, 1.12, 0
5088, 0.65, 1.14, 0
5089, 0.65, 1.16, 0
5090, 0.65, 1.18, 0
5091, 0.66666666666667, 0.02, 0
5092, 0.66666666666667, 0.04, 0
5093, 0.66666666666667, 0.06, 0
5094, 0.66666666666667, 0.08, 0
5095, 0.66666666666667, 0.1, 0
5096, 0.66666666666667, 0.12, 0
5097, 0.66666666666667, 0.14, 0
5098, 0.66666666666667, 0.16, 0
5099, 0.66666666666667, 0.18, 0
5100, 0.66666666666667, 0.2, 0
5101, 0.66666666666667, 0.22, 0
5102, 0.66666666666667, 0.24, 0
5103, 0.66666666666667, 0.26, 0
5104, 0.66666666666667, 0.28, 0
5105, 0.66666666666667, 0.3, 0
5106, 0.66666666666667, 0.32, 0
5107, 0.66666666666667, 0.34, 0
5108, 0.66666666666667, 0.36, 0
5109, 0.66666666666667, 0.38, 0
5110, 0.66666666666667, 0.4, 0
5111, 0.66666666666667, 0.42, 0
5112, 0.66666666666667, 0.44, 0
5113, 0.66666666666667, 0.46, 0
5114, 0.66666666666667, 0.48, 0
5115, 0.66666666666667, 0.5, 0
5116, 0.66666666666667, 0.52, 0
5117, 0.66666666666667, 0.54, 0
5118, 0.66666666666667, 0.56, 0
5119, 0.66666666666667, 0.58, 0
5120, 0.66666666666667, 0.6, 0
5121, 0.66666666666667, 0.62, 0
5122, 0.66666666666667, 0.64, 0
5123, 0.66666666666667, 0.66, 0
5124, 0.66666666666667, 0.68, 0
5125, 0.66666666666667, 0.7, 0
5126, 0.66666666666667, 0.72, 0
5127, 0.66666666666667, 0.74, 0
5128, 0.66666666666667, 0.76, 0
5129, 0.66666666666667, 0.78, 0
5130, 0.66666666666667, 0.8, 0
5131, 0.66666666666667, 0.82, 0
5132, 0.66666666666667, 0.84, 0
5133, 0.66666666666667, 0.86, 0
5134, 0.66666666666667, 0.88, 0
5135, 0.66666666666667, 0.9, 0
5136, 0.66666666666667, 0.92, 0
5137, 0.66666666666667, 0.94, 0
5138, 0.66666666666667, 0.96, 0
5139, 0.66666666666667, 0.98, 0
5140, 0.66666666666667, 1, 0
5141, 0.66666666666667, 1.02, 0
5142, 0.66666666666667, 1.04, 0
5143, 0.66666666666667, 1.06, 0
5144, 0.66666666666667, 1.08, 0
5145, 0.66666666666667, 1.1, 0
5146, 0.66666666666667, 1.12, 0
5147, 0.66666666666667, 1.14, 0
5148, 0.66666666666667, 1.16, 0
5149, 0.66666666666667, 1.18, 0
5150, 0.68333333333333, 0.02, 0
5151, 0.68333333333333, 0.04, 0
5152, 0.68333333333333, 0.06, 0
5153, 0.68333333333333, 0.08, 0
5154, 0.68333333333333, 0.1, 0
5155, 0.68333333333333, 0.12, 0
5156, 0.68333333333333, 0.14, 0
5157, 0.68333333333333, 0.16, 0
5158, 0.68333333333333, 0.18, 0
5159, 0.68333333333333, 0.2, 0
5160, 0.68333333333333, 0.22, 0
5161, 0.68333333333333, 0.24, 0
5162, 0.68333333333333, 0.26, 0
5163, 0.68333333333333, 0.28, 0
5164, 0.68333333333333, 0.3, 0
5165, 0.68333333333333, 0.32, 0
5166, 0.68333333333333, 0.34, 0
5167, 0.68333333333333, 0.36, 0
5168, 0.68333333333333, 0.38, 0
5169, 0.68333333333333, 0.4, 0
5170, 0.68333333333333, 0.42, 0
5171, 0.68333333333333, 0.44, 0
5172, 0.68333333333333, 0.46, 0
5173, 0.68333333333333, 0.48, 0
5174, 0.68333333333333, 0.5, 0
5175, 0.68333333333333, 0.52, 0
5176, 0.68333333333333, 0.54, 0
5177, 0.68333333333333, 0.56, 0
5178, 0.68333333333333, 0.58, 0
5179, 0.68333333333333, 0.6, 0
5180, 0.68333333333333, 0.62, 0
5181, 0.68333333333333, 0.64, 0
5182, 0.68333333333333, 0.66, 0
5183, 0.68333333333333, 0.68, 0
5184, 0.68333333333333, 0.7, 0
5185, 0.68333333333333, 0.72, 0
5186, 0.68333333333333, 0.74, 0
5187, 0.68333333333333, 0.76, 0
5188, 0.68333333333333, 0.78, 0
5189, 0.68333333333333, 0.8, 0
5190, 0.68333333333333, 0.82, 0
5191, 0.68333333333333, 0.84, 0
5192, 0.68333333333333, 0.86, 0
5193, 0.68333333333333, 0.88, 0
5194, 0.68333333333333, 0.9, 0
5195, 0.68333333333333, 0.92, 0
5196, 0.68333333333333, 0.94, 0
5197, 0.68333333333333, 0.96, 0
5198, 0.68333333333333, 0.98, 0
5199, 0.68333333333333, 1, 0
5200, 0.68333333333333, 1.02, 0
5201, 0.68333333333333, 1.04, 0
5202, 0.68333333333333, 1.06, 0
5203, 0.68333333333333, 1.08, 0
5204, 0.68333333333333, 1.1, 0
5205, 0.68333333333333, 1.12, 0
5206, 0.68333333333333, 1.14, 0
5207, 0.68333333333333, 1.16, 0
5208, 0.68333333333333, 1.18, 0
5209, 0.7, 0.02, 0
5210, 0.7, 0.04, 0
5211, 0.7, 0.06, 0
5212, 0.7, 0.08, 0
5213, 0.7, 0.1, 0
5214, 0.7, 0.12, 0
5215, 0.7, 0.14, 0
5216, 0.7, 0.16, 0
5217, 0.7, 0.18, 0
5218, 0.7, 0.2, 0
5219, 0.7, 0.22, 0
5220, 0.7, 0.24, 0
5221, 0.7, 0.26, 0
5222, 0.7, 0.28, 0
5223, 0.7, 0.3, 0
5224, 0.7, 0.32, 0
5225, 0.7, 0.34, 0
5226, 0.7, 0.36, 0
5227, 0.7, 0.38, 0
5228, 0.7, 0.4, 0
5229, 0.7, 0.42, 0
5230, 0.7, 0.44, 0
5231, 0.7, 0.46, 0
5232, 0.7, 0.48, 0
5233, 0.7, 0.5, 0
5234, 0.7, 0.52, 0
5235, 0.7, 0.54, 0
5236, 0.7, 0.56, 0
5237, 0.7, 0.58, 0
5238, 0.7, 0.6, 0
5239, 0.7, 0.62, 0
5240, 0.7, 0.64, 0
5241, 0.7, 0.66, 0
5242, 0.7, 0.68, 0
5243, 0.7, 0.7, 0
5244, 0.7, 0.72, 0
5245, 0.7, 0.74, 0
5246, 0.7, 0.76, 0
5247, 0.7, 0.78, 0
5248, 0.7, 0.8, 0
5249, 0.7, 0.82, 0
5250, 0.7, 0.84, 0
5251, 0.7, 0.86, 0
5252, 0.7, 0.88, 0
5253, 0.7, 0.9, 0
5254, 0.7, 0.92, 0
5255, 0.7, 0.94, 0
5256, 0.7, 0.96, 0
5257, 0.7, 0.98, 0
5258, 0.7, 1, 0
5259, 0.7, 1.02, 0
5260, 0.7, 1.04, 0
5261, 0.7, 1.06, 0
5262, 0.7, 1.08, 0
5263, 0.7, 1.1, 0
5264, 0.7, 1.12, 0
5265, 0.7, 1.14, 0
5266, 0.7, 1.16, 0
5267, 0.7, 1.18, 0
5268, 0.71666666666667, 0.02, 0
5269, 0.71666666666667, 0.04, 0
5270, 0.71666666666667, 0.06, 0
5271, 0.71666666666667, 0.08, 0
5272, 0.71666666666667, 0.1, 0
5273, 0.71666666666667, 0.12, 0
5274, 0.71666666666667, 0.14, 0
5275, 0.71666666666667, 0.16, 0
5276, 0.71666666666667, 0.18, 0
5277, 0.71666666666667, 0.2, 0
5278, 0.71666666666667, 0.22, 0
5279, 0.71666666666667, 0.24, 0
5280, 0.71666666666667, 0.26, 0
5281, 0.71666666666667, 0.28, 0
5282, 0.71666666666667, 0.3, 0
5283, 0.71666666666667, 0.32, 0
5284, 0.71666666666667, 0.34, 0
5285, 0.71666666666667, 0.36, 0
5286, 0.71666666666667, 0.38, 0
5287, 0.71666666666667, 0.4, 0
5288, 0.71666666666667, 0.42, 0
5289, 0.71666666666667, 0.44, 0
5290, 0.71666666666667, 0.46, 0
5291, 0.71666666666667, 0.48, 0
5292, 0.71666666666667, 0.5, 0
5293, 0.71666666666667, 0.52, 0
5294, 0.71666666666667, 0.54, 0
5295, 0.71666666666667, 0.56, 0
5296, 0.71666666666667, 0.58, 0
5297, 0.71666666666667, 0.6, 0
5298, 0.71666666666667, 0.62, 0
5299, 0.71666666666667, 0.64, 0
5300, 0.71666666666667, 0.66, 0
5301, 0.71666666666667, 0.68, 0
5302, 0.71666666666667, 0.7, 0
5303, 0.71666666666667, 0.72, 0
5304, 0.71666666666667, 0.74, 0
5305, 0.71666666666667, 0.76, 0
5306, 0.71666666666667, 0.78, 0
5307, 0.71666666666667, 0.8, 0
5308, 0.71666666666667, 0.82, 0
5309, 0.71666666666667, 0.84, 0
5310, 0.71666666666667, 0.86, 0
5311, 0.71666666666667, 0.88, 0
5312, 0.71666666666667, 0.9, 0
5313, 0.71666666666667, 0.92, 0
5314, 0.71666666666667, 0.94, 0
5315, 0.71666666666667, 0.96, 0
5316, 0.71666666666667, 0.98, 0
5317, 0.71666666666667, 1, 0
5318, 0.71666666666667, 1.02, 0
5319, 0.71666666666667, 1.04, 0
5320, 0.71666666666667, 1.06, 0
5321, 0.71666666666667, 1.08, 0
5322, 0.71666666666667, 1.1, 0
5323, 0.71666666666667, 1.12, 0
5324, 0.71666666666667, 1.14, 0
5325, 0.71666666666667, 1.16, 0
5326, 0.71666666666667, 1.18, 0
5327, 0.73333333333333, 0.02, 0
5328, 0.73333333333333, 0.04, 0
5329, 0.73333333333333, 0.06, 0
5330, 0.73333333333333, 0.08, 0
5331, 0.73333333333333, 0.1, 0
5332, 0.73333333333333, 0.12, 0
5333, 0.73333333333333, 0.14, 0
5334, 0.73333333333333, 0.16, 0
5335, 0.73333333333333, 0.18, 0
5336, 0.73333333333333, 0.2, 0
5337, 0.73333333333333, 0.22, 0
5338, 0.73333333333333, 0.24, 0
5339, 0.73333333333333, 0.26, 0
5340, 0.73333333333333, 0.28, 0
5341, 0.73333333333333, 0.3, 0
5342, 0.73333333333333, 0.32, 0
5343, 0.73333333333333, 0.34, 0
5344, 0.73333333333333, 0.36, 0
5345, 0.73333333333333, 0.38, 0
5346, 0.73333333333333, 0.4, 0
5347, 0.73333333333333, 0.42, 0
5348, 0.73333333333333, 0.44, 0
5349, 0.73333333333333, 0.46, 0
5350, 0.73333333333333, 0.48, 0
5351, 0.73333333333333, 0.5, 0
5352, 0.73333333333333, 0.52, 0
5353, 0.73333333333333, 0.54, 0
5354, 0.73333333333333, 0.56, 0
5355, 0.73333333333333, 0.58, 0
5356, 0.73333333333333, 0.6, 0
5357, 0.73333333333333, 0.62, 0
5358, 0.73333333333333, 0.64, 0
5359, 0.73333333333333, 0.66, 0
5360, 0.73333333333333, 0.68, 0
5361, 0.73333333333333, 0.7, 0
5362, 0.73333333333333, 0.72, 0
5363, 0.73333333333333, 0.74, 0
5364, 0.73333333333333, 0.76, 0
5365, 0.73333333333333, 0.78, 0
5366, 0.73333333333333, 0.8, 0
5367, 0.73333333333333, 0.82, 0
5368, 0.73333333333333, 0.84, 0
5369, 0.73333333333333, 0.86, 0
5370, 0.73333333333333, 0.88, 0
5371, 0.73333333333333, 0.9, 0
5372, 0.73333333333333, 0.92, 0
5373, 0.73333333333333, 0.94, 0
5374, 0.73333333333333, 0.96, 0
5375, 0.73333333333333, 0.98, 0
5376, 0.73333333333333, 1, 0
5377, 0.73333333333333, 1.02, 0
5378, 0.73333333333333, 1.04, 0
5379, 0.73333333333333, 1.06, 0
5380, 0.73333333333333, 1.08, 0
5381, 0.73333333333333, 1.1, 0
5382, 0.73333333333333, 1.12, 0
5383, 0.73333333333333, 1.14, 0
5384, 0.73333333333333, 1.16, 0
5385, 0.73333333333333, 1.18, 0
5386, 0.75, 0.02, 0
5387, 0.75, 0.04, 0
5388, 0.75, 0.06, 0
5389, 0.75, 0.08, 0
5390, 0.75, 0.1, 0
5391, 0.75, 0.12, 0
5392, 0.75, 0.14, 0
5393, 0.75, 0.16, 0
5394, 0.75, 0.18, 0
5395, 0.75, 0.2, 0
5396, 0.75, 0.22, 0
5397, 0.75, 0.24, 0
5398, 0.75, 0.26, 0
5399, 0.75, 0.28, 0
5400, 0.75, 0.3, 0
5401, 0.75, 0.32, 0
5402, 0.75, 0.34, 0
5403, 0.75, 0.36, 0
5404, 0.75, 0.38, 0
5405, 0.75, 0.4, 0
5406, 0.75, 0.42, 0
5407, 0.75, 0.44, 0
5408, 0.75, 0.46, 0
5409, 0.75, 0.48, 0
5410, 0.75, 0.5, 0
5411, 0.75, 0.52, 0
5412, 0.75, 0.54, 0
5413, 0.75, 0.56, 0
5414, 0.75, 0.58, 0
5415, 0.75, 0.6, 0
5416, 0.75, 0.62, 0
5417, 0.75, 0.64, 0
5418, 0.75, 0.66, 0
5419, 0.75, 0.68, 0
5420, 0.75, 0.7, 0
5421, 0.75, 0.72, 0
5422, 0.75, 0.74, 0
5423, 0.75, 0.76, 0
5424, 0.75, 0.78, 0
5425, 0.75, 0.8, 0
5426, 0.75, 0.82, 0
5427, 0.75, 0.84, 0
5428, 0.75, 0.86, 0
5429, 0.75, 0.88, 0
5430, 0.75, 0.9, 0
5431, 0.75, 0.92, 0
5432, 0.75, 0.94, 0
5433, 0.75, 0.96, 0
5434, 0.75, 0.98, 0
5435, 0.75, 1, 0
5436, 0.75, 1.02, 0
5437, 0.75, 1.04, 0
5438, 0.75, 1.06, 0
5439, 0.75, 1.08, 0
5440, 0.75, 1.1, 0
5441, 0.75, 1.12, 0
5442, 0.75, 1.14, 0
5443, 0.75, 1.16, 0
5444, 0.75, 1.18, 0
5445, 0.76666666666667, 0.02, 0
5446, 0.76666666666667, 0.04, 0
5447, 0.76666666666667, 0.06, 0
5448, 0.76666666666667, 0.08, 0
5449, 0.76666666666667, 0.1, 0
5450, 0.76666666666667, 0.12, 0
5451, 0.76666666666667, 0.14, 0
5452, 0.76666666666667, 0.16, 0
5453, 0.76666666666667, 0.18, 0
5454, 0.76666666666667, 0.2, 0
5455, 0.76666666666667, 0.22, 0
5456, 0.76666666666667, 0.24, 0
5457, 0.76666666666667, 0.26, 0
5458, 0.76666666666667, 0.28, 0
5459, 0.76666666666667, 0.3, 0
5460, 0.76666666666667, 0.32, 0
5461, 0.76666666666667, 0.34, 0
5462, 0.76666666666667, 0.36, 0
5463, 0.76666666666667, 0.38, 0
5464, 0.76666666666667, 0.4, 0
5465, 0.76666666666667, 0.42, 0
5466, 0.76666666666667, 0.44, 0
5467, 0.76666666666667, 0.46, 0
5468, 0.76666666666667, 0.48, 0
5469, 0.76666666666667, 0.5, 0
5470, 0.76666666666667, 0.52, 0
5471, 0.76666666666667, 0.54, 0
5472, 0.76666666666667, 0.56, 0
5473, 0.76666666666667, 0.58, 0
5474, 0.76666666666667, 0.6, 0
5475, 0.76666666666667, 0.62, 0
5476, 0.76666666666667, 0.64, 0
5477, 0.76666666666667, 0.66, 0
5478, 0.76666666666667, 0.68, 0
5479, 0.76666666666667, 0.7, 0
5480, 0.76666666666667, 0.72, 0
5481, 0.76666666666667, 0.74, 0
5482, 0.76666666666667, 0.76, 0
5483, 0.76666666666667, 0.78, 0
5484, 0.76666666666667, 0.8, 0
5485, 0.76666666666667, 0.82, 0
5486, 0.76666666666667, 0.84, 0
5487, 0.76666666666667, 0.86, 0
5488, 0.76666666666667, 0.88, 0
5489, 0.76666666666667, 0.9, 0
5490, 0.76666666666667, 0.92, 0
5491, 0.76666666666667, 0.94, 0
5492, 0.76666666666667, 0.96, 0
5493, 0.76666666666667, 0.98, 0
5494, 0.76666666666667, 1, 0
5495, 0.76666666666667, 1.02, 0
5496, 0.76666666666667, 1.04, 0
5497, 0.76666666666667, 1.06, 0
5498, 0.76666666666667, 1.08, 0
5499, 0.76666666666667, 1.1, 0
5500, 0.76666666666667, 1.12, 0
5501, 0.76666666666667, 1.14, 0
5502, 0.76666666666667, 1.16, 0
5503, 0.76666666666667, 1.18, 0
5504, 0.78333333333333, 0.02, 0
5505, 0.78333333333333, 0.04, 0
5506, 0.78333333333333, 0.06, 0
5507, 0.78333333333333, 0.08, 0
5508, 0.78333333333333, 0.1, 0
5509, 0.78333333333333, 0.12, 0
5510, 0.78333333333333, 0.14, 0
5511, 0.78333333333333, 0.16, 0
5512, 0.78333333333333, 0.18, 0
5513, 0.78333333333333, 0.2, 0
5514, 0.78333333333333, 0.22, 0
5515, 0.78333333333333, 0.24, 0
5516, 0.78333333333333, 0.26, 0
5517, 0.78333333333333, 0.28, 0
5518, 0.78333333333333, 0.3, 0
5519, 0.78333333333333, 0.32, 0
5520, 0.78333333333333, 0.34, 0
5521, 0.78333333333333, 0.36, 0
5522, 0.78333333333333, 0.38, 0
5523, 0.78333333333333, 0.4, 0
5524, 0.78333333333333, 0.42, 0
5525, 0.78333333333333, 0.44, 0
5526, 0.78333333333333, 0.46, 0
5527, 0.78333333333333, 0.48, 0
5528, 0.78333333333333, 0.5, 0
5529, 0.78333333333333, 0.52, 0
5530, 0.78333333333333, 0.54, 0
5531, 0.78333333333333, 0.56, 0
5532, 0.78333333333333, 0.58, 0
5533, 0.78333333333333, 0.6, 0
5534, 0.78333333333333, 0.62, 0
5535, 0.78333333333333, 0.64, 0
5536, 0.78333333333333, 0.66, 0
5537, 0.78333333333333, 0.68, 0
5538, 0.78333333333333, 0.7, 0
5539, 0.78333333333333, 0.72, 0
5540, 0.78333333333333, 0.74, 0
5541, 0.78333333333333, 0.76, 0
5542, 0.78333333333333, 0.78, 0
5543, 0.78333333333333, 0.8, 0
5544, 0.78333333333333, 0.82, 0
5545, 0.78333333333333, 0.84, 0
5546, 0.78333333333333, 0.86, 0
5547, 0.78333333333333, 0.88, 0
5548, 0.78333333333333, 0.9, 0
5549, 0.78333333333333, 0.92, 0
5550, 0.78333333333333, 0.94, 0
5551, 0.78333333333333, 0.96, 0
5552, 0.78333333333333, 0.98, 0
5553, 0.78333333333333, 1, 0
5554, 0.78333333333333, 1.02, 0
5555, 0.78333333333333, 1.04, 0
5556, 0.78333333333333, 1.06, 0
5557, 0.78333333333333, 1.08, 0
5558, 0.78333333333333, 1.1, 0
5559, 0.78333333333333, 1.12, 0
5560, 0.78333333333333, 1.14, 0
5561, 0.78333333333333, 1.16, 0
5562, 0.78333333333333, 1.18, 0
5563, 0.8, 0.02, 0
5564, 0.8, 0.04, 0
5565, 0.8, 0.06, 0
5566, 0.8, 0.08, 0
5567, 0.8, 0.1, 0
5568, 0.8, 0.12, 0
5569, 0.8, 0.14, 0
5570, 0.8, 0.16, 0
5571, 0.8, 0.18, 0
5572, 0.8, 0.2, 0
5573, 0.8, 0.22, 0
5574, 0.8, 0.24, 0
5575, 0.8, 0.26, 0
5576, 0.8, 0.28, 0
5577, 0.8, 0.3, 0
5578, 0.8, 0.32, 0
5579, 0.8, 0.34, 0
5580, 0.8, 0.36, 0
5581, 0.8, 0.38, 0
5582, 0.8, 0.4, 0
5583, 0.8, 0.42, 0
5584, 0.8, 0.44, 0
5585, 0.8, 0.46, 0
5586, 0.8, 0.48, 0
5587, 0.8, 0.5, 0
5588, 0.8, 0.52, 0
5589, 0.8, 0.54, 0
5590, 0.8, 0.56, 0
5591, 0.8, 0.58, 0
5592, 0.8, 0.6, 0
5593, 0.8, 0.62, 0
5594, 0.8, 0.64, 0
5595, 0.8, 0.66, 0
5596, 0.8, 0.68, 0
5597, 0.8, 0.7, 0
5598, 0.8, 0.72, 0
5599, 0.8, 0.74, 0
5600, 0.8, 0.76, 0
5601, 0.8, 0.78, 0
5602, 0.8, 0.8, 0
5603, 0.8, 0.82, 0
5604, 0.8, 0.84, 0
5605, 0.8, 0.86, 0
5606, 0.8, 0.88, 0
5607, 0.8, 0.9, 0
5608, 0.8, 0.92, 0
5609, 0.8, 0.94, 0
5610, 0.8, 0.96, 0
5611, 0.8, 0.98, 0
5612, 0.8, 1, 0
5613, 0.8, 1.02, 0
5614, 0.8, 1.04, 0
5615, 0.8, 1.06, 0
5616, 0.8, 1.08, 0
5617, 0.8, 1.1, 0
5618, 0.8, 1.12, 0
5619, 0.8, 1.14, 0
5620, 0.8, 1.16, 0
5621, 0.8, 1.18, 0
5622, 0.81666666666667, 0.02, 0
5623, 0.81666666666667, 0.04, 0
5624, 0.81666666666667, 0.06, 0
5625, 0.81666666666667, 0.08, 0
5626, 0.81666666666667, 0.1, 0
5627, 0.81666666666667, 0.12, 0
5628, 0.81666666666667, 0.14, 0
5629, 0.81666666666667, 0.16, 0
5630, 0.81666666666667, 0.18, 0
5631, 0.81666666666667, 0.2, 0
5632, 0.81666666666667, 0.22, 0
5633, 0.81666666666667, 0.24, 0
5634, 0.81666666666667, 0.26, 0
5635, 0.81666666666667, 0.28, 0
5636, 0.81666666666667, 0.3, 0
5637, 0.81666666666667, 0.32, 0
5638, 0.81666666666667, 0.34, 0
5639, 0.81666666666667, 0.36, 0
5640, 0.81666666666667, 0.38, 0
5641, 0.81666666666667, 0.4, 0
5642, 0.81666666666667, 0.42, 0
5643, 0.81666666666667, 0.44, 0
5644, 0.81666666666667, 0.46, 0
5645, 0.81666666666667, 0.48, 0
5646, 0.81666666666667, 0.5, 0
5647, 0.81666666666667, 0.52, 0
5648, 0.81666666666667, 0.54, 0
5649, 0.81666666666667, 0.56, 0
5650, 0.81666666666667, 0.58, 0
5651, 0.81666666666667, 0.6, 0
5652, 0.81666666666667, 0.62, 0
5653, 0.81666666666667, 0.64, 0
5654, 0.81666666666667, 0.66, 0
5655, 0.81666666666667, 0.68, 0
5656, 0.81666666666667, 0.7, 0
5657, 0.81666666666667, 0.72, 0
5658, 0.81666666666667, 0.74, 0
5659, 0.81666666666667, 0.76, 0
5660, 0.81666666666667, 0.78, 0
5661, 0.81666666666667, 0.8, 0
5662, 0.81666666666667, 0.82, 0
5663, 0.81666666666667, 0.84, 0
5664, 0.81666666666667, 0.86, 0
5665, 0.81666666666667, 0.88, 0
5666, 0.81666666666667, 0.9, 0
5667, 0.81666666666667, 0.92, 0
5668, 0.81666666666667, 0.94, 0
5669, 0.81666666666667, 0.96, 0
5670, 0.81666666666667, 0.98, 0
5671, 0.81666666666667, 1, 0
5672, 0.81666666666667, 1.02, 0
5673, 0.81666666666667, 1.04, 0
5674, 0.81666666666667, 1.06, 0
5675, 0.81666666666667, 1.08, 0
5676, 0.81666666666667, 1.1, 0
5677, 0.81666666666667, 1.12, 0
5678, 0.81666666666667, 1.14, 0
5679, 0.81666666666667, 1.16, 0
5680, 0.81666666666667, 1.18, 0
5681, 0.83333333333333, 0.02, 0
5682, 0.83333333333333, 0.04, 0
5683, 0.83333333333333, 0.06, 0
5684, 0.83333333333333, 0.08, 0
5685, 0.83333333333333, 0.1, 0
5686, 0.83333333333333, 0.12, 0
5687, 0.83333333333333, 0.14, 0
5688, 0.83333333333333, 0.16, 0
5689, 0.83333333333333, 0.18, 0
5690, 0.83333333333333, 0.2, 0
5691, 0.83333333333333, 0.22, 0
5692, 0.83333333333333, 0.24, 0
5693, 0.83333333333333, 0.26, 0
5694, 0.83333333333333, 0.28, 0
5695, 0.83333333333333, 0.3, 0
5696, 0.83333333333333, 0.32, 0
5697, 0.83333333333333, 0.34, 0
5698, 0.83333333333333, 0.36, 0
5699, 0.83333333333333, 0.38, 0
5700, 0.83333333333333, 0.4, 0
5701, 0.83333333333333, 0.42, 0
5702, 0.83333333333333, 0.44, 0
5703, 0.83333333333333, 0.46, 0
5704, 0.83333333333333, 0.48, 0
5705, 0.83333333333333, 0.5, 0
5706, 0.83333333333333, 0.52, 0
5707, 0.83333333333333, 0.54, 0
5708, 0.83333333333333, 0.56, 0
5709, 0.83333333333333, 0.58, 0
5710, 0.83333333333333, 0.6, 0
5711, 0.83333333333333, 0.62, 0
5712, 0.83333333333333, 0.64, 0
5713, 0.83333333333333, 0.66, 0
5714, 0.83333333333333, 0.68, 0
5715, 0.83333333333333, 0.7, 0
5716, 0.83333333333333, 0.72, 0
5717, 0.83333333333333, 0.74, 0
5718, 0.83333333333333, 0.76, 0
5719, 0.83333333333333, 0.78, 0
5720, 0.83333333333333, 0.8, 0
5721, 0.83333333333333, 0.82, 0
5722, 0.83333333333333, 0.84, 0
5723, 0.83333333333333, 0.86, 0
5724, 0.83333333333333, 0.88, 0
5725, 0.83333333333333, 0.9, 0
5726, 0.83333333333333, 0.92, 0
5727, 0.83333333333333, 0.94, 0
5728, 0.83333333333333, 0.96, 0
5729, 0.83333333333333, 0.98, 0
5730, 0.83333333333333, 1, 0
5731, 0.83333333333333, 1.02, 0
5732, 0.83333333333333, 1.04, 0
5733, 0.83333333333333, 1.06, 0
5734, 0.83333333333333, 1.08, 0
5735, 0.83333333333333, 1.1, 0
5736, 0.83333333333333, 1.12, 0
5737, 0.83333333333333, 1.14, 0
5738, 0.83333333333333, 1.16, 0
5739, 0.83333333333333, 1.18, 0
5740, 0.85, 0.02, 0
5741, 0.85, 0.04, 0
5742, 0.85, 0.06, 0
5743, 0.85, 0.08, 0
5744, 0.85, 0.1, 0
5745, 0.85, 0.12, 0
5746, 0.85, 0.14, 0
5747, 0.85, 0.16, 0
5748, 0.85, 0.18, 0
5749, 0.85, 0.2, 0
5750, 0.85, 0.22, 0
5751, 0.85, 0.24, 0
5752, 0.85, 0.26, 0
5753, 0.85, 0.28, 0
5754, 0.85, 0.3, 0
5755, 0.85, 0.32, 0
5756, 0.85, 0.34, 0
5757, 0.85, 0.36, 0
5758, 0.85, 0.38, 0
5759, 0.85, 0.4, 0
5760, 0.85, 0.42, 0
5761, 0.85, 0.44, 0
5762, 0.85, 0.46, 0
5763, 0.85, 0.48, 0
5764, 0.85, 0.5, 0
5765, 0.85, 0.52, 0
5766, 0.85, 0.54, 0
5767, 0.85, 0.56, 0
5768, 0.85, 0.58, 0
5769, 0.85, 0.6, 0
5770, 0.85, 0.62, 0
5771, 0.85, 0.64, 0
5772, 0.85, 0.66, 0
5773, 0.85, 0.68, 0
5774, 0.85, 0.7, 0
5775, 0.85, 0.72, 0
5776, 0.85, 0.74, 0
5777, 0.85, 0.76, 0
5778, 0.85, 0.78, 0
5779, 0.85, 0.8, 0
5780, 0.85, 0.82, 0
5781, 0.85, 0.84, 0
5782, 0.85, 0.86, 0
5783, 0.85, 0.88, 0
5784, 0.85, 0.9, 0
5785, 0.85, 0.92, 0
5786, 0.85, 0.94, 0
5787, 0.85, 0.96, 0
5788, 0.85, 0.98, 0
5789, 0.85, 1, 0
5790, 0.85, 1.02, 0
5791, 0.85, 1.04, 0
5792, 0.85, 1.06, 0
5793, 0.85, 1.08, 0
5794, 0.85, 1.1, 0
5795, 0.85, 1.12, 0
5796, 0.85, 1.14, 0
5797, 0.85, 1.16, 0
5798, 0.85, 1.18, 0
5799, 0.86666666666667, 0.02, 0
5800, 0.86666666666667, 0.04, 0
5801, 0.86666666666667, 0.06, 0
5802, 0.86666666666667, 0.08, 0
5803, 0.86666666666667, 0.1, 0
5804, 0.86666666666667, 0.12, 0
5805, 0.86666666666667, 0.14, 0
5806, 0.86666666666667, 0.16, 0
5807, 0.86666666666667, 0.18, 0
5808, 0.86666666666667, 0.2, 0
5809, 0.86666666666667, 0.22, 0
5810, 0.86666666666667, 0.24, 0
5811, 0.86666666666667, 0.26, 0
5812, 0.86666666666667, 0.28, 0
5813, 0.86666666666667, 0.3, 0
5814, 0.86666666666667, 0.32, 0
5815, 0.86666666666667, 0.34, 0
5816, 0.86666666666667, 0.36, 0
5817, 0.86666666666667, 0.38, 0
5818, 0.86666666666667, 0.4, 0
5819, 0.86666666666667, 0.42, 0
5820, 0.86666666666667, 0.44, 0
5821, 0.86666666666667, 0.46, 0
5822, 0.86666666666667, 0.48, 0
5823, 0.86666666666667, 0.5, 0
5824, 0.86666666666667, 0.52, 0
5825, 0.86666666666667, 0.54, 0
5826, 0.86666666666667, 0.56, 0
5827, 0.86666666666667, 0.58, 0
5828, 0.86666666666667, 0.6, 0
5829, 0.86666666666667, 0.62, 0
5830, 0.86666666666667, 0.64, 0
5831, 0.86666666666667, 0.66, 0
5832, 0.86666666666667, 0.68, 0
5833, 0.86666666666667, 0.7, 0
5834, 0.86666666666667, 0.72, 0
5835, 0.86666666666667, 0.74, 0
5836, 0.86666666666667, 0.76, 0
5837, 0.86666666666667, 0.78, 0
5838, 0.86666666666667, 0.8, 0
5839, 0.86666666666667, 0.82, 0
5840, 0.86666666666667, 0.84, 0
5841, 0.86666666666667, 0.86, 0
5842, 0.86666666666667, 0.88, 0
5843, 0.86666666666667, 0.9, 0
5844, 0.86666666666667, 0.92, 0
5845, 0.86666666666667, 0.94, 0
5846, 0.86666666666667, 0.96, 0
5847, 0.86666666666667, 0.98, 0
5848, 0.86666666666667, 1, 0
5849, 0.86666666666667, 1.02, 0
5850, 0.86666666666667, 1.04, 0
5851, 0.86666666666667, 1.06, 0
5852, 0.86666666666667, 1.08, 0
5853, 0.86666666666667, 1.1, 0
5854, 0.86666666666667, 1.12, 0
5855, 0.86666666666667, 1.14, 0
5856, 0.86666666666667, 1.16, 0
5857, 0.86666666666667, 1.18, 0
5858, 0.88333333333333, 0.02, 0
5859, 0.88333333333333, 0.04, 0
5860, 0.88333333333333, 0.06, 0
5861, 0.88333333333333, 0.08, 0
5862, 0.88333333333333, 0.1, 0
5863, 0.88333333333333, 0.12, 0
5864, 0.88333333333333, 0.14, 0
5865, 0.88333333333333, 0.16, 0
5866, 0.88333333333333, 0.18, 0
5867, 0.88333333333333, 0.2, 0
5868, 0.88333333333333, 0.22, 0
5869, 0.88333333333333, 0.24, 0
5870, 0.88333333333333, 0.26, 0
5871, 0.88333333333333, 0.28, 0
5872, 0.88333333333333, 0.3, 0
5873, 0.88333333333333, 0.32, 0
5874, 0.88333333333333, 0.34, 0
5875, 0.88333333333333, 0.36, 0
5876, 0.88333333333333, 0.38, 0
5877, 0.88333333333333, 0.4, 0
5878, 0.88333333333333, 0.42, 0
5879, 0.88333333333333, 0.44, 0
5880, 0.88333333333333, 0.46, 0
5881, 0.88333333333333, 0.48, 0
5882, 0.88333333333333, 0.5, 0
5883, 0.88333333333333, 0.52, 0
5884, 0.88333333333333, 0.54, 0
5885, 0.88333333333333, 0.56, 0
5886, 0.88333333333333, 0.58, 0
5887, 0.88333333333333, 0.6, 0
5888, 0.88333333333333, 0.62, 0
5889, 0.88333333333333, 0.64, 0
5890, 0.88333333333333, 0.66, 0
5891, 0.88333333333333, 0.68, 0
5892, 0.88333333333333, 0.7, 0
5893, 0.88333333333333, 0.72, 0
5894, 0.88333333333333, 0.74, 0
5895, 0.88333333333333, 0.76, 0
5896, 0.88333333333333, 0.78, 0
5897, 0.88333333333333, 0.8, 0
5898, 0.88333333333333, 0.82, 0
5899, 0.88333333333333, 0.84, 0
5900, 0.88333333333333, 0.86, 0
5901, 0.88333333333333, 0.88, 0
5902, 0.88333333333333, 0.9, 0
5903, 0.88333333333333, 0.92, 0
5904, 0.88333333333333, 0.94, 0
5905, 0.88333333333333, 0.96, 0
5906, 0.88333333333333, 0.98, 0
5907, 0.88333333333333, 1, 0
5908, 0.88333333333333, 1.02, 0
5909, 0.88333333333333, 1.04, 0
5910, 0.88333333333333, 1.06, 0
5911, 0.88333333333333, 1.08, 0
5912, 0.88333333333333, 1.1, 0
5913, 0.88333333333333, 1.12, 0
5914, 0.88333333333333, 1.14, 0
5915, 0.88333333333333, 1.16, 0
5916, 0.88333333333333, 1.18, 0
5917, 0.9, 0.02, 0
5918, 0.9, 0.04, 0
5919, 0.9, 0.06, 0
5920, 0.9, 0.08, 0
5921, 0.9, 0.1, 0
5922, 0.9, 0.12, 0
5923, 0.9, 0.14, 0
5924, 0.9, 0.16, 0
5925, 0.9, 0.18, 0
5926, 0.9, 0.2, 0
5927, 0.9, 0.22, 0
5928, 0.9, 0.24, 0
5929, 0.9, 0.26, 0
5930, 0.9, 0.28, 0
5931, 0.9, 0.3, 0
5932, 0.9, 0.32, 0
5933, 0.9, 0.34, 0
5934, 0.9, 0.36, 0
5935, 0.9, 0.38, 0
5936, 0.9, 0.4, 0
5937, 0.9, 0.42, 0
5938, 0.9, 0.44, 0
5939, 0.9, 0.46, 0
5940, 0.9, 0.48, 0
5941, 0.9, 0.5, 0
5942, 0.9, 0.52, 0
5943, 0.9, 0.54, 0
5944, 0.9, 0.56, 0
5945, 0.9, 0.58, 0
5946, 0.9, 0.6, 0
5947, 0.9, 0.62, 0
5948, 0.9, 0.64, 0
5949, 0.9, 0.66, 0
5950, 0.9, 0.68, 0
5951, 0.9, 0.7, 0
5952, 0.9, 0.72, 0
5953, 0.9, 0.74, 0
5954, 0.9, 0.76, 0
5955, 0.9, 0.78, 0
5956, 0.9, 0.8, 0
5957, 0.9, 0.82, 0
5958, 0.9, 0.84, 0
5959, 0.9, 0.86, 0
5960, 0.9, 0.88, 0
5961, 0.9, 0.9, 0
5962, 0.9, 0.92, 0
5963, 0.9, 0.94, 0
5964, 0.9, 0.96, 0
5965, 0.9, 0.98, 0
5966, 0.9, 1, 0
5967, 0.9, 1.02, 0
5968, 0.9, 1.04, 0
5969, 0.9, 1.06, 0
5970, 0.9, 1.08, 0
5971, 0.9, 1.1, 0
5972, 0.9, 1.12, 0
5973, 0.9, 1.14, 0
5974, 0.9, 1.16, 0
5975, 0.9, 1.18, 0
5976, 0.91666666666667, 0.02, 0
5977, 0.91666666666667, 0.04, 0
5978, 0.91666666666667, 0.06, 0
5979, 0.91666666666667, 0.08, 0
5980, 0.91666666666667, 0.1, 0
5981, 0.91666666666667, 0.12, 0
5982, 0.91666666666667, 0.14, 0
5983, 0.91666666666667, 0.16, 0
5984, 0.91666666666667, 0.18, 0
5985, 0.91666666666667, 0.2, 0
5986, 0.91666666666667, 0.22, 0
5987, 0.91666666666667, 0.24, 0
5988, 0.91666666666667, 0.26, 0
5989, 0.91666666666667, 0.28, 0
5990, 0.91666666666667, 0.3, 0
5991, 0.91666666666667, 0.32, 0
5992, 0.91666666666667, 0.34, 0
5993, 0.91666666666667, 0.36, 0
5994, 0.91666666666667, 0.38, 0
5995, 0.91666666666667, 0.4, 0
5996, 0.91666666666667, 0.42, 0
5997, 0.91666666666667, 0.44, 0
5998, 0.91666666666667, 0.46, 0
5999, 0.91666666666667, 0.48, 0
6000, 0.91666666666667, 0.5, 0
6001, 0.91666666666667, 0.52, 0
6002, 0.91666666666667, 0.54, 0
6003, 0.91666666666667, 0.56, 0
6004, 0.91666666666667, 0.58, 0
6005, 0.91666666666667, 0.6, 0
6006, 0.91666666666667, 0.62, 0
6007, 0.91666666666667, 0.64, 0
6008, 0.91666666666667, 0.66, 0
6009, 0.91666666666667, 0.68, 0
6010, 0.91666666666667, 0.7, 0
6011, 0.91666666666667, 0.72, 0
6012, 0.91666666666667, 0.74, 0
6013, 0.91666666666667, 0.76, 0
6014, 0.91666666666667, 0.78, 0
6015, 0.91666666666667, 0.8, 0
6016, 0.91666666666667, 0.82, 0
6017, 0.91666666666667, 0.84, 0
6018, 0.91666666666667, 0.86, 0
6019, 0.91666666666667, 0.88, 0
6020, 0.91666666666667, 0.9, 0
6021, 0.91666666666667, 0.92, 0
6022, 0.91666666666667, 0.94, 0
6023, 0.91666666666667, 0.96, 0
6024, 0.91666666666667, 0.98, 0
6025, 0.91666666666667, 1, 0
6026, 0.91666666666667, 1.02, 0
6027, 0.91666666666667, 1.04, 0
6028, 0.91666666666667, 1.06, 0
6029, 0.91666666666667, 1.08, 0
6030, 0.91666666666667, 1.1, 0
6031, 0.91666666666667, 1.12, 0
6032, 0.91666666666667, 1.14, 0
6033, 0.91666666666667, 1.16, 0
6034, 0.91666666666667, 1.18, 0
6035, 0.93333333333333, 0.02, 0
6036, 0.93333333333333, 0.04, 0
6037, 0.93333333333333, 0.06, 0
6038, 0.93333333333333, 0.08, 0
6039, 0.93333333333333, 0.1, 0
6040, 0.93333333333333, 0.12, 0
6041, 0.93333333333333, 0.14, 0
6042, 0.93333333333333, 0.16, 0
6043, 0.93333333333333, 0.18, 0
6044, 0.93333333333333, 0.2, 0
6045, 0.93333333333333, 0.22, 0
6046, 0.93333333333333, 0.24, 0
6047, 0.93333333333333, 0.26, 0
6048, 0.93333333333333, 0.28, 0
6049, 0.93333333333333, 0.3, 0
6050, 0.93333333333333, 0.32, 0
6051, 0.93333333333333, 0.34, 0
6052, 0.93333333333333, 0.36, 0
6053, 0.93333333333333, 0.38, 0
6054, 0.93333333333333, 0.4, 0
6055, 0.93333333333333, 0.42, 0
6056, 0.93333333333333, 0.44, 0
6057, 0.93333333333333, 0.46, 0
6058, 0.93333333333333, 0.48, 0
6059, 0.93333333333333, 0.5, 0
6060, 0.93333333333333, 0.52, 0
6061, 0.93333333333333, 0.54, 0
6062, 0.93333333333333, 0.56, 0
6063, 0.93333333333333, 0.58, 0
6064, 0.93333333333333, 0.6, 0
6065, 0.93333333333333, 0.62, 0
6066, 0.93333333333333, 0.64, 0
6067, 0.93333333333333, 0.66, 0
6068, 0.93333333333333, 0.68, 0
6069, 0.93333333333333, 0.7, 0
6070, 0.93333333333333, 0.72, 0
6071, 0.93333333333333, 0.74, 0
6072, 0.93333333333333, 0.76, 0
6073, 0.93333333333333, 0.78, 0
6074, 0.93333333333333, 0.8, 0
6075, 0.93333333333333, 0.82, 0
6076, 0.93333333333333, 0.84, 0
6077, 0.93333333333333, 0.86, 0
6078, 0.93333333333333, 0.88, 0
6079, 0.93333333333333, 0.9, 0
6080, 0.93333333333333, 0.92, 0
6081, 0.93333333333333, 0.94, 0
6082, 0.93333333333333, 0.96, 0
6083, 0.93333333333333, 0.98, 0
6084, 0.93333333333333, 1, 0
6085, 0.93333333333333, 1.02, 0
6086, 0.93333333333333, 1.04, 0
6087, 0.93333333333333, 1.06, 0
6088, 0.93333333333333, 1.08, 0
6089, 0.93333333333333, 1.1, 0
6090, 0.93333333333333, 1.12, 0
6091, 0.93333333333333, 1.14, 0
6092, 0.93333333333333, 1.16, 0
6093, 0.93333333333333, 1.18, 0
6094, 0.95, 0.02, 0
6095, 0.95, 0.04, 0
6096, 0.95, 0.06, 0
6097, 0.95, 0.08, 0
6098, 0.95, 0.1, 0
6099, 0.95, 0.12, 0
6100, 0.95, 0.14, 0
6101, 0.95, 0.16, 0
6102, 0.95, 0.18, 0
6103, 0.95, 0.2, 0
6104, 0.95, 0.22, 0
6105, 0.95, 0.24, 0
6106, 0.95, 0.26, 0
6107, 0.95, 0.28, 0
6108, 0.95, 0.3, 0
6109, 0.95, 0.32, 0
6110, 0.95, 0.34, 0
6111, 0.95, 0.36, 0
6112, 0.95, 0.38, 0
6113, 0.95, 0.4, 0
6114, 0.95, 0.42, 0
6115, 0.95, 0.44, 0
6116, 0.95, 0.46, 0
6117, 0.95, 0.48, 0
6118, 0.95, 0.5, 0
6119, 0.95, 0.52, 0
6120, 0.95, 0.54, 0
6121, 0.95, 0.56, 0
6122, 0.95, 0.58, 0
6123, 0.95, 0.6, 0
6124, 0.95, 0.62, 0
6125, 0.95, 0.64, 0
6126, 0.95, 0.66, 0
6127, 0.95, 0.68, 0
6128, 0.95, 0.7, 0
6129, 0.95, 0.72, 0
6130, 0.95, 0.74, 0
6131, 0.95, 0.76, 0
6132, 0.95, 0.78, 0
6133, 0.95, 0.8, 0
6134, 0.95, 0.82, 0
6135, 0.95, 0.84, 0
6136, 0.95, 0.86, 0
6137, 0.95, 0.88, 0
6138, 0.95, 0.9, 0
6139, 0.95, 0.92, 0
6140, 0.95, 0.94, 0
6141, 0.95, 0.96, 0
6142, 0.95, 0.98, 0
6143, 0.95, 1, 0
6144, 0.95, 1.02, 0
6145, 0.95, 1.04, 0
6146, 0.95, 1.06, 0
6147, 0.95, 1.08, 0
6148, 0.95, 1.1, 0
6149, 0.95, 1.12, 0
6150, 0.95, 1.14, 0
6151, 0.95, 1.16, 0
6152, 0.95, 1.18, 0
6153, 0.96666666666667, 0.02, 0
6154, 0.96666666666667, 0.04, 0
6155, 0.96666666666667, 0.06, 0
6156, 0.96666666666667, 0.08, 0
6157, 0.96666666666667, 0.1, 0
6158, 0.96666666666667, 0.12, 0
6159, 0.96666666666667, 0.14, 0
6160, 0.96666666666667, 0.16, 0
6161, 0.96666666666667, 0.18, 0
6162, 0.96666666666667, 0.2, 0
6163, 0.96666666666667, 0.22, 0
6164, 0.96666666666667, 0.24, 0
6165, 0.96666666666667, 0.26, 0
6166, 0.96666666666667, 0.28, 0
6167, 0.96666666666667, 0.3, 0
6168, 0.96666666666667, 0.32, 0
6169, 0.96666666666667, 0.34, 0
6170, 0.96666666666667, 0.36, 0
6171, 0.96666666666667, 0.38, 0
6172, 0.96666666666667, 0.4, 0
6173, 0.96666666666667, 0.42, 0
6174, 0.96666666666667, 0.44, 0
6175, 0.96666666666667, 0.46, 0
6176, 0.96666666666667, 0.48, 0
6177, 0.96666666666667, 0.5, 0
6178, 0.96666666666667, 0.52, 0
6179, 0.96666666666667, 0.54, 0
6180, 0.96666666666667, 0.56, 0
6181, 0.96666666666667, 0.58, 0
6182, 0.96666666666667, 0.6, 0
6183, 0.96666666666667, 0.62, 0
6184, 0.96666666666667, 0.64, 0
6185, 0.96666666666667, 0.66, 0
6186, 0.96666666666667, 0.68, 0
6187, 0.96666666666667, 0.7, 0
6188, 0.96666666666667, 0.72, 0
6189, 0.96666666666667, 0.74, 0
6190, 0.96666666666667, 0.76, 0
6191, 0.96666666666667, 0.78, 0
6192, 0.96666666666667, 0.8, 0
6193, 0.96666666666667, 0.82, 0
6194, 0.96666666666667, 0.84, 0
6195, 0.96666666666667, 0.86, 0
6196, 0.96666666666667, 0.88, 0
6197, 0.96666666666667, 0.9, 0
6198, 0.96666666666667, 0.92, 0
6199, 0.96666666666667, 0.94, 0
6200, 0.96666666666667, 0.96, 0
6201, 0.96666666666667, 0.98, 0
6202, 0.96666666666667, 1, 0
6203, 0.96666666666667, 1.02, 0
6204, 0.96666666666667, 1.04, 0
6205, 0.96666666666667, 1.06, 0
6206, 0.96666666666667, 1.08, 0
6207, 0.96666666666667, 1.1, 0
6208, 0.96666666666667, 1.12, 0
6209, 0.96666666666667, 1.14, 0
6210, 0.96666666666667, 1.16, 0
6211, 0.96666666666667, 1.18, 0
6212, 0.98333333333333, 0.02, 0
6213, 0.98333333333333, 0.04, 0
6214, 0.98333333333333, 0.06, 0
6215, 0.98333333333333, 0.08, 0
6216, 0.98333333333333, 0.1, 0
6217, 0.98333333333333, 0.12, 0
6218, 0.98333333333333, 0.14, 0
6219, 0.98333333333333, 0.16, 0
6220, 0.98333333333333, 0.18, 0
6221, 0.98333333333333, 0.2, 0
6222, 0.98333333333333, 0.22, 0
6223, 0.98333333333333, 0.24, 0
6224, 0.98333333333333, 0.26, 0
6225, 0.98333333333333, 0.28, 0
6226, 0.98333333333333, 0.3, 0
6227, 0.98333333333333, 0.32, 0
6228, 0.98333333333333, 0.34, 0
6229, 0.98333333333333, 0.36, 0
6230, 0.98333333333333, 0.38, 0
6231, 0.98333333333333, 0.4, 0
6232, 0.98333333333333, 0.42, 0
6233, 0.98333333333333, 0.44, 0
6234, 0.98333333333333, 0.46, 0
6235, 0.98333333333333, 0.48, 0
6236, 0.98333333333333, 0.5, 0
6237, 0.98333333333333, 0.52, 0
6238, 0.98333333333333, 0.54, 0
6239, 0.98333333333333, 0.56, 0
6240, 0.98333333333333, 0.58, 0
6241, 0.98333333333333, 0.6, 0
6242, 0.98333333333333, 0.62, 0
6243, 0.98333333333333, 0.64, 0
6244, 0.98333333333333, 0.66, 0
6245, 0.98333333333333, 0.68, 0
6246, 0.98333333333333, 0.7, 0
6247, 0.98333333333333, 0.72, 0
6248, 0.98333333333333, 0.74, 0
6249, 0.98333333333333, 0.76, 0
6250, 0.98333333333333, 0.78, 0
6251, 0.98333333333333, 0.8, 0
6252, 0.98333333333333, 0.82, 0
6253, 0.98333333333333, 0.84, 0
6254, 0.98333333333333, 0.86, 0
6255, 0.98333333333333, 0.88, 0
6256, 0.98333333333333, 0.9, 0
6257, 0.98333333333333, 0.92, 0
6258, 0.98333333333333, 0.94, 0
6259, 0.98333333333333, 0.96, 0
6260, 0.98333333333333, 0.98, 0
6261, 0.98333333333333, 1, 0
6262, 0.98333333333333, 1.02, 0
6263, 0.98333333333333, 1.04, 0
6264, 0.98333333333333, 1.06, 0
6265, 0.98333333333333, 1.08, 0
6266, 0.98333333333333, 1.1, 0
6267, 0.98333333333333, 1.12, 0
6268, 0.98333333333333, 1.14, 0
6269, 0.98333333333333, 1.16, 0
6270, 0.98333333333333, 1.18, 0
6271, 0.016666666666667, 0.01, 0
6272, 0.0083333333333333, 0.02, 0
6273, 0.016666666666667, 0.03, 0
6274, 0.0083333333333334, 0.04, 0
6275, 0.016666666666667, 0.05, 0
6276, 0.0083333333333333, 0.06, 0
6277, 0.016666666666667, 0.07, 0
6278, 0.0083333333333333, 0.08, 0
6279, 0.016666666666667, 0.09, 0
6280, 0.0083333333333333, 0.1, 0
6281, 0.016666666666667, 0.11, 0
6282, 0.0083333333333334, 0.12, 0
6283, 0.016666666666667, 0.13, 0
6284, 0.0083333333333334, 0.14, 0
6285, 0.016666666666667, 0.15, 0
6286, 0.0083333333333333, 0.16, 0
6287, 0.016666666666667, 0.17, 0
6288, 0.0083333333333333, 0.18, 0
6289, 0.016666666666667, 0.19, 0
6290, 0.0083333333333334, 0.2, 0
6291, 0.016666666666667, 0.21, 0
6292, 0.0083333333333333, 0.22, 0
6293, 0.016666666666667, 0.23, 0
6294, 0.0083333333333333, 0.24, 0
6295, 0.016666666666667, 0.25, 0
6296, 0.0083333333333334, 0.26, 0
6297, 0.016666666666667, 0.27, 0
6298, 0.0083333333333333, 0.28, 0
6299, 0.016666666666667, 0.29, 0
6300, 0.0083333333333334, 0.3, 0
6301, 0.016666666666667, 0.31, 0
6302, 0.0083333333333334, 0.32, 0
6303, 0.016666666666667, 0.33, 0
6304, 0.0083333333333333, 0.34, 0
6305, 0.016666666666667, 0.35, 0
6306, 0.0083333333333334, 0.36, 0
6307, 0.016666666666667, 0.37, 0
6308, 0.0083333333333334, 0.38, 0
6309, 0.016666666666667, 0.39, 0
6310, 0.0083333333333333, 0.4, 0
6311, 0.016666666666667, 0.41, 0
6312, 0.0083333333333333, 0.42, 0
6313, 0.016666666666667, 0.43, 0
6314, 0.0083333333333334, 0.44, 0
6315, 0.016666666666667, 0.45, 0
6316, 0.0083333333333334, 0.46, 0
6317, 0.016666666666667, 0.47, 0
6318, 0.0083333333333334, 0.48, 0
6319, 0.016666666666667, 0.49, 0
6320, 0.0083333333333334, 0.5, 0
6321, 0.016666666666667, 0.51, 0
6322, 0.0083333333333333, 0.52, 0
6323, 0.016666666666667, 0.53, 0
6324, 0.0083333333333334, 0.54, 0
6325, 0.016666666666667, 0.55, 0
6326, 0.0083333333333334, 0.56, 0
6327, 0.016666666666667, 0.57, 0
6328, 0.0083333333333334, 0.58, 0
6329, 0.016666666666667, 0.59, 0
6330, 0.0083333333333334, 0.6, 0
6331, 0.016666666666667, 0.61, 0
6332, 0.0083333333333334, 0.62, 0
6333, 0.016666666666667, 0.63, 0
6334, 0.0083333333333333, 0.64, 0
6335, 0.016666666666667, 0.65, 0
6336, 0.0083333333333334, 0.66, 0
6337, 0.016666666666667, 0.67, 0
6338, 0.0083333333333334, 0.68, 0
6339, 0.016666666666667, 0.69, 0
6340, 0.0083333333333334, 0.7, 0
6341, 0.016666666666667, 0.71, 0
6342, 0.0083333333333334, 0.72, 0
6343, 0.016666666666667, 0.73, 0
6344, 0.0083333333333334, 0.74, 0
6345, 0.016666666666667, 0.75, 0
6346, 0.0083333333333334, 0.76, 0
6347, 0.016666666666667, 0.77, 0
6348, 0.0083333333333334, 0.78, 0
6349, 0.016666666666667, 0.79, 0
6350, 0.0083333333333334, 0.8, 0
6351, 0.016666666666667, 0.81, 0
6352, 0.0083333333333334, 0.82, 0
6353, 0.016666666666667, 0.83, 0
6354, 0.0083333333333334, 0.84, 0
6355, 0.016666666666667, 0.85, 0
6356, 0.0083333333333334, 0.86, 0
6357, 0.016666666666667, 0.87, 0
6358, 0.0083333333333334, 0.88, 0
6359, 0.016666666666667, 0.89, 0
6360, 0.0083333333333334, 0.9, 0
6361, 0.016666666666667, 0.91, 0
6362, 0.0083333333333334, 0.92, 0
6363, 0.016666666666667, 0.93, 0
6364, 0.0083333333333334, 0.94, 0
6365, 0.016666666666667, 0.95, 0
6366, 0.0083333333333334, 0.96, 0
6367, 0.016666666666667, 0.97, 0
6368, 0.0083333333333334, 0.98, 0
6369, 0.016666666666667, 0.99, 0
6370, 0.0083333333333334, 1, 0
6371, 0.016666666666667, 1.01, 0
6372, 0.0083333333333334, 1.02, 0
6373, 0.016666666666667, 1.03, 0
6374, 0.0083333333333334, 1.04, 0
6375, 0.016666666666667, 1.05, 0
6376, 0.0083333333333334, 1.06, 0
6377, 0.016666666666667, 1.07, 0
6378, 0.0083333333333334, 1.08, 0
6379, 0.016666666666667, 1.09, 0
6380, 0.0083333333333334, 1.1, 0
6381, 0.016666666666667, 1.11, 0
6382, 0.0083333333333334, 1.12, 0
6383, 0.016666666666667, 1.13, 0
6384, 0.0083333333333334, 1.14, 0
6385, 0.016666666666667, 1.15, 0
6386, 0.0083333333333334, 1.16, 0
6387, 0.016666666666667, 1.17, 0
6388, 0.0083333333333334, 1.18, 0
6389, 0.016666666666667, 1.19, 0
6390, 0.033333333333333, 0.01, 0
6391, 0.025, 0.02, 0
6392, 0.033333333333333, 0.03, 0
6393, 0.025, 0.04, 0
6394, 0.033333333333333, 0.05, 0
6395, 0.025, 0.06, 0
6396, 0.033333333333333, 0.07, 0
6397, 0.025, 0.08, 0
6398, 0.033333333333333, 0.09, 0
6399, 0.025, 0.1, 0
6400, 0.033333333333333, 0.11, 0
6401, 0.025, 0.12, 0
6402, 0.033333333333333, 0.13, 0
6403, 0.025, 0.14, 0
6404, 0.033333333333333, 0.15, 0
6405, 0.025, 0.16, 0
6406, 0.033333333333333, 0.17, 0
6407, 0.025, 0.18, 0
6408, 0.033333333333333, 0.19, 0
6409, 0.025, 0.2, 0
6410, 0.033333333333333, 0.21, 0
6411, 0.025, 0.22, 0
6412, 0.033333333333333, 0.23, 0
6413, 0.025, 0.24, 0
6414, 0.033333333333333, 0.25, 0
6415, 0.025, 0.26, 0
6416, 0.033333333333333, 0.27, 0
6417, 0.025, 0.28, 0
6418, 0.033333333333333, 0.29, 0
6419, 0.025, 0.3, 0
6420, 0.033333333333333, 0.31, 0
6421, 0.025, 0.32, 0
6422, 0.033333333333333, 0.33, 0
6423, 0.025, 0.34, 0
6424, 0.033333333333333, 0.35, 0
6425, 0.025, 0.36, 0
6426, 0.033333333333333, 0.37, 0
6427, 0.025, 0.38, 0
6428, 0.033333333333333, 0.39, 0
6429, 0.025, 0.4, 0
6430, 0.033333333333333, 0.41, 0
6431, 0.025, 0.42, 0
6432, 0.033333333333333, 0.43, 0
6433, 0.025, 0.44, 0
6434, 0.033333333333333, 0.45, 0
6435, 0.025, 0.46, 0
6436, 0.033333333333333, 0.47, 0
6437, 0.025, 0.48, 0
6438, 0.033333333333333, 0.49, 0
6439, 0.025, 0.5, 0
6440, 0.033333333333333, 0.51, 0
6441, 0.025, 0.52, 0
6442, 0.033333333333333, 0.53, 0
6443, 0.025, 0.54, 0
6444, 0.033333333333333, 0.55, 0
6445, 0.025, 0.56, 0
6446, 0.033333333333333, 0.57, 0
6447, 0.025, 0.58, 0
6448, 0.033333333333333, 0.59, 0
6449, 0.025, 0.6, 0
6450, 0.033333333333333, 0.61, 0
6451, 0.025, 0.62, 0
6452, 0.033333333333333, 0.63, 0
6453, 0.025, 0.64, 0
6454, 0.033333333333333, 0.65, 0
6455, 0.025, 0.66, 0
6456, 0.033333333333333, 0.67, 0
6457, 0.025, 0.68, 0
6458, 0.033333333333333, 0.69, 0
6459, 0.025, 0.7, 0
6460, 0.033333333333333, 0.71, 0
6461, 0.025, 0.72, 0
6462, 0.033333333333333, 0.73, 0
6463, 0.025, 0.74, 0
6464, 0.033333333333333, 0.75, 0
6465, 0.025, 0.76, 0
6466, 0.033333333333333, 0.77, 0
6467, 0.025, 0.78, 0
6468, 0.033333333333333, 0.79, 0
6469, 0.025, 0.8, 0
6470, 0.033333333333333, 0.81, 0
6471, 0.025, 0.82, 0
6472, 0.033333333333333, 0.83, 0
6473, 0.025, 0.84, 0
6474, 0.033333333333333, 0.85, 0
6475, 0.025, 0.86, 0
6476, 0.033333333333333, 0.87, 0
6477, 0.025, 0.88, 0
6478, 0.033333333333333, 0.89, 0
6479, 0.025, 0.9, 0
6480, 0.033333333333333, 0.91, 0
6481, 0.025, 0.92, 0
6482, 0.033333333333333, 0.93, 0
6483, 0.025, 0.94, 0
6484, 0.033333333333333, 0.95, 0
6485, 0.025, 0.96, 0
6486, 0.033333333333333, 0.97, 0
6487, 0.025, 0.98, 0
6488, 0.033333333333333, 0.99, 0
6489, 0.025, 1, 0
6490, 0.033333333333333, 1.01, 0
6491, 0.025, 1.02, 0
6492, 0.033333333333333, 1.03, 0
6493, 0.025, 1.04, 0
6494, 0.033333333333333, 1.05, 0
6495, 0.025, 1.06, 0
6496, 0.033333333333333, 1.07, 0
6497, 0.025, 1.08, 0
6498, 0.033333333333333, 1.09, 0
6499, 0.025, 1.1, 0
6500, 0.033333333333333, 1.11, 0
6501, 0.025, 1.12, 0
6502, 0.033333333333333, 1.13, 0
6503, 0.025, 1.14, 0
6504, 0.033333333333333, 1.15, 0
6505, 0.025, 1.16, 0
6506, 0.033333333333333, 1.17, 0
6507, 0.025, 1.18, 0
6508, 0.033333333333333, 1.19, 0
6509, 0.05, 0.01, 0
6510, 0.041666666666667, 0.02, 0
6511, 0.05, 0.03, 0
6512, 0.041666666666667, 0.04, 0
6513, 0.05, 0.05, 0
6514, 0.041666666666667, 0.06, 0
6515, 0.05, 0.07, 0
6516, 0.041666666666667, 0.08, 0
6517, 0.05, 0.09, 0
6518, 0.041666666666667, 0.1, 0
6519, 0.05, 0.11, 0
6520, 0.041666666666667, 0.12, 0
6521, 0.05, 0.13, 0
6522, 0.041666666666667, 0.14, 0
6523, 0.05, 0.15, 0
6524, 0.041666666666667, 0.16, 0
6525, 0.05, 0.17, 0
6526, 0.041666666666667, 0.18, 0
6527, 0.05, 0.19, 0
6528, 0.041666666666667, 0.2, 0
6529, 0.05, 0.21, 0
6530, 0.041666666666667, 0.22, 0
6531, 0.05, 0.23, 0
6532, 0.041666666666667, 0.24, 0
6533, 0.05, 0.25, 0
6534, 0.041666666666667, 0.26, 0
6535, 0.05, 0.27, 0
6536, 0.041666666666667, 0.28, 0
6537, 0.05, 0.29, 0
6538, 0.041666666666667, 0.3, 0
6539, 0.05, 0.31, 0
6540, 0.041666666666667, 0.32, 0
6541, 0.05, 0.33, 0
6542, 0.041666666666667, 0.34, 0
6543, 0.05, 0.35, 0
6544, 0.041666666666667, 0.36, 0
6545, 0.05, 0.37, 0
6546, 0.041666666666667, 0.38, 0
6547, 0.05, 0.39, 0
6548, 0.041666666666667, 0.4, 0
6549, 0.05, 0.41, 0
6550, 0.041666666666667, 0.42, 0
6551, 0.05, 0.43, 0
6552, 0.041666666666667, 0.44, 0
6553, 0.05, 0.45, 0
6554, 0.041666666666667, 0.46, 0
6555, 0.05, 0.47, 0
6556, 0.041666666666667, 0.48, 0
6557, 0.05, 0.49, 0
6558, 0.041666666666667, 0.5, 0
6559, 0.05, 0.51, 0
6560, 0.041666666666667, 0.52, 0
6561, 0.05, 0.53, 0
6562, 0.041666666666667, 0.54, 0
6563, 0.05, 0.55, 0
6564, 0.041666666666667, 0.56, 0
6565, 0.05, 0.57, 0
6566, 0.041666666666667, 0.58, 0
6567, 0.05, 0.59, 0
6568, 0.041666666666667, 0.6, 0
6569, 0.05, 0.61, 0
6570, 0.041666666666667, 0.62, 0
6571, 0.05, 0.63, 0
6572, 0.041666666666667, 0.64, 0
6573, 0.05, 0.65, 0
6574, 0.041666666666667, 0.66, 0
6575, 0.05, 0.67, 0
6576, 0.041666666666667, 0.68, 0
6577, 0.05, 0.69, 0
6578, 0.041666666666667, 0.7, 0
6579, 0.05, 0.71, 0
6580, 0.041666666666667, 0.72, 0
6581, 0.05, 0.73, 0
6582, 0.041666666666667, 0.74, 0
6583, 0.05, 0.75, 0
6584, 0.041666666666667, 0.76, 0
6585, 0.05, 0.77, 0
6586, 0.041666666666667, 0.78, 0
6587, 0.05, 0.79, 0
6588, 0.041666666666667, 0.8, 0
6589, 0.05, 0.81, 0
6590, 0.041666666666667, 0.82, 0
6591, 0.05, 0.83, 0
6592, 0.041666666666667, 0.84, 0
6593, 0.05, 0.85, 0
6594, 0.041666666666667, 0.86, 0
6595, 0.05, 0.87, 0
6596, 0.041666666666667, 0.88, 0
6597, 0.05, 0.89, 0
6598, 0.041666666666667, 0.9, 0
6599, 0.05, 0.91, 0
6600, 0.041666666666667, 0.92, 0
6601, 0.05, 0.93, 0
6602, 0.041666666666667, 0.94, 0
6603, 0.05, 0.95, 0
6604, 0.041666666666667, 0.96, 0
6605, 0.05, 0.97, 0
6606, 0.041666666666667, 0.98, 0
6607, 0.05, 0.99, 0
6608, 0.041666666666667, 1, 0
6609, 0.05, 1.01, 0
6610, 0.041666666666667, 1.02, 0
6611, 0.05, 1.03, 0
6612, 0.041666666666667, 1.04, 0
6613, 0.05, 1.05, 0
6614, 0.041666666666667, 1.06, 0
6615, 0.05, 1.07, 0
6616, 0.041666666666667, 1.08, 0
6617, 0.05, 1.09, 0
6618, 0.041666666666667, 1.1, 0
6619, 0.05, 1.11, 0
6620, 0.041666666666667, 1.12, 0
6621, 0.05, 1.13, 0
6622, 0.041666666666667, 1.14, 0
6623, 0.05, 1.15, 0
6624, 0.041666666666667, 1.16, 0
6625, 0.05, 1.17, 0
6626, 0.041666666666667, 1.18, 0
6627, 0.05, 1.19, 0
6628, 0.066666666666667, 0.01, 0
6629, 0.058333333333333, 0.02, 0
6630, 0.066666666666667, 0.03, 0
6631, 0.058333333333333, 0.04, 0
6632, 0.066666666666667, 0.05, 0
6633, 0.058333333333333, 0.06, 0
6634, 0.066666666666667, 0.07, 0
6635, 0.058333333333333, 0.08, 0
6636, 0.066666666666667, 0.09, 0
6637, 0.058333333333333, 0.1, 0
6638, 0.066666666666667, 0.11, 0
6639, 0.058333333333333, 0.12, 0
6640, 0.066666666666667, 0.13, 0
6641, 0.058333333333333, 0.14, 0
6642, 0.066666666666667, 0.15, 0
6643, 0.058333333333333, 0.16, 0
6644, 0.066666666666667, 0.17, 0
6645, 0.058333333333333, 0.18, 0
6646, 0.066666666666667, 0.19, 0
6647, 0.058333333333333, 0.2, 0
6648, 0.066666666666667, 0.21, 0
6649, 0.058333333333333, 0.22, 0
6650, 0.066666666666667, 0.23, 0
6651, 0.058333333333333, 0.24, 0
6652, 0.066666666666667, 0.25, 0
6653, 0.058333333333333, 0.26, 0
6654, 0.066666666666667, 0.27, 0
6655, 0.058333333333333, 0.28, 0
6656, 0.066666666666667, 0.29, 0
6657, 0.058333333333333, 0.3, 0
6658, 0.066666666666667, 0.31, 0
6659, 0.058333333333333, 0.32, 0
6660, 0.066666666666667, 0.33, 0
6661, 0.058333333333333, 0.34, 0
6662, 0.066666666666667, 0.35, 0
6663, 0.058333333333333, 0.36, 0
6664, 0.066666666666667, 0.37, 0
6665, 0.058333333333333, 0.38, 0
6666, 0.066666666666667, 0.39, 0
6667, 0.058333333333333, 0.4, 0
6668, 0.066666666666667, 0.41, 0
6669, 0.058333333333333, 0.42, 0
6670, 0.066666666666667, 0.43, 0
6671, 0.058333333333333, 0.44, 0
6672, 0.066666666666667, 0.45, 0
6673, 0.058333333333333, 0.46, 0
6674, 0.066666666666667, 0.47, 0
6675, 0.058333333333333, 0.48, 0
6676, 0.066666666666667, 0.49, 0
6677, 0.058333333333333, 0.5, 0
6678, 0.066666666666667, 0.51, 0
6679, 0.058333333333333, 0.52, 0
6680, 0.066666666666667, 0.53, 0
6681, 0.058333333333333, 0.54, 0
6682, 0.066666666666667, 0.55, 0
6683, 0.058333333333333, 0.56, 0
6684, 0.066666666666667, 0.57, 0
6685, 0.058333333333333, 0.58, 0
6686, 0.066666666666667, 0.59, 0
6687, 0.058333333333333, 0.6, 0
6688, 0.066666666666667, 0.61, 0
6689, 0.058333333333333, 0.62, 0
6690, 0.066666666666667, 0.63, 0
6691, 0.058333333333333, 0.64, 0
6692, 0.066666666666667, 0.65, 0
6693, 0.058333333333333, 0.66, 0
6694, 0.066666666666667, 0.67, 0
6695, 0.058333333333333, 0.68, 0
6696, 0.066666666666667, 0.69, 0
6697, 0.058333333333333, 0.7, 0
6698, 0.066666666666667, 0.71, 0
6699, 0.058333333333333, 0.72, 0
6700, 0.066666666666667, 0.73, 0
6701, 0.058333333333333, 0.74, 0
6702, 0.066666666666667, 0.75, 0
6703, 0.058333333333333, 0.76, 0
6704, 0.066666666666667, 0.77, 0
6705, 0.058333333333333, 0.78, 0
6706, 0.066666666666667, 0.79, 0
6707, 0.058333333333333, 0.8, 0
6708, 0.066666666666667, 0.81, 0
6709, 0.058333333333333, 0.82, 0
6710, 0.066666666666667, 0.83, 0
6711, 0.058333333333333, 0.84, 0
6712, 0.066666666666667, 0.85, 0
6713, 0.058333333333333, 0.86, 0
6714, 0.066666666666667, 0.87, 0
6715, 0.058333333333333, 0.88, 0
6716, 0.066666666666667, 0.89, 0
6717, 0.058333333333333, 0.9, 0
6718, 0.066666666666667, 0.91, 0
6719, 0.058333333333333, 0.92, 0
6720, 0.066666666666667, 0.93, 0
6721, 0.058333333333333, 0.94, 0
6722, 0.066666666666667, 0.95, 0
6723, 0.058333333333333, 0.96, 0
6724, 0.066666666666667, 0.97, 0
6725, 0.058333333333333, 0.98, 0
6726, 0.066666666666667, 0.99, 0
6727, 0.058333333333333, 1, 0
6728, 0.066666666666667, 1.01, 0
6729, 0.058333333333333, 1.02, 0
6730, 0.066666666666667, 1.03, 0
6731, 0.058333333333333, 1.04, 0
6732, 0.066666666666667, 1.05, 0
6733, 0.058333333333333, 1.06, 0
6734, 0.066666666666667, 1.07, 0
6735, 0.058333333333333, 1.08, 0
6736, 0.066666666666667, 1.09, 0
6737, 0.058333333333333, 1.1, 0
6738, 0.066666666666667, 1.11, 0
6739, 0.058333333333333, 1.12, 0
6740, 0.066666666666667, 1.13, 0
6741, 0.058333333333333, 1.14, 0
6742, 0.066666666666667, 1.15, 0
6743, 0.058333333333333, 1.16, 0
6744, 0.066666666666667, 1.17, 0
6745, 0.058333333333333, 1.18, 0
6746, 0.066666666666667, 1.19, 0
6747, 0.083333333333333, 0.01, 0
6748, 0.075, 0.02, 0
6749, 0.083333333333333, 0.03, 0
6750, 0.075, 0.04, 0
6751, 0.083333333333333, 0.05, 0
6752, 0.075, 0.06, 0
6753, 0.083333333333333, 0.07, 0
6754, 0.075, 0.08, 0
6755, 0.083333333333333, 0.09, 0
6756, 0.075, 0.1, 0
6757, 0.083333333333333, 0.11, 0
6758, 0.075, 0.12, 0
6759, 0.083333333333333, 0.13, 0
6760, 0.075, 0.14, 0
6761, 0.083333333333333, 0.15, 0
6762, 0.075, 0.16, 0
6763, 0.083333333333333, 0.17, 0
6764, 0.075, 0.18, 0
6765, 0.083333333333333, 0.19, 0
6766, 0.075, 0.2, 0
6767, 0.083333333333333, 0.21, 0
6768, 0.075, 0.22, 0
6769, 0.083333333333333, 0.23, 0
6770, 0.075, 0.24, 0
6771, 0.083333333333333, 0.25, 0
6772, 0.075, 0.26, 0
6773, 0.083333333333333, 0.27, 0
6774, 0.075, 0.28, 0
6775, 0.083333333333333, 0.29, 0
6776, 0.075, 0.3, 0
6777, 0.083333333333333, 0.31, 0
6778, 0.075, 0.32, 0
6779, 0.083333333333333, 0.33, 0
6780, 0.075, 0.34, 0
6781, 0.083333333333333, 0.35, 0
6782, 0.075, 0.36, 0
6783, 0.083333333333333, 0.37, 0
6784, 0.075, 0.38, 0
6785, 0.083333333333333, 0.39, 0
6786, 0.075, 0.4, 0
6787, 0.083333333333333, 0.41, 0
6788, 0.075, 0.42, 0
6789, 0.083333333333333, 0.43, 0
6790, 0.075, 0.44, 0
6791, 0.083333333333333, 0.45, 0
6792, 0.075, 0.46, 0
6793, 0.083333333333333, 0.47, 0
6794, 0.075, 0.48, 0
6795, 0.083333333333333, 0.49, 0
6796, 0.075, 0.5, 0
6797, 0.083333333333333, 0.51, 0
6798, 0.075, 0.52, 0
6799, 0.083333333333333, 0.53, 0
6800, 0.075, 0.54, 0
6801, 0.083333333333333, 0.55, 0
6802, 0.075, 0.56, 0
6803, 0.083333333333333, 0.57, 0
6804, 0.075, 0.58, 0
6805, 0.083333333333333, 0.59, 0
6806, 0.075, 0.6, 0
6807, 0.083333333333333, 0.61, 0
6808, 0.075, 0.62, 0
6809, 0.083333333333333, 0.63, 0
6810, 0.075, 0.64, 0
6811, 0.083333333333333, 0.65, 0
6812, 0.075, 0.66, 0
6813, 0.083333333333333, 0.67, 0
6814, 0.075, 0.68, 0
6815, 0.083333333333333, 0.69, 0
6816, 0.075, 0.7, 0
6817, 0.083333333333333, 0.71, 0
6818, 0.075, 0.72, 0
6819, 0.083333333333333, 0.73, 0
6820, 0.075, 0.74, 0
6821, 0.083333333333333, 0.75, 0
6822, 0.075, 0.76, 0
6823, 0.083333333333333, 0.77, 0
6824, 0.075, 0.78, 0
6825, 0.083333333333333, 0.79, 0
6826, 0.075, 0.8, 0
6827, 0.083333333333333, 0.81, 0
6828, 0.075, 0.82, 0
6829, 0.083333333333333, 0.83, 0
6830, 0.075, 0.84, 0
6831, 0.083333333333333, 0.85, 0
6832, 0.075, 0.86, 0
6833, 0.083333333333333, 0.87, 0
6834, 0.075, 0.88, 0
6835, 0.083333333333333, 0.89, 0
6836, 0.075, 0.9, 0
6837, 0.083333333333333, 0.91, 0
6838, 0.075, 0.92, 0
6839, 0.083333333333333, 0.93, 0
6840, 0.075, 0.94, 0
6841, 0.083333333333333, 0.95, 0
6842, 0.075, 0.96, 0
6843, 0.083333333333333, 0.97, 0
6844, 0.075, 0.98, 0
6845, 0.083333333333333, 0.99, 0
6846, 0.075, 1, 0
6847, 0.083333333333333, 1.01, 0
6848, 0.075, 1.02, 0
6849, 0.083333333333333, 1.03, 0
6850, 0.075, 1.04, 0
6851, 0.083333333333333, 1.05, 0
6852, 0.075, 1.06, 0
6853, 0.083333333333333, 1.07, 0
6854, 0.075, 1.08, 0
6855, 0.083333333333333, 1.09, 0
6856, 0.075, 1.1, 0
6857, 0.083333333333333, 1.11, 0
6858, 0.075, 1.12, 0
6859, 0.083333333333333, 1.13, 0
6860, 0.075, 1.14, 0
6861, 0.083333333333333, 1.15, 0
6862, 0.075, 1.16, 0
6863, 0.083333333333333, 1.17, 0
6864, 0.075, 1.18, 0
6865, 0.083333333333333, 1.19, 0
6866, 0.1, 0.01, 0
6867, 0.091666666666667, 0.02, 0
6868, 0.1, 0.03, 0
6869, 0.091666666666667, 0.04, 0
6870, 0.1, 0.05, 0
6871, 0.091666666666667, 0.06, 0
6872, 0.1, 0.07, 0
6873, 0.091666666666667, 0.08, 0
6874, 0.1, 0.09, 0
6875, 0.091666666666667, 0.1, 0
6876, 0.1, 0.11, 0
6877, 0.091666666666667, 0.12, 0
6878, 0.1, 0.13, 0
6879, 0.091666666666667, 0.14, 0
6880, 0.1, 0.15, 0
6881, 0.091666666666667, 0.16, 0
6882, 0.1, 0.17, 0
6883, 0.091666666666667, 0.18, 0
6884, 0.1, 0.19, 0
6885, 0.091666666666667, 0.2, 0
6886, 0.1, 0.21, 0
6887, 0.091666666666667, 0.22, 0
6888, 0.1, 0.23, 0
6889, 0.091666666666667, 0.24, 0
6890, 0.1, 0.25, 0
6891, 0.091666666666667, 0.26, 0
6892, 0.1, 0.27, 0
6893, 0.091666666666667, 0.28, 0
6894, 0.1, 0.29, 0
6895, 0.091666666666667, 0.3, 0
6896, 0.1, 0.31, 0
6897, 0.091666666666667, 0.32, 0
6898, 0.1, 0.33, 0
6899, 0.091666666666667, 0.34, 0
6900, 0.1, 0.35, 0
6901, 0.091666666666667, 0.36, 0
6902, 0.1, 0.37, 0
6903, 0.091666666666667, 0.38, 0
6904, 0.1, 0.39, 0
6905, 0.091666666666667, 0.4, 0
6906, 0.1, 0.41, 0
6907, 0.091666666666667, 0.42, 0
6908, 0.1, 0.43, 0
6909, 0.091666666666667, 0.44, 0
6910, 0.1, 0.45, 0
6911, 0.091666666666667, 0.46, 0
6912, 0.1, 0.47, 0
6913, 0.091666666666667, 0.48, 0
6914, 0.1, 0.49, 0
6915, 0.091666666666667, 0.5, 0
6916, 0.1, 0.51, 0
6917, 0.091666666666667, 0.52, 0
6918, 0.1, 0.53, 0
6919, 0.091666666666667, 0.54, 0
6920, 0.1, 0.55, 0
6921, 0.091666666666667, 0.56, 0
6922, 0.1, 0.57, 0
6923, 0.091666666666667, 0.58, 0
6924, 0.1, 0.59, 0
6925, 0.091666666666667, 0.6, 0
6926, 0.1, 0.61, 0
6927, 0.091666666666667, 0.62, 0
6928, 0.1, 0.63, 0
6929, 0.091666666666667, 0.64, 0
6930, 0.1, 0.65, 0
6931, 0.091666666666667, 0.66, 0
6932, 0.1, 0.67, 0
6933, 0.091666666666667, 0.68, 0
6934, 0.1, 0.69, 0
6935, 0.091666666666667, 0.7, 0
6936, 0.1, 0.71, 0
6937, 0.091666666666667, 0.72, 0
6938, 0.1, 0.73, 0
6939, 0.091666666666667, 0.74, 0
6940, 0.1, 0.75, 0
6941, 0.091666666666667, 0.76, 0
6942, 0.1, 0.77, 0
6943, 0.091666666666667, 0.78, 0
6944, 0.1, 0.79, 0
6945, 0.091666666666667, 0.8, 0
6946, 0.1, 0.81, 0
6947, 0.091666666666667, 0.82, 0
6948, 0.1, 0.83, 0
6949, 0.091666666666667, 0.84, 0
6950, 0.1, 0.85, 0
6951, 0.091666666666667, 0.86, 0
6952, 0.1, 0.87, 0
6953, 0.091666666666667, 0.88, 0
6954, 0.1, 0.89, 0
6955, 0.091666666666667, 0.9, 0
6956, 0.1, 0.91, 0
6957, 0.091666666666667, 0.92, 0
6958, 0.1, 0.93, 0
6959, 0.091666666666667, 0.94, 0
6960, 0.1, 0.95, 0
6961, 0.091666666666667, 0.96, 0
6962, 0.1, 0.97, 0
6963, 0.091666666666667, 0.98, 0
6964, 0.1, 0.99, 0
6965, 0.091666666666667, 1, 0
6966, 0.1, 1.01, 0
6967, 0.091666666666667, 1.02, 0
6968, 0.1, 1.03, 0
6969, 0.091666666666667, 1.04, 0
6970, 0.1, 1.05, 0
6971, 0.091666666666667, 1.06, 0
6972, 0.1, 1.07, 0
6973, 0.091666666666667, 1.08, 0
6974, 0.1, 1.09, 0
6975, 0.091666666666667, 1.1, 0
6976, 0.1, 1.11, 0
6977, 0.091666666666667, 1.12, 0
6978, 0.1, 1.13, 0
6979, 0.091666666666667, 1.14, 0
6980, 0.1, 1.15, 0
6981, 0.091666666666667, 1.16, 0
6982, 0.1, 1.17, 0
6983, 0.091666666666667, 1.18, 0
6984, 0.1, 1.19, 0
6985, 0.11666666666667, 0.01, 0
6986, 0.10833333333333, 0.02, 0
6987, 0.11666666666667, 0.03, 0
6988, 0.10833333333333, 0.04, 0
6989, 0.11666666666667, 0.05, 0
6990, 0.10833333333333, 0.06, 0
6991, 0.11666666666667, 0.07, 0
6992, 0.10833333333333, 0.08, 0
6993, 0.11666666666667, 0.09, 0
6994, 0.10833333333333, 0.1, 0
6995, 0.11666666666667, 0.11, 0
6996, 0.10833333333333, 0.12, 0
6997, 0.11666666666667, 0.13, 0
6998, 0.10833333333333, 0.14, 0
6999, 0.11666666666667, 0.15, 0
7000, 0.10833333333333, 0.16, 0
7001, 0.11666666666667, 0.17, 0
7002, 0.10833333333333, 0.18, 0
7003, 0.11666666666667, 0.19, 0
7004, 0.10833333333333, 0.2, 0
7005, 0.11666666666667, 0.21, 0
7006, 0.10833333333333, 0.22, 0
7007, 0.11666666666667, 0.23, 0
7008, 0.10833333333333, 0.24, 0
7009, 0.11666666666667, 0.25, 0
7010, 0.10833333333333, 0.26, 0
7011, 0.11666666666667, 0.27, 0
7012, 0.10833333333333, 0.28, 0
7013, 0.11666666666667, 0.29, 0
7014, 0.10833333333333, 0.3, 0
7015, 0.11666666666667, 0.31, 0
7016, 0.10833333333333, 0.32, 0
7017, 0.11666666666667, 0.33, 0
7018, 0.10833333333333, 0.34, 0
7019, 0.11666666666667, 0.35, 0
7020, 0.10833333333333, 0.36, 0
7021, 0.11666666666667, 0.37, 0
7022, 0.10833333333333, 0.38, 0
7023, 0.11666666666667, 0.39, 0
7024, 0.10833333333333, 0.4, 0
7025, 0.11666666666667, 0.41, 0
7026, 0.10833333333333, 0.42, 0
7027, 0.11666666666667, 0.43, 0
7028, 0.10833333333333, 0.44, 0
7029, 0.11666666666667, 0.45, 0
7030, 0.10833333333333, 0.46, 0
7031, 0.11666666666667, 0.47, 0
7032, 0.10833333333333, 0.48, 0
7033, 0.11666666666667, 0.49, 0
7034, 0.10833333333333, 0.5, 0
7035, 0.11666666666667, 0.51, 0
7036, 0.10833333333333, 0.52, 0
7037, 0.11666666666667, 0.53, 0
7038, 0.10833333333333, 0.54, 0
7039, 0.11666666666667, 0.55, 0
7040, 0.10833333333333, 0.56, 0
7041, 0.11666666666667, 0.57, 0
7042, 0.10833333333333, 0.58, 0
7043, 0.11666666666667, 0.59, 0
7044, 0.10833333333333, 0.6, 0
7045, 0.11666666666667, 0.61, 0
7046, 0.10833333333333, 0.62, 0
7047, 0.11666666666667, 0.63, 0
7048, 0.10833333333333, 0.64, 0
7049, 0.11666666666667, 0.65, 0
7050, 0.10833333333333, 0.66, 0
7051, 0.11666666666667, 0.67, 0
7052, 0.10833333333333, 0.68, 0
7053, 0.11666666666667, 0.69, 0
7054, 0.10833333333333, 0.7, 0
7055, 0.11666666666667, 0.71, 0
7056, 0.10833333333333, 0.72, 0
7057, 0.11666666666667, 0.73, 0
7058, 0.10833333333333, 0.74, 0
7059, 0.11666666666667, 0.75, 0
7060, 0.10833333333333, 0.76, 0
7061, 0.11666666666667, 0.77, 0
7062, 0.10833333333333, 0.78, 0
7063, 0.11666666666667, 0.79, 0
7064, 0.10833333333333, 0.8, 0
7065, 0.11666666666667, 0.81, 0
7066, 0.10833333333333, 0.82, 0
7067, 0.11666666666667, 0.83, 0
7068, 0.10833333333333, 0.84, 0
7069, 0.11666666666667, 0.85, 0
7070, 0.10833333333333, 0.86, 0
7071, 0.11666666666667, 0.87, 0
7072, 0.10833333333333, 0.88, 0
7073, 0.11666666666667, 0.89, 0
7074, 0.10833333333333, 0.9, 0
7075, 0.11666666666667, 0.91, 0
7076, 0.10833333333333, 0.92, 0
7077, 0.11666666666667, 0.93, 0
7078, 0.10833333333333, 0.94, 0
7079, 0.11666666666667, 0.95, 0
7080, 0.10833333333333, 0.96, 0
7081, 0.11666666666667, 0.97, 0
7082, 0.10833333333333, 0.98, 0
7083, 0.11666666666667, 0.99, 0
7084, 0.10833333333333, 1, 0
7085, 0.11666666666667, 1.01, 0
7086, 0.10833333333333, 1.02, 0
7087, 0.11666666666667, 1.03, 0
7088, 0.10833333333333, 1.04, 0
7089, 0.11666666666667, 1.05, 0
7090, 0.10833333333333, 1.06, 0
7091, 0.11666666666667, 1.07, 0
7092, 0.10833333333333, 1.08, 0
7093, 0.11666666666667, 1.09, 0
7094, 0.10833333333333, 1.1, 0
7095, 0.11666666666667, 1.11, 0
7096, 0.10833333333333, 1.12, 0
7097, 0.11666666666667, 1.13, 0
7098, 0.10833333333333, 1.14, 0
7099, 0.11666666666667, 1.15, 0
7100, 0.10833333333333, 1.16, 0
7101, 0.11666666666667, 1.17, 0
7102, 0.10833333333333, 1.18, 0
7103, 0.11666666666667, 1.19, 0
7104, 0.13333333333333, 0.01, 0
7105, 0.125, 0.02, 0
7106, 0.13333333333333, 0.03, 0
7107, 0.125, 0.04, 0
7108, 0.13333333333333, 0.05, 0
7109, 0.125, 0.06, 0
7110, 0.13333333333333, 0.07, 0
7111, 0.125, 0.08, 0
7112, 0.13333333333333, 0.09, 0
7113, 0.125, 0.1, 0
7114, 0.13333333333333, 0.11, 0
7115, 0.125, 0.12, 0
7116, 0.13333333333333, 0.13, 0
7117, 0.125, 0.14, 0
7118, 0.13333333333333, 0.15, 0
7119, 0.125, 0.16, 0
7120, 0.13333333333333, 0.17, 0
7121, 0.125, 0.18, 0
7122, 0.13333333333333, 0.19, 0
7123, 0.125, 0.2, 0
7124, 0.13333333333333, 0.21, 0
7125, 0.125, 0.22, 0
7126, 0.13333333333333, 0.23, 0
7127, 0.125, 0.24, 0
7128, 0.13333333333333, 0.25, 0
7129, 0.125, 0.26, 0
7130, 0.13333333333333, 0.27, 0
7131, 0.125, 0.28, 0
7132, 0.13333333333333, 0.29, 0
7133, 0.125, 0.3, 0
7134, 0.13333333333333, 0.31, 0
7135, 0.125, 0.32, 0
7136, 0.13333333333333, 0.33, 0
7137, 0.125, 0.34, 0
7138, 0.13333333333333, 0.35, 0
7139, 0.125, 0.36, 0
7140, 0.13333333333333, 0.37, 0
7141, 0.125, 0.38, 0
7142, 0.13333333333333, 0.39, 0
7143, 0.125, 0.4, 0
7144, 0.13333333333333, 0.41, 0
7145, 0.125, 0.42, 0
7146, 0.13333333333333, 0.43, 0
7147, 0.125, 0.44, 0
7148, 0.13333333333333, 0.45, 0
7149, 0.125, 0.46, 0
7150, 0.13333333333333, 0.47, 0
7151, 0.125, 0.48, 0
7152, 0.13333333333333, 0.49, 0
7153, 0.125, 0.5, 0
7154, 0.13333333333333, 0.51, 0
7155, 0.125, 0.52, 0
7156, 0.13333333333333, 0.53, 0
7157, 0.125, 0.54, 0
7158, 0.13333333333333, 0.55, 0
7159, 0.125, 0.56, 0
7160, 0.13333333333333, 0.57, 0
7161, 0.125, 0.58, 0
7162, 0.13333333333333, 0.59, 0
7163, 0.125, 0.6, 0
7164, 0.13333333333333, 0.61, 0
7165, 0.125, 0.62, 0
7166, 0.13333333333333, 0.63, 0
7167, 0.125, 0.64, 0
7168, 0.13333333333333, 0.65, 0
7169, 0.125, 0.66, 0
7170, 0.13333333333333, 0.67, 0
7171, 0.125, 0.68, 0
7172, 0.13333333333333, 0.69, 0
7173, 0.125, 0.7, 0
7174, 0.13333333333333, 0.71, 0
7175, 0.125, 0.72, 0
7176, 0.13333333333333, 0.73, 0
7177, 0.125, 0.74, 0
7178, 0.13333333333333, 0.75, 0
7179, 0.125, 0.76, 0
7180, 0.13333333333333, 0.77, 0
7181, 0.125, 0.78, 0
7182, 0.13333333333333, 0.79, 0
7183, 0.125, 0.8, 0
7184, 0.13333333333333, 0.81, 0
7185, 0.125, 0.82, 0
7186, 0.13333333333333, 0.83, 0
7187, 0.125, 0.84, 0
7188, 0.13333333333333, 0.85, 0
7189, 0.125, 0.86, 0
7190, 0.13333333333333, 0.87, 0
7191, 0.125, 0.88, 0
7192, 0.13333333333333, 0.89, 0
7193, 0.125, 0.9, 0
7194, 0.13333333333333, 0.91, 0
7195, 0.125, 0.92, 0
7196, 0.13333333333333, 0.93, 0
7197, 0.125, 0.94, 0
7198, 0.13333333333333, 0.95, 0
7199, 0.125, 0.96, 0
7200, 0.13333333333333, 0.97, 0
7201, 0.125, 0.98, 0
7202, 0.13333333333333, 0.99, 0
7203, 0.125, 1, 0
7204, 0.13333333333333, 1.01, 0
7205, 0.125, 1.02, 0
7206, 0.13333333333333, 1.03, 0
7207, 0.125, 1.04, 0
7208, 0.13333333333333, 1.05, 0
7209, 0.125, 1.06, 0
7210, 0.13333333333333, 1.07, 0
7211, 0.125, 1.08, 0
7212, 0.13333333333333, 1.09, 0
7213, 0.125, 1.1, 0
7214, 0.13333333333333, 1.11, 0
7215, 0.125, 1.12, 0
7216, 0.13333333333333, 1.13, 0
7217, 0.125, 1.14, 0
7218, 0.13333333333333, 1.15, 0
7219, 0.125, 1.16, 0
7220, 0.13333333333333, 1.17, 0
7221, 0.125, 1.18, 0
7222, 0.13333333333333, 1.19, 0
7223, 0.15, 0.01, 0
7224, 0.14166666666667, 0.02, 0
7225, 0.15, 0.03, 0
7226, 0.14166666666667, 0.04, 0
7227, 0.15, 0.05, 0
7228, 0.14166666666667, 0.06, 0
7229, 0.15, 0.07, 0
7230, 0.14166666666667, 0.08, 0
7231, 0.15, 0.09, 0
7232, 0.14166666666667, 0.1, 0
7233, 0.15, 0.11, 0
7234, 0.14166666666667, 0.12, 0
7235, 0.15, 0.13, 0
7236, 0.14166666666667, 0.14, 0
7237, 0.15, 0.15, 0
7238, 0.14166666666667, 0.16, 0
7239, 0.15, 0.17, 0
7240, 0.14166666666667, 0.18, 0
7241, 0.15, 0.19, 0
7242, 0.14166666666667, 0.2, 0
7243, 0.15, 0.21, 0
7244, 0.14166666666667, 0.22, 0
7245, 0.15, 0.23, 0
7246, 0.14166666666667, 0.24, 0
7247, 0.15, 0.25, 0
7248, 0.14166666666667, 0.26, 0
7249, 0.15, 0.27, 0
7250, 0.14166666666667, 0.28, 0
7251, 0.15, 0.29, 0
7252, 0.14166666666667, 0.3, 0
7253, 0.15, 0.31, 0
7254, 0.14166666666667, 0.32, 0
7255, 0.15, 0.33, 0
7256, 0.14166666666667, 0.34, 0
7257, 0.15, 0.35, 0
7258, 0.14166666666667, 0.36, 0
7259, 0.15, 0.37, 0
7260, 0.14166666666667, 0.38, 0
7261, 0.15, 0.39, 0
7262, 0.14166666666667, 0.4, 0
7263, 0.15, 0.41, 0
7264, 0.14166666666667, 0.42, 0
7265, 0.15, 0.43, 0
7266, 0.14166666666667, 0.44, 0
7267, 0.15, 0.45, 0
7268, 0.14166666666667, 0.46, 0
7269, 0.15, 0.47, 0
7270, 0.14166666666667, 0.48, 0
7271, 0.15, 0.49, 0
7272, 0.14166666666667, 0.5, 0
7273, 0.15, 0.51, 0
7274, 0.14166666666667, 0.52, 0
7275, 0.15, 0.53, 0
7276, 0.14166666666667, 0.54, 0
7277, 0.15, 0.55, 0
7278, 0.14166666666667, 0.56, 0
7279, 0.15, 0.57, 0
7280, 0.14166666666667, 0.58, 0
7281, 0.15, 0.59, 0
7282, 0.14166666666667, 0.6, 0
7283, 0.15, 0.61, 0
7284, 0.14166666666667, 0.62, 0
7285, 0.15, 0.63, 0
7286, 0.14166666666667, 0.64, 0
7287, 0.15, 0.65, 0
7288, 0.14166666666667, 0.66, 0
7289, 0.15, 0.67, 0
7290, 0.14166666666667, 0.68, 0
7291, 0.15, 0.69, 0
7292, 0.14166666666667, 0.7, 0
7293, 0.15, 0.71, 0
7294, 0.14166666666667, 0.72, 0
7295, 0.15, 0.73, 0
7296, 0.14166666666667, 0.74, 0
7297, 0.15, 0.75, 0
7298, 0.14166666666667, 0.76, 0
7299, 0.15, 0.77, 0
7300, 0.14166666666667, 0.78, 0
7301, 0.15, 0.79, 0
7302, 0.14166666666667, 0.8, 0
7303, 0.15, 0.81, 0
7304, 0.14166666666667, 0.82, 0
7305, 0.15, 0.83, 0
7306, 0.14166666666667, 0.84, 0
7307, 0.15, 0.85, 0
7308, 0.14166666666667, 0.86, 0
7309, 0.15, 0.87, 0
7310, 0.14166666666667, 0.88, 0
7311, 0.15, 0.89, 0
7312, 0.14166666666667, 0.9, 0
7313, 0.15, 0.91, 0
7314, 0.14166666666667, 0.92, 0
7315, 0.15, 0.93, 0
7316, 0.14166666666667, 0.94, 0
7317, 0.15, 0.95, 0
7318, 0.14166666666667, 0.96, 0
7319, 0.15, 0.97, 0
7320, 0.14166666666667, 0.98, 0
7321, 0.15, 0.99, 0
7322, 0.14166666666667, 1, 0
7323, 0.15, 1.01, 0
7324, 0.14166666666667, 1.02, 0
7325, 0.15, 1.03, 0
7326, 0.14166666666667, 1.04, 0
7327, 0.15, 1.05, 0
7328, 0.14166666666667, 1.06, 0
7329, 0.15, 1.07, 0
7330, 0.14166666666667, 1.08, 0
7331, 0.15, 1.09, 0
7332, 0.14166666666667, 1.1, 0
7333, 0.15, 1.11, 0
7334, 0.14166666666667, 1.12, 0
7335, 0.15, 1.13, 0
7336, 0.14166666666667, 1.14, 0
7337, 0.15, 1.15, 0
7338, 0.14166666666667, 1.16, 0
7339, 0.15, 1.17, 0
7340, 0.14166666666667, 1.18, 0
7341, 0.15, 1.19, 0
7342, 0.16666666666667, 0.01, 0
7343, 0.15833333333333, 0.02, 0
7344, 0.16666666666667, 0.03, 0
7345, 0.15833333333333, 0.04, 0
7346, 0.16666666666667, 0.05, 0
7347, 0.15833333333333, 0.06, 0
7348, 0.16666666666667, 0.07, 0
7349, 0.15833333333333, 0.08, 0
7350, 0.16666666666667, 0.09, 0
7351, 0.15833333333333, 0.1, 0
7352, 0.16666666666667, 0.11, 0
7353, 0.15833333333333, 0.12, 0
7354, 0.16666666666667, 0.13, 0
7355, 0.15833333333333, 0.14, 0
7356, 0.16666666666667, 0.15, 0
7357, 0.15833333333333, 0.16, 0
7358, 0.16666666666667, 0.17, 0
7359, 0.15833333333333, 0.18, 0
7360, 0.16666666666667, 0.19, 0
7361, 0.15833333333333, 0.2, 0
7362, 0.16666666666667, 0.21, 0
7363, 0.15833333333333, 0.22, 0
7364, 0.16666666666667, 0.23, 0
7365, 0.15833333333333, 0.24, 0
7366, 0.16666666666667, 0.25, 0
7367, 0.15833333333333, 0.26, 0
7368, 0.16666666666667, 0.27, 0
7369, 0.15833333333333, 0.28, 0
7370, 0.16666666666667, 0.29, 0
7371, 0.15833333333333, 0.3, 0
7372, 0.16666666666667, 0.31, 0
7373, 0.15833333333333, 0.32, 0
7374, 0.16666666666667, 0.33, 0
7375, 0.15833333333333, 0.34, 0
7376, 0.16666666666667, 0.35, 0
7377, 0.15833333333333, 0.36, 0
7378, 0.16666666666667, 0.37, 0
7379, 0.15833333333333, 0.38, 0
7380, 0.16666666666667, 0.39, 0
7381, 0.15833333333333, 0.4, 0
7382, 0.16666666666667, 0.41, 0
7383, 0.15833333333333, 0.42, 0
7384, 0.16666666666667, 0.43, 0
7385, 0.15833333333333, 0.44, 0
7386, 0.16666666666667, 0.45, 0
7387, 0.15833333333333, 0.46, 0
7388, 0.16666666666667, 0.47, 0
7389, 0.15833333333333, 0.48, 0
7390, 0.16666666666667, 0.49, 0
7391, 0.15833333333333, 0.5, 0
7392, 0.16666666666667, 0.51, 0
7393, 0.15833333333333, 0.52, 0
7394, 0.16666666666667, 0.53, 0
7395, 0.15833333333333, 0.54, 0
7396, 0.16666666666667, 0.55, 0
7397, 0.15833333333333, 0.56, 0
7398, 0.16666666666667, 0.57, 0
7399, 0.15833333333333, 0.58, 0
7400, 0.16666666666667, 0.59, 0
7401, 0.15833333333333, 0.6, 0
7402, 0.16666666666667, 0.61, 0
7403, 0.15833333333333, 0.62, 0
7404, 0.16666666666667, 0.63, 0
7405, 0.15833333333333, 0.64, 0
7406, 0.16666666666667, 0.65, 0
7407, 0.15833333333333, 0.66, 0
7408, 0.16666666666667, 0.67, 0
7409, 0.15833333333333, 0.68, 0
7410, 0.16666666666667, 0.69, 0
7411, 0.15833333333333, 0.7, 0
7412, 0.16666666666667, 0.71, 0
7413, 0.15833333333333, 0.72, 0
7414, 0.16666666666667, 0.73, 0
7415, 0.15833333333333, 0.74, 0
7416, 0.16666666666667, 0.75, 0
7417, 0.15833333333333, 0.76, 0
7418, 0.16666666666667, 0.77, 0
7419, 0.15833333333333, 0.78, 0
7420, 0.16666666666667, 0.79, 0
7421, 0.15833333333333, 0.8, 0
7422, 0.16666666666667, 0.81, 0
7423, 0.15833333333333, 0.82, 0
7424, 0.16666666666667, 0.83, 0
7425, 0.15833333333333, 0.84, 0
7426, 0.16666666666667, 0.85, 0
7427, 0.15833333333333, 0.86, 0
7428, 0.16666666666667, 0.87, 0
