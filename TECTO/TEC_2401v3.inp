27414, 0.05, -0.091666666666667, 0
27415, 0.058333333333333, -0.1, 0
27416, 0.066666666666667, -0.091666666666667, 0
27417, 0.075, -0.1, 0
27418, 0.083333333333333, -0.091666666666667, 0
27419, 0.091666666666667, -0.1, 0
27420, 0.1, -0.091666666666667, 0
27421, 0.10833333333333, -0.1, 0
27422, 0.11666666666667, -0.091666666666667, 0
27423, 0.125, -0.1, 0
27424, 0.13333333333333, -0.091666666666667, 0
27425, 0.14166666666667, -0.1, 0
27426, 0.15, -0.091666666666667, 0
27427, 0.15833333333333, -0.1, 0
27428, 0.16666666666667, -0.091666666666667, 0
27429, 0.175, -0.1, 0
27430, 0.18333333333333, -0.091666666666667, 0
27431, 0.19166666666667, -0.1, 0
27432, 0.2, -0.091666666666667, 0
27433, 0.20833333333333, -0.1, 0
27434, 0.21666666666667, -0.091666666666667, 0
27435, 0.225, -0.1, 0
27436, 0.23333333333333, -0.091666666666667, 0
27437, 0.24166666666667, -0.1, 0
27438, 0.25, -0.091666666666667, 0
27439, 0.25833333333333, -0.1, 0
27440, 0.26666666666667, -0.091666666666667, 0
27441, 0.275, -0.1, 0
27442, 0.28333333333333, -0.091666666666667, 0
27443, 0.29166666666667, -0.1, 0
27444, 0.3, -0.091666666666667, 0
27445, 0.30833333333333, -0.1, 0
27446, 0.31666666666667, -0.091666666666667, 0
27447, 0.325, -0.1, 0
27448, 0.33333333333333, -0.091666666666667, 0
27449, 0.34166666666667, -0.1, 0
27450, 0.35, -0.091666666666667, 0
27451, 0.35833333333333, -0.1, 0
27452, 0.36666666666667, -0.091666666666667, 0
27453, 0.375, -0.1, 0
27454, 0.38333333333333, -0.091666666666667, 0
27455, 0.39166666666667, -0.1, 0
27456, 0.4, -0.091666666666667, 0
27457, 0.40833333333333, -0.1, 0
27458, 0.41666666666667, -0.091666666666667, 0
27459, 0.425, -0.1, 0
27460, 0.43333333333333, -0.091666666666667, 0
27461, 0.44166666666667, -0.1, 0
27462, 0.45, -0.091666666666667, 0
27463, 0.45833333333333, -0.1, 0
27464, 0.46666666666667, -0.091666666666667, 0
27465, 0.475, -0.1, 0
27466, 0.48333333333333, -0.091666666666667, 0
27467, 0.49166666666667, -0.1, 0
27468, 0.5, -0.091666666666667, 0
27469, 0.50833333333333, -0.1, 0
27470, 0.51666666666667, -0.091666666666667, 0
27471, 0.525, -0.1, 0
27472, 0.53333333333333, -0.091666666666667, 0
27473, 0.54166666666667, -0.1, 0
27474, 0.55, -0.091666666666667, 0
27475, 0.55833333333333, -0.1, 0
27476, 0.56666666666667, -0.091666666666667, 0
27477, 0.575, -0.1, 0
27478, 0.58333333333333, -0.091666666666667, 0
27479, 0.59166666666667, -0.1, 0
27480, 0.6, -0.091666666666667, 0
27481, 0.60833333333333, -0.1, 0
27482, 0.61666666666667, -0.091666666666667, 0
27483, 0.625, -0.1, 0
27484, 0.63333333333333, -0.091666666666667, 0
27485, 0.64166666666667, -0.1, 0
27486, 0.65, -0.091666666666667, 0
27487, 0.65833333333333, -0.1, 0
27488, 0.66666666666667, -0.091666666666667, 0
27489, 0.675, -0.1, 0
27490, 0.68333333333333, -0.091666666666667, 0
27491, 0.69166666666667, -0.1, 0
27492, 0.7, -0.091666666666667, 0
27493, 0.70833333333333, -0.1, 0
27494, 0.71666666666667, -0.091666666666667, 0
27495, 0.725, -0.1, 0
27496, 0.73333333333333, -0.091666666666667, 0
27497, 0.74166666666667, -0.1, 0
27498, 0.75, -0.091666666666667, 0
27499, 0.75833333333333, -0.1, 0
27500, 0.76666666666667, -0.091666666666667, 0
27501, 0.775, -0.1, 0
27502, 0.78333333333333, -0.091666666666667, 0
27503, 0.79166666666667, -0.1, 0
27504, 0.8, -0.091666666666667, 0
27505, 0.80833333333333, -0.1, 0
27506, 0.81666666666667, -0.091666666666667, 0
27507, 0.825, -0.1, 0
27508, 0.83333333333333, -0.091666666666667, 0
27509, 0.84166666666667, -0.1, 0
27510, 0.85, -0.091666666666667, 0
27511, 0.85833333333333, -0.1, 0
27512, 0.86666666666667, -0.091666666666667, 0
27513, 0.875, -0.1, 0
27514, 0.88333333333333, -0.091666666666667, 0
27515, 0.89166666666667, -0.1, 0
27516, 0.9, -0.091666666666667, 0
27517, 0.90833333333333, -0.1, 0
27518, 0.91666666666667, -0.091666666666667, 0
27519, 0.925, -0.1, 0
27520, 0.93333333333333, -0.091666666666667, 0
27521, 0.94166666666667, -0.1, 0
27522, 0.95, -0.091666666666667, 0
27523, 0.95833333333333, -0.1, 0
27524, 0.96666666666667, -0.091666666666667, 0
27525, 0.975, -0.1, 0
27526, 0.98333333333333, -0.091666666666667, 0
27527, 0.99166666666667, -0.1, 0
27528, 0.0083333333333333, -0.11666666666667, 0
27529, 0.016666666666667, -0.10833333333333, 0
27530, 0.025, -0.11666666666667, 0
27531, 0.033333333333333, -0.10833333333333, 0
27532, 0.041666666666667, -0.11666666666667, 0
27533, 0.05, -0.10833333333333, 0
27534, 0.058333333333333, -0.11666666666667, 0
27535, 0.066666666666667, -0.10833333333333, 0
27536, 0.075, -0.11666666666667, 0
27537, 0.083333333333333, -0.10833333333333, 0
27538, 0.091666666666667, -0.11666666666667, 0
27539, 0.1, -0.10833333333333, 0
27540, 0.10833333333333, -0.11666666666667, 0
27541, 0.11666666666667, -0.10833333333333, 0
27542, 0.125, -0.11666666666667, 0
27543, 0.13333333333333, -0.10833333333333, 0
27544, 0.14166666666667, -0.11666666666667, 0
27545, 0.15, -0.10833333333333, 0
27546, 0.15833333333333, -0.11666666666667, 0
27547, 0.16666666666667, -0.10833333333333, 0
27548, 0.175, -0.11666666666667, 0
27549, 0.18333333333333, -0.10833333333333, 0
27550, 0.19166666666667, -0.11666666666667, 0
27551, 0.2, -0.10833333333333, 0
27552, 0.20833333333333, -0.11666666666667, 0
27553, 0.21666666666667, -0.10833333333333, 0
27554, 0.225, -0.11666666666667, 0
27555, 0.23333333333333, -0.10833333333333, 0
27556, 0.24166666666667, -0.11666666666667, 0
27557, 0.25, -0.10833333333333, 0
27558, 0.25833333333333, -0.11666666666667, 0
27559, 0.26666666666667, -0.10833333333333, 0
27560, 0.275, -0.11666666666667, 0
27561, 0.28333333333333, -0.10833333333333, 0
27562, 0.29166666666667, -0.11666666666667, 0
27563, 0.3, -0.10833333333333, 0
27564, 0.30833333333333, -0.11666666666667, 0
27565, 0.31666666666667, -0.10833333333333, 0
27566, 0.325, -0.11666666666667, 0
27567, 0.33333333333333, -0.10833333333333, 0
27568, 0.34166666666667, -0.11666666666667, 0
27569, 0.35, -0.10833333333333, 0
27570, 0.35833333333333, -0.11666666666667, 0
27571, 0.36666666666667, -0.10833333333333, 0
27572, 0.375, -0.11666666666667, 0
27573, 0.38333333333333, -0.10833333333333, 0
27574, 0.39166666666667, -0.11666666666667, 0
27575, 0.4, -0.10833333333333, 0
27576, 0.40833333333333, -0.11666666666667, 0
27577, 0.41666666666667, -0.10833333333333, 0
27578, 0.425, -0.11666666666667, 0
27579, 0.43333333333333, -0.10833333333333, 0
27580, 0.44166666666667, -0.11666666666667, 0
27581, 0.45, -0.10833333333333, 0
27582, 0.45833333333333, -0.11666666666667, 0
27583, 0.46666666666667, -0.10833333333333, 0
27584, 0.475, -0.11666666666667, 0
27585, 0.48333333333333, -0.10833333333333, 0
27586, 0.49166666666667, -0.11666666666667, 0
27587, 0.5, -0.10833333333333, 0
27588, 0.50833333333333, -0.11666666666667, 0
27589, 0.51666666666667, -0.10833333333333, 0
27590, 0.525, -0.11666666666667, 0
27591, 0.53333333333333, -0.10833333333333, 0
27592, 0.54166666666667, -0.11666666666667, 0
27593, 0.55, -0.10833333333333, 0
27594, 0.55833333333333, -0.11666666666667, 0
27595, 0.56666666666667, -0.10833333333333, 0
27596, 0.575, -0.11666666666667, 0
27597, 0.58333333333333, -0.10833333333333, 0
27598, 0.59166666666667, -0.11666666666667, 0
27599, 0.6, -0.10833333333333, 0
27600, 0.60833333333333, -0.11666666666667, 0
27601, 0.61666666666667, -0.10833333333333, 0
27602, 0.625, -0.11666666666667, 0
27603, 0.63333333333333, -0.10833333333333, 0
27604, 0.64166666666667, -0.11666666666667, 0
27605, 0.65, -0.10833333333333, 0
27606, 0.65833333333333, -0.11666666666667, 0
27607, 0.66666666666667, -0.10833333333333, 0
27608, 0.675, -0.11666666666667, 0
27609, 0.68333333333333, -0.10833333333333, 0
27610, 0.69166666666667, -0.11666666666667, 0
27611, 0.7, -0.10833333333333, 0
27612, 0.70833333333333, -0.11666666666667, 0
27613, 0.71666666666667, -0.10833333333333, 0
27614, 0.725, -0.11666666666667, 0
27615, 0.73333333333333, -0.10833333333333, 0
27616, 0.74166666666667, -0.11666666666667, 0
27617, 0.75, -0.10833333333333, 0
27618, 0.75833333333333, -0.11666666666667, 0
27619, 0.76666666666667, -0.10833333333333, 0
27620, 0.775, -0.11666666666667, 0
27621, 0.78333333333333, -0.10833333333333, 0
27622, 0.79166666666667, -0.11666666666667, 0
27623, 0.8, -0.10833333333333, 0
27624, 0.80833333333333, -0.11666666666667, 0
27625, 0.81666666666667, -0.10833333333333, 0
27626, 0.825, -0.11666666666667, 0
27627, 0.83333333333333, -0.10833333333333, 0
27628, 0.84166666666667, -0.11666666666667, 0
27629, 0.85, -0.10833333333333, 0
27630, 0.85833333333333, -0.11666666666667, 0
27631, 0.86666666666667, -0.10833333333333, 0
27632, 0.875, -0.11666666666667, 0
27633, 0.88333333333333, -0.10833333333333, 0
27634, 0.89166666666667, -0.11666666666667, 0
27635, 0.9, -0.10833333333333, 0
27636, 0.90833333333333, -0.11666666666667, 0
27637, 0.91666666666667, -0.10833333333333, 0
27638, 0.925, -0.11666666666667, 0
27639, 0.93333333333333, -0.10833333333333, 0
27640, 0.94166666666667, -0.11666666666667, 0
27641, 0.95, -0.10833333333333, 0
27642, 0.95833333333333, -0.11666666666667, 0
27643, 0.96666666666667, -0.10833333333333, 0
27644, 0.975, -0.11666666666667, 0
27645, 0.98333333333333, -0.10833333333333, 0
27646, 0.99166666666667, -0.11666666666667, 0
27647, 0.0083333333333333, -0.13333333333333, 0
27648, 0.016666666666667, -0.125, 0
27649, 0.025, -0.13333333333333, 0
27650, 0.033333333333333, -0.125, 0
27651, 0.041666666666667, -0.13333333333333, 0
27652, 0.05, -0.125, 0
27653, 0.058333333333333, -0.13333333333333, 0
27654, 0.066666666666667, -0.125, 0
27655, 0.075, -0.13333333333333, 0
27656, 0.083333333333333, -0.125, 0
27657, 0.091666666666667, -0.13333333333333, 0
27658, 0.1, -0.125, 0
27659, 0.10833333333333, -0.13333333333333, 0
27660, 0.11666666666667, -0.125, 0
27661, 0.125, -0.13333333333333, 0
27662, 0.13333333333333, -0.125, 0
27663, 0.14166666666667, -0.13333333333333, 0
27664, 0.15, -0.125, 0
27665, 0.15833333333333, -0.13333333333333, 0
27666, 0.16666666666667, -0.125, 0
27667, 0.175, -0.13333333333333, 0
27668, 0.18333333333333, -0.125, 0
27669, 0.19166666666667, -0.13333333333333, 0
27670, 0.2, -0.125, 0
27671, 0.20833333333333, -0.13333333333333, 0
27672, 0.21666666666667, -0.125, 0
27673, 0.225, -0.13333333333333, 0
27674, 0.23333333333333, -0.125, 0
27675, 0.24166666666667, -0.13333333333333, 0
27676, 0.25, -0.125, 0
27677, 0.25833333333333, -0.13333333333333, 0
27678, 0.26666666666667, -0.125, 0
27679, 0.275, -0.13333333333333, 0
27680, 0.28333333333333, -0.125, 0
27681, 0.29166666666667, -0.13333333333333, 0
27682, 0.3, -0.125, 0
27683, 0.30833333333333, -0.13333333333333, 0
27684, 0.31666666666667, -0.125, 0
27685, 0.325, -0.13333333333333, 0
27686, 0.33333333333333, -0.125, 0
27687, 0.34166666666667, -0.13333333333333, 0
27688, 0.35, -0.125, 0
27689, 0.35833333333333, -0.13333333333333, 0
27690, 0.36666666666667, -0.125, 0
27691, 0.375, -0.13333333333333, 0
27692, 0.38333333333333, -0.125, 0
27693, 0.39166666666667, -0.13333333333333, 0
27694, 0.4, -0.125, 0
27695, 0.40833333333333, -0.13333333333333, 0
27696, 0.41666666666667, -0.125, 0
27697, 0.425, -0.13333333333333, 0
27698, 0.43333333333333, -0.125, 0
27699, 0.44166666666667, -0.13333333333333, 0
27700, 0.45, -0.125, 0
27701, 0.45833333333333, -0.13333333333333, 0
27702, 0.46666666666667, -0.125, 0
27703, 0.475, -0.13333333333333, 0
27704, 0.48333333333333, -0.125, 0
27705, 0.49166666666667, -0.13333333333333, 0
27706, 0.5, -0.125, 0
27707, 0.50833333333333, -0.13333333333333, 0
27708, 0.51666666666667, -0.125, 0
27709, 0.525, -0.13333333333333, 0
27710, 0.53333333333333, -0.125, 0
27711, 0.54166666666667, -0.13333333333333, 0
27712, 0.55, -0.125, 0
27713, 0.55833333333333, -0.13333333333333, 0
27714, 0.56666666666667, -0.125, 0
27715, 0.575, -0.13333333333333, 0
27716, 0.58333333333333, -0.125, 0
27717, 0.59166666666667, -0.13333333333333, 0
27718, 0.6, -0.125, 0
27719, 0.60833333333333, -0.13333333333333, 0
27720, 0.61666666666667, -0.125, 0
27721, 0.625, -0.13333333333333, 0
27722, 0.63333333333333, -0.125, 0
27723, 0.64166666666667, -0.13333333333333, 0
27724, 0.65, -0.125, 0
27725, 0.65833333333333, -0.13333333333333, 0
27726, 0.66666666666667, -0.125, 0
27727, 0.675, -0.13333333333333, 0
27728, 0.68333333333333, -0.125, 0
27729, 0.69166666666667, -0.13333333333333, 0
27730, 0.7, -0.125, 0
27731, 0.70833333333333, -0.13333333333333, 0
27732, 0.71666666666667, -0.125, 0
27733, 0.725, -0.13333333333333, 0
27734, 0.73333333333333, -0.125, 0
27735, 0.74166666666667, -0.13333333333333, 0
27736, 0.75, -0.125, 0
27737, 0.75833333333333, -0.13333333333333, 0
27738, 0.76666666666667, -0.125, 0
27739, 0.775, -0.13333333333333, 0
27740, 0.78333333333333, -0.125, 0
27741, 0.79166666666667, -0.13333333333333, 0
27742, 0.8, -0.125, 0
27743, 0.80833333333333, -0.13333333333333, 0
27744, 0.81666666666667, -0.125, 0
27745, 0.825, -0.13333333333333, 0
27746, 0.83333333333333, -0.125, 0
27747, 0.84166666666667, -0.13333333333333, 0
27748, 0.85, -0.125, 0
27749, 0.85833333333333, -0.13333333333333, 0
27750, 0.86666666666667, -0.125, 0
27751, 0.875, -0.13333333333333, 0
27752, 0.88333333333333, -0.125, 0
27753, 0.89166666666667, -0.13333333333333, 0
27754, 0.9, -0.125, 0
27755, 0.90833333333333, -0.13333333333333, 0
27756, 0.91666666666667, -0.125, 0
27757, 0.925, -0.13333333333333, 0
27758, 0.93333333333333, -0.125, 0
27759, 0.94166666666667, -0.13333333333333, 0
27760, 0.95, -0.125, 0
27761, 0.95833333333333, -0.13333333333333, 0
27762, 0.96666666666667, -0.125, 0
27763, 0.975, -0.13333333333333, 0
27764, 0.98333333333333, -0.125, 0
27765, 0.99166666666667, -0.13333333333333, 0
27766, 0.016666666666667, -0.14166666666667, 0
27767, 0.033333333333333, -0.14166666666667, 0
27768, 0.05, -0.14166666666667, 0
27769, 0.066666666666667, -0.14166666666667, 0
27770, 0.083333333333333, -0.14166666666667, 0
27771, 0.1, -0.14166666666667, 0
27772, 0.11666666666667, -0.14166666666667, 0
27773, 0.13333333333333, -0.14166666666667, 0
27774, 0.15, -0.14166666666667, 0
27775, 0.16666666666667, -0.14166666666667, 0
27776, 0.18333333333333, -0.14166666666667, 0
27777, 0.2, -0.14166666666667, 0
27778, 0.21666666666667, -0.14166666666667, 0
27779, 0.23333333333333, -0.14166666666667, 0
27780, 0.25, -0.14166666666667, 0
27781, 0.26666666666667, -0.14166666666667, 0
27782, 0.28333333333333, -0.14166666666667, 0
27783, 0.3, -0.14166666666667, 0
27784, 0.31666666666667, -0.14166666666667, 0
27785, 0.33333333333333, -0.14166666666667, 0
27786, 0.35, -0.14166666666667, 0
27787, 0.36666666666667, -0.14166666666667, 0
27788, 0.38333333333333, -0.14166666666667, 0
27789, 0.4, -0.14166666666667, 0
27790, 0.41666666666667, -0.14166666666667, 0
27791, 0.43333333333333, -0.14166666666667, 0
27792, 0.45, -0.14166666666667, 0
27793, 0.46666666666667, -0.14166666666667, 0
27794, 0.48333333333333, -0.14166666666667, 0
27795, 0.5, -0.14166666666667, 0
27796, 0.51666666666667, -0.14166666666667, 0
27797, 0.53333333333333, -0.14166666666667, 0
27798, 0.55, -0.14166666666667, 0
27799, 0.56666666666667, -0.14166666666667, 0
27800, 0.58333333333333, -0.14166666666667, 0
27801, 0.6, -0.14166666666667, 0
27802, 0.61666666666667, -0.14166666666667, 0
27803, 0.63333333333333, -0.14166666666667, 0
27804, 0.65, -0.14166666666667, 0
27805, 0.66666666666667, -0.14166666666667, 0
27806, 0.68333333333333, -0.14166666666667, 0
27807, 0.7, -0.14166666666667, 0
27808, 0.71666666666667, -0.14166666666667, 0
27809, 0.73333333333333, -0.14166666666667, 0
27810, 0.75, -0.14166666666667, 0
27811, 0.76666666666667, -0.14166666666667, 0
27812, 0.78333333333333, -0.14166666666667, 0
27813, 0.8, -0.14166666666667, 0
27814, 0.81666666666667, -0.14166666666667, 0
27815, 0.83333333333333, -0.14166666666667, 0
27816, 0.85, -0.14166666666667, 0
27817, 0.86666666666667, -0.14166666666667, 0
27818, 0.88333333333333, -0.14166666666667, 0
27819, 0.9, -0.14166666666667, 0
27820, 0.91666666666667, -0.14166666666667, 0
27821, 0.93333333333333, -0.14166666666667, 0
27822, 0.95, -0.14166666666667, 0
27823, 0.96666666666667, -0.14166666666667, 0
27824, 0.98333333333333, -0.14166666666667, 0
27825, -0.033333333333333, -0.066666666666667, 0
27826, -0.033333333333333, -0.083333333333333, 0
27827, -0.033333333333333, -0.1, 0
27828, -0.033333333333333, -0.11666666666667, 0
27829, -0.033333333333333, -0.13333333333333, 0
27830, -0.066666666666667, -0.066666666666667, 0
27831, -0.066666666666667, -0.083333333333333, 0
27832, -0.066666666666667, -0.1, 0
27833, -0.066666666666667, -0.11666666666667, 0
27834, -0.066666666666667, -0.13333333333333, 0
27835, -0.033333333333333, -0.058333333333333, 0
27836, -0.016666666666667, -0.066666666666667, 0
27837, -0.033333333333333, -0.075, 0
27838, -0.016666666666667, -0.083333333333333, 0
27839, -0.033333333333333, -0.091666666666667, 0
27840, -0.016666666666667, -0.1, 0
27841, -0.033333333333333, -0.10833333333333, 0
27842, -0.016666666666667, -0.11666666666667, 0
27843, -0.033333333333333, -0.125, 0
27844, -0.016666666666667, -0.13333333333333, 0
27845, -0.033333333333333, -0.14166666666667, 0
27846, -0.066666666666667, -0.058333333333333, 0
27847, -0.05, -0.066666666666667, 0
27848, -0.066666666666667, -0.075, 0
27849, -0.05, -0.083333333333333, 0
27850, -0.066666666666667, -0.091666666666667, 0
27851, -0.05, -0.1, 0
27852, -0.066666666666667, -0.10833333333333, 0
27853, -0.05, -0.11666666666667, 0
27854, -0.066666666666667, -0.125, 0
27855, -0.05, -0.13333333333333, 0
27856, -0.066666666666667, -0.14166666666667, 0
27857, -0.083333333333333, -0.066666666666667, 0
27858, -0.083333333333333, -0.083333333333333, 0
27859, -0.083333333333333, -0.1, 0
27860, -0.083333333333333, -0.11666666666667, 0
27861, -0.083333333333333, -0.13333333333333, 0
27862, 0.016666666666667, -0.19, 0
27863, 0.033333333333333, -0.19, 0
27864, 0.05, -0.19, 0
27865, 0.066666666666667, -0.19, 0
27866, 0.083333333333333, -0.19, 0
27867, 0.1, -0.19, 0
27868, 0.11666666666667, -0.19, 0
27869, 0.13333333333333, -0.19, 0
27870, 0.15, -0.19, 0
27871, 0.16666666666667, -0.19, 0
27872, 0.18333333333333, -0.19, 0
27873, 0.2, -0.19, 0
27874, 0.21666666666667, -0.19, 0
27875, 0.23333333333333, -0.19, 0
27876, 0.25, -0.19, 0
27877, 0.26666666666667, -0.19, 0
27878, 0.28333333333333, -0.19, 0
27879, 0.3, -0.19, 0
27880, 0.31666666666667, -0.19, 0
27881, 0.33333333333333, -0.19, 0
27882, 0.35, -0.19, 0
27883, 0.36666666666667, -0.19, 0
27884, 0.38333333333333, -0.19, 0
27885, 0.4, -0.19, 0
27886, 0.41666666666667, -0.19, 0
27887, 0.43333333333333, -0.19, 0
27888, 0.45, -0.19, 0
27889, 0.46666666666667, -0.19, 0
27890, 0.48333333333333, -0.19, 0
27891, 0.5, -0.19, 0
27892, 0.51666666666667, -0.19, 0
27893, 0.53333333333333, -0.19, 0
27894, 0.55, -0.19, 0
27895, 0.56666666666667, -0.19, 0
27896, 0.58333333333333, -0.19, 0
27897, 0.6, -0.19, 0
27898, 0.61666666666667, -0.19, 0
27899, 0.63333333333333, -0.19, 0
27900, 0.65, -0.19, 0
27901, 0.66666666666667, -0.19, 0
27902, 0.68333333333333, -0.19, 0
27903, 0.7, -0.19, 0
27904, 0.71666666666667, -0.19, 0
27905, 0.73333333333333, -0.19, 0
27906, 0.75, -0.19, 0
27907, 0.76666666666667, -0.19, 0
27908, 0.78333333333333, -0.19, 0
27909, 0.8, -0.19, 0
27910, 0.81666666666667, -0.19, 0
27911, 0.83333333333333, -0.19, 0
27912, 0.85, -0.19, 0
27913, 0.86666666666667, -0.19, 0
27914, 0.88333333333333, -0.19, 0
27915, 0.9, -0.19, 0
27916, 0.91666666666667, -0.19, 0
27917, 0.93333333333333, -0.19, 0
27918, 0.95, -0.19, 0
27919, 0.96666666666667, -0.19, 0
27920, 0.98333333333333, -0.19, 0
27921, 0.016666666666667, -0.23, 0
27922, 0.033333333333333, -0.23, 0
27923, 0.05, -0.23, 0
27924, 0.066666666666667, -0.23, 0
27925, 0.083333333333333, -0.23, 0
27926, 0.1, -0.23, 0
27927, 0.11666666666667, -0.23, 0
27928, 0.13333333333333, -0.23, 0
27929, 0.15, -0.23, 0
27930, 0.16666666666667, -0.23, 0
27931, 0.18333333333333, -0.23, 0
27932, 0.2, -0.23, 0
27933, 0.21666666666667, -0.23, 0
27934, 0.23333333333333, -0.23, 0
27935, 0.25, -0.23, 0
27936, 0.26666666666667, -0.23, 0
27937, 0.28333333333333, -0.23, 0
27938, 0.3, -0.23, 0
27939, 0.31666666666667, -0.23, 0
27940, 0.33333333333333, -0.23, 0
27941, 0.35, -0.23, 0
27942, 0.36666666666667, -0.23, 0
27943, 0.38333333333333, -0.23, 0
27944, 0.4, -0.23, 0
27945, 0.41666666666667, -0.23, 0
27946, 0.43333333333333, -0.23, 0
27947, 0.45, -0.23, 0
27948, 0.46666666666667, -0.23, 0
27949, 0.48333333333333, -0.23, 0
27950, 0.5, -0.23, 0
27951, 0.51666666666667, -0.23, 0
27952, 0.53333333333333, -0.23, 0
27953, 0.55, -0.23, 0
27954, 0.56666666666667, -0.23, 0
27955, 0.58333333333333, -0.23, 0
27956, 0.6, -0.23, 0
27957, 0.61666666666667, -0.23, 0
27958, 0.63333333333333, -0.23, 0
27959, 0.65, -0.23, 0
27960, 0.66666666666667, -0.23, 0
27961, 0.68333333333333, -0.23, 0
27962, 0.7, -0.23, 0
27963, 0.71666666666667, -0.23, 0
27964, 0.73333333333333, -0.23, 0
27965, 0.75, -0.23, 0
27966, 0.76666666666667, -0.23, 0
27967, 0.78333333333333, -0.23, 0
27968, 0.8, -0.23, 0
27969, 0.81666666666667, -0.23, 0
27970, 0.83333333333333, -0.23, 0
27971, 0.85, -0.23, 0
27972, 0.86666666666667, -0.23, 0
27973, 0.88333333333333, -0.23, 0
27974, 0.9, -0.23, 0
27975, 0.91666666666667, -0.23, 0
27976, 0.93333333333333, -0.23, 0
27977, 0.95, -0.23, 0
27978, 0.96666666666667, -0.23, 0
27979, 0.98333333333333, -0.23, 0
27980, 0.016666666666667, -0.27, 0
27981, 0.033333333333333, -0.27, 0
27982, 0.05, -0.27, 0
27983, 0.066666666666667, -0.27, 0
27984, 0.083333333333333, -0.27, 0
27985, 0.1, -0.27, 0
27986, 0.11666666666667, -0.27, 0
27987, 0.13333333333333, -0.27, 0
27988, 0.15, -0.27, 0
27989, 0.16666666666667, -0.27, 0
27990, 0.18333333333333, -0.27, 0
27991, 0.2, -0.27, 0
27992, 0.21666666666667, -0.27, 0
27993, 0.23333333333333, -0.27, 0
27994, 0.25, -0.27, 0
27995, 0.26666666666667, -0.27, 0
27996, 0.28333333333333, -0.27, 0
27997, 0.3, -0.27, 0
27998, 0.31666666666667, -0.27, 0
27999, 0.33333333333333, -0.27, 0
28000, 0.35, -0.27, 0
28001, 0.36666666666667, -0.27, 0
28002, 0.38333333333333, -0.27, 0
28003, 0.4, -0.27, 0
28004, 0.41666666666667, -0.27, 0
28005, 0.43333333333333, -0.27, 0
28006, 0.45, -0.27, 0
28007, 0.46666666666667, -0.27, 0
28008, 0.48333333333333, -0.27, 0
28009, 0.5, -0.27, 0
28010, 0.51666666666667, -0.27, 0
28011, 0.53333333333333, -0.27, 0
28012, 0.55, -0.27, 0
28013, 0.56666666666667, -0.27, 0
28014, 0.58333333333333, -0.27, 0
28015, 0.6, -0.27, 0
28016, 0.61666666666667, -0.27, 0
28017, 0.63333333333333, -0.27, 0
28018, 0.65, -0.27, 0
28019, 0.66666666666667, -0.27, 0
28020, 0.68333333333333, -0.27, 0
28021, 0.7, -0.27, 0
28022, 0.71666666666667, -0.27, 0
28023, 0.73333333333333, -0.27, 0
28024, 0.75, -0.27, 0
28025, 0.76666666666667, -0.27, 0
28026, 0.78333333333333, -0.27, 0
28027, 0.8, -0.27, 0
28028, 0.81666666666667, -0.27, 0
28029, 0.83333333333333, -0.27, 0
28030, 0.85, -0.27, 0
28031, 0.86666666666667, -0.27, 0
28032, 0.88333333333333, -0.27, 0
28033, 0.9, -0.27, 0
28034, 0.91666666666667, -0.27, 0
28035, 0.93333333333333, -0.27, 0
28036, 0.95, -0.27, 0
28037, 0.96666666666667, -0.27, 0
28038, 0.98333333333333, -0.27, 0
28039, 0.016666666666667, -0.31, 0
28040, 0.033333333333333, -0.31, 0
28041, 0.05, -0.31, 0
28042, 0.066666666666667, -0.31, 0
28043, 0.083333333333333, -0.31, 0
28044, 0.1, -0.31, 0
28045, 0.11666666666667, -0.31, 0
28046, 0.13333333333333, -0.31, 0
28047, 0.15, -0.31, 0
28048, 0.16666666666667, -0.31, 0
28049, 0.18333333333333, -0.31, 0
28050, 0.2, -0.31, 0
28051, 0.21666666666667, -0.31, 0
28052, 0.23333333333333, -0.31, 0
28053, 0.25, -0.31, 0
28054, 0.26666666666667, -0.31, 0
28055, 0.28333333333333, -0.31, 0
28056, 0.3, -0.31, 0
28057, 0.31666666666667, -0.31, 0
28058, 0.33333333333333, -0.31, 0
28059, 0.35, -0.31, 0
28060, 0.36666666666667, -0.31, 0
28061, 0.38333333333333, -0.31, 0
28062, 0.4, -0.31, 0
28063, 0.41666666666667, -0.31, 0
28064, 0.43333333333333, -0.31, 0
28065, 0.45, -0.31, 0
28066, 0.46666666666667, -0.31, 0
28067, 0.48333333333333, -0.31, 0
28068, 0.5, -0.31, 0
28069, 0.51666666666667, -0.31, 0
28070, 0.53333333333333, -0.31, 0
28071, 0.55, -0.31, 0
28072, 0.56666666666667, -0.31, 0
28073, 0.58333333333333, -0.31, 0
28074, 0.6, -0.31, 0
28075, 0.61666666666667, -0.31, 0
28076, 0.63333333333333, -0.31, 0
28077, 0.65, -0.31, 0
28078, 0.66666666666667, -0.31, 0
28079, 0.68333333333333, -0.31, 0
28080, 0.7, -0.31, 0
28081, 0.71666666666667, -0.31, 0
28082, 0.73333333333333, -0.31, 0
28083, 0.75, -0.31, 0
28084, 0.76666666666667, -0.31, 0
28085, 0.78333333333333, -0.31, 0
28086, 0.8, -0.31, 0
28087, 0.81666666666667, -0.31, 0
28088, 0.83333333333333, -0.31, 0
28089, 0.85, -0.31, 0
28090, 0.86666666666667, -0.31, 0
28091, 0.88333333333333, -0.31, 0
28092, 0.9, -0.31, 0
28093, 0.91666666666667, -0.31, 0
28094, 0.93333333333333, -0.31, 0
28095, 0.95, -0.31, 0
28096, 0.96666666666667, -0.31, 0
28097, 0.98333333333333, -0.31, 0
28098, 0.0083333333333333, -0.19, 0
28099, 0.016666666666667, -0.17, 0
28100, 0.025, -0.19, 0
28101, 0.033333333333333, -0.17, 0
28102, 0.041666666666667, -0.19, 0
28103, 0.05, -0.17, 0
28104, 0.058333333333333, -0.19, 0
28105, 0.066666666666667, -0.17, 0
28106, 0.075, -0.19, 0
28107, 0.083333333333333, -0.17, 0
28108, 0.091666666666667, -0.19, 0
28109, 0.1, -0.17, 0
28110, 0.10833333333333, -0.19, 0
28111, 0.11666666666667, -0.17, 0
28112, 0.125, -0.19, 0
28113, 0.13333333333333, -0.17, 0
28114, 0.14166666666667, -0.19, 0
28115, 0.15, -0.17, 0
28116, 0.15833333333333, -0.19, 0
28117, 0.16666666666667, -0.17, 0
28118, 0.175, -0.19, 0
28119, 0.18333333333333, -0.17, 0
28120, 0.19166666666667, -0.19, 0
28121, 0.2, -0.17, 0
28122, 0.20833333333333, -0.19, 0
28123, 0.21666666666667, -0.17, 0
28124, 0.225, -0.19, 0
28125, 0.23333333333333, -0.17, 0
28126, 0.24166666666667, -0.19, 0
28127, 0.25, -0.17, 0
28128, 0.25833333333333, -0.19, 0
28129, 0.26666666666667, -0.17, 0
28130, 0.275, -0.19, 0
28131, 0.28333333333333, -0.17, 0
28132, 0.29166666666667, -0.19, 0
28133, 0.3, -0.17, 0
28134, 0.30833333333333, -0.19, 0
28135, 0.31666666666667, -0.17, 0
28136, 0.325, -0.19, 0
28137, 0.33333333333333, -0.17, 0
28138, 0.34166666666667, -0.19, 0
28139, 0.35, -0.17, 0
28140, 0.35833333333333, -0.19, 0
28141, 0.36666666666667, -0.17, 0
28142, 0.375, -0.19, 0
28143, 0.38333333333333, -0.17, 0
28144, 0.39166666666667, -0.19, 0
28145, 0.4, -0.17, 0
28146, 0.40833333333333, -0.19, 0
28147, 0.41666666666667, -0.17, 0
28148, 0.425, -0.19, 0
28149, 0.43333333333333, -0.17, 0
28150, 0.44166666666667, -0.19, 0
28151, 0.45, -0.17, 0
28152, 0.45833333333333, -0.19, 0
28153, 0.46666666666667, -0.17, 0
28154, 0.475, -0.19, 0
28155, 0.48333333333333, -0.17, 0
28156, 0.49166666666667, -0.19, 0
28157, 0.5, -0.17, 0
28158, 0.50833333333333, -0.19, 0
28159, 0.51666666666667, -0.17, 0
28160, 0.525, -0.19, 0
28161, 0.53333333333333, -0.17, 0
28162, 0.54166666666667, -0.19, 0
28163, 0.55, -0.17, 0
28164, 0.55833333333333, -0.19, 0
28165, 0.56666666666667, -0.17, 0
28166, 0.575, -0.19, 0
28167, 0.58333333333333, -0.17, 0
28168, 0.59166666666667, -0.19, 0
28169, 0.6, -0.17, 0
28170, 0.60833333333333, -0.19, 0
28171, 0.61666666666667, -0.17, 0
28172, 0.625, -0.19, 0
28173, 0.63333333333333, -0.17, 0
28174, 0.64166666666667, -0.19, 0
28175, 0.65, -0.17, 0
28176, 0.65833333333333, -0.19, 0
28177, 0.66666666666667, -0.17, 0
28178, 0.675, -0.19, 0
28179, 0.68333333333333, -0.17, 0
28180, 0.69166666666667, -0.19, 0
28181, 0.7, -0.17, 0
28182, 0.70833333333333, -0.19, 0
28183, 0.71666666666667, -0.17, 0
28184, 0.725, -0.19, 0
28185, 0.73333333333333, -0.17, 0
28186, 0.74166666666667, -0.19, 0
28187, 0.75, -0.17, 0
28188, 0.75833333333333, -0.19, 0
28189, 0.76666666666667, -0.17, 0
28190, 0.775, -0.19, 0
28191, 0.78333333333333, -0.17, 0
28192, 0.79166666666667, -0.19, 0
28193, 0.8, -0.17, 0
28194, 0.80833333333333, -0.19, 0
28195, 0.81666666666667, -0.17, 0
28196, 0.825, -0.19, 0
28197, 0.83333333333333, -0.17, 0
28198, 0.84166666666667, -0.19, 0
28199, 0.85, -0.17, 0
28200, 0.85833333333333, -0.19, 0
28201, 0.86666666666667, -0.17, 0
28202, 0.875, -0.19, 0
28203, 0.88333333333333, -0.17, 0
28204, 0.89166666666667, -0.19, 0
28205, 0.9, -0.17, 0
28206, 0.90833333333333, -0.19, 0
28207, 0.91666666666667, -0.17, 0
28208, 0.925, -0.19, 0
28209, 0.93333333333333, -0.17, 0
28210, 0.94166666666667, -0.19, 0
28211, 0.95, -0.17, 0
28212, 0.95833333333333, -0.19, 0
28213, 0.96666666666667, -0.17, 0
28214, 0.975, -0.19, 0
28215, 0.98333333333333, -0.17, 0
28216, 0.99166666666667, -0.19, 0
28217, 0.0083333333333333, -0.23, 0
28218, 0.016666666666667, -0.21, 0
28219, 0.025, -0.23, 0
28220, 0.033333333333333, -0.21, 0
28221, 0.041666666666667, -0.23, 0
28222, 0.05, -0.21, 0
28223, 0.058333333333333, -0.23, 0
28224, 0.066666666666667, -0.21, 0
28225, 0.075, -0.23, 0
28226, 0.083333333333333, -0.21, 0
28227, 0.091666666666667, -0.23, 0
28228, 0.1, -0.21, 0
28229, 0.10833333333333, -0.23, 0
28230, 0.11666666666667, -0.21, 0
28231, 0.125, -0.23, 0
28232, 0.13333333333333, -0.21, 0
28233, 0.14166666666667, -0.23, 0
28234, 0.15, -0.21, 0
28235, 0.15833333333333, -0.23, 0
28236, 0.16666666666667, -0.21, 0
28237, 0.175, -0.23, 0
28238, 0.18333333333333, -0.21, 0
28239, 0.19166666666667, -0.23, 0
28240, 0.2, -0.21, 0
28241, 0.20833333333333, -0.23, 0
28242, 0.21666666666667, -0.21, 0
28243, 0.225, -0.23, 0
28244, 0.23333333333333, -0.21, 0
28245, 0.24166666666667, -0.23, 0
28246, 0.25, -0.21, 0
28247, 0.25833333333333, -0.23, 0
28248, 0.26666666666667, -0.21, 0
28249, 0.275, -0.23, 0
28250, 0.28333333333333, -0.21, 0
28251, 0.29166666666667, -0.23, 0
28252, 0.3, -0.21, 0
28253, 0.30833333333333, -0.23, 0
28254, 0.31666666666667, -0.21, 0
28255, 0.325, -0.23, 0
28256, 0.33333333333333, -0.21, 0
28257, 0.34166666666667, -0.23, 0
28258, 0.35, -0.21, 0
28259, 0.35833333333333, -0.23, 0
28260, 0.36666666666667, -0.21, 0
28261, 0.375, -0.23, 0
28262, 0.38333333333333, -0.21, 0
28263, 0.39166666666667, -0.23, 0
28264, 0.4, -0.21, 0
28265, 0.40833333333333, -0.23, 0
28266, 0.41666666666667, -0.21, 0
28267, 0.425, -0.23, 0
28268, 0.43333333333333, -0.21, 0
28269, 0.44166666666667, -0.23, 0
28270, 0.45, -0.21, 0
28271, 0.45833333333333, -0.23, 0
28272, 0.46666666666667, -0.21, 0
28273, 0.475, -0.23, 0
28274, 0.48333333333333, -0.21, 0
28275, 0.49166666666667, -0.23, 0
28276, 0.5, -0.21, 0
28277, 0.50833333333333, -0.23, 0
28278, 0.51666666666667, -0.21, 0
28279, 0.525, -0.23, 0
28280, 0.53333333333333, -0.21, 0
28281, 0.54166666666667, -0.23, 0
28282, 0.55, -0.21, 0
28283, 0.55833333333333, -0.23, 0
28284, 0.56666666666667, -0.21, 0
28285, 0.575, -0.23, 0
28286, 0.58333333333333, -0.21, 0
28287, 0.59166666666667, -0.23, 0
28288, 0.6, -0.21, 0
28289, 0.60833333333333, -0.23, 0
28290, 0.61666666666667, -0.21, 0
28291, 0.625, -0.23, 0
28292, 0.63333333333333, -0.21, 0
28293, 0.64166666666667, -0.23, 0
28294, 0.65, -0.21, 0
28295, 0.65833333333333, -0.23, 0
28296, 0.66666666666667, -0.21, 0
28297, 0.675, -0.23, 0
28298, 0.68333333333333, -0.21, 0
28299, 0.69166666666667, -0.23, 0
28300, 0.7, -0.21, 0
28301, 0.70833333333333, -0.23, 0
28302, 0.71666666666667, -0.21, 0
28303, 0.725, -0.23, 0
28304, 0.73333333333333, -0.21, 0
28305, 0.74166666666667, -0.23, 0
28306, 0.75, -0.21, 0
28307, 0.75833333333333, -0.23, 0
28308, 0.76666666666667, -0.21, 0
28309, 0.775, -0.23, 0
28310, 0.78333333333333, -0.21, 0
28311, 0.79166666666667, -0.23, 0
28312, 0.8, -0.21, 0
28313, 0.80833333333333, -0.23, 0
28314, 0.81666666666667, -0.21, 0
28315, 0.825, -0.23, 0
28316, 0.83333333333333, -0.21, 0
28317, 0.84166666666667, -0.23, 0
28318, 0.85, -0.21, 0
28319, 0.85833333333333, -0.23, 0
28320, 0.86666666666667, -0.21, 0
28321, 0.875, -0.23, 0
28322, 0.88333333333333, -0.21, 0
28323, 0.89166666666667, -0.23, 0
28324, 0.9, -0.21, 0
28325, 0.90833333333333, -0.23, 0
28326, 0.91666666666667, -0.21, 0
28327, 0.925, -0.23, 0
28328, 0.93333333333333, -0.21, 0
28329, 0.94166666666667, -0.23, 0
28330, 0.95, -0.21, 0
28331, 0.95833333333333, -0.23, 0
28332, 0.96666666666667, -0.21, 0
28333, 0.975, -0.23, 0
28334, 0.98333333333333, -0.21, 0
28335, 0.99166666666667, -0.23, 0
28336, 0.0083333333333333, -0.27, 0
28337, 0.016666666666667, -0.25, 0
28338, 0.025, -0.27, 0
28339, 0.033333333333333, -0.25, 0
28340, 0.041666666666667, -0.27, 0
28341, 0.05, -0.25, 0
28342, 0.058333333333333, -0.27, 0
28343, 0.066666666666667, -0.25, 0
28344, 0.075, -0.27, 0
28345, 0.083333333333333, -0.25, 0
28346, 0.091666666666667, -0.27, 0
28347, 0.1, -0.25, 0
28348, 0.10833333333333, -0.27, 0
28349, 0.11666666666667, -0.25, 0
28350, 0.125, -0.27, 0
28351, 0.13333333333333, -0.25, 0
28352, 0.14166666666667, -0.27, 0
28353, 0.15, -0.25, 0
28354, 0.15833333333333, -0.27, 0
28355, 0.16666666666667, -0.25, 0
28356, 0.175, -0.27, 0
28357, 0.18333333333333, -0.25, 0
28358, 0.19166666666667, -0.27, 0
28359, 0.2, -0.25, 0
28360, 0.20833333333333, -0.27, 0
28361, 0.21666666666667, -0.25, 0
28362, 0.225, -0.27, 0
28363, 0.23333333333333, -0.25, 0
28364, 0.24166666666667, -0.27, 0
28365, 0.25, -0.25, 0
28366, 0.25833333333333, -0.27, 0
28367, 0.26666666666667, -0.25, 0
28368, 0.275, -0.27, 0
28369, 0.28333333333333, -0.25, 0
28370, 0.29166666666667, -0.27, 0
28371, 0.3, -0.25, 0
28372, 0.30833333333333, -0.27, 0
28373, 0.31666666666667, -0.25, 0
28374, 0.325, -0.27, 0
28375, 0.33333333333333, -0.25, 0
28376, 0.34166666666667, -0.27, 0
28377, 0.35, -0.25, 0
28378, 0.35833333333333, -0.27, 0
28379, 0.36666666666667, -0.25, 0
28380, 0.375, -0.27, 0
28381, 0.38333333333333, -0.25, 0
28382, 0.39166666666667, -0.27, 0
28383, 0.4, -0.25, 0
28384, 0.40833333333333, -0.27, 0
28385, 0.41666666666667, -0.25, 0
28386, 0.425, -0.27, 0
28387, 0.43333333333333, -0.25, 0
28388, 0.44166666666667, -0.27, 0
28389, 0.45, -0.25, 0
28390, 0.45833333333333, -0.27, 0
28391, 0.46666666666667, -0.25, 0
28392, 0.475, -0.27, 0
28393, 0.48333333333333, -0.25, 0
28394, 0.49166666666667, -0.27, 0
28395, 0.5, -0.25, 0
28396, 0.50833333333333, -0.27, 0
28397, 0.51666666666667, -0.25, 0
28398, 0.525, -0.27, 0
28399, 0.53333333333333, -0.25, 0
28400, 0.54166666666667, -0.27, 0
28401, 0.55, -0.25, 0
28402, 0.55833333333333, -0.27, 0
28403, 0.56666666666667, -0.25, 0
28404, 0.575, -0.27, 0
28405, 0.58333333333333, -0.25, 0
28406, 0.59166666666667, -0.27, 0
28407, 0.6, -0.25, 0
28408, 0.60833333333333, -0.27, 0
28409, 0.61666666666667, -0.25, 0
28410, 0.625, -0.27, 0
28411, 0.63333333333333, -0.25, 0
28412, 0.64166666666667, -0.27, 0
28413, 0.65, -0.25, 0
28414, 0.65833333333333, -0.27, 0
28415, 0.66666666666667, -0.25, 0
28416, 0.675, -0.27, 0
28417, 0.68333333333333, -0.25, 0
28418, 0.69166666666667, -0.27, 0
28419, 0.7, -0.25, 0
28420, 0.70833333333333, -0.27, 0
28421, 0.71666666666667, -0.25, 0
28422, 0.725, -0.27, 0
28423, 0.73333333333333, -0.25, 0
28424, 0.74166666666667, -0.27, 0
28425, 0.75, -0.25, 0
28426, 0.75833333333333, -0.27, 0
28427, 0.76666666666667, -0.25, 0
28428, 0.775, -0.27, 0
28429, 0.78333333333333, -0.25, 0
28430, 0.79166666666667, -0.27, 0
28431, 0.8, -0.25, 0
28432, 0.80833333333333, -0.27, 0
28433, 0.81666666666667, -0.25, 0
28434, 0.825, -0.27, 0
28435, 0.83333333333333, -0.25, 0
28436, 0.84166666666667, -0.27, 0
28437, 0.85, -0.25, 0
28438, 0.85833333333333, -0.27, 0
28439, 0.86666666666667, -0.25, 0
28440, 0.875, -0.27, 0
28441, 0.88333333333333, -0.25, 0
28442, 0.89166666666667, -0.27, 0
28443, 0.9, -0.25, 0
28444, 0.90833333333333, -0.27, 0
28445, 0.91666666666667, -0.25, 0
28446, 0.925, -0.27, 0
28447, 0.93333333333333, -0.25, 0
28448, 0.94166666666667, -0.27, 0
28449, 0.95, -0.25, 0
28450, 0.95833333333333, -0.27, 0
28451, 0.96666666666667, -0.25, 0
28452, 0.975, -0.27, 0
28453, 0.98333333333333, -0.25, 0
28454, 0.99166666666667, -0.27, 0
28455, 0.0083333333333333, -0.31, 0
28456, 0.016666666666667, -0.29, 0
28457, 0.025, -0.31, 0
28458, 0.033333333333333, -0.29, 0
28459, 0.041666666666667, -0.31, 0
28460, 0.05, -0.29, 0
28461, 0.058333333333333, -0.31, 0
28462, 0.066666666666667, -0.29, 0
28463, 0.075, -0.31, 0
28464, 0.083333333333333, -0.29, 0
28465, 0.091666666666667, -0.31, 0
28466, 0.1, -0.29, 0
28467, 0.10833333333333, -0.31, 0
28468, 0.11666666666667, -0.29, 0
28469, 0.125, -0.31, 0
28470, 0.13333333333333, -0.29, 0
28471, 0.14166666666667, -0.31, 0
28472, 0.15, -0.29, 0
28473, 0.15833333333333, -0.31, 0
28474, 0.16666666666667, -0.29, 0
28475, 0.175, -0.31, 0
28476, 0.18333333333333, -0.29, 0
28477, 0.19166666666667, -0.31, 0
28478, 0.2, -0.29, 0
28479, 0.20833333333333, -0.31, 0
28480, 0.21666666666667, -0.29, 0
28481, 0.225, -0.31, 0
28482, 0.23333333333333, -0.29, 0
28483, 0.24166666666667, -0.31, 0
28484, 0.25, -0.29, 0
28485, 0.25833333333333, -0.31, 0
28486, 0.26666666666667, -0.29, 0
28487, 0.275, -0.31, 0
28488, 0.28333333333333, -0.29, 0
28489, 0.29166666666667, -0.31, 0
28490, 0.3, -0.29, 0
28491, 0.30833333333333, -0.31, 0
28492, 0.31666666666667, -0.29, 0
28493, 0.325, -0.31, 0
28494, 0.33333333333333, -0.29, 0
28495, 0.34166666666667, -0.31, 0
28496, 0.35, -0.29, 0
28497, 0.35833333333333, -0.31, 0
28498, 0.36666666666667, -0.29, 0
28499, 0.375, -0.31, 0
28500, 0.38333333333333, -0.29, 0
28501, 0.39166666666667, -0.31, 0
28502, 0.4, -0.29, 0
28503, 0.40833333333333, -0.31, 0
28504, 0.41666666666667, -0.29, 0
28505, 0.425, -0.31, 0
28506, 0.43333333333333, -0.29, 0
28507, 0.44166666666667, -0.31, 0
28508, 0.45, -0.29, 0
28509, 0.45833333333333, -0.31, 0
28510, 0.46666666666667, -0.29, 0
28511, 0.475, -0.31, 0
28512, 0.48333333333333, -0.29, 0
28513, 0.49166666666667, -0.31, 0
28514, 0.5, -0.29, 0
28515, 0.50833333333333, -0.31, 0
28516, 0.51666666666667, -0.29, 0
28517, 0.525, -0.31, 0
28518, 0.53333333333333, -0.29, 0
28519, 0.54166666666667, -0.31, 0
28520, 0.55, -0.29, 0
28521, 0.55833333333333, -0.31, 0
28522, 0.56666666666667, -0.29, 0
28523, 0.575, -0.31, 0
28524, 0.58333333333333, -0.29, 0
28525, 0.59166666666667, -0.31, 0
28526, 0.6, -0.29, 0
28527, 0.60833333333333, -0.31, 0
28528, 0.61666666666667, -0.29, 0
28529, 0.625, -0.31, 0
28530, 0.63333333333333, -0.29, 0
28531, 0.64166666666667, -0.31, 0
28532, 0.65, -0.29, 0
28533, 0.65833333333333, -0.31, 0
28534, 0.66666666666667, -0.29, 0
28535, 0.675, -0.31, 0
28536, 0.68333333333333, -0.29, 0
28537, 0.69166666666667, -0.31, 0
28538, 0.7, -0.29, 0
28539, 0.70833333333333, -0.31, 0
28540, 0.71666666666667, -0.29, 0
28541, 0.725, -0.31, 0
28542, 0.73333333333333, -0.29, 0
28543, 0.74166666666667, -0.31, 0
28544, 0.75, -0.29, 0
28545, 0.75833333333333, -0.31, 0
28546, 0.76666666666667, -0.29, 0
28547, 0.775, -0.31, 0
28548, 0.78333333333333, -0.29, 0
28549, 0.79166666666667, -0.31, 0
28550, 0.8, -0.29, 0
28551, 0.80833333333333, -0.31, 0
28552, 0.81666666666667, -0.29, 0
28553, 0.825, -0.31, 0
28554, 0.83333333333333, -0.29, 0
28555, 0.84166666666667, -0.31, 0
28556, 0.85, -0.29, 0
28557, 0.85833333333333, -0.31, 0
28558, 0.86666666666667, -0.29, 0
28559, 0.875, -0.31, 0
28560, 0.88333333333333, -0.29, 0
28561, 0.89166666666667, -0.31, 0
28562, 0.9, -0.29, 0
28563, 0.90833333333333, -0.31, 0
28564, 0.91666666666667, -0.29, 0
28565, 0.925, -0.31, 0
28566, 0.93333333333333, -0.29, 0
28567, 0.94166666666667, -0.31, 0
28568, 0.95, -0.29, 0
28569, 0.95833333333333, -0.31, 0
28570, 0.96666666666667, -0.29, 0
28571, 0.975, -0.31, 0
28572, 0.98333333333333, -0.29, 0
28573, 0.99166666666667, -0.31, 0
28574, 0.016666666666667, -0.33, 0
28575, 0.033333333333333, -0.33, 0
28576, 0.05, -0.33, 0
28577, 0.066666666666667, -0.33, 0
28578, 0.083333333333333, -0.33, 0
28579, 0.1, -0.33, 0
28580, 0.11666666666667, -0.33, 0
28581, 0.13333333333333, -0.33, 0
28582, 0.15, -0.33, 0
28583, 0.16666666666667, -0.33, 0
28584, 0.18333333333333, -0.33, 0
28585, 0.2, -0.33, 0
28586, 0.21666666666667, -0.33, 0
28587, 0.23333333333333, -0.33, 0
28588, 0.25, -0.33, 0
28589, 0.26666666666667, -0.33, 0
28590, 0.28333333333333, -0.33, 0
28591, 0.3, -0.33, 0
28592, 0.31666666666667, -0.33, 0
28593, 0.33333333333333, -0.33, 0
28594, 0.35, -0.33, 0
28595, 0.36666666666667, -0.33, 0
28596, 0.38333333333333, -0.33, 0
28597, 0.4, -0.33, 0
28598, 0.41666666666667, -0.33, 0
28599, 0.43333333333333, -0.33, 0
28600, 0.45, -0.33, 0
28601, 0.46666666666667, -0.33, 0
28602, 0.48333333333333, -0.33, 0
28603, 0.5, -0.33, 0
28604, 0.51666666666667, -0.33, 0
28605, 0.53333333333333, -0.33, 0
28606, 0.55, -0.33, 0
28607, 0.56666666666667, -0.33, 0
28608, 0.58333333333333, -0.33, 0
28609, 0.6, -0.33, 0
28610, 0.61666666666667, -0.33, 0
28611, 0.63333333333333, -0.33, 0
28612, 0.65, -0.33, 0
28613, 0.66666666666667, -0.33, 0
28614, 0.68333333333333, -0.33, 0
28615, 0.7, -0.33, 0
28616, 0.71666666666667, -0.33, 0
28617, 0.73333333333333, -0.33, 0
28618, 0.75, -0.33, 0
28619, 0.76666666666667, -0.33, 0
28620, 0.78333333333333, -0.33, 0
28621, 0.8, -0.33, 0
28622, 0.81666666666667, -0.33, 0
28623, 0.83333333333333, -0.33, 0
28624, 0.85, -0.33, 0
28625, 0.86666666666667, -0.33, 0
28626, 0.88333333333333, -0.33, 0
28627, 0.9, -0.33, 0
28628, 0.91666666666667, -0.33, 0
28629, 0.93333333333333, -0.33, 0
28630, 0.95, -0.33, 0
28631, 0.96666666666667, -0.33, 0
28632, 0.98333333333333, -0.33, 0
28633, 1.2166666666667, -0.19, 0
28634, 1.2333333333333, -0.19, 0
28635, 1.25, -0.19, 0
28636, 1.2666666666667, -0.19, 0
28637, 1.2833333333333, -0.19, 0
28638, 1.3, -0.19, 0
28639, 1.3166666666667, -0.19, 0
28640, 1.3333333333333, -0.19, 0
28641, 1.35, -0.19, 0
28642, 1.3666666666667, -0.19, 0
28643, 1.3833333333333, -0.19, 0
28644, 1.4, -0.19, 0
28645, 1.4166666666667, -0.19, 0
28646, 1.4333333333333, -0.19, 0
28647, 1.45, -0.19, 0
28648, 1.4666666666667, -0.19, 0
28649, 1.4833333333333, -0.19, 0
28650, 1.5, -0.19, 0
28651, 1.5166666666667, -0.19, 0
28652, 1.5333333333333, -0.19, 0
28653, 1.55, -0.19, 0
28654, 1.5666666666667, -0.19, 0
28655, 1.5833333333333, -0.19, 0
28656, 1.6, -0.19, 0
28657, 1.6166666666667, -0.19, 0
28658, 1.6333333333333, -0.19, 0
28659, 1.65, -0.19, 0
28660, 1.6666666666667, -0.19, 0
28661, 1.6833333333333, -0.19, 0
28662, 1.7, -0.19, 0
28663, 1.7166666666667, -0.19, 0
28664, 1.7333333333333, -0.19, 0
28665, 1.75, -0.19, 0
28666, 1.7666666666667, -0.19, 0
28667, 1.7833333333333, -0.19, 0
28668, 1.8, -0.19, 0
28669, 1.8166666666667, -0.19, 0
28670, 1.8333333333333, -0.19, 0
28671, 1.85, -0.19, 0
28672, 1.8666666666667, -0.19, 0
28673, 1.8833333333333, -0.19, 0
28674, 1.9, -0.19, 0
28675, 1.9166666666667, -0.19, 0
28676, 1.9333333333333, -0.19, 0
28677, 1.95, -0.19, 0
28678, 1.9666666666667, -0.19, 0
28679, 1.9833333333333, -0.19, 0
28680, 2, -0.19, 0
28681, 2.0166666666667, -0.19, 0
28682, 2.0333333333333, -0.19, 0
28683, 2.05, -0.19, 0
28684, 2.0666666666667, -0.19, 0
28685, 2.0833333333333, -0.19, 0
28686, 2.1, -0.19, 0
28687, 2.1166666666667, -0.19, 0
28688, 2.1333333333333, -0.19, 0
28689, 2.15, -0.19, 0
28690, 2.1666666666667, -0.19, 0
28691, 2.1833333333333, -0.19, 0
28692, 1.2166666666667, -0.23, 0
28693, 1.2333333333333, -0.23, 0
28694, 1.25, -0.23, 0
28695, 1.2666666666667, -0.23, 0
28696, 1.2833333333333, -0.23, 0
28697, 1.3, -0.23, 0
28698, 1.3166666666667, -0.23, 0
28699, 1.3333333333333, -0.23, 0
28700, 1.35, -0.23, 0
28701, 1.3666666666667, -0.23, 0
28702, 1.3833333333333, -0.23, 0
28703, 1.4, -0.23, 0
28704, 1.4166666666667, -0.23, 0
28705, 1.4333333333333, -0.23, 0
28706, 1.45, -0.23, 0
28707, 1.4666666666667, -0.23, 0
28708, 1.4833333333333, -0.23, 0
28709, 1.5, -0.23, 0
28710, 1.5166666666667, -0.23, 0
28711, 1.5333333333333, -0.23, 0
28712, 1.55, -0.23, 0
28713, 1.5666666666667, -0.23, 0
28714, 1.5833333333333, -0.23, 0
28715, 1.6, -0.23, 0
28716, 1.6166666666667, -0.23, 0
28717, 1.6333333333333, -0.23, 0
28718, 1.65, -0.23, 0
28719, 1.6666666666667, -0.23, 0
28720, 1.6833333333333, -0.23, 0
28721, 1.7, -0.23, 0
28722, 1.7166666666667, -0.23, 0
28723, 1.7333333333333, -0.23, 0
28724, 1.75, -0.23, 0
28725, 1.7666666666667, -0.23, 0
28726, 1.7833333333333, -0.23, 0
28727, 1.8, -0.23, 0
28728, 1.8166666666667, -0.23, 0
28729, 1.8333333333333, -0.23, 0
28730, 1.85, -0.23, 0
28731, 1.8666666666667, -0.23, 0
28732, 1.8833333333333, -0.23, 0
28733, 1.9, -0.23, 0
28734, 1.9166666666667, -0.23, 0
28735, 1.9333333333333, -0.23, 0
28736, 1.95, -0.23, 0
28737, 1.9666666666667, -0.23, 0
28738, 1.9833333333333, -0.23, 0
28739, 2, -0.23, 0
28740, 2.0166666666667, -0.23, 0
28741, 2.0333333333333, -0.23, 0
28742, 2.05, -0.23, 0
28743, 2.0666666666667, -0.23, 0
28744, 2.0833333333333, -0.23, 0
28745, 2.1, -0.23, 0
28746, 2.1166666666667, -0.23, 0
28747, 2.1333333333333, -0.23, 0
28748, 2.15, -0.23, 0
28749, 2.1666666666667, -0.23, 0
28750, 2.1833333333333, -0.23, 0
28751, 1.2166666666667, -0.27, 0
28752, 1.2333333333333, -0.27, 0
28753, 1.25, -0.27, 0
28754, 1.2666666666667, -0.27, 0
28755, 1.2833333333333, -0.27, 0
28756, 1.3, -0.27, 0
28757, 1.3166666666667, -0.27, 0
28758, 1.3333333333333, -0.27, 0
28759, 1.35, -0.27, 0
28760, 1.3666666666667, -0.27, 0
28761, 1.3833333333333, -0.27, 0
28762, 1.4, -0.27, 0
28763, 1.4166666666667, -0.27, 0
28764, 1.4333333333333, -0.27, 0
28765, 1.45, -0.27, 0
28766, 1.4666666666667, -0.27, 0
28767, 1.4833333333333, -0.27, 0
28768, 1.5, -0.27, 0
28769, 1.5166666666667, -0.27, 0
28770, 1.5333333333333, -0.27, 0
28771, 1.55, -0.27, 0
28772, 1.5666666666667, -0.27, 0
28773, 1.5833333333333, -0.27, 0
28774, 1.6, -0.27, 0
28775, 1.6166666666667, -0.27, 0
28776, 1.6333333333333, -0.27, 0
28777, 1.65, -0.27, 0
28778, 1.6666666666667, -0.27, 0
28779, 1.6833333333333, -0.27, 0
28780, 1.7, -0.27, 0
28781, 1.7166666666667, -0.27, 0
28782, 1.7333333333333, -0.27, 0
28783, 1.75, -0.27, 0
28784, 1.7666666666667, -0.27, 0
28785, 1.7833333333333, -0.27, 0
28786, 1.8, -0.27, 0
28787, 1.8166666666667, -0.27, 0
28788, 1.8333333333333, -0.27, 0
28789, 1.85, -0.27, 0
28790, 1.8666666666667, -0.27, 0
28791, 1.8833333333333, -0.27, 0
28792, 1.9, -0.27, 0
28793, 1.9166666666667, -0.27, 0
28794, 1.9333333333333, -0.27, 0
28795, 1.95, -0.27, 0
28796, 1.9666666666667, -0.27, 0
28797, 1.9833333333333, -0.27, 0
28798, 2, -0.27, 0
28799, 2.0166666666667, -0.27, 0
28800, 2.0333333333333, -0.27, 0
28801, 2.05, -0.27, 0
28802, 2.0666666666667, -0.27, 0
28803, 2.0833333333333, -0.27, 0
28804, 2.1, -0.27, 0
28805, 2.1166666666667, -0.27, 0
28806, 2.1333333333333, -0.27, 0
28807, 2.15, -0.27, 0
28808, 2.1666666666667, -0.27, 0
28809, 2.1833333333333, -0.27, 0
28810, 1.2166666666667, -0.31, 0
28811, 1.2333333333333, -0.31, 0
28812, 1.25, -0.31, 0
28813, 1.2666666666667, -0.31, 0
28814, 1.2833333333333, -0.31, 0
28815, 1.3, -0.31, 0
28816, 1.3166666666667, -0.31, 0
28817, 1.3333333333333, -0.31, 0
28818, 1.35, -0.31, 0
28819, 1.3666666666667, -0.31, 0
28820, 1.3833333333333, -0.31, 0
28821, 1.4, -0.31, 0
28822, 1.4166666666667, -0.31, 0
28823, 1.4333333333333, -0.31, 0
28824, 1.45, -0.31, 0
28825, 1.4666666666667, -0.31, 0
28826, 1.4833333333333, -0.31, 0
28827, 1.5, -0.31, 0
28828, 1.5166666666667, -0.31, 0
28829, 1.5333333333333, -0.31, 0
28830, 1.55, -0.31, 0
28831, 1.5666666666667, -0.31, 0
28832, 1.5833333333333, -0.31, 0
28833, 1.6, -0.31, 0
28834, 1.6166666666667, -0.31, 0
28835, 1.6333333333333, -0.31, 0
28836, 1.65, -0.31, 0
28837, 1.6666666666667, -0.31, 0
28838, 1.6833333333333, -0.31, 0
28839, 1.7, -0.31, 0
28840, 1.7166666666667, -0.31, 0
28841, 1.7333333333333, -0.31, 0
28842, 1.75, -0.31, 0
28843, 1.7666666666667, -0.31, 0
28844, 1.7833333333333, -0.31, 0
28845, 1.8, -0.31, 0
28846, 1.8166666666667, -0.31, 0
28847, 1.8333333333333, -0.31, 0
28848, 1.85, -0.31, 0
28849, 1.8666666666667, -0.31, 0
28850, 1.8833333333333, -0.31, 0
28851, 1.9, -0.31, 0
28852, 1.9166666666667, -0.31, 0
28853, 1.9333333333333, -0.31, 0
28854, 1.95, -0.31, 0
28855, 1.9666666666667, -0.31, 0
28856, 1.9833333333333, -0.31, 0
28857, 2, -0.31, 0
28858, 2.0166666666667, -0.31, 0
28859, 2.0333333333333, -0.31, 0
28860, 2.05, -0.31, 0
28861, 2.0666666666667, -0.31, 0
28862, 2.0833333333333, -0.31, 0
28863, 2.1, -0.31, 0
28864, 2.1166666666667, -0.31, 0
28865, 2.1333333333333, -0.31, 0
28866, 2.15, -0.31, 0
28867, 2.1666666666667, -0.31, 0
28868, 2.1833333333333, -0.31, 0
28869, 1.2083333333333, -0.19, 0
28870, 1.2166666666667, -0.17, 0
28871, 1.225, -0.19, 0
28872, 1.2333333333333, -0.17, 0
28873, 1.2416666666667, -0.19, 0
28874, 1.25, -0.17, 0
28875, 1.2583333333333, -0.19, 0
28876, 1.2666666666667, -0.17, 0
28877, 1.275, -0.19, 0
28878, 1.2833333333333, -0.17, 0
28879, 1.2916666666667, -0.19, 0
28880, 1.3, -0.17, 0
28881, 1.3083333333333, -0.19, 0
28882, 1.3166666666667, -0.17, 0
28883, 1.325, -0.19, 0
28884, 1.3333333333333, -0.17, 0
28885, 1.3416666666667, -0.19, 0
28886, 1.35, -0.17, 0
28887, 1.3583333333333, -0.19, 0
28888, 1.3666666666667, -0.17, 0
28889, 1.375, -0.19, 0
28890, 1.3833333333333, -0.17, 0
28891, 1.3916666666667, -0.19, 0
28892, 1.4, -0.17, 0
28893, 1.4083333333333, -0.19, 0
28894, 1.4166666666667, -0.17, 0
28895, 1.425, -0.19, 0
28896, 1.4333333333333, -0.17, 0
28897, 1.4416666666667, -0.19, 0
28898, 1.45, -0.17, 0
28899, 1.4583333333333, -0.19, 0
28900, 1.4666666666667, -0.17, 0
28901, 1.475, -0.19, 0
28902, 1.4833333333333, -0.17, 0
28903, 1.4916666666667, -0.19, 0
28904, 1.5, -0.17, 0
28905, 1.5083333333333, -0.19, 0
28906, 1.5166666666667, -0.17, 0
28907, 1.525, -0.19, 0
28908, 1.5333333333333, -0.17, 0
28909, 1.5416666666667, -0.19, 0
28910, 1.55, -0.17, 0
28911, 1.5583333333333, -0.19, 0
28912, 1.5666666666667, -0.17, 0
28913, 1.575, -0.19, 0
28914, 1.5833333333333, -0.17, 0
28915, 1.5916666666667, -0.19, 0
28916, 1.6, -0.17, 0
28917, 1.6083333333333, -0.19, 0
28918, 1.6166666666667, -0.17, 0
28919, 1.625, -0.19, 0
28920, 1.6333333333333, -0.17, 0
28921, 1.6416666666667, -0.19, 0
28922, 1.65, -0.17, 0
28923, 1.6583333333333, -0.19, 0
28924, 1.6666666666667, -0.17, 0
28925, 1.675, -0.19, 0
28926, 1.6833333333333, -0.17, 0
28927, 1.6916666666667, -0.19, 0
28928, 1.7, -0.17, 0
28929, 1.7083333333333, -0.19, 0
28930, 1.7166666666667, -0.17, 0
28931, 1.725, -0.19, 0
28932, 1.7333333333333, -0.17, 0
28933, 1.7416666666667, -0.19, 0
28934, 1.75, -0.17, 0
28935, 1.7583333333333, -0.19, 0
28936, 1.7666666666667, -0.17, 0
28937, 1.775, -0.19, 0
28938, 1.7833333333333, -0.17, 0
28939, 1.7916666666667, -0.19, 0
28940, 1.8, -0.17, 0
28941, 1.8083333333333, -0.19, 0
28942, 1.8166666666667, -0.17, 0
28943, 1.825, -0.19, 0
28944, 1.8333333333333, -0.17, 0
28945, 1.8416666666667, -0.19, 0
28946, 1.85, -0.17, 0
28947, 1.8583333333333, -0.19, 0
28948, 1.8666666666667, -0.17, 0
28949, 1.875, -0.19, 0
28950, 1.8833333333333, -0.17, 0
28951, 1.8916666666667, -0.19, 0
28952, 1.9, -0.17, 0
28953, 1.9083333333333, -0.19, 0
28954, 1.9166666666667, -0.17, 0
28955, 1.925, -0.19, 0
28956, 1.9333333333333, -0.17, 0
28957, 1.9416666666667, -0.19, 0
28958, 1.95, -0.17, 0
28959, 1.9583333333333, -0.19, 0
28960, 1.9666666666667, -0.17, 0
28961, 1.975, -0.19, 0
28962, 1.9833333333333, -0.17, 0
28963, 1.9916666666667, -0.19, 0
28964, 2, -0.17, 0
28965, 2.0083333333333, -0.19, 0
28966, 2.0166666666667, -0.17, 0
28967, 2.025, -0.19, 0
28968, 2.0333333333333, -0.17, 0
28969, 2.0416666666667, -0.19, 0
28970, 2.05, -0.17, 0
28971, 2.0583333333333, -0.19, 0
28972, 2.0666666666667, -0.17, 0
28973, 2.075, -0.19, 0
28974, 2.0833333333333, -0.17, 0
28975, 2.0916666666667, -0.19, 0
28976, 2.1, -0.17, 0
28977, 2.1083333333333, -0.19, 0
28978, 2.1166666666667, -0.17, 0
28979, 2.125, -0.19, 0
28980, 2.1333333333333, -0.17, 0
28981, 2.1416666666667, -0.19, 0
28982, 2.15, -0.17, 0
28983, 2.1583333333333, -0.19, 0
28984, 2.1666666666667, -0.17, 0
28985, 2.175, -0.19, 0
28986, 2.1833333333333, -0.17, 0
28987, 2.1916666666667, -0.19, 0
28988, 1.2083333333333, -0.23, 0
28989, 1.2166666666667, -0.21, 0
28990, 1.225, -0.23, 0
28991, 1.2333333333333, -0.21, 0
28992, 1.2416666666667, -0.23, 0
28993, 1.25, -0.21, 0
28994, 1.2583333333333, -0.23, 0
28995, 1.2666666666667, -0.21, 0
28996, 1.275, -0.23, 0
28997, 1.2833333333333, -0.21, 0
28998, 1.2916666666667, -0.23, 0
28999, 1.3, -0.21, 0
29000, 1.3083333333333, -0.23, 0
29001, 1.3166666666667, -0.21, 0
29002, 1.325, -0.23, 0
29003, 1.3333333333333, -0.21, 0
29004, 1.3416666666667, -0.23, 0
29005, 1.35, -0.21, 0
29006, 1.3583333333333, -0.23, 0
29007, 1.3666666666667, -0.21, 0
29008, 1.375, -0.23, 0
29009, 1.3833333333333, -0.21, 0
29010, 1.3916666666667, -0.23, 0
29011, 1.4, -0.21, 0
29012, 1.4083333333333, -0.23, 0
29013, 1.4166666666667, -0.21, 0
29014, 1.425, -0.23, 0
29015, 1.4333333333333, -0.21, 0
29016, 1.4416666666667, -0.23, 0
29017, 1.45, -0.21, 0
29018, 1.4583333333333, -0.23, 0
29019, 1.4666666666667, -0.21, 0
29020, 1.475, -0.23, 0
29021, 1.4833333333333, -0.21, 0
29022, 1.4916666666667, -0.23, 0
29023, 1.5, -0.21, 0
29024, 1.5083333333333, -0.23, 0
29025, 1.5166666666667, -0.21, 0
29026, 1.525, -0.23, 0
29027, 1.5333333333333, -0.21, 0
29028, 1.5416666666667, -0.23, 0
29029, 1.55, -0.21, 0
29030, 1.5583333333333, -0.23, 0
29031, 1.5666666666667, -0.21, 0
29032, 1.575, -0.23, 0
29033, 1.5833333333333, -0.21, 0
29034, 1.5916666666667, -0.23, 0
29035, 1.6, -0.21, 0
29036, 1.6083333333333, -0.23, 0
29037, 1.6166666666667, -0.21, 0
29038, 1.625, -0.23, 0
29039, 1.6333333333333, -0.21, 0
29040, 1.6416666666667, -0.23, 0
29041, 1.65, -0.21, 0
29042, 1.6583333333333, -0.23, 0
29043, 1.6666666666667, -0.21, 0
29044, 1.675, -0.23, 0
29045, 1.6833333333333, -0.21, 0
29046, 1.6916666666667, -0.23, 0
29047, 1.7, -0.21, 0
29048, 1.7083333333333, -0.23, 0
29049, 1.7166666666667, -0.21, 0
29050, 1.725, -0.23, 0
29051, 1.7333333333333, -0.21, 0
29052, 1.7416666666667, -0.23, 0
29053, 1.75, -0.21, 0
29054, 1.7583333333333, -0.23, 0
29055, 1.7666666666667, -0.21, 0
29056, 1.775, -0.23, 0
29057, 1.7833333333333, -0.21, 0
29058, 1.7916666666667, -0.23, 0
29059, 1.8, -0.21, 0
29060, 1.8083333333333, -0.23, 0
29061, 1.8166666666667, -0.21, 0
29062, 1.825, -0.23, 0
29063, 1.8333333333333, -0.21, 0
29064, 1.8416666666667, -0.23, 0
29065, 1.85, -0.21, 0
29066, 1.8583333333333, -0.23, 0
29067, 1.8666666666667, -0.21, 0
29068, 1.875, -0.23, 0
29069, 1.8833333333333, -0.21, 0
29070, 1.8916666666667, -0.23, 0
29071, 1.9, -0.21, 0
29072, 1.9083333333333, -0.23, 0
29073, 1.9166666666667, -0.21, 0
29074, 1.925, -0.23, 0
29075, 1.9333333333333, -0.21, 0
29076, 1.9416666666667, -0.23, 0
29077, 1.95, -0.21, 0
29078, 1.9583333333333, -0.23, 0
29079, 1.9666666666667, -0.21, 0
29080, 1.975, -0.23, 0
29081, 1.9833333333333, -0.21, 0
29082, 1.9916666666667, -0.23, 0
29083, 2, -0.21, 0
29084, 2.0083333333333, -0.23, 0
29085, 2.0166666666667, -0.21, 0
29086, 2.025, -0.23, 0
29087, 2.0333333333333, -0.21, 0
29088, 2.0416666666667, -0.23, 0
29089, 2.05, -0.21, 0
29090, 2.0583333333333, -0.23, 0
29091, 2.0666666666667, -0.21, 0
29092, 2.075, -0.23, 0
29093, 2.0833333333333, -0.21, 0
29094, 2.0916666666667, -0.23, 0
29095, 2.1, -0.21, 0
29096, 2.1083333333333, -0.23, 0
29097, 2.1166666666667, -0.21, 0
29098, 2.125, -0.23, 0
29099, 2.1333333333333, -0.21, 0
29100, 2.1416666666667, -0.23, 0
29101, 2.15, -0.21, 0
29102, 2.1583333333333, -0.23, 0
29103, 2.1666666666667, -0.21, 0
29104, 2.175, -0.23, 0
29105, 2.1833333333333, -0.21, 0
29106, 2.1916666666667, -0.23, 0
29107, 1.2083333333333, -0.27, 0
29108, 1.2166666666667, -0.25, 0
29109, 1.225, -0.27, 0
29110, 1.2333333333333, -0.25, 0
29111, 1.2416666666667, -0.27, 0
29112, 1.25, -0.25, 0
29113, 1.2583333333333, -0.27, 0
29114, 1.2666666666667, -0.25, 0
29115, 1.275, -0.27, 0
29116, 1.2833333333333, -0.25, 0
29117, 1.2916666666667, -0.27, 0
29118, 1.3, -0.25, 0
29119, 1.3083333333333, -0.27, 0
29120, 1.3166666666667, -0.25, 0
29121, 1.325, -0.27, 0
29122, 1.3333333333333, -0.25, 0
29123, 1.3416666666667, -0.27, 0
29124, 1.35, -0.25, 0
29125, 1.3583333333333, -0.27, 0
29126, 1.3666666666667, -0.25, 0
29127, 1.375, -0.27, 0
29128, 1.3833333333333, -0.25, 0
29129, 1.3916666666667, -0.27, 0
29130, 1.4, -0.25, 0
29131, 1.4083333333333, -0.27, 0
29132, 1.4166666666667, -0.25, 0
29133, 1.425, -0.27, 0
29134, 1.4333333333333, -0.25, 0
29135, 1.4416666666667, -0.27, 0
29136, 1.45, -0.25, 0
29137, 1.4583333333333, -0.27, 0
29138, 1.4666666666667, -0.25, 0
29139, 1.475, -0.27, 0
29140, 1.4833333333333, -0.25, 0
29141, 1.4916666666667, -0.27, 0
29142, 1.5, -0.25, 0
29143, 1.5083333333333, -0.27, 0
29144, 1.5166666666667, -0.25, 0
29145, 1.525, -0.27, 0
29146, 1.5333333333333, -0.25, 0
29147, 1.5416666666667, -0.27, 0
29148, 1.55, -0.25, 0
29149, 1.5583333333333, -0.27, 0
29150, 1.5666666666667, -0.25, 0
29151, 1.575, -0.27, 0
29152, 1.5833333333333, -0.25, 0
29153, 1.5916666666667, -0.27, 0
29154, 1.6, -0.25, 0
29155, 1.6083333333333, -0.27, 0
29156, 1.6166666666667, -0.25, 0
29157, 1.625, -0.27, 0
29158, 1.6333333333333, -0.25, 0
29159, 1.6416666666667, -0.27, 0
29160, 1.65, -0.25, 0
29161, 1.6583333333333, -0.27, 0
29162, 1.6666666666667, -0.25, 0
29163, 1.675, -0.27, 0
29164, 1.6833333333333, -0.25, 0
29165, 1.6916666666667, -0.27, 0
29166, 1.7, -0.25, 0
29167, 1.7083333333333, -0.27, 0
29168, 1.7166666666667, -0.25, 0
29169, 1.725, -0.27, 0
29170, 1.7333333333333, -0.25, 0
29171, 1.7416666666667, -0.27, 0
29172, 1.75, -0.25, 0
29173, 1.7583333333333, -0.27, 0
29174, 1.7666666666667, -0.25, 0
29175, 1.775, -0.27, 0
29176, 1.7833333333333, -0.25, 0
29177, 1.7916666666667, -0.27, 0
29178, 1.8, -0.25, 0
29179, 1.8083333333333, -0.27, 0
29180, 1.8166666666667, -0.25, 0
29181, 1.825, -0.27, 0
29182, 1.8333333333333, -0.25, 0
29183, 1.8416666666667, -0.27, 0
29184, 1.85, -0.25, 0
29185, 1.8583333333333, -0.27, 0
29186, 1.8666666666667, -0.25, 0
29187, 1.875, -0.27, 0
29188, 1.8833333333333, -0.25, 0
29189, 1.8916666666667, -0.27, 0
29190, 1.9, -0.25, 0
29191, 1.9083333333333, -0.27, 0
29192, 1.9166666666667, -0.25, 0
29193, 1.925, -0.27, 0
29194, 1.9333333333333, -0.25, 0
29195, 1.9416666666667, -0.27, 0
29196, 1.95, -0.25, 0
29197, 1.9583333333333, -0.27, 0
29198, 1.9666666666667, -0.25, 0
29199, 1.975, -0.27, 0
29200, 1.9833333333333, -0.25, 0
29201, 1.9916666666667, -0.27, 0
29202, 2, -0.25, 0
29203, 2.0083333333333, -0.27, 0
29204, 2.0166666666667, -0.25, 0
29205, 2.025, -0.27, 0
29206, 2.0333333333333, -0.25, 0
29207, 2.0416666666667, -0.27, 0
29208, 2.05, -0.25, 0
29209, 2.0583333333333, -0.27, 0
29210, 2.0666666666667, -0.25, 0
29211, 2.075, -0.27, 0
29212, 2.0833333333333, -0.25, 0
29213, 2.0916666666667, -0.27, 0
29214, 2.1, -0.25, 0
29215, 2.1083333333333, -0.27, 0
29216, 2.1166666666667, -0.25, 0
29217, 2.125, -0.27, 0
29218, 2.1333333333333, -0.25, 0
29219, 2.1416666666667, -0.27, 0
29220, 2.15, -0.25, 0
29221, 2.1583333333333, -0.27, 0
29222, 2.1666666666667, -0.25, 0
29223, 2.175, -0.27, 0
29224, 2.1833333333333, -0.25, 0
29225, 2.1916666666667, -0.27, 0
29226, 1.2083333333333, -0.31, 0
29227, 1.2166666666667, -0.29, 0
29228, 1.225, -0.31, 0
29229, 1.2333333333333, -0.29, 0
29230, 1.2416666666667, -0.31, 0
29231, 1.25, -0.29, 0
29232, 1.2583333333333, -0.31, 0
29233, 1.2666666666667, -0.29, 0
29234, 1.275, -0.31, 0
29235, 1.2833333333333, -0.29, 0
29236, 1.2916666666667, -0.31, 0
29237, 1.3, -0.29, 0
29238, 1.3083333333333, -0.31, 0
29239, 1.3166666666667, -0.29, 0
29240, 1.325, -0.31, 0
29241, 1.3333333333333, -0.29, 0
29242, 1.3416666666667, -0.31, 0
29243, 1.35, -0.29, 0
29244, 1.3583333333333, -0.31, 0
29245, 1.3666666666667, -0.29, 0
29246, 1.375, -0.31, 0
29247, 1.3833333333333, -0.29, 0
29248, 1.3916666666667, -0.31, 0
29249, 1.4, -0.29, 0
29250, 1.4083333333333, -0.31, 0
29251, 1.4166666666667, -0.29, 0
29252, 1.425, -0.31, 0
29253, 1.4333333333333, -0.29, 0
29254, 1.4416666666667, -0.31, 0
29255, 1.45, -0.29, 0
29256, 1.4583333333333, -0.31, 0
29257, 1.4666666666667, -0.29, 0
29258, 1.475, -0.31, 0
29259, 1.4833333333333, -0.29, 0
29260, 1.4916666666667, -0.31, 0
29261, 1.5, -0.29, 0
29262, 1.5083333333333, -0.31, 0
29263, 1.5166666666667, -0.29, 0
29264, 1.525, -0.31, 0
29265, 1.5333333333333, -0.29, 0
29266, 1.5416666666667, -0.31, 0
29267, 1.55, -0.29, 0
29268, 1.5583333333333, -0.31, 0
29269, 1.5666666666667, -0.29, 0
29270, 1.575, -0.31, 0
29271, 1.5833333333333, -0.29, 0
29272, 1.5916666666667, -0.31, 0
29273, 1.6, -0.29, 0
29274, 1.6083333333333, -0.31, 0
29275, 1.6166666666667, -0.29, 0
29276, 1.625, -0.31, 0
29277, 1.6333333333333, -0.29, 0
29278, 1.6416666666667, -0.31, 0
29279, 1.65, -0.29, 0
29280, 1.6583333333333, -0.31, 0
29281, 1.6666666666667, -0.29, 0
29282, 1.675, -0.31, 0
29283, 1.6833333333333, -0.29, 0
29284, 1.6916666666667, -0.31, 0
29285, 1.7, -0.29, 0
29286, 1.7083333333333, -0.31, 0
29287, 1.7166666666667, -0.29, 0
29288, 1.725, -0.31, 0
29289, 1.7333333333333, -0.29, 0
29290, 1.7416666666667, -0.31, 0
29291, 1.75, -0.29, 0
29292, 1.7583333333333, -0.31, 0
29293, 1.7666666666667, -0.29, 0
29294, 1.775, -0.31, 0
29295, 1.7833333333333, -0.29, 0
29296, 1.7916666666667, -0.31, 0
29297, 1.8, -0.29, 0
29298, 1.8083333333333, -0.31, 0
29299, 1.8166666666667, -0.29, 0
29300, 1.825, -0.31, 0
29301, 1.8333333333333, -0.29, 0
29302, 1.8416666666667, -0.31, 0
29303, 1.85, -0.29, 0
29304, 1.8583333333333, -0.31, 0
29305, 1.8666666666667, -0.29, 0
29306, 1.875, -0.31, 0
29307, 1.8833333333333, -0.29, 0
29308, 1.8916666666667, -0.31, 0
29309, 1.9, -0.29, 0
29310, 1.9083333333333, -0.31, 0
29311, 1.9166666666667, -0.29, 0
29312, 1.925, -0.31, 0
29313, 1.9333333333333, -0.29, 0
29314, 1.9416666666667, -0.31, 0
29315, 1.95, -0.29, 0
29316, 1.9583333333333, -0.31, 0
29317, 1.9666666666667, -0.29, 0
29318, 1.975, -0.31, 0
29319, 1.9833333333333, -0.29, 0
29320, 1.9916666666667, -0.31, 0
29321, 2, -0.29, 0
29322, 2.0083333333333, -0.31, 0
29323, 2.0166666666667, -0.29, 0
29324, 2.025, -0.31, 0
29325, 2.0333333333333, -0.29, 0
29326, 2.0416666666667, -0.31, 0
29327, 2.05, -0.29, 0
29328, 2.0583333333333, -0.31, 0
29329, 2.0666666666667, -0.29, 0
29330, 2.075, -0.31, 0
29331, 2.0833333333333, -0.29, 0
29332, 2.0916666666667, -0.31, 0
29333, 2.1, -0.29, 0
29334, 2.1083333333333, -0.31, 0
29335, 2.1166666666667, -0.29, 0
29336, 2.125, -0.31, 0
29337, 2.1333333333333, -0.29, 0
29338, 2.1416666666667, -0.31, 0
29339, 2.15, -0.29, 0
29340, 2.1583333333333, -0.31, 0
29341, 2.1666666666667, -0.29, 0
29342, 2.175, -0.31, 0
29343, 2.1833333333333, -0.29, 0
29344, 2.1916666666667, -0.31, 0
29345, 1.2166666666667, -0.33, 0
29346, 1.2333333333333, -0.33, 0
29347, 1.25, -0.33, 0
29348, 1.2666666666667, -0.33, 0
29349, 1.2833333333333, -0.33, 0
29350, 1.3, -0.33, 0
29351, 1.3166666666667, -0.33, 0
29352, 1.3333333333333, -0.33, 0
29353, 1.35, -0.33, 0
29354, 1.3666666666667, -0.33, 0
29355, 1.3833333333333, -0.33, 0
29356, 1.4, -0.33, 0
29357, 1.4166666666667, -0.33, 0
29358, 1.4333333333333, -0.33, 0
29359, 1.45, -0.33, 0
29360, 1.4666666666667, -0.33, 0
29361, 1.4833333333333, -0.33, 0
29362, 1.5, -0.33, 0
29363, 1.5166666666667, -0.33, 0
29364, 1.5333333333333, -0.33, 0
29365, 1.55, -0.33, 0
29366, 1.5666666666667, -0.33, 0
29367, 1.5833333333333, -0.33, 0
29368, 1.6, -0.33, 0
29369, 1.6166666666667, -0.33, 0
29370, 1.6333333333333, -0.33, 0
29371, 1.65, -0.33, 0
29372, 1.6666666666667, -0.33, 0
29373, 1.6833333333333, -0.33, 0
29374, 1.7, -0.33, 0
29375, 1.7166666666667, -0.33, 0
29376, 1.7333333333333, -0.33, 0
29377, 1.75, -0.33, 0
29378, 1.7666666666667, -0.33, 0
29379, 1.7833333333333, -0.33, 0
29380, 1.8, -0.33, 0
29381, 1.8166666666667, -0.33, 0
29382, 1.8333333333333, -0.33, 0
29383, 1.85, -0.33, 0
29384, 1.8666666666667, -0.33, 0
29385, 1.8833333333333, -0.33, 0
29386, 1.9, -0.33, 0
29387, 1.9166666666667, -0.33, 0
29388, 1.9333333333333, -0.33, 0
29389, 1.95, -0.33, 0
29390, 1.9666666666667, -0.33, 0
29391, 1.9833333333333, -0.33, 0
29392, 2, -0.33, 0
29393, 2.0166666666667, -0.33, 0
29394, 2.0333333333333, -0.33, 0
29395, 2.05, -0.33, 0
29396, 2.0666666666667, -0.33, 0
29397, 2.0833333333333, -0.33, 0
29398, 2.1, -0.33, 0
29399, 2.1166666666667, -0.33, 0
29400, 2.1333333333333, -0.33, 0
29401, 2.15, -0.33, 0
29402, 2.1666666666667, -0.33, 0
29403, 2.1833333333333, -0.33, 0
29404, 2.2333333333333, -0.19, 0
29405, 2.2666666666667, -0.19, 0
29406, 2.2333333333333, -0.23, 0
29407, 2.2666666666667, -0.23, 0
29408, 2.2333333333333, -0.27, 0
29409, 2.2666666666667, -0.27, 0
29410, 2.2333333333333, -0.31, 0
29411, 2.2666666666667, -0.31, 0
29412, 2.2166666666667, -0.19, 0
29413, 2.2333333333333, -0.17, 0
29414, 2.25, -0.19, 0
29415, 2.2666666666667, -0.17, 0
29416, 2.2833333333333, -0.19, 0
29417, 2.2166666666667, -0.23, 0
29418, 2.2333333333333, -0.21, 0
29419, 2.25, -0.23, 0
29420, 2.2666666666667, -0.21, 0
29421, 2.2833333333333, -0.23, 0
29422, 2.2166666666667, -0.27, 0
29423, 2.2333333333333, -0.25, 0
29424, 2.25, -0.27, 0
29425, 2.2666666666667, -0.25, 0
29426, 2.2833333333333, -0.27, 0
29427, 2.2166666666667, -0.31, 0
29428, 2.2333333333333, -0.29, 0
29429, 2.25, -0.31, 0
29430, 2.2666666666667, -0.29, 0
29431, 2.2833333333333, -0.31, 0
29432, 2.2333333333333, -0.33, 0
29433, 2.2666666666667, -0.33, 0
29434, 0.98333333333333, 1.39, 0
29435, 0.96666666666667, 1.39, 0
29436, 0.95, 1.39, 0
29437, 0.93333333333333, 1.39, 0
29438, 0.91666666666667, 1.39, 0
29439, 0.9, 1.39, 0
29440, 0.88333333333333, 1.39, 0
29441, 0.86666666666667, 1.39, 0
29442, 0.85, 1.39, 0
29443, 0.83333333333333, 1.39, 0
29444, 0.81666666666667, 1.39, 0
29445, 0.8, 1.39, 0
29446, 0.78333333333333, 1.39, 0
29447, 0.76666666666667, 1.39, 0
29448, 0.75, 1.39, 0
29449, 0.73333333333333, 1.39, 0
29450, 0.71666666666667, 1.39, 0
29451, 0.7, 1.39, 0
29452, 0.68333333333333, 1.39, 0
29453, 0.66666666666667, 1.39, 0
29454, 0.65, 1.39, 0
29455, 0.63333333333333, 1.39, 0
29456, 0.61666666666667, 1.39, 0
29457, 0.6, 1.39, 0
29458, 0.58333333333333, 1.39, 0
29459, 0.56666666666667, 1.39, 0
29460, 0.55, 1.39, 0
29461, 0.53333333333333, 1.39, 0
29462, 0.51666666666667, 1.39, 0
29463, 0.5, 1.39, 0
29464, 0.48333333333333, 1.39, 0
29465, 0.46666666666667, 1.39, 0
29466, 0.45, 1.39, 0
29467, 0.43333333333333, 1.39, 0
29468, 0.41666666666667, 1.39, 0
29469, 0.4, 1.39, 0
29470, 0.38333333333333, 1.39, 0
29471, 0.36666666666667, 1.39, 0
29472, 0.35, 1.39, 0
29473, 0.33333333333333, 1.39, 0
29474, 0.31666666666667, 1.39, 0
29475, 0.3, 1.39, 0
29476, 0.28333333333333, 1.39, 0
29477, 0.26666666666667, 1.39, 0
29478, 0.25, 1.39, 0
29479, 0.23333333333333, 1.39, 0
29480, 0.21666666666667, 1.39, 0
29481, 0.2, 1.39, 0
29482, 0.18333333333333, 1.39, 0
29483, 0.16666666666667, 1.39, 0
29484, 0.15, 1.39, 0
29485, 0.13333333333333, 1.39, 0
29486, 0.11666666666667, 1.39, 0
29487, 0.1, 1.39, 0
29488, 0.083333333333333, 1.39, 0
29489, 0.066666666666667, 1.39, 0
29490, 0.05, 1.39, 0
29491, 0.033333333333333, 1.39, 0
29492, 0.016666666666667, 1.39, 0
29493, 0.98333333333333, 1.43, 0
29494, 0.96666666666667, 1.43, 0
29495, 0.95, 1.43, 0
29496, 0.93333333333333, 1.43, 0
29497, 0.91666666666667, 1.43, 0
29498, 0.9, 1.43, 0
29499, 0.88333333333333, 1.43, 0
29500, 0.86666666666667, 1.43, 0
29501, 0.85, 1.43, 0
29502, 0.83333333333333, 1.43, 0
29503, 0.81666666666667, 1.43, 0
29504, 0.8, 1.43, 0
29505, 0.78333333333333, 1.43, 0
29506, 0.76666666666667, 1.43, 0
29507, 0.75, 1.43, 0
29508, 0.73333333333333, 1.43, 0
29509, 0.71666666666667, 1.43, 0
29510, 0.7, 1.43, 0
29511, 0.68333333333333, 1.43, 0
29512, 0.66666666666667, 1.43, 0
29513, 0.65, 1.43, 0
29514, 0.63333333333333, 1.43, 0
29515, 0.61666666666667, 1.43, 0
29516, 0.6, 1.43, 0
29517, 0.58333333333333, 1.43, 0
29518, 0.56666666666667, 1.43, 0
29519, 0.55, 1.43, 0
29520, 0.53333333333333, 1.43, 0
29521, 0.51666666666667, 1.43, 0
29522, 0.5, 1.43, 0
29523, 0.48333333333333, 1.43, 0
29524, 0.46666666666667, 1.43, 0
29525, 0.45, 1.43, 0
29526, 0.43333333333333, 1.43, 0
29527, 0.41666666666667, 1.43, 0
29528, 0.4, 1.43, 0
29529, 0.38333333333333, 1.43, 0
29530, 0.36666666666667, 1.43, 0
29531, 0.35, 1.43, 0
29532, 0.33333333333333, 1.43, 0
29533, 0.31666666666667, 1.43, 0
29534, 0.3, 1.43, 0
29535, 0.28333333333333, 1.43, 0
29536, 0.26666666666667, 1.43, 0
29537, 0.25, 1.43, 0
29538, 0.23333333333333, 1.43, 0
29539, 0.21666666666667, 1.43, 0
29540, 0.2, 1.43, 0
29541, 0.18333333333333, 1.43, 0
29542, 0.16666666666667, 1.43, 0
29543, 0.15, 1.43, 0
29544, 0.13333333333333, 1.43, 0
29545, 0.11666666666667, 1.43, 0
29546, 0.1, 1.43, 0
29547, 0.083333333333333, 1.43, 0
29548, 0.066666666666667, 1.43, 0
29549, 0.05, 1.43, 0
29550, 0.033333333333333, 1.43, 0
29551, 0.016666666666667, 1.43, 0
29552, 0.98333333333333, 1.47, 0
29553, 0.96666666666667, 1.47, 0
29554, 0.95, 1.47, 0
29555, 0.93333333333333, 1.47, 0
29556, 0.91666666666667, 1.47, 0
29557, 0.9, 1.47, 0
29558, 0.88333333333333, 1.47, 0
29559, 0.86666666666667, 1.47, 0
29560, 0.85, 1.47, 0
29561, 0.83333333333333, 1.47, 0
29562, 0.81666666666667, 1.47, 0
29563, 0.8, 1.47, 0
29564, 0.78333333333333, 1.47, 0
29565, 0.76666666666667, 1.47, 0
29566, 0.75, 1.47, 0
29567, 0.73333333333333, 1.47, 0
29568, 0.71666666666667, 1.47, 0
29569, 0.7, 1.47, 0
29570, 0.68333333333333, 1.47, 0
29571, 0.66666666666667, 1.47, 0
29572, 0.65, 1.47, 0
29573, 0.63333333333333, 1.47, 0
29574, 0.61666666666667, 1.47, 0
29575, 0.6, 1.47, 0
29576, 0.58333333333333, 1.47, 0
29577, 0.56666666666667, 1.47, 0
29578, 0.55, 1.47, 0
29579, 0.53333333333333, 1.47, 0
29580, 0.51666666666667, 1.47, 0
29581, 0.5, 1.47, 0
29582, 0.48333333333333, 1.47, 0
29583, 0.46666666666667, 1.47, 0
29584, 0.45, 1.47, 0
29585, 0.43333333333333, 1.47, 0
29586, 0.41666666666667, 1.47, 0
29587, 0.4, 1.47, 0
29588, 0.38333333333333, 1.47, 0
29589, 0.36666666666667, 1.47, 0
29590, 0.35, 1.47, 0
29591, 0.33333333333333, 1.47, 0
29592, 0.31666666666667, 1.47, 0
29593, 0.3, 1.47, 0
29594, 0.28333333333333, 1.47, 0
29595, 0.26666666666667, 1.47, 0
29596, 0.25, 1.47, 0
29597, 0.23333333333333, 1.47, 0
29598, 0.21666666666667, 1.47, 0
29599, 0.2, 1.47, 0
29600, 0.18333333333333, 1.47, 0
29601, 0.16666666666667, 1.47, 0
29602, 0.15, 1.47, 0
29603, 0.13333333333333, 1.47, 0
29604, 0.11666666666667, 1.47, 0
29605, 0.1, 1.47, 0
29606, 0.083333333333333, 1.47, 0
29607, 0.066666666666667, 1.47, 0
29608, 0.05, 1.47, 0
29609, 0.033333333333333, 1.47, 0
29610, 0.016666666666667, 1.47, 0
29611, 0.98333333333333, 1.51, 0
29612, 0.96666666666667, 1.51, 0
29613, 0.95, 1.51, 0
29614, 0.93333333333333, 1.51, 0
29615, 0.91666666666667, 1.51, 0
29616, 0.9, 1.51, 0
29617, 0.88333333333333, 1.51, 0
29618, 0.86666666666667, 1.51, 0
29619, 0.85, 1.51, 0
29620, 0.83333333333333, 1.51, 0
29621, 0.81666666666667, 1.51, 0
29622, 0.8, 1.51, 0
29623, 0.78333333333333, 1.51, 0
29624, 0.76666666666667, 1.51, 0
29625, 0.75, 1.51, 0
29626, 0.73333333333333, 1.51, 0
29627, 0.71666666666667, 1.51, 0
29628, 0.7, 1.51, 0
29629, 0.68333333333333, 1.51, 0
29630, 0.66666666666667, 1.51, 0
29631, 0.65, 1.51, 0
29632, 0.63333333333333, 1.51, 0
29633, 0.61666666666667, 1.51, 0
29634, 0.6, 1.51, 0
29635, 0.58333333333333, 1.51, 0
29636, 0.56666666666667, 1.51, 0
29637, 0.55, 1.51, 0
29638, 0.53333333333333, 1.51, 0
29639, 0.51666666666667, 1.51, 0
29640, 0.5, 1.51, 0
29641, 0.48333333333333, 1.51, 0
29642, 0.46666666666667, 1.51, 0
29643, 0.45, 1.51, 0
29644, 0.43333333333333, 1.51, 0
29645, 0.41666666666667, 1.51, 0
29646, 0.4, 1.51, 0
29647, 0.38333333333333, 1.51, 0
29648, 0.36666666666667, 1.51, 0
29649, 0.35, 1.51, 0
29650, 0.33333333333333, 1.51, 0
29651, 0.31666666666667, 1.51, 0
29652, 0.3, 1.51, 0
29653, 0.28333333333333, 1.51, 0
29654, 0.26666666666667, 1.51, 0
29655, 0.25, 1.51, 0
29656, 0.23333333333333, 1.51, 0
29657, 0.21666666666667, 1.51, 0
29658, 0.2, 1.51, 0
29659, 0.18333333333333, 1.51, 0
29660, 0.16666666666667, 1.51, 0
29661, 0.15, 1.51, 0
29662, 0.13333333333333, 1.51, 0
29663, 0.11666666666667, 1.51, 0
29664, 0.1, 1.51, 0
29665, 0.083333333333333, 1.51, 0
29666, 0.066666666666667, 1.51, 0
29667, 0.05, 1.51, 0
29668, 0.033333333333333, 1.51, 0
29669, 0.016666666666667, 1.51, 0
29670, 0.99166666666667, 1.39, 0
29671, 0.98333333333333, 1.37, 0
29672, 0.975, 1.39, 0
29673, 0.96666666666667, 1.37, 0
29674, 0.95833333333333, 1.39, 0
29675, 0.95, 1.37, 0
29676, 0.94166666666667, 1.39, 0
29677, 0.93333333333333, 1.37, 0
29678, 0.925, 1.39, 0
29679, 0.91666666666667, 1.37, 0
29680, 0.90833333333333, 1.39, 0
29681, 0.9, 1.37, 0
29682, 0.89166666666667, 1.39, 0
29683, 0.88333333333333, 1.37, 0
29684, 0.875, 1.39, 0
29685, 0.86666666666667, 1.37, 0
29686, 0.85833333333333, 1.39, 0
29687, 0.85, 1.37, 0
29688, 0.84166666666667, 1.39, 0
29689, 0.83333333333333, 1.37, 0
29690, 0.825, 1.39, 0
29691, 0.81666666666667, 1.37, 0
29692, 0.80833333333333, 1.39, 0
29693, 0.8, 1.37, 0
29694, 0.79166666666667, 1.39, 0
29695, 0.78333333333333, 1.37, 0
29696, 0.775, 1.39, 0
29697, 0.76666666666667, 1.37, 0
29698, 0.75833333333333, 1.39, 0
29699, 0.75, 1.37, 0
29700, 0.74166666666667, 1.39, 0
29701, 0.73333333333333, 1.37, 0
29702, 0.725, 1.39, 0
29703, 0.71666666666667, 1.37, 0
29704, 0.70833333333333, 1.39, 0
29705, 0.7, 1.37, 0
29706, 0.69166666666667, 1.39, 0
29707, 0.68333333333333, 1.37, 0
29708, 0.675, 1.39, 0
29709, 0.66666666666667, 1.37, 0
29710, 0.65833333333333, 1.39, 0
29711, 0.65, 1.37, 0
29712, 0.64166666666667, 1.39, 0
29713, 0.63333333333333, 1.37, 0
29714, 0.625, 1.39, 0
29715, 0.61666666666667, 1.37, 0
29716, 0.60833333333333, 1.39, 0
29717, 0.6, 1.37, 0
29718, 0.59166666666667, 1.39, 0
29719, 0.58333333333333, 1.37, 0
29720, 0.575, 1.39, 0
29721, 0.56666666666667, 1.37, 0
29722, 0.55833333333333, 1.39, 0
29723, 0.55, 1.37, 0
29724, 0.54166666666667, 1.39, 0
29725, 0.53333333333333, 1.37, 0
29726, 0.525, 1.39, 0
29727, 0.51666666666667, 1.37, 0
29728, 0.50833333333333, 1.39, 0
29729, 0.5, 1.37, 0
29730, 0.49166666666667, 1.39, 0
29731, 0.48333333333333, 1.37, 0
29732, 0.475, 1.39, 0
29733, 0.46666666666667, 1.37, 0
29734, 0.45833333333333, 1.39, 0
29735, 0.45, 1.37, 0
29736, 0.44166666666667, 1.39, 0
29737, 0.43333333333333, 1.37, 0
29738, 0.425, 1.39, 0
29739, 0.41666666666667, 1.37, 0
29740, 0.40833333333333, 1.39, 0
29741, 0.4, 1.37, 0
29742, 0.39166666666667, 1.39, 0
29743, 0.38333333333333, 1.37, 0
29744, 0.375, 1.39, 0
29745, 0.36666666666667, 1.37, 0
29746, 0.35833333333333, 1.39, 0
29747, 0.35, 1.37, 0
29748, 0.34166666666667, 1.39, 0
29749, 0.33333333333333, 1.37, 0
29750, 0.325, 1.39, 0
29751, 0.31666666666667, 1.37, 0
29752, 0.30833333333333, 1.39, 0
29753, 0.3, 1.37, 0
29754, 0.29166666666667, 1.39, 0
29755, 0.28333333333333, 1.37, 0
29756, 0.275, 1.39, 0
29757, 0.26666666666667, 1.37, 0
29758, 0.25833333333333, 1.39, 0
29759, 0.25, 1.37, 0
29760, 0.24166666666667, 1.39, 0
29761, 0.23333333333333, 1.37, 0
29762, 0.225, 1.39, 0
29763, 0.21666666666667, 1.37, 0
29764, 0.20833333333333, 1.39, 0
29765, 0.2, 1.37, 0
29766, 0.19166666666667, 1.39, 0
29767, 0.18333333333333, 1.37, 0
29768, 0.175, 1.39, 0
29769, 0.16666666666667, 1.37, 0
29770, 0.15833333333333, 1.39, 0
29771, 0.15, 1.37, 0
29772, 0.14166666666667, 1.39, 0
29773, 0.13333333333333, 1.37, 0
29774, 0.125, 1.39, 0
29775, 0.11666666666667, 1.37, 0
29776, 0.10833333333333, 1.39, 0
29777, 0.1, 1.37, 0
29778, 0.091666666666667, 1.39, 0
29779, 0.083333333333333, 1.37, 0
29780, 0.075, 1.39, 0
29781, 0.066666666666667, 1.37, 0
29782, 0.058333333333333, 1.39, 0
29783, 0.05, 1.37, 0
29784, 0.041666666666667, 1.39, 0
29785, 0.033333333333333, 1.37, 0
29786, 0.025, 1.39, 0
29787, 0.016666666666667, 1.37, 0
29788, 0.0083333333333333, 1.39, 0
29789, 0.99166666666667, 1.43, 0
29790, 0.98333333333333, 1.41, 0
29791, 0.975, 1.43, 0
29792, 0.96666666666667, 1.41, 0
29793, 0.95833333333333, 1.43, 0
29794, 0.95, 1.41, 0
29795, 0.94166666666667, 1.43, 0
29796, 0.93333333333333, 1.41, 0
29797, 0.925, 1.43, 0
29798, 0.91666666666667, 1.41, 0
29799, 0.90833333333333, 1.43, 0
29800, 0.9, 1.41, 0
29801, 0.89166666666667, 1.43, 0
29802, 0.88333333333333, 1.41, 0
29803, 0.875, 1.43, 0
29804, 0.86666666666667, 1.41, 0
29805, 0.85833333333333, 1.43, 0
29806, 0.85, 1.41, 0
29807, 0.84166666666667, 1.43, 0
29808, 0.83333333333333, 1.41, 0
29809, 0.825, 1.43, 0
29810, 0.81666666666667, 1.41, 0
29811, 0.80833333333333, 1.43, 0
29812, 0.8, 1.41, 0
29813, 0.79166666666667, 1.43, 0
29814, 0.78333333333333, 1.41, 0
29815, 0.775, 1.43, 0
29816, 0.76666666666667, 1.41, 0
29817, 0.75833333333333, 1.43, 0
29818, 0.75, 1.41, 0
29819, 0.74166666666667, 1.43, 0
29820, 0.73333333333333, 1.41, 0
29821, 0.725, 1.43, 0
29822, 0.71666666666667, 1.41, 0
29823, 0.70833333333333, 1.43, 0
29824, 0.7, 1.41, 0
29825, 0.69166666666667, 1.43, 0
29826, 0.68333333333333, 1.41, 0
29827, 0.675, 1.43, 0
29828, 0.66666666666667, 1.41, 0
29829, 0.65833333333333, 1.43, 0
29830, 0.65, 1.41, 0
29831, 0.64166666666667, 1.43, 0
29832, 0.63333333333333, 1.41, 0
29833, 0.625, 1.43, 0
29834, 0.61666666666667, 1.41, 0
29835, 0.60833333333333, 1.43, 0
29836, 0.6, 1.41, 0
29837, 0.59166666666667, 1.43, 0
29838, 0.58333333333333, 1.41, 0
29839, 0.575, 1.43, 0
29840, 0.56666666666667, 1.41, 0
29841, 0.55833333333333, 1.43, 0
29842, 0.55, 1.41, 0
29843, 0.54166666666667, 1.43, 0
29844, 0.53333333333333, 1.41, 0
29845, 0.525, 1.43, 0
29846, 0.51666666666667, 1.41, 0
29847, 0.50833333333333, 1.43, 0
29848, 0.5, 1.41, 0
29849, 0.49166666666667, 1.43, 0
29850, 0.48333333333333, 1.41, 0
29851, 0.475, 1.43, 0
29852, 0.46666666666667, 1.41, 0
29853, 0.45833333333333, 1.43, 0
29854, 0.45, 1.41, 0
29855, 0.44166666666667, 1.43, 0
29856, 0.43333333333333, 1.41, 0
29857, 0.425, 1.43, 0
29858, 0.41666666666667, 1.41, 0
29859, 0.40833333333333, 1.43, 0
29860, 0.4, 1.41, 0
29861, 0.39166666666667, 1.43, 0
29862, 0.38333333333333, 1.41, 0
29863, 0.375, 1.43, 0
29864, 0.36666666666667, 1.41, 0
29865, 0.35833333333333, 1.43, 0
29866, 0.35, 1.41, 0
29867, 0.34166666666667, 1.43, 0
29868, 0.33333333333333, 1.41, 0
29869, 0.325, 1.43, 0
29870, 0.31666666666667, 1.41, 0
29871, 0.30833333333333, 1.43, 0
29872, 0.3, 1.41, 0
29873, 0.29166666666667, 1.43, 0
29874, 0.28333333333333, 1.41, 0
29875, 0.275, 1.43, 0
29876, 0.26666666666667, 1.41, 0
29877, 0.25833333333333, 1.43, 0
29878, 0.25, 1.41, 0
29879, 0.24166666666667, 1.43, 0
29880, 0.23333333333333, 1.41, 0
29881, 0.225, 1.43, 0
29882, 0.21666666666667, 1.41, 0
29883, 0.20833333333333, 1.43, 0
29884, 0.2, 1.41, 0
29885, 0.19166666666667, 1.43, 0
29886, 0.18333333333333, 1.41, 0
29887, 0.175, 1.43, 0
29888, 0.16666666666667, 1.41, 0
29889, 0.15833333333333, 1.43, 0
29890, 0.15, 1.41, 0
29891, 0.14166666666667, 1.43, 0
29892, 0.13333333333333, 1.41, 0
29893, 0.125, 1.43, 0
29894, 0.11666666666667, 1.41, 0
29895, 0.10833333333333, 1.43, 0
29896, 0.1, 1.41, 0
29897, 0.091666666666667, 1.43, 0
29898, 0.083333333333333, 1.41, 0
29899, 0.075, 1.43, 0
29900, 0.066666666666667, 1.41, 0
29901, 0.058333333333333, 1.43, 0
29902, 0.05, 1.41, 0
29903, 0.041666666666667, 1.43, 0
29904, 0.033333333333333, 1.41, 0
29905, 0.025, 1.43, 0
29906, 0.016666666666667, 1.41, 0
29907, 0.0083333333333333, 1.43, 0
29908, 0.99166666666667, 1.47, 0
29909, 0.98333333333333, 1.45, 0
29910, 0.975, 1.47, 0
29911, 0.96666666666667, 1.45, 0
29912, 0.95833333333333, 1.47, 0
29913, 0.95, 1.45, 0
29914, 0.94166666666667, 1.47, 0
29915, 0.93333333333333, 1.45, 0
29916, 0.925, 1.47, 0
29917, 0.91666666666667, 1.45, 0
29918, 0.90833333333333, 1.47, 0
29919, 0.9, 1.45, 0
29920, 0.89166666666667, 1.47, 0
29921, 0.88333333333333, 1.45, 0
29922, 0.875, 1.47, 0
29923, 0.86666666666667, 1.45, 0
29924, 0.85833333333333, 1.47, 0
29925, 0.85, 1.45, 0
29926, 0.84166666666667, 1.47, 0
29927, 0.83333333333333, 1.45, 0
29928, 0.825, 1.47, 0
29929, 0.81666666666667, 1.45, 0
29930, 0.80833333333333, 1.47, 0
29931, 0.8, 1.45, 0
29932, 0.79166666666667, 1.47, 0
29933, 0.78333333333333, 1.45, 0
29934, 0.775, 1.47, 0
29935, 0.76666666666667, 1.45, 0
29936, 0.75833333333333, 1.47, 0
29937, 0.75, 1.45, 0
29938, 0.74166666666667, 1.47, 0
29939, 0.73333333333333, 1.45, 0
29940, 0.725, 1.47, 0
29941, 0.71666666666667, 1.45, 0
29942, 0.70833333333333, 1.47, 0
29943, 0.7, 1.45, 0
29944, 0.69166666666667, 1.47, 0
29945, 0.68333333333333, 1.45, 0
29946, 0.675, 1.47, 0
29947, 0.66666666666667, 1.45, 0
29948, 0.65833333333333, 1.47, 0
29949, 0.65, 1.45, 0
29950, 0.64166666666667, 1.47, 0
29951, 0.63333333333333, 1.45, 0
29952, 0.625, 1.47, 0
29953, 0.61666666666667, 1.45, 0
29954, 0.60833333333333, 1.47, 0
29955, 0.6, 1.45, 0
29956, 0.59166666666667, 1.47, 0
29957, 0.58333333333333, 1.45, 0
29958, 0.575, 1.47, 0
29959, 0.56666666666667, 1.45, 0
29960, 0.55833333333333, 1.47, 0
29961, 0.55, 1.45, 0
29962, 0.54166666666667, 1.47, 0
29963, 0.53333333333333, 1.45, 0
29964, 0.525, 1.47, 0
29965, 0.51666666666667, 1.45, 0
29966, 0.50833333333333, 1.47, 0
29967, 0.5, 1.45, 0
29968, 0.49166666666667, 1.47, 0
29969, 0.48333333333333, 1.45, 0
29970, 0.475, 1.47, 0
29971, 0.46666666666667, 1.45, 0
29972, 0.45833333333333, 1.47, 0
29973, 0.45, 1.45, 0
29974, 0.44166666666667, 1.47, 0
29975, 0.43333333333333, 1.45, 0
29976, 0.425, 1.47, 0
29977, 0.41666666666667, 1.45, 0
29978, 0.40833333333333, 1.47, 0
29979, 0.4, 1.45, 0
29980, 0.39166666666667, 1.47, 0
29981, 0.38333333333333, 1.45, 0
29982, 0.375, 1.47, 0
29983, 0.36666666666667, 1.45, 0
29984, 0.35833333333333, 1.47, 0
29985, 0.35, 1.45, 0
29986, 0.34166666666667, 1.47, 0
29987, 0.33333333333333, 1.45, 0
29988, 0.325, 1.47, 0
29989, 0.31666666666667, 1.45, 0
29990, 0.30833333333333, 1.47, 0
29991, 0.3, 1.45, 0
29992, 0.29166666666667, 1.47, 0
29993, 0.28333333333333, 1.45, 0
29994, 0.275, 1.47, 0
29995, 0.26666666666667, 1.45, 0
29996, 0.25833333333333, 1.47, 0
29997, 0.25, 1.45, 0
29998, 0.24166666666667, 1.47, 0
29999, 0.23333333333333, 1.45, 0
30000, 0.225, 1.47, 0
30001, 0.21666666666667, 1.45, 0
30002, 0.20833333333333, 1.47, 0
30003, 0.2, 1.45, 0
30004, 0.19166666666667, 1.47, 0
30005, 0.18333333333333, 1.45, 0
30006, 0.175, 1.47, 0
30007, 0.16666666666667, 1.45, 0
30008, 0.15833333333333, 1.47, 0
30009, 0.15, 1.45, 0
30010, 0.14166666666667, 1.47, 0
30011, 0.13333333333333, 1.45, 0
30012, 0.125, 1.47, 0
30013, 0.11666666666667, 1.45, 0
30014, 0.10833333333333, 1.47, 0
30015, 0.1, 1.45, 0
30016, 0.091666666666667, 1.47, 0
30017, 0.083333333333333, 1.45, 0
30018, 0.075, 1.47, 0
30019, 0.066666666666667, 1.45, 0
30020, 0.058333333333333, 1.47, 0
30021, 0.05, 1.45, 0
30022, 0.041666666666667, 1.47, 0
30023, 0.033333333333333, 1.45, 0
30024, 0.025, 1.47, 0
30025, 0.016666666666667, 1.45, 0
30026, 0.0083333333333333, 1.47, 0
30027, 0.99166666666667, 1.51, 0
30028, 0.98333333333333, 1.49, 0
30029, 0.975, 1.51, 0
30030, 0.96666666666667, 1.49, 0
30031, 0.95833333333333, 1.51, 0
30032, 0.95, 1.49, 0
30033, 0.94166666666667, 1.51, 0
30034, 0.93333333333333, 1.49, 0
30035, 0.925, 1.51, 0
30036, 0.91666666666667, 1.49, 0
30037, 0.90833333333333, 1.51, 0
30038, 0.9, 1.49, 0
30039, 0.89166666666667, 1.51, 0
30040, 0.88333333333333, 1.49, 0
30041, 0.875, 1.51, 0
30042, 0.86666666666667, 1.49, 0
30043, 0.85833333333333, 1.51, 0
30044, 0.85, 1.49, 0
30045, 0.84166666666667, 1.51, 0
30046, 0.83333333333333, 1.49, 0
30047, 0.825, 1.51, 0
30048, 0.81666666666667, 1.49, 0
30049, 0.80833333333333, 1.51, 0
30050, 0.8, 1.49, 0
30051, 0.79166666666667, 1.51, 0
30052, 0.78333333333333, 1.49, 0
30053, 0.775, 1.51, 0
30054, 0.76666666666667, 1.49, 0
30055, 0.75833333333333, 1.51, 0
30056, 0.75, 1.49, 0
30057, 0.74166666666667, 1.51, 0
30058, 0.73333333333333, 1.49, 0
30059, 0.725, 1.51, 0
30060, 0.71666666666667, 1.49, 0
30061, 0.70833333333333, 1.51, 0
30062, 0.7, 1.49, 0
30063, 0.69166666666667, 1.51, 0
30064, 0.68333333333333, 1.49, 0
30065, 0.675, 1.51, 0
30066, 0.66666666666667, 1.49, 0
30067, 0.65833333333333, 1.51, 0
30068, 0.65, 1.49, 0
30069, 0.64166666666667, 1.51, 0
30070, 0.63333333333333, 1.49, 0
30071, 0.625, 1.51, 0
30072, 0.61666666666667, 1.49, 0
30073, 0.60833333333333, 1.51, 0
30074, 0.6, 1.49, 0
30075, 0.59166666666667, 1.51, 0
30076, 0.58333333333333, 1.49, 0
30077, 0.575, 1.51, 0
30078, 0.56666666666667, 1.49, 0
30079, 0.55833333333333, 1.51, 0
30080, 0.55, 1.49, 0
30081, 0.54166666666667, 1.51, 0
30082, 0.53333333333333, 1.49, 0
30083, 0.525, 1.51, 0
30084, 0.51666666666667, 1.49, 0
30085, 0.50833333333333, 1.51, 0
30086, 0.5, 1.49, 0
30087, 0.49166666666667, 1.51, 0
30088, 0.48333333333333, 1.49, 0
30089, 0.475, 1.51, 0
30090, 0.46666666666667, 1.49, 0
30091, 0.45833333333333, 1.51, 0
30092, 0.45, 1.49, 0
30093, 0.44166666666667, 1.51, 0
30094, 0.43333333333333, 1.49, 0
30095, 0.425, 1.51, 0
30096, 0.41666666666667, 1.49, 0
30097, 0.40833333333333, 1.51, 0
30098, 0.4, 1.49, 0
30099, 0.39166666666667, 1.51, 0
30100, 0.38333333333333, 1.49, 0
30101, 0.375, 1.51, 0
30102, 0.36666666666667, 1.49, 0
30103, 0.35833333333333, 1.51, 0
30104, 0.35, 1.49, 0
30105, 0.34166666666667, 1.51, 0
30106, 0.33333333333333, 1.49, 0
30107, 0.325, 1.51, 0
30108, 0.31666666666667, 1.49, 0
30109, 0.30833333333333, 1.51, 0
30110, 0.3, 1.49, 0
30111, 0.29166666666667, 1.51, 0
30112, 0.28333333333333, 1.49, 0
30113, 0.275, 1.51, 0
30114, 0.26666666666667, 1.49, 0
30115, 0.25833333333333, 1.51, 0
30116, 0.25, 1.49, 0
30117, 0.24166666666667, 1.51, 0
30118, 0.23333333333333, 1.49, 0
30119, 0.225, 1.51, 0
30120, 0.21666666666667, 1.49, 0
30121, 0.20833333333333, 1.51, 0
30122, 0.2, 1.49, 0
30123, 0.19166666666667, 1.51, 0
30124, 0.18333333333333, 1.49, 0
30125, 0.175, 1.51, 0
30126, 0.16666666666667, 1.49, 0
30127, 0.15833333333333, 1.51, 0
30128, 0.15, 1.49, 0
30129, 0.14166666666667, 1.51, 0
30130, 0.13333333333333, 1.49, 0
30131, 0.125, 1.51, 0
30132, 0.11666666666667, 1.49, 0
30133, 0.10833333333333, 1.51, 0
30134, 0.1, 1.49, 0
30135, 0.091666666666667, 1.51, 0
30136, 0.083333333333333, 1.49, 0
30137, 0.075, 1.51, 0
30138, 0.066666666666667, 1.49, 0
30139, 0.058333333333333, 1.51, 0
30140, 0.05, 1.49, 0
30141, 0.041666666666667, 1.51, 0
30142, 0.033333333333333, 1.49, 0
30143, 0.025, 1.51, 0
30144, 0.016666666666667, 1.49, 0
30145, 0.0083333333333333, 1.51, 0
30146, 0.98333333333333, 1.53, 0
30147, 0.96666666666667, 1.53, 0
30148, 0.95, 1.53, 0
30149, 0.93333333333333, 1.53, 0
30150, 0.91666666666667, 1.53, 0
30151, 0.9, 1.53, 0
30152, 0.88333333333333, 1.53, 0
30153, 0.86666666666667, 1.53, 0
30154, 0.85, 1.53, 0
30155, 0.83333333333333, 1.53, 0
30156, 0.81666666666667, 1.53, 0
30157, 0.8, 1.53, 0
30158, 0.78333333333333, 1.53, 0
30159, 0.76666666666667, 1.53, 0
30160, 0.75, 1.53, 0
30161, 0.73333333333333, 1.53, 0
30162, 0.71666666666667, 1.53, 0
30163, 0.7, 1.53, 0
30164, 0.68333333333333, 1.53, 0
30165, 0.66666666666667, 1.53, 0
30166, 0.65, 1.53, 0
30167, 0.63333333333333, 1.53, 0
30168, 0.61666666666667, 1.53, 0
30169, 0.6, 1.53, 0
30170, 0.58333333333333, 1.53, 0
30171, 0.56666666666667, 1.53, 0
30172, 0.55, 1.53, 0
30173, 0.53333333333333, 1.53, 0
30174, 0.51666666666667, 1.53, 0
30175, 0.5, 1.53, 0
30176, 0.48333333333333, 1.53, 0
30177, 0.46666666666667, 1.53, 0
30178, 0.45, 1.53, 0
30179, 0.43333333333333, 1.53, 0
30180, 0.41666666666667, 1.53, 0
30181, 0.4, 1.53, 0
30182, 0.38333333333333, 1.53, 0
30183, 0.36666666666667, 1.53, 0
30184, 0.35, 1.53, 0
30185, 0.33333333333333, 1.53, 0
30186, 0.31666666666667, 1.53, 0
30187, 0.3, 1.53, 0
30188, 0.28333333333333, 1.53, 0
30189, 0.26666666666667, 1.53, 0
30190, 0.25, 1.53, 0
30191, 0.23333333333333, 1.53, 0
30192, 0.21666666666667, 1.53, 0
30193, 0.2, 1.53, 0
30194, 0.18333333333333, 1.53, 0
30195, 0.16666666666667, 1.53, 0
30196, 0.15, 1.53, 0
30197, 0.13333333333333, 1.53, 0
30198, 0.11666666666667, 1.53, 0
30199, 0.1, 1.53, 0
30200, 0.083333333333333, 1.53, 0
30201, 0.066666666666667, 1.53, 0
30202, 0.05, 1.53, 0
30203, 0.033333333333333, 1.53, 0
30204, 0.016666666666667, 1.53, 0
30205, 1.025, 1.39, 0
30206, 1.025, 1.43, 0
30207, 1.025, 1.47, 0
30208, 1.025, 1.51, 0
30209, 1.05, 1.39, 0
30210, 1.05, 1.43, 0
30211, 1.05, 1.47, 0
30212, 1.05, 1.51, 0
30213, 1.075, 1.39, 0
30214, 1.075, 1.43, 0
30215, 1.075, 1.47, 0
30216, 1.075, 1.51, 0
30217, 1.1, 1.39, 0
30218, 1.1, 1.43, 0
30219, 1.1, 1.47, 0
30220, 1.1, 1.51, 0
30221, 1.125, 1.39, 0
30222, 1.125, 1.43, 0
30223, 1.125, 1.47, 0
30224, 1.125, 1.51, 0
30225, 1.15, 1.39, 0
30226, 1.15, 1.43, 0
30227, 1.15, 1.47, 0
30228, 1.15, 1.51, 0
30229, 1.175, 1.39, 0
30230, 1.175, 1.43, 0
30231, 1.175, 1.47, 0
30232, 1.175, 1.51, 0
30233, 1.025, 1.37, 0
30234, 1.0125, 1.39, 0
30235, 1.025, 1.41, 0
30236, 1.0125, 1.43, 0
30237, 1.025, 1.45, 0
30238, 1.0125, 1.47, 0
30239, 1.025, 1.49, 0
30240, 1.0125, 1.51, 0
30241, 1.025, 1.53, 0
30242, 1.05, 1.37, 0
30243, 1.0375, 1.39, 0
30244, 1.05, 1.41, 0
30245, 1.0375, 1.43, 0
30246, 1.05, 1.45, 0
30247, 1.0375, 1.47, 0
30248, 1.05, 1.49, 0
30249, 1.0375, 1.51, 0
30250, 1.05, 1.53, 0
30251, 1.075, 1.37, 0
30252, 1.0625, 1.39, 0
30253, 1.075, 1.41, 0
30254, 1.0625, 1.43, 0
30255, 1.075, 1.45, 0
30256, 1.0625, 1.47, 0
30257, 1.075, 1.49, 0
30258, 1.0625, 1.51, 0
30259, 1.075, 1.53, 0
30260, 1.1, 1.37, 0
30261, 1.0875, 1.39, 0
30262, 1.1, 1.41, 0
30263, 1.0875, 1.43, 0
30264, 1.1, 1.45, 0
30265, 1.0875, 1.47, 0
30266, 1.1, 1.49, 0
30267, 1.0875, 1.51, 0
30268, 1.1, 1.53, 0
30269, 1.125, 1.37, 0
30270, 1.1125, 1.39, 0
30271, 1.125, 1.41, 0
30272, 1.1125, 1.43, 0
30273, 1.125, 1.45, 0
30274, 1.1125, 1.47, 0
30275, 1.125, 1.49, 0
30276, 1.1125, 1.51, 0
30277, 1.125, 1.53, 0
30278, 1.15, 1.37, 0
30279, 1.1375, 1.39, 0
30280, 1.15, 1.41, 0
30281, 1.1375, 1.43, 0
30282, 1.15, 1.45, 0
30283, 1.1375, 1.47, 0
30284, 1.15, 1.49, 0
30285, 1.1375, 1.51, 0
30286, 1.15, 1.53, 0
30287, 1.175, 1.37, 0
30288, 1.1625, 1.39, 0
30289, 1.175, 1.41, 0
30290, 1.1625, 1.43, 0
30291, 1.175, 1.45, 0
30292, 1.1625, 1.47, 0
30293, 1.175, 1.49, 0
30294, 1.1625, 1.51, 0
30295, 1.175, 1.53, 0
30296, 1.1875, 1.39, 0
30297, 1.1875, 1.43, 0
30298, 1.1875, 1.47, 0
30299, 1.1875, 1.51, 0
30300, 2.2333333333333, -0.066666666666667, 0
30301, 2.2666666666667, -0.066666666666667, 0
30302, 2.2333333333333, -0.083333333333333, 0
30303, 2.2666666666667, -0.083333333333333, 0
30304, 2.2333333333333, -0.1, 0
30305, 2.2666666666667, -0.1, 0
30306, 2.2333333333333, -0.11666666666667, 0
30307, 2.2666666666667, -0.11666666666667, 0
30308, 2.2333333333333, -0.13333333333333, 0
30309, 2.2666666666667, -0.13333333333333, 0
30310, 2.2166666666667, -0.066666666666667, 0
30311, 2.2333333333333, -0.058333333333333, 0
30312, 2.25, -0.066666666666667, 0
30313, 2.2666666666667, -0.058333333333333, 0
30314, 2.2833333333333, -0.066666666666667, 0
30315, 2.2166666666667, -0.083333333333333, 0
30316, 2.2333333333333, -0.075, 0
30317, 2.25, -0.083333333333333, 0
30318, 2.2666666666667, -0.075, 0
30319, 2.2833333333333, -0.083333333333333, 0
30320, 2.2166666666667, -0.1, 0
30321, 2.2333333333333, -0.091666666666667, 0
30322, 2.25, -0.1, 0
30323, 2.2666666666667, -0.091666666666667, 0
30324, 2.2833333333333, -0.1, 0
30325, 2.2166666666667, -0.11666666666667, 0
30326, 2.2333333333333, -0.10833333333333, 0
30327, 2.25, -0.11666666666667, 0
30328, 2.2666666666667, -0.10833333333333, 0
30329, 2.2833333333333, -0.11666666666667, 0
30330, 2.2166666666667, -0.13333333333333, 0
30331, 2.2333333333333, -0.125, 0
30332, 2.25, -0.13333333333333, 0
30333, 2.2666666666667, -0.125, 0
30334, 2.2833333333333, -0.13333333333333, 0
30335, 2.2333333333333, -0.14166666666667, 0
30336, 2.2666666666667, -0.14166666666667, 0
30337, -0.033333333333333, -0.19, 0
30338, -0.066666666666667, -0.19, 0
30339, -0.033333333333333, -0.23, 0
30340, -0.066666666666667, -0.23, 0
30341, -0.033333333333333, -0.27, 0
30342, -0.066666666666667, -0.27, 0
30343, -0.033333333333333, -0.31, 0
30344, -0.066666666666667, -0.31, 0
30345, -0.033333333333333, -0.17, 0
30346, -0.016666666666667, -0.19, 0
30347, -0.066666666666667, -0.17, 0
30348, -0.05, -0.19, 0
30349, -0.083333333333333, -0.19, 0
30350, -0.033333333333333, -0.21, 0
30351, -0.016666666666667, -0.23, 0
30352, -0.066666666666667, -0.21, 0
30353, -0.05, -0.23, 0
30354, -0.083333333333333, -0.23, 0
30355, -0.033333333333333, -0.25, 0
30356, -0.016666666666667, -0.27, 0
30357, -0.066666666666667, -0.25, 0
30358, -0.05, -0.27, 0
30359, -0.083333333333333, -0.27, 0
30360, -0.033333333333333, -0.29, 0
30361, -0.016666666666667, -0.31, 0
30362, -0.066666666666667, -0.29, 0
30363, -0.05, -0.31, 0
30364, -0.083333333333333, -0.31, 0
30365, -0.033333333333333, -0.33, 0
30366, -0.066666666666667, -0.33, 0
30367, 1.2166666666667, 1.39, 0
30368, 1.2333333333333, 1.39, 0
30369, 1.25, 1.39, 0
30370, 1.2666666666667, 1.39, 0
30371, 1.2833333333333, 1.39, 0
30372, 1.3, 1.39, 0
30373, 1.3166666666667, 1.39, 0
30374, 1.3333333333333, 1.39, 0
30375, 1.35, 1.39, 0
30376, 1.3666666666667, 1.39, 0
30377, 1.3833333333333, 1.39, 0
30378, 1.4, 1.39, 0
30379, 1.4166666666667, 1.39, 0
30380, 1.4333333333333, 1.39, 0
30381, 1.45, 1.39, 0
30382, 1.4666666666667, 1.39, 0
30383, 1.4833333333333, 1.39, 0
30384, 1.5, 1.39, 0
30385, 1.5166666666667, 1.39, 0
30386, 1.5333333333333, 1.39, 0
30387, 1.55, 1.39, 0
30388, 1.5666666666667, 1.39, 0
30389, 1.5833333333333, 1.39, 0
30390, 1.6, 1.39, 0
30391, 1.6166666666667, 1.39, 0
30392, 1.6333333333333, 1.39, 0
30393, 1.65, 1.39, 0
30394, 1.6666666666667, 1.39, 0
30395, 1.6833333333333, 1.39, 0
30396, 1.7, 1.39, 0
30397, 1.7166666666667, 1.39, 0
30398, 1.7333333333333, 1.39, 0
30399, 1.75, 1.39, 0
30400, 1.7666666666667, 1.39, 0
30401, 1.7833333333333, 1.39, 0
30402, 1.8, 1.39, 0
30403, 1.8166666666667, 1.39, 0
30404, 1.8333333333333, 1.39, 0
30405, 1.85, 1.39, 0
30406, 1.8666666666667, 1.39, 0
30407, 1.8833333333333, 1.39, 0
30408, 1.9, 1.39, 0
30409, 1.9166666666667, 1.39, 0
30410, 1.9333333333333, 1.39, 0
30411, 1.95, 1.39, 0
30412, 1.9666666666667, 1.39, 0
30413, 1.9833333333333, 1.39, 0
30414, 2, 1.39, 0
30415, 2.0166666666667, 1.39, 0
30416, 2.0333333333333, 1.39, 0
30417, 2.05, 1.39, 0
30418, 2.0666666666667, 1.39, 0
30419, 2.0833333333333, 1.39, 0
30420, 2.1, 1.39, 0
30421, 2.1166666666667, 1.39, 0
30422, 2.1333333333333, 1.39, 0
30423, 2.15, 1.39, 0
30424, 2.1666666666667, 1.39, 0
30425, 2.1833333333333, 1.39, 0
30426, 1.2166666666667, 1.43, 0
30427, 1.2333333333333, 1.43, 0
30428, 1.25, 1.43, 0
30429, 1.2666666666667, 1.43, 0
30430, 1.2833333333333, 1.43, 0
30431, 1.3, 1.43, 0
30432, 1.3166666666667, 1.43, 0
30433, 1.3333333333333, 1.43, 0
30434, 1.35, 1.43, 0
30435, 1.3666666666667, 1.43, 0
30436, 1.3833333333333, 1.43, 0
30437, 1.4, 1.43, 0
30438, 1.4166666666667, 1.43, 0
30439, 1.4333333333333, 1.43, 0
30440, 1.45, 1.43, 0
30441, 1.4666666666667, 1.43, 0
30442, 1.4833333333333, 1.43, 0
30443, 1.5, 1.43, 0
30444, 1.5166666666667, 1.43, 0
30445, 1.5333333333333, 1.43, 0
30446, 1.55, 1.43, 0
30447, 1.5666666666667, 1.43, 0
30448, 1.5833333333333, 1.43, 0
30449, 1.6, 1.43, 0
30450, 1.6166666666667, 1.43, 0
30451, 1.6333333333333, 1.43, 0
30452, 1.65, 1.43, 0
30453, 1.6666666666667, 1.43, 0
30454, 1.6833333333333, 1.43, 0
30455, 1.7, 1.43, 0
30456, 1.7166666666667, 1.43, 0
30457, 1.7333333333333, 1.43, 0
30458, 1.75, 1.43, 0
30459, 1.7666666666667, 1.43, 0
30460, 1.7833333333333, 1.43, 0
30461, 1.8, 1.43, 0
30462, 1.8166666666667, 1.43, 0
30463, 1.8333333333333, 1.43, 0
30464, 1.85, 1.43, 0
30465, 1.8666666666667, 1.43, 0
30466, 1.8833333333333, 1.43, 0
30467, 1.9, 1.43, 0
30468, 1.9166666666667, 1.43, 0
30469, 1.9333333333333, 1.43, 0
30470, 1.95, 1.43, 0
30471, 1.9666666666667, 1.43, 0
30472, 1.9833333333333, 1.43, 0
30473, 2, 1.43, 0
30474, 2.0166666666667, 1.43, 0
30475, 2.0333333333333, 1.43, 0
30476, 2.05, 1.43, 0
30477, 2.0666666666667, 1.43, 0
30478, 2.0833333333333, 1.43, 0
30479, 2.1, 1.43, 0
30480, 2.1166666666667, 1.43, 0
30481, 2.1333333333333, 1.43, 0
30482, 2.15, 1.43, 0
30483, 2.1666666666667, 1.43, 0
30484, 2.1833333333333, 1.43, 0
30485, 1.2166666666667, 1.47, 0
30486, 1.2333333333333, 1.47, 0
30487, 1.25, 1.47, 0
30488, 1.2666666666667, 1.47, 0
30489, 1.2833333333333, 1.47, 0
30490, 1.3, 1.47, 0
30491, 1.3166666666667, 1.47, 0
30492, 1.3333333333333, 1.47, 0
30493, 1.35, 1.47, 0
30494, 1.3666666666667, 1.47, 0
30495, 1.3833333333333, 1.47, 0
30496, 1.4, 1.47, 0
30497, 1.4166666666667, 1.47, 0
30498, 1.4333333333333, 1.47, 0
30499, 1.45, 1.47, 0
30500, 1.4666666666667, 1.47, 0
30501, 1.4833333333333, 1.47, 0
30502, 1.5, 1.47, 0
30503, 1.5166666666667, 1.47, 0
30504, 1.5333333333333, 1.47, 0
30505, 1.55, 1.47, 0
30506, 1.5666666666667, 1.47, 0
30507, 1.5833333333333, 1.47, 0
30508, 1.6, 1.47, 0
30509, 1.6166666666667, 1.47, 0
30510, 1.6333333333333, 1.47, 0
30511, 1.65, 1.47, 0
30512, 1.6666666666667, 1.47, 0
30513, 1.6833333333333, 1.47, 0
30514, 1.7, 1.47, 0
30515, 1.7166666666667, 1.47, 0
30516, 1.7333333333333, 1.47, 0
30517, 1.75, 1.47, 0
30518, 1.7666666666667, 1.47, 0
30519, 1.7833333333333, 1.47, 0
30520, 1.8, 1.47, 0
30521, 1.8166666666667, 1.47, 0
30522, 1.8333333333333, 1.47, 0
30523, 1.85, 1.47, 0
30524, 1.8666666666667, 1.47, 0
30525, 1.8833333333333, 1.47, 0
30526, 1.9, 1.47, 0
30527, 1.9166666666667, 1.47, 0
30528, 1.9333333333333, 1.47, 0
30529, 1.95, 1.47, 0
30530, 1.9666666666667, 1.47, 0
30531, 1.9833333333333, 1.47, 0
30532, 2, 1.47, 0
30533, 2.0166666666667, 1.47, 0
30534, 2.0333333333333, 1.47, 0
30535, 2.05, 1.47, 0
30536, 2.0666666666667, 1.47, 0
30537, 2.0833333333333, 1.47, 0
30538, 2.1, 1.47, 0
30539, 2.1166666666667, 1.47, 0
30540, 2.1333333333333, 1.47, 0
30541, 2.15, 1.47, 0
30542, 2.1666666666667, 1.47, 0
30543, 2.1833333333333, 1.47, 0
30544, 1.2166666666667, 1.51, 0
30545, 1.2333333333333, 1.51, 0
30546, 1.25, 1.51, 0
30547, 1.2666666666667, 1.51, 0
30548, 1.2833333333333, 1.51, 0
30549, 1.3, 1.51, 0
30550, 1.3166666666667, 1.51, 0
30551, 1.3333333333333, 1.51, 0
30552, 1.35, 1.51, 0
30553, 1.3666666666667, 1.51, 0
30554, 1.3833333333333, 1.51, 0
30555, 1.4, 1.51, 0
30556, 1.4166666666667, 1.51, 0
30557, 1.4333333333333, 1.51, 0
30558, 1.45, 1.51, 0
30559, 1.4666666666667, 1.51, 0
30560, 1.4833333333333, 1.51, 0
30561, 1.5, 1.51, 0
30562, 1.5166666666667, 1.51, 0
30563, 1.5333333333333, 1.51, 0
30564, 1.55, 1.51, 0
30565, 1.5666666666667, 1.51, 0
30566, 1.5833333333333, 1.51, 0
30567, 1.6, 1.51, 0
30568, 1.6166666666667, 1.51, 0
30569, 1.6333333333333, 1.51, 0
30570, 1.65, 1.51, 0
30571, 1.6666666666667, 1.51, 0
30572, 1.6833333333333, 1.51, 0
30573, 1.7, 1.51, 0
30574, 1.7166666666667, 1.51, 0
30575, 1.7333333333333, 1.51, 0
30576, 1.75, 1.51, 0
30577, 1.7666666666667, 1.51, 0
30578, 1.7833333333333, 1.51, 0
30579, 1.8, 1.51, 0
30580, 1.8166666666667, 1.51, 0
30581, 1.8333333333333, 1.51, 0
30582, 1.85, 1.51, 0
30583, 1.8666666666667, 1.51, 0
30584, 1.8833333333333, 1.51, 0
30585, 1.9, 1.51, 0
30586, 1.9166666666667, 1.51, 0
30587, 1.9333333333333, 1.51, 0
30588, 1.95, 1.51, 0
30589, 1.9666666666667, 1.51, 0
30590, 1.9833333333333, 1.51, 0
30591, 2, 1.51, 0
30592, 2.0166666666667, 1.51, 0
30593, 2.0333333333333, 1.51, 0
30594, 2.05, 1.51, 0
30595, 2.0666666666667, 1.51, 0
30596, 2.0833333333333, 1.51, 0
30597, 2.1, 1.51, 0
30598, 2.1166666666667, 1.51, 0
30599, 2.1333333333333, 1.51, 0
30600, 2.15, 1.51, 0
30601, 2.1666666666667, 1.51, 0
30602, 2.1833333333333, 1.51, 0
30603, 1.2166666666667, 1.37, 0
30604, 1.2083333333333, 1.39, 0
30605, 1.2333333333333, 1.37, 0
30606, 1.225, 1.39, 0
30607, 1.25, 1.37, 0
30608, 1.2416666666667, 1.39, 0
30609, 1.2666666666667, 1.37, 0
30610, 1.2583333333333, 1.39, 0
30611, 1.2833333333333, 1.37, 0
30612, 1.275, 1.39, 0
30613, 1.3, 1.37, 0
30614, 1.2916666666667, 1.39, 0
30615, 1.3166666666667, 1.37, 0
30616, 1.3083333333333, 1.39, 0
30617, 1.3333333333333, 1.37, 0
30618, 1.325, 1.39, 0
30619, 1.35, 1.37, 0
30620, 1.3416666666667, 1.39, 0
30621, 1.3666666666667, 1.37, 0
30622, 1.3583333333333, 1.39, 0
30623, 1.3833333333333, 1.37, 0
30624, 1.375, 1.39, 0
30625, 1.4, 1.37, 0
30626, 1.3916666666667, 1.39, 0
30627, 1.4166666666667, 1.37, 0
30628, 1.4083333333333, 1.39, 0
30629, 1.4333333333333, 1.37, 0
30630, 1.425, 1.39, 0
30631, 1.45, 1.37, 0
30632, 1.4416666666667, 1.39, 0
30633, 1.4666666666667, 1.37, 0
30634, 1.4583333333333, 1.39, 0
30635, 1.4833333333333, 1.37, 0
30636, 1.475, 1.39, 0
30637, 1.5, 1.37, 0
30638, 1.4916666666667, 1.39, 0
30639, 1.5166666666667, 1.37, 0
30640, 1.5083333333333, 1.39, 0
30641, 1.5333333333333, 1.37, 0
30642, 1.525, 1.39, 0
30643, 1.55, 1.37, 0
30644, 1.5416666666667, 1.39, 0
30645, 1.5666666666667, 1.37, 0
30646, 1.5583333333333, 1.39, 0
30647, 1.5833333333333, 1.37, 0
30648, 1.575, 1.39, 0
30649, 1.6, 1.37, 0
30650, 1.5916666666667, 1.39, 0
30651, 1.6166666666667, 1.37, 0
30652, 1.6083333333333, 1.39, 0
30653, 1.6333333333333, 1.37, 0
30654, 1.625, 1.39, 0
30655, 1.65, 1.37, 0
30656, 1.6416666666667, 1.39, 0
30657, 1.6666666666667, 1.37, 0
30658, 1.6583333333333, 1.39, 0
30659, 1.6833333333333, 1.37, 0
30660, 1.675, 1.39, 0
30661, 1.7, 1.37, 0
30662, 1.6916666666667, 1.39, 0
