24460, 1.375, 0.24, 0
24461, 1.3833333333333, 0.25, 0
24462, 1.3916666666667, 0.24, 0
24463, 1.4, 0.25, 0
24464, 1.4083333333333, 0.24, 0
24465, 1.4166666666667, 0.25, 0
24466, 1.425, 0.24, 0
24467, 1.4333333333333, 0.25, 0
24468, 1.4416666666667, 0.24, 0
24469, 1.45, 0.25, 0
24470, 1.4583333333333, 0.24, 0
24471, 1.4666666666667, 0.25, 0
24472, 1.475, 0.24, 0
24473, 1.4833333333333, 0.25, 0
24474, 1.4916666666667, 0.24, 0
24475, 1.5, 0.25, 0
24476, 1.5083333333333, 0.24, 0
24477, 1.5166666666667, 0.25, 0
24478, 1.525, 0.24, 0
24479, 1.5333333333333, 0.25, 0
24480, 1.5416666666667, 0.24, 0
24481, 1.55, 0.25, 0
24482, 1.5583333333333, 0.24, 0
24483, 1.5666666666667, 0.25, 0
24484, 1.575, 0.24, 0
24485, 1.5833333333333, 0.25, 0
24486, 1.5916666666667, 0.24, 0
24487, 1.6, 0.25, 0
24488, 1.6083333333333, 0.24, 0
24489, 1.6166666666667, 0.25, 0
24490, 1.625, 0.24, 0
24491, 1.6333333333333, 0.25, 0
24492, 1.6416666666667, 0.24, 0
24493, 1.65, 0.25, 0
24494, 1.6583333333333, 0.24, 0
24495, 1.6666666666667, 0.25, 0
24496, 1.675, 0.24, 0
24497, 1.6833333333333, 0.25, 0
24498, 1.6916666666667, 0.24, 0
24499, 1.7, 0.25, 0
24500, 1.7083333333333, 0.24, 0
24501, 1.7166666666667, 0.25, 0
24502, 1.725, 0.24, 0
24503, 1.7333333333333, 0.25, 0
24504, 1.7416666666667, 0.24, 0
24505, 1.75, 0.25, 0
24506, 1.7583333333333, 0.24, 0
24507, 1.7666666666667, 0.25, 0
24508, 1.775, 0.24, 0
24509, 1.7833333333333, 0.25, 0
24510, 1.7916666666667, 0.24, 0
24511, 1.8, 0.25, 0
24512, 1.8083333333333, 0.24, 0
24513, 1.8166666666667, 0.25, 0
24514, 1.825, 0.24, 0
24515, 1.8333333333333, 0.25, 0
24516, 1.8416666666667, 0.24, 0
24517, 1.85, 0.25, 0
24518, 1.8583333333333, 0.24, 0
24519, 1.8666666666667, 0.25, 0
24520, 1.875, 0.24, 0
24521, 1.8833333333333, 0.25, 0
24522, 1.8916666666667, 0.24, 0
24523, 1.9, 0.25, 0
24524, 1.9083333333333, 0.24, 0
24525, 1.9166666666667, 0.25, 0
24526, 1.925, 0.24, 0
24527, 1.9333333333333, 0.25, 0
24528, 1.9416666666667, 0.24, 0
24529, 1.95, 0.25, 0
24530, 1.9583333333333, 0.24, 0
24531, 1.9666666666667, 0.25, 0
24532, 1.975, 0.24, 0
24533, 1.9833333333333, 0.25, 0
24534, 1.9916666666667, 0.24, 0
24535, 2, 0.25, 0
24536, 2.0083333333333, 0.24, 0
24537, 2.0166666666667, 0.25, 0
24538, 2.025, 0.24, 0
24539, 2.0333333333333, 0.25, 0
24540, 2.0416666666667, 0.24, 0
24541, 2.05, 0.25, 0
24542, 2.0583333333333, 0.24, 0
24543, 2.0666666666667, 0.25, 0
24544, 2.075, 0.24, 0
24545, 2.0833333333333, 0.25, 0
24546, 2.0916666666667, 0.24, 0
24547, 2.1, 0.25, 0
24548, 2.1083333333333, 0.24, 0
24549, 2.1166666666667, 0.25, 0
24550, 2.125, 0.24, 0
24551, 2.1333333333333, 0.25, 0
24552, 2.1416666666667, 0.24, 0
24553, 2.15, 0.25, 0
24554, 2.1583333333333, 0.24, 0
24555, 2.1666666666667, 0.25, 0
24556, 2.175, 0.24, 0
24557, 2.1833333333333, 0.25, 0
24558, 2.1916666666667, 0.24, 0
24559, 1.2083333333333, 0.22, 0
24560, 1.2166666666667, 0.23, 0
24561, 1.225, 0.22, 0
24562, 1.2333333333333, 0.23, 0
24563, 1.2416666666667, 0.22, 0
24564, 1.25, 0.23, 0
24565, 1.2583333333333, 0.22, 0
24566, 1.2666666666667, 0.23, 0
24567, 1.275, 0.22, 0
24568, 1.2833333333333, 0.23, 0
24569, 1.2916666666667, 0.22, 0
24570, 1.3, 0.23, 0
24571, 1.3083333333333, 0.22, 0
24572, 1.3166666666667, 0.23, 0
24573, 1.325, 0.22, 0
24574, 1.3333333333333, 0.23, 0
24575, 1.3416666666667, 0.22, 0
24576, 1.35, 0.23, 0
24577, 1.3583333333333, 0.22, 0
24578, 1.3666666666667, 0.23, 0
24579, 1.375, 0.22, 0
24580, 1.3833333333333, 0.23, 0
24581, 1.3916666666667, 0.22, 0
24582, 1.4, 0.23, 0
24583, 1.4083333333333, 0.22, 0
24584, 1.4166666666667, 0.23, 0
24585, 1.425, 0.22, 0
24586, 1.4333333333333, 0.23, 0
24587, 1.4416666666667, 0.22, 0
24588, 1.45, 0.23, 0
24589, 1.4583333333333, 0.22, 0
24590, 1.4666666666667, 0.23, 0
24591, 1.475, 0.22, 0
24592, 1.4833333333333, 0.23, 0
24593, 1.4916666666667, 0.22, 0
24594, 1.5, 0.23, 0
24595, 1.5083333333333, 0.22, 0
24596, 1.5166666666667, 0.23, 0
24597, 1.525, 0.22, 0
24598, 1.5333333333333, 0.23, 0
24599, 1.5416666666667, 0.22, 0
24600, 1.55, 0.23, 0
24601, 1.5583333333333, 0.22, 0
24602, 1.5666666666667, 0.23, 0
24603, 1.575, 0.22, 0
24604, 1.5833333333333, 0.23, 0
24605, 1.5916666666667, 0.22, 0
24606, 1.6, 0.23, 0
24607, 1.6083333333333, 0.22, 0
24608, 1.6166666666667, 0.23, 0
24609, 1.625, 0.22, 0
24610, 1.6333333333333, 0.23, 0
24611, 1.6416666666667, 0.22, 0
24612, 1.65, 0.23, 0
24613, 1.6583333333333, 0.22, 0
24614, 1.6666666666667, 0.23, 0
24615, 1.675, 0.22, 0
24616, 1.6833333333333, 0.23, 0
24617, 1.6916666666667, 0.22, 0
24618, 1.7, 0.23, 0
24619, 1.7083333333333, 0.22, 0
24620, 1.7166666666667, 0.23, 0
24621, 1.725, 0.22, 0
24622, 1.7333333333333, 0.23, 0
24623, 1.7416666666667, 0.22, 0
24624, 1.75, 0.23, 0
24625, 1.7583333333333, 0.22, 0
24626, 1.7666666666667, 0.23, 0
24627, 1.775, 0.22, 0
24628, 1.7833333333333, 0.23, 0
24629, 1.7916666666667, 0.22, 0
24630, 1.8, 0.23, 0
24631, 1.8083333333333, 0.22, 0
24632, 1.8166666666667, 0.23, 0
24633, 1.825, 0.22, 0
24634, 1.8333333333333, 0.23, 0
24635, 1.8416666666667, 0.22, 0
24636, 1.85, 0.23, 0
24637, 1.8583333333333, 0.22, 0
24638, 1.8666666666667, 0.23, 0
24639, 1.875, 0.22, 0
24640, 1.8833333333333, 0.23, 0
24641, 1.8916666666667, 0.22, 0
24642, 1.9, 0.23, 0
24643, 1.9083333333333, 0.22, 0
24644, 1.9166666666667, 0.23, 0
24645, 1.925, 0.22, 0
24646, 1.9333333333333, 0.23, 0
24647, 1.9416666666667, 0.22, 0
24648, 1.95, 0.23, 0
24649, 1.9583333333333, 0.22, 0
24650, 1.9666666666667, 0.23, 0
24651, 1.975, 0.22, 0
24652, 1.9833333333333, 0.23, 0
24653, 1.9916666666667, 0.22, 0
24654, 2, 0.23, 0
24655, 2.0083333333333, 0.22, 0
24656, 2.0166666666667, 0.23, 0
24657, 2.025, 0.22, 0
24658, 2.0333333333333, 0.23, 0
24659, 2.0416666666667, 0.22, 0
24660, 2.05, 0.23, 0
24661, 2.0583333333333, 0.22, 0
24662, 2.0666666666667, 0.23, 0
24663, 2.075, 0.22, 0
24664, 2.0833333333333, 0.23, 0
24665, 2.0916666666667, 0.22, 0
24666, 2.1, 0.23, 0
24667, 2.1083333333333, 0.22, 0
24668, 2.1166666666667, 0.23, 0
24669, 2.125, 0.22, 0
24670, 2.1333333333333, 0.23, 0
24671, 2.1416666666667, 0.22, 0
24672, 2.15, 0.23, 0
24673, 2.1583333333333, 0.22, 0
24674, 2.1666666666667, 0.23, 0
24675, 2.175, 0.22, 0
24676, 2.1833333333333, 0.23, 0
24677, 2.1916666666667, 0.22, 0
24678, 1.2083333333333, 0.2, 0
24679, 1.2166666666667, 0.21, 0
24680, 1.225, 0.2, 0
24681, 1.2333333333333, 0.21, 0
24682, 1.2416666666667, 0.2, 0
24683, 1.25, 0.21, 0
24684, 1.2583333333333, 0.2, 0
24685, 1.2666666666667, 0.21, 0
24686, 1.275, 0.2, 0
24687, 1.2833333333333, 0.21, 0
24688, 1.2916666666667, 0.2, 0
24689, 1.3, 0.21, 0
24690, 1.3083333333333, 0.2, 0
24691, 1.3166666666667, 0.21, 0
24692, 1.325, 0.2, 0
24693, 1.3333333333333, 0.21, 0
24694, 1.3416666666667, 0.2, 0
24695, 1.35, 0.21, 0
24696, 1.3583333333333, 0.2, 0
24697, 1.3666666666667, 0.21, 0
24698, 1.375, 0.2, 0
24699, 1.3833333333333, 0.21, 0
24700, 1.3916666666667, 0.2, 0
24701, 1.4, 0.21, 0
24702, 1.4083333333333, 0.2, 0
24703, 1.4166666666667, 0.21, 0
24704, 1.425, 0.2, 0
24705, 1.4333333333333, 0.21, 0
24706, 1.4416666666667, 0.2, 0
24707, 1.45, 0.21, 0
24708, 1.4583333333333, 0.2, 0
24709, 1.4666666666667, 0.21, 0
24710, 1.475, 0.2, 0
24711, 1.4833333333333, 0.21, 0
24712, 1.4916666666667, 0.2, 0
24713, 1.5, 0.21, 0
24714, 1.5083333333333, 0.2, 0
24715, 1.5166666666667, 0.21, 0
24716, 1.525, 0.2, 0
24717, 1.5333333333333, 0.21, 0
24718, 1.5416666666667, 0.2, 0
24719, 1.55, 0.21, 0
24720, 1.5583333333333, 0.2, 0
24721, 1.5666666666667, 0.21, 0
24722, 1.575, 0.2, 0
24723, 1.5833333333333, 0.21, 0
24724, 1.5916666666667, 0.2, 0
24725, 1.6, 0.21, 0
24726, 1.6083333333333, 0.2, 0
24727, 1.6166666666667, 0.21, 0
24728, 1.625, 0.2, 0
24729, 1.6333333333333, 0.21, 0
24730, 1.6416666666667, 0.2, 0
24731, 1.65, 0.21, 0
24732, 1.6583333333333, 0.2, 0
24733, 1.6666666666667, 0.21, 0
24734, 1.675, 0.2, 0
24735, 1.6833333333333, 0.21, 0
24736, 1.6916666666667, 0.2, 0
24737, 1.7, 0.21, 0
24738, 1.7083333333333, 0.2, 0
24739, 1.7166666666667, 0.21, 0
24740, 1.725, 0.2, 0
24741, 1.7333333333333, 0.21, 0
24742, 1.7416666666667, 0.2, 0
24743, 1.75, 0.21, 0
24744, 1.7583333333333, 0.2, 0
24745, 1.7666666666667, 0.21, 0
24746, 1.775, 0.2, 0
24747, 1.7833333333333, 0.21, 0
24748, 1.7916666666667, 0.2, 0
24749, 1.8, 0.21, 0
24750, 1.8083333333333, 0.2, 0
24751, 1.8166666666667, 0.21, 0
24752, 1.825, 0.2, 0
24753, 1.8333333333333, 0.21, 0
24754, 1.8416666666667, 0.2, 0
24755, 1.85, 0.21, 0
24756, 1.8583333333333, 0.2, 0
24757, 1.8666666666667, 0.21, 0
24758, 1.875, 0.2, 0
24759, 1.8833333333333, 0.21, 0
24760, 1.8916666666667, 0.2, 0
24761, 1.9, 0.21, 0
24762, 1.9083333333333, 0.2, 0
24763, 1.9166666666667, 0.21, 0
24764, 1.925, 0.2, 0
24765, 1.9333333333333, 0.21, 0
24766, 1.9416666666667, 0.2, 0
24767, 1.95, 0.21, 0
24768, 1.9583333333333, 0.2, 0
24769, 1.9666666666667, 0.21, 0
24770, 1.975, 0.2, 0
24771, 1.9833333333333, 0.21, 0
24772, 1.9916666666667, 0.2, 0
24773, 2, 0.21, 0
24774, 2.0083333333333, 0.2, 0
24775, 2.0166666666667, 0.21, 0
24776, 2.025, 0.2, 0
24777, 2.0333333333333, 0.21, 0
24778, 2.0416666666667, 0.2, 0
24779, 2.05, 0.21, 0
24780, 2.0583333333333, 0.2, 0
24781, 2.0666666666667, 0.21, 0
24782, 2.075, 0.2, 0
24783, 2.0833333333333, 0.21, 0
24784, 2.0916666666667, 0.2, 0
24785, 2.1, 0.21, 0
24786, 2.1083333333333, 0.2, 0
24787, 2.1166666666667, 0.21, 0
24788, 2.125, 0.2, 0
24789, 2.1333333333333, 0.21, 0
24790, 2.1416666666667, 0.2, 0
24791, 2.15, 0.21, 0
24792, 2.1583333333333, 0.2, 0
24793, 2.1666666666667, 0.21, 0
24794, 2.175, 0.2, 0
24795, 2.1833333333333, 0.21, 0
24796, 2.1916666666667, 0.2, 0
24797, 1.2083333333333, 0.18, 0
24798, 1.2166666666667, 0.19, 0
24799, 1.225, 0.18, 0
24800, 1.2333333333333, 0.19, 0
24801, 1.2416666666667, 0.18, 0
24802, 1.25, 0.19, 0
24803, 1.2583333333333, 0.18, 0
24804, 1.2666666666667, 0.19, 0
24805, 1.275, 0.18, 0
24806, 1.2833333333333, 0.19, 0
24807, 1.2916666666667, 0.18, 0
24808, 1.3, 0.19, 0
24809, 1.3083333333333, 0.18, 0
24810, 1.3166666666667, 0.19, 0
24811, 1.325, 0.18, 0
24812, 1.3333333333333, 0.19, 0
24813, 1.3416666666667, 0.18, 0
24814, 1.35, 0.19, 0
24815, 1.3583333333333, 0.18, 0
24816, 1.3666666666667, 0.19, 0
24817, 1.375, 0.18, 0
24818, 1.3833333333333, 0.19, 0
24819, 1.3916666666667, 0.18, 0
24820, 1.4, 0.19, 0
24821, 1.4083333333333, 0.18, 0
24822, 1.4166666666667, 0.19, 0
24823, 1.425, 0.18, 0
24824, 1.4333333333333, 0.19, 0
24825, 1.4416666666667, 0.18, 0
24826, 1.45, 0.19, 0
24827, 1.4583333333333, 0.18, 0
24828, 1.4666666666667, 0.19, 0
24829, 1.475, 0.18, 0
24830, 1.4833333333333, 0.19, 0
24831, 1.4916666666667, 0.18, 0
24832, 1.5, 0.19, 0
24833, 1.5083333333333, 0.18, 0
24834, 1.5166666666667, 0.19, 0
24835, 1.525, 0.18, 0
24836, 1.5333333333333, 0.19, 0
24837, 1.5416666666667, 0.18, 0
24838, 1.55, 0.19, 0
24839, 1.5583333333333, 0.18, 0
24840, 1.5666666666667, 0.19, 0
24841, 1.575, 0.18, 0
24842, 1.5833333333333, 0.19, 0
24843, 1.5916666666667, 0.18, 0
24844, 1.6, 0.19, 0
24845, 1.6083333333333, 0.18, 0
24846, 1.6166666666667, 0.19, 0
24847, 1.625, 0.18, 0
24848, 1.6333333333333, 0.19, 0
24849, 1.6416666666667, 0.18, 0
24850, 1.65, 0.19, 0
24851, 1.6583333333333, 0.18, 0
24852, 1.6666666666667, 0.19, 0
24853, 1.675, 0.18, 0
24854, 1.6833333333333, 0.19, 0
24855, 1.6916666666667, 0.18, 0
24856, 1.7, 0.19, 0
24857, 1.7083333333333, 0.18, 0
24858, 1.7166666666667, 0.19, 0
24859, 1.725, 0.18, 0
24860, 1.7333333333333, 0.19, 0
24861, 1.7416666666667, 0.18, 0
24862, 1.75, 0.19, 0
24863, 1.7583333333333, 0.18, 0
24864, 1.7666666666667, 0.19, 0
24865, 1.775, 0.18, 0
24866, 1.7833333333333, 0.19, 0
24867, 1.7916666666667, 0.18, 0
24868, 1.8, 0.19, 0
24869, 1.8083333333333, 0.18, 0
24870, 1.8166666666667, 0.19, 0
24871, 1.825, 0.18, 0
24872, 1.8333333333333, 0.19, 0
24873, 1.8416666666667, 0.18, 0
24874, 1.85, 0.19, 0
24875, 1.8583333333333, 0.18, 0
24876, 1.8666666666667, 0.19, 0
24877, 1.875, 0.18, 0
24878, 1.8833333333333, 0.19, 0
24879, 1.8916666666667, 0.18, 0
24880, 1.9, 0.19, 0
24881, 1.9083333333333, 0.18, 0
24882, 1.9166666666667, 0.19, 0
24883, 1.925, 0.18, 0
24884, 1.9333333333333, 0.19, 0
24885, 1.9416666666667, 0.18, 0
24886, 1.95, 0.19, 0
24887, 1.9583333333333, 0.18, 0
24888, 1.9666666666667, 0.19, 0
24889, 1.975, 0.18, 0
24890, 1.9833333333333, 0.19, 0
24891, 1.9916666666667, 0.18, 0
24892, 2, 0.19, 0
24893, 2.0083333333333, 0.18, 0
24894, 2.0166666666667, 0.19, 0
24895, 2.025, 0.18, 0
24896, 2.0333333333333, 0.19, 0
24897, 2.0416666666667, 0.18, 0
24898, 2.05, 0.19, 0
24899, 2.0583333333333, 0.18, 0
24900, 2.0666666666667, 0.19, 0
24901, 2.075, 0.18, 0
24902, 2.0833333333333, 0.19, 0
24903, 2.0916666666667, 0.18, 0
24904, 2.1, 0.19, 0
24905, 2.1083333333333, 0.18, 0
24906, 2.1166666666667, 0.19, 0
24907, 2.125, 0.18, 0
24908, 2.1333333333333, 0.19, 0
24909, 2.1416666666667, 0.18, 0
24910, 2.15, 0.19, 0
24911, 2.1583333333333, 0.18, 0
24912, 2.1666666666667, 0.19, 0
24913, 2.175, 0.18, 0
24914, 2.1833333333333, 0.19, 0
24915, 2.1916666666667, 0.18, 0
24916, 1.2083333333333, 0.16, 0
24917, 1.2166666666667, 0.17, 0
24918, 1.225, 0.16, 0
24919, 1.2333333333333, 0.17, 0
24920, 1.2416666666667, 0.16, 0
24921, 1.25, 0.17, 0
24922, 1.2583333333333, 0.16, 0
24923, 1.2666666666667, 0.17, 0
24924, 1.275, 0.16, 0
24925, 1.2833333333333, 0.17, 0
24926, 1.2916666666667, 0.16, 0
24927, 1.3, 0.17, 0
24928, 1.3083333333333, 0.16, 0
24929, 1.3166666666667, 0.17, 0
24930, 1.325, 0.16, 0
24931, 1.3333333333333, 0.17, 0
24932, 1.3416666666667, 0.16, 0
24933, 1.35, 0.17, 0
24934, 1.3583333333333, 0.16, 0
24935, 1.3666666666667, 0.17, 0
24936, 1.375, 0.16, 0
24937, 1.3833333333333, 0.17, 0
24938, 1.3916666666667, 0.16, 0
24939, 1.4, 0.17, 0
24940, 1.4083333333333, 0.16, 0
24941, 1.4166666666667, 0.17, 0
24942, 1.425, 0.16, 0
24943, 1.4333333333333, 0.17, 0
24944, 1.4416666666667, 0.16, 0
24945, 1.45, 0.17, 0
24946, 1.4583333333333, 0.16, 0
24947, 1.4666666666667, 0.17, 0
24948, 1.475, 0.16, 0
24949, 1.4833333333333, 0.17, 0
24950, 1.4916666666667, 0.16, 0
24951, 1.5, 0.17, 0
24952, 1.5083333333333, 0.16, 0
24953, 1.5166666666667, 0.17, 0
24954, 1.525, 0.16, 0
24955, 1.5333333333333, 0.17, 0
24956, 1.5416666666667, 0.16, 0
24957, 1.55, 0.17, 0
24958, 1.5583333333333, 0.16, 0
24959, 1.5666666666667, 0.17, 0
24960, 1.575, 0.16, 0
24961, 1.5833333333333, 0.17, 0
24962, 1.5916666666667, 0.16, 0
24963, 1.6, 0.17, 0
24964, 1.6083333333333, 0.16, 0
24965, 1.6166666666667, 0.17, 0
24966, 1.625, 0.16, 0
24967, 1.6333333333333, 0.17, 0
24968, 1.6416666666667, 0.16, 0
24969, 1.65, 0.17, 0
24970, 1.6583333333333, 0.16, 0
24971, 1.6666666666667, 0.17, 0
24972, 1.675, 0.16, 0
24973, 1.6833333333333, 0.17, 0
24974, 1.6916666666667, 0.16, 0
24975, 1.7, 0.17, 0
24976, 1.7083333333333, 0.16, 0
24977, 1.7166666666667, 0.17, 0
24978, 1.725, 0.16, 0
24979, 1.7333333333333, 0.17, 0
24980, 1.7416666666667, 0.16, 0
24981, 1.75, 0.17, 0
24982, 1.7583333333333, 0.16, 0
24983, 1.7666666666667, 0.17, 0
24984, 1.775, 0.16, 0
24985, 1.7833333333333, 0.17, 0
24986, 1.7916666666667, 0.16, 0
24987, 1.8, 0.17, 0
24988, 1.8083333333333, 0.16, 0
24989, 1.8166666666667, 0.17, 0
24990, 1.825, 0.16, 0
24991, 1.8333333333333, 0.17, 0
24992, 1.8416666666667, 0.16, 0
24993, 1.85, 0.17, 0
24994, 1.8583333333333, 0.16, 0
24995, 1.8666666666667, 0.17, 0
24996, 1.875, 0.16, 0
24997, 1.8833333333333, 0.17, 0
24998, 1.8916666666667, 0.16, 0
24999, 1.9, 0.17, 0
25000, 1.9083333333333, 0.16, 0
25001, 1.9166666666667, 0.17, 0
25002, 1.925, 0.16, 0
25003, 1.9333333333333, 0.17, 0
25004, 1.9416666666667, 0.16, 0
25005, 1.95, 0.17, 0
25006, 1.9583333333333, 0.16, 0
25007, 1.9666666666667, 0.17, 0
25008, 1.975, 0.16, 0
25009, 1.9833333333333, 0.17, 0
25010, 1.9916666666667, 0.16, 0
25011, 2, 0.17, 0
25012, 2.0083333333333, 0.16, 0
25013, 2.0166666666667, 0.17, 0
25014, 2.025, 0.16, 0
25015, 2.0333333333333, 0.17, 0
25016, 2.0416666666667, 0.16, 0
25017, 2.05, 0.17, 0
25018, 2.0583333333333, 0.16, 0
25019, 2.0666666666667, 0.17, 0
25020, 2.075, 0.16, 0
25021, 2.0833333333333, 0.17, 0
25022, 2.0916666666667, 0.16, 0
25023, 2.1, 0.17, 0
25024, 2.1083333333333, 0.16, 0
25025, 2.1166666666667, 0.17, 0
25026, 2.125, 0.16, 0
25027, 2.1333333333333, 0.17, 0
25028, 2.1416666666667, 0.16, 0
25029, 2.15, 0.17, 0
25030, 2.1583333333333, 0.16, 0
25031, 2.1666666666667, 0.17, 0
25032, 2.175, 0.16, 0
25033, 2.1833333333333, 0.17, 0
25034, 2.1916666666667, 0.16, 0
25035, 1.2083333333333, 0.14, 0
25036, 1.2166666666667, 0.15, 0
25037, 1.225, 0.14, 0
25038, 1.2333333333333, 0.15, 0
25039, 1.2416666666667, 0.14, 0
25040, 1.25, 0.15, 0
25041, 1.2583333333333, 0.14, 0
25042, 1.2666666666667, 0.15, 0
25043, 1.275, 0.14, 0
25044, 1.2833333333333, 0.15, 0
25045, 1.2916666666667, 0.14, 0
25046, 1.3, 0.15, 0
25047, 1.3083333333333, 0.14, 0
25048, 1.3166666666667, 0.15, 0
25049, 1.325, 0.14, 0
25050, 1.3333333333333, 0.15, 0
25051, 1.3416666666667, 0.14, 0
25052, 1.35, 0.15, 0
25053, 1.3583333333333, 0.14, 0
25054, 1.3666666666667, 0.15, 0
25055, 1.375, 0.14, 0
25056, 1.3833333333333, 0.15, 0
25057, 1.3916666666667, 0.14, 0
25058, 1.4, 0.15, 0
25059, 1.4083333333333, 0.14, 0
25060, 1.4166666666667, 0.15, 0
25061, 1.425, 0.14, 0
25062, 1.4333333333333, 0.15, 0
25063, 1.4416666666667, 0.14, 0
25064, 1.45, 0.15, 0
25065, 1.4583333333333, 0.14, 0
25066, 1.4666666666667, 0.15, 0
25067, 1.475, 0.14, 0
25068, 1.4833333333333, 0.15, 0
25069, 1.4916666666667, 0.14, 0
25070, 1.5, 0.15, 0
25071, 1.5083333333333, 0.14, 0
25072, 1.5166666666667, 0.15, 0
25073, 1.525, 0.14, 0
25074, 1.5333333333333, 0.15, 0
25075, 1.5416666666667, 0.14, 0
25076, 1.55, 0.15, 0
25077, 1.5583333333333, 0.14, 0
25078, 1.5666666666667, 0.15, 0
25079, 1.575, 0.14, 0
25080, 1.5833333333333, 0.15, 0
25081, 1.5916666666667, 0.14, 0
25082, 1.6, 0.15, 0
25083, 1.6083333333333, 0.14, 0
25084, 1.6166666666667, 0.15, 0
25085, 1.625, 0.14, 0
25086, 1.6333333333333, 0.15, 0
25087, 1.6416666666667, 0.14, 0
25088, 1.65, 0.15, 0
25089, 1.6583333333333, 0.14, 0
25090, 1.6666666666667, 0.15, 0
25091, 1.675, 0.14, 0
25092, 1.6833333333333, 0.15, 0
25093, 1.6916666666667, 0.14, 0
25094, 1.7, 0.15, 0
25095, 1.7083333333333, 0.14, 0
25096, 1.7166666666667, 0.15, 0
25097, 1.725, 0.14, 0
25098, 1.7333333333333, 0.15, 0
25099, 1.7416666666667, 0.14, 0
25100, 1.75, 0.15, 0
25101, 1.7583333333333, 0.14, 0
25102, 1.7666666666667, 0.15, 0
25103, 1.775, 0.14, 0
25104, 1.7833333333333, 0.15, 0
25105, 1.7916666666667, 0.14, 0
25106, 1.8, 0.15, 0
25107, 1.8083333333333, 0.14, 0
25108, 1.8166666666667, 0.15, 0
25109, 1.825, 0.14, 0
25110, 1.8333333333333, 0.15, 0
25111, 1.8416666666667, 0.14, 0
25112, 1.85, 0.15, 0
25113, 1.8583333333333, 0.14, 0
25114, 1.8666666666667, 0.15, 0
25115, 1.875, 0.14, 0
25116, 1.8833333333333, 0.15, 0
25117, 1.8916666666667, 0.14, 0
25118, 1.9, 0.15, 0
25119, 1.9083333333333, 0.14, 0
25120, 1.9166666666667, 0.15, 0
25121, 1.925, 0.14, 0
25122, 1.9333333333333, 0.15, 0
25123, 1.9416666666667, 0.14, 0
25124, 1.95, 0.15, 0
25125, 1.9583333333333, 0.14, 0
25126, 1.9666666666667, 0.15, 0
25127, 1.975, 0.14, 0
25128, 1.9833333333333, 0.15, 0
25129, 1.9916666666667, 0.14, 0
25130, 2, 0.15, 0
25131, 2.0083333333333, 0.14, 0
25132, 2.0166666666667, 0.15, 0
25133, 2.025, 0.14, 0
25134, 2.0333333333333, 0.15, 0
25135, 2.0416666666667, 0.14, 0
25136, 2.05, 0.15, 0
25137, 2.0583333333333, 0.14, 0
25138, 2.0666666666667, 0.15, 0
25139, 2.075, 0.14, 0
25140, 2.0833333333333, 0.15, 0
25141, 2.0916666666667, 0.14, 0
25142, 2.1, 0.15, 0
25143, 2.1083333333333, 0.14, 0
25144, 2.1166666666667, 0.15, 0
25145, 2.125, 0.14, 0
25146, 2.1333333333333, 0.15, 0
25147, 2.1416666666667, 0.14, 0
25148, 2.15, 0.15, 0
25149, 2.1583333333333, 0.14, 0
25150, 2.1666666666667, 0.15, 0
25151, 2.175, 0.14, 0
25152, 2.1833333333333, 0.15, 0
25153, 2.1916666666667, 0.14, 0
25154, 1.2083333333333, 0.12, 0
25155, 1.2166666666667, 0.13, 0
25156, 1.225, 0.12, 0
25157, 1.2333333333333, 0.13, 0
25158, 1.2416666666667, 0.12, 0
25159, 1.25, 0.13, 0
25160, 1.2583333333333, 0.12, 0
25161, 1.2666666666667, 0.13, 0
25162, 1.275, 0.12, 0
25163, 1.2833333333333, 0.13, 0
25164, 1.2916666666667, 0.12, 0
25165, 1.3, 0.13, 0
25166, 1.3083333333333, 0.12, 0
25167, 1.3166666666667, 0.13, 0
25168, 1.325, 0.12, 0
25169, 1.3333333333333, 0.13, 0
25170, 1.3416666666667, 0.12, 0
25171, 1.35, 0.13, 0
25172, 1.3583333333333, 0.12, 0
25173, 1.3666666666667, 0.13, 0
25174, 1.375, 0.12, 0
25175, 1.3833333333333, 0.13, 0
25176, 1.3916666666667, 0.12, 0
25177, 1.4, 0.13, 0
25178, 1.4083333333333, 0.12, 0
25179, 1.4166666666667, 0.13, 0
25180, 1.425, 0.12, 0
25181, 1.4333333333333, 0.13, 0
25182, 1.4416666666667, 0.12, 0
25183, 1.45, 0.13, 0
25184, 1.4583333333333, 0.12, 0
25185, 1.4666666666667, 0.13, 0
25186, 1.475, 0.12, 0
25187, 1.4833333333333, 0.13, 0
25188, 1.4916666666667, 0.12, 0
25189, 1.5, 0.13, 0
25190, 1.5083333333333, 0.12, 0
25191, 1.5166666666667, 0.13, 0
25192, 1.525, 0.12, 0
25193, 1.5333333333333, 0.13, 0
25194, 1.5416666666667, 0.12, 0
25195, 1.55, 0.13, 0
25196, 1.5583333333333, 0.12, 0
25197, 1.5666666666667, 0.13, 0
25198, 1.575, 0.12, 0
25199, 1.5833333333333, 0.13, 0
25200, 1.5916666666667, 0.12, 0
25201, 1.6, 0.13, 0
25202, 1.6083333333333, 0.12, 0
25203, 1.6166666666667, 0.13, 0
25204, 1.625, 0.12, 0
25205, 1.6333333333333, 0.13, 0
25206, 1.6416666666667, 0.12, 0
25207, 1.65, 0.13, 0
25208, 1.6583333333333, 0.12, 0
25209, 1.6666666666667, 0.13, 0
25210, 1.675, 0.12, 0
25211, 1.6833333333333, 0.13, 0
25212, 1.6916666666667, 0.12, 0
25213, 1.7, 0.13, 0
25214, 1.7083333333333, 0.12, 0
25215, 1.7166666666667, 0.13, 0
25216, 1.725, 0.12, 0
25217, 1.7333333333333, 0.13, 0
25218, 1.7416666666667, 0.12, 0
25219, 1.75, 0.13, 0
25220, 1.7583333333333, 0.12, 0
25221, 1.7666666666667, 0.13, 0
25222, 1.775, 0.12, 0
25223, 1.7833333333333, 0.13, 0
25224, 1.7916666666667, 0.12, 0
25225, 1.8, 0.13, 0
25226, 1.8083333333333, 0.12, 0
25227, 1.8166666666667, 0.13, 0
25228, 1.825, 0.12, 0
25229, 1.8333333333333, 0.13, 0
25230, 1.8416666666667, 0.12, 0
25231, 1.85, 0.13, 0
25232, 1.8583333333333, 0.12, 0
25233, 1.8666666666667, 0.13, 0
25234, 1.875, 0.12, 0
25235, 1.8833333333333, 0.13, 0
25236, 1.8916666666667, 0.12, 0
25237, 1.9, 0.13, 0
25238, 1.9083333333333, 0.12, 0
25239, 1.9166666666667, 0.13, 0
25240, 1.925, 0.12, 0
25241, 1.9333333333333, 0.13, 0
25242, 1.9416666666667, 0.12, 0
25243, 1.95, 0.13, 0
25244, 1.9583333333333, 0.12, 0
25245, 1.9666666666667, 0.13, 0
25246, 1.975, 0.12, 0
25247, 1.9833333333333, 0.13, 0
25248, 1.9916666666667, 0.12, 0
25249, 2, 0.13, 0
25250, 2.0083333333333, 0.12, 0
25251, 2.0166666666667, 0.13, 0
25252, 2.025, 0.12, 0
25253, 2.0333333333333, 0.13, 0
25254, 2.0416666666667, 0.12, 0
25255, 2.05, 0.13, 0
25256, 2.0583333333333, 0.12, 0
25257, 2.0666666666667, 0.13, 0
25258, 2.075, 0.12, 0
25259, 2.0833333333333, 0.13, 0
25260, 2.0916666666667, 0.12, 0
25261, 2.1, 0.13, 0
25262, 2.1083333333333, 0.12, 0
25263, 2.1166666666667, 0.13, 0
25264, 2.125, 0.12, 0
25265, 2.1333333333333, 0.13, 0
25266, 2.1416666666667, 0.12, 0
25267, 2.15, 0.13, 0
25268, 2.1583333333333, 0.12, 0
25269, 2.1666666666667, 0.13, 0
25270, 2.175, 0.12, 0
25271, 2.1833333333333, 0.13, 0
25272, 2.1916666666667, 0.12, 0
25273, 1.2083333333333, 0.1, 0
25274, 1.2166666666667, 0.11, 0
25275, 1.225, 0.1, 0
25276, 1.2333333333333, 0.11, 0
25277, 1.2416666666667, 0.1, 0
25278, 1.25, 0.11, 0
25279, 1.2583333333333, 0.1, 0
25280, 1.2666666666667, 0.11, 0
25281, 1.275, 0.1, 0
25282, 1.2833333333333, 0.11, 0
25283, 1.2916666666667, 0.1, 0
25284, 1.3, 0.11, 0
25285, 1.3083333333333, 0.1, 0
25286, 1.3166666666667, 0.11, 0
25287, 1.325, 0.1, 0
25288, 1.3333333333333, 0.11, 0
25289, 1.3416666666667, 0.1, 0
25290, 1.35, 0.11, 0
25291, 1.3583333333333, 0.1, 0
25292, 1.3666666666667, 0.11, 0
25293, 1.375, 0.1, 0
25294, 1.3833333333333, 0.11, 0
25295, 1.3916666666667, 0.1, 0
25296, 1.4, 0.11, 0
25297, 1.4083333333333, 0.1, 0
25298, 1.4166666666667, 0.11, 0
25299, 1.425, 0.1, 0
25300, 1.4333333333333, 0.11, 0
25301, 1.4416666666667, 0.1, 0
25302, 1.45, 0.11, 0
25303, 1.4583333333333, 0.1, 0
25304, 1.4666666666667, 0.11, 0
25305, 1.475, 0.1, 0
25306, 1.4833333333333, 0.11, 0
25307, 1.4916666666667, 0.1, 0
25308, 1.5, 0.11, 0
25309, 1.5083333333333, 0.1, 0
25310, 1.5166666666667, 0.11, 0
25311, 1.525, 0.1, 0
25312, 1.5333333333333, 0.11, 0
25313, 1.5416666666667, 0.1, 0
25314, 1.55, 0.11, 0
25315, 1.5583333333333, 0.1, 0
25316, 1.5666666666667, 0.11, 0
25317, 1.575, 0.1, 0
25318, 1.5833333333333, 0.11, 0
25319, 1.5916666666667, 0.1, 0
25320, 1.6, 0.11, 0
25321, 1.6083333333333, 0.1, 0
25322, 1.6166666666667, 0.11, 0
25323, 1.625, 0.1, 0
25324, 1.6333333333333, 0.11, 0
25325, 1.6416666666667, 0.1, 0
25326, 1.65, 0.11, 0
25327, 1.6583333333333, 0.1, 0
25328, 1.6666666666667, 0.11, 0
25329, 1.675, 0.1, 0
25330, 1.6833333333333, 0.11, 0
25331, 1.6916666666667, 0.1, 0
25332, 1.7, 0.11, 0
25333, 1.7083333333333, 0.1, 0
25334, 1.7166666666667, 0.11, 0
25335, 1.725, 0.1, 0
25336, 1.7333333333333, 0.11, 0
25337, 1.7416666666667, 0.1, 0
25338, 1.75, 0.11, 0
25339, 1.7583333333333, 0.1, 0
25340, 1.7666666666667, 0.11, 0
25341, 1.775, 0.1, 0
25342, 1.7833333333333, 0.11, 0
25343, 1.7916666666667, 0.1, 0
25344, 1.8, 0.11, 0
25345, 1.8083333333333, 0.1, 0
25346, 1.8166666666667, 0.11, 0
25347, 1.825, 0.1, 0
25348, 1.8333333333333, 0.11, 0
25349, 1.8416666666667, 0.1, 0
25350, 1.85, 0.11, 0
25351, 1.8583333333333, 0.1, 0
25352, 1.8666666666667, 0.11, 0
25353, 1.875, 0.1, 0
25354, 1.8833333333333, 0.11, 0
25355, 1.8916666666667, 0.1, 0
25356, 1.9, 0.11, 0
25357, 1.9083333333333, 0.1, 0
25358, 1.9166666666667, 0.11, 0
25359, 1.925, 0.1, 0
25360, 1.9333333333333, 0.11, 0
25361, 1.9416666666667, 0.1, 0
25362, 1.95, 0.11, 0
25363, 1.9583333333333, 0.1, 0
25364, 1.9666666666667, 0.11, 0
25365, 1.975, 0.1, 0
25366, 1.9833333333333, 0.11, 0
25367, 1.9916666666667, 0.1, 0
25368, 2, 0.11, 0
25369, 2.0083333333333, 0.1, 0
25370, 2.0166666666667, 0.11, 0
25371, 2.025, 0.1, 0
25372, 2.0333333333333, 0.11, 0
25373, 2.0416666666667, 0.1, 0
25374, 2.05, 0.11, 0
25375, 2.0583333333333, 0.1, 0
25376, 2.0666666666667, 0.11, 0
25377, 2.075, 0.1, 0
25378, 2.0833333333333, 0.11, 0
25379, 2.0916666666667, 0.1, 0
25380, 2.1, 0.11, 0
25381, 2.1083333333333, 0.1, 0
25382, 2.1166666666667, 0.11, 0
25383, 2.125, 0.1, 0
25384, 2.1333333333333, 0.11, 0
25385, 2.1416666666667, 0.1, 0
25386, 2.15, 0.11, 0
25387, 2.1583333333333, 0.1, 0
25388, 2.1666666666667, 0.11, 0
25389, 2.175, 0.1, 0
25390, 2.1833333333333, 0.11, 0
25391, 2.1916666666667, 0.1, 0
25392, 1.2083333333333, 0.08, 0
25393, 1.2166666666667, 0.09, 0
25394, 1.225, 0.08, 0
25395, 1.2333333333333, 0.09, 0
25396, 1.2416666666667, 0.08, 0
25397, 1.25, 0.09, 0
25398, 1.2583333333333, 0.08, 0
25399, 1.2666666666667, 0.09, 0
25400, 1.275, 0.08, 0
25401, 1.2833333333333, 0.09, 0
25402, 1.2916666666667, 0.08, 0
25403, 1.3, 0.09, 0
25404, 1.3083333333333, 0.08, 0
25405, 1.3166666666667, 0.09, 0
25406, 1.325, 0.08, 0
25407, 1.3333333333333, 0.09, 0
25408, 1.3416666666667, 0.08, 0
25409, 1.35, 0.09, 0
25410, 1.3583333333333, 0.08, 0
25411, 1.3666666666667, 0.09, 0
25412, 1.375, 0.08, 0
25413, 1.3833333333333, 0.09, 0
25414, 1.3916666666667, 0.08, 0
25415, 1.4, 0.09, 0
25416, 1.4083333333333, 0.08, 0
25417, 1.4166666666667, 0.09, 0
25418, 1.425, 0.08, 0
25419, 1.4333333333333, 0.09, 0
25420, 1.4416666666667, 0.08, 0
25421, 1.45, 0.09, 0
25422, 1.4583333333333, 0.08, 0
25423, 1.4666666666667, 0.09, 0
25424, 1.475, 0.08, 0
25425, 1.4833333333333, 0.09, 0
25426, 1.4916666666667, 0.08, 0
25427, 1.5, 0.09, 0
25428, 1.5083333333333, 0.08, 0
25429, 1.5166666666667, 0.09, 0
25430, 1.525, 0.08, 0
25431, 1.5333333333333, 0.09, 0
25432, 1.5416666666667, 0.08, 0
25433, 1.55, 0.09, 0
25434, 1.5583333333333, 0.08, 0
25435, 1.5666666666667, 0.09, 0
25436, 1.575, 0.08, 0
25437, 1.5833333333333, 0.09, 0
25438, 1.5916666666667, 0.08, 0
25439, 1.6, 0.09, 0
25440, 1.6083333333333, 0.08, 0
25441, 1.6166666666667, 0.09, 0
25442, 1.625, 0.08, 0
25443, 1.6333333333333, 0.09, 0
25444, 1.6416666666667, 0.08, 0
25445, 1.65, 0.09, 0
25446, 1.6583333333333, 0.08, 0
25447, 1.6666666666667, 0.09, 0
25448, 1.675, 0.08, 0
25449, 1.6833333333333, 0.09, 0
25450, 1.6916666666667, 0.08, 0
25451, 1.7, 0.09, 0
25452, 1.7083333333333, 0.08, 0
25453, 1.7166666666667, 0.09, 0
25454, 1.725, 0.08, 0
25455, 1.7333333333333, 0.09, 0
25456, 1.7416666666667, 0.08, 0
25457, 1.75, 0.09, 0
25458, 1.7583333333333, 0.08, 0
25459, 1.7666666666667, 0.09, 0
25460, 1.775, 0.08, 0
25461, 1.7833333333333, 0.09, 0
25462, 1.7916666666667, 0.08, 0
25463, 1.8, 0.09, 0
25464, 1.8083333333333, 0.08, 0
25465, 1.8166666666667, 0.09, 0
25466, 1.825, 0.08, 0
25467, 1.8333333333333, 0.09, 0
25468, 1.8416666666667, 0.08, 0
25469, 1.85, 0.09, 0
25470, 1.8583333333333, 0.08, 0
25471, 1.8666666666667, 0.09, 0
25472, 1.875, 0.08, 0
25473, 1.8833333333333, 0.09, 0
25474, 1.8916666666667, 0.08, 0
25475, 1.9, 0.09, 0
25476, 1.9083333333333, 0.08, 0
25477, 1.9166666666667, 0.09, 0
25478, 1.925, 0.08, 0
25479, 1.9333333333333, 0.09, 0
25480, 1.9416666666667, 0.08, 0
25481, 1.95, 0.09, 0
25482, 1.9583333333333, 0.08, 0
25483, 1.9666666666667, 0.09, 0
25484, 1.975, 0.08, 0
25485, 1.9833333333333, 0.09, 0
25486, 1.9916666666667, 0.08, 0
25487, 2, 0.09, 0
25488, 2.0083333333333, 0.08, 0
25489, 2.0166666666667, 0.09, 0
25490, 2.025, 0.08, 0
25491, 2.0333333333333, 0.09, 0
25492, 2.0416666666667, 0.08, 0
25493, 2.05, 0.09, 0
25494, 2.0583333333333, 0.08, 0
25495, 2.0666666666667, 0.09, 0
25496, 2.075, 0.08, 0
25497, 2.0833333333333, 0.09, 0
25498, 2.0916666666667, 0.08, 0
25499, 2.1, 0.09, 0
25500, 2.1083333333333, 0.08, 0
25501, 2.1166666666667, 0.09, 0
25502, 2.125, 0.08, 0
25503, 2.1333333333333, 0.09, 0
25504, 2.1416666666667, 0.08, 0
25505, 2.15, 0.09, 0
25506, 2.1583333333333, 0.08, 0
25507, 2.1666666666667, 0.09, 0
25508, 2.175, 0.08, 0
25509, 2.1833333333333, 0.09, 0
25510, 2.1916666666667, 0.08, 0
25511, 1.2083333333333, 0.06, 0
25512, 1.2166666666667, 0.07, 0
25513, 1.225, 0.06, 0
25514, 1.2333333333333, 0.07, 0
25515, 1.2416666666667, 0.06, 0
25516, 1.25, 0.07, 0
25517, 1.2583333333333, 0.06, 0
25518, 1.2666666666667, 0.07, 0
25519, 1.275, 0.06, 0
25520, 1.2833333333333, 0.07, 0
25521, 1.2916666666667, 0.06, 0
25522, 1.3, 0.07, 0
25523, 1.3083333333333, 0.06, 0
25524, 1.3166666666667, 0.07, 0
25525, 1.325, 0.06, 0
25526, 1.3333333333333, 0.07, 0
25527, 1.3416666666667, 0.06, 0
25528, 1.35, 0.07, 0
25529, 1.3583333333333, 0.06, 0
25530, 1.3666666666667, 0.07, 0
25531, 1.375, 0.06, 0
25532, 1.3833333333333, 0.07, 0
25533, 1.3916666666667, 0.06, 0
25534, 1.4, 0.07, 0
25535, 1.4083333333333, 0.06, 0
25536, 1.4166666666667, 0.07, 0
25537, 1.425, 0.06, 0
25538, 1.4333333333333, 0.07, 0
25539, 1.4416666666667, 0.06, 0
25540, 1.45, 0.07, 0
25541, 1.4583333333333, 0.06, 0
25542, 1.4666666666667, 0.07, 0
25543, 1.475, 0.06, 0
25544, 1.4833333333333, 0.07, 0
25545, 1.4916666666667, 0.06, 0
25546, 1.5, 0.07, 0
25547, 1.5083333333333, 0.06, 0
25548, 1.5166666666667, 0.07, 0
25549, 1.525, 0.06, 0
25550, 1.5333333333333, 0.07, 0
25551, 1.5416666666667, 0.06, 0
25552, 1.55, 0.07, 0
25553, 1.5583333333333, 0.06, 0
25554, 1.5666666666667, 0.07, 0
25555, 1.575, 0.06, 0
25556, 1.5833333333333, 0.07, 0
25557, 1.5916666666667, 0.06, 0
25558, 1.6, 0.07, 0
25559, 1.6083333333333, 0.06, 0
25560, 1.6166666666667, 0.07, 0
25561, 1.625, 0.06, 0
25562, 1.6333333333333, 0.07, 0
25563, 1.6416666666667, 0.06, 0
25564, 1.65, 0.07, 0
25565, 1.6583333333333, 0.06, 0
25566, 1.6666666666667, 0.07, 0
25567, 1.675, 0.06, 0
25568, 1.6833333333333, 0.07, 0
25569, 1.6916666666667, 0.06, 0
25570, 1.7, 0.07, 0
25571, 1.7083333333333, 0.06, 0
25572, 1.7166666666667, 0.07, 0
25573, 1.725, 0.06, 0
25574, 1.7333333333333, 0.07, 0
25575, 1.7416666666667, 0.06, 0
25576, 1.75, 0.07, 0
25577, 1.7583333333333, 0.06, 0
25578, 1.7666666666667, 0.07, 0
25579, 1.775, 0.06, 0
25580, 1.7833333333333, 0.07, 0
25581, 1.7916666666667, 0.06, 0
25582, 1.8, 0.07, 0
25583, 1.8083333333333, 0.06, 0
25584, 1.8166666666667, 0.07, 0
25585, 1.825, 0.06, 0
25586, 1.8333333333333, 0.07, 0
25587, 1.8416666666667, 0.06, 0
25588, 1.85, 0.07, 0
25589, 1.8583333333333, 0.06, 0
25590, 1.8666666666667, 0.07, 0
25591, 1.875, 0.06, 0
25592, 1.8833333333333, 0.07, 0
25593, 1.8916666666667, 0.06, 0
25594, 1.9, 0.07, 0
25595, 1.9083333333333, 0.06, 0
25596, 1.9166666666667, 0.07, 0
25597, 1.925, 0.06, 0
25598, 1.9333333333333, 0.07, 0
25599, 1.9416666666667, 0.06, 0
25600, 1.95, 0.07, 0
25601, 1.9583333333333, 0.06, 0
25602, 1.9666666666667, 0.07, 0
25603, 1.975, 0.06, 0
25604, 1.9833333333333, 0.07, 0
25605, 1.9916666666667, 0.06, 0
25606, 2, 0.07, 0
25607, 2.0083333333333, 0.06, 0
25608, 2.0166666666667, 0.07, 0
25609, 2.025, 0.06, 0
25610, 2.0333333333333, 0.07, 0
25611, 2.0416666666667, 0.06, 0
25612, 2.05, 0.07, 0
25613, 2.0583333333333, 0.06, 0
25614, 2.0666666666667, 0.07, 0
25615, 2.075, 0.06, 0
25616, 2.0833333333333, 0.07, 0
25617, 2.0916666666667, 0.06, 0
25618, 2.1, 0.07, 0
25619, 2.1083333333333, 0.06, 0
25620, 2.1166666666667, 0.07, 0
25621, 2.125, 0.06, 0
25622, 2.1333333333333, 0.07, 0
25623, 2.1416666666667, 0.06, 0
25624, 2.15, 0.07, 0
25625, 2.1583333333333, 0.06, 0
25626, 2.1666666666667, 0.07, 0
25627, 2.175, 0.06, 0
25628, 2.1833333333333, 0.07, 0
25629, 2.1916666666667, 0.06, 0
25630, 1.2083333333333, 0.04, 0
25631, 1.2166666666667, 0.05, 0
25632, 1.225, 0.04, 0
25633, 1.2333333333333, 0.05, 0
25634, 1.2416666666667, 0.04, 0
25635, 1.25, 0.05, 0
25636, 1.2583333333333, 0.04, 0
25637, 1.2666666666667, 0.05, 0
25638, 1.275, 0.04, 0
25639, 1.2833333333333, 0.05, 0
25640, 1.2916666666667, 0.04, 0
25641, 1.3, 0.05, 0
25642, 1.3083333333333, 0.04, 0
25643, 1.3166666666667, 0.05, 0
25644, 1.325, 0.04, 0
25645, 1.3333333333333, 0.05, 0
25646, 1.3416666666667, 0.04, 0
25647, 1.35, 0.05, 0
25648, 1.3583333333333, 0.04, 0
25649, 1.3666666666667, 0.05, 0
25650, 1.375, 0.04, 0
25651, 1.3833333333333, 0.05, 0
25652, 1.3916666666667, 0.04, 0
25653, 1.4, 0.05, 0
25654, 1.4083333333333, 0.04, 0
25655, 1.4166666666667, 0.05, 0
25656, 1.425, 0.04, 0
25657, 1.4333333333333, 0.05, 0
25658, 1.4416666666667, 0.04, 0
25659, 1.45, 0.05, 0
25660, 1.4583333333333, 0.04, 0
25661, 1.4666666666667, 0.05, 0
25662, 1.475, 0.04, 0
25663, 1.4833333333333, 0.05, 0
25664, 1.4916666666667, 0.04, 0
25665, 1.5, 0.05, 0
25666, 1.5083333333333, 0.04, 0
25667, 1.5166666666667, 0.05, 0
25668, 1.525, 0.04, 0
25669, 1.5333333333333, 0.05, 0
25670, 1.5416666666667, 0.04, 0
25671, 1.55, 0.05, 0
25672, 1.5583333333333, 0.04, 0
25673, 1.5666666666667, 0.05, 0
25674, 1.575, 0.04, 0
25675, 1.5833333333333, 0.05, 0
25676, 1.5916666666667, 0.04, 0
25677, 1.6, 0.05, 0
25678, 1.6083333333333, 0.04, 0
25679, 1.6166666666667, 0.05, 0
25680, 1.625, 0.04, 0
25681, 1.6333333333333, 0.05, 0
25682, 1.6416666666667, 0.04, 0
25683, 1.65, 0.05, 0
25684, 1.6583333333333, 0.04, 0
25685, 1.6666666666667, 0.05, 0
25686, 1.675, 0.04, 0
25687, 1.6833333333333, 0.05, 0
25688, 1.6916666666667, 0.04, 0
25689, 1.7, 0.05, 0
25690, 1.7083333333333, 0.04, 0
25691, 1.7166666666667, 0.05, 0
25692, 1.725, 0.04, 0
25693, 1.7333333333333, 0.05, 0
25694, 1.7416666666667, 0.04, 0
25695, 1.75, 0.05, 0
25696, 1.7583333333333, 0.04, 0
25697, 1.7666666666667, 0.05, 0
25698, 1.775, 0.04, 0
25699, 1.7833333333333, 0.05, 0
25700, 1.7916666666667, 0.04, 0
25701, 1.8, 0.05, 0
25702, 1.8083333333333, 0.04, 0
25703, 1.8166666666667, 0.05, 0
25704, 1.825, 0.04, 0
25705, 1.8333333333333, 0.05, 0
25706, 1.8416666666667, 0.04, 0
25707, 1.85, 0.05, 0
25708, 1.8583333333333, 0.04, 0
25709, 1.8666666666667, 0.05, 0
25710, 1.875, 0.04, 0
25711, 1.8833333333333, 0.05, 0
25712, 1.8916666666667, 0.04, 0
25713, 1.9, 0.05, 0
25714, 1.9083333333333, 0.04, 0
25715, 1.9166666666667, 0.05, 0
25716, 1.925, 0.04, 0
25717, 1.9333333333333, 0.05, 0
25718, 1.9416666666667, 0.04, 0
25719, 1.95, 0.05, 0
25720, 1.9583333333333, 0.04, 0
25721, 1.9666666666667, 0.05, 0
25722, 1.975, 0.04, 0
25723, 1.9833333333333, 0.05, 0
25724, 1.9916666666667, 0.04, 0
25725, 2, 0.05, 0
25726, 2.0083333333333, 0.04, 0
25727, 2.0166666666667, 0.05, 0
25728, 2.025, 0.04, 0
25729, 2.0333333333333, 0.05, 0
25730, 2.0416666666667, 0.04, 0
25731, 2.05, 0.05, 0
25732, 2.0583333333333, 0.04, 0
25733, 2.0666666666667, 0.05, 0
25734, 2.075, 0.04, 0
25735, 2.0833333333333, 0.05, 0
25736, 2.0916666666667, 0.04, 0
25737, 2.1, 0.05, 0
25738, 2.1083333333333, 0.04, 0
25739, 2.1166666666667, 0.05, 0
25740, 2.125, 0.04, 0
25741, 2.1333333333333, 0.05, 0
25742, 2.1416666666667, 0.04, 0
25743, 2.15, 0.05, 0
25744, 2.1583333333333, 0.04, 0
25745, 2.1666666666667, 0.05, 0
25746, 2.175, 0.04, 0
25747, 2.1833333333333, 0.05, 0
25748, 2.1916666666667, 0.04, 0
25749, 1.2083333333333, 0.02, 0
25750, 1.2166666666667, 0.03, 0
25751, 1.225, 0.02, 0
25752, 1.2333333333333, 0.03, 0
25753, 1.2416666666667, 0.02, 0
25754, 1.25, 0.03, 0
25755, 1.2583333333333, 0.02, 0
25756, 1.2666666666667, 0.03, 0
25757, 1.275, 0.02, 0
25758, 1.2833333333333, 0.03, 0
25759, 1.2916666666667, 0.02, 0
25760, 1.3, 0.03, 0
25761, 1.3083333333333, 0.02, 0
25762, 1.3166666666667, 0.03, 0
25763, 1.325, 0.02, 0
25764, 1.3333333333333, 0.03, 0
25765, 1.3416666666667, 0.02, 0
25766, 1.35, 0.03, 0
25767, 1.3583333333333, 0.02, 0
25768, 1.3666666666667, 0.03, 0
25769, 1.375, 0.02, 0
25770, 1.3833333333333, 0.03, 0
25771, 1.3916666666667, 0.02, 0
25772, 1.4, 0.03, 0
25773, 1.4083333333333, 0.02, 0
25774, 1.4166666666667, 0.03, 0
25775, 1.425, 0.02, 0
25776, 1.4333333333333, 0.03, 0
25777, 1.4416666666667, 0.02, 0
25778, 1.45, 0.03, 0
25779, 1.4583333333333, 0.02, 0
25780, 1.4666666666667, 0.03, 0
25781, 1.475, 0.02, 0
25782, 1.4833333333333, 0.03, 0
25783, 1.4916666666667, 0.02, 0
25784, 1.5, 0.03, 0
25785, 1.5083333333333, 0.02, 0
25786, 1.5166666666667, 0.03, 0
25787, 1.525, 0.02, 0
25788, 1.5333333333333, 0.03, 0
25789, 1.5416666666667, 0.02, 0
25790, 1.55, 0.03, 0
25791, 1.5583333333333, 0.02, 0
25792, 1.5666666666667, 0.03, 0
25793, 1.575, 0.02, 0
25794, 1.5833333333333, 0.03, 0
25795, 1.5916666666667, 0.02, 0
25796, 1.6, 0.03, 0
25797, 1.6083333333333, 0.02, 0
25798, 1.6166666666667, 0.03, 0
25799, 1.625, 0.02, 0
25800, 1.6333333333333, 0.03, 0
25801, 1.6416666666667, 0.02, 0
25802, 1.65, 0.03, 0
25803, 1.6583333333333, 0.02, 0
25804, 1.6666666666667, 0.03, 0
25805, 1.675, 0.02, 0
25806, 1.6833333333333, 0.03, 0
25807, 1.6916666666667, 0.02, 0
25808, 1.7, 0.03, 0
25809, 1.7083333333333, 0.02, 0
25810, 1.7166666666667, 0.03, 0
25811, 1.725, 0.02, 0
25812, 1.7333333333333, 0.03, 0
25813, 1.7416666666667, 0.02, 0
25814, 1.75, 0.03, 0
25815, 1.7583333333333, 0.02, 0
25816, 1.7666666666667, 0.03, 0
25817, 1.775, 0.02, 0
25818, 1.7833333333333, 0.03, 0
25819, 1.7916666666667, 0.02, 0
25820, 1.8, 0.03, 0
25821, 1.8083333333333, 0.02, 0
25822, 1.8166666666667, 0.03, 0
25823, 1.825, 0.02, 0
25824, 1.8333333333333, 0.03, 0
25825, 1.8416666666667, 0.02, 0
25826, 1.85, 0.03, 0
25827, 1.8583333333333, 0.02, 0
25828, 1.8666666666667, 0.03, 0
25829, 1.875, 0.02, 0
25830, 1.8833333333333, 0.03, 0
25831, 1.8916666666667, 0.02, 0
25832, 1.9, 0.03, 0
25833, 1.9083333333333, 0.02, 0
25834, 1.9166666666667, 0.03, 0
25835, 1.925, 0.02, 0
25836, 1.9333333333333, 0.03, 0
25837, 1.9416666666667, 0.02, 0
25838, 1.95, 0.03, 0
25839, 1.9583333333333, 0.02, 0
25840, 1.9666666666667, 0.03, 0
25841, 1.975, 0.02, 0
25842, 1.9833333333333, 0.03, 0
25843, 1.9916666666667, 0.02, 0
25844, 2, 0.03, 0
25845, 2.0083333333333, 0.02, 0
25846, 2.0166666666667, 0.03, 0
25847, 2.025, 0.02, 0
25848, 2.0333333333333, 0.03, 0
25849, 2.0416666666667, 0.02, 0
25850, 2.05, 0.03, 0
25851, 2.0583333333333, 0.02, 0
25852, 2.0666666666667, 0.03, 0
25853, 2.075, 0.02, 0
25854, 2.0833333333333, 0.03, 0
25855, 2.0916666666667, 0.02, 0
25856, 2.1, 0.03, 0
25857, 2.1083333333333, 0.02, 0
25858, 2.1166666666667, 0.03, 0
25859, 2.125, 0.02, 0
25860, 2.1333333333333, 0.03, 0
25861, 2.1416666666667, 0.02, 0
25862, 2.15, 0.03, 0
25863, 2.1583333333333, 0.02, 0
25864, 2.1666666666667, 0.03, 0
25865, 2.175, 0.02, 0
25866, 2.1833333333333, 0.03, 0
25867, 2.1916666666667, 0.02, 0
25868, 1.2166666666667, 0.0099999999999998, 0
25869, 1.2333333333333, 0.01, 0
25870, 1.25, 0.0099999999999996, 0
25871, 1.2666666666667, 0.01, 0
25872, 1.2833333333333, 0.01, 0
25873, 1.3, 0.01, 0
25874, 1.3166666666667, 0.01, 0
25875, 1.3333333333333, 0.01, 0
25876, 1.35, 0.01, 0
25877, 1.3666666666667, 0.01, 0
25878, 1.3833333333333, 0.01, 0
25879, 1.4, 0.01, 0
25880, 1.4166666666667, 0.01, 0
25881, 1.4333333333333, 0.01, 0
25882, 1.45, 0.01, 0
25883, 1.4666666666667, 0.01, 0
25884, 1.4833333333333, 0.01, 0
25885, 1.5, 0.01, 0
25886, 1.5166666666667, 0.01, 0
25887, 1.5333333333333, 0.01, 0
25888, 1.55, 0.01, 0
25889, 1.5666666666667, 0.01, 0
25890, 1.5833333333333, 0.01, 0
25891, 1.6, 0.01, 0
25892, 1.6166666666667, 0.01, 0
25893, 1.6333333333333, 0.01, 0
25894, 1.65, 0.01, 0
25895, 1.6666666666667, 0.01, 0
25896, 1.6833333333333, 0.01, 0
25897, 1.7, 0.01, 0
25898, 1.7166666666667, 0.01, 0
25899, 1.7333333333333, 0.01, 0
25900, 1.75, 0.01, 0
25901, 1.7666666666667, 0.01, 0
25902, 1.7833333333333, 0.01, 0
25903, 1.8, 0.01, 0
25904, 1.8166666666667, 0.01, 0
25905, 1.8333333333333, 0.01, 0
25906, 1.85, 0.01, 0
25907, 1.8666666666667, 0.01, 0
25908, 1.8833333333333, 0.01, 0
25909, 1.9, 0.01, 0
25910, 1.9166666666667, 0.01, 0
25911, 1.9333333333333, 0.01, 0
25912, 1.95, 0.01, 0
25913, 1.9666666666667, 0.01, 0
25914, 1.9833333333333, 0.01, 0
25915, 2, 0.01, 0
25916, 2.0166666666667, 0.01, 0
25917, 2.0333333333333, 0.01, 0
25918, 2.05, 0.01, 0
25919, 2.0666666666667, 0.01, 0
25920, 2.0833333333333, 0.01, 0
25921, 2.1, 0.01, 0
25922, 2.1166666666667, 0.01, 0
25923, 2.1333333333333, 0.01, 0
25924, 2.15, 0.01, 0
25925, 2.1666666666667, 0.01, 0
25926, 2.1833333333333, 0.01, 0
25927, 1.2166666666667, -0.066666666666667, 0
25928, 1.2333333333333, -0.066666666666667, 0
25929, 1.25, -0.066666666666667, 0
25930, 1.2666666666667, -0.066666666666667, 0
25931, 1.2833333333333, -0.066666666666667, 0
25932, 1.3, -0.066666666666667, 0
25933, 1.3166666666667, -0.066666666666667, 0
25934, 1.3333333333333, -0.066666666666667, 0
25935, 1.35, -0.066666666666667, 0
25936, 1.3666666666667, -0.066666666666667, 0
25937, 1.3833333333333, -0.066666666666667, 0
25938, 1.4, -0.066666666666667, 0
25939, 1.4166666666667, -0.066666666666667, 0
25940, 1.4333333333333, -0.066666666666667, 0
25941, 1.45, -0.066666666666667, 0
25942, 1.4666666666667, -0.066666666666667, 0
25943, 1.4833333333333, -0.066666666666667, 0
25944, 1.5, -0.066666666666667, 0
25945, 1.5166666666667, -0.066666666666667, 0
25946, 1.5333333333333, -0.066666666666667, 0
25947, 1.55, -0.066666666666667, 0
25948, 1.5666666666667, -0.066666666666667, 0
25949, 1.5833333333333, -0.066666666666667, 0
25950, 1.6, -0.066666666666667, 0
25951, 1.6166666666667, -0.066666666666667, 0
25952, 1.6333333333333, -0.066666666666667, 0
25953, 1.65, -0.066666666666667, 0
25954, 1.6666666666667, -0.066666666666667, 0
25955, 1.6833333333333, -0.066666666666667, 0
25956, 1.7, -0.066666666666667, 0
25957, 1.7166666666667, -0.066666666666667, 0
25958, 1.7333333333333, -0.066666666666667, 0
25959, 1.75, -0.066666666666667, 0
25960, 1.7666666666667, -0.066666666666667, 0
25961, 1.7833333333333, -0.066666666666667, 0
25962, 1.8, -0.066666666666667, 0
25963, 1.8166666666667, -0.066666666666667, 0
25964, 1.8333333333333, -0.066666666666667, 0
25965, 1.85, -0.066666666666667, 0
25966, 1.8666666666667, -0.066666666666667, 0
25967, 1.8833333333333, -0.066666666666667, 0
25968, 1.9, -0.066666666666667, 0
25969, 1.9166666666667, -0.066666666666667, 0
25970, 1.9333333333333, -0.066666666666667, 0
25971, 1.95, -0.066666666666667, 0
25972, 1.9666666666667, -0.066666666666667, 0
25973, 1.9833333333333, -0.066666666666667, 0
25974, 2, -0.066666666666667, 0
25975, 2.0166666666667, -0.066666666666667, 0
25976, 2.0333333333333, -0.066666666666667, 0
25977, 2.05, -0.066666666666667, 0
25978, 2.0666666666667, -0.066666666666667, 0
25979, 2.0833333333333, -0.066666666666667, 0
25980, 2.1, -0.066666666666667, 0
25981, 2.1166666666667, -0.066666666666667, 0
25982, 2.1333333333333, -0.066666666666667, 0
25983, 2.15, -0.066666666666667, 0
25984, 2.1666666666667, -0.066666666666667, 0
25985, 2.1833333333333, -0.066666666666667, 0
25986, 1.2166666666667, -0.083333333333333, 0
25987, 1.2333333333333, -0.083333333333333, 0
25988, 1.25, -0.083333333333333, 0
25989, 1.2666666666667, -0.083333333333333, 0
25990, 1.2833333333333, -0.083333333333333, 0
25991, 1.3, -0.083333333333333, 0
25992, 1.3166666666667, -0.083333333333333, 0
25993, 1.3333333333333, -0.083333333333333, 0
25994, 1.35, -0.083333333333333, 0
25995, 1.3666666666667, -0.083333333333333, 0
25996, 1.3833333333333, -0.083333333333333, 0
25997, 1.4, -0.083333333333333, 0
25998, 1.4166666666667, -0.083333333333333, 0
25999, 1.4333333333333, -0.083333333333333, 0
26000, 1.45, -0.083333333333333, 0
26001, 1.4666666666667, -0.083333333333333, 0
26002, 1.4833333333333, -0.083333333333333, 0
26003, 1.5, -0.083333333333333, 0
26004, 1.5166666666667, -0.083333333333333, 0
26005, 1.5333333333333, -0.083333333333333, 0
26006, 1.55, -0.083333333333333, 0
26007, 1.5666666666667, -0.083333333333333, 0
26008, 1.5833333333333, -0.083333333333333, 0
26009, 1.6, -0.083333333333333, 0
26010, 1.6166666666667, -0.083333333333333, 0
26011, 1.6333333333333, -0.083333333333333, 0
26012, 1.65, -0.083333333333333, 0
26013, 1.6666666666667, -0.083333333333333, 0
26014, 1.6833333333333, -0.083333333333333, 0
26015, 1.7, -0.083333333333333, 0
26016, 1.7166666666667, -0.083333333333333, 0
26017, 1.7333333333333, -0.083333333333333, 0
26018, 1.75, -0.083333333333333, 0
26019, 1.7666666666667, -0.083333333333333, 0
26020, 1.7833333333333, -0.083333333333333, 0
26021, 1.8, -0.083333333333333, 0
26022, 1.8166666666667, -0.083333333333333, 0
26023, 1.8333333333333, -0.083333333333333, 0
26024, 1.85, -0.083333333333333, 0
26025, 1.8666666666667, -0.083333333333333, 0
26026, 1.8833333333333, -0.083333333333333, 0
26027, 1.9, -0.083333333333333, 0
26028, 1.9166666666667, -0.083333333333333, 0
26029, 1.9333333333333, -0.083333333333333, 0
26030, 1.95, -0.083333333333333, 0
26031, 1.9666666666667, -0.083333333333333, 0
26032, 1.9833333333333, -0.083333333333333, 0
26033, 2, -0.083333333333333, 0
26034, 2.0166666666667, -0.083333333333333, 0
26035, 2.0333333333333, -0.083333333333333, 0
26036, 2.05, -0.083333333333333, 0
26037, 2.0666666666667, -0.083333333333333, 0
26038, 2.0833333333333, -0.083333333333333, 0
26039, 2.1, -0.083333333333333, 0
26040, 2.1166666666667, -0.083333333333333, 0
26041, 2.1333333333333, -0.083333333333333, 0
26042, 2.15, -0.083333333333333, 0
26043, 2.1666666666667, -0.083333333333333, 0
26044, 2.1833333333333, -0.083333333333333, 0
26045, 1.2166666666667, -0.1, 0
26046, 1.2333333333333, -0.1, 0
26047, 1.25, -0.1, 0
26048, 1.2666666666667, -0.1, 0
26049, 1.2833333333333, -0.1, 0
26050, 1.3, -0.1, 0
26051, 1.3166666666667, -0.1, 0
26052, 1.3333333333333, -0.1, 0
26053, 1.35, -0.1, 0
26054, 1.3666666666667, -0.1, 0
26055, 1.3833333333333, -0.1, 0
26056, 1.4, -0.1, 0
26057, 1.4166666666667, -0.1, 0
26058, 1.4333333333333, -0.1, 0
26059, 1.45, -0.1, 0
26060, 1.4666666666667, -0.1, 0
26061, 1.4833333333333, -0.1, 0
26062, 1.5, -0.1, 0
26063, 1.5166666666667, -0.1, 0
26064, 1.5333333333333, -0.1, 0
26065, 1.55, -0.1, 0
26066, 1.5666666666667, -0.1, 0
26067, 1.5833333333333, -0.1, 0
26068, 1.6, -0.1, 0
26069, 1.6166666666667, -0.1, 0
26070, 1.6333333333333, -0.1, 0
26071, 1.65, -0.1, 0
26072, 1.6666666666667, -0.1, 0
26073, 1.6833333333333, -0.1, 0
26074, 1.7, -0.1, 0
26075, 1.7166666666667, -0.1, 0
26076, 1.7333333333333, -0.1, 0
26077, 1.75, -0.1, 0
26078, 1.7666666666667, -0.1, 0
26079, 1.7833333333333, -0.1, 0
26080, 1.8, -0.1, 0
26081, 1.8166666666667, -0.1, 0
26082, 1.8333333333333, -0.1, 0
26083, 1.85, -0.1, 0
26084, 1.8666666666667, -0.1, 0
26085, 1.8833333333333, -0.1, 0
26086, 1.9, -0.1, 0
26087, 1.9166666666667, -0.1, 0
26088, 1.9333333333333, -0.1, 0
26089, 1.95, -0.1, 0
26090, 1.9666666666667, -0.1, 0
26091, 1.9833333333333, -0.1, 0
26092, 2, -0.1, 0
26093, 2.0166666666667, -0.1, 0
26094, 2.0333333333333, -0.1, 0
26095, 2.05, -0.1, 0
26096, 2.0666666666667, -0.1, 0
26097, 2.0833333333333, -0.1, 0
26098, 2.1, -0.1, 0
26099, 2.1166666666667, -0.1, 0
26100, 2.1333333333333, -0.1, 0
26101, 2.15, -0.1, 0
26102, 2.1666666666667, -0.1, 0
26103, 2.1833333333333, -0.1, 0
26104, 1.2166666666667, -0.11666666666667, 0
26105, 1.2333333333333, -0.11666666666667, 0
26106, 1.25, -0.11666666666667, 0
26107, 1.2666666666667, -0.11666666666667, 0
26108, 1.2833333333333, -0.11666666666667, 0
26109, 1.3, -0.11666666666667, 0
26110, 1.3166666666667, -0.11666666666667, 0
26111, 1.3333333333333, -0.11666666666667, 0
26112, 1.35, -0.11666666666667, 0
26113, 1.3666666666667, -0.11666666666667, 0
26114, 1.3833333333333, -0.11666666666667, 0
26115, 1.4, -0.11666666666667, 0
26116, 1.4166666666667, -0.11666666666667, 0
26117, 1.4333333333333, -0.11666666666667, 0
26118, 1.45, -0.11666666666667, 0
26119, 1.4666666666667, -0.11666666666667, 0
26120, 1.4833333333333, -0.11666666666667, 0
26121, 1.5, -0.11666666666667, 0
26122, 1.5166666666667, -0.11666666666667, 0
26123, 1.5333333333333, -0.11666666666667, 0
26124, 1.55, -0.11666666666667, 0
26125, 1.5666666666667, -0.11666666666667, 0
26126, 1.5833333333333, -0.11666666666667, 0
26127, 1.6, -0.11666666666667, 0
26128, 1.6166666666667, -0.11666666666667, 0
26129, 1.6333333333333, -0.11666666666667, 0
26130, 1.65, -0.11666666666667, 0
26131, 1.6666666666667, -0.11666666666667, 0
26132, 1.6833333333333, -0.11666666666667, 0
26133, 1.7, -0.11666666666667, 0
26134, 1.7166666666667, -0.11666666666667, 0
26135, 1.7333333333333, -0.11666666666667, 0
26136, 1.75, -0.11666666666667, 0
26137, 1.7666666666667, -0.11666666666667, 0
26138, 1.7833333333333, -0.11666666666667, 0
26139, 1.8, -0.11666666666667, 0
26140, 1.8166666666667, -0.11666666666667, 0
26141, 1.8333333333333, -0.11666666666667, 0
26142, 1.85, -0.11666666666667, 0
26143, 1.8666666666667, -0.11666666666667, 0
26144, 1.8833333333333, -0.11666666666667, 0
26145, 1.9, -0.11666666666667, 0
26146, 1.9166666666667, -0.11666666666667, 0
26147, 1.9333333333333, -0.11666666666667, 0
26148, 1.95, -0.11666666666667, 0
26149, 1.9666666666667, -0.11666666666667, 0
26150, 1.9833333333333, -0.11666666666667, 0
26151, 2, -0.11666666666667, 0
26152, 2.0166666666667, -0.11666666666667, 0
26153, 2.0333333333333, -0.11666666666667, 0
26154, 2.05, -0.11666666666667, 0
26155, 2.0666666666667, -0.11666666666667, 0
26156, 2.0833333333333, -0.11666666666667, 0
26157, 2.1, -0.11666666666667, 0
26158, 2.1166666666667, -0.11666666666667, 0
26159, 2.1333333333333, -0.11666666666667, 0
26160, 2.15, -0.11666666666667, 0
26161, 2.1666666666667, -0.11666666666667, 0
26162, 2.1833333333333, -0.11666666666667, 0
26163, 1.2166666666667, -0.13333333333333, 0
26164, 1.2333333333333, -0.13333333333333, 0
26165, 1.25, -0.13333333333333, 0
26166, 1.2666666666667, -0.13333333333333, 0
26167, 1.2833333333333, -0.13333333333333, 0
26168, 1.3, -0.13333333333333, 0
26169, 1.3166666666667, -0.13333333333333, 0
26170, 1.3333333333333, -0.13333333333333, 0
26171, 1.35, -0.13333333333333, 0
26172, 1.3666666666667, -0.13333333333333, 0
26173, 1.3833333333333, -0.13333333333333, 0
26174, 1.4, -0.13333333333333, 0
26175, 1.4166666666667, -0.13333333333333, 0
26176, 1.4333333333333, -0.13333333333333, 0
26177, 1.45, -0.13333333333333, 0
26178, 1.4666666666667, -0.13333333333333, 0
26179, 1.4833333333333, -0.13333333333333, 0
26180, 1.5, -0.13333333333333, 0
26181, 1.5166666666667, -0.13333333333333, 0
26182, 1.5333333333333, -0.13333333333333, 0
26183, 1.55, -0.13333333333333, 0
26184, 1.5666666666667, -0.13333333333333, 0
26185, 1.5833333333333, -0.13333333333333, 0
26186, 1.6, -0.13333333333333, 0
26187, 1.6166666666667, -0.13333333333333, 0
26188, 1.6333333333333, -0.13333333333333, 0
26189, 1.65, -0.13333333333333, 0
26190, 1.6666666666667, -0.13333333333333, 0
26191, 1.6833333333333, -0.13333333333333, 0
26192, 1.7, -0.13333333333333, 0
26193, 1.7166666666667, -0.13333333333333, 0
26194, 1.7333333333333, -0.13333333333333, 0
26195, 1.75, -0.13333333333333, 0
26196, 1.7666666666667, -0.13333333333333, 0
26197, 1.7833333333333, -0.13333333333333, 0
26198, 1.8, -0.13333333333333, 0
26199, 1.8166666666667, -0.13333333333333, 0
26200, 1.8333333333333, -0.13333333333333, 0
26201, 1.85, -0.13333333333333, 0
26202, 1.8666666666667, -0.13333333333333, 0
26203, 1.8833333333333, -0.13333333333333, 0
26204, 1.9, -0.13333333333333, 0
26205, 1.9166666666667, -0.13333333333333, 0
26206, 1.9333333333333, -0.13333333333333, 0
26207, 1.95, -0.13333333333333, 0
26208, 1.9666666666667, -0.13333333333333, 0
26209, 1.9833333333333, -0.13333333333333, 0
26210, 2, -0.13333333333333, 0
26211, 2.0166666666667, -0.13333333333333, 0
26212, 2.0333333333333, -0.13333333333333, 0
26213, 2.05, -0.13333333333333, 0
26214, 2.0666666666667, -0.13333333333333, 0
26215, 2.0833333333333, -0.13333333333333, 0
26216, 2.1, -0.13333333333333, 0
26217, 2.1166666666667, -0.13333333333333, 0
26218, 2.1333333333333, -0.13333333333333, 0
26219, 2.15, -0.13333333333333, 0
26220, 2.1666666666667, -0.13333333333333, 0
26221, 2.1833333333333, -0.13333333333333, 0
26222, 1.2083333333333, -0.066666666666667, 0
26223, 1.2166666666667, -0.058333333333333, 0
26224, 1.225, -0.066666666666667, 0
26225, 1.2333333333333, -0.058333333333333, 0
26226, 1.2416666666667, -0.066666666666667, 0
26227, 1.25, -0.058333333333333, 0
26228, 1.2583333333333, -0.066666666666667, 0
26229, 1.2666666666667, -0.058333333333333, 0
26230, 1.275, -0.066666666666667, 0
26231, 1.2833333333333, -0.058333333333333, 0
26232, 1.2916666666667, -0.066666666666667, 0
26233, 1.3, -0.058333333333333, 0
26234, 1.3083333333333, -0.066666666666667, 0
26235, 1.3166666666667, -0.058333333333333, 0
26236, 1.325, -0.066666666666667, 0
26237, 1.3333333333333, -0.058333333333333, 0
26238, 1.3416666666667, -0.066666666666667, 0
26239, 1.35, -0.058333333333333, 0
26240, 1.3583333333333, -0.066666666666667, 0
26241, 1.3666666666667, -0.058333333333333, 0
26242, 1.375, -0.066666666666667, 0
26243, 1.3833333333333, -0.058333333333333, 0
26244, 1.3916666666667, -0.066666666666667, 0
26245, 1.4, -0.058333333333333, 0
26246, 1.4083333333333, -0.066666666666667, 0
26247, 1.4166666666667, -0.058333333333333, 0
26248, 1.425, -0.066666666666667, 0
26249, 1.4333333333333, -0.058333333333333, 0
26250, 1.4416666666667, -0.066666666666667, 0
26251, 1.45, -0.058333333333333, 0
26252, 1.4583333333333, -0.066666666666667, 0
26253, 1.4666666666667, -0.058333333333333, 0
26254, 1.475, -0.066666666666667, 0
26255, 1.4833333333333, -0.058333333333333, 0
26256, 1.4916666666667, -0.066666666666667, 0
26257, 1.5, -0.058333333333333, 0
26258, 1.5083333333333, -0.066666666666667, 0
26259, 1.5166666666667, -0.058333333333333, 0
26260, 1.525, -0.066666666666667, 0
26261, 1.5333333333333, -0.058333333333333, 0
26262, 1.5416666666667, -0.066666666666667, 0
26263, 1.55, -0.058333333333333, 0
26264, 1.5583333333333, -0.066666666666667, 0
26265, 1.5666666666667, -0.058333333333333, 0
26266, 1.575, -0.066666666666667, 0
26267, 1.5833333333333, -0.058333333333333, 0
26268, 1.5916666666667, -0.066666666666667, 0
26269, 1.6, -0.058333333333333, 0
26270, 1.6083333333333, -0.066666666666667, 0
26271, 1.6166666666667, -0.058333333333333, 0
26272, 1.625, -0.066666666666667, 0
26273, 1.6333333333333, -0.058333333333333, 0
26274, 1.6416666666667, -0.066666666666667, 0
26275, 1.65, -0.058333333333333, 0
26276, 1.6583333333333, -0.066666666666667, 0
26277, 1.6666666666667, -0.058333333333333, 0
26278, 1.675, -0.066666666666667, 0
26279, 1.6833333333333, -0.058333333333333, 0
26280, 1.6916666666667, -0.066666666666667, 0
26281, 1.7, -0.058333333333333, 0
26282, 1.7083333333333, -0.066666666666667, 0
26283, 1.7166666666667, -0.058333333333333, 0
26284, 1.725, -0.066666666666667, 0
26285, 1.7333333333333, -0.058333333333333, 0
26286, 1.7416666666667, -0.066666666666667, 0
26287, 1.75, -0.058333333333333, 0
26288, 1.7583333333333, -0.066666666666667, 0
26289, 1.7666666666667, -0.058333333333333, 0
26290, 1.775, -0.066666666666667, 0
26291, 1.7833333333333, -0.058333333333333, 0
26292, 1.7916666666667, -0.066666666666667, 0
26293, 1.8, -0.058333333333333, 0
26294, 1.8083333333333, -0.066666666666667, 0
26295, 1.8166666666667, -0.058333333333333, 0
26296, 1.825, -0.066666666666667, 0
26297, 1.8333333333333, -0.058333333333333, 0
26298, 1.8416666666667, -0.066666666666667, 0
26299, 1.85, -0.058333333333333, 0
26300, 1.8583333333333, -0.066666666666667, 0
26301, 1.8666666666667, -0.058333333333333, 0
26302, 1.875, -0.066666666666667, 0
26303, 1.8833333333333, -0.058333333333333, 0
26304, 1.8916666666667, -0.066666666666667, 0
26305, 1.9, -0.058333333333333, 0
26306, 1.9083333333333, -0.066666666666667, 0
26307, 1.9166666666667, -0.058333333333333, 0
26308, 1.925, -0.066666666666667, 0
26309, 1.9333333333333, -0.058333333333333, 0
26310, 1.9416666666667, -0.066666666666667, 0
26311, 1.95, -0.058333333333333, 0
26312, 1.9583333333333, -0.066666666666667, 0
26313, 1.9666666666667, -0.058333333333333, 0
26314, 1.975, -0.066666666666667, 0
26315, 1.9833333333333, -0.058333333333333, 0
26316, 1.9916666666667, -0.066666666666667, 0
26317, 2, -0.058333333333333, 0
26318, 2.0083333333333, -0.066666666666667, 0
26319, 2.0166666666667, -0.058333333333333, 0
26320, 2.025, -0.066666666666667, 0
26321, 2.0333333333333, -0.058333333333333, 0
26322, 2.0416666666667, -0.066666666666667, 0
26323, 2.05, -0.058333333333333, 0
26324, 2.0583333333333, -0.066666666666667, 0
26325, 2.0666666666667, -0.058333333333333, 0
26326, 2.075, -0.066666666666667, 0
26327, 2.0833333333333, -0.058333333333333, 0
26328, 2.0916666666667, -0.066666666666667, 0
26329, 2.1, -0.058333333333333, 0
26330, 2.1083333333333, -0.066666666666667, 0
26331, 2.1166666666667, -0.058333333333333, 0
26332, 2.125, -0.066666666666667, 0
26333, 2.1333333333333, -0.058333333333333, 0
26334, 2.1416666666667, -0.066666666666667, 0
26335, 2.15, -0.058333333333333, 0
26336, 2.1583333333333, -0.066666666666667, 0
26337, 2.1666666666667, -0.058333333333333, 0
26338, 2.175, -0.066666666666667, 0
26339, 2.1833333333333, -0.058333333333333, 0
26340, 2.1916666666667, -0.066666666666667, 0
26341, 1.2083333333333, -0.083333333333333, 0
26342, 1.2166666666667, -0.075, 0
26343, 1.225, -0.083333333333333, 0
26344, 1.2333333333333, -0.075, 0
26345, 1.2416666666667, -0.083333333333333, 0
26346, 1.25, -0.075, 0
26347, 1.2583333333333, -0.083333333333333, 0
26348, 1.2666666666667, -0.075, 0
26349, 1.275, -0.083333333333333, 0
26350, 1.2833333333333, -0.075, 0
26351, 1.2916666666667, -0.083333333333333, 0
26352, 1.3, -0.075, 0
26353, 1.3083333333333, -0.083333333333333, 0
26354, 1.3166666666667, -0.075, 0
26355, 1.325, -0.083333333333333, 0
26356, 1.3333333333333, -0.075, 0
26357, 1.3416666666667, -0.083333333333333, 0
26358, 1.35, -0.075, 0
26359, 1.3583333333333, -0.083333333333333, 0
26360, 1.3666666666667, -0.075, 0
26361, 1.375, -0.083333333333333, 0
26362, 1.3833333333333, -0.075, 0
26363, 1.3916666666667, -0.083333333333333, 0
26364, 1.4, -0.075, 0
26365, 1.4083333333333, -0.083333333333333, 0
26366, 1.4166666666667, -0.075, 0
26367, 1.425, -0.083333333333333, 0
26368, 1.4333333333333, -0.075, 0
26369, 1.4416666666667, -0.083333333333333, 0
26370, 1.45, -0.075, 0
26371, 1.4583333333333, -0.083333333333333, 0
26372, 1.4666666666667, -0.075, 0
26373, 1.475, -0.083333333333333, 0
26374, 1.4833333333333, -0.075, 0
26375, 1.4916666666667, -0.083333333333333, 0
26376, 1.5, -0.075, 0
26377, 1.5083333333333, -0.083333333333333, 0
26378, 1.5166666666667, -0.075, 0
26379, 1.525, -0.083333333333333, 0
26380, 1.5333333333333, -0.075, 0
26381, 1.5416666666667, -0.083333333333333, 0
26382, 1.55, -0.075, 0
26383, 1.5583333333333, -0.083333333333333, 0
26384, 1.5666666666667, -0.075, 0
26385, 1.575, -0.083333333333333, 0
26386, 1.5833333333333, -0.075, 0
26387, 1.5916666666667, -0.083333333333333, 0
26388, 1.6, -0.075, 0
26389, 1.6083333333333, -0.083333333333333, 0
26390, 1.6166666666667, -0.075, 0
26391, 1.625, -0.083333333333333, 0
26392, 1.6333333333333, -0.075, 0
26393, 1.6416666666667, -0.083333333333333, 0
26394, 1.65, -0.075, 0
26395, 1.6583333333333, -0.083333333333333, 0
26396, 1.6666666666667, -0.075, 0
26397, 1.675, -0.083333333333333, 0
26398, 1.6833333333333, -0.075, 0
26399, 1.6916666666667, -0.083333333333333, 0
26400, 1.7, -0.075, 0
26401, 1.7083333333333, -0.083333333333333, 0
26402, 1.7166666666667, -0.075, 0
26403, 1.725, -0.083333333333333, 0
26404, 1.7333333333333, -0.075, 0
26405, 1.7416666666667, -0.083333333333333, 0
26406, 1.75, -0.075, 0
26407, 1.7583333333333, -0.083333333333333, 0
26408, 1.7666666666667, -0.075, 0
26409, 1.775, -0.083333333333333, 0
26410, 1.7833333333333, -0.075, 0
26411, 1.7916666666667, -0.083333333333333, 0
26412, 1.8, -0.075, 0
26413, 1.8083333333333, -0.083333333333333, 0
26414, 1.8166666666667, -0.075, 0
26415, 1.825, -0.083333333333333, 0
26416, 1.8333333333333, -0.075, 0
26417, 1.8416666666667, -0.083333333333333, 0
26418, 1.85, -0.075, 0
26419, 1.8583333333333, -0.083333333333333, 0
26420, 1.8666666666667, -0.075, 0
26421, 1.875, -0.083333333333333, 0
26422, 1.8833333333333, -0.075, 0
26423, 1.8916666666667, -0.083333333333333, 0
26424, 1.9, -0.075, 0
26425, 1.9083333333333, -0.083333333333333, 0
26426, 1.9166666666667, -0.075, 0
26427, 1.925, -0.083333333333333, 0
26428, 1.9333333333333, -0.075, 0
26429, 1.9416666666667, -0.083333333333333, 0
26430, 1.95, -0.075, 0
26431, 1.9583333333333, -0.083333333333333, 0
26432, 1.9666666666667, -0.075, 0
26433, 1.975, -0.083333333333333, 0
26434, 1.9833333333333, -0.075, 0
26435, 1.9916666666667, -0.083333333333333, 0
26436, 2, -0.075, 0
26437, 2.0083333333333, -0.083333333333333, 0
26438, 2.0166666666667, -0.075, 0
26439, 2.025, -0.083333333333333, 0
26440, 2.0333333333333, -0.075, 0
26441, 2.0416666666667, -0.083333333333333, 0
26442, 2.05, -0.075, 0
26443, 2.0583333333333, -0.083333333333333, 0
26444, 2.0666666666667, -0.075, 0
26445, 2.075, -0.083333333333333, 0
26446, 2.0833333333333, -0.075, 0
26447, 2.0916666666667, -0.083333333333333, 0
26448, 2.1, -0.075, 0
26449, 2.1083333333333, -0.083333333333333, 0
26450, 2.1166666666667, -0.075, 0
26451, 2.125, -0.083333333333333, 0
26452, 2.1333333333333, -0.075, 0
26453, 2.1416666666667, -0.083333333333333, 0
26454, 2.15, -0.075, 0
26455, 2.1583333333333, -0.083333333333333, 0
26456, 2.1666666666667, -0.075, 0
26457, 2.175, -0.083333333333333, 0
26458, 2.1833333333333, -0.075, 0
26459, 2.1916666666667, -0.083333333333333, 0
26460, 1.2083333333333, -0.1, 0
26461, 1.2166666666667, -0.091666666666667, 0
26462, 1.225, -0.1, 0
26463, 1.2333333333333, -0.091666666666667, 0
26464, 1.2416666666667, -0.1, 0
26465, 1.25, -0.091666666666667, 0
26466, 1.2583333333333, -0.1, 0
26467, 1.2666666666667, -0.091666666666667, 0
26468, 1.275, -0.1, 0
26469, 1.2833333333333, -0.091666666666667, 0
26470, 1.2916666666667, -0.1, 0
26471, 1.3, -0.091666666666667, 0
26472, 1.3083333333333, -0.1, 0
26473, 1.3166666666667, -0.091666666666667, 0
26474, 1.325, -0.1, 0
26475, 1.3333333333333, -0.091666666666667, 0
26476, 1.3416666666667, -0.1, 0
26477, 1.35, -0.091666666666667, 0
26478, 1.3583333333333, -0.1, 0
26479, 1.3666666666667, -0.091666666666667, 0
26480, 1.375, -0.1, 0
26481, 1.3833333333333, -0.091666666666667, 0
26482, 1.3916666666667, -0.1, 0
26483, 1.4, -0.091666666666667, 0
26484, 1.4083333333333, -0.1, 0
26485, 1.4166666666667, -0.091666666666667, 0
26486, 1.425, -0.1, 0
26487, 1.4333333333333, -0.091666666666667, 0
26488, 1.4416666666667, -0.1, 0
26489, 1.45, -0.091666666666667, 0
26490, 1.4583333333333, -0.1, 0
26491, 1.4666666666667, -0.091666666666667, 0
26492, 1.475, -0.1, 0
26493, 1.4833333333333, -0.091666666666667, 0
26494, 1.4916666666667, -0.1, 0
26495, 1.5, -0.091666666666667, 0
26496, 1.5083333333333, -0.1, 0
26497, 1.5166666666667, -0.091666666666667, 0
26498, 1.525, -0.1, 0
26499, 1.5333333333333, -0.091666666666667, 0
26500, 1.5416666666667, -0.1, 0
26501, 1.55, -0.091666666666667, 0
26502, 1.5583333333333, -0.1, 0
26503, 1.5666666666667, -0.091666666666667, 0
26504, 1.575, -0.1, 0
26505, 1.5833333333333, -0.091666666666667, 0
26506, 1.5916666666667, -0.1, 0
26507, 1.6, -0.091666666666667, 0
26508, 1.6083333333333, -0.1, 0
26509, 1.6166666666667, -0.091666666666667, 0
26510, 1.625, -0.1, 0
26511, 1.6333333333333, -0.091666666666667, 0
26512, 1.6416666666667, -0.1, 0
26513, 1.65, -0.091666666666667, 0
26514, 1.6583333333333, -0.1, 0
26515, 1.6666666666667, -0.091666666666667, 0
26516, 1.675, -0.1, 0
26517, 1.6833333333333, -0.091666666666667, 0
26518, 1.6916666666667, -0.1, 0
26519, 1.7, -0.091666666666667, 0
26520, 1.7083333333333, -0.1, 0
26521, 1.7166666666667, -0.091666666666667, 0
26522, 1.725, -0.1, 0
26523, 1.7333333333333, -0.091666666666667, 0
26524, 1.7416666666667, -0.1, 0
26525, 1.75, -0.091666666666667, 0
26526, 1.7583333333333, -0.1, 0
26527, 1.7666666666667, -0.091666666666667, 0
26528, 1.775, -0.1, 0
26529, 1.7833333333333, -0.091666666666667, 0
26530, 1.7916666666667, -0.1, 0
26531, 1.8, -0.091666666666667, 0
26532, 1.8083333333333, -0.1, 0
26533, 1.8166666666667, -0.091666666666667, 0
26534, 1.825, -0.1, 0
26535, 1.8333333333333, -0.091666666666667, 0
26536, 1.8416666666667, -0.1, 0
26537, 1.85, -0.091666666666667, 0
26538, 1.8583333333333, -0.1, 0
26539, 1.8666666666667, -0.091666666666667, 0
26540, 1.875, -0.1, 0
26541, 1.8833333333333, -0.091666666666667, 0
26542, 1.8916666666667, -0.1, 0
26543, 1.9, -0.091666666666667, 0
26544, 1.9083333333333, -0.1, 0
26545, 1.9166666666667, -0.091666666666667, 0
26546, 1.925, -0.1, 0
26547, 1.9333333333333, -0.091666666666667, 0
26548, 1.9416666666667, -0.1, 0
26549, 1.95, -0.091666666666667, 0
26550, 1.9583333333333, -0.1, 0
26551, 1.9666666666667, -0.091666666666667, 0
26552, 1.975, -0.1, 0
26553, 1.9833333333333, -0.091666666666667, 0
26554, 1.9916666666667, -0.1, 0
26555, 2, -0.091666666666667, 0
26556, 2.0083333333333, -0.1, 0
26557, 2.0166666666667, -0.091666666666667, 0
26558, 2.025, -0.1, 0
26559, 2.0333333333333, -0.091666666666667, 0
26560, 2.0416666666667, -0.1, 0
26561, 2.05, -0.091666666666667, 0
26562, 2.0583333333333, -0.1, 0
26563, 2.0666666666667, -0.091666666666667, 0
26564, 2.075, -0.1, 0
26565, 2.0833333333333, -0.091666666666667, 0
26566, 2.0916666666667, -0.1, 0
26567, 2.1, -0.091666666666667, 0
26568, 2.1083333333333, -0.1, 0
26569, 2.1166666666667, -0.091666666666667, 0
26570, 2.125, -0.1, 0
26571, 2.1333333333333, -0.091666666666667, 0
26572, 2.1416666666667, -0.1, 0
26573, 2.15, -0.091666666666667, 0
26574, 2.1583333333333, -0.1, 0
26575, 2.1666666666667, -0.091666666666667, 0
26576, 2.175, -0.1, 0
26577, 2.1833333333333, -0.091666666666667, 0
26578, 2.1916666666667, -0.1, 0
26579, 1.2083333333333, -0.11666666666667, 0
26580, 1.2166666666667, -0.10833333333333, 0
26581, 1.225, -0.11666666666667, 0
26582, 1.2333333333333, -0.10833333333333, 0
26583, 1.2416666666667, -0.11666666666667, 0
26584, 1.25, -0.10833333333333, 0
26585, 1.2583333333333, -0.11666666666667, 0
26586, 1.2666666666667, -0.10833333333333, 0
26587, 1.275, -0.11666666666667, 0
26588, 1.2833333333333, -0.10833333333333, 0
26589, 1.2916666666667, -0.11666666666667, 0
26590, 1.3, -0.10833333333333, 0
26591, 1.3083333333333, -0.11666666666667, 0
26592, 1.3166666666667, -0.10833333333333, 0
26593, 1.325, -0.11666666666667, 0
26594, 1.3333333333333, -0.10833333333333, 0
26595, 1.3416666666667, -0.11666666666667, 0
26596, 1.35, -0.10833333333333, 0
26597, 1.3583333333333, -0.11666666666667, 0
26598, 1.3666666666667, -0.10833333333333, 0
26599, 1.375, -0.11666666666667, 0
26600, 1.3833333333333, -0.10833333333333, 0
26601, 1.3916666666667, -0.11666666666667, 0
26602, 1.4, -0.10833333333333, 0
26603, 1.4083333333333, -0.11666666666667, 0
26604, 1.4166666666667, -0.10833333333333, 0
26605, 1.425, -0.11666666666667, 0
26606, 1.4333333333333, -0.10833333333333, 0
26607, 1.4416666666667, -0.11666666666667, 0
26608, 1.45, -0.10833333333333, 0
26609, 1.4583333333333, -0.11666666666667, 0
26610, 1.4666666666667, -0.10833333333333, 0
26611, 1.475, -0.11666666666667, 0
26612, 1.4833333333333, -0.10833333333333, 0
26613, 1.4916666666667, -0.11666666666667, 0
26614, 1.5, -0.10833333333333, 0
26615, 1.5083333333333, -0.11666666666667, 0
26616, 1.5166666666667, -0.10833333333333, 0
26617, 1.525, -0.11666666666667, 0
26618, 1.5333333333333, -0.10833333333333, 0
26619, 1.5416666666667, -0.11666666666667, 0
26620, 1.55, -0.10833333333333, 0
26621, 1.5583333333333, -0.11666666666667, 0
26622, 1.5666666666667, -0.10833333333333, 0
26623, 1.575, -0.11666666666667, 0
26624, 1.5833333333333, -0.10833333333333, 0
26625, 1.5916666666667, -0.11666666666667, 0
26626, 1.6, -0.10833333333333, 0
26627, 1.6083333333333, -0.11666666666667, 0
26628, 1.6166666666667, -0.10833333333333, 0
26629, 1.625, -0.11666666666667, 0
26630, 1.6333333333333, -0.10833333333333, 0
26631, 1.6416666666667, -0.11666666666667, 0
26632, 1.65, -0.10833333333333, 0
26633, 1.6583333333333, -0.11666666666667, 0
26634, 1.6666666666667, -0.10833333333333, 0
26635, 1.675, -0.11666666666667, 0
26636, 1.6833333333333, -0.10833333333333, 0
26637, 1.6916666666667, -0.11666666666667, 0
26638, 1.7, -0.10833333333333, 0
26639, 1.7083333333333, -0.11666666666667, 0
26640, 1.7166666666667, -0.10833333333333, 0
26641, 1.725, -0.11666666666667, 0
26642, 1.7333333333333, -0.10833333333333, 0
26643, 1.7416666666667, -0.11666666666667, 0
26644, 1.75, -0.10833333333333, 0
26645, 1.7583333333333, -0.11666666666667, 0
26646, 1.7666666666667, -0.10833333333333, 0
26647, 1.775, -0.11666666666667, 0
26648, 1.7833333333333, -0.10833333333333, 0
26649, 1.7916666666667, -0.11666666666667, 0
26650, 1.8, -0.10833333333333, 0
26651, 1.8083333333333, -0.11666666666667, 0
26652, 1.8166666666667, -0.10833333333333, 0
26653, 1.825, -0.11666666666667, 0
26654, 1.8333333333333, -0.10833333333333, 0
26655, 1.8416666666667, -0.11666666666667, 0
26656, 1.85, -0.10833333333333, 0
26657, 1.8583333333333, -0.11666666666667, 0
26658, 1.8666666666667, -0.10833333333333, 0
26659, 1.875, -0.11666666666667, 0
26660, 1.8833333333333, -0.10833333333333, 0
26661, 1.8916666666667, -0.11666666666667, 0
26662, 1.9, -0.10833333333333, 0
26663, 1.9083333333333, -0.11666666666667, 0
26664, 1.9166666666667, -0.10833333333333, 0
26665, 1.925, -0.11666666666667, 0
26666, 1.9333333333333, -0.10833333333333, 0
26667, 1.9416666666667, -0.11666666666667, 0
26668, 1.95, -0.10833333333333, 0
26669, 1.9583333333333, -0.11666666666667, 0
26670, 1.9666666666667, -0.10833333333333, 0
26671, 1.975, -0.11666666666667, 0
26672, 1.9833333333333, -0.10833333333333, 0
26673, 1.9916666666667, -0.11666666666667, 0
26674, 2, -0.10833333333333, 0
26675, 2.0083333333333, -0.11666666666667, 0
26676, 2.0166666666667, -0.10833333333333, 0
26677, 2.025, -0.11666666666667, 0
26678, 2.0333333333333, -0.10833333333333, 0
26679, 2.0416666666667, -0.11666666666667, 0
26680, 2.05, -0.10833333333333, 0
26681, 2.0583333333333, -0.11666666666667, 0
26682, 2.0666666666667, -0.10833333333333, 0
26683, 2.075, -0.11666666666667, 0
26684, 2.0833333333333, -0.10833333333333, 0
26685, 2.0916666666667, -0.11666666666667, 0
26686, 2.1, -0.10833333333333, 0
26687, 2.1083333333333, -0.11666666666667, 0
26688, 2.1166666666667, -0.10833333333333, 0
26689, 2.125, -0.11666666666667, 0
26690, 2.1333333333333, -0.10833333333333, 0
26691, 2.1416666666667, -0.11666666666667, 0
26692, 2.15, -0.10833333333333, 0
26693, 2.1583333333333, -0.11666666666667, 0
26694, 2.1666666666667, -0.10833333333333, 0
26695, 2.175, -0.11666666666667, 0
26696, 2.1833333333333, -0.10833333333333, 0
26697, 2.1916666666667, -0.11666666666667, 0
26698, 1.2083333333333, -0.13333333333333, 0
26699, 1.2166666666667, -0.125, 0
26700, 1.225, -0.13333333333333, 0
26701, 1.2333333333333, -0.125, 0
26702, 1.2416666666667, -0.13333333333333, 0
26703, 1.25, -0.125, 0
26704, 1.2583333333333, -0.13333333333333, 0
26705, 1.2666666666667, -0.125, 0
26706, 1.275, -0.13333333333333, 0
26707, 1.2833333333333, -0.125, 0
26708, 1.2916666666667, -0.13333333333333, 0
26709, 1.3, -0.125, 0
26710, 1.3083333333333, -0.13333333333333, 0
26711, 1.3166666666667, -0.125, 0
26712, 1.325, -0.13333333333333, 0
26713, 1.3333333333333, -0.125, 0
26714, 1.3416666666667, -0.13333333333333, 0
26715, 1.35, -0.125, 0
26716, 1.3583333333333, -0.13333333333333, 0
26717, 1.3666666666667, -0.125, 0
26718, 1.375, -0.13333333333333, 0
26719, 1.3833333333333, -0.125, 0
26720, 1.3916666666667, -0.13333333333333, 0
26721, 1.4, -0.125, 0
26722, 1.4083333333333, -0.13333333333333, 0
26723, 1.4166666666667, -0.125, 0
26724, 1.425, -0.13333333333333, 0
26725, 1.4333333333333, -0.125, 0
26726, 1.4416666666667, -0.13333333333333, 0
26727, 1.45, -0.125, 0
26728, 1.4583333333333, -0.13333333333333, 0
26729, 1.4666666666667, -0.125, 0
26730, 1.475, -0.13333333333333, 0
26731, 1.4833333333333, -0.125, 0
26732, 1.4916666666667, -0.13333333333333, 0
26733, 1.5, -0.125, 0
26734, 1.5083333333333, -0.13333333333333, 0
26735, 1.5166666666667, -0.125, 0
26736, 1.525, -0.13333333333333, 0
26737, 1.5333333333333, -0.125, 0
26738, 1.5416666666667, -0.13333333333333, 0
26739, 1.55, -0.125, 0
26740, 1.5583333333333, -0.13333333333333, 0
26741, 1.5666666666667, -0.125, 0
26742, 1.575, -0.13333333333333, 0
26743, 1.5833333333333, -0.125, 0
26744, 1.5916666666667, -0.13333333333333, 0
26745, 1.6, -0.125, 0
26746, 1.6083333333333, -0.13333333333333, 0
26747, 1.6166666666667, -0.125, 0
26748, 1.625, -0.13333333333333, 0
26749, 1.6333333333333, -0.125, 0
26750, 1.6416666666667, -0.13333333333333, 0
26751, 1.65, -0.125, 0
26752, 1.6583333333333, -0.13333333333333, 0
26753, 1.6666666666667, -0.125, 0
26754, 1.675, -0.13333333333333, 0
26755, 1.6833333333333, -0.125, 0
26756, 1.6916666666667, -0.13333333333333, 0
26757, 1.7, -0.125, 0
26758, 1.7083333333333, -0.13333333333333, 0
26759, 1.7166666666667, -0.125, 0
26760, 1.725, -0.13333333333333, 0
26761, 1.7333333333333, -0.125, 0
26762, 1.7416666666667, -0.13333333333333, 0
26763, 1.75, -0.125, 0
26764, 1.7583333333333, -0.13333333333333, 0
26765, 1.7666666666667, -0.125, 0
26766, 1.775, -0.13333333333333, 0
26767, 1.7833333333333, -0.125, 0
26768, 1.7916666666667, -0.13333333333333, 0
26769, 1.8, -0.125, 0
26770, 1.8083333333333, -0.13333333333333, 0
26771, 1.8166666666667, -0.125, 0
26772, 1.825, -0.13333333333333, 0
26773, 1.8333333333333, -0.125, 0
26774, 1.8416666666667, -0.13333333333333, 0
26775, 1.85, -0.125, 0
26776, 1.8583333333333, -0.13333333333333, 0
26777, 1.8666666666667, -0.125, 0
26778, 1.875, -0.13333333333333, 0
26779, 1.8833333333333, -0.125, 0
26780, 1.8916666666667, -0.13333333333333, 0
26781, 1.9, -0.125, 0
26782, 1.9083333333333, -0.13333333333333, 0
26783, 1.9166666666667, -0.125, 0
26784, 1.925, -0.13333333333333, 0
26785, 1.9333333333333, -0.125, 0
26786, 1.9416666666667, -0.13333333333333, 0
26787, 1.95, -0.125, 0
26788, 1.9583333333333, -0.13333333333333, 0
26789, 1.9666666666667, -0.125, 0
26790, 1.975, -0.13333333333333, 0
26791, 1.9833333333333, -0.125, 0
26792, 1.9916666666667, -0.13333333333333, 0
26793, 2, -0.125, 0
26794, 2.0083333333333, -0.13333333333333, 0
26795, 2.0166666666667, -0.125, 0
26796, 2.025, -0.13333333333333, 0
26797, 2.0333333333333, -0.125, 0
26798, 2.0416666666667, -0.13333333333333, 0
26799, 2.05, -0.125, 0
26800, 2.0583333333333, -0.13333333333333, 0
26801, 2.0666666666667, -0.125, 0
26802, 2.075, -0.13333333333333, 0
26803, 2.0833333333333, -0.125, 0
26804, 2.0916666666667, -0.13333333333333, 0
26805, 2.1, -0.125, 0
26806, 2.1083333333333, -0.13333333333333, 0
26807, 2.1166666666667, -0.125, 0
26808, 2.125, -0.13333333333333, 0
26809, 2.1333333333333, -0.125, 0
26810, 2.1416666666667, -0.13333333333333, 0
26811, 2.15, -0.125, 0
26812, 2.1583333333333, -0.13333333333333, 0
26813, 2.1666666666667, -0.125, 0
26814, 2.175, -0.13333333333333, 0
26815, 2.1833333333333, -0.125, 0
26816, 2.1916666666667, -0.13333333333333, 0
26817, 1.2166666666667, -0.14166666666667, 0
26818, 1.2333333333333, -0.14166666666667, 0
26819, 1.25, -0.14166666666667, 0
26820, 1.2666666666667, -0.14166666666667, 0
26821, 1.2833333333333, -0.14166666666667, 0
26822, 1.3, -0.14166666666667, 0
26823, 1.3166666666667, -0.14166666666667, 0
26824, 1.3333333333333, -0.14166666666667, 0
26825, 1.35, -0.14166666666667, 0
26826, 1.3666666666667, -0.14166666666667, 0
26827, 1.3833333333333, -0.14166666666667, 0
26828, 1.4, -0.14166666666667, 0
26829, 1.4166666666667, -0.14166666666667, 0
26830, 1.4333333333333, -0.14166666666667, 0
26831, 1.45, -0.14166666666667, 0
26832, 1.4666666666667, -0.14166666666667, 0
26833, 1.4833333333333, -0.14166666666667, 0
26834, 1.5, -0.14166666666667, 0
26835, 1.5166666666667, -0.14166666666667, 0
26836, 1.5333333333333, -0.14166666666667, 0
26837, 1.55, -0.14166666666667, 0
26838, 1.5666666666667, -0.14166666666667, 0
26839, 1.5833333333333, -0.14166666666667, 0
26840, 1.6, -0.14166666666667, 0
26841, 1.6166666666667, -0.14166666666667, 0
26842, 1.6333333333333, -0.14166666666667, 0
26843, 1.65, -0.14166666666667, 0
26844, 1.6666666666667, -0.14166666666667, 0
26845, 1.6833333333333, -0.14166666666667, 0
26846, 1.7, -0.14166666666667, 0
26847, 1.7166666666667, -0.14166666666667, 0
26848, 1.7333333333333, -0.14166666666667, 0
26849, 1.75, -0.14166666666667, 0
26850, 1.7666666666667, -0.14166666666667, 0
26851, 1.7833333333333, -0.14166666666667, 0
26852, 1.8, -0.14166666666667, 0
26853, 1.8166666666667, -0.14166666666667, 0
26854, 1.8333333333333, -0.14166666666667, 0
26855, 1.85, -0.14166666666667, 0
26856, 1.8666666666667, -0.14166666666667, 0
26857, 1.8833333333333, -0.14166666666667, 0
26858, 1.9, -0.14166666666667, 0
26859, 1.9166666666667, -0.14166666666667, 0
26860, 1.9333333333333, -0.14166666666667, 0
26861, 1.95, -0.14166666666667, 0
26862, 1.9666666666667, -0.14166666666667, 0
26863, 1.9833333333333, -0.14166666666667, 0
26864, 2, -0.14166666666667, 0
26865, 2.0166666666667, -0.14166666666667, 0
26866, 2.0333333333333, -0.14166666666667, 0
26867, 2.05, -0.14166666666667, 0
26868, 2.0666666666667, -0.14166666666667, 0
26869, 2.0833333333333, -0.14166666666667, 0
26870, 2.1, -0.14166666666667, 0
26871, 2.1166666666667, -0.14166666666667, 0
26872, 2.1333333333333, -0.14166666666667, 0
26873, 2.15, -0.14166666666667, 0
26874, 2.1666666666667, -0.14166666666667, 0
26875, 2.1833333333333, -0.14166666666667, 0
26876, 0.016666666666667, -0.066666666666667, 0
26877, 0.033333333333333, -0.066666666666667, 0
26878, 0.05, -0.066666666666667, 0
26879, 0.066666666666667, -0.066666666666667, 0
26880, 0.083333333333333, -0.066666666666667, 0
26881, 0.1, -0.066666666666667, 0
26882, 0.11666666666667, -0.066666666666667, 0
26883, 0.13333333333333, -0.066666666666667, 0
26884, 0.15, -0.066666666666667, 0
26885, 0.16666666666667, -0.066666666666667, 0
26886, 0.18333333333333, -0.066666666666667, 0
26887, 0.2, -0.066666666666667, 0
26888, 0.21666666666667, -0.066666666666667, 0
26889, 0.23333333333333, -0.066666666666667, 0
26890, 0.25, -0.066666666666667, 0
26891, 0.26666666666667, -0.066666666666667, 0
26892, 0.28333333333333, -0.066666666666667, 0
26893, 0.3, -0.066666666666667, 0
26894, 0.31666666666667, -0.066666666666667, 0
26895, 0.33333333333333, -0.066666666666667, 0
26896, 0.35, -0.066666666666667, 0
26897, 0.36666666666667, -0.066666666666667, 0
26898, 0.38333333333333, -0.066666666666667, 0
26899, 0.4, -0.066666666666667, 0
26900, 0.41666666666667, -0.066666666666667, 0
26901, 0.43333333333333, -0.066666666666667, 0
26902, 0.45, -0.066666666666667, 0
26903, 0.46666666666667, -0.066666666666667, 0
26904, 0.48333333333333, -0.066666666666667, 0
26905, 0.5, -0.066666666666667, 0
26906, 0.51666666666667, -0.066666666666667, 0
26907, 0.53333333333333, -0.066666666666667, 0
26908, 0.55, -0.066666666666667, 0
26909, 0.56666666666667, -0.066666666666667, 0
26910, 0.58333333333333, -0.066666666666667, 0
26911, 0.6, -0.066666666666667, 0
26912, 0.61666666666667, -0.066666666666667, 0
26913, 0.63333333333333, -0.066666666666667, 0
26914, 0.65, -0.066666666666667, 0
26915, 0.66666666666667, -0.066666666666667, 0
26916, 0.68333333333333, -0.066666666666667, 0
26917, 0.7, -0.066666666666667, 0
26918, 0.71666666666667, -0.066666666666667, 0
26919, 0.73333333333333, -0.066666666666667, 0
26920, 0.75, -0.066666666666667, 0
26921, 0.76666666666667, -0.066666666666667, 0
26922, 0.78333333333333, -0.066666666666667, 0
26923, 0.8, -0.066666666666667, 0
26924, 0.81666666666667, -0.066666666666667, 0
26925, 0.83333333333333, -0.066666666666667, 0
26926, 0.85, -0.066666666666667, 0
26927, 0.86666666666667, -0.066666666666667, 0
26928, 0.88333333333333, -0.066666666666667, 0
26929, 0.9, -0.066666666666667, 0
26930, 0.91666666666667, -0.066666666666667, 0
26931, 0.93333333333333, -0.066666666666667, 0
26932, 0.95, -0.066666666666667, 0
26933, 0.96666666666667, -0.066666666666667, 0
26934, 0.98333333333333, -0.066666666666667, 0
26935, 0.016666666666667, -0.083333333333333, 0
26936, 0.033333333333333, -0.083333333333333, 0
26937, 0.05, -0.083333333333333, 0
26938, 0.066666666666667, -0.083333333333333, 0
26939, 0.083333333333333, -0.083333333333333, 0
26940, 0.1, -0.083333333333333, 0
26941, 0.11666666666667, -0.083333333333333, 0
26942, 0.13333333333333, -0.083333333333333, 0
26943, 0.15, -0.083333333333333, 0
26944, 0.16666666666667, -0.083333333333333, 0
26945, 0.18333333333333, -0.083333333333333, 0
26946, 0.2, -0.083333333333333, 0
26947, 0.21666666666667, -0.083333333333333, 0
26948, 0.23333333333333, -0.083333333333333, 0
26949, 0.25, -0.083333333333333, 0
26950, 0.26666666666667, -0.083333333333333, 0
26951, 0.28333333333333, -0.083333333333333, 0
26952, 0.3, -0.083333333333333, 0
26953, 0.31666666666667, -0.083333333333333, 0
26954, 0.33333333333333, -0.083333333333333, 0
26955, 0.35, -0.083333333333333, 0
26956, 0.36666666666667, -0.083333333333333, 0
26957, 0.38333333333333, -0.083333333333333, 0
26958, 0.4, -0.083333333333333, 0
26959, 0.41666666666667, -0.083333333333333, 0
26960, 0.43333333333333, -0.083333333333333, 0
26961, 0.45, -0.083333333333333, 0
26962, 0.46666666666667, -0.083333333333333, 0
26963, 0.48333333333333, -0.083333333333333, 0
26964, 0.5, -0.083333333333333, 0
26965, 0.51666666666667, -0.083333333333333, 0
26966, 0.53333333333333, -0.083333333333333, 0
26967, 0.55, -0.083333333333333, 0
26968, 0.56666666666667, -0.083333333333333, 0
26969, 0.58333333333333, -0.083333333333333, 0
26970, 0.6, -0.083333333333333, 0
26971, 0.61666666666667, -0.083333333333333, 0
26972, 0.63333333333333, -0.083333333333333, 0
26973, 0.65, -0.083333333333333, 0
26974, 0.66666666666667, -0.083333333333333, 0
26975, 0.68333333333333, -0.083333333333333, 0
26976, 0.7, -0.083333333333333, 0
26977, 0.71666666666667, -0.083333333333333, 0
26978, 0.73333333333333, -0.083333333333333, 0
26979, 0.75, -0.083333333333333, 0
26980, 0.76666666666667, -0.083333333333333, 0
26981, 0.78333333333333, -0.083333333333333, 0
26982, 0.8, -0.083333333333333, 0
26983, 0.81666666666667, -0.083333333333333, 0
26984, 0.83333333333333, -0.083333333333333, 0
26985, 0.85, -0.083333333333333, 0
26986, 0.86666666666667, -0.083333333333333, 0
26987, 0.88333333333333, -0.083333333333333, 0
26988, 0.9, -0.083333333333333, 0
26989, 0.91666666666667, -0.083333333333333, 0
26990, 0.93333333333333, -0.083333333333333, 0
26991, 0.95, -0.083333333333333, 0
26992, 0.96666666666667, -0.083333333333333, 0
26993, 0.98333333333333, -0.083333333333333, 0
26994, 0.016666666666667, -0.1, 0
26995, 0.033333333333333, -0.1, 0
26996, 0.05, -0.1, 0
26997, 0.066666666666667, -0.1, 0
26998, 0.083333333333333, -0.1, 0
26999, 0.1, -0.1, 0
27000, 0.11666666666667, -0.1, 0
27001, 0.13333333333333, -0.1, 0
27002, 0.15, -0.1, 0
27003, 0.16666666666667, -0.1, 0
27004, 0.18333333333333, -0.1, 0
27005, 0.2, -0.1, 0
27006, 0.21666666666667, -0.1, 0
27007, 0.23333333333333, -0.1, 0
27008, 0.25, -0.1, 0
27009, 0.26666666666667, -0.1, 0
27010, 0.28333333333333, -0.1, 0
27011, 0.3, -0.1, 0
27012, 0.31666666666667, -0.1, 0
27013, 0.33333333333333, -0.1, 0
27014, 0.35, -0.1, 0
27015, 0.36666666666667, -0.1, 0
27016, 0.38333333333333, -0.1, 0
27017, 0.4, -0.1, 0
27018, 0.41666666666667, -0.1, 0
27019, 0.43333333333333, -0.1, 0
27020, 0.45, -0.1, 0
27021, 0.46666666666667, -0.1, 0
27022, 0.48333333333333, -0.1, 0
27023, 0.5, -0.1, 0
27024, 0.51666666666667, -0.1, 0
27025, 0.53333333333333, -0.1, 0
27026, 0.55, -0.1, 0
27027, 0.56666666666667, -0.1, 0
27028, 0.58333333333333, -0.1, 0
27029, 0.6, -0.1, 0
27030, 0.61666666666667, -0.1, 0
27031, 0.63333333333333, -0.1, 0
27032, 0.65, -0.1, 0
27033, 0.66666666666667, -0.1, 0
27034, 0.68333333333333, -0.1, 0
27035, 0.7, -0.1, 0
27036, 0.71666666666667, -0.1, 0
27037, 0.73333333333333, -0.1, 0
27038, 0.75, -0.1, 0
27039, 0.76666666666667, -0.1, 0
27040, 0.78333333333333, -0.1, 0
27041, 0.8, -0.1, 0
27042, 0.81666666666667, -0.1, 0
27043, 0.83333333333333, -0.1, 0
27044, 0.85, -0.1, 0
27045, 0.86666666666667, -0.1, 0
27046, 0.88333333333333, -0.1, 0
27047, 0.9, -0.1, 0
27048, 0.91666666666667, -0.1, 0
27049, 0.93333333333333, -0.1, 0
27050, 0.95, -0.1, 0
27051, 0.96666666666667, -0.1, 0
27052, 0.98333333333333, -0.1, 0
27053, 0.016666666666667, -0.11666666666667, 0
27054, 0.033333333333333, -0.11666666666667, 0
27055, 0.05, -0.11666666666667, 0
27056, 0.066666666666667, -0.11666666666667, 0
27057, 0.083333333333333, -0.11666666666667, 0
27058, 0.1, -0.11666666666667, 0
27059, 0.11666666666667, -0.11666666666667, 0
27060, 0.13333333333333, -0.11666666666667, 0
27061, 0.15, -0.11666666666667, 0
27062, 0.16666666666667, -0.11666666666667, 0
27063, 0.18333333333333, -0.11666666666667, 0
27064, 0.2, -0.11666666666667, 0
27065, 0.21666666666667, -0.11666666666667, 0
27066, 0.23333333333333, -0.11666666666667, 0
27067, 0.25, -0.11666666666667, 0
27068, 0.26666666666667, -0.11666666666667, 0
27069, 0.28333333333333, -0.11666666666667, 0
27070, 0.3, -0.11666666666667, 0
27071, 0.31666666666667, -0.11666666666667, 0
27072, 0.33333333333333, -0.11666666666667, 0
27073, 0.35, -0.11666666666667, 0
27074, 0.36666666666667, -0.11666666666667, 0
27075, 0.38333333333333, -0.11666666666667, 0
27076, 0.4, -0.11666666666667, 0
27077, 0.41666666666667, -0.11666666666667, 0
27078, 0.43333333333333, -0.11666666666667, 0
27079, 0.45, -0.11666666666667, 0
27080, 0.46666666666667, -0.11666666666667, 0
27081, 0.48333333333333, -0.11666666666667, 0
27082, 0.5, -0.11666666666667, 0
27083, 0.51666666666667, -0.11666666666667, 0
27084, 0.53333333333333, -0.11666666666667, 0
27085, 0.55, -0.11666666666667, 0
27086, 0.56666666666667, -0.11666666666667, 0
27087, 0.58333333333333, -0.11666666666667, 0
27088, 0.6, -0.11666666666667, 0
27089, 0.61666666666667, -0.11666666666667, 0
27090, 0.63333333333333, -0.11666666666667, 0
27091, 0.65, -0.11666666666667, 0
27092, 0.66666666666667, -0.11666666666667, 0
27093, 0.68333333333333, -0.11666666666667, 0
27094, 0.7, -0.11666666666667, 0
27095, 0.71666666666667, -0.11666666666667, 0
27096, 0.73333333333333, -0.11666666666667, 0
27097, 0.75, -0.11666666666667, 0
27098, 0.76666666666667, -0.11666666666667, 0
27099, 0.78333333333333, -0.11666666666667, 0
27100, 0.8, -0.11666666666667, 0
27101, 0.81666666666667, -0.11666666666667, 0
27102, 0.83333333333333, -0.11666666666667, 0
27103, 0.85, -0.11666666666667, 0
27104, 0.86666666666667, -0.11666666666667, 0
27105, 0.88333333333333, -0.11666666666667, 0
27106, 0.9, -0.11666666666667, 0
27107, 0.91666666666667, -0.11666666666667, 0
27108, 0.93333333333333, -0.11666666666667, 0
27109, 0.95, -0.11666666666667, 0
27110, 0.96666666666667, -0.11666666666667, 0
27111, 0.98333333333333, -0.11666666666667, 0
27112, 0.016666666666667, -0.13333333333333, 0
27113, 0.033333333333333, -0.13333333333333, 0
27114, 0.05, -0.13333333333333, 0
27115, 0.066666666666667, -0.13333333333333, 0
27116, 0.083333333333333, -0.13333333333333, 0
27117, 0.1, -0.13333333333333, 0
27118, 0.11666666666667, -0.13333333333333, 0
27119, 0.13333333333333, -0.13333333333333, 0
27120, 0.15, -0.13333333333333, 0
27121, 0.16666666666667, -0.13333333333333, 0
27122, 0.18333333333333, -0.13333333333333, 0
27123, 0.2, -0.13333333333333, 0
27124, 0.21666666666667, -0.13333333333333, 0
27125, 0.23333333333333, -0.13333333333333, 0
27126, 0.25, -0.13333333333333, 0
27127, 0.26666666666667, -0.13333333333333, 0
27128, 0.28333333333333, -0.13333333333333, 0
27129, 0.3, -0.13333333333333, 0
27130, 0.31666666666667, -0.13333333333333, 0
27131, 0.33333333333333, -0.13333333333333, 0
27132, 0.35, -0.13333333333333, 0
27133, 0.36666666666667, -0.13333333333333, 0
27134, 0.38333333333333, -0.13333333333333, 0
27135, 0.4, -0.13333333333333, 0
27136, 0.41666666666667, -0.13333333333333, 0
27137, 0.43333333333333, -0.13333333333333, 0
27138, 0.45, -0.13333333333333, 0
27139, 0.46666666666667, -0.13333333333333, 0
27140, 0.48333333333333, -0.13333333333333, 0
27141, 0.5, -0.13333333333333, 0
27142, 0.51666666666667, -0.13333333333333, 0
27143, 0.53333333333333, -0.13333333333333, 0
27144, 0.55, -0.13333333333333, 0
27145, 0.56666666666667, -0.13333333333333, 0
27146, 0.58333333333333, -0.13333333333333, 0
27147, 0.6, -0.13333333333333, 0
27148, 0.61666666666667, -0.13333333333333, 0
27149, 0.63333333333333, -0.13333333333333, 0
27150, 0.65, -0.13333333333333, 0
27151, 0.66666666666667, -0.13333333333333, 0
27152, 0.68333333333333, -0.13333333333333, 0
27153, 0.7, -0.13333333333333, 0
27154, 0.71666666666667, -0.13333333333333, 0
27155, 0.73333333333333, -0.13333333333333, 0
27156, 0.75, -0.13333333333333, 0
27157, 0.76666666666667, -0.13333333333333, 0
27158, 0.78333333333333, -0.13333333333333, 0
27159, 0.8, -0.13333333333333, 0
27160, 0.81666666666667, -0.13333333333333, 0
27161, 0.83333333333333, -0.13333333333333, 0
27162, 0.85, -0.13333333333333, 0
27163, 0.86666666666667, -0.13333333333333, 0
27164, 0.88333333333333, -0.13333333333333, 0
27165, 0.9, -0.13333333333333, 0
27166, 0.91666666666667, -0.13333333333333, 0
27167, 0.93333333333333, -0.13333333333333, 0
27168, 0.95, -0.13333333333333, 0
27169, 0.96666666666667, -0.13333333333333, 0
27170, 0.98333333333333, -0.13333333333333, 0
27171, 0.0083333333333333, -0.066666666666667, 0
27172, 0.016666666666667, -0.058333333333333, 0
27173, 0.025, -0.066666666666667, 0
27174, 0.033333333333333, -0.058333333333333, 0
27175, 0.041666666666667, -0.066666666666667, 0
27176, 0.05, -0.058333333333333, 0
27177, 0.058333333333333, -0.066666666666667, 0
27178, 0.066666666666667, -0.058333333333333, 0
27179, 0.075, -0.066666666666667, 0
27180, 0.083333333333333, -0.058333333333333, 0
27181, 0.091666666666667, -0.066666666666667, 0
27182, 0.1, -0.058333333333333, 0
27183, 0.10833333333333, -0.066666666666667, 0
27184, 0.11666666666667, -0.058333333333333, 0
27185, 0.125, -0.066666666666667, 0
27186, 0.13333333333333, -0.058333333333333, 0
27187, 0.14166666666667, -0.066666666666667, 0
27188, 0.15, -0.058333333333333, 0
27189, 0.15833333333333, -0.066666666666667, 0
27190, 0.16666666666667, -0.058333333333333, 0
27191, 0.175, -0.066666666666667, 0
27192, 0.18333333333333, -0.058333333333333, 0
27193, 0.19166666666667, -0.066666666666667, 0
27194, 0.2, -0.058333333333333, 0
27195, 0.20833333333333, -0.066666666666667, 0
27196, 0.21666666666667, -0.058333333333333, 0
27197, 0.225, -0.066666666666667, 0
27198, 0.23333333333333, -0.058333333333333, 0
27199, 0.24166666666667, -0.066666666666667, 0
27200, 0.25, -0.058333333333333, 0
27201, 0.25833333333333, -0.066666666666667, 0
27202, 0.26666666666667, -0.058333333333333, 0
27203, 0.275, -0.066666666666667, 0
27204, 0.28333333333333, -0.058333333333333, 0
27205, 0.29166666666667, -0.066666666666667, 0
27206, 0.3, -0.058333333333333, 0
27207, 0.30833333333333, -0.066666666666667, 0
27208, 0.31666666666667, -0.058333333333333, 0
27209, 0.325, -0.066666666666667, 0
27210, 0.33333333333333, -0.058333333333333, 0
27211, 0.34166666666667, -0.066666666666667, 0
27212, 0.35, -0.058333333333333, 0
27213, 0.35833333333333, -0.066666666666667, 0
27214, 0.36666666666667, -0.058333333333333, 0
27215, 0.375, -0.066666666666667, 0
27216, 0.38333333333333, -0.058333333333333, 0
27217, 0.39166666666667, -0.066666666666667, 0
27218, 0.4, -0.058333333333333, 0
27219, 0.40833333333333, -0.066666666666667, 0
27220, 0.41666666666667, -0.058333333333333, 0
27221, 0.425, -0.066666666666667, 0
27222, 0.43333333333333, -0.058333333333333, 0
27223, 0.44166666666667, -0.066666666666667, 0
27224, 0.45, -0.058333333333333, 0
27225, 0.45833333333333, -0.066666666666667, 0
27226, 0.46666666666667, -0.058333333333333, 0
27227, 0.475, -0.066666666666667, 0
27228, 0.48333333333333, -0.058333333333333, 0
27229, 0.49166666666667, -0.066666666666667, 0
27230, 0.5, -0.058333333333333, 0
27231, 0.50833333333333, -0.066666666666667, 0
27232, 0.51666666666667, -0.058333333333333, 0
27233, 0.525, -0.066666666666667, 0
27234, 0.53333333333333, -0.058333333333333, 0
27235, 0.54166666666667, -0.066666666666667, 0
27236, 0.55, -0.058333333333333, 0
27237, 0.55833333333333, -0.066666666666667, 0
27238, 0.56666666666667, -0.058333333333333, 0
27239, 0.575, -0.066666666666667, 0
27240, 0.58333333333333, -0.058333333333333, 0
27241, 0.59166666666667, -0.066666666666667, 0
27242, 0.6, -0.058333333333333, 0
27243, 0.60833333333333, -0.066666666666667, 0
27244, 0.61666666666667, -0.058333333333333, 0
27245, 0.625, -0.066666666666667, 0
27246, 0.63333333333333, -0.058333333333333, 0
27247, 0.64166666666667, -0.066666666666667, 0
27248, 0.65, -0.058333333333333, 0
27249, 0.65833333333333, -0.066666666666667, 0
27250, 0.66666666666667, -0.058333333333333, 0
27251, 0.675, -0.066666666666667, 0
27252, 0.68333333333333, -0.058333333333333, 0
27253, 0.69166666666667, -0.066666666666667, 0
27254, 0.7, -0.058333333333333, 0
27255, 0.70833333333333, -0.066666666666667, 0
27256, 0.71666666666667, -0.058333333333333, 0
27257, 0.725, -0.066666666666667, 0
27258, 0.73333333333333, -0.058333333333333, 0
27259, 0.74166666666667, -0.066666666666667, 0
27260, 0.75, -0.058333333333333, 0
27261, 0.75833333333333, -0.066666666666667, 0
27262, 0.76666666666667, -0.058333333333333, 0
27263, 0.775, -0.066666666666667, 0
27264, 0.78333333333333, -0.058333333333333, 0
27265, 0.79166666666667, -0.066666666666667, 0
27266, 0.8, -0.058333333333333, 0
27267, 0.80833333333333, -0.066666666666667, 0
27268, 0.81666666666667, -0.058333333333333, 0
27269, 0.825, -0.066666666666667, 0
27270, 0.83333333333333, -0.058333333333333, 0
27271, 0.84166666666667, -0.066666666666667, 0
27272, 0.85, -0.058333333333333, 0
27273, 0.85833333333333, -0.066666666666667, 0
27274, 0.86666666666667, -0.058333333333333, 0
27275, 0.875, -0.066666666666667, 0
27276, 0.88333333333333, -0.058333333333333, 0
27277, 0.89166666666667, -0.066666666666667, 0
27278, 0.9, -0.058333333333333, 0
27279, 0.90833333333333, -0.066666666666667, 0
27280, 0.91666666666667, -0.058333333333333, 0
27281, 0.925, -0.066666666666667, 0
27282, 0.93333333333333, -0.058333333333333, 0
27283, 0.94166666666667, -0.066666666666667, 0
27284, 0.95, -0.058333333333333, 0
27285, 0.95833333333333, -0.066666666666667, 0
27286, 0.96666666666667, -0.058333333333333, 0
27287, 0.975, -0.066666666666667, 0
27288, 0.98333333333333, -0.058333333333333, 0
27289, 0.99166666666667, -0.066666666666667, 0
27290, 0.0083333333333333, -0.083333333333333, 0
27291, 0.016666666666667, -0.075, 0
27292, 0.025, -0.083333333333333, 0
27293, 0.033333333333333, -0.075, 0
27294, 0.041666666666667, -0.083333333333333, 0
27295, 0.05, -0.075, 0
27296, 0.058333333333333, -0.083333333333333, 0
27297, 0.066666666666667, -0.075, 0
27298, 0.075, -0.083333333333333, 0
27299, 0.083333333333333, -0.075, 0
27300, 0.091666666666667, -0.083333333333333, 0
27301, 0.1, -0.075, 0
27302, 0.10833333333333, -0.083333333333333, 0
27303, 0.11666666666667, -0.075, 0
27304, 0.125, -0.083333333333333, 0
27305, 0.13333333333333, -0.075, 0
27306, 0.14166666666667, -0.083333333333333, 0
27307, 0.15, -0.075, 0
27308, 0.15833333333333, -0.083333333333333, 0
27309, 0.16666666666667, -0.075, 0
27310, 0.175, -0.083333333333333, 0
27311, 0.18333333333333, -0.075, 0
27312, 0.19166666666667, -0.083333333333333, 0
27313, 0.2, -0.075, 0
27314, 0.20833333333333, -0.083333333333333, 0
27315, 0.21666666666667, -0.075, 0
27316, 0.225, -0.083333333333333, 0
27317, 0.23333333333333, -0.075, 0
27318, 0.24166666666667, -0.083333333333333, 0
27319, 0.25, -0.075, 0
27320, 0.25833333333333, -0.083333333333333, 0
27321, 0.26666666666667, -0.075, 0
27322, 0.275, -0.083333333333333, 0
27323, 0.28333333333333, -0.075, 0
27324, 0.29166666666667, -0.083333333333333, 0
27325, 0.3, -0.075, 0
27326, 0.30833333333333, -0.083333333333333, 0
27327, 0.31666666666667, -0.075, 0
27328, 0.325, -0.083333333333333, 0
27329, 0.33333333333333, -0.075, 0
27330, 0.34166666666667, -0.083333333333333, 0
27331, 0.35, -0.075, 0
27332, 0.35833333333333, -0.083333333333333, 0
27333, 0.36666666666667, -0.075, 0
27334, 0.375, -0.083333333333333, 0
27335, 0.38333333333333, -0.075, 0
27336, 0.39166666666667, -0.083333333333333, 0
27337, 0.4, -0.075, 0
27338, 0.40833333333333, -0.083333333333333, 0
27339, 0.41666666666667, -0.075, 0
27340, 0.425, -0.083333333333333, 0
27341, 0.43333333333333, -0.075, 0
27342, 0.44166666666667, -0.083333333333333, 0
27343, 0.45, -0.075, 0
27344, 0.45833333333333, -0.083333333333333, 0
27345, 0.46666666666667, -0.075, 0
27346, 0.475, -0.083333333333333, 0
27347, 0.48333333333333, -0.075, 0
27348, 0.49166666666667, -0.083333333333333, 0
27349, 0.5, -0.075, 0
27350, 0.50833333333333, -0.083333333333333, 0
27351, 0.51666666666667, -0.075, 0
27352, 0.525, -0.083333333333333, 0
27353, 0.53333333333333, -0.075, 0
27354, 0.54166666666667, -0.083333333333333, 0
27355, 0.55, -0.075, 0
27356, 0.55833333333333, -0.083333333333333, 0
27357, 0.56666666666667, -0.075, 0
27358, 0.575, -0.083333333333333, 0
27359, 0.58333333333333, -0.075, 0
27360, 0.59166666666667, -0.083333333333333, 0
27361, 0.6, -0.075, 0
27362, 0.60833333333333, -0.083333333333333, 0
27363, 0.61666666666667, -0.075, 0
27364, 0.625, -0.083333333333333, 0
27365, 0.63333333333333, -0.075, 0
27366, 0.64166666666667, -0.083333333333333, 0
27367, 0.65, -0.075, 0
27368, 0.65833333333333, -0.083333333333333, 0
27369, 0.66666666666667, -0.075, 0
27370, 0.675, -0.083333333333333, 0
27371, 0.68333333333333, -0.075, 0
27372, 0.69166666666667, -0.083333333333333, 0
27373, 0.7, -0.075, 0
27374, 0.70833333333333, -0.083333333333333, 0
27375, 0.71666666666667, -0.075, 0
27376, 0.725, -0.083333333333333, 0
27377, 0.73333333333333, -0.075, 0
27378, 0.74166666666667, -0.083333333333333, 0
27379, 0.75, -0.075, 0
27380, 0.75833333333333, -0.083333333333333, 0
27381, 0.76666666666667, -0.075, 0
27382, 0.775, -0.083333333333333, 0
27383, 0.78333333333333, -0.075, 0
27384, 0.79166666666667, -0.083333333333333, 0
27385, 0.8, -0.075, 0
27386, 0.80833333333333, -0.083333333333333, 0
27387, 0.81666666666667, -0.075, 0
27388, 0.825, -0.083333333333333, 0
27389, 0.83333333333333, -0.075, 0
27390, 0.84166666666667, -0.083333333333333, 0
27391, 0.85, -0.075, 0
27392, 0.85833333333333, -0.083333333333333, 0
27393, 0.86666666666667, -0.075, 0
27394, 0.875, -0.083333333333333, 0
27395, 0.88333333333333, -0.075, 0
27396, 0.89166666666667, -0.083333333333333, 0
27397, 0.9, -0.075, 0
27398, 0.90833333333333, -0.083333333333333, 0
27399, 0.91666666666667, -0.075, 0
27400, 0.925, -0.083333333333333, 0
27401, 0.93333333333333, -0.075, 0
27402, 0.94166666666667, -0.083333333333333, 0
27403, 0.95, -0.075, 0
27404, 0.95833333333333, -0.083333333333333, 0
27405, 0.96666666666667, -0.075, 0
27406, 0.975, -0.083333333333333, 0
27407, 0.98333333333333, -0.075, 0
27408, 0.99166666666667, -0.083333333333333, 0
27409, 0.0083333333333333, -0.1, 0
27410, 0.016666666666667, -0.091666666666667, 0
27411, 0.025, -0.1, 0
27412, 0.033333333333333, -0.091666666666667, 0
27413, 0.041666666666667, -0.1, 0
