17397, 1.6333333333333, 0.5, 0
17398, 1.65, 0.5, 0
17399, 1.6666666666667, 0.5, 0
17400, 1.6833333333333, 0.5, 0
17401, 1.7, 0.5, 0
17402, 1.7166666666667, 0.5, 0
17403, 1.7333333333333, 0.5, 0
17404, 1.75, 0.5, 0
17405, 1.7666666666667, 0.5, 0
17406, 1.7833333333333, 0.5, 0
17407, 1.8, 0.5, 0
17408, 1.8166666666667, 0.5, 0
17409, 1.8333333333333, 0.5, 0
17410, 1.85, 0.5, 0
17411, 1.8666666666667, 0.5, 0
17412, 1.8833333333333, 0.5, 0
17413, 1.9, 0.5, 0
17414, 1.9166666666667, 0.5, 0
17415, 1.9333333333333, 0.5, 0
17416, 1.95, 0.5, 0
17417, 1.9666666666667, 0.5, 0
17418, 1.9833333333333, 0.5, 0
17419, 2, 0.5, 0
17420, 2.0166666666667, 0.5, 0
17421, 2.0333333333333, 0.5, 0
17422, 2.05, 0.5, 0
17423, 2.0666666666667, 0.5, 0
17424, 2.0833333333333, 0.5, 0
17425, 2.1, 0.5, 0
17426, 2.1166666666667, 0.5, 0
17427, 2.1333333333333, 0.5, 0
17428, 2.15, 0.5, 0
17429, 2.1666666666667, 0.5, 0
17430, 2.1833333333333, 0.5, 0
17431, 1.2166666666667, 0.48, 0
17432, 1.2333333333333, 0.48, 0
17433, 1.25, 0.48, 0
17434, 1.2666666666667, 0.48, 0
17435, 1.2833333333333, 0.48, 0
17436, 1.3, 0.48, 0
17437, 1.3166666666667, 0.48, 0
17438, 1.3333333333333, 0.48, 0
17439, 1.35, 0.48, 0
17440, 1.3666666666667, 0.48, 0
17441, 1.3833333333333, 0.48, 0
17442, 1.4, 0.48, 0
17443, 1.4166666666667, 0.48, 0
17444, 1.4333333333333, 0.48, 0
17445, 1.45, 0.48, 0
17446, 1.4666666666667, 0.48, 0
17447, 1.4833333333333, 0.48, 0
17448, 1.5, 0.48, 0
17449, 1.5166666666667, 0.48, 0
17450, 1.5333333333333, 0.48, 0
17451, 1.55, 0.48, 0
17452, 1.5666666666667, 0.48, 0
17453, 1.5833333333333, 0.48, 0
17454, 1.6, 0.48, 0
17455, 1.6166666666667, 0.48, 0
17456, 1.6333333333333, 0.48, 0
17457, 1.65, 0.48, 0
17458, 1.6666666666667, 0.48, 0
17459, 1.6833333333333, 0.48, 0
17460, 1.7, 0.48, 0
17461, 1.7166666666667, 0.48, 0
17462, 1.7333333333333, 0.48, 0
17463, 1.75, 0.48, 0
17464, 1.7666666666667, 0.48, 0
17465, 1.7833333333333, 0.48, 0
17466, 1.8, 0.48, 0
17467, 1.8166666666667, 0.48, 0
17468, 1.8333333333333, 0.48, 0
17469, 1.85, 0.48, 0
17470, 1.8666666666667, 0.48, 0
17471, 1.8833333333333, 0.48, 0
17472, 1.9, 0.48, 0
17473, 1.9166666666667, 0.48, 0
17474, 1.9333333333333, 0.48, 0
17475, 1.95, 0.48, 0
17476, 1.9666666666667, 0.48, 0
17477, 1.9833333333333, 0.48, 0
17478, 2, 0.48, 0
17479, 2.0166666666667, 0.48, 0
17480, 2.0333333333333, 0.48, 0
17481, 2.05, 0.48, 0
17482, 2.0666666666667, 0.48, 0
17483, 2.0833333333333, 0.48, 0
17484, 2.1, 0.48, 0
17485, 2.1166666666667, 0.48, 0
17486, 2.1333333333333, 0.48, 0
17487, 2.15, 0.48, 0
17488, 2.1666666666667, 0.48, 0
17489, 2.1833333333333, 0.48, 0
17490, 1.2166666666667, 0.46, 0
17491, 1.2333333333333, 0.46, 0
17492, 1.25, 0.46, 0
17493, 1.2666666666667, 0.46, 0
17494, 1.2833333333333, 0.46, 0
17495, 1.3, 0.46, 0
17496, 1.3166666666667, 0.46, 0
17497, 1.3333333333333, 0.46, 0
17498, 1.35, 0.46, 0
17499, 1.3666666666667, 0.46, 0
17500, 1.3833333333333, 0.46, 0
17501, 1.4, 0.46, 0
17502, 1.4166666666667, 0.46, 0
17503, 1.4333333333333, 0.46, 0
17504, 1.45, 0.46, 0
17505, 1.4666666666667, 0.46, 0
17506, 1.4833333333333, 0.46, 0
17507, 1.5, 0.46, 0
17508, 1.5166666666667, 0.46, 0
17509, 1.5333333333333, 0.46, 0
17510, 1.55, 0.46, 0
17511, 1.5666666666667, 0.46, 0
17512, 1.5833333333333, 0.46, 0
17513, 1.6, 0.46, 0
17514, 1.6166666666667, 0.46, 0
17515, 1.6333333333333, 0.46, 0
17516, 1.65, 0.46, 0
17517, 1.6666666666667, 0.46, 0
17518, 1.6833333333333, 0.46, 0
17519, 1.7, 0.46, 0
17520, 1.7166666666667, 0.46, 0
17521, 1.7333333333333, 0.46, 0
17522, 1.75, 0.46, 0
17523, 1.7666666666667, 0.46, 0
17524, 1.7833333333333, 0.46, 0
17525, 1.8, 0.46, 0
17526, 1.8166666666667, 0.46, 0
17527, 1.8333333333333, 0.46, 0
17528, 1.85, 0.46, 0
17529, 1.8666666666667, 0.46, 0
17530, 1.8833333333333, 0.46, 0
17531, 1.9, 0.46, 0
17532, 1.9166666666667, 0.46, 0
17533, 1.9333333333333, 0.46, 0
17534, 1.95, 0.46, 0
17535, 1.9666666666667, 0.46, 0
17536, 1.9833333333333, 0.46, 0
17537, 2, 0.46, 0
17538, 2.0166666666667, 0.46, 0
17539, 2.0333333333333, 0.46, 0
17540, 2.05, 0.46, 0
17541, 2.0666666666667, 0.46, 0
17542, 2.0833333333333, 0.46, 0
17543, 2.1, 0.46, 0
17544, 2.1166666666667, 0.46, 0
17545, 2.1333333333333, 0.46, 0
17546, 2.15, 0.46, 0
17547, 2.1666666666667, 0.46, 0
17548, 2.1833333333333, 0.46, 0
17549, 1.2166666666667, 0.44, 0
17550, 1.2333333333333, 0.44, 0
17551, 1.25, 0.44, 0
17552, 1.2666666666667, 0.44, 0
17553, 1.2833333333333, 0.44, 0
17554, 1.3, 0.44, 0
17555, 1.3166666666667, 0.44, 0
17556, 1.3333333333333, 0.44, 0
17557, 1.35, 0.44, 0
17558, 1.3666666666667, 0.44, 0
17559, 1.3833333333333, 0.44, 0
17560, 1.4, 0.44, 0
17561, 1.4166666666667, 0.44, 0
17562, 1.4333333333333, 0.44, 0
17563, 1.45, 0.44, 0
17564, 1.4666666666667, 0.44, 0
17565, 1.4833333333333, 0.44, 0
17566, 1.5, 0.44, 0
17567, 1.5166666666667, 0.44, 0
17568, 1.5333333333333, 0.44, 0
17569, 1.55, 0.44, 0
17570, 1.5666666666667, 0.44, 0
17571, 1.5833333333333, 0.44, 0
17572, 1.6, 0.44, 0
17573, 1.6166666666667, 0.44, 0
17574, 1.6333333333333, 0.44, 0
17575, 1.65, 0.44, 0
17576, 1.6666666666667, 0.44, 0
17577, 1.6833333333333, 0.44, 0
17578, 1.7, 0.44, 0
17579, 1.7166666666667, 0.44, 0
17580, 1.7333333333333, 0.44, 0
17581, 1.75, 0.44, 0
17582, 1.7666666666667, 0.44, 0
17583, 1.7833333333333, 0.44, 0
17584, 1.8, 0.44, 0
17585, 1.8166666666667, 0.44, 0
17586, 1.8333333333333, 0.44, 0
17587, 1.85, 0.44, 0
17588, 1.8666666666667, 0.44, 0
17589, 1.8833333333333, 0.44, 0
17590, 1.9, 0.44, 0
17591, 1.9166666666667, 0.44, 0
17592, 1.9333333333333, 0.44, 0
17593, 1.95, 0.44, 0
17594, 1.9666666666667, 0.44, 0
17595, 1.9833333333333, 0.44, 0
17596, 2, 0.44, 0
17597, 2.0166666666667, 0.44, 0
17598, 2.0333333333333, 0.44, 0
17599, 2.05, 0.44, 0
17600, 2.0666666666667, 0.44, 0
17601, 2.0833333333333, 0.44, 0
17602, 2.1, 0.44, 0
17603, 2.1166666666667, 0.44, 0
17604, 2.1333333333333, 0.44, 0
17605, 2.15, 0.44, 0
17606, 2.1666666666667, 0.44, 0
17607, 2.1833333333333, 0.44, 0
17608, 1.2166666666667, 0.42, 0
17609, 1.2333333333333, 0.42, 0
17610, 1.25, 0.42, 0
17611, 1.2666666666667, 0.42, 0
17612, 1.2833333333333, 0.42, 0
17613, 1.3, 0.42, 0
17614, 1.3166666666667, 0.42, 0
17615, 1.3333333333333, 0.42, 0
17616, 1.35, 0.42, 0
17617, 1.3666666666667, 0.42, 0
17618, 1.3833333333333, 0.42, 0
17619, 1.4, 0.42, 0
17620, 1.4166666666667, 0.42, 0
17621, 1.4333333333333, 0.42, 0
17622, 1.45, 0.42, 0
17623, 1.4666666666667, 0.42, 0
17624, 1.4833333333333, 0.42, 0
17625, 1.5, 0.42, 0
17626, 1.5166666666667, 0.42, 0
17627, 1.5333333333333, 0.42, 0
17628, 1.55, 0.42, 0
17629, 1.5666666666667, 0.42, 0
17630, 1.5833333333333, 0.42, 0
17631, 1.6, 0.42, 0
17632, 1.6166666666667, 0.42, 0
17633, 1.6333333333333, 0.42, 0
17634, 1.65, 0.42, 0
17635, 1.6666666666667, 0.42, 0
17636, 1.6833333333333, 0.42, 0
17637, 1.7, 0.42, 0
17638, 1.7166666666667, 0.42, 0
17639, 1.7333333333333, 0.42, 0
17640, 1.75, 0.42, 0
17641, 1.7666666666667, 0.42, 0
17642, 1.7833333333333, 0.42, 0
17643, 1.8, 0.42, 0
17644, 1.8166666666667, 0.42, 0
17645, 1.8333333333333, 0.42, 0
17646, 1.85, 0.42, 0
17647, 1.8666666666667, 0.42, 0
17648, 1.8833333333333, 0.42, 0
17649, 1.9, 0.42, 0
17650, 1.9166666666667, 0.42, 0
17651, 1.9333333333333, 0.42, 0
17652, 1.95, 0.42, 0
17653, 1.9666666666667, 0.42, 0
17654, 1.9833333333333, 0.42, 0
17655, 2, 0.42, 0
17656, 2.0166666666667, 0.42, 0
17657, 2.0333333333333, 0.42, 0
17658, 2.05, 0.42, 0
17659, 2.0666666666667, 0.42, 0
17660, 2.0833333333333, 0.42, 0
17661, 2.1, 0.42, 0
17662, 2.1166666666667, 0.42, 0
17663, 2.1333333333333, 0.42, 0
17664, 2.15, 0.42, 0
17665, 2.1666666666667, 0.42, 0
17666, 2.1833333333333, 0.42, 0
17667, 1.2166666666667, 0.4, 0
17668, 1.2333333333333, 0.4, 0
17669, 1.25, 0.4, 0
17670, 1.2666666666667, 0.4, 0
17671, 1.2833333333333, 0.4, 0
17672, 1.3, 0.4, 0
17673, 1.3166666666667, 0.4, 0
17674, 1.3333333333333, 0.4, 0
17675, 1.35, 0.4, 0
17676, 1.3666666666667, 0.4, 0
17677, 1.3833333333333, 0.4, 0
17678, 1.4, 0.4, 0
17679, 1.4166666666667, 0.4, 0
17680, 1.4333333333333, 0.4, 0
17681, 1.45, 0.4, 0
17682, 1.4666666666667, 0.4, 0
17683, 1.4833333333333, 0.4, 0
17684, 1.5, 0.4, 0
17685, 1.5166666666667, 0.4, 0
17686, 1.5333333333333, 0.4, 0
17687, 1.55, 0.4, 0
17688, 1.5666666666667, 0.4, 0
17689, 1.5833333333333, 0.4, 0
17690, 1.6, 0.4, 0
17691, 1.6166666666667, 0.4, 0
17692, 1.6333333333333, 0.4, 0
17693, 1.65, 0.4, 0
17694, 1.6666666666667, 0.4, 0
17695, 1.6833333333333, 0.4, 0
17696, 1.7, 0.4, 0
17697, 1.7166666666667, 0.4, 0
17698, 1.7333333333333, 0.4, 0
17699, 1.75, 0.4, 0
17700, 1.7666666666667, 0.4, 0
17701, 1.7833333333333, 0.4, 0
17702, 1.8, 0.4, 0
17703, 1.8166666666667, 0.4, 0
17704, 1.8333333333333, 0.4, 0
17705, 1.85, 0.4, 0
17706, 1.8666666666667, 0.4, 0
17707, 1.8833333333333, 0.4, 0
17708, 1.9, 0.4, 0
17709, 1.9166666666667, 0.4, 0
17710, 1.9333333333333, 0.4, 0
17711, 1.95, 0.4, 0
17712, 1.9666666666667, 0.4, 0
17713, 1.9833333333333, 0.4, 0
17714, 2, 0.4, 0
17715, 2.0166666666667, 0.4, 0
17716, 2.0333333333333, 0.4, 0
17717, 2.05, 0.4, 0
17718, 2.0666666666667, 0.4, 0
17719, 2.0833333333333, 0.4, 0
17720, 2.1, 0.4, 0
17721, 2.1166666666667, 0.4, 0
17722, 2.1333333333333, 0.4, 0
17723, 2.15, 0.4, 0
17724, 2.1666666666667, 0.4, 0
17725, 2.1833333333333, 0.4, 0
17726, 1.2166666666667, 0.38, 0
17727, 1.2333333333333, 0.38, 0
17728, 1.25, 0.38, 0
17729, 1.2666666666667, 0.38, 0
17730, 1.2833333333333, 0.38, 0
17731, 1.3, 0.38, 0
17732, 1.3166666666667, 0.38, 0
17733, 1.3333333333333, 0.38, 0
17734, 1.35, 0.38, 0
17735, 1.3666666666667, 0.38, 0
17736, 1.3833333333333, 0.38, 0
17737, 1.4, 0.38, 0
17738, 1.4166666666667, 0.38, 0
17739, 1.4333333333333, 0.38, 0
17740, 1.45, 0.38, 0
17741, 1.4666666666667, 0.38, 0
17742, 1.4833333333333, 0.38, 0
17743, 1.5, 0.38, 0
17744, 1.5166666666667, 0.38, 0
17745, 1.5333333333333, 0.38, 0
17746, 1.55, 0.38, 0
17747, 1.5666666666667, 0.38, 0
17748, 1.5833333333333, 0.38, 0
17749, 1.6, 0.38, 0
17750, 1.6166666666667, 0.38, 0
17751, 1.6333333333333, 0.38, 0
17752, 1.65, 0.38, 0
17753, 1.6666666666667, 0.38, 0
17754, 1.6833333333333, 0.38, 0
17755, 1.7, 0.38, 0
17756, 1.7166666666667, 0.38, 0
17757, 1.7333333333333, 0.38, 0
17758, 1.75, 0.38, 0
17759, 1.7666666666667, 0.38, 0
17760, 1.7833333333333, 0.38, 0
17761, 1.8, 0.38, 0
17762, 1.8166666666667, 0.38, 0
17763, 1.8333333333333, 0.38, 0
17764, 1.85, 0.38, 0
17765, 1.8666666666667, 0.38, 0
17766, 1.8833333333333, 0.38, 0
17767, 1.9, 0.38, 0
17768, 1.9166666666667, 0.38, 0
17769, 1.9333333333333, 0.38, 0
17770, 1.95, 0.38, 0
17771, 1.9666666666667, 0.38, 0
17772, 1.9833333333333, 0.38, 0
17773, 2, 0.38, 0
17774, 2.0166666666667, 0.38, 0
17775, 2.0333333333333, 0.38, 0
17776, 2.05, 0.38, 0
17777, 2.0666666666667, 0.38, 0
17778, 2.0833333333333, 0.38, 0
17779, 2.1, 0.38, 0
17780, 2.1166666666667, 0.38, 0
17781, 2.1333333333333, 0.38, 0
17782, 2.15, 0.38, 0
17783, 2.1666666666667, 0.38, 0
17784, 2.1833333333333, 0.38, 0
17785, 1.2166666666667, 0.36, 0
17786, 1.2333333333333, 0.36, 0
17787, 1.25, 0.36, 0
17788, 1.2666666666667, 0.36, 0
17789, 1.2833333333333, 0.36, 0
17790, 1.3, 0.36, 0
17791, 1.3166666666667, 0.36, 0
17792, 1.3333333333333, 0.36, 0
17793, 1.35, 0.36, 0
17794, 1.3666666666667, 0.36, 0
17795, 1.3833333333333, 0.36, 0
17796, 1.4, 0.36, 0
17797, 1.4166666666667, 0.36, 0
17798, 1.4333333333333, 0.36, 0
17799, 1.45, 0.36, 0
17800, 1.4666666666667, 0.36, 0
17801, 1.4833333333333, 0.36, 0
17802, 1.5, 0.36, 0
17803, 1.5166666666667, 0.36, 0
17804, 1.5333333333333, 0.36, 0
17805, 1.55, 0.36, 0
17806, 1.5666666666667, 0.36, 0
17807, 1.5833333333333, 0.36, 0
17808, 1.6, 0.36, 0
17809, 1.6166666666667, 0.36, 0
17810, 1.6333333333333, 0.36, 0
17811, 1.65, 0.36, 0
17812, 1.6666666666667, 0.36, 0
17813, 1.6833333333333, 0.36, 0
17814, 1.7, 0.36, 0
17815, 1.7166666666667, 0.36, 0
17816, 1.7333333333333, 0.36, 0
17817, 1.75, 0.36, 0
17818, 1.7666666666667, 0.36, 0
17819, 1.7833333333333, 0.36, 0
17820, 1.8, 0.36, 0
17821, 1.8166666666667, 0.36, 0
17822, 1.8333333333333, 0.36, 0
17823, 1.85, 0.36, 0
17824, 1.8666666666667, 0.36, 0
17825, 1.8833333333333, 0.36, 0
17826, 1.9, 0.36, 0
17827, 1.9166666666667, 0.36, 0
17828, 1.9333333333333, 0.36, 0
17829, 1.95, 0.36, 0
17830, 1.9666666666667, 0.36, 0
17831, 1.9833333333333, 0.36, 0
17832, 2, 0.36, 0
17833, 2.0166666666667, 0.36, 0
17834, 2.0333333333333, 0.36, 0
17835, 2.05, 0.36, 0
17836, 2.0666666666667, 0.36, 0
17837, 2.0833333333333, 0.36, 0
17838, 2.1, 0.36, 0
17839, 2.1166666666667, 0.36, 0
17840, 2.1333333333333, 0.36, 0
17841, 2.15, 0.36, 0
17842, 2.1666666666667, 0.36, 0
17843, 2.1833333333333, 0.36, 0
17844, 1.2166666666667, 0.34, 0
17845, 1.2333333333333, 0.34, 0
17846, 1.25, 0.34, 0
17847, 1.2666666666667, 0.34, 0
17848, 1.2833333333333, 0.34, 0
17849, 1.3, 0.34, 0
17850, 1.3166666666667, 0.34, 0
17851, 1.3333333333333, 0.34, 0
17852, 1.35, 0.34, 0
17853, 1.3666666666667, 0.34, 0
17854, 1.3833333333333, 0.34, 0
17855, 1.4, 0.34, 0
17856, 1.4166666666667, 0.34, 0
17857, 1.4333333333333, 0.34, 0
17858, 1.45, 0.34, 0
17859, 1.4666666666667, 0.34, 0
17860, 1.4833333333333, 0.34, 0
17861, 1.5, 0.34, 0
17862, 1.5166666666667, 0.34, 0
17863, 1.5333333333333, 0.34, 0
17864, 1.55, 0.34, 0
17865, 1.5666666666667, 0.34, 0
17866, 1.5833333333333, 0.34, 0
17867, 1.6, 0.34, 0
17868, 1.6166666666667, 0.34, 0
17869, 1.6333333333333, 0.34, 0
17870, 1.65, 0.34, 0
17871, 1.6666666666667, 0.34, 0
17872, 1.6833333333333, 0.34, 0
17873, 1.7, 0.34, 0
17874, 1.7166666666667, 0.34, 0
17875, 1.7333333333333, 0.34, 0
17876, 1.75, 0.34, 0
17877, 1.7666666666667, 0.34, 0
17878, 1.7833333333333, 0.34, 0
17879, 1.8, 0.34, 0
17880, 1.8166666666667, 0.34, 0
17881, 1.8333333333333, 0.34, 0
17882, 1.85, 0.34, 0
17883, 1.8666666666667, 0.34, 0
17884, 1.8833333333333, 0.34, 0
17885, 1.9, 0.34, 0
17886, 1.9166666666667, 0.34, 0
17887, 1.9333333333333, 0.34, 0
17888, 1.95, 0.34, 0
17889, 1.9666666666667, 0.34, 0
17890, 1.9833333333333, 0.34, 0
17891, 2, 0.34, 0
17892, 2.0166666666667, 0.34, 0
17893, 2.0333333333333, 0.34, 0
17894, 2.05, 0.34, 0
17895, 2.0666666666667, 0.34, 0
17896, 2.0833333333333, 0.34, 0
17897, 2.1, 0.34, 0
17898, 2.1166666666667, 0.34, 0
17899, 2.1333333333333, 0.34, 0
17900, 2.15, 0.34, 0
17901, 2.1666666666667, 0.34, 0
17902, 2.1833333333333, 0.34, 0
17903, 1.2166666666667, 0.32, 0
17904, 1.2333333333333, 0.32, 0
17905, 1.25, 0.32, 0
17906, 1.2666666666667, 0.32, 0
17907, 1.2833333333333, 0.32, 0
17908, 1.3, 0.32, 0
17909, 1.3166666666667, 0.32, 0
17910, 1.3333333333333, 0.32, 0
17911, 1.35, 0.32, 0
17912, 1.3666666666667, 0.32, 0
17913, 1.3833333333333, 0.32, 0
17914, 1.4, 0.32, 0
17915, 1.4166666666667, 0.32, 0
17916, 1.4333333333333, 0.32, 0
17917, 1.45, 0.32, 0
17918, 1.4666666666667, 0.32, 0
17919, 1.4833333333333, 0.32, 0
17920, 1.5, 0.32, 0
17921, 1.5166666666667, 0.32, 0
17922, 1.5333333333333, 0.32, 0
17923, 1.55, 0.32, 0
17924, 1.5666666666667, 0.32, 0
17925, 1.5833333333333, 0.32, 0
17926, 1.6, 0.32, 0
17927, 1.6166666666667, 0.32, 0
17928, 1.6333333333333, 0.32, 0
17929, 1.65, 0.32, 0
17930, 1.6666666666667, 0.32, 0
17931, 1.6833333333333, 0.32, 0
17932, 1.7, 0.32, 0
17933, 1.7166666666667, 0.32, 0
17934, 1.7333333333333, 0.32, 0
17935, 1.75, 0.32, 0
17936, 1.7666666666667, 0.32, 0
17937, 1.7833333333333, 0.32, 0
17938, 1.8, 0.32, 0
17939, 1.8166666666667, 0.32, 0
17940, 1.8333333333333, 0.32, 0
17941, 1.85, 0.32, 0
17942, 1.8666666666667, 0.32, 0
17943, 1.8833333333333, 0.32, 0
17944, 1.9, 0.32, 0
17945, 1.9166666666667, 0.32, 0
17946, 1.9333333333333, 0.32, 0
17947, 1.95, 0.32, 0
17948, 1.9666666666667, 0.32, 0
17949, 1.9833333333333, 0.32, 0
17950, 2, 0.32, 0
17951, 2.0166666666667, 0.32, 0
17952, 2.0333333333333, 0.32, 0
17953, 2.05, 0.32, 0
17954, 2.0666666666667, 0.32, 0
17955, 2.0833333333333, 0.32, 0
17956, 2.1, 0.32, 0
17957, 2.1166666666667, 0.32, 0
17958, 2.1333333333333, 0.32, 0
17959, 2.15, 0.32, 0
17960, 2.1666666666667, 0.32, 0
17961, 2.1833333333333, 0.32, 0
17962, 1.2166666666667, 0.3, 0
17963, 1.2333333333333, 0.3, 0
17964, 1.25, 0.3, 0
17965, 1.2666666666667, 0.3, 0
17966, 1.2833333333333, 0.3, 0
17967, 1.3, 0.3, 0
17968, 1.3166666666667, 0.3, 0
17969, 1.3333333333333, 0.3, 0
17970, 1.35, 0.3, 0
17971, 1.3666666666667, 0.3, 0
17972, 1.3833333333333, 0.3, 0
17973, 1.4, 0.3, 0
17974, 1.4166666666667, 0.3, 0
17975, 1.4333333333333, 0.3, 0
17976, 1.45, 0.3, 0
17977, 1.4666666666667, 0.3, 0
17978, 1.4833333333333, 0.3, 0
17979, 1.5, 0.3, 0
17980, 1.5166666666667, 0.3, 0
17981, 1.5333333333333, 0.3, 0
17982, 1.55, 0.3, 0
17983, 1.5666666666667, 0.3, 0
17984, 1.5833333333333, 0.3, 0
17985, 1.6, 0.3, 0
17986, 1.6166666666667, 0.3, 0
17987, 1.6333333333333, 0.3, 0
17988, 1.65, 0.3, 0
17989, 1.6666666666667, 0.3, 0
17990, 1.6833333333333, 0.3, 0
17991, 1.7, 0.3, 0
17992, 1.7166666666667, 0.3, 0
17993, 1.7333333333333, 0.3, 0
17994, 1.75, 0.3, 0
17995, 1.7666666666667, 0.3, 0
17996, 1.7833333333333, 0.3, 0
17997, 1.8, 0.3, 0
17998, 1.8166666666667, 0.3, 0
17999, 1.8333333333333, 0.3, 0
18000, 1.85, 0.3, 0
18001, 1.8666666666667, 0.3, 0
18002, 1.8833333333333, 0.3, 0
18003, 1.9, 0.3, 0
18004, 1.9166666666667, 0.3, 0
18005, 1.9333333333333, 0.3, 0
18006, 1.95, 0.3, 0
18007, 1.9666666666667, 0.3, 0
18008, 1.9833333333333, 0.3, 0
18009, 2, 0.3, 0
18010, 2.0166666666667, 0.3, 0
18011, 2.0333333333333, 0.3, 0
18012, 2.05, 0.3, 0
18013, 2.0666666666667, 0.3, 0
18014, 2.0833333333333, 0.3, 0
18015, 2.1, 0.3, 0
18016, 2.1166666666667, 0.3, 0
18017, 2.1333333333333, 0.3, 0
18018, 2.15, 0.3, 0
18019, 2.1666666666667, 0.3, 0
18020, 2.1833333333333, 0.3, 0
18021, 1.2166666666667, 0.28, 0
18022, 1.2333333333333, 0.28, 0
18023, 1.25, 0.28, 0
18024, 1.2666666666667, 0.28, 0
18025, 1.2833333333333, 0.28, 0
18026, 1.3, 0.28, 0
18027, 1.3166666666667, 0.28, 0
18028, 1.3333333333333, 0.28, 0
18029, 1.35, 0.28, 0
18030, 1.3666666666667, 0.28, 0
18031, 1.3833333333333, 0.28, 0
18032, 1.4, 0.28, 0
18033, 1.4166666666667, 0.28, 0
18034, 1.4333333333333, 0.28, 0
18035, 1.45, 0.28, 0
18036, 1.4666666666667, 0.28, 0
18037, 1.4833333333333, 0.28, 0
18038, 1.5, 0.28, 0
18039, 1.5166666666667, 0.28, 0
18040, 1.5333333333333, 0.28, 0
18041, 1.55, 0.28, 0
18042, 1.5666666666667, 0.28, 0
18043, 1.5833333333333, 0.28, 0
18044, 1.6, 0.28, 0
18045, 1.6166666666667, 0.28, 0
18046, 1.6333333333333, 0.28, 0
18047, 1.65, 0.28, 0
18048, 1.6666666666667, 0.28, 0
18049, 1.6833333333333, 0.28, 0
18050, 1.7, 0.28, 0
18051, 1.7166666666667, 0.28, 0
18052, 1.7333333333333, 0.28, 0
18053, 1.75, 0.28, 0
18054, 1.7666666666667, 0.28, 0
18055, 1.7833333333333, 0.28, 0
18056, 1.8, 0.28, 0
18057, 1.8166666666667, 0.28, 0
18058, 1.8333333333333, 0.28, 0
18059, 1.85, 0.28, 0
18060, 1.8666666666667, 0.28, 0
18061, 1.8833333333333, 0.28, 0
18062, 1.9, 0.28, 0
18063, 1.9166666666667, 0.28, 0
18064, 1.9333333333333, 0.28, 0
18065, 1.95, 0.28, 0
18066, 1.9666666666667, 0.28, 0
18067, 1.9833333333333, 0.28, 0
18068, 2, 0.28, 0
18069, 2.0166666666667, 0.28, 0
18070, 2.0333333333333, 0.28, 0
18071, 2.05, 0.28, 0
18072, 2.0666666666667, 0.28, 0
18073, 2.0833333333333, 0.28, 0
18074, 2.1, 0.28, 0
18075, 2.1166666666667, 0.28, 0
18076, 2.1333333333333, 0.28, 0
18077, 2.15, 0.28, 0
18078, 2.1666666666667, 0.28, 0
18079, 2.1833333333333, 0.28, 0
18080, 1.2166666666667, 0.26, 0
18081, 1.2333333333333, 0.26, 0
18082, 1.25, 0.26, 0
18083, 1.2666666666667, 0.26, 0
18084, 1.2833333333333, 0.26, 0
18085, 1.3, 0.26, 0
18086, 1.3166666666667, 0.26, 0
18087, 1.3333333333333, 0.26, 0
18088, 1.35, 0.26, 0
18089, 1.3666666666667, 0.26, 0
18090, 1.3833333333333, 0.26, 0
18091, 1.4, 0.26, 0
18092, 1.4166666666667, 0.26, 0
18093, 1.4333333333333, 0.26, 0
18094, 1.45, 0.26, 0
18095, 1.4666666666667, 0.26, 0
18096, 1.4833333333333, 0.26, 0
18097, 1.5, 0.26, 0
18098, 1.5166666666667, 0.26, 0
18099, 1.5333333333333, 0.26, 0
18100, 1.55, 0.26, 0
18101, 1.5666666666667, 0.26, 0
18102, 1.5833333333333, 0.26, 0
18103, 1.6, 0.26, 0
18104, 1.6166666666667, 0.26, 0
18105, 1.6333333333333, 0.26, 0
18106, 1.65, 0.26, 0
18107, 1.6666666666667, 0.26, 0
18108, 1.6833333333333, 0.26, 0
18109, 1.7, 0.26, 0
18110, 1.7166666666667, 0.26, 0
18111, 1.7333333333333, 0.26, 0
18112, 1.75, 0.26, 0
18113, 1.7666666666667, 0.26, 0
18114, 1.7833333333333, 0.26, 0
18115, 1.8, 0.26, 0
18116, 1.8166666666667, 0.26, 0
18117, 1.8333333333333, 0.26, 0
18118, 1.85, 0.26, 0
18119, 1.8666666666667, 0.26, 0
18120, 1.8833333333333, 0.26, 0
18121, 1.9, 0.26, 0
18122, 1.9166666666667, 0.26, 0
18123, 1.9333333333333, 0.26, 0
18124, 1.95, 0.26, 0
18125, 1.9666666666667, 0.26, 0
18126, 1.9833333333333, 0.26, 0
18127, 2, 0.26, 0
18128, 2.0166666666667, 0.26, 0
18129, 2.0333333333333, 0.26, 0
18130, 2.05, 0.26, 0
18131, 2.0666666666667, 0.26, 0
18132, 2.0833333333333, 0.26, 0
18133, 2.1, 0.26, 0
18134, 2.1166666666667, 0.26, 0
18135, 2.1333333333333, 0.26, 0
18136, 2.15, 0.26, 0
18137, 2.1666666666667, 0.26, 0
18138, 2.1833333333333, 0.26, 0
18139, 1.2166666666667, 0.24, 0
18140, 1.2333333333333, 0.24, 0
18141, 1.25, 0.24, 0
18142, 1.2666666666667, 0.24, 0
18143, 1.2833333333333, 0.24, 0
18144, 1.3, 0.24, 0
18145, 1.3166666666667, 0.24, 0
18146, 1.3333333333333, 0.24, 0
18147, 1.35, 0.24, 0
18148, 1.3666666666667, 0.24, 0
18149, 1.3833333333333, 0.24, 0
18150, 1.4, 0.24, 0
18151, 1.4166666666667, 0.24, 0
18152, 1.4333333333333, 0.24, 0
18153, 1.45, 0.24, 0
18154, 1.4666666666667, 0.24, 0
18155, 1.4833333333333, 0.24, 0
18156, 1.5, 0.24, 0
18157, 1.5166666666667, 0.24, 0
18158, 1.5333333333333, 0.24, 0
18159, 1.55, 0.24, 0
18160, 1.5666666666667, 0.24, 0
18161, 1.5833333333333, 0.24, 0
18162, 1.6, 0.24, 0
18163, 1.6166666666667, 0.24, 0
18164, 1.6333333333333, 0.24, 0
18165, 1.65, 0.24, 0
18166, 1.6666666666667, 0.24, 0
18167, 1.6833333333333, 0.24, 0
18168, 1.7, 0.24, 0
18169, 1.7166666666667, 0.24, 0
18170, 1.7333333333333, 0.24, 0
18171, 1.75, 0.24, 0
18172, 1.7666666666667, 0.24, 0
18173, 1.7833333333333, 0.24, 0
18174, 1.8, 0.24, 0
18175, 1.8166666666667, 0.24, 0
18176, 1.8333333333333, 0.24, 0
18177, 1.85, 0.24, 0
18178, 1.8666666666667, 0.24, 0
18179, 1.8833333333333, 0.24, 0
18180, 1.9, 0.24, 0
18181, 1.9166666666667, 0.24, 0
18182, 1.9333333333333, 0.24, 0
18183, 1.95, 0.24, 0
18184, 1.9666666666667, 0.24, 0
18185, 1.9833333333333, 0.24, 0
18186, 2, 0.24, 0
18187, 2.0166666666667, 0.24, 0
18188, 2.0333333333333, 0.24, 0
18189, 2.05, 0.24, 0
18190, 2.0666666666667, 0.24, 0
18191, 2.0833333333333, 0.24, 0
18192, 2.1, 0.24, 0
18193, 2.1166666666667, 0.24, 0
18194, 2.1333333333333, 0.24, 0
18195, 2.15, 0.24, 0
18196, 2.1666666666667, 0.24, 0
18197, 2.1833333333333, 0.24, 0
18198, 1.2166666666667, 0.22, 0
18199, 1.2333333333333, 0.22, 0
18200, 1.25, 0.22, 0
18201, 1.2666666666667, 0.22, 0
18202, 1.2833333333333, 0.22, 0
18203, 1.3, 0.22, 0
18204, 1.3166666666667, 0.22, 0
18205, 1.3333333333333, 0.22, 0
18206, 1.35, 0.22, 0
18207, 1.3666666666667, 0.22, 0
18208, 1.3833333333333, 0.22, 0
18209, 1.4, 0.22, 0
18210, 1.4166666666667, 0.22, 0
18211, 1.4333333333333, 0.22, 0
18212, 1.45, 0.22, 0
18213, 1.4666666666667, 0.22, 0
18214, 1.4833333333333, 0.22, 0
18215, 1.5, 0.22, 0
18216, 1.5166666666667, 0.22, 0
18217, 1.5333333333333, 0.22, 0
18218, 1.55, 0.22, 0
18219, 1.5666666666667, 0.22, 0
18220, 1.5833333333333, 0.22, 0
18221, 1.6, 0.22, 0
18222, 1.6166666666667, 0.22, 0
18223, 1.6333333333333, 0.22, 0
18224, 1.65, 0.22, 0
18225, 1.6666666666667, 0.22, 0
18226, 1.6833333333333, 0.22, 0
18227, 1.7, 0.22, 0
18228, 1.7166666666667, 0.22, 0
18229, 1.7333333333333, 0.22, 0
18230, 1.75, 0.22, 0
18231, 1.7666666666667, 0.22, 0
18232, 1.7833333333333, 0.22, 0
18233, 1.8, 0.22, 0
18234, 1.8166666666667, 0.22, 0
18235, 1.8333333333333, 0.22, 0
18236, 1.85, 0.22, 0
18237, 1.8666666666667, 0.22, 0
18238, 1.8833333333333, 0.22, 0
18239, 1.9, 0.22, 0
18240, 1.9166666666667, 0.22, 0
18241, 1.9333333333333, 0.22, 0
18242, 1.95, 0.22, 0
18243, 1.9666666666667, 0.22, 0
18244, 1.9833333333333, 0.22, 0
18245, 2, 0.22, 0
18246, 2.0166666666667, 0.22, 0
18247, 2.0333333333333, 0.22, 0
18248, 2.05, 0.22, 0
18249, 2.0666666666667, 0.22, 0
18250, 2.0833333333333, 0.22, 0
18251, 2.1, 0.22, 0
18252, 2.1166666666667, 0.22, 0
18253, 2.1333333333333, 0.22, 0
18254, 2.15, 0.22, 0
18255, 2.1666666666667, 0.22, 0
18256, 2.1833333333333, 0.22, 0
18257, 1.2166666666667, 0.2, 0
18258, 1.2333333333333, 0.2, 0
18259, 1.25, 0.2, 0
18260, 1.2666666666667, 0.2, 0
18261, 1.2833333333333, 0.2, 0
18262, 1.3, 0.2, 0
18263, 1.3166666666667, 0.2, 0
18264, 1.3333333333333, 0.2, 0
18265, 1.35, 0.2, 0
18266, 1.3666666666667, 0.2, 0
18267, 1.3833333333333, 0.2, 0
18268, 1.4, 0.2, 0
18269, 1.4166666666667, 0.2, 0
18270, 1.4333333333333, 0.2, 0
18271, 1.45, 0.2, 0
18272, 1.4666666666667, 0.2, 0
18273, 1.4833333333333, 0.2, 0
18274, 1.5, 0.2, 0
18275, 1.5166666666667, 0.2, 0
18276, 1.5333333333333, 0.2, 0
18277, 1.55, 0.2, 0
18278, 1.5666666666667, 0.2, 0
18279, 1.5833333333333, 0.2, 0
18280, 1.6, 0.2, 0
18281, 1.6166666666667, 0.2, 0
18282, 1.6333333333333, 0.2, 0
18283, 1.65, 0.2, 0
18284, 1.6666666666667, 0.2, 0
18285, 1.6833333333333, 0.2, 0
18286, 1.7, 0.2, 0
18287, 1.7166666666667, 0.2, 0
18288, 1.7333333333333, 0.2, 0
18289, 1.75, 0.2, 0
18290, 1.7666666666667, 0.2, 0
18291, 1.7833333333333, 0.2, 0
18292, 1.8, 0.2, 0
18293, 1.8166666666667, 0.2, 0
18294, 1.8333333333333, 0.2, 0
18295, 1.85, 0.2, 0
18296, 1.8666666666667, 0.2, 0
18297, 1.8833333333333, 0.2, 0
18298, 1.9, 0.2, 0
18299, 1.9166666666667, 0.2, 0
18300, 1.9333333333333, 0.2, 0
18301, 1.95, 0.2, 0
18302, 1.9666666666667, 0.2, 0
18303, 1.9833333333333, 0.2, 0
18304, 2, 0.2, 0
18305, 2.0166666666667, 0.2, 0
18306, 2.0333333333333, 0.2, 0
18307, 2.05, 0.2, 0
18308, 2.0666666666667, 0.2, 0
18309, 2.0833333333333, 0.2, 0
18310, 2.1, 0.2, 0
18311, 2.1166666666667, 0.2, 0
18312, 2.1333333333333, 0.2, 0
18313, 2.15, 0.2, 0
18314, 2.1666666666667, 0.2, 0
18315, 2.1833333333333, 0.2, 0
18316, 1.2166666666667, 0.18, 0
18317, 1.2333333333333, 0.18, 0
18318, 1.25, 0.18, 0
18319, 1.2666666666667, 0.18, 0
18320, 1.2833333333333, 0.18, 0
18321, 1.3, 0.18, 0
18322, 1.3166666666667, 0.18, 0
18323, 1.3333333333333, 0.18, 0
18324, 1.35, 0.18, 0
18325, 1.3666666666667, 0.18, 0
18326, 1.3833333333333, 0.18, 0
18327, 1.4, 0.18, 0
18328, 1.4166666666667, 0.18, 0
18329, 1.4333333333333, 0.18, 0
18330, 1.45, 0.18, 0
18331, 1.4666666666667, 0.18, 0
18332, 1.4833333333333, 0.18, 0
18333, 1.5, 0.18, 0
18334, 1.5166666666667, 0.18, 0
18335, 1.5333333333333, 0.18, 0
18336, 1.55, 0.18, 0
18337, 1.5666666666667, 0.18, 0
18338, 1.5833333333333, 0.18, 0
18339, 1.6, 0.18, 0
18340, 1.6166666666667, 0.18, 0
18341, 1.6333333333333, 0.18, 0
18342, 1.65, 0.18, 0
18343, 1.6666666666667, 0.18, 0
18344, 1.6833333333333, 0.18, 0
18345, 1.7, 0.18, 0
18346, 1.7166666666667, 0.18, 0
18347, 1.7333333333333, 0.18, 0
18348, 1.75, 0.18, 0
18349, 1.7666666666667, 0.18, 0
18350, 1.7833333333333, 0.18, 0
18351, 1.8, 0.18, 0
18352, 1.8166666666667, 0.18, 0
18353, 1.8333333333333, 0.18, 0
18354, 1.85, 0.18, 0
18355, 1.8666666666667, 0.18, 0
18356, 1.8833333333333, 0.18, 0
18357, 1.9, 0.18, 0
18358, 1.9166666666667, 0.18, 0
18359, 1.9333333333333, 0.18, 0
18360, 1.95, 0.18, 0
18361, 1.9666666666667, 0.18, 0
18362, 1.9833333333333, 0.18, 0
18363, 2, 0.18, 0
18364, 2.0166666666667, 0.18, 0
18365, 2.0333333333333, 0.18, 0
18366, 2.05, 0.18, 0
18367, 2.0666666666667, 0.18, 0
18368, 2.0833333333333, 0.18, 0
18369, 2.1, 0.18, 0
18370, 2.1166666666667, 0.18, 0
18371, 2.1333333333333, 0.18, 0
18372, 2.15, 0.18, 0
18373, 2.1666666666667, 0.18, 0
18374, 2.1833333333333, 0.18, 0
18375, 1.2166666666667, 0.16, 0
18376, 1.2333333333333, 0.16, 0
18377, 1.25, 0.16, 0
18378, 1.2666666666667, 0.16, 0
18379, 1.2833333333333, 0.16, 0
18380, 1.3, 0.16, 0
18381, 1.3166666666667, 0.16, 0
18382, 1.3333333333333, 0.16, 0
18383, 1.35, 0.16, 0
18384, 1.3666666666667, 0.16, 0
18385, 1.3833333333333, 0.16, 0
18386, 1.4, 0.16, 0
18387, 1.4166666666667, 0.16, 0
18388, 1.4333333333333, 0.16, 0
18389, 1.45, 0.16, 0
18390, 1.4666666666667, 0.16, 0
18391, 1.4833333333333, 0.16, 0
18392, 1.5, 0.16, 0
18393, 1.5166666666667, 0.16, 0
18394, 1.5333333333333, 0.16, 0
18395, 1.55, 0.16, 0
18396, 1.5666666666667, 0.16, 0
18397, 1.5833333333333, 0.16, 0
18398, 1.6, 0.16, 0
18399, 1.6166666666667, 0.16, 0
18400, 1.6333333333333, 0.16, 0
18401, 1.65, 0.16, 0
18402, 1.6666666666667, 0.16, 0
18403, 1.6833333333333, 0.16, 0
18404, 1.7, 0.16, 0
18405, 1.7166666666667, 0.16, 0
18406, 1.7333333333333, 0.16, 0
18407, 1.75, 0.16, 0
18408, 1.7666666666667, 0.16, 0
18409, 1.7833333333333, 0.16, 0
18410, 1.8, 0.16, 0
18411, 1.8166666666667, 0.16, 0
18412, 1.8333333333333, 0.16, 0
18413, 1.85, 0.16, 0
18414, 1.8666666666667, 0.16, 0
18415, 1.8833333333333, 0.16, 0
18416, 1.9, 0.16, 0
18417, 1.9166666666667, 0.16, 0
18418, 1.9333333333333, 0.16, 0
18419, 1.95, 0.16, 0
18420, 1.9666666666667, 0.16, 0
18421, 1.9833333333333, 0.16, 0
18422, 2, 0.16, 0
18423, 2.0166666666667, 0.16, 0
18424, 2.0333333333333, 0.16, 0
18425, 2.05, 0.16, 0
18426, 2.0666666666667, 0.16, 0
18427, 2.0833333333333, 0.16, 0
18428, 2.1, 0.16, 0
18429, 2.1166666666667, 0.16, 0
18430, 2.1333333333333, 0.16, 0
18431, 2.15, 0.16, 0
18432, 2.1666666666667, 0.16, 0
18433, 2.1833333333333, 0.16, 0
18434, 1.2166666666667, 0.14, 0
18435, 1.2333333333333, 0.14, 0
18436, 1.25, 0.14, 0
18437, 1.2666666666667, 0.14, 0
18438, 1.2833333333333, 0.14, 0
18439, 1.3, 0.14, 0
18440, 1.3166666666667, 0.14, 0
18441, 1.3333333333333, 0.14, 0
18442, 1.35, 0.14, 0
18443, 1.3666666666667, 0.14, 0
18444, 1.3833333333333, 0.14, 0
18445, 1.4, 0.14, 0
18446, 1.4166666666667, 0.14, 0
18447, 1.4333333333333, 0.14, 0
18448, 1.45, 0.14, 0
18449, 1.4666666666667, 0.14, 0
18450, 1.4833333333333, 0.14, 0
18451, 1.5, 0.14, 0
18452, 1.5166666666667, 0.14, 0
18453, 1.5333333333333, 0.14, 0
18454, 1.55, 0.14, 0
18455, 1.5666666666667, 0.14, 0
18456, 1.5833333333333, 0.14, 0
18457, 1.6, 0.14, 0
18458, 1.6166666666667, 0.14, 0
18459, 1.6333333333333, 0.14, 0
18460, 1.65, 0.14, 0
18461, 1.6666666666667, 0.14, 0
18462, 1.6833333333333, 0.14, 0
18463, 1.7, 0.14, 0
18464, 1.7166666666667, 0.14, 0
18465, 1.7333333333333, 0.14, 0
18466, 1.75, 0.14, 0
18467, 1.7666666666667, 0.14, 0
18468, 1.7833333333333, 0.14, 0
18469, 1.8, 0.14, 0
18470, 1.8166666666667, 0.14, 0
18471, 1.8333333333333, 0.14, 0
18472, 1.85, 0.14, 0
18473, 1.8666666666667, 0.14, 0
18474, 1.8833333333333, 0.14, 0
18475, 1.9, 0.14, 0
18476, 1.9166666666667, 0.14, 0
18477, 1.9333333333333, 0.14, 0
18478, 1.95, 0.14, 0
18479, 1.9666666666667, 0.14, 0
18480, 1.9833333333333, 0.14, 0
18481, 2, 0.14, 0
18482, 2.0166666666667, 0.14, 0
18483, 2.0333333333333, 0.14, 0
18484, 2.05, 0.14, 0
18485, 2.0666666666667, 0.14, 0
18486, 2.0833333333333, 0.14, 0
18487, 2.1, 0.14, 0
18488, 2.1166666666667, 0.14, 0
18489, 2.1333333333333, 0.14, 0
18490, 2.15, 0.14, 0
18491, 2.1666666666667, 0.14, 0
18492, 2.1833333333333, 0.14, 0
18493, 1.2166666666667, 0.12, 0
18494, 1.2333333333333, 0.12, 0
18495, 1.25, 0.12, 0
18496, 1.2666666666667, 0.12, 0
18497, 1.2833333333333, 0.12, 0
18498, 1.3, 0.12, 0
18499, 1.3166666666667, 0.12, 0
18500, 1.3333333333333, 0.12, 0
18501, 1.35, 0.12, 0
18502, 1.3666666666667, 0.12, 0
18503, 1.3833333333333, 0.12, 0
18504, 1.4, 0.12, 0
18505, 1.4166666666667, 0.12, 0
18506, 1.4333333333333, 0.12, 0
18507, 1.45, 0.12, 0
18508, 1.4666666666667, 0.12, 0
18509, 1.4833333333333, 0.12, 0
18510, 1.5, 0.12, 0
18511, 1.5166666666667, 0.12, 0
18512, 1.5333333333333, 0.12, 0
18513, 1.55, 0.12, 0
18514, 1.5666666666667, 0.12, 0
18515, 1.5833333333333, 0.12, 0
18516, 1.6, 0.12, 0
18517, 1.6166666666667, 0.12, 0
18518, 1.6333333333333, 0.12, 0
18519, 1.65, 0.12, 0
18520, 1.6666666666667, 0.12, 0
18521, 1.6833333333333, 0.12, 0
18522, 1.7, 0.12, 0
18523, 1.7166666666667, 0.12, 0
18524, 1.7333333333333, 0.12, 0
18525, 1.75, 0.12, 0
18526, 1.7666666666667, 0.12, 0
18527, 1.7833333333333, 0.12, 0
18528, 1.8, 0.12, 0
18529, 1.8166666666667, 0.12, 0
18530, 1.8333333333333, 0.12, 0
18531, 1.85, 0.12, 0
18532, 1.8666666666667, 0.12, 0
18533, 1.8833333333333, 0.12, 0
18534, 1.9, 0.12, 0
18535, 1.9166666666667, 0.12, 0
18536, 1.9333333333333, 0.12, 0
18537, 1.95, 0.12, 0
18538, 1.9666666666667, 0.12, 0
18539, 1.9833333333333, 0.12, 0
18540, 2, 0.12, 0
18541, 2.0166666666667, 0.12, 0
18542, 2.0333333333333, 0.12, 0
18543, 2.05, 0.12, 0
18544, 2.0666666666667, 0.12, 0
18545, 2.0833333333333, 0.12, 0
18546, 2.1, 0.12, 0
18547, 2.1166666666667, 0.12, 0
18548, 2.1333333333333, 0.12, 0
18549, 2.15, 0.12, 0
18550, 2.1666666666667, 0.12, 0
18551, 2.1833333333333, 0.12, 0
18552, 1.2166666666667, 0.1, 0
18553, 1.2333333333333, 0.1, 0
18554, 1.25, 0.1, 0
18555, 1.2666666666667, 0.1, 0
18556, 1.2833333333333, 0.1, 0
18557, 1.3, 0.1, 0
18558, 1.3166666666667, 0.1, 0
18559, 1.3333333333333, 0.1, 0
18560, 1.35, 0.1, 0
18561, 1.3666666666667, 0.1, 0
18562, 1.3833333333333, 0.1, 0
18563, 1.4, 0.1, 0
18564, 1.4166666666667, 0.1, 0
18565, 1.4333333333333, 0.1, 0
18566, 1.45, 0.1, 0
18567, 1.4666666666667, 0.1, 0
18568, 1.4833333333333, 0.1, 0
18569, 1.5, 0.1, 0
18570, 1.5166666666667, 0.1, 0
18571, 1.5333333333333, 0.1, 0
18572, 1.55, 0.1, 0
18573, 1.5666666666667, 0.1, 0
18574, 1.5833333333333, 0.1, 0
18575, 1.6, 0.1, 0
18576, 1.6166666666667, 0.1, 0
18577, 1.6333333333333, 0.1, 0
18578, 1.65, 0.1, 0
18579, 1.6666666666667, 0.1, 0
18580, 1.6833333333333, 0.1, 0
18581, 1.7, 0.1, 0
18582, 1.7166666666667, 0.1, 0
18583, 1.7333333333333, 0.1, 0
18584, 1.75, 0.1, 0
18585, 1.7666666666667, 0.1, 0
18586, 1.7833333333333, 0.1, 0
18587, 1.8, 0.1, 0
18588, 1.8166666666667, 0.1, 0
18589, 1.8333333333333, 0.1, 0
18590, 1.85, 0.1, 0
18591, 1.8666666666667, 0.1, 0
18592, 1.8833333333333, 0.1, 0
18593, 1.9, 0.1, 0
18594, 1.9166666666667, 0.1, 0
18595, 1.9333333333333, 0.1, 0
18596, 1.95, 0.1, 0
18597, 1.9666666666667, 0.1, 0
18598, 1.9833333333333, 0.1, 0
18599, 2, 0.1, 0
18600, 2.0166666666667, 0.1, 0
18601, 2.0333333333333, 0.1, 0
18602, 2.05, 0.1, 0
18603, 2.0666666666667, 0.1, 0
18604, 2.0833333333333, 0.1, 0
18605, 2.1, 0.1, 0
18606, 2.1166666666667, 0.1, 0
18607, 2.1333333333333, 0.1, 0
18608, 2.15, 0.1, 0
18609, 2.1666666666667, 0.1, 0
18610, 2.1833333333333, 0.1, 0
18611, 1.2166666666667, 0.080000000000001, 0
18612, 1.2333333333333, 0.08, 0
18613, 1.25, 0.08, 0
18614, 1.2666666666667, 0.080000000000001, 0
18615, 1.2833333333333, 0.08, 0
18616, 1.3, 0.08, 0
18617, 1.3166666666667, 0.080000000000001, 0
18618, 1.3333333333333, 0.08, 0
18619, 1.35, 0.08, 0
18620, 1.3666666666667, 0.080000000000001, 0
18621, 1.3833333333333, 0.08, 0
18622, 1.4, 0.08, 0
18623, 1.4166666666667, 0.08, 0
18624, 1.4333333333333, 0.08, 0
18625, 1.45, 0.08, 0
18626, 1.4666666666667, 0.08, 0
18627, 1.4833333333333, 0.08, 0
18628, 1.5, 0.08, 0
18629, 1.5166666666667, 0.08, 0
18630, 1.5333333333333, 0.08, 0
18631, 1.55, 0.08, 0
18632, 1.5666666666667, 0.08, 0
18633, 1.5833333333333, 0.08, 0
18634, 1.6, 0.08, 0
18635, 1.6166666666667, 0.08, 0
18636, 1.6333333333333, 0.08, 0
18637, 1.65, 0.08, 0
18638, 1.6666666666667, 0.08, 0
18639, 1.6833333333333, 0.08, 0
18640, 1.7, 0.08, 0
18641, 1.7166666666667, 0.08, 0
18642, 1.7333333333333, 0.08, 0
18643, 1.75, 0.08, 0
18644, 1.7666666666667, 0.08, 0
18645, 1.7833333333333, 0.08, 0
18646, 1.8, 0.08, 0
18647, 1.8166666666667, 0.08, 0
18648, 1.8333333333333, 0.08, 0
18649, 1.85, 0.08, 0
18650, 1.8666666666667, 0.08, 0
18651, 1.8833333333333, 0.08, 0
18652, 1.9, 0.08, 0
18653, 1.9166666666667, 0.08, 0
18654, 1.9333333333333, 0.08, 0
18655, 1.95, 0.08, 0
18656, 1.9666666666667, 0.08, 0
18657, 1.9833333333333, 0.08, 0
18658, 2, 0.08, 0
18659, 2.0166666666667, 0.08, 0
18660, 2.0333333333333, 0.08, 0
18661, 2.05, 0.08, 0
18662, 2.0666666666667, 0.08, 0
18663, 2.0833333333333, 0.08, 0
18664, 2.1, 0.08, 0
18665, 2.1166666666667, 0.08, 0
18666, 2.1333333333333, 0.08, 0
18667, 2.15, 0.08, 0
18668, 2.1666666666667, 0.08, 0
18669, 2.1833333333333, 0.08, 0
18670, 1.2166666666667, 0.06, 0
18671, 1.2333333333333, 0.06, 0
18672, 1.25, 0.06, 0
18673, 1.2666666666667, 0.06, 0
18674, 1.2833333333333, 0.06, 0
18675, 1.3, 0.06, 0
18676, 1.3166666666667, 0.06, 0
18677, 1.3333333333333, 0.06, 0
18678, 1.35, 0.06, 0
18679, 1.3666666666667, 0.06, 0
18680, 1.3833333333333, 0.06, 0
18681, 1.4, 0.06, 0
18682, 1.4166666666667, 0.06, 0
18683, 1.4333333333333, 0.06, 0
18684, 1.45, 0.06, 0
18685, 1.4666666666667, 0.06, 0
18686, 1.4833333333333, 0.06, 0
18687, 1.5, 0.06, 0
18688, 1.5166666666667, 0.06, 0
18689, 1.5333333333333, 0.06, 0
18690, 1.55, 0.06, 0
18691, 1.5666666666667, 0.06, 0
18692, 1.5833333333333, 0.06, 0
18693, 1.6, 0.06, 0
18694, 1.6166666666667, 0.06, 0
18695, 1.6333333333333, 0.06, 0
18696, 1.65, 0.06, 0
18697, 1.6666666666667, 0.06, 0
18698, 1.6833333333333, 0.06, 0
18699, 1.7, 0.06, 0
18700, 1.7166666666667, 0.06, 0
18701, 1.7333333333333, 0.06, 0
18702, 1.75, 0.06, 0
18703, 1.7666666666667, 0.06, 0
18704, 1.7833333333333, 0.06, 0
18705, 1.8, 0.06, 0
18706, 1.8166666666667, 0.06, 0
18707, 1.8333333333333, 0.06, 0
18708, 1.85, 0.06, 0
18709, 1.8666666666667, 0.06, 0
18710, 1.8833333333333, 0.06, 0
18711, 1.9, 0.06, 0
18712, 1.9166666666667, 0.06, 0
18713, 1.9333333333333, 0.06, 0
18714, 1.95, 0.06, 0
18715, 1.9666666666667, 0.06, 0
18716, 1.9833333333333, 0.06, 0
18717, 2, 0.06, 0
18718, 2.0166666666667, 0.06, 0
18719, 2.0333333333333, 0.06, 0
18720, 2.05, 0.06, 0
18721, 2.0666666666667, 0.06, 0
18722, 2.0833333333333, 0.06, 0
18723, 2.1, 0.06, 0
18724, 2.1166666666667, 0.06, 0
18725, 2.1333333333333, 0.06, 0
18726, 2.15, 0.06, 0
18727, 2.1666666666667, 0.06, 0
18728, 2.1833333333333, 0.06, 0
18729, 1.2166666666667, 0.04, 0
18730, 1.2333333333333, 0.04, 0
18731, 1.25, 0.04, 0
18732, 1.2666666666667, 0.04, 0
18733, 1.2833333333333, 0.04, 0
18734, 1.3, 0.04, 0
18735, 1.3166666666667, 0.04, 0
18736, 1.3333333333333, 0.04, 0
18737, 1.35, 0.04, 0
18738, 1.3666666666667, 0.04, 0
18739, 1.3833333333333, 0.04, 0
18740, 1.4, 0.04, 0
18741, 1.4166666666667, 0.04, 0
18742, 1.4333333333333, 0.04, 0
18743, 1.45, 0.04, 0
18744, 1.4666666666667, 0.04, 0
18745, 1.4833333333333, 0.04, 0
18746, 1.5, 0.04, 0
18747, 1.5166666666667, 0.04, 0
18748, 1.5333333333333, 0.04, 0
18749, 1.55, 0.04, 0
18750, 1.5666666666667, 0.04, 0
18751, 1.5833333333333, 0.04, 0
18752, 1.6, 0.04, 0
18753, 1.6166666666667, 0.04, 0
18754, 1.6333333333333, 0.04, 0
18755, 1.65, 0.04, 0
18756, 1.6666666666667, 0.04, 0
18757, 1.6833333333333, 0.04, 0
18758, 1.7, 0.04, 0
18759, 1.7166666666667, 0.04, 0
18760, 1.7333333333333, 0.04, 0
18761, 1.75, 0.04, 0
18762, 1.7666666666667, 0.04, 0
18763, 1.7833333333333, 0.04, 0
18764, 1.8, 0.04, 0
18765, 1.8166666666667, 0.04, 0
18766, 1.8333333333333, 0.04, 0
18767, 1.85, 0.04, 0
18768, 1.8666666666667, 0.04, 0
18769, 1.8833333333333, 0.04, 0
18770, 1.9, 0.04, 0
18771, 1.9166666666667, 0.04, 0
18772, 1.9333333333333, 0.04, 0
18773, 1.95, 0.04, 0
18774, 1.9666666666667, 0.04, 0
18775, 1.9833333333333, 0.04, 0
18776, 2, 0.04, 0
18777, 2.0166666666667, 0.04, 0
18778, 2.0333333333333, 0.04, 0
18779, 2.05, 0.04, 0
18780, 2.0666666666667, 0.04, 0
18781, 2.0833333333333, 0.040000000000001, 0
18782, 2.1, 0.04, 0
18783, 2.1166666666667, 0.04, 0
18784, 2.1333333333333, 0.04, 0
18785, 2.15, 0.04, 0
18786, 2.1666666666667, 0.04, 0
18787, 2.1833333333333, 0.04, 0
18788, 1.2166666666667, 0.02, 0
18789, 1.2333333333333, 0.02, 0
18790, 1.25, 0.019999999999999, 0
18791, 1.2666666666667, 0.02, 0
18792, 1.2833333333333, 0.02, 0
18793, 1.3, 0.02, 0
18794, 1.3166666666667, 0.02, 0
18795, 1.3333333333333, 0.02, 0
18796, 1.35, 0.02, 0
18797, 1.3666666666667, 0.02, 0
18798, 1.3833333333333, 0.02, 0
18799, 1.4, 0.02, 0
18800, 1.4166666666667, 0.02, 0
18801, 1.4333333333333, 0.02, 0
18802, 1.45, 0.02, 0
18803, 1.4666666666667, 0.02, 0
18804, 1.4833333333333, 0.02, 0
18805, 1.5, 0.02, 0
18806, 1.5166666666667, 0.02, 0
18807, 1.5333333333333, 0.02, 0
18808, 1.55, 0.02, 0
18809, 1.5666666666667, 0.02, 0
18810, 1.5833333333333, 0.02, 0
18811, 1.6, 0.02, 0
18812, 1.6166666666667, 0.02, 0
18813, 1.6333333333333, 0.02, 0
18814, 1.65, 0.02, 0
18815, 1.6666666666667, 0.02, 0
18816, 1.6833333333333, 0.02, 0
18817, 1.7, 0.02, 0
18818, 1.7166666666667, 0.02, 0
18819, 1.7333333333333, 0.02, 0
18820, 1.75, 0.02, 0
18821, 1.7666666666667, 0.02, 0
18822, 1.7833333333333, 0.02, 0
18823, 1.8, 0.02, 0
18824, 1.8166666666667, 0.02, 0
18825, 1.8333333333333, 0.02, 0
18826, 1.85, 0.02, 0
18827, 1.8666666666667, 0.02, 0
18828, 1.8833333333333, 0.02, 0
18829, 1.9, 0.02, 0
18830, 1.9166666666667, 0.02, 0
18831, 1.9333333333333, 0.02, 0
18832, 1.95, 0.02, 0
18833, 1.9666666666667, 0.02, 0
18834, 1.9833333333333, 0.02, 0
18835, 2, 0.02, 0
18836, 2.0166666666667, 0.02, 0
18837, 2.0333333333333, 0.02, 0
18838, 2.05, 0.02, 0
18839, 2.0666666666667, 0.02, 0
18840, 2.0833333333333, 0.02, 0
18841, 2.1, 0.02, 0
18842, 2.1166666666667, 0.02, 0
18843, 2.1333333333333, 0.02, 0
18844, 2.15, 0.02, 0
18845, 2.1666666666667, 0.02, 0
18846, 2.1833333333333, 0.02, 0
18847, 1.2083333333333, 1.18, 0
18848, 1.2166666666667, 1.19, 0
18849, 1.225, 1.18, 0
18850, 1.2333333333333, 1.19, 0
18851, 1.2416666666667, 1.18, 0
18852, 1.25, 1.19, 0
18853, 1.2583333333333, 1.18, 0
18854, 1.2666666666667, 1.19, 0
18855, 1.275, 1.18, 0
18856, 1.2833333333333, 1.19, 0
18857, 1.2916666666667, 1.18, 0
18858, 1.3, 1.19, 0
18859, 1.3083333333333, 1.18, 0
18860, 1.3166666666667, 1.19, 0
18861, 1.325, 1.18, 0
18862, 1.3333333333333, 1.19, 0
18863, 1.3416666666667, 1.18, 0
18864, 1.35, 1.19, 0
18865, 1.3583333333333, 1.18, 0
18866, 1.3666666666667, 1.19, 0
18867, 1.375, 1.18, 0
18868, 1.3833333333333, 1.19, 0
18869, 1.3916666666667, 1.18, 0
18870, 1.4, 1.19, 0
18871, 1.4083333333333, 1.18, 0
18872, 1.4166666666667, 1.19, 0
18873, 1.425, 1.18, 0
18874, 1.4333333333333, 1.19, 0
18875, 1.4416666666667, 1.18, 0
18876, 1.45, 1.19, 0
18877, 1.4583333333333, 1.18, 0
18878, 1.4666666666667, 1.19, 0
18879, 1.475, 1.18, 0
18880, 1.4833333333333, 1.19, 0
18881, 1.4916666666667, 1.18, 0
18882, 1.5, 1.19, 0
18883, 1.5083333333333, 1.18, 0
18884, 1.5166666666667, 1.19, 0
18885, 1.525, 1.18, 0
18886, 1.5333333333333, 1.19, 0
18887, 1.5416666666667, 1.18, 0
18888, 1.55, 1.19, 0
18889, 1.5583333333333, 1.18, 0
18890, 1.5666666666667, 1.19, 0
18891, 1.575, 1.18, 0
18892, 1.5833333333333, 1.19, 0
18893, 1.5916666666667, 1.18, 0
18894, 1.6, 1.19, 0
18895, 1.6083333333333, 1.18, 0
18896, 1.6166666666667, 1.19, 0
18897, 1.625, 1.18, 0
18898, 1.6333333333333, 1.19, 0
18899, 1.6416666666667, 1.18, 0
18900, 1.65, 1.19, 0
18901, 1.6583333333333, 1.18, 0
18902, 1.6666666666667, 1.19, 0
18903, 1.675, 1.18, 0
18904, 1.6833333333333, 1.19, 0
18905, 1.6916666666667, 1.18, 0
18906, 1.7, 1.19, 0
18907, 1.7083333333333, 1.18, 0
18908, 1.7166666666667, 1.19, 0
18909, 1.725, 1.18, 0
18910, 1.7333333333333, 1.19, 0
18911, 1.7416666666667, 1.18, 0
18912, 1.75, 1.19, 0
18913, 1.7583333333333, 1.18, 0
18914, 1.7666666666667, 1.19, 0
18915, 1.775, 1.18, 0
18916, 1.7833333333333, 1.19, 0
18917, 1.7916666666667, 1.18, 0
18918, 1.8, 1.19, 0
18919, 1.8083333333333, 1.18, 0
18920, 1.8166666666667, 1.19, 0
18921, 1.825, 1.18, 0
18922, 1.8333333333333, 1.19, 0
18923, 1.8416666666667, 1.18, 0
18924, 1.85, 1.19, 0
18925, 1.8583333333333, 1.18, 0
18926, 1.8666666666667, 1.19, 0
18927, 1.875, 1.18, 0
18928, 1.8833333333333, 1.19, 0
18929, 1.8916666666667, 1.18, 0
18930, 1.9, 1.19, 0
18931, 1.9083333333333, 1.18, 0
18932, 1.9166666666667, 1.19, 0
18933, 1.925, 1.18, 0
18934, 1.9333333333333, 1.19, 0
18935, 1.9416666666667, 1.18, 0
18936, 1.95, 1.19, 0
18937, 1.9583333333333, 1.18, 0
18938, 1.9666666666667, 1.19, 0
18939, 1.975, 1.18, 0
18940, 1.9833333333333, 1.19, 0
18941, 1.9916666666667, 1.18, 0
18942, 2, 1.19, 0
18943, 2.0083333333333, 1.18, 0
18944, 2.0166666666667, 1.19, 0
18945, 2.025, 1.18, 0
18946, 2.0333333333333, 1.19, 0
18947, 2.0416666666667, 1.18, 0
18948, 2.05, 1.19, 0
18949, 2.0583333333333, 1.18, 0
18950, 2.0666666666667, 1.19, 0
18951, 2.075, 1.18, 0
18952, 2.0833333333333, 1.19, 0
18953, 2.0916666666667, 1.18, 0
18954, 2.1, 1.19, 0
18955, 2.1083333333333, 1.18, 0
18956, 2.1166666666667, 1.19, 0
18957, 2.125, 1.18, 0
18958, 2.1333333333333, 1.19, 0
18959, 2.1416666666667, 1.18, 0
18960, 2.15, 1.19, 0
18961, 2.1583333333333, 1.18, 0
18962, 2.1666666666667, 1.19, 0
18963, 2.175, 1.18, 0
18964, 2.1833333333333, 1.19, 0
18965, 2.1916666666667, 1.18, 0
18966, 1.2083333333333, 1.16, 0
18967, 1.2166666666667, 1.17, 0
18968, 1.225, 1.16, 0
18969, 1.2333333333333, 1.17, 0
18970, 1.2416666666667, 1.16, 0
18971, 1.25, 1.17, 0
18972, 1.2583333333333, 1.16, 0
18973, 1.2666666666667, 1.17, 0
18974, 1.275, 1.16, 0
18975, 1.2833333333333, 1.17, 0
18976, 1.2916666666667, 1.16, 0
18977, 1.3, 1.17, 0
18978, 1.3083333333333, 1.16, 0
18979, 1.3166666666667, 1.17, 0
18980, 1.325, 1.16, 0
18981, 1.3333333333333, 1.17, 0
18982, 1.3416666666667, 1.16, 0
18983, 1.35, 1.17, 0
18984, 1.3583333333333, 1.16, 0
18985, 1.3666666666667, 1.17, 0
18986, 1.375, 1.16, 0
18987, 1.3833333333333, 1.17, 0
18988, 1.3916666666667, 1.16, 0
18989, 1.4, 1.17, 0
18990, 1.4083333333333, 1.16, 0
18991, 1.4166666666667, 1.17, 0
18992, 1.425, 1.16, 0
18993, 1.4333333333333, 1.17, 0
18994, 1.4416666666667, 1.16, 0
18995, 1.45, 1.17, 0
18996, 1.4583333333333, 1.16, 0
18997, 1.4666666666667, 1.17, 0
18998, 1.475, 1.16, 0
18999, 1.4833333333333, 1.17, 0
19000, 1.4916666666667, 1.16, 0
19001, 1.5, 1.17, 0
19002, 1.5083333333333, 1.16, 0
19003, 1.5166666666667, 1.17, 0
19004, 1.525, 1.16, 0
19005, 1.5333333333333, 1.17, 0
19006, 1.5416666666667, 1.16, 0
19007, 1.55, 1.17, 0
19008, 1.5583333333333, 1.16, 0
19009, 1.5666666666667, 1.17, 0
19010, 1.575, 1.16, 0
19011, 1.5833333333333, 1.17, 0
19012, 1.5916666666667, 1.16, 0
19013, 1.6, 1.17, 0
19014, 1.6083333333333, 1.16, 0
19015, 1.6166666666667, 1.17, 0
19016, 1.625, 1.16, 0
19017, 1.6333333333333, 1.17, 0
19018, 1.6416666666667, 1.16, 0
19019, 1.65, 1.17, 0
19020, 1.6583333333333, 1.16, 0
19021, 1.6666666666667, 1.17, 0
19022, 1.675, 1.16, 0
19023, 1.6833333333333, 1.17, 0
19024, 1.6916666666667, 1.16, 0
19025, 1.7, 1.17, 0
19026, 1.7083333333333, 1.16, 0
19027, 1.7166666666667, 1.17, 0
19028, 1.725, 1.16, 0
19029, 1.7333333333333, 1.17, 0
19030, 1.7416666666667, 1.16, 0
19031, 1.75, 1.17, 0
19032, 1.7583333333333, 1.16, 0
19033, 1.7666666666667, 1.17, 0
19034, 1.775, 1.16, 0
19035, 1.7833333333333, 1.17, 0
19036, 1.7916666666667, 1.16, 0
19037, 1.8, 1.17, 0
19038, 1.8083333333333, 1.16, 0
19039, 1.8166666666667, 1.17, 0
19040, 1.825, 1.16, 0
19041, 1.8333333333333, 1.17, 0
19042, 1.8416666666667, 1.16, 0
19043, 1.85, 1.17, 0
19044, 1.8583333333333, 1.16, 0
19045, 1.8666666666667, 1.17, 0
19046, 1.875, 1.16, 0
19047, 1.8833333333333, 1.17, 0
19048, 1.8916666666667, 1.16, 0
19049, 1.9, 1.17, 0
19050, 1.9083333333333, 1.16, 0
19051, 1.9166666666667, 1.17, 0
19052, 1.925, 1.16, 0
19053, 1.9333333333333, 1.17, 0
19054, 1.9416666666667, 1.16, 0
19055, 1.95, 1.17, 0
19056, 1.9583333333333, 1.16, 0
19057, 1.9666666666667, 1.17, 0
19058, 1.975, 1.16, 0
19059, 1.9833333333333, 1.17, 0
19060, 1.9916666666667, 1.16, 0
19061, 2, 1.17, 0
19062, 2.0083333333333, 1.16, 0
19063, 2.0166666666667, 1.17, 0
19064, 2.025, 1.16, 0
19065, 2.0333333333333, 1.17, 0
19066, 2.0416666666667, 1.16, 0
19067, 2.05, 1.17, 0
19068, 2.0583333333333, 1.16, 0
19069, 2.0666666666667, 1.17, 0
19070, 2.075, 1.16, 0
19071, 2.0833333333333, 1.17, 0
19072, 2.0916666666667, 1.16, 0
19073, 2.1, 1.17, 0
19074, 2.1083333333333, 1.16, 0
19075, 2.1166666666667, 1.17, 0
19076, 2.125, 1.16, 0
19077, 2.1333333333333, 1.17, 0
19078, 2.1416666666667, 1.16, 0
19079, 2.15, 1.17, 0
19080, 2.1583333333333, 1.16, 0
19081, 2.1666666666667, 1.17, 0
19082, 2.175, 1.16, 0
19083, 2.1833333333333, 1.17, 0
19084, 2.1916666666667, 1.16, 0
19085, 1.2083333333333, 1.14, 0
19086, 1.2166666666667, 1.15, 0
19087, 1.225, 1.14, 0
19088, 1.2333333333333, 1.15, 0
19089, 1.2416666666667, 1.14, 0
19090, 1.25, 1.15, 0
19091, 1.2583333333333, 1.14, 0
19092, 1.2666666666667, 1.15, 0
19093, 1.275, 1.14, 0
19094, 1.2833333333333, 1.15, 0
19095, 1.2916666666667, 1.14, 0
19096, 1.3, 1.15, 0
19097, 1.3083333333333, 1.14, 0
19098, 1.3166666666667, 1.15, 0
19099, 1.325, 1.14, 0
19100, 1.3333333333333, 1.15, 0
19101, 1.3416666666667, 1.14, 0
19102, 1.35, 1.15, 0
19103, 1.3583333333333, 1.14, 0
19104, 1.3666666666667, 1.15, 0
19105, 1.375, 1.14, 0
19106, 1.3833333333333, 1.15, 0
19107, 1.3916666666667, 1.14, 0
19108, 1.4, 1.15, 0
19109, 1.4083333333333, 1.14, 0
19110, 1.4166666666667, 1.15, 0
19111, 1.425, 1.14, 0
19112, 1.4333333333333, 1.15, 0
19113, 1.4416666666667, 1.14, 0
19114, 1.45, 1.15, 0
19115, 1.4583333333333, 1.14, 0
19116, 1.4666666666667, 1.15, 0
19117, 1.475, 1.14, 0
19118, 1.4833333333333, 1.15, 0
19119, 1.4916666666667, 1.14, 0
19120, 1.5, 1.15, 0
19121, 1.5083333333333, 1.14, 0
19122, 1.5166666666667, 1.15, 0
19123, 1.525, 1.14, 0
19124, 1.5333333333333, 1.15, 0
19125, 1.5416666666667, 1.14, 0
19126, 1.55, 1.15, 0
19127, 1.5583333333333, 1.14, 0
19128, 1.5666666666667, 1.15, 0
19129, 1.575, 1.14, 0
19130, 1.5833333333333, 1.15, 0
19131, 1.5916666666667, 1.14, 0
19132, 1.6, 1.15, 0
19133, 1.6083333333333, 1.14, 0
19134, 1.6166666666667, 1.15, 0
19135, 1.625, 1.14, 0
19136, 1.6333333333333, 1.15, 0
19137, 1.6416666666667, 1.14, 0
19138, 1.65, 1.15, 0
19139, 1.6583333333333, 1.14, 0
19140, 1.6666666666667, 1.15, 0
19141, 1.675, 1.14, 0
19142, 1.6833333333333, 1.15, 0
19143, 1.6916666666667, 1.14, 0
19144, 1.7, 1.15, 0
19145, 1.7083333333333, 1.14, 0
19146, 1.7166666666667, 1.15, 0
19147, 1.725, 1.14, 0
19148, 1.7333333333333, 1.15, 0
19149, 1.7416666666667, 1.14, 0
19150, 1.75, 1.15, 0
19151, 1.7583333333333, 1.14, 0
19152, 1.7666666666667, 1.15, 0
19153, 1.775, 1.14, 0
19154, 1.7833333333333, 1.15, 0
19155, 1.7916666666667, 1.14, 0
19156, 1.8, 1.15, 0
19157, 1.8083333333333, 1.14, 0
19158, 1.8166666666667, 1.15, 0
19159, 1.825, 1.14, 0
19160, 1.8333333333333, 1.15, 0
19161, 1.8416666666667, 1.14, 0
19162, 1.85, 1.15, 0
19163, 1.8583333333333, 1.14, 0
19164, 1.8666666666667, 1.15, 0
19165, 1.875, 1.14, 0
19166, 1.8833333333333, 1.15, 0
19167, 1.8916666666667, 1.14, 0
19168, 1.9, 1.15, 0
19169, 1.9083333333333, 1.14, 0
19170, 1.9166666666667, 1.15, 0
19171, 1.925, 1.14, 0
19172, 1.9333333333333, 1.15, 0
19173, 1.9416666666667, 1.14, 0
19174, 1.95, 1.15, 0
19175, 1.9583333333333, 1.14, 0
19176, 1.9666666666667, 1.15, 0
19177, 1.975, 1.14, 0
19178, 1.9833333333333, 1.15, 0
19179, 1.9916666666667, 1.14, 0
19180, 2, 1.15, 0
19181, 2.0083333333333, 1.14, 0
19182, 2.0166666666667, 1.15, 0
19183, 2.025, 1.14, 0
19184, 2.0333333333333, 1.15, 0
19185, 2.0416666666667, 1.14, 0
19186, 2.05, 1.15, 0
19187, 2.0583333333333, 1.14, 0
19188, 2.0666666666667, 1.15, 0
19189, 2.075, 1.14, 0
19190, 2.0833333333333, 1.15, 0
19191, 2.0916666666667, 1.14, 0
19192, 2.1, 1.15, 0
19193, 2.1083333333333, 1.14, 0
19194, 2.1166666666667, 1.15, 0
19195, 2.125, 1.14, 0
19196, 2.1333333333333, 1.15, 0
19197, 2.1416666666667, 1.14, 0
19198, 2.15, 1.15, 0
19199, 2.1583333333333, 1.14, 0
19200, 2.1666666666667, 1.15, 0
19201, 2.175, 1.14, 0
19202, 2.1833333333333, 1.15, 0
19203, 2.1916666666667, 1.14, 0
19204, 1.2083333333333, 1.12, 0
19205, 1.2166666666667, 1.13, 0
19206, 1.225, 1.12, 0
19207, 1.2333333333333, 1.13, 0
19208, 1.2416666666667, 1.12, 0
19209, 1.25, 1.13, 0
19210, 1.2583333333333, 1.12, 0
19211, 1.2666666666667, 1.13, 0
19212, 1.275, 1.12, 0
19213, 1.2833333333333, 1.13, 0
19214, 1.2916666666667, 1.12, 0
19215, 1.3, 1.13, 0
19216, 1.3083333333333, 1.12, 0
19217, 1.3166666666667, 1.13, 0
19218, 1.325, 1.12, 0
19219, 1.3333333333333, 1.13, 0
19220, 1.3416666666667, 1.12, 0
19221, 1.35, 1.13, 0
19222, 1.3583333333333, 1.12, 0
19223, 1.3666666666667, 1.13, 0
19224, 1.375, 1.12, 0
19225, 1.3833333333333, 1.13, 0
19226, 1.3916666666667, 1.12, 0
19227, 1.4, 1.13, 0
19228, 1.4083333333333, 1.12, 0
19229, 1.4166666666667, 1.13, 0
19230, 1.425, 1.12, 0
19231, 1.4333333333333, 1.13, 0
19232, 1.4416666666667, 1.12, 0
19233, 1.45, 1.13, 0
19234, 1.4583333333333, 1.12, 0
19235, 1.4666666666667, 1.13, 0
19236, 1.475, 1.12, 0
19237, 1.4833333333333, 1.13, 0
19238, 1.4916666666667, 1.12, 0
19239, 1.5, 1.13, 0
19240, 1.5083333333333, 1.12, 0
19241, 1.5166666666667, 1.13, 0
19242, 1.525, 1.12, 0
19243, 1.5333333333333, 1.13, 0
19244, 1.5416666666667, 1.12, 0
19245, 1.55, 1.13, 0
19246, 1.5583333333333, 1.12, 0
19247, 1.5666666666667, 1.13, 0
19248, 1.575, 1.12, 0
19249, 1.5833333333333, 1.13, 0
19250, 1.5916666666667, 1.12, 0
19251, 1.6, 1.13, 0
19252, 1.6083333333333, 1.12, 0
19253, 1.6166666666667, 1.13, 0
19254, 1.625, 1.12, 0
19255, 1.6333333333333, 1.13, 0
19256, 1.6416666666667, 1.12, 0
19257, 1.65, 1.13, 0
19258, 1.6583333333333, 1.12, 0
19259, 1.6666666666667, 1.13, 0
19260, 1.675, 1.12, 0
19261, 1.6833333333333, 1.13, 0
19262, 1.6916666666667, 1.12, 0
19263, 1.7, 1.13, 0
19264, 1.7083333333333, 1.12, 0
19265, 1.7166666666667, 1.13, 0
19266, 1.725, 1.12, 0
19267, 1.7333333333333, 1.13, 0
19268, 1.7416666666667, 1.12, 0
19269, 1.75, 1.13, 0
19270, 1.7583333333333, 1.12, 0
19271, 1.7666666666667, 1.13, 0
19272, 1.775, 1.12, 0
19273, 1.7833333333333, 1.13, 0
19274, 1.7916666666667, 1.12, 0
19275, 1.8, 1.13, 0
19276, 1.8083333333333, 1.12, 0
19277, 1.8166666666667, 1.13, 0
19278, 1.825, 1.12, 0
19279, 1.8333333333333, 1.13, 0
19280, 1.8416666666667, 1.12, 0
19281, 1.85, 1.13, 0
19282, 1.8583333333333, 1.12, 0
19283, 1.8666666666667, 1.13, 0
19284, 1.875, 1.12, 0
19285, 1.8833333333333, 1.13, 0
19286, 1.8916666666667, 1.12, 0
19287, 1.9, 1.13, 0
19288, 1.9083333333333, 1.12, 0
19289, 1.9166666666667, 1.13, 0
19290, 1.925, 1.12, 0
19291, 1.9333333333333, 1.13, 0
19292, 1.9416666666667, 1.12, 0
19293, 1.95, 1.13, 0
19294, 1.9583333333333, 1.12, 0
19295, 1.9666666666667, 1.13, 0
19296, 1.975, 1.12, 0
19297, 1.9833333333333, 1.13, 0
19298, 1.9916666666667, 1.12, 0
19299, 2, 1.13, 0
19300, 2.0083333333333, 1.12, 0
19301, 2.0166666666667, 1.13, 0
19302, 2.025, 1.12, 0
19303, 2.0333333333333, 1.13, 0
19304, 2.0416666666667, 1.12, 0
19305, 2.05, 1.13, 0
19306, 2.0583333333333, 1.12, 0
19307, 2.0666666666667, 1.13, 0
19308, 2.075, 1.12, 0
19309, 2.0833333333333, 1.13, 0
19310, 2.0916666666667, 1.12, 0
19311, 2.1, 1.13, 0
19312, 2.1083333333333, 1.12, 0
19313, 2.1166666666667, 1.13, 0
19314, 2.125, 1.12, 0
19315, 2.1333333333333, 1.13, 0
19316, 2.1416666666667, 1.12, 0
19317, 2.15, 1.13, 0
19318, 2.1583333333333, 1.12, 0
19319, 2.1666666666667, 1.13, 0
19320, 2.175, 1.12, 0
19321, 2.1833333333333, 1.13, 0
19322, 2.1916666666667, 1.12, 0
19323, 1.2083333333333, 1.1, 0
19324, 1.2166666666667, 1.11, 0
19325, 1.225, 1.1, 0
19326, 1.2333333333333, 1.11, 0
19327, 1.2416666666667, 1.1, 0
19328, 1.25, 1.11, 0
19329, 1.2583333333333, 1.1, 0
19330, 1.2666666666667, 1.11, 0
19331, 1.275, 1.1, 0
19332, 1.2833333333333, 1.11, 0
19333, 1.2916666666667, 1.1, 0
19334, 1.3, 1.11, 0
19335, 1.3083333333333, 1.1, 0
19336, 1.3166666666667, 1.11, 0
19337, 1.325, 1.1, 0
19338, 1.3333333333333, 1.11, 0
19339, 1.3416666666667, 1.1, 0
19340, 1.35, 1.11, 0
19341, 1.3583333333333, 1.1, 0
19342, 1.3666666666667, 1.11, 0
19343, 1.375, 1.1, 0
19344, 1.3833333333333, 1.11, 0
19345, 1.3916666666667, 1.1, 0
19346, 1.4, 1.11, 0
19347, 1.4083333333333, 1.1, 0
19348, 1.4166666666667, 1.11, 0
19349, 1.425, 1.1, 0
19350, 1.4333333333333, 1.11, 0
19351, 1.4416666666667, 1.1, 0
19352, 1.45, 1.11, 0
19353, 1.4583333333333, 1.1, 0
19354, 1.4666666666667, 1.11, 0
19355, 1.475, 1.1, 0
19356, 1.4833333333333, 1.11, 0
19357, 1.4916666666667, 1.1, 0
19358, 1.5, 1.11, 0
19359, 1.5083333333333, 1.1, 0
19360, 1.5166666666667, 1.11, 0
19361, 1.525, 1.1, 0
19362, 1.5333333333333, 1.11, 0
19363, 1.5416666666667, 1.1, 0
19364, 1.55, 1.11, 0
19365, 1.5583333333333, 1.1, 0
19366, 1.5666666666667, 1.11, 0
19367, 1.575, 1.1, 0
19368, 1.5833333333333, 1.11, 0
19369, 1.5916666666667, 1.1, 0
19370, 1.6, 1.11, 0
19371, 1.6083333333333, 1.1, 0
19372, 1.6166666666667, 1.11, 0
19373, 1.625, 1.1, 0
19374, 1.6333333333333, 1.11, 0
19375, 1.6416666666667, 1.1, 0
19376, 1.65, 1.11, 0
19377, 1.6583333333333, 1.1, 0
19378, 1.6666666666667, 1.11, 0
19379, 1.675, 1.1, 0
19380, 1.6833333333333, 1.11, 0
19381, 1.6916666666667, 1.1, 0
19382, 1.7, 1.11, 0
19383, 1.7083333333333, 1.1, 0
19384, 1.7166666666667, 1.11, 0
19385, 1.725, 1.1, 0
19386, 1.7333333333333, 1.11, 0
19387, 1.7416666666667, 1.1, 0
19388, 1.75, 1.11, 0
19389, 1.7583333333333, 1.1, 0
19390, 1.7666666666667, 1.11, 0
19391, 1.775, 1.1, 0
19392, 1.7833333333333, 1.11, 0
19393, 1.7916666666667, 1.1, 0
19394, 1.8, 1.11, 0
19395, 1.8083333333333, 1.1, 0
19396, 1.8166666666667, 1.11, 0
19397, 1.825, 1.1, 0
19398, 1.8333333333333, 1.11, 0
19399, 1.8416666666667, 1.1, 0
19400, 1.85, 1.11, 0
19401, 1.8583333333333, 1.1, 0
19402, 1.8666666666667, 1.11, 0
19403, 1.875, 1.1, 0
19404, 1.8833333333333, 1.11, 0
19405, 1.8916666666667, 1.1, 0
19406, 1.9, 1.11, 0
19407, 1.9083333333333, 1.1, 0
19408, 1.9166666666667, 1.11, 0
19409, 1.925, 1.1, 0
19410, 1.9333333333333, 1.11, 0
19411, 1.9416666666667, 1.1, 0
19412, 1.95, 1.11, 0
19413, 1.9583333333333, 1.1, 0
19414, 1.9666666666667, 1.11, 0
19415, 1.975, 1.1, 0
19416, 1.9833333333333, 1.11, 0
19417, 1.9916666666667, 1.1, 0
19418, 2, 1.11, 0
19419, 2.0083333333333, 1.1, 0
19420, 2.0166666666667, 1.11, 0
19421, 2.025, 1.1, 0
19422, 2.0333333333333, 1.11, 0
19423, 2.0416666666667, 1.1, 0
19424, 2.05, 1.11, 0
19425, 2.0583333333333, 1.1, 0
19426, 2.0666666666667, 1.11, 0
19427, 2.075, 1.1, 0
19428, 2.0833333333333, 1.11, 0
19429, 2.0916666666667, 1.1, 0
19430, 2.1, 1.11, 0
19431, 2.1083333333333, 1.1, 0
19432, 2.1166666666667, 1.11, 0
19433, 2.125, 1.1, 0
19434, 2.1333333333333, 1.11, 0
19435, 2.1416666666667, 1.1, 0
19436, 2.15, 1.11, 0
19437, 2.1583333333333, 1.1, 0
19438, 2.1666666666667, 1.11, 0
19439, 2.175, 1.1, 0
19440, 2.1833333333333, 1.11, 0
19441, 2.1916666666667, 1.1, 0
19442, 1.2083333333333, 1.08, 0
19443, 1.2166666666667, 1.09, 0
19444, 1.225, 1.08, 0
19445, 1.2333333333333, 1.09, 0
19446, 1.2416666666667, 1.08, 0
19447, 1.25, 1.09, 0
19448, 1.2583333333333, 1.08, 0
19449, 1.2666666666667, 1.09, 0
19450, 1.275, 1.08, 0
19451, 1.2833333333333, 1.09, 0
19452, 1.2916666666667, 1.08, 0
19453, 1.3, 1.09, 0
19454, 1.3083333333333, 1.08, 0
19455, 1.3166666666667, 1.09, 0
19456, 1.325, 1.08, 0
19457, 1.3333333333333, 1.09, 0
19458, 1.3416666666667, 1.08, 0
19459, 1.35, 1.09, 0
19460, 1.3583333333333, 1.08, 0
19461, 1.3666666666667, 1.09, 0
19462, 1.375, 1.08, 0
19463, 1.3833333333333, 1.09, 0
19464, 1.3916666666667, 1.08, 0
19465, 1.4, 1.09, 0
19466, 1.4083333333333, 1.08, 0
19467, 1.4166666666667, 1.09, 0
19468, 1.425, 1.08, 0
19469, 1.4333333333333, 1.09, 0
19470, 1.4416666666667, 1.08, 0
19471, 1.45, 1.09, 0
19472, 1.4583333333333, 1.08, 0
19473, 1.4666666666667, 1.09, 0
19474, 1.475, 1.08, 0
19475, 1.4833333333333, 1.09, 0
19476, 1.4916666666667, 1.08, 0
19477, 1.5, 1.09, 0
19478, 1.5083333333333, 1.08, 0
19479, 1.5166666666667, 1.09, 0
19480, 1.525, 1.08, 0
19481, 1.5333333333333, 1.09, 0
19482, 1.5416666666667, 1.08, 0
19483, 1.55, 1.09, 0
19484, 1.5583333333333, 1.08, 0
19485, 1.5666666666667, 1.09, 0
19486, 1.575, 1.08, 0
19487, 1.5833333333333, 1.09, 0
19488, 1.5916666666667, 1.08, 0
19489, 1.6, 1.09, 0
19490, 1.6083333333333, 1.08, 0
19491, 1.6166666666667, 1.09, 0
19492, 1.625, 1.08, 0
19493, 1.6333333333333, 1.09, 0
19494, 1.6416666666667, 1.08, 0
19495, 1.65, 1.09, 0
19496, 1.6583333333333, 1.08, 0
19497, 1.6666666666667, 1.09, 0
19498, 1.675, 1.08, 0
19499, 1.6833333333333, 1.09, 0
19500, 1.6916666666667, 1.08, 0
19501, 1.7, 1.09, 0
19502, 1.7083333333333, 1.08, 0
19503, 1.7166666666667, 1.09, 0
19504, 1.725, 1.08, 0
19505, 1.7333333333333, 1.09, 0
19506, 1.7416666666667, 1.08, 0
19507, 1.75, 1.09, 0
19508, 1.7583333333333, 1.08, 0
19509, 1.7666666666667, 1.09, 0
19510, 1.775, 1.08, 0
19511, 1.7833333333333, 1.09, 0
19512, 1.7916666666667, 1.08, 0
19513, 1.8, 1.09, 0
19514, 1.8083333333333, 1.08, 0
19515, 1.8166666666667, 1.09, 0
19516, 1.825, 1.08, 0
19517, 1.8333333333333, 1.09, 0
19518, 1.8416666666667, 1.08, 0
19519, 1.85, 1.09, 0
19520, 1.8583333333333, 1.08, 0
19521, 1.8666666666667, 1.09, 0
19522, 1.875, 1.08, 0
19523, 1.8833333333333, 1.09, 0
19524, 1.8916666666667, 1.08, 0
19525, 1.9, 1.09, 0
19526, 1.9083333333333, 1.08, 0
19527, 1.9166666666667, 1.09, 0
19528, 1.925, 1.08, 0
19529, 1.9333333333333, 1.09, 0
19530, 1.9416666666667, 1.08, 0
19531, 1.95, 1.09, 0
19532, 1.9583333333333, 1.08, 0
19533, 1.9666666666667, 1.09, 0
19534, 1.975, 1.08, 0
19535, 1.9833333333333, 1.09, 0
19536, 1.9916666666667, 1.08, 0
19537, 2, 1.09, 0
19538, 2.0083333333333, 1.08, 0
19539, 2.0166666666667, 1.09, 0
19540, 2.025, 1.08, 0
19541, 2.0333333333333, 1.09, 0
19542, 2.0416666666667, 1.08, 0
19543, 2.05, 1.09, 0
19544, 2.0583333333333, 1.08, 0
19545, 2.0666666666667, 1.09, 0
19546, 2.075, 1.08, 0
19547, 2.0833333333333, 1.09, 0
19548, 2.0916666666667, 1.08, 0
19549, 2.1, 1.09, 0
19550, 2.1083333333333, 1.08, 0
19551, 2.1166666666667, 1.09, 0
19552, 2.125, 1.08, 0
19553, 2.1333333333333, 1.09, 0
19554, 2.1416666666667, 1.08, 0
19555, 2.15, 1.09, 0
19556, 2.1583333333333, 1.08, 0
19557, 2.1666666666667, 1.09, 0
19558, 2.175, 1.08, 0
19559, 2.1833333333333, 1.09, 0
19560, 2.1916666666667, 1.08, 0
19561, 1.2083333333333, 1.06, 0
19562, 1.2166666666667, 1.07, 0
19563, 1.225, 1.06, 0
19564, 1.2333333333333, 1.07, 0
19565, 1.2416666666667, 1.06, 0
19566, 1.25, 1.07, 0
19567, 1.2583333333333, 1.06, 0
19568, 1.2666666666667, 1.07, 0
19569, 1.275, 1.06, 0
19570, 1.2833333333333, 1.07, 0
19571, 1.2916666666667, 1.06, 0
19572, 1.3, 1.07, 0
19573, 1.3083333333333, 1.06, 0
19574, 1.3166666666667, 1.07, 0
19575, 1.325, 1.06, 0
19576, 1.3333333333333, 1.07, 0
19577, 1.3416666666667, 1.06, 0
19578, 1.35, 1.07, 0
19579, 1.3583333333333, 1.06, 0
19580, 1.3666666666667, 1.07, 0
19581, 1.375, 1.06, 0
19582, 1.3833333333333, 1.07, 0
19583, 1.3916666666667, 1.06, 0
19584, 1.4, 1.07, 0
19585, 1.4083333333333, 1.06, 0
19586, 1.4166666666667, 1.07, 0
19587, 1.425, 1.06, 0
19588, 1.4333333333333, 1.07, 0
19589, 1.4416666666667, 1.06, 0
19590, 1.45, 1.07, 0
19591, 1.4583333333333, 1.06, 0
19592, 1.4666666666667, 1.07, 0
19593, 1.475, 1.06, 0
19594, 1.4833333333333, 1.07, 0
19595, 1.4916666666667, 1.06, 0
19596, 1.5, 1.07, 0
19597, 1.5083333333333, 1.06, 0
19598, 1.5166666666667, 1.07, 0
19599, 1.525, 1.06, 0
19600, 1.5333333333333, 1.07, 0
19601, 1.5416666666667, 1.06, 0
19602, 1.55, 1.07, 0
19603, 1.5583333333333, 1.06, 0
19604, 1.5666666666667, 1.07, 0
19605, 1.575, 1.06, 0
19606, 1.5833333333333, 1.07, 0
19607, 1.5916666666667, 1.06, 0
19608, 1.6, 1.07, 0
19609, 1.6083333333333, 1.06, 0
19610, 1.6166666666667, 1.07, 0
19611, 1.625, 1.06, 0
19612, 1.6333333333333, 1.07, 0
19613, 1.6416666666667, 1.06, 0
19614, 1.65, 1.07, 0
19615, 1.6583333333333, 1.06, 0
19616, 1.6666666666667, 1.07, 0
19617, 1.675, 1.06, 0
19618, 1.6833333333333, 1.07, 0
19619, 1.6916666666667, 1.06, 0
19620, 1.7, 1.07, 0
19621, 1.7083333333333, 1.06, 0
19622, 1.7166666666667, 1.07, 0
19623, 1.725, 1.06, 0
19624, 1.7333333333333, 1.07, 0
19625, 1.7416666666667, 1.06, 0
19626, 1.75, 1.07, 0
19627, 1.7583333333333, 1.06, 0
19628, 1.7666666666667, 1.07, 0
19629, 1.775, 1.06, 0
19630, 1.7833333333333, 1.07, 0
19631, 1.7916666666667, 1.06, 0
19632, 1.8, 1.07, 0
19633, 1.8083333333333, 1.06, 0
19634, 1.8166666666667, 1.07, 0
19635, 1.825, 1.06, 0
19636, 1.8333333333333, 1.07, 0
19637, 1.8416666666667, 1.06, 0
19638, 1.85, 1.07, 0
19639, 1.8583333333333, 1.06, 0
19640, 1.8666666666667, 1.07, 0
19641, 1.875, 1.06, 0
19642, 1.8833333333333, 1.07, 0
19643, 1.8916666666667, 1.06, 0
19644, 1.9, 1.07, 0
19645, 1.9083333333333, 1.06, 0
19646, 1.9166666666667, 1.07, 0
19647, 1.925, 1.06, 0
19648, 1.9333333333333, 1.07, 0
19649, 1.9416666666667, 1.06, 0
19650, 1.95, 1.07, 0
19651, 1.9583333333333, 1.06, 0
19652, 1.9666666666667, 1.07, 0
19653, 1.975, 1.06, 0
19654, 1.9833333333333, 1.07, 0
19655, 1.9916666666667, 1.06, 0
19656, 2, 1.07, 0
19657, 2.0083333333333, 1.06, 0
19658, 2.0166666666667, 1.07, 0
19659, 2.025, 1.06, 0
19660, 2.0333333333333, 1.07, 0
19661, 2.0416666666667, 1.06, 0
19662, 2.05, 1.07, 0
19663, 2.0583333333333, 1.06, 0
19664, 2.0666666666667, 1.07, 0
19665, 2.075, 1.06, 0
19666, 2.0833333333333, 1.07, 0
19667, 2.0916666666667, 1.06, 0
19668, 2.1, 1.07, 0
19669, 2.1083333333333, 1.06, 0
19670, 2.1166666666667, 1.07, 0
19671, 2.125, 1.06, 0
19672, 2.1333333333333, 1.07, 0
19673, 2.1416666666667, 1.06, 0
19674, 2.15, 1.07, 0
19675, 2.1583333333333, 1.06, 0
19676, 2.1666666666667, 1.07, 0
19677, 2.175, 1.06, 0
19678, 2.1833333333333, 1.07, 0
19679, 2.1916666666667, 1.06, 0
19680, 1.2083333333333, 1.04, 0
19681, 1.2166666666667, 1.05, 0
19682, 1.225, 1.04, 0
19683, 1.2333333333333, 1.05, 0
19684, 1.2416666666667, 1.04, 0
19685, 1.25, 1.05, 0
19686, 1.2583333333333, 1.04, 0
19687, 1.2666666666667, 1.05, 0
19688, 1.275, 1.04, 0
19689, 1.2833333333333, 1.05, 0
19690, 1.2916666666667, 1.04, 0
19691, 1.3, 1.05, 0
19692, 1.3083333333333, 1.04, 0
19693, 1.3166666666667, 1.05, 0
19694, 1.325, 1.04, 0
19695, 1.3333333333333, 1.05, 0
19696, 1.3416666666667, 1.04, 0
19697, 1.35, 1.05, 0
19698, 1.3583333333333, 1.04, 0
19699, 1.3666666666667, 1.05, 0
19700, 1.375, 1.04, 0
19701, 1.3833333333333, 1.05, 0
19702, 1.3916666666667, 1.04, 0
19703, 1.4, 1.05, 0
19704, 1.4083333333333, 1.04, 0
19705, 1.4166666666667, 1.05, 0
19706, 1.425, 1.04, 0
19707, 1.4333333333333, 1.05, 0
19708, 1.4416666666667, 1.04, 0
19709, 1.45, 1.05, 0
19710, 1.4583333333333, 1.04, 0
19711, 1.4666666666667, 1.05, 0
19712, 1.475, 1.04, 0
19713, 1.4833333333333, 1.05, 0
19714, 1.4916666666667, 1.04, 0
19715, 1.5, 1.05, 0
19716, 1.5083333333333, 1.04, 0
19717, 1.5166666666667, 1.05, 0
19718, 1.525, 1.04, 0
19719, 1.5333333333333, 1.05, 0
19720, 1.5416666666667, 1.04, 0
19721, 1.55, 1.05, 0
19722, 1.5583333333333, 1.04, 0
19723, 1.5666666666667, 1.05, 0
19724, 1.575, 1.04, 0
19725, 1.5833333333333, 1.05, 0
19726, 1.5916666666667, 1.04, 0
19727, 1.6, 1.05, 0
19728, 1.6083333333333, 1.04, 0
19729, 1.6166666666667, 1.05, 0
19730, 1.625, 1.04, 0
19731, 1.6333333333333, 1.05, 0
19732, 1.6416666666667, 1.04, 0
19733, 1.65, 1.05, 0
19734, 1.6583333333333, 1.04, 0
19735, 1.6666666666667, 1.05, 0
19736, 1.675, 1.04, 0
19737, 1.6833333333333, 1.05, 0
19738, 1.6916666666667, 1.04, 0
19739, 1.7, 1.05, 0
19740, 1.7083333333333, 1.04, 0
19741, 1.7166666666667, 1.05, 0
19742, 1.725, 1.04, 0
19743, 1.7333333333333, 1.05, 0
19744, 1.7416666666667, 1.04, 0
19745, 1.75, 1.05, 0
19746, 1.7583333333333, 1.04, 0
19747, 1.7666666666667, 1.05, 0
19748, 1.775, 1.04, 0
19749, 1.7833333333333, 1.05, 0
19750, 1.7916666666667, 1.04, 0
19751, 1.8, 1.05, 0
19752, 1.8083333333333, 1.04, 0
19753, 1.8166666666667, 1.05, 0
19754, 1.825, 1.04, 0
19755, 1.8333333333333, 1.05, 0
19756, 1.8416666666667, 1.04, 0
19757, 1.85, 1.05, 0
19758, 1.8583333333333, 1.04, 0
19759, 1.8666666666667, 1.05, 0
19760, 1.875, 1.04, 0
19761, 1.8833333333333, 1.05, 0
19762, 1.8916666666667, 1.04, 0
19763, 1.9, 1.05, 0
19764, 1.9083333333333, 1.04, 0
19765, 1.9166666666667, 1.05, 0
19766, 1.925, 1.04, 0
19767, 1.9333333333333, 1.05, 0
19768, 1.9416666666667, 1.04, 0
19769, 1.95, 1.05, 0
19770, 1.9583333333333, 1.04, 0
19771, 1.9666666666667, 1.05, 0
19772, 1.975, 1.04, 0
19773, 1.9833333333333, 1.05, 0
19774, 1.9916666666667, 1.04, 0
19775, 2, 1.05, 0
19776, 2.0083333333333, 1.04, 0
19777, 2.0166666666667, 1.05, 0
19778, 2.025, 1.04, 0
19779, 2.0333333333333, 1.05, 0
19780, 2.0416666666667, 1.04, 0
19781, 2.05, 1.05, 0
19782, 2.0583333333333, 1.04, 0
19783, 2.0666666666667, 1.05, 0
19784, 2.075, 1.04, 0
19785, 2.0833333333333, 1.05, 0
19786, 2.0916666666667, 1.04, 0
19787, 2.1, 1.05, 0
19788, 2.1083333333333, 1.04, 0
19789, 2.1166666666667, 1.05, 0
19790, 2.125, 1.04, 0
19791, 2.1333333333333, 1.05, 0
19792, 2.1416666666667, 1.04, 0
19793, 2.15, 1.05, 0
19794, 2.1583333333333, 1.04, 0
19795, 2.1666666666667, 1.05, 0
19796, 2.175, 1.04, 0
19797, 2.1833333333333, 1.05, 0
19798, 2.1916666666667, 1.04, 0
19799, 1.2083333333333, 1.02, 0
19800, 1.2166666666667, 1.03, 0
19801, 1.225, 1.02, 0
19802, 1.2333333333333, 1.03, 0
19803, 1.2416666666667, 1.02, 0
19804, 1.25, 1.03, 0
19805, 1.2583333333333, 1.02, 0
19806, 1.2666666666667, 1.03, 0
19807, 1.275, 1.02, 0
19808, 1.2833333333333, 1.03, 0
19809, 1.2916666666667, 1.02, 0
19810, 1.3, 1.03, 0
19811, 1.3083333333333, 1.02, 0
19812, 1.3166666666667, 1.03, 0
19813, 1.325, 1.02, 0
19814, 1.3333333333333, 1.03, 0
19815, 1.3416666666667, 1.02, 0
19816, 1.35, 1.03, 0
19817, 1.3583333333333, 1.02, 0
19818, 1.3666666666667, 1.03, 0
19819, 1.375, 1.02, 0
19820, 1.3833333333333, 1.03, 0
19821, 1.3916666666667, 1.02, 0
19822, 1.4, 1.03, 0
19823, 1.4083333333333, 1.02, 0
19824, 1.4166666666667, 1.03, 0
19825, 1.425, 1.02, 0
19826, 1.4333333333333, 1.03, 0
19827, 1.4416666666667, 1.02, 0
19828, 1.45, 1.03, 0
19829, 1.4583333333333, 1.02, 0
19830, 1.4666666666667, 1.03, 0
19831, 1.475, 1.02, 0
19832, 1.4833333333333, 1.03, 0
19833, 1.4916666666667, 1.02, 0
19834, 1.5, 1.03, 0
19835, 1.5083333333333, 1.02, 0
19836, 1.5166666666667, 1.03, 0
19837, 1.525, 1.02, 0
19838, 1.5333333333333, 1.03, 0
19839, 1.5416666666667, 1.02, 0
19840, 1.55, 1.03, 0
19841, 1.5583333333333, 1.02, 0
19842, 1.5666666666667, 1.03, 0
19843, 1.575, 1.02, 0
19844, 1.5833333333333, 1.03, 0
19845, 1.5916666666667, 1.02, 0
19846, 1.6, 1.03, 0
19847, 1.6083333333333, 1.02, 0
19848, 1.6166666666667, 1.03, 0
19849, 1.625, 1.02, 0
19850, 1.6333333333333, 1.03, 0
19851, 1.6416666666667, 1.02, 0
19852, 1.65, 1.03, 0
19853, 1.6583333333333, 1.02, 0
19854, 1.6666666666667, 1.03, 0
19855, 1.675, 1.02, 0
19856, 1.6833333333333, 1.03, 0
19857, 1.6916666666667, 1.02, 0
19858, 1.7, 1.03, 0
19859, 1.7083333333333, 1.02, 0
19860, 1.7166666666667, 1.03, 0
19861, 1.725, 1.02, 0
19862, 1.7333333333333, 1.03, 0
19863, 1.7416666666667, 1.02, 0
19864, 1.75, 1.03, 0
19865, 1.7583333333333, 1.02, 0
19866, 1.7666666666667, 1.03, 0
19867, 1.775, 1.02, 0
19868, 1.7833333333333, 1.03, 0
19869, 1.7916666666667, 1.02, 0
19870, 1.8, 1.03, 0
19871, 1.8083333333333, 1.02, 0
19872, 1.8166666666667, 1.03, 0
19873, 1.825, 1.02, 0
19874, 1.8333333333333, 1.03, 0
19875, 1.8416666666667, 1.02, 0
19876, 1.85, 1.03, 0
19877, 1.8583333333333, 1.02, 0
19878, 1.8666666666667, 1.03, 0
19879, 1.875, 1.02, 0
19880, 1.8833333333333, 1.03, 0
19881, 1.8916666666667, 1.02, 0
19882, 1.9, 1.03, 0
19883, 1.9083333333333, 1.02, 0
19884, 1.9166666666667, 1.03, 0
19885, 1.925, 1.02, 0
19886, 1.9333333333333, 1.03, 0
19887, 1.9416666666667, 1.02, 0
19888, 1.95, 1.03, 0
19889, 1.9583333333333, 1.02, 0
19890, 1.9666666666667, 1.03, 0
19891, 1.975, 1.02, 0
19892, 1.9833333333333, 1.03, 0
19893, 1.9916666666667, 1.02, 0
19894, 2, 1.03, 0
19895, 2.0083333333333, 1.02, 0
19896, 2.0166666666667, 1.03, 0
19897, 2.025, 1.02, 0
19898, 2.0333333333333, 1.03, 0
19899, 2.0416666666667, 1.02, 0
19900, 2.05, 1.03, 0
19901, 2.0583333333333, 1.02, 0
19902, 2.0666666666667, 1.03, 0
19903, 2.075, 1.02, 0
19904, 2.0833333333333, 1.03, 0
19905, 2.0916666666667, 1.02, 0
19906, 2.1, 1.03, 0
19907, 2.1083333333333, 1.02, 0
19908, 2.1166666666667, 1.03, 0
19909, 2.125, 1.02, 0
19910, 2.1333333333333, 1.03, 0
19911, 2.1416666666667, 1.02, 0
19912, 2.15, 1.03, 0
19913, 2.1583333333333, 1.02, 0
19914, 2.1666666666667, 1.03, 0
19915, 2.175, 1.02, 0
19916, 2.1833333333333, 1.03, 0
19917, 2.1916666666667, 1.02, 0
19918, 1.2083333333333, 1, 0
19919, 1.2166666666667, 1.01, 0
19920, 1.225, 1, 0
19921, 1.2333333333333, 1.01, 0
19922, 1.2416666666667, 1, 0
19923, 1.25, 1.01, 0
19924, 1.2583333333333, 1, 0
19925, 1.2666666666667, 1.01, 0
19926, 1.275, 1, 0
19927, 1.2833333333333, 1.01, 0
19928, 1.2916666666667, 1, 0
19929, 1.3, 1.01, 0
19930, 1.3083333333333, 1, 0
19931, 1.3166666666667, 1.01, 0
19932, 1.325, 1, 0
19933, 1.3333333333333, 1.01, 0
19934, 1.3416666666667, 1, 0
19935, 1.35, 1.01, 0
19936, 1.3583333333333, 1, 0
19937, 1.3666666666667, 1.01, 0
19938, 1.375, 1, 0
19939, 1.3833333333333, 1.01, 0
19940, 1.3916666666667, 1, 0
19941, 1.4, 1.01, 0
19942, 1.4083333333333, 1, 0
19943, 1.4166666666667, 1.01, 0
19944, 1.425, 1, 0
19945, 1.4333333333333, 1.01, 0
19946, 1.4416666666667, 1, 0
19947, 1.45, 1.01, 0
19948, 1.4583333333333, 1, 0
19949, 1.4666666666667, 1.01, 0
19950, 1.475, 1, 0
19951, 1.4833333333333, 1.01, 0
19952, 1.4916666666667, 1, 0
19953, 1.5, 1.01, 0
19954, 1.5083333333333, 1, 0
19955, 1.5166666666667, 1.01, 0
19956, 1.525, 1, 0
19957, 1.5333333333333, 1.01, 0
19958, 1.5416666666667, 1, 0
19959, 1.55, 1.01, 0
19960, 1.5583333333333, 1, 0
19961, 1.5666666666667, 1.01, 0
19962, 1.575, 1, 0
19963, 1.5833333333333, 1.01, 0
19964, 1.5916666666667, 1, 0
19965, 1.6, 1.01, 0
19966, 1.6083333333333, 1, 0
19967, 1.6166666666667, 1.01, 0
19968, 1.625, 1, 0
19969, 1.6333333333333, 1.01, 0
19970, 1.6416666666667, 1, 0
19971, 1.65, 1.01, 0
19972, 1.6583333333333, 1, 0
19973, 1.6666666666667, 1.01, 0
19974, 1.675, 1, 0
19975, 1.6833333333333, 1.01, 0
19976, 1.6916666666667, 1, 0
19977, 1.7, 1.01, 0
19978, 1.7083333333333, 1, 0
19979, 1.7166666666667, 1.01, 0
19980, 1.725, 1, 0
19981, 1.7333333333333, 1.01, 0
19982, 1.7416666666667, 1, 0
19983, 1.75, 1.01, 0
19984, 1.7583333333333, 1, 0
19985, 1.7666666666667, 1.01, 0
19986, 1.775, 1, 0
19987, 1.7833333333333, 1.01, 0
19988, 1.7916666666667, 1, 0
19989, 1.8, 1.01, 0
19990, 1.8083333333333, 1, 0
19991, 1.8166666666667, 1.01, 0
19992, 1.825, 1, 0
19993, 1.8333333333333, 1.01, 0
19994, 1.8416666666667, 1, 0
19995, 1.85, 1.01, 0
19996, 1.8583333333333, 1, 0
19997, 1.8666666666667, 1.01, 0
19998, 1.875, 1, 0
19999, 1.8833333333333, 1.01, 0
20000, 1.8916666666667, 1, 0
20001, 1.9, 1.01, 0
20002, 1.9083333333333, 1, 0
20003, 1.9166666666667, 1.01, 0
20004, 1.925, 1, 0
20005, 1.9333333333333, 1.01, 0
20006, 1.9416666666667, 1, 0
20007, 1.95, 1.01, 0
20008, 1.9583333333333, 1, 0
20009, 1.9666666666667, 1.01, 0
20010, 1.975, 1, 0
20011, 1.9833333333333, 1.01, 0
20012, 1.9916666666667, 1, 0
20013, 2, 1.01, 0
20014, 2.0083333333333, 1, 0
20015, 2.0166666666667, 1.01, 0
20016, 2.025, 1, 0
20017, 2.0333333333333, 1.01, 0
20018, 2.0416666666667, 1, 0
20019, 2.05, 1.01, 0
20020, 2.0583333333333, 1, 0
20021, 2.0666666666667, 1.01, 0
20022, 2.075, 1, 0
20023, 2.0833333333333, 1.01, 0
20024, 2.0916666666667, 1, 0
20025, 2.1, 1.01, 0
20026, 2.1083333333333, 1, 0
20027, 2.1166666666667, 1.01, 0
20028, 2.125, 1, 0
20029, 2.1333333333333, 1.01, 0
20030, 2.1416666666667, 1, 0
20031, 2.15, 1.01, 0
20032, 2.1583333333333, 1, 0
20033, 2.1666666666667, 1.01, 0
20034, 2.175, 1, 0
20035, 2.1833333333333, 1.01, 0
20036, 2.1916666666667, 1, 0
20037, 1.2083333333333, 0.98, 0
20038, 1.2166666666667, 0.99, 0
20039, 1.225, 0.98, 0
20040, 1.2333333333333, 0.99, 0
20041, 1.2416666666667, 0.98, 0
20042, 1.25, 0.99, 0
20043, 1.2583333333333, 0.98, 0
20044, 1.2666666666667, 0.99, 0
20045, 1.275, 0.98, 0
20046, 1.2833333333333, 0.99, 0
20047, 1.2916666666667, 0.98, 0
20048, 1.3, 0.99, 0
20049, 1.3083333333333, 0.98, 0
20050, 1.3166666666667, 0.99, 0
20051, 1.325, 0.98, 0
20052, 1.3333333333333, 0.99, 0
20053, 1.3416666666667, 0.98, 0
20054, 1.35, 0.99, 0
20055, 1.3583333333333, 0.98, 0
20056, 1.3666666666667, 0.99, 0
20057, 1.375, 0.98, 0
20058, 1.3833333333333, 0.99, 0
20059, 1.3916666666667, 0.98, 0
20060, 1.4, 0.99, 0
20061, 1.4083333333333, 0.98, 0
20062, 1.4166666666667, 0.99, 0
20063, 1.425, 0.98, 0
20064, 1.4333333333333, 0.99, 0
20065, 1.4416666666667, 0.98, 0
20066, 1.45, 0.99, 0
20067, 1.4583333333333, 0.98, 0
20068, 1.4666666666667, 0.99, 0
20069, 1.475, 0.98, 0
20070, 1.4833333333333, 0.99, 0
20071, 1.4916666666667, 0.98, 0
20072, 1.5, 0.99, 0
20073, 1.5083333333333, 0.98, 0
20074, 1.5166666666667, 0.99, 0
20075, 1.525, 0.98, 0
20076, 1.5333333333333, 0.99, 0
20077, 1.5416666666667, 0.98, 0
20078, 1.55, 0.99, 0
20079, 1.5583333333333, 0.98, 0
20080, 1.5666666666667, 0.99, 0
20081, 1.575, 0.98, 0
20082, 1.5833333333333, 0.99, 0
20083, 1.5916666666667, 0.98, 0
20084, 1.6, 0.99, 0
20085, 1.6083333333333, 0.98, 0
20086, 1.6166666666667, 0.99, 0
20087, 1.625, 0.98, 0
20088, 1.6333333333333, 0.99, 0
20089, 1.6416666666667, 0.98, 0
20090, 1.65, 0.99, 0
20091, 1.6583333333333, 0.98, 0
20092, 1.6666666666667, 0.99, 0
20093, 1.675, 0.98, 0
20094, 1.6833333333333, 0.99, 0
20095, 1.6916666666667, 0.98, 0
20096, 1.7, 0.99, 0
20097, 1.7083333333333, 0.98, 0
20098, 1.7166666666667, 0.99, 0
20099, 1.725, 0.98, 0
20100, 1.7333333333333, 0.99, 0
20101, 1.7416666666667, 0.98, 0
20102, 1.75, 0.99, 0
20103, 1.7583333333333, 0.98, 0
20104, 1.7666666666667, 0.99, 0
20105, 1.775, 0.98, 0
20106, 1.7833333333333, 0.99, 0
20107, 1.7916666666667, 0.98, 0
20108, 1.8, 0.99, 0
20109, 1.8083333333333, 0.98, 0
20110, 1.8166666666667, 0.99, 0
20111, 1.825, 0.98, 0
20112, 1.8333333333333, 0.99, 0
20113, 1.8416666666667, 0.98, 0
20114, 1.85, 0.99, 0
20115, 1.8583333333333, 0.98, 0
20116, 1.8666666666667, 0.99, 0
20117, 1.875, 0.98, 0
20118, 1.8833333333333, 0.99, 0
20119, 1.8916666666667, 0.98, 0
20120, 1.9, 0.99, 0
20121, 1.9083333333333, 0.98, 0
20122, 1.9166666666667, 0.99, 0
20123, 1.925, 0.98, 0
20124, 1.9333333333333, 0.99, 0
20125, 1.9416666666667, 0.98, 0
20126, 1.95, 0.99, 0
20127, 1.9583333333333, 0.98, 0
20128, 1.9666666666667, 0.99, 0
20129, 1.975, 0.98, 0
20130, 1.9833333333333, 0.99, 0
20131, 1.9916666666667, 0.98, 0
20132, 2, 0.99, 0
20133, 2.0083333333333, 0.98, 0
20134, 2.0166666666667, 0.99, 0
20135, 2.025, 0.98, 0
20136, 2.0333333333333, 0.99, 0
20137, 2.0416666666667, 0.98, 0
20138, 2.05, 0.99, 0
20139, 2.0583333333333, 0.98, 0
20140, 2.0666666666667, 0.99, 0
20141, 2.075, 0.98, 0
20142, 2.0833333333333, 0.99, 0
20143, 2.0916666666667, 0.98, 0
20144, 2.1, 0.99, 0
20145, 2.1083333333333, 0.98, 0
20146, 2.1166666666667, 0.99, 0
20147, 2.125, 0.98, 0
20148, 2.1333333333333, 0.99, 0
20149, 2.1416666666667, 0.98, 0
20150, 2.15, 0.99, 0
20151, 2.1583333333333, 0.98, 0
20152, 2.1666666666667, 0.99, 0
20153, 2.175, 0.98, 0
20154, 2.1833333333333, 0.99, 0
20155, 2.1916666666667, 0.98, 0
20156, 1.2083333333333, 0.96, 0
20157, 1.2166666666667, 0.97, 0
20158, 1.225, 0.96, 0
20159, 1.2333333333333, 0.97, 0
20160, 1.2416666666667, 0.96, 0
20161, 1.25, 0.97, 0
20162, 1.2583333333333, 0.96, 0
20163, 1.2666666666667, 0.97, 0
20164, 1.275, 0.96, 0
20165, 1.2833333333333, 0.97, 0
20166, 1.2916666666667, 0.96, 0
20167, 1.3, 0.97, 0
20168, 1.3083333333333, 0.96, 0
20169, 1.3166666666667, 0.97, 0
20170, 1.325, 0.96, 0
20171, 1.3333333333333, 0.97, 0
20172, 1.3416666666667, 0.96, 0
20173, 1.35, 0.97, 0
20174, 1.3583333333333, 0.96, 0
20175, 1.3666666666667, 0.97, 0
20176, 1.375, 0.96, 0
20177, 1.3833333333333, 0.97, 0
20178, 1.3916666666667, 0.96, 0
20179, 1.4, 0.97, 0
20180, 1.4083333333333, 0.96, 0
20181, 1.4166666666667, 0.97, 0
20182, 1.425, 0.96, 0
20183, 1.4333333333333, 0.97, 0
20184, 1.4416666666667, 0.96, 0
20185, 1.45, 0.97, 0
20186, 1.4583333333333, 0.96, 0
20187, 1.4666666666667, 0.97, 0
20188, 1.475, 0.96, 0
20189, 1.4833333333333, 0.97, 0
20190, 1.4916666666667, 0.96, 0
20191, 1.5, 0.97, 0
20192, 1.5083333333333, 0.96, 0
20193, 1.5166666666667, 0.97, 0
20194, 1.525, 0.96, 0
20195, 1.5333333333333, 0.97, 0
20196, 1.5416666666667, 0.96, 0
20197, 1.55, 0.97, 0
20198, 1.5583333333333, 0.96, 0
20199, 1.5666666666667, 0.97, 0
20200, 1.575, 0.96, 0
20201, 1.5833333333333, 0.97, 0
20202, 1.5916666666667, 0.96, 0
20203, 1.6, 0.97, 0
20204, 1.6083333333333, 0.96, 0
20205, 1.6166666666667, 0.97, 0
20206, 1.625, 0.96, 0
20207, 1.6333333333333, 0.97, 0
20208, 1.6416666666667, 0.96, 0
20209, 1.65, 0.97, 0
20210, 1.6583333333333, 0.96, 0
20211, 1.6666666666667, 0.97, 0
20212, 1.675, 0.96, 0
20213, 1.6833333333333, 0.97, 0
20214, 1.6916666666667, 0.96, 0
20215, 1.7, 0.97, 0
20216, 1.7083333333333, 0.96, 0
20217, 1.7166666666667, 0.97, 0
20218, 1.725, 0.96, 0
20219, 1.7333333333333, 0.97, 0
20220, 1.7416666666667, 0.96, 0
20221, 1.75, 0.97, 0
20222, 1.7583333333333, 0.96, 0
20223, 1.7666666666667, 0.97, 0
20224, 1.775, 0.96, 0
20225, 1.7833333333333, 0.97, 0
20226, 1.7916666666667, 0.96, 0
20227, 1.8, 0.97, 0
20228, 1.8083333333333, 0.96, 0
20229, 1.8166666666667, 0.97, 0
20230, 1.825, 0.96, 0
20231, 1.8333333333333, 0.97, 0
20232, 1.8416666666667, 0.96, 0
20233, 1.85, 0.97, 0
20234, 1.8583333333333, 0.96, 0
20235, 1.8666666666667, 0.97, 0
20236, 1.875, 0.96, 0
20237, 1.8833333333333, 0.97, 0
20238, 1.8916666666667, 0.96, 0
20239, 1.9, 0.97, 0
20240, 1.9083333333333, 0.96, 0
20241, 1.9166666666667, 0.97, 0
20242, 1.925, 0.96, 0
20243, 1.9333333333333, 0.97, 0
20244, 1.9416666666667, 0.96, 0
20245, 1.95, 0.97, 0
20246, 1.9583333333333, 0.96, 0
20247, 1.9666666666667, 0.97, 0
20248, 1.975, 0.96, 0
20249, 1.9833333333333, 0.97, 0
20250, 1.9916666666667, 0.96, 0
20251, 2, 0.97, 0
20252, 2.0083333333333, 0.96, 0
20253, 2.0166666666667, 0.97, 0
20254, 2.025, 0.96, 0
20255, 2.0333333333333, 0.97, 0
20256, 2.0416666666667, 0.96, 0
20257, 2.05, 0.97, 0
20258, 2.0583333333333, 0.96, 0
20259, 2.0666666666667, 0.97, 0
20260, 2.075, 0.96, 0
20261, 2.0833333333333, 0.97, 0
20262, 2.0916666666667, 0.96, 0
20263, 2.1, 0.97, 0
20264, 2.1083333333333, 0.96, 0
20265, 2.1166666666667, 0.97, 0
20266, 2.125, 0.96, 0
20267, 2.1333333333333, 0.97, 0
20268, 2.1416666666667, 0.96, 0
20269, 2.15, 0.97, 0
20270, 2.1583333333333, 0.96, 0
20271, 2.1666666666667, 0.97, 0
20272, 2.175, 0.96, 0
20273, 2.1833333333333, 0.97, 0
20274, 2.1916666666667, 0.96, 0
20275, 1.2083333333333, 0.94, 0
20276, 1.2166666666667, 0.95, 0
20277, 1.225, 0.94, 0
20278, 1.2333333333333, 0.95, 0
20279, 1.2416666666667, 0.94, 0
20280, 1.25, 0.95, 0
20281, 1.2583333333333, 0.94, 0
20282, 1.2666666666667, 0.95, 0
20283, 1.275, 0.94, 0
20284, 1.2833333333333, 0.95, 0
20285, 1.2916666666667, 0.94, 0
20286, 1.3, 0.95, 0
20287, 1.3083333333333, 0.94, 0
20288, 1.3166666666667, 0.95, 0
20289, 1.325, 0.94, 0
20290, 1.3333333333333, 0.95, 0
20291, 1.3416666666667, 0.94, 0
20292, 1.35, 0.95, 0
20293, 1.3583333333333, 0.94, 0
20294, 1.3666666666667, 0.95, 0
20295, 1.375, 0.94, 0
20296, 1.3833333333333, 0.95, 0
20297, 1.3916666666667, 0.94, 0
20298, 1.4, 0.95, 0
20299, 1.4083333333333, 0.94, 0
20300, 1.4166666666667, 0.95, 0
20301, 1.425, 0.94, 0
20302, 1.4333333333333, 0.95, 0
20303, 1.4416666666667, 0.94, 0
20304, 1.45, 0.95, 0
20305, 1.4583333333333, 0.94, 0
20306, 1.4666666666667, 0.95, 0
20307, 1.475, 0.94, 0
20308, 1.4833333333333, 0.95, 0
20309, 1.4916666666667, 0.94, 0
20310, 1.5, 0.95, 0
20311, 1.5083333333333, 0.94, 0
20312, 1.5166666666667, 0.95, 0
20313, 1.525, 0.94, 0
20314, 1.5333333333333, 0.95, 0
20315, 1.5416666666667, 0.94, 0
20316, 1.55, 0.95, 0
20317, 1.5583333333333, 0.94, 0
20318, 1.5666666666667, 0.95, 0
20319, 1.575, 0.94, 0
20320, 1.5833333333333, 0.95, 0
20321, 1.5916666666667, 0.94, 0
20322, 1.6, 0.95, 0
20323, 1.6083333333333, 0.94, 0
20324, 1.6166666666667, 0.95, 0
20325, 1.625, 0.94, 0
20326, 1.6333333333333, 0.95, 0
20327, 1.6416666666667, 0.94, 0
20328, 1.65, 0.95, 0
20329, 1.6583333333333, 0.94, 0
20330, 1.6666666666667, 0.95, 0
20331, 1.675, 0.94, 0
20332, 1.6833333333333, 0.95, 0
20333, 1.6916666666667, 0.94, 0
20334, 1.7, 0.95, 0
20335, 1.7083333333333, 0.94, 0
20336, 1.7166666666667, 0.95, 0
20337, 1.725, 0.94, 0
20338, 1.7333333333333, 0.95, 0
20339, 1.7416666666667, 0.94, 0
20340, 1.75, 0.95, 0
20341, 1.7583333333333, 0.94, 0
20342, 1.7666666666667, 0.95, 0
20343, 1.775, 0.94, 0
20344, 1.7833333333333, 0.95, 0
20345, 1.7916666666667, 0.94, 0
20346, 1.8, 0.95, 0
20347, 1.8083333333333, 0.94, 0
20348, 1.8166666666667, 0.95, 0
20349, 1.825, 0.94, 0
20350, 1.8333333333333, 0.95, 0
20351, 1.8416666666667, 0.94, 0
20352, 1.85, 0.95, 0
20353, 1.8583333333333, 0.94, 0
20354, 1.8666666666667, 0.95, 0
20355, 1.875, 0.94, 0
20356, 1.8833333333333, 0.95, 0
20357, 1.8916666666667, 0.94, 0
20358, 1.9, 0.95, 0
20359, 1.9083333333333, 0.94, 0
20360, 1.9166666666667, 0.95, 0
20361, 1.925, 0.94, 0
20362, 1.9333333333333, 0.95, 0
20363, 1.9416666666667, 0.94, 0
20364, 1.95, 0.95, 0
20365, 1.9583333333333, 0.94, 0
20366, 1.9666666666667, 0.95, 0
20367, 1.975, 0.94, 0
20368, 1.9833333333333, 0.95, 0
20369, 1.9916666666667, 0.94, 0
20370, 2, 0.95, 0
20371, 2.0083333333333, 0.94, 0
20372, 2.0166666666667, 0.95, 0
20373, 2.025, 0.94, 0
20374, 2.0333333333333, 0.95, 0
20375, 2.0416666666667, 0.94, 0
20376, 2.05, 0.95, 0
20377, 2.0583333333333, 0.94, 0
20378, 2.0666666666667, 0.95, 0
20379, 2.075, 0.94, 0
20380, 2.0833333333333, 0.95, 0
20381, 2.0916666666667, 0.94, 0
20382, 2.1, 0.95, 0
20383, 2.1083333333333, 0.94, 0
20384, 2.1166666666667, 0.95, 0
20385, 2.125, 0.94, 0
20386, 2.1333333333333, 0.95, 0
20387, 2.1416666666667, 0.94, 0
20388, 2.15, 0.95, 0
20389, 2.1583333333333, 0.94, 0
20390, 2.1666666666667, 0.95, 0
20391, 2.175, 0.94, 0
20392, 2.1833333333333, 0.95, 0
20393, 2.1916666666667, 0.94, 0
20394, 1.2083333333333, 0.92, 0
20395, 1.2166666666667, 0.93, 0
20396, 1.225, 0.92, 0
20397, 1.2333333333333, 0.93, 0
20398, 1.2416666666667, 0.92, 0
20399, 1.25, 0.93, 0
20400, 1.2583333333333, 0.92, 0
20401, 1.2666666666667, 0.93, 0
20402, 1.275, 0.92, 0
20403, 1.2833333333333, 0.93, 0
20404, 1.2916666666667, 0.92, 0
20405, 1.3, 0.93, 0
20406, 1.3083333333333, 0.92, 0
20407, 1.3166666666667, 0.93, 0
20408, 1.325, 0.92, 0
20409, 1.3333333333333, 0.93, 0
20410, 1.3416666666667, 0.92, 0
20411, 1.35, 0.93, 0
20412, 1.3583333333333, 0.92, 0
20413, 1.3666666666667, 0.93, 0
20414, 1.375, 0.92, 0
20415, 1.3833333333333, 0.93, 0
20416, 1.3916666666667, 0.92, 0
20417, 1.4, 0.93, 0
20418, 1.4083333333333, 0.92, 0
20419, 1.4166666666667, 0.93, 0
20420, 1.425, 0.92, 0
20421, 1.4333333333333, 0.93, 0
20422, 1.4416666666667, 0.92, 0
20423, 1.45, 0.93, 0
20424, 1.4583333333333, 0.92, 0
20425, 1.4666666666667, 0.93, 0
20426, 1.475, 0.92, 0
20427, 1.4833333333333, 0.93, 0
20428, 1.4916666666667, 0.92, 0
20429, 1.5, 0.93, 0
20430, 1.5083333333333, 0.92, 0
20431, 1.5166666666667, 0.93, 0
20432, 1.525, 0.92, 0
20433, 1.5333333333333, 0.93, 0
20434, 1.5416666666667, 0.92, 0
20435, 1.55, 0.93, 0
20436, 1.5583333333333, 0.92, 0
20437, 1.5666666666667, 0.93, 0
20438, 1.575, 0.92, 0
20439, 1.5833333333333, 0.93, 0
20440, 1.5916666666667, 0.92, 0
20441, 1.6, 0.93, 0
20442, 1.6083333333333, 0.92, 0
20443, 1.6166666666667, 0.93, 0
20444, 1.625, 0.92, 0
20445, 1.6333333333333, 0.93, 0
20446, 1.6416666666667, 0.92, 0
20447, 1.65, 0.93, 0
20448, 1.6583333333333, 0.92, 0
20449, 1.6666666666667, 0.93, 0
20450, 1.675, 0.92, 0
20451, 1.6833333333333, 0.93, 0
20452, 1.6916666666667, 0.92, 0
20453, 1.7, 0.93, 0
20454, 1.7083333333333, 0.92, 0
20455, 1.7166666666667, 0.93, 0
20456, 1.725, 0.92, 0
20457, 1.7333333333333, 0.93, 0
20458, 1.7416666666667, 0.92, 0
20459, 1.75, 0.93, 0
20460, 1.7583333333333, 0.92, 0
20461, 1.7666666666667, 0.93, 0
20462, 1.775, 0.92, 0
20463, 1.7833333333333, 0.93, 0
20464, 1.7916666666667, 0.92, 0
20465, 1.8, 0.93, 0
20466, 1.8083333333333, 0.92, 0
20467, 1.8166666666667, 0.93, 0
20468, 1.825, 0.92, 0
20469, 1.8333333333333, 0.93, 0
20470, 1.8416666666667, 0.92, 0
20471, 1.85, 0.93, 0
20472, 1.8583333333333, 0.92, 0
20473, 1.8666666666667, 0.93, 0
20474, 1.875, 0.92, 0
20475, 1.8833333333333, 0.93, 0
20476, 1.8916666666667, 0.92, 0
20477, 1.9, 0.93, 0
20478, 1.9083333333333, 0.92, 0
20479, 1.9166666666667, 0.93, 0
20480, 1.925, 0.92, 0
20481, 1.9333333333333, 0.93, 0
20482, 1.9416666666667, 0.92, 0
20483, 1.95, 0.93, 0
20484, 1.9583333333333, 0.92, 0
20485, 1.9666666666667, 0.93, 0
20486, 1.975, 0.92, 0
20487, 1.9833333333333, 0.93, 0
20488, 1.9916666666667, 0.92, 0
20489, 2, 0.93, 0
20490, 2.0083333333333, 0.92, 0
20491, 2.0166666666667, 0.93, 0
20492, 2.025, 0.92, 0
20493, 2.0333333333333, 0.93, 0
20494, 2.0416666666667, 0.92, 0
20495, 2.05, 0.93, 0
20496, 2.0583333333333, 0.92, 0
20497, 2.0666666666667, 0.93, 0
20498, 2.075, 0.92, 0
20499, 2.0833333333333, 0.93, 0
20500, 2.0916666666667, 0.92, 0
20501, 2.1, 0.93, 0
20502, 2.1083333333333, 0.92, 0
20503, 2.1166666666667, 0.93, 0
20504, 2.125, 0.92, 0
20505, 2.1333333333333, 0.93, 0
20506, 2.1416666666667, 0.92, 0
20507, 2.15, 0.93, 0
20508, 2.1583333333333, 0.92, 0
20509, 2.1666666666667, 0.93, 0
20510, 2.175, 0.92, 0
20511, 2.1833333333333, 0.93, 0
20512, 2.1916666666667, 0.92, 0
20513, 1.2083333333333, 0.9, 0
20514, 1.2166666666667, 0.91, 0
20515, 1.225, 0.9, 0
20516, 1.2333333333333, 0.91, 0
20517, 1.2416666666667, 0.9, 0
20518, 1.25, 0.91, 0
20519, 1.2583333333333, 0.9, 0
20520, 1.2666666666667, 0.91, 0
20521, 1.275, 0.9, 0
20522, 1.2833333333333, 0.91, 0
20523, 1.2916666666667, 0.9, 0
20524, 1.3, 0.91, 0
20525, 1.3083333333333, 0.9, 0
20526, 1.3166666666667, 0.91, 0
20527, 1.325, 0.9, 0
20528, 1.3333333333333, 0.91, 0
20529, 1.3416666666667, 0.9, 0
20530, 1.35, 0.91, 0
20531, 1.3583333333333, 0.9, 0
20532, 1.3666666666667, 0.91, 0
20533, 1.375, 0.9, 0
20534, 1.3833333333333, 0.91, 0
20535, 1.3916666666667, 0.9, 0
20536, 1.4, 0.91, 0
20537, 1.4083333333333, 0.9, 0
20538, 1.4166666666667, 0.91, 0
20539, 1.425, 0.9, 0
20540, 1.4333333333333, 0.91, 0
20541, 1.4416666666667, 0.9, 0
20542, 1.45, 0.91, 0
20543, 1.4583333333333, 0.9, 0
20544, 1.4666666666667, 0.91, 0
20545, 1.475, 0.9, 0
20546, 1.4833333333333, 0.91, 0
20547, 1.4916666666667, 0.9, 0
20548, 1.5, 0.91, 0
20549, 1.5083333333333, 0.9, 0
20550, 1.5166666666667, 0.91, 0
20551, 1.525, 0.9, 0
20552, 1.5333333333333, 0.91, 0
20553, 1.5416666666667, 0.9, 0
20554, 1.55, 0.91, 0
20555, 1.5583333333333, 0.9, 0
20556, 1.5666666666667, 0.91, 0
20557, 1.575, 0.9, 0
20558, 1.5833333333333, 0.91, 0
20559, 1.5916666666667, 0.9, 0
20560, 1.6, 0.91, 0
20561, 1.6083333333333, 0.9, 0
20562, 1.6166666666667, 0.91, 0
20563, 1.625, 0.9, 0
20564, 1.6333333333333, 0.91, 0
20565, 1.6416666666667, 0.9, 0
20566, 1.65, 0.91, 0
20567, 1.6583333333333, 0.9, 0
20568, 1.6666666666667, 0.91, 0
20569, 1.675, 0.9, 0
20570, 1.6833333333333, 0.91, 0
20571, 1.6916666666667, 0.9, 0
20572, 1.7, 0.91, 0
20573, 1.7083333333333, 0.9, 0
20574, 1.7166666666667, 0.91, 0
20575, 1.725, 0.9, 0
20576, 1.7333333333333, 0.91, 0
20577, 1.7416666666667, 0.9, 0
20578, 1.75, 0.91, 0
20579, 1.7583333333333, 0.9, 0
20580, 1.7666666666667, 0.91, 0
20581, 1.775, 0.9, 0
20582, 1.7833333333333, 0.91, 0
20583, 1.7916666666667, 0.9, 0
20584, 1.8, 0.91, 0
20585, 1.8083333333333, 0.9, 0
20586, 1.8166666666667, 0.91, 0
20587, 1.825, 0.9, 0
20588, 1.8333333333333, 0.91, 0
20589, 1.8416666666667, 0.9, 0
20590, 1.85, 0.91, 0
20591, 1.8583333333333, 0.9, 0
20592, 1.8666666666667, 0.91, 0
20593, 1.875, 0.9, 0
20594, 1.8833333333333, 0.91, 0
20595, 1.8916666666667, 0.9, 0
20596, 1.9, 0.91, 0
20597, 1.9083333333333, 0.9, 0
20598, 1.9166666666667, 0.91, 0
20599, 1.925, 0.9, 0
20600, 1.9333333333333, 0.91, 0
20601, 1.9416666666667, 0.9, 0
20602, 1.95, 0.91, 0
20603, 1.9583333333333, 0.9, 0
20604, 1.9666666666667, 0.91, 0
20605, 1.975, 0.9, 0
20606, 1.9833333333333, 0.91, 0
20607, 1.9916666666667, 0.9, 0
20608, 2, 0.91, 0
20609, 2.0083333333333, 0.9, 0
20610, 2.0166666666667, 0.91, 0
20611, 2.025, 0.9, 0
20612, 2.0333333333333, 0.91, 0
20613, 2.0416666666667, 0.9, 0
20614, 2.05, 0.91, 0
20615, 2.0583333333333, 0.9, 0
20616, 2.0666666666667, 0.91, 0
20617, 2.075, 0.9, 0
20618, 2.0833333333333, 0.91, 0
20619, 2.0916666666667, 0.9, 0
20620, 2.1, 0.91, 0
20621, 2.1083333333333, 0.9, 0
20622, 2.1166666666667, 0.91, 0
20623, 2.125, 0.9, 0
20624, 2.1333333333333, 0.91, 0
20625, 2.1416666666667, 0.9, 0
20626, 2.15, 0.91, 0
20627, 2.1583333333333, 0.9, 0
20628, 2.1666666666667, 0.91, 0
20629, 2.175, 0.9, 0
20630, 2.1833333333333, 0.91, 0
20631, 2.1916666666667, 0.9, 0
20632, 1.2083333333333, 0.88, 0
20633, 1.2166666666667, 0.89, 0
20634, 1.225, 0.88, 0
20635, 1.2333333333333, 0.89, 0
20636, 1.2416666666667, 0.88, 0
20637, 1.25, 0.89, 0
20638, 1.2583333333333, 0.88, 0
20639, 1.2666666666667, 0.89, 0
20640, 1.275, 0.88, 0
20641, 1.2833333333333, 0.89, 0
20642, 1.2916666666667, 0.88, 0
20643, 1.3, 0.89, 0
20644, 1.3083333333333, 0.88, 0
20645, 1.3166666666667, 0.89, 0
20646, 1.325, 0.88, 0
20647, 1.3333333333333, 0.89, 0
20648, 1.3416666666667, 0.88, 0
20649, 1.35, 0.89, 0
20650, 1.3583333333333, 0.88, 0
20651, 1.3666666666667, 0.89, 0
20652, 1.375, 0.88, 0
20653, 1.3833333333333, 0.89, 0
20654, 1.3916666666667, 0.88, 0
20655, 1.4, 0.89, 0
20656, 1.4083333333333, 0.88, 0
20657, 1.4166666666667, 0.89, 0
20658, 1.425, 0.88, 0
20659, 1.4333333333333, 0.89, 0
20660, 1.4416666666667, 0.88, 0
20661, 1.45, 0.89, 0
20662, 1.4583333333333, 0.88, 0
20663, 1.4666666666667, 0.89, 0
20664, 1.475, 0.88, 0
20665, 1.4833333333333, 0.89, 0
20666, 1.4916666666667, 0.88, 0
20667, 1.5, 0.89, 0
20668, 1.5083333333333, 0.88, 0
20669, 1.5166666666667, 0.89, 0
20670, 1.525, 0.88, 0
20671, 1.5333333333333, 0.89, 0
20672, 1.5416666666667, 0.88, 0
20673, 1.55, 0.89, 0
20674, 1.5583333333333, 0.88, 0
20675, 1.5666666666667, 0.89, 0
20676, 1.575, 0.88, 0
20677, 1.5833333333333, 0.89, 0
20678, 1.5916666666667, 0.88, 0
20679, 1.6, 0.89, 0
20680, 1.6083333333333, 0.88, 0
20681, 1.6166666666667, 0.89, 0
20682, 1.625, 0.88, 0
20683, 1.6333333333333, 0.89, 0
20684, 1.6416666666667, 0.88, 0
20685, 1.65, 0.89, 0
20686, 1.6583333333333, 0.88, 0
20687, 1.6666666666667, 0.89, 0
20688, 1.675, 0.88, 0
20689, 1.6833333333333, 0.89, 0
20690, 1.6916666666667, 0.88, 0
20691, 1.7, 0.89, 0
20692, 1.7083333333333, 0.88, 0
20693, 1.7166666666667, 0.89, 0
20694, 1.725, 0.88, 0
20695, 1.7333333333333, 0.89, 0
20696, 1.7416666666667, 0.88, 0
20697, 1.75, 0.89, 0
20698, 1.7583333333333, 0.88, 0
20699, 1.7666666666667, 0.89, 0
20700, 1.775, 0.88, 0
20701, 1.7833333333333, 0.89, 0
20702, 1.7916666666667, 0.88, 0
20703, 1.8, 0.89, 0
20704, 1.8083333333333, 0.88, 0
20705, 1.8166666666667, 0.89, 0
20706, 1.825, 0.88, 0
20707, 1.8333333333333, 0.89, 0
20708, 1.8416666666667, 0.88, 0
20709, 1.85, 0.89, 0
20710, 1.8583333333333, 0.88, 0
20711, 1.8666666666667, 0.89, 0
20712, 1.875, 0.88, 0
20713, 1.8833333333333, 0.89, 0
20714, 1.8916666666667, 0.88, 0
20715, 1.9, 0.89, 0
20716, 1.9083333333333, 0.88, 0
20717, 1.9166666666667, 0.89, 0
20718, 1.925, 0.88, 0
20719, 1.9333333333333, 0.89, 0
20720, 1.9416666666667, 0.88, 0
20721, 1.95, 0.89, 0
20722, 1.9583333333333, 0.88, 0
20723, 1.9666666666667, 0.89, 0
20724, 1.975, 0.88, 0
20725, 1.9833333333333, 0.89, 0
20726, 1.9916666666667, 0.88, 0
20727, 2, 0.89, 0
20728, 2.0083333333333, 0.88, 0
20729, 2.0166666666667, 0.89, 0
20730, 2.025, 0.88, 0
20731, 2.0333333333333, 0.89, 0
20732, 2.0416666666667, 0.88, 0
20733, 2.05, 0.89, 0
20734, 2.0583333333333, 0.88, 0
20735, 2.0666666666667, 0.89, 0
20736, 2.075, 0.88, 0
20737, 2.0833333333333, 0.89, 0
20738, 2.0916666666667, 0.88, 0
20739, 2.1, 0.89, 0
20740, 2.1083333333333, 0.88, 0
20741, 2.1166666666667, 0.89, 0
20742, 2.125, 0.88, 0
20743, 2.1333333333333, 0.89, 0
20744, 2.1416666666667, 0.88, 0
20745, 2.15, 0.89, 0
20746, 2.1583333333333, 0.88, 0
20747, 2.1666666666667, 0.89, 0
20748, 2.175, 0.88, 0
20749, 2.1833333333333, 0.89, 0
20750, 2.1916666666667, 0.88, 0
20751, 1.2083333333333, 0.86, 0
20752, 1.2166666666667, 0.87, 0
20753, 1.225, 0.86, 0
20754, 1.2333333333333, 0.87, 0
20755, 1.2416666666667, 0.86, 0
20756, 1.25, 0.87, 0
20757, 1.2583333333333, 0.86, 0
20758, 1.2666666666667, 0.87, 0
20759, 1.275, 0.86, 0
20760, 1.2833333333333, 0.87, 0
20761, 1.2916666666667, 0.86, 0
20762, 1.3, 0.87, 0
20763, 1.3083333333333, 0.86, 0
20764, 1.3166666666667, 0.87, 0
20765, 1.325, 0.86, 0
20766, 1.3333333333333, 0.87, 0
20767, 1.3416666666667, 0.86, 0
20768, 1.35, 0.87, 0
20769, 1.3583333333333, 0.86, 0
20770, 1.3666666666667, 0.87, 0
20771, 1.375, 0.86, 0
20772, 1.3833333333333, 0.87, 0
20773, 1.3916666666667, 0.86, 0
20774, 1.4, 0.87, 0
20775, 1.4083333333333, 0.86, 0
20776, 1.4166666666667, 0.87, 0
20777, 1.425, 0.86, 0
20778, 1.4333333333333, 0.87, 0
20779, 1.4416666666667, 0.86, 0
20780, 1.45, 0.87, 0
20781, 1.4583333333333, 0.86, 0
20782, 1.4666666666667, 0.87, 0
20783, 1.475, 0.86, 0
20784, 1.4833333333333, 0.87, 0
20785, 1.4916666666667, 0.86, 0
20786, 1.5, 0.87, 0
20787, 1.5083333333333, 0.86, 0
20788, 1.5166666666667, 0.87, 0
20789, 1.525, 0.86, 0
20790, 1.5333333333333, 0.87, 0
20791, 1.5416666666667, 0.86, 0
20792, 1.55, 0.87, 0
20793, 1.5583333333333, 0.86, 0
20794, 1.5666666666667, 0.87, 0
20795, 1.575, 0.86, 0
20796, 1.5833333333333, 0.87, 0
20797, 1.5916666666667, 0.86, 0
20798, 1.6, 0.87, 0
20799, 1.6083333333333, 0.86, 0
20800, 1.6166666666667, 0.87, 0
20801, 1.625, 0.86, 0
20802, 1.6333333333333, 0.87, 0
20803, 1.6416666666667, 0.86, 0
20804, 1.65, 0.87, 0
20805, 1.6583333333333, 0.86, 0
20806, 1.6666666666667, 0.87, 0
20807, 1.675, 0.86, 0
20808, 1.6833333333333, 0.87, 0
20809, 1.6916666666667, 0.86, 0
20810, 1.7, 0.87, 0
20811, 1.7083333333333, 0.86, 0
20812, 1.7166666666667, 0.87, 0
20813, 1.725, 0.86, 0
20814, 1.7333333333333, 0.87, 0
20815, 1.7416666666667, 0.86, 0
20816, 1.75, 0.87, 0
20817, 1.7583333333333, 0.86, 0
20818, 1.7666666666667, 0.87, 0
20819, 1.775, 0.86, 0
20820, 1.7833333333333, 0.87, 0
20821, 1.7916666666667, 0.86, 0
20822, 1.8, 0.87, 0
20823, 1.8083333333333, 0.86, 0
20824, 1.8166666666667, 0.87, 0
20825, 1.825, 0.86, 0
20826, 1.8333333333333, 0.87, 0
20827, 1.8416666666667, 0.86, 0
20828, 1.85, 0.87, 0
20829, 1.8583333333333, 0.86, 0
20830, 1.8666666666667, 0.87, 0
20831, 1.875, 0.86, 0
20832, 1.8833333333333, 0.87, 0
20833, 1.8916666666667, 0.86, 0
20834, 1.9, 0.87, 0
20835, 1.9083333333333, 0.86, 0
20836, 1.9166666666667, 0.87, 0
20837, 1.925, 0.86, 0
20838, 1.9333333333333, 0.87, 0
20839, 1.9416666666667, 0.86, 0
20840, 1.95, 0.87, 0
20841, 1.9583333333333, 0.86, 0
20842, 1.9666666666667, 0.87, 0
20843, 1.975, 0.86, 0
20844, 1.9833333333333, 0.87, 0
20845, 1.9916666666667, 0.86, 0
20846, 2, 0.87, 0
20847, 2.0083333333333, 0.86, 0
20848, 2.0166666666667, 0.87, 0
20849, 2.025, 0.86, 0
20850, 2.0333333333333, 0.87, 0
20851, 2.0416666666667, 0.86, 0
20852, 2.05, 0.87, 0
20853, 2.0583333333333, 0.86, 0
20854, 2.0666666666667, 0.87, 0
20855, 2.075, 0.86, 0
20856, 2.0833333333333, 0.87, 0
20857, 2.0916666666667, 0.86, 0
20858, 2.1, 0.87, 0
20859, 2.1083333333333, 0.86, 0
20860, 2.1166666666667, 0.87, 0
20861, 2.125, 0.86, 0
20862, 2.1333333333333, 0.87, 0
20863, 2.1416666666667, 0.86, 0
20864, 2.15, 0.87, 0
20865, 2.1583333333333, 0.86, 0
20866, 2.1666666666667, 0.87, 0
20867, 2.175, 0.86, 0
20868, 2.1833333333333, 0.87, 0
20869, 2.1916666666667, 0.86, 0
20870, 1.2083333333333, 0.84, 0
20871, 1.2166666666667, 0.85, 0
20872, 1.225, 0.84, 0
20873, 1.2333333333333, 0.85, 0
20874, 1.2416666666667, 0.84, 0
20875, 1.25, 0.85, 0
20876, 1.2583333333333, 0.84, 0
20877, 1.2666666666667, 0.85, 0
20878, 1.275, 0.84, 0
20879, 1.2833333333333, 0.85, 0
20880, 1.2916666666667, 0.84, 0
20881, 1.3, 0.85, 0
20882, 1.3083333333333, 0.84, 0
20883, 1.3166666666667, 0.85, 0
20884, 1.325, 0.84, 0
20885, 1.3333333333333, 0.85, 0
20886, 1.3416666666667, 0.84, 0
20887, 1.35, 0.85, 0
20888, 1.3583333333333, 0.84, 0
20889, 1.3666666666667, 0.85, 0
20890, 1.375, 0.84, 0
20891, 1.3833333333333, 0.85, 0
20892, 1.3916666666667, 0.84, 0
20893, 1.4, 0.85, 0
20894, 1.4083333333333, 0.84, 0
20895, 1.4166666666667, 0.85, 0
20896, 1.425, 0.84, 0
20897, 1.4333333333333, 0.85, 0
20898, 1.4416666666667, 0.84, 0
20899, 1.45, 0.85, 0
20900, 1.4583333333333, 0.84, 0
20901, 1.4666666666667, 0.85, 0
20902, 1.475, 0.84, 0
20903, 1.4833333333333, 0.85, 0
20904, 1.4916666666667, 0.84, 0
20905, 1.5, 0.85, 0
20906, 1.5083333333333, 0.84, 0
20907, 1.5166666666667, 0.85, 0
20908, 1.525, 0.84, 0
20909, 1.5333333333333, 0.85, 0
20910, 1.5416666666667, 0.84, 0
20911, 1.55, 0.85, 0
20912, 1.5583333333333, 0.84, 0
20913, 1.5666666666667, 0.85, 0
20914, 1.575, 0.84, 0
20915, 1.5833333333333, 0.85, 0
20916, 1.5916666666667, 0.84, 0
20917, 1.6, 0.85, 0
20918, 1.6083333333333, 0.84, 0
20919, 1.6166666666667, 0.85, 0
20920, 1.625, 0.84, 0
20921, 1.6333333333333, 0.85, 0
20922, 1.6416666666667, 0.84, 0
20923, 1.65, 0.85, 0
20924, 1.6583333333333, 0.84, 0
20925, 1.6666666666667, 0.85, 0
20926, 1.675, 0.84, 0
20927, 1.6833333333333, 0.85, 0
20928, 1.6916666666667, 0.84, 0
20929, 1.7, 0.85, 0
20930, 1.7083333333333, 0.84, 0
20931, 1.7166666666667, 0.85, 0
20932, 1.725, 0.84, 0
20933, 1.7333333333333, 0.85, 0
20934, 1.7416666666667, 0.84, 0
20935, 1.75, 0.85, 0
