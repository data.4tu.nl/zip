10415, 28058, 2072, 2073, 28059, 28593, 2132, 28594, 28495
10416, 28059, 2073, 2074, 28060, 28594, 2133, 28595, 28497
10417, 28060, 2074, 2075, 28061, 28595, 2134, 28596, 28499
10418, 28061, 2075, 2076, 28062, 28596, 2135, 28597, 28501
10419, 28062, 2076, 2077, 28063, 28597, 2136, 28598, 28503
10420, 28063, 2077, 2078, 28064, 28598, 2137, 28599, 28505
10421, 28064, 2078, 2079, 28065, 28599, 2138, 28600, 28507
10422, 28065, 2079, 2080, 28066, 28600, 2139, 28601, 28509
10423, 28066, 2080, 2081, 28067, 28601, 2140, 28602, 28511
10424, 28067, 2081, 2082, 28068, 28602, 2141, 28603, 28513
10425, 28068, 2082, 2083, 28069, 28603, 2142, 28604, 28515
10426, 28069, 2083, 2084, 28070, 28604, 2143, 28605, 28517
10427, 28070, 2084, 2085, 28071, 28605, 2144, 28606, 28519
10428, 28071, 2085, 2086, 28072, 28606, 2145, 28607, 28521
10429, 28072, 2086, 2087, 28073, 28607, 2146, 28608, 28523
10430, 28073, 2087, 2088, 28074, 28608, 2147, 28609, 28525
10431, 28074, 2088, 2089, 28075, 28609, 2148, 28610, 28527
10432, 28075, 2089, 2090, 28076, 28610, 2149, 28611, 28529
10433, 28076, 2090, 2091, 28077, 28611, 2150, 28612, 28531
10434, 28077, 2091, 2092, 28078, 28612, 2151, 28613, 28533
10435, 28078, 2092, 2093, 28079, 28613, 2152, 28614, 28535
10436, 28079, 2093, 2094, 28080, 28614, 2153, 28615, 28537
10437, 28080, 2094, 2095, 28081, 28615, 2154, 28616, 28539
10438, 28081, 2095, 2096, 28082, 28616, 2155, 28617, 28541
10439, 28082, 2096, 2097, 28083, 28617, 2156, 28618, 28543
10440, 28083, 2097, 2098, 28084, 28618, 2157, 28619, 28545
10441, 28084, 2098, 2099, 28085, 28619, 2158, 28620, 28547
10442, 28085, 2099, 2100, 28086, 28620, 2159, 28621, 28549
10443, 28086, 2100, 2101, 28087, 28621, 2160, 28622, 28551
10444, 28087, 2101, 2102, 28088, 28622, 2161, 28623, 28553
10445, 28088, 2102, 2103, 28089, 28623, 2162, 28624, 28555
10446, 28089, 2103, 2104, 28090, 28624, 2163, 28625, 28557
10447, 28090, 2104, 2105, 28091, 28625, 2164, 28626, 28559
10448, 28091, 2105, 2106, 28092, 28626, 2165, 28627, 28561
10449, 28092, 2106, 2107, 28093, 28627, 2166, 28628, 28563
10450, 28093, 2107, 2108, 28094, 28628, 2167, 28629, 28565
10451, 28094, 2108, 2109, 28095, 28629, 2168, 28630, 28567
10452, 28095, 2109, 2110, 28096, 28630, 2169, 28631, 28569
10453, 28096, 2110, 2111, 28097, 28631, 2170, 28632, 28571
10454, 28097, 2111, 33, 2047, 28632, 2171, 2052, 28573
*ELEMENT, type=CPS8, ELSET=Surface12
10455, 14, 1282, 28633, 1149, 1286, 28869, 28870, 1208
10456, 1149, 28633, 28634, 1150, 28870, 28871, 28872, 1209
10457, 1150, 28634, 28635, 1151, 28872, 28873, 28874, 1210
10458, 1151, 28635, 28636, 1152, 28874, 28875, 28876, 1211
10459, 1152, 28636, 28637, 1153, 28876, 28877, 28878, 1212
10460, 1153, 28637, 28638, 1154, 28878, 28879, 28880, 1213
10461, 1154, 28638, 28639, 1155, 28880, 28881, 28882, 1214
10462, 1155, 28639, 28640, 1156, 28882, 28883, 28884, 1215
10463, 1156, 28640, 28641, 1157, 28884, 28885, 28886, 1216
10464, 1157, 28641, 28642, 1158, 28886, 28887, 28888, 1217
10465, 1158, 28642, 28643, 1159, 28888, 28889, 28890, 1218
10466, 1159, 28643, 28644, 1160, 28890, 28891, 28892, 1219
10467, 1160, 28644, 28645, 1161, 28892, 28893, 28894, 1220
10468, 1161, 28645, 28646, 1162, 28894, 28895, 28896, 1221
10469, 1162, 28646, 28647, 1163, 28896, 28897, 28898, 1222
10470, 1163, 28647, 28648, 1164, 28898, 28899, 28900, 1223
10471, 1164, 28648, 28649, 1165, 28900, 28901, 28902, 1224
10472, 1165, 28649, 28650, 1166, 28902, 28903, 28904, 1225
10473, 1166, 28650, 28651, 1167, 28904, 28905, 28906, 1226
10474, 1167, 28651, 28652, 1168, 28906, 28907, 28908, 1227
10475, 1168, 28652, 28653, 1169, 28908, 28909, 28910, 1228
10476, 1169, 28653, 28654, 1170, 28910, 28911, 28912, 1229
10477, 1170, 28654, 28655, 1171, 28912, 28913, 28914, 1230
10478, 1171, 28655, 28656, 1172, 28914, 28915, 28916, 1231
10479, 1172, 28656, 28657, 1173, 28916, 28917, 28918, 1232
10480, 1173, 28657, 28658, 1174, 28918, 28919, 28920, 1233
10481, 1174, 28658, 28659, 1175, 28920, 28921, 28922, 1234
10482, 1175, 28659, 28660, 1176, 28922, 28923, 28924, 1235
10483, 1176, 28660, 28661, 1177, 28924, 28925, 28926, 1236
10484, 1177, 28661, 28662, 1178, 28926, 28927, 28928, 1237
10485, 1178, 28662, 28663, 1179, 28928, 28929, 28930, 1238
10486, 1179, 28663, 28664, 1180, 28930, 28931, 28932, 1239
10487, 1180, 28664, 28665, 1181, 28932, 28933, 28934, 1240
10488, 1181, 28665, 28666, 1182, 28934, 28935, 28936, 1241
10489, 1182, 28666, 28667, 1183, 28936, 28937, 28938, 1242
10490, 1183, 28667, 28668, 1184, 28938, 28939, 28940, 1243
10491, 1184, 28668, 28669, 1185, 28940, 28941, 28942, 1244
10492, 1185, 28669, 28670, 1186, 28942, 28943, 28944, 1245
10493, 1186, 28670, 28671, 1187, 28944, 28945, 28946, 1246
10494, 1187, 28671, 28672, 1188, 28946, 28947, 28948, 1247
10495, 1188, 28672, 28673, 1189, 28948, 28949, 28950, 1248
10496, 1189, 28673, 28674, 1190, 28950, 28951, 28952, 1249
10497, 1190, 28674, 28675, 1191, 28952, 28953, 28954, 1250
10498, 1191, 28675, 28676, 1192, 28954, 28955, 28956, 1251
10499, 1192, 28676, 28677, 1193, 28956, 28957, 28958, 1252
10500, 1193, 28677, 28678, 1194, 28958, 28959, 28960, 1253
10501, 1194, 28678, 28679, 1195, 28960, 28961, 28962, 1254
10502, 1195, 28679, 28680, 1196, 28962, 28963, 28964, 1255
10503, 1196, 28680, 28681, 1197, 28964, 28965, 28966, 1256
10504, 1197, 28681, 28682, 1198, 28966, 28967, 28968, 1257
10505, 1198, 28682, 28683, 1199, 28968, 28969, 28970, 1258
10506, 1199, 28683, 28684, 1200, 28970, 28971, 28972, 1259
10507, 1200, 28684, 28685, 1201, 28972, 28973, 28974, 1260
10508, 1201, 28685, 28686, 1202, 28974, 28975, 28976, 1261
10509, 1202, 28686, 28687, 1203, 28976, 28977, 28978, 1262
10510, 1203, 28687, 28688, 1204, 28978, 28979, 28980, 1263
10511, 1204, 28688, 28689, 1205, 28980, 28981, 28982, 1264
10512, 1205, 28689, 28690, 1206, 28982, 28983, 28984, 1265
10513, 1206, 28690, 28691, 1207, 28984, 28985, 28986, 1266
10514, 1207, 28691, 1291, 15, 28986, 28987, 1295, 1267
10515, 1282, 1283, 28692, 28633, 1287, 28988, 28989, 28869
10516, 28633, 28692, 28693, 28634, 28989, 28990, 28991, 28871
10517, 28634, 28693, 28694, 28635, 28991, 28992, 28993, 28873
10518, 28635, 28694, 28695, 28636, 28993, 28994, 28995, 28875
10519, 28636, 28695, 28696, 28637, 28995, 28996, 28997, 28877
10520, 28637, 28696, 28697, 28638, 28997, 28998, 28999, 28879
10521, 28638, 28697, 28698, 28639, 28999, 29000, 29001, 28881
10522, 28639, 28698, 28699, 28640, 29001, 29002, 29003, 28883
10523, 28640, 28699, 28700, 28641, 29003, 29004, 29005, 28885
10524, 28641, 28700, 28701, 28642, 29005, 29006, 29007, 28887
10525, 28642, 28701, 28702, 28643, 29007, 29008, 29009, 28889
10526, 28643, 28702, 28703, 28644, 29009, 29010, 29011, 28891
10527, 28644, 28703, 28704, 28645, 29011, 29012, 29013, 28893
10528, 28645, 28704, 28705, 28646, 29013, 29014, 29015, 28895
10529, 28646, 28705, 28706, 28647, 29015, 29016, 29017, 28897
10530, 28647, 28706, 28707, 28648, 29017, 29018, 29019, 28899
10531, 28648, 28707, 28708, 28649, 29019, 29020, 29021, 28901
10532, 28649, 28708, 28709, 28650, 29021, 29022, 29023, 28903
10533, 28650, 28709, 28710, 28651, 29023, 29024, 29025, 28905
10534, 28651, 28710, 28711, 28652, 29025, 29026, 29027, 28907
10535, 28652, 28711, 28712, 28653, 29027, 29028, 29029, 28909
10536, 28653, 28712, 28713, 28654, 29029, 29030, 29031, 28911
10537, 28654, 28713, 28714, 28655, 29031, 29032, 29033, 28913
10538, 28655, 28714, 28715, 28656, 29033, 29034, 29035, 28915
10539, 28656, 28715, 28716, 28657, 29035, 29036, 29037, 28917
10540, 28657, 28716, 28717, 28658, 29037, 29038, 29039, 28919
10541, 28658, 28717, 28718, 28659, 29039, 29040, 29041, 28921
10542, 28659, 28718, 28719, 28660, 29041, 29042, 29043, 28923
10543, 28660, 28719, 28720, 28661, 29043, 29044, 29045, 28925
10544, 28661, 28720, 28721, 28662, 29045, 29046, 29047, 28927
10545, 28662, 28721, 28722, 28663, 29047, 29048, 29049, 28929
10546, 28663, 28722, 28723, 28664, 29049, 29050, 29051, 28931
10547, 28664, 28723, 28724, 28665, 29051, 29052, 29053, 28933
10548, 28665, 28724, 28725, 28666, 29053, 29054, 29055, 28935
10549, 28666, 28725, 28726, 28667, 29055, 29056, 29057, 28937
10550, 28667, 28726, 28727, 28668, 29057, 29058, 29059, 28939
10551, 28668, 28727, 28728, 28669, 29059, 29060, 29061, 28941
10552, 28669, 28728, 28729, 28670, 29061, 29062, 29063, 28943
10553, 28670, 28729, 28730, 28671, 29063, 29064, 29065, 28945
10554, 28671, 28730, 28731, 28672, 29065, 29066, 29067, 28947
10555, 28672, 28731, 28732, 28673, 29067, 29068, 29069, 28949
10556, 28673, 28732, 28733, 28674, 29069, 29070, 29071, 28951
10557, 28674, 28733, 28734, 28675, 29071, 29072, 29073, 28953
10558, 28675, 28734, 28735, 28676, 29073, 29074, 29075, 28955
10559, 28676, 28735, 28736, 28677, 29075, 29076, 29077, 28957
10560, 28677, 28736, 28737, 28678, 29077, 29078, 29079, 28959
10561, 28678, 28737, 28738, 28679, 29079, 29080, 29081, 28961
10562, 28679, 28738, 28739, 28680, 29081, 29082, 29083, 28963
10563, 28680, 28739, 28740, 28681, 29083, 29084, 29085, 28965
10564, 28681, 28740, 28741, 28682, 29085, 29086, 29087, 28967
10565, 28682, 28741, 28742, 28683, 29087, 29088, 29089, 28969
10566, 28683, 28742, 28743, 28684, 29089, 29090, 29091, 28971
10567, 28684, 28743, 28744, 28685, 29091, 29092, 29093, 28973
10568, 28685, 28744, 28745, 28686, 29093, 29094, 29095, 28975
10569, 28686, 28745, 28746, 28687, 29095, 29096, 29097, 28977
10570, 28687, 28746, 28747, 28688, 29097, 29098, 29099, 28979
10571, 28688, 28747, 28748, 28689, 29099, 29100, 29101, 28981
10572, 28689, 28748, 28749, 28690, 29101, 29102, 29103, 28983
10573, 28690, 28749, 28750, 28691, 29103, 29104, 29105, 28985
10574, 28691, 28750, 1292, 1291, 29105, 29106, 1296, 28987
10575, 1283, 1284, 28751, 28692, 1288, 29107, 29108, 28988
10576, 28692, 28751, 28752, 28693, 29108, 29109, 29110, 28990
10577, 28693, 28752, 28753, 28694, 29110, 29111, 29112, 28992
10578, 28694, 28753, 28754, 28695, 29112, 29113, 29114, 28994
10579, 28695, 28754, 28755, 28696, 29114, 29115, 29116, 28996
10580, 28696, 28755, 28756, 28697, 29116, 29117, 29118, 28998
10581, 28697, 28756, 28757, 28698, 29118, 29119, 29120, 29000
10582, 28698, 28757, 28758, 28699, 29120, 29121, 29122, 29002
10583, 28699, 28758, 28759, 28700, 29122, 29123, 29124, 29004
10584, 28700, 28759, 28760, 28701, 29124, 29125, 29126, 29006
10585, 28701, 28760, 28761, 28702, 29126, 29127, 29128, 29008
10586, 28702, 28761, 28762, 28703, 29128, 29129, 29130, 29010
10587, 28703, 28762, 28763, 28704, 29130, 29131, 29132, 29012
10588, 28704, 28763, 28764, 28705, 29132, 29133, 29134, 29014
10589, 28705, 28764, 28765, 28706, 29134, 29135, 29136, 29016
10590, 28706, 28765, 28766, 28707, 29136, 29137, 29138, 29018
10591, 28707, 28766, 28767, 28708, 29138, 29139, 29140, 29020
10592, 28708, 28767, 28768, 28709, 29140, 29141, 29142, 29022
10593, 28709, 28768, 28769, 28710, 29142, 29143, 29144, 29024
10594, 28710, 28769, 28770, 28711, 29144, 29145, 29146, 29026
10595, 28711, 28770, 28771, 28712, 29146, 29147, 29148, 29028
10596, 28712, 28771, 28772, 28713, 29148, 29149, 29150, 29030
10597, 28713, 28772, 28773, 28714, 29150, 29151, 29152, 29032
10598, 28714, 28773, 28774, 28715, 29152, 29153, 29154, 29034
10599, 28715, 28774, 28775, 28716, 29154, 29155, 29156, 29036
10600, 28716, 28775, 28776, 28717, 29156, 29157, 29158, 29038
10601, 28717, 28776, 28777, 28718, 29158, 29159, 29160, 29040
10602, 28718, 28777, 28778, 28719, 29160, 29161, 29162, 29042
10603, 28719, 28778, 28779, 28720, 29162, 29163, 29164, 29044
10604, 28720, 28779, 28780, 28721, 29164, 29165, 29166, 29046
10605, 28721, 28780, 28781, 28722, 29166, 29167, 29168, 29048
10606, 28722, 28781, 28782, 28723, 29168, 29169, 29170, 29050
10607, 28723, 28782, 28783, 28724, 29170, 29171, 29172, 29052
10608, 28724, 28783, 28784, 28725, 29172, 29173, 29174, 29054
10609, 28725, 28784, 28785, 28726, 29174, 29175, 29176, 29056
10610, 28726, 28785, 28786, 28727, 29176, 29177, 29178, 29058
10611, 28727, 28786, 28787, 28728, 29178, 29179, 29180, 29060
10612, 28728, 28787, 28788, 28729, 29180, 29181, 29182, 29062
10613, 28729, 28788, 28789, 28730, 29182, 29183, 29184, 29064
10614, 28730, 28789, 28790, 28731, 29184, 29185, 29186, 29066
10615, 28731, 28790, 28791, 28732, 29186, 29187, 29188, 29068
10616, 28732, 28791, 28792, 28733, 29188, 29189, 29190, 29070
10617, 28733, 28792, 28793, 28734, 29190, 29191, 29192, 29072
10618, 28734, 28793, 28794, 28735, 29192, 29193, 29194, 29074
10619, 28735, 28794, 28795, 28736, 29194, 29195, 29196, 29076
10620, 28736, 28795, 28796, 28737, 29196, 29197, 29198, 29078
10621, 28737, 28796, 28797, 28738, 29198, 29199, 29200, 29080
10622, 28738, 28797, 28798, 28739, 29200, 29201, 29202, 29082
10623, 28739, 28798, 28799, 28740, 29202, 29203, 29204, 29084
10624, 28740, 28799, 28800, 28741, 29204, 29205, 29206, 29086
10625, 28741, 28800, 28801, 28742, 29206, 29207, 29208, 29088
10626, 28742, 28801, 28802, 28743, 29208, 29209, 29210, 29090
10627, 28743, 28802, 28803, 28744, 29210, 29211, 29212, 29092
10628, 28744, 28803, 28804, 28745, 29212, 29213, 29214, 29094
10629, 28745, 28804, 28805, 28746, 29214, 29215, 29216, 29096
10630, 28746, 28805, 28806, 28747, 29216, 29217, 29218, 29098
10631, 28747, 28806, 28807, 28748, 29218, 29219, 29220, 29100
10632, 28748, 28807, 28808, 28749, 29220, 29221, 29222, 29102
10633, 28749, 28808, 28809, 28750, 29222, 29223, 29224, 29104
10634, 28750, 28809, 1293, 1292, 29224, 29225, 1297, 29106
10635, 1284, 1285, 28810, 28751, 1289, 29226, 29227, 29107
10636, 28751, 28810, 28811, 28752, 29227, 29228, 29229, 29109
10637, 28752, 28811, 28812, 28753, 29229, 29230, 29231, 29111
10638, 28753, 28812, 28813, 28754, 29231, 29232, 29233, 29113
10639, 28754, 28813, 28814, 28755, 29233, 29234, 29235, 29115
10640, 28755, 28814, 28815, 28756, 29235, 29236, 29237, 29117
10641, 28756, 28815, 28816, 28757, 29237, 29238, 29239, 29119
10642, 28757, 28816, 28817, 28758, 29239, 29240, 29241, 29121
10643, 28758, 28817, 28818, 28759, 29241, 29242, 29243, 29123
10644, 28759, 28818, 28819, 28760, 29243, 29244, 29245, 29125
10645, 28760, 28819, 28820, 28761, 29245, 29246, 29247, 29127
10646, 28761, 28820, 28821, 28762, 29247, 29248, 29249, 29129
10647, 28762, 28821, 28822, 28763, 29249, 29250, 29251, 29131
10648, 28763, 28822, 28823, 28764, 29251, 29252, 29253, 29133
10649, 28764, 28823, 28824, 28765, 29253, 29254, 29255, 29135
10650, 28765, 28824, 28825, 28766, 29255, 29256, 29257, 29137
10651, 28766, 28825, 28826, 28767, 29257, 29258, 29259, 29139
10652, 28767, 28826, 28827, 28768, 29259, 29260, 29261, 29141
10653, 28768, 28827, 28828, 28769, 29261, 29262, 29263, 29143
10654, 28769, 28828, 28829, 28770, 29263, 29264, 29265, 29145
10655, 28770, 28829, 28830, 28771, 29265, 29266, 29267, 29147
10656, 28771, 28830, 28831, 28772, 29267, 29268, 29269, 29149
10657, 28772, 28831, 28832, 28773, 29269, 29270, 29271, 29151
10658, 28773, 28832, 28833, 28774, 29271, 29272, 29273, 29153
10659, 28774, 28833, 28834, 28775, 29273, 29274, 29275, 29155
10660, 28775, 28834, 28835, 28776, 29275, 29276, 29277, 29157
10661, 28776, 28835, 28836, 28777, 29277, 29278, 29279, 29159
10662, 28777, 28836, 28837, 28778, 29279, 29280, 29281, 29161
10663, 28778, 28837, 28838, 28779, 29281, 29282, 29283, 29163
10664, 28779, 28838, 28839, 28780, 29283, 29284, 29285, 29165
10665, 28780, 28839, 28840, 28781, 29285, 29286, 29287, 29167
10666, 28781, 28840, 28841, 28782, 29287, 29288, 29289, 29169
10667, 28782, 28841, 28842, 28783, 29289, 29290, 29291, 29171
10668, 28783, 28842, 28843, 28784, 29291, 29292, 29293, 29173
10669, 28784, 28843, 28844, 28785, 29293, 29294, 29295, 29175
10670, 28785, 28844, 28845, 28786, 29295, 29296, 29297, 29177
10671, 28786, 28845, 28846, 28787, 29297, 29298, 29299, 29179
10672, 28787, 28846, 28847, 28788, 29299, 29300, 29301, 29181
10673, 28788, 28847, 28848, 28789, 29301, 29302, 29303, 29183
10674, 28789, 28848, 28849, 28790, 29303, 29304, 29305, 29185
10675, 28790, 28849, 28850, 28791, 29305, 29306, 29307, 29187
10676, 28791, 28850, 28851, 28792, 29307, 29308, 29309, 29189
10677, 28792, 28851, 28852, 28793, 29309, 29310, 29311, 29191
10678, 28793, 28852, 28853, 28794, 29311, 29312, 29313, 29193
10679, 28794, 28853, 28854, 28795, 29313, 29314, 29315, 29195
10680, 28795, 28854, 28855, 28796, 29315, 29316, 29317, 29197
10681, 28796, 28855, 28856, 28797, 29317, 29318, 29319, 29199
10682, 28797, 28856, 28857, 28798, 29319, 29320, 29321, 29201
10683, 28798, 28857, 28858, 28799, 29321, 29322, 29323, 29203
10684, 28799, 28858, 28859, 28800, 29323, 29324, 29325, 29205
10685, 28800, 28859, 28860, 28801, 29325, 29326, 29327, 29207
10686, 28801, 28860, 28861, 28802, 29327, 29328, 29329, 29209
10687, 28802, 28861, 28862, 28803, 29329, 29330, 29331, 29211
10688, 28803, 28862, 28863, 28804, 29331, 29332, 29333, 29213
10689, 28804, 28863, 28864, 28805, 29333, 29334, 29335, 29215
10690, 28805, 28864, 28865, 28806, 29335, 29336, 29337, 29217
10691, 28806, 28865, 28866, 28807, 29337, 29338, 29339, 29219
10692, 28807, 28866, 28867, 28808, 29339, 29340, 29341, 29221
10693, 28808, 28867, 28868, 28809, 29341, 29342, 29343, 29223
10694, 28809, 28868, 1294, 1293, 29343, 29344, 1298, 29225
10695, 1285, 19, 1300, 28810, 1290, 1359, 29345, 29226
10696, 28810, 1300, 1301, 28811, 29345, 1360, 29346, 29228
10697, 28811, 1301, 1302, 28812, 29346, 1361, 29347, 29230
10698, 28812, 1302, 1303, 28813, 29347, 1362, 29348, 29232
10699, 28813, 1303, 1304, 28814, 29348, 1363, 29349, 29234
10700, 28814, 1304, 1305, 28815, 29349, 1364, 29350, 29236
10701, 28815, 1305, 1306, 28816, 29350, 1365, 29351, 29238
10702, 28816, 1306, 1307, 28817, 29351, 1366, 29352, 29240
10703, 28817, 1307, 1308, 28818, 29352, 1367, 29353, 29242
10704, 28818, 1308, 1309, 28819, 29353, 1368, 29354, 29244
10705, 28819, 1309, 1310, 28820, 29354, 1369, 29355, 29246
10706, 28820, 1310, 1311, 28821, 29355, 1370, 29356, 29248
10707, 28821, 1311, 1312, 28822, 29356, 1371, 29357, 29250
10708, 28822, 1312, 1313, 28823, 29357, 1372, 29358, 29252
10709, 28823, 1313, 1314, 28824, 29358, 1373, 29359, 29254
10710, 28824, 1314, 1315, 28825, 29359, 1374, 29360, 29256
10711, 28825, 1315, 1316, 28826, 29360, 1375, 29361, 29258
10712, 28826, 1316, 1317, 28827, 29361, 1376, 29362, 29260
10713, 28827, 1317, 1318, 28828, 29362, 1377, 29363, 29262
10714, 28828, 1318, 1319, 28829, 29363, 1378, 29364, 29264
10715, 28829, 1319, 1320, 28830, 29364, 1379, 29365, 29266
10716, 28830, 1320, 1321, 28831, 29365, 1380, 29366, 29268
10717, 28831, 1321, 1322, 28832, 29366, 1381, 29367, 29270
10718, 28832, 1322, 1323, 28833, 29367, 1382, 29368, 29272
10719, 28833, 1323, 1324, 28834, 29368, 1383, 29369, 29274
10720, 28834, 1324, 1325, 28835, 29369, 1384, 29370, 29276
10721, 28835, 1325, 1326, 28836, 29370, 1385, 29371, 29278
10722, 28836, 1326, 1327, 28837, 29371, 1386, 29372, 29280
10723, 28837, 1327, 1328, 28838, 29372, 1387, 29373, 29282
10724, 28838, 1328, 1329, 28839, 29373, 1388, 29374, 29284
10725, 28839, 1329, 1330, 28840, 29374, 1389, 29375, 29286
10726, 28840, 1330, 1331, 28841, 29375, 1390, 29376, 29288
10727, 28841, 1331, 1332, 28842, 29376, 1391, 29377, 29290
10728, 28842, 1332, 1333, 28843, 29377, 1392, 29378, 29292
10729, 28843, 1333, 1334, 28844, 29378, 1393, 29379, 29294
10730, 28844, 1334, 1335, 28845, 29379, 1394, 29380, 29296
10731, 28845, 1335, 1336, 28846, 29380, 1395, 29381, 29298
10732, 28846, 1336, 1337, 28847, 29381, 1396, 29382, 29300
10733, 28847, 1337, 1338, 28848, 29382, 1397, 29383, 29302
10734, 28848, 1338, 1339, 28849, 29383, 1398, 29384, 29304
10735, 28849, 1339, 1340, 28850, 29384, 1399, 29385, 29306
10736, 28850, 1340, 1341, 28851, 29385, 1400, 29386, 29308
10737, 28851, 1341, 1342, 28852, 29386, 1401, 29387, 29310
10738, 28852, 1342, 1343, 28853, 29387, 1402, 29388, 29312
10739, 28853, 1343, 1344, 28854, 29388, 1403, 29389, 29314
10740, 28854, 1344, 1345, 28855, 29389, 1404, 29390, 29316
10741, 28855, 1345, 1346, 28856, 29390, 1405, 29391, 29318
10742, 28856, 1346, 1347, 28857, 29391, 1406, 29392, 29320
10743, 28857, 1347, 1348, 28858, 29392, 1407, 29393, 29322
10744, 28858, 1348, 1349, 28859, 29393, 1408, 29394, 29324
10745, 28859, 1349, 1350, 28860, 29394, 1409, 29395, 29326
10746, 28860, 1350, 1351, 28861, 29395, 1410, 29396, 29328
10747, 28861, 1351, 1352, 28862, 29396, 1411, 29397, 29330
10748, 28862, 1352, 1353, 28863, 29397, 1412, 29398, 29332
10749, 28863, 1353, 1354, 28864, 29398, 1413, 29399, 29334
10750, 28864, 1354, 1355, 28865, 29399, 1414, 29400, 29336
10751, 28865, 1355, 1356, 28866, 29400, 1415, 29401, 29338
10752, 28866, 1356, 1357, 28867, 29401, 1416, 29402, 29340
10753, 28867, 1357, 1358, 28868, 29402, 1417, 29403, 29342
10754, 28868, 1358, 20, 1294, 29403, 1418, 1299, 29344
*ELEMENT, type=CPS8, ELSET=Surface13
10755, 15, 1291, 29404, 1428, 1295, 29412, 29413, 1430
10756, 1428, 29404, 29405, 1429, 29413, 29414, 29415, 1431
10757, 1429, 29405, 1419, 21, 29415, 29416, 1423, 1432
10758, 1291, 1292, 29406, 29404, 1296, 29417, 29418, 29412
10759, 29404, 29406, 29407, 29405, 29418, 29419, 29420, 29414
10760, 29405, 29407, 1420, 1419, 29420, 29421, 1424, 29416
10761, 1292, 1293, 29408, 29406, 1297, 29422, 29423, 29417
10762, 29406, 29408, 29409, 29407, 29423, 29424, 29425, 29419
10763, 29407, 29409, 1421, 1420, 29425, 29426, 1425, 29421
10764, 1293, 1294, 29410, 29408, 1298, 29427, 29428, 29422
10765, 29408, 29410, 29411, 29409, 29428, 29429, 29430, 29424
10766, 29409, 29411, 1422, 1421, 29430, 29431, 1426, 29426
10767, 1294, 20, 1433, 29410, 1299, 1435, 29432, 29427
10768, 29410, 1433, 1434, 29411, 29432, 1436, 29433, 29429
10769, 29411, 1434, 22, 1422, 29433, 1437, 1427, 29431
*ELEMENT, type=CPS8, ELSET=Surface14
10770, 1, 43, 29434, 2247, 47, 29670, 29671, 2306
10771, 2247, 29434, 29435, 2248, 29671, 29672, 29673, 2307
10772, 2248, 29435, 29436, 2249, 29673, 29674, 29675, 2308
10773, 2249, 29436, 29437, 2250, 29675, 29676, 29677, 2309
10774, 2250, 29437, 29438, 2251, 29677, 29678, 29679, 2310
10775, 2251, 29438, 29439, 2252, 29679, 29680, 29681, 2311
10776, 2252, 29439, 29440, 2253, 29681, 29682, 29683, 2312
10777, 2253, 29440, 29441, 2254, 29683, 29684, 29685, 2313
10778, 2254, 29441, 29442, 2255, 29685, 29686, 29687, 2314
10779, 2255, 29442, 29443, 2256, 29687, 29688, 29689, 2315
10780, 2256, 29443, 29444, 2257, 29689, 29690, 29691, 2316
10781, 2257, 29444, 29445, 2258, 29691, 29692, 29693, 2317
10782, 2258, 29445, 29446, 2259, 29693, 29694, 29695, 2318
10783, 2259, 29446, 29447, 2260, 29695, 29696, 29697, 2319
10784, 2260, 29447, 29448, 2261, 29697, 29698, 29699, 2320
10785, 2261, 29448, 29449, 2262, 29699, 29700, 29701, 2321
10786, 2262, 29449, 29450, 2263, 29701, 29702, 29703, 2322
10787, 2263, 29450, 29451, 2264, 29703, 29704, 29705, 2323
10788, 2264, 29451, 29452, 2265, 29705, 29706, 29707, 2324
10789, 2265, 29452, 29453, 2266, 29707, 29708, 29709, 2325
10790, 2266, 29453, 29454, 2267, 29709, 29710, 29711, 2326
10791, 2267, 29454, 29455, 2268, 29711, 29712, 29713, 2327
10792, 2268, 29455, 29456, 2269, 29713, 29714, 29715, 2328
10793, 2269, 29456, 29457, 2270, 29715, 29716, 29717, 2329
10794, 2270, 29457, 29458, 2271, 29717, 29718, 29719, 2330
10795, 2271, 29458, 29459, 2272, 29719, 29720, 29721, 2331
10796, 2272, 29459, 29460, 2273, 29721, 29722, 29723, 2332
10797, 2273, 29460, 29461, 2274, 29723, 29724, 29725, 2333
10798, 2274, 29461, 29462, 2275, 29725, 29726, 29727, 2334
10799, 2275, 29462, 29463, 2276, 29727, 29728, 29729, 2335
10800, 2276, 29463, 29464, 2277, 29729, 29730, 29731, 2336
10801, 2277, 29464, 29465, 2278, 29731, 29732, 29733, 2337
10802, 2278, 29465, 29466, 2279, 29733, 29734, 29735, 2338
10803, 2279, 29466, 29467, 2280, 29735, 29736, 29737, 2339
10804, 2280, 29467, 29468, 2281, 29737, 29738, 29739, 2340
10805, 2281, 29468, 29469, 2282, 29739, 29740, 29741, 2341
10806, 2282, 29469, 29470, 2283, 29741, 29742, 29743, 2342
10807, 2283, 29470, 29471, 2284, 29743, 29744, 29745, 2343
10808, 2284, 29471, 29472, 2285, 29745, 29746, 29747, 2344
10809, 2285, 29472, 29473, 2286, 29747, 29748, 29749, 2345
10810, 2286, 29473, 29474, 2287, 29749, 29750, 29751, 2346
10811, 2287, 29474, 29475, 2288, 29751, 29752, 29753, 2347
10812, 2288, 29475, 29476, 2289, 29753, 29754, 29755, 2348
10813, 2289, 29476, 29477, 2290, 29755, 29756, 29757, 2349
10814, 2290, 29477, 29478, 2291, 29757, 29758, 29759, 2350
10815, 2291, 29478, 29479, 2292, 29759, 29760, 29761, 2351
10816, 2292, 29479, 29480, 2293, 29761, 29762, 29763, 2352
10817, 2293, 29480, 29481, 2294, 29763, 29764, 29765, 2353
10818, 2294, 29481, 29482, 2295, 29765, 29766, 29767, 2354
10819, 2295, 29482, 29483, 2296, 29767, 29768, 29769, 2355
10820, 2296, 29483, 29484, 2297, 29769, 29770, 29771, 2356
10821, 2297, 29484, 29485, 2298, 29771, 29772, 29773, 2357
10822, 2298, 29485, 29486, 2299, 29773, 29774, 29775, 2358
10823, 2299, 29486, 29487, 2300, 29775, 29776, 29777, 2359
10824, 2300, 29487, 29488, 2301, 29777, 29778, 29779, 2360
10825, 2301, 29488, 29489, 2302, 29779, 29780, 29781, 2361
10826, 2302, 29489, 29490, 2303, 29781, 29782, 29783, 2362
10827, 2303, 29490, 29491, 2304, 29783, 29784, 29785, 2363
10828, 2304, 29491, 29492, 2305, 29785, 29786, 29787, 2364
10829, 2305, 29492, 2496, 35, 29787, 29788, 2500, 2365
10830, 43, 44, 29493, 29434, 48, 29789, 29790, 29670
10831, 29434, 29493, 29494, 29435, 29790, 29791, 29792, 29672
10832, 29435, 29494, 29495, 29436, 29792, 29793, 29794, 29674
10833, 29436, 29495, 29496, 29437, 29794, 29795, 29796, 29676
10834, 29437, 29496, 29497, 29438, 29796, 29797, 29798, 29678
10835, 29438, 29497, 29498, 29439, 29798, 29799, 29800, 29680
10836, 29439, 29498, 29499, 29440, 29800, 29801, 29802, 29682
10837, 29440, 29499, 29500, 29441, 29802, 29803, 29804, 29684
10838, 29441, 29500, 29501, 29442, 29804, 29805, 29806, 29686
10839, 29442, 29501, 29502, 29443, 29806, 29807, 29808, 29688
10840, 29443, 29502, 29503, 29444, 29808, 29809, 29810, 29690
10841, 29444, 29503, 29504, 29445, 29810, 29811, 29812, 29692
10842, 29445, 29504, 29505, 29446, 29812, 29813, 29814, 29694
10843, 29446, 29505, 29506, 29447, 29814, 29815, 29816, 29696
10844, 29447, 29506, 29507, 29448, 29816, 29817, 29818, 29698
10845, 29448, 29507, 29508, 29449, 29818, 29819, 29820, 29700
10846, 29449, 29508, 29509, 29450, 29820, 29821, 29822, 29702
10847, 29450, 29509, 29510, 29451, 29822, 29823, 29824, 29704
10848, 29451, 29510, 29511, 29452, 29824, 29825, 29826, 29706
10849, 29452, 29511, 29512, 29453, 29826, 29827, 29828, 29708
10850, 29453, 29512, 29513, 29454, 29828, 29829, 29830, 29710
10851, 29454, 29513, 29514, 29455, 29830, 29831, 29832, 29712
10852, 29455, 29514, 29515, 29456, 29832, 29833, 29834, 29714
10853, 29456, 29515, 29516, 29457, 29834, 29835, 29836, 29716
10854, 29457, 29516, 29517, 29458, 29836, 29837, 29838, 29718
10855, 29458, 29517, 29518, 29459, 29838, 29839, 29840, 29720
10856, 29459, 29518, 29519, 29460, 29840, 29841, 29842, 29722
10857, 29460, 29519, 29520, 29461, 29842, 29843, 29844, 29724
10858, 29461, 29520, 29521, 29462, 29844, 29845, 29846, 29726
10859, 29462, 29521, 29522, 29463, 29846, 29847, 29848, 29728
10860, 29463, 29522, 29523, 29464, 29848, 29849, 29850, 29730
10861, 29464, 29523, 29524, 29465, 29850, 29851, 29852, 29732
10862, 29465, 29524, 29525, 29466, 29852, 29853, 29854, 29734
10863, 29466, 29525, 29526, 29467, 29854, 29855, 29856, 29736
10864, 29467, 29526, 29527, 29468, 29856, 29857, 29858, 29738
10865, 29468, 29527, 29528, 29469, 29858, 29859, 29860, 29740
10866, 29469, 29528, 29529, 29470, 29860, 29861, 29862, 29742
10867, 29470, 29529, 29530, 29471, 29862, 29863, 29864, 29744
10868, 29471, 29530, 29531, 29472, 29864, 29865, 29866, 29746
10869, 29472, 29531, 29532, 29473, 29866, 29867, 29868, 29748
10870, 29473, 29532, 29533, 29474, 29868, 29869, 29870, 29750
10871, 29474, 29533, 29534, 29475, 29870, 29871, 29872, 29752
10872, 29475, 29534, 29535, 29476, 29872, 29873, 29874, 29754
10873, 29476, 29535, 29536, 29477, 29874, 29875, 29876, 29756
10874, 29477, 29536, 29537, 29478, 29876, 29877, 29878, 29758
10875, 29478, 29537, 29538, 29479, 29878, 29879, 29880, 29760
10876, 29479, 29538, 29539, 29480, 29880, 29881, 29882, 29762
10877, 29480, 29539, 29540, 29481, 29882, 29883, 29884, 29764
10878, 29481, 29540, 29541, 29482, 29884, 29885, 29886, 29766
10879, 29482, 29541, 29542, 29483, 29886, 29887, 29888, 29768
10880, 29483, 29542, 29543, 29484, 29888, 29889, 29890, 29770
10881, 29484, 29543, 29544, 29485, 29890, 29891, 29892, 29772
10882, 29485, 29544, 29545, 29486, 29892, 29893, 29894, 29774
10883, 29486, 29545, 29546, 29487, 29894, 29895, 29896, 29776
10884, 29487, 29546, 29547, 29488, 29896, 29897, 29898, 29778
10885, 29488, 29547, 29548, 29489, 29898, 29899, 29900, 29780
10886, 29489, 29548, 29549, 29490, 29900, 29901, 29902, 29782
10887, 29490, 29549, 29550, 29491, 29902, 29903, 29904, 29784
10888, 29491, 29550, 29551, 29492, 29904, 29905, 29906, 29786
10889, 29492, 29551, 2497, 2496, 29906, 29907, 2501, 29788
10890, 44, 45, 29552, 29493, 49, 29908, 29909, 29789
10891, 29493, 29552, 29553, 29494, 29909, 29910, 29911, 29791
10892, 29494, 29553, 29554, 29495, 29911, 29912, 29913, 29793
10893, 29495, 29554, 29555, 29496, 29913, 29914, 29915, 29795
10894, 29496, 29555, 29556, 29497, 29915, 29916, 29917, 29797
10895, 29497, 29556, 29557, 29498, 29917, 29918, 29919, 29799
10896, 29498, 29557, 29558, 29499, 29919, 29920, 29921, 29801
10897, 29499, 29558, 29559, 29500, 29921, 29922, 29923, 29803
10898, 29500, 29559, 29560, 29501, 29923, 29924, 29925, 29805
10899, 29501, 29560, 29561, 29502, 29925, 29926, 29927, 29807
10900, 29502, 29561, 29562, 29503, 29927, 29928, 29929, 29809
10901, 29503, 29562, 29563, 29504, 29929, 29930, 29931, 29811
10902, 29504, 29563, 29564, 29505, 29931, 29932, 29933, 29813
10903, 29505, 29564, 29565, 29506, 29933, 29934, 29935, 29815
10904, 29506, 29565, 29566, 29507, 29935, 29936, 29937, 29817
10905, 29507, 29566, 29567, 29508, 29937, 29938, 29939, 29819
10906, 29508, 29567, 29568, 29509, 29939, 29940, 29941, 29821
10907, 29509, 29568, 29569, 29510, 29941, 29942, 29943, 29823
10908, 29510, 29569, 29570, 29511, 29943, 29944, 29945, 29825
10909, 29511, 29570, 29571, 29512, 29945, 29946, 29947, 29827
10910, 29512, 29571, 29572, 29513, 29947, 29948, 29949, 29829
10911, 29513, 29572, 29573, 29514, 29949, 29950, 29951, 29831
10912, 29514, 29573, 29574, 29515, 29951, 29952, 29953, 29833
10913, 29515, 29574, 29575, 29516, 29953, 29954, 29955, 29835
10914, 29516, 29575, 29576, 29517, 29955, 29956, 29957, 29837
10915, 29517, 29576, 29577, 29518, 29957, 29958, 29959, 29839
10916, 29518, 29577, 29578, 29519, 29959, 29960, 29961, 29841
10917, 29519, 29578, 29579, 29520, 29961, 29962, 29963, 29843
10918, 29520, 29579, 29580, 29521, 29963, 29964, 29965, 29845
10919, 29521, 29580, 29581, 29522, 29965, 29966, 29967, 29847
10920, 29522, 29581, 29582, 29523, 29967, 29968, 29969, 29849
10921, 29523, 29582, 29583, 29524, 29969, 29970, 29971, 29851
10922, 29524, 29583, 29584, 29525, 29971, 29972, 29973, 29853
10923, 29525, 29584, 29585, 29526, 29973, 29974, 29975, 29855
10924, 29526, 29585, 29586, 29527, 29975, 29976, 29977, 29857
10925, 29527, 29586, 29587, 29528, 29977, 29978, 29979, 29859
10926, 29528, 29587, 29588, 29529, 29979, 29980, 29981, 29861
10927, 29529, 29588, 29589, 29530, 29981, 29982, 29983, 29863
10928, 29530, 29589, 29590, 29531, 29983, 29984, 29985, 29865
10929, 29531, 29590, 29591, 29532, 29985, 29986, 29987, 29867
10930, 29532, 29591, 29592, 29533, 29987, 29988, 29989, 29869
10931, 29533, 29592, 29593, 29534, 29989, 29990, 29991, 29871
10932, 29534, 29593, 29594, 29535, 29991, 29992, 29993, 29873
10933, 29535, 29594, 29595, 29536, 29993, 29994, 29995, 29875
10934, 29536, 29595, 29596, 29537, 29995, 29996, 29997, 29877
10935, 29537, 29596, 29597, 29538, 29997, 29998, 29999, 29879
10936, 29538, 29597, 29598, 29539, 29999, 30000, 30001, 29881
10937, 29539, 29598, 29599, 29540, 30001, 30002, 30003, 29883
10938, 29540, 29599, 29600, 29541, 30003, 30004, 30005, 29885
10939, 29541, 29600, 29601, 29542, 30005, 30006, 30007, 29887
10940, 29542, 29601, 29602, 29543, 30007, 30008, 30009, 29889
10941, 29543, 29602, 29603, 29544, 30009, 30010, 30011, 29891
10942, 29544, 29603, 29604, 29545, 30011, 30012, 30013, 29893
10943, 29545, 29604, 29605, 29546, 30013, 30014, 30015, 29895
10944, 29546, 29605, 29606, 29547, 30015, 30016, 30017, 29897
10945, 29547, 29606, 29607, 29548, 30017, 30018, 30019, 29899
10946, 29548, 29607, 29608, 29549, 30019, 30020, 30021, 29901
10947, 29549, 29608, 29609, 29550, 30021, 30022, 30023, 29903
10948, 29550, 29609, 29610, 29551, 30023, 30024, 30025, 29905
10949, 29551, 29610, 2498, 2497, 30025, 30026, 2502, 29907
10950, 45, 46, 29611, 29552, 50, 30027, 30028, 29908
10951, 29552, 29611, 29612, 29553, 30028, 30029, 30030, 29910
10952, 29553, 29612, 29613, 29554, 30030, 30031, 30032, 29912
10953, 29554, 29613, 29614, 29555, 30032, 30033, 30034, 29914
10954, 29555, 29614, 29615, 29556, 30034, 30035, 30036, 29916
10955, 29556, 29615, 29616, 29557, 30036, 30037, 30038, 29918
10956, 29557, 29616, 29617, 29558, 30038, 30039, 30040, 29920
10957, 29558, 29617, 29618, 29559, 30040, 30041, 30042, 29922
10958, 29559, 29618, 29619, 29560, 30042, 30043, 30044, 29924
10959, 29560, 29619, 29620, 29561, 30044, 30045, 30046, 29926
10960, 29561, 29620, 29621, 29562, 30046, 30047, 30048, 29928
10961, 29562, 29621, 29622, 29563, 30048, 30049, 30050, 29930
10962, 29563, 29622, 29623, 29564, 30050, 30051, 30052, 29932
10963, 29564, 29623, 29624, 29565, 30052, 30053, 30054, 29934
10964, 29565, 29624, 29625, 29566, 30054, 30055, 30056, 29936
10965, 29566, 29625, 29626, 29567, 30056, 30057, 30058, 29938
10966, 29567, 29626, 29627, 29568, 30058, 30059, 30060, 29940
10967, 29568, 29627, 29628, 29569, 30060, 30061, 30062, 29942
10968, 29569, 29628, 29629, 29570, 30062, 30063, 30064, 29944
10969, 29570, 29629, 29630, 29571, 30064, 30065, 30066, 29946
10970, 29571, 29630, 29631, 29572, 30066, 30067, 30068, 29948
10971, 29572, 29631, 29632, 29573, 30068, 30069, 30070, 29950
10972, 29573, 29632, 29633, 29574, 30070, 30071, 30072, 29952
10973, 29574, 29633, 29634, 29575, 30072, 30073, 30074, 29954
10974, 29575, 29634, 29635, 29576, 30074, 30075, 30076, 29956
10975, 29576, 29635, 29636, 29577, 30076, 30077, 30078, 29958
10976, 29577, 29636, 29637, 29578, 30078, 30079, 30080, 29960
10977, 29578, 29637, 29638, 29579, 30080, 30081, 30082, 29962
10978, 29579, 29638, 29639, 29580, 30082, 30083, 30084, 29964
10979, 29580, 29639, 29640, 29581, 30084, 30085, 30086, 29966
10980, 29581, 29640, 29641, 29582, 30086, 30087, 30088, 29968
10981, 29582, 29641, 29642, 29583, 30088, 30089, 30090, 29970
10982, 29583, 29642, 29643, 29584, 30090, 30091, 30092, 29972
10983, 29584, 29643, 29644, 29585, 30092, 30093, 30094, 29974
10984, 29585, 29644, 29645, 29586, 30094, 30095, 30096, 29976
10985, 29586, 29645, 29646, 29587, 30096, 30097, 30098, 29978
10986, 29587, 29646, 29647, 29588, 30098, 30099, 30100, 29980
10987, 29588, 29647, 29648, 29589, 30100, 30101, 30102, 29982
10988, 29589, 29648, 29649, 29590, 30102, 30103, 30104, 29984
10989, 29590, 29649, 29650, 29591, 30104, 30105, 30106, 29986
10990, 29591, 29650, 29651, 29592, 30106, 30107, 30108, 29988
10991, 29592, 29651, 29652, 29593, 30108, 30109, 30110, 29990
10992, 29593, 29652, 29653, 29594, 30110, 30111, 30112, 29992
10993, 29594, 29653, 29654, 29595, 30112, 30113, 30114, 29994
10994, 29595, 29654, 29655, 29596, 30114, 30115, 30116, 29996
10995, 29596, 29655, 29656, 29597, 30116, 30117, 30118, 29998
10996, 29597, 29656, 29657, 29598, 30118, 30119, 30120, 30000
10997, 29598, 29657, 29658, 29599, 30120, 30121, 30122, 30002
10998, 29599, 29658, 29659, 29600, 30122, 30123, 30124, 30004
10999, 29600, 29659, 29660, 29601, 30124, 30125, 30126, 30006
11000, 29601, 29660, 29661, 29602, 30126, 30127, 30128, 30008
11001, 29602, 29661, 29662, 29603, 30128, 30129, 30130, 30010
11002, 29603, 29662, 29663, 29604, 30130, 30131, 30132, 30012
11003, 29604, 29663, 29664, 29605, 30132, 30133, 30134, 30014
11004, 29605, 29664, 29665, 29606, 30134, 30135, 30136, 30016
11005, 29606, 29665, 29666, 29607, 30136, 30137, 30138, 30018
11006, 29607, 29666, 29667, 29608, 30138, 30139, 30140, 30020
11007, 29608, 29667, 29668, 29609, 30140, 30141, 30142, 30022
11008, 29609, 29668, 29669, 29610, 30142, 30143, 30144, 30024
11009, 29610, 29669, 2499, 2498, 30144, 30145, 2503, 30026
11010, 46, 2, 2505, 29611, 51, 2564, 30146, 30027
11011, 29611, 2505, 2506, 29612, 30146, 2565, 30147, 30029
11012, 29612, 2506, 2507, 29613, 30147, 2566, 30148, 30031
11013, 29613, 2507, 2508, 29614, 30148, 2567, 30149, 30033
11014, 29614, 2508, 2509, 29615, 30149, 2568, 30150, 30035
11015, 29615, 2509, 2510, 29616, 30150, 2569, 30151, 30037
11016, 29616, 2510, 2511, 29617, 30151, 2570, 30152, 30039
11017, 29617, 2511, 2512, 29618, 30152, 2571, 30153, 30041
11018, 29618, 2512, 2513, 29619, 30153, 2572, 30154, 30043
11019, 29619, 2513, 2514, 29620, 30154, 2573, 30155, 30045
11020, 29620, 2514, 2515, 29621, 30155, 2574, 30156, 30047
11021, 29621, 2515, 2516, 29622, 30156, 2575, 30157, 30049
11022, 29622, 2516, 2517, 29623, 30157, 2576, 30158, 30051
11023, 29623, 2517, 2518, 29624, 30158, 2577, 30159, 30053
11024, 29624, 2518, 2519, 29625, 30159, 2578, 30160, 30055
11025, 29625, 2519, 2520, 29626, 30160, 2579, 30161, 30057
11026, 29626, 2520, 2521, 29627, 30161, 2580, 30162, 30059
11027, 29627, 2521, 2522, 29628, 30162, 2581, 30163, 30061
11028, 29628, 2522, 2523, 29629, 30163, 2582, 30164, 30063
11029, 29629, 2523, 2524, 29630, 30164, 2583, 30165, 30065
11030, 29630, 2524, 2525, 29631, 30165, 2584, 30166, 30067
11031, 29631, 2525, 2526, 29632, 30166, 2585, 30167, 30069
11032, 29632, 2526, 2527, 29633, 30167, 2586, 30168, 30071
11033, 29633, 2527, 2528, 29634, 30168, 2587, 30169, 30073
11034, 29634, 2528, 2529, 29635, 30169, 2588, 30170, 30075
11035, 29635, 2529, 2530, 29636, 30170, 2589, 30171, 30077
11036, 29636, 2530, 2531, 29637, 30171, 2590, 30172, 30079
11037, 29637, 2531, 2532, 29638, 30172, 2591, 30173, 30081
11038, 29638, 2532, 2533, 29639, 30173, 2592, 30174, 30083
11039, 29639, 2533, 2534, 29640, 30174, 2593, 30175, 30085
11040, 29640, 2534, 2535, 29641, 30175, 2594, 30176, 30087
11041, 29641, 2535, 2536, 29642, 30176, 2595, 30177, 30089
11042, 29642, 2536, 2537, 29643, 30177, 2596, 30178, 30091
11043, 29643, 2537, 2538, 29644, 30178, 2597, 30179, 30093
11044, 29644, 2538, 2539, 29645, 30179, 2598, 30180, 30095
11045, 29645, 2539, 2540, 29646, 30180, 2599, 30181, 30097
11046, 29646, 2540, 2541, 29647, 30181, 2600, 30182, 30099
11047, 29647, 2541, 2542, 29648, 30182, 2601, 30183, 30101
11048, 29648, 2542, 2543, 29649, 30183, 2602, 30184, 30103
11049, 29649, 2543, 2544, 29650, 30184, 2603, 30185, 30105
11050, 29650, 2544, 2545, 29651, 30185, 2604, 30186, 30107
11051, 29651, 2545, 2546, 29652, 30186, 2605, 30187, 30109
11052, 29652, 2546, 2547, 29653, 30187, 2606, 30188, 30111
11053, 29653, 2547, 2548, 29654, 30188, 2607, 30189, 30113
11054, 29654, 2548, 2549, 29655, 30189, 2608, 30190, 30115
11055, 29655, 2549, 2550, 29656, 30190, 2609, 30191, 30117
11056, 29656, 2550, 2551, 29657, 30191, 2610, 30192, 30119
11057, 29657, 2551, 2552, 29658, 30192, 2611, 30193, 30121
11058, 29658, 2552, 2553, 29659, 30193, 2612, 30194, 30123
11059, 29659, 2553, 2554, 29660, 30194, 2613, 30195, 30125
11060, 29660, 2554, 2555, 29661, 30195, 2614, 30196, 30127
11061, 29661, 2555, 2556, 29662, 30196, 2615, 30197, 30129
11062, 29662, 2556, 2557, 29663, 30197, 2616, 30198, 30131
11063, 29663, 2557, 2558, 29664, 30198, 2617, 30199, 30133
11064, 29664, 2558, 2559, 29665, 30199, 2618, 30200, 30135
11065, 29665, 2559, 2560, 29666, 30200, 2619, 30201, 30137
11066, 29666, 2560, 2561, 29667, 30201, 2620, 30202, 30139
11067, 29667, 2561, 2562, 29668, 30202, 2621, 30203, 30141
11068, 29668, 2562, 2563, 29669, 30203, 2622, 30204, 30143
11069, 29669, 2563, 37, 2499, 30204, 2623, 2504, 30145
*ELEMENT, type=CPS8, ELSET=Surface17
11070, 1, 647, 30205, 43, 654, 30233, 30234, 47
11071, 43, 30205, 30206, 44, 30234, 30235, 30236, 48
11072, 44, 30206, 30207, 45, 30236, 30237, 30238, 49
11073, 45, 30207, 30208, 46, 30238, 30239, 30240, 50
11074, 46, 30208, 1438, 2, 30240, 30241, 1445, 51
11075, 647, 648, 30209, 30205, 655, 30242, 30243, 30233
11076, 30205, 30209, 30210, 30206, 30243, 30244, 30245, 30235
11077, 30206, 30210, 30211, 30207, 30245, 30246, 30247, 30237
11078, 30207, 30211, 30212, 30208, 30247, 30248, 30249, 30239
11079, 30208, 30212, 1439, 1438, 30249, 30250, 1446, 30241
11080, 648, 649, 30213, 30209, 656, 30251, 30252, 30242
11081, 30209, 30213, 30214, 30210, 30252, 30253, 30254, 30244
11082, 30210, 30214, 30215, 30211, 30254, 30255, 30256, 30246
11083, 30211, 30215, 30216, 30212, 30256, 30257, 30258, 30248
11084, 30212, 30216, 1440, 1439, 30258, 30259, 1447, 30250
11085, 649, 650, 30217, 30213, 657, 30260, 30261, 30251
11086, 30213, 30217, 30218, 30214, 30261, 30262, 30263, 30253
11087, 30214, 30218, 30219, 30215, 30263, 30264, 30265, 30255
11088, 30215, 30219, 30220, 30216, 30265, 30266, 30267, 30257
11089, 30216, 30220, 1441, 1440, 30267, 30268, 1448, 30259
11090, 650, 651, 30221, 30217, 658, 30269, 30270, 30260
11091, 30217, 30221, 30222, 30218, 30270, 30271, 30272, 30262
11092, 30218, 30222, 30223, 30219, 30272, 30273, 30274, 30264
11093, 30219, 30223, 30224, 30220, 30274, 30275, 30276, 30266
11094, 30220, 30224, 1442, 1441, 30276, 30277, 1449, 30268
11095, 651, 652, 30225, 30221, 659, 30278, 30279, 30269
11096, 30221, 30225, 30226, 30222, 30279, 30280, 30281, 30271
11097, 30222, 30226, 30227, 30223, 30281, 30282, 30283, 30273
11098, 30223, 30227, 30228, 30224, 30283, 30284, 30285, 30275
11099, 30224, 30228, 1443, 1442, 30285, 30286, 1450, 30277
11100, 652, 653, 30229, 30225, 660, 30287, 30288, 30278
11101, 30225, 30229, 30230, 30226, 30288, 30289, 30290, 30280
11102, 30226, 30230, 30231, 30227, 30290, 30291, 30292, 30282
11103, 30227, 30231, 30232, 30228, 30292, 30293, 30294, 30284
11104, 30228, 30232, 1444, 1443, 30294, 30295, 1451, 30286
11105, 653, 9, 1453, 30229, 661, 1457, 30296, 30287
11106, 30229, 1453, 1454, 30230, 30296, 1458, 30297, 30289
11107, 30230, 1454, 1455, 30231, 30297, 1459, 30298, 30291
11108, 30231, 1455, 1456, 30232, 30298, 1460, 30299, 30293
11109, 30232, 1456, 23, 1444, 30299, 1461, 1452, 30295
*ELEMENT, type=CPS8, ELSET=Surface18
11110, 28, 1638, 30300, 2183, 1643, 30310, 30311, 2185
11111, 2183, 30300, 30301, 2184, 30311, 30312, 30313, 2186
11112, 2184, 30301, 2172, 34, 30313, 30314, 2177, 2187
11113, 1638, 1639, 30302, 30300, 1644, 30315, 30316, 30310
11114, 30300, 30302, 30303, 30301, 30316, 30317, 30318, 30312
11115, 30301, 30303, 2173, 2172, 30318, 30319, 2178, 30314
11116, 1639, 1640, 30304, 30302, 1645, 30320, 30321, 30315
11117, 30302, 30304, 30305, 30303, 30321, 30322, 30323, 30317
11118, 30303, 30305, 2174, 2173, 30323, 30324, 2179, 30319
11119, 1640, 1641, 30306, 30304, 1646, 30325, 30326, 30320
11120, 30304, 30306, 30307, 30305, 30326, 30327, 30328, 30322
11121, 30305, 30307, 2175, 2174, 30328, 30329, 2180, 30324
11122, 1641, 1642, 30308, 30306, 1647, 30330, 30331, 30325
11123, 30306, 30308, 30309, 30307, 30331, 30332, 30333, 30327
11124, 30307, 30309, 2176, 2175, 30333, 30334, 2181, 30329
11125, 1642, 15, 1428, 30308, 1648, 1430, 30335, 30330
11126, 30308, 1428, 1429, 30309, 30335, 1431, 30336, 30332
11127, 30309, 1429, 21, 2176, 30336, 1432, 2182, 30334
*ELEMENT, type=CPS8, ELSET=Surface19
11128, 16, 1268, 30337, 1273, 1270, 30345, 30346, 1277
11129, 1268, 1269, 30338, 30337, 1271, 30347, 30348, 30345
11130, 1269, 17, 1465, 30338, 1272, 1470, 30349, 30347
11131, 1273, 30337, 30339, 1274, 30346, 30350, 30351, 1278
11132, 30337, 30338, 30340, 30339, 30348, 30352, 30353, 30350
11133, 30338, 1465, 1464, 30340, 30349, 1469, 30354, 30352
11134, 1274, 30339, 30341, 1275, 30351, 30355, 30356, 1279
11135, 30339, 30340, 30342, 30341, 30353, 30357, 30358, 30355
11136, 30340, 1464, 1463, 30342, 30354, 1468, 30359, 30357
11137, 1275, 30341, 30343, 1276, 30356, 30360, 30361, 1280
11138, 30341, 30342, 30344, 30343, 30358, 30362, 30363, 30360
11139, 30342, 1463, 1462, 30344, 30359, 1467, 30364, 30362
11140, 1276, 30343, 1471, 18, 30361, 30365, 1473, 1281
11141, 30343, 30344, 1472, 1471, 30363, 30366, 1474, 30365
11142, 30344, 1462, 24, 1472, 30364, 1466, 1475, 30366
*ELEMENT, type=CPS8, ELSET=Surface20
11143, 9, 2366, 30367, 1453, 2425, 30603, 30604, 1457
11144, 2366, 2367, 30368, 30367, 2426, 30605, 30606, 30603
11145, 2367, 2368, 30369, 30368, 2427, 30607, 30608, 30605
11146, 2368, 2369, 30370, 30369, 2428, 30609, 30610, 30607
11147, 2369, 2370, 30371, 30370, 2429, 30611, 30612, 30609
11148, 2370, 2371, 30372, 30371, 2430, 30613, 30614, 30611
11149, 2371, 2372, 30373, 30372, 2431, 30615, 30616, 30613
11150, 2372, 2373, 30374, 30373, 2432, 30617, 30618, 30615
11151, 2373, 2374, 30375, 30374, 2433, 30619, 30620, 30617
11152, 2374, 2375, 30376, 30375, 2434, 30621, 30622, 30619
11153, 2375, 2376, 30377, 30376, 2435, 30623, 30624, 30621
11154, 2376, 2377, 30378, 30377, 2436, 30625, 30626, 30623
11155, 2377, 2378, 30379, 30378, 2437, 30627, 30628, 30625
11156, 2378, 2379, 30380, 30379, 2438, 30629, 30630, 30627
11157, 2379, 2380, 30381, 30380, 2439, 30631, 30632, 30629
11158, 2380, 2381, 30382, 30381, 2440, 30633, 30634, 30631
11159, 2381, 2382, 30383, 30382, 2441, 30635, 30636, 30633
11160, 2382, 2383, 30384, 30383, 2442, 30637, 30638, 30635
11161, 2383, 2384, 30385, 30384, 2443, 30639, 30640, 30637
11162, 2384, 2385, 30386, 30385, 2444, 30641, 30642, 30639
11163, 2385, 2386, 30387, 30386, 2445, 30643, 30644, 30641
11164, 2386, 2387, 30388, 30387, 2446, 30645, 30646, 30643
11165, 2387, 2388, 30389, 30388, 2447, 30647, 30648, 30645
11166, 2388, 2389, 30390, 30389, 2448, 30649, 30650, 30647
11167, 2389, 2390, 30391, 30390, 2449, 30651, 30652, 30649
11168, 2390, 2391, 30392, 30391, 2450, 30653, 30654, 30651
11169, 2391, 2392, 30393, 30392, 2451, 30655, 30656, 30653
11170, 2392, 2393, 30394, 30393, 2452, 30657, 30658, 30655
11171, 2393, 2394, 30395, 30394, 2453, 30659, 30660, 30657
11172, 2394, 2395, 30396, 30395, 2454, 30661, 30662, 30659
11173, 2395, 2396, 30397, 30396, 2455, 30663, 30664, 30661
11174, 2396, 2397, 30398, 30397, 2456, 30665, 30666, 30663
11175, 2397, 2398, 30399, 30398, 2457, 30667, 30668, 30665
11176, 2398, 2399, 30400, 30399, 2458, 30669, 30670, 30667
11177, 2399, 2400, 30401, 30400, 2459, 30671, 30672, 30669
11178, 2400, 2401, 30402, 30401, 2460, 30673, 30674, 30671
11179, 2401, 2402, 30403, 30402, 2461, 30675, 30676, 30673
11180, 2402, 2403, 30404, 30403, 2462, 30677, 30678, 30675
11181, 2403, 2404, 30405, 30404, 2463, 30679, 30680, 30677
11182, 2404, 2405, 30406, 30405, 2464, 30681, 30682, 30679
11183, 2405, 2406, 30407, 30406, 2465, 30683, 30684, 30681
11184, 2406, 2407, 30408, 30407, 2466, 30685, 30686, 30683
11185, 2407, 2408, 30409, 30408, 2467, 30687, 30688, 30685
11186, 2408, 2409, 30410, 30409, 2468, 30689, 30690, 30687
11187, 2409, 2410, 30411, 30410, 2469, 30691, 30692, 30689
11188, 2410, 2411, 30412, 30411, 2470, 30693, 30694, 30691
11189, 2411, 2412, 30413, 30412, 2471, 30695, 30696, 30693
11190, 2412, 2413, 30414, 30413, 2472, 30697, 30698, 30695
11191, 2413, 2414, 30415, 30414, 2473, 30699, 30700, 30697
11192, 2414, 2415, 30416, 30415, 2474, 30701, 30702, 30699
11193, 2415, 2416, 30417, 30416, 2475, 30703, 30704, 30701
11194, 2416, 2417, 30418, 30417, 2476, 30705, 30706, 30703
11195, 2417, 2418, 30419, 30418, 2477, 30707, 30708, 30705
11196, 2418, 2419, 30420, 30419, 2478, 30709, 30710, 30707
11197, 2419, 2420, 30421, 30420, 2479, 30711, 30712, 30709
11198, 2420, 2421, 30422, 30421, 2480, 30713, 30714, 30711
11199, 2421, 2422, 30423, 30422, 2481, 30715, 30716, 30713
11200, 2422, 2423, 30424, 30423, 2482, 30717, 30718, 30715
11201, 2423, 2424, 30425, 30424, 2483, 30719, 30720, 30717
11202, 2424, 36, 2627, 30425, 2484, 2632, 30721, 30719
11203, 1453, 30367, 30426, 1454, 30604, 30722, 30723, 1458
11204, 30367, 30368, 30427, 30426, 30606, 30724, 30725, 30722
11205, 30368, 30369, 30428, 30427, 30608, 30726, 30727, 30724
11206, 30369, 30370, 30429, 30428, 30610, 30728, 30729, 30726
11207, 30370, 30371, 30430, 30429, 30612, 30730, 30731, 30728
11208, 30371, 30372, 30431, 30430, 30614, 30732, 30733, 30730
11209, 30372, 30373, 30432, 30431, 30616, 30734, 30735, 30732
11210, 30373, 30374, 30433, 30432, 30618, 30736, 30737, 30734
11211, 30374, 30375, 30434, 30433, 30620, 30738, 30739, 30736
11212, 30375, 30376, 30435, 30434, 30622, 30740, 30741, 30738
11213, 30376, 30377, 30436, 30435, 30624, 30742, 30743, 30740
11214, 30377, 30378, 30437, 30436, 30626, 30744, 30745, 30742
11215, 30378, 30379, 30438, 30437, 30628, 30746, 30747, 30744
11216, 30379, 30380, 30439, 30438, 30630, 30748, 30749, 30746
11217, 30380, 30381, 30440, 30439, 30632, 30750, 30751, 30748
11218, 30381, 30382, 30441, 30440, 30634, 30752, 30753, 30750
11219, 30382, 30383, 30442, 30441, 30636, 30754, 30755, 30752
11220, 30383, 30384, 30443, 30442, 30638, 30756, 30757, 30754
11221, 30384, 30385, 30444, 30443, 30640, 30758, 30759, 30756
11222, 30385, 30386, 30445, 30444, 30642, 30760, 30761, 30758
11223, 30386, 30387, 30446, 30445, 30644, 30762, 30763, 30760
11224, 30387, 30388, 30447, 30446, 30646, 30764, 30765, 30762
11225, 30388, 30389, 30448, 30447, 30648, 30766, 30767, 30764
11226, 30389, 30390, 30449, 30448, 30650, 30768, 30769, 30766
11227, 30390, 30391, 30450, 30449, 30652, 30770, 30771, 30768
11228, 30391, 30392, 30451, 30450, 30654, 30772, 30773, 30770
11229, 30392, 30393, 30452, 30451, 30656, 30774, 30775, 30772
11230, 30393, 30394, 30453, 30452, 30658, 30776, 30777, 30774
11231, 30394, 30395, 30454, 30453, 30660, 30778, 30779, 30776
11232, 30395, 30396, 30455, 30454, 30662, 30780, 30781, 30778
11233, 30396, 30397, 30456, 30455, 30664, 30782, 30783, 30780
11234, 30397, 30398, 30457, 30456, 30666, 30784, 30785, 30782
11235, 30398, 30399, 30458, 30457, 30668, 30786, 30787, 30784
11236, 30399, 30400, 30459, 30458, 30670, 30788, 30789, 30786
11237, 30400, 30401, 30460, 30459, 30672, 30790, 30791, 30788
11238, 30401, 30402, 30461, 30460, 30674, 30792, 30793, 30790
11239, 30402, 30403, 30462, 30461, 30676, 30794, 30795, 30792
11240, 30403, 30404, 30463, 30462, 30678, 30796, 30797, 30794
11241, 30404, 30405, 30464, 30463, 30680, 30798, 30799, 30796
11242, 30405, 30406, 30465, 30464, 30682, 30800, 30801, 30798
11243, 30406, 30407, 30466, 30465, 30684, 30802, 30803, 30800
11244, 30407, 30408, 30467, 30466, 30686, 30804, 30805, 30802
11245, 30408, 30409, 30468, 30467, 30688, 30806, 30807, 30804
11246, 30409, 30410, 30469, 30468, 30690, 30808, 30809, 30806
11247, 30410, 30411, 30470, 30469, 30692, 30810, 30811, 30808
11248, 30411, 30412, 30471, 30470, 30694, 30812, 30813, 30810
11249, 30412, 30413, 30472, 30471, 30696, 30814, 30815, 30812
11250, 30413, 30414, 30473, 30472, 30698, 30816, 30817, 30814
11251, 30414, 30415, 30474, 30473, 30700, 30818, 30819, 30816
11252, 30415, 30416, 30475, 30474, 30702, 30820, 30821, 30818
11253, 30416, 30417, 30476, 30475, 30704, 30822, 30823, 30820
11254, 30417, 30418, 30477, 30476, 30706, 30824, 30825, 30822
11255, 30418, 30419, 30478, 30477, 30708, 30826, 30827, 30824
11256, 30419, 30420, 30479, 30478, 30710, 30828, 30829, 30826
11257, 30420, 30421, 30480, 30479, 30712, 30830, 30831, 30828
11258, 30421, 30422, 30481, 30480, 30714, 30832, 30833, 30830
11259, 30422, 30423, 30482, 30481, 30716, 30834, 30835, 30832
11260, 30423, 30424, 30483, 30482, 30718, 30836, 30837, 30834
11261, 30424, 30425, 30484, 30483, 30720, 30838, 30839, 30836
11262, 30425, 2627, 2626, 30484, 30721, 2631, 30840, 30838
11263, 1454, 30426, 30485, 1455, 30723, 30841, 30842, 1459
11264, 30426, 30427, 30486, 30485, 30725, 30843, 30844, 30841
11265, 30427, 30428, 30487, 30486, 30727, 30845, 30846, 30843
11266, 30428, 30429, 30488, 30487, 30729, 30847, 30848, 30845
11267, 30429, 30430, 30489, 30488, 30731, 30849, 30850, 30847
11268, 30430, 30431, 30490, 30489, 30733, 30851, 30852, 30849
11269, 30431, 30432, 30491, 30490, 30735, 30853, 30854, 30851
11270, 30432, 30433, 30492, 30491, 30737, 30855, 30856, 30853
11271, 30433, 30434, 30493, 30492, 30739, 30857, 30858, 30855
11272, 30434, 30435, 30494, 30493, 30741, 30859, 30860, 30857
11273, 30435, 30436, 30495, 30494, 30743, 30861, 30862, 30859
11274, 30436, 30437, 30496, 30495, 30745, 30863, 30864, 30861
11275, 30437, 30438, 30497, 30496, 30747, 30865, 30866, 30863
11276, 30438, 30439, 30498, 30497, 30749, 30867, 30868, 30865
11277, 30439, 30440, 30499, 30498, 30751, 30869, 30870, 30867
11278, 30440, 30441, 30500, 30499, 30753, 30871, 30872, 30869
11279, 30441, 30442, 30501, 30500, 30755, 30873, 30874, 30871
11280, 30442, 30443, 30502, 30501, 30757, 30875, 30876, 30873
11281, 30443, 30444, 30503, 30502, 30759, 30877, 30878, 30875
11282, 30444, 30445, 30504, 30503, 30761, 30879, 30880, 30877
11283, 30445, 30446, 30505, 30504, 30763, 30881, 30882, 30879
11284, 30446, 30447, 30506, 30505, 30765, 30883, 30884, 30881
11285, 30447, 30448, 30507, 30506, 30767, 30885, 30886, 30883
11286, 30448, 30449, 30508, 30507, 30769, 30887, 30888, 30885
11287, 30449, 30450, 30509, 30508, 30771, 30889, 30890, 30887
11288, 30450, 30451, 30510, 30509, 30773, 30891, 30892, 30889
11289, 30451, 30452, 30511, 30510, 30775, 30893, 30894, 30891
11290, 30452, 30453, 30512, 30511, 30777, 30895, 30896, 30893
11291, 30453, 30454, 30513, 30512, 30779, 30897, 30898, 30895
11292, 30454, 30455, 30514, 30513, 30781, 30899, 30900, 30897
11293, 30455, 30456, 30515, 30514, 30783, 30901, 30902, 30899
11294, 30456, 30457, 30516, 30515, 30785, 30903, 30904, 30901
11295, 30457, 30458, 30517, 30516, 30787, 30905, 30906, 30903
11296, 30458, 30459, 30518, 30517, 30789, 30907, 30908, 30905
11297, 30459, 30460, 30519, 30518, 30791, 30909, 30910, 30907
11298, 30460, 30461, 30520, 30519, 30793, 30911, 30912, 30909
11299, 30461, 30462, 30521, 30520, 30795, 30913, 30914, 30911
11300, 30462, 30463, 30522, 30521, 30797, 30915, 30916, 30913
11301, 30463, 30464, 30523, 30522, 30799, 30917, 30918, 30915
11302, 30464, 30465, 30524, 30523, 30801, 30919, 30920, 30917
11303, 30465, 30466, 30525, 30524, 30803, 30921, 30922, 30919
11304, 30466, 30467, 30526, 30525, 30805, 30923, 30924, 30921
11305, 30467, 30468, 30527, 30526, 30807, 30925, 30926, 30923
11306, 30468, 30469, 30528, 30527, 30809, 30927, 30928, 30925
11307, 30469, 30470, 30529, 30528, 30811, 30929, 30930, 30927
11308, 30470, 30471, 30530, 30529, 30813, 30931, 30932, 30929
11309, 30471, 30472, 30531, 30530, 30815, 30933, 30934, 30931
11310, 30472, 30473, 30532, 30531, 30817, 30935, 30936, 30933
11311, 30473, 30474, 30533, 30532, 30819, 30937, 30938, 30935
11312, 30474, 30475, 30534, 30533, 30821, 30939, 30940, 30937
11313, 30475, 30476, 30535, 30534, 30823, 30941, 30942, 30939
11314, 30476, 30477, 30536, 30535, 30825, 30943, 30944, 30941
11315, 30477, 30478, 30537, 30536, 30827, 30945, 30946, 30943
11316, 30478, 30479, 30538, 30537, 30829, 30947, 30948, 30945
11317, 30479, 30480, 30539, 30538, 30831, 30949, 30950, 30947
11318, 30480, 30481, 30540, 30539, 30833, 30951, 30952, 30949
11319, 30481, 30482, 30541, 30540, 30835, 30953, 30954, 30951
11320, 30482, 30483, 30542, 30541, 30837, 30955, 30956, 30953
11321, 30483, 30484, 30543, 30542, 30839, 30957, 30958, 30955
11322, 30484, 2626, 2625, 30543, 30840, 2630, 30959, 30957
11323, 1455, 30485, 30544, 1456, 30842, 30960, 30961, 1460
11324, 30485, 30486, 30545, 30544, 30844, 30962, 30963, 30960
11325, 30486, 30487, 30546, 30545, 30846, 30964, 30965, 30962
11326, 30487, 30488, 30547, 30546, 30848, 30966, 30967, 30964
11327, 30488, 30489, 30548, 30547, 30850, 30968, 30969, 30966
11328, 30489, 30490, 30549, 30548, 30852, 30970, 30971, 30968
11329, 30490, 30491, 30550, 30549, 30854, 30972, 30973, 30970
11330, 30491, 30492, 30551, 30550, 30856, 30974, 30975, 30972
11331, 30492, 30493, 30552, 30551, 30858, 30976, 30977, 30974
11332, 30493, 30494, 30553, 30552, 30860, 30978, 30979, 30976
11333, 30494, 30495, 30554, 30553, 30862, 30980, 30981, 30978
11334, 30495, 30496, 30555, 30554, 30864, 30982, 30983, 30980
11335, 30496, 30497, 30556, 30555, 30866, 30984, 30985, 30982
11336, 30497, 30498, 30557, 30556, 30868, 30986, 30987, 30984
11337, 30498, 30499, 30558, 30557, 30870, 30988, 30989, 30986
11338, 30499, 30500, 30559, 30558, 30872, 30990, 30991, 30988
11339, 30500, 30501, 30560, 30559, 30874, 30992, 30993, 30990
11340, 30501, 30502, 30561, 30560, 30876, 30994, 30995, 30992
11341, 30502, 30503, 30562, 30561, 30878, 30996, 30997, 30994
11342, 30503, 30504, 30563, 30562, 30880, 30998, 30999, 30996
11343, 30504, 30505, 30564, 30563, 30882, 31000, 31001, 30998
11344, 30505, 30506, 30565, 30564, 30884, 31002, 31003, 31000
11345, 30506, 30507, 30566, 30565, 30886, 31004, 31005, 31002
11346, 30507, 30508, 30567, 30566, 30888, 31006, 31007, 31004
11347, 30508, 30509, 30568, 30567, 30890, 31008, 31009, 31006
11348, 30509, 30510, 30569, 30568, 30892, 31010, 31011, 31008
11349, 30510, 30511, 30570, 30569, 30894, 31012, 31013, 31010
11350, 30511, 30512, 30571, 30570, 30896, 31014, 31015, 31012
11351, 30512, 30513, 30572, 30571, 30898, 31016, 31017, 31014
11352, 30513, 30514, 30573, 30572, 30900, 31018, 31019, 31016
11353, 30514, 30515, 30574, 30573, 30902, 31020, 31021, 31018
11354, 30515, 30516, 30575, 30574, 30904, 31022, 31023, 31020
11355, 30516, 30517, 30576, 30575, 30906, 31024, 31025, 31022
11356, 30517, 30518, 30577, 30576, 30908, 31026, 31027, 31024
11357, 30518, 30519, 30578, 30577, 30910, 31028, 31029, 31026
11358, 30519, 30520, 30579, 30578, 30912, 31030, 31031, 31028
11359, 30520, 30521, 30580, 30579, 30914, 31032, 31033, 31030
11360, 30521, 30522, 30581, 30580, 30916, 31034, 31035, 31032
11361, 30522, 30523, 30582, 30581, 30918, 31036, 31037, 31034
11362, 30523, 30524, 30583, 30582, 30920, 31038, 31039, 31036
11363, 30524, 30525, 30584, 30583, 30922, 31040, 31041, 31038
11364, 30525, 30526, 30585, 30584, 30924, 31042, 31043, 31040
11365, 30526, 30527, 30586, 30585, 30926, 31044, 31045, 31042
11366, 30527, 30528, 30587, 30586, 30928, 31046, 31047, 31044
11367, 30528, 30529, 30588, 30587, 30930, 31048, 31049, 31046
11368, 30529, 30530, 30589, 30588, 30932, 31050, 31051, 31048
11369, 30530, 30531, 30590, 30589, 30934, 31052, 31053, 31050
11370, 30531, 30532, 30591, 30590, 30936, 31054, 31055, 31052
11371, 30532, 30533, 30592, 30591, 30938, 31056, 31057, 31054
11372, 30533, 30534, 30593, 30592, 30940, 31058, 31059, 31056
11373, 30534, 30535, 30594, 30593, 30942, 31060, 31061, 31058
11374, 30535, 30536, 30595, 30594, 30944, 31062, 31063, 31060
11375, 30536, 30537, 30596, 30595, 30946, 31064, 31065, 31062
11376, 30537, 30538, 30597, 30596, 30948, 31066, 31067, 31064
11377, 30538, 30539, 30598, 30597, 30950, 31068, 31069, 31066
11378, 30539, 30540, 30599, 30598, 30952, 31070, 31071, 31068
11379, 30540, 30541, 30600, 30599, 30954, 31072, 31073, 31070
11380, 30541, 30542, 30601, 30600, 30956, 31074, 31075, 31072
11381, 30542, 30543, 30602, 30601, 30958, 31076, 31077, 31074
11382, 30543, 2625, 2624, 30602, 30959, 2629, 31078, 31076
11383, 1456, 30544, 2633, 23, 30961, 31079, 2692, 1461
11384, 30544, 30545, 2634, 2633, 30963, 31080, 2693, 31079
11385, 30545, 30546, 2635, 2634, 30965, 31081, 2694, 31080
11386, 30546, 30547, 2636, 2635, 30967, 31082, 2695, 31081
11387, 30547, 30548, 2637, 2636, 30969, 31083, 2696, 31082
11388, 30548, 30549, 2638, 2637, 30971, 31084, 2697, 31083
11389, 30549, 30550, 2639, 2638, 30973, 31085, 2698, 31084
11390, 30550, 30551, 2640, 2639, 30975, 31086, 2699, 31085
11391, 30551, 30552, 2641, 2640, 30977, 31087, 2700, 31086
11392, 30552, 30553, 2642, 2641, 30979, 31088, 2701, 31087
11393, 30553, 30554, 2643, 2642, 30981, 31089, 2702, 31088
11394, 30554, 30555, 2644, 2643, 30983, 31090, 2703, 31089
11395, 30555, 30556, 2645, 2644, 30985, 31091, 2704, 31090
11396, 30556, 30557, 2646, 2645, 30987, 31092, 2705, 31091
11397, 30557, 30558, 2647, 2646, 30989, 31093, 2706, 31092
11398, 30558, 30559, 2648, 2647, 30991, 31094, 2707, 31093
11399, 30559, 30560, 2649, 2648, 30993, 31095, 2708, 31094
11400, 30560, 30561, 2650, 2649, 30995, 31096, 2709, 31095
11401, 30561, 30562, 2651, 2650, 30997, 31097, 2710, 31096
11402, 30562, 30563, 2652, 2651, 30999, 31098, 2711, 31097
11403, 30563, 30564, 2653, 2652, 31001, 31099, 2712, 31098
11404, 30564, 30565, 2654, 2653, 31003, 31100, 2713, 31099
11405, 30565, 30566, 2655, 2654, 31005, 31101, 2714, 31100
11406, 30566, 30567, 2656, 2655, 31007, 31102, 2715, 31101
11407, 30567, 30568, 2657, 2656, 31009, 31103, 2716, 31102
11408, 30568, 30569, 2658, 2657, 31011, 31104, 2717, 31103
11409, 30569, 30570, 2659, 2658, 31013, 31105, 2718, 31104
11410, 30570, 30571, 2660, 2659, 31015, 31106, 2719, 31105
11411, 30571, 30572, 2661, 2660, 31017, 31107, 2720, 31106
11412, 30572, 30573, 2662, 2661, 31019, 31108, 2721, 31107
11413, 30573, 30574, 2663, 2662, 31021, 31109, 2722, 31108
11414, 30574, 30575, 2664, 2663, 31023, 31110, 2723, 31109
11415, 30575, 30576, 2665, 2664, 31025, 31111, 2724, 31110
11416, 30576, 30577, 2666, 2665, 31027, 31112, 2725, 31111
11417, 30577, 30578, 2667, 2666, 31029, 31113, 2726, 31112
11418, 30578, 30579, 2668, 2667, 31031, 31114, 2727, 31113
11419, 30579, 30580, 2669, 2668, 31033, 31115, 2728, 31114
11420, 30580, 30581, 2670, 2669, 31035, 31116, 2729, 31115
11421, 30581, 30582, 2671, 2670, 31037, 31117, 2730, 31116
11422, 30582, 30583, 2672, 2671, 31039, 31118, 2731, 31117
11423, 30583, 30584, 2673, 2672, 31041, 31119, 2732, 31118
11424, 30584, 30585, 2674, 2673, 31043, 31120, 2733, 31119
11425, 30585, 30586, 2675, 2674, 31045, 31121, 2734, 31120
11426, 30586, 30587, 2676, 2675, 31047, 31122, 2735, 31121
11427, 30587, 30588, 2677, 2676, 31049, 31123, 2736, 31122
11428, 30588, 30589, 2678, 2677, 31051, 31124, 2737, 31123
11429, 30589, 30590, 2679, 2678, 31053, 31125, 2738, 31124
11430, 30590, 30591, 2680, 2679, 31055, 31126, 2739, 31125
11431, 30591, 30592, 2681, 2680, 31057, 31127, 2740, 31126
11432, 30592, 30593, 2682, 2681, 31059, 31128, 2741, 31127
11433, 30593, 30594, 2683, 2682, 31061, 31129, 2742, 31128
11434, 30594, 30595, 2684, 2683, 31063, 31130, 2743, 31129
11435, 30595, 30596, 2685, 2684, 31065, 31131, 2744, 31130
11436, 30596, 30597, 2686, 2685, 31067, 31132, 2745, 31131
11437, 30597, 30598, 2687, 2686, 31069, 31133, 2746, 31132
11438, 30598, 30599, 2688, 2687, 31071, 31134, 2747, 31133
11439, 30599, 30600, 2689, 2688, 31073, 31135, 2748, 31134
11440, 30600, 30601, 2690, 2689, 31075, 31136, 2749, 31135
11441, 30601, 30602, 2691, 2690, 31077, 31137, 2750, 31136
11442, 30602, 2624, 38, 2691, 31078, 2628, 2751, 31137
*ELEMENT, type=CPS8, ELSET=Surface22
11443, 3, 1476, 31138, 52, 1477, 31197, 31198, 111
11444, 52, 31138, 31139, 53, 31198, 31199, 31200, 112
11445, 53, 31139, 31140, 54, 31200, 31201, 31202, 113
11446, 54, 31140, 31141, 55, 31202, 31203, 31204, 114
11447, 55, 31141, 31142, 56, 31204, 31205, 31206, 115
11448, 56, 31142, 31143, 57, 31206, 31207, 31208, 116
11449, 57, 31143, 31144, 58, 31208, 31209, 31210, 117
11450, 58, 31144, 31145, 59, 31210, 31211, 31212, 118
11451, 59, 31145, 31146, 60, 31212, 31213, 31214, 119
11452, 60, 31146, 31147, 61, 31214, 31215, 31216, 120
11453, 61, 31147, 31148, 62, 31216, 31217, 31218, 121
11454, 62, 31148, 31149, 63, 31218, 31219, 31220, 122
11455, 63, 31149, 31150, 64, 31220, 31221, 31222, 123
11456, 64, 31150, 31151, 65, 31222, 31223, 31224, 124
11457, 65, 31151, 31152, 66, 31224, 31225, 31226, 125
11458, 66, 31152, 31153, 67, 31226, 31227, 31228, 126
11459, 67, 31153, 31154, 68, 31228, 31229, 31230, 127
11460, 68, 31154, 31155, 69, 31230, 31231, 31232, 128
11461, 69, 31155, 31156, 70, 31232, 31233, 31234, 129
11462, 70, 31156, 31157, 71, 31234, 31235, 31236, 130
11463, 71, 31157, 31158, 72, 31236, 31237, 31238, 131
11464, 72, 31158, 31159, 73, 31238, 31239, 31240, 132
11465, 73, 31159, 31160, 74, 31240, 31241, 31242, 133
11466, 74, 31160, 31161, 75, 31242, 31243, 31244, 134
11467, 75, 31161, 31162, 76, 31244, 31245, 31246, 135
11468, 76, 31162, 31163, 77, 31246, 31247, 31248, 136
11469, 77, 31163, 31164, 78, 31248, 31249, 31250, 137
11470, 78, 31164, 31165, 79, 31250, 31251, 31252, 138
11471, 79, 31165, 31166, 80, 31252, 31253, 31254, 139
11472, 80, 31166, 31167, 81, 31254, 31255, 31256, 140
11473, 81, 31167, 31168, 82, 31256, 31257, 31258, 141
11474, 82, 31168, 31169, 83, 31258, 31259, 31260, 142
11475, 83, 31169, 31170, 84, 31260, 31261, 31262, 143
11476, 84, 31170, 31171, 85, 31262, 31263, 31264, 144
11477, 85, 31171, 31172, 86, 31264, 31265, 31266, 145
11478, 86, 31172, 31173, 87, 31266, 31267, 31268, 146
11479, 87, 31173, 31174, 88, 31268, 31269, 31270, 147
11480, 88, 31174, 31175, 89, 31270, 31271, 31272, 148
11481, 89, 31175, 31176, 90, 31272, 31273, 31274, 149
11482, 90, 31176, 31177, 91, 31274, 31275, 31276, 150
11483, 91, 31177, 31178, 92, 31276, 31277, 31278, 151
11484, 92, 31178, 31179, 93, 31278, 31279, 31280, 152
11485, 93, 31179, 31180, 94, 31280, 31281, 31282, 153
11486, 94, 31180, 31181, 95, 31282, 31283, 31284, 154
11487, 95, 31181, 31182, 96, 31284, 31285, 31286, 155
11488, 96, 31182, 31183, 97, 31286, 31287, 31288, 156
11489, 97, 31183, 31184, 98, 31288, 31289, 31290, 157
11490, 98, 31184, 31185, 99, 31290, 31291, 31292, 158
11491, 99, 31185, 31186, 100, 31292, 31293, 31294, 159
11492, 100, 31186, 31187, 101, 31294, 31295, 31296, 160
11493, 101, 31187, 31188, 102, 31296, 31297, 31298, 161
11494, 102, 31188, 31189, 103, 31298, 31299, 31300, 162
11495, 103, 31189, 31190, 104, 31300, 31301, 31302, 163
11496, 104, 31190, 31191, 105, 31302, 31303, 31304, 164
11497, 105, 31191, 31192, 106, 31304, 31305, 31306, 165
11498, 106, 31192, 31193, 107, 31306, 31307, 31308, 166
11499, 107, 31193, 31194, 108, 31308, 31309, 31310, 167
11500, 108, 31194, 31195, 109, 31310, 31311, 31312, 168
11501, 109, 31195, 31196, 110, 31312, 31313, 31314, 169
11502, 110, 31196, 1479, 4, 31314, 31315, 1480, 170
11503, 1476, 10, 911, 31138, 1478, 970, 31316, 31197
11504, 31138, 911, 912, 31139, 31316, 971, 31317, 31199
11505, 31139, 912, 913, 31140, 31317, 972, 31318, 31201
11506, 31140, 913, 914, 31141, 31318, 973, 31319, 31203
11507, 31141, 914, 915, 31142, 31319, 974, 31320, 31205
11508, 31142, 915, 916, 31143, 31320, 975, 31321, 31207
11509, 31143, 916, 917, 31144, 31321, 976, 31322, 31209
11510, 31144, 917, 918, 31145, 31322, 977, 31323, 31211
11511, 31145, 918, 919, 31146, 31323, 978, 31324, 31213
11512, 31146, 919, 920, 31147, 31324, 979, 31325, 31215
11513, 31147, 920, 921, 31148, 31325, 980, 31326, 31217
11514, 31148, 921, 922, 31149, 31326, 981, 31327, 31219
11515, 31149, 922, 923, 31150, 31327, 982, 31328, 31221
11516, 31150, 923, 924, 31151, 31328, 983, 31329, 31223
11517, 31151, 924, 925, 31152, 31329, 984, 31330, 31225
11518, 31152, 925, 926, 31153, 31330, 985, 31331, 31227
11519, 31153, 926, 927, 31154, 31331, 986, 31332, 31229
11520, 31154, 927, 928, 31155, 31332, 987, 31333, 31231
11521, 31155, 928, 929, 31156, 31333, 988, 31334, 31233
11522, 31156, 929, 930, 31157, 31334, 989, 31335, 31235
11523, 31157, 930, 931, 31158, 31335, 990, 31336, 31237
11524, 31158, 931, 932, 31159, 31336, 991, 31337, 31239
11525, 31159, 932, 933, 31160, 31337, 992, 31338, 31241
11526, 31160, 933, 934, 31161, 31338, 993, 31339, 31243
11527, 31161, 934, 935, 31162, 31339, 994, 31340, 31245
11528, 31162, 935, 936, 31163, 31340, 995, 31341, 31247
11529, 31163, 936, 937, 31164, 31341, 996, 31342, 31249
11530, 31164, 937, 938, 31165, 31342, 997, 31343, 31251
11531, 31165, 938, 939, 31166, 31343, 998, 31344, 31253
11532, 31166, 939, 940, 31167, 31344, 999, 31345, 31255
11533, 31167, 940, 941, 31168, 31345, 1000, 31346, 31257
11534, 31168, 941, 942, 31169, 31346, 1001, 31347, 31259
11535, 31169, 942, 943, 31170, 31347, 1002, 31348, 31261
11536, 31170, 943, 944, 31171, 31348, 1003, 31349, 31263
11537, 31171, 944, 945, 31172, 31349, 1004, 31350, 31265
11538, 31172, 945, 946, 31173, 31350, 1005, 31351, 31267
11539, 31173, 946, 947, 31174, 31351, 1006, 31352, 31269
11540, 31174, 947, 948, 31175, 31352, 1007, 31353, 31271
11541, 31175, 948, 949, 31176, 31353, 1008, 31354, 31273
11542, 31176, 949, 950, 31177, 31354, 1009, 31355, 31275
11543, 31177, 950, 951, 31178, 31355, 1010, 31356, 31277
11544, 31178, 951, 952, 31179, 31356, 1011, 31357, 31279
11545, 31179, 952, 953, 31180, 31357, 1012, 31358, 31281
11546, 31180, 953, 954, 31181, 31358, 1013, 31359, 31283
11547, 31181, 954, 955, 31182, 31359, 1014, 31360, 31285
11548, 31182, 955, 956, 31183, 31360, 1015, 31361, 31287
11549, 31183, 956, 957, 31184, 31361, 1016, 31362, 31289
11550, 31184, 957, 958, 31185, 31362, 1017, 31363, 31291
11551, 31185, 958, 959, 31186, 31363, 1018, 31364, 31293
11552, 31186, 959, 960, 31187, 31364, 1019, 31365, 31295
11553, 31187, 960, 961, 31188, 31365, 1020, 31366, 31297
11554, 31188, 961, 962, 31189, 31366, 1021, 31367, 31299
11555, 31189, 962, 963, 31190, 31367, 1022, 31368, 31301
11556, 31190, 963, 964, 31191, 31368, 1023, 31369, 31303
11557, 31191, 964, 965, 31192, 31369, 1024, 31370, 31305
11558, 31192, 965, 966, 31193, 31370, 1025, 31371, 31307
11559, 31193, 966, 967, 31194, 31371, 1026, 31372, 31309
11560, 31194, 967, 968, 31195, 31372, 1027, 31373, 31311
11561, 31195, 968, 969, 31196, 31373, 1028, 31374, 31313
11562, 31196, 969, 12, 1479, 31374, 1029, 1481, 31315
*ELEMENT, type=CPS8, ELSET=Surface25
11563, 5, 2188, 31375, 171, 2189, 31434, 31435, 230
11564, 171, 31375, 31376, 172, 31435, 31436, 31437, 231
11565, 172, 31376, 31377, 173, 31437, 31438, 31439, 232
11566, 173, 31377, 31378, 174, 31439, 31440, 31441, 233
11567, 174, 31378, 31379, 175, 31441, 31442, 31443, 234
11568, 175, 31379, 31380, 176, 31443, 31444, 31445, 235
11569, 176, 31380, 31381, 177, 31445, 31446, 31447, 236
11570, 177, 31381, 31382, 178, 31447, 31448, 31449, 237
11571, 178, 31382, 31383, 179, 31449, 31450, 31451, 238
11572, 179, 31383, 31384, 180, 31451, 31452, 31453, 239
11573, 180, 31384, 31385, 181, 31453, 31454, 31455, 240
11574, 181, 31385, 31386, 182, 31455, 31456, 31457, 241
11575, 182, 31386, 31387, 183, 31457, 31458, 31459, 242
11576, 183, 31387, 31388, 184, 31459, 31460, 31461, 243
11577, 184, 31388, 31389, 185, 31461, 31462, 31463, 244
11578, 185, 31389, 31390, 186, 31463, 31464, 31465, 245
11579, 186, 31390, 31391, 187, 31465, 31466, 31467, 246
11580, 187, 31391, 31392, 188, 31467, 31468, 31469, 247
11581, 188, 31392, 31393, 189, 31469, 31470, 31471, 248
11582, 189, 31393, 31394, 190, 31471, 31472, 31473, 249
11583, 190, 31394, 31395, 191, 31473, 31474, 31475, 250
11584, 191, 31395, 31396, 192, 31475, 31476, 31477, 251
11585, 192, 31396, 31397, 193, 31477, 31478, 31479, 252
11586, 193, 31397, 31398, 194, 31479, 31480, 31481, 253
11587, 194, 31398, 31399, 195, 31481, 31482, 31483, 254
11588, 195, 31399, 31400, 196, 31483, 31484, 31485, 255
11589, 196, 31400, 31401, 197, 31485, 31486, 31487, 256
11590, 197, 31401, 31402, 198, 31487, 31488, 31489, 257
11591, 198, 31402, 31403, 199, 31489, 31490, 31491, 258
11592, 199, 31403, 31404, 200, 31491, 31492, 31493, 259
11593, 200, 31404, 31405, 201, 31493, 31494, 31495, 260
11594, 201, 31405, 31406, 202, 31495, 31496, 31497, 261
11595, 202, 31406, 31407, 203, 31497, 31498, 31499, 262
11596, 203, 31407, 31408, 204, 31499, 31500, 31501, 263
11597, 204, 31408, 31409, 205, 31501, 31502, 31503, 264
11598, 205, 31409, 31410, 206, 31503, 31504, 31505, 265
11599, 206, 31410, 31411, 207, 31505, 31506, 31507, 266
11600, 207, 31411, 31412, 208, 31507, 31508, 31509, 267
11601, 208, 31412, 31413, 209, 31509, 31510, 31511, 268
11602, 209, 31413, 31414, 210, 31511, 31512, 31513, 269
11603, 210, 31414, 31415, 211, 31513, 31514, 31515, 270
11604, 211, 31415, 31416, 212, 31515, 31516, 31517, 271
11605, 212, 31416, 31417, 213, 31517, 31518, 31519, 272
11606, 213, 31417, 31418, 214, 31519, 31520, 31521, 273
11607, 214, 31418, 31419, 215, 31521, 31522, 31523, 274
11608, 215, 31419, 31420, 216, 31523, 31524, 31525, 275
11609, 216, 31420, 31421, 217, 31525, 31526, 31527, 276
11610, 217, 31421, 31422, 218, 31527, 31528, 31529, 277
11611, 218, 31422, 31423, 219, 31529, 31530, 31531, 278
11612, 219, 31423, 31424, 220, 31531, 31532, 31533, 279
11613, 220, 31424, 31425, 221, 31533, 31534, 31535, 280
11614, 221, 31425, 31426, 222, 31535, 31536, 31537, 281
11615, 222, 31426, 31427, 223, 31537, 31538, 31539, 282
11616, 223, 31427, 31428, 224, 31539, 31540, 31541, 283
11617, 224, 31428, 31429, 225, 31541, 31542, 31543, 284
11618, 225, 31429, 31430, 226, 31543, 31544, 31545, 285
11619, 226, 31430, 31431, 227, 31545, 31546, 31547, 286
11620, 227, 31431, 31432, 228, 31547, 31548, 31549, 287
11621, 228, 31432, 31433, 229, 31549, 31550, 31551, 288
11622, 229, 31433, 2191, 6, 31551, 31552, 2192, 289
11623, 2188, 29, 1790, 31375, 2190, 1849, 31553, 31434
11624, 31375, 1790, 1791, 31376, 31553, 1850, 31554, 31436
11625, 31376, 1791, 1792, 31377, 31554, 1851, 31555, 31438
11626, 31377, 1792, 1793, 31378, 31555, 1852, 31556, 31440
11627, 31378, 1793, 1794, 31379, 31556, 1853, 31557, 31442
11628, 31379, 1794, 1795, 31380, 31557, 1854, 31558, 31444
11629, 31380, 1795, 1796, 31381, 31558, 1855, 31559, 31446
11630, 31381, 1796, 1797, 31382, 31559, 1856, 31560, 31448
11631, 31382, 1797, 1798, 31383, 31560, 1857, 31561, 31450
11632, 31383, 1798, 1799, 31384, 31561, 1858, 31562, 31452
11633, 31384, 1799, 1800, 31385, 31562, 1859, 31563, 31454
11634, 31385, 1800, 1801, 31386, 31563, 1860, 31564, 31456
11635, 31386, 1801, 1802, 31387, 31564, 1861, 31565, 31458
11636, 31387, 1802, 1803, 31388, 31565, 1862, 31566, 31460
11637, 31388, 1803, 1804, 31389, 31566, 1863, 31567, 31462
11638, 31389, 1804, 1805, 31390, 31567, 1864, 31568, 31464
11639, 31390, 1805, 1806, 31391, 31568, 1865, 31569, 31466
11640, 31391, 1806, 1807, 31392, 31569, 1866, 31570, 31468
11641, 31392, 1807, 1808, 31393, 31570, 1867, 31571, 31470
11642, 31393, 1808, 1809, 31394, 31571, 1868, 31572, 31472
11643, 31394, 1809, 1810, 31395, 31572, 1869, 31573, 31474
11644, 31395, 1810, 1811, 31396, 31573, 1870, 31574, 31476
11645, 31396, 1811, 1812, 31397, 31574, 1871, 31575, 31478
11646, 31397, 1812, 1813, 31398, 31575, 1872, 31576, 31480
11647, 31398, 1813, 1814, 31399, 31576, 1873, 31577, 31482
11648, 31399, 1814, 1815, 31400, 31577, 1874, 31578, 31484
11649, 31400, 1815, 1816, 31401, 31578, 1875, 31579, 31486
11650, 31401, 1816, 1817, 31402, 31579, 1876, 31580, 31488
11651, 31402, 1817, 1818, 31403, 31580, 1877, 31581, 31490
11652, 31403, 1818, 1819, 31404, 31581, 1878, 31582, 31492
11653, 31404, 1819, 1820, 31405, 31582, 1879, 31583, 31494
11654, 31405, 1820, 1821, 31406, 31583, 1880, 31584, 31496
11655, 31406, 1821, 1822, 31407, 31584, 1881, 31585, 31498
11656, 31407, 1822, 1823, 31408, 31585, 1882, 31586, 31500
11657, 31408, 1823, 1824, 31409, 31586, 1883, 31587, 31502
11658, 31409, 1824, 1825, 31410, 31587, 1884, 31588, 31504
11659, 31410, 1825, 1826, 31411, 31588, 1885, 31589, 31506
11660, 31411, 1826, 1827, 31412, 31589, 1886, 31590, 31508
11661, 31412, 1827, 1828, 31413, 31590, 1887, 31591, 31510
11662, 31413, 1828, 1829, 31414, 31591, 1888, 31592, 31512
11663, 31414, 1829, 1830, 31415, 31592, 1889, 31593, 31514
11664, 31415, 1830, 1831, 31416, 31593, 1890, 31594, 31516
11665, 31416, 1831, 1832, 31417, 31594, 1891, 31595, 31518
11666, 31417, 1832, 1833, 31418, 31595, 1892, 31596, 31520
11667, 31418, 1833, 1834, 31419, 31596, 1893, 31597, 31522
11668, 31419, 1834, 1835, 31420, 31597, 1894, 31598, 31524
11669, 31420, 1835, 1836, 31421, 31598, 1895, 31599, 31526
11670, 31421, 1836, 1837, 31422, 31599, 1896, 31600, 31528
11671, 31422, 1837, 1838, 31423, 31600, 1897, 31601, 31530
11672, 31423, 1838, 1839, 31424, 31601, 1898, 31602, 31532
11673, 31424, 1839, 1840, 31425, 31602, 1899, 31603, 31534
11674, 31425, 1840, 1841, 31426, 31603, 1900, 31604, 31536
11675, 31426, 1841, 1842, 31427, 31604, 1901, 31605, 31538
11676, 31427, 1842, 1843, 31428, 31605, 1902, 31606, 31540
11677, 31428, 1843, 1844, 31429, 31606, 1903, 31607, 31542
11678, 31429, 1844, 1845, 31430, 31607, 1904, 31608, 31544
11679, 31430, 1845, 1846, 31431, 31608, 1905, 31609, 31546
11680, 31431, 1846, 1847, 31432, 31609, 1906, 31610, 31548
11681, 31432, 1847, 1848, 31433, 31610, 1907, 31611, 31550
11682, 31433, 1848, 30, 2191, 31611, 1908, 2193, 31552
*ELEMENT, type=CPS8, ELSET=Surface26
11683, 11, 2194, 31612, 1030, 2195, 31671, 31672, 1089
11684, 1030, 31612, 31613, 1031, 31672, 31673, 31674, 1090
11685, 1031, 31613, 31614, 1032, 31674, 31675, 31676, 1091
11686, 1032, 31614, 31615, 1033, 31676, 31677, 31678, 1092
11687, 1033, 31615, 31616, 1034, 31678, 31679, 31680, 1093
11688, 1034, 31616, 31617, 1035, 31680, 31681, 31682, 1094
11689, 1035, 31617, 31618, 1036, 31682, 31683, 31684, 1095
11690, 1036, 31618, 31619, 1037, 31684, 31685, 31686, 1096
11691, 1037, 31619, 31620, 1038, 31686, 31687, 31688, 1097
11692, 1038, 31620, 31621, 1039, 31688, 31689, 31690, 1098
11693, 1039, 31621, 31622, 1040, 31690, 31691, 31692, 1099
11694, 1040, 31622, 31623, 1041, 31692, 31693, 31694, 1100
11695, 1041, 31623, 31624, 1042, 31694, 31695, 31696, 1101
11696, 1042, 31624, 31625, 1043, 31696, 31697, 31698, 1102
11697, 1043, 31625, 31626, 1044, 31698, 31699, 31700, 1103
11698, 1044, 31626, 31627, 1045, 31700, 31701, 31702, 1104
11699, 1045, 31627, 31628, 1046, 31702, 31703, 31704, 1105
11700, 1046, 31628, 31629, 1047, 31704, 31705, 31706, 1106
11701, 1047, 31629, 31630, 1048, 31706, 31707, 31708, 1107
11702, 1048, 31630, 31631, 1049, 31708, 31709, 31710, 1108
11703, 1049, 31631, 31632, 1050, 31710, 31711, 31712, 1109
11704, 1050, 31632, 31633, 1051, 31712, 31713, 31714, 1110
11705, 1051, 31633, 31634, 1052, 31714, 31715, 31716, 1111
11706, 1052, 31634, 31635, 1053, 31716, 31717, 31718, 1112
11707, 1053, 31635, 31636, 1054, 31718, 31719, 31720, 1113
11708, 1054, 31636, 31637, 1055, 31720, 31721, 31722, 1114
11709, 1055, 31637, 31638, 1056, 31722, 31723, 31724, 1115
11710, 1056, 31638, 31639, 1057, 31724, 31725, 31726, 1116
11711, 1057, 31639, 31640, 1058, 31726, 31727, 31728, 1117
11712, 1058, 31640, 31641, 1059, 31728, 31729, 31730, 1118
11713, 1059, 31641, 31642, 1060, 31730, 31731, 31732, 1119
11714, 1060, 31642, 31643, 1061, 31732, 31733, 31734, 1120
11715, 1061, 31643, 31644, 1062, 31734, 31735, 31736, 1121
11716, 1062, 31644, 31645, 1063, 31736, 31737, 31738, 1122
11717, 1063, 31645, 31646, 1064, 31738, 31739, 31740, 1123
11718, 1064, 31646, 31647, 1065, 31740, 31741, 31742, 1124
11719, 1065, 31647, 31648, 1066, 31742, 31743, 31744, 1125
11720, 1066, 31648, 31649, 1067, 31744, 31745, 31746, 1126
11721, 1067, 31649, 31650, 1068, 31746, 31747, 31748, 1127
11722, 1068, 31650, 31651, 1069, 31748, 31749, 31750, 1128
11723, 1069, 31651, 31652, 1070, 31750, 31751, 31752, 1129
11724, 1070, 31652, 31653, 1071, 31752, 31753, 31754, 1130
11725, 1071, 31653, 31654, 1072, 31754, 31755, 31756, 1131
11726, 1072, 31654, 31655, 1073, 31756, 31757, 31758, 1132
11727, 1073, 31655, 31656, 1074, 31758, 31759, 31760, 1133
11728, 1074, 31656, 31657, 1075, 31760, 31761, 31762, 1134
11729, 1075, 31657, 31658, 1076, 31762, 31763, 31764, 1135
11730, 1076, 31658, 31659, 1077, 31764, 31765, 31766, 1136
11731, 1077, 31659, 31660, 1078, 31766, 31767, 31768, 1137
11732, 1078, 31660, 31661, 1079, 31768, 31769, 31770, 1138
11733, 1079, 31661, 31662, 1080, 31770, 31771, 31772, 1139
11734, 1080, 31662, 31663, 1081, 31772, 31773, 31774, 1140
11735, 1081, 31663, 31664, 1082, 31774, 31775, 31776, 1141
11736, 1082, 31664, 31665, 1083, 31776, 31777, 31778, 1142
11737, 1083, 31665, 31666, 1084, 31778, 31779, 31780, 1143
11738, 1084, 31666, 31667, 1085, 31780, 31781, 31782, 1144
11739, 1085, 31667, 31668, 1086, 31782, 31783, 31784, 1145
11740, 1086, 31668, 31669, 1087, 31784, 31785, 31786, 1146
11741, 1087, 31669, 31670, 1088, 31786, 31787, 31788, 1147
11742, 1088, 31670, 2197, 13, 31788, 31789, 2198, 1148
11743, 2194, 27, 1649, 31612, 2196, 1708, 31790, 31671
11744, 31612, 1649, 1650, 31613, 31790, 1709, 31791, 31673
11745, 31613, 1650, 1651, 31614, 31791, 1710, 31792, 31675
11746, 31614, 1651, 1652, 31615, 31792, 1711, 31793, 31677
11747, 31615, 1652, 1653, 31616, 31793, 1712, 31794, 31679
11748, 31616, 1653, 1654, 31617, 31794, 1713, 31795, 31681
11749, 31617, 1654, 1655, 31618, 31795, 1714, 31796, 31683
11750, 31618, 1655, 1656, 31619, 31796, 1715, 31797, 31685
11751, 31619, 1656, 1657, 31620, 31797, 1716, 31798, 31687
11752, 31620, 1657, 1658, 31621, 31798, 1717, 31799, 31689
11753, 31621, 1658, 1659, 31622, 31799, 1718, 31800, 31691
11754, 31622, 1659, 1660, 31623, 31800, 1719, 31801, 31693
11755, 31623, 1660, 1661, 31624, 31801, 1720, 31802, 31695
11756, 31624, 1661, 1662, 31625, 31802, 1721, 31803, 31697
11757, 31625, 1662, 1663, 31626, 31803, 1722, 31804, 31699
11758, 31626, 1663, 1664, 31627, 31804, 1723, 31805, 31701
11759, 31627, 1664, 1665, 31628, 31805, 1724, 31806, 31703
11760, 31628, 1665, 1666, 31629, 31806, 1725, 31807, 31705
11761, 31629, 1666, 1667, 31630, 31807, 1726, 31808, 31707
11762, 31630, 1667, 1668, 31631, 31808, 1727, 31809, 31709
11763, 31631, 1668, 1669, 31632, 31809, 1728, 31810, 31711
11764, 31632, 1669, 1670, 31633, 31810, 1729, 31811, 31713
11765, 31633, 1670, 1671, 31634, 31811, 1730, 31812, 31715
11766, 31634, 1671, 1672, 31635, 31812, 1731, 31813, 31717
11767, 31635, 1672, 1673, 31636, 31813, 1732, 31814, 31719
11768, 31636, 1673, 1674, 31637, 31814, 1733, 31815, 31721
11769, 31637, 1674, 1675, 31638, 31815, 1734, 31816, 31723
11770, 31638, 1675, 1676, 31639, 31816, 1735, 31817, 31725
11771, 31639, 1676, 1677, 31640, 31817, 1736, 31818, 31727
11772, 31640, 1677, 1678, 31641, 31818, 1737, 31819, 31729
11773, 31641, 1678, 1679, 31642, 31819, 1738, 31820, 31731
11774, 31642, 1679, 1680, 31643, 31820, 1739, 31821, 31733
11775, 31643, 1680, 1681, 31644, 31821, 1740, 31822, 31735
11776, 31644, 1681, 1682, 31645, 31822, 1741, 31823, 31737
11777, 31645, 1682, 1683, 31646, 31823, 1742, 31824, 31739
11778, 31646, 1683, 1684, 31647, 31824, 1743, 31825, 31741
11779, 31647, 1684, 1685, 31648, 31825, 1744, 31826, 31743
11780, 31648, 1685, 1686, 31649, 31826, 1745, 31827, 31745
11781, 31649, 1686, 1687, 31650, 31827, 1746, 31828, 31747
11782, 31650, 1687, 1688, 31651, 31828, 1747, 31829, 31749
11783, 31651, 1688, 1689, 31652, 31829, 1748, 31830, 31751
11784, 31652, 1689, 1690, 31653, 31830, 1749, 31831, 31753
11785, 31653, 1690, 1691, 31654, 31831, 1750, 31832, 31755
11786, 31654, 1691, 1692, 31655, 31832, 1751, 31833, 31757
11787, 31655, 1692, 1693, 31656, 31833, 1752, 31834, 31759
11788, 31656, 1693, 1694, 31657, 31834, 1753, 31835, 31761
11789, 31657, 1694, 1695, 31658, 31835, 1754, 31836, 31763
11790, 31658, 1695, 1696, 31659, 31836, 1755, 31837, 31765
11791, 31659, 1696, 1697, 31660, 31837, 1756, 31838, 31767
11792, 31660, 1697, 1698, 31661, 31838, 1757, 31839, 31769
11793, 31661, 1698, 1699, 31662, 31839, 1758, 31840, 31771
11794, 31662, 1699, 1700, 31663, 31840, 1759, 31841, 31773
11795, 31663, 1700, 1701, 31664, 31841, 1760, 31842, 31775
11796, 31664, 1701, 1702, 31665, 31842, 1761, 31843, 31777
11797, 31665, 1702, 1703, 31666, 31843, 1762, 31844, 31779
11798, 31666, 1703, 1704, 31667, 31844, 1763, 31845, 31781
11799, 31667, 1704, 1705, 31668, 31845, 1764, 31846, 31783
11800, 31668, 1705, 1706, 31669, 31846, 1765, 31847, 31785
11801, 31669, 1706, 1707, 31670, 31847, 1766, 31848, 31787
11802, 31670, 1707, 28, 2197, 31848, 1767, 2199, 31789
*ELEMENT, type=CPS8, ELSET=Surface27
11803, 7, 2200, 31849, 409, 2201, 31908, 31909, 468
11804, 409, 31849, 31850, 410, 31909, 31910, 31911, 469
11805, 410, 31850, 31851, 411, 31911, 31912, 31913, 470
11806, 411, 31851, 31852, 412, 31913, 31914, 31915, 471
11807, 412, 31852, 31853, 413, 31915, 31916, 31917, 472
11808, 413, 31853, 31854, 414, 31917, 31918, 31919, 473
11809, 414, 31854, 31855, 415, 31919, 31920, 31921, 474
11810, 415, 31855, 31856, 416, 31921, 31922, 31923, 475
11811, 416, 31856, 31857, 417, 31923, 31924, 31925, 476
11812, 417, 31857, 31858, 418, 31925, 31926, 31927, 477
11813, 418, 31858, 31859, 419, 31927, 31928, 31929, 478
11814, 419, 31859, 31860, 420, 31929, 31930, 31931, 479
11815, 420, 31860, 31861, 421, 31931, 31932, 31933, 480
11816, 421, 31861, 31862, 422, 31933, 31934, 31935, 481
11817, 422, 31862, 31863, 423, 31935, 31936, 31937, 482
11818, 423, 31863, 31864, 424, 31937, 31938, 31939, 483
11819, 424, 31864, 31865, 425, 31939, 31940, 31941, 484
11820, 425, 31865, 31866, 426, 31941, 31942, 31943, 485
11821, 426, 31866, 31867, 427, 31943, 31944, 31945, 486
11822, 427, 31867, 31868, 428, 31945, 31946, 31947, 487
11823, 428, 31868, 31869, 429, 31947, 31948, 31949, 488
11824, 429, 31869, 31870, 430, 31949, 31950, 31951, 489
11825, 430, 31870, 31871, 431, 31951, 31952, 31953, 490
11826, 431, 31871, 31872, 432, 31953, 31954, 31955, 491
11827, 432, 31872, 31873, 433, 31955, 31956, 31957, 492
11828, 433, 31873, 31874, 434, 31957, 31958, 31959, 493
11829, 434, 31874, 31875, 435, 31959, 31960, 31961, 494
11830, 435, 31875, 31876, 436, 31961, 31962, 31963, 495
11831, 436, 31876, 31877, 437, 31963, 31964, 31965, 496
11832, 437, 31877, 31878, 438, 31965, 31966, 31967, 497
11833, 438, 31878, 31879, 439, 31967, 31968, 31969, 498
11834, 439, 31879, 31880, 440, 31969, 31970, 31971, 499
11835, 440, 31880, 31881, 441, 31971, 31972, 31973, 500
11836, 441, 31881, 31882, 442, 31973, 31974, 31975, 501
11837, 442, 31882, 31883, 443, 31975, 31976, 31977, 502
11838, 443, 31883, 31884, 444, 31977, 31978, 31979, 503
11839, 444, 31884, 31885, 445, 31979, 31980, 31981, 504
11840, 445, 31885, 31886, 446, 31981, 31982, 31983, 505
11841, 446, 31886, 31887, 447, 31983, 31984, 31985, 506
11842, 447, 31887, 31888, 448, 31985, 31986, 31987, 507
11843, 448, 31888, 31889, 449, 31987, 31988, 31989, 508
11844, 449, 31889, 31890, 450, 31989, 31990, 31991, 509
11845, 450, 31890, 31891, 451, 31991, 31992, 31993, 510
11846, 451, 31891, 31892, 452, 31993, 31994, 31995, 511
11847, 452, 31892, 31893, 453, 31995, 31996, 31997, 512
11848, 453, 31893, 31894, 454, 31997, 31998, 31999, 513
11849, 454, 31894, 31895, 455, 31999, 32000, 32001, 514
11850, 455, 31895, 31896, 456, 32001, 32002, 32003, 515
11851, 456, 31896, 31897, 457, 32003, 32004, 32005, 516
11852, 457, 31897, 31898, 458, 32005, 32006, 32007, 517
11853, 458, 31898, 31899, 459, 32007, 32008, 32009, 518
11854, 459, 31899, 31900, 460, 32009, 32010, 32011, 519
11855, 460, 31900, 31901, 461, 32011, 32012, 32013, 520
11856, 461, 31901, 31902, 462, 32013, 32014, 32015, 521
11857, 462, 31902, 31903, 463, 32015, 32016, 32017, 522
11858, 463, 31903, 31904, 464, 32017, 32018, 32019, 523
11859, 464, 31904, 31905, 465, 32019, 32020, 32021, 524
11860, 465, 31905, 31906, 466, 32021, 32022, 32023, 525
11861, 466, 31906, 31907, 467, 32023, 32024, 32025, 526
11862, 467, 31907, 2203, 8, 32025, 32026, 2204, 527
11863, 2200, 25, 1493, 31849, 2202, 1552, 32027, 31908
11864, 31849, 1493, 1494, 31850, 32027, 1553, 32028, 31910
11865, 31850, 1494, 1495, 31851, 32028, 1554, 32029, 31912
11866, 31851, 1495, 1496, 31852, 32029, 1555, 32030, 31914
11867, 31852, 1496, 1497, 31853, 32030, 1556, 32031, 31916
11868, 31853, 1497, 1498, 31854, 32031, 1557, 32032, 31918
11869, 31854, 1498, 1499, 31855, 32032, 1558, 32033, 31920
11870, 31855, 1499, 1500, 31856, 32033, 1559, 32034, 31922
11871, 31856, 1500, 1501, 31857, 32034, 1560, 32035, 31924
11872, 31857, 1501, 1502, 31858, 32035, 1561, 32036, 31926
11873, 31858, 1502, 1503, 31859, 32036, 1562, 32037, 31928
11874, 31859, 1503, 1504, 31860, 32037, 1563, 32038, 31930
11875, 31860, 1504, 1505, 31861, 32038, 1564, 32039, 31932
11876, 31861, 1505, 1506, 31862, 32039, 1565, 32040, 31934
11877, 31862, 1506, 1507, 31863, 32040, 1566, 32041, 31936
11878, 31863, 1507, 1508, 31864, 32041, 1567, 32042, 31938
11879, 31864, 1508, 1509, 31865, 32042, 1568, 32043, 31940
11880, 31865, 1509, 1510, 31866, 32043, 1569, 32044, 31942
11881, 31866, 1510, 1511, 31867, 32044, 1570, 32045, 31944
11882, 31867, 1511, 1512, 31868, 32045, 1571, 32046, 31946
11883, 31868, 1512, 1513, 31869, 32046, 1572, 32047, 31948
11884, 31869, 1513, 1514, 31870, 32047, 1573, 32048, 31950
11885, 31870, 1514, 1515, 31871, 32048, 1574, 32049, 31952
11886, 31871, 1515, 1516, 31872, 32049, 1575, 32050, 31954
11887, 31872, 1516, 1517, 31873, 32050, 1576, 32051, 31956
11888, 31873, 1517, 1518, 31874, 32051, 1577, 32052, 31958
11889, 31874, 1518, 1519, 31875, 32052, 1578, 32053, 31960
11890, 31875, 1519, 1520, 31876, 32053, 1579, 32054, 31962
11891, 31876, 1520, 1521, 31877, 32054, 1580, 32055, 31964
11892, 31877, 1521, 1522, 31878, 32055, 1581, 32056, 31966
11893, 31878, 1522, 1523, 31879, 32056, 1582, 32057, 31968
11894, 31879, 1523, 1524, 31880, 32057, 1583, 32058, 31970
11895, 31880, 1524, 1525, 31881, 32058, 1584, 32059, 31972
11896, 31881, 1525, 1526, 31882, 32059, 1585, 32060, 31974
11897, 31882, 1526, 1527, 31883, 32060, 1586, 32061, 31976
11898, 31883, 1527, 1528, 31884, 32061, 1587, 32062, 31978
11899, 31884, 1528, 1529, 31885, 32062, 1588, 32063, 31980
11900, 31885, 1529, 1530, 31886, 32063, 1589, 32064, 31982
11901, 31886, 1530, 1531, 31887, 32064, 1590, 32065, 31984
11902, 31887, 1531, 1532, 31888, 32065, 1591, 32066, 31986
11903, 31888, 1532, 1533, 31889, 32066, 1592, 32067, 31988
11904, 31889, 1533, 1534, 31890, 32067, 1593, 32068, 31990
11905, 31890, 1534, 1535, 31891, 32068, 1594, 32069, 31992
11906, 31891, 1535, 1536, 31892, 32069, 1595, 32070, 31994
11907, 31892, 1536, 1537, 31893, 32070, 1596, 32071, 31996
11908, 31893, 1537, 1538, 31894, 32071, 1597, 32072, 31998
11909, 31894, 1538, 1539, 31895, 32072, 1598, 32073, 32000
11910, 31895, 1539, 1540, 31896, 32073, 1599, 32074, 32002
11911, 31896, 1540, 1541, 31897, 32074, 1600, 32075, 32004
11912, 31897, 1541, 1542, 31898, 32075, 1601, 32076, 32006
11913, 31898, 1542, 1543, 31899, 32076, 1602, 32077, 32008
11914, 31899, 1543, 1544, 31900, 32077, 1603, 32078, 32010
11915, 31900, 1544, 1545, 31901, 32078, 1604, 32079, 32012
11916, 31901, 1545, 1546, 31902, 32079, 1605, 32080, 32014
11917, 31902, 1546, 1547, 31903, 32080, 1606, 32081, 32016
11918, 31903, 1547, 1548, 31904, 32081, 1607, 32082, 32018
11919, 31904, 1548, 1549, 31905, 32082, 1608, 32083, 32020
11920, 31905, 1549, 1550, 31906, 32083, 1609, 32084, 32022
11921, 31906, 1550, 1551, 31907, 32084, 1610, 32085, 32024
11922, 31907, 1551, 26, 2203, 32085, 1611, 2205, 32026
*ELEMENT, type=CPS8, ELSET=Surface28
11923, 14, 2206, 32086, 1282, 2213, 32114, 32115, 1286
11924, 1282, 32086, 32087, 1283, 32115, 32116, 32117, 1287
11925, 1283, 32087, 32088, 1284, 32117, 32118, 32119, 1288
11926, 1284, 32088, 32089, 1285, 32119, 32120, 32121, 1289
11927, 1285, 32089, 2221, 19, 32121, 32122, 2228, 1290
11928, 2206, 2207, 32090, 32086, 2214, 32123, 32124, 32114
11929, 32086, 32090, 32091, 32087, 32124, 32125, 32126, 32116
11930, 32087, 32091, 32092, 32088, 32126, 32127, 32128, 32118
11931, 32088, 32092, 32093, 32089, 32128, 32129, 32130, 32120
11932, 32089, 32093, 2222, 2221, 32130, 32131, 2229, 32122
11933, 2207, 2208, 32094, 32090, 2215, 32132, 32133, 32123
11934, 32090, 32094, 32095, 32091, 32133, 32134, 32135, 32125
11935, 32091, 32095, 32096, 32092, 32135, 32136, 32137, 32127
11936, 32092, 32096, 32097, 32093, 32137, 32138, 32139, 32129
11937, 32093, 32097, 2223, 2222, 32139, 32140, 2230, 32131
11938, 2208, 2209, 32098, 32094, 2216, 32141, 32142, 32132
11939, 32094, 32098, 32099, 32095, 32142, 32143, 32144, 32134
11940, 32095, 32099, 32100, 32096, 32144, 32145, 32146, 32136
11941, 32096, 32100, 32101, 32097, 32146, 32147, 32148, 32138
11942, 32097, 32101, 2224, 2223, 32148, 32149, 2231, 32140
11943, 2209, 2210, 32102, 32098, 2217, 32150, 32151, 32141
11944, 32098, 32102, 32103, 32099, 32151, 32152, 32153, 32143
11945, 32099, 32103, 32104, 32100, 32153, 32154, 32155, 32145
11946, 32100, 32104, 32105, 32101, 32155, 32156, 32157, 32147
11947, 32101, 32105, 2225, 2224, 32157, 32158, 2232, 32149
11948, 2210, 2211, 32106, 32102, 2218, 32159, 32160, 32150
11949, 32102, 32106, 32107, 32103, 32160, 32161, 32162, 32152
11950, 32103, 32107, 32108, 32104, 32162, 32163, 32164, 32154
11951, 32104, 32108, 32109, 32105, 32164, 32165, 32166, 32156
11952, 32105, 32109, 2226, 2225, 32166, 32167, 2233, 32158
11953, 2211, 2212, 32110, 32106, 2219, 32168, 32169, 32159
11954, 32106, 32110, 32111, 32107, 32169, 32170, 32171, 32161
11955, 32107, 32111, 32112, 32108, 32171, 32172, 32173, 32163
11956, 32108, 32112, 32113, 32109, 32173, 32174, 32175, 32165
11957, 32109, 32113, 2227, 2226, 32175, 32176, 2234, 32167
11958, 2212, 31, 2044, 32110, 2220, 2048, 32177, 32168
11959, 32110, 2044, 2045, 32111, 32177, 2049, 32178, 32170
11960, 32111, 2045, 2046, 32112, 32178, 2050, 32179, 32172
11961, 32112, 2046, 2047, 32113, 32179, 2051, 32180, 32174
11962, 32113, 2047, 33, 2227, 32180, 2052, 2235, 32176
*ELEMENT, type=CPS8, ELSET=Surface31
11963, 39, 2752, 32181, 2762, 2754, 32189, 32190, 2766
11964, 2762, 32181, 32182, 2763, 32190, 32191, 32192, 2767
11965, 2763, 32182, 32183, 2764, 32192, 32193, 32194, 2768
11966, 2764, 32183, 32184, 2765, 32194, 32195, 32196, 2769
11967, 2765, 32184, 2757, 40, 32196, 32197, 2759, 2770
11968, 2752, 2753, 32185, 32181, 2755, 32198, 32199, 32189
11969, 32181, 32185, 32186, 32182, 32199, 32200, 32201, 32191
11970, 32182, 32186, 32187, 32183, 32201, 32202, 32203, 32193
11971, 32183, 32187, 32188, 32184, 32203, 32204, 32205, 32195
11972, 32184, 32188, 2758, 2757, 32205, 32206, 2760, 32197
11973, 2753, 38, 2624, 32185, 2756, 2628, 32207, 32198
11974, 32185, 2624, 2625, 32186, 32207, 2629, 32208, 32200
11975, 32186, 2625, 2626, 32187, 32208, 2630, 32209, 32202
11976, 32187, 2626, 2627, 32188, 32209, 2631, 32210, 32204
11977, 32188, 2627, 36, 2758, 32210, 2632, 2761, 32206
*ELEMENT, type=CPS8, ELSET=Surface32
11978, 41, 2771, 32211, 2781, 2773, 32219, 32220, 2785
11979, 2781, 32211, 32212, 2782, 32220, 32221, 32222, 2786
11980, 2782, 32212, 32213, 2783, 32222, 32223, 32224, 2787
11981, 2783, 32213, 32214, 2784, 32224, 32225, 32226, 2788
11982, 2784, 32214, 2776, 42, 32226, 32227, 2778, 2789
11983, 2771, 2772, 32215, 32211, 2774, 32228, 32229, 32219
11984, 32211, 32215, 32216, 32212, 32229, 32230, 32231, 32221
11985, 32212, 32216, 32217, 32213, 32231, 32232, 32233, 32223
11986, 32213, 32217, 32218, 32214, 32233, 32234, 32235, 32225
11987, 32214, 32218, 2777, 2776, 32235, 32236, 2779, 32227
11988, 2772, 35, 2496, 32215, 2775, 2500, 32237, 32228
11989, 32215, 2496, 2497, 32216, 32237, 2501, 32238, 32230
11990, 32216, 2497, 2498, 32217, 32238, 2502, 32239, 32232
11991, 32217, 2498, 2499, 32218, 32239, 2503, 32240, 32234
11992, 32218, 2499, 37, 2777, 32240, 2504, 2780, 32236
*ELSET,ELSET=Ceramic_Top
751, 752, 753, 754, 755, 756, 757, 758, 1302, 1303, 
1304, 1305, 1306, 1307, 1308, 1309, 1310, 1311, 1312, 1313, 
1314, 1315, 1316, 1317, 1318, 1319, 1320, 1321, 1322, 1323, 
1324, 1325, 1326, 1327, 1328, 1329, 1330, 1331, 1332, 1333, 
1334, 1335, 1336, 1337, 1338, 1339, 1340, 1341, 1342, 1343, 
1344, 1345, 1346, 1347, 1348, 1349, 1350, 1351, 1352, 1353, 
1354, 1355, 1356, 1357, 1358, 1359, 1360, 1361, 1367, 1368, 
1369, 1370, 1371, 1372, 1373, 1374, 1375, 1376, 1377, 1378, 
1379, 1380, 1381, 1382, 1383, 1384, 1385, 1386, 1387, 1388, 
1389, 1390, 1391, 1392, 1393, 1394, 1395, 1396, 1397, 1398, 
1399, 1400, 1401, 1402, 1403, 1404, 1405, 1406, 1407, 1408, 
1409, 1410, 1411, 1412, 1413, 1414, 1415, 1416, 1417, 1418, 
1419, 1420, 1421, 1422, 1423, 1424, 1425, 1426, 1427, 1428, 
1429, 1441, 1442, 1443, 
*ELSET,ELSET=Ceramic_Bottom
680, 681, 682, 683, 684, 685, 686, 687, 688, 689, 
690, 691, 692, 693, 694, 695, 696, 697, 698, 699, 
700, 701, 702, 703, 704, 705, 706, 707, 708, 709, 
710, 711, 712, 713, 714, 715, 716, 717, 718, 719, 
720, 721, 722, 723, 724, 725, 726, 727, 728, 729, 
730, 731, 732, 733, 734, 735, 736, 737, 738, 739, 
748, 749, 750, 769, 770, 771, 1068, 1069, 1070, 1071, 
1072, 1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 
1082, 1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 
1092, 1093, 1094, 1095, 1096, 1097, 1098, 1099, 1100, 1101, 
1102, 1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 1111, 
1112, 1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 1121, 
1122, 1123, 1124, 1125, 1126, 1127, 1157, 1158, 1159, 1160, 
1161, 1162, 1163, 1164, 
*ELSET,ELSET=ElectrodeMinX
1057, 1058, 1059, 1060, 1061, 1062, 
*ELSET,ELSET=ElectrodeMaxX
1128, 1129, 1130, 1131, 1132, 1133, 
*ELSET,ELSET=Contact_CeramicCopper
348, 349, 350, 351, 352, 353, 354, 355, 602, 603, 
604, 605, 606, 607, 608, 609, 610, 611, 612, 613, 
614, 615, 616, 617, 618, 619, 620, 621, 622, 623, 
624, 625, 626, 627, 628, 629, 630, 631, 632, 633, 
634, 635, 636, 637, 638, 639, 640, 641, 642, 643, 
644, 645, 646, 647, 648, 649, 650, 651, 652, 653, 
654, 655, 656, 657, 658, 659, 660, 661, 662, 663, 
664, 745, 746, 747, 994, 995, 996, 997, 998, 999, 
1000, 1001, 1002, 1003, 1004, 1005, 1006, 1007, 1008, 1009, 
1010, 1011, 1012, 1013, 1014, 1015, 1016, 1017, 1018, 1019, 
1020, 1021, 1022, 1023, 1024, 1025, 1026, 1027, 1028, 1029, 
1030, 1031, 1032, 1033, 1034, 1035, 1036, 1037, 1038, 1039, 
1040, 1041, 1042, 1043, 1044, 1045, 1046, 1047, 1048, 1049, 
1050, 1051, 1052, 1053, 1171, 1172, 1173, 1174, 1175, 1176, 
1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 1185, 1186, 
1187, 1188, 1189, 1190, 1191, 1192, 1193, 1194, 1195, 1196, 
1197, 1198, 1199, 1200, 1201, 1202, 1203, 1204, 1205, 1206, 
1207, 1208, 1209, 1210, 1211, 1212, 1213, 1214, 1215, 1216, 
1217, 1218, 1219, 1220, 1221, 1222, 1223, 1224, 1225, 1226, 
1227, 1228, 1229, 1230, 1231, 1232, 1233, 1234, 1235, 1236, 
1237, 1238, 1239, 1240, 1241, 1242, 1243, 1244, 1245, 1246, 
1247, 1248, 1249, 1250, 1251, 1252, 1253, 1254, 1255, 1256, 
1257, 1258, 1259, 1260, 1261, 1262, 1263, 1264, 1265, 1266, 
1267, 1268, 1269, 1270, 1271, 1272, 1273, 1274, 1275, 1276, 
1277, 1278, 1279, 1280, 1281, 1282, 1283, 1284, 1285, 1286, 
1287, 1288, 1289, 1290, 
*ELSET,ELSET=Symm_X
740, 741, 742, 743, 744, 764, 765, 766, 767, 768, 
1057, 1058, 1059, 1060, 1061, 1062, 1128, 1129, 1130, 1131, 
1132, 1133, 1433, 1434, 1435, 1436, 1437, 1444, 1445, 1446, 
1447, 1448, 
*ELSET,ELSET=Volume
1449, 1450, 1451, 1452, 1453, 1454, 1455, 1456, 1457, 1458, 
1459, 1460, 1461, 1462, 1463, 1464, 1465, 1466, 1467, 1468, 
1469, 1470, 1471, 1472, 1473, 1474, 1475, 1476, 1477, 1478, 
1479, 1480, 1481, 1482, 1483, 1484, 1485, 1486, 1487, 1488, 
1489, 1490, 1491, 1492, 1493, 1494, 1495, 1496, 1497, 1498, 
1499, 1500, 1501, 1502, 1503, 1504, 1505, 1506, 1507, 1508, 
1509, 1510, 1511, 1512, 1513, 1514, 1515, 1516, 1517, 1518, 
1519, 1520, 1521, 1522, 1523, 1524, 1525, 1526, 1527, 1528, 
1529, 1530, 1531, 1532, 1533, 1534, 1535, 1536, 1537, 1538, 
1539, 1540, 1541, 1542, 1543, 1544, 1545, 1546, 1547, 1548, 
1549, 1550, 1551, 1552, 1553, 1554, 1555, 1556, 1557, 1558, 
1559, 1560, 1561, 1562, 1563, 1564, 1565, 1566, 1567, 1568, 
1569, 1570, 1571, 1572, 1573, 1574, 1575, 1576, 1577, 1578, 
1579, 1580, 1581, 1582, 1583, 1584, 1585, 1586, 1587, 1588, 
1589, 1590, 1591, 1592, 1593, 1594, 1595, 1596, 1597, 1598, 
1599, 1600, 1601, 1602, 1603, 1604, 1605, 1606, 1607, 1608, 
1609, 1610, 1611, 1612, 1613, 1614, 1615, 1616, 1617, 1618, 
1619, 1620, 1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 
1629, 1630, 1631, 1632, 1633, 1634, 1635, 1636, 1637, 1638, 
1639, 1640, 1641, 1642, 1643, 1644, 1645, 1646, 1647, 1648, 
1649, 1650, 1651, 1652, 1653, 1654, 1655, 1656, 1657, 1658, 
1659, 1660, 1661, 1662, 1663, 1664, 1665, 1666, 1667, 1668, 
1669, 1670, 1671, 1672, 1673, 1674, 1675, 1676, 1677, 1678, 
1679, 1680, 1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 
1689, 1690, 1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 
1699, 1700, 1701, 1702, 1703, 1704, 1705, 1706, 1707, 1708, 
1709, 1710, 1711, 1712, 1713, 1714, 1715, 1716, 1717, 1718, 
1719, 1720, 1721, 1722, 1723, 1724, 1725, 1726, 1727, 1728, 
1729, 1730, 1731, 1732, 1733, 1734, 1735, 1736, 1737, 1738, 
1739, 1740, 1741, 1742, 1743, 1744, 1745, 1746, 1747, 1748, 
1749, 1750, 1751, 1752, 1753, 1754, 1755, 1756, 1757, 1758, 
1759, 1760, 1761, 1762, 1763, 1764, 1765, 1766, 1767, 1768, 
1769, 1770, 1771, 1772, 1773, 1774, 1775, 1776, 1777, 1778, 
1779, 1780, 1781, 1782, 1783, 1784, 1785, 1786, 1787, 1788, 
1789, 1790, 1791, 1792, 1793, 1794, 1795, 1796, 1797, 1798, 
1799, 1800, 1801, 1802, 1803, 1804, 1805, 1806, 1807, 1808, 
1809, 1810, 1811, 1812, 1813, 1814, 1815, 1816, 1817, 1818, 
