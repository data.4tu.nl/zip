*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_2401v3.inp
*NODE
1, 1, 1.35, 0
2, 1, 1.55, 0
3, 1.2, 1.25, 0
4, 2.2, 1.25, 0
5, 0, 0, 0
6, 1, 0, 0
7, 1, 1.2, 0
8, 0, 1.2, 0
9, 1.2, 1.35, 0
10, 1.2, 1.2, 0
11, 1.2, 0, 0
12, 2.2, 1.2, 0
13, 2.2, 0, 0
14, 1.2, -0.15, 0
15, 2.2, -0.15, 0
16, 0, -0.15, 0
17, -0.1, -0.15, 0
18, 0, -0.35, 0
19, 1.2, -0.35, 0
20, 2.2, -0.35, 0
21, 2.3, -0.15, 0
22, 2.3, -0.35, 0
23, 1.2, 1.55, 0
24, -0.1, -0.35, 0
25, 1, 1.25, 0
26, 0, 1.25, 0
27, 1.2, -0.05, 0
28, 2.2, -0.05, 0
29, 0, -0.05, 0
30, 1, -0.05, 0
31, 1, -0.15, 0
32, -0.1, -0.05, 0
33, 1, -0.35, 0
34, 2.3, -0.05, 0
35, 0, 1.35, 0
36, 2.2, 1.35, 0
37, 0, 1.55, 0
38, 2.2, 1.55, 0
39, 2.3, 1.55, 0
40, 2.3, 1.35, 0
41, -0.1, 1.35, 0
42, -0.1, 1.55, 0
43, 1, 1.39, 0
44, 1, 1.43, 0
45, 1, 1.47, 0
46, 1, 1.51, 0
47, 1, 1.37, 0
48, 1, 1.41, 0
49, 1, 1.45, 0
50, 1, 1.49, 0
51, 1, 1.53, 0
52, 1.2166666666667, 1.25, 0
53, 1.2333333333333, 1.25, 0
54, 1.25, 1.25, 0
55, 1.2666666666667, 1.25, 0
56, 1.2833333333333, 1.25, 0
57, 1.3, 1.25, 0
58, 1.3166666666667, 1.25, 0
59, 1.3333333333333, 1.25, 0
60, 1.35, 1.25, 0
61, 1.3666666666667, 1.25, 0
62, 1.3833333333333, 1.25, 0
63, 1.4, 1.25, 0
64, 1.4166666666667, 1.25, 0
65, 1.4333333333333, 1.25, 0
66, 1.45, 1.25, 0
67, 1.4666666666667, 1.25, 0
68, 1.4833333333333, 1.25, 0
69, 1.5, 1.25, 0
70, 1.5166666666667, 1.25, 0
71, 1.5333333333333, 1.25, 0
72, 1.55, 1.25, 0
73, 1.5666666666667, 1.25, 0
74, 1.5833333333333, 1.25, 0
75, 1.6, 1.25, 0
76, 1.6166666666667, 1.25, 0
77, 1.6333333333333, 1.25, 0
78, 1.65, 1.25, 0
79, 1.6666666666667, 1.25, 0
80, 1.6833333333333, 1.25, 0
81, 1.7, 1.25, 0
82, 1.7166666666667, 1.25, 0
83, 1.7333333333333, 1.25, 0
84, 1.75, 1.25, 0
85, 1.7666666666667, 1.25, 0
86, 1.7833333333333, 1.25, 0
87, 1.8, 1.25, 0
88, 1.8166666666667, 1.25, 0
89, 1.8333333333333, 1.25, 0
90, 1.85, 1.25, 0
91, 1.8666666666667, 1.25, 0
92, 1.8833333333333, 1.25, 0
93, 1.9, 1.25, 0
94, 1.9166666666667, 1.25, 0
95, 1.9333333333333, 1.25, 0
96, 1.95, 1.25, 0
97, 1.9666666666667, 1.25, 0
98, 1.9833333333333, 1.25, 0
99, 2, 1.25, 0
100, 2.0166666666667, 1.25, 0
101, 2.0333333333333, 1.25, 0
102, 2.05, 1.25, 0
103, 2.0666666666667, 1.25, 0
104, 2.0833333333333, 1.25, 0
105, 2.1, 1.25, 0
106, 2.1166666666667, 1.25, 0
107, 2.1333333333333, 1.25, 0
108, 2.15, 1.25, 0
109, 2.1666666666667, 1.25, 0
110, 2.1833333333333, 1.25, 0
111, 1.2083333333333, 1.25, 0
112, 1.225, 1.25, 0
113, 1.2416666666667, 1.25, 0
114, 1.2583333333333, 1.25, 0
115, 1.275, 1.25, 0
116, 1.2916666666667, 1.25, 0
117, 1.3083333333333, 1.25, 0
118, 1.325, 1.25, 0
119, 1.3416666666667, 1.25, 0
120, 1.3583333333333, 1.25, 0
121, 1.375, 1.25, 0
122, 1.3916666666667, 1.25, 0
123, 1.4083333333333, 1.25, 0
124, 1.425, 1.25, 0
125, 1.4416666666667, 1.25, 0
126, 1.4583333333333, 1.25, 0
127, 1.475, 1.25, 0
128, 1.4916666666667, 1.25, 0
129, 1.5083333333333, 1.25, 0
130, 1.525, 1.25, 0
131, 1.5416666666667, 1.25, 0
132, 1.5583333333333, 1.25, 0
133, 1.575, 1.25, 0
134, 1.5916666666667, 1.25, 0
135, 1.6083333333333, 1.25, 0
136, 1.625, 1.25, 0
137, 1.6416666666667, 1.25, 0
138, 1.6583333333333, 1.25, 0
139, 1.675, 1.25, 0
140, 1.6916666666667, 1.25, 0
141, 1.7083333333333, 1.25, 0
142, 1.725, 1.25, 0
143, 1.7416666666667, 1.25, 0
144, 1.7583333333333, 1.25, 0
145, 1.775, 1.25, 0
146, 1.7916666666667, 1.25, 0
147, 1.8083333333333, 1.25, 0
148, 1.825, 1.25, 0
149, 1.8416666666667, 1.25, 0
150, 1.8583333333333, 1.25, 0
151, 1.875, 1.25, 0
152, 1.8916666666667, 1.25, 0
153, 1.9083333333333, 1.25, 0
154, 1.925, 1.25, 0
155, 1.9416666666667, 1.25, 0
156, 1.9583333333333, 1.25, 0
157, 1.975, 1.25, 0
158, 1.9916666666667, 1.25, 0
159, 2.0083333333333, 1.25, 0
160, 2.025, 1.25, 0
161, 2.0416666666667, 1.25, 0
162, 2.0583333333333, 1.25, 0
163, 2.075, 1.25, 0
164, 2.0916666666667, 1.25, 0
165, 2.1083333333333, 1.25, 0
166, 2.125, 1.25, 0
167, 2.1416666666667, 1.25, 0
168, 2.1583333333333, 1.25, 0
169, 2.175, 1.25, 0
170, 2.1916666666667, 1.25, 0
171, 0.016666666666667, 0, 0
172, 0.033333333333333, 0, 0
173, 0.05, 0, 0
174, 0.066666666666667, 0, 0
175, 0.083333333333333, 0, 0
176, 0.1, 0, 0
177, 0.11666666666667, 0, 0
178, 0.13333333333333, 0, 0
179, 0.15, 0, 0
180, 0.16666666666667, 0, 0
181, 0.18333333333333, 0, 0
182, 0.2, 0, 0
183, 0.21666666666667, 0, 0
184, 0.23333333333333, 0, 0
185, 0.25, 0, 0
186, 0.26666666666667, 0, 0
187, 0.28333333333333, 0, 0
188, 0.3, 0, 0
189, 0.31666666666667, 0, 0
190, 0.33333333333333, 0, 0
191, 0.35, 0, 0
192, 0.36666666666667, 0, 0
193, 0.38333333333333, 0, 0
194, 0.4, 0, 0
195, 0.41666666666667, 0, 0
196, 0.43333333333333, 0, 0
197, 0.45, 0, 0
198, 0.46666666666667, 0, 0
199, 0.48333333333333, 0, 0
200, 0.5, 0, 0
201, 0.51666666666667, 0, 0
202, 0.53333333333333, 0, 0
203, 0.55, 0, 0
204, 0.56666666666667, 0, 0
205, 0.58333333333333, 0, 0
206, 0.6, 0, 0
207, 0.61666666666667, 0, 0
208, 0.63333333333333, 0, 0
209, 0.65, 0, 0
210, 0.66666666666667, 0, 0
211, 0.68333333333333, 0, 0
212, 0.7, 0, 0
213, 0.71666666666667, 0, 0
214, 0.73333333333333, 0, 0
215, 0.75, 0, 0
216, 0.76666666666667, 0, 0
217, 0.78333333333333, 0, 0
218, 0.8, 0, 0
219, 0.81666666666667, 0, 0
220, 0.83333333333333, 0, 0
221, 0.85, 0, 0
222, 0.86666666666667, 0, 0
223, 0.88333333333333, 0, 0
224, 0.9, 0, 0
225, 0.91666666666667, 0, 0
226, 0.93333333333333, 0, 0
227, 0.95, 0, 0
228, 0.96666666666667, 0, 0
229, 0.98333333333333, 0, 0
230, 0.0083333333333333, 0, 0
231, 0.025, 0, 0
232, 0.041666666666667, 0, 0
233, 0.058333333333333, 0, 0
234, 0.075, 0, 0
235, 0.091666666666667, 0, 0
236, 0.10833333333333, 0, 0
237, 0.125, 0, 0
238, 0.14166666666667, 0, 0
239, 0.15833333333333, 0, 0
240, 0.175, 0, 0
241, 0.19166666666667, 0, 0
242, 0.20833333333333, 0, 0
243, 0.225, 0, 0
244, 0.24166666666667, 0, 0
245, 0.25833333333333, 0, 0
246, 0.275, 0, 0
247, 0.29166666666667, 0, 0
248, 0.30833333333333, 0, 0
249, 0.325, 0, 0
250, 0.34166666666667, 0, 0
251, 0.35833333333333, 0, 0
252, 0.375, 0, 0
253, 0.39166666666667, 0, 0
254, 0.40833333333333, 0, 0
255, 0.425, 0, 0
256, 0.44166666666667, 0, 0
257, 0.45833333333333, 0, 0
258, 0.475, 0, 0
259, 0.49166666666667, 0, 0
260, 0.50833333333333, 0, 0
261, 0.525, 0, 0
262, 0.54166666666667, 0, 0
263, 0.55833333333333, 0, 0
264, 0.575, 0, 0
265, 0.59166666666667, 0, 0
266, 0.60833333333333, 0, 0
267, 0.625, 0, 0
268, 0.64166666666667, 0, 0
269, 0.65833333333333, 0, 0
270, 0.675, 0, 0
271, 0.69166666666667, 0, 0
272, 0.70833333333333, 0, 0
273, 0.725, 0, 0
274, 0.74166666666667, 0, 0
275, 0.75833333333333, 0, 0
276, 0.775, 0, 0
277, 0.79166666666667, 0, 0
278, 0.80833333333333, 0, 0
279, 0.825, 0, 0
280, 0.84166666666667, 0, 0
281, 0.85833333333333, 0, 0
282, 0.875, 0, 0
283, 0.89166666666667, 0, 0
284, 0.90833333333333, 0, 0
285, 0.925, 0, 0
286, 0.94166666666667, 0, 0
287, 0.95833333333333, 0, 0
288, 0.975, 0, 0
289, 0.99166666666667, 0, 0
290, 1, 0.02, 0
291, 1, 0.04, 0
292, 1, 0.06, 0
293, 1, 0.08, 0
294, 1, 0.1, 0
295, 1, 0.12, 0
296, 1, 0.14, 0
297, 1, 0.16, 0
298, 1, 0.18, 0
299, 1, 0.2, 0
300, 1, 0.22, 0
301, 1, 0.24, 0
302, 1, 0.26, 0
303, 1, 0.28, 0
304, 1, 0.3, 0
305, 1, 0.32, 0
306, 1, 0.34, 0
307, 1, 0.36, 0
308, 1, 0.38, 0
309, 1, 0.4, 0
310, 1, 0.42, 0
311, 1, 0.44, 0
312, 1, 0.46, 0
313, 1, 0.48, 0
314, 1, 0.5, 0
315, 1, 0.52, 0
316, 1, 0.54, 0
317, 1, 0.56, 0
318, 1, 0.58, 0
319, 1, 0.6, 0
320, 1, 0.62, 0
321, 1, 0.64, 0
322, 1, 0.66, 0
323, 1, 0.68, 0
324, 1, 0.7, 0
325, 1, 0.72, 0
326, 1, 0.74, 0
327, 1, 0.76, 0
328, 1, 0.78, 0
329, 1, 0.8, 0
330, 1, 0.82, 0
331, 1, 0.84, 0
332, 1, 0.86, 0
333, 1, 0.88, 0
334, 1, 0.9, 0
335, 1, 0.92, 0
336, 1, 0.94, 0
337, 1, 0.96, 0
338, 1, 0.98, 0
339, 1, 1, 0
340, 1, 1.02, 0
341, 1, 1.04, 0
342, 1, 1.06, 0
343, 1, 1.08, 0
344, 1, 1.1, 0
345, 1, 1.12, 0
346, 1, 1.14, 0
347, 1, 1.16, 0
348, 1, 1.18, 0
349, 1, 0.01, 0
350, 1, 0.03, 0
351, 1, 0.05, 0
352, 1, 0.07, 0
353, 1, 0.09, 0
354, 1, 0.11, 0
355, 1, 0.13, 0
356, 1, 0.15, 0
357, 1, 0.17, 0
358, 1, 0.19, 0
359, 1, 0.21, 0
360, 1, 0.23, 0
361, 1, 0.25, 0
362, 1, 0.27, 0
363, 1, 0.29, 0
364, 1, 0.31, 0
365, 1, 0.33, 0
366, 1, 0.35, 0
367, 1, 0.37, 0
368, 1, 0.39, 0
369, 1, 0.41, 0
370, 1, 0.43, 0
371, 1, 0.45, 0
372, 1, 0.47, 0
373, 1, 0.49, 0
374, 1, 0.51, 0
375, 1, 0.53, 0
376, 1, 0.55, 0
377, 1, 0.57, 0
378, 1, 0.59, 0
379, 1, 0.61, 0
380, 1, 0.63, 0
381, 1, 0.65, 0
382, 1, 0.67, 0
383, 1, 0.69, 0
384, 1, 0.71, 0
385, 1, 0.73, 0
386, 1, 0.75, 0
387, 1, 0.77, 0
388, 1, 0.79, 0
389, 1, 0.81, 0
390, 1, 0.83, 0
391, 1, 0.85, 0
392, 1, 0.87, 0
393, 1, 0.89, 0
394, 1, 0.91, 0
395, 1, 0.93, 0
396, 1, 0.95, 0
397, 1, 0.97, 0
398, 1, 0.99, 0
399, 1, 1.01, 0
400, 1, 1.03, 0
401, 1, 1.05, 0
402, 1, 1.07, 0
403, 1, 1.09, 0
404, 1, 1.11, 0
405, 1, 1.13, 0
406, 1, 1.15, 0
407, 1, 1.17, 0
408, 1, 1.19, 0
409, 0.98333333333333, 1.2, 0
410, 0.96666666666667, 1.2, 0
411, 0.95, 1.2, 0
412, 0.93333333333333, 1.2, 0
413, 0.91666666666667, 1.2, 0
414, 0.9, 1.2, 0
415, 0.88333333333333, 1.2, 0
416, 0.86666666666667, 1.2, 0
417, 0.85, 1.2, 0
418, 0.83333333333333, 1.2, 0
419, 0.81666666666667, 1.2, 0
420, 0.8, 1.2, 0
421, 0.78333333333333, 1.2, 0
422, 0.76666666666667, 1.2, 0
423, 0.75, 1.2, 0
424, 0.73333333333333, 1.2, 0
425, 0.71666666666667, 1.2, 0
426, 0.7, 1.2, 0
427, 0.68333333333333, 1.2, 0
428, 0.66666666666667, 1.2, 0
429, 0.65, 1.2, 0
430, 0.63333333333333, 1.2, 0
431, 0.61666666666667, 1.2, 0
432, 0.6, 1.2, 0
433, 0.58333333333333, 1.2, 0
434, 0.56666666666667, 1.2, 0
435, 0.55, 1.2, 0
436, 0.53333333333333, 1.2, 0
437, 0.51666666666667, 1.2, 0
438, 0.5, 1.2, 0
439, 0.48333333333333, 1.2, 0
440, 0.46666666666667, 1.2, 0
441, 0.45, 1.2, 0
442, 0.43333333333333, 1.2, 0
443, 0.41666666666667, 1.2, 0
444, 0.4, 1.2, 0
445, 0.38333333333333, 1.2, 0
446, 0.36666666666667, 1.2, 0
447, 0.35, 1.2, 0
448, 0.33333333333333, 1.2, 0
449, 0.31666666666667, 1.2, 0
450, 0.3, 1.2, 0
451, 0.28333333333333, 1.2, 0
452, 0.26666666666667, 1.2, 0
453, 0.25, 1.2, 0
454, 0.23333333333333, 1.2, 0
455, 0.21666666666667, 1.2, 0
456, 0.2, 1.2, 0
457, 0.18333333333333, 1.2, 0
458, 0.16666666666667, 1.2, 0
459, 0.15, 1.2, 0
460, 0.13333333333333, 1.2, 0
461, 0.11666666666667, 1.2, 0
462, 0.1, 1.2, 0
463, 0.083333333333333, 1.2, 0
464, 0.066666666666667, 1.2, 0
465, 0.05, 1.2, 0
466, 0.033333333333333, 1.2, 0
467, 0.016666666666667, 1.2, 0
468, 0.99166666666667, 1.2, 0
469, 0.975, 1.2, 0
470, 0.95833333333333, 1.2, 0
471, 0.94166666666667, 1.2, 0
472, 0.925, 1.2, 0
473, 0.90833333333333, 1.2, 0
474, 0.89166666666667, 1.2, 0
475, 0.875, 1.2, 0
476, 0.85833333333333, 1.2, 0
477, 0.84166666666667, 1.2, 0
478, 0.825, 1.2, 0
479, 0.80833333333333, 1.2, 0
480, 0.79166666666667, 1.2, 0
481, 0.775, 1.2, 0
482, 0.75833333333333, 1.2, 0
483, 0.74166666666667, 1.2, 0
484, 0.725, 1.2, 0
485, 0.70833333333333, 1.2, 0
486, 0.69166666666667, 1.2, 0
487, 0.675, 1.2, 0
488, 0.65833333333333, 1.2, 0
489, 0.64166666666667, 1.2, 0
490, 0.625, 1.2, 0
491, 0.60833333333333, 1.2, 0
492, 0.59166666666667, 1.2, 0
493, 0.575, 1.2, 0
494, 0.55833333333333, 1.2, 0
495, 0.54166666666667, 1.2, 0
496, 0.525, 1.2, 0
497, 0.50833333333333, 1.2, 0
498, 0.49166666666667, 1.2, 0
499, 0.475, 1.2, 0
500, 0.45833333333333, 1.2, 0
501, 0.44166666666667, 1.2, 0
502, 0.425, 1.2, 0
503, 0.40833333333333, 1.2, 0
504, 0.39166666666667, 1.2, 0
505, 0.375, 1.2, 0
506, 0.35833333333333, 1.2, 0
507, 0.34166666666667, 1.2, 0
508, 0.325, 1.2, 0
509, 0.30833333333333, 1.2, 0
510, 0.29166666666667, 1.2, 0
511, 0.275, 1.2, 0
512, 0.25833333333333, 1.2, 0
513, 0.24166666666667, 1.2, 0
514, 0.225, 1.2, 0
515, 0.20833333333333, 1.2, 0
516, 0.19166666666667, 1.2, 0
517, 0.175, 1.2, 0
518, 0.15833333333333, 1.2, 0
519, 0.14166666666667, 1.2, 0
520, 0.125, 1.2, 0
521, 0.10833333333333, 1.2, 0
522, 0.091666666666667, 1.2, 0
523, 0.075, 1.2, 0
524, 0.058333333333333, 1.2, 0
525, 0.041666666666667, 1.2, 0
526, 0.025, 1.2, 0
527, 0.0083333333333333, 1.2, 0
528, 0, 1.18, 0
529, 0, 1.16, 0
530, 0, 1.14, 0
531, 0, 1.12, 0
532, 0, 1.1, 0
533, 0, 1.08, 0
534, 0, 1.06, 0
535, 0, 1.04, 0
536, 0, 1.02, 0
537, 0, 1, 0
538, 0, 0.98, 0
539, 0, 0.96, 0
540, 0, 0.94, 0
541, 0, 0.92, 0
542, 0, 0.9, 0
543, 0, 0.88, 0
544, 0, 0.86, 0
545, 0, 0.84, 0
546, 0, 0.82, 0
547, 0, 0.8, 0
548, 0, 0.78, 0
549, 0, 0.76, 0
550, 0, 0.74, 0
551, 0, 0.72, 0
552, 0, 0.7, 0
553, 0, 0.68, 0
554, 0, 0.66, 0
555, 0, 0.64, 0
556, 0, 0.62, 0
557, 0, 0.6, 0
558, 0, 0.58, 0
559, 0, 0.56, 0
560, 0, 0.54, 0
561, 0, 0.52, 0
562, 0, 0.5, 0
563, 0, 0.48, 0
564, 0, 0.46, 0
565, 0, 0.44, 0
566, 0, 0.42, 0
567, 0, 0.4, 0
568, 0, 0.38, 0
569, 0, 0.36, 0
570, 0, 0.34, 0
571, 0, 0.32, 0
572, 0, 0.3, 0
573, 0, 0.28, 0
574, 0, 0.26, 0
575, 0, 0.24, 0
576, 0, 0.22, 0
577, 0, 0.2, 0
578, 0, 0.18, 0
579, 0, 0.16, 0
580, 0, 0.14, 0
581, 0, 0.12, 0
582, 0, 0.1, 0
583, 0, 0.08, 0
584, 0, 0.06, 0
585, 0, 0.04, 0
586, 0, 0.02, 0
587, 0, 1.19, 0
588, 0, 1.17, 0
589, 0, 1.15, 0
590, 0, 1.13, 0
591, 0, 1.11, 0
592, 0, 1.09, 0
593, 0, 1.07, 0
594, 0, 1.05, 0
595, 0, 1.03, 0
596, 0, 1.01, 0
597, 0, 0.99, 0
598, 0, 0.97, 0
599, 0, 0.95, 0
600, 0, 0.93, 0
601, 0, 0.91, 0
602, 0, 0.89, 0
603, 0, 0.87, 0
604, 0, 0.85, 0
605, 0, 0.83, 0
606, 0, 0.81, 0
607, 0, 0.79, 0
608, 0, 0.77, 0
609, 0, 0.75, 0
610, 0, 0.73, 0
611, 0, 0.71, 0
612, 0, 0.69, 0
613, 0, 0.67, 0
614, 0, 0.65, 0
615, 0, 0.63, 0
616, 0, 0.61, 0
617, 0, 0.59, 0
618, 0, 0.57, 0
619, 0, 0.55, 0
620, 0, 0.53, 0
621, 0, 0.51, 0
622, 0, 0.49, 0
623, 0, 0.47, 0
624, 0, 0.45, 0
625, 0, 0.43, 0
626, 0, 0.41, 0
627, 0, 0.39, 0
628, 0, 0.37, 0
629, 0, 0.35, 0
630, 0, 0.33, 0
631, 0, 0.31, 0
632, 0, 0.29, 0
633, 0, 0.27, 0
634, 0, 0.25, 0
635, 0, 0.23, 0
636, 0, 0.21, 0
637, 0, 0.19, 0
638, 0, 0.17, 0
639, 0, 0.15, 0
640, 0, 0.13, 0
641, 0, 0.11, 0
642, 0, 0.09, 0
643, 0, 0.07, 0
644, 0, 0.05, 0
645, 0, 0.03, 0
646, 0, 0.01, 0
647, 1.025, 1.35, 0
648, 1.05, 1.35, 0
649, 1.075, 1.35, 0
650, 1.1, 1.35, 0
651, 1.125, 1.35, 0
652, 1.15, 1.35, 0
653, 1.175, 1.35, 0
654, 1.0125, 1.35, 0
655, 1.0375, 1.35, 0
656, 1.0625, 1.35, 0
657, 1.0875, 1.35, 0
658, 1.1125, 1.35, 0
659, 1.1375, 1.35, 0
660, 1.1625, 1.35, 0
661, 1.1875, 1.35, 0
662, 1.2, 1.2666666666667, 0
663, 1.2, 1.2833333333333, 0
664, 1.2, 1.3, 0
665, 1.2, 1.3166666666667, 0
666, 1.2, 1.3333333333333, 0
667, 1.2, 1.2583333333333, 0
668, 1.2, 1.275, 0
669, 1.2, 1.2916666666667, 0
670, 1.2, 1.3083333333333, 0
671, 1.2, 1.325, 0
672, 1.2, 1.3416666666667, 0
673, 1.2, 1.18, 0
674, 1.2, 1.16, 0
675, 1.2, 1.14, 0
676, 1.2, 1.12, 0
677, 1.2, 1.1, 0
678, 1.2, 1.08, 0
679, 1.2, 1.06, 0
680, 1.2, 1.04, 0
681, 1.2, 1.02, 0
682, 1.2, 1, 0
683, 1.2, 0.98, 0
684, 1.2, 0.96, 0
685, 1.2, 0.94, 0
686, 1.2, 0.92, 0
687, 1.2, 0.9, 0
688, 1.2, 0.88, 0
689, 1.2, 0.86, 0
690, 1.2, 0.84, 0
691, 1.2, 0.82, 0
692, 1.2, 0.8, 0
693, 1.2, 0.78, 0
694, 1.2, 0.76, 0
695, 1.2, 0.74, 0
696, 1.2, 0.72, 0
697, 1.2, 0.7, 0
698, 1.2, 0.68, 0
699, 1.2, 0.66, 0
700, 1.2, 0.64, 0
701, 1.2, 0.62, 0
702, 1.2, 0.6, 0
703, 1.2, 0.58, 0
704, 1.2, 0.56, 0
705, 1.2, 0.54, 0
706, 1.2, 0.52, 0
707, 1.2, 0.5, 0
708, 1.2, 0.48, 0
709, 1.2, 0.46, 0
710, 1.2, 0.44, 0
711, 1.2, 0.42, 0
712, 1.2, 0.4, 0
713, 1.2, 0.38, 0
714, 1.2, 0.36, 0
715, 1.2, 0.34, 0
716, 1.2, 0.32, 0
717, 1.2, 0.3, 0
718, 1.2, 0.28, 0
719, 1.2, 0.26, 0
720, 1.2, 0.24, 0
721, 1.2, 0.22, 0
722, 1.2, 0.2, 0
723, 1.2, 0.18, 0
724, 1.2, 0.16, 0
725, 1.2, 0.14, 0
726, 1.2, 0.12, 0
727, 1.2, 0.1, 0
728, 1.2, 0.08, 0
729, 1.2, 0.06, 0
730, 1.2, 0.04, 0
731, 1.2, 0.02, 0
732, 1.2, 1.19, 0
733, 1.2, 1.17, 0
734, 1.2, 1.15, 0
735, 1.2, 1.13, 0
736, 1.2, 1.11, 0
737, 1.2, 1.09, 0
738, 1.2, 1.07, 0
739, 1.2, 1.05, 0
740, 1.2, 1.03, 0
741, 1.2, 1.01, 0
742, 1.2, 0.99, 0
743, 1.2, 0.97, 0
744, 1.2, 0.95, 0
745, 1.2, 0.93, 0
746, 1.2, 0.91, 0
747, 1.2, 0.89, 0
748, 1.2, 0.87, 0
749, 1.2, 0.85, 0
750, 1.2, 0.83, 0
751, 1.2, 0.81, 0
752, 1.2, 0.79, 0
753, 1.2, 0.77, 0
754, 1.2, 0.75, 0
755, 1.2, 0.73, 0
756, 1.2, 0.71, 0
757, 1.2, 0.69, 0
758, 1.2, 0.67, 0
759, 1.2, 0.65, 0
760, 1.2, 0.63, 0
761, 1.2, 0.61, 0
762, 1.2, 0.59, 0
763, 1.2, 0.57, 0
764, 1.2, 0.55, 0
765, 1.2, 0.53, 0
766, 1.2, 0.51, 0
767, 1.2, 0.49, 0
768, 1.2, 0.47, 0
769, 1.2, 0.45, 0
770, 1.2, 0.43, 0
771, 1.2, 0.41, 0
772, 1.2, 0.39, 0
773, 1.2, 0.37, 0
774, 1.2, 0.35, 0
775, 1.2, 0.33, 0
776, 1.2, 0.31, 0
777, 1.2, 0.29, 0
778, 1.2, 0.27, 0
779, 1.2, 0.25, 0
780, 1.2, 0.23, 0
781, 1.2, 0.21, 0
782, 1.2, 0.19, 0
783, 1.2, 0.17, 0
784, 1.2, 0.15, 0
785, 1.2, 0.13, 0
786, 1.2, 0.11, 0
787, 1.2, 0.09, 0
788, 1.2, 0.07, 0
789, 1.2, 0.05, 0
790, 1.2, 0.03, 0
791, 1.2, 0.01, 0
792, 2.2, 1.18, 0
793, 2.2, 1.16, 0
794, 2.2, 1.14, 0
795, 2.2, 1.12, 0
796, 2.2, 1.1, 0
797, 2.2, 1.08, 0
798, 2.2, 1.06, 0
799, 2.2, 1.04, 0
800, 2.2, 1.02, 0
801, 2.2, 1, 0
802, 2.2, 0.98, 0
803, 2.2, 0.96, 0
804, 2.2, 0.94, 0
805, 2.2, 0.92, 0
806, 2.2, 0.9, 0
807, 2.2, 0.88, 0
808, 2.2, 0.86, 0
809, 2.2, 0.84, 0
810, 2.2, 0.82, 0
811, 2.2, 0.8, 0
812, 2.2, 0.78, 0
813, 2.2, 0.76, 0
814, 2.2, 0.74, 0
815, 2.2, 0.72, 0
816, 2.2, 0.7, 0
817, 2.2, 0.68, 0
818, 2.2, 0.66, 0
819, 2.2, 0.64, 0
820, 2.2, 0.62, 0
821, 2.2, 0.6, 0
822, 2.2, 0.58, 0
823, 2.2, 0.56, 0
824, 2.2, 0.54, 0
825, 2.2, 0.52, 0
826, 2.2, 0.5, 0
827, 2.2, 0.48, 0
828, 2.2, 0.46, 0
829, 2.2, 0.44, 0
830, 2.2, 0.42, 0
831, 2.2, 0.4, 0
832, 2.2, 0.38, 0
833, 2.2, 0.36, 0
834, 2.2, 0.34, 0
835, 2.2, 0.32, 0
836, 2.2, 0.3, 0
837, 2.2, 0.28, 0
838, 2.2, 0.26, 0
839, 2.2, 0.24, 0
840, 2.2, 0.22, 0
841, 2.2, 0.2, 0
842, 2.2, 0.18, 0
843, 2.2, 0.16, 0
844, 2.2, 0.14, 0
845, 2.2, 0.12, 0
846, 2.2, 0.1, 0
847, 2.2, 0.08, 0
848, 2.2, 0.06, 0
849, 2.2, 0.04, 0
850, 2.2, 0.02, 0
851, 2.2, 1.19, 0
852, 2.2, 1.17, 0
853, 2.2, 1.15, 0
854, 2.2, 1.13, 0
855, 2.2, 1.11, 0
856, 2.2, 1.09, 0
857, 2.2, 1.07, 0
858, 2.2, 1.05, 0
859, 2.2, 1.03, 0
860, 2.2, 1.01, 0
861, 2.2, 0.99, 0
862, 2.2, 0.97, 0
863, 2.2, 0.95, 0
864, 2.2, 0.93, 0
865, 2.2, 0.91, 0
866, 2.2, 0.89, 0
867, 2.2, 0.87, 0
868, 2.2, 0.85, 0
869, 2.2, 0.83, 0
870, 2.2, 0.81, 0
871, 2.2, 0.79, 0
872, 2.2, 0.77, 0
873, 2.2, 0.75, 0
874, 2.2, 0.73, 0
875, 2.2, 0.71, 0
876, 2.2, 0.69, 0
877, 2.2, 0.67, 0
878, 2.2, 0.65, 0
879, 2.2, 0.63, 0
880, 2.2, 0.61, 0
881, 2.2, 0.59, 0
882, 2.2, 0.57, 0
883, 2.2, 0.55, 0
884, 2.2, 0.53, 0
885, 2.2, 0.51, 0
886, 2.2, 0.49, 0
887, 2.2, 0.47, 0
888, 2.2, 0.45, 0
889, 2.2, 0.43, 0
890, 2.2, 0.41, 0
891, 2.2, 0.39, 0
892, 2.2, 0.37, 0
893, 2.2, 0.35, 0
894, 2.2, 0.33, 0
895, 2.2, 0.31, 0
896, 2.2, 0.29, 0
897, 2.2, 0.27, 0
898, 2.2, 0.25, 0
899, 2.2, 0.23, 0
900, 2.2, 0.21, 0
901, 2.2, 0.19, 0
902, 2.2, 0.17, 0
903, 2.2, 0.15, 0
904, 2.2, 0.13, 0
905, 2.2, 0.11, 0
906, 2.2, 0.09, 0
907, 2.2, 0.07, 0
908, 2.2, 0.05, 0
909, 2.2, 0.03, 0
910, 2.2, 0.01, 0
911, 1.2166666666667, 1.2, 0
912, 1.2333333333333, 1.2, 0
913, 1.25, 1.2, 0
914, 1.2666666666667, 1.2, 0
915, 1.2833333333333, 1.2, 0
916, 1.3, 1.2, 0
917, 1.3166666666667, 1.2, 0
918, 1.3333333333333, 1.2, 0
919, 1.35, 1.2, 0
920, 1.3666666666667, 1.2, 0
921, 1.3833333333333, 1.2, 0
922, 1.4, 1.2, 0
923, 1.4166666666667, 1.2, 0
924, 1.4333333333333, 1.2, 0
925, 1.45, 1.2, 0
926, 1.4666666666667, 1.2, 0
927, 1.4833333333333, 1.2, 0
928, 1.5, 1.2, 0
929, 1.5166666666667, 1.2, 0
930, 1.5333333333333, 1.2, 0
931, 1.55, 1.2, 0
932, 1.5666666666667, 1.2, 0
933, 1.5833333333333, 1.2, 0
934, 1.6, 1.2, 0
935, 1.6166666666667, 1.2, 0
936, 1.6333333333333, 1.2, 0
937, 1.65, 1.2, 0
938, 1.6666666666667, 1.2, 0
939, 1.6833333333333, 1.2, 0
940, 1.7, 1.2, 0
941, 1.7166666666667, 1.2, 0
942, 1.7333333333333, 1.2, 0
943, 1.75, 1.2, 0
944, 1.7666666666667, 1.2, 0
945, 1.7833333333333, 1.2, 0
946, 1.8, 1.2, 0
947, 1.8166666666667, 1.2, 0
948, 1.8333333333333, 1.2, 0
949, 1.85, 1.2, 0
950, 1.8666666666667, 1.2, 0
951, 1.8833333333333, 1.2, 0
952, 1.9, 1.2, 0
953, 1.9166666666667, 1.2, 0
954, 1.9333333333333, 1.2, 0
955, 1.95, 1.2, 0
956, 1.9666666666667, 1.2, 0
957, 1.9833333333333, 1.2, 0
958, 2, 1.2, 0
959, 2.0166666666667, 1.2, 0
960, 2.0333333333333, 1.2, 0
961, 2.05, 1.2, 0
962, 2.0666666666667, 1.2, 0
963, 2.0833333333333, 1.2, 0
964, 2.1, 1.2, 0
965, 2.1166666666667, 1.2, 0
966, 2.1333333333333, 1.2, 0
967, 2.15, 1.2, 0
968, 2.1666666666667, 1.2, 0
969, 2.1833333333333, 1.2, 0
970, 1.2083333333333, 1.2, 0
971, 1.225, 1.2, 0
972, 1.2416666666667, 1.2, 0
973, 1.2583333333333, 1.2, 0
974, 1.275, 1.2, 0
975, 1.2916666666667, 1.2, 0
976, 1.3083333333333, 1.2, 0
977, 1.325, 1.2, 0
978, 1.3416666666667, 1.2, 0
979, 1.3583333333333, 1.2, 0
980, 1.375, 1.2, 0
981, 1.3916666666667, 1.2, 0
982, 1.4083333333333, 1.2, 0
983, 1.425, 1.2, 0
984, 1.4416666666667, 1.2, 0
985, 1.4583333333333, 1.2, 0
986, 1.475, 1.2, 0
987, 1.4916666666667, 1.2, 0
988, 1.5083333333333, 1.2, 0
989, 1.525, 1.2, 0
990, 1.5416666666667, 1.2, 0
991, 1.5583333333333, 1.2, 0
992, 1.575, 1.2, 0
993, 1.5916666666667, 1.2, 0
994, 1.6083333333333, 1.2, 0
995, 1.625, 1.2, 0
996, 1.6416666666667, 1.2, 0
997, 1.6583333333333, 1.2, 0
998, 1.675, 1.2, 0
999, 1.6916666666667, 1.2, 0
1000, 1.7083333333333, 1.2, 0
1001, 1.725, 1.2, 0
1002, 1.7416666666667, 1.2, 0
1003, 1.7583333333333, 1.2, 0
1004, 1.775, 1.2, 0
1005, 1.7916666666667, 1.2, 0
1006, 1.8083333333333, 1.2, 0
1007, 1.825, 1.2, 0
1008, 1.8416666666667, 1.2, 0
1009, 1.8583333333333, 1.2, 0
1010, 1.875, 1.2, 0
1011, 1.8916666666667, 1.2, 0
1012, 1.9083333333333, 1.2, 0
1013, 1.925, 1.2, 0
1014, 1.9416666666667, 1.2, 0
1015, 1.9583333333333, 1.2, 0
1016, 1.975, 1.2, 0
1017, 1.9916666666667, 1.2, 0
1018, 2.0083333333333, 1.2, 0
1019, 2.025, 1.2, 0
1020, 2.0416666666667, 1.2, 0
1021, 2.0583333333333, 1.2, 0
1022, 2.075, 1.2, 0
1023, 2.0916666666667, 1.2, 0
1024, 2.1083333333333, 1.2, 0
1025, 2.125, 1.2, 0
1026, 2.1416666666667, 1.2, 0
1027, 2.1583333333333, 1.2, 0
1028, 2.175, 1.2, 0
1029, 2.1916666666667, 1.2, 0
1030, 1.2166666666667, 0, 0
1031, 1.2333333333333, 0, 0
1032, 1.25, 0, 0
1033, 1.2666666666667, 0, 0
1034, 1.2833333333333, 0, 0
1035, 1.3, 0, 0
1036, 1.3166666666667, 0, 0
1037, 1.3333333333333, 0, 0
1038, 1.35, 0, 0
1039, 1.3666666666667, 0, 0
1040, 1.3833333333333, 0, 0
1041, 1.4, 0, 0
1042, 1.4166666666667, 0, 0
1043, 1.4333333333333, 0, 0
1044, 1.45, 0, 0
1045, 1.4666666666667, 0, 0
1046, 1.4833333333333, 0, 0
1047, 1.5, 0, 0
1048, 1.5166666666667, 0, 0
1049, 1.5333333333333, 0, 0
1050, 1.55, 0, 0
1051, 1.5666666666667, 0, 0
1052, 1.5833333333333, 0, 0
1053, 1.6, 0, 0
1054, 1.6166666666667, 0, 0
1055, 1.6333333333333, 0, 0
1056, 1.65, 0, 0
1057, 1.6666666666667, 0, 0
1058, 1.6833333333333, 0, 0
1059, 1.7, 0, 0
1060, 1.7166666666667, 0, 0
1061, 1.7333333333333, 0, 0
1062, 1.75, 0, 0
1063, 1.7666666666667, 0, 0
1064, 1.7833333333333, 0, 0
1065, 1.8, 0, 0
1066, 1.8166666666667, 0, 0
1067, 1.8333333333333, 0, 0
1068, 1.85, 0, 0
1069, 1.8666666666667, 0, 0
1070, 1.8833333333333, 0, 0
1071, 1.9, 0, 0
1072, 1.9166666666667, 0, 0
1073, 1.9333333333333, 0, 0
1074, 1.95, 0, 0
1075, 1.9666666666667, 0, 0
1076, 1.9833333333333, 0, 0
1077, 2, 0, 0
1078, 2.0166666666667, 0, 0
1079, 2.0333333333333, 0, 0
1080, 2.05, 0, 0
1081, 2.0666666666667, 0, 0
1082, 2.0833333333333, 0, 0
1083, 2.1, 0, 0
1084, 2.1166666666667, 0, 0
1085, 2.1333333333333, 0, 0
1086, 2.15, 0, 0
1087, 2.1666666666667, 0, 0
1088, 2.1833333333333, 0, 0
1089, 1.2083333333333, 0, 0
1090, 1.225, 0, 0
1091, 1.2416666666667, 0, 0
1092, 1.2583333333333, 0, 0
1093, 1.275, 0, 0
1094, 1.2916666666667, 0, 0
1095, 1.3083333333333, 0, 0
1096, 1.325, 0, 0
1097, 1.3416666666667, 0, 0
1098, 1.3583333333333, 0, 0
1099, 1.375, 0, 0
1100, 1.3916666666667, 0, 0
1101, 1.4083333333333, 0, 0
1102, 1.425, 0, 0
1103, 1.4416666666667, 0, 0
1104, 1.4583333333333, 0, 0
1105, 1.475, 0, 0
1106, 1.4916666666667, 0, 0
1107, 1.5083333333333, 0, 0
1108, 1.525, 0, 0
1109, 1.5416666666667, 0, 0
1110, 1.5583333333333, 0, 0
1111, 1.575, 0, 0
1112, 1.5916666666667, 0, 0
1113, 1.6083333333333, 0, 0
1114, 1.625, 0, 0
1115, 1.6416666666667, 0, 0
1116, 1.6583333333333, 0, 0
1117, 1.675, 0, 0
1118, 1.6916666666667, 0, 0
1119, 1.7083333333333, 0, 0
1120, 1.725, 0, 0
1121, 1.7416666666667, 0, 0
1122, 1.7583333333333, 0, 0
1123, 1.775, 0, 0
1124, 1.7916666666667, 0, 0
1125, 1.8083333333333, 0, 0
1126, 1.825, 0, 0
1127, 1.8416666666667, 0, 0
1128, 1.8583333333333, 0, 0
1129, 1.875, 0, 0
1130, 1.8916666666667, 0, 0
1131, 1.9083333333333, 0, 0
1132, 1.925, 0, 0
1133, 1.9416666666667, 0, 0
1134, 1.9583333333333, 0, 0
1135, 1.975, 0, 0
1136, 1.9916666666667, 0, 0
1137, 2.0083333333333, 0, 0
1138, 2.025, 0, 0
1139, 2.0416666666667, 0, 0
1140, 2.0583333333333, 0, 0
1141, 2.075, 0, 0
1142, 2.0916666666667, 0, 0
1143, 2.1083333333333, 0, 0
1144, 2.125, 0, 0
1145, 2.1416666666667, 0, 0
1146, 2.1583333333333, 0, 0
1147, 2.175, 0, 0
1148, 2.1916666666667, 0, 0
1149, 1.2166666666667, -0.15, 0
1150, 1.2333333333333, -0.15, 0
1151, 1.25, -0.15, 0
1152, 1.2666666666667, -0.15, 0
1153, 1.2833333333333, -0.15, 0
1154, 1.3, -0.15, 0
1155, 1.3166666666667, -0.15, 0
1156, 1.3333333333333, -0.15, 0
1157, 1.35, -0.15, 0
1158, 1.3666666666667, -0.15, 0
1159, 1.3833333333333, -0.15, 0
1160, 1.4, -0.15, 0
1161, 1.4166666666667, -0.15, 0
1162, 1.4333333333333, -0.15, 0
1163, 1.45, -0.15, 0
1164, 1.4666666666667, -0.15, 0
1165, 1.4833333333333, -0.15, 0
1166, 1.5, -0.15, 0
1167, 1.5166666666667, -0.15, 0
1168, 1.5333333333333, -0.15, 0
1169, 1.55, -0.15, 0
1170, 1.5666666666667, -0.15, 0
1171, 1.5833333333333, -0.15, 0
1172, 1.6, -0.15, 0
1173, 1.6166666666667, -0.15, 0
1174, 1.6333333333333, -0.15, 0
1175, 1.65, -0.15, 0
1176, 1.6666666666667, -0.15, 0
1177, 1.6833333333333, -0.15, 0
1178, 1.7, -0.15, 0
1179, 1.7166666666667, -0.15, 0
1180, 1.7333333333333, -0.15, 0
1181, 1.75, -0.15, 0
1182, 1.7666666666667, -0.15, 0
1183, 1.7833333333333, -0.15, 0
1184, 1.8, -0.15, 0
1185, 1.8166666666667, -0.15, 0
1186, 1.8333333333333, -0.15, 0
1187, 1.85, -0.15, 0
1188, 1.8666666666667, -0.15, 0
1189, 1.8833333333333, -0.15, 0
1190, 1.9, -0.15, 0
1191, 1.9166666666667, -0.15, 0
1192, 1.9333333333333, -0.15, 0
1193, 1.95, -0.15, 0
1194, 1.9666666666667, -0.15, 0
1195, 1.9833333333333, -0.15, 0
1196, 2, -0.15, 0
1197, 2.0166666666667, -0.15, 0
1198, 2.0333333333333, -0.15, 0
1199, 2.05, -0.15, 0
1200, 2.0666666666667, -0.15, 0
1201, 2.0833333333333, -0.15, 0
1202, 2.1, -0.15, 0
1203, 2.1166666666667, -0.15, 0
1204, 2.1333333333333, -0.15, 0
1205, 2.15, -0.15, 0
1206, 2.1666666666667, -0.15, 0
1207, 2.1833333333333, -0.15, 0
1208, 1.2083333333333, -0.15, 0
1209, 1.225, -0.15, 0
1210, 1.2416666666667, -0.15, 0
1211, 1.2583333333333, -0.15, 0
1212, 1.275, -0.15, 0
1213, 1.2916666666667, -0.15, 0
1214, 1.3083333333333, -0.15, 0
1215, 1.325, -0.15, 0
1216, 1.3416666666667, -0.15, 0
1217, 1.3583333333333, -0.15, 0
1218, 1.375, -0.15, 0
1219, 1.3916666666667, -0.15, 0
1220, 1.4083333333333, -0.15, 0
1221, 1.425, -0.15, 0
1222, 1.4416666666667, -0.15, 0
1223, 1.4583333333333, -0.15, 0
1224, 1.475, -0.15, 0
1225, 1.4916666666667, -0.15, 0
1226, 1.5083333333333, -0.15, 0
1227, 1.525, -0.15, 0
1228, 1.5416666666667, -0.15, 0
1229, 1.5583333333333, -0.15, 0
1230, 1.575, -0.15, 0
1231, 1.5916666666667, -0.15, 0
1232, 1.6083333333333, -0.15, 0
1233, 1.625, -0.15, 0
1234, 1.6416666666667, -0.15, 0
1235, 1.6583333333333, -0.15, 0
1236, 1.675, -0.15, 0
1237, 1.6916666666667, -0.15, 0
1238, 1.7083333333333, -0.15, 0
1239, 1.725, -0.15, 0
1240, 1.7416666666667, -0.15, 0
1241, 1.7583333333333, -0.15, 0
1242, 1.775, -0.15, 0
1243, 1.7916666666667, -0.15, 0
1244, 1.8083333333333, -0.15, 0
1245, 1.825, -0.15, 0
1246, 1.8416666666667, -0.15, 0
1247, 1.8583333333333, -0.15, 0
1248, 1.875, -0.15, 0
1249, 1.8916666666667, -0.15, 0
1250, 1.9083333333333, -0.15, 0
1251, 1.925, -0.15, 0
1252, 1.9416666666667, -0.15, 0
1253, 1.9583333333333, -0.15, 0
1254, 1.975, -0.15, 0
1255, 1.9916666666667, -0.15, 0
1256, 2.0083333333333, -0.15, 0
1257, 2.025, -0.15, 0
1258, 2.0416666666667, -0.15, 0
1259, 2.0583333333333, -0.15, 0
1260, 2.075, -0.15, 0
1261, 2.0916666666667, -0.15, 0
1262, 2.1083333333333, -0.15, 0
1263, 2.125, -0.15, 0
1264, 2.1416666666667, -0.15, 0
1265, 2.1583333333333, -0.15, 0
1266, 2.175, -0.15, 0
1267, 2.1916666666667, -0.15, 0
1268, -0.033333333333333, -0.15, 0
1269, -0.066666666666667, -0.15, 0
1270, -0.016666666666667, -0.15, 0
1271, -0.05, -0.15, 0
1272, -0.083333333333333, -0.15, 0
1273, 0, -0.19, 0
1274, 0, -0.23, 0
1275, 0, -0.27, 0
1276, 0, -0.31, 0
1277, 0, -0.17, 0
1278, 0, -0.21, 0
1279, 0, -0.25, 0
1280, 0, -0.29, 0
1281, 0, -0.33, 0
1282, 1.2, -0.19, 0
1283, 1.2, -0.23, 0
1284, 1.2, -0.27, 0
1285, 1.2, -0.31, 0
1286, 1.2, -0.17, 0
1287, 1.2, -0.21, 0
1288, 1.2, -0.25, 0
1289, 1.2, -0.29, 0
1290, 1.2, -0.33, 0
1291, 2.2, -0.19, 0
1292, 2.2, -0.23, 0
1293, 2.2, -0.27, 0
1294, 2.2, -0.31, 0
1295, 2.2, -0.17, 0
1296, 2.2, -0.21, 0
1297, 2.2, -0.25, 0
1298, 2.2, -0.29, 0
1299, 2.2, -0.33, 0
1300, 1.2166666666667, -0.35, 0
1301, 1.2333333333333, -0.35, 0
1302, 1.25, -0.35, 0
1303, 1.2666666666667, -0.35, 0
1304, 1.2833333333333, -0.35, 0
1305, 1.3, -0.35, 0
1306, 1.3166666666667, -0.35, 0
1307, 1.3333333333333, -0.35, 0
1308, 1.35, -0.35, 0
1309, 1.3666666666667, -0.35, 0
1310, 1.3833333333333, -0.35, 0
1311, 1.4, -0.35, 0
1312, 1.4166666666667, -0.35, 0
1313, 1.4333333333333, -0.35, 0
1314, 1.45, -0.35, 0
1315, 1.4666666666667, -0.35, 0
1316, 1.4833333333333, -0.35, 0
1317, 1.5, -0.35, 0
1318, 1.5166666666667, -0.35, 0
1319, 1.5333333333333, -0.35, 0
1320, 1.55, -0.35, 0
1321, 1.5666666666667, -0.35, 0
1322, 1.5833333333333, -0.35, 0
1323, 1.6, -0.35, 0
1324, 1.6166666666667, -0.35, 0
1325, 1.6333333333333, -0.35, 0
1326, 1.65, -0.35, 0
1327, 1.6666666666667, -0.35, 0
1328, 1.6833333333333, -0.35, 0
1329, 1.7, -0.35, 0
1330, 1.7166666666667, -0.35, 0
1331, 1.7333333333333, -0.35, 0
1332, 1.75, -0.35, 0
1333, 1.7666666666667, -0.35, 0
1334, 1.7833333333333, -0.35, 0
1335, 1.8, -0.35, 0
1336, 1.8166666666667, -0.35, 0
1337, 1.8333333333333, -0.35, 0
1338, 1.85, -0.35, 0
1339, 1.8666666666667, -0.35, 0
1340, 1.8833333333333, -0.35, 0
1341, 1.9, -0.35, 0
1342, 1.9166666666667, -0.35, 0
1343, 1.9333333333333, -0.35, 0
1344, 1.95, -0.35, 0
1345, 1.9666666666667, -0.35, 0
1346, 1.9833333333333, -0.35, 0
1347, 2, -0.35, 0
1348, 2.0166666666667, -0.35, 0
1349, 2.0333333333333, -0.35, 0
1350, 2.05, -0.35, 0
1351, 2.0666666666667, -0.35, 0
1352, 2.0833333333333, -0.35, 0
1353, 2.1, -0.35, 0
1354, 2.1166666666667, -0.35, 0
1355, 2.1333333333333, -0.35, 0
1356, 2.15, -0.35, 0
1357, 2.1666666666667, -0.35, 0
1358, 2.1833333333333, -0.35, 0
1359, 1.2083333333333, -0.35, 0
1360, 1.225, -0.35, 0
1361, 1.2416666666667, -0.35, 0
1362, 1.2583333333333, -0.35, 0
1363, 1.275, -0.35, 0
1364, 1.2916666666667, -0.35, 0
1365, 1.3083333333333, -0.35, 0
1366, 1.325, -0.35, 0
1367, 1.3416666666667, -0.35, 0
1368, 1.3583333333333, -0.35, 0
1369, 1.375, -0.35, 0
1370, 1.3916666666667, -0.35, 0
1371, 1.4083333333333, -0.35, 0
1372, 1.425, -0.35, 0
1373, 1.4416666666667, -0.35, 0
1374, 1.4583333333333, -0.35, 0
1375, 1.475, -0.35, 0
1376, 1.4916666666667, -0.35, 0
1377, 1.5083333333333, -0.35, 0
1378, 1.525, -0.35, 0
1379, 1.5416666666667, -0.35, 0
1380, 1.5583333333333, -0.35, 0
1381, 1.575, -0.35, 0
1382, 1.5916666666667, -0.35, 0
1383, 1.6083333333333, -0.35, 0
1384, 1.625, -0.35, 0
1385, 1.6416666666667, -0.35, 0
1386, 1.6583333333333, -0.35, 0
1387, 1.675, -0.35, 0
1388, 1.6916666666667, -0.35, 0
1389, 1.7083333333333, -0.35, 0
1390, 1.725, -0.35, 0
1391, 1.7416666666667, -0.35, 0
1392, 1.7583333333333, -0.35, 0
1393, 1.775, -0.35, 0
1394, 1.7916666666667, -0.35, 0
1395, 1.8083333333333, -0.35, 0
1396, 1.825, -0.35, 0
1397, 1.8416666666667, -0.35, 0
1398, 1.8583333333333, -0.35, 0
1399, 1.875, -0.35, 0
1400, 1.8916666666667, -0.35, 0
1401, 1.9083333333333, -0.35, 0
1402, 1.925, -0.35, 0
1403, 1.9416666666667, -0.35, 0
1404, 1.9583333333333, -0.35, 0
1405, 1.975, -0.35, 0
1406, 1.9916666666667, -0.35, 0
1407, 2.0083333333333, -0.35, 0
1408, 2.025, -0.35, 0
1409, 2.0416666666667, -0.35, 0
1410, 2.0583333333333, -0.35, 0
1411, 2.075, -0.35, 0
1412, 2.0916666666667, -0.35, 0
1413, 2.1083333333333, -0.35, 0
1414, 2.125, -0.35, 0
1415, 2.1416666666667, -0.35, 0
1416, 2.1583333333333, -0.35, 0
1417, 2.175, -0.35, 0
1418, 2.1916666666667, -0.35, 0
1419, 2.3, -0.19, 0
1420, 2.3, -0.23, 0
1421, 2.3, -0.27, 0
1422, 2.3, -0.31, 0
1423, 2.3, -0.17, 0
1424, 2.3, -0.21, 0
1425, 2.3, -0.25, 0
1426, 2.3, -0.29, 0
1427, 2.3, -0.33, 0
1428, 2.2333333333333, -0.15, 0
1429, 2.2666666666667, -0.15, 0
1430, 2.2166666666667, -0.15, 0
1431, 2.25, -0.15, 0
1432, 2.2833333333333, -0.15, 0
1433, 2.2333333333333, -0.35, 0
1434, 2.2666666666667, -0.35, 0
1435, 2.2166666666667, -0.35, 0
1436, 2.25, -0.35, 0
1437, 2.2833333333333, -0.35, 0
1438, 1.025, 1.55, 0
1439, 1.05, 1.55, 0
1440, 1.075, 1.55, 0
1441, 1.1, 1.55, 0
1442, 1.125, 1.55, 0
1443, 1.15, 1.55, 0
1444, 1.175, 1.55, 0
1445, 1.0125, 1.55, 0
1446, 1.0375, 1.55, 0
1447, 1.0625, 1.55, 0
1448, 1.0875, 1.55, 0
1449, 1.1125, 1.55, 0
1450, 1.1375, 1.55, 0
1451, 1.1625, 1.55, 0
1452, 1.1875, 1.55, 0
1453, 1.2, 1.39, 0
1454, 1.2, 1.43, 0
1455, 1.2, 1.47, 0
1456, 1.2, 1.51, 0
1457, 1.2, 1.37, 0
1458, 1.2, 1.41, 0
1459, 1.2, 1.45, 0
1460, 1.2, 1.49, 0
1461, 1.2, 1.53, 0
1462, -0.1, -0.31, 0
1463, -0.1, -0.27, 0
1464, -0.1, -0.23, 0
1465, -0.1, -0.19, 0
1466, -0.1, -0.33, 0
1467, -0.1, -0.29, 0
1468, -0.1, -0.25, 0
1469, -0.1, -0.21, 0
1470, -0.1, -0.17, 0
1471, -0.033333333333333, -0.35, 0
1472, -0.066666666666667, -0.35, 0
1473, -0.016666666666667, -0.35, 0
1474, -0.05, -0.35, 0
1475, -0.083333333333333, -0.35, 0
1476, 1.2, 1.225, 0
1477, 1.2, 1.2375, 0
1478, 1.2, 1.2125, 0
1479, 2.2, 1.225, 0
1480, 2.2, 1.2375, 0
1481, 2.2, 1.2125, 0
1482, 1, 1.2666666666667, 0
1483, 1, 1.2833333333333, 0
1484, 1, 1.3, 0
1485, 1, 1.3166666666667, 0
1486, 1, 1.3333333333333, 0
1487, 1, 1.2583333333333, 0
1488, 1, 1.275, 0
1489, 1, 1.2916666666667, 0
1490, 1, 1.3083333333333, 0
1491, 1, 1.325, 0
1492, 1, 1.3416666666667, 0
1493, 0.98333333333333, 1.25, 0
1494, 0.96666666666667, 1.25, 0
1495, 0.95, 1.25, 0
1496, 0.93333333333333, 1.25, 0
1497, 0.91666666666667, 1.25, 0
1498, 0.9, 1.25, 0
1499, 0.88333333333333, 1.25, 0
1500, 0.86666666666667, 1.25, 0
1501, 0.85, 1.25, 0
1502, 0.83333333333333, 1.25, 0
1503, 0.81666666666667, 1.25, 0
1504, 0.8, 1.25, 0
1505, 0.78333333333333, 1.25, 0
1506, 0.76666666666667, 1.25, 0
1507, 0.75, 1.25, 0
1508, 0.73333333333333, 1.25, 0
1509, 0.71666666666667, 1.25, 0
1510, 0.7, 1.25, 0
1511, 0.68333333333333, 1.25, 0
1512, 0.66666666666667, 1.25, 0
1513, 0.65, 1.25, 0
1514, 0.63333333333333, 1.25, 0
1515, 0.61666666666667, 1.25, 0
1516, 0.6, 1.25, 0
1517, 0.58333333333333, 1.25, 0
1518, 0.56666666666667, 1.25, 0
1519, 0.55, 1.25, 0
1520, 0.53333333333333, 1.25, 0
1521, 0.51666666666667, 1.25, 0
1522, 0.5, 1.25, 0
1523, 0.48333333333333, 1.25, 0
1524, 0.46666666666667, 1.25, 0
1525, 0.45, 1.25, 0
1526, 0.43333333333333, 1.25, 0
1527, 0.41666666666667, 1.25, 0
1528, 0.4, 1.25, 0
1529, 0.38333333333333, 1.25, 0
1530, 0.36666666666667, 1.25, 0
1531, 0.35, 1.25, 0
1532, 0.33333333333333, 1.25, 0
1533, 0.31666666666667, 1.25, 0
1534, 0.3, 1.25, 0
1535, 0.28333333333333, 1.25, 0
1536, 0.26666666666667, 1.25, 0
1537, 0.25, 1.25, 0
1538, 0.23333333333333, 1.25, 0
1539, 0.21666666666667, 1.25, 0
1540, 0.2, 1.25, 0
1541, 0.18333333333333, 1.25, 0
1542, 0.16666666666667, 1.25, 0
1543, 0.15, 1.25, 0
1544, 0.13333333333333, 1.25, 0
1545, 0.11666666666667, 1.25, 0
1546, 0.1, 1.25, 0
1547, 0.083333333333333, 1.25, 0
1548, 0.066666666666667, 1.25, 0
1549, 0.05, 1.25, 0
1550, 0.033333333333333, 1.25, 0
1551, 0.016666666666667, 1.25, 0
1552, 0.99166666666667, 1.25, 0
1553, 0.975, 1.25, 0
1554, 0.95833333333333, 1.25, 0
1555, 0.94166666666667, 1.25, 0
1556, 0.925, 1.25, 0
1557, 0.90833333333333, 1.25, 0
1558, 0.89166666666667, 1.25, 0
1559, 0.875, 1.25, 0
1560, 0.85833333333333, 1.25, 0
1561, 0.84166666666667, 1.25, 0
1562, 0.825, 1.25, 0
1563, 0.80833333333333, 1.25, 0
1564, 0.79166666666667, 1.25, 0
1565, 0.775, 1.25, 0
1566, 0.75833333333333, 1.25, 0
1567, 0.74166666666667, 1.25, 0
1568, 0.725, 1.25, 0
1569, 0.70833333333333, 1.25, 0
1570, 0.69166666666667, 1.25, 0
1571, 0.675, 1.25, 0
1572, 0.65833333333333, 1.25, 0
1573, 0.64166666666667, 1.25, 0
1574, 0.625, 1.25, 0
1575, 0.60833333333333, 1.25, 0
1576, 0.59166666666667, 1.25, 0
1577, 0.575, 1.25, 0
1578, 0.55833333333333, 1.25, 0
1579, 0.54166666666667, 1.25, 0
1580, 0.525, 1.25, 0
1581, 0.50833333333333, 1.25, 0
1582, 0.49166666666667, 1.25, 0
1583, 0.475, 1.25, 0
1584, 0.45833333333333, 1.25, 0
1585, 0.44166666666667, 1.25, 0
1586, 0.425, 1.25, 0
1587, 0.40833333333333, 1.25, 0
1588, 0.39166666666667, 1.25, 0
1589, 0.375, 1.25, 0
1590, 0.35833333333333, 1.25, 0
1591, 0.34166666666667, 1.25, 0
1592, 0.325, 1.25, 0
1593, 0.30833333333333, 1.25, 0
1594, 0.29166666666667, 1.25, 0
1595, 0.275, 1.25, 0
1596, 0.25833333333333, 1.25, 0
1597, 0.24166666666667, 1.25, 0
1598, 0.225, 1.25, 0
1599, 0.20833333333333, 1.25, 0
1600, 0.19166666666667, 1.25, 0
1601, 0.175, 1.25, 0
1602, 0.15833333333333, 1.25, 0
1603, 0.14166666666667, 1.25, 0
1604, 0.125, 1.25, 0
1605, 0.10833333333333, 1.25, 0
1606, 0.091666666666667, 1.25, 0
1607, 0.075, 1.25, 0
1608, 0.058333333333333, 1.25, 0
1609, 0.041666666666667, 1.25, 0
1610, 0.025, 1.25, 0
1611, 0.0083333333333333, 1.25, 0
1612, 1.025, 1.25, 0
1613, 1.05, 1.25, 0
1614, 1.075, 1.25, 0
1615, 1.1, 1.25, 0
1616, 1.125, 1.25, 0
1617, 1.15, 1.25, 0
1618, 1.175, 1.25, 0
1619, 1.0125, 1.25, 0
1620, 1.0375, 1.25, 0
1621, 1.0625, 1.25, 0
1622, 1.0875, 1.25, 0
1623, 1.1125, 1.25, 0
1624, 1.1375, 1.25, 0
1625, 1.1625, 1.25, 0
1626, 1.1875, 1.25, 0
1627, 1.2, -0.066666666666667, 0
1628, 1.2, -0.083333333333333, 0
1629, 1.2, -0.1, 0
1630, 1.2, -0.11666666666667, 0
1631, 1.2, -0.13333333333333, 0
1632, 1.2, -0.058333333333333, 0
1633, 1.2, -0.075, 0
1634, 1.2, -0.091666666666667, 0
1635, 1.2, -0.10833333333333, 0
1636, 1.2, -0.125, 0
1637, 1.2, -0.14166666666667, 0
1638, 2.2, -0.066666666666667, 0
1639, 2.2, -0.083333333333333, 0
1640, 2.2, -0.1, 0
1641, 2.2, -0.11666666666667, 0
1642, 2.2, -0.13333333333333, 0
1643, 2.2, -0.058333333333333, 0
1644, 2.2, -0.075, 0
1645, 2.2, -0.091666666666667, 0
1646, 2.2, -0.10833333333333, 0
1647, 2.2, -0.125, 0
1648, 2.2, -0.14166666666667, 0
1649, 1.2166666666667, -0.05, 0
1650, 1.2333333333333, -0.05, 0
1651, 1.25, -0.05, 0
1652, 1.2666666666667, -0.05, 0
1653, 1.2833333333333, -0.05, 0
1654, 1.3, -0.05, 0
1655, 1.3166666666667, -0.05, 0
1656, 1.3333333333333, -0.05, 0
1657, 1.35, -0.05, 0
1658, 1.3666666666667, -0.05, 0
1659, 1.3833333333333, -0.05, 0
1660, 1.4, -0.05, 0
1661, 1.4166666666667, -0.05, 0
1662, 1.4333333333333, -0.05, 0
1663, 1.45, -0.05, 0
1664, 1.4666666666667, -0.05, 0
1665, 1.4833333333333, -0.05, 0
1666, 1.5, -0.05, 0
1667, 1.5166666666667, -0.05, 0
1668, 1.5333333333333, -0.05, 0
1669, 1.55, -0.05, 0
1670, 1.5666666666667, -0.05, 0
1671, 1.5833333333333, -0.05, 0
1672, 1.6, -0.05, 0
1673, 1.6166666666667, -0.05, 0
1674, 1.6333333333333, -0.05, 0
1675, 1.65, -0.05, 0
1676, 1.6666666666667, -0.05, 0
1677, 1.6833333333333, -0.05, 0
1678, 1.7, -0.05, 0
1679, 1.7166666666667, -0.05, 0
1680, 1.7333333333333, -0.05, 0
1681, 1.75, -0.05, 0
1682, 1.7666666666667, -0.05, 0
1683, 1.7833333333333, -0.05, 0
1684, 1.8, -0.05, 0
1685, 1.8166666666667, -0.05, 0
1686, 1.8333333333333, -0.05, 0
1687, 1.85, -0.05, 0
1688, 1.8666666666667, -0.05, 0
1689, 1.8833333333333, -0.05, 0
1690, 1.9, -0.05, 0
1691, 1.9166666666667, -0.05, 0
1692, 1.9333333333333, -0.05, 0
1693, 1.95, -0.05, 0
1694, 1.9666666666667, -0.05, 0
1695, 1.9833333333333, -0.05, 0
1696, 2, -0.05, 0
1697, 2.0166666666667, -0.05, 0
1698, 2.0333333333333, -0.05, 0
1699, 2.05, -0.05, 0
1700, 2.0666666666667, -0.05, 0
1701, 2.0833333333333, -0.05, 0
1702, 2.1, -0.05, 0
1703, 2.1166666666667, -0.05, 0
1704, 2.1333333333333, -0.05, 0
1705, 2.15, -0.05, 0
1706, 2.1666666666667, -0.05, 0
1707, 2.1833333333333, -0.05, 0
1708, 1.2083333333333, -0.05, 0
1709, 1.225, -0.05, 0
1710, 1.2416666666667, -0.05, 0
1711, 1.2583333333333, -0.05, 0
1712, 1.275, -0.05, 0
1713, 1.2916666666667, -0.05, 0
1714, 1.3083333333333, -0.05, 0
1715, 1.325, -0.05, 0
1716, 1.3416666666667, -0.05, 0
1717, 1.3583333333333, -0.05, 0
1718, 1.375, -0.05, 0
1719, 1.3916666666667, -0.05, 0
1720, 1.4083333333333, -0.05, 0
1721, 1.425, -0.05, 0
1722, 1.4416666666667, -0.05, 0
1723, 1.4583333333333, -0.05, 0
1724, 1.475, -0.05, 0
1725, 1.4916666666667, -0.05, 0
1726, 1.5083333333333, -0.05, 0
1727, 1.525, -0.05, 0
1728, 1.5416666666667, -0.05, 0
1729, 1.5583333333333, -0.05, 0
1730, 1.575, -0.05, 0
1731, 1.5916666666667, -0.05, 0
1732, 1.6083333333333, -0.05, 0
1733, 1.625, -0.05, 0
1734, 1.6416666666667, -0.05, 0
1735, 1.6583333333333, -0.05, 0
1736, 1.675, -0.05, 0
1737, 1.6916666666667, -0.05, 0
1738, 1.7083333333333, -0.05, 0
1739, 1.725, -0.05, 0
1740, 1.7416666666667, -0.05, 0
1741, 1.7583333333333, -0.05, 0
1742, 1.775, -0.05, 0
1743, 1.7916666666667, -0.05, 0
1744, 1.8083333333333, -0.05, 0
1745, 1.825, -0.05, 0
1746, 1.8416666666667, -0.05, 0
1747, 1.8583333333333, -0.05, 0
1748, 1.875, -0.05, 0
1749, 1.8916666666667, -0.05, 0
1750, 1.9083333333333, -0.05, 0
1751, 1.925, -0.05, 0
1752, 1.9416666666667, -0.05, 0
1753, 1.9583333333333, -0.05, 0
1754, 1.975, -0.05, 0
1755, 1.9916666666667, -0.05, 0
1756, 2.0083333333333, -0.05, 0
1757, 2.025, -0.05, 0
1758, 2.0416666666667, -0.05, 0
1759, 2.0583333333333, -0.05, 0
1760, 2.075, -0.05, 0
1761, 2.0916666666667, -0.05, 0
1762, 2.1083333333333, -0.05, 0
1763, 2.125, -0.05, 0
1764, 2.1416666666667, -0.05, 0
1765, 2.1583333333333, -0.05, 0
1766, 2.175, -0.05, 0
1767, 2.1916666666667, -0.05, 0
1768, 0, -0.066666666666667, 0
1769, 0, -0.083333333333333, 0
1770, 0, -0.1, 0
1771, 0, -0.11666666666667, 0
1772, 0, -0.13333333333333, 0
1773, 0, -0.058333333333333, 0
1774, 0, -0.075, 0
1775, 0, -0.091666666666667, 0
1776, 0, -0.10833333333333, 0
1777, 0, -0.125, 0
1778, 0, -0.14166666666667, 0
1779, 1, -0.066666666666667, 0
1780, 1, -0.083333333333333, 0
1781, 1, -0.1, 0
1782, 1, -0.11666666666667, 0
1783, 1, -0.13333333333333, 0
1784, 1, -0.058333333333333, 0
1785, 1, -0.075, 0
1786, 1, -0.091666666666667, 0
1787, 1, -0.10833333333333, 0
1788, 1, -0.125, 0
1789, 1, -0.14166666666667, 0
1790, 0.016666666666667, -0.05, 0
1791, 0.033333333333333, -0.05, 0
1792, 0.05, -0.05, 0
1793, 0.066666666666667, -0.05, 0
1794, 0.083333333333333, -0.05, 0
1795, 0.1, -0.05, 0
1796, 0.11666666666667, -0.05, 0
1797, 0.13333333333333, -0.05, 0
1798, 0.15, -0.05, 0
1799, 0.16666666666667, -0.05, 0
1800, 0.18333333333333, -0.05, 0
1801, 0.2, -0.05, 0
1802, 0.21666666666667, -0.05, 0
1803, 0.23333333333333, -0.05, 0
1804, 0.25, -0.05, 0
1805, 0.26666666666667, -0.05, 0
1806, 0.28333333333333, -0.05, 0
1807, 0.3, -0.05, 0
1808, 0.31666666666667, -0.05, 0
1809, 0.33333333333333, -0.05, 0
1810, 0.35, -0.05, 0
1811, 0.36666666666667, -0.05, 0
1812, 0.38333333333333, -0.05, 0
1813, 0.4, -0.05, 0
1814, 0.41666666666667, -0.05, 0
1815, 0.43333333333333, -0.05, 0
1816, 0.45, -0.05, 0
1817, 0.46666666666667, -0.05, 0
1818, 0.48333333333333, -0.05, 0
1819, 0.5, -0.05, 0
1820, 0.51666666666667, -0.05, 0
1821, 0.53333333333333, -0.05, 0
1822, 0.55, -0.05, 0
1823, 0.56666666666667, -0.05, 0
1824, 0.58333333333333, -0.05, 0
1825, 0.6, -0.05, 0
1826, 0.61666666666667, -0.05, 0
1827, 0.63333333333333, -0.05, 0
1828, 0.65, -0.05, 0
1829, 0.66666666666667, -0.05, 0
1830, 0.68333333333333, -0.05, 0
1831, 0.7, -0.05, 0
1832, 0.71666666666667, -0.05, 0
1833, 0.73333333333333, -0.05, 0
1834, 0.75, -0.05, 0
1835, 0.76666666666667, -0.05, 0
1836, 0.78333333333333, -0.05, 0
1837, 0.8, -0.05, 0
1838, 0.81666666666667, -0.05, 0
1839, 0.83333333333333, -0.05, 0
1840, 0.85, -0.05, 0
1841, 0.86666666666667, -0.05, 0
1842, 0.88333333333333, -0.05, 0
1843, 0.9, -0.05, 0
1844, 0.91666666666667, -0.05, 0
1845, 0.93333333333333, -0.05, 0
1846, 0.95, -0.05, 0
1847, 0.96666666666667, -0.05, 0
1848, 0.98333333333333, -0.05, 0
1849, 0.0083333333333333, -0.05, 0
1850, 0.025, -0.05, 0
1851, 0.041666666666667, -0.05, 0
1852, 0.058333333333333, -0.05, 0
1853, 0.075, -0.05, 0
1854, 0.091666666666667, -0.05, 0
1855, 0.10833333333333, -0.05, 0
1856, 0.125, -0.05, 0
1857, 0.14166666666667, -0.05, 0
1858, 0.15833333333333, -0.05, 0
1859, 0.175, -0.05, 0
1860, 0.19166666666667, -0.05, 0
1861, 0.20833333333333, -0.05, 0
1862, 0.225, -0.05, 0
1863, 0.24166666666667, -0.05, 0
1864, 0.25833333333333, -0.05, 0
1865, 0.275, -0.05, 0
1866, 0.29166666666667, -0.05, 0
1867, 0.30833333333333, -0.05, 0
1868, 0.325, -0.05, 0
1869, 0.34166666666667, -0.05, 0
1870, 0.35833333333333, -0.05, 0
1871, 0.375, -0.05, 0
1872, 0.39166666666667, -0.05, 0
1873, 0.40833333333333, -0.05, 0
1874, 0.425, -0.05, 0
1875, 0.44166666666667, -0.05, 0
1876, 0.45833333333333, -0.05, 0
1877, 0.475, -0.05, 0
1878, 0.49166666666667, -0.05, 0
1879, 0.50833333333333, -0.05, 0
1880, 0.525, -0.05, 0
1881, 0.54166666666667, -0.05, 0
1882, 0.55833333333333, -0.05, 0
1883, 0.575, -0.05, 0
1884, 0.59166666666667, -0.05, 0
1885, 0.60833333333333, -0.05, 0
1886, 0.625, -0.05, 0
1887, 0.64166666666667, -0.05, 0
1888, 0.65833333333333, -0.05, 0
1889, 0.675, -0.05, 0
1890, 0.69166666666667, -0.05, 0
1891, 0.70833333333333, -0.05, 0
1892, 0.725, -0.05, 0
1893, 0.74166666666667, -0.05, 0
1894, 0.75833333333333, -0.05, 0
1895, 0.775, -0.05, 0
1896, 0.79166666666667, -0.05, 0
1897, 0.80833333333333, -0.05, 0
1898, 0.825, -0.05, 0
1899, 0.84166666666667, -0.05, 0
1900, 0.85833333333333, -0.05, 0
1901, 0.875, -0.05, 0
1902, 0.89166666666667, -0.05, 0
1903, 0.90833333333333, -0.05, 0
1904, 0.925, -0.05, 0
1905, 0.94166666666667, -0.05, 0
1906, 0.95833333333333, -0.05, 0
1907, 0.975, -0.05, 0
1908, 0.99166666666667, -0.05, 0
1909, 0.016666666666667, -0.15, 0
1910, 0.033333333333333, -0.15, 0
1911, 0.05, -0.15, 0
1912, 0.066666666666667, -0.15, 0
1913, 0.083333333333333, -0.15, 0
1914, 0.1, -0.15, 0
1915, 0.11666666666667, -0.15, 0
1916, 0.13333333333333, -0.15, 0
1917, 0.15, -0.15, 0
1918, 0.16666666666667, -0.15, 0
1919, 0.18333333333333, -0.15, 0
1920, 0.2, -0.15, 0
1921, 0.21666666666667, -0.15, 0
1922, 0.23333333333333, -0.15, 0
1923, 0.25, -0.15, 0
1924, 0.26666666666667, -0.15, 0
1925, 0.28333333333333, -0.15, 0
1926, 0.3, -0.15, 0
1927, 0.31666666666667, -0.15, 0
1928, 0.33333333333333, -0.15, 0
1929, 0.35, -0.15, 0
1930, 0.36666666666667, -0.15, 0
1931, 0.38333333333333, -0.15, 0
1932, 0.4, -0.15, 0
1933, 0.41666666666667, -0.15, 0
1934, 0.43333333333333, -0.15, 0
1935, 0.45, -0.15, 0
1936, 0.46666666666667, -0.15, 0
1937, 0.48333333333333, -0.15, 0
1938, 0.5, -0.15, 0
1939, 0.51666666666667, -0.15, 0
1940, 0.53333333333333, -0.15, 0
1941, 0.55, -0.15, 0
1942, 0.56666666666667, -0.15, 0
1943, 0.58333333333333, -0.15, 0
1944, 0.6, -0.15, 0
1945, 0.61666666666667, -0.15, 0
1946, 0.63333333333333, -0.15, 0
1947, 0.65, -0.15, 0
1948, 0.66666666666667, -0.15, 0
1949, 0.68333333333333, -0.15, 0
1950, 0.7, -0.15, 0
1951, 0.71666666666667, -0.15, 0
1952, 0.73333333333333, -0.15, 0
1953, 0.75, -0.15, 0
1954, 0.76666666666667, -0.15, 0
1955, 0.78333333333333, -0.15, 0
1956, 0.8, -0.15, 0
1957, 0.81666666666667, -0.15, 0
1958, 0.83333333333333, -0.15, 0
1959, 0.85, -0.15, 0
1960, 0.86666666666667, -0.15, 0
1961, 0.88333333333333, -0.15, 0
1962, 0.9, -0.15, 0
1963, 0.91666666666667, -0.15, 0
1964, 0.93333333333333, -0.15, 0
1965, 0.95, -0.15, 0
1966, 0.96666666666667, -0.15, 0
1967, 0.98333333333333, -0.15, 0
1968, 0.0083333333333333, -0.15, 0
1969, 0.025, -0.15, 0
1970, 0.041666666666667, -0.15, 0
1971, 0.058333333333333, -0.15, 0
1972, 0.075, -0.15, 0
1973, 0.091666666666667, -0.15, 0
1974, 0.10833333333333, -0.15, 0
1975, 0.125, -0.15, 0
1976, 0.14166666666667, -0.15, 0
1977, 0.15833333333333, -0.15, 0
1978, 0.175, -0.15, 0
1979, 0.19166666666667, -0.15, 0
1980, 0.20833333333333, -0.15, 0
1981, 0.225, -0.15, 0
1982, 0.24166666666667, -0.15, 0
1983, 0.25833333333333, -0.15, 0
1984, 0.275, -0.15, 0
1985, 0.29166666666667, -0.15, 0
1986, 0.30833333333333, -0.15, 0
1987, 0.325, -0.15, 0
1988, 0.34166666666667, -0.15, 0
1989, 0.35833333333333, -0.15, 0
1990, 0.375, -0.15, 0
1991, 0.39166666666667, -0.15, 0
1992, 0.40833333333333, -0.15, 0
1993, 0.425, -0.15, 0
1994, 0.44166666666667, -0.15, 0
1995, 0.45833333333333, -0.15, 0
1996, 0.475, -0.15, 0
1997, 0.49166666666667, -0.15, 0
1998, 0.50833333333333, -0.15, 0
1999, 0.525, -0.15, 0
2000, 0.54166666666667, -0.15, 0
2001, 0.55833333333333, -0.15, 0
2002, 0.575, -0.15, 0
2003, 0.59166666666667, -0.15, 0
2004, 0.60833333333333, -0.15, 0
2005, 0.625, -0.15, 0
2006, 0.64166666666667, -0.15, 0
2007, 0.65833333333333, -0.15, 0
2008, 0.675, -0.15, 0
2009, 0.69166666666667, -0.15, 0
2010, 0.70833333333333, -0.15, 0
2011, 0.725, -0.15, 0
2012, 0.74166666666667, -0.15, 0
2013, 0.75833333333333, -0.15, 0
2014, 0.775, -0.15, 0
2015, 0.79166666666667, -0.15, 0
2016, 0.80833333333333, -0.15, 0
2017, 0.825, -0.15, 0
2018, 0.84166666666667, -0.15, 0
2019, 0.85833333333333, -0.15, 0
2020, 0.875, -0.15, 0
2021, 0.89166666666667, -0.15, 0
2022, 0.90833333333333, -0.15, 0
2023, 0.925, -0.15, 0
2024, 0.94166666666667, -0.15, 0
2025, 0.95833333333333, -0.15, 0
2026, 0.975, -0.15, 0
2027, 0.99166666666667, -0.15, 0
2028, -0.033333333333333, -0.05, 0
2029, -0.066666666666667, -0.05, 0
2030, -0.016666666666667, -0.05, 0
2031, -0.05, -0.05, 0
2032, -0.083333333333333, -0.05, 0
2033, -0.1, -0.066666666666667, 0
2034, -0.1, -0.083333333333333, 0
2035, -0.1, -0.1, 0
2036, -0.1, -0.11666666666667, 0
2037, -0.1, -0.13333333333333, 0
2038, -0.1, -0.058333333333333, 0
2039, -0.1, -0.075, 0
2040, -0.1, -0.091666666666667, 0
2041, -0.1, -0.10833333333333, 0
2042, -0.1, -0.125, 0
2043, -0.1, -0.14166666666667, 0
2044, 1, -0.19, 0
2045, 1, -0.23, 0
2046, 1, -0.27, 0
2047, 1, -0.31, 0
2048, 1, -0.17, 0
2049, 1, -0.21, 0
2050, 1, -0.25, 0
2051, 1, -0.29, 0
2052, 1, -0.33, 0
2053, 0.016666666666667, -0.35, 0
2054, 0.033333333333333, -0.35, 0
2055, 0.05, -0.35, 0
2056, 0.066666666666667, -0.35, 0
2057, 0.083333333333333, -0.35, 0
2058, 0.1, -0.35, 0
2059, 0.11666666666667, -0.35, 0
2060, 0.13333333333333, -0.35, 0
2061, 0.15, -0.35, 0
2062, 0.16666666666667, -0.35, 0
2063, 0.18333333333333, -0.35, 0
2064, 0.2, -0.35, 0
2065, 0.21666666666667, -0.35, 0
2066, 0.23333333333333, -0.35, 0
2067, 0.25, -0.35, 0
2068, 0.26666666666667, -0.35, 0
2069, 0.28333333333333, -0.35, 0
2070, 0.3, -0.35, 0
2071, 0.31666666666667, -0.35, 0
2072, 0.33333333333333, -0.35, 0
2073, 0.35, -0.35, 0
2074, 0.36666666666667, -0.35, 0
2075, 0.38333333333333, -0.35, 0
2076, 0.4, -0.35, 0
2077, 0.41666666666667, -0.35, 0
2078, 0.43333333333333, -0.35, 0
2079, 0.45, -0.35, 0
2080, 0.46666666666667, -0.35, 0
2081, 0.48333333333333, -0.35, 0
2082, 0.5, -0.35, 0
2083, 0.51666666666667, -0.35, 0
2084, 0.53333333333333, -0.35, 0
2085, 0.55, -0.35, 0
2086, 0.56666666666667, -0.35, 0
2087, 0.58333333333333, -0.35, 0
2088, 0.6, -0.35, 0
2089, 0.61666666666667, -0.35, 0
2090, 0.63333333333333, -0.35, 0
2091, 0.65, -0.35, 0
2092, 0.66666666666667, -0.35, 0
2093, 0.68333333333333, -0.35, 0
2094, 0.7, -0.35, 0
2095, 0.71666666666667, -0.35, 0
2096, 0.73333333333333, -0.35, 0
2097, 0.75, -0.35, 0
2098, 0.76666666666667, -0.35, 0
2099, 0.78333333333333, -0.35, 0
2100, 0.8, -0.35, 0
2101, 0.81666666666667, -0.35, 0
2102, 0.83333333333333, -0.35, 0
2103, 0.85, -0.35, 0
2104, 0.86666666666667, -0.35, 0
2105, 0.88333333333333, -0.35, 0
2106, 0.9, -0.35, 0
2107, 0.91666666666667, -0.35, 0
2108, 0.93333333333333, -0.35, 0
2109, 0.95, -0.35, 0
2110, 0.96666666666667, -0.35, 0
2111, 0.98333333333333, -0.35, 0
2112, 0.0083333333333333, -0.35, 0
2113, 0.025, -0.35, 0
2114, 0.041666666666667, -0.35, 0
2115, 0.058333333333333, -0.35, 0
2116, 0.075, -0.35, 0
2117, 0.091666666666667, -0.35, 0
2118, 0.10833333333333, -0.35, 0
2119, 0.125, -0.35, 0
2120, 0.14166666666667, -0.35, 0
2121, 0.15833333333333, -0.35, 0
2122, 0.175, -0.35, 0
2123, 0.19166666666667, -0.35, 0
2124, 0.20833333333333, -0.35, 0
2125, 0.225, -0.35, 0
2126, 0.24166666666667, -0.35, 0
2127, 0.25833333333333, -0.35, 0
2128, 0.275, -0.35, 0
2129, 0.29166666666667, -0.35, 0
2130, 0.30833333333333, -0.35, 0
2131, 0.325, -0.35, 0
2132, 0.34166666666667, -0.35, 0
2133, 0.35833333333333, -0.35, 0
2134, 0.375, -0.35, 0
2135, 0.39166666666667, -0.35, 0
2136, 0.40833333333333, -0.35, 0
2137, 0.425, -0.35, 0
2138, 0.44166666666667, -0.35, 0
2139, 0.45833333333333, -0.35, 0
2140, 0.475, -0.35, 0
2141, 0.49166666666667, -0.35, 0
2142, 0.50833333333333, -0.35, 0
2143, 0.525, -0.35, 0
2144, 0.54166666666667, -0.35, 0
2145, 0.55833333333333, -0.35, 0
2146, 0.575, -0.35, 0
2147, 0.59166666666667, -0.35, 0
2148, 0.60833333333333, -0.35, 0
2149, 0.625, -0.35, 0
2150, 0.64166666666667, -0.35, 0
2151, 0.65833333333333, -0.35, 0
2152, 0.675, -0.35, 0
2153, 0.69166666666667, -0.35, 0
2154, 0.70833333333333, -0.35, 0
2155, 0.725, -0.35, 0
2156, 0.74166666666667, -0.35, 0
2157, 0.75833333333333, -0.35, 0
2158, 0.775, -0.35, 0
2159, 0.79166666666667, -0.35, 0
2160, 0.80833333333333, -0.35, 0
2161, 0.825, -0.35, 0
2162, 0.84166666666667, -0.35, 0
2163, 0.85833333333333, -0.35, 0
2164, 0.875, -0.35, 0
2165, 0.89166666666667, -0.35, 0
2166, 0.90833333333333, -0.35, 0
2167, 0.925, -0.35, 0
2168, 0.94166666666667, -0.35, 0
2169, 0.95833333333333, -0.35, 0
2170, 0.975, -0.35, 0
2171, 0.99166666666667, -0.35, 0
2172, 2.3, -0.066666666666667, 0
2173, 2.3, -0.083333333333333, 0
2174, 2.3, -0.1, 0
2175, 2.3, -0.11666666666667, 0
2176, 2.3, -0.13333333333333, 0
2177, 2.3, -0.058333333333333, 0
2178, 2.3, -0.075, 0
2179, 2.3, -0.091666666666667, 0
2180, 2.3, -0.10833333333333, 0
2181, 2.3, -0.125, 0
2182, 2.3, -0.14166666666667, 0
2183, 2.2333333333333, -0.05, 0
2184, 2.2666666666667, -0.05, 0
2185, 2.2166666666667, -0.05, 0
2186, 2.25, -0.05, 0
2187, 2.2833333333333, -0.05, 0
2188, 0, -0.025, 0
2189, 0, -0.0125, 0
2190, 0, -0.0375, 0
2191, 1, -0.025, 0
2192, 1, -0.0125, 0
2193, 1, -0.0375, 0
2194, 1.2, -0.025, 0
2195, 1.2, -0.0125, 0
2196, 1.2, -0.0375, 0
2197, 2.2, -0.025, 0
2198, 2.2, -0.0125, 0
2199, 2.2, -0.0375, 0
2200, 1, 1.225, 0
2201, 1, 1.2125, 0
2202, 1, 1.2375, 0
2203, 0, 1.225, 0
2204, 0, 1.2125, 0
2205, 0, 1.2375, 0
2206, 1.175, -0.15, 0
2207, 1.15, -0.15, 0
2208, 1.125, -0.15, 0
2209, 1.1, -0.15, 0
2210, 1.075, -0.15, 0
2211, 1.05, -0.15, 0
2212, 1.025, -0.15, 0
2213, 1.1875, -0.15, 0
2214, 1.1625, -0.15, 0
2215, 1.1375, -0.15, 0
2216, 1.1125, -0.15, 0
2217, 1.0875, -0.15, 0
2218, 1.0625, -0.15, 0
2219, 1.0375, -0.15, 0
2220, 1.0125, -0.15, 0
2221, 1.175, -0.35, 0
2222, 1.15, -0.35, 0
2223, 1.125, -0.35, 0
2224, 1.1, -0.35, 0
2225, 1.075, -0.35, 0
2226, 1.05, -0.35, 0
2227, 1.025, -0.35, 0
2228, 1.1875, -0.35, 0
2229, 1.1625, -0.35, 0
2230, 1.1375, -0.35, 0
2231, 1.1125, -0.35, 0
2232, 1.0875, -0.35, 0
2233, 1.0625, -0.35, 0
2234, 1.0375, -0.35, 0
2235, 1.0125, -0.35, 0
2236, 0, 1.2666666666667, 0
2237, 0, 1.2833333333333, 0
2238, 0, 1.3, 0
2239, 0, 1.3166666666667, 0
2240, 0, 1.3333333333333, 0
2241, 0, 1.2583333333333, 0
2242, 0, 1.275, 0
2243, 0, 1.2916666666667, 0
2244, 0, 1.3083333333333, 0
2245, 0, 1.325, 0
2246, 0, 1.3416666666667, 0
2247, 0.98333333333333, 1.35, 0
2248, 0.96666666666667, 1.35, 0
2249, 0.95, 1.35, 0
2250, 0.93333333333333, 1.35, 0
2251, 0.91666666666667, 1.35, 0
2252, 0.9, 1.35, 0
2253, 0.88333333333333, 1.35, 0
2254, 0.86666666666667, 1.35, 0
2255, 0.85, 1.35, 0
2256, 0.83333333333333, 1.35, 0
2257, 0.81666666666667, 1.35, 0
2258, 0.8, 1.35, 0
2259, 0.78333333333333, 1.35, 0
2260, 0.76666666666667, 1.35, 0
2261, 0.75, 1.35, 0
2262, 0.73333333333333, 1.35, 0
2263, 0.71666666666667, 1.35, 0
2264, 0.7, 1.35, 0
2265, 0.68333333333333, 1.35, 0
2266, 0.66666666666667, 1.35, 0
2267, 0.65, 1.35, 0
2268, 0.63333333333333, 1.35, 0
2269, 0.61666666666667, 1.35, 0
2270, 0.6, 1.35, 0
2271, 0.58333333333333, 1.35, 0
2272, 0.56666666666667, 1.35, 0
2273, 0.55, 1.35, 0
2274, 0.53333333333333, 1.35, 0
2275, 0.51666666666667, 1.35, 0
2276, 0.5, 1.35, 0
2277, 0.48333333333333, 1.35, 0
2278, 0.46666666666667, 1.35, 0
2279, 0.45, 1.35, 0
2280, 0.43333333333333, 1.35, 0
2281, 0.41666666666667, 1.35, 0
2282, 0.4, 1.35, 0
2283, 0.38333333333333, 1.35, 0
2284, 0.36666666666667, 1.35, 0
2285, 0.35, 1.35, 0
2286, 0.33333333333333, 1.35, 0
2287, 0.31666666666667, 1.35, 0
2288, 0.3, 1.35, 0
2289, 0.28333333333333, 1.35, 0
2290, 0.26666666666667, 1.35, 0
2291, 0.25, 1.35, 0
2292, 0.23333333333333, 1.35, 0
2293, 0.21666666666667, 1.35, 0
2294, 0.2, 1.35, 0
2295, 0.18333333333333, 1.35, 0
2296, 0.16666666666667, 1.35, 0
2297, 0.15, 1.35, 0
2298, 0.13333333333333, 1.35, 0
2299, 0.11666666666667, 1.35, 0
2300, 0.1, 1.35, 0
2301, 0.083333333333333, 1.35, 0
2302, 0.066666666666667, 1.35, 0
2303, 0.05, 1.35, 0
2304, 0.033333333333333, 1.35, 0
2305, 0.016666666666667, 1.35, 0
2306, 0.99166666666667, 1.35, 0
2307, 0.975, 1.35, 0
2308, 0.95833333333333, 1.35, 0
2309, 0.94166666666667, 1.35, 0
2310, 0.925, 1.35, 0
2311, 0.90833333333333, 1.35, 0
2312, 0.89166666666667, 1.35, 0
2313, 0.875, 1.35, 0
2314, 0.85833333333333, 1.35, 0
2315, 0.84166666666667, 1.35, 0
2316, 0.825, 1.35, 0
2317, 0.80833333333333, 1.35, 0
2318, 0.79166666666667, 1.35, 0
2319, 0.775, 1.35, 0
2320, 0.75833333333333, 1.35, 0
2321, 0.74166666666667, 1.35, 0
2322, 0.725, 1.35, 0
2323, 0.70833333333333, 1.35, 0
2324, 0.69166666666667, 1.35, 0
2325, 0.675, 1.35, 0
2326, 0.65833333333333, 1.35, 0
2327, 0.64166666666667, 1.35, 0
2328, 0.625, 1.35, 0
2329, 0.60833333333333, 1.35, 0
2330, 0.59166666666667, 1.35, 0
2331, 0.575, 1.35, 0
2332, 0.55833333333333, 1.35, 0
2333, 0.54166666666667, 1.35, 0
2334, 0.525, 1.35, 0
2335, 0.50833333333333, 1.35, 0
2336, 0.49166666666667, 1.35, 0
2337, 0.475, 1.35, 0
2338, 0.45833333333333, 1.35, 0
2339, 0.44166666666667, 1.35, 0
2340, 0.425, 1.35, 0
2341, 0.40833333333333, 1.35, 0
2342, 0.39166666666667, 1.35, 0
2343, 0.375, 1.35, 0
2344, 0.35833333333333, 1.35, 0
2345, 0.34166666666667, 1.35, 0
2346, 0.325, 1.35, 0
2347, 0.30833333333333, 1.35, 0
2348, 0.29166666666667, 1.35, 0
2349, 0.275, 1.35, 0
2350, 0.25833333333333, 1.35, 0
2351, 0.24166666666667, 1.35, 0
2352, 0.225, 1.35, 0
2353, 0.20833333333333, 1.35, 0
2354, 0.19166666666667, 1.35, 0
2355, 0.175, 1.35, 0
2356, 0.15833333333333, 1.35, 0
2357, 0.14166666666667, 1.35, 0
2358, 0.125, 1.35, 0
2359, 0.10833333333333, 1.35, 0
2360, 0.091666666666667, 1.35, 0
2361, 0.075, 1.35, 0
2362, 0.058333333333333, 1.35, 0
2363, 0.041666666666667, 1.35, 0
2364, 0.025, 1.35, 0
2365, 0.0083333333333333, 1.35, 0
2366, 1.2166666666667, 1.35, 0
2367, 1.2333333333333, 1.35, 0
2368, 1.25, 1.35, 0
2369, 1.2666666666667, 1.35, 0
2370, 1.2833333333333, 1.35, 0
2371, 1.3, 1.35, 0
2372, 1.3166666666667, 1.35, 0
2373, 1.3333333333333, 1.35, 0
2374, 1.35, 1.35, 0
2375, 1.3666666666667, 1.35, 0
2376, 1.3833333333333, 1.35, 0
2377, 1.4, 1.35, 0
2378, 1.4166666666667, 1.35, 0
2379, 1.4333333333333, 1.35, 0
2380, 1.45, 1.35, 0
2381, 1.4666666666667, 1.35, 0
2382, 1.4833333333333, 1.35, 0
2383, 1.5, 1.35, 0
2384, 1.5166666666667, 1.35, 0
2385, 1.5333333333333, 1.35, 0
2386, 1.55, 1.35, 0
2387, 1.5666666666667, 1.35, 0
2388, 1.5833333333333, 1.35, 0
2389, 1.6, 1.35, 0
2390, 1.6166666666667, 1.35, 0
2391, 1.6333333333333, 1.35, 0
2392, 1.65, 1.35, 0
2393, 1.6666666666667, 1.35, 0
2394, 1.6833333333333, 1.35, 0
2395, 1.7, 1.35, 0
2396, 1.7166666666667, 1.35, 0
2397, 1.7333333333333, 1.35, 0
2398, 1.75, 1.35, 0
2399, 1.7666666666667, 1.35, 0
2400, 1.7833333333333, 1.35, 0
2401, 1.8, 1.35, 0
2402, 1.8166666666667, 1.35, 0
2403, 1.8333333333333, 1.35, 0
2404, 1.85, 1.35, 0
2405, 1.8666666666667, 1.35, 0
2406, 1.8833333333333, 1.35, 0
2407, 1.9, 1.35, 0
2408, 1.9166666666667, 1.35, 0
2409, 1.9333333333333, 1.35, 0
2410, 1.95, 1.35, 0
2411, 1.9666666666667, 1.35, 0
2412, 1.9833333333333, 1.35, 0
2413, 2, 1.35, 0
2414, 2.0166666666667, 1.35, 0
2415, 2.0333333333333, 1.35, 0
2416, 2.05, 1.35, 0
2417, 2.0666666666667, 1.35, 0
2418, 2.0833333333333, 1.35, 0
2419, 2.1, 1.35, 0
2420, 2.1166666666667, 1.35, 0
2421, 2.1333333333333, 1.35, 0
2422, 2.15, 1.35, 0
2423, 2.1666666666667, 1.35, 0
2424, 2.1833333333333, 1.35, 0
2425, 1.2083333333333, 1.35, 0
2426, 1.225, 1.35, 0
2427, 1.2416666666667, 1.35, 0
2428, 1.2583333333333, 1.35, 0
2429, 1.275, 1.35, 0
2430, 1.2916666666667, 1.35, 0
2431, 1.3083333333333, 1.35, 0
2432, 1.325, 1.35, 0
2433, 1.3416666666667, 1.35, 0
2434, 1.3583333333333, 1.35, 0
2435, 1.375, 1.35, 0
2436, 1.3916666666667, 1.35, 0
2437, 1.4083333333333, 1.35, 0
2438, 1.425, 1.35, 0
2439, 1.4416666666667, 1.35, 0
2440, 1.4583333333333, 1.35, 0
2441, 1.475, 1.35, 0
2442, 1.4916666666667, 1.35, 0
2443, 1.5083333333333, 1.35, 0
2444, 1.525, 1.35, 0
2445, 1.5416666666667, 1.35, 0
2446, 1.5583333333333, 1.35, 0
2447, 1.575, 1.35, 0
2448, 1.5916666666667, 1.35, 0
2449, 1.6083333333333, 1.35, 0
2450, 1.625, 1.35, 0
2451, 1.6416666666667, 1.35, 0
2452, 1.6583333333333, 1.35, 0
2453, 1.675, 1.35, 0
2454, 1.6916666666667, 1.35, 0
2455, 1.7083333333333, 1.35, 0
2456, 1.725, 1.35, 0
2457, 1.7416666666667, 1.35, 0
2458, 1.7583333333333, 1.35, 0
2459, 1.775, 1.35, 0
2460, 1.7916666666667, 1.35, 0
2461, 1.8083333333333, 1.35, 0
2462, 1.825, 1.35, 0
2463, 1.8416666666667, 1.35, 0
2464, 1.8583333333333, 1.35, 0
2465, 1.875, 1.35, 0
2466, 1.8916666666667, 1.35, 0
2467, 1.9083333333333, 1.35, 0
2468, 1.925, 1.35, 0
2469, 1.9416666666667, 1.35, 0
2470, 1.9583333333333, 1.35, 0
2471, 1.975, 1.35, 0
2472, 1.9916666666667, 1.35, 0
2473, 2.0083333333333, 1.35, 0
2474, 2.025, 1.35, 0
2475, 2.0416666666667, 1.35, 0
2476, 2.0583333333333, 1.35, 0
2477, 2.075, 1.35, 0
2478, 2.0916666666667, 1.35, 0
2479, 2.1083333333333, 1.35, 0
2480, 2.125, 1.35, 0
2481, 2.1416666666667, 1.35, 0
2482, 2.1583333333333, 1.35, 0
2483, 2.175, 1.35, 0
2484, 2.1916666666667, 1.35, 0
2485, 2.2, 1.2666666666667, 0
2486, 2.2, 1.2833333333333, 0
2487, 2.2, 1.3, 0
2488, 2.2, 1.3166666666667, 0
2489, 2.2, 1.3333333333333, 0
2490, 2.2, 1.2583333333333, 0
2491, 2.2, 1.275, 0
2492, 2.2, 1.2916666666667, 0
2493, 2.2, 1.3083333333333, 0
2494, 2.2, 1.325, 0
2495, 2.2, 1.3416666666667, 0
2496, 0, 1.39, 0
2497, 0, 1.43, 0
2498, 0, 1.47, 0
2499, 0, 1.51, 0
2500, 0, 1.37, 0
2501, 0, 1.41, 0
2502, 0, 1.45, 0
2503, 0, 1.49, 0
2504, 0, 1.53, 0
2505, 0.98333333333333, 1.55, 0
2506, 0.96666666666667, 1.55, 0
2507, 0.95, 1.55, 0
2508, 0.93333333333333, 1.55, 0
2509, 0.91666666666667, 1.55, 0
2510, 0.9, 1.55, 0
2511, 0.88333333333333, 1.55, 0
2512, 0.86666666666667, 1.55, 0
2513, 0.85, 1.55, 0
2514, 0.83333333333333, 1.55, 0
2515, 0.81666666666667, 1.55, 0
2516, 0.8, 1.55, 0
2517, 0.78333333333333, 1.55, 0
2518, 0.76666666666667, 1.55, 0
2519, 0.75, 1.55, 0
2520, 0.73333333333333, 1.55, 0
2521, 0.71666666666667, 1.55, 0
2522, 0.7, 1.55, 0
2523, 0.68333333333333, 1.55, 0
2524, 0.66666666666667, 1.55, 0
2525, 0.65, 1.55, 0
2526, 0.63333333333333, 1.55, 0
2527, 0.61666666666667, 1.55, 0
2528, 0.6, 1.55, 0
2529, 0.58333333333333, 1.55, 0
2530, 0.56666666666667, 1.55, 0
2531, 0.55, 1.55, 0
2532, 0.53333333333333, 1.55, 0
2533, 0.51666666666667, 1.55, 0
2534, 0.5, 1.55, 0
2535, 0.48333333333333, 1.55, 0
2536, 0.46666666666667, 1.55, 0
2537, 0.45, 1.55, 0
2538, 0.43333333333333, 1.55, 0
2539, 0.41666666666667, 1.55, 0
2540, 0.4, 1.55, 0
2541, 0.38333333333333, 1.55, 0
2542, 0.36666666666667, 1.55, 0
2543, 0.35, 1.55, 0
2544, 0.33333333333333, 1.55, 0
2545, 0.31666666666667, 1.55, 0
2546, 0.3, 1.55, 0
2547, 0.28333333333333, 1.55, 0
2548, 0.26666666666667, 1.55, 0
2549, 0.25, 1.55, 0
2550, 0.23333333333333, 1.55, 0
2551, 0.21666666666667, 1.55, 0
2552, 0.2, 1.55, 0
2553, 0.18333333333333, 1.55, 0
2554, 0.16666666666667, 1.55, 0
2555, 0.15, 1.55, 0
2556, 0.13333333333333, 1.55, 0
2557, 0.11666666666667, 1.55, 0
2558, 0.1, 1.55, 0
2559, 0.083333333333333, 1.55, 0
2560, 0.066666666666667, 1.55, 0
2561, 0.05, 1.55, 0
2562, 0.033333333333333, 1.55, 0
2563, 0.016666666666667, 1.55, 0
2564, 0.99166666666667, 1.55, 0
2565, 0.975, 1.55, 0
2566, 0.95833333333333, 1.55, 0
2567, 0.94166666666667, 1.55, 0
2568, 0.925, 1.55, 0
2569, 0.90833333333333, 1.55, 0
2570, 0.89166666666667, 1.55, 0
2571, 0.875, 1.55, 0
2572, 0.85833333333333, 1.55, 0
2573, 0.84166666666667, 1.55, 0
2574, 0.825, 1.55, 0
2575, 0.80833333333333, 1.55, 0
2576, 0.79166666666667, 1.55, 0
2577, 0.775, 1.55, 0
2578, 0.75833333333333, 1.55, 0
2579, 0.74166666666667, 1.55, 0
2580, 0.725, 1.55, 0
2581, 0.70833333333333, 1.55, 0
2582, 0.69166666666667, 1.55, 0
2583, 0.675, 1.55, 0
2584, 0.65833333333333, 1.55, 0
2585, 0.64166666666667, 1.55, 0
2586, 0.625, 1.55, 0
2587, 0.60833333333333, 1.55, 0
2588, 0.59166666666667, 1.55, 0
2589, 0.575, 1.55, 0
2590, 0.55833333333333, 1.55, 0
2591, 0.54166666666667, 1.55, 0
2592, 0.525, 1.55, 0
2593, 0.50833333333333, 1.55, 0
2594, 0.49166666666667, 1.55, 0
2595, 0.475, 1.55, 0
2596, 0.45833333333333, 1.55, 0
2597, 0.44166666666667, 1.55, 0
2598, 0.425, 1.55, 0
2599, 0.40833333333333, 1.55, 0
2600, 0.39166666666667, 1.55, 0
2601, 0.375, 1.55, 0
2602, 0.35833333333333, 1.55, 0
2603, 0.34166666666667, 1.55, 0
2604, 0.325, 1.55, 0
2605, 0.30833333333333, 1.55, 0
2606, 0.29166666666667, 1.55, 0
2607, 0.275, 1.55, 0
2608, 0.25833333333333, 1.55, 0
2609, 0.24166666666667, 1.55, 0
2610, 0.225, 1.55, 0
2611, 0.20833333333333, 1.55, 0
2612, 0.19166666666667, 1.55, 0
2613, 0.175, 1.55, 0
2614, 0.15833333333333, 1.55, 0
2615, 0.14166666666667, 1.55, 0
2616, 0.125, 1.55, 0
2617, 0.10833333333333, 1.55, 0
2618, 0.091666666666667, 1.55, 0
2619, 0.075, 1.55, 0
2620, 0.058333333333333, 1.55, 0
2621, 0.041666666666667, 1.55, 0
2622, 0.025, 1.55, 0
2623, 0.0083333333333333, 1.55, 0
2624, 2.2, 1.51, 0
2625, 2.2, 1.47, 0
2626, 2.2, 1.43, 0
2627, 2.2, 1.39, 0
2628, 2.2, 1.53, 0
2629, 2.2, 1.49, 0
2630, 2.2, 1.45, 0
2631, 2.2, 1.41, 0
2632, 2.2, 1.37, 0
2633, 1.2166666666667, 1.55, 0
2634, 1.2333333333333, 1.55, 0
2635, 1.25, 1.55, 0
2636, 1.2666666666667, 1.55, 0
2637, 1.2833333333333, 1.55, 0
2638, 1.3, 1.55, 0
2639, 1.3166666666667, 1.55, 0
2640, 1.3333333333333, 1.55, 0
2641, 1.35, 1.55, 0
2642, 1.3666666666667, 1.55, 0
2643, 1.3833333333333, 1.55, 0
2644, 1.4, 1.55, 0
2645, 1.4166666666667, 1.55, 0
2646, 1.4333333333333, 1.55, 0
2647, 1.45, 1.55, 0
2648, 1.4666666666667, 1.55, 0
2649, 1.4833333333333, 1.55, 0
2650, 1.5, 1.55, 0
2651, 1.5166666666667, 1.55, 0
2652, 1.5333333333333, 1.55, 0
2653, 1.55, 1.55, 0
2654, 1.5666666666667, 1.55, 0
2655, 1.5833333333333, 1.55, 0
2656, 1.6, 1.55, 0
2657, 1.6166666666667, 1.55, 0
2658, 1.6333333333333, 1.55, 0
2659, 1.65, 1.55, 0
2660, 1.6666666666667, 1.55, 0
2661, 1.6833333333333, 1.55, 0
2662, 1.7, 1.55, 0
2663, 1.7166666666667, 1.55, 0
2664, 1.7333333333333, 1.55, 0
2665, 1.75, 1.55, 0
2666, 1.7666666666667, 1.55, 0
2667, 1.7833333333333, 1.55, 0
2668, 1.8, 1.55, 0
2669, 1.8166666666667, 1.55, 0
2670, 1.8333333333333, 1.55, 0
2671, 1.85, 1.55, 0
2672, 1.8666666666667, 1.55, 0
2673, 1.8833333333333, 1.55, 0
2674, 1.9, 1.55, 0
2675, 1.9166666666667, 1.55, 0
2676, 1.9333333333333, 1.55, 0
2677, 1.95, 1.55, 0
2678, 1.9666666666667, 1.55, 0
2679, 1.9833333333333, 1.55, 0
2680, 2, 1.55, 0
2681, 2.0166666666667, 1.55, 0
2682, 2.0333333333333, 1.55, 0
2683, 2.05, 1.55, 0
2684, 2.0666666666667, 1.55, 0
2685, 2.0833333333333, 1.55, 0
2686, 2.1, 1.55, 0
2687, 2.1166666666667, 1.55, 0
2688, 2.1333333333333, 1.55, 0
2689, 2.15, 1.55, 0
2690, 2.1666666666667, 1.55, 0
2691, 2.1833333333333, 1.55, 0
2692, 1.2083333333333, 1.55, 0
2693, 1.225, 1.55, 0
2694, 1.2416666666667, 1.55, 0
2695, 1.2583333333333, 1.55, 0
2696, 1.275, 1.55, 0
2697, 1.2916666666667, 1.55, 0
2698, 1.3083333333333, 1.55, 0
2699, 1.325, 1.55, 0
2700, 1.3416666666667, 1.55, 0
2701, 1.3583333333333, 1.55, 0
2702, 1.375, 1.55, 0
2703, 1.3916666666667, 1.55, 0
2704, 1.4083333333333, 1.55, 0
2705, 1.425, 1.55, 0
2706, 1.4416666666667, 1.55, 0
2707, 1.4583333333333, 1.55, 0
2708, 1.475, 1.55, 0
2709, 1.4916666666667, 1.55, 0
2710, 1.5083333333333, 1.55, 0
2711, 1.525, 1.55, 0
2712, 1.5416666666667, 1.55, 0
2713, 1.5583333333333, 1.55, 0
2714, 1.575, 1.55, 0
2715, 1.5916666666667, 1.55, 0
2716, 1.6083333333333, 1.55, 0
2717, 1.625, 1.55, 0
2718, 1.6416666666667, 1.55, 0
2719, 1.6583333333333, 1.55, 0
2720, 1.675, 1.55, 0
2721, 1.6916666666667, 1.55, 0
2722, 1.7083333333333, 1.55, 0
2723, 1.725, 1.55, 0
2724, 1.7416666666667, 1.55, 0
2725, 1.7583333333333, 1.55, 0
2726, 1.775, 1.55, 0
2727, 1.7916666666667, 1.55, 0
2728, 1.8083333333333, 1.55, 0
2729, 1.825, 1.55, 0
2730, 1.8416666666667, 1.55, 0
2731, 1.8583333333333, 1.55, 0
2732, 1.875, 1.55, 0
2733, 1.8916666666667, 1.55, 0
2734, 1.9083333333333, 1.55, 0
2735, 1.925, 1.55, 0
2736, 1.9416666666667, 1.55, 0
2737, 1.9583333333333, 1.55, 0
2738, 1.975, 1.55, 0
2739, 1.9916666666667, 1.55, 0
2740, 2.0083333333333, 1.55, 0
2741, 2.025, 1.55, 0
2742, 2.0416666666667, 1.55, 0
2743, 2.0583333333333, 1.55, 0
2744, 2.075, 1.55, 0
2745, 2.0916666666667, 1.55, 0
2746, 2.1083333333333, 1.55, 0
2747, 2.125, 1.55, 0
2748, 2.1416666666667, 1.55, 0
2749, 2.1583333333333, 1.55, 0
2750, 2.175, 1.55, 0
2751, 2.1916666666667, 1.55, 0
2752, 2.2666666666667, 1.55, 0
2753, 2.2333333333333, 1.55, 0
2754, 2.2833333333333, 1.55, 0
2755, 2.25, 1.55, 0
2756, 2.2166666666667, 1.55, 0
2757, 2.2666666666667, 1.35, 0
2758, 2.2333333333333, 1.35, 0
2759, 2.2833333333333, 1.35, 0
2760, 2.25, 1.35, 0
2761, 2.2166666666667, 1.35, 0
2762, 2.3, 1.51, 0
2763, 2.3, 1.47, 0
2764, 2.3, 1.43, 0
2765, 2.3, 1.39, 0
2766, 2.3, 1.53, 0
2767, 2.3, 1.49, 0
2768, 2.3, 1.45, 0
2769, 2.3, 1.41, 0
2770, 2.3, 1.37, 0
2771, -0.066666666666667, 1.35, 0
2772, -0.033333333333333, 1.35, 0
2773, -0.083333333333333, 1.35, 0
2774, -0.05, 1.35, 0
2775, -0.016666666666667, 1.35, 0
2776, -0.066666666666667, 1.55, 0
2777, -0.033333333333333, 1.55, 0
2778, -0.083333333333333, 1.55, 0
2779, -0.05, 1.55, 0
2780, -0.016666666666667, 1.55, 0
2781, -0.1, 1.39, 0
2782, -0.1, 1.43, 0
2783, -0.1, 1.47, 0
2784, -0.1, 1.51, 0
2785, -0.1, 1.37, 0
2786, -0.1, 1.41, 0
2787, -0.1, 1.45, 0
2788, -0.1, 1.49, 0
2789, -0.1, 1.53, 0
2790, 0.016666666666667, 0.02, 0
2791, 0.016666666666667, 0.04, 0
2792, 0.016666666666667, 0.06, 0
2793, 0.016666666666667, 0.08, 0
2794, 0.016666666666667, 0.1, 0
2795, 0.016666666666667, 0.12, 0
2796, 0.016666666666667, 0.14, 0
2797, 0.016666666666667, 0.16, 0
2798, 0.016666666666667, 0.18, 0
2799, 0.016666666666667, 0.2, 0
2800, 0.016666666666667, 0.22, 0
2801, 0.016666666666667, 0.24, 0
2802, 0.016666666666667, 0.26, 0
2803, 0.016666666666667, 0.28, 0
2804, 0.016666666666667, 0.3, 0
2805, 0.016666666666667, 0.32, 0
2806, 0.016666666666667, 0.34, 0
2807, 0.016666666666667, 0.36, 0
2808, 0.016666666666667, 0.38, 0
2809, 0.016666666666667, 0.4, 0
2810, 0.016666666666667, 0.42, 0
2811, 0.016666666666667, 0.44, 0
2812, 0.016666666666667, 0.46, 0
2813, 0.016666666666667, 0.48, 0
2814, 0.016666666666667, 0.5, 0
2815, 0.016666666666667, 0.52, 0
2816, 0.016666666666667, 0.54, 0
2817, 0.016666666666667, 0.56, 0
2818, 0.016666666666667, 0.58, 0
2819, 0.016666666666667, 0.6, 0
2820, 0.016666666666667, 0.62, 0
2821, 0.016666666666667, 0.64, 0
2822, 0.016666666666667, 0.66, 0
2823, 0.016666666666667, 0.68, 0
2824, 0.016666666666667, 0.7, 0
2825, 0.016666666666667, 0.72, 0
2826, 0.016666666666667, 0.74, 0
2827, 0.016666666666667, 0.76, 0
2828, 0.016666666666667, 0.78, 0
2829, 0.016666666666667, 0.8, 0
2830, 0.016666666666667, 0.82, 0
2831, 0.016666666666667, 0.84, 0
2832, 0.016666666666667, 0.86, 0
2833, 0.016666666666667, 0.88, 0
2834, 0.016666666666667, 0.9, 0
2835, 0.016666666666667, 0.92, 0
2836, 0.016666666666667, 0.94, 0
2837, 0.016666666666667, 0.96, 0
2838, 0.016666666666667, 0.98, 0
2839, 0.016666666666667, 1, 0
2840, 0.016666666666667, 1.02, 0
2841, 0.016666666666667, 1.04, 0
2842, 0.016666666666667, 1.06, 0
2843, 0.016666666666667, 1.08, 0
2844, 0.016666666666667, 1.1, 0
2845, 0.016666666666667, 1.12, 0
2846, 0.016666666666667, 1.14, 0
2847, 0.016666666666667, 1.16, 0
2848, 0.016666666666667, 1.18, 0
2849, 0.033333333333333, 0.02, 0
2850, 0.033333333333333, 0.04, 0
2851, 0.033333333333333, 0.06, 0
2852, 0.033333333333333, 0.08, 0
2853, 0.033333333333333, 0.1, 0
2854, 0.033333333333333, 0.12, 0
2855, 0.033333333333333, 0.14, 0
2856, 0.033333333333333, 0.16, 0
2857, 0.033333333333333, 0.18, 0
2858, 0.033333333333333, 0.2, 0
2859, 0.033333333333333, 0.22, 0
2860, 0.033333333333333, 0.24, 0
2861, 0.033333333333333, 0.26, 0
2862, 0.033333333333333, 0.28, 0
2863, 0.033333333333333, 0.3, 0
2864, 0.033333333333333, 0.32, 0
2865, 0.033333333333333, 0.34, 0
2866, 0.033333333333333, 0.36, 0
2867, 0.033333333333333, 0.38, 0
2868, 0.033333333333333, 0.4, 0
2869, 0.033333333333333, 0.42, 0
2870, 0.033333333333333, 0.44, 0
2871, 0.033333333333333, 0.46, 0
2872, 0.033333333333333, 0.48, 0
2873, 0.033333333333333, 0.5, 0
2874, 0.033333333333333, 0.52, 0
2875, 0.033333333333333, 0.54, 0
2876, 0.033333333333333, 0.56, 0
2877, 0.033333333333333, 0.58, 0
2878, 0.033333333333333, 0.6, 0
2879, 0.033333333333333, 0.62, 0
2880, 0.033333333333333, 0.64, 0
2881, 0.033333333333333, 0.66, 0
2882, 0.033333333333333, 0.68, 0
2883, 0.033333333333333, 0.7, 0
2884, 0.033333333333333, 0.72, 0
2885, 0.033333333333333, 0.74, 0
2886, 0.033333333333333, 0.76, 0
2887, 0.033333333333333, 0.78, 0
2888, 0.033333333333333, 0.8, 0
2889, 0.033333333333333, 0.82, 0
2890, 0.033333333333333, 0.84, 0
2891, 0.033333333333333, 0.86, 0
2892, 0.033333333333333, 0.88, 0
2893, 0.033333333333333, 0.9, 0
2894, 0.033333333333333, 0.92, 0
2895, 0.033333333333333, 0.94, 0
2896, 0.033333333333333, 0.96, 0
2897, 0.033333333333333, 0.98, 0
2898, 0.033333333333333, 1, 0
2899, 0.033333333333333, 1.02, 0
2900, 0.033333333333333, 1.04, 0
2901, 0.033333333333333, 1.06, 0
2902, 0.033333333333333, 1.08, 0
2903, 0.033333333333333, 1.1, 0
2904, 0.033333333333333, 1.12, 0
2905, 0.033333333333333, 1.14, 0
2906, 0.033333333333333, 1.16, 0
2907, 0.033333333333333, 1.18, 0
2908, 0.05, 0.02, 0
2909, 0.05, 0.04, 0
2910, 0.05, 0.06, 0
2911, 0.05, 0.08, 0
2912, 0.05, 0.1, 0
2913, 0.05, 0.12, 0
2914, 0.05, 0.14, 0
2915, 0.05, 0.16, 0
2916, 0.05, 0.18, 0
2917, 0.05, 0.2, 0
2918, 0.05, 0.22, 0
2919, 0.05, 0.24, 0
2920, 0.05, 0.26, 0
2921, 0.05, 0.28, 0
2922, 0.05, 0.3, 0
2923, 0.05, 0.32, 0
2924, 0.05, 0.34, 0
2925, 0.05, 0.36, 0
2926, 0.05, 0.38, 0
2927, 0.05, 0.4, 0
2928, 0.05, 0.42, 0
2929, 0.05, 0.44, 0
2930, 0.05, 0.46, 0
2931, 0.05, 0.48, 0
2932, 0.05, 0.5, 0
2933, 0.05, 0.52, 0
2934, 0.05, 0.54, 0
2935, 0.05, 0.56, 0
2936, 0.05, 0.58, 0
2937, 0.05, 0.6, 0
2938, 0.05, 0.62, 0
2939, 0.05, 0.64, 0
2940, 0.05, 0.66, 0
2941, 0.05, 0.68, 0
2942, 0.05, 0.7, 0
2943, 0.05, 0.72, 0
2944, 0.05, 0.74, 0
2945, 0.05, 0.76, 0
2946, 0.05, 0.78, 0
2947, 0.05, 0.8, 0
2948, 0.05, 0.82, 0
2949, 0.05, 0.84, 0
2950, 0.05, 0.86, 0
2951, 0.05, 0.88, 0
2952, 0.05, 0.9, 0
2953, 0.05, 0.92, 0
2954, 0.05, 0.94, 0
2955, 0.05, 0.96, 0
2956, 0.05, 0.98, 0
2957, 0.05, 1, 0
2958, 0.05, 1.02, 0
2959, 0.05, 1.04, 0
2960, 0.05, 1.06, 0
2961, 0.05, 1.08, 0
2962, 0.05, 1.1, 0
2963, 0.05, 1.12, 0
2964, 0.05, 1.14, 0
2965, 0.05, 1.16, 0
2966, 0.05, 1.18, 0
2967, 0.066666666666667, 0.02, 0
2968, 0.066666666666667, 0.04, 0
2969, 0.066666666666667, 0.06, 0
2970, 0.066666666666667, 0.08, 0
2971, 0.066666666666667, 0.1, 0
2972, 0.066666666666667, 0.12, 0
2973, 0.066666666666667, 0.14, 0
2974, 0.066666666666667, 0.16, 0
2975, 0.066666666666667, 0.18, 0
2976, 0.066666666666667, 0.2, 0
2977, 0.066666666666667, 0.22, 0
2978, 0.066666666666667, 0.24, 0
2979, 0.066666666666667, 0.26, 0
2980, 0.066666666666667, 0.28, 0
2981, 0.066666666666667, 0.3, 0
2982, 0.066666666666667, 0.32, 0
2983, 0.066666666666667, 0.34, 0
2984, 0.066666666666667, 0.36, 0
2985, 0.066666666666667, 0.38, 0
2986, 0.066666666666667, 0.4, 0
2987, 0.066666666666667, 0.42, 0
2988, 0.066666666666667, 0.44, 0
2989, 0.066666666666667, 0.46, 0
2990, 0.066666666666667, 0.48, 0
2991, 0.066666666666667, 0.5, 0
2992, 0.066666666666667, 0.52, 0
2993, 0.066666666666667, 0.54, 0
2994, 0.066666666666667, 0.56, 0
2995, 0.066666666666667, 0.58, 0
2996, 0.066666666666667, 0.6, 0
2997, 0.066666666666667, 0.62, 0
2998, 0.066666666666667, 0.64, 0
2999, 0.066666666666667, 0.66, 0
3000, 0.066666666666667, 0.68, 0
3001, 0.066666666666667, 0.7, 0
3002, 0.066666666666667, 0.72, 0
3003, 0.066666666666667, 0.74, 0
3004, 0.066666666666667, 0.76, 0
3005, 0.066666666666667, 0.78, 0
3006, 0.066666666666667, 0.8, 0
3007, 0.066666666666667, 0.82, 0
3008, 0.066666666666667, 0.84, 0
3009, 0.066666666666667, 0.86, 0
3010, 0.066666666666667, 0.88, 0
3011, 0.066666666666667, 0.9, 0
3012, 0.066666666666667, 0.92, 0
3013, 0.066666666666667, 0.94, 0
3014, 0.066666666666667, 0.96, 0
3015, 0.066666666666667, 0.98, 0
3016, 0.066666666666667, 1, 0
3017, 0.066666666666667, 1.02, 0
3018, 0.066666666666667, 1.04, 0
3019, 0.066666666666667, 1.06, 0
3020, 0.066666666666667, 1.08, 0
3021, 0.066666666666667, 1.1, 0
3022, 0.066666666666667, 1.12, 0
3023, 0.066666666666667, 1.14, 0
3024, 0.066666666666667, 1.16, 0
3025, 0.066666666666667, 1.18, 0
3026, 0.083333333333333, 0.02, 0
3027, 0.083333333333333, 0.04, 0
3028, 0.083333333333333, 0.06, 0
3029, 0.083333333333333, 0.08, 0
3030, 0.083333333333333, 0.1, 0
3031, 0.083333333333333, 0.12, 0
3032, 0.083333333333333, 0.14, 0
3033, 0.083333333333333, 0.16, 0
3034, 0.083333333333333, 0.18, 0
3035, 0.083333333333333, 0.2, 0
3036, 0.083333333333333, 0.22, 0
3037, 0.083333333333333, 0.24, 0
3038, 0.083333333333333, 0.26, 0
3039, 0.083333333333333, 0.28, 0
3040, 0.083333333333333, 0.3, 0
3041, 0.083333333333333, 0.32, 0
3042, 0.083333333333333, 0.34, 0
3043, 0.083333333333333, 0.36, 0
3044, 0.083333333333333, 0.38, 0
3045, 0.083333333333333, 0.4, 0
3046, 0.083333333333333, 0.42, 0
3047, 0.083333333333333, 0.44, 0
3048, 0.083333333333333, 0.46, 0
3049, 0.083333333333333, 0.48, 0
3050, 0.083333333333333, 0.5, 0
3051, 0.083333333333333, 0.52, 0
3052, 0.083333333333333, 0.54, 0
3053, 0.083333333333333, 0.56, 0
3054, 0.083333333333333, 0.58, 0
3055, 0.083333333333333, 0.6, 0
3056, 0.083333333333333, 0.62, 0
3057, 0.083333333333333, 0.64, 0
3058, 0.083333333333333, 0.66, 0
3059, 0.083333333333333, 0.68, 0
3060, 0.083333333333333, 0.7, 0
3061, 0.083333333333333, 0.72, 0
3062, 0.083333333333333, 0.74, 0
3063, 0.083333333333333, 0.76, 0
3064, 0.083333333333333, 0.78, 0
3065, 0.083333333333333, 0.8, 0
3066, 0.083333333333333, 0.82, 0
3067, 0.083333333333333, 0.84, 0
3068, 0.083333333333333, 0.86, 0
3069, 0.083333333333333, 0.88, 0
3070, 0.083333333333333, 0.9, 0
3071, 0.083333333333333, 0.92, 0
3072, 0.083333333333333, 0.94, 0
3073, 0.083333333333333, 0.96, 0
3074, 0.083333333333333, 0.98, 0
3075, 0.083333333333333, 1, 0
3076, 0.083333333333333, 1.02, 0
3077, 0.083333333333333, 1.04, 0
3078, 0.083333333333333, 1.06, 0
3079, 0.083333333333333, 1.08, 0
3080, 0.083333333333333, 1.1, 0
3081, 0.083333333333333, 1.12, 0
3082, 0.083333333333333, 1.14, 0
3083, 0.083333333333333, 1.16, 0
3084, 0.083333333333333, 1.18, 0
3085, 0.1, 0.02, 0
3086, 0.1, 0.04, 0
3087, 0.1, 0.06, 0
3088, 0.1, 0.08, 0
3089, 0.1, 0.1, 0
3090, 0.1, 0.12, 0
3091, 0.1, 0.14, 0
3092, 0.1, 0.16, 0
3093, 0.1, 0.18, 0
3094, 0.1, 0.2, 0
3095, 0.1, 0.22, 0
3096, 0.1, 0.24, 0
3097, 0.1, 0.26, 0
3098, 0.1, 0.28, 0
3099, 0.1, 0.3, 0
3100, 0.1, 0.32, 0
3101, 0.1, 0.34, 0
3102, 0.1, 0.36, 0
3103, 0.1, 0.38, 0
3104, 0.1, 0.4, 0
3105, 0.1, 0.42, 0
3106, 0.1, 0.44, 0
3107, 0.1, 0.46, 0
3108, 0.1, 0.48, 0
3109, 0.1, 0.5, 0
3110, 0.1, 0.52, 0
3111, 0.1, 0.54, 0
3112, 0.1, 0.56, 0
3113, 0.1, 0.58, 0
3114, 0.1, 0.6, 0
3115, 0.1, 0.62, 0
3116, 0.1, 0.64, 0
3117, 0.1, 0.66, 0
3118, 0.1, 0.68, 0
3119, 0.1, 0.7, 0
3120, 0.1, 0.72, 0
3121, 0.1, 0.74, 0
3122, 0.1, 0.76, 0
3123, 0.1, 0.78, 0
3124, 0.1, 0.8, 0
3125, 0.1, 0.82, 0
3126, 0.1, 0.84, 0
3127, 0.1, 0.86, 0
3128, 0.1, 0.88, 0
3129, 0.1, 0.9, 0
3130, 0.1, 0.92, 0
3131, 0.1, 0.94, 0
3132, 0.1, 0.96, 0
3133, 0.1, 0.98, 0
3134, 0.1, 1, 0
3135, 0.1, 1.02, 0
3136, 0.1, 1.04, 0
3137, 0.1, 1.06, 0
3138, 0.1, 1.08, 0
3139, 0.1, 1.1, 0
3140, 0.1, 1.12, 0
3141, 0.1, 1.14, 0
3142, 0.1, 1.16, 0
3143, 0.1, 1.18, 0
3144, 0.11666666666667, 0.02, 0
3145, 0.11666666666667, 0.04, 0
3146, 0.11666666666667, 0.06, 0
3147, 0.11666666666667, 0.08, 0
3148, 0.11666666666667, 0.1, 0
3149, 0.11666666666667, 0.12, 0
3150, 0.11666666666667, 0.14, 0
3151, 0.11666666666667, 0.16, 0
3152, 0.11666666666667, 0.18, 0
3153, 0.11666666666667, 0.2, 0
3154, 0.11666666666667, 0.22, 0
3155, 0.11666666666667, 0.24, 0
3156, 0.11666666666667, 0.26, 0
3157, 0.11666666666667, 0.28, 0
3158, 0.11666666666667, 0.3, 0
3159, 0.11666666666667, 0.32, 0
3160, 0.11666666666667, 0.34, 0
3161, 0.11666666666667, 0.36, 0
3162, 0.11666666666667, 0.38, 0
3163, 0.11666666666667, 0.4, 0
3164, 0.11666666666667, 0.42, 0
3165, 0.11666666666667, 0.44, 0
3166, 0.11666666666667, 0.46, 0
3167, 0.11666666666667, 0.48, 0
3168, 0.11666666666667, 0.5, 0
3169, 0.11666666666667, 0.52, 0
3170, 0.11666666666667, 0.54, 0
3171, 0.11666666666667, 0.56, 0
3172, 0.11666666666667, 0.58, 0
3173, 0.11666666666667, 0.6, 0
3174, 0.11666666666667, 0.62, 0
3175, 0.11666666666667, 0.64, 0
3176, 0.11666666666667, 0.66, 0
3177, 0.11666666666667, 0.68, 0
3178, 0.11666666666667, 0.7, 0
3179, 0.11666666666667, 0.72, 0
3180, 0.11666666666667, 0.74, 0
3181, 0.11666666666667, 0.76, 0
3182, 0.11666666666667, 0.78, 0
3183, 0.11666666666667, 0.8, 0
3184, 0.11666666666667, 0.82, 0
3185, 0.11666666666667, 0.84, 0
3186, 0.11666666666667, 0.86, 0
3187, 0.11666666666667, 0.88, 0
3188, 0.11666666666667, 0.9, 0
3189, 0.11666666666667, 0.92, 0
3190, 0.11666666666667, 0.94, 0
3191, 0.11666666666667, 0.96, 0
3192, 0.11666666666667, 0.98, 0
3193, 0.11666666666667, 1, 0
3194, 0.11666666666667, 1.02, 0
3195, 0.11666666666667, 1.04, 0
3196, 0.11666666666667, 1.06, 0
3197, 0.11666666666667, 1.08, 0
3198, 0.11666666666667, 1.1, 0
3199, 0.11666666666667, 1.12, 0
3200, 0.11666666666667, 1.14, 0
3201, 0.11666666666667, 1.16, 0
3202, 0.11666666666667, 1.18, 0
3203, 0.13333333333333, 0.02, 0
3204, 0.13333333333333, 0.04, 0
3205, 0.13333333333333, 0.06, 0
3206, 0.13333333333333, 0.08, 0
3207, 0.13333333333333, 0.1, 0
3208, 0.13333333333333, 0.12, 0
3209, 0.13333333333333, 0.14, 0
3210, 0.13333333333333, 0.16, 0
3211, 0.13333333333333, 0.18, 0
3212, 0.13333333333333, 0.2, 0
3213, 0.13333333333333, 0.22, 0
3214, 0.13333333333333, 0.24, 0
3215, 0.13333333333333, 0.26, 0
3216, 0.13333333333333, 0.28, 0
3217, 0.13333333333333, 0.3, 0
3218, 0.13333333333333, 0.32, 0
3219, 0.13333333333333, 0.34, 0
3220, 0.13333333333333, 0.36, 0
3221, 0.13333333333333, 0.38, 0
3222, 0.13333333333333, 0.4, 0
3223, 0.13333333333333, 0.42, 0
3224, 0.13333333333333, 0.44, 0
3225, 0.13333333333333, 0.46, 0
3226, 0.13333333333333, 0.48, 0
3227, 0.13333333333333, 0.5, 0
3228, 0.13333333333333, 0.52, 0
3229, 0.13333333333333, 0.54, 0
3230, 0.13333333333333, 0.56, 0
3231, 0.13333333333333, 0.58, 0
3232, 0.13333333333333, 0.6, 0
3233, 0.13333333333333, 0.62, 0
3234, 0.13333333333333, 0.64, 0
3235, 0.13333333333333, 0.66, 0
3236, 0.13333333333333, 0.68, 0
3237, 0.13333333333333, 0.7, 0
3238, 0.13333333333333, 0.72, 0
3239, 0.13333333333333, 0.74, 0
3240, 0.13333333333333, 0.76, 0
3241, 0.13333333333333, 0.78, 0
3242, 0.13333333333333, 0.8, 0
3243, 0.13333333333333, 0.82, 0
3244, 0.13333333333333, 0.84, 0
3245, 0.13333333333333, 0.86, 0
3246, 0.13333333333333, 0.88, 0
3247, 0.13333333333333, 0.9, 0
3248, 0.13333333333333, 0.92, 0
3249, 0.13333333333333, 0.94, 0
3250, 0.13333333333333, 0.96, 0
3251, 0.13333333333333, 0.98, 0
3252, 0.13333333333333, 1, 0
3253, 0.13333333333333, 1.02, 0
3254, 0.13333333333333, 1.04, 0
3255, 0.13333333333333, 1.06, 0
3256, 0.13333333333333, 1.08, 0
3257, 0.13333333333333, 1.1, 0
3258, 0.13333333333333, 1.12, 0
3259, 0.13333333333333, 1.14, 0
3260, 0.13333333333333, 1.16, 0
3261, 0.13333333333333, 1.18, 0
3262, 0.15, 0.02, 0
3263, 0.15, 0.04, 0
3264, 0.15, 0.06, 0
3265, 0.15, 0.08, 0
3266, 0.15, 0.1, 0
3267, 0.15, 0.12, 0
3268, 0.15, 0.14, 0
3269, 0.15, 0.16, 0
3270, 0.15, 0.18, 0
3271, 0.15, 0.2, 0
3272, 0.15, 0.22, 0
3273, 0.15, 0.24, 0
3274, 0.15, 0.26, 0
3275, 0.15, 0.28, 0
3276, 0.15, 0.3, 0
3277, 0.15, 0.32, 0
3278, 0.15, 0.34, 0
3279, 0.15, 0.36, 0
3280, 0.15, 0.38, 0
3281, 0.15, 0.4, 0
3282, 0.15, 0.42, 0
3283, 0.15, 0.44, 0
3284, 0.15, 0.46, 0
3285, 0.15, 0.48, 0
3286, 0.15, 0.5, 0
3287, 0.15, 0.52, 0
3288, 0.15, 0.54, 0
3289, 0.15, 0.56, 0
3290, 0.15, 0.58, 0
3291, 0.15, 0.6, 0
3292, 0.15, 0.62, 0
3293, 0.15, 0.64, 0
3294, 0.15, 0.66, 0
3295, 0.15, 0.68, 0
3296, 0.15, 0.7, 0
3297, 0.15, 0.72, 0
3298, 0.15, 0.74, 0
3299, 0.15, 0.76, 0
3300, 0.15, 0.78, 0
3301, 0.15, 0.8, 0
3302, 0.15, 0.82, 0
3303, 0.15, 0.84, 0
3304, 0.15, 0.86, 0
3305, 0.15, 0.88, 0
3306, 0.15, 0.9, 0
3307, 0.15, 0.92, 0
3308, 0.15, 0.94, 0
3309, 0.15, 0.96, 0
3310, 0.15, 0.98, 0
3311, 0.15, 1, 0
3312, 0.15, 1.02, 0
3313, 0.15, 1.04, 0
3314, 0.15, 1.06, 0
3315, 0.15, 1.08, 0
3316, 0.15, 1.1, 0
3317, 0.15, 1.12, 0
3318, 0.15, 1.14, 0
3319, 0.15, 1.16, 0
3320, 0.15, 1.18, 0
3321, 0.16666666666667, 0.02, 0
3322, 0.16666666666667, 0.04, 0
3323, 0.16666666666667, 0.06, 0
3324, 0.16666666666667, 0.08, 0
3325, 0.16666666666667, 0.1, 0
3326, 0.16666666666667, 0.12, 0
3327, 0.16666666666667, 0.14, 0
3328, 0.16666666666667, 0.16, 0
3329, 0.16666666666667, 0.18, 0
3330, 0.16666666666667, 0.2, 0
3331, 0.16666666666667, 0.22, 0
3332, 0.16666666666667, 0.24, 0
3333, 0.16666666666667, 0.26, 0
3334, 0.16666666666667, 0.28, 0
3335, 0.16666666666667, 0.3, 0
3336, 0.16666666666667, 0.32, 0
3337, 0.16666666666667, 0.34, 0
3338, 0.16666666666667, 0.36, 0
3339, 0.16666666666667, 0.38, 0
3340, 0.16666666666667, 0.4, 0
3341, 0.16666666666667, 0.42, 0
3342, 0.16666666666667, 0.44, 0
3343, 0.16666666666667, 0.46, 0
3344, 0.16666666666667, 0.48, 0
3345, 0.16666666666667, 0.5, 0
3346, 0.16666666666667, 0.52, 0
3347, 0.16666666666667, 0.54, 0
3348, 0.16666666666667, 0.56, 0
3349, 0.16666666666667, 0.58, 0
3350, 0.16666666666667, 0.6, 0
3351, 0.16666666666667, 0.62, 0
3352, 0.16666666666667, 0.64, 0
3353, 0.16666666666667, 0.66, 0
3354, 0.16666666666667, 0.68, 0
3355, 0.16666666666667, 0.7, 0
3356, 0.16666666666667, 0.72, 0
3357, 0.16666666666667, 0.74, 0
3358, 0.16666666666667, 0.76, 0
3359, 0.16666666666667, 0.78, 0
3360, 0.16666666666667, 0.8, 0
3361, 0.16666666666667, 0.82, 0
3362, 0.16666666666667, 0.84, 0
3363, 0.16666666666667, 0.86, 0
3364, 0.16666666666667, 0.88, 0
3365, 0.16666666666667, 0.9, 0
3366, 0.16666666666667, 0.92, 0
3367, 0.16666666666667, 0.94, 0
3368, 0.16666666666667, 0.96, 0
3369, 0.16666666666667, 0.98, 0
3370, 0.16666666666667, 1, 0
3371, 0.16666666666667, 1.02, 0
3372, 0.16666666666667, 1.04, 0
3373, 0.16666666666667, 1.06, 0
3374, 0.16666666666667, 1.08, 0
3375, 0.16666666666667, 1.1, 0
3376, 0.16666666666667, 1.12, 0
3377, 0.16666666666667, 1.14, 0
3378, 0.16666666666667, 1.16, 0
3379, 0.16666666666667, 1.18, 0
3380, 0.18333333333333, 0.02, 0
3381, 0.18333333333333, 0.04, 0
3382, 0.18333333333333, 0.06, 0
3383, 0.18333333333333, 0.08, 0
3384, 0.18333333333333, 0.1, 0
3385, 0.18333333333333, 0.12, 0
3386, 0.18333333333333, 0.14, 0
3387, 0.18333333333333, 0.16, 0
3388, 0.18333333333333, 0.18, 0
3389, 0.18333333333333, 0.2, 0
3390, 0.18333333333333, 0.22, 0
3391, 0.18333333333333, 0.24, 0
3392, 0.18333333333333, 0.26, 0
3393, 0.18333333333333, 0.28, 0
3394, 0.18333333333333, 0.3, 0
3395, 0.18333333333333, 0.32, 0
3396, 0.18333333333333, 0.34, 0
3397, 0.18333333333333, 0.36, 0
3398, 0.18333333333333, 0.38, 0
3399, 0.18333333333333, 0.4, 0
3400, 0.18333333333333, 0.42, 0
3401, 0.18333333333333, 0.44, 0
3402, 0.18333333333333, 0.46, 0
3403, 0.18333333333333, 0.48, 0
3404, 0.18333333333333, 0.5, 0
3405, 0.18333333333333, 0.52, 0
3406, 0.18333333333333, 0.54, 0
3407, 0.18333333333333, 0.56, 0
3408, 0.18333333333333, 0.58, 0
3409, 0.18333333333333, 0.6, 0
3410, 0.18333333333333, 0.62, 0
3411, 0.18333333333333, 0.64, 0
3412, 0.18333333333333, 0.66, 0
3413, 0.18333333333333, 0.68, 0
3414, 0.18333333333333, 0.7, 0
3415, 0.18333333333333, 0.72, 0
3416, 0.18333333333333, 0.74, 0
3417, 0.18333333333333, 0.76, 0
3418, 0.18333333333333, 0.78, 0
3419, 0.18333333333333, 0.8, 0
3420, 0.18333333333333, 0.82, 0
3421, 0.18333333333333, 0.84, 0
3422, 0.18333333333333, 0.86, 0
3423, 0.18333333333333, 0.88, 0
3424, 0.18333333333333, 0.9, 0
3425, 0.18333333333333, 0.92, 0
3426, 0.18333333333333, 0.94, 0
3427, 0.18333333333333, 0.96, 0
3428, 0.18333333333333, 0.98, 0
3429, 0.18333333333333, 1, 0
3430, 0.18333333333333, 1.02, 0
3431, 0.18333333333333, 1.04, 0
3432, 0.18333333333333, 1.06, 0
3433, 0.18333333333333, 1.08, 0
3434, 0.18333333333333, 1.1, 0
3435, 0.18333333333333, 1.12, 0
3436, 0.18333333333333, 1.14, 0
3437, 0.18333333333333, 1.16, 0
3438, 0.18333333333333, 1.18, 0
3439, 0.2, 0.02, 0
3440, 0.2, 0.04, 0
3441, 0.2, 0.06, 0
3442, 0.2, 0.08, 0
3443, 0.2, 0.1, 0
3444, 0.2, 0.12, 0
3445, 0.2, 0.14, 0
3446, 0.2, 0.16, 0
3447, 0.2, 0.18, 0
3448, 0.2, 0.2, 0
3449, 0.2, 0.22, 0
3450, 0.2, 0.24, 0
3451, 0.2, 0.26, 0
3452, 0.2, 0.28, 0
3453, 0.2, 0.3, 0
3454, 0.2, 0.32, 0
3455, 0.2, 0.34, 0
3456, 0.2, 0.36, 0
3457, 0.2, 0.38, 0
3458, 0.2, 0.4, 0
3459, 0.2, 0.42, 0
3460, 0.2, 0.44, 0
3461, 0.2, 0.46, 0
3462, 0.2, 0.48, 0
3463, 0.2, 0.5, 0
3464, 0.2, 0.52, 0
3465, 0.2, 0.54, 0
3466, 0.2, 0.56, 0
3467, 0.2, 0.58, 0
3468, 0.2, 0.6, 0
3469, 0.2, 0.62, 0
3470, 0.2, 0.64, 0
3471, 0.2, 0.66, 0
3472, 0.2, 0.68, 0
3473, 0.2, 0.7, 0
3474, 0.2, 0.72, 0
3475, 0.2, 0.74, 0
3476, 0.2, 0.76, 0
3477, 0.2, 0.78, 0
3478, 0.2, 0.8, 0
3479, 0.2, 0.82, 0
3480, 0.2, 0.84, 0
3481, 0.2, 0.86, 0
3482, 0.2, 0.88, 0
3483, 0.2, 0.9, 0
3484, 0.2, 0.92, 0
3485, 0.2, 0.94, 0
3486, 0.2, 0.96, 0
3487, 0.2, 0.98, 0
3488, 0.2, 1, 0
3489, 0.2, 1.02, 0
3490, 0.2, 1.04, 0
3491, 0.2, 1.06, 0
3492, 0.2, 1.08, 0
3493, 0.2, 1.1, 0
3494, 0.2, 1.12, 0
3495, 0.2, 1.14, 0
3496, 0.2, 1.16, 0
3497, 0.2, 1.18, 0
3498, 0.21666666666667, 0.02, 0
3499, 0.21666666666667, 0.04, 0
3500, 0.21666666666667, 0.06, 0
3501, 0.21666666666667, 0.08, 0
3502, 0.21666666666667, 0.1, 0
3503, 0.21666666666667, 0.12, 0
3504, 0.21666666666667, 0.14, 0
3505, 0.21666666666667, 0.16, 0
3506, 0.21666666666667, 0.18, 0
3507, 0.21666666666667, 0.2, 0
3508, 0.21666666666667, 0.22, 0
3509, 0.21666666666667, 0.24, 0
3510, 0.21666666666667, 0.26, 0
3511, 0.21666666666667, 0.28, 0
3512, 0.21666666666667, 0.3, 0
3513, 0.21666666666667, 0.32, 0
3514, 0.21666666666667, 0.34, 0
3515, 0.21666666666667, 0.36, 0
3516, 0.21666666666667, 0.38, 0
3517, 0.21666666666667, 0.4, 0
3518, 0.21666666666667, 0.42, 0
3519, 0.21666666666667, 0.44, 0
3520, 0.21666666666667, 0.46, 0
3521, 0.21666666666667, 0.48, 0
3522, 0.21666666666667, 0.5, 0
3523, 0.21666666666667, 0.52, 0
3524, 0.21666666666667, 0.54, 0
3525, 0.21666666666667, 0.56, 0
3526, 0.21666666666667, 0.58, 0
3527, 0.21666666666667, 0.6, 0
3528, 0.21666666666667, 0.62, 0
3529, 0.21666666666667, 0.64, 0
3530, 0.21666666666667, 0.66, 0
3531, 0.21666666666667, 0.68, 0
3532, 0.21666666666667, 0.7, 0
3533, 0.21666666666667, 0.72, 0
3534, 0.21666666666667, 0.74, 0
3535, 0.21666666666667, 0.76, 0
3536, 0.21666666666667, 0.78, 0
3537, 0.21666666666667, 0.8, 0
3538, 0.21666666666667, 0.82, 0
3539, 0.21666666666667, 0.84, 0
3540, 0.21666666666667, 0.86, 0
3541, 0.21666666666667, 0.88, 0
3542, 0.21666666666667, 0.9, 0
3543, 0.21666666666667, 0.92, 0
3544, 0.21666666666667, 0.94, 0
3545, 0.21666666666667, 0.96, 0
3546, 0.21666666666667, 0.98, 0
3547, 0.21666666666667, 1, 0
3548, 0.21666666666667, 1.02, 0
3549, 0.21666666666667, 1.04, 0
3550, 0.21666666666667, 1.06, 0
3551, 0.21666666666667, 1.08, 0
3552, 0.21666666666667, 1.1, 0
3553, 0.21666666666667, 1.12, 0
3554, 0.21666666666667, 1.14, 0
3555, 0.21666666666667, 1.16, 0
3556, 0.21666666666667, 1.18, 0
3557, 0.23333333333333, 0.02, 0
3558, 0.23333333333333, 0.04, 0
3559, 0.23333333333333, 0.06, 0
3560, 0.23333333333333, 0.08, 0
3561, 0.23333333333333, 0.1, 0
3562, 0.23333333333333, 0.12, 0
3563, 0.23333333333333, 0.14, 0
3564, 0.23333333333333, 0.16, 0
3565, 0.23333333333333, 0.18, 0
3566, 0.23333333333333, 0.2, 0
3567, 0.23333333333333, 0.22, 0
3568, 0.23333333333333, 0.24, 0
3569, 0.23333333333333, 0.26, 0
3570, 0.23333333333333, 0.28, 0
3571, 0.23333333333333, 0.3, 0
3572, 0.23333333333333, 0.32, 0
3573, 0.23333333333333, 0.34, 0
3574, 0.23333333333333, 0.36, 0
3575, 0.23333333333333, 0.38, 0
3576, 0.23333333333333, 0.4, 0
3577, 0.23333333333333, 0.42, 0
3578, 0.23333333333333, 0.44, 0
3579, 0.23333333333333, 0.46, 0
3580, 0.23333333333333, 0.48, 0
3581, 0.23333333333333, 0.5, 0
3582, 0.23333333333333, 0.52, 0
3583, 0.23333333333333, 0.54, 0
3584, 0.23333333333333, 0.56, 0
3585, 0.23333333333333, 0.58, 0
3586, 0.23333333333333, 0.6, 0
3587, 0.23333333333333, 0.62, 0
3588, 0.23333333333333, 0.64, 0
3589, 0.23333333333333, 0.66, 0
3590, 0.23333333333333, 0.68, 0
3591, 0.23333333333333, 0.7, 0
3592, 0.23333333333333, 0.72, 0
3593, 0.23333333333333, 0.74, 0
3594, 0.23333333333333, 0.76, 0
3595, 0.23333333333333, 0.78, 0
3596, 0.23333333333333, 0.8, 0
3597, 0.23333333333333, 0.82, 0
3598, 0.23333333333333, 0.84, 0
3599, 0.23333333333333, 0.86, 0
3600, 0.23333333333333, 0.88, 0
3601, 0.23333333333333, 0.9, 0
3602, 0.23333333333333, 0.92, 0
3603, 0.23333333333333, 0.94, 0
3604, 0.23333333333333, 0.96, 0
3605, 0.23333333333333, 0.98, 0
3606, 0.23333333333333, 1, 0
3607, 0.23333333333333, 1.02, 0
3608, 0.23333333333333, 1.04, 0
3609, 0.23333333333333, 1.06, 0
3610, 0.23333333333333, 1.08, 0
3611, 0.23333333333333, 1.1, 0
3612, 0.23333333333333, 1.12, 0
3613, 0.23333333333333, 1.14, 0
3614, 0.23333333333333, 1.16, 0
3615, 0.23333333333333, 1.18, 0
3616, 0.25, 0.02, 0
3617, 0.25, 0.04, 0
3618, 0.25, 0.06, 0
3619, 0.25, 0.08, 0
3620, 0.25, 0.1, 0
3621, 0.25, 0.12, 0
3622, 0.25, 0.14, 0
3623, 0.25, 0.16, 0
3624, 0.25, 0.18, 0
3625, 0.25, 0.2, 0
3626, 0.25, 0.22, 0
3627, 0.25, 0.24, 0
3628, 0.25, 0.26, 0
3629, 0.25, 0.28, 0
3630, 0.25, 0.3, 0
3631, 0.25, 0.32, 0
3632, 0.25, 0.34, 0
3633, 0.25, 0.36, 0
3634, 0.25, 0.38, 0
3635, 0.25, 0.4, 0
3636, 0.25, 0.42, 0
3637, 0.25, 0.44, 0
3638, 0.25, 0.46, 0
3639, 0.25, 0.48, 0
3640, 0.25, 0.5, 0
3641, 0.25, 0.52, 0
3642, 0.25, 0.54, 0
3643, 0.25, 0.56, 0
3644, 0.25, 0.58, 0
3645, 0.25, 0.6, 0
3646, 0.25, 0.62, 0
3647, 0.25, 0.64, 0
3648, 0.25, 0.66, 0
3649, 0.25, 0.68, 0
3650, 0.25, 0.7, 0
3651, 0.25, 0.72, 0
3652, 0.25, 0.74, 0
3653, 0.25, 0.76, 0
3654, 0.25, 0.78, 0
3655, 0.25, 0.8, 0
3656, 0.25, 0.82, 0
3657, 0.25, 0.84, 0
3658, 0.25, 0.86, 0
3659, 0.25, 0.88, 0
3660, 0.25, 0.9, 0
3661, 0.25, 0.92, 0
3662, 0.25, 0.94, 0
3663, 0.25, 0.96, 0
3664, 0.25, 0.98, 0
3665, 0.25, 1, 0
3666, 0.25, 1.02, 0
3667, 0.25, 1.04, 0
3668, 0.25, 1.06, 0
3669, 0.25, 1.08, 0
3670, 0.25, 1.1, 0
3671, 0.25, 1.12, 0
3672, 0.25, 1.14, 0
3673, 0.25, 1.16, 0
3674, 0.25, 1.18, 0
3675, 0.26666666666667, 0.02, 0
3676, 0.26666666666667, 0.04, 0
3677, 0.26666666666667, 0.06, 0
3678, 0.26666666666667, 0.08, 0
3679, 0.26666666666667, 0.1, 0
3680, 0.26666666666667, 0.12, 0
3681, 0.26666666666667, 0.14, 0
3682, 0.26666666666667, 0.16, 0
3683, 0.26666666666667, 0.18, 0
3684, 0.26666666666667, 0.2, 0
3685, 0.26666666666667, 0.22, 0
3686, 0.26666666666667, 0.24, 0
3687, 0.26666666666667, 0.26, 0
3688, 0.26666666666667, 0.28, 0
3689, 0.26666666666667, 0.3, 0
3690, 0.26666666666667, 0.32, 0
3691, 0.26666666666667, 0.34, 0
3692, 0.26666666666667, 0.36, 0
3693, 0.26666666666667, 0.38, 0
3694, 0.26666666666667, 0.4, 0
3695, 0.26666666666667, 0.42, 0
3696, 0.26666666666667, 0.44, 0
3697, 0.26666666666667, 0.46, 0
3698, 0.26666666666667, 0.48, 0
3699, 0.26666666666667, 0.5, 0
3700, 0.26666666666667, 0.52, 0
3701, 0.26666666666667, 0.54, 0
3702, 0.26666666666667, 0.56, 0
3703, 0.26666666666667, 0.58, 0
3704, 0.26666666666667, 0.6, 0
3705, 0.26666666666667, 0.62, 0
3706, 0.26666666666667, 0.64, 0
3707, 0.26666666666667, 0.66, 0
3708, 0.26666666666667, 0.68, 0
3709, 0.26666666666667, 0.7, 0
3710, 0.26666666666667, 0.72, 0
3711, 0.26666666666667, 0.74, 0
3712, 0.26666666666667, 0.76, 0
3713, 0.26666666666667, 0.78, 0
3714, 0.26666666666667, 0.8, 0
3715, 0.26666666666667, 0.82, 0
3716, 0.26666666666667, 0.84, 0
3717, 0.26666666666667, 0.86, 0
3718, 0.26666666666667, 0.88, 0
3719, 0.26666666666667, 0.9, 0
3720, 0.26666666666667, 0.92, 0
3721, 0.26666666666667, 0.94, 0
3722, 0.26666666666667, 0.96, 0
3723, 0.26666666666667, 0.98, 0
3724, 0.26666666666667, 1, 0
3725, 0.26666666666667, 1.02, 0
3726, 0.26666666666667, 1.04, 0
3727, 0.26666666666667, 1.06, 0
3728, 0.26666666666667, 1.08, 0
3729, 0.26666666666667, 1.1, 0
3730, 0.26666666666667, 1.12, 0
3731, 0.26666666666667, 1.14, 0
3732, 0.26666666666667, 1.16, 0
3733, 0.26666666666667, 1.18, 0
3734, 0.28333333333333, 0.02, 0
3735, 0.28333333333333, 0.04, 0
3736, 0.28333333333333, 0.06, 0
3737, 0.28333333333333, 0.08, 0
3738, 0.28333333333333, 0.1, 0
3739, 0.28333333333333, 0.12, 0
3740, 0.28333333333333, 0.14, 0
3741, 0.28333333333333, 0.16, 0
3742, 0.28333333333333, 0.18, 0
3743, 0.28333333333333, 0.2, 0
3744, 0.28333333333333, 0.22, 0
3745, 0.28333333333333, 0.24, 0
3746, 0.28333333333333, 0.26, 0
3747, 0.28333333333333, 0.28, 0
3748, 0.28333333333333, 0.3, 0
3749, 0.28333333333333, 0.32, 0
3750, 0.28333333333333, 0.34, 0
3751, 0.28333333333333, 0.36, 0
3752, 0.28333333333333, 0.38, 0
3753, 0.28333333333333, 0.4, 0
3754, 0.28333333333333, 0.42, 0
3755, 0.28333333333333, 0.44, 0
3756, 0.28333333333333, 0.46, 0
3757, 0.28333333333333, 0.48, 0
3758, 0.28333333333333, 0.5, 0
3759, 0.28333333333333, 0.52, 0
3760, 0.28333333333333, 0.54, 0
3761, 0.28333333333333, 0.56, 0
3762, 0.28333333333333, 0.58, 0
3763, 0.28333333333333, 0.6, 0
3764, 0.28333333333333, 0.62, 0
3765, 0.28333333333333, 0.64, 0
3766, 0.28333333333333, 0.66, 0
3767, 0.28333333333333, 0.68, 0
3768, 0.28333333333333, 0.7, 0
3769, 0.28333333333333, 0.72, 0
3770, 0.28333333333333, 0.74, 0
3771, 0.28333333333333, 0.76, 0
3772, 0.28333333333333, 0.78, 0
3773, 0.28333333333333, 0.8, 0
3774, 0.28333333333333, 0.82, 0
3775, 0.28333333333333, 0.84, 0
3776, 0.28333333333333, 0.86, 0
3777, 0.28333333333333, 0.88, 0
3778, 0.28333333333333, 0.9, 0
3779, 0.28333333333333, 0.92, 0
3780, 0.28333333333333, 0.94, 0
3781, 0.28333333333333, 0.96, 0
3782, 0.28333333333333, 0.98, 0
3783, 0.28333333333333, 1, 0
3784, 0.28333333333333, 1.02, 0
3785, 0.28333333333333, 1.04, 0
3786, 0.28333333333333, 1.06, 0
3787, 0.28333333333333, 1.08, 0
3788, 0.28333333333333, 1.1, 0
3789, 0.28333333333333, 1.12, 0
3790, 0.28333333333333, 1.14, 0
3791, 0.28333333333333, 1.16, 0
3792, 0.28333333333333, 1.18, 0
3793, 0.3, 0.02, 0
3794, 0.3, 0.04, 0
3795, 0.3, 0.06, 0
3796, 0.3, 0.08, 0
3797, 0.3, 0.1, 0
3798, 0.3, 0.12, 0
3799, 0.3, 0.14, 0
3800, 0.3, 0.16, 0
3801, 0.3, 0.18, 0
3802, 0.3, 0.2, 0
3803, 0.3, 0.22, 0
3804, 0.3, 0.24, 0
3805, 0.3, 0.26, 0
3806, 0.3, 0.28, 0
3807, 0.3, 0.3, 0
3808, 0.3, 0.32, 0
3809, 0.3, 0.34, 0
3810, 0.3, 0.36, 0
3811, 0.3, 0.38, 0
3812, 0.3, 0.4, 0
3813, 0.3, 0.42, 0
3814, 0.3, 0.44, 0
3815, 0.3, 0.46, 0
3816, 0.3, 0.48, 0
3817, 0.3, 0.5, 0
3818, 0.3, 0.52, 0
3819, 0.3, 0.54, 0
3820, 0.3, 0.56, 0
3821, 0.3, 0.58, 0
3822, 0.3, 0.6, 0
3823, 0.3, 0.62, 0
3824, 0.3, 0.64, 0
3825, 0.3, 0.66, 0
3826, 0.3, 0.68, 0
3827, 0.3, 0.7, 0
3828, 0.3, 0.72, 0
3829, 0.3, 0.74, 0
3830, 0.3, 0.76, 0
3831, 0.3, 0.78, 0
3832, 0.3, 0.8, 0
3833, 0.3, 0.82, 0
3834, 0.3, 0.84, 0
3835, 0.3, 0.86, 0
3836, 0.3, 0.88, 0
3837, 0.3, 0.9, 0
3838, 0.3, 0.92, 0
3839, 0.3, 0.94, 0
3840, 0.3, 0.96, 0
3841, 0.3, 0.98, 0
3842, 0.3, 1, 0
3843, 0.3, 1.02, 0
3844, 0.3, 1.04, 0
3845, 0.3, 1.06, 0
3846, 0.3, 1.08, 0
3847, 0.3, 1.1, 0
3848, 0.3, 1.12, 0
3849, 0.3, 1.14, 0
3850, 0.3, 1.16, 0
3851, 0.3, 1.18, 0
3852, 0.31666666666667, 0.02, 0
3853, 0.31666666666667, 0.04, 0
3854, 0.31666666666667, 0.06, 0
3855, 0.31666666666667, 0.08, 0
3856, 0.31666666666667, 0.1, 0
3857, 0.31666666666667, 0.12, 0
3858, 0.31666666666667, 0.14, 0
3859, 0.31666666666667, 0.16, 0
3860, 0.31666666666667, 0.18, 0
3861, 0.31666666666667, 0.2, 0
3862, 0.31666666666667, 0.22, 0
3863, 0.31666666666667, 0.24, 0
3864, 0.31666666666667, 0.26, 0
3865, 0.31666666666667, 0.28, 0
3866, 0.31666666666667, 0.3, 0
3867, 0.31666666666667, 0.32, 0
3868, 0.31666666666667, 0.34, 0
3869, 0.31666666666667, 0.36, 0
3870, 0.31666666666667, 0.38, 0
3871, 0.31666666666667, 0.4, 0
