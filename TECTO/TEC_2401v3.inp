30663, 1.7166666666667, 1.37, 0
30664, 1.7083333333333, 1.39, 0
30665, 1.7333333333333, 1.37, 0
30666, 1.725, 1.39, 0
30667, 1.75, 1.37, 0
30668, 1.7416666666667, 1.39, 0
30669, 1.7666666666667, 1.37, 0
30670, 1.7583333333333, 1.39, 0
30671, 1.7833333333333, 1.37, 0
30672, 1.775, 1.39, 0
30673, 1.8, 1.37, 0
30674, 1.7916666666667, 1.39, 0
30675, 1.8166666666667, 1.37, 0
30676, 1.8083333333333, 1.39, 0
30677, 1.8333333333333, 1.37, 0
30678, 1.825, 1.39, 0
30679, 1.85, 1.37, 0
30680, 1.8416666666667, 1.39, 0
30681, 1.8666666666667, 1.37, 0
30682, 1.8583333333333, 1.39, 0
30683, 1.8833333333333, 1.37, 0
30684, 1.875, 1.39, 0
30685, 1.9, 1.37, 0
30686, 1.8916666666667, 1.39, 0
30687, 1.9166666666667, 1.37, 0
30688, 1.9083333333333, 1.39, 0
30689, 1.9333333333333, 1.37, 0
30690, 1.925, 1.39, 0
30691, 1.95, 1.37, 0
30692, 1.9416666666667, 1.39, 0
30693, 1.9666666666667, 1.37, 0
30694, 1.9583333333333, 1.39, 0
30695, 1.9833333333333, 1.37, 0
30696, 1.975, 1.39, 0
30697, 2, 1.37, 0
30698, 1.9916666666667, 1.39, 0
30699, 2.0166666666667, 1.37, 0
30700, 2.0083333333333, 1.39, 0
30701, 2.0333333333333, 1.37, 0
30702, 2.025, 1.39, 0
30703, 2.05, 1.37, 0
30704, 2.0416666666667, 1.39, 0
30705, 2.0666666666667, 1.37, 0
30706, 2.0583333333333, 1.39, 0
30707, 2.0833333333333, 1.37, 0
30708, 2.075, 1.39, 0
30709, 2.1, 1.37, 0
30710, 2.0916666666667, 1.39, 0
30711, 2.1166666666667, 1.37, 0
30712, 2.1083333333333, 1.39, 0
30713, 2.1333333333333, 1.37, 0
30714, 2.125, 1.39, 0
30715, 2.15, 1.37, 0
30716, 2.1416666666667, 1.39, 0
30717, 2.1666666666667, 1.37, 0
30718, 2.1583333333333, 1.39, 0
30719, 2.1833333333333, 1.37, 0
30720, 2.175, 1.39, 0
30721, 2.1916666666667, 1.39, 0
30722, 1.2166666666667, 1.41, 0
30723, 1.2083333333333, 1.43, 0
30724, 1.2333333333333, 1.41, 0
30725, 1.225, 1.43, 0
30726, 1.25, 1.41, 0
30727, 1.2416666666667, 1.43, 0
30728, 1.2666666666667, 1.41, 0
30729, 1.2583333333333, 1.43, 0
30730, 1.2833333333333, 1.41, 0
30731, 1.275, 1.43, 0
30732, 1.3, 1.41, 0
30733, 1.2916666666667, 1.43, 0
30734, 1.3166666666667, 1.41, 0
30735, 1.3083333333333, 1.43, 0
30736, 1.3333333333333, 1.41, 0
30737, 1.325, 1.43, 0
30738, 1.35, 1.41, 0
30739, 1.3416666666667, 1.43, 0
30740, 1.3666666666667, 1.41, 0
30741, 1.3583333333333, 1.43, 0
30742, 1.3833333333333, 1.41, 0
30743, 1.375, 1.43, 0
30744, 1.4, 1.41, 0
30745, 1.3916666666667, 1.43, 0
30746, 1.4166666666667, 1.41, 0
30747, 1.4083333333333, 1.43, 0
30748, 1.4333333333333, 1.41, 0
30749, 1.425, 1.43, 0
30750, 1.45, 1.41, 0
30751, 1.4416666666667, 1.43, 0
30752, 1.4666666666667, 1.41, 0
30753, 1.4583333333333, 1.43, 0
30754, 1.4833333333333, 1.41, 0
30755, 1.475, 1.43, 0
30756, 1.5, 1.41, 0
30757, 1.4916666666667, 1.43, 0
30758, 1.5166666666667, 1.41, 0
30759, 1.5083333333333, 1.43, 0
30760, 1.5333333333333, 1.41, 0
30761, 1.525, 1.43, 0
30762, 1.55, 1.41, 0
30763, 1.5416666666667, 1.43, 0
30764, 1.5666666666667, 1.41, 0
30765, 1.5583333333333, 1.43, 0
30766, 1.5833333333333, 1.41, 0
30767, 1.575, 1.43, 0
30768, 1.6, 1.41, 0
30769, 1.5916666666667, 1.43, 0
30770, 1.6166666666667, 1.41, 0
30771, 1.6083333333333, 1.43, 0
30772, 1.6333333333333, 1.41, 0
30773, 1.625, 1.43, 0
30774, 1.65, 1.41, 0
30775, 1.6416666666667, 1.43, 0
30776, 1.6666666666667, 1.41, 0
30777, 1.6583333333333, 1.43, 0
30778, 1.6833333333333, 1.41, 0
30779, 1.675, 1.43, 0
30780, 1.7, 1.41, 0
30781, 1.6916666666667, 1.43, 0
30782, 1.7166666666667, 1.41, 0
30783, 1.7083333333333, 1.43, 0
30784, 1.7333333333333, 1.41, 0
30785, 1.725, 1.43, 0
30786, 1.75, 1.41, 0
30787, 1.7416666666667, 1.43, 0
30788, 1.7666666666667, 1.41, 0
30789, 1.7583333333333, 1.43, 0
30790, 1.7833333333333, 1.41, 0
30791, 1.775, 1.43, 0
30792, 1.8, 1.41, 0
30793, 1.7916666666667, 1.43, 0
30794, 1.8166666666667, 1.41, 0
30795, 1.8083333333333, 1.43, 0
30796, 1.8333333333333, 1.41, 0
30797, 1.825, 1.43, 0
30798, 1.85, 1.41, 0
30799, 1.8416666666667, 1.43, 0
30800, 1.8666666666667, 1.41, 0
30801, 1.8583333333333, 1.43, 0
30802, 1.8833333333333, 1.41, 0
30803, 1.875, 1.43, 0
30804, 1.9, 1.41, 0
30805, 1.8916666666667, 1.43, 0
30806, 1.9166666666667, 1.41, 0
30807, 1.9083333333333, 1.43, 0
30808, 1.9333333333333, 1.41, 0
30809, 1.925, 1.43, 0
30810, 1.95, 1.41, 0
30811, 1.9416666666667, 1.43, 0
30812, 1.9666666666667, 1.41, 0
30813, 1.9583333333333, 1.43, 0
30814, 1.9833333333333, 1.41, 0
30815, 1.975, 1.43, 0
30816, 2, 1.41, 0
30817, 1.9916666666667, 1.43, 0
30818, 2.0166666666667, 1.41, 0
30819, 2.0083333333333, 1.43, 0
30820, 2.0333333333333, 1.41, 0
30821, 2.025, 1.43, 0
30822, 2.05, 1.41, 0
30823, 2.0416666666667, 1.43, 0
30824, 2.0666666666667, 1.41, 0
30825, 2.0583333333333, 1.43, 0
30826, 2.0833333333333, 1.41, 0
30827, 2.075, 1.43, 0
30828, 2.1, 1.41, 0
30829, 2.0916666666667, 1.43, 0
30830, 2.1166666666667, 1.41, 0
30831, 2.1083333333333, 1.43, 0
30832, 2.1333333333333, 1.41, 0
30833, 2.125, 1.43, 0
30834, 2.15, 1.41, 0
30835, 2.1416666666667, 1.43, 0
30836, 2.1666666666667, 1.41, 0
30837, 2.1583333333333, 1.43, 0
30838, 2.1833333333333, 1.41, 0
30839, 2.175, 1.43, 0
30840, 2.1916666666667, 1.43, 0
30841, 1.2166666666667, 1.45, 0
30842, 1.2083333333333, 1.47, 0
30843, 1.2333333333333, 1.45, 0
30844, 1.225, 1.47, 0
30845, 1.25, 1.45, 0
30846, 1.2416666666667, 1.47, 0
30847, 1.2666666666667, 1.45, 0
30848, 1.2583333333333, 1.47, 0
30849, 1.2833333333333, 1.45, 0
30850, 1.275, 1.47, 0
30851, 1.3, 1.45, 0
30852, 1.2916666666667, 1.47, 0
30853, 1.3166666666667, 1.45, 0
30854, 1.3083333333333, 1.47, 0
30855, 1.3333333333333, 1.45, 0
30856, 1.325, 1.47, 0
30857, 1.35, 1.45, 0
30858, 1.3416666666667, 1.47, 0
30859, 1.3666666666667, 1.45, 0
30860, 1.3583333333333, 1.47, 0
30861, 1.3833333333333, 1.45, 0
30862, 1.375, 1.47, 0
30863, 1.4, 1.45, 0
30864, 1.3916666666667, 1.47, 0
30865, 1.4166666666667, 1.45, 0
30866, 1.4083333333333, 1.47, 0
30867, 1.4333333333333, 1.45, 0
30868, 1.425, 1.47, 0
30869, 1.45, 1.45, 0
30870, 1.4416666666667, 1.47, 0
30871, 1.4666666666667, 1.45, 0
30872, 1.4583333333333, 1.47, 0
30873, 1.4833333333333, 1.45, 0
30874, 1.475, 1.47, 0
30875, 1.5, 1.45, 0
30876, 1.4916666666667, 1.47, 0
30877, 1.5166666666667, 1.45, 0
30878, 1.5083333333333, 1.47, 0
30879, 1.5333333333333, 1.45, 0
30880, 1.525, 1.47, 0
30881, 1.55, 1.45, 0
30882, 1.5416666666667, 1.47, 0
30883, 1.5666666666667, 1.45, 0
30884, 1.5583333333333, 1.47, 0
30885, 1.5833333333333, 1.45, 0
30886, 1.575, 1.47, 0
30887, 1.6, 1.45, 0
30888, 1.5916666666667, 1.47, 0
30889, 1.6166666666667, 1.45, 0
30890, 1.6083333333333, 1.47, 0
30891, 1.6333333333333, 1.45, 0
30892, 1.625, 1.47, 0
30893, 1.65, 1.45, 0
30894, 1.6416666666667, 1.47, 0
30895, 1.6666666666667, 1.45, 0
30896, 1.6583333333333, 1.47, 0
30897, 1.6833333333333, 1.45, 0
30898, 1.675, 1.47, 0
30899, 1.7, 1.45, 0
30900, 1.6916666666667, 1.47, 0
30901, 1.7166666666667, 1.45, 0
30902, 1.7083333333333, 1.47, 0
30903, 1.7333333333333, 1.45, 0
30904, 1.725, 1.47, 0
30905, 1.75, 1.45, 0
30906, 1.7416666666667, 1.47, 0
30907, 1.7666666666667, 1.45, 0
30908, 1.7583333333333, 1.47, 0
30909, 1.7833333333333, 1.45, 0
30910, 1.775, 1.47, 0
30911, 1.8, 1.45, 0
30912, 1.7916666666667, 1.47, 0
30913, 1.8166666666667, 1.45, 0
30914, 1.8083333333333, 1.47, 0
30915, 1.8333333333333, 1.45, 0
30916, 1.825, 1.47, 0
30917, 1.85, 1.45, 0
30918, 1.8416666666667, 1.47, 0
30919, 1.8666666666667, 1.45, 0
30920, 1.8583333333333, 1.47, 0
30921, 1.8833333333333, 1.45, 0
30922, 1.875, 1.47, 0
30923, 1.9, 1.45, 0
30924, 1.8916666666667, 1.47, 0
30925, 1.9166666666667, 1.45, 0
30926, 1.9083333333333, 1.47, 0
30927, 1.9333333333333, 1.45, 0
30928, 1.925, 1.47, 0
30929, 1.95, 1.45, 0
30930, 1.9416666666667, 1.47, 0
30931, 1.9666666666667, 1.45, 0
30932, 1.9583333333333, 1.47, 0
30933, 1.9833333333333, 1.45, 0
30934, 1.975, 1.47, 0
30935, 2, 1.45, 0
30936, 1.9916666666667, 1.47, 0
30937, 2.0166666666667, 1.45, 0
30938, 2.0083333333333, 1.47, 0
30939, 2.0333333333333, 1.45, 0
30940, 2.025, 1.47, 0
30941, 2.05, 1.45, 0
30942, 2.0416666666667, 1.47, 0
30943, 2.0666666666667, 1.45, 0
30944, 2.0583333333333, 1.47, 0
30945, 2.0833333333333, 1.45, 0
30946, 2.075, 1.47, 0
30947, 2.1, 1.45, 0
30948, 2.0916666666667, 1.47, 0
30949, 2.1166666666667, 1.45, 0
30950, 2.1083333333333, 1.47, 0
30951, 2.1333333333333, 1.45, 0
30952, 2.125, 1.47, 0
30953, 2.15, 1.45, 0
30954, 2.1416666666667, 1.47, 0
30955, 2.1666666666667, 1.45, 0
30956, 2.1583333333333, 1.47, 0
30957, 2.1833333333333, 1.45, 0
30958, 2.175, 1.47, 0
30959, 2.1916666666667, 1.47, 0
30960, 1.2166666666667, 1.49, 0
30961, 1.2083333333333, 1.51, 0
30962, 1.2333333333333, 1.49, 0
30963, 1.225, 1.51, 0
30964, 1.25, 1.49, 0
30965, 1.2416666666667, 1.51, 0
30966, 1.2666666666667, 1.49, 0
30967, 1.2583333333333, 1.51, 0
30968, 1.2833333333333, 1.49, 0
30969, 1.275, 1.51, 0
30970, 1.3, 1.49, 0
30971, 1.2916666666667, 1.51, 0
30972, 1.3166666666667, 1.49, 0
30973, 1.3083333333333, 1.51, 0
30974, 1.3333333333333, 1.49, 0
30975, 1.325, 1.51, 0
30976, 1.35, 1.49, 0
30977, 1.3416666666667, 1.51, 0
30978, 1.3666666666667, 1.49, 0
30979, 1.3583333333333, 1.51, 0
30980, 1.3833333333333, 1.49, 0
30981, 1.375, 1.51, 0
30982, 1.4, 1.49, 0
30983, 1.3916666666667, 1.51, 0
30984, 1.4166666666667, 1.49, 0
30985, 1.4083333333333, 1.51, 0
30986, 1.4333333333333, 1.49, 0
30987, 1.425, 1.51, 0
30988, 1.45, 1.49, 0
30989, 1.4416666666667, 1.51, 0
30990, 1.4666666666667, 1.49, 0
30991, 1.4583333333333, 1.51, 0
30992, 1.4833333333333, 1.49, 0
30993, 1.475, 1.51, 0
30994, 1.5, 1.49, 0
30995, 1.4916666666667, 1.51, 0
30996, 1.5166666666667, 1.49, 0
30997, 1.5083333333333, 1.51, 0
30998, 1.5333333333333, 1.49, 0
30999, 1.525, 1.51, 0
31000, 1.55, 1.49, 0
31001, 1.5416666666667, 1.51, 0
31002, 1.5666666666667, 1.49, 0
31003, 1.5583333333333, 1.51, 0
31004, 1.5833333333333, 1.49, 0
31005, 1.575, 1.51, 0
31006, 1.6, 1.49, 0
31007, 1.5916666666667, 1.51, 0
31008, 1.6166666666667, 1.49, 0
31009, 1.6083333333333, 1.51, 0
31010, 1.6333333333333, 1.49, 0
31011, 1.625, 1.51, 0
31012, 1.65, 1.49, 0
31013, 1.6416666666667, 1.51, 0
31014, 1.6666666666667, 1.49, 0
31015, 1.6583333333333, 1.51, 0
31016, 1.6833333333333, 1.49, 0
31017, 1.675, 1.51, 0
31018, 1.7, 1.49, 0
31019, 1.6916666666667, 1.51, 0
31020, 1.7166666666667, 1.49, 0
31021, 1.7083333333333, 1.51, 0
31022, 1.7333333333333, 1.49, 0
31023, 1.725, 1.51, 0
31024, 1.75, 1.49, 0
31025, 1.7416666666667, 1.51, 0
31026, 1.7666666666667, 1.49, 0
31027, 1.7583333333333, 1.51, 0
31028, 1.7833333333333, 1.49, 0
31029, 1.775, 1.51, 0
31030, 1.8, 1.49, 0
31031, 1.7916666666667, 1.51, 0
31032, 1.8166666666667, 1.49, 0
31033, 1.8083333333333, 1.51, 0
31034, 1.8333333333333, 1.49, 0
31035, 1.825, 1.51, 0
31036, 1.85, 1.49, 0
31037, 1.8416666666667, 1.51, 0
31038, 1.8666666666667, 1.49, 0
31039, 1.8583333333333, 1.51, 0
31040, 1.8833333333333, 1.49, 0
31041, 1.875, 1.51, 0
31042, 1.9, 1.49, 0
31043, 1.8916666666667, 1.51, 0
31044, 1.9166666666667, 1.49, 0
31045, 1.9083333333333, 1.51, 0
31046, 1.9333333333333, 1.49, 0
31047, 1.925, 1.51, 0
31048, 1.95, 1.49, 0
31049, 1.9416666666667, 1.51, 0
31050, 1.9666666666667, 1.49, 0
31051, 1.9583333333333, 1.51, 0
31052, 1.9833333333333, 1.49, 0
31053, 1.975, 1.51, 0
31054, 2, 1.49, 0
31055, 1.9916666666667, 1.51, 0
31056, 2.0166666666667, 1.49, 0
31057, 2.0083333333333, 1.51, 0
31058, 2.0333333333333, 1.49, 0
31059, 2.025, 1.51, 0
31060, 2.05, 1.49, 0
31061, 2.0416666666667, 1.51, 0
31062, 2.0666666666667, 1.49, 0
31063, 2.0583333333333, 1.51, 0
31064, 2.0833333333333, 1.49, 0
31065, 2.075, 1.51, 0
31066, 2.1, 1.49, 0
31067, 2.0916666666667, 1.51, 0
31068, 2.1166666666667, 1.49, 0
31069, 2.1083333333333, 1.51, 0
31070, 2.1333333333333, 1.49, 0
31071, 2.125, 1.51, 0
31072, 2.15, 1.49, 0
31073, 2.1416666666667, 1.51, 0
31074, 2.1666666666667, 1.49, 0
31075, 2.1583333333333, 1.51, 0
31076, 2.1833333333333, 1.49, 0
31077, 2.175, 1.51, 0
31078, 2.1916666666667, 1.51, 0
31079, 1.2166666666667, 1.53, 0
31080, 1.2333333333333, 1.53, 0
31081, 1.25, 1.53, 0
31082, 1.2666666666667, 1.53, 0
31083, 1.2833333333333, 1.53, 0
31084, 1.3, 1.53, 0
31085, 1.3166666666667, 1.53, 0
31086, 1.3333333333333, 1.53, 0
31087, 1.35, 1.53, 0
31088, 1.3666666666667, 1.53, 0
31089, 1.3833333333333, 1.53, 0
31090, 1.4, 1.53, 0
31091, 1.4166666666667, 1.53, 0
31092, 1.4333333333333, 1.53, 0
31093, 1.45, 1.53, 0
31094, 1.4666666666667, 1.53, 0
31095, 1.4833333333333, 1.53, 0
31096, 1.5, 1.53, 0
31097, 1.5166666666667, 1.53, 0
31098, 1.5333333333333, 1.53, 0
31099, 1.55, 1.53, 0
31100, 1.5666666666667, 1.53, 0
31101, 1.5833333333333, 1.53, 0
31102, 1.6, 1.53, 0
31103, 1.6166666666667, 1.53, 0
31104, 1.6333333333333, 1.53, 0
31105, 1.65, 1.53, 0
31106, 1.6666666666667, 1.53, 0
31107, 1.6833333333333, 1.53, 0
31108, 1.7, 1.53, 0
31109, 1.7166666666667, 1.53, 0
31110, 1.7333333333333, 1.53, 0
31111, 1.75, 1.53, 0
31112, 1.7666666666667, 1.53, 0
31113, 1.7833333333333, 1.53, 0
31114, 1.8, 1.53, 0
31115, 1.8166666666667, 1.53, 0
31116, 1.8333333333333, 1.53, 0
31117, 1.85, 1.53, 0
31118, 1.8666666666667, 1.53, 0
31119, 1.8833333333333, 1.53, 0
31120, 1.9, 1.53, 0
31121, 1.9166666666667, 1.53, 0
31122, 1.9333333333333, 1.53, 0
31123, 1.95, 1.53, 0
31124, 1.9666666666667, 1.53, 0
31125, 1.9833333333333, 1.53, 0
31126, 2, 1.53, 0
31127, 2.0166666666667, 1.53, 0
31128, 2.0333333333333, 1.53, 0
31129, 2.05, 1.53, 0
31130, 2.0666666666667, 1.53, 0
31131, 2.0833333333333, 1.53, 0
31132, 2.1, 1.53, 0
31133, 2.1166666666667, 1.53, 0
31134, 2.1333333333333, 1.53, 0
31135, 2.15, 1.53, 0
31136, 2.1666666666667, 1.53, 0
31137, 2.1833333333333, 1.53, 0
31138, 1.2166666666667, 1.225, 0
31139, 1.2333333333333, 1.225, 0
31140, 1.25, 1.225, 0
31141, 1.2666666666667, 1.225, 0
31142, 1.2833333333333, 1.225, 0
31143, 1.3, 1.225, 0
31144, 1.3166666666667, 1.225, 0
31145, 1.3333333333333, 1.225, 0
31146, 1.35, 1.225, 0
31147, 1.3666666666667, 1.225, 0
31148, 1.3833333333333, 1.225, 0
31149, 1.4, 1.225, 0
31150, 1.4166666666667, 1.225, 0
31151, 1.4333333333333, 1.225, 0
31152, 1.45, 1.225, 0
31153, 1.4666666666667, 1.225, 0
31154, 1.4833333333333, 1.225, 0
31155, 1.5, 1.225, 0
31156, 1.5166666666667, 1.225, 0
31157, 1.5333333333333, 1.225, 0
31158, 1.55, 1.225, 0
31159, 1.5666666666667, 1.225, 0
31160, 1.5833333333333, 1.225, 0
31161, 1.6, 1.225, 0
31162, 1.6166666666667, 1.225, 0
31163, 1.6333333333333, 1.225, 0
31164, 1.65, 1.225, 0
31165, 1.6666666666667, 1.225, 0
31166, 1.6833333333333, 1.225, 0
31167, 1.7, 1.225, 0
31168, 1.7166666666667, 1.225, 0
31169, 1.7333333333333, 1.225, 0
31170, 1.75, 1.225, 0
31171, 1.7666666666667, 1.225, 0
31172, 1.7833333333333, 1.225, 0
31173, 1.8, 1.225, 0
31174, 1.8166666666667, 1.225, 0
31175, 1.8333333333333, 1.225, 0
31176, 1.85, 1.225, 0
31177, 1.8666666666667, 1.225, 0
31178, 1.8833333333333, 1.225, 0
31179, 1.9, 1.225, 0
31180, 1.9166666666667, 1.225, 0
31181, 1.9333333333333, 1.225, 0
31182, 1.95, 1.225, 0
31183, 1.9666666666667, 1.225, 0
31184, 1.9833333333333, 1.225, 0
31185, 2, 1.225, 0
31186, 2.0166666666667, 1.225, 0
31187, 2.0333333333333, 1.225, 0
31188, 2.05, 1.225, 0
31189, 2.0666666666667, 1.225, 0
31190, 2.0833333333333, 1.225, 0
31191, 2.1, 1.225, 0
31192, 2.1166666666667, 1.225, 0
31193, 2.1333333333333, 1.225, 0
31194, 2.15, 1.225, 0
31195, 2.1666666666667, 1.225, 0
31196, 2.1833333333333, 1.225, 0
31197, 1.2083333333333, 1.225, 0
31198, 1.2166666666667, 1.2375, 0
31199, 1.225, 1.225, 0
31200, 1.2333333333333, 1.2375, 0
31201, 1.2416666666667, 1.225, 0
31202, 1.25, 1.2375, 0
31203, 1.2583333333333, 1.225, 0
31204, 1.2666666666667, 1.2375, 0
31205, 1.275, 1.225, 0
31206, 1.2833333333333, 1.2375, 0
31207, 1.2916666666667, 1.225, 0
31208, 1.3, 1.2375, 0
31209, 1.3083333333333, 1.225, 0
31210, 1.3166666666667, 1.2375, 0
31211, 1.325, 1.225, 0
31212, 1.3333333333333, 1.2375, 0
31213, 1.3416666666667, 1.225, 0
31214, 1.35, 1.2375, 0
31215, 1.3583333333333, 1.225, 0
31216, 1.3666666666667, 1.2375, 0
31217, 1.375, 1.225, 0
31218, 1.3833333333333, 1.2375, 0
31219, 1.3916666666667, 1.225, 0
31220, 1.4, 1.2375, 0
31221, 1.4083333333333, 1.225, 0
31222, 1.4166666666667, 1.2375, 0
31223, 1.425, 1.225, 0
31224, 1.4333333333333, 1.2375, 0
31225, 1.4416666666667, 1.225, 0
31226, 1.45, 1.2375, 0
31227, 1.4583333333333, 1.225, 0
31228, 1.4666666666667, 1.2375, 0
31229, 1.475, 1.225, 0
31230, 1.4833333333333, 1.2375, 0
31231, 1.4916666666667, 1.225, 0
31232, 1.5, 1.2375, 0
31233, 1.5083333333333, 1.225, 0
31234, 1.5166666666667, 1.2375, 0
31235, 1.525, 1.225, 0
31236, 1.5333333333333, 1.2375, 0
31237, 1.5416666666667, 1.225, 0
31238, 1.55, 1.2375, 0
31239, 1.5583333333333, 1.225, 0
31240, 1.5666666666667, 1.2375, 0
31241, 1.575, 1.225, 0
31242, 1.5833333333333, 1.2375, 0
31243, 1.5916666666667, 1.225, 0
31244, 1.6, 1.2375, 0
31245, 1.6083333333333, 1.225, 0
31246, 1.6166666666667, 1.2375, 0
31247, 1.625, 1.225, 0
31248, 1.6333333333333, 1.2375, 0
31249, 1.6416666666667, 1.225, 0
31250, 1.65, 1.2375, 0
31251, 1.6583333333333, 1.225, 0
31252, 1.6666666666667, 1.2375, 0
31253, 1.675, 1.225, 0
31254, 1.6833333333333, 1.2375, 0
31255, 1.6916666666667, 1.225, 0
31256, 1.7, 1.2375, 0
31257, 1.7083333333333, 1.225, 0
31258, 1.7166666666667, 1.2375, 0
31259, 1.725, 1.225, 0
31260, 1.7333333333333, 1.2375, 0
31261, 1.7416666666667, 1.225, 0
31262, 1.75, 1.2375, 0
31263, 1.7583333333333, 1.225, 0
31264, 1.7666666666667, 1.2375, 0
31265, 1.775, 1.225, 0
31266, 1.7833333333333, 1.2375, 0
31267, 1.7916666666667, 1.225, 0
31268, 1.8, 1.2375, 0
31269, 1.8083333333333, 1.225, 0
31270, 1.8166666666667, 1.2375, 0
31271, 1.825, 1.225, 0
31272, 1.8333333333333, 1.2375, 0
31273, 1.8416666666667, 1.225, 0
31274, 1.85, 1.2375, 0
31275, 1.8583333333333, 1.225, 0
31276, 1.8666666666667, 1.2375, 0
31277, 1.875, 1.225, 0
31278, 1.8833333333333, 1.2375, 0
31279, 1.8916666666667, 1.225, 0
31280, 1.9, 1.2375, 0
31281, 1.9083333333333, 1.225, 0
31282, 1.9166666666667, 1.2375, 0
31283, 1.925, 1.225, 0
31284, 1.9333333333333, 1.2375, 0
31285, 1.9416666666667, 1.225, 0
31286, 1.95, 1.2375, 0
31287, 1.9583333333333, 1.225, 0
31288, 1.9666666666667, 1.2375, 0
31289, 1.975, 1.225, 0
31290, 1.9833333333333, 1.2375, 0
31291, 1.9916666666667, 1.225, 0
31292, 2, 1.2375, 0
31293, 2.0083333333333, 1.225, 0
31294, 2.0166666666667, 1.2375, 0
31295, 2.025, 1.225, 0
31296, 2.0333333333333, 1.2375, 0
31297, 2.0416666666667, 1.225, 0
31298, 2.05, 1.2375, 0
31299, 2.0583333333333, 1.225, 0
31300, 2.0666666666667, 1.2375, 0
31301, 2.075, 1.225, 0
31302, 2.0833333333333, 1.2375, 0
31303, 2.0916666666667, 1.225, 0
31304, 2.1, 1.2375, 0
31305, 2.1083333333333, 1.225, 0
31306, 2.1166666666667, 1.2375, 0
31307, 2.125, 1.225, 0
31308, 2.1333333333333, 1.2375, 0
31309, 2.1416666666667, 1.225, 0
31310, 2.15, 1.2375, 0
31311, 2.1583333333333, 1.225, 0
31312, 2.1666666666667, 1.2375, 0
31313, 2.175, 1.225, 0
31314, 2.1833333333333, 1.2375, 0
31315, 2.1916666666667, 1.225, 0
31316, 1.2166666666667, 1.2125, 0
31317, 1.2333333333333, 1.2125, 0
31318, 1.25, 1.2125, 0
31319, 1.2666666666667, 1.2125, 0
31320, 1.2833333333333, 1.2125, 0
31321, 1.3, 1.2125, 0
31322, 1.3166666666667, 1.2125, 0
31323, 1.3333333333333, 1.2125, 0
31324, 1.35, 1.2125, 0
31325, 1.3666666666667, 1.2125, 0
31326, 1.3833333333333, 1.2125, 0
31327, 1.4, 1.2125, 0
31328, 1.4166666666667, 1.2125, 0
31329, 1.4333333333333, 1.2125, 0
31330, 1.45, 1.2125, 0
31331, 1.4666666666667, 1.2125, 0
31332, 1.4833333333333, 1.2125, 0
31333, 1.5, 1.2125, 0
31334, 1.5166666666667, 1.2125, 0
31335, 1.5333333333333, 1.2125, 0
31336, 1.55, 1.2125, 0
31337, 1.5666666666667, 1.2125, 0
31338, 1.5833333333333, 1.2125, 0
31339, 1.6, 1.2125, 0
31340, 1.6166666666667, 1.2125, 0
31341, 1.6333333333333, 1.2125, 0
31342, 1.65, 1.2125, 0
31343, 1.6666666666667, 1.2125, 0
31344, 1.6833333333333, 1.2125, 0
31345, 1.7, 1.2125, 0
31346, 1.7166666666667, 1.2125, 0
31347, 1.7333333333333, 1.2125, 0
31348, 1.75, 1.2125, 0
31349, 1.7666666666667, 1.2125, 0
31350, 1.7833333333333, 1.2125, 0
31351, 1.8, 1.2125, 0
31352, 1.8166666666667, 1.2125, 0
31353, 1.8333333333333, 1.2125, 0
31354, 1.85, 1.2125, 0
31355, 1.8666666666667, 1.2125, 0
31356, 1.8833333333333, 1.2125, 0
31357, 1.9, 1.2125, 0
31358, 1.9166666666667, 1.2125, 0
31359, 1.9333333333333, 1.2125, 0
31360, 1.95, 1.2125, 0
31361, 1.9666666666667, 1.2125, 0
31362, 1.9833333333333, 1.2125, 0
31363, 2, 1.2125, 0
31364, 2.0166666666667, 1.2125, 0
31365, 2.0333333333333, 1.2125, 0
31366, 2.05, 1.2125, 0
31367, 2.0666666666667, 1.2125, 0
31368, 2.0833333333333, 1.2125, 0
31369, 2.1, 1.2125, 0
31370, 2.1166666666667, 1.2125, 0
31371, 2.1333333333333, 1.2125, 0
31372, 2.15, 1.2125, 0
31373, 2.1666666666667, 1.2125, 0
31374, 2.1833333333333, 1.2125, 0
31375, 0.016666666666667, -0.025, 0
31376, 0.033333333333333, -0.025, 0
31377, 0.05, -0.025, 0
31378, 0.066666666666667, -0.025, 0
31379, 0.083333333333333, -0.025, 0
31380, 0.1, -0.025, 0
31381, 0.11666666666667, -0.025, 0
31382, 0.13333333333333, -0.025, 0
31383, 0.15, -0.025, 0
31384, 0.16666666666667, -0.025, 0
31385, 0.18333333333333, -0.025, 0
31386, 0.2, -0.025, 0
31387, 0.21666666666667, -0.025, 0
31388, 0.23333333333333, -0.025, 0
31389, 0.25, -0.025, 0
31390, 0.26666666666667, -0.025, 0
31391, 0.28333333333333, -0.025, 0
31392, 0.3, -0.025, 0
31393, 0.31666666666667, -0.025, 0
31394, 0.33333333333333, -0.025, 0
31395, 0.35, -0.025, 0
31396, 0.36666666666667, -0.025, 0
31397, 0.38333333333333, -0.025, 0
31398, 0.4, -0.025, 0
31399, 0.41666666666667, -0.025, 0
31400, 0.43333333333333, -0.025, 0
31401, 0.45, -0.025, 0
31402, 0.46666666666667, -0.025, 0
31403, 0.48333333333333, -0.025, 0
31404, 0.5, -0.025, 0
31405, 0.51666666666667, -0.025, 0
31406, 0.53333333333333, -0.025, 0
31407, 0.55, -0.025, 0
31408, 0.56666666666667, -0.025, 0
31409, 0.58333333333333, -0.025, 0
31410, 0.6, -0.025, 0
31411, 0.61666666666667, -0.025, 0
31412, 0.63333333333333, -0.025, 0
31413, 0.65, -0.025, 0
31414, 0.66666666666667, -0.025, 0
31415, 0.68333333333333, -0.025, 0
31416, 0.7, -0.025, 0
31417, 0.71666666666667, -0.025, 0
31418, 0.73333333333333, -0.025, 0
31419, 0.75, -0.025, 0
31420, 0.76666666666667, -0.025, 0
31421, 0.78333333333333, -0.025, 0
31422, 0.8, -0.025, 0
31423, 0.81666666666667, -0.025, 0
31424, 0.83333333333333, -0.025, 0
31425, 0.85, -0.025, 0
31426, 0.86666666666667, -0.025, 0
31427, 0.88333333333333, -0.025, 0
31428, 0.9, -0.025, 0
31429, 0.91666666666667, -0.025, 0
31430, 0.93333333333333, -0.025, 0
31431, 0.95, -0.025, 0
31432, 0.96666666666667, -0.025, 0
31433, 0.98333333333333, -0.025, 0
31434, 0.0083333333333333, -0.025, 0
31435, 0.016666666666667, -0.0125, 0
31436, 0.025, -0.025, 0
31437, 0.033333333333333, -0.0125, 0
31438, 0.041666666666667, -0.025, 0
31439, 0.05, -0.0125, 0
31440, 0.058333333333333, -0.025, 0
31441, 0.066666666666667, -0.0125, 0
31442, 0.075, -0.025, 0
31443, 0.083333333333333, -0.0125, 0
31444, 0.091666666666667, -0.025, 0
31445, 0.1, -0.0125, 0
31446, 0.10833333333333, -0.025, 0
31447, 0.11666666666667, -0.0125, 0
31448, 0.125, -0.025, 0
31449, 0.13333333333333, -0.0125, 0
31450, 0.14166666666667, -0.025, 0
31451, 0.15, -0.0125, 0
31452, 0.15833333333333, -0.025, 0
31453, 0.16666666666667, -0.0125, 0
31454, 0.175, -0.025, 0
31455, 0.18333333333333, -0.0125, 0
31456, 0.19166666666667, -0.025, 0
31457, 0.2, -0.0125, 0
31458, 0.20833333333333, -0.025, 0
31459, 0.21666666666667, -0.0125, 0
31460, 0.225, -0.025, 0
31461, 0.23333333333333, -0.0125, 0
31462, 0.24166666666667, -0.025, 0
31463, 0.25, -0.0125, 0
31464, 0.25833333333333, -0.025, 0
31465, 0.26666666666667, -0.0125, 0
31466, 0.275, -0.025, 0
31467, 0.28333333333333, -0.0125, 0
31468, 0.29166666666667, -0.025, 0
31469, 0.3, -0.0125, 0
31470, 0.30833333333333, -0.025, 0
31471, 0.31666666666667, -0.0125, 0
31472, 0.325, -0.025, 0
31473, 0.33333333333333, -0.0125, 0
31474, 0.34166666666667, -0.025, 0
31475, 0.35, -0.0125, 0
31476, 0.35833333333333, -0.025, 0
31477, 0.36666666666667, -0.0125, 0
31478, 0.375, -0.025, 0
31479, 0.38333333333333, -0.0125, 0
31480, 0.39166666666667, -0.025, 0
31481, 0.4, -0.0125, 0
31482, 0.40833333333333, -0.025, 0
31483, 0.41666666666667, -0.0125, 0
31484, 0.425, -0.025, 0
31485, 0.43333333333333, -0.0125, 0
31486, 0.44166666666667, -0.025, 0
31487, 0.45, -0.0125, 0
31488, 0.45833333333333, -0.025, 0
31489, 0.46666666666667, -0.0125, 0
31490, 0.475, -0.025, 0
31491, 0.48333333333333, -0.0125, 0
31492, 0.49166666666667, -0.025, 0
31493, 0.5, -0.0125, 0
31494, 0.50833333333333, -0.025, 0
31495, 0.51666666666667, -0.0125, 0
31496, 0.525, -0.025, 0
31497, 0.53333333333333, -0.0125, 0
31498, 0.54166666666667, -0.025, 0
31499, 0.55, -0.0125, 0
31500, 0.55833333333333, -0.025, 0
31501, 0.56666666666667, -0.0125, 0
31502, 0.575, -0.025, 0
31503, 0.58333333333333, -0.0125, 0
31504, 0.59166666666667, -0.025, 0
31505, 0.6, -0.0125, 0
31506, 0.60833333333333, -0.025, 0
31507, 0.61666666666667, -0.0125, 0
31508, 0.625, -0.025, 0
31509, 0.63333333333333, -0.0125, 0
31510, 0.64166666666667, -0.025, 0
31511, 0.65, -0.0125, 0
31512, 0.65833333333333, -0.025, 0
31513, 0.66666666666667, -0.0125, 0
31514, 0.675, -0.025, 0
31515, 0.68333333333333, -0.0125, 0
31516, 0.69166666666667, -0.025, 0
31517, 0.7, -0.0125, 0
31518, 0.70833333333333, -0.025, 0
31519, 0.71666666666667, -0.0125, 0
31520, 0.725, -0.025, 0
31521, 0.73333333333333, -0.0125, 0
31522, 0.74166666666667, -0.025, 0
31523, 0.75, -0.0125, 0
31524, 0.75833333333333, -0.025, 0
31525, 0.76666666666667, -0.0125, 0
31526, 0.775, -0.025, 0
31527, 0.78333333333333, -0.0125, 0
31528, 0.79166666666667, -0.025, 0
31529, 0.8, -0.0125, 0
31530, 0.80833333333333, -0.025, 0
31531, 0.81666666666667, -0.0125, 0
31532, 0.825, -0.025, 0
31533, 0.83333333333333, -0.0125, 0
31534, 0.84166666666667, -0.025, 0
31535, 0.85, -0.0125, 0
31536, 0.85833333333333, -0.025, 0
31537, 0.86666666666667, -0.0125, 0
31538, 0.875, -0.025, 0
31539, 0.88333333333333, -0.0125, 0
31540, 0.89166666666667, -0.025, 0
31541, 0.9, -0.0125, 0
31542, 0.90833333333333, -0.025, 0
31543, 0.91666666666667, -0.0125, 0
31544, 0.925, -0.025, 0
31545, 0.93333333333333, -0.0125, 0
31546, 0.94166666666667, -0.025, 0
31547, 0.95, -0.0125, 0
31548, 0.95833333333333, -0.025, 0
31549, 0.96666666666667, -0.0125, 0
31550, 0.975, -0.025, 0
31551, 0.98333333333333, -0.0125, 0
31552, 0.99166666666667, -0.025, 0
31553, 0.016666666666667, -0.0375, 0
31554, 0.033333333333333, -0.0375, 0
31555, 0.05, -0.0375, 0
31556, 0.066666666666667, -0.0375, 0
31557, 0.083333333333333, -0.0375, 0
31558, 0.1, -0.0375, 0
31559, 0.11666666666667, -0.0375, 0
31560, 0.13333333333333, -0.0375, 0
31561, 0.15, -0.0375, 0
31562, 0.16666666666667, -0.0375, 0
31563, 0.18333333333333, -0.0375, 0
31564, 0.2, -0.0375, 0
31565, 0.21666666666667, -0.0375, 0
31566, 0.23333333333333, -0.0375, 0
31567, 0.25, -0.0375, 0
31568, 0.26666666666667, -0.0375, 0
31569, 0.28333333333333, -0.0375, 0
31570, 0.3, -0.0375, 0
31571, 0.31666666666667, -0.0375, 0
31572, 0.33333333333333, -0.0375, 0
31573, 0.35, -0.0375, 0
31574, 0.36666666666667, -0.0375, 0
31575, 0.38333333333333, -0.0375, 0
31576, 0.4, -0.0375, 0
31577, 0.41666666666667, -0.0375, 0
31578, 0.43333333333333, -0.0375, 0
31579, 0.45, -0.0375, 0
31580, 0.46666666666667, -0.0375, 0
31581, 0.48333333333333, -0.0375, 0
31582, 0.5, -0.0375, 0
31583, 0.51666666666667, -0.0375, 0
31584, 0.53333333333333, -0.0375, 0
31585, 0.55, -0.0375, 0
31586, 0.56666666666667, -0.0375, 0
31587, 0.58333333333333, -0.0375, 0
31588, 0.6, -0.0375, 0
31589, 0.61666666666667, -0.0375, 0
31590, 0.63333333333333, -0.0375, 0
31591, 0.65, -0.0375, 0
31592, 0.66666666666667, -0.0375, 0
31593, 0.68333333333333, -0.0375, 0
31594, 0.7, -0.0375, 0
31595, 0.71666666666667, -0.0375, 0
31596, 0.73333333333333, -0.0375, 0
31597, 0.75, -0.0375, 0
31598, 0.76666666666667, -0.0375, 0
31599, 0.78333333333333, -0.0375, 0
31600, 0.8, -0.0375, 0
31601, 0.81666666666667, -0.0375, 0
31602, 0.83333333333333, -0.0375, 0
31603, 0.85, -0.0375, 0
31604, 0.86666666666667, -0.0375, 0
31605, 0.88333333333333, -0.0375, 0
31606, 0.9, -0.0375, 0
31607, 0.91666666666667, -0.0375, 0
31608, 0.93333333333333, -0.0375, 0
31609, 0.95, -0.0375, 0
31610, 0.96666666666667, -0.0375, 0
31611, 0.98333333333333, -0.0375, 0
31612, 1.2166666666667, -0.025, 0
31613, 1.2333333333333, -0.025, 0
31614, 1.25, -0.025, 0
31615, 1.2666666666667, -0.025, 0
31616, 1.2833333333333, -0.025, 0
31617, 1.3, -0.025, 0
31618, 1.3166666666667, -0.025, 0
31619, 1.3333333333333, -0.025, 0
31620, 1.35, -0.025, 0
31621, 1.3666666666667, -0.025, 0
31622, 1.3833333333333, -0.025, 0
31623, 1.4, -0.025, 0
31624, 1.4166666666667, -0.025, 0
31625, 1.4333333333333, -0.025, 0
31626, 1.45, -0.025, 0
31627, 1.4666666666667, -0.025, 0
31628, 1.4833333333333, -0.025, 0
31629, 1.5, -0.025, 0
31630, 1.5166666666667, -0.025, 0
31631, 1.5333333333333, -0.025, 0
31632, 1.55, -0.025, 0
31633, 1.5666666666667, -0.025, 0
31634, 1.5833333333333, -0.025, 0
31635, 1.6, -0.025, 0
31636, 1.6166666666667, -0.025, 0
31637, 1.6333333333333, -0.025, 0
31638, 1.65, -0.025, 0
31639, 1.6666666666667, -0.025, 0
31640, 1.6833333333333, -0.025, 0
31641, 1.7, -0.025, 0
31642, 1.7166666666667, -0.025, 0
31643, 1.7333333333333, -0.025, 0
31644, 1.75, -0.025, 0
31645, 1.7666666666667, -0.025, 0
31646, 1.7833333333333, -0.025, 0
31647, 1.8, -0.025, 0
31648, 1.8166666666667, -0.025, 0
31649, 1.8333333333333, -0.025, 0
31650, 1.85, -0.025, 0
31651, 1.8666666666667, -0.025, 0
31652, 1.8833333333333, -0.025, 0
31653, 1.9, -0.025, 0
31654, 1.9166666666667, -0.025, 0
31655, 1.9333333333333, -0.025, 0
31656, 1.95, -0.025, 0
31657, 1.9666666666667, -0.025, 0
31658, 1.9833333333333, -0.025, 0
31659, 2, -0.025, 0
31660, 2.0166666666667, -0.025, 0
31661, 2.0333333333333, -0.025, 0
31662, 2.05, -0.025, 0
31663, 2.0666666666667, -0.025, 0
31664, 2.0833333333333, -0.025, 0
31665, 2.1, -0.025, 0
31666, 2.1166666666667, -0.025, 0
31667, 2.1333333333333, -0.025, 0
31668, 2.15, -0.025, 0
31669, 2.1666666666667, -0.025, 0
31670, 2.1833333333333, -0.025, 0
31671, 1.2083333333333, -0.025, 0
31672, 1.2166666666667, -0.0125, 0
31673, 1.225, -0.025, 0
31674, 1.2333333333333, -0.0125, 0
31675, 1.2416666666667, -0.025, 0
31676, 1.25, -0.0125, 0
31677, 1.2583333333333, -0.025, 0
31678, 1.2666666666667, -0.0125, 0
31679, 1.275, -0.025, 0
31680, 1.2833333333333, -0.0125, 0
31681, 1.2916666666667, -0.025, 0
31682, 1.3, -0.0125, 0
31683, 1.3083333333333, -0.025, 0
31684, 1.3166666666667, -0.0125, 0
31685, 1.325, -0.025, 0
31686, 1.3333333333333, -0.0125, 0
31687, 1.3416666666667, -0.025, 0
31688, 1.35, -0.0125, 0
31689, 1.3583333333333, -0.025, 0
31690, 1.3666666666667, -0.0125, 0
31691, 1.375, -0.025, 0
31692, 1.3833333333333, -0.0125, 0
31693, 1.3916666666667, -0.025, 0
31694, 1.4, -0.0125, 0
31695, 1.4083333333333, -0.025, 0
31696, 1.4166666666667, -0.0125, 0
31697, 1.425, -0.025, 0
31698, 1.4333333333333, -0.0125, 0
31699, 1.4416666666667, -0.025, 0
31700, 1.45, -0.0125, 0
31701, 1.4583333333333, -0.025, 0
31702, 1.4666666666667, -0.0125, 0
31703, 1.475, -0.025, 0
31704, 1.4833333333333, -0.0125, 0
31705, 1.4916666666667, -0.025, 0
31706, 1.5, -0.0125, 0
31707, 1.5083333333333, -0.025, 0
31708, 1.5166666666667, -0.0125, 0
31709, 1.525, -0.025, 0
31710, 1.5333333333333, -0.0125, 0
31711, 1.5416666666667, -0.025, 0
31712, 1.55, -0.0125, 0
31713, 1.5583333333333, -0.025, 0
31714, 1.5666666666667, -0.0125, 0
31715, 1.575, -0.025, 0
31716, 1.5833333333333, -0.0125, 0
31717, 1.5916666666667, -0.025, 0
31718, 1.6, -0.0125, 0
31719, 1.6083333333333, -0.025, 0
31720, 1.6166666666667, -0.0125, 0
31721, 1.625, -0.025, 0
31722, 1.6333333333333, -0.0125, 0
31723, 1.6416666666667, -0.025, 0
31724, 1.65, -0.0125, 0
31725, 1.6583333333333, -0.025, 0
31726, 1.6666666666667, -0.0125, 0
31727, 1.675, -0.025, 0
31728, 1.6833333333333, -0.0125, 0
31729, 1.6916666666667, -0.025, 0
31730, 1.7, -0.0125, 0
31731, 1.7083333333333, -0.025, 0
31732, 1.7166666666667, -0.0125, 0
31733, 1.725, -0.025, 0
31734, 1.7333333333333, -0.0125, 0
31735, 1.7416666666667, -0.025, 0
31736, 1.75, -0.0125, 0
31737, 1.7583333333333, -0.025, 0
31738, 1.7666666666667, -0.0125, 0
31739, 1.775, -0.025, 0
31740, 1.7833333333333, -0.0125, 0
31741, 1.7916666666667, -0.025, 0
31742, 1.8, -0.0125, 0
31743, 1.8083333333333, -0.025, 0
31744, 1.8166666666667, -0.0125, 0
31745, 1.825, -0.025, 0
31746, 1.8333333333333, -0.0125, 0
31747, 1.8416666666667, -0.025, 0
31748, 1.85, -0.0125, 0
31749, 1.8583333333333, -0.025, 0
31750, 1.8666666666667, -0.0125, 0
31751, 1.875, -0.025, 0
31752, 1.8833333333333, -0.0125, 0
31753, 1.8916666666667, -0.025, 0
31754, 1.9, -0.0125, 0
31755, 1.9083333333333, -0.025, 0
31756, 1.9166666666667, -0.0125, 0
31757, 1.925, -0.025, 0
31758, 1.9333333333333, -0.0125, 0
31759, 1.9416666666667, -0.025, 0
31760, 1.95, -0.0125, 0
31761, 1.9583333333333, -0.025, 0
31762, 1.9666666666667, -0.0125, 0
31763, 1.975, -0.025, 0
31764, 1.9833333333333, -0.0125, 0
31765, 1.9916666666667, -0.025, 0
31766, 2, -0.0125, 0
31767, 2.0083333333333, -0.025, 0
31768, 2.0166666666667, -0.0125, 0
31769, 2.025, -0.025, 0
31770, 2.0333333333333, -0.0125, 0
31771, 2.0416666666667, -0.025, 0
31772, 2.05, -0.0125, 0
31773, 2.0583333333333, -0.025, 0
31774, 2.0666666666667, -0.0125, 0
31775, 2.075, -0.025, 0
31776, 2.0833333333333, -0.0125, 0
31777, 2.0916666666667, -0.025, 0
31778, 2.1, -0.0125, 0
31779, 2.1083333333333, -0.025, 0
31780, 2.1166666666667, -0.0125, 0
31781, 2.125, -0.025, 0
31782, 2.1333333333333, -0.0125, 0
31783, 2.1416666666667, -0.025, 0
31784, 2.15, -0.0125, 0
31785, 2.1583333333333, -0.025, 0
31786, 2.1666666666667, -0.0125, 0
31787, 2.175, -0.025, 0
31788, 2.1833333333333, -0.0125, 0
31789, 2.1916666666667, -0.025, 0
31790, 1.2166666666667, -0.0375, 0
31791, 1.2333333333333, -0.0375, 0
31792, 1.25, -0.0375, 0
31793, 1.2666666666667, -0.0375, 0
31794, 1.2833333333333, -0.0375, 0
31795, 1.3, -0.0375, 0
31796, 1.3166666666667, -0.0375, 0
31797, 1.3333333333333, -0.0375, 0
31798, 1.35, -0.0375, 0
31799, 1.3666666666667, -0.0375, 0
31800, 1.3833333333333, -0.0375, 0
31801, 1.4, -0.0375, 0
31802, 1.4166666666667, -0.0375, 0
31803, 1.4333333333333, -0.0375, 0
31804, 1.45, -0.0375, 0
31805, 1.4666666666667, -0.0375, 0
31806, 1.4833333333333, -0.0375, 0
31807, 1.5, -0.0375, 0
31808, 1.5166666666667, -0.0375, 0
31809, 1.5333333333333, -0.0375, 0
31810, 1.55, -0.0375, 0
31811, 1.5666666666667, -0.0375, 0
31812, 1.5833333333333, -0.0375, 0
31813, 1.6, -0.0375, 0
31814, 1.6166666666667, -0.0375, 0
31815, 1.6333333333333, -0.0375, 0
31816, 1.65, -0.0375, 0
31817, 1.6666666666667, -0.0375, 0
31818, 1.6833333333333, -0.0375, 0
31819, 1.7, -0.0375, 0
31820, 1.7166666666667, -0.0375, 0
31821, 1.7333333333333, -0.0375, 0
31822, 1.75, -0.0375, 0
31823, 1.7666666666667, -0.0375, 0
31824, 1.7833333333333, -0.0375, 0
31825, 1.8, -0.0375, 0
31826, 1.8166666666667, -0.0375, 0
31827, 1.8333333333333, -0.0375, 0
31828, 1.85, -0.0375, 0
31829, 1.8666666666667, -0.0375, 0
31830, 1.8833333333333, -0.0375, 0
31831, 1.9, -0.0375, 0
31832, 1.9166666666667, -0.0375, 0
31833, 1.9333333333333, -0.0375, 0
31834, 1.95, -0.0375, 0
31835, 1.9666666666667, -0.0375, 0
31836, 1.9833333333333, -0.0375, 0
31837, 2, -0.0375, 0
31838, 2.0166666666667, -0.0375, 0
31839, 2.0333333333333, -0.0375, 0
31840, 2.05, -0.0375, 0
31841, 2.0666666666667, -0.0375, 0
31842, 2.0833333333333, -0.0375, 0
31843, 2.1, -0.0375, 0
31844, 2.1166666666667, -0.0375, 0
31845, 2.1333333333333, -0.0375, 0
31846, 2.15, -0.0375, 0
31847, 2.1666666666667, -0.0375, 0
31848, 2.1833333333333, -0.0375, 0
31849, 0.98333333333333, 1.225, 0
31850, 0.96666666666667, 1.225, 0
31851, 0.95, 1.225, 0
31852, 0.93333333333333, 1.225, 0
31853, 0.91666666666667, 1.225, 0
31854, 0.9, 1.225, 0
31855, 0.88333333333333, 1.225, 0
31856, 0.86666666666667, 1.225, 0
31857, 0.85, 1.225, 0
31858, 0.83333333333333, 1.225, 0
31859, 0.81666666666667, 1.225, 0
31860, 0.8, 1.225, 0
31861, 0.78333333333333, 1.225, 0
31862, 0.76666666666667, 1.225, 0
31863, 0.75, 1.225, 0
31864, 0.73333333333333, 1.225, 0
31865, 0.71666666666667, 1.225, 0
31866, 0.7, 1.225, 0
31867, 0.68333333333333, 1.225, 0
31868, 0.66666666666667, 1.225, 0
31869, 0.65, 1.225, 0
31870, 0.63333333333333, 1.225, 0
31871, 0.61666666666667, 1.225, 0
31872, 0.6, 1.225, 0
31873, 0.58333333333333, 1.225, 0
31874, 0.56666666666667, 1.225, 0
31875, 0.55, 1.225, 0
31876, 0.53333333333333, 1.225, 0
31877, 0.51666666666667, 1.225, 0
31878, 0.5, 1.225, 0
31879, 0.48333333333333, 1.225, 0
31880, 0.46666666666667, 1.225, 0
31881, 0.45, 1.225, 0
31882, 0.43333333333333, 1.225, 0
31883, 0.41666666666667, 1.225, 0
31884, 0.4, 1.225, 0
31885, 0.38333333333333, 1.225, 0
31886, 0.36666666666667, 1.225, 0
31887, 0.35, 1.225, 0
31888, 0.33333333333333, 1.225, 0
31889, 0.31666666666667, 1.225, 0
31890, 0.3, 1.225, 0
31891, 0.28333333333333, 1.225, 0
31892, 0.26666666666667, 1.225, 0
31893, 0.25, 1.225, 0
31894, 0.23333333333333, 1.225, 0
31895, 0.21666666666667, 1.225, 0
31896, 0.2, 1.225, 0
31897, 0.18333333333333, 1.225, 0
31898, 0.16666666666667, 1.225, 0
31899, 0.15, 1.225, 0
31900, 0.13333333333333, 1.225, 0
31901, 0.11666666666667, 1.225, 0
31902, 0.1, 1.225, 0
31903, 0.083333333333333, 1.225, 0
31904, 0.066666666666667, 1.225, 0
31905, 0.05, 1.225, 0
31906, 0.033333333333333, 1.225, 0
31907, 0.016666666666667, 1.225, 0
31908, 0.99166666666667, 1.225, 0
31909, 0.98333333333333, 1.2125, 0
31910, 0.975, 1.225, 0
31911, 0.96666666666667, 1.2125, 0
31912, 0.95833333333333, 1.225, 0
31913, 0.95, 1.2125, 0
31914, 0.94166666666667, 1.225, 0
31915, 0.93333333333333, 1.2125, 0
31916, 0.925, 1.225, 0
31917, 0.91666666666667, 1.2125, 0
31918, 0.90833333333333, 1.225, 0
31919, 0.9, 1.2125, 0
31920, 0.89166666666667, 1.225, 0
31921, 0.88333333333333, 1.2125, 0
31922, 0.875, 1.225, 0
31923, 0.86666666666667, 1.2125, 0
31924, 0.85833333333333, 1.225, 0
31925, 0.85, 1.2125, 0
31926, 0.84166666666667, 1.225, 0
31927, 0.83333333333333, 1.2125, 0
31928, 0.825, 1.225, 0
31929, 0.81666666666667, 1.2125, 0
31930, 0.80833333333333, 1.225, 0
31931, 0.8, 1.2125, 0
31932, 0.79166666666667, 1.225, 0
31933, 0.78333333333333, 1.2125, 0
31934, 0.775, 1.225, 0
31935, 0.76666666666667, 1.2125, 0
31936, 0.75833333333333, 1.225, 0
31937, 0.75, 1.2125, 0
31938, 0.74166666666667, 1.225, 0
31939, 0.73333333333333, 1.2125, 0
31940, 0.725, 1.225, 0
31941, 0.71666666666667, 1.2125, 0
31942, 0.70833333333333, 1.225, 0
31943, 0.7, 1.2125, 0
31944, 0.69166666666667, 1.225, 0
31945, 0.68333333333333, 1.2125, 0
31946, 0.675, 1.225, 0
31947, 0.66666666666667, 1.2125, 0
31948, 0.65833333333333, 1.225, 0
31949, 0.65, 1.2125, 0
31950, 0.64166666666667, 1.225, 0
31951, 0.63333333333333, 1.2125, 0
31952, 0.625, 1.225, 0
31953, 0.61666666666667, 1.2125, 0
31954, 0.60833333333333, 1.225, 0
31955, 0.6, 1.2125, 0
31956, 0.59166666666667, 1.225, 0
31957, 0.58333333333333, 1.2125, 0
31958, 0.575, 1.225, 0
31959, 0.56666666666667, 1.2125, 0
31960, 0.55833333333333, 1.225, 0
31961, 0.55, 1.2125, 0
31962, 0.54166666666667, 1.225, 0
31963, 0.53333333333333, 1.2125, 0
31964, 0.525, 1.225, 0
31965, 0.51666666666667, 1.2125, 0
31966, 0.50833333333333, 1.225, 0
31967, 0.5, 1.2125, 0
31968, 0.49166666666667, 1.225, 0
31969, 0.48333333333333, 1.2125, 0
31970, 0.475, 1.225, 0
31971, 0.46666666666667, 1.2125, 0
31972, 0.45833333333333, 1.225, 0
31973, 0.45, 1.2125, 0
31974, 0.44166666666667, 1.225, 0
31975, 0.43333333333333, 1.2125, 0
31976, 0.425, 1.225, 0
31977, 0.41666666666667, 1.2125, 0
31978, 0.40833333333333, 1.225, 0
31979, 0.4, 1.2125, 0
31980, 0.39166666666667, 1.225, 0
31981, 0.38333333333333, 1.2125, 0
31982, 0.375, 1.225, 0
31983, 0.36666666666667, 1.2125, 0
31984, 0.35833333333333, 1.225, 0
31985, 0.35, 1.2125, 0
31986, 0.34166666666667, 1.225, 0
31987, 0.33333333333333, 1.2125, 0
31988, 0.325, 1.225, 0
31989, 0.31666666666667, 1.2125, 0
31990, 0.30833333333333, 1.225, 0
31991, 0.3, 1.2125, 0
31992, 0.29166666666667, 1.225, 0
31993, 0.28333333333333, 1.2125, 0
31994, 0.275, 1.225, 0
31995, 0.26666666666667, 1.2125, 0
31996, 0.25833333333333, 1.225, 0
31997, 0.25, 1.2125, 0
31998, 0.24166666666667, 1.225, 0
31999, 0.23333333333333, 1.2125, 0
32000, 0.225, 1.225, 0
32001, 0.21666666666667, 1.2125, 0
32002, 0.20833333333333, 1.225, 0
32003, 0.2, 1.2125, 0
32004, 0.19166666666667, 1.225, 0
32005, 0.18333333333333, 1.2125, 0
32006, 0.175, 1.225, 0
32007, 0.16666666666667, 1.2125, 0
32008, 0.15833333333333, 1.225, 0
32009, 0.15, 1.2125, 0
32010, 0.14166666666667, 1.225, 0
32011, 0.13333333333333, 1.2125, 0
32012, 0.125, 1.225, 0
32013, 0.11666666666667, 1.2125, 0
32014, 0.10833333333333, 1.225, 0
32015, 0.1, 1.2125, 0
32016, 0.091666666666667, 1.225, 0
32017, 0.083333333333333, 1.2125, 0
32018, 0.075, 1.225, 0
32019, 0.066666666666667, 1.2125, 0
32020, 0.058333333333333, 1.225, 0
32021, 0.05, 1.2125, 0
32022, 0.041666666666667, 1.225, 0
32023, 0.033333333333333, 1.2125, 0
32024, 0.025, 1.225, 0
32025, 0.016666666666667, 1.2125, 0
32026, 0.0083333333333333, 1.225, 0
32027, 0.98333333333333, 1.2375, 0
32028, 0.96666666666667, 1.2375, 0
32029, 0.95, 1.2375, 0
32030, 0.93333333333333, 1.2375, 0
32031, 0.91666666666667, 1.2375, 0
32032, 0.9, 1.2375, 0
32033, 0.88333333333333, 1.2375, 0
32034, 0.86666666666667, 1.2375, 0
32035, 0.85, 1.2375, 0
32036, 0.83333333333333, 1.2375, 0
32037, 0.81666666666667, 1.2375, 0
32038, 0.8, 1.2375, 0
32039, 0.78333333333333, 1.2375, 0
32040, 0.76666666666667, 1.2375, 0
32041, 0.75, 1.2375, 0
32042, 0.73333333333333, 1.2375, 0
32043, 0.71666666666667, 1.2375, 0
32044, 0.7, 1.2375, 0
32045, 0.68333333333333, 1.2375, 0
32046, 0.66666666666667, 1.2375, 0
32047, 0.65, 1.2375, 0
32048, 0.63333333333333, 1.2375, 0
32049, 0.61666666666667, 1.2375, 0
32050, 0.6, 1.2375, 0
32051, 0.58333333333333, 1.2375, 0
32052, 0.56666666666667, 1.2375, 0
32053, 0.55, 1.2375, 0
32054, 0.53333333333333, 1.2375, 0
32055, 0.51666666666667, 1.2375, 0
32056, 0.5, 1.2375, 0
32057, 0.48333333333333, 1.2375, 0
32058, 0.46666666666667, 1.2375, 0
32059, 0.45, 1.2375, 0
32060, 0.43333333333333, 1.2375, 0
32061, 0.41666666666667, 1.2375, 0
32062, 0.4, 1.2375, 0
32063, 0.38333333333333, 1.2375, 0
32064, 0.36666666666667, 1.2375, 0
32065, 0.35, 1.2375, 0
32066, 0.33333333333333, 1.2375, 0
32067, 0.31666666666667, 1.2375, 0
32068, 0.3, 1.2375, 0
32069, 0.28333333333333, 1.2375, 0
32070, 0.26666666666667, 1.2375, 0
32071, 0.25, 1.2375, 0
32072, 0.23333333333333, 1.2375, 0
32073, 0.21666666666667, 1.2375, 0
32074, 0.2, 1.2375, 0
32075, 0.18333333333333, 1.2375, 0
32076, 0.16666666666667, 1.2375, 0
32077, 0.15, 1.2375, 0
32078, 0.13333333333333, 1.2375, 0
32079, 0.11666666666667, 1.2375, 0
32080, 0.1, 1.2375, 0
32081, 0.083333333333333, 1.2375, 0
32082, 0.066666666666667, 1.2375, 0
32083, 0.05, 1.2375, 0
32084, 0.033333333333333, 1.2375, 0
32085, 0.016666666666667, 1.2375, 0
32086, 1.175, -0.19, 0
32087, 1.175, -0.23, 0
32088, 1.175, -0.27, 0
32089, 1.175, -0.31, 0
32090, 1.15, -0.19, 0
32091, 1.15, -0.23, 0
32092, 1.15, -0.27, 0
32093, 1.15, -0.31, 0
32094, 1.125, -0.19, 0
32095, 1.125, -0.23, 0
32096, 1.125, -0.27, 0
32097, 1.125, -0.31, 0
32098, 1.1, -0.19, 0
32099, 1.1, -0.23, 0
32100, 1.1, -0.27, 0
32101, 1.1, -0.31, 0
32102, 1.075, -0.19, 0
32103, 1.075, -0.23, 0
32104, 1.075, -0.27, 0
32105, 1.075, -0.31, 0
32106, 1.05, -0.19, 0
32107, 1.05, -0.23, 0
32108, 1.05, -0.27, 0
32109, 1.05, -0.31, 0
32110, 1.025, -0.19, 0
32111, 1.025, -0.23, 0
32112, 1.025, -0.27, 0
32113, 1.025, -0.31, 0
32114, 1.175, -0.17, 0
32115, 1.1875, -0.19, 0
32116, 1.175, -0.21, 0
32117, 1.1875, -0.23, 0
32118, 1.175, -0.25, 0
32119, 1.1875, -0.27, 0
32120, 1.175, -0.29, 0
32121, 1.1875, -0.31, 0
32122, 1.175, -0.33, 0
32123, 1.15, -0.17, 0
32124, 1.1625, -0.19, 0
32125, 1.15, -0.21, 0
32126, 1.1625, -0.23, 0
32127, 1.15, -0.25, 0
32128, 1.1625, -0.27, 0
32129, 1.15, -0.29, 0
32130, 1.1625, -0.31, 0
32131, 1.15, -0.33, 0
32132, 1.125, -0.17, 0
32133, 1.1375, -0.19, 0
32134, 1.125, -0.21, 0
32135, 1.1375, -0.23, 0
32136, 1.125, -0.25, 0
32137, 1.1375, -0.27, 0
32138, 1.125, -0.29, 0
32139, 1.1375, -0.31, 0
32140, 1.125, -0.33, 0
32141, 1.1, -0.17, 0
32142, 1.1125, -0.19, 0
32143, 1.1, -0.21, 0
32144, 1.1125, -0.23, 0
32145, 1.1, -0.25, 0
32146, 1.1125, -0.27, 0
32147, 1.1, -0.29, 0
32148, 1.1125, -0.31, 0
32149, 1.1, -0.33, 0
32150, 1.075, -0.17, 0
32151, 1.0875, -0.19, 0
32152, 1.075, -0.21, 0
32153, 1.0875, -0.23, 0
32154, 1.075, -0.25, 0
32155, 1.0875, -0.27, 0
32156, 1.075, -0.29, 0
32157, 1.0875, -0.31, 0
32158, 1.075, -0.33, 0
32159, 1.05, -0.17, 0
32160, 1.0625, -0.19, 0
32161, 1.05, -0.21, 0
32162, 1.0625, -0.23, 0
32163, 1.05, -0.25, 0
32164, 1.0625, -0.27, 0
32165, 1.05, -0.29, 0
32166, 1.0625, -0.31, 0
32167, 1.05, -0.33, 0
32168, 1.025, -0.17, 0
32169, 1.0375, -0.19, 0
32170, 1.025, -0.21, 0
32171, 1.0375, -0.23, 0
32172, 1.025, -0.25, 0
32173, 1.0375, -0.27, 0
32174, 1.025, -0.29, 0
32175, 1.0375, -0.31, 0
32176, 1.025, -0.33, 0
32177, 1.0125, -0.19, 0
32178, 1.0125, -0.23, 0
32179, 1.0125, -0.27, 0
32180, 1.0125, -0.31, 0
32181, 2.2666666666667, 1.51, 0
32182, 2.2666666666667, 1.47, 0
32183, 2.2666666666667, 1.43, 0
32184, 2.2666666666667, 1.39, 0
32185, 2.2333333333333, 1.51, 0
32186, 2.2333333333333, 1.47, 0
32187, 2.2333333333333, 1.43, 0
32188, 2.2333333333333, 1.39, 0
32189, 2.2666666666667, 1.53, 0
32190, 2.2833333333333, 1.51, 0
32191, 2.2666666666667, 1.49, 0
32192, 2.2833333333333, 1.47, 0
32193, 2.2666666666667, 1.45, 0
32194, 2.2833333333333, 1.43, 0
32195, 2.2666666666667, 1.41, 0
32196, 2.2833333333333, 1.39, 0
32197, 2.2666666666667, 1.37, 0
32198, 2.2333333333333, 1.53, 0
32199, 2.25, 1.51, 0
32200, 2.2333333333333, 1.49, 0
32201, 2.25, 1.47, 0
32202, 2.2333333333333, 1.45, 0
32203, 2.25, 1.43, 0
32204, 2.2333333333333, 1.41, 0
32205, 2.25, 1.39, 0
32206, 2.2333333333333, 1.37, 0
32207, 2.2166666666667, 1.51, 0
32208, 2.2166666666667, 1.47, 0
32209, 2.2166666666667, 1.43, 0
32210, 2.2166666666667, 1.39, 0
32211, -0.066666666666667, 1.39, 0
32212, -0.066666666666667, 1.43, 0
32213, -0.066666666666667, 1.47, 0
32214, -0.066666666666667, 1.51, 0
32215, -0.033333333333333, 1.39, 0
32216, -0.033333333333333, 1.43, 0
32217, -0.033333333333333, 1.47, 0
32218, -0.033333333333333, 1.51, 0
32219, -0.066666666666667, 1.37, 0
32220, -0.083333333333333, 1.39, 0
32221, -0.066666666666667, 1.41, 0
32222, -0.083333333333333, 1.43, 0
32223, -0.066666666666667, 1.45, 0
32224, -0.083333333333333, 1.47, 0
32225, -0.066666666666667, 1.49, 0
32226, -0.083333333333333, 1.51, 0
32227, -0.066666666666667, 1.53, 0
32228, -0.033333333333333, 1.37, 0
32229, -0.05, 1.39, 0
32230, -0.033333333333333, 1.41, 0
32231, -0.05, 1.43, 0
32232, -0.033333333333333, 1.45, 0
32233, -0.05, 1.47, 0
32234, -0.033333333333333, 1.49, 0
32235, -0.05, 1.51, 0
32236, -0.033333333333333, 1.53, 0
32237, -0.016666666666667, 1.39, 0
32238, -0.016666666666667, 1.43, 0
32239, -0.016666666666667, 1.47, 0
32240, -0.016666666666667, 1.51, 0
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line90
43, 1, 47, 43
44, 43, 48, 44
45, 44, 49, 45
46, 45, 50, 46
47, 46, 51, 2
*ELEMENT, type=T3D3, ELSET=Line103
48, 3, 111, 52
49, 52, 112, 53
50, 53, 113, 54
51, 54, 114, 55
52, 55, 115, 56
53, 56, 116, 57
54, 57, 117, 58
55, 58, 118, 59
56, 59, 119, 60
57, 60, 120, 61
58, 61, 121, 62
59, 62, 122, 63
60, 63, 123, 64
61, 64, 124, 65
62, 65, 125, 66
63, 66, 126, 67
64, 67, 127, 68
65, 68, 128, 69
66, 69, 129, 70
67, 70, 130, 71
68, 71, 131, 72
69, 72, 132, 73
70, 73, 133, 74
71, 74, 134, 75
72, 75, 135, 76
73, 76, 136, 77
74, 77, 137, 78
75, 78, 138, 79
76, 79, 139, 80
77, 80, 140, 81
78, 81, 141, 82
79, 82, 142, 83
80, 83, 143, 84
81, 84, 144, 85
82, 85, 145, 86
83, 86, 146, 87
84, 87, 147, 88
85, 88, 148, 89
86, 89, 149, 90
87, 90, 150, 91
88, 91, 151, 92
89, 92, 152, 93
90, 93, 153, 94
91, 94, 154, 95
92, 95, 155, 96
93, 96, 156, 97
94, 97, 157, 98
95, 98, 158, 99
96, 99, 159, 100
97, 100, 160, 101
98, 101, 161, 102
99, 102, 162, 103
100, 103, 163, 104
101, 104, 164, 105
102, 105, 165, 106
103, 106, 166, 107
104, 107, 167, 108
105, 108, 168, 109
106, 109, 169, 110
107, 110, 170, 4
*ELEMENT, type=T3D3, ELSET=Line104
108, 5, 230, 171
109, 171, 231, 172
110, 172, 232, 173
111, 173, 233, 174
112, 174, 234, 175
113, 175, 235, 176
114, 176, 236, 177
115, 177, 237, 178
116, 178, 238, 179
117, 179, 239, 180
118, 180, 240, 181
119, 181, 241, 182
120, 182, 242, 183
121, 183, 243, 184
122, 184, 244, 185
123, 185, 245, 186
124, 186, 246, 187
125, 187, 247, 188
126, 188, 248, 189
127, 189, 249, 190
128, 190, 250, 191
129, 191, 251, 192
130, 192, 252, 193
131, 193, 253, 194
132, 194, 254, 195
133, 195, 255, 196
134, 196, 256, 197
135, 197, 257, 198
136, 198, 258, 199
137, 199, 259, 200
138, 200, 260, 201
139, 201, 261, 202
140, 202, 262, 203
141, 203, 263, 204
142, 204, 264, 205
143, 205, 265, 206
144, 206, 266, 207
145, 207, 267, 208
146, 208, 268, 209
147, 209, 269, 210
148, 210, 270, 211
149, 211, 271, 212
150, 212, 272, 213
151, 213, 273, 214
152, 214, 274, 215
153, 215, 275, 216
154, 216, 276, 217
155, 217, 277, 218
156, 218, 278, 219
157, 219, 279, 220
158, 220, 280, 221
159, 221, 281, 222
160, 222, 282, 223
161, 223, 283, 224
162, 224, 284, 225
163, 225, 285, 226
164, 226, 286, 227
165, 227, 287, 228
166, 228, 288, 229
167, 229, 289, 6
*ELEMENT, type=T3D3, ELSET=Line105
168, 6, 349, 290
169, 290, 350, 291
170, 291, 351, 292
171, 292, 352, 293
172, 293, 353, 294
173, 294, 354, 295
174, 295, 355, 296
175, 296, 356, 297
176, 297, 357, 298
177, 298, 358, 299
178, 299, 359, 300
179, 300, 360, 301
180, 301, 361, 302
181, 302, 362, 303
182, 303, 363, 304
183, 304, 364, 305
184, 305, 365, 306
185, 306, 366, 307
186, 307, 367, 308
187, 308, 368, 309
188, 309, 369, 310
189, 310, 370, 311
190, 311, 371, 312
191, 312, 372, 313
192, 313, 373, 314
193, 314, 374, 315
194, 315, 375, 316
195, 316, 376, 317
196, 317, 377, 318
197, 318, 378, 319
198, 319, 379, 320
199, 320, 380, 321
200, 321, 381, 322
201, 322, 382, 323
202, 323, 383, 324
203, 324, 384, 325
204, 325, 385, 326
205, 326, 386, 327
206, 327, 387, 328
207, 328, 388, 329
208, 329, 389, 330
209, 330, 390, 331
210, 331, 391, 332
211, 332, 392, 333
212, 333, 393, 334
213, 334, 394, 335
214, 335, 395, 336
215, 336, 396, 337
216, 337, 397, 338
217, 338, 398, 339
218, 339, 399, 340
219, 340, 400, 341
220, 341, 401, 342
221, 342, 402, 343
222, 343, 403, 344
223, 344, 404, 345
224, 345, 405, 346
225, 346, 406, 347
226, 347, 407, 348
227, 348, 408, 7
*ELEMENT, type=T3D3, ELSET=Line106
228, 7, 468, 409
229, 409, 469, 410
230, 410, 470, 411
231, 411, 471, 412
232, 412, 472, 413
233, 413, 473, 414
234, 414, 474, 415
235, 415, 475, 416
236, 416, 476, 417
237, 417, 477, 418
238, 418, 478, 419
239, 419, 479, 420
240, 420, 480, 421
241, 421, 481, 422
242, 422, 482, 423
243, 423, 483, 424
244, 424, 484, 425
245, 425, 485, 426
246, 426, 486, 427
247, 427, 487, 428
248, 428, 488, 429
249, 429, 489, 430
250, 430, 490, 431
251, 431, 491, 432
252, 432, 492, 433
253, 433, 493, 434
254, 434, 494, 435
255, 435, 495, 436
256, 436, 496, 437
257, 437, 497, 438
258, 438, 498, 439
259, 439, 499, 440
260, 440, 500, 441
261, 441, 501, 442
262, 442, 502, 443
263, 443, 503, 444
264, 444, 504, 445
265, 445, 505, 446
266, 446, 506, 447
267, 447, 507, 448
268, 448, 508, 449
269, 449, 509, 450
270, 450, 510, 451
271, 451, 511, 452
272, 452, 512, 453
273, 453, 513, 454
274, 454, 514, 455
275, 455, 515, 456
276, 456, 516, 457
277, 457, 517, 458
278, 458, 518, 459
279, 459, 519, 460
280, 460, 520, 461
281, 461, 521, 462
282, 462, 522, 463
283, 463, 523, 464
284, 464, 524, 465
285, 465, 525, 466
286, 466, 526, 467
287, 467, 527, 8
*ELEMENT, type=T3D3, ELSET=Line107
288, 8, 587, 528
289, 528, 588, 529
290, 529, 589, 530
291, 530, 590, 531
292, 531, 591, 532
293, 532, 592, 533
294, 533, 593, 534
295, 534, 594, 535
296, 535, 595, 536
297, 536, 596, 537
298, 537, 597, 538
299, 538, 598, 539
300, 539, 599, 540
301, 540, 600, 541
302, 541, 601, 542
303, 542, 602, 543
304, 543, 603, 544
305, 544, 604, 545
306, 545, 605, 546
307, 546, 606, 547
308, 547, 607, 548
309, 548, 608, 549
310, 549, 609, 550
311, 550, 610, 551
312, 551, 611, 552
313, 552, 612, 553
314, 553, 613, 554
315, 554, 614, 555
316, 555, 615, 556
317, 556, 616, 557
318, 557, 617, 558
319, 558, 618, 559
320, 559, 619, 560
321, 560, 620, 561
322, 561, 621, 562
323, 562, 622, 563
324, 563, 623, 564
325, 564, 624, 565
326, 565, 625, 566
327, 566, 626, 567
328, 567, 627, 568
329, 568, 628, 569
330, 569, 629, 570
331, 570, 630, 571
332, 571, 631, 572
333, 572, 632, 573
334, 573, 633, 574
335, 574, 634, 575
336, 575, 635, 576
337, 576, 636, 577
338, 577, 637, 578
339, 578, 638, 579
340, 579, 639, 580
341, 580, 640, 581
342, 581, 641, 582
343, 582, 642, 583
344, 583, 643, 584
345, 584, 644, 585
346, 585, 645, 586
347, 586, 646, 5
*ELEMENT, type=T3D3, ELSET=Line109
348, 1, 654, 647
349, 647, 655, 648
350, 648, 656, 649
351, 649, 657, 650
352, 650, 658, 651
353, 651, 659, 652
354, 652, 660, 653
355, 653, 661, 9
*ELEMENT, type=T3D3, ELSET=Line110
356, 3, 667, 662
357, 662, 668, 663
358, 663, 669, 664
359, 664, 670, 665
360, 665, 671, 666
361, 666, 672, 9
*ELEMENT, type=T3D3, ELSET=Line113
362, 10, 732, 673
363, 673, 733, 674
364, 674, 734, 675
365, 675, 735, 676
366, 676, 736, 677
367, 677, 737, 678
368, 678, 738, 679
369, 679, 739, 680
370, 680, 740, 681
371, 681, 741, 682
372, 682, 742, 683
373, 683, 743, 684
374, 684, 744, 685
375, 685, 745, 686
376, 686, 746, 687
377, 687, 747, 688
378, 688, 748, 689
379, 689, 749, 690
380, 690, 750, 691
381, 691, 751, 692
382, 692, 752, 693
383, 693, 753, 694
384, 694, 754, 695
385, 695, 755, 696
386, 696, 756, 697
387, 697, 757, 698
388, 698, 758, 699
389, 699, 759, 700
390, 700, 760, 701
391, 701, 761, 702
392, 702, 762, 703
393, 703, 763, 704
394, 704, 764, 705
395, 705, 765, 706
396, 706, 766, 707
397, 707, 767, 708
398, 708, 768, 709
399, 709, 769, 710
400, 710, 770, 711
401, 711, 771, 712
402, 712, 772, 713
403, 713, 773, 714
404, 714, 774, 715
405, 715, 775, 716
406, 716, 776, 717
407, 717, 777, 718
408, 718, 778, 719
409, 719, 779, 720
410, 720, 780, 721
411, 721, 781, 722
412, 722, 782, 723
413, 723, 783, 724
414, 724, 784, 725
415, 725, 785, 726
416, 726, 786, 727
417, 727, 787, 728
418, 728, 788, 729
419, 729, 789, 730
420, 730, 790, 731
421, 731, 791, 11
*ELEMENT, type=T3D3, ELSET=Line114
422, 12, 851, 792
423, 792, 852, 793
424, 793, 853, 794
425, 794, 854, 795
426, 795, 855, 796
427, 796, 856, 797
428, 797, 857, 798
429, 798, 858, 799
430, 799, 859, 800
431, 800, 860, 801
432, 801, 861, 802
433, 802, 862, 803
434, 803, 863, 804
435, 804, 864, 805
436, 805, 865, 806
437, 806, 866, 807
438, 807, 867, 808
439, 808, 868, 809
440, 809, 869, 810
441, 810, 870, 811
442, 811, 871, 812
443, 812, 872, 813
444, 813, 873, 814
445, 814, 874, 815
446, 815, 875, 816
447, 816, 876, 817
448, 817, 877, 818
449, 818, 878, 819
450, 819, 879, 820
451, 820, 880, 821
452, 821, 881, 822
453, 822, 882, 823
454, 823, 883, 824
455, 824, 884, 825
456, 825, 885, 826
457, 826, 886, 827
458, 827, 887, 828
459, 828, 888, 829
460, 829, 889, 830
461, 830, 890, 831
462, 831, 891, 832
463, 832, 892, 833
464, 833, 893, 834
465, 834, 894, 835
466, 835, 895, 836
467, 836, 896, 837
468, 837, 897, 838
469, 838, 898, 839
470, 839, 899, 840
471, 840, 900, 841
472, 841, 901, 842
473, 842, 902, 843
474, 843, 903, 844
475, 844, 904, 845
476, 845, 905, 846
477, 846, 906, 847
478, 847, 907, 848
479, 848, 908, 849
480, 849, 909, 850
481, 850, 910, 13
*ELEMENT, type=T3D3, ELSET=Line115
482, 10, 970, 911
483, 911, 971, 912
484, 912, 972, 913
485, 913, 973, 914
486, 914, 974, 915
487, 915, 975, 916
488, 916, 976, 917
489, 917, 977, 918
490, 918, 978, 919
491, 919, 979, 920
492, 920, 980, 921
493, 921, 981, 922
494, 922, 982, 923
495, 923, 983, 924
496, 924, 984, 925
497, 925, 985, 926
498, 926, 986, 927
499, 927, 987, 928
500, 928, 988, 929
501, 929, 989, 930
502, 930, 990, 931
503, 931, 991, 932
504, 932, 992, 933
505, 933, 993, 934
506, 934, 994, 935
507, 935, 995, 936
508, 936, 996, 937
509, 937, 997, 938
510, 938, 998, 939
511, 939, 999, 940
512, 940, 1000, 941
513, 941, 1001, 942
514, 942, 1002, 943
515, 943, 1003, 944
516, 944, 1004, 945
517, 945, 1005, 946
518, 946, 1006, 947
519, 947, 1007, 948
520, 948, 1008, 949
521, 949, 1009, 950
522, 950, 1010, 951
523, 951, 1011, 952
524, 952, 1012, 953
525, 953, 1013, 954
526, 954, 1014, 955
527, 955, 1015, 956
528, 956, 1016, 957
529, 957, 1017, 958
530, 958, 1018, 959
531, 959, 1019, 960
532, 960, 1020, 961
533, 961, 1021, 962
534, 962, 1022, 963
535, 963, 1023, 964
536, 964, 1024, 965
537, 965, 1025, 966
538, 966, 1026, 967
539, 967, 1027, 968
540, 968, 1028, 969
541, 969, 1029, 12
*ELEMENT, type=T3D3, ELSET=Line116
542, 11, 1089, 1030
543, 1030, 1090, 1031
544, 1031, 1091, 1032
545, 1032, 1092, 1033
546, 1033, 1093, 1034
547, 1034, 1094, 1035
548, 1035, 1095, 1036
549, 1036, 1096, 1037
550, 1037, 1097, 1038
551, 1038, 1098, 1039
552, 1039, 1099, 1040
553, 1040, 1100, 1041
554, 1041, 1101, 1042
555, 1042, 1102, 1043
556, 1043, 1103, 1044
557, 1044, 1104, 1045
558, 1045, 1105, 1046
559, 1046, 1106, 1047
560, 1047, 1107, 1048
561, 1048, 1108, 1049
562, 1049, 1109, 1050
563, 1050, 1110, 1051
564, 1051, 1111, 1052
565, 1052, 1112, 1053
566, 1053, 1113, 1054
567, 1054, 1114, 1055
568, 1055, 1115, 1056
569, 1056, 1116, 1057
570, 1057, 1117, 1058
571, 1058, 1118, 1059
572, 1059, 1119, 1060
573, 1060, 1120, 1061
574, 1061, 1121, 1062
575, 1062, 1122, 1063
576, 1063, 1123, 1064
577, 1064, 1124, 1065
578, 1065, 1125, 1066
579, 1066, 1126, 1067
580, 1067, 1127, 1068
581, 1068, 1128, 1069
582, 1069, 1129, 1070
583, 1070, 1130, 1071
584, 1071, 1131, 1072
585, 1072, 1132, 1073
586, 1073, 1133, 1074
587, 1074, 1134, 1075
588, 1075, 1135, 1076
589, 1076, 1136, 1077
590, 1077, 1137, 1078
591, 1078, 1138, 1079
592, 1079, 1139, 1080
593, 1080, 1140, 1081
594, 1081, 1141, 1082
595, 1082, 1142, 1083
596, 1083, 1143, 1084
597, 1084, 1144, 1085
598, 1085, 1145, 1086
599, 1086, 1146, 1087
600, 1087, 1147, 1088
601, 1088, 1148, 13
*ELEMENT, type=T3D3, ELSET=Line119
602, 14, 1208, 1149
603, 1149, 1209, 1150
604, 1150, 1210, 1151
605, 1151, 1211, 1152
606, 1152, 1212, 1153
607, 1153, 1213, 1154
608, 1154, 1214, 1155
609, 1155, 1215, 1156
610, 1156, 1216, 1157
611, 1157, 1217, 1158
612, 1158, 1218, 1159
613, 1159, 1219, 1160
614, 1160, 1220, 1161
615, 1161, 1221, 1162
616, 1162, 1222, 1163
617, 1163, 1223, 1164
618, 1164, 1224, 1165
619, 1165, 1225, 1166
620, 1166, 1226, 1167
621, 1167, 1227, 1168
622, 1168, 1228, 1169
623, 1169, 1229, 1170
624, 1170, 1230, 1171
625, 1171, 1231, 1172
626, 1172, 1232, 1173
627, 1173, 1233, 1174
628, 1174, 1234, 1175
629, 1175, 1235, 1176
630, 1176, 1236, 1177
631, 1177, 1237, 1178
632, 1178, 1238, 1179
633, 1179, 1239, 1180
634, 1180, 1240, 1181
635, 1181, 1241, 1182
636, 1182, 1242, 1183
637, 1183, 1243, 1184
638, 1184, 1244, 1185
639, 1185, 1245, 1186
640, 1186, 1246, 1187
641, 1187, 1247, 1188
642, 1188, 1248, 1189
643, 1189, 1249, 1190
644, 1190, 1250, 1191
645, 1191, 1251, 1192
646, 1192, 1252, 1193
647, 1193, 1253, 1194
648, 1194, 1254, 1195
649, 1195, 1255, 1196
650, 1196, 1256, 1197
651, 1197, 1257, 1198
652, 1198, 1258, 1199
653, 1199, 1259, 1200
654, 1200, 1260, 1201
655, 1201, 1261, 1202
656, 1202, 1262, 1203
657, 1203, 1263, 1204
658, 1204, 1264, 1205
659, 1205, 1265, 1206
660, 1206, 1266, 1207
661, 1207, 1267, 15
*ELEMENT, type=T3D3, ELSET=Line124
662, 16, 1270, 1268
663, 1268, 1271, 1269
664, 1269, 1272, 17
*ELEMENT, type=T3D3, ELSET=Line126
665, 16, 1277, 1273
666, 1273, 1278, 1274
667, 1274, 1279, 1275
668, 1275, 1280, 1276
669, 1276, 1281, 18
*ELEMENT, type=T3D3, ELSET=Line129
670, 14, 1286, 1282
671, 1282, 1287, 1283
672, 1283, 1288, 1284
673, 1284, 1289, 1285
674, 1285, 1290, 19
*ELEMENT, type=T3D3, ELSET=Line130
675, 15, 1295, 1291
676, 1291, 1296, 1292
677, 1292, 1297, 1293
678, 1293, 1298, 1294
679, 1294, 1299, 20
*ELEMENT, type=T3D3, ELSET=Line131
680, 19, 1359, 1300
681, 1300, 1360, 1301
682, 1301, 1361, 1302
683, 1302, 1362, 1303
684, 1303, 1363, 1304
685, 1304, 1364, 1305
686, 1305, 1365, 1306
687, 1306, 1366, 1307
688, 1307, 1367, 1308
689, 1308, 1368, 1309
690, 1309, 1369, 1310
691, 1310, 1370, 1311
692, 1311, 1371, 1312
693, 1312, 1372, 1313
694, 1313, 1373, 1314
695, 1314, 1374, 1315
696, 1315, 1375, 1316
697, 1316, 1376, 1317
698, 1317, 1377, 1318
699, 1318, 1378, 1319
700, 1319, 1379, 1320
701, 1320, 1380, 1321
702, 1321, 1381, 1322
703, 1322, 1382, 1323
704, 1323, 1383, 1324
705, 1324, 1384, 1325
706, 1325, 1385, 1326
707, 1326, 1386, 1327
708, 1327, 1387, 1328
709, 1328, 1388, 1329
710, 1329, 1389, 1330
711, 1330, 1390, 1331
712, 1331, 1391, 1332
713, 1332, 1392, 1333
714, 1333, 1393, 1334
715, 1334, 1394, 1335
716, 1335, 1395, 1336
717, 1336, 1396, 1337
718, 1337, 1397, 1338
719, 1338, 1398, 1339
720, 1339, 1399, 1340
721, 1340, 1400, 1341
722, 1341, 1401, 1342
723, 1342, 1402, 1343
724, 1343, 1403, 1344
725, 1344, 1404, 1345
726, 1345, 1405, 1346
727, 1346, 1406, 1347
728, 1347, 1407, 1348
729, 1348, 1408, 1349
730, 1349, 1409, 1350
731, 1350, 1410, 1351
732, 1351, 1411, 1352
733, 1352, 1412, 1353
734, 1353, 1413, 1354
735, 1354, 1414, 1355
736, 1355, 1415, 1356
737, 1356, 1416, 1357
738, 1357, 1417, 1358
739, 1358, 1418, 20
*ELEMENT, type=T3D3, ELSET=Line132
740, 21, 1423, 1419
741, 1419, 1424, 1420
742, 1420, 1425, 1421
743, 1421, 1426, 1422
744, 1422, 1427, 22
*ELEMENT, type=T3D3, ELSET=Line133
745, 15, 1430, 1428
746, 1428, 1431, 1429
747, 1429, 1432, 21
*ELEMENT, type=T3D3, ELSET=Line134
748, 20, 1435, 1433
749, 1433, 1436, 1434
750, 1434, 1437, 22
*ELEMENT, type=T3D3, ELSET=Line135
751, 2, 1445, 1438
752, 1438, 1446, 1439
753, 1439, 1447, 1440
754, 1440, 1448, 1441
755, 1441, 1449, 1442
756, 1442, 1450, 1443
757, 1443, 1451, 1444
758, 1444, 1452, 23
*ELEMENT, type=T3D3, ELSET=Line136
759, 9, 1457, 1453
760, 1453, 1458, 1454
761, 1454, 1459, 1455
762, 1455, 1460, 1456
763, 1456, 1461, 23
*ELEMENT, type=T3D3, ELSET=Line139
764, 24, 1466, 1462
765, 1462, 1467, 1463
766, 1463, 1468, 1464
767, 1464, 1469, 1465
768, 1465, 1470, 17
*ELEMENT, type=T3D3, ELSET=Line140
769, 18, 1473, 1471
770, 1471, 1474, 1472
771, 1472, 1475, 24
*ELEMENT, type=T3D3, ELSET=Line145
772, 3, 1477, 1476
773, 1476, 1478, 10
*ELEMENT, type=T3D3, ELSET=Line146
774, 4, 1480, 1479
775, 1479, 1481, 12
*ELEMENT, type=T3D3, ELSET=Line147
776, 25, 1487, 1482
777, 1482, 1488, 1483
778, 1483, 1489, 1484
779, 1484, 1490, 1485
780, 1485, 1491, 1486
781, 1486, 1492, 1
*ELEMENT, type=T3D3, ELSET=Line149
782, 25, 1552, 1493
783, 1493, 1553, 1494
784, 1494, 1554, 1495
785, 1495, 1555, 1496
786, 1496, 1556, 1497
787, 1497, 1557, 1498
788, 1498, 1558, 1499
789, 1499, 1559, 1500
790, 1500, 1560, 1501
791, 1501, 1561, 1502
792, 1502, 1562, 1503
793, 1503, 1563, 1504
794, 1504, 1564, 1505
795, 1505, 1565, 1506
796, 1506, 1566, 1507
797, 1507, 1567, 1508
798, 1508, 1568, 1509
799, 1509, 1569, 1510
800, 1510, 1570, 1511
801, 1511, 1571, 1512
802, 1512, 1572, 1513
803, 1513, 1573, 1514
804, 1514, 1574, 1515
805, 1515, 1575, 1516
806, 1516, 1576, 1517
807, 1517, 1577, 1518
808, 1518, 1578, 1519
809, 1519, 1579, 1520
810, 1520, 1580, 1521
811, 1521, 1581, 1522
812, 1522, 1582, 1523
813, 1523, 1583, 1524
814, 1524, 1584, 1525
815, 1525, 1585, 1526
816, 1526, 1586, 1527
817, 1527, 1587, 1528
818, 1528, 1588, 1529
819, 1529, 1589, 1530
820, 1530, 1590, 1531
821, 1531, 1591, 1532
822, 1532, 1592, 1533
823, 1533, 1593, 1534
824, 1534, 1594, 1535
825, 1535, 1595, 1536
826, 1536, 1596, 1537
827, 1537, 1597, 1538
828, 1538, 1598, 1539
829, 1539, 1599, 1540
830, 1540, 1600, 1541
831, 1541, 1601, 1542
832, 1542, 1602, 1543
833, 1543, 1603, 1544
834, 1544, 1604, 1545
835, 1545, 1605, 1546
836, 1546, 1606, 1547
837, 1547, 1607, 1548
838, 1548, 1608, 1549
839, 1549, 1609, 1550
840, 1550, 1610, 1551
841, 1551, 1611, 26
*ELEMENT, type=T3D3, ELSET=Line150
842, 25, 1619, 1612
843, 1612, 1620, 1613
844, 1613, 1621, 1614
845, 1614, 1622, 1615
846, 1615, 1623, 1616
847, 1616, 1624, 1617
848, 1617, 1625, 1618
849, 1618, 1626, 3
*ELEMENT, type=T3D3, ELSET=Line151
850, 27, 1632, 1627
851, 1627, 1633, 1628
852, 1628, 1634, 1629
853, 1629, 1635, 1630
854, 1630, 1636, 1631
855, 1631, 1637, 14
*ELEMENT, type=T3D3, ELSET=Line152
856, 28, 1643, 1638
857, 1638, 1644, 1639
858, 1639, 1645, 1640
859, 1640, 1646, 1641
860, 1641, 1647, 1642
861, 1642, 1648, 15
*ELEMENT, type=T3D3, ELSET=Line153
862, 27, 1708, 1649
863, 1649, 1709, 1650
864, 1650, 1710, 1651
865, 1651, 1711, 1652
866, 1652, 1712, 1653
867, 1653, 1713, 1654
868, 1654, 1714, 1655
869, 1655, 1715, 1656
870, 1656, 1716, 1657
871, 1657, 1717, 1658
872, 1658, 1718, 1659
873, 1659, 1719, 1660
874, 1660, 1720, 1661
875, 1661, 1721, 1662
876, 1662, 1722, 1663
877, 1663, 1723, 1664
878, 1664, 1724, 1665
879, 1665, 1725, 1666
880, 1666, 1726, 1667
881, 1667, 1727, 1668
882, 1668, 1728, 1669
883, 1669, 1729, 1670
884, 1670, 1730, 1671
885, 1671, 1731, 1672
886, 1672, 1732, 1673
887, 1673, 1733, 1674
888, 1674, 1734, 1675
889, 1675, 1735, 1676
890, 1676, 1736, 1677
891, 1677, 1737, 1678
892, 1678, 1738, 1679
893, 1679, 1739, 1680
894, 1680, 1740, 1681
895, 1681, 1741, 1682
896, 1682, 1742, 1683
897, 1683, 1743, 1684
898, 1684, 1744, 1685
899, 1685, 1745, 1686
900, 1686, 1746, 1687
901, 1687, 1747, 1688
902, 1688, 1748, 1689
903, 1689, 1749, 1690
904, 1690, 1750, 1691
905, 1691, 1751, 1692
906, 1692, 1752, 1693
907, 1693, 1753, 1694
908, 1694, 1754, 1695
909, 1695, 1755, 1696
910, 1696, 1756, 1697
911, 1697, 1757, 1698
912, 1698, 1758, 1699
913, 1699, 1759, 1700
914, 1700, 1760, 1701
915, 1701, 1761, 1702
916, 1702, 1762, 1703
917, 1703, 1763, 1704
918, 1704, 1764, 1705
919, 1705, 1765, 1706
920, 1706, 1766, 1707
921, 1707, 1767, 28
*ELEMENT, type=T3D3, ELSET=Line154
922, 29, 1773, 1768
923, 1768, 1774, 1769
924, 1769, 1775, 1770
925, 1770, 1776, 1771
926, 1771, 1777, 1772
927, 1772, 1778, 16
*ELEMENT, type=T3D3, ELSET=Line155
928, 30, 1784, 1779
929, 1779, 1785, 1780
930, 1780, 1786, 1781
931, 1781, 1787, 1782
932, 1782, 1788, 1783
933, 1783, 1789, 31
*ELEMENT, type=T3D3, ELSET=Line156
934, 29, 1849, 1790
935, 1790, 1850, 1791
936, 1791, 1851, 1792
937, 1792, 1852, 1793
938, 1793, 1853, 1794
939, 1794, 1854, 1795
940, 1795, 1855, 1796
941, 1796, 1856, 1797
942, 1797, 1857, 1798
943, 1798, 1858, 1799
944, 1799, 1859, 1800
945, 1800, 1860, 1801
946, 1801, 1861, 1802
947, 1802, 1862, 1803
948, 1803, 1863, 1804
949, 1804, 1864, 1805
950, 1805, 1865, 1806
951, 1806, 1866, 1807
952, 1807, 1867, 1808
953, 1808, 1868, 1809
954, 1809, 1869, 1810
955, 1810, 1870, 1811
956, 1811, 1871, 1812
957, 1812, 1872, 1813
958, 1813, 1873, 1814
959, 1814, 1874, 1815
960, 1815, 1875, 1816
961, 1816, 1876, 1817
962, 1817, 1877, 1818
963, 1818, 1878, 1819
964, 1819, 1879, 1820
965, 1820, 1880, 1821
966, 1821, 1881, 1822
967, 1822, 1882, 1823
968, 1823, 1883, 1824
969, 1824, 1884, 1825
970, 1825, 1885, 1826
971, 1826, 1886, 1827
972, 1827, 1887, 1828
973, 1828, 1888, 1829
974, 1829, 1889, 1830
975, 1830, 1890, 1831
976, 1831, 1891, 1832
977, 1832, 1892, 1833
978, 1833, 1893, 1834
979, 1834, 1894, 1835
980, 1835, 1895, 1836
981, 1836, 1896, 1837
982, 1837, 1897, 1838
983, 1838, 1898, 1839
984, 1839, 1899, 1840
985, 1840, 1900, 1841
986, 1841, 1901, 1842
987, 1842, 1902, 1843
988, 1843, 1903, 1844
989, 1844, 1904, 1845
990, 1845, 1905, 1846
991, 1846, 1906, 1847
992, 1847, 1907, 1848
993, 1848, 1908, 30
*ELEMENT, type=T3D3, ELSET=Line157
994, 16, 1968, 1909
995, 1909, 1969, 1910
996, 1910, 1970, 1911
997, 1911, 1971, 1912
998, 1912, 1972, 1913
999, 1913, 1973, 1914
1000, 1914, 1974, 1915
1001, 1915, 1975, 1916
1002, 1916, 1976, 1917
1003, 1917, 1977, 1918
1004, 1918, 1978, 1919
1005, 1919, 1979, 1920
1006, 1920, 1980, 1921
1007, 1921, 1981, 1922
1008, 1922, 1982, 1923
1009, 1923, 1983, 1924
1010, 1924, 1984, 1925
1011, 1925, 1985, 1926
1012, 1926, 1986, 1927
1013, 1927, 1987, 1928
1014, 1928, 1988, 1929
1015, 1929, 1989, 1930
1016, 1930, 1990, 1931
1017, 1931, 1991, 1932
1018, 1932, 1992, 1933
1019, 1933, 1993, 1934
1020, 1934, 1994, 1935
1021, 1935, 1995, 1936
1022, 1936, 1996, 1937
1023, 1937, 1997, 1938
1024, 1938, 1998, 1939
1025, 1939, 1999, 1940
1026, 1940, 2000, 1941
1027, 1941, 2001, 1942
1028, 1942, 2002, 1943
1029, 1943, 2003, 1944
1030, 1944, 2004, 1945
1031, 1945, 2005, 1946
1032, 1946, 2006, 1947
1033, 1947, 2007, 1948
1034, 1948, 2008, 1949
1035, 1949, 2009, 1950
1036, 1950, 2010, 1951
1037, 1951, 2011, 1952
1038, 1952, 2012, 1953
1039, 1953, 2013, 1954
1040, 1954, 2014, 1955
1041, 1955, 2015, 1956
1042, 1956, 2016, 1957
1043, 1957, 2017, 1958
1044, 1958, 2018, 1959
1045, 1959, 2019, 1960
1046, 1960, 2020, 1961
1047, 1961, 2021, 1962
1048, 1962, 2022, 1963
1049, 1963, 2023, 1964
1050, 1964, 2024, 1965
1051, 1965, 2025, 1966
1052, 1966, 2026, 1967
1053, 1967, 2027, 31
*ELEMENT, type=T3D3, ELSET=Line158
1054, 29, 2030, 2028
1055, 2028, 2031, 2029
1056, 2029, 2032, 32
*ELEMENT, type=T3D3, ELSET=Line159
1057, 32, 2038, 2033
1058, 2033, 2039, 2034
1059, 2034, 2040, 2035
1060, 2035, 2041, 2036
1061, 2036, 2042, 2037
1062, 2037, 2043, 17
*ELEMENT, type=T3D3, ELSET=Line160
1063, 31, 2048, 2044
1064, 2044, 2049, 2045
1065, 2045, 2050, 2046
1066, 2046, 2051, 2047
1067, 2047, 2052, 33
*ELEMENT, type=T3D3, ELSET=Line161
1068, 18, 2112, 2053
1069, 2053, 2113, 2054
1070, 2054, 2114, 2055
1071, 2055, 2115, 2056
1072, 2056, 2116, 2057
1073, 2057, 2117, 2058
1074, 2058, 2118, 2059
1075, 2059, 2119, 2060
1076, 2060, 2120, 2061
1077, 2061, 2121, 2062
1078, 2062, 2122, 2063
1079, 2063, 2123, 2064
1080, 2064, 2124, 2065
1081, 2065, 2125, 2066
1082, 2066, 2126, 2067
1083, 2067, 2127, 2068
1084, 2068, 2128, 2069
1085, 2069, 2129, 2070
1086, 2070, 2130, 2071
1087, 2071, 2131, 2072
1088, 2072, 2132, 2073
1089, 2073, 2133, 2074
1090, 2074, 2134, 2075
1091, 2075, 2135, 2076
1092, 2076, 2136, 2077
1093, 2077, 2137, 2078
1094, 2078, 2138, 2079
1095, 2079, 2139, 2080
1096, 2080, 2140, 2081
1097, 2081, 2141, 2082
1098, 2082, 2142, 2083
1099, 2083, 2143, 2084
1100, 2084, 2144, 2085
1101, 2085, 2145, 2086
1102, 2086, 2146, 2087
1103, 2087, 2147, 2088
1104, 2088, 2148, 2089
1105, 2089, 2149, 2090
1106, 2090, 2150, 2091
1107, 2091, 2151, 2092
1108, 2092, 2152, 2093
1109, 2093, 2153, 2094
1110, 2094, 2154, 2095
1111, 2095, 2155, 2096
1112, 2096, 2156, 2097
1113, 2097, 2157, 2098
1114, 2098, 2158, 2099
1115, 2099, 2159, 2100
1116, 2100, 2160, 2101
1117, 2101, 2161, 2102
1118, 2102, 2162, 2103
1119, 2103, 2163, 2104
1120, 2104, 2164, 2105
1121, 2105, 2165, 2106
1122, 2106, 2166, 2107
1123, 2107, 2167, 2108
1124, 2108, 2168, 2109
1125, 2109, 2169, 2110
1126, 2110, 2170, 2111
1127, 2111, 2171, 33
*ELEMENT, type=T3D3, ELSET=Line162
1128, 34, 2177, 2172
1129, 2172, 2178, 2173
1130, 2173, 2179, 2174
1131, 2174, 2180, 2175
1132, 2175, 2181, 2176
1133, 2176, 2182, 21
*ELEMENT, type=T3D3, ELSET=Line163
1134, 28, 2185, 2183
1135, 2183, 2186, 2184
1136, 2184, 2187, 34
*ELEMENT, type=T3D3, ELSET=Line164
1137, 5, 2189, 2188
1138, 2188, 2190, 29
*ELEMENT, type=T3D3, ELSET=Line165
1139, 6, 2192, 2191
1140, 2191, 2193, 30
*ELEMENT, type=T3D3, ELSET=Line166
1141, 11, 2195, 2194
1142, 2194, 2196, 27
*ELEMENT, type=T3D3, ELSET=Line167
1143, 13, 2198, 2197
1144, 2197, 2199, 28
*ELEMENT, type=T3D3, ELSET=Line168
1145, 7, 2201, 2200
1146, 2200, 2202, 25
*ELEMENT, type=T3D3, ELSET=Line169
1147, 8, 2204, 2203
1148, 2203, 2205, 26
*ELEMENT, type=T3D3, ELSET=Line170
1149, 14, 2213, 2206
1150, 2206, 2214, 2207
1151, 2207, 2215, 2208
1152, 2208, 2216, 2209
1153, 2209, 2217, 2210
1154, 2210, 2218, 2211
1155, 2211, 2219, 2212
1156, 2212, 2220, 31
*ELEMENT, type=T3D3, ELSET=Line171
1157, 19, 2228, 2221
1158, 2221, 2229, 2222
1159, 2222, 2230, 2223
1160, 2223, 2231, 2224
1161, 2224, 2232, 2225
1162, 2225, 2233, 2226
1163, 2226, 2234, 2227
1164, 2227, 2235, 33
*ELEMENT, type=T3D3, ELSET=Line172
1165, 26, 2241, 2236
1166, 2236, 2242, 2237
1167, 2237, 2243, 2238
1168, 2238, 2244, 2239
1169, 2239, 2245, 2240
1170, 2240, 2246, 35
*ELEMENT, type=T3D3, ELSET=Line173
1171, 1, 2306, 2247
1172, 2247, 2307, 2248
1173, 2248, 2308, 2249
1174, 2249, 2309, 2250
1175, 2250, 2310, 2251
1176, 2251, 2311, 2252
1177, 2252, 2312, 2253
1178, 2253, 2313, 2254
1179, 2254, 2314, 2255
1180, 2255, 2315, 2256
1181, 2256, 2316, 2257
1182, 2257, 2317, 2258
1183, 2258, 2318, 2259
1184, 2259, 2319, 2260
1185, 2260, 2320, 2261
1186, 2261, 2321, 2262
1187, 2262, 2322, 2263
1188, 2263, 2323, 2264
1189, 2264, 2324, 2265
1190, 2265, 2325, 2266
1191, 2266, 2326, 2267
1192, 2267, 2327, 2268
1193, 2268, 2328, 2269
1194, 2269, 2329, 2270
1195, 2270, 2330, 2271
1196, 2271, 2331, 2272
1197, 2272, 2332, 2273
1198, 2273, 2333, 2274
1199, 2274, 2334, 2275
1200, 2275, 2335, 2276
1201, 2276, 2336, 2277
1202, 2277, 2337, 2278
1203, 2278, 2338, 2279
1204, 2279, 2339, 2280
1205, 2280, 2340, 2281
1206, 2281, 2341, 2282
1207, 2282, 2342, 2283
1208, 2283, 2343, 2284
1209, 2284, 2344, 2285
1210, 2285, 2345, 2286
1211, 2286, 2346, 2287
1212, 2287, 2347, 2288
1213, 2288, 2348, 2289
1214, 2289, 2349, 2290
1215, 2290, 2350, 2291
1216, 2291, 2351, 2292
1217, 2292, 2352, 2293
1218, 2293, 2353, 2294
1219, 2294, 2354, 2295
1220, 2295, 2355, 2296
1221, 2296, 2356, 2297
1222, 2297, 2357, 2298
1223, 2298, 2358, 2299
1224, 2299, 2359, 2300
1225, 2300, 2360, 2301
1226, 2301, 2361, 2302
1227, 2302, 2362, 2303
1228, 2303, 2363, 2304
1229, 2304, 2364, 2305
1230, 2305, 2365, 35
*ELEMENT, type=T3D3, ELSET=Line174
1231, 9, 2425, 2366
1232, 2366, 2426, 2367
1233, 2367, 2427, 2368
1234, 2368, 2428, 2369
1235, 2369, 2429, 2370
1236, 2370, 2430, 2371
1237, 2371, 2431, 2372
1238, 2372, 2432, 2373
1239, 2373, 2433, 2374
1240, 2374, 2434, 2375
1241, 2375, 2435, 2376
1242, 2376, 2436, 2377
1243, 2377, 2437, 2378
1244, 2378, 2438, 2379
1245, 2379, 2439, 2380
1246, 2380, 2440, 2381
1247, 2381, 2441, 2382
1248, 2382, 2442, 2383
1249, 2383, 2443, 2384
1250, 2384, 2444, 2385
1251, 2385, 2445, 2386
1252, 2386, 2446, 2387
1253, 2387, 2447, 2388
1254, 2388, 2448, 2389
1255, 2389, 2449, 2390
1256, 2390, 2450, 2391
1257, 2391, 2451, 2392
1258, 2392, 2452, 2393
1259, 2393, 2453, 2394
1260, 2394, 2454, 2395
1261, 2395, 2455, 2396
1262, 2396, 2456, 2397
1263, 2397, 2457, 2398
1264, 2398, 2458, 2399
1265, 2399, 2459, 2400
1266, 2400, 2460, 2401
1267, 2401, 2461, 2402
1268, 2402, 2462, 2403
1269, 2403, 2463, 2404
1270, 2404, 2464, 2405
1271, 2405, 2465, 2406
1272, 2406, 2466, 2407
1273, 2407, 2467, 2408
1274, 2408, 2468, 2409
1275, 2409, 2469, 2410
1276, 2410, 2470, 2411
1277, 2411, 2471, 2412
1278, 2412, 2472, 2413
1279, 2413, 2473, 2414
1280, 2414, 2474, 2415
1281, 2415, 2475, 2416
1282, 2416, 2476, 2417
1283, 2417, 2477, 2418
1284, 2418, 2478, 2419
1285, 2419, 2479, 2420
1286, 2420, 2480, 2421
1287, 2421, 2481, 2422
1288, 2422, 2482, 2423
1289, 2423, 2483, 2424
1290, 2424, 2484, 36
*ELEMENT, type=T3D3, ELSET=Line175
1291, 4, 2490, 2485
1292, 2485, 2491, 2486
1293, 2486, 2492, 2487
1294, 2487, 2493, 2488
1295, 2488, 2494, 2489
1296, 2489, 2495, 36
*ELEMENT, type=T3D3, ELSET=Line176
1297, 35, 2500, 2496
1298, 2496, 2501, 2497
1299, 2497, 2502, 2498
1300, 2498, 2503, 2499
1301, 2499, 2504, 37
*ELEMENT, type=T3D3, ELSET=Line177
1302, 2, 2564, 2505
1303, 2505, 2565, 2506
1304, 2506, 2566, 2507
1305, 2507, 2567, 2508
1306, 2508, 2568, 2509
1307, 2509, 2569, 2510
1308, 2510, 2570, 2511
1309, 2511, 2571, 2512
1310, 2512, 2572, 2513
1311, 2513, 2573, 2514
1312, 2514, 2574, 2515
1313, 2515, 2575, 2516
1314, 2516, 2576, 2517
1315, 2517, 2577, 2518
1316, 2518, 2578, 2519
1317, 2519, 2579, 2520
1318, 2520, 2580, 2521
1319, 2521, 2581, 2522
1320, 2522, 2582, 2523
1321, 2523, 2583, 2524
1322, 2524, 2584, 2525
1323, 2525, 2585, 2526
1324, 2526, 2586, 2527
1325, 2527, 2587, 2528
1326, 2528, 2588, 2529
1327, 2529, 2589, 2530
1328, 2530, 2590, 2531
1329, 2531, 2591, 2532
1330, 2532, 2592, 2533
1331, 2533, 2593, 2534
1332, 2534, 2594, 2535
1333, 2535, 2595, 2536
1334, 2536, 2596, 2537
1335, 2537, 2597, 2538
1336, 2538, 2598, 2539
1337, 2539, 2599, 2540
1338, 2540, 2600, 2541
1339, 2541, 2601, 2542
1340, 2542, 2602, 2543
1341, 2543, 2603, 2544
1342, 2544, 2604, 2545
1343, 2545, 2605, 2546
1344, 2546, 2606, 2547
1345, 2547, 2607, 2548
1346, 2548, 2608, 2549
1347, 2549, 2609, 2550
1348, 2550, 2610, 2551
1349, 2551, 2611, 2552
1350, 2552, 2612, 2553
1351, 2553, 2613, 2554
1352, 2554, 2614, 2555
1353, 2555, 2615, 2556
1354, 2556, 2616, 2557
1355, 2557, 2617, 2558
1356, 2558, 2618, 2559
1357, 2559, 2619, 2560
1358, 2560, 2620, 2561
1359, 2561, 2621, 2562
1360, 2562, 2622, 2563
1361, 2563, 2623, 37
*ELEMENT, type=T3D3, ELSET=Line178
1362, 38, 2628, 2624
1363, 2624, 2629, 2625
1364, 2625, 2630, 2626
1365, 2626, 2631, 2627
1366, 2627, 2632, 36
*ELEMENT, type=T3D3, ELSET=Line179
1367, 23, 2692, 2633
1368, 2633, 2693, 2634
1369, 2634, 2694, 2635
1370, 2635, 2695, 2636
1371, 2636, 2696, 2637
1372, 2637, 2697, 2638
1373, 2638, 2698, 2639
1374, 2639, 2699, 2640
1375, 2640, 2700, 2641
1376, 2641, 2701, 2642
1377, 2642, 2702, 2643
1378, 2643, 2703, 2644
1379, 2644, 2704, 2645
1380, 2645, 2705, 2646
1381, 2646, 2706, 2647
1382, 2647, 2707, 2648
1383, 2648, 2708, 2649
1384, 2649, 2709, 2650
1385, 2650, 2710, 2651
1386, 2651, 2711, 2652
1387, 2652, 2712, 2653
1388, 2653, 2713, 2654
1389, 2654, 2714, 2655
1390, 2655, 2715, 2656
1391, 2656, 2716, 2657
1392, 2657, 2717, 2658
1393, 2658, 2718, 2659
1394, 2659, 2719, 2660
1395, 2660, 2720, 2661
1396, 2661, 2721, 2662
1397, 2662, 2722, 2663
1398, 2663, 2723, 2664
1399, 2664, 2724, 2665
1400, 2665, 2725, 2666
1401, 2666, 2726, 2667
1402, 2667, 2727, 2668
1403, 2668, 2728, 2669
1404, 2669, 2729, 2670
1405, 2670, 2730, 2671
1406, 2671, 2731, 2672
1407, 2672, 2732, 2673
1408, 2673, 2733, 2674
1409, 2674, 2734, 2675
1410, 2675, 2735, 2676
1411, 2676, 2736, 2677
1412, 2677, 2737, 2678
1413, 2678, 2738, 2679
1414, 2679, 2739, 2680
1415, 2680, 2740, 2681
1416, 2681, 2741, 2682
1417, 2682, 2742, 2683
1418, 2683, 2743, 2684
1419, 2684, 2744, 2685
1420, 2685, 2745, 2686
1421, 2686, 2746, 2687
1422, 2687, 2747, 2688
1423, 2688, 2748, 2689
1424, 2689, 2749, 2690
1425, 2690, 2750, 2691
1426, 2691, 2751, 38
*ELEMENT, type=T3D3, ELSET=Line180
1427, 39, 2754, 2752
1428, 2752, 2755, 2753
1429, 2753, 2756, 38
*ELEMENT, type=T3D3, ELSET=Line181
1430, 40, 2759, 2757
1431, 2757, 2760, 2758
1432, 2758, 2761, 36
*ELEMENT, type=T3D3, ELSET=Line182
1433, 39, 2766, 2762
1434, 2762, 2767, 2763
1435, 2763, 2768, 2764
1436, 2764, 2769, 2765
1437, 2765, 2770, 40
*ELEMENT, type=T3D3, ELSET=Line183
1438, 41, 2773, 2771
1439, 2771, 2774, 2772
1440, 2772, 2775, 35
*ELEMENT, type=T3D3, ELSET=Line184
1441, 42, 2778, 2776
1442, 2776, 2779, 2777
1443, 2777, 2780, 37
*ELEMENT, type=T3D3, ELSET=Line185
1444, 41, 2785, 2781
1445, 2781, 2786, 2782
1446, 2782, 2787, 2783
1447, 2783, 2788, 2784
1448, 2784, 2789, 42
*ELEMENT, type=CPS8, ELSET=Surface1
1449, 5, 171, 2790, 586, 230, 6271, 6272, 646
1450, 586, 2790, 2791, 585, 6272, 6273, 6274, 645
1451, 585, 2791, 2792, 584, 6274, 6275, 6276, 644
1452, 584, 2792, 2793, 583, 6276, 6277, 6278, 643
1453, 583, 2793, 2794, 582, 6278, 6279, 6280, 642
1454, 582, 2794, 2795, 581, 6280, 6281, 6282, 641
1455, 581, 2795, 2796, 580, 6282, 6283, 6284, 640
1456, 580, 2796, 2797, 579, 6284, 6285, 6286, 639
1457, 579, 2797, 2798, 578, 6286, 6287, 6288, 638
1458, 578, 2798, 2799, 577, 6288, 6289, 6290, 637
1459, 577, 2799, 2800, 576, 6290, 6291, 6292, 636
1460, 576, 2800, 2801, 575, 6292, 6293, 6294, 635
1461, 575, 2801, 2802, 574, 6294, 6295, 6296, 634
1462, 574, 2802, 2803, 573, 6296, 6297, 6298, 633
1463, 573, 2803, 2804, 572, 6298, 6299, 6300, 632
1464, 572, 2804, 2805, 571, 6300, 6301, 6302, 631
1465, 571, 2805, 2806, 570, 6302, 6303, 6304, 630
1466, 570, 2806, 2807, 569, 6304, 6305, 6306, 629
1467, 569, 2807, 2808, 568, 6306, 6307, 6308, 628
1468, 568, 2808, 2809, 567, 6308, 6309, 6310, 627
1469, 567, 2809, 2810, 566, 6310, 6311, 6312, 626
1470, 566, 2810, 2811, 565, 6312, 6313, 6314, 625
1471, 565, 2811, 2812, 564, 6314, 6315, 6316, 624
1472, 564, 2812, 2813, 563, 6316, 6317, 6318, 623
1473, 563, 2813, 2814, 562, 6318, 6319, 6320, 622
1474, 562, 2814, 2815, 561, 6320, 6321, 6322, 621
1475, 561, 2815, 2816, 560, 6322, 6323, 6324, 620
1476, 560, 2816, 2817, 559, 6324, 6325, 6326, 619
1477, 559, 2817, 2818, 558, 6326, 6327, 6328, 618
1478, 558, 2818, 2819, 557, 6328, 6329, 6330, 617
1479, 557, 2819, 2820, 556, 6330, 6331, 6332, 616
1480, 556, 2820, 2821, 555, 6332, 6333, 6334, 615
1481, 555, 2821, 2822, 554, 6334, 6335, 6336, 614
1482, 554, 2822, 2823, 553, 6336, 6337, 6338, 613
1483, 553, 2823, 2824, 552, 6338, 6339, 6340, 612
1484, 552, 2824, 2825, 551, 6340, 6341, 6342, 611
1485, 551, 2825, 2826, 550, 6342, 6343, 6344, 610
1486, 550, 2826, 2827, 549, 6344, 6345, 6346, 609
1487, 549, 2827, 2828, 548, 6346, 6347, 6348, 608
1488, 548, 2828, 2829, 547, 6348, 6349, 6350, 607
1489, 547, 2829, 2830, 546, 6350, 6351, 6352, 606
1490, 546, 2830, 2831, 545, 6352, 6353, 6354, 605
1491, 545, 2831, 2832, 544, 6354, 6355, 6356, 604
1492, 544, 2832, 2833, 543, 6356, 6357, 6358, 603
1493, 543, 2833, 2834, 542, 6358, 6359, 6360, 602
1494, 542, 2834, 2835, 541, 6360, 6361, 6362, 601
1495, 541, 2835, 2836, 540, 6362, 6363, 6364, 600
1496, 540, 2836, 2837, 539, 6364, 6365, 6366, 599
1497, 539, 2837, 2838, 538, 6366, 6367, 6368, 598
1498, 538, 2838, 2839, 537, 6368, 6369, 6370, 597
1499, 537, 2839, 2840, 536, 6370, 6371, 6372, 596
1500, 536, 2840, 2841, 535, 6372, 6373, 6374, 595
1501, 535, 2841, 2842, 534, 6374, 6375, 6376, 594
1502, 534, 2842, 2843, 533, 6376, 6377, 6378, 593
1503, 533, 2843, 2844, 532, 6378, 6379, 6380, 592
1504, 532, 2844, 2845, 531, 6380, 6381, 6382, 591
1505, 531, 2845, 2846, 530, 6382, 6383, 6384, 590
1506, 530, 2846, 2847, 529, 6384, 6385, 6386, 589
1507, 529, 2847, 2848, 528, 6386, 6387, 6388, 588
1508, 528, 2848, 467, 8, 6388, 6389, 527, 587
1509, 171, 172, 2849, 2790, 231, 6390, 6391, 6271
1510, 2790, 2849, 2850, 2791, 6391, 6392, 6393, 6273
1511, 2791, 2850, 2851, 2792, 6393, 6394, 6395, 6275
1512, 2792, 2851, 2852, 2793, 6395, 6396, 6397, 6277
1513, 2793, 2852, 2853, 2794, 6397, 6398, 6399, 6279
1514, 2794, 2853, 2854, 2795, 6399, 6400, 6401, 6281
1515, 2795, 2854, 2855, 2796, 6401, 6402, 6403, 6283
1516, 2796, 2855, 2856, 2797, 6403, 6404, 6405, 6285
1517, 2797, 2856, 2857, 2798, 6405, 6406, 6407, 6287
1518, 2798, 2857, 2858, 2799, 6407, 6408, 6409, 6289
1519, 2799, 2858, 2859, 2800, 6409, 6410, 6411, 6291
1520, 2800, 2859, 2860, 2801, 6411, 6412, 6413, 6293
1521, 2801, 2860, 2861, 2802, 6413, 6414, 6415, 6295
1522, 2802, 2861, 2862, 2803, 6415, 6416, 6417, 6297
1523, 2803, 2862, 2863, 2804, 6417, 6418, 6419, 6299
1524, 2804, 2863, 2864, 2805, 6419, 6420, 6421, 6301
1525, 2805, 2864, 2865, 2806, 6421, 6422, 6423, 6303
1526, 2806, 2865, 2866, 2807, 6423, 6424, 6425, 6305
1527, 2807, 2866, 2867, 2808, 6425, 6426, 6427, 6307
1528, 2808, 2867, 2868, 2809, 6427, 6428, 6429, 6309
1529, 2809, 2868, 2869, 2810, 6429, 6430, 6431, 6311
1530, 2810, 2869, 2870, 2811, 6431, 6432, 6433, 6313
1531, 2811, 2870, 2871, 2812, 6433, 6434, 6435, 6315
1532, 2812, 2871, 2872, 2813, 6435, 6436, 6437, 6317
1533, 2813, 2872, 2873, 2814, 6437, 6438, 6439, 6319
1534, 2814, 2873, 2874, 2815, 6439, 6440, 6441, 6321
1535, 2815, 2874, 2875, 2816, 6441, 6442, 6443, 6323
1536, 2816, 2875, 2876, 2817, 6443, 6444, 6445, 6325
1537, 2817, 2876, 2877, 2818, 6445, 6446, 6447, 6327
1538, 2818, 2877, 2878, 2819, 6447, 6448, 6449, 6329
1539, 2819, 2878, 2879, 2820, 6449, 6450, 6451, 6331
1540, 2820, 2879, 2880, 2821, 6451, 6452, 6453, 6333
1541, 2821, 2880, 2881, 2822, 6453, 6454, 6455, 6335
1542, 2822, 2881, 2882, 2823, 6455, 6456, 6457, 6337
1543, 2823, 2882, 2883, 2824, 6457, 6458, 6459, 6339
1544, 2824, 2883, 2884, 2825, 6459, 6460, 6461, 6341
1545, 2825, 2884, 2885, 2826, 6461, 6462, 6463, 6343
1546, 2826, 2885, 2886, 2827, 6463, 6464, 6465, 6345
1547, 2827, 2886, 2887, 2828, 6465, 6466, 6467, 6347
1548, 2828, 2887, 2888, 2829, 6467, 6468, 6469, 6349
1549, 2829, 2888, 2889, 2830, 6469, 6470, 6471, 6351
1550, 2830, 2889, 2890, 2831, 6471, 6472, 6473, 6353
1551, 2831, 2890, 2891, 2832, 6473, 6474, 6475, 6355
1552, 2832, 2891, 2892, 2833, 6475, 6476, 6477, 6357
1553, 2833, 2892, 2893, 2834, 6477, 6478, 6479, 6359
1554, 2834, 2893, 2894, 2835, 6479, 6480, 6481, 6361
1555, 2835, 2894, 2895, 2836, 6481, 6482, 6483, 6363
1556, 2836, 2895, 2896, 2837, 6483, 6484, 6485, 6365
1557, 2837, 2896, 2897, 2838, 6485, 6486, 6487, 6367
1558, 2838, 2897, 2898, 2839, 6487, 6488, 6489, 6369
1559, 2839, 2898, 2899, 2840, 6489, 6490, 6491, 6371
1560, 2840, 2899, 2900, 2841, 6491, 6492, 6493, 6373
1561, 2841, 2900, 2901, 2842, 6493, 6494, 6495, 6375
1562, 2842, 2901, 2902, 2843, 6495, 6496, 6497, 6377
1563, 2843, 2902, 2903, 2844, 6497, 6498, 6499, 6379
1564, 2844, 2903, 2904, 2845, 6499, 6500, 6501, 6381
1565, 2845, 2904, 2905, 2846, 6501, 6502, 6503, 6383
1566, 2846, 2905, 2906, 2847, 6503, 6504, 6505, 6385
1567, 2847, 2906, 2907, 2848, 6505, 6506, 6507, 6387
1568, 2848, 2907, 466, 467, 6507, 6508, 526, 6389
1569, 172, 173, 2908, 2849, 232, 6509, 6510, 6390
1570, 2849, 2908, 2909, 2850, 6510, 6511, 6512, 6392
1571, 2850, 2909, 2910, 2851, 6512, 6513, 6514, 6394
1572, 2851, 2910, 2911, 2852, 6514, 6515, 6516, 6396
1573, 2852, 2911, 2912, 2853, 6516, 6517, 6518, 6398
1574, 2853, 2912, 2913, 2854, 6518, 6519, 6520, 6400
1575, 2854, 2913, 2914, 2855, 6520, 6521, 6522, 6402
1576, 2855, 2914, 2915, 2856, 6522, 6523, 6524, 6404
1577, 2856, 2915, 2916, 2857, 6524, 6525, 6526, 6406
1578, 2857, 2916, 2917, 2858, 6526, 6527, 6528, 6408
1579, 2858, 2917, 2918, 2859, 6528, 6529, 6530, 6410
1580, 2859, 2918, 2919, 2860, 6530, 6531, 6532, 6412
1581, 2860, 2919, 2920, 2861, 6532, 6533, 6534, 6414
1582, 2861, 2920, 2921, 2862, 6534, 6535, 6536, 6416
1583, 2862, 2921, 2922, 2863, 6536, 6537, 6538, 6418
1584, 2863, 2922, 2923, 2864, 6538, 6539, 6540, 6420
1585, 2864, 2923, 2924, 2865, 6540, 6541, 6542, 6422
1586, 2865, 2924, 2925, 2866, 6542, 6543, 6544, 6424
1587, 2866, 2925, 2926, 2867, 6544, 6545, 6546, 6426
1588, 2867, 2926, 2927, 2868, 6546, 6547, 6548, 6428
1589, 2868, 2927, 2928, 2869, 6548, 6549, 6550, 6430
1590, 2869, 2928, 2929, 2870, 6550, 6551, 6552, 6432
1591, 2870, 2929, 2930, 2871, 6552, 6553, 6554, 6434
1592, 2871, 2930, 2931, 2872, 6554, 6555, 6556, 6436
1593, 2872, 2931, 2932, 2873, 6556, 6557, 6558, 6438
1594, 2873, 2932, 2933, 2874, 6558, 6559, 6560, 6440
1595, 2874, 2933, 2934, 2875, 6560, 6561, 6562, 6442
1596, 2875, 2934, 2935, 2876, 6562, 6563, 6564, 6444
1597, 2876, 2935, 2936, 2877, 6564, 6565, 6566, 6446
1598, 2877, 2936, 2937, 2878, 6566, 6567, 6568, 6448
1599, 2878, 2937, 2938, 2879, 6568, 6569, 6570, 6450
1600, 2879, 2938, 2939, 2880, 6570, 6571, 6572, 6452
1601, 2880, 2939, 2940, 2881, 6572, 6573, 6574, 6454
1602, 2881, 2940, 2941, 2882, 6574, 6575, 6576, 6456
1603, 2882, 2941, 2942, 2883, 6576, 6577, 6578, 6458
1604, 2883, 2942, 2943, 2884, 6578, 6579, 6580, 6460
1605, 2884, 2943, 2944, 2885, 6580, 6581, 6582, 6462
1606, 2885, 2944, 2945, 2886, 6582, 6583, 6584, 6464
1607, 2886, 2945, 2946, 2887, 6584, 6585, 6586, 6466
1608, 2887, 2946, 2947, 2888, 6586, 6587, 6588, 6468
1609, 2888, 2947, 2948, 2889, 6588, 6589, 6590, 6470
1610, 2889, 2948, 2949, 2890, 6590, 6591, 6592, 6472
1611, 2890, 2949, 2950, 2891, 6592, 6593, 6594, 6474
1612, 2891, 2950, 2951, 2892, 6594, 6595, 6596, 6476
1613, 2892, 2951, 2952, 2893, 6596, 6597, 6598, 6478
1614, 2893, 2952, 2953, 2894, 6598, 6599, 6600, 6480
1615, 2894, 2953, 2954, 2895, 6600, 6601, 6602, 6482
1616, 2895, 2954, 2955, 2896, 6602, 6603, 6604, 6484
1617, 2896, 2955, 2956, 2897, 6604, 6605, 6606, 6486
1618, 2897, 2956, 2957, 2898, 6606, 6607, 6608, 6488
1619, 2898, 2957, 2958, 2899, 6608, 6609, 6610, 6490
1620, 2899, 2958, 2959, 2900, 6610, 6611, 6612, 6492
1621, 2900, 2959, 2960, 2901, 6612, 6613, 6614, 6494
1622, 2901, 2960, 2961, 2902, 6614, 6615, 6616, 6496
1623, 2902, 2961, 2962, 2903, 6616, 6617, 6618, 6498
1624, 2903, 2962, 2963, 2904, 6618, 6619, 6620, 6500
1625, 2904, 2963, 2964, 2905, 6620, 6621, 6622, 6502
1626, 2905, 2964, 2965, 2906, 6622, 6623, 6624, 6504
1627, 2906, 2965, 2966, 2907, 6624, 6625, 6626, 6506
1628, 2907, 2966, 465, 466, 6626, 6627, 525, 6508
1629, 173, 174, 2967, 2908, 233, 6628, 6629, 6509
1630, 2908, 2967, 2968, 2909, 6629, 6630, 6631, 6511
1631, 2909, 2968, 2969, 2910, 6631, 6632, 6633, 6513
1632, 2910, 2969, 2970, 2911, 6633, 6634, 6635, 6515
1633, 2911, 2970, 2971, 2912, 6635, 6636, 6637, 6517
1634, 2912, 2971, 2972, 2913, 6637, 6638, 6639, 6519
1635, 2913, 2972, 2973, 2914, 6639, 6640, 6641, 6521
1636, 2914, 2973, 2974, 2915, 6641, 6642, 6643, 6523
1637, 2915, 2974, 2975, 2916, 6643, 6644, 6645, 6525
1638, 2916, 2975, 2976, 2917, 6645, 6646, 6647, 6527
1639, 2917, 2976, 2977, 2918, 6647, 6648, 6649, 6529
1640, 2918, 2977, 2978, 2919, 6649, 6650, 6651, 6531
1641, 2919, 2978, 2979, 2920, 6651, 6652, 6653, 6533
1642, 2920, 2979, 2980, 2921, 6653, 6654, 6655, 6535
1643, 2921, 2980, 2981, 2922, 6655, 6656, 6657, 6537
1644, 2922, 2981, 2982, 2923, 6657, 6658, 6659, 6539
1645, 2923, 2982, 2983, 2924, 6659, 6660, 6661, 6541
1646, 2924, 2983, 2984, 2925, 6661, 6662, 6663, 6543
1647, 2925, 2984, 2985, 2926, 6663, 6664, 6665, 6545
1648, 2926, 2985, 2986, 2927, 6665, 6666, 6667, 6547
1649, 2927, 2986, 2987, 2928, 6667, 6668, 6669, 6549
1650, 2928, 2987, 2988, 2929, 6669, 6670, 6671, 6551
1651, 2929, 2988, 2989, 2930, 6671, 6672, 6673, 6553
1652, 2930, 2989, 2990, 2931, 6673, 6674, 6675, 6555
1653, 2931, 2990, 2991, 2932, 6675, 6676, 6677, 6557
1654, 2932, 2991, 2992, 2933, 6677, 6678, 6679, 6559
1655, 2933, 2992, 2993, 2934, 6679, 6680, 6681, 6561
1656, 2934, 2993, 2994, 2935, 6681, 6682, 6683, 6563
1657, 2935, 2994, 2995, 2936, 6683, 6684, 6685, 6565
1658, 2936, 2995, 2996, 2937, 6685, 6686, 6687, 6567
1659, 2937, 2996, 2997, 2938, 6687, 6688, 6689, 6569
1660, 2938, 2997, 2998, 2939, 6689, 6690, 6691, 6571
1661, 2939, 2998, 2999, 2940, 6691, 6692, 6693, 6573
1662, 2940, 2999, 3000, 2941, 6693, 6694, 6695, 6575
1663, 2941, 3000, 3001, 2942, 6695, 6696, 6697, 6577
1664, 2942, 3001, 3002, 2943, 6697, 6698, 6699, 6579
1665, 2943, 3002, 3003, 2944, 6699, 6700, 6701, 6581
1666, 2944, 3003, 3004, 2945, 6701, 6702, 6703, 6583
1667, 2945, 3004, 3005, 2946, 6703, 6704, 6705, 6585
1668, 2946, 3005, 3006, 2947, 6705, 6706, 6707, 6587
1669, 2947, 3006, 3007, 2948, 6707, 6708, 6709, 6589
1670, 2948, 3007, 3008, 2949, 6709, 6710, 6711, 6591
1671, 2949, 3008, 3009, 2950, 6711, 6712, 6713, 6593
1672, 2950, 3009, 3010, 2951, 6713, 6714, 6715, 6595
1673, 2951, 3010, 3011, 2952, 6715, 6716, 6717, 6597
1674, 2952, 3011, 3012, 2953, 6717, 6718, 6719, 6599
1675, 2953, 3012, 3013, 2954, 6719, 6720, 6721, 6601
1676, 2954, 3013, 3014, 2955, 6721, 6722, 6723, 6603
1677, 2955, 3014, 3015, 2956, 6723, 6724, 6725, 6605
1678, 2956, 3015, 3016, 2957, 6725, 6726, 6727, 6607
1679, 2957, 3016, 3017, 2958, 6727, 6728, 6729, 6609
1680, 2958, 3017, 3018, 2959, 6729, 6730, 6731, 6611
1681, 2959, 3018, 3019, 2960, 6731, 6732, 6733, 6613
1682, 2960, 3019, 3020, 2961, 6733, 6734, 6735, 6615
1683, 2961, 3020, 3021, 2962, 6735, 6736, 6737, 6617
1684, 2962, 3021, 3022, 2963, 6737, 6738, 6739, 6619
1685, 2963, 3022, 3023, 2964, 6739, 6740, 6741, 6621
1686, 2964, 3023, 3024, 2965, 6741, 6742, 6743, 6623
1687, 2965, 3024, 3025, 2966, 6743, 6744, 6745, 6625
1688, 2966, 3025, 464, 465, 6745, 6746, 524, 6627
1689, 174, 175, 3026, 2967, 234, 6747, 6748, 6628
1690, 2967, 3026, 3027, 2968, 6748, 6749, 6750, 6630
1691, 2968, 3027, 3028, 2969, 6750, 6751, 6752, 6632
1692, 2969, 3028, 3029, 2970, 6752, 6753, 6754, 6634
1693, 2970, 3029, 3030, 2971, 6754, 6755, 6756, 6636
1694, 2971, 3030, 3031, 2972, 6756, 6757, 6758, 6638
1695, 2972, 3031, 3032, 2973, 6758, 6759, 6760, 6640
1696, 2973, 3032, 3033, 2974, 6760, 6761, 6762, 6642
1697, 2974, 3033, 3034, 2975, 6762, 6763, 6764, 6644
1698, 2975, 3034, 3035, 2976, 6764, 6765, 6766, 6646
1699, 2976, 3035, 3036, 2977, 6766, 6767, 6768, 6648
1700, 2977, 3036, 3037, 2978, 6768, 6769, 6770, 6650
1701, 2978, 3037, 3038, 2979, 6770, 6771, 6772, 6652
1702, 2979, 3038, 3039, 2980, 6772, 6773, 6774, 6654
1703, 2980, 3039, 3040, 2981, 6774, 6775, 6776, 6656
1704, 2981, 3040, 3041, 2982, 6776, 6777, 6778, 6658
1705, 2982, 3041, 3042, 2983, 6778, 6779, 6780, 6660
1706, 2983, 3042, 3043, 2984, 6780, 6781, 6782, 6662
1707, 2984, 3043, 3044, 2985, 6782, 6783, 6784, 6664
1708, 2985, 3044, 3045, 2986, 6784, 6785, 6786, 6666
1709, 2986, 3045, 3046, 2987, 6786, 6787, 6788, 6668
1710, 2987, 3046, 3047, 2988, 6788, 6789, 6790, 6670
1711, 2988, 3047, 3048, 2989, 6790, 6791, 6792, 6672
1712, 2989, 3048, 3049, 2990, 6792, 6793, 6794, 6674
1713, 2990, 3049, 3050, 2991, 6794, 6795, 6796, 6676
1714, 2991, 3050, 3051, 2992, 6796, 6797, 6798, 6678
1715, 2992, 3051, 3052, 2993, 6798, 6799, 6800, 6680
1716, 2993, 3052, 3053, 2994, 6800, 6801, 6802, 6682
1717, 2994, 3053, 3054, 2995, 6802, 6803, 6804, 6684
1718, 2995, 3054, 3055, 2996, 6804, 6805, 6806, 6686
1719, 2996, 3055, 3056, 2997, 6806, 6807, 6808, 6688
1720, 2997, 3056, 3057, 2998, 6808, 6809, 6810, 6690
1721, 2998, 3057, 3058, 2999, 6810, 6811, 6812, 6692
1722, 2999, 3058, 3059, 3000, 6812, 6813, 6814, 6694
1723, 3000, 3059, 3060, 3001, 6814, 6815, 6816, 6696
1724, 3001, 3060, 3061, 3002, 6816, 6817, 6818, 6698
1725, 3002, 3061, 3062, 3003, 6818, 6819, 6820, 6700
1726, 3003, 3062, 3063, 3004, 6820, 6821, 6822, 6702
1727, 3004, 3063, 3064, 3005, 6822, 6823, 6824, 6704
1728, 3005, 3064, 3065, 3006, 6824, 6825, 6826, 6706
1729, 3006, 3065, 3066, 3007, 6826, 6827, 6828, 6708
1730, 3007, 3066, 3067, 3008, 6828, 6829, 6830, 6710
1731, 3008, 3067, 3068, 3009, 6830, 6831, 6832, 6712
1732, 3009, 3068, 3069, 3010, 6832, 6833, 6834, 6714
1733, 3010, 3069, 3070, 3011, 6834, 6835, 6836, 6716
1734, 3011, 3070, 3071, 3012, 6836, 6837, 6838, 6718
1735, 3012, 3071, 3072, 3013, 6838, 6839, 6840, 6720
1736, 3013, 3072, 3073, 3014, 6840, 6841, 6842, 6722
1737, 3014, 3073, 3074, 3015, 6842, 6843, 6844, 6724
1738, 3015, 3074, 3075, 3016, 6844, 6845, 6846, 6726
1739, 3016, 3075, 3076, 3017, 6846, 6847, 6848, 6728
1740, 3017, 3076, 3077, 3018, 6848, 6849, 6850, 6730
1741, 3018, 3077, 3078, 3019, 6850, 6851, 6852, 6732
1742, 3019, 3078, 3079, 3020, 6852, 6853, 6854, 6734
1743, 3020, 3079, 3080, 3021, 6854, 6855, 6856, 6736
1744, 3021, 3080, 3081, 3022, 6856, 6857, 6858, 6738
1745, 3022, 3081, 3082, 3023, 6858, 6859, 6860, 6740
1746, 3023, 3082, 3083, 3024, 6860, 6861, 6862, 6742
1747, 3024, 3083, 3084, 3025, 6862, 6863, 6864, 6744
1748, 3025, 3084, 463, 464, 6864, 6865, 523, 6746
1749, 175, 176, 3085, 3026, 235, 6866, 6867, 6747
1750, 3026, 3085, 3086, 3027, 6867, 6868, 6869, 6749
1751, 3027, 3086, 3087, 3028, 6869, 6870, 6871, 6751
1752, 3028, 3087, 3088, 3029, 6871, 6872, 6873, 6753
1753, 3029, 3088, 3089, 3030, 6873, 6874, 6875, 6755
1754, 3030, 3089, 3090, 3031, 6875, 6876, 6877, 6757
1755, 3031, 3090, 3091, 3032, 6877, 6878, 6879, 6759
1756, 3032, 3091, 3092, 3033, 6879, 6880, 6881, 6761
1757, 3033, 3092, 3093, 3034, 6881, 6882, 6883, 6763
1758, 3034, 3093, 3094, 3035, 6883, 6884, 6885, 6765
1759, 3035, 3094, 3095, 3036, 6885, 6886, 6887, 6767
1760, 3036, 3095, 3096, 3037, 6887, 6888, 6889, 6769
1761, 3037, 3096, 3097, 3038, 6889, 6890, 6891, 6771
1762, 3038, 3097, 3098, 3039, 6891, 6892, 6893, 6773
1763, 3039, 3098, 3099, 3040, 6893, 6894, 6895, 6775
1764, 3040, 3099, 3100, 3041, 6895, 6896, 6897, 6777
1765, 3041, 3100, 3101, 3042, 6897, 6898, 6899, 6779
1766, 3042, 3101, 3102, 3043, 6899, 6900, 6901, 6781
1767, 3043, 3102, 3103, 3044, 6901, 6902, 6903, 6783
1768, 3044, 3103, 3104, 3045, 6903, 6904, 6905, 6785
1769, 3045, 3104, 3105, 3046, 6905, 6906, 6907, 6787
1770, 3046, 3105, 3106, 3047, 6907, 6908, 6909, 6789
1771, 3047, 3106, 3107, 3048, 6909, 6910, 6911, 6791
1772, 3048, 3107, 3108, 3049, 6911, 6912, 6913, 6793
1773, 3049, 3108, 3109, 3050, 6913, 6914, 6915, 6795
1774, 3050, 3109, 3110, 3051, 6915, 6916, 6917, 6797
1775, 3051, 3110, 3111, 3052, 6917, 6918, 6919, 6799
1776, 3052, 3111, 3112, 3053, 6919, 6920, 6921, 6801
1777, 3053, 3112, 3113, 3054, 6921, 6922, 6923, 6803
1778, 3054, 3113, 3114, 3055, 6923, 6924, 6925, 6805
1779, 3055, 3114, 3115, 3056, 6925, 6926, 6927, 6807
1780, 3056, 3115, 3116, 3057, 6927, 6928, 6929, 6809
1781, 3057, 3116, 3117, 3058, 6929, 6930, 6931, 6811
1782, 3058, 3117, 3118, 3059, 6931, 6932, 6933, 6813
1783, 3059, 3118, 3119, 3060, 6933, 6934, 6935, 6815
1784, 3060, 3119, 3120, 3061, 6935, 6936, 6937, 6817
1785, 3061, 3120, 3121, 3062, 6937, 6938, 6939, 6819
1786, 3062, 3121, 3122, 3063, 6939, 6940, 6941, 6821
1787, 3063, 3122, 3123, 3064, 6941, 6942, 6943, 6823
1788, 3064, 3123, 3124, 3065, 6943, 6944, 6945, 6825
1789, 3065, 3124, 3125, 3066, 6945, 6946, 6947, 6827
1790, 3066, 3125, 3126, 3067, 6947, 6948, 6949, 6829
1791, 3067, 3126, 3127, 3068, 6949, 6950, 6951, 6831
1792, 3068, 3127, 3128, 3069, 6951, 6952, 6953, 6833
1793, 3069, 3128, 3129, 3070, 6953, 6954, 6955, 6835
1794, 3070, 3129, 3130, 3071, 6955, 6956, 6957, 6837
1795, 3071, 3130, 3131, 3072, 6957, 6958, 6959, 6839
1796, 3072, 3131, 3132, 3073, 6959, 6960, 6961, 6841
1797, 3073, 3132, 3133, 3074, 6961, 6962, 6963, 6843
1798, 3074, 3133, 3134, 3075, 6963, 6964, 6965, 6845
1799, 3075, 3134, 3135, 3076, 6965, 6966, 6967, 6847
1800, 3076, 3135, 3136, 3077, 6967, 6968, 6969, 6849
1801, 3077, 3136, 3137, 3078, 6969, 6970, 6971, 6851
1802, 3078, 3137, 3138, 3079, 6971, 6972, 6973, 6853
1803, 3079, 3138, 3139, 3080, 6973, 6974, 6975, 6855
1804, 3080, 3139, 3140, 3081, 6975, 6976, 6977, 6857
1805, 3081, 3140, 3141, 3082, 6977, 6978, 6979, 6859
1806, 3082, 3141, 3142, 3083, 6979, 6980, 6981, 6861
1807, 3083, 3142, 3143, 3084, 6981, 6982, 6983, 6863
1808, 3084, 3143, 462, 463, 6983, 6984, 522, 6865
1809, 176, 177, 3144, 3085, 236, 6985, 6986, 6866
1810, 3085, 3144, 3145, 3086, 6986, 6987, 6988, 6868
1811, 3086, 3145, 3146, 3087, 6988, 6989, 6990, 6870
1812, 3087, 3146, 3147, 3088, 6990, 6991, 6992, 6872
1813, 3088, 3147, 3148, 3089, 6992, 6993, 6994, 6874
1814, 3089, 3148, 3149, 3090, 6994, 6995, 6996, 6876
1815, 3090, 3149, 3150, 3091, 6996, 6997, 6998, 6878
1816, 3091, 3150, 3151, 3092, 6998, 6999, 7000, 6880
1817, 3092, 3151, 3152, 3093, 7000, 7001, 7002, 6882
1818, 3093, 3152, 3153, 3094, 7002, 7003, 7004, 6884
1819, 3094, 3153, 3154, 3095, 7004, 7005, 7006, 6886
1820, 3095, 3154, 3155, 3096, 7006, 7007, 7008, 6888
1821, 3096, 3155, 3156, 3097, 7008, 7009, 7010, 6890
1822, 3097, 3156, 3157, 3098, 7010, 7011, 7012, 6892
1823, 3098, 3157, 3158, 3099, 7012, 7013, 7014, 6894
1824, 3099, 3158, 3159, 3100, 7014, 7015, 7016, 6896
1825, 3100, 3159, 3160, 3101, 7016, 7017, 7018, 6898
1826, 3101, 3160, 3161, 3102, 7018, 7019, 7020, 6900
1827, 3102, 3161, 3162, 3103, 7020, 7021, 7022, 6902
1828, 3103, 3162, 3163, 3104, 7022, 7023, 7024, 6904
1829, 3104, 3163, 3164, 3105, 7024, 7025, 7026, 6906
1830, 3105, 3164, 3165, 3106, 7026, 7027, 7028, 6908
1831, 3106, 3165, 3166, 3107, 7028, 7029, 7030, 6910
1832, 3107, 3166, 3167, 3108, 7030, 7031, 7032, 6912
1833, 3108, 3167, 3168, 3109, 7032, 7033, 7034, 6914
1834, 3109, 3168, 3169, 3110, 7034, 7035, 7036, 6916
1835, 3110, 3169, 3170, 3111, 7036, 7037, 7038, 6918
1836, 3111, 3170, 3171, 3112, 7038, 7039, 7040, 6920
1837, 3112, 3171, 3172, 3113, 7040, 7041, 7042, 6922
1838, 3113, 3172, 3173, 3114, 7042, 7043, 7044, 6924
1839, 3114, 3173, 3174, 3115, 7044, 7045, 7046, 6926
1840, 3115, 3174, 3175, 3116, 7046, 7047, 7048, 6928
1841, 3116, 3175, 3176, 3117, 7048, 7049, 7050, 6930
1842, 3117, 3176, 3177, 3118, 7050, 7051, 7052, 6932
1843, 3118, 3177, 3178, 3119, 7052, 7053, 7054, 6934
1844, 3119, 3178, 3179, 3120, 7054, 7055, 7056, 6936
1845, 3120, 3179, 3180, 3121, 7056, 7057, 7058, 6938
1846, 3121, 3180, 3181, 3122, 7058, 7059, 7060, 6940
1847, 3122, 3181, 3182, 3123, 7060, 7061, 7062, 6942
1848, 3123, 3182, 3183, 3124, 7062, 7063, 7064, 6944
1849, 3124, 3183, 3184, 3125, 7064, 7065, 7066, 6946
1850, 3125, 3184, 3185, 3126, 7066, 7067, 7068, 6948
1851, 3126, 3185, 3186, 3127, 7068, 7069, 7070, 6950
1852, 3127, 3186, 3187, 3128, 7070, 7071, 7072, 6952
1853, 3128, 3187, 3188, 3129, 7072, 7073, 7074, 6954
1854, 3129, 3188, 3189, 3130, 7074, 7075, 7076, 6956
1855, 3130, 3189, 3190, 3131, 7076, 7077, 7078, 6958
1856, 3131, 3190, 3191, 3132, 7078, 7079, 7080, 6960
