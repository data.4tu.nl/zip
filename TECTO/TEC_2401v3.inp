3719, 4963, 5022, 5023, 4964, 10773, 10774, 10775, 10655
3720, 4964, 5023, 5024, 4965, 10775, 10776, 10777, 10657
3721, 4965, 5024, 5025, 4966, 10777, 10778, 10779, 10659
3722, 4966, 5025, 5026, 4967, 10779, 10780, 10781, 10661
3723, 4967, 5026, 5027, 4968, 10781, 10782, 10783, 10663
3724, 4968, 5027, 5028, 4969, 10783, 10784, 10785, 10665
3725, 4969, 5028, 5029, 4970, 10785, 10786, 10787, 10667
3726, 4970, 5029, 5030, 4971, 10787, 10788, 10789, 10669
3727, 4971, 5030, 5031, 4972, 10789, 10790, 10791, 10671
3728, 4972, 5031, 430, 431, 10791, 10792, 490, 10673
3729, 208, 209, 5032, 4973, 268, 10793, 10794, 10674
3730, 4973, 5032, 5033, 4974, 10794, 10795, 10796, 10676
3731, 4974, 5033, 5034, 4975, 10796, 10797, 10798, 10678
3732, 4975, 5034, 5035, 4976, 10798, 10799, 10800, 10680
3733, 4976, 5035, 5036, 4977, 10800, 10801, 10802, 10682
3734, 4977, 5036, 5037, 4978, 10802, 10803, 10804, 10684
3735, 4978, 5037, 5038, 4979, 10804, 10805, 10806, 10686
3736, 4979, 5038, 5039, 4980, 10806, 10807, 10808, 10688
3737, 4980, 5039, 5040, 4981, 10808, 10809, 10810, 10690
3738, 4981, 5040, 5041, 4982, 10810, 10811, 10812, 10692
3739, 4982, 5041, 5042, 4983, 10812, 10813, 10814, 10694
3740, 4983, 5042, 5043, 4984, 10814, 10815, 10816, 10696
3741, 4984, 5043, 5044, 4985, 10816, 10817, 10818, 10698
3742, 4985, 5044, 5045, 4986, 10818, 10819, 10820, 10700
3743, 4986, 5045, 5046, 4987, 10820, 10821, 10822, 10702
3744, 4987, 5046, 5047, 4988, 10822, 10823, 10824, 10704
3745, 4988, 5047, 5048, 4989, 10824, 10825, 10826, 10706
3746, 4989, 5048, 5049, 4990, 10826, 10827, 10828, 10708
3747, 4990, 5049, 5050, 4991, 10828, 10829, 10830, 10710
3748, 4991, 5050, 5051, 4992, 10830, 10831, 10832, 10712
3749, 4992, 5051, 5052, 4993, 10832, 10833, 10834, 10714
3750, 4993, 5052, 5053, 4994, 10834, 10835, 10836, 10716
3751, 4994, 5053, 5054, 4995, 10836, 10837, 10838, 10718
3752, 4995, 5054, 5055, 4996, 10838, 10839, 10840, 10720
3753, 4996, 5055, 5056, 4997, 10840, 10841, 10842, 10722
3754, 4997, 5056, 5057, 4998, 10842, 10843, 10844, 10724
3755, 4998, 5057, 5058, 4999, 10844, 10845, 10846, 10726
3756, 4999, 5058, 5059, 5000, 10846, 10847, 10848, 10728
3757, 5000, 5059, 5060, 5001, 10848, 10849, 10850, 10730
3758, 5001, 5060, 5061, 5002, 10850, 10851, 10852, 10732
3759, 5002, 5061, 5062, 5003, 10852, 10853, 10854, 10734
3760, 5003, 5062, 5063, 5004, 10854, 10855, 10856, 10736
3761, 5004, 5063, 5064, 5005, 10856, 10857, 10858, 10738
3762, 5005, 5064, 5065, 5006, 10858, 10859, 10860, 10740
3763, 5006, 5065, 5066, 5007, 10860, 10861, 10862, 10742
3764, 5007, 5066, 5067, 5008, 10862, 10863, 10864, 10744
3765, 5008, 5067, 5068, 5009, 10864, 10865, 10866, 10746
3766, 5009, 5068, 5069, 5010, 10866, 10867, 10868, 10748
3767, 5010, 5069, 5070, 5011, 10868, 10869, 10870, 10750
3768, 5011, 5070, 5071, 5012, 10870, 10871, 10872, 10752
3769, 5012, 5071, 5072, 5013, 10872, 10873, 10874, 10754
3770, 5013, 5072, 5073, 5014, 10874, 10875, 10876, 10756
3771, 5014, 5073, 5074, 5015, 10876, 10877, 10878, 10758
3772, 5015, 5074, 5075, 5016, 10878, 10879, 10880, 10760
3773, 5016, 5075, 5076, 5017, 10880, 10881, 10882, 10762
3774, 5017, 5076, 5077, 5018, 10882, 10883, 10884, 10764
3775, 5018, 5077, 5078, 5019, 10884, 10885, 10886, 10766
3776, 5019, 5078, 5079, 5020, 10886, 10887, 10888, 10768
3777, 5020, 5079, 5080, 5021, 10888, 10889, 10890, 10770
3778, 5021, 5080, 5081, 5022, 10890, 10891, 10892, 10772
3779, 5022, 5081, 5082, 5023, 10892, 10893, 10894, 10774
3780, 5023, 5082, 5083, 5024, 10894, 10895, 10896, 10776
3781, 5024, 5083, 5084, 5025, 10896, 10897, 10898, 10778
3782, 5025, 5084, 5085, 5026, 10898, 10899, 10900, 10780
3783, 5026, 5085, 5086, 5027, 10900, 10901, 10902, 10782
3784, 5027, 5086, 5087, 5028, 10902, 10903, 10904, 10784
3785, 5028, 5087, 5088, 5029, 10904, 10905, 10906, 10786
3786, 5029, 5088, 5089, 5030, 10906, 10907, 10908, 10788
3787, 5030, 5089, 5090, 5031, 10908, 10909, 10910, 10790
3788, 5031, 5090, 429, 430, 10910, 10911, 489, 10792
3789, 209, 210, 5091, 5032, 269, 10912, 10913, 10793
3790, 5032, 5091, 5092, 5033, 10913, 10914, 10915, 10795
3791, 5033, 5092, 5093, 5034, 10915, 10916, 10917, 10797
3792, 5034, 5093, 5094, 5035, 10917, 10918, 10919, 10799
3793, 5035, 5094, 5095, 5036, 10919, 10920, 10921, 10801
3794, 5036, 5095, 5096, 5037, 10921, 10922, 10923, 10803
3795, 5037, 5096, 5097, 5038, 10923, 10924, 10925, 10805
3796, 5038, 5097, 5098, 5039, 10925, 10926, 10927, 10807
3797, 5039, 5098, 5099, 5040, 10927, 10928, 10929, 10809
3798, 5040, 5099, 5100, 5041, 10929, 10930, 10931, 10811
3799, 5041, 5100, 5101, 5042, 10931, 10932, 10933, 10813
3800, 5042, 5101, 5102, 5043, 10933, 10934, 10935, 10815
3801, 5043, 5102, 5103, 5044, 10935, 10936, 10937, 10817
3802, 5044, 5103, 5104, 5045, 10937, 10938, 10939, 10819
3803, 5045, 5104, 5105, 5046, 10939, 10940, 10941, 10821
3804, 5046, 5105, 5106, 5047, 10941, 10942, 10943, 10823
3805, 5047, 5106, 5107, 5048, 10943, 10944, 10945, 10825
3806, 5048, 5107, 5108, 5049, 10945, 10946, 10947, 10827
3807, 5049, 5108, 5109, 5050, 10947, 10948, 10949, 10829
3808, 5050, 5109, 5110, 5051, 10949, 10950, 10951, 10831
3809, 5051, 5110, 5111, 5052, 10951, 10952, 10953, 10833
3810, 5052, 5111, 5112, 5053, 10953, 10954, 10955, 10835
3811, 5053, 5112, 5113, 5054, 10955, 10956, 10957, 10837
3812, 5054, 5113, 5114, 5055, 10957, 10958, 10959, 10839
3813, 5055, 5114, 5115, 5056, 10959, 10960, 10961, 10841
3814, 5056, 5115, 5116, 5057, 10961, 10962, 10963, 10843
3815, 5057, 5116, 5117, 5058, 10963, 10964, 10965, 10845
3816, 5058, 5117, 5118, 5059, 10965, 10966, 10967, 10847
3817, 5059, 5118, 5119, 5060, 10967, 10968, 10969, 10849
3818, 5060, 5119, 5120, 5061, 10969, 10970, 10971, 10851
3819, 5061, 5120, 5121, 5062, 10971, 10972, 10973, 10853
3820, 5062, 5121, 5122, 5063, 10973, 10974, 10975, 10855
3821, 5063, 5122, 5123, 5064, 10975, 10976, 10977, 10857
3822, 5064, 5123, 5124, 5065, 10977, 10978, 10979, 10859
3823, 5065, 5124, 5125, 5066, 10979, 10980, 10981, 10861
3824, 5066, 5125, 5126, 5067, 10981, 10982, 10983, 10863
3825, 5067, 5126, 5127, 5068, 10983, 10984, 10985, 10865
3826, 5068, 5127, 5128, 5069, 10985, 10986, 10987, 10867
3827, 5069, 5128, 5129, 5070, 10987, 10988, 10989, 10869
3828, 5070, 5129, 5130, 5071, 10989, 10990, 10991, 10871
3829, 5071, 5130, 5131, 5072, 10991, 10992, 10993, 10873
3830, 5072, 5131, 5132, 5073, 10993, 10994, 10995, 10875
3831, 5073, 5132, 5133, 5074, 10995, 10996, 10997, 10877
3832, 5074, 5133, 5134, 5075, 10997, 10998, 10999, 10879
3833, 5075, 5134, 5135, 5076, 10999, 11000, 11001, 10881
3834, 5076, 5135, 5136, 5077, 11001, 11002, 11003, 10883
3835, 5077, 5136, 5137, 5078, 11003, 11004, 11005, 10885
3836, 5078, 5137, 5138, 5079, 11005, 11006, 11007, 10887
3837, 5079, 5138, 5139, 5080, 11007, 11008, 11009, 10889
3838, 5080, 5139, 5140, 5081, 11009, 11010, 11011, 10891
3839, 5081, 5140, 5141, 5082, 11011, 11012, 11013, 10893
3840, 5082, 5141, 5142, 5083, 11013, 11014, 11015, 10895
3841, 5083, 5142, 5143, 5084, 11015, 11016, 11017, 10897
3842, 5084, 5143, 5144, 5085, 11017, 11018, 11019, 10899
3843, 5085, 5144, 5145, 5086, 11019, 11020, 11021, 10901
3844, 5086, 5145, 5146, 5087, 11021, 11022, 11023, 10903
3845, 5087, 5146, 5147, 5088, 11023, 11024, 11025, 10905
3846, 5088, 5147, 5148, 5089, 11025, 11026, 11027, 10907
3847, 5089, 5148, 5149, 5090, 11027, 11028, 11029, 10909
3848, 5090, 5149, 428, 429, 11029, 11030, 488, 10911
3849, 210, 211, 5150, 5091, 270, 11031, 11032, 10912
3850, 5091, 5150, 5151, 5092, 11032, 11033, 11034, 10914
3851, 5092, 5151, 5152, 5093, 11034, 11035, 11036, 10916
3852, 5093, 5152, 5153, 5094, 11036, 11037, 11038, 10918
3853, 5094, 5153, 5154, 5095, 11038, 11039, 11040, 10920
3854, 5095, 5154, 5155, 5096, 11040, 11041, 11042, 10922
3855, 5096, 5155, 5156, 5097, 11042, 11043, 11044, 10924
3856, 5097, 5156, 5157, 5098, 11044, 11045, 11046, 10926
3857, 5098, 5157, 5158, 5099, 11046, 11047, 11048, 10928
3858, 5099, 5158, 5159, 5100, 11048, 11049, 11050, 10930
3859, 5100, 5159, 5160, 5101, 11050, 11051, 11052, 10932
3860, 5101, 5160, 5161, 5102, 11052, 11053, 11054, 10934
3861, 5102, 5161, 5162, 5103, 11054, 11055, 11056, 10936
3862, 5103, 5162, 5163, 5104, 11056, 11057, 11058, 10938
3863, 5104, 5163, 5164, 5105, 11058, 11059, 11060, 10940
3864, 5105, 5164, 5165, 5106, 11060, 11061, 11062, 10942
3865, 5106, 5165, 5166, 5107, 11062, 11063, 11064, 10944
3866, 5107, 5166, 5167, 5108, 11064, 11065, 11066, 10946
3867, 5108, 5167, 5168, 5109, 11066, 11067, 11068, 10948
3868, 5109, 5168, 5169, 5110, 11068, 11069, 11070, 10950
3869, 5110, 5169, 5170, 5111, 11070, 11071, 11072, 10952
3870, 5111, 5170, 5171, 5112, 11072, 11073, 11074, 10954
3871, 5112, 5171, 5172, 5113, 11074, 11075, 11076, 10956
3872, 5113, 5172, 5173, 5114, 11076, 11077, 11078, 10958
3873, 5114, 5173, 5174, 5115, 11078, 11079, 11080, 10960
3874, 5115, 5174, 5175, 5116, 11080, 11081, 11082, 10962
3875, 5116, 5175, 5176, 5117, 11082, 11083, 11084, 10964
3876, 5117, 5176, 5177, 5118, 11084, 11085, 11086, 10966
3877, 5118, 5177, 5178, 5119, 11086, 11087, 11088, 10968
3878, 5119, 5178, 5179, 5120, 11088, 11089, 11090, 10970
3879, 5120, 5179, 5180, 5121, 11090, 11091, 11092, 10972
3880, 5121, 5180, 5181, 5122, 11092, 11093, 11094, 10974
3881, 5122, 5181, 5182, 5123, 11094, 11095, 11096, 10976
3882, 5123, 5182, 5183, 5124, 11096, 11097, 11098, 10978
3883, 5124, 5183, 5184, 5125, 11098, 11099, 11100, 10980
3884, 5125, 5184, 5185, 5126, 11100, 11101, 11102, 10982
3885, 5126, 5185, 5186, 5127, 11102, 11103, 11104, 10984
3886, 5127, 5186, 5187, 5128, 11104, 11105, 11106, 10986
3887, 5128, 5187, 5188, 5129, 11106, 11107, 11108, 10988
3888, 5129, 5188, 5189, 5130, 11108, 11109, 11110, 10990
3889, 5130, 5189, 5190, 5131, 11110, 11111, 11112, 10992
3890, 5131, 5190, 5191, 5132, 11112, 11113, 11114, 10994
3891, 5132, 5191, 5192, 5133, 11114, 11115, 11116, 10996
3892, 5133, 5192, 5193, 5134, 11116, 11117, 11118, 10998
3893, 5134, 5193, 5194, 5135, 11118, 11119, 11120, 11000
3894, 5135, 5194, 5195, 5136, 11120, 11121, 11122, 11002
3895, 5136, 5195, 5196, 5137, 11122, 11123, 11124, 11004
3896, 5137, 5196, 5197, 5138, 11124, 11125, 11126, 11006
3897, 5138, 5197, 5198, 5139, 11126, 11127, 11128, 11008
3898, 5139, 5198, 5199, 5140, 11128, 11129, 11130, 11010
3899, 5140, 5199, 5200, 5141, 11130, 11131, 11132, 11012
3900, 5141, 5200, 5201, 5142, 11132, 11133, 11134, 11014
3901, 5142, 5201, 5202, 5143, 11134, 11135, 11136, 11016
3902, 5143, 5202, 5203, 5144, 11136, 11137, 11138, 11018
3903, 5144, 5203, 5204, 5145, 11138, 11139, 11140, 11020
3904, 5145, 5204, 5205, 5146, 11140, 11141, 11142, 11022
3905, 5146, 5205, 5206, 5147, 11142, 11143, 11144, 11024
3906, 5147, 5206, 5207, 5148, 11144, 11145, 11146, 11026
3907, 5148, 5207, 5208, 5149, 11146, 11147, 11148, 11028
3908, 5149, 5208, 427, 428, 11148, 11149, 487, 11030
3909, 211, 212, 5209, 5150, 271, 11150, 11151, 11031
3910, 5150, 5209, 5210, 5151, 11151, 11152, 11153, 11033
3911, 5151, 5210, 5211, 5152, 11153, 11154, 11155, 11035
3912, 5152, 5211, 5212, 5153, 11155, 11156, 11157, 11037
3913, 5153, 5212, 5213, 5154, 11157, 11158, 11159, 11039
3914, 5154, 5213, 5214, 5155, 11159, 11160, 11161, 11041
3915, 5155, 5214, 5215, 5156, 11161, 11162, 11163, 11043
3916, 5156, 5215, 5216, 5157, 11163, 11164, 11165, 11045
3917, 5157, 5216, 5217, 5158, 11165, 11166, 11167, 11047
3918, 5158, 5217, 5218, 5159, 11167, 11168, 11169, 11049
3919, 5159, 5218, 5219, 5160, 11169, 11170, 11171, 11051
3920, 5160, 5219, 5220, 5161, 11171, 11172, 11173, 11053
3921, 5161, 5220, 5221, 5162, 11173, 11174, 11175, 11055
3922, 5162, 5221, 5222, 5163, 11175, 11176, 11177, 11057
3923, 5163, 5222, 5223, 5164, 11177, 11178, 11179, 11059
3924, 5164, 5223, 5224, 5165, 11179, 11180, 11181, 11061
3925, 5165, 5224, 5225, 5166, 11181, 11182, 11183, 11063
3926, 5166, 5225, 5226, 5167, 11183, 11184, 11185, 11065
3927, 5167, 5226, 5227, 5168, 11185, 11186, 11187, 11067
3928, 5168, 5227, 5228, 5169, 11187, 11188, 11189, 11069
3929, 5169, 5228, 5229, 5170, 11189, 11190, 11191, 11071
3930, 5170, 5229, 5230, 5171, 11191, 11192, 11193, 11073
3931, 5171, 5230, 5231, 5172, 11193, 11194, 11195, 11075
3932, 5172, 5231, 5232, 5173, 11195, 11196, 11197, 11077
3933, 5173, 5232, 5233, 5174, 11197, 11198, 11199, 11079
3934, 5174, 5233, 5234, 5175, 11199, 11200, 11201, 11081
3935, 5175, 5234, 5235, 5176, 11201, 11202, 11203, 11083
3936, 5176, 5235, 5236, 5177, 11203, 11204, 11205, 11085
3937, 5177, 5236, 5237, 5178, 11205, 11206, 11207, 11087
3938, 5178, 5237, 5238, 5179, 11207, 11208, 11209, 11089
3939, 5179, 5238, 5239, 5180, 11209, 11210, 11211, 11091
3940, 5180, 5239, 5240, 5181, 11211, 11212, 11213, 11093
3941, 5181, 5240, 5241, 5182, 11213, 11214, 11215, 11095
3942, 5182, 5241, 5242, 5183, 11215, 11216, 11217, 11097
3943, 5183, 5242, 5243, 5184, 11217, 11218, 11219, 11099
3944, 5184, 5243, 5244, 5185, 11219, 11220, 11221, 11101
3945, 5185, 5244, 5245, 5186, 11221, 11222, 11223, 11103
3946, 5186, 5245, 5246, 5187, 11223, 11224, 11225, 11105
3947, 5187, 5246, 5247, 5188, 11225, 11226, 11227, 11107
3948, 5188, 5247, 5248, 5189, 11227, 11228, 11229, 11109
3949, 5189, 5248, 5249, 5190, 11229, 11230, 11231, 11111
3950, 5190, 5249, 5250, 5191, 11231, 11232, 11233, 11113
3951, 5191, 5250, 5251, 5192, 11233, 11234, 11235, 11115
3952, 5192, 5251, 5252, 5193, 11235, 11236, 11237, 11117
3953, 5193, 5252, 5253, 5194, 11237, 11238, 11239, 11119
3954, 5194, 5253, 5254, 5195, 11239, 11240, 11241, 11121
3955, 5195, 5254, 5255, 5196, 11241, 11242, 11243, 11123
3956, 5196, 5255, 5256, 5197, 11243, 11244, 11245, 11125
3957, 5197, 5256, 5257, 5198, 11245, 11246, 11247, 11127
3958, 5198, 5257, 5258, 5199, 11247, 11248, 11249, 11129
3959, 5199, 5258, 5259, 5200, 11249, 11250, 11251, 11131
3960, 5200, 5259, 5260, 5201, 11251, 11252, 11253, 11133
3961, 5201, 5260, 5261, 5202, 11253, 11254, 11255, 11135
3962, 5202, 5261, 5262, 5203, 11255, 11256, 11257, 11137
3963, 5203, 5262, 5263, 5204, 11257, 11258, 11259, 11139
3964, 5204, 5263, 5264, 5205, 11259, 11260, 11261, 11141
3965, 5205, 5264, 5265, 5206, 11261, 11262, 11263, 11143
3966, 5206, 5265, 5266, 5207, 11263, 11264, 11265, 11145
3967, 5207, 5266, 5267, 5208, 11265, 11266, 11267, 11147
3968, 5208, 5267, 426, 427, 11267, 11268, 486, 11149
3969, 212, 213, 5268, 5209, 272, 11269, 11270, 11150
3970, 5209, 5268, 5269, 5210, 11270, 11271, 11272, 11152
3971, 5210, 5269, 5270, 5211, 11272, 11273, 11274, 11154
3972, 5211, 5270, 5271, 5212, 11274, 11275, 11276, 11156
3973, 5212, 5271, 5272, 5213, 11276, 11277, 11278, 11158
3974, 5213, 5272, 5273, 5214, 11278, 11279, 11280, 11160
3975, 5214, 5273, 5274, 5215, 11280, 11281, 11282, 11162
3976, 5215, 5274, 5275, 5216, 11282, 11283, 11284, 11164
3977, 5216, 5275, 5276, 5217, 11284, 11285, 11286, 11166
3978, 5217, 5276, 5277, 5218, 11286, 11287, 11288, 11168
3979, 5218, 5277, 5278, 5219, 11288, 11289, 11290, 11170
3980, 5219, 5278, 5279, 5220, 11290, 11291, 11292, 11172
3981, 5220, 5279, 5280, 5221, 11292, 11293, 11294, 11174
3982, 5221, 5280, 5281, 5222, 11294, 11295, 11296, 11176
3983, 5222, 5281, 5282, 5223, 11296, 11297, 11298, 11178
3984, 5223, 5282, 5283, 5224, 11298, 11299, 11300, 11180
3985, 5224, 5283, 5284, 5225, 11300, 11301, 11302, 11182
3986, 5225, 5284, 5285, 5226, 11302, 11303, 11304, 11184
3987, 5226, 5285, 5286, 5227, 11304, 11305, 11306, 11186
3988, 5227, 5286, 5287, 5228, 11306, 11307, 11308, 11188
3989, 5228, 5287, 5288, 5229, 11308, 11309, 11310, 11190
3990, 5229, 5288, 5289, 5230, 11310, 11311, 11312, 11192
3991, 5230, 5289, 5290, 5231, 11312, 11313, 11314, 11194
3992, 5231, 5290, 5291, 5232, 11314, 11315, 11316, 11196
3993, 5232, 5291, 5292, 5233, 11316, 11317, 11318, 11198
3994, 5233, 5292, 5293, 5234, 11318, 11319, 11320, 11200
3995, 5234, 5293, 5294, 5235, 11320, 11321, 11322, 11202
3996, 5235, 5294, 5295, 5236, 11322, 11323, 11324, 11204
3997, 5236, 5295, 5296, 5237, 11324, 11325, 11326, 11206
3998, 5237, 5296, 5297, 5238, 11326, 11327, 11328, 11208
3999, 5238, 5297, 5298, 5239, 11328, 11329, 11330, 11210
4000, 5239, 5298, 5299, 5240, 11330, 11331, 11332, 11212
4001, 5240, 5299, 5300, 5241, 11332, 11333, 11334, 11214
4002, 5241, 5300, 5301, 5242, 11334, 11335, 11336, 11216
4003, 5242, 5301, 5302, 5243, 11336, 11337, 11338, 11218
4004, 5243, 5302, 5303, 5244, 11338, 11339, 11340, 11220
4005, 5244, 5303, 5304, 5245, 11340, 11341, 11342, 11222
4006, 5245, 5304, 5305, 5246, 11342, 11343, 11344, 11224
4007, 5246, 5305, 5306, 5247, 11344, 11345, 11346, 11226
4008, 5247, 5306, 5307, 5248, 11346, 11347, 11348, 11228
4009, 5248, 5307, 5308, 5249, 11348, 11349, 11350, 11230
4010, 5249, 5308, 5309, 5250, 11350, 11351, 11352, 11232
4011, 5250, 5309, 5310, 5251, 11352, 11353, 11354, 11234
4012, 5251, 5310, 5311, 5252, 11354, 11355, 11356, 11236
4013, 5252, 5311, 5312, 5253, 11356, 11357, 11358, 11238
4014, 5253, 5312, 5313, 5254, 11358, 11359, 11360, 11240
4015, 5254, 5313, 5314, 5255, 11360, 11361, 11362, 11242
4016, 5255, 5314, 5315, 5256, 11362, 11363, 11364, 11244
4017, 5256, 5315, 5316, 5257, 11364, 11365, 11366, 11246
4018, 5257, 5316, 5317, 5258, 11366, 11367, 11368, 11248
4019, 5258, 5317, 5318, 5259, 11368, 11369, 11370, 11250
4020, 5259, 5318, 5319, 5260, 11370, 11371, 11372, 11252
4021, 5260, 5319, 5320, 5261, 11372, 11373, 11374, 11254
4022, 5261, 5320, 5321, 5262, 11374, 11375, 11376, 11256
4023, 5262, 5321, 5322, 5263, 11376, 11377, 11378, 11258
4024, 5263, 5322, 5323, 5264, 11378, 11379, 11380, 11260
4025, 5264, 5323, 5324, 5265, 11380, 11381, 11382, 11262
4026, 5265, 5324, 5325, 5266, 11382, 11383, 11384, 11264
4027, 5266, 5325, 5326, 5267, 11384, 11385, 11386, 11266
4028, 5267, 5326, 425, 426, 11386, 11387, 485, 11268
4029, 213, 214, 5327, 5268, 273, 11388, 11389, 11269
4030, 5268, 5327, 5328, 5269, 11389, 11390, 11391, 11271
4031, 5269, 5328, 5329, 5270, 11391, 11392, 11393, 11273
4032, 5270, 5329, 5330, 5271, 11393, 11394, 11395, 11275
4033, 5271, 5330, 5331, 5272, 11395, 11396, 11397, 11277
4034, 5272, 5331, 5332, 5273, 11397, 11398, 11399, 11279
4035, 5273, 5332, 5333, 5274, 11399, 11400, 11401, 11281
4036, 5274, 5333, 5334, 5275, 11401, 11402, 11403, 11283
4037, 5275, 5334, 5335, 5276, 11403, 11404, 11405, 11285
4038, 5276, 5335, 5336, 5277, 11405, 11406, 11407, 11287
4039, 5277, 5336, 5337, 5278, 11407, 11408, 11409, 11289
4040, 5278, 5337, 5338, 5279, 11409, 11410, 11411, 11291
4041, 5279, 5338, 5339, 5280, 11411, 11412, 11413, 11293
4042, 5280, 5339, 5340, 5281, 11413, 11414, 11415, 11295
4043, 5281, 5340, 5341, 5282, 11415, 11416, 11417, 11297
4044, 5282, 5341, 5342, 5283, 11417, 11418, 11419, 11299
4045, 5283, 5342, 5343, 5284, 11419, 11420, 11421, 11301
4046, 5284, 5343, 5344, 5285, 11421, 11422, 11423, 11303
4047, 5285, 5344, 5345, 5286, 11423, 11424, 11425, 11305
4048, 5286, 5345, 5346, 5287, 11425, 11426, 11427, 11307
4049, 5287, 5346, 5347, 5288, 11427, 11428, 11429, 11309
4050, 5288, 5347, 5348, 5289, 11429, 11430, 11431, 11311
4051, 5289, 5348, 5349, 5290, 11431, 11432, 11433, 11313
4052, 5290, 5349, 5350, 5291, 11433, 11434, 11435, 11315
4053, 5291, 5350, 5351, 5292, 11435, 11436, 11437, 11317
4054, 5292, 5351, 5352, 5293, 11437, 11438, 11439, 11319
4055, 5293, 5352, 5353, 5294, 11439, 11440, 11441, 11321
4056, 5294, 5353, 5354, 5295, 11441, 11442, 11443, 11323
4057, 5295, 5354, 5355, 5296, 11443, 11444, 11445, 11325
4058, 5296, 5355, 5356, 5297, 11445, 11446, 11447, 11327
4059, 5297, 5356, 5357, 5298, 11447, 11448, 11449, 11329
4060, 5298, 5357, 5358, 5299, 11449, 11450, 11451, 11331
4061, 5299, 5358, 5359, 5300, 11451, 11452, 11453, 11333
4062, 5300, 5359, 5360, 5301, 11453, 11454, 11455, 11335
4063, 5301, 5360, 5361, 5302, 11455, 11456, 11457, 11337
4064, 5302, 5361, 5362, 5303, 11457, 11458, 11459, 11339
4065, 5303, 5362, 5363, 5304, 11459, 11460, 11461, 11341
4066, 5304, 5363, 5364, 5305, 11461, 11462, 11463, 11343
4067, 5305, 5364, 5365, 5306, 11463, 11464, 11465, 11345
4068, 5306, 5365, 5366, 5307, 11465, 11466, 11467, 11347
4069, 5307, 5366, 5367, 5308, 11467, 11468, 11469, 11349
4070, 5308, 5367, 5368, 5309, 11469, 11470, 11471, 11351
4071, 5309, 5368, 5369, 5310, 11471, 11472, 11473, 11353
4072, 5310, 5369, 5370, 5311, 11473, 11474, 11475, 11355
4073, 5311, 5370, 5371, 5312, 11475, 11476, 11477, 11357
4074, 5312, 5371, 5372, 5313, 11477, 11478, 11479, 11359
4075, 5313, 5372, 5373, 5314, 11479, 11480, 11481, 11361
4076, 5314, 5373, 5374, 5315, 11481, 11482, 11483, 11363
4077, 5315, 5374, 5375, 5316, 11483, 11484, 11485, 11365
4078, 5316, 5375, 5376, 5317, 11485, 11486, 11487, 11367
4079, 5317, 5376, 5377, 5318, 11487, 11488, 11489, 11369
4080, 5318, 5377, 5378, 5319, 11489, 11490, 11491, 11371
4081, 5319, 5378, 5379, 5320, 11491, 11492, 11493, 11373
4082, 5320, 5379, 5380, 5321, 11493, 11494, 11495, 11375
4083, 5321, 5380, 5381, 5322, 11495, 11496, 11497, 11377
4084, 5322, 5381, 5382, 5323, 11497, 11498, 11499, 11379
4085, 5323, 5382, 5383, 5324, 11499, 11500, 11501, 11381
4086, 5324, 5383, 5384, 5325, 11501, 11502, 11503, 11383
4087, 5325, 5384, 5385, 5326, 11503, 11504, 11505, 11385
4088, 5326, 5385, 424, 425, 11505, 11506, 484, 11387
4089, 214, 215, 5386, 5327, 274, 11507, 11508, 11388
4090, 5327, 5386, 5387, 5328, 11508, 11509, 11510, 11390
4091, 5328, 5387, 5388, 5329, 11510, 11511, 11512, 11392
4092, 5329, 5388, 5389, 5330, 11512, 11513, 11514, 11394
4093, 5330, 5389, 5390, 5331, 11514, 11515, 11516, 11396
4094, 5331, 5390, 5391, 5332, 11516, 11517, 11518, 11398
4095, 5332, 5391, 5392, 5333, 11518, 11519, 11520, 11400
4096, 5333, 5392, 5393, 5334, 11520, 11521, 11522, 11402
4097, 5334, 5393, 5394, 5335, 11522, 11523, 11524, 11404
4098, 5335, 5394, 5395, 5336, 11524, 11525, 11526, 11406
4099, 5336, 5395, 5396, 5337, 11526, 11527, 11528, 11408
4100, 5337, 5396, 5397, 5338, 11528, 11529, 11530, 11410
4101, 5338, 5397, 5398, 5339, 11530, 11531, 11532, 11412
4102, 5339, 5398, 5399, 5340, 11532, 11533, 11534, 11414
4103, 5340, 5399, 5400, 5341, 11534, 11535, 11536, 11416
4104, 5341, 5400, 5401, 5342, 11536, 11537, 11538, 11418
4105, 5342, 5401, 5402, 5343, 11538, 11539, 11540, 11420
4106, 5343, 5402, 5403, 5344, 11540, 11541, 11542, 11422
4107, 5344, 5403, 5404, 5345, 11542, 11543, 11544, 11424
4108, 5345, 5404, 5405, 5346, 11544, 11545, 11546, 11426
4109, 5346, 5405, 5406, 5347, 11546, 11547, 11548, 11428
4110, 5347, 5406, 5407, 5348, 11548, 11549, 11550, 11430
4111, 5348, 5407, 5408, 5349, 11550, 11551, 11552, 11432
4112, 5349, 5408, 5409, 5350, 11552, 11553, 11554, 11434
4113, 5350, 5409, 5410, 5351, 11554, 11555, 11556, 11436
4114, 5351, 5410, 5411, 5352, 11556, 11557, 11558, 11438
4115, 5352, 5411, 5412, 5353, 11558, 11559, 11560, 11440
4116, 5353, 5412, 5413, 5354, 11560, 11561, 11562, 11442
4117, 5354, 5413, 5414, 5355, 11562, 11563, 11564, 11444
4118, 5355, 5414, 5415, 5356, 11564, 11565, 11566, 11446
4119, 5356, 5415, 5416, 5357, 11566, 11567, 11568, 11448
4120, 5357, 5416, 5417, 5358, 11568, 11569, 11570, 11450
4121, 5358, 5417, 5418, 5359, 11570, 11571, 11572, 11452
4122, 5359, 5418, 5419, 5360, 11572, 11573, 11574, 11454
4123, 5360, 5419, 5420, 5361, 11574, 11575, 11576, 11456
4124, 5361, 5420, 5421, 5362, 11576, 11577, 11578, 11458
4125, 5362, 5421, 5422, 5363, 11578, 11579, 11580, 11460
4126, 5363, 5422, 5423, 5364, 11580, 11581, 11582, 11462
4127, 5364, 5423, 5424, 5365, 11582, 11583, 11584, 11464
4128, 5365, 5424, 5425, 5366, 11584, 11585, 11586, 11466
4129, 5366, 5425, 5426, 5367, 11586, 11587, 11588, 11468
4130, 5367, 5426, 5427, 5368, 11588, 11589, 11590, 11470
4131, 5368, 5427, 5428, 5369, 11590, 11591, 11592, 11472
4132, 5369, 5428, 5429, 5370, 11592, 11593, 11594, 11474
4133, 5370, 5429, 5430, 5371, 11594, 11595, 11596, 11476
4134, 5371, 5430, 5431, 5372, 11596, 11597, 11598, 11478
4135, 5372, 5431, 5432, 5373, 11598, 11599, 11600, 11480
4136, 5373, 5432, 5433, 5374, 11600, 11601, 11602, 11482
4137, 5374, 5433, 5434, 5375, 11602, 11603, 11604, 11484
4138, 5375, 5434, 5435, 5376, 11604, 11605, 11606, 11486
4139, 5376, 5435, 5436, 5377, 11606, 11607, 11608, 11488
4140, 5377, 5436, 5437, 5378, 11608, 11609, 11610, 11490
4141, 5378, 5437, 5438, 5379, 11610, 11611, 11612, 11492
4142, 5379, 5438, 5439, 5380, 11612, 11613, 11614, 11494
4143, 5380, 5439, 5440, 5381, 11614, 11615, 11616, 11496
4144, 5381, 5440, 5441, 5382, 11616, 11617, 11618, 11498
4145, 5382, 5441, 5442, 5383, 11618, 11619, 11620, 11500
4146, 5383, 5442, 5443, 5384, 11620, 11621, 11622, 11502
4147, 5384, 5443, 5444, 5385, 11622, 11623, 11624, 11504
4148, 5385, 5444, 423, 424, 11624, 11625, 483, 11506
4149, 215, 216, 5445, 5386, 275, 11626, 11627, 11507
4150, 5386, 5445, 5446, 5387, 11627, 11628, 11629, 11509
4151, 5387, 5446, 5447, 5388, 11629, 11630, 11631, 11511
4152, 5388, 5447, 5448, 5389, 11631, 11632, 11633, 11513
4153, 5389, 5448, 5449, 5390, 11633, 11634, 11635, 11515
4154, 5390, 5449, 5450, 5391, 11635, 11636, 11637, 11517
4155, 5391, 5450, 5451, 5392, 11637, 11638, 11639, 11519
4156, 5392, 5451, 5452, 5393, 11639, 11640, 11641, 11521
4157, 5393, 5452, 5453, 5394, 11641, 11642, 11643, 11523
4158, 5394, 5453, 5454, 5395, 11643, 11644, 11645, 11525
4159, 5395, 5454, 5455, 5396, 11645, 11646, 11647, 11527
4160, 5396, 5455, 5456, 5397, 11647, 11648, 11649, 11529
4161, 5397, 5456, 5457, 5398, 11649, 11650, 11651, 11531
4162, 5398, 5457, 5458, 5399, 11651, 11652, 11653, 11533
4163, 5399, 5458, 5459, 5400, 11653, 11654, 11655, 11535
4164, 5400, 5459, 5460, 5401, 11655, 11656, 11657, 11537
4165, 5401, 5460, 5461, 5402, 11657, 11658, 11659, 11539
4166, 5402, 5461, 5462, 5403, 11659, 11660, 11661, 11541
4167, 5403, 5462, 5463, 5404, 11661, 11662, 11663, 11543
4168, 5404, 5463, 5464, 5405, 11663, 11664, 11665, 11545
4169, 5405, 5464, 5465, 5406, 11665, 11666, 11667, 11547
4170, 5406, 5465, 5466, 5407, 11667, 11668, 11669, 11549
4171, 5407, 5466, 5467, 5408, 11669, 11670, 11671, 11551
4172, 5408, 5467, 5468, 5409, 11671, 11672, 11673, 11553
4173, 5409, 5468, 5469, 5410, 11673, 11674, 11675, 11555
4174, 5410, 5469, 5470, 5411, 11675, 11676, 11677, 11557
4175, 5411, 5470, 5471, 5412, 11677, 11678, 11679, 11559
4176, 5412, 5471, 5472, 5413, 11679, 11680, 11681, 11561
4177, 5413, 5472, 5473, 5414, 11681, 11682, 11683, 11563
4178, 5414, 5473, 5474, 5415, 11683, 11684, 11685, 11565
4179, 5415, 5474, 5475, 5416, 11685, 11686, 11687, 11567
4180, 5416, 5475, 5476, 5417, 11687, 11688, 11689, 11569
4181, 5417, 5476, 5477, 5418, 11689, 11690, 11691, 11571
4182, 5418, 5477, 5478, 5419, 11691, 11692, 11693, 11573
4183, 5419, 5478, 5479, 5420, 11693, 11694, 11695, 11575
4184, 5420, 5479, 5480, 5421, 11695, 11696, 11697, 11577
4185, 5421, 5480, 5481, 5422, 11697, 11698, 11699, 11579
4186, 5422, 5481, 5482, 5423, 11699, 11700, 11701, 11581
4187, 5423, 5482, 5483, 5424, 11701, 11702, 11703, 11583
4188, 5424, 5483, 5484, 5425, 11703, 11704, 11705, 11585
4189, 5425, 5484, 5485, 5426, 11705, 11706, 11707, 11587
4190, 5426, 5485, 5486, 5427, 11707, 11708, 11709, 11589
4191, 5427, 5486, 5487, 5428, 11709, 11710, 11711, 11591
4192, 5428, 5487, 5488, 5429, 11711, 11712, 11713, 11593
4193, 5429, 5488, 5489, 5430, 11713, 11714, 11715, 11595
4194, 5430, 5489, 5490, 5431, 11715, 11716, 11717, 11597
4195, 5431, 5490, 5491, 5432, 11717, 11718, 11719, 11599
4196, 5432, 5491, 5492, 5433, 11719, 11720, 11721, 11601
4197, 5433, 5492, 5493, 5434, 11721, 11722, 11723, 11603
4198, 5434, 5493, 5494, 5435, 11723, 11724, 11725, 11605
4199, 5435, 5494, 5495, 5436, 11725, 11726, 11727, 11607
4200, 5436, 5495, 5496, 5437, 11727, 11728, 11729, 11609
4201, 5437, 5496, 5497, 5438, 11729, 11730, 11731, 11611
4202, 5438, 5497, 5498, 5439, 11731, 11732, 11733, 11613
4203, 5439, 5498, 5499, 5440, 11733, 11734, 11735, 11615
4204, 5440, 5499, 5500, 5441, 11735, 11736, 11737, 11617
4205, 5441, 5500, 5501, 5442, 11737, 11738, 11739, 11619
4206, 5442, 5501, 5502, 5443, 11739, 11740, 11741, 11621
4207, 5443, 5502, 5503, 5444, 11741, 11742, 11743, 11623
4208, 5444, 5503, 422, 423, 11743, 11744, 482, 11625
4209, 216, 217, 5504, 5445, 276, 11745, 11746, 11626
4210, 5445, 5504, 5505, 5446, 11746, 11747, 11748, 11628
4211, 5446, 5505, 5506, 5447, 11748, 11749, 11750, 11630
4212, 5447, 5506, 5507, 5448, 11750, 11751, 11752, 11632
4213, 5448, 5507, 5508, 5449, 11752, 11753, 11754, 11634
4214, 5449, 5508, 5509, 5450, 11754, 11755, 11756, 11636
4215, 5450, 5509, 5510, 5451, 11756, 11757, 11758, 11638
4216, 5451, 5510, 5511, 5452, 11758, 11759, 11760, 11640
4217, 5452, 5511, 5512, 5453, 11760, 11761, 11762, 11642
4218, 5453, 5512, 5513, 5454, 11762, 11763, 11764, 11644
4219, 5454, 5513, 5514, 5455, 11764, 11765, 11766, 11646
4220, 5455, 5514, 5515, 5456, 11766, 11767, 11768, 11648
4221, 5456, 5515, 5516, 5457, 11768, 11769, 11770, 11650
4222, 5457, 5516, 5517, 5458, 11770, 11771, 11772, 11652
4223, 5458, 5517, 5518, 5459, 11772, 11773, 11774, 11654
4224, 5459, 5518, 5519, 5460, 11774, 11775, 11776, 11656
4225, 5460, 5519, 5520, 5461, 11776, 11777, 11778, 11658
4226, 5461, 5520, 5521, 5462, 11778, 11779, 11780, 11660
4227, 5462, 5521, 5522, 5463, 11780, 11781, 11782, 11662
4228, 5463, 5522, 5523, 5464, 11782, 11783, 11784, 11664
4229, 5464, 5523, 5524, 5465, 11784, 11785, 11786, 11666
4230, 5465, 5524, 5525, 5466, 11786, 11787, 11788, 11668
4231, 5466, 5525, 5526, 5467, 11788, 11789, 11790, 11670
4232, 5467, 5526, 5527, 5468, 11790, 11791, 11792, 11672
4233, 5468, 5527, 5528, 5469, 11792, 11793, 11794, 11674
4234, 5469, 5528, 5529, 5470, 11794, 11795, 11796, 11676
4235, 5470, 5529, 5530, 5471, 11796, 11797, 11798, 11678
4236, 5471, 5530, 5531, 5472, 11798, 11799, 11800, 11680
4237, 5472, 5531, 5532, 5473, 11800, 11801, 11802, 11682
4238, 5473, 5532, 5533, 5474, 11802, 11803, 11804, 11684
4239, 5474, 5533, 5534, 5475, 11804, 11805, 11806, 11686
4240, 5475, 5534, 5535, 5476, 11806, 11807, 11808, 11688
4241, 5476, 5535, 5536, 5477, 11808, 11809, 11810, 11690
4242, 5477, 5536, 5537, 5478, 11810, 11811, 11812, 11692
4243, 5478, 5537, 5538, 5479, 11812, 11813, 11814, 11694
4244, 5479, 5538, 5539, 5480, 11814, 11815, 11816, 11696
4245, 5480, 5539, 5540, 5481, 11816, 11817, 11818, 11698
4246, 5481, 5540, 5541, 5482, 11818, 11819, 11820, 11700
4247, 5482, 5541, 5542, 5483, 11820, 11821, 11822, 11702
4248, 5483, 5542, 5543, 5484, 11822, 11823, 11824, 11704
4249, 5484, 5543, 5544, 5485, 11824, 11825, 11826, 11706
4250, 5485, 5544, 5545, 5486, 11826, 11827, 11828, 11708
4251, 5486, 5545, 5546, 5487, 11828, 11829, 11830, 11710
4252, 5487, 5546, 5547, 5488, 11830, 11831, 11832, 11712
4253, 5488, 5547, 5548, 5489, 11832, 11833, 11834, 11714
4254, 5489, 5548, 5549, 5490, 11834, 11835, 11836, 11716
4255, 5490, 5549, 5550, 5491, 11836, 11837, 11838, 11718
4256, 5491, 5550, 5551, 5492, 11838, 11839, 11840, 11720
4257, 5492, 5551, 5552, 5493, 11840, 11841, 11842, 11722
4258, 5493, 5552, 5553, 5494, 11842, 11843, 11844, 11724
4259, 5494, 5553, 5554, 5495, 11844, 11845, 11846, 11726
4260, 5495, 5554, 5555, 5496, 11846, 11847, 11848, 11728
4261, 5496, 5555, 5556, 5497, 11848, 11849, 11850, 11730
4262, 5497, 5556, 5557, 5498, 11850, 11851, 11852, 11732
4263, 5498, 5557, 5558, 5499, 11852, 11853, 11854, 11734
4264, 5499, 5558, 5559, 5500, 11854, 11855, 11856, 11736
4265, 5500, 5559, 5560, 5501, 11856, 11857, 11858, 11738
4266, 5501, 5560, 5561, 5502, 11858, 11859, 11860, 11740
4267, 5502, 5561, 5562, 5503, 11860, 11861, 11862, 11742
4268, 5503, 5562, 421, 422, 11862, 11863, 481, 11744
4269, 217, 218, 5563, 5504, 277, 11864, 11865, 11745
4270, 5504, 5563, 5564, 5505, 11865, 11866, 11867, 11747
4271, 5505, 5564, 5565, 5506, 11867, 11868, 11869, 11749
4272, 5506, 5565, 5566, 5507, 11869, 11870, 11871, 11751
4273, 5507, 5566, 5567, 5508, 11871, 11872, 11873, 11753
4274, 5508, 5567, 5568, 5509, 11873, 11874, 11875, 11755
4275, 5509, 5568, 5569, 5510, 11875, 11876, 11877, 11757
4276, 5510, 5569, 5570, 5511, 11877, 11878, 11879, 11759
4277, 5511, 5570, 5571, 5512, 11879, 11880, 11881, 11761
4278, 5512, 5571, 5572, 5513, 11881, 11882, 11883, 11763
4279, 5513, 5572, 5573, 5514, 11883, 11884, 11885, 11765
4280, 5514, 5573, 5574, 5515, 11885, 11886, 11887, 11767
4281, 5515, 5574, 5575, 5516, 11887, 11888, 11889, 11769
4282, 5516, 5575, 5576, 5517, 11889, 11890, 11891, 11771
4283, 5517, 5576, 5577, 5518, 11891, 11892, 11893, 11773
4284, 5518, 5577, 5578, 5519, 11893, 11894, 11895, 11775
4285, 5519, 5578, 5579, 5520, 11895, 11896, 11897, 11777
4286, 5520, 5579, 5580, 5521, 11897, 11898, 11899, 11779
4287, 5521, 5580, 5581, 5522, 11899, 11900, 11901, 11781
4288, 5522, 5581, 5582, 5523, 11901, 11902, 11903, 11783
4289, 5523, 5582, 5583, 5524, 11903, 11904, 11905, 11785
4290, 5524, 5583, 5584, 5525, 11905, 11906, 11907, 11787
4291, 5525, 5584, 5585, 5526, 11907, 11908, 11909, 11789
4292, 5526, 5585, 5586, 5527, 11909, 11910, 11911, 11791
4293, 5527, 5586, 5587, 5528, 11911, 11912, 11913, 11793
4294, 5528, 5587, 5588, 5529, 11913, 11914, 11915, 11795
4295, 5529, 5588, 5589, 5530, 11915, 11916, 11917, 11797
4296, 5530, 5589, 5590, 5531, 11917, 11918, 11919, 11799
4297, 5531, 5590, 5591, 5532, 11919, 11920, 11921, 11801
4298, 5532, 5591, 5592, 5533, 11921, 11922, 11923, 11803
4299, 5533, 5592, 5593, 5534, 11923, 11924, 11925, 11805
4300, 5534, 5593, 5594, 5535, 11925, 11926, 11927, 11807
4301, 5535, 5594, 5595, 5536, 11927, 11928, 11929, 11809
4302, 5536, 5595, 5596, 5537, 11929, 11930, 11931, 11811
4303, 5537, 5596, 5597, 5538, 11931, 11932, 11933, 11813
4304, 5538, 5597, 5598, 5539, 11933, 11934, 11935, 11815
4305, 5539, 5598, 5599, 5540, 11935, 11936, 11937, 11817
4306, 5540, 5599, 5600, 5541, 11937, 11938, 11939, 11819
4307, 5541, 5600, 5601, 5542, 11939, 11940, 11941, 11821
4308, 5542, 5601, 5602, 5543, 11941, 11942, 11943, 11823
4309, 5543, 5602, 5603, 5544, 11943, 11944, 11945, 11825
4310, 5544, 5603, 5604, 5545, 11945, 11946, 11947, 11827
4311, 5545, 5604, 5605, 5546, 11947, 11948, 11949, 11829
4312, 5546, 5605, 5606, 5547, 11949, 11950, 11951, 11831
4313, 5547, 5606, 5607, 5548, 11951, 11952, 11953, 11833
4314, 5548, 5607, 5608, 5549, 11953, 11954, 11955, 11835
4315, 5549, 5608, 5609, 5550, 11955, 11956, 11957, 11837
4316, 5550, 5609, 5610, 5551, 11957, 11958, 11959, 11839
4317, 5551, 5610, 5611, 5552, 11959, 11960, 11961, 11841
4318, 5552, 5611, 5612, 5553, 11961, 11962, 11963, 11843
4319, 5553, 5612, 5613, 5554, 11963, 11964, 11965, 11845
4320, 5554, 5613, 5614, 5555, 11965, 11966, 11967, 11847
4321, 5555, 5614, 5615, 5556, 11967, 11968, 11969, 11849
4322, 5556, 5615, 5616, 5557, 11969, 11970, 11971, 11851
4323, 5557, 5616, 5617, 5558, 11971, 11972, 11973, 11853
4324, 5558, 5617, 5618, 5559, 11973, 11974, 11975, 11855
4325, 5559, 5618, 5619, 5560, 11975, 11976, 11977, 11857
4326, 5560, 5619, 5620, 5561, 11977, 11978, 11979, 11859
4327, 5561, 5620, 5621, 5562, 11979, 11980, 11981, 11861
4328, 5562, 5621, 420, 421, 11981, 11982, 480, 11863
4329, 218, 219, 5622, 5563, 278, 11983, 11984, 11864
4330, 5563, 5622, 5623, 5564, 11984, 11985, 11986, 11866
4331, 5564, 5623, 5624, 5565, 11986, 11987, 11988, 11868
4332, 5565, 5624, 5625, 5566, 11988, 11989, 11990, 11870
4333, 5566, 5625, 5626, 5567, 11990, 11991, 11992, 11872
4334, 5567, 5626, 5627, 5568, 11992, 11993, 11994, 11874
4335, 5568, 5627, 5628, 5569, 11994, 11995, 11996, 11876
4336, 5569, 5628, 5629, 5570, 11996, 11997, 11998, 11878
4337, 5570, 5629, 5630, 5571, 11998, 11999, 12000, 11880
4338, 5571, 5630, 5631, 5572, 12000, 12001, 12002, 11882
4339, 5572, 5631, 5632, 5573, 12002, 12003, 12004, 11884
4340, 5573, 5632, 5633, 5574, 12004, 12005, 12006, 11886
4341, 5574, 5633, 5634, 5575, 12006, 12007, 12008, 11888
4342, 5575, 5634, 5635, 5576, 12008, 12009, 12010, 11890
4343, 5576, 5635, 5636, 5577, 12010, 12011, 12012, 11892
4344, 5577, 5636, 5637, 5578, 12012, 12013, 12014, 11894
4345, 5578, 5637, 5638, 5579, 12014, 12015, 12016, 11896
4346, 5579, 5638, 5639, 5580, 12016, 12017, 12018, 11898
4347, 5580, 5639, 5640, 5581, 12018, 12019, 12020, 11900
4348, 5581, 5640, 5641, 5582, 12020, 12021, 12022, 11902
4349, 5582, 5641, 5642, 5583, 12022, 12023, 12024, 11904
4350, 5583, 5642, 5643, 5584, 12024, 12025, 12026, 11906
4351, 5584, 5643, 5644, 5585, 12026, 12027, 12028, 11908
4352, 5585, 5644, 5645, 5586, 12028, 12029, 12030, 11910
4353, 5586, 5645, 5646, 5587, 12030, 12031, 12032, 11912
4354, 5587, 5646, 5647, 5588, 12032, 12033, 12034, 11914
4355, 5588, 5647, 5648, 5589, 12034, 12035, 12036, 11916
4356, 5589, 5648, 5649, 5590, 12036, 12037, 12038, 11918
4357, 5590, 5649, 5650, 5591, 12038, 12039, 12040, 11920
4358, 5591, 5650, 5651, 5592, 12040, 12041, 12042, 11922
4359, 5592, 5651, 5652, 5593, 12042, 12043, 12044, 11924
4360, 5593, 5652, 5653, 5594, 12044, 12045, 12046, 11926
4361, 5594, 5653, 5654, 5595, 12046, 12047, 12048, 11928
4362, 5595, 5654, 5655, 5596, 12048, 12049, 12050, 11930
4363, 5596, 5655, 5656, 5597, 12050, 12051, 12052, 11932
4364, 5597, 5656, 5657, 5598, 12052, 12053, 12054, 11934
4365, 5598, 5657, 5658, 5599, 12054, 12055, 12056, 11936
4366, 5599, 5658, 5659, 5600, 12056, 12057, 12058, 11938
4367, 5600, 5659, 5660, 5601, 12058, 12059, 12060, 11940
4368, 5601, 5660, 5661, 5602, 12060, 12061, 12062, 11942
4369, 5602, 5661, 5662, 5603, 12062, 12063, 12064, 11944
4370, 5603, 5662, 5663, 5604, 12064, 12065, 12066, 11946
4371, 5604, 5663, 5664, 5605, 12066, 12067, 12068, 11948
4372, 5605, 5664, 5665, 5606, 12068, 12069, 12070, 11950
4373, 5606, 5665, 5666, 5607, 12070, 12071, 12072, 11952
4374, 5607, 5666, 5667, 5608, 12072, 12073, 12074, 11954
4375, 5608, 5667, 5668, 5609, 12074, 12075, 12076, 11956
4376, 5609, 5668, 5669, 5610, 12076, 12077, 12078, 11958
4377, 5610, 5669, 5670, 5611, 12078, 12079, 12080, 11960
4378, 5611, 5670, 5671, 5612, 12080, 12081, 12082, 11962
4379, 5612, 5671, 5672, 5613, 12082, 12083, 12084, 11964
4380, 5613, 5672, 5673, 5614, 12084, 12085, 12086, 11966
4381, 5614, 5673, 5674, 5615, 12086, 12087, 12088, 11968
4382, 5615, 5674, 5675, 5616, 12088, 12089, 12090, 11970
4383, 5616, 5675, 5676, 5617, 12090, 12091, 12092, 11972
4384, 5617, 5676, 5677, 5618, 12092, 12093, 12094, 11974
4385, 5618, 5677, 5678, 5619, 12094, 12095, 12096, 11976
4386, 5619, 5678, 5679, 5620, 12096, 12097, 12098, 11978
4387, 5620, 5679, 5680, 5621, 12098, 12099, 12100, 11980
4388, 5621, 5680, 419, 420, 12100, 12101, 479, 11982
4389, 219, 220, 5681, 5622, 279, 12102, 12103, 11983
4390, 5622, 5681, 5682, 5623, 12103, 12104, 12105, 11985
4391, 5623, 5682, 5683, 5624, 12105, 12106, 12107, 11987
4392, 5624, 5683, 5684, 5625, 12107, 12108, 12109, 11989
4393, 5625, 5684, 5685, 5626, 12109, 12110, 12111, 11991
4394, 5626, 5685, 5686, 5627, 12111, 12112, 12113, 11993
4395, 5627, 5686, 5687, 5628, 12113, 12114, 12115, 11995
4396, 5628, 5687, 5688, 5629, 12115, 12116, 12117, 11997
4397, 5629, 5688, 5689, 5630, 12117, 12118, 12119, 11999
4398, 5630, 5689, 5690, 5631, 12119, 12120, 12121, 12001
4399, 5631, 5690, 5691, 5632, 12121, 12122, 12123, 12003
4400, 5632, 5691, 5692, 5633, 12123, 12124, 12125, 12005
4401, 5633, 5692, 5693, 5634, 12125, 12126, 12127, 12007
4402, 5634, 5693, 5694, 5635, 12127, 12128, 12129, 12009
4403, 5635, 5694, 5695, 5636, 12129, 12130, 12131, 12011
4404, 5636, 5695, 5696, 5637, 12131, 12132, 12133, 12013
4405, 5637, 5696, 5697, 5638, 12133, 12134, 12135, 12015
4406, 5638, 5697, 5698, 5639, 12135, 12136, 12137, 12017
4407, 5639, 5698, 5699, 5640, 12137, 12138, 12139, 12019
4408, 5640, 5699, 5700, 5641, 12139, 12140, 12141, 12021
4409, 5641, 5700, 5701, 5642, 12141, 12142, 12143, 12023
4410, 5642, 5701, 5702, 5643, 12143, 12144, 12145, 12025
4411, 5643, 5702, 5703, 5644, 12145, 12146, 12147, 12027
4412, 5644, 5703, 5704, 5645, 12147, 12148, 12149, 12029
4413, 5645, 5704, 5705, 5646, 12149, 12150, 12151, 12031
4414, 5646, 5705, 5706, 5647, 12151, 12152, 12153, 12033
4415, 5647, 5706, 5707, 5648, 12153, 12154, 12155, 12035
4416, 5648, 5707, 5708, 5649, 12155, 12156, 12157, 12037
4417, 5649, 5708, 5709, 5650, 12157, 12158, 12159, 12039
4418, 5650, 5709, 5710, 5651, 12159, 12160, 12161, 12041
4419, 5651, 5710, 5711, 5652, 12161, 12162, 12163, 12043
4420, 5652, 5711, 5712, 5653, 12163, 12164, 12165, 12045
4421, 5653, 5712, 5713, 5654, 12165, 12166, 12167, 12047
4422, 5654, 5713, 5714, 5655, 12167, 12168, 12169, 12049
4423, 5655, 5714, 5715, 5656, 12169, 12170, 12171, 12051
4424, 5656, 5715, 5716, 5657, 12171, 12172, 12173, 12053
4425, 5657, 5716, 5717, 5658, 12173, 12174, 12175, 12055
4426, 5658, 5717, 5718, 5659, 12175, 12176, 12177, 12057
4427, 5659, 5718, 5719, 5660, 12177, 12178, 12179, 12059
4428, 5660, 5719, 5720, 5661, 12179, 12180, 12181, 12061
4429, 5661, 5720, 5721, 5662, 12181, 12182, 12183, 12063
4430, 5662, 5721, 5722, 5663, 12183, 12184, 12185, 12065
4431, 5663, 5722, 5723, 5664, 12185, 12186, 12187, 12067
4432, 5664, 5723, 5724, 5665, 12187, 12188, 12189, 12069
4433, 5665, 5724, 5725, 5666, 12189, 12190, 12191, 12071
4434, 5666, 5725, 5726, 5667, 12191, 12192, 12193, 12073
4435, 5667, 5726, 5727, 5668, 12193, 12194, 12195, 12075
4436, 5668, 5727, 5728, 5669, 12195, 12196, 12197, 12077
4437, 5669, 5728, 5729, 5670, 12197, 12198, 12199, 12079
4438, 5670, 5729, 5730, 5671, 12199, 12200, 12201, 12081
4439, 5671, 5730, 5731, 5672, 12201, 12202, 12203, 12083
4440, 5672, 5731, 5732, 5673, 12203, 12204, 12205, 12085
4441, 5673, 5732, 5733, 5674, 12205, 12206, 12207, 12087
4442, 5674, 5733, 5734, 5675, 12207, 12208, 12209, 12089
4443, 5675, 5734, 5735, 5676, 12209, 12210, 12211, 12091
4444, 5676, 5735, 5736, 5677, 12211, 12212, 12213, 12093
4445, 5677, 5736, 5737, 5678, 12213, 12214, 12215, 12095
4446, 5678, 5737, 5738, 5679, 12215, 12216, 12217, 12097
4447, 5679, 5738, 5739, 5680, 12217, 12218, 12219, 12099
4448, 5680, 5739, 418, 419, 12219, 12220, 478, 12101
4449, 220, 221, 5740, 5681, 280, 12221, 12222, 12102
4450, 5681, 5740, 5741, 5682, 12222, 12223, 12224, 12104
4451, 5682, 5741, 5742, 5683, 12224, 12225, 12226, 12106
4452, 5683, 5742, 5743, 5684, 12226, 12227, 12228, 12108
4453, 5684, 5743, 5744, 5685, 12228, 12229, 12230, 12110
4454, 5685, 5744, 5745, 5686, 12230, 12231, 12232, 12112
4455, 5686, 5745, 5746, 5687, 12232, 12233, 12234, 12114
4456, 5687, 5746, 5747, 5688, 12234, 12235, 12236, 12116
4457, 5688, 5747, 5748, 5689, 12236, 12237, 12238, 12118
4458, 5689, 5748, 5749, 5690, 12238, 12239, 12240, 12120
4459, 5690, 5749, 5750, 5691, 12240, 12241, 12242, 12122
4460, 5691, 5750, 5751, 5692, 12242, 12243, 12244, 12124
4461, 5692, 5751, 5752, 5693, 12244, 12245, 12246, 12126
4462, 5693, 5752, 5753, 5694, 12246, 12247, 12248, 12128
4463, 5694, 5753, 5754, 5695, 12248, 12249, 12250, 12130
4464, 5695, 5754, 5755, 5696, 12250, 12251, 12252, 12132
4465, 5696, 5755, 5756, 5697, 12252, 12253, 12254, 12134
4466, 5697, 5756, 5757, 5698, 12254, 12255, 12256, 12136
4467, 5698, 5757, 5758, 5699, 12256, 12257, 12258, 12138
4468, 5699, 5758, 5759, 5700, 12258, 12259, 12260, 12140
4469, 5700, 5759, 5760, 5701, 12260, 12261, 12262, 12142
4470, 5701, 5760, 5761, 5702, 12262, 12263, 12264, 12144
4471, 5702, 5761, 5762, 5703, 12264, 12265, 12266, 12146
4472, 5703, 5762, 5763, 5704, 12266, 12267, 12268, 12148
4473, 5704, 5763, 5764, 5705, 12268, 12269, 12270, 12150
4474, 5705, 5764, 5765, 5706, 12270, 12271, 12272, 12152
4475, 5706, 5765, 5766, 5707, 12272, 12273, 12274, 12154
4476, 5707, 5766, 5767, 5708, 12274, 12275, 12276, 12156
4477, 5708, 5767, 5768, 5709, 12276, 12277, 12278, 12158
4478, 5709, 5768, 5769, 5710, 12278, 12279, 12280, 12160
4479, 5710, 5769, 5770, 5711, 12280, 12281, 12282, 12162
4480, 5711, 5770, 5771, 5712, 12282, 12283, 12284, 12164
4481, 5712, 5771, 5772, 5713, 12284, 12285, 12286, 12166
4482, 5713, 5772, 5773, 5714, 12286, 12287, 12288, 12168
4483, 5714, 5773, 5774, 5715, 12288, 12289, 12290, 12170
4484, 5715, 5774, 5775, 5716, 12290, 12291, 12292, 12172
4485, 5716, 5775, 5776, 5717, 12292, 12293, 12294, 12174
4486, 5717, 5776, 5777, 5718, 12294, 12295, 12296, 12176
4487, 5718, 5777, 5778, 5719, 12296, 12297, 12298, 12178
4488, 5719, 5778, 5779, 5720, 12298, 12299, 12300, 12180
4489, 5720, 5779, 5780, 5721, 12300, 12301, 12302, 12182
4490, 5721, 5780, 5781, 5722, 12302, 12303, 12304, 12184
4491, 5722, 5781, 5782, 5723, 12304, 12305, 12306, 12186
4492, 5723, 5782, 5783, 5724, 12306, 12307, 12308, 12188
4493, 5724, 5783, 5784, 5725, 12308, 12309, 12310, 12190
4494, 5725, 5784, 5785, 5726, 12310, 12311, 12312, 12192
4495, 5726, 5785, 5786, 5727, 12312, 12313, 12314, 12194
4496, 5727, 5786, 5787, 5728, 12314, 12315, 12316, 12196
4497, 5728, 5787, 5788, 5729, 12316, 12317, 12318, 12198
4498, 5729, 5788, 5789, 5730, 12318, 12319, 12320, 12200
4499, 5730, 5789, 5790, 5731, 12320, 12321, 12322, 12202
4500, 5731, 5790, 5791, 5732, 12322, 12323, 12324, 12204
4501, 5732, 5791, 5792, 5733, 12324, 12325, 12326, 12206
4502, 5733, 5792, 5793, 5734, 12326, 12327, 12328, 12208
4503, 5734, 5793, 5794, 5735, 12328, 12329, 12330, 12210
4504, 5735, 5794, 5795, 5736, 12330, 12331, 12332, 12212
4505, 5736, 5795, 5796, 5737, 12332, 12333, 12334, 12214
4506, 5737, 5796, 5797, 5738, 12334, 12335, 12336, 12216
4507, 5738, 5797, 5798, 5739, 12336, 12337, 12338, 12218
4508, 5739, 5798, 417, 418, 12338, 12339, 477, 12220
4509, 221, 222, 5799, 5740, 281, 12340, 12341, 12221
4510, 5740, 5799, 5800, 5741, 12341, 12342, 12343, 12223
4511, 5741, 5800, 5801, 5742, 12343, 12344, 12345, 12225
4512, 5742, 5801, 5802, 5743, 12345, 12346, 12347, 12227
4513, 5743, 5802, 5803, 5744, 12347, 12348, 12349, 12229
4514, 5744, 5803, 5804, 5745, 12349, 12350, 12351, 12231
4515, 5745, 5804, 5805, 5746, 12351, 12352, 12353, 12233
4516, 5746, 5805, 5806, 5747, 12353, 12354, 12355, 12235
4517, 5747, 5806, 5807, 5748, 12355, 12356, 12357, 12237
4518, 5748, 5807, 5808, 5749, 12357, 12358, 12359, 12239
4519, 5749, 5808, 5809, 5750, 12359, 12360, 12361, 12241
4520, 5750, 5809, 5810, 5751, 12361, 12362, 12363, 12243
4521, 5751, 5810, 5811, 5752, 12363, 12364, 12365, 12245
4522, 5752, 5811, 5812, 5753, 12365, 12366, 12367, 12247
4523, 5753, 5812, 5813, 5754, 12367, 12368, 12369, 12249
4524, 5754, 5813, 5814, 5755, 12369, 12370, 12371, 12251
4525, 5755, 5814, 5815, 5756, 12371, 12372, 12373, 12253
4526, 5756, 5815, 5816, 5757, 12373, 12374, 12375, 12255
4527, 5757, 5816, 5817, 5758, 12375, 12376, 12377, 12257
4528, 5758, 5817, 5818, 5759, 12377, 12378, 12379, 12259
4529, 5759, 5818, 5819, 5760, 12379, 12380, 12381, 12261
4530, 5760, 5819, 5820, 5761, 12381, 12382, 12383, 12263
4531, 5761, 5820, 5821, 5762, 12383, 12384, 12385, 12265
4532, 5762, 5821, 5822, 5763, 12385, 12386, 12387, 12267
4533, 5763, 5822, 5823, 5764, 12387, 12388, 12389, 12269
4534, 5764, 5823, 5824, 5765, 12389, 12390, 12391, 12271
4535, 5765, 5824, 5825, 5766, 12391, 12392, 12393, 12273
4536, 5766, 5825, 5826, 5767, 12393, 12394, 12395, 12275
4537, 5767, 5826, 5827, 5768, 12395, 12396, 12397, 12277
4538, 5768, 5827, 5828, 5769, 12397, 12398, 12399, 12279
4539, 5769, 5828, 5829, 5770, 12399, 12400, 12401, 12281
4540, 5770, 5829, 5830, 5771, 12401, 12402, 12403, 12283
4541, 5771, 5830, 5831, 5772, 12403, 12404, 12405, 12285
4542, 5772, 5831, 5832, 5773, 12405, 12406, 12407, 12287
4543, 5773, 5832, 5833, 5774, 12407, 12408, 12409, 12289
4544, 5774, 5833, 5834, 5775, 12409, 12410, 12411, 12291
4545, 5775, 5834, 5835, 5776, 12411, 12412, 12413, 12293
4546, 5776, 5835, 5836, 5777, 12413, 12414, 12415, 12295
4547, 5777, 5836, 5837, 5778, 12415, 12416, 12417, 12297
4548, 5778, 5837, 5838, 5779, 12417, 12418, 12419, 12299
4549, 5779, 5838, 5839, 5780, 12419, 12420, 12421, 12301
4550, 5780, 5839, 5840, 5781, 12421, 12422, 12423, 12303
4551, 5781, 5840, 5841, 5782, 12423, 12424, 12425, 12305
4552, 5782, 5841, 5842, 5783, 12425, 12426, 12427, 12307
4553, 5783, 5842, 5843, 5784, 12427, 12428, 12429, 12309
4554, 5784, 5843, 5844, 5785, 12429, 12430, 12431, 12311
4555, 5785, 5844, 5845, 5786, 12431, 12432, 12433, 12313
4556, 5786, 5845, 5846, 5787, 12433, 12434, 12435, 12315
4557, 5787, 5846, 5847, 5788, 12435, 12436, 12437, 12317
4558, 5788, 5847, 5848, 5789, 12437, 12438, 12439, 12319
4559, 5789, 5848, 5849, 5790, 12439, 12440, 12441, 12321
4560, 5790, 5849, 5850, 5791, 12441, 12442, 12443, 12323
4561, 5791, 5850, 5851, 5792, 12443, 12444, 12445, 12325
4562, 5792, 5851, 5852, 5793, 12445, 12446, 12447, 12327
4563, 5793, 5852, 5853, 5794, 12447, 12448, 12449, 12329
4564, 5794, 5853, 5854, 5795, 12449, 12450, 12451, 12331
4565, 5795, 5854, 5855, 5796, 12451, 12452, 12453, 12333
4566, 5796, 5855, 5856, 5797, 12453, 12454, 12455, 12335
4567, 5797, 5856, 5857, 5798, 12455, 12456, 12457, 12337
4568, 5798, 5857, 416, 417, 12457, 12458, 476, 12339
4569, 222, 223, 5858, 5799, 282, 12459, 12460, 12340
4570, 5799, 5858, 5859, 5800, 12460, 12461, 12462, 12342
4571, 5800, 5859, 5860, 5801, 12462, 12463, 12464, 12344
4572, 5801, 5860, 5861, 5802, 12464, 12465, 12466, 12346
4573, 5802, 5861, 5862, 5803, 12466, 12467, 12468, 12348
4574, 5803, 5862, 5863, 5804, 12468, 12469, 12470, 12350
4575, 5804, 5863, 5864, 5805, 12470, 12471, 12472, 12352
4576, 5805, 5864, 5865, 5806, 12472, 12473, 12474, 12354
4577, 5806, 5865, 5866, 5807, 12474, 12475, 12476, 12356
4578, 5807, 5866, 5867, 5808, 12476, 12477, 12478, 12358
4579, 5808, 5867, 5868, 5809, 12478, 12479, 12480, 12360
4580, 5809, 5868, 5869, 5810, 12480, 12481, 12482, 12362
4581, 5810, 5869, 5870, 5811, 12482, 12483, 12484, 12364
4582, 5811, 5870, 5871, 5812, 12484, 12485, 12486, 12366
4583, 5812, 5871, 5872, 5813, 12486, 12487, 12488, 12368
4584, 5813, 5872, 5873, 5814, 12488, 12489, 12490, 12370
4585, 5814, 5873, 5874, 5815, 12490, 12491, 12492, 12372
4586, 5815, 5874, 5875, 5816, 12492, 12493, 12494, 12374
4587, 5816, 5875, 5876, 5817, 12494, 12495, 12496, 12376
4588, 5817, 5876, 5877, 5818, 12496, 12497, 12498, 12378
4589, 5818, 5877, 5878, 5819, 12498, 12499, 12500, 12380
4590, 5819, 5878, 5879, 5820, 12500, 12501, 12502, 12382
4591, 5820, 5879, 5880, 5821, 12502, 12503, 12504, 12384
4592, 5821, 5880, 5881, 5822, 12504, 12505, 12506, 12386
4593, 5822, 5881, 5882, 5823, 12506, 12507, 12508, 12388
4594, 5823, 5882, 5883, 5824, 12508, 12509, 12510, 12390
4595, 5824, 5883, 5884, 5825, 12510, 12511, 12512, 12392
4596, 5825, 5884, 5885, 5826, 12512, 12513, 12514, 12394
4597, 5826, 5885, 5886, 5827, 12514, 12515, 12516, 12396
4598, 5827, 5886, 5887, 5828, 12516, 12517, 12518, 12398
4599, 5828, 5887, 5888, 5829, 12518, 12519, 12520, 12400
4600, 5829, 5888, 5889, 5830, 12520, 12521, 12522, 12402
4601, 5830, 5889, 5890, 5831, 12522, 12523, 12524, 12404
4602, 5831, 5890, 5891, 5832, 12524, 12525, 12526, 12406
4603, 5832, 5891, 5892, 5833, 12526, 12527, 12528, 12408
4604, 5833, 5892, 5893, 5834, 12528, 12529, 12530, 12410
4605, 5834, 5893, 5894, 5835, 12530, 12531, 12532, 12412
4606, 5835, 5894, 5895, 5836, 12532, 12533, 12534, 12414
4607, 5836, 5895, 5896, 5837, 12534, 12535, 12536, 12416
4608, 5837, 5896, 5897, 5838, 12536, 12537, 12538, 12418
4609, 5838, 5897, 5898, 5839, 12538, 12539, 12540, 12420
4610, 5839, 5898, 5899, 5840, 12540, 12541, 12542, 12422
4611, 5840, 5899, 5900, 5841, 12542, 12543, 12544, 12424
4612, 5841, 5900, 5901, 5842, 12544, 12545, 12546, 12426
4613, 5842, 5901, 5902, 5843, 12546, 12547, 12548, 12428
4614, 5843, 5902, 5903, 5844, 12548, 12549, 12550, 12430
4615, 5844, 5903, 5904, 5845, 12550, 12551, 12552, 12432
4616, 5845, 5904, 5905, 5846, 12552, 12553, 12554, 12434
4617, 5846, 5905, 5906, 5847, 12554, 12555, 12556, 12436
4618, 5847, 5906, 5907, 5848, 12556, 12557, 12558, 12438
4619, 5848, 5907, 5908, 5849, 12558, 12559, 12560, 12440
4620, 5849, 5908, 5909, 5850, 12560, 12561, 12562, 12442
4621, 5850, 5909, 5910, 5851, 12562, 12563, 12564, 12444
4622, 5851, 5910, 5911, 5852, 12564, 12565, 12566, 12446
4623, 5852, 5911, 5912, 5853, 12566, 12567, 12568, 12448
4624, 5853, 5912, 5913, 5854, 12568, 12569, 12570, 12450
4625, 5854, 5913, 5914, 5855, 12570, 12571, 12572, 12452
4626, 5855, 5914, 5915, 5856, 12572, 12573, 12574, 12454
4627, 5856, 5915, 5916, 5857, 12574, 12575, 12576, 12456
4628, 5857, 5916, 415, 416, 12576, 12577, 475, 12458
4629, 223, 224, 5917, 5858, 283, 12578, 12579, 12459
4630, 5858, 5917, 5918, 5859, 12579, 12580, 12581, 12461
4631, 5859, 5918, 5919, 5860, 12581, 12582, 12583, 12463
4632, 5860, 5919, 5920, 5861, 12583, 12584, 12585, 12465
4633, 5861, 5920, 5921, 5862, 12585, 12586, 12587, 12467
4634, 5862, 5921, 5922, 5863, 12587, 12588, 12589, 12469
4635, 5863, 5922, 5923, 5864, 12589, 12590, 12591, 12471
4636, 5864, 5923, 5924, 5865, 12591, 12592, 12593, 12473
4637, 5865, 5924, 5925, 5866, 12593, 12594, 12595, 12475
4638, 5866, 5925, 5926, 5867, 12595, 12596, 12597, 12477
4639, 5867, 5926, 5927, 5868, 12597, 12598, 12599, 12479
4640, 5868, 5927, 5928, 5869, 12599, 12600, 12601, 12481
4641, 5869, 5928, 5929, 5870, 12601, 12602, 12603, 12483
4642, 5870, 5929, 5930, 5871, 12603, 12604, 12605, 12485
4643, 5871, 5930, 5931, 5872, 12605, 12606, 12607, 12487
4644, 5872, 5931, 5932, 5873, 12607, 12608, 12609, 12489
4645, 5873, 5932, 5933, 5874, 12609, 12610, 12611, 12491
4646, 5874, 5933, 5934, 5875, 12611, 12612, 12613, 12493
4647, 5875, 5934, 5935, 5876, 12613, 12614, 12615, 12495
4648, 5876, 5935, 5936, 5877, 12615, 12616, 12617, 12497
4649, 5877, 5936, 5937, 5878, 12617, 12618, 12619, 12499
4650, 5878, 5937, 5938, 5879, 12619, 12620, 12621, 12501
4651, 5879, 5938, 5939, 5880, 12621, 12622, 12623, 12503
4652, 5880, 5939, 5940, 5881, 12623, 12624, 12625, 12505
4653, 5881, 5940, 5941, 5882, 12625, 12626, 12627, 12507
4654, 5882, 5941, 5942, 5883, 12627, 12628, 12629, 12509
4655, 5883, 5942, 5943, 5884, 12629, 12630, 12631, 12511
4656, 5884, 5943, 5944, 5885, 12631, 12632, 12633, 12513
4657, 5885, 5944, 5945, 5886, 12633, 12634, 12635, 12515
4658, 5886, 5945, 5946, 5887, 12635, 12636, 12637, 12517
4659, 5887, 5946, 5947, 5888, 12637, 12638, 12639, 12519
4660, 5888, 5947, 5948, 5889, 12639, 12640, 12641, 12521
4661, 5889, 5948, 5949, 5890, 12641, 12642, 12643, 12523
4662, 5890, 5949, 5950, 5891, 12643, 12644, 12645, 12525
4663, 5891, 5950, 5951, 5892, 12645, 12646, 12647, 12527
4664, 5892, 5951, 5952, 5893, 12647, 12648, 12649, 12529
4665, 5893, 5952, 5953, 5894, 12649, 12650, 12651, 12531
4666, 5894, 5953, 5954, 5895, 12651, 12652, 12653, 12533
4667, 5895, 5954, 5955, 5896, 12653, 12654, 12655, 12535
4668, 5896, 5955, 5956, 5897, 12655, 12656, 12657, 12537
4669, 5897, 5956, 5957, 5898, 12657, 12658, 12659, 12539
4670, 5898, 5957, 5958, 5899, 12659, 12660, 12661, 12541
4671, 5899, 5958, 5959, 5900, 12661, 12662, 12663, 12543
4672, 5900, 5959, 5960, 5901, 12663, 12664, 12665, 12545
4673, 5901, 5960, 5961, 5902, 12665, 12666, 12667, 12547
4674, 5902, 5961, 5962, 5903, 12667, 12668, 12669, 12549
4675, 5903, 5962, 5963, 5904, 12669, 12670, 12671, 12551
4676, 5904, 5963, 5964, 5905, 12671, 12672, 12673, 12553
4677, 5905, 5964, 5965, 5906, 12673, 12674, 12675, 12555
4678, 5906, 5965, 5966, 5907, 12675, 12676, 12677, 12557
4679, 5907, 5966, 5967, 5908, 12677, 12678, 12679, 12559
4680, 5908, 5967, 5968, 5909, 12679, 12680, 12681, 12561
4681, 5909, 5968, 5969, 5910, 12681, 12682, 12683, 12563
4682, 5910, 5969, 5970, 5911, 12683, 12684, 12685, 12565
4683, 5911, 5970, 5971, 5912, 12685, 12686, 12687, 12567
4684, 5912, 5971, 5972, 5913, 12687, 12688, 12689, 12569
4685, 5913, 5972, 5973, 5914, 12689, 12690, 12691, 12571
4686, 5914, 5973, 5974, 5915, 12691, 12692, 12693, 12573
4687, 5915, 5974, 5975, 5916, 12693, 12694, 12695, 12575
4688, 5916, 5975, 414, 415, 12695, 12696, 474, 12577
4689, 224, 225, 5976, 5917, 284, 12697, 12698, 12578
4690, 5917, 5976, 5977, 5918, 12698, 12699, 12700, 12580
4691, 5918, 5977, 5978, 5919, 12700, 12701, 12702, 12582
4692, 5919, 5978, 5979, 5920, 12702, 12703, 12704, 12584
4693, 5920, 5979, 5980, 5921, 12704, 12705, 12706, 12586
4694, 5921, 5980, 5981, 5922, 12706, 12707, 12708, 12588
4695, 5922, 5981, 5982, 5923, 12708, 12709, 12710, 12590
4696, 5923, 5982, 5983, 5924, 12710, 12711, 12712, 12592
4697, 5924, 5983, 5984, 5925, 12712, 12713, 12714, 12594
4698, 5925, 5984, 5985, 5926, 12714, 12715, 12716, 12596
4699, 5926, 5985, 5986, 5927, 12716, 12717, 12718, 12598
4700, 5927, 5986, 5987, 5928, 12718, 12719, 12720, 12600
4701, 5928, 5987, 5988, 5929, 12720, 12721, 12722, 12602
4702, 5929, 5988, 5989, 5930, 12722, 12723, 12724, 12604
4703, 5930, 5989, 5990, 5931, 12724, 12725, 12726, 12606
4704, 5931, 5990, 5991, 5932, 12726, 12727, 12728, 12608
4705, 5932, 5991, 5992, 5933, 12728, 12729, 12730, 12610
4706, 5933, 5992, 5993, 5934, 12730, 12731, 12732, 12612
4707, 5934, 5993, 5994, 5935, 12732, 12733, 12734, 12614
4708, 5935, 5994, 5995, 5936, 12734, 12735, 12736, 12616
4709, 5936, 5995, 5996, 5937, 12736, 12737, 12738, 12618
4710, 5937, 5996, 5997, 5938, 12738, 12739, 12740, 12620
4711, 5938, 5997, 5998, 5939, 12740, 12741, 12742, 12622
4712, 5939, 5998, 5999, 5940, 12742, 12743, 12744, 12624
4713, 5940, 5999, 6000, 5941, 12744, 12745, 12746, 12626
4714, 5941, 6000, 6001, 5942, 12746, 12747, 12748, 12628
4715, 5942, 6001, 6002, 5943, 12748, 12749, 12750, 12630
4716, 5943, 6002, 6003, 5944, 12750, 12751, 12752, 12632
4717, 5944, 6003, 6004, 5945, 12752, 12753, 12754, 12634
4718, 5945, 6004, 6005, 5946, 12754, 12755, 12756, 12636
4719, 5946, 6005, 6006, 5947, 12756, 12757, 12758, 12638
4720, 5947, 6006, 6007, 5948, 12758, 12759, 12760, 12640
4721, 5948, 6007, 6008, 5949, 12760, 12761, 12762, 12642
4722, 5949, 6008, 6009, 5950, 12762, 12763, 12764, 12644
4723, 5950, 6009, 6010, 5951, 12764, 12765, 12766, 12646
4724, 5951, 6010, 6011, 5952, 12766, 12767, 12768, 12648
4725, 5952, 6011, 6012, 5953, 12768, 12769, 12770, 12650
4726, 5953, 6012, 6013, 5954, 12770, 12771, 12772, 12652
4727, 5954, 6013, 6014, 5955, 12772, 12773, 12774, 12654
4728, 5955, 6014, 6015, 5956, 12774, 12775, 12776, 12656
4729, 5956, 6015, 6016, 5957, 12776, 12777, 12778, 12658
4730, 5957, 6016, 6017, 5958, 12778, 12779, 12780, 12660
4731, 5958, 6017, 6018, 5959, 12780, 12781, 12782, 12662
4732, 5959, 6018, 6019, 5960, 12782, 12783, 12784, 12664
4733, 5960, 6019, 6020, 5961, 12784, 12785, 12786, 12666
4734, 5961, 6020, 6021, 5962, 12786, 12787, 12788, 12668
4735, 5962, 6021, 6022, 5963, 12788, 12789, 12790, 12670
4736, 5963, 6022, 6023, 5964, 12790, 12791, 12792, 12672
4737, 5964, 6023, 6024, 5965, 12792, 12793, 12794, 12674
4738, 5965, 6024, 6025, 5966, 12794, 12795, 12796, 12676
4739, 5966, 6025, 6026, 5967, 12796, 12797, 12798, 12678
4740, 5967, 6026, 6027, 5968, 12798, 12799, 12800, 12680
4741, 5968, 6027, 6028, 5969, 12800, 12801, 12802, 12682
4742, 5969, 6028, 6029, 5970, 12802, 12803, 12804, 12684
4743, 5970, 6029, 6030, 5971, 12804, 12805, 12806, 12686
4744, 5971, 6030, 6031, 5972, 12806, 12807, 12808, 12688
4745, 5972, 6031, 6032, 5973, 12808, 12809, 12810, 12690
4746, 5973, 6032, 6033, 5974, 12810, 12811, 12812, 12692
4747, 5974, 6033, 6034, 5975, 12812, 12813, 12814, 12694
4748, 5975, 6034, 413, 414, 12814, 12815, 473, 12696
4749, 225, 226, 6035, 5976, 285, 12816, 12817, 12697
4750, 5976, 6035, 6036, 5977, 12817, 12818, 12819, 12699
4751, 5977, 6036, 6037, 5978, 12819, 12820, 12821, 12701
4752, 5978, 6037, 6038, 5979, 12821, 12822, 12823, 12703
4753, 5979, 6038, 6039, 5980, 12823, 12824, 12825, 12705
4754, 5980, 6039, 6040, 5981, 12825, 12826, 12827, 12707
4755, 5981, 6040, 6041, 5982, 12827, 12828, 12829, 12709
4756, 5982, 6041, 6042, 5983, 12829, 12830, 12831, 12711
4757, 5983, 6042, 6043, 5984, 12831, 12832, 12833, 12713
4758, 5984, 6043, 6044, 5985, 12833, 12834, 12835, 12715
4759, 5985, 6044, 6045, 5986, 12835, 12836, 12837, 12717
4760, 5986, 6045, 6046, 5987, 12837, 12838, 12839, 12719
4761, 5987, 6046, 6047, 5988, 12839, 12840, 12841, 12721
4762, 5988, 6047, 6048, 5989, 12841, 12842, 12843, 12723
4763, 5989, 6048, 6049, 5990, 12843, 12844, 12845, 12725
4764, 5990, 6049, 6050, 5991, 12845, 12846, 12847, 12727
4765, 5991, 6050, 6051, 5992, 12847, 12848, 12849, 12729
4766, 5992, 6051, 6052, 5993, 12849, 12850, 12851, 12731
4767, 5993, 6052, 6053, 5994, 12851, 12852, 12853, 12733
4768, 5994, 6053, 6054, 5995, 12853, 12854, 12855, 12735
4769, 5995, 6054, 6055, 5996, 12855, 12856, 12857, 12737
4770, 5996, 6055, 6056, 5997, 12857, 12858, 12859, 12739
4771, 5997, 6056, 6057, 5998, 12859, 12860, 12861, 12741
4772, 5998, 6057, 6058, 5999, 12861, 12862, 12863, 12743
4773, 5999, 6058, 6059, 6000, 12863, 12864, 12865, 12745
4774, 6000, 6059, 6060, 6001, 12865, 12866, 12867, 12747
4775, 6001, 6060, 6061, 6002, 12867, 12868, 12869, 12749
4776, 6002, 6061, 6062, 6003, 12869, 12870, 12871, 12751
4777, 6003, 6062, 6063, 6004, 12871, 12872, 12873, 12753
4778, 6004, 6063, 6064, 6005, 12873, 12874, 12875, 12755
4779, 6005, 6064, 6065, 6006, 12875, 12876, 12877, 12757
4780, 6006, 6065, 6066, 6007, 12877, 12878, 12879, 12759
4781, 6007, 6066, 6067, 6008, 12879, 12880, 12881, 12761
4782, 6008, 6067, 6068, 6009, 12881, 12882, 12883, 12763
4783, 6009, 6068, 6069, 6010, 12883, 12884, 12885, 12765
4784, 6010, 6069, 6070, 6011, 12885, 12886, 12887, 12767
4785, 6011, 6070, 6071, 6012, 12887, 12888, 12889, 12769
4786, 6012, 6071, 6072, 6013, 12889, 12890, 12891, 12771
4787, 6013, 6072, 6073, 6014, 12891, 12892, 12893, 12773
4788, 6014, 6073, 6074, 6015, 12893, 12894, 12895, 12775
4789, 6015, 6074, 6075, 6016, 12895, 12896, 12897, 12777
4790, 6016, 6075, 6076, 6017, 12897, 12898, 12899, 12779
4791, 6017, 6076, 6077, 6018, 12899, 12900, 12901, 12781
4792, 6018, 6077, 6078, 6019, 12901, 12902, 12903, 12783
4793, 6019, 6078, 6079, 6020, 12903, 12904, 12905, 12785
4794, 6020, 6079, 6080, 6021, 12905, 12906, 12907, 12787
4795, 6021, 6080, 6081, 6022, 12907, 12908, 12909, 12789
4796, 6022, 6081, 6082, 6023, 12909, 12910, 12911, 12791
4797, 6023, 6082, 6083, 6024, 12911, 12912, 12913, 12793
4798, 6024, 6083, 6084, 6025, 12913, 12914, 12915, 12795
4799, 6025, 6084, 6085, 6026, 12915, 12916, 12917, 12797
4800, 6026, 6085, 6086, 6027, 12917, 12918, 12919, 12799
4801, 6027, 6086, 6087, 6028, 12919, 12920, 12921, 12801
4802, 6028, 6087, 6088, 6029, 12921, 12922, 12923, 12803
4803, 6029, 6088, 6089, 6030, 12923, 12924, 12925, 12805
4804, 6030, 6089, 6090, 6031, 12925, 12926, 12927, 12807
4805, 6031, 6090, 6091, 6032, 12927, 12928, 12929, 12809
4806, 6032, 6091, 6092, 6033, 12929, 12930, 12931, 12811
4807, 6033, 6092, 6093, 6034, 12931, 12932, 12933, 12813
4808, 6034, 6093, 412, 413, 12933, 12934, 472, 12815
4809, 226, 227, 6094, 6035, 286, 12935, 12936, 12816
4810, 6035, 6094, 6095, 6036, 12936, 12937, 12938, 12818
4811, 6036, 6095, 6096, 6037, 12938, 12939, 12940, 12820
4812, 6037, 6096, 6097, 6038, 12940, 12941, 12942, 12822
4813, 6038, 6097, 6098, 6039, 12942, 12943, 12944, 12824
4814, 6039, 6098, 6099, 6040, 12944, 12945, 12946, 12826
4815, 6040, 6099, 6100, 6041, 12946, 12947, 12948, 12828
4816, 6041, 6100, 6101, 6042, 12948, 12949, 12950, 12830
4817, 6042, 6101, 6102, 6043, 12950, 12951, 12952, 12832
4818, 6043, 6102, 6103, 6044, 12952, 12953, 12954, 12834
4819, 6044, 6103, 6104, 6045, 12954, 12955, 12956, 12836
4820, 6045, 6104, 6105, 6046, 12956, 12957, 12958, 12838
4821, 6046, 6105, 6106, 6047, 12958, 12959, 12960, 12840
4822, 6047, 6106, 6107, 6048, 12960, 12961, 12962, 12842
4823, 6048, 6107, 6108, 6049, 12962, 12963, 12964, 12844
4824, 6049, 6108, 6109, 6050, 12964, 12965, 12966, 12846
4825, 6050, 6109, 6110, 6051, 12966, 12967, 12968, 12848
4826, 6051, 6110, 6111, 6052, 12968, 12969, 12970, 12850
4827, 6052, 6111, 6112, 6053, 12970, 12971, 12972, 12852
4828, 6053, 6112, 6113, 6054, 12972, 12973, 12974, 12854
4829, 6054, 6113, 6114, 6055, 12974, 12975, 12976, 12856
4830, 6055, 6114, 6115, 6056, 12976, 12977, 12978, 12858
4831, 6056, 6115, 6116, 6057, 12978, 12979, 12980, 12860
4832, 6057, 6116, 6117, 6058, 12980, 12981, 12982, 12862
4833, 6058, 6117, 6118, 6059, 12982, 12983, 12984, 12864
4834, 6059, 6118, 6119, 6060, 12984, 12985, 12986, 12866
4835, 6060, 6119, 6120, 6061, 12986, 12987, 12988, 12868
4836, 6061, 6120, 6121, 6062, 12988, 12989, 12990, 12870
4837, 6062, 6121, 6122, 6063, 12990, 12991, 12992, 12872
4838, 6063, 6122, 6123, 6064, 12992, 12993, 12994, 12874
4839, 6064, 6123, 6124, 6065, 12994, 12995, 12996, 12876
4840, 6065, 6124, 6125, 6066, 12996, 12997, 12998, 12878
4841, 6066, 6125, 6126, 6067, 12998, 12999, 13000, 12880
4842, 6067, 6126, 6127, 6068, 13000, 13001, 13002, 12882
4843, 6068, 6127, 6128, 6069, 13002, 13003, 13004, 12884
4844, 6069, 6128, 6129, 6070, 13004, 13005, 13006, 12886
4845, 6070, 6129, 6130, 6071, 13006, 13007, 13008, 12888
4846, 6071, 6130, 6131, 6072, 13008, 13009, 13010, 12890
4847, 6072, 6131, 6132, 6073, 13010, 13011, 13012, 12892
4848, 6073, 6132, 6133, 6074, 13012, 13013, 13014, 12894
4849, 6074, 6133, 6134, 6075, 13014, 13015, 13016, 12896
4850, 6075, 6134, 6135, 6076, 13016, 13017, 13018, 12898
4851, 6076, 6135, 6136, 6077, 13018, 13019, 13020, 12900
4852, 6077, 6136, 6137, 6078, 13020, 13021, 13022, 12902
4853, 6078, 6137, 6138, 6079, 13022, 13023, 13024, 12904
4854, 6079, 6138, 6139, 6080, 13024, 13025, 13026, 12906
4855, 6080, 6139, 6140, 6081, 13026, 13027, 13028, 12908
4856, 6081, 6140, 6141, 6082, 13028, 13029, 13030, 12910
4857, 6082, 6141, 6142, 6083, 13030, 13031, 13032, 12912
4858, 6083, 6142, 6143, 6084, 13032, 13033, 13034, 12914
4859, 6084, 6143, 6144, 6085, 13034, 13035, 13036, 12916
4860, 6085, 6144, 6145, 6086, 13036, 13037, 13038, 12918
4861, 6086, 6145, 6146, 6087, 13038, 13039, 13040, 12920
4862, 6087, 6146, 6147, 6088, 13040, 13041, 13042, 12922
4863, 6088, 6147, 6148, 6089, 13042, 13043, 13044, 12924
4864, 6089, 6148, 6149, 6090, 13044, 13045, 13046, 12926
4865, 6090, 6149, 6150, 6091, 13046, 13047, 13048, 12928
4866, 6091, 6150, 6151, 6092, 13048, 13049, 13050, 12930
4867, 6092, 6151, 6152, 6093, 13050, 13051, 13052, 12932
4868, 6093, 6152, 411, 412, 13052, 13053, 471, 12934
4869, 227, 228, 6153, 6094, 287, 13054, 13055, 12935
4870, 6094, 6153, 6154, 6095, 13055, 13056, 13057, 12937
4871, 6095, 6154, 6155, 6096, 13057, 13058, 13059, 12939
4872, 6096, 6155, 6156, 6097, 13059, 13060, 13061, 12941
4873, 6097, 6156, 6157, 6098, 13061, 13062, 13063, 12943
4874, 6098, 6157, 6158, 6099, 13063, 13064, 13065, 12945
4875, 6099, 6158, 6159, 6100, 13065, 13066, 13067, 12947
4876, 6100, 6159, 6160, 6101, 13067, 13068, 13069, 12949
4877, 6101, 6160, 6161, 6102, 13069, 13070, 13071, 12951
4878, 6102, 6161, 6162, 6103, 13071, 13072, 13073, 12953
4879, 6103, 6162, 6163, 6104, 13073, 13074, 13075, 12955
4880, 6104, 6163, 6164, 6105, 13075, 13076, 13077, 12957
4881, 6105, 6164, 6165, 6106, 13077, 13078, 13079, 12959
4882, 6106, 6165, 6166, 6107, 13079, 13080, 13081, 12961
4883, 6107, 6166, 6167, 6108, 13081, 13082, 13083, 12963
4884, 6108, 6167, 6168, 6109, 13083, 13084, 13085, 12965
4885, 6109, 6168, 6169, 6110, 13085, 13086, 13087, 12967
4886, 6110, 6169, 6170, 6111, 13087, 13088, 13089, 12969
4887, 6111, 6170, 6171, 6112, 13089, 13090, 13091, 12971
4888, 6112, 6171, 6172, 6113, 13091, 13092, 13093, 12973
4889, 6113, 6172, 6173, 6114, 13093, 13094, 13095, 12975
4890, 6114, 6173, 6174, 6115, 13095, 13096, 13097, 12977
4891, 6115, 6174, 6175, 6116, 13097, 13098, 13099, 12979
4892, 6116, 6175, 6176, 6117, 13099, 13100, 13101, 12981
4893, 6117, 6176, 6177, 6118, 13101, 13102, 13103, 12983
4894, 6118, 6177, 6178, 6119, 13103, 13104, 13105, 12985
4895, 6119, 6178, 6179, 6120, 13105, 13106, 13107, 12987
4896, 6120, 6179, 6180, 6121, 13107, 13108, 13109, 12989
4897, 6121, 6180, 6181, 6122, 13109, 13110, 13111, 12991
4898, 6122, 6181, 6182, 6123, 13111, 13112, 13113, 12993
4899, 6123, 6182, 6183, 6124, 13113, 13114, 13115, 12995
4900, 6124, 6183, 6184, 6125, 13115, 13116, 13117, 12997
4901, 6125, 6184, 6185, 6126, 13117, 13118, 13119, 12999
4902, 6126, 6185, 6186, 6127, 13119, 13120, 13121, 13001
4903, 6127, 6186, 6187, 6128, 13121, 13122, 13123, 13003
4904, 6128, 6187, 6188, 6129, 13123, 13124, 13125, 13005
4905, 6129, 6188, 6189, 6130, 13125, 13126, 13127, 13007
4906, 6130, 6189, 6190, 6131, 13127, 13128, 13129, 13009
4907, 6131, 6190, 6191, 6132, 13129, 13130, 13131, 13011
4908, 6132, 6191, 6192, 6133, 13131, 13132, 13133, 13013
4909, 6133, 6192, 6193, 6134, 13133, 13134, 13135, 13015
4910, 6134, 6193, 6194, 6135, 13135, 13136, 13137, 13017
4911, 6135, 6194, 6195, 6136, 13137, 13138, 13139, 13019
4912, 6136, 6195, 6196, 6137, 13139, 13140, 13141, 13021
4913, 6137, 6196, 6197, 6138, 13141, 13142, 13143, 13023
4914, 6138, 6197, 6198, 6139, 13143, 13144, 13145, 13025
4915, 6139, 6198, 6199, 6140, 13145, 13146, 13147, 13027
4916, 6140, 6199, 6200, 6141, 13147, 13148, 13149, 13029
4917, 6141, 6200, 6201, 6142, 13149, 13150, 13151, 13031
4918, 6142, 6201, 6202, 6143, 13151, 13152, 13153, 13033
4919, 6143, 6202, 6203, 6144, 13153, 13154, 13155, 13035
4920, 6144, 6203, 6204, 6145, 13155, 13156, 13157, 13037
4921, 6145, 6204, 6205, 6146, 13157, 13158, 13159, 13039
4922, 6146, 6205, 6206, 6147, 13159, 13160, 13161, 13041
4923, 6147, 6206, 6207, 6148, 13161, 13162, 13163, 13043
4924, 6148, 6207, 6208, 6149, 13163, 13164, 13165, 13045
4925, 6149, 6208, 6209, 6150, 13165, 13166, 13167, 13047
4926, 6150, 6209, 6210, 6151, 13167, 13168, 13169, 13049
4927, 6151, 6210, 6211, 6152, 13169, 13170, 13171, 13051
4928, 6152, 6211, 410, 411, 13171, 13172, 470, 13053
4929, 228, 229, 6212, 6153, 288, 13173, 13174, 13054
4930, 6153, 6212, 6213, 6154, 13174, 13175, 13176, 13056
4931, 6154, 6213, 6214, 6155, 13176, 13177, 13178, 13058
4932, 6155, 6214, 6215, 6156, 13178, 13179, 13180, 13060
4933, 6156, 6215, 6216, 6157, 13180, 13181, 13182, 13062
4934, 6157, 6216, 6217, 6158, 13182, 13183, 13184, 13064
4935, 6158, 6217, 6218, 6159, 13184, 13185, 13186, 13066
4936, 6159, 6218, 6219, 6160, 13186, 13187, 13188, 13068
4937, 6160, 6219, 6220, 6161, 13188, 13189, 13190, 13070
4938, 6161, 6220, 6221, 6162, 13190, 13191, 13192, 13072
4939, 6162, 6221, 6222, 6163, 13192, 13193, 13194, 13074
4940, 6163, 6222, 6223, 6164, 13194, 13195, 13196, 13076
4941, 6164, 6223, 6224, 6165, 13196, 13197, 13198, 13078
4942, 6165, 6224, 6225, 6166, 13198, 13199, 13200, 13080
4943, 6166, 6225, 6226, 6167, 13200, 13201, 13202, 13082
4944, 6167, 6226, 6227, 6168, 13202, 13203, 13204, 13084
4945, 6168, 6227, 6228, 6169, 13204, 13205, 13206, 13086
4946, 6169, 6228, 6229, 6170, 13206, 13207, 13208, 13088
4947, 6170, 6229, 6230, 6171, 13208, 13209, 13210, 13090
4948, 6171, 6230, 6231, 6172, 13210, 13211, 13212, 13092
4949, 6172, 6231, 6232, 6173, 13212, 13213, 13214, 13094
4950, 6173, 6232, 6233, 6174, 13214, 13215, 13216, 13096
4951, 6174, 6233, 6234, 6175, 13216, 13217, 13218, 13098
4952, 6175, 6234, 6235, 6176, 13218, 13219, 13220, 13100
4953, 6176, 6235, 6236, 6177, 13220, 13221, 13222, 13102
4954, 6177, 6236, 6237, 6178, 13222, 13223, 13224, 13104
4955, 6178, 6237, 6238, 6179, 13224, 13225, 13226, 13106
4956, 6179, 6238, 6239, 6180, 13226, 13227, 13228, 13108
4957, 6180, 6239, 6240, 6181, 13228, 13229, 13230, 13110
4958, 6181, 6240, 6241, 6182, 13230, 13231, 13232, 13112
4959, 6182, 6241, 6242, 6183, 13232, 13233, 13234, 13114
4960, 6183, 6242, 6243, 6184, 13234, 13235, 13236, 13116
4961, 6184, 6243, 6244, 6185, 13236, 13237, 13238, 13118
4962, 6185, 6244, 6245, 6186, 13238, 13239, 13240, 13120
4963, 6186, 6245, 6246, 6187, 13240, 13241, 13242, 13122
4964, 6187, 6246, 6247, 6188, 13242, 13243, 13244, 13124
4965, 6188, 6247, 6248, 6189, 13244, 13245, 13246, 13126
4966, 6189, 6248, 6249, 6190, 13246, 13247, 13248, 13128
4967, 6190, 6249, 6250, 6191, 13248, 13249, 13250, 13130
4968, 6191, 6250, 6251, 6192, 13250, 13251, 13252, 13132
4969, 6192, 6251, 6252, 6193, 13252, 13253, 13254, 13134
4970, 6193, 6252, 6253, 6194, 13254, 13255, 13256, 13136
4971, 6194, 6253, 6254, 6195, 13256, 13257, 13258, 13138
4972, 6195, 6254, 6255, 6196, 13258, 13259, 13260, 13140
4973, 6196, 6255, 6256, 6197, 13260, 13261, 13262, 13142
4974, 6197, 6256, 6257, 6198, 13262, 13263, 13264, 13144
4975, 6198, 6257, 6258, 6199, 13264, 13265, 13266, 13146
4976, 6199, 6258, 6259, 6200, 13266, 13267, 13268, 13148
4977, 6200, 6259, 6260, 6201, 13268, 13269, 13270, 13150
4978, 6201, 6260, 6261, 6202, 13270, 13271, 13272, 13152
4979, 6202, 6261, 6262, 6203, 13272, 13273, 13274, 13154
4980, 6203, 6262, 6263, 6204, 13274, 13275, 13276, 13156
4981, 6204, 6263, 6264, 6205, 13276, 13277, 13278, 13158
4982, 6205, 6264, 6265, 6206, 13278, 13279, 13280, 13160
4983, 6206, 6265, 6266, 6207, 13280, 13281, 13282, 13162
4984, 6207, 6266, 6267, 6208, 13282, 13283, 13284, 13164
4985, 6208, 6267, 6268, 6209, 13284, 13285, 13286, 13166
4986, 6209, 6268, 6269, 6210, 13286, 13287, 13288, 13168
4987, 6210, 6269, 6270, 6211, 13288, 13289, 13290, 13170
4988, 6211, 6270, 409, 410, 13290, 13291, 469, 13172
4989, 229, 6, 290, 6212, 289, 349, 13292, 13173
4990, 6212, 290, 291, 6213, 13292, 350, 13293, 13175
4991, 6213, 291, 292, 6214, 13293, 351, 13294, 13177
4992, 6214, 292, 293, 6215, 13294, 352, 13295, 13179
4993, 6215, 293, 294, 6216, 13295, 353, 13296, 13181
4994, 6216, 294, 295, 6217, 13296, 354, 13297, 13183
4995, 6217, 295, 296, 6218, 13297, 355, 13298, 13185
4996, 6218, 296, 297, 6219, 13298, 356, 13299, 13187
4997, 6219, 297, 298, 6220, 13299, 357, 13300, 13189
4998, 6220, 298, 299, 6221, 13300, 358, 13301, 13191
4999, 6221, 299, 300, 6222, 13301, 359, 13302, 13193
5000, 6222, 300, 301, 6223, 13302, 360, 13303, 13195
5001, 6223, 301, 302, 6224, 13303, 361, 13304, 13197
5002, 6224, 302, 303, 6225, 13304, 362, 13305, 13199
5003, 6225, 303, 304, 6226, 13305, 363, 13306, 13201
5004, 6226, 304, 305, 6227, 13306, 364, 13307, 13203
5005, 6227, 305, 306, 6228, 13307, 365, 13308, 13205
5006, 6228, 306, 307, 6229, 13308, 366, 13309, 13207
5007, 6229, 307, 308, 6230, 13309, 367, 13310, 13209
5008, 6230, 308, 309, 6231, 13310, 368, 13311, 13211
5009, 6231, 309, 310, 6232, 13311, 369, 13312, 13213
5010, 6232, 310, 311, 6233, 13312, 370, 13313, 13215
5011, 6233, 311, 312, 6234, 13313, 371, 13314, 13217
5012, 6234, 312, 313, 6235, 13314, 372, 13315, 13219
5013, 6235, 313, 314, 6236, 13315, 373, 13316, 13221
5014, 6236, 314, 315, 6237, 13316, 374, 13317, 13223
5015, 6237, 315, 316, 6238, 13317, 375, 13318, 13225
5016, 6238, 316, 317, 6239, 13318, 376, 13319, 13227
5017, 6239, 317, 318, 6240, 13319, 377, 13320, 13229
5018, 6240, 318, 319, 6241, 13320, 378, 13321, 13231
5019, 6241, 319, 320, 6242, 13321, 379, 13322, 13233
5020, 6242, 320, 321, 6243, 13322, 380, 13323, 13235
5021, 6243, 321, 322, 6244, 13323, 381, 13324, 13237
5022, 6244, 322, 323, 6245, 13324, 382, 13325, 13239
5023, 6245, 323, 324, 6246, 13325, 383, 13326, 13241
5024, 6246, 324, 325, 6247, 13326, 384, 13327, 13243
5025, 6247, 325, 326, 6248, 13327, 385, 13328, 13245
5026, 6248, 326, 327, 6249, 13328, 386, 13329, 13247
5027, 6249, 327, 328, 6250, 13329, 387, 13330, 13249
5028, 6250, 328, 329, 6251, 13330, 388, 13331, 13251
5029, 6251, 329, 330, 6252, 13331, 389, 13332, 13253
5030, 6252, 330, 331, 6253, 13332, 390, 13333, 13255
5031, 6253, 331, 332, 6254, 13333, 391, 13334, 13257
5032, 6254, 332, 333, 6255, 13334, 392, 13335, 13259
5033, 6255, 333, 334, 6256, 13335, 393, 13336, 13261
5034, 6256, 334, 335, 6257, 13336, 394, 13337, 13263
5035, 6257, 335, 336, 6258, 13337, 395, 13338, 13265
5036, 6258, 336, 337, 6259, 13338, 396, 13339, 13267
5037, 6259, 337, 338, 6260, 13339, 397, 13340, 13269
5038, 6260, 338, 339, 6261, 13340, 398, 13341, 13271
5039, 6261, 339, 340, 6262, 13341, 399, 13342, 13273
5040, 6262, 340, 341, 6263, 13342, 400, 13343, 13275
5041, 6263, 341, 342, 6264, 13343, 401, 13344, 13277
5042, 6264, 342, 343, 6265, 13344, 402, 13345, 13279
5043, 6265, 343, 344, 6266, 13345, 403, 13346, 13281
5044, 6266, 344, 345, 6267, 13346, 404, 13347, 13283
5045, 6267, 345, 346, 6268, 13347, 405, 13348, 13285
5046, 6268, 346, 347, 6269, 13348, 406, 13349, 13287
5047, 6269, 347, 348, 6270, 13349, 407, 13350, 13289
5048, 6270, 348, 7, 409, 13350, 408, 468, 13291
*ELEMENT, type=CPS8, ELSET=Surface2
5049, 25, 1482, 13351, 1493, 1487, 13646, 13647, 1552
5050, 1493, 13351, 13352, 1494, 13647, 13648, 13649, 1553
5051, 1494, 13352, 13353, 1495, 13649, 13650, 13651, 1554
5052, 1495, 13353, 13354, 1496, 13651, 13652, 13653, 1555
5053, 1496, 13354, 13355, 1497, 13653, 13654, 13655, 1556
5054, 1497, 13355, 13356, 1498, 13655, 13656, 13657, 1557
5055, 1498, 13356, 13357, 1499, 13657, 13658, 13659, 1558
5056, 1499, 13357, 13358, 1500, 13659, 13660, 13661, 1559
5057, 1500, 13358, 13359, 1501, 13661, 13662, 13663, 1560
5058, 1501, 13359, 13360, 1502, 13663, 13664, 13665, 1561
5059, 1502, 13360, 13361, 1503, 13665, 13666, 13667, 1562
5060, 1503, 13361, 13362, 1504, 13667, 13668, 13669, 1563
5061, 1504, 13362, 13363, 1505, 13669, 13670, 13671, 1564
5062, 1505, 13363, 13364, 1506, 13671, 13672, 13673, 1565
5063, 1506, 13364, 13365, 1507, 13673, 13674, 13675, 1566
5064, 1507, 13365, 13366, 1508, 13675, 13676, 13677, 1567
5065, 1508, 13366, 13367, 1509, 13677, 13678, 13679, 1568
5066, 1509, 13367, 13368, 1510, 13679, 13680, 13681, 1569
5067, 1510, 13368, 13369, 1511, 13681, 13682, 13683, 1570
5068, 1511, 13369, 13370, 1512, 13683, 13684, 13685, 1571
5069, 1512, 13370, 13371, 1513, 13685, 13686, 13687, 1572
5070, 1513, 13371, 13372, 1514, 13687, 13688, 13689, 1573
5071, 1514, 13372, 13373, 1515, 13689, 13690, 13691, 1574
5072, 1515, 13373, 13374, 1516, 13691, 13692, 13693, 1575
5073, 1516, 13374, 13375, 1517, 13693, 13694, 13695, 1576
5074, 1517, 13375, 13376, 1518, 13695, 13696, 13697, 1577
5075, 1518, 13376, 13377, 1519, 13697, 13698, 13699, 1578
5076, 1519, 13377, 13378, 1520, 13699, 13700, 13701, 1579
5077, 1520, 13378, 13379, 1521, 13701, 13702, 13703, 1580
5078, 1521, 13379, 13380, 1522, 13703, 13704, 13705, 1581
5079, 1522, 13380, 13381, 1523, 13705, 13706, 13707, 1582
5080, 1523, 13381, 13382, 1524, 13707, 13708, 13709, 1583
5081, 1524, 13382, 13383, 1525, 13709, 13710, 13711, 1584
5082, 1525, 13383, 13384, 1526, 13711, 13712, 13713, 1585
5083, 1526, 13384, 13385, 1527, 13713, 13714, 13715, 1586
5084, 1527, 13385, 13386, 1528, 13715, 13716, 13717, 1587
5085, 1528, 13386, 13387, 1529, 13717, 13718, 13719, 1588
5086, 1529, 13387, 13388, 1530, 13719, 13720, 13721, 1589
5087, 1530, 13388, 13389, 1531, 13721, 13722, 13723, 1590
5088, 1531, 13389, 13390, 1532, 13723, 13724, 13725, 1591
5089, 1532, 13390, 13391, 1533, 13725, 13726, 13727, 1592
5090, 1533, 13391, 13392, 1534, 13727, 13728, 13729, 1593
5091, 1534, 13392, 13393, 1535, 13729, 13730, 13731, 1594
5092, 1535, 13393, 13394, 1536, 13731, 13732, 13733, 1595
5093, 1536, 13394, 13395, 1537, 13733, 13734, 13735, 1596
5094, 1537, 13395, 13396, 1538, 13735, 13736, 13737, 1597
5095, 1538, 13396, 13397, 1539, 13737, 13738, 13739, 1598
5096, 1539, 13397, 13398, 1540, 13739, 13740, 13741, 1599
5097, 1540, 13398, 13399, 1541, 13741, 13742, 13743, 1600
5098, 1541, 13399, 13400, 1542, 13743, 13744, 13745, 1601
5099, 1542, 13400, 13401, 1543, 13745, 13746, 13747, 1602
5100, 1543, 13401, 13402, 1544, 13747, 13748, 13749, 1603
5101, 1544, 13402, 13403, 1545, 13749, 13750, 13751, 1604
5102, 1545, 13403, 13404, 1546, 13751, 13752, 13753, 1605
5103, 1546, 13404, 13405, 1547, 13753, 13754, 13755, 1606
5104, 1547, 13405, 13406, 1548, 13755, 13756, 13757, 1607
5105, 1548, 13406, 13407, 1549, 13757, 13758, 13759, 1608
5106, 1549, 13407, 13408, 1550, 13759, 13760, 13761, 1609
5107, 1550, 13408, 13409, 1551, 13761, 13762, 13763, 1610
5108, 1551, 13409, 2236, 26, 13763, 13764, 2241, 1611
5109, 1482, 1483, 13410, 13351, 1488, 13765, 13766, 13646
5110, 13351, 13410, 13411, 13352, 13766, 13767, 13768, 13648
5111, 13352, 13411, 13412, 13353, 13768, 13769, 13770, 13650
5112, 13353, 13412, 13413, 13354, 13770, 13771, 13772, 13652
5113, 13354, 13413, 13414, 13355, 13772, 13773, 13774, 13654
5114, 13355, 13414, 13415, 13356, 13774, 13775, 13776, 13656
5115, 13356, 13415, 13416, 13357, 13776, 13777, 13778, 13658
5116, 13357, 13416, 13417, 13358, 13778, 13779, 13780, 13660
5117, 13358, 13417, 13418, 13359, 13780, 13781, 13782, 13662
5118, 13359, 13418, 13419, 13360, 13782, 13783, 13784, 13664
5119, 13360, 13419, 13420, 13361, 13784, 13785, 13786, 13666
5120, 13361, 13420, 13421, 13362, 13786, 13787, 13788, 13668
5121, 13362, 13421, 13422, 13363, 13788, 13789, 13790, 13670
5122, 13363, 13422, 13423, 13364, 13790, 13791, 13792, 13672
5123, 13364, 13423, 13424, 13365, 13792, 13793, 13794, 13674
5124, 13365, 13424, 13425, 13366, 13794, 13795, 13796, 13676
5125, 13366, 13425, 13426, 13367, 13796, 13797, 13798, 13678
5126, 13367, 13426, 13427, 13368, 13798, 13799, 13800, 13680
5127, 13368, 13427, 13428, 13369, 13800, 13801, 13802, 13682
5128, 13369, 13428, 13429, 13370, 13802, 13803, 13804, 13684
5129, 13370, 13429, 13430, 13371, 13804, 13805, 13806, 13686
5130, 13371, 13430, 13431, 13372, 13806, 13807, 13808, 13688
5131, 13372, 13431, 13432, 13373, 13808, 13809, 13810, 13690
5132, 13373, 13432, 13433, 13374, 13810, 13811, 13812, 13692
5133, 13374, 13433, 13434, 13375, 13812, 13813, 13814, 13694
5134, 13375, 13434, 13435, 13376, 13814, 13815, 13816, 13696
5135, 13376, 13435, 13436, 13377, 13816, 13817, 13818, 13698
5136, 13377, 13436, 13437, 13378, 13818, 13819, 13820, 13700
5137, 13378, 13437, 13438, 13379, 13820, 13821, 13822, 13702
5138, 13379, 13438, 13439, 13380, 13822, 13823, 13824, 13704
5139, 13380, 13439, 13440, 13381, 13824, 13825, 13826, 13706
5140, 13381, 13440, 13441, 13382, 13826, 13827, 13828, 13708
5141, 13382, 13441, 13442, 13383, 13828, 13829, 13830, 13710
5142, 13383, 13442, 13443, 13384, 13830, 13831, 13832, 13712
5143, 13384, 13443, 13444, 13385, 13832, 13833, 13834, 13714
5144, 13385, 13444, 13445, 13386, 13834, 13835, 13836, 13716
5145, 13386, 13445, 13446, 13387, 13836, 13837, 13838, 13718
5146, 13387, 13446, 13447, 13388, 13838, 13839, 13840, 13720
5147, 13388, 13447, 13448, 13389, 13840, 13841, 13842, 13722
5148, 13389, 13448, 13449, 13390, 13842, 13843, 13844, 13724
5149, 13390, 13449, 13450, 13391, 13844, 13845, 13846, 13726
5150, 13391, 13450, 13451, 13392, 13846, 13847, 13848, 13728
5151, 13392, 13451, 13452, 13393, 13848, 13849, 13850, 13730
5152, 13393, 13452, 13453, 13394, 13850, 13851, 13852, 13732
5153, 13394, 13453, 13454, 13395, 13852, 13853, 13854, 13734
5154, 13395, 13454, 13455, 13396, 13854, 13855, 13856, 13736
5155, 13396, 13455, 13456, 13397, 13856, 13857, 13858, 13738
5156, 13397, 13456, 13457, 13398, 13858, 13859, 13860, 13740
5157, 13398, 13457, 13458, 13399, 13860, 13861, 13862, 13742
5158, 13399, 13458, 13459, 13400, 13862, 13863, 13864, 13744
5159, 13400, 13459, 13460, 13401, 13864, 13865, 13866, 13746
5160, 13401, 13460, 13461, 13402, 13866, 13867, 13868, 13748
5161, 13402, 13461, 13462, 13403, 13868, 13869, 13870, 13750
5162, 13403, 13462, 13463, 13404, 13870, 13871, 13872, 13752
5163, 13404, 13463, 13464, 13405, 13872, 13873, 13874, 13754
5164, 13405, 13464, 13465, 13406, 13874, 13875, 13876, 13756
5165, 13406, 13465, 13466, 13407, 13876, 13877, 13878, 13758
5166, 13407, 13466, 13467, 13408, 13878, 13879, 13880, 13760
5167, 13408, 13467, 13468, 13409, 13880, 13881, 13882, 13762
5168, 13409, 13468, 2237, 2236, 13882, 13883, 2242, 13764
5169, 1483, 1484, 13469, 13410, 1489, 13884, 13885, 13765
5170, 13410, 13469, 13470, 13411, 13885, 13886, 13887, 13767
5171, 13411, 13470, 13471, 13412, 13887, 13888, 13889, 13769
5172, 13412, 13471, 13472, 13413, 13889, 13890, 13891, 13771
5173, 13413, 13472, 13473, 13414, 13891, 13892, 13893, 13773
5174, 13414, 13473, 13474, 13415, 13893, 13894, 13895, 13775
5175, 13415, 13474, 13475, 13416, 13895, 13896, 13897, 13777
5176, 13416, 13475, 13476, 13417, 13897, 13898, 13899, 13779
5177, 13417, 13476, 13477, 13418, 13899, 13900, 13901, 13781
5178, 13418, 13477, 13478, 13419, 13901, 13902, 13903, 13783
5179, 13419, 13478, 13479, 13420, 13903, 13904, 13905, 13785
5180, 13420, 13479, 13480, 13421, 13905, 13906, 13907, 13787
5181, 13421, 13480, 13481, 13422, 13907, 13908, 13909, 13789
5182, 13422, 13481, 13482, 13423, 13909, 13910, 13911, 13791
5183, 13423, 13482, 13483, 13424, 13911, 13912, 13913, 13793
5184, 13424, 13483, 13484, 13425, 13913, 13914, 13915, 13795
5185, 13425, 13484, 13485, 13426, 13915, 13916, 13917, 13797
5186, 13426, 13485, 13486, 13427, 13917, 13918, 13919, 13799
5187, 13427, 13486, 13487, 13428, 13919, 13920, 13921, 13801
5188, 13428, 13487, 13488, 13429, 13921, 13922, 13923, 13803
5189, 13429, 13488, 13489, 13430, 13923, 13924, 13925, 13805
5190, 13430, 13489, 13490, 13431, 13925, 13926, 13927, 13807
5191, 13431, 13490, 13491, 13432, 13927, 13928, 13929, 13809
5192, 13432, 13491, 13492, 13433, 13929, 13930, 13931, 13811
5193, 13433, 13492, 13493, 13434, 13931, 13932, 13933, 13813
5194, 13434, 13493, 13494, 13435, 13933, 13934, 13935, 13815
5195, 13435, 13494, 13495, 13436, 13935, 13936, 13937, 13817
5196, 13436, 13495, 13496, 13437, 13937, 13938, 13939, 13819
5197, 13437, 13496, 13497, 13438, 13939, 13940, 13941, 13821
5198, 13438, 13497, 13498, 13439, 13941, 13942, 13943, 13823
5199, 13439, 13498, 13499, 13440, 13943, 13944, 13945, 13825
5200, 13440, 13499, 13500, 13441, 13945, 13946, 13947, 13827
5201, 13441, 13500, 13501, 13442, 13947, 13948, 13949, 13829
5202, 13442, 13501, 13502, 13443, 13949, 13950, 13951, 13831
5203, 13443, 13502, 13503, 13444, 13951, 13952, 13953, 13833
5204, 13444, 13503, 13504, 13445, 13953, 13954, 13955, 13835
5205, 13445, 13504, 13505, 13446, 13955, 13956, 13957, 13837
5206, 13446, 13505, 13506, 13447, 13957, 13958, 13959, 13839
5207, 13447, 13506, 13507, 13448, 13959, 13960, 13961, 13841
5208, 13448, 13507, 13508, 13449, 13961, 13962, 13963, 13843
5209, 13449, 13508, 13509, 13450, 13963, 13964, 13965, 13845
5210, 13450, 13509, 13510, 13451, 13965, 13966, 13967, 13847
5211, 13451, 13510, 13511, 13452, 13967, 13968, 13969, 13849
5212, 13452, 13511, 13512, 13453, 13969, 13970, 13971, 13851
5213, 13453, 13512, 13513, 13454, 13971, 13972, 13973, 13853
5214, 13454, 13513, 13514, 13455, 13973, 13974, 13975, 13855
5215, 13455, 13514, 13515, 13456, 13975, 13976, 13977, 13857
5216, 13456, 13515, 13516, 13457, 13977, 13978, 13979, 13859
5217, 13457, 13516, 13517, 13458, 13979, 13980, 13981, 13861
5218, 13458, 13517, 13518, 13459, 13981, 13982, 13983, 13863
5219, 13459, 13518, 13519, 13460, 13983, 13984, 13985, 13865
5220, 13460, 13519, 13520, 13461, 13985, 13986, 13987, 13867
5221, 13461, 13520, 13521, 13462, 13987, 13988, 13989, 13869
5222, 13462, 13521, 13522, 13463, 13989, 13990, 13991, 13871
5223, 13463, 13522, 13523, 13464, 13991, 13992, 13993, 13873
5224, 13464, 13523, 13524, 13465, 13993, 13994, 13995, 13875
5225, 13465, 13524, 13525, 13466, 13995, 13996, 13997, 13877
5226, 13466, 13525, 13526, 13467, 13997, 13998, 13999, 13879
5227, 13467, 13526, 13527, 13468, 13999, 14000, 14001, 13881
5228, 13468, 13527, 2238, 2237, 14001, 14002, 2243, 13883
5229, 1484, 1485, 13528, 13469, 1490, 14003, 14004, 13884
5230, 13469, 13528, 13529, 13470, 14004, 14005, 14006, 13886
5231, 13470, 13529, 13530, 13471, 14006, 14007, 14008, 13888
5232, 13471, 13530, 13531, 13472, 14008, 14009, 14010, 13890
5233, 13472, 13531, 13532, 13473, 14010, 14011, 14012, 13892
5234, 13473, 13532, 13533, 13474, 14012, 14013, 14014, 13894
5235, 13474, 13533, 13534, 13475, 14014, 14015, 14016, 13896
5236, 13475, 13534, 13535, 13476, 14016, 14017, 14018, 13898
5237, 13476, 13535, 13536, 13477, 14018, 14019, 14020, 13900
5238, 13477, 13536, 13537, 13478, 14020, 14021, 14022, 13902
5239, 13478, 13537, 13538, 13479, 14022, 14023, 14024, 13904
5240, 13479, 13538, 13539, 13480, 14024, 14025, 14026, 13906
5241, 13480, 13539, 13540, 13481, 14026, 14027, 14028, 13908
5242, 13481, 13540, 13541, 13482, 14028, 14029, 14030, 13910
5243, 13482, 13541, 13542, 13483, 14030, 14031, 14032, 13912
5244, 13483, 13542, 13543, 13484, 14032, 14033, 14034, 13914
5245, 13484, 13543, 13544, 13485, 14034, 14035, 14036, 13916
5246, 13485, 13544, 13545, 13486, 14036, 14037, 14038, 13918
5247, 13486, 13545, 13546, 13487, 14038, 14039, 14040, 13920
5248, 13487, 13546, 13547, 13488, 14040, 14041, 14042, 13922
5249, 13488, 13547, 13548, 13489, 14042, 14043, 14044, 13924
5250, 13489, 13548, 13549, 13490, 14044, 14045, 14046, 13926
5251, 13490, 13549, 13550, 13491, 14046, 14047, 14048, 13928
5252, 13491, 13550, 13551, 13492, 14048, 14049, 14050, 13930
5253, 13492, 13551, 13552, 13493, 14050, 14051, 14052, 13932
5254, 13493, 13552, 13553, 13494, 14052, 14053, 14054, 13934
5255, 13494, 13553, 13554, 13495, 14054, 14055, 14056, 13936
5256, 13495, 13554, 13555, 13496, 14056, 14057, 14058, 13938
5257, 13496, 13555, 13556, 13497, 14058, 14059, 14060, 13940
5258, 13497, 13556, 13557, 13498, 14060, 14061, 14062, 13942
5259, 13498, 13557, 13558, 13499, 14062, 14063, 14064, 13944
5260, 13499, 13558, 13559, 13500, 14064, 14065, 14066, 13946
5261, 13500, 13559, 13560, 13501, 14066, 14067, 14068, 13948
5262, 13501, 13560, 13561, 13502, 14068, 14069, 14070, 13950
5263, 13502, 13561, 13562, 13503, 14070, 14071, 14072, 13952
5264, 13503, 13562, 13563, 13504, 14072, 14073, 14074, 13954
5265, 13504, 13563, 13564, 13505, 14074, 14075, 14076, 13956
5266, 13505, 13564, 13565, 13506, 14076, 14077, 14078, 13958
5267, 13506, 13565, 13566, 13507, 14078, 14079, 14080, 13960
5268, 13507, 13566, 13567, 13508, 14080, 14081, 14082, 13962
5269, 13508, 13567, 13568, 13509, 14082, 14083, 14084, 13964
5270, 13509, 13568, 13569, 13510, 14084, 14085, 14086, 13966
5271, 13510, 13569, 13570, 13511, 14086, 14087, 14088, 13968
5272, 13511, 13570, 13571, 13512, 14088, 14089, 14090, 13970
5273, 13512, 13571, 13572, 13513, 14090, 14091, 14092, 13972
5274, 13513, 13572, 13573, 13514, 14092, 14093, 14094, 13974
5275, 13514, 13573, 13574, 13515, 14094, 14095, 14096, 13976
5276, 13515, 13574, 13575, 13516, 14096, 14097, 14098, 13978
5277, 13516, 13575, 13576, 13517, 14098, 14099, 14100, 13980
5278, 13517, 13576, 13577, 13518, 14100, 14101, 14102, 13982
5279, 13518, 13577, 13578, 13519, 14102, 14103, 14104, 13984
5280, 13519, 13578, 13579, 13520, 14104, 14105, 14106, 13986
5281, 13520, 13579, 13580, 13521, 14106, 14107, 14108, 13988
5282, 13521, 13580, 13581, 13522, 14108, 14109, 14110, 13990
5283, 13522, 13581, 13582, 13523, 14110, 14111, 14112, 13992
5284, 13523, 13582, 13583, 13524, 14112, 14113, 14114, 13994
5285, 13524, 13583, 13584, 13525, 14114, 14115, 14116, 13996
5286, 13525, 13584, 13585, 13526, 14116, 14117, 14118, 13998
5287, 13526, 13585, 13586, 13527, 14118, 14119, 14120, 14000
5288, 13527, 13586, 2239, 2238, 14120, 14121, 2244, 14002
5289, 1485, 1486, 13587, 13528, 1491, 14122, 14123, 14003
5290, 13528, 13587, 13588, 13529, 14123, 14124, 14125, 14005
5291, 13529, 13588, 13589, 13530, 14125, 14126, 14127, 14007
5292, 13530, 13589, 13590, 13531, 14127, 14128, 14129, 14009
5293, 13531, 13590, 13591, 13532, 14129, 14130, 14131, 14011
5294, 13532, 13591, 13592, 13533, 14131, 14132, 14133, 14013
5295, 13533, 13592, 13593, 13534, 14133, 14134, 14135, 14015
5296, 13534, 13593, 13594, 13535, 14135, 14136, 14137, 14017
5297, 13535, 13594, 13595, 13536, 14137, 14138, 14139, 14019
5298, 13536, 13595, 13596, 13537, 14139, 14140, 14141, 14021
5299, 13537, 13596, 13597, 13538, 14141, 14142, 14143, 14023
5300, 13538, 13597, 13598, 13539, 14143, 14144, 14145, 14025
5301, 13539, 13598, 13599, 13540, 14145, 14146, 14147, 14027
5302, 13540, 13599, 13600, 13541, 14147, 14148, 14149, 14029
5303, 13541, 13600, 13601, 13542, 14149, 14150, 14151, 14031
5304, 13542, 13601, 13602, 13543, 14151, 14152, 14153, 14033
5305, 13543, 13602, 13603, 13544, 14153, 14154, 14155, 14035
5306, 13544, 13603, 13604, 13545, 14155, 14156, 14157, 14037
5307, 13545, 13604, 13605, 13546, 14157, 14158, 14159, 14039
5308, 13546, 13605, 13606, 13547, 14159, 14160, 14161, 14041
5309, 13547, 13606, 13607, 13548, 14161, 14162, 14163, 14043
5310, 13548, 13607, 13608, 13549, 14163, 14164, 14165, 14045
5311, 13549, 13608, 13609, 13550, 14165, 14166, 14167, 14047
5312, 13550, 13609, 13610, 13551, 14167, 14168, 14169, 14049
5313, 13551, 13610, 13611, 13552, 14169, 14170, 14171, 14051
5314, 13552, 13611, 13612, 13553, 14171, 14172, 14173, 14053
5315, 13553, 13612, 13613, 13554, 14173, 14174, 14175, 14055
5316, 13554, 13613, 13614, 13555, 14175, 14176, 14177, 14057
5317, 13555, 13614, 13615, 13556, 14177, 14178, 14179, 14059
5318, 13556, 13615, 13616, 13557, 14179, 14180, 14181, 14061
5319, 13557, 13616, 13617, 13558, 14181, 14182, 14183, 14063
5320, 13558, 13617, 13618, 13559, 14183, 14184, 14185, 14065
5321, 13559, 13618, 13619, 13560, 14185, 14186, 14187, 14067
5322, 13560, 13619, 13620, 13561, 14187, 14188, 14189, 14069
5323, 13561, 13620, 13621, 13562, 14189, 14190, 14191, 14071
5324, 13562, 13621, 13622, 13563, 14191, 14192, 14193, 14073
5325, 13563, 13622, 13623, 13564, 14193, 14194, 14195, 14075
5326, 13564, 13623, 13624, 13565, 14195, 14196, 14197, 14077
5327, 13565, 13624, 13625, 13566, 14197, 14198, 14199, 14079
5328, 13566, 13625, 13626, 13567, 14199, 14200, 14201, 14081
5329, 13567, 13626, 13627, 13568, 14201, 14202, 14203, 14083
5330, 13568, 13627, 13628, 13569, 14203, 14204, 14205, 14085
5331, 13569, 13628, 13629, 13570, 14205, 14206, 14207, 14087
5332, 13570, 13629, 13630, 13571, 14207, 14208, 14209, 14089
5333, 13571, 13630, 13631, 13572, 14209, 14210, 14211, 14091
5334, 13572, 13631, 13632, 13573, 14211, 14212, 14213, 14093
5335, 13573, 13632, 13633, 13574, 14213, 14214, 14215, 14095
5336, 13574, 13633, 13634, 13575, 14215, 14216, 14217, 14097
5337, 13575, 13634, 13635, 13576, 14217, 14218, 14219, 14099
5338, 13576, 13635, 13636, 13577, 14219, 14220, 14221, 14101
5339, 13577, 13636, 13637, 13578, 14221, 14222, 14223, 14103
5340, 13578, 13637, 13638, 13579, 14223, 14224, 14225, 14105
5341, 13579, 13638, 13639, 13580, 14225, 14226, 14227, 14107
5342, 13580, 13639, 13640, 13581, 14227, 14228, 14229, 14109
5343, 13581, 13640, 13641, 13582, 14229, 14230, 14231, 14111
5344, 13582, 13641, 13642, 13583, 14231, 14232, 14233, 14113
5345, 13583, 13642, 13643, 13584, 14233, 14234, 14235, 14115
5346, 13584, 13643, 13644, 13585, 14235, 14236, 14237, 14117
5347, 13585, 13644, 13645, 13586, 14237, 14238, 14239, 14119
5348, 13586, 13645, 2240, 2239, 14239, 14240, 2245, 14121
5349, 1486, 1, 2247, 13587, 1492, 2306, 14241, 14122
5350, 13587, 2247, 2248, 13588, 14241, 2307, 14242, 14124
5351, 13588, 2248, 2249, 13589, 14242, 2308, 14243, 14126
5352, 13589, 2249, 2250, 13590, 14243, 2309, 14244, 14128
5353, 13590, 2250, 2251, 13591, 14244, 2310, 14245, 14130
5354, 13591, 2251, 2252, 13592, 14245, 2311, 14246, 14132
5355, 13592, 2252, 2253, 13593, 14246, 2312, 14247, 14134
5356, 13593, 2253, 2254, 13594, 14247, 2313, 14248, 14136
5357, 13594, 2254, 2255, 13595, 14248, 2314, 14249, 14138
5358, 13595, 2255, 2256, 13596, 14249, 2315, 14250, 14140
5359, 13596, 2256, 2257, 13597, 14250, 2316, 14251, 14142
5360, 13597, 2257, 2258, 13598, 14251, 2317, 14252, 14144
5361, 13598, 2258, 2259, 13599, 14252, 2318, 14253, 14146
5362, 13599, 2259, 2260, 13600, 14253, 2319, 14254, 14148
5363, 13600, 2260, 2261, 13601, 14254, 2320, 14255, 14150
5364, 13601, 2261, 2262, 13602, 14255, 2321, 14256, 14152
5365, 13602, 2262, 2263, 13603, 14256, 2322, 14257, 14154
5366, 13603, 2263, 2264, 13604, 14257, 2323, 14258, 14156
5367, 13604, 2264, 2265, 13605, 14258, 2324, 14259, 14158
5368, 13605, 2265, 2266, 13606, 14259, 2325, 14260, 14160
5369, 13606, 2266, 2267, 13607, 14260, 2326, 14261, 14162
5370, 13607, 2267, 2268, 13608, 14261, 2327, 14262, 14164
5371, 13608, 2268, 2269, 13609, 14262, 2328, 14263, 14166
5372, 13609, 2269, 2270, 13610, 14263, 2329, 14264, 14168
5373, 13610, 2270, 2271, 13611, 14264, 2330, 14265, 14170
5374, 13611, 2271, 2272, 13612, 14265, 2331, 14266, 14172
5375, 13612, 2272, 2273, 13613, 14266, 2332, 14267, 14174
5376, 13613, 2273, 2274, 13614, 14267, 2333, 14268, 14176
5377, 13614, 2274, 2275, 13615, 14268, 2334, 14269, 14178
5378, 13615, 2275, 2276, 13616, 14269, 2335, 14270, 14180
5379, 13616, 2276, 2277, 13617, 14270, 2336, 14271, 14182
5380, 13617, 2277, 2278, 13618, 14271, 2337, 14272, 14184
5381, 13618, 2278, 2279, 13619, 14272, 2338, 14273, 14186
5382, 13619, 2279, 2280, 13620, 14273, 2339, 14274, 14188
5383, 13620, 2280, 2281, 13621, 14274, 2340, 14275, 14190
5384, 13621, 2281, 2282, 13622, 14275, 2341, 14276, 14192
5385, 13622, 2282, 2283, 13623, 14276, 2342, 14277, 14194
5386, 13623, 2283, 2284, 13624, 14277, 2343, 14278, 14196
5387, 13624, 2284, 2285, 13625, 14278, 2344, 14279, 14198
5388, 13625, 2285, 2286, 13626, 14279, 2345, 14280, 14200
5389, 13626, 2286, 2287, 13627, 14280, 2346, 14281, 14202
5390, 13627, 2287, 2288, 13628, 14281, 2347, 14282, 14204
5391, 13628, 2288, 2289, 13629, 14282, 2348, 14283, 14206
5392, 13629, 2289, 2290, 13630, 14283, 2349, 14284, 14208
5393, 13630, 2290, 2291, 13631, 14284, 2350, 14285, 14210
5394, 13631, 2291, 2292, 13632, 14285, 2351, 14286, 14212
5395, 13632, 2292, 2293, 13633, 14286, 2352, 14287, 14214
5396, 13633, 2293, 2294, 13634, 14287, 2353, 14288, 14216
5397, 13634, 2294, 2295, 13635, 14288, 2354, 14289, 14218
5398, 13635, 2295, 2296, 13636, 14289, 2355, 14290, 14220
5399, 13636, 2296, 2297, 13637, 14290, 2356, 14291, 14222
5400, 13637, 2297, 2298, 13638, 14291, 2357, 14292, 14224
5401, 13638, 2298, 2299, 13639, 14292, 2358, 14293, 14226
5402, 13639, 2299, 2300, 13640, 14293, 2359, 14294, 14228
5403, 13640, 2300, 2301, 13641, 14294, 2360, 14295, 14230
5404, 13641, 2301, 2302, 13642, 14295, 2361, 14296, 14232
5405, 13642, 2302, 2303, 13643, 14296, 2362, 14297, 14234
5406, 13643, 2303, 2304, 13644, 14297, 2363, 14298, 14236
5407, 13644, 2304, 2305, 13645, 14298, 2364, 14299, 14238
5408, 13645, 2305, 35, 2240, 14299, 2365, 2246, 14240
*ELEMENT, type=CPS8, ELSET=Surface3
5409, 25, 1612, 14300, 1482, 1619, 14335, 14336, 1487
5410, 1482, 14300, 14301, 1483, 14336, 14337, 14338, 1488
5411, 1483, 14301, 14302, 1484, 14338, 14339, 14340, 1489
5412, 1484, 14302, 14303, 1485, 14340, 14341, 14342, 1490
5413, 1485, 14303, 14304, 1486, 14342, 14343, 14344, 1491
5414, 1486, 14304, 647, 1, 14344, 14345, 654, 1492
5415, 1612, 1613, 14305, 14300, 1620, 14346, 14347, 14335
5416, 14300, 14305, 14306, 14301, 14347, 14348, 14349, 14337
5417, 14301, 14306, 14307, 14302, 14349, 14350, 14351, 14339
5418, 14302, 14307, 14308, 14303, 14351, 14352, 14353, 14341
5419, 14303, 14308, 14309, 14304, 14353, 14354, 14355, 14343
5420, 14304, 14309, 648, 647, 14355, 14356, 655, 14345
5421, 1613, 1614, 14310, 14305, 1621, 14357, 14358, 14346
5422, 14305, 14310, 14311, 14306, 14358, 14359, 14360, 14348
5423, 14306, 14311, 14312, 14307, 14360, 14361, 14362, 14350
5424, 14307, 14312, 14313, 14308, 14362, 14363, 14364, 14352
5425, 14308, 14313, 14314, 14309, 14364, 14365, 14366, 14354
5426, 14309, 14314, 649, 648, 14366, 14367, 656, 14356
5427, 1614, 1615, 14315, 14310, 1622, 14368, 14369, 14357
5428, 14310, 14315, 14316, 14311, 14369, 14370, 14371, 14359
5429, 14311, 14316, 14317, 14312, 14371, 14372, 14373, 14361
5430, 14312, 14317, 14318, 14313, 14373, 14374, 14375, 14363
5431, 14313, 14318, 14319, 14314, 14375, 14376, 14377, 14365
5432, 14314, 14319, 650, 649, 14377, 14378, 657, 14367
5433, 1615, 1616, 14320, 14315, 1623, 14379, 14380, 14368
5434, 14315, 14320, 14321, 14316, 14380, 14381, 14382, 14370
5435, 14316, 14321, 14322, 14317, 14382, 14383, 14384, 14372
5436, 14317, 14322, 14323, 14318, 14384, 14385, 14386, 14374
5437, 14318, 14323, 14324, 14319, 14386, 14387, 14388, 14376
5438, 14319, 14324, 651, 650, 14388, 14389, 658, 14378
5439, 1616, 1617, 14325, 14320, 1624, 14390, 14391, 14379
5440, 14320, 14325, 14326, 14321, 14391, 14392, 14393, 14381
5441, 14321, 14326, 14327, 14322, 14393, 14394, 14395, 14383
5442, 14322, 14327, 14328, 14323, 14395, 14396, 14397, 14385
5443, 14323, 14328, 14329, 14324, 14397, 14398, 14399, 14387
5444, 14324, 14329, 652, 651, 14399, 14400, 659, 14389
5445, 1617, 1618, 14330, 14325, 1625, 14401, 14402, 14390
5446, 14325, 14330, 14331, 14326, 14402, 14403, 14404, 14392
5447, 14326, 14331, 14332, 14327, 14404, 14405, 14406, 14394
5448, 14327, 14332, 14333, 14328, 14406, 14407, 14408, 14396
5449, 14328, 14333, 14334, 14329, 14408, 14409, 14410, 14398
5450, 14329, 14334, 653, 652, 14410, 14411, 660, 14400
5451, 1618, 3, 662, 14330, 1626, 667, 14412, 14401
5452, 14330, 662, 663, 14331, 14412, 668, 14413, 14403
5453, 14331, 663, 664, 14332, 14413, 669, 14414, 14405
5454, 14332, 664, 665, 14333, 14414, 670, 14415, 14407
5455, 14333, 665, 666, 14334, 14415, 671, 14416, 14409
5456, 14334, 666, 9, 653, 14416, 672, 661, 14411
*ELEMENT, type=CPS8, ELSET=Surface4
5457, 3, 52, 14417, 662, 111, 14712, 14713, 667
5458, 662, 14417, 14418, 663, 14713, 14714, 14715, 668
