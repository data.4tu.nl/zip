8762, 18202, 18261, 18262, 18203, 24687, 24688, 24689, 24569
8763, 18203, 18262, 18263, 18204, 24689, 24690, 24691, 24571
8764, 18204, 18263, 18264, 18205, 24691, 24692, 24693, 24573
8765, 18205, 18264, 18265, 18206, 24693, 24694, 24695, 24575
8766, 18206, 18265, 18266, 18207, 24695, 24696, 24697, 24577
8767, 18207, 18266, 18267, 18208, 24697, 24698, 24699, 24579
8768, 18208, 18267, 18268, 18209, 24699, 24700, 24701, 24581
8769, 18209, 18268, 18269, 18210, 24701, 24702, 24703, 24583
8770, 18210, 18269, 18270, 18211, 24703, 24704, 24705, 24585
8771, 18211, 18270, 18271, 18212, 24705, 24706, 24707, 24587
8772, 18212, 18271, 18272, 18213, 24707, 24708, 24709, 24589
8773, 18213, 18272, 18273, 18214, 24709, 24710, 24711, 24591
8774, 18214, 18273, 18274, 18215, 24711, 24712, 24713, 24593
8775, 18215, 18274, 18275, 18216, 24713, 24714, 24715, 24595
8776, 18216, 18275, 18276, 18217, 24715, 24716, 24717, 24597
8777, 18217, 18276, 18277, 18218, 24717, 24718, 24719, 24599
8778, 18218, 18277, 18278, 18219, 24719, 24720, 24721, 24601
8779, 18219, 18278, 18279, 18220, 24721, 24722, 24723, 24603
8780, 18220, 18279, 18280, 18221, 24723, 24724, 24725, 24605
8781, 18221, 18280, 18281, 18222, 24725, 24726, 24727, 24607
8782, 18222, 18281, 18282, 18223, 24727, 24728, 24729, 24609
8783, 18223, 18282, 18283, 18224, 24729, 24730, 24731, 24611
8784, 18224, 18283, 18284, 18225, 24731, 24732, 24733, 24613
8785, 18225, 18284, 18285, 18226, 24733, 24734, 24735, 24615
8786, 18226, 18285, 18286, 18227, 24735, 24736, 24737, 24617
8787, 18227, 18286, 18287, 18228, 24737, 24738, 24739, 24619
8788, 18228, 18287, 18288, 18229, 24739, 24740, 24741, 24621
8789, 18229, 18288, 18289, 18230, 24741, 24742, 24743, 24623
8790, 18230, 18289, 18290, 18231, 24743, 24744, 24745, 24625
8791, 18231, 18290, 18291, 18232, 24745, 24746, 24747, 24627
8792, 18232, 18291, 18292, 18233, 24747, 24748, 24749, 24629
8793, 18233, 18292, 18293, 18234, 24749, 24750, 24751, 24631
8794, 18234, 18293, 18294, 18235, 24751, 24752, 24753, 24633
8795, 18235, 18294, 18295, 18236, 24753, 24754, 24755, 24635
8796, 18236, 18295, 18296, 18237, 24755, 24756, 24757, 24637
8797, 18237, 18296, 18297, 18238, 24757, 24758, 24759, 24639
8798, 18238, 18297, 18298, 18239, 24759, 24760, 24761, 24641
8799, 18239, 18298, 18299, 18240, 24761, 24762, 24763, 24643
8800, 18240, 18299, 18300, 18241, 24763, 24764, 24765, 24645
8801, 18241, 18300, 18301, 18242, 24765, 24766, 24767, 24647
8802, 18242, 18301, 18302, 18243, 24767, 24768, 24769, 24649
8803, 18243, 18302, 18303, 18244, 24769, 24770, 24771, 24651
8804, 18244, 18303, 18304, 18245, 24771, 24772, 24773, 24653
8805, 18245, 18304, 18305, 18246, 24773, 24774, 24775, 24655
8806, 18246, 18305, 18306, 18247, 24775, 24776, 24777, 24657
8807, 18247, 18306, 18307, 18248, 24777, 24778, 24779, 24659
8808, 18248, 18307, 18308, 18249, 24779, 24780, 24781, 24661
8809, 18249, 18308, 18309, 18250, 24781, 24782, 24783, 24663
8810, 18250, 18309, 18310, 18251, 24783, 24784, 24785, 24665
8811, 18251, 18310, 18311, 18252, 24785, 24786, 24787, 24667
8812, 18252, 18311, 18312, 18253, 24787, 24788, 24789, 24669
8813, 18253, 18312, 18313, 18254, 24789, 24790, 24791, 24671
8814, 18254, 18313, 18314, 18255, 24791, 24792, 24793, 24673
8815, 18255, 18314, 18315, 18256, 24793, 24794, 24795, 24675
8816, 18256, 18315, 841, 840, 24795, 24796, 900, 24677
8817, 722, 723, 18316, 18257, 782, 24797, 24798, 24678
8818, 18257, 18316, 18317, 18258, 24798, 24799, 24800, 24680
8819, 18258, 18317, 18318, 18259, 24800, 24801, 24802, 24682
8820, 18259, 18318, 18319, 18260, 24802, 24803, 24804, 24684
8821, 18260, 18319, 18320, 18261, 24804, 24805, 24806, 24686
8822, 18261, 18320, 18321, 18262, 24806, 24807, 24808, 24688
8823, 18262, 18321, 18322, 18263, 24808, 24809, 24810, 24690
8824, 18263, 18322, 18323, 18264, 24810, 24811, 24812, 24692
8825, 18264, 18323, 18324, 18265, 24812, 24813, 24814, 24694
8826, 18265, 18324, 18325, 18266, 24814, 24815, 24816, 24696
8827, 18266, 18325, 18326, 18267, 24816, 24817, 24818, 24698
8828, 18267, 18326, 18327, 18268, 24818, 24819, 24820, 24700
8829, 18268, 18327, 18328, 18269, 24820, 24821, 24822, 24702
8830, 18269, 18328, 18329, 18270, 24822, 24823, 24824, 24704
8831, 18270, 18329, 18330, 18271, 24824, 24825, 24826, 24706
8832, 18271, 18330, 18331, 18272, 24826, 24827, 24828, 24708
8833, 18272, 18331, 18332, 18273, 24828, 24829, 24830, 24710
8834, 18273, 18332, 18333, 18274, 24830, 24831, 24832, 24712
8835, 18274, 18333, 18334, 18275, 24832, 24833, 24834, 24714
8836, 18275, 18334, 18335, 18276, 24834, 24835, 24836, 24716
8837, 18276, 18335, 18336, 18277, 24836, 24837, 24838, 24718
8838, 18277, 18336, 18337, 18278, 24838, 24839, 24840, 24720
8839, 18278, 18337, 18338, 18279, 24840, 24841, 24842, 24722
8840, 18279, 18338, 18339, 18280, 24842, 24843, 24844, 24724
8841, 18280, 18339, 18340, 18281, 24844, 24845, 24846, 24726
8842, 18281, 18340, 18341, 18282, 24846, 24847, 24848, 24728
8843, 18282, 18341, 18342, 18283, 24848, 24849, 24850, 24730
8844, 18283, 18342, 18343, 18284, 24850, 24851, 24852, 24732
8845, 18284, 18343, 18344, 18285, 24852, 24853, 24854, 24734
8846, 18285, 18344, 18345, 18286, 24854, 24855, 24856, 24736
8847, 18286, 18345, 18346, 18287, 24856, 24857, 24858, 24738
8848, 18287, 18346, 18347, 18288, 24858, 24859, 24860, 24740
8849, 18288, 18347, 18348, 18289, 24860, 24861, 24862, 24742
8850, 18289, 18348, 18349, 18290, 24862, 24863, 24864, 24744
8851, 18290, 18349, 18350, 18291, 24864, 24865, 24866, 24746
8852, 18291, 18350, 18351, 18292, 24866, 24867, 24868, 24748
8853, 18292, 18351, 18352, 18293, 24868, 24869, 24870, 24750
8854, 18293, 18352, 18353, 18294, 24870, 24871, 24872, 24752
8855, 18294, 18353, 18354, 18295, 24872, 24873, 24874, 24754
8856, 18295, 18354, 18355, 18296, 24874, 24875, 24876, 24756
8857, 18296, 18355, 18356, 18297, 24876, 24877, 24878, 24758
8858, 18297, 18356, 18357, 18298, 24878, 24879, 24880, 24760
8859, 18298, 18357, 18358, 18299, 24880, 24881, 24882, 24762
8860, 18299, 18358, 18359, 18300, 24882, 24883, 24884, 24764
8861, 18300, 18359, 18360, 18301, 24884, 24885, 24886, 24766
8862, 18301, 18360, 18361, 18302, 24886, 24887, 24888, 24768
8863, 18302, 18361, 18362, 18303, 24888, 24889, 24890, 24770
8864, 18303, 18362, 18363, 18304, 24890, 24891, 24892, 24772
8865, 18304, 18363, 18364, 18305, 24892, 24893, 24894, 24774
8866, 18305, 18364, 18365, 18306, 24894, 24895, 24896, 24776
8867, 18306, 18365, 18366, 18307, 24896, 24897, 24898, 24778
8868, 18307, 18366, 18367, 18308, 24898, 24899, 24900, 24780
8869, 18308, 18367, 18368, 18309, 24900, 24901, 24902, 24782
8870, 18309, 18368, 18369, 18310, 24902, 24903, 24904, 24784
8871, 18310, 18369, 18370, 18311, 24904, 24905, 24906, 24786
8872, 18311, 18370, 18371, 18312, 24906, 24907, 24908, 24788
8873, 18312, 18371, 18372, 18313, 24908, 24909, 24910, 24790
8874, 18313, 18372, 18373, 18314, 24910, 24911, 24912, 24792
8875, 18314, 18373, 18374, 18315, 24912, 24913, 24914, 24794
8876, 18315, 18374, 842, 841, 24914, 24915, 901, 24796
8877, 723, 724, 18375, 18316, 783, 24916, 24917, 24797
8878, 18316, 18375, 18376, 18317, 24917, 24918, 24919, 24799
8879, 18317, 18376, 18377, 18318, 24919, 24920, 24921, 24801
8880, 18318, 18377, 18378, 18319, 24921, 24922, 24923, 24803
8881, 18319, 18378, 18379, 18320, 24923, 24924, 24925, 24805
8882, 18320, 18379, 18380, 18321, 24925, 24926, 24927, 24807
8883, 18321, 18380, 18381, 18322, 24927, 24928, 24929, 24809
8884, 18322, 18381, 18382, 18323, 24929, 24930, 24931, 24811
8885, 18323, 18382, 18383, 18324, 24931, 24932, 24933, 24813
8886, 18324, 18383, 18384, 18325, 24933, 24934, 24935, 24815
8887, 18325, 18384, 18385, 18326, 24935, 24936, 24937, 24817
8888, 18326, 18385, 18386, 18327, 24937, 24938, 24939, 24819
8889, 18327, 18386, 18387, 18328, 24939, 24940, 24941, 24821
8890, 18328, 18387, 18388, 18329, 24941, 24942, 24943, 24823
8891, 18329, 18388, 18389, 18330, 24943, 24944, 24945, 24825
8892, 18330, 18389, 18390, 18331, 24945, 24946, 24947, 24827
8893, 18331, 18390, 18391, 18332, 24947, 24948, 24949, 24829
8894, 18332, 18391, 18392, 18333, 24949, 24950, 24951, 24831
8895, 18333, 18392, 18393, 18334, 24951, 24952, 24953, 24833
8896, 18334, 18393, 18394, 18335, 24953, 24954, 24955, 24835
8897, 18335, 18394, 18395, 18336, 24955, 24956, 24957, 24837
8898, 18336, 18395, 18396, 18337, 24957, 24958, 24959, 24839
8899, 18337, 18396, 18397, 18338, 24959, 24960, 24961, 24841
8900, 18338, 18397, 18398, 18339, 24961, 24962, 24963, 24843
8901, 18339, 18398, 18399, 18340, 24963, 24964, 24965, 24845
8902, 18340, 18399, 18400, 18341, 24965, 24966, 24967, 24847
8903, 18341, 18400, 18401, 18342, 24967, 24968, 24969, 24849
8904, 18342, 18401, 18402, 18343, 24969, 24970, 24971, 24851
8905, 18343, 18402, 18403, 18344, 24971, 24972, 24973, 24853
8906, 18344, 18403, 18404, 18345, 24973, 24974, 24975, 24855
8907, 18345, 18404, 18405, 18346, 24975, 24976, 24977, 24857
8908, 18346, 18405, 18406, 18347, 24977, 24978, 24979, 24859
8909, 18347, 18406, 18407, 18348, 24979, 24980, 24981, 24861
8910, 18348, 18407, 18408, 18349, 24981, 24982, 24983, 24863
8911, 18349, 18408, 18409, 18350, 24983, 24984, 24985, 24865
8912, 18350, 18409, 18410, 18351, 24985, 24986, 24987, 24867
8913, 18351, 18410, 18411, 18352, 24987, 24988, 24989, 24869
8914, 18352, 18411, 18412, 18353, 24989, 24990, 24991, 24871
8915, 18353, 18412, 18413, 18354, 24991, 24992, 24993, 24873
8916, 18354, 18413, 18414, 18355, 24993, 24994, 24995, 24875
8917, 18355, 18414, 18415, 18356, 24995, 24996, 24997, 24877
8918, 18356, 18415, 18416, 18357, 24997, 24998, 24999, 24879
8919, 18357, 18416, 18417, 18358, 24999, 25000, 25001, 24881
8920, 18358, 18417, 18418, 18359, 25001, 25002, 25003, 24883
8921, 18359, 18418, 18419, 18360, 25003, 25004, 25005, 24885
8922, 18360, 18419, 18420, 18361, 25005, 25006, 25007, 24887
8923, 18361, 18420, 18421, 18362, 25007, 25008, 25009, 24889
8924, 18362, 18421, 18422, 18363, 25009, 25010, 25011, 24891
8925, 18363, 18422, 18423, 18364, 25011, 25012, 25013, 24893
8926, 18364, 18423, 18424, 18365, 25013, 25014, 25015, 24895
8927, 18365, 18424, 18425, 18366, 25015, 25016, 25017, 24897
8928, 18366, 18425, 18426, 18367, 25017, 25018, 25019, 24899
8929, 18367, 18426, 18427, 18368, 25019, 25020, 25021, 24901
8930, 18368, 18427, 18428, 18369, 25021, 25022, 25023, 24903
8931, 18369, 18428, 18429, 18370, 25023, 25024, 25025, 24905
8932, 18370, 18429, 18430, 18371, 25025, 25026, 25027, 24907
8933, 18371, 18430, 18431, 18372, 25027, 25028, 25029, 24909
8934, 18372, 18431, 18432, 18373, 25029, 25030, 25031, 24911
8935, 18373, 18432, 18433, 18374, 25031, 25032, 25033, 24913
8936, 18374, 18433, 843, 842, 25033, 25034, 902, 24915
8937, 724, 725, 18434, 18375, 784, 25035, 25036, 24916
8938, 18375, 18434, 18435, 18376, 25036, 25037, 25038, 24918
8939, 18376, 18435, 18436, 18377, 25038, 25039, 25040, 24920
8940, 18377, 18436, 18437, 18378, 25040, 25041, 25042, 24922
8941, 18378, 18437, 18438, 18379, 25042, 25043, 25044, 24924
8942, 18379, 18438, 18439, 18380, 25044, 25045, 25046, 24926
8943, 18380, 18439, 18440, 18381, 25046, 25047, 25048, 24928
8944, 18381, 18440, 18441, 18382, 25048, 25049, 25050, 24930
8945, 18382, 18441, 18442, 18383, 25050, 25051, 25052, 24932
8946, 18383, 18442, 18443, 18384, 25052, 25053, 25054, 24934
8947, 18384, 18443, 18444, 18385, 25054, 25055, 25056, 24936
8948, 18385, 18444, 18445, 18386, 25056, 25057, 25058, 24938
8949, 18386, 18445, 18446, 18387, 25058, 25059, 25060, 24940
8950, 18387, 18446, 18447, 18388, 25060, 25061, 25062, 24942
8951, 18388, 18447, 18448, 18389, 25062, 25063, 25064, 24944
8952, 18389, 18448, 18449, 18390, 25064, 25065, 25066, 24946
8953, 18390, 18449, 18450, 18391, 25066, 25067, 25068, 24948
8954, 18391, 18450, 18451, 18392, 25068, 25069, 25070, 24950
8955, 18392, 18451, 18452, 18393, 25070, 25071, 25072, 24952
8956, 18393, 18452, 18453, 18394, 25072, 25073, 25074, 24954
8957, 18394, 18453, 18454, 18395, 25074, 25075, 25076, 24956
8958, 18395, 18454, 18455, 18396, 25076, 25077, 25078, 24958
8959, 18396, 18455, 18456, 18397, 25078, 25079, 25080, 24960
8960, 18397, 18456, 18457, 18398, 25080, 25081, 25082, 24962
8961, 18398, 18457, 18458, 18399, 25082, 25083, 25084, 24964
8962, 18399, 18458, 18459, 18400, 25084, 25085, 25086, 24966
8963, 18400, 18459, 18460, 18401, 25086, 25087, 25088, 24968
8964, 18401, 18460, 18461, 18402, 25088, 25089, 25090, 24970
8965, 18402, 18461, 18462, 18403, 25090, 25091, 25092, 24972
8966, 18403, 18462, 18463, 18404, 25092, 25093, 25094, 24974
8967, 18404, 18463, 18464, 18405, 25094, 25095, 25096, 24976
8968, 18405, 18464, 18465, 18406, 25096, 25097, 25098, 24978
8969, 18406, 18465, 18466, 18407, 25098, 25099, 25100, 24980
8970, 18407, 18466, 18467, 18408, 25100, 25101, 25102, 24982
8971, 18408, 18467, 18468, 18409, 25102, 25103, 25104, 24984
8972, 18409, 18468, 18469, 18410, 25104, 25105, 25106, 24986
8973, 18410, 18469, 18470, 18411, 25106, 25107, 25108, 24988
8974, 18411, 18470, 18471, 18412, 25108, 25109, 25110, 24990
8975, 18412, 18471, 18472, 18413, 25110, 25111, 25112, 24992
8976, 18413, 18472, 18473, 18414, 25112, 25113, 25114, 24994
8977, 18414, 18473, 18474, 18415, 25114, 25115, 25116, 24996
8978, 18415, 18474, 18475, 18416, 25116, 25117, 25118, 24998
8979, 18416, 18475, 18476, 18417, 25118, 25119, 25120, 25000
8980, 18417, 18476, 18477, 18418, 25120, 25121, 25122, 25002
8981, 18418, 18477, 18478, 18419, 25122, 25123, 25124, 25004
8982, 18419, 18478, 18479, 18420, 25124, 25125, 25126, 25006
8983, 18420, 18479, 18480, 18421, 25126, 25127, 25128, 25008
8984, 18421, 18480, 18481, 18422, 25128, 25129, 25130, 25010
8985, 18422, 18481, 18482, 18423, 25130, 25131, 25132, 25012
8986, 18423, 18482, 18483, 18424, 25132, 25133, 25134, 25014
8987, 18424, 18483, 18484, 18425, 25134, 25135, 25136, 25016
8988, 18425, 18484, 18485, 18426, 25136, 25137, 25138, 25018
8989, 18426, 18485, 18486, 18427, 25138, 25139, 25140, 25020
8990, 18427, 18486, 18487, 18428, 25140, 25141, 25142, 25022
8991, 18428, 18487, 18488, 18429, 25142, 25143, 25144, 25024
8992, 18429, 18488, 18489, 18430, 25144, 25145, 25146, 25026
8993, 18430, 18489, 18490, 18431, 25146, 25147, 25148, 25028
8994, 18431, 18490, 18491, 18432, 25148, 25149, 25150, 25030
8995, 18432, 18491, 18492, 18433, 25150, 25151, 25152, 25032
8996, 18433, 18492, 844, 843, 25152, 25153, 903, 25034
8997, 725, 726, 18493, 18434, 785, 25154, 25155, 25035
8998, 18434, 18493, 18494, 18435, 25155, 25156, 25157, 25037
8999, 18435, 18494, 18495, 18436, 25157, 25158, 25159, 25039
9000, 18436, 18495, 18496, 18437, 25159, 25160, 25161, 25041
9001, 18437, 18496, 18497, 18438, 25161, 25162, 25163, 25043
9002, 18438, 18497, 18498, 18439, 25163, 25164, 25165, 25045
9003, 18439, 18498, 18499, 18440, 25165, 25166, 25167, 25047
9004, 18440, 18499, 18500, 18441, 25167, 25168, 25169, 25049
9005, 18441, 18500, 18501, 18442, 25169, 25170, 25171, 25051
9006, 18442, 18501, 18502, 18443, 25171, 25172, 25173, 25053
9007, 18443, 18502, 18503, 18444, 25173, 25174, 25175, 25055
9008, 18444, 18503, 18504, 18445, 25175, 25176, 25177, 25057
9009, 18445, 18504, 18505, 18446, 25177, 25178, 25179, 25059
9010, 18446, 18505, 18506, 18447, 25179, 25180, 25181, 25061
9011, 18447, 18506, 18507, 18448, 25181, 25182, 25183, 25063
9012, 18448, 18507, 18508, 18449, 25183, 25184, 25185, 25065
9013, 18449, 18508, 18509, 18450, 25185, 25186, 25187, 25067
9014, 18450, 18509, 18510, 18451, 25187, 25188, 25189, 25069
9015, 18451, 18510, 18511, 18452, 25189, 25190, 25191, 25071
9016, 18452, 18511, 18512, 18453, 25191, 25192, 25193, 25073
9017, 18453, 18512, 18513, 18454, 25193, 25194, 25195, 25075
9018, 18454, 18513, 18514, 18455, 25195, 25196, 25197, 25077
9019, 18455, 18514, 18515, 18456, 25197, 25198, 25199, 25079
9020, 18456, 18515, 18516, 18457, 25199, 25200, 25201, 25081
9021, 18457, 18516, 18517, 18458, 25201, 25202, 25203, 25083
9022, 18458, 18517, 18518, 18459, 25203, 25204, 25205, 25085
9023, 18459, 18518, 18519, 18460, 25205, 25206, 25207, 25087
9024, 18460, 18519, 18520, 18461, 25207, 25208, 25209, 25089
9025, 18461, 18520, 18521, 18462, 25209, 25210, 25211, 25091
9026, 18462, 18521, 18522, 18463, 25211, 25212, 25213, 25093
9027, 18463, 18522, 18523, 18464, 25213, 25214, 25215, 25095
9028, 18464, 18523, 18524, 18465, 25215, 25216, 25217, 25097
9029, 18465, 18524, 18525, 18466, 25217, 25218, 25219, 25099
9030, 18466, 18525, 18526, 18467, 25219, 25220, 25221, 25101
9031, 18467, 18526, 18527, 18468, 25221, 25222, 25223, 25103
9032, 18468, 18527, 18528, 18469, 25223, 25224, 25225, 25105
9033, 18469, 18528, 18529, 18470, 25225, 25226, 25227, 25107
9034, 18470, 18529, 18530, 18471, 25227, 25228, 25229, 25109
9035, 18471, 18530, 18531, 18472, 25229, 25230, 25231, 25111
9036, 18472, 18531, 18532, 18473, 25231, 25232, 25233, 25113
9037, 18473, 18532, 18533, 18474, 25233, 25234, 25235, 25115
9038, 18474, 18533, 18534, 18475, 25235, 25236, 25237, 25117
9039, 18475, 18534, 18535, 18476, 25237, 25238, 25239, 25119
9040, 18476, 18535, 18536, 18477, 25239, 25240, 25241, 25121
9041, 18477, 18536, 18537, 18478, 25241, 25242, 25243, 25123
9042, 18478, 18537, 18538, 18479, 25243, 25244, 25245, 25125
9043, 18479, 18538, 18539, 18480, 25245, 25246, 25247, 25127
9044, 18480, 18539, 18540, 18481, 25247, 25248, 25249, 25129
9045, 18481, 18540, 18541, 18482, 25249, 25250, 25251, 25131
9046, 18482, 18541, 18542, 18483, 25251, 25252, 25253, 25133
9047, 18483, 18542, 18543, 18484, 25253, 25254, 25255, 25135
9048, 18484, 18543, 18544, 18485, 25255, 25256, 25257, 25137
9049, 18485, 18544, 18545, 18486, 25257, 25258, 25259, 25139
9050, 18486, 18545, 18546, 18487, 25259, 25260, 25261, 25141
9051, 18487, 18546, 18547, 18488, 25261, 25262, 25263, 25143
9052, 18488, 18547, 18548, 18489, 25263, 25264, 25265, 25145
9053, 18489, 18548, 18549, 18490, 25265, 25266, 25267, 25147
9054, 18490, 18549, 18550, 18491, 25267, 25268, 25269, 25149
9055, 18491, 18550, 18551, 18492, 25269, 25270, 25271, 25151
9056, 18492, 18551, 845, 844, 25271, 25272, 904, 25153
9057, 726, 727, 18552, 18493, 786, 25273, 25274, 25154
9058, 18493, 18552, 18553, 18494, 25274, 25275, 25276, 25156
9059, 18494, 18553, 18554, 18495, 25276, 25277, 25278, 25158
9060, 18495, 18554, 18555, 18496, 25278, 25279, 25280, 25160
9061, 18496, 18555, 18556, 18497, 25280, 25281, 25282, 25162
9062, 18497, 18556, 18557, 18498, 25282, 25283, 25284, 25164
9063, 18498, 18557, 18558, 18499, 25284, 25285, 25286, 25166
9064, 18499, 18558, 18559, 18500, 25286, 25287, 25288, 25168
9065, 18500, 18559, 18560, 18501, 25288, 25289, 25290, 25170
9066, 18501, 18560, 18561, 18502, 25290, 25291, 25292, 25172
9067, 18502, 18561, 18562, 18503, 25292, 25293, 25294, 25174
9068, 18503, 18562, 18563, 18504, 25294, 25295, 25296, 25176
9069, 18504, 18563, 18564, 18505, 25296, 25297, 25298, 25178
9070, 18505, 18564, 18565, 18506, 25298, 25299, 25300, 25180
9071, 18506, 18565, 18566, 18507, 25300, 25301, 25302, 25182
9072, 18507, 18566, 18567, 18508, 25302, 25303, 25304, 25184
9073, 18508, 18567, 18568, 18509, 25304, 25305, 25306, 25186
9074, 18509, 18568, 18569, 18510, 25306, 25307, 25308, 25188
9075, 18510, 18569, 18570, 18511, 25308, 25309, 25310, 25190
9076, 18511, 18570, 18571, 18512, 25310, 25311, 25312, 25192
9077, 18512, 18571, 18572, 18513, 25312, 25313, 25314, 25194
9078, 18513, 18572, 18573, 18514, 25314, 25315, 25316, 25196
9079, 18514, 18573, 18574, 18515, 25316, 25317, 25318, 25198
9080, 18515, 18574, 18575, 18516, 25318, 25319, 25320, 25200
9081, 18516, 18575, 18576, 18517, 25320, 25321, 25322, 25202
9082, 18517, 18576, 18577, 18518, 25322, 25323, 25324, 25204
9083, 18518, 18577, 18578, 18519, 25324, 25325, 25326, 25206
9084, 18519, 18578, 18579, 18520, 25326, 25327, 25328, 25208
9085, 18520, 18579, 18580, 18521, 25328, 25329, 25330, 25210
9086, 18521, 18580, 18581, 18522, 25330, 25331, 25332, 25212
9087, 18522, 18581, 18582, 18523, 25332, 25333, 25334, 25214
9088, 18523, 18582, 18583, 18524, 25334, 25335, 25336, 25216
9089, 18524, 18583, 18584, 18525, 25336, 25337, 25338, 25218
9090, 18525, 18584, 18585, 18526, 25338, 25339, 25340, 25220
9091, 18526, 18585, 18586, 18527, 25340, 25341, 25342, 25222
9092, 18527, 18586, 18587, 18528, 25342, 25343, 25344, 25224
9093, 18528, 18587, 18588, 18529, 25344, 25345, 25346, 25226
9094, 18529, 18588, 18589, 18530, 25346, 25347, 25348, 25228
9095, 18530, 18589, 18590, 18531, 25348, 25349, 25350, 25230
9096, 18531, 18590, 18591, 18532, 25350, 25351, 25352, 25232
9097, 18532, 18591, 18592, 18533, 25352, 25353, 25354, 25234
9098, 18533, 18592, 18593, 18534, 25354, 25355, 25356, 25236
9099, 18534, 18593, 18594, 18535, 25356, 25357, 25358, 25238
9100, 18535, 18594, 18595, 18536, 25358, 25359, 25360, 25240
9101, 18536, 18595, 18596, 18537, 25360, 25361, 25362, 25242
9102, 18537, 18596, 18597, 18538, 25362, 25363, 25364, 25244
9103, 18538, 18597, 18598, 18539, 25364, 25365, 25366, 25246
9104, 18539, 18598, 18599, 18540, 25366, 25367, 25368, 25248
9105, 18540, 18599, 18600, 18541, 25368, 25369, 25370, 25250
9106, 18541, 18600, 18601, 18542, 25370, 25371, 25372, 25252
9107, 18542, 18601, 18602, 18543, 25372, 25373, 25374, 25254
9108, 18543, 18602, 18603, 18544, 25374, 25375, 25376, 25256
9109, 18544, 18603, 18604, 18545, 25376, 25377, 25378, 25258
9110, 18545, 18604, 18605, 18546, 25378, 25379, 25380, 25260
9111, 18546, 18605, 18606, 18547, 25380, 25381, 25382, 25262
9112, 18547, 18606, 18607, 18548, 25382, 25383, 25384, 25264
9113, 18548, 18607, 18608, 18549, 25384, 25385, 25386, 25266
9114, 18549, 18608, 18609, 18550, 25386, 25387, 25388, 25268
9115, 18550, 18609, 18610, 18551, 25388, 25389, 25390, 25270
9116, 18551, 18610, 846, 845, 25390, 25391, 905, 25272
9117, 727, 728, 18611, 18552, 787, 25392, 25393, 25273
9118, 18552, 18611, 18612, 18553, 25393, 25394, 25395, 25275
9119, 18553, 18612, 18613, 18554, 25395, 25396, 25397, 25277
9120, 18554, 18613, 18614, 18555, 25397, 25398, 25399, 25279
9121, 18555, 18614, 18615, 18556, 25399, 25400, 25401, 25281
9122, 18556, 18615, 18616, 18557, 25401, 25402, 25403, 25283
9123, 18557, 18616, 18617, 18558, 25403, 25404, 25405, 25285
9124, 18558, 18617, 18618, 18559, 25405, 25406, 25407, 25287
9125, 18559, 18618, 18619, 18560, 25407, 25408, 25409, 25289
9126, 18560, 18619, 18620, 18561, 25409, 25410, 25411, 25291
9127, 18561, 18620, 18621, 18562, 25411, 25412, 25413, 25293
9128, 18562, 18621, 18622, 18563, 25413, 25414, 25415, 25295
9129, 18563, 18622, 18623, 18564, 25415, 25416, 25417, 25297
9130, 18564, 18623, 18624, 18565, 25417, 25418, 25419, 25299
9131, 18565, 18624, 18625, 18566, 25419, 25420, 25421, 25301
9132, 18566, 18625, 18626, 18567, 25421, 25422, 25423, 25303
9133, 18567, 18626, 18627, 18568, 25423, 25424, 25425, 25305
9134, 18568, 18627, 18628, 18569, 25425, 25426, 25427, 25307
9135, 18569, 18628, 18629, 18570, 25427, 25428, 25429, 25309
9136, 18570, 18629, 18630, 18571, 25429, 25430, 25431, 25311
9137, 18571, 18630, 18631, 18572, 25431, 25432, 25433, 25313
9138, 18572, 18631, 18632, 18573, 25433, 25434, 25435, 25315
9139, 18573, 18632, 18633, 18574, 25435, 25436, 25437, 25317
9140, 18574, 18633, 18634, 18575, 25437, 25438, 25439, 25319
9141, 18575, 18634, 18635, 18576, 25439, 25440, 25441, 25321
9142, 18576, 18635, 18636, 18577, 25441, 25442, 25443, 25323
9143, 18577, 18636, 18637, 18578, 25443, 25444, 25445, 25325
9144, 18578, 18637, 18638, 18579, 25445, 25446, 25447, 25327
9145, 18579, 18638, 18639, 18580, 25447, 25448, 25449, 25329
9146, 18580, 18639, 18640, 18581, 25449, 25450, 25451, 25331
9147, 18581, 18640, 18641, 18582, 25451, 25452, 25453, 25333
9148, 18582, 18641, 18642, 18583, 25453, 25454, 25455, 25335
9149, 18583, 18642, 18643, 18584, 25455, 25456, 25457, 25337
9150, 18584, 18643, 18644, 18585, 25457, 25458, 25459, 25339
9151, 18585, 18644, 18645, 18586, 25459, 25460, 25461, 25341
9152, 18586, 18645, 18646, 18587, 25461, 25462, 25463, 25343
9153, 18587, 18646, 18647, 18588, 25463, 25464, 25465, 25345
9154, 18588, 18647, 18648, 18589, 25465, 25466, 25467, 25347
9155, 18589, 18648, 18649, 18590, 25467, 25468, 25469, 25349
9156, 18590, 18649, 18650, 18591, 25469, 25470, 25471, 25351
9157, 18591, 18650, 18651, 18592, 25471, 25472, 25473, 25353
9158, 18592, 18651, 18652, 18593, 25473, 25474, 25475, 25355
9159, 18593, 18652, 18653, 18594, 25475, 25476, 25477, 25357
9160, 18594, 18653, 18654, 18595, 25477, 25478, 25479, 25359
9161, 18595, 18654, 18655, 18596, 25479, 25480, 25481, 25361
9162, 18596, 18655, 18656, 18597, 25481, 25482, 25483, 25363
9163, 18597, 18656, 18657, 18598, 25483, 25484, 25485, 25365
9164, 18598, 18657, 18658, 18599, 25485, 25486, 25487, 25367
9165, 18599, 18658, 18659, 18600, 25487, 25488, 25489, 25369
9166, 18600, 18659, 18660, 18601, 25489, 25490, 25491, 25371
9167, 18601, 18660, 18661, 18602, 25491, 25492, 25493, 25373
9168, 18602, 18661, 18662, 18603, 25493, 25494, 25495, 25375
9169, 18603, 18662, 18663, 18604, 25495, 25496, 25497, 25377
9170, 18604, 18663, 18664, 18605, 25497, 25498, 25499, 25379
9171, 18605, 18664, 18665, 18606, 25499, 25500, 25501, 25381
9172, 18606, 18665, 18666, 18607, 25501, 25502, 25503, 25383
9173, 18607, 18666, 18667, 18608, 25503, 25504, 25505, 25385
9174, 18608, 18667, 18668, 18609, 25505, 25506, 25507, 25387
9175, 18609, 18668, 18669, 18610, 25507, 25508, 25509, 25389
9176, 18610, 18669, 847, 846, 25509, 25510, 906, 25391
9177, 728, 729, 18670, 18611, 788, 25511, 25512, 25392
9178, 18611, 18670, 18671, 18612, 25512, 25513, 25514, 25394
9179, 18612, 18671, 18672, 18613, 25514, 25515, 25516, 25396
9180, 18613, 18672, 18673, 18614, 25516, 25517, 25518, 25398
9181, 18614, 18673, 18674, 18615, 25518, 25519, 25520, 25400
9182, 18615, 18674, 18675, 18616, 25520, 25521, 25522, 25402
9183, 18616, 18675, 18676, 18617, 25522, 25523, 25524, 25404
9184, 18617, 18676, 18677, 18618, 25524, 25525, 25526, 25406
9185, 18618, 18677, 18678, 18619, 25526, 25527, 25528, 25408
9186, 18619, 18678, 18679, 18620, 25528, 25529, 25530, 25410
9187, 18620, 18679, 18680, 18621, 25530, 25531, 25532, 25412
9188, 18621, 18680, 18681, 18622, 25532, 25533, 25534, 25414
9189, 18622, 18681, 18682, 18623, 25534, 25535, 25536, 25416
9190, 18623, 18682, 18683, 18624, 25536, 25537, 25538, 25418
9191, 18624, 18683, 18684, 18625, 25538, 25539, 25540, 25420
9192, 18625, 18684, 18685, 18626, 25540, 25541, 25542, 25422
9193, 18626, 18685, 18686, 18627, 25542, 25543, 25544, 25424
9194, 18627, 18686, 18687, 18628, 25544, 25545, 25546, 25426
9195, 18628, 18687, 18688, 18629, 25546, 25547, 25548, 25428
9196, 18629, 18688, 18689, 18630, 25548, 25549, 25550, 25430
9197, 18630, 18689, 18690, 18631, 25550, 25551, 25552, 25432
9198, 18631, 18690, 18691, 18632, 25552, 25553, 25554, 25434
9199, 18632, 18691, 18692, 18633, 25554, 25555, 25556, 25436
9200, 18633, 18692, 18693, 18634, 25556, 25557, 25558, 25438
9201, 18634, 18693, 18694, 18635, 25558, 25559, 25560, 25440
9202, 18635, 18694, 18695, 18636, 25560, 25561, 25562, 25442
9203, 18636, 18695, 18696, 18637, 25562, 25563, 25564, 25444
9204, 18637, 18696, 18697, 18638, 25564, 25565, 25566, 25446
9205, 18638, 18697, 18698, 18639, 25566, 25567, 25568, 25448
9206, 18639, 18698, 18699, 18640, 25568, 25569, 25570, 25450
9207, 18640, 18699, 18700, 18641, 25570, 25571, 25572, 25452
9208, 18641, 18700, 18701, 18642, 25572, 25573, 25574, 25454
9209, 18642, 18701, 18702, 18643, 25574, 25575, 25576, 25456
9210, 18643, 18702, 18703, 18644, 25576, 25577, 25578, 25458
9211, 18644, 18703, 18704, 18645, 25578, 25579, 25580, 25460
9212, 18645, 18704, 18705, 18646, 25580, 25581, 25582, 25462
9213, 18646, 18705, 18706, 18647, 25582, 25583, 25584, 25464
9214, 18647, 18706, 18707, 18648, 25584, 25585, 25586, 25466
9215, 18648, 18707, 18708, 18649, 25586, 25587, 25588, 25468
9216, 18649, 18708, 18709, 18650, 25588, 25589, 25590, 25470
9217, 18650, 18709, 18710, 18651, 25590, 25591, 25592, 25472
9218, 18651, 18710, 18711, 18652, 25592, 25593, 25594, 25474
9219, 18652, 18711, 18712, 18653, 25594, 25595, 25596, 25476
9220, 18653, 18712, 18713, 18654, 25596, 25597, 25598, 25478
9221, 18654, 18713, 18714, 18655, 25598, 25599, 25600, 25480
9222, 18655, 18714, 18715, 18656, 25600, 25601, 25602, 25482
9223, 18656, 18715, 18716, 18657, 25602, 25603, 25604, 25484
9224, 18657, 18716, 18717, 18658, 25604, 25605, 25606, 25486
9225, 18658, 18717, 18718, 18659, 25606, 25607, 25608, 25488
9226, 18659, 18718, 18719, 18660, 25608, 25609, 25610, 25490
9227, 18660, 18719, 18720, 18661, 25610, 25611, 25612, 25492
9228, 18661, 18720, 18721, 18662, 25612, 25613, 25614, 25494
9229, 18662, 18721, 18722, 18663, 25614, 25615, 25616, 25496
9230, 18663, 18722, 18723, 18664, 25616, 25617, 25618, 25498
9231, 18664, 18723, 18724, 18665, 25618, 25619, 25620, 25500
9232, 18665, 18724, 18725, 18666, 25620, 25621, 25622, 25502
9233, 18666, 18725, 18726, 18667, 25622, 25623, 25624, 25504
9234, 18667, 18726, 18727, 18668, 25624, 25625, 25626, 25506
9235, 18668, 18727, 18728, 18669, 25626, 25627, 25628, 25508
9236, 18669, 18728, 848, 847, 25628, 25629, 907, 25510
9237, 729, 730, 18729, 18670, 789, 25630, 25631, 25511
9238, 18670, 18729, 18730, 18671, 25631, 25632, 25633, 25513
9239, 18671, 18730, 18731, 18672, 25633, 25634, 25635, 25515
9240, 18672, 18731, 18732, 18673, 25635, 25636, 25637, 25517
9241, 18673, 18732, 18733, 18674, 25637, 25638, 25639, 25519
9242, 18674, 18733, 18734, 18675, 25639, 25640, 25641, 25521
9243, 18675, 18734, 18735, 18676, 25641, 25642, 25643, 25523
9244, 18676, 18735, 18736, 18677, 25643, 25644, 25645, 25525
9245, 18677, 18736, 18737, 18678, 25645, 25646, 25647, 25527
9246, 18678, 18737, 18738, 18679, 25647, 25648, 25649, 25529
9247, 18679, 18738, 18739, 18680, 25649, 25650, 25651, 25531
9248, 18680, 18739, 18740, 18681, 25651, 25652, 25653, 25533
9249, 18681, 18740, 18741, 18682, 25653, 25654, 25655, 25535
9250, 18682, 18741, 18742, 18683, 25655, 25656, 25657, 25537
9251, 18683, 18742, 18743, 18684, 25657, 25658, 25659, 25539
9252, 18684, 18743, 18744, 18685, 25659, 25660, 25661, 25541
9253, 18685, 18744, 18745, 18686, 25661, 25662, 25663, 25543
9254, 18686, 18745, 18746, 18687, 25663, 25664, 25665, 25545
9255, 18687, 18746, 18747, 18688, 25665, 25666, 25667, 25547
9256, 18688, 18747, 18748, 18689, 25667, 25668, 25669, 25549
9257, 18689, 18748, 18749, 18690, 25669, 25670, 25671, 25551
9258, 18690, 18749, 18750, 18691, 25671, 25672, 25673, 25553
9259, 18691, 18750, 18751, 18692, 25673, 25674, 25675, 25555
9260, 18692, 18751, 18752, 18693, 25675, 25676, 25677, 25557
9261, 18693, 18752, 18753, 18694, 25677, 25678, 25679, 25559
9262, 18694, 18753, 18754, 18695, 25679, 25680, 25681, 25561
9263, 18695, 18754, 18755, 18696, 25681, 25682, 25683, 25563
9264, 18696, 18755, 18756, 18697, 25683, 25684, 25685, 25565
9265, 18697, 18756, 18757, 18698, 25685, 25686, 25687, 25567
9266, 18698, 18757, 18758, 18699, 25687, 25688, 25689, 25569
9267, 18699, 18758, 18759, 18700, 25689, 25690, 25691, 25571
9268, 18700, 18759, 18760, 18701, 25691, 25692, 25693, 25573
9269, 18701, 18760, 18761, 18702, 25693, 25694, 25695, 25575
9270, 18702, 18761, 18762, 18703, 25695, 25696, 25697, 25577
9271, 18703, 18762, 18763, 18704, 25697, 25698, 25699, 25579
9272, 18704, 18763, 18764, 18705, 25699, 25700, 25701, 25581
9273, 18705, 18764, 18765, 18706, 25701, 25702, 25703, 25583
9274, 18706, 18765, 18766, 18707, 25703, 25704, 25705, 25585
9275, 18707, 18766, 18767, 18708, 25705, 25706, 25707, 25587
9276, 18708, 18767, 18768, 18709, 25707, 25708, 25709, 25589
9277, 18709, 18768, 18769, 18710, 25709, 25710, 25711, 25591
9278, 18710, 18769, 18770, 18711, 25711, 25712, 25713, 25593
9279, 18711, 18770, 18771, 18712, 25713, 25714, 25715, 25595
9280, 18712, 18771, 18772, 18713, 25715, 25716, 25717, 25597
9281, 18713, 18772, 18773, 18714, 25717, 25718, 25719, 25599
9282, 18714, 18773, 18774, 18715, 25719, 25720, 25721, 25601
9283, 18715, 18774, 18775, 18716, 25721, 25722, 25723, 25603
9284, 18716, 18775, 18776, 18717, 25723, 25724, 25725, 25605
9285, 18717, 18776, 18777, 18718, 25725, 25726, 25727, 25607
9286, 18718, 18777, 18778, 18719, 25727, 25728, 25729, 25609
9287, 18719, 18778, 18779, 18720, 25729, 25730, 25731, 25611
9288, 18720, 18779, 18780, 18721, 25731, 25732, 25733, 25613
9289, 18721, 18780, 18781, 18722, 25733, 25734, 25735, 25615
9290, 18722, 18781, 18782, 18723, 25735, 25736, 25737, 25617
9291, 18723, 18782, 18783, 18724, 25737, 25738, 25739, 25619
9292, 18724, 18783, 18784, 18725, 25739, 25740, 25741, 25621
9293, 18725, 18784, 18785, 18726, 25741, 25742, 25743, 25623
9294, 18726, 18785, 18786, 18727, 25743, 25744, 25745, 25625
9295, 18727, 18786, 18787, 18728, 25745, 25746, 25747, 25627
9296, 18728, 18787, 849, 848, 25747, 25748, 908, 25629
9297, 730, 731, 18788, 18729, 790, 25749, 25750, 25630
9298, 18729, 18788, 18789, 18730, 25750, 25751, 25752, 25632
9299, 18730, 18789, 18790, 18731, 25752, 25753, 25754, 25634
9300, 18731, 18790, 18791, 18732, 25754, 25755, 25756, 25636
9301, 18732, 18791, 18792, 18733, 25756, 25757, 25758, 25638
9302, 18733, 18792, 18793, 18734, 25758, 25759, 25760, 25640
9303, 18734, 18793, 18794, 18735, 25760, 25761, 25762, 25642
9304, 18735, 18794, 18795, 18736, 25762, 25763, 25764, 25644
9305, 18736, 18795, 18796, 18737, 25764, 25765, 25766, 25646
9306, 18737, 18796, 18797, 18738, 25766, 25767, 25768, 25648
9307, 18738, 18797, 18798, 18739, 25768, 25769, 25770, 25650
9308, 18739, 18798, 18799, 18740, 25770, 25771, 25772, 25652
9309, 18740, 18799, 18800, 18741, 25772, 25773, 25774, 25654
9310, 18741, 18800, 18801, 18742, 25774, 25775, 25776, 25656
9311, 18742, 18801, 18802, 18743, 25776, 25777, 25778, 25658
9312, 18743, 18802, 18803, 18744, 25778, 25779, 25780, 25660
9313, 18744, 18803, 18804, 18745, 25780, 25781, 25782, 25662
9314, 18745, 18804, 18805, 18746, 25782, 25783, 25784, 25664
9315, 18746, 18805, 18806, 18747, 25784, 25785, 25786, 25666
9316, 18747, 18806, 18807, 18748, 25786, 25787, 25788, 25668
9317, 18748, 18807, 18808, 18749, 25788, 25789, 25790, 25670
9318, 18749, 18808, 18809, 18750, 25790, 25791, 25792, 25672
9319, 18750, 18809, 18810, 18751, 25792, 25793, 25794, 25674
9320, 18751, 18810, 18811, 18752, 25794, 25795, 25796, 25676
9321, 18752, 18811, 18812, 18753, 25796, 25797, 25798, 25678
9322, 18753, 18812, 18813, 18754, 25798, 25799, 25800, 25680
9323, 18754, 18813, 18814, 18755, 25800, 25801, 25802, 25682
9324, 18755, 18814, 18815, 18756, 25802, 25803, 25804, 25684
9325, 18756, 18815, 18816, 18757, 25804, 25805, 25806, 25686
9326, 18757, 18816, 18817, 18758, 25806, 25807, 25808, 25688
9327, 18758, 18817, 18818, 18759, 25808, 25809, 25810, 25690
9328, 18759, 18818, 18819, 18760, 25810, 25811, 25812, 25692
9329, 18760, 18819, 18820, 18761, 25812, 25813, 25814, 25694
9330, 18761, 18820, 18821, 18762, 25814, 25815, 25816, 25696
9331, 18762, 18821, 18822, 18763, 25816, 25817, 25818, 25698
9332, 18763, 18822, 18823, 18764, 25818, 25819, 25820, 25700
9333, 18764, 18823, 18824, 18765, 25820, 25821, 25822, 25702
9334, 18765, 18824, 18825, 18766, 25822, 25823, 25824, 25704
9335, 18766, 18825, 18826, 18767, 25824, 25825, 25826, 25706
9336, 18767, 18826, 18827, 18768, 25826, 25827, 25828, 25708
9337, 18768, 18827, 18828, 18769, 25828, 25829, 25830, 25710
9338, 18769, 18828, 18829, 18770, 25830, 25831, 25832, 25712
9339, 18770, 18829, 18830, 18771, 25832, 25833, 25834, 25714
9340, 18771, 18830, 18831, 18772, 25834, 25835, 25836, 25716
9341, 18772, 18831, 18832, 18773, 25836, 25837, 25838, 25718
9342, 18773, 18832, 18833, 18774, 25838, 25839, 25840, 25720
9343, 18774, 18833, 18834, 18775, 25840, 25841, 25842, 25722
9344, 18775, 18834, 18835, 18776, 25842, 25843, 25844, 25724
9345, 18776, 18835, 18836, 18777, 25844, 25845, 25846, 25726
9346, 18777, 18836, 18837, 18778, 25846, 25847, 25848, 25728
9347, 18778, 18837, 18838, 18779, 25848, 25849, 25850, 25730
9348, 18779, 18838, 18839, 18780, 25850, 25851, 25852, 25732
9349, 18780, 18839, 18840, 18781, 25852, 25853, 25854, 25734
9350, 18781, 18840, 18841, 18782, 25854, 25855, 25856, 25736
9351, 18782, 18841, 18842, 18783, 25856, 25857, 25858, 25738
9352, 18783, 18842, 18843, 18784, 25858, 25859, 25860, 25740
9353, 18784, 18843, 18844, 18785, 25860, 25861, 25862, 25742
9354, 18785, 18844, 18845, 18786, 25862, 25863, 25864, 25744
9355, 18786, 18845, 18846, 18787, 25864, 25865, 25866, 25746
9356, 18787, 18846, 850, 849, 25866, 25867, 909, 25748
9357, 731, 11, 1030, 18788, 791, 1089, 25868, 25749
9358, 18788, 1030, 1031, 18789, 25868, 1090, 25869, 25751
9359, 18789, 1031, 1032, 18790, 25869, 1091, 25870, 25753
9360, 18790, 1032, 1033, 18791, 25870, 1092, 25871, 25755
9361, 18791, 1033, 1034, 18792, 25871, 1093, 25872, 25757
9362, 18792, 1034, 1035, 18793, 25872, 1094, 25873, 25759
9363, 18793, 1035, 1036, 18794, 25873, 1095, 25874, 25761
9364, 18794, 1036, 1037, 18795, 25874, 1096, 25875, 25763
9365, 18795, 1037, 1038, 18796, 25875, 1097, 25876, 25765
9366, 18796, 1038, 1039, 18797, 25876, 1098, 25877, 25767
9367, 18797, 1039, 1040, 18798, 25877, 1099, 25878, 25769
9368, 18798, 1040, 1041, 18799, 25878, 1100, 25879, 25771
9369, 18799, 1041, 1042, 18800, 25879, 1101, 25880, 25773
9370, 18800, 1042, 1043, 18801, 25880, 1102, 25881, 25775
9371, 18801, 1043, 1044, 18802, 25881, 1103, 25882, 25777
9372, 18802, 1044, 1045, 18803, 25882, 1104, 25883, 25779
9373, 18803, 1045, 1046, 18804, 25883, 1105, 25884, 25781
9374, 18804, 1046, 1047, 18805, 25884, 1106, 25885, 25783
9375, 18805, 1047, 1048, 18806, 25885, 1107, 25886, 25785
9376, 18806, 1048, 1049, 18807, 25886, 1108, 25887, 25787
9377, 18807, 1049, 1050, 18808, 25887, 1109, 25888, 25789
9378, 18808, 1050, 1051, 18809, 25888, 1110, 25889, 25791
9379, 18809, 1051, 1052, 18810, 25889, 1111, 25890, 25793
9380, 18810, 1052, 1053, 18811, 25890, 1112, 25891, 25795
9381, 18811, 1053, 1054, 18812, 25891, 1113, 25892, 25797
9382, 18812, 1054, 1055, 18813, 25892, 1114, 25893, 25799
9383, 18813, 1055, 1056, 18814, 25893, 1115, 25894, 25801
9384, 18814, 1056, 1057, 18815, 25894, 1116, 25895, 25803
9385, 18815, 1057, 1058, 18816, 25895, 1117, 25896, 25805
9386, 18816, 1058, 1059, 18817, 25896, 1118, 25897, 25807
9387, 18817, 1059, 1060, 18818, 25897, 1119, 25898, 25809
9388, 18818, 1060, 1061, 18819, 25898, 1120, 25899, 25811
9389, 18819, 1061, 1062, 18820, 25899, 1121, 25900, 25813
9390, 18820, 1062, 1063, 18821, 25900, 1122, 25901, 25815
9391, 18821, 1063, 1064, 18822, 25901, 1123, 25902, 25817
9392, 18822, 1064, 1065, 18823, 25902, 1124, 25903, 25819
9393, 18823, 1065, 1066, 18824, 25903, 1125, 25904, 25821
9394, 18824, 1066, 1067, 18825, 25904, 1126, 25905, 25823
9395, 18825, 1067, 1068, 18826, 25905, 1127, 25906, 25825
9396, 18826, 1068, 1069, 18827, 25906, 1128, 25907, 25827
9397, 18827, 1069, 1070, 18828, 25907, 1129, 25908, 25829
9398, 18828, 1070, 1071, 18829, 25908, 1130, 25909, 25831
9399, 18829, 1071, 1072, 18830, 25909, 1131, 25910, 25833
9400, 18830, 1072, 1073, 18831, 25910, 1132, 25911, 25835
9401, 18831, 1073, 1074, 18832, 25911, 1133, 25912, 25837
9402, 18832, 1074, 1075, 18833, 25912, 1134, 25913, 25839
9403, 18833, 1075, 1076, 18834, 25913, 1135, 25914, 25841
9404, 18834, 1076, 1077, 18835, 25914, 1136, 25915, 25843
9405, 18835, 1077, 1078, 18836, 25915, 1137, 25916, 25845
9406, 18836, 1078, 1079, 18837, 25916, 1138, 25917, 25847
9407, 18837, 1079, 1080, 18838, 25917, 1139, 25918, 25849
9408, 18838, 1080, 1081, 18839, 25918, 1140, 25919, 25851
9409, 18839, 1081, 1082, 18840, 25919, 1141, 25920, 25853
9410, 18840, 1082, 1083, 18841, 25920, 1142, 25921, 25855
9411, 18841, 1083, 1084, 18842, 25921, 1143, 25922, 25857
9412, 18842, 1084, 1085, 18843, 25922, 1144, 25923, 25859
9413, 18843, 1085, 1086, 18844, 25923, 1145, 25924, 25861
9414, 18844, 1086, 1087, 18845, 25924, 1146, 25925, 25863
9415, 18845, 1087, 1088, 18846, 25925, 1147, 25926, 25865
9416, 18846, 1088, 13, 850, 25926, 1148, 910, 25867
*ELEMENT, type=CPS8, ELSET=Surface6
9417, 27, 1627, 25927, 1649, 1632, 26222, 26223, 1708
9418, 1649, 25927, 25928, 1650, 26223, 26224, 26225, 1709
9419, 1650, 25928, 25929, 1651, 26225, 26226, 26227, 1710
9420, 1651, 25929, 25930, 1652, 26227, 26228, 26229, 1711
9421, 1652, 25930, 25931, 1653, 26229, 26230, 26231, 1712
9422, 1653, 25931, 25932, 1654, 26231, 26232, 26233, 1713
9423, 1654, 25932, 25933, 1655, 26233, 26234, 26235, 1714
9424, 1655, 25933, 25934, 1656, 26235, 26236, 26237, 1715
9425, 1656, 25934, 25935, 1657, 26237, 26238, 26239, 1716
9426, 1657, 25935, 25936, 1658, 26239, 26240, 26241, 1717
9427, 1658, 25936, 25937, 1659, 26241, 26242, 26243, 1718
9428, 1659, 25937, 25938, 1660, 26243, 26244, 26245, 1719
9429, 1660, 25938, 25939, 1661, 26245, 26246, 26247, 1720
9430, 1661, 25939, 25940, 1662, 26247, 26248, 26249, 1721
9431, 1662, 25940, 25941, 1663, 26249, 26250, 26251, 1722
9432, 1663, 25941, 25942, 1664, 26251, 26252, 26253, 1723
9433, 1664, 25942, 25943, 1665, 26253, 26254, 26255, 1724
9434, 1665, 25943, 25944, 1666, 26255, 26256, 26257, 1725
9435, 1666, 25944, 25945, 1667, 26257, 26258, 26259, 1726
9436, 1667, 25945, 25946, 1668, 26259, 26260, 26261, 1727
9437, 1668, 25946, 25947, 1669, 26261, 26262, 26263, 1728
9438, 1669, 25947, 25948, 1670, 26263, 26264, 26265, 1729
9439, 1670, 25948, 25949, 1671, 26265, 26266, 26267, 1730
9440, 1671, 25949, 25950, 1672, 26267, 26268, 26269, 1731
9441, 1672, 25950, 25951, 1673, 26269, 26270, 26271, 1732
9442, 1673, 25951, 25952, 1674, 26271, 26272, 26273, 1733
9443, 1674, 25952, 25953, 1675, 26273, 26274, 26275, 1734
9444, 1675, 25953, 25954, 1676, 26275, 26276, 26277, 1735
9445, 1676, 25954, 25955, 1677, 26277, 26278, 26279, 1736
9446, 1677, 25955, 25956, 1678, 26279, 26280, 26281, 1737
9447, 1678, 25956, 25957, 1679, 26281, 26282, 26283, 1738
9448, 1679, 25957, 25958, 1680, 26283, 26284, 26285, 1739
9449, 1680, 25958, 25959, 1681, 26285, 26286, 26287, 1740
9450, 1681, 25959, 25960, 1682, 26287, 26288, 26289, 1741
9451, 1682, 25960, 25961, 1683, 26289, 26290, 26291, 1742
9452, 1683, 25961, 25962, 1684, 26291, 26292, 26293, 1743
9453, 1684, 25962, 25963, 1685, 26293, 26294, 26295, 1744
9454, 1685, 25963, 25964, 1686, 26295, 26296, 26297, 1745
9455, 1686, 25964, 25965, 1687, 26297, 26298, 26299, 1746
9456, 1687, 25965, 25966, 1688, 26299, 26300, 26301, 1747
9457, 1688, 25966, 25967, 1689, 26301, 26302, 26303, 1748
9458, 1689, 25967, 25968, 1690, 26303, 26304, 26305, 1749
9459, 1690, 25968, 25969, 1691, 26305, 26306, 26307, 1750
9460, 1691, 25969, 25970, 1692, 26307, 26308, 26309, 1751
9461, 1692, 25970, 25971, 1693, 26309, 26310, 26311, 1752
9462, 1693, 25971, 25972, 1694, 26311, 26312, 26313, 1753
9463, 1694, 25972, 25973, 1695, 26313, 26314, 26315, 1754
9464, 1695, 25973, 25974, 1696, 26315, 26316, 26317, 1755
9465, 1696, 25974, 25975, 1697, 26317, 26318, 26319, 1756
9466, 1697, 25975, 25976, 1698, 26319, 26320, 26321, 1757
9467, 1698, 25976, 25977, 1699, 26321, 26322, 26323, 1758
9468, 1699, 25977, 25978, 1700, 26323, 26324, 26325, 1759
9469, 1700, 25978, 25979, 1701, 26325, 26326, 26327, 1760
9470, 1701, 25979, 25980, 1702, 26327, 26328, 26329, 1761
9471, 1702, 25980, 25981, 1703, 26329, 26330, 26331, 1762
9472, 1703, 25981, 25982, 1704, 26331, 26332, 26333, 1763
9473, 1704, 25982, 25983, 1705, 26333, 26334, 26335, 1764
9474, 1705, 25983, 25984, 1706, 26335, 26336, 26337, 1765
9475, 1706, 25984, 25985, 1707, 26337, 26338, 26339, 1766
9476, 1707, 25985, 1638, 28, 26339, 26340, 1643, 1767
9477, 1627, 1628, 25986, 25927, 1633, 26341, 26342, 26222
9478, 25927, 25986, 25987, 25928, 26342, 26343, 26344, 26224
9479, 25928, 25987, 25988, 25929, 26344, 26345, 26346, 26226
9480, 25929, 25988, 25989, 25930, 26346, 26347, 26348, 26228
9481, 25930, 25989, 25990, 25931, 26348, 26349, 26350, 26230
9482, 25931, 25990, 25991, 25932, 26350, 26351, 26352, 26232
9483, 25932, 25991, 25992, 25933, 26352, 26353, 26354, 26234
9484, 25933, 25992, 25993, 25934, 26354, 26355, 26356, 26236
9485, 25934, 25993, 25994, 25935, 26356, 26357, 26358, 26238
9486, 25935, 25994, 25995, 25936, 26358, 26359, 26360, 26240
9487, 25936, 25995, 25996, 25937, 26360, 26361, 26362, 26242
9488, 25937, 25996, 25997, 25938, 26362, 26363, 26364, 26244
9489, 25938, 25997, 25998, 25939, 26364, 26365, 26366, 26246
9490, 25939, 25998, 25999, 25940, 26366, 26367, 26368, 26248
9491, 25940, 25999, 26000, 25941, 26368, 26369, 26370, 26250
9492, 25941, 26000, 26001, 25942, 26370, 26371, 26372, 26252
9493, 25942, 26001, 26002, 25943, 26372, 26373, 26374, 26254
9494, 25943, 26002, 26003, 25944, 26374, 26375, 26376, 26256
9495, 25944, 26003, 26004, 25945, 26376, 26377, 26378, 26258
9496, 25945, 26004, 26005, 25946, 26378, 26379, 26380, 26260
9497, 25946, 26005, 26006, 25947, 26380, 26381, 26382, 26262
9498, 25947, 26006, 26007, 25948, 26382, 26383, 26384, 26264
9499, 25948, 26007, 26008, 25949, 26384, 26385, 26386, 26266
9500, 25949, 26008, 26009, 25950, 26386, 26387, 26388, 26268
9501, 25950, 26009, 26010, 25951, 26388, 26389, 26390, 26270
9502, 25951, 26010, 26011, 25952, 26390, 26391, 26392, 26272
9503, 25952, 26011, 26012, 25953, 26392, 26393, 26394, 26274
9504, 25953, 26012, 26013, 25954, 26394, 26395, 26396, 26276
9505, 25954, 26013, 26014, 25955, 26396, 26397, 26398, 26278
9506, 25955, 26014, 26015, 25956, 26398, 26399, 26400, 26280
9507, 25956, 26015, 26016, 25957, 26400, 26401, 26402, 26282
9508, 25957, 26016, 26017, 25958, 26402, 26403, 26404, 26284
9509, 25958, 26017, 26018, 25959, 26404, 26405, 26406, 26286
9510, 25959, 26018, 26019, 25960, 26406, 26407, 26408, 26288
9511, 25960, 26019, 26020, 25961, 26408, 26409, 26410, 26290
9512, 25961, 26020, 26021, 25962, 26410, 26411, 26412, 26292
9513, 25962, 26021, 26022, 25963, 26412, 26413, 26414, 26294
9514, 25963, 26022, 26023, 25964, 26414, 26415, 26416, 26296
9515, 25964, 26023, 26024, 25965, 26416, 26417, 26418, 26298
9516, 25965, 26024, 26025, 25966, 26418, 26419, 26420, 26300
9517, 25966, 26025, 26026, 25967, 26420, 26421, 26422, 26302
9518, 25967, 26026, 26027, 25968, 26422, 26423, 26424, 26304
9519, 25968, 26027, 26028, 25969, 26424, 26425, 26426, 26306
9520, 25969, 26028, 26029, 25970, 26426, 26427, 26428, 26308
9521, 25970, 26029, 26030, 25971, 26428, 26429, 26430, 26310
9522, 25971, 26030, 26031, 25972, 26430, 26431, 26432, 26312
9523, 25972, 26031, 26032, 25973, 26432, 26433, 26434, 26314
9524, 25973, 26032, 26033, 25974, 26434, 26435, 26436, 26316
9525, 25974, 26033, 26034, 25975, 26436, 26437, 26438, 26318
9526, 25975, 26034, 26035, 25976, 26438, 26439, 26440, 26320
9527, 25976, 26035, 26036, 25977, 26440, 26441, 26442, 26322
9528, 25977, 26036, 26037, 25978, 26442, 26443, 26444, 26324
9529, 25978, 26037, 26038, 25979, 26444, 26445, 26446, 26326
9530, 25979, 26038, 26039, 25980, 26446, 26447, 26448, 26328
9531, 25980, 26039, 26040, 25981, 26448, 26449, 26450, 26330
9532, 25981, 26040, 26041, 25982, 26450, 26451, 26452, 26332
9533, 25982, 26041, 26042, 25983, 26452, 26453, 26454, 26334
9534, 25983, 26042, 26043, 25984, 26454, 26455, 26456, 26336
9535, 25984, 26043, 26044, 25985, 26456, 26457, 26458, 26338
9536, 25985, 26044, 1639, 1638, 26458, 26459, 1644, 26340
9537, 1628, 1629, 26045, 25986, 1634, 26460, 26461, 26341
9538, 25986, 26045, 26046, 25987, 26461, 26462, 26463, 26343
9539, 25987, 26046, 26047, 25988, 26463, 26464, 26465, 26345
9540, 25988, 26047, 26048, 25989, 26465, 26466, 26467, 26347
9541, 25989, 26048, 26049, 25990, 26467, 26468, 26469, 26349
9542, 25990, 26049, 26050, 25991, 26469, 26470, 26471, 26351
9543, 25991, 26050, 26051, 25992, 26471, 26472, 26473, 26353
9544, 25992, 26051, 26052, 25993, 26473, 26474, 26475, 26355
9545, 25993, 26052, 26053, 25994, 26475, 26476, 26477, 26357
9546, 25994, 26053, 26054, 25995, 26477, 26478, 26479, 26359
9547, 25995, 26054, 26055, 25996, 26479, 26480, 26481, 26361
9548, 25996, 26055, 26056, 25997, 26481, 26482, 26483, 26363
9549, 25997, 26056, 26057, 25998, 26483, 26484, 26485, 26365
9550, 25998, 26057, 26058, 25999, 26485, 26486, 26487, 26367
9551, 25999, 26058, 26059, 26000, 26487, 26488, 26489, 26369
9552, 26000, 26059, 26060, 26001, 26489, 26490, 26491, 26371
9553, 26001, 26060, 26061, 26002, 26491, 26492, 26493, 26373
9554, 26002, 26061, 26062, 26003, 26493, 26494, 26495, 26375
9555, 26003, 26062, 26063, 26004, 26495, 26496, 26497, 26377
9556, 26004, 26063, 26064, 26005, 26497, 26498, 26499, 26379
9557, 26005, 26064, 26065, 26006, 26499, 26500, 26501, 26381
9558, 26006, 26065, 26066, 26007, 26501, 26502, 26503, 26383
9559, 26007, 26066, 26067, 26008, 26503, 26504, 26505, 26385
9560, 26008, 26067, 26068, 26009, 26505, 26506, 26507, 26387
9561, 26009, 26068, 26069, 26010, 26507, 26508, 26509, 26389
9562, 26010, 26069, 26070, 26011, 26509, 26510, 26511, 26391
9563, 26011, 26070, 26071, 26012, 26511, 26512, 26513, 26393
9564, 26012, 26071, 26072, 26013, 26513, 26514, 26515, 26395
9565, 26013, 26072, 26073, 26014, 26515, 26516, 26517, 26397
9566, 26014, 26073, 26074, 26015, 26517, 26518, 26519, 26399
9567, 26015, 26074, 26075, 26016, 26519, 26520, 26521, 26401
9568, 26016, 26075, 26076, 26017, 26521, 26522, 26523, 26403
9569, 26017, 26076, 26077, 26018, 26523, 26524, 26525, 26405
9570, 26018, 26077, 26078, 26019, 26525, 26526, 26527, 26407
9571, 26019, 26078, 26079, 26020, 26527, 26528, 26529, 26409
9572, 26020, 26079, 26080, 26021, 26529, 26530, 26531, 26411
9573, 26021, 26080, 26081, 26022, 26531, 26532, 26533, 26413
9574, 26022, 26081, 26082, 26023, 26533, 26534, 26535, 26415
9575, 26023, 26082, 26083, 26024, 26535, 26536, 26537, 26417
9576, 26024, 26083, 26084, 26025, 26537, 26538, 26539, 26419
9577, 26025, 26084, 26085, 26026, 26539, 26540, 26541, 26421
9578, 26026, 26085, 26086, 26027, 26541, 26542, 26543, 26423
9579, 26027, 26086, 26087, 26028, 26543, 26544, 26545, 26425
9580, 26028, 26087, 26088, 26029, 26545, 26546, 26547, 26427
9581, 26029, 26088, 26089, 26030, 26547, 26548, 26549, 26429
9582, 26030, 26089, 26090, 26031, 26549, 26550, 26551, 26431
9583, 26031, 26090, 26091, 26032, 26551, 26552, 26553, 26433
9584, 26032, 26091, 26092, 26033, 26553, 26554, 26555, 26435
9585, 26033, 26092, 26093, 26034, 26555, 26556, 26557, 26437
9586, 26034, 26093, 26094, 26035, 26557, 26558, 26559, 26439
9587, 26035, 26094, 26095, 26036, 26559, 26560, 26561, 26441
9588, 26036, 26095, 26096, 26037, 26561, 26562, 26563, 26443
9589, 26037, 26096, 26097, 26038, 26563, 26564, 26565, 26445
9590, 26038, 26097, 26098, 26039, 26565, 26566, 26567, 26447
9591, 26039, 26098, 26099, 26040, 26567, 26568, 26569, 26449
9592, 26040, 26099, 26100, 26041, 26569, 26570, 26571, 26451
9593, 26041, 26100, 26101, 26042, 26571, 26572, 26573, 26453
9594, 26042, 26101, 26102, 26043, 26573, 26574, 26575, 26455
9595, 26043, 26102, 26103, 26044, 26575, 26576, 26577, 26457
9596, 26044, 26103, 1640, 1639, 26577, 26578, 1645, 26459
9597, 1629, 1630, 26104, 26045, 1635, 26579, 26580, 26460
9598, 26045, 26104, 26105, 26046, 26580, 26581, 26582, 26462
9599, 26046, 26105, 26106, 26047, 26582, 26583, 26584, 26464
9600, 26047, 26106, 26107, 26048, 26584, 26585, 26586, 26466
9601, 26048, 26107, 26108, 26049, 26586, 26587, 26588, 26468
9602, 26049, 26108, 26109, 26050, 26588, 26589, 26590, 26470
9603, 26050, 26109, 26110, 26051, 26590, 26591, 26592, 26472
9604, 26051, 26110, 26111, 26052, 26592, 26593, 26594, 26474
9605, 26052, 26111, 26112, 26053, 26594, 26595, 26596, 26476
9606, 26053, 26112, 26113, 26054, 26596, 26597, 26598, 26478
9607, 26054, 26113, 26114, 26055, 26598, 26599, 26600, 26480
9608, 26055, 26114, 26115, 26056, 26600, 26601, 26602, 26482
9609, 26056, 26115, 26116, 26057, 26602, 26603, 26604, 26484
9610, 26057, 26116, 26117, 26058, 26604, 26605, 26606, 26486
9611, 26058, 26117, 26118, 26059, 26606, 26607, 26608, 26488
9612, 26059, 26118, 26119, 26060, 26608, 26609, 26610, 26490
9613, 26060, 26119, 26120, 26061, 26610, 26611, 26612, 26492
9614, 26061, 26120, 26121, 26062, 26612, 26613, 26614, 26494
9615, 26062, 26121, 26122, 26063, 26614, 26615, 26616, 26496
9616, 26063, 26122, 26123, 26064, 26616, 26617, 26618, 26498
9617, 26064, 26123, 26124, 26065, 26618, 26619, 26620, 26500
9618, 26065, 26124, 26125, 26066, 26620, 26621, 26622, 26502
9619, 26066, 26125, 26126, 26067, 26622, 26623, 26624, 26504
9620, 26067, 26126, 26127, 26068, 26624, 26625, 26626, 26506
9621, 26068, 26127, 26128, 26069, 26626, 26627, 26628, 26508
9622, 26069, 26128, 26129, 26070, 26628, 26629, 26630, 26510
9623, 26070, 26129, 26130, 26071, 26630, 26631, 26632, 26512
9624, 26071, 26130, 26131, 26072, 26632, 26633, 26634, 26514
9625, 26072, 26131, 26132, 26073, 26634, 26635, 26636, 26516
9626, 26073, 26132, 26133, 26074, 26636, 26637, 26638, 26518
9627, 26074, 26133, 26134, 26075, 26638, 26639, 26640, 26520
9628, 26075, 26134, 26135, 26076, 26640, 26641, 26642, 26522
9629, 26076, 26135, 26136, 26077, 26642, 26643, 26644, 26524
9630, 26077, 26136, 26137, 26078, 26644, 26645, 26646, 26526
9631, 26078, 26137, 26138, 26079, 26646, 26647, 26648, 26528
9632, 26079, 26138, 26139, 26080, 26648, 26649, 26650, 26530
9633, 26080, 26139, 26140, 26081, 26650, 26651, 26652, 26532
9634, 26081, 26140, 26141, 26082, 26652, 26653, 26654, 26534
9635, 26082, 26141, 26142, 26083, 26654, 26655, 26656, 26536
9636, 26083, 26142, 26143, 26084, 26656, 26657, 26658, 26538
9637, 26084, 26143, 26144, 26085, 26658, 26659, 26660, 26540
9638, 26085, 26144, 26145, 26086, 26660, 26661, 26662, 26542
9639, 26086, 26145, 26146, 26087, 26662, 26663, 26664, 26544
9640, 26087, 26146, 26147, 26088, 26664, 26665, 26666, 26546
9641, 26088, 26147, 26148, 26089, 26666, 26667, 26668, 26548
9642, 26089, 26148, 26149, 26090, 26668, 26669, 26670, 26550
9643, 26090, 26149, 26150, 26091, 26670, 26671, 26672, 26552
9644, 26091, 26150, 26151, 26092, 26672, 26673, 26674, 26554
9645, 26092, 26151, 26152, 26093, 26674, 26675, 26676, 26556
9646, 26093, 26152, 26153, 26094, 26676, 26677, 26678, 26558
9647, 26094, 26153, 26154, 26095, 26678, 26679, 26680, 26560
9648, 26095, 26154, 26155, 26096, 26680, 26681, 26682, 26562
9649, 26096, 26155, 26156, 26097, 26682, 26683, 26684, 26564
9650, 26097, 26156, 26157, 26098, 26684, 26685, 26686, 26566
9651, 26098, 26157, 26158, 26099, 26686, 26687, 26688, 26568
9652, 26099, 26158, 26159, 26100, 26688, 26689, 26690, 26570
9653, 26100, 26159, 26160, 26101, 26690, 26691, 26692, 26572
9654, 26101, 26160, 26161, 26102, 26692, 26693, 26694, 26574
9655, 26102, 26161, 26162, 26103, 26694, 26695, 26696, 26576
9656, 26103, 26162, 1641, 1640, 26696, 26697, 1646, 26578
9657, 1630, 1631, 26163, 26104, 1636, 26698, 26699, 26579
9658, 26104, 26163, 26164, 26105, 26699, 26700, 26701, 26581
9659, 26105, 26164, 26165, 26106, 26701, 26702, 26703, 26583
9660, 26106, 26165, 26166, 26107, 26703, 26704, 26705, 26585
9661, 26107, 26166, 26167, 26108, 26705, 26706, 26707, 26587
9662, 26108, 26167, 26168, 26109, 26707, 26708, 26709, 26589
9663, 26109, 26168, 26169, 26110, 26709, 26710, 26711, 26591
9664, 26110, 26169, 26170, 26111, 26711, 26712, 26713, 26593
9665, 26111, 26170, 26171, 26112, 26713, 26714, 26715, 26595
9666, 26112, 26171, 26172, 26113, 26715, 26716, 26717, 26597
9667, 26113, 26172, 26173, 26114, 26717, 26718, 26719, 26599
9668, 26114, 26173, 26174, 26115, 26719, 26720, 26721, 26601
9669, 26115, 26174, 26175, 26116, 26721, 26722, 26723, 26603
9670, 26116, 26175, 26176, 26117, 26723, 26724, 26725, 26605
9671, 26117, 26176, 26177, 26118, 26725, 26726, 26727, 26607
9672, 26118, 26177, 26178, 26119, 26727, 26728, 26729, 26609
9673, 26119, 26178, 26179, 26120, 26729, 26730, 26731, 26611
9674, 26120, 26179, 26180, 26121, 26731, 26732, 26733, 26613
9675, 26121, 26180, 26181, 26122, 26733, 26734, 26735, 26615
9676, 26122, 26181, 26182, 26123, 26735, 26736, 26737, 26617
9677, 26123, 26182, 26183, 26124, 26737, 26738, 26739, 26619
9678, 26124, 26183, 26184, 26125, 26739, 26740, 26741, 26621
9679, 26125, 26184, 26185, 26126, 26741, 26742, 26743, 26623
9680, 26126, 26185, 26186, 26127, 26743, 26744, 26745, 26625
9681, 26127, 26186, 26187, 26128, 26745, 26746, 26747, 26627
9682, 26128, 26187, 26188, 26129, 26747, 26748, 26749, 26629
9683, 26129, 26188, 26189, 26130, 26749, 26750, 26751, 26631
9684, 26130, 26189, 26190, 26131, 26751, 26752, 26753, 26633
9685, 26131, 26190, 26191, 26132, 26753, 26754, 26755, 26635
9686, 26132, 26191, 26192, 26133, 26755, 26756, 26757, 26637
9687, 26133, 26192, 26193, 26134, 26757, 26758, 26759, 26639
9688, 26134, 26193, 26194, 26135, 26759, 26760, 26761, 26641
9689, 26135, 26194, 26195, 26136, 26761, 26762, 26763, 26643
9690, 26136, 26195, 26196, 26137, 26763, 26764, 26765, 26645
9691, 26137, 26196, 26197, 26138, 26765, 26766, 26767, 26647
9692, 26138, 26197, 26198, 26139, 26767, 26768, 26769, 26649
9693, 26139, 26198, 26199, 26140, 26769, 26770, 26771, 26651
9694, 26140, 26199, 26200, 26141, 26771, 26772, 26773, 26653
9695, 26141, 26200, 26201, 26142, 26773, 26774, 26775, 26655
9696, 26142, 26201, 26202, 26143, 26775, 26776, 26777, 26657
9697, 26143, 26202, 26203, 26144, 26777, 26778, 26779, 26659
9698, 26144, 26203, 26204, 26145, 26779, 26780, 26781, 26661
9699, 26145, 26204, 26205, 26146, 26781, 26782, 26783, 26663
9700, 26146, 26205, 26206, 26147, 26783, 26784, 26785, 26665
9701, 26147, 26206, 26207, 26148, 26785, 26786, 26787, 26667
9702, 26148, 26207, 26208, 26149, 26787, 26788, 26789, 26669
9703, 26149, 26208, 26209, 26150, 26789, 26790, 26791, 26671
9704, 26150, 26209, 26210, 26151, 26791, 26792, 26793, 26673
9705, 26151, 26210, 26211, 26152, 26793, 26794, 26795, 26675
9706, 26152, 26211, 26212, 26153, 26795, 26796, 26797, 26677
9707, 26153, 26212, 26213, 26154, 26797, 26798, 26799, 26679
9708, 26154, 26213, 26214, 26155, 26799, 26800, 26801, 26681
9709, 26155, 26214, 26215, 26156, 26801, 26802, 26803, 26683
9710, 26156, 26215, 26216, 26157, 26803, 26804, 26805, 26685
9711, 26157, 26216, 26217, 26158, 26805, 26806, 26807, 26687
9712, 26158, 26217, 26218, 26159, 26807, 26808, 26809, 26689
9713, 26159, 26218, 26219, 26160, 26809, 26810, 26811, 26691
9714, 26160, 26219, 26220, 26161, 26811, 26812, 26813, 26693
9715, 26161, 26220, 26221, 26162, 26813, 26814, 26815, 26695
9716, 26162, 26221, 1642, 1641, 26815, 26816, 1647, 26697
9717, 1631, 14, 1149, 26163, 1637, 1208, 26817, 26698
9718, 26163, 1149, 1150, 26164, 26817, 1209, 26818, 26700
9719, 26164, 1150, 1151, 26165, 26818, 1210, 26819, 26702
9720, 26165, 1151, 1152, 26166, 26819, 1211, 26820, 26704
9721, 26166, 1152, 1153, 26167, 26820, 1212, 26821, 26706
9722, 26167, 1153, 1154, 26168, 26821, 1213, 26822, 26708
9723, 26168, 1154, 1155, 26169, 26822, 1214, 26823, 26710
9724, 26169, 1155, 1156, 26170, 26823, 1215, 26824, 26712
9725, 26170, 1156, 1157, 26171, 26824, 1216, 26825, 26714
9726, 26171, 1157, 1158, 26172, 26825, 1217, 26826, 26716
9727, 26172, 1158, 1159, 26173, 26826, 1218, 26827, 26718
9728, 26173, 1159, 1160, 26174, 26827, 1219, 26828, 26720
9729, 26174, 1160, 1161, 26175, 26828, 1220, 26829, 26722
9730, 26175, 1161, 1162, 26176, 26829, 1221, 26830, 26724
9731, 26176, 1162, 1163, 26177, 26830, 1222, 26831, 26726
9732, 26177, 1163, 1164, 26178, 26831, 1223, 26832, 26728
9733, 26178, 1164, 1165, 26179, 26832, 1224, 26833, 26730
9734, 26179, 1165, 1166, 26180, 26833, 1225, 26834, 26732
9735, 26180, 1166, 1167, 26181, 26834, 1226, 26835, 26734
9736, 26181, 1167, 1168, 26182, 26835, 1227, 26836, 26736
9737, 26182, 1168, 1169, 26183, 26836, 1228, 26837, 26738
9738, 26183, 1169, 1170, 26184, 26837, 1229, 26838, 26740
9739, 26184, 1170, 1171, 26185, 26838, 1230, 26839, 26742
9740, 26185, 1171, 1172, 26186, 26839, 1231, 26840, 26744
9741, 26186, 1172, 1173, 26187, 26840, 1232, 26841, 26746
9742, 26187, 1173, 1174, 26188, 26841, 1233, 26842, 26748
9743, 26188, 1174, 1175, 26189, 26842, 1234, 26843, 26750
9744, 26189, 1175, 1176, 26190, 26843, 1235, 26844, 26752
9745, 26190, 1176, 1177, 26191, 26844, 1236, 26845, 26754
9746, 26191, 1177, 1178, 26192, 26845, 1237, 26846, 26756
9747, 26192, 1178, 1179, 26193, 26846, 1238, 26847, 26758
9748, 26193, 1179, 1180, 26194, 26847, 1239, 26848, 26760
9749, 26194, 1180, 1181, 26195, 26848, 1240, 26849, 26762
9750, 26195, 1181, 1182, 26196, 26849, 1241, 26850, 26764
9751, 26196, 1182, 1183, 26197, 26850, 1242, 26851, 26766
9752, 26197, 1183, 1184, 26198, 26851, 1243, 26852, 26768
9753, 26198, 1184, 1185, 26199, 26852, 1244, 26853, 26770
9754, 26199, 1185, 1186, 26200, 26853, 1245, 26854, 26772
9755, 26200, 1186, 1187, 26201, 26854, 1246, 26855, 26774
9756, 26201, 1187, 1188, 26202, 26855, 1247, 26856, 26776
9757, 26202, 1188, 1189, 26203, 26856, 1248, 26857, 26778
9758, 26203, 1189, 1190, 26204, 26857, 1249, 26858, 26780
9759, 26204, 1190, 1191, 26205, 26858, 1250, 26859, 26782
9760, 26205, 1191, 1192, 26206, 26859, 1251, 26860, 26784
9761, 26206, 1192, 1193, 26207, 26860, 1252, 26861, 26786
9762, 26207, 1193, 1194, 26208, 26861, 1253, 26862, 26788
9763, 26208, 1194, 1195, 26209, 26862, 1254, 26863, 26790
9764, 26209, 1195, 1196, 26210, 26863, 1255, 26864, 26792
9765, 26210, 1196, 1197, 26211, 26864, 1256, 26865, 26794
9766, 26211, 1197, 1198, 26212, 26865, 1257, 26866, 26796
9767, 26212, 1198, 1199, 26213, 26866, 1258, 26867, 26798
9768, 26213, 1199, 1200, 26214, 26867, 1259, 26868, 26800
9769, 26214, 1200, 1201, 26215, 26868, 1260, 26869, 26802
9770, 26215, 1201, 1202, 26216, 26869, 1261, 26870, 26804
9771, 26216, 1202, 1203, 26217, 26870, 1262, 26871, 26806
9772, 26217, 1203, 1204, 26218, 26871, 1263, 26872, 26808
9773, 26218, 1204, 1205, 26219, 26872, 1264, 26873, 26810
9774, 26219, 1205, 1206, 26220, 26873, 1265, 26874, 26812
9775, 26220, 1206, 1207, 26221, 26874, 1266, 26875, 26814
9776, 26221, 1207, 15, 1642, 26875, 1267, 1648, 26816
*ELEMENT, type=CPS8, ELSET=Surface7
9777, 29, 1768, 26876, 1790, 1773, 27171, 27172, 1849
9778, 1790, 26876, 26877, 1791, 27172, 27173, 27174, 1850
9779, 1791, 26877, 26878, 1792, 27174, 27175, 27176, 1851
9780, 1792, 26878, 26879, 1793, 27176, 27177, 27178, 1852
9781, 1793, 26879, 26880, 1794, 27178, 27179, 27180, 1853
9782, 1794, 26880, 26881, 1795, 27180, 27181, 27182, 1854
9783, 1795, 26881, 26882, 1796, 27182, 27183, 27184, 1855
9784, 1796, 26882, 26883, 1797, 27184, 27185, 27186, 1856
9785, 1797, 26883, 26884, 1798, 27186, 27187, 27188, 1857
9786, 1798, 26884, 26885, 1799, 27188, 27189, 27190, 1858
9787, 1799, 26885, 26886, 1800, 27190, 27191, 27192, 1859
9788, 1800, 26886, 26887, 1801, 27192, 27193, 27194, 1860
9789, 1801, 26887, 26888, 1802, 27194, 27195, 27196, 1861
9790, 1802, 26888, 26889, 1803, 27196, 27197, 27198, 1862
9791, 1803, 26889, 26890, 1804, 27198, 27199, 27200, 1863
9792, 1804, 26890, 26891, 1805, 27200, 27201, 27202, 1864
9793, 1805, 26891, 26892, 1806, 27202, 27203, 27204, 1865
9794, 1806, 26892, 26893, 1807, 27204, 27205, 27206, 1866
9795, 1807, 26893, 26894, 1808, 27206, 27207, 27208, 1867
9796, 1808, 26894, 26895, 1809, 27208, 27209, 27210, 1868
9797, 1809, 26895, 26896, 1810, 27210, 27211, 27212, 1869
9798, 1810, 26896, 26897, 1811, 27212, 27213, 27214, 1870
9799, 1811, 26897, 26898, 1812, 27214, 27215, 27216, 1871
9800, 1812, 26898, 26899, 1813, 27216, 27217, 27218, 1872
9801, 1813, 26899, 26900, 1814, 27218, 27219, 27220, 1873
9802, 1814, 26900, 26901, 1815, 27220, 27221, 27222, 1874
9803, 1815, 26901, 26902, 1816, 27222, 27223, 27224, 1875
9804, 1816, 26902, 26903, 1817, 27224, 27225, 27226, 1876
9805, 1817, 26903, 26904, 1818, 27226, 27227, 27228, 1877
9806, 1818, 26904, 26905, 1819, 27228, 27229, 27230, 1878
9807, 1819, 26905, 26906, 1820, 27230, 27231, 27232, 1879
9808, 1820, 26906, 26907, 1821, 27232, 27233, 27234, 1880
9809, 1821, 26907, 26908, 1822, 27234, 27235, 27236, 1881
9810, 1822, 26908, 26909, 1823, 27236, 27237, 27238, 1882
9811, 1823, 26909, 26910, 1824, 27238, 27239, 27240, 1883
9812, 1824, 26910, 26911, 1825, 27240, 27241, 27242, 1884
9813, 1825, 26911, 26912, 1826, 27242, 27243, 27244, 1885
9814, 1826, 26912, 26913, 1827, 27244, 27245, 27246, 1886
9815, 1827, 26913, 26914, 1828, 27246, 27247, 27248, 1887
9816, 1828, 26914, 26915, 1829, 27248, 27249, 27250, 1888
9817, 1829, 26915, 26916, 1830, 27250, 27251, 27252, 1889
9818, 1830, 26916, 26917, 1831, 27252, 27253, 27254, 1890
9819, 1831, 26917, 26918, 1832, 27254, 27255, 27256, 1891
9820, 1832, 26918, 26919, 1833, 27256, 27257, 27258, 1892
9821, 1833, 26919, 26920, 1834, 27258, 27259, 27260, 1893
9822, 1834, 26920, 26921, 1835, 27260, 27261, 27262, 1894
9823, 1835, 26921, 26922, 1836, 27262, 27263, 27264, 1895
9824, 1836, 26922, 26923, 1837, 27264, 27265, 27266, 1896
9825, 1837, 26923, 26924, 1838, 27266, 27267, 27268, 1897
9826, 1838, 26924, 26925, 1839, 27268, 27269, 27270, 1898
9827, 1839, 26925, 26926, 1840, 27270, 27271, 27272, 1899
9828, 1840, 26926, 26927, 1841, 27272, 27273, 27274, 1900
9829, 1841, 26927, 26928, 1842, 27274, 27275, 27276, 1901
9830, 1842, 26928, 26929, 1843, 27276, 27277, 27278, 1902
9831, 1843, 26929, 26930, 1844, 27278, 27279, 27280, 1903
9832, 1844, 26930, 26931, 1845, 27280, 27281, 27282, 1904
9833, 1845, 26931, 26932, 1846, 27282, 27283, 27284, 1905
9834, 1846, 26932, 26933, 1847, 27284, 27285, 27286, 1906
9835, 1847, 26933, 26934, 1848, 27286, 27287, 27288, 1907
9836, 1848, 26934, 1779, 30, 27288, 27289, 1784, 1908
9837, 1768, 1769, 26935, 26876, 1774, 27290, 27291, 27171
9838, 26876, 26935, 26936, 26877, 27291, 27292, 27293, 27173
9839, 26877, 26936, 26937, 26878, 27293, 27294, 27295, 27175
9840, 26878, 26937, 26938, 26879, 27295, 27296, 27297, 27177
9841, 26879, 26938, 26939, 26880, 27297, 27298, 27299, 27179
9842, 26880, 26939, 26940, 26881, 27299, 27300, 27301, 27181
9843, 26881, 26940, 26941, 26882, 27301, 27302, 27303, 27183
9844, 26882, 26941, 26942, 26883, 27303, 27304, 27305, 27185
9845, 26883, 26942, 26943, 26884, 27305, 27306, 27307, 27187
9846, 26884, 26943, 26944, 26885, 27307, 27308, 27309, 27189
9847, 26885, 26944, 26945, 26886, 27309, 27310, 27311, 27191
9848, 26886, 26945, 26946, 26887, 27311, 27312, 27313, 27193
9849, 26887, 26946, 26947, 26888, 27313, 27314, 27315, 27195
9850, 26888, 26947, 26948, 26889, 27315, 27316, 27317, 27197
9851, 26889, 26948, 26949, 26890, 27317, 27318, 27319, 27199
9852, 26890, 26949, 26950, 26891, 27319, 27320, 27321, 27201
9853, 26891, 26950, 26951, 26892, 27321, 27322, 27323, 27203
9854, 26892, 26951, 26952, 26893, 27323, 27324, 27325, 27205
9855, 26893, 26952, 26953, 26894, 27325, 27326, 27327, 27207
9856, 26894, 26953, 26954, 26895, 27327, 27328, 27329, 27209
9857, 26895, 26954, 26955, 26896, 27329, 27330, 27331, 27211
9858, 26896, 26955, 26956, 26897, 27331, 27332, 27333, 27213
9859, 26897, 26956, 26957, 26898, 27333, 27334, 27335, 27215
9860, 26898, 26957, 26958, 26899, 27335, 27336, 27337, 27217
9861, 26899, 26958, 26959, 26900, 27337, 27338, 27339, 27219
9862, 26900, 26959, 26960, 26901, 27339, 27340, 27341, 27221
9863, 26901, 26960, 26961, 26902, 27341, 27342, 27343, 27223
9864, 26902, 26961, 26962, 26903, 27343, 27344, 27345, 27225
9865, 26903, 26962, 26963, 26904, 27345, 27346, 27347, 27227
9866, 26904, 26963, 26964, 26905, 27347, 27348, 27349, 27229
9867, 26905, 26964, 26965, 26906, 27349, 27350, 27351, 27231
9868, 26906, 26965, 26966, 26907, 27351, 27352, 27353, 27233
9869, 26907, 26966, 26967, 26908, 27353, 27354, 27355, 27235
9870, 26908, 26967, 26968, 26909, 27355, 27356, 27357, 27237
9871, 26909, 26968, 26969, 26910, 27357, 27358, 27359, 27239
9872, 26910, 26969, 26970, 26911, 27359, 27360, 27361, 27241
9873, 26911, 26970, 26971, 26912, 27361, 27362, 27363, 27243
9874, 26912, 26971, 26972, 26913, 27363, 27364, 27365, 27245
9875, 26913, 26972, 26973, 26914, 27365, 27366, 27367, 27247
9876, 26914, 26973, 26974, 26915, 27367, 27368, 27369, 27249
9877, 26915, 26974, 26975, 26916, 27369, 27370, 27371, 27251
9878, 26916, 26975, 26976, 26917, 27371, 27372, 27373, 27253
9879, 26917, 26976, 26977, 26918, 27373, 27374, 27375, 27255
9880, 26918, 26977, 26978, 26919, 27375, 27376, 27377, 27257
9881, 26919, 26978, 26979, 26920, 27377, 27378, 27379, 27259
9882, 26920, 26979, 26980, 26921, 27379, 27380, 27381, 27261
9883, 26921, 26980, 26981, 26922, 27381, 27382, 27383, 27263
9884, 26922, 26981, 26982, 26923, 27383, 27384, 27385, 27265
9885, 26923, 26982, 26983, 26924, 27385, 27386, 27387, 27267
9886, 26924, 26983, 26984, 26925, 27387, 27388, 27389, 27269
9887, 26925, 26984, 26985, 26926, 27389, 27390, 27391, 27271
9888, 26926, 26985, 26986, 26927, 27391, 27392, 27393, 27273
9889, 26927, 26986, 26987, 26928, 27393, 27394, 27395, 27275
9890, 26928, 26987, 26988, 26929, 27395, 27396, 27397, 27277
9891, 26929, 26988, 26989, 26930, 27397, 27398, 27399, 27279
9892, 26930, 26989, 26990, 26931, 27399, 27400, 27401, 27281
9893, 26931, 26990, 26991, 26932, 27401, 27402, 27403, 27283
9894, 26932, 26991, 26992, 26933, 27403, 27404, 27405, 27285
9895, 26933, 26992, 26993, 26934, 27405, 27406, 27407, 27287
9896, 26934, 26993, 1780, 1779, 27407, 27408, 1785, 27289
9897, 1769, 1770, 26994, 26935, 1775, 27409, 27410, 27290
9898, 26935, 26994, 26995, 26936, 27410, 27411, 27412, 27292
9899, 26936, 26995, 26996, 26937, 27412, 27413, 27414, 27294
9900, 26937, 26996, 26997, 26938, 27414, 27415, 27416, 27296
9901, 26938, 26997, 26998, 26939, 27416, 27417, 27418, 27298
9902, 26939, 26998, 26999, 26940, 27418, 27419, 27420, 27300
9903, 26940, 26999, 27000, 26941, 27420, 27421, 27422, 27302
9904, 26941, 27000, 27001, 26942, 27422, 27423, 27424, 27304
9905, 26942, 27001, 27002, 26943, 27424, 27425, 27426, 27306
9906, 26943, 27002, 27003, 26944, 27426, 27427, 27428, 27308
9907, 26944, 27003, 27004, 26945, 27428, 27429, 27430, 27310
9908, 26945, 27004, 27005, 26946, 27430, 27431, 27432, 27312
9909, 26946, 27005, 27006, 26947, 27432, 27433, 27434, 27314
9910, 26947, 27006, 27007, 26948, 27434, 27435, 27436, 27316
9911, 26948, 27007, 27008, 26949, 27436, 27437, 27438, 27318
9912, 26949, 27008, 27009, 26950, 27438, 27439, 27440, 27320
9913, 26950, 27009, 27010, 26951, 27440, 27441, 27442, 27322
9914, 26951, 27010, 27011, 26952, 27442, 27443, 27444, 27324
9915, 26952, 27011, 27012, 26953, 27444, 27445, 27446, 27326
9916, 26953, 27012, 27013, 26954, 27446, 27447, 27448, 27328
9917, 26954, 27013, 27014, 26955, 27448, 27449, 27450, 27330
9918, 26955, 27014, 27015, 26956, 27450, 27451, 27452, 27332
9919, 26956, 27015, 27016, 26957, 27452, 27453, 27454, 27334
9920, 26957, 27016, 27017, 26958, 27454, 27455, 27456, 27336
9921, 26958, 27017, 27018, 26959, 27456, 27457, 27458, 27338
9922, 26959, 27018, 27019, 26960, 27458, 27459, 27460, 27340
9923, 26960, 27019, 27020, 26961, 27460, 27461, 27462, 27342
9924, 26961, 27020, 27021, 26962, 27462, 27463, 27464, 27344
9925, 26962, 27021, 27022, 26963, 27464, 27465, 27466, 27346
9926, 26963, 27022, 27023, 26964, 27466, 27467, 27468, 27348
9927, 26964, 27023, 27024, 26965, 27468, 27469, 27470, 27350
9928, 26965, 27024, 27025, 26966, 27470, 27471, 27472, 27352
9929, 26966, 27025, 27026, 26967, 27472, 27473, 27474, 27354
9930, 26967, 27026, 27027, 26968, 27474, 27475, 27476, 27356
9931, 26968, 27027, 27028, 26969, 27476, 27477, 27478, 27358
9932, 26969, 27028, 27029, 26970, 27478, 27479, 27480, 27360
9933, 26970, 27029, 27030, 26971, 27480, 27481, 27482, 27362
9934, 26971, 27030, 27031, 26972, 27482, 27483, 27484, 27364
9935, 26972, 27031, 27032, 26973, 27484, 27485, 27486, 27366
9936, 26973, 27032, 27033, 26974, 27486, 27487, 27488, 27368
9937, 26974, 27033, 27034, 26975, 27488, 27489, 27490, 27370
9938, 26975, 27034, 27035, 26976, 27490, 27491, 27492, 27372
9939, 26976, 27035, 27036, 26977, 27492, 27493, 27494, 27374
9940, 26977, 27036, 27037, 26978, 27494, 27495, 27496, 27376
9941, 26978, 27037, 27038, 26979, 27496, 27497, 27498, 27378
9942, 26979, 27038, 27039, 26980, 27498, 27499, 27500, 27380
9943, 26980, 27039, 27040, 26981, 27500, 27501, 27502, 27382
9944, 26981, 27040, 27041, 26982, 27502, 27503, 27504, 27384
9945, 26982, 27041, 27042, 26983, 27504, 27505, 27506, 27386
9946, 26983, 27042, 27043, 26984, 27506, 27507, 27508, 27388
9947, 26984, 27043, 27044, 26985, 27508, 27509, 27510, 27390
9948, 26985, 27044, 27045, 26986, 27510, 27511, 27512, 27392
9949, 26986, 27045, 27046, 26987, 27512, 27513, 27514, 27394
9950, 26987, 27046, 27047, 26988, 27514, 27515, 27516, 27396
9951, 26988, 27047, 27048, 26989, 27516, 27517, 27518, 27398
9952, 26989, 27048, 27049, 26990, 27518, 27519, 27520, 27400
9953, 26990, 27049, 27050, 26991, 27520, 27521, 27522, 27402
9954, 26991, 27050, 27051, 26992, 27522, 27523, 27524, 27404
9955, 26992, 27051, 27052, 26993, 27524, 27525, 27526, 27406
9956, 26993, 27052, 1781, 1780, 27526, 27527, 1786, 27408
9957, 1770, 1771, 27053, 26994, 1776, 27528, 27529, 27409
9958, 26994, 27053, 27054, 26995, 27529, 27530, 27531, 27411
9959, 26995, 27054, 27055, 26996, 27531, 27532, 27533, 27413
9960, 26996, 27055, 27056, 26997, 27533, 27534, 27535, 27415
9961, 26997, 27056, 27057, 26998, 27535, 27536, 27537, 27417
9962, 26998, 27057, 27058, 26999, 27537, 27538, 27539, 27419
9963, 26999, 27058, 27059, 27000, 27539, 27540, 27541, 27421
9964, 27000, 27059, 27060, 27001, 27541, 27542, 27543, 27423
9965, 27001, 27060, 27061, 27002, 27543, 27544, 27545, 27425
9966, 27002, 27061, 27062, 27003, 27545, 27546, 27547, 27427
9967, 27003, 27062, 27063, 27004, 27547, 27548, 27549, 27429
9968, 27004, 27063, 27064, 27005, 27549, 27550, 27551, 27431
9969, 27005, 27064, 27065, 27006, 27551, 27552, 27553, 27433
9970, 27006, 27065, 27066, 27007, 27553, 27554, 27555, 27435
9971, 27007, 27066, 27067, 27008, 27555, 27556, 27557, 27437
9972, 27008, 27067, 27068, 27009, 27557, 27558, 27559, 27439
9973, 27009, 27068, 27069, 27010, 27559, 27560, 27561, 27441
9974, 27010, 27069, 27070, 27011, 27561, 27562, 27563, 27443
9975, 27011, 27070, 27071, 27012, 27563, 27564, 27565, 27445
9976, 27012, 27071, 27072, 27013, 27565, 27566, 27567, 27447
9977, 27013, 27072, 27073, 27014, 27567, 27568, 27569, 27449
9978, 27014, 27073, 27074, 27015, 27569, 27570, 27571, 27451
9979, 27015, 27074, 27075, 27016, 27571, 27572, 27573, 27453
9980, 27016, 27075, 27076, 27017, 27573, 27574, 27575, 27455
9981, 27017, 27076, 27077, 27018, 27575, 27576, 27577, 27457
9982, 27018, 27077, 27078, 27019, 27577, 27578, 27579, 27459
9983, 27019, 27078, 27079, 27020, 27579, 27580, 27581, 27461
9984, 27020, 27079, 27080, 27021, 27581, 27582, 27583, 27463
9985, 27021, 27080, 27081, 27022, 27583, 27584, 27585, 27465
9986, 27022, 27081, 27082, 27023, 27585, 27586, 27587, 27467
9987, 27023, 27082, 27083, 27024, 27587, 27588, 27589, 27469
9988, 27024, 27083, 27084, 27025, 27589, 27590, 27591, 27471
9989, 27025, 27084, 27085, 27026, 27591, 27592, 27593, 27473
9990, 27026, 27085, 27086, 27027, 27593, 27594, 27595, 27475
9991, 27027, 27086, 27087, 27028, 27595, 27596, 27597, 27477
9992, 27028, 27087, 27088, 27029, 27597, 27598, 27599, 27479
9993, 27029, 27088, 27089, 27030, 27599, 27600, 27601, 27481
9994, 27030, 27089, 27090, 27031, 27601, 27602, 27603, 27483
9995, 27031, 27090, 27091, 27032, 27603, 27604, 27605, 27485
9996, 27032, 27091, 27092, 27033, 27605, 27606, 27607, 27487
9997, 27033, 27092, 27093, 27034, 27607, 27608, 27609, 27489
9998, 27034, 27093, 27094, 27035, 27609, 27610, 27611, 27491
9999, 27035, 27094, 27095, 27036, 27611, 27612, 27613, 27493
10000, 27036, 27095, 27096, 27037, 27613, 27614, 27615, 27495
10001, 27037, 27096, 27097, 27038, 27615, 27616, 27617, 27497
10002, 27038, 27097, 27098, 27039, 27617, 27618, 27619, 27499
10003, 27039, 27098, 27099, 27040, 27619, 27620, 27621, 27501
10004, 27040, 27099, 27100, 27041, 27621, 27622, 27623, 27503
10005, 27041, 27100, 27101, 27042, 27623, 27624, 27625, 27505
10006, 27042, 27101, 27102, 27043, 27625, 27626, 27627, 27507
10007, 27043, 27102, 27103, 27044, 27627, 27628, 27629, 27509
10008, 27044, 27103, 27104, 27045, 27629, 27630, 27631, 27511
10009, 27045, 27104, 27105, 27046, 27631, 27632, 27633, 27513
10010, 27046, 27105, 27106, 27047, 27633, 27634, 27635, 27515
10011, 27047, 27106, 27107, 27048, 27635, 27636, 27637, 27517
10012, 27048, 27107, 27108, 27049, 27637, 27638, 27639, 27519
10013, 27049, 27108, 27109, 27050, 27639, 27640, 27641, 27521
10014, 27050, 27109, 27110, 27051, 27641, 27642, 27643, 27523
10015, 27051, 27110, 27111, 27052, 27643, 27644, 27645, 27525
10016, 27052, 27111, 1782, 1781, 27645, 27646, 1787, 27527
10017, 1771, 1772, 27112, 27053, 1777, 27647, 27648, 27528
10018, 27053, 27112, 27113, 27054, 27648, 27649, 27650, 27530
10019, 27054, 27113, 27114, 27055, 27650, 27651, 27652, 27532
10020, 27055, 27114, 27115, 27056, 27652, 27653, 27654, 27534
10021, 27056, 27115, 27116, 27057, 27654, 27655, 27656, 27536
10022, 27057, 27116, 27117, 27058, 27656, 27657, 27658, 27538
10023, 27058, 27117, 27118, 27059, 27658, 27659, 27660, 27540
10024, 27059, 27118, 27119, 27060, 27660, 27661, 27662, 27542
10025, 27060, 27119, 27120, 27061, 27662, 27663, 27664, 27544
10026, 27061, 27120, 27121, 27062, 27664, 27665, 27666, 27546
10027, 27062, 27121, 27122, 27063, 27666, 27667, 27668, 27548
10028, 27063, 27122, 27123, 27064, 27668, 27669, 27670, 27550
10029, 27064, 27123, 27124, 27065, 27670, 27671, 27672, 27552
10030, 27065, 27124, 27125, 27066, 27672, 27673, 27674, 27554
10031, 27066, 27125, 27126, 27067, 27674, 27675, 27676, 27556
10032, 27067, 27126, 27127, 27068, 27676, 27677, 27678, 27558
10033, 27068, 27127, 27128, 27069, 27678, 27679, 27680, 27560
10034, 27069, 27128, 27129, 27070, 27680, 27681, 27682, 27562
10035, 27070, 27129, 27130, 27071, 27682, 27683, 27684, 27564
10036, 27071, 27130, 27131, 27072, 27684, 27685, 27686, 27566
10037, 27072, 27131, 27132, 27073, 27686, 27687, 27688, 27568
10038, 27073, 27132, 27133, 27074, 27688, 27689, 27690, 27570
10039, 27074, 27133, 27134, 27075, 27690, 27691, 27692, 27572
10040, 27075, 27134, 27135, 27076, 27692, 27693, 27694, 27574
10041, 27076, 27135, 27136, 27077, 27694, 27695, 27696, 27576
10042, 27077, 27136, 27137, 27078, 27696, 27697, 27698, 27578
10043, 27078, 27137, 27138, 27079, 27698, 27699, 27700, 27580
10044, 27079, 27138, 27139, 27080, 27700, 27701, 27702, 27582
10045, 27080, 27139, 27140, 27081, 27702, 27703, 27704, 27584
10046, 27081, 27140, 27141, 27082, 27704, 27705, 27706, 27586
10047, 27082, 27141, 27142, 27083, 27706, 27707, 27708, 27588
10048, 27083, 27142, 27143, 27084, 27708, 27709, 27710, 27590
10049, 27084, 27143, 27144, 27085, 27710, 27711, 27712, 27592
10050, 27085, 27144, 27145, 27086, 27712, 27713, 27714, 27594
10051, 27086, 27145, 27146, 27087, 27714, 27715, 27716, 27596
10052, 27087, 27146, 27147, 27088, 27716, 27717, 27718, 27598
10053, 27088, 27147, 27148, 27089, 27718, 27719, 27720, 27600
10054, 27089, 27148, 27149, 27090, 27720, 27721, 27722, 27602
10055, 27090, 27149, 27150, 27091, 27722, 27723, 27724, 27604
10056, 27091, 27150, 27151, 27092, 27724, 27725, 27726, 27606
10057, 27092, 27151, 27152, 27093, 27726, 27727, 27728, 27608
10058, 27093, 27152, 27153, 27094, 27728, 27729, 27730, 27610
10059, 27094, 27153, 27154, 27095, 27730, 27731, 27732, 27612
10060, 27095, 27154, 27155, 27096, 27732, 27733, 27734, 27614
10061, 27096, 27155, 27156, 27097, 27734, 27735, 27736, 27616
10062, 27097, 27156, 27157, 27098, 27736, 27737, 27738, 27618
10063, 27098, 27157, 27158, 27099, 27738, 27739, 27740, 27620
10064, 27099, 27158, 27159, 27100, 27740, 27741, 27742, 27622
10065, 27100, 27159, 27160, 27101, 27742, 27743, 27744, 27624
10066, 27101, 27160, 27161, 27102, 27744, 27745, 27746, 27626
10067, 27102, 27161, 27162, 27103, 27746, 27747, 27748, 27628
10068, 27103, 27162, 27163, 27104, 27748, 27749, 27750, 27630
10069, 27104, 27163, 27164, 27105, 27750, 27751, 27752, 27632
10070, 27105, 27164, 27165, 27106, 27752, 27753, 27754, 27634
10071, 27106, 27165, 27166, 27107, 27754, 27755, 27756, 27636
10072, 27107, 27166, 27167, 27108, 27756, 27757, 27758, 27638
10073, 27108, 27167, 27168, 27109, 27758, 27759, 27760, 27640
10074, 27109, 27168, 27169, 27110, 27760, 27761, 27762, 27642
10075, 27110, 27169, 27170, 27111, 27762, 27763, 27764, 27644
10076, 27111, 27170, 1783, 1782, 27764, 27765, 1788, 27646
10077, 1772, 16, 1909, 27112, 1778, 1968, 27766, 27647
10078, 27112, 1909, 1910, 27113, 27766, 1969, 27767, 27649
10079, 27113, 1910, 1911, 27114, 27767, 1970, 27768, 27651
10080, 27114, 1911, 1912, 27115, 27768, 1971, 27769, 27653
10081, 27115, 1912, 1913, 27116, 27769, 1972, 27770, 27655
10082, 27116, 1913, 1914, 27117, 27770, 1973, 27771, 27657
10083, 27117, 1914, 1915, 27118, 27771, 1974, 27772, 27659
10084, 27118, 1915, 1916, 27119, 27772, 1975, 27773, 27661
10085, 27119, 1916, 1917, 27120, 27773, 1976, 27774, 27663
10086, 27120, 1917, 1918, 27121, 27774, 1977, 27775, 27665
10087, 27121, 1918, 1919, 27122, 27775, 1978, 27776, 27667
10088, 27122, 1919, 1920, 27123, 27776, 1979, 27777, 27669
10089, 27123, 1920, 1921, 27124, 27777, 1980, 27778, 27671
10090, 27124, 1921, 1922, 27125, 27778, 1981, 27779, 27673
10091, 27125, 1922, 1923, 27126, 27779, 1982, 27780, 27675
10092, 27126, 1923, 1924, 27127, 27780, 1983, 27781, 27677
10093, 27127, 1924, 1925, 27128, 27781, 1984, 27782, 27679
10094, 27128, 1925, 1926, 27129, 27782, 1985, 27783, 27681
10095, 27129, 1926, 1927, 27130, 27783, 1986, 27784, 27683
10096, 27130, 1927, 1928, 27131, 27784, 1987, 27785, 27685
10097, 27131, 1928, 1929, 27132, 27785, 1988, 27786, 27687
10098, 27132, 1929, 1930, 27133, 27786, 1989, 27787, 27689
10099, 27133, 1930, 1931, 27134, 27787, 1990, 27788, 27691
10100, 27134, 1931, 1932, 27135, 27788, 1991, 27789, 27693
10101, 27135, 1932, 1933, 27136, 27789, 1992, 27790, 27695
10102, 27136, 1933, 1934, 27137, 27790, 1993, 27791, 27697
10103, 27137, 1934, 1935, 27138, 27791, 1994, 27792, 27699
10104, 27138, 1935, 1936, 27139, 27792, 1995, 27793, 27701
10105, 27139, 1936, 1937, 27140, 27793, 1996, 27794, 27703
10106, 27140, 1937, 1938, 27141, 27794, 1997, 27795, 27705
10107, 27141, 1938, 1939, 27142, 27795, 1998, 27796, 27707
10108, 27142, 1939, 1940, 27143, 27796, 1999, 27797, 27709
10109, 27143, 1940, 1941, 27144, 27797, 2000, 27798, 27711
10110, 27144, 1941, 1942, 27145, 27798, 2001, 27799, 27713
10111, 27145, 1942, 1943, 27146, 27799, 2002, 27800, 27715
10112, 27146, 1943, 1944, 27147, 27800, 2003, 27801, 27717
10113, 27147, 1944, 1945, 27148, 27801, 2004, 27802, 27719
10114, 27148, 1945, 1946, 27149, 27802, 2005, 27803, 27721
10115, 27149, 1946, 1947, 27150, 27803, 2006, 27804, 27723
10116, 27150, 1947, 1948, 27151, 27804, 2007, 27805, 27725
10117, 27151, 1948, 1949, 27152, 27805, 2008, 27806, 27727
10118, 27152, 1949, 1950, 27153, 27806, 2009, 27807, 27729
10119, 27153, 1950, 1951, 27154, 27807, 2010, 27808, 27731
10120, 27154, 1951, 1952, 27155, 27808, 2011, 27809, 27733
10121, 27155, 1952, 1953, 27156, 27809, 2012, 27810, 27735
10122, 27156, 1953, 1954, 27157, 27810, 2013, 27811, 27737
10123, 27157, 1954, 1955, 27158, 27811, 2014, 27812, 27739
10124, 27158, 1955, 1956, 27159, 27812, 2015, 27813, 27741
10125, 27159, 1956, 1957, 27160, 27813, 2016, 27814, 27743
10126, 27160, 1957, 1958, 27161, 27814, 2017, 27815, 27745
10127, 27161, 1958, 1959, 27162, 27815, 2018, 27816, 27747
10128, 27162, 1959, 1960, 27163, 27816, 2019, 27817, 27749
10129, 27163, 1960, 1961, 27164, 27817, 2020, 27818, 27751
10130, 27164, 1961, 1962, 27165, 27818, 2021, 27819, 27753
10131, 27165, 1962, 1963, 27166, 27819, 2022, 27820, 27755
10132, 27166, 1963, 1964, 27167, 27820, 2023, 27821, 27757
10133, 27167, 1964, 1965, 27168, 27821, 2024, 27822, 27759
10134, 27168, 1965, 1966, 27169, 27822, 2025, 27823, 27761
10135, 27169, 1966, 1967, 27170, 27823, 2026, 27824, 27763
10136, 27170, 1967, 31, 1783, 27824, 2027, 1789, 27765
*ELEMENT, type=CPS8, ELSET=Surface9
10137, 29, 2028, 27825, 1768, 2030, 27835, 27836, 1773
10138, 1768, 27825, 27826, 1769, 27836, 27837, 27838, 1774
10139, 1769, 27826, 27827, 1770, 27838, 27839, 27840, 1775
10140, 1770, 27827, 27828, 1771, 27840, 27841, 27842, 1776
10141, 1771, 27828, 27829, 1772, 27842, 27843, 27844, 1777
10142, 1772, 27829, 1268, 16, 27844, 27845, 1270, 1778
10143, 2028, 2029, 27830, 27825, 2031, 27846, 27847, 27835
10144, 27825, 27830, 27831, 27826, 27847, 27848, 27849, 27837
10145, 27826, 27831, 27832, 27827, 27849, 27850, 27851, 27839
10146, 27827, 27832, 27833, 27828, 27851, 27852, 27853, 27841
10147, 27828, 27833, 27834, 27829, 27853, 27854, 27855, 27843
10148, 27829, 27834, 1269, 1268, 27855, 27856, 1271, 27845
10149, 2029, 32, 2033, 27830, 2032, 2038, 27857, 27846
10150, 27830, 2033, 2034, 27831, 27857, 2039, 27858, 27848
10151, 27831, 2034, 2035, 27832, 27858, 2040, 27859, 27850
10152, 27832, 2035, 2036, 27833, 27859, 2041, 27860, 27852
10153, 27833, 2036, 2037, 27834, 27860, 2042, 27861, 27854
10154, 27834, 2037, 17, 1269, 27861, 2043, 1272, 27856
*ELEMENT, type=CPS8, ELSET=Surface10
10155, 16, 1273, 27862, 1909, 1277, 28098, 28099, 1968
10156, 1909, 27862, 27863, 1910, 28099, 28100, 28101, 1969
10157, 1910, 27863, 27864, 1911, 28101, 28102, 28103, 1970
10158, 1911, 27864, 27865, 1912, 28103, 28104, 28105, 1971
10159, 1912, 27865, 27866, 1913, 28105, 28106, 28107, 1972
10160, 1913, 27866, 27867, 1914, 28107, 28108, 28109, 1973
10161, 1914, 27867, 27868, 1915, 28109, 28110, 28111, 1974
10162, 1915, 27868, 27869, 1916, 28111, 28112, 28113, 1975
10163, 1916, 27869, 27870, 1917, 28113, 28114, 28115, 1976
10164, 1917, 27870, 27871, 1918, 28115, 28116, 28117, 1977
10165, 1918, 27871, 27872, 1919, 28117, 28118, 28119, 1978
10166, 1919, 27872, 27873, 1920, 28119, 28120, 28121, 1979
10167, 1920, 27873, 27874, 1921, 28121, 28122, 28123, 1980
10168, 1921, 27874, 27875, 1922, 28123, 28124, 28125, 1981
10169, 1922, 27875, 27876, 1923, 28125, 28126, 28127, 1982
10170, 1923, 27876, 27877, 1924, 28127, 28128, 28129, 1983
10171, 1924, 27877, 27878, 1925, 28129, 28130, 28131, 1984
10172, 1925, 27878, 27879, 1926, 28131, 28132, 28133, 1985
10173, 1926, 27879, 27880, 1927, 28133, 28134, 28135, 1986
10174, 1927, 27880, 27881, 1928, 28135, 28136, 28137, 1987
10175, 1928, 27881, 27882, 1929, 28137, 28138, 28139, 1988
10176, 1929, 27882, 27883, 1930, 28139, 28140, 28141, 1989
10177, 1930, 27883, 27884, 1931, 28141, 28142, 28143, 1990
10178, 1931, 27884, 27885, 1932, 28143, 28144, 28145, 1991
10179, 1932, 27885, 27886, 1933, 28145, 28146, 28147, 1992
10180, 1933, 27886, 27887, 1934, 28147, 28148, 28149, 1993
10181, 1934, 27887, 27888, 1935, 28149, 28150, 28151, 1994
10182, 1935, 27888, 27889, 1936, 28151, 28152, 28153, 1995
10183, 1936, 27889, 27890, 1937, 28153, 28154, 28155, 1996
10184, 1937, 27890, 27891, 1938, 28155, 28156, 28157, 1997
10185, 1938, 27891, 27892, 1939, 28157, 28158, 28159, 1998
10186, 1939, 27892, 27893, 1940, 28159, 28160, 28161, 1999
10187, 1940, 27893, 27894, 1941, 28161, 28162, 28163, 2000
10188, 1941, 27894, 27895, 1942, 28163, 28164, 28165, 2001
10189, 1942, 27895, 27896, 1943, 28165, 28166, 28167, 2002
10190, 1943, 27896, 27897, 1944, 28167, 28168, 28169, 2003
10191, 1944, 27897, 27898, 1945, 28169, 28170, 28171, 2004
10192, 1945, 27898, 27899, 1946, 28171, 28172, 28173, 2005
10193, 1946, 27899, 27900, 1947, 28173, 28174, 28175, 2006
10194, 1947, 27900, 27901, 1948, 28175, 28176, 28177, 2007
10195, 1948, 27901, 27902, 1949, 28177, 28178, 28179, 2008
10196, 1949, 27902, 27903, 1950, 28179, 28180, 28181, 2009
10197, 1950, 27903, 27904, 1951, 28181, 28182, 28183, 2010
10198, 1951, 27904, 27905, 1952, 28183, 28184, 28185, 2011
10199, 1952, 27905, 27906, 1953, 28185, 28186, 28187, 2012
10200, 1953, 27906, 27907, 1954, 28187, 28188, 28189, 2013
10201, 1954, 27907, 27908, 1955, 28189, 28190, 28191, 2014
10202, 1955, 27908, 27909, 1956, 28191, 28192, 28193, 2015
10203, 1956, 27909, 27910, 1957, 28193, 28194, 28195, 2016
10204, 1957, 27910, 27911, 1958, 28195, 28196, 28197, 2017
10205, 1958, 27911, 27912, 1959, 28197, 28198, 28199, 2018
10206, 1959, 27912, 27913, 1960, 28199, 28200, 28201, 2019
10207, 1960, 27913, 27914, 1961, 28201, 28202, 28203, 2020
10208, 1961, 27914, 27915, 1962, 28203, 28204, 28205, 2021
10209, 1962, 27915, 27916, 1963, 28205, 28206, 28207, 2022
10210, 1963, 27916, 27917, 1964, 28207, 28208, 28209, 2023
10211, 1964, 27917, 27918, 1965, 28209, 28210, 28211, 2024
10212, 1965, 27918, 27919, 1966, 28211, 28212, 28213, 2025
10213, 1966, 27919, 27920, 1967, 28213, 28214, 28215, 2026
10214, 1967, 27920, 2044, 31, 28215, 28216, 2048, 2027
10215, 1273, 1274, 27921, 27862, 1278, 28217, 28218, 28098
10216, 27862, 27921, 27922, 27863, 28218, 28219, 28220, 28100
10217, 27863, 27922, 27923, 27864, 28220, 28221, 28222, 28102
10218, 27864, 27923, 27924, 27865, 28222, 28223, 28224, 28104
10219, 27865, 27924, 27925, 27866, 28224, 28225, 28226, 28106
10220, 27866, 27925, 27926, 27867, 28226, 28227, 28228, 28108
10221, 27867, 27926, 27927, 27868, 28228, 28229, 28230, 28110
10222, 27868, 27927, 27928, 27869, 28230, 28231, 28232, 28112
10223, 27869, 27928, 27929, 27870, 28232, 28233, 28234, 28114
10224, 27870, 27929, 27930, 27871, 28234, 28235, 28236, 28116
10225, 27871, 27930, 27931, 27872, 28236, 28237, 28238, 28118
10226, 27872, 27931, 27932, 27873, 28238, 28239, 28240, 28120
10227, 27873, 27932, 27933, 27874, 28240, 28241, 28242, 28122
10228, 27874, 27933, 27934, 27875, 28242, 28243, 28244, 28124
10229, 27875, 27934, 27935, 27876, 28244, 28245, 28246, 28126
10230, 27876, 27935, 27936, 27877, 28246, 28247, 28248, 28128
10231, 27877, 27936, 27937, 27878, 28248, 28249, 28250, 28130
10232, 27878, 27937, 27938, 27879, 28250, 28251, 28252, 28132
10233, 27879, 27938, 27939, 27880, 28252, 28253, 28254, 28134
10234, 27880, 27939, 27940, 27881, 28254, 28255, 28256, 28136
10235, 27881, 27940, 27941, 27882, 28256, 28257, 28258, 28138
10236, 27882, 27941, 27942, 27883, 28258, 28259, 28260, 28140
10237, 27883, 27942, 27943, 27884, 28260, 28261, 28262, 28142
10238, 27884, 27943, 27944, 27885, 28262, 28263, 28264, 28144
10239, 27885, 27944, 27945, 27886, 28264, 28265, 28266, 28146
10240, 27886, 27945, 27946, 27887, 28266, 28267, 28268, 28148
10241, 27887, 27946, 27947, 27888, 28268, 28269, 28270, 28150
10242, 27888, 27947, 27948, 27889, 28270, 28271, 28272, 28152
10243, 27889, 27948, 27949, 27890, 28272, 28273, 28274, 28154
10244, 27890, 27949, 27950, 27891, 28274, 28275, 28276, 28156
10245, 27891, 27950, 27951, 27892, 28276, 28277, 28278, 28158
10246, 27892, 27951, 27952, 27893, 28278, 28279, 28280, 28160
10247, 27893, 27952, 27953, 27894, 28280, 28281, 28282, 28162
10248, 27894, 27953, 27954, 27895, 28282, 28283, 28284, 28164
10249, 27895, 27954, 27955, 27896, 28284, 28285, 28286, 28166
10250, 27896, 27955, 27956, 27897, 28286, 28287, 28288, 28168
10251, 27897, 27956, 27957, 27898, 28288, 28289, 28290, 28170
10252, 27898, 27957, 27958, 27899, 28290, 28291, 28292, 28172
10253, 27899, 27958, 27959, 27900, 28292, 28293, 28294, 28174
10254, 27900, 27959, 27960, 27901, 28294, 28295, 28296, 28176
10255, 27901, 27960, 27961, 27902, 28296, 28297, 28298, 28178
10256, 27902, 27961, 27962, 27903, 28298, 28299, 28300, 28180
10257, 27903, 27962, 27963, 27904, 28300, 28301, 28302, 28182
10258, 27904, 27963, 27964, 27905, 28302, 28303, 28304, 28184
10259, 27905, 27964, 27965, 27906, 28304, 28305, 28306, 28186
10260, 27906, 27965, 27966, 27907, 28306, 28307, 28308, 28188
10261, 27907, 27966, 27967, 27908, 28308, 28309, 28310, 28190
10262, 27908, 27967, 27968, 27909, 28310, 28311, 28312, 28192
10263, 27909, 27968, 27969, 27910, 28312, 28313, 28314, 28194
10264, 27910, 27969, 27970, 27911, 28314, 28315, 28316, 28196
10265, 27911, 27970, 27971, 27912, 28316, 28317, 28318, 28198
10266, 27912, 27971, 27972, 27913, 28318, 28319, 28320, 28200
10267, 27913, 27972, 27973, 27914, 28320, 28321, 28322, 28202
10268, 27914, 27973, 27974, 27915, 28322, 28323, 28324, 28204
10269, 27915, 27974, 27975, 27916, 28324, 28325, 28326, 28206
10270, 27916, 27975, 27976, 27917, 28326, 28327, 28328, 28208
10271, 27917, 27976, 27977, 27918, 28328, 28329, 28330, 28210
10272, 27918, 27977, 27978, 27919, 28330, 28331, 28332, 28212
10273, 27919, 27978, 27979, 27920, 28332, 28333, 28334, 28214
10274, 27920, 27979, 2045, 2044, 28334, 28335, 2049, 28216
10275, 1274, 1275, 27980, 27921, 1279, 28336, 28337, 28217
10276, 27921, 27980, 27981, 27922, 28337, 28338, 28339, 28219
10277, 27922, 27981, 27982, 27923, 28339, 28340, 28341, 28221
10278, 27923, 27982, 27983, 27924, 28341, 28342, 28343, 28223
10279, 27924, 27983, 27984, 27925, 28343, 28344, 28345, 28225
10280, 27925, 27984, 27985, 27926, 28345, 28346, 28347, 28227
10281, 27926, 27985, 27986, 27927, 28347, 28348, 28349, 28229
10282, 27927, 27986, 27987, 27928, 28349, 28350, 28351, 28231
10283, 27928, 27987, 27988, 27929, 28351, 28352, 28353, 28233
10284, 27929, 27988, 27989, 27930, 28353, 28354, 28355, 28235
10285, 27930, 27989, 27990, 27931, 28355, 28356, 28357, 28237
10286, 27931, 27990, 27991, 27932, 28357, 28358, 28359, 28239
10287, 27932, 27991, 27992, 27933, 28359, 28360, 28361, 28241
10288, 27933, 27992, 27993, 27934, 28361, 28362, 28363, 28243
10289, 27934, 27993, 27994, 27935, 28363, 28364, 28365, 28245
10290, 27935, 27994, 27995, 27936, 28365, 28366, 28367, 28247
10291, 27936, 27995, 27996, 27937, 28367, 28368, 28369, 28249
10292, 27937, 27996, 27997, 27938, 28369, 28370, 28371, 28251
10293, 27938, 27997, 27998, 27939, 28371, 28372, 28373, 28253
10294, 27939, 27998, 27999, 27940, 28373, 28374, 28375, 28255
10295, 27940, 27999, 28000, 27941, 28375, 28376, 28377, 28257
10296, 27941, 28000, 28001, 27942, 28377, 28378, 28379, 28259
10297, 27942, 28001, 28002, 27943, 28379, 28380, 28381, 28261
10298, 27943, 28002, 28003, 27944, 28381, 28382, 28383, 28263
10299, 27944, 28003, 28004, 27945, 28383, 28384, 28385, 28265
10300, 27945, 28004, 28005, 27946, 28385, 28386, 28387, 28267
10301, 27946, 28005, 28006, 27947, 28387, 28388, 28389, 28269
10302, 27947, 28006, 28007, 27948, 28389, 28390, 28391, 28271
10303, 27948, 28007, 28008, 27949, 28391, 28392, 28393, 28273
10304, 27949, 28008, 28009, 27950, 28393, 28394, 28395, 28275
10305, 27950, 28009, 28010, 27951, 28395, 28396, 28397, 28277
10306, 27951, 28010, 28011, 27952, 28397, 28398, 28399, 28279
10307, 27952, 28011, 28012, 27953, 28399, 28400, 28401, 28281
10308, 27953, 28012, 28013, 27954, 28401, 28402, 28403, 28283
10309, 27954, 28013, 28014, 27955, 28403, 28404, 28405, 28285
10310, 27955, 28014, 28015, 27956, 28405, 28406, 28407, 28287
10311, 27956, 28015, 28016, 27957, 28407, 28408, 28409, 28289
10312, 27957, 28016, 28017, 27958, 28409, 28410, 28411, 28291
10313, 27958, 28017, 28018, 27959, 28411, 28412, 28413, 28293
10314, 27959, 28018, 28019, 27960, 28413, 28414, 28415, 28295
10315, 27960, 28019, 28020, 27961, 28415, 28416, 28417, 28297
10316, 27961, 28020, 28021, 27962, 28417, 28418, 28419, 28299
10317, 27962, 28021, 28022, 27963, 28419, 28420, 28421, 28301
10318, 27963, 28022, 28023, 27964, 28421, 28422, 28423, 28303
10319, 27964, 28023, 28024, 27965, 28423, 28424, 28425, 28305
10320, 27965, 28024, 28025, 27966, 28425, 28426, 28427, 28307
10321, 27966, 28025, 28026, 27967, 28427, 28428, 28429, 28309
10322, 27967, 28026, 28027, 27968, 28429, 28430, 28431, 28311
10323, 27968, 28027, 28028, 27969, 28431, 28432, 28433, 28313
10324, 27969, 28028, 28029, 27970, 28433, 28434, 28435, 28315
10325, 27970, 28029, 28030, 27971, 28435, 28436, 28437, 28317
10326, 27971, 28030, 28031, 27972, 28437, 28438, 28439, 28319
10327, 27972, 28031, 28032, 27973, 28439, 28440, 28441, 28321
10328, 27973, 28032, 28033, 27974, 28441, 28442, 28443, 28323
10329, 27974, 28033, 28034, 27975, 28443, 28444, 28445, 28325
10330, 27975, 28034, 28035, 27976, 28445, 28446, 28447, 28327
10331, 27976, 28035, 28036, 27977, 28447, 28448, 28449, 28329
10332, 27977, 28036, 28037, 27978, 28449, 28450, 28451, 28331
10333, 27978, 28037, 28038, 27979, 28451, 28452, 28453, 28333
10334, 27979, 28038, 2046, 2045, 28453, 28454, 2050, 28335
10335, 1275, 1276, 28039, 27980, 1280, 28455, 28456, 28336
10336, 27980, 28039, 28040, 27981, 28456, 28457, 28458, 28338
10337, 27981, 28040, 28041, 27982, 28458, 28459, 28460, 28340
10338, 27982, 28041, 28042, 27983, 28460, 28461, 28462, 28342
10339, 27983, 28042, 28043, 27984, 28462, 28463, 28464, 28344
10340, 27984, 28043, 28044, 27985, 28464, 28465, 28466, 28346
10341, 27985, 28044, 28045, 27986, 28466, 28467, 28468, 28348
10342, 27986, 28045, 28046, 27987, 28468, 28469, 28470, 28350
10343, 27987, 28046, 28047, 27988, 28470, 28471, 28472, 28352
10344, 27988, 28047, 28048, 27989, 28472, 28473, 28474, 28354
10345, 27989, 28048, 28049, 27990, 28474, 28475, 28476, 28356
10346, 27990, 28049, 28050, 27991, 28476, 28477, 28478, 28358
10347, 27991, 28050, 28051, 27992, 28478, 28479, 28480, 28360
10348, 27992, 28051, 28052, 27993, 28480, 28481, 28482, 28362
10349, 27993, 28052, 28053, 27994, 28482, 28483, 28484, 28364
10350, 27994, 28053, 28054, 27995, 28484, 28485, 28486, 28366
10351, 27995, 28054, 28055, 27996, 28486, 28487, 28488, 28368
10352, 27996, 28055, 28056, 27997, 28488, 28489, 28490, 28370
10353, 27997, 28056, 28057, 27998, 28490, 28491, 28492, 28372
10354, 27998, 28057, 28058, 27999, 28492, 28493, 28494, 28374
10355, 27999, 28058, 28059, 28000, 28494, 28495, 28496, 28376
10356, 28000, 28059, 28060, 28001, 28496, 28497, 28498, 28378
10357, 28001, 28060, 28061, 28002, 28498, 28499, 28500, 28380
10358, 28002, 28061, 28062, 28003, 28500, 28501, 28502, 28382
10359, 28003, 28062, 28063, 28004, 28502, 28503, 28504, 28384
10360, 28004, 28063, 28064, 28005, 28504, 28505, 28506, 28386
10361, 28005, 28064, 28065, 28006, 28506, 28507, 28508, 28388
10362, 28006, 28065, 28066, 28007, 28508, 28509, 28510, 28390
10363, 28007, 28066, 28067, 28008, 28510, 28511, 28512, 28392
10364, 28008, 28067, 28068, 28009, 28512, 28513, 28514, 28394
10365, 28009, 28068, 28069, 28010, 28514, 28515, 28516, 28396
10366, 28010, 28069, 28070, 28011, 28516, 28517, 28518, 28398
10367, 28011, 28070, 28071, 28012, 28518, 28519, 28520, 28400
10368, 28012, 28071, 28072, 28013, 28520, 28521, 28522, 28402
10369, 28013, 28072, 28073, 28014, 28522, 28523, 28524, 28404
10370, 28014, 28073, 28074, 28015, 28524, 28525, 28526, 28406
10371, 28015, 28074, 28075, 28016, 28526, 28527, 28528, 28408
10372, 28016, 28075, 28076, 28017, 28528, 28529, 28530, 28410
10373, 28017, 28076, 28077, 28018, 28530, 28531, 28532, 28412
10374, 28018, 28077, 28078, 28019, 28532, 28533, 28534, 28414
10375, 28019, 28078, 28079, 28020, 28534, 28535, 28536, 28416
10376, 28020, 28079, 28080, 28021, 28536, 28537, 28538, 28418
10377, 28021, 28080, 28081, 28022, 28538, 28539, 28540, 28420
10378, 28022, 28081, 28082, 28023, 28540, 28541, 28542, 28422
10379, 28023, 28082, 28083, 28024, 28542, 28543, 28544, 28424
10380, 28024, 28083, 28084, 28025, 28544, 28545, 28546, 28426
10381, 28025, 28084, 28085, 28026, 28546, 28547, 28548, 28428
10382, 28026, 28085, 28086, 28027, 28548, 28549, 28550, 28430
10383, 28027, 28086, 28087, 28028, 28550, 28551, 28552, 28432
10384, 28028, 28087, 28088, 28029, 28552, 28553, 28554, 28434
10385, 28029, 28088, 28089, 28030, 28554, 28555, 28556, 28436
10386, 28030, 28089, 28090, 28031, 28556, 28557, 28558, 28438
10387, 28031, 28090, 28091, 28032, 28558, 28559, 28560, 28440
10388, 28032, 28091, 28092, 28033, 28560, 28561, 28562, 28442
10389, 28033, 28092, 28093, 28034, 28562, 28563, 28564, 28444
10390, 28034, 28093, 28094, 28035, 28564, 28565, 28566, 28446
10391, 28035, 28094, 28095, 28036, 28566, 28567, 28568, 28448
10392, 28036, 28095, 28096, 28037, 28568, 28569, 28570, 28450
10393, 28037, 28096, 28097, 28038, 28570, 28571, 28572, 28452
10394, 28038, 28097, 2047, 2046, 28572, 28573, 2051, 28454
10395, 1276, 18, 2053, 28039, 1281, 2112, 28574, 28455
10396, 28039, 2053, 2054, 28040, 28574, 2113, 28575, 28457
10397, 28040, 2054, 2055, 28041, 28575, 2114, 28576, 28459
10398, 28041, 2055, 2056, 28042, 28576, 2115, 28577, 28461
10399, 28042, 2056, 2057, 28043, 28577, 2116, 28578, 28463
10400, 28043, 2057, 2058, 28044, 28578, 2117, 28579, 28465
10401, 28044, 2058, 2059, 28045, 28579, 2118, 28580, 28467
10402, 28045, 2059, 2060, 28046, 28580, 2119, 28581, 28469
10403, 28046, 2060, 2061, 28047, 28581, 2120, 28582, 28471
10404, 28047, 2061, 2062, 28048, 28582, 2121, 28583, 28473
10405, 28048, 2062, 2063, 28049, 28583, 2122, 28584, 28475
10406, 28049, 2063, 2064, 28050, 28584, 2123, 28585, 28477
10407, 28050, 2064, 2065, 28051, 28585, 2124, 28586, 28479
10408, 28051, 2065, 2066, 28052, 28586, 2125, 28587, 28481
10409, 28052, 2066, 2067, 28053, 28587, 2126, 28588, 28483
10410, 28053, 2067, 2068, 28054, 28588, 2127, 28589, 28485
10411, 28054, 2068, 2069, 28055, 28589, 2128, 28590, 28487
10412, 28055, 2069, 2070, 28056, 28590, 2129, 28591, 28489
10413, 28056, 2070, 2071, 28057, 28591, 2130, 28592, 28491
10414, 28057, 2071, 2072, 28058, 28592, 2131, 28593, 28493
