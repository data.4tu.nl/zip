14174, 0.55833333333333, 1.3333333333333, 0
14175, 0.55, 1.325, 0
14176, 0.54166666666667, 1.3333333333333, 0
14177, 0.53333333333333, 1.325, 0
14178, 0.525, 1.3333333333333, 0
14179, 0.51666666666667, 1.325, 0
14180, 0.50833333333333, 1.3333333333333, 0
14181, 0.5, 1.325, 0
14182, 0.49166666666667, 1.3333333333333, 0
14183, 0.48333333333333, 1.325, 0
14184, 0.475, 1.3333333333333, 0
14185, 0.46666666666667, 1.325, 0
14186, 0.45833333333333, 1.3333333333333, 0
14187, 0.45, 1.325, 0
14188, 0.44166666666667, 1.3333333333333, 0
14189, 0.43333333333333, 1.325, 0
14190, 0.425, 1.3333333333333, 0
14191, 0.41666666666667, 1.325, 0
14192, 0.40833333333333, 1.3333333333333, 0
14193, 0.4, 1.325, 0
14194, 0.39166666666667, 1.3333333333333, 0
14195, 0.38333333333333, 1.325, 0
14196, 0.375, 1.3333333333333, 0
14197, 0.36666666666667, 1.325, 0
14198, 0.35833333333333, 1.3333333333333, 0
14199, 0.35, 1.325, 0
14200, 0.34166666666667, 1.3333333333333, 0
14201, 0.33333333333333, 1.325, 0
14202, 0.325, 1.3333333333333, 0
14203, 0.31666666666667, 1.325, 0
14204, 0.30833333333333, 1.3333333333333, 0
14205, 0.3, 1.325, 0
14206, 0.29166666666667, 1.3333333333333, 0
14207, 0.28333333333333, 1.325, 0
14208, 0.275, 1.3333333333333, 0
14209, 0.26666666666667, 1.325, 0
14210, 0.25833333333333, 1.3333333333333, 0
14211, 0.25, 1.325, 0
14212, 0.24166666666667, 1.3333333333333, 0
14213, 0.23333333333333, 1.325, 0
14214, 0.225, 1.3333333333333, 0
14215, 0.21666666666667, 1.325, 0
14216, 0.20833333333333, 1.3333333333333, 0
14217, 0.2, 1.325, 0
14218, 0.19166666666667, 1.3333333333333, 0
14219, 0.18333333333333, 1.325, 0
14220, 0.175, 1.3333333333333, 0
14221, 0.16666666666667, 1.325, 0
14222, 0.15833333333333, 1.3333333333333, 0
14223, 0.15, 1.325, 0
14224, 0.14166666666667, 1.3333333333333, 0
14225, 0.13333333333333, 1.325, 0
14226, 0.125, 1.3333333333333, 0
14227, 0.11666666666667, 1.325, 0
14228, 0.10833333333333, 1.3333333333333, 0
14229, 0.1, 1.325, 0
14230, 0.091666666666667, 1.3333333333333, 0
14231, 0.083333333333333, 1.325, 0
14232, 0.075, 1.3333333333333, 0
14233, 0.066666666666667, 1.325, 0
14234, 0.058333333333333, 1.3333333333333, 0
14235, 0.05, 1.325, 0
14236, 0.041666666666667, 1.3333333333333, 0
14237, 0.033333333333333, 1.325, 0
14238, 0.025, 1.3333333333333, 0
14239, 0.016666666666667, 1.325, 0
14240, 0.0083333333333333, 1.3333333333333, 0
14241, 0.98333333333333, 1.3416666666667, 0
14242, 0.96666666666667, 1.3416666666667, 0
14243, 0.95, 1.3416666666667, 0
14244, 0.93333333333333, 1.3416666666667, 0
14245, 0.91666666666667, 1.3416666666667, 0
14246, 0.9, 1.3416666666667, 0
14247, 0.88333333333333, 1.3416666666667, 0
14248, 0.86666666666667, 1.3416666666667, 0
14249, 0.85, 1.3416666666667, 0
14250, 0.83333333333333, 1.3416666666667, 0
14251, 0.81666666666667, 1.3416666666667, 0
14252, 0.8, 1.3416666666667, 0
14253, 0.78333333333333, 1.3416666666667, 0
14254, 0.76666666666667, 1.3416666666667, 0
14255, 0.75, 1.3416666666667, 0
14256, 0.73333333333333, 1.3416666666667, 0
14257, 0.71666666666667, 1.3416666666667, 0
14258, 0.7, 1.3416666666667, 0
14259, 0.68333333333333, 1.3416666666667, 0
14260, 0.66666666666667, 1.3416666666667, 0
14261, 0.65, 1.3416666666667, 0
14262, 0.63333333333333, 1.3416666666667, 0
14263, 0.61666666666667, 1.3416666666667, 0
14264, 0.6, 1.3416666666667, 0
14265, 0.58333333333333, 1.3416666666667, 0
14266, 0.56666666666667, 1.3416666666667, 0
14267, 0.55, 1.3416666666667, 0
14268, 0.53333333333333, 1.3416666666667, 0
14269, 0.51666666666667, 1.3416666666667, 0
14270, 0.5, 1.3416666666667, 0
14271, 0.48333333333333, 1.3416666666667, 0
14272, 0.46666666666667, 1.3416666666667, 0
14273, 0.45, 1.3416666666667, 0
14274, 0.43333333333333, 1.3416666666667, 0
14275, 0.41666666666667, 1.3416666666667, 0
14276, 0.4, 1.3416666666667, 0
14277, 0.38333333333333, 1.3416666666667, 0
14278, 0.36666666666667, 1.3416666666667, 0
14279, 0.35, 1.3416666666667, 0
14280, 0.33333333333333, 1.3416666666667, 0
14281, 0.31666666666667, 1.3416666666667, 0
14282, 0.3, 1.3416666666667, 0
14283, 0.28333333333333, 1.3416666666667, 0
14284, 0.26666666666667, 1.3416666666667, 0
14285, 0.25, 1.3416666666667, 0
14286, 0.23333333333333, 1.3416666666667, 0
14287, 0.21666666666667, 1.3416666666667, 0
14288, 0.2, 1.3416666666667, 0
14289, 0.18333333333333, 1.3416666666667, 0
14290, 0.16666666666667, 1.3416666666667, 0
14291, 0.15, 1.3416666666667, 0
14292, 0.13333333333333, 1.3416666666667, 0
14293, 0.11666666666667, 1.3416666666667, 0
14294, 0.1, 1.3416666666667, 0
14295, 0.083333333333333, 1.3416666666667, 0
14296, 0.066666666666667, 1.3416666666667, 0
14297, 0.05, 1.3416666666667, 0
14298, 0.033333333333333, 1.3416666666667, 0
14299, 0.016666666666667, 1.3416666666667, 0
14300, 1.025, 1.2666666666667, 0
14301, 1.025, 1.2833333333333, 0
14302, 1.025, 1.3, 0
14303, 1.025, 1.3166666666667, 0
14304, 1.025, 1.3333333333333, 0
14305, 1.05, 1.2666666666667, 0
14306, 1.05, 1.2833333333333, 0
14307, 1.05, 1.3, 0
14308, 1.05, 1.3166666666667, 0
14309, 1.05, 1.3333333333333, 0
14310, 1.075, 1.2666666666667, 0
14311, 1.075, 1.2833333333333, 0
14312, 1.075, 1.3, 0
14313, 1.075, 1.3166666666667, 0
14314, 1.075, 1.3333333333333, 0
14315, 1.1, 1.2666666666667, 0
14316, 1.1, 1.2833333333333, 0
14317, 1.1, 1.3, 0
14318, 1.1, 1.3166666666667, 0
14319, 1.1, 1.3333333333333, 0
14320, 1.125, 1.2666666666667, 0
14321, 1.125, 1.2833333333333, 0
14322, 1.125, 1.3, 0
14323, 1.125, 1.3166666666667, 0
14324, 1.125, 1.3333333333333, 0
14325, 1.15, 1.2666666666667, 0
14326, 1.15, 1.2833333333333, 0
14327, 1.15, 1.3, 0
14328, 1.15, 1.3166666666667, 0
14329, 1.15, 1.3333333333333, 0
14330, 1.175, 1.2666666666667, 0
14331, 1.175, 1.2833333333333, 0
14332, 1.175, 1.3, 0
14333, 1.175, 1.3166666666667, 0
14334, 1.175, 1.3333333333333, 0
14335, 1.025, 1.2583333333333, 0
14336, 1.0125, 1.2666666666667, 0
14337, 1.025, 1.275, 0
14338, 1.0125, 1.2833333333333, 0
14339, 1.025, 1.2916666666667, 0
14340, 1.0125, 1.3, 0
14341, 1.025, 1.3083333333333, 0
14342, 1.0125, 1.3166666666667, 0
14343, 1.025, 1.325, 0
14344, 1.0125, 1.3333333333333, 0
14345, 1.025, 1.3416666666667, 0
14346, 1.05, 1.2583333333333, 0
14347, 1.0375, 1.2666666666667, 0
14348, 1.05, 1.275, 0
14349, 1.0375, 1.2833333333333, 0
14350, 1.05, 1.2916666666667, 0
14351, 1.0375, 1.3, 0
14352, 1.05, 1.3083333333333, 0
14353, 1.0375, 1.3166666666667, 0
14354, 1.05, 1.325, 0
14355, 1.0375, 1.3333333333333, 0
14356, 1.05, 1.3416666666667, 0
14357, 1.075, 1.2583333333333, 0
14358, 1.0625, 1.2666666666667, 0
14359, 1.075, 1.275, 0
14360, 1.0625, 1.2833333333333, 0
14361, 1.075, 1.2916666666667, 0
14362, 1.0625, 1.3, 0
14363, 1.075, 1.3083333333333, 0
14364, 1.0625, 1.3166666666667, 0
14365, 1.075, 1.325, 0
14366, 1.0625, 1.3333333333333, 0
14367, 1.075, 1.3416666666667, 0
14368, 1.1, 1.2583333333333, 0
14369, 1.0875, 1.2666666666667, 0
14370, 1.1, 1.275, 0
14371, 1.0875, 1.2833333333333, 0
14372, 1.1, 1.2916666666667, 0
14373, 1.0875, 1.3, 0
14374, 1.1, 1.3083333333333, 0
14375, 1.0875, 1.3166666666667, 0
14376, 1.1, 1.325, 0
14377, 1.0875, 1.3333333333333, 0
14378, 1.1, 1.3416666666667, 0
14379, 1.125, 1.2583333333333, 0
14380, 1.1125, 1.2666666666667, 0
14381, 1.125, 1.275, 0
14382, 1.1125, 1.2833333333333, 0
14383, 1.125, 1.2916666666667, 0
14384, 1.1125, 1.3, 0
14385, 1.125, 1.3083333333333, 0
14386, 1.1125, 1.3166666666667, 0
14387, 1.125, 1.325, 0
14388, 1.1125, 1.3333333333333, 0
14389, 1.125, 1.3416666666667, 0
14390, 1.15, 1.2583333333333, 0
14391, 1.1375, 1.2666666666667, 0
14392, 1.15, 1.275, 0
14393, 1.1375, 1.2833333333333, 0
14394, 1.15, 1.2916666666667, 0
14395, 1.1375, 1.3, 0
14396, 1.15, 1.3083333333333, 0
14397, 1.1375, 1.3166666666667, 0
14398, 1.15, 1.325, 0
14399, 1.1375, 1.3333333333333, 0
14400, 1.15, 1.3416666666667, 0
14401, 1.175, 1.2583333333333, 0
14402, 1.1625, 1.2666666666667, 0
14403, 1.175, 1.275, 0
14404, 1.1625, 1.2833333333333, 0
14405, 1.175, 1.2916666666667, 0
14406, 1.1625, 1.3, 0
14407, 1.175, 1.3083333333333, 0
14408, 1.1625, 1.3166666666667, 0
14409, 1.175, 1.325, 0
14410, 1.1625, 1.3333333333333, 0
14411, 1.175, 1.3416666666667, 0
14412, 1.1875, 1.2666666666667, 0
14413, 1.1875, 1.2833333333333, 0
14414, 1.1875, 1.3, 0
14415, 1.1875, 1.3166666666667, 0
14416, 1.1875, 1.3333333333333, 0
14417, 1.2166666666667, 1.2666666666667, 0
14418, 1.2166666666667, 1.2833333333333, 0
14419, 1.2166666666667, 1.3, 0
14420, 1.2166666666667, 1.3166666666667, 0
14421, 1.2166666666667, 1.3333333333333, 0
14422, 1.2333333333333, 1.2666666666667, 0
14423, 1.2333333333333, 1.2833333333333, 0
14424, 1.2333333333333, 1.3, 0
14425, 1.2333333333333, 1.3166666666667, 0
14426, 1.2333333333333, 1.3333333333333, 0
14427, 1.25, 1.2666666666667, 0
14428, 1.25, 1.2833333333333, 0
14429, 1.25, 1.3, 0
14430, 1.25, 1.3166666666667, 0
14431, 1.25, 1.3333333333333, 0
14432, 1.2666666666667, 1.2666666666667, 0
14433, 1.2666666666667, 1.2833333333333, 0
14434, 1.2666666666667, 1.3, 0
14435, 1.2666666666667, 1.3166666666667, 0
14436, 1.2666666666667, 1.3333333333333, 0
14437, 1.2833333333333, 1.2666666666667, 0
14438, 1.2833333333333, 1.2833333333333, 0
14439, 1.2833333333333, 1.3, 0
14440, 1.2833333333333, 1.3166666666667, 0
14441, 1.2833333333333, 1.3333333333333, 0
14442, 1.3, 1.2666666666667, 0
14443, 1.3, 1.2833333333333, 0
14444, 1.3, 1.3, 0
14445, 1.3, 1.3166666666667, 0
14446, 1.3, 1.3333333333333, 0
14447, 1.3166666666667, 1.2666666666667, 0
14448, 1.3166666666667, 1.2833333333333, 0
14449, 1.3166666666667, 1.3, 0
14450, 1.3166666666667, 1.3166666666667, 0
14451, 1.3166666666667, 1.3333333333333, 0
14452, 1.3333333333333, 1.2666666666667, 0
14453, 1.3333333333333, 1.2833333333333, 0
14454, 1.3333333333333, 1.3, 0
14455, 1.3333333333333, 1.3166666666667, 0
14456, 1.3333333333333, 1.3333333333333, 0
14457, 1.35, 1.2666666666667, 0
14458, 1.35, 1.2833333333333, 0
14459, 1.35, 1.3, 0
14460, 1.35, 1.3166666666667, 0
14461, 1.35, 1.3333333333333, 0
14462, 1.3666666666667, 1.2666666666667, 0
14463, 1.3666666666667, 1.2833333333333, 0
14464, 1.3666666666667, 1.3, 0
14465, 1.3666666666667, 1.3166666666667, 0
14466, 1.3666666666667, 1.3333333333333, 0
14467, 1.3833333333333, 1.2666666666667, 0
14468, 1.3833333333333, 1.2833333333333, 0
14469, 1.3833333333333, 1.3, 0
14470, 1.3833333333333, 1.3166666666667, 0
14471, 1.3833333333333, 1.3333333333333, 0
14472, 1.4, 1.2666666666667, 0
14473, 1.4, 1.2833333333333, 0
14474, 1.4, 1.3, 0
14475, 1.4, 1.3166666666667, 0
14476, 1.4, 1.3333333333333, 0
14477, 1.4166666666667, 1.2666666666667, 0
14478, 1.4166666666667, 1.2833333333333, 0
14479, 1.4166666666667, 1.3, 0
14480, 1.4166666666667, 1.3166666666667, 0
14481, 1.4166666666667, 1.3333333333333, 0
14482, 1.4333333333333, 1.2666666666667, 0
14483, 1.4333333333333, 1.2833333333333, 0
14484, 1.4333333333333, 1.3, 0
14485, 1.4333333333333, 1.3166666666667, 0
14486, 1.4333333333333, 1.3333333333333, 0
14487, 1.45, 1.2666666666667, 0
14488, 1.45, 1.2833333333333, 0
14489, 1.45, 1.3, 0
14490, 1.45, 1.3166666666667, 0
14491, 1.45, 1.3333333333333, 0
14492, 1.4666666666667, 1.2666666666667, 0
14493, 1.4666666666667, 1.2833333333333, 0
14494, 1.4666666666667, 1.3, 0
14495, 1.4666666666667, 1.3166666666667, 0
14496, 1.4666666666667, 1.3333333333333, 0
14497, 1.4833333333333, 1.2666666666667, 0
14498, 1.4833333333333, 1.2833333333333, 0
14499, 1.4833333333333, 1.3, 0
14500, 1.4833333333333, 1.3166666666667, 0
14501, 1.4833333333333, 1.3333333333333, 0
14502, 1.5, 1.2666666666667, 0
14503, 1.5, 1.2833333333333, 0
14504, 1.5, 1.3, 0
14505, 1.5, 1.3166666666667, 0
14506, 1.5, 1.3333333333333, 0
14507, 1.5166666666667, 1.2666666666667, 0
14508, 1.5166666666667, 1.2833333333333, 0
14509, 1.5166666666667, 1.3, 0
14510, 1.5166666666667, 1.3166666666667, 0
14511, 1.5166666666667, 1.3333333333333, 0
14512, 1.5333333333333, 1.2666666666667, 0
14513, 1.5333333333333, 1.2833333333333, 0
14514, 1.5333333333333, 1.3, 0
14515, 1.5333333333333, 1.3166666666667, 0
14516, 1.5333333333333, 1.3333333333333, 0
14517, 1.55, 1.2666666666667, 0
14518, 1.55, 1.2833333333333, 0
14519, 1.55, 1.3, 0
14520, 1.55, 1.3166666666667, 0
14521, 1.55, 1.3333333333333, 0
14522, 1.5666666666667, 1.2666666666667, 0
14523, 1.5666666666667, 1.2833333333333, 0
14524, 1.5666666666667, 1.3, 0
14525, 1.5666666666667, 1.3166666666667, 0
14526, 1.5666666666667, 1.3333333333333, 0
14527, 1.5833333333333, 1.2666666666667, 0
14528, 1.5833333333333, 1.2833333333333, 0
14529, 1.5833333333333, 1.3, 0
14530, 1.5833333333333, 1.3166666666667, 0
14531, 1.5833333333333, 1.3333333333333, 0
14532, 1.6, 1.2666666666667, 0
14533, 1.6, 1.2833333333333, 0
14534, 1.6, 1.3, 0
14535, 1.6, 1.3166666666667, 0
14536, 1.6, 1.3333333333333, 0
14537, 1.6166666666667, 1.2666666666667, 0
14538, 1.6166666666667, 1.2833333333333, 0
14539, 1.6166666666667, 1.3, 0
14540, 1.6166666666667, 1.3166666666667, 0
14541, 1.6166666666667, 1.3333333333333, 0
14542, 1.6333333333333, 1.2666666666667, 0
14543, 1.6333333333333, 1.2833333333333, 0
14544, 1.6333333333333, 1.3, 0
14545, 1.6333333333333, 1.3166666666667, 0
14546, 1.6333333333333, 1.3333333333333, 0
14547, 1.65, 1.2666666666667, 0
14548, 1.65, 1.2833333333333, 0
14549, 1.65, 1.3, 0
14550, 1.65, 1.3166666666667, 0
14551, 1.65, 1.3333333333333, 0
14552, 1.6666666666667, 1.2666666666667, 0
14553, 1.6666666666667, 1.2833333333333, 0
14554, 1.6666666666667, 1.3, 0
14555, 1.6666666666667, 1.3166666666667, 0
14556, 1.6666666666667, 1.3333333333333, 0
14557, 1.6833333333333, 1.2666666666667, 0
14558, 1.6833333333333, 1.2833333333333, 0
14559, 1.6833333333333, 1.3, 0
14560, 1.6833333333333, 1.3166666666667, 0
14561, 1.6833333333333, 1.3333333333333, 0
14562, 1.7, 1.2666666666667, 0
14563, 1.7, 1.2833333333333, 0
14564, 1.7, 1.3, 0
14565, 1.7, 1.3166666666667, 0
14566, 1.7, 1.3333333333333, 0
14567, 1.7166666666667, 1.2666666666667, 0
14568, 1.7166666666667, 1.2833333333333, 0
14569, 1.7166666666667, 1.3, 0
14570, 1.7166666666667, 1.3166666666667, 0
14571, 1.7166666666667, 1.3333333333333, 0
14572, 1.7333333333333, 1.2666666666667, 0
14573, 1.7333333333333, 1.2833333333333, 0
14574, 1.7333333333333, 1.3, 0
14575, 1.7333333333333, 1.3166666666667, 0
14576, 1.7333333333333, 1.3333333333333, 0
14577, 1.75, 1.2666666666667, 0
14578, 1.75, 1.2833333333333, 0
14579, 1.75, 1.3, 0
14580, 1.75, 1.3166666666667, 0
14581, 1.75, 1.3333333333333, 0
14582, 1.7666666666667, 1.2666666666667, 0
14583, 1.7666666666667, 1.2833333333333, 0
14584, 1.7666666666667, 1.3, 0
14585, 1.7666666666667, 1.3166666666667, 0
14586, 1.7666666666667, 1.3333333333333, 0
14587, 1.7833333333333, 1.2666666666667, 0
14588, 1.7833333333333, 1.2833333333333, 0
14589, 1.7833333333333, 1.3, 0
14590, 1.7833333333333, 1.3166666666667, 0
14591, 1.7833333333333, 1.3333333333333, 0
14592, 1.8, 1.2666666666667, 0
14593, 1.8, 1.2833333333333, 0
14594, 1.8, 1.3, 0
14595, 1.8, 1.3166666666667, 0
14596, 1.8, 1.3333333333333, 0
14597, 1.8166666666667, 1.2666666666667, 0
14598, 1.8166666666667, 1.2833333333333, 0
14599, 1.8166666666667, 1.3, 0
14600, 1.8166666666667, 1.3166666666667, 0
14601, 1.8166666666667, 1.3333333333333, 0
14602, 1.8333333333333, 1.2666666666667, 0
14603, 1.8333333333333, 1.2833333333333, 0
14604, 1.8333333333333, 1.3, 0
14605, 1.8333333333333, 1.3166666666667, 0
14606, 1.8333333333333, 1.3333333333333, 0
14607, 1.85, 1.2666666666667, 0
14608, 1.85, 1.2833333333333, 0
14609, 1.85, 1.3, 0
14610, 1.85, 1.3166666666667, 0
14611, 1.85, 1.3333333333333, 0
14612, 1.8666666666667, 1.2666666666667, 0
14613, 1.8666666666667, 1.2833333333333, 0
14614, 1.8666666666667, 1.3, 0
14615, 1.8666666666667, 1.3166666666667, 0
14616, 1.8666666666667, 1.3333333333333, 0
14617, 1.8833333333333, 1.2666666666667, 0
14618, 1.8833333333333, 1.2833333333333, 0
14619, 1.8833333333333, 1.3, 0
14620, 1.8833333333333, 1.3166666666667, 0
14621, 1.8833333333333, 1.3333333333333, 0
14622, 1.9, 1.2666666666667, 0
14623, 1.9, 1.2833333333333, 0
14624, 1.9, 1.3, 0
14625, 1.9, 1.3166666666667, 0
14626, 1.9, 1.3333333333333, 0
14627, 1.9166666666667, 1.2666666666667, 0
14628, 1.9166666666667, 1.2833333333333, 0
14629, 1.9166666666667, 1.3, 0
14630, 1.9166666666667, 1.3166666666667, 0
14631, 1.9166666666667, 1.3333333333333, 0
14632, 1.9333333333333, 1.2666666666667, 0
14633, 1.9333333333333, 1.2833333333333, 0
14634, 1.9333333333333, 1.3, 0
14635, 1.9333333333333, 1.3166666666667, 0
14636, 1.9333333333333, 1.3333333333333, 0
14637, 1.95, 1.2666666666667, 0
14638, 1.95, 1.2833333333333, 0
14639, 1.95, 1.3, 0
14640, 1.95, 1.3166666666667, 0
14641, 1.95, 1.3333333333333, 0
14642, 1.9666666666667, 1.2666666666667, 0
14643, 1.9666666666667, 1.2833333333333, 0
14644, 1.9666666666667, 1.3, 0
14645, 1.9666666666667, 1.3166666666667, 0
14646, 1.9666666666667, 1.3333333333333, 0
14647, 1.9833333333333, 1.2666666666667, 0
14648, 1.9833333333333, 1.2833333333333, 0
14649, 1.9833333333333, 1.3, 0
14650, 1.9833333333333, 1.3166666666667, 0
14651, 1.9833333333333, 1.3333333333333, 0
14652, 2, 1.2666666666667, 0
14653, 2, 1.2833333333333, 0
14654, 2, 1.3, 0
14655, 2, 1.3166666666667, 0
14656, 2, 1.3333333333333, 0
14657, 2.0166666666667, 1.2666666666667, 0
14658, 2.0166666666667, 1.2833333333333, 0
14659, 2.0166666666667, 1.3, 0
14660, 2.0166666666667, 1.3166666666667, 0
14661, 2.0166666666667, 1.3333333333333, 0
14662, 2.0333333333333, 1.2666666666667, 0
14663, 2.0333333333333, 1.2833333333333, 0
14664, 2.0333333333333, 1.3, 0
14665, 2.0333333333333, 1.3166666666667, 0
14666, 2.0333333333333, 1.3333333333333, 0
14667, 2.05, 1.2666666666667, 0
14668, 2.05, 1.2833333333333, 0
14669, 2.05, 1.3, 0
14670, 2.05, 1.3166666666667, 0
14671, 2.05, 1.3333333333333, 0
14672, 2.0666666666667, 1.2666666666667, 0
14673, 2.0666666666667, 1.2833333333333, 0
14674, 2.0666666666667, 1.3, 0
14675, 2.0666666666667, 1.3166666666667, 0
14676, 2.0666666666667, 1.3333333333333, 0
14677, 2.0833333333333, 1.2666666666667, 0
14678, 2.0833333333333, 1.2833333333333, 0
14679, 2.0833333333333, 1.3, 0
14680, 2.0833333333333, 1.3166666666667, 0
14681, 2.0833333333333, 1.3333333333333, 0
14682, 2.1, 1.2666666666667, 0
14683, 2.1, 1.2833333333333, 0
14684, 2.1, 1.3, 0
14685, 2.1, 1.3166666666667, 0
14686, 2.1, 1.3333333333333, 0
14687, 2.1166666666667, 1.2666666666667, 0
14688, 2.1166666666667, 1.2833333333333, 0
14689, 2.1166666666667, 1.3, 0
14690, 2.1166666666667, 1.3166666666667, 0
14691, 2.1166666666667, 1.3333333333333, 0
14692, 2.1333333333333, 1.2666666666667, 0
14693, 2.1333333333333, 1.2833333333333, 0
14694, 2.1333333333333, 1.3, 0
14695, 2.1333333333333, 1.3166666666667, 0
14696, 2.1333333333333, 1.3333333333333, 0
14697, 2.15, 1.2666666666667, 0
14698, 2.15, 1.2833333333333, 0
14699, 2.15, 1.3, 0
14700, 2.15, 1.3166666666667, 0
14701, 2.15, 1.3333333333333, 0
14702, 2.1666666666667, 1.2666666666667, 0
14703, 2.1666666666667, 1.2833333333333, 0
14704, 2.1666666666667, 1.3, 0
14705, 2.1666666666667, 1.3166666666667, 0
14706, 2.1666666666667, 1.3333333333333, 0
14707, 2.1833333333333, 1.2666666666667, 0
14708, 2.1833333333333, 1.2833333333333, 0
14709, 2.1833333333333, 1.3, 0
14710, 2.1833333333333, 1.3166666666667, 0
14711, 2.1833333333333, 1.3333333333333, 0
14712, 1.2166666666667, 1.2583333333333, 0
14713, 1.2083333333333, 1.2666666666667, 0
14714, 1.2166666666667, 1.275, 0
14715, 1.2083333333333, 1.2833333333333, 0
14716, 1.2166666666667, 1.2916666666667, 0
14717, 1.2083333333333, 1.3, 0
14718, 1.2166666666667, 1.3083333333333, 0
14719, 1.2083333333333, 1.3166666666667, 0
14720, 1.2166666666667, 1.325, 0
14721, 1.2083333333333, 1.3333333333333, 0
14722, 1.2166666666667, 1.3416666666667, 0
14723, 1.2333333333333, 1.2583333333333, 0
14724, 1.225, 1.2666666666667, 0
14725, 1.2333333333333, 1.275, 0
14726, 1.225, 1.2833333333333, 0
14727, 1.2333333333333, 1.2916666666667, 0
14728, 1.225, 1.3, 0
14729, 1.2333333333333, 1.3083333333333, 0
14730, 1.225, 1.3166666666667, 0
14731, 1.2333333333333, 1.325, 0
14732, 1.225, 1.3333333333333, 0
14733, 1.2333333333333, 1.3416666666667, 0
14734, 1.25, 1.2583333333333, 0
14735, 1.2416666666667, 1.2666666666667, 0
14736, 1.25, 1.275, 0
14737, 1.2416666666667, 1.2833333333333, 0
14738, 1.25, 1.2916666666667, 0
14739, 1.2416666666667, 1.3, 0
14740, 1.25, 1.3083333333333, 0
14741, 1.2416666666667, 1.3166666666667, 0
14742, 1.25, 1.325, 0
14743, 1.2416666666667, 1.3333333333333, 0
14744, 1.25, 1.3416666666667, 0
14745, 1.2666666666667, 1.2583333333333, 0
14746, 1.2583333333333, 1.2666666666667, 0
14747, 1.2666666666667, 1.275, 0
14748, 1.2583333333333, 1.2833333333333, 0
14749, 1.2666666666667, 1.2916666666667, 0
14750, 1.2583333333333, 1.3, 0
14751, 1.2666666666667, 1.3083333333333, 0
14752, 1.2583333333333, 1.3166666666667, 0
14753, 1.2666666666667, 1.325, 0
14754, 1.2583333333333, 1.3333333333333, 0
14755, 1.2666666666667, 1.3416666666667, 0
14756, 1.2833333333333, 1.2583333333333, 0
14757, 1.275, 1.2666666666667, 0
14758, 1.2833333333333, 1.275, 0
14759, 1.275, 1.2833333333333, 0
14760, 1.2833333333333, 1.2916666666667, 0
14761, 1.275, 1.3, 0
14762, 1.2833333333333, 1.3083333333333, 0
14763, 1.275, 1.3166666666667, 0
14764, 1.2833333333333, 1.325, 0
14765, 1.275, 1.3333333333333, 0
14766, 1.2833333333333, 1.3416666666667, 0
14767, 1.3, 1.2583333333333, 0
14768, 1.2916666666667, 1.2666666666667, 0
14769, 1.3, 1.275, 0
14770, 1.2916666666667, 1.2833333333333, 0
14771, 1.3, 1.2916666666667, 0
14772, 1.2916666666667, 1.3, 0
14773, 1.3, 1.3083333333333, 0
14774, 1.2916666666667, 1.3166666666667, 0
14775, 1.3, 1.325, 0
14776, 1.2916666666667, 1.3333333333333, 0
14777, 1.3, 1.3416666666667, 0
14778, 1.3166666666667, 1.2583333333333, 0
14779, 1.3083333333333, 1.2666666666667, 0
14780, 1.3166666666667, 1.275, 0
14781, 1.3083333333333, 1.2833333333333, 0
14782, 1.3166666666667, 1.2916666666667, 0
14783, 1.3083333333333, 1.3, 0
14784, 1.3166666666667, 1.3083333333333, 0
14785, 1.3083333333333, 1.3166666666667, 0
14786, 1.3166666666667, 1.325, 0
14787, 1.3083333333333, 1.3333333333333, 0
14788, 1.3166666666667, 1.3416666666667, 0
14789, 1.3333333333333, 1.2583333333333, 0
14790, 1.325, 1.2666666666667, 0
14791, 1.3333333333333, 1.275, 0
14792, 1.325, 1.2833333333333, 0
14793, 1.3333333333333, 1.2916666666667, 0
14794, 1.325, 1.3, 0
14795, 1.3333333333333, 1.3083333333333, 0
14796, 1.325, 1.3166666666667, 0
14797, 1.3333333333333, 1.325, 0
14798, 1.325, 1.3333333333333, 0
14799, 1.3333333333333, 1.3416666666667, 0
14800, 1.35, 1.2583333333333, 0
14801, 1.3416666666667, 1.2666666666667, 0
14802, 1.35, 1.275, 0
14803, 1.3416666666667, 1.2833333333333, 0
14804, 1.35, 1.2916666666667, 0
14805, 1.3416666666667, 1.3, 0
14806, 1.35, 1.3083333333333, 0
14807, 1.3416666666667, 1.3166666666667, 0
14808, 1.35, 1.325, 0
14809, 1.3416666666667, 1.3333333333333, 0
14810, 1.35, 1.3416666666667, 0
14811, 1.3666666666667, 1.2583333333333, 0
14812, 1.3583333333333, 1.2666666666667, 0
14813, 1.3666666666667, 1.275, 0
14814, 1.3583333333333, 1.2833333333333, 0
14815, 1.3666666666667, 1.2916666666667, 0
14816, 1.3583333333333, 1.3, 0
14817, 1.3666666666667, 1.3083333333333, 0
14818, 1.3583333333333, 1.3166666666667, 0
14819, 1.3666666666667, 1.325, 0
14820, 1.3583333333333, 1.3333333333333, 0
14821, 1.3666666666667, 1.3416666666667, 0
14822, 1.3833333333333, 1.2583333333333, 0
14823, 1.375, 1.2666666666667, 0
14824, 1.3833333333333, 1.275, 0
14825, 1.375, 1.2833333333333, 0
14826, 1.3833333333333, 1.2916666666667, 0
14827, 1.375, 1.3, 0
14828, 1.3833333333333, 1.3083333333333, 0
14829, 1.375, 1.3166666666667, 0
14830, 1.3833333333333, 1.325, 0
14831, 1.375, 1.3333333333333, 0
14832, 1.3833333333333, 1.3416666666667, 0
14833, 1.4, 1.2583333333333, 0
14834, 1.3916666666667, 1.2666666666667, 0
14835, 1.4, 1.275, 0
14836, 1.3916666666667, 1.2833333333333, 0
14837, 1.4, 1.2916666666667, 0
14838, 1.3916666666667, 1.3, 0
14839, 1.4, 1.3083333333333, 0
14840, 1.3916666666667, 1.3166666666667, 0
14841, 1.4, 1.325, 0
14842, 1.3916666666667, 1.3333333333333, 0
14843, 1.4, 1.3416666666667, 0
14844, 1.4166666666667, 1.2583333333333, 0
14845, 1.4083333333333, 1.2666666666667, 0
14846, 1.4166666666667, 1.275, 0
14847, 1.4083333333333, 1.2833333333333, 0
14848, 1.4166666666667, 1.2916666666667, 0
14849, 1.4083333333333, 1.3, 0
14850, 1.4166666666667, 1.3083333333333, 0
14851, 1.4083333333333, 1.3166666666667, 0
14852, 1.4166666666667, 1.325, 0
14853, 1.4083333333333, 1.3333333333333, 0
14854, 1.4166666666667, 1.3416666666667, 0
14855, 1.4333333333333, 1.2583333333333, 0
14856, 1.425, 1.2666666666667, 0
14857, 1.4333333333333, 1.275, 0
14858, 1.425, 1.2833333333333, 0
14859, 1.4333333333333, 1.2916666666667, 0
14860, 1.425, 1.3, 0
14861, 1.4333333333333, 1.3083333333333, 0
14862, 1.425, 1.3166666666667, 0
14863, 1.4333333333333, 1.325, 0
14864, 1.425, 1.3333333333333, 0
14865, 1.4333333333333, 1.3416666666667, 0
14866, 1.45, 1.2583333333333, 0
14867, 1.4416666666667, 1.2666666666667, 0
14868, 1.45, 1.275, 0
14869, 1.4416666666667, 1.2833333333333, 0
14870, 1.45, 1.2916666666667, 0
14871, 1.4416666666667, 1.3, 0
14872, 1.45, 1.3083333333333, 0
14873, 1.4416666666667, 1.3166666666667, 0
14874, 1.45, 1.325, 0
14875, 1.4416666666667, 1.3333333333333, 0
14876, 1.45, 1.3416666666667, 0
14877, 1.4666666666667, 1.2583333333333, 0
14878, 1.4583333333333, 1.2666666666667, 0
14879, 1.4666666666667, 1.275, 0
14880, 1.4583333333333, 1.2833333333333, 0
14881, 1.4666666666667, 1.2916666666667, 0
14882, 1.4583333333333, 1.3, 0
14883, 1.4666666666667, 1.3083333333333, 0
14884, 1.4583333333333, 1.3166666666667, 0
14885, 1.4666666666667, 1.325, 0
14886, 1.4583333333333, 1.3333333333333, 0
14887, 1.4666666666667, 1.3416666666667, 0
14888, 1.4833333333333, 1.2583333333333, 0
14889, 1.475, 1.2666666666667, 0
14890, 1.4833333333333, 1.275, 0
14891, 1.475, 1.2833333333333, 0
14892, 1.4833333333333, 1.2916666666667, 0
14893, 1.475, 1.3, 0
14894, 1.4833333333333, 1.3083333333333, 0
14895, 1.475, 1.3166666666667, 0
14896, 1.4833333333333, 1.325, 0
14897, 1.475, 1.3333333333333, 0
14898, 1.4833333333333, 1.3416666666667, 0
14899, 1.5, 1.2583333333333, 0
14900, 1.4916666666667, 1.2666666666667, 0
14901, 1.5, 1.275, 0
14902, 1.4916666666667, 1.2833333333333, 0
14903, 1.5, 1.2916666666667, 0
14904, 1.4916666666667, 1.3, 0
14905, 1.5, 1.3083333333333, 0
14906, 1.4916666666667, 1.3166666666667, 0
14907, 1.5, 1.325, 0
14908, 1.4916666666667, 1.3333333333333, 0
14909, 1.5, 1.3416666666667, 0
14910, 1.5166666666667, 1.2583333333333, 0
14911, 1.5083333333333, 1.2666666666667, 0
14912, 1.5166666666667, 1.275, 0
14913, 1.5083333333333, 1.2833333333333, 0
14914, 1.5166666666667, 1.2916666666667, 0
14915, 1.5083333333333, 1.3, 0
14916, 1.5166666666667, 1.3083333333333, 0
14917, 1.5083333333333, 1.3166666666667, 0
14918, 1.5166666666667, 1.325, 0
14919, 1.5083333333333, 1.3333333333333, 0
14920, 1.5166666666667, 1.3416666666667, 0
14921, 1.5333333333333, 1.2583333333333, 0
14922, 1.525, 1.2666666666667, 0
14923, 1.5333333333333, 1.275, 0
14924, 1.525, 1.2833333333333, 0
14925, 1.5333333333333, 1.2916666666667, 0
14926, 1.525, 1.3, 0
14927, 1.5333333333333, 1.3083333333333, 0
14928, 1.525, 1.3166666666667, 0
14929, 1.5333333333333, 1.325, 0
14930, 1.525, 1.3333333333333, 0
14931, 1.5333333333333, 1.3416666666667, 0
14932, 1.55, 1.2583333333333, 0
14933, 1.5416666666667, 1.2666666666667, 0
14934, 1.55, 1.275, 0
14935, 1.5416666666667, 1.2833333333333, 0
14936, 1.55, 1.2916666666667, 0
14937, 1.5416666666667, 1.3, 0
14938, 1.55, 1.3083333333333, 0
14939, 1.5416666666667, 1.3166666666667, 0
14940, 1.55, 1.325, 0
14941, 1.5416666666667, 1.3333333333333, 0
14942, 1.55, 1.3416666666667, 0
14943, 1.5666666666667, 1.2583333333333, 0
14944, 1.5583333333333, 1.2666666666667, 0
14945, 1.5666666666667, 1.275, 0
14946, 1.5583333333333, 1.2833333333333, 0
14947, 1.5666666666667, 1.2916666666667, 0
14948, 1.5583333333333, 1.3, 0
14949, 1.5666666666667, 1.3083333333333, 0
14950, 1.5583333333333, 1.3166666666667, 0
14951, 1.5666666666667, 1.325, 0
14952, 1.5583333333333, 1.3333333333333, 0
14953, 1.5666666666667, 1.3416666666667, 0
14954, 1.5833333333333, 1.2583333333333, 0
14955, 1.575, 1.2666666666667, 0
14956, 1.5833333333333, 1.275, 0
14957, 1.575, 1.2833333333333, 0
14958, 1.5833333333333, 1.2916666666667, 0
14959, 1.575, 1.3, 0
14960, 1.5833333333333, 1.3083333333333, 0
14961, 1.575, 1.3166666666667, 0
14962, 1.5833333333333, 1.325, 0
14963, 1.575, 1.3333333333333, 0
14964, 1.5833333333333, 1.3416666666667, 0
14965, 1.6, 1.2583333333333, 0
14966, 1.5916666666667, 1.2666666666667, 0
14967, 1.6, 1.275, 0
14968, 1.5916666666667, 1.2833333333333, 0
14969, 1.6, 1.2916666666667, 0
14970, 1.5916666666667, 1.3, 0
14971, 1.6, 1.3083333333333, 0
14972, 1.5916666666667, 1.3166666666667, 0
14973, 1.6, 1.325, 0
14974, 1.5916666666667, 1.3333333333333, 0
14975, 1.6, 1.3416666666667, 0
14976, 1.6166666666667, 1.2583333333333, 0
14977, 1.6083333333333, 1.2666666666667, 0
14978, 1.6166666666667, 1.275, 0
14979, 1.6083333333333, 1.2833333333333, 0
14980, 1.6166666666667, 1.2916666666667, 0
14981, 1.6083333333333, 1.3, 0
14982, 1.6166666666667, 1.3083333333333, 0
14983, 1.6083333333333, 1.3166666666667, 0
14984, 1.6166666666667, 1.325, 0
14985, 1.6083333333333, 1.3333333333333, 0
14986, 1.6166666666667, 1.3416666666667, 0
14987, 1.6333333333333, 1.2583333333333, 0
14988, 1.625, 1.2666666666667, 0
14989, 1.6333333333333, 1.275, 0
14990, 1.625, 1.2833333333333, 0
14991, 1.6333333333333, 1.2916666666667, 0
14992, 1.625, 1.3, 0
14993, 1.6333333333333, 1.3083333333333, 0
14994, 1.625, 1.3166666666667, 0
14995, 1.6333333333333, 1.325, 0
14996, 1.625, 1.3333333333333, 0
14997, 1.6333333333333, 1.3416666666667, 0
14998, 1.65, 1.2583333333333, 0
14999, 1.6416666666667, 1.2666666666667, 0
15000, 1.65, 1.275, 0
15001, 1.6416666666667, 1.2833333333333, 0
15002, 1.65, 1.2916666666667, 0
15003, 1.6416666666667, 1.3, 0
15004, 1.65, 1.3083333333333, 0
15005, 1.6416666666667, 1.3166666666667, 0
15006, 1.65, 1.325, 0
15007, 1.6416666666667, 1.3333333333333, 0
15008, 1.65, 1.3416666666667, 0
15009, 1.6666666666667, 1.2583333333333, 0
15010, 1.6583333333333, 1.2666666666667, 0
15011, 1.6666666666667, 1.275, 0
15012, 1.6583333333333, 1.2833333333333, 0
15013, 1.6666666666667, 1.2916666666667, 0
15014, 1.6583333333333, 1.3, 0
15015, 1.6666666666667, 1.3083333333333, 0
15016, 1.6583333333333, 1.3166666666667, 0
15017, 1.6666666666667, 1.325, 0
15018, 1.6583333333333, 1.3333333333333, 0
15019, 1.6666666666667, 1.3416666666667, 0
15020, 1.6833333333333, 1.2583333333333, 0
15021, 1.675, 1.2666666666667, 0
15022, 1.6833333333333, 1.275, 0
15023, 1.675, 1.2833333333333, 0
15024, 1.6833333333333, 1.2916666666667, 0
15025, 1.675, 1.3, 0
15026, 1.6833333333333, 1.3083333333333, 0
15027, 1.675, 1.3166666666667, 0
15028, 1.6833333333333, 1.325, 0
15029, 1.675, 1.3333333333333, 0
15030, 1.6833333333333, 1.3416666666667, 0
15031, 1.7, 1.2583333333333, 0
15032, 1.6916666666667, 1.2666666666667, 0
15033, 1.7, 1.275, 0
15034, 1.6916666666667, 1.2833333333333, 0
15035, 1.7, 1.2916666666667, 0
15036, 1.6916666666667, 1.3, 0
15037, 1.7, 1.3083333333333, 0
15038, 1.6916666666667, 1.3166666666667, 0
15039, 1.7, 1.325, 0
15040, 1.6916666666667, 1.3333333333333, 0
15041, 1.7, 1.3416666666667, 0
15042, 1.7166666666667, 1.2583333333333, 0
15043, 1.7083333333333, 1.2666666666667, 0
15044, 1.7166666666667, 1.275, 0
15045, 1.7083333333333, 1.2833333333333, 0
15046, 1.7166666666667, 1.2916666666667, 0
15047, 1.7083333333333, 1.3, 0
15048, 1.7166666666667, 1.3083333333333, 0
15049, 1.7083333333333, 1.3166666666667, 0
15050, 1.7166666666667, 1.325, 0
15051, 1.7083333333333, 1.3333333333333, 0
15052, 1.7166666666667, 1.3416666666667, 0
15053, 1.7333333333333, 1.2583333333333, 0
15054, 1.725, 1.2666666666667, 0
15055, 1.7333333333333, 1.275, 0
15056, 1.725, 1.2833333333333, 0
15057, 1.7333333333333, 1.2916666666667, 0
15058, 1.725, 1.3, 0
15059, 1.7333333333333, 1.3083333333333, 0
15060, 1.725, 1.3166666666667, 0
15061, 1.7333333333333, 1.325, 0
15062, 1.725, 1.3333333333333, 0
15063, 1.7333333333333, 1.3416666666667, 0
15064, 1.75, 1.2583333333333, 0
15065, 1.7416666666667, 1.2666666666667, 0
15066, 1.75, 1.275, 0
15067, 1.7416666666667, 1.2833333333333, 0
15068, 1.75, 1.2916666666667, 0
15069, 1.7416666666667, 1.3, 0
15070, 1.75, 1.3083333333333, 0
15071, 1.7416666666667, 1.3166666666667, 0
15072, 1.75, 1.325, 0
15073, 1.7416666666667, 1.3333333333333, 0
15074, 1.75, 1.3416666666667, 0
15075, 1.7666666666667, 1.2583333333333, 0
15076, 1.7583333333333, 1.2666666666667, 0
15077, 1.7666666666667, 1.275, 0
15078, 1.7583333333333, 1.2833333333333, 0
15079, 1.7666666666667, 1.2916666666667, 0
15080, 1.7583333333333, 1.3, 0
15081, 1.7666666666667, 1.3083333333333, 0
15082, 1.7583333333333, 1.3166666666667, 0
15083, 1.7666666666667, 1.325, 0
15084, 1.7583333333333, 1.3333333333333, 0
15085, 1.7666666666667, 1.3416666666667, 0
15086, 1.7833333333333, 1.2583333333333, 0
15087, 1.775, 1.2666666666667, 0
15088, 1.7833333333333, 1.275, 0
15089, 1.775, 1.2833333333333, 0
15090, 1.7833333333333, 1.2916666666667, 0
15091, 1.775, 1.3, 0
15092, 1.7833333333333, 1.3083333333333, 0
15093, 1.775, 1.3166666666667, 0
15094, 1.7833333333333, 1.325, 0
15095, 1.775, 1.3333333333333, 0
15096, 1.7833333333333, 1.3416666666667, 0
15097, 1.8, 1.2583333333333, 0
15098, 1.7916666666667, 1.2666666666667, 0
15099, 1.8, 1.275, 0
15100, 1.7916666666667, 1.2833333333333, 0
15101, 1.8, 1.2916666666667, 0
15102, 1.7916666666667, 1.3, 0
15103, 1.8, 1.3083333333333, 0
15104, 1.7916666666667, 1.3166666666667, 0
15105, 1.8, 1.325, 0
15106, 1.7916666666667, 1.3333333333333, 0
15107, 1.8, 1.3416666666667, 0
15108, 1.8166666666667, 1.2583333333333, 0
15109, 1.8083333333333, 1.2666666666667, 0
15110, 1.8166666666667, 1.275, 0
15111, 1.8083333333333, 1.2833333333333, 0
15112, 1.8166666666667, 1.2916666666667, 0
15113, 1.8083333333333, 1.3, 0
15114, 1.8166666666667, 1.3083333333333, 0
15115, 1.8083333333333, 1.3166666666667, 0
15116, 1.8166666666667, 1.325, 0
15117, 1.8083333333333, 1.3333333333333, 0
15118, 1.8166666666667, 1.3416666666667, 0
15119, 1.8333333333333, 1.2583333333333, 0
15120, 1.825, 1.2666666666667, 0
15121, 1.8333333333333, 1.275, 0
15122, 1.825, 1.2833333333333, 0
15123, 1.8333333333333, 1.2916666666667, 0
15124, 1.825, 1.3, 0
15125, 1.8333333333333, 1.3083333333333, 0
15126, 1.825, 1.3166666666667, 0
15127, 1.8333333333333, 1.325, 0
15128, 1.825, 1.3333333333333, 0
15129, 1.8333333333333, 1.3416666666667, 0
15130, 1.85, 1.2583333333333, 0
15131, 1.8416666666667, 1.2666666666667, 0
15132, 1.85, 1.275, 0
15133, 1.8416666666667, 1.2833333333333, 0
15134, 1.85, 1.2916666666667, 0
15135, 1.8416666666667, 1.3, 0
15136, 1.85, 1.3083333333333, 0
15137, 1.8416666666667, 1.3166666666667, 0
15138, 1.85, 1.325, 0
15139, 1.8416666666667, 1.3333333333333, 0
15140, 1.85, 1.3416666666667, 0
15141, 1.8666666666667, 1.2583333333333, 0
15142, 1.8583333333333, 1.2666666666667, 0
15143, 1.8666666666667, 1.275, 0
15144, 1.8583333333333, 1.2833333333333, 0
15145, 1.8666666666667, 1.2916666666667, 0
15146, 1.8583333333333, 1.3, 0
15147, 1.8666666666667, 1.3083333333333, 0
15148, 1.8583333333333, 1.3166666666667, 0
15149, 1.8666666666667, 1.325, 0
15150, 1.8583333333333, 1.3333333333333, 0
15151, 1.8666666666667, 1.3416666666667, 0
15152, 1.8833333333333, 1.2583333333333, 0
15153, 1.875, 1.2666666666667, 0
15154, 1.8833333333333, 1.275, 0
15155, 1.875, 1.2833333333333, 0
15156, 1.8833333333333, 1.2916666666667, 0
15157, 1.875, 1.3, 0
15158, 1.8833333333333, 1.3083333333333, 0
15159, 1.875, 1.3166666666667, 0
15160, 1.8833333333333, 1.325, 0
15161, 1.875, 1.3333333333333, 0
15162, 1.8833333333333, 1.3416666666667, 0
15163, 1.9, 1.2583333333333, 0
15164, 1.8916666666667, 1.2666666666667, 0
15165, 1.9, 1.275, 0
15166, 1.8916666666667, 1.2833333333333, 0
15167, 1.9, 1.2916666666667, 0
15168, 1.8916666666667, 1.3, 0
15169, 1.9, 1.3083333333333, 0
15170, 1.8916666666667, 1.3166666666667, 0
15171, 1.9, 1.325, 0
15172, 1.8916666666667, 1.3333333333333, 0
15173, 1.9, 1.3416666666667, 0
15174, 1.9166666666667, 1.2583333333333, 0
15175, 1.9083333333333, 1.2666666666667, 0
15176, 1.9166666666667, 1.275, 0
15177, 1.9083333333333, 1.2833333333333, 0
15178, 1.9166666666667, 1.2916666666667, 0
15179, 1.9083333333333, 1.3, 0
15180, 1.9166666666667, 1.3083333333333, 0
15181, 1.9083333333333, 1.3166666666667, 0
15182, 1.9166666666667, 1.325, 0
15183, 1.9083333333333, 1.3333333333333, 0
15184, 1.9166666666667, 1.3416666666667, 0
15185, 1.9333333333333, 1.2583333333333, 0
15186, 1.925, 1.2666666666667, 0
15187, 1.9333333333333, 1.275, 0
15188, 1.925, 1.2833333333333, 0
15189, 1.9333333333333, 1.2916666666667, 0
15190, 1.925, 1.3, 0
15191, 1.9333333333333, 1.3083333333333, 0
15192, 1.925, 1.3166666666667, 0
15193, 1.9333333333333, 1.325, 0
15194, 1.925, 1.3333333333333, 0
15195, 1.9333333333333, 1.3416666666667, 0
15196, 1.95, 1.2583333333333, 0
15197, 1.9416666666667, 1.2666666666667, 0
15198, 1.95, 1.275, 0
15199, 1.9416666666667, 1.2833333333333, 0
15200, 1.95, 1.2916666666667, 0
15201, 1.9416666666667, 1.3, 0
15202, 1.95, 1.3083333333333, 0
15203, 1.9416666666667, 1.3166666666667, 0
15204, 1.95, 1.325, 0
15205, 1.9416666666667, 1.3333333333333, 0
15206, 1.95, 1.3416666666667, 0
15207, 1.9666666666667, 1.2583333333333, 0
15208, 1.9583333333333, 1.2666666666667, 0
15209, 1.9666666666667, 1.275, 0
15210, 1.9583333333333, 1.2833333333333, 0
15211, 1.9666666666667, 1.2916666666667, 0
15212, 1.9583333333333, 1.3, 0
15213, 1.9666666666667, 1.3083333333333, 0
15214, 1.9583333333333, 1.3166666666667, 0
15215, 1.9666666666667, 1.325, 0
15216, 1.9583333333333, 1.3333333333333, 0
15217, 1.9666666666667, 1.3416666666667, 0
15218, 1.9833333333333, 1.2583333333333, 0
15219, 1.975, 1.2666666666667, 0
15220, 1.9833333333333, 1.275, 0
15221, 1.975, 1.2833333333333, 0
15222, 1.9833333333333, 1.2916666666667, 0
15223, 1.975, 1.3, 0
15224, 1.9833333333333, 1.3083333333333, 0
15225, 1.975, 1.3166666666667, 0
15226, 1.9833333333333, 1.325, 0
15227, 1.975, 1.3333333333333, 0
15228, 1.9833333333333, 1.3416666666667, 0
15229, 2, 1.2583333333333, 0
15230, 1.9916666666667, 1.2666666666667, 0
15231, 2, 1.275, 0
15232, 1.9916666666667, 1.2833333333333, 0
15233, 2, 1.2916666666667, 0
15234, 1.9916666666667, 1.3, 0
15235, 2, 1.3083333333333, 0
15236, 1.9916666666667, 1.3166666666667, 0
15237, 2, 1.325, 0
15238, 1.9916666666667, 1.3333333333333, 0
15239, 2, 1.3416666666667, 0
15240, 2.0166666666667, 1.2583333333333, 0
15241, 2.0083333333333, 1.2666666666667, 0
15242, 2.0166666666667, 1.275, 0
15243, 2.0083333333333, 1.2833333333333, 0
15244, 2.0166666666667, 1.2916666666667, 0
15245, 2.0083333333333, 1.3, 0
15246, 2.0166666666667, 1.3083333333333, 0
15247, 2.0083333333333, 1.3166666666667, 0
15248, 2.0166666666667, 1.325, 0
15249, 2.0083333333333, 1.3333333333333, 0
15250, 2.0166666666667, 1.3416666666667, 0
15251, 2.0333333333333, 1.2583333333333, 0
15252, 2.025, 1.2666666666667, 0
15253, 2.0333333333333, 1.275, 0
15254, 2.025, 1.2833333333333, 0
15255, 2.0333333333333, 1.2916666666667, 0
15256, 2.025, 1.3, 0
15257, 2.0333333333333, 1.3083333333333, 0
15258, 2.025, 1.3166666666667, 0
15259, 2.0333333333333, 1.325, 0
15260, 2.025, 1.3333333333333, 0
15261, 2.0333333333333, 1.3416666666667, 0
15262, 2.05, 1.2583333333333, 0
15263, 2.0416666666667, 1.2666666666667, 0
15264, 2.05, 1.275, 0
15265, 2.0416666666667, 1.2833333333333, 0
15266, 2.05, 1.2916666666667, 0
15267, 2.0416666666667, 1.3, 0
15268, 2.05, 1.3083333333333, 0
15269, 2.0416666666667, 1.3166666666667, 0
15270, 2.05, 1.325, 0
15271, 2.0416666666667, 1.3333333333333, 0
15272, 2.05, 1.3416666666667, 0
15273, 2.0666666666667, 1.2583333333333, 0
15274, 2.0583333333333, 1.2666666666667, 0
15275, 2.0666666666667, 1.275, 0
15276, 2.0583333333333, 1.2833333333333, 0
15277, 2.0666666666667, 1.2916666666667, 0
15278, 2.0583333333333, 1.3, 0
15279, 2.0666666666667, 1.3083333333333, 0
15280, 2.0583333333333, 1.3166666666667, 0
15281, 2.0666666666667, 1.325, 0
15282, 2.0583333333333, 1.3333333333333, 0
15283, 2.0666666666667, 1.3416666666667, 0
15284, 2.0833333333333, 1.2583333333333, 0
15285, 2.075, 1.2666666666667, 0
15286, 2.0833333333333, 1.275, 0
15287, 2.075, 1.2833333333333, 0
15288, 2.0833333333333, 1.2916666666667, 0
15289, 2.075, 1.3, 0
15290, 2.0833333333333, 1.3083333333333, 0
15291, 2.075, 1.3166666666667, 0
15292, 2.0833333333333, 1.325, 0
15293, 2.075, 1.3333333333333, 0
15294, 2.0833333333333, 1.3416666666667, 0
15295, 2.1, 1.2583333333333, 0
15296, 2.0916666666667, 1.2666666666667, 0
15297, 2.1, 1.275, 0
15298, 2.0916666666667, 1.2833333333333, 0
15299, 2.1, 1.2916666666667, 0
15300, 2.0916666666667, 1.3, 0
15301, 2.1, 1.3083333333333, 0
15302, 2.0916666666667, 1.3166666666667, 0
15303, 2.1, 1.325, 0
15304, 2.0916666666667, 1.3333333333333, 0
15305, 2.1, 1.3416666666667, 0
15306, 2.1166666666667, 1.2583333333333, 0
15307, 2.1083333333333, 1.2666666666667, 0
15308, 2.1166666666667, 1.275, 0
15309, 2.1083333333333, 1.2833333333333, 0
15310, 2.1166666666667, 1.2916666666667, 0
15311, 2.1083333333333, 1.3, 0
15312, 2.1166666666667, 1.3083333333333, 0
15313, 2.1083333333333, 1.3166666666667, 0
15314, 2.1166666666667, 1.325, 0
15315, 2.1083333333333, 1.3333333333333, 0
15316, 2.1166666666667, 1.3416666666667, 0
15317, 2.1333333333333, 1.2583333333333, 0
15318, 2.125, 1.2666666666667, 0
15319, 2.1333333333333, 1.275, 0
15320, 2.125, 1.2833333333333, 0
15321, 2.1333333333333, 1.2916666666667, 0
15322, 2.125, 1.3, 0
15323, 2.1333333333333, 1.3083333333333, 0
15324, 2.125, 1.3166666666667, 0
15325, 2.1333333333333, 1.325, 0
15326, 2.125, 1.3333333333333, 0
15327, 2.1333333333333, 1.3416666666667, 0
15328, 2.15, 1.2583333333333, 0
15329, 2.1416666666667, 1.2666666666667, 0
15330, 2.15, 1.275, 0
15331, 2.1416666666667, 1.2833333333333, 0
15332, 2.15, 1.2916666666667, 0
15333, 2.1416666666667, 1.3, 0
15334, 2.15, 1.3083333333333, 0
15335, 2.1416666666667, 1.3166666666667, 0
15336, 2.15, 1.325, 0
15337, 2.1416666666667, 1.3333333333333, 0
15338, 2.15, 1.3416666666667, 0
15339, 2.1666666666667, 1.2583333333333, 0
15340, 2.1583333333333, 1.2666666666667, 0
15341, 2.1666666666667, 1.275, 0
15342, 2.1583333333333, 1.2833333333333, 0
15343, 2.1666666666667, 1.2916666666667, 0
15344, 2.1583333333333, 1.3, 0
15345, 2.1666666666667, 1.3083333333333, 0
15346, 2.1583333333333, 1.3166666666667, 0
15347, 2.1666666666667, 1.325, 0
15348, 2.1583333333333, 1.3333333333333, 0
15349, 2.1666666666667, 1.3416666666667, 0
15350, 2.1833333333333, 1.2583333333333, 0
15351, 2.175, 1.2666666666667, 0
15352, 2.1833333333333, 1.275, 0
15353, 2.175, 1.2833333333333, 0
15354, 2.1833333333333, 1.2916666666667, 0
15355, 2.175, 1.3, 0
15356, 2.1833333333333, 1.3083333333333, 0
15357, 2.175, 1.3166666666667, 0
15358, 2.1833333333333, 1.325, 0
15359, 2.175, 1.3333333333333, 0
15360, 2.1833333333333, 1.3416666666667, 0
15361, 2.1916666666667, 1.2666666666667, 0
15362, 2.1916666666667, 1.2833333333333, 0
15363, 2.1916666666667, 1.3, 0
15364, 2.1916666666667, 1.3166666666667, 0
15365, 2.1916666666667, 1.3333333333333, 0
15366, 1.2166666666667, 1.18, 0
15367, 1.2333333333333, 1.18, 0
15368, 1.25, 1.18, 0
15369, 1.2666666666667, 1.18, 0
15370, 1.2833333333333, 1.18, 0
15371, 1.3, 1.18, 0
15372, 1.3166666666667, 1.18, 0
15373, 1.3333333333333, 1.18, 0
15374, 1.35, 1.18, 0
15375, 1.3666666666667, 1.18, 0
15376, 1.3833333333333, 1.18, 0
15377, 1.4, 1.18, 0
15378, 1.4166666666667, 1.18, 0
15379, 1.4333333333333, 1.18, 0
15380, 1.45, 1.18, 0
15381, 1.4666666666667, 1.18, 0
15382, 1.4833333333333, 1.18, 0
15383, 1.5, 1.18, 0
15384, 1.5166666666667, 1.18, 0
15385, 1.5333333333333, 1.18, 0
15386, 1.55, 1.18, 0
15387, 1.5666666666667, 1.18, 0
15388, 1.5833333333333, 1.18, 0
15389, 1.6, 1.18, 0
15390, 1.6166666666667, 1.18, 0
15391, 1.6333333333333, 1.18, 0
15392, 1.65, 1.18, 0
15393, 1.6666666666667, 1.18, 0
15394, 1.6833333333333, 1.18, 0
15395, 1.7, 1.18, 0
15396, 1.7166666666667, 1.18, 0
15397, 1.7333333333333, 1.18, 0
15398, 1.75, 1.18, 0
15399, 1.7666666666667, 1.18, 0
15400, 1.7833333333333, 1.18, 0
15401, 1.8, 1.18, 0
15402, 1.8166666666667, 1.18, 0
15403, 1.8333333333333, 1.18, 0
15404, 1.85, 1.18, 0
15405, 1.8666666666667, 1.18, 0
15406, 1.8833333333333, 1.18, 0
15407, 1.9, 1.18, 0
15408, 1.9166666666667, 1.18, 0
15409, 1.9333333333333, 1.18, 0
15410, 1.95, 1.18, 0
15411, 1.9666666666667, 1.18, 0
15412, 1.9833333333333, 1.18, 0
15413, 2, 1.18, 0
15414, 2.0166666666667, 1.18, 0
15415, 2.0333333333333, 1.18, 0
15416, 2.05, 1.18, 0
15417, 2.0666666666667, 1.18, 0
15418, 2.0833333333333, 1.18, 0
15419, 2.1, 1.18, 0
15420, 2.1166666666667, 1.18, 0
15421, 2.1333333333333, 1.18, 0
15422, 2.15, 1.18, 0
15423, 2.1666666666667, 1.18, 0
15424, 2.1833333333333, 1.18, 0
15425, 1.2166666666667, 1.16, 0
15426, 1.2333333333333, 1.16, 0
15427, 1.25, 1.16, 0
15428, 1.2666666666667, 1.16, 0
15429, 1.2833333333333, 1.16, 0
15430, 1.3, 1.16, 0
15431, 1.3166666666667, 1.16, 0
15432, 1.3333333333333, 1.16, 0
15433, 1.35, 1.16, 0
15434, 1.3666666666667, 1.16, 0
15435, 1.3833333333333, 1.16, 0
15436, 1.4, 1.16, 0
15437, 1.4166666666667, 1.16, 0
15438, 1.4333333333333, 1.16, 0
15439, 1.45, 1.16, 0
15440, 1.4666666666667, 1.16, 0
15441, 1.4833333333333, 1.16, 0
15442, 1.5, 1.16, 0
15443, 1.5166666666667, 1.16, 0
15444, 1.5333333333333, 1.16, 0
15445, 1.55, 1.16, 0
15446, 1.5666666666667, 1.16, 0
15447, 1.5833333333333, 1.16, 0
15448, 1.6, 1.16, 0
15449, 1.6166666666667, 1.16, 0
15450, 1.6333333333333, 1.16, 0
15451, 1.65, 1.16, 0
15452, 1.6666666666667, 1.16, 0
15453, 1.6833333333333, 1.16, 0
15454, 1.7, 1.16, 0
15455, 1.7166666666667, 1.16, 0
15456, 1.7333333333333, 1.16, 0
15457, 1.75, 1.16, 0
15458, 1.7666666666667, 1.16, 0
15459, 1.7833333333333, 1.16, 0
15460, 1.8, 1.16, 0
15461, 1.8166666666667, 1.16, 0
15462, 1.8333333333333, 1.16, 0
15463, 1.85, 1.16, 0
15464, 1.8666666666667, 1.16, 0
15465, 1.8833333333333, 1.16, 0
15466, 1.9, 1.16, 0
15467, 1.9166666666667, 1.16, 0
15468, 1.9333333333333, 1.16, 0
15469, 1.95, 1.16, 0
15470, 1.9666666666667, 1.16, 0
15471, 1.9833333333333, 1.16, 0
15472, 2, 1.16, 0
15473, 2.0166666666667, 1.16, 0
15474, 2.0333333333333, 1.16, 0
15475, 2.05, 1.16, 0
15476, 2.0666666666667, 1.16, 0
15477, 2.0833333333333, 1.16, 0
15478, 2.1, 1.16, 0
15479, 2.1166666666667, 1.16, 0
15480, 2.1333333333333, 1.16, 0
15481, 2.15, 1.16, 0
15482, 2.1666666666667, 1.16, 0
15483, 2.1833333333333, 1.16, 0
15484, 1.2166666666667, 1.14, 0
15485, 1.2333333333333, 1.14, 0
15486, 1.25, 1.14, 0
15487, 1.2666666666667, 1.14, 0
15488, 1.2833333333333, 1.14, 0
15489, 1.3, 1.14, 0
15490, 1.3166666666667, 1.14, 0
15491, 1.3333333333333, 1.14, 0
15492, 1.35, 1.14, 0
15493, 1.3666666666667, 1.14, 0
15494, 1.3833333333333, 1.14, 0
15495, 1.4, 1.14, 0
15496, 1.4166666666667, 1.14, 0
15497, 1.4333333333333, 1.14, 0
15498, 1.45, 1.14, 0
15499, 1.4666666666667, 1.14, 0
15500, 1.4833333333333, 1.14, 0
15501, 1.5, 1.14, 0
15502, 1.5166666666667, 1.14, 0
15503, 1.5333333333333, 1.14, 0
15504, 1.55, 1.14, 0
15505, 1.5666666666667, 1.14, 0
15506, 1.5833333333333, 1.14, 0
15507, 1.6, 1.14, 0
15508, 1.6166666666667, 1.14, 0
15509, 1.6333333333333, 1.14, 0
15510, 1.65, 1.14, 0
15511, 1.6666666666667, 1.14, 0
15512, 1.6833333333333, 1.14, 0
15513, 1.7, 1.14, 0
15514, 1.7166666666667, 1.14, 0
15515, 1.7333333333333, 1.14, 0
15516, 1.75, 1.14, 0
15517, 1.7666666666667, 1.14, 0
15518, 1.7833333333333, 1.14, 0
15519, 1.8, 1.14, 0
15520, 1.8166666666667, 1.14, 0
15521, 1.8333333333333, 1.14, 0
15522, 1.85, 1.14, 0
15523, 1.8666666666667, 1.14, 0
15524, 1.8833333333333, 1.14, 0
15525, 1.9, 1.14, 0
15526, 1.9166666666667, 1.14, 0
15527, 1.9333333333333, 1.14, 0
15528, 1.95, 1.14, 0
15529, 1.9666666666667, 1.14, 0
15530, 1.9833333333333, 1.14, 0
15531, 2, 1.14, 0
15532, 2.0166666666667, 1.14, 0
15533, 2.0333333333333, 1.14, 0
15534, 2.05, 1.14, 0
15535, 2.0666666666667, 1.14, 0
15536, 2.0833333333333, 1.14, 0
15537, 2.1, 1.14, 0
15538, 2.1166666666667, 1.14, 0
15539, 2.1333333333333, 1.14, 0
15540, 2.15, 1.14, 0
15541, 2.1666666666667, 1.14, 0
15542, 2.1833333333333, 1.14, 0
15543, 1.2166666666667, 1.12, 0
15544, 1.2333333333333, 1.12, 0
15545, 1.25, 1.12, 0
15546, 1.2666666666667, 1.12, 0
15547, 1.2833333333333, 1.12, 0
15548, 1.3, 1.12, 0
15549, 1.3166666666667, 1.12, 0
15550, 1.3333333333333, 1.12, 0
15551, 1.35, 1.12, 0
15552, 1.3666666666667, 1.12, 0
15553, 1.3833333333333, 1.12, 0
15554, 1.4, 1.12, 0
15555, 1.4166666666667, 1.12, 0
15556, 1.4333333333333, 1.12, 0
15557, 1.45, 1.12, 0
15558, 1.4666666666667, 1.12, 0
15559, 1.4833333333333, 1.12, 0
15560, 1.5, 1.12, 0
15561, 1.5166666666667, 1.12, 0
15562, 1.5333333333333, 1.12, 0
15563, 1.55, 1.12, 0
15564, 1.5666666666667, 1.12, 0
15565, 1.5833333333333, 1.12, 0
15566, 1.6, 1.12, 0
15567, 1.6166666666667, 1.12, 0
15568, 1.6333333333333, 1.12, 0
15569, 1.65, 1.12, 0
15570, 1.6666666666667, 1.12, 0
15571, 1.6833333333333, 1.12, 0
15572, 1.7, 1.12, 0
15573, 1.7166666666667, 1.12, 0
15574, 1.7333333333333, 1.12, 0
15575, 1.75, 1.12, 0
15576, 1.7666666666667, 1.12, 0
15577, 1.7833333333333, 1.12, 0
15578, 1.8, 1.12, 0
15579, 1.8166666666667, 1.12, 0
15580, 1.8333333333333, 1.12, 0
15581, 1.85, 1.12, 0
15582, 1.8666666666667, 1.12, 0
15583, 1.8833333333333, 1.12, 0
15584, 1.9, 1.12, 0
15585, 1.9166666666667, 1.12, 0
15586, 1.9333333333333, 1.12, 0
15587, 1.95, 1.12, 0
15588, 1.9666666666667, 1.12, 0
15589, 1.9833333333333, 1.12, 0
15590, 2, 1.12, 0
15591, 2.0166666666667, 1.12, 0
15592, 2.0333333333333, 1.12, 0
15593, 2.05, 1.12, 0
15594, 2.0666666666667, 1.12, 0
15595, 2.0833333333333, 1.12, 0
15596, 2.1, 1.12, 0
15597, 2.1166666666667, 1.12, 0
15598, 2.1333333333333, 1.12, 0
15599, 2.15, 1.12, 0
15600, 2.1666666666667, 1.12, 0
15601, 2.1833333333333, 1.12, 0
15602, 1.2166666666667, 1.1, 0
15603, 1.2333333333333, 1.1, 0
15604, 1.25, 1.1, 0
15605, 1.2666666666667, 1.1, 0
15606, 1.2833333333333, 1.1, 0
15607, 1.3, 1.1, 0
15608, 1.3166666666667, 1.1, 0
15609, 1.3333333333333, 1.1, 0
15610, 1.35, 1.1, 0
15611, 1.3666666666667, 1.1, 0
15612, 1.3833333333333, 1.1, 0
15613, 1.4, 1.1, 0
15614, 1.4166666666667, 1.1, 0
15615, 1.4333333333333, 1.1, 0
15616, 1.45, 1.1, 0
15617, 1.4666666666667, 1.1, 0
15618, 1.4833333333333, 1.1, 0
15619, 1.5, 1.1, 0
15620, 1.5166666666667, 1.1, 0
15621, 1.5333333333333, 1.1, 0
15622, 1.55, 1.1, 0
15623, 1.5666666666667, 1.1, 0
15624, 1.5833333333333, 1.1, 0
15625, 1.6, 1.1, 0
15626, 1.6166666666667, 1.1, 0
15627, 1.6333333333333, 1.1, 0
15628, 1.65, 1.1, 0
15629, 1.6666666666667, 1.1, 0
15630, 1.6833333333333, 1.1, 0
15631, 1.7, 1.1, 0
15632, 1.7166666666667, 1.1, 0
15633, 1.7333333333333, 1.1, 0
15634, 1.75, 1.1, 0
15635, 1.7666666666667, 1.1, 0
15636, 1.7833333333333, 1.1, 0
15637, 1.8, 1.1, 0
15638, 1.8166666666667, 1.1, 0
15639, 1.8333333333333, 1.1, 0
15640, 1.85, 1.1, 0
15641, 1.8666666666667, 1.1, 0
15642, 1.8833333333333, 1.1, 0
15643, 1.9, 1.1, 0
15644, 1.9166666666667, 1.1, 0
15645, 1.9333333333333, 1.1, 0
15646, 1.95, 1.1, 0
15647, 1.9666666666667, 1.1, 0
15648, 1.9833333333333, 1.1, 0
15649, 2, 1.1, 0
15650, 2.0166666666667, 1.1, 0
15651, 2.0333333333333, 1.1, 0
15652, 2.05, 1.1, 0
15653, 2.0666666666667, 1.1, 0
15654, 2.0833333333333, 1.1, 0
15655, 2.1, 1.1, 0
15656, 2.1166666666667, 1.1, 0
15657, 2.1333333333333, 1.1, 0
15658, 2.15, 1.1, 0
15659, 2.1666666666667, 1.1, 0
15660, 2.1833333333333, 1.1, 0
15661, 1.2166666666667, 1.08, 0
15662, 1.2333333333333, 1.08, 0
15663, 1.25, 1.08, 0
15664, 1.2666666666667, 1.08, 0
15665, 1.2833333333333, 1.08, 0
15666, 1.3, 1.08, 0
15667, 1.3166666666667, 1.08, 0
15668, 1.3333333333333, 1.08, 0
15669, 1.35, 1.08, 0
15670, 1.3666666666667, 1.08, 0
15671, 1.3833333333333, 1.08, 0
15672, 1.4, 1.08, 0
15673, 1.4166666666667, 1.08, 0
15674, 1.4333333333333, 1.08, 0
15675, 1.45, 1.08, 0
15676, 1.4666666666667, 1.08, 0
15677, 1.4833333333333, 1.08, 0
15678, 1.5, 1.08, 0
15679, 1.5166666666667, 1.08, 0
15680, 1.5333333333333, 1.08, 0
15681, 1.55, 1.08, 0
15682, 1.5666666666667, 1.08, 0
15683, 1.5833333333333, 1.08, 0
15684, 1.6, 1.08, 0
15685, 1.6166666666667, 1.08, 0
15686, 1.6333333333333, 1.08, 0
15687, 1.65, 1.08, 0
15688, 1.6666666666667, 1.08, 0
15689, 1.6833333333333, 1.08, 0
15690, 1.7, 1.08, 0
15691, 1.7166666666667, 1.08, 0
15692, 1.7333333333333, 1.08, 0
15693, 1.75, 1.08, 0
15694, 1.7666666666667, 1.08, 0
15695, 1.7833333333333, 1.08, 0
15696, 1.8, 1.08, 0
15697, 1.8166666666667, 1.08, 0
15698, 1.8333333333333, 1.08, 0
15699, 1.85, 1.08, 0
15700, 1.8666666666667, 1.08, 0
15701, 1.8833333333333, 1.08, 0
15702, 1.9, 1.08, 0
15703, 1.9166666666667, 1.08, 0
15704, 1.9333333333333, 1.08, 0
15705, 1.95, 1.08, 0
15706, 1.9666666666667, 1.08, 0
15707, 1.9833333333333, 1.08, 0
15708, 2, 1.08, 0
15709, 2.0166666666667, 1.08, 0
15710, 2.0333333333333, 1.08, 0
15711, 2.05, 1.08, 0
15712, 2.0666666666667, 1.08, 0
15713, 2.0833333333333, 1.08, 0
15714, 2.1, 1.08, 0
15715, 2.1166666666667, 1.08, 0
15716, 2.1333333333333, 1.08, 0
15717, 2.15, 1.08, 0
15718, 2.1666666666667, 1.08, 0
15719, 2.1833333333333, 1.08, 0
15720, 1.2166666666667, 1.06, 0
15721, 1.2333333333333, 1.06, 0
15722, 1.25, 1.06, 0
15723, 1.2666666666667, 1.06, 0
15724, 1.2833333333333, 1.06, 0
15725, 1.3, 1.06, 0
15726, 1.3166666666667, 1.06, 0
15727, 1.3333333333333, 1.06, 0
15728, 1.35, 1.06, 0
15729, 1.3666666666667, 1.06, 0
15730, 1.3833333333333, 1.06, 0
15731, 1.4, 1.06, 0
15732, 1.4166666666667, 1.06, 0
15733, 1.4333333333333, 1.06, 0
15734, 1.45, 1.06, 0
15735, 1.4666666666667, 1.06, 0
15736, 1.4833333333333, 1.06, 0
15737, 1.5, 1.06, 0
15738, 1.5166666666667, 1.06, 0
15739, 1.5333333333333, 1.06, 0
15740, 1.55, 1.06, 0
15741, 1.5666666666667, 1.06, 0
15742, 1.5833333333333, 1.06, 0
15743, 1.6, 1.06, 0
15744, 1.6166666666667, 1.06, 0
15745, 1.6333333333333, 1.06, 0
15746, 1.65, 1.06, 0
15747, 1.6666666666667, 1.06, 0
15748, 1.6833333333333, 1.06, 0
15749, 1.7, 1.06, 0
15750, 1.7166666666667, 1.06, 0
15751, 1.7333333333333, 1.06, 0
15752, 1.75, 1.06, 0
15753, 1.7666666666667, 1.06, 0
15754, 1.7833333333333, 1.06, 0
15755, 1.8, 1.06, 0
15756, 1.8166666666667, 1.06, 0
15757, 1.8333333333333, 1.06, 0
15758, 1.85, 1.06, 0
15759, 1.8666666666667, 1.06, 0
15760, 1.8833333333333, 1.06, 0
15761, 1.9, 1.06, 0
15762, 1.9166666666667, 1.06, 0
15763, 1.9333333333333, 1.06, 0
15764, 1.95, 1.06, 0
15765, 1.9666666666667, 1.06, 0
15766, 1.9833333333333, 1.06, 0
15767, 2, 1.06, 0
15768, 2.0166666666667, 1.06, 0
15769, 2.0333333333333, 1.06, 0
15770, 2.05, 1.06, 0
15771, 2.0666666666667, 1.06, 0
15772, 2.0833333333333, 1.06, 0
15773, 2.1, 1.06, 0
15774, 2.1166666666667, 1.06, 0
15775, 2.1333333333333, 1.06, 0
15776, 2.15, 1.06, 0
15777, 2.1666666666667, 1.06, 0
15778, 2.1833333333333, 1.06, 0
15779, 1.2166666666667, 1.04, 0
15780, 1.2333333333333, 1.04, 0
15781, 1.25, 1.04, 0
15782, 1.2666666666667, 1.04, 0
15783, 1.2833333333333, 1.04, 0
15784, 1.3, 1.04, 0
15785, 1.3166666666667, 1.04, 0
15786, 1.3333333333333, 1.04, 0
15787, 1.35, 1.04, 0
15788, 1.3666666666667, 1.04, 0
15789, 1.3833333333333, 1.04, 0
15790, 1.4, 1.04, 0
15791, 1.4166666666667, 1.04, 0
15792, 1.4333333333333, 1.04, 0
15793, 1.45, 1.04, 0
15794, 1.4666666666667, 1.04, 0
15795, 1.4833333333333, 1.04, 0
15796, 1.5, 1.04, 0
15797, 1.5166666666667, 1.04, 0
15798, 1.5333333333333, 1.04, 0
15799, 1.55, 1.04, 0
15800, 1.5666666666667, 1.04, 0
15801, 1.5833333333333, 1.04, 0
15802, 1.6, 1.04, 0
15803, 1.6166666666667, 1.04, 0
15804, 1.6333333333333, 1.04, 0
15805, 1.65, 1.04, 0
15806, 1.6666666666667, 1.04, 0
15807, 1.6833333333333, 1.04, 0
15808, 1.7, 1.04, 0
15809, 1.7166666666667, 1.04, 0
15810, 1.7333333333333, 1.04, 0
15811, 1.75, 1.04, 0
15812, 1.7666666666667, 1.04, 0
15813, 1.7833333333333, 1.04, 0
15814, 1.8, 1.04, 0
15815, 1.8166666666667, 1.04, 0
15816, 1.8333333333333, 1.04, 0
15817, 1.85, 1.04, 0
15818, 1.8666666666667, 1.04, 0
15819, 1.8833333333333, 1.04, 0
15820, 1.9, 1.04, 0
15821, 1.9166666666667, 1.04, 0
15822, 1.9333333333333, 1.04, 0
15823, 1.95, 1.04, 0
15824, 1.9666666666667, 1.04, 0
15825, 1.9833333333333, 1.04, 0
15826, 2, 1.04, 0
15827, 2.0166666666667, 1.04, 0
15828, 2.0333333333333, 1.04, 0
15829, 2.05, 1.04, 0
15830, 2.0666666666667, 1.04, 0
15831, 2.0833333333333, 1.04, 0
15832, 2.1, 1.04, 0
15833, 2.1166666666667, 1.04, 0
15834, 2.1333333333333, 1.04, 0
15835, 2.15, 1.04, 0
15836, 2.1666666666667, 1.04, 0
15837, 2.1833333333333, 1.04, 0
15838, 1.2166666666667, 1.02, 0
15839, 1.2333333333333, 1.02, 0
15840, 1.25, 1.02, 0
15841, 1.2666666666667, 1.02, 0
15842, 1.2833333333333, 1.02, 0
15843, 1.3, 1.02, 0
15844, 1.3166666666667, 1.02, 0
15845, 1.3333333333333, 1.02, 0
15846, 1.35, 1.02, 0
15847, 1.3666666666667, 1.02, 0
15848, 1.3833333333333, 1.02, 0
15849, 1.4, 1.02, 0
15850, 1.4166666666667, 1.02, 0
15851, 1.4333333333333, 1.02, 0
15852, 1.45, 1.02, 0
15853, 1.4666666666667, 1.02, 0
15854, 1.4833333333333, 1.02, 0
15855, 1.5, 1.02, 0
15856, 1.5166666666667, 1.02, 0
15857, 1.5333333333333, 1.02, 0
15858, 1.55, 1.02, 0
15859, 1.5666666666667, 1.02, 0
15860, 1.5833333333333, 1.02, 0
15861, 1.6, 1.02, 0
15862, 1.6166666666667, 1.02, 0
15863, 1.6333333333333, 1.02, 0
15864, 1.65, 1.02, 0
15865, 1.6666666666667, 1.02, 0
15866, 1.6833333333333, 1.02, 0
15867, 1.7, 1.02, 0
15868, 1.7166666666667, 1.02, 0
15869, 1.7333333333333, 1.02, 0
15870, 1.75, 1.02, 0
15871, 1.7666666666667, 1.02, 0
15872, 1.7833333333333, 1.02, 0
15873, 1.8, 1.02, 0
15874, 1.8166666666667, 1.02, 0
15875, 1.8333333333333, 1.02, 0
15876, 1.85, 1.02, 0
15877, 1.8666666666667, 1.02, 0
15878, 1.8833333333333, 1.02, 0
15879, 1.9, 1.02, 0
15880, 1.9166666666667, 1.02, 0
15881, 1.9333333333333, 1.02, 0
15882, 1.95, 1.02, 0
15883, 1.9666666666667, 1.02, 0
15884, 1.9833333333333, 1.02, 0
15885, 2, 1.02, 0
15886, 2.0166666666667, 1.02, 0
15887, 2.0333333333333, 1.02, 0
15888, 2.05, 1.02, 0
15889, 2.0666666666667, 1.02, 0
15890, 2.0833333333333, 1.02, 0
15891, 2.1, 1.02, 0
15892, 2.1166666666667, 1.02, 0
15893, 2.1333333333333, 1.02, 0
15894, 2.15, 1.02, 0
15895, 2.1666666666667, 1.02, 0
15896, 2.1833333333333, 1.02, 0
15897, 1.2166666666667, 1, 0
15898, 1.2333333333333, 1, 0
15899, 1.25, 1, 0
15900, 1.2666666666667, 1, 0
15901, 1.2833333333333, 1, 0
15902, 1.3, 1, 0
15903, 1.3166666666667, 1, 0
15904, 1.3333333333333, 1, 0
15905, 1.35, 1, 0
15906, 1.3666666666667, 1, 0
15907, 1.3833333333333, 1, 0
15908, 1.4, 1, 0
15909, 1.4166666666667, 1, 0
15910, 1.4333333333333, 1, 0
15911, 1.45, 1, 0
15912, 1.4666666666667, 1, 0
15913, 1.4833333333333, 1, 0
15914, 1.5, 1, 0
15915, 1.5166666666667, 1, 0
15916, 1.5333333333333, 1, 0
15917, 1.55, 1, 0
15918, 1.5666666666667, 1, 0
15919, 1.5833333333333, 1, 0
15920, 1.6, 1, 0
15921, 1.6166666666667, 1, 0
15922, 1.6333333333333, 1, 0
15923, 1.65, 1, 0
15924, 1.6666666666667, 1, 0
15925, 1.6833333333333, 1, 0
15926, 1.7, 1, 0
15927, 1.7166666666667, 1, 0
15928, 1.7333333333333, 1, 0
15929, 1.75, 1, 0
15930, 1.7666666666667, 1, 0
15931, 1.7833333333333, 1, 0
15932, 1.8, 1, 0
15933, 1.8166666666667, 1, 0
15934, 1.8333333333333, 1, 0
15935, 1.85, 1, 0
15936, 1.8666666666667, 1, 0
15937, 1.8833333333333, 1, 0
15938, 1.9, 1, 0
15939, 1.9166666666667, 1, 0
15940, 1.9333333333333, 1, 0
15941, 1.95, 1, 0
15942, 1.9666666666667, 1, 0
15943, 1.9833333333333, 1, 0
15944, 2, 1, 0
15945, 2.0166666666667, 1, 0
15946, 2.0333333333333, 1, 0
15947, 2.05, 1, 0
15948, 2.0666666666667, 1, 0
15949, 2.0833333333333, 1, 0
15950, 2.1, 1, 0
15951, 2.1166666666667, 1, 0
15952, 2.1333333333333, 1, 0
15953, 2.15, 1, 0
15954, 2.1666666666667, 1, 0
15955, 2.1833333333333, 1, 0
15956, 1.2166666666667, 0.98, 0
15957, 1.2333333333333, 0.98, 0
15958, 1.25, 0.98, 0
15959, 1.2666666666667, 0.98, 0
15960, 1.2833333333333, 0.98, 0
15961, 1.3, 0.98, 0
15962, 1.3166666666667, 0.98, 0
15963, 1.3333333333333, 0.98, 0
15964, 1.35, 0.98, 0
15965, 1.3666666666667, 0.98, 0
15966, 1.3833333333333, 0.98, 0
15967, 1.4, 0.98, 0
15968, 1.4166666666667, 0.98, 0
15969, 1.4333333333333, 0.98, 0
15970, 1.45, 0.98, 0
15971, 1.4666666666667, 0.98, 0
15972, 1.4833333333333, 0.98, 0
15973, 1.5, 0.98, 0
15974, 1.5166666666667, 0.98, 0
15975, 1.5333333333333, 0.98, 0
15976, 1.55, 0.98, 0
15977, 1.5666666666667, 0.98, 0
15978, 1.5833333333333, 0.98, 0
15979, 1.6, 0.98, 0
15980, 1.6166666666667, 0.98, 0
15981, 1.6333333333333, 0.98, 0
15982, 1.65, 0.98, 0
15983, 1.6666666666667, 0.98, 0
15984, 1.6833333333333, 0.98, 0
15985, 1.7, 0.98, 0
15986, 1.7166666666667, 0.98, 0
15987, 1.7333333333333, 0.98, 0
15988, 1.75, 0.98, 0
15989, 1.7666666666667, 0.98, 0
15990, 1.7833333333333, 0.98, 0
15991, 1.8, 0.98, 0
15992, 1.8166666666667, 0.98, 0
15993, 1.8333333333333, 0.98, 0
15994, 1.85, 0.98, 0
15995, 1.8666666666667, 0.98, 0
15996, 1.8833333333333, 0.98, 0
15997, 1.9, 0.98, 0
15998, 1.9166666666667, 0.98, 0
15999, 1.9333333333333, 0.98, 0
16000, 1.95, 0.98, 0
16001, 1.9666666666667, 0.98, 0
16002, 1.9833333333333, 0.98, 0
16003, 2, 0.98, 0
16004, 2.0166666666667, 0.98, 0
16005, 2.0333333333333, 0.98, 0
16006, 2.05, 0.98, 0
16007, 2.0666666666667, 0.98, 0
16008, 2.0833333333333, 0.98, 0
16009, 2.1, 0.98, 0
16010, 2.1166666666667, 0.98, 0
16011, 2.1333333333333, 0.98, 0
16012, 2.15, 0.98, 0
16013, 2.1666666666667, 0.98, 0
16014, 2.1833333333333, 0.98, 0
16015, 1.2166666666667, 0.96, 0
16016, 1.2333333333333, 0.96, 0
16017, 1.25, 0.96, 0
16018, 1.2666666666667, 0.96, 0
16019, 1.2833333333333, 0.96, 0
16020, 1.3, 0.96, 0
16021, 1.3166666666667, 0.96, 0
16022, 1.3333333333333, 0.96, 0
16023, 1.35, 0.96, 0
16024, 1.3666666666667, 0.96, 0
16025, 1.3833333333333, 0.96, 0
16026, 1.4, 0.96, 0
16027, 1.4166666666667, 0.96, 0
16028, 1.4333333333333, 0.96, 0
16029, 1.45, 0.96, 0
16030, 1.4666666666667, 0.96, 0
16031, 1.4833333333333, 0.96, 0
16032, 1.5, 0.96, 0
16033, 1.5166666666667, 0.96, 0
16034, 1.5333333333333, 0.96, 0
16035, 1.55, 0.96, 0
16036, 1.5666666666667, 0.96, 0
16037, 1.5833333333333, 0.96, 0
16038, 1.6, 0.96, 0
16039, 1.6166666666667, 0.96, 0
16040, 1.6333333333333, 0.96, 0
16041, 1.65, 0.96, 0
16042, 1.6666666666667, 0.96, 0
16043, 1.6833333333333, 0.96, 0
16044, 1.7, 0.96, 0
16045, 1.7166666666667, 0.96, 0
16046, 1.7333333333333, 0.96, 0
16047, 1.75, 0.96, 0
16048, 1.7666666666667, 0.96, 0
16049, 1.7833333333333, 0.96, 0
16050, 1.8, 0.96, 0
16051, 1.8166666666667, 0.96, 0
16052, 1.8333333333333, 0.96, 0
16053, 1.85, 0.96, 0
16054, 1.8666666666667, 0.96, 0
16055, 1.8833333333333, 0.96, 0
16056, 1.9, 0.96, 0
16057, 1.9166666666667, 0.96, 0
16058, 1.9333333333333, 0.96, 0
16059, 1.95, 0.96, 0
16060, 1.9666666666667, 0.96, 0
16061, 1.9833333333333, 0.96, 0
16062, 2, 0.96, 0
16063, 2.0166666666667, 0.96, 0
16064, 2.0333333333333, 0.96, 0
16065, 2.05, 0.96, 0
16066, 2.0666666666667, 0.96, 0
16067, 2.0833333333333, 0.96, 0
16068, 2.1, 0.96, 0
16069, 2.1166666666667, 0.96, 0
16070, 2.1333333333333, 0.96, 0
16071, 2.15, 0.96, 0
16072, 2.1666666666667, 0.96, 0
16073, 2.1833333333333, 0.96, 0
16074, 1.2166666666667, 0.94, 0
16075, 1.2333333333333, 0.94, 0
16076, 1.25, 0.94, 0
16077, 1.2666666666667, 0.94, 0
16078, 1.2833333333333, 0.94, 0
16079, 1.3, 0.94, 0
16080, 1.3166666666667, 0.94, 0
16081, 1.3333333333333, 0.94, 0
16082, 1.35, 0.94, 0
16083, 1.3666666666667, 0.94, 0
16084, 1.3833333333333, 0.94, 0
16085, 1.4, 0.94, 0
16086, 1.4166666666667, 0.94, 0
16087, 1.4333333333333, 0.94, 0
16088, 1.45, 0.94, 0
16089, 1.4666666666667, 0.94, 0
16090, 1.4833333333333, 0.94, 0
16091, 1.5, 0.94, 0
16092, 1.5166666666667, 0.94, 0
16093, 1.5333333333333, 0.94, 0
16094, 1.55, 0.94, 0
16095, 1.5666666666667, 0.94, 0
16096, 1.5833333333333, 0.94, 0
16097, 1.6, 0.94, 0
16098, 1.6166666666667, 0.94, 0
16099, 1.6333333333333, 0.94, 0
16100, 1.65, 0.94, 0
16101, 1.6666666666667, 0.94, 0
16102, 1.6833333333333, 0.94, 0
16103, 1.7, 0.94, 0
16104, 1.7166666666667, 0.94, 0
16105, 1.7333333333333, 0.94, 0
16106, 1.75, 0.94, 0
16107, 1.7666666666667, 0.94, 0
16108, 1.7833333333333, 0.94, 0
16109, 1.8, 0.94, 0
16110, 1.8166666666667, 0.94, 0
16111, 1.8333333333333, 0.94, 0
16112, 1.85, 0.94, 0
16113, 1.8666666666667, 0.94, 0
16114, 1.8833333333333, 0.94, 0
16115, 1.9, 0.94, 0
16116, 1.9166666666667, 0.94, 0
16117, 1.9333333333333, 0.94, 0
16118, 1.95, 0.94, 0
16119, 1.9666666666667, 0.94, 0
16120, 1.9833333333333, 0.94, 0
16121, 2, 0.94, 0
16122, 2.0166666666667, 0.94, 0
16123, 2.0333333333333, 0.94, 0
16124, 2.05, 0.94, 0
16125, 2.0666666666667, 0.94, 0
16126, 2.0833333333333, 0.94, 0
16127, 2.1, 0.94, 0
16128, 2.1166666666667, 0.94, 0
16129, 2.1333333333333, 0.94, 0
16130, 2.15, 0.94, 0
16131, 2.1666666666667, 0.94, 0
16132, 2.1833333333333, 0.94, 0
16133, 1.2166666666667, 0.92, 0
16134, 1.2333333333333, 0.92, 0
16135, 1.25, 0.92, 0
16136, 1.2666666666667, 0.92, 0
16137, 1.2833333333333, 0.92, 0
16138, 1.3, 0.92, 0
16139, 1.3166666666667, 0.92, 0
16140, 1.3333333333333, 0.92, 0
16141, 1.35, 0.92, 0
16142, 1.3666666666667, 0.92, 0
16143, 1.3833333333333, 0.92, 0
16144, 1.4, 0.92, 0
16145, 1.4166666666667, 0.92, 0
16146, 1.4333333333333, 0.92, 0
16147, 1.45, 0.92, 0
16148, 1.4666666666667, 0.92, 0
16149, 1.4833333333333, 0.92, 0
16150, 1.5, 0.92, 0
16151, 1.5166666666667, 0.92, 0
16152, 1.5333333333333, 0.92, 0
16153, 1.55, 0.92, 0
16154, 1.5666666666667, 0.92, 0
16155, 1.5833333333333, 0.92, 0
16156, 1.6, 0.92, 0
16157, 1.6166666666667, 0.92, 0
16158, 1.6333333333333, 0.92, 0
16159, 1.65, 0.92, 0
16160, 1.6666666666667, 0.92, 0
16161, 1.6833333333333, 0.92, 0
16162, 1.7, 0.92, 0
16163, 1.7166666666667, 0.92, 0
16164, 1.7333333333333, 0.92, 0
16165, 1.75, 0.92, 0
16166, 1.7666666666667, 0.92, 0
16167, 1.7833333333333, 0.92, 0
16168, 1.8, 0.92, 0
16169, 1.8166666666667, 0.92, 0
16170, 1.8333333333333, 0.92, 0
16171, 1.85, 0.92, 0
16172, 1.8666666666667, 0.92, 0
16173, 1.8833333333333, 0.92, 0
16174, 1.9, 0.92, 0
16175, 1.9166666666667, 0.92, 0
16176, 1.9333333333333, 0.92, 0
16177, 1.95, 0.92, 0
16178, 1.9666666666667, 0.92, 0
16179, 1.9833333333333, 0.92, 0
16180, 2, 0.92, 0
16181, 2.0166666666667, 0.92, 0
16182, 2.0333333333333, 0.92, 0
16183, 2.05, 0.92, 0
16184, 2.0666666666667, 0.92, 0
16185, 2.0833333333333, 0.92, 0
16186, 2.1, 0.92, 0
16187, 2.1166666666667, 0.92, 0
16188, 2.1333333333333, 0.92, 0
16189, 2.15, 0.92, 0
16190, 2.1666666666667, 0.92, 0
16191, 2.1833333333333, 0.92, 0
16192, 1.2166666666667, 0.9, 0
16193, 1.2333333333333, 0.9, 0
16194, 1.25, 0.9, 0
16195, 1.2666666666667, 0.9, 0
16196, 1.2833333333333, 0.9, 0
16197, 1.3, 0.9, 0
16198, 1.3166666666667, 0.9, 0
16199, 1.3333333333333, 0.9, 0
16200, 1.35, 0.9, 0
16201, 1.3666666666667, 0.9, 0
16202, 1.3833333333333, 0.9, 0
16203, 1.4, 0.9, 0
16204, 1.4166666666667, 0.9, 0
16205, 1.4333333333333, 0.9, 0
16206, 1.45, 0.9, 0
16207, 1.4666666666667, 0.9, 0
16208, 1.4833333333333, 0.9, 0
16209, 1.5, 0.9, 0
16210, 1.5166666666667, 0.9, 0
16211, 1.5333333333333, 0.9, 0
16212, 1.55, 0.9, 0
16213, 1.5666666666667, 0.9, 0
16214, 1.5833333333333, 0.9, 0
16215, 1.6, 0.9, 0
16216, 1.6166666666667, 0.9, 0
16217, 1.6333333333333, 0.9, 0
16218, 1.65, 0.9, 0
16219, 1.6666666666667, 0.9, 0
16220, 1.6833333333333, 0.9, 0
16221, 1.7, 0.9, 0
16222, 1.7166666666667, 0.9, 0
16223, 1.7333333333333, 0.9, 0
16224, 1.75, 0.9, 0
16225, 1.7666666666667, 0.9, 0
16226, 1.7833333333333, 0.9, 0
16227, 1.8, 0.9, 0
16228, 1.8166666666667, 0.9, 0
16229, 1.8333333333333, 0.9, 0
16230, 1.85, 0.9, 0
16231, 1.8666666666667, 0.9, 0
16232, 1.8833333333333, 0.9, 0
16233, 1.9, 0.9, 0
16234, 1.9166666666667, 0.9, 0
16235, 1.9333333333333, 0.9, 0
16236, 1.95, 0.9, 0
16237, 1.9666666666667, 0.9, 0
16238, 1.9833333333333, 0.9, 0
16239, 2, 0.9, 0
16240, 2.0166666666667, 0.9, 0
16241, 2.0333333333333, 0.9, 0
16242, 2.05, 0.9, 0
16243, 2.0666666666667, 0.9, 0
16244, 2.0833333333333, 0.9, 0
16245, 2.1, 0.9, 0
16246, 2.1166666666667, 0.9, 0
16247, 2.1333333333333, 0.9, 0
16248, 2.15, 0.9, 0
16249, 2.1666666666667, 0.9, 0
16250, 2.1833333333333, 0.9, 0
16251, 1.2166666666667, 0.88, 0
16252, 1.2333333333333, 0.88, 0
16253, 1.25, 0.88, 0
16254, 1.2666666666667, 0.88, 0
16255, 1.2833333333333, 0.88, 0
16256, 1.3, 0.88, 0
16257, 1.3166666666667, 0.88, 0
16258, 1.3333333333333, 0.88, 0
16259, 1.35, 0.88, 0
16260, 1.3666666666667, 0.88, 0
16261, 1.3833333333333, 0.88, 0
16262, 1.4, 0.88, 0
16263, 1.4166666666667, 0.88, 0
16264, 1.4333333333333, 0.88, 0
16265, 1.45, 0.88, 0
16266, 1.4666666666667, 0.88, 0
16267, 1.4833333333333, 0.88, 0
16268, 1.5, 0.88, 0
16269, 1.5166666666667, 0.88, 0
16270, 1.5333333333333, 0.88, 0
16271, 1.55, 0.88, 0
16272, 1.5666666666667, 0.88, 0
16273, 1.5833333333333, 0.88, 0
16274, 1.6, 0.88, 0
16275, 1.6166666666667, 0.88, 0
16276, 1.6333333333333, 0.88, 0
16277, 1.65, 0.88, 0
16278, 1.6666666666667, 0.88, 0
16279, 1.6833333333333, 0.88, 0
16280, 1.7, 0.88, 0
16281, 1.7166666666667, 0.88, 0
16282, 1.7333333333333, 0.88, 0
16283, 1.75, 0.88, 0
16284, 1.7666666666667, 0.88, 0
16285, 1.7833333333333, 0.88, 0
16286, 1.8, 0.88, 0
16287, 1.8166666666667, 0.88, 0
16288, 1.8333333333333, 0.88, 0
16289, 1.85, 0.88, 0
16290, 1.8666666666667, 0.88, 0
16291, 1.8833333333333, 0.88, 0
16292, 1.9, 0.88, 0
16293, 1.9166666666667, 0.88, 0
16294, 1.9333333333333, 0.88, 0
16295, 1.95, 0.88, 0
16296, 1.9666666666667, 0.88, 0
16297, 1.9833333333333, 0.88, 0
16298, 2, 0.88, 0
16299, 2.0166666666667, 0.88, 0
16300, 2.0333333333333, 0.88, 0
16301, 2.05, 0.88, 0
16302, 2.0666666666667, 0.88, 0
16303, 2.0833333333333, 0.88, 0
16304, 2.1, 0.88, 0
16305, 2.1166666666667, 0.88, 0
16306, 2.1333333333333, 0.88, 0
16307, 2.15, 0.88, 0
16308, 2.1666666666667, 0.88, 0
16309, 2.1833333333333, 0.88, 0
16310, 1.2166666666667, 0.86, 0
16311, 1.2333333333333, 0.86, 0
16312, 1.25, 0.86, 0
16313, 1.2666666666667, 0.86, 0
16314, 1.2833333333333, 0.86, 0
16315, 1.3, 0.86, 0
16316, 1.3166666666667, 0.86, 0
16317, 1.3333333333333, 0.86, 0
16318, 1.35, 0.86, 0
16319, 1.3666666666667, 0.86, 0
16320, 1.3833333333333, 0.86, 0
16321, 1.4, 0.86, 0
16322, 1.4166666666667, 0.86, 0
16323, 1.4333333333333, 0.86, 0
16324, 1.45, 0.86, 0
16325, 1.4666666666667, 0.86, 0
16326, 1.4833333333333, 0.86, 0
16327, 1.5, 0.86, 0
16328, 1.5166666666667, 0.86, 0
16329, 1.5333333333333, 0.86, 0
16330, 1.55, 0.86, 0
16331, 1.5666666666667, 0.86, 0
16332, 1.5833333333333, 0.86, 0
16333, 1.6, 0.86, 0
16334, 1.6166666666667, 0.86, 0
16335, 1.6333333333333, 0.86, 0
16336, 1.65, 0.86, 0
16337, 1.6666666666667, 0.86, 0
16338, 1.6833333333333, 0.86, 0
16339, 1.7, 0.86, 0
16340, 1.7166666666667, 0.86, 0
16341, 1.7333333333333, 0.86, 0
16342, 1.75, 0.86, 0
16343, 1.7666666666667, 0.86, 0
16344, 1.7833333333333, 0.86, 0
16345, 1.8, 0.86, 0
16346, 1.8166666666667, 0.86, 0
16347, 1.8333333333333, 0.86, 0
16348, 1.85, 0.86, 0
16349, 1.8666666666667, 0.86, 0
16350, 1.8833333333333, 0.86, 0
16351, 1.9, 0.86, 0
16352, 1.9166666666667, 0.86, 0
16353, 1.9333333333333, 0.86, 0
16354, 1.95, 0.86, 0
16355, 1.9666666666667, 0.86, 0
16356, 1.9833333333333, 0.86, 0
16357, 2, 0.86, 0
16358, 2.0166666666667, 0.86, 0
16359, 2.0333333333333, 0.86, 0
16360, 2.05, 0.86, 0
16361, 2.0666666666667, 0.86, 0
16362, 2.0833333333333, 0.86, 0
16363, 2.1, 0.86, 0
16364, 2.1166666666667, 0.86, 0
16365, 2.1333333333333, 0.86, 0
16366, 2.15, 0.86, 0
16367, 2.1666666666667, 0.86, 0
16368, 2.1833333333333, 0.86, 0
16369, 1.2166666666667, 0.84, 0
16370, 1.2333333333333, 0.84, 0
16371, 1.25, 0.84, 0
16372, 1.2666666666667, 0.84, 0
16373, 1.2833333333333, 0.84, 0
16374, 1.3, 0.84, 0
16375, 1.3166666666667, 0.84, 0
16376, 1.3333333333333, 0.84, 0
16377, 1.35, 0.84, 0
16378, 1.3666666666667, 0.84, 0
16379, 1.3833333333333, 0.84, 0
16380, 1.4, 0.84, 0
16381, 1.4166666666667, 0.84, 0
16382, 1.4333333333333, 0.84, 0
16383, 1.45, 0.84, 0
16384, 1.4666666666667, 0.84, 0
16385, 1.4833333333333, 0.84, 0
16386, 1.5, 0.84, 0
16387, 1.5166666666667, 0.84, 0
16388, 1.5333333333333, 0.84, 0
16389, 1.55, 0.84, 0
16390, 1.5666666666667, 0.84, 0
16391, 1.5833333333333, 0.84, 0
16392, 1.6, 0.84, 0
16393, 1.6166666666667, 0.84, 0
16394, 1.6333333333333, 0.84, 0
16395, 1.65, 0.84, 0
16396, 1.6666666666667, 0.84, 0
16397, 1.6833333333333, 0.84, 0
16398, 1.7, 0.84, 0
16399, 1.7166666666667, 0.84, 0
16400, 1.7333333333333, 0.84, 0
16401, 1.75, 0.84, 0
16402, 1.7666666666667, 0.84, 0
16403, 1.7833333333333, 0.84, 0
16404, 1.8, 0.84, 0
16405, 1.8166666666667, 0.84, 0
16406, 1.8333333333333, 0.84, 0
16407, 1.85, 0.84, 0
16408, 1.8666666666667, 0.84, 0
16409, 1.8833333333333, 0.84, 0
16410, 1.9, 0.84, 0
16411, 1.9166666666667, 0.84, 0
16412, 1.9333333333333, 0.84, 0
16413, 1.95, 0.84, 0
16414, 1.9666666666667, 0.84, 0
16415, 1.9833333333333, 0.84, 0
16416, 2, 0.84, 0
16417, 2.0166666666667, 0.84, 0
16418, 2.0333333333333, 0.84, 0
16419, 2.05, 0.84, 0
16420, 2.0666666666667, 0.84, 0
16421, 2.0833333333333, 0.84, 0
16422, 2.1, 0.84, 0
16423, 2.1166666666667, 0.84, 0
16424, 2.1333333333333, 0.84, 0
16425, 2.15, 0.84, 0
16426, 2.1666666666667, 0.84, 0
16427, 2.1833333333333, 0.84, 0
16428, 1.2166666666667, 0.82, 0
16429, 1.2333333333333, 0.82, 0
16430, 1.25, 0.82, 0
16431, 1.2666666666667, 0.82, 0
16432, 1.2833333333333, 0.82, 0
16433, 1.3, 0.82, 0
16434, 1.3166666666667, 0.82, 0
16435, 1.3333333333333, 0.82, 0
16436, 1.35, 0.82, 0
16437, 1.3666666666667, 0.82, 0
16438, 1.3833333333333, 0.82, 0
16439, 1.4, 0.82, 0
16440, 1.4166666666667, 0.82, 0
16441, 1.4333333333333, 0.82, 0
16442, 1.45, 0.82, 0
16443, 1.4666666666667, 0.82, 0
16444, 1.4833333333333, 0.82, 0
16445, 1.5, 0.82, 0
16446, 1.5166666666667, 0.82, 0
16447, 1.5333333333333, 0.82, 0
16448, 1.55, 0.82, 0
16449, 1.5666666666667, 0.82, 0
16450, 1.5833333333333, 0.82, 0
16451, 1.6, 0.82, 0
16452, 1.6166666666667, 0.82, 0
16453, 1.6333333333333, 0.82, 0
16454, 1.65, 0.82, 0
16455, 1.6666666666667, 0.82, 0
16456, 1.6833333333333, 0.82, 0
16457, 1.7, 0.82, 0
16458, 1.7166666666667, 0.82, 0
16459, 1.7333333333333, 0.82, 0
16460, 1.75, 0.82, 0
16461, 1.7666666666667, 0.82, 0
16462, 1.7833333333333, 0.82, 0
16463, 1.8, 0.82, 0
16464, 1.8166666666667, 0.82, 0
16465, 1.8333333333333, 0.82, 0
16466, 1.85, 0.82, 0
16467, 1.8666666666667, 0.82, 0
16468, 1.8833333333333, 0.82, 0
16469, 1.9, 0.82, 0
16470, 1.9166666666667, 0.82, 0
16471, 1.9333333333333, 0.82, 0
16472, 1.95, 0.82, 0
16473, 1.9666666666667, 0.82, 0
16474, 1.9833333333333, 0.82, 0
16475, 2, 0.82, 0
16476, 2.0166666666667, 0.82, 0
16477, 2.0333333333333, 0.82, 0
16478, 2.05, 0.82, 0
16479, 2.0666666666667, 0.82, 0
16480, 2.0833333333333, 0.82, 0
16481, 2.1, 0.82, 0
16482, 2.1166666666667, 0.82, 0
16483, 2.1333333333333, 0.82, 0
16484, 2.15, 0.82, 0
16485, 2.1666666666667, 0.82, 0
16486, 2.1833333333333, 0.82, 0
16487, 1.2166666666667, 0.8, 0
16488, 1.2333333333333, 0.8, 0
16489, 1.25, 0.8, 0
16490, 1.2666666666667, 0.8, 0
16491, 1.2833333333333, 0.8, 0
16492, 1.3, 0.8, 0
16493, 1.3166666666667, 0.8, 0
16494, 1.3333333333333, 0.8, 0
16495, 1.35, 0.8, 0
16496, 1.3666666666667, 0.8, 0
16497, 1.3833333333333, 0.8, 0
16498, 1.4, 0.8, 0
16499, 1.4166666666667, 0.8, 0
16500, 1.4333333333333, 0.8, 0
16501, 1.45, 0.8, 0
16502, 1.4666666666667, 0.8, 0
16503, 1.4833333333333, 0.8, 0
16504, 1.5, 0.8, 0
16505, 1.5166666666667, 0.8, 0
16506, 1.5333333333333, 0.8, 0
16507, 1.55, 0.8, 0
16508, 1.5666666666667, 0.8, 0
16509, 1.5833333333333, 0.8, 0
16510, 1.6, 0.8, 0
16511, 1.6166666666667, 0.8, 0
16512, 1.6333333333333, 0.8, 0
16513, 1.65, 0.8, 0
16514, 1.6666666666667, 0.8, 0
16515, 1.6833333333333, 0.8, 0
16516, 1.7, 0.8, 0
16517, 1.7166666666667, 0.8, 0
16518, 1.7333333333333, 0.8, 0
16519, 1.75, 0.8, 0
16520, 1.7666666666667, 0.8, 0
16521, 1.7833333333333, 0.8, 0
16522, 1.8, 0.8, 0
16523, 1.8166666666667, 0.8, 0
16524, 1.8333333333333, 0.8, 0
16525, 1.85, 0.8, 0
16526, 1.8666666666667, 0.8, 0
16527, 1.8833333333333, 0.8, 0
16528, 1.9, 0.8, 0
16529, 1.9166666666667, 0.8, 0
16530, 1.9333333333333, 0.8, 0
16531, 1.95, 0.8, 0
16532, 1.9666666666667, 0.8, 0
16533, 1.9833333333333, 0.8, 0
16534, 2, 0.8, 0
16535, 2.0166666666667, 0.8, 0
16536, 2.0333333333333, 0.8, 0
16537, 2.05, 0.8, 0
16538, 2.0666666666667, 0.8, 0
16539, 2.0833333333333, 0.8, 0
16540, 2.1, 0.8, 0
16541, 2.1166666666667, 0.8, 0
16542, 2.1333333333333, 0.8, 0
16543, 2.15, 0.8, 0
16544, 2.1666666666667, 0.8, 0
16545, 2.1833333333333, 0.8, 0
16546, 1.2166666666667, 0.78, 0
16547, 1.2333333333333, 0.78, 0
16548, 1.25, 0.78, 0
16549, 1.2666666666667, 0.78, 0
16550, 1.2833333333333, 0.78, 0
16551, 1.3, 0.78, 0
16552, 1.3166666666667, 0.78, 0
16553, 1.3333333333333, 0.78, 0
16554, 1.35, 0.78, 0
16555, 1.3666666666667, 0.78, 0
16556, 1.3833333333333, 0.78, 0
16557, 1.4, 0.78, 0
16558, 1.4166666666667, 0.78, 0
16559, 1.4333333333333, 0.78, 0
16560, 1.45, 0.78, 0
16561, 1.4666666666667, 0.78, 0
16562, 1.4833333333333, 0.78, 0
16563, 1.5, 0.78, 0
16564, 1.5166666666667, 0.78, 0
16565, 1.5333333333333, 0.78, 0
16566, 1.55, 0.78, 0
16567, 1.5666666666667, 0.78, 0
16568, 1.5833333333333, 0.78, 0
16569, 1.6, 0.78, 0
16570, 1.6166666666667, 0.78, 0
16571, 1.6333333333333, 0.78, 0
16572, 1.65, 0.78, 0
16573, 1.6666666666667, 0.78, 0
16574, 1.6833333333333, 0.78, 0
16575, 1.7, 0.78, 0
16576, 1.7166666666667, 0.78, 0
16577, 1.7333333333333, 0.78, 0
16578, 1.75, 0.78, 0
16579, 1.7666666666667, 0.78, 0
16580, 1.7833333333333, 0.78, 0
16581, 1.8, 0.78, 0
16582, 1.8166666666667, 0.78, 0
16583, 1.8333333333333, 0.78, 0
16584, 1.85, 0.78, 0
16585, 1.8666666666667, 0.78, 0
16586, 1.8833333333333, 0.78, 0
16587, 1.9, 0.78, 0
16588, 1.9166666666667, 0.78, 0
16589, 1.9333333333333, 0.78, 0
16590, 1.95, 0.78, 0
16591, 1.9666666666667, 0.78, 0
16592, 1.9833333333333, 0.78, 0
16593, 2, 0.78, 0
16594, 2.0166666666667, 0.78, 0
16595, 2.0333333333333, 0.78, 0
16596, 2.05, 0.78, 0
16597, 2.0666666666667, 0.78, 0
16598, 2.0833333333333, 0.78, 0
16599, 2.1, 0.78, 0
16600, 2.1166666666667, 0.78, 0
16601, 2.1333333333333, 0.78, 0
16602, 2.15, 0.78, 0
16603, 2.1666666666667, 0.78, 0
16604, 2.1833333333333, 0.78, 0
16605, 1.2166666666667, 0.76, 0
16606, 1.2333333333333, 0.76, 0
16607, 1.25, 0.76, 0
16608, 1.2666666666667, 0.76, 0
16609, 1.2833333333333, 0.76, 0
16610, 1.3, 0.76, 0
16611, 1.3166666666667, 0.76, 0
16612, 1.3333333333333, 0.76, 0
16613, 1.35, 0.76, 0
16614, 1.3666666666667, 0.76, 0
16615, 1.3833333333333, 0.76, 0
16616, 1.4, 0.76, 0
16617, 1.4166666666667, 0.76, 0
16618, 1.4333333333333, 0.76, 0
16619, 1.45, 0.76, 0
16620, 1.4666666666667, 0.76, 0
16621, 1.4833333333333, 0.76, 0
16622, 1.5, 0.76, 0
16623, 1.5166666666667, 0.76, 0
16624, 1.5333333333333, 0.76, 0
16625, 1.55, 0.76, 0
16626, 1.5666666666667, 0.76, 0
16627, 1.5833333333333, 0.76, 0
16628, 1.6, 0.76, 0
16629, 1.6166666666667, 0.76, 0
16630, 1.6333333333333, 0.76, 0
16631, 1.65, 0.76, 0
16632, 1.6666666666667, 0.76, 0
16633, 1.6833333333333, 0.76, 0
16634, 1.7, 0.76, 0
16635, 1.7166666666667, 0.76, 0
16636, 1.7333333333333, 0.76, 0
16637, 1.75, 0.76, 0
16638, 1.7666666666667, 0.76, 0
16639, 1.7833333333333, 0.76, 0
16640, 1.8, 0.76, 0
16641, 1.8166666666667, 0.76, 0
16642, 1.8333333333333, 0.76, 0
16643, 1.85, 0.76, 0
16644, 1.8666666666667, 0.76, 0
16645, 1.8833333333333, 0.76, 0
16646, 1.9, 0.76, 0
16647, 1.9166666666667, 0.76, 0
16648, 1.9333333333333, 0.76, 0
16649, 1.95, 0.76, 0
16650, 1.9666666666667, 0.76, 0
16651, 1.9833333333333, 0.76, 0
16652, 2, 0.76, 0
16653, 2.0166666666667, 0.76, 0
16654, 2.0333333333333, 0.76, 0
16655, 2.05, 0.76, 0
16656, 2.0666666666667, 0.76, 0
16657, 2.0833333333333, 0.76, 0
16658, 2.1, 0.76, 0
16659, 2.1166666666667, 0.76, 0
16660, 2.1333333333333, 0.76, 0
16661, 2.15, 0.76, 0
16662, 2.1666666666667, 0.76, 0
16663, 2.1833333333333, 0.76, 0
16664, 1.2166666666667, 0.74, 0
16665, 1.2333333333333, 0.74, 0
16666, 1.25, 0.74, 0
16667, 1.2666666666667, 0.74, 0
16668, 1.2833333333333, 0.74, 0
16669, 1.3, 0.74, 0
16670, 1.3166666666667, 0.74, 0
16671, 1.3333333333333, 0.74, 0
16672, 1.35, 0.74, 0
16673, 1.3666666666667, 0.74, 0
16674, 1.3833333333333, 0.74, 0
16675, 1.4, 0.74, 0
16676, 1.4166666666667, 0.74, 0
16677, 1.4333333333333, 0.74, 0
16678, 1.45, 0.74, 0
16679, 1.4666666666667, 0.74, 0
16680, 1.4833333333333, 0.74, 0
16681, 1.5, 0.74, 0
16682, 1.5166666666667, 0.74, 0
16683, 1.5333333333333, 0.74, 0
16684, 1.55, 0.74, 0
16685, 1.5666666666667, 0.74, 0
16686, 1.5833333333333, 0.74, 0
16687, 1.6, 0.74, 0
16688, 1.6166666666667, 0.74, 0
16689, 1.6333333333333, 0.74, 0
16690, 1.65, 0.74, 0
16691, 1.6666666666667, 0.74, 0
16692, 1.6833333333333, 0.74, 0
16693, 1.7, 0.74, 0
16694, 1.7166666666667, 0.74, 0
16695, 1.7333333333333, 0.74, 0
16696, 1.75, 0.74, 0
16697, 1.7666666666667, 0.74, 0
16698, 1.7833333333333, 0.74, 0
16699, 1.8, 0.74, 0
16700, 1.8166666666667, 0.74, 0
16701, 1.8333333333333, 0.74, 0
16702, 1.85, 0.74, 0
16703, 1.8666666666667, 0.74, 0
16704, 1.8833333333333, 0.74, 0
16705, 1.9, 0.74, 0
16706, 1.9166666666667, 0.74, 0
16707, 1.9333333333333, 0.74, 0
16708, 1.95, 0.74, 0
16709, 1.9666666666667, 0.74, 0
16710, 1.9833333333333, 0.74, 0
16711, 2, 0.74, 0
16712, 2.0166666666667, 0.74, 0
16713, 2.0333333333333, 0.74, 0
16714, 2.05, 0.74, 0
16715, 2.0666666666667, 0.74, 0
16716, 2.0833333333333, 0.74, 0
16717, 2.1, 0.74, 0
16718, 2.1166666666667, 0.74, 0
16719, 2.1333333333333, 0.74, 0
16720, 2.15, 0.74, 0
16721, 2.1666666666667, 0.74, 0
16722, 2.1833333333333, 0.74, 0
16723, 1.2166666666667, 0.72, 0
16724, 1.2333333333333, 0.72, 0
16725, 1.25, 0.72, 0
16726, 1.2666666666667, 0.72, 0
16727, 1.2833333333333, 0.72, 0
16728, 1.3, 0.72, 0
16729, 1.3166666666667, 0.72, 0
16730, 1.3333333333333, 0.72, 0
16731, 1.35, 0.72, 0
16732, 1.3666666666667, 0.72, 0
16733, 1.3833333333333, 0.72, 0
16734, 1.4, 0.72, 0
16735, 1.4166666666667, 0.72, 0
16736, 1.4333333333333, 0.72, 0
16737, 1.45, 0.72, 0
16738, 1.4666666666667, 0.72, 0
16739, 1.4833333333333, 0.72, 0
16740, 1.5, 0.72, 0
16741, 1.5166666666667, 0.72, 0
16742, 1.5333333333333, 0.72, 0
16743, 1.55, 0.72, 0
16744, 1.5666666666667, 0.72, 0
16745, 1.5833333333333, 0.72, 0
16746, 1.6, 0.72, 0
16747, 1.6166666666667, 0.72, 0
16748, 1.6333333333333, 0.72, 0
16749, 1.65, 0.72, 0
16750, 1.6666666666667, 0.72, 0
16751, 1.6833333333333, 0.72, 0
16752, 1.7, 0.72, 0
16753, 1.7166666666667, 0.72, 0
16754, 1.7333333333333, 0.72, 0
16755, 1.75, 0.72, 0
16756, 1.7666666666667, 0.72, 0
16757, 1.7833333333333, 0.72, 0
16758, 1.8, 0.72, 0
16759, 1.8166666666667, 0.72, 0
16760, 1.8333333333333, 0.72, 0
16761, 1.85, 0.72, 0
16762, 1.8666666666667, 0.72, 0
16763, 1.8833333333333, 0.72, 0
16764, 1.9, 0.72, 0
16765, 1.9166666666667, 0.72, 0
16766, 1.9333333333333, 0.72, 0
16767, 1.95, 0.72, 0
16768, 1.9666666666667, 0.72, 0
16769, 1.9833333333333, 0.72, 0
16770, 2, 0.72, 0
16771, 2.0166666666667, 0.72, 0
16772, 2.0333333333333, 0.72, 0
16773, 2.05, 0.72, 0
16774, 2.0666666666667, 0.72, 0
16775, 2.0833333333333, 0.72, 0
16776, 2.1, 0.72, 0
16777, 2.1166666666667, 0.72, 0
16778, 2.1333333333333, 0.72, 0
16779, 2.15, 0.72, 0
16780, 2.1666666666667, 0.72, 0
16781, 2.1833333333333, 0.72, 0
16782, 1.2166666666667, 0.7, 0
16783, 1.2333333333333, 0.7, 0
16784, 1.25, 0.7, 0
16785, 1.2666666666667, 0.7, 0
16786, 1.2833333333333, 0.7, 0
16787, 1.3, 0.7, 0
16788, 1.3166666666667, 0.7, 0
16789, 1.3333333333333, 0.7, 0
16790, 1.35, 0.7, 0
16791, 1.3666666666667, 0.7, 0
16792, 1.3833333333333, 0.7, 0
16793, 1.4, 0.7, 0
16794, 1.4166666666667, 0.7, 0
16795, 1.4333333333333, 0.7, 0
16796, 1.45, 0.7, 0
16797, 1.4666666666667, 0.7, 0
16798, 1.4833333333333, 0.7, 0
16799, 1.5, 0.7, 0
16800, 1.5166666666667, 0.7, 0
16801, 1.5333333333333, 0.7, 0
16802, 1.55, 0.7, 0
16803, 1.5666666666667, 0.7, 0
16804, 1.5833333333333, 0.7, 0
16805, 1.6, 0.7, 0
16806, 1.6166666666667, 0.7, 0
16807, 1.6333333333333, 0.7, 0
16808, 1.65, 0.7, 0
16809, 1.6666666666667, 0.7, 0
16810, 1.6833333333333, 0.7, 0
16811, 1.7, 0.7, 0
16812, 1.7166666666667, 0.7, 0
16813, 1.7333333333333, 0.7, 0
16814, 1.75, 0.7, 0
16815, 1.7666666666667, 0.7, 0
16816, 1.7833333333333, 0.7, 0
16817, 1.8, 0.7, 0
16818, 1.8166666666667, 0.7, 0
16819, 1.8333333333333, 0.7, 0
16820, 1.85, 0.7, 0
16821, 1.8666666666667, 0.7, 0
16822, 1.8833333333333, 0.7, 0
16823, 1.9, 0.7, 0
16824, 1.9166666666667, 0.7, 0
16825, 1.9333333333333, 0.7, 0
16826, 1.95, 0.7, 0
16827, 1.9666666666667, 0.7, 0
16828, 1.9833333333333, 0.7, 0
16829, 2, 0.7, 0
16830, 2.0166666666667, 0.7, 0
16831, 2.0333333333333, 0.7, 0
16832, 2.05, 0.7, 0
16833, 2.0666666666667, 0.7, 0
16834, 2.0833333333333, 0.7, 0
16835, 2.1, 0.7, 0
16836, 2.1166666666667, 0.7, 0
16837, 2.1333333333333, 0.7, 0
16838, 2.15, 0.7, 0
16839, 2.1666666666667, 0.7, 0
16840, 2.1833333333333, 0.7, 0
16841, 1.2166666666667, 0.68, 0
16842, 1.2333333333333, 0.68, 0
16843, 1.25, 0.68, 0
16844, 1.2666666666667, 0.68, 0
16845, 1.2833333333333, 0.68, 0
16846, 1.3, 0.68, 0
16847, 1.3166666666667, 0.68, 0
16848, 1.3333333333333, 0.68, 0
16849, 1.35, 0.68, 0
16850, 1.3666666666667, 0.68, 0
16851, 1.3833333333333, 0.68, 0
16852, 1.4, 0.68, 0
16853, 1.4166666666667, 0.68, 0
16854, 1.4333333333333, 0.68, 0
16855, 1.45, 0.68, 0
16856, 1.4666666666667, 0.68, 0
16857, 1.4833333333333, 0.68, 0
16858, 1.5, 0.68, 0
16859, 1.5166666666667, 0.68, 0
16860, 1.5333333333333, 0.68, 0
16861, 1.55, 0.68, 0
16862, 1.5666666666667, 0.68, 0
16863, 1.5833333333333, 0.68, 0
16864, 1.6, 0.68, 0
16865, 1.6166666666667, 0.68, 0
16866, 1.6333333333333, 0.68, 0
16867, 1.65, 0.68, 0
16868, 1.6666666666667, 0.68, 0
16869, 1.6833333333333, 0.68, 0
16870, 1.7, 0.68, 0
16871, 1.7166666666667, 0.68, 0
16872, 1.7333333333333, 0.68, 0
16873, 1.75, 0.68, 0
16874, 1.7666666666667, 0.68, 0
16875, 1.7833333333333, 0.68, 0
16876, 1.8, 0.68, 0
16877, 1.8166666666667, 0.68, 0
16878, 1.8333333333333, 0.68, 0
16879, 1.85, 0.68, 0
16880, 1.8666666666667, 0.68, 0
16881, 1.8833333333333, 0.68, 0
16882, 1.9, 0.68, 0
16883, 1.9166666666667, 0.68, 0
16884, 1.9333333333333, 0.68, 0
16885, 1.95, 0.68, 0
16886, 1.9666666666667, 0.68, 0
16887, 1.9833333333333, 0.68, 0
16888, 2, 0.68, 0
16889, 2.0166666666667, 0.68, 0
16890, 2.0333333333333, 0.68, 0
16891, 2.05, 0.68, 0
16892, 2.0666666666667, 0.68, 0
16893, 2.0833333333333, 0.68, 0
16894, 2.1, 0.68, 0
16895, 2.1166666666667, 0.68, 0
16896, 2.1333333333333, 0.68, 0
16897, 2.15, 0.68, 0
16898, 2.1666666666667, 0.68, 0
16899, 2.1833333333333, 0.68, 0
16900, 1.2166666666667, 0.66, 0
16901, 1.2333333333333, 0.66, 0
16902, 1.25, 0.66, 0
16903, 1.2666666666667, 0.66, 0
16904, 1.2833333333333, 0.66, 0
16905, 1.3, 0.66, 0
16906, 1.3166666666667, 0.66, 0
16907, 1.3333333333333, 0.66, 0
16908, 1.35, 0.66, 0
16909, 1.3666666666667, 0.66, 0
16910, 1.3833333333333, 0.66, 0
16911, 1.4, 0.66, 0
16912, 1.4166666666667, 0.66, 0
16913, 1.4333333333333, 0.66, 0
16914, 1.45, 0.66, 0
16915, 1.4666666666667, 0.66, 0
16916, 1.4833333333333, 0.66, 0
16917, 1.5, 0.66, 0
16918, 1.5166666666667, 0.66, 0
16919, 1.5333333333333, 0.66, 0
16920, 1.55, 0.66, 0
16921, 1.5666666666667, 0.66, 0
16922, 1.5833333333333, 0.66, 0
16923, 1.6, 0.66, 0
16924, 1.6166666666667, 0.66, 0
16925, 1.6333333333333, 0.66, 0
16926, 1.65, 0.66, 0
16927, 1.6666666666667, 0.66, 0
16928, 1.6833333333333, 0.66, 0
16929, 1.7, 0.66, 0
16930, 1.7166666666667, 0.66, 0
16931, 1.7333333333333, 0.66, 0
16932, 1.75, 0.66, 0
16933, 1.7666666666667, 0.66, 0
16934, 1.7833333333333, 0.66, 0
16935, 1.8, 0.66, 0
16936, 1.8166666666667, 0.66, 0
16937, 1.8333333333333, 0.66, 0
16938, 1.85, 0.66, 0
16939, 1.8666666666667, 0.66, 0
16940, 1.8833333333333, 0.66, 0
16941, 1.9, 0.66, 0
16942, 1.9166666666667, 0.66, 0
16943, 1.9333333333333, 0.66, 0
16944, 1.95, 0.66, 0
16945, 1.9666666666667, 0.66, 0
16946, 1.9833333333333, 0.66, 0
16947, 2, 0.66, 0
16948, 2.0166666666667, 0.66, 0
16949, 2.0333333333333, 0.66, 0
16950, 2.05, 0.66, 0
16951, 2.0666666666667, 0.66, 0
16952, 2.0833333333333, 0.66, 0
16953, 2.1, 0.66, 0
16954, 2.1166666666667, 0.66, 0
16955, 2.1333333333333, 0.66, 0
16956, 2.15, 0.66, 0
16957, 2.1666666666667, 0.66, 0
16958, 2.1833333333333, 0.66, 0
16959, 1.2166666666667, 0.64, 0
16960, 1.2333333333333, 0.64, 0
16961, 1.25, 0.64, 0
16962, 1.2666666666667, 0.64, 0
16963, 1.2833333333333, 0.64, 0
16964, 1.3, 0.64, 0
16965, 1.3166666666667, 0.64, 0
16966, 1.3333333333333, 0.64, 0
16967, 1.35, 0.64, 0
16968, 1.3666666666667, 0.64, 0
16969, 1.3833333333333, 0.64, 0
16970, 1.4, 0.64, 0
16971, 1.4166666666667, 0.64, 0
16972, 1.4333333333333, 0.64, 0
16973, 1.45, 0.64, 0
16974, 1.4666666666667, 0.64, 0
16975, 1.4833333333333, 0.64, 0
16976, 1.5, 0.64, 0
16977, 1.5166666666667, 0.64, 0
16978, 1.5333333333333, 0.64, 0
16979, 1.55, 0.64, 0
16980, 1.5666666666667, 0.64, 0
16981, 1.5833333333333, 0.64, 0
16982, 1.6, 0.64, 0
16983, 1.6166666666667, 0.64, 0
16984, 1.6333333333333, 0.64, 0
16985, 1.65, 0.64, 0
16986, 1.6666666666667, 0.64, 0
16987, 1.6833333333333, 0.64, 0
16988, 1.7, 0.64, 0
16989, 1.7166666666667, 0.64, 0
16990, 1.7333333333333, 0.64, 0
16991, 1.75, 0.64, 0
16992, 1.7666666666667, 0.64, 0
16993, 1.7833333333333, 0.64, 0
16994, 1.8, 0.64, 0
16995, 1.8166666666667, 0.64, 0
16996, 1.8333333333333, 0.64, 0
16997, 1.85, 0.64, 0
16998, 1.8666666666667, 0.64, 0
16999, 1.8833333333333, 0.64, 0
17000, 1.9, 0.64, 0
17001, 1.9166666666667, 0.64, 0
17002, 1.9333333333333, 0.64, 0
17003, 1.95, 0.64, 0
17004, 1.9666666666667, 0.64, 0
17005, 1.9833333333333, 0.64, 0
17006, 2, 0.64, 0
17007, 2.0166666666667, 0.64, 0
17008, 2.0333333333333, 0.64, 0
17009, 2.05, 0.64, 0
17010, 2.0666666666667, 0.64, 0
17011, 2.0833333333333, 0.64, 0
17012, 2.1, 0.64, 0
17013, 2.1166666666667, 0.64, 0
17014, 2.1333333333333, 0.64, 0
17015, 2.15, 0.64, 0
17016, 2.1666666666667, 0.64, 0
17017, 2.1833333333333, 0.64, 0
17018, 1.2166666666667, 0.62, 0
17019, 1.2333333333333, 0.62, 0
17020, 1.25, 0.62, 0
17021, 1.2666666666667, 0.62, 0
17022, 1.2833333333333, 0.62, 0
17023, 1.3, 0.62, 0
17024, 1.3166666666667, 0.62, 0
17025, 1.3333333333333, 0.62, 0
17026, 1.35, 0.62, 0
17027, 1.3666666666667, 0.62, 0
17028, 1.3833333333333, 0.62, 0
17029, 1.4, 0.62, 0
17030, 1.4166666666667, 0.62, 0
17031, 1.4333333333333, 0.62, 0
17032, 1.45, 0.62, 0
17033, 1.4666666666667, 0.62, 0
17034, 1.4833333333333, 0.62, 0
17035, 1.5, 0.62, 0
17036, 1.5166666666667, 0.62, 0
17037, 1.5333333333333, 0.62, 0
17038, 1.55, 0.62, 0
17039, 1.5666666666667, 0.62, 0
17040, 1.5833333333333, 0.62, 0
17041, 1.6, 0.62, 0
17042, 1.6166666666667, 0.62, 0
17043, 1.6333333333333, 0.62, 0
17044, 1.65, 0.62, 0
17045, 1.6666666666667, 0.62, 0
17046, 1.6833333333333, 0.62, 0
17047, 1.7, 0.62, 0
17048, 1.7166666666667, 0.62, 0
17049, 1.7333333333333, 0.62, 0
17050, 1.75, 0.62, 0
17051, 1.7666666666667, 0.62, 0
17052, 1.7833333333333, 0.62, 0
17053, 1.8, 0.62, 0
17054, 1.8166666666667, 0.62, 0
17055, 1.8333333333333, 0.62, 0
17056, 1.85, 0.62, 0
17057, 1.8666666666667, 0.62, 0
17058, 1.8833333333333, 0.62, 0
17059, 1.9, 0.62, 0
17060, 1.9166666666667, 0.62, 0
17061, 1.9333333333333, 0.62, 0
17062, 1.95, 0.62, 0
17063, 1.9666666666667, 0.62, 0
17064, 1.9833333333333, 0.62, 0
17065, 2, 0.62, 0
17066, 2.0166666666667, 0.62, 0
17067, 2.0333333333333, 0.62, 0
17068, 2.05, 0.62, 0
17069, 2.0666666666667, 0.62, 0
17070, 2.0833333333333, 0.62, 0
17071, 2.1, 0.62, 0
17072, 2.1166666666667, 0.62, 0
17073, 2.1333333333333, 0.62, 0
17074, 2.15, 0.62, 0
17075, 2.1666666666667, 0.62, 0
17076, 2.1833333333333, 0.62, 0
17077, 1.2166666666667, 0.6, 0
17078, 1.2333333333333, 0.6, 0
17079, 1.25, 0.6, 0
17080, 1.2666666666667, 0.6, 0
17081, 1.2833333333333, 0.6, 0
17082, 1.3, 0.6, 0
17083, 1.3166666666667, 0.6, 0
17084, 1.3333333333333, 0.6, 0
17085, 1.35, 0.6, 0
17086, 1.3666666666667, 0.6, 0
17087, 1.3833333333333, 0.6, 0
17088, 1.4, 0.6, 0
17089, 1.4166666666667, 0.6, 0
17090, 1.4333333333333, 0.6, 0
17091, 1.45, 0.6, 0
17092, 1.4666666666667, 0.6, 0
17093, 1.4833333333333, 0.6, 0
17094, 1.5, 0.6, 0
17095, 1.5166666666667, 0.6, 0
17096, 1.5333333333333, 0.6, 0
17097, 1.55, 0.6, 0
17098, 1.5666666666667, 0.6, 0
17099, 1.5833333333333, 0.6, 0
17100, 1.6, 0.6, 0
17101, 1.6166666666667, 0.6, 0
17102, 1.6333333333333, 0.6, 0
17103, 1.65, 0.6, 0
17104, 1.6666666666667, 0.6, 0
17105, 1.6833333333333, 0.6, 0
17106, 1.7, 0.6, 0
17107, 1.7166666666667, 0.6, 0
17108, 1.7333333333333, 0.6, 0
17109, 1.75, 0.6, 0
17110, 1.7666666666667, 0.6, 0
17111, 1.7833333333333, 0.6, 0
17112, 1.8, 0.6, 0
17113, 1.8166666666667, 0.6, 0
17114, 1.8333333333333, 0.6, 0
17115, 1.85, 0.6, 0
17116, 1.8666666666667, 0.6, 0
17117, 1.8833333333333, 0.6, 0
17118, 1.9, 0.6, 0
17119, 1.9166666666667, 0.6, 0
17120, 1.9333333333333, 0.6, 0
17121, 1.95, 0.6, 0
17122, 1.9666666666667, 0.6, 0
17123, 1.9833333333333, 0.6, 0
17124, 2, 0.6, 0
17125, 2.0166666666667, 0.6, 0
17126, 2.0333333333333, 0.6, 0
17127, 2.05, 0.6, 0
17128, 2.0666666666667, 0.6, 0
17129, 2.0833333333333, 0.6, 0
17130, 2.1, 0.6, 0
17131, 2.1166666666667, 0.6, 0
17132, 2.1333333333333, 0.6, 0
17133, 2.15, 0.6, 0
17134, 2.1666666666667, 0.6, 0
17135, 2.1833333333333, 0.6, 0
17136, 1.2166666666667, 0.58, 0
17137, 1.2333333333333, 0.58, 0
17138, 1.25, 0.58, 0
17139, 1.2666666666667, 0.58, 0
17140, 1.2833333333333, 0.58, 0
17141, 1.3, 0.58, 0
17142, 1.3166666666667, 0.58, 0
17143, 1.3333333333333, 0.58, 0
17144, 1.35, 0.58, 0
17145, 1.3666666666667, 0.58, 0
17146, 1.3833333333333, 0.58, 0
17147, 1.4, 0.58, 0
17148, 1.4166666666667, 0.58, 0
17149, 1.4333333333333, 0.58, 0
17150, 1.45, 0.58, 0
17151, 1.4666666666667, 0.58, 0
17152, 1.4833333333333, 0.58, 0
17153, 1.5, 0.58, 0
17154, 1.5166666666667, 0.58, 0
17155, 1.5333333333333, 0.58, 0
17156, 1.55, 0.58, 0
17157, 1.5666666666667, 0.58, 0
17158, 1.5833333333333, 0.58, 0
17159, 1.6, 0.58, 0
17160, 1.6166666666667, 0.58, 0
17161, 1.6333333333333, 0.58, 0
17162, 1.65, 0.58, 0
17163, 1.6666666666667, 0.58, 0
17164, 1.6833333333333, 0.58, 0
17165, 1.7, 0.58, 0
17166, 1.7166666666667, 0.58, 0
17167, 1.7333333333333, 0.58, 0
17168, 1.75, 0.58, 0
17169, 1.7666666666667, 0.58, 0
17170, 1.7833333333333, 0.58, 0
17171, 1.8, 0.58, 0
17172, 1.8166666666667, 0.58, 0
17173, 1.8333333333333, 0.58, 0
17174, 1.85, 0.58, 0
17175, 1.8666666666667, 0.58, 0
17176, 1.8833333333333, 0.58, 0
17177, 1.9, 0.58, 0
17178, 1.9166666666667, 0.58, 0
17179, 1.9333333333333, 0.58, 0
17180, 1.95, 0.58, 0
17181, 1.9666666666667, 0.58, 0
17182, 1.9833333333333, 0.58, 0
17183, 2, 0.58, 0
17184, 2.0166666666667, 0.58, 0
17185, 2.0333333333333, 0.58, 0
17186, 2.05, 0.58, 0
17187, 2.0666666666667, 0.58, 0
17188, 2.0833333333333, 0.58, 0
17189, 2.1, 0.58, 0
17190, 2.1166666666667, 0.58, 0
17191, 2.1333333333333, 0.58, 0
17192, 2.15, 0.58, 0
17193, 2.1666666666667, 0.58, 0
17194, 2.1833333333333, 0.58, 0
17195, 1.2166666666667, 0.56, 0
17196, 1.2333333333333, 0.56, 0
17197, 1.25, 0.56, 0
17198, 1.2666666666667, 0.56, 0
17199, 1.2833333333333, 0.56, 0
17200, 1.3, 0.56, 0
17201, 1.3166666666667, 0.56, 0
17202, 1.3333333333333, 0.56, 0
17203, 1.35, 0.56, 0
17204, 1.3666666666667, 0.56, 0
17205, 1.3833333333333, 0.56, 0
17206, 1.4, 0.56, 0
17207, 1.4166666666667, 0.56, 0
17208, 1.4333333333333, 0.56, 0
17209, 1.45, 0.56, 0
17210, 1.4666666666667, 0.56, 0
17211, 1.4833333333333, 0.56, 0
17212, 1.5, 0.56, 0
17213, 1.5166666666667, 0.56, 0
17214, 1.5333333333333, 0.56, 0
17215, 1.55, 0.56, 0
17216, 1.5666666666667, 0.56, 0
17217, 1.5833333333333, 0.56, 0
17218, 1.6, 0.56, 0
17219, 1.6166666666667, 0.56, 0
17220, 1.6333333333333, 0.56, 0
17221, 1.65, 0.56, 0
17222, 1.6666666666667, 0.56, 0
17223, 1.6833333333333, 0.56, 0
17224, 1.7, 0.56, 0
17225, 1.7166666666667, 0.56, 0
17226, 1.7333333333333, 0.56, 0
17227, 1.75, 0.56, 0
17228, 1.7666666666667, 0.56, 0
17229, 1.7833333333333, 0.56, 0
17230, 1.8, 0.56, 0
17231, 1.8166666666667, 0.56, 0
17232, 1.8333333333333, 0.56, 0
17233, 1.85, 0.56, 0
17234, 1.8666666666667, 0.56, 0
17235, 1.8833333333333, 0.56, 0
17236, 1.9, 0.56, 0
17237, 1.9166666666667, 0.56, 0
17238, 1.9333333333333, 0.56, 0
17239, 1.95, 0.56, 0
17240, 1.9666666666667, 0.56, 0
17241, 1.9833333333333, 0.56, 0
17242, 2, 0.56, 0
17243, 2.0166666666667, 0.56, 0
17244, 2.0333333333333, 0.56, 0
17245, 2.05, 0.56, 0
17246, 2.0666666666667, 0.56, 0
17247, 2.0833333333333, 0.56, 0
17248, 2.1, 0.56, 0
17249, 2.1166666666667, 0.56, 0
17250, 2.1333333333333, 0.56, 0
17251, 2.15, 0.56, 0
17252, 2.1666666666667, 0.56, 0
17253, 2.1833333333333, 0.56, 0
17254, 1.2166666666667, 0.54, 0
17255, 1.2333333333333, 0.54, 0
17256, 1.25, 0.54, 0
17257, 1.2666666666667, 0.54, 0
17258, 1.2833333333333, 0.54, 0
17259, 1.3, 0.54, 0
17260, 1.3166666666667, 0.54, 0
17261, 1.3333333333333, 0.54, 0
17262, 1.35, 0.54, 0
17263, 1.3666666666667, 0.54, 0
17264, 1.3833333333333, 0.54, 0
17265, 1.4, 0.54, 0
17266, 1.4166666666667, 0.54, 0
17267, 1.4333333333333, 0.54, 0
17268, 1.45, 0.54, 0
17269, 1.4666666666667, 0.54, 0
17270, 1.4833333333333, 0.54, 0
17271, 1.5, 0.54, 0
17272, 1.5166666666667, 0.54, 0
17273, 1.5333333333333, 0.54, 0
17274, 1.55, 0.54, 0
17275, 1.5666666666667, 0.54, 0
17276, 1.5833333333333, 0.54, 0
17277, 1.6, 0.54, 0
17278, 1.6166666666667, 0.54, 0
17279, 1.6333333333333, 0.54, 0
17280, 1.65, 0.54, 0
17281, 1.6666666666667, 0.54, 0
17282, 1.6833333333333, 0.54, 0
17283, 1.7, 0.54, 0
17284, 1.7166666666667, 0.54, 0
17285, 1.7333333333333, 0.54, 0
17286, 1.75, 0.54, 0
17287, 1.7666666666667, 0.54, 0
17288, 1.7833333333333, 0.54, 0
17289, 1.8, 0.54, 0
17290, 1.8166666666667, 0.54, 0
17291, 1.8333333333333, 0.54, 0
17292, 1.85, 0.54, 0
17293, 1.8666666666667, 0.54, 0
17294, 1.8833333333333, 0.54, 0
17295, 1.9, 0.54, 0
17296, 1.9166666666667, 0.54, 0
17297, 1.9333333333333, 0.54, 0
17298, 1.95, 0.54, 0
17299, 1.9666666666667, 0.54, 0
17300, 1.9833333333333, 0.54, 0
17301, 2, 0.54, 0
17302, 2.0166666666667, 0.54, 0
17303, 2.0333333333333, 0.54, 0
17304, 2.05, 0.54, 0
17305, 2.0666666666667, 0.54, 0
17306, 2.0833333333333, 0.54, 0
17307, 2.1, 0.54, 0
17308, 2.1166666666667, 0.54, 0
17309, 2.1333333333333, 0.54, 0
17310, 2.15, 0.54, 0
17311, 2.1666666666667, 0.54, 0
17312, 2.1833333333333, 0.54, 0
17313, 1.2166666666667, 0.52, 0
17314, 1.2333333333333, 0.52, 0
17315, 1.25, 0.52, 0
17316, 1.2666666666667, 0.52, 0
17317, 1.2833333333333, 0.52, 0
17318, 1.3, 0.52, 0
17319, 1.3166666666667, 0.52, 0
17320, 1.3333333333333, 0.52, 0
17321, 1.35, 0.52, 0
17322, 1.3666666666667, 0.52, 0
17323, 1.3833333333333, 0.52, 0
17324, 1.4, 0.52, 0
17325, 1.4166666666667, 0.52, 0
17326, 1.4333333333333, 0.52, 0
17327, 1.45, 0.52, 0
17328, 1.4666666666667, 0.52, 0
17329, 1.4833333333333, 0.52, 0
17330, 1.5, 0.52, 0
17331, 1.5166666666667, 0.52, 0
17332, 1.5333333333333, 0.52, 0
17333, 1.55, 0.52, 0
17334, 1.5666666666667, 0.52, 0
17335, 1.5833333333333, 0.52, 0
17336, 1.6, 0.52, 0
17337, 1.6166666666667, 0.52, 0
17338, 1.6333333333333, 0.52, 0
17339, 1.65, 0.52, 0
17340, 1.6666666666667, 0.52, 0
17341, 1.6833333333333, 0.52, 0
17342, 1.7, 0.52, 0
17343, 1.7166666666667, 0.52, 0
17344, 1.7333333333333, 0.52, 0
17345, 1.75, 0.52, 0
17346, 1.7666666666667, 0.52, 0
17347, 1.7833333333333, 0.52, 0
17348, 1.8, 0.52, 0
17349, 1.8166666666667, 0.52, 0
17350, 1.8333333333333, 0.52, 0
17351, 1.85, 0.52, 0
17352, 1.8666666666667, 0.52, 0
17353, 1.8833333333333, 0.52, 0
17354, 1.9, 0.52, 0
17355, 1.9166666666667, 0.52, 0
17356, 1.9333333333333, 0.52, 0
17357, 1.95, 0.52, 0
17358, 1.9666666666667, 0.52, 0
17359, 1.9833333333333, 0.52, 0
17360, 2, 0.52, 0
17361, 2.0166666666667, 0.52, 0
17362, 2.0333333333333, 0.52, 0
17363, 2.05, 0.52, 0
17364, 2.0666666666667, 0.52, 0
17365, 2.0833333333333, 0.52, 0
17366, 2.1, 0.52, 0
17367, 2.1166666666667, 0.52, 0
17368, 2.1333333333333, 0.52, 0
17369, 2.15, 0.52, 0
17370, 2.1666666666667, 0.52, 0
17371, 2.1833333333333, 0.52, 0
17372, 1.2166666666667, 0.5, 0
17373, 1.2333333333333, 0.5, 0
17374, 1.25, 0.5, 0
17375, 1.2666666666667, 0.5, 0
17376, 1.2833333333333, 0.5, 0
17377, 1.3, 0.5, 0
17378, 1.3166666666667, 0.5, 0
17379, 1.3333333333333, 0.5, 0
17380, 1.35, 0.5, 0
17381, 1.3666666666667, 0.5, 0
17382, 1.3833333333333, 0.5, 0
17383, 1.4, 0.5, 0
17384, 1.4166666666667, 0.5, 0
17385, 1.4333333333333, 0.5, 0
17386, 1.45, 0.5, 0
17387, 1.4666666666667, 0.5, 0
17388, 1.4833333333333, 0.5, 0
17389, 1.5, 0.5, 0
17390, 1.5166666666667, 0.5, 0
17391, 1.5333333333333, 0.5, 0
17392, 1.55, 0.5, 0
17393, 1.5666666666667, 0.5, 0
17394, 1.5833333333333, 0.5, 0
17395, 1.6, 0.5, 0
17396, 1.6166666666667, 0.5, 0
