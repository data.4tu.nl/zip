54428, 54396, 10924, 10903, 54427
11777, 39363, 10611, 10601, 39373, 39364, 10612, 10602, 39374, 54807, 10923, 54817, 54428, 54808, 10925, 54818, 
54431, 54399, 10926, 10905, 54430
11778, 39364, 10612, 10602, 39374, 39365, 10613, 10603, 39375, 54808, 10925, 54818, 54431, 54809, 10927, 54819, 
54434, 54402, 10928, 10907, 54433
11779, 39365, 10613, 10603, 39375, 39366, 10614, 10604, 39376, 54809, 10927, 54819, 54434, 54810, 10929, 54820, 
54437, 54405, 10930, 10909, 54436
11780, 39366, 10614, 10604, 39376, 39367, 10615, 10605, 39377, 54810, 10929, 54820, 54437, 54811, 10931, 54821, 
54440, 54408, 10932, 10911, 54439
11781, 39367, 10615, 10605, 39377, 39368, 10616, 10606, 39378, 54811, 10931, 54821, 54440, 54812, 10933, 54822, 
54443, 54411, 10934, 10913, 54442
11782, 39368, 10616, 10606, 39378, 8814, 771, 770, 8815, 54812, 10933, 54822, 54443, 9826, 793, 9827, 
9796, 54414, 10935, 10914, 54445
11783, 6627, 614, 613, 6628, 39369, 10597, 10587, 39379, 7639, 636, 7640, 7611, 54813, 10894, 54823, 
54447, 54415, 10895, 10874, 54446
11784, 39369, 10597, 10587, 39379, 39370, 10598, 10588, 39380, 54813, 10894, 54823, 54447, 54814, 10896, 54824, 
54450, 54418, 10897, 10876, 54449
11785, 39370, 10598, 10588, 39380, 39371, 10599, 10589, 39381, 54814, 10896, 54824, 54450, 54815, 10898, 54825, 
54453, 54421, 10899, 10878, 54452
11786, 39371, 10599, 10589, 39381, 39372, 10600, 10590, 39382, 54815, 10898, 54825, 54453, 54816, 10900, 54826, 
54456, 54424, 10901, 10880, 54455
11787, 39372, 10600, 10590, 39382, 39373, 10601, 10591, 39383, 54816, 10900, 54826, 54456, 54817, 10902, 54827, 
54459, 54427, 10903, 10882, 54458
11788, 39373, 10601, 10591, 39383, 39374, 10602, 10592, 39384, 54817, 10902, 54827, 54459, 54818, 10904, 54828, 
54462, 54430, 10905, 10884, 54461
11789, 39374, 10602, 10592, 39384, 39375, 10603, 10593, 39385, 54818, 10904, 54828, 54462, 54819, 10906, 54829, 
54465, 54433, 10907, 10886, 54464
11790, 39375, 10603, 10593, 39385, 39376, 10604, 10594, 39386, 54819, 10906, 54829, 54465, 54820, 10908, 54830, 
54468, 54436, 10909, 10888, 54467
11791, 39376, 10604, 10594, 39386, 39377, 10605, 10595, 39387, 54820, 10908, 54830, 54468, 54821, 10910, 54831, 
54471, 54439, 10911, 10890, 54470
11792, 39377, 10605, 10595, 39387, 39378, 10606, 10596, 39388, 54821, 10910, 54831, 54471, 54822, 10912, 54832, 
54474, 54442, 10913, 10892, 54473
11793, 39378, 10606, 10596, 39388, 8815, 770, 769, 8816, 54822, 10912, 54832, 54474, 9827, 792, 9828, 
9798, 54445, 10914, 10893, 54476
11794, 6628, 613, 612, 6629, 39379, 10587, 10577, 39389, 7640, 635, 7641, 7613, 54823, 10873, 54833, 
54478, 54446, 10874, 10853, 54477
11795, 39379, 10587, 10577, 39389, 39380, 10588, 10578, 39390, 54823, 10873, 54833, 54478, 54824, 10875, 54834, 
54481, 54449, 10876, 10855, 54480
11796, 39380, 10588, 10578, 39390, 39381, 10589, 10579, 39391, 54824, 10875, 54834, 54481, 54825, 10877, 54835, 
54484, 54452, 10878, 10857, 54483
11797, 39381, 10589, 10579, 39391, 39382, 10590, 10580, 39392, 54825, 10877, 54835, 54484, 54826, 10879, 54836, 
54487, 54455, 10880, 10859, 54486
11798, 39382, 10590, 10580, 39392, 39383, 10591, 10581, 39393, 54826, 10879, 54836, 54487, 54827, 10881, 54837, 
54490, 54458, 10882, 10861, 54489
11799, 39383, 10591, 10581, 39393, 39384, 10592, 10582, 39394, 54827, 10881, 54837, 54490, 54828, 10883, 54838, 
54493, 54461, 10884, 10863, 54492
11800, 39384, 10592, 10582, 39394, 39385, 10593, 10583, 39395, 54828, 10883, 54838, 54493, 54829, 10885, 54839, 
54496, 54464, 10886, 10865, 54495
11801, 39385, 10593, 10583, 39395, 39386, 10594, 10584, 39396, 54829, 10885, 54839, 54496, 54830, 10887, 54840, 
54499, 54467, 10888, 10867, 54498
11802, 39386, 10594, 10584, 39396, 39387, 10595, 10585, 39397, 54830, 10887, 54840, 54499, 54831, 10889, 54841, 
54502, 54470, 10890, 10869, 54501
11803, 39387, 10595, 10585, 39397, 39388, 10596, 10586, 39398, 54831, 10889, 54841, 54502, 54832, 10891, 54842, 
54505, 54473, 10892, 10871, 54504
11804, 39388, 10596, 10586, 39398, 8816, 769, 768, 8817, 54832, 10891, 54842, 54505, 9828, 791, 9829, 
9800, 54476, 10893, 10872, 54507
11805, 6629, 612, 611, 6630, 39389, 10577, 10567, 39399, 7641, 634, 7642, 7615, 54833, 10852, 54843, 
54509, 54477, 10853, 10832, 54508
11806, 39389, 10577, 10567, 39399, 39390, 10578, 10568, 39400, 54833, 10852, 54843, 54509, 54834, 10854, 54844, 
54512, 54480, 10855, 10834, 54511
11807, 39390, 10578, 10568, 39400, 39391, 10579, 10569, 39401, 54834, 10854, 54844, 54512, 54835, 10856, 54845, 
54515, 54483, 10857, 10836, 54514
11808, 39391, 10579, 10569, 39401, 39392, 10580, 10570, 39402, 54835, 10856, 54845, 54515, 54836, 10858, 54846, 
54518, 54486, 10859, 10838, 54517
11809, 39392, 10580, 10570, 39402, 39393, 10581, 10571, 39403, 54836, 10858, 54846, 54518, 54837, 10860, 54847, 
54521, 54489, 10861, 10840, 54520
11810, 39393, 10581, 10571, 39403, 39394, 10582, 10572, 39404, 54837, 10860, 54847, 54521, 54838, 10862, 54848, 
54524, 54492, 10863, 10842, 54523
11811, 39394, 10582, 10572, 39404, 39395, 10583, 10573, 39405, 54838, 10862, 54848, 54524, 54839, 10864, 54849, 
54527, 54495, 10865, 10844, 54526
11812, 39395, 10583, 10573, 39405, 39396, 10584, 10574, 39406, 54839, 10864, 54849, 54527, 54840, 10866, 54850, 
54530, 54498, 10867, 10846, 54529
11813, 39396, 10584, 10574, 39406, 39397, 10585, 10575, 39407, 54840, 10866, 54850, 54530, 54841, 10868, 54851, 
54533, 54501, 10869, 10848, 54532
11814, 39397, 10585, 10575, 39407, 39398, 10586, 10576, 39408, 54841, 10868, 54851, 54533, 54842, 10870, 54852, 
54536, 54504, 10871, 10850, 54535
11815, 39398, 10586, 10576, 39408, 8817, 768, 767, 8818, 54842, 10870, 54852, 54536, 9829, 790, 9830, 
9802, 54507, 10872, 10851, 54538
11816, 6630, 611, 610, 6631, 39399, 10567, 10557, 39409, 7642, 633, 7643, 7617, 54843, 10831, 54853, 
54540, 54508, 10832, 10811, 54539
11817, 39399, 10567, 10557, 39409, 39400, 10568, 10558, 39410, 54843, 10831, 54853, 54540, 54844, 10833, 54854, 
54543, 54511, 10834, 10813, 54542
11818, 39400, 10568, 10558, 39410, 39401, 10569, 10559, 39411, 54844, 10833, 54854, 54543, 54845, 10835, 54855, 
54546, 54514, 10836, 10815, 54545
11819, 39401, 10569, 10559, 39411, 39402, 10570, 10560, 39412, 54845, 10835, 54855, 54546, 54846, 10837, 54856, 
54549, 54517, 10838, 10817, 54548
11820, 39402, 10570, 10560, 39412, 39403, 10571, 10561, 39413, 54846, 10837, 54856, 54549, 54847, 10839, 54857, 
54552, 54520, 10840, 10819, 54551
11821, 39403, 10571, 10561, 39413, 39404, 10572, 10562, 39414, 54847, 10839, 54857, 54552, 54848, 10841, 54858, 
54555, 54523, 10842, 10821, 54554
11822, 39404, 10572, 10562, 39414, 39405, 10573, 10563, 39415, 54848, 10841, 54858, 54555, 54849, 10843, 54859, 
54558, 54526, 10844, 10823, 54557
11823, 39405, 10573, 10563, 39415, 39406, 10574, 10564, 39416, 54849, 10843, 54859, 54558, 54850, 10845, 54860, 
54561, 54529, 10846, 10825, 54560
11824, 39406, 10574, 10564, 39416, 39407, 10575, 10565, 39417, 54850, 10845, 54860, 54561, 54851, 10847, 54861, 
54564, 54532, 10848, 10827, 54563
11825, 39407, 10575, 10565, 39417, 39408, 10576, 10566, 39418, 54851, 10847, 54861, 54564, 54852, 10849, 54862, 
54567, 54535, 10850, 10829, 54566
11826, 39408, 10576, 10566, 39418, 8818, 767, 766, 8819, 54852, 10849, 54862, 54567, 9830, 789, 9831, 
9804, 54538, 10851, 10830, 54569
11827, 6631, 610, 609, 6632, 39409, 10557, 10547, 39419, 7643, 632, 7644, 7619, 54853, 10810, 54863, 
54571, 54539, 10811, 10790, 54570
11828, 39409, 10557, 10547, 39419, 39410, 10558, 10548, 39420, 54853, 10810, 54863, 54571, 54854, 10812, 54864, 
54574, 54542, 10813, 10792, 54573
11829, 39410, 10558, 10548, 39420, 39411, 10559, 10549, 39421, 54854, 10812, 54864, 54574, 54855, 10814, 54865, 
54577, 54545, 10815, 10794, 54576
11830, 39411, 10559, 10549, 39421, 39412, 10560, 10550, 39422, 54855, 10814, 54865, 54577, 54856, 10816, 54866, 
54580, 54548, 10817, 10796, 54579
11831, 39412, 10560, 10550, 39422, 39413, 10561, 10551, 39423, 54856, 10816, 54866, 54580, 54857, 10818, 54867, 
54583, 54551, 10819, 10798, 54582
11832, 39413, 10561, 10551, 39423, 39414, 10562, 10552, 39424, 54857, 10818, 54867, 54583, 54858, 10820, 54868, 
54586, 54554, 10821, 10800, 54585
11833, 39414, 10562, 10552, 39424, 39415, 10563, 10553, 39425, 54858, 10820, 54868, 54586, 54859, 10822, 54869, 
54589, 54557, 10823, 10802, 54588
11834, 39415, 10563, 10553, 39425, 39416, 10564, 10554, 39426, 54859, 10822, 54869, 54589, 54860, 10824, 54870, 
54592, 54560, 10825, 10804, 54591
11835, 39416, 10564, 10554, 39426, 39417, 10565, 10555, 39427, 54860, 10824, 54870, 54592, 54861, 10826, 54871, 
54595, 54563, 10827, 10806, 54594
11836, 39417, 10565, 10555, 39427, 39418, 10566, 10556, 39428, 54861, 10826, 54871, 54595, 54862, 10828, 54872, 
54598, 54566, 10829, 10808, 54597
11837, 39418, 10566, 10556, 39428, 8819, 766, 765, 8820, 54862, 10828, 54872, 54598, 9831, 788, 9832, 
9806, 54569, 10830, 10809, 54600
11838, 6632, 609, 608, 6633, 39419, 10547, 10537, 39429, 7644, 631, 7645, 7621, 54863, 10789, 54873, 
54602, 54570, 10790, 10769, 54601
11839, 39419, 10547, 10537, 39429, 39420, 10548, 10538, 39430, 54863, 10789, 54873, 54602, 54864, 10791, 54874, 
54605, 54573, 10792, 10771, 54604
11840, 39420, 10548, 10538, 39430, 39421, 10549, 10539, 39431, 54864, 10791, 54874, 54605, 54865, 10793, 54875, 
54608, 54576, 10794, 10773, 54607
11841, 39421, 10549, 10539, 39431, 39422, 10550, 10540, 39432, 54865, 10793, 54875, 54608, 54866, 10795, 54876, 
54611, 54579, 10796, 10775, 54610
11842, 39422, 10550, 10540, 39432, 39423, 10551, 10541, 39433, 54866, 10795, 54876, 54611, 54867, 10797, 54877, 
54614, 54582, 10798, 10777, 54613
11843, 39423, 10551, 10541, 39433, 39424, 10552, 10542, 39434, 54867, 10797, 54877, 54614, 54868, 10799, 54878, 
54617, 54585, 10800, 10779, 54616
11844, 39424, 10552, 10542, 39434, 39425, 10553, 10543, 39435, 54868, 10799, 54878, 54617, 54869, 10801, 54879, 
54620, 54588, 10802, 10781, 54619
11845, 39425, 10553, 10543, 39435, 39426, 10554, 10544, 39436, 54869, 10801, 54879, 54620, 54870, 10803, 54880, 
54623, 54591, 10804, 10783, 54622
11846, 39426, 10554, 10544, 39436, 39427, 10555, 10545, 39437, 54870, 10803, 54880, 54623, 54871, 10805, 54881, 
54626, 54594, 10806, 10785, 54625
11847, 39427, 10555, 10545, 39437, 39428, 10556, 10546, 39438, 54871, 10805, 54881, 54626, 54872, 10807, 54882, 
54629, 54597, 10808, 10787, 54628
11848, 39428, 10556, 10546, 39438, 8820, 765, 764, 8821, 54872, 10807, 54882, 54629, 9832, 787, 9833, 
9808, 54600, 10809, 10788, 54631
11849, 6633, 608, 607, 6634, 39429, 10537, 10527, 39439, 7645, 630, 7646, 7623, 54873, 10768, 54883, 
54633, 54601, 10769, 10748, 54632
11850, 39429, 10537, 10527, 39439, 39430, 10538, 10528, 39440, 54873, 10768, 54883, 54633, 54874, 10770, 54884, 
54636, 54604, 10771, 10750, 54635
11851, 39430, 10538, 10528, 39440, 39431, 10539, 10529, 39441, 54874, 10770, 54884, 54636, 54875, 10772, 54885, 
54639, 54607, 10773, 10752, 54638
11852, 39431, 10539, 10529, 39441, 39432, 10540, 10530, 39442, 54875, 10772, 54885, 54639, 54876, 10774, 54886, 
54642, 54610, 10775, 10754, 54641
11853, 39432, 10540, 10530, 39442, 39433, 10541, 10531, 39443, 54876, 10774, 54886, 54642, 54877, 10776, 54887, 
54645, 54613, 10777, 10756, 54644
11854, 39433, 10541, 10531, 39443, 39434, 10542, 10532, 39444, 54877, 10776, 54887, 54645, 54878, 10778, 54888, 
54648, 54616, 10779, 10758, 54647
11855, 39434, 10542, 10532, 39444, 39435, 10543, 10533, 39445, 54878, 10778, 54888, 54648, 54879, 10780, 54889, 
54651, 54619, 10781, 10760, 54650
11856, 39435, 10543, 10533, 39445, 39436, 10544, 10534, 39446, 54879, 10780, 54889, 54651, 54880, 10782, 54890, 
54654, 54622, 10783, 10762, 54653
11857, 39436, 10544, 10534, 39446, 39437, 10545, 10535, 39447, 54880, 10782, 54890, 54654, 54881, 10784, 54891, 
54657, 54625, 10785, 10764, 54656
11858, 39437, 10545, 10535, 39447, 39438, 10546, 10536, 39448, 54881, 10784, 54891, 54657, 54882, 10786, 54892, 
54660, 54628, 10787, 10766, 54659
11859, 39438, 10546, 10536, 39448, 8821, 764, 763, 8822, 54882, 10786, 54892, 54660, 9833, 786, 9834, 
9810, 54631, 10788, 10767, 54662
11860, 6634, 607, 14, 583, 39439, 10527, 808, 10054, 7646, 629, 606, 7624, 54883, 10747, 10526, 
54663, 54632, 10748, 818, 10516
11861, 39439, 10527, 808, 10054, 39440, 10528, 809, 10053, 54883, 10747, 10526, 54663, 54884, 10749, 10525, 
54664, 54635, 10750, 819, 10514
11862, 39440, 10528, 809, 10053, 39441, 10529, 810, 10052, 54884, 10749, 10525, 54664, 54885, 10751, 10524, 
54665, 54638, 10752, 820, 10512
11863, 39441, 10529, 810, 10052, 39442, 10530, 811, 10051, 54885, 10751, 10524, 54665, 54886, 10753, 10523, 
54666, 54641, 10754, 821, 10510
11864, 39442, 10530, 811, 10051, 39443, 10531, 812, 10050, 54886, 10753, 10523, 54666, 54887, 10755, 10522, 
54667, 54644, 10756, 822, 10508
11865, 39443, 10531, 812, 10050, 39444, 10532, 813, 10049, 54887, 10755, 10522, 54667, 54888, 10757, 10521, 
54668, 54647, 10758, 823, 10506
11866, 39444, 10532, 813, 10049, 39445, 10533, 814, 10048, 54888, 10757, 10521, 54668, 54889, 10759, 10520, 
54669, 54650, 10760, 824, 10504
11867, 39445, 10533, 814, 10048, 39446, 10534, 815, 10047, 54889, 10759, 10520, 54669, 54890, 10761, 10519, 
54670, 54653, 10762, 825, 10502
11868, 39446, 10534, 815, 10047, 39447, 10535, 816, 10046, 54890, 10761, 10519, 54670, 54891, 10763, 10518, 
54671, 54656, 10764, 826, 10500
11869, 39447, 10535, 816, 10046, 39448, 10536, 817, 10045, 54891, 10763, 10518, 54671, 54892, 10765, 10517, 
54672, 54659, 10766, 827, 10498
11870, 39448, 10536, 817, 10045, 8822, 763, 16, 739, 54892, 10765, 10517, 54672, 9834, 785, 762, 
9812, 54662, 10767, 828, 10496
*ELEMENT, type=C3D20, ELSET=Volume4
11871, 13, 829, 11219, 628, 697, 11317, 54893, 10737, 830, 11242, 11241, 651, 11336, 55114, 55115, 
11209, 707, 11338, 55113, 11189
11872, 697, 11317, 54893, 10737, 698, 11316, 54894, 10738, 11336, 55114, 55115, 11209, 11334, 55117, 55118, 
11210, 708, 11337, 55116, 11191
11873, 698, 11316, 54894, 10738, 699, 11315, 54895, 10739, 11334, 55117, 55118, 11210, 11332, 55120, 55121, 
11211, 709, 11335, 55119, 11193
11874, 699, 11315, 54895, 10739, 700, 11314, 54896, 10740, 11332, 55120, 55121, 11211, 11330, 55123, 55124, 
11212, 710, 11333, 55122, 11195
11875, 700, 11314, 54896, 10740, 701, 11313, 54897, 10741, 11330, 55123, 55124, 11212, 11328, 55126, 55127, 
11213, 711, 11331, 55125, 11197
11876, 701, 11313, 54897, 10741, 702, 11312, 54898, 10742, 11328, 55126, 55127, 11213, 11326, 55129, 55130, 
11214, 712, 11329, 55128, 11199
11877, 702, 11312, 54898, 10742, 703, 11311, 54899, 10743, 11326, 55129, 55130, 11214, 11324, 55132, 55133, 
11215, 713, 11327, 55131, 11201
11878, 703, 11311, 54899, 10743, 704, 11310, 54900, 10744, 11324, 55132, 55133, 11215, 11322, 55135, 55136, 
11216, 714, 11325, 55134, 11203
11879, 704, 11310, 54900, 10744, 705, 11309, 54901, 10745, 11322, 55135, 55136, 11216, 11320, 55138, 55139, 
11217, 715, 11323, 55137, 11205
11880, 705, 11309, 54901, 10745, 706, 11308, 54902, 10746, 11320, 55138, 55139, 11217, 11318, 55141, 55142, 
11218, 716, 11321, 55140, 11207
11881, 706, 11308, 54902, 10746, 15, 880, 11349, 784, 11318, 55141, 55142, 11218, 881, 11371, 11372, 
807, 717, 11319, 55143, 11208
11882, 628, 11219, 11220, 627, 10737, 54893, 54903, 10727, 11241, 11244, 11243, 650, 55115, 55145, 55146, 
11188, 11189, 55113, 55144, 11168
11883, 10737, 54893, 54903, 10727, 10738, 54894, 54904, 10728, 55115, 55145, 55146, 11188, 55118, 55148, 55149, 
11190, 11191, 55116, 55147, 11170
11884, 10738, 54894, 54904, 10728, 10739, 54895, 54905, 10729, 55118, 55148, 55149, 11190, 55121, 55151, 55152, 
11192, 11193, 55119, 55150, 11172
11885, 10739, 54895, 54905, 10729, 10740, 54896, 54906, 10730, 55121, 55151, 55152, 11192, 55124, 55154, 55155, 
11194, 11195, 55122, 55153, 11174
11886, 10740, 54896, 54906, 10730, 10741, 54897, 54907, 10731, 55124, 55154, 55155, 11194, 55127, 55157, 55158, 
11196, 11197, 55125, 55156, 11176
11887, 10741, 54897, 54907, 10731, 10742, 54898, 54908, 10732, 55127, 55157, 55158, 11196, 55130, 55160, 55161, 
11198, 11199, 55128, 55159, 11178
11888, 10742, 54898, 54908, 10732, 10743, 54899, 54909, 10733, 55130, 55160, 55161, 11198, 55133, 55163, 55164, 
11200, 11201, 55131, 55162, 11180
11889, 10743, 54899, 54909, 10733, 10744, 54900, 54910, 10734, 55133, 55163, 55164, 11200, 55136, 55166, 55167, 
11202, 11203, 55134, 55165, 11182
11890, 10744, 54900, 54910, 10734, 10745, 54901, 54911, 10735, 55136, 55166, 55167, 11202, 55139, 55169, 55170, 
11204, 11205, 55137, 55168, 11184
11891, 10745, 54901, 54911, 10735, 10746, 54902, 54912, 10736, 55139, 55169, 55170, 11204, 55142, 55172, 55173, 
11206, 11207, 55140, 55171, 11186
11892, 10746, 54902, 54912, 10736, 784, 11349, 11350, 783, 55142, 55172, 55173, 11206, 11372, 11373, 11374, 
806, 11208, 55143, 55174, 11187
11893, 627, 11220, 11221, 626, 10727, 54903, 54913, 10717, 11243, 11246, 11245, 649, 55146, 55176, 55177, 
11167, 11168, 55144, 55175, 11147
11894, 10727, 54903, 54913, 10717, 10728, 54904, 54914, 10718, 55146, 55176, 55177, 11167, 55149, 55179, 55180, 
11169, 11170, 55147, 55178, 11149
11895, 10728, 54904, 54914, 10718, 10729, 54905, 54915, 10719, 55149, 55179, 55180, 11169, 55152, 55182, 55183, 
11171, 11172, 55150, 55181, 11151
11896, 10729, 54905, 54915, 10719, 10730, 54906, 54916, 10720, 55152, 55182, 55183, 11171, 55155, 55185, 55186, 
11173, 11174, 55153, 55184, 11153
11897, 10730, 54906, 54916, 10720, 10731, 54907, 54917, 10721, 55155, 55185, 55186, 11173, 55158, 55188, 55189, 
11175, 11176, 55156, 55187, 11155
11898, 10731, 54907, 54917, 10721, 10732, 54908, 54918, 10722, 55158, 55188, 55189, 11175, 55161, 55191, 55192, 
11177, 11178, 55159, 55190, 11157
11899, 10732, 54908, 54918, 10722, 10733, 54909, 54919, 10723, 55161, 55191, 55192, 11177, 55164, 55194, 55195, 
11179, 11180, 55162, 55193, 11159
11900, 10733, 54909, 54919, 10723, 10734, 54910, 54920, 10724, 55164, 55194, 55195, 11179, 55167, 55197, 55198, 
11181, 11182, 55165, 55196, 11161
11901, 10734, 54910, 54920, 10724, 10735, 54911, 54921, 10725, 55167, 55197, 55198, 11181, 55170, 55200, 55201, 
11183, 11184, 55168, 55199, 11163
11902, 10735, 54911, 54921, 10725, 10736, 54912, 54922, 10726, 55170, 55200, 55201, 11183, 55173, 55203, 55204, 
11185, 11186, 55171, 55202, 11165
11903, 10736, 54912, 54922, 10726, 783, 11350, 11351, 782, 55173, 55203, 55204, 11185, 11374, 11375, 11376, 
805, 11187, 55174, 55205, 11166
11904, 626, 11221, 11222, 625, 10717, 54913, 54923, 10707, 11245, 11248, 11247, 648, 55177, 55207, 55208, 
11146, 11147, 55175, 55206, 11126
11905, 10717, 54913, 54923, 10707, 10718, 54914, 54924, 10708, 55177, 55207, 55208, 11146, 55180, 55210, 55211, 
11148, 11149, 55178, 55209, 11128
11906, 10718, 54914, 54924, 10708, 10719, 54915, 54925, 10709, 55180, 55210, 55211, 11148, 55183, 55213, 55214, 
11150, 11151, 55181, 55212, 11130
11907, 10719, 54915, 54925, 10709, 10720, 54916, 54926, 10710, 55183, 55213, 55214, 11150, 55186, 55216, 55217, 
11152, 11153, 55184, 55215, 11132
11908, 10720, 54916, 54926, 10710, 10721, 54917, 54927, 10711, 55186, 55216, 55217, 11152, 55189, 55219, 55220, 
11154, 11155, 55187, 55218, 11134
11909, 10721, 54917, 54927, 10711, 10722, 54918, 54928, 10712, 55189, 55219, 55220, 11154, 55192, 55222, 55223, 
11156, 11157, 55190, 55221, 11136
11910, 10722, 54918, 54928, 10712, 10723, 54919, 54929, 10713, 55192, 55222, 55223, 11156, 55195, 55225, 55226, 
11158, 11159, 55193, 55224, 11138
11911, 10723, 54919, 54929, 10713, 10724, 54920, 54930, 10714, 55195, 55225, 55226, 11158, 55198, 55228, 55229, 
11160, 11161, 55196, 55227, 11140
11912, 10724, 54920, 54930, 10714, 10725, 54921, 54931, 10715, 55198, 55228, 55229, 11160, 55201, 55231, 55232, 
11162, 11163, 55199, 55230, 11142
11913, 10725, 54921, 54931, 10715, 10726, 54922, 54932, 10716, 55201, 55231, 55232, 11162, 55204, 55234, 55235, 
11164, 11165, 55202, 55233, 11144
11914, 10726, 54922, 54932, 10716, 782, 11351, 11352, 781, 55204, 55234, 55235, 11164, 11376, 11377, 11378, 
804, 11166, 55205, 55236, 11145
11915, 625, 11222, 11223, 624, 10707, 54923, 54933, 10697, 11247, 11250, 11249, 647, 55208, 55238, 55239, 
11125, 11126, 55206, 55237, 11105
11916, 10707, 54923, 54933, 10697, 10708, 54924, 54934, 10698, 55208, 55238, 55239, 11125, 55211, 55241, 55242, 
11127, 11128, 55209, 55240, 11107
11917, 10708, 54924, 54934, 10698, 10709, 54925, 54935, 10699, 55211, 55241, 55242, 11127, 55214, 55244, 55245, 
11129, 11130, 55212, 55243, 11109
11918, 10709, 54925, 54935, 10699, 10710, 54926, 54936, 10700, 55214, 55244, 55245, 11129, 55217, 55247, 55248, 
11131, 11132, 55215, 55246, 11111
11919, 10710, 54926, 54936, 10700, 10711, 54927, 54937, 10701, 55217, 55247, 55248, 11131, 55220, 55250, 55251, 
11133, 11134, 55218, 55249, 11113
11920, 10711, 54927, 54937, 10701, 10712, 54928, 54938, 10702, 55220, 55250, 55251, 11133, 55223, 55253, 55254, 
11135, 11136, 55221, 55252, 11115
11921, 10712, 54928, 54938, 10702, 10713, 54929, 54939, 10703, 55223, 55253, 55254, 11135, 55226, 55256, 55257, 
11137, 11138, 55224, 55255, 11117
11922, 10713, 54929, 54939, 10703, 10714, 54930, 54940, 10704, 55226, 55256, 55257, 11137, 55229, 55259, 55260, 
11139, 11140, 55227, 55258, 11119
11923, 10714, 54930, 54940, 10704, 10715, 54931, 54941, 10705, 55229, 55259, 55260, 11139, 55232, 55262, 55263, 
11141, 11142, 55230, 55261, 11121
11924, 10715, 54931, 54941, 10705, 10716, 54932, 54942, 10706, 55232, 55262, 55263, 11141, 55235, 55265, 55266, 
11143, 11144, 55233, 55264, 11123
11925, 10716, 54932, 54942, 10706, 781, 11352, 11353, 780, 55235, 55265, 55266, 11143, 11378, 11379, 11380, 
803, 11145, 55236, 55267, 11124
11926, 624, 11223, 11224, 623, 10697, 54933, 54943, 10687, 11249, 11252, 11251, 646, 55239, 55269, 55270, 
11104, 11105, 55237, 55268, 11084
11927, 10697, 54933, 54943, 10687, 10698, 54934, 54944, 10688, 55239, 55269, 55270, 11104, 55242, 55272, 55273, 
11106, 11107, 55240, 55271, 11086
11928, 10698, 54934, 54944, 10688, 10699, 54935, 54945, 10689, 55242, 55272, 55273, 11106, 55245, 55275, 55276, 
11108, 11109, 55243, 55274, 11088
11929, 10699, 54935, 54945, 10689, 10700, 54936, 54946, 10690, 55245, 55275, 55276, 11108, 55248, 55278, 55279, 
11110, 11111, 55246, 55277, 11090
11930, 10700, 54936, 54946, 10690, 10701, 54937, 54947, 10691, 55248, 55278, 55279, 11110, 55251, 55281, 55282, 
11112, 11113, 55249, 55280, 11092
11931, 10701, 54937, 54947, 10691, 10702, 54938, 54948, 10692, 55251, 55281, 55282, 11112, 55254, 55284, 55285, 
11114, 11115, 55252, 55283, 11094
11932, 10702, 54938, 54948, 10692, 10703, 54939, 54949, 10693, 55254, 55284, 55285, 11114, 55257, 55287, 55288, 
11116, 11117, 55255, 55286, 11096
11933, 10703, 54939, 54949, 10693, 10704, 54940, 54950, 10694, 55257, 55287, 55288, 11116, 55260, 55290, 55291, 
11118, 11119, 55258, 55289, 11098
11934, 10704, 54940, 54950, 10694, 10705, 54941, 54951, 10695, 55260, 55290, 55291, 11118, 55263, 55293, 55294, 
11120, 11121, 55261, 55292, 11100
11935, 10705, 54941, 54951, 10695, 10706, 54942, 54952, 10696, 55263, 55293, 55294, 11120, 55266, 55296, 55297, 
11122, 11123, 55264, 55295, 11102
11936, 10706, 54942, 54952, 10696, 780, 11353, 11354, 779, 55266, 55296, 55297, 11122, 11380, 11381, 11382, 
802, 11124, 55267, 55298, 11103
11937, 623, 11224, 11225, 622, 10687, 54943, 54953, 10677, 11251, 11254, 11253, 645, 55270, 55300, 55301, 
11083, 11084, 55268, 55299, 11063
11938, 10687, 54943, 54953, 10677, 10688, 54944, 54954, 10678, 55270, 55300, 55301, 11083, 55273, 55303, 55304, 
11085, 11086, 55271, 55302, 11065
11939, 10688, 54944, 54954, 10678, 10689, 54945, 54955, 10679, 55273, 55303, 55304, 11085, 55276, 55306, 55307, 
11087, 11088, 55274, 55305, 11067
11940, 10689, 54945, 54955, 10679, 10690, 54946, 54956, 10680, 55276, 55306, 55307, 11087, 55279, 55309, 55310, 
11089, 11090, 55277, 55308, 11069
11941, 10690, 54946, 54956, 10680, 10691, 54947, 54957, 10681, 55279, 55309, 55310, 11089, 55282, 55312, 55313, 
11091, 11092, 55280, 55311, 11071
11942, 10691, 54947, 54957, 10681, 10692, 54948, 54958, 10682, 55282, 55312, 55313, 11091, 55285, 55315, 55316, 
11093, 11094, 55283, 55314, 11073
11943, 10692, 54948, 54958, 10682, 10693, 54949, 54959, 10683, 55285, 55315, 55316, 11093, 55288, 55318, 55319, 
11095, 11096, 55286, 55317, 11075
11944, 10693, 54949, 54959, 10683, 10694, 54950, 54960, 10684, 55288, 55318, 55319, 11095, 55291, 55321, 55322, 
11097, 11098, 55289, 55320, 11077
11945, 10694, 54950, 54960, 10684, 10695, 54951, 54961, 10685, 55291, 55321, 55322, 11097, 55294, 55324, 55325, 
11099, 11100, 55292, 55323, 11079
11946, 10695, 54951, 54961, 10685, 10696, 54952, 54962, 10686, 55294, 55324, 55325, 11099, 55297, 55327, 55328, 
11101, 11102, 55295, 55326, 11081
11947, 10696, 54952, 54962, 10686, 779, 11354, 11355, 778, 55297, 55327, 55328, 11101, 11382, 11383, 11384, 
801, 11103, 55298, 55329, 11082
11948, 622, 11225, 11226, 621, 10677, 54953, 54963, 10667, 11253, 11256, 11255, 644, 55301, 55331, 55332, 
11062, 11063, 55299, 55330, 11042
11949, 10677, 54953, 54963, 10667, 10678, 54954, 54964, 10668, 55301, 55331, 55332, 11062, 55304, 55334, 55335, 
11064, 11065, 55302, 55333, 11044
11950, 10678, 54954, 54964, 10668, 10679, 54955, 54965, 10669, 55304, 55334, 55335, 11064, 55307, 55337, 55338, 
11066, 11067, 55305, 55336, 11046
11951, 10679, 54955, 54965, 10669, 10680, 54956, 54966, 10670, 55307, 55337, 55338, 11066, 55310, 55340, 55341, 
11068, 11069, 55308, 55339, 11048
11952, 10680, 54956, 54966, 10670, 10681, 54957, 54967, 10671, 55310, 55340, 55341, 11068, 55313, 55343, 55344, 
11070, 11071, 55311, 55342, 11050
11953, 10681, 54957, 54967, 10671, 10682, 54958, 54968, 10672, 55313, 55343, 55344, 11070, 55316, 55346, 55347, 
11072, 11073, 55314, 55345, 11052
11954, 10682, 54958, 54968, 10672, 10683, 54959, 54969, 10673, 55316, 55346, 55347, 11072, 55319, 55349, 55350, 
11074, 11075, 55317, 55348, 11054
11955, 10683, 54959, 54969, 10673, 10684, 54960, 54970, 10674, 55319, 55349, 55350, 11074, 55322, 55352, 55353, 
11076, 11077, 55320, 55351, 11056
11956, 10684, 54960, 54970, 10674, 10685, 54961, 54971, 10675, 55322, 55352, 55353, 11076, 55325, 55355, 55356, 
11078, 11079, 55323, 55354, 11058
11957, 10685, 54961, 54971, 10675, 10686, 54962, 54972, 10676, 55325, 55355, 55356, 11078, 55328, 55358, 55359, 
11080, 11081, 55326, 55357, 11060
11958, 10686, 54962, 54972, 10676, 778, 11355, 11356, 777, 55328, 55358, 55359, 11080, 11384, 11385, 11386, 
800, 11082, 55329, 55360, 11061
11959, 621, 11226, 11227, 620, 10667, 54963, 54973, 10657, 11255, 11258, 11257, 643, 55332, 55362, 55363, 
11041, 11042, 55330, 55361, 11021
11960, 10667, 54963, 54973, 10657, 10668, 54964, 54974, 10658, 55332, 55362, 55363, 11041, 55335, 55365, 55366, 
11043, 11044, 55333, 55364, 11023
11961, 10668, 54964, 54974, 10658, 10669, 54965, 54975, 10659, 55335, 55365, 55366, 11043, 55338, 55368, 55369, 
11045, 11046, 55336, 55367, 11025
11962, 10669, 54965, 54975, 10659, 10670, 54966, 54976, 10660, 55338, 55368, 55369, 11045, 55341, 55371, 55372, 
11047, 11048, 55339, 55370, 11027
11963, 10670, 54966, 54976, 10660, 10671, 54967, 54977, 10661, 55341, 55371, 55372, 11047, 55344, 55374, 55375, 
11049, 11050, 55342, 55373, 11029
11964, 10671, 54967, 54977, 10661, 10672, 54968, 54978, 10662, 55344, 55374, 55375, 11049, 55347, 55377, 55378, 
11051, 11052, 55345, 55376, 11031
11965, 10672, 54968, 54978, 10662, 10673, 54969, 54979, 10663, 55347, 55377, 55378, 11051, 55350, 55380, 55381, 
11053, 11054, 55348, 55379, 11033
11966, 10673, 54969, 54979, 10663, 10674, 54970, 54980, 10664, 55350, 55380, 55381, 11053, 55353, 55383, 55384, 
11055, 11056, 55351, 55382, 11035
11967, 10674, 54970, 54980, 10664, 10675, 54971, 54981, 10665, 55353, 55383, 55384, 11055, 55356, 55386, 55387, 
11057, 11058, 55354, 55385, 11037
11968, 10675, 54971, 54981, 10665, 10676, 54972, 54982, 10666, 55356, 55386, 55387, 11057, 55359, 55389, 55390, 
11059, 11060, 55357, 55388, 11039
11969, 10676, 54972, 54982, 10666, 777, 11356, 11357, 776, 55359, 55389, 55390, 11059, 11386, 11387, 11388, 
799, 11061, 55360, 55391, 11040
11970, 620, 11227, 11228, 619, 10657, 54973, 54983, 10647, 11257, 11260, 11259, 642, 55363, 55393, 55394, 
11020, 11021, 55361, 55392, 11000
11971, 10657, 54973, 54983, 10647, 10658, 54974, 54984, 10648, 55363, 55393, 55394, 11020, 55366, 55396, 55397, 
11022, 11023, 55364, 55395, 11002
11972, 10658, 54974, 54984, 10648, 10659, 54975, 54985, 10649, 55366, 55396, 55397, 11022, 55369, 55399, 55400, 
11024, 11025, 55367, 55398, 11004
11973, 10659, 54975, 54985, 10649, 10660, 54976, 54986, 10650, 55369, 55399, 55400, 11024, 55372, 55402, 55403, 
11026, 11027, 55370, 55401, 11006
11974, 10660, 54976, 54986, 10650, 10661, 54977, 54987, 10651, 55372, 55402, 55403, 11026, 55375, 55405, 55406, 
11028, 11029, 55373, 55404, 11008
11975, 10661, 54977, 54987, 10651, 10662, 54978, 54988, 10652, 55375, 55405, 55406, 11028, 55378, 55408, 55409, 
11030, 11031, 55376, 55407, 11010
11976, 10662, 54978, 54988, 10652, 10663, 54979, 54989, 10653, 55378, 55408, 55409, 11030, 55381, 55411, 55412, 
11032, 11033, 55379, 55410, 11012
11977, 10663, 54979, 54989, 10653, 10664, 54980, 54990, 10654, 55381, 55411, 55412, 11032, 55384, 55414, 55415, 
11034, 11035, 55382, 55413, 11014
11978, 10664, 54980, 54990, 10654, 10665, 54981, 54991, 10655, 55384, 55414, 55415, 11034, 55387, 55417, 55418, 
11036, 11037, 55385, 55416, 11016
11979, 10665, 54981, 54991, 10655, 10666, 54982, 54992, 10656, 55387, 55417, 55418, 11036, 55390, 55420, 55421, 
11038, 11039, 55388, 55419, 11018
11980, 10666, 54982, 54992, 10656, 776, 11357, 11358, 775, 55390, 55420, 55421, 11038, 11388, 11389, 11390, 
798, 11040, 55391, 55422, 11019
11981, 619, 11228, 11229, 618, 10647, 54983, 54993, 10637, 11259, 11262, 11261, 641, 55394, 55424, 55425, 
10999, 11000, 55392, 55423, 10979
11982, 10647, 54983, 54993, 10637, 10648, 54984, 54994, 10638, 55394, 55424, 55425, 10999, 55397, 55427, 55428, 
11001, 11002, 55395, 55426, 10981
11983, 10648, 54984, 54994, 10638, 10649, 54985, 54995, 10639, 55397, 55427, 55428, 11001, 55400, 55430, 55431, 
11003, 11004, 55398, 55429, 10983
11984, 10649, 54985, 54995, 10639, 10650, 54986, 54996, 10640, 55400, 55430, 55431, 11003, 55403, 55433, 55434, 
11005, 11006, 55401, 55432, 10985
11985, 10650, 54986, 54996, 10640, 10651, 54987, 54997, 10641, 55403, 55433, 55434, 11005, 55406, 55436, 55437, 
11007, 11008, 55404, 55435, 10987
11986, 10651, 54987, 54997, 10641, 10652, 54988, 54998, 10642, 55406, 55436, 55437, 11007, 55409, 55439, 55440, 
11009, 11010, 55407, 55438, 10989
11987, 10652, 54988, 54998, 10642, 10653, 54989, 54999, 10643, 55409, 55439, 55440, 11009, 55412, 55442, 55443, 
11011, 11012, 55410, 55441, 10991
11988, 10653, 54989, 54999, 10643, 10654, 54990, 55000, 10644, 55412, 55442, 55443, 11011, 55415, 55445, 55446, 
11013, 11014, 55413, 55444, 10993
11989, 10654, 54990, 55000, 10644, 10655, 54991, 55001, 10645, 55415, 55445, 55446, 11013, 55418, 55448, 55449, 
11015, 11016, 55416, 55447, 10995
11990, 10655, 54991, 55001, 10645, 10656, 54992, 55002, 10646, 55418, 55448, 55449, 11015, 55421, 55451, 55452, 
11017, 11018, 55419, 55450, 10997
11991, 10656, 54992, 55002, 10646, 775, 11358, 11359, 774, 55421, 55451, 55452, 11017, 11390, 11391, 11392, 
797, 11019, 55422, 55453, 10998
11992, 618, 11229, 11230, 617, 10637, 54993, 55003, 10627, 11261, 11264, 11263, 640, 55425, 55455, 55456, 
10978, 10979, 55423, 55454, 10958
11993, 10637, 54993, 55003, 10627, 10638, 54994, 55004, 10628, 55425, 55455, 55456, 10978, 55428, 55458, 55459, 
10980, 10981, 55426, 55457, 10960
11994, 10638, 54994, 55004, 10628, 10639, 54995, 55005, 10629, 55428, 55458, 55459, 10980, 55431, 55461, 55462, 
10982, 10983, 55429, 55460, 10962
11995, 10639, 54995, 55005, 10629, 10640, 54996, 55006, 10630, 55431, 55461, 55462, 10982, 55434, 55464, 55465, 
10984, 10985, 55432, 55463, 10964
11996, 10640, 54996, 55006, 10630, 10641, 54997, 55007, 10631, 55434, 55464, 55465, 10984, 55437, 55467, 55468, 
10986, 10987, 55435, 55466, 10966
11997, 10641, 54997, 55007, 10631, 10642, 54998, 55008, 10632, 55437, 55467, 55468, 10986, 55440, 55470, 55471, 
10988, 10989, 55438, 55469, 10968
11998, 10642, 54998, 55008, 10632, 10643, 54999, 55009, 10633, 55440, 55470, 55471, 10988, 55443, 55473, 55474, 
10990, 10991, 55441, 55472, 10970
11999, 10643, 54999, 55009, 10633, 10644, 55000, 55010, 10634, 55443, 55473, 55474, 10990, 55446, 55476, 55477, 
10992, 10993, 55444, 55475, 10972
12000, 10644, 55000, 55010, 10634, 10645, 55001, 55011, 10635, 55446, 55476, 55477, 10992, 55449, 55479, 55480, 
10994, 10995, 55447, 55478, 10974
12001, 10645, 55001, 55011, 10635, 10646, 55002, 55012, 10636, 55449, 55479, 55480, 10994, 55452, 55482, 55483, 
10996, 10997, 55450, 55481, 10976
12002, 10646, 55002, 55012, 10636, 774, 11359, 11360, 773, 55452, 55482, 55483, 10996, 11392, 11393, 11394, 
796, 10998, 55453, 55484, 10977
12003, 617, 11230, 11231, 616, 10627, 55003, 55013, 10617, 11263, 11266, 11265, 639, 55456, 55486, 55487, 
10957, 10958, 55454, 55485, 10937
12004, 10627, 55003, 55013, 10617, 10628, 55004, 55014, 10618, 55456, 55486, 55487, 10957, 55459, 55489, 55490, 
10959, 10960, 55457, 55488, 10939
12005, 10628, 55004, 55014, 10618, 10629, 55005, 55015, 10619, 55459, 55489, 55490, 10959, 55462, 55492, 55493, 
10961, 10962, 55460, 55491, 10941
12006, 10629, 55005, 55015, 10619, 10630, 55006, 55016, 10620, 55462, 55492, 55493, 10961, 55465, 55495, 55496, 
10963, 10964, 55463, 55494, 10943
12007, 10630, 55006, 55016, 10620, 10631, 55007, 55017, 10621, 55465, 55495, 55496, 10963, 55468, 55498, 55499, 
10965, 10966, 55466, 55497, 10945
12008, 10631, 55007, 55017, 10621, 10632, 55008, 55018, 10622, 55468, 55498, 55499, 10965, 55471, 55501, 55502, 
10967, 10968, 55469, 55500, 10947
12009, 10632, 55008, 55018, 10622, 10633, 55009, 55019, 10623, 55471, 55501, 55502, 10967, 55474, 55504, 55505, 
10969, 10970, 55472, 55503, 10949
12010, 10633, 55009, 55019, 10623, 10634, 55010, 55020, 10624, 55474, 55504, 55505, 10969, 55477, 55507, 55508, 
10971, 10972, 55475, 55506, 10951
12011, 10634, 55010, 55020, 10624, 10635, 55011, 55021, 10625, 55477, 55507, 55508, 10971, 55480, 55510, 55511, 
10973, 10974, 55478, 55509, 10953
12012, 10635, 55011, 55021, 10625, 10636, 55012, 55022, 10626, 55480, 55510, 55511, 10973, 55483, 55513, 55514, 
10975, 10976, 55481, 55512, 10955
12013, 10636, 55012, 55022, 10626, 773, 11360, 11361, 772, 55483, 55513, 55514, 10975, 11394, 11395, 11396, 
795, 10977, 55484, 55515, 10956
12014, 616, 11231, 11232, 615, 10617, 55013, 55023, 10607, 11265, 11268, 11267, 638, 55487, 55517, 55518, 
10936, 10937, 55485, 55516, 10916
12015, 10617, 55013, 55023, 10607, 10618, 55014, 55024, 10608, 55487, 55517, 55518, 10936, 55490, 55520, 55521, 
10938, 10939, 55488, 55519, 10918
12016, 10618, 55014, 55024, 10608, 10619, 55015, 55025, 10609, 55490, 55520, 55521, 10938, 55493, 55523, 55524, 
10940, 10941, 55491, 55522, 10920
12017, 10619, 55015, 55025, 10609, 10620, 55016, 55026, 10610, 55493, 55523, 55524, 10940, 55496, 55526, 55527, 
10942, 10943, 55494, 55525, 10922
12018, 10620, 55016, 55026, 10610, 10621, 55017, 55027, 10611, 55496, 55526, 55527, 10942, 55499, 55529, 55530, 
10944, 10945, 55497, 55528, 10924
12019, 10621, 55017, 55027, 10611, 10622, 55018, 55028, 10612, 55499, 55529, 55530, 10944, 55502, 55532, 55533, 
10946, 10947, 55500, 55531, 10926
12020, 10622, 55018, 55028, 10612, 10623, 55019, 55029, 10613, 55502, 55532, 55533, 10946, 55505, 55535, 55536, 
10948, 10949, 55503, 55534, 10928
12021, 10623, 55019, 55029, 10613, 10624, 55020, 55030, 10614, 55505, 55535, 55536, 10948, 55508, 55538, 55539, 
10950, 10951, 55506, 55537, 10930
12022, 10624, 55020, 55030, 10614, 10625, 55021, 55031, 10615, 55508, 55538, 55539, 10950, 55511, 55541, 55542, 
10952, 10953, 55509, 55540, 10932
12023, 10625, 55021, 55031, 10615, 10626, 55022, 55032, 10616, 55511, 55541, 55542, 10952, 55514, 55544, 55545, 
10954, 10955, 55512, 55543, 10934
12024, 10626, 55022, 55032, 10616, 772, 11361, 11362, 771, 55514, 55544, 55545, 10954, 11396, 11397, 11398, 
794, 10956, 55515, 55546, 10935
12025, 615, 11232, 11233, 614, 10607, 55023, 55033, 10597, 11267, 11270, 11269, 637, 55518, 55548, 55549, 
10915, 10916, 55516, 55547, 10895
12026, 10607, 55023, 55033, 10597, 10608, 55024, 55034, 10598, 55518, 55548, 55549, 10915, 55521, 55551, 55552, 
10917, 10918, 55519, 55550, 10897
12027, 10608, 55024, 55034, 10598, 10609, 55025, 55035, 10599, 55521, 55551, 55552, 10917, 55524, 55554, 55555, 
10919, 10920, 55522, 55553, 10899
12028, 10609, 55025, 55035, 10599, 10610, 55026, 55036, 10600, 55524, 55554, 55555, 10919, 55527, 55557, 55558, 
10921, 10922, 55525, 55556, 10901
12029, 10610, 55026, 55036, 10600, 10611, 55027, 55037, 10601, 55527, 55557, 55558, 10921, 55530, 55560, 55561, 
10923, 10924, 55528, 55559, 10903
12030, 10611, 55027, 55037, 10601, 10612, 55028, 55038, 10602, 55530, 55560, 55561, 10923, 55533, 55563, 55564, 
10925, 10926, 55531, 55562, 10905
12031, 10612, 55028, 55038, 10602, 10613, 55029, 55039, 10603, 55533, 55563, 55564, 10925, 55536, 55566, 55567, 
10927, 10928, 55534, 55565, 10907
12032, 10613, 55029, 55039, 10603, 10614, 55030, 55040, 10604, 55536, 55566, 55567, 10927, 55539, 55569, 55570, 
10929, 10930, 55537, 55568, 10909
12033, 10614, 55030, 55040, 10604, 10615, 55031, 55041, 10605, 55539, 55569, 55570, 10929, 55542, 55572, 55573, 
10931, 10932, 55540, 55571, 10911
12034, 10615, 55031, 55041, 10605, 10616, 55032, 55042, 10606, 55542, 55572, 55573, 10931, 55545, 55575, 55576, 
10933, 10934, 55543, 55574, 10913
12035, 10616, 55032, 55042, 10606, 771, 11362, 11363, 770, 55545, 55575, 55576, 10933, 11398, 11399, 11400, 
793, 10935, 55546, 55577, 10914
12036, 614, 11233, 11234, 613, 10597, 55033, 55043, 10587, 11269, 11272, 11271, 636, 55549, 55579, 55580, 
10894, 10895, 55547, 55578, 10874
12037, 10597, 55033, 55043, 10587, 10598, 55034, 55044, 10588, 55549, 55579, 55580, 10894, 55552, 55582, 55583, 
10896, 10897, 55550, 55581, 10876
12038, 10598, 55034, 55044, 10588, 10599, 55035, 55045, 10589, 55552, 55582, 55583, 10896, 55555, 55585, 55586, 
10898, 10899, 55553, 55584, 10878
12039, 10599, 55035, 55045, 10589, 10600, 55036, 55046, 10590, 55555, 55585, 55586, 10898, 55558, 55588, 55589, 
10900, 10901, 55556, 55587, 10880
12040, 10600, 55036, 55046, 10590, 10601, 55037, 55047, 10591, 55558, 55588, 55589, 10900, 55561, 55591, 55592, 
10902, 10903, 55559, 55590, 10882
12041, 10601, 55037, 55047, 10591, 10602, 55038, 55048, 10592, 55561, 55591, 55592, 10902, 55564, 55594, 55595, 
10904, 10905, 55562, 55593, 10884
12042, 10602, 55038, 55048, 10592, 10603, 55039, 55049, 10593, 55564, 55594, 55595, 10904, 55567, 55597, 55598, 
10906, 10907, 55565, 55596, 10886
12043, 10603, 55039, 55049, 10593, 10604, 55040, 55050, 10594, 55567, 55597, 55598, 10906, 55570, 55600, 55601, 
10908, 10909, 55568, 55599, 10888
12044, 10604, 55040, 55050, 10594, 10605, 55041, 55051, 10595, 55570, 55600, 55601, 10908, 55573, 55603, 55604, 
10910, 10911, 55571, 55602, 10890
12045, 10605, 55041, 55051, 10595, 10606, 55042, 55052, 10596, 55573, 55603, 55604, 10910, 55576, 55606, 55607, 
10912, 10913, 55574, 55605, 10892
12046, 10606, 55042, 55052, 10596, 770, 11363, 11364, 769, 55576, 55606, 55607, 10912, 11400, 11401, 11402, 
792, 10914, 55577, 55608, 10893
12047, 613, 11234, 11235, 612, 10587, 55043, 55053, 10577, 11271, 11274, 11273, 635, 55580, 55610, 55611, 
10873, 10874, 55578, 55609, 10853
12048, 10587, 55043, 55053, 10577, 10588, 55044, 55054, 10578, 55580, 55610, 55611, 10873, 55583, 55613, 55614, 
10875, 10876, 55581, 55612, 10855
12049, 10588, 55044, 55054, 10578, 10589, 55045, 55055, 10579, 55583, 55613, 55614, 10875, 55586, 55616, 55617, 
10877, 10878, 55584, 55615, 10857
12050, 10589, 55045, 55055, 10579, 10590, 55046, 55056, 10580, 55586, 55616, 55617, 10877, 55589, 55619, 55620, 
10879, 10880, 55587, 55618, 10859
12051, 10590, 55046, 55056, 10580, 10591, 55047, 55057, 10581, 55589, 55619, 55620, 10879, 55592, 55622, 55623, 
10881, 10882, 55590, 55621, 10861
12052, 10591, 55047, 55057, 10581, 10592, 55048, 55058, 10582, 55592, 55622, 55623, 10881, 55595, 55625, 55626, 
10883, 10884, 55593, 55624, 10863
12053, 10592, 55048, 55058, 10582, 10593, 55049, 55059, 10583, 55595, 55625, 55626, 10883, 55598, 55628, 55629, 
10885, 10886, 55596, 55627, 10865
12054, 10593, 55049, 55059, 10583, 10594, 55050, 55060, 10584, 55598, 55628, 55629, 10885, 55601, 55631, 55632, 
10887, 10888, 55599, 55630, 10867
12055, 10594, 55050, 55060, 10584, 10595, 55051, 55061, 10585, 55601, 55631, 55632, 10887, 55604, 55634, 55635, 
10889, 10890, 55602, 55633, 10869
12056, 10595, 55051, 55061, 10585, 10596, 55052, 55062, 10586, 55604, 55634, 55635, 10889, 55607, 55637, 55638, 
10891, 10892, 55605, 55636, 10871
12057, 10596, 55052, 55062, 10586, 769, 11364, 11365, 768, 55607, 55637, 55638, 10891, 11402, 11403, 11404, 
791, 10893, 55608, 55639, 10872
12058, 612, 11235, 11236, 611, 10577, 55053, 55063, 10567, 11273, 11276, 11275, 634, 55611, 55641, 55642, 
10852, 10853, 55609, 55640, 10832
12059, 10577, 55053, 55063, 10567, 10578, 55054, 55064, 10568, 55611, 55641, 55642, 10852, 55614, 55644, 55645, 
10854, 10855, 55612, 55643, 10834
12060, 10578, 55054, 55064, 10568, 10579, 55055, 55065, 10569, 55614, 55644, 55645, 10854, 55617, 55647, 55648, 
10856, 10857, 55615, 55646, 10836
12061, 10579, 55055, 55065, 10569, 10580, 55056, 55066, 10570, 55617, 55647, 55648, 10856, 55620, 55650, 55651, 
10858, 10859, 55618, 55649, 10838
12062, 10580, 55056, 55066, 10570, 10581, 55057, 55067, 10571, 55620, 55650, 55651, 10858, 55623, 55653, 55654, 
10860, 10861, 55621, 55652, 10840
12063, 10581, 55057, 55067, 10571, 10582, 55058, 55068, 10572, 55623, 55653, 55654, 10860, 55626, 55656, 55657, 
10862, 10863, 55624, 55655, 10842
12064, 10582, 55058, 55068, 10572, 10583, 55059, 55069, 10573, 55626, 55656, 55657, 10862, 55629, 55659, 55660, 
10864, 10865, 55627, 55658, 10844
12065, 10583, 55059, 55069, 10573, 10584, 55060, 55070, 10574, 55629, 55659, 55660, 10864, 55632, 55662, 55663, 
10866, 10867, 55630, 55661, 10846
12066, 10584, 55060, 55070, 10574, 10585, 55061, 55071, 10575, 55632, 55662, 55663, 10866, 55635, 55665, 55666, 
10868, 10869, 55633, 55664, 10848
12067, 10585, 55061, 55071, 10575, 10586, 55062, 55072, 10576, 55635, 55665, 55666, 10868, 55638, 55668, 55669, 
10870, 10871, 55636, 55667, 10850
12068, 10586, 55062, 55072, 10576, 768, 11365, 11366, 767, 55638, 55668, 55669, 10870, 11404, 11405, 11406, 
790, 10872, 55639, 55670, 10851
12069, 611, 11236, 11237, 610, 10567, 55063, 55073, 10557, 11275, 11278, 11277, 633, 55642, 55672, 55673, 
10831, 10832, 55640, 55671, 10811
12070, 10567, 55063, 55073, 10557, 10568, 55064, 55074, 10558, 55642, 55672, 55673, 10831, 55645, 55675, 55676, 
10833, 10834, 55643, 55674, 10813
12071, 10568, 55064, 55074, 10558, 10569, 55065, 55075, 10559, 55645, 55675, 55676, 10833, 55648, 55678, 55679, 
10835, 10836, 55646, 55677, 10815
12072, 10569, 55065, 55075, 10559, 10570, 55066, 55076, 10560, 55648, 55678, 55679, 10835, 55651, 55681, 55682, 
10837, 10838, 55649, 55680, 10817
12073, 10570, 55066, 55076, 10560, 10571, 55067, 55077, 10561, 55651, 55681, 55682, 10837, 55654, 55684, 55685, 
10839, 10840, 55652, 55683, 10819
12074, 10571, 55067, 55077, 10561, 10572, 55068, 55078, 10562, 55654, 55684, 55685, 10839, 55657, 55687, 55688, 
10841, 10842, 55655, 55686, 10821
12075, 10572, 55068, 55078, 10562, 10573, 55069, 55079, 10563, 55657, 55687, 55688, 10841, 55660, 55690, 55691, 
10843, 10844, 55658, 55689, 10823
12076, 10573, 55069, 55079, 10563, 10574, 55070, 55080, 10564, 55660, 55690, 55691, 10843, 55663, 55693, 55694, 
10845, 10846, 55661, 55692, 10825
12077, 10574, 55070, 55080, 10564, 10575, 55071, 55081, 10565, 55663, 55693, 55694, 10845, 55666, 55696, 55697, 
10847, 10848, 55664, 55695, 10827
12078, 10575, 55071, 55081, 10565, 10576, 55072, 55082, 10566, 55666, 55696, 55697, 10847, 55669, 55699, 55700, 
10849, 10850, 55667, 55698, 10829
12079, 10576, 55072, 55082, 10566, 767, 11366, 11367, 766, 55669, 55699, 55700, 10849, 11406, 11407, 11408, 
789, 10851, 55670, 55701, 10830
12080, 610, 11237, 11238, 609, 10557, 55073, 55083, 10547, 11277, 11280, 11279, 632, 55673, 55703, 55704, 
10810, 10811, 55671, 55702, 10790
12081, 10557, 55073, 55083, 10547, 10558, 55074, 55084, 10548, 55673, 55703, 55704, 10810, 55676, 55706, 55707, 
10812, 10813, 55674, 55705, 10792
12082, 10558, 55074, 55084, 10548, 10559, 55075, 55085, 10549, 55676, 55706, 55707, 10812, 55679, 55709, 55710, 
10814, 10815, 55677, 55708, 10794
12083, 10559, 55075, 55085, 10549, 10560, 55076, 55086, 10550, 55679, 55709, 55710, 10814, 55682, 55712, 55713, 
10816, 10817, 55680, 55711, 10796
12084, 10560, 55076, 55086, 10550, 10561, 55077, 55087, 10551, 55682, 55712, 55713, 10816, 55685, 55715, 55716, 
10818, 10819, 55683, 55714, 10798
12085, 10561, 55077, 55087, 10551, 10562, 55078, 55088, 10552, 55685, 55715, 55716, 10818, 55688, 55718, 55719, 
10820, 10821, 55686, 55717, 10800
12086, 10562, 55078, 55088, 10552, 10563, 55079, 55089, 10553, 55688, 55718, 55719, 10820, 55691, 55721, 55722, 
10822, 10823, 55689, 55720, 10802
12087, 10563, 55079, 55089, 10553, 10564, 55080, 55090, 10554, 55691, 55721, 55722, 10822, 55694, 55724, 55725, 
10824, 10825, 55692, 55723, 10804
12088, 10564, 55080, 55090, 10554, 10565, 55081, 55091, 10555, 55694, 55724, 55725, 10824, 55697, 55727, 55728, 
10826, 10827, 55695, 55726, 10806
12089, 10565, 55081, 55091, 10555, 10566, 55082, 55092, 10556, 55697, 55727, 55728, 10826, 55700, 55730, 55731, 
10828, 10829, 55698, 55729, 10808
12090, 10566, 55082, 55092, 10556, 766, 11367, 11368, 765, 55700, 55730, 55731, 10828, 11408, 11409, 11410, 
788, 10830, 55701, 55732, 10809
12091, 609, 11238, 11239, 608, 10547, 55083, 55093, 10537, 11279, 11282, 11281, 631, 55704, 55734, 55735, 
10789, 10790, 55702, 55733, 10769
12092, 10547, 55083, 55093, 10537, 10548, 55084, 55094, 10538, 55704, 55734, 55735, 10789, 55707, 55737, 55738, 
10791, 10792, 55705, 55736, 10771
12093, 10548, 55084, 55094, 10538, 10549, 55085, 55095, 10539, 55707, 55737, 55738, 10791, 55710, 55740, 55741, 
10793, 10794, 55708, 55739, 10773
12094, 10549, 55085, 55095, 10539, 10550, 55086, 55096, 10540, 55710, 55740, 55741, 10793, 55713, 55743, 55744, 
10795, 10796, 55711, 55742, 10775
12095, 10550, 55086, 55096, 10540, 10551, 55087, 55097, 10541, 55713, 55743, 55744, 10795, 55716, 55746, 55747, 
10797, 10798, 55714, 55745, 10777
12096, 10551, 55087, 55097, 10541, 10552, 55088, 55098, 10542, 55716, 55746, 55747, 10797, 55719, 55749, 55750, 
10799, 10800, 55717, 55748, 10779
12097, 10552, 55088, 55098, 10542, 10553, 55089, 55099, 10543, 55719, 55749, 55750, 10799, 55722, 55752, 55753, 
10801, 10802, 55720, 55751, 10781
12098, 10553, 55089, 55099, 10543, 10554, 55090, 55100, 10544, 55722, 55752, 55753, 10801, 55725, 55755, 55756, 
10803, 10804, 55723, 55754, 10783
12099, 10554, 55090, 55100, 10544, 10555, 55091, 55101, 10545, 55725, 55755, 55756, 10803, 55728, 55758, 55759, 
10805, 10806, 55726, 55757, 10785
12100, 10555, 55091, 55101, 10545, 10556, 55092, 55102, 10546, 55728, 55758, 55759, 10805, 55731, 55761, 55762, 
10807, 10808, 55729, 55760, 10787
12101, 10556, 55092, 55102, 10546, 765, 11368, 11369, 764, 55731, 55761, 55762, 10807, 11410, 11411, 11412, 
787, 10809, 55732, 55763, 10788
12102, 608, 11239, 11240, 607, 10537, 55093, 55103, 10527, 11281, 11284, 11283, 630, 55735, 55765, 55766, 
10768, 10769, 55733, 55764, 10748
12103, 10537, 55093, 55103, 10527, 10538, 55094, 55104, 10528, 55735, 55765, 55766, 10768, 55738, 55768, 55769, 
10770, 10771, 55736, 55767, 10750
12104, 10538, 55094, 55104, 10528, 10539, 55095, 55105, 10529, 55738, 55768, 55769, 10770, 55741, 55771, 55772, 
10772, 10773, 55739, 55770, 10752
12105, 10539, 55095, 55105, 10529, 10540, 55096, 55106, 10530, 55741, 55771, 55772, 10772, 55744, 55774, 55775, 
10774, 10775, 55742, 55773, 10754
12106, 10540, 55096, 55106, 10530, 10541, 55097, 55107, 10531, 55744, 55774, 55775, 10774, 55747, 55777, 55778, 
10776, 10777, 55745, 55776, 10756
12107, 10541, 55097, 55107, 10531, 10542, 55098, 55108, 10532, 55747, 55777, 55778, 10776, 55750, 55780, 55781, 
10778, 10779, 55748, 55779, 10758
12108, 10542, 55098, 55108, 10532, 10543, 55099, 55109, 10533, 55750, 55780, 55781, 10778, 55753, 55783, 55784, 
10780, 10781, 55751, 55782, 10760
12109, 10543, 55099, 55109, 10533, 10544, 55100, 55110, 10534, 55753, 55783, 55784, 10780, 55756, 55786, 55787, 
10782, 10783, 55754, 55785, 10762
12110, 10544, 55100, 55110, 10534, 10545, 55101, 55111, 10535, 55756, 55786, 55787, 10782, 55759, 55789, 55790, 
10784, 10785, 55757, 55788, 10764
12111, 10545, 55101, 55111, 10535, 10546, 55102, 55112, 10536, 55759, 55789, 55790, 10784, 55762, 55792, 55793, 
10786, 10787, 55760, 55791, 10766
12112, 10546, 55102, 55112, 10536, 764, 11369, 11370, 763, 55762, 55792, 55793, 10786, 11412, 11413, 11414, 
786, 10788, 55763, 55794, 10767
12113, 607, 11240, 832, 14, 10527, 55103, 11447, 808, 11283, 11285, 833, 629, 55766, 55795, 11467, 
10747, 10748, 55764, 11468, 818
12114, 10527, 55103, 11447, 808, 10528, 55104, 11446, 809, 55766, 55795, 11467, 10747, 55769, 55796, 11465, 
10749, 10750, 55767, 11466, 819
12115, 10528, 55104, 11446, 809, 10529, 55105, 11445, 810, 55769, 55796, 11465, 10749, 55772, 55797, 11463, 
10751, 10752, 55770, 11464, 820
12116, 10529, 55105, 11445, 810, 10530, 55106, 11444, 811, 55772, 55797, 11463, 10751, 55775, 55798, 11461, 
10753, 10754, 55773, 11462, 821
12117, 10530, 55106, 11444, 811, 10531, 55107, 11443, 812, 55775, 55798, 11461, 10753, 55778, 55799, 11459, 
10755, 10756, 55776, 11460, 822
12118, 10531, 55107, 11443, 812, 10532, 55108, 11442, 813, 55778, 55799, 11459, 10755, 55781, 55800, 11457, 
10757, 10758, 55779, 11458, 823
12119, 10532, 55108, 11442, 813, 10533, 55109, 11441, 814, 55781, 55800, 11457, 10757, 55784, 55801, 11455, 
10759, 10760, 55782, 11456, 824
12120, 10533, 55109, 11441, 814, 10534, 55110, 11440, 815, 55784, 55801, 11455, 10759, 55787, 55802, 11453, 
10761, 10762, 55785, 11454, 825
12121, 10534, 55110, 11440, 815, 10535, 55111, 11439, 816, 55787, 55802, 11453, 10761, 55790, 55803, 11451, 
10763, 10764, 55788, 11452, 826
12122, 10535, 55111, 11439, 816, 10536, 55112, 11438, 817, 55790, 55803, 11451, 10763, 55793, 55804, 11449, 
10765, 10766, 55791, 11450, 827
12123, 10536, 55112, 11438, 817, 763, 11370, 904, 16, 55793, 55804, 11449, 10765, 11414, 11415, 905, 
785, 10767, 55794, 11448, 828
12124, 829, 17, 856, 11219, 11317, 883, 11689, 54893, 831, 879, 11286, 11242, 11348, 12161, 55805, 
55114, 11338, 893, 12141, 55113
12125, 11317, 883, 11689, 54893, 11316, 884, 11690, 54894, 11348, 12161, 55805, 55114, 11347, 12162, 55806, 
55117, 11337, 894, 12143, 55116
12126, 11316, 884, 11690, 54894, 11315, 885, 11691, 54895, 11347, 12162, 55806, 55117, 11346, 12163, 55807, 
55120, 11335, 895, 12145, 55119
12127, 11315, 885, 11691, 54895, 11314, 886, 11692, 54896, 11346, 12163, 55807, 55120, 11345, 12164, 55808, 
55123, 11333, 896, 12147, 55122
12128, 11314, 886, 11692, 54896, 11313, 887, 11693, 54897, 11345, 12164, 55808, 55123, 11344, 12165, 55809, 
55126, 11331, 897, 12149, 55125
12129, 11313, 887, 11693, 54897, 11312, 888, 11694, 54898, 11344, 12165, 55809, 55126, 11343, 12166, 55810, 
55129, 11329, 898, 12151, 55128
12130, 11312, 888, 11694, 54898, 11311, 889, 11695, 54899, 11343, 12166, 55810, 55129, 11342, 12167, 55811, 
55132, 11327, 899, 12153, 55131
12131, 11311, 889, 11695, 54899, 11310, 890, 11696, 54900, 11342, 12167, 55811, 55132, 11341, 12168, 55812, 
55135, 11325, 900, 12155, 55134
12132, 11310, 890, 11696, 54900, 11309, 891, 11697, 54901, 11341, 12168, 55812, 55135, 11340, 12169, 55813, 
55138, 11323, 901, 12157, 55137
12133, 11309, 891, 11697, 54901, 11308, 892, 11698, 54902, 11340, 12169, 55813, 55138, 11339, 12170, 55814, 
55141, 11321, 902, 12159, 55140
12134, 11308, 892, 11698, 54902, 880, 19, 928, 11349, 11339, 12170, 55814, 55141, 882, 951, 11416, 
11371, 11319, 903, 12160, 55143
12135, 11219, 856, 855, 11220, 54893, 11689, 11679, 54903, 11286, 878, 11287, 11244, 55805, 12140, 55815, 
55145, 55113, 12141, 12120, 55144
12136, 54893, 11689, 11679, 54903, 54894, 11690, 11680, 54904, 55805, 12140, 55815, 55145, 55806, 12142, 55816, 
55148, 55116, 12143, 12122, 55147
12137, 54894, 11690, 11680, 54904, 54895, 11691, 11681, 54905, 55806, 12142, 55816, 55148, 55807, 12144, 55817, 
55151, 55119, 12145, 12124, 55150
12138, 54895, 11691, 11681, 54905, 54896, 11692, 11682, 54906, 55807, 12144, 55817, 55151, 55808, 12146, 55818, 
55154, 55122, 12147, 12126, 55153
12139, 54896, 11692, 11682, 54906, 54897, 11693, 11683, 54907, 55808, 12146, 55818, 55154, 55809, 12148, 55819, 
55157, 55125, 12149, 12128, 55156
12140, 54897, 11693, 11683, 54907, 54898, 11694, 11684, 54908, 55809, 12148, 55819, 55157, 55810, 12150, 55820, 
55160, 55128, 12151, 12130, 55159
12141, 54898, 11694, 11684, 54908, 54899, 11695, 11685, 54909, 55810, 12150, 55820, 55160, 55811, 12152, 55821, 
55163, 55131, 12153, 12132, 55162
12142, 54899, 11695, 11685, 54909, 54900, 11696, 11686, 54910, 55811, 12152, 55821, 55163, 55812, 12154, 55822, 
55166, 55134, 12155, 12134, 55165
12143, 54900, 11696, 11686, 54910, 54901, 11697, 11687, 54911, 55812, 12154, 55822, 55166, 55813, 12156, 55823, 
55169, 55137, 12157, 12136, 55168
12144, 54901, 11697, 11687, 54911, 54902, 11698, 11688, 54912, 55813, 12156, 55823, 55169, 55814, 12158, 55824, 
55172, 55140, 12159, 12138, 55171
12145, 54902, 11698, 11688, 54912, 11349, 928, 927, 11350, 55814, 12158, 55824, 55172, 11416, 950, 11417, 
11373, 55143, 12160, 12139, 55174
12146, 11220, 855, 854, 11221, 54903, 11679, 11669, 54913, 11287, 877, 11288, 11246, 55815, 12119, 55825, 
55176, 55144, 12120, 12099, 55175
12147, 54903, 11679, 11669, 54913, 54904, 11680, 11670, 54914, 55815, 12119, 55825, 55176, 55816, 12121, 55826, 
55179, 55147, 12122, 12101, 55178
12148, 54904, 11680, 11670, 54914, 54905, 11681, 11671, 54915, 55816, 12121, 55826, 55179, 55817, 12123, 55827, 
55182, 55150, 12124, 12103, 55181
12149, 54905, 11681, 11671, 54915, 54906, 11682, 11672, 54916, 55817, 12123, 55827, 55182, 55818, 12125, 55828, 
55185, 55153, 12126, 12105, 55184
12150, 54906, 11682, 11672, 54916, 54907, 11683, 11673, 54917, 55818, 12125, 55828, 55185, 55819, 12127, 55829, 
55188, 55156, 12128, 12107, 55187
12151, 54907, 11683, 11673, 54917, 54908, 11684, 11674, 54918, 55819, 12127, 55829, 55188, 55820, 12129, 55830, 
55191, 55159, 12130, 12109, 55190
12152, 54908, 11684, 11674, 54918, 54909, 11685, 11675, 54919, 55820, 12129, 55830, 55191, 55821, 12131, 55831, 
55194, 55162, 12132, 12111, 55193
12153, 54909, 11685, 11675, 54919, 54910, 11686, 11676, 54920, 55821, 12131, 55831, 55194, 55822, 12133, 55832, 
55197, 55165, 12134, 12113, 55196
12154, 54910, 11686, 11676, 54920, 54911, 11687, 11677, 54921, 55822, 12133, 55832, 55197, 55823, 12135, 55833, 
55200, 55168, 12136, 12115, 55199
12155, 54911, 11687, 11677, 54921, 54912, 11688, 11678, 54922, 55823, 12135, 55833, 55200, 55824, 12137, 55834, 
55203, 55171, 12138, 12117, 55202
12156, 54912, 11688, 11678, 54922, 11350, 927, 926, 11351, 55824, 12137, 55834, 55203, 11417, 949, 11418, 
11375, 55174, 12139, 12118, 55205
12157, 11221, 854, 853, 11222, 54913, 11669, 11659, 54923, 11288, 876, 11289, 11248, 55825, 12098, 55835, 
55207, 55175, 12099, 12078, 55206
12158, 54913, 11669, 11659, 54923, 54914, 11670, 11660, 54924, 55825, 12098, 55835, 55207, 55826, 12100, 55836, 
55210, 55178, 12101, 12080, 55209
12159, 54914, 11670, 11660, 54924, 54915, 11671, 11661, 54925, 55826, 12100, 55836, 55210, 55827, 12102, 55837, 
55213, 55181, 12103, 12082, 55212
12160, 54915, 11671, 11661, 54925, 54916, 11672, 11662, 54926, 55827, 12102, 55837, 55213, 55828, 12104, 55838, 
55216, 55184, 12105, 12084, 55215
12161, 54916, 11672, 11662, 54926, 54917, 11673, 11663, 54927, 55828, 12104, 55838, 55216, 55829, 12106, 55839, 
55219, 55187, 12107, 12086, 55218
12162, 54917, 11673, 11663, 54927, 54918, 11674, 11664, 54928, 55829, 12106, 55839, 55219, 55830, 12108, 55840, 
55222, 55190, 12109, 12088, 55221
12163, 54918, 11674, 11664, 54928, 54919, 11675, 11665, 54929, 55830, 12108, 55840, 55222, 55831, 12110, 55841, 
55225, 55193, 12111, 12090, 55224
12164, 54919, 11675, 11665, 54929, 54920, 11676, 11666, 54930, 55831, 12110, 55841, 55225, 55832, 12112, 55842, 
55228, 55196, 12113, 12092, 55227
12165, 54920, 11676, 11666, 54930, 54921, 11677, 11667, 54931, 55832, 12112, 55842, 55228, 55833, 12114, 55843, 
55231, 55199, 12115, 12094, 55230
12166, 54921, 11677, 11667, 54931, 54922, 11678, 11668, 54932, 55833, 12114, 55843, 55231, 55834, 12116, 55844, 
55234, 55202, 12117, 12096, 55233
12167, 54922, 11678, 11668, 54932, 11351, 926, 925, 11352, 55834, 12116, 55844, 55234, 11418, 948, 11419, 
11377, 55205, 12118, 12097, 55236
12168, 11222, 853, 852, 11223, 54923, 11659, 11649, 54933, 11289, 875, 11290, 11250, 55835, 12077, 55845, 
55238, 55206, 12078, 12057, 55237
12169, 54923, 11659, 11649, 54933, 54924, 11660, 11650, 54934, 55835, 12077, 55845, 55238, 55836, 12079, 55846, 
55241, 55209, 12080, 12059, 55240
12170, 54924, 11660, 11650, 54934, 54925, 11661, 11651, 54935, 55836, 12079, 55846, 55241, 55837, 12081, 55847, 
55244, 55212, 12082, 12061, 55243
12171, 54925, 11661, 11651, 54935, 54926, 11662, 11652, 54936, 55837, 12081, 55847, 55244, 55838, 12083, 55848, 
55247, 55215, 12084, 12063, 55246
12172, 54926, 11662, 11652, 54936, 54927, 11663, 11653, 54937, 55838, 12083, 55848, 55247, 55839, 12085, 55849, 
55250, 55218, 12086, 12065, 55249
12173, 54927, 11663, 11653, 54937, 54928, 11664, 11654, 54938, 55839, 12085, 55849, 55250, 55840, 12087, 55850, 
55253, 55221, 12088, 12067, 55252
12174, 54928, 11664, 11654, 54938, 54929, 11665, 11655, 54939, 55840, 12087, 55850, 55253, 55841, 12089, 55851, 
55256, 55224, 12090, 12069, 55255
12175, 54929, 11665, 11655, 54939, 54930, 11666, 11656, 54940, 55841, 12089, 55851, 55256, 55842, 12091, 55852, 
55259, 55227, 12092, 12071, 55258
12176, 54930, 11666, 11656, 54940, 54931, 11667, 11657, 54941, 55842, 12091, 55852, 55259, 55843, 12093, 55853, 
55262, 55230, 12094, 12073, 55261
12177, 54931, 11667, 11657, 54941, 54932, 11668, 11658, 54942, 55843, 12093, 55853, 55262, 55844, 12095, 55854, 
55265, 55233, 12096, 12075, 55264
12178, 54932, 11668, 11658, 54942, 11352, 925, 924, 11353, 55844, 12095, 55854, 55265, 11419, 947, 11420, 
11379, 55236, 12097, 12076, 55267
12179, 11223, 852, 851, 11224, 54933, 11649, 11639, 54943, 11290, 874, 11291, 11252, 55845, 12056, 55855, 
55269, 55237, 12057, 12036, 55268
12180, 54933, 11649, 11639, 54943, 54934, 11650, 11640, 54944, 55845, 12056, 55855, 55269, 55846, 12058, 55856, 
55272, 55240, 12059, 12038, 55271
12181, 54934, 11650, 11640, 54944, 54935, 11651, 11641, 54945, 55846, 12058, 55856, 55272, 55847, 12060, 55857, 
55275, 55243, 12061, 12040, 55274
12182, 54935, 11651, 11641, 54945, 54936, 11652, 11642, 54946, 55847, 12060, 55857, 55275, 55848, 12062, 55858, 
55278, 55246, 12063, 12042, 55277
12183, 54936, 11652, 11642, 54946, 54937, 11653, 11643, 54947, 55848, 12062, 55858, 55278, 55849, 12064, 55859, 
55281, 55249, 12065, 12044, 55280
12184, 54937, 11653, 11643, 54947, 54938, 11654, 11644, 54948, 55849, 12064, 55859, 55281, 55850, 12066, 55860, 
55284, 55252, 12067, 12046, 55283
12185, 54938, 11654, 11644, 54948, 54939, 11655, 11645, 54949, 55850, 12066, 55860, 55284, 55851, 12068, 55861, 
55287, 55255, 12069, 12048, 55286
12186, 54939, 11655, 11645, 54949, 54940, 11656, 11646, 54950, 55851, 12068, 55861, 55287, 55852, 12070, 55862, 
55290, 55258, 12071, 12050, 55289
12187, 54940, 11656, 11646, 54950, 54941, 11657, 11647, 54951, 55852, 12070, 55862, 55290, 55853, 12072, 55863, 
55293, 55261, 12073, 12052, 55292
12188, 54941, 11657, 11647, 54951, 54942, 11658, 11648, 54952, 55853, 12072, 55863, 55293, 55854, 12074, 55864, 
55296, 55264, 12075, 12054, 55295
12189, 54942, 11658, 11648, 54952, 11353, 924, 923, 11354, 55854, 12074, 55864, 55296, 11420, 946, 11421, 
11381, 55267, 12076, 12055, 55298
12190, 11224, 851, 850, 11225, 54943, 11639, 11629, 54953, 11291, 873, 11292, 11254, 55855, 12035, 55865, 
55300, 55268, 12036, 12015, 55299
12191, 54943, 11639, 11629, 54953, 54944, 11640, 11630, 54954, 55855, 12035, 55865, 55300, 55856, 12037, 55866, 
55303, 55271, 12038, 12017, 55302
12192, 54944, 11640, 11630, 54954, 54945, 11641, 11631, 54955, 55856, 12037, 55866, 55303, 55857, 12039, 55867, 
55306, 55274, 12040, 12019, 55305
12193, 54945, 11641, 11631, 54955, 54946, 11642, 11632, 54956, 55857, 12039, 55867, 55306, 55858, 12041, 55868, 
55309, 55277, 12042, 12021, 55308
12194, 54946, 11642, 11632, 54956, 54947, 11643, 11633, 54957, 55858, 12041, 55868, 55309, 55859, 12043, 55869, 
55312, 55280, 12044, 12023, 55311
12195, 54947, 11643, 11633, 54957, 54948, 11644, 11634, 54958, 55859, 12043, 55869, 55312, 55860, 12045, 55870, 
55315, 55283, 12046, 12025, 55314
12196, 54948, 11644, 11634, 54958, 54949, 11645, 11635, 54959, 55860, 12045, 55870, 55315, 55861, 12047, 55871, 
55318, 55286, 12048, 12027, 55317
12197, 54949, 11645, 11635, 54959, 54950, 11646, 11636, 54960, 55861, 12047, 55871, 55318, 55862, 12049, 55872, 
55321, 55289, 12050, 12029, 55320
12198, 54950, 11646, 11636, 54960, 54951, 11647, 11637, 54961, 55862, 12049, 55872, 55321, 55863, 12051, 55873, 
55324, 55292, 12052, 12031, 55323
12199, 54951, 11647, 11637, 54961, 54952, 11648, 11638, 54962, 55863, 12051, 55873, 55324, 55864, 12053, 55874, 
55327, 55295, 12054, 12033, 55326
12200, 54952, 11648, 11638, 54962, 11354, 923, 922, 11355, 55864, 12053, 55874, 55327, 11421, 945, 11422, 
11383, 55298, 12055, 12034, 55329
12201, 11225, 850, 849, 11226, 54953, 11629, 11619, 54963, 11292, 872, 11293, 11256, 55865, 12014, 55875, 
55331, 55299, 12015, 11994, 55330
12202, 54953, 11629, 11619, 54963, 54954, 11630, 11620, 54964, 55865, 12014, 55875, 55331, 55866, 12016, 55876, 
55334, 55302, 12017, 11996, 55333
12203, 54954, 11630, 11620, 54964, 54955, 11631, 11621, 54965, 55866, 12016, 55876, 55334, 55867, 12018, 55877, 
55337, 55305, 12019, 11998, 55336
12204, 54955, 11631, 11621, 54965, 54956, 11632, 11622, 54966, 55867, 12018, 55877, 55337, 55868, 12020, 55878, 
55340, 55308, 12021, 12000, 55339
12205, 54956, 11632, 11622, 54966, 54957, 11633, 11623, 54967, 55868, 12020, 55878, 55340, 55869, 12022, 55879, 
55343, 55311, 12023, 12002, 55342
12206, 54957, 11633, 11623, 54967, 54958, 11634, 11624, 54968, 55869, 12022, 55879, 55343, 55870, 12024, 55880, 
55346, 55314, 12025, 12004, 55345
12207, 54958, 11634, 11624, 54968, 54959, 11635, 11625, 54969, 55870, 12024, 55880, 55346, 55871, 12026, 55881, 
55349, 55317, 12027, 12006, 55348
12208, 54959, 11635, 11625, 54969, 54960, 11636, 11626, 54970, 55871, 12026, 55881, 55349, 55872, 12028, 55882, 
55352, 55320, 12029, 12008, 55351
12209, 54960, 11636, 11626, 54970, 54961, 11637, 11627, 54971, 55872, 12028, 55882, 55352, 55873, 12030, 55883, 
55355, 55323, 12031, 12010, 55354
12210, 54961, 11637, 11627, 54971, 54962, 11638, 11628, 54972, 55873, 12030, 55883, 55355, 55874, 12032, 55884, 
55358, 55326, 12033, 12012, 55357
12211, 54962, 11638, 11628, 54972, 11355, 922, 921, 11356, 55874, 12032, 55884, 55358, 11422, 944, 11423, 
11385, 55329, 12034, 12013, 55360
12212, 11226, 849, 848, 11227, 54963, 11619, 11609, 54973, 11293, 871, 11294, 11258, 55875, 11993, 55885, 
55362, 55330, 11994, 11973, 55361
12213, 54963, 11619, 11609, 54973, 54964, 11620, 11610, 54974, 55875, 11993, 55885, 55362, 55876, 11995, 55886, 
55365, 55333, 11996, 11975, 55364
12214, 54964, 11620, 11610, 54974, 54965, 11621, 11611, 54975, 55876, 11995, 55886, 55365, 55877, 11997, 55887, 
55368, 55336, 11998, 11977, 55367
12215, 54965, 11621, 11611, 54975, 54966, 11622, 11612, 54976, 55877, 11997, 55887, 55368, 55878, 11999, 55888, 
55371, 55339, 12000, 11979, 55370
12216, 54966, 11622, 11612, 54976, 54967, 11623, 11613, 54977, 55878, 11999, 55888, 55371, 55879, 12001, 55889, 
55374, 55342, 12002, 11981, 55373
12217, 54967, 11623, 11613, 54977, 54968, 11624, 11614, 54978, 55879, 12001, 55889, 55374, 55880, 12003, 55890, 
55377, 55345, 12004, 11983, 55376
12218, 54968, 11624, 11614, 54978, 54969, 11625, 11615, 54979, 55880, 12003, 55890, 55377, 55881, 12005, 55891, 
55380, 55348, 12006, 11985, 55379
12219, 54969, 11625, 11615, 54979, 54970, 11626, 11616, 54980, 55881, 12005, 55891, 55380, 55882, 12007, 55892, 
55383, 55351, 12008, 11987, 55382
12220, 54970, 11626, 11616, 54980, 54971, 11627, 11617, 54981, 55882, 12007, 55892, 55383, 55883, 12009, 55893, 
55386, 55354, 12010, 11989, 55385
12221, 54971, 11627, 11617, 54981, 54972, 11628, 11618, 54982, 55883, 12009, 55893, 55386, 55884, 12011, 55894, 
55389, 55357, 12012, 11991, 55388
12222, 54972, 11628, 11618, 54982, 11356, 921, 920, 11357, 55884, 12011, 55894, 55389, 11423, 943, 11424, 
11387, 55360, 12013, 11992, 55391
12223, 11227, 848, 847, 11228, 54973, 11609, 11599, 54983, 11294, 870, 11295, 11260, 55885, 11972, 55895, 
55393, 55361, 11973, 11952, 55392
12224, 54973, 11609, 11599, 54983, 54974, 11610, 11600, 54984, 55885, 11972, 55895, 55393, 55886, 11974, 55896, 
55396, 55364, 11975, 11954, 55395
12225, 54974, 11610, 11600, 54984, 54975, 11611, 11601, 54985, 55886, 11974, 55896, 55396, 55887, 11976, 55897, 
55399, 55367, 11977, 11956, 55398
12226, 54975, 11611, 11601, 54985, 54976, 11612, 11602, 54986, 55887, 11976, 55897, 55399, 55888, 11978, 55898, 
55402, 55370, 11979, 11958, 55401
12227, 54976, 11612, 11602, 54986, 54977, 11613, 11603, 54987, 55888, 11978, 55898, 55402, 55889, 11980, 55899, 
55405, 55373, 11981, 11960, 55404
12228, 54977, 11613, 11603, 54987, 54978, 11614, 11604, 54988, 55889, 11980, 55899, 55405, 55890, 11982, 55900, 
55408, 55376, 11983, 11962, 55407
12229, 54978, 11614, 11604, 54988, 54979, 11615, 11605, 54989, 55890, 11982, 55900, 55408, 55891, 11984, 55901, 
55411, 55379, 11985, 11964, 55410
12230, 54979, 11615, 11605, 54989, 54980, 11616, 11606, 54990, 55891, 11984, 55901, 55411, 55892, 11986, 55902, 
55414, 55382, 11987, 11966, 55413
12231, 54980, 11616, 11606, 54990, 54981, 11617, 11607, 54991, 55892, 11986, 55902, 55414, 55893, 11988, 55903, 
55417, 55385, 11989, 11968, 55416
12232, 54981, 11617, 11607, 54991, 54982, 11618, 11608, 54992, 55893, 11988, 55903, 55417, 55894, 11990, 55904, 
55420, 55388, 11991, 11970, 55419
12233, 54982, 11618, 11608, 54992, 11357, 920, 919, 11358, 55894, 11990, 55904, 55420, 11424, 942, 11425, 
11389, 55391, 11992, 11971, 55422
12234, 11228, 847, 846, 11229, 54983, 11599, 11589, 54993, 11295, 869, 11296, 11262, 55895, 11951, 55905, 
55424, 55392, 11952, 11931, 55423
12235, 54983, 11599, 11589, 54993, 54984, 11600, 11590, 54994, 55895, 11951, 55905, 55424, 55896, 11953, 55906, 
55427, 55395, 11954, 11933, 55426
12236, 54984, 11600, 11590, 54994, 54985, 11601, 11591, 54995, 55896, 11953, 55906, 55427, 55897, 11955, 55907, 
55430, 55398, 11956, 11935, 55429
12237, 54985, 11601, 11591, 54995, 54986, 11602, 11592, 54996, 55897, 11955, 55907, 55430, 55898, 11957, 55908, 
55433, 55401, 11958, 11937, 55432
12238, 54986, 11602, 11592, 54996, 54987, 11603, 11593, 54997, 55898, 11957, 55908, 55433, 55899, 11959, 55909, 
55436, 55404, 11960, 11939, 55435
12239, 54987, 11603, 11593, 54997, 54988, 11604, 11594, 54998, 55899, 11959, 55909, 55436, 55900, 11961, 55910, 
55439, 55407, 11962, 11941, 55438
12240, 54988, 11604, 11594, 54998, 54989, 11605, 11595, 54999, 55900, 11961, 55910, 55439, 55901, 11963, 55911, 
55442, 55410, 11964, 11943, 55441
12241, 54989, 11605, 11595, 54999, 54990, 11606, 11596, 55000, 55901, 11963, 55911, 55442, 55902, 11965, 55912, 
55445, 55413, 11966, 11945, 55444
12242, 54990, 11606, 11596, 55000, 54991, 11607, 11597, 55001, 55902, 11965, 55912, 55445, 55903, 11967, 55913, 
55448, 55416, 11968, 11947, 55447
12243, 54991, 11607, 11597, 55001, 54992, 11608, 11598, 55002, 55903, 11967, 55913, 55448, 55904, 11969, 55914, 
55451, 55419, 11970, 11949, 55450
12244, 54992, 11608, 11598, 55002, 11358, 919, 918, 11359, 55904, 11969, 55914, 55451, 11425, 941, 11426, 
11391, 55422, 11971, 11950, 55453
12245, 11229, 846, 845, 11230, 54993, 11589, 11579, 55003, 11296, 868, 11297, 11264, 55905, 11930, 55915, 
55455, 55423, 11931, 11910, 55454
12246, 54993, 11589, 11579, 55003, 54994, 11590, 11580, 55004, 55905, 11930, 55915, 55455, 55906, 11932, 55916, 
55458, 55426, 11933, 11912, 55457
12247, 54994, 11590, 11580, 55004, 54995, 11591, 11581, 55005, 55906, 11932, 55916, 55458, 55907, 11934, 55917, 
55461, 55429, 11935, 11914, 55460
12248, 54995, 11591, 11581, 55005, 54996, 11592, 11582, 55006, 55907, 11934, 55917, 55461, 55908, 11936, 55918, 
55464, 55432, 11937, 11916, 55463
12249, 54996, 11592, 11582, 55006, 54997, 11593, 11583, 55007, 55908, 11936, 55918, 55464, 55909, 11938, 55919, 
55467, 55435, 11939, 11918, 55466
12250, 54997, 11593, 11583, 55007, 54998, 11594, 11584, 55008, 55909, 11938, 55919, 55467, 55910, 11940, 55920, 
55470, 55438, 11941, 11920, 55469
12251, 54998, 11594, 11584, 55008, 54999, 11595, 11585, 55009, 55910, 11940, 55920, 55470, 55911, 11942, 55921, 
55473, 55441, 11943, 11922, 55472
12252, 54999, 11595, 11585, 55009, 55000, 11596, 11586, 55010, 55911, 11942, 55921, 55473, 55912, 11944, 55922, 
55476, 55444, 11945, 11924, 55475
12253, 55000, 11596, 11586, 55010, 55001, 11597, 11587, 55011, 55912, 11944, 55922, 55476, 55913, 11946, 55923, 
55479, 55447, 11947, 11926, 55478
12254, 55001, 11597, 11587, 55011, 55002, 11598, 11588, 55012, 55913, 11946, 55923, 55479, 55914, 11948, 55924, 
55482, 55450, 11949, 11928, 55481
12255, 55002, 11598, 11588, 55012, 11359, 918, 917, 11360, 55914, 11948, 55924, 55482, 11426, 940, 11427, 
11393, 55453, 11950, 11929, 55484
12256, 11230, 845, 844, 11231, 55003, 11579, 11569, 55013, 11297, 867, 11298, 11266, 55915, 11909, 55925, 
55486, 55454, 11910, 11889, 55485
12257, 55003, 11579, 11569, 55013, 55004, 11580, 11570, 55014, 55915, 11909, 55925, 55486, 55916, 11911, 55926, 
55489, 55457, 11912, 11891, 55488
12258, 55004, 11580, 11570, 55014, 55005, 11581, 11571, 55015, 55916, 11911, 55926, 55489, 55917, 11913, 55927, 
55492, 55460, 11914, 11893, 55491
12259, 55005, 11581, 11571, 55015, 55006, 11582, 11572, 55016, 55917, 11913, 55927, 55492, 55918, 11915, 55928, 
55495, 55463, 11916, 11895, 55494
12260, 55006, 11582, 11572, 55016, 55007, 11583, 11573, 55017, 55918, 11915, 55928, 55495, 55919, 11917, 55929, 
55498, 55466, 11918, 11897, 55497
12261, 55007, 11583, 11573, 55017, 55008, 11584, 11574, 55018, 55919, 11917, 55929, 55498, 55920, 11919, 55930, 
55501, 55469, 11920, 11899, 55500
12262, 55008, 11584, 11574, 55018, 55009, 11585, 11575, 55019, 55920, 11919, 55930, 55501, 55921, 11921, 55931, 
55504, 55472, 11922, 11901, 55503
12263, 55009, 11585, 11575, 55019, 55010, 11586, 11576, 55020, 55921, 11921, 55931, 55504, 55922, 11923, 55932, 
55507, 55475, 11924, 11903, 55506
12264, 55010, 11586, 11576, 55020, 55011, 11587, 11577, 55021, 55922, 11923, 55932, 55507, 55923, 11925, 55933, 
55510, 55478, 11926, 11905, 55509
12265, 55011, 11587, 11577, 55021, 55012, 11588, 11578, 55022, 55923, 11925, 55933, 55510, 55924, 11927, 55934, 
55513, 55481, 11928, 11907, 55512
12266, 55012, 11588, 11578, 55022, 11360, 917, 916, 11361, 55924, 11927, 55934, 55513, 11427, 939, 11428, 
11395, 55484, 11929, 11908, 55515
12267, 11231, 844, 843, 11232, 55013, 11569, 11559, 55023, 11298, 866, 11299, 11268, 55925, 11888, 55935, 
55517, 55485, 11889, 11868, 55516
12268, 55013, 11569, 11559, 55023, 55014, 11570, 11560, 55024, 55925, 11888, 55935, 55517, 55926, 11890, 55936, 
55520, 55488, 11891, 11870, 55519
12269, 55014, 11570, 11560, 55024, 55015, 11571, 11561, 55025, 55926, 11890, 55936, 55520, 55927, 11892, 55937, 
55523, 55491, 11893, 11872, 55522
12270, 55015, 11571, 11561, 55025, 55016, 11572, 11562, 55026, 55927, 11892, 55937, 55523, 55928, 11894, 55938, 
55526, 55494, 11895, 11874, 55525
12271, 55016, 11572, 11562, 55026, 55017, 11573, 11563, 55027, 55928, 11894, 55938, 55526, 55929, 11896, 55939, 
55529, 55497, 11897, 11876, 55528
12272, 55017, 11573, 11563, 55027, 55018, 11574, 11564, 55028, 55929, 11896, 55939, 55529, 55930, 11898, 55940, 
55532, 55500, 11899, 11878, 55531
12273, 55018, 11574, 11564, 55028, 55019, 11575, 11565, 55029, 55930, 11898, 55940, 55532, 55931, 11900, 55941, 
55535, 55503, 11901, 11880, 55534
12274, 55019, 11575, 11565, 55029, 55020, 11576, 11566, 55030, 55931, 11900, 55941, 55535, 55932, 11902, 55942, 
55538, 55506, 11903, 11882, 55537
12275, 55020, 11576, 11566, 55030, 55021, 11577, 11567, 55031, 55932, 11902, 55942, 55538, 55933, 11904, 55943, 
55541, 55509, 11905, 11884, 55540
12276, 55021, 11577, 11567, 55031, 55022, 11578, 11568, 55032, 55933, 11904, 55943, 55541, 55934, 11906, 55944, 
55544, 55512, 11907, 11886, 55543
12277, 55022, 11578, 11568, 55032, 11361, 916, 915, 11362, 55934, 11906, 55944, 55544, 11428, 938, 11429, 
11397, 55515, 11908, 11887, 55546
12278, 11232, 843, 842, 11233, 55023, 11559, 11549, 55033, 11299, 865, 11300, 11270, 55935, 11867, 55945, 
55548, 55516, 11868, 11847, 55547
12279, 55023, 11559, 11549, 55033, 55024, 11560, 11550, 55034, 55935, 11867, 55945, 55548, 55936, 11869, 55946, 
55551, 55519, 11870, 11849, 55550
12280, 55024, 11560, 11550, 55034, 55025, 11561, 11551, 55035, 55936, 11869, 55946, 55551, 55937, 11871, 55947, 
55554, 55522, 11872, 11851, 55553
12281, 55025, 11561, 11551, 55035, 55026, 11562, 11552, 55036, 55937, 11871, 55947, 55554, 55938, 11873, 55948, 
55557, 55525, 11874, 11853, 55556
12282, 55026, 11562, 11552, 55036, 55027, 11563, 11553, 55037, 55938, 11873, 55948, 55557, 55939, 11875, 55949, 
55560, 55528, 11876, 11855, 55559
12283, 55027, 11563, 11553, 55037, 55028, 11564, 11554, 55038, 55939, 11875, 55949, 55560, 55940, 11877, 55950, 
55563, 55531, 11878, 11857, 55562
12284, 55028, 11564, 11554, 55038, 55029, 11565, 11555, 55039, 55940, 11877, 55950, 55563, 55941, 11879, 55951, 
55566, 55534, 11880, 11859, 55565
12285, 55029, 11565, 11555, 55039, 55030, 11566, 11556, 55040, 55941, 11879, 55951, 55566, 55942, 11881, 55952, 
55569, 55537, 11882, 11861, 55568
12286, 55030, 11566, 11556, 55040, 55031, 11567, 11557, 55041, 55942, 11881, 55952, 55569, 55943, 11883, 55953, 
55572, 55540, 11884, 11863, 55571
12287, 55031, 11567, 11557, 55041, 55032, 11568, 11558, 55042, 55943, 11883, 55953, 55572, 55944, 11885, 55954, 
55575, 55543, 11886, 11865, 55574
12288, 55032, 11568, 11558, 55042, 11362, 915, 914, 11363, 55944, 11885, 55954, 55575, 11429, 937, 11430, 
11399, 55546, 11887, 11866, 55577
12289, 11233, 842, 841, 11234, 55033, 11549, 11539, 55043, 11300, 864, 11301, 11272, 55945, 11846, 55955, 
55579, 55547, 11847, 11826, 55578
12290, 55033, 11549, 11539, 55043, 55034, 11550, 11540, 55044, 55945, 11846, 55955, 55579, 55946, 11848, 55956, 
55582, 55550, 11849, 11828, 55581
12291, 55034, 11550, 11540, 55044, 55035, 11551, 11541, 55045, 55946, 11848, 55956, 55582, 55947, 11850, 55957, 
55585, 55553, 11851, 11830, 55584
12292, 55035, 11551, 11541, 55045, 55036, 11552, 11542, 55046, 55947, 11850, 55957, 55585, 55948, 11852, 55958, 
55588, 55556, 11853, 11832, 55587
12293, 55036, 11552, 11542, 55046, 55037, 11553, 11543, 55047, 55948, 11852, 55958, 55588, 55949, 11854, 55959, 
55591, 55559, 11855, 11834, 55590
12294, 55037, 11553, 11543, 55047, 55038, 11554, 11544, 55048, 55949, 11854, 55959, 55591, 55950, 11856, 55960, 
55594, 55562, 11857, 11836, 55593
12295, 55038, 11554, 11544, 55048, 55039, 11555, 11545, 55049, 55950, 11856, 55960, 55594, 55951, 11858, 55961, 
55597, 55565, 11859, 11838, 55596
12296, 55039, 11555, 11545, 55049, 55040, 11556, 11546, 55050, 55951, 11858, 55961, 55597, 55952, 11860, 55962, 
55600, 55568, 11861, 11840, 55599
12297, 55040, 11556, 11546, 55050, 55041, 11557, 11547, 55051, 55952, 11860, 55962, 55600, 55953, 11862, 55963, 
55603, 55571, 11863, 11842, 55602
12298, 55041, 11557, 11547, 55051, 55042, 11558, 11548, 55052, 55953, 11862, 55963, 55603, 55954, 11864, 55964, 
55606, 55574, 11865, 11844, 55605
12299, 55042, 11558, 11548, 55052, 11363, 914, 913, 11364, 55954, 11864, 55964, 55606, 11430, 936, 11431, 
11401, 55577, 11866, 11845, 55608
12300, 11234, 841, 840, 11235, 55043, 11539, 11529, 55053, 11301, 863, 11302, 11274, 55955, 11825, 55965, 
55610, 55578, 11826, 11805, 55609
12301, 55043, 11539, 11529, 55053, 55044, 11540, 11530, 55054, 55955, 11825, 55965, 55610, 55956, 11827, 55966, 
55613, 55581, 11828, 11807, 55612
12302, 55044, 11540, 11530, 55054, 55045, 11541, 11531, 55055, 55956, 11827, 55966, 55613, 55957, 11829, 55967, 
55616, 55584, 11830, 11809, 55615
12303, 55045, 11541, 11531, 55055, 55046, 11542, 11532, 55056, 55957, 11829, 55967, 55616, 55958, 11831, 55968, 
55619, 55587, 11832, 11811, 55618
12304, 55046, 11542, 11532, 55056, 55047, 11543, 11533, 55057, 55958, 11831, 55968, 55619, 55959, 11833, 55969, 
55622, 55590, 11834, 11813, 55621
12305, 55047, 11543, 11533, 55057, 55048, 11544, 11534, 55058, 55959, 11833, 55969, 55622, 55960, 11835, 55970, 
55625, 55593, 11836, 11815, 55624
12306, 55048, 11544, 11534, 55058, 55049, 11545, 11535, 55059, 55960, 11835, 55970, 55625, 55961, 11837, 55971, 
55628, 55596, 11838, 11817, 55627
12307, 55049, 11545, 11535, 55059, 55050, 11546, 11536, 55060, 55961, 11837, 55971, 55628, 55962, 11839, 55972, 
55631, 55599, 11840, 11819, 55630
12308, 55050, 11546, 11536, 55060, 55051, 11547, 11537, 55061, 55962, 11839, 55972, 55631, 55963, 11841, 55973, 
55634, 55602, 11842, 11821, 55633
12309, 55051, 11547, 11537, 55061, 55052, 11548, 11538, 55062, 55963, 11841, 55973, 55634, 55964, 11843, 55974, 
55637, 55605, 11844, 11823, 55636
12310, 55052, 11548, 11538, 55062, 11364, 913, 912, 11365, 55964, 11843, 55974, 55637, 11431, 935, 11432, 
11403, 55608, 11845, 11824, 55639
12311, 11235, 840, 839, 11236, 55053, 11529, 11519, 55063, 11302, 862, 11303, 11276, 55965, 11804, 55975, 
55641, 55609, 11805, 11784, 55640
12312, 55053, 11529, 11519, 55063, 55054, 11530, 11520, 55064, 55965, 11804, 55975, 55641, 55966, 11806, 55976, 
55644, 55612, 11807, 11786, 55643
12313, 55054, 11530, 11520, 55064, 55055, 11531, 11521, 55065, 55966, 11806, 55976, 55644, 55967, 11808, 55977, 
55647, 55615, 11809, 11788, 55646
12314, 55055, 11531, 11521, 55065, 55056, 11532, 11522, 55066, 55967, 11808, 55977, 55647, 55968, 11810, 55978, 
55650, 55618, 11811, 11790, 55649
12315, 55056, 11532, 11522, 55066, 55057, 11533, 11523, 55067, 55968, 11810, 55978, 55650, 55969, 11812, 55979, 
55653, 55621, 11813, 11792, 55652
12316, 55057, 11533, 11523, 55067, 55058, 11534, 11524, 55068, 55969, 11812, 55979, 55653, 55970, 11814, 55980, 
55656, 55624, 11815, 11794, 55655
12317, 55058, 11534, 11524, 55068, 55059, 11535, 11525, 55069, 55970, 11814, 55980, 55656, 55971, 11816, 55981, 
55659, 55627, 11817, 11796, 55658
12318, 55059, 11535, 11525, 55069, 55060, 11536, 11526, 55070, 55971, 11816, 55981, 55659, 55972, 11818, 55982, 
55662, 55630, 11819, 11798, 55661
12319, 55060, 11536, 11526, 55070, 55061, 11537, 11527, 55071, 55972, 11818, 55982, 55662, 55973, 11820, 55983, 
55665, 55633, 11821, 11800, 55664
12320, 55061, 11537, 11527, 55071, 55062, 11538, 11528, 55072, 55973, 11820, 55983, 55665, 55974, 11822, 55984, 
55668, 55636, 11823, 11802, 55667
12321, 55062, 11538, 11528, 55072, 11365, 912, 911, 11366, 55974, 11822, 55984, 55668, 11432, 934, 11433, 
11405, 55639, 11824, 11803, 55670
12322, 11236, 839, 838, 11237, 55063, 11519, 11509, 55073, 11303, 861, 11304, 11278, 55975, 11783, 55985, 
55672, 55640, 11784, 11763, 55671
12323, 55063, 11519, 11509, 55073, 55064, 11520, 11510, 55074, 55975, 11783, 55985, 55672, 55976, 11785, 55986, 
55675, 55643, 11786, 11765, 55674
12324, 55064, 11520, 11510, 55074, 55065, 11521, 11511, 55075, 55976, 11785, 55986, 55675, 55977, 11787, 55987, 
55678, 55646, 11788, 11767, 55677
12325, 55065, 11521, 11511, 55075, 55066, 11522, 11512, 55076, 55977, 11787, 55987, 55678, 55978, 11789, 55988, 
55681, 55649, 11790, 11769, 55680
12326, 55066, 11522, 11512, 55076, 55067, 11523, 11513, 55077, 55978, 11789, 55988, 55681, 55979, 11791, 55989, 
55684, 55652, 11792, 11771, 55683
12327, 55067, 11523, 11513, 55077, 55068, 11524, 11514, 55078, 55979, 11791, 55989, 55684, 55980, 11793, 55990, 
55687, 55655, 11794, 11773, 55686
12328, 55068, 11524, 11514, 55078, 55069, 11525, 11515, 55079, 55980, 11793, 55990, 55687, 55981, 11795, 55991, 
55690, 55658, 11796, 11775, 55689
12329, 55069, 11525, 11515, 55079, 55070, 11526, 11516, 55080, 55981, 11795, 55991, 55690, 55982, 11797, 55992, 
55693, 55661, 11798, 11777, 55692
12330, 55070, 11526, 11516, 55080, 55071, 11527, 11517, 55081, 55982, 11797, 55992, 55693, 55983, 11799, 55993, 
55696, 55664, 11800, 11779, 55695
12331, 55071, 11527, 11517, 55081, 55072, 11528, 11518, 55082, 55983, 11799, 55993, 55696, 55984, 11801, 55994, 
55699, 55667, 11802, 11781, 55698
12332, 55072, 11528, 11518, 55082, 11366, 911, 910, 11367, 55984, 11801, 55994, 55699, 11433, 933, 11434, 
11407, 55670, 11803, 11782, 55701
12333, 11237, 838, 837, 11238, 55073, 11509, 11499, 55083, 11304, 860, 11305, 11280, 55985, 11762, 55995, 
55703, 55671, 11763, 11742, 55702
12334, 55073, 11509, 11499, 55083, 55074, 11510, 11500, 55084, 55985, 11762, 55995, 55703, 55986, 11764, 55996, 
55706, 55674, 11765, 11744, 55705
12335, 55074, 11510, 11500, 55084, 55075, 11511, 11501, 55085, 55986, 11764, 55996, 55706, 55987, 11766, 55997, 
55709, 55677, 11767, 11746, 55708
12336, 55075, 11511, 11501, 55085, 55076, 11512, 11502, 55086, 55987, 11766, 55997, 55709, 55988, 11768, 55998, 
55712, 55680, 11769, 11748, 55711
12337, 55076, 11512, 11502, 55086, 55077, 11513, 11503, 55087, 55988, 11768, 55998, 55712, 55989, 11770, 55999, 
55715, 55683, 11771, 11750, 55714
12338, 55077, 11513, 11503, 55087, 55078, 11514, 11504, 55088, 55989, 11770, 55999, 55715, 55990, 11772, 56000, 
55718, 55686, 11773, 11752, 55717
12339, 55078, 11514, 11504, 55088, 55079, 11515, 11505, 55089, 55990, 11772, 56000, 55718, 55991, 11774, 56001, 
55721, 55689, 11775, 11754, 55720
12340, 55079, 11515, 11505, 55089, 55080, 11516, 11506, 55090, 55991, 11774, 56001, 55721, 55992, 11776, 56002, 
55724, 55692, 11777, 11756, 55723
12341, 55080, 11516, 11506, 55090, 55081, 11517, 11507, 55091, 55992, 11776, 56002, 55724, 55993, 11778, 56003, 
55727, 55695, 11779, 11758, 55726
12342, 55081, 11517, 11507, 55091, 55082, 11518, 11508, 55092, 55993, 11778, 56003, 55727, 55994, 11780, 56004, 
55730, 55698, 11781, 11760, 55729
12343, 55082, 11518, 11508, 55092, 11367, 910, 909, 11368, 55994, 11780, 56004, 55730, 11434, 932, 11435, 
11409, 55701, 11782, 11761, 55732
12344, 11238, 837, 836, 11239, 55083, 11499, 11489, 55093, 11305, 859, 11306, 11282, 55995, 11741, 56005, 
55734, 55702, 11742, 11721, 55733
12345, 55083, 11499, 11489, 55093, 55084, 11500, 11490, 55094, 55995, 11741, 56005, 55734, 55996, 11743, 56006, 
55737, 55705, 11744, 11723, 55736
12346, 55084, 11500, 11490, 55094, 55085, 11501, 11491, 55095, 55996, 11743, 56006, 55737, 55997, 11745, 56007, 
55740, 55708, 11746, 11725, 55739
12347, 55085, 11501, 11491, 55095, 55086, 11502, 11492, 55096, 55997, 11745, 56007, 55740, 55998, 11747, 56008, 
55743, 55711, 11748, 11727, 55742
12348, 55086, 11502, 11492, 55096, 55087, 11503, 11493, 55097, 55998, 11747, 56008, 55743, 55999, 11749, 56009, 
55746, 55714, 11750, 11729, 55745
12349, 55087, 11503, 11493, 55097, 55088, 11504, 11494, 55098, 55999, 11749, 56009, 55746, 56000, 11751, 56010, 
55749, 55717, 11752, 11731, 55748
12350, 55088, 11504, 11494, 55098, 55089, 11505, 11495, 55099, 56000, 11751, 56010, 55749, 56001, 11753, 56011, 
55752, 55720, 11754, 11733, 55751
12351, 55089, 11505, 11495, 55099, 55090, 11506, 11496, 55100, 56001, 11753, 56011, 55752, 56002, 11755, 56012, 
55755, 55723, 11756, 11735, 55754
12352, 55090, 11506, 11496, 55100, 55091, 11507, 11497, 55101, 56002, 11755, 56012, 55755, 56003, 11757, 56013, 
55758, 55726, 11758, 11737, 55757
12353, 55091, 11507, 11497, 55101, 55092, 11508, 11498, 55102, 56003, 11757, 56013, 55758, 56004, 11759, 56014, 
55761, 55729, 11760, 11739, 55760
12354, 55092, 11508, 11498, 55102, 11368, 909, 908, 11369, 56004, 11759, 56014, 55761, 11435, 931, 11436, 
11411, 55732, 11761, 11740, 55763
12355, 11239, 836, 835, 11240, 55093, 11489, 11479, 55103, 11306, 858, 11307, 11284, 56005, 11720, 56015, 
55765, 55733, 11721, 11700, 55764
12356, 55093, 11489, 11479, 55103, 55094, 11490, 11480, 55104, 56005, 11720, 56015, 55765, 56006, 11722, 56016, 
55768, 55736, 11723, 11702, 55767
12357, 55094, 11490, 11480, 55104, 55095, 11491, 11481, 55105, 56006, 11722, 56016, 55768, 56007, 11724, 56017, 
55771, 55739, 11725, 11704, 55770
12358, 55095, 11491, 11481, 55105, 55096, 11492, 11482, 55106, 56007, 11724, 56017, 55771, 56008, 11726, 56018, 
55774, 55742, 11727, 11706, 55773
12359, 55096, 11492, 11482, 55106, 55097, 11493, 11483, 55107, 56008, 11726, 56018, 55774, 56009, 11728, 56019, 
55777, 55745, 11729, 11708, 55776
12360, 55097, 11493, 11483, 55107, 55098, 11494, 11484, 55108, 56009, 11728, 56019, 55777, 56010, 11730, 56020, 
55780, 55748, 11731, 11710, 55779
12361, 55098, 11494, 11484, 55108, 55099, 11495, 11485, 55109, 56010, 11730, 56020, 55780, 56011, 11732, 56021, 
55783, 55751, 11733, 11712, 55782
12362, 55099, 11495, 11485, 55109, 55100, 11496, 11486, 55110, 56011, 11732, 56021, 55783, 56012, 11734, 56022, 
55786, 55754, 11735, 11714, 55785
12363, 55100, 11496, 11486, 55110, 55101, 11497, 11487, 55111, 56012, 11734, 56022, 55786, 56013, 11736, 56023, 
55789, 55757, 11737, 11716, 55788
12364, 55101, 11497, 11487, 55111, 55102, 11498, 11488, 55112, 56013, 11736, 56023, 55789, 56014, 11738, 56024, 
55792, 55760, 11739, 11718, 55791
12365, 55102, 11498, 11488, 55112, 11369, 908, 907, 11370, 56014, 11738, 56024, 55792, 11436, 930, 11437, 
11413, 55763, 11740, 11719, 55794
12366, 11240, 835, 18, 832, 55103, 11479, 952, 11447, 11307, 857, 834, 11285, 56015, 11699, 11478, 
55795, 55764, 11700, 962, 11468
12367, 55103, 11479, 952, 11447, 55104, 11480, 953, 11446, 56015, 11699, 11478, 55795, 56016, 11701, 11477, 
55796, 55767, 11702, 963, 11466
12368, 55104, 11480, 953, 11446, 55105, 11481, 954, 11445, 56016, 11701, 11477, 55796, 56017, 11703, 11476, 
55797, 55770, 11704, 964, 11464
12369, 55105, 11481, 954, 11445, 55106, 11482, 955, 11444, 56017, 11703, 11476, 55797, 56018, 11705, 11475, 
55798, 55773, 11706, 965, 11462
12370, 55106, 11482, 955, 11444, 55107, 11483, 956, 11443, 56018, 11705, 11475, 55798, 56019, 11707, 11474, 
55799, 55776, 11708, 966, 11460
12371, 55107, 11483, 956, 11443, 55108, 11484, 957, 11442, 56019, 11707, 11474, 55799, 56020, 11709, 11473, 
55800, 55779, 11710, 967, 11458
12372, 55108, 11484, 957, 11442, 55109, 11485, 958, 11441, 56020, 11709, 11473, 55800, 56021, 11711, 11472, 
55801, 55782, 11712, 968, 11456
12373, 55109, 11485, 958, 11441, 55110, 11486, 959, 11440, 56021, 11711, 11472, 55801, 56022, 11713, 11471, 
55802, 55785, 11714, 969, 11454
12374, 55110, 11486, 959, 11440, 55111, 11487, 960, 11439, 56022, 11713, 11471, 55802, 56023, 11715, 11470, 
55803, 55788, 11716, 970, 11452
12375, 55111, 11487, 960, 11439, 55112, 11488, 961, 11438, 56023, 11715, 11470, 55803, 56024, 11717, 11469, 
55804, 55791, 11718, 971, 11450
12376, 55112, 11488, 961, 11438, 11370, 907, 20, 904, 56024, 11717, 11469, 55804, 11437, 929, 906, 
11415, 55794, 11719, 972, 11448
*ELEMENT, type=C3D20, ELSET=Volume5
12377, 17, 973, 12171, 856, 883, 12336, 56025, 11689, 975, 12216, 12215, 879, 12365, 56466, 56467, 
12161, 893, 12367, 56465, 12141
12378, 883, 12336, 56025, 11689, 884, 12335, 56026, 11690, 12365, 56466, 56467, 12161, 12363, 56469, 56470, 
12162, 894, 12366, 56468, 12143
12379, 884, 12335, 56026, 11690, 885, 12334, 56027, 11691, 12363, 56469, 56470, 12162, 12361, 56472, 56473, 
12163, 895, 12364, 56471, 12145
12380, 885, 12334, 56027, 11691, 886, 12333, 56028, 11692, 12361, 56472, 56473, 12163, 12359, 56475, 56476, 
12164, 896, 12362, 56474, 12147
12381, 886, 12333, 56028, 11692, 887, 12332, 56029, 11693, 12359, 56475, 56476, 12164, 12357, 56478, 56479, 
12165, 897, 12360, 56477, 12149
12382, 887, 12332, 56029, 11693, 888, 12331, 56030, 11694, 12357, 56478, 56479, 12165, 12355, 56481, 56482, 
12166, 898, 12358, 56480, 12151
12383, 888, 12331, 56030, 11694, 889, 12330, 56031, 11695, 12355, 56481, 56482, 12166, 12353, 56484, 56485, 
12167, 899, 12356, 56483, 12153
12384, 889, 12330, 56031, 11695, 890, 12329, 56032, 11696, 12353, 56484, 56485, 12167, 12351, 56487, 56488, 
12168, 900, 12354, 56486, 12155
12385, 890, 12329, 56032, 11696, 891, 12328, 56033, 11697, 12351, 56487, 56488, 12168, 12349, 56490, 56491, 
12169, 901, 12352, 56489, 12157
12386, 891, 12328, 56033, 11697, 892, 12327, 56034, 11698, 12349, 56490, 56491, 12169, 12347, 56493, 56494, 
12170, 902, 12350, 56492, 12159
12387, 892, 12327, 56034, 11698, 19, 1028, 12399, 928, 12347, 56493, 56494, 12170, 1030, 12443, 12444, 
951, 903, 12348, 56495, 12160
12388, 856, 12171, 12172, 855, 11689, 56025, 56035, 11679, 12215, 12218, 12217, 878, 56467, 56497, 56498, 
12140, 12141, 56465, 56496, 12120
12389, 11689, 56025, 56035, 11679, 11690, 56026, 56036, 11680, 56467, 56497, 56498, 12140, 56470, 56500, 56501, 
12142, 12143, 56468, 56499, 12122
12390, 11690, 56026, 56036, 11680, 11691, 56027, 56037, 11681, 56470, 56500, 56501, 12142, 56473, 56503, 56504, 
12144, 12145, 56471, 56502, 12124
12391, 11691, 56027, 56037, 11681, 11692, 56028, 56038, 11682, 56473, 56503, 56504, 12144, 56476, 56506, 56507, 
12146, 12147, 56474, 56505, 12126
12392, 11692, 56028, 56038, 11682, 11693, 56029, 56039, 11683, 56476, 56506, 56507, 12146, 56479, 56509, 56510, 
12148, 12149, 56477, 56508, 12128
12393, 11693, 56029, 56039, 11683, 11694, 56030, 56040, 11684, 56479, 56509, 56510, 12148, 56482, 56512, 56513, 
12150, 12151, 56480, 56511, 12130
12394, 11694, 56030, 56040, 11684, 11695, 56031, 56041, 11685, 56482, 56512, 56513, 12150, 56485, 56515, 56516, 
12152, 12153, 56483, 56514, 12132
12395, 11695, 56031, 56041, 11685, 11696, 56032, 56042, 11686, 56485, 56515, 56516, 12152, 56488, 56518, 56519, 
12154, 12155, 56486, 56517, 12134
12396, 11696, 56032, 56042, 11686, 11697, 56033, 56043, 11687, 56488, 56518, 56519, 12154, 56491, 56521, 56522, 
12156, 12157, 56489, 56520, 12136
12397, 11697, 56033, 56043, 11687, 11698, 56034, 56044, 11688, 56491, 56521, 56522, 12156, 56494, 56524, 56525, 
12158, 12159, 56492, 56523, 12138
12398, 11698, 56034, 56044, 11688, 928, 12399, 12400, 927, 56494, 56524, 56525, 12158, 12444, 12445, 12446, 
950, 12160, 56495, 56526, 12139
12399, 855, 12172, 12173, 854, 11679, 56035, 56045, 11669, 12217, 12220, 12219, 877, 56498, 56528, 56529, 
12119, 12120, 56496, 56527, 12099
12400, 11679, 56035, 56045, 11669, 11680, 56036, 56046, 11670, 56498, 56528, 56529, 12119, 56501, 56531, 56532, 
12121, 12122, 56499, 56530, 12101
12401, 11680, 56036, 56046, 11670, 11681, 56037, 56047, 11671, 56501, 56531, 56532, 12121, 56504, 56534, 56535, 
12123, 12124, 56502, 56533, 12103
12402, 11681, 56037, 56047, 11671, 11682, 56038, 56048, 11672, 56504, 56534, 56535, 12123, 56507, 56537, 56538, 
12125, 12126, 56505, 56536, 12105
12403, 11682, 56038, 56048, 11672, 11683, 56039, 56049, 11673, 56507, 56537, 56538, 12125, 56510, 56540, 56541, 
12127, 12128, 56508, 56539, 12107
12404, 11683, 56039, 56049, 11673, 11684, 56040, 56050, 11674, 56510, 56540, 56541, 12127, 56513, 56543, 56544, 
12129, 12130, 56511, 56542, 12109
12405, 11684, 56040, 56050, 11674, 11685, 56041, 56051, 11675, 56513, 56543, 56544, 12129, 56516, 56546, 56547, 
12131, 12132, 56514, 56545, 12111
12406, 11685, 56041, 56051, 11675, 11686, 56042, 56052, 11676, 56516, 56546, 56547, 12131, 56519, 56549, 56550, 
12133, 12134, 56517, 56548, 12113
12407, 11686, 56042, 56052, 11676, 11687, 56043, 56053, 11677, 56519, 56549, 56550, 12133, 56522, 56552, 56553, 
12135, 12136, 56520, 56551, 12115
12408, 11687, 56043, 56053, 11677, 11688, 56044, 56054, 11678, 56522, 56552, 56553, 12135, 56525, 56555, 56556, 
12137, 12138, 56523, 56554, 12117
12409, 11688, 56044, 56054, 11678, 927, 12400, 12401, 926, 56525, 56555, 56556, 12137, 12446, 12447, 12448, 
949, 12139, 56526, 56557, 12118
12410, 854, 12173, 12174, 853, 11669, 56045, 56055, 11659, 12219, 12222, 12221, 876, 56529, 56559, 56560, 
12098, 12099, 56527, 56558, 12078
12411, 11669, 56045, 56055, 11659, 11670, 56046, 56056, 11660, 56529, 56559, 56560, 12098, 56532, 56562, 56563, 
12100, 12101, 56530, 56561, 12080
12412, 11670, 56046, 56056, 11660, 11671, 56047, 56057, 11661, 56532, 56562, 56563, 12100, 56535, 56565, 56566, 
12102, 12103, 56533, 56564, 12082
12413, 11671, 56047, 56057, 11661, 11672, 56048, 56058, 11662, 56535, 56565, 56566, 12102, 56538, 56568, 56569, 
12104, 12105, 56536, 56567, 12084
12414, 11672, 56048, 56058, 11662, 11673, 56049, 56059, 11663, 56538, 56568, 56569, 12104, 56541, 56571, 56572, 
12106, 12107, 56539, 56570, 12086
12415, 11673, 56049, 56059, 11663, 11674, 56050, 56060, 11664, 56541, 56571, 56572, 12106, 56544, 56574, 56575, 
12108, 12109, 56542, 56573, 12088
12416, 11674, 56050, 56060, 11664, 11675, 56051, 56061, 11665, 56544, 56574, 56575, 12108, 56547, 56577, 56578, 
12110, 12111, 56545, 56576, 12090
12417, 11675, 56051, 56061, 11665, 11676, 56052, 56062, 11666, 56547, 56577, 56578, 12110, 56550, 56580, 56581, 
12112, 12113, 56548, 56579, 12092
12418, 11676, 56052, 56062, 11666, 11677, 56053, 56063, 11667, 56550, 56580, 56581, 12112, 56553, 56583, 56584, 
12114, 12115, 56551, 56582, 12094
12419, 11677, 56053, 56063, 11667, 11678, 56054, 56064, 11668, 56553, 56583, 56584, 12114, 56556, 56586, 56587, 
12116, 12117, 56554, 56585, 12096
12420, 11678, 56054, 56064, 11668, 926, 12401, 12402, 925, 56556, 56586, 56587, 12116, 12448, 12449, 12450, 
948, 12118, 56557, 56588, 12097
12421, 853, 12174, 12175, 852, 11659, 56055, 56065, 11649, 12221, 12224, 12223, 875, 56560, 56590, 56591, 
12077, 12078, 56558, 56589, 12057
12422, 11659, 56055, 56065, 11649, 11660, 56056, 56066, 11650, 56560, 56590, 56591, 12077, 56563, 56593, 56594, 
12079, 12080, 56561, 56592, 12059
12423, 11660, 56056, 56066, 11650, 11661, 56057, 56067, 11651, 56563, 56593, 56594, 12079, 56566, 56596, 56597, 
12081, 12082, 56564, 56595, 12061
12424, 11661, 56057, 56067, 11651, 11662, 56058, 56068, 11652, 56566, 56596, 56597, 12081, 56569, 56599, 56600, 
12083, 12084, 56567, 56598, 12063
12425, 11662, 56058, 56068, 11652, 11663, 56059, 56069, 11653, 56569, 56599, 56600, 12083, 56572, 56602, 56603, 
12085, 12086, 56570, 56601, 12065
12426, 11663, 56059, 56069, 11653, 11664, 56060, 56070, 11654, 56572, 56602, 56603, 12085, 56575, 56605, 56606, 
12087, 12088, 56573, 56604, 12067
12427, 11664, 56060, 56070, 11654, 11665, 56061, 56071, 11655, 56575, 56605, 56606, 12087, 56578, 56608, 56609, 
12089, 12090, 56576, 56607, 12069
12428, 11665, 56061, 56071, 11655, 11666, 56062, 56072, 11656, 56578, 56608, 56609, 12089, 56581, 56611, 56612, 
12091, 12092, 56579, 56610, 12071
12429, 11666, 56062, 56072, 11656, 11667, 56063, 56073, 11657, 56581, 56611, 56612, 12091, 56584, 56614, 56615, 
12093, 12094, 56582, 56613, 12073
12430, 11667, 56063, 56073, 11657, 11668, 56064, 56074, 11658, 56584, 56614, 56615, 12093, 56587, 56617, 56618, 
12095, 12096, 56585, 56616, 12075
12431, 11668, 56064, 56074, 11658, 925, 12402, 12403, 924, 56587, 56617, 56618, 12095, 12450, 12451, 12452, 
947, 12097, 56588, 56619, 12076
12432, 852, 12175, 12176, 851, 11649, 56065, 56075, 11639, 12223, 12226, 12225, 874, 56591, 56621, 56622, 
12056, 12057, 56589, 56620, 12036
12433, 11649, 56065, 56075, 11639, 11650, 56066, 56076, 11640, 56591, 56621, 56622, 12056, 56594, 56624, 56625, 
12058, 12059, 56592, 56623, 12038
12434, 11650, 56066, 56076, 11640, 11651, 56067, 56077, 11641, 56594, 56624, 56625, 12058, 56597, 56627, 56628, 
12060, 12061, 56595, 56626, 12040
12435, 11651, 56067, 56077, 11641, 11652, 56068, 56078, 11642, 56597, 56627, 56628, 12060, 56600, 56630, 56631, 
12062, 12063, 56598, 56629, 12042
12436, 11652, 56068, 56078, 11642, 11653, 56069, 56079, 11643, 56600, 56630, 56631, 12062, 56603, 56633, 56634, 
12064, 12065, 56601, 56632, 12044
12437, 11653, 56069, 56079, 11643, 11654, 56070, 56080, 11644, 56603, 56633, 56634, 12064, 56606, 56636, 56637, 
12066, 12067, 56604, 56635, 12046
12438, 11654, 56070, 56080, 11644, 11655, 56071, 56081, 11645, 56606, 56636, 56637, 12066, 56609, 56639, 56640, 
12068, 12069, 56607, 56638, 12048
12439, 11655, 56071, 56081, 11645, 11656, 56072, 56082, 11646, 56609, 56639, 56640, 12068, 56612, 56642, 56643, 
12070, 12071, 56610, 56641, 12050
12440, 11656, 56072, 56082, 11646, 11657, 56073, 56083, 11647, 56612, 56642, 56643, 12070, 56615, 56645, 56646, 
12072, 12073, 56613, 56644, 12052
12441, 11657, 56073, 56083, 11647, 11658, 56074, 56084, 11648, 56615, 56645, 56646, 12072, 56618, 56648, 56649, 
12074, 12075, 56616, 56647, 12054
12442, 11658, 56074, 56084, 11648, 924, 12403, 12404, 923, 56618, 56648, 56649, 12074, 12452, 12453, 12454, 
946, 12076, 56619, 56650, 12055
12443, 851, 12176, 12177, 850, 11639, 56075, 56085, 11629, 12225, 12228, 12227, 873, 56622, 56652, 56653, 
12035, 12036, 56620, 56651, 12015
12444, 11639, 56075, 56085, 11629, 11640, 56076, 56086, 11630, 56622, 56652, 56653, 12035, 56625, 56655, 56656, 
12037, 12038, 56623, 56654, 12017
12445, 11640, 56076, 56086, 11630, 11641, 56077, 56087, 11631, 56625, 56655, 56656, 12037, 56628, 56658, 56659, 
12039, 12040, 56626, 56657, 12019
12446, 11641, 56077, 56087, 11631, 11642, 56078, 56088, 11632, 56628, 56658, 56659, 12039, 56631, 56661, 56662, 
12041, 12042, 56629, 56660, 12021
12447, 11642, 56078, 56088, 11632, 11643, 56079, 56089, 11633, 56631, 56661, 56662, 12041, 56634, 56664, 56665, 
12043, 12044, 56632, 56663, 12023
12448, 11643, 56079, 56089, 11633, 11644, 56080, 56090, 11634, 56634, 56664, 56665, 12043, 56637, 56667, 56668, 
12045, 12046, 56635, 56666, 12025
12449, 11644, 56080, 56090, 11634, 11645, 56081, 56091, 11635, 56637, 56667, 56668, 12045, 56640, 56670, 56671, 
12047, 12048, 56638, 56669, 12027
12450, 11645, 56081, 56091, 11635, 11646, 56082, 56092, 11636, 56640, 56670, 56671, 12047, 56643, 56673, 56674, 
12049, 12050, 56641, 56672, 12029
12451, 11646, 56082, 56092, 11636, 11647, 56083, 56093, 11637, 56643, 56673, 56674, 12049, 56646, 56676, 56677, 
12051, 12052, 56644, 56675, 12031
12452, 11647, 56083, 56093, 11637, 11648, 56084, 56094, 11638, 56646, 56676, 56677, 12051, 56649, 56679, 56680, 
12053, 12054, 56647, 56678, 12033
12453, 11648, 56084, 56094, 11638, 923, 12404, 12405, 922, 56649, 56679, 56680, 12053, 12454, 12455, 12456, 
945, 12055, 56650, 56681, 12034
12454, 850, 12177, 12178, 849, 11629, 56085, 56095, 11619, 12227, 12230, 12229, 872, 56653, 56683, 56684, 
12014, 12015, 56651, 56682, 11994
12455, 11629, 56085, 56095, 11619, 11630, 56086, 56096, 11620, 56653, 56683, 56684, 12014, 56656, 56686, 56687, 
12016, 12017, 56654, 56685, 11996
12456, 11630, 56086, 56096, 11620, 11631, 56087, 56097, 11621, 56656, 56686, 56687, 12016, 56659, 56689, 56690, 
12018, 12019, 56657, 56688, 11998
12457, 11631, 56087, 56097, 11621, 11632, 56088, 56098, 11622, 56659, 56689, 56690, 12018, 56662, 56692, 56693, 
12020, 12021, 56660, 56691, 12000
12458, 11632, 56088, 56098, 11622, 11633, 56089, 56099, 11623, 56662, 56692, 56693, 12020, 56665, 56695, 56696, 
12022, 12023, 56663, 56694, 12002
12459, 11633, 56089, 56099, 11623, 11634, 56090, 56100, 11624, 56665, 56695, 56696, 12022, 56668, 56698, 56699, 
12024, 12025, 56666, 56697, 12004
12460, 11634, 56090, 56100, 11624, 11635, 56091, 56101, 11625, 56668, 56698, 56699, 12024, 56671, 56701, 56702, 
12026, 12027, 56669, 56700, 12006
12461, 11635, 56091, 56101, 11625, 11636, 56092, 56102, 11626, 56671, 56701, 56702, 12026, 56674, 56704, 56705, 
12028, 12029, 56672, 56703, 12008
12462, 11636, 56092, 56102, 11626, 11637, 56093, 56103, 11627, 56674, 56704, 56705, 12028, 56677, 56707, 56708, 
12030, 12031, 56675, 56706, 12010
12463, 11637, 56093, 56103, 11627, 11638, 56094, 56104, 11628, 56677, 56707, 56708, 12030, 56680, 56710, 56711, 
12032, 12033, 56678, 56709, 12012
12464, 11638, 56094, 56104, 11628, 922, 12405, 12406, 921, 56680, 56710, 56711, 12032, 12456, 12457, 12458, 
944, 12034, 56681, 56712, 12013
