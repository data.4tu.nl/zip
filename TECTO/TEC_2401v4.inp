20640, 21768, 2011, 21686, 81918, 21769, 2010, 21687, 81919, 21989, 21717, 82141, 82830, 21991, 21718, 82144, 
82831, 21992, 2021, 21700, 82143
20641, 21769, 2010, 21687, 81919, 21770, 2009, 21688, 81920, 21991, 21718, 82144, 82831, 21993, 21719, 82147, 
82832, 21994, 2020, 21702, 82146
20642, 21770, 2009, 21688, 81920, 21771, 2008, 21689, 81921, 21993, 21719, 82147, 82832, 21995, 21720, 82150, 
82833, 21996, 2019, 21704, 82149
20643, 21771, 2008, 21689, 81921, 21772, 2007, 21690, 81922, 21995, 21720, 82150, 82833, 21997, 21721, 82153, 
82834, 21998, 2018, 21706, 82152
20644, 21772, 2007, 21690, 81922, 21773, 2006, 21691, 81923, 21997, 21721, 82153, 82834, 21999, 21722, 82156, 
82835, 22000, 2017, 21708, 82155
20645, 21773, 2006, 21691, 81923, 21774, 2005, 21692, 81924, 21999, 21722, 82156, 82835, 22001, 21723, 82159, 
82836, 22002, 2016, 21710, 82158
20646, 21774, 2005, 21692, 81924, 21775, 2004, 21693, 81925, 22001, 21723, 82159, 82836, 22003, 21724, 82162, 
82837, 22004, 2015, 21712, 82161
20647, 21775, 2004, 21693, 81925, 21776, 2003, 21694, 81926, 22003, 21724, 82162, 82837, 22005, 21725, 82165, 
82838, 22006, 2014, 21714, 82164
20648, 21776, 2003, 21694, 81926, 1958, 43, 1952, 21596, 22005, 21725, 82165, 82838, 1980, 1954, 21619, 
21663, 22007, 2013, 21715, 82167
20649, 1908, 1907, 21507, 21508, 21777, 21767, 81917, 81927, 1930, 21574, 21531, 21575, 22008, 82829, 82169, 
82839, 22009, 21988, 82137, 82168
20650, 21777, 21767, 81917, 81927, 21778, 21768, 81918, 81928, 22008, 82829, 82169, 82839, 22010, 82830, 82172, 
82840, 22011, 21990, 82140, 82171
20651, 21778, 21768, 81918, 81928, 21779, 21769, 81919, 81929, 22010, 82830, 82172, 82840, 22012, 82831, 82175, 
82841, 22013, 21992, 82143, 82174
20652, 21779, 21769, 81919, 81929, 21780, 21770, 81920, 81930, 22012, 82831, 82175, 82841, 22014, 82832, 82178, 
82842, 22015, 21994, 82146, 82177
20653, 21780, 21770, 81920, 81930, 21781, 21771, 81921, 81931, 22014, 82832, 82178, 82842, 22016, 82833, 82181, 
82843, 22017, 21996, 82149, 82180
20654, 21781, 21771, 81921, 81931, 21782, 21772, 81922, 81932, 22016, 82833, 82181, 82843, 22018, 82834, 82184, 
82844, 22019, 21998, 82152, 82183
20655, 21782, 21772, 81922, 81932, 21783, 21773, 81923, 81933, 22018, 82834, 82184, 82844, 22020, 82835, 82187, 
82845, 22021, 22000, 82155, 82186
20656, 21783, 21773, 81923, 81933, 21784, 21774, 81924, 81934, 22020, 82835, 82187, 82845, 22022, 82836, 82190, 
82846, 22023, 22002, 82158, 82189
20657, 21784, 21774, 81924, 81934, 21785, 21775, 81925, 81935, 22022, 82836, 82190, 82846, 22024, 82837, 82193, 
82847, 22025, 22004, 82161, 82192
20658, 21785, 21775, 81925, 81935, 21786, 21776, 81926, 81936, 22024, 82837, 82193, 82847, 22026, 82838, 82196, 
82848, 22027, 22006, 82164, 82195
20659, 21786, 21776, 81926, 81936, 1959, 1958, 21596, 21597, 22026, 82838, 82196, 82848, 1981, 21663, 21621, 
21664, 22028, 22007, 82167, 82198
20660, 1909, 1908, 21508, 21509, 21787, 21777, 81927, 81937, 1931, 21575, 21533, 21576, 22029, 82839, 82200, 
82849, 22030, 22009, 82168, 82199
20661, 21787, 21777, 81927, 81937, 21788, 21778, 81928, 81938, 22029, 82839, 82200, 82849, 22031, 82840, 82203, 
82850, 22032, 22011, 82171, 82202
20662, 21788, 21778, 81928, 81938, 21789, 21779, 81929, 81939, 22031, 82840, 82203, 82850, 22033, 82841, 82206, 
82851, 22034, 22013, 82174, 82205
20663, 21789, 21779, 81929, 81939, 21790, 21780, 81930, 81940, 22033, 82841, 82206, 82851, 22035, 82842, 82209, 
82852, 22036, 22015, 82177, 82208
20664, 21790, 21780, 81930, 81940, 21791, 21781, 81931, 81941, 22035, 82842, 82209, 82852, 22037, 82843, 82212, 
82853, 22038, 22017, 82180, 82211
20665, 21791, 21781, 81931, 81941, 21792, 21782, 81932, 81942, 22037, 82843, 82212, 82853, 22039, 82844, 82215, 
82854, 22040, 22019, 82183, 82214
20666, 21792, 21782, 81932, 81942, 21793, 21783, 81933, 81943, 22039, 82844, 82215, 82854, 22041, 82845, 82218, 
82855, 22042, 22021, 82186, 82217
20667, 21793, 21783, 81933, 81943, 21794, 21784, 81934, 81944, 22041, 82845, 82218, 82855, 22043, 82846, 82221, 
82856, 22044, 22023, 82189, 82220
20668, 21794, 21784, 81934, 81944, 21795, 21785, 81935, 81945, 22043, 82846, 82221, 82856, 22045, 82847, 82224, 
82857, 22046, 22025, 82192, 82223
20669, 21795, 21785, 81935, 81945, 21796, 21786, 81936, 81946, 22045, 82847, 82224, 82857, 22047, 82848, 82227, 
82858, 22048, 22027, 82195, 82226
20670, 21796, 21786, 81936, 81946, 1960, 1959, 21597, 21598, 22047, 82848, 82227, 82858, 1982, 21664, 21623, 
21665, 22049, 22028, 82198, 82229
20671, 1910, 1909, 21509, 21510, 21797, 21787, 81937, 81947, 1932, 21576, 21535, 21577, 22050, 82849, 82231, 
82859, 22051, 22030, 82199, 82230
20672, 21797, 21787, 81937, 81947, 21798, 21788, 81938, 81948, 22050, 82849, 82231, 82859, 22052, 82850, 82234, 
82860, 22053, 22032, 82202, 82233
20673, 21798, 21788, 81938, 81948, 21799, 21789, 81939, 81949, 22052, 82850, 82234, 82860, 22054, 82851, 82237, 
82861, 22055, 22034, 82205, 82236
20674, 21799, 21789, 81939, 81949, 21800, 21790, 81940, 81950, 22054, 82851, 82237, 82861, 22056, 82852, 82240, 
82862, 22057, 22036, 82208, 82239
20675, 21800, 21790, 81940, 81950, 21801, 21791, 81941, 81951, 22056, 82852, 82240, 82862, 22058, 82853, 82243, 
82863, 22059, 22038, 82211, 82242
20676, 21801, 21791, 81941, 81951, 21802, 21792, 81942, 81952, 22058, 82853, 82243, 82863, 22060, 82854, 82246, 
82864, 22061, 22040, 82214, 82245
20677, 21802, 21792, 81942, 81952, 21803, 21793, 81943, 81953, 22060, 82854, 82246, 82864, 22062, 82855, 82249, 
82865, 22063, 22042, 82217, 82248
20678, 21803, 21793, 81943, 81953, 21804, 21794, 81944, 81954, 22062, 82855, 82249, 82865, 22064, 82856, 82252, 
82866, 22065, 22044, 82220, 82251
20679, 21804, 21794, 81944, 81954, 21805, 21795, 81945, 81955, 22064, 82856, 82252, 82866, 22066, 82857, 82255, 
82867, 22067, 22046, 82223, 82254
20680, 21805, 21795, 81945, 81955, 21806, 21796, 81946, 81956, 22066, 82857, 82255, 82867, 22068, 82858, 82258, 
82868, 22069, 22048, 82226, 82257
20681, 21806, 21796, 81946, 81956, 1961, 1960, 21598, 21599, 22068, 82858, 82258, 82868, 1983, 21665, 21625, 
21666, 22070, 22049, 82229, 82260
20682, 1911, 1910, 21510, 21511, 21807, 21797, 81947, 81957, 1933, 21577, 21537, 21578, 22071, 82859, 82262, 
82869, 22072, 22051, 82230, 82261
20683, 21807, 21797, 81947, 81957, 21808, 21798, 81948, 81958, 22071, 82859, 82262, 82869, 22073, 82860, 82265, 
82870, 22074, 22053, 82233, 82264
20684, 21808, 21798, 81948, 81958, 21809, 21799, 81949, 81959, 22073, 82860, 82265, 82870, 22075, 82861, 82268, 
82871, 22076, 22055, 82236, 82267
20685, 21809, 21799, 81949, 81959, 21810, 21800, 81950, 81960, 22075, 82861, 82268, 82871, 22077, 82862, 82271, 
82872, 22078, 22057, 82239, 82270
20686, 21810, 21800, 81950, 81960, 21811, 21801, 81951, 81961, 22077, 82862, 82271, 82872, 22079, 82863, 82274, 
82873, 22080, 22059, 82242, 82273
20687, 21811, 21801, 81951, 81961, 21812, 21802, 81952, 81962, 22079, 82863, 82274, 82873, 22081, 82864, 82277, 
82874, 22082, 22061, 82245, 82276
20688, 21812, 21802, 81952, 81962, 21813, 21803, 81953, 81963, 22081, 82864, 82277, 82874, 22083, 82865, 82280, 
82875, 22084, 22063, 82248, 82279
20689, 21813, 21803, 81953, 81963, 21814, 21804, 81954, 81964, 22083, 82865, 82280, 82875, 22085, 82866, 82283, 
82876, 22086, 22065, 82251, 82282
20690, 21814, 21804, 81954, 81964, 21815, 21805, 81955, 81965, 22085, 82866, 82283, 82876, 22087, 82867, 82286, 
82877, 22088, 22067, 82254, 82285
20691, 21815, 21805, 81955, 81965, 21816, 21806, 81956, 81966, 22087, 82867, 82286, 82877, 22089, 82868, 82289, 
82878, 22090, 22069, 82257, 82288
20692, 21816, 21806, 81956, 81966, 1962, 1961, 21599, 21600, 22089, 82868, 82289, 82878, 1984, 21666, 21627, 
21667, 22091, 22070, 82260, 82291
20693, 1912, 1911, 21511, 21512, 21817, 21807, 81957, 81967, 1934, 21578, 21539, 21579, 22092, 82869, 82293, 
82879, 22093, 22072, 82261, 82292
20694, 21817, 21807, 81957, 81967, 21818, 21808, 81958, 81968, 22092, 82869, 82293, 82879, 22094, 82870, 82296, 
82880, 22095, 22074, 82264, 82295
20695, 21818, 21808, 81958, 81968, 21819, 21809, 81959, 81969, 22094, 82870, 82296, 82880, 22096, 82871, 82299, 
82881, 22097, 22076, 82267, 82298
20696, 21819, 21809, 81959, 81969, 21820, 21810, 81960, 81970, 22096, 82871, 82299, 82881, 22098, 82872, 82302, 
82882, 22099, 22078, 82270, 82301
20697, 21820, 21810, 81960, 81970, 21821, 21811, 81961, 81971, 22098, 82872, 82302, 82882, 22100, 82873, 82305, 
82883, 22101, 22080, 82273, 82304
20698, 21821, 21811, 81961, 81971, 21822, 21812, 81962, 81972, 22100, 82873, 82305, 82883, 22102, 82874, 82308, 
82884, 22103, 22082, 82276, 82307
20699, 21822, 21812, 81962, 81972, 21823, 21813, 81963, 81973, 22102, 82874, 82308, 82884, 22104, 82875, 82311, 
82885, 22105, 22084, 82279, 82310
20700, 21823, 21813, 81963, 81973, 21824, 21814, 81964, 81974, 22104, 82875, 82311, 82885, 22106, 82876, 82314, 
82886, 22107, 22086, 82282, 82313
20701, 21824, 21814, 81964, 81974, 21825, 21815, 81965, 81975, 22106, 82876, 82314, 82886, 22108, 82877, 82317, 
82887, 22109, 22088, 82285, 82316
20702, 21825, 21815, 81965, 81975, 21826, 21816, 81966, 81976, 22108, 82877, 82317, 82887, 22110, 82878, 82320, 
82888, 22111, 22090, 82288, 82319
20703, 21826, 21816, 81966, 81976, 1963, 1962, 21600, 21601, 22110, 82878, 82320, 82888, 1985, 21667, 21629, 
21668, 22112, 22091, 82291, 82322
20704, 1913, 1912, 21512, 21513, 21827, 21817, 81967, 81977, 1935, 21579, 21541, 21580, 22113, 82879, 82324, 
82889, 22114, 22093, 82292, 82323
20705, 21827, 21817, 81967, 81977, 21828, 21818, 81968, 81978, 22113, 82879, 82324, 82889, 22115, 82880, 82327, 
82890, 22116, 22095, 82295, 82326
20706, 21828, 21818, 81968, 81978, 21829, 21819, 81969, 81979, 22115, 82880, 82327, 82890, 22117, 82881, 82330, 
82891, 22118, 22097, 82298, 82329
20707, 21829, 21819, 81969, 81979, 21830, 21820, 81970, 81980, 22117, 82881, 82330, 82891, 22119, 82882, 82333, 
82892, 22120, 22099, 82301, 82332
20708, 21830, 21820, 81970, 81980, 21831, 21821, 81971, 81981, 22119, 82882, 82333, 82892, 22121, 82883, 82336, 
82893, 22122, 22101, 82304, 82335
20709, 21831, 21821, 81971, 81981, 21832, 21822, 81972, 81982, 22121, 82883, 82336, 82893, 22123, 82884, 82339, 
82894, 22124, 22103, 82307, 82338
20710, 21832, 21822, 81972, 81982, 21833, 21823, 81973, 81983, 22123, 82884, 82339, 82894, 22125, 82885, 82342, 
82895, 22126, 22105, 82310, 82341
20711, 21833, 21823, 81973, 81983, 21834, 21824, 81974, 81984, 22125, 82885, 82342, 82895, 22127, 82886, 82345, 
82896, 22128, 22107, 82313, 82344
20712, 21834, 21824, 81974, 81984, 21835, 21825, 81975, 81985, 22127, 82886, 82345, 82896, 22129, 82887, 82348, 
82897, 22130, 22109, 82316, 82347
20713, 21835, 21825, 81975, 81985, 21836, 21826, 81976, 81986, 22129, 82887, 82348, 82897, 22131, 82888, 82351, 
82898, 22132, 22111, 82319, 82350
20714, 21836, 21826, 81976, 81986, 1964, 1963, 21601, 21602, 22131, 82888, 82351, 82898, 1986, 21668, 21631, 
21669, 22133, 22112, 82322, 82353
20715, 1914, 1913, 21513, 21514, 21837, 21827, 81977, 81987, 1936, 21580, 21543, 21581, 22134, 82889, 82355, 
82899, 22135, 22114, 82323, 82354
20716, 21837, 21827, 81977, 81987, 21838, 21828, 81978, 81988, 22134, 82889, 82355, 82899, 22136, 82890, 82358, 
82900, 22137, 22116, 82326, 82357
20717, 21838, 21828, 81978, 81988, 21839, 21829, 81979, 81989, 22136, 82890, 82358, 82900, 22138, 82891, 82361, 
82901, 22139, 22118, 82329, 82360
20718, 21839, 21829, 81979, 81989, 21840, 21830, 81980, 81990, 22138, 82891, 82361, 82901, 22140, 82892, 82364, 
82902, 22141, 22120, 82332, 82363
20719, 21840, 21830, 81980, 81990, 21841, 21831, 81981, 81991, 22140, 82892, 82364, 82902, 22142, 82893, 82367, 
82903, 22143, 22122, 82335, 82366
20720, 21841, 21831, 81981, 81991, 21842, 21832, 81982, 81992, 22142, 82893, 82367, 82903, 22144, 82894, 82370, 
82904, 22145, 22124, 82338, 82369
20721, 21842, 21832, 81982, 81992, 21843, 21833, 81983, 81993, 22144, 82894, 82370, 82904, 22146, 82895, 82373, 
82905, 22147, 22126, 82341, 82372
20722, 21843, 21833, 81983, 81993, 21844, 21834, 81984, 81994, 22146, 82895, 82373, 82905, 22148, 82896, 82376, 
82906, 22149, 22128, 82344, 82375
20723, 21844, 21834, 81984, 81994, 21845, 21835, 81985, 81995, 22148, 82896, 82376, 82906, 22150, 82897, 82379, 
82907, 22151, 22130, 82347, 82378
20724, 21845, 21835, 81985, 81995, 21846, 21836, 81986, 81996, 22150, 82897, 82379, 82907, 22152, 82898, 82382, 
82908, 22153, 22132, 82350, 82381
20725, 21846, 21836, 81986, 81996, 1965, 1964, 21602, 21603, 22152, 82898, 82382, 82908, 1987, 21669, 21633, 
21670, 22154, 22133, 82353, 82384
20726, 1915, 1914, 21514, 21515, 21847, 21837, 81987, 81997, 1937, 21581, 21545, 21582, 22155, 82899, 82386, 
82909, 22156, 22135, 82354, 82385
20727, 21847, 21837, 81987, 81997, 21848, 21838, 81988, 81998, 22155, 82899, 82386, 82909, 22157, 82900, 82389, 
82910, 22158, 22137, 82357, 82388
20728, 21848, 21838, 81988, 81998, 21849, 21839, 81989, 81999, 22157, 82900, 82389, 82910, 22159, 82901, 82392, 
82911, 22160, 22139, 82360, 82391
20729, 21849, 21839, 81989, 81999, 21850, 21840, 81990, 82000, 22159, 82901, 82392, 82911, 22161, 82902, 82395, 
82912, 22162, 22141, 82363, 82394
20730, 21850, 21840, 81990, 82000, 21851, 21841, 81991, 82001, 22161, 82902, 82395, 82912, 22163, 82903, 82398, 
82913, 22164, 22143, 82366, 82397
20731, 21851, 21841, 81991, 82001, 21852, 21842, 81992, 82002, 22163, 82903, 82398, 82913, 22165, 82904, 82401, 
82914, 22166, 22145, 82369, 82400
20732, 21852, 21842, 81992, 82002, 21853, 21843, 81993, 82003, 22165, 82904, 82401, 82914, 22167, 82905, 82404, 
82915, 22168, 22147, 82372, 82403
20733, 21853, 21843, 81993, 82003, 21854, 21844, 81994, 82004, 22167, 82905, 82404, 82915, 22169, 82906, 82407, 
82916, 22170, 22149, 82375, 82406
20734, 21854, 21844, 81994, 82004, 21855, 21845, 81995, 82005, 22169, 82906, 82407, 82916, 22171, 82907, 82410, 
82917, 22172, 22151, 82378, 82409
20735, 21855, 21845, 81995, 82005, 21856, 21846, 81996, 82006, 22171, 82907, 82410, 82917, 22173, 82908, 82413, 
82918, 22174, 22153, 82381, 82412
20736, 21856, 21846, 81996, 82006, 1966, 1965, 21603, 21604, 22173, 82908, 82413, 82918, 1988, 21670, 21635, 
21671, 22175, 22154, 82384, 82415
20737, 1916, 1915, 21515, 21516, 21857, 21847, 81997, 82007, 1938, 21582, 21547, 21583, 22176, 82909, 82417, 
82919, 22177, 22156, 82385, 82416
20738, 21857, 21847, 81997, 82007, 21858, 21848, 81998, 82008, 22176, 82909, 82417, 82919, 22178, 82910, 82420, 
82920, 22179, 22158, 82388, 82419
20739, 21858, 21848, 81998, 82008, 21859, 21849, 81999, 82009, 22178, 82910, 82420, 82920, 22180, 82911, 82423, 
82921, 22181, 22160, 82391, 82422
20740, 21859, 21849, 81999, 82009, 21860, 21850, 82000, 82010, 22180, 82911, 82423, 82921, 22182, 82912, 82426, 
82922, 22183, 22162, 82394, 82425
20741, 21860, 21850, 82000, 82010, 21861, 21851, 82001, 82011, 22182, 82912, 82426, 82922, 22184, 82913, 82429, 
82923, 22185, 22164, 82397, 82428
20742, 21861, 21851, 82001, 82011, 21862, 21852, 82002, 82012, 22184, 82913, 82429, 82923, 22186, 82914, 82432, 
82924, 22187, 22166, 82400, 82431
20743, 21862, 21852, 82002, 82012, 21863, 21853, 82003, 82013, 22186, 82914, 82432, 82924, 22188, 82915, 82435, 
82925, 22189, 22168, 82403, 82434
20744, 21863, 21853, 82003, 82013, 21864, 21854, 82004, 82014, 22188, 82915, 82435, 82925, 22190, 82916, 82438, 
82926, 22191, 22170, 82406, 82437
20745, 21864, 21854, 82004, 82014, 21865, 21855, 82005, 82015, 22190, 82916, 82438, 82926, 22192, 82917, 82441, 
82927, 22193, 22172, 82409, 82440
20746, 21865, 21855, 82005, 82015, 21866, 21856, 82006, 82016, 22192, 82917, 82441, 82927, 22194, 82918, 82444, 
82928, 22195, 22174, 82412, 82443
20747, 21866, 21856, 82006, 82016, 1967, 1966, 21604, 21605, 22194, 82918, 82444, 82928, 1989, 21671, 21637, 
21672, 22196, 22175, 82415, 82446
20748, 1917, 1916, 21516, 21517, 21867, 21857, 82007, 82017, 1939, 21583, 21549, 21584, 22197, 82919, 82448, 
82929, 22198, 22177, 82416, 82447
20749, 21867, 21857, 82007, 82017, 21868, 21858, 82008, 82018, 22197, 82919, 82448, 82929, 22199, 82920, 82451, 
82930, 22200, 22179, 82419, 82450
20750, 21868, 21858, 82008, 82018, 21869, 21859, 82009, 82019, 22199, 82920, 82451, 82930, 22201, 82921, 82454, 
82931, 22202, 22181, 82422, 82453
20751, 21869, 21859, 82009, 82019, 21870, 21860, 82010, 82020, 22201, 82921, 82454, 82931, 22203, 82922, 82457, 
82932, 22204, 22183, 82425, 82456
20752, 21870, 21860, 82010, 82020, 21871, 21861, 82011, 82021, 22203, 82922, 82457, 82932, 22205, 82923, 82460, 
82933, 22206, 22185, 82428, 82459
20753, 21871, 21861, 82011, 82021, 21872, 21862, 82012, 82022, 22205, 82923, 82460, 82933, 22207, 82924, 82463, 
82934, 22208, 22187, 82431, 82462
20754, 21872, 21862, 82012, 82022, 21873, 21863, 82013, 82023, 22207, 82924, 82463, 82934, 22209, 82925, 82466, 
82935, 22210, 22189, 82434, 82465
20755, 21873, 21863, 82013, 82023, 21874, 21864, 82014, 82024, 22209, 82925, 82466, 82935, 22211, 82926, 82469, 
82936, 22212, 22191, 82437, 82468
20756, 21874, 21864, 82014, 82024, 21875, 21865, 82015, 82025, 22211, 82926, 82469, 82936, 22213, 82927, 82472, 
82937, 22214, 22193, 82440, 82471
20757, 21875, 21865, 82015, 82025, 21876, 21866, 82016, 82026, 22213, 82927, 82472, 82937, 22215, 82928, 82475, 
82938, 22216, 22195, 82443, 82474
20758, 21876, 21866, 82016, 82026, 1968, 1967, 21605, 21606, 22215, 82928, 82475, 82938, 1990, 21672, 21639, 
21673, 22217, 22196, 82446, 82477
20759, 1918, 1917, 21517, 21518, 21877, 21867, 82017, 82027, 1940, 21584, 21551, 21585, 22218, 82929, 82479, 
82939, 22219, 22198, 82447, 82478
20760, 21877, 21867, 82017, 82027, 21878, 21868, 82018, 82028, 22218, 82929, 82479, 82939, 22220, 82930, 82482, 
82940, 22221, 22200, 82450, 82481
20761, 21878, 21868, 82018, 82028, 21879, 21869, 82019, 82029, 22220, 82930, 82482, 82940, 22222, 82931, 82485, 
82941, 22223, 22202, 82453, 82484
20762, 21879, 21869, 82019, 82029, 21880, 21870, 82020, 82030, 22222, 82931, 82485, 82941, 22224, 82932, 82488, 
82942, 22225, 22204, 82456, 82487
20763, 21880, 21870, 82020, 82030, 21881, 21871, 82021, 82031, 22224, 82932, 82488, 82942, 22226, 82933, 82491, 
82943, 22227, 22206, 82459, 82490
20764, 21881, 21871, 82021, 82031, 21882, 21872, 82022, 82032, 22226, 82933, 82491, 82943, 22228, 82934, 82494, 
82944, 22229, 22208, 82462, 82493
20765, 21882, 21872, 82022, 82032, 21883, 21873, 82023, 82033, 22228, 82934, 82494, 82944, 22230, 82935, 82497, 
82945, 22231, 22210, 82465, 82496
20766, 21883, 21873, 82023, 82033, 21884, 21874, 82024, 82034, 22230, 82935, 82497, 82945, 22232, 82936, 82500, 
82946, 22233, 22212, 82468, 82499
20767, 21884, 21874, 82024, 82034, 21885, 21875, 82025, 82035, 22232, 82936, 82500, 82946, 22234, 82937, 82503, 
82947, 22235, 22214, 82471, 82502
20768, 21885, 21875, 82025, 82035, 21886, 21876, 82026, 82036, 22234, 82937, 82503, 82947, 22236, 82938, 82506, 
82948, 22237, 22216, 82474, 82505
20769, 21886, 21876, 82026, 82036, 1969, 1968, 21606, 21607, 22236, 82938, 82506, 82948, 1991, 21673, 21641, 
21674, 22238, 22217, 82477, 82508
20770, 1919, 1918, 21518, 21519, 21887, 21877, 82027, 82037, 1941, 21585, 21553, 21586, 22239, 82939, 82510, 
82949, 22240, 22219, 82478, 82509
20771, 21887, 21877, 82027, 82037, 21888, 21878, 82028, 82038, 22239, 82939, 82510, 82949, 22241, 82940, 82513, 
82950, 22242, 22221, 82481, 82512
20772, 21888, 21878, 82028, 82038, 21889, 21879, 82029, 82039, 22241, 82940, 82513, 82950, 22243, 82941, 82516, 
82951, 22244, 22223, 82484, 82515
20773, 21889, 21879, 82029, 82039, 21890, 21880, 82030, 82040, 22243, 82941, 82516, 82951, 22245, 82942, 82519, 
82952, 22246, 22225, 82487, 82518
20774, 21890, 21880, 82030, 82040, 21891, 21881, 82031, 82041, 22245, 82942, 82519, 82952, 22247, 82943, 82522, 
82953, 22248, 22227, 82490, 82521
20775, 21891, 21881, 82031, 82041, 21892, 21882, 82032, 82042, 22247, 82943, 82522, 82953, 22249, 82944, 82525, 
82954, 22250, 22229, 82493, 82524
20776, 21892, 21882, 82032, 82042, 21893, 21883, 82033, 82043, 22249, 82944, 82525, 82954, 22251, 82945, 82528, 
82955, 22252, 22231, 82496, 82527
20777, 21893, 21883, 82033, 82043, 21894, 21884, 82034, 82044, 22251, 82945, 82528, 82955, 22253, 82946, 82531, 
82956, 22254, 22233, 82499, 82530
20778, 21894, 21884, 82034, 82044, 21895, 21885, 82035, 82045, 22253, 82946, 82531, 82956, 22255, 82947, 82534, 
82957, 22256, 22235, 82502, 82533
20779, 21895, 21885, 82035, 82045, 21896, 21886, 82036, 82046, 22255, 82947, 82534, 82957, 22257, 82948, 82537, 
82958, 22258, 22237, 82505, 82536
20780, 21896, 21886, 82036, 82046, 1970, 1969, 21607, 21608, 22257, 82948, 82537, 82958, 1992, 21674, 21643, 
21675, 22259, 22238, 82508, 82539
20781, 1920, 1919, 21519, 21520, 21897, 21887, 82037, 82047, 1942, 21586, 21555, 21587, 22260, 82949, 82541, 
82959, 22261, 22240, 82509, 82540
20782, 21897, 21887, 82037, 82047, 21898, 21888, 82038, 82048, 22260, 82949, 82541, 82959, 22262, 82950, 82544, 
82960, 22263, 22242, 82512, 82543
20783, 21898, 21888, 82038, 82048, 21899, 21889, 82039, 82049, 22262, 82950, 82544, 82960, 22264, 82951, 82547, 
82961, 22265, 22244, 82515, 82546
20784, 21899, 21889, 82039, 82049, 21900, 21890, 82040, 82050, 22264, 82951, 82547, 82961, 22266, 82952, 82550, 
82962, 22267, 22246, 82518, 82549
20785, 21900, 21890, 82040, 82050, 21901, 21891, 82041, 82051, 22266, 82952, 82550, 82962, 22268, 82953, 82553, 
82963, 22269, 22248, 82521, 82552
20786, 21901, 21891, 82041, 82051, 21902, 21892, 82042, 82052, 22268, 82953, 82553, 82963, 22270, 82954, 82556, 
82964, 22271, 22250, 82524, 82555
20787, 21902, 21892, 82042, 82052, 21903, 21893, 82043, 82053, 22270, 82954, 82556, 82964, 22272, 82955, 82559, 
82965, 22273, 22252, 82527, 82558
20788, 21903, 21893, 82043, 82053, 21904, 21894, 82044, 82054, 22272, 82955, 82559, 82965, 22274, 82956, 82562, 
82966, 22275, 22254, 82530, 82561
20789, 21904, 21894, 82044, 82054, 21905, 21895, 82045, 82055, 22274, 82956, 82562, 82966, 22276, 82957, 82565, 
82967, 22277, 22256, 82533, 82564
20790, 21905, 21895, 82045, 82055, 21906, 21896, 82046, 82056, 22276, 82957, 82565, 82967, 22278, 82958, 82568, 
82968, 22279, 22258, 82536, 82567
20791, 21906, 21896, 82046, 82056, 1971, 1970, 21608, 21609, 22278, 82958, 82568, 82968, 1993, 21675, 21645, 
21676, 22280, 22259, 82539, 82570
20792, 1921, 1920, 21520, 21521, 21907, 21897, 82047, 82057, 1943, 21587, 21557, 21588, 22281, 82959, 82572, 
82969, 22282, 22261, 82540, 82571
20793, 21907, 21897, 82047, 82057, 21908, 21898, 82048, 82058, 22281, 82959, 82572, 82969, 22283, 82960, 82575, 
82970, 22284, 22263, 82543, 82574
20794, 21908, 21898, 82048, 82058, 21909, 21899, 82049, 82059, 22283, 82960, 82575, 82970, 22285, 82961, 82578, 
82971, 22286, 22265, 82546, 82577
20795, 21909, 21899, 82049, 82059, 21910, 21900, 82050, 82060, 22285, 82961, 82578, 82971, 22287, 82962, 82581, 
82972, 22288, 22267, 82549, 82580
20796, 21910, 21900, 82050, 82060, 21911, 21901, 82051, 82061, 22287, 82962, 82581, 82972, 22289, 82963, 82584, 
82973, 22290, 22269, 82552, 82583
20797, 21911, 21901, 82051, 82061, 21912, 21902, 82052, 82062, 22289, 82963, 82584, 82973, 22291, 82964, 82587, 
82974, 22292, 22271, 82555, 82586
20798, 21912, 21902, 82052, 82062, 21913, 21903, 82053, 82063, 22291, 82964, 82587, 82974, 22293, 82965, 82590, 
82975, 22294, 22273, 82558, 82589
20799, 21913, 21903, 82053, 82063, 21914, 21904, 82054, 82064, 22293, 82965, 82590, 82975, 22295, 82966, 82593, 
82976, 22296, 22275, 82561, 82592
20800, 21914, 21904, 82054, 82064, 21915, 21905, 82055, 82065, 22295, 82966, 82593, 82976, 22297, 82967, 82596, 
82977, 22298, 22277, 82564, 82595
20801, 21915, 21905, 82055, 82065, 21916, 21906, 82056, 82066, 22297, 82967, 82596, 82977, 22299, 82968, 82599, 
82978, 22300, 22279, 82567, 82598
20802, 21916, 21906, 82056, 82066, 1972, 1971, 21609, 21610, 22299, 82968, 82599, 82978, 1994, 21676, 21647, 
21677, 22301, 22280, 82570, 82601
20803, 1922, 1921, 21521, 21522, 21917, 21907, 82057, 82067, 1944, 21588, 21559, 21589, 22302, 82969, 82603, 
82979, 22303, 22282, 82571, 82602
20804, 21917, 21907, 82057, 82067, 21918, 21908, 82058, 82068, 22302, 82969, 82603, 82979, 22304, 82970, 82606, 
82980, 22305, 22284, 82574, 82605
20805, 21918, 21908, 82058, 82068, 21919, 21909, 82059, 82069, 22304, 82970, 82606, 82980, 22306, 82971, 82609, 
82981, 22307, 22286, 82577, 82608
20806, 21919, 21909, 82059, 82069, 21920, 21910, 82060, 82070, 22306, 82971, 82609, 82981, 22308, 82972, 82612, 
82982, 22309, 22288, 82580, 82611
20807, 21920, 21910, 82060, 82070, 21921, 21911, 82061, 82071, 22308, 82972, 82612, 82982, 22310, 82973, 82615, 
82983, 22311, 22290, 82583, 82614
20808, 21921, 21911, 82061, 82071, 21922, 21912, 82062, 82072, 22310, 82973, 82615, 82983, 22312, 82974, 82618, 
82984, 22313, 22292, 82586, 82617
20809, 21922, 21912, 82062, 82072, 21923, 21913, 82063, 82073, 22312, 82974, 82618, 82984, 22314, 82975, 82621, 
82985, 22315, 22294, 82589, 82620
20810, 21923, 21913, 82063, 82073, 21924, 21914, 82064, 82074, 22314, 82975, 82621, 82985, 22316, 82976, 82624, 
82986, 22317, 22296, 82592, 82623
20811, 21924, 21914, 82064, 82074, 21925, 21915, 82065, 82075, 22316, 82976, 82624, 82986, 22318, 82977, 82627, 
82987, 22319, 22298, 82595, 82626
20812, 21925, 21915, 82065, 82075, 21926, 21916, 82066, 82076, 22318, 82977, 82627, 82987, 22320, 82978, 82630, 
82988, 22321, 22300, 82598, 82629
20813, 21926, 21916, 82066, 82076, 1973, 1972, 21610, 21611, 22320, 82978, 82630, 82988, 1995, 21677, 21649, 
21678, 22322, 22301, 82601, 82632
20814, 1923, 1922, 21522, 21523, 21927, 21917, 82067, 82077, 1945, 21589, 21561, 21590, 22323, 82979, 82634, 
82989, 22324, 22303, 82602, 82633
20815, 21927, 21917, 82067, 82077, 21928, 21918, 82068, 82078, 22323, 82979, 82634, 82989, 22325, 82980, 82637, 
82990, 22326, 22305, 82605, 82636
20816, 21928, 21918, 82068, 82078, 21929, 21919, 82069, 82079, 22325, 82980, 82637, 82990, 22327, 82981, 82640, 
82991, 22328, 22307, 82608, 82639
20817, 21929, 21919, 82069, 82079, 21930, 21920, 82070, 82080, 22327, 82981, 82640, 82991, 22329, 82982, 82643, 
82992, 22330, 22309, 82611, 82642
20818, 21930, 21920, 82070, 82080, 21931, 21921, 82071, 82081, 22329, 82982, 82643, 82992, 22331, 82983, 82646, 
82993, 22332, 22311, 82614, 82645
20819, 21931, 21921, 82071, 82081, 21932, 21922, 82072, 82082, 22331, 82983, 82646, 82993, 22333, 82984, 82649, 
82994, 22334, 22313, 82617, 82648
20820, 21932, 21922, 82072, 82082, 21933, 21923, 82073, 82083, 22333, 82984, 82649, 82994, 22335, 82985, 82652, 
82995, 22336, 22315, 82620, 82651
20821, 21933, 21923, 82073, 82083, 21934, 21924, 82074, 82084, 22335, 82985, 82652, 82995, 22337, 82986, 82655, 
82996, 22338, 22317, 82623, 82654
20822, 21934, 21924, 82074, 82084, 21935, 21925, 82075, 82085, 22337, 82986, 82655, 82996, 22339, 82987, 82658, 
82997, 22340, 22319, 82626, 82657
20823, 21935, 21925, 82075, 82085, 21936, 21926, 82076, 82086, 22339, 82987, 82658, 82997, 22341, 82988, 82661, 
82998, 22342, 22321, 82629, 82660
20824, 21936, 21926, 82076, 82086, 1974, 1973, 21611, 21612, 22341, 82988, 82661, 82998, 1996, 21678, 21651, 
21679, 22343, 22322, 82632, 82663
20825, 1924, 1923, 21523, 21524, 21937, 21927, 82077, 82087, 1946, 21590, 21563, 21591, 22344, 82989, 82665, 
82999, 22345, 22324, 82633, 82664
20826, 21937, 21927, 82077, 82087, 21938, 21928, 82078, 82088, 22344, 82989, 82665, 82999, 22346, 82990, 82668, 
83000, 22347, 22326, 82636, 82667
20827, 21938, 21928, 82078, 82088, 21939, 21929, 82079, 82089, 22346, 82990, 82668, 83000, 22348, 82991, 82671, 
83001, 22349, 22328, 82639, 82670
20828, 21939, 21929, 82079, 82089, 21940, 21930, 82080, 82090, 22348, 82991, 82671, 83001, 22350, 82992, 82674, 
83002, 22351, 22330, 82642, 82673
20829, 21940, 21930, 82080, 82090, 21941, 21931, 82081, 82091, 22350, 82992, 82674, 83002, 22352, 82993, 82677, 
83003, 22353, 22332, 82645, 82676
20830, 21941, 21931, 82081, 82091, 21942, 21932, 82082, 82092, 22352, 82993, 82677, 83003, 22354, 82994, 82680, 
83004, 22355, 22334, 82648, 82679
20831, 21942, 21932, 82082, 82092, 21943, 21933, 82083, 82093, 22354, 82994, 82680, 83004, 22356, 82995, 82683, 
83005, 22357, 22336, 82651, 82682
20832, 21943, 21933, 82083, 82093, 21944, 21934, 82084, 82094, 22356, 82995, 82683, 83005, 22358, 82996, 82686, 
83006, 22359, 22338, 82654, 82685
20833, 21944, 21934, 82084, 82094, 21945, 21935, 82085, 82095, 22358, 82996, 82686, 83006, 22360, 82997, 82689, 
83007, 22361, 22340, 82657, 82688
20834, 21945, 21935, 82085, 82095, 21946, 21936, 82086, 82096, 22360, 82997, 82689, 83007, 22362, 82998, 82692, 
83008, 22363, 22342, 82660, 82691
20835, 21946, 21936, 82086, 82096, 1975, 1974, 21612, 21613, 22362, 82998, 82692, 83008, 1997, 21679, 21653, 
21680, 22364, 22343, 82663, 82694
20836, 1925, 1924, 21524, 21525, 21947, 21937, 82087, 82097, 1947, 21591, 21565, 21592, 22365, 82999, 82696, 
83009, 22366, 22345, 82664, 82695
20837, 21947, 21937, 82087, 82097, 21948, 21938, 82088, 82098, 22365, 82999, 82696, 83009, 22367, 83000, 82699, 
83010, 22368, 22347, 82667, 82698
20838, 21948, 21938, 82088, 82098, 21949, 21939, 82089, 82099, 22367, 83000, 82699, 83010, 22369, 83001, 82702, 
83011, 22370, 22349, 82670, 82701
20839, 21949, 21939, 82089, 82099, 21950, 21940, 82090, 82100, 22369, 83001, 82702, 83011, 22371, 83002, 82705, 
83012, 22372, 22351, 82673, 82704
20840, 21950, 21940, 82090, 82100, 21951, 21941, 82091, 82101, 22371, 83002, 82705, 83012, 22373, 83003, 82708, 
83013, 22374, 22353, 82676, 82707
20841, 21951, 21941, 82091, 82101, 21952, 21942, 82092, 82102, 22373, 83003, 82708, 83013, 22375, 83004, 82711, 
83014, 22376, 22355, 82679, 82710
20842, 21952, 21942, 82092, 82102, 21953, 21943, 82093, 82103, 22375, 83004, 82711, 83014, 22377, 83005, 82714, 
83015, 22378, 22357, 82682, 82713
20843, 21953, 21943, 82093, 82103, 21954, 21944, 82094, 82104, 22377, 83005, 82714, 83015, 22379, 83006, 82717, 
83016, 22380, 22359, 82685, 82716
20844, 21954, 21944, 82094, 82104, 21955, 21945, 82095, 82105, 22379, 83006, 82717, 83016, 22381, 83007, 82720, 
83017, 22382, 22361, 82688, 82719
20845, 21955, 21945, 82095, 82105, 21956, 21946, 82096, 82106, 22381, 83007, 82720, 83017, 22383, 83008, 82723, 
83018, 22384, 22363, 82691, 82722
20846, 21956, 21946, 82096, 82106, 1976, 1975, 21613, 21614, 22383, 83008, 82723, 83018, 1998, 21680, 21655, 
21681, 22385, 22364, 82694, 82725
20847, 1926, 1925, 21525, 21526, 21957, 21947, 82097, 82107, 1948, 21592, 21567, 21593, 22386, 83009, 82727, 
83019, 22387, 22366, 82695, 82726
20848, 21957, 21947, 82097, 82107, 21958, 21948, 82098, 82108, 22386, 83009, 82727, 83019, 22388, 83010, 82730, 
83020, 22389, 22368, 82698, 82729
20849, 21958, 21948, 82098, 82108, 21959, 21949, 82099, 82109, 22388, 83010, 82730, 83020, 22390, 83011, 82733, 
83021, 22391, 22370, 82701, 82732
20850, 21959, 21949, 82099, 82109, 21960, 21950, 82100, 82110, 22390, 83011, 82733, 83021, 22392, 83012, 82736, 
83022, 22393, 22372, 82704, 82735
20851, 21960, 21950, 82100, 82110, 21961, 21951, 82101, 82111, 22392, 83012, 82736, 83022, 22394, 83013, 82739, 
83023, 22395, 22374, 82707, 82738
20852, 21961, 21951, 82101, 82111, 21962, 21952, 82102, 82112, 22394, 83013, 82739, 83023, 22396, 83014, 82742, 
83024, 22397, 22376, 82710, 82741
20853, 21962, 21952, 82102, 82112, 21963, 21953, 82103, 82113, 22396, 83014, 82742, 83024, 22398, 83015, 82745, 
83025, 22399, 22378, 82713, 82744
20854, 21963, 21953, 82103, 82113, 21964, 21954, 82104, 82114, 22398, 83015, 82745, 83025, 22400, 83016, 82748, 
83026, 22401, 22380, 82716, 82747
20855, 21964, 21954, 82104, 82114, 21965, 21955, 82105, 82115, 22400, 83016, 82748, 83026, 22402, 83017, 82751, 
83027, 22403, 22382, 82719, 82750
20856, 21965, 21955, 82105, 82115, 21966, 21956, 82106, 82116, 22402, 83017, 82751, 83027, 22404, 83018, 82754, 
83028, 22405, 22384, 82722, 82753
20857, 21966, 21956, 82106, 82116, 1977, 1976, 21614, 21615, 22404, 83018, 82754, 83028, 1999, 21681, 21657, 
21682, 22406, 22385, 82725, 82756
20858, 1927, 1926, 21526, 21527, 21967, 21957, 82107, 82117, 1949, 21593, 21569, 21594, 22407, 83019, 82758, 
83029, 22408, 22387, 82726, 82757
20859, 21967, 21957, 82107, 82117, 21968, 21958, 82108, 82118, 22407, 83019, 82758, 83029, 22409, 83020, 82761, 
83030, 22410, 22389, 82729, 82760
20860, 21968, 21958, 82108, 82118, 21969, 21959, 82109, 82119, 22409, 83020, 82761, 83030, 22411, 83021, 82764, 
83031, 22412, 22391, 82732, 82763
20861, 21969, 21959, 82109, 82119, 21970, 21960, 82110, 82120, 22411, 83021, 82764, 83031, 22413, 83022, 82767, 
83032, 22414, 22393, 82735, 82766
20862, 21970, 21960, 82110, 82120, 21971, 21961, 82111, 82121, 22413, 83022, 82767, 83032, 22415, 83023, 82770, 
83033, 22416, 22395, 82738, 82769
20863, 21971, 21961, 82111, 82121, 21972, 21962, 82112, 82122, 22415, 83023, 82770, 83033, 22417, 83024, 82773, 
83034, 22418, 22397, 82741, 82772
20864, 21972, 21962, 82112, 82122, 21973, 21963, 82113, 82123, 22417, 83024, 82773, 83034, 22419, 83025, 82776, 
83035, 22420, 22399, 82744, 82775
20865, 21973, 21963, 82113, 82123, 21974, 21964, 82114, 82124, 22419, 83025, 82776, 83035, 22421, 83026, 82779, 
83036, 22422, 22401, 82747, 82778
20866, 21974, 21964, 82114, 82124, 21975, 21965, 82115, 82125, 22421, 83026, 82779, 83036, 22423, 83027, 82782, 
83037, 22424, 22403, 82750, 82781
20867, 21975, 21965, 82115, 82125, 21976, 21966, 82116, 82126, 22423, 83027, 82782, 83037, 22425, 83028, 82785, 
83038, 22426, 22405, 82753, 82784
20868, 21976, 21966, 82116, 82126, 1978, 1977, 21615, 21616, 22425, 83028, 82785, 83038, 2000, 21682, 21659, 
21683, 22427, 22406, 82756, 82787
20869, 1928, 1927, 21527, 21528, 21977, 21967, 82117, 82127, 1950, 21594, 21571, 21595, 22428, 83029, 82789, 
83039, 22429, 22408, 82757, 82788
20870, 21977, 21967, 82117, 82127, 21978, 21968, 82118, 82128, 22428, 83029, 82789, 83039, 22430, 83030, 82792, 
83040, 22431, 22410, 82760, 82791
20871, 21978, 21968, 82118, 82128, 21979, 21969, 82119, 82129, 22430, 83030, 82792, 83040, 22432, 83031, 82795, 
83041, 22433, 22412, 82763, 82794
20872, 21979, 21969, 82119, 82129, 21980, 21970, 82120, 82130, 22432, 83031, 82795, 83041, 22434, 83032, 82798, 
83042, 22435, 22414, 82766, 82797
20873, 21980, 21970, 82120, 82130, 21981, 21971, 82121, 82131, 22434, 83032, 82798, 83042, 22436, 83033, 82801, 
83043, 22437, 22416, 82769, 82800
20874, 21981, 21971, 82121, 82131, 21982, 21972, 82122, 82132, 22436, 83033, 82801, 83043, 22438, 83034, 82804, 
83044, 22439, 22418, 82772, 82803
20875, 21982, 21972, 82122, 82132, 21983, 21973, 82123, 82133, 22438, 83034, 82804, 83044, 22440, 83035, 82807, 
83045, 22441, 22420, 82775, 82806
20876, 21983, 21973, 82123, 82133, 21984, 21974, 82124, 82134, 22440, 83035, 82807, 83045, 22442, 83036, 82810, 
83046, 22443, 22422, 82778, 82809
20877, 21984, 21974, 82124, 82134, 21985, 21975, 82125, 82135, 22442, 83036, 82810, 83046, 22444, 83037, 82813, 
83047, 22445, 22424, 82781, 82812
20878, 21985, 21975, 82125, 82135, 21986, 21976, 82126, 82136, 22444, 83037, 82813, 83047, 22446, 83038, 82816, 
83048, 22447, 22426, 82784, 82815
20879, 21986, 21976, 82126, 82136, 1979, 1978, 21616, 21617, 22446, 83038, 82816, 83048, 2001, 21683, 21661, 
21684, 22448, 22427, 82787, 82818
20880, 42, 1928, 21528, 1904, 2033, 21977, 82127, 21726, 1951, 21595, 21573, 1906, 22449, 83039, 82819, 
21757, 2044, 22429, 82788, 21736
20881, 2033, 21977, 82127, 21726, 2032, 21978, 82128, 21727, 22449, 83039, 82819, 21757, 22450, 83040, 82820, 
21758, 2043, 22431, 82791, 21738
20882, 2032, 21978, 82128, 21727, 2031, 21979, 82129, 21728, 22450, 83040, 82820, 21758, 22451, 83041, 82821, 
21759, 2042, 22433, 82794, 21740
20883, 2031, 21979, 82129, 21728, 2030, 21980, 82130, 21729, 22451, 83041, 82821, 21759, 22452, 83042, 82822, 
21760, 2041, 22435, 82797, 21742
20884, 2030, 21980, 82130, 21729, 2029, 21981, 82131, 21730, 22452, 83042, 82822, 21760, 22453, 83043, 82823, 
21761, 2040, 22437, 82800, 21744
20885, 2029, 21981, 82131, 21730, 2028, 21982, 82132, 21731, 22453, 83043, 82823, 21761, 22454, 83044, 82824, 
21762, 2039, 22439, 82803, 21746
20886, 2028, 21982, 82132, 21731, 2027, 21983, 82133, 21732, 22454, 83044, 82824, 21762, 22455, 83045, 82825, 
21763, 2038, 22441, 82806, 21748
20887, 2027, 21983, 82133, 21732, 2026, 21984, 82134, 21733, 22455, 83045, 82825, 21763, 22456, 83046, 82826, 
21764, 2037, 22443, 82809, 21750
20888, 2026, 21984, 82134, 21733, 2025, 21985, 82135, 21734, 22456, 83046, 82826, 21764, 22457, 83047, 82827, 
21765, 2036, 22445, 82812, 21752
20889, 2025, 21985, 82135, 21734, 2024, 21986, 82136, 21735, 22457, 83047, 82827, 21765, 22458, 83048, 82828, 
21766, 2035, 22447, 82815, 21754
20890, 2024, 21986, 82136, 21735, 44, 1979, 21617, 1955, 22458, 83048, 82828, 21766, 2002, 21684, 21662, 
1957, 2034, 22448, 82818, 21756
*ELEMENT, type=C3D20, ELSET=Volume11
20891, 28762, 3077, 41, 1907, 83049, 29074, 2012, 21767, 28806, 3079, 1929, 28807, 83490, 29094, 21987, 
83491, 83489, 29095, 2023, 21988
20892, 83049, 29074, 2012, 21767, 83050, 29075, 2011, 21768, 83490, 29094, 21987, 83491, 83493, 29096, 21989, 
83494, 83492, 29097, 2022, 21990
20893, 83050, 29075, 2011, 21768, 83051, 29076, 2010, 21769, 83493, 29096, 21989, 83494, 83496, 29098, 21991, 
83497, 83495, 29099, 2021, 21992
20894, 83051, 29076, 2010, 21769, 83052, 29077, 2009, 21770, 83496, 29098, 21991, 83497, 83499, 29100, 21993, 
83500, 83498, 29101, 2020, 21994
20895, 83052, 29077, 2009, 21770, 83053, 29078, 2008, 21771, 83499, 29100, 21993, 83500, 83502, 29102, 21995, 
83503, 83501, 29103, 2019, 21996
20896, 83053, 29078, 2008, 21771, 83054, 29079, 2007, 21772, 83502, 29102, 21995, 83503, 83505, 29104, 21997, 
83506, 83504, 29105, 2018, 21998
20897, 83054, 29079, 2007, 21772, 83055, 29080, 2006, 21773, 83505, 29104, 21997, 83506, 83508, 29106, 21999, 
83509, 83507, 29107, 2017, 22000
20898, 83055, 29080, 2006, 21773, 83056, 29081, 2005, 21774, 83508, 29106, 21999, 83509, 83511, 29108, 22001, 
83512, 83510, 29109, 2016, 22002
20899, 83056, 29081, 2005, 21774, 83057, 29082, 2004, 21775, 83511, 29108, 22001, 83512, 83514, 29110, 22003, 
83515, 83513, 29111, 2015, 22004
20900, 83057, 29082, 2004, 21775, 83058, 29083, 2003, 21776, 83514, 29110, 22003, 83515, 83517, 29112, 22005, 
83518, 83516, 29113, 2014, 22006
20901, 83058, 29083, 2003, 21776, 28918, 3127, 43, 1958, 83517, 29112, 22005, 83518, 28963, 3129, 1980, 
28962, 83519, 29114, 2013, 22007
20902, 28763, 28762, 1907, 1908, 83059, 83049, 21767, 21777, 28808, 28807, 1930, 28809, 83521, 83491, 22008, 
83522, 83520, 83489, 21988, 22009
20903, 83059, 83049, 21767, 21777, 83060, 83050, 21768, 21778, 83521, 83491, 22008, 83522, 83524, 83494, 22010, 
83525, 83523, 83492, 21990, 22011
20904, 83060, 83050, 21768, 21778, 83061, 83051, 21769, 21779, 83524, 83494, 22010, 83525, 83527, 83497, 22012, 
83528, 83526, 83495, 21992, 22013
20905, 83061, 83051, 21769, 21779, 83062, 83052, 21770, 21780, 83527, 83497, 22012, 83528, 83530, 83500, 22014, 
83531, 83529, 83498, 21994, 22015
20906, 83062, 83052, 21770, 21780, 83063, 83053, 21771, 21781, 83530, 83500, 22014, 83531, 83533, 83503, 22016, 
83534, 83532, 83501, 21996, 22017
20907, 83063, 83053, 21771, 21781, 83064, 83054, 21772, 21782, 83533, 83503, 22016, 83534, 83536, 83506, 22018, 
83537, 83535, 83504, 21998, 22019
20908, 83064, 83054, 21772, 21782, 83065, 83055, 21773, 21783, 83536, 83506, 22018, 83537, 83539, 83509, 22020, 
83540, 83538, 83507, 22000, 22021
20909, 83065, 83055, 21773, 21783, 83066, 83056, 21774, 21784, 83539, 83509, 22020, 83540, 83542, 83512, 22022, 
83543, 83541, 83510, 22002, 22023
20910, 83066, 83056, 21774, 21784, 83067, 83057, 21775, 21785, 83542, 83512, 22022, 83543, 83545, 83515, 22024, 
83546, 83544, 83513, 22004, 22025
20911, 83067, 83057, 21775, 21785, 83068, 83058, 21776, 21786, 83545, 83515, 22024, 83546, 83548, 83518, 22026, 
83549, 83547, 83516, 22006, 22027
20912, 83068, 83058, 21776, 21786, 28919, 28918, 1958, 1959, 83548, 83518, 22026, 83549, 28965, 28962, 1981, 
28964, 83550, 83519, 22007, 22028
20913, 28764, 28763, 1908, 1909, 83069, 83059, 21777, 21787, 28810, 28809, 1931, 28811, 83552, 83522, 22029, 
83553, 83551, 83520, 22009, 22030
20914, 83069, 83059, 21777, 21787, 83070, 83060, 21778, 21788, 83552, 83522, 22029, 83553, 83555, 83525, 22031, 
83556, 83554, 83523, 22011, 22032
20915, 83070, 83060, 21778, 21788, 83071, 83061, 21779, 21789, 83555, 83525, 22031, 83556, 83558, 83528, 22033, 
83559, 83557, 83526, 22013, 22034
20916, 83071, 83061, 21779, 21789, 83072, 83062, 21780, 21790, 83558, 83528, 22033, 83559, 83561, 83531, 22035, 
83562, 83560, 83529, 22015, 22036
20917, 83072, 83062, 21780, 21790, 83073, 83063, 21781, 21791, 83561, 83531, 22035, 83562, 83564, 83534, 22037, 
83565, 83563, 83532, 22017, 22038
20918, 83073, 83063, 21781, 21791, 83074, 83064, 21782, 21792, 83564, 83534, 22037, 83565, 83567, 83537, 22039, 
83568, 83566, 83535, 22019, 22040
20919, 83074, 83064, 21782, 21792, 83075, 83065, 21783, 21793, 83567, 83537, 22039, 83568, 83570, 83540, 22041, 
83571, 83569, 83538, 22021, 22042
20920, 83075, 83065, 21783, 21793, 83076, 83066, 21784, 21794, 83570, 83540, 22041, 83571, 83573, 83543, 22043, 
83574, 83572, 83541, 22023, 22044
20921, 83076, 83066, 21784, 21794, 83077, 83067, 21785, 21795, 83573, 83543, 22043, 83574, 83576, 83546, 22045, 
83577, 83575, 83544, 22025, 22046
20922, 83077, 83067, 21785, 21795, 83078, 83068, 21786, 21796, 83576, 83546, 22045, 83577, 83579, 83549, 22047, 
83580, 83578, 83547, 22027, 22048
20923, 83078, 83068, 21786, 21796, 28920, 28919, 1959, 1960, 83579, 83549, 22047, 83580, 28967, 28964, 1982, 
28966, 83581, 83550, 22028, 22049
20924, 28765, 28764, 1909, 1910, 83079, 83069, 21787, 21797, 28812, 28811, 1932, 28813, 83583, 83553, 22050, 
83584, 83582, 83551, 22030, 22051
20925, 83079, 83069, 21787, 21797, 83080, 83070, 21788, 21798, 83583, 83553, 22050, 83584, 83586, 83556, 22052, 
83587, 83585, 83554, 22032, 22053
20926, 83080, 83070, 21788, 21798, 83081, 83071, 21789, 21799, 83586, 83556, 22052, 83587, 83589, 83559, 22054, 
83590, 83588, 83557, 22034, 22055
20927, 83081, 83071, 21789, 21799, 83082, 83072, 21790, 21800, 83589, 83559, 22054, 83590, 83592, 83562, 22056, 
83593, 83591, 83560, 22036, 22057
20928, 83082, 83072, 21790, 21800, 83083, 83073, 21791, 21801, 83592, 83562, 22056, 83593, 83595, 83565, 22058, 
83596, 83594, 83563, 22038, 22059
20929, 83083, 83073, 21791, 21801, 83084, 83074, 21792, 21802, 83595, 83565, 22058, 83596, 83598, 83568, 22060, 
83599, 83597, 83566, 22040, 22061
20930, 83084, 83074, 21792, 21802, 83085, 83075, 21793, 21803, 83598, 83568, 22060, 83599, 83601, 83571, 22062, 
83602, 83600, 83569, 22042, 22063
20931, 83085, 83075, 21793, 21803, 83086, 83076, 21794, 21804, 83601, 83571, 22062, 83602, 83604, 83574, 22064, 
83605, 83603, 83572, 22044, 22065
20932, 83086, 83076, 21794, 21804, 83087, 83077, 21795, 21805, 83604, 83574, 22064, 83605, 83607, 83577, 22066, 
83608, 83606, 83575, 22046, 22067
20933, 83087, 83077, 21795, 21805, 83088, 83078, 21796, 21806, 83607, 83577, 22066, 83608, 83610, 83580, 22068, 
83611, 83609, 83578, 22048, 22069
20934, 83088, 83078, 21796, 21806, 28921, 28920, 1960, 1961, 83610, 83580, 22068, 83611, 28969, 28966, 1983, 
28968, 83612, 83581, 22049, 22070
20935, 28766, 28765, 1910, 1911, 83089, 83079, 21797, 21807, 28814, 28813, 1933, 28815, 83614, 83584, 22071, 
83615, 83613, 83582, 22051, 22072
20936, 83089, 83079, 21797, 21807, 83090, 83080, 21798, 21808, 83614, 83584, 22071, 83615, 83617, 83587, 22073, 
83618, 83616, 83585, 22053, 22074
20937, 83090, 83080, 21798, 21808, 83091, 83081, 21799, 21809, 83617, 83587, 22073, 83618, 83620, 83590, 22075, 
83621, 83619, 83588, 22055, 22076
20938, 83091, 83081, 21799, 21809, 83092, 83082, 21800, 21810, 83620, 83590, 22075, 83621, 83623, 83593, 22077, 
83624, 83622, 83591, 22057, 22078
20939, 83092, 83082, 21800, 21810, 83093, 83083, 21801, 21811, 83623, 83593, 22077, 83624, 83626, 83596, 22079, 
83627, 83625, 83594, 22059, 22080
20940, 83093, 83083, 21801, 21811, 83094, 83084, 21802, 21812, 83626, 83596, 22079, 83627, 83629, 83599, 22081, 
83630, 83628, 83597, 22061, 22082
20941, 83094, 83084, 21802, 21812, 83095, 83085, 21803, 21813, 83629, 83599, 22081, 83630, 83632, 83602, 22083, 
83633, 83631, 83600, 22063, 22084
20942, 83095, 83085, 21803, 21813, 83096, 83086, 21804, 21814, 83632, 83602, 22083, 83633, 83635, 83605, 22085, 
83636, 83634, 83603, 22065, 22086
20943, 83096, 83086, 21804, 21814, 83097, 83087, 21805, 21815, 83635, 83605, 22085, 83636, 83638, 83608, 22087, 
83639, 83637, 83606, 22067, 22088
20944, 83097, 83087, 21805, 21815, 83098, 83088, 21806, 21816, 83638, 83608, 22087, 83639, 83641, 83611, 22089, 
83642, 83640, 83609, 22069, 22090
20945, 83098, 83088, 21806, 21816, 28922, 28921, 1961, 1962, 83641, 83611, 22089, 83642, 28971, 28968, 1984, 
28970, 83643, 83612, 22070, 22091
20946, 28767, 28766, 1911, 1912, 83099, 83089, 21807, 21817, 28816, 28815, 1934, 28817, 83645, 83615, 22092, 
83646, 83644, 83613, 22072, 22093
20947, 83099, 83089, 21807, 21817, 83100, 83090, 21808, 21818, 83645, 83615, 22092, 83646, 83648, 83618, 22094, 
83649, 83647, 83616, 22074, 22095
20948, 83100, 83090, 21808, 21818, 83101, 83091, 21809, 21819, 83648, 83618, 22094, 83649, 83651, 83621, 22096, 
83652, 83650, 83619, 22076, 22097
20949, 83101, 83091, 21809, 21819, 83102, 83092, 21810, 21820, 83651, 83621, 22096, 83652, 83654, 83624, 22098, 
83655, 83653, 83622, 22078, 22099
20950, 83102, 83092, 21810, 21820, 83103, 83093, 21811, 21821, 83654, 83624, 22098, 83655, 83657, 83627, 22100, 
83658, 83656, 83625, 22080, 22101
20951, 83103, 83093, 21811, 21821, 83104, 83094, 21812, 21822, 83657, 83627, 22100, 83658, 83660, 83630, 22102, 
83661, 83659, 83628, 22082, 22103
20952, 83104, 83094, 21812, 21822, 83105, 83095, 21813, 21823, 83660, 83630, 22102, 83661, 83663, 83633, 22104, 
83664, 83662, 83631, 22084, 22105
20953, 83105, 83095, 21813, 21823, 83106, 83096, 21814, 21824, 83663, 83633, 22104, 83664, 83666, 83636, 22106, 
83667, 83665, 83634, 22086, 22107
20954, 83106, 83096, 21814, 21824, 83107, 83097, 21815, 21825, 83666, 83636, 22106, 83667, 83669, 83639, 22108, 
83670, 83668, 83637, 22088, 22109
20955, 83107, 83097, 21815, 21825, 83108, 83098, 21816, 21826, 83669, 83639, 22108, 83670, 83672, 83642, 22110, 
83673, 83671, 83640, 22090, 22111
20956, 83108, 83098, 21816, 21826, 28923, 28922, 1962, 1963, 83672, 83642, 22110, 83673, 28973, 28970, 1985, 
28972, 83674, 83643, 22091, 22112
20957, 28768, 28767, 1912, 1913, 83109, 83099, 21817, 21827, 28818, 28817, 1935, 28819, 83676, 83646, 22113, 
83677, 83675, 83644, 22093, 22114
20958, 83109, 83099, 21817, 21827, 83110, 83100, 21818, 21828, 83676, 83646, 22113, 83677, 83679, 83649, 22115, 
83680, 83678, 83647, 22095, 22116
20959, 83110, 83100, 21818, 21828, 83111, 83101, 21819, 21829, 83679, 83649, 22115, 83680, 83682, 83652, 22117, 
83683, 83681, 83650, 22097, 22118
20960, 83111, 83101, 21819, 21829, 83112, 83102, 21820, 21830, 83682, 83652, 22117, 83683, 83685, 83655, 22119, 
83686, 83684, 83653, 22099, 22120
20961, 83112, 83102, 21820, 21830, 83113, 83103, 21821, 21831, 83685, 83655, 22119, 83686, 83688, 83658, 22121, 
83689, 83687, 83656, 22101, 22122
20962, 83113, 83103, 21821, 21831, 83114, 83104, 21822, 21832, 83688, 83658, 22121, 83689, 83691, 83661, 22123, 
83692, 83690, 83659, 22103, 22124
20963, 83114, 83104, 21822, 21832, 83115, 83105, 21823, 21833, 83691, 83661, 22123, 83692, 83694, 83664, 22125, 
83695, 83693, 83662, 22105, 22126
20964, 83115, 83105, 21823, 21833, 83116, 83106, 21824, 21834, 83694, 83664, 22125, 83695, 83697, 83667, 22127, 
83698, 83696, 83665, 22107, 22128
20965, 83116, 83106, 21824, 21834, 83117, 83107, 21825, 21835, 83697, 83667, 22127, 83698, 83700, 83670, 22129, 
83701, 83699, 83668, 22109, 22130
20966, 83117, 83107, 21825, 21835, 83118, 83108, 21826, 21836, 83700, 83670, 22129, 83701, 83703, 83673, 22131, 
83704, 83702, 83671, 22111, 22132
20967, 83118, 83108, 21826, 21836, 28924, 28923, 1963, 1964, 83703, 83673, 22131, 83704, 28975, 28972, 1986, 
28974, 83705, 83674, 22112, 22133
20968, 28769, 28768, 1913, 1914, 83119, 83109, 21827, 21837, 28820, 28819, 1936, 28821, 83707, 83677, 22134, 
83708, 83706, 83675, 22114, 22135
20969, 83119, 83109, 21827, 21837, 83120, 83110, 21828, 21838, 83707, 83677, 22134, 83708, 83710, 83680, 22136, 
83711, 83709, 83678, 22116, 22137
20970, 83120, 83110, 21828, 21838, 83121, 83111, 21829, 21839, 83710, 83680, 22136, 83711, 83713, 83683, 22138, 
83714, 83712, 83681, 22118, 22139
20971, 83121, 83111, 21829, 21839, 83122, 83112, 21830, 21840, 83713, 83683, 22138, 83714, 83716, 83686, 22140, 
83717, 83715, 83684, 22120, 22141
20972, 83122, 83112, 21830, 21840, 83123, 83113, 21831, 21841, 83716, 83686, 22140, 83717, 83719, 83689, 22142, 
83720, 83718, 83687, 22122, 22143
20973, 83123, 83113, 21831, 21841, 83124, 83114, 21832, 21842, 83719, 83689, 22142, 83720, 83722, 83692, 22144, 
83723, 83721, 83690, 22124, 22145
20974, 83124, 83114, 21832, 21842, 83125, 83115, 21833, 21843, 83722, 83692, 22144, 83723, 83725, 83695, 22146, 
83726, 83724, 83693, 22126, 22147
20975, 83125, 83115, 21833, 21843, 83126, 83116, 21834, 21844, 83725, 83695, 22146, 83726, 83728, 83698, 22148, 
83729, 83727, 83696, 22128, 22149
20976, 83126, 83116, 21834, 21844, 83127, 83117, 21835, 21845, 83728, 83698, 22148, 83729, 83731, 83701, 22150, 
83732, 83730, 83699, 22130, 22151
20977, 83127, 83117, 21835, 21845, 83128, 83118, 21836, 21846, 83731, 83701, 22150, 83732, 83734, 83704, 22152, 
83735, 83733, 83702, 22132, 22153
20978, 83128, 83118, 21836, 21846, 28925, 28924, 1964, 1965, 83734, 83704, 22152, 83735, 28977, 28974, 1987, 
28976, 83736, 83705, 22133, 22154
20979, 28770, 28769, 1914, 1915, 83129, 83119, 21837, 21847, 28822, 28821, 1937, 28823, 83738, 83708, 22155, 
83739, 83737, 83706, 22135, 22156
20980, 83129, 83119, 21837, 21847, 83130, 83120, 21838, 21848, 83738, 83708, 22155, 83739, 83741, 83711, 22157, 
83742, 83740, 83709, 22137, 22158
20981, 83130, 83120, 21838, 21848, 83131, 83121, 21839, 21849, 83741, 83711, 22157, 83742, 83744, 83714, 22159, 
83745, 83743, 83712, 22139, 22160
20982, 83131, 83121, 21839, 21849, 83132, 83122, 21840, 21850, 83744, 83714, 22159, 83745, 83747, 83717, 22161, 
83748, 83746, 83715, 22141, 22162
20983, 83132, 83122, 21840, 21850, 83133, 83123, 21841, 21851, 83747, 83717, 22161, 83748, 83750, 83720, 22163, 
83751, 83749, 83718, 22143, 22164
20984, 83133, 83123, 21841, 21851, 83134, 83124, 21842, 21852, 83750, 83720, 22163, 83751, 83753, 83723, 22165, 
83754, 83752, 83721, 22145, 22166
20985, 83134, 83124, 21842, 21852, 83135, 83125, 21843, 21853, 83753, 83723, 22165, 83754, 83756, 83726, 22167, 
83757, 83755, 83724, 22147, 22168
20986, 83135, 83125, 21843, 21853, 83136, 83126, 21844, 21854, 83756, 83726, 22167, 83757, 83759, 83729, 22169, 
83760, 83758, 83727, 22149, 22170
20987, 83136, 83126, 21844, 21854, 83137, 83127, 21845, 21855, 83759, 83729, 22169, 83760, 83762, 83732, 22171, 
83763, 83761, 83730, 22151, 22172
20988, 83137, 83127, 21845, 21855, 83138, 83128, 21846, 21856, 83762, 83732, 22171, 83763, 83765, 83735, 22173, 
83766, 83764, 83733, 22153, 22174
20989, 83138, 83128, 21846, 21856, 28926, 28925, 1965, 1966, 83765, 83735, 22173, 83766, 28979, 28976, 1988, 
28978, 83767, 83736, 22154, 22175
20990, 28771, 28770, 1915, 1916, 83139, 83129, 21847, 21857, 28824, 28823, 1938, 28825, 83769, 83739, 22176, 
83770, 83768, 83737, 22156, 22177
20991, 83139, 83129, 21847, 21857, 83140, 83130, 21848, 21858, 83769, 83739, 22176, 83770, 83772, 83742, 22178, 
83773, 83771, 83740, 22158, 22179
20992, 83140, 83130, 21848, 21858, 83141, 83131, 21849, 21859, 83772, 83742, 22178, 83773, 83775, 83745, 22180, 
83776, 83774, 83743, 22160, 22181
20993, 83141, 83131, 21849, 21859, 83142, 83132, 21850, 21860, 83775, 83745, 22180, 83776, 83778, 83748, 22182, 
83779, 83777, 83746, 22162, 22183
20994, 83142, 83132, 21850, 21860, 83143, 83133, 21851, 21861, 83778, 83748, 22182, 83779, 83781, 83751, 22184, 
83782, 83780, 83749, 22164, 22185
20995, 83143, 83133, 21851, 21861, 83144, 83134, 21852, 21862, 83781, 83751, 22184, 83782, 83784, 83754, 22186, 
83785, 83783, 83752, 22166, 22187
20996, 83144, 83134, 21852, 21862, 83145, 83135, 21853, 21863, 83784, 83754, 22186, 83785, 83787, 83757, 22188, 
83788, 83786, 83755, 22168, 22189
20997, 83145, 83135, 21853, 21863, 83146, 83136, 21854, 21864, 83787, 83757, 22188, 83788, 83790, 83760, 22190, 
83791, 83789, 83758, 22170, 22191
20998, 83146, 83136, 21854, 21864, 83147, 83137, 21855, 21865, 83790, 83760, 22190, 83791, 83793, 83763, 22192, 
83794, 83792, 83761, 22172, 22193
20999, 83147, 83137, 21855, 21865, 83148, 83138, 21856, 21866, 83793, 83763, 22192, 83794, 83796, 83766, 22194, 
83797, 83795, 83764, 22174, 22195
21000, 83148, 83138, 21856, 21866, 28927, 28926, 1966, 1967, 83796, 83766, 22194, 83797, 28981, 28978, 1989, 
28980, 83798, 83767, 22175, 22196
21001, 28772, 28771, 1916, 1917, 83149, 83139, 21857, 21867, 28826, 28825, 1939, 28827, 83800, 83770, 22197, 
83801, 83799, 83768, 22177, 22198
21002, 83149, 83139, 21857, 21867, 83150, 83140, 21858, 21868, 83800, 83770, 22197, 83801, 83803, 83773, 22199, 
83804, 83802, 83771, 22179, 22200
21003, 83150, 83140, 21858, 21868, 83151, 83141, 21859, 21869, 83803, 83773, 22199, 83804, 83806, 83776, 22201, 
83807, 83805, 83774, 22181, 22202
21004, 83151, 83141, 21859, 21869, 83152, 83142, 21860, 21870, 83806, 83776, 22201, 83807, 83809, 83779, 22203, 
83810, 83808, 83777, 22183, 22204
21005, 83152, 83142, 21860, 21870, 83153, 83143, 21861, 21871, 83809, 83779, 22203, 83810, 83812, 83782, 22205, 
83813, 83811, 83780, 22185, 22206
21006, 83153, 83143, 21861, 21871, 83154, 83144, 21862, 21872, 83812, 83782, 22205, 83813, 83815, 83785, 22207, 
83816, 83814, 83783, 22187, 22208
21007, 83154, 83144, 21862, 21872, 83155, 83145, 21863, 21873, 83815, 83785, 22207, 83816, 83818, 83788, 22209, 
83819, 83817, 83786, 22189, 22210
21008, 83155, 83145, 21863, 21873, 83156, 83146, 21864, 21874, 83818, 83788, 22209, 83819, 83821, 83791, 22211, 
83822, 83820, 83789, 22191, 22212
21009, 83156, 83146, 21864, 21874, 83157, 83147, 21865, 21875, 83821, 83791, 22211, 83822, 83824, 83794, 22213, 
83825, 83823, 83792, 22193, 22214
21010, 83157, 83147, 21865, 21875, 83158, 83148, 21866, 21876, 83824, 83794, 22213, 83825, 83827, 83797, 22215, 
83828, 83826, 83795, 22195, 22216
21011, 83158, 83148, 21866, 21876, 28928, 28927, 1967, 1968, 83827, 83797, 22215, 83828, 28983, 28980, 1990, 
28982, 83829, 83798, 22196, 22217
21012, 28773, 28772, 1917, 1918, 83159, 83149, 21867, 21877, 28828, 28827, 1940, 28829, 83831, 83801, 22218, 
83832, 83830, 83799, 22198, 22219
21013, 83159, 83149, 21867, 21877, 83160, 83150, 21868, 21878, 83831, 83801, 22218, 83832, 83834, 83804, 22220, 
83835, 83833, 83802, 22200, 22221
21014, 83160, 83150, 21868, 21878, 83161, 83151, 21869, 21879, 83834, 83804, 22220, 83835, 83837, 83807, 22222, 
83838, 83836, 83805, 22202, 22223
21015, 83161, 83151, 21869, 21879, 83162, 83152, 21870, 21880, 83837, 83807, 22222, 83838, 83840, 83810, 22224, 
83841, 83839, 83808, 22204, 22225
21016, 83162, 83152, 21870, 21880, 83163, 83153, 21871, 21881, 83840, 83810, 22224, 83841, 83843, 83813, 22226, 
83844, 83842, 83811, 22206, 22227
21017, 83163, 83153, 21871, 21881, 83164, 83154, 21872, 21882, 83843, 83813, 22226, 83844, 83846, 83816, 22228, 
83847, 83845, 83814, 22208, 22229
21018, 83164, 83154, 21872, 21882, 83165, 83155, 21873, 21883, 83846, 83816, 22228, 83847, 83849, 83819, 22230, 
83850, 83848, 83817, 22210, 22231
21019, 83165, 83155, 21873, 21883, 83166, 83156, 21874, 21884, 83849, 83819, 22230, 83850, 83852, 83822, 22232, 
83853, 83851, 83820, 22212, 22233
21020, 83166, 83156, 21874, 21884, 83167, 83157, 21875, 21885, 83852, 83822, 22232, 83853, 83855, 83825, 22234, 
83856, 83854, 83823, 22214, 22235
21021, 83167, 83157, 21875, 21885, 83168, 83158, 21876, 21886, 83855, 83825, 22234, 83856, 83858, 83828, 22236, 
83859, 83857, 83826, 22216, 22237
21022, 83168, 83158, 21876, 21886, 28929, 28928, 1968, 1969, 83858, 83828, 22236, 83859, 28985, 28982, 1991, 
28984, 83860, 83829, 22217, 22238
21023, 28774, 28773, 1918, 1919, 83169, 83159, 21877, 21887, 28830, 28829, 1941, 28831, 83862, 83832, 22239, 
83863, 83861, 83830, 22219, 22240
21024, 83169, 83159, 21877, 21887, 83170, 83160, 21878, 21888, 83862, 83832, 22239, 83863, 83865, 83835, 22241, 
83866, 83864, 83833, 22221, 22242
21025, 83170, 83160, 21878, 21888, 83171, 83161, 21879, 21889, 83865, 83835, 22241, 83866, 83868, 83838, 22243, 
83869, 83867, 83836, 22223, 22244
21026, 83171, 83161, 21879, 21889, 83172, 83162, 21880, 21890, 83868, 83838, 22243, 83869, 83871, 83841, 22245, 
83872, 83870, 83839, 22225, 22246
21027, 83172, 83162, 21880, 21890, 83173, 83163, 21881, 21891, 83871, 83841, 22245, 83872, 83874, 83844, 22247, 
83875, 83873, 83842, 22227, 22248
21028, 83173, 83163, 21881, 21891, 83174, 83164, 21882, 21892, 83874, 83844, 22247, 83875, 83877, 83847, 22249, 
83878, 83876, 83845, 22229, 22250
21029, 83174, 83164, 21882, 21892, 83175, 83165, 21883, 21893, 83877, 83847, 22249, 83878, 83880, 83850, 22251, 
83881, 83879, 83848, 22231, 22252
21030, 83175, 83165, 21883, 21893, 83176, 83166, 21884, 21894, 83880, 83850, 22251, 83881, 83883, 83853, 22253, 
83884, 83882, 83851, 22233, 22254
21031, 83176, 83166, 21884, 21894, 83177, 83167, 21885, 21895, 83883, 83853, 22253, 83884, 83886, 83856, 22255, 
83887, 83885, 83854, 22235, 22256
21032, 83177, 83167, 21885, 21895, 83178, 83168, 21886, 21896, 83886, 83856, 22255, 83887, 83889, 83859, 22257, 
83890, 83888, 83857, 22237, 22258
21033, 83178, 83168, 21886, 21896, 28930, 28929, 1969, 1970, 83889, 83859, 22257, 83890, 28987, 28984, 1992, 
28986, 83891, 83860, 22238, 22259
21034, 28775, 28774, 1919, 1920, 83179, 83169, 21887, 21897, 28832, 28831, 1942, 28833, 83893, 83863, 22260, 
83894, 83892, 83861, 22240, 22261
21035, 83179, 83169, 21887, 21897, 83180, 83170, 21888, 21898, 83893, 83863, 22260, 83894, 83896, 83866, 22262, 
83897, 83895, 83864, 22242, 22263
21036, 83180, 83170, 21888, 21898, 83181, 83171, 21889, 21899, 83896, 83866, 22262, 83897, 83899, 83869, 22264, 
83900, 83898, 83867, 22244, 22265
21037, 83181, 83171, 21889, 21899, 83182, 83172, 21890, 21900, 83899, 83869, 22264, 83900, 83902, 83872, 22266, 
83903, 83901, 83870, 22246, 22267
21038, 83182, 83172, 21890, 21900, 83183, 83173, 21891, 21901, 83902, 83872, 22266, 83903, 83905, 83875, 22268, 
83906, 83904, 83873, 22248, 22269
21039, 83183, 83173, 21891, 21901, 83184, 83174, 21892, 21902, 83905, 83875, 22268, 83906, 83908, 83878, 22270, 
83909, 83907, 83876, 22250, 22271
21040, 83184, 83174, 21892, 21902, 83185, 83175, 21893, 21903, 83908, 83878, 22270, 83909, 83911, 83881, 22272, 
83912, 83910, 83879, 22252, 22273
21041, 83185, 83175, 21893, 21903, 83186, 83176, 21894, 21904, 83911, 83881, 22272, 83912, 83914, 83884, 22274, 
83915, 83913, 83882, 22254, 22275
21042, 83186, 83176, 21894, 21904, 83187, 83177, 21895, 21905, 83914, 83884, 22274, 83915, 83917, 83887, 22276, 
83918, 83916, 83885, 22256, 22277
21043, 83187, 83177, 21895, 21905, 83188, 83178, 21896, 21906, 83917, 83887, 22276, 83918, 83920, 83890, 22278, 
83921, 83919, 83888, 22258, 22279
21044, 83188, 83178, 21896, 21906, 28931, 28930, 1970, 1971, 83920, 83890, 22278, 83921, 28989, 28986, 1993, 
28988, 83922, 83891, 22259, 22280
21045, 28776, 28775, 1920, 1921, 83189, 83179, 21897, 21907, 28834, 28833, 1943, 28835, 83924, 83894, 22281, 
83925, 83923, 83892, 22261, 22282
21046, 83189, 83179, 21897, 21907, 83190, 83180, 21898, 21908, 83924, 83894, 22281, 83925, 83927, 83897, 22283, 
83928, 83926, 83895, 22263, 22284
21047, 83190, 83180, 21898, 21908, 83191, 83181, 21899, 21909, 83927, 83897, 22283, 83928, 83930, 83900, 22285, 
83931, 83929, 83898, 22265, 22286
21048, 83191, 83181, 21899, 21909, 83192, 83182, 21900, 21910, 83930, 83900, 22285, 83931, 83933, 83903, 22287, 
83934, 83932, 83901, 22267, 22288
21049, 83192, 83182, 21900, 21910, 83193, 83183, 21901, 21911, 83933, 83903, 22287, 83934, 83936, 83906, 22289, 
83937, 83935, 83904, 22269, 22290
21050, 83193, 83183, 21901, 21911, 83194, 83184, 21902, 21912, 83936, 83906, 22289, 83937, 83939, 83909, 22291, 
83940, 83938, 83907, 22271, 22292
21051, 83194, 83184, 21902, 21912, 83195, 83185, 21903, 21913, 83939, 83909, 22291, 83940, 83942, 83912, 22293, 
83943, 83941, 83910, 22273, 22294
21052, 83195, 83185, 21903, 21913, 83196, 83186, 21904, 21914, 83942, 83912, 22293, 83943, 83945, 83915, 22295, 
83946, 83944, 83913, 22275, 22296
21053, 83196, 83186, 21904, 21914, 83197, 83187, 21905, 21915, 83945, 83915, 22295, 83946, 83948, 83918, 22297, 
83949, 83947, 83916, 22277, 22298
21054, 83197, 83187, 21905, 21915, 83198, 83188, 21906, 21916, 83948, 83918, 22297, 83949, 83951, 83921, 22299, 
83952, 83950, 83919, 22279, 22300
21055, 83198, 83188, 21906, 21916, 28932, 28931, 1971, 1972, 83951, 83921, 22299, 83952, 28991, 28988, 1994, 
28990, 83953, 83922, 22280, 22301
21056, 28777, 28776, 1921, 1922, 83199, 83189, 21907, 21917, 28836, 28835, 1944, 28837, 83955, 83925, 22302, 
83956, 83954, 83923, 22282, 22303
21057, 83199, 83189, 21907, 21917, 83200, 83190, 21908, 21918, 83955, 83925, 22302, 83956, 83958, 83928, 22304, 
83959, 83957, 83926, 22284, 22305
21058, 83200, 83190, 21908, 21918, 83201, 83191, 21909, 21919, 83958, 83928, 22304, 83959, 83961, 83931, 22306, 
83962, 83960, 83929, 22286, 22307
21059, 83201, 83191, 21909, 21919, 83202, 83192, 21910, 21920, 83961, 83931, 22306, 83962, 83964, 83934, 22308, 
83965, 83963, 83932, 22288, 22309
21060, 83202, 83192, 21910, 21920, 83203, 83193, 21911, 21921, 83964, 83934, 22308, 83965, 83967, 83937, 22310, 
83968, 83966, 83935, 22290, 22311
21061, 83203, 83193, 21911, 21921, 83204, 83194, 21912, 21922, 83967, 83937, 22310, 83968, 83970, 83940, 22312, 
83971, 83969, 83938, 22292, 22313
21062, 83204, 83194, 21912, 21922, 83205, 83195, 21913, 21923, 83970, 83940, 22312, 83971, 83973, 83943, 22314, 
83974, 83972, 83941, 22294, 22315
21063, 83205, 83195, 21913, 21923, 83206, 83196, 21914, 21924, 83973, 83943, 22314, 83974, 83976, 83946, 22316, 
83977, 83975, 83944, 22296, 22317
21064, 83206, 83196, 21914, 21924, 83207, 83197, 21915, 21925, 83976, 83946, 22316, 83977, 83979, 83949, 22318, 
83980, 83978, 83947, 22298, 22319
21065, 83207, 83197, 21915, 21925, 83208, 83198, 21916, 21926, 83979, 83949, 22318, 83980, 83982, 83952, 22320, 
83983, 83981, 83950, 22300, 22321
21066, 83208, 83198, 21916, 21926, 28933, 28932, 1972, 1973, 83982, 83952, 22320, 83983, 28993, 28990, 1995, 
28992, 83984, 83953, 22301, 22322
21067, 28778, 28777, 1922, 1923, 83209, 83199, 21917, 21927, 28838, 28837, 1945, 28839, 83986, 83956, 22323, 
83987, 83985, 83954, 22303, 22324
21068, 83209, 83199, 21917, 21927, 83210, 83200, 21918, 21928, 83986, 83956, 22323, 83987, 83989, 83959, 22325, 
83990, 83988, 83957, 22305, 22326
21069, 83210, 83200, 21918, 21928, 83211, 83201, 21919, 21929, 83989, 83959, 22325, 83990, 83992, 83962, 22327, 
83993, 83991, 83960, 22307, 22328
21070, 83211, 83201, 21919, 21929, 83212, 83202, 21920, 21930, 83992, 83962, 22327, 83993, 83995, 83965, 22329, 
83996, 83994, 83963, 22309, 22330
21071, 83212, 83202, 21920, 21930, 83213, 83203, 21921, 21931, 83995, 83965, 22329, 83996, 83998, 83968, 22331, 
83999, 83997, 83966, 22311, 22332
21072, 83213, 83203, 21921, 21931, 83214, 83204, 21922, 21932, 83998, 83968, 22331, 83999, 84001, 83971, 22333, 
84002, 84000, 83969, 22313, 22334
21073, 83214, 83204, 21922, 21932, 83215, 83205, 21923, 21933, 84001, 83971, 22333, 84002, 84004, 83974, 22335, 
84005, 84003, 83972, 22315, 22336
21074, 83215, 83205, 21923, 21933, 83216, 83206, 21924, 21934, 84004, 83974, 22335, 84005, 84007, 83977, 22337, 
84008, 84006, 83975, 22317, 22338
21075, 83216, 83206, 21924, 21934, 83217, 83207, 21925, 21935, 84007, 83977, 22337, 84008, 84010, 83980, 22339, 
84011, 84009, 83978, 22319, 22340
21076, 83217, 83207, 21925, 21935, 83218, 83208, 21926, 21936, 84010, 83980, 22339, 84011, 84013, 83983, 22341, 
84014, 84012, 83981, 22321, 22342
21077, 83218, 83208, 21926, 21936, 28934, 28933, 1973, 1974, 84013, 83983, 22341, 84014, 28995, 28992, 1996, 
28994, 84015, 83984, 22322, 22343
21078, 28779, 28778, 1923, 1924, 83219, 83209, 21927, 21937, 28840, 28839, 1946, 28841, 84017, 83987, 22344, 
84018, 84016, 83985, 22324, 22345
21079, 83219, 83209, 21927, 21937, 83220, 83210, 21928, 21938, 84017, 83987, 22344, 84018, 84020, 83990, 22346, 
84021, 84019, 83988, 22326, 22347
21080, 83220, 83210, 21928, 21938, 83221, 83211, 21929, 21939, 84020, 83990, 22346, 84021, 84023, 83993, 22348, 
84024, 84022, 83991, 22328, 22349
21081, 83221, 83211, 21929, 21939, 83222, 83212, 21930, 21940, 84023, 83993, 22348, 84024, 84026, 83996, 22350, 
84027, 84025, 83994, 22330, 22351
21082, 83222, 83212, 21930, 21940, 83223, 83213, 21931, 21941, 84026, 83996, 22350, 84027, 84029, 83999, 22352, 
84030, 84028, 83997, 22332, 22353
21083, 83223, 83213, 21931, 21941, 83224, 83214, 21932, 21942, 84029, 83999, 22352, 84030, 84032, 84002, 22354, 
84033, 84031, 84000, 22334, 22355
21084, 83224, 83214, 21932, 21942, 83225, 83215, 21933, 21943, 84032, 84002, 22354, 84033, 84035, 84005, 22356, 
84036, 84034, 84003, 22336, 22357
21085, 83225, 83215, 21933, 21943, 83226, 83216, 21934, 21944, 84035, 84005, 22356, 84036, 84038, 84008, 22358, 
84039, 84037, 84006, 22338, 22359
21086, 83226, 83216, 21934, 21944, 83227, 83217, 21935, 21945, 84038, 84008, 22358, 84039, 84041, 84011, 22360, 
84042, 84040, 84009, 22340, 22361
21087, 83227, 83217, 21935, 21945, 83228, 83218, 21936, 21946, 84041, 84011, 22360, 84042, 84044, 84014, 22362, 
84045, 84043, 84012, 22342, 22363
21088, 83228, 83218, 21936, 21946, 28935, 28934, 1974, 1975, 84044, 84014, 22362, 84045, 28997, 28994, 1997, 
28996, 84046, 84015, 22343, 22364
21089, 28780, 28779, 1924, 1925, 83229, 83219, 21937, 21947, 28842, 28841, 1947, 28843, 84048, 84018, 22365, 
84049, 84047, 84016, 22345, 22366
21090, 83229, 83219, 21937, 21947, 83230, 83220, 21938, 21948, 84048, 84018, 22365, 84049, 84051, 84021, 22367, 
84052, 84050, 84019, 22347, 22368
21091, 83230, 83220, 21938, 21948, 83231, 83221, 21939, 21949, 84051, 84021, 22367, 84052, 84054, 84024, 22369, 
84055, 84053, 84022, 22349, 22370
21092, 83231, 83221, 21939, 21949, 83232, 83222, 21940, 21950, 84054, 84024, 22369, 84055, 84057, 84027, 22371, 
84058, 84056, 84025, 22351, 22372
21093, 83232, 83222, 21940, 21950, 83233, 83223, 21941, 21951, 84057, 84027, 22371, 84058, 84060, 84030, 22373, 
84061, 84059, 84028, 22353, 22374
21094, 83233, 83223, 21941, 21951, 83234, 83224, 21942, 21952, 84060, 84030, 22373, 84061, 84063, 84033, 22375, 
84064, 84062, 84031, 22355, 22376
21095, 83234, 83224, 21942, 21952, 83235, 83225, 21943, 21953, 84063, 84033, 22375, 84064, 84066, 84036, 22377, 
84067, 84065, 84034, 22357, 22378
21096, 83235, 83225, 21943, 21953, 83236, 83226, 21944, 21954, 84066, 84036, 22377, 84067, 84069, 84039, 22379, 
84070, 84068, 84037, 22359, 22380
21097, 83236, 83226, 21944, 21954, 83237, 83227, 21945, 21955, 84069, 84039, 22379, 84070, 84072, 84042, 22381, 
84073, 84071, 84040, 22361, 22382
21098, 83237, 83227, 21945, 21955, 83238, 83228, 21946, 21956, 84072, 84042, 22381, 84073, 84075, 84045, 22383, 
84076, 84074, 84043, 22363, 22384
21099, 83238, 83228, 21946, 21956, 28936, 28935, 1975, 1976, 84075, 84045, 22383, 84076, 28999, 28996, 1998, 
28998, 84077, 84046, 22364, 22385
21100, 28781, 28780, 1925, 1926, 83239, 83229, 21947, 21957, 28844, 28843, 1948, 28845, 84079, 84049, 22386, 
84080, 84078, 84047, 22366, 22387
21101, 83239, 83229, 21947, 21957, 83240, 83230, 21948, 21958, 84079, 84049, 22386, 84080, 84082, 84052, 22388, 
84083, 84081, 84050, 22368, 22389
21102, 83240, 83230, 21948, 21958, 83241, 83231, 21949, 21959, 84082, 84052, 22388, 84083, 84085, 84055, 22390, 
84086, 84084, 84053, 22370, 22391
21103, 83241, 83231, 21949, 21959, 83242, 83232, 21950, 21960, 84085, 84055, 22390, 84086, 84088, 84058, 22392, 
84089, 84087, 84056, 22372, 22393
21104, 83242, 83232, 21950, 21960, 83243, 83233, 21951, 21961, 84088, 84058, 22392, 84089, 84091, 84061, 22394, 
84092, 84090, 84059, 22374, 22395
21105, 83243, 83233, 21951, 21961, 83244, 83234, 21952, 21962, 84091, 84061, 22394, 84092, 84094, 84064, 22396, 
84095, 84093, 84062, 22376, 22397
21106, 83244, 83234, 21952, 21962, 83245, 83235, 21953, 21963, 84094, 84064, 22396, 84095, 84097, 84067, 22398, 
84098, 84096, 84065, 22378, 22399
21107, 83245, 83235, 21953, 21963, 83246, 83236, 21954, 21964, 84097, 84067, 22398, 84098, 84100, 84070, 22400, 
84101, 84099, 84068, 22380, 22401
21108, 83246, 83236, 21954, 21964, 83247, 83237, 21955, 21965, 84100, 84070, 22400, 84101, 84103, 84073, 22402, 
84104, 84102, 84071, 22382, 22403
21109, 83247, 83237, 21955, 21965, 83248, 83238, 21956, 21966, 84103, 84073, 22402, 84104, 84106, 84076, 22404, 
84107, 84105, 84074, 22384, 22405
21110, 83248, 83238, 21956, 21966, 28937, 28936, 1976, 1977, 84106, 84076, 22404, 84107, 29001, 28998, 1999, 
29000, 84108, 84077, 22385, 22406
21111, 28782, 28781, 1926, 1927, 83249, 83239, 21957, 21967, 28846, 28845, 1949, 28847, 84110, 84080, 22407, 
84111, 84109, 84078, 22387, 22408
21112, 83249, 83239, 21957, 21967, 83250, 83240, 21958, 21968, 84110, 84080, 22407, 84111, 84113, 84083, 22409, 
84114, 84112, 84081, 22389, 22410
21113, 83250, 83240, 21958, 21968, 83251, 83241, 21959, 21969, 84113, 84083, 22409, 84114, 84116, 84086, 22411, 
84117, 84115, 84084, 22391, 22412
21114, 83251, 83241, 21959, 21969, 83252, 83242, 21960, 21970, 84116, 84086, 22411, 84117, 84119, 84089, 22413, 
84120, 84118, 84087, 22393, 22414
21115, 83252, 83242, 21960, 21970, 83253, 83243, 21961, 21971, 84119, 84089, 22413, 84120, 84122, 84092, 22415, 
84123, 84121, 84090, 22395, 22416
21116, 83253, 83243, 21961, 21971, 83254, 83244, 21962, 21972, 84122, 84092, 22415, 84123, 84125, 84095, 22417, 
84126, 84124, 84093, 22397, 22418
21117, 83254, 83244, 21962, 21972, 83255, 83245, 21963, 21973, 84125, 84095, 22417, 84126, 84128, 84098, 22419, 
84129, 84127, 84096, 22399, 22420
21118, 83255, 83245, 21963, 21973, 83256, 83246, 21964, 21974, 84128, 84098, 22419, 84129, 84131, 84101, 22421, 
84132, 84130, 84099, 22401, 22422
21119, 83256, 83246, 21964, 21974, 83257, 83247, 21965, 21975, 84131, 84101, 22421, 84132, 84134, 84104, 22423, 
84135, 84133, 84102, 22403, 22424
21120, 83257, 83247, 21965, 21975, 83258, 83248, 21966, 21976, 84134, 84104, 22423, 84135, 84137, 84107, 22425, 
84138, 84136, 84105, 22405, 22426
21121, 83258, 83248, 21966, 21976, 28938, 28937, 1977, 1978, 84137, 84107, 22425, 84138, 29003, 29000, 2000, 
29002, 84139, 84108, 22406, 22427
21122, 28783, 28782, 1927, 1928, 83259, 83249, 21967, 21977, 28848, 28847, 1950, 28849, 84141, 84111, 22428, 
84142, 84140, 84109, 22408, 22429
21123, 83259, 83249, 21967, 21977, 83260, 83250, 21968, 21978, 84141, 84111, 22428, 84142, 84144, 84114, 22430, 
84145, 84143, 84112, 22410, 22431
21124, 83260, 83250, 21968, 21978, 83261, 83251, 21969, 21979, 84144, 84114, 22430, 84145, 84147, 84117, 22432, 
84148, 84146, 84115, 22412, 22433
21125, 83261, 83251, 21969, 21979, 83262, 83252, 21970, 21980, 84147, 84117, 22432, 84148, 84150, 84120, 22434, 
84151, 84149, 84118, 22414, 22435
21126, 83262, 83252, 21970, 21980, 83263, 83253, 21971, 21981, 84150, 84120, 22434, 84151, 84153, 84123, 22436, 
84154, 84152, 84121, 22416, 22437
21127, 83263, 83253, 21971, 21981, 83264, 83254, 21972, 21982, 84153, 84123, 22436, 84154, 84156, 84126, 22438, 
84157, 84155, 84124, 22418, 22439
21128, 83264, 83254, 21972, 21982, 83265, 83255, 21973, 21983, 84156, 84126, 22438, 84157, 84159, 84129, 22440, 
84160, 84158, 84127, 22420, 22441
21129, 83265, 83255, 21973, 21983, 83266, 83256, 21974, 21984, 84159, 84129, 22440, 84160, 84162, 84132, 22442, 
84163, 84161, 84130, 22422, 22443
21130, 83266, 83256, 21974, 21984, 83267, 83257, 21975, 21985, 84162, 84132, 22442, 84163, 84165, 84135, 22444, 
84166, 84164, 84133, 22424, 22445
21131, 83267, 83257, 21975, 21985, 83268, 83258, 21976, 21986, 84165, 84135, 22444, 84166, 84168, 84138, 22446, 
84169, 84167, 84136, 22426, 22447
21132, 83268, 83258, 21976, 21986, 28939, 28938, 1978, 1979, 84168, 84138, 22446, 84169, 29005, 29002, 2001, 
29004, 84170, 84139, 22427, 22448
21133, 2045, 28783, 1928, 42, 22459, 83259, 21977, 2033, 28850, 28849, 1951, 2047, 84171, 84142, 22449, 
22480, 22479, 84140, 22429, 2044
21134, 22459, 83259, 21977, 2033, 22460, 83260, 21978, 2032, 84171, 84142, 22449, 22480, 84172, 84145, 22450, 
22482, 22481, 84143, 22431, 2043
21135, 22460, 83260, 21978, 2032, 22461, 83261, 21979, 2031, 84172, 84145, 22450, 22482, 84173, 84148, 22451, 
22484, 22483, 84146, 22433, 2042
21136, 22461, 83261, 21979, 2031, 22462, 83262, 21980, 2030, 84173, 84148, 22451, 22484, 84174, 84151, 22452, 
22486, 22485, 84149, 22435, 2041
21137, 22462, 83262, 21980, 2030, 22463, 83263, 21981, 2029, 84174, 84151, 22452, 22486, 84175, 84154, 22453, 
22488, 22487, 84152, 22437, 2040
21138, 22463, 83263, 21981, 2029, 22464, 83264, 21982, 2028, 84175, 84154, 22453, 22488, 84176, 84157, 22454, 
22490, 22489, 84155, 22439, 2039
21139, 22464, 83264, 21982, 2028, 22465, 83265, 21983, 2027, 84176, 84157, 22454, 22490, 84177, 84160, 22455, 
22492, 22491, 84158, 22441, 2038
21140, 22465, 83265, 21983, 2027, 22466, 83266, 21984, 2026, 84177, 84160, 22455, 22492, 84178, 84163, 22456, 
22494, 22493, 84161, 22443, 2037
21141, 22466, 83266, 21984, 2026, 22467, 83267, 21985, 2025, 84178, 84163, 22456, 22494, 84179, 84166, 22457, 
22496, 22495, 84164, 22445, 2036
21142, 22467, 83267, 21985, 2025, 22468, 83268, 21986, 2024, 84179, 84166, 22457, 22496, 84180, 84169, 22458, 
22498, 22497, 84167, 22447, 2035
21143, 22468, 83268, 21986, 2024, 2050, 28939, 1979, 44, 84180, 84169, 22458, 22498, 29006, 29004, 2002, 
2052, 22499, 84170, 22448, 2034
21144, 28784, 3078, 3077, 28762, 83269, 29084, 29074, 83049, 28851, 3080, 28806, 28852, 84182, 29115, 83490, 
84183, 84181, 29116, 29095, 83489
21145, 83269, 29084, 29074, 83049, 83270, 29085, 29075, 83050, 84182, 29115, 83490, 84183, 84185, 29117, 83493, 
84186, 84184, 29118, 29097, 83492
21146, 83270, 29085, 29075, 83050, 83271, 29086, 29076, 83051, 84185, 29117, 83493, 84186, 84188, 29119, 83496, 
84189, 84187, 29120, 29099, 83495
21147, 83271, 29086, 29076, 83051, 83272, 29087, 29077, 83052, 84188, 29119, 83496, 84189, 84191, 29121, 83499, 
84192, 84190, 29122, 29101, 83498
21148, 83272, 29087, 29077, 83052, 83273, 29088, 29078, 83053, 84191, 29121, 83499, 84192, 84194, 29123, 83502, 
84195, 84193, 29124, 29103, 83501
21149, 83273, 29088, 29078, 83053, 83274, 29089, 29079, 83054, 84194, 29123, 83502, 84195, 84197, 29125, 83505, 
84198, 84196, 29126, 29105, 83504
21150, 83274, 29089, 29079, 83054, 83275, 29090, 29080, 83055, 84197, 29125, 83505, 84198, 84200, 29127, 83508, 
84201, 84199, 29128, 29107, 83507
21151, 83275, 29090, 29080, 83055, 83276, 29091, 29081, 83056, 84200, 29127, 83508, 84201, 84203, 29129, 83511, 
84204, 84202, 29130, 29109, 83510
21152, 83276, 29091, 29081, 83056, 83277, 29092, 29082, 83057, 84203, 29129, 83511, 84204, 84206, 29131, 83514, 
84207, 84205, 29132, 29111, 83513
21153, 83277, 29092, 29082, 83057, 83278, 29093, 29083, 83058, 84206, 29131, 83514, 84207, 84209, 29133, 83517, 
84210, 84208, 29134, 29113, 83516
21154, 83278, 29093, 29083, 83058, 28940, 3128, 3127, 28918, 84209, 29133, 83517, 84210, 29008, 3130, 28963, 
29007, 84211, 29135, 29114, 83519
21155, 28785, 28784, 28762, 28763, 83279, 83269, 83049, 83059, 28853, 28852, 28808, 28854, 84213, 84183, 83521, 
84214, 84212, 84181, 83489, 83520
21156, 83279, 83269, 83049, 83059, 83280, 83270, 83050, 83060, 84213, 84183, 83521, 84214, 84216, 84186, 83524, 
84217, 84215, 84184, 83492, 83523
21157, 83280, 83270, 83050, 83060, 83281, 83271, 83051, 83061, 84216, 84186, 83524, 84217, 84219, 84189, 83527, 
84220, 84218, 84187, 83495, 83526
21158, 83281, 83271, 83051, 83061, 83282, 83272, 83052, 83062, 84219, 84189, 83527, 84220, 84222, 84192, 83530, 
84223, 84221, 84190, 83498, 83529
21159, 83282, 83272, 83052, 83062, 83283, 83273, 83053, 83063, 84222, 84192, 83530, 84223, 84225, 84195, 83533, 
84226, 84224, 84193, 83501, 83532
21160, 83283, 83273, 83053, 83063, 83284, 83274, 83054, 83064, 84225, 84195, 83533, 84226, 84228, 84198, 83536, 
84229, 84227, 84196, 83504, 83535
21161, 83284, 83274, 83054, 83064, 83285, 83275, 83055, 83065, 84228, 84198, 83536, 84229, 84231, 84201, 83539, 
84232, 84230, 84199, 83507, 83538
21162, 83285, 83275, 83055, 83065, 83286, 83276, 83056, 83066, 84231, 84201, 83539, 84232, 84234, 84204, 83542, 
84235, 84233, 84202, 83510, 83541
21163, 83286, 83276, 83056, 83066, 83287, 83277, 83057, 83067, 84234, 84204, 83542, 84235, 84237, 84207, 83545, 
84238, 84236, 84205, 83513, 83544
21164, 83287, 83277, 83057, 83067, 83288, 83278, 83058, 83068, 84237, 84207, 83545, 84238, 84240, 84210, 83548, 
84241, 84239, 84208, 83516, 83547
21165, 83288, 83278, 83058, 83068, 28941, 28940, 28918, 28919, 84240, 84210, 83548, 84241, 29010, 29007, 28965, 
29009, 84242, 84211, 83519, 83550
21166, 28786, 28785, 28763, 28764, 83289, 83279, 83059, 83069, 28855, 28854, 28810, 28856, 84244, 84214, 83552, 
84245, 84243, 84212, 83520, 83551
21167, 83289, 83279, 83059, 83069, 83290, 83280, 83060, 83070, 84244, 84214, 83552, 84245, 84247, 84217, 83555, 
84248, 84246, 84215, 83523, 83554
21168, 83290, 83280, 83060, 83070, 83291, 83281, 83061, 83071, 84247, 84217, 83555, 84248, 84250, 84220, 83558, 
84251, 84249, 84218, 83526, 83557
21169, 83291, 83281, 83061, 83071, 83292, 83282, 83062, 83072, 84250, 84220, 83558, 84251, 84253, 84223, 83561, 
84254, 84252, 84221, 83529, 83560
21170, 83292, 83282, 83062, 83072, 83293, 83283, 83063, 83073, 84253, 84223, 83561, 84254, 84256, 84226, 83564, 
84257, 84255, 84224, 83532, 83563
21171, 83293, 83283, 83063, 83073, 83294, 83284, 83064, 83074, 84256, 84226, 83564, 84257, 84259, 84229, 83567, 
84260, 84258, 84227, 83535, 83566
21172, 83294, 83284, 83064, 83074, 83295, 83285, 83065, 83075, 84259, 84229, 83567, 84260, 84262, 84232, 83570, 
84263, 84261, 84230, 83538, 83569
21173, 83295, 83285, 83065, 83075, 83296, 83286, 83066, 83076, 84262, 84232, 83570, 84263, 84265, 84235, 83573, 
84266, 84264, 84233, 83541, 83572
21174, 83296, 83286, 83066, 83076, 83297, 83287, 83067, 83077, 84265, 84235, 83573, 84266, 84268, 84238, 83576, 
84269, 84267, 84236, 83544, 83575
21175, 83297, 83287, 83067, 83077, 83298, 83288, 83068, 83078, 84268, 84238, 83576, 84269, 84271, 84241, 83579, 
84272, 84270, 84239, 83547, 83578
21176, 83298, 83288, 83068, 83078, 28942, 28941, 28919, 28920, 84271, 84241, 83579, 84272, 29012, 29009, 28967, 
29011, 84273, 84242, 83550, 83581
21177, 28787, 28786, 28764, 28765, 83299, 83289, 83069, 83079, 28857, 28856, 28812, 28858, 84275, 84245, 83583, 
84276, 84274, 84243, 83551, 83582
21178, 83299, 83289, 83069, 83079, 83300, 83290, 83070, 83080, 84275, 84245, 83583, 84276, 84278, 84248, 83586, 
84279, 84277, 84246, 83554, 83585
21179, 83300, 83290, 83070, 83080, 83301, 83291, 83071, 83081, 84278, 84248, 83586, 84279, 84281, 84251, 83589, 
84282, 84280, 84249, 83557, 83588
21180, 83301, 83291, 83071, 83081, 83302, 83292, 83072, 83082, 84281, 84251, 83589, 84282, 84284, 84254, 83592, 
84285, 84283, 84252, 83560, 83591
21181, 83302, 83292, 83072, 83082, 83303, 83293, 83073, 83083, 84284, 84254, 83592, 84285, 84287, 84257, 83595, 
84288, 84286, 84255, 83563, 83594
21182, 83303, 83293, 83073, 83083, 83304, 83294, 83074, 83084, 84287, 84257, 83595, 84288, 84290, 84260, 83598, 
84291, 84289, 84258, 83566, 83597
21183, 83304, 83294, 83074, 83084, 83305, 83295, 83075, 83085, 84290, 84260, 83598, 84291, 84293, 84263, 83601, 
84294, 84292, 84261, 83569, 83600
21184, 83305, 83295, 83075, 83085, 83306, 83296, 83076, 83086, 84293, 84263, 83601, 84294, 84296, 84266, 83604, 
84297, 84295, 84264, 83572, 83603
21185, 83306, 83296, 83076, 83086, 83307, 83297, 83077, 83087, 84296, 84266, 83604, 84297, 84299, 84269, 83607, 
84300, 84298, 84267, 83575, 83606
21186, 83307, 83297, 83077, 83087, 83308, 83298, 83078, 83088, 84299, 84269, 83607, 84300, 84302, 84272, 83610, 
84303, 84301, 84270, 83578, 83609
21187, 83308, 83298, 83078, 83088, 28943, 28942, 28920, 28921, 84302, 84272, 83610, 84303, 29014, 29011, 28969, 
29013, 84304, 84273, 83581, 83612
21188, 28788, 28787, 28765, 28766, 83309, 83299, 83079, 83089, 28859, 28858, 28814, 28860, 84306, 84276, 83614, 
84307, 84305, 84274, 83582, 83613
21189, 83309, 83299, 83079, 83089, 83310, 83300, 83080, 83090, 84306, 84276, 83614, 84307, 84309, 84279, 83617, 
84310, 84308, 84277, 83585, 83616
21190, 83310, 83300, 83080, 83090, 83311, 83301, 83081, 83091, 84309, 84279, 83617, 84310, 84312, 84282, 83620, 
84313, 84311, 84280, 83588, 83619
21191, 83311, 83301, 83081, 83091, 83312, 83302, 83082, 83092, 84312, 84282, 83620, 84313, 84315, 84285, 83623, 
84316, 84314, 84283, 83591, 83622
21192, 83312, 83302, 83082, 83092, 83313, 83303, 83083, 83093, 84315, 84285, 83623, 84316, 84318, 84288, 83626, 
84319, 84317, 84286, 83594, 83625
21193, 83313, 83303, 83083, 83093, 83314, 83304, 83084, 83094, 84318, 84288, 83626, 84319, 84321, 84291, 83629, 
84322, 84320, 84289, 83597, 83628
21194, 83314, 83304, 83084, 83094, 83315, 83305, 83085, 83095, 84321, 84291, 83629, 84322, 84324, 84294, 83632, 
84325, 84323, 84292, 83600, 83631
21195, 83315, 83305, 83085, 83095, 83316, 83306, 83086, 83096, 84324, 84294, 83632, 84325, 84327, 84297, 83635, 
84328, 84326, 84295, 83603, 83634
21196, 83316, 83306, 83086, 83096, 83317, 83307, 83087, 83097, 84327, 84297, 83635, 84328, 84330, 84300, 83638, 
84331, 84329, 84298, 83606, 83637
21197, 83317, 83307, 83087, 83097, 83318, 83308, 83088, 83098, 84330, 84300, 83638, 84331, 84333, 84303, 83641, 
84334, 84332, 84301, 83609, 83640
21198, 83318, 83308, 83088, 83098, 28944, 28943, 28921, 28922, 84333, 84303, 83641, 84334, 29016, 29013, 28971, 
29015, 84335, 84304, 83612, 83643
21199, 28789, 28788, 28766, 28767, 83319, 83309, 83089, 83099, 28861, 28860, 28816, 28862, 84337, 84307, 83645, 
84338, 84336, 84305, 83613, 83644
21200, 83319, 83309, 83089, 83099, 83320, 83310, 83090, 83100, 84337, 84307, 83645, 84338, 84340, 84310, 83648, 
84341, 84339, 84308, 83616, 83647
21201, 83320, 83310, 83090, 83100, 83321, 83311, 83091, 83101, 84340, 84310, 83648, 84341, 84343, 84313, 83651, 
84344, 84342, 84311, 83619, 83650
21202, 83321, 83311, 83091, 83101, 83322, 83312, 83092, 83102, 84343, 84313, 83651, 84344, 84346, 84316, 83654, 
84347, 84345, 84314, 83622, 83653
21203, 83322, 83312, 83092, 83102, 83323, 83313, 83093, 83103, 84346, 84316, 83654, 84347, 84349, 84319, 83657, 
84350, 84348, 84317, 83625, 83656
21204, 83323, 83313, 83093, 83103, 83324, 83314, 83094, 83104, 84349, 84319, 83657, 84350, 84352, 84322, 83660, 
84353, 84351, 84320, 83628, 83659
21205, 83324, 83314, 83094, 83104, 83325, 83315, 83095, 83105, 84352, 84322, 83660, 84353, 84355, 84325, 83663, 
84356, 84354, 84323, 83631, 83662
21206, 83325, 83315, 83095, 83105, 83326, 83316, 83096, 83106, 84355, 84325, 83663, 84356, 84358, 84328, 83666, 
84359, 84357, 84326, 83634, 83665
21207, 83326, 83316, 83096, 83106, 83327, 83317, 83097, 83107, 84358, 84328, 83666, 84359, 84361, 84331, 83669, 
84362, 84360, 84329, 83637, 83668
21208, 83327, 83317, 83097, 83107, 83328, 83318, 83098, 83108, 84361, 84331, 83669, 84362, 84364, 84334, 83672, 
84365, 84363, 84332, 83640, 83671
21209, 83328, 83318, 83098, 83108, 28945, 28944, 28922, 28923, 84364, 84334, 83672, 84365, 29018, 29015, 28973, 
29017, 84366, 84335, 83643, 83674
21210, 28790, 28789, 28767, 28768, 83329, 83319, 83099, 83109, 28863, 28862, 28818, 28864, 84368, 84338, 83676, 
84369, 84367, 84336, 83644, 83675
21211, 83329, 83319, 83099, 83109, 83330, 83320, 83100, 83110, 84368, 84338, 83676, 84369, 84371, 84341, 83679, 
84372, 84370, 84339, 83647, 83678
21212, 83330, 83320, 83100, 83110, 83331, 83321, 83101, 83111, 84371, 84341, 83679, 84372, 84374, 84344, 83682, 
84375, 84373, 84342, 83650, 83681
21213, 83331, 83321, 83101, 83111, 83332, 83322, 83102, 83112, 84374, 84344, 83682, 84375, 84377, 84347, 83685, 
84378, 84376, 84345, 83653, 83684
21214, 83332, 83322, 83102, 83112, 83333, 83323, 83103, 83113, 84377, 84347, 83685, 84378, 84380, 84350, 83688, 
84381, 84379, 84348, 83656, 83687
21215, 83333, 83323, 83103, 83113, 83334, 83324, 83104, 83114, 84380, 84350, 83688, 84381, 84383, 84353, 83691, 
84384, 84382, 84351, 83659, 83690
21216, 83334, 83324, 83104, 83114, 83335, 83325, 83105, 83115, 84383, 84353, 83691, 84384, 84386, 84356, 83694, 
84387, 84385, 84354, 83662, 83693
21217, 83335, 83325, 83105, 83115, 83336, 83326, 83106, 83116, 84386, 84356, 83694, 84387, 84389, 84359, 83697, 
84390, 84388, 84357, 83665, 83696
21218, 83336, 83326, 83106, 83116, 83337, 83327, 83107, 83117, 84389, 84359, 83697, 84390, 84392, 84362, 83700, 
84393, 84391, 84360, 83668, 83699
21219, 83337, 83327, 83107, 83117, 83338, 83328, 83108, 83118, 84392, 84362, 83700, 84393, 84395, 84365, 83703, 
84396, 84394, 84363, 83671, 83702
21220, 83338, 83328, 83108, 83118, 28946, 28945, 28923, 28924, 84395, 84365, 83703, 84396, 29020, 29017, 28975, 
29019, 84397, 84366, 83674, 83705
21221, 28791, 28790, 28768, 28769, 83339, 83329, 83109, 83119, 28865, 28864, 28820, 28866, 84399, 84369, 83707, 
84400, 84398, 84367, 83675, 83706
21222, 83339, 83329, 83109, 83119, 83340, 83330, 83110, 83120, 84399, 84369, 83707, 84400, 84402, 84372, 83710, 
84403, 84401, 84370, 83678, 83709
21223, 83340, 83330, 83110, 83120, 83341, 83331, 83111, 83121, 84402, 84372, 83710, 84403, 84405, 84375, 83713, 
84406, 84404, 84373, 83681, 83712
21224, 83341, 83331, 83111, 83121, 83342, 83332, 83112, 83122, 84405, 84375, 83713, 84406, 84408, 84378, 83716, 
84409, 84407, 84376, 83684, 83715
21225, 83342, 83332, 83112, 83122, 83343, 83333, 83113, 83123, 84408, 84378, 83716, 84409, 84411, 84381, 83719, 
84412, 84410, 84379, 83687, 83718
21226, 83343, 83333, 83113, 83123, 83344, 83334, 83114, 83124, 84411, 84381, 83719, 84412, 84414, 84384, 83722, 
84415, 84413, 84382, 83690, 83721
21227, 83344, 83334, 83114, 83124, 83345, 83335, 83115, 83125, 84414, 84384, 83722, 84415, 84417, 84387, 83725, 
84418, 84416, 84385, 83693, 83724
21228, 83345, 83335, 83115, 83125, 83346, 83336, 83116, 83126, 84417, 84387, 83725, 84418, 84420, 84390, 83728, 
84421, 84419, 84388, 83696, 83727
21229, 83346, 83336, 83116, 83126, 83347, 83337, 83117, 83127, 84420, 84390, 83728, 84421, 84423, 84393, 83731, 
84424, 84422, 84391, 83699, 83730
21230, 83347, 83337, 83117, 83127, 83348, 83338, 83118, 83128, 84423, 84393, 83731, 84424, 84426, 84396, 83734, 
84427, 84425, 84394, 83702, 83733
21231, 83348, 83338, 83118, 83128, 28947, 28946, 28924, 28925, 84426, 84396, 83734, 84427, 29022, 29019, 28977, 
29021, 84428, 84397, 83705, 83736
21232, 28792, 28791, 28769, 28770, 83349, 83339, 83119, 83129, 28867, 28866, 28822, 28868, 84430, 84400, 83738, 
84431, 84429, 84398, 83706, 83737
21233, 83349, 83339, 83119, 83129, 83350, 83340, 83120, 83130, 84430, 84400, 83738, 84431, 84433, 84403, 83741, 
84434, 84432, 84401, 83709, 83740
21234, 83350, 83340, 83120, 83130, 83351, 83341, 83121, 83131, 84433, 84403, 83741, 84434, 84436, 84406, 83744, 
84437, 84435, 84404, 83712, 83743
21235, 83351, 83341, 83121, 83131, 83352, 83342, 83122, 83132, 84436, 84406, 83744, 84437, 84439, 84409, 83747, 
84440, 84438, 84407, 83715, 83746
21236, 83352, 83342, 83122, 83132, 83353, 83343, 83123, 83133, 84439, 84409, 83747, 84440, 84442, 84412, 83750, 
84443, 84441, 84410, 83718, 83749
21237, 83353, 83343, 83123, 83133, 83354, 83344, 83124, 83134, 84442, 84412, 83750, 84443, 84445, 84415, 83753, 
84446, 84444, 84413, 83721, 83752
21238, 83354, 83344, 83124, 83134, 83355, 83345, 83125, 83135, 84445, 84415, 83753, 84446, 84448, 84418, 83756, 
84449, 84447, 84416, 83724, 83755
21239, 83355, 83345, 83125, 83135, 83356, 83346, 83126, 83136, 84448, 84418, 83756, 84449, 84451, 84421, 83759, 
84452, 84450, 84419, 83727, 83758
21240, 83356, 83346, 83126, 83136, 83357, 83347, 83127, 83137, 84451, 84421, 83759, 84452, 84454, 84424, 83762, 
84455, 84453, 84422, 83730, 83761
21241, 83357, 83347, 83127, 83137, 83358, 83348, 83128, 83138, 84454, 84424, 83762, 84455, 84457, 84427, 83765, 
84458, 84456, 84425, 83733, 83764
21242, 83358, 83348, 83128, 83138, 28948, 28947, 28925, 28926, 84457, 84427, 83765, 84458, 29024, 29021, 28979, 
29023, 84459, 84428, 83736, 83767
21243, 28793, 28792, 28770, 28771, 83359, 83349, 83129, 83139, 28869, 28868, 28824, 28870, 84461, 84431, 83769, 
84462, 84460, 84429, 83737, 83768
21244, 83359, 83349, 83129, 83139, 83360, 83350, 83130, 83140, 84461, 84431, 83769, 84462, 84464, 84434, 83772, 
84465, 84463, 84432, 83740, 83771
21245, 83360, 83350, 83130, 83140, 83361, 83351, 83131, 83141, 84464, 84434, 83772, 84465, 84467, 84437, 83775, 
84468, 84466, 84435, 83743, 83774
21246, 83361, 83351, 83131, 83141, 83362, 83352, 83132, 83142, 84467, 84437, 83775, 84468, 84470, 84440, 83778, 
84471, 84469, 84438, 83746, 83777
21247, 83362, 83352, 83132, 83142, 83363, 83353, 83133, 83143, 84470, 84440, 83778, 84471, 84473, 84443, 83781, 
84474, 84472, 84441, 83749, 83780
21248, 83363, 83353, 83133, 83143, 83364, 83354, 83134, 83144, 84473, 84443, 83781, 84474, 84476, 84446, 83784, 
84477, 84475, 84444, 83752, 83783
21249, 83364, 83354, 83134, 83144, 83365, 83355, 83135, 83145, 84476, 84446, 83784, 84477, 84479, 84449, 83787, 
84480, 84478, 84447, 83755, 83786
21250, 83365, 83355, 83135, 83145, 83366, 83356, 83136, 83146, 84479, 84449, 83787, 84480, 84482, 84452, 83790, 
84483, 84481, 84450, 83758, 83789
21251, 83366, 83356, 83136, 83146, 83367, 83357, 83137, 83147, 84482, 84452, 83790, 84483, 84485, 84455, 83793, 
84486, 84484, 84453, 83761, 83792
21252, 83367, 83357, 83137, 83147, 83368, 83358, 83138, 83148, 84485, 84455, 83793, 84486, 84488, 84458, 83796, 
84489, 84487, 84456, 83764, 83795
21253, 83368, 83358, 83138, 83148, 28949, 28948, 28926, 28927, 84488, 84458, 83796, 84489, 29026, 29023, 28981, 
29025, 84490, 84459, 83767, 83798
21254, 28794, 28793, 28771, 28772, 83369, 83359, 83139, 83149, 28871, 28870, 28826, 28872, 84492, 84462, 83800, 
84493, 84491, 84460, 83768, 83799
21255, 83369, 83359, 83139, 83149, 83370, 83360, 83140, 83150, 84492, 84462, 83800, 84493, 84495, 84465, 83803, 
84496, 84494, 84463, 83771, 83802
21256, 83370, 83360, 83140, 83150, 83371, 83361, 83141, 83151, 84495, 84465, 83803, 84496, 84498, 84468, 83806, 
84499, 84497, 84466, 83774, 83805
21257, 83371, 83361, 83141, 83151, 83372, 83362, 83142, 83152, 84498, 84468, 83806, 84499, 84501, 84471, 83809, 
84502, 84500, 84469, 83777, 83808
21258, 83372, 83362, 83142, 83152, 83373, 83363, 83143, 83153, 84501, 84471, 83809, 84502, 84504, 84474, 83812, 
84505, 84503, 84472, 83780, 83811
21259, 83373, 83363, 83143, 83153, 83374, 83364, 83144, 83154, 84504, 84474, 83812, 84505, 84507, 84477, 83815, 
84508, 84506, 84475, 83783, 83814
21260, 83374, 83364, 83144, 83154, 83375, 83365, 83145, 83155, 84507, 84477, 83815, 84508, 84510, 84480, 83818, 
84511, 84509, 84478, 83786, 83817
21261, 83375, 83365, 83145, 83155, 83376, 83366, 83146, 83156, 84510, 84480, 83818, 84511, 84513, 84483, 83821, 
84514, 84512, 84481, 83789, 83820
21262, 83376, 83366, 83146, 83156, 83377, 83367, 83147, 83157, 84513, 84483, 83821, 84514, 84516, 84486, 83824, 
84517, 84515, 84484, 83792, 83823
21263, 83377, 83367, 83147, 83157, 83378, 83368, 83148, 83158, 84516, 84486, 83824, 84517, 84519, 84489, 83827, 
84520, 84518, 84487, 83795, 83826
21264, 83378, 83368, 83148, 83158, 28950, 28949, 28927, 28928, 84519, 84489, 83827, 84520, 29028, 29025, 28983, 
29027, 84521, 84490, 83798, 83829
21265, 28795, 28794, 28772, 28773, 83379, 83369, 83149, 83159, 28873, 28872, 28828, 28874, 84523, 84493, 83831, 
84524, 84522, 84491, 83799, 83830
21266, 83379, 83369, 83149, 83159, 83380, 83370, 83150, 83160, 84523, 84493, 83831, 84524, 84526, 84496, 83834, 
84527, 84525, 84494, 83802, 83833
21267, 83380, 83370, 83150, 83160, 83381, 83371, 83151, 83161, 84526, 84496, 83834, 84527, 84529, 84499, 83837, 
84530, 84528, 84497, 83805, 83836
21268, 83381, 83371, 83151, 83161, 83382, 83372, 83152, 83162, 84529, 84499, 83837, 84530, 84532, 84502, 83840, 
84533, 84531, 84500, 83808, 83839
21269, 83382, 83372, 83152, 83162, 83383, 83373, 83153, 83163, 84532, 84502, 83840, 84533, 84535, 84505, 83843, 
84536, 84534, 84503, 83811, 83842
21270, 83383, 83373, 83153, 83163, 83384, 83374, 83154, 83164, 84535, 84505, 83843, 84536, 84538, 84508, 83846, 
84539, 84537, 84506, 83814, 83845
21271, 83384, 83374, 83154, 83164, 83385, 83375, 83155, 83165, 84538, 84508, 83846, 84539, 84541, 84511, 83849, 
84542, 84540, 84509, 83817, 83848
21272, 83385, 83375, 83155, 83165, 83386, 83376, 83156, 83166, 84541, 84511, 83849, 84542, 84544, 84514, 83852, 
84545, 84543, 84512, 83820, 83851
21273, 83386, 83376, 83156, 83166, 83387, 83377, 83157, 83167, 84544, 84514, 83852, 84545, 84547, 84517, 83855, 
84548, 84546, 84515, 83823, 83854
21274, 83387, 83377, 83157, 83167, 83388, 83378, 83158, 83168, 84547, 84517, 83855, 84548, 84550, 84520, 83858, 
84551, 84549, 84518, 83826, 83857
21275, 83388, 83378, 83158, 83168, 28951, 28950, 28928, 28929, 84550, 84520, 83858, 84551, 29030, 29027, 28985, 
29029, 84552, 84521, 83829, 83860
21276, 28796, 28795, 28773, 28774, 83389, 83379, 83159, 83169, 28875, 28874, 28830, 28876, 84554, 84524, 83862, 
84555, 84553, 84522, 83830, 83861
21277, 83389, 83379, 83159, 83169, 83390, 83380, 83160, 83170, 84554, 84524, 83862, 84555, 84557, 84527, 83865, 
84558, 84556, 84525, 83833, 83864
21278, 83390, 83380, 83160, 83170, 83391, 83381, 83161, 83171, 84557, 84527, 83865, 84558, 84560, 84530, 83868, 
84561, 84559, 84528, 83836, 83867
21279, 83391, 83381, 83161, 83171, 83392, 83382, 83162, 83172, 84560, 84530, 83868, 84561, 84563, 84533, 83871, 
84564, 84562, 84531, 83839, 83870
21280, 83392, 83382, 83162, 83172, 83393, 83383, 83163, 83173, 84563, 84533, 83871, 84564, 84566, 84536, 83874, 
84567, 84565, 84534, 83842, 83873
21281, 83393, 83383, 83163, 83173, 83394, 83384, 83164, 83174, 84566, 84536, 83874, 84567, 84569, 84539, 83877, 
84570, 84568, 84537, 83845, 83876
21282, 83394, 83384, 83164, 83174, 83395, 83385, 83165, 83175, 84569, 84539, 83877, 84570, 84572, 84542, 83880, 
84573, 84571, 84540, 83848, 83879
21283, 83395, 83385, 83165, 83175, 83396, 83386, 83166, 83176, 84572, 84542, 83880, 84573, 84575, 84545, 83883, 
84576, 84574, 84543, 83851, 83882
21284, 83396, 83386, 83166, 83176, 83397, 83387, 83167, 83177, 84575, 84545, 83883, 84576, 84578, 84548, 83886, 
84579, 84577, 84546, 83854, 83885
21285, 83397, 83387, 83167, 83177, 83398, 83388, 83168, 83178, 84578, 84548, 83886, 84579, 84581, 84551, 83889, 
84582, 84580, 84549, 83857, 83888
21286, 83398, 83388, 83168, 83178, 28952, 28951, 28929, 28930, 84581, 84551, 83889, 84582, 29032, 29029, 28987, 
29031, 84583, 84552, 83860, 83891
21287, 28797, 28796, 28774, 28775, 83399, 83389, 83169, 83179, 28877, 28876, 28832, 28878, 84585, 84555, 83893, 
84586, 84584, 84553, 83861, 83892
21288, 83399, 83389, 83169, 83179, 83400, 83390, 83170, 83180, 84585, 84555, 83893, 84586, 84588, 84558, 83896, 
84589, 84587, 84556, 83864, 83895
21289, 83400, 83390, 83170, 83180, 83401, 83391, 83171, 83181, 84588, 84558, 83896, 84589, 84591, 84561, 83899, 
84592, 84590, 84559, 83867, 83898
21290, 83401, 83391, 83171, 83181, 83402, 83392, 83172, 83182, 84591, 84561, 83899, 84592, 84594, 84564, 83902, 
84595, 84593, 84562, 83870, 83901
21291, 83402, 83392, 83172, 83182, 83403, 83393, 83173, 83183, 84594, 84564, 83902, 84595, 84597, 84567, 83905, 
84598, 84596, 84565, 83873, 83904
21292, 83403, 83393, 83173, 83183, 83404, 83394, 83174, 83184, 84597, 84567, 83905, 84598, 84600, 84570, 83908, 
84601, 84599, 84568, 83876, 83907
21293, 83404, 83394, 83174, 83184, 83405, 83395, 83175, 83185, 84600, 84570, 83908, 84601, 84603, 84573, 83911, 
84604, 84602, 84571, 83879, 83910
21294, 83405, 83395, 83175, 83185, 83406, 83396, 83176, 83186, 84603, 84573, 83911, 84604, 84606, 84576, 83914, 
84607, 84605, 84574, 83882, 83913
21295, 83406, 83396, 83176, 83186, 83407, 83397, 83177, 83187, 84606, 84576, 83914, 84607, 84609, 84579, 83917, 
84610, 84608, 84577, 83885, 83916
21296, 83407, 83397, 83177, 83187, 83408, 83398, 83178, 83188, 84609, 84579, 83917, 84610, 84612, 84582, 83920, 
84613, 84611, 84580, 83888, 83919
21297, 83408, 83398, 83178, 83188, 28953, 28952, 28930, 28931, 84612, 84582, 83920, 84613, 29034, 29031, 28989, 
29033, 84614, 84583, 83891, 83922
21298, 28798, 28797, 28775, 28776, 83409, 83399, 83179, 83189, 28879, 28878, 28834, 28880, 84616, 84586, 83924, 
84617, 84615, 84584, 83892, 83923
21299, 83409, 83399, 83179, 83189, 83410, 83400, 83180, 83190, 84616, 84586, 83924, 84617, 84619, 84589, 83927, 
84620, 84618, 84587, 83895, 83926
21300, 83410, 83400, 83180, 83190, 83411, 83401, 83181, 83191, 84619, 84589, 83927, 84620, 84622, 84592, 83930, 
84623, 84621, 84590, 83898, 83929
21301, 83411, 83401, 83181, 83191, 83412, 83402, 83182, 83192, 84622, 84592, 83930, 84623, 84625, 84595, 83933, 
84626, 84624, 84593, 83901, 83932
21302, 83412, 83402, 83182, 83192, 83413, 83403, 83183, 83193, 84625, 84595, 83933, 84626, 84628, 84598, 83936, 
84629, 84627, 84596, 83904, 83935
21303, 83413, 83403, 83183, 83193, 83414, 83404, 83184, 83194, 84628, 84598, 83936, 84629, 84631, 84601, 83939, 
84632, 84630, 84599, 83907, 83938
21304, 83414, 83404, 83184, 83194, 83415, 83405, 83185, 83195, 84631, 84601, 83939, 84632, 84634, 84604, 83942, 
84635, 84633, 84602, 83910, 83941
21305, 83415, 83405, 83185, 83195, 83416, 83406, 83186, 83196, 84634, 84604, 83942, 84635, 84637, 84607, 83945, 
84638, 84636, 84605, 83913, 83944
21306, 83416, 83406, 83186, 83196, 83417, 83407, 83187, 83197, 84637, 84607, 83945, 84638, 84640, 84610, 83948, 
84641, 84639, 84608, 83916, 83947
21307, 83417, 83407, 83187, 83197, 83418, 83408, 83188, 83198, 84640, 84610, 83948, 84641, 84643, 84613, 83951, 
84644, 84642, 84611, 83919, 83950
21308, 83418, 83408, 83188, 83198, 28954, 28953, 28931, 28932, 84643, 84613, 83951, 84644, 29036, 29033, 28991, 
29035, 84645, 84614, 83922, 83953
21309, 28799, 28798, 28776, 28777, 83419, 83409, 83189, 83199, 28881, 28880, 28836, 28882, 84647, 84617, 83955, 
84648, 84646, 84615, 83923, 83954
21310, 83419, 83409, 83189, 83199, 83420, 83410, 83190, 83200, 84647, 84617, 83955, 84648, 84650, 84620, 83958, 
84651, 84649, 84618, 83926, 83957
21311, 83420, 83410, 83190, 83200, 83421, 83411, 83191, 83201, 84650, 84620, 83958, 84651, 84653, 84623, 83961, 
84654, 84652, 84621, 83929, 83960
21312, 83421, 83411, 83191, 83201, 83422, 83412, 83192, 83202, 84653, 84623, 83961, 84654, 84656, 84626, 83964, 
84657, 84655, 84624, 83932, 83963
21313, 83422, 83412, 83192, 83202, 83423, 83413, 83193, 83203, 84656, 84626, 83964, 84657, 84659, 84629, 83967, 
84660, 84658, 84627, 83935, 83966
21314, 83423, 83413, 83193, 83203, 83424, 83414, 83194, 83204, 84659, 84629, 83967, 84660, 84662, 84632, 83970, 
84663, 84661, 84630, 83938, 83969
21315, 83424, 83414, 83194, 83204, 83425, 83415, 83195, 83205, 84662, 84632, 83970, 84663, 84665, 84635, 83973, 
84666, 84664, 84633, 83941, 83972
21316, 83425, 83415, 83195, 83205, 83426, 83416, 83196, 83206, 84665, 84635, 83973, 84666, 84668, 84638, 83976, 
84669, 84667, 84636, 83944, 83975
21317, 83426, 83416, 83196, 83206, 83427, 83417, 83197, 83207, 84668, 84638, 83976, 84669, 84671, 84641, 83979, 
84672, 84670, 84639, 83947, 83978
21318, 83427, 83417, 83197, 83207, 83428, 83418, 83198, 83208, 84671, 84641, 83979, 84672, 84674, 84644, 83982, 
84675, 84673, 84642, 83950, 83981
21319, 83428, 83418, 83198, 83208, 28955, 28954, 28932, 28933, 84674, 84644, 83982, 84675, 29038, 29035, 28993, 
29037, 84676, 84645, 83953, 83984
21320, 28800, 28799, 28777, 28778, 83429, 83419, 83199, 83209, 28883, 28882, 28838, 28884, 84678, 84648, 83986, 
84679, 84677, 84646, 83954, 83985
21321, 83429, 83419, 83199, 83209, 83430, 83420, 83200, 83210, 84678, 84648, 83986, 84679, 84681, 84651, 83989, 
84682, 84680, 84649, 83957, 83988
21322, 83430, 83420, 83200, 83210, 83431, 83421, 83201, 83211, 84681, 84651, 83989, 84682, 84684, 84654, 83992, 
