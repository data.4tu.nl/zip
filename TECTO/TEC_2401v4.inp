19277, 65735, 65725, 65505, 65515, 65736, 65726, 65506, 65516, 79370, 79340, 78678, 79371, 79373, 79343, 78681, 
79374, 79372, 79341, 78649, 78680
19278, 65736, 65726, 65506, 65516, 65737, 65727, 65507, 65517, 79373, 79343, 78681, 79374, 79376, 79346, 78684, 
79377, 79375, 79344, 78652, 78683
19279, 65737, 65727, 65507, 65517, 65738, 65728, 65508, 65518, 79376, 79346, 78684, 79377, 79379, 79349, 78687, 
79380, 79378, 79347, 78655, 78686
19280, 65738, 65728, 65508, 65518, 65739, 65729, 65509, 65519, 79379, 79349, 78687, 79380, 79382, 79352, 78690, 
79383, 79381, 79350, 78658, 78689
19281, 65739, 65729, 65509, 65519, 65740, 65730, 65510, 65520, 79382, 79352, 78690, 79383, 79385, 79355, 78693, 
79386, 79384, 79353, 78661, 78692
19282, 65740, 65730, 65510, 65520, 65741, 65731, 65511, 65521, 79385, 79355, 78693, 79386, 79388, 79358, 78696, 
79389, 79387, 79356, 78664, 78695
19283, 65741, 65731, 65511, 65521, 65742, 65732, 65512, 65522, 79388, 79358, 78696, 79389, 79391, 79361, 78699, 
79392, 79390, 79359, 78667, 78698
19284, 65742, 65732, 65512, 65522, 18345, 18344, 18322, 18323, 79391, 79361, 78699, 79392, 19258, 19255, 19213, 
19257, 79393, 79362, 78670, 78701
19285, 16850, 16849, 16827, 16828, 65743, 65733, 65513, 65523, 17763, 17762, 17718, 17764, 79395, 79365, 78703, 
79396, 79394, 79363, 78671, 78702
19286, 65743, 65733, 65513, 65523, 65744, 65734, 65514, 65524, 79395, 79365, 78703, 79396, 79398, 79368, 78706, 
79399, 79397, 79366, 78674, 78705
19287, 65744, 65734, 65514, 65524, 65745, 65735, 65515, 65525, 79398, 79368, 78706, 79399, 79401, 79371, 78709, 
79402, 79400, 79369, 78677, 78708
19288, 65745, 65735, 65515, 65525, 65746, 65736, 65516, 65526, 79401, 79371, 78709, 79402, 79404, 79374, 78712, 
79405, 79403, 79372, 78680, 78711
19289, 65746, 65736, 65516, 65526, 65747, 65737, 65517, 65527, 79404, 79374, 78712, 79405, 79407, 79377, 78715, 
79408, 79406, 79375, 78683, 78714
19290, 65747, 65737, 65517, 65527, 65748, 65738, 65518, 65528, 79407, 79377, 78715, 79408, 79410, 79380, 78718, 
79411, 79409, 79378, 78686, 78717
19291, 65748, 65738, 65518, 65528, 65749, 65739, 65519, 65529, 79410, 79380, 78718, 79411, 79413, 79383, 78721, 
79414, 79412, 79381, 78689, 78720
19292, 65749, 65739, 65519, 65529, 65750, 65740, 65520, 65530, 79413, 79383, 78721, 79414, 79416, 79386, 78724, 
79417, 79415, 79384, 78692, 78723
19293, 65750, 65740, 65520, 65530, 65751, 65741, 65521, 65531, 79416, 79386, 78724, 79417, 79419, 79389, 78727, 
79420, 79418, 79387, 78695, 78726
19294, 65751, 65741, 65521, 65531, 65752, 65742, 65522, 65532, 79419, 79389, 78727, 79420, 79422, 79392, 78730, 
79423, 79421, 79390, 78698, 78729
19295, 65752, 65742, 65522, 65532, 18346, 18345, 18323, 18324, 79422, 79392, 78730, 79423, 19260, 19257, 19215, 
19259, 79424, 79393, 78701, 78732
19296, 16851, 16850, 16828, 16829, 65753, 65743, 65523, 65533, 17765, 17764, 17720, 17766, 79426, 79396, 78734, 
79427, 79425, 79394, 78702, 78733
19297, 65753, 65743, 65523, 65533, 65754, 65744, 65524, 65534, 79426, 79396, 78734, 79427, 79429, 79399, 78737, 
79430, 79428, 79397, 78705, 78736
19298, 65754, 65744, 65524, 65534, 65755, 65745, 65525, 65535, 79429, 79399, 78737, 79430, 79432, 79402, 78740, 
79433, 79431, 79400, 78708, 78739
19299, 65755, 65745, 65525, 65535, 65756, 65746, 65526, 65536, 79432, 79402, 78740, 79433, 79435, 79405, 78743, 
79436, 79434, 79403, 78711, 78742
19300, 65756, 65746, 65526, 65536, 65757, 65747, 65527, 65537, 79435, 79405, 78743, 79436, 79438, 79408, 78746, 
79439, 79437, 79406, 78714, 78745
19301, 65757, 65747, 65527, 65537, 65758, 65748, 65528, 65538, 79438, 79408, 78746, 79439, 79441, 79411, 78749, 
79442, 79440, 79409, 78717, 78748
19302, 65758, 65748, 65528, 65538, 65759, 65749, 65529, 65539, 79441, 79411, 78749, 79442, 79444, 79414, 78752, 
79445, 79443, 79412, 78720, 78751
19303, 65759, 65749, 65529, 65539, 65760, 65750, 65530, 65540, 79444, 79414, 78752, 79445, 79447, 79417, 78755, 
79448, 79446, 79415, 78723, 78754
19304, 65760, 65750, 65530, 65540, 65761, 65751, 65531, 65541, 79447, 79417, 78755, 79448, 79450, 79420, 78758, 
79451, 79449, 79418, 78726, 78757
19305, 65761, 65751, 65531, 65541, 65762, 65752, 65532, 65542, 79450, 79420, 78758, 79451, 79453, 79423, 78761, 
79454, 79452, 79421, 78729, 78760
19306, 65762, 65752, 65532, 65542, 18347, 18346, 18324, 18325, 79453, 79423, 78761, 79454, 19262, 19259, 19217, 
19261, 79455, 79424, 78732, 78763
19307, 16852, 16851, 16829, 16830, 65763, 65753, 65533, 65543, 17767, 17766, 17722, 17768, 79457, 79427, 78765, 
79458, 79456, 79425, 78733, 78764
19308, 65763, 65753, 65533, 65543, 65764, 65754, 65534, 65544, 79457, 79427, 78765, 79458, 79460, 79430, 78768, 
79461, 79459, 79428, 78736, 78767
19309, 65764, 65754, 65534, 65544, 65765, 65755, 65535, 65545, 79460, 79430, 78768, 79461, 79463, 79433, 78771, 
79464, 79462, 79431, 78739, 78770
19310, 65765, 65755, 65535, 65545, 65766, 65756, 65536, 65546, 79463, 79433, 78771, 79464, 79466, 79436, 78774, 
79467, 79465, 79434, 78742, 78773
19311, 65766, 65756, 65536, 65546, 65767, 65757, 65537, 65547, 79466, 79436, 78774, 79467, 79469, 79439, 78777, 
79470, 79468, 79437, 78745, 78776
19312, 65767, 65757, 65537, 65547, 65768, 65758, 65538, 65548, 79469, 79439, 78777, 79470, 79472, 79442, 78780, 
79473, 79471, 79440, 78748, 78779
19313, 65768, 65758, 65538, 65548, 65769, 65759, 65539, 65549, 79472, 79442, 78780, 79473, 79475, 79445, 78783, 
79476, 79474, 79443, 78751, 78782
19314, 65769, 65759, 65539, 65549, 65770, 65760, 65540, 65550, 79475, 79445, 78783, 79476, 79478, 79448, 78786, 
79479, 79477, 79446, 78754, 78785
19315, 65770, 65760, 65540, 65550, 65771, 65761, 65541, 65551, 79478, 79448, 78786, 79479, 79481, 79451, 78789, 
79482, 79480, 79449, 78757, 78788
19316, 65771, 65761, 65541, 65551, 65772, 65762, 65542, 65552, 79481, 79451, 78789, 79482, 79484, 79454, 78792, 
79485, 79483, 79452, 78760, 78791
19317, 65772, 65762, 65542, 65552, 18348, 18347, 18325, 18326, 79484, 79454, 78792, 79485, 19264, 19261, 19219, 
19263, 79486, 79455, 78763, 78794
19318, 16853, 16852, 16830, 16831, 65773, 65763, 65543, 65553, 17769, 17768, 17724, 17770, 79488, 79458, 78796, 
79489, 79487, 79456, 78764, 78795
19319, 65773, 65763, 65543, 65553, 65774, 65764, 65544, 65554, 79488, 79458, 78796, 79489, 79491, 79461, 78799, 
79492, 79490, 79459, 78767, 78798
19320, 65774, 65764, 65544, 65554, 65775, 65765, 65545, 65555, 79491, 79461, 78799, 79492, 79494, 79464, 78802, 
79495, 79493, 79462, 78770, 78801
19321, 65775, 65765, 65545, 65555, 65776, 65766, 65546, 65556, 79494, 79464, 78802, 79495, 79497, 79467, 78805, 
79498, 79496, 79465, 78773, 78804
19322, 65776, 65766, 65546, 65556, 65777, 65767, 65547, 65557, 79497, 79467, 78805, 79498, 79500, 79470, 78808, 
79501, 79499, 79468, 78776, 78807
19323, 65777, 65767, 65547, 65557, 65778, 65768, 65548, 65558, 79500, 79470, 78808, 79501, 79503, 79473, 78811, 
79504, 79502, 79471, 78779, 78810
19324, 65778, 65768, 65548, 65558, 65779, 65769, 65549, 65559, 79503, 79473, 78811, 79504, 79506, 79476, 78814, 
79507, 79505, 79474, 78782, 78813
19325, 65779, 65769, 65549, 65559, 65780, 65770, 65550, 65560, 79506, 79476, 78814, 79507, 79509, 79479, 78817, 
79510, 79508, 79477, 78785, 78816
19326, 65780, 65770, 65550, 65560, 65781, 65771, 65551, 65561, 79509, 79479, 78817, 79510, 79512, 79482, 78820, 
79513, 79511, 79480, 78788, 78819
19327, 65781, 65771, 65551, 65561, 65782, 65772, 65552, 65562, 79512, 79482, 78820, 79513, 79515, 79485, 78823, 
79516, 79514, 79483, 78791, 78822
19328, 65782, 65772, 65552, 65562, 18349, 18348, 18326, 18327, 79515, 79485, 78823, 79516, 19266, 19263, 19221, 
19265, 79517, 79486, 78794, 78825
19329, 16854, 16853, 16831, 16832, 65783, 65773, 65553, 65563, 17771, 17770, 17726, 17772, 79519, 79489, 78827, 
79520, 79518, 79487, 78795, 78826
19330, 65783, 65773, 65553, 65563, 65784, 65774, 65554, 65564, 79519, 79489, 78827, 79520, 79522, 79492, 78830, 
79523, 79521, 79490, 78798, 78829
19331, 65784, 65774, 65554, 65564, 65785, 65775, 65555, 65565, 79522, 79492, 78830, 79523, 79525, 79495, 78833, 
79526, 79524, 79493, 78801, 78832
19332, 65785, 65775, 65555, 65565, 65786, 65776, 65556, 65566, 79525, 79495, 78833, 79526, 79528, 79498, 78836, 
79529, 79527, 79496, 78804, 78835
19333, 65786, 65776, 65556, 65566, 65787, 65777, 65557, 65567, 79528, 79498, 78836, 79529, 79531, 79501, 78839, 
79532, 79530, 79499, 78807, 78838
19334, 65787, 65777, 65557, 65567, 65788, 65778, 65558, 65568, 79531, 79501, 78839, 79532, 79534, 79504, 78842, 
79535, 79533, 79502, 78810, 78841
19335, 65788, 65778, 65558, 65568, 65789, 65779, 65559, 65569, 79534, 79504, 78842, 79535, 79537, 79507, 78845, 
79538, 79536, 79505, 78813, 78844
19336, 65789, 65779, 65559, 65569, 65790, 65780, 65560, 65570, 79537, 79507, 78845, 79538, 79540, 79510, 78848, 
79541, 79539, 79508, 78816, 78847
19337, 65790, 65780, 65560, 65570, 65791, 65781, 65561, 65571, 79540, 79510, 78848, 79541, 79543, 79513, 78851, 
79544, 79542, 79511, 78819, 78850
19338, 65791, 65781, 65561, 65571, 65792, 65782, 65562, 65572, 79543, 79513, 78851, 79544, 79546, 79516, 78854, 
79547, 79545, 79514, 78822, 78853
19339, 65792, 65782, 65562, 65572, 18350, 18349, 18327, 18328, 79546, 79516, 78854, 79547, 19268, 19265, 19223, 
19267, 79548, 79517, 78825, 78856
19340, 16855, 16854, 16832, 16833, 65793, 65783, 65563, 65573, 17773, 17772, 17728, 17774, 79550, 79520, 78858, 
79551, 79549, 79518, 78826, 78857
19341, 65793, 65783, 65563, 65573, 65794, 65784, 65564, 65574, 79550, 79520, 78858, 79551, 79553, 79523, 78861, 
79554, 79552, 79521, 78829, 78860
19342, 65794, 65784, 65564, 65574, 65795, 65785, 65565, 65575, 79553, 79523, 78861, 79554, 79556, 79526, 78864, 
79557, 79555, 79524, 78832, 78863
19343, 65795, 65785, 65565, 65575, 65796, 65786, 65566, 65576, 79556, 79526, 78864, 79557, 79559, 79529, 78867, 
79560, 79558, 79527, 78835, 78866
19344, 65796, 65786, 65566, 65576, 65797, 65787, 65567, 65577, 79559, 79529, 78867, 79560, 79562, 79532, 78870, 
79563, 79561, 79530, 78838, 78869
19345, 65797, 65787, 65567, 65577, 65798, 65788, 65568, 65578, 79562, 79532, 78870, 79563, 79565, 79535, 78873, 
79566, 79564, 79533, 78841, 78872
19346, 65798, 65788, 65568, 65578, 65799, 65789, 65569, 65579, 79565, 79535, 78873, 79566, 79568, 79538, 78876, 
79569, 79567, 79536, 78844, 78875
19347, 65799, 65789, 65569, 65579, 65800, 65790, 65570, 65580, 79568, 79538, 78876, 79569, 79571, 79541, 78879, 
79572, 79570, 79539, 78847, 78878
19348, 65800, 65790, 65570, 65580, 65801, 65791, 65571, 65581, 79571, 79541, 78879, 79572, 79574, 79544, 78882, 
79575, 79573, 79542, 78850, 78881
19349, 65801, 65791, 65571, 65581, 65802, 65792, 65572, 65582, 79574, 79544, 78882, 79575, 79577, 79547, 78885, 
79578, 79576, 79545, 78853, 78884
19350, 65802, 65792, 65572, 65582, 18351, 18350, 18328, 18329, 79577, 79547, 78885, 79578, 19270, 19267, 19225, 
19269, 79579, 79548, 78856, 78887
19351, 16856, 16855, 16833, 16834, 65803, 65793, 65573, 65583, 17775, 17774, 17730, 17776, 79581, 79551, 78889, 
79582, 79580, 79549, 78857, 78888
19352, 65803, 65793, 65573, 65583, 65804, 65794, 65574, 65584, 79581, 79551, 78889, 79582, 79584, 79554, 78892, 
79585, 79583, 79552, 78860, 78891
19353, 65804, 65794, 65574, 65584, 65805, 65795, 65575, 65585, 79584, 79554, 78892, 79585, 79587, 79557, 78895, 
79588, 79586, 79555, 78863, 78894
19354, 65805, 65795, 65575, 65585, 65806, 65796, 65576, 65586, 79587, 79557, 78895, 79588, 79590, 79560, 78898, 
79591, 79589, 79558, 78866, 78897
19355, 65806, 65796, 65576, 65586, 65807, 65797, 65577, 65587, 79590, 79560, 78898, 79591, 79593, 79563, 78901, 
79594, 79592, 79561, 78869, 78900
19356, 65807, 65797, 65577, 65587, 65808, 65798, 65578, 65588, 79593, 79563, 78901, 79594, 79596, 79566, 78904, 
79597, 79595, 79564, 78872, 78903
19357, 65808, 65798, 65578, 65588, 65809, 65799, 65579, 65589, 79596, 79566, 78904, 79597, 79599, 79569, 78907, 
79600, 79598, 79567, 78875, 78906
19358, 65809, 65799, 65579, 65589, 65810, 65800, 65580, 65590, 79599, 79569, 78907, 79600, 79602, 79572, 78910, 
79603, 79601, 79570, 78878, 78909
19359, 65810, 65800, 65580, 65590, 65811, 65801, 65581, 65591, 79602, 79572, 78910, 79603, 79605, 79575, 78913, 
79606, 79604, 79573, 78881, 78912
19360, 65811, 65801, 65581, 65591, 65812, 65802, 65582, 65592, 79605, 79575, 78913, 79606, 79608, 79578, 78916, 
79609, 79607, 79576, 78884, 78915
19361, 65812, 65802, 65582, 65592, 18352, 18351, 18329, 18330, 79608, 79578, 78916, 79609, 19272, 19269, 19227, 
19271, 79610, 79579, 78887, 78918
19362, 1652, 16856, 16834, 1651, 20303, 65803, 65583, 20293, 17777, 17776, 17732, 1674, 79611, 79582, 78919, 
20722, 20721, 79580, 78888, 20700
19363, 20303, 65803, 65583, 20293, 20304, 65804, 65584, 20294, 79611, 79582, 78919, 20722, 79612, 79585, 78920, 
20724, 20723, 79583, 78891, 20702
19364, 20304, 65804, 65584, 20294, 20305, 65805, 65585, 20295, 79612, 79585, 78920, 20724, 79613, 79588, 78921, 
20726, 20725, 79586, 78894, 20704
19365, 20305, 65805, 65585, 20295, 20306, 65806, 65586, 20296, 79613, 79588, 78921, 20726, 79614, 79591, 78922, 
20728, 20727, 79589, 78897, 20706
19366, 20306, 65806, 65586, 20296, 20307, 65807, 65587, 20297, 79614, 79591, 78922, 20728, 79615, 79594, 78923, 
20730, 20729, 79592, 78900, 20708
19367, 20307, 65807, 65587, 20297, 20308, 65808, 65588, 20298, 79615, 79594, 78923, 20730, 79616, 79597, 78924, 
20732, 20731, 79595, 78903, 20710
19368, 20308, 65808, 65588, 20298, 20309, 65809, 65589, 20299, 79616, 79597, 78924, 20732, 79617, 79600, 78925, 
20734, 20733, 79598, 78906, 20712
19369, 20309, 65809, 65589, 20299, 20310, 65810, 65590, 20300, 79617, 79600, 78925, 20734, 79618, 79603, 78926, 
20736, 20735, 79601, 78909, 20714
19370, 20310, 65810, 65590, 20300, 20311, 65811, 65591, 20301, 79618, 79603, 78926, 20736, 79619, 79606, 78927, 
20738, 20737, 79604, 78912, 20716
19371, 20311, 65811, 65591, 20301, 20312, 65812, 65592, 20302, 79619, 79606, 78927, 20738, 79620, 79609, 78928, 
20740, 20739, 79607, 78915, 20718
19372, 20312, 65812, 65592, 20302, 1787, 18352, 18330, 1786, 79620, 79609, 78928, 20740, 19273, 19271, 19228, 
1809, 20741, 79610, 78918, 20720
19373, 16857, 1608, 1607, 16835, 65813, 19621, 19611, 65593, 17778, 1630, 17733, 17779, 79622, 20050, 78930, 
79623, 79621, 20051, 20030, 78929
19374, 65813, 19621, 19611, 65593, 65814, 19622, 19612, 65594, 79622, 20050, 78930, 79623, 79625, 20052, 78933, 
79626, 79624, 20053, 20032, 78932
19375, 65814, 19622, 19612, 65594, 65815, 19623, 19613, 65595, 79625, 20052, 78933, 79626, 79628, 20054, 78936, 
79629, 79627, 20055, 20034, 78935
19376, 65815, 19623, 19613, 65595, 65816, 19624, 19614, 65596, 79628, 20054, 78936, 79629, 79631, 20056, 78939, 
79632, 79630, 20057, 20036, 78938
19377, 65816, 19624, 19614, 65596, 65817, 19625, 19615, 65597, 79631, 20056, 78939, 79632, 79634, 20058, 78942, 
79635, 79633, 20059, 20038, 78941
19378, 65817, 19625, 19615, 65597, 65818, 19626, 19616, 65598, 79634, 20058, 78942, 79635, 79637, 20060, 78945, 
79638, 79636, 20061, 20040, 78944
19379, 65818, 19626, 19616, 65598, 65819, 19627, 19617, 65599, 79637, 20060, 78945, 79638, 79640, 20062, 78948, 
79641, 79639, 20063, 20042, 78947
19380, 65819, 19627, 19617, 65599, 65820, 19628, 19618, 65600, 79640, 20062, 78948, 79641, 79643, 20064, 78951, 
79644, 79642, 20065, 20044, 78950
19381, 65820, 19628, 19618, 65600, 65821, 19629, 19619, 65601, 79643, 20064, 78951, 79644, 79646, 20066, 78954, 
79647, 79645, 20067, 20046, 78953
19382, 65821, 19629, 19619, 65601, 65822, 19630, 19620, 65602, 79646, 20066, 78954, 79647, 79649, 20068, 78957, 
79650, 79648, 20069, 20048, 78956
19383, 65822, 19630, 19620, 65602, 18353, 1743, 1742, 18331, 79649, 20068, 78957, 79650, 19275, 1765, 19230, 
19274, 79651, 20070, 20049, 78959
19384, 16858, 16857, 16835, 16836, 65823, 65813, 65593, 65603, 17780, 17779, 17735, 17781, 79653, 79623, 78961, 
79654, 79652, 79621, 78929, 78960
19385, 65823, 65813, 65593, 65603, 65824, 65814, 65594, 65604, 79653, 79623, 78961, 79654, 79656, 79626, 78964, 
79657, 79655, 79624, 78932, 78963
19386, 65824, 65814, 65594, 65604, 65825, 65815, 65595, 65605, 79656, 79626, 78964, 79657, 79659, 79629, 78967, 
79660, 79658, 79627, 78935, 78966
19387, 65825, 65815, 65595, 65605, 65826, 65816, 65596, 65606, 79659, 79629, 78967, 79660, 79662, 79632, 78970, 
79663, 79661, 79630, 78938, 78969
19388, 65826, 65816, 65596, 65606, 65827, 65817, 65597, 65607, 79662, 79632, 78970, 79663, 79665, 79635, 78973, 
79666, 79664, 79633, 78941, 78972
19389, 65827, 65817, 65597, 65607, 65828, 65818, 65598, 65608, 79665, 79635, 78973, 79666, 79668, 79638, 78976, 
79669, 79667, 79636, 78944, 78975
19390, 65828, 65818, 65598, 65608, 65829, 65819, 65599, 65609, 79668, 79638, 78976, 79669, 79671, 79641, 78979, 
79672, 79670, 79639, 78947, 78978
19391, 65829, 65819, 65599, 65609, 65830, 65820, 65600, 65610, 79671, 79641, 78979, 79672, 79674, 79644, 78982, 
79675, 79673, 79642, 78950, 78981
19392, 65830, 65820, 65600, 65610, 65831, 65821, 65601, 65611, 79674, 79644, 78982, 79675, 79677, 79647, 78985, 
79678, 79676, 79645, 78953, 78984
19393, 65831, 65821, 65601, 65611, 65832, 65822, 65602, 65612, 79677, 79647, 78985, 79678, 79680, 79650, 78988, 
79681, 79679, 79648, 78956, 78987
19394, 65832, 65822, 65602, 65612, 18354, 18353, 18331, 18332, 79680, 79650, 78988, 79681, 19277, 19274, 19232, 
19276, 79682, 79651, 78959, 78990
19395, 16859, 16858, 16836, 16837, 65833, 65823, 65603, 65613, 17782, 17781, 17737, 17783, 79684, 79654, 78992, 
79685, 79683, 79652, 78960, 78991
19396, 65833, 65823, 65603, 65613, 65834, 65824, 65604, 65614, 79684, 79654, 78992, 79685, 79687, 79657, 78995, 
79688, 79686, 79655, 78963, 78994
19397, 65834, 65824, 65604, 65614, 65835, 65825, 65605, 65615, 79687, 79657, 78995, 79688, 79690, 79660, 78998, 
79691, 79689, 79658, 78966, 78997
19398, 65835, 65825, 65605, 65615, 65836, 65826, 65606, 65616, 79690, 79660, 78998, 79691, 79693, 79663, 79001, 
79694, 79692, 79661, 78969, 79000
19399, 65836, 65826, 65606, 65616, 65837, 65827, 65607, 65617, 79693, 79663, 79001, 79694, 79696, 79666, 79004, 
79697, 79695, 79664, 78972, 79003
19400, 65837, 65827, 65607, 65617, 65838, 65828, 65608, 65618, 79696, 79666, 79004, 79697, 79699, 79669, 79007, 
79700, 79698, 79667, 78975, 79006
19401, 65838, 65828, 65608, 65618, 65839, 65829, 65609, 65619, 79699, 79669, 79007, 79700, 79702, 79672, 79010, 
79703, 79701, 79670, 78978, 79009
19402, 65839, 65829, 65609, 65619, 65840, 65830, 65610, 65620, 79702, 79672, 79010, 79703, 79705, 79675, 79013, 
79706, 79704, 79673, 78981, 79012
19403, 65840, 65830, 65610, 65620, 65841, 65831, 65611, 65621, 79705, 79675, 79013, 79706, 79708, 79678, 79016, 
79709, 79707, 79676, 78984, 79015
19404, 65841, 65831, 65611, 65621, 65842, 65832, 65612, 65622, 79708, 79678, 79016, 79709, 79711, 79681, 79019, 
79712, 79710, 79679, 78987, 79018
19405, 65842, 65832, 65612, 65622, 18355, 18354, 18332, 18333, 79711, 79681, 79019, 79712, 19279, 19276, 19234, 
19278, 79713, 79682, 78990, 79021
19406, 16860, 16859, 16837, 16838, 65843, 65833, 65613, 65623, 17784, 17783, 17739, 17785, 79715, 79685, 79023, 
79716, 79714, 79683, 78991, 79022
19407, 65843, 65833, 65613, 65623, 65844, 65834, 65614, 65624, 79715, 79685, 79023, 79716, 79718, 79688, 79026, 
79719, 79717, 79686, 78994, 79025
19408, 65844, 65834, 65614, 65624, 65845, 65835, 65615, 65625, 79718, 79688, 79026, 79719, 79721, 79691, 79029, 
79722, 79720, 79689, 78997, 79028
19409, 65845, 65835, 65615, 65625, 65846, 65836, 65616, 65626, 79721, 79691, 79029, 79722, 79724, 79694, 79032, 
79725, 79723, 79692, 79000, 79031
19410, 65846, 65836, 65616, 65626, 65847, 65837, 65617, 65627, 79724, 79694, 79032, 79725, 79727, 79697, 79035, 
79728, 79726, 79695, 79003, 79034
19411, 65847, 65837, 65617, 65627, 65848, 65838, 65618, 65628, 79727, 79697, 79035, 79728, 79730, 79700, 79038, 
79731, 79729, 79698, 79006, 79037
19412, 65848, 65838, 65618, 65628, 65849, 65839, 65619, 65629, 79730, 79700, 79038, 79731, 79733, 79703, 79041, 
79734, 79732, 79701, 79009, 79040
19413, 65849, 65839, 65619, 65629, 65850, 65840, 65620, 65630, 79733, 79703, 79041, 79734, 79736, 79706, 79044, 
79737, 79735, 79704, 79012, 79043
19414, 65850, 65840, 65620, 65630, 65851, 65841, 65621, 65631, 79736, 79706, 79044, 79737, 79739, 79709, 79047, 
79740, 79738, 79707, 79015, 79046
19415, 65851, 65841, 65621, 65631, 65852, 65842, 65622, 65632, 79739, 79709, 79047, 79740, 79742, 79712, 79050, 
79743, 79741, 79710, 79018, 79049
19416, 65852, 65842, 65622, 65632, 18356, 18355, 18333, 18334, 79742, 79712, 79050, 79743, 19281, 19278, 19236, 
19280, 79744, 79713, 79021, 79052
19417, 16861, 16860, 16838, 16839, 65853, 65843, 65623, 65633, 17786, 17785, 17741, 17787, 79746, 79716, 79054, 
79747, 79745, 79714, 79022, 79053
19418, 65853, 65843, 65623, 65633, 65854, 65844, 65624, 65634, 79746, 79716, 79054, 79747, 79749, 79719, 79057, 
79750, 79748, 79717, 79025, 79056
19419, 65854, 65844, 65624, 65634, 65855, 65845, 65625, 65635, 79749, 79719, 79057, 79750, 79752, 79722, 79060, 
79753, 79751, 79720, 79028, 79059
19420, 65855, 65845, 65625, 65635, 65856, 65846, 65626, 65636, 79752, 79722, 79060, 79753, 79755, 79725, 79063, 
79756, 79754, 79723, 79031, 79062
19421, 65856, 65846, 65626, 65636, 65857, 65847, 65627, 65637, 79755, 79725, 79063, 79756, 79758, 79728, 79066, 
79759, 79757, 79726, 79034, 79065
19422, 65857, 65847, 65627, 65637, 65858, 65848, 65628, 65638, 79758, 79728, 79066, 79759, 79761, 79731, 79069, 
79762, 79760, 79729, 79037, 79068
19423, 65858, 65848, 65628, 65638, 65859, 65849, 65629, 65639, 79761, 79731, 79069, 79762, 79764, 79734, 79072, 
79765, 79763, 79732, 79040, 79071
19424, 65859, 65849, 65629, 65639, 65860, 65850, 65630, 65640, 79764, 79734, 79072, 79765, 79767, 79737, 79075, 
79768, 79766, 79735, 79043, 79074
19425, 65860, 65850, 65630, 65640, 65861, 65851, 65631, 65641, 79767, 79737, 79075, 79768, 79770, 79740, 79078, 
79771, 79769, 79738, 79046, 79077
19426, 65861, 65851, 65631, 65641, 65862, 65852, 65632, 65642, 79770, 79740, 79078, 79771, 79773, 79743, 79081, 
79774, 79772, 79741, 79049, 79080
19427, 65862, 65852, 65632, 65642, 18357, 18356, 18334, 18335, 79773, 79743, 79081, 79774, 19283, 19280, 19238, 
19282, 79775, 79744, 79052, 79083
19428, 16862, 16861, 16839, 16840, 65863, 65853, 65633, 65643, 17788, 17787, 17743, 17789, 79777, 79747, 79085, 
79778, 79776, 79745, 79053, 79084
19429, 65863, 65853, 65633, 65643, 65864, 65854, 65634, 65644, 79777, 79747, 79085, 79778, 79780, 79750, 79088, 
79781, 79779, 79748, 79056, 79087
19430, 65864, 65854, 65634, 65644, 65865, 65855, 65635, 65645, 79780, 79750, 79088, 79781, 79783, 79753, 79091, 
79784, 79782, 79751, 79059, 79090
19431, 65865, 65855, 65635, 65645, 65866, 65856, 65636, 65646, 79783, 79753, 79091, 79784, 79786, 79756, 79094, 
79787, 79785, 79754, 79062, 79093
19432, 65866, 65856, 65636, 65646, 65867, 65857, 65637, 65647, 79786, 79756, 79094, 79787, 79789, 79759, 79097, 
79790, 79788, 79757, 79065, 79096
19433, 65867, 65857, 65637, 65647, 65868, 65858, 65638, 65648, 79789, 79759, 79097, 79790, 79792, 79762, 79100, 
79793, 79791, 79760, 79068, 79099
19434, 65868, 65858, 65638, 65648, 65869, 65859, 65639, 65649, 79792, 79762, 79100, 79793, 79795, 79765, 79103, 
79796, 79794, 79763, 79071, 79102
19435, 65869, 65859, 65639, 65649, 65870, 65860, 65640, 65650, 79795, 79765, 79103, 79796, 79798, 79768, 79106, 
79799, 79797, 79766, 79074, 79105
19436, 65870, 65860, 65640, 65650, 65871, 65861, 65641, 65651, 79798, 79768, 79106, 79799, 79801, 79771, 79109, 
79802, 79800, 79769, 79077, 79108
19437, 65871, 65861, 65641, 65651, 65872, 65862, 65642, 65652, 79801, 79771, 79109, 79802, 79804, 79774, 79112, 
79805, 79803, 79772, 79080, 79111
19438, 65872, 65862, 65642, 65652, 18358, 18357, 18335, 18336, 79804, 79774, 79112, 79805, 19285, 19282, 19240, 
19284, 79806, 79775, 79083, 79114
19439, 16863, 16862, 16840, 16841, 65873, 65863, 65643, 65653, 17790, 17789, 17745, 17791, 79808, 79778, 79116, 
79809, 79807, 79776, 79084, 79115
19440, 65873, 65863, 65643, 65653, 65874, 65864, 65644, 65654, 79808, 79778, 79116, 79809, 79811, 79781, 79119, 
79812, 79810, 79779, 79087, 79118
19441, 65874, 65864, 65644, 65654, 65875, 65865, 65645, 65655, 79811, 79781, 79119, 79812, 79814, 79784, 79122, 
79815, 79813, 79782, 79090, 79121
19442, 65875, 65865, 65645, 65655, 65876, 65866, 65646, 65656, 79814, 79784, 79122, 79815, 79817, 79787, 79125, 
79818, 79816, 79785, 79093, 79124
19443, 65876, 65866, 65646, 65656, 65877, 65867, 65647, 65657, 79817, 79787, 79125, 79818, 79820, 79790, 79128, 
79821, 79819, 79788, 79096, 79127
19444, 65877, 65867, 65647, 65657, 65878, 65868, 65648, 65658, 79820, 79790, 79128, 79821, 79823, 79793, 79131, 
79824, 79822, 79791, 79099, 79130
19445, 65878, 65868, 65648, 65658, 65879, 65869, 65649, 65659, 79823, 79793, 79131, 79824, 79826, 79796, 79134, 
79827, 79825, 79794, 79102, 79133
19446, 65879, 65869, 65649, 65659, 65880, 65870, 65650, 65660, 79826, 79796, 79134, 79827, 79829, 79799, 79137, 
79830, 79828, 79797, 79105, 79136
19447, 65880, 65870, 65650, 65660, 65881, 65871, 65651, 65661, 79829, 79799, 79137, 79830, 79832, 79802, 79140, 
79833, 79831, 79800, 79108, 79139
19448, 65881, 65871, 65651, 65661, 65882, 65872, 65652, 65662, 79832, 79802, 79140, 79833, 79835, 79805, 79143, 
79836, 79834, 79803, 79111, 79142
19449, 65882, 65872, 65652, 65662, 18359, 18358, 18336, 18337, 79835, 79805, 79143, 79836, 19287, 19284, 19242, 
19286, 79837, 79806, 79114, 79145
19450, 16864, 16863, 16841, 16842, 65883, 65873, 65653, 65663, 17792, 17791, 17747, 17793, 79839, 79809, 79147, 
79840, 79838, 79807, 79115, 79146
19451, 65883, 65873, 65653, 65663, 65884, 65874, 65654, 65664, 79839, 79809, 79147, 79840, 79842, 79812, 79150, 
79843, 79841, 79810, 79118, 79149
19452, 65884, 65874, 65654, 65664, 65885, 65875, 65655, 65665, 79842, 79812, 79150, 79843, 79845, 79815, 79153, 
79846, 79844, 79813, 79121, 79152
19453, 65885, 65875, 65655, 65665, 65886, 65876, 65656, 65666, 79845, 79815, 79153, 79846, 79848, 79818, 79156, 
79849, 79847, 79816, 79124, 79155
19454, 65886, 65876, 65656, 65666, 65887, 65877, 65657, 65667, 79848, 79818, 79156, 79849, 79851, 79821, 79159, 
79852, 79850, 79819, 79127, 79158
19455, 65887, 65877, 65657, 65667, 65888, 65878, 65658, 65668, 79851, 79821, 79159, 79852, 79854, 79824, 79162, 
79855, 79853, 79822, 79130, 79161
19456, 65888, 65878, 65658, 65668, 65889, 65879, 65659, 65669, 79854, 79824, 79162, 79855, 79857, 79827, 79165, 
79858, 79856, 79825, 79133, 79164
19457, 65889, 65879, 65659, 65669, 65890, 65880, 65660, 65670, 79857, 79827, 79165, 79858, 79860, 79830, 79168, 
79861, 79859, 79828, 79136, 79167
19458, 65890, 65880, 65660, 65670, 65891, 65881, 65661, 65671, 79860, 79830, 79168, 79861, 79863, 79833, 79171, 
79864, 79862, 79831, 79139, 79170
19459, 65891, 65881, 65661, 65671, 65892, 65882, 65662, 65672, 79863, 79833, 79171, 79864, 79866, 79836, 79174, 
79867, 79865, 79834, 79142, 79173
19460, 65892, 65882, 65662, 65672, 18360, 18359, 18337, 18338, 79866, 79836, 79174, 79867, 19289, 19286, 19244, 
19288, 79868, 79837, 79145, 79176
19461, 16865, 16864, 16842, 16843, 65893, 65883, 65663, 65673, 17794, 17793, 17749, 17795, 79870, 79840, 79178, 
79871, 79869, 79838, 79146, 79177
19462, 65893, 65883, 65663, 65673, 65894, 65884, 65664, 65674, 79870, 79840, 79178, 79871, 79873, 79843, 79181, 
79874, 79872, 79841, 79149, 79180
19463, 65894, 65884, 65664, 65674, 65895, 65885, 65665, 65675, 79873, 79843, 79181, 79874, 79876, 79846, 79184, 
79877, 79875, 79844, 79152, 79183
19464, 65895, 65885, 65665, 65675, 65896, 65886, 65666, 65676, 79876, 79846, 79184, 79877, 79879, 79849, 79187, 
79880, 79878, 79847, 79155, 79186
19465, 65896, 65886, 65666, 65676, 65897, 65887, 65667, 65677, 79879, 79849, 79187, 79880, 79882, 79852, 79190, 
79883, 79881, 79850, 79158, 79189
19466, 65897, 65887, 65667, 65677, 65898, 65888, 65668, 65678, 79882, 79852, 79190, 79883, 79885, 79855, 79193, 
79886, 79884, 79853, 79161, 79192
19467, 65898, 65888, 65668, 65678, 65899, 65889, 65669, 65679, 79885, 79855, 79193, 79886, 79888, 79858, 79196, 
79889, 79887, 79856, 79164, 79195
19468, 65899, 65889, 65669, 65679, 65900, 65890, 65670, 65680, 79888, 79858, 79196, 79889, 79891, 79861, 79199, 
79892, 79890, 79859, 79167, 79198
19469, 65900, 65890, 65670, 65680, 65901, 65891, 65671, 65681, 79891, 79861, 79199, 79892, 79894, 79864, 79202, 
79895, 79893, 79862, 79170, 79201
19470, 65901, 65891, 65671, 65681, 65902, 65892, 65672, 65682, 79894, 79864, 79202, 79895, 79897, 79867, 79205, 
79898, 79896, 79865, 79173, 79204
19471, 65902, 65892, 65672, 65682, 18361, 18360, 18338, 18339, 79897, 79867, 79205, 79898, 19291, 19288, 19246, 
19290, 79899, 79868, 79176, 79207
19472, 16866, 16865, 16843, 16844, 65903, 65893, 65673, 65683, 17796, 17795, 17751, 17797, 79901, 79871, 79209, 
79902, 79900, 79869, 79177, 79208
19473, 65903, 65893, 65673, 65683, 65904, 65894, 65674, 65684, 79901, 79871, 79209, 79902, 79904, 79874, 79212, 
79905, 79903, 79872, 79180, 79211
19474, 65904, 65894, 65674, 65684, 65905, 65895, 65675, 65685, 79904, 79874, 79212, 79905, 79907, 79877, 79215, 
79908, 79906, 79875, 79183, 79214
19475, 65905, 65895, 65675, 65685, 65906, 65896, 65676, 65686, 79907, 79877, 79215, 79908, 79910, 79880, 79218, 
79911, 79909, 79878, 79186, 79217
19476, 65906, 65896, 65676, 65686, 65907, 65897, 65677, 65687, 79910, 79880, 79218, 79911, 79913, 79883, 79221, 
79914, 79912, 79881, 79189, 79220
19477, 65907, 65897, 65677, 65687, 65908, 65898, 65678, 65688, 79913, 79883, 79221, 79914, 79916, 79886, 79224, 
79917, 79915, 79884, 79192, 79223
19478, 65908, 65898, 65678, 65688, 65909, 65899, 65679, 65689, 79916, 79886, 79224, 79917, 79919, 79889, 79227, 
79920, 79918, 79887, 79195, 79226
19479, 65909, 65899, 65679, 65689, 65910, 65900, 65680, 65690, 79919, 79889, 79227, 79920, 79922, 79892, 79230, 
79923, 79921, 79890, 79198, 79229
19480, 65910, 65900, 65680, 65690, 65911, 65901, 65681, 65691, 79922, 79892, 79230, 79923, 79925, 79895, 79233, 
79926, 79924, 79893, 79201, 79232
19481, 65911, 65901, 65681, 65691, 65912, 65902, 65682, 65692, 79925, 79895, 79233, 79926, 79928, 79898, 79236, 
79929, 79927, 79896, 79204, 79235
19482, 65912, 65902, 65682, 65692, 18362, 18361, 18339, 18340, 79928, 79898, 79236, 79929, 19293, 19290, 19248, 
19292, 79930, 79899, 79207, 79238
19483, 16867, 16866, 16844, 16845, 65913, 65903, 65683, 65693, 17798, 17797, 17753, 17799, 79932, 79902, 79240, 
79933, 79931, 79900, 79208, 79239
19484, 65913, 65903, 65683, 65693, 65914, 65904, 65684, 65694, 79932, 79902, 79240, 79933, 79935, 79905, 79243, 
79936, 79934, 79903, 79211, 79242
19485, 65914, 65904, 65684, 65694, 65915, 65905, 65685, 65695, 79935, 79905, 79243, 79936, 79938, 79908, 79246, 
79939, 79937, 79906, 79214, 79245
19486, 65915, 65905, 65685, 65695, 65916, 65906, 65686, 65696, 79938, 79908, 79246, 79939, 79941, 79911, 79249, 
79942, 79940, 79909, 79217, 79248
19487, 65916, 65906, 65686, 65696, 65917, 65907, 65687, 65697, 79941, 79911, 79249, 79942, 79944, 79914, 79252, 
79945, 79943, 79912, 79220, 79251
19488, 65917, 65907, 65687, 65697, 65918, 65908, 65688, 65698, 79944, 79914, 79252, 79945, 79947, 79917, 79255, 
79948, 79946, 79915, 79223, 79254
19489, 65918, 65908, 65688, 65698, 65919, 65909, 65689, 65699, 79947, 79917, 79255, 79948, 79950, 79920, 79258, 
79951, 79949, 79918, 79226, 79257
19490, 65919, 65909, 65689, 65699, 65920, 65910, 65690, 65700, 79950, 79920, 79258, 79951, 79953, 79923, 79261, 
79954, 79952, 79921, 79229, 79260
19491, 65920, 65910, 65690, 65700, 65921, 65911, 65691, 65701, 79953, 79923, 79261, 79954, 79956, 79926, 79264, 
79957, 79955, 79924, 79232, 79263
19492, 65921, 65911, 65691, 65701, 65922, 65912, 65692, 65702, 79956, 79926, 79264, 79957, 79959, 79929, 79267, 
79960, 79958, 79927, 79235, 79266
19493, 65922, 65912, 65692, 65702, 18363, 18362, 18340, 18341, 79959, 79929, 79267, 79960, 19295, 19292, 19250, 
19294, 79961, 79930, 79238, 79269
19494, 16868, 16867, 16845, 16846, 65923, 65913, 65693, 65703, 17800, 17799, 17755, 17801, 79963, 79933, 79271, 
79964, 79962, 79931, 79239, 79270
19495, 65923, 65913, 65693, 65703, 65924, 65914, 65694, 65704, 79963, 79933, 79271, 79964, 79966, 79936, 79274, 
79967, 79965, 79934, 79242, 79273
19496, 65924, 65914, 65694, 65704, 65925, 65915, 65695, 65705, 79966, 79936, 79274, 79967, 79969, 79939, 79277, 
79970, 79968, 79937, 79245, 79276
19497, 65925, 65915, 65695, 65705, 65926, 65916, 65696, 65706, 79969, 79939, 79277, 79970, 79972, 79942, 79280, 
79973, 79971, 79940, 79248, 79279
19498, 65926, 65916, 65696, 65706, 65927, 65917, 65697, 65707, 79972, 79942, 79280, 79973, 79975, 79945, 79283, 
79976, 79974, 79943, 79251, 79282
19499, 65927, 65917, 65697, 65707, 65928, 65918, 65698, 65708, 79975, 79945, 79283, 79976, 79978, 79948, 79286, 
79979, 79977, 79946, 79254, 79285
19500, 65928, 65918, 65698, 65708, 65929, 65919, 65699, 65709, 79978, 79948, 79286, 79979, 79981, 79951, 79289, 
79982, 79980, 79949, 79257, 79288
19501, 65929, 65919, 65699, 65709, 65930, 65920, 65700, 65710, 79981, 79951, 79289, 79982, 79984, 79954, 79292, 
79985, 79983, 79952, 79260, 79291
19502, 65930, 65920, 65700, 65710, 65931, 65921, 65701, 65711, 79984, 79954, 79292, 79985, 79987, 79957, 79295, 
79988, 79986, 79955, 79263, 79294
19503, 65931, 65921, 65701, 65711, 65932, 65922, 65702, 65712, 79987, 79957, 79295, 79988, 79990, 79960, 79298, 
79991, 79989, 79958, 79266, 79297
19504, 65932, 65922, 65702, 65712, 18364, 18363, 18341, 18342, 79990, 79960, 79298, 79991, 19297, 19294, 19252, 
19296, 79992, 79961, 79269, 79300
19505, 16869, 16868, 16846, 16847, 65933, 65923, 65703, 65713, 17802, 17801, 17757, 17803, 79994, 79964, 79302, 
79995, 79993, 79962, 79270, 79301
19506, 65933, 65923, 65703, 65713, 65934, 65924, 65704, 65714, 79994, 79964, 79302, 79995, 79997, 79967, 79305, 
79998, 79996, 79965, 79273, 79304
19507, 65934, 65924, 65704, 65714, 65935, 65925, 65705, 65715, 79997, 79967, 79305, 79998, 80000, 79970, 79308, 
80001, 79999, 79968, 79276, 79307
19508, 65935, 65925, 65705, 65715, 65936, 65926, 65706, 65716, 80000, 79970, 79308, 80001, 80003, 79973, 79311, 
80004, 80002, 79971, 79279, 79310
19509, 65936, 65926, 65706, 65716, 65937, 65927, 65707, 65717, 80003, 79973, 79311, 80004, 80006, 79976, 79314, 
80007, 80005, 79974, 79282, 79313
19510, 65937, 65927, 65707, 65717, 65938, 65928, 65708, 65718, 80006, 79976, 79314, 80007, 80009, 79979, 79317, 
80010, 80008, 79977, 79285, 79316
19511, 65938, 65928, 65708, 65718, 65939, 65929, 65709, 65719, 80009, 79979, 79317, 80010, 80012, 79982, 79320, 
80013, 80011, 79980, 79288, 79319
19512, 65939, 65929, 65709, 65719, 65940, 65930, 65710, 65720, 80012, 79982, 79320, 80013, 80015, 79985, 79323, 
80016, 80014, 79983, 79291, 79322
19513, 65940, 65930, 65710, 65720, 65941, 65931, 65711, 65721, 80015, 79985, 79323, 80016, 80018, 79988, 79326, 
80019, 80017, 79986, 79294, 79325
19514, 65941, 65931, 65711, 65721, 65942, 65932, 65712, 65722, 80018, 79988, 79326, 80019, 80021, 79991, 79329, 
80022, 80020, 79989, 79297, 79328
19515, 65942, 65932, 65712, 65722, 18365, 18364, 18342, 18343, 80021, 79991, 79329, 80022, 19299, 19296, 19254, 
19298, 80023, 79992, 79300, 79331
19516, 16870, 16869, 16847, 16848, 65943, 65933, 65713, 65723, 17804, 17803, 17759, 17805, 80025, 79995, 79333, 
80026, 80024, 79993, 79301, 79332
19517, 65943, 65933, 65713, 65723, 65944, 65934, 65714, 65724, 80025, 79995, 79333, 80026, 80028, 79998, 79336, 
80029, 80027, 79996, 79304, 79335
19518, 65944, 65934, 65714, 65724, 65945, 65935, 65715, 65725, 80028, 79998, 79336, 80029, 80031, 80001, 79339, 
80032, 80030, 79999, 79307, 79338
19519, 65945, 65935, 65715, 65725, 65946, 65936, 65716, 65726, 80031, 80001, 79339, 80032, 80034, 80004, 79342, 
80035, 80033, 80002, 79310, 79341
19520, 65946, 65936, 65716, 65726, 65947, 65937, 65717, 65727, 80034, 80004, 79342, 80035, 80037, 80007, 79345, 
80038, 80036, 80005, 79313, 79344
19521, 65947, 65937, 65717, 65727, 65948, 65938, 65718, 65728, 80037, 80007, 79345, 80038, 80040, 80010, 79348, 
80041, 80039, 80008, 79316, 79347
19522, 65948, 65938, 65718, 65728, 65949, 65939, 65719, 65729, 80040, 80010, 79348, 80041, 80043, 80013, 79351, 
80044, 80042, 80011, 79319, 79350
19523, 65949, 65939, 65719, 65729, 65950, 65940, 65720, 65730, 80043, 80013, 79351, 80044, 80046, 80016, 79354, 
80047, 80045, 80014, 79322, 79353
19524, 65950, 65940, 65720, 65730, 65951, 65941, 65721, 65731, 80046, 80016, 79354, 80047, 80049, 80019, 79357, 
80050, 80048, 80017, 79325, 79356
19525, 65951, 65941, 65721, 65731, 65952, 65942, 65722, 65732, 80049, 80019, 79357, 80050, 80052, 80022, 79360, 
80053, 80051, 80020, 79328, 79359
19526, 65952, 65942, 65722, 65732, 18366, 18365, 18343, 18344, 80052, 80022, 79360, 80053, 19301, 19298, 19256, 
19300, 80054, 80023, 79331, 79362
19527, 16871, 16870, 16848, 16849, 65953, 65943, 65723, 65733, 17806, 17805, 17761, 17807, 80056, 80026, 79364, 
80057, 80055, 80024, 79332, 79363
19528, 65953, 65943, 65723, 65733, 65954, 65944, 65724, 65734, 80056, 80026, 79364, 80057, 80059, 80029, 79367, 
80060, 80058, 80027, 79335, 79366
19529, 65954, 65944, 65724, 65734, 65955, 65945, 65725, 65735, 80059, 80029, 79367, 80060, 80062, 80032, 79370, 
80063, 80061, 80030, 79338, 79369
19530, 65955, 65945, 65725, 65735, 65956, 65946, 65726, 65736, 80062, 80032, 79370, 80063, 80065, 80035, 79373, 
80066, 80064, 80033, 79341, 79372
19531, 65956, 65946, 65726, 65736, 65957, 65947, 65727, 65737, 80065, 80035, 79373, 80066, 80068, 80038, 79376, 
80069, 80067, 80036, 79344, 79375
19532, 65957, 65947, 65727, 65737, 65958, 65948, 65728, 65738, 80068, 80038, 79376, 80069, 80071, 80041, 79379, 
80072, 80070, 80039, 79347, 79378
19533, 65958, 65948, 65728, 65738, 65959, 65949, 65729, 65739, 80071, 80041, 79379, 80072, 80074, 80044, 79382, 
80075, 80073, 80042, 79350, 79381
19534, 65959, 65949, 65729, 65739, 65960, 65950, 65730, 65740, 80074, 80044, 79382, 80075, 80077, 80047, 79385, 
80078, 80076, 80045, 79353, 79384
19535, 65960, 65950, 65730, 65740, 65961, 65951, 65731, 65741, 80077, 80047, 79385, 80078, 80080, 80050, 79388, 
80081, 80079, 80048, 79356, 79387
19536, 65961, 65951, 65731, 65741, 65962, 65952, 65732, 65742, 80080, 80050, 79388, 80081, 80083, 80053, 79391, 
80084, 80082, 80051, 79359, 79390
19537, 65962, 65952, 65732, 65742, 18367, 18366, 18344, 18345, 80083, 80053, 79391, 80084, 19303, 19300, 19258, 
19302, 80085, 80054, 79362, 79393
19538, 16872, 16871, 16849, 16850, 65963, 65953, 65733, 65743, 17808, 17807, 17763, 17809, 80087, 80057, 79395, 
80088, 80086, 80055, 79363, 79394
19539, 65963, 65953, 65733, 65743, 65964, 65954, 65734, 65744, 80087, 80057, 79395, 80088, 80090, 80060, 79398, 
80091, 80089, 80058, 79366, 79397
19540, 65964, 65954, 65734, 65744, 65965, 65955, 65735, 65745, 80090, 80060, 79398, 80091, 80093, 80063, 79401, 
80094, 80092, 80061, 79369, 79400
19541, 65965, 65955, 65735, 65745, 65966, 65956, 65736, 65746, 80093, 80063, 79401, 80094, 80096, 80066, 79404, 
80097, 80095, 80064, 79372, 79403
19542, 65966, 65956, 65736, 65746, 65967, 65957, 65737, 65747, 80096, 80066, 79404, 80097, 80099, 80069, 79407, 
80100, 80098, 80067, 79375, 79406
19543, 65967, 65957, 65737, 65747, 65968, 65958, 65738, 65748, 80099, 80069, 79407, 80100, 80102, 80072, 79410, 
80103, 80101, 80070, 79378, 79409
19544, 65968, 65958, 65738, 65748, 65969, 65959, 65739, 65749, 80102, 80072, 79410, 80103, 80105, 80075, 79413, 
80106, 80104, 80073, 79381, 79412
19545, 65969, 65959, 65739, 65749, 65970, 65960, 65740, 65750, 80105, 80075, 79413, 80106, 80108, 80078, 79416, 
80109, 80107, 80076, 79384, 79415
19546, 65970, 65960, 65740, 65750, 65971, 65961, 65741, 65751, 80108, 80078, 79416, 80109, 80111, 80081, 79419, 
80112, 80110, 80079, 79387, 79418
19547, 65971, 65961, 65741, 65751, 65972, 65962, 65742, 65752, 80111, 80081, 79419, 80112, 80114, 80084, 79422, 
80115, 80113, 80082, 79390, 79421
19548, 65972, 65962, 65742, 65752, 18368, 18367, 18345, 18346, 80114, 80084, 79422, 80115, 19305, 19302, 19260, 
19304, 80116, 80085, 79393, 79424
19549, 16873, 16872, 16850, 16851, 65973, 65963, 65743, 65753, 17810, 17809, 17765, 17811, 80118, 80088, 79426, 
80119, 80117, 80086, 79394, 79425
19550, 65973, 65963, 65743, 65753, 65974, 65964, 65744, 65754, 80118, 80088, 79426, 80119, 80121, 80091, 79429, 
80122, 80120, 80089, 79397, 79428
19551, 65974, 65964, 65744, 65754, 65975, 65965, 65745, 65755, 80121, 80091, 79429, 80122, 80124, 80094, 79432, 
80125, 80123, 80092, 79400, 79431
19552, 65975, 65965, 65745, 65755, 65976, 65966, 65746, 65756, 80124, 80094, 79432, 80125, 80127, 80097, 79435, 
80128, 80126, 80095, 79403, 79434
19553, 65976, 65966, 65746, 65756, 65977, 65967, 65747, 65757, 80127, 80097, 79435, 80128, 80130, 80100, 79438, 
80131, 80129, 80098, 79406, 79437
19554, 65977, 65967, 65747, 65757, 65978, 65968, 65748, 65758, 80130, 80100, 79438, 80131, 80133, 80103, 79441, 
80134, 80132, 80101, 79409, 79440
19555, 65978, 65968, 65748, 65758, 65979, 65969, 65749, 65759, 80133, 80103, 79441, 80134, 80136, 80106, 79444, 
80137, 80135, 80104, 79412, 79443
19556, 65979, 65969, 65749, 65759, 65980, 65970, 65750, 65760, 80136, 80106, 79444, 80137, 80139, 80109, 79447, 
80140, 80138, 80107, 79415, 79446
19557, 65980, 65970, 65750, 65760, 65981, 65971, 65751, 65761, 80139, 80109, 79447, 80140, 80142, 80112, 79450, 
80143, 80141, 80110, 79418, 79449
19558, 65981, 65971, 65751, 65761, 65982, 65972, 65752, 65762, 80142, 80112, 79450, 80143, 80145, 80115, 79453, 
80146, 80144, 80113, 79421, 79452
19559, 65982, 65972, 65752, 65762, 18369, 18368, 18346, 18347, 80145, 80115, 79453, 80146, 19307, 19304, 19262, 
19306, 80147, 80116, 79424, 79455
19560, 16874, 16873, 16851, 16852, 65983, 65973, 65753, 65763, 17812, 17811, 17767, 17813, 80149, 80119, 79457, 
80150, 80148, 80117, 79425, 79456
19561, 65983, 65973, 65753, 65763, 65984, 65974, 65754, 65764, 80149, 80119, 79457, 80150, 80152, 80122, 79460, 
80153, 80151, 80120, 79428, 79459
19562, 65984, 65974, 65754, 65764, 65985, 65975, 65755, 65765, 80152, 80122, 79460, 80153, 80155, 80125, 79463, 
80156, 80154, 80123, 79431, 79462
19563, 65985, 65975, 65755, 65765, 65986, 65976, 65756, 65766, 80155, 80125, 79463, 80156, 80158, 80128, 79466, 
80159, 80157, 80126, 79434, 79465
19564, 65986, 65976, 65756, 65766, 65987, 65977, 65757, 65767, 80158, 80128, 79466, 80159, 80161, 80131, 79469, 
80162, 80160, 80129, 79437, 79468
19565, 65987, 65977, 65757, 65767, 65988, 65978, 65758, 65768, 80161, 80131, 79469, 80162, 80164, 80134, 79472, 
80165, 80163, 80132, 79440, 79471
19566, 65988, 65978, 65758, 65768, 65989, 65979, 65759, 65769, 80164, 80134, 79472, 80165, 80167, 80137, 79475, 
80168, 80166, 80135, 79443, 79474
19567, 65989, 65979, 65759, 65769, 65990, 65980, 65760, 65770, 80167, 80137, 79475, 80168, 80170, 80140, 79478, 
80171, 80169, 80138, 79446, 79477
19568, 65990, 65980, 65760, 65770, 65991, 65981, 65761, 65771, 80170, 80140, 79478, 80171, 80173, 80143, 79481, 
80174, 80172, 80141, 79449, 79480
19569, 65991, 65981, 65761, 65771, 65992, 65982, 65762, 65772, 80173, 80143, 79481, 80174, 80176, 80146, 79484, 
80177, 80175, 80144, 79452, 79483
19570, 65992, 65982, 65762, 65772, 18370, 18369, 18347, 18348, 80176, 80146, 79484, 80177, 19309, 19306, 19264, 
19308, 80178, 80147, 79455, 79486
19571, 16875, 16874, 16852, 16853, 65993, 65983, 65763, 65773, 17814, 17813, 17769, 17815, 80180, 80150, 79488, 
80181, 80179, 80148, 79456, 79487
19572, 65993, 65983, 65763, 65773, 65994, 65984, 65764, 65774, 80180, 80150, 79488, 80181, 80183, 80153, 79491, 
80184, 80182, 80151, 79459, 79490
19573, 65994, 65984, 65764, 65774, 65995, 65985, 65765, 65775, 80183, 80153, 79491, 80184, 80186, 80156, 79494, 
80187, 80185, 80154, 79462, 79493
19574, 65995, 65985, 65765, 65775, 65996, 65986, 65766, 65776, 80186, 80156, 79494, 80187, 80189, 80159, 79497, 
80190, 80188, 80157, 79465, 79496
19575, 65996, 65986, 65766, 65776, 65997, 65987, 65767, 65777, 80189, 80159, 79497, 80190, 80192, 80162, 79500, 
80193, 80191, 80160, 79468, 79499
19576, 65997, 65987, 65767, 65777, 65998, 65988, 65768, 65778, 80192, 80162, 79500, 80193, 80195, 80165, 79503, 
80196, 80194, 80163, 79471, 79502
19577, 65998, 65988, 65768, 65778, 65999, 65989, 65769, 65779, 80195, 80165, 79503, 80196, 80198, 80168, 79506, 
80199, 80197, 80166, 79474, 79505
19578, 65999, 65989, 65769, 65779, 66000, 65990, 65770, 65780, 80198, 80168, 79506, 80199, 80201, 80171, 79509, 
80202, 80200, 80169, 79477, 79508
19579, 66000, 65990, 65770, 65780, 66001, 65991, 65771, 65781, 80201, 80171, 79509, 80202, 80204, 80174, 79512, 
80205, 80203, 80172, 79480, 79511
19580, 66001, 65991, 65771, 65781, 66002, 65992, 65772, 65782, 80204, 80174, 79512, 80205, 80207, 80177, 79515, 
80208, 80206, 80175, 79483, 79514
19581, 66002, 65992, 65772, 65782, 18371, 18370, 18348, 18349, 80207, 80177, 79515, 80208, 19311, 19308, 19266, 
19310, 80209, 80178, 79486, 79517
19582, 16876, 16875, 16853, 16854, 66003, 65993, 65773, 65783, 17816, 17815, 17771, 17817, 80211, 80181, 79519, 
80212, 80210, 80179, 79487, 79518
19583, 66003, 65993, 65773, 65783, 66004, 65994, 65774, 65784, 80211, 80181, 79519, 80212, 80214, 80184, 79522, 
80215, 80213, 80182, 79490, 79521
19584, 66004, 65994, 65774, 65784, 66005, 65995, 65775, 65785, 80214, 80184, 79522, 80215, 80217, 80187, 79525, 
80218, 80216, 80185, 79493, 79524
19585, 66005, 65995, 65775, 65785, 66006, 65996, 65776, 65786, 80217, 80187, 79525, 80218, 80220, 80190, 79528, 
80221, 80219, 80188, 79496, 79527
19586, 66006, 65996, 65776, 65786, 66007, 65997, 65777, 65787, 80220, 80190, 79528, 80221, 80223, 80193, 79531, 
80224, 80222, 80191, 79499, 79530
19587, 66007, 65997, 65777, 65787, 66008, 65998, 65778, 65788, 80223, 80193, 79531, 80224, 80226, 80196, 79534, 
80227, 80225, 80194, 79502, 79533
19588, 66008, 65998, 65778, 65788, 66009, 65999, 65779, 65789, 80226, 80196, 79534, 80227, 80229, 80199, 79537, 
80230, 80228, 80197, 79505, 79536
19589, 66009, 65999, 65779, 65789, 66010, 66000, 65780, 65790, 80229, 80199, 79537, 80230, 80232, 80202, 79540, 
80233, 80231, 80200, 79508, 79539
19590, 66010, 66000, 65780, 65790, 66011, 66001, 65781, 65791, 80232, 80202, 79540, 80233, 80235, 80205, 79543, 
80236, 80234, 80203, 79511, 79542
19591, 66011, 66001, 65781, 65791, 66012, 66002, 65782, 65792, 80235, 80205, 79543, 80236, 80238, 80208, 79546, 
80239, 80237, 80206, 79514, 79545
19592, 66012, 66002, 65782, 65792, 18372, 18371, 18349, 18350, 80238, 80208, 79546, 80239, 19313, 19310, 19268, 
19312, 80240, 80209, 79517, 79548
19593, 16877, 16876, 16854, 16855, 66013, 66003, 65783, 65793, 17818, 17817, 17773, 17819, 80242, 80212, 79550, 
80243, 80241, 80210, 79518, 79549
19594, 66013, 66003, 65783, 65793, 66014, 66004, 65784, 65794, 80242, 80212, 79550, 80243, 80245, 80215, 79553, 
80246, 80244, 80213, 79521, 79552
19595, 66014, 66004, 65784, 65794, 66015, 66005, 65785, 65795, 80245, 80215, 79553, 80246, 80248, 80218, 79556, 
80249, 80247, 80216, 79524, 79555
19596, 66015, 66005, 65785, 65795, 66016, 66006, 65786, 65796, 80248, 80218, 79556, 80249, 80251, 80221, 79559, 
80252, 80250, 80219, 79527, 79558
19597, 66016, 66006, 65786, 65796, 66017, 66007, 65787, 65797, 80251, 80221, 79559, 80252, 80254, 80224, 79562, 
80255, 80253, 80222, 79530, 79561
19598, 66017, 66007, 65787, 65797, 66018, 66008, 65788, 65798, 80254, 80224, 79562, 80255, 80257, 80227, 79565, 
80258, 80256, 80225, 79533, 79564
19599, 66018, 66008, 65788, 65798, 66019, 66009, 65789, 65799, 80257, 80227, 79565, 80258, 80260, 80230, 79568, 
80261, 80259, 80228, 79536, 79567
19600, 66019, 66009, 65789, 65799, 66020, 66010, 65790, 65800, 80260, 80230, 79568, 80261, 80263, 80233, 79571, 
80264, 80262, 80231, 79539, 79570
19601, 66020, 66010, 65790, 65800, 66021, 66011, 65791, 65801, 80263, 80233, 79571, 80264, 80266, 80236, 79574, 
80267, 80265, 80234, 79542, 79573
19602, 66021, 66011, 65791, 65801, 66022, 66012, 65792, 65802, 80266, 80236, 79574, 80267, 80269, 80239, 79577, 
80270, 80268, 80237, 79545, 79576
19603, 66022, 66012, 65792, 65802, 18373, 18372, 18350, 18351, 80269, 80239, 79577, 80270, 19315, 19312, 19270, 
19314, 80271, 80240, 79548, 79579
19604, 16878, 16877, 16855, 16856, 66023, 66013, 65793, 65803, 17820, 17819, 17775, 17821, 80273, 80243, 79581, 
80274, 80272, 80241, 79549, 79580
19605, 66023, 66013, 65793, 65803, 66024, 66014, 65794, 65804, 80273, 80243, 79581, 80274, 80276, 80246, 79584, 
80277, 80275, 80244, 79552, 79583
19606, 66024, 66014, 65794, 65804, 66025, 66015, 65795, 65805, 80276, 80246, 79584, 80277, 80279, 80249, 79587, 
80280, 80278, 80247, 79555, 79586
19607, 66025, 66015, 65795, 65805, 66026, 66016, 65796, 65806, 80279, 80249, 79587, 80280, 80282, 80252, 79590, 
80283, 80281, 80250, 79558, 79589
19608, 66026, 66016, 65796, 65806, 66027, 66017, 65797, 65807, 80282, 80252, 79590, 80283, 80285, 80255, 79593, 
80286, 80284, 80253, 79561, 79592
19609, 66027, 66017, 65797, 65807, 66028, 66018, 65798, 65808, 80285, 80255, 79593, 80286, 80288, 80258, 79596, 
80289, 80287, 80256, 79564, 79595
19610, 66028, 66018, 65798, 65808, 66029, 66019, 65799, 65809, 80288, 80258, 79596, 80289, 80291, 80261, 79599, 
80292, 80290, 80259, 79567, 79598
19611, 66029, 66019, 65799, 65809, 66030, 66020, 65800, 65810, 80291, 80261, 79599, 80292, 80294, 80264, 79602, 
80295, 80293, 80262, 79570, 79601
19612, 66030, 66020, 65800, 65810, 66031, 66021, 65801, 65811, 80294, 80264, 79602, 80295, 80297, 80267, 79605, 
80298, 80296, 80265, 79573, 79604
19613, 66031, 66021, 65801, 65811, 66032, 66022, 65802, 65812, 80297, 80267, 79605, 80298, 80300, 80270, 79608, 
80301, 80299, 80268, 79576, 79607
19614, 66032, 66022, 65802, 65812, 18374, 18373, 18351, 18352, 80300, 80270, 79608, 80301, 19317, 19314, 19272, 
19316, 80302, 80271, 79579, 79610
19615, 1653, 16878, 16856, 1652, 20313, 66023, 65803, 20303, 17822, 17821, 17777, 1675, 80303, 80274, 79611, 
20743, 20742, 80272, 79580, 20721
19616, 20313, 66023, 65803, 20303, 20314, 66024, 65804, 20304, 80303, 80274, 79611, 20743, 80304, 80277, 79612, 
20745, 20744, 80275, 79583, 20723
19617, 20314, 66024, 65804, 20304, 20315, 66025, 65805, 20305, 80304, 80277, 79612, 20745, 80305, 80280, 79613, 
20747, 20746, 80278, 79586, 20725
19618, 20315, 66025, 65805, 20305, 20316, 66026, 65806, 20306, 80305, 80280, 79613, 20747, 80306, 80283, 79614, 
20749, 20748, 80281, 79589, 20727
19619, 20316, 66026, 65806, 20306, 20317, 66027, 65807, 20307, 80306, 80283, 79614, 20749, 80307, 80286, 79615, 
20751, 20750, 80284, 79592, 20729
19620, 20317, 66027, 65807, 20307, 20318, 66028, 65808, 20308, 80307, 80286, 79615, 20751, 80308, 80289, 79616, 
20753, 20752, 80287, 79595, 20731
19621, 20318, 66028, 65808, 20308, 20319, 66029, 65809, 20309, 80308, 80289, 79616, 20753, 80309, 80292, 79617, 
20755, 20754, 80290, 79598, 20733
19622, 20319, 66029, 65809, 20309, 20320, 66030, 65810, 20310, 80309, 80292, 79617, 20755, 80310, 80295, 79618, 
20757, 20756, 80293, 79601, 20735
19623, 20320, 66030, 65810, 20310, 20321, 66031, 65811, 20311, 80310, 80295, 79618, 20757, 80311, 80298, 79619, 
20759, 20758, 80296, 79604, 20737
19624, 20321, 66031, 65811, 20311, 20322, 66032, 65812, 20312, 80311, 80298, 79619, 20759, 80312, 80301, 79620, 
20761, 20760, 80299, 79607, 20739
19625, 20322, 66032, 65812, 20312, 1788, 18374, 18352, 1787, 80312, 80301, 79620, 20761, 19318, 19316, 19273, 
1810, 20762, 80302, 79610, 20741
19626, 16879, 1609, 1608, 16857, 66033, 19631, 19621, 65813, 17823, 1631, 17778, 17824, 80314, 20071, 79622, 
80315, 80313, 20072, 20051, 79621
19627, 66033, 19631, 19621, 65813, 66034, 19632, 19622, 65814, 80314, 20071, 79622, 80315, 80317, 20073, 79625, 
80318, 80316, 20074, 20053, 79624
19628, 66034, 19632, 19622, 65814, 66035, 19633, 19623, 65815, 80317, 20073, 79625, 80318, 80320, 20075, 79628, 
80321, 80319, 20076, 20055, 79627
19629, 66035, 19633, 19623, 65815, 66036, 19634, 19624, 65816, 80320, 20075, 79628, 80321, 80323, 20077, 79631, 
80324, 80322, 20078, 20057, 79630
19630, 66036, 19634, 19624, 65816, 66037, 19635, 19625, 65817, 80323, 20077, 79631, 80324, 80326, 20079, 79634, 
80327, 80325, 20080, 20059, 79633
19631, 66037, 19635, 19625, 65817, 66038, 19636, 19626, 65818, 80326, 20079, 79634, 80327, 80329, 20081, 79637, 
80330, 80328, 20082, 20061, 79636
19632, 66038, 19636, 19626, 65818, 66039, 19637, 19627, 65819, 80329, 20081, 79637, 80330, 80332, 20083, 79640, 
80333, 80331, 20084, 20063, 79639
19633, 66039, 19637, 19627, 65819, 66040, 19638, 19628, 65820, 80332, 20083, 79640, 80333, 80335, 20085, 79643, 
80336, 80334, 20086, 20065, 79642
19634, 66040, 19638, 19628, 65820, 66041, 19639, 19629, 65821, 80335, 20085, 79643, 80336, 80338, 20087, 79646, 
80339, 80337, 20088, 20067, 79645
19635, 66041, 19639, 19629, 65821, 66042, 19640, 19630, 65822, 80338, 20087, 79646, 80339, 80341, 20089, 79649, 
80342, 80340, 20090, 20069, 79648
19636, 66042, 19640, 19630, 65822, 18375, 1744, 1743, 18353, 80341, 20089, 79649, 80342, 19320, 1766, 19275, 
19319, 80343, 20091, 20070, 79651
19637, 16880, 16879, 16857, 16858, 66043, 66033, 65813, 65823, 17825, 17824, 17780, 17826, 80345, 80315, 79653, 
80346, 80344, 80313, 79621, 79652
19638, 66043, 66033, 65813, 65823, 66044, 66034, 65814, 65824, 80345, 80315, 79653, 80346, 80348, 80318, 79656, 
80349, 80347, 80316, 79624, 79655
19639, 66044, 66034, 65814, 65824, 66045, 66035, 65815, 65825, 80348, 80318, 79656, 80349, 80351, 80321, 79659, 
80352, 80350, 80319, 79627, 79658
19640, 66045, 66035, 65815, 65825, 66046, 66036, 65816, 65826, 80351, 80321, 79659, 80352, 80354, 80324, 79662, 
80355, 80353, 80322, 79630, 79661
19641, 66046, 66036, 65816, 65826, 66047, 66037, 65817, 65827, 80354, 80324, 79662, 80355, 80357, 80327, 79665, 
80358, 80356, 80325, 79633, 79664
19642, 66047, 66037, 65817, 65827, 66048, 66038, 65818, 65828, 80357, 80327, 79665, 80358, 80360, 80330, 79668, 
80361, 80359, 80328, 79636, 79667
19643, 66048, 66038, 65818, 65828, 66049, 66039, 65819, 65829, 80360, 80330, 79668, 80361, 80363, 80333, 79671, 
80364, 80362, 80331, 79639, 79670
19644, 66049, 66039, 65819, 65829, 66050, 66040, 65820, 65830, 80363, 80333, 79671, 80364, 80366, 80336, 79674, 
80367, 80365, 80334, 79642, 79673
19645, 66050, 66040, 65820, 65830, 66051, 66041, 65821, 65831, 80366, 80336, 79674, 80367, 80369, 80339, 79677, 
80370, 80368, 80337, 79645, 79676
19646, 66051, 66041, 65821, 65831, 66052, 66042, 65822, 65832, 80369, 80339, 79677, 80370, 80372, 80342, 79680, 
80373, 80371, 80340, 79648, 79679
19647, 66052, 66042, 65822, 65832, 18376, 18375, 18353, 18354, 80372, 80342, 79680, 80373, 19322, 19319, 19277, 
19321, 80374, 80343, 79651, 79682
19648, 16881, 16880, 16858, 16859, 66053, 66043, 65823, 65833, 17827, 17826, 17782, 17828, 80376, 80346, 79684, 
80377, 80375, 80344, 79652, 79683
19649, 66053, 66043, 65823, 65833, 66054, 66044, 65824, 65834, 80376, 80346, 79684, 80377, 80379, 80349, 79687, 
80380, 80378, 80347, 79655, 79686
19650, 66054, 66044, 65824, 65834, 66055, 66045, 65825, 65835, 80379, 80349, 79687, 80380, 80382, 80352, 79690, 
80383, 80381, 80350, 79658, 79689
19651, 66055, 66045, 65825, 65835, 66056, 66046, 65826, 65836, 80382, 80352, 79690, 80383, 80385, 80355, 79693, 
80386, 80384, 80353, 79661, 79692
19652, 66056, 66046, 65826, 65836, 66057, 66047, 65827, 65837, 80385, 80355, 79693, 80386, 80388, 80358, 79696, 
80389, 80387, 80356, 79664, 79695
19653, 66057, 66047, 65827, 65837, 66058, 66048, 65828, 65838, 80388, 80358, 79696, 80389, 80391, 80361, 79699, 
80392, 80390, 80359, 79667, 79698
19654, 66058, 66048, 65828, 65838, 66059, 66049, 65829, 65839, 80391, 80361, 79699, 80392, 80394, 80364, 79702, 
80395, 80393, 80362, 79670, 79701
19655, 66059, 66049, 65829, 65839, 66060, 66050, 65830, 65840, 80394, 80364, 79702, 80395, 80397, 80367, 79705, 
80398, 80396, 80365, 79673, 79704
19656, 66060, 66050, 65830, 65840, 66061, 66051, 65831, 65841, 80397, 80367, 79705, 80398, 80400, 80370, 79708, 
80401, 80399, 80368, 79676, 79707
19657, 66061, 66051, 65831, 65841, 66062, 66052, 65832, 65842, 80400, 80370, 79708, 80401, 80403, 80373, 79711, 
80404, 80402, 80371, 79679, 79710
19658, 66062, 66052, 65832, 65842, 18377, 18376, 18354, 18355, 80403, 80373, 79711, 80404, 19324, 19321, 19279, 
19323, 80405, 80374, 79682, 79713
19659, 16882, 16881, 16859, 16860, 66063, 66053, 65833, 65843, 17829, 17828, 17784, 17830, 80407, 80377, 79715, 
80408, 80406, 80375, 79683, 79714
19660, 66063, 66053, 65833, 65843, 66064, 66054, 65834, 65844, 80407, 80377, 79715, 80408, 80410, 80380, 79718, 
80411, 80409, 80378, 79686, 79717
19661, 66064, 66054, 65834, 65844, 66065, 66055, 65835, 65845, 80410, 80380, 79718, 80411, 80413, 80383, 79721, 
80414, 80412, 80381, 79689, 79720
19662, 66065, 66055, 65835, 65845, 66066, 66056, 65836, 65846, 80413, 80383, 79721, 80414, 80416, 80386, 79724, 
80417, 80415, 80384, 79692, 79723
19663, 66066, 66056, 65836, 65846, 66067, 66057, 65837, 65847, 80416, 80386, 79724, 80417, 80419, 80389, 79727, 
80420, 80418, 80387, 79695, 79726
19664, 66067, 66057, 65837, 65847, 66068, 66058, 65838, 65848, 80419, 80389, 79727, 80420, 80422, 80392, 79730, 
80423, 80421, 80390, 79698, 79729
19665, 66068, 66058, 65838, 65848, 66069, 66059, 65839, 65849, 80422, 80392, 79730, 80423, 80425, 80395, 79733, 
80426, 80424, 80393, 79701, 79732
19666, 66069, 66059, 65839, 65849, 66070, 66060, 65840, 65850, 80425, 80395, 79733, 80426, 80428, 80398, 79736, 
80429, 80427, 80396, 79704, 79735
19667, 66070, 66060, 65840, 65850, 66071, 66061, 65841, 65851, 80428, 80398, 79736, 80429, 80431, 80401, 79739, 
80432, 80430, 80399, 79707, 79738
19668, 66071, 66061, 65841, 65851, 66072, 66062, 65842, 65852, 80431, 80401, 79739, 80432, 80434, 80404, 79742, 
80435, 80433, 80402, 79710, 79741
19669, 66072, 66062, 65842, 65852, 18378, 18377, 18355, 18356, 80434, 80404, 79742, 80435, 19326, 19323, 19281, 
19325, 80436, 80405, 79713, 79744
19670, 16883, 16882, 16860, 16861, 66073, 66063, 65843, 65853, 17831, 17830, 17786, 17832, 80438, 80408, 79746, 
80439, 80437, 80406, 79714, 79745
19671, 66073, 66063, 65843, 65853, 66074, 66064, 65844, 65854, 80438, 80408, 79746, 80439, 80441, 80411, 79749, 
80442, 80440, 80409, 79717, 79748
19672, 66074, 66064, 65844, 65854, 66075, 66065, 65845, 65855, 80441, 80411, 79749, 80442, 80444, 80414, 79752, 
80445, 80443, 80412, 79720, 79751
19673, 66075, 66065, 65845, 65855, 66076, 66066, 65846, 65856, 80444, 80414, 79752, 80445, 80447, 80417, 79755, 
80448, 80446, 80415, 79723, 79754
19674, 66076, 66066, 65846, 65856, 66077, 66067, 65847, 65857, 80447, 80417, 79755, 80448, 80450, 80420, 79758, 
80451, 80449, 80418, 79726, 79757
19675, 66077, 66067, 65847, 65857, 66078, 66068, 65848, 65858, 80450, 80420, 79758, 80451, 80453, 80423, 79761, 
80454, 80452, 80421, 79729, 79760
19676, 66078, 66068, 65848, 65858, 66079, 66069, 65849, 65859, 80453, 80423, 79761, 80454, 80456, 80426, 79764, 
80457, 80455, 80424, 79732, 79763
19677, 66079, 66069, 65849, 65859, 66080, 66070, 65850, 65860, 80456, 80426, 79764, 80457, 80459, 80429, 79767, 
80460, 80458, 80427, 79735, 79766
19678, 66080, 66070, 65850, 65860, 66081, 66071, 65851, 65861, 80459, 80429, 79767, 80460, 80462, 80432, 79770, 
80463, 80461, 80430, 79738, 79769
19679, 66081, 66071, 65851, 65861, 66082, 66072, 65852, 65862, 80462, 80432, 79770, 80463, 80465, 80435, 79773, 
80466, 80464, 80433, 79741, 79772
19680, 66082, 66072, 65852, 65862, 18379, 18378, 18356, 18357, 80465, 80435, 79773, 80466, 19328, 19325, 19283, 
19327, 80467, 80436, 79744, 79775
19681, 16884, 16883, 16861, 16862, 66083, 66073, 65853, 65863, 17833, 17832, 17788, 17834, 80469, 80439, 79777, 
80470, 80468, 80437, 79745, 79776
19682, 66083, 66073, 65853, 65863, 66084, 66074, 65854, 65864, 80469, 80439, 79777, 80470, 80472, 80442, 79780, 
80473, 80471, 80440, 79748, 79779
19683, 66084, 66074, 65854, 65864, 66085, 66075, 65855, 65865, 80472, 80442, 79780, 80473, 80475, 80445, 79783, 
80476, 80474, 80443, 79751, 79782
19684, 66085, 66075, 65855, 65865, 66086, 66076, 65856, 65866, 80475, 80445, 79783, 80476, 80478, 80448, 79786, 
80479, 80477, 80446, 79754, 79785
19685, 66086, 66076, 65856, 65866, 66087, 66077, 65857, 65867, 80478, 80448, 79786, 80479, 80481, 80451, 79789, 
80482, 80480, 80449, 79757, 79788
19686, 66087, 66077, 65857, 65867, 66088, 66078, 65858, 65868, 80481, 80451, 79789, 80482, 80484, 80454, 79792, 
80485, 80483, 80452, 79760, 79791
19687, 66088, 66078, 65858, 65868, 66089, 66079, 65859, 65869, 80484, 80454, 79792, 80485, 80487, 80457, 79795, 
80488, 80486, 80455, 79763, 79794
19688, 66089, 66079, 65859, 65869, 66090, 66080, 65860, 65870, 80487, 80457, 79795, 80488, 80490, 80460, 79798, 
80491, 80489, 80458, 79766, 79797
19689, 66090, 66080, 65860, 65870, 66091, 66081, 65861, 65871, 80490, 80460, 79798, 80491, 80493, 80463, 79801, 
80494, 80492, 80461, 79769, 79800
19690, 66091, 66081, 65861, 65871, 66092, 66082, 65862, 65872, 80493, 80463, 79801, 80494, 80496, 80466, 79804, 
80497, 80495, 80464, 79772, 79803
19691, 66092, 66082, 65862, 65872, 18380, 18379, 18357, 18358, 80496, 80466, 79804, 80497, 19330, 19327, 19285, 
19329, 80498, 80467, 79775, 79806
19692, 16885, 16884, 16862, 16863, 66093, 66083, 65863, 65873, 17835, 17834, 17790, 17836, 80500, 80470, 79808, 
80501, 80499, 80468, 79776, 79807
19693, 66093, 66083, 65863, 65873, 66094, 66084, 65864, 65874, 80500, 80470, 79808, 80501, 80503, 80473, 79811, 
80504, 80502, 80471, 79779, 79810
19694, 66094, 66084, 65864, 65874, 66095, 66085, 65865, 65875, 80503, 80473, 79811, 80504, 80506, 80476, 79814, 
80507, 80505, 80474, 79782, 79813
19695, 66095, 66085, 65865, 65875, 66096, 66086, 65866, 65876, 80506, 80476, 79814, 80507, 80509, 80479, 79817, 
80510, 80508, 80477, 79785, 79816
19696, 66096, 66086, 65866, 65876, 66097, 66087, 65867, 65877, 80509, 80479, 79817, 80510, 80512, 80482, 79820, 
80513, 80511, 80480, 79788, 79819
19697, 66097, 66087, 65867, 65877, 66098, 66088, 65868, 65878, 80512, 80482, 79820, 80513, 80515, 80485, 79823, 
80516, 80514, 80483, 79791, 79822
19698, 66098, 66088, 65868, 65878, 66099, 66089, 65869, 65879, 80515, 80485, 79823, 80516, 80518, 80488, 79826, 
80519, 80517, 80486, 79794, 79825
19699, 66099, 66089, 65869, 65879, 66100, 66090, 65870, 65880, 80518, 80488, 79826, 80519, 80521, 80491, 79829, 
80522, 80520, 80489, 79797, 79828
19700, 66100, 66090, 65870, 65880, 66101, 66091, 65871, 65881, 80521, 80491, 79829, 80522, 80524, 80494, 79832, 
80525, 80523, 80492, 79800, 79831
19701, 66101, 66091, 65871, 65881, 66102, 66092, 65872, 65882, 80524, 80494, 79832, 80525, 80527, 80497, 79835, 
80528, 80526, 80495, 79803, 79834
19702, 66102, 66092, 65872, 65882, 18381, 18380, 18358, 18359, 80527, 80497, 79835, 80528, 19332, 19329, 19287, 
19331, 80529, 80498, 79806, 79837
19703, 16886, 16885, 16863, 16864, 66103, 66093, 65873, 65883, 17837, 17836, 17792, 17838, 80531, 80501, 79839, 
80532, 80530, 80499, 79807, 79838
19704, 66103, 66093, 65873, 65883, 66104, 66094, 65874, 65884, 80531, 80501, 79839, 80532, 80534, 80504, 79842, 
80535, 80533, 80502, 79810, 79841
19705, 66104, 66094, 65874, 65884, 66105, 66095, 65875, 65885, 80534, 80504, 79842, 80535, 80537, 80507, 79845, 
80538, 80536, 80505, 79813, 79844
19706, 66105, 66095, 65875, 65885, 66106, 66096, 65876, 65886, 80537, 80507, 79845, 80538, 80540, 80510, 79848, 
80541, 80539, 80508, 79816, 79847
19707, 66106, 66096, 65876, 65886, 66107, 66097, 65877, 65887, 80540, 80510, 79848, 80541, 80543, 80513, 79851, 
80544, 80542, 80511, 79819, 79850
19708, 66107, 66097, 65877, 65887, 66108, 66098, 65878, 65888, 80543, 80513, 79851, 80544, 80546, 80516, 79854, 
80547, 80545, 80514, 79822, 79853
19709, 66108, 66098, 65878, 65888, 66109, 66099, 65879, 65889, 80546, 80516, 79854, 80547, 80549, 80519, 79857, 
80550, 80548, 80517, 79825, 79856
19710, 66109, 66099, 65879, 65889, 66110, 66100, 65880, 65890, 80549, 80519, 79857, 80550, 80552, 80522, 79860, 
80553, 80551, 80520, 79828, 79859
19711, 66110, 66100, 65880, 65890, 66111, 66101, 65881, 65891, 80552, 80522, 79860, 80553, 80555, 80525, 79863, 
80556, 80554, 80523, 79831, 79862
19712, 66111, 66101, 65881, 65891, 66112, 66102, 65882, 65892, 80555, 80525, 79863, 80556, 80558, 80528, 79866, 
80559, 80557, 80526, 79834, 79865
19713, 66112, 66102, 65882, 65892, 18382, 18381, 18359, 18360, 80558, 80528, 79866, 80559, 19334, 19331, 19289, 
19333, 80560, 80529, 79837, 79868
19714, 16887, 16886, 16864, 16865, 66113, 66103, 65883, 65893, 17839, 17838, 17794, 17840, 80562, 80532, 79870, 
80563, 80561, 80530, 79838, 79869
19715, 66113, 66103, 65883, 65893, 66114, 66104, 65884, 65894, 80562, 80532, 79870, 80563, 80565, 80535, 79873, 
80566, 80564, 80533, 79841, 79872
19716, 66114, 66104, 65884, 65894, 66115, 66105, 65885, 65895, 80565, 80535, 79873, 80566, 80568, 80538, 79876, 
80569, 80567, 80536, 79844, 79875
19717, 66115, 66105, 65885, 65895, 66116, 66106, 65886, 65896, 80568, 80538, 79876, 80569, 80571, 80541, 79879, 
80572, 80570, 80539, 79847, 79878
19718, 66116, 66106, 65886, 65896, 66117, 66107, 65887, 65897, 80571, 80541, 79879, 80572, 80574, 80544, 79882, 
80575, 80573, 80542, 79850, 79881
19719, 66117, 66107, 65887, 65897, 66118, 66108, 65888, 65898, 80574, 80544, 79882, 80575, 80577, 80547, 79885, 
80578, 80576, 80545, 79853, 79884
19720, 66118, 66108, 65888, 65898, 66119, 66109, 65889, 65899, 80577, 80547, 79885, 80578, 80580, 80550, 79888, 
80581, 80579, 80548, 79856, 79887
19721, 66119, 66109, 65889, 65899, 66120, 66110, 65890, 65900, 80580, 80550, 79888, 80581, 80583, 80553, 79891, 
80584, 80582, 80551, 79859, 79890
19722, 66120, 66110, 65890, 65900, 66121, 66111, 65891, 65901, 80583, 80553, 79891, 80584, 80586, 80556, 79894, 
80587, 80585, 80554, 79862, 79893
19723, 66121, 66111, 65891, 65901, 66122, 66112, 65892, 65902, 80586, 80556, 79894, 80587, 80589, 80559, 79897, 
80590, 80588, 80557, 79865, 79896
19724, 66122, 66112, 65892, 65902, 18383, 18382, 18360, 18361, 80589, 80559, 79897, 80590, 19336, 19333, 19291, 
19335, 80591, 80560, 79868, 79899
19725, 16888, 16887, 16865, 16866, 66123, 66113, 65893, 65903, 17841, 17840, 17796, 17842, 80593, 80563, 79901, 
80594, 80592, 80561, 79869, 79900
19726, 66123, 66113, 65893, 65903, 66124, 66114, 65894, 65904, 80593, 80563, 79901, 80594, 80596, 80566, 79904, 
80597, 80595, 80564, 79872, 79903
19727, 66124, 66114, 65894, 65904, 66125, 66115, 65895, 65905, 80596, 80566, 79904, 80597, 80599, 80569, 79907, 
80600, 80598, 80567, 79875, 79906
19728, 66125, 66115, 65895, 65905, 66126, 66116, 65896, 65906, 80599, 80569, 79907, 80600, 80602, 80572, 79910, 
80603, 80601, 80570, 79878, 79909
19729, 66126, 66116, 65896, 65906, 66127, 66117, 65897, 65907, 80602, 80572, 79910, 80603, 80605, 80575, 79913, 
80606, 80604, 80573, 79881, 79912
19730, 66127, 66117, 65897, 65907, 66128, 66118, 65898, 65908, 80605, 80575, 79913, 80606, 80608, 80578, 79916, 
80609, 80607, 80576, 79884, 79915
19731, 66128, 66118, 65898, 65908, 66129, 66119, 65899, 65909, 80608, 80578, 79916, 80609, 80611, 80581, 79919, 
80612, 80610, 80579, 79887, 79918
19732, 66129, 66119, 65899, 65909, 66130, 66120, 65900, 65910, 80611, 80581, 79919, 80612, 80614, 80584, 79922, 
80615, 80613, 80582, 79890, 79921
19733, 66130, 66120, 65900, 65910, 66131, 66121, 65901, 65911, 80614, 80584, 79922, 80615, 80617, 80587, 79925, 
80618, 80616, 80585, 79893, 79924
19734, 66131, 66121, 65901, 65911, 66132, 66122, 65902, 65912, 80617, 80587, 79925, 80618, 80620, 80590, 79928, 
80621, 80619, 80588, 79896, 79927
19735, 66132, 66122, 65902, 65912, 18384, 18383, 18361, 18362, 80620, 80590, 79928, 80621, 19338, 19335, 19293, 
19337, 80622, 80591, 79899, 79930
19736, 16889, 16888, 16866, 16867, 66133, 66123, 65903, 65913, 17843, 17842, 17798, 17844, 80624, 80594, 79932, 
80625, 80623, 80592, 79900, 79931
19737, 66133, 66123, 65903, 65913, 66134, 66124, 65904, 65914, 80624, 80594, 79932, 80625, 80627, 80597, 79935, 
80628, 80626, 80595, 79903, 79934
19738, 66134, 66124, 65904, 65914, 66135, 66125, 65905, 65915, 80627, 80597, 79935, 80628, 80630, 80600, 79938, 
80631, 80629, 80598, 79906, 79937
19739, 66135, 66125, 65905, 65915, 66136, 66126, 65906, 65916, 80630, 80600, 79938, 80631, 80633, 80603, 79941, 
80634, 80632, 80601, 79909, 79940
19740, 66136, 66126, 65906, 65916, 66137, 66127, 65907, 65917, 80633, 80603, 79941, 80634, 80636, 80606, 79944, 
80637, 80635, 80604, 79912, 79943
19741, 66137, 66127, 65907, 65917, 66138, 66128, 65908, 65918, 80636, 80606, 79944, 80637, 80639, 80609, 79947, 
80640, 80638, 80607, 79915, 79946
19742, 66138, 66128, 65908, 65918, 66139, 66129, 65909, 65919, 80639, 80609, 79947, 80640, 80642, 80612, 79950, 
80643, 80641, 80610, 79918, 79949
19743, 66139, 66129, 65909, 65919, 66140, 66130, 65910, 65920, 80642, 80612, 79950, 80643, 80645, 80615, 79953, 
80646, 80644, 80613, 79921, 79952
19744, 66140, 66130, 65910, 65920, 66141, 66131, 65911, 65921, 80645, 80615, 79953, 80646, 80648, 80618, 79956, 
80649, 80647, 80616, 79924, 79955
19745, 66141, 66131, 65911, 65921, 66142, 66132, 65912, 65922, 80648, 80618, 79956, 80649, 80651, 80621, 79959, 
80652, 80650, 80619, 79927, 79958
19746, 66142, 66132, 65912, 65922, 18385, 18384, 18362, 18363, 80651, 80621, 79959, 80652, 19340, 19337, 19295, 
19339, 80653, 80622, 79930, 79961
19747, 16890, 16889, 16867, 16868, 66143, 66133, 65913, 65923, 17845, 17844, 17800, 17846, 80655, 80625, 79963, 
80656, 80654, 80623, 79931, 79962
19748, 66143, 66133, 65913, 65923, 66144, 66134, 65914, 65924, 80655, 80625, 79963, 80656, 80658, 80628, 79966, 
80659, 80657, 80626, 79934, 79965
19749, 66144, 66134, 65914, 65924, 66145, 66135, 65915, 65925, 80658, 80628, 79966, 80659, 80661, 80631, 79969, 
80662, 80660, 80629, 79937, 79968
19750, 66145, 66135, 65915, 65925, 66146, 66136, 65916, 65926, 80661, 80631, 79969, 80662, 80664, 80634, 79972, 
80665, 80663, 80632, 79940, 79971
19751, 66146, 66136, 65916, 65926, 66147, 66137, 65917, 65927, 80664, 80634, 79972, 80665, 80667, 80637, 79975, 
80668, 80666, 80635, 79943, 79974
19752, 66147, 66137, 65917, 65927, 66148, 66138, 65918, 65928, 80667, 80637, 79975, 80668, 80670, 80640, 79978, 
80671, 80669, 80638, 79946, 79977
19753, 66148, 66138, 65918, 65928, 66149, 66139, 65919, 65929, 80670, 80640, 79978, 80671, 80673, 80643, 79981, 
80674, 80672, 80641, 79949, 79980
19754, 66149, 66139, 65919, 65929, 66150, 66140, 65920, 65930, 80673, 80643, 79981, 80674, 80676, 80646, 79984, 
80677, 80675, 80644, 79952, 79983
19755, 66150, 66140, 65920, 65930, 66151, 66141, 65921, 65931, 80676, 80646, 79984, 80677, 80679, 80649, 79987, 
80680, 80678, 80647, 79955, 79986
19756, 66151, 66141, 65921, 65931, 66152, 66142, 65922, 65932, 80679, 80649, 79987, 80680, 80682, 80652, 79990, 
80683, 80681, 80650, 79958, 79989
19757, 66152, 66142, 65922, 65932, 18386, 18385, 18363, 18364, 80682, 80652, 79990, 80683, 19342, 19339, 19297, 
19341, 80684, 80653, 79961, 79992
19758, 16891, 16890, 16868, 16869, 66153, 66143, 65923, 65933, 17847, 17846, 17802, 17848, 80686, 80656, 79994, 
80687, 80685, 80654, 79962, 79993
19759, 66153, 66143, 65923, 65933, 66154, 66144, 65924, 65934, 80686, 80656, 79994, 80687, 80689, 80659, 79997, 
80690, 80688, 80657, 79965, 79996
19760, 66154, 66144, 65924, 65934, 66155, 66145, 65925, 65935, 80689, 80659, 79997, 80690, 80692, 80662, 80000, 
80693, 80691, 80660, 79968, 79999
19761, 66155, 66145, 65925, 65935, 66156, 66146, 65926, 65936, 80692, 80662, 80000, 80693, 80695, 80665, 80003, 
80696, 80694, 80663, 79971, 80002
19762, 66156, 66146, 65926, 65936, 66157, 66147, 65927, 65937, 80695, 80665, 80003, 80696, 80698, 80668, 80006, 
80699, 80697, 80666, 79974, 80005
19763, 66157, 66147, 65927, 65937, 66158, 66148, 65928, 65938, 80698, 80668, 80006, 80699, 80701, 80671, 80009, 
80702, 80700, 80669, 79977, 80008
19764, 66158, 66148, 65928, 65938, 66159, 66149, 65929, 65939, 80701, 80671, 80009, 80702, 80704, 80674, 80012, 
80705, 80703, 80672, 79980, 80011
19765, 66159, 66149, 65929, 65939, 66160, 66150, 65930, 65940, 80704, 80674, 80012, 80705, 80707, 80677, 80015, 
80708, 80706, 80675, 79983, 80014
19766, 66160, 66150, 65930, 65940, 66161, 66151, 65931, 65941, 80707, 80677, 80015, 80708, 80710, 80680, 80018, 
80711, 80709, 80678, 79986, 80017
19767, 66161, 66151, 65931, 65941, 66162, 66152, 65932, 65942, 80710, 80680, 80018, 80711, 80713, 80683, 80021, 
80714, 80712, 80681, 79989, 80020
19768, 66162, 66152, 65932, 65942, 18387, 18386, 18364, 18365, 80713, 80683, 80021, 80714, 19344, 19341, 19299, 
19343, 80715, 80684, 79992, 80023
19769, 16892, 16891, 16869, 16870, 66163, 66153, 65933, 65943, 17849, 17848, 17804, 17850, 80717, 80687, 80025, 
80718, 80716, 80685, 79993, 80024
19770, 66163, 66153, 65933, 65943, 66164, 66154, 65934, 65944, 80717, 80687, 80025, 80718, 80720, 80690, 80028, 
80721, 80719, 80688, 79996, 80027
19771, 66164, 66154, 65934, 65944, 66165, 66155, 65935, 65945, 80720, 80690, 80028, 80721, 80723, 80693, 80031, 
80724, 80722, 80691, 79999, 80030
19772, 66165, 66155, 65935, 65945, 66166, 66156, 65936, 65946, 80723, 80693, 80031, 80724, 80726, 80696, 80034, 
80727, 80725, 80694, 80002, 80033
19773, 66166, 66156, 65936, 65946, 66167, 66157, 65937, 65947, 80726, 80696, 80034, 80727, 80729, 80699, 80037, 
80730, 80728, 80697, 80005, 80036
19774, 66167, 66157, 65937, 65947, 66168, 66158, 65938, 65948, 80729, 80699, 80037, 80730, 80732, 80702, 80040, 
80733, 80731, 80700, 80008, 80039
19775, 66168, 66158, 65938, 65948, 66169, 66159, 65939, 65949, 80732, 80702, 80040, 80733, 80735, 80705, 80043, 
80736, 80734, 80703, 80011, 80042
19776, 66169, 66159, 65939, 65949, 66170, 66160, 65940, 65950, 80735, 80705, 80043, 80736, 80738, 80708, 80046, 
80739, 80737, 80706, 80014, 80045
19777, 66170, 66160, 65940, 65950, 66171, 66161, 65941, 65951, 80738, 80708, 80046, 80739, 80741, 80711, 80049, 
80742, 80740, 80709, 80017, 80048
19778, 66171, 66161, 65941, 65951, 66172, 66162, 65942, 65952, 80741, 80711, 80049, 80742, 80744, 80714, 80052, 
80745, 80743, 80712, 80020, 80051
19779, 66172, 66162, 65942, 65952, 18388, 18387, 18365, 18366, 80744, 80714, 80052, 80745, 19346, 19343, 19301, 
19345, 80746, 80715, 80023, 80054
19780, 16893, 16892, 16870, 16871, 66173, 66163, 65943, 65953, 17851, 17850, 17806, 17852, 80748, 80718, 80056, 
80749, 80747, 80716, 80024, 80055
19781, 66173, 66163, 65943, 65953, 66174, 66164, 65944, 65954, 80748, 80718, 80056, 80749, 80751, 80721, 80059, 
80752, 80750, 80719, 80027, 80058
19782, 66174, 66164, 65944, 65954, 66175, 66165, 65945, 65955, 80751, 80721, 80059, 80752, 80754, 80724, 80062, 
80755, 80753, 80722, 80030, 80061
19783, 66175, 66165, 65945, 65955, 66176, 66166, 65946, 65956, 80754, 80724, 80062, 80755, 80757, 80727, 80065, 
80758, 80756, 80725, 80033, 80064
19784, 66176, 66166, 65946, 65956, 66177, 66167, 65947, 65957, 80757, 80727, 80065, 80758, 80760, 80730, 80068, 
80761, 80759, 80728, 80036, 80067
19785, 66177, 66167, 65947, 65957, 66178, 66168, 65948, 65958, 80760, 80730, 80068, 80761, 80763, 80733, 80071, 
80764, 80762, 80731, 80039, 80070
19786, 66178, 66168, 65948, 65958, 66179, 66169, 65949, 65959, 80763, 80733, 80071, 80764, 80766, 80736, 80074, 
80767, 80765, 80734, 80042, 80073
19787, 66179, 66169, 65949, 65959, 66180, 66170, 65950, 65960, 80766, 80736, 80074, 80767, 80769, 80739, 80077, 
80770, 80768, 80737, 80045, 80076
19788, 66180, 66170, 65950, 65960, 66181, 66171, 65951, 65961, 80769, 80739, 80077, 80770, 80772, 80742, 80080, 
80773, 80771, 80740, 80048, 80079
19789, 66181, 66171, 65951, 65961, 66182, 66172, 65952, 65962, 80772, 80742, 80080, 80773, 80775, 80745, 80083, 
80776, 80774, 80743, 80051, 80082
19790, 66182, 66172, 65952, 65962, 18389, 18388, 18366, 18367, 80775, 80745, 80083, 80776, 19348, 19345, 19303, 
19347, 80777, 80746, 80054, 80085
19791, 16894, 16893, 16871, 16872, 66183, 66173, 65953, 65963, 17853, 17852, 17808, 17854, 80779, 80749, 80087, 
80780, 80778, 80747, 80055, 80086
19792, 66183, 66173, 65953, 65963, 66184, 66174, 65954, 65964, 80779, 80749, 80087, 80780, 80782, 80752, 80090, 
80783, 80781, 80750, 80058, 80089
19793, 66184, 66174, 65954, 65964, 66185, 66175, 65955, 65965, 80782, 80752, 80090, 80783, 80785, 80755, 80093, 
80786, 80784, 80753, 80061, 80092
19794, 66185, 66175, 65955, 65965, 66186, 66176, 65956, 65966, 80785, 80755, 80093, 80786, 80788, 80758, 80096, 
80789, 80787, 80756, 80064, 80095
19795, 66186, 66176, 65956, 65966, 66187, 66177, 65957, 65967, 80788, 80758, 80096, 80789, 80791, 80761, 80099, 
80792, 80790, 80759, 80067, 80098
19796, 66187, 66177, 65957, 65967, 66188, 66178, 65958, 65968, 80791, 80761, 80099, 80792, 80794, 80764, 80102, 
80795, 80793, 80762, 80070, 80101
19797, 66188, 66178, 65958, 65968, 66189, 66179, 65959, 65969, 80794, 80764, 80102, 80795, 80797, 80767, 80105, 
80798, 80796, 80765, 80073, 80104
19798, 66189, 66179, 65959, 65969, 66190, 66180, 65960, 65970, 80797, 80767, 80105, 80798, 80800, 80770, 80108, 
80801, 80799, 80768, 80076, 80107
19799, 66190, 66180, 65960, 65970, 66191, 66181, 65961, 65971, 80800, 80770, 80108, 80801, 80803, 80773, 80111, 
80804, 80802, 80771, 80079, 80110
19800, 66191, 66181, 65961, 65971, 66192, 66182, 65962, 65972, 80803, 80773, 80111, 80804, 80806, 80776, 80114, 
80807, 80805, 80774, 80082, 80113
19801, 66192, 66182, 65962, 65972, 18390, 18389, 18367, 18368, 80806, 80776, 80114, 80807, 19350, 19347, 19305, 
19349, 80808, 80777, 80085, 80116
19802, 16895, 16894, 16872, 16873, 66193, 66183, 65963, 65973, 17855, 17854, 17810, 17856, 80810, 80780, 80118, 
80811, 80809, 80778, 80086, 80117
19803, 66193, 66183, 65963, 65973, 66194, 66184, 65964, 65974, 80810, 80780, 80118, 80811, 80813, 80783, 80121, 
80814, 80812, 80781, 80089, 80120
19804, 66194, 66184, 65964, 65974, 66195, 66185, 65965, 65975, 80813, 80783, 80121, 80814, 80816, 80786, 80124, 
80817, 80815, 80784, 80092, 80123
19805, 66195, 66185, 65965, 65975, 66196, 66186, 65966, 65976, 80816, 80786, 80124, 80817, 80819, 80789, 80127, 
80820, 80818, 80787, 80095, 80126
19806, 66196, 66186, 65966, 65976, 66197, 66187, 65967, 65977, 80819, 80789, 80127, 80820, 80822, 80792, 80130, 
80823, 80821, 80790, 80098, 80129
19807, 66197, 66187, 65967, 65977, 66198, 66188, 65968, 65978, 80822, 80792, 80130, 80823, 80825, 80795, 80133, 
80826, 80824, 80793, 80101, 80132
19808, 66198, 66188, 65968, 65978, 66199, 66189, 65969, 65979, 80825, 80795, 80133, 80826, 80828, 80798, 80136, 
80829, 80827, 80796, 80104, 80135
19809, 66199, 66189, 65969, 65979, 66200, 66190, 65970, 65980, 80828, 80798, 80136, 80829, 80831, 80801, 80139, 
80832, 80830, 80799, 80107, 80138
19810, 66200, 66190, 65970, 65980, 66201, 66191, 65971, 65981, 80831, 80801, 80139, 80832, 80834, 80804, 80142, 
80835, 80833, 80802, 80110, 80141
19811, 66201, 66191, 65971, 65981, 66202, 66192, 65972, 65982, 80834, 80804, 80142, 80835, 80837, 80807, 80145, 
80838, 80836, 80805, 80113, 80144
19812, 66202, 66192, 65972, 65982, 18391, 18390, 18368, 18369, 80837, 80807, 80145, 80838, 19352, 19349, 19307, 
19351, 80839, 80808, 80116, 80147
19813, 16896, 16895, 16873, 16874, 66203, 66193, 65973, 65983, 17857, 17856, 17812, 17858, 80841, 80811, 80149, 
80842, 80840, 80809, 80117, 80148
19814, 66203, 66193, 65973, 65983, 66204, 66194, 65974, 65984, 80841, 80811, 80149, 80842, 80844, 80814, 80152, 
80845, 80843, 80812, 80120, 80151
19815, 66204, 66194, 65974, 65984, 66205, 66195, 65975, 65985, 80844, 80814, 80152, 80845, 80847, 80817, 80155, 
80848, 80846, 80815, 80123, 80154
19816, 66205, 66195, 65975, 65985, 66206, 66196, 65976, 65986, 80847, 80817, 80155, 80848, 80850, 80820, 80158, 
80851, 80849, 80818, 80126, 80157
19817, 66206, 66196, 65976, 65986, 66207, 66197, 65977, 65987, 80850, 80820, 80158, 80851, 80853, 80823, 80161, 
80854, 80852, 80821, 80129, 80160
19818, 66207, 66197, 65977, 65987, 66208, 66198, 65978, 65988, 80853, 80823, 80161, 80854, 80856, 80826, 80164, 
80857, 80855, 80824, 80132, 80163
19819, 66208, 66198, 65978, 65988, 66209, 66199, 65979, 65989, 80856, 80826, 80164, 80857, 80859, 80829, 80167, 
80860, 80858, 80827, 80135, 80166
19820, 66209, 66199, 65979, 65989, 66210, 66200, 65980, 65990, 80859, 80829, 80167, 80860, 80862, 80832, 80170, 
80863, 80861, 80830, 80138, 80169
19821, 66210, 66200, 65980, 65990, 66211, 66201, 65981, 65991, 80862, 80832, 80170, 80863, 80865, 80835, 80173, 
80866, 80864, 80833, 80141, 80172
19822, 66211, 66201, 65981, 65991, 66212, 66202, 65982, 65992, 80865, 80835, 80173, 80866, 80868, 80838, 80176, 
80869, 80867, 80836, 80144, 80175
19823, 66212, 66202, 65982, 65992, 18392, 18391, 18369, 18370, 80868, 80838, 80176, 80869, 19354, 19351, 19309, 
19353, 80870, 80839, 80147, 80178
19824, 16897, 16896, 16874, 16875, 66213, 66203, 65983, 65993, 17859, 17858, 17814, 17860, 80872, 80842, 80180, 
80873, 80871, 80840, 80148, 80179
19825, 66213, 66203, 65983, 65993, 66214, 66204, 65984, 65994, 80872, 80842, 80180, 80873, 80875, 80845, 80183, 
80876, 80874, 80843, 80151, 80182
19826, 66214, 66204, 65984, 65994, 66215, 66205, 65985, 65995, 80875, 80845, 80183, 80876, 80878, 80848, 80186, 
80879, 80877, 80846, 80154, 80185
19827, 66215, 66205, 65985, 65995, 66216, 66206, 65986, 65996, 80878, 80848, 80186, 80879, 80881, 80851, 80189, 
80882, 80880, 80849, 80157, 80188
19828, 66216, 66206, 65986, 65996, 66217, 66207, 65987, 65997, 80881, 80851, 80189, 80882, 80884, 80854, 80192, 
80885, 80883, 80852, 80160, 80191
19829, 66217, 66207, 65987, 65997, 66218, 66208, 65988, 65998, 80884, 80854, 80192, 80885, 80887, 80857, 80195, 
80888, 80886, 80855, 80163, 80194
19830, 66218, 66208, 65988, 65998, 66219, 66209, 65989, 65999, 80887, 80857, 80195, 80888, 80890, 80860, 80198, 
80891, 80889, 80858, 80166, 80197
19831, 66219, 66209, 65989, 65999, 66220, 66210, 65990, 66000, 80890, 80860, 80198, 80891, 80893, 80863, 80201, 
80894, 80892, 80861, 80169, 80200
19832, 66220, 66210, 65990, 66000, 66221, 66211, 65991, 66001, 80893, 80863, 80201, 80894, 80896, 80866, 80204, 
80897, 80895, 80864, 80172, 80203
19833, 66221, 66211, 65991, 66001, 66222, 66212, 65992, 66002, 80896, 80866, 80204, 80897, 80899, 80869, 80207, 
80900, 80898, 80867, 80175, 80206
19834, 66222, 66212, 65992, 66002, 18393, 18392, 18370, 18371, 80899, 80869, 80207, 80900, 19356, 19353, 19311, 
19355, 80901, 80870, 80178, 80209
19835, 16898, 16897, 16875, 16876, 66223, 66213, 65993, 66003, 17861, 17860, 17816, 17862, 80903, 80873, 80211, 
80904, 80902, 80871, 80179, 80210
19836, 66223, 66213, 65993, 66003, 66224, 66214, 65994, 66004, 80903, 80873, 80211, 80904, 80906, 80876, 80214, 
80907, 80905, 80874, 80182, 80213
19837, 66224, 66214, 65994, 66004, 66225, 66215, 65995, 66005, 80906, 80876, 80214, 80907, 80909, 80879, 80217, 
80910, 80908, 80877, 80185, 80216
19838, 66225, 66215, 65995, 66005, 66226, 66216, 65996, 66006, 80909, 80879, 80217, 80910, 80912, 80882, 80220, 
80913, 80911, 80880, 80188, 80219
19839, 66226, 66216, 65996, 66006, 66227, 66217, 65997, 66007, 80912, 80882, 80220, 80913, 80915, 80885, 80223, 
80916, 80914, 80883, 80191, 80222
19840, 66227, 66217, 65997, 66007, 66228, 66218, 65998, 66008, 80915, 80885, 80223, 80916, 80918, 80888, 80226, 
80919, 80917, 80886, 80194, 80225
19841, 66228, 66218, 65998, 66008, 66229, 66219, 65999, 66009, 80918, 80888, 80226, 80919, 80921, 80891, 80229, 
80922, 80920, 80889, 80197, 80228
19842, 66229, 66219, 65999, 66009, 66230, 66220, 66000, 66010, 80921, 80891, 80229, 80922, 80924, 80894, 80232, 
80925, 80923, 80892, 80200, 80231
19843, 66230, 66220, 66000, 66010, 66231, 66221, 66001, 66011, 80924, 80894, 80232, 80925, 80927, 80897, 80235, 
80928, 80926, 80895, 80203, 80234
19844, 66231, 66221, 66001, 66011, 66232, 66222, 66002, 66012, 80927, 80897, 80235, 80928, 80930, 80900, 80238, 
80931, 80929, 80898, 80206, 80237
19845, 66232, 66222, 66002, 66012, 18394, 18393, 18371, 18372, 80930, 80900, 80238, 80931, 19358, 19355, 19313, 
19357, 80932, 80901, 80209, 80240
19846, 16899, 16898, 16876, 16877, 66233, 66223, 66003, 66013, 17863, 17862, 17818, 17864, 80934, 80904, 80242, 
80935, 80933, 80902, 80210, 80241
19847, 66233, 66223, 66003, 66013, 66234, 66224, 66004, 66014, 80934, 80904, 80242, 80935, 80937, 80907, 80245, 
80938, 80936, 80905, 80213, 80244
19848, 66234, 66224, 66004, 66014, 66235, 66225, 66005, 66015, 80937, 80907, 80245, 80938, 80940, 80910, 80248, 
80941, 80939, 80908, 80216, 80247
19849, 66235, 66225, 66005, 66015, 66236, 66226, 66006, 66016, 80940, 80910, 80248, 80941, 80943, 80913, 80251, 
80944, 80942, 80911, 80219, 80250
19850, 66236, 66226, 66006, 66016, 66237, 66227, 66007, 66017, 80943, 80913, 80251, 80944, 80946, 80916, 80254, 
80947, 80945, 80914, 80222, 80253
19851, 66237, 66227, 66007, 66017, 66238, 66228, 66008, 66018, 80946, 80916, 80254, 80947, 80949, 80919, 80257, 
80950, 80948, 80917, 80225, 80256
19852, 66238, 66228, 66008, 66018, 66239, 66229, 66009, 66019, 80949, 80919, 80257, 80950, 80952, 80922, 80260, 
80953, 80951, 80920, 80228, 80259
19853, 66239, 66229, 66009, 66019, 66240, 66230, 66010, 66020, 80952, 80922, 80260, 80953, 80955, 80925, 80263, 
80956, 80954, 80923, 80231, 80262
19854, 66240, 66230, 66010, 66020, 66241, 66231, 66011, 66021, 80955, 80925, 80263, 80956, 80958, 80928, 80266, 
80959, 80957, 80926, 80234, 80265
19855, 66241, 66231, 66011, 66021, 66242, 66232, 66012, 66022, 80958, 80928, 80266, 80959, 80961, 80931, 80269, 
80962, 80960, 80929, 80237, 80268
19856, 66242, 66232, 66012, 66022, 18395, 18394, 18372, 18373, 80961, 80931, 80269, 80962, 19360, 19357, 19315, 
19359, 80963, 80932, 80240, 80271
19857, 16900, 16899, 16877, 16878, 66243, 66233, 66013, 66023, 17865, 17864, 17820, 17866, 80965, 80935, 80273, 
80966, 80964, 80933, 80241, 80272
19858, 66243, 66233, 66013, 66023, 66244, 66234, 66014, 66024, 80965, 80935, 80273, 80966, 80968, 80938, 80276, 
80969, 80967, 80936, 80244, 80275
19859, 66244, 66234, 66014, 66024, 66245, 66235, 66015, 66025, 80968, 80938, 80276, 80969, 80971, 80941, 80279, 
80972, 80970, 80939, 80247, 80278
19860, 66245, 66235, 66015, 66025, 66246, 66236, 66016, 66026, 80971, 80941, 80279, 80972, 80974, 80944, 80282, 
80975, 80973, 80942, 80250, 80281
19861, 66246, 66236, 66016, 66026, 66247, 66237, 66017, 66027, 80974, 80944, 80282, 80975, 80977, 80947, 80285, 
80978, 80976, 80945, 80253, 80284
19862, 66247, 66237, 66017, 66027, 66248, 66238, 66018, 66028, 80977, 80947, 80285, 80978, 80980, 80950, 80288, 
80981, 80979, 80948, 80256, 80287
19863, 66248, 66238, 66018, 66028, 66249, 66239, 66019, 66029, 80980, 80950, 80288, 80981, 80983, 80953, 80291, 
80984, 80982, 80951, 80259, 80290
19864, 66249, 66239, 66019, 66029, 66250, 66240, 66020, 66030, 80983, 80953, 80291, 80984, 80986, 80956, 80294, 
80987, 80985, 80954, 80262, 80293
19865, 66250, 66240, 66020, 66030, 66251, 66241, 66021, 66031, 80986, 80956, 80294, 80987, 80989, 80959, 80297, 
80990, 80988, 80957, 80265, 80296
19866, 66251, 66241, 66021, 66031, 66252, 66242, 66022, 66032, 80989, 80959, 80297, 80990, 80992, 80962, 80300, 
80993, 80991, 80960, 80268, 80299
19867, 66252, 66242, 66022, 66032, 18396, 18395, 18373, 18374, 80992, 80962, 80300, 80993, 19362, 19359, 19317, 
19361, 80994, 80963, 80271, 80302
19868, 1654, 16900, 16878, 1653, 20323, 66243, 66023, 20313, 17867, 17866, 17822, 1676, 80995, 80966, 80303, 
20764, 20763, 80964, 80272, 20742
19869, 20323, 66243, 66023, 20313, 20324, 66244, 66024, 20314, 80995, 80966, 80303, 20764, 80996, 80969, 80304, 
20766, 20765, 80967, 80275, 20744
19870, 20324, 66244, 66024, 20314, 20325, 66245, 66025, 20315, 80996, 80969, 80304, 20766, 80997, 80972, 80305, 
20768, 20767, 80970, 80278, 20746
19871, 20325, 66245, 66025, 20315, 20326, 66246, 66026, 20316, 80997, 80972, 80305, 20768, 80998, 80975, 80306, 
20770, 20769, 80973, 80281, 20748
19872, 20326, 66246, 66026, 20316, 20327, 66247, 66027, 20317, 80998, 80975, 80306, 20770, 80999, 80978, 80307, 
20772, 20771, 80976, 80284, 20750
19873, 20327, 66247, 66027, 20317, 20328, 66248, 66028, 20318, 80999, 80978, 80307, 20772, 81000, 80981, 80308, 
20774, 20773, 80979, 80287, 20752
19874, 20328, 66248, 66028, 20318, 20329, 66249, 66029, 20319, 81000, 80981, 80308, 20774, 81001, 80984, 80309, 
20776, 20775, 80982, 80290, 20754
19875, 20329, 66249, 66029, 20319, 20330, 66250, 66030, 20320, 81001, 80984, 80309, 20776, 81002, 80987, 80310, 
20778, 20777, 80985, 80293, 20756
19876, 20330, 66250, 66030, 20320, 20331, 66251, 66031, 20321, 81002, 80987, 80310, 20778, 81003, 80990, 80311, 
20780, 20779, 80988, 80296, 20758
19877, 20331, 66251, 66031, 20321, 20332, 66252, 66032, 20322, 81003, 80990, 80311, 20780, 81004, 80993, 80312, 
20782, 20781, 80991, 80299, 20760
19878, 20332, 66252, 66032, 20322, 1789, 18396, 18374, 1788, 81004, 80993, 80312, 20782, 19363, 19361, 19318, 
1811, 20783, 80994, 80302, 20762
19879, 16901, 1610, 1609, 16879, 66253, 19641, 19631, 66033, 17868, 1632, 17823, 17869, 81006, 20092, 80314, 
81007, 81005, 20093, 20072, 80313
19880, 66253, 19641, 19631, 66033, 66254, 19642, 19632, 66034, 81006, 20092, 80314, 81007, 81009, 20094, 80317, 
81010, 81008, 20095, 20074, 80316
19881, 66254, 19642, 19632, 66034, 66255, 19643, 19633, 66035, 81009, 20094, 80317, 81010, 81012, 20096, 80320, 
81013, 81011, 20097, 20076, 80319
19882, 66255, 19643, 19633, 66035, 66256, 19644, 19634, 66036, 81012, 20096, 80320, 81013, 81015, 20098, 80323, 
81016, 81014, 20099, 20078, 80322
19883, 66256, 19644, 19634, 66036, 66257, 19645, 19635, 66037, 81015, 20098, 80323, 81016, 81018, 20100, 80326, 
81019, 81017, 20101, 20080, 80325
19884, 66257, 19645, 19635, 66037, 66258, 19646, 19636, 66038, 81018, 20100, 80326, 81019, 81021, 20102, 80329, 
81022, 81020, 20103, 20082, 80328
19885, 66258, 19646, 19636, 66038, 66259, 19647, 19637, 66039, 81021, 20102, 80329, 81022, 81024, 20104, 80332, 
81025, 81023, 20105, 20084, 80331
19886, 66259, 19647, 19637, 66039, 66260, 19648, 19638, 66040, 81024, 20104, 80332, 81025, 81027, 20106, 80335, 
81028, 81026, 20107, 20086, 80334
19887, 66260, 19648, 19638, 66040, 66261, 19649, 19639, 66041, 81027, 20106, 80335, 81028, 81030, 20108, 80338, 
81031, 81029, 20109, 20088, 80337
19888, 66261, 19649, 19639, 66041, 66262, 19650, 19640, 66042, 81030, 20108, 80338, 81031, 81033, 20110, 80341, 
81034, 81032, 20111, 20090, 80340
19889, 66262, 19650, 19640, 66042, 18397, 1745, 1744, 18375, 81033, 20110, 80341, 81034, 19365, 1767, 19320, 
19364, 81035, 20112, 20091, 80343
19890, 16902, 16901, 16879, 16880, 66263, 66253, 66033, 66043, 17870, 17869, 17825, 17871, 81037, 81007, 80345, 
81038, 81036, 81005, 80313, 80344
19891, 66263, 66253, 66033, 66043, 66264, 66254, 66034, 66044, 81037, 81007, 80345, 81038, 81040, 81010, 80348, 
81041, 81039, 81008, 80316, 80347
19892, 66264, 66254, 66034, 66044, 66265, 66255, 66035, 66045, 81040, 81010, 80348, 81041, 81043, 81013, 80351, 
81044, 81042, 81011, 80319, 80350
19893, 66265, 66255, 66035, 66045, 66266, 66256, 66036, 66046, 81043, 81013, 80351, 81044, 81046, 81016, 80354, 
81047, 81045, 81014, 80322, 80353
19894, 66266, 66256, 66036, 66046, 66267, 66257, 66037, 66047, 81046, 81016, 80354, 81047, 81049, 81019, 80357, 
81050, 81048, 81017, 80325, 80356
19895, 66267, 66257, 66037, 66047, 66268, 66258, 66038, 66048, 81049, 81019, 80357, 81050, 81052, 81022, 80360, 
81053, 81051, 81020, 80328, 80359
19896, 66268, 66258, 66038, 66048, 66269, 66259, 66039, 66049, 81052, 81022, 80360, 81053, 81055, 81025, 80363, 
81056, 81054, 81023, 80331, 80362
19897, 66269, 66259, 66039, 66049, 66270, 66260, 66040, 66050, 81055, 81025, 80363, 81056, 81058, 81028, 80366, 
81059, 81057, 81026, 80334, 80365
19898, 66270, 66260, 66040, 66050, 66271, 66261, 66041, 66051, 81058, 81028, 80366, 81059, 81061, 81031, 80369, 
81062, 81060, 81029, 80337, 80368
19899, 66271, 66261, 66041, 66051, 66272, 66262, 66042, 66052, 81061, 81031, 80369, 81062, 81064, 81034, 80372, 
81065, 81063, 81032, 80340, 80371
19900, 66272, 66262, 66042, 66052, 18398, 18397, 18375, 18376, 81064, 81034, 80372, 81065, 19367, 19364, 19322, 
19366, 81066, 81035, 80343, 80374
19901, 16903, 16902, 16880, 16881, 66273, 66263, 66043, 66053, 17872, 17871, 17827, 17873, 81068, 81038, 80376, 
81069, 81067, 81036, 80344, 80375
19902, 66273, 66263, 66043, 66053, 66274, 66264, 66044, 66054, 81068, 81038, 80376, 81069, 81071, 81041, 80379, 
81072, 81070, 81039, 80347, 80378
19903, 66274, 66264, 66044, 66054, 66275, 66265, 66045, 66055, 81071, 81041, 80379, 81072, 81074, 81044, 80382, 
81075, 81073, 81042, 80350, 80381
19904, 66275, 66265, 66045, 66055, 66276, 66266, 66046, 66056, 81074, 81044, 80382, 81075, 81077, 81047, 80385, 
81078, 81076, 81045, 80353, 80384
19905, 66276, 66266, 66046, 66056, 66277, 66267, 66047, 66057, 81077, 81047, 80385, 81078, 81080, 81050, 80388, 
81081, 81079, 81048, 80356, 80387
19906, 66277, 66267, 66047, 66057, 66278, 66268, 66048, 66058, 81080, 81050, 80388, 81081, 81083, 81053, 80391, 
81084, 81082, 81051, 80359, 80390
19907, 66278, 66268, 66048, 66058, 66279, 66269, 66049, 66059, 81083, 81053, 80391, 81084, 81086, 81056, 80394, 
81087, 81085, 81054, 80362, 80393
19908, 66279, 66269, 66049, 66059, 66280, 66270, 66050, 66060, 81086, 81056, 80394, 81087, 81089, 81059, 80397, 
81090, 81088, 81057, 80365, 80396
19909, 66280, 66270, 66050, 66060, 66281, 66271, 66051, 66061, 81089, 81059, 80397, 81090, 81092, 81062, 80400, 
81093, 81091, 81060, 80368, 80399
19910, 66281, 66271, 66051, 66061, 66282, 66272, 66052, 66062, 81092, 81062, 80400, 81093, 81095, 81065, 80403, 
81096, 81094, 81063, 80371, 80402
19911, 66282, 66272, 66052, 66062, 18399, 18398, 18376, 18377, 81095, 81065, 80403, 81096, 19369, 19366, 19324, 
19368, 81097, 81066, 80374, 80405
19912, 16904, 16903, 16881, 16882, 66283, 66273, 66053, 66063, 17874, 17873, 17829, 17875, 81099, 81069, 80407, 
81100, 81098, 81067, 80375, 80406
19913, 66283, 66273, 66053, 66063, 66284, 66274, 66054, 66064, 81099, 81069, 80407, 81100, 81102, 81072, 80410, 
81103, 81101, 81070, 80378, 80409
19914, 66284, 66274, 66054, 66064, 66285, 66275, 66055, 66065, 81102, 81072, 80410, 81103, 81105, 81075, 80413, 
81106, 81104, 81073, 80381, 80412
19915, 66285, 66275, 66055, 66065, 66286, 66276, 66056, 66066, 81105, 81075, 80413, 81106, 81108, 81078, 80416, 
81109, 81107, 81076, 80384, 80415
19916, 66286, 66276, 66056, 66066, 66287, 66277, 66057, 66067, 81108, 81078, 80416, 81109, 81111, 81081, 80419, 
81112, 81110, 81079, 80387, 80418
19917, 66287, 66277, 66057, 66067, 66288, 66278, 66058, 66068, 81111, 81081, 80419, 81112, 81114, 81084, 80422, 
81115, 81113, 81082, 80390, 80421
19918, 66288, 66278, 66058, 66068, 66289, 66279, 66059, 66069, 81114, 81084, 80422, 81115, 81117, 81087, 80425, 
81118, 81116, 81085, 80393, 80424
19919, 66289, 66279, 66059, 66069, 66290, 66280, 66060, 66070, 81117, 81087, 80425, 81118, 81120, 81090, 80428, 
81121, 81119, 81088, 80396, 80427
19920, 66290, 66280, 66060, 66070, 66291, 66281, 66061, 66071, 81120, 81090, 80428, 81121, 81123, 81093, 80431, 
81124, 81122, 81091, 80399, 80430
19921, 66291, 66281, 66061, 66071, 66292, 66282, 66062, 66072, 81123, 81093, 80431, 81124, 81126, 81096, 80434, 
81127, 81125, 81094, 80402, 80433
19922, 66292, 66282, 66062, 66072, 18400, 18399, 18377, 18378, 81126, 81096, 80434, 81127, 19371, 19368, 19326, 
19370, 81128, 81097, 80405, 80436
19923, 16905, 16904, 16882, 16883, 66293, 66283, 66063, 66073, 17876, 17875, 17831, 17877, 81130, 81100, 80438, 
81131, 81129, 81098, 80406, 80437
19924, 66293, 66283, 66063, 66073, 66294, 66284, 66064, 66074, 81130, 81100, 80438, 81131, 81133, 81103, 80441, 
81134, 81132, 81101, 80409, 80440
19925, 66294, 66284, 66064, 66074, 66295, 66285, 66065, 66075, 81133, 81103, 80441, 81134, 81136, 81106, 80444, 
81137, 81135, 81104, 80412, 80443
19926, 66295, 66285, 66065, 66075, 66296, 66286, 66066, 66076, 81136, 81106, 80444, 81137, 81139, 81109, 80447, 
81140, 81138, 81107, 80415, 80446
19927, 66296, 66286, 66066, 66076, 66297, 66287, 66067, 66077, 81139, 81109, 80447, 81140, 81142, 81112, 80450, 
81143, 81141, 81110, 80418, 80449
19928, 66297, 66287, 66067, 66077, 66298, 66288, 66068, 66078, 81142, 81112, 80450, 81143, 81145, 81115, 80453, 
81146, 81144, 81113, 80421, 80452
19929, 66298, 66288, 66068, 66078, 66299, 66289, 66069, 66079, 81145, 81115, 80453, 81146, 81148, 81118, 80456, 
81149, 81147, 81116, 80424, 80455
19930, 66299, 66289, 66069, 66079, 66300, 66290, 66070, 66080, 81148, 81118, 80456, 81149, 81151, 81121, 80459, 
81152, 81150, 81119, 80427, 80458
19931, 66300, 66290, 66070, 66080, 66301, 66291, 66071, 66081, 81151, 81121, 80459, 81152, 81154, 81124, 80462, 
81155, 81153, 81122, 80430, 80461
19932, 66301, 66291, 66071, 66081, 66302, 66292, 66072, 66082, 81154, 81124, 80462, 81155, 81157, 81127, 80465, 
81158, 81156, 81125, 80433, 80464
19933, 66302, 66292, 66072, 66082, 18401, 18400, 18378, 18379, 81157, 81127, 80465, 81158, 19373, 19370, 19328, 
19372, 81159, 81128, 80436, 80467
19934, 16906, 16905, 16883, 16884, 66303, 66293, 66073, 66083, 17878, 17877, 17833, 17879, 81161, 81131, 80469, 
81162, 81160, 81129, 80437, 80468
19935, 66303, 66293, 66073, 66083, 66304, 66294, 66074, 66084, 81161, 81131, 80469, 81162, 81164, 81134, 80472, 
81165, 81163, 81132, 80440, 80471
19936, 66304, 66294, 66074, 66084, 66305, 66295, 66075, 66085, 81164, 81134, 80472, 81165, 81167, 81137, 80475, 
81168, 81166, 81135, 80443, 80474
19937, 66305, 66295, 66075, 66085, 66306, 66296, 66076, 66086, 81167, 81137, 80475, 81168, 81170, 81140, 80478, 
81171, 81169, 81138, 80446, 80477
19938, 66306, 66296, 66076, 66086, 66307, 66297, 66077, 66087, 81170, 81140, 80478, 81171, 81173, 81143, 80481, 
81174, 81172, 81141, 80449, 80480
19939, 66307, 66297, 66077, 66087, 66308, 66298, 66078, 66088, 81173, 81143, 80481, 81174, 81176, 81146, 80484, 
81177, 81175, 81144, 80452, 80483
19940, 66308, 66298, 66078, 66088, 66309, 66299, 66079, 66089, 81176, 81146, 80484, 81177, 81179, 81149, 80487, 
81180, 81178, 81147, 80455, 80486
19941, 66309, 66299, 66079, 66089, 66310, 66300, 66080, 66090, 81179, 81149, 80487, 81180, 81182, 81152, 80490, 
81183, 81181, 81150, 80458, 80489
19942, 66310, 66300, 66080, 66090, 66311, 66301, 66081, 66091, 81182, 81152, 80490, 81183, 81185, 81155, 80493, 
81186, 81184, 81153, 80461, 80492
19943, 66311, 66301, 66081, 66091, 66312, 66302, 66082, 66092, 81185, 81155, 80493, 81186, 81188, 81158, 80496, 
81189, 81187, 81156, 80464, 80495
19944, 66312, 66302, 66082, 66092, 18402, 18401, 18379, 18380, 81188, 81158, 80496, 81189, 19375, 19372, 19330, 
19374, 81190, 81159, 80467, 80498
19945, 16907, 16906, 16884, 16885, 66313, 66303, 66083, 66093, 17880, 17879, 17835, 17881, 81192, 81162, 80500, 
81193, 81191, 81160, 80468, 80499
19946, 66313, 66303, 66083, 66093, 66314, 66304, 66084, 66094, 81192, 81162, 80500, 81193, 81195, 81165, 80503, 
81196, 81194, 81163, 80471, 80502
19947, 66314, 66304, 66084, 66094, 66315, 66305, 66085, 66095, 81195, 81165, 80503, 81196, 81198, 81168, 80506, 
81199, 81197, 81166, 80474, 80505
19948, 66315, 66305, 66085, 66095, 66316, 66306, 66086, 66096, 81198, 81168, 80506, 81199, 81201, 81171, 80509, 
81202, 81200, 81169, 80477, 80508
19949, 66316, 66306, 66086, 66096, 66317, 66307, 66087, 66097, 81201, 81171, 80509, 81202, 81204, 81174, 80512, 
81205, 81203, 81172, 80480, 80511
19950, 66317, 66307, 66087, 66097, 66318, 66308, 66088, 66098, 81204, 81174, 80512, 81205, 81207, 81177, 80515, 
81208, 81206, 81175, 80483, 80514
19951, 66318, 66308, 66088, 66098, 66319, 66309, 66089, 66099, 81207, 81177, 80515, 81208, 81210, 81180, 80518, 
81211, 81209, 81178, 80486, 80517
19952, 66319, 66309, 66089, 66099, 66320, 66310, 66090, 66100, 81210, 81180, 80518, 81211, 81213, 81183, 80521, 
81214, 81212, 81181, 80489, 80520
19953, 66320, 66310, 66090, 66100, 66321, 66311, 66091, 66101, 81213, 81183, 80521, 81214, 81216, 81186, 80524, 
81217, 81215, 81184, 80492, 80523
19954, 66321, 66311, 66091, 66101, 66322, 66312, 66092, 66102, 81216, 81186, 80524, 81217, 81219, 81189, 80527, 
81220, 81218, 81187, 80495, 80526
19955, 66322, 66312, 66092, 66102, 18403, 18402, 18380, 18381, 81219, 81189, 80527, 81220, 19377, 19374, 19332, 
19376, 81221, 81190, 80498, 80529
19956, 16908, 16907, 16885, 16886, 66323, 66313, 66093, 66103, 17882, 17881, 17837, 17883, 81223, 81193, 80531, 
81224, 81222, 81191, 80499, 80530
