22068, 22069, 22070, 22071, 22072, 22073, 22074, 22075, 22076, 22077, 
22078, 22079, 22080, 22081, 22082, 22083, 22084, 22085, 22086, 22087, 
22088, 22089, 22090, 22091, 22092, 22093, 22094, 22095, 22096, 22097, 
22098, 22099, 22100, 22101, 22102, 22103, 22104, 22105, 22106, 22107, 
22108, 22109, 22110, 22111, 22112, 22113, 22114, 22115, 22116, 22117, 
22118, 22119, 22120, 22121, 22122, 22123, 22124, 22125, 22126, 22127, 
22128, 22129, 22130, 22131, 22132, 22133, 22134, 22135, 22136, 22137, 
22138, 22139, 22140, 22141, 22142, 22143, 22144, 22145, 22146, 22147, 
22148, 22149, 22150, 22151, 22152, 22153, 22154, 22155, 22156, 22157, 
22158, 22159, 22160, 22161, 22162, 22163, 22164, 22165, 22166, 22167, 
22168, 22169, 22170, 22171, 22172, 22173, 22174, 22175, 22176, 22177, 
22178, 22179, 22180, 22181, 22182, 22183, 22184, 22185, 22186, 22187, 
22188, 22189, 22190, 22191, 22192, 22193, 22194, 22195, 22196, 22197, 
22198, 22199, 22200, 22201, 22202, 22203, 22204, 22205, 22206, 22207, 
22208, 22209, 22210, 22211, 22212, 22213, 22214, 22215, 22216, 22217, 
22218, 22219, 22220, 22221, 22222, 22223, 22224, 22225, 22226, 22227, 
22228, 22229, 22230, 22231, 22232, 22233, 22234, 22235, 22236, 22237, 
22238, 22239, 22240, 22241, 22242, 22243, 22244, 22245, 22246, 22247, 
22248, 22249, 22250, 22251, 22252, 22253, 22254, 22255, 22256, 22257, 
22258, 22259, 22260, 22261, 22262, 22263, 22264, 22265, 22266, 22267, 
22268, 22269, 22270, 22271, 22272, 22273, 22274, 22275, 22276, 22277, 
22278, 22279, 22280, 22281, 22282, 22283, 22284, 22285, 22286, 22287, 
22288, 22289, 22290, 22291, 22292, 22293, 22294, 22295, 22296, 22297, 
22298, 22299, 22300, 22301, 22302, 22303, 22304, 22305, 22306, 22307, 
22308, 22309, 22310, 22311, 22312, 22313, 22314, 22315, 22316, 22317, 
22318, 22319, 22320, 22321, 22322, 22323, 22324, 22325, 22326, 22327, 
22328, 22329, 22330, 22331, 22332, 22333, 22334, 22335, 22336, 22337, 
22338, 22339, 22340, 22341, 22342, 22343, 22344, 22345, 22346, 22347, 
22348, 22349, 22350, 22351, 22352, 22353, 22354, 22355, 22356, 22357, 
22358, 22359, 22360, 22361, 22362, 22363, 22364, 22365, 22366, 22367, 
22368, 22369, 22370, 22371, 22372, 22373, 22374, 22375, 22376, 22377, 
22378, 22379, 22380, 22381, 22382, 22383, 22384, 22385, 22386, 22387, 
22388, 22389, 22390, 22391, 22392, 22393, 22394, 22395, 22396, 22397, 
22398, 22399, 22400, 22401, 22402, 22403, 22404, 22405, 22406, 22407, 
22408, 22409, 22410, 22411, 22412, 22413, 22414, 22415, 22416, 22417, 
22418, 22419, 22420, 22421, 22422, 22423, 22424, 22425, 22426, 22427, 
22428, 22429, 22430, 22431, 22432, 22433, 22434, 22435, 22436, 22437, 
22438, 22439, 22440, 22441, 22442, 22443, 22444, 22445, 22446, 22447, 
22448, 22449, 22450, 22451, 22452, 22453, 22454, 22455, 22456, 22457, 
22458, 22459, 22460, 22461, 22462, 22463, 22464, 22465, 22466, 22467, 
22468, 22469, 22470, 22471, 22472, 22473, 22474, 22475, 22476, 22477, 
22478, 22479, 22480, 22481, 22482, 22483, 22484, 22485, 22486, 22487, 
22488, 22489, 22490, 22491, 22492, 22493, 22494, 22495, 22496, 22497, 
22498, 22499, 22500, 22501, 22502, 22503, 22504, 22505, 22506, 22507, 
22508, 22509, 22510, 22511, 22512, 22513, 22514, 22515, 22516, 22517, 
22518, 22519, 22520, 22521, 22522, 22523, 22524, 22525, 22526, 22527, 
22528, 22529, 22530, 22531, 22532, 22533, 22534, 22535, 22536, 22537, 
22538, 22539, 22540, 22541, 22542, 22543, 22544, 22545, 22546, 22547, 
22548, 22549, 22550, 22551, 22552, 22553, 22554, 22555, 22556, 22557, 
22558, 22559, 22560, 22561, 22562, 22563, 22564, 22565, 22566, 22567, 
22568, 22569, 22570, 22571, 22572, 22573, 22574, 22575, 22576, 22577, 
22578, 22579, 22580, 22581, 22582, 22583, 22584, 22585, 22586, 22587, 
22588, 22589, 22590, 22591, 22592, 22593, 22594, 22595, 22596, 22597, 
22598, 22599, 22600, 22601, 22602, 22603, 22604, 22605, 22606, 22607, 
22608, 22609, 22610, 22611, 22612, 22613, 22614, 22615, 22616, 22617, 
22618, 22619, 22620, 22621, 22622, 22623, 22624, 22625, 22626, 22627, 
22628, 22629, 22630, 22631, 22632, 22633, 22634, 22635, 22636, 22637, 
22638, 22639, 22640, 22641, 22642, 22643, 22644, 22645, 22646, 22647, 
22648, 22649, 22650, 22651, 22652, 22653, 22654, 22655, 22656, 22657, 
22658, 22659, 22660, 22661, 22662, 22663, 22664, 22665, 22666, 22667, 
22668, 22669, 22670, 22671, 22672, 22673, 22674, 22675, 22676, 22677, 
22678, 22679, 22680, 22681, 22682, 22683, 22684, 22685, 22686, 22687, 
22688, 22689, 22690, 22691, 22692, 22693, 22694, 22695, 22696, 22697, 
22698, 22699, 22700, 22701, 22702, 22703, 22704, 22705, 22706, 22707, 
22708, 22709, 22710, 22711, 22712, 22713, 22714, 22715, 22716, 22717, 
22718, 22719, 22720, 22721, 22722, 22723, 22724, 22725, 22726, 22727, 
22728, 22729, 22730, 22731, 22732, 22733, 22734, 22735, 22736, 22737, 
22738, 22739, 22740, 22741, 22742, 22743, 22744, 22745, 22746, 22747, 
22748, 22749, 22750, 22751, 22752, 22753, 22754, 22755, 22756, 22757, 
22758, 22759, 22760, 22761, 22762, 22763, 22764, 22765, 22766, 22767, 
22768, 22769, 22770, 22771, 22772, 22773, 22774, 22775, 22776, 22777, 
22778, 22779, 22780, 22781, 22782, 22783, 22784, 22785, 22786, 22787, 
22788, 22789, 22790, 22791, 22792, 22793, 22794, 22795, 22796, 22797, 
22798, 22799, 22800, 22801, 22802, 22803, 22804, 22805, 22806, 22807, 
22808, 22809, 22810, 22811, 22812, 22813, 22814, 22815, 22816, 22817, 
22818, 22819, 22820, 22821, 22822, 22823, 22824, 22825, 22826, 22827, 
22828, 22829, 22830, 22831, 22832, 22833, 22834, 22835, 22836, 22837, 
22838, 22839, 22840, 22841, 22842, 22843, 22844, 22845, 22846, 22847, 
22848, 22849, 22850, 22851, 22852, 22853, 22854, 22855, 22856, 22857, 
22858, 22859, 22860, 22861, 22862, 22863, 22864, 22865, 22866, 22867, 
22868, 22869, 22870, 22871, 22872, 22873, 22874, 22875, 22876, 22877, 
22878, 22879, 22880, 22881, 22882, 22883, 22884, 22885, 22886, 22887, 
22888, 22889, 22890, 22891, 22892, 22893, 22894, 22895, 22896, 22897, 
22898, 22899, 22900, 22901, 22902, 22903, 22904, 22905, 22906, 22907, 
22908, 22909, 22910, 22911, 22912, 22913, 22914, 22915, 22916, 22917, 
22918, 22919, 22920, 22921, 22922, 22923, 22924, 22925, 22926, 22927, 
22928, 22929, 22930, 22931, 22932, 22933, 22934, 22935, 22936, 22937, 
22938, 22939, 22940, 22941, 22942, 22943, 22944, 22945, 22946, 22947, 
22948, 22949, 22950, 22951, 22952, 22953, 22954, 22955, 22956, 22957, 
22958, 22959, 22960, 22961, 22962, 22963, 22964, 22965, 22966, 22967, 
22968, 22969, 22970, 22971, 22972, 22973, 22974, 22975, 22976, 22977, 
22978, 22979, 22980, 22981, 22982, 22983, 22984, 22985, 22986, 22987, 
22988, 22989, 22990, 22991, 22992, 22993, 22994, 22995, 22996, 22997, 
22998, 22999, 23000, 23001, 23002, 23003, 23004, 23005, 23006, 23007, 
23008, 23009, 23010, 23011, 23012, 23013, 23014, 23015, 23016, 23017, 
23018, 23019, 23020, 23021, 23022, 23023, 23024, 23025, 23026, 23027, 
23028, 23029, 23030, 23031, 23032, 23033, 23034, 23035, 23036, 23037, 
23038, 23039, 23040, 23041, 23042, 23043, 23044, 23045, 23046, 23047, 
23048, 23049, 23050, 23051, 23052, 23053, 23054, 23055, 23056, 23057, 
23058, 23059, 23060, 23061, 23062, 23063, 23064, 23065, 23066, 23067, 
23068, 23069, 23070, 23071, 23072, 23073, 23074, 23075, 23076, 23077, 
23078, 23079, 23080, 23081, 23082, 23083, 23084, 23085, 23086, 23087, 
23088, 23089, 23090, 23091, 23092, 23093, 23094, 23095, 23096, 23097, 
23098, 23099, 23100, 23101, 23102, 23103, 23104, 23105, 23106, 23107, 
23108, 23109, 23110, 23111, 23112, 23113, 23114, 23115, 23116, 23117, 
23118, 23119, 23120, 23121, 23122, 23123, 23124, 23125, 23126, 23127, 
23128, 23129, 23130, 23131, 23132, 23133, 23134, 23135, 23136, 23137, 
23138, 23139, 23140, 23141, 23142, 23143, 23144, 23145, 23146, 23147, 
23148, 23149, 23150, 23151, 23152, 23153, 23154, 23155, 23156, 23157, 
23158, 23159, 23160, 23161, 23162, 23163, 23164, 23165, 23166, 23167, 
23168, 23169, 23170, 23171, 23172, 23173, 23174, 23175, 23176, 23177, 
23178, 23179, 23180, 23181, 23182, 23183, 23184, 23185, 23186, 23187, 
23188, 23189, 23190, 23191, 23192, 23193, 23194, 23195, 23196, 23197, 
23198, 23199, 23200, 23201, 23202, 23203, 23204, 23205, 23206, 23207, 
23208, 23209, 23210, 23211, 23212, 23213, 23214, 23215, 23216, 23217, 
23218, 23219, 23220, 23221, 23222, 23223, 23224, 23225, 23226, 23227, 
23228, 23229, 23230, 23231, 23232, 23233, 23234, 23235, 23236, 23237, 
23238, 23239, 23240, 23241, 23242, 23243, 23244, 23245, 23246, 23247, 
23248, 23249, 23250, 23251, 23252, 23253, 23254, 23255, 23256, 23257, 
23258, 23259, 23260, 23261, 23262, 23263, 23264, 23265, 23266, 23267, 
23268, 23269, 23270, 23271, 23272, 23273, 23274, 23275, 23276, 23277, 
23278, 23279, 23280, 23281, 23282, 23283, 23284, 23285, 23286, 23287, 
23288, 23289, 23290, 23291, 23292, 23293, 23294, 23295, 23296, 23297, 
23298, 23299, 23300, 23301, 23302, 23303, 23304, 23305, 23306, 23307, 
23308, 23309, 23310, 23311, 23312, 23313, 23314, 23315, 23316, 23317, 
23318, 23319, 23320, 23321, 23322, 23323, 23324, 23325, 23326, 23327, 
23328, 23329, 23330, 23331, 23332, 23333, 23334, 23335, 23336, 23337, 
23338, 23339, 23340, 23341, 23342, 23343, 23344, 23345, 23346, 23347, 
23348, 23349, 23350, 23351, 23352, 23353, 23354, 23355, 23356, 23357, 
23358, 23359, 23360, 23361, 23362, 23363, 23364, 23365, 23366, 23367, 
23368, 23369, 23370, 23371, 23372, 23373, 23374, 23375, 23376, 23377, 
23378, 23379, 23380, 23381, 23382, 23383, 23384, 23385, 23386, 23387, 
23388, 23389, 23390, 23391, 23392, 23393, 23394, 23395, 23396, 23397, 
23398, 23399, 23400, 23401, 23402, 23403, 23404, 23405, 23406, 23407, 
23408, 23409, 23410, 23411, 23412, 23413, 23414, 23415, 23416, 23417, 
23418, 23419, 23420, 23421, 23422, 23423, 23424, 23425, 23426, 23427, 
23428, 23429, 23430, 23431, 23432, 23433, 23434, 23435, 23436, 23437, 
23438, 23439, 23440, 23441, 23442, 23443, 23444, 23445, 23446, 23447, 
23448, 23449, 23450, 23451, 23452, 23453, 23454, 23455, 23456, 23457, 
23458, 23459, 23460, 23461, 23462, 23463, 23464, 23465, 23466, 23467, 
23468, 23469, 23470, 23471, 23472, 23473, 23474, 23475, 23476, 23477, 
23478, 23479, 23480, 23481, 23482, 23483, 23484, 23485, 23486, 23487, 
23488, 23489, 23490, 23491, 23492, 23493, 23494, 23495, 23496, 23497, 
23498, 23499, 23500, 23501, 23502, 23503, 23504, 23505, 23506, 23507, 
23508, 23509, 23510, 23511, 23512, 23513, 23514, 23515, 23516, 23517, 
23518, 23519, 23520, 23521, 23522, 23523, 23524, 23525, 23526, 23527, 
23528, 23529, 23530, 23531, 23532, 23533, 23534, 23535, 23536, 23537, 
23538, 23539, 23540, 23541, 23542, 23543, 23544, 23545, 23546, 23547, 
23548, 23549, 23550, 23551, 23552, 23553, 23554, 23555, 23556, 23557, 
23558, 23559, 23560, 23561, 23562, 23563, 23564, 23565, 23566, 23567, 
23568, 23569, 23570, 23571, 23572, 23573, 23574, 23575, 23576, 23577, 
23578, 23579, 23580, 23581, 23582, 23583, 23584, 23585, 23586, 23587, 
23588, 23589, 23590, 23591, 23592, 23593, 23594, 23595, 23596, 23597, 
23598, 23599, 23600, 23601, 23602, 23603, 23604, 23605, 23606, 23607, 
23608, 23609, 23610, 23611, 23612, 23613, 23614, 23615, 23616, 23617, 
23618, 23619, 23620, 23621, 23622, 23623, 23624, 23625, 23626, 23627, 
23628, 23629, 23630, 23631, 23632, 23633, 23634, 23635, 23636, 23637, 
23638, 23639, 23640, 23641, 23642, 23643, 23644, 23645, 23646, 23647, 
23648, 23649, 23650, 23651, 23652, 23653, 23654, 23655, 23656, 23657, 
23658, 23659, 23660, 23661, 23662, 23663, 23664, 23665, 23666, 23667, 
23668, 23669, 23670, 23671, 23672, 23673, 23674, 23675, 23676, 23677, 
23678, 23679, 23680, 23681, 23682, 23683, 23684, 23685, 23686, 23687, 
23688, 23689, 23690, 23691, 23692, 23693, 23694, 23695, 23696, 23697, 
23698, 23699, 23700, 23701, 23702, 23703, 23704, 23705, 23706, 23707, 
23708, 23709, 23710, 23711, 23712, 23713, 23714, 23715, 23716, 23717, 
23718, 23719, 23720, 23721, 23722, 23723, 23724, 23725, 23726, 23727, 
23728, 23729, 23730, 23731, 23732, 23733, 23734, 23735, 23736, 23737, 
23738, 23739, 23740, 23741, 23742, 23743, 23744, 23745, 23746, 23747, 
23748, 23749, 23750, 23751, 23752, 23753, 23754, 23755, 23756, 23757, 
23758, 23759, 23760, 23761, 23762, 23763, 23764, 23765, 23766, 23767, 
23768, 23769, 23770, 23771, 23772, 23773, 23774, 23775, 23776, 23777, 
23778, 23779, 23780, 23781, 23782, 23783, 23784, 23785, 23786, 23787, 
23788, 23789, 23790, 23791, 23792, 23793, 23794, 23795, 23796, 23797, 
23798, 23799, 23800, 23801, 23802, 23803, 23804, 23805, 23806, 23807, 
23808, 23809, 23810, 23811, 23812, 23813, 23814, 23815, 23816, 23817, 
23818, 23819, 23820, 23821, 23822, 23823, 23824, 23825, 23826, 23827, 
23828, 23829, 23830, 23831, 23832, 23833, 23834, 23835, 23836, 23837, 
23838, 23839, 23840, 23841, 23842, 23843, 23844, 23845, 23846, 23847, 
23848, 23849, 23850, 23851, 23852, 23853, 23854, 23855, 23856, 23857, 
23858, 23859, 23860, 23861, 23862, 23863, 23864, 23865, 23866, 23867, 
23868, 23869, 23870, 23871, 23872, 23873, 23874, 23875, 23876, 23877, 
23878, 23879, 23880, 23881, 23882, 23883, 23884, 23885, 23886, 23887, 
23888, 23889, 23890, 23891, 23892, 23893, 23894, 23895, 23896, 23897, 
23898, 23899, 23900, 23901, 23902, 23903, 23904, 23905, 23906, 23907, 
23908, 23909, 23910, 23911, 23912, 23913, 23914, 23915, 23916, 23917, 
23918, 23919, 23920, 23921, 23922, 23923, 23924, 23925, 23926, 23927, 
23928, 23929, 23930, 23931, 23932, 23933, 23934, 23935, 23936, 23937, 
23938, 23939, 23940, 23941, 23942, 23943, 23944, 23945, 23946, 23947, 
23948, 23949, 23950, 23951, 23952, 23953, 23954, 23955, 23956, 23957, 
23958, 23959, 23960, 23961, 23962, 23963, 23964, 23965, 23966, 23967, 
23968, 23969, 23970, 23971, 23972, 23973, 23974, 23975, 23976, 23977, 
23978, 23979, 23980, 23981, 23982, 23983, 23984, 23985, 23986, 23987, 
23988, 23989, 23990, 23991, 23992, 23993, 23994, 23995, 23996, 23997, 
23998, 23999, 24000, 24001, 24002, 24003, 24004, 24005, 24006, 24007, 
24008, 24009, 24010, 24011, 24012, 24013, 24014, 24015, 24016, 24017, 
24018, 24019, 24020, 24021, 24022, 24023, 24024, 24025, 24026, 24027, 
24028, 24029, 24030, 24031, 24032, 24033, 24034, 24035, 24036, 24037, 
24038, 24039, 24040, 24041, 24042, 24043, 24044, 24045, 24046, 24047, 
24048, 24049, 24050, 24051, 24052, 24053, 24054, 24055, 24056, 24057, 
24058, 24059, 24060, 24061, 24062, 24063, 24064, 24065, 24066, 24067, 
24068, 24069, 24070, 24071, 24072, 24073, 24074, 24075, 24076, 24077, 
24078, 24079, 24080, 24081, 24082, 24083, 24084, 24085, 24086, 24087, 
24088, 24089, 24090, 24091, 24092, 24093, 24094, 24095, 24096, 24097, 
24098, 24099, 24100, 24101, 24102, 24103, 24104, 24105, 24106, 24107, 
24108, 24109, 24110, 24111, 24112, 24113, 24114, 24115, 24116, 24117, 
24118, 24119, 24120, 24121, 24122, 24123, 24124, 24125, 24126, 24127, 
24128, 24129, 24130, 24131, 24132, 24133, 24134, 24135, 24136, 24137, 
24138, 24139, 24140, 24141, 24142, 24143, 24144, 24145, 24146, 24147, 
24148, 24149, 24150, 24151, 24152, 24153, 24154, 24155, 24156, 24157, 
24158, 24159, 24160, 24161, 24162, 24163, 24164, 24165, 24166, 24167, 
24168, 24169, 24170, 24171, 24172, 24173, 24174, 24175, 24176, 24177, 
24178, 24179, 24180, 24181, 24182, 24183, 24184, 24185, 24186, 24187, 
24188, 24189, 24190, 24191, 24192, 24193, 24194, 24195, 24196, 24197, 
24198, 24199, 24200, 24201, 24202, 24203, 24204, 24205, 24206, 24207, 
24208, 24209, 24210, 24211, 24212, 24213, 24214, 24215, 24216, 24217, 
24218, 24219, 24220, 24221, 24222, 24223, 24224, 24225, 24226, 24227, 
24228, 24229, 24230, 24231, 24232, 24233, 24234, 24235, 24236, 24237, 
24238, 24239, 24240, 24241, 24242, 24243, 24244, 24245, 24246, 24247, 
24248, 24249, 24250, 24251, 24252, 24253, 24254, 24255, 24256, 24257, 
24258, 24259, 24260, 24261, 24262, 24263, 24264, 24265, 24266, 24267, 
24268, 24269, 24270, 24271, 24272, 24273, 24274, 24275, 24276, 24277, 
24278, 24279, 24280, 24281, 24282, 24283, 24284, 24285, 24286, 24287, 
24288, 24289, 24290, 24291, 24292, 24293, 24294, 24295, 24296, 24297, 
24298, 24299, 24300, 24301, 24302, 24303, 24304, 24305, 24306, 24307, 
24308, 24309, 24310, 24311, 24312, 24313, 24314, 24315, 24316, 24317, 
24318, 24319, 24320, 24321, 24322, 24323, 24324, 24325, 24326, 24327, 
24328, 24329, 24330, 24331, 24332, 24333, 24334, 24335, 24336, 24337, 
24338, 24339, 24340, 24341, 24342, 24343, 24344, 24345, 24346, 24347, 
24348, 24349, 24350, 24351, 24352, 24353, 24354, 24355, 24356, 24357, 
24358, 24359, 24360, 24361, 24362, 24363, 24364, 24365, 24366, 24367, 
24368, 24369, 24370, 24371, 24372, 24373, 24374, 24375, 24376, 24377, 
24378, 24379, 24380, 24381, 24382, 24383, 24384, 24385, 24386, 24387, 
24388, 24389, 24390, 24391, 24392, 24393, 24394, 24395, 24396, 24397, 
24398, 24399, 24400, 24401, 24402, 24403, 24404, 24405, 24406, 24407, 
24408, 24409, 24410, 24411, 24412, 24413, 24414, 24415, 24416, 24417, 
24418, 24419, 24420, 24421, 24422, 24423, 24424, 24425, 24426, 24427, 
24428, 24429, 24430, 24431, 24432, 24433, 24434, 24435, 24436, 24437, 
24438, 24439, 24440, 24441, 24442, 24443, 24444, 24445, 24446, 24447, 
24448, 24449, 24450, 24451, 24452, 24453, 24454, 24455, 24456, 24457, 
24458, 24459, 24460, 24461, 24462, 24463, 24464, 24465, 24466, 24467, 
24468, 24469, 24470, 24471, 24472, 24473, 24474, 24475, 24476, 24477, 
24478, 24479, 24480, 24481, 24482, 24483, 24484, 24485, 24486, 24487, 
24488, 24489, 24490, 24491, 24492, 24493, 24494, 24495, 24496, 24497, 
24498, 24499, 24500, 24501, 24502, 24503, 24504, 24505, 24506, 24507, 
24508, 24509, 24510, 24511, 24512, 24513, 24514, 24515, 24516, 24517, 
24518, 24519, 24520, 24521, 24522, 24523, 24524, 24525, 24526, 24527, 
24528, 24529, 24530, 24531, 24532, 24533, 24534, 24535, 24536, 24537, 
24538, 24539, 24540, 24541, 24542, 24543, 24544, 24545, 24546, 24547, 
24548, 24549, 24550, 24551, 24552, 24553, 24554, 24555, 24556, 24557, 
24558, 24559, 24560, 24561, 24562, 24563, 24564, 24565, 24566, 24567, 
24568, 24569, 24570, 24571, 24572, 24573, 24574, 24575, 24576, 24577, 
24578, 24579, 24580, 24581, 24582, 24583, 24584, 24585, 24586, 24587, 
24588, 24589, 24590, 24591, 24592, 24593, 24594, 24595, 24596, 24597, 
24598, 24599, 24600, 24601, 24602, 24603, 24604, 24605, 24606, 24607, 
24608, 24609, 24610, 24611, 24612, 24613, 24614, 24615, 24616, 24617, 
24618, 24619, 24620, 24621, 24622, 24623, 24624, 24625, 24626, 24627, 
24628, 24629, 24630, 24631, 24632, 24633, 24634, 24635, 24636, 24637, 
24638, 24639, 24640, 24641, 24642, 24643, 24644, 24645, 24646, 24647, 
24648, 24649, 24650, 24651, 24652, 24653, 24654, 24655, 24656, 24657, 
24658, 24659, 24660, 24661, 24662, 24663, 24664, 24665, 24666, 24667, 
24668, 24669, 24670, 24671, 24672, 24673, 24674, 24675, 24676, 24677, 
24678, 24679, 24680, 24681, 24682, 24683, 24684, 24685, 24686, 24687, 
24688, 24689, 24690, 24691, 24692, 24693, 24694, 24695, 24696, 24697, 
24698, 24699, 24700, 24701, 24702, 24703, 24704, 24705, 24706, 24707, 
24708, 24709, 24710, 24711, 24712, 24713, 24714, 24715, 24716, 24717, 
24718, 24719, 24720, 24721, 24722, 24723, 24724, 24725, 24726, 24727, 
24728, 24729, 24730, 24731, 24732, 24733, 24734, 24735, 24736, 24737, 
24738, 24739, 24740, 24741, 24742, 24743, 24744, 24745, 24746, 24747, 
24748, 24749, 24750, 24751, 24752, 24753, 24754, 24755, 24756, 24757, 
24758, 24759, 24760, 24761, 24762, 24763, 24764, 24765, 24766, 24767, 
24768, 24769, 24770, 24771, 24772, 24773, 24774, 24775, 24776, 24777, 
24778, 24779, 24780, 24781, 24782, 24783, 24784, 24785, 24786, 24787, 
24788, 24789, 24790, 24791, 24792, 24793, 24794, 24795, 24796, 24797, 
24798, 24799, 24800, 24801, 24802, 24803, 24804, 24805, 24806, 24807, 
24808, 24809, 24810, 24811, 24812, 24813, 24814, 24815, 24816, 24817, 
24818, 24819, 24820, 24821, 24822, 24823, 24824, 24825, 24826, 24827, 
24828, 24829, 24830, 24831, 24832, 24833, 24834, 24835, 24836, 24837, 
24838, 24839, 24840, 24841, 24842, 24843, 24844, 24845, 24846, 24847, 
24848, 24849, 24850, 24851, 24852, 24853, 24854, 24855, 24856, 24857, 
24858, 24859, 24860, 24861, 24862, 24863, 24864, 24865, 24866, 24867, 
24868, 24869, 24870, 24871, 24872, 24873, 24874, 24875, 24876, 24877, 
24878, 24879, 24880, 24881, 24882, 24883, 24884, 24885, 24886, 24887, 
24888, 24889, 24890, 24891, 24892, 24893, 24894, 24895, 24896, 24897, 
24898, 24899, 24900, 24901, 24902, 24903, 24904, 24905, 24906, 24907, 
24908, 24909, 24910, 24911, 24912, 24913, 24914, 24915, 24916, 24917, 
24918, 24919, 24920, 24921, 24922, 24923, 24924, 24925, 24926, 24927, 
24928, 24929, 24930, 24931, 24932, 24933, 24934, 24935, 24936, 24937, 
24938, 24939, 24940, 24941, 24942, 24943, 24944, 24945, 24946, 24947, 
24948, 24949, 24950, 24951, 24952, 24953, 24954, 24955, 24956, 24957, 
24958, 24959, 24960, 24961, 24962, 24963, 24964, 24965, 24966, 24967, 
24968, 24969, 24970, 24971, 24972, 24973, 24974, 24975, 24976, 24977, 
24978, 24979, 24980, 24981, 24982, 24983, 24984, 24985, 24986, 24987, 
24988, 24989, 24990, 24991, 24992, 24993, 24994, 24995, 24996, 24997, 
24998, 24999, 25000, 25001, 25002, 25003, 25004, 25005, 25006, 25007, 
25008, 25009, 25010, 25011, 25012, 25013, 25014, 25015, 25016, 25017, 
25018, 25019, 25020, 25021, 25022, 25023, 25024, 25025, 25026, 25027, 
25028, 25029, 25030, 25031, 25032, 25033, 25034, 25035, 25036, 25037, 
25038, 25039, 25040, 25041, 25042, 25043, 25044, 25045, 25046, 25047, 
25048, 25049, 25050, 25051, 25052, 25053, 25054, 25055, 25056, 25057, 
25058, 25059, 25060, 25061, 25062, 25063, 25064, 25065, 25066, 25067, 
25068, 25069, 25070, 25071, 25072, 25073, 25074, 25075, 25076, 25077, 
25078, 25079, 25080, 25081, 25082, 25083, 25084, 25085, 25086, 25087, 
25088, 25089, 25090, 25091, 25092, 25093, 25094, 25095, 25096, 25097, 
25098, 25099, 25100, 25101, 25102, 25103, 25104, 25105, 25106, 25107, 
25108, 25109, 25110, 25111, 25112, 25113, 25114, 25115, 25116, 25117, 
25118, 25119, 25120, 25121, 25122, 25123, 25124, 25125, 25126, 25127, 
25128, 25129, 25130, 25131, 25132, 25133, 25134, 25135, 25136, 25137, 
25138, 25139, 25140, 25141, 25142, 25143, 25144, 25145, 25146, 25147, 
25148, 25149, 25150, 25151, 25152, 25153, 25154, 25155, 25156, 25157, 
25158, 25159, 25160, 25161, 25162, 25163, 25164, 25165, 25166, 25167, 
25168, 25169, 25170, 25171, 25172, 25173, 25174, 25175, 25176, 25177, 
25178, 25179, 25180, 25181, 25182, 25183, 25184, 25185, 25186, 25187, 
25188, 25189, 25190, 25191, 25192, 25193, 25194, 25195, 25196, 25197, 
25198, 25199, 25200, 25201, 25202, 25203, 25204, 25205, 25206, 25207, 
25208, 25209, 25210, 25211, 25212, 25213, 25214, 25215, 25216, 25217, 
25218, 25219, 25220, 25221, 25222, 25223, 25224, 25225, 25226, 25227, 
25228, 25229, 25230, 25231, 25232, 25233, 25234, 25235, 25236, 25237, 
25238, 25239, 25240, 25241, 25242, 25243, 25244, 25245, 25246, 25247, 
25248, 25249, 25250, 25251, 25252, 25253, 25254, 25255, 25256, 25257, 
25258, 25259, 25260, 25261, 25262, 25263, 25264, 25265, 25266, 25267, 
25268, 25269, 25270, 25271, 25272, 25273, 25274, 25275, 25276, 25277, 
25278, 25279, 25280, 25281, 25282, 25283, 25284, 25285, 25286, 25287, 
25288, 25289, 25290, 25291, 25292, 25293, 25294, 25295, 25296, 25297, 
25298, 25299, 25300, 25301, 25302, 25303, 25304, 25305, 25306, 25307, 
25308, 25309, 25310, 25311, 25312, 25313, 25314, 25315, 25316, 25317, 
25318, 25319, 25320, 25321, 25322, 25323, 25324, 25325, 25326, 25327, 
25328, 25329, 25330, 25331, 25332, 25333, 25334, 25335, 25336, 25337, 
25338, 25339, 25340, 25341, 25342, 25343, 25344, 25345, 25346, 25347, 
25348, 25349, 25350, 25351, 25352, 25353, 25354, 25355, 25356, 25357, 
25358, 25359, 25360, 25361, 25362, 25363, 25364, 25365, 25366, 25367, 
25368, 25369, 25370, 25371, 25372, 25373, 25374, 25375, 25376, 25377, 
25378, 25379, 25380, 25381, 25382, 25383, 25384, 25385, 25386, 25387, 
25388, 25389, 25390, 25391, 25392, 25393, 25394, 25395, 25396, 25397, 
25398, 25399, 25400, 25401, 25402, 25403, 25404, 25405, 25406, 25407, 
25408, 25409, 25410, 25411, 25412, 25413, 25414, 25415, 25416, 25417, 
25418, 25419, 25420, 25421, 25422, 25423, 25424, 25425, 25426, 25427, 
25428, 25429, 25430, 25431, 25432, 25433, 25434, 25435, 25436, 25437, 
25438, 25439, 25440, 25441, 25442, 25443, 25444, 25445, 25446, 25447, 
25448, 25449, 25450, 25451, 25452, 25453, 25454, 25455, 25456, 25457, 
25458, 25459, 25460, 25461, 25462, 25463, 25464, 25465, 25466, 25467, 
25468, 25469, 25470, 25471, 25472, 25473, 25474, 25475, 25476, 25477, 
25478, 25479, 25480, 25481, 25482, 25483, 25484, 25485, 25486, 25487, 
25488, 25489, 25490, 25491, 25492, 25493, 25494, 25495, 25496, 25497, 
25498, 25499, 25500, 25501, 25502, 25503, 25504, 25505, 25506, 25507, 
25508, 25509, 25510, 25511, 25512, 25513, 25514, 25515, 25516, 25517, 
25518, 25519, 25520, 25521, 25522, 25523, 25524, 25525, 25526, 25527, 
25528, 25529, 25530, 25531, 25532, 25533, 25534, 25535, 25536, 25537, 
25538, 25539, 25540, 25541, 25542, 25543, 25544, 25545, 25546, 25547, 
25548, 25549, 25550, 25551, 25552, 25553, 25554, 25555, 25556, 25557, 
25558, 25559, 25560, 25561, 25562, 25563, 25564, 25565, 25566, 25567, 
25568, 25569, 25570, 25571, 25572, 25573, 25574, 25575, 25576, 25577, 
25578, 25579, 25580, 25581, 25582, 25583, 25584, 25585, 25586, 25587, 
25588, 25589, 25590, 25591, 25592, 25593, 25594, 25595, 25596, 25597, 
25598, 25599, 25600, 25601, 25602, 25603, 25604, 25605, 25606, 25607, 
25608, 25609, 25610, 25611, 25612, 25613, 25614, 25615, 25616, 25617, 
25618, 25619, 25620, 25621, 25622, 25623, 25624, 25625, 25626, 25627, 
25628, 25629, 25630, 25631, 25632, 25633, 25634, 25635, 25636, 25637, 
25638, 25639, 25640, 25641, 25642, 25643, 25644, 25645, 25646, 25647, 
25648, 25649, 25650, 25651, 25652, 25653, 25654, 25655, 25656, 25657, 
25658, 25659, 25660, 25661, 25662, 25663, 25664, 25665, 25666, 25667, 
25668, 25669, 25670, 25671, 25672, 25673, 25674, 25675, 25676, 25677, 
25678, 25679, 25680, 25681, 25682, 25683, 25684, 25685, 25686, 25687, 
25688, 25689, 25690, 25691, 25692, 25693, 25694, 25695, 25696, 25697, 
25698, 25699, 25700, 25701, 25702, 25703, 25704, 25705, 25706, 25707, 
25708, 25709, 25710, 25711, 25712, 25713, 25714, 25715, 25716, 25717, 
25718, 25719, 25720, 25721, 25722, 25723, 25724, 25725, 25726, 25727, 
25728, 25729, 25730, 25731, 25732, 25733, 25734, 25735, 25736, 25737, 
25738, 25739, 25740, 25741, 25742, 25743, 25744, 25745, 25746, 25747, 
25748, 25749, 25750, 25751, 25752, 25753, 25754, 25755, 25756, 25757, 
25758, 25759, 25760, 25761, 25762, 25763, 25764, 25765, 25766, 25767, 
25768, 25769, 25770, 25771, 25772, 25773, 25774, 25775, 25776, 25777, 
25778, 25779, 25780, 25781, 25782, 25783, 25784, 25785, 25786, 25787, 
25788, 25789, 25790, 25791, 25792, 25793, 25794, 25795, 25796, 25797, 
25798, 25799, 25800, 25801, 25802, 25803, 25804, 25805, 25806, 25807, 
25808, 25809, 25810, 25811, 25812, 25813, 25814, 25815, 25816, 25817, 
25818, 25819, 25820, 25821, 25822, 25823, 25824, 25825, 25826, 25827, 
25828, 25829, 25830, 25831, 25832, 25833, 25834, 25835, 25836, 25837, 
25838, 25839, 25840, 25841, 25842, 25843, 25844, 25845, 25846, 25847, 
25848, 25849, 25850, 25851, 25852, 25853, 25854, 25855, 25856, 25857, 
25858, 25859, 25860, 25861, 25862, 25863, 25864, 25865, 25866, 25867, 
25868, 25869, 25870, 25871, 25872, 25873, 25874, 25875, 25876, 25877, 
25878, 25879, 25880, 25881, 25882, 25883, 25884, 25885, 25886, 25887, 
25888, 25889, 25890, 25891, 25892, 25893, 25894, 25895, 25896, 25897, 
25898, 25899, 25900, 25901, 25902, 25903, 25904, 25905, 25906, 25907, 
25908, 25909, 25910, 25911, 25912, 25913, 25914, 25915, 25916, 25917, 
25918, 25919, 25920, 25921, 25922, 25923, 25924, 25925, 25926, 25927, 
25928, 25929, 25930, 25931, 25932, 25933, 25934, 25935, 25936, 25937, 
25938, 25939, 25940, 25941, 25942, 25943, 25944, 25945, 25946, 25947, 
25948, 25949, 25950, 25951, 25952, 25953, 25954, 25955, 25956, 25957, 
25958, 25959, 25960, 25961, 25962, 25963, 25964, 25965, 25966, 25967, 
25968, 25969, 25970, 25971, 25972, 25973, 25974, 25975, 25976, 25977, 
25978, 25979, 25980, 25981, 25982, 25983, 25984, 25985, 25986, 25987, 
25988, 25989, 25990, 25991, 25992, 25993, 25994, 25995, 25996, 25997, 
25998, 25999, 26000, 26001, 26002, 26003, 26004, 26005, 26006, 26007, 
26008, 26009, 26010, 26011, 26012, 26013, 26014, 26015, 26016, 26017, 
26018, 26019, 26020, 26021, 26022, 26023, 26024, 26025, 26026, 26027, 
26028, 26029, 26030, 26031, 26032, 26033, 26034, 26035, 26036, 26037, 
26038, 26039, 26040, 26041, 26042, 26043, 26044, 26045, 26046, 26047, 
26048, 26049, 26050, 26051, 26052, 26053, 26054, 26055, 26056, 26057, 
26058, 26059, 26060, 26061, 26062, 26063, 26064, 26065, 26066, 26067, 
26068, 26069, 26070, 26071, 26072, 26073, 26074, 26075, 26076, 26077, 
26078, 26079, 26080, 26081, 26082, 26083, 26084, 26085, 26086, 26087, 
26088, 26089, 26090, 26091, 26092, 26093, 26094, 26095, 26096, 26097, 
26098, 26099, 26100, 26101, 26102, 26103, 26104, 26105, 26106, 26107, 
26108, 26109, 26110, 26111, 26112, 26113, 26114, 26115, 26116, 26117, 
26118, 26119, 26120, 26121, 26122, 26123, 26124, 26125, 26126, 26127, 
26128, 26129, 26130, 26131, 26132, 26133, 26134, 26135, 26136, 26137, 
26138, 26139, 26140, 26141, 26142, 26143, 26144, 26145, 26146, 26147, 
26148, 26149, 26150, 26151, 26152, 26153, 26154, 26155, 26156, 26157, 
26158, 26159, 26160, 26161, 26162, 26163, 26164, 26165, 26166, 26167, 
26168, 26169, 26170, 26171, 26172, 26173, 26174, 26175, 26176, 26177, 
26178, 26179, 26180, 26181, 26182, 26183, 26184, 26185, 26186, 26187, 
26188, 26189, 26190, 26191, 26192, 26193, 26194, 26195, 26196, 26197, 
26198, 26199, 26200, 26201, 26202, 26203, 26204, 26205, 26206, 26207, 
26208, 26209, 26210, 26211, 26212, 26213, 26214, 26215, 26216, 26217, 
26218, 26219, 26220, 26221, 26222, 26223, 26224, 26225, 26226, 26227, 
26228, 26229, 26230, 26231, 26232, 26233, 26234, 26235, 26236, 26237, 
26238, 26239, 26240, 26241, 26242, 26243, 26244, 26245, 26246, 26247, 
26248, 26249, 26250, 26251, 26252, 26253, 26254, 26255, 26256, 26257, 
26258, 26259, 26260, 26261, 26262, 26263, 26264, 26265, 26266, 26267, 
26268, 26269, 26270, 26271, 26272, 26273, 26274, 26275, 26276, 26277, 
26278, 26279, 26280, 26281, 26282, 26283, 26284, 26285, 26286, 26287, 
26288, 26289, 26290, 26291, 26292, 26293, 26294, 26295, 26296, 26297, 
26298, 26299, 26300, 26301, 26302, 26303, 26304, 26305, 26306, 26307, 
26308, 26309, 26310, 26311, 26312, 26313, 26314, 26315, 26316, 26317, 
26318, 26319, 26320, 26321, 26322, 26323, 26324, 26325, 26326, 26327, 
26328, 26329, 26330, 26331, 26332, 26333, 26334, 26335, 26336, 26337, 
26338, 26339, 26340, 26341, 26342, 26343, 26344, 26345, 26346, 26347, 
26348, 26349, 26350, 26351, 26352, 26353, 26354, 26355, 26356, 26357, 
26358, 26359, 26360, 26361, 26362, 26363, 26364, 26365, 26366, 26367, 
26368, 26369, 26370, 26371, 26372, 26373, 26374, 26375, 26376, 26377, 
26378, 26379, 26380, 26381, 26382, 26383, 26384, 26385, 26386, 26387, 
26388, 26389, 26390, 26391, 26392, 26393, 26394, 26395, 26396, 26397, 
26398, 26399, 26400, 26401, 26402, 26403, 26404, 26405, 26406, 26407, 
26408, 26409, 26410, 26411, 26412, 26413, 26414, 26415, 26416, 26417, 
26418, 26419, 26420, 26421, 26422, 26423, 26424, 26425, 26426, 26427, 
26428, 26429, 26430, 26431, 26432, 26433, 26434, 26435, 26436, 26437, 
26438, 26439, 26440, 26441, 26442, 26443, 26444, 26445, 26446, 26447, 
26448, 26449, 26450, 26451, 26452, 26453, 26454, 26455, 26456, 26457, 
26458, 26459, 26460, 26461, 26462, 26463, 26464, 26465, 26466, 26467, 
26468, 26469, 26470, 26471, 26472, 26473, 26474, 26475, 26476, 26477, 
26478, 26479, 26480, 26481, 26482, 26483, 26484, 26485, 26486, 26487, 
26488, 26489, 26490, 26491, 26492, 26493, 26494, 26495, 26496, 26497, 
26498, 26499, 26500, 26501, 26502, 26503, 26504, 26505, 26506, 26507, 
26508, 26509, 26510, 26511, 26512, 26513, 26514, 26515, 26516, 26517, 
26518, 26519, 26520, 26521, 26522, 26523, 26524, 26525, 26526, 26527, 
26528, 26529, 26530, 26531, 26532, 26533, 26534, 26535, 26536, 26537, 
26538, 26539, 26540, 26541, 26542, 26543, 26544, 26545, 26546, 26547, 
26548, 26549, 26550, 26551, 26552, 26553, 26554, 26555, 26556, 26557, 
26558, 26559, 26560, 26561, 26562, 26563, 26564, 26565, 26566, 26567, 
26568, 26569, 26570, 26571, 26572, 26573, 26574, 26575, 26576, 26577, 
26578, 26579, 26580, 26581, 26582, 26583, 26584, 26585, 26586, 26587, 
26588, 26589, 26590, 26591, 26592, 26593, 26594, 26595, 26596, 26597, 
26598, 26599, 26600, 26601, 26602, 26603, 26604, 26605, 26606, 26607, 
26608, 26609, 26610, 26611, 26612, 26613, 26614, 26615, 26616, 26617, 
26618, 26619, 26620, 26621, 26622, 26623, 26624, 26625, 26626, 26627, 
26628, 26629, 26630, 26631, 26632, 26633, 26634, 26635, 26636, 26637, 
26638, 26639, 26640, 26641, 26642, 26643, 26644, 26645, 26646, 26647, 
26648, 26649, 26650, 26651, 26652, 26653, 26654, 26655, 26656, 26657, 
26658, 26659, 26660, 26661, 26662, 26663, 26664, 26665, 26666, 26667, 
26668, 26669, 26670, 26671, 26672, 26673, 26674, 26675, 26676, 26677, 
26678, 26679, 26680, 26681, 26682, 26683, 26684, 26685, 26686, 26687, 
26688, 26689, 26690, 26691, 26692, 26693, 26694, 26695, 26696, 26697, 
26698, 26699, 26700, 26701, 26702, 26703, 26704, 26705, 26706, 26707, 
26708, 26709, 26710, 26711, 26712, 26713, 26714, 26715, 26716, 26717, 
26718, 26719, 26720, 26721, 26722, 26723, 26724, 26725, 26726, 26727, 
26728, 26729, 26730, 26731, 26831, 26832, 26833, 26834, 26835, 26836, 
26837, 26838, 26839, 26840, 26841, 26842, 26843, 26844, 26845, 26846, 
26847, 26848, 26849, 26850, 26851, 26852, 26853, 26854, 26855, 26856, 
26857, 26858, 26859, 26860, 26861, 26862, 26863, 26864, 26865, 26866, 
26867, 26868, 26869, 26870, 26871, 26872, 26873, 26874, 26875, 26876, 
26877, 26878, 26879, 26880, 26881, 26882, 26883, 26884, 26885, 26886, 
26887, 26888, 26889, 26890, 26891, 26892, 26893, 26894, 26895, 26896, 
26897, 26898, 26899, 26900, 26901, 26902, 26903, 26904, 26905, 26906, 
26907, 26908, 26909, 26910, 26911, 26912, 26913, 26914, 26915, 26916, 
26917, 26918, 26919, 26920, 26921, 26922, 26923, 26924, 26925, 26926, 
26927, 26928, 26929, 26930, 26931, 26932, 26933, 26934, 26935, 26936, 
26937, 26938, 26939, 26940, 26941, 26942, 26943, 26944, 26945, 26946, 
26947, 26948, 26949, 26950, 26951, 26952, 26953, 26954, 26955, 26956, 
26957, 26958, 26959, 26960, 26961, 26962, 
*ELSET,ELSET=Copper
4787, 4788, 4789, 4790, 4791, 4792, 4793, 4794, 4795, 4796, 
4797, 4798, 4799, 4800, 4801, 4802, 4803, 4804, 4805, 4806, 
4807, 4808, 4809, 4810, 4811, 4812, 4813, 4814, 4815, 4816, 
4817, 4818, 4819, 4820, 4821, 4822, 4823, 4824, 4825, 4826, 
4827, 4828, 4829, 4830, 4831, 4832, 4833, 4834, 4835, 4836, 
4837, 4838, 4839, 4840, 4841, 4842, 4843, 4844, 4845, 4846, 
4847, 4848, 4849, 4850, 4851, 4852, 4853, 4854, 4855, 4856, 
4857, 4858, 4859, 4860, 4861, 4862, 4863, 4864, 4865, 4866, 
4867, 4868, 4869, 4870, 4871, 4872, 4873, 4874, 4875, 4876, 
4877, 4878, 4879, 4880, 4881, 4882, 4883, 4884, 4885, 4886, 
4887, 4888, 4889, 4890, 4891, 4892, 4893, 4894, 4895, 4896, 
4897, 4898, 4899, 4900, 4901, 4902, 4903, 4904, 4905, 4906, 
4907, 4908, 4909, 4910, 4911, 4912, 4913, 4914, 4915, 4916, 
4917, 4918, 4919, 4920, 4921, 4922, 4923, 4924, 4925, 4926, 
4927, 4928, 4929, 4930, 4931, 4932, 4933, 4934, 4935, 4936, 
4937, 4938, 4939, 4940, 4941, 4942, 4943, 4944, 4945, 4946, 
4947, 4948, 4949, 4950, 4951, 4952, 4953, 4954, 4955, 4956, 
4957, 4958, 4959, 4960, 4961, 4962, 4963, 4964, 4965, 4966, 
4967, 4968, 4969, 4970, 4971, 4972, 4973, 4974, 4975, 4976, 
4977, 4978, 4979, 4980, 4981, 4982, 4983, 4984, 4985, 4986, 
4987, 4988, 4989, 4990, 4991, 4992, 4993, 4994, 4995, 4996, 
4997, 4998, 4999, 5000, 5001, 5002, 5003, 5004, 5005, 5006, 
5007, 5008, 5009, 5010, 5011, 5012, 5013, 5014, 5015, 5016, 
5017, 5018, 5019, 5020, 5021, 5022, 5023, 5024, 5025, 5026, 
5027, 5028, 5029, 5030, 5031, 5032, 5033, 5034, 5035, 5036, 
5037, 5038, 5039, 5040, 5041, 5042, 5043, 5044, 5045, 5046, 
5047, 5048, 5049, 5050, 5051, 5052, 5053, 5054, 5055, 5056, 
5057, 5058, 5059, 5060, 5061, 5062, 5063, 5064, 5065, 5066, 
5067, 5068, 5069, 5070, 5071, 5072, 5073, 5074, 5075, 5076, 
5077, 5078, 5079, 5080, 5081, 5082, 5083, 5084, 5085, 5086, 
5087, 5088, 5089, 5090, 5091, 5092, 5093, 5094, 5095, 5096, 
5097, 5098, 5099, 5100, 5101, 5102, 5103, 5104, 5105, 5106, 
5107, 5108, 5109, 5110, 5111, 5112, 5113, 5114, 5115, 5116, 
5117, 5118, 5119, 5120, 5121, 5122, 5123, 5124, 5125, 5126, 
5127, 5128, 5129, 5130, 5131, 5132, 5133, 5134, 5135, 5136, 
5137, 5138, 5139, 5140, 5141, 5142, 5143, 5144, 5145, 5146, 
5147, 5148, 5149, 5150, 5151, 5152, 5153, 5154, 5155, 5156, 
5157, 5158, 5159, 5160, 5161, 5162, 5163, 5164, 5165, 5166, 
5167, 5168, 5169, 5170, 5171, 5172, 5173, 5174, 5175, 5176, 
5177, 5178, 5179, 5180, 5181, 5182, 5183, 5184, 5185, 5186, 
5187, 5188, 5189, 5190, 5191, 5192, 5193, 5194, 5195, 5196, 
5197, 5198, 5199, 5200, 5201, 5202, 5203, 5204, 5205, 5206, 
5207, 5208, 5209, 5210, 5211, 5212, 5213, 5214, 5215, 5216, 
5217, 5218, 5219, 5220, 5221, 5222, 5223, 5224, 5225, 5226, 
5227, 5228, 5229, 5230, 5231, 5232, 5233, 5234, 5235, 5236, 
5237, 5238, 5239, 5240, 5241, 5242, 5243, 5244, 5245, 5246, 
5247, 5248, 5249, 5250, 5251, 5252, 5253, 5254, 5255, 5256, 
5257, 5258, 5259, 5260, 5261, 5262, 5263, 5264, 5265, 5266, 
5267, 5268, 5269, 5270, 5271, 5272, 5273, 5274, 5275, 5276, 
5277, 5278, 5279, 5280, 5281, 5282, 5283, 5284, 5285, 5286, 
5287, 5288, 5289, 5290, 5291, 5292, 5293, 5294, 5295, 5296, 
5297, 5298, 5299, 5300, 5301, 5302, 5303, 5304, 5305, 5306, 
5307, 5308, 5309, 5310, 5311, 5312, 5313, 5314, 5315, 5316, 
5317, 5318, 5319, 5320, 5321, 5322, 5323, 5324, 5325, 5326, 
5327, 5328, 5329, 5330, 5331, 5332, 5333, 5334, 5335, 5336, 
5337, 5338, 5339, 5340, 5341, 5342, 5343, 5344, 5345, 5346, 
5347, 5348, 5349, 5350, 5351, 5352, 5353, 5354, 5355, 5356, 
5357, 5358, 5359, 5360, 5361, 5362, 5363, 5364, 5365, 5366, 
5367, 5368, 5369, 5370, 5371, 5372, 5373, 5374, 5375, 5376, 
5377, 5378, 5379, 5380, 5381, 5382, 5383, 5384, 5385, 5386, 
5387, 5388, 5389, 5390, 5391, 5392, 5393, 5394, 5395, 5396, 
5397, 5398, 5399, 5400, 5401, 5402, 5403, 5404, 5405, 5406, 
5407, 5408, 5409, 5410, 5411, 5412, 5413, 5414, 5415, 5416, 
5417, 5418, 5419, 5420, 5421, 5422, 5423, 5424, 5425, 5426, 
5427, 5428, 5429, 5430, 5431, 5432, 5433, 5434, 5435, 5436, 
5437, 5438, 5439, 5440, 5441, 5442, 5443, 5444, 5445, 5446, 
5447, 5448, 5449, 5450, 5451, 5452, 5453, 5454, 5455, 5456, 
5457, 5458, 5459, 5460, 5461, 5462, 5463, 5464, 5465, 5466, 
5467, 5468, 5469, 5470, 5471, 5472, 5473, 5474, 5475, 5476, 
5477, 5478, 5479, 5480, 5481, 5482, 5483, 5484, 5485, 5486, 
5487, 5488, 5489, 5490, 5491, 5492, 5493, 5494, 5495, 5496, 
5497, 5498, 5499, 5500, 5501, 5502, 5503, 5504, 5505, 5506, 
5507, 5508, 5509, 5510, 5511, 5512, 5513, 5514, 5515, 5516, 
5517, 5518, 5519, 5520, 5521, 5522, 5523, 5524, 5525, 5526, 
5527, 5528, 5529, 5530, 5531, 5532, 5533, 5534, 5535, 5536, 
5537, 5538, 5539, 5540, 5541, 5542, 5543, 5544, 5545, 12377, 
12378, 12379, 12380, 12381, 12382, 12383, 12384, 12385, 12386, 12387, 
12388, 12389, 12390, 12391, 12392, 12393, 12394, 12395, 12396, 12397, 
12398, 12399, 12400, 12401, 12402, 12403, 12404, 12405, 12406, 12407, 
12408, 12409, 12410, 12411, 12412, 12413, 12414, 12415, 12416, 12417, 
12418, 12419, 12420, 12421, 12422, 12423, 12424, 12425, 12426, 12427, 
12428, 12429, 12430, 12431, 12432, 12433, 12434, 12435, 12436, 12437, 
12438, 12439, 12440, 12441, 12442, 12443, 12444, 12445, 12446, 12447, 
12448, 12449, 12450, 12451, 12452, 12453, 12454, 12455, 12456, 12457, 
12458, 12459, 12460, 12461, 12462, 12463, 12464, 12465, 12466, 12467, 
12468, 12469, 12470, 12471, 12472, 12473, 12474, 12475, 12476, 12477, 
12478, 12479, 12480, 12481, 12482, 12483, 12484, 12485, 12486, 12487, 
12488, 12489, 12490, 12491, 12492, 12493, 12494, 12495, 12496, 12497, 
12498, 12499, 12500, 12501, 12502, 12503, 12504, 12505, 12506, 12507, 
12508, 12509, 12510, 12511, 12512, 12513, 12514, 12515, 12516, 12517, 
12518, 12519, 12520, 12521, 12522, 12523, 12524, 12525, 12526, 12527, 
12528, 12529, 12530, 12531, 12532, 12533, 12534, 12535, 12536, 12537, 
12538, 12539, 12540, 12541, 12542, 12543, 12544, 12545, 12546, 12547, 
12548, 12549, 12550, 12551, 12552, 12553, 12554, 12555, 12556, 12557, 
12558, 12559, 12560, 12561, 12562, 12563, 12564, 12565, 12566, 12567, 
12568, 12569, 12570, 12571, 12572, 12573, 12574, 12575, 12576, 12577, 
12578, 12579, 12580, 12581, 12582, 12583, 12584, 12585, 12586, 12587, 
12588, 12589, 12590, 12591, 12592, 12593, 12594, 12595, 12596, 12597, 
12598, 12599, 12600, 12601, 12602, 12603, 12604, 12605, 12606, 12607, 
12608, 12609, 12610, 12611, 12612, 12613, 12614, 12615, 12616, 12617, 
12618, 12619, 12620, 12621, 12622, 12623, 12624, 12625, 12626, 12627, 
12628, 12629, 12630, 12631, 12632, 12633, 12634, 12635, 12636, 12637, 
12638, 12639, 12640, 12641, 12642, 12643, 12644, 12645, 12646, 12647, 
12648, 12649, 12650, 12651, 12652, 12653, 12654, 12655, 12656, 12657, 
12658, 12659, 12660, 12661, 12662, 12663, 12664, 12665, 12666, 12667, 
12668, 12669, 12670, 12671, 12672, 12673, 12674, 12675, 12676, 12677, 
12678, 12679, 12680, 12681, 12682, 12683, 12684, 12685, 12686, 12687, 
12688, 12689, 12690, 12691, 12692, 12693, 12694, 12695, 12696, 12697, 
12698, 12699, 12700, 12701, 12702, 12703, 12704, 12705, 12706, 12707, 
12708, 12709, 12710, 12711, 12712, 12713, 12714, 12715, 12716, 12717, 
12718, 12719, 12720, 12721, 12722, 12723, 12724, 12725, 12726, 12727, 
12728, 12729, 12730, 12731, 12732, 12733, 12734, 12735, 12736, 12737, 
12738, 12739, 12740, 12741, 12742, 12743, 12744, 12745, 12746, 12747, 
12748, 12749, 12750, 12751, 12752, 12753, 12754, 12755, 12756, 12757, 
12758, 12759, 12760, 12761, 12762, 12763, 12764, 12765, 12766, 12767, 
12768, 12769, 12770, 12771, 12772, 12773, 12774, 12775, 12776, 12777, 
12778, 12779, 12780, 12781, 12782, 12783, 12784, 12785, 12786, 12787, 
12788, 12789, 12790, 12791, 12792, 12793, 12794, 12795, 12796, 12797, 
12798, 12799, 12800, 12801, 12802, 12803, 12804, 12805, 12806, 12807, 
12808, 12809, 12810, 12811, 12812, 12813, 12814, 12815, 12816, 12817, 
12818, 12819, 12820, 12821, 12822, 12823, 12824, 12825, 12826, 12827, 
12828, 12829, 12830, 12831, 12832, 12833, 12834, 12835, 12836, 12837, 
12838, 12839, 12840, 12841, 12842, 12843, 12844, 12845, 12846, 12847, 
12848, 12849, 12850, 12851, 12852, 12853, 12854, 12855, 12856, 12857, 
12858, 12859, 12860, 12861, 12862, 12863, 12864, 12865, 12866, 12867, 
12868, 12869, 12870, 12871, 12872, 12873, 12874, 12875, 12876, 12877, 
12878, 12879, 12880, 12881, 12882, 12883, 12884, 12885, 12886, 12887, 
12888, 12889, 12890, 12891, 12892, 12893, 12894, 12895, 12896, 12897, 
12898, 12899, 12900, 12901, 12902, 12903, 12904, 12905, 12906, 12907, 
12908, 12909, 12910, 12911, 12912, 12913, 12914, 12915, 12916, 12917, 
12918, 12919, 12920, 12921, 12922, 12923, 12924, 12925, 12926, 12927, 
12928, 12929, 12930, 12931, 12932, 12933, 12934, 12935, 12936, 12937, 
12938, 12939, 12940, 12941, 12942, 12943, 12944, 12945, 12946, 12947, 
12948, 12949, 12950, 12951, 12952, 12953, 12954, 12955, 12956, 12957, 
12958, 12959, 12960, 12961, 12962, 12963, 12964, 12965, 12966, 12967, 
12968, 12969, 12970, 12971, 12972, 12973, 12974, 12975, 12976, 12977, 
12978, 12979, 12980, 12981, 12982, 12983, 12984, 12985, 12986, 12987, 
12988, 12989, 12990, 12991, 12992, 12993, 12994, 12995, 12996, 12997, 
12998, 12999, 13000, 13001, 13002, 13003, 13004, 13005, 13006, 13007, 
13008, 13009, 13010, 13011, 13012, 13013, 13014, 13015, 13016, 13017, 
13018, 13019, 13020, 13021, 13022, 13023, 13024, 13025, 13026, 13027, 
13028, 13029, 13030, 13031, 13032, 13033, 13034, 13035, 13036, 13037, 
13038, 13039, 13040, 13041, 13042, 13043, 13044, 13045, 13046, 13047, 
13048, 13049, 13050, 13051, 13052, 13053, 13054, 13055, 13056, 13057, 
13058, 13059, 13060, 13061, 13062, 13063, 13064, 13065, 13066, 13067, 
13068, 13069, 13070, 13071, 13072, 13073, 13074, 13075, 13076, 13077, 
13078, 13079, 13080, 13081, 13082, 13083, 13084, 13085, 13086, 13087, 
13088, 13089, 13090, 13091, 13092, 13093, 13094, 13095, 13096, 13097, 
13098, 13099, 13100, 13101, 13102, 13103, 13104, 13105, 13106, 13107, 
13108, 13109, 13110, 13111, 13112, 13113, 13114, 13115, 13116, 13117, 
13118, 13119, 13120, 13121, 13122, 13123, 13124, 13125, 13126, 13127, 
13128, 13129, 13130, 13131, 13132, 13133, 13134, 13135, 13136, 13137, 
13138, 13139, 13140, 13141, 13142, 13143, 13144, 13145, 13146, 13147, 
13148, 13149, 13150, 13151, 13152, 13153, 13154, 13155, 13156, 13157, 
13158, 13159, 13160, 13161, 13162, 13163, 13164, 13165, 13166, 13167, 
13168, 13169, 13170, 13171, 13172, 13173, 13174, 13175, 13176, 13177, 
13178, 13179, 13180, 13181, 13182, 13183, 13184, 13185, 13186, 13187, 
13188, 13189, 13190, 13191, 13192, 13193, 13194, 13195, 13196, 13197, 
13198, 13199, 13200, 13201, 13202, 13203, 13204, 13205, 13206, 13207, 
13208, 13209, 13210, 13211, 13212, 13213, 13214, 13215, 13216, 13217, 
13218, 13219, 13220, 13221, 13222, 13223, 13224, 13225, 13226, 13227, 
13228, 13229, 13230, 13231, 13232, 13233, 13234, 13235, 13236, 13237, 
13238, 13239, 13240, 13241, 13242, 13243, 13244, 13245, 13246, 13247, 
13248, 13249, 13250, 13251, 13252, 13253, 13254, 13255, 13256, 13257, 
13258, 13259, 13260, 13261, 13262, 13263, 13264, 13265, 13266, 13267, 
13268, 13269, 13270, 13271, 13272, 13273, 13274, 13275, 13276, 13277, 
13278, 13279, 13280, 13281, 13282, 13283, 13284, 13285, 13286, 13287, 
13288, 13289, 13290, 13291, 13292, 13293, 13294, 13295, 13296, 13297, 
13298, 13299, 13300, 13301, 13302, 13303, 13304, 13305, 13306, 13307, 
13308, 13309, 13310, 13311, 13312, 13313, 13314, 13315, 13316, 13317, 
13318, 13319, 13320, 13321, 13322, 13323, 13324, 13325, 13326, 13327, 
13328, 13329, 13330, 13331, 13332, 13333, 13334, 13335, 13336, 13337, 
13338, 13339, 13340, 13341, 13342, 13343, 13344, 13345, 13346, 13347, 
13348, 13349, 13350, 13351, 13352, 13353, 13354, 13355, 13356, 13357, 
13358, 13359, 13360, 13361, 13362, 13363, 13364, 13365, 13366, 13367, 
13368, 13369, 13370, 13371, 13372, 13373, 13374, 13375, 13376, 13377, 
13378, 13379, 13380, 13381, 13382, 13383, 13384, 13385, 13386, 13387, 
13388, 13389, 13390, 13391, 13392, 13393, 13394, 13395, 13396, 13397, 
13398, 13399, 13400, 13401, 13402, 13403, 13404, 13405, 13406, 13407, 
13408, 13409, 13410, 13411, 13412, 13413, 13414, 13415, 13416, 13417, 
13418, 13419, 13420, 13421, 13422, 13423, 13424, 13425, 13426, 13427, 
13428, 13429, 13430, 13431, 13432, 13433, 13434, 13435, 13436, 13437, 
13438, 13439, 13440, 13441, 13442, 13443, 13444, 13445, 13446, 13447, 
13448, 13449, 13450, 13451, 13452, 13453, 13454, 13455, 13456, 13457, 
13458, 13459, 13460, 13461, 13462, 13463, 13464, 13465, 13466, 13467, 
13468, 13469, 13470, 13471, 13472, 13473, 13474, 13475, 13476, 13477, 
13478, 13479, 13480, 13481, 13482, 13483, 13484, 13485, 13486, 13487, 
13488, 13489, 13490, 13491, 13492, 13493, 13494, 13495, 13496, 13497, 
13498, 13499, 13500, 13501, 13502, 13503, 13504, 13505, 13506, 13507, 
13508, 13509, 13510, 13511, 13512, 13513, 13514, 13515, 13516, 13517, 
13518, 13519, 13520, 13521, 13522, 13523, 13524, 13525, 13526, 13527, 
13528, 13529, 13530, 13531, 13532, 13533, 13534, 13535, 13536, 13537, 
13538, 13539, 13540, 13541, 13542, 13543, 13544, 13545, 13546, 13547, 
13548, 13549, 13550, 13551, 13552, 13553, 13554, 13555, 13556, 13557, 
13558, 13559, 13560, 13561, 13562, 13563, 13564, 13565, 13566, 13567, 
13568, 13569, 13570, 13571, 13572, 13573, 13574, 13575, 13576, 13577, 
13578, 13579, 13580, 13581, 13582, 13583, 13584, 13585, 13586, 13587, 
13588, 13589, 13590, 13591, 13592, 13593, 13594, 13595, 13596, 13597, 
13598, 13599, 13600, 13601, 13602, 13603, 13604, 13605, 13606, 13607, 
13608, 13609, 13610, 13611, 13612, 13613, 13614, 13615, 13616, 13617, 
13618, 13619, 13620, 13621, 13622, 13623, 13624, 13625, 13626, 13627, 
13628, 13629, 13630, 13631, 13632, 13633, 13634, 13635, 13636, 13637, 
13638, 13639, 13640, 13641, 13642, 13643, 13644, 13645, 13646, 13647, 
13648, 13649, 13650, 13651, 13652, 13653, 13654, 13655, 13656, 13657, 
13658, 13659, 13660, 13661, 13662, 13663, 13664, 13665, 13666, 13667, 
13668, 13669, 13670, 13671, 13672, 13673, 13674, 13675, 13676, 13677, 
13678, 13679, 13680, 13681, 13682, 13683, 13684, 13685, 13686, 13687, 
13688, 13689, 13690, 13691, 13692, 13693, 13694, 13695, 13696, 13697, 
13698, 13699, 13700, 13701, 13702, 13703, 13704, 13705, 13706, 13707, 
13708, 13709, 13710, 13711, 13712, 13713, 13714, 13715, 13716, 13717, 
13718, 13719, 13720, 13721, 13722, 13723, 13724, 13725, 13726, 13727, 
13728, 13729, 13730, 13731, 13732, 13733, 13734, 13735, 13736, 13737, 
13738, 13739, 13740, 13741, 13742, 13743, 13744, 13745, 13746, 13747, 
13748, 13749, 13750, 13751, 13752, 13753, 13754, 13755, 13756, 13757, 
13758, 13759, 13760, 13761, 13762, 13763, 13764, 13765, 13766, 13767, 
13768, 13769, 13770, 13771, 13772, 13773, 13774, 13775, 13776, 13777, 
13778, 13779, 13780, 13781, 13782, 13783, 13784, 13785, 13786, 13787, 
13788, 13789, 13790, 13791, 13792, 13793, 13794, 13795, 13796, 13797, 
13798, 13799, 13800, 13801, 13802, 13803, 13804, 13805, 13806, 13807, 
13808, 13809, 13810, 13811, 13812, 13813, 13814, 13815, 13816, 13817, 
13818, 13819, 13820, 13821, 13822, 13823, 13824, 13825, 13826, 13827, 
13828, 13829, 13830, 13831, 13832, 13833, 13834, 13835, 13836, 13837, 
13838, 13839, 13840, 13841, 13842, 13843, 13844, 13845, 13846, 13847, 
13848, 13849, 13850, 13851, 13852, 13853, 13854, 13855, 13856, 13857, 
13858, 13859, 13860, 13861, 13862, 13863, 13864, 13865, 13866, 13867, 
13868, 13869, 13870, 13871, 13872, 13873, 13874, 13875, 13876, 13877, 
13878, 13879, 13880, 13881, 13882, 13883, 13884, 13885, 13886, 13887, 
13888, 13889, 13890, 13891, 13892, 13893, 13894, 13895, 13896, 13897, 
13898, 13899, 13900, 13901, 13902, 13903, 13904, 13905, 13906, 13907, 
13908, 13909, 13910, 13911, 13912, 13913, 13914, 13915, 13916, 13917, 
13918, 13919, 13920, 13921, 13922, 13923, 13924, 13925, 13926, 13927, 
13928, 13929, 13930, 13931, 13932, 13933, 13934, 13935, 13936, 13937, 
13938, 13939, 13940, 13941, 13942, 13943, 13944, 13945, 13946, 13947, 
13948, 13949, 13950, 13951, 13952, 13953, 13954, 13955, 13956, 13957, 
13958, 13959, 13960, 13961, 13962, 13963, 13964, 13965, 13966, 13967, 
13968, 13969, 13970, 13971, 13972, 13973, 13974, 13975, 13976, 13977, 
13978, 13979, 13980, 13981, 13982, 13983, 13984, 13985, 13986, 13987, 
13988, 13989, 13990, 13991, 13992, 13993, 13994, 13995, 13996, 13997, 
13998, 13999, 14000, 14001, 14002, 14003, 14004, 14005, 14006, 14007, 
14008, 14009, 14010, 14011, 14012, 14013, 14014, 14015, 14016, 14017, 
14018, 14019, 14020, 14021, 14022, 14023, 14024, 14025, 14026, 14027, 
14028, 14029, 14030, 14031, 14032, 14033, 14034, 14035, 14036, 14037, 
14038, 14039, 14040, 14041, 14042, 14043, 14044, 14045, 14046, 14047, 
14048, 14049, 14050, 14051, 14052, 14053, 14054, 14055, 14056, 14057, 
14058, 14059, 20891, 20892, 20893, 20894, 20895, 20896, 20897, 20898, 
20899, 20900, 20901, 20902, 20903, 20904, 20905, 20906, 20907, 20908, 
20909, 20910, 20911, 20912, 20913, 20914, 20915, 20916, 20917, 20918, 
20919, 20920, 20921, 20922, 20923, 20924, 20925, 20926, 20927, 20928, 
20929, 20930, 20931, 20932, 20933, 20934, 20935, 20936, 20937, 20938, 
20939, 20940, 20941, 20942, 20943, 20944, 20945, 20946, 20947, 20948, 
20949, 20950, 20951, 20952, 20953, 20954, 20955, 20956, 20957, 20958, 
20959, 20960, 20961, 20962, 20963, 20964, 20965, 20966, 20967, 20968, 
20969, 20970, 20971, 20972, 20973, 20974, 20975, 20976, 20977, 20978, 
20979, 20980, 20981, 20982, 20983, 20984, 20985, 20986, 20987, 20988, 
20989, 20990, 20991, 20992, 20993, 20994, 20995, 20996, 20997, 20998, 
20999, 21000, 21001, 21002, 21003, 21004, 21005, 21006, 21007, 21008, 
21009, 21010, 21011, 21012, 21013, 21014, 21015, 21016, 21017, 21018, 
21019, 21020, 21021, 21022, 21023, 21024, 21025, 21026, 21027, 21028, 
21029, 21030, 21031, 21032, 21033, 21034, 21035, 21036, 21037, 21038, 
21039, 21040, 21041, 21042, 21043, 21044, 21045, 21046, 21047, 21048, 
21049, 21050, 21051, 21052, 21053, 21054, 21055, 21056, 21057, 21058, 
21059, 21060, 21061, 21062, 21063, 21064, 21065, 21066, 21067, 21068, 
21069, 21070, 21071, 21072, 21073, 21074, 21075, 21076, 21077, 21078, 
21079, 21080, 21081, 21082, 21083, 21084, 21085, 21086, 21087, 21088, 
21089, 21090, 21091, 21092, 21093, 21094, 21095, 21096, 21097, 21098, 
21099, 21100, 21101, 21102, 21103, 21104, 21105, 21106, 21107, 21108, 
21109, 21110, 21111, 21112, 21113, 21114, 21115, 21116, 21117, 21118, 
21119, 21120, 21121, 21122, 21123, 21124, 21125, 21126, 21127, 21128, 
21129, 21130, 21131, 21132, 21133, 21134, 21135, 21136, 21137, 21138, 
21139, 21140, 21141, 21142, 21143, 21144, 21145, 21146, 21147, 21148, 
21149, 21150, 21151, 21152, 21153, 21154, 21155, 21156, 21157, 21158, 
21159, 21160, 21161, 21162, 21163, 21164, 21165, 21166, 21167, 21168, 
21169, 21170, 21171, 21172, 21173, 21174, 21175, 21176, 21177, 21178, 
21179, 21180, 21181, 21182, 21183, 21184, 21185, 21186, 21187, 21188, 
21189, 21190, 21191, 21192, 21193, 21194, 21195, 21196, 21197, 21198, 
21199, 21200, 21201, 21202, 21203, 21204, 21205, 21206, 21207, 21208, 
21209, 21210, 21211, 21212, 21213, 21214, 21215, 21216, 21217, 21218, 
21219, 21220, 21221, 21222, 21223, 21224, 21225, 21226, 21227, 21228, 
21229, 21230, 21231, 21232, 21233, 21234, 21235, 21236, 21237, 21238, 
21239, 21240, 21241, 21242, 21243, 21244, 21245, 21246, 21247, 21248, 
21249, 21250, 21251, 21252, 21253, 21254, 21255, 21256, 21257, 21258, 
21259, 21260, 21261, 21262, 21263, 21264, 21265, 21266, 21267, 21268, 
21269, 21270, 21271, 21272, 21273, 21274, 21275, 21276, 21277, 21278, 
21279, 21280, 21281, 21282, 21283, 21284, 21285, 21286, 21287, 21288, 
21289, 21290, 21291, 21292, 21293, 21294, 21295, 21296, 21297, 21298, 
21299, 21300, 21301, 21302, 21303, 21304, 21305, 21306, 21307, 21308, 
21309, 21310, 21311, 21312, 21313, 21314, 21315, 21316, 21317, 21318, 
21319, 21320, 21321, 21322, 21323, 21324, 21325, 21326, 21327, 21328, 
21329, 21330, 21331, 21332, 21333, 21334, 21335, 21336, 21337, 21338, 
21339, 21340, 21341, 21342, 21343, 21344, 21345, 21346, 21347, 21348, 
21349, 21350, 21351, 21352, 21353, 21354, 21355, 21356, 21357, 21358, 
21359, 21360, 21361, 21362, 21363, 21364, 21365, 21366, 21367, 21368, 
21369, 21370, 21371, 21372, 21373, 21374, 21375, 21376, 21377, 21378, 
21379, 21380, 21381, 21382, 21383, 21384, 21385, 21386, 21387, 21388, 
21389, 21390, 21391, 21392, 21393, 21394, 21395, 21396, 21397, 21398, 
21399, 21400, 21401, 21402, 21403, 21404, 21405, 21406, 21407, 21408, 
21409, 21410, 21411, 21412, 21413, 21414, 21415, 21416, 21417, 21418, 
21419, 21420, 21421, 21422, 21423, 21424, 21425, 21426, 21427, 21428, 
21429, 21430, 21431, 21432, 21433, 21434, 21435, 21436, 21437, 21438, 
21439, 21440, 21441, 21442, 21443, 21444, 21445, 21446, 21447, 21448, 
21449, 21450, 21451, 21452, 21453, 21454, 21455, 21456, 21457, 21458, 
21459, 21460, 21461, 21462, 21463, 21464, 21465, 21466, 21467, 21468, 
21469, 21470, 21471, 21472, 21473, 21474, 21475, 21476, 21477, 21478, 
21479, 21480, 21481, 21482, 21483, 21484, 21485, 21486, 21487, 21488, 
21489, 21490, 21491, 21492, 21493, 21494, 21495, 21496, 21497, 21498, 
21499, 21500, 21501, 21502, 21503, 21504, 21505, 21506, 21507, 21508, 
21509, 21510, 21511, 21512, 21513, 21514, 21515, 21516, 21517, 21518, 
21519, 21520, 21521, 21522, 21523, 21524, 21525, 21526, 21527, 21528, 
21529, 21530, 21531, 21532, 21533, 21534, 21535, 21536, 21537, 21538, 
21539, 21540, 21541, 21542, 21543, 21544, 21545, 21546, 21547, 21548, 
21549, 21550, 21551, 21552, 21553, 21554, 21555, 21556, 21557, 21558, 
21559, 21560, 21561, 21562, 21563, 21564, 21565, 21566, 21567, 21568, 
21569, 21570, 21571, 21572, 21573, 21574, 21575, 21576, 21577, 21578, 
21579, 21580, 21581, 21582, 21583, 21584, 21585, 21586, 21587, 21588, 
21589, 21590, 21591, 21592, 21593, 21594, 21595, 21596, 21597, 21598, 
21599, 21600, 21601, 21602, 21603, 21604, 21605, 21606, 21607, 21608, 
21609, 21610, 21611, 21612, 21613, 21614, 21615, 21616, 21617, 21618, 
21619, 21620, 21621, 21622, 21623, 21624, 21625, 21626, 21627, 21628, 
21629, 21630, 21631, 21632, 21633, 21634, 21635, 21636, 21637, 21638, 
21639, 21640, 21641, 21642, 21643, 21644, 21645, 21646, 21647, 21648, 
21649, 21650, 21651, 21652, 21653, 21654, 21655, 21656, 21657, 21658, 
21659, 21660, 21661, 21662, 21663, 21664, 21665, 21666, 21667, 21668, 
21669, 21670, 21671, 21672, 21673, 21674, 21675, 21676, 21677, 21678, 
21679, 21680, 21681, 21682, 21683, 21684, 21685, 21686, 21687, 21688, 
21689, 21690, 21691, 21692, 21693, 21694, 21695, 21696, 21697, 21698, 
21699, 21700, 21701, 21702, 21703, 21704, 21705, 21706, 21707, 21708, 
21709, 21710, 21711, 21712, 21713, 21714, 21715, 21716, 21717, 21718, 
21719, 21720, 21721, 21722, 21723, 21724, 21725, 21726, 21727, 21728, 
21729, 21730, 21731, 21732, 21733, 21734, 21735, 21736, 21737, 21738, 
21739, 21740, 21741, 21742, 21743, 21744, 21745, 21746, 21747, 21748, 
21749, 21750, 21751, 21752, 21753, 21754, 21755, 21756, 21757, 21758, 
21759, 21760, 21761, 21762, 21763, 21764, 21765, 21766, 21767, 21768, 
21769, 21770, 21771, 21772, 21773, 21774, 21775, 21776, 21777, 21778, 
21779, 21780, 21781, 21782, 21783, 21784, 21785, 21786, 21787, 21788, 
21789, 21790, 21791, 21792, 21793, 21794, 21795, 21796, 21797, 21798, 
21799, 21800, 21801, 21802, 21803, 21804, 21805, 21806, 21807, 21808, 
21809, 21810, 21811, 21812, 21813, 21814, 21815, 21816, 21817, 21818, 
21819, 21820, 21821, 21822, 21823, 21824, 21825, 21826, 21827, 21828, 
21829, 21830, 21831, 21832, 21833, 21834, 21835, 21836, 21837, 21838, 
21839, 21840, 21841, 21842, 21843, 21844, 21845, 21846, 21847, 26732, 
26733, 26734, 26735, 26736, 26737, 26738, 26739, 26740, 26741, 26742, 
26743, 26744, 26745, 26746, 26747, 26748, 26749, 26750, 26751, 26752, 
26753, 26754, 26755, 26756, 26757, 26758, 26759, 26760, 26761, 26762, 
26763, 26764, 26765, 26766, 26767, 26768, 26769, 26770, 26771, 26772, 
26773, 26774, 26775, 26776, 26777, 26778, 26779, 26780, 26781, 26782, 
26783, 26784, 26785, 26786, 26787, 26788, 26789, 26790, 26791, 26792, 
26793, 26794, 26795, 26796, 26797, 26798, 26799, 26800, 26801, 26802, 
26803, 26804, 26805, 26806, 26807, 26808, 26809, 26810, 26811, 26812, 
26813, 26814, 26815, 26816, 26817, 26818, 26819, 26820, 26821, 26822, 
26823, 26824, 26825, 26826, 26827, 26828, 26829, 26830, 26963, 26964, 
26965, 26966, 26967, 26968, 26969, 26970, 26971, 26972, 26973, 26974, 
26975, 26976, 26977, 26978, 26979, 26980, 26981, 26982, 26983, 26984, 
26985, 26986, 26987, 26988, 26989, 26990, 26991, 26992, 26993, 26994, 
26995, 26996, 26997, 26998, 26999, 27000, 27001, 27002, 27003, 27004, 
27005, 27006, 27007, 27008, 27009, 27010, 27011, 27012, 27013, 27014, 
27015, 27016, 27017, 27018, 27019, 27020, 27021, 27022, 27023, 27024, 
27025, 27026, 27027, 27028, 27029, 27030, 27031, 27032, 27033, 27034, 
27035, 27036, 27037, 27038, 27039, 27040, 27041, 27042, 27043, 27044, 
27045, 27046, 27047, 27048, 27049, 27050, 27051, 27052, 27053, 27054, 
27055, 27056, 27057, 27058, 27059, 27060, 27061, 
*ELSET,ELSET=Solder
5546, 5547, 5548, 5549, 5550, 5551, 5552, 5553, 5554, 5555, 
5556, 5557, 5558, 5559, 5560, 5561, 5562, 5563, 5564, 5565, 
5566, 5567, 5568, 5569, 5570, 5571, 5572, 5573, 5574, 5575, 
5576, 5577, 5578, 5579, 5580, 5581, 5582, 5583, 5584, 5585, 
5586, 5587, 5588, 5589, 5590, 5591, 5592, 5593, 5594, 5595, 
5596, 5597, 5598, 5599, 5600, 5601, 5602, 5603, 5604, 5605, 
5606, 5607, 5608, 5609, 5610, 5611, 5612, 5613, 5614, 5615, 
5616, 5617, 5618, 5619, 5620, 5621, 5622, 5623, 5624, 5625, 
5626, 5627, 5628, 5629, 5630, 5631, 5632, 5633, 5634, 5635, 
5636, 5637, 5638, 5639, 5640, 5641, 5642, 5643, 5644, 5645, 
5646, 5647, 5648, 5649, 5650, 5651, 5652, 5653, 5654, 5655, 
5656, 5657, 5658, 5659, 5660, 5661, 5662, 5663, 5664, 5665, 
5666, 5667, 5668, 5669, 5670, 5671, 5672, 5673, 5674, 5675, 
5676, 5677, 5678, 5679, 5680, 5681, 5682, 5683, 5684, 5685, 
5686, 5687, 5688, 5689, 5690, 5691, 5692, 5693, 5694, 5695, 
5696, 5697, 5698, 5699, 5700, 5701, 5702, 5703, 5704, 5705, 
5706, 5707, 5708, 5709, 5710, 5711, 5712, 5713, 5714, 5715, 
5716, 5717, 5718, 5719, 5720, 5721, 5722, 5723, 5724, 5725, 
5726, 5727, 5728, 5729, 5730, 5731, 5732, 5733, 5734, 5735, 
5736, 5737, 5738, 5739, 5740, 5741, 5742, 5743, 5744, 5745, 
5746, 5747, 5748, 5749, 5750, 5751, 5752, 5753, 5754, 5755, 
5756, 5757, 5758, 5759, 5760, 5761, 5762, 5763, 5764, 5765, 
5766, 5767, 5768, 5769, 5770, 5771, 5772, 5773, 5774, 5775, 
5776, 5777, 5778, 5779, 5780, 5781, 5782, 5783, 5784, 5785, 
5786, 5787, 5788, 5789, 5790, 5791, 5792, 5793, 5794, 5795, 
5796, 5797, 5798, 5799, 5800, 5801, 5802, 5803, 5804, 5805, 
5806, 5807, 5808, 5809, 5810, 5811, 5812, 5813, 5814, 5815, 
5816, 5817, 5818, 5819, 5820, 5821, 5822, 5823, 5824, 5825, 
5826, 5827, 5828, 5829, 5830, 5831, 5832, 5833, 5834, 5835, 
5836, 5837, 5838, 5839, 5840, 5841, 5842, 5843, 5844, 5845, 
5846, 5847, 5848, 5849, 5850, 5851, 5852, 5853, 5854, 5855, 
5856, 5857, 5858, 5859, 5860, 5861, 5862, 5863, 5864, 5865, 
5866, 5867, 5868, 5869, 5870, 5871, 5872, 5873, 5874, 5875, 
5876, 5877, 5878, 5879, 5880, 5881, 5882, 5883, 5884, 5885, 
5886, 5887, 5888, 5889, 5890, 5891, 5892, 5893, 5894, 5895, 
5896, 5897, 5898, 5899, 5900, 5901, 5902, 5903, 5904, 5905, 
5906, 5907, 5908, 5909, 5910, 5911, 5912, 5913, 5914, 5915, 
5916, 5917, 5918, 5919, 5920, 5921, 5922, 5923, 5924, 5925, 
5926, 5927, 5928, 5929, 5930, 5931, 5932, 5933, 5934, 5935, 
5936, 5937, 5938, 5939, 5940, 5941, 5942, 5943, 5944, 5945, 
5946, 5947, 5948, 5949, 5950, 5951, 5952, 5953, 5954, 5955, 
5956, 5957, 5958, 5959, 5960, 5961, 5962, 5963, 5964, 5965, 
5966, 5967, 5968, 5969, 5970, 5971, 5972, 5973, 5974, 5975, 
5976, 5977, 5978, 5979, 5980, 5981, 5982, 5983, 5984, 5985, 
5986, 5987, 5988, 5989, 5990, 5991, 5992, 5993, 5994, 5995, 
5996, 5997, 5998, 5999, 6000, 6001, 6002, 6003, 6004, 6005, 
6006, 6007, 6008, 6009, 6010, 6011, 6012, 6013, 6014, 6015, 
6016, 6017, 6018, 6019, 6020, 6021, 6022, 6023, 6024, 6025, 
6026, 6027, 6028, 6029, 6030, 6031, 6032, 6033, 6034, 6035, 
6036, 6037, 6038, 6039, 6040, 6041, 6042, 6043, 6044, 6045, 
6046, 6047, 6048, 6049, 6050, 6051, 11871, 11872, 11873, 11874, 
11875, 11876, 11877, 11878, 11879, 11880, 11881, 11882, 11883, 11884, 
11885, 11886, 11887, 11888, 11889, 11890, 11891, 11892, 11893, 11894, 
11895, 11896, 11897, 11898, 11899, 11900, 11901, 11902, 11903, 11904, 
11905, 11906, 11907, 11908, 11909, 11910, 11911, 11912, 11913, 11914, 
11915, 11916, 11917, 11918, 11919, 11920, 11921, 11922, 11923, 11924, 
11925, 11926, 11927, 11928, 11929, 11930, 11931, 11932, 11933, 11934, 
11935, 11936, 11937, 11938, 11939, 11940, 11941, 11942, 11943, 11944, 
11945, 11946, 11947, 11948, 11949, 11950, 11951, 11952, 11953, 11954, 
11955, 11956, 11957, 11958, 11959, 11960, 11961, 11962, 11963, 11964, 
11965, 11966, 11967, 11968, 11969, 11970, 11971, 11972, 11973, 11974, 
11975, 11976, 11977, 11978, 11979, 11980, 11981, 11982, 11983, 11984, 
11985, 11986, 11987, 11988, 11989, 11990, 11991, 11992, 11993, 11994, 
11995, 11996, 11997, 11998, 11999, 12000, 12001, 12002, 12003, 12004, 
12005, 12006, 12007, 12008, 12009, 12010, 12011, 12012, 12013, 12014, 
12015, 12016, 12017, 12018, 12019, 12020, 12021, 12022, 12023, 12024, 
12025, 12026, 12027, 12028, 12029, 12030, 12031, 12032, 12033, 12034, 
12035, 12036, 12037, 12038, 12039, 12040, 12041, 12042, 12043, 12044, 
12045, 12046, 12047, 12048, 12049, 12050, 12051, 12052, 12053, 12054, 
12055, 12056, 12057, 12058, 12059, 12060, 12061, 12062, 12063, 12064, 
12065, 12066, 12067, 12068, 12069, 12070, 12071, 12072, 12073, 12074, 
12075, 12076, 12077, 12078, 12079, 12080, 12081, 12082, 12083, 12084, 
12085, 12086, 12087, 12088, 12089, 12090, 12091, 12092, 12093, 12094, 
12095, 12096, 12097, 12098, 12099, 12100, 12101, 12102, 12103, 12104, 
12105, 12106, 12107, 12108, 12109, 12110, 12111, 12112, 12113, 12114, 
12115, 12116, 12117, 12118, 12119, 12120, 12121, 12122, 12123, 12124, 
12125, 12126, 12127, 12128, 12129, 12130, 12131, 12132, 12133, 12134, 
12135, 12136, 12137, 12138, 12139, 12140, 12141, 12142, 12143, 12144, 
12145, 12146, 12147, 12148, 12149, 12150, 12151, 12152, 12153, 12154, 
12155, 12156, 12157, 12158, 12159, 12160, 12161, 12162, 12163, 12164, 
12165, 12166, 12167, 12168, 12169, 12170, 12171, 12172, 12173, 12174, 
12175, 12176, 12177, 12178, 12179, 12180, 12181, 12182, 12183, 12184, 
12185, 12186, 12187, 12188, 12189, 12190, 12191, 12192, 12193, 12194, 
12195, 12196, 12197, 12198, 12199, 12200, 12201, 12202, 12203, 12204, 
12205, 12206, 12207, 12208, 12209, 12210, 12211, 12212, 12213, 12214, 
12215, 12216, 12217, 12218, 12219, 12220, 12221, 12222, 12223, 12224, 
12225, 12226, 12227, 12228, 12229, 12230, 12231, 12232, 12233, 12234, 
12235, 12236, 12237, 12238, 12239, 12240, 12241, 12242, 12243, 12244, 
12245, 12246, 12247, 12248, 12249, 12250, 12251, 12252, 12253, 12254, 
12255, 12256, 12257, 12258, 12259, 12260, 12261, 12262, 12263, 12264, 
12265, 12266, 12267, 12268, 12269, 12270, 12271, 12272, 12273, 12274, 
12275, 12276, 12277, 12278, 12279, 12280, 12281, 12282, 12283, 12284, 
12285, 12286, 12287, 12288, 12289, 12290, 12291, 12292, 12293, 12294, 
12295, 12296, 12297, 12298, 12299, 12300, 12301, 12302, 12303, 12304, 
12305, 12306, 12307, 12308, 12309, 12310, 12311, 12312, 12313, 12314, 
12315, 12316, 12317, 12318, 12319, 12320, 12321, 12322, 12323, 12324, 
12325, 12326, 12327, 12328, 12329, 12330, 12331, 12332, 12333, 12334, 
12335, 12336, 12337, 12338, 12339, 12340, 12341, 12342, 12343, 12344, 
12345, 12346, 12347, 12348, 12349, 12350, 12351, 12352, 12353, 12354, 
12355, 12356, 12357, 12358, 12359, 12360, 12361, 12362, 12363, 12364, 
12365, 12366, 12367, 12368, 12369, 12370, 12371, 12372, 12373, 12374, 
12375, 12376, 14060, 14061, 14062, 14063, 14064, 14065, 14066, 14067, 
14068, 14069, 14070, 14071, 14072, 14073, 14074, 14075, 14076, 14077, 
14078, 14079, 14080, 14081, 14082, 14083, 14084, 14085, 14086, 14087, 
14088, 14089, 14090, 14091, 14092, 14093, 14094, 14095, 14096, 14097, 
14098, 14099, 14100, 14101, 14102, 14103, 14104, 14105, 14106, 14107, 
14108, 14109, 14110, 14111, 14112, 14113, 14114, 14115, 14116, 14117, 
14118, 14119, 14120, 14121, 14122, 14123, 14124, 14125, 14126, 14127, 
14128, 14129, 14130, 14131, 14132, 14133, 14134, 14135, 14136, 14137, 
14138, 14139, 14140, 14141, 14142, 14143, 14144, 14145, 14146, 14147, 
14148, 14149, 14150, 14151, 14152, 14153, 14154, 14155, 14156, 14157, 
14158, 14159, 14160, 14161, 14162, 14163, 14164, 14165, 14166, 14167, 
14168, 14169, 14170, 14171, 14172, 14173, 14174, 14175, 14176, 14177, 
14178, 14179, 14180, 14181, 14182, 14183, 14184, 14185, 14186, 14187, 
14188, 14189, 14190, 14191, 14192, 14193, 14194, 14195, 14196, 14197, 
14198, 14199, 14200, 14201, 14202, 14203, 14204, 14205, 14206, 14207, 
14208, 14209, 14210, 14211, 14212, 14213, 14214, 14215, 14216, 14217, 
14218, 14219, 14220, 14221, 14222, 14223, 14224, 14225, 14226, 14227, 
14228, 14229, 14230, 14231, 14232, 14233, 14234, 14235, 14236, 14237, 
14238, 14239, 14240, 14241, 14242, 14243, 14244, 14245, 14246, 14247, 
14248, 14249, 14250, 14251, 14252, 14253, 14254, 14255, 14256, 14257, 
14258, 14259, 14260, 14261, 14262, 14263, 14264, 14265, 14266, 14267, 
14268, 14269, 14270, 14271, 14272, 14273, 14274, 14275, 14276, 14277, 
14278, 14279, 14280, 14281, 14282, 14283, 14284, 14285, 14286, 14287, 
14288, 14289, 14290, 14291, 14292, 14293, 14294, 14295, 14296, 14297, 
14298, 14299, 14300, 14301, 14302, 14303, 14304, 14305, 14306, 14307, 
14308, 14309, 14310, 14311, 14312, 14313, 14314, 14315, 14316, 14317, 
14318, 14319, 14320, 14321, 14322, 14323, 14324, 14325, 14326, 14327, 
14328, 14329, 14330, 14331, 14332, 14333, 14334, 14335, 14336, 14337, 
14338, 14339, 14340, 14341, 14342, 14343, 14344, 14345, 14346, 14347, 
14348, 14349, 14350, 14351, 14352, 14353, 14354, 14355, 14356, 14357, 
14358, 14359, 14360, 14361, 14362, 14363, 14364, 14365, 14366, 14367, 
14368, 14369, 14370, 14371, 14372, 14373, 14374, 14375, 14376, 14377, 
14378, 14379, 14380, 14381, 14382, 14383, 14384, 14385, 14386, 14387, 
14388, 14389, 14390, 14391, 14392, 14393, 14394, 14395, 14396, 14397, 
14398, 14399, 14400, 14401, 14402, 14403, 14404, 14405, 14406, 14407, 
14408, 14409, 14410, 14411, 14412, 14413, 14414, 14415, 14416, 14417, 
14418, 14419, 14420, 14421, 14422, 14423, 14424, 14425, 14426, 14427, 
14428, 14429, 14430, 14431, 14432, 14433, 14434, 14435, 14436, 14437, 
14438, 14439, 14440, 14441, 14442, 14443, 14444, 14445, 14446, 14447, 
14448, 14449, 14450, 14451, 14452, 14453, 14454, 14455, 14456, 14457, 
14458, 14459, 14460, 14461, 14462, 14463, 14464, 14465, 14466, 14467, 
14468, 14469, 14470, 14471, 14472, 14473, 14474, 14475, 14476, 14477, 
14478, 14479, 14480, 14481, 14482, 14483, 14484, 14485, 14486, 14487, 
14488, 14489, 14490, 14491, 14492, 14493, 14494, 14495, 14496, 14497, 
14498, 14499, 14500, 14501, 14502, 14503, 14504, 14505, 14506, 14507, 
14508, 14509, 14510, 14511, 14512, 14513, 14514, 14515, 14516, 14517, 
14518, 14519, 14520, 14521, 14522, 14523, 14524, 14525, 14526, 14527, 
14528, 14529, 14530, 14531, 14532, 14533, 14534, 14535, 14536, 14537, 
14538, 14539, 14540, 14541, 14542, 14543, 14544, 14545, 14546, 14547, 
14548, 14549, 14550, 14551, 14552, 14553, 14554, 14555, 14556, 14557, 
14558, 14559, 14560, 14561, 14562, 14563, 14564, 14565, 20385, 20386, 
20387, 20388, 20389, 20390, 20391, 20392, 20393, 20394, 20395, 20396, 
20397, 20398, 20399, 20400, 20401, 20402, 20403, 20404, 20405, 20406, 
20407, 20408, 20409, 20410, 20411, 20412, 20413, 20414, 20415, 20416, 
20417, 20418, 20419, 20420, 20421, 20422, 20423, 20424, 20425, 20426, 
20427, 20428, 20429, 20430, 20431, 20432, 20433, 20434, 20435, 20436, 
20437, 20438, 20439, 20440, 20441, 20442, 20443, 20444, 20445, 20446, 
20447, 20448, 20449, 20450, 20451, 20452, 20453, 20454, 20455, 20456, 
20457, 20458, 20459, 20460, 20461, 20462, 20463, 20464, 20465, 20466, 
20467, 20468, 20469, 20470, 20471, 20472, 20473, 20474, 20475, 20476, 
20477, 20478, 20479, 20480, 20481, 20482, 20483, 20484, 20485, 20486, 
20487, 20488, 20489, 20490, 20491, 20492, 20493, 20494, 20495, 20496, 
20497, 20498, 20499, 20500, 20501, 20502, 20503, 20504, 20505, 20506, 
20507, 20508, 20509, 20510, 20511, 20512, 20513, 20514, 20515, 20516, 
20517, 20518, 20519, 20520, 20521, 20522, 20523, 20524, 20525, 20526, 
20527, 20528, 20529, 20530, 20531, 20532, 20533, 20534, 20535, 20536, 
20537, 20538, 20539, 20540, 20541, 20542, 20543, 20544, 20545, 20546, 
20547, 20548, 20549, 20550, 20551, 20552, 20553, 20554, 20555, 20556, 
20557, 20558, 20559, 20560, 20561, 20562, 20563, 20564, 20565, 20566, 
20567, 20568, 20569, 20570, 20571, 20572, 20573, 20574, 20575, 20576, 
20577, 20578, 20579, 20580, 20581, 20582, 20583, 20584, 20585, 20586, 
20587, 20588, 20589, 20590, 20591, 20592, 20593, 20594, 20595, 20596, 
20597, 20598, 20599, 20600, 20601, 20602, 20603, 20604, 20605, 20606, 
20607, 20608, 20609, 20610, 20611, 20612, 20613, 20614, 20615, 20616, 
20617, 20618, 20619, 20620, 20621, 20622, 20623, 20624, 20625, 20626, 
20627, 20628, 20629, 20630, 20631, 20632, 20633, 20634, 20635, 20636, 
20637, 20638, 20639, 20640, 20641, 20642, 20643, 20644, 20645, 20646, 
20647, 20648, 20649, 20650, 20651, 20652, 20653, 20654, 20655, 20656, 
20657, 20658, 20659, 20660, 20661, 20662, 20663, 20664, 20665, 20666, 
20667, 20668, 20669, 20670, 20671, 20672, 20673, 20674, 20675, 20676, 
20677, 20678, 20679, 20680, 20681, 20682, 20683, 20684, 20685, 20686, 
20687, 20688, 20689, 20690, 20691, 20692, 20693, 20694, 20695, 20696, 
20697, 20698, 20699, 20700, 20701, 20702, 20703, 20704, 20705, 20706, 
20707, 20708, 20709, 20710, 20711, 20712, 20713, 20714, 20715, 20716, 
20717, 20718, 20719, 20720, 20721, 20722, 20723, 20724, 20725, 20726, 
20727, 20728, 20729, 20730, 20731, 20732, 20733, 20734, 20735, 20736, 
20737, 20738, 20739, 20740, 20741, 20742, 20743, 20744, 20745, 20746, 
20747, 20748, 20749, 20750, 20751, 20752, 20753, 20754, 20755, 20756, 
20757, 20758, 20759, 20760, 20761, 20762, 20763, 20764, 20765, 20766, 
20767, 20768, 20769, 20770, 20771, 20772, 20773, 20774, 20775, 20776, 
20777, 20778, 20779, 20780, 20781, 20782, 20783, 20784, 20785, 20786, 
20787, 20788, 20789, 20790, 20791, 20792, 20793, 20794, 20795, 20796, 
20797, 20798, 20799, 20800, 20801, 20802, 20803, 20804, 20805, 20806, 
20807, 20808, 20809, 20810, 20811, 20812, 20813, 20814, 20815, 20816, 
20817, 20818, 20819, 20820, 20821, 20822, 20823, 20824, 20825, 20826, 
20827, 20828, 20829, 20830, 20831, 20832, 20833, 20834, 20835, 20836, 
20837, 20838, 20839, 20840, 20841, 20842, 20843, 20844, 20845, 20846, 
20847, 20848, 20849, 20850, 20851, 20852, 20853, 20854, 20855, 20856, 
20857, 20858, 20859, 20860, 20861, 20862, 20863, 20864, 20865, 20866, 
20867, 20868, 20869, 20870, 20871, 20872, 20873, 20874, 20875, 20876, 
20877, 20878, 20879, 20880, 20881, 20882, 20883, 20884, 20885, 20886, 
20887, 20888, 20889, 20890, 
*ELSET,ELSET=SemiconductorP+
6052, 6053, 6054, 6055, 6056, 6057, 6058, 6059, 6060, 6061, 
6062, 6063, 6064, 6065, 6066, 6067, 6068, 6069, 6070, 6071, 
6072, 6073, 6074, 6075, 6076, 6077, 6078, 6079, 6080, 6081, 
6082, 6083, 6084, 6085, 6086, 6087, 6088, 6089, 6090, 6091, 
6092, 6093, 6094, 6095, 6096, 6097, 6098, 6099, 6100, 6101, 
6102, 6103, 6104, 6105, 6106, 6107, 6108, 6109, 6110, 6111, 
6112, 6113, 6114, 6115, 6116, 6117, 6118, 6119, 6120, 6121, 
6122, 6123, 6124, 6125, 6126, 6127, 6128, 6129, 6130, 6131, 
6132, 6133, 6134, 6135, 6136, 6137, 6138, 6139, 6140, 6141, 
6142, 6143, 6144, 6145, 6146, 6147, 6148, 6149, 6150, 6151, 
6152, 6153, 6154, 6155, 6156, 6157, 6158, 6159, 6160, 6161, 
6162, 6163, 6164, 6165, 6166, 6167, 6168, 6169, 6170, 6171, 
6172, 6173, 6174, 6175, 6176, 6177, 6178, 6179, 6180, 6181, 
6182, 6183, 6184, 6185, 6186, 6187, 6188, 6189, 6190, 6191, 
6192, 6193, 6194, 6195, 6196, 6197, 6198, 6199, 6200, 6201, 
6202, 6203, 6204, 6205, 6206, 6207, 6208, 6209, 6210, 6211, 
6212, 6213, 6214, 6215, 6216, 6217, 6218, 6219, 6220, 6221, 
6222, 6223, 6224, 6225, 6226, 6227, 6228, 6229, 6230, 6231, 
6232, 6233, 6234, 6235, 6236, 6237, 6238, 6239, 6240, 6241, 
6242, 6243, 6244, 6245, 6246, 6247, 6248, 6249, 6250, 6251, 
6252, 6253, 6254, 6255, 6256, 6257, 6258, 6259, 6260, 6261, 
6262, 6263, 6264, 6265, 6266, 6267, 6268, 6269, 6270, 6271, 
6272, 6273, 6274, 6275, 6276, 6277, 6278, 6279, 6280, 6281, 
6282, 6283, 6284, 6285, 6286, 6287, 6288, 6289, 6290, 6291, 
6292, 6293, 6294, 6295, 6296, 6297, 6298, 6299, 6300, 6301, 
6302, 6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 6311, 
6312, 6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 6321, 
6322, 6323, 6324, 6325, 6326, 6327, 6328, 6329, 6330, 6331, 
6332, 6333, 6334, 6335, 6336, 6337, 6338, 6339, 6340, 6341, 
6342, 6343, 6344, 6345, 6346, 6347, 6348, 6349, 6350, 6351, 
6352, 6353, 6354, 6355, 6356, 6357, 6358, 6359, 6360, 6361, 
6362, 6363, 6364, 6365, 6366, 6367, 6368, 6369, 6370, 6371, 
6372, 6373, 6374, 6375, 6376, 6377, 6378, 6379, 6380, 6381, 
6382, 6383, 6384, 6385, 6386, 6387, 6388, 6389, 6390, 6391, 
6392, 6393, 6394, 6395, 6396, 6397, 6398, 6399, 6400, 6401, 
6402, 6403, 6404, 6405, 6406, 6407, 6408, 6409, 6410, 6411, 
6412, 6413, 6414, 6415, 6416, 6417, 6418, 6419, 6420, 6421, 
6422, 6423, 6424, 6425, 6426, 6427, 6428, 6429, 6430, 6431, 
6432, 6433, 6434, 6435, 6436, 6437, 6438, 6439, 6440, 6441, 
6442, 6443, 6444, 6445, 6446, 6447, 6448, 6449, 6450, 6451, 
6452, 6453, 6454, 6455, 6456, 6457, 6458, 6459, 6460, 6461, 
6462, 6463, 6464, 6465, 6466, 6467, 6468, 6469, 6470, 6471, 
6472, 6473, 6474, 6475, 6476, 6477, 6478, 6479, 6480, 6481, 
6482, 6483, 6484, 6485, 6486, 6487, 6488, 6489, 6490, 6491, 
6492, 6493, 6494, 6495, 6496, 6497, 6498, 6499, 6500, 6501, 
6502, 6503, 6504, 6505, 6506, 6507, 6508, 6509, 6510, 6511, 
6512, 6513, 6514, 6515, 6516, 6517, 6518, 6519, 6520, 6521, 
6522, 6523, 6524, 6525, 6526, 6527, 6528, 6529, 6530, 6531, 
6532, 6533, 6534, 6535, 6536, 6537, 6538, 6539, 6540, 6541, 
6542, 6543, 6544, 6545, 6546, 6547, 6548, 6549, 6550, 6551, 
6552, 6553, 6554, 6555, 6556, 6557, 6558, 6559, 6560, 6561, 
6562, 6563, 6564, 6565, 6566, 6567, 6568, 6569, 6570, 6571, 
6572, 6573, 6574, 6575, 6576, 6577, 6578, 6579, 6580, 6581, 
6582, 6583, 6584, 6585, 6586, 6587, 6588, 6589, 6590, 6591, 
6592, 6593, 6594, 6595, 6596, 6597, 6598, 6599, 6600, 6601, 
6602, 6603, 6604, 6605, 6606, 6607, 6608, 6609, 6610, 6611, 
6612, 6613, 6614, 6615, 6616, 6617, 6618, 6619, 6620, 6621, 
6622, 6623, 6624, 6625, 6626, 6627, 6628, 6629, 6630, 6631, 
6632, 6633, 6634, 6635, 6636, 6637, 6638, 6639, 6640, 6641, 
6642, 6643, 6644, 6645, 6646, 6647, 6648, 6649, 6650, 6651, 
6652, 6653, 6654, 6655, 6656, 6657, 6658, 6659, 6660, 6661, 
6662, 6663, 6664, 6665, 6666, 6667, 6668, 6669, 6670, 6671, 
6672, 6673, 6674, 6675, 6676, 6677, 6678, 6679, 6680, 6681, 
6682, 6683, 6684, 6685, 6686, 6687, 6688, 6689, 6690, 6691, 
6692, 6693, 6694, 6695, 6696, 6697, 6698, 6699, 6700, 6701, 
6702, 6703, 6704, 6705, 6706, 6707, 6708, 6709, 6710, 6711, 
6712, 6713, 6714, 6715, 6716, 6717, 6718, 6719, 6720, 6721, 
6722, 6723, 6724, 6725, 6726, 6727, 6728, 6729, 6730, 6731, 
6732, 6733, 6734, 6735, 6736, 6737, 6738, 6739, 6740, 6741, 
6742, 6743, 6744, 6745, 6746, 6747, 6748, 6749, 6750, 6751, 
6752, 6753, 6754, 6755, 6756, 6757, 6758, 6759, 6760, 6761, 
6762, 6763, 6764, 6765, 6766, 6767, 6768, 6769, 6770, 6771, 
6772, 6773, 6774, 6775, 6776, 6777, 6778, 6779, 6780, 6781, 
6782, 6783, 6784, 6785, 6786, 6787, 6788, 6789, 6790, 6791, 
6792, 6793, 6794, 6795, 6796, 6797, 6798, 6799, 6800, 6801, 
6802, 6803, 6804, 6805, 6806, 6807, 6808, 6809, 6810, 6811, 
6812, 6813, 6814, 6815, 6816, 6817, 6818, 6819, 6820, 6821, 
6822, 6823, 6824, 6825, 6826, 6827, 6828, 6829, 6830, 6831, 
6832, 6833, 6834, 6835, 6836, 6837, 6838, 6839, 6840, 6841, 
6842, 6843, 6844, 6845, 6846, 6847, 6848, 6849, 6850, 6851, 
6852, 6853, 6854, 6855, 6856, 6857, 6858, 6859, 6860, 6861, 
6862, 6863, 6864, 6865, 6866, 6867, 6868, 6869, 6870, 6871, 
6872, 6873, 6874, 6875, 6876, 6877, 6878, 6879, 6880, 6881, 
6882, 6883, 6884, 6885, 6886, 6887, 6888, 6889, 6890, 6891, 
6892, 6893, 6894, 6895, 6896, 6897, 6898, 6899, 6900, 6901, 
6902, 6903, 6904, 6905, 6906, 6907, 6908, 6909, 6910, 6911, 
6912, 6913, 6914, 6915, 6916, 6917, 6918, 6919, 6920, 6921, 
6922, 6923, 6924, 6925, 6926, 6927, 6928, 6929, 6930, 6931, 
6932, 6933, 6934, 6935, 6936, 6937, 6938, 6939, 6940, 6941, 
6942, 6943, 6944, 6945, 6946, 6947, 6948, 6949, 6950, 6951, 
6952, 6953, 6954, 6955, 6956, 6957, 6958, 6959, 6960, 6961, 
6962, 6963, 6964, 6965, 6966, 6967, 6968, 6969, 6970, 6971, 
6972, 6973, 6974, 6975, 6976, 6977, 6978, 6979, 6980, 6981, 
6982, 6983, 6984, 6985, 6986, 6987, 6988, 6989, 6990, 6991, 
6992, 6993, 6994, 6995, 6996, 6997, 6998, 6999, 7000, 7001, 
7002, 7003, 7004, 7005, 7006, 7007, 7008, 7009, 7010, 7011, 
7012, 7013, 7014, 7015, 7016, 7017, 7018, 7019, 7020, 7021, 
7022, 7023, 7024, 7025, 7026, 7027, 7028, 7029, 7030, 7031, 
7032, 7033, 7034, 7035, 7036, 7037, 7038, 7039, 7040, 7041, 
7042, 7043, 7044, 7045, 7046, 7047, 7048, 7049, 7050, 7051, 
7052, 7053, 7054, 7055, 7056, 7057, 7058, 7059, 7060, 7061, 
7062, 7063, 7064, 7065, 7066, 7067, 7068, 7069, 7070, 7071, 
7072, 7073, 7074, 7075, 7076, 7077, 7078, 7079, 7080, 7081, 
7082, 7083, 7084, 7085, 7086, 7087, 7088, 7089, 7090, 7091, 
7092, 7093, 7094, 7095, 7096, 7097, 7098, 7099, 7100, 7101, 
7102, 7103, 7104, 7105, 7106, 7107, 7108, 7109, 7110, 7111, 
7112, 7113, 7114, 7115, 7116, 7117, 7118, 7119, 7120, 7121, 
7122, 7123, 7124, 7125, 7126, 7127, 7128, 7129, 7130, 7131, 
7132, 7133, 7134, 7135, 7136, 7137, 7138, 7139, 7140, 7141, 
7142, 7143, 7144, 7145, 7146, 7147, 7148, 7149, 7150, 7151, 
7152, 7153, 7154, 7155, 7156, 7157, 7158, 7159, 7160, 7161, 
7162, 7163, 7164, 7165, 7166, 7167, 7168, 7169, 7170, 7171, 
7172, 7173, 7174, 7175, 7176, 7177, 7178, 7179, 7180, 7181, 
7182, 7183, 7184, 7185, 7186, 7187, 7188, 7189, 7190, 7191, 
7192, 7193, 7194, 7195, 7196, 7197, 7198, 7199, 7200, 7201, 
7202, 7203, 7204, 7205, 7206, 7207, 7208, 7209, 7210, 7211, 
7212, 7213, 7214, 7215, 7216, 7217, 7218, 7219, 7220, 7221, 
7222, 7223, 7224, 7225, 7226, 7227, 7228, 7229, 7230, 7231, 
7232, 7233, 7234, 7235, 7236, 7237, 7238, 7239, 7240, 7241, 
7242, 7243, 7244, 7245, 7246, 7247, 7248, 7249, 7250, 7251, 
7252, 7253, 7254, 7255, 7256, 7257, 7258, 7259, 7260, 7261, 
7262, 7263, 7264, 7265, 7266, 7267, 7268, 7269, 7270, 7271, 
7272, 7273, 7274, 7275, 7276, 7277, 7278, 7279, 7280, 7281, 
7282, 7283, 7284, 7285, 7286, 7287, 7288, 7289, 7290, 7291, 
7292, 7293, 7294, 7295, 7296, 7297, 7298, 7299, 7300, 7301, 
7302, 7303, 7304, 7305, 7306, 7307, 7308, 7309, 7310, 7311, 
7312, 7313, 7314, 7315, 7316, 7317, 7318, 7319, 7320, 7321, 
7322, 7323, 7324, 7325, 7326, 7327, 7328, 7329, 7330, 7331, 
7332, 7333, 7334, 7335, 7336, 7337, 7338, 7339, 7340, 7341, 
7342, 7343, 7344, 7345, 7346, 7347, 7348, 7349, 7350, 7351, 
7352, 7353, 7354, 7355, 7356, 7357, 7358, 7359, 7360, 7361, 
7362, 7363, 7364, 7365, 7366, 7367, 7368, 7369, 7370, 7371, 
7372, 7373, 7374, 7375, 7376, 7377, 7378, 7379, 7380, 7381, 
7382, 7383, 7384, 7385, 7386, 7387, 7388, 7389, 7390, 7391, 
7392, 7393, 7394, 7395, 7396, 7397, 7398, 7399, 7400, 7401, 
7402, 7403, 7404, 7405, 7406, 7407, 7408, 7409, 7410, 7411, 
7412, 7413, 7414, 7415, 7416, 7417, 7418, 7419, 7420, 7421, 
7422, 7423, 7424, 7425, 7426, 7427, 7428, 7429, 7430, 7431, 
7432, 7433, 7434, 7435, 7436, 7437, 7438, 7439, 7440, 7441, 
7442, 7443, 7444, 7445, 7446, 7447, 7448, 7449, 7450, 7451, 
7452, 7453, 7454, 7455, 7456, 7457, 7458, 7459, 7460, 7461, 
7462, 7463, 7464, 7465, 7466, 7467, 7468, 7469, 7470, 7471, 
7472, 7473, 7474, 7475, 7476, 7477, 7478, 7479, 7480, 7481, 
7482, 7483, 7484, 7485, 7486, 7487, 7488, 7489, 7490, 7491, 
7492, 7493, 7494, 7495, 7496, 7497, 7498, 7499, 7500, 7501, 
7502, 7503, 7504, 7505, 7506, 7507, 7508, 7509, 7510, 7511, 
7512, 7513, 7514, 7515, 7516, 7517, 7518, 7519, 7520, 7521, 
7522, 7523, 7524, 7525, 7526, 7527, 7528, 7529, 7530, 7531, 
7532, 7533, 7534, 7535, 7536, 7537, 7538, 7539, 7540, 7541, 
7542, 7543, 7544, 7545, 7546, 7547, 7548, 7549, 7550, 7551, 
7552, 7553, 7554, 7555, 7556, 7557, 7558, 7559, 7560, 7561, 
7562, 7563, 7564, 7565, 7566, 7567, 7568, 7569, 7570, 7571, 
7572, 7573, 7574, 7575, 7576, 7577, 7578, 7579, 7580, 7581, 
7582, 7583, 7584, 7585, 7586, 7587, 7588, 7589, 7590, 7591, 
7592, 7593, 7594, 7595, 7596, 7597, 7598, 7599, 7600, 7601, 
7602, 7603, 7604, 7605, 7606, 7607, 7608, 7609, 7610, 7611, 
7612, 7613, 7614, 7615, 7616, 7617, 7618, 7619, 7620, 7621, 
7622, 7623, 7624, 7625, 7626, 7627, 7628, 7629, 7630, 7631, 
7632, 7633, 7634, 7635, 7636, 7637, 7638, 7639, 7640, 7641, 
7642, 7643, 7644, 7645, 7646, 7647, 7648, 7649, 7650, 7651, 
7652, 7653, 7654, 7655, 7656, 7657, 7658, 7659, 7660, 7661, 
7662, 7663, 7664, 7665, 7666, 7667, 7668, 7669, 7670, 7671, 
7672, 7673, 7674, 7675, 7676, 7677, 7678, 7679, 7680, 7681, 
7682, 7683, 7684, 7685, 7686, 7687, 7688, 7689, 7690, 7691, 
7692, 7693, 7694, 7695, 7696, 7697, 7698, 7699, 7700, 7701, 
7702, 7703, 7704, 7705, 7706, 7707, 7708, 7709, 7710, 7711, 
7712, 7713, 7714, 7715, 7716, 7717, 7718, 7719, 7720, 7721, 
7722, 7723, 7724, 7725, 7726, 7727, 7728, 7729, 7730, 7731, 
7732, 7733, 7734, 7735, 7736, 7737, 7738, 7739, 7740, 7741, 
7742, 7743, 7744, 7745, 7746, 7747, 7748, 7749, 7750, 7751, 
7752, 7753, 7754, 7755, 7756, 7757, 7758, 7759, 7760, 7761, 
7762, 7763, 7764, 7765, 7766, 7767, 7768, 7769, 7770, 7771, 
7772, 7773, 7774, 7775, 7776, 7777, 7778, 7779, 7780, 7781, 
7782, 7783, 7784, 7785, 7786, 7787, 7788, 7789, 7790, 7791, 
7792, 7793, 7794, 7795, 7796, 7797, 7798, 7799, 7800, 7801, 
7802, 7803, 7804, 7805, 7806, 7807, 7808, 7809, 7810, 7811, 
7812, 7813, 7814, 7815, 7816, 7817, 7818, 7819, 7820, 7821, 
7822, 7823, 7824, 7825, 7826, 7827, 7828, 7829, 7830, 7831, 
7832, 7833, 7834, 7835, 7836, 7837, 7838, 7839, 7840, 7841, 
7842, 7843, 7844, 7845, 7846, 7847, 7848, 7849, 7850, 7851, 
7852, 7853, 7854, 7855, 7856, 7857, 7858, 7859, 7860, 7861, 
7862, 7863, 7864, 7865, 7866, 7867, 7868, 7869, 7870, 7871, 
7872, 7873, 7874, 7875, 7876, 7877, 7878, 7879, 7880, 7881, 
7882, 7883, 7884, 7885, 7886, 7887, 7888, 7889, 7890, 7891, 
7892, 7893, 7894, 7895, 7896, 7897, 7898, 7899, 7900, 7901, 
7902, 7903, 7904, 7905, 7906, 7907, 7908, 7909, 7910, 7911, 
7912, 7913, 7914, 7915, 7916, 7917, 7918, 7919, 7920, 7921, 
7922, 7923, 7924, 7925, 7926, 7927, 7928, 7929, 7930, 7931, 
7932, 7933, 7934, 7935, 7936, 7937, 7938, 7939, 7940, 7941, 
7942, 7943, 7944, 7945, 7946, 7947, 7948, 7949, 7950, 7951, 
7952, 7953, 7954, 7955, 7956, 7957, 7958, 7959, 7960, 7961, 
7962, 7963, 7964, 7965, 7966, 7967, 7968, 7969, 7970, 7971, 
7972, 7973, 7974, 7975, 7976, 7977, 7978, 7979, 7980, 7981, 
7982, 7983, 7984, 7985, 7986, 7987, 7988, 7989, 7990, 7991, 
7992, 7993, 7994, 7995, 7996, 7997, 7998, 7999, 8000, 8001, 
8002, 8003, 8004, 8005, 8006, 8007, 8008, 8009, 8010, 8011, 
8012, 8013, 8014, 8015, 8016, 8017, 8018, 8019, 8020, 8021, 
8022, 8023, 8024, 8025, 8026, 8027, 8028, 8029, 8030, 8031, 
8032, 8033, 8034, 8035, 8036, 8037, 8038, 8039, 8040, 8041, 
8042, 8043, 8044, 8045, 8046, 8047, 8048, 8049, 8050, 8051, 
8052, 8053, 8054, 8055, 8056, 8057, 8058, 8059, 8060, 8061, 
8062, 8063, 8064, 8065, 8066, 8067, 8068, 8069, 8070, 8071, 
8072, 8073, 8074, 8075, 8076, 8077, 8078, 8079, 8080, 8081, 
8082, 8083, 8084, 8085, 8086, 8087, 8088, 8089, 8090, 8091, 
8092, 8093, 8094, 8095, 8096, 8097, 8098, 8099, 8100, 8101, 
8102, 8103, 8104, 8105, 8106, 8107, 8108, 8109, 8110, 8111, 
8112, 8113, 8114, 8115, 8116, 8117, 8118, 8119, 8120, 8121, 
8122, 8123, 8124, 8125, 8126, 8127, 8128, 8129, 8130, 8131, 
8132, 8133, 8134, 8135, 8136, 8137, 8138, 8139, 8140, 8141, 
8142, 8143, 8144, 8145, 8146, 8147, 8148, 8149, 8150, 8151, 
8152, 8153, 8154, 8155, 8156, 8157, 8158, 8159, 8160, 8161, 
8162, 8163, 8164, 8165, 8166, 8167, 8168, 8169, 8170, 8171, 
8172, 8173, 8174, 8175, 8176, 8177, 8178, 8179, 8180, 8181, 
8182, 8183, 8184, 8185, 8186, 8187, 8188, 8189, 8190, 8191, 
8192, 8193, 8194, 8195, 8196, 8197, 8198, 8199, 8200, 8201, 
8202, 8203, 8204, 8205, 8206, 8207, 8208, 8209, 8210, 8211, 
8212, 8213, 8214, 8215, 8216, 8217, 8218, 8219, 8220, 8221, 
8222, 8223, 8224, 8225, 8226, 8227, 8228, 8229, 8230, 8231, 
8232, 8233, 8234, 8235, 8236, 8237, 8238, 8239, 8240, 8241, 
8242, 8243, 8244, 8245, 8246, 8247, 8248, 8249, 8250, 8251, 
8252, 8253, 8254, 8255, 8256, 8257, 8258, 8259, 8260, 8261, 
8262, 8263, 8264, 8265, 8266, 8267, 8268, 8269, 8270, 8271, 
8272, 8273, 8274, 8275, 8276, 8277, 8278, 8279, 8280, 8281, 
8282, 8283, 8284, 8285, 8286, 8287, 8288, 8289, 8290, 8291, 
8292, 8293, 8294, 8295, 8296, 8297, 8298, 8299, 8300, 8301, 
8302, 8303, 8304, 8305, 8306, 8307, 8308, 8309, 8310, 8311, 
8312, 8313, 8314, 8315, 8316, 8317, 8318, 8319, 8320, 8321, 
8322, 8323, 8324, 8325, 8326, 8327, 8328, 8329, 8330, 8331, 
8332, 8333, 8334, 8335, 8336, 8337, 8338, 8339, 8340, 8341, 
8342, 8343, 8344, 8345, 8346, 8347, 8348, 8349, 8350, 8351, 
8352, 8353, 8354, 8355, 8356, 8357, 8358, 8359, 8360, 8361, 
8362, 8363, 8364, 8365, 8366, 8367, 8368, 8369, 8370, 8371, 
8372, 8373, 8374, 8375, 8376, 8377, 8378, 8379, 8380, 8381, 
8382, 8383, 8384, 8385, 8386, 8387, 8388, 8389, 8390, 8391, 
8392, 8393, 8394, 8395, 8396, 8397, 8398, 8399, 8400, 8401, 
8402, 8403, 8404, 8405, 8406, 8407, 8408, 8409, 8410, 8411, 
8412, 8413, 8414, 8415, 8416, 8417, 8418, 8419, 8420, 8421, 
8422, 8423, 8424, 8425, 8426, 8427, 8428, 8429, 8430, 8431, 
8432, 8433, 8434, 8435, 8436, 8437, 8438, 8439, 8440, 8441, 
8442, 8443, 8444, 8445, 8446, 8447, 8448, 8449, 8450, 8451, 
8452, 8453, 8454, 8455, 8456, 8457, 8458, 8459, 8460, 8461, 
8462, 8463, 8464, 8465, 8466, 8467, 8468, 8469, 8470, 8471, 
8472, 8473, 8474, 8475, 8476, 8477, 8478, 8479, 8480, 8481, 
8482, 8483, 8484, 8485, 8486, 8487, 8488, 8489, 8490, 8491, 
8492, 8493, 8494, 8495, 8496, 8497, 8498, 8499, 8500, 8501, 
8502, 8503, 8504, 8505, 8506, 8507, 8508, 8509, 8510, 8511, 
8512, 8513, 8514, 8515, 8516, 8517, 8518, 8519, 8520, 8521, 
8522, 8523, 8524, 8525, 8526, 8527, 8528, 8529, 8530, 8531, 
8532, 8533, 8534, 8535, 8536, 8537, 8538, 8539, 8540, 8541, 
8542, 8543, 8544, 8545, 8546, 8547, 8548, 8549, 8550, 8551, 
8552, 8553, 8554, 8555, 8556, 8557, 8558, 8559, 8560, 8561, 
8562, 8563, 8564, 8565, 8566, 8567, 8568, 8569, 8570, 8571, 
8572, 8573, 8574, 8575, 8576, 8577, 8578, 8579, 8580, 8581, 
8582, 8583, 8584, 8585, 8586, 8587, 8588, 8589, 8590, 8591, 
8592, 8593, 8594, 8595, 8596, 8597, 8598, 8599, 8600, 8601, 
8602, 8603, 8604, 8605, 8606, 8607, 8608, 8609, 8610, 8611, 
8612, 8613, 8614, 8615, 8616, 8617, 8618, 8619, 8620, 8621, 
8622, 8623, 8624, 8625, 8626, 8627, 8628, 8629, 8630, 8631, 
8632, 8633, 8634, 8635, 8636, 8637, 8638, 8639, 8640, 8641, 
8642, 8643, 8644, 8645, 8646, 8647, 8648, 8649, 8650, 8651, 
8652, 8653, 8654, 8655, 8656, 8657, 8658, 8659, 8660, 8661, 
8662, 8663, 8664, 8665, 8666, 8667, 8668, 8669, 8670, 8671, 
8672, 8673, 8674, 8675, 8676, 8677, 8678, 8679, 8680, 8681, 
8682, 8683, 8684, 8685, 8686, 8687, 8688, 8689, 8690, 8691, 
8692, 8693, 8694, 8695, 8696, 8697, 8698, 8699, 8700, 8701, 
8702, 8703, 8704, 8705, 8706, 8707, 8708, 8709, 8710, 8711, 
8712, 8713, 8714, 8715, 8716, 8717, 8718, 8719, 8720, 8721, 
8722, 8723, 8724, 8725, 8726, 8727, 8728, 8729, 8730, 8731, 
8732, 8733, 8734, 8735, 8736, 8737, 8738, 8739, 8740, 8741, 
8742, 8743, 8744, 8745, 8746, 8747, 8748, 8749, 8750, 8751, 
8752, 8753, 8754, 8755, 8756, 8757, 8758, 8759, 8760, 8761, 
8762, 8763, 8764, 8765, 8766, 8767, 8768, 8769, 8770, 8771, 
8772, 8773, 8774, 8775, 8776, 8777, 8778, 8779, 8780, 8781, 
8782, 8783, 8784, 8785, 8786, 8787, 8788, 8789, 8790, 8791, 
8792, 8793, 8794, 8795, 8796, 8797, 8798, 8799, 8800, 8801, 
8802, 8803, 8804, 8805, 8806, 8807, 8808, 8809, 8810, 8811, 
8812, 8813, 8814, 8815, 8816, 8817, 8818, 8819, 8820, 8821, 
8822, 8823, 8824, 8825, 8826, 8827, 8828, 8829, 8830, 8831, 
8832, 8833, 8834, 8835, 8836, 8837, 8838, 8839, 8840, 8841, 
8842, 8843, 8844, 8845, 8846, 8847, 8848, 8849, 8850, 8851, 
8852, 8853, 8854, 8855, 8856, 8857, 8858, 8859, 8860, 8861, 
8862, 8863, 8864, 8865, 8866, 8867, 8868, 8869, 8870, 8871, 
8872, 8873, 8874, 8875, 8876, 8877, 8878, 8879, 8880, 8881, 
8882, 8883, 8884, 8885, 8886, 8887, 8888, 8889, 8890, 8891, 
8892, 8893, 8894, 8895, 8896, 8897, 8898, 8899, 8900, 8901, 
8902, 8903, 8904, 8905, 8906, 8907, 8908, 8909, 8910, 8911, 
8912, 8913, 8914, 8915, 8916, 8917, 8918, 8919, 8920, 8921, 
8922, 8923, 8924, 8925, 8926, 8927, 8928, 8929, 8930, 8931, 
8932, 8933, 8934, 8935, 8936, 8937, 8938, 8939, 8940, 8941, 
8942, 8943, 8944, 8945, 8946, 8947, 8948, 8949, 8950, 8951, 
8952, 8953, 8954, 8955, 8956, 8957, 8958, 8959, 8960, 8961, 
8962, 8963, 8964, 8965, 8966, 8967, 8968, 8969, 8970, 8971, 
8972, 8973, 8974, 8975, 8976, 8977, 8978, 8979, 8980, 8981, 
8982, 8983, 8984, 8985, 8986, 8987, 8988, 8989, 8990, 8991, 
8992, 8993, 8994, 8995, 8996, 8997, 8998, 8999, 9000, 9001, 
9002, 9003, 9004, 9005, 9006, 9007, 9008, 9009, 9010, 9011, 
9012, 9013, 9014, 9015, 9016, 9017, 9018, 9019, 9020, 9021, 
9022, 9023, 9024, 9025, 9026, 9027, 9028, 9029, 9030, 9031, 
9032, 9033, 9034, 9035, 9036, 9037, 9038, 9039, 9040, 9041, 
9042, 9043, 9044, 9045, 9046, 9047, 9048, 9049, 9050, 9051, 
9052, 9053, 9054, 9055, 9056, 9057, 9058, 9059, 9060, 9061, 
9062, 9063, 9064, 9065, 9066, 9067, 9068, 9069, 9070, 9071, 
9072, 9073, 9074, 9075, 9076, 9077, 9078, 9079, 9080, 9081, 
9082, 9083, 9084, 9085, 9086, 9087, 9088, 9089, 9090, 9091, 
9092, 9093, 9094, 9095, 9096, 9097, 9098, 9099, 9100, 9101, 
9102, 9103, 9104, 9105, 9106, 9107, 9108, 9109, 9110, 9111, 
9112, 9113, 9114, 9115, 9116, 9117, 9118, 9119, 9120, 9121, 
9122, 9123, 9124, 9125, 9126, 9127, 9128, 9129, 9130, 9131, 
9132, 9133, 9134, 9135, 9136, 9137, 9138, 9139, 9140, 9141, 
9142, 9143, 9144, 9145, 9146, 9147, 9148, 9149, 9150, 9151, 
9152, 9153, 9154, 9155, 9156, 9157, 9158, 9159, 9160, 9161, 
9162, 9163, 9164, 9165, 9166, 9167, 9168, 9169, 9170, 9171, 
9172, 9173, 9174, 9175, 9176, 9177, 9178, 9179, 9180, 9181, 
9182, 9183, 9184, 9185, 9186, 9187, 9188, 9189, 9190, 9191, 
9192, 9193, 9194, 9195, 9196, 9197, 9198, 9199, 9200, 9201, 
9202, 9203, 9204, 9205, 9206, 9207, 9208, 9209, 9210, 9211, 
9212, 9213, 9214, 9215, 9216, 9217, 9218, 9219, 9220, 9221, 
9222, 9223, 9224, 9225, 9226, 9227, 9228, 9229, 9230, 9231, 
9232, 9233, 9234, 9235, 9236, 9237, 9238, 9239, 9240, 9241, 
9242, 9243, 9244, 9245, 9246, 9247, 9248, 9249, 9250, 9251, 
9252, 9253, 9254, 9255, 9256, 9257, 9258, 9259, 9260, 9261, 
9262, 9263, 9264, 9265, 9266, 9267, 9268, 9269, 9270, 9271, 
9272, 9273, 9274, 9275, 9276, 9277, 9278, 9279, 9280, 9281, 
9282, 9283, 9284, 9285, 9286, 9287, 9288, 9289, 9290, 9291, 
9292, 9293, 9294, 9295, 9296, 9297, 9298, 9299, 9300, 9301, 
9302, 9303, 9304, 9305, 9306, 9307, 9308, 9309, 9310, 9311, 
9312, 9313, 9314, 9315, 9316, 9317, 9318, 9319, 9320, 9321, 
9322, 9323, 9324, 9325, 9326, 9327, 9328, 9329, 9330, 9331, 
9332, 9333, 9334, 9335, 9336, 9337, 9338, 9339, 9340, 9341, 
9342, 9343, 9344, 9345, 9346, 9347, 9348, 9349, 9350, 9351, 
9352, 9353, 9354, 9355, 9356, 9357, 9358, 9359, 9360, 9361, 
9362, 9363, 9364, 9365, 9366, 9367, 9368, 9369, 9370, 9371, 
9372, 9373, 9374, 9375, 9376, 9377, 9378, 9379, 9380, 9381, 
9382, 9383, 9384, 9385, 9386, 9387, 9388, 9389, 9390, 9391, 
9392, 9393, 9394, 9395, 9396, 9397, 9398, 9399, 9400, 9401, 
9402, 9403, 9404, 9405, 9406, 9407, 9408, 9409, 9410, 9411, 
9412, 9413, 9414, 9415, 9416, 9417, 9418, 9419, 9420, 9421, 
9422, 9423, 9424, 9425, 9426, 9427, 9428, 9429, 9430, 9431, 
9432, 9433, 9434, 9435, 9436, 9437, 9438, 9439, 9440, 9441, 
9442, 9443, 9444, 9445, 9446, 9447, 9448, 9449, 9450, 9451, 
9452, 9453, 9454, 9455, 9456, 9457, 9458, 9459, 9460, 9461, 
9462, 9463, 9464, 9465, 9466, 9467, 9468, 9469, 9470, 9471, 
9472, 9473, 9474, 9475, 9476, 9477, 9478, 9479, 9480, 9481, 
9482, 9483, 9484, 9485, 9486, 9487, 9488, 9489, 9490, 9491, 
9492, 9493, 9494, 9495, 9496, 9497, 9498, 9499, 9500, 9501, 
9502, 9503, 9504, 9505, 9506, 9507, 9508, 9509, 9510, 9511, 
9512, 9513, 9514, 9515, 9516, 9517, 9518, 9519, 9520, 9521, 
9522, 9523, 9524, 9525, 9526, 9527, 9528, 9529, 9530, 9531, 
9532, 9533, 9534, 9535, 9536, 9537, 9538, 9539, 9540, 9541, 
9542, 9543, 9544, 9545, 9546, 9547, 9548, 9549, 9550, 9551, 
9552, 9553, 9554, 9555, 9556, 9557, 9558, 9559, 9560, 9561, 
9562, 9563, 9564, 9565, 9566, 9567, 9568, 9569, 9570, 9571, 
9572, 9573, 9574, 9575, 9576, 9577, 9578, 9579, 9580, 9581, 
9582, 9583, 9584, 9585, 9586, 9587, 9588, 9589, 9590, 9591, 
9592, 9593, 9594, 9595, 9596, 9597, 9598, 9599, 9600, 9601, 
9602, 9603, 9604, 9605, 9606, 9607, 9608, 9609, 9610, 9611, 
9612, 9613, 9614, 9615, 9616, 9617, 9618, 9619, 9620, 9621, 
9622, 9623, 9624, 9625, 9626, 9627, 9628, 9629, 9630, 9631, 
9632, 9633, 9634, 9635, 9636, 9637, 9638, 9639, 9640, 9641, 
9642, 9643, 9644, 9645, 9646, 9647, 9648, 9649, 9650, 9651, 
9652, 9653, 9654, 9655, 9656, 9657, 9658, 9659, 9660, 9661, 
9662, 9663, 9664, 9665, 9666, 9667, 9668, 9669, 9670, 9671, 
9672, 9673, 9674, 9675, 9676, 9677, 9678, 9679, 9680, 9681, 
9682, 9683, 9684, 9685, 9686, 9687, 9688, 9689, 9690, 9691, 
9692, 9693, 9694, 9695, 9696, 9697, 9698, 9699, 9700, 9701, 
9702, 9703, 9704, 9705, 9706, 9707, 9708, 9709, 9710, 9711, 
9712, 9713, 9714, 9715, 9716, 9717, 9718, 9719, 9720, 9721, 
9722, 9723, 9724, 9725, 9726, 9727, 9728, 9729, 9730, 9731, 
9732, 9733, 9734, 9735, 9736, 9737, 9738, 9739, 9740, 9741, 
9742, 9743, 9744, 9745, 9746, 9747, 9748, 9749, 9750, 9751, 
9752, 9753, 9754, 9755, 9756, 9757, 9758, 9759, 9760, 9761, 
9762, 9763, 9764, 9765, 9766, 9767, 9768, 9769, 9770, 9771, 
9772, 9773, 9774, 9775, 9776, 9777, 9778, 9779, 9780, 9781, 
9782, 9783, 9784, 9785, 9786, 9787, 9788, 9789, 9790, 9791, 
9792, 9793, 9794, 9795, 9796, 9797, 9798, 9799, 9800, 9801, 
9802, 9803, 9804, 9805, 9806, 9807, 9808, 9809, 9810, 9811, 
9812, 9813, 9814, 9815, 9816, 9817, 9818, 9819, 9820, 9821, 
9822, 9823, 9824, 9825, 9826, 9827, 9828, 9829, 9830, 9831, 
9832, 9833, 9834, 9835, 9836, 9837, 9838, 9839, 9840, 9841, 
9842, 9843, 9844, 9845, 9846, 9847, 9848, 9849, 9850, 9851, 
9852, 9853, 9854, 9855, 9856, 9857, 9858, 9859, 9860, 9861, 
9862, 9863, 9864, 9865, 9866, 9867, 9868, 9869, 9870, 9871, 
9872, 9873, 9874, 9875, 9876, 9877, 9878, 9879, 9880, 9881, 
9882, 9883, 9884, 9885, 9886, 9887, 9888, 9889, 9890, 9891, 
9892, 9893, 9894, 9895, 9896, 9897, 9898, 9899, 9900, 9901, 
9902, 9903, 9904, 9905, 9906, 9907, 9908, 9909, 9910, 9911, 
9912, 9913, 9914, 9915, 9916, 9917, 9918, 9919, 9920, 9921, 
9922, 9923, 9924, 9925, 9926, 9927, 9928, 9929, 9930, 9931, 
9932, 9933, 9934, 9935, 9936, 9937, 9938, 9939, 9940, 9941, 
9942, 9943, 9944, 9945, 9946, 9947, 9948, 9949, 9950, 9951, 
9952, 9953, 9954, 9955, 9956, 9957, 9958, 9959, 9960, 9961, 
9962, 9963, 9964, 9965, 9966, 9967, 9968, 9969, 9970, 9971, 
9972, 9973, 9974, 9975, 9976, 9977, 9978, 9979, 9980, 9981, 
9982, 9983, 9984, 9985, 9986, 9987, 9988, 9989, 9990, 9991, 
9992, 9993, 9994, 9995, 9996, 9997, 9998, 9999, 10000, 10001, 
10002, 10003, 10004, 10005, 10006, 10007, 10008, 10009, 10010, 10011, 
10012, 10013, 10014, 10015, 10016, 10017, 10018, 10019, 10020, 10021, 
10022, 10023, 10024, 10025, 10026, 10027, 10028, 10029, 10030, 10031, 
10032, 10033, 10034, 10035, 10036, 10037, 10038, 10039, 10040, 10041, 
10042, 10043, 10044, 10045, 10046, 10047, 10048, 10049, 10050, 10051, 
10052, 10053, 10054, 10055, 10056, 10057, 10058, 10059, 10060, 10061, 
10062, 10063, 10064, 10065, 10066, 10067, 10068, 10069, 10070, 10071, 
10072, 10073, 10074, 10075, 10076, 10077, 10078, 10079, 10080, 10081, 
10082, 10083, 10084, 10085, 10086, 10087, 10088, 10089, 10090, 10091, 
10092, 10093, 10094, 10095, 10096, 10097, 10098, 10099, 10100, 10101, 
10102, 10103, 10104, 10105, 10106, 10107, 10108, 10109, 10110, 10111, 
10112, 10113, 10114, 10115, 10116, 10117, 10118, 10119, 10120, 10121, 
10122, 10123, 10124, 10125, 10126, 10127, 10128, 10129, 10130, 10131, 
10132, 10133, 10134, 10135, 10136, 10137, 10138, 10139, 10140, 10141, 
10142, 10143, 10144, 10145, 10146, 10147, 10148, 10149, 10150, 10151, 
10152, 10153, 10154, 10155, 10156, 10157, 10158, 10159, 10160, 10161, 
10162, 10163, 10164, 10165, 10166, 10167, 10168, 10169, 10170, 10171, 
10172, 10173, 10174, 10175, 10176, 10177, 10178, 10179, 10180, 10181, 
10182, 10183, 10184, 10185, 10186, 10187, 10188, 10189, 10190, 10191, 
10192, 10193, 10194, 10195, 10196, 10197, 10198, 10199, 10200, 10201, 
10202, 10203, 10204, 10205, 10206, 10207, 10208, 10209, 10210, 10211, 
10212, 10213, 10214, 10215, 10216, 10217, 10218, 10219, 10220, 10221, 
10222, 10223, 10224, 10225, 10226, 10227, 10228, 10229, 10230, 10231, 
10232, 10233, 10234, 10235, 10236, 10237, 10238, 10239, 10240, 10241, 
10242, 10243, 10244, 10245, 10246, 10247, 10248, 10249, 10250, 10251, 
10252, 10253, 10254, 10255, 10256, 10257, 10258, 10259, 10260, 10261, 
10262, 10263, 10264, 10265, 10266, 10267, 10268, 10269, 10270, 10271, 
10272, 10273, 10274, 10275, 10276, 10277, 10278, 10279, 10280, 10281, 
10282, 10283, 10284, 10285, 10286, 10287, 10288, 10289, 10290, 10291, 
10292, 10293, 10294, 10295, 10296, 10297, 10298, 10299, 10300, 10301, 
10302, 10303, 10304, 10305, 10306, 10307, 10308, 10309, 10310, 10311, 
10312, 10313, 10314, 10315, 10316, 10317, 10318, 10319, 10320, 10321, 
10322, 10323, 10324, 10325, 10326, 10327, 10328, 10329, 10330, 10331, 
10332, 10333, 10334, 10335, 10336, 10337, 10338, 10339, 10340, 10341, 
10342, 10343, 10344, 10345, 10346, 10347, 10348, 10349, 10350, 10351, 
10352, 10353, 10354, 10355, 10356, 10357, 10358, 10359, 10360, 10361, 
10362, 10363, 10364, 10365, 10366, 10367, 10368, 10369, 10370, 10371, 
10372, 10373, 10374, 10375, 10376, 10377, 10378, 10379, 10380, 10381, 
10382, 10383, 10384, 10385, 10386, 10387, 10388, 10389, 10390, 10391, 
10392, 10393, 10394, 10395, 10396, 10397, 10398, 10399, 10400, 10401, 
10402, 10403, 10404, 10405, 10406, 10407, 10408, 10409, 10410, 10411, 
10412, 10413, 10414, 10415, 10416, 10417, 10418, 10419, 10420, 10421, 
10422, 10423, 10424, 10425, 10426, 10427, 10428, 10429, 10430, 10431, 
10432, 10433, 10434, 10435, 10436, 10437, 10438, 10439, 10440, 10441, 
