22690, 86006, 23834, 23824, 86016, 86007, 23835, 23825, 86017, 88302, 24224, 88312, 87778, 88303, 24226, 88313, 
87781, 87749, 24227, 24206, 87780
22691, 86007, 23835, 23825, 86017, 86008, 23836, 23826, 86018, 88303, 24226, 88313, 87781, 88304, 24228, 88314, 
87784, 87752, 24229, 24208, 87783
22692, 86008, 23836, 23826, 86018, 86009, 23837, 23827, 86019, 88304, 24228, 88314, 87784, 88305, 24230, 88315, 
87787, 87755, 24231, 24210, 87786
22693, 86009, 23837, 23827, 86019, 86010, 23838, 23828, 86020, 88305, 24230, 88315, 87787, 88306, 24232, 88316, 
87790, 87758, 24233, 24212, 87789
22694, 86010, 23838, 23828, 86020, 23403, 2329, 2328, 23404, 88306, 24232, 88316, 87790, 23560, 2351, 23561, 
23523, 87761, 24234, 24213, 87792
22695, 23078, 2248, 2247, 23079, 86011, 23819, 23809, 86021, 23235, 2270, 23236, 23200, 88307, 24193, 88317, 
87794, 87762, 24194, 24173, 87793
22696, 86011, 23819, 23809, 86021, 86012, 23820, 23810, 86022, 88307, 24193, 88317, 87794, 88308, 24195, 88318, 
87797, 87765, 24196, 24175, 87796
22697, 86012, 23820, 23810, 86022, 86013, 23821, 23811, 86023, 88308, 24195, 88318, 87797, 88309, 24197, 88319, 
87800, 87768, 24198, 24177, 87799
22698, 86013, 23821, 23811, 86023, 86014, 23822, 23812, 86024, 88309, 24197, 88319, 87800, 88310, 24199, 88320, 
87803, 87771, 24200, 24179, 87802
22699, 86014, 23822, 23812, 86024, 86015, 23823, 23813, 86025, 88310, 24199, 88320, 87803, 88311, 24201, 88321, 
87806, 87774, 24202, 24181, 87805
22700, 86015, 23823, 23813, 86025, 86016, 23824, 23814, 86026, 88311, 24201, 88321, 87806, 88312, 24203, 88322, 
87809, 87777, 24204, 24183, 87808
22701, 86016, 23824, 23814, 86026, 86017, 23825, 23815, 86027, 88312, 24203, 88322, 87809, 88313, 24205, 88323, 
87812, 87780, 24206, 24185, 87811
22702, 86017, 23825, 23815, 86027, 86018, 23826, 23816, 86028, 88313, 24205, 88323, 87812, 88314, 24207, 88324, 
87815, 87783, 24208, 24187, 87814
22703, 86018, 23826, 23816, 86028, 86019, 23827, 23817, 86029, 88314, 24207, 88324, 87815, 88315, 24209, 88325, 
87818, 87786, 24210, 24189, 87817
22704, 86019, 23827, 23817, 86029, 86020, 23828, 23818, 86030, 88315, 24209, 88325, 87818, 88316, 24211, 88326, 
87821, 87789, 24212, 24191, 87820
22705, 86020, 23828, 23818, 86030, 23404, 2328, 2327, 23405, 88316, 24211, 88326, 87821, 23561, 2350, 23562, 
23525, 87792, 24213, 24192, 87823
22706, 23079, 2247, 2246, 23080, 86021, 23809, 23799, 86031, 23236, 2269, 23237, 23202, 88317, 24172, 88327, 
87825, 87793, 24173, 24152, 87824
22707, 86021, 23809, 23799, 86031, 86022, 23810, 23800, 86032, 88317, 24172, 88327, 87825, 88318, 24174, 88328, 
87828, 87796, 24175, 24154, 87827
22708, 86022, 23810, 23800, 86032, 86023, 23811, 23801, 86033, 88318, 24174, 88328, 87828, 88319, 24176, 88329, 
87831, 87799, 24177, 24156, 87830
22709, 86023, 23811, 23801, 86033, 86024, 23812, 23802, 86034, 88319, 24176, 88329, 87831, 88320, 24178, 88330, 
87834, 87802, 24179, 24158, 87833
22710, 86024, 23812, 23802, 86034, 86025, 23813, 23803, 86035, 88320, 24178, 88330, 87834, 88321, 24180, 88331, 
87837, 87805, 24181, 24160, 87836
22711, 86025, 23813, 23803, 86035, 86026, 23814, 23804, 86036, 88321, 24180, 88331, 87837, 88322, 24182, 88332, 
87840, 87808, 24183, 24162, 87839
22712, 86026, 23814, 23804, 86036, 86027, 23815, 23805, 86037, 88322, 24182, 88332, 87840, 88323, 24184, 88333, 
87843, 87811, 24185, 24164, 87842
22713, 86027, 23815, 23805, 86037, 86028, 23816, 23806, 86038, 88323, 24184, 88333, 87843, 88324, 24186, 88334, 
87846, 87814, 24187, 24166, 87845
22714, 86028, 23816, 23806, 86038, 86029, 23817, 23807, 86039, 88324, 24186, 88334, 87846, 88325, 24188, 88335, 
87849, 87817, 24189, 24168, 87848
22715, 86029, 23817, 23807, 86039, 86030, 23818, 23808, 86040, 88325, 24188, 88335, 87849, 88326, 24190, 88336, 
87852, 87820, 24191, 24170, 87851
22716, 86030, 23818, 23808, 86040, 23405, 2327, 2326, 23406, 88326, 24190, 88336, 87852, 23562, 2349, 23563, 
23527, 87823, 24192, 24171, 87854
22717, 23080, 2246, 2245, 23081, 86031, 23799, 23789, 86041, 23237, 2268, 23238, 23204, 88327, 24151, 88337, 
87856, 87824, 24152, 24131, 87855
22718, 86031, 23799, 23789, 86041, 86032, 23800, 23790, 86042, 88327, 24151, 88337, 87856, 88328, 24153, 88338, 
87859, 87827, 24154, 24133, 87858
22719, 86032, 23800, 23790, 86042, 86033, 23801, 23791, 86043, 88328, 24153, 88338, 87859, 88329, 24155, 88339, 
87862, 87830, 24156, 24135, 87861
22720, 86033, 23801, 23791, 86043, 86034, 23802, 23792, 86044, 88329, 24155, 88339, 87862, 88330, 24157, 88340, 
87865, 87833, 24158, 24137, 87864
22721, 86034, 23802, 23792, 86044, 86035, 23803, 23793, 86045, 88330, 24157, 88340, 87865, 88331, 24159, 88341, 
87868, 87836, 24160, 24139, 87867
22722, 86035, 23803, 23793, 86045, 86036, 23804, 23794, 86046, 88331, 24159, 88341, 87868, 88332, 24161, 88342, 
87871, 87839, 24162, 24141, 87870
22723, 86036, 23804, 23794, 86046, 86037, 23805, 23795, 86047, 88332, 24161, 88342, 87871, 88333, 24163, 88343, 
87874, 87842, 24164, 24143, 87873
22724, 86037, 23805, 23795, 86047, 86038, 23806, 23796, 86048, 88333, 24163, 88343, 87874, 88334, 24165, 88344, 
87877, 87845, 24166, 24145, 87876
22725, 86038, 23806, 23796, 86048, 86039, 23807, 23797, 86049, 88334, 24165, 88344, 87877, 88335, 24167, 88345, 
87880, 87848, 24168, 24147, 87879
22726, 86039, 23807, 23797, 86049, 86040, 23808, 23798, 86050, 88335, 24167, 88345, 87880, 88336, 24169, 88346, 
87883, 87851, 24170, 24149, 87882
22727, 86040, 23808, 23798, 86050, 23406, 2326, 2325, 23407, 88336, 24169, 88346, 87883, 23563, 2348, 23564, 
23529, 87854, 24171, 24150, 87885
22728, 23081, 2245, 2244, 23082, 86041, 23789, 23779, 86051, 23238, 2267, 23239, 23206, 88337, 24130, 88347, 
87887, 87855, 24131, 24110, 87886
22729, 86041, 23789, 23779, 86051, 86042, 23790, 23780, 86052, 88337, 24130, 88347, 87887, 88338, 24132, 88348, 
87890, 87858, 24133, 24112, 87889
22730, 86042, 23790, 23780, 86052, 86043, 23791, 23781, 86053, 88338, 24132, 88348, 87890, 88339, 24134, 88349, 
87893, 87861, 24135, 24114, 87892
22731, 86043, 23791, 23781, 86053, 86044, 23792, 23782, 86054, 88339, 24134, 88349, 87893, 88340, 24136, 88350, 
87896, 87864, 24137, 24116, 87895
22732, 86044, 23792, 23782, 86054, 86045, 23793, 23783, 86055, 88340, 24136, 88350, 87896, 88341, 24138, 88351, 
87899, 87867, 24139, 24118, 87898
22733, 86045, 23793, 23783, 86055, 86046, 23794, 23784, 86056, 88341, 24138, 88351, 87899, 88342, 24140, 88352, 
87902, 87870, 24141, 24120, 87901
22734, 86046, 23794, 23784, 86056, 86047, 23795, 23785, 86057, 88342, 24140, 88352, 87902, 88343, 24142, 88353, 
87905, 87873, 24143, 24122, 87904
22735, 86047, 23795, 23785, 86057, 86048, 23796, 23786, 86058, 88343, 24142, 88353, 87905, 88344, 24144, 88354, 
87908, 87876, 24145, 24124, 87907
22736, 86048, 23796, 23786, 86058, 86049, 23797, 23787, 86059, 88344, 24144, 88354, 87908, 88345, 24146, 88355, 
87911, 87879, 24147, 24126, 87910
22737, 86049, 23797, 23787, 86059, 86050, 23798, 23788, 86060, 88345, 24146, 88355, 87911, 88346, 24148, 88356, 
87914, 87882, 24149, 24128, 87913
22738, 86050, 23798, 23788, 86060, 23407, 2325, 2324, 23408, 88346, 24148, 88356, 87914, 23564, 2347, 23565, 
23531, 87885, 24150, 24129, 87916
22739, 23082, 2244, 2243, 23083, 86051, 23779, 23769, 86061, 23239, 2266, 23240, 23208, 88347, 24109, 88357, 
87918, 87886, 24110, 24089, 87917
22740, 86051, 23779, 23769, 86061, 86052, 23780, 23770, 86062, 88347, 24109, 88357, 87918, 88348, 24111, 88358, 
87921, 87889, 24112, 24091, 87920
22741, 86052, 23780, 23770, 86062, 86053, 23781, 23771, 86063, 88348, 24111, 88358, 87921, 88349, 24113, 88359, 
87924, 87892, 24114, 24093, 87923
22742, 86053, 23781, 23771, 86063, 86054, 23782, 23772, 86064, 88349, 24113, 88359, 87924, 88350, 24115, 88360, 
87927, 87895, 24116, 24095, 87926
22743, 86054, 23782, 23772, 86064, 86055, 23783, 23773, 86065, 88350, 24115, 88360, 87927, 88351, 24117, 88361, 
87930, 87898, 24118, 24097, 87929
22744, 86055, 23783, 23773, 86065, 86056, 23784, 23774, 86066, 88351, 24117, 88361, 87930, 88352, 24119, 88362, 
87933, 87901, 24120, 24099, 87932
22745, 86056, 23784, 23774, 86066, 86057, 23785, 23775, 86067, 88352, 24119, 88362, 87933, 88353, 24121, 88363, 
87936, 87904, 24122, 24101, 87935
22746, 86057, 23785, 23775, 86067, 86058, 23786, 23776, 86068, 88353, 24121, 88363, 87936, 88354, 24123, 88364, 
87939, 87907, 24124, 24103, 87938
22747, 86058, 23786, 23776, 86068, 86059, 23787, 23777, 86069, 88354, 24123, 88364, 87939, 88355, 24125, 88365, 
87942, 87910, 24126, 24105, 87941
22748, 86059, 23787, 23777, 86069, 86060, 23788, 23778, 86070, 88355, 24125, 88365, 87942, 88356, 24127, 88366, 
87945, 87913, 24128, 24107, 87944
22749, 86060, 23788, 23778, 86070, 23408, 2324, 2323, 23409, 88356, 24127, 88366, 87945, 23565, 2346, 23566, 
23533, 87916, 24129, 24108, 87947
22750, 23083, 2243, 2242, 23084, 86061, 23769, 23759, 86071, 23240, 2265, 23241, 23210, 88357, 24088, 88367, 
87949, 87917, 24089, 24068, 87948
22751, 86061, 23769, 23759, 86071, 86062, 23770, 23760, 86072, 88357, 24088, 88367, 87949, 88358, 24090, 88368, 
87952, 87920, 24091, 24070, 87951
22752, 86062, 23770, 23760, 86072, 86063, 23771, 23761, 86073, 88358, 24090, 88368, 87952, 88359, 24092, 88369, 
87955, 87923, 24093, 24072, 87954
22753, 86063, 23771, 23761, 86073, 86064, 23772, 23762, 86074, 88359, 24092, 88369, 87955, 88360, 24094, 88370, 
87958, 87926, 24095, 24074, 87957
22754, 86064, 23772, 23762, 86074, 86065, 23773, 23763, 86075, 88360, 24094, 88370, 87958, 88361, 24096, 88371, 
87961, 87929, 24097, 24076, 87960
22755, 86065, 23773, 23763, 86075, 86066, 23774, 23764, 86076, 88361, 24096, 88371, 87961, 88362, 24098, 88372, 
87964, 87932, 24099, 24078, 87963
22756, 86066, 23774, 23764, 86076, 86067, 23775, 23765, 86077, 88362, 24098, 88372, 87964, 88363, 24100, 88373, 
87967, 87935, 24101, 24080, 87966
22757, 86067, 23775, 23765, 86077, 86068, 23776, 23766, 86078, 88363, 24100, 88373, 87967, 88364, 24102, 88374, 
87970, 87938, 24103, 24082, 87969
22758, 86068, 23776, 23766, 86078, 86069, 23777, 23767, 86079, 88364, 24102, 88374, 87970, 88365, 24104, 88375, 
87973, 87941, 24105, 24084, 87972
22759, 86069, 23777, 23767, 86079, 86070, 23778, 23768, 86080, 88365, 24104, 88375, 87973, 88366, 24106, 88376, 
87976, 87944, 24107, 24086, 87975
22760, 86070, 23778, 23768, 86080, 23409, 2323, 2322, 23410, 88366, 24106, 88376, 87976, 23566, 2345, 23567, 
23535, 87947, 24108, 24087, 87978
22761, 23084, 2242, 2241, 23085, 86071, 23759, 23749, 86081, 23241, 2264, 23242, 23212, 88367, 24067, 88377, 
87980, 87948, 24068, 24047, 87979
22762, 86071, 23759, 23749, 86081, 86072, 23760, 23750, 86082, 88367, 24067, 88377, 87980, 88368, 24069, 88378, 
87983, 87951, 24070, 24049, 87982
22763, 86072, 23760, 23750, 86082, 86073, 23761, 23751, 86083, 88368, 24069, 88378, 87983, 88369, 24071, 88379, 
87986, 87954, 24072, 24051, 87985
22764, 86073, 23761, 23751, 86083, 86074, 23762, 23752, 86084, 88369, 24071, 88379, 87986, 88370, 24073, 88380, 
87989, 87957, 24074, 24053, 87988
22765, 86074, 23762, 23752, 86084, 86075, 23763, 23753, 86085, 88370, 24073, 88380, 87989, 88371, 24075, 88381, 
87992, 87960, 24076, 24055, 87991
22766, 86075, 23763, 23753, 86085, 86076, 23764, 23754, 86086, 88371, 24075, 88381, 87992, 88372, 24077, 88382, 
87995, 87963, 24078, 24057, 87994
22767, 86076, 23764, 23754, 86086, 86077, 23765, 23755, 86087, 88372, 24077, 88382, 87995, 88373, 24079, 88383, 
87998, 87966, 24080, 24059, 87997
22768, 86077, 23765, 23755, 86087, 86078, 23766, 23756, 86088, 88373, 24079, 88383, 87998, 88374, 24081, 88384, 
88001, 87969, 24082, 24061, 88000
22769, 86078, 23766, 23756, 86088, 86079, 23767, 23757, 86089, 88374, 24081, 88384, 88001, 88375, 24083, 88385, 
88004, 87972, 24084, 24063, 88003
22770, 86079, 23767, 23757, 86089, 86080, 23768, 23758, 86090, 88375, 24083, 88385, 88004, 88376, 24085, 88386, 
88007, 87975, 24086, 24065, 88006
22771, 86080, 23768, 23758, 86090, 23410, 2322, 2321, 23411, 88376, 24085, 88386, 88007, 23567, 2344, 23568, 
23537, 87978, 24087, 24066, 88009
22772, 23085, 2241, 2240, 23086, 86081, 23749, 23739, 86091, 23242, 2263, 23243, 23214, 88377, 24046, 88387, 
88011, 87979, 24047, 24026, 88010
22773, 86081, 23749, 23739, 86091, 86082, 23750, 23740, 86092, 88377, 24046, 88387, 88011, 88378, 24048, 88388, 
88014, 87982, 24049, 24028, 88013
22774, 86082, 23750, 23740, 86092, 86083, 23751, 23741, 86093, 88378, 24048, 88388, 88014, 88379, 24050, 88389, 
88017, 87985, 24051, 24030, 88016
22775, 86083, 23751, 23741, 86093, 86084, 23752, 23742, 86094, 88379, 24050, 88389, 88017, 88380, 24052, 88390, 
88020, 87988, 24053, 24032, 88019
22776, 86084, 23752, 23742, 86094, 86085, 23753, 23743, 86095, 88380, 24052, 88390, 88020, 88381, 24054, 88391, 
88023, 87991, 24055, 24034, 88022
22777, 86085, 23753, 23743, 86095, 86086, 23754, 23744, 86096, 88381, 24054, 88391, 88023, 88382, 24056, 88392, 
88026, 87994, 24057, 24036, 88025
22778, 86086, 23754, 23744, 86096, 86087, 23755, 23745, 86097, 88382, 24056, 88392, 88026, 88383, 24058, 88393, 
88029, 87997, 24059, 24038, 88028
22779, 86087, 23755, 23745, 86097, 86088, 23756, 23746, 86098, 88383, 24058, 88393, 88029, 88384, 24060, 88394, 
88032, 88000, 24061, 24040, 88031
22780, 86088, 23756, 23746, 86098, 86089, 23757, 23747, 86099, 88384, 24060, 88394, 88032, 88385, 24062, 88395, 
88035, 88003, 24063, 24042, 88034
22781, 86089, 23757, 23747, 86099, 86090, 23758, 23748, 86100, 88385, 24062, 88395, 88035, 88386, 24064, 88396, 
88038, 88006, 24065, 24044, 88037
22782, 86090, 23758, 23748, 86100, 23411, 2321, 2320, 23412, 88386, 24064, 88396, 88038, 23568, 2343, 23569, 
23539, 88009, 24066, 24045, 88040
22783, 23086, 2240, 2239, 23087, 86091, 23739, 23729, 86101, 23243, 2262, 23244, 23216, 88387, 24025, 88397, 
88042, 88010, 24026, 24005, 88041
22784, 86091, 23739, 23729, 86101, 86092, 23740, 23730, 86102, 88387, 24025, 88397, 88042, 88388, 24027, 88398, 
88045, 88013, 24028, 24007, 88044
22785, 86092, 23740, 23730, 86102, 86093, 23741, 23731, 86103, 88388, 24027, 88398, 88045, 88389, 24029, 88399, 
88048, 88016, 24030, 24009, 88047
22786, 86093, 23741, 23731, 86103, 86094, 23742, 23732, 86104, 88389, 24029, 88399, 88048, 88390, 24031, 88400, 
88051, 88019, 24032, 24011, 88050
22787, 86094, 23742, 23732, 86104, 86095, 23743, 23733, 86105, 88390, 24031, 88400, 88051, 88391, 24033, 88401, 
88054, 88022, 24034, 24013, 88053
22788, 86095, 23743, 23733, 86105, 86096, 23744, 23734, 86106, 88391, 24033, 88401, 88054, 88392, 24035, 88402, 
88057, 88025, 24036, 24015, 88056
22789, 86096, 23744, 23734, 86106, 86097, 23745, 23735, 86107, 88392, 24035, 88402, 88057, 88393, 24037, 88403, 
88060, 88028, 24038, 24017, 88059
22790, 86097, 23745, 23735, 86107, 86098, 23746, 23736, 86108, 88393, 24037, 88403, 88060, 88394, 24039, 88404, 
88063, 88031, 24040, 24019, 88062
22791, 86098, 23746, 23736, 86108, 86099, 23747, 23737, 86109, 88394, 24039, 88404, 88063, 88395, 24041, 88405, 
88066, 88034, 24042, 24021, 88065
22792, 86099, 23747, 23737, 86109, 86100, 23748, 23738, 86110, 88395, 24041, 88405, 88066, 88396, 24043, 88406, 
88069, 88037, 24044, 24023, 88068
22793, 86100, 23748, 23738, 86110, 23412, 2320, 2319, 23413, 88396, 24043, 88406, 88069, 23569, 2342, 23570, 
23541, 88040, 24045, 24024, 88071
22794, 23087, 2239, 2238, 23088, 86101, 23729, 23719, 86111, 23244, 2261, 23245, 23218, 88397, 24004, 88407, 
88073, 88041, 24005, 23984, 88072
22795, 86101, 23729, 23719, 86111, 86102, 23730, 23720, 86112, 88397, 24004, 88407, 88073, 88398, 24006, 88408, 
88076, 88044, 24007, 23986, 88075
22796, 86102, 23730, 23720, 86112, 86103, 23731, 23721, 86113, 88398, 24006, 88408, 88076, 88399, 24008, 88409, 
88079, 88047, 24009, 23988, 88078
22797, 86103, 23731, 23721, 86113, 86104, 23732, 23722, 86114, 88399, 24008, 88409, 88079, 88400, 24010, 88410, 
88082, 88050, 24011, 23990, 88081
22798, 86104, 23732, 23722, 86114, 86105, 23733, 23723, 86115, 88400, 24010, 88410, 88082, 88401, 24012, 88411, 
88085, 88053, 24013, 23992, 88084
22799, 86105, 23733, 23723, 86115, 86106, 23734, 23724, 86116, 88401, 24012, 88411, 88085, 88402, 24014, 88412, 
88088, 88056, 24015, 23994, 88087
22800, 86106, 23734, 23724, 86116, 86107, 23735, 23725, 86117, 88402, 24014, 88412, 88088, 88403, 24016, 88413, 
88091, 88059, 24017, 23996, 88090
22801, 86107, 23735, 23725, 86117, 86108, 23736, 23726, 86118, 88403, 24016, 88413, 88091, 88404, 24018, 88414, 
88094, 88062, 24019, 23998, 88093
22802, 86108, 23736, 23726, 86118, 86109, 23737, 23727, 86119, 88404, 24018, 88414, 88094, 88405, 24020, 88415, 
88097, 88065, 24021, 24000, 88096
22803, 86109, 23737, 23727, 86119, 86110, 23738, 23728, 86120, 88405, 24020, 88415, 88097, 88406, 24022, 88416, 
88100, 88068, 24023, 24002, 88099
22804, 86110, 23738, 23728, 86120, 23413, 2319, 2318, 23414, 88406, 24022, 88416, 88100, 23570, 2341, 23571, 
23543, 88071, 24024, 24003, 88102
22805, 23088, 2238, 2237, 23089, 86111, 23719, 23709, 86121, 23245, 2260, 23246, 23220, 88407, 23983, 88417, 
88104, 88072, 23984, 23963, 88103
22806, 86111, 23719, 23709, 86121, 86112, 23720, 23710, 86122, 88407, 23983, 88417, 88104, 88408, 23985, 88418, 
88107, 88075, 23986, 23965, 88106
22807, 86112, 23720, 23710, 86122, 86113, 23721, 23711, 86123, 88408, 23985, 88418, 88107, 88409, 23987, 88419, 
88110, 88078, 23988, 23967, 88109
22808, 86113, 23721, 23711, 86123, 86114, 23722, 23712, 86124, 88409, 23987, 88419, 88110, 88410, 23989, 88420, 
88113, 88081, 23990, 23969, 88112
22809, 86114, 23722, 23712, 86124, 86115, 23723, 23713, 86125, 88410, 23989, 88420, 88113, 88411, 23991, 88421, 
88116, 88084, 23992, 23971, 88115
22810, 86115, 23723, 23713, 86125, 86116, 23724, 23714, 86126, 88411, 23991, 88421, 88116, 88412, 23993, 88422, 
88119, 88087, 23994, 23973, 88118
22811, 86116, 23724, 23714, 86126, 86117, 23725, 23715, 86127, 88412, 23993, 88422, 88119, 88413, 23995, 88423, 
88122, 88090, 23996, 23975, 88121
22812, 86117, 23725, 23715, 86127, 86118, 23726, 23716, 86128, 88413, 23995, 88423, 88122, 88414, 23997, 88424, 
88125, 88093, 23998, 23977, 88124
22813, 86118, 23726, 23716, 86128, 86119, 23727, 23717, 86129, 88414, 23997, 88424, 88125, 88415, 23999, 88425, 
88128, 88096, 24000, 23979, 88127
22814, 86119, 23727, 23717, 86129, 86120, 23728, 23718, 86130, 88415, 23999, 88425, 88128, 88416, 24001, 88426, 
88131, 88099, 24002, 23981, 88130
22815, 86120, 23728, 23718, 86130, 23414, 2318, 2317, 23415, 88416, 24001, 88426, 88131, 23571, 2340, 23572, 
23545, 88102, 24003, 23982, 88133
22816, 23089, 2237, 2236, 23090, 86121, 23709, 23699, 86131, 23246, 2259, 23247, 23222, 88417, 23962, 88427, 
88135, 88103, 23963, 23942, 88134
22817, 86121, 23709, 23699, 86131, 86122, 23710, 23700, 86132, 88417, 23962, 88427, 88135, 88418, 23964, 88428, 
88138, 88106, 23965, 23944, 88137
22818, 86122, 23710, 23700, 86132, 86123, 23711, 23701, 86133, 88418, 23964, 88428, 88138, 88419, 23966, 88429, 
88141, 88109, 23967, 23946, 88140
22819, 86123, 23711, 23701, 86133, 86124, 23712, 23702, 86134, 88419, 23966, 88429, 88141, 88420, 23968, 88430, 
88144, 88112, 23969, 23948, 88143
22820, 86124, 23712, 23702, 86134, 86125, 23713, 23703, 86135, 88420, 23968, 88430, 88144, 88421, 23970, 88431, 
88147, 88115, 23971, 23950, 88146
22821, 86125, 23713, 23703, 86135, 86126, 23714, 23704, 86136, 88421, 23970, 88431, 88147, 88422, 23972, 88432, 
88150, 88118, 23973, 23952, 88149
22822, 86126, 23714, 23704, 86136, 86127, 23715, 23705, 86137, 88422, 23972, 88432, 88150, 88423, 23974, 88433, 
88153, 88121, 23975, 23954, 88152
22823, 86127, 23715, 23705, 86137, 86128, 23716, 23706, 86138, 88423, 23974, 88433, 88153, 88424, 23976, 88434, 
88156, 88124, 23977, 23956, 88155
22824, 86128, 23716, 23706, 86138, 86129, 23717, 23707, 86139, 88424, 23976, 88434, 88156, 88425, 23978, 88435, 
88159, 88127, 23979, 23958, 88158
22825, 86129, 23717, 23707, 86139, 86130, 23718, 23708, 86140, 88425, 23978, 88435, 88159, 88426, 23980, 88436, 
88162, 88130, 23981, 23960, 88161
22826, 86130, 23718, 23708, 86140, 23415, 2317, 2316, 23416, 88426, 23980, 88436, 88162, 23572, 2339, 23573, 
23547, 88133, 23982, 23961, 88164
22827, 23090, 2236, 2235, 23091, 86131, 23699, 23689, 86141, 23247, 2258, 23248, 23224, 88427, 23941, 88437, 
88166, 88134, 23942, 23921, 88165
22828, 86131, 23699, 23689, 86141, 86132, 23700, 23690, 86142, 88427, 23941, 88437, 88166, 88428, 23943, 88438, 
88169, 88137, 23944, 23923, 88168
22829, 86132, 23700, 23690, 86142, 86133, 23701, 23691, 86143, 88428, 23943, 88438, 88169, 88429, 23945, 88439, 
88172, 88140, 23946, 23925, 88171
22830, 86133, 23701, 23691, 86143, 86134, 23702, 23692, 86144, 88429, 23945, 88439, 88172, 88430, 23947, 88440, 
88175, 88143, 23948, 23927, 88174
22831, 86134, 23702, 23692, 86144, 86135, 23703, 23693, 86145, 88430, 23947, 88440, 88175, 88431, 23949, 88441, 
88178, 88146, 23950, 23929, 88177
22832, 86135, 23703, 23693, 86145, 86136, 23704, 23694, 86146, 88431, 23949, 88441, 88178, 88432, 23951, 88442, 
88181, 88149, 23952, 23931, 88180
22833, 86136, 23704, 23694, 86146, 86137, 23705, 23695, 86147, 88432, 23951, 88442, 88181, 88433, 23953, 88443, 
88184, 88152, 23954, 23933, 88183
22834, 86137, 23705, 23695, 86147, 86138, 23706, 23696, 86148, 88433, 23953, 88443, 88184, 88434, 23955, 88444, 
88187, 88155, 23956, 23935, 88186
22835, 86138, 23706, 23696, 86148, 86139, 23707, 23697, 86149, 88434, 23955, 88444, 88187, 88435, 23957, 88445, 
88190, 88158, 23958, 23937, 88189
22836, 86139, 23707, 23697, 86149, 86140, 23708, 23698, 86150, 88435, 23957, 88445, 88190, 88436, 23959, 88446, 
88193, 88161, 23960, 23939, 88192
22837, 86140, 23708, 23698, 86150, 23416, 2316, 2315, 23417, 88436, 23959, 88446, 88193, 23573, 2338, 23574, 
23549, 88164, 23961, 23940, 88195
22838, 23091, 2235, 2234, 23092, 86141, 23689, 23679, 86151, 23248, 2257, 23249, 23226, 88437, 23920, 88447, 
88197, 88165, 23921, 23900, 88196
22839, 86141, 23689, 23679, 86151, 86142, 23690, 23680, 86152, 88437, 23920, 88447, 88197, 88438, 23922, 88448, 
88200, 88168, 23923, 23902, 88199
22840, 86142, 23690, 23680, 86152, 86143, 23691, 23681, 86153, 88438, 23922, 88448, 88200, 88439, 23924, 88449, 
88203, 88171, 23925, 23904, 88202
22841, 86143, 23691, 23681, 86153, 86144, 23692, 23682, 86154, 88439, 23924, 88449, 88203, 88440, 23926, 88450, 
88206, 88174, 23927, 23906, 88205
22842, 86144, 23692, 23682, 86154, 86145, 23693, 23683, 86155, 88440, 23926, 88450, 88206, 88441, 23928, 88451, 
88209, 88177, 23929, 23908, 88208
22843, 86145, 23693, 23683, 86155, 86146, 23694, 23684, 86156, 88441, 23928, 88451, 88209, 88442, 23930, 88452, 
88212, 88180, 23931, 23910, 88211
22844, 86146, 23694, 23684, 86156, 86147, 23695, 23685, 86157, 88442, 23930, 88452, 88212, 88443, 23932, 88453, 
88215, 88183, 23933, 23912, 88214
22845, 86147, 23695, 23685, 86157, 86148, 23696, 23686, 86158, 88443, 23932, 88453, 88215, 88444, 23934, 88454, 
88218, 88186, 23935, 23914, 88217
22846, 86148, 23696, 23686, 86158, 86149, 23697, 23687, 86159, 88444, 23934, 88454, 88218, 88445, 23936, 88455, 
88221, 88189, 23937, 23916, 88220
22847, 86149, 23697, 23687, 86159, 86150, 23698, 23688, 86160, 88445, 23936, 88455, 88221, 88446, 23938, 88456, 
88224, 88192, 23939, 23918, 88223
22848, 86150, 23698, 23688, 86160, 23417, 2315, 2314, 23418, 88446, 23938, 88456, 88224, 23574, 2337, 23575, 
23551, 88195, 23940, 23919, 88226
22849, 23092, 2234, 56, 2229, 86151, 23679, 2359, 23605, 23249, 2256, 2233, 23227, 88447, 23899, 23678, 
88227, 88196, 23900, 2369, 23668
22850, 86151, 23679, 2359, 23605, 86152, 23680, 2360, 23604, 88447, 23899, 23678, 88227, 88448, 23901, 23677, 
88228, 88199, 23902, 2370, 23666
22851, 86152, 23680, 2360, 23604, 86153, 23681, 2361, 23603, 88448, 23901, 23677, 88228, 88449, 23903, 23676, 
88229, 88202, 23904, 2371, 23664
22852, 86153, 23681, 2361, 23603, 86154, 23682, 2362, 23602, 88449, 23903, 23676, 88229, 88450, 23905, 23675, 
88230, 88205, 23906, 2372, 23662
22853, 86154, 23682, 2362, 23602, 86155, 23683, 2363, 23601, 88450, 23905, 23675, 88230, 88451, 23907, 23674, 
88231, 88208, 23908, 2373, 23660
22854, 86155, 23683, 2363, 23601, 86156, 23684, 2364, 23600, 88451, 23907, 23674, 88231, 88452, 23909, 23673, 
88232, 88211, 23910, 2374, 23658
22855, 86156, 23684, 2364, 23600, 86157, 23685, 2365, 23599, 88452, 23909, 23673, 88232, 88453, 23911, 23672, 
88233, 88214, 23912, 2375, 23656
22856, 86157, 23685, 2365, 23599, 86158, 23686, 2366, 23598, 88453, 23911, 23672, 88233, 88454, 23913, 23671, 
88234, 88217, 23914, 2376, 23654
22857, 86158, 23686, 2366, 23598, 86159, 23687, 2367, 23597, 88454, 23913, 23671, 88234, 88455, 23915, 23670, 
88235, 88220, 23916, 2377, 23652
22858, 86159, 23687, 2367, 23597, 86160, 23688, 2368, 23596, 88455, 23915, 23670, 88235, 88456, 23917, 23669, 
88236, 88223, 23918, 2378, 23650
22859, 86160, 23688, 2368, 23596, 23418, 2314, 58, 2309, 88456, 23917, 23669, 88236, 23575, 2336, 2313, 
23553, 88226, 23919, 2379, 23648
*ELEMENT, type=C3D20, ELSET=Volume21
22860, 23, 2279, 24371, 1134, 1042, 23250, 88457, 13513, 2282, 24384, 24383, 1138, 23280, 88578, 88579, 
13554, 1053, 23281, 88577, 13553
22861, 1042, 23250, 88457, 13513, 1041, 23251, 88458, 13514, 23280, 88578, 88579, 13554, 23282, 88581, 88582, 
13556, 1052, 23283, 88580, 13555
22862, 1041, 23251, 88458, 13514, 1040, 23252, 88459, 13515, 23282, 88581, 88582, 13556, 23284, 88584, 88585, 
13558, 1051, 23285, 88583, 13557
22863, 1040, 23252, 88459, 13515, 1039, 23253, 88460, 13516, 23284, 88584, 88585, 13558, 23286, 88587, 88588, 
13560, 1050, 23287, 88586, 13559
22864, 1039, 23253, 88460, 13516, 1038, 23254, 88461, 13517, 23286, 88587, 88588, 13560, 23288, 88590, 88591, 
13562, 1049, 23289, 88589, 13561
22865, 1038, 23254, 88461, 13517, 1037, 23255, 88462, 13518, 23288, 88590, 88591, 13562, 23290, 88593, 88594, 
13564, 1048, 23291, 88592, 13563
22866, 1037, 23255, 88462, 13518, 1036, 23256, 88463, 13519, 23290, 88593, 88594, 13564, 23292, 88596, 88597, 
13566, 1047, 23293, 88595, 13565
22867, 1036, 23256, 88463, 13519, 1035, 23257, 88464, 13520, 23292, 88596, 88597, 13566, 23294, 88599, 88600, 
13568, 1046, 23295, 88598, 13567
22868, 1035, 23257, 88464, 13520, 1034, 23258, 88465, 13521, 23294, 88599, 88600, 13568, 23296, 88602, 88603, 
13570, 1045, 23297, 88601, 13569
22869, 1034, 23258, 88465, 13521, 1033, 23259, 88466, 13522, 23296, 88602, 88603, 13570, 23298, 88605, 88606, 
13572, 1044, 23299, 88604, 13571
22870, 1033, 23259, 88466, 13522, 21, 2220, 24414, 1157, 23298, 88605, 88606, 13572, 2223, 24426, 24427, 
1161, 1043, 23300, 88607, 13573
22871, 1134, 24371, 24372, 1135, 13513, 88457, 88467, 13523, 24383, 24386, 24385, 1139, 88579, 88609, 88610, 
13575, 13553, 88577, 88608, 13574
22872, 13513, 88457, 88467, 13523, 13514, 88458, 88468, 13524, 88579, 88609, 88610, 13575, 88582, 88612, 88613, 
13577, 13555, 88580, 88611, 13576
22873, 13514, 88458, 88468, 13524, 13515, 88459, 88469, 13525, 88582, 88612, 88613, 13577, 88585, 88615, 88616, 
13579, 13557, 88583, 88614, 13578
22874, 13515, 88459, 88469, 13525, 13516, 88460, 88470, 13526, 88585, 88615, 88616, 13579, 88588, 88618, 88619, 
13581, 13559, 88586, 88617, 13580
22875, 13516, 88460, 88470, 13526, 13517, 88461, 88471, 13527, 88588, 88618, 88619, 13581, 88591, 88621, 88622, 
13583, 13561, 88589, 88620, 13582
22876, 13517, 88461, 88471, 13527, 13518, 88462, 88472, 13528, 88591, 88621, 88622, 13583, 88594, 88624, 88625, 
13585, 13563, 88592, 88623, 13584
22877, 13518, 88462, 88472, 13528, 13519, 88463, 88473, 13529, 88594, 88624, 88625, 13585, 88597, 88627, 88628, 
13587, 13565, 88595, 88626, 13586
22878, 13519, 88463, 88473, 13529, 13520, 88464, 88474, 13530, 88597, 88627, 88628, 13587, 88600, 88630, 88631, 
13589, 13567, 88598, 88629, 13588
22879, 13520, 88464, 88474, 13530, 13521, 88465, 88475, 13531, 88600, 88630, 88631, 13589, 88603, 88633, 88634, 
13591, 13569, 88601, 88632, 13590
22880, 13521, 88465, 88475, 13531, 13522, 88466, 88476, 13532, 88603, 88633, 88634, 13591, 88606, 88636, 88637, 
13593, 13571, 88604, 88635, 13592
22881, 13522, 88466, 88476, 13532, 1157, 24414, 24415, 1158, 88606, 88636, 88637, 13593, 24427, 24428, 24429, 
1162, 13573, 88607, 88638, 13594
22882, 1135, 24372, 24373, 1136, 13523, 88467, 88477, 13533, 24385, 24388, 24387, 1140, 88610, 88640, 88641, 
13596, 13574, 88608, 88639, 13595
22883, 13523, 88467, 88477, 13533, 13524, 88468, 88478, 13534, 88610, 88640, 88641, 13596, 88613, 88643, 88644, 
13598, 13576, 88611, 88642, 13597
22884, 13524, 88468, 88478, 13534, 13525, 88469, 88479, 13535, 88613, 88643, 88644, 13598, 88616, 88646, 88647, 
13600, 13578, 88614, 88645, 13599
22885, 13525, 88469, 88479, 13535, 13526, 88470, 88480, 13536, 88616, 88646, 88647, 13600, 88619, 88649, 88650, 
13602, 13580, 88617, 88648, 13601
22886, 13526, 88470, 88480, 13536, 13527, 88471, 88481, 13537, 88619, 88649, 88650, 13602, 88622, 88652, 88653, 
13604, 13582, 88620, 88651, 13603
22887, 13527, 88471, 88481, 13537, 13528, 88472, 88482, 13538, 88622, 88652, 88653, 13604, 88625, 88655, 88656, 
13606, 13584, 88623, 88654, 13605
22888, 13528, 88472, 88482, 13538, 13529, 88473, 88483, 13539, 88625, 88655, 88656, 13606, 88628, 88658, 88659, 
13608, 13586, 88626, 88657, 13607
22889, 13529, 88473, 88483, 13539, 13530, 88474, 88484, 13540, 88628, 88658, 88659, 13608, 88631, 88661, 88662, 
13610, 13588, 88629, 88660, 13609
22890, 13530, 88474, 88484, 13540, 13531, 88475, 88485, 13541, 88631, 88661, 88662, 13610, 88634, 88664, 88665, 
13612, 13590, 88632, 88663, 13611
22891, 13531, 88475, 88485, 13541, 13532, 88476, 88486, 13542, 88634, 88664, 88665, 13612, 88637, 88667, 88668, 
13614, 13592, 88635, 88666, 13613
22892, 13532, 88476, 88486, 13542, 1158, 24415, 24416, 1159, 88637, 88667, 88668, 13614, 24429, 24430, 24431, 
1163, 13594, 88638, 88669, 13615
22893, 1136, 24373, 24374, 1137, 13533, 88477, 88487, 13543, 24387, 24390, 24389, 1141, 88641, 88671, 88672, 
13617, 13595, 88639, 88670, 13616
22894, 13533, 88477, 88487, 13543, 13534, 88478, 88488, 13544, 88641, 88671, 88672, 13617, 88644, 88674, 88675, 
13619, 13597, 88642, 88673, 13618
22895, 13534, 88478, 88488, 13544, 13535, 88479, 88489, 13545, 88644, 88674, 88675, 13619, 88647, 88677, 88678, 
13621, 13599, 88645, 88676, 13620
22896, 13535, 88479, 88489, 13545, 13536, 88480, 88490, 13546, 88647, 88677, 88678, 13621, 88650, 88680, 88681, 
13623, 13601, 88648, 88679, 13622
22897, 13536, 88480, 88490, 13546, 13537, 88481, 88491, 13547, 88650, 88680, 88681, 13623, 88653, 88683, 88684, 
13625, 13603, 88651, 88682, 13624
22898, 13537, 88481, 88491, 13547, 13538, 88482, 88492, 13548, 88653, 88683, 88684, 13625, 88656, 88686, 88687, 
13627, 13605, 88654, 88685, 13626
22899, 13538, 88482, 88492, 13548, 13539, 88483, 88493, 13549, 88656, 88686, 88687, 13627, 88659, 88689, 88690, 
13629, 13607, 88657, 88688, 13628
22900, 13539, 88483, 88493, 13549, 13540, 88484, 88494, 13550, 88659, 88689, 88690, 13629, 88662, 88692, 88693, 
13631, 13609, 88660, 88691, 13630
22901, 13540, 88484, 88494, 13550, 13541, 88485, 88495, 13551, 88662, 88692, 88693, 13631, 88665, 88695, 88696, 
13633, 13611, 88663, 88694, 13632
22902, 13541, 88485, 88495, 13551, 13542, 88486, 88496, 13552, 88665, 88695, 88696, 13633, 88668, 88698, 88699, 
13635, 13613, 88666, 88697, 13634
22903, 13542, 88486, 88496, 13552, 1159, 24416, 24417, 1160, 88668, 88698, 88699, 13635, 24431, 24432, 24433, 
1164, 13615, 88669, 88700, 13636
22904, 1137, 24374, 2380, 26, 13543, 88487, 24457, 1201, 24389, 24391, 2383, 1142, 88672, 88701, 24487, 
13637, 13616, 88670, 24488, 1212
22905, 13543, 88487, 24457, 1201, 13544, 88488, 24458, 1200, 88672, 88701, 24487, 13637, 88675, 88702, 24489, 
13638, 13618, 88673, 24490, 1211
22906, 13544, 88488, 24458, 1200, 13545, 88489, 24459, 1199, 88675, 88702, 24489, 13638, 88678, 88703, 24491, 
13639, 13620, 88676, 24492, 1210
22907, 13545, 88489, 24459, 1199, 13546, 88490, 24460, 1198, 88678, 88703, 24491, 13639, 88681, 88704, 24493, 
13640, 13622, 88679, 24494, 1209
22908, 13546, 88490, 24460, 1198, 13547, 88491, 24461, 1197, 88681, 88704, 24493, 13640, 88684, 88705, 24495, 
13641, 13624, 88682, 24496, 1208
22909, 13547, 88491, 24461, 1197, 13548, 88492, 24462, 1196, 88684, 88705, 24495, 13641, 88687, 88706, 24497, 
13642, 13626, 88685, 24498, 1207
22910, 13548, 88492, 24462, 1196, 13549, 88493, 24463, 1195, 88687, 88706, 24497, 13642, 88690, 88707, 24499, 
13643, 13628, 88688, 24500, 1206
22911, 13549, 88493, 24463, 1195, 13550, 88494, 24464, 1194, 88690, 88707, 24499, 13643, 88693, 88708, 24501, 
13644, 13630, 88691, 24502, 1205
22912, 13550, 88494, 24464, 1194, 13551, 88495, 24465, 1193, 88693, 88708, 24501, 13644, 88696, 88709, 24503, 
13645, 13632, 88694, 24504, 1204
22913, 13551, 88495, 24465, 1193, 13552, 88496, 24466, 1192, 88696, 88709, 24503, 13645, 88699, 88710, 24505, 
13646, 13634, 88697, 24506, 1203
22914, 13552, 88496, 24466, 1192, 1160, 24417, 2396, 28, 88699, 88710, 24505, 13646, 24433, 24434, 2399, 
1165, 13636, 88700, 24507, 1202
22915, 2279, 2280, 24375, 24371, 23250, 23260, 88497, 88457, 2283, 24393, 24392, 24384, 23301, 88712, 88713, 
88578, 23281, 23302, 88711, 88577
22916, 23250, 23260, 88497, 88457, 23251, 23261, 88498, 88458, 23301, 88712, 88713, 88578, 23303, 88715, 88716, 
88581, 23283, 23304, 88714, 88580
22917, 23251, 23261, 88498, 88458, 23252, 23262, 88499, 88459, 23303, 88715, 88716, 88581, 23305, 88718, 88719, 
88584, 23285, 23306, 88717, 88583
22918, 23252, 23262, 88499, 88459, 23253, 23263, 88500, 88460, 23305, 88718, 88719, 88584, 23307, 88721, 88722, 
88587, 23287, 23308, 88720, 88586
22919, 23253, 23263, 88500, 88460, 23254, 23264, 88501, 88461, 23307, 88721, 88722, 88587, 23309, 88724, 88725, 
88590, 23289, 23310, 88723, 88589
22920, 23254, 23264, 88501, 88461, 23255, 23265, 88502, 88462, 23309, 88724, 88725, 88590, 23311, 88727, 88728, 
88593, 23291, 23312, 88726, 88592
22921, 23255, 23265, 88502, 88462, 23256, 23266, 88503, 88463, 23311, 88727, 88728, 88593, 23313, 88730, 88731, 
88596, 23293, 23314, 88729, 88595
22922, 23256, 23266, 88503, 88463, 23257, 23267, 88504, 88464, 23313, 88730, 88731, 88596, 23315, 88733, 88734, 
88599, 23295, 23316, 88732, 88598
22923, 23257, 23267, 88504, 88464, 23258, 23268, 88505, 88465, 23315, 88733, 88734, 88599, 23317, 88736, 88737, 
88602, 23297, 23318, 88735, 88601
22924, 23258, 23268, 88505, 88465, 23259, 23269, 88506, 88466, 23317, 88736, 88737, 88602, 23319, 88739, 88740, 
88605, 23299, 23320, 88738, 88604
22925, 23259, 23269, 88506, 88466, 2220, 2221, 24418, 24414, 23319, 88739, 88740, 88605, 2224, 24435, 24436, 
24426, 23300, 23321, 88741, 88607
22926, 24371, 24375, 24376, 24372, 88457, 88497, 88507, 88467, 24392, 24395, 24394, 24386, 88713, 88743, 88744, 
88609, 88577, 88711, 88742, 88608
22927, 88457, 88497, 88507, 88467, 88458, 88498, 88508, 88468, 88713, 88743, 88744, 88609, 88716, 88746, 88747, 
88612, 88580, 88714, 88745, 88611
22928, 88458, 88498, 88508, 88468, 88459, 88499, 88509, 88469, 88716, 88746, 88747, 88612, 88719, 88749, 88750, 
88615, 88583, 88717, 88748, 88614
22929, 88459, 88499, 88509, 88469, 88460, 88500, 88510, 88470, 88719, 88749, 88750, 88615, 88722, 88752, 88753, 
88618, 88586, 88720, 88751, 88617
22930, 88460, 88500, 88510, 88470, 88461, 88501, 88511, 88471, 88722, 88752, 88753, 88618, 88725, 88755, 88756, 
88621, 88589, 88723, 88754, 88620
22931, 88461, 88501, 88511, 88471, 88462, 88502, 88512, 88472, 88725, 88755, 88756, 88621, 88728, 88758, 88759, 
88624, 88592, 88726, 88757, 88623
22932, 88462, 88502, 88512, 88472, 88463, 88503, 88513, 88473, 88728, 88758, 88759, 88624, 88731, 88761, 88762, 
88627, 88595, 88729, 88760, 88626
22933, 88463, 88503, 88513, 88473, 88464, 88504, 88514, 88474, 88731, 88761, 88762, 88627, 88734, 88764, 88765, 
88630, 88598, 88732, 88763, 88629
22934, 88464, 88504, 88514, 88474, 88465, 88505, 88515, 88475, 88734, 88764, 88765, 88630, 88737, 88767, 88768, 
88633, 88601, 88735, 88766, 88632
22935, 88465, 88505, 88515, 88475, 88466, 88506, 88516, 88476, 88737, 88767, 88768, 88633, 88740, 88770, 88771, 
88636, 88604, 88738, 88769, 88635
22936, 88466, 88506, 88516, 88476, 24414, 24418, 24419, 24415, 88740, 88770, 88771, 88636, 24436, 24437, 24438, 
24428, 88607, 88741, 88772, 88638
22937, 24372, 24376, 24377, 24373, 88467, 88507, 88517, 88477, 24394, 24397, 24396, 24388, 88744, 88774, 88775, 
88640, 88608, 88742, 88773, 88639
22938, 88467, 88507, 88517, 88477, 88468, 88508, 88518, 88478, 88744, 88774, 88775, 88640, 88747, 88777, 88778, 
88643, 88611, 88745, 88776, 88642
22939, 88468, 88508, 88518, 88478, 88469, 88509, 88519, 88479, 88747, 88777, 88778, 88643, 88750, 88780, 88781, 
88646, 88614, 88748, 88779, 88645
22940, 88469, 88509, 88519, 88479, 88470, 88510, 88520, 88480, 88750, 88780, 88781, 88646, 88753, 88783, 88784, 
88649, 88617, 88751, 88782, 88648
22941, 88470, 88510, 88520, 88480, 88471, 88511, 88521, 88481, 88753, 88783, 88784, 88649, 88756, 88786, 88787, 
88652, 88620, 88754, 88785, 88651
22942, 88471, 88511, 88521, 88481, 88472, 88512, 88522, 88482, 88756, 88786, 88787, 88652, 88759, 88789, 88790, 
88655, 88623, 88757, 88788, 88654
22943, 88472, 88512, 88522, 88482, 88473, 88513, 88523, 88483, 88759, 88789, 88790, 88655, 88762, 88792, 88793, 
88658, 88626, 88760, 88791, 88657
22944, 88473, 88513, 88523, 88483, 88474, 88514, 88524, 88484, 88762, 88792, 88793, 88658, 88765, 88795, 88796, 
88661, 88629, 88763, 88794, 88660
22945, 88474, 88514, 88524, 88484, 88475, 88515, 88525, 88485, 88765, 88795, 88796, 88661, 88768, 88798, 88799, 
88664, 88632, 88766, 88797, 88663
22946, 88475, 88515, 88525, 88485, 88476, 88516, 88526, 88486, 88768, 88798, 88799, 88664, 88771, 88801, 88802, 
88667, 88635, 88769, 88800, 88666
22947, 88476, 88516, 88526, 88486, 24415, 24419, 24420, 24416, 88771, 88801, 88802, 88667, 24438, 24439, 24440, 
24430, 88638, 88772, 88803, 88669
22948, 24373, 24377, 24378, 24374, 88477, 88517, 88527, 88487, 24396, 24399, 24398, 24390, 88775, 88805, 88806, 
88671, 88639, 88773, 88804, 88670
22949, 88477, 88517, 88527, 88487, 88478, 88518, 88528, 88488, 88775, 88805, 88806, 88671, 88778, 88808, 88809, 
88674, 88642, 88776, 88807, 88673
22950, 88478, 88518, 88528, 88488, 88479, 88519, 88529, 88489, 88778, 88808, 88809, 88674, 88781, 88811, 88812, 
88677, 88645, 88779, 88810, 88676
22951, 88479, 88519, 88529, 88489, 88480, 88520, 88530, 88490, 88781, 88811, 88812, 88677, 88784, 88814, 88815, 
88680, 88648, 88782, 88813, 88679
22952, 88480, 88520, 88530, 88490, 88481, 88521, 88531, 88491, 88784, 88814, 88815, 88680, 88787, 88817, 88818, 
88683, 88651, 88785, 88816, 88682
22953, 88481, 88521, 88531, 88491, 88482, 88522, 88532, 88492, 88787, 88817, 88818, 88683, 88790, 88820, 88821, 
88686, 88654, 88788, 88819, 88685
22954, 88482, 88522, 88532, 88492, 88483, 88523, 88533, 88493, 88790, 88820, 88821, 88686, 88793, 88823, 88824, 
88689, 88657, 88791, 88822, 88688
22955, 88483, 88523, 88533, 88493, 88484, 88524, 88534, 88494, 88793, 88823, 88824, 88689, 88796, 88826, 88827, 
88692, 88660, 88794, 88825, 88691
22956, 88484, 88524, 88534, 88494, 88485, 88525, 88535, 88495, 88796, 88826, 88827, 88692, 88799, 88829, 88830, 
88695, 88663, 88797, 88828, 88694
22957, 88485, 88525, 88535, 88495, 88486, 88526, 88536, 88496, 88799, 88829, 88830, 88695, 88802, 88832, 88833, 
88698, 88666, 88800, 88831, 88697
22958, 88486, 88526, 88536, 88496, 24416, 24420, 24421, 24417, 88802, 88832, 88833, 88698, 24440, 24441, 24442, 
24432, 88669, 88803, 88834, 88700
22959, 24374, 24378, 2381, 2380, 88487, 88527, 24467, 24457, 24398, 24400, 2384, 24391, 88806, 88835, 24508, 
88701, 88670, 88804, 24509, 24488
22960, 88487, 88527, 24467, 24457, 88488, 88528, 24468, 24458, 88806, 88835, 24508, 88701, 88809, 88836, 24510, 
88702, 88673, 88807, 24511, 24490
22961, 88488, 88528, 24468, 24458, 88489, 88529, 24469, 24459, 88809, 88836, 24510, 88702, 88812, 88837, 24512, 
88703, 88676, 88810, 24513, 24492
22962, 88489, 88529, 24469, 24459, 88490, 88530, 24470, 24460, 88812, 88837, 24512, 88703, 88815, 88838, 24514, 
88704, 88679, 88813, 24515, 24494
22963, 88490, 88530, 24470, 24460, 88491, 88531, 24471, 24461, 88815, 88838, 24514, 88704, 88818, 88839, 24516, 
88705, 88682, 88816, 24517, 24496
22964, 88491, 88531, 24471, 24461, 88492, 88532, 24472, 24462, 88818, 88839, 24516, 88705, 88821, 88840, 24518, 
88706, 88685, 88819, 24519, 24498
22965, 88492, 88532, 24472, 24462, 88493, 88533, 24473, 24463, 88821, 88840, 24518, 88706, 88824, 88841, 24520, 
88707, 88688, 88822, 24521, 24500
22966, 88493, 88533, 24473, 24463, 88494, 88534, 24474, 24464, 88824, 88841, 24520, 88707, 88827, 88842, 24522, 
88708, 88691, 88825, 24523, 24502
22967, 88494, 88534, 24474, 24464, 88495, 88535, 24475, 24465, 88827, 88842, 24522, 88708, 88830, 88843, 24524, 
88709, 88694, 88828, 24525, 24504
22968, 88495, 88535, 24475, 24465, 88496, 88536, 24476, 24466, 88830, 88843, 24524, 88709, 88833, 88844, 24526, 
88710, 88697, 88831, 24527, 24506
22969, 88496, 88536, 24476, 24466, 24417, 24421, 2397, 2396, 88833, 88844, 24526, 88710, 24442, 24443, 2400, 
24434, 88700, 88834, 24528, 24507
22970, 2280, 2281, 24379, 24375, 23260, 23270, 88537, 88497, 2284, 24402, 24401, 24393, 23322, 88846, 88847, 
88712, 23302, 23323, 88845, 88711
22971, 23260, 23270, 88537, 88497, 23261, 23271, 88538, 88498, 23322, 88846, 88847, 88712, 23324, 88849, 88850, 
88715, 23304, 23325, 88848, 88714
22972, 23261, 23271, 88538, 88498, 23262, 23272, 88539, 88499, 23324, 88849, 88850, 88715, 23326, 88852, 88853, 
88718, 23306, 23327, 88851, 88717
22973, 23262, 23272, 88539, 88499, 23263, 23273, 88540, 88500, 23326, 88852, 88853, 88718, 23328, 88855, 88856, 
88721, 23308, 23329, 88854, 88720
22974, 23263, 23273, 88540, 88500, 23264, 23274, 88541, 88501, 23328, 88855, 88856, 88721, 23330, 88858, 88859, 
88724, 23310, 23331, 88857, 88723
22975, 23264, 23274, 88541, 88501, 23265, 23275, 88542, 88502, 23330, 88858, 88859, 88724, 23332, 88861, 88862, 
88727, 23312, 23333, 88860, 88726
22976, 23265, 23275, 88542, 88502, 23266, 23276, 88543, 88503, 23332, 88861, 88862, 88727, 23334, 88864, 88865, 
88730, 23314, 23335, 88863, 88729
22977, 23266, 23276, 88543, 88503, 23267, 23277, 88544, 88504, 23334, 88864, 88865, 88730, 23336, 88867, 88868, 
88733, 23316, 23337, 88866, 88732
22978, 23267, 23277, 88544, 88504, 23268, 23278, 88545, 88505, 23336, 88867, 88868, 88733, 23338, 88870, 88871, 
88736, 23318, 23339, 88869, 88735
22979, 23268, 23278, 88545, 88505, 23269, 23279, 88546, 88506, 23338, 88870, 88871, 88736, 23340, 88873, 88874, 
88739, 23320, 23341, 88872, 88738
22980, 23269, 23279, 88546, 88506, 2221, 2222, 24422, 24418, 23340, 88873, 88874, 88739, 2225, 24444, 24445, 
24435, 23321, 23342, 88875, 88741
22981, 24375, 24379, 24380, 24376, 88497, 88537, 88547, 88507, 24401, 24404, 24403, 24395, 88847, 88877, 88878, 
88743, 88711, 88845, 88876, 88742
22982, 88497, 88537, 88547, 88507, 88498, 88538, 88548, 88508, 88847, 88877, 88878, 88743, 88850, 88880, 88881, 
88746, 88714, 88848, 88879, 88745
22983, 88498, 88538, 88548, 88508, 88499, 88539, 88549, 88509, 88850, 88880, 88881, 88746, 88853, 88883, 88884, 
88749, 88717, 88851, 88882, 88748
22984, 88499, 88539, 88549, 88509, 88500, 88540, 88550, 88510, 88853, 88883, 88884, 88749, 88856, 88886, 88887, 
88752, 88720, 88854, 88885, 88751
22985, 88500, 88540, 88550, 88510, 88501, 88541, 88551, 88511, 88856, 88886, 88887, 88752, 88859, 88889, 88890, 
88755, 88723, 88857, 88888, 88754
22986, 88501, 88541, 88551, 88511, 88502, 88542, 88552, 88512, 88859, 88889, 88890, 88755, 88862, 88892, 88893, 
88758, 88726, 88860, 88891, 88757
22987, 88502, 88542, 88552, 88512, 88503, 88543, 88553, 88513, 88862, 88892, 88893, 88758, 88865, 88895, 88896, 
88761, 88729, 88863, 88894, 88760
22988, 88503, 88543, 88553, 88513, 88504, 88544, 88554, 88514, 88865, 88895, 88896, 88761, 88868, 88898, 88899, 
88764, 88732, 88866, 88897, 88763
22989, 88504, 88544, 88554, 88514, 88505, 88545, 88555, 88515, 88868, 88898, 88899, 88764, 88871, 88901, 88902, 
88767, 88735, 88869, 88900, 88766
22990, 88505, 88545, 88555, 88515, 88506, 88546, 88556, 88516, 88871, 88901, 88902, 88767, 88874, 88904, 88905, 
88770, 88738, 88872, 88903, 88769
22991, 88506, 88546, 88556, 88516, 24418, 24422, 24423, 24419, 88874, 88904, 88905, 88770, 24445, 24446, 24447, 
24437, 88741, 88875, 88906, 88772
22992, 24376, 24380, 24381, 24377, 88507, 88547, 88557, 88517, 24403, 24406, 24405, 24397, 88878, 88908, 88909, 
88774, 88742, 88876, 88907, 88773
22993, 88507, 88547, 88557, 88517, 88508, 88548, 88558, 88518, 88878, 88908, 88909, 88774, 88881, 88911, 88912, 
88777, 88745, 88879, 88910, 88776
22994, 88508, 88548, 88558, 88518, 88509, 88549, 88559, 88519, 88881, 88911, 88912, 88777, 88884, 88914, 88915, 
88780, 88748, 88882, 88913, 88779
22995, 88509, 88549, 88559, 88519, 88510, 88550, 88560, 88520, 88884, 88914, 88915, 88780, 88887, 88917, 88918, 
88783, 88751, 88885, 88916, 88782
22996, 88510, 88550, 88560, 88520, 88511, 88551, 88561, 88521, 88887, 88917, 88918, 88783, 88890, 88920, 88921, 
88786, 88754, 88888, 88919, 88785
22997, 88511, 88551, 88561, 88521, 88512, 88552, 88562, 88522, 88890, 88920, 88921, 88786, 88893, 88923, 88924, 
88789, 88757, 88891, 88922, 88788
22998, 88512, 88552, 88562, 88522, 88513, 88553, 88563, 88523, 88893, 88923, 88924, 88789, 88896, 88926, 88927, 
88792, 88760, 88894, 88925, 88791
22999, 88513, 88553, 88563, 88523, 88514, 88554, 88564, 88524, 88896, 88926, 88927, 88792, 88899, 88929, 88930, 
88795, 88763, 88897, 88928, 88794
23000, 88514, 88554, 88564, 88524, 88515, 88555, 88565, 88525, 88899, 88929, 88930, 88795, 88902, 88932, 88933, 
88798, 88766, 88900, 88931, 88797
23001, 88515, 88555, 88565, 88525, 88516, 88556, 88566, 88526, 88902, 88932, 88933, 88798, 88905, 88935, 88936, 
88801, 88769, 88903, 88934, 88800
23002, 88516, 88556, 88566, 88526, 24419, 24423, 24424, 24420, 88905, 88935, 88936, 88801, 24447, 24448, 24449, 
24439, 88772, 88906, 88937, 88803
23003, 24377, 24381, 24382, 24378, 88517, 88557, 88567, 88527, 24405, 24408, 24407, 24399, 88909, 88939, 88940, 
88805, 88773, 88907, 88938, 88804
23004, 88517, 88557, 88567, 88527, 88518, 88558, 88568, 88528, 88909, 88939, 88940, 88805, 88912, 88942, 88943, 
88808, 88776, 88910, 88941, 88807
23005, 88518, 88558, 88568, 88528, 88519, 88559, 88569, 88529, 88912, 88942, 88943, 88808, 88915, 88945, 88946, 
88811, 88779, 88913, 88944, 88810
23006, 88519, 88559, 88569, 88529, 88520, 88560, 88570, 88530, 88915, 88945, 88946, 88811, 88918, 88948, 88949, 
88814, 88782, 88916, 88947, 88813
23007, 88520, 88560, 88570, 88530, 88521, 88561, 88571, 88531, 88918, 88948, 88949, 88814, 88921, 88951, 88952, 
88817, 88785, 88919, 88950, 88816
23008, 88521, 88561, 88571, 88531, 88522, 88562, 88572, 88532, 88921, 88951, 88952, 88817, 88924, 88954, 88955, 
88820, 88788, 88922, 88953, 88819
23009, 88522, 88562, 88572, 88532, 88523, 88563, 88573, 88533, 88924, 88954, 88955, 88820, 88927, 88957, 88958, 
88823, 88791, 88925, 88956, 88822
23010, 88523, 88563, 88573, 88533, 88524, 88564, 88574, 88534, 88927, 88957, 88958, 88823, 88930, 88960, 88961, 
88826, 88794, 88928, 88959, 88825
23011, 88524, 88564, 88574, 88534, 88525, 88565, 88575, 88535, 88930, 88960, 88961, 88826, 88933, 88963, 88964, 
88829, 88797, 88931, 88962, 88828
23012, 88525, 88565, 88575, 88535, 88526, 88566, 88576, 88536, 88933, 88963, 88964, 88829, 88936, 88966, 88967, 
88832, 88800, 88934, 88965, 88831
23013, 88526, 88566, 88576, 88536, 24420, 24424, 24425, 24421, 88936, 88966, 88967, 88832, 24449, 24450, 24451, 
24441, 88803, 88937, 88968, 88834
23014, 24378, 24382, 2382, 2381, 88527, 88567, 24477, 24467, 24407, 24409, 2385, 24400, 88940, 88969, 24529, 
88835, 88804, 88938, 24530, 24509
23015, 88527, 88567, 24477, 24467, 88528, 88568, 24478, 24468, 88940, 88969, 24529, 88835, 88943, 88970, 24531, 
88836, 88807, 88941, 24532, 24511
23016, 88528, 88568, 24478, 24468, 88529, 88569, 24479, 24469, 88943, 88970, 24531, 88836, 88946, 88971, 24533, 
88837, 88810, 88944, 24534, 24513
23017, 88529, 88569, 24479, 24469, 88530, 88570, 24480, 24470, 88946, 88971, 24533, 88837, 88949, 88972, 24535, 
88838, 88813, 88947, 24536, 24515
23018, 88530, 88570, 24480, 24470, 88531, 88571, 24481, 24471, 88949, 88972, 24535, 88838, 88952, 88973, 24537, 
88839, 88816, 88950, 24538, 24517
23019, 88531, 88571, 24481, 24471, 88532, 88572, 24482, 24472, 88952, 88973, 24537, 88839, 88955, 88974, 24539, 
88840, 88819, 88953, 24540, 24519
23020, 88532, 88572, 24482, 24472, 88533, 88573, 24483, 24473, 88955, 88974, 24539, 88840, 88958, 88975, 24541, 
88841, 88822, 88956, 24542, 24521
23021, 88533, 88573, 24483, 24473, 88534, 88574, 24484, 24474, 88958, 88975, 24541, 88841, 88961, 88976, 24543, 
88842, 88825, 88959, 24544, 24523
23022, 88534, 88574, 24484, 24474, 88535, 88575, 24485, 24475, 88961, 88976, 24543, 88842, 88964, 88977, 24545, 
88843, 88828, 88962, 24546, 24525
23023, 88535, 88575, 24485, 24475, 88536, 88576, 24486, 24476, 88964, 88977, 24545, 88843, 88967, 88978, 24547, 
88844, 88831, 88965, 24548, 24527
23024, 88536, 88576, 24486, 24476, 24421, 24425, 2398, 2397, 88967, 88978, 24547, 88844, 24451, 24452, 2401, 
24443, 88834, 88968, 24549, 24528
23025, 2281, 57, 2387, 24379, 23270, 2295, 24560, 88537, 2285, 2391, 24410, 24402, 23343, 24601, 88979, 
88846, 23323, 2306, 24600, 88845
23026, 23270, 2295, 24560, 88537, 23271, 2294, 24561, 88538, 23343, 24601, 88979, 88846, 23344, 24603, 88980, 
88849, 23325, 2305, 24602, 88848
23027, 23271, 2294, 24561, 88538, 23272, 2293, 24562, 88539, 23344, 24603, 88980, 88849, 23345, 24605, 88981, 
88852, 23327, 2304, 24604, 88851
23028, 23272, 2293, 24562, 88539, 23273, 2292, 24563, 88540, 23345, 24605, 88981, 88852, 23346, 24607, 88982, 
88855, 23329, 2303, 24606, 88854
23029, 23273, 2292, 24563, 88540, 23274, 2291, 24564, 88541, 23346, 24607, 88982, 88855, 23347, 24609, 88983, 
88858, 23331, 2302, 24608, 88857
23030, 23274, 2291, 24564, 88541, 23275, 2290, 24565, 88542, 23347, 24609, 88983, 88858, 23348, 24611, 88984, 
88861, 23333, 2301, 24610, 88860
23031, 23275, 2290, 24565, 88542, 23276, 2289, 24566, 88543, 23348, 24611, 88984, 88861, 23349, 24613, 88985, 
88864, 23335, 2300, 24612, 88863
23032, 23276, 2289, 24566, 88543, 23277, 2288, 24567, 88544, 23349, 24613, 88985, 88864, 23350, 24615, 88986, 
88867, 23337, 2299, 24614, 88866
23033, 23277, 2288, 24567, 88544, 23278, 2287, 24568, 88545, 23350, 24615, 88986, 88867, 23351, 24617, 88987, 
88870, 23339, 2298, 24616, 88869
23034, 23278, 2287, 24568, 88545, 23279, 2286, 24569, 88546, 23351, 24617, 88987, 88870, 23352, 24619, 88988, 
88873, 23341, 2297, 24618, 88872
23035, 23279, 2286, 24569, 88546, 2222, 55, 2403, 24422, 23352, 24619, 88988, 88873, 2226, 2407, 24453, 
24444, 23342, 2296, 24620, 88875
23036, 24379, 2387, 2388, 24380, 88537, 24560, 24570, 88547, 24410, 2392, 24411, 24404, 88979, 24622, 88989, 
88877, 88845, 24600, 24621, 88876
23037, 88537, 24560, 24570, 88547, 88538, 24561, 24571, 88548, 88979, 24622, 88989, 88877, 88980, 24624, 88990, 
88880, 88848, 24602, 24623, 88879
23038, 88538, 24561, 24571, 88548, 88539, 24562, 24572, 88549, 88980, 24624, 88990, 88880, 88981, 24626, 88991, 
88883, 88851, 24604, 24625, 88882
23039, 88539, 24562, 24572, 88549, 88540, 24563, 24573, 88550, 88981, 24626, 88991, 88883, 88982, 24628, 88992, 
88886, 88854, 24606, 24627, 88885
23040, 88540, 24563, 24573, 88550, 88541, 24564, 24574, 88551, 88982, 24628, 88992, 88886, 88983, 24630, 88993, 
88889, 88857, 24608, 24629, 88888
23041, 88541, 24564, 24574, 88551, 88542, 24565, 24575, 88552, 88983, 24630, 88993, 88889, 88984, 24632, 88994, 
88892, 88860, 24610, 24631, 88891
23042, 88542, 24565, 24575, 88552, 88543, 24566, 24576, 88553, 88984, 24632, 88994, 88892, 88985, 24634, 88995, 
88895, 88863, 24612, 24633, 88894
23043, 88543, 24566, 24576, 88553, 88544, 24567, 24577, 88554, 88985, 24634, 88995, 88895, 88986, 24636, 88996, 
88898, 88866, 24614, 24635, 88897
23044, 88544, 24567, 24577, 88554, 88545, 24568, 24578, 88555, 88986, 24636, 88996, 88898, 88987, 24638, 88997, 
88901, 88869, 24616, 24637, 88900
23045, 88545, 24568, 24578, 88555, 88546, 24569, 24579, 88556, 88987, 24638, 88997, 88901, 88988, 24640, 88998, 
88904, 88872, 24618, 24639, 88903
23046, 88546, 24569, 24579, 88556, 24422, 2403, 2404, 24423, 88988, 24640, 88998, 88904, 24453, 2408, 24454, 
24446, 88875, 24620, 24641, 88906
23047, 24380, 2388, 2389, 24381, 88547, 24570, 24580, 88557, 24411, 2393, 24412, 24406, 88989, 24643, 88999, 
88908, 88876, 24621, 24642, 88907
23048, 88547, 24570, 24580, 88557, 88548, 24571, 24581, 88558, 88989, 24643, 88999, 88908, 88990, 24645, 89000, 
88911, 88879, 24623, 24644, 88910
23049, 88548, 24571, 24581, 88558, 88549, 24572, 24582, 88559, 88990, 24645, 89000, 88911, 88991, 24647, 89001, 
88914, 88882, 24625, 24646, 88913
23050, 88549, 24572, 24582, 88559, 88550, 24573, 24583, 88560, 88991, 24647, 89001, 88914, 88992, 24649, 89002, 
88917, 88885, 24627, 24648, 88916
23051, 88550, 24573, 24583, 88560, 88551, 24574, 24584, 88561, 88992, 24649, 89002, 88917, 88993, 24651, 89003, 
88920, 88888, 24629, 24650, 88919
23052, 88551, 24574, 24584, 88561, 88552, 24575, 24585, 88562, 88993, 24651, 89003, 88920, 88994, 24653, 89004, 
88923, 88891, 24631, 24652, 88922
23053, 88552, 24575, 24585, 88562, 88553, 24576, 24586, 88563, 88994, 24653, 89004, 88923, 88995, 24655, 89005, 
88926, 88894, 24633, 24654, 88925
23054, 88553, 24576, 24586, 88563, 88554, 24577, 24587, 88564, 88995, 24655, 89005, 88926, 88996, 24657, 89006, 
88929, 88897, 24635, 24656, 88928
23055, 88554, 24577, 24587, 88564, 88555, 24578, 24588, 88565, 88996, 24657, 89006, 88929, 88997, 24659, 89007, 
88932, 88900, 24637, 24658, 88931
23056, 88555, 24578, 24588, 88565, 88556, 24579, 24589, 88566, 88997, 24659, 89007, 88932, 88998, 24661, 89008, 
88935, 88903, 24639, 24660, 88934
23057, 88556, 24579, 24589, 88566, 24423, 2404, 2405, 24424, 88998, 24661, 89008, 88935, 24454, 2409, 24455, 
24448, 88906, 24641, 24662, 88937
23058, 24381, 2389, 2390, 24382, 88557, 24580, 24590, 88567, 24412, 2394, 24413, 24408, 88999, 24664, 89009, 
88939, 88907, 24642, 24663, 88938
23059, 88557, 24580, 24590, 88567, 88558, 24581, 24591, 88568, 88999, 24664, 89009, 88939, 89000, 24666, 89010, 
88942, 88910, 24644, 24665, 88941
23060, 88558, 24581, 24591, 88568, 88559, 24582, 24592, 88569, 89000, 24666, 89010, 88942, 89001, 24668, 89011, 
88945, 88913, 24646, 24667, 88944
23061, 88559, 24582, 24592, 88569, 88560, 24583, 24593, 88570, 89001, 24668, 89011, 88945, 89002, 24670, 89012, 
88948, 88916, 24648, 24669, 88947
23062, 88560, 24583, 24593, 88570, 88561, 24584, 24594, 88571, 89002, 24670, 89012, 88948, 89003, 24672, 89013, 
88951, 88919, 24650, 24671, 88950
23063, 88561, 24584, 24594, 88571, 88562, 24585, 24595, 88572, 89003, 24672, 89013, 88951, 89004, 24674, 89014, 
88954, 88922, 24652, 24673, 88953
23064, 88562, 24585, 24595, 88572, 88563, 24586, 24596, 88573, 89004, 24674, 89014, 88954, 89005, 24676, 89015, 
88957, 88925, 24654, 24675, 88956
23065, 88563, 24586, 24596, 88573, 88564, 24587, 24597, 88574, 89005, 24676, 89015, 88957, 89006, 24678, 89016, 
88960, 88928, 24656, 24677, 88959
23066, 88564, 24587, 24597, 88574, 88565, 24588, 24598, 88575, 89006, 24678, 89016, 88960, 89007, 24680, 89017, 
88963, 88931, 24658, 24679, 88962
23067, 88565, 24588, 24598, 88575, 88566, 24589, 24599, 88576, 89007, 24680, 89017, 88963, 89008, 24682, 89018, 
88966, 88934, 24660, 24681, 88965
23068, 88566, 24589, 24599, 88576, 24424, 2405, 2406, 24425, 89008, 24682, 89018, 88966, 24455, 2410, 24456, 
24450, 88937, 24662, 24683, 88968
23069, 24382, 2390, 59, 2382, 88567, 24590, 2421, 24477, 24413, 2395, 2386, 24409, 89009, 24684, 24550, 
88969, 88938, 24663, 2432, 24530
23070, 88567, 24590, 2421, 24477, 88568, 24591, 2420, 24478, 89009, 24684, 24550, 88969, 89010, 24685, 24551, 
88970, 88941, 24665, 2431, 24532
23071, 88568, 24591, 2420, 24478, 88569, 24592, 2419, 24479, 89010, 24685, 24551, 88970, 89011, 24686, 24552, 
88971, 88944, 24667, 2430, 24534
23072, 88569, 24592, 2419, 24479, 88570, 24593, 2418, 24480, 89011, 24686, 24552, 88971, 89012, 24687, 24553, 
88972, 88947, 24669, 2429, 24536
23073, 88570, 24593, 2418, 24480, 88571, 24594, 2417, 24481, 89012, 24687, 24553, 88972, 89013, 24688, 24554, 
88973, 88950, 24671, 2428, 24538
23074, 88571, 24594, 2417, 24481, 88572, 24595, 2416, 24482, 89013, 24688, 24554, 88973, 89014, 24689, 24555, 
88974, 88953, 24673, 2427, 24540
23075, 88572, 24595, 2416, 24482, 88573, 24596, 2415, 24483, 89014, 24689, 24555, 88974, 89015, 24690, 24556, 
88975, 88956, 24675, 2426, 24542
23076, 88573, 24596, 2415, 24483, 88574, 24597, 2414, 24484, 89015, 24690, 24556, 88975, 89016, 24691, 24557, 
88976, 88959, 24677, 2425, 24544
23077, 88574, 24597, 2414, 24484, 88575, 24598, 2413, 24485, 89016, 24691, 24557, 88976, 89017, 24692, 24558, 
88977, 88962, 24679, 2424, 24546
23078, 88575, 24598, 2413, 24485, 88576, 24599, 2412, 24486, 89017, 24692, 24558, 88977, 89018, 24693, 24559, 
88978, 88965, 24681, 2423, 24548
23079, 88576, 24599, 2412, 24486, 24425, 2406, 60, 2398, 89018, 24693, 24559, 88978, 24456, 2411, 2402, 
24452, 88968, 24683, 2422, 24549
*ELEMENT, type=C3D20, ELSET=Volume22
23080, 26, 2380, 24694, 1258, 1201, 24457, 89019, 14723, 2383, 24761, 24760, 1280, 24487, 89680, 89681, 
14944, 1212, 24488, 89679, 14943
23081, 1201, 24457, 89019, 14723, 1200, 24458, 89020, 14724, 24487, 89680, 89681, 14944, 24489, 89683, 89684, 
14946, 1211, 24490, 89682, 14945
23082, 1200, 24458, 89020, 14724, 1199, 24459, 89021, 14725, 24489, 89683, 89684, 14946, 24491, 89686, 89687, 
14948, 1210, 24492, 89685, 14947
23083, 1199, 24459, 89021, 14725, 1198, 24460, 89022, 14726, 24491, 89686, 89687, 14948, 24493, 89689, 89690, 
14950, 1209, 24494, 89688, 14949
23084, 1198, 24460, 89022, 14726, 1197, 24461, 89023, 14727, 24493, 89689, 89690, 14950, 24495, 89692, 89693, 
14952, 1208, 24496, 89691, 14951
23085, 1197, 24461, 89023, 14727, 1196, 24462, 89024, 14728, 24495, 89692, 89693, 14952, 24497, 89695, 89696, 
14954, 1207, 24498, 89694, 14953
23086, 1196, 24462, 89024, 14728, 1195, 24463, 89025, 14729, 24497, 89695, 89696, 14954, 24499, 89698, 89699, 
14956, 1206, 24500, 89697, 14955
23087, 1195, 24463, 89025, 14729, 1194, 24464, 89026, 14730, 24499, 89698, 89699, 14956, 24501, 89701, 89702, 
14958, 1205, 24502, 89700, 14957
23088, 1194, 24464, 89026, 14730, 1193, 24465, 89027, 14731, 24501, 89701, 89702, 14958, 24503, 89704, 89705, 
14960, 1204, 24504, 89703, 14959
23089, 1193, 24465, 89027, 14731, 1192, 24466, 89028, 14732, 24503, 89704, 89705, 14960, 24505, 89707, 89708, 
14962, 1203, 24506, 89706, 14961
23090, 1192, 24466, 89028, 14732, 28, 2396, 24917, 1353, 24505, 89707, 89708, 14962, 2399, 24983, 24984, 
1375, 1202, 24507, 89709, 14963
23091, 1258, 24694, 24695, 1259, 14723, 89019, 89029, 14733, 24760, 24763, 24762, 1281, 89681, 89711, 89712, 
14965, 14943, 89679, 89710, 14964
23092, 14723, 89019, 89029, 14733, 14724, 89020, 89030, 14734, 89681, 89711, 89712, 14965, 89684, 89714, 89715, 
14967, 14945, 89682, 89713, 14966
23093, 14724, 89020, 89030, 14734, 14725, 89021, 89031, 14735, 89684, 89714, 89715, 14967, 89687, 89717, 89718, 
14969, 14947, 89685, 89716, 14968
23094, 14725, 89021, 89031, 14735, 14726, 89022, 89032, 14736, 89687, 89717, 89718, 14969, 89690, 89720, 89721, 
14971, 14949, 89688, 89719, 14970
23095, 14726, 89022, 89032, 14736, 14727, 89023, 89033, 14737, 89690, 89720, 89721, 14971, 89693, 89723, 89724, 
14973, 14951, 89691, 89722, 14972
23096, 14727, 89023, 89033, 14737, 14728, 89024, 89034, 14738, 89693, 89723, 89724, 14973, 89696, 89726, 89727, 
14975, 14953, 89694, 89725, 14974
23097, 14728, 89024, 89034, 14738, 14729, 89025, 89035, 14739, 89696, 89726, 89727, 14975, 89699, 89729, 89730, 
14977, 14955, 89697, 89728, 14976
23098, 14729, 89025, 89035, 14739, 14730, 89026, 89036, 14740, 89699, 89729, 89730, 14977, 89702, 89732, 89733, 
14979, 14957, 89700, 89731, 14978
23099, 14730, 89026, 89036, 14740, 14731, 89027, 89037, 14741, 89702, 89732, 89733, 14979, 89705, 89735, 89736, 
14981, 14959, 89703, 89734, 14980
23100, 14731, 89027, 89037, 14741, 14732, 89028, 89038, 14742, 89705, 89735, 89736, 14981, 89708, 89738, 89739, 
14983, 14961, 89706, 89737, 14982
23101, 14732, 89028, 89038, 14742, 1353, 24917, 24918, 1354, 89708, 89738, 89739, 14983, 24984, 24985, 24986, 
1376, 14963, 89709, 89740, 14984
23102, 1259, 24695, 24696, 1260, 14733, 89029, 89039, 14743, 24762, 24765, 24764, 1282, 89712, 89742, 89743, 
14986, 14964, 89710, 89741, 14985
23103, 14733, 89029, 89039, 14743, 14734, 89030, 89040, 14744, 89712, 89742, 89743, 14986, 89715, 89745, 89746, 
14988, 14966, 89713, 89744, 14987
23104, 14734, 89030, 89040, 14744, 14735, 89031, 89041, 14745, 89715, 89745, 89746, 14988, 89718, 89748, 89749, 
14990, 14968, 89716, 89747, 14989
23105, 14735, 89031, 89041, 14745, 14736, 89032, 89042, 14746, 89718, 89748, 89749, 14990, 89721, 89751, 89752, 
14992, 14970, 89719, 89750, 14991
23106, 14736, 89032, 89042, 14746, 14737, 89033, 89043, 14747, 89721, 89751, 89752, 14992, 89724, 89754, 89755, 
14994, 14972, 89722, 89753, 14993
23107, 14737, 89033, 89043, 14747, 14738, 89034, 89044, 14748, 89724, 89754, 89755, 14994, 89727, 89757, 89758, 
14996, 14974, 89725, 89756, 14995
23108, 14738, 89034, 89044, 14748, 14739, 89035, 89045, 14749, 89727, 89757, 89758, 14996, 89730, 89760, 89761, 
14998, 14976, 89728, 89759, 14997
23109, 14739, 89035, 89045, 14749, 14740, 89036, 89046, 14750, 89730, 89760, 89761, 14998, 89733, 89763, 89764, 
15000, 14978, 89731, 89762, 14999
23110, 14740, 89036, 89046, 14750, 14741, 89037, 89047, 14751, 89733, 89763, 89764, 15000, 89736, 89766, 89767, 
15002, 14980, 89734, 89765, 15001
23111, 14741, 89037, 89047, 14751, 14742, 89038, 89048, 14752, 89736, 89766, 89767, 15002, 89739, 89769, 89770, 
15004, 14982, 89737, 89768, 15003
23112, 14742, 89038, 89048, 14752, 1354, 24918, 24919, 1355, 89739, 89769, 89770, 15004, 24986, 24987, 24988, 
1377, 14984, 89740, 89771, 15005
23113, 1260, 24696, 24697, 1261, 14743, 89039, 89049, 14753, 24764, 24767, 24766, 1283, 89743, 89773, 89774, 
15007, 14985, 89741, 89772, 15006
23114, 14743, 89039, 89049, 14753, 14744, 89040, 89050, 14754, 89743, 89773, 89774, 15007, 89746, 89776, 89777, 
15009, 14987, 89744, 89775, 15008
23115, 14744, 89040, 89050, 14754, 14745, 89041, 89051, 14755, 89746, 89776, 89777, 15009, 89749, 89779, 89780, 
15011, 14989, 89747, 89778, 15010
23116, 14745, 89041, 89051, 14755, 14746, 89042, 89052, 14756, 89749, 89779, 89780, 15011, 89752, 89782, 89783, 
15013, 14991, 89750, 89781, 15012
23117, 14746, 89042, 89052, 14756, 14747, 89043, 89053, 14757, 89752, 89782, 89783, 15013, 89755, 89785, 89786, 
15015, 14993, 89753, 89784, 15014
23118, 14747, 89043, 89053, 14757, 14748, 89044, 89054, 14758, 89755, 89785, 89786, 15015, 89758, 89788, 89789, 
15017, 14995, 89756, 89787, 15016
23119, 14748, 89044, 89054, 14758, 14749, 89045, 89055, 14759, 89758, 89788, 89789, 15017, 89761, 89791, 89792, 
15019, 14997, 89759, 89790, 15018
23120, 14749, 89045, 89055, 14759, 14750, 89046, 89056, 14760, 89761, 89791, 89792, 15019, 89764, 89794, 89795, 
15021, 14999, 89762, 89793, 15020
23121, 14750, 89046, 89056, 14760, 14751, 89047, 89057, 14761, 89764, 89794, 89795, 15021, 89767, 89797, 89798, 
15023, 15001, 89765, 89796, 15022
23122, 14751, 89047, 89057, 14761, 14752, 89048, 89058, 14762, 89767, 89797, 89798, 15023, 89770, 89800, 89801, 
15025, 15003, 89768, 89799, 15024
23123, 14752, 89048, 89058, 14762, 1355, 24919, 24920, 1356, 89770, 89800, 89801, 15025, 24988, 24989, 24990, 
1378, 15005, 89771, 89802, 15026
23124, 1261, 24697, 24698, 1262, 14753, 89049, 89059, 14763, 24766, 24769, 24768, 1284, 89774, 89804, 89805, 
15028, 15006, 89772, 89803, 15027
23125, 14753, 89049, 89059, 14763, 14754, 89050, 89060, 14764, 89774, 89804, 89805, 15028, 89777, 89807, 89808, 
15030, 15008, 89775, 89806, 15029
23126, 14754, 89050, 89060, 14764, 14755, 89051, 89061, 14765, 89777, 89807, 89808, 15030, 89780, 89810, 89811, 
15032, 15010, 89778, 89809, 15031
23127, 14755, 89051, 89061, 14765, 14756, 89052, 89062, 14766, 89780, 89810, 89811, 15032, 89783, 89813, 89814, 
15034, 15012, 89781, 89812, 15033
23128, 14756, 89052, 89062, 14766, 14757, 89053, 89063, 14767, 89783, 89813, 89814, 15034, 89786, 89816, 89817, 
15036, 15014, 89784, 89815, 15035
23129, 14757, 89053, 89063, 14767, 14758, 89054, 89064, 14768, 89786, 89816, 89817, 15036, 89789, 89819, 89820, 
15038, 15016, 89787, 89818, 15037
23130, 14758, 89054, 89064, 14768, 14759, 89055, 89065, 14769, 89789, 89819, 89820, 15038, 89792, 89822, 89823, 
15040, 15018, 89790, 89821, 15039
23131, 14759, 89055, 89065, 14769, 14760, 89056, 89066, 14770, 89792, 89822, 89823, 15040, 89795, 89825, 89826, 
15042, 15020, 89793, 89824, 15041
23132, 14760, 89056, 89066, 14770, 14761, 89057, 89067, 14771, 89795, 89825, 89826, 15042, 89798, 89828, 89829, 
15044, 15022, 89796, 89827, 15043
23133, 14761, 89057, 89067, 14771, 14762, 89058, 89068, 14772, 89798, 89828, 89829, 15044, 89801, 89831, 89832, 
15046, 15024, 89799, 89830, 15045
23134, 14762, 89058, 89068, 14772, 1356, 24920, 24921, 1357, 89801, 89831, 89832, 15046, 24990, 24991, 24992, 
1379, 15026, 89802, 89833, 15047
23135, 1262, 24698, 24699, 1263, 14763, 89059, 89069, 14773, 24768, 24771, 24770, 1285, 89805, 89835, 89836, 
15049, 15027, 89803, 89834, 15048
23136, 14763, 89059, 89069, 14773, 14764, 89060, 89070, 14774, 89805, 89835, 89836, 15049, 89808, 89838, 89839, 
15051, 15029, 89806, 89837, 15050
23137, 14764, 89060, 89070, 14774, 14765, 89061, 89071, 14775, 89808, 89838, 89839, 15051, 89811, 89841, 89842, 
15053, 15031, 89809, 89840, 15052
23138, 14765, 89061, 89071, 14775, 14766, 89062, 89072, 14776, 89811, 89841, 89842, 15053, 89814, 89844, 89845, 
15055, 15033, 89812, 89843, 15054
23139, 14766, 89062, 89072, 14776, 14767, 89063, 89073, 14777, 89814, 89844, 89845, 15055, 89817, 89847, 89848, 
15057, 15035, 89815, 89846, 15056
23140, 14767, 89063, 89073, 14777, 14768, 89064, 89074, 14778, 89817, 89847, 89848, 15057, 89820, 89850, 89851, 
15059, 15037, 89818, 89849, 15058
23141, 14768, 89064, 89074, 14778, 14769, 89065, 89075, 14779, 89820, 89850, 89851, 15059, 89823, 89853, 89854, 
15061, 15039, 89821, 89852, 15060
23142, 14769, 89065, 89075, 14779, 14770, 89066, 89076, 14780, 89823, 89853, 89854, 15061, 89826, 89856, 89857, 
15063, 15041, 89824, 89855, 15062
23143, 14770, 89066, 89076, 14780, 14771, 89067, 89077, 14781, 89826, 89856, 89857, 15063, 89829, 89859, 89860, 
15065, 15043, 89827, 89858, 15064
23144, 14771, 89067, 89077, 14781, 14772, 89068, 89078, 14782, 89829, 89859, 89860, 15065, 89832, 89862, 89863, 
15067, 15045, 89830, 89861, 15066
23145, 14772, 89068, 89078, 14782, 1357, 24921, 24922, 1358, 89832, 89862, 89863, 15067, 24992, 24993, 24994, 
1380, 15047, 89833, 89864, 15068
23146, 1263, 24699, 24700, 1264, 14773, 89069, 89079, 14783, 24770, 24773, 24772, 1286, 89836, 89866, 89867, 
15070, 15048, 89834, 89865, 15069
23147, 14773, 89069, 89079, 14783, 14774, 89070, 89080, 14784, 89836, 89866, 89867, 15070, 89839, 89869, 89870, 
15072, 15050, 89837, 89868, 15071
23148, 14774, 89070, 89080, 14784, 14775, 89071, 89081, 14785, 89839, 89869, 89870, 15072, 89842, 89872, 89873, 
15074, 15052, 89840, 89871, 15073
23149, 14775, 89071, 89081, 14785, 14776, 89072, 89082, 14786, 89842, 89872, 89873, 15074, 89845, 89875, 89876, 
15076, 15054, 89843, 89874, 15075
23150, 14776, 89072, 89082, 14786, 14777, 89073, 89083, 14787, 89845, 89875, 89876, 15076, 89848, 89878, 89879, 
15078, 15056, 89846, 89877, 15077
23151, 14777, 89073, 89083, 14787, 14778, 89074, 89084, 14788, 89848, 89878, 89879, 15078, 89851, 89881, 89882, 
15080, 15058, 89849, 89880, 15079
23152, 14778, 89074, 89084, 14788, 14779, 89075, 89085, 14789, 89851, 89881, 89882, 15080, 89854, 89884, 89885, 
15082, 15060, 89852, 89883, 15081
23153, 14779, 89075, 89085, 14789, 14780, 89076, 89086, 14790, 89854, 89884, 89885, 15082, 89857, 89887, 89888, 
15084, 15062, 89855, 89886, 15083
23154, 14780, 89076, 89086, 14790, 14781, 89077, 89087, 14791, 89857, 89887, 89888, 15084, 89860, 89890, 89891, 
15086, 15064, 89858, 89889, 15085
23155, 14781, 89077, 89087, 14791, 14782, 89078, 89088, 14792, 89860, 89890, 89891, 15086, 89863, 89893, 89894, 
15088, 15066, 89861, 89892, 15087
23156, 14782, 89078, 89088, 14792, 1358, 24922, 24923, 1359, 89863, 89893, 89894, 15088, 24994, 24995, 24996, 
1381, 15068, 89864, 89895, 15089
23157, 1264, 24700, 24701, 1265, 14783, 89079, 89089, 14793, 24772, 24775, 24774, 1287, 89867, 89897, 89898, 
15091, 15069, 89865, 89896, 15090
23158, 14783, 89079, 89089, 14793, 14784, 89080, 89090, 14794, 89867, 89897, 89898, 15091, 89870, 89900, 89901, 
15093, 15071, 89868, 89899, 15092
23159, 14784, 89080, 89090, 14794, 14785, 89081, 89091, 14795, 89870, 89900, 89901, 15093, 89873, 89903, 89904, 
15095, 15073, 89871, 89902, 15094
23160, 14785, 89081, 89091, 14795, 14786, 89082, 89092, 14796, 89873, 89903, 89904, 15095, 89876, 89906, 89907, 
15097, 15075, 89874, 89905, 15096
23161, 14786, 89082, 89092, 14796, 14787, 89083, 89093, 14797, 89876, 89906, 89907, 15097, 89879, 89909, 89910, 
15099, 15077, 89877, 89908, 15098
23162, 14787, 89083, 89093, 14797, 14788, 89084, 89094, 14798, 89879, 89909, 89910, 15099, 89882, 89912, 89913, 
15101, 15079, 89880, 89911, 15100
23163, 14788, 89084, 89094, 14798, 14789, 89085, 89095, 14799, 89882, 89912, 89913, 15101, 89885, 89915, 89916, 
15103, 15081, 89883, 89914, 15102
23164, 14789, 89085, 89095, 14799, 14790, 89086, 89096, 14800, 89885, 89915, 89916, 15103, 89888, 89918, 89919, 
15105, 15083, 89886, 89917, 15104
23165, 14790, 89086, 89096, 14800, 14791, 89087, 89097, 14801, 89888, 89918, 89919, 15105, 89891, 89921, 89922, 
15107, 15085, 89889, 89920, 15106
23166, 14791, 89087, 89097, 14801, 14792, 89088, 89098, 14802, 89891, 89921, 89922, 15107, 89894, 89924, 89925, 
15109, 15087, 89892, 89923, 15108
23167, 14792, 89088, 89098, 14802, 1359, 24923, 24924, 1360, 89894, 89924, 89925, 15109, 24996, 24997, 24998, 
1382, 15089, 89895, 89926, 15110
23168, 1265, 24701, 24702, 1266, 14793, 89089, 89099, 14803, 24774, 24777, 24776, 1288, 89898, 89928, 89929, 
15112, 15090, 89896, 89927, 15111
23169, 14793, 89089, 89099, 14803, 14794, 89090, 89100, 14804, 89898, 89928, 89929, 15112, 89901, 89931, 89932, 
15114, 15092, 89899, 89930, 15113
23170, 14794, 89090, 89100, 14804, 14795, 89091, 89101, 14805, 89901, 89931, 89932, 15114, 89904, 89934, 89935, 
15116, 15094, 89902, 89933, 15115
23171, 14795, 89091, 89101, 14805, 14796, 89092, 89102, 14806, 89904, 89934, 89935, 15116, 89907, 89937, 89938, 
15118, 15096, 89905, 89936, 15117
23172, 14796, 89092, 89102, 14806, 14797, 89093, 89103, 14807, 89907, 89937, 89938, 15118, 89910, 89940, 89941, 
15120, 15098, 89908, 89939, 15119
23173, 14797, 89093, 89103, 14807, 14798, 89094, 89104, 14808, 89910, 89940, 89941, 15120, 89913, 89943, 89944, 
15122, 15100, 89911, 89942, 15121
23174, 14798, 89094, 89104, 14808, 14799, 89095, 89105, 14809, 89913, 89943, 89944, 15122, 89916, 89946, 89947, 
15124, 15102, 89914, 89945, 15123
23175, 14799, 89095, 89105, 14809, 14800, 89096, 89106, 14810, 89916, 89946, 89947, 15124, 89919, 89949, 89950, 
15126, 15104, 89917, 89948, 15125
23176, 14800, 89096, 89106, 14810, 14801, 89097, 89107, 14811, 89919, 89949, 89950, 15126, 89922, 89952, 89953, 
15128, 15106, 89920, 89951, 15127
23177, 14801, 89097, 89107, 14811, 14802, 89098, 89108, 14812, 89922, 89952, 89953, 15128, 89925, 89955, 89956, 
15130, 15108, 89923, 89954, 15129
23178, 14802, 89098, 89108, 14812, 1360, 24924, 24925, 1361, 89925, 89955, 89956, 15130, 24998, 24999, 25000, 
1383, 15110, 89926, 89957, 15131
23179, 1266, 24702, 24703, 1267, 14803, 89099, 89109, 14813, 24776, 24779, 24778, 1289, 89929, 89959, 89960, 
15133, 15111, 89927, 89958, 15132
23180, 14803, 89099, 89109, 14813, 14804, 89100, 89110, 14814, 89929, 89959, 89960, 15133, 89932, 89962, 89963, 
15135, 15113, 89930, 89961, 15134
23181, 14804, 89100, 89110, 14814, 14805, 89101, 89111, 14815, 89932, 89962, 89963, 15135, 89935, 89965, 89966, 
15137, 15115, 89933, 89964, 15136
23182, 14805, 89101, 89111, 14815, 14806, 89102, 89112, 14816, 89935, 89965, 89966, 15137, 89938, 89968, 89969, 
15139, 15117, 89936, 89967, 15138
23183, 14806, 89102, 89112, 14816, 14807, 89103, 89113, 14817, 89938, 89968, 89969, 15139, 89941, 89971, 89972, 
15141, 15119, 89939, 89970, 15140
23184, 14807, 89103, 89113, 14817, 14808, 89104, 89114, 14818, 89941, 89971, 89972, 15141, 89944, 89974, 89975, 
15143, 15121, 89942, 89973, 15142
23185, 14808, 89104, 89114, 14818, 14809, 89105, 89115, 14819, 89944, 89974, 89975, 15143, 89947, 89977, 89978, 
15145, 15123, 89945, 89976, 15144
23186, 14809, 89105, 89115, 14819, 14810, 89106, 89116, 14820, 89947, 89977, 89978, 15145, 89950, 89980, 89981, 
15147, 15125, 89948, 89979, 15146
23187, 14810, 89106, 89116, 14820, 14811, 89107, 89117, 14821, 89950, 89980, 89981, 15147, 89953, 89983, 89984, 
15149, 15127, 89951, 89982, 15148
23188, 14811, 89107, 89117, 14821, 14812, 89108, 89118, 14822, 89953, 89983, 89984, 15149, 89956, 89986, 89987, 
15151, 15129, 89954, 89985, 15150
23189, 14812, 89108, 89118, 14822, 1361, 24925, 24926, 1362, 89956, 89986, 89987, 15151, 25000, 25001, 25002, 
1384, 15131, 89957, 89988, 15152
23190, 1267, 24703, 24704, 1268, 14813, 89109, 89119, 14823, 24778, 24781, 24780, 1290, 89960, 89990, 89991, 
15154, 15132, 89958, 89989, 15153
23191, 14813, 89109, 89119, 14823, 14814, 89110, 89120, 14824, 89960, 89990, 89991, 15154, 89963, 89993, 89994, 
15156, 15134, 89961, 89992, 15155
23192, 14814, 89110, 89120, 14824, 14815, 89111, 89121, 14825, 89963, 89993, 89994, 15156, 89966, 89996, 89997, 
15158, 15136, 89964, 89995, 15157
23193, 14815, 89111, 89121, 14825, 14816, 89112, 89122, 14826, 89966, 89996, 89997, 15158, 89969, 89999, 90000, 
15160, 15138, 89967, 89998, 15159
23194, 14816, 89112, 89122, 14826, 14817, 89113, 89123, 14827, 89969, 89999, 90000, 15160, 89972, 90002, 90003, 
15162, 15140, 89970, 90001, 15161
23195, 14817, 89113, 89123, 14827, 14818, 89114, 89124, 14828, 89972, 90002, 90003, 15162, 89975, 90005, 90006, 
15164, 15142, 89973, 90004, 15163
23196, 14818, 89114, 89124, 14828, 14819, 89115, 89125, 14829, 89975, 90005, 90006, 15164, 89978, 90008, 90009, 
15166, 15144, 89976, 90007, 15165
23197, 14819, 89115, 89125, 14829, 14820, 89116, 89126, 14830, 89978, 90008, 90009, 15166, 89981, 90011, 90012, 
15168, 15146, 89979, 90010, 15167
23198, 14820, 89116, 89126, 14830, 14821, 89117, 89127, 14831, 89981, 90011, 90012, 15168, 89984, 90014, 90015, 
15170, 15148, 89982, 90013, 15169
23199, 14821, 89117, 89127, 14831, 14822, 89118, 89128, 14832, 89984, 90014, 90015, 15170, 89987, 90017, 90018, 
15172, 15150, 89985, 90016, 15171
23200, 14822, 89118, 89128, 14832, 1362, 24926, 24927, 1363, 89987, 90017, 90018, 15172, 25002, 25003, 25004, 
1385, 15152, 89988, 90019, 15173
23201, 1268, 24704, 24705, 1269, 14823, 89119, 89129, 14833, 24780, 24783, 24782, 1291, 89991, 90021, 90022, 
15175, 15153, 89989, 90020, 15174
23202, 14823, 89119, 89129, 14833, 14824, 89120, 89130, 14834, 89991, 90021, 90022, 15175, 89994, 90024, 90025, 
15177, 15155, 89992, 90023, 15176
23203, 14824, 89120, 89130, 14834, 14825, 89121, 89131, 14835, 89994, 90024, 90025, 15177, 89997, 90027, 90028, 
15179, 15157, 89995, 90026, 15178
23204, 14825, 89121, 89131, 14835, 14826, 89122, 89132, 14836, 89997, 90027, 90028, 15179, 90000, 90030, 90031, 
15181, 15159, 89998, 90029, 15180
23205, 14826, 89122, 89132, 14836, 14827, 89123, 89133, 14837, 90000, 90030, 90031, 15181, 90003, 90033, 90034, 
15183, 15161, 90001, 90032, 15182
23206, 14827, 89123, 89133, 14837, 14828, 89124, 89134, 14838, 90003, 90033, 90034, 15183, 90006, 90036, 90037, 
15185, 15163, 90004, 90035, 15184
23207, 14828, 89124, 89134, 14838, 14829, 89125, 89135, 14839, 90006, 90036, 90037, 15185, 90009, 90039, 90040, 
15187, 15165, 90007, 90038, 15186
23208, 14829, 89125, 89135, 14839, 14830, 89126, 89136, 14840, 90009, 90039, 90040, 15187, 90012, 90042, 90043, 
15189, 15167, 90010, 90041, 15188
23209, 14830, 89126, 89136, 14840, 14831, 89127, 89137, 14841, 90012, 90042, 90043, 15189, 90015, 90045, 90046, 
15191, 15169, 90013, 90044, 15190
23210, 14831, 89127, 89137, 14841, 14832, 89128, 89138, 14842, 90015, 90045, 90046, 15191, 90018, 90048, 90049, 
15193, 15171, 90016, 90047, 15192
23211, 14832, 89128, 89138, 14842, 1363, 24927, 24928, 1364, 90018, 90048, 90049, 15193, 25004, 25005, 25006, 
1386, 15173, 90019, 90050, 15194
23212, 1269, 24705, 24706, 1270, 14833, 89129, 89139, 14843, 24782, 24785, 24784, 1292, 90022, 90052, 90053, 
15196, 15174, 90020, 90051, 15195
23213, 14833, 89129, 89139, 14843, 14834, 89130, 89140, 14844, 90022, 90052, 90053, 15196, 90025, 90055, 90056, 
15198, 15176, 90023, 90054, 15197
23214, 14834, 89130, 89140, 14844, 14835, 89131, 89141, 14845, 90025, 90055, 90056, 15198, 90028, 90058, 90059, 
15200, 15178, 90026, 90057, 15199
23215, 14835, 89131, 89141, 14845, 14836, 89132, 89142, 14846, 90028, 90058, 90059, 15200, 90031, 90061, 90062, 
15202, 15180, 90029, 90060, 15201
23216, 14836, 89132, 89142, 14846, 14837, 89133, 89143, 14847, 90031, 90061, 90062, 15202, 90034, 90064, 90065, 
15204, 15182, 90032, 90063, 15203
23217, 14837, 89133, 89143, 14847, 14838, 89134, 89144, 14848, 90034, 90064, 90065, 15204, 90037, 90067, 90068, 
15206, 15184, 90035, 90066, 15205
23218, 14838, 89134, 89144, 14848, 14839, 89135, 89145, 14849, 90037, 90067, 90068, 15206, 90040, 90070, 90071, 
15208, 15186, 90038, 90069, 15207
23219, 14839, 89135, 89145, 14849, 14840, 89136, 89146, 14850, 90040, 90070, 90071, 15208, 90043, 90073, 90074, 
15210, 15188, 90041, 90072, 15209
23220, 14840, 89136, 89146, 14850, 14841, 89137, 89147, 14851, 90043, 90073, 90074, 15210, 90046, 90076, 90077, 
15212, 15190, 90044, 90075, 15211
23221, 14841, 89137, 89147, 14851, 14842, 89138, 89148, 14852, 90046, 90076, 90077, 15212, 90049, 90079, 90080, 
15214, 15192, 90047, 90078, 15213
23222, 14842, 89138, 89148, 14852, 1364, 24928, 24929, 1365, 90049, 90079, 90080, 15214, 25006, 25007, 25008, 
1387, 15194, 90050, 90081, 15215
23223, 1270, 24706, 24707, 1271, 14843, 89139, 89149, 14853, 24784, 24787, 24786, 1293, 90053, 90083, 90084, 
15217, 15195, 90051, 90082, 15216
23224, 14843, 89139, 89149, 14853, 14844, 89140, 89150, 14854, 90053, 90083, 90084, 15217, 90056, 90086, 90087, 
15219, 15197, 90054, 90085, 15218
23225, 14844, 89140, 89150, 14854, 14845, 89141, 89151, 14855, 90056, 90086, 90087, 15219, 90059, 90089, 90090, 
15221, 15199, 90057, 90088, 15220
23226, 14845, 89141, 89151, 14855, 14846, 89142, 89152, 14856, 90059, 90089, 90090, 15221, 90062, 90092, 90093, 
15223, 15201, 90060, 90091, 15222
23227, 14846, 89142, 89152, 14856, 14847, 89143, 89153, 14857, 90062, 90092, 90093, 15223, 90065, 90095, 90096, 
15225, 15203, 90063, 90094, 15224
23228, 14847, 89143, 89153, 14857, 14848, 89144, 89154, 14858, 90065, 90095, 90096, 15225, 90068, 90098, 90099, 
15227, 15205, 90066, 90097, 15226
23229, 14848, 89144, 89154, 14858, 14849, 89145, 89155, 14859, 90068, 90098, 90099, 15227, 90071, 90101, 90102, 
15229, 15207, 90069, 90100, 15228
23230, 14849, 89145, 89155, 14859, 14850, 89146, 89156, 14860, 90071, 90101, 90102, 15229, 90074, 90104, 90105, 
15231, 15209, 90072, 90103, 15230
23231, 14850, 89146, 89156, 14860, 14851, 89147, 89157, 14861, 90074, 90104, 90105, 15231, 90077, 90107, 90108, 
15233, 15211, 90075, 90106, 15232
23232, 14851, 89147, 89157, 14861, 14852, 89148, 89158, 14862, 90077, 90107, 90108, 15233, 90080, 90110, 90111, 
15235, 15213, 90078, 90109, 15234
23233, 14852, 89148, 89158, 14862, 1365, 24929, 24930, 1366, 90080, 90110, 90111, 15235, 25008, 25009, 25010, 
1388, 15215, 90081, 90112, 15236
23234, 1271, 24707, 24708, 1272, 14853, 89149, 89159, 14863, 24786, 24789, 24788, 1294, 90084, 90114, 90115, 
15238, 15216, 90082, 90113, 15237
23235, 14853, 89149, 89159, 14863, 14854, 89150, 89160, 14864, 90084, 90114, 90115, 15238, 90087, 90117, 90118, 
15240, 15218, 90085, 90116, 15239
23236, 14854, 89150, 89160, 14864, 14855, 89151, 89161, 14865, 90087, 90117, 90118, 15240, 90090, 90120, 90121, 
15242, 15220, 90088, 90119, 15241
23237, 14855, 89151, 89161, 14865, 14856, 89152, 89162, 14866, 90090, 90120, 90121, 15242, 90093, 90123, 90124, 
15244, 15222, 90091, 90122, 15243
23238, 14856, 89152, 89162, 14866, 14857, 89153, 89163, 14867, 90093, 90123, 90124, 15244, 90096, 90126, 90127, 
15246, 15224, 90094, 90125, 15245
23239, 14857, 89153, 89163, 14867, 14858, 89154, 89164, 14868, 90096, 90126, 90127, 15246, 90099, 90129, 90130, 
15248, 15226, 90097, 90128, 15247
23240, 14858, 89154, 89164, 14868, 14859, 89155, 89165, 14869, 90099, 90129, 90130, 15248, 90102, 90132, 90133, 
15250, 15228, 90100, 90131, 15249
23241, 14859, 89155, 89165, 14869, 14860, 89156, 89166, 14870, 90102, 90132, 90133, 15250, 90105, 90135, 90136, 
15252, 15230, 90103, 90134, 15251
23242, 14860, 89156, 89166, 14870, 14861, 89157, 89167, 14871, 90105, 90135, 90136, 15252, 90108, 90138, 90139, 
15254, 15232, 90106, 90137, 15253
23243, 14861, 89157, 89167, 14871, 14862, 89158, 89168, 14872, 90108, 90138, 90139, 15254, 90111, 90141, 90142, 
15256, 15234, 90109, 90140, 15255
23244, 14862, 89158, 89168, 14872, 1366, 24930, 24931, 1367, 90111, 90141, 90142, 15256, 25010, 25011, 25012, 
1389, 15236, 90112, 90143, 15257
23245, 1272, 24708, 24709, 1273, 14863, 89159, 89169, 14873, 24788, 24791, 24790, 1295, 90115, 90145, 90146, 
15259, 15237, 90113, 90144, 15258
23246, 14863, 89159, 89169, 14873, 14864, 89160, 89170, 14874, 90115, 90145, 90146, 15259, 90118, 90148, 90149, 
15261, 15239, 90116, 90147, 15260
23247, 14864, 89160, 89170, 14874, 14865, 89161, 89171, 14875, 90118, 90148, 90149, 15261, 90121, 90151, 90152, 
15263, 15241, 90119, 90150, 15262
23248, 14865, 89161, 89171, 14875, 14866, 89162, 89172, 14876, 90121, 90151, 90152, 15263, 90124, 90154, 90155, 
15265, 15243, 90122, 90153, 15264
23249, 14866, 89162, 89172, 14876, 14867, 89163, 89173, 14877, 90124, 90154, 90155, 15265, 90127, 90157, 90158, 
15267, 15245, 90125, 90156, 15266
23250, 14867, 89163, 89173, 14877, 14868, 89164, 89174, 14878, 90127, 90157, 90158, 15267, 90130, 90160, 90161, 
15269, 15247, 90128, 90159, 15268
23251, 14868, 89164, 89174, 14878, 14869, 89165, 89175, 14879, 90130, 90160, 90161, 15269, 90133, 90163, 90164, 
15271, 15249, 90131, 90162, 15270
23252, 14869, 89165, 89175, 14879, 14870, 89166, 89176, 14880, 90133, 90163, 90164, 15271, 90136, 90166, 90167, 
15273, 15251, 90134, 90165, 15272
23253, 14870, 89166, 89176, 14880, 14871, 89167, 89177, 14881, 90136, 90166, 90167, 15273, 90139, 90169, 90170, 
15275, 15253, 90137, 90168, 15274
23254, 14871, 89167, 89177, 14881, 14872, 89168, 89178, 14882, 90139, 90169, 90170, 15275, 90142, 90172, 90173, 
15277, 15255, 90140, 90171, 15276
23255, 14872, 89168, 89178, 14882, 1367, 24931, 24932, 1368, 90142, 90172, 90173, 15277, 25012, 25013, 25014, 
1390, 15257, 90143, 90174, 15278
23256, 1273, 24709, 24710, 1274, 14873, 89169, 89179, 14883, 24790, 24793, 24792, 1296, 90146, 90176, 90177, 
15280, 15258, 90144, 90175, 15279
23257, 14873, 89169, 89179, 14883, 14874, 89170, 89180, 14884, 90146, 90176, 90177, 15280, 90149, 90179, 90180, 
15282, 15260, 90147, 90178, 15281
23258, 14874, 89170, 89180, 14884, 14875, 89171, 89181, 14885, 90149, 90179, 90180, 15282, 90152, 90182, 90183, 
15284, 15262, 90150, 90181, 15283
23259, 14875, 89171, 89181, 14885, 14876, 89172, 89182, 14886, 90152, 90182, 90183, 15284, 90155, 90185, 90186, 
15286, 15264, 90153, 90184, 15285
23260, 14876, 89172, 89182, 14886, 14877, 89173, 89183, 14887, 90155, 90185, 90186, 15286, 90158, 90188, 90189, 
15288, 15266, 90156, 90187, 15287
23261, 14877, 89173, 89183, 14887, 14878, 89174, 89184, 14888, 90158, 90188, 90189, 15288, 90161, 90191, 90192, 
15290, 15268, 90159, 90190, 15289
23262, 14878, 89174, 89184, 14888, 14879, 89175, 89185, 14889, 90161, 90191, 90192, 15290, 90164, 90194, 90195, 
15292, 15270, 90162, 90193, 15291
23263, 14879, 89175, 89185, 14889, 14880, 89176, 89186, 14890, 90164, 90194, 90195, 15292, 90167, 90197, 90198, 
15294, 15272, 90165, 90196, 15293
23264, 14880, 89176, 89186, 14890, 14881, 89177, 89187, 14891, 90167, 90197, 90198, 15294, 90170, 90200, 90201, 
15296, 15274, 90168, 90199, 15295
23265, 14881, 89177, 89187, 14891, 14882, 89178, 89188, 14892, 90170, 90200, 90201, 15296, 90173, 90203, 90204, 
15298, 15276, 90171, 90202, 15297
23266, 14882, 89178, 89188, 14892, 1368, 24932, 24933, 1369, 90173, 90203, 90204, 15298, 25014, 25015, 25016, 
1391, 15278, 90174, 90205, 15299
23267, 1274, 24710, 24711, 1275, 14883, 89179, 89189, 14893, 24792, 24795, 24794, 1297, 90177, 90207, 90208, 
15301, 15279, 90175, 90206, 15300
23268, 14883, 89179, 89189, 14893, 14884, 89180, 89190, 14894, 90177, 90207, 90208, 15301, 90180, 90210, 90211, 
15303, 15281, 90178, 90209, 15302
23269, 14884, 89180, 89190, 14894, 14885, 89181, 89191, 14895, 90180, 90210, 90211, 15303, 90183, 90213, 90214, 
15305, 15283, 90181, 90212, 15304
23270, 14885, 89181, 89191, 14895, 14886, 89182, 89192, 14896, 90183, 90213, 90214, 15305, 90186, 90216, 90217, 
15307, 15285, 90184, 90215, 15306
23271, 14886, 89182, 89192, 14896, 14887, 89183, 89193, 14897, 90186, 90216, 90217, 15307, 90189, 90219, 90220, 
15309, 15287, 90187, 90218, 15308
23272, 14887, 89183, 89193, 14897, 14888, 89184, 89194, 14898, 90189, 90219, 90220, 15309, 90192, 90222, 90223, 
15311, 15289, 90190, 90221, 15310
23273, 14888, 89184, 89194, 14898, 14889, 89185, 89195, 14899, 90192, 90222, 90223, 15311, 90195, 90225, 90226, 
15313, 15291, 90193, 90224, 15312
23274, 14889, 89185, 89195, 14899, 14890, 89186, 89196, 14900, 90195, 90225, 90226, 15313, 90198, 90228, 90229, 
15315, 15293, 90196, 90227, 15314
23275, 14890, 89186, 89196, 14900, 14891, 89187, 89197, 14901, 90198, 90228, 90229, 15315, 90201, 90231, 90232, 
15317, 15295, 90199, 90230, 15316
23276, 14891, 89187, 89197, 14901, 14892, 89188, 89198, 14902, 90201, 90231, 90232, 15317, 90204, 90234, 90235, 
15319, 15297, 90202, 90233, 15318
23277, 14892, 89188, 89198, 14902, 1369, 24933, 24934, 1370, 90204, 90234, 90235, 15319, 25016, 25017, 25018, 
1392, 15299, 90205, 90236, 15320
23278, 1275, 24711, 24712, 1276, 14893, 89189, 89199, 14903, 24794, 24797, 24796, 1298, 90208, 90238, 90239, 
15322, 15300, 90206, 90237, 15321
23279, 14893, 89189, 89199, 14903, 14894, 89190, 89200, 14904, 90208, 90238, 90239, 15322, 90211, 90241, 90242, 
15324, 15302, 90209, 90240, 15323
23280, 14894, 89190, 89200, 14904, 14895, 89191, 89201, 14905, 90211, 90241, 90242, 15324, 90214, 90244, 90245, 
15326, 15304, 90212, 90243, 15325
23281, 14895, 89191, 89201, 14905, 14896, 89192, 89202, 14906, 90214, 90244, 90245, 15326, 90217, 90247, 90248, 
15328, 15306, 90215, 90246, 15327
23282, 14896, 89192, 89202, 14906, 14897, 89193, 89203, 14907, 90217, 90247, 90248, 15328, 90220, 90250, 90251, 
15330, 15308, 90218, 90249, 15329
23283, 14897, 89193, 89203, 14907, 14898, 89194, 89204, 14908, 90220, 90250, 90251, 15330, 90223, 90253, 90254, 
15332, 15310, 90221, 90252, 15331
23284, 14898, 89194, 89204, 14908, 14899, 89195, 89205, 14909, 90223, 90253, 90254, 15332, 90226, 90256, 90257, 
15334, 15312, 90224, 90255, 15333
23285, 14899, 89195, 89205, 14909, 14900, 89196, 89206, 14910, 90226, 90256, 90257, 15334, 90229, 90259, 90260, 
15336, 15314, 90227, 90258, 15335
23286, 14900, 89196, 89206, 14910, 14901, 89197, 89207, 14911, 90229, 90259, 90260, 15336, 90232, 90262, 90263, 
15338, 15316, 90230, 90261, 15337
23287, 14901, 89197, 89207, 14911, 14902, 89198, 89208, 14912, 90232, 90262, 90263, 15338, 90235, 90265, 90266, 
15340, 15318, 90233, 90264, 15339
23288, 14902, 89198, 89208, 14912, 1370, 24934, 24935, 1371, 90235, 90265, 90266, 15340, 25018, 25019, 25020, 
1393, 15320, 90236, 90267, 15341
23289, 1276, 24712, 24713, 1277, 14903, 89199, 89209, 14913, 24796, 24799, 24798, 1299, 90239, 90269, 90270, 
15343, 15321, 90237, 90268, 15342
23290, 14903, 89199, 89209, 14913, 14904, 89200, 89210, 14914, 90239, 90269, 90270, 15343, 90242, 90272, 90273, 
15345, 15323, 90240, 90271, 15344
23291, 14904, 89200, 89210, 14914, 14905, 89201, 89211, 14915, 90242, 90272, 90273, 15345, 90245, 90275, 90276, 
15347, 15325, 90243, 90274, 15346
23292, 14905, 89201, 89211, 14915, 14906, 89202, 89212, 14916, 90245, 90275, 90276, 15347, 90248, 90278, 90279, 
15349, 15327, 90246, 90277, 15348
23293, 14906, 89202, 89212, 14916, 14907, 89203, 89213, 14917, 90248, 90278, 90279, 15349, 90251, 90281, 90282, 
15351, 15329, 90249, 90280, 15350
23294, 14907, 89203, 89213, 14917, 14908, 89204, 89214, 14918, 90251, 90281, 90282, 15351, 90254, 90284, 90285, 
15353, 15331, 90252, 90283, 15352
23295, 14908, 89204, 89214, 14918, 14909, 89205, 89215, 14919, 90254, 90284, 90285, 15353, 90257, 90287, 90288, 
15355, 15333, 90255, 90286, 15354
23296, 14909, 89205, 89215, 14919, 14910, 89206, 89216, 14920, 90257, 90287, 90288, 15355, 90260, 90290, 90291, 
15357, 15335, 90258, 90289, 15356
23297, 14910, 89206, 89216, 14920, 14911, 89207, 89217, 14921, 90260, 90290, 90291, 15357, 90263, 90293, 90294, 
15359, 15337, 90261, 90292, 15358
23298, 14911, 89207, 89217, 14921, 14912, 89208, 89218, 14922, 90263, 90293, 90294, 15359, 90266, 90296, 90297, 
15361, 15339, 90264, 90295, 15360
23299, 14912, 89208, 89218, 14922, 1371, 24935, 24936, 1372, 90266, 90296, 90297, 15361, 25020, 25021, 25022, 
1394, 15341, 90267, 90298, 15362
23300, 1277, 24713, 24714, 1278, 14913, 89209, 89219, 14923, 24798, 24801, 24800, 1300, 90270, 90300, 90301, 
15364, 15342, 90268, 90299, 15363
23301, 14913, 89209, 89219, 14923, 14914, 89210, 89220, 14924, 90270, 90300, 90301, 15364, 90273, 90303, 90304, 
15366, 15344, 90271, 90302, 15365
23302, 14914, 89210, 89220, 14924, 14915, 89211, 89221, 14925, 90273, 90303, 90304, 15366, 90276, 90306, 90307, 
15368, 15346, 90274, 90305, 15367
23303, 14915, 89211, 89221, 14925, 14916, 89212, 89222, 14926, 90276, 90306, 90307, 15368, 90279, 90309, 90310, 
15370, 15348, 90277, 90308, 15369
23304, 14916, 89212, 89222, 14926, 14917, 89213, 89223, 14927, 90279, 90309, 90310, 15370, 90282, 90312, 90313, 
15372, 15350, 90280, 90311, 15371
23305, 14917, 89213, 89223, 14927, 14918, 89214, 89224, 14928, 90282, 90312, 90313, 15372, 90285, 90315, 90316, 
15374, 15352, 90283, 90314, 15373
23306, 14918, 89214, 89224, 14928, 14919, 89215, 89225, 14929, 90285, 90315, 90316, 15374, 90288, 90318, 90319, 
15376, 15354, 90286, 90317, 15375
23307, 14919, 89215, 89225, 14929, 14920, 89216, 89226, 14930, 90288, 90318, 90319, 15376, 90291, 90321, 90322, 
15378, 15356, 90289, 90320, 15377
23308, 14920, 89216, 89226, 14930, 14921, 89217, 89227, 14931, 90291, 90321, 90322, 15378, 90294, 90324, 90325, 
15380, 15358, 90292, 90323, 15379
23309, 14921, 89217, 89227, 14931, 14922, 89218, 89228, 14932, 90294, 90324, 90325, 15380, 90297, 90327, 90328, 
15382, 15360, 90295, 90326, 15381
23310, 14922, 89218, 89228, 14932, 1372, 24936, 24937, 1373, 90297, 90327, 90328, 15382, 25022, 25023, 25024, 
1395, 15362, 90298, 90329, 15383
23311, 1278, 24714, 24715, 1279, 14923, 89219, 89229, 14933, 24800, 24803, 24802, 1301, 90301, 90331, 90332, 
15385, 15363, 90299, 90330, 15384
23312, 14923, 89219, 89229, 14933, 14924, 89220, 89230, 14934, 90301, 90331, 90332, 15385, 90304, 90334, 90335, 
15387, 15365, 90302, 90333, 15386
23313, 14924, 89220, 89230, 14934, 14925, 89221, 89231, 14935, 90304, 90334, 90335, 15387, 90307, 90337, 90338, 
15389, 15367, 90305, 90336, 15388
23314, 14925, 89221, 89231, 14935, 14926, 89222, 89232, 14936, 90307, 90337, 90338, 15389, 90310, 90340, 90341, 
15391, 15369, 90308, 90339, 15390
23315, 14926, 89222, 89232, 14936, 14927, 89223, 89233, 14937, 90310, 90340, 90341, 15391, 90313, 90343, 90344, 
15393, 15371, 90311, 90342, 15392
23316, 14927, 89223, 89233, 14937, 14928, 89224, 89234, 14938, 90313, 90343, 90344, 15393, 90316, 90346, 90347, 
15395, 15373, 90314, 90345, 15394
23317, 14928, 89224, 89234, 14938, 14929, 89225, 89235, 14939, 90316, 90346, 90347, 15395, 90319, 90349, 90350, 
15397, 15375, 90317, 90348, 15396
23318, 14929, 89225, 89235, 14939, 14930, 89226, 89236, 14940, 90319, 90349, 90350, 15397, 90322, 90352, 90353, 
15399, 15377, 90320, 90351, 15398
23319, 14930, 89226, 89236, 14940, 14931, 89227, 89237, 14941, 90322, 90352, 90353, 15399, 90325, 90355, 90356, 
15401, 15379, 90323, 90354, 15400
23320, 14931, 89227, 89237, 14941, 14932, 89228, 89238, 14942, 90325, 90355, 90356, 15401, 90328, 90358, 90359, 
15403, 15381, 90326, 90357, 15402
23321, 14932, 89228, 89238, 14942, 1373, 24937, 24938, 1374, 90328, 90358, 90359, 15403, 25024, 25025, 25026, 
1396, 15383, 90329, 90360, 15404
23322, 1279, 24715, 2433, 30, 14933, 89229, 25140, 1433, 24802, 24804, 2436, 1302, 90332, 90361, 25170, 
15405, 15384, 90330, 25171, 1444
23323, 14933, 89229, 25140, 1433, 14934, 89230, 25141, 1432, 90332, 90361, 25170, 15405, 90335, 90362, 25172, 
15406, 15386, 90333, 25173, 1443
23324, 14934, 89230, 25141, 1432, 14935, 89231, 25142, 1431, 90335, 90362, 25172, 15406, 90338, 90363, 25174, 
15407, 15388, 90336, 25175, 1442
23325, 14935, 89231, 25142, 1431, 14936, 89232, 25143, 1430, 90338, 90363, 25174, 15407, 90341, 90364, 25176, 
15408, 15390, 90339, 25177, 1441
23326, 14936, 89232, 25143, 1430, 14937, 89233, 25144, 1429, 90341, 90364, 25176, 15408, 90344, 90365, 25178, 
15409, 15392, 90342, 25179, 1440
23327, 14937, 89233, 25144, 1429, 14938, 89234, 25145, 1428, 90344, 90365, 25178, 15409, 90347, 90366, 25180, 
15410, 15394, 90345, 25181, 1439
23328, 14938, 89234, 25145, 1428, 14939, 89235, 25146, 1427, 90347, 90366, 25180, 15410, 90350, 90367, 25182, 
15411, 15396, 90348, 25183, 1438
23329, 14939, 89235, 25146, 1427, 14940, 89236, 25147, 1426, 90350, 90367, 25182, 15411, 90353, 90368, 25184, 
15412, 15398, 90351, 25185, 1437
23330, 14940, 89236, 25147, 1426, 14941, 89237, 25148, 1425, 90353, 90368, 25184, 15412, 90356, 90369, 25186, 
15413, 15400, 90354, 25187, 1436
23331, 14941, 89237, 25148, 1425, 14942, 89238, 25149, 1424, 90356, 90369, 25186, 15413, 90359, 90370, 25188, 
15414, 15402, 90357, 25189, 1435
23332, 14942, 89238, 25149, 1424, 1374, 24938, 2485, 32, 90359, 90370, 25188, 15414, 25026, 25027, 2488, 
1397, 15404, 90360, 25190, 1434
23333, 2380, 2381, 24716, 24694, 24457, 24467, 89239, 89019, 2384, 24806, 24805, 24761, 24508, 90372, 90373, 
89680, 24488, 24509, 90371, 89679
23334, 24457, 24467, 89239, 89019, 24458, 24468, 89240, 89020, 24508, 90372, 90373, 89680, 24510, 90375, 90376, 
89683, 24490, 24511, 90374, 89682
23335, 24458, 24468, 89240, 89020, 24459, 24469, 89241, 89021, 24510, 90375, 90376, 89683, 24512, 90378, 90379, 
89686, 24492, 24513, 90377, 89685
23336, 24459, 24469, 89241, 89021, 24460, 24470, 89242, 89022, 24512, 90378, 90379, 89686, 24514, 90381, 90382, 
89689, 24494, 24515, 90380, 89688
23337, 24460, 24470, 89242, 89022, 24461, 24471, 89243, 89023, 24514, 90381, 90382, 89689, 24516, 90384, 90385, 
89692, 24496, 24517, 90383, 89691
23338, 24461, 24471, 89243, 89023, 24462, 24472, 89244, 89024, 24516, 90384, 90385, 89692, 24518, 90387, 90388, 
89695, 24498, 24519, 90386, 89694
23339, 24462, 24472, 89244, 89024, 24463, 24473, 89245, 89025, 24518, 90387, 90388, 89695, 24520, 90390, 90391, 
89698, 24500, 24521, 90389, 89697
23340, 24463, 24473, 89245, 89025, 24464, 24474, 89246, 89026, 24520, 90390, 90391, 89698, 24522, 90393, 90394, 
89701, 24502, 24523, 90392, 89700
23341, 24464, 24474, 89246, 89026, 24465, 24475, 89247, 89027, 24522, 90393, 90394, 89701, 24524, 90396, 90397, 
89704, 24504, 24525, 90395, 89703
23342, 24465, 24475, 89247, 89027, 24466, 24476, 89248, 89028, 24524, 90396, 90397, 89704, 24526, 90399, 90400, 
89707, 24506, 24527, 90398, 89706
23343, 24466, 24476, 89248, 89028, 2396, 2397, 24939, 24917, 24526, 90399, 90400, 89707, 2400, 25028, 25029, 
24983, 24507, 24528, 90401, 89709
23344, 24694, 24716, 24717, 24695, 89019, 89239, 89249, 89029, 24805, 24808, 24807, 24763, 90373, 90403, 90404, 
89711, 89679, 90371, 90402, 89710
23345, 89019, 89239, 89249, 89029, 89020, 89240, 89250, 89030, 90373, 90403, 90404, 89711, 90376, 90406, 90407, 
89714, 89682, 90374, 90405, 89713
23346, 89020, 89240, 89250, 89030, 89021, 89241, 89251, 89031, 90376, 90406, 90407, 89714, 90379, 90409, 90410, 
89717, 89685, 90377, 90408, 89716
23347, 89021, 89241, 89251, 89031, 89022, 89242, 89252, 89032, 90379, 90409, 90410, 89717, 90382, 90412, 90413, 
89720, 89688, 90380, 90411, 89719
23348, 89022, 89242, 89252, 89032, 89023, 89243, 89253, 89033, 90382, 90412, 90413, 89720, 90385, 90415, 90416, 
89723, 89691, 90383, 90414, 89722
23349, 89023, 89243, 89253, 89033, 89024, 89244, 89254, 89034, 90385, 90415, 90416, 89723, 90388, 90418, 90419, 
89726, 89694, 90386, 90417, 89725
23350, 89024, 89244, 89254, 89034, 89025, 89245, 89255, 89035, 90388, 90418, 90419, 89726, 90391, 90421, 90422, 
89729, 89697, 90389, 90420, 89728
23351, 89025, 89245, 89255, 89035, 89026, 89246, 89256, 89036, 90391, 90421, 90422, 89729, 90394, 90424, 90425, 
89732, 89700, 90392, 90423, 89731
23352, 89026, 89246, 89256, 89036, 89027, 89247, 89257, 89037, 90394, 90424, 90425, 89732, 90397, 90427, 90428, 
89735, 89703, 90395, 90426, 89734
23353, 89027, 89247, 89257, 89037, 89028, 89248, 89258, 89038, 90397, 90427, 90428, 89735, 90400, 90430, 90431, 
89738, 89706, 90398, 90429, 89737
23354, 89028, 89248, 89258, 89038, 24917, 24939, 24940, 24918, 90400, 90430, 90431, 89738, 25029, 25030, 25031, 
24985, 89709, 90401, 90432, 89740
23355, 24695, 24717, 24718, 24696, 89029, 89249, 89259, 89039, 24807, 24810, 24809, 24765, 90404, 90434, 90435, 
89742, 89710, 90402, 90433, 89741
23356, 89029, 89249, 89259, 89039, 89030, 89250, 89260, 89040, 90404, 90434, 90435, 89742, 90407, 90437, 90438, 
89745, 89713, 90405, 90436, 89744
23357, 89030, 89250, 89260, 89040, 89031, 89251, 89261, 89041, 90407, 90437, 90438, 89745, 90410, 90440, 90441, 
89748, 89716, 90408, 90439, 89747
23358, 89031, 89251, 89261, 89041, 89032, 89252, 89262, 89042, 90410, 90440, 90441, 89748, 90413, 90443, 90444, 
89751, 89719, 90411, 90442, 89750
23359, 89032, 89252, 89262, 89042, 89033, 89253, 89263, 89043, 90413, 90443, 90444, 89751, 90416, 90446, 90447, 
89754, 89722, 90414, 90445, 89753
23360, 89033, 89253, 89263, 89043, 89034, 89254, 89264, 89044, 90416, 90446, 90447, 89754, 90419, 90449, 90450, 
89757, 89725, 90417, 90448, 89756
23361, 89034, 89254, 89264, 89044, 89035, 89255, 89265, 89045, 90419, 90449, 90450, 89757, 90422, 90452, 90453, 
89760, 89728, 90420, 90451, 89759
23362, 89035, 89255, 89265, 89045, 89036, 89256, 89266, 89046, 90422, 90452, 90453, 89760, 90425, 90455, 90456, 
89763, 89731, 90423, 90454, 89762
23363, 89036, 89256, 89266, 89046, 89037, 89257, 89267, 89047, 90425, 90455, 90456, 89763, 90428, 90458, 90459, 
89766, 89734, 90426, 90457, 89765
23364, 89037, 89257, 89267, 89047, 89038, 89258, 89268, 89048, 90428, 90458, 90459, 89766, 90431, 90461, 90462, 
89769, 89737, 90429, 90460, 89768
23365, 89038, 89258, 89268, 89048, 24918, 24940, 24941, 24919, 90431, 90461, 90462, 89769, 25031, 25032, 25033, 
24987, 89740, 90432, 90463, 89771
23366, 24696, 24718, 24719, 24697, 89039, 89259, 89269, 89049, 24809, 24812, 24811, 24767, 90435, 90465, 90466, 
89773, 89741, 90433, 90464, 89772
23367, 89039, 89259, 89269, 89049, 89040, 89260, 89270, 89050, 90435, 90465, 90466, 89773, 90438, 90468, 90469, 
89776, 89744, 90436, 90467, 89775
23368, 89040, 89260, 89270, 89050, 89041, 89261, 89271, 89051, 90438, 90468, 90469, 89776, 90441, 90471, 90472, 
89779, 89747, 90439, 90470, 89778
23369, 89041, 89261, 89271, 89051, 89042, 89262, 89272, 89052, 90441, 90471, 90472, 89779, 90444, 90474, 90475, 
89782, 89750, 90442, 90473, 89781
23370, 89042, 89262, 89272, 89052, 89043, 89263, 89273, 89053, 90444, 90474, 90475, 89782, 90447, 90477, 90478, 
89785, 89753, 90445, 90476, 89784
23371, 89043, 89263, 89273, 89053, 89044, 89264, 89274, 89054, 90447, 90477, 90478, 89785, 90450, 90480, 90481, 
89788, 89756, 90448, 90479, 89787
23372, 89044, 89264, 89274, 89054, 89045, 89265, 89275, 89055, 90450, 90480, 90481, 89788, 90453, 90483, 90484, 
89791, 89759, 90451, 90482, 89790
23373, 89045, 89265, 89275, 89055, 89046, 89266, 89276, 89056, 90453, 90483, 90484, 89791, 90456, 90486, 90487, 
