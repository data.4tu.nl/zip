84685, 84683, 84652, 83960, 83991
21323, 83431, 83421, 83201, 83211, 83432, 83422, 83202, 83212, 84684, 84654, 83992, 84685, 84687, 84657, 83995, 
84688, 84686, 84655, 83963, 83994
21324, 83432, 83422, 83202, 83212, 83433, 83423, 83203, 83213, 84687, 84657, 83995, 84688, 84690, 84660, 83998, 
84691, 84689, 84658, 83966, 83997
21325, 83433, 83423, 83203, 83213, 83434, 83424, 83204, 83214, 84690, 84660, 83998, 84691, 84693, 84663, 84001, 
84694, 84692, 84661, 83969, 84000
21326, 83434, 83424, 83204, 83214, 83435, 83425, 83205, 83215, 84693, 84663, 84001, 84694, 84696, 84666, 84004, 
84697, 84695, 84664, 83972, 84003
21327, 83435, 83425, 83205, 83215, 83436, 83426, 83206, 83216, 84696, 84666, 84004, 84697, 84699, 84669, 84007, 
84700, 84698, 84667, 83975, 84006
21328, 83436, 83426, 83206, 83216, 83437, 83427, 83207, 83217, 84699, 84669, 84007, 84700, 84702, 84672, 84010, 
84703, 84701, 84670, 83978, 84009
21329, 83437, 83427, 83207, 83217, 83438, 83428, 83208, 83218, 84702, 84672, 84010, 84703, 84705, 84675, 84013, 
84706, 84704, 84673, 83981, 84012
21330, 83438, 83428, 83208, 83218, 28956, 28955, 28933, 28934, 84705, 84675, 84013, 84706, 29040, 29037, 28995, 
29039, 84707, 84676, 83984, 84015
21331, 28801, 28800, 28778, 28779, 83439, 83429, 83209, 83219, 28885, 28884, 28840, 28886, 84709, 84679, 84017, 
84710, 84708, 84677, 83985, 84016
21332, 83439, 83429, 83209, 83219, 83440, 83430, 83210, 83220, 84709, 84679, 84017, 84710, 84712, 84682, 84020, 
84713, 84711, 84680, 83988, 84019
21333, 83440, 83430, 83210, 83220, 83441, 83431, 83211, 83221, 84712, 84682, 84020, 84713, 84715, 84685, 84023, 
84716, 84714, 84683, 83991, 84022
21334, 83441, 83431, 83211, 83221, 83442, 83432, 83212, 83222, 84715, 84685, 84023, 84716, 84718, 84688, 84026, 
84719, 84717, 84686, 83994, 84025
21335, 83442, 83432, 83212, 83222, 83443, 83433, 83213, 83223, 84718, 84688, 84026, 84719, 84721, 84691, 84029, 
84722, 84720, 84689, 83997, 84028
21336, 83443, 83433, 83213, 83223, 83444, 83434, 83214, 83224, 84721, 84691, 84029, 84722, 84724, 84694, 84032, 
84725, 84723, 84692, 84000, 84031
21337, 83444, 83434, 83214, 83224, 83445, 83435, 83215, 83225, 84724, 84694, 84032, 84725, 84727, 84697, 84035, 
84728, 84726, 84695, 84003, 84034
21338, 83445, 83435, 83215, 83225, 83446, 83436, 83216, 83226, 84727, 84697, 84035, 84728, 84730, 84700, 84038, 
84731, 84729, 84698, 84006, 84037
21339, 83446, 83436, 83216, 83226, 83447, 83437, 83217, 83227, 84730, 84700, 84038, 84731, 84733, 84703, 84041, 
84734, 84732, 84701, 84009, 84040
21340, 83447, 83437, 83217, 83227, 83448, 83438, 83218, 83228, 84733, 84703, 84041, 84734, 84736, 84706, 84044, 
84737, 84735, 84704, 84012, 84043
21341, 83448, 83438, 83218, 83228, 28957, 28956, 28934, 28935, 84736, 84706, 84044, 84737, 29042, 29039, 28997, 
29041, 84738, 84707, 84015, 84046
21342, 28802, 28801, 28779, 28780, 83449, 83439, 83219, 83229, 28887, 28886, 28842, 28888, 84740, 84710, 84048, 
84741, 84739, 84708, 84016, 84047
21343, 83449, 83439, 83219, 83229, 83450, 83440, 83220, 83230, 84740, 84710, 84048, 84741, 84743, 84713, 84051, 
84744, 84742, 84711, 84019, 84050
21344, 83450, 83440, 83220, 83230, 83451, 83441, 83221, 83231, 84743, 84713, 84051, 84744, 84746, 84716, 84054, 
84747, 84745, 84714, 84022, 84053
21345, 83451, 83441, 83221, 83231, 83452, 83442, 83222, 83232, 84746, 84716, 84054, 84747, 84749, 84719, 84057, 
84750, 84748, 84717, 84025, 84056
21346, 83452, 83442, 83222, 83232, 83453, 83443, 83223, 83233, 84749, 84719, 84057, 84750, 84752, 84722, 84060, 
84753, 84751, 84720, 84028, 84059
21347, 83453, 83443, 83223, 83233, 83454, 83444, 83224, 83234, 84752, 84722, 84060, 84753, 84755, 84725, 84063, 
84756, 84754, 84723, 84031, 84062
21348, 83454, 83444, 83224, 83234, 83455, 83445, 83225, 83235, 84755, 84725, 84063, 84756, 84758, 84728, 84066, 
84759, 84757, 84726, 84034, 84065
21349, 83455, 83445, 83225, 83235, 83456, 83446, 83226, 83236, 84758, 84728, 84066, 84759, 84761, 84731, 84069, 
84762, 84760, 84729, 84037, 84068
21350, 83456, 83446, 83226, 83236, 83457, 83447, 83227, 83237, 84761, 84731, 84069, 84762, 84764, 84734, 84072, 
84765, 84763, 84732, 84040, 84071
21351, 83457, 83447, 83227, 83237, 83458, 83448, 83228, 83238, 84764, 84734, 84072, 84765, 84767, 84737, 84075, 
84768, 84766, 84735, 84043, 84074
21352, 83458, 83448, 83228, 83238, 28958, 28957, 28935, 28936, 84767, 84737, 84075, 84768, 29044, 29041, 28999, 
29043, 84769, 84738, 84046, 84077
21353, 28803, 28802, 28780, 28781, 83459, 83449, 83229, 83239, 28889, 28888, 28844, 28890, 84771, 84741, 84079, 
84772, 84770, 84739, 84047, 84078
21354, 83459, 83449, 83229, 83239, 83460, 83450, 83230, 83240, 84771, 84741, 84079, 84772, 84774, 84744, 84082, 
84775, 84773, 84742, 84050, 84081
21355, 83460, 83450, 83230, 83240, 83461, 83451, 83231, 83241, 84774, 84744, 84082, 84775, 84777, 84747, 84085, 
84778, 84776, 84745, 84053, 84084
21356, 83461, 83451, 83231, 83241, 83462, 83452, 83232, 83242, 84777, 84747, 84085, 84778, 84780, 84750, 84088, 
84781, 84779, 84748, 84056, 84087
21357, 83462, 83452, 83232, 83242, 83463, 83453, 83233, 83243, 84780, 84750, 84088, 84781, 84783, 84753, 84091, 
84784, 84782, 84751, 84059, 84090
21358, 83463, 83453, 83233, 83243, 83464, 83454, 83234, 83244, 84783, 84753, 84091, 84784, 84786, 84756, 84094, 
84787, 84785, 84754, 84062, 84093
21359, 83464, 83454, 83234, 83244, 83465, 83455, 83235, 83245, 84786, 84756, 84094, 84787, 84789, 84759, 84097, 
84790, 84788, 84757, 84065, 84096
21360, 83465, 83455, 83235, 83245, 83466, 83456, 83236, 83246, 84789, 84759, 84097, 84790, 84792, 84762, 84100, 
84793, 84791, 84760, 84068, 84099
21361, 83466, 83456, 83236, 83246, 83467, 83457, 83237, 83247, 84792, 84762, 84100, 84793, 84795, 84765, 84103, 
84796, 84794, 84763, 84071, 84102
21362, 83467, 83457, 83237, 83247, 83468, 83458, 83238, 83248, 84795, 84765, 84103, 84796, 84798, 84768, 84106, 
84799, 84797, 84766, 84074, 84105
21363, 83468, 83458, 83238, 83248, 28959, 28958, 28936, 28937, 84798, 84768, 84106, 84799, 29046, 29043, 29001, 
29045, 84800, 84769, 84077, 84108
21364, 28804, 28803, 28781, 28782, 83469, 83459, 83239, 83249, 28891, 28890, 28846, 28892, 84802, 84772, 84110, 
84803, 84801, 84770, 84078, 84109
21365, 83469, 83459, 83239, 83249, 83470, 83460, 83240, 83250, 84802, 84772, 84110, 84803, 84805, 84775, 84113, 
84806, 84804, 84773, 84081, 84112
21366, 83470, 83460, 83240, 83250, 83471, 83461, 83241, 83251, 84805, 84775, 84113, 84806, 84808, 84778, 84116, 
84809, 84807, 84776, 84084, 84115
21367, 83471, 83461, 83241, 83251, 83472, 83462, 83242, 83252, 84808, 84778, 84116, 84809, 84811, 84781, 84119, 
84812, 84810, 84779, 84087, 84118
21368, 83472, 83462, 83242, 83252, 83473, 83463, 83243, 83253, 84811, 84781, 84119, 84812, 84814, 84784, 84122, 
84815, 84813, 84782, 84090, 84121
21369, 83473, 83463, 83243, 83253, 83474, 83464, 83244, 83254, 84814, 84784, 84122, 84815, 84817, 84787, 84125, 
84818, 84816, 84785, 84093, 84124
21370, 83474, 83464, 83244, 83254, 83475, 83465, 83245, 83255, 84817, 84787, 84125, 84818, 84820, 84790, 84128, 
84821, 84819, 84788, 84096, 84127
21371, 83475, 83465, 83245, 83255, 83476, 83466, 83246, 83256, 84820, 84790, 84128, 84821, 84823, 84793, 84131, 
84824, 84822, 84791, 84099, 84130
21372, 83476, 83466, 83246, 83256, 83477, 83467, 83247, 83257, 84823, 84793, 84131, 84824, 84826, 84796, 84134, 
84827, 84825, 84794, 84102, 84133
21373, 83477, 83467, 83247, 83257, 83478, 83468, 83248, 83258, 84826, 84796, 84134, 84827, 84829, 84799, 84137, 
84830, 84828, 84797, 84105, 84136
21374, 83478, 83468, 83248, 83258, 28960, 28959, 28937, 28938, 84829, 84799, 84137, 84830, 29048, 29045, 29003, 
29047, 84831, 84800, 84108, 84139
21375, 28805, 28804, 28782, 28783, 83479, 83469, 83249, 83259, 28893, 28892, 28848, 28894, 84833, 84803, 84141, 
84834, 84832, 84801, 84109, 84140
21376, 83479, 83469, 83249, 83259, 83480, 83470, 83250, 83260, 84833, 84803, 84141, 84834, 84836, 84806, 84144, 
84837, 84835, 84804, 84112, 84143
21377, 83480, 83470, 83250, 83260, 83481, 83471, 83251, 83261, 84836, 84806, 84144, 84837, 84839, 84809, 84147, 
84840, 84838, 84807, 84115, 84146
21378, 83481, 83471, 83251, 83261, 83482, 83472, 83252, 83262, 84839, 84809, 84147, 84840, 84842, 84812, 84150, 
84843, 84841, 84810, 84118, 84149
21379, 83482, 83472, 83252, 83262, 83483, 83473, 83253, 83263, 84842, 84812, 84150, 84843, 84845, 84815, 84153, 
84846, 84844, 84813, 84121, 84152
21380, 83483, 83473, 83253, 83263, 83484, 83474, 83254, 83264, 84845, 84815, 84153, 84846, 84848, 84818, 84156, 
84849, 84847, 84816, 84124, 84155
21381, 83484, 83474, 83254, 83264, 83485, 83475, 83255, 83265, 84848, 84818, 84156, 84849, 84851, 84821, 84159, 
84852, 84850, 84819, 84127, 84158
21382, 83485, 83475, 83255, 83265, 83486, 83476, 83256, 83266, 84851, 84821, 84159, 84852, 84854, 84824, 84162, 
84855, 84853, 84822, 84130, 84161
21383, 83486, 83476, 83256, 83266, 83487, 83477, 83257, 83267, 84854, 84824, 84162, 84855, 84857, 84827, 84165, 
84858, 84856, 84825, 84133, 84164
21384, 83487, 83477, 83257, 83267, 83488, 83478, 83258, 83268, 84857, 84827, 84165, 84858, 84860, 84830, 84168, 
84861, 84859, 84828, 84136, 84167
21385, 83488, 83478, 83258, 83268, 28961, 28960, 28938, 28939, 84860, 84830, 84168, 84861, 29050, 29047, 29005, 
29049, 84862, 84831, 84139, 84170
21386, 2046, 28805, 28783, 2045, 22469, 83479, 83259, 22459, 28895, 28894, 28850, 2048, 84863, 84834, 84171, 
22501, 22500, 84832, 84140, 22479
21387, 22469, 83479, 83259, 22459, 22470, 83480, 83260, 22460, 84863, 84834, 84171, 22501, 84864, 84837, 84172, 
22503, 22502, 84835, 84143, 22481
21388, 22470, 83480, 83260, 22460, 22471, 83481, 83261, 22461, 84864, 84837, 84172, 22503, 84865, 84840, 84173, 
22505, 22504, 84838, 84146, 22483
21389, 22471, 83481, 83261, 22461, 22472, 83482, 83262, 22462, 84865, 84840, 84173, 22505, 84866, 84843, 84174, 
22507, 22506, 84841, 84149, 22485
21390, 22472, 83482, 83262, 22462, 22473, 83483, 83263, 22463, 84866, 84843, 84174, 22507, 84867, 84846, 84175, 
22509, 22508, 84844, 84152, 22487
21391, 22473, 83483, 83263, 22463, 22474, 83484, 83264, 22464, 84867, 84846, 84175, 22509, 84868, 84849, 84176, 
22511, 22510, 84847, 84155, 22489
21392, 22474, 83484, 83264, 22464, 22475, 83485, 83265, 22465, 84868, 84849, 84176, 22511, 84869, 84852, 84177, 
22513, 22512, 84850, 84158, 22491
21393, 22475, 83485, 83265, 22465, 22476, 83486, 83266, 22466, 84869, 84852, 84177, 22513, 84870, 84855, 84178, 
22515, 22514, 84853, 84161, 22493
21394, 22476, 83486, 83266, 22466, 22477, 83487, 83267, 22467, 84870, 84855, 84178, 22515, 84871, 84858, 84179, 
22517, 22516, 84856, 84164, 22495
21395, 22477, 83487, 83267, 22467, 22478, 83488, 83268, 22468, 84871, 84858, 84179, 22517, 84872, 84861, 84180, 
22519, 22518, 84859, 84167, 22497
21396, 22478, 83488, 83268, 22468, 2051, 28961, 28939, 2050, 84872, 84861, 84180, 22519, 29051, 29049, 29006, 
2053, 22520, 84862, 84170, 22499
21397, 3082, 85, 3078, 28784, 29146, 3186, 29084, 83269, 3104, 3081, 28851, 28896, 29366, 29136, 84182, 
84873, 29367, 3197, 29116, 84181
21398, 29146, 3186, 29084, 83269, 29147, 3185, 29085, 83270, 29366, 29136, 84182, 84873, 29368, 29137, 84185, 
84874, 29369, 3196, 29118, 84184
21399, 29147, 3185, 29085, 83270, 29148, 3184, 29086, 83271, 29368, 29137, 84185, 84874, 29370, 29138, 84188, 
84875, 29371, 3195, 29120, 84187
21400, 29148, 3184, 29086, 83271, 29149, 3183, 29087, 83272, 29370, 29138, 84188, 84875, 29372, 29139, 84191, 
84876, 29373, 3194, 29122, 84190
21401, 29149, 3183, 29087, 83272, 29150, 3182, 29088, 83273, 29372, 29139, 84191, 84876, 29374, 29140, 84194, 
84877, 29375, 3193, 29124, 84193
21402, 29150, 3182, 29088, 83273, 29151, 3181, 29089, 83274, 29374, 29140, 84194, 84877, 29376, 29141, 84197, 
84878, 29377, 3192, 29126, 84196
21403, 29151, 3181, 29089, 83274, 29152, 3180, 29090, 83275, 29376, 29141, 84197, 84878, 29378, 29142, 84200, 
84879, 29379, 3191, 29128, 84199
21404, 29152, 3180, 29090, 83275, 29153, 3179, 29091, 83276, 29378, 29142, 84200, 84879, 29380, 29143, 84203, 
84880, 29381, 3190, 29130, 84202
21405, 29153, 3179, 29091, 83276, 29154, 3178, 29092, 83277, 29380, 29143, 84203, 84880, 29382, 29144, 84206, 
84881, 29383, 3189, 29132, 84205
21406, 29154, 3178, 29092, 83277, 29155, 3177, 29093, 83278, 29382, 29144, 84206, 84881, 29384, 29145, 84209, 
84882, 29385, 3188, 29134, 84208
21407, 29155, 3177, 29093, 83278, 3132, 86, 3128, 28940, 29384, 29145, 84209, 84882, 3154, 3131, 29008, 
29052, 29386, 3187, 29135, 84211
21408, 3083, 3082, 28784, 28785, 29156, 29146, 83269, 83279, 3105, 28896, 28853, 28897, 29387, 84873, 84213, 
84883, 29388, 29367, 84181, 84212
21409, 29156, 29146, 83269, 83279, 29157, 29147, 83270, 83280, 29387, 84873, 84213, 84883, 29389, 84874, 84216, 
84884, 29390, 29369, 84184, 84215
21410, 29157, 29147, 83270, 83280, 29158, 29148, 83271, 83281, 29389, 84874, 84216, 84884, 29391, 84875, 84219, 
84885, 29392, 29371, 84187, 84218
21411, 29158, 29148, 83271, 83281, 29159, 29149, 83272, 83282, 29391, 84875, 84219, 84885, 29393, 84876, 84222, 
84886, 29394, 29373, 84190, 84221
21412, 29159, 29149, 83272, 83282, 29160, 29150, 83273, 83283, 29393, 84876, 84222, 84886, 29395, 84877, 84225, 
84887, 29396, 29375, 84193, 84224
21413, 29160, 29150, 83273, 83283, 29161, 29151, 83274, 83284, 29395, 84877, 84225, 84887, 29397, 84878, 84228, 
84888, 29398, 29377, 84196, 84227
21414, 29161, 29151, 83274, 83284, 29162, 29152, 83275, 83285, 29397, 84878, 84228, 84888, 29399, 84879, 84231, 
84889, 29400, 29379, 84199, 84230
21415, 29162, 29152, 83275, 83285, 29163, 29153, 83276, 83286, 29399, 84879, 84231, 84889, 29401, 84880, 84234, 
84890, 29402, 29381, 84202, 84233
21416, 29163, 29153, 83276, 83286, 29164, 29154, 83277, 83287, 29401, 84880, 84234, 84890, 29403, 84881, 84237, 
84891, 29404, 29383, 84205, 84236
21417, 29164, 29154, 83277, 83287, 29165, 29155, 83278, 83288, 29403, 84881, 84237, 84891, 29405, 84882, 84240, 
84892, 29406, 29385, 84208, 84239
21418, 29165, 29155, 83278, 83288, 3133, 3132, 28940, 28941, 29405, 84882, 84240, 84892, 3155, 29052, 29010, 
29053, 29407, 29386, 84211, 84242
21419, 3084, 3083, 28785, 28786, 29166, 29156, 83279, 83289, 3106, 28897, 28855, 28898, 29408, 84883, 84244, 
84893, 29409, 29388, 84212, 84243
21420, 29166, 29156, 83279, 83289, 29167, 29157, 83280, 83290, 29408, 84883, 84244, 84893, 29410, 84884, 84247, 
84894, 29411, 29390, 84215, 84246
21421, 29167, 29157, 83280, 83290, 29168, 29158, 83281, 83291, 29410, 84884, 84247, 84894, 29412, 84885, 84250, 
84895, 29413, 29392, 84218, 84249
21422, 29168, 29158, 83281, 83291, 29169, 29159, 83282, 83292, 29412, 84885, 84250, 84895, 29414, 84886, 84253, 
84896, 29415, 29394, 84221, 84252
21423, 29169, 29159, 83282, 83292, 29170, 29160, 83283, 83293, 29414, 84886, 84253, 84896, 29416, 84887, 84256, 
84897, 29417, 29396, 84224, 84255
21424, 29170, 29160, 83283, 83293, 29171, 29161, 83284, 83294, 29416, 84887, 84256, 84897, 29418, 84888, 84259, 
84898, 29419, 29398, 84227, 84258
21425, 29171, 29161, 83284, 83294, 29172, 29162, 83285, 83295, 29418, 84888, 84259, 84898, 29420, 84889, 84262, 
84899, 29421, 29400, 84230, 84261
21426, 29172, 29162, 83285, 83295, 29173, 29163, 83286, 83296, 29420, 84889, 84262, 84899, 29422, 84890, 84265, 
84900, 29423, 29402, 84233, 84264
21427, 29173, 29163, 83286, 83296, 29174, 29164, 83287, 83297, 29422, 84890, 84265, 84900, 29424, 84891, 84268, 
84901, 29425, 29404, 84236, 84267
21428, 29174, 29164, 83287, 83297, 29175, 29165, 83288, 83298, 29424, 84891, 84268, 84901, 29426, 84892, 84271, 
84902, 29427, 29406, 84239, 84270
21429, 29175, 29165, 83288, 83298, 3134, 3133, 28941, 28942, 29426, 84892, 84271, 84902, 3156, 29053, 29012, 
29054, 29428, 29407, 84242, 84273
21430, 3085, 3084, 28786, 28787, 29176, 29166, 83289, 83299, 3107, 28898, 28857, 28899, 29429, 84893, 84275, 
84903, 29430, 29409, 84243, 84274
21431, 29176, 29166, 83289, 83299, 29177, 29167, 83290, 83300, 29429, 84893, 84275, 84903, 29431, 84894, 84278, 
84904, 29432, 29411, 84246, 84277
21432, 29177, 29167, 83290, 83300, 29178, 29168, 83291, 83301, 29431, 84894, 84278, 84904, 29433, 84895, 84281, 
84905, 29434, 29413, 84249, 84280
21433, 29178, 29168, 83291, 83301, 29179, 29169, 83292, 83302, 29433, 84895, 84281, 84905, 29435, 84896, 84284, 
84906, 29436, 29415, 84252, 84283
21434, 29179, 29169, 83292, 83302, 29180, 29170, 83293, 83303, 29435, 84896, 84284, 84906, 29437, 84897, 84287, 
84907, 29438, 29417, 84255, 84286
21435, 29180, 29170, 83293, 83303, 29181, 29171, 83294, 83304, 29437, 84897, 84287, 84907, 29439, 84898, 84290, 
84908, 29440, 29419, 84258, 84289
21436, 29181, 29171, 83294, 83304, 29182, 29172, 83295, 83305, 29439, 84898, 84290, 84908, 29441, 84899, 84293, 
84909, 29442, 29421, 84261, 84292
21437, 29182, 29172, 83295, 83305, 29183, 29173, 83296, 83306, 29441, 84899, 84293, 84909, 29443, 84900, 84296, 
84910, 29444, 29423, 84264, 84295
21438, 29183, 29173, 83296, 83306, 29184, 29174, 83297, 83307, 29443, 84900, 84296, 84910, 29445, 84901, 84299, 
84911, 29446, 29425, 84267, 84298
21439, 29184, 29174, 83297, 83307, 29185, 29175, 83298, 83308, 29445, 84901, 84299, 84911, 29447, 84902, 84302, 
84912, 29448, 29427, 84270, 84301
21440, 29185, 29175, 83298, 83308, 3135, 3134, 28942, 28943, 29447, 84902, 84302, 84912, 3157, 29054, 29014, 
29055, 29449, 29428, 84273, 84304
21441, 3086, 3085, 28787, 28788, 29186, 29176, 83299, 83309, 3108, 28899, 28859, 28900, 29450, 84903, 84306, 
84913, 29451, 29430, 84274, 84305
21442, 29186, 29176, 83299, 83309, 29187, 29177, 83300, 83310, 29450, 84903, 84306, 84913, 29452, 84904, 84309, 
84914, 29453, 29432, 84277, 84308
21443, 29187, 29177, 83300, 83310, 29188, 29178, 83301, 83311, 29452, 84904, 84309, 84914, 29454, 84905, 84312, 
84915, 29455, 29434, 84280, 84311
21444, 29188, 29178, 83301, 83311, 29189, 29179, 83302, 83312, 29454, 84905, 84312, 84915, 29456, 84906, 84315, 
84916, 29457, 29436, 84283, 84314
21445, 29189, 29179, 83302, 83312, 29190, 29180, 83303, 83313, 29456, 84906, 84315, 84916, 29458, 84907, 84318, 
84917, 29459, 29438, 84286, 84317
21446, 29190, 29180, 83303, 83313, 29191, 29181, 83304, 83314, 29458, 84907, 84318, 84917, 29460, 84908, 84321, 
84918, 29461, 29440, 84289, 84320
21447, 29191, 29181, 83304, 83314, 29192, 29182, 83305, 83315, 29460, 84908, 84321, 84918, 29462, 84909, 84324, 
84919, 29463, 29442, 84292, 84323
21448, 29192, 29182, 83305, 83315, 29193, 29183, 83306, 83316, 29462, 84909, 84324, 84919, 29464, 84910, 84327, 
84920, 29465, 29444, 84295, 84326
21449, 29193, 29183, 83306, 83316, 29194, 29184, 83307, 83317, 29464, 84910, 84327, 84920, 29466, 84911, 84330, 
84921, 29467, 29446, 84298, 84329
21450, 29194, 29184, 83307, 83317, 29195, 29185, 83308, 83318, 29466, 84911, 84330, 84921, 29468, 84912, 84333, 
84922, 29469, 29448, 84301, 84332
21451, 29195, 29185, 83308, 83318, 3136, 3135, 28943, 28944, 29468, 84912, 84333, 84922, 3158, 29055, 29016, 
29056, 29470, 29449, 84304, 84335
21452, 3087, 3086, 28788, 28789, 29196, 29186, 83309, 83319, 3109, 28900, 28861, 28901, 29471, 84913, 84337, 
84923, 29472, 29451, 84305, 84336
21453, 29196, 29186, 83309, 83319, 29197, 29187, 83310, 83320, 29471, 84913, 84337, 84923, 29473, 84914, 84340, 
84924, 29474, 29453, 84308, 84339
21454, 29197, 29187, 83310, 83320, 29198, 29188, 83311, 83321, 29473, 84914, 84340, 84924, 29475, 84915, 84343, 
84925, 29476, 29455, 84311, 84342
21455, 29198, 29188, 83311, 83321, 29199, 29189, 83312, 83322, 29475, 84915, 84343, 84925, 29477, 84916, 84346, 
84926, 29478, 29457, 84314, 84345
21456, 29199, 29189, 83312, 83322, 29200, 29190, 83313, 83323, 29477, 84916, 84346, 84926, 29479, 84917, 84349, 
84927, 29480, 29459, 84317, 84348
21457, 29200, 29190, 83313, 83323, 29201, 29191, 83314, 83324, 29479, 84917, 84349, 84927, 29481, 84918, 84352, 
84928, 29482, 29461, 84320, 84351
21458, 29201, 29191, 83314, 83324, 29202, 29192, 83315, 83325, 29481, 84918, 84352, 84928, 29483, 84919, 84355, 
84929, 29484, 29463, 84323, 84354
21459, 29202, 29192, 83315, 83325, 29203, 29193, 83316, 83326, 29483, 84919, 84355, 84929, 29485, 84920, 84358, 
84930, 29486, 29465, 84326, 84357
21460, 29203, 29193, 83316, 83326, 29204, 29194, 83317, 83327, 29485, 84920, 84358, 84930, 29487, 84921, 84361, 
84931, 29488, 29467, 84329, 84360
21461, 29204, 29194, 83317, 83327, 29205, 29195, 83318, 83328, 29487, 84921, 84361, 84931, 29489, 84922, 84364, 
84932, 29490, 29469, 84332, 84363
21462, 29205, 29195, 83318, 83328, 3137, 3136, 28944, 28945, 29489, 84922, 84364, 84932, 3159, 29056, 29018, 
29057, 29491, 29470, 84335, 84366
21463, 3088, 3087, 28789, 28790, 29206, 29196, 83319, 83329, 3110, 28901, 28863, 28902, 29492, 84923, 84368, 
84933, 29493, 29472, 84336, 84367
21464, 29206, 29196, 83319, 83329, 29207, 29197, 83320, 83330, 29492, 84923, 84368, 84933, 29494, 84924, 84371, 
84934, 29495, 29474, 84339, 84370
21465, 29207, 29197, 83320, 83330, 29208, 29198, 83321, 83331, 29494, 84924, 84371, 84934, 29496, 84925, 84374, 
84935, 29497, 29476, 84342, 84373
21466, 29208, 29198, 83321, 83331, 29209, 29199, 83322, 83332, 29496, 84925, 84374, 84935, 29498, 84926, 84377, 
84936, 29499, 29478, 84345, 84376
21467, 29209, 29199, 83322, 83332, 29210, 29200, 83323, 83333, 29498, 84926, 84377, 84936, 29500, 84927, 84380, 
84937, 29501, 29480, 84348, 84379
21468, 29210, 29200, 83323, 83333, 29211, 29201, 83324, 83334, 29500, 84927, 84380, 84937, 29502, 84928, 84383, 
84938, 29503, 29482, 84351, 84382
21469, 29211, 29201, 83324, 83334, 29212, 29202, 83325, 83335, 29502, 84928, 84383, 84938, 29504, 84929, 84386, 
84939, 29505, 29484, 84354, 84385
21470, 29212, 29202, 83325, 83335, 29213, 29203, 83326, 83336, 29504, 84929, 84386, 84939, 29506, 84930, 84389, 
84940, 29507, 29486, 84357, 84388
21471, 29213, 29203, 83326, 83336, 29214, 29204, 83327, 83337, 29506, 84930, 84389, 84940, 29508, 84931, 84392, 
84941, 29509, 29488, 84360, 84391
21472, 29214, 29204, 83327, 83337, 29215, 29205, 83328, 83338, 29508, 84931, 84392, 84941, 29510, 84932, 84395, 
84942, 29511, 29490, 84363, 84394
21473, 29215, 29205, 83328, 83338, 3138, 3137, 28945, 28946, 29510, 84932, 84395, 84942, 3160, 29057, 29020, 
29058, 29512, 29491, 84366, 84397
21474, 3089, 3088, 28790, 28791, 29216, 29206, 83329, 83339, 3111, 28902, 28865, 28903, 29513, 84933, 84399, 
84943, 29514, 29493, 84367, 84398
21475, 29216, 29206, 83329, 83339, 29217, 29207, 83330, 83340, 29513, 84933, 84399, 84943, 29515, 84934, 84402, 
84944, 29516, 29495, 84370, 84401
21476, 29217, 29207, 83330, 83340, 29218, 29208, 83331, 83341, 29515, 84934, 84402, 84944, 29517, 84935, 84405, 
84945, 29518, 29497, 84373, 84404
21477, 29218, 29208, 83331, 83341, 29219, 29209, 83332, 83342, 29517, 84935, 84405, 84945, 29519, 84936, 84408, 
84946, 29520, 29499, 84376, 84407
21478, 29219, 29209, 83332, 83342, 29220, 29210, 83333, 83343, 29519, 84936, 84408, 84946, 29521, 84937, 84411, 
84947, 29522, 29501, 84379, 84410
21479, 29220, 29210, 83333, 83343, 29221, 29211, 83334, 83344, 29521, 84937, 84411, 84947, 29523, 84938, 84414, 
84948, 29524, 29503, 84382, 84413
21480, 29221, 29211, 83334, 83344, 29222, 29212, 83335, 83345, 29523, 84938, 84414, 84948, 29525, 84939, 84417, 
84949, 29526, 29505, 84385, 84416
21481, 29222, 29212, 83335, 83345, 29223, 29213, 83336, 83346, 29525, 84939, 84417, 84949, 29527, 84940, 84420, 
84950, 29528, 29507, 84388, 84419
21482, 29223, 29213, 83336, 83346, 29224, 29214, 83337, 83347, 29527, 84940, 84420, 84950, 29529, 84941, 84423, 
84951, 29530, 29509, 84391, 84422
21483, 29224, 29214, 83337, 83347, 29225, 29215, 83338, 83348, 29529, 84941, 84423, 84951, 29531, 84942, 84426, 
84952, 29532, 29511, 84394, 84425
21484, 29225, 29215, 83338, 83348, 3139, 3138, 28946, 28947, 29531, 84942, 84426, 84952, 3161, 29058, 29022, 
29059, 29533, 29512, 84397, 84428
21485, 3090, 3089, 28791, 28792, 29226, 29216, 83339, 83349, 3112, 28903, 28867, 28904, 29534, 84943, 84430, 
84953, 29535, 29514, 84398, 84429
21486, 29226, 29216, 83339, 83349, 29227, 29217, 83340, 83350, 29534, 84943, 84430, 84953, 29536, 84944, 84433, 
84954, 29537, 29516, 84401, 84432
21487, 29227, 29217, 83340, 83350, 29228, 29218, 83341, 83351, 29536, 84944, 84433, 84954, 29538, 84945, 84436, 
84955, 29539, 29518, 84404, 84435
21488, 29228, 29218, 83341, 83351, 29229, 29219, 83342, 83352, 29538, 84945, 84436, 84955, 29540, 84946, 84439, 
84956, 29541, 29520, 84407, 84438
21489, 29229, 29219, 83342, 83352, 29230, 29220, 83343, 83353, 29540, 84946, 84439, 84956, 29542, 84947, 84442, 
84957, 29543, 29522, 84410, 84441
21490, 29230, 29220, 83343, 83353, 29231, 29221, 83344, 83354, 29542, 84947, 84442, 84957, 29544, 84948, 84445, 
84958, 29545, 29524, 84413, 84444
21491, 29231, 29221, 83344, 83354, 29232, 29222, 83345, 83355, 29544, 84948, 84445, 84958, 29546, 84949, 84448, 
84959, 29547, 29526, 84416, 84447
21492, 29232, 29222, 83345, 83355, 29233, 29223, 83346, 83356, 29546, 84949, 84448, 84959, 29548, 84950, 84451, 
84960, 29549, 29528, 84419, 84450
21493, 29233, 29223, 83346, 83356, 29234, 29224, 83347, 83357, 29548, 84950, 84451, 84960, 29550, 84951, 84454, 
84961, 29551, 29530, 84422, 84453
21494, 29234, 29224, 83347, 83357, 29235, 29225, 83348, 83358, 29550, 84951, 84454, 84961, 29552, 84952, 84457, 
84962, 29553, 29532, 84425, 84456
21495, 29235, 29225, 83348, 83358, 3140, 3139, 28947, 28948, 29552, 84952, 84457, 84962, 3162, 29059, 29024, 
29060, 29554, 29533, 84428, 84459
21496, 3091, 3090, 28792, 28793, 29236, 29226, 83349, 83359, 3113, 28904, 28869, 28905, 29555, 84953, 84461, 
84963, 29556, 29535, 84429, 84460
21497, 29236, 29226, 83349, 83359, 29237, 29227, 83350, 83360, 29555, 84953, 84461, 84963, 29557, 84954, 84464, 
84964, 29558, 29537, 84432, 84463
21498, 29237, 29227, 83350, 83360, 29238, 29228, 83351, 83361, 29557, 84954, 84464, 84964, 29559, 84955, 84467, 
84965, 29560, 29539, 84435, 84466
21499, 29238, 29228, 83351, 83361, 29239, 29229, 83352, 83362, 29559, 84955, 84467, 84965, 29561, 84956, 84470, 
84966, 29562, 29541, 84438, 84469
21500, 29239, 29229, 83352, 83362, 29240, 29230, 83353, 83363, 29561, 84956, 84470, 84966, 29563, 84957, 84473, 
84967, 29564, 29543, 84441, 84472
21501, 29240, 29230, 83353, 83363, 29241, 29231, 83354, 83364, 29563, 84957, 84473, 84967, 29565, 84958, 84476, 
84968, 29566, 29545, 84444, 84475
21502, 29241, 29231, 83354, 83364, 29242, 29232, 83355, 83365, 29565, 84958, 84476, 84968, 29567, 84959, 84479, 
84969, 29568, 29547, 84447, 84478
21503, 29242, 29232, 83355, 83365, 29243, 29233, 83356, 83366, 29567, 84959, 84479, 84969, 29569, 84960, 84482, 
84970, 29570, 29549, 84450, 84481
21504, 29243, 29233, 83356, 83366, 29244, 29234, 83357, 83367, 29569, 84960, 84482, 84970, 29571, 84961, 84485, 
84971, 29572, 29551, 84453, 84484
21505, 29244, 29234, 83357, 83367, 29245, 29235, 83358, 83368, 29571, 84961, 84485, 84971, 29573, 84962, 84488, 
84972, 29574, 29553, 84456, 84487
21506, 29245, 29235, 83358, 83368, 3141, 3140, 28948, 28949, 29573, 84962, 84488, 84972, 3163, 29060, 29026, 
29061, 29575, 29554, 84459, 84490
21507, 3092, 3091, 28793, 28794, 29246, 29236, 83359, 83369, 3114, 28905, 28871, 28906, 29576, 84963, 84492, 
84973, 29577, 29556, 84460, 84491
21508, 29246, 29236, 83359, 83369, 29247, 29237, 83360, 83370, 29576, 84963, 84492, 84973, 29578, 84964, 84495, 
84974, 29579, 29558, 84463, 84494
21509, 29247, 29237, 83360, 83370, 29248, 29238, 83361, 83371, 29578, 84964, 84495, 84974, 29580, 84965, 84498, 
84975, 29581, 29560, 84466, 84497
21510, 29248, 29238, 83361, 83371, 29249, 29239, 83362, 83372, 29580, 84965, 84498, 84975, 29582, 84966, 84501, 
84976, 29583, 29562, 84469, 84500
21511, 29249, 29239, 83362, 83372, 29250, 29240, 83363, 83373, 29582, 84966, 84501, 84976, 29584, 84967, 84504, 
84977, 29585, 29564, 84472, 84503
21512, 29250, 29240, 83363, 83373, 29251, 29241, 83364, 83374, 29584, 84967, 84504, 84977, 29586, 84968, 84507, 
84978, 29587, 29566, 84475, 84506
21513, 29251, 29241, 83364, 83374, 29252, 29242, 83365, 83375, 29586, 84968, 84507, 84978, 29588, 84969, 84510, 
84979, 29589, 29568, 84478, 84509
21514, 29252, 29242, 83365, 83375, 29253, 29243, 83366, 83376, 29588, 84969, 84510, 84979, 29590, 84970, 84513, 
84980, 29591, 29570, 84481, 84512
21515, 29253, 29243, 83366, 83376, 29254, 29244, 83367, 83377, 29590, 84970, 84513, 84980, 29592, 84971, 84516, 
84981, 29593, 29572, 84484, 84515
21516, 29254, 29244, 83367, 83377, 29255, 29245, 83368, 83378, 29592, 84971, 84516, 84981, 29594, 84972, 84519, 
84982, 29595, 29574, 84487, 84518
21517, 29255, 29245, 83368, 83378, 3142, 3141, 28949, 28950, 29594, 84972, 84519, 84982, 3164, 29061, 29028, 
29062, 29596, 29575, 84490, 84521
21518, 3093, 3092, 28794, 28795, 29256, 29246, 83369, 83379, 3115, 28906, 28873, 28907, 29597, 84973, 84523, 
84983, 29598, 29577, 84491, 84522
21519, 29256, 29246, 83369, 83379, 29257, 29247, 83370, 83380, 29597, 84973, 84523, 84983, 29599, 84974, 84526, 
84984, 29600, 29579, 84494, 84525
21520, 29257, 29247, 83370, 83380, 29258, 29248, 83371, 83381, 29599, 84974, 84526, 84984, 29601, 84975, 84529, 
84985, 29602, 29581, 84497, 84528
21521, 29258, 29248, 83371, 83381, 29259, 29249, 83372, 83382, 29601, 84975, 84529, 84985, 29603, 84976, 84532, 
84986, 29604, 29583, 84500, 84531
21522, 29259, 29249, 83372, 83382, 29260, 29250, 83373, 83383, 29603, 84976, 84532, 84986, 29605, 84977, 84535, 
84987, 29606, 29585, 84503, 84534
21523, 29260, 29250, 83373, 83383, 29261, 29251, 83374, 83384, 29605, 84977, 84535, 84987, 29607, 84978, 84538, 
84988, 29608, 29587, 84506, 84537
21524, 29261, 29251, 83374, 83384, 29262, 29252, 83375, 83385, 29607, 84978, 84538, 84988, 29609, 84979, 84541, 
84989, 29610, 29589, 84509, 84540
21525, 29262, 29252, 83375, 83385, 29263, 29253, 83376, 83386, 29609, 84979, 84541, 84989, 29611, 84980, 84544, 
84990, 29612, 29591, 84512, 84543
21526, 29263, 29253, 83376, 83386, 29264, 29254, 83377, 83387, 29611, 84980, 84544, 84990, 29613, 84981, 84547, 
84991, 29614, 29593, 84515, 84546
21527, 29264, 29254, 83377, 83387, 29265, 29255, 83378, 83388, 29613, 84981, 84547, 84991, 29615, 84982, 84550, 
84992, 29616, 29595, 84518, 84549
21528, 29265, 29255, 83378, 83388, 3143, 3142, 28950, 28951, 29615, 84982, 84550, 84992, 3165, 29062, 29030, 
29063, 29617, 29596, 84521, 84552
21529, 3094, 3093, 28795, 28796, 29266, 29256, 83379, 83389, 3116, 28907, 28875, 28908, 29618, 84983, 84554, 
84993, 29619, 29598, 84522, 84553
21530, 29266, 29256, 83379, 83389, 29267, 29257, 83380, 83390, 29618, 84983, 84554, 84993, 29620, 84984, 84557, 
84994, 29621, 29600, 84525, 84556
21531, 29267, 29257, 83380, 83390, 29268, 29258, 83381, 83391, 29620, 84984, 84557, 84994, 29622, 84985, 84560, 
84995, 29623, 29602, 84528, 84559
21532, 29268, 29258, 83381, 83391, 29269, 29259, 83382, 83392, 29622, 84985, 84560, 84995, 29624, 84986, 84563, 
84996, 29625, 29604, 84531, 84562
21533, 29269, 29259, 83382, 83392, 29270, 29260, 83383, 83393, 29624, 84986, 84563, 84996, 29626, 84987, 84566, 
84997, 29627, 29606, 84534, 84565
21534, 29270, 29260, 83383, 83393, 29271, 29261, 83384, 83394, 29626, 84987, 84566, 84997, 29628, 84988, 84569, 
84998, 29629, 29608, 84537, 84568
21535, 29271, 29261, 83384, 83394, 29272, 29262, 83385, 83395, 29628, 84988, 84569, 84998, 29630, 84989, 84572, 
84999, 29631, 29610, 84540, 84571
21536, 29272, 29262, 83385, 83395, 29273, 29263, 83386, 83396, 29630, 84989, 84572, 84999, 29632, 84990, 84575, 
85000, 29633, 29612, 84543, 84574
21537, 29273, 29263, 83386, 83396, 29274, 29264, 83387, 83397, 29632, 84990, 84575, 85000, 29634, 84991, 84578, 
85001, 29635, 29614, 84546, 84577
21538, 29274, 29264, 83387, 83397, 29275, 29265, 83388, 83398, 29634, 84991, 84578, 85001, 29636, 84992, 84581, 
85002, 29637, 29616, 84549, 84580
21539, 29275, 29265, 83388, 83398, 3144, 3143, 28951, 28952, 29636, 84992, 84581, 85002, 3166, 29063, 29032, 
29064, 29638, 29617, 84552, 84583
21540, 3095, 3094, 28796, 28797, 29276, 29266, 83389, 83399, 3117, 28908, 28877, 28909, 29639, 84993, 84585, 
85003, 29640, 29619, 84553, 84584
21541, 29276, 29266, 83389, 83399, 29277, 29267, 83390, 83400, 29639, 84993, 84585, 85003, 29641, 84994, 84588, 
85004, 29642, 29621, 84556, 84587
21542, 29277, 29267, 83390, 83400, 29278, 29268, 83391, 83401, 29641, 84994, 84588, 85004, 29643, 84995, 84591, 
85005, 29644, 29623, 84559, 84590
21543, 29278, 29268, 83391, 83401, 29279, 29269, 83392, 83402, 29643, 84995, 84591, 85005, 29645, 84996, 84594, 
85006, 29646, 29625, 84562, 84593
21544, 29279, 29269, 83392, 83402, 29280, 29270, 83393, 83403, 29645, 84996, 84594, 85006, 29647, 84997, 84597, 
85007, 29648, 29627, 84565, 84596
21545, 29280, 29270, 83393, 83403, 29281, 29271, 83394, 83404, 29647, 84997, 84597, 85007, 29649, 84998, 84600, 
85008, 29650, 29629, 84568, 84599
21546, 29281, 29271, 83394, 83404, 29282, 29272, 83395, 83405, 29649, 84998, 84600, 85008, 29651, 84999, 84603, 
85009, 29652, 29631, 84571, 84602
21547, 29282, 29272, 83395, 83405, 29283, 29273, 83396, 83406, 29651, 84999, 84603, 85009, 29653, 85000, 84606, 
85010, 29654, 29633, 84574, 84605
21548, 29283, 29273, 83396, 83406, 29284, 29274, 83397, 83407, 29653, 85000, 84606, 85010, 29655, 85001, 84609, 
85011, 29656, 29635, 84577, 84608
21549, 29284, 29274, 83397, 83407, 29285, 29275, 83398, 83408, 29655, 85001, 84609, 85011, 29657, 85002, 84612, 
85012, 29658, 29637, 84580, 84611
21550, 29285, 29275, 83398, 83408, 3145, 3144, 28952, 28953, 29657, 85002, 84612, 85012, 3167, 29064, 29034, 
29065, 29659, 29638, 84583, 84614
21551, 3096, 3095, 28797, 28798, 29286, 29276, 83399, 83409, 3118, 28909, 28879, 28910, 29660, 85003, 84616, 
85013, 29661, 29640, 84584, 84615
21552, 29286, 29276, 83399, 83409, 29287, 29277, 83400, 83410, 29660, 85003, 84616, 85013, 29662, 85004, 84619, 
85014, 29663, 29642, 84587, 84618
21553, 29287, 29277, 83400, 83410, 29288, 29278, 83401, 83411, 29662, 85004, 84619, 85014, 29664, 85005, 84622, 
85015, 29665, 29644, 84590, 84621
21554, 29288, 29278, 83401, 83411, 29289, 29279, 83402, 83412, 29664, 85005, 84622, 85015, 29666, 85006, 84625, 
85016, 29667, 29646, 84593, 84624
21555, 29289, 29279, 83402, 83412, 29290, 29280, 83403, 83413, 29666, 85006, 84625, 85016, 29668, 85007, 84628, 
85017, 29669, 29648, 84596, 84627
21556, 29290, 29280, 83403, 83413, 29291, 29281, 83404, 83414, 29668, 85007, 84628, 85017, 29670, 85008, 84631, 
85018, 29671, 29650, 84599, 84630
21557, 29291, 29281, 83404, 83414, 29292, 29282, 83405, 83415, 29670, 85008, 84631, 85018, 29672, 85009, 84634, 
85019, 29673, 29652, 84602, 84633
21558, 29292, 29282, 83405, 83415, 29293, 29283, 83406, 83416, 29672, 85009, 84634, 85019, 29674, 85010, 84637, 
85020, 29675, 29654, 84605, 84636
21559, 29293, 29283, 83406, 83416, 29294, 29284, 83407, 83417, 29674, 85010, 84637, 85020, 29676, 85011, 84640, 
85021, 29677, 29656, 84608, 84639
21560, 29294, 29284, 83407, 83417, 29295, 29285, 83408, 83418, 29676, 85011, 84640, 85021, 29678, 85012, 84643, 
85022, 29679, 29658, 84611, 84642
21561, 29295, 29285, 83408, 83418, 3146, 3145, 28953, 28954, 29678, 85012, 84643, 85022, 3168, 29065, 29036, 
29066, 29680, 29659, 84614, 84645
21562, 3097, 3096, 28798, 28799, 29296, 29286, 83409, 83419, 3119, 28910, 28881, 28911, 29681, 85013, 84647, 
85023, 29682, 29661, 84615, 84646
21563, 29296, 29286, 83409, 83419, 29297, 29287, 83410, 83420, 29681, 85013, 84647, 85023, 29683, 85014, 84650, 
85024, 29684, 29663, 84618, 84649
21564, 29297, 29287, 83410, 83420, 29298, 29288, 83411, 83421, 29683, 85014, 84650, 85024, 29685, 85015, 84653, 
85025, 29686, 29665, 84621, 84652
21565, 29298, 29288, 83411, 83421, 29299, 29289, 83412, 83422, 29685, 85015, 84653, 85025, 29687, 85016, 84656, 
85026, 29688, 29667, 84624, 84655
21566, 29299, 29289, 83412, 83422, 29300, 29290, 83413, 83423, 29687, 85016, 84656, 85026, 29689, 85017, 84659, 
85027, 29690, 29669, 84627, 84658
21567, 29300, 29290, 83413, 83423, 29301, 29291, 83414, 83424, 29689, 85017, 84659, 85027, 29691, 85018, 84662, 
85028, 29692, 29671, 84630, 84661
21568, 29301, 29291, 83414, 83424, 29302, 29292, 83415, 83425, 29691, 85018, 84662, 85028, 29693, 85019, 84665, 
85029, 29694, 29673, 84633, 84664
21569, 29302, 29292, 83415, 83425, 29303, 29293, 83416, 83426, 29693, 85019, 84665, 85029, 29695, 85020, 84668, 
85030, 29696, 29675, 84636, 84667
21570, 29303, 29293, 83416, 83426, 29304, 29294, 83417, 83427, 29695, 85020, 84668, 85030, 29697, 85021, 84671, 
85031, 29698, 29677, 84639, 84670
21571, 29304, 29294, 83417, 83427, 29305, 29295, 83418, 83428, 29697, 85021, 84671, 85031, 29699, 85022, 84674, 
85032, 29700, 29679, 84642, 84673
21572, 29305, 29295, 83418, 83428, 3147, 3146, 28954, 28955, 29699, 85022, 84674, 85032, 3169, 29066, 29038, 
29067, 29701, 29680, 84645, 84676
21573, 3098, 3097, 28799, 28800, 29306, 29296, 83419, 83429, 3120, 28911, 28883, 28912, 29702, 85023, 84678, 
85033, 29703, 29682, 84646, 84677
21574, 29306, 29296, 83419, 83429, 29307, 29297, 83420, 83430, 29702, 85023, 84678, 85033, 29704, 85024, 84681, 
85034, 29705, 29684, 84649, 84680
21575, 29307, 29297, 83420, 83430, 29308, 29298, 83421, 83431, 29704, 85024, 84681, 85034, 29706, 85025, 84684, 
85035, 29707, 29686, 84652, 84683
21576, 29308, 29298, 83421, 83431, 29309, 29299, 83422, 83432, 29706, 85025, 84684, 85035, 29708, 85026, 84687, 
85036, 29709, 29688, 84655, 84686
21577, 29309, 29299, 83422, 83432, 29310, 29300, 83423, 83433, 29708, 85026, 84687, 85036, 29710, 85027, 84690, 
85037, 29711, 29690, 84658, 84689
21578, 29310, 29300, 83423, 83433, 29311, 29301, 83424, 83434, 29710, 85027, 84690, 85037, 29712, 85028, 84693, 
85038, 29713, 29692, 84661, 84692
21579, 29311, 29301, 83424, 83434, 29312, 29302, 83425, 83435, 29712, 85028, 84693, 85038, 29714, 85029, 84696, 
85039, 29715, 29694, 84664, 84695
21580, 29312, 29302, 83425, 83435, 29313, 29303, 83426, 83436, 29714, 85029, 84696, 85039, 29716, 85030, 84699, 
85040, 29717, 29696, 84667, 84698
21581, 29313, 29303, 83426, 83436, 29314, 29304, 83427, 83437, 29716, 85030, 84699, 85040, 29718, 85031, 84702, 
85041, 29719, 29698, 84670, 84701
21582, 29314, 29304, 83427, 83437, 29315, 29305, 83428, 83438, 29718, 85031, 84702, 85041, 29720, 85032, 84705, 
85042, 29721, 29700, 84673, 84704
21583, 29315, 29305, 83428, 83438, 3148, 3147, 28955, 28956, 29720, 85032, 84705, 85042, 3170, 29067, 29040, 
29068, 29722, 29701, 84676, 84707
21584, 3099, 3098, 28800, 28801, 29316, 29306, 83429, 83439, 3121, 28912, 28885, 28913, 29723, 85033, 84709, 
85043, 29724, 29703, 84677, 84708
21585, 29316, 29306, 83429, 83439, 29317, 29307, 83430, 83440, 29723, 85033, 84709, 85043, 29725, 85034, 84712, 
85044, 29726, 29705, 84680, 84711
21586, 29317, 29307, 83430, 83440, 29318, 29308, 83431, 83441, 29725, 85034, 84712, 85044, 29727, 85035, 84715, 
85045, 29728, 29707, 84683, 84714
21587, 29318, 29308, 83431, 83441, 29319, 29309, 83432, 83442, 29727, 85035, 84715, 85045, 29729, 85036, 84718, 
85046, 29730, 29709, 84686, 84717
21588, 29319, 29309, 83432, 83442, 29320, 29310, 83433, 83443, 29729, 85036, 84718, 85046, 29731, 85037, 84721, 
85047, 29732, 29711, 84689, 84720
21589, 29320, 29310, 83433, 83443, 29321, 29311, 83434, 83444, 29731, 85037, 84721, 85047, 29733, 85038, 84724, 
85048, 29734, 29713, 84692, 84723
21590, 29321, 29311, 83434, 83444, 29322, 29312, 83435, 83445, 29733, 85038, 84724, 85048, 29735, 85039, 84727, 
85049, 29736, 29715, 84695, 84726
21591, 29322, 29312, 83435, 83445, 29323, 29313, 83436, 83446, 29735, 85039, 84727, 85049, 29737, 85040, 84730, 
85050, 29738, 29717, 84698, 84729
21592, 29323, 29313, 83436, 83446, 29324, 29314, 83437, 83447, 29737, 85040, 84730, 85050, 29739, 85041, 84733, 
85051, 29740, 29719, 84701, 84732
21593, 29324, 29314, 83437, 83447, 29325, 29315, 83438, 83448, 29739, 85041, 84733, 85051, 29741, 85042, 84736, 
85052, 29742, 29721, 84704, 84735
21594, 29325, 29315, 83438, 83448, 3149, 3148, 28956, 28957, 29741, 85042, 84736, 85052, 3171, 29068, 29042, 
29069, 29743, 29722, 84707, 84738
21595, 3100, 3099, 28801, 28802, 29326, 29316, 83439, 83449, 3122, 28913, 28887, 28914, 29744, 85043, 84740, 
85053, 29745, 29724, 84708, 84739
21596, 29326, 29316, 83439, 83449, 29327, 29317, 83440, 83450, 29744, 85043, 84740, 85053, 29746, 85044, 84743, 
85054, 29747, 29726, 84711, 84742
21597, 29327, 29317, 83440, 83450, 29328, 29318, 83441, 83451, 29746, 85044, 84743, 85054, 29748, 85045, 84746, 
85055, 29749, 29728, 84714, 84745
21598, 29328, 29318, 83441, 83451, 29329, 29319, 83442, 83452, 29748, 85045, 84746, 85055, 29750, 85046, 84749, 
85056, 29751, 29730, 84717, 84748
21599, 29329, 29319, 83442, 83452, 29330, 29320, 83443, 83453, 29750, 85046, 84749, 85056, 29752, 85047, 84752, 
85057, 29753, 29732, 84720, 84751
21600, 29330, 29320, 83443, 83453, 29331, 29321, 83444, 83454, 29752, 85047, 84752, 85057, 29754, 85048, 84755, 
85058, 29755, 29734, 84723, 84754
21601, 29331, 29321, 83444, 83454, 29332, 29322, 83445, 83455, 29754, 85048, 84755, 85058, 29756, 85049, 84758, 
85059, 29757, 29736, 84726, 84757
21602, 29332, 29322, 83445, 83455, 29333, 29323, 83446, 83456, 29756, 85049, 84758, 85059, 29758, 85050, 84761, 
85060, 29759, 29738, 84729, 84760
21603, 29333, 29323, 83446, 83456, 29334, 29324, 83447, 83457, 29758, 85050, 84761, 85060, 29760, 85051, 84764, 
85061, 29761, 29740, 84732, 84763
21604, 29334, 29324, 83447, 83457, 29335, 29325, 83448, 83458, 29760, 85051, 84764, 85061, 29762, 85052, 84767, 
85062, 29763, 29742, 84735, 84766
21605, 29335, 29325, 83448, 83458, 3150, 3149, 28957, 28958, 29762, 85052, 84767, 85062, 3172, 29069, 29044, 
29070, 29764, 29743, 84738, 84769
21606, 3101, 3100, 28802, 28803, 29336, 29326, 83449, 83459, 3123, 28914, 28889, 28915, 29765, 85053, 84771, 
85063, 29766, 29745, 84739, 84770
21607, 29336, 29326, 83449, 83459, 29337, 29327, 83450, 83460, 29765, 85053, 84771, 85063, 29767, 85054, 84774, 
85064, 29768, 29747, 84742, 84773
21608, 29337, 29327, 83450, 83460, 29338, 29328, 83451, 83461, 29767, 85054, 84774, 85064, 29769, 85055, 84777, 
85065, 29770, 29749, 84745, 84776
21609, 29338, 29328, 83451, 83461, 29339, 29329, 83452, 83462, 29769, 85055, 84777, 85065, 29771, 85056, 84780, 
85066, 29772, 29751, 84748, 84779
21610, 29339, 29329, 83452, 83462, 29340, 29330, 83453, 83463, 29771, 85056, 84780, 85066, 29773, 85057, 84783, 
85067, 29774, 29753, 84751, 84782
21611, 29340, 29330, 83453, 83463, 29341, 29331, 83454, 83464, 29773, 85057, 84783, 85067, 29775, 85058, 84786, 
85068, 29776, 29755, 84754, 84785
21612, 29341, 29331, 83454, 83464, 29342, 29332, 83455, 83465, 29775, 85058, 84786, 85068, 29777, 85059, 84789, 
85069, 29778, 29757, 84757, 84788
21613, 29342, 29332, 83455, 83465, 29343, 29333, 83456, 83466, 29777, 85059, 84789, 85069, 29779, 85060, 84792, 
85070, 29780, 29759, 84760, 84791
21614, 29343, 29333, 83456, 83466, 29344, 29334, 83457, 83467, 29779, 85060, 84792, 85070, 29781, 85061, 84795, 
85071, 29782, 29761, 84763, 84794
21615, 29344, 29334, 83457, 83467, 29345, 29335, 83458, 83468, 29781, 85061, 84795, 85071, 29783, 85062, 84798, 
85072, 29784, 29763, 84766, 84797
21616, 29345, 29335, 83458, 83468, 3151, 3150, 28958, 28959, 29783, 85062, 84798, 85072, 3173, 29070, 29046, 
29071, 29785, 29764, 84769, 84800
21617, 3102, 3101, 28803, 28804, 29346, 29336, 83459, 83469, 3124, 28915, 28891, 28916, 29786, 85063, 84802, 
85073, 29787, 29766, 84770, 84801
21618, 29346, 29336, 83459, 83469, 29347, 29337, 83460, 83470, 29786, 85063, 84802, 85073, 29788, 85064, 84805, 
85074, 29789, 29768, 84773, 84804
21619, 29347, 29337, 83460, 83470, 29348, 29338, 83461, 83471, 29788, 85064, 84805, 85074, 29790, 85065, 84808, 
85075, 29791, 29770, 84776, 84807
21620, 29348, 29338, 83461, 83471, 29349, 29339, 83462, 83472, 29790, 85065, 84808, 85075, 29792, 85066, 84811, 
85076, 29793, 29772, 84779, 84810
21621, 29349, 29339, 83462, 83472, 29350, 29340, 83463, 83473, 29792, 85066, 84811, 85076, 29794, 85067, 84814, 
85077, 29795, 29774, 84782, 84813
21622, 29350, 29340, 83463, 83473, 29351, 29341, 83464, 83474, 29794, 85067, 84814, 85077, 29796, 85068, 84817, 
85078, 29797, 29776, 84785, 84816
21623, 29351, 29341, 83464, 83474, 29352, 29342, 83465, 83475, 29796, 85068, 84817, 85078, 29798, 85069, 84820, 
85079, 29799, 29778, 84788, 84819
21624, 29352, 29342, 83465, 83475, 29353, 29343, 83466, 83476, 29798, 85069, 84820, 85079, 29800, 85070, 84823, 
85080, 29801, 29780, 84791, 84822
21625, 29353, 29343, 83466, 83476, 29354, 29344, 83467, 83477, 29800, 85070, 84823, 85080, 29802, 85071, 84826, 
85081, 29803, 29782, 84794, 84825
21626, 29354, 29344, 83467, 83477, 29355, 29345, 83468, 83478, 29802, 85071, 84826, 85081, 29804, 85072, 84829, 
85082, 29805, 29784, 84797, 84828
21627, 29355, 29345, 83468, 83478, 3152, 3151, 28959, 28960, 29804, 85072, 84829, 85082, 3174, 29071, 29048, 
29072, 29806, 29785, 84800, 84831
21628, 3103, 3102, 28804, 28805, 29356, 29346, 83469, 83479, 3125, 28916, 28893, 28917, 29807, 85073, 84833, 
85083, 29808, 29787, 84801, 84832
21629, 29356, 29346, 83469, 83479, 29357, 29347, 83470, 83480, 29807, 85073, 84833, 85083, 29809, 85074, 84836, 
85084, 29810, 29789, 84804, 84835
21630, 29357, 29347, 83470, 83480, 29358, 29348, 83471, 83481, 29809, 85074, 84836, 85084, 29811, 85075, 84839, 
85085, 29812, 29791, 84807, 84838
21631, 29358, 29348, 83471, 83481, 29359, 29349, 83472, 83482, 29811, 85075, 84839, 85085, 29813, 85076, 84842, 
85086, 29814, 29793, 84810, 84841
21632, 29359, 29349, 83472, 83482, 29360, 29350, 83473, 83483, 29813, 85076, 84842, 85086, 29815, 85077, 84845, 
85087, 29816, 29795, 84813, 84844
21633, 29360, 29350, 83473, 83483, 29361, 29351, 83474, 83484, 29815, 85077, 84845, 85087, 29817, 85078, 84848, 
85088, 29818, 29797, 84816, 84847
21634, 29361, 29351, 83474, 83484, 29362, 29352, 83475, 83485, 29817, 85078, 84848, 85088, 29819, 85079, 84851, 
85089, 29820, 29799, 84819, 84850
21635, 29362, 29352, 83475, 83485, 29363, 29353, 83476, 83486, 29819, 85079, 84851, 85089, 29821, 85080, 84854, 
85090, 29822, 29801, 84822, 84853
21636, 29363, 29353, 83476, 83486, 29364, 29354, 83477, 83487, 29821, 85080, 84854, 85090, 29823, 85081, 84857, 
85091, 29824, 29803, 84825, 84856
21637, 29364, 29354, 83477, 83487, 29365, 29355, 83478, 83488, 29823, 85081, 84857, 85091, 29825, 85082, 84860, 
85092, 29826, 29805, 84828, 84859
21638, 29365, 29355, 83478, 83488, 3153, 3152, 28960, 28961, 29825, 85082, 84860, 85092, 3175, 29072, 29050, 
29073, 29827, 29806, 84831, 84862
21639, 45, 3103, 28805, 2046, 2064, 29356, 83479, 22469, 3126, 28917, 28895, 2049, 29828, 85083, 84863, 
22521, 2075, 29808, 84832, 22500
21640, 2064, 29356, 83479, 22469, 2063, 29357, 83480, 22470, 29828, 85083, 84863, 22521, 29829, 85084, 84864, 
22522, 2074, 29810, 84835, 22502
21641, 2063, 29357, 83480, 22470, 2062, 29358, 83481, 22471, 29829, 85084, 84864, 22522, 29830, 85085, 84865, 
22523, 2073, 29812, 84838, 22504
21642, 2062, 29358, 83481, 22471, 2061, 29359, 83482, 22472, 29830, 85085, 84865, 22523, 29831, 85086, 84866, 
22524, 2072, 29814, 84841, 22506
21643, 2061, 29359, 83482, 22472, 2060, 29360, 83483, 22473, 29831, 85086, 84866, 22524, 29832, 85087, 84867, 
22525, 2071, 29816, 84844, 22508
21644, 2060, 29360, 83483, 22473, 2059, 29361, 83484, 22474, 29832, 85087, 84867, 22525, 29833, 85088, 84868, 
22526, 2070, 29818, 84847, 22510
21645, 2059, 29361, 83484, 22474, 2058, 29362, 83485, 22475, 29833, 85088, 84868, 22526, 29834, 85089, 84869, 
22527, 2069, 29820, 84850, 22512
21646, 2058, 29362, 83485, 22475, 2057, 29363, 83486, 22476, 29834, 85089, 84869, 22527, 29835, 85090, 84870, 
22528, 2068, 29822, 84853, 22514
21647, 2057, 29363, 83486, 22476, 2056, 29364, 83487, 22477, 29835, 85090, 84870, 22528, 29836, 85091, 84871, 
22529, 2067, 29824, 84856, 22516
21648, 2056, 29364, 83487, 22477, 2055, 29365, 83488, 22478, 29836, 85091, 84871, 22529, 29837, 85092, 84872, 
22530, 2066, 29826, 84859, 22518
21649, 2055, 29365, 83488, 22478, 46, 3153, 28961, 2051, 29837, 85092, 84872, 22530, 3176, 29073, 29051, 
2054, 2065, 29827, 84862, 22520
*ELEMENT, type=C3D20, ELSET=Volume12
21650, 42, 2076, 22531, 2045, 2033, 22563, 85093, 22459, 2078, 22536, 22535, 2047, 22584, 85134, 85135, 
22480, 2044, 22583, 85133, 22479
21651, 2033, 22563, 85093, 22459, 2032, 22564, 85094, 22460, 22584, 85134, 85135, 22480, 22586, 85137, 85138, 
22482, 2043, 22585, 85136, 22481
21652, 2032, 22564, 85094, 22460, 2031, 22565, 85095, 22461, 22586, 85137, 85138, 22482, 22588, 85140, 85141, 
22484, 2042, 22587, 85139, 22483
21653, 2031, 22565, 85095, 22461, 2030, 22566, 85096, 22462, 22588, 85140, 85141, 22484, 22590, 85143, 85144, 
22486, 2041, 22589, 85142, 22485
21654, 2030, 22566, 85096, 22462, 2029, 22567, 85097, 22463, 22590, 85143, 85144, 22486, 22592, 85146, 85147, 
22488, 2040, 22591, 85145, 22487
21655, 2029, 22567, 85097, 22463, 2028, 22568, 85098, 22464, 22592, 85146, 85147, 22488, 22594, 85149, 85150, 
22490, 2039, 22593, 85148, 22489
21656, 2028, 22568, 85098, 22464, 2027, 22569, 85099, 22465, 22594, 85149, 85150, 22490, 22596, 85152, 85153, 
22492, 2038, 22595, 85151, 22491
21657, 2027, 22569, 85099, 22465, 2026, 22570, 85100, 22466, 22596, 85152, 85153, 22492, 22598, 85155, 85156, 
22494, 2037, 22597, 85154, 22493
21658, 2026, 22570, 85100, 22466, 2025, 22571, 85101, 22467, 22598, 85155, 85156, 22494, 22600, 85158, 85159, 
22496, 2036, 22599, 85157, 22495
21659, 2025, 22571, 85101, 22467, 2024, 22572, 85102, 22468, 22600, 85158, 85159, 22496, 22602, 85161, 85162, 
22498, 2035, 22601, 85160, 22497
21660, 2024, 22572, 85102, 22468, 44, 2091, 22547, 2050, 22602, 85161, 85162, 22498, 2093, 22551, 22552, 
2052, 2034, 22603, 85163, 22499
21661, 2045, 22531, 22532, 2046, 22459, 85093, 85103, 22469, 22535, 22538, 22537, 2048, 85135, 85165, 85166, 
22501, 22479, 85133, 85164, 22500
21662, 22459, 85093, 85103, 22469, 22460, 85094, 85104, 22470, 85135, 85165, 85166, 22501, 85138, 85168, 85169, 
22503, 22481, 85136, 85167, 22502
21663, 22460, 85094, 85104, 22470, 22461, 85095, 85105, 22471, 85138, 85168, 85169, 22503, 85141, 85171, 85172, 
22505, 22483, 85139, 85170, 22504
21664, 22461, 85095, 85105, 22471, 22462, 85096, 85106, 22472, 85141, 85171, 85172, 22505, 85144, 85174, 85175, 
22507, 22485, 85142, 85173, 22506
21665, 22462, 85096, 85106, 22472, 22463, 85097, 85107, 22473, 85144, 85174, 85175, 22507, 85147, 85177, 85178, 
22509, 22487, 85145, 85176, 22508
21666, 22463, 85097, 85107, 22473, 22464, 85098, 85108, 22474, 85147, 85177, 85178, 22509, 85150, 85180, 85181, 
22511, 22489, 85148, 85179, 22510
21667, 22464, 85098, 85108, 22474, 22465, 85099, 85109, 22475, 85150, 85180, 85181, 22511, 85153, 85183, 85184, 
22513, 22491, 85151, 85182, 22512
21668, 22465, 85099, 85109, 22475, 22466, 85100, 85110, 22476, 85153, 85183, 85184, 22513, 85156, 85186, 85187, 
22515, 22493, 85154, 85185, 22514
21669, 22466, 85100, 85110, 22476, 22467, 85101, 85111, 22477, 85156, 85186, 85187, 22515, 85159, 85189, 85190, 
22517, 22495, 85157, 85188, 22516
21670, 22467, 85101, 85111, 22477, 22468, 85102, 85112, 22478, 85159, 85189, 85190, 22517, 85162, 85192, 85193, 
22519, 22497, 85160, 85191, 22518
21671, 22468, 85102, 85112, 22478, 2050, 22547, 22548, 2051, 85162, 85192, 85193, 22519, 22552, 22553, 22554, 
2053, 22499, 85163, 85194, 22520
21672, 2046, 22532, 2081, 45, 22469, 85103, 22635, 2064, 22537, 22539, 2083, 2049, 85166, 85195, 22655, 
22521, 22500, 85164, 22656, 2075
21673, 22469, 85103, 22635, 2064, 22470, 85104, 22636, 2063, 85166, 85195, 22655, 22521, 85169, 85196, 22657, 
22522, 22502, 85167, 22658, 2074
21674, 22470, 85104, 22636, 2063, 22471, 85105, 22637, 2062, 85169, 85196, 22657, 22522, 85172, 85197, 22659, 
22523, 22504, 85170, 22660, 2073
21675, 22471, 85105, 22637, 2062, 22472, 85106, 22638, 2061, 85172, 85197, 22659, 22523, 85175, 85198, 22661, 
22524, 22506, 85173, 22662, 2072
21676, 22472, 85106, 22638, 2061, 22473, 85107, 22639, 2060, 85175, 85198, 22661, 22524, 85178, 85199, 22663, 
22525, 22508, 85176, 22664, 2071
21677, 22473, 85107, 22639, 2060, 22474, 85108, 22640, 2059, 85178, 85199, 22663, 22525, 85181, 85200, 22665, 
22526, 22510, 85179, 22666, 2070
21678, 22474, 85108, 22640, 2059, 22475, 85109, 22641, 2058, 85181, 85200, 22665, 22526, 85184, 85201, 22667, 
22527, 22512, 85182, 22668, 2069
21679, 22475, 85109, 22641, 2058, 22476, 85110, 22642, 2057, 85184, 85201, 22667, 22527, 85187, 85202, 22669, 
22528, 22514, 85185, 22670, 2068
21680, 22476, 85110, 22642, 2057, 22477, 85111, 22643, 2056, 85187, 85202, 22669, 22528, 85190, 85203, 22671, 
22529, 22516, 85188, 22672, 2067
21681, 22477, 85111, 22643, 2056, 22478, 85112, 22644, 2055, 85190, 85203, 22671, 22529, 85193, 85204, 22673, 
22530, 22518, 85191, 22674, 2066
21682, 22478, 85112, 22644, 2055, 2051, 22548, 2096, 46, 85193, 85204, 22673, 22530, 22554, 22555, 2098, 
2054, 22520, 85194, 22675, 2065
21683, 2076, 2077, 22533, 22531, 22563, 22573, 85113, 85093, 2079, 22541, 22540, 22536, 22605, 85206, 85207, 
85134, 22583, 22604, 85205, 85133
21684, 22563, 22573, 85113, 85093, 22564, 22574, 85114, 85094, 22605, 85206, 85207, 85134, 22607, 85209, 85210, 
85137, 22585, 22606, 85208, 85136
21685, 22564, 22574, 85114, 85094, 22565, 22575, 85115, 85095, 22607, 85209, 85210, 85137, 22609, 85212, 85213, 
85140, 22587, 22608, 85211, 85139
21686, 22565, 22575, 85115, 85095, 22566, 22576, 85116, 85096, 22609, 85212, 85213, 85140, 22611, 85215, 85216, 
85143, 22589, 22610, 85214, 85142
21687, 22566, 22576, 85116, 85096, 22567, 22577, 85117, 85097, 22611, 85215, 85216, 85143, 22613, 85218, 85219, 
85146, 22591, 22612, 85217, 85145
21688, 22567, 22577, 85117, 85097, 22568, 22578, 85118, 85098, 22613, 85218, 85219, 85146, 22615, 85221, 85222, 
85149, 22593, 22614, 85220, 85148
21689, 22568, 22578, 85118, 85098, 22569, 22579, 85119, 85099, 22615, 85221, 85222, 85149, 22617, 85224, 85225, 
85152, 22595, 22616, 85223, 85151
21690, 22569, 22579, 85119, 85099, 22570, 22580, 85120, 85100, 22617, 85224, 85225, 85152, 22619, 85227, 85228, 
85155, 22597, 22618, 85226, 85154
21691, 22570, 22580, 85120, 85100, 22571, 22581, 85121, 85101, 22619, 85227, 85228, 85155, 22621, 85230, 85231, 
85158, 22599, 22620, 85229, 85157
21692, 22571, 22581, 85121, 85101, 22572, 22582, 85122, 85102, 22621, 85230, 85231, 85158, 22623, 85233, 85234, 
85161, 22601, 22622, 85232, 85160
21693, 22572, 22582, 85122, 85102, 2091, 2092, 22549, 22547, 22623, 85233, 85234, 85161, 2094, 22556, 22557, 
22551, 22603, 22624, 85235, 85163
21694, 22531, 22533, 22534, 22532, 85093, 85113, 85123, 85103, 22540, 22543, 22542, 22538, 85207, 85237, 85238, 
85165, 85133, 85205, 85236, 85164
21695, 85093, 85113, 85123, 85103, 85094, 85114, 85124, 85104, 85207, 85237, 85238, 85165, 85210, 85240, 85241, 
85168, 85136, 85208, 85239, 85167
21696, 85094, 85114, 85124, 85104, 85095, 85115, 85125, 85105, 85210, 85240, 85241, 85168, 85213, 85243, 85244, 
85171, 85139, 85211, 85242, 85170
21697, 85095, 85115, 85125, 85105, 85096, 85116, 85126, 85106, 85213, 85243, 85244, 85171, 85216, 85246, 85247, 
85174, 85142, 85214, 85245, 85173
21698, 85096, 85116, 85126, 85106, 85097, 85117, 85127, 85107, 85216, 85246, 85247, 85174, 85219, 85249, 85250, 
85177, 85145, 85217, 85248, 85176
21699, 85097, 85117, 85127, 85107, 85098, 85118, 85128, 85108, 85219, 85249, 85250, 85177, 85222, 85252, 85253, 
85180, 85148, 85220, 85251, 85179
21700, 85098, 85118, 85128, 85108, 85099, 85119, 85129, 85109, 85222, 85252, 85253, 85180, 85225, 85255, 85256, 
85183, 85151, 85223, 85254, 85182
21701, 85099, 85119, 85129, 85109, 85100, 85120, 85130, 85110, 85225, 85255, 85256, 85183, 85228, 85258, 85259, 
85186, 85154, 85226, 85257, 85185
21702, 85100, 85120, 85130, 85110, 85101, 85121, 85131, 85111, 85228, 85258, 85259, 85186, 85231, 85261, 85262, 
85189, 85157, 85229, 85260, 85188
21703, 85101, 85121, 85131, 85111, 85102, 85122, 85132, 85112, 85231, 85261, 85262, 85189, 85234, 85264, 85265, 
85192, 85160, 85232, 85263, 85191
21704, 85102, 85122, 85132, 85112, 22547, 22549, 22550, 22548, 85234, 85264, 85265, 85192, 22557, 22558, 22559, 
22553, 85163, 85235, 85266, 85194
21705, 22532, 22534, 2082, 2081, 85103, 85123, 22645, 22635, 22542, 22544, 2084, 22539, 85238, 85267, 22676, 
85195, 85164, 85236, 22677, 22656
21706, 85103, 85123, 22645, 22635, 85104, 85124, 22646, 22636, 85238, 85267, 22676, 85195, 85241, 85268, 22678, 
85196, 85167, 85239, 22679, 22658
21707, 85104, 85124, 22646, 22636, 85105, 85125, 22647, 22637, 85241, 85268, 22678, 85196, 85244, 85269, 22680, 
85197, 85170, 85242, 22681, 22660
21708, 85105, 85125, 22647, 22637, 85106, 85126, 22648, 22638, 85244, 85269, 22680, 85197, 85247, 85270, 22682, 
85198, 85173, 85245, 22683, 22662
21709, 85106, 85126, 22648, 22638, 85107, 85127, 22649, 22639, 85247, 85270, 22682, 85198, 85250, 85271, 22684, 
85199, 85176, 85248, 22685, 22664
21710, 85107, 85127, 22649, 22639, 85108, 85128, 22650, 22640, 85250, 85271, 22684, 85199, 85253, 85272, 22686, 
85200, 85179, 85251, 22687, 22666
21711, 85108, 85128, 22650, 22640, 85109, 85129, 22651, 22641, 85253, 85272, 22686, 85200, 85256, 85273, 22688, 
85201, 85182, 85254, 22689, 22668
21712, 85109, 85129, 22651, 22641, 85110, 85130, 22652, 22642, 85256, 85273, 22688, 85201, 85259, 85274, 22690, 
85202, 85185, 85257, 22691, 22670
21713, 85110, 85130, 22652, 22642, 85111, 85131, 22653, 22643, 85259, 85274, 22690, 85202, 85262, 85275, 22692, 
85203, 85188, 85260, 22693, 22672
21714, 85111, 85131, 22653, 22643, 85112, 85132, 22654, 22644, 85262, 85275, 22692, 85203, 85265, 85276, 22694, 
85204, 85191, 85263, 22695, 22674
21715, 85112, 85132, 22654, 22644, 22548, 22550, 2097, 2096, 85265, 85276, 22694, 85204, 22559, 22560, 2099, 
22555, 85194, 85266, 22696, 22675
21716, 2077, 47, 2086, 22533, 22573, 2115, 22707, 85113, 2080, 2088, 22545, 22541, 22625, 22728, 85277, 
85206, 22604, 2126, 22727, 85205
21717, 22573, 2115, 22707, 85113, 22574, 2114, 22708, 85114, 22625, 22728, 85277, 85206, 22626, 22730, 85278, 
85209, 22606, 2125, 22729, 85208
21718, 22574, 2114, 22708, 85114, 22575, 2113, 22709, 85115, 22626, 22730, 85278, 85209, 22627, 22732, 85279, 
85212, 22608, 2124, 22731, 85211
21719, 22575, 2113, 22709, 85115, 22576, 2112, 22710, 85116, 22627, 22732, 85279, 85212, 22628, 22734, 85280, 
85215, 22610, 2123, 22733, 85214
21720, 22576, 2112, 22710, 85116, 22577, 2111, 22711, 85117, 22628, 22734, 85280, 85215, 22629, 22736, 85281, 
85218, 22612, 2122, 22735, 85217
21721, 22577, 2111, 22711, 85117, 22578, 2110, 22712, 85118, 22629, 22736, 85281, 85218, 22630, 22738, 85282, 
85221, 22614, 2121, 22737, 85220
21722, 22578, 2110, 22712, 85118, 22579, 2109, 22713, 85119, 22630, 22738, 85282, 85221, 22631, 22740, 85283, 
85224, 22616, 2120, 22739, 85223
21723, 22579, 2109, 22713, 85119, 22580, 2108, 22714, 85120, 22631, 22740, 85283, 85224, 22632, 22742, 85284, 
85227, 22618, 2119, 22741, 85226
21724, 22580, 2108, 22714, 85120, 22581, 2107, 22715, 85121, 22632, 22742, 85284, 85227, 22633, 22744, 85285, 
85230, 22620, 2118, 22743, 85229
21725, 22581, 2107, 22715, 85121, 22582, 2106, 22716, 85122, 22633, 22744, 85285, 85230, 22634, 22746, 85286, 
85233, 22622, 2117, 22745, 85232
21726, 22582, 2106, 22716, 85122, 2092, 49, 2101, 22549, 22634, 22746, 85286, 85233, 2095, 2103, 22561, 
22556, 22624, 2116, 22747, 85235
21727, 22533, 2086, 2087, 22534, 85113, 22707, 22717, 85123, 22545, 2089, 22546, 22543, 85277, 22749, 85287, 
85237, 85205, 22727, 22748, 85236
21728, 85113, 22707, 22717, 85123, 85114, 22708, 22718, 85124, 85277, 22749, 85287, 85237, 85278, 22751, 85288, 
85240, 85208, 22729, 22750, 85239
21729, 85114, 22708, 22718, 85124, 85115, 22709, 22719, 85125, 85278, 22751, 85288, 85240, 85279, 22753, 85289, 
85243, 85211, 22731, 22752, 85242
21730, 85115, 22709, 22719, 85125, 85116, 22710, 22720, 85126, 85279, 22753, 85289, 85243, 85280, 22755, 85290, 
85246, 85214, 22733, 22754, 85245
21731, 85116, 22710, 22720, 85126, 85117, 22711, 22721, 85127, 85280, 22755, 85290, 85246, 85281, 22757, 85291, 
85249, 85217, 22735, 22756, 85248
21732, 85117, 22711, 22721, 85127, 85118, 22712, 22722, 85128, 85281, 22757, 85291, 85249, 85282, 22759, 85292, 
85252, 85220, 22737, 22758, 85251
21733, 85118, 22712, 22722, 85128, 85119, 22713, 22723, 85129, 85282, 22759, 85292, 85252, 85283, 22761, 85293, 
85255, 85223, 22739, 22760, 85254
21734, 85119, 22713, 22723, 85129, 85120, 22714, 22724, 85130, 85283, 22761, 85293, 85255, 85284, 22763, 85294, 
85258, 85226, 22741, 22762, 85257
21735, 85120, 22714, 22724, 85130, 85121, 22715, 22725, 85131, 85284, 22763, 85294, 85258, 85285, 22765, 85295, 
85261, 85229, 22743, 22764, 85260
21736, 85121, 22715, 22725, 85131, 85122, 22716, 22726, 85132, 85285, 22765, 85295, 85261, 85286, 22767, 85296, 
85264, 85232, 22745, 22766, 85263
21737, 85122, 22716, 22726, 85132, 22549, 2101, 2102, 22550, 85286, 22767, 85296, 85264, 22561, 2104, 22562, 
22558, 85235, 22747, 22768, 85266
21738, 22534, 2087, 48, 2082, 85123, 22717, 2136, 22645, 22546, 2090, 2085, 22544, 85287, 22769, 22697, 
85267, 85236, 22748, 2147, 22677
21739, 85123, 22717, 2136, 22645, 85124, 22718, 2135, 22646, 85287, 22769, 22697, 85267, 85288, 22770, 22698, 
85268, 85239, 22750, 2146, 22679
21740, 85124, 22718, 2135, 22646, 85125, 22719, 2134, 22647, 85288, 22770, 22698, 85268, 85289, 22771, 22699, 
85269, 85242, 22752, 2145, 22681
21741, 85125, 22719, 2134, 22647, 85126, 22720, 2133, 22648, 85289, 22771, 22699, 85269, 85290, 22772, 22700, 
85270, 85245, 22754, 2144, 22683
21742, 85126, 22720, 2133, 22648, 85127, 22721, 2132, 22649, 85290, 22772, 22700, 85270, 85291, 22773, 22701, 
85271, 85248, 22756, 2143, 22685
21743, 85127, 22721, 2132, 22649, 85128, 22722, 2131, 22650, 85291, 22773, 22701, 85271, 85292, 22774, 22702, 
85272, 85251, 22758, 2142, 22687
21744, 85128, 22722, 2131, 22650, 85129, 22723, 2130, 22651, 85292, 22774, 22702, 85272, 85293, 22775, 22703, 
85273, 85254, 22760, 2141, 22689
21745, 85129, 22723, 2130, 22651, 85130, 22724, 2129, 22652, 85293, 22775, 22703, 85273, 85294, 22776, 22704, 
85274, 85257, 22762, 2140, 22691
21746, 85130, 22724, 2129, 22652, 85131, 22725, 2128, 22653, 85294, 22776, 22704, 85274, 85295, 22777, 22705, 
85275, 85260, 22764, 2139, 22693
21747, 85131, 22725, 2128, 22653, 85132, 22726, 2127, 22654, 85295, 22777, 22705, 85275, 85296, 22778, 22706, 
85276, 85263, 22766, 2138, 22695
21748, 85132, 22726, 2127, 22654, 22550, 2102, 50, 2097, 85296, 22778, 22706, 85276, 22562, 2105, 2100, 
22560, 85266, 22768, 2137, 22696
*ELEMENT, type=C3D20, ELSET=Volume13
21749, 22779, 2148, 1, 98, 85297, 22852, 110, 3377, 22799, 2150, 109, 22800, 85338, 22858, 3429, 
85339, 85337, 22859, 112, 3424
21750, 85297, 22852, 110, 3377, 85298, 22851, 111, 3378, 85338, 22858, 3429, 85339, 85341, 22856, 3430, 
85342, 85340, 22857, 113, 3426
21751, 85298, 22851, 111, 3378, 22867, 2179, 3, 124, 85341, 22856, 3430, 85342, 22888, 2181, 135, 
22887, 85343, 22855, 114, 3428
21752, 22780, 22779, 98, 97, 85299, 85297, 3377, 3375, 22801, 22800, 108, 22802, 85345, 85339, 3425, 
85346, 85344, 85337, 3424, 3419
21753, 85299, 85297, 3377, 3375, 85300, 85298, 3378, 3376, 85345, 85339, 3425, 85346, 85348, 85342, 3427, 
85349, 85347, 85340, 3426, 3421
21754, 85300, 85298, 3378, 3376, 22868, 22867, 124, 123, 85348, 85342, 3427, 85349, 22890, 22887, 134, 
22889, 85350, 85343, 3428, 3423
21755, 22781, 22780, 97, 96, 85301, 85299, 3375, 3373, 22803, 22802, 107, 22804, 85352, 85346, 3420, 
85353, 85351, 85344, 3419, 3414
21756, 85301, 85299, 3375, 3373, 85302, 85300, 3376, 3374, 85352, 85346, 3420, 85353, 85355, 85349, 3422, 
85356, 85354, 85347, 3421, 3416
21757, 85302, 85300, 3376, 3374, 22869, 22868, 123, 122, 85355, 85349, 3422, 85356, 22892, 22889, 133, 
22891, 85357, 85350, 3423, 3418
21758, 22782, 22781, 96, 95, 85303, 85301, 3373, 3371, 22805, 22804, 106, 22806, 85359, 85353, 3415, 
85360, 85358, 85351, 3414, 3409
21759, 85303, 85301, 3373, 3371, 85304, 85302, 3374, 3372, 85359, 85353, 3415, 85360, 85362, 85356, 3417, 
85363, 85361, 85354, 3416, 3411
21760, 85304, 85302, 3374, 3372, 22870, 22869, 122, 121, 85362, 85356, 3417, 85363, 22894, 22891, 132, 
22893, 85364, 85357, 3418, 3413
21761, 22783, 22782, 95, 94, 85305, 85303, 3371, 3369, 22807, 22806, 105, 22808, 85366, 85360, 3410, 
85367, 85365, 85358, 3409, 3404
21762, 85305, 85303, 3371, 3369, 85306, 85304, 3372, 3370, 85366, 85360, 3410, 85367, 85369, 85363, 3412, 
85370, 85368, 85361, 3411, 3406
21763, 85306, 85304, 3372, 3370, 22871, 22870, 121, 120, 85369, 85363, 3412, 85370, 22896, 22893, 131, 
22895, 85371, 85364, 3413, 3408
21764, 22784, 22783, 94, 93, 85307, 85305, 3369, 3367, 22809, 22808, 104, 22810, 85373, 85367, 3405, 
85374, 85372, 85365, 3404, 3399
21765, 85307, 85305, 3369, 3367, 85308, 85306, 3370, 3368, 85373, 85367, 3405, 85374, 85376, 85370, 3407, 
85377, 85375, 85368, 3406, 3401
21766, 85308, 85306, 3370, 3368, 22872, 22871, 120, 119, 85376, 85370, 3407, 85377, 22898, 22895, 130, 
22897, 85378, 85371, 3408, 3403
21767, 22785, 22784, 93, 92, 85309, 85307, 3367, 3365, 22811, 22810, 103, 22812, 85380, 85374, 3400, 
85381, 85379, 85372, 3399, 3394
21768, 85309, 85307, 3367, 3365, 85310, 85308, 3368, 3366, 85380, 85374, 3400, 85381, 85383, 85377, 3402, 
85384, 85382, 85375, 3401, 3396
21769, 85310, 85308, 3368, 3366, 22873, 22872, 119, 118, 85383, 85377, 3402, 85384, 22900, 22897, 129, 
22899, 85385, 85378, 3403, 3398
21770, 22786, 22785, 92, 91, 85311, 85309, 3365, 3363, 22813, 22812, 102, 22814, 85387, 85381, 3395, 
85388, 85386, 85379, 3394, 3389
21771, 85311, 85309, 3365, 3363, 85312, 85310, 3366, 3364, 85387, 85381, 3395, 85388, 85390, 85384, 3397, 
85391, 85389, 85382, 3396, 3391
21772, 85312, 85310, 3366, 3364, 22874, 22873, 118, 117, 85390, 85384, 3397, 85391, 22902, 22899, 128, 
22901, 85392, 85385, 3398, 3393
21773, 22787, 22786, 91, 90, 85313, 85311, 3363, 3361, 22815, 22814, 101, 22816, 85394, 85388, 3390, 
85395, 85393, 85386, 3389, 3384
21774, 85313, 85311, 3363, 3361, 85314, 85312, 3364, 3362, 85394, 85388, 3390, 85395, 85397, 85391, 3392, 
85398, 85396, 85389, 3391, 3386
21775, 85314, 85312, 3364, 3362, 22875, 22874, 117, 116, 85397, 85391, 3392, 85398, 22904, 22901, 127, 
22903, 85399, 85392, 3393, 3388
21776, 22788, 22787, 90, 89, 85315, 85313, 3361, 3359, 22817, 22816, 100, 22818, 85401, 85395, 3385, 
85402, 85400, 85393, 3384, 3379
21777, 85315, 85313, 3361, 3359, 85316, 85314, 3362, 3360, 85401, 85395, 3385, 85402, 85404, 85398, 3387, 
85405, 85403, 85396, 3386, 3381
21778, 85316, 85314, 3362, 3360, 22876, 22875, 116, 115, 85404, 85398, 3387, 85405, 22906, 22903, 126, 
22905, 85406, 85399, 3388, 3383
21779, 2153, 22788, 89, 2, 22940, 85315, 3359, 136, 22819, 22818, 99, 2155, 85407, 85402, 3380, 
22945, 22947, 85400, 3379, 138
21780, 22940, 85315, 3359, 136, 22939, 85316, 3360, 137, 85407, 85402, 3380, 22945, 85408, 85405, 3382, 
22943, 22946, 85403, 3381, 139
21781, 22939, 85316, 3360, 137, 2189, 22876, 115, 4, 85408, 85405, 3382, 22943, 22907, 22905, 125, 
2191, 22944, 85406, 3383, 140
21782, 22789, 2149, 2148, 22779, 85317, 22854, 22852, 85297, 22820, 2151, 22799, 22821, 85410, 22863, 85338, 
85411, 85409, 22864, 22859, 85337
21783, 85317, 22854, 22852, 85297, 85318, 22853, 22851, 85298, 85410, 22863, 85338, 85411, 85413, 22861, 85341, 
85414, 85412, 22862, 22857, 85340
21784, 85318, 22853, 22851, 85298, 22877, 2180, 2179, 22867, 85413, 22861, 85341, 85414, 22909, 2182, 22888, 
22908, 85415, 22860, 22855, 85343
21785, 22790, 22789, 22779, 22780, 85319, 85317, 85297, 85299, 22822, 22821, 22801, 22823, 85417, 85411, 85345, 
85418, 85416, 85409, 85337, 85344
21786, 85319, 85317, 85297, 85299, 85320, 85318, 85298, 85300, 85417, 85411, 85345, 85418, 85420, 85414, 85348, 
85421, 85419, 85412, 85340, 85347
21787, 85320, 85318, 85298, 85300, 22878, 22877, 22867, 22868, 85420, 85414, 85348, 85421, 22911, 22908, 22890, 
22910, 85422, 85415, 85343, 85350
21788, 22791, 22790, 22780, 22781, 85321, 85319, 85299, 85301, 22824, 22823, 22803, 22825, 85424, 85418, 85352, 
85425, 85423, 85416, 85344, 85351
21789, 85321, 85319, 85299, 85301, 85322, 85320, 85300, 85302, 85424, 85418, 85352, 85425, 85427, 85421, 85355, 
85428, 85426, 85419, 85347, 85354
21790, 85322, 85320, 85300, 85302, 22879, 22878, 22868, 22869, 85427, 85421, 85355, 85428, 22913, 22910, 22892, 
22912, 85429, 85422, 85350, 85357
21791, 22792, 22791, 22781, 22782, 85323, 85321, 85301, 85303, 22826, 22825, 22805, 22827, 85431, 85425, 85359, 
85432, 85430, 85423, 85351, 85358
21792, 85323, 85321, 85301, 85303, 85324, 85322, 85302, 85304, 85431, 85425, 85359, 85432, 85434, 85428, 85362, 
85435, 85433, 85426, 85354, 85361
21793, 85324, 85322, 85302, 85304, 22880, 22879, 22869, 22870, 85434, 85428, 85362, 85435, 22915, 22912, 22894, 
22914, 85436, 85429, 85357, 85364
21794, 22793, 22792, 22782, 22783, 85325, 85323, 85303, 85305, 22828, 22827, 22807, 22829, 85438, 85432, 85366, 
85439, 85437, 85430, 85358, 85365
21795, 85325, 85323, 85303, 85305, 85326, 85324, 85304, 85306, 85438, 85432, 85366, 85439, 85441, 85435, 85369, 
85442, 85440, 85433, 85361, 85368
21796, 85326, 85324, 85304, 85306, 22881, 22880, 22870, 22871, 85441, 85435, 85369, 85442, 22917, 22914, 22896, 
22916, 85443, 85436, 85364, 85371
21797, 22794, 22793, 22783, 22784, 85327, 85325, 85305, 85307, 22830, 22829, 22809, 22831, 85445, 85439, 85373, 
85446, 85444, 85437, 85365, 85372
21798, 85327, 85325, 85305, 85307, 85328, 85326, 85306, 85308, 85445, 85439, 85373, 85446, 85448, 85442, 85376, 
85449, 85447, 85440, 85368, 85375
21799, 85328, 85326, 85306, 85308, 22882, 22881, 22871, 22872, 85448, 85442, 85376, 85449, 22919, 22916, 22898, 
22918, 85450, 85443, 85371, 85378
21800, 22795, 22794, 22784, 22785, 85329, 85327, 85307, 85309, 22832, 22831, 22811, 22833, 85452, 85446, 85380, 
85453, 85451, 85444, 85372, 85379
21801, 85329, 85327, 85307, 85309, 85330, 85328, 85308, 85310, 85452, 85446, 85380, 85453, 85455, 85449, 85383, 
85456, 85454, 85447, 85375, 85382
21802, 85330, 85328, 85308, 85310, 22883, 22882, 22872, 22873, 85455, 85449, 85383, 85456, 22921, 22918, 22900, 
22920, 85457, 85450, 85378, 85385
21803, 22796, 22795, 22785, 22786, 85331, 85329, 85309, 85311, 22834, 22833, 22813, 22835, 85459, 85453, 85387, 
85460, 85458, 85451, 85379, 85386
21804, 85331, 85329, 85309, 85311, 85332, 85330, 85310, 85312, 85459, 85453, 85387, 85460, 85462, 85456, 85390, 
85463, 85461, 85454, 85382, 85389
21805, 85332, 85330, 85310, 85312, 22884, 22883, 22873, 22874, 85462, 85456, 85390, 85463, 22923, 22920, 22902, 
22922, 85464, 85457, 85385, 85392
21806, 22797, 22796, 22786, 22787, 85333, 85331, 85311, 85313, 22836, 22835, 22815, 22837, 85466, 85460, 85394, 
85467, 85465, 85458, 85386, 85393
21807, 85333, 85331, 85311, 85313, 85334, 85332, 85312, 85314, 85466, 85460, 85394, 85467, 85469, 85463, 85397, 
85470, 85468, 85461, 85389, 85396
21808, 85334, 85332, 85312, 85314, 22885, 22884, 22874, 22875, 85469, 85463, 85397, 85470, 22925, 22922, 22904, 
22924, 85471, 85464, 85392, 85399
21809, 22798, 22797, 22787, 22788, 85335, 85333, 85313, 85315, 22838, 22837, 22817, 22839, 85473, 85467, 85401, 
85474, 85472, 85465, 85393, 85400
21810, 85335, 85333, 85313, 85315, 85336, 85334, 85314, 85316, 85473, 85467, 85401, 85474, 85476, 85470, 85404, 
85477, 85475, 85468, 85396, 85403
21811, 85336, 85334, 85314, 85316, 22886, 22885, 22875, 22876, 85476, 85470, 85404, 85477, 22927, 22924, 22906, 
22926, 85478, 85471, 85399, 85406
21812, 2154, 22798, 22788, 2153, 22942, 85335, 85315, 22940, 22840, 22839, 22819, 2156, 85479, 85474, 85407, 
22950, 22952, 85472, 85400, 22947
21813, 22942, 85335, 85315, 22940, 22941, 85336, 85316, 22939, 85479, 85474, 85407, 22950, 85480, 85477, 85408, 
22948, 22951, 85475, 85403, 22946
21814, 22941, 85336, 85316, 22939, 2190, 22886, 22876, 2189, 85480, 85477, 85408, 22948, 22928, 22926, 22907, 
2192, 22949, 85478, 85406, 22944
21815, 2167, 51, 2149, 22789, 22973, 2184, 22854, 85317, 2178, 2152, 22820, 22841, 23025, 22866, 85410, 
85481, 23020, 2186, 22864, 85409
21816, 22973, 2184, 22854, 85317, 22974, 2185, 22853, 85318, 23025, 22866, 85410, 85481, 23026, 22865, 85413, 
85482, 23022, 2187, 22862, 85412
21817, 22974, 2185, 22853, 85318, 2203, 53, 2180, 22877, 23026, 22865, 85413, 85482, 2214, 2183, 22909, 
22929, 23024, 2188, 22860, 85415
21818, 2166, 2167, 22789, 22790, 22971, 22973, 85317, 85319, 2177, 22841, 22822, 22842, 23021, 85481, 85417, 
85483, 23015, 23020, 85409, 85416
21819, 22971, 22973, 85317, 85319, 22972, 22974, 85318, 85320, 23021, 85481, 85417, 85483, 23023, 85482, 85420, 
85484, 23017, 23022, 85412, 85419
21820, 22972, 22974, 85318, 85320, 2202, 2203, 22877, 22878, 23023, 85482, 85420, 85484, 2213, 22929, 22911, 
22930, 23019, 23024, 85415, 85422
21821, 2165, 2166, 22790, 22791, 22969, 22971, 85319, 85321, 2176, 22842, 22824, 22843, 23016, 85483, 85424, 
85485, 23010, 23015, 85416, 85423
21822, 22969, 22971, 85319, 85321, 22970, 22972, 85320, 85322, 23016, 85483, 85424, 85485, 23018, 85484, 85427, 
85486, 23012, 23017, 85419, 85426
21823, 22970, 22972, 85320, 85322, 2201, 2202, 22878, 22879, 23018, 85484, 85427, 85486, 2212, 22930, 22913, 
22931, 23014, 23019, 85422, 85429
21824, 2164, 2165, 22791, 22792, 22967, 22969, 85321, 85323, 2175, 22843, 22826, 22844, 23011, 85485, 85431, 
85487, 23005, 23010, 85423, 85430
21825, 22967, 22969, 85321, 85323, 22968, 22970, 85322, 85324, 23011, 85485, 85431, 85487, 23013, 85486, 85434, 
85488, 23007, 23012, 85426, 85433
21826, 22968, 22970, 85322, 85324, 2200, 2201, 22879, 22880, 23013, 85486, 85434, 85488, 2211, 22931, 22915, 
22932, 23009, 23014, 85429, 85436
21827, 2163, 2164, 22792, 22793, 22965, 22967, 85323, 85325, 2174, 22844, 22828, 22845, 23006, 85487, 85438, 
85489, 23000, 23005, 85430, 85437
21828, 22965, 22967, 85323, 85325, 22966, 22968, 85324, 85326, 23006, 85487, 85438, 85489, 23008, 85488, 85441, 
85490, 23002, 23007, 85433, 85440
21829, 22966, 22968, 85324, 85326, 2199, 2200, 22880, 22881, 23008, 85488, 85441, 85490, 2210, 22932, 22917, 
22933, 23004, 23009, 85436, 85443
21830, 2162, 2163, 22793, 22794, 22963, 22965, 85325, 85327, 2173, 22845, 22830, 22846, 23001, 85489, 85445, 
85491, 22995, 23000, 85437, 85444
21831, 22963, 22965, 85325, 85327, 22964, 22966, 85326, 85328, 23001, 85489, 85445, 85491, 23003, 85490, 85448, 
85492, 22997, 23002, 85440, 85447
21832, 22964, 22966, 85326, 85328, 2198, 2199, 22881, 22882, 23003, 85490, 85448, 85492, 2209, 22933, 22919, 
22934, 22999, 23004, 85443, 85450
21833, 2161, 2162, 22794, 22795, 22961, 22963, 85327, 85329, 2172, 22846, 22832, 22847, 22996, 85491, 85452, 
85493, 22990, 22995, 85444, 85451
21834, 22961, 22963, 85327, 85329, 22962, 22964, 85328, 85330, 22996, 85491, 85452, 85493, 22998, 85492, 85455, 
85494, 22992, 22997, 85447, 85454
21835, 22962, 22964, 85328, 85330, 2197, 2198, 22882, 22883, 22998, 85492, 85455, 85494, 2208, 22934, 22921, 
22935, 22994, 22999, 85450, 85457
21836, 2160, 2161, 22795, 22796, 22959, 22961, 85329, 85331, 2171, 22847, 22834, 22848, 22991, 85493, 85459, 
85495, 22985, 22990, 85451, 85458
21837, 22959, 22961, 85329, 85331, 22960, 22962, 85330, 85332, 22991, 85493, 85459, 85495, 22993, 85494, 85462, 
85496, 22987, 22992, 85454, 85461
21838, 22960, 22962, 85330, 85332, 2196, 2197, 22883, 22884, 22993, 85494, 85462, 85496, 2207, 22935, 22923, 
22936, 22989, 22994, 85457, 85464
21839, 2159, 2160, 22796, 22797, 22957, 22959, 85331, 85333, 2170, 22848, 22836, 22849, 22986, 85495, 85466, 
85497, 22980, 22985, 85458, 85465
21840, 22957, 22959, 85331, 85333, 22958, 22960, 85332, 85334, 22986, 85495, 85466, 85497, 22988, 85496, 85469, 
85498, 22982, 22987, 85461, 85468
21841, 22958, 22960, 85332, 85334, 2195, 2196, 22884, 22885, 22988, 85496, 85469, 85498, 2206, 22936, 22925, 
22937, 22984, 22989, 85464, 85471
21842, 2158, 2159, 22797, 22798, 22955, 22957, 85333, 85335, 2169, 22849, 22838, 22850, 22981, 85497, 85473, 
85499, 22975, 22980, 85465, 85472
21843, 22955, 22957, 85333, 85335, 22956, 22958, 85334, 85336, 22981, 85497, 85473, 85499, 22983, 85498, 85476, 
85500, 22977, 22982, 85468, 85475
21844, 22956, 22958, 85334, 85336, 2194, 2195, 22885, 22886, 22983, 85498, 85476, 85500, 2205, 22937, 22927, 
22938, 22979, 22984, 85471, 85478
21845, 52, 2158, 22798, 2154, 2215, 22955, 85335, 22942, 2168, 22850, 22840, 2157, 22976, 85499, 85479, 
22954, 2217, 22975, 85472, 22952
21846, 2215, 22955, 85335, 22942, 2216, 22956, 85336, 22941, 22976, 85499, 85479, 22954, 22978, 85500, 85480, 
22953, 2218, 22977, 85475, 22951
21847, 2216, 22956, 85336, 22941, 54, 2194, 22886, 2190, 22978, 85500, 85480, 22953, 2204, 22938, 22928, 
2193, 2219, 22979, 85478, 22949
*ELEMENT, type=C3D20, ELSET=Volume20
21848, 21, 2220, 23027, 1004, 1033, 23259, 85501, 12837, 2223, 23094, 23093, 1027, 23298, 86162, 86163, 
13309, 1043, 23300, 86161, 13289
21849, 1033, 23259, 85501, 12837, 1034, 23258, 85502, 12838, 23298, 86162, 86163, 13309, 23296, 86165, 86166, 
13310, 1044, 23299, 86164, 13291
21850, 1034, 23258, 85502, 12838, 1035, 23257, 85503, 12839, 23296, 86165, 86166, 13310, 23294, 86168, 86169, 
13311, 1045, 23297, 86167, 13293
21851, 1035, 23257, 85503, 12839, 1036, 23256, 85504, 12840, 23294, 86168, 86169, 13311, 23292, 86171, 86172, 
13312, 1046, 23295, 86170, 13295
21852, 1036, 23256, 85504, 12840, 1037, 23255, 85505, 12841, 23292, 86171, 86172, 13312, 23290, 86174, 86175, 
13313, 1047, 23293, 86173, 13297
21853, 1037, 23255, 85505, 12841, 1038, 23254, 85506, 12842, 23290, 86174, 86175, 13313, 23288, 86177, 86178, 
13314, 1048, 23291, 86176, 13299
21854, 1038, 23254, 85506, 12842, 1039, 23253, 85507, 12843, 23288, 86177, 86178, 13314, 23286, 86180, 86181, 
13315, 1049, 23289, 86179, 13301
21855, 1039, 23253, 85507, 12843, 1040, 23252, 85508, 12844, 23286, 86180, 86181, 13315, 23284, 86183, 86184, 
13316, 1050, 23287, 86182, 13303
21856, 1040, 23252, 85508, 12844, 1041, 23251, 85509, 12845, 23284, 86183, 86184, 13316, 23282, 86186, 86187, 
13317, 1051, 23285, 86185, 13305
21857, 1041, 23251, 85509, 12845, 1042, 23250, 85510, 12846, 23282, 86186, 86187, 13317, 23280, 86189, 86190, 
13318, 1052, 23283, 86188, 13307
21858, 1042, 23250, 85510, 12846, 23, 2279, 23353, 1080, 23280, 86189, 86190, 13318, 2282, 23419, 23420, 
1103, 1053, 23281, 86191, 13308
21859, 1004, 23027, 23028, 1003, 12837, 85501, 85511, 12827, 23093, 23096, 23095, 1026, 86163, 86193, 86194, 
13288, 13289, 86161, 86192, 13268
21860, 12837, 85501, 85511, 12827, 12838, 85502, 85512, 12828, 86163, 86193, 86194, 13288, 86166, 86196, 86197, 
13290, 13291, 86164, 86195, 13270
21861, 12838, 85502, 85512, 12828, 12839, 85503, 85513, 12829, 86166, 86196, 86197, 13290, 86169, 86199, 86200, 
13292, 13293, 86167, 86198, 13272
21862, 12839, 85503, 85513, 12829, 12840, 85504, 85514, 12830, 86169, 86199, 86200, 13292, 86172, 86202, 86203, 
13294, 13295, 86170, 86201, 13274
21863, 12840, 85504, 85514, 12830, 12841, 85505, 85515, 12831, 86172, 86202, 86203, 13294, 86175, 86205, 86206, 
13296, 13297, 86173, 86204, 13276
21864, 12841, 85505, 85515, 12831, 12842, 85506, 85516, 12832, 86175, 86205, 86206, 13296, 86178, 86208, 86209, 
13298, 13299, 86176, 86207, 13278
21865, 12842, 85506, 85516, 12832, 12843, 85507, 85517, 12833, 86178, 86208, 86209, 13298, 86181, 86211, 86212, 
13300, 13301, 86179, 86210, 13280
21866, 12843, 85507, 85517, 12833, 12844, 85508, 85518, 12834, 86181, 86211, 86212, 13300, 86184, 86214, 86215, 
13302, 13303, 86182, 86213, 13282
21867, 12844, 85508, 85518, 12834, 12845, 85509, 85519, 12835, 86184, 86214, 86215, 13302, 86187, 86217, 86218, 
13304, 13305, 86185, 86216, 13284
21868, 12845, 85509, 85519, 12835, 12846, 85510, 85520, 12836, 86187, 86217, 86218, 13304, 86190, 86220, 86221, 
13306, 13307, 86188, 86219, 13286
21869, 12846, 85510, 85520, 12836, 1080, 23353, 23354, 1079, 86190, 86220, 86221, 13306, 23420, 23421, 23422, 
1102, 13308, 86191, 86222, 13287
21870, 1003, 23028, 23029, 1002, 12827, 85511, 85521, 12817, 23095, 23098, 23097, 1025, 86194, 86224, 86225, 
13267, 13268, 86192, 86223, 13247
21871, 12827, 85511, 85521, 12817, 12828, 85512, 85522, 12818, 86194, 86224, 86225, 13267, 86197, 86227, 86228, 
13269, 13270, 86195, 86226, 13249
21872, 12828, 85512, 85522, 12818, 12829, 85513, 85523, 12819, 86197, 86227, 86228, 13269, 86200, 86230, 86231, 
13271, 13272, 86198, 86229, 13251
21873, 12829, 85513, 85523, 12819, 12830, 85514, 85524, 12820, 86200, 86230, 86231, 13271, 86203, 86233, 86234, 
13273, 13274, 86201, 86232, 13253
21874, 12830, 85514, 85524, 12820, 12831, 85515, 85525, 12821, 86203, 86233, 86234, 13273, 86206, 86236, 86237, 
13275, 13276, 86204, 86235, 13255
21875, 12831, 85515, 85525, 12821, 12832, 85516, 85526, 12822, 86206, 86236, 86237, 13275, 86209, 86239, 86240, 
13277, 13278, 86207, 86238, 13257
21876, 12832, 85516, 85526, 12822, 12833, 85517, 85527, 12823, 86209, 86239, 86240, 13277, 86212, 86242, 86243, 
13279, 13280, 86210, 86241, 13259
21877, 12833, 85517, 85527, 12823, 12834, 85518, 85528, 12824, 86212, 86242, 86243, 13279, 86215, 86245, 86246, 
13281, 13282, 86213, 86244, 13261
21878, 12834, 85518, 85528, 12824, 12835, 85519, 85529, 12825, 86215, 86245, 86246, 13281, 86218, 86248, 86249, 
13283, 13284, 86216, 86247, 13263
21879, 12835, 85519, 85529, 12825, 12836, 85520, 85530, 12826, 86218, 86248, 86249, 13283, 86221, 86251, 86252, 
13285, 13286, 86219, 86250, 13265
21880, 12836, 85520, 85530, 12826, 1079, 23354, 23355, 1078, 86221, 86251, 86252, 13285, 23422, 23423, 23424, 
1101, 13287, 86222, 86253, 13266
21881, 1002, 23029, 23030, 1001, 12817, 85521, 85531, 12807, 23097, 23100, 23099, 1024, 86225, 86255, 86256, 
13246, 13247, 86223, 86254, 13226
21882, 12817, 85521, 85531, 12807, 12818, 85522, 85532, 12808, 86225, 86255, 86256, 13246, 86228, 86258, 86259, 
13248, 13249, 86226, 86257, 13228
21883, 12818, 85522, 85532, 12808, 12819, 85523, 85533, 12809, 86228, 86258, 86259, 13248, 86231, 86261, 86262, 
13250, 13251, 86229, 86260, 13230
21884, 12819, 85523, 85533, 12809, 12820, 85524, 85534, 12810, 86231, 86261, 86262, 13250, 86234, 86264, 86265, 
13252, 13253, 86232, 86263, 13232
21885, 12820, 85524, 85534, 12810, 12821, 85525, 85535, 12811, 86234, 86264, 86265, 13252, 86237, 86267, 86268, 
13254, 13255, 86235, 86266, 13234
21886, 12821, 85525, 85535, 12811, 12822, 85526, 85536, 12812, 86237, 86267, 86268, 13254, 86240, 86270, 86271, 
13256, 13257, 86238, 86269, 13236
21887, 12822, 85526, 85536, 12812, 12823, 85527, 85537, 12813, 86240, 86270, 86271, 13256, 86243, 86273, 86274, 
13258, 13259, 86241, 86272, 13238
21888, 12823, 85527, 85537, 12813, 12824, 85528, 85538, 12814, 86243, 86273, 86274, 13258, 86246, 86276, 86277, 
13260, 13261, 86244, 86275, 13240
21889, 12824, 85528, 85538, 12814, 12825, 85529, 85539, 12815, 86246, 86276, 86277, 13260, 86249, 86279, 86280, 
13262, 13263, 86247, 86278, 13242
21890, 12825, 85529, 85539, 12815, 12826, 85530, 85540, 12816, 86249, 86279, 86280, 13262, 86252, 86282, 86283, 
13264, 13265, 86250, 86281, 13244
21891, 12826, 85530, 85540, 12816, 1078, 23355, 23356, 1077, 86252, 86282, 86283, 13264, 23424, 23425, 23426, 
1100, 13266, 86253, 86284, 13245
21892, 1001, 23030, 23031, 1000, 12807, 85531, 85541, 12797, 23099, 23102, 23101, 1023, 86256, 86286, 86287, 
13225, 13226, 86254, 86285, 13205
21893, 12807, 85531, 85541, 12797, 12808, 85532, 85542, 12798, 86256, 86286, 86287, 13225, 86259, 86289, 86290, 
13227, 13228, 86257, 86288, 13207
21894, 12808, 85532, 85542, 12798, 12809, 85533, 85543, 12799, 86259, 86289, 86290, 13227, 86262, 86292, 86293, 
13229, 13230, 86260, 86291, 13209
21895, 12809, 85533, 85543, 12799, 12810, 85534, 85544, 12800, 86262, 86292, 86293, 13229, 86265, 86295, 86296, 
13231, 13232, 86263, 86294, 13211
21896, 12810, 85534, 85544, 12800, 12811, 85535, 85545, 12801, 86265, 86295, 86296, 13231, 86268, 86298, 86299, 
13233, 13234, 86266, 86297, 13213
21897, 12811, 85535, 85545, 12801, 12812, 85536, 85546, 12802, 86268, 86298, 86299, 13233, 86271, 86301, 86302, 
13235, 13236, 86269, 86300, 13215
21898, 12812, 85536, 85546, 12802, 12813, 85537, 85547, 12803, 86271, 86301, 86302, 13235, 86274, 86304, 86305, 
13237, 13238, 86272, 86303, 13217
21899, 12813, 85537, 85547, 12803, 12814, 85538, 85548, 12804, 86274, 86304, 86305, 13237, 86277, 86307, 86308, 
13239, 13240, 86275, 86306, 13219
21900, 12814, 85538, 85548, 12804, 12815, 85539, 85549, 12805, 86277, 86307, 86308, 13239, 86280, 86310, 86311, 
13241, 13242, 86278, 86309, 13221
21901, 12815, 85539, 85549, 12805, 12816, 85540, 85550, 12806, 86280, 86310, 86311, 13241, 86283, 86313, 86314, 
13243, 13244, 86281, 86312, 13223
21902, 12816, 85540, 85550, 12806, 1077, 23356, 23357, 1076, 86283, 86313, 86314, 13243, 23426, 23427, 23428, 
1099, 13245, 86284, 86315, 13224
21903, 1000, 23031, 23032, 999, 12797, 85541, 85551, 12787, 23101, 23104, 23103, 1022, 86287, 86317, 86318, 
13204, 13205, 86285, 86316, 13184
21904, 12797, 85541, 85551, 12787, 12798, 85542, 85552, 12788, 86287, 86317, 86318, 13204, 86290, 86320, 86321, 
13206, 13207, 86288, 86319, 13186
21905, 12798, 85542, 85552, 12788, 12799, 85543, 85553, 12789, 86290, 86320, 86321, 13206, 86293, 86323, 86324, 
13208, 13209, 86291, 86322, 13188
21906, 12799, 85543, 85553, 12789, 12800, 85544, 85554, 12790, 86293, 86323, 86324, 13208, 86296, 86326, 86327, 
13210, 13211, 86294, 86325, 13190
21907, 12800, 85544, 85554, 12790, 12801, 85545, 85555, 12791, 86296, 86326, 86327, 13210, 86299, 86329, 86330, 
13212, 13213, 86297, 86328, 13192
21908, 12801, 85545, 85555, 12791, 12802, 85546, 85556, 12792, 86299, 86329, 86330, 13212, 86302, 86332, 86333, 
13214, 13215, 86300, 86331, 13194
21909, 12802, 85546, 85556, 12792, 12803, 85547, 85557, 12793, 86302, 86332, 86333, 13214, 86305, 86335, 86336, 
13216, 13217, 86303, 86334, 13196
21910, 12803, 85547, 85557, 12793, 12804, 85548, 85558, 12794, 86305, 86335, 86336, 13216, 86308, 86338, 86339, 
13218, 13219, 86306, 86337, 13198
21911, 12804, 85548, 85558, 12794, 12805, 85549, 85559, 12795, 86308, 86338, 86339, 13218, 86311, 86341, 86342, 
13220, 13221, 86309, 86340, 13200
21912, 12805, 85549, 85559, 12795, 12806, 85550, 85560, 12796, 86311, 86341, 86342, 13220, 86314, 86344, 86345, 
13222, 13223, 86312, 86343, 13202
21913, 12806, 85550, 85560, 12796, 1076, 23357, 23358, 1075, 86314, 86344, 86345, 13222, 23428, 23429, 23430, 
1098, 13224, 86315, 86346, 13203
21914, 999, 23032, 23033, 998, 12787, 85551, 85561, 12777, 23103, 23106, 23105, 1021, 86318, 86348, 86349, 
13183, 13184, 86316, 86347, 13163
21915, 12787, 85551, 85561, 12777, 12788, 85552, 85562, 12778, 86318, 86348, 86349, 13183, 86321, 86351, 86352, 
13185, 13186, 86319, 86350, 13165
21916, 12788, 85552, 85562, 12778, 12789, 85553, 85563, 12779, 86321, 86351, 86352, 13185, 86324, 86354, 86355, 
13187, 13188, 86322, 86353, 13167
21917, 12789, 85553, 85563, 12779, 12790, 85554, 85564, 12780, 86324, 86354, 86355, 13187, 86327, 86357, 86358, 
13189, 13190, 86325, 86356, 13169
21918, 12790, 85554, 85564, 12780, 12791, 85555, 85565, 12781, 86327, 86357, 86358, 13189, 86330, 86360, 86361, 
13191, 13192, 86328, 86359, 13171
21919, 12791, 85555, 85565, 12781, 12792, 85556, 85566, 12782, 86330, 86360, 86361, 13191, 86333, 86363, 86364, 
13193, 13194, 86331, 86362, 13173
21920, 12792, 85556, 85566, 12782, 12793, 85557, 85567, 12783, 86333, 86363, 86364, 13193, 86336, 86366, 86367, 
13195, 13196, 86334, 86365, 13175
21921, 12793, 85557, 85567, 12783, 12794, 85558, 85568, 12784, 86336, 86366, 86367, 13195, 86339, 86369, 86370, 
13197, 13198, 86337, 86368, 13177
21922, 12794, 85558, 85568, 12784, 12795, 85559, 85569, 12785, 86339, 86369, 86370, 13197, 86342, 86372, 86373, 
13199, 13200, 86340, 86371, 13179
21923, 12795, 85559, 85569, 12785, 12796, 85560, 85570, 12786, 86342, 86372, 86373, 13199, 86345, 86375, 86376, 
13201, 13202, 86343, 86374, 13181
21924, 12796, 85560, 85570, 12786, 1075, 23358, 23359, 1074, 86345, 86375, 86376, 13201, 23430, 23431, 23432, 
1097, 13203, 86346, 86377, 13182
21925, 998, 23033, 23034, 997, 12777, 85561, 85571, 12767, 23105, 23108, 23107, 1020, 86349, 86379, 86380, 
13162, 13163, 86347, 86378, 13142
21926, 12777, 85561, 85571, 12767, 12778, 85562, 85572, 12768, 86349, 86379, 86380, 13162, 86352, 86382, 86383, 
13164, 13165, 86350, 86381, 13144
21927, 12778, 85562, 85572, 12768, 12779, 85563, 85573, 12769, 86352, 86382, 86383, 13164, 86355, 86385, 86386, 
13166, 13167, 86353, 86384, 13146
21928, 12779, 85563, 85573, 12769, 12780, 85564, 85574, 12770, 86355, 86385, 86386, 13166, 86358, 86388, 86389, 
13168, 13169, 86356, 86387, 13148
21929, 12780, 85564, 85574, 12770, 12781, 85565, 85575, 12771, 86358, 86388, 86389, 13168, 86361, 86391, 86392, 
13170, 13171, 86359, 86390, 13150
21930, 12781, 85565, 85575, 12771, 12782, 85566, 85576, 12772, 86361, 86391, 86392, 13170, 86364, 86394, 86395, 
13172, 13173, 86362, 86393, 13152
21931, 12782, 85566, 85576, 12772, 12783, 85567, 85577, 12773, 86364, 86394, 86395, 13172, 86367, 86397, 86398, 
13174, 13175, 86365, 86396, 13154
21932, 12783, 85567, 85577, 12773, 12784, 85568, 85578, 12774, 86367, 86397, 86398, 13174, 86370, 86400, 86401, 
13176, 13177, 86368, 86399, 13156
21933, 12784, 85568, 85578, 12774, 12785, 85569, 85579, 12775, 86370, 86400, 86401, 13176, 86373, 86403, 86404, 
13178, 13179, 86371, 86402, 13158
21934, 12785, 85569, 85579, 12775, 12786, 85570, 85580, 12776, 86373, 86403, 86404, 13178, 86376, 86406, 86407, 
13180, 13181, 86374, 86405, 13160
21935, 12786, 85570, 85580, 12776, 1074, 23359, 23360, 1073, 86376, 86406, 86407, 13180, 23432, 23433, 23434, 
1096, 13182, 86377, 86408, 13161
21936, 997, 23034, 23035, 996, 12767, 85571, 85581, 12757, 23107, 23110, 23109, 1019, 86380, 86410, 86411, 
13141, 13142, 86378, 86409, 13121
21937, 12767, 85571, 85581, 12757, 12768, 85572, 85582, 12758, 86380, 86410, 86411, 13141, 86383, 86413, 86414, 
13143, 13144, 86381, 86412, 13123
21938, 12768, 85572, 85582, 12758, 12769, 85573, 85583, 12759, 86383, 86413, 86414, 13143, 86386, 86416, 86417, 
13145, 13146, 86384, 86415, 13125
21939, 12769, 85573, 85583, 12759, 12770, 85574, 85584, 12760, 86386, 86416, 86417, 13145, 86389, 86419, 86420, 
13147, 13148, 86387, 86418, 13127
21940, 12770, 85574, 85584, 12760, 12771, 85575, 85585, 12761, 86389, 86419, 86420, 13147, 86392, 86422, 86423, 
13149, 13150, 86390, 86421, 13129
21941, 12771, 85575, 85585, 12761, 12772, 85576, 85586, 12762, 86392, 86422, 86423, 13149, 86395, 86425, 86426, 
13151, 13152, 86393, 86424, 13131
21942, 12772, 85576, 85586, 12762, 12773, 85577, 85587, 12763, 86395, 86425, 86426, 13151, 86398, 86428, 86429, 
13153, 13154, 86396, 86427, 13133
21943, 12773, 85577, 85587, 12763, 12774, 85578, 85588, 12764, 86398, 86428, 86429, 13153, 86401, 86431, 86432, 
13155, 13156, 86399, 86430, 13135
21944, 12774, 85578, 85588, 12764, 12775, 85579, 85589, 12765, 86401, 86431, 86432, 13155, 86404, 86434, 86435, 
13157, 13158, 86402, 86433, 13137
21945, 12775, 85579, 85589, 12765, 12776, 85580, 85590, 12766, 86404, 86434, 86435, 13157, 86407, 86437, 86438, 
13159, 13160, 86405, 86436, 13139
21946, 12776, 85580, 85590, 12766, 1073, 23360, 23361, 1072, 86407, 86437, 86438, 13159, 23434, 23435, 23436, 
1095, 13161, 86408, 86439, 13140
21947, 996, 23035, 23036, 995, 12757, 85581, 85591, 12747, 23109, 23112, 23111, 1018, 86411, 86441, 86442, 
13120, 13121, 86409, 86440, 13100
21948, 12757, 85581, 85591, 12747, 12758, 85582, 85592, 12748, 86411, 86441, 86442, 13120, 86414, 86444, 86445, 
13122, 13123, 86412, 86443, 13102
21949, 12758, 85582, 85592, 12748, 12759, 85583, 85593, 12749, 86414, 86444, 86445, 13122, 86417, 86447, 86448, 
13124, 13125, 86415, 86446, 13104
21950, 12759, 85583, 85593, 12749, 12760, 85584, 85594, 12750, 86417, 86447, 86448, 13124, 86420, 86450, 86451, 
13126, 13127, 86418, 86449, 13106
21951, 12760, 85584, 85594, 12750, 12761, 85585, 85595, 12751, 86420, 86450, 86451, 13126, 86423, 86453, 86454, 
13128, 13129, 86421, 86452, 13108
21952, 12761, 85585, 85595, 12751, 12762, 85586, 85596, 12752, 86423, 86453, 86454, 13128, 86426, 86456, 86457, 
13130, 13131, 86424, 86455, 13110
21953, 12762, 85586, 85596, 12752, 12763, 85587, 85597, 12753, 86426, 86456, 86457, 13130, 86429, 86459, 86460, 
13132, 13133, 86427, 86458, 13112
21954, 12763, 85587, 85597, 12753, 12764, 85588, 85598, 12754, 86429, 86459, 86460, 13132, 86432, 86462, 86463, 
13134, 13135, 86430, 86461, 13114
21955, 12764, 85588, 85598, 12754, 12765, 85589, 85599, 12755, 86432, 86462, 86463, 13134, 86435, 86465, 86466, 
13136, 13137, 86433, 86464, 13116
21956, 12765, 85589, 85599, 12755, 12766, 85590, 85600, 12756, 86435, 86465, 86466, 13136, 86438, 86468, 86469, 
13138, 13139, 86436, 86467, 13118
21957, 12766, 85590, 85600, 12756, 1072, 23361, 23362, 1071, 86438, 86468, 86469, 13138, 23436, 23437, 23438, 
1094, 13140, 86439, 86470, 13119
21958, 995, 23036, 23037, 994, 12747, 85591, 85601, 12737, 23111, 23114, 23113, 1017, 86442, 86472, 86473, 
13099, 13100, 86440, 86471, 13079
21959, 12747, 85591, 85601, 12737, 12748, 85592, 85602, 12738, 86442, 86472, 86473, 13099, 86445, 86475, 86476, 
13101, 13102, 86443, 86474, 13081
21960, 12748, 85592, 85602, 12738, 12749, 85593, 85603, 12739, 86445, 86475, 86476, 13101, 86448, 86478, 86479, 
13103, 13104, 86446, 86477, 13083
21961, 12749, 85593, 85603, 12739, 12750, 85594, 85604, 12740, 86448, 86478, 86479, 13103, 86451, 86481, 86482, 
13105, 13106, 86449, 86480, 13085
21962, 12750, 85594, 85604, 12740, 12751, 85595, 85605, 12741, 86451, 86481, 86482, 13105, 86454, 86484, 86485, 
13107, 13108, 86452, 86483, 13087
21963, 12751, 85595, 85605, 12741, 12752, 85596, 85606, 12742, 86454, 86484, 86485, 13107, 86457, 86487, 86488, 
13109, 13110, 86455, 86486, 13089
21964, 12752, 85596, 85606, 12742, 12753, 85597, 85607, 12743, 86457, 86487, 86488, 13109, 86460, 86490, 86491, 
13111, 13112, 86458, 86489, 13091
21965, 12753, 85597, 85607, 12743, 12754, 85598, 85608, 12744, 86460, 86490, 86491, 13111, 86463, 86493, 86494, 
13113, 13114, 86461, 86492, 13093
21966, 12754, 85598, 85608, 12744, 12755, 85599, 85609, 12745, 86463, 86493, 86494, 13113, 86466, 86496, 86497, 
13115, 13116, 86464, 86495, 13095
21967, 12755, 85599, 85609, 12745, 12756, 85600, 85610, 12746, 86466, 86496, 86497, 13115, 86469, 86499, 86500, 
13117, 13118, 86467, 86498, 13097
21968, 12756, 85600, 85610, 12746, 1071, 23362, 23363, 1070, 86469, 86499, 86500, 13117, 23438, 23439, 23440, 
1093, 13119, 86470, 86501, 13098
21969, 994, 23037, 23038, 993, 12737, 85601, 85611, 12727, 23113, 23116, 23115, 1016, 86473, 86503, 86504, 
13078, 13079, 86471, 86502, 13058
21970, 12737, 85601, 85611, 12727, 12738, 85602, 85612, 12728, 86473, 86503, 86504, 13078, 86476, 86506, 86507, 
13080, 13081, 86474, 86505, 13060
21971, 12738, 85602, 85612, 12728, 12739, 85603, 85613, 12729, 86476, 86506, 86507, 13080, 86479, 86509, 86510, 
13082, 13083, 86477, 86508, 13062
21972, 12739, 85603, 85613, 12729, 12740, 85604, 85614, 12730, 86479, 86509, 86510, 13082, 86482, 86512, 86513, 
13084, 13085, 86480, 86511, 13064
21973, 12740, 85604, 85614, 12730, 12741, 85605, 85615, 12731, 86482, 86512, 86513, 13084, 86485, 86515, 86516, 
13086, 13087, 86483, 86514, 13066
21974, 12741, 85605, 85615, 12731, 12742, 85606, 85616, 12732, 86485, 86515, 86516, 13086, 86488, 86518, 86519, 
13088, 13089, 86486, 86517, 13068
21975, 12742, 85606, 85616, 12732, 12743, 85607, 85617, 12733, 86488, 86518, 86519, 13088, 86491, 86521, 86522, 
13090, 13091, 86489, 86520, 13070
21976, 12743, 85607, 85617, 12733, 12744, 85608, 85618, 12734, 86491, 86521, 86522, 13090, 86494, 86524, 86525, 
13092, 13093, 86492, 86523, 13072
21977, 12744, 85608, 85618, 12734, 12745, 85609, 85619, 12735, 86494, 86524, 86525, 13092, 86497, 86527, 86528, 
13094, 13095, 86495, 86526, 13074
21978, 12745, 85609, 85619, 12735, 12746, 85610, 85620, 12736, 86497, 86527, 86528, 13094, 86500, 86530, 86531, 
13096, 13097, 86498, 86529, 13076
21979, 12746, 85610, 85620, 12736, 1070, 23363, 23364, 1069, 86500, 86530, 86531, 13096, 23440, 23441, 23442, 
1092, 13098, 86501, 86532, 13077
21980, 993, 23038, 23039, 992, 12727, 85611, 85621, 12717, 23115, 23118, 23117, 1015, 86504, 86534, 86535, 
13057, 13058, 86502, 86533, 13037
21981, 12727, 85611, 85621, 12717, 12728, 85612, 85622, 12718, 86504, 86534, 86535, 13057, 86507, 86537, 86538, 
13059, 13060, 86505, 86536, 13039
21982, 12728, 85612, 85622, 12718, 12729, 85613, 85623, 12719, 86507, 86537, 86538, 13059, 86510, 86540, 86541, 
13061, 13062, 86508, 86539, 13041
21983, 12729, 85613, 85623, 12719, 12730, 85614, 85624, 12720, 86510, 86540, 86541, 13061, 86513, 86543, 86544, 
13063, 13064, 86511, 86542, 13043
21984, 12730, 85614, 85624, 12720, 12731, 85615, 85625, 12721, 86513, 86543, 86544, 13063, 86516, 86546, 86547, 
13065, 13066, 86514, 86545, 13045
21985, 12731, 85615, 85625, 12721, 12732, 85616, 85626, 12722, 86516, 86546, 86547, 13065, 86519, 86549, 86550, 
13067, 13068, 86517, 86548, 13047
21986, 12732, 85616, 85626, 12722, 12733, 85617, 85627, 12723, 86519, 86549, 86550, 13067, 86522, 86552, 86553, 
13069, 13070, 86520, 86551, 13049
21987, 12733, 85617, 85627, 12723, 12734, 85618, 85628, 12724, 86522, 86552, 86553, 13069, 86525, 86555, 86556, 
13071, 13072, 86523, 86554, 13051
21988, 12734, 85618, 85628, 12724, 12735, 85619, 85629, 12725, 86525, 86555, 86556, 13071, 86528, 86558, 86559, 
13073, 13074, 86526, 86557, 13053
21989, 12735, 85619, 85629, 12725, 12736, 85620, 85630, 12726, 86528, 86558, 86559, 13073, 86531, 86561, 86562, 
13075, 13076, 86529, 86560, 13055
21990, 12736, 85620, 85630, 12726, 1069, 23364, 23365, 1068, 86531, 86561, 86562, 13075, 23442, 23443, 23444, 
1091, 13077, 86532, 86563, 13056
21991, 992, 23039, 23040, 991, 12717, 85621, 85631, 12707, 23117, 23120, 23119, 1014, 86535, 86565, 86566, 
13036, 13037, 86533, 86564, 13016
21992, 12717, 85621, 85631, 12707, 12718, 85622, 85632, 12708, 86535, 86565, 86566, 13036, 86538, 86568, 86569, 
13038, 13039, 86536, 86567, 13018
21993, 12718, 85622, 85632, 12708, 12719, 85623, 85633, 12709, 86538, 86568, 86569, 13038, 86541, 86571, 86572, 
13040, 13041, 86539, 86570, 13020
21994, 12719, 85623, 85633, 12709, 12720, 85624, 85634, 12710, 86541, 86571, 86572, 13040, 86544, 86574, 86575, 
13042, 13043, 86542, 86573, 13022
21995, 12720, 85624, 85634, 12710, 12721, 85625, 85635, 12711, 86544, 86574, 86575, 13042, 86547, 86577, 86578, 
13044, 13045, 86545, 86576, 13024
21996, 12721, 85625, 85635, 12711, 12722, 85626, 85636, 12712, 86547, 86577, 86578, 13044, 86550, 86580, 86581, 
13046, 13047, 86548, 86579, 13026
21997, 12722, 85626, 85636, 12712, 12723, 85627, 85637, 12713, 86550, 86580, 86581, 13046, 86553, 86583, 86584, 
13048, 13049, 86551, 86582, 13028
21998, 12723, 85627, 85637, 12713, 12724, 85628, 85638, 12714, 86553, 86583, 86584, 13048, 86556, 86586, 86587, 
13050, 13051, 86554, 86585, 13030
21999, 12724, 85628, 85638, 12714, 12725, 85629, 85639, 12715, 86556, 86586, 86587, 13050, 86559, 86589, 86590, 
13052, 13053, 86557, 86588, 13032
22000, 12725, 85629, 85639, 12715, 12726, 85630, 85640, 12716, 86559, 86589, 86590, 13052, 86562, 86592, 86593, 
13054, 13055, 86560, 86591, 13034
22001, 12726, 85630, 85640, 12716, 1068, 23365, 23366, 1067, 86562, 86592, 86593, 13054, 23444, 23445, 23446, 
1090, 13056, 86563, 86594, 13035
22002, 991, 23040, 23041, 990, 12707, 85631, 85641, 12697, 23119, 23122, 23121, 1013, 86566, 86596, 86597, 
13015, 13016, 86564, 86595, 12995
22003, 12707, 85631, 85641, 12697, 12708, 85632, 85642, 12698, 86566, 86596, 86597, 13015, 86569, 86599, 86600, 
13017, 13018, 86567, 86598, 12997
22004, 12708, 85632, 85642, 12698, 12709, 85633, 85643, 12699, 86569, 86599, 86600, 13017, 86572, 86602, 86603, 
13019, 13020, 86570, 86601, 12999
22005, 12709, 85633, 85643, 12699, 12710, 85634, 85644, 12700, 86572, 86602, 86603, 13019, 86575, 86605, 86606, 
13021, 13022, 86573, 86604, 13001
22006, 12710, 85634, 85644, 12700, 12711, 85635, 85645, 12701, 86575, 86605, 86606, 13021, 86578, 86608, 86609, 
13023, 13024, 86576, 86607, 13003
22007, 12711, 85635, 85645, 12701, 12712, 85636, 85646, 12702, 86578, 86608, 86609, 13023, 86581, 86611, 86612, 
13025, 13026, 86579, 86610, 13005
22008, 12712, 85636, 85646, 12702, 12713, 85637, 85647, 12703, 86581, 86611, 86612, 13025, 86584, 86614, 86615, 
13027, 13028, 86582, 86613, 13007
