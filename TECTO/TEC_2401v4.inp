12465, 849, 12178, 12179, 848, 11619, 56095, 56105, 11609, 12229, 12232, 12231, 871, 56684, 56714, 56715, 
11993, 11994, 56682, 56713, 11973
12466, 11619, 56095, 56105, 11609, 11620, 56096, 56106, 11610, 56684, 56714, 56715, 11993, 56687, 56717, 56718, 
11995, 11996, 56685, 56716, 11975
12467, 11620, 56096, 56106, 11610, 11621, 56097, 56107, 11611, 56687, 56717, 56718, 11995, 56690, 56720, 56721, 
11997, 11998, 56688, 56719, 11977
12468, 11621, 56097, 56107, 11611, 11622, 56098, 56108, 11612, 56690, 56720, 56721, 11997, 56693, 56723, 56724, 
11999, 12000, 56691, 56722, 11979
12469, 11622, 56098, 56108, 11612, 11623, 56099, 56109, 11613, 56693, 56723, 56724, 11999, 56696, 56726, 56727, 
12001, 12002, 56694, 56725, 11981
12470, 11623, 56099, 56109, 11613, 11624, 56100, 56110, 11614, 56696, 56726, 56727, 12001, 56699, 56729, 56730, 
12003, 12004, 56697, 56728, 11983
12471, 11624, 56100, 56110, 11614, 11625, 56101, 56111, 11615, 56699, 56729, 56730, 12003, 56702, 56732, 56733, 
12005, 12006, 56700, 56731, 11985
12472, 11625, 56101, 56111, 11615, 11626, 56102, 56112, 11616, 56702, 56732, 56733, 12005, 56705, 56735, 56736, 
12007, 12008, 56703, 56734, 11987
12473, 11626, 56102, 56112, 11616, 11627, 56103, 56113, 11617, 56705, 56735, 56736, 12007, 56708, 56738, 56739, 
12009, 12010, 56706, 56737, 11989
12474, 11627, 56103, 56113, 11617, 11628, 56104, 56114, 11618, 56708, 56738, 56739, 12009, 56711, 56741, 56742, 
12011, 12012, 56709, 56740, 11991
12475, 11628, 56104, 56114, 11618, 921, 12406, 12407, 920, 56711, 56741, 56742, 12011, 12458, 12459, 12460, 
943, 12013, 56712, 56743, 11992
12476, 848, 12179, 12180, 847, 11609, 56105, 56115, 11599, 12231, 12234, 12233, 870, 56715, 56745, 56746, 
11972, 11973, 56713, 56744, 11952
12477, 11609, 56105, 56115, 11599, 11610, 56106, 56116, 11600, 56715, 56745, 56746, 11972, 56718, 56748, 56749, 
11974, 11975, 56716, 56747, 11954
12478, 11610, 56106, 56116, 11600, 11611, 56107, 56117, 11601, 56718, 56748, 56749, 11974, 56721, 56751, 56752, 
11976, 11977, 56719, 56750, 11956
12479, 11611, 56107, 56117, 11601, 11612, 56108, 56118, 11602, 56721, 56751, 56752, 11976, 56724, 56754, 56755, 
11978, 11979, 56722, 56753, 11958
12480, 11612, 56108, 56118, 11602, 11613, 56109, 56119, 11603, 56724, 56754, 56755, 11978, 56727, 56757, 56758, 
11980, 11981, 56725, 56756, 11960
12481, 11613, 56109, 56119, 11603, 11614, 56110, 56120, 11604, 56727, 56757, 56758, 11980, 56730, 56760, 56761, 
11982, 11983, 56728, 56759, 11962
12482, 11614, 56110, 56120, 11604, 11615, 56111, 56121, 11605, 56730, 56760, 56761, 11982, 56733, 56763, 56764, 
11984, 11985, 56731, 56762, 11964
12483, 11615, 56111, 56121, 11605, 11616, 56112, 56122, 11606, 56733, 56763, 56764, 11984, 56736, 56766, 56767, 
11986, 11987, 56734, 56765, 11966
12484, 11616, 56112, 56122, 11606, 11617, 56113, 56123, 11607, 56736, 56766, 56767, 11986, 56739, 56769, 56770, 
11988, 11989, 56737, 56768, 11968
12485, 11617, 56113, 56123, 11607, 11618, 56114, 56124, 11608, 56739, 56769, 56770, 11988, 56742, 56772, 56773, 
11990, 11991, 56740, 56771, 11970
12486, 11618, 56114, 56124, 11608, 920, 12407, 12408, 919, 56742, 56772, 56773, 11990, 12460, 12461, 12462, 
942, 11992, 56743, 56774, 11971
12487, 847, 12180, 12181, 846, 11599, 56115, 56125, 11589, 12233, 12236, 12235, 869, 56746, 56776, 56777, 
11951, 11952, 56744, 56775, 11931
12488, 11599, 56115, 56125, 11589, 11600, 56116, 56126, 11590, 56746, 56776, 56777, 11951, 56749, 56779, 56780, 
11953, 11954, 56747, 56778, 11933
12489, 11600, 56116, 56126, 11590, 11601, 56117, 56127, 11591, 56749, 56779, 56780, 11953, 56752, 56782, 56783, 
11955, 11956, 56750, 56781, 11935
12490, 11601, 56117, 56127, 11591, 11602, 56118, 56128, 11592, 56752, 56782, 56783, 11955, 56755, 56785, 56786, 
11957, 11958, 56753, 56784, 11937
12491, 11602, 56118, 56128, 11592, 11603, 56119, 56129, 11593, 56755, 56785, 56786, 11957, 56758, 56788, 56789, 
11959, 11960, 56756, 56787, 11939
12492, 11603, 56119, 56129, 11593, 11604, 56120, 56130, 11594, 56758, 56788, 56789, 11959, 56761, 56791, 56792, 
11961, 11962, 56759, 56790, 11941
12493, 11604, 56120, 56130, 11594, 11605, 56121, 56131, 11595, 56761, 56791, 56792, 11961, 56764, 56794, 56795, 
11963, 11964, 56762, 56793, 11943
12494, 11605, 56121, 56131, 11595, 11606, 56122, 56132, 11596, 56764, 56794, 56795, 11963, 56767, 56797, 56798, 
11965, 11966, 56765, 56796, 11945
12495, 11606, 56122, 56132, 11596, 11607, 56123, 56133, 11597, 56767, 56797, 56798, 11965, 56770, 56800, 56801, 
11967, 11968, 56768, 56799, 11947
12496, 11607, 56123, 56133, 11597, 11608, 56124, 56134, 11598, 56770, 56800, 56801, 11967, 56773, 56803, 56804, 
11969, 11970, 56771, 56802, 11949
12497, 11608, 56124, 56134, 11598, 919, 12408, 12409, 918, 56773, 56803, 56804, 11969, 12462, 12463, 12464, 
941, 11971, 56774, 56805, 11950
12498, 846, 12181, 12182, 845, 11589, 56125, 56135, 11579, 12235, 12238, 12237, 868, 56777, 56807, 56808, 
11930, 11931, 56775, 56806, 11910
12499, 11589, 56125, 56135, 11579, 11590, 56126, 56136, 11580, 56777, 56807, 56808, 11930, 56780, 56810, 56811, 
11932, 11933, 56778, 56809, 11912
12500, 11590, 56126, 56136, 11580, 11591, 56127, 56137, 11581, 56780, 56810, 56811, 11932, 56783, 56813, 56814, 
11934, 11935, 56781, 56812, 11914
12501, 11591, 56127, 56137, 11581, 11592, 56128, 56138, 11582, 56783, 56813, 56814, 11934, 56786, 56816, 56817, 
11936, 11937, 56784, 56815, 11916
12502, 11592, 56128, 56138, 11582, 11593, 56129, 56139, 11583, 56786, 56816, 56817, 11936, 56789, 56819, 56820, 
11938, 11939, 56787, 56818, 11918
12503, 11593, 56129, 56139, 11583, 11594, 56130, 56140, 11584, 56789, 56819, 56820, 11938, 56792, 56822, 56823, 
11940, 11941, 56790, 56821, 11920
12504, 11594, 56130, 56140, 11584, 11595, 56131, 56141, 11585, 56792, 56822, 56823, 11940, 56795, 56825, 56826, 
11942, 11943, 56793, 56824, 11922
12505, 11595, 56131, 56141, 11585, 11596, 56132, 56142, 11586, 56795, 56825, 56826, 11942, 56798, 56828, 56829, 
11944, 11945, 56796, 56827, 11924
12506, 11596, 56132, 56142, 11586, 11597, 56133, 56143, 11587, 56798, 56828, 56829, 11944, 56801, 56831, 56832, 
11946, 11947, 56799, 56830, 11926
12507, 11597, 56133, 56143, 11587, 11598, 56134, 56144, 11588, 56801, 56831, 56832, 11946, 56804, 56834, 56835, 
11948, 11949, 56802, 56833, 11928
12508, 11598, 56134, 56144, 11588, 918, 12409, 12410, 917, 56804, 56834, 56835, 11948, 12464, 12465, 12466, 
940, 11950, 56805, 56836, 11929
12509, 845, 12182, 12183, 844, 11579, 56135, 56145, 11569, 12237, 12240, 12239, 867, 56808, 56838, 56839, 
11909, 11910, 56806, 56837, 11889
12510, 11579, 56135, 56145, 11569, 11580, 56136, 56146, 11570, 56808, 56838, 56839, 11909, 56811, 56841, 56842, 
11911, 11912, 56809, 56840, 11891
12511, 11580, 56136, 56146, 11570, 11581, 56137, 56147, 11571, 56811, 56841, 56842, 11911, 56814, 56844, 56845, 
11913, 11914, 56812, 56843, 11893
12512, 11581, 56137, 56147, 11571, 11582, 56138, 56148, 11572, 56814, 56844, 56845, 11913, 56817, 56847, 56848, 
11915, 11916, 56815, 56846, 11895
12513, 11582, 56138, 56148, 11572, 11583, 56139, 56149, 11573, 56817, 56847, 56848, 11915, 56820, 56850, 56851, 
11917, 11918, 56818, 56849, 11897
12514, 11583, 56139, 56149, 11573, 11584, 56140, 56150, 11574, 56820, 56850, 56851, 11917, 56823, 56853, 56854, 
11919, 11920, 56821, 56852, 11899
12515, 11584, 56140, 56150, 11574, 11585, 56141, 56151, 11575, 56823, 56853, 56854, 11919, 56826, 56856, 56857, 
11921, 11922, 56824, 56855, 11901
12516, 11585, 56141, 56151, 11575, 11586, 56142, 56152, 11576, 56826, 56856, 56857, 11921, 56829, 56859, 56860, 
11923, 11924, 56827, 56858, 11903
12517, 11586, 56142, 56152, 11576, 11587, 56143, 56153, 11577, 56829, 56859, 56860, 11923, 56832, 56862, 56863, 
11925, 11926, 56830, 56861, 11905
12518, 11587, 56143, 56153, 11577, 11588, 56144, 56154, 11578, 56832, 56862, 56863, 11925, 56835, 56865, 56866, 
11927, 11928, 56833, 56864, 11907
12519, 11588, 56144, 56154, 11578, 917, 12410, 12411, 916, 56835, 56865, 56866, 11927, 12466, 12467, 12468, 
939, 11929, 56836, 56867, 11908
12520, 844, 12183, 12184, 843, 11569, 56145, 56155, 11559, 12239, 12242, 12241, 866, 56839, 56869, 56870, 
11888, 11889, 56837, 56868, 11868
12521, 11569, 56145, 56155, 11559, 11570, 56146, 56156, 11560, 56839, 56869, 56870, 11888, 56842, 56872, 56873, 
11890, 11891, 56840, 56871, 11870
12522, 11570, 56146, 56156, 11560, 11571, 56147, 56157, 11561, 56842, 56872, 56873, 11890, 56845, 56875, 56876, 
11892, 11893, 56843, 56874, 11872
12523, 11571, 56147, 56157, 11561, 11572, 56148, 56158, 11562, 56845, 56875, 56876, 11892, 56848, 56878, 56879, 
11894, 11895, 56846, 56877, 11874
12524, 11572, 56148, 56158, 11562, 11573, 56149, 56159, 11563, 56848, 56878, 56879, 11894, 56851, 56881, 56882, 
11896, 11897, 56849, 56880, 11876
12525, 11573, 56149, 56159, 11563, 11574, 56150, 56160, 11564, 56851, 56881, 56882, 11896, 56854, 56884, 56885, 
11898, 11899, 56852, 56883, 11878
12526, 11574, 56150, 56160, 11564, 11575, 56151, 56161, 11565, 56854, 56884, 56885, 11898, 56857, 56887, 56888, 
11900, 11901, 56855, 56886, 11880
12527, 11575, 56151, 56161, 11565, 11576, 56152, 56162, 11566, 56857, 56887, 56888, 11900, 56860, 56890, 56891, 
11902, 11903, 56858, 56889, 11882
12528, 11576, 56152, 56162, 11566, 11577, 56153, 56163, 11567, 56860, 56890, 56891, 11902, 56863, 56893, 56894, 
11904, 11905, 56861, 56892, 11884
12529, 11577, 56153, 56163, 11567, 11578, 56154, 56164, 11568, 56863, 56893, 56894, 11904, 56866, 56896, 56897, 
11906, 11907, 56864, 56895, 11886
12530, 11578, 56154, 56164, 11568, 916, 12411, 12412, 915, 56866, 56896, 56897, 11906, 12468, 12469, 12470, 
938, 11908, 56867, 56898, 11887
12531, 843, 12184, 12185, 842, 11559, 56155, 56165, 11549, 12241, 12244, 12243, 865, 56870, 56900, 56901, 
11867, 11868, 56868, 56899, 11847
12532, 11559, 56155, 56165, 11549, 11560, 56156, 56166, 11550, 56870, 56900, 56901, 11867, 56873, 56903, 56904, 
11869, 11870, 56871, 56902, 11849
12533, 11560, 56156, 56166, 11550, 11561, 56157, 56167, 11551, 56873, 56903, 56904, 11869, 56876, 56906, 56907, 
11871, 11872, 56874, 56905, 11851
12534, 11561, 56157, 56167, 11551, 11562, 56158, 56168, 11552, 56876, 56906, 56907, 11871, 56879, 56909, 56910, 
11873, 11874, 56877, 56908, 11853
12535, 11562, 56158, 56168, 11552, 11563, 56159, 56169, 11553, 56879, 56909, 56910, 11873, 56882, 56912, 56913, 
11875, 11876, 56880, 56911, 11855
12536, 11563, 56159, 56169, 11553, 11564, 56160, 56170, 11554, 56882, 56912, 56913, 11875, 56885, 56915, 56916, 
11877, 11878, 56883, 56914, 11857
12537, 11564, 56160, 56170, 11554, 11565, 56161, 56171, 11555, 56885, 56915, 56916, 11877, 56888, 56918, 56919, 
11879, 11880, 56886, 56917, 11859
12538, 11565, 56161, 56171, 11555, 11566, 56162, 56172, 11556, 56888, 56918, 56919, 11879, 56891, 56921, 56922, 
11881, 11882, 56889, 56920, 11861
12539, 11566, 56162, 56172, 11556, 11567, 56163, 56173, 11557, 56891, 56921, 56922, 11881, 56894, 56924, 56925, 
11883, 11884, 56892, 56923, 11863
12540, 11567, 56163, 56173, 11557, 11568, 56164, 56174, 11558, 56894, 56924, 56925, 11883, 56897, 56927, 56928, 
11885, 11886, 56895, 56926, 11865
12541, 11568, 56164, 56174, 11558, 915, 12412, 12413, 914, 56897, 56927, 56928, 11885, 12470, 12471, 12472, 
937, 11887, 56898, 56929, 11866
12542, 842, 12185, 12186, 841, 11549, 56165, 56175, 11539, 12243, 12246, 12245, 864, 56901, 56931, 56932, 
11846, 11847, 56899, 56930, 11826
12543, 11549, 56165, 56175, 11539, 11550, 56166, 56176, 11540, 56901, 56931, 56932, 11846, 56904, 56934, 56935, 
11848, 11849, 56902, 56933, 11828
12544, 11550, 56166, 56176, 11540, 11551, 56167, 56177, 11541, 56904, 56934, 56935, 11848, 56907, 56937, 56938, 
11850, 11851, 56905, 56936, 11830
12545, 11551, 56167, 56177, 11541, 11552, 56168, 56178, 11542, 56907, 56937, 56938, 11850, 56910, 56940, 56941, 
11852, 11853, 56908, 56939, 11832
12546, 11552, 56168, 56178, 11542, 11553, 56169, 56179, 11543, 56910, 56940, 56941, 11852, 56913, 56943, 56944, 
11854, 11855, 56911, 56942, 11834
12547, 11553, 56169, 56179, 11543, 11554, 56170, 56180, 11544, 56913, 56943, 56944, 11854, 56916, 56946, 56947, 
11856, 11857, 56914, 56945, 11836
12548, 11554, 56170, 56180, 11544, 11555, 56171, 56181, 11545, 56916, 56946, 56947, 11856, 56919, 56949, 56950, 
11858, 11859, 56917, 56948, 11838
12549, 11555, 56171, 56181, 11545, 11556, 56172, 56182, 11546, 56919, 56949, 56950, 11858, 56922, 56952, 56953, 
11860, 11861, 56920, 56951, 11840
12550, 11556, 56172, 56182, 11546, 11557, 56173, 56183, 11547, 56922, 56952, 56953, 11860, 56925, 56955, 56956, 
11862, 11863, 56923, 56954, 11842
12551, 11557, 56173, 56183, 11547, 11558, 56174, 56184, 11548, 56925, 56955, 56956, 11862, 56928, 56958, 56959, 
11864, 11865, 56926, 56957, 11844
12552, 11558, 56174, 56184, 11548, 914, 12413, 12414, 913, 56928, 56958, 56959, 11864, 12472, 12473, 12474, 
936, 11866, 56929, 56960, 11845
12553, 841, 12186, 12187, 840, 11539, 56175, 56185, 11529, 12245, 12248, 12247, 863, 56932, 56962, 56963, 
11825, 11826, 56930, 56961, 11805
12554, 11539, 56175, 56185, 11529, 11540, 56176, 56186, 11530, 56932, 56962, 56963, 11825, 56935, 56965, 56966, 
11827, 11828, 56933, 56964, 11807
12555, 11540, 56176, 56186, 11530, 11541, 56177, 56187, 11531, 56935, 56965, 56966, 11827, 56938, 56968, 56969, 
11829, 11830, 56936, 56967, 11809
12556, 11541, 56177, 56187, 11531, 11542, 56178, 56188, 11532, 56938, 56968, 56969, 11829, 56941, 56971, 56972, 
11831, 11832, 56939, 56970, 11811
12557, 11542, 56178, 56188, 11532, 11543, 56179, 56189, 11533, 56941, 56971, 56972, 11831, 56944, 56974, 56975, 
11833, 11834, 56942, 56973, 11813
12558, 11543, 56179, 56189, 11533, 11544, 56180, 56190, 11534, 56944, 56974, 56975, 11833, 56947, 56977, 56978, 
11835, 11836, 56945, 56976, 11815
12559, 11544, 56180, 56190, 11534, 11545, 56181, 56191, 11535, 56947, 56977, 56978, 11835, 56950, 56980, 56981, 
11837, 11838, 56948, 56979, 11817
12560, 11545, 56181, 56191, 11535, 11546, 56182, 56192, 11536, 56950, 56980, 56981, 11837, 56953, 56983, 56984, 
11839, 11840, 56951, 56982, 11819
12561, 11546, 56182, 56192, 11536, 11547, 56183, 56193, 11537, 56953, 56983, 56984, 11839, 56956, 56986, 56987, 
11841, 11842, 56954, 56985, 11821
12562, 11547, 56183, 56193, 11537, 11548, 56184, 56194, 11538, 56956, 56986, 56987, 11841, 56959, 56989, 56990, 
11843, 11844, 56957, 56988, 11823
12563, 11548, 56184, 56194, 11538, 913, 12414, 12415, 912, 56959, 56989, 56990, 11843, 12474, 12475, 12476, 
935, 11845, 56960, 56991, 11824
12564, 840, 12187, 12188, 839, 11529, 56185, 56195, 11519, 12247, 12250, 12249, 862, 56963, 56993, 56994, 
11804, 11805, 56961, 56992, 11784
12565, 11529, 56185, 56195, 11519, 11530, 56186, 56196, 11520, 56963, 56993, 56994, 11804, 56966, 56996, 56997, 
11806, 11807, 56964, 56995, 11786
12566, 11530, 56186, 56196, 11520, 11531, 56187, 56197, 11521, 56966, 56996, 56997, 11806, 56969, 56999, 57000, 
11808, 11809, 56967, 56998, 11788
12567, 11531, 56187, 56197, 11521, 11532, 56188, 56198, 11522, 56969, 56999, 57000, 11808, 56972, 57002, 57003, 
11810, 11811, 56970, 57001, 11790
12568, 11532, 56188, 56198, 11522, 11533, 56189, 56199, 11523, 56972, 57002, 57003, 11810, 56975, 57005, 57006, 
11812, 11813, 56973, 57004, 11792
12569, 11533, 56189, 56199, 11523, 11534, 56190, 56200, 11524, 56975, 57005, 57006, 11812, 56978, 57008, 57009, 
11814, 11815, 56976, 57007, 11794
12570, 11534, 56190, 56200, 11524, 11535, 56191, 56201, 11525, 56978, 57008, 57009, 11814, 56981, 57011, 57012, 
11816, 11817, 56979, 57010, 11796
12571, 11535, 56191, 56201, 11525, 11536, 56192, 56202, 11526, 56981, 57011, 57012, 11816, 56984, 57014, 57015, 
11818, 11819, 56982, 57013, 11798
12572, 11536, 56192, 56202, 11526, 11537, 56193, 56203, 11527, 56984, 57014, 57015, 11818, 56987, 57017, 57018, 
11820, 11821, 56985, 57016, 11800
12573, 11537, 56193, 56203, 11527, 11538, 56194, 56204, 11528, 56987, 57017, 57018, 11820, 56990, 57020, 57021, 
11822, 11823, 56988, 57019, 11802
12574, 11538, 56194, 56204, 11528, 912, 12415, 12416, 911, 56990, 57020, 57021, 11822, 12476, 12477, 12478, 
934, 11824, 56991, 57022, 11803
12575, 839, 12188, 12189, 838, 11519, 56195, 56205, 11509, 12249, 12252, 12251, 861, 56994, 57024, 57025, 
11783, 11784, 56992, 57023, 11763
12576, 11519, 56195, 56205, 11509, 11520, 56196, 56206, 11510, 56994, 57024, 57025, 11783, 56997, 57027, 57028, 
11785, 11786, 56995, 57026, 11765
12577, 11520, 56196, 56206, 11510, 11521, 56197, 56207, 11511, 56997, 57027, 57028, 11785, 57000, 57030, 57031, 
11787, 11788, 56998, 57029, 11767
12578, 11521, 56197, 56207, 11511, 11522, 56198, 56208, 11512, 57000, 57030, 57031, 11787, 57003, 57033, 57034, 
11789, 11790, 57001, 57032, 11769
12579, 11522, 56198, 56208, 11512, 11523, 56199, 56209, 11513, 57003, 57033, 57034, 11789, 57006, 57036, 57037, 
11791, 11792, 57004, 57035, 11771
12580, 11523, 56199, 56209, 11513, 11524, 56200, 56210, 11514, 57006, 57036, 57037, 11791, 57009, 57039, 57040, 
11793, 11794, 57007, 57038, 11773
12581, 11524, 56200, 56210, 11514, 11525, 56201, 56211, 11515, 57009, 57039, 57040, 11793, 57012, 57042, 57043, 
11795, 11796, 57010, 57041, 11775
12582, 11525, 56201, 56211, 11515, 11526, 56202, 56212, 11516, 57012, 57042, 57043, 11795, 57015, 57045, 57046, 
11797, 11798, 57013, 57044, 11777
12583, 11526, 56202, 56212, 11516, 11527, 56203, 56213, 11517, 57015, 57045, 57046, 11797, 57018, 57048, 57049, 
11799, 11800, 57016, 57047, 11779
12584, 11527, 56203, 56213, 11517, 11528, 56204, 56214, 11518, 57018, 57048, 57049, 11799, 57021, 57051, 57052, 
11801, 11802, 57019, 57050, 11781
12585, 11528, 56204, 56214, 11518, 911, 12416, 12417, 910, 57021, 57051, 57052, 11801, 12478, 12479, 12480, 
933, 11803, 57022, 57053, 11782
12586, 838, 12189, 12190, 837, 11509, 56205, 56215, 11499, 12251, 12254, 12253, 860, 57025, 57055, 57056, 
11762, 11763, 57023, 57054, 11742
12587, 11509, 56205, 56215, 11499, 11510, 56206, 56216, 11500, 57025, 57055, 57056, 11762, 57028, 57058, 57059, 
11764, 11765, 57026, 57057, 11744
12588, 11510, 56206, 56216, 11500, 11511, 56207, 56217, 11501, 57028, 57058, 57059, 11764, 57031, 57061, 57062, 
11766, 11767, 57029, 57060, 11746
12589, 11511, 56207, 56217, 11501, 11512, 56208, 56218, 11502, 57031, 57061, 57062, 11766, 57034, 57064, 57065, 
11768, 11769, 57032, 57063, 11748
12590, 11512, 56208, 56218, 11502, 11513, 56209, 56219, 11503, 57034, 57064, 57065, 11768, 57037, 57067, 57068, 
11770, 11771, 57035, 57066, 11750
12591, 11513, 56209, 56219, 11503, 11514, 56210, 56220, 11504, 57037, 57067, 57068, 11770, 57040, 57070, 57071, 
11772, 11773, 57038, 57069, 11752
12592, 11514, 56210, 56220, 11504, 11515, 56211, 56221, 11505, 57040, 57070, 57071, 11772, 57043, 57073, 57074, 
11774, 11775, 57041, 57072, 11754
12593, 11515, 56211, 56221, 11505, 11516, 56212, 56222, 11506, 57043, 57073, 57074, 11774, 57046, 57076, 57077, 
11776, 11777, 57044, 57075, 11756
12594, 11516, 56212, 56222, 11506, 11517, 56213, 56223, 11507, 57046, 57076, 57077, 11776, 57049, 57079, 57080, 
11778, 11779, 57047, 57078, 11758
12595, 11517, 56213, 56223, 11507, 11518, 56214, 56224, 11508, 57049, 57079, 57080, 11778, 57052, 57082, 57083, 
11780, 11781, 57050, 57081, 11760
12596, 11518, 56214, 56224, 11508, 910, 12417, 12418, 909, 57052, 57082, 57083, 11780, 12480, 12481, 12482, 
932, 11782, 57053, 57084, 11761
12597, 837, 12190, 12191, 836, 11499, 56215, 56225, 11489, 12253, 12256, 12255, 859, 57056, 57086, 57087, 
11741, 11742, 57054, 57085, 11721
12598, 11499, 56215, 56225, 11489, 11500, 56216, 56226, 11490, 57056, 57086, 57087, 11741, 57059, 57089, 57090, 
11743, 11744, 57057, 57088, 11723
12599, 11500, 56216, 56226, 11490, 11501, 56217, 56227, 11491, 57059, 57089, 57090, 11743, 57062, 57092, 57093, 
11745, 11746, 57060, 57091, 11725
12600, 11501, 56217, 56227, 11491, 11502, 56218, 56228, 11492, 57062, 57092, 57093, 11745, 57065, 57095, 57096, 
11747, 11748, 57063, 57094, 11727
12601, 11502, 56218, 56228, 11492, 11503, 56219, 56229, 11493, 57065, 57095, 57096, 11747, 57068, 57098, 57099, 
11749, 11750, 57066, 57097, 11729
12602, 11503, 56219, 56229, 11493, 11504, 56220, 56230, 11494, 57068, 57098, 57099, 11749, 57071, 57101, 57102, 
11751, 11752, 57069, 57100, 11731
12603, 11504, 56220, 56230, 11494, 11505, 56221, 56231, 11495, 57071, 57101, 57102, 11751, 57074, 57104, 57105, 
11753, 11754, 57072, 57103, 11733
12604, 11505, 56221, 56231, 11495, 11506, 56222, 56232, 11496, 57074, 57104, 57105, 11753, 57077, 57107, 57108, 
11755, 11756, 57075, 57106, 11735
12605, 11506, 56222, 56232, 11496, 11507, 56223, 56233, 11497, 57077, 57107, 57108, 11755, 57080, 57110, 57111, 
11757, 11758, 57078, 57109, 11737
12606, 11507, 56223, 56233, 11497, 11508, 56224, 56234, 11498, 57080, 57110, 57111, 11757, 57083, 57113, 57114, 
11759, 11760, 57081, 57112, 11739
12607, 11508, 56224, 56234, 11498, 909, 12418, 12419, 908, 57083, 57113, 57114, 11759, 12482, 12483, 12484, 
931, 11761, 57084, 57115, 11740
12608, 836, 12191, 12192, 835, 11489, 56225, 56235, 11479, 12255, 12258, 12257, 858, 57087, 57117, 57118, 
11720, 11721, 57085, 57116, 11700
12609, 11489, 56225, 56235, 11479, 11490, 56226, 56236, 11480, 57087, 57117, 57118, 11720, 57090, 57120, 57121, 
11722, 11723, 57088, 57119, 11702
12610, 11490, 56226, 56236, 11480, 11491, 56227, 56237, 11481, 57090, 57120, 57121, 11722, 57093, 57123, 57124, 
11724, 11725, 57091, 57122, 11704
12611, 11491, 56227, 56237, 11481, 11492, 56228, 56238, 11482, 57093, 57123, 57124, 11724, 57096, 57126, 57127, 
11726, 11727, 57094, 57125, 11706
12612, 11492, 56228, 56238, 11482, 11493, 56229, 56239, 11483, 57096, 57126, 57127, 11726, 57099, 57129, 57130, 
11728, 11729, 57097, 57128, 11708
12613, 11493, 56229, 56239, 11483, 11494, 56230, 56240, 11484, 57099, 57129, 57130, 11728, 57102, 57132, 57133, 
11730, 11731, 57100, 57131, 11710
12614, 11494, 56230, 56240, 11484, 11495, 56231, 56241, 11485, 57102, 57132, 57133, 11730, 57105, 57135, 57136, 
11732, 11733, 57103, 57134, 11712
12615, 11495, 56231, 56241, 11485, 11496, 56232, 56242, 11486, 57105, 57135, 57136, 11732, 57108, 57138, 57139, 
11734, 11735, 57106, 57137, 11714
12616, 11496, 56232, 56242, 11486, 11497, 56233, 56243, 11487, 57108, 57138, 57139, 11734, 57111, 57141, 57142, 
11736, 11737, 57109, 57140, 11716
12617, 11497, 56233, 56243, 11487, 11498, 56234, 56244, 11488, 57111, 57141, 57142, 11736, 57114, 57144, 57145, 
11738, 11739, 57112, 57143, 11718
12618, 11498, 56234, 56244, 11488, 908, 12419, 12420, 907, 57114, 57144, 57145, 11738, 12484, 12485, 12486, 
930, 11740, 57115, 57146, 11719
12619, 835, 12192, 978, 18, 11479, 56235, 12564, 952, 12257, 12259, 980, 857, 57118, 57147, 12594, 
11699, 11700, 57116, 12595, 962
12620, 11479, 56235, 12564, 952, 11480, 56236, 12563, 953, 57118, 57147, 12594, 11699, 57121, 57148, 12592, 
11701, 11702, 57119, 12593, 963
12621, 11480, 56236, 12563, 953, 11481, 56237, 12562, 954, 57121, 57148, 12592, 11701, 57124, 57149, 12590, 
11703, 11704, 57122, 12591, 964
12622, 11481, 56237, 12562, 954, 11482, 56238, 12561, 955, 57124, 57149, 12590, 11703, 57127, 57150, 12588, 
11705, 11706, 57125, 12589, 965
12623, 11482, 56238, 12561, 955, 11483, 56239, 12560, 956, 57127, 57150, 12588, 11705, 57130, 57151, 12586, 
11707, 11708, 57128, 12587, 966
12624, 11483, 56239, 12560, 956, 11484, 56240, 12559, 957, 57130, 57151, 12586, 11707, 57133, 57152, 12584, 
11709, 11710, 57131, 12585, 967
12625, 11484, 56240, 12559, 957, 11485, 56241, 12558, 958, 57133, 57152, 12584, 11709, 57136, 57153, 12582, 
11711, 11712, 57134, 12583, 968
12626, 11485, 56241, 12558, 958, 11486, 56242, 12557, 959, 57136, 57153, 12582, 11711, 57139, 57154, 12580, 
11713, 11714, 57137, 12581, 969
12627, 11486, 56242, 12557, 959, 11487, 56243, 12556, 960, 57139, 57154, 12580, 11713, 57142, 57155, 12578, 
11715, 11716, 57140, 12579, 970
12628, 11487, 56243, 12556, 960, 11488, 56244, 12555, 961, 57142, 57155, 12578, 11715, 57145, 57156, 12576, 
11717, 11718, 57143, 12577, 971
12629, 11488, 56244, 12555, 961, 907, 12420, 1054, 20, 57145, 57156, 12576, 11717, 12486, 12487, 1056, 
929, 11719, 57146, 12575, 972
12630, 973, 974, 12193, 12171, 12336, 12346, 56245, 56025, 976, 12261, 12260, 12216, 12386, 57158, 57159, 
56466, 12367, 12388, 57157, 56465
12631, 12336, 12346, 56245, 56025, 12335, 12345, 56246, 56026, 12386, 57158, 57159, 56466, 12384, 57161, 57162, 
56469, 12366, 12387, 57160, 56468
12632, 12335, 12345, 56246, 56026, 12334, 12344, 56247, 56027, 12384, 57161, 57162, 56469, 12382, 57164, 57165, 
56472, 12364, 12385, 57163, 56471
12633, 12334, 12344, 56247, 56027, 12333, 12343, 56248, 56028, 12382, 57164, 57165, 56472, 12380, 57167, 57168, 
56475, 12362, 12383, 57166, 56474
12634, 12333, 12343, 56248, 56028, 12332, 12342, 56249, 56029, 12380, 57167, 57168, 56475, 12378, 57170, 57171, 
56478, 12360, 12381, 57169, 56477
12635, 12332, 12342, 56249, 56029, 12331, 12341, 56250, 56030, 12378, 57170, 57171, 56478, 12376, 57173, 57174, 
56481, 12358, 12379, 57172, 56480
12636, 12331, 12341, 56250, 56030, 12330, 12340, 56251, 56031, 12376, 57173, 57174, 56481, 12374, 57176, 57177, 
56484, 12356, 12377, 57175, 56483
12637, 12330, 12340, 56251, 56031, 12329, 12339, 56252, 56032, 12374, 57176, 57177, 56484, 12372, 57179, 57180, 
56487, 12354, 12375, 57178, 56486
12638, 12329, 12339, 56252, 56032, 12328, 12338, 56253, 56033, 12372, 57179, 57180, 56487, 12370, 57182, 57183, 
56490, 12352, 12373, 57181, 56489
12639, 12328, 12338, 56253, 56033, 12327, 12337, 56254, 56034, 12370, 57182, 57183, 56490, 12368, 57185, 57186, 
56493, 12350, 12371, 57184, 56492
12640, 12327, 12337, 56254, 56034, 1028, 1029, 12421, 12399, 12368, 57185, 57186, 56493, 1031, 12488, 12489, 
12443, 12348, 12369, 57187, 56495
12641, 12171, 12193, 12194, 12172, 56025, 56245, 56255, 56035, 12260, 12263, 12262, 12218, 57159, 57189, 57190, 
56497, 56465, 57157, 57188, 56496
12642, 56025, 56245, 56255, 56035, 56026, 56246, 56256, 56036, 57159, 57189, 57190, 56497, 57162, 57192, 57193, 
56500, 56468, 57160, 57191, 56499
12643, 56026, 56246, 56256, 56036, 56027, 56247, 56257, 56037, 57162, 57192, 57193, 56500, 57165, 57195, 57196, 
56503, 56471, 57163, 57194, 56502
12644, 56027, 56247, 56257, 56037, 56028, 56248, 56258, 56038, 57165, 57195, 57196, 56503, 57168, 57198, 57199, 
56506, 56474, 57166, 57197, 56505
12645, 56028, 56248, 56258, 56038, 56029, 56249, 56259, 56039, 57168, 57198, 57199, 56506, 57171, 57201, 57202, 
56509, 56477, 57169, 57200, 56508
12646, 56029, 56249, 56259, 56039, 56030, 56250, 56260, 56040, 57171, 57201, 57202, 56509, 57174, 57204, 57205, 
56512, 56480, 57172, 57203, 56511
12647, 56030, 56250, 56260, 56040, 56031, 56251, 56261, 56041, 57174, 57204, 57205, 56512, 57177, 57207, 57208, 
56515, 56483, 57175, 57206, 56514
12648, 56031, 56251, 56261, 56041, 56032, 56252, 56262, 56042, 57177, 57207, 57208, 56515, 57180, 57210, 57211, 
56518, 56486, 57178, 57209, 56517
12649, 56032, 56252, 56262, 56042, 56033, 56253, 56263, 56043, 57180, 57210, 57211, 56518, 57183, 57213, 57214, 
56521, 56489, 57181, 57212, 56520
12650, 56033, 56253, 56263, 56043, 56034, 56254, 56264, 56044, 57183, 57213, 57214, 56521, 57186, 57216, 57217, 
56524, 56492, 57184, 57215, 56523
12651, 56034, 56254, 56264, 56044, 12399, 12421, 12422, 12400, 57186, 57216, 57217, 56524, 12489, 12490, 12491, 
12445, 56495, 57187, 57218, 56526
12652, 12172, 12194, 12195, 12173, 56035, 56255, 56265, 56045, 12262, 12265, 12264, 12220, 57190, 57220, 57221, 
56528, 56496, 57188, 57219, 56527
12653, 56035, 56255, 56265, 56045, 56036, 56256, 56266, 56046, 57190, 57220, 57221, 56528, 57193, 57223, 57224, 
56531, 56499, 57191, 57222, 56530
12654, 56036, 56256, 56266, 56046, 56037, 56257, 56267, 56047, 57193, 57223, 57224, 56531, 57196, 57226, 57227, 
56534, 56502, 57194, 57225, 56533
12655, 56037, 56257, 56267, 56047, 56038, 56258, 56268, 56048, 57196, 57226, 57227, 56534, 57199, 57229, 57230, 
56537, 56505, 57197, 57228, 56536
12656, 56038, 56258, 56268, 56048, 56039, 56259, 56269, 56049, 57199, 57229, 57230, 56537, 57202, 57232, 57233, 
56540, 56508, 57200, 57231, 56539
12657, 56039, 56259, 56269, 56049, 56040, 56260, 56270, 56050, 57202, 57232, 57233, 56540, 57205, 57235, 57236, 
56543, 56511, 57203, 57234, 56542
12658, 56040, 56260, 56270, 56050, 56041, 56261, 56271, 56051, 57205, 57235, 57236, 56543, 57208, 57238, 57239, 
56546, 56514, 57206, 57237, 56545
12659, 56041, 56261, 56271, 56051, 56042, 56262, 56272, 56052, 57208, 57238, 57239, 56546, 57211, 57241, 57242, 
56549, 56517, 57209, 57240, 56548
12660, 56042, 56262, 56272, 56052, 56043, 56263, 56273, 56053, 57211, 57241, 57242, 56549, 57214, 57244, 57245, 
56552, 56520, 57212, 57243, 56551
12661, 56043, 56263, 56273, 56053, 56044, 56264, 56274, 56054, 57214, 57244, 57245, 56552, 57217, 57247, 57248, 
56555, 56523, 57215, 57246, 56554
12662, 56044, 56264, 56274, 56054, 12400, 12422, 12423, 12401, 57217, 57247, 57248, 56555, 12491, 12492, 12493, 
12447, 56526, 57218, 57249, 56557
12663, 12173, 12195, 12196, 12174, 56045, 56265, 56275, 56055, 12264, 12267, 12266, 12222, 57221, 57251, 57252, 
56559, 56527, 57219, 57250, 56558
12664, 56045, 56265, 56275, 56055, 56046, 56266, 56276, 56056, 57221, 57251, 57252, 56559, 57224, 57254, 57255, 
56562, 56530, 57222, 57253, 56561
12665, 56046, 56266, 56276, 56056, 56047, 56267, 56277, 56057, 57224, 57254, 57255, 56562, 57227, 57257, 57258, 
56565, 56533, 57225, 57256, 56564
12666, 56047, 56267, 56277, 56057, 56048, 56268, 56278, 56058, 57227, 57257, 57258, 56565, 57230, 57260, 57261, 
56568, 56536, 57228, 57259, 56567
12667, 56048, 56268, 56278, 56058, 56049, 56269, 56279, 56059, 57230, 57260, 57261, 56568, 57233, 57263, 57264, 
56571, 56539, 57231, 57262, 56570
12668, 56049, 56269, 56279, 56059, 56050, 56270, 56280, 56060, 57233, 57263, 57264, 56571, 57236, 57266, 57267, 
56574, 56542, 57234, 57265, 56573
12669, 56050, 56270, 56280, 56060, 56051, 56271, 56281, 56061, 57236, 57266, 57267, 56574, 57239, 57269, 57270, 
56577, 56545, 57237, 57268, 56576
12670, 56051, 56271, 56281, 56061, 56052, 56272, 56282, 56062, 57239, 57269, 57270, 56577, 57242, 57272, 57273, 
56580, 56548, 57240, 57271, 56579
12671, 56052, 56272, 56282, 56062, 56053, 56273, 56283, 56063, 57242, 57272, 57273, 56580, 57245, 57275, 57276, 
56583, 56551, 57243, 57274, 56582
12672, 56053, 56273, 56283, 56063, 56054, 56274, 56284, 56064, 57245, 57275, 57276, 56583, 57248, 57278, 57279, 
56586, 56554, 57246, 57277, 56585
12673, 56054, 56274, 56284, 56064, 12401, 12423, 12424, 12402, 57248, 57278, 57279, 56586, 12493, 12494, 12495, 
12449, 56557, 57249, 57280, 56588
12674, 12174, 12196, 12197, 12175, 56055, 56275, 56285, 56065, 12266, 12269, 12268, 12224, 57252, 57282, 57283, 
56590, 56558, 57250, 57281, 56589
12675, 56055, 56275, 56285, 56065, 56056, 56276, 56286, 56066, 57252, 57282, 57283, 56590, 57255, 57285, 57286, 
56593, 56561, 57253, 57284, 56592
12676, 56056, 56276, 56286, 56066, 56057, 56277, 56287, 56067, 57255, 57285, 57286, 56593, 57258, 57288, 57289, 
56596, 56564, 57256, 57287, 56595
12677, 56057, 56277, 56287, 56067, 56058, 56278, 56288, 56068, 57258, 57288, 57289, 56596, 57261, 57291, 57292, 
56599, 56567, 57259, 57290, 56598
12678, 56058, 56278, 56288, 56068, 56059, 56279, 56289, 56069, 57261, 57291, 57292, 56599, 57264, 57294, 57295, 
56602, 56570, 57262, 57293, 56601
12679, 56059, 56279, 56289, 56069, 56060, 56280, 56290, 56070, 57264, 57294, 57295, 56602, 57267, 57297, 57298, 
56605, 56573, 57265, 57296, 56604
12680, 56060, 56280, 56290, 56070, 56061, 56281, 56291, 56071, 57267, 57297, 57298, 56605, 57270, 57300, 57301, 
56608, 56576, 57268, 57299, 56607
12681, 56061, 56281, 56291, 56071, 56062, 56282, 56292, 56072, 57270, 57300, 57301, 56608, 57273, 57303, 57304, 
56611, 56579, 57271, 57302, 56610
12682, 56062, 56282, 56292, 56072, 56063, 56283, 56293, 56073, 57273, 57303, 57304, 56611, 57276, 57306, 57307, 
56614, 56582, 57274, 57305, 56613
12683, 56063, 56283, 56293, 56073, 56064, 56284, 56294, 56074, 57276, 57306, 57307, 56614, 57279, 57309, 57310, 
56617, 56585, 57277, 57308, 56616
12684, 56064, 56284, 56294, 56074, 12402, 12424, 12425, 12403, 57279, 57309, 57310, 56617, 12495, 12496, 12497, 
12451, 56588, 57280, 57311, 56619
12685, 12175, 12197, 12198, 12176, 56065, 56285, 56295, 56075, 12268, 12271, 12270, 12226, 57283, 57313, 57314, 
56621, 56589, 57281, 57312, 56620
12686, 56065, 56285, 56295, 56075, 56066, 56286, 56296, 56076, 57283, 57313, 57314, 56621, 57286, 57316, 57317, 
56624, 56592, 57284, 57315, 56623
12687, 56066, 56286, 56296, 56076, 56067, 56287, 56297, 56077, 57286, 57316, 57317, 56624, 57289, 57319, 57320, 
56627, 56595, 57287, 57318, 56626
12688, 56067, 56287, 56297, 56077, 56068, 56288, 56298, 56078, 57289, 57319, 57320, 56627, 57292, 57322, 57323, 
56630, 56598, 57290, 57321, 56629
12689, 56068, 56288, 56298, 56078, 56069, 56289, 56299, 56079, 57292, 57322, 57323, 56630, 57295, 57325, 57326, 
56633, 56601, 57293, 57324, 56632
12690, 56069, 56289, 56299, 56079, 56070, 56290, 56300, 56080, 57295, 57325, 57326, 56633, 57298, 57328, 57329, 
56636, 56604, 57296, 57327, 56635
12691, 56070, 56290, 56300, 56080, 56071, 56291, 56301, 56081, 57298, 57328, 57329, 56636, 57301, 57331, 57332, 
56639, 56607, 57299, 57330, 56638
12692, 56071, 56291, 56301, 56081, 56072, 56292, 56302, 56082, 57301, 57331, 57332, 56639, 57304, 57334, 57335, 
56642, 56610, 57302, 57333, 56641
12693, 56072, 56292, 56302, 56082, 56073, 56293, 56303, 56083, 57304, 57334, 57335, 56642, 57307, 57337, 57338, 
56645, 56613, 57305, 57336, 56644
12694, 56073, 56293, 56303, 56083, 56074, 56294, 56304, 56084, 57307, 57337, 57338, 56645, 57310, 57340, 57341, 
56648, 56616, 57308, 57339, 56647
12695, 56074, 56294, 56304, 56084, 12403, 12425, 12426, 12404, 57310, 57340, 57341, 56648, 12497, 12498, 12499, 
12453, 56619, 57311, 57342, 56650
12696, 12176, 12198, 12199, 12177, 56075, 56295, 56305, 56085, 12270, 12273, 12272, 12228, 57314, 57344, 57345, 
56652, 56620, 57312, 57343, 56651
12697, 56075, 56295, 56305, 56085, 56076, 56296, 56306, 56086, 57314, 57344, 57345, 56652, 57317, 57347, 57348, 
56655, 56623, 57315, 57346, 56654
12698, 56076, 56296, 56306, 56086, 56077, 56297, 56307, 56087, 57317, 57347, 57348, 56655, 57320, 57350, 57351, 
56658, 56626, 57318, 57349, 56657
12699, 56077, 56297, 56307, 56087, 56078, 56298, 56308, 56088, 57320, 57350, 57351, 56658, 57323, 57353, 57354, 
56661, 56629, 57321, 57352, 56660
12700, 56078, 56298, 56308, 56088, 56079, 56299, 56309, 56089, 57323, 57353, 57354, 56661, 57326, 57356, 57357, 
56664, 56632, 57324, 57355, 56663
12701, 56079, 56299, 56309, 56089, 56080, 56300, 56310, 56090, 57326, 57356, 57357, 56664, 57329, 57359, 57360, 
56667, 56635, 57327, 57358, 56666
12702, 56080, 56300, 56310, 56090, 56081, 56301, 56311, 56091, 57329, 57359, 57360, 56667, 57332, 57362, 57363, 
56670, 56638, 57330, 57361, 56669
12703, 56081, 56301, 56311, 56091, 56082, 56302, 56312, 56092, 57332, 57362, 57363, 56670, 57335, 57365, 57366, 
56673, 56641, 57333, 57364, 56672
12704, 56082, 56302, 56312, 56092, 56083, 56303, 56313, 56093, 57335, 57365, 57366, 56673, 57338, 57368, 57369, 
56676, 56644, 57336, 57367, 56675
12705, 56083, 56303, 56313, 56093, 56084, 56304, 56314, 56094, 57338, 57368, 57369, 56676, 57341, 57371, 57372, 
56679, 56647, 57339, 57370, 56678
12706, 56084, 56304, 56314, 56094, 12404, 12426, 12427, 12405, 57341, 57371, 57372, 56679, 12499, 12500, 12501, 
12455, 56650, 57342, 57373, 56681
12707, 12177, 12199, 12200, 12178, 56085, 56305, 56315, 56095, 12272, 12275, 12274, 12230, 57345, 57375, 57376, 
56683, 56651, 57343, 57374, 56682
12708, 56085, 56305, 56315, 56095, 56086, 56306, 56316, 56096, 57345, 57375, 57376, 56683, 57348, 57378, 57379, 
56686, 56654, 57346, 57377, 56685
12709, 56086, 56306, 56316, 56096, 56087, 56307, 56317, 56097, 57348, 57378, 57379, 56686, 57351, 57381, 57382, 
56689, 56657, 57349, 57380, 56688
12710, 56087, 56307, 56317, 56097, 56088, 56308, 56318, 56098, 57351, 57381, 57382, 56689, 57354, 57384, 57385, 
56692, 56660, 57352, 57383, 56691
12711, 56088, 56308, 56318, 56098, 56089, 56309, 56319, 56099, 57354, 57384, 57385, 56692, 57357, 57387, 57388, 
56695, 56663, 57355, 57386, 56694
12712, 56089, 56309, 56319, 56099, 56090, 56310, 56320, 56100, 57357, 57387, 57388, 56695, 57360, 57390, 57391, 
56698, 56666, 57358, 57389, 56697
12713, 56090, 56310, 56320, 56100, 56091, 56311, 56321, 56101, 57360, 57390, 57391, 56698, 57363, 57393, 57394, 
56701, 56669, 57361, 57392, 56700
12714, 56091, 56311, 56321, 56101, 56092, 56312, 56322, 56102, 57363, 57393, 57394, 56701, 57366, 57396, 57397, 
56704, 56672, 57364, 57395, 56703
12715, 56092, 56312, 56322, 56102, 56093, 56313, 56323, 56103, 57366, 57396, 57397, 56704, 57369, 57399, 57400, 
56707, 56675, 57367, 57398, 56706
12716, 56093, 56313, 56323, 56103, 56094, 56314, 56324, 56104, 57369, 57399, 57400, 56707, 57372, 57402, 57403, 
56710, 56678, 57370, 57401, 56709
12717, 56094, 56314, 56324, 56104, 12405, 12427, 12428, 12406, 57372, 57402, 57403, 56710, 12501, 12502, 12503, 
12457, 56681, 57373, 57404, 56712
12718, 12178, 12200, 12201, 12179, 56095, 56315, 56325, 56105, 12274, 12277, 12276, 12232, 57376, 57406, 57407, 
56714, 56682, 57374, 57405, 56713
12719, 56095, 56315, 56325, 56105, 56096, 56316, 56326, 56106, 57376, 57406, 57407, 56714, 57379, 57409, 57410, 
56717, 56685, 57377, 57408, 56716
12720, 56096, 56316, 56326, 56106, 56097, 56317, 56327, 56107, 57379, 57409, 57410, 56717, 57382, 57412, 57413, 
56720, 56688, 57380, 57411, 56719
12721, 56097, 56317, 56327, 56107, 56098, 56318, 56328, 56108, 57382, 57412, 57413, 56720, 57385, 57415, 57416, 
56723, 56691, 57383, 57414, 56722
12722, 56098, 56318, 56328, 56108, 56099, 56319, 56329, 56109, 57385, 57415, 57416, 56723, 57388, 57418, 57419, 
56726, 56694, 57386, 57417, 56725
12723, 56099, 56319, 56329, 56109, 56100, 56320, 56330, 56110, 57388, 57418, 57419, 56726, 57391, 57421, 57422, 
56729, 56697, 57389, 57420, 56728
12724, 56100, 56320, 56330, 56110, 56101, 56321, 56331, 56111, 57391, 57421, 57422, 56729, 57394, 57424, 57425, 
56732, 56700, 57392, 57423, 56731
12725, 56101, 56321, 56331, 56111, 56102, 56322, 56332, 56112, 57394, 57424, 57425, 56732, 57397, 57427, 57428, 
56735, 56703, 57395, 57426, 56734
12726, 56102, 56322, 56332, 56112, 56103, 56323, 56333, 56113, 57397, 57427, 57428, 56735, 57400, 57430, 57431, 
56738, 56706, 57398, 57429, 56737
12727, 56103, 56323, 56333, 56113, 56104, 56324, 56334, 56114, 57400, 57430, 57431, 56738, 57403, 57433, 57434, 
56741, 56709, 57401, 57432, 56740
12728, 56104, 56324, 56334, 56114, 12406, 12428, 12429, 12407, 57403, 57433, 57434, 56741, 12503, 12504, 12505, 
12459, 56712, 57404, 57435, 56743
12729, 12179, 12201, 12202, 12180, 56105, 56325, 56335, 56115, 12276, 12279, 12278, 12234, 57407, 57437, 57438, 
56745, 56713, 57405, 57436, 56744
12730, 56105, 56325, 56335, 56115, 56106, 56326, 56336, 56116, 57407, 57437, 57438, 56745, 57410, 57440, 57441, 
56748, 56716, 57408, 57439, 56747
12731, 56106, 56326, 56336, 56116, 56107, 56327, 56337, 56117, 57410, 57440, 57441, 56748, 57413, 57443, 57444, 
56751, 56719, 57411, 57442, 56750
12732, 56107, 56327, 56337, 56117, 56108, 56328, 56338, 56118, 57413, 57443, 57444, 56751, 57416, 57446, 57447, 
56754, 56722, 57414, 57445, 56753
12733, 56108, 56328, 56338, 56118, 56109, 56329, 56339, 56119, 57416, 57446, 57447, 56754, 57419, 57449, 57450, 
56757, 56725, 57417, 57448, 56756
12734, 56109, 56329, 56339, 56119, 56110, 56330, 56340, 56120, 57419, 57449, 57450, 56757, 57422, 57452, 57453, 
56760, 56728, 57420, 57451, 56759
12735, 56110, 56330, 56340, 56120, 56111, 56331, 56341, 56121, 57422, 57452, 57453, 56760, 57425, 57455, 57456, 
56763, 56731, 57423, 57454, 56762
12736, 56111, 56331, 56341, 56121, 56112, 56332, 56342, 56122, 57425, 57455, 57456, 56763, 57428, 57458, 57459, 
56766, 56734, 57426, 57457, 56765
12737, 56112, 56332, 56342, 56122, 56113, 56333, 56343, 56123, 57428, 57458, 57459, 56766, 57431, 57461, 57462, 
56769, 56737, 57429, 57460, 56768
12738, 56113, 56333, 56343, 56123, 56114, 56334, 56344, 56124, 57431, 57461, 57462, 56769, 57434, 57464, 57465, 
56772, 56740, 57432, 57463, 56771
12739, 56114, 56334, 56344, 56124, 12407, 12429, 12430, 12408, 57434, 57464, 57465, 56772, 12505, 12506, 12507, 
12461, 56743, 57435, 57466, 56774
12740, 12180, 12202, 12203, 12181, 56115, 56335, 56345, 56125, 12278, 12281, 12280, 12236, 57438, 57468, 57469, 
56776, 56744, 57436, 57467, 56775
12741, 56115, 56335, 56345, 56125, 56116, 56336, 56346, 56126, 57438, 57468, 57469, 56776, 57441, 57471, 57472, 
56779, 56747, 57439, 57470, 56778
12742, 56116, 56336, 56346, 56126, 56117, 56337, 56347, 56127, 57441, 57471, 57472, 56779, 57444, 57474, 57475, 
56782, 56750, 57442, 57473, 56781
12743, 56117, 56337, 56347, 56127, 56118, 56338, 56348, 56128, 57444, 57474, 57475, 56782, 57447, 57477, 57478, 
56785, 56753, 57445, 57476, 56784
12744, 56118, 56338, 56348, 56128, 56119, 56339, 56349, 56129, 57447, 57477, 57478, 56785, 57450, 57480, 57481, 
56788, 56756, 57448, 57479, 56787
12745, 56119, 56339, 56349, 56129, 56120, 56340, 56350, 56130, 57450, 57480, 57481, 56788, 57453, 57483, 57484, 
56791, 56759, 57451, 57482, 56790
12746, 56120, 56340, 56350, 56130, 56121, 56341, 56351, 56131, 57453, 57483, 57484, 56791, 57456, 57486, 57487, 
56794, 56762, 57454, 57485, 56793
12747, 56121, 56341, 56351, 56131, 56122, 56342, 56352, 56132, 57456, 57486, 57487, 56794, 57459, 57489, 57490, 
56797, 56765, 57457, 57488, 56796
12748, 56122, 56342, 56352, 56132, 56123, 56343, 56353, 56133, 57459, 57489, 57490, 56797, 57462, 57492, 57493, 
56800, 56768, 57460, 57491, 56799
12749, 56123, 56343, 56353, 56133, 56124, 56344, 56354, 56134, 57462, 57492, 57493, 56800, 57465, 57495, 57496, 
56803, 56771, 57463, 57494, 56802
12750, 56124, 56344, 56354, 56134, 12408, 12430, 12431, 12409, 57465, 57495, 57496, 56803, 12507, 12508, 12509, 
12463, 56774, 57466, 57497, 56805
12751, 12181, 12203, 12204, 12182, 56125, 56345, 56355, 56135, 12280, 12283, 12282, 12238, 57469, 57499, 57500, 
56807, 56775, 57467, 57498, 56806
12752, 56125, 56345, 56355, 56135, 56126, 56346, 56356, 56136, 57469, 57499, 57500, 56807, 57472, 57502, 57503, 
56810, 56778, 57470, 57501, 56809
12753, 56126, 56346, 56356, 56136, 56127, 56347, 56357, 56137, 57472, 57502, 57503, 56810, 57475, 57505, 57506, 
56813, 56781, 57473, 57504, 56812
12754, 56127, 56347, 56357, 56137, 56128, 56348, 56358, 56138, 57475, 57505, 57506, 56813, 57478, 57508, 57509, 
56816, 56784, 57476, 57507, 56815
12755, 56128, 56348, 56358, 56138, 56129, 56349, 56359, 56139, 57478, 57508, 57509, 56816, 57481, 57511, 57512, 
56819, 56787, 57479, 57510, 56818
12756, 56129, 56349, 56359, 56139, 56130, 56350, 56360, 56140, 57481, 57511, 57512, 56819, 57484, 57514, 57515, 
56822, 56790, 57482, 57513, 56821
12757, 56130, 56350, 56360, 56140, 56131, 56351, 56361, 56141, 57484, 57514, 57515, 56822, 57487, 57517, 57518, 
56825, 56793, 57485, 57516, 56824
12758, 56131, 56351, 56361, 56141, 56132, 56352, 56362, 56142, 57487, 57517, 57518, 56825, 57490, 57520, 57521, 
56828, 56796, 57488, 57519, 56827
12759, 56132, 56352, 56362, 56142, 56133, 56353, 56363, 56143, 57490, 57520, 57521, 56828, 57493, 57523, 57524, 
56831, 56799, 57491, 57522, 56830
12760, 56133, 56353, 56363, 56143, 56134, 56354, 56364, 56144, 57493, 57523, 57524, 56831, 57496, 57526, 57527, 
56834, 56802, 57494, 57525, 56833
12761, 56134, 56354, 56364, 56144, 12409, 12431, 12432, 12410, 57496, 57526, 57527, 56834, 12509, 12510, 12511, 
12465, 56805, 57497, 57528, 56836
12762, 12182, 12204, 12205, 12183, 56135, 56355, 56365, 56145, 12282, 12285, 12284, 12240, 57500, 57530, 57531, 
56838, 56806, 57498, 57529, 56837
12763, 56135, 56355, 56365, 56145, 56136, 56356, 56366, 56146, 57500, 57530, 57531, 56838, 57503, 57533, 57534, 
56841, 56809, 57501, 57532, 56840
12764, 56136, 56356, 56366, 56146, 56137, 56357, 56367, 56147, 57503, 57533, 57534, 56841, 57506, 57536, 57537, 
56844, 56812, 57504, 57535, 56843
12765, 56137, 56357, 56367, 56147, 56138, 56358, 56368, 56148, 57506, 57536, 57537, 56844, 57509, 57539, 57540, 
56847, 56815, 57507, 57538, 56846
12766, 56138, 56358, 56368, 56148, 56139, 56359, 56369, 56149, 57509, 57539, 57540, 56847, 57512, 57542, 57543, 
56850, 56818, 57510, 57541, 56849
12767, 56139, 56359, 56369, 56149, 56140, 56360, 56370, 56150, 57512, 57542, 57543, 56850, 57515, 57545, 57546, 
56853, 56821, 57513, 57544, 56852
12768, 56140, 56360, 56370, 56150, 56141, 56361, 56371, 56151, 57515, 57545, 57546, 56853, 57518, 57548, 57549, 
56856, 56824, 57516, 57547, 56855
12769, 56141, 56361, 56371, 56151, 56142, 56362, 56372, 56152, 57518, 57548, 57549, 56856, 57521, 57551, 57552, 
56859, 56827, 57519, 57550, 56858
12770, 56142, 56362, 56372, 56152, 56143, 56363, 56373, 56153, 57521, 57551, 57552, 56859, 57524, 57554, 57555, 
56862, 56830, 57522, 57553, 56861
12771, 56143, 56363, 56373, 56153, 56144, 56364, 56374, 56154, 57524, 57554, 57555, 56862, 57527, 57557, 57558, 
56865, 56833, 57525, 57556, 56864
12772, 56144, 56364, 56374, 56154, 12410, 12432, 12433, 12411, 57527, 57557, 57558, 56865, 12511, 12512, 12513, 
12467, 56836, 57528, 57559, 56867
12773, 12183, 12205, 12206, 12184, 56145, 56365, 56375, 56155, 12284, 12287, 12286, 12242, 57531, 57561, 57562, 
56869, 56837, 57529, 57560, 56868
12774, 56145, 56365, 56375, 56155, 56146, 56366, 56376, 56156, 57531, 57561, 57562, 56869, 57534, 57564, 57565, 
56872, 56840, 57532, 57563, 56871
12775, 56146, 56366, 56376, 56156, 56147, 56367, 56377, 56157, 57534, 57564, 57565, 56872, 57537, 57567, 57568, 
56875, 56843, 57535, 57566, 56874
12776, 56147, 56367, 56377, 56157, 56148, 56368, 56378, 56158, 57537, 57567, 57568, 56875, 57540, 57570, 57571, 
56878, 56846, 57538, 57569, 56877
12777, 56148, 56368, 56378, 56158, 56149, 56369, 56379, 56159, 57540, 57570, 57571, 56878, 57543, 57573, 57574, 
56881, 56849, 57541, 57572, 56880
12778, 56149, 56369, 56379, 56159, 56150, 56370, 56380, 56160, 57543, 57573, 57574, 56881, 57546, 57576, 57577, 
56884, 56852, 57544, 57575, 56883
12779, 56150, 56370, 56380, 56160, 56151, 56371, 56381, 56161, 57546, 57576, 57577, 56884, 57549, 57579, 57580, 
56887, 56855, 57547, 57578, 56886
12780, 56151, 56371, 56381, 56161, 56152, 56372, 56382, 56162, 57549, 57579, 57580, 56887, 57552, 57582, 57583, 
56890, 56858, 57550, 57581, 56889
12781, 56152, 56372, 56382, 56162, 56153, 56373, 56383, 56163, 57552, 57582, 57583, 56890, 57555, 57585, 57586, 
56893, 56861, 57553, 57584, 56892
12782, 56153, 56373, 56383, 56163, 56154, 56374, 56384, 56164, 57555, 57585, 57586, 56893, 57558, 57588, 57589, 
56896, 56864, 57556, 57587, 56895
12783, 56154, 56374, 56384, 56164, 12411, 12433, 12434, 12412, 57558, 57588, 57589, 56896, 12513, 12514, 12515, 
12469, 56867, 57559, 57590, 56898
12784, 12184, 12206, 12207, 12185, 56155, 56375, 56385, 56165, 12286, 12289, 12288, 12244, 57562, 57592, 57593, 
56900, 56868, 57560, 57591, 56899
12785, 56155, 56375, 56385, 56165, 56156, 56376, 56386, 56166, 57562, 57592, 57593, 56900, 57565, 57595, 57596, 
56903, 56871, 57563, 57594, 56902
12786, 56156, 56376, 56386, 56166, 56157, 56377, 56387, 56167, 57565, 57595, 57596, 56903, 57568, 57598, 57599, 
56906, 56874, 57566, 57597, 56905
12787, 56157, 56377, 56387, 56167, 56158, 56378, 56388, 56168, 57568, 57598, 57599, 56906, 57571, 57601, 57602, 
56909, 56877, 57569, 57600, 56908
12788, 56158, 56378, 56388, 56168, 56159, 56379, 56389, 56169, 57571, 57601, 57602, 56909, 57574, 57604, 57605, 
56912, 56880, 57572, 57603, 56911
12789, 56159, 56379, 56389, 56169, 56160, 56380, 56390, 56170, 57574, 57604, 57605, 56912, 57577, 57607, 57608, 
56915, 56883, 57575, 57606, 56914
12790, 56160, 56380, 56390, 56170, 56161, 56381, 56391, 56171, 57577, 57607, 57608, 56915, 57580, 57610, 57611, 
56918, 56886, 57578, 57609, 56917
12791, 56161, 56381, 56391, 56171, 56162, 56382, 56392, 56172, 57580, 57610, 57611, 56918, 57583, 57613, 57614, 
56921, 56889, 57581, 57612, 56920
12792, 56162, 56382, 56392, 56172, 56163, 56383, 56393, 56173, 57583, 57613, 57614, 56921, 57586, 57616, 57617, 
56924, 56892, 57584, 57615, 56923
12793, 56163, 56383, 56393, 56173, 56164, 56384, 56394, 56174, 57586, 57616, 57617, 56924, 57589, 57619, 57620, 
56927, 56895, 57587, 57618, 56926
12794, 56164, 56384, 56394, 56174, 12412, 12434, 12435, 12413, 57589, 57619, 57620, 56927, 12515, 12516, 12517, 
12471, 56898, 57590, 57621, 56929
12795, 12185, 12207, 12208, 12186, 56165, 56385, 56395, 56175, 12288, 12291, 12290, 12246, 57593, 57623, 57624, 
56931, 56899, 57591, 57622, 56930
12796, 56165, 56385, 56395, 56175, 56166, 56386, 56396, 56176, 57593, 57623, 57624, 56931, 57596, 57626, 57627, 
56934, 56902, 57594, 57625, 56933
12797, 56166, 56386, 56396, 56176, 56167, 56387, 56397, 56177, 57596, 57626, 57627, 56934, 57599, 57629, 57630, 
56937, 56905, 57597, 57628, 56936
12798, 56167, 56387, 56397, 56177, 56168, 56388, 56398, 56178, 57599, 57629, 57630, 56937, 57602, 57632, 57633, 
56940, 56908, 57600, 57631, 56939
12799, 56168, 56388, 56398, 56178, 56169, 56389, 56399, 56179, 57602, 57632, 57633, 56940, 57605, 57635, 57636, 
56943, 56911, 57603, 57634, 56942
12800, 56169, 56389, 56399, 56179, 56170, 56390, 56400, 56180, 57605, 57635, 57636, 56943, 57608, 57638, 57639, 
56946, 56914, 57606, 57637, 56945
12801, 56170, 56390, 56400, 56180, 56171, 56391, 56401, 56181, 57608, 57638, 57639, 56946, 57611, 57641, 57642, 
56949, 56917, 57609, 57640, 56948
12802, 56171, 56391, 56401, 56181, 56172, 56392, 56402, 56182, 57611, 57641, 57642, 56949, 57614, 57644, 57645, 
56952, 56920, 57612, 57643, 56951
12803, 56172, 56392, 56402, 56182, 56173, 56393, 56403, 56183, 57614, 57644, 57645, 56952, 57617, 57647, 57648, 
56955, 56923, 57615, 57646, 56954
12804, 56173, 56393, 56403, 56183, 56174, 56394, 56404, 56184, 57617, 57647, 57648, 56955, 57620, 57650, 57651, 
56958, 56926, 57618, 57649, 56957
12805, 56174, 56394, 56404, 56184, 12413, 12435, 12436, 12414, 57620, 57650, 57651, 56958, 12517, 12518, 12519, 
12473, 56929, 57621, 57652, 56960
12806, 12186, 12208, 12209, 12187, 56175, 56395, 56405, 56185, 12290, 12293, 12292, 12248, 57624, 57654, 57655, 
56962, 56930, 57622, 57653, 56961
12807, 56175, 56395, 56405, 56185, 56176, 56396, 56406, 56186, 57624, 57654, 57655, 56962, 57627, 57657, 57658, 
56965, 56933, 57625, 57656, 56964
12808, 56176, 56396, 56406, 56186, 56177, 56397, 56407, 56187, 57627, 57657, 57658, 56965, 57630, 57660, 57661, 
56968, 56936, 57628, 57659, 56967
12809, 56177, 56397, 56407, 56187, 56178, 56398, 56408, 56188, 57630, 57660, 57661, 56968, 57633, 57663, 57664, 
56971, 56939, 57631, 57662, 56970
12810, 56178, 56398, 56408, 56188, 56179, 56399, 56409, 56189, 57633, 57663, 57664, 56971, 57636, 57666, 57667, 
56974, 56942, 57634, 57665, 56973
12811, 56179, 56399, 56409, 56189, 56180, 56400, 56410, 56190, 57636, 57666, 57667, 56974, 57639, 57669, 57670, 
56977, 56945, 57637, 57668, 56976
12812, 56180, 56400, 56410, 56190, 56181, 56401, 56411, 56191, 57639, 57669, 57670, 56977, 57642, 57672, 57673, 
56980, 56948, 57640, 57671, 56979
12813, 56181, 56401, 56411, 56191, 56182, 56402, 56412, 56192, 57642, 57672, 57673, 56980, 57645, 57675, 57676, 
56983, 56951, 57643, 57674, 56982
12814, 56182, 56402, 56412, 56192, 56183, 56403, 56413, 56193, 57645, 57675, 57676, 56983, 57648, 57678, 57679, 
56986, 56954, 57646, 57677, 56985
12815, 56183, 56403, 56413, 56193, 56184, 56404, 56414, 56194, 57648, 57678, 57679, 56986, 57651, 57681, 57682, 
56989, 56957, 57649, 57680, 56988
12816, 56184, 56404, 56414, 56194, 12414, 12436, 12437, 12415, 57651, 57681, 57682, 56989, 12519, 12520, 12521, 
12475, 56960, 57652, 57683, 56991
12817, 12187, 12209, 12210, 12188, 56185, 56405, 56415, 56195, 12292, 12295, 12294, 12250, 57655, 57685, 57686, 
56993, 56961, 57653, 57684, 56992
12818, 56185, 56405, 56415, 56195, 56186, 56406, 56416, 56196, 57655, 57685, 57686, 56993, 57658, 57688, 57689, 
56996, 56964, 57656, 57687, 56995
12819, 56186, 56406, 56416, 56196, 56187, 56407, 56417, 56197, 57658, 57688, 57689, 56996, 57661, 57691, 57692, 
56999, 56967, 57659, 57690, 56998
12820, 56187, 56407, 56417, 56197, 56188, 56408, 56418, 56198, 57661, 57691, 57692, 56999, 57664, 57694, 57695, 
57002, 56970, 57662, 57693, 57001
12821, 56188, 56408, 56418, 56198, 56189, 56409, 56419, 56199, 57664, 57694, 57695, 57002, 57667, 57697, 57698, 
57005, 56973, 57665, 57696, 57004
12822, 56189, 56409, 56419, 56199, 56190, 56410, 56420, 56200, 57667, 57697, 57698, 57005, 57670, 57700, 57701, 
57008, 56976, 57668, 57699, 57007
12823, 56190, 56410, 56420, 56200, 56191, 56411, 56421, 56201, 57670, 57700, 57701, 57008, 57673, 57703, 57704, 
57011, 56979, 57671, 57702, 57010
12824, 56191, 56411, 56421, 56201, 56192, 56412, 56422, 56202, 57673, 57703, 57704, 57011, 57676, 57706, 57707, 
57014, 56982, 57674, 57705, 57013
12825, 56192, 56412, 56422, 56202, 56193, 56413, 56423, 56203, 57676, 57706, 57707, 57014, 57679, 57709, 57710, 
57017, 56985, 57677, 57708, 57016
12826, 56193, 56413, 56423, 56203, 56194, 56414, 56424, 56204, 57679, 57709, 57710, 57017, 57682, 57712, 57713, 
57020, 56988, 57680, 57711, 57019
12827, 56194, 56414, 56424, 56204, 12415, 12437, 12438, 12416, 57682, 57712, 57713, 57020, 12521, 12522, 12523, 
12477, 56991, 57683, 57714, 57022
12828, 12188, 12210, 12211, 12189, 56195, 56415, 56425, 56205, 12294, 12297, 12296, 12252, 57686, 57716, 57717, 
57024, 56992, 57684, 57715, 57023
12829, 56195, 56415, 56425, 56205, 56196, 56416, 56426, 56206, 57686, 57716, 57717, 57024, 57689, 57719, 57720, 
57027, 56995, 57687, 57718, 57026
12830, 56196, 56416, 56426, 56206, 56197, 56417, 56427, 56207, 57689, 57719, 57720, 57027, 57692, 57722, 57723, 
57030, 56998, 57690, 57721, 57029
12831, 56197, 56417, 56427, 56207, 56198, 56418, 56428, 56208, 57692, 57722, 57723, 57030, 57695, 57725, 57726, 
57033, 57001, 57693, 57724, 57032
12832, 56198, 56418, 56428, 56208, 56199, 56419, 56429, 56209, 57695, 57725, 57726, 57033, 57698, 57728, 57729, 
57036, 57004, 57696, 57727, 57035
12833, 56199, 56419, 56429, 56209, 56200, 56420, 56430, 56210, 57698, 57728, 57729, 57036, 57701, 57731, 57732, 
57039, 57007, 57699, 57730, 57038
12834, 56200, 56420, 56430, 56210, 56201, 56421, 56431, 56211, 57701, 57731, 57732, 57039, 57704, 57734, 57735, 
57042, 57010, 57702, 57733, 57041
12835, 56201, 56421, 56431, 56211, 56202, 56422, 56432, 56212, 57704, 57734, 57735, 57042, 57707, 57737, 57738, 
57045, 57013, 57705, 57736, 57044
12836, 56202, 56422, 56432, 56212, 56203, 56423, 56433, 56213, 57707, 57737, 57738, 57045, 57710, 57740, 57741, 
57048, 57016, 57708, 57739, 57047
12837, 56203, 56423, 56433, 56213, 56204, 56424, 56434, 56214, 57710, 57740, 57741, 57048, 57713, 57743, 57744, 
57051, 57019, 57711, 57742, 57050
12838, 56204, 56424, 56434, 56214, 12416, 12438, 12439, 12417, 57713, 57743, 57744, 57051, 12523, 12524, 12525, 
12479, 57022, 57714, 57745, 57053
12839, 12189, 12211, 12212, 12190, 56205, 56425, 56435, 56215, 12296, 12299, 12298, 12254, 57717, 57747, 57748, 
57055, 57023, 57715, 57746, 57054
12840, 56205, 56425, 56435, 56215, 56206, 56426, 56436, 56216, 57717, 57747, 57748, 57055, 57720, 57750, 57751, 
57058, 57026, 57718, 57749, 57057
12841, 56206, 56426, 56436, 56216, 56207, 56427, 56437, 56217, 57720, 57750, 57751, 57058, 57723, 57753, 57754, 
57061, 57029, 57721, 57752, 57060
12842, 56207, 56427, 56437, 56217, 56208, 56428, 56438, 56218, 57723, 57753, 57754, 57061, 57726, 57756, 57757, 
57064, 57032, 57724, 57755, 57063
12843, 56208, 56428, 56438, 56218, 56209, 56429, 56439, 56219, 57726, 57756, 57757, 57064, 57729, 57759, 57760, 
57067, 57035, 57727, 57758, 57066
12844, 56209, 56429, 56439, 56219, 56210, 56430, 56440, 56220, 57729, 57759, 57760, 57067, 57732, 57762, 57763, 
57070, 57038, 57730, 57761, 57069
12845, 56210, 56430, 56440, 56220, 56211, 56431, 56441, 56221, 57732, 57762, 57763, 57070, 57735, 57765, 57766, 
57073, 57041, 57733, 57764, 57072
12846, 56211, 56431, 56441, 56221, 56212, 56432, 56442, 56222, 57735, 57765, 57766, 57073, 57738, 57768, 57769, 
57076, 57044, 57736, 57767, 57075
12847, 56212, 56432, 56442, 56222, 56213, 56433, 56443, 56223, 57738, 57768, 57769, 57076, 57741, 57771, 57772, 
57079, 57047, 57739, 57770, 57078
12848, 56213, 56433, 56443, 56223, 56214, 56434, 56444, 56224, 57741, 57771, 57772, 57079, 57744, 57774, 57775, 
57082, 57050, 57742, 57773, 57081
12849, 56214, 56434, 56444, 56224, 12417, 12439, 12440, 12418, 57744, 57774, 57775, 57082, 12525, 12526, 12527, 
12481, 57053, 57745, 57776, 57084
12850, 12190, 12212, 12213, 12191, 56215, 56435, 56445, 56225, 12298, 12301, 12300, 12256, 57748, 57778, 57779, 
57086, 57054, 57746, 57777, 57085
12851, 56215, 56435, 56445, 56225, 56216, 56436, 56446, 56226, 57748, 57778, 57779, 57086, 57751, 57781, 57782, 
57089, 57057, 57749, 57780, 57088
12852, 56216, 56436, 56446, 56226, 56217, 56437, 56447, 56227, 57751, 57781, 57782, 57089, 57754, 57784, 57785, 
57092, 57060, 57752, 57783, 57091
12853, 56217, 56437, 56447, 56227, 56218, 56438, 56448, 56228, 57754, 57784, 57785, 57092, 57757, 57787, 57788, 
57095, 57063, 57755, 57786, 57094
12854, 56218, 56438, 56448, 56228, 56219, 56439, 56449, 56229, 57757, 57787, 57788, 57095, 57760, 57790, 57791, 
57098, 57066, 57758, 57789, 57097
12855, 56219, 56439, 56449, 56229, 56220, 56440, 56450, 56230, 57760, 57790, 57791, 57098, 57763, 57793, 57794, 
57101, 57069, 57761, 57792, 57100
12856, 56220, 56440, 56450, 56230, 56221, 56441, 56451, 56231, 57763, 57793, 57794, 57101, 57766, 57796, 57797, 
57104, 57072, 57764, 57795, 57103
12857, 56221, 56441, 56451, 56231, 56222, 56442, 56452, 56232, 57766, 57796, 57797, 57104, 57769, 57799, 57800, 
57107, 57075, 57767, 57798, 57106
12858, 56222, 56442, 56452, 56232, 56223, 56443, 56453, 56233, 57769, 57799, 57800, 57107, 57772, 57802, 57803, 
57110, 57078, 57770, 57801, 57109
12859, 56223, 56443, 56453, 56233, 56224, 56444, 56454, 56234, 57772, 57802, 57803, 57110, 57775, 57805, 57806, 
57113, 57081, 57773, 57804, 57112
12860, 56224, 56444, 56454, 56234, 12418, 12440, 12441, 12419, 57775, 57805, 57806, 57113, 12527, 12528, 12529, 
12483, 57084, 57776, 57807, 57115
12861, 12191, 12213, 12214, 12192, 56225, 56445, 56455, 56235, 12300, 12303, 12302, 12258, 57779, 57809, 57810, 
57117, 57085, 57777, 57808, 57116
12862, 56225, 56445, 56455, 56235, 56226, 56446, 56456, 56236, 57779, 57809, 57810, 57117, 57782, 57812, 57813, 
57120, 57088, 57780, 57811, 57119
12863, 56226, 56446, 56456, 56236, 56227, 56447, 56457, 56237, 57782, 57812, 57813, 57120, 57785, 57815, 57816, 
57123, 57091, 57783, 57814, 57122
12864, 56227, 56447, 56457, 56237, 56228, 56448, 56458, 56238, 57785, 57815, 57816, 57123, 57788, 57818, 57819, 
57126, 57094, 57786, 57817, 57125
12865, 56228, 56448, 56458, 56238, 56229, 56449, 56459, 56239, 57788, 57818, 57819, 57126, 57791, 57821, 57822, 
57129, 57097, 57789, 57820, 57128
12866, 56229, 56449, 56459, 56239, 56230, 56450, 56460, 56240, 57791, 57821, 57822, 57129, 57794, 57824, 57825, 
57132, 57100, 57792, 57823, 57131
12867, 56230, 56450, 56460, 56240, 56231, 56451, 56461, 56241, 57794, 57824, 57825, 57132, 57797, 57827, 57828, 
57135, 57103, 57795, 57826, 57134
12868, 56231, 56451, 56461, 56241, 56232, 56452, 56462, 56242, 57797, 57827, 57828, 57135, 57800, 57830, 57831, 
57138, 57106, 57798, 57829, 57137
12869, 56232, 56452, 56462, 56242, 56233, 56453, 56463, 56243, 57800, 57830, 57831, 57138, 57803, 57833, 57834, 
57141, 57109, 57801, 57832, 57140
12870, 56233, 56453, 56463, 56243, 56234, 56454, 56464, 56244, 57803, 57833, 57834, 57141, 57806, 57836, 57837, 
57144, 57112, 57804, 57835, 57143
12871, 56234, 56454, 56464, 56244, 12419, 12441, 12442, 12420, 57806, 57836, 57837, 57144, 12529, 12530, 12531, 
12485, 57115, 57807, 57838, 57146
12872, 12192, 12214, 979, 978, 56235, 56455, 12574, 12564, 12302, 12304, 981, 12259, 57810, 57839, 12615, 
57147, 57116, 57808, 12616, 12595
12873, 56235, 56455, 12574, 12564, 56236, 56456, 12573, 12563, 57810, 57839, 12615, 57147, 57813, 57840, 12613, 
57148, 57119, 57811, 12614, 12593
12874, 56236, 56456, 12573, 12563, 56237, 56457, 12572, 12562, 57813, 57840, 12613, 57148, 57816, 57841, 12611, 
57149, 57122, 57814, 12612, 12591
12875, 56237, 56457, 12572, 12562, 56238, 56458, 12571, 12561, 57816, 57841, 12611, 57149, 57819, 57842, 12609, 
57150, 57125, 57817, 12610, 12589
12876, 56238, 56458, 12571, 12561, 56239, 56459, 12570, 12560, 57819, 57842, 12609, 57150, 57822, 57843, 12607, 
57151, 57128, 57820, 12608, 12587
12877, 56239, 56459, 12570, 12560, 56240, 56460, 12569, 12559, 57822, 57843, 12607, 57151, 57825, 57844, 12605, 
57152, 57131, 57823, 12606, 12585
12878, 56240, 56460, 12569, 12559, 56241, 56461, 12568, 12558, 57825, 57844, 12605, 57152, 57828, 57845, 12603, 
57153, 57134, 57826, 12604, 12583
12879, 56241, 56461, 12568, 12558, 56242, 56462, 12567, 12557, 57828, 57845, 12603, 57153, 57831, 57846, 12601, 
57154, 57137, 57829, 12602, 12581
12880, 56242, 56462, 12567, 12557, 56243, 56463, 12566, 12556, 57831, 57846, 12601, 57154, 57834, 57847, 12599, 
57155, 57140, 57832, 12600, 12579
12881, 56243, 56463, 12566, 12556, 56244, 56464, 12565, 12555, 57834, 57847, 12599, 57155, 57837, 57848, 12597, 
57156, 57143, 57835, 12598, 12577
12882, 56244, 56464, 12565, 12555, 12420, 12442, 1055, 1054, 57837, 57848, 12597, 57156, 12531, 12532, 1057, 
12487, 57146, 57838, 12596, 12575
12883, 974, 21, 1004, 12193, 12346, 1033, 12837, 56245, 977, 1027, 12305, 12261, 12398, 13309, 57849, 
57158, 12388, 1043, 13289, 57157
12884, 12346, 1033, 12837, 56245, 12345, 1034, 12838, 56246, 12398, 13309, 57849, 57158, 12397, 13310, 57850, 
57161, 12387, 1044, 13291, 57160
12885, 12345, 1034, 12838, 56246, 12344, 1035, 12839, 56247, 12397, 13310, 57850, 57161, 12396, 13311, 57851, 
57164, 12385, 1045, 13293, 57163
12886, 12344, 1035, 12839, 56247, 12343, 1036, 12840, 56248, 12396, 13311, 57851, 57164, 12395, 13312, 57852, 
57167, 12383, 1046, 13295, 57166
12887, 12343, 1036, 12840, 56248, 12342, 1037, 12841, 56249, 12395, 13312, 57852, 57167, 12394, 13313, 57853, 
57170, 12381, 1047, 13297, 57169
12888, 12342, 1037, 12841, 56249, 12341, 1038, 12842, 56250, 12394, 13313, 57853, 57170, 12393, 13314, 57854, 
57173, 12379, 1048, 13299, 57172
12889, 12341, 1038, 12842, 56250, 12340, 1039, 12843, 56251, 12393, 13314, 57854, 57173, 12392, 13315, 57855, 
57176, 12377, 1049, 13301, 57175
12890, 12340, 1039, 12843, 56251, 12339, 1040, 12844, 56252, 12392, 13315, 57855, 57176, 12391, 13316, 57856, 
57179, 12375, 1050, 13303, 57178
12891, 12339, 1040, 12844, 56252, 12338, 1041, 12845, 56253, 12391, 13316, 57856, 57179, 12390, 13317, 57857, 
57182, 12373, 1051, 13305, 57181
12892, 12338, 1041, 12845, 56253, 12337, 1042, 12846, 56254, 12390, 13317, 57857, 57182, 12389, 13318, 57858, 
57185, 12371, 1052, 13307, 57184
12893, 12337, 1042, 12846, 56254, 1029, 23, 1080, 12421, 12389, 13318, 57858, 57185, 1032, 1103, 12533, 
12488, 12369, 1053, 13308, 57187
12894, 12193, 1004, 1003, 12194, 56245, 12837, 12827, 56255, 12305, 1026, 12306, 12263, 57849, 13288, 57859, 
57189, 57157, 13289, 13268, 57188
12895, 56245, 12837, 12827, 56255, 56246, 12838, 12828, 56256, 57849, 13288, 57859, 57189, 57850, 13290, 57860, 
57192, 57160, 13291, 13270, 57191
12896, 56246, 12838, 12828, 56256, 56247, 12839, 12829, 56257, 57850, 13290, 57860, 57192, 57851, 13292, 57861, 
57195, 57163, 13293, 13272, 57194
12897, 56247, 12839, 12829, 56257, 56248, 12840, 12830, 56258, 57851, 13292, 57861, 57195, 57852, 13294, 57862, 
57198, 57166, 13295, 13274, 57197
12898, 56248, 12840, 12830, 56258, 56249, 12841, 12831, 56259, 57852, 13294, 57862, 57198, 57853, 13296, 57863, 
57201, 57169, 13297, 13276, 57200
12899, 56249, 12841, 12831, 56259, 56250, 12842, 12832, 56260, 57853, 13296, 57863, 57201, 57854, 13298, 57864, 
57204, 57172, 13299, 13278, 57203
12900, 56250, 12842, 12832, 56260, 56251, 12843, 12833, 56261, 57854, 13298, 57864, 57204, 57855, 13300, 57865, 
57207, 57175, 13301, 13280, 57206
12901, 56251, 12843, 12833, 56261, 56252, 12844, 12834, 56262, 57855, 13300, 57865, 57207, 57856, 13302, 57866, 
57210, 57178, 13303, 13282, 57209
12902, 56252, 12844, 12834, 56262, 56253, 12845, 12835, 56263, 57856, 13302, 57866, 57210, 57857, 13304, 57867, 
57213, 57181, 13305, 13284, 57212
12903, 56253, 12845, 12835, 56263, 56254, 12846, 12836, 56264, 57857, 13304, 57867, 57213, 57858, 13306, 57868, 
57216, 57184, 13307, 13286, 57215
12904, 56254, 12846, 12836, 56264, 12421, 1080, 1079, 12422, 57858, 13306, 57868, 57216, 12533, 1102, 12534, 
12490, 57187, 13308, 13287, 57218
12905, 12194, 1003, 1002, 12195, 56255, 12827, 12817, 56265, 12306, 1025, 12307, 12265, 57859, 13267, 57869, 
57220, 57188, 13268, 13247, 57219
12906, 56255, 12827, 12817, 56265, 56256, 12828, 12818, 56266, 57859, 13267, 57869, 57220, 57860, 13269, 57870, 
57223, 57191, 13270, 13249, 57222
12907, 56256, 12828, 12818, 56266, 56257, 12829, 12819, 56267, 57860, 13269, 57870, 57223, 57861, 13271, 57871, 
57226, 57194, 13272, 13251, 57225
12908, 56257, 12829, 12819, 56267, 56258, 12830, 12820, 56268, 57861, 13271, 57871, 57226, 57862, 13273, 57872, 
57229, 57197, 13274, 13253, 57228
12909, 56258, 12830, 12820, 56268, 56259, 12831, 12821, 56269, 57862, 13273, 57872, 57229, 57863, 13275, 57873, 
57232, 57200, 13276, 13255, 57231
12910, 56259, 12831, 12821, 56269, 56260, 12832, 12822, 56270, 57863, 13275, 57873, 57232, 57864, 13277, 57874, 
57235, 57203, 13278, 13257, 57234
12911, 56260, 12832, 12822, 56270, 56261, 12833, 12823, 56271, 57864, 13277, 57874, 57235, 57865, 13279, 57875, 
57238, 57206, 13280, 13259, 57237
12912, 56261, 12833, 12823, 56271, 56262, 12834, 12824, 56272, 57865, 13279, 57875, 57238, 57866, 13281, 57876, 
57241, 57209, 13282, 13261, 57240
12913, 56262, 12834, 12824, 56272, 56263, 12835, 12825, 56273, 57866, 13281, 57876, 57241, 57867, 13283, 57877, 
57244, 57212, 13284, 13263, 57243
12914, 56263, 12835, 12825, 56273, 56264, 12836, 12826, 56274, 57867, 13283, 57877, 57244, 57868, 13285, 57878, 
57247, 57215, 13286, 13265, 57246
12915, 56264, 12836, 12826, 56274, 12422, 1079, 1078, 12423, 57868, 13285, 57878, 57247, 12534, 1101, 12535, 
12492, 57218, 13287, 13266, 57249
12916, 12195, 1002, 1001, 12196, 56265, 12817, 12807, 56275, 12307, 1024, 12308, 12267, 57869, 13246, 57879, 
57251, 57219, 13247, 13226, 57250
12917, 56265, 12817, 12807, 56275, 56266, 12818, 12808, 56276, 57869, 13246, 57879, 57251, 57870, 13248, 57880, 
57254, 57222, 13249, 13228, 57253
12918, 56266, 12818, 12808, 56276, 56267, 12819, 12809, 56277, 57870, 13248, 57880, 57254, 57871, 13250, 57881, 
57257, 57225, 13251, 13230, 57256
12919, 56267, 12819, 12809, 56277, 56268, 12820, 12810, 56278, 57871, 13250, 57881, 57257, 57872, 13252, 57882, 
57260, 57228, 13253, 13232, 57259
12920, 56268, 12820, 12810, 56278, 56269, 12821, 12811, 56279, 57872, 13252, 57882, 57260, 57873, 13254, 57883, 
57263, 57231, 13255, 13234, 57262
12921, 56269, 12821, 12811, 56279, 56270, 12822, 12812, 56280, 57873, 13254, 57883, 57263, 57874, 13256, 57884, 
57266, 57234, 13257, 13236, 57265
12922, 56270, 12822, 12812, 56280, 56271, 12823, 12813, 56281, 57874, 13256, 57884, 57266, 57875, 13258, 57885, 
57269, 57237, 13259, 13238, 57268
12923, 56271, 12823, 12813, 56281, 56272, 12824, 12814, 56282, 57875, 13258, 57885, 57269, 57876, 13260, 57886, 
57272, 57240, 13261, 13240, 57271
12924, 56272, 12824, 12814, 56282, 56273, 12825, 12815, 56283, 57876, 13260, 57886, 57272, 57877, 13262, 57887, 
57275, 57243, 13263, 13242, 57274
12925, 56273, 12825, 12815, 56283, 56274, 12826, 12816, 56284, 57877, 13262, 57887, 57275, 57878, 13264, 57888, 
57278, 57246, 13265, 13244, 57277
12926, 56274, 12826, 12816, 56284, 12423, 1078, 1077, 12424, 57878, 13264, 57888, 57278, 12535, 1100, 12536, 
12494, 57249, 13266, 13245, 57280
12927, 12196, 1001, 1000, 12197, 56275, 12807, 12797, 56285, 12308, 1023, 12309, 12269, 57879, 13225, 57889, 
57282, 57250, 13226, 13205, 57281
12928, 56275, 12807, 12797, 56285, 56276, 12808, 12798, 56286, 57879, 13225, 57889, 57282, 57880, 13227, 57890, 
57285, 57253, 13228, 13207, 57284
12929, 56276, 12808, 12798, 56286, 56277, 12809, 12799, 56287, 57880, 13227, 57890, 57285, 57881, 13229, 57891, 
57288, 57256, 13230, 13209, 57287
12930, 56277, 12809, 12799, 56287, 56278, 12810, 12800, 56288, 57881, 13229, 57891, 57288, 57882, 13231, 57892, 
57291, 57259, 13232, 13211, 57290
12931, 56278, 12810, 12800, 56288, 56279, 12811, 12801, 56289, 57882, 13231, 57892, 57291, 57883, 13233, 57893, 
57294, 57262, 13234, 13213, 57293
12932, 56279, 12811, 12801, 56289, 56280, 12812, 12802, 56290, 57883, 13233, 57893, 57294, 57884, 13235, 57894, 
57297, 57265, 13236, 13215, 57296
12933, 56280, 12812, 12802, 56290, 56281, 12813, 12803, 56291, 57884, 13235, 57894, 57297, 57885, 13237, 57895, 
57300, 57268, 13238, 13217, 57299
12934, 56281, 12813, 12803, 56291, 56282, 12814, 12804, 56292, 57885, 13237, 57895, 57300, 57886, 13239, 57896, 
57303, 57271, 13240, 13219, 57302
12935, 56282, 12814, 12804, 56292, 56283, 12815, 12805, 56293, 57886, 13239, 57896, 57303, 57887, 13241, 57897, 
57306, 57274, 13242, 13221, 57305
12936, 56283, 12815, 12805, 56293, 56284, 12816, 12806, 56294, 57887, 13241, 57897, 57306, 57888, 13243, 57898, 
57309, 57277, 13244, 13223, 57308
12937, 56284, 12816, 12806, 56294, 12424, 1077, 1076, 12425, 57888, 13243, 57898, 57309, 12536, 1099, 12537, 
12496, 57280, 13245, 13224, 57311
12938, 12197, 1000, 999, 12198, 56285, 12797, 12787, 56295, 12309, 1022, 12310, 12271, 57889, 13204, 57899, 
57313, 57281, 13205, 13184, 57312
12939, 56285, 12797, 12787, 56295, 56286, 12798, 12788, 56296, 57889, 13204, 57899, 57313, 57890, 13206, 57900, 
57316, 57284, 13207, 13186, 57315
12940, 56286, 12798, 12788, 56296, 56287, 12799, 12789, 56297, 57890, 13206, 57900, 57316, 57891, 13208, 57901, 
57319, 57287, 13209, 13188, 57318
12941, 56287, 12799, 12789, 56297, 56288, 12800, 12790, 56298, 57891, 13208, 57901, 57319, 57892, 13210, 57902, 
57322, 57290, 13211, 13190, 57321
12942, 56288, 12800, 12790, 56298, 56289, 12801, 12791, 56299, 57892, 13210, 57902, 57322, 57893, 13212, 57903, 
57325, 57293, 13213, 13192, 57324
12943, 56289, 12801, 12791, 56299, 56290, 12802, 12792, 56300, 57893, 13212, 57903, 57325, 57894, 13214, 57904, 
57328, 57296, 13215, 13194, 57327
12944, 56290, 12802, 12792, 56300, 56291, 12803, 12793, 56301, 57894, 13214, 57904, 57328, 57895, 13216, 57905, 
57331, 57299, 13217, 13196, 57330
12945, 56291, 12803, 12793, 56301, 56292, 12804, 12794, 56302, 57895, 13216, 57905, 57331, 57896, 13218, 57906, 
57334, 57302, 13219, 13198, 57333
12946, 56292, 12804, 12794, 56302, 56293, 12805, 12795, 56303, 57896, 13218, 57906, 57334, 57897, 13220, 57907, 
57337, 57305, 13221, 13200, 57336
12947, 56293, 12805, 12795, 56303, 56294, 12806, 12796, 56304, 57897, 13220, 57907, 57337, 57898, 13222, 57908, 
57340, 57308, 13223, 13202, 57339
12948, 56294, 12806, 12796, 56304, 12425, 1076, 1075, 12426, 57898, 13222, 57908, 57340, 12537, 1098, 12538, 
12498, 57311, 13224, 13203, 57342
12949, 12198, 999, 998, 12199, 56295, 12787, 12777, 56305, 12310, 1021, 12311, 12273, 57899, 13183, 57909, 
57344, 57312, 13184, 13163, 57343
12950, 56295, 12787, 12777, 56305, 56296, 12788, 12778, 56306, 57899, 13183, 57909, 57344, 57900, 13185, 57910, 
57347, 57315, 13186, 13165, 57346
12951, 56296, 12788, 12778, 56306, 56297, 12789, 12779, 56307, 57900, 13185, 57910, 57347, 57901, 13187, 57911, 
57350, 57318, 13188, 13167, 57349
12952, 56297, 12789, 12779, 56307, 56298, 12790, 12780, 56308, 57901, 13187, 57911, 57350, 57902, 13189, 57912, 
57353, 57321, 13190, 13169, 57352
12953, 56298, 12790, 12780, 56308, 56299, 12791, 12781, 56309, 57902, 13189, 57912, 57353, 57903, 13191, 57913, 
57356, 57324, 13192, 13171, 57355
12954, 56299, 12791, 12781, 56309, 56300, 12792, 12782, 56310, 57903, 13191, 57913, 57356, 57904, 13193, 57914, 
57359, 57327, 13194, 13173, 57358
12955, 56300, 12792, 12782, 56310, 56301, 12793, 12783, 56311, 57904, 13193, 57914, 57359, 57905, 13195, 57915, 
57362, 57330, 13196, 13175, 57361
12956, 56301, 12793, 12783, 56311, 56302, 12794, 12784, 56312, 57905, 13195, 57915, 57362, 57906, 13197, 57916, 
57365, 57333, 13198, 13177, 57364
12957, 56302, 12794, 12784, 56312, 56303, 12795, 12785, 56313, 57906, 13197, 57916, 57365, 57907, 13199, 57917, 
57368, 57336, 13200, 13179, 57367
12958, 56303, 12795, 12785, 56313, 56304, 12796, 12786, 56314, 57907, 13199, 57917, 57368, 57908, 13201, 57918, 
57371, 57339, 13202, 13181, 57370
12959, 56304, 12796, 12786, 56314, 12426, 1075, 1074, 12427, 57908, 13201, 57918, 57371, 12538, 1097, 12539, 
12500, 57342, 13203, 13182, 57373
12960, 12199, 998, 997, 12200, 56305, 12777, 12767, 56315, 12311, 1020, 12312, 12275, 57909, 13162, 57919, 
57375, 57343, 13163, 13142, 57374
12961, 56305, 12777, 12767, 56315, 56306, 12778, 12768, 56316, 57909, 13162, 57919, 57375, 57910, 13164, 57920, 
57378, 57346, 13165, 13144, 57377
12962, 56306, 12778, 12768, 56316, 56307, 12779, 12769, 56317, 57910, 13164, 57920, 57378, 57911, 13166, 57921, 
57381, 57349, 13167, 13146, 57380
12963, 56307, 12779, 12769, 56317, 56308, 12780, 12770, 56318, 57911, 13166, 57921, 57381, 57912, 13168, 57922, 
57384, 57352, 13169, 13148, 57383
12964, 56308, 12780, 12770, 56318, 56309, 12781, 12771, 56319, 57912, 13168, 57922, 57384, 57913, 13170, 57923, 
57387, 57355, 13171, 13150, 57386
12965, 56309, 12781, 12771, 56319, 56310, 12782, 12772, 56320, 57913, 13170, 57923, 57387, 57914, 13172, 57924, 
57390, 57358, 13173, 13152, 57389
12966, 56310, 12782, 12772, 56320, 56311, 12783, 12773, 56321, 57914, 13172, 57924, 57390, 57915, 13174, 57925, 
57393, 57361, 13175, 13154, 57392
12967, 56311, 12783, 12773, 56321, 56312, 12784, 12774, 56322, 57915, 13174, 57925, 57393, 57916, 13176, 57926, 
57396, 57364, 13177, 13156, 57395
12968, 56312, 12784, 12774, 56322, 56313, 12785, 12775, 56323, 57916, 13176, 57926, 57396, 57917, 13178, 57927, 
57399, 57367, 13179, 13158, 57398
12969, 56313, 12785, 12775, 56323, 56314, 12786, 12776, 56324, 57917, 13178, 57927, 57399, 57918, 13180, 57928, 
57402, 57370, 13181, 13160, 57401
12970, 56314, 12786, 12776, 56324, 12427, 1074, 1073, 12428, 57918, 13180, 57928, 57402, 12539, 1096, 12540, 
12502, 57373, 13182, 13161, 57404
12971, 12200, 997, 996, 12201, 56315, 12767, 12757, 56325, 12312, 1019, 12313, 12277, 57919, 13141, 57929, 
57406, 57374, 13142, 13121, 57405
12972, 56315, 12767, 12757, 56325, 56316, 12768, 12758, 56326, 57919, 13141, 57929, 57406, 57920, 13143, 57930, 
57409, 57377, 13144, 13123, 57408
12973, 56316, 12768, 12758, 56326, 56317, 12769, 12759, 56327, 57920, 13143, 57930, 57409, 57921, 13145, 57931, 
57412, 57380, 13146, 13125, 57411
12974, 56317, 12769, 12759, 56327, 56318, 12770, 12760, 56328, 57921, 13145, 57931, 57412, 57922, 13147, 57932, 
57415, 57383, 13148, 13127, 57414
12975, 56318, 12770, 12760, 56328, 56319, 12771, 12761, 56329, 57922, 13147, 57932, 57415, 57923, 13149, 57933, 
57418, 57386, 13150, 13129, 57417
12976, 56319, 12771, 12761, 56329, 56320, 12772, 12762, 56330, 57923, 13149, 57933, 57418, 57924, 13151, 57934, 
57421, 57389, 13152, 13131, 57420
12977, 56320, 12772, 12762, 56330, 56321, 12773, 12763, 56331, 57924, 13151, 57934, 57421, 57925, 13153, 57935, 
57424, 57392, 13154, 13133, 57423
12978, 56321, 12773, 12763, 56331, 56322, 12774, 12764, 56332, 57925, 13153, 57935, 57424, 57926, 13155, 57936, 
57427, 57395, 13156, 13135, 57426
12979, 56322, 12774, 12764, 56332, 56323, 12775, 12765, 56333, 57926, 13155, 57936, 57427, 57927, 13157, 57937, 
57430, 57398, 13158, 13137, 57429
12980, 56323, 12775, 12765, 56333, 56324, 12776, 12766, 56334, 57927, 13157, 57937, 57430, 57928, 13159, 57938, 
57433, 57401, 13160, 13139, 57432
12981, 56324, 12776, 12766, 56334, 12428, 1073, 1072, 12429, 57928, 13159, 57938, 57433, 12540, 1095, 12541, 
12504, 57404, 13161, 13140, 57435
12982, 12201, 996, 995, 12202, 56325, 12757, 12747, 56335, 12313, 1018, 12314, 12279, 57929, 13120, 57939, 
57437, 57405, 13121, 13100, 57436
12983, 56325, 12757, 12747, 56335, 56326, 12758, 12748, 56336, 57929, 13120, 57939, 57437, 57930, 13122, 57940, 
57440, 57408, 13123, 13102, 57439
12984, 56326, 12758, 12748, 56336, 56327, 12759, 12749, 56337, 57930, 13122, 57940, 57440, 57931, 13124, 57941, 
57443, 57411, 13125, 13104, 57442
12985, 56327, 12759, 12749, 56337, 56328, 12760, 12750, 56338, 57931, 13124, 57941, 57443, 57932, 13126, 57942, 
57446, 57414, 13127, 13106, 57445
12986, 56328, 12760, 12750, 56338, 56329, 12761, 12751, 56339, 57932, 13126, 57942, 57446, 57933, 13128, 57943, 
57449, 57417, 13129, 13108, 57448
12987, 56329, 12761, 12751, 56339, 56330, 12762, 12752, 56340, 57933, 13128, 57943, 57449, 57934, 13130, 57944, 
57452, 57420, 13131, 13110, 57451
12988, 56330, 12762, 12752, 56340, 56331, 12763, 12753, 56341, 57934, 13130, 57944, 57452, 57935, 13132, 57945, 
57455, 57423, 13133, 13112, 57454
12989, 56331, 12763, 12753, 56341, 56332, 12764, 12754, 56342, 57935, 13132, 57945, 57455, 57936, 13134, 57946, 
57458, 57426, 13135, 13114, 57457
12990, 56332, 12764, 12754, 56342, 56333, 12765, 12755, 56343, 57936, 13134, 57946, 57458, 57937, 13136, 57947, 
57461, 57429, 13137, 13116, 57460
12991, 56333, 12765, 12755, 56343, 56334, 12766, 12756, 56344, 57937, 13136, 57947, 57461, 57938, 13138, 57948, 
57464, 57432, 13139, 13118, 57463
12992, 56334, 12766, 12756, 56344, 12429, 1072, 1071, 12430, 57938, 13138, 57948, 57464, 12541, 1094, 12542, 
12506, 57435, 13140, 13119, 57466
12993, 12202, 995, 994, 12203, 56335, 12747, 12737, 56345, 12314, 1017, 12315, 12281, 57939, 13099, 57949, 
57468, 57436, 13100, 13079, 57467
12994, 56335, 12747, 12737, 56345, 56336, 12748, 12738, 56346, 57939, 13099, 57949, 57468, 57940, 13101, 57950, 
57471, 57439, 13102, 13081, 57470
12995, 56336, 12748, 12738, 56346, 56337, 12749, 12739, 56347, 57940, 13101, 57950, 57471, 57941, 13103, 57951, 
57474, 57442, 13104, 13083, 57473
12996, 56337, 12749, 12739, 56347, 56338, 12750, 12740, 56348, 57941, 13103, 57951, 57474, 57942, 13105, 57952, 
57477, 57445, 13106, 13085, 57476
12997, 56338, 12750, 12740, 56348, 56339, 12751, 12741, 56349, 57942, 13105, 57952, 57477, 57943, 13107, 57953, 
57480, 57448, 13108, 13087, 57479
12998, 56339, 12751, 12741, 56349, 56340, 12752, 12742, 56350, 57943, 13107, 57953, 57480, 57944, 13109, 57954, 
57483, 57451, 13110, 13089, 57482
12999, 56340, 12752, 12742, 56350, 56341, 12753, 12743, 56351, 57944, 13109, 57954, 57483, 57945, 13111, 57955, 
57486, 57454, 13112, 13091, 57485
13000, 56341, 12753, 12743, 56351, 56342, 12754, 12744, 56352, 57945, 13111, 57955, 57486, 57946, 13113, 57956, 
57489, 57457, 13114, 13093, 57488
13001, 56342, 12754, 12744, 56352, 56343, 12755, 12745, 56353, 57946, 13113, 57956, 57489, 57947, 13115, 57957, 
57492, 57460, 13116, 13095, 57491
13002, 56343, 12755, 12745, 56353, 56344, 12756, 12746, 56354, 57947, 13115, 57957, 57492, 57948, 13117, 57958, 
57495, 57463, 13118, 13097, 57494
13003, 56344, 12756, 12746, 56354, 12430, 1071, 1070, 12431, 57948, 13117, 57958, 57495, 12542, 1093, 12543, 
12508, 57466, 13119, 13098, 57497
13004, 12203, 994, 993, 12204, 56345, 12737, 12727, 56355, 12315, 1016, 12316, 12283, 57949, 13078, 57959, 
57499, 57467, 13079, 13058, 57498
13005, 56345, 12737, 12727, 56355, 56346, 12738, 12728, 56356, 57949, 13078, 57959, 57499, 57950, 13080, 57960, 
57502, 57470, 13081, 13060, 57501
13006, 56346, 12738, 12728, 56356, 56347, 12739, 12729, 56357, 57950, 13080, 57960, 57502, 57951, 13082, 57961, 
57505, 57473, 13083, 13062, 57504
13007, 56347, 12739, 12729, 56357, 56348, 12740, 12730, 56358, 57951, 13082, 57961, 57505, 57952, 13084, 57962, 
57508, 57476, 13085, 13064, 57507
13008, 56348, 12740, 12730, 56358, 56349, 12741, 12731, 56359, 57952, 13084, 57962, 57508, 57953, 13086, 57963, 
57511, 57479, 13087, 13066, 57510
13009, 56349, 12741, 12731, 56359, 56350, 12742, 12732, 56360, 57953, 13086, 57963, 57511, 57954, 13088, 57964, 
57514, 57482, 13089, 13068, 57513
13010, 56350, 12742, 12732, 56360, 56351, 12743, 12733, 56361, 57954, 13088, 57964, 57514, 57955, 13090, 57965, 
57517, 57485, 13091, 13070, 57516
13011, 56351, 12743, 12733, 56361, 56352, 12744, 12734, 56362, 57955, 13090, 57965, 57517, 57956, 13092, 57966, 
57520, 57488, 13093, 13072, 57519
13012, 56352, 12744, 12734, 56362, 56353, 12745, 12735, 56363, 57956, 13092, 57966, 57520, 57957, 13094, 57967, 
57523, 57491, 13095, 13074, 57522
13013, 56353, 12745, 12735, 56363, 56354, 12746, 12736, 56364, 57957, 13094, 57967, 57523, 57958, 13096, 57968, 
57526, 57494, 13097, 13076, 57525
13014, 56354, 12746, 12736, 56364, 12431, 1070, 1069, 12432, 57958, 13096, 57968, 57526, 12543, 1092, 12544, 
12510, 57497, 13098, 13077, 57528
13015, 12204, 993, 992, 12205, 56355, 12727, 12717, 56365, 12316, 1015, 12317, 12285, 57959, 13057, 57969, 
57530, 57498, 13058, 13037, 57529
13016, 56355, 12727, 12717, 56365, 56356, 12728, 12718, 56366, 57959, 13057, 57969, 57530, 57960, 13059, 57970, 
57533, 57501, 13060, 13039, 57532
13017, 56356, 12728, 12718, 56366, 56357, 12729, 12719, 56367, 57960, 13059, 57970, 57533, 57961, 13061, 57971, 
57536, 57504, 13062, 13041, 57535
13018, 56357, 12729, 12719, 56367, 56358, 12730, 12720, 56368, 57961, 13061, 57971, 57536, 57962, 13063, 57972, 
57539, 57507, 13064, 13043, 57538
13019, 56358, 12730, 12720, 56368, 56359, 12731, 12721, 56369, 57962, 13063, 57972, 57539, 57963, 13065, 57973, 
57542, 57510, 13066, 13045, 57541
13020, 56359, 12731, 12721, 56369, 56360, 12732, 12722, 56370, 57963, 13065, 57973, 57542, 57964, 13067, 57974, 
57545, 57513, 13068, 13047, 57544
13021, 56360, 12732, 12722, 56370, 56361, 12733, 12723, 56371, 57964, 13067, 57974, 57545, 57965, 13069, 57975, 
57548, 57516, 13070, 13049, 57547
13022, 56361, 12733, 12723, 56371, 56362, 12734, 12724, 56372, 57965, 13069, 57975, 57548, 57966, 13071, 57976, 
57551, 57519, 13072, 13051, 57550
13023, 56362, 12734, 12724, 56372, 56363, 12735, 12725, 56373, 57966, 13071, 57976, 57551, 57967, 13073, 57977, 
57554, 57522, 13074, 13053, 57553
13024, 56363, 12735, 12725, 56373, 56364, 12736, 12726, 56374, 57967, 13073, 57977, 57554, 57968, 13075, 57978, 
57557, 57525, 13076, 13055, 57556
13025, 56364, 12736, 12726, 56374, 12432, 1069, 1068, 12433, 57968, 13075, 57978, 57557, 12544, 1091, 12545, 
12512, 57528, 13077, 13056, 57559
13026, 12205, 992, 991, 12206, 56365, 12717, 12707, 56375, 12317, 1014, 12318, 12287, 57969, 13036, 57979, 
57561, 57529, 13037, 13016, 57560
13027, 56365, 12717, 12707, 56375, 56366, 12718, 12708, 56376, 57969, 13036, 57979, 57561, 57970, 13038, 57980, 
57564, 57532, 13039, 13018, 57563
13028, 56366, 12718, 12708, 56376, 56367, 12719, 12709, 56377, 57970, 13038, 57980, 57564, 57971, 13040, 57981, 
57567, 57535, 13041, 13020, 57566
13029, 56367, 12719, 12709, 56377, 56368, 12720, 12710, 56378, 57971, 13040, 57981, 57567, 57972, 13042, 57982, 
57570, 57538, 13043, 13022, 57569
13030, 56368, 12720, 12710, 56378, 56369, 12721, 12711, 56379, 57972, 13042, 57982, 57570, 57973, 13044, 57983, 
57573, 57541, 13045, 13024, 57572
13031, 56369, 12721, 12711, 56379, 56370, 12722, 12712, 56380, 57973, 13044, 57983, 57573, 57974, 13046, 57984, 
57576, 57544, 13047, 13026, 57575
13032, 56370, 12722, 12712, 56380, 56371, 12723, 12713, 56381, 57974, 13046, 57984, 57576, 57975, 13048, 57985, 
57579, 57547, 13049, 13028, 57578
13033, 56371, 12723, 12713, 56381, 56372, 12724, 12714, 56382, 57975, 13048, 57985, 57579, 57976, 13050, 57986, 
57582, 57550, 13051, 13030, 57581
13034, 56372, 12724, 12714, 56382, 56373, 12725, 12715, 56383, 57976, 13050, 57986, 57582, 57977, 13052, 57987, 
57585, 57553, 13053, 13032, 57584
13035, 56373, 12725, 12715, 56383, 56374, 12726, 12716, 56384, 57977, 13052, 57987, 57585, 57978, 13054, 57988, 
57588, 57556, 13055, 13034, 57587
13036, 56374, 12726, 12716, 56384, 12433, 1068, 1067, 12434, 57978, 13054, 57988, 57588, 12545, 1090, 12546, 
12514, 57559, 13056, 13035, 57590
13037, 12206, 991, 990, 12207, 56375, 12707, 12697, 56385, 12318, 1013, 12319, 12289, 57979, 13015, 57989, 
57592, 57560, 13016, 12995, 57591
13038, 56375, 12707, 12697, 56385, 56376, 12708, 12698, 56386, 57979, 13015, 57989, 57592, 57980, 13017, 57990, 
57595, 57563, 13018, 12997, 57594
13039, 56376, 12708, 12698, 56386, 56377, 12709, 12699, 56387, 57980, 13017, 57990, 57595, 57981, 13019, 57991, 
57598, 57566, 13020, 12999, 57597
13040, 56377, 12709, 12699, 56387, 56378, 12710, 12700, 56388, 57981, 13019, 57991, 57598, 57982, 13021, 57992, 
57601, 57569, 13022, 13001, 57600
13041, 56378, 12710, 12700, 56388, 56379, 12711, 12701, 56389, 57982, 13021, 57992, 57601, 57983, 13023, 57993, 
57604, 57572, 13024, 13003, 57603
13042, 56379, 12711, 12701, 56389, 56380, 12712, 12702, 56390, 57983, 13023, 57993, 57604, 57984, 13025, 57994, 
57607, 57575, 13026, 13005, 57606
13043, 56380, 12712, 12702, 56390, 56381, 12713, 12703, 56391, 57984, 13025, 57994, 57607, 57985, 13027, 57995, 
57610, 57578, 13028, 13007, 57609
13044, 56381, 12713, 12703, 56391, 56382, 12714, 12704, 56392, 57985, 13027, 57995, 57610, 57986, 13029, 57996, 
57613, 57581, 13030, 13009, 57612
13045, 56382, 12714, 12704, 56392, 56383, 12715, 12705, 56393, 57986, 13029, 57996, 57613, 57987, 13031, 57997, 
57616, 57584, 13032, 13011, 57615
13046, 56383, 12715, 12705, 56393, 56384, 12716, 12706, 56394, 57987, 13031, 57997, 57616, 57988, 13033, 57998, 
57619, 57587, 13034, 13013, 57618
13047, 56384, 12716, 12706, 56394, 12434, 1067, 1066, 12435, 57988, 13033, 57998, 57619, 12546, 1089, 12547, 
12516, 57590, 13035, 13014, 57621
13048, 12207, 990, 989, 12208, 56385, 12697, 12687, 56395, 12319, 1012, 12320, 12291, 57989, 12994, 57999, 
57623, 57591, 12995, 12974, 57622
13049, 56385, 12697, 12687, 56395, 56386, 12698, 12688, 56396, 57989, 12994, 57999, 57623, 57990, 12996, 58000, 
57626, 57594, 12997, 12976, 57625
13050, 56386, 12698, 12688, 56396, 56387, 12699, 12689, 56397, 57990, 12996, 58000, 57626, 57991, 12998, 58001, 
57629, 57597, 12999, 12978, 57628
13051, 56387, 12699, 12689, 56397, 56388, 12700, 12690, 56398, 57991, 12998, 58001, 57629, 57992, 13000, 58002, 
57632, 57600, 13001, 12980, 57631
13052, 56388, 12700, 12690, 56398, 56389, 12701, 12691, 56399, 57992, 13000, 58002, 57632, 57993, 13002, 58003, 
57635, 57603, 13003, 12982, 57634
13053, 56389, 12701, 12691, 56399, 56390, 12702, 12692, 56400, 57993, 13002, 58003, 57635, 57994, 13004, 58004, 
57638, 57606, 13005, 12984, 57637
13054, 56390, 12702, 12692, 56400, 56391, 12703, 12693, 56401, 57994, 13004, 58004, 57638, 57995, 13006, 58005, 
57641, 57609, 13007, 12986, 57640
13055, 56391, 12703, 12693, 56401, 56392, 12704, 12694, 56402, 57995, 13006, 58005, 57641, 57996, 13008, 58006, 
57644, 57612, 13009, 12988, 57643
13056, 56392, 12704, 12694, 56402, 56393, 12705, 12695, 56403, 57996, 13008, 58006, 57644, 57997, 13010, 58007, 
57647, 57615, 13011, 12990, 57646
13057, 56393, 12705, 12695, 56403, 56394, 12706, 12696, 56404, 57997, 13010, 58007, 57647, 57998, 13012, 58008, 
57650, 57618, 13013, 12992, 57649
13058, 56394, 12706, 12696, 56404, 12435, 1066, 1065, 12436, 57998, 13012, 58008, 57650, 12547, 1088, 12548, 
12518, 57621, 13014, 12993, 57652
13059, 12208, 989, 988, 12209, 56395, 12687, 12677, 56405, 12320, 1011, 12321, 12293, 57999, 12973, 58009, 
57654, 57622, 12974, 12953, 57653
13060, 56395, 12687, 12677, 56405, 56396, 12688, 12678, 56406, 57999, 12973, 58009, 57654, 58000, 12975, 58010, 
57657, 57625, 12976, 12955, 57656
13061, 56396, 12688, 12678, 56406, 56397, 12689, 12679, 56407, 58000, 12975, 58010, 57657, 58001, 12977, 58011, 
57660, 57628, 12978, 12957, 57659
13062, 56397, 12689, 12679, 56407, 56398, 12690, 12680, 56408, 58001, 12977, 58011, 57660, 58002, 12979, 58012, 
57663, 57631, 12980, 12959, 57662
13063, 56398, 12690, 12680, 56408, 56399, 12691, 12681, 56409, 58002, 12979, 58012, 57663, 58003, 12981, 58013, 
57666, 57634, 12982, 12961, 57665
13064, 56399, 12691, 12681, 56409, 56400, 12692, 12682, 56410, 58003, 12981, 58013, 57666, 58004, 12983, 58014, 
57669, 57637, 12984, 12963, 57668
13065, 56400, 12692, 12682, 56410, 56401, 12693, 12683, 56411, 58004, 12983, 58014, 57669, 58005, 12985, 58015, 
57672, 57640, 12986, 12965, 57671
13066, 56401, 12693, 12683, 56411, 56402, 12694, 12684, 56412, 58005, 12985, 58015, 57672, 58006, 12987, 58016, 
57675, 57643, 12988, 12967, 57674
13067, 56402, 12694, 12684, 56412, 56403, 12695, 12685, 56413, 58006, 12987, 58016, 57675, 58007, 12989, 58017, 
57678, 57646, 12990, 12969, 57677
13068, 56403, 12695, 12685, 56413, 56404, 12696, 12686, 56414, 58007, 12989, 58017, 57678, 58008, 12991, 58018, 
57681, 57649, 12992, 12971, 57680
13069, 56404, 12696, 12686, 56414, 12436, 1065, 1064, 12437, 58008, 12991, 58018, 57681, 12548, 1087, 12549, 
12520, 57652, 12993, 12972, 57683
13070, 12209, 988, 987, 12210, 56405, 12677, 12667, 56415, 12321, 1010, 12322, 12295, 58009, 12952, 58019, 
57685, 57653, 12953, 12932, 57684
13071, 56405, 12677, 12667, 56415, 56406, 12678, 12668, 56416, 58009, 12952, 58019, 57685, 58010, 12954, 58020, 
57688, 57656, 12955, 12934, 57687
13072, 56406, 12678, 12668, 56416, 56407, 12679, 12669, 56417, 58010, 12954, 58020, 57688, 58011, 12956, 58021, 
57691, 57659, 12957, 12936, 57690
13073, 56407, 12679, 12669, 56417, 56408, 12680, 12670, 56418, 58011, 12956, 58021, 57691, 58012, 12958, 58022, 
57694, 57662, 12959, 12938, 57693
13074, 56408, 12680, 12670, 56418, 56409, 12681, 12671, 56419, 58012, 12958, 58022, 57694, 58013, 12960, 58023, 
57697, 57665, 12961, 12940, 57696
13075, 56409, 12681, 12671, 56419, 56410, 12682, 12672, 56420, 58013, 12960, 58023, 57697, 58014, 12962, 58024, 
57700, 57668, 12963, 12942, 57699
13076, 56410, 12682, 12672, 56420, 56411, 12683, 12673, 56421, 58014, 12962, 58024, 57700, 58015, 12964, 58025, 
57703, 57671, 12965, 12944, 57702
13077, 56411, 12683, 12673, 56421, 56412, 12684, 12674, 56422, 58015, 12964, 58025, 57703, 58016, 12966, 58026, 
57706, 57674, 12967, 12946, 57705
13078, 56412, 12684, 12674, 56422, 56413, 12685, 12675, 56423, 58016, 12966, 58026, 57706, 58017, 12968, 58027, 
57709, 57677, 12969, 12948, 57708
13079, 56413, 12685, 12675, 56423, 56414, 12686, 12676, 56424, 58017, 12968, 58027, 57709, 58018, 12970, 58028, 
57712, 57680, 12971, 12950, 57711
13080, 56414, 12686, 12676, 56424, 12437, 1064, 1063, 12438, 58018, 12970, 58028, 57712, 12549, 1086, 12550, 
12522, 57683, 12972, 12951, 57714
13081, 12210, 987, 986, 12211, 56415, 12667, 12657, 56425, 12322, 1009, 12323, 12297, 58019, 12931, 58029, 
57716, 57684, 12932, 12911, 57715
13082, 56415, 12667, 12657, 56425, 56416, 12668, 12658, 56426, 58019, 12931, 58029, 57716, 58020, 12933, 58030, 
57719, 57687, 12934, 12913, 57718
13083, 56416, 12668, 12658, 56426, 56417, 12669, 12659, 56427, 58020, 12933, 58030, 57719, 58021, 12935, 58031, 
57722, 57690, 12936, 12915, 57721
13084, 56417, 12669, 12659, 56427, 56418, 12670, 12660, 56428, 58021, 12935, 58031, 57722, 58022, 12937, 58032, 
57725, 57693, 12938, 12917, 57724
13085, 56418, 12670, 12660, 56428, 56419, 12671, 12661, 56429, 58022, 12937, 58032, 57725, 58023, 12939, 58033, 
57728, 57696, 12940, 12919, 57727
13086, 56419, 12671, 12661, 56429, 56420, 12672, 12662, 56430, 58023, 12939, 58033, 57728, 58024, 12941, 58034, 
57731, 57699, 12942, 12921, 57730
13087, 56420, 12672, 12662, 56430, 56421, 12673, 12663, 56431, 58024, 12941, 58034, 57731, 58025, 12943, 58035, 
57734, 57702, 12944, 12923, 57733
13088, 56421, 12673, 12663, 56431, 56422, 12674, 12664, 56432, 58025, 12943, 58035, 57734, 58026, 12945, 58036, 
57737, 57705, 12946, 12925, 57736
13089, 56422, 12674, 12664, 56432, 56423, 12675, 12665, 56433, 58026, 12945, 58036, 57737, 58027, 12947, 58037, 
57740, 57708, 12948, 12927, 57739
13090, 56423, 12675, 12665, 56433, 56424, 12676, 12666, 56434, 58027, 12947, 58037, 57740, 58028, 12949, 58038, 
57743, 57711, 12950, 12929, 57742
13091, 56424, 12676, 12666, 56434, 12438, 1063, 1062, 12439, 58028, 12949, 58038, 57743, 12550, 1085, 12551, 
12524, 57714, 12951, 12930, 57745
13092, 12211, 986, 985, 12212, 56425, 12657, 12647, 56435, 12323, 1008, 12324, 12299, 58029, 12910, 58039, 
57747, 57715, 12911, 12890, 57746
13093, 56425, 12657, 12647, 56435, 56426, 12658, 12648, 56436, 58029, 12910, 58039, 57747, 58030, 12912, 58040, 
57750, 57718, 12913, 12892, 57749
13094, 56426, 12658, 12648, 56436, 56427, 12659, 12649, 56437, 58030, 12912, 58040, 57750, 58031, 12914, 58041, 
57753, 57721, 12915, 12894, 57752
13095, 56427, 12659, 12649, 56437, 56428, 12660, 12650, 56438, 58031, 12914, 58041, 57753, 58032, 12916, 58042, 
57756, 57724, 12917, 12896, 57755
13096, 56428, 12660, 12650, 56438, 56429, 12661, 12651, 56439, 58032, 12916, 58042, 57756, 58033, 12918, 58043, 
57759, 57727, 12919, 12898, 57758
13097, 56429, 12661, 12651, 56439, 56430, 12662, 12652, 56440, 58033, 12918, 58043, 57759, 58034, 12920, 58044, 
57762, 57730, 12921, 12900, 57761
13098, 56430, 12662, 12652, 56440, 56431, 12663, 12653, 56441, 58034, 12920, 58044, 57762, 58035, 12922, 58045, 
57765, 57733, 12923, 12902, 57764
13099, 56431, 12663, 12653, 56441, 56432, 12664, 12654, 56442, 58035, 12922, 58045, 57765, 58036, 12924, 58046, 
57768, 57736, 12925, 12904, 57767
13100, 56432, 12664, 12654, 56442, 56433, 12665, 12655, 56443, 58036, 12924, 58046, 57768, 58037, 12926, 58047, 
57771, 57739, 12927, 12906, 57770
13101, 56433, 12665, 12655, 56443, 56434, 12666, 12656, 56444, 58037, 12926, 58047, 57771, 58038, 12928, 58048, 
57774, 57742, 12929, 12908, 57773
13102, 56434, 12666, 12656, 56444, 12439, 1062, 1061, 12440, 58038, 12928, 58048, 57774, 12551, 1084, 12552, 
12526, 57745, 12930, 12909, 57776
13103, 12212, 985, 984, 12213, 56435, 12647, 12637, 56445, 12324, 1007, 12325, 12301, 58039, 12889, 58049, 
57778, 57746, 12890, 12869, 57777
13104, 56435, 12647, 12637, 56445, 56436, 12648, 12638, 56446, 58039, 12889, 58049, 57778, 58040, 12891, 58050, 
57781, 57749, 12892, 12871, 57780
13105, 56436, 12648, 12638, 56446, 56437, 12649, 12639, 56447, 58040, 12891, 58050, 57781, 58041, 12893, 58051, 
57784, 57752, 12894, 12873, 57783
13106, 56437, 12649, 12639, 56447, 56438, 12650, 12640, 56448, 58041, 12893, 58051, 57784, 58042, 12895, 58052, 
57787, 57755, 12896, 12875, 57786
13107, 56438, 12650, 12640, 56448, 56439, 12651, 12641, 56449, 58042, 12895, 58052, 57787, 58043, 12897, 58053, 
57790, 57758, 12898, 12877, 57789
13108, 56439, 12651, 12641, 56449, 56440, 12652, 12642, 56450, 58043, 12897, 58053, 57790, 58044, 12899, 58054, 
57793, 57761, 12900, 12879, 57792
13109, 56440, 12652, 12642, 56450, 56441, 12653, 12643, 56451, 58044, 12899, 58054, 57793, 58045, 12901, 58055, 
57796, 57764, 12902, 12881, 57795
13110, 56441, 12653, 12643, 56451, 56442, 12654, 12644, 56452, 58045, 12901, 58055, 57796, 58046, 12903, 58056, 
57799, 57767, 12904, 12883, 57798
13111, 56442, 12654, 12644, 56452, 56443, 12655, 12645, 56453, 58046, 12903, 58056, 57799, 58047, 12905, 58057, 
57802, 57770, 12906, 12885, 57801
13112, 56443, 12655, 12645, 56453, 56444, 12656, 12646, 56454, 58047, 12905, 58057, 57802, 58048, 12907, 58058, 
57805, 57773, 12908, 12887, 57804
13113, 56444, 12656, 12646, 56454, 12440, 1061, 1060, 12441, 58048, 12907, 58058, 57805, 12552, 1083, 12553, 
12528, 57776, 12909, 12888, 57807
13114, 12213, 984, 983, 12214, 56445, 12637, 12627, 56455, 12325, 1006, 12326, 12303, 58049, 12868, 58059, 
57809, 57777, 12869, 12848, 57808
13115, 56445, 12637, 12627, 56455, 56446, 12638, 12628, 56456, 58049, 12868, 58059, 57809, 58050, 12870, 58060, 
57812, 57780, 12871, 12850, 57811
13116, 56446, 12638, 12628, 56456, 56447, 12639, 12629, 56457, 58050, 12870, 58060, 57812, 58051, 12872, 58061, 
57815, 57783, 12873, 12852, 57814
13117, 56447, 12639, 12629, 56457, 56448, 12640, 12630, 56458, 58051, 12872, 58061, 57815, 58052, 12874, 58062, 
57818, 57786, 12875, 12854, 57817
13118, 56448, 12640, 12630, 56458, 56449, 12641, 12631, 56459, 58052, 12874, 58062, 57818, 58053, 12876, 58063, 
57821, 57789, 12877, 12856, 57820
13119, 56449, 12641, 12631, 56459, 56450, 12642, 12632, 56460, 58053, 12876, 58063, 57821, 58054, 12878, 58064, 
57824, 57792, 12879, 12858, 57823
13120, 56450, 12642, 12632, 56460, 56451, 12643, 12633, 56461, 58054, 12878, 58064, 57824, 58055, 12880, 58065, 
57827, 57795, 12881, 12860, 57826
13121, 56451, 12643, 12633, 56461, 56452, 12644, 12634, 56462, 58055, 12880, 58065, 57827, 58056, 12882, 58066, 
57830, 57798, 12883, 12862, 57829
13122, 56452, 12644, 12634, 56462, 56453, 12645, 12635, 56463, 58056, 12882, 58066, 57830, 58057, 12884, 58067, 
57833, 57801, 12885, 12864, 57832
13123, 56453, 12645, 12635, 56463, 56454, 12646, 12636, 56464, 58057, 12884, 58067, 57833, 58058, 12886, 58068, 
57836, 57804, 12887, 12866, 57835
13124, 56454, 12646, 12636, 56464, 12441, 1060, 1059, 12442, 58058, 12886, 58068, 57836, 12553, 1082, 12554, 
12530, 57807, 12888, 12867, 57838
13125, 12214, 983, 22, 979, 56455, 12627, 1104, 12574, 12326, 1005, 982, 12304, 58059, 12847, 12626, 
57839, 57808, 12848, 1114, 12616
13126, 56455, 12627, 1104, 12574, 56456, 12628, 1105, 12573, 58059, 12847, 12626, 57839, 58060, 12849, 12625, 
57840, 57811, 12850, 1115, 12614
13127, 56456, 12628, 1105, 12573, 56457, 12629, 1106, 12572, 58060, 12849, 12625, 57840, 58061, 12851, 12624, 
57841, 57814, 12852, 1116, 12612
13128, 56457, 12629, 1106, 12572, 56458, 12630, 1107, 12571, 58061, 12851, 12624, 57841, 58062, 12853, 12623, 
57842, 57817, 12854, 1117, 12610
13129, 56458, 12630, 1107, 12571, 56459, 12631, 1108, 12570, 58062, 12853, 12623, 57842, 58063, 12855, 12622, 
57843, 57820, 12856, 1118, 12608
13130, 56459, 12631, 1108, 12570, 56460, 12632, 1109, 12569, 58063, 12855, 12622, 57843, 58064, 12857, 12621, 
57844, 57823, 12858, 1119, 12606
13131, 56460, 12632, 1109, 12569, 56461, 12633, 1110, 12568, 58064, 12857, 12621, 57844, 58065, 12859, 12620, 
57845, 57826, 12860, 1120, 12604
13132, 56461, 12633, 1110, 12568, 56462, 12634, 1111, 12567, 58065, 12859, 12620, 57845, 58066, 12861, 12619, 
57846, 57829, 12862, 1121, 12602
13133, 56462, 12634, 1111, 12567, 56463, 12635, 1112, 12566, 58066, 12861, 12619, 57846, 58067, 12863, 12618, 
57847, 57832, 12864, 1122, 12600
13134, 56463, 12635, 1112, 12566, 56464, 12636, 1113, 12565, 58067, 12863, 12618, 57847, 58068, 12865, 12617, 
57848, 57835, 12866, 1123, 12598
13135, 56464, 12636, 1113, 12565, 12442, 1059, 24, 1055, 58068, 12865, 12617, 57848, 12554, 1081, 1058, 
12532, 57838, 12867, 1124, 12596
*ELEMENT, type=C3D20, ELSET=Volume6
13136, 13319, 1125, 19, 1028, 58069, 13379, 892, 12327, 13327, 1129, 1030, 13328, 58150, 13419, 12347, 
58151, 58149, 13420, 903, 12348
13137, 58069, 13379, 892, 12327, 58070, 13380, 891, 12328, 58150, 13419, 12347, 58151, 58153, 13421, 12349, 
58154, 58152, 13422, 902, 12350
13138, 58070, 13380, 891, 12328, 58071, 13381, 890, 12329, 58153, 13421, 12349, 58154, 58156, 13423, 12351, 
58157, 58155, 13424, 901, 12352
13139, 58071, 13381, 890, 12329, 58072, 13382, 889, 12330, 58156, 13423, 12351, 58157, 58159, 13425, 12353, 
58160, 58158, 13426, 900, 12354
13140, 58072, 13382, 889, 12330, 58073, 13383, 888, 12331, 58159, 13425, 12353, 58160, 58162, 13427, 12355, 
58163, 58161, 13428, 899, 12356
13141, 58073, 13383, 888, 12331, 58074, 13384, 887, 12332, 58162, 13427, 12355, 58163, 58165, 13429, 12357, 
58166, 58164, 13430, 898, 12358
13142, 58074, 13384, 887, 12332, 58075, 13385, 886, 12333, 58165, 13429, 12357, 58166, 58168, 13431, 12359, 
58169, 58167, 13432, 897, 12360
13143, 58075, 13385, 886, 12333, 58076, 13386, 885, 12334, 58168, 13431, 12359, 58169, 58171, 13433, 12361, 
58172, 58170, 13434, 896, 12362
13144, 58076, 13386, 885, 12334, 58077, 13387, 884, 12335, 58171, 13433, 12361, 58172, 58174, 13435, 12363, 
58175, 58173, 13436, 895, 12364
13145, 58077, 13387, 884, 12335, 58078, 13388, 883, 12336, 58174, 13435, 12363, 58175, 58177, 13437, 12365, 
58178, 58176, 13438, 894, 12366
13146, 58078, 13388, 883, 12336, 13349, 1148, 17, 973, 58177, 13437, 12365, 58178, 13358, 1152, 975, 
13357, 58179, 13439, 893, 12367
13147, 13320, 13319, 1028, 1029, 58079, 58069, 12327, 12337, 13329, 13328, 1031, 13330, 58181, 58151, 12368, 
58182, 58180, 58149, 12348, 12369
13148, 58079, 58069, 12327, 12337, 58080, 58070, 12328, 12338, 58181, 58151, 12368, 58182, 58184, 58154, 12370, 
58185, 58183, 58152, 12350, 12371
