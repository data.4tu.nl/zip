15877, 62774, 62764, 62544, 62554, 62775, 62765, 62545, 62555, 70061, 70031, 69369, 70062, 70064, 70034, 69372, 
70065, 70063, 70032, 69340, 69371
15878, 62775, 62765, 62545, 62555, 62776, 62766, 62546, 62556, 70064, 70034, 69372, 70065, 70067, 70037, 69375, 
70068, 70066, 70035, 69343, 69374
15879, 62776, 62766, 62546, 62556, 62777, 62767, 62547, 62557, 70067, 70037, 69375, 70068, 70070, 70040, 69378, 
70071, 70069, 70038, 69346, 69377
15880, 62777, 62767, 62547, 62557, 62778, 62768, 62548, 62558, 70070, 70040, 69378, 70071, 70073, 70043, 69381, 
70074, 70072, 70041, 69349, 69380
15881, 62778, 62768, 62548, 62558, 62779, 62769, 62549, 62559, 70073, 70043, 69381, 70074, 70076, 70046, 69384, 
70077, 70075, 70044, 69352, 69383
15882, 62779, 62769, 62549, 62559, 62780, 62770, 62550, 62560, 70076, 70046, 69384, 70077, 70079, 70049, 69387, 
70080, 70078, 70047, 69355, 69386
15883, 62780, 62770, 62550, 62560, 62781, 62771, 62551, 62561, 70079, 70049, 69387, 70080, 70082, 70052, 69390, 
70083, 70081, 70050, 69358, 69389
15884, 62781, 62771, 62551, 62561, 62782, 62772, 62552, 62562, 70082, 70052, 69390, 70083, 70085, 70055, 69393, 
70086, 70084, 70053, 69361, 69392
15885, 62782, 62772, 62552, 62562, 18049, 18048, 18026, 18027, 70085, 70055, 69393, 70086, 18653, 18650, 18608, 
18652, 70087, 70056, 69364, 69395
15886, 16554, 16553, 16531, 16532, 62783, 62773, 62553, 62563, 17158, 17157, 17113, 17159, 70089, 70059, 69397, 
70090, 70088, 70057, 69365, 69396
15887, 62783, 62773, 62553, 62563, 62784, 62774, 62554, 62564, 70089, 70059, 69397, 70090, 70092, 70062, 69400, 
70093, 70091, 70060, 69368, 69399
15888, 62784, 62774, 62554, 62564, 62785, 62775, 62555, 62565, 70092, 70062, 69400, 70093, 70095, 70065, 69403, 
70096, 70094, 70063, 69371, 69402
15889, 62785, 62775, 62555, 62565, 62786, 62776, 62556, 62566, 70095, 70065, 69403, 70096, 70098, 70068, 69406, 
70099, 70097, 70066, 69374, 69405
15890, 62786, 62776, 62556, 62566, 62787, 62777, 62557, 62567, 70098, 70068, 69406, 70099, 70101, 70071, 69409, 
70102, 70100, 70069, 69377, 69408
15891, 62787, 62777, 62557, 62567, 62788, 62778, 62558, 62568, 70101, 70071, 69409, 70102, 70104, 70074, 69412, 
70105, 70103, 70072, 69380, 69411
15892, 62788, 62778, 62558, 62568, 62789, 62779, 62559, 62569, 70104, 70074, 69412, 70105, 70107, 70077, 69415, 
70108, 70106, 70075, 69383, 69414
15893, 62789, 62779, 62559, 62569, 62790, 62780, 62560, 62570, 70107, 70077, 69415, 70108, 70110, 70080, 69418, 
70111, 70109, 70078, 69386, 69417
15894, 62790, 62780, 62560, 62570, 62791, 62781, 62561, 62571, 70110, 70080, 69418, 70111, 70113, 70083, 69421, 
70114, 70112, 70081, 69389, 69420
15895, 62791, 62781, 62561, 62571, 62792, 62782, 62562, 62572, 70113, 70083, 69421, 70114, 70116, 70086, 69424, 
70117, 70115, 70084, 69392, 69423
15896, 62792, 62782, 62562, 62572, 18050, 18049, 18027, 18028, 70116, 70086, 69424, 70117, 18655, 18652, 18610, 
18654, 70118, 70087, 69395, 69426
15897, 16555, 16554, 16532, 16533, 62793, 62783, 62563, 62573, 17160, 17159, 17115, 17161, 70120, 70090, 69428, 
70121, 70119, 70088, 69396, 69427
15898, 62793, 62783, 62563, 62573, 62794, 62784, 62564, 62574, 70120, 70090, 69428, 70121, 70123, 70093, 69431, 
70124, 70122, 70091, 69399, 69430
15899, 62794, 62784, 62564, 62574, 62795, 62785, 62565, 62575, 70123, 70093, 69431, 70124, 70126, 70096, 69434, 
70127, 70125, 70094, 69402, 69433
15900, 62795, 62785, 62565, 62575, 62796, 62786, 62566, 62576, 70126, 70096, 69434, 70127, 70129, 70099, 69437, 
70130, 70128, 70097, 69405, 69436
15901, 62796, 62786, 62566, 62576, 62797, 62787, 62567, 62577, 70129, 70099, 69437, 70130, 70132, 70102, 69440, 
70133, 70131, 70100, 69408, 69439
15902, 62797, 62787, 62567, 62577, 62798, 62788, 62568, 62578, 70132, 70102, 69440, 70133, 70135, 70105, 69443, 
70136, 70134, 70103, 69411, 69442
15903, 62798, 62788, 62568, 62578, 62799, 62789, 62569, 62579, 70135, 70105, 69443, 70136, 70138, 70108, 69446, 
70139, 70137, 70106, 69414, 69445
15904, 62799, 62789, 62569, 62579, 62800, 62790, 62570, 62580, 70138, 70108, 69446, 70139, 70141, 70111, 69449, 
70142, 70140, 70109, 69417, 69448
15905, 62800, 62790, 62570, 62580, 62801, 62791, 62571, 62581, 70141, 70111, 69449, 70142, 70144, 70114, 69452, 
70145, 70143, 70112, 69420, 69451
15906, 62801, 62791, 62571, 62581, 62802, 62792, 62572, 62582, 70144, 70114, 69452, 70145, 70147, 70117, 69455, 
70148, 70146, 70115, 69423, 69454
15907, 62802, 62792, 62572, 62582, 18051, 18050, 18028, 18029, 70147, 70117, 69455, 70148, 18657, 18654, 18612, 
18656, 70149, 70118, 69426, 69457
15908, 16556, 16555, 16533, 16534, 62803, 62793, 62573, 62583, 17162, 17161, 17117, 17163, 70151, 70121, 69459, 
70152, 70150, 70119, 69427, 69458
15909, 62803, 62793, 62573, 62583, 62804, 62794, 62574, 62584, 70151, 70121, 69459, 70152, 70154, 70124, 69462, 
70155, 70153, 70122, 69430, 69461
15910, 62804, 62794, 62574, 62584, 62805, 62795, 62575, 62585, 70154, 70124, 69462, 70155, 70157, 70127, 69465, 
70158, 70156, 70125, 69433, 69464
15911, 62805, 62795, 62575, 62585, 62806, 62796, 62576, 62586, 70157, 70127, 69465, 70158, 70160, 70130, 69468, 
70161, 70159, 70128, 69436, 69467
15912, 62806, 62796, 62576, 62586, 62807, 62797, 62577, 62587, 70160, 70130, 69468, 70161, 70163, 70133, 69471, 
70164, 70162, 70131, 69439, 69470
15913, 62807, 62797, 62577, 62587, 62808, 62798, 62578, 62588, 70163, 70133, 69471, 70164, 70166, 70136, 69474, 
70167, 70165, 70134, 69442, 69473
15914, 62808, 62798, 62578, 62588, 62809, 62799, 62579, 62589, 70166, 70136, 69474, 70167, 70169, 70139, 69477, 
70170, 70168, 70137, 69445, 69476
15915, 62809, 62799, 62579, 62589, 62810, 62800, 62580, 62590, 70169, 70139, 69477, 70170, 70172, 70142, 69480, 
70173, 70171, 70140, 69448, 69479
15916, 62810, 62800, 62580, 62590, 62811, 62801, 62581, 62591, 70172, 70142, 69480, 70173, 70175, 70145, 69483, 
70176, 70174, 70143, 69451, 69482
15917, 62811, 62801, 62581, 62591, 62812, 62802, 62582, 62592, 70175, 70145, 69483, 70176, 70178, 70148, 69486, 
70179, 70177, 70146, 69454, 69485
15918, 62812, 62802, 62582, 62592, 18052, 18051, 18029, 18030, 70178, 70148, 69486, 70179, 18659, 18656, 18614, 
18658, 70180, 70149, 69457, 69488
15919, 16557, 16556, 16534, 16535, 62813, 62803, 62583, 62593, 17164, 17163, 17119, 17165, 70182, 70152, 69490, 
70183, 70181, 70150, 69458, 69489
15920, 62813, 62803, 62583, 62593, 62814, 62804, 62584, 62594, 70182, 70152, 69490, 70183, 70185, 70155, 69493, 
70186, 70184, 70153, 69461, 69492
15921, 62814, 62804, 62584, 62594, 62815, 62805, 62585, 62595, 70185, 70155, 69493, 70186, 70188, 70158, 69496, 
70189, 70187, 70156, 69464, 69495
15922, 62815, 62805, 62585, 62595, 62816, 62806, 62586, 62596, 70188, 70158, 69496, 70189, 70191, 70161, 69499, 
70192, 70190, 70159, 69467, 69498
15923, 62816, 62806, 62586, 62596, 62817, 62807, 62587, 62597, 70191, 70161, 69499, 70192, 70194, 70164, 69502, 
70195, 70193, 70162, 69470, 69501
15924, 62817, 62807, 62587, 62597, 62818, 62808, 62588, 62598, 70194, 70164, 69502, 70195, 70197, 70167, 69505, 
70198, 70196, 70165, 69473, 69504
15925, 62818, 62808, 62588, 62598, 62819, 62809, 62589, 62599, 70197, 70167, 69505, 70198, 70200, 70170, 69508, 
70201, 70199, 70168, 69476, 69507
15926, 62819, 62809, 62589, 62599, 62820, 62810, 62590, 62600, 70200, 70170, 69508, 70201, 70203, 70173, 69511, 
70204, 70202, 70171, 69479, 69510
15927, 62820, 62810, 62590, 62600, 62821, 62811, 62591, 62601, 70203, 70173, 69511, 70204, 70206, 70176, 69514, 
70207, 70205, 70174, 69482, 69513
15928, 62821, 62811, 62591, 62601, 62822, 62812, 62592, 62602, 70206, 70176, 69514, 70207, 70209, 70179, 69517, 
70210, 70208, 70177, 69485, 69516
15929, 62822, 62812, 62592, 62602, 18053, 18052, 18030, 18031, 70209, 70179, 69517, 70210, 18661, 18658, 18616, 
18660, 70211, 70180, 69488, 69519
15930, 16558, 16557, 16535, 16536, 62823, 62813, 62593, 62603, 17166, 17165, 17121, 17167, 70213, 70183, 69521, 
70214, 70212, 70181, 69489, 69520
15931, 62823, 62813, 62593, 62603, 62824, 62814, 62594, 62604, 70213, 70183, 69521, 70214, 70216, 70186, 69524, 
70217, 70215, 70184, 69492, 69523
15932, 62824, 62814, 62594, 62604, 62825, 62815, 62595, 62605, 70216, 70186, 69524, 70217, 70219, 70189, 69527, 
70220, 70218, 70187, 69495, 69526
15933, 62825, 62815, 62595, 62605, 62826, 62816, 62596, 62606, 70219, 70189, 69527, 70220, 70222, 70192, 69530, 
70223, 70221, 70190, 69498, 69529
15934, 62826, 62816, 62596, 62606, 62827, 62817, 62597, 62607, 70222, 70192, 69530, 70223, 70225, 70195, 69533, 
70226, 70224, 70193, 69501, 69532
15935, 62827, 62817, 62597, 62607, 62828, 62818, 62598, 62608, 70225, 70195, 69533, 70226, 70228, 70198, 69536, 
70229, 70227, 70196, 69504, 69535
15936, 62828, 62818, 62598, 62608, 62829, 62819, 62599, 62609, 70228, 70198, 69536, 70229, 70231, 70201, 69539, 
70232, 70230, 70199, 69507, 69538
15937, 62829, 62819, 62599, 62609, 62830, 62820, 62600, 62610, 70231, 70201, 69539, 70232, 70234, 70204, 69542, 
70235, 70233, 70202, 69510, 69541
15938, 62830, 62820, 62600, 62610, 62831, 62821, 62601, 62611, 70234, 70204, 69542, 70235, 70237, 70207, 69545, 
70238, 70236, 70205, 69513, 69544
15939, 62831, 62821, 62601, 62611, 62832, 62822, 62602, 62612, 70237, 70207, 69545, 70238, 70240, 70210, 69548, 
70241, 70239, 70208, 69516, 69547
15940, 62832, 62822, 62602, 62612, 18054, 18053, 18031, 18032, 70240, 70210, 69548, 70241, 18663, 18660, 18618, 
18662, 70242, 70211, 69519, 69550
15941, 16559, 16558, 16536, 16537, 62833, 62823, 62603, 62613, 17168, 17167, 17123, 17169, 70244, 70214, 69552, 
70245, 70243, 70212, 69520, 69551
15942, 62833, 62823, 62603, 62613, 62834, 62824, 62604, 62614, 70244, 70214, 69552, 70245, 70247, 70217, 69555, 
70248, 70246, 70215, 69523, 69554
15943, 62834, 62824, 62604, 62614, 62835, 62825, 62605, 62615, 70247, 70217, 69555, 70248, 70250, 70220, 69558, 
70251, 70249, 70218, 69526, 69557
15944, 62835, 62825, 62605, 62615, 62836, 62826, 62606, 62616, 70250, 70220, 69558, 70251, 70253, 70223, 69561, 
70254, 70252, 70221, 69529, 69560
15945, 62836, 62826, 62606, 62616, 62837, 62827, 62607, 62617, 70253, 70223, 69561, 70254, 70256, 70226, 69564, 
70257, 70255, 70224, 69532, 69563
15946, 62837, 62827, 62607, 62617, 62838, 62828, 62608, 62618, 70256, 70226, 69564, 70257, 70259, 70229, 69567, 
70260, 70258, 70227, 69535, 69566
15947, 62838, 62828, 62608, 62618, 62839, 62829, 62609, 62619, 70259, 70229, 69567, 70260, 70262, 70232, 69570, 
70263, 70261, 70230, 69538, 69569
15948, 62839, 62829, 62609, 62619, 62840, 62830, 62610, 62620, 70262, 70232, 69570, 70263, 70265, 70235, 69573, 
70266, 70264, 70233, 69541, 69572
15949, 62840, 62830, 62610, 62620, 62841, 62831, 62611, 62621, 70265, 70235, 69573, 70266, 70268, 70238, 69576, 
70269, 70267, 70236, 69544, 69575
15950, 62841, 62831, 62611, 62621, 62842, 62832, 62612, 62622, 70268, 70238, 69576, 70269, 70271, 70241, 69579, 
70272, 70270, 70239, 69547, 69578
15951, 62842, 62832, 62612, 62622, 18055, 18054, 18032, 18033, 70271, 70241, 69579, 70272, 18665, 18662, 18620, 
18664, 70273, 70242, 69550, 69581
15952, 16560, 16559, 16537, 16538, 62843, 62833, 62613, 62623, 17170, 17169, 17125, 17171, 70275, 70245, 69583, 
70276, 70274, 70243, 69551, 69582
15953, 62843, 62833, 62613, 62623, 62844, 62834, 62614, 62624, 70275, 70245, 69583, 70276, 70278, 70248, 69586, 
70279, 70277, 70246, 69554, 69585
15954, 62844, 62834, 62614, 62624, 62845, 62835, 62615, 62625, 70278, 70248, 69586, 70279, 70281, 70251, 69589, 
70282, 70280, 70249, 69557, 69588
15955, 62845, 62835, 62615, 62625, 62846, 62836, 62616, 62626, 70281, 70251, 69589, 70282, 70284, 70254, 69592, 
70285, 70283, 70252, 69560, 69591
15956, 62846, 62836, 62616, 62626, 62847, 62837, 62617, 62627, 70284, 70254, 69592, 70285, 70287, 70257, 69595, 
70288, 70286, 70255, 69563, 69594
15957, 62847, 62837, 62617, 62627, 62848, 62838, 62618, 62628, 70287, 70257, 69595, 70288, 70290, 70260, 69598, 
70291, 70289, 70258, 69566, 69597
15958, 62848, 62838, 62618, 62628, 62849, 62839, 62619, 62629, 70290, 70260, 69598, 70291, 70293, 70263, 69601, 
70294, 70292, 70261, 69569, 69600
15959, 62849, 62839, 62619, 62629, 62850, 62840, 62620, 62630, 70293, 70263, 69601, 70294, 70296, 70266, 69604, 
70297, 70295, 70264, 69572, 69603
15960, 62850, 62840, 62620, 62630, 62851, 62841, 62621, 62631, 70296, 70266, 69604, 70297, 70299, 70269, 69607, 
70300, 70298, 70267, 69575, 69606
15961, 62851, 62841, 62621, 62631, 62852, 62842, 62622, 62632, 70299, 70269, 69607, 70300, 70302, 70272, 69610, 
70303, 70301, 70270, 69578, 69609
15962, 62852, 62842, 62622, 62632, 18056, 18055, 18033, 18034, 70302, 70272, 69610, 70303, 18667, 18664, 18622, 
18666, 70304, 70273, 69581, 69612
15963, 16561, 16560, 16538, 16539, 62853, 62843, 62623, 62633, 17172, 17171, 17127, 17173, 70306, 70276, 69614, 
70307, 70305, 70274, 69582, 69613
15964, 62853, 62843, 62623, 62633, 62854, 62844, 62624, 62634, 70306, 70276, 69614, 70307, 70309, 70279, 69617, 
70310, 70308, 70277, 69585, 69616
15965, 62854, 62844, 62624, 62634, 62855, 62845, 62625, 62635, 70309, 70279, 69617, 70310, 70312, 70282, 69620, 
70313, 70311, 70280, 69588, 69619
15966, 62855, 62845, 62625, 62635, 62856, 62846, 62626, 62636, 70312, 70282, 69620, 70313, 70315, 70285, 69623, 
70316, 70314, 70283, 69591, 69622
15967, 62856, 62846, 62626, 62636, 62857, 62847, 62627, 62637, 70315, 70285, 69623, 70316, 70318, 70288, 69626, 
70319, 70317, 70286, 69594, 69625
15968, 62857, 62847, 62627, 62637, 62858, 62848, 62628, 62638, 70318, 70288, 69626, 70319, 70321, 70291, 69629, 
70322, 70320, 70289, 69597, 69628
15969, 62858, 62848, 62628, 62638, 62859, 62849, 62629, 62639, 70321, 70291, 69629, 70322, 70324, 70294, 69632, 
70325, 70323, 70292, 69600, 69631
15970, 62859, 62849, 62629, 62639, 62860, 62850, 62630, 62640, 70324, 70294, 69632, 70325, 70327, 70297, 69635, 
70328, 70326, 70295, 69603, 69634
15971, 62860, 62850, 62630, 62640, 62861, 62851, 62631, 62641, 70327, 70297, 69635, 70328, 70330, 70300, 69638, 
70331, 70329, 70298, 69606, 69637
15972, 62861, 62851, 62631, 62641, 62862, 62852, 62632, 62642, 70330, 70300, 69638, 70331, 70333, 70303, 69641, 
70334, 70332, 70301, 69609, 69640
15973, 62862, 62852, 62632, 62642, 18057, 18056, 18034, 18035, 70333, 70303, 69641, 70334, 18669, 18666, 18624, 
18668, 70335, 70304, 69612, 69643
15974, 16562, 16561, 16539, 16540, 62863, 62853, 62633, 62643, 17174, 17173, 17129, 17175, 70337, 70307, 69645, 
70338, 70336, 70305, 69613, 69644
15975, 62863, 62853, 62633, 62643, 62864, 62854, 62634, 62644, 70337, 70307, 69645, 70338, 70340, 70310, 69648, 
70341, 70339, 70308, 69616, 69647
15976, 62864, 62854, 62634, 62644, 62865, 62855, 62635, 62645, 70340, 70310, 69648, 70341, 70343, 70313, 69651, 
70344, 70342, 70311, 69619, 69650
15977, 62865, 62855, 62635, 62645, 62866, 62856, 62636, 62646, 70343, 70313, 69651, 70344, 70346, 70316, 69654, 
70347, 70345, 70314, 69622, 69653
15978, 62866, 62856, 62636, 62646, 62867, 62857, 62637, 62647, 70346, 70316, 69654, 70347, 70349, 70319, 69657, 
70350, 70348, 70317, 69625, 69656
15979, 62867, 62857, 62637, 62647, 62868, 62858, 62638, 62648, 70349, 70319, 69657, 70350, 70352, 70322, 69660, 
70353, 70351, 70320, 69628, 69659
15980, 62868, 62858, 62638, 62648, 62869, 62859, 62639, 62649, 70352, 70322, 69660, 70353, 70355, 70325, 69663, 
70356, 70354, 70323, 69631, 69662
15981, 62869, 62859, 62639, 62649, 62870, 62860, 62640, 62650, 70355, 70325, 69663, 70356, 70358, 70328, 69666, 
70359, 70357, 70326, 69634, 69665
15982, 62870, 62860, 62640, 62650, 62871, 62861, 62641, 62651, 70358, 70328, 69666, 70359, 70361, 70331, 69669, 
70362, 70360, 70329, 69637, 69668
15983, 62871, 62861, 62641, 62651, 62872, 62862, 62642, 62652, 70361, 70331, 69669, 70362, 70364, 70334, 69672, 
70365, 70363, 70332, 69640, 69671
15984, 62872, 62862, 62642, 62652, 18058, 18057, 18035, 18036, 70364, 70334, 69672, 70365, 18671, 18668, 18626, 
18670, 70366, 70335, 69643, 69674
15985, 16563, 16562, 16540, 16541, 62873, 62863, 62643, 62653, 17176, 17175, 17131, 17177, 70368, 70338, 69676, 
70369, 70367, 70336, 69644, 69675
15986, 62873, 62863, 62643, 62653, 62874, 62864, 62644, 62654, 70368, 70338, 69676, 70369, 70371, 70341, 69679, 
70372, 70370, 70339, 69647, 69678
15987, 62874, 62864, 62644, 62654, 62875, 62865, 62645, 62655, 70371, 70341, 69679, 70372, 70374, 70344, 69682, 
70375, 70373, 70342, 69650, 69681
15988, 62875, 62865, 62645, 62655, 62876, 62866, 62646, 62656, 70374, 70344, 69682, 70375, 70377, 70347, 69685, 
70378, 70376, 70345, 69653, 69684
15989, 62876, 62866, 62646, 62656, 62877, 62867, 62647, 62657, 70377, 70347, 69685, 70378, 70380, 70350, 69688, 
70381, 70379, 70348, 69656, 69687
15990, 62877, 62867, 62647, 62657, 62878, 62868, 62648, 62658, 70380, 70350, 69688, 70381, 70383, 70353, 69691, 
70384, 70382, 70351, 69659, 69690
15991, 62878, 62868, 62648, 62658, 62879, 62869, 62649, 62659, 70383, 70353, 69691, 70384, 70386, 70356, 69694, 
70387, 70385, 70354, 69662, 69693
15992, 62879, 62869, 62649, 62659, 62880, 62870, 62650, 62660, 70386, 70356, 69694, 70387, 70389, 70359, 69697, 
70390, 70388, 70357, 69665, 69696
15993, 62880, 62870, 62650, 62660, 62881, 62871, 62651, 62661, 70389, 70359, 69697, 70390, 70392, 70362, 69700, 
70393, 70391, 70360, 69668, 69699
15994, 62881, 62871, 62651, 62661, 62882, 62872, 62652, 62662, 70392, 70362, 69700, 70393, 70395, 70365, 69703, 
70396, 70394, 70363, 69671, 69702
15995, 62882, 62872, 62652, 62662, 18059, 18058, 18036, 18037, 70395, 70365, 69703, 70396, 18673, 18670, 18628, 
18672, 70397, 70366, 69674, 69705
15996, 16564, 16563, 16541, 16542, 62883, 62873, 62653, 62663, 17178, 17177, 17133, 17179, 70399, 70369, 69707, 
70400, 70398, 70367, 69675, 69706
15997, 62883, 62873, 62653, 62663, 62884, 62874, 62654, 62664, 70399, 70369, 69707, 70400, 70402, 70372, 69710, 
70403, 70401, 70370, 69678, 69709
15998, 62884, 62874, 62654, 62664, 62885, 62875, 62655, 62665, 70402, 70372, 69710, 70403, 70405, 70375, 69713, 
70406, 70404, 70373, 69681, 69712
15999, 62885, 62875, 62655, 62665, 62886, 62876, 62656, 62666, 70405, 70375, 69713, 70406, 70408, 70378, 69716, 
70409, 70407, 70376, 69684, 69715
16000, 62886, 62876, 62656, 62666, 62887, 62877, 62657, 62667, 70408, 70378, 69716, 70409, 70411, 70381, 69719, 
70412, 70410, 70379, 69687, 69718
16001, 62887, 62877, 62657, 62667, 62888, 62878, 62658, 62668, 70411, 70381, 69719, 70412, 70414, 70384, 69722, 
70415, 70413, 70382, 69690, 69721
16002, 62888, 62878, 62658, 62668, 62889, 62879, 62659, 62669, 70414, 70384, 69722, 70415, 70417, 70387, 69725, 
70418, 70416, 70385, 69693, 69724
16003, 62889, 62879, 62659, 62669, 62890, 62880, 62660, 62670, 70417, 70387, 69725, 70418, 70420, 70390, 69728, 
70421, 70419, 70388, 69696, 69727
16004, 62890, 62880, 62660, 62670, 62891, 62881, 62661, 62671, 70420, 70390, 69728, 70421, 70423, 70393, 69731, 
70424, 70422, 70391, 69699, 69730
16005, 62891, 62881, 62661, 62671, 62892, 62882, 62662, 62672, 70423, 70393, 69731, 70424, 70426, 70396, 69734, 
70427, 70425, 70394, 69702, 69733
16006, 62892, 62882, 62662, 62672, 18060, 18059, 18037, 18038, 70426, 70396, 69734, 70427, 18675, 18672, 18630, 
18674, 70428, 70397, 69705, 69736
16007, 16565, 16564, 16542, 16543, 62893, 62883, 62663, 62673, 17180, 17179, 17135, 17181, 70430, 70400, 69738, 
70431, 70429, 70398, 69706, 69737
16008, 62893, 62883, 62663, 62673, 62894, 62884, 62664, 62674, 70430, 70400, 69738, 70431, 70433, 70403, 69741, 
70434, 70432, 70401, 69709, 69740
16009, 62894, 62884, 62664, 62674, 62895, 62885, 62665, 62675, 70433, 70403, 69741, 70434, 70436, 70406, 69744, 
70437, 70435, 70404, 69712, 69743
16010, 62895, 62885, 62665, 62675, 62896, 62886, 62666, 62676, 70436, 70406, 69744, 70437, 70439, 70409, 69747, 
70440, 70438, 70407, 69715, 69746
16011, 62896, 62886, 62666, 62676, 62897, 62887, 62667, 62677, 70439, 70409, 69747, 70440, 70442, 70412, 69750, 
70443, 70441, 70410, 69718, 69749
16012, 62897, 62887, 62667, 62677, 62898, 62888, 62668, 62678, 70442, 70412, 69750, 70443, 70445, 70415, 69753, 
70446, 70444, 70413, 69721, 69752
16013, 62898, 62888, 62668, 62678, 62899, 62889, 62669, 62679, 70445, 70415, 69753, 70446, 70448, 70418, 69756, 
70449, 70447, 70416, 69724, 69755
16014, 62899, 62889, 62669, 62679, 62900, 62890, 62670, 62680, 70448, 70418, 69756, 70449, 70451, 70421, 69759, 
70452, 70450, 70419, 69727, 69758
16015, 62900, 62890, 62670, 62680, 62901, 62891, 62671, 62681, 70451, 70421, 69759, 70452, 70454, 70424, 69762, 
70455, 70453, 70422, 69730, 69761
16016, 62901, 62891, 62671, 62681, 62902, 62892, 62672, 62682, 70454, 70424, 69762, 70455, 70457, 70427, 69765, 
70458, 70456, 70425, 69733, 69764
16017, 62902, 62892, 62672, 62682, 18061, 18060, 18038, 18039, 70457, 70427, 69765, 70458, 18677, 18674, 18632, 
18676, 70459, 70428, 69736, 69767
16018, 16566, 16565, 16543, 16544, 62903, 62893, 62673, 62683, 17182, 17181, 17137, 17183, 70461, 70431, 69769, 
70462, 70460, 70429, 69737, 69768
16019, 62903, 62893, 62673, 62683, 62904, 62894, 62674, 62684, 70461, 70431, 69769, 70462, 70464, 70434, 69772, 
70465, 70463, 70432, 69740, 69771
16020, 62904, 62894, 62674, 62684, 62905, 62895, 62675, 62685, 70464, 70434, 69772, 70465, 70467, 70437, 69775, 
70468, 70466, 70435, 69743, 69774
16021, 62905, 62895, 62675, 62685, 62906, 62896, 62676, 62686, 70467, 70437, 69775, 70468, 70470, 70440, 69778, 
70471, 70469, 70438, 69746, 69777
16022, 62906, 62896, 62676, 62686, 62907, 62897, 62677, 62687, 70470, 70440, 69778, 70471, 70473, 70443, 69781, 
70474, 70472, 70441, 69749, 69780
16023, 62907, 62897, 62677, 62687, 62908, 62898, 62678, 62688, 70473, 70443, 69781, 70474, 70476, 70446, 69784, 
70477, 70475, 70444, 69752, 69783
16024, 62908, 62898, 62678, 62688, 62909, 62899, 62679, 62689, 70476, 70446, 69784, 70477, 70479, 70449, 69787, 
70480, 70478, 70447, 69755, 69786
16025, 62909, 62899, 62679, 62689, 62910, 62900, 62680, 62690, 70479, 70449, 69787, 70480, 70482, 70452, 69790, 
70483, 70481, 70450, 69758, 69789
16026, 62910, 62900, 62680, 62690, 62911, 62901, 62681, 62691, 70482, 70452, 69790, 70483, 70485, 70455, 69793, 
70486, 70484, 70453, 69761, 69792
16027, 62911, 62901, 62681, 62691, 62912, 62902, 62682, 62692, 70485, 70455, 69793, 70486, 70488, 70458, 69796, 
70489, 70487, 70456, 69764, 69795
16028, 62912, 62902, 62682, 62692, 18062, 18061, 18039, 18040, 70488, 70458, 69796, 70489, 18679, 18676, 18634, 
18678, 70490, 70459, 69767, 69798
16029, 16567, 16566, 16544, 16545, 62913, 62903, 62683, 62693, 17184, 17183, 17139, 17185, 70492, 70462, 69800, 
70493, 70491, 70460, 69768, 69799
16030, 62913, 62903, 62683, 62693, 62914, 62904, 62684, 62694, 70492, 70462, 69800, 70493, 70495, 70465, 69803, 
70496, 70494, 70463, 69771, 69802
16031, 62914, 62904, 62684, 62694, 62915, 62905, 62685, 62695, 70495, 70465, 69803, 70496, 70498, 70468, 69806, 
70499, 70497, 70466, 69774, 69805
16032, 62915, 62905, 62685, 62695, 62916, 62906, 62686, 62696, 70498, 70468, 69806, 70499, 70501, 70471, 69809, 
70502, 70500, 70469, 69777, 69808
16033, 62916, 62906, 62686, 62696, 62917, 62907, 62687, 62697, 70501, 70471, 69809, 70502, 70504, 70474, 69812, 
70505, 70503, 70472, 69780, 69811
16034, 62917, 62907, 62687, 62697, 62918, 62908, 62688, 62698, 70504, 70474, 69812, 70505, 70507, 70477, 69815, 
70508, 70506, 70475, 69783, 69814
16035, 62918, 62908, 62688, 62698, 62919, 62909, 62689, 62699, 70507, 70477, 69815, 70508, 70510, 70480, 69818, 
70511, 70509, 70478, 69786, 69817
16036, 62919, 62909, 62689, 62699, 62920, 62910, 62690, 62700, 70510, 70480, 69818, 70511, 70513, 70483, 69821, 
70514, 70512, 70481, 69789, 69820
16037, 62920, 62910, 62690, 62700, 62921, 62911, 62691, 62701, 70513, 70483, 69821, 70514, 70516, 70486, 69824, 
70517, 70515, 70484, 69792, 69823
16038, 62921, 62911, 62691, 62701, 62922, 62912, 62692, 62702, 70516, 70486, 69824, 70517, 70519, 70489, 69827, 
70520, 70518, 70487, 69795, 69826
16039, 62922, 62912, 62692, 62702, 18063, 18062, 18040, 18041, 70519, 70489, 69827, 70520, 18681, 18678, 18636, 
18680, 70521, 70490, 69798, 69829
16040, 16568, 16567, 16545, 16546, 62923, 62913, 62693, 62703, 17186, 17185, 17141, 17187, 70523, 70493, 69831, 
70524, 70522, 70491, 69799, 69830
16041, 62923, 62913, 62693, 62703, 62924, 62914, 62694, 62704, 70523, 70493, 69831, 70524, 70526, 70496, 69834, 
70527, 70525, 70494, 69802, 69833
16042, 62924, 62914, 62694, 62704, 62925, 62915, 62695, 62705, 70526, 70496, 69834, 70527, 70529, 70499, 69837, 
70530, 70528, 70497, 69805, 69836
16043, 62925, 62915, 62695, 62705, 62926, 62916, 62696, 62706, 70529, 70499, 69837, 70530, 70532, 70502, 69840, 
70533, 70531, 70500, 69808, 69839
16044, 62926, 62916, 62696, 62706, 62927, 62917, 62697, 62707, 70532, 70502, 69840, 70533, 70535, 70505, 69843, 
70536, 70534, 70503, 69811, 69842
16045, 62927, 62917, 62697, 62707, 62928, 62918, 62698, 62708, 70535, 70505, 69843, 70536, 70538, 70508, 69846, 
70539, 70537, 70506, 69814, 69845
16046, 62928, 62918, 62698, 62708, 62929, 62919, 62699, 62709, 70538, 70508, 69846, 70539, 70541, 70511, 69849, 
70542, 70540, 70509, 69817, 69848
16047, 62929, 62919, 62699, 62709, 62930, 62920, 62700, 62710, 70541, 70511, 69849, 70542, 70544, 70514, 69852, 
70545, 70543, 70512, 69820, 69851
16048, 62930, 62920, 62700, 62710, 62931, 62921, 62701, 62711, 70544, 70514, 69852, 70545, 70547, 70517, 69855, 
70548, 70546, 70515, 69823, 69854
16049, 62931, 62921, 62701, 62711, 62932, 62922, 62702, 62712, 70547, 70517, 69855, 70548, 70550, 70520, 69858, 
70551, 70549, 70518, 69826, 69857
16050, 62932, 62922, 62702, 62712, 18064, 18063, 18041, 18042, 70550, 70520, 69858, 70551, 18683, 18680, 18638, 
18682, 70552, 70521, 69829, 69860
16051, 16569, 16568, 16546, 16547, 62933, 62923, 62703, 62713, 17188, 17187, 17143, 17189, 70554, 70524, 69862, 
70555, 70553, 70522, 69830, 69861
16052, 62933, 62923, 62703, 62713, 62934, 62924, 62704, 62714, 70554, 70524, 69862, 70555, 70557, 70527, 69865, 
70558, 70556, 70525, 69833, 69864
16053, 62934, 62924, 62704, 62714, 62935, 62925, 62705, 62715, 70557, 70527, 69865, 70558, 70560, 70530, 69868, 
70561, 70559, 70528, 69836, 69867
16054, 62935, 62925, 62705, 62715, 62936, 62926, 62706, 62716, 70560, 70530, 69868, 70561, 70563, 70533, 69871, 
70564, 70562, 70531, 69839, 69870
16055, 62936, 62926, 62706, 62716, 62937, 62927, 62707, 62717, 70563, 70533, 69871, 70564, 70566, 70536, 69874, 
70567, 70565, 70534, 69842, 69873
16056, 62937, 62927, 62707, 62717, 62938, 62928, 62708, 62718, 70566, 70536, 69874, 70567, 70569, 70539, 69877, 
70570, 70568, 70537, 69845, 69876
16057, 62938, 62928, 62708, 62718, 62939, 62929, 62709, 62719, 70569, 70539, 69877, 70570, 70572, 70542, 69880, 
70573, 70571, 70540, 69848, 69879
16058, 62939, 62929, 62709, 62719, 62940, 62930, 62710, 62720, 70572, 70542, 69880, 70573, 70575, 70545, 69883, 
70576, 70574, 70543, 69851, 69882
16059, 62940, 62930, 62710, 62720, 62941, 62931, 62711, 62721, 70575, 70545, 69883, 70576, 70578, 70548, 69886, 
70579, 70577, 70546, 69854, 69885
16060, 62941, 62931, 62711, 62721, 62942, 62932, 62712, 62722, 70578, 70548, 69886, 70579, 70581, 70551, 69889, 
70582, 70580, 70549, 69857, 69888
16061, 62942, 62932, 62712, 62722, 18065, 18064, 18042, 18043, 70581, 70551, 69889, 70582, 18685, 18682, 18640, 
18684, 70583, 70552, 69860, 69891
16062, 16570, 16569, 16547, 16548, 62943, 62933, 62713, 62723, 17190, 17189, 17145, 17191, 70585, 70555, 69893, 
70586, 70584, 70553, 69861, 69892
16063, 62943, 62933, 62713, 62723, 62944, 62934, 62714, 62724, 70585, 70555, 69893, 70586, 70588, 70558, 69896, 
70589, 70587, 70556, 69864, 69895
16064, 62944, 62934, 62714, 62724, 62945, 62935, 62715, 62725, 70588, 70558, 69896, 70589, 70591, 70561, 69899, 
70592, 70590, 70559, 69867, 69898
16065, 62945, 62935, 62715, 62725, 62946, 62936, 62716, 62726, 70591, 70561, 69899, 70592, 70594, 70564, 69902, 
70595, 70593, 70562, 69870, 69901
16066, 62946, 62936, 62716, 62726, 62947, 62937, 62717, 62727, 70594, 70564, 69902, 70595, 70597, 70567, 69905, 
70598, 70596, 70565, 69873, 69904
16067, 62947, 62937, 62717, 62727, 62948, 62938, 62718, 62728, 70597, 70567, 69905, 70598, 70600, 70570, 69908, 
70601, 70599, 70568, 69876, 69907
16068, 62948, 62938, 62718, 62728, 62949, 62939, 62719, 62729, 70600, 70570, 69908, 70601, 70603, 70573, 69911, 
70604, 70602, 70571, 69879, 69910
16069, 62949, 62939, 62719, 62729, 62950, 62940, 62720, 62730, 70603, 70573, 69911, 70604, 70606, 70576, 69914, 
70607, 70605, 70574, 69882, 69913
16070, 62950, 62940, 62720, 62730, 62951, 62941, 62721, 62731, 70606, 70576, 69914, 70607, 70609, 70579, 69917, 
70610, 70608, 70577, 69885, 69916
16071, 62951, 62941, 62721, 62731, 62952, 62942, 62722, 62732, 70609, 70579, 69917, 70610, 70612, 70582, 69920, 
70613, 70611, 70580, 69888, 69919
16072, 62952, 62942, 62722, 62732, 18066, 18065, 18043, 18044, 70612, 70582, 69920, 70613, 18687, 18684, 18642, 
18686, 70614, 70583, 69891, 69922
16073, 1639, 16570, 16548, 1638, 20173, 62943, 62723, 20163, 17192, 17191, 17147, 1661, 70615, 70586, 69923, 
20449, 20448, 70584, 69892, 20427
16074, 20173, 62943, 62723, 20163, 20174, 62944, 62724, 20164, 70615, 70586, 69923, 20449, 70616, 70589, 69924, 
20451, 20450, 70587, 69895, 20429
16075, 20174, 62944, 62724, 20164, 20175, 62945, 62725, 20165, 70616, 70589, 69924, 20451, 70617, 70592, 69925, 
20453, 20452, 70590, 69898, 20431
16076, 20175, 62945, 62725, 20165, 20176, 62946, 62726, 20166, 70617, 70592, 69925, 20453, 70618, 70595, 69926, 
20455, 20454, 70593, 69901, 20433
16077, 20176, 62946, 62726, 20166, 20177, 62947, 62727, 20167, 70618, 70595, 69926, 20455, 70619, 70598, 69927, 
20457, 20456, 70596, 69904, 20435
16078, 20177, 62947, 62727, 20167, 20178, 62948, 62728, 20168, 70619, 70598, 69927, 20457, 70620, 70601, 69928, 
20459, 20458, 70599, 69907, 20437
16079, 20178, 62948, 62728, 20168, 20179, 62949, 62729, 20169, 70620, 70601, 69928, 20459, 70621, 70604, 69929, 
20461, 20460, 70602, 69910, 20439
16080, 20179, 62949, 62729, 20169, 20180, 62950, 62730, 20170, 70621, 70604, 69929, 20461, 70622, 70607, 69930, 
20463, 20462, 70605, 69913, 20441
16081, 20180, 62950, 62730, 20170, 20181, 62951, 62731, 20171, 70622, 70607, 69930, 20463, 70623, 70610, 69931, 
20465, 20464, 70608, 69916, 20443
16082, 20181, 62951, 62731, 20171, 20182, 62952, 62732, 20172, 70623, 70610, 69931, 20465, 70624, 70613, 69932, 
20467, 20466, 70611, 69919, 20445
16083, 20182, 62952, 62732, 20172, 1774, 18066, 18044, 1773, 70624, 70613, 69932, 20467, 18688, 18686, 18643, 
1796, 20468, 70614, 69922, 20447
16084, 16571, 1595, 1594, 16549, 62953, 19491, 19481, 62733, 17193, 1617, 17148, 17194, 70626, 19777, 69934, 
70627, 70625, 19778, 19757, 69933
16085, 62953, 19491, 19481, 62733, 62954, 19492, 19482, 62734, 70626, 19777, 69934, 70627, 70629, 19779, 69937, 
70630, 70628, 19780, 19759, 69936
16086, 62954, 19492, 19482, 62734, 62955, 19493, 19483, 62735, 70629, 19779, 69937, 70630, 70632, 19781, 69940, 
70633, 70631, 19782, 19761, 69939
16087, 62955, 19493, 19483, 62735, 62956, 19494, 19484, 62736, 70632, 19781, 69940, 70633, 70635, 19783, 69943, 
70636, 70634, 19784, 19763, 69942
16088, 62956, 19494, 19484, 62736, 62957, 19495, 19485, 62737, 70635, 19783, 69943, 70636, 70638, 19785, 69946, 
70639, 70637, 19786, 19765, 69945
16089, 62957, 19495, 19485, 62737, 62958, 19496, 19486, 62738, 70638, 19785, 69946, 70639, 70641, 19787, 69949, 
70642, 70640, 19788, 19767, 69948
16090, 62958, 19496, 19486, 62738, 62959, 19497, 19487, 62739, 70641, 19787, 69949, 70642, 70644, 19789, 69952, 
70645, 70643, 19790, 19769, 69951
16091, 62959, 19497, 19487, 62739, 62960, 19498, 19488, 62740, 70644, 19789, 69952, 70645, 70647, 19791, 69955, 
70648, 70646, 19792, 19771, 69954
16092, 62960, 19498, 19488, 62740, 62961, 19499, 19489, 62741, 70647, 19791, 69955, 70648, 70650, 19793, 69958, 
70651, 70649, 19794, 19773, 69957
16093, 62961, 19499, 19489, 62741, 62962, 19500, 19490, 62742, 70650, 19793, 69958, 70651, 70653, 19795, 69961, 
70654, 70652, 19796, 19775, 69960
16094, 62962, 19500, 19490, 62742, 18067, 1730, 1729, 18045, 70653, 19795, 69961, 70654, 18690, 1752, 18645, 
18689, 70655, 19797, 19776, 69963
16095, 16572, 16571, 16549, 16550, 62963, 62953, 62733, 62743, 17195, 17194, 17150, 17196, 70657, 70627, 69965, 
70658, 70656, 70625, 69933, 69964
16096, 62963, 62953, 62733, 62743, 62964, 62954, 62734, 62744, 70657, 70627, 69965, 70658, 70660, 70630, 69968, 
70661, 70659, 70628, 69936, 69967
16097, 62964, 62954, 62734, 62744, 62965, 62955, 62735, 62745, 70660, 70630, 69968, 70661, 70663, 70633, 69971, 
70664, 70662, 70631, 69939, 69970
16098, 62965, 62955, 62735, 62745, 62966, 62956, 62736, 62746, 70663, 70633, 69971, 70664, 70666, 70636, 69974, 
70667, 70665, 70634, 69942, 69973
16099, 62966, 62956, 62736, 62746, 62967, 62957, 62737, 62747, 70666, 70636, 69974, 70667, 70669, 70639, 69977, 
70670, 70668, 70637, 69945, 69976
16100, 62967, 62957, 62737, 62747, 62968, 62958, 62738, 62748, 70669, 70639, 69977, 70670, 70672, 70642, 69980, 
70673, 70671, 70640, 69948, 69979
16101, 62968, 62958, 62738, 62748, 62969, 62959, 62739, 62749, 70672, 70642, 69980, 70673, 70675, 70645, 69983, 
70676, 70674, 70643, 69951, 69982
16102, 62969, 62959, 62739, 62749, 62970, 62960, 62740, 62750, 70675, 70645, 69983, 70676, 70678, 70648, 69986, 
70679, 70677, 70646, 69954, 69985
16103, 62970, 62960, 62740, 62750, 62971, 62961, 62741, 62751, 70678, 70648, 69986, 70679, 70681, 70651, 69989, 
70682, 70680, 70649, 69957, 69988
16104, 62971, 62961, 62741, 62751, 62972, 62962, 62742, 62752, 70681, 70651, 69989, 70682, 70684, 70654, 69992, 
70685, 70683, 70652, 69960, 69991
16105, 62972, 62962, 62742, 62752, 18068, 18067, 18045, 18046, 70684, 70654, 69992, 70685, 18692, 18689, 18647, 
18691, 70686, 70655, 69963, 69994
16106, 16573, 16572, 16550, 16551, 62973, 62963, 62743, 62753, 17197, 17196, 17152, 17198, 70688, 70658, 69996, 
70689, 70687, 70656, 69964, 69995
16107, 62973, 62963, 62743, 62753, 62974, 62964, 62744, 62754, 70688, 70658, 69996, 70689, 70691, 70661, 69999, 
70692, 70690, 70659, 69967, 69998
16108, 62974, 62964, 62744, 62754, 62975, 62965, 62745, 62755, 70691, 70661, 69999, 70692, 70694, 70664, 70002, 
70695, 70693, 70662, 69970, 70001
16109, 62975, 62965, 62745, 62755, 62976, 62966, 62746, 62756, 70694, 70664, 70002, 70695, 70697, 70667, 70005, 
70698, 70696, 70665, 69973, 70004
16110, 62976, 62966, 62746, 62756, 62977, 62967, 62747, 62757, 70697, 70667, 70005, 70698, 70700, 70670, 70008, 
70701, 70699, 70668, 69976, 70007
16111, 62977, 62967, 62747, 62757, 62978, 62968, 62748, 62758, 70700, 70670, 70008, 70701, 70703, 70673, 70011, 
70704, 70702, 70671, 69979, 70010
16112, 62978, 62968, 62748, 62758, 62979, 62969, 62749, 62759, 70703, 70673, 70011, 70704, 70706, 70676, 70014, 
70707, 70705, 70674, 69982, 70013
16113, 62979, 62969, 62749, 62759, 62980, 62970, 62750, 62760, 70706, 70676, 70014, 70707, 70709, 70679, 70017, 
70710, 70708, 70677, 69985, 70016
16114, 62980, 62970, 62750, 62760, 62981, 62971, 62751, 62761, 70709, 70679, 70017, 70710, 70712, 70682, 70020, 
70713, 70711, 70680, 69988, 70019
16115, 62981, 62971, 62751, 62761, 62982, 62972, 62752, 62762, 70712, 70682, 70020, 70713, 70715, 70685, 70023, 
70716, 70714, 70683, 69991, 70022
16116, 62982, 62972, 62752, 62762, 18069, 18068, 18046, 18047, 70715, 70685, 70023, 70716, 18694, 18691, 18649, 
18693, 70717, 70686, 69994, 70025
16117, 16574, 16573, 16551, 16552, 62983, 62973, 62753, 62763, 17199, 17198, 17154, 17200, 70719, 70689, 70027, 
70720, 70718, 70687, 69995, 70026
16118, 62983, 62973, 62753, 62763, 62984, 62974, 62754, 62764, 70719, 70689, 70027, 70720, 70722, 70692, 70030, 
70723, 70721, 70690, 69998, 70029
16119, 62984, 62974, 62754, 62764, 62985, 62975, 62755, 62765, 70722, 70692, 70030, 70723, 70725, 70695, 70033, 
70726, 70724, 70693, 70001, 70032
16120, 62985, 62975, 62755, 62765, 62986, 62976, 62756, 62766, 70725, 70695, 70033, 70726, 70728, 70698, 70036, 
70729, 70727, 70696, 70004, 70035
16121, 62986, 62976, 62756, 62766, 62987, 62977, 62757, 62767, 70728, 70698, 70036, 70729, 70731, 70701, 70039, 
70732, 70730, 70699, 70007, 70038
16122, 62987, 62977, 62757, 62767, 62988, 62978, 62758, 62768, 70731, 70701, 70039, 70732, 70734, 70704, 70042, 
70735, 70733, 70702, 70010, 70041
16123, 62988, 62978, 62758, 62768, 62989, 62979, 62759, 62769, 70734, 70704, 70042, 70735, 70737, 70707, 70045, 
70738, 70736, 70705, 70013, 70044
16124, 62989, 62979, 62759, 62769, 62990, 62980, 62760, 62770, 70737, 70707, 70045, 70738, 70740, 70710, 70048, 
70741, 70739, 70708, 70016, 70047
16125, 62990, 62980, 62760, 62770, 62991, 62981, 62761, 62771, 70740, 70710, 70048, 70741, 70743, 70713, 70051, 
70744, 70742, 70711, 70019, 70050
16126, 62991, 62981, 62761, 62771, 62992, 62982, 62762, 62772, 70743, 70713, 70051, 70744, 70746, 70716, 70054, 
70747, 70745, 70714, 70022, 70053
16127, 62992, 62982, 62762, 62772, 18070, 18069, 18047, 18048, 70746, 70716, 70054, 70747, 18696, 18693, 18651, 
18695, 70748, 70717, 70025, 70056
16128, 16575, 16574, 16552, 16553, 62993, 62983, 62763, 62773, 17201, 17200, 17156, 17202, 70750, 70720, 70058, 
70751, 70749, 70718, 70026, 70057
16129, 62993, 62983, 62763, 62773, 62994, 62984, 62764, 62774, 70750, 70720, 70058, 70751, 70753, 70723, 70061, 
70754, 70752, 70721, 70029, 70060
16130, 62994, 62984, 62764, 62774, 62995, 62985, 62765, 62775, 70753, 70723, 70061, 70754, 70756, 70726, 70064, 
70757, 70755, 70724, 70032, 70063
16131, 62995, 62985, 62765, 62775, 62996, 62986, 62766, 62776, 70756, 70726, 70064, 70757, 70759, 70729, 70067, 
70760, 70758, 70727, 70035, 70066
16132, 62996, 62986, 62766, 62776, 62997, 62987, 62767, 62777, 70759, 70729, 70067, 70760, 70762, 70732, 70070, 
70763, 70761, 70730, 70038, 70069
16133, 62997, 62987, 62767, 62777, 62998, 62988, 62768, 62778, 70762, 70732, 70070, 70763, 70765, 70735, 70073, 
70766, 70764, 70733, 70041, 70072
16134, 62998, 62988, 62768, 62778, 62999, 62989, 62769, 62779, 70765, 70735, 70073, 70766, 70768, 70738, 70076, 
70769, 70767, 70736, 70044, 70075
16135, 62999, 62989, 62769, 62779, 63000, 62990, 62770, 62780, 70768, 70738, 70076, 70769, 70771, 70741, 70079, 
70772, 70770, 70739, 70047, 70078
16136, 63000, 62990, 62770, 62780, 63001, 62991, 62771, 62781, 70771, 70741, 70079, 70772, 70774, 70744, 70082, 
70775, 70773, 70742, 70050, 70081
16137, 63001, 62991, 62771, 62781, 63002, 62992, 62772, 62782, 70774, 70744, 70082, 70775, 70777, 70747, 70085, 
70778, 70776, 70745, 70053, 70084
16138, 63002, 62992, 62772, 62782, 18071, 18070, 18048, 18049, 70777, 70747, 70085, 70778, 18698, 18695, 18653, 
18697, 70779, 70748, 70056, 70087
16139, 16576, 16575, 16553, 16554, 63003, 62993, 62773, 62783, 17203, 17202, 17158, 17204, 70781, 70751, 70089, 
70782, 70780, 70749, 70057, 70088
16140, 63003, 62993, 62773, 62783, 63004, 62994, 62774, 62784, 70781, 70751, 70089, 70782, 70784, 70754, 70092, 
70785, 70783, 70752, 70060, 70091
16141, 63004, 62994, 62774, 62784, 63005, 62995, 62775, 62785, 70784, 70754, 70092, 70785, 70787, 70757, 70095, 
70788, 70786, 70755, 70063, 70094
16142, 63005, 62995, 62775, 62785, 63006, 62996, 62776, 62786, 70787, 70757, 70095, 70788, 70790, 70760, 70098, 
70791, 70789, 70758, 70066, 70097
16143, 63006, 62996, 62776, 62786, 63007, 62997, 62777, 62787, 70790, 70760, 70098, 70791, 70793, 70763, 70101, 
70794, 70792, 70761, 70069, 70100
16144, 63007, 62997, 62777, 62787, 63008, 62998, 62778, 62788, 70793, 70763, 70101, 70794, 70796, 70766, 70104, 
70797, 70795, 70764, 70072, 70103
16145, 63008, 62998, 62778, 62788, 63009, 62999, 62779, 62789, 70796, 70766, 70104, 70797, 70799, 70769, 70107, 
70800, 70798, 70767, 70075, 70106
16146, 63009, 62999, 62779, 62789, 63010, 63000, 62780, 62790, 70799, 70769, 70107, 70800, 70802, 70772, 70110, 
70803, 70801, 70770, 70078, 70109
16147, 63010, 63000, 62780, 62790, 63011, 63001, 62781, 62791, 70802, 70772, 70110, 70803, 70805, 70775, 70113, 
70806, 70804, 70773, 70081, 70112
16148, 63011, 63001, 62781, 62791, 63012, 63002, 62782, 62792, 70805, 70775, 70113, 70806, 70808, 70778, 70116, 
70809, 70807, 70776, 70084, 70115
16149, 63012, 63002, 62782, 62792, 18072, 18071, 18049, 18050, 70808, 70778, 70116, 70809, 18700, 18697, 18655, 
18699, 70810, 70779, 70087, 70118
16150, 16577, 16576, 16554, 16555, 63013, 63003, 62783, 62793, 17205, 17204, 17160, 17206, 70812, 70782, 70120, 
70813, 70811, 70780, 70088, 70119
16151, 63013, 63003, 62783, 62793, 63014, 63004, 62784, 62794, 70812, 70782, 70120, 70813, 70815, 70785, 70123, 
70816, 70814, 70783, 70091, 70122
16152, 63014, 63004, 62784, 62794, 63015, 63005, 62785, 62795, 70815, 70785, 70123, 70816, 70818, 70788, 70126, 
70819, 70817, 70786, 70094, 70125
16153, 63015, 63005, 62785, 62795, 63016, 63006, 62786, 62796, 70818, 70788, 70126, 70819, 70821, 70791, 70129, 
70822, 70820, 70789, 70097, 70128
16154, 63016, 63006, 62786, 62796, 63017, 63007, 62787, 62797, 70821, 70791, 70129, 70822, 70824, 70794, 70132, 
70825, 70823, 70792, 70100, 70131
16155, 63017, 63007, 62787, 62797, 63018, 63008, 62788, 62798, 70824, 70794, 70132, 70825, 70827, 70797, 70135, 
70828, 70826, 70795, 70103, 70134
16156, 63018, 63008, 62788, 62798, 63019, 63009, 62789, 62799, 70827, 70797, 70135, 70828, 70830, 70800, 70138, 
70831, 70829, 70798, 70106, 70137
16157, 63019, 63009, 62789, 62799, 63020, 63010, 62790, 62800, 70830, 70800, 70138, 70831, 70833, 70803, 70141, 
70834, 70832, 70801, 70109, 70140
16158, 63020, 63010, 62790, 62800, 63021, 63011, 62791, 62801, 70833, 70803, 70141, 70834, 70836, 70806, 70144, 
70837, 70835, 70804, 70112, 70143
16159, 63021, 63011, 62791, 62801, 63022, 63012, 62792, 62802, 70836, 70806, 70144, 70837, 70839, 70809, 70147, 
70840, 70838, 70807, 70115, 70146
16160, 63022, 63012, 62792, 62802, 18073, 18072, 18050, 18051, 70839, 70809, 70147, 70840, 18702, 18699, 18657, 
18701, 70841, 70810, 70118, 70149
16161, 16578, 16577, 16555, 16556, 63023, 63013, 62793, 62803, 17207, 17206, 17162, 17208, 70843, 70813, 70151, 
70844, 70842, 70811, 70119, 70150
16162, 63023, 63013, 62793, 62803, 63024, 63014, 62794, 62804, 70843, 70813, 70151, 70844, 70846, 70816, 70154, 
70847, 70845, 70814, 70122, 70153
16163, 63024, 63014, 62794, 62804, 63025, 63015, 62795, 62805, 70846, 70816, 70154, 70847, 70849, 70819, 70157, 
70850, 70848, 70817, 70125, 70156
16164, 63025, 63015, 62795, 62805, 63026, 63016, 62796, 62806, 70849, 70819, 70157, 70850, 70852, 70822, 70160, 
70853, 70851, 70820, 70128, 70159
16165, 63026, 63016, 62796, 62806, 63027, 63017, 62797, 62807, 70852, 70822, 70160, 70853, 70855, 70825, 70163, 
70856, 70854, 70823, 70131, 70162
16166, 63027, 63017, 62797, 62807, 63028, 63018, 62798, 62808, 70855, 70825, 70163, 70856, 70858, 70828, 70166, 
70859, 70857, 70826, 70134, 70165
16167, 63028, 63018, 62798, 62808, 63029, 63019, 62799, 62809, 70858, 70828, 70166, 70859, 70861, 70831, 70169, 
70862, 70860, 70829, 70137, 70168
16168, 63029, 63019, 62799, 62809, 63030, 63020, 62800, 62810, 70861, 70831, 70169, 70862, 70864, 70834, 70172, 
70865, 70863, 70832, 70140, 70171
16169, 63030, 63020, 62800, 62810, 63031, 63021, 62801, 62811, 70864, 70834, 70172, 70865, 70867, 70837, 70175, 
70868, 70866, 70835, 70143, 70174
16170, 63031, 63021, 62801, 62811, 63032, 63022, 62802, 62812, 70867, 70837, 70175, 70868, 70870, 70840, 70178, 
70871, 70869, 70838, 70146, 70177
16171, 63032, 63022, 62802, 62812, 18074, 18073, 18051, 18052, 70870, 70840, 70178, 70871, 18704, 18701, 18659, 
18703, 70872, 70841, 70149, 70180
16172, 16579, 16578, 16556, 16557, 63033, 63023, 62803, 62813, 17209, 17208, 17164, 17210, 70874, 70844, 70182, 
70875, 70873, 70842, 70150, 70181
16173, 63033, 63023, 62803, 62813, 63034, 63024, 62804, 62814, 70874, 70844, 70182, 70875, 70877, 70847, 70185, 
70878, 70876, 70845, 70153, 70184
16174, 63034, 63024, 62804, 62814, 63035, 63025, 62805, 62815, 70877, 70847, 70185, 70878, 70880, 70850, 70188, 
70881, 70879, 70848, 70156, 70187
16175, 63035, 63025, 62805, 62815, 63036, 63026, 62806, 62816, 70880, 70850, 70188, 70881, 70883, 70853, 70191, 
70884, 70882, 70851, 70159, 70190
16176, 63036, 63026, 62806, 62816, 63037, 63027, 62807, 62817, 70883, 70853, 70191, 70884, 70886, 70856, 70194, 
70887, 70885, 70854, 70162, 70193
16177, 63037, 63027, 62807, 62817, 63038, 63028, 62808, 62818, 70886, 70856, 70194, 70887, 70889, 70859, 70197, 
70890, 70888, 70857, 70165, 70196
16178, 63038, 63028, 62808, 62818, 63039, 63029, 62809, 62819, 70889, 70859, 70197, 70890, 70892, 70862, 70200, 
70893, 70891, 70860, 70168, 70199
16179, 63039, 63029, 62809, 62819, 63040, 63030, 62810, 62820, 70892, 70862, 70200, 70893, 70895, 70865, 70203, 
70896, 70894, 70863, 70171, 70202
16180, 63040, 63030, 62810, 62820, 63041, 63031, 62811, 62821, 70895, 70865, 70203, 70896, 70898, 70868, 70206, 
70899, 70897, 70866, 70174, 70205
16181, 63041, 63031, 62811, 62821, 63042, 63032, 62812, 62822, 70898, 70868, 70206, 70899, 70901, 70871, 70209, 
70902, 70900, 70869, 70177, 70208
16182, 63042, 63032, 62812, 62822, 18075, 18074, 18052, 18053, 70901, 70871, 70209, 70902, 18706, 18703, 18661, 
18705, 70903, 70872, 70180, 70211
16183, 16580, 16579, 16557, 16558, 63043, 63033, 62813, 62823, 17211, 17210, 17166, 17212, 70905, 70875, 70213, 
70906, 70904, 70873, 70181, 70212
16184, 63043, 63033, 62813, 62823, 63044, 63034, 62814, 62824, 70905, 70875, 70213, 70906, 70908, 70878, 70216, 
70909, 70907, 70876, 70184, 70215
16185, 63044, 63034, 62814, 62824, 63045, 63035, 62815, 62825, 70908, 70878, 70216, 70909, 70911, 70881, 70219, 
70912, 70910, 70879, 70187, 70218
16186, 63045, 63035, 62815, 62825, 63046, 63036, 62816, 62826, 70911, 70881, 70219, 70912, 70914, 70884, 70222, 
70915, 70913, 70882, 70190, 70221
16187, 63046, 63036, 62816, 62826, 63047, 63037, 62817, 62827, 70914, 70884, 70222, 70915, 70917, 70887, 70225, 
70918, 70916, 70885, 70193, 70224
16188, 63047, 63037, 62817, 62827, 63048, 63038, 62818, 62828, 70917, 70887, 70225, 70918, 70920, 70890, 70228, 
70921, 70919, 70888, 70196, 70227
16189, 63048, 63038, 62818, 62828, 63049, 63039, 62819, 62829, 70920, 70890, 70228, 70921, 70923, 70893, 70231, 
70924, 70922, 70891, 70199, 70230
16190, 63049, 63039, 62819, 62829, 63050, 63040, 62820, 62830, 70923, 70893, 70231, 70924, 70926, 70896, 70234, 
70927, 70925, 70894, 70202, 70233
16191, 63050, 63040, 62820, 62830, 63051, 63041, 62821, 62831, 70926, 70896, 70234, 70927, 70929, 70899, 70237, 
70930, 70928, 70897, 70205, 70236
16192, 63051, 63041, 62821, 62831, 63052, 63042, 62822, 62832, 70929, 70899, 70237, 70930, 70932, 70902, 70240, 
70933, 70931, 70900, 70208, 70239
16193, 63052, 63042, 62822, 62832, 18076, 18075, 18053, 18054, 70932, 70902, 70240, 70933, 18708, 18705, 18663, 
18707, 70934, 70903, 70211, 70242
16194, 16581, 16580, 16558, 16559, 63053, 63043, 62823, 62833, 17213, 17212, 17168, 17214, 70936, 70906, 70244, 
70937, 70935, 70904, 70212, 70243
16195, 63053, 63043, 62823, 62833, 63054, 63044, 62824, 62834, 70936, 70906, 70244, 70937, 70939, 70909, 70247, 
70940, 70938, 70907, 70215, 70246
16196, 63054, 63044, 62824, 62834, 63055, 63045, 62825, 62835, 70939, 70909, 70247, 70940, 70942, 70912, 70250, 
70943, 70941, 70910, 70218, 70249
16197, 63055, 63045, 62825, 62835, 63056, 63046, 62826, 62836, 70942, 70912, 70250, 70943, 70945, 70915, 70253, 
70946, 70944, 70913, 70221, 70252
16198, 63056, 63046, 62826, 62836, 63057, 63047, 62827, 62837, 70945, 70915, 70253, 70946, 70948, 70918, 70256, 
70949, 70947, 70916, 70224, 70255
16199, 63057, 63047, 62827, 62837, 63058, 63048, 62828, 62838, 70948, 70918, 70256, 70949, 70951, 70921, 70259, 
70952, 70950, 70919, 70227, 70258
16200, 63058, 63048, 62828, 62838, 63059, 63049, 62829, 62839, 70951, 70921, 70259, 70952, 70954, 70924, 70262, 
70955, 70953, 70922, 70230, 70261
16201, 63059, 63049, 62829, 62839, 63060, 63050, 62830, 62840, 70954, 70924, 70262, 70955, 70957, 70927, 70265, 
70958, 70956, 70925, 70233, 70264
16202, 63060, 63050, 62830, 62840, 63061, 63051, 62831, 62841, 70957, 70927, 70265, 70958, 70960, 70930, 70268, 
70961, 70959, 70928, 70236, 70267
16203, 63061, 63051, 62831, 62841, 63062, 63052, 62832, 62842, 70960, 70930, 70268, 70961, 70963, 70933, 70271, 
70964, 70962, 70931, 70239, 70270
16204, 63062, 63052, 62832, 62842, 18077, 18076, 18054, 18055, 70963, 70933, 70271, 70964, 18710, 18707, 18665, 
18709, 70965, 70934, 70242, 70273
16205, 16582, 16581, 16559, 16560, 63063, 63053, 62833, 62843, 17215, 17214, 17170, 17216, 70967, 70937, 70275, 
70968, 70966, 70935, 70243, 70274
16206, 63063, 63053, 62833, 62843, 63064, 63054, 62834, 62844, 70967, 70937, 70275, 70968, 70970, 70940, 70278, 
70971, 70969, 70938, 70246, 70277
16207, 63064, 63054, 62834, 62844, 63065, 63055, 62835, 62845, 70970, 70940, 70278, 70971, 70973, 70943, 70281, 
70974, 70972, 70941, 70249, 70280
16208, 63065, 63055, 62835, 62845, 63066, 63056, 62836, 62846, 70973, 70943, 70281, 70974, 70976, 70946, 70284, 
70977, 70975, 70944, 70252, 70283
16209, 63066, 63056, 62836, 62846, 63067, 63057, 62837, 62847, 70976, 70946, 70284, 70977, 70979, 70949, 70287, 
70980, 70978, 70947, 70255, 70286
16210, 63067, 63057, 62837, 62847, 63068, 63058, 62838, 62848, 70979, 70949, 70287, 70980, 70982, 70952, 70290, 
70983, 70981, 70950, 70258, 70289
16211, 63068, 63058, 62838, 62848, 63069, 63059, 62839, 62849, 70982, 70952, 70290, 70983, 70985, 70955, 70293, 
70986, 70984, 70953, 70261, 70292
16212, 63069, 63059, 62839, 62849, 63070, 63060, 62840, 62850, 70985, 70955, 70293, 70986, 70988, 70958, 70296, 
70989, 70987, 70956, 70264, 70295
16213, 63070, 63060, 62840, 62850, 63071, 63061, 62841, 62851, 70988, 70958, 70296, 70989, 70991, 70961, 70299, 
70992, 70990, 70959, 70267, 70298
16214, 63071, 63061, 62841, 62851, 63072, 63062, 62842, 62852, 70991, 70961, 70299, 70992, 70994, 70964, 70302, 
70995, 70993, 70962, 70270, 70301
16215, 63072, 63062, 62842, 62852, 18078, 18077, 18055, 18056, 70994, 70964, 70302, 70995, 18712, 18709, 18667, 
18711, 70996, 70965, 70273, 70304
16216, 16583, 16582, 16560, 16561, 63073, 63063, 62843, 62853, 17217, 17216, 17172, 17218, 70998, 70968, 70306, 
70999, 70997, 70966, 70274, 70305
16217, 63073, 63063, 62843, 62853, 63074, 63064, 62844, 62854, 70998, 70968, 70306, 70999, 71001, 70971, 70309, 
71002, 71000, 70969, 70277, 70308
16218, 63074, 63064, 62844, 62854, 63075, 63065, 62845, 62855, 71001, 70971, 70309, 71002, 71004, 70974, 70312, 
71005, 71003, 70972, 70280, 70311
16219, 63075, 63065, 62845, 62855, 63076, 63066, 62846, 62856, 71004, 70974, 70312, 71005, 71007, 70977, 70315, 
71008, 71006, 70975, 70283, 70314
16220, 63076, 63066, 62846, 62856, 63077, 63067, 62847, 62857, 71007, 70977, 70315, 71008, 71010, 70980, 70318, 
71011, 71009, 70978, 70286, 70317
16221, 63077, 63067, 62847, 62857, 63078, 63068, 62848, 62858, 71010, 70980, 70318, 71011, 71013, 70983, 70321, 
71014, 71012, 70981, 70289, 70320
16222, 63078, 63068, 62848, 62858, 63079, 63069, 62849, 62859, 71013, 70983, 70321, 71014, 71016, 70986, 70324, 
71017, 71015, 70984, 70292, 70323
16223, 63079, 63069, 62849, 62859, 63080, 63070, 62850, 62860, 71016, 70986, 70324, 71017, 71019, 70989, 70327, 
71020, 71018, 70987, 70295, 70326
16224, 63080, 63070, 62850, 62860, 63081, 63071, 62851, 62861, 71019, 70989, 70327, 71020, 71022, 70992, 70330, 
71023, 71021, 70990, 70298, 70329
16225, 63081, 63071, 62851, 62861, 63082, 63072, 62852, 62862, 71022, 70992, 70330, 71023, 71025, 70995, 70333, 
71026, 71024, 70993, 70301, 70332
16226, 63082, 63072, 62852, 62862, 18079, 18078, 18056, 18057, 71025, 70995, 70333, 71026, 18714, 18711, 18669, 
18713, 71027, 70996, 70304, 70335
16227, 16584, 16583, 16561, 16562, 63083, 63073, 62853, 62863, 17219, 17218, 17174, 17220, 71029, 70999, 70337, 
71030, 71028, 70997, 70305, 70336
16228, 63083, 63073, 62853, 62863, 63084, 63074, 62854, 62864, 71029, 70999, 70337, 71030, 71032, 71002, 70340, 
71033, 71031, 71000, 70308, 70339
16229, 63084, 63074, 62854, 62864, 63085, 63075, 62855, 62865, 71032, 71002, 70340, 71033, 71035, 71005, 70343, 
71036, 71034, 71003, 70311, 70342
16230, 63085, 63075, 62855, 62865, 63086, 63076, 62856, 62866, 71035, 71005, 70343, 71036, 71038, 71008, 70346, 
71039, 71037, 71006, 70314, 70345
16231, 63086, 63076, 62856, 62866, 63087, 63077, 62857, 62867, 71038, 71008, 70346, 71039, 71041, 71011, 70349, 
71042, 71040, 71009, 70317, 70348
16232, 63087, 63077, 62857, 62867, 63088, 63078, 62858, 62868, 71041, 71011, 70349, 71042, 71044, 71014, 70352, 
71045, 71043, 71012, 70320, 70351
16233, 63088, 63078, 62858, 62868, 63089, 63079, 62859, 62869, 71044, 71014, 70352, 71045, 71047, 71017, 70355, 
71048, 71046, 71015, 70323, 70354
16234, 63089, 63079, 62859, 62869, 63090, 63080, 62860, 62870, 71047, 71017, 70355, 71048, 71050, 71020, 70358, 
71051, 71049, 71018, 70326, 70357
16235, 63090, 63080, 62860, 62870, 63091, 63081, 62861, 62871, 71050, 71020, 70358, 71051, 71053, 71023, 70361, 
71054, 71052, 71021, 70329, 70360
16236, 63091, 63081, 62861, 62871, 63092, 63082, 62862, 62872, 71053, 71023, 70361, 71054, 71056, 71026, 70364, 
71057, 71055, 71024, 70332, 70363
16237, 63092, 63082, 62862, 62872, 18080, 18079, 18057, 18058, 71056, 71026, 70364, 71057, 18716, 18713, 18671, 
18715, 71058, 71027, 70335, 70366
16238, 16585, 16584, 16562, 16563, 63093, 63083, 62863, 62873, 17221, 17220, 17176, 17222, 71060, 71030, 70368, 
71061, 71059, 71028, 70336, 70367
16239, 63093, 63083, 62863, 62873, 63094, 63084, 62864, 62874, 71060, 71030, 70368, 71061, 71063, 71033, 70371, 
71064, 71062, 71031, 70339, 70370
16240, 63094, 63084, 62864, 62874, 63095, 63085, 62865, 62875, 71063, 71033, 70371, 71064, 71066, 71036, 70374, 
71067, 71065, 71034, 70342, 70373
16241, 63095, 63085, 62865, 62875, 63096, 63086, 62866, 62876, 71066, 71036, 70374, 71067, 71069, 71039, 70377, 
71070, 71068, 71037, 70345, 70376
16242, 63096, 63086, 62866, 62876, 63097, 63087, 62867, 62877, 71069, 71039, 70377, 71070, 71072, 71042, 70380, 
71073, 71071, 71040, 70348, 70379
16243, 63097, 63087, 62867, 62877, 63098, 63088, 62868, 62878, 71072, 71042, 70380, 71073, 71075, 71045, 70383, 
71076, 71074, 71043, 70351, 70382
16244, 63098, 63088, 62868, 62878, 63099, 63089, 62869, 62879, 71075, 71045, 70383, 71076, 71078, 71048, 70386, 
71079, 71077, 71046, 70354, 70385
16245, 63099, 63089, 62869, 62879, 63100, 63090, 62870, 62880, 71078, 71048, 70386, 71079, 71081, 71051, 70389, 
71082, 71080, 71049, 70357, 70388
16246, 63100, 63090, 62870, 62880, 63101, 63091, 62871, 62881, 71081, 71051, 70389, 71082, 71084, 71054, 70392, 
71085, 71083, 71052, 70360, 70391
16247, 63101, 63091, 62871, 62881, 63102, 63092, 62872, 62882, 71084, 71054, 70392, 71085, 71087, 71057, 70395, 
71088, 71086, 71055, 70363, 70394
16248, 63102, 63092, 62872, 62882, 18081, 18080, 18058, 18059, 71087, 71057, 70395, 71088, 18718, 18715, 18673, 
18717, 71089, 71058, 70366, 70397
16249, 16586, 16585, 16563, 16564, 63103, 63093, 62873, 62883, 17223, 17222, 17178, 17224, 71091, 71061, 70399, 
71092, 71090, 71059, 70367, 70398
16250, 63103, 63093, 62873, 62883, 63104, 63094, 62874, 62884, 71091, 71061, 70399, 71092, 71094, 71064, 70402, 
71095, 71093, 71062, 70370, 70401
16251, 63104, 63094, 62874, 62884, 63105, 63095, 62875, 62885, 71094, 71064, 70402, 71095, 71097, 71067, 70405, 
71098, 71096, 71065, 70373, 70404
16252, 63105, 63095, 62875, 62885, 63106, 63096, 62876, 62886, 71097, 71067, 70405, 71098, 71100, 71070, 70408, 
71101, 71099, 71068, 70376, 70407
16253, 63106, 63096, 62876, 62886, 63107, 63097, 62877, 62887, 71100, 71070, 70408, 71101, 71103, 71073, 70411, 
71104, 71102, 71071, 70379, 70410
16254, 63107, 63097, 62877, 62887, 63108, 63098, 62878, 62888, 71103, 71073, 70411, 71104, 71106, 71076, 70414, 
71107, 71105, 71074, 70382, 70413
16255, 63108, 63098, 62878, 62888, 63109, 63099, 62879, 62889, 71106, 71076, 70414, 71107, 71109, 71079, 70417, 
71110, 71108, 71077, 70385, 70416
16256, 63109, 63099, 62879, 62889, 63110, 63100, 62880, 62890, 71109, 71079, 70417, 71110, 71112, 71082, 70420, 
71113, 71111, 71080, 70388, 70419
16257, 63110, 63100, 62880, 62890, 63111, 63101, 62881, 62891, 71112, 71082, 70420, 71113, 71115, 71085, 70423, 
71116, 71114, 71083, 70391, 70422
16258, 63111, 63101, 62881, 62891, 63112, 63102, 62882, 62892, 71115, 71085, 70423, 71116, 71118, 71088, 70426, 
71119, 71117, 71086, 70394, 70425
16259, 63112, 63102, 62882, 62892, 18082, 18081, 18059, 18060, 71118, 71088, 70426, 71119, 18720, 18717, 18675, 
18719, 71120, 71089, 70397, 70428
16260, 16587, 16586, 16564, 16565, 63113, 63103, 62883, 62893, 17225, 17224, 17180, 17226, 71122, 71092, 70430, 
71123, 71121, 71090, 70398, 70429
16261, 63113, 63103, 62883, 62893, 63114, 63104, 62884, 62894, 71122, 71092, 70430, 71123, 71125, 71095, 70433, 
71126, 71124, 71093, 70401, 70432
16262, 63114, 63104, 62884, 62894, 63115, 63105, 62885, 62895, 71125, 71095, 70433, 71126, 71128, 71098, 70436, 
71129, 71127, 71096, 70404, 70435
16263, 63115, 63105, 62885, 62895, 63116, 63106, 62886, 62896, 71128, 71098, 70436, 71129, 71131, 71101, 70439, 
71132, 71130, 71099, 70407, 70438
16264, 63116, 63106, 62886, 62896, 63117, 63107, 62887, 62897, 71131, 71101, 70439, 71132, 71134, 71104, 70442, 
71135, 71133, 71102, 70410, 70441
16265, 63117, 63107, 62887, 62897, 63118, 63108, 62888, 62898, 71134, 71104, 70442, 71135, 71137, 71107, 70445, 
71138, 71136, 71105, 70413, 70444
16266, 63118, 63108, 62888, 62898, 63119, 63109, 62889, 62899, 71137, 71107, 70445, 71138, 71140, 71110, 70448, 
71141, 71139, 71108, 70416, 70447
16267, 63119, 63109, 62889, 62899, 63120, 63110, 62890, 62900, 71140, 71110, 70448, 71141, 71143, 71113, 70451, 
71144, 71142, 71111, 70419, 70450
16268, 63120, 63110, 62890, 62900, 63121, 63111, 62891, 62901, 71143, 71113, 70451, 71144, 71146, 71116, 70454, 
71147, 71145, 71114, 70422, 70453
16269, 63121, 63111, 62891, 62901, 63122, 63112, 62892, 62902, 71146, 71116, 70454, 71147, 71149, 71119, 70457, 
71150, 71148, 71117, 70425, 70456
16270, 63122, 63112, 62892, 62902, 18083, 18082, 18060, 18061, 71149, 71119, 70457, 71150, 18722, 18719, 18677, 
18721, 71151, 71120, 70428, 70459
16271, 16588, 16587, 16565, 16566, 63123, 63113, 62893, 62903, 17227, 17226, 17182, 17228, 71153, 71123, 70461, 
71154, 71152, 71121, 70429, 70460
16272, 63123, 63113, 62893, 62903, 63124, 63114, 62894, 62904, 71153, 71123, 70461, 71154, 71156, 71126, 70464, 
71157, 71155, 71124, 70432, 70463
16273, 63124, 63114, 62894, 62904, 63125, 63115, 62895, 62905, 71156, 71126, 70464, 71157, 71159, 71129, 70467, 
71160, 71158, 71127, 70435, 70466
16274, 63125, 63115, 62895, 62905, 63126, 63116, 62896, 62906, 71159, 71129, 70467, 71160, 71162, 71132, 70470, 
71163, 71161, 71130, 70438, 70469
16275, 63126, 63116, 62896, 62906, 63127, 63117, 62897, 62907, 71162, 71132, 70470, 71163, 71165, 71135, 70473, 
71166, 71164, 71133, 70441, 70472
16276, 63127, 63117, 62897, 62907, 63128, 63118, 62898, 62908, 71165, 71135, 70473, 71166, 71168, 71138, 70476, 
71169, 71167, 71136, 70444, 70475
16277, 63128, 63118, 62898, 62908, 63129, 63119, 62899, 62909, 71168, 71138, 70476, 71169, 71171, 71141, 70479, 
71172, 71170, 71139, 70447, 70478
16278, 63129, 63119, 62899, 62909, 63130, 63120, 62900, 62910, 71171, 71141, 70479, 71172, 71174, 71144, 70482, 
71175, 71173, 71142, 70450, 70481
16279, 63130, 63120, 62900, 62910, 63131, 63121, 62901, 62911, 71174, 71144, 70482, 71175, 71177, 71147, 70485, 
71178, 71176, 71145, 70453, 70484
16280, 63131, 63121, 62901, 62911, 63132, 63122, 62902, 62912, 71177, 71147, 70485, 71178, 71180, 71150, 70488, 
71181, 71179, 71148, 70456, 70487
16281, 63132, 63122, 62902, 62912, 18084, 18083, 18061, 18062, 71180, 71150, 70488, 71181, 18724, 18721, 18679, 
18723, 71182, 71151, 70459, 70490
16282, 16589, 16588, 16566, 16567, 63133, 63123, 62903, 62913, 17229, 17228, 17184, 17230, 71184, 71154, 70492, 
71185, 71183, 71152, 70460, 70491
16283, 63133, 63123, 62903, 62913, 63134, 63124, 62904, 62914, 71184, 71154, 70492, 71185, 71187, 71157, 70495, 
71188, 71186, 71155, 70463, 70494
16284, 63134, 63124, 62904, 62914, 63135, 63125, 62905, 62915, 71187, 71157, 70495, 71188, 71190, 71160, 70498, 
71191, 71189, 71158, 70466, 70497
16285, 63135, 63125, 62905, 62915, 63136, 63126, 62906, 62916, 71190, 71160, 70498, 71191, 71193, 71163, 70501, 
71194, 71192, 71161, 70469, 70500
16286, 63136, 63126, 62906, 62916, 63137, 63127, 62907, 62917, 71193, 71163, 70501, 71194, 71196, 71166, 70504, 
71197, 71195, 71164, 70472, 70503
16287, 63137, 63127, 62907, 62917, 63138, 63128, 62908, 62918, 71196, 71166, 70504, 71197, 71199, 71169, 70507, 
71200, 71198, 71167, 70475, 70506
16288, 63138, 63128, 62908, 62918, 63139, 63129, 62909, 62919, 71199, 71169, 70507, 71200, 71202, 71172, 70510, 
71203, 71201, 71170, 70478, 70509
16289, 63139, 63129, 62909, 62919, 63140, 63130, 62910, 62920, 71202, 71172, 70510, 71203, 71205, 71175, 70513, 
71206, 71204, 71173, 70481, 70512
16290, 63140, 63130, 62910, 62920, 63141, 63131, 62911, 62921, 71205, 71175, 70513, 71206, 71208, 71178, 70516, 
71209, 71207, 71176, 70484, 70515
16291, 63141, 63131, 62911, 62921, 63142, 63132, 62912, 62922, 71208, 71178, 70516, 71209, 71211, 71181, 70519, 
71212, 71210, 71179, 70487, 70518
16292, 63142, 63132, 62912, 62922, 18085, 18084, 18062, 18063, 71211, 71181, 70519, 71212, 18726, 18723, 18681, 
18725, 71213, 71182, 70490, 70521
16293, 16590, 16589, 16567, 16568, 63143, 63133, 62913, 62923, 17231, 17230, 17186, 17232, 71215, 71185, 70523, 
71216, 71214, 71183, 70491, 70522
16294, 63143, 63133, 62913, 62923, 63144, 63134, 62914, 62924, 71215, 71185, 70523, 71216, 71218, 71188, 70526, 
71219, 71217, 71186, 70494, 70525
16295, 63144, 63134, 62914, 62924, 63145, 63135, 62915, 62925, 71218, 71188, 70526, 71219, 71221, 71191, 70529, 
71222, 71220, 71189, 70497, 70528
16296, 63145, 63135, 62915, 62925, 63146, 63136, 62916, 62926, 71221, 71191, 70529, 71222, 71224, 71194, 70532, 
71225, 71223, 71192, 70500, 70531
16297, 63146, 63136, 62916, 62926, 63147, 63137, 62917, 62927, 71224, 71194, 70532, 71225, 71227, 71197, 70535, 
71228, 71226, 71195, 70503, 70534
16298, 63147, 63137, 62917, 62927, 63148, 63138, 62918, 62928, 71227, 71197, 70535, 71228, 71230, 71200, 70538, 
71231, 71229, 71198, 70506, 70537
16299, 63148, 63138, 62918, 62928, 63149, 63139, 62919, 62929, 71230, 71200, 70538, 71231, 71233, 71203, 70541, 
71234, 71232, 71201, 70509, 70540
16300, 63149, 63139, 62919, 62929, 63150, 63140, 62920, 62930, 71233, 71203, 70541, 71234, 71236, 71206, 70544, 
71237, 71235, 71204, 70512, 70543
16301, 63150, 63140, 62920, 62930, 63151, 63141, 62921, 62931, 71236, 71206, 70544, 71237, 71239, 71209, 70547, 
71240, 71238, 71207, 70515, 70546
16302, 63151, 63141, 62921, 62931, 63152, 63142, 62922, 62932, 71239, 71209, 70547, 71240, 71242, 71212, 70550, 
71243, 71241, 71210, 70518, 70549
16303, 63152, 63142, 62922, 62932, 18086, 18085, 18063, 18064, 71242, 71212, 70550, 71243, 18728, 18725, 18683, 
18727, 71244, 71213, 70521, 70552
16304, 16591, 16590, 16568, 16569, 63153, 63143, 62923, 62933, 17233, 17232, 17188, 17234, 71246, 71216, 70554, 
71247, 71245, 71214, 70522, 70553
16305, 63153, 63143, 62923, 62933, 63154, 63144, 62924, 62934, 71246, 71216, 70554, 71247, 71249, 71219, 70557, 
71250, 71248, 71217, 70525, 70556
16306, 63154, 63144, 62924, 62934, 63155, 63145, 62925, 62935, 71249, 71219, 70557, 71250, 71252, 71222, 70560, 
71253, 71251, 71220, 70528, 70559
16307, 63155, 63145, 62925, 62935, 63156, 63146, 62926, 62936, 71252, 71222, 70560, 71253, 71255, 71225, 70563, 
71256, 71254, 71223, 70531, 70562
16308, 63156, 63146, 62926, 62936, 63157, 63147, 62927, 62937, 71255, 71225, 70563, 71256, 71258, 71228, 70566, 
71259, 71257, 71226, 70534, 70565
16309, 63157, 63147, 62927, 62937, 63158, 63148, 62928, 62938, 71258, 71228, 70566, 71259, 71261, 71231, 70569, 
71262, 71260, 71229, 70537, 70568
16310, 63158, 63148, 62928, 62938, 63159, 63149, 62929, 62939, 71261, 71231, 70569, 71262, 71264, 71234, 70572, 
71265, 71263, 71232, 70540, 70571
16311, 63159, 63149, 62929, 62939, 63160, 63150, 62930, 62940, 71264, 71234, 70572, 71265, 71267, 71237, 70575, 
71268, 71266, 71235, 70543, 70574
16312, 63160, 63150, 62930, 62940, 63161, 63151, 62931, 62941, 71267, 71237, 70575, 71268, 71270, 71240, 70578, 
71271, 71269, 71238, 70546, 70577
16313, 63161, 63151, 62931, 62941, 63162, 63152, 62932, 62942, 71270, 71240, 70578, 71271, 71273, 71243, 70581, 
71274, 71272, 71241, 70549, 70580
16314, 63162, 63152, 62932, 62942, 18087, 18086, 18064, 18065, 71273, 71243, 70581, 71274, 18730, 18727, 18685, 
18729, 71275, 71244, 70552, 70583
16315, 16592, 16591, 16569, 16570, 63163, 63153, 62933, 62943, 17235, 17234, 17190, 17236, 71277, 71247, 70585, 
71278, 71276, 71245, 70553, 70584
16316, 63163, 63153, 62933, 62943, 63164, 63154, 62934, 62944, 71277, 71247, 70585, 71278, 71280, 71250, 70588, 
71281, 71279, 71248, 70556, 70587
16317, 63164, 63154, 62934, 62944, 63165, 63155, 62935, 62945, 71280, 71250, 70588, 71281, 71283, 71253, 70591, 
71284, 71282, 71251, 70559, 70590
16318, 63165, 63155, 62935, 62945, 63166, 63156, 62936, 62946, 71283, 71253, 70591, 71284, 71286, 71256, 70594, 
71287, 71285, 71254, 70562, 70593
16319, 63166, 63156, 62936, 62946, 63167, 63157, 62937, 62947, 71286, 71256, 70594, 71287, 71289, 71259, 70597, 
71290, 71288, 71257, 70565, 70596
16320, 63167, 63157, 62937, 62947, 63168, 63158, 62938, 62948, 71289, 71259, 70597, 71290, 71292, 71262, 70600, 
71293, 71291, 71260, 70568, 70599
16321, 63168, 63158, 62938, 62948, 63169, 63159, 62939, 62949, 71292, 71262, 70600, 71293, 71295, 71265, 70603, 
71296, 71294, 71263, 70571, 70602
16322, 63169, 63159, 62939, 62949, 63170, 63160, 62940, 62950, 71295, 71265, 70603, 71296, 71298, 71268, 70606, 
71299, 71297, 71266, 70574, 70605
16323, 63170, 63160, 62940, 62950, 63171, 63161, 62941, 62951, 71298, 71268, 70606, 71299, 71301, 71271, 70609, 
71302, 71300, 71269, 70577, 70608
16324, 63171, 63161, 62941, 62951, 63172, 63162, 62942, 62952, 71301, 71271, 70609, 71302, 71304, 71274, 70612, 
71305, 71303, 71272, 70580, 70611
16325, 63172, 63162, 62942, 62952, 18088, 18087, 18065, 18066, 71304, 71274, 70612, 71305, 18732, 18729, 18687, 
18731, 71306, 71275, 70583, 70614
16326, 1640, 16592, 16570, 1639, 20183, 63163, 62943, 20173, 17237, 17236, 17192, 1662, 71307, 71278, 70615, 
20470, 20469, 71276, 70584, 20448
16327, 20183, 63163, 62943, 20173, 20184, 63164, 62944, 20174, 71307, 71278, 70615, 20470, 71308, 71281, 70616, 
20472, 20471, 71279, 70587, 20450
16328, 20184, 63164, 62944, 20174, 20185, 63165, 62945, 20175, 71308, 71281, 70616, 20472, 71309, 71284, 70617, 
20474, 20473, 71282, 70590, 20452
16329, 20185, 63165, 62945, 20175, 20186, 63166, 62946, 20176, 71309, 71284, 70617, 20474, 71310, 71287, 70618, 
20476, 20475, 71285, 70593, 20454
16330, 20186, 63166, 62946, 20176, 20187, 63167, 62947, 20177, 71310, 71287, 70618, 20476, 71311, 71290, 70619, 
20478, 20477, 71288, 70596, 20456
16331, 20187, 63167, 62947, 20177, 20188, 63168, 62948, 20178, 71311, 71290, 70619, 20478, 71312, 71293, 70620, 
20480, 20479, 71291, 70599, 20458
16332, 20188, 63168, 62948, 20178, 20189, 63169, 62949, 20179, 71312, 71293, 70620, 20480, 71313, 71296, 70621, 
20482, 20481, 71294, 70602, 20460
16333, 20189, 63169, 62949, 20179, 20190, 63170, 62950, 20180, 71313, 71296, 70621, 20482, 71314, 71299, 70622, 
20484, 20483, 71297, 70605, 20462
16334, 20190, 63170, 62950, 20180, 20191, 63171, 62951, 20181, 71314, 71299, 70622, 20484, 71315, 71302, 70623, 
20486, 20485, 71300, 70608, 20464
16335, 20191, 63171, 62951, 20181, 20192, 63172, 62952, 20182, 71315, 71302, 70623, 20486, 71316, 71305, 70624, 
20488, 20487, 71303, 70611, 20466
16336, 20192, 63172, 62952, 20182, 1775, 18088, 18066, 1774, 71316, 71305, 70624, 20488, 18733, 18731, 18688, 
1797, 20489, 71306, 70614, 20468
16337, 16593, 1596, 1595, 16571, 63173, 19501, 19491, 62953, 17238, 1618, 17193, 17239, 71318, 19798, 70626, 
71319, 71317, 19799, 19778, 70625
16338, 63173, 19501, 19491, 62953, 63174, 19502, 19492, 62954, 71318, 19798, 70626, 71319, 71321, 19800, 70629, 
71322, 71320, 19801, 19780, 70628
16339, 63174, 19502, 19492, 62954, 63175, 19503, 19493, 62955, 71321, 19800, 70629, 71322, 71324, 19802, 70632, 
71325, 71323, 19803, 19782, 70631
16340, 63175, 19503, 19493, 62955, 63176, 19504, 19494, 62956, 71324, 19802, 70632, 71325, 71327, 19804, 70635, 
71328, 71326, 19805, 19784, 70634
16341, 63176, 19504, 19494, 62956, 63177, 19505, 19495, 62957, 71327, 19804, 70635, 71328, 71330, 19806, 70638, 
71331, 71329, 19807, 19786, 70637
16342, 63177, 19505, 19495, 62957, 63178, 19506, 19496, 62958, 71330, 19806, 70638, 71331, 71333, 19808, 70641, 
71334, 71332, 19809, 19788, 70640
16343, 63178, 19506, 19496, 62958, 63179, 19507, 19497, 62959, 71333, 19808, 70641, 71334, 71336, 19810, 70644, 
71337, 71335, 19811, 19790, 70643
16344, 63179, 19507, 19497, 62959, 63180, 19508, 19498, 62960, 71336, 19810, 70644, 71337, 71339, 19812, 70647, 
71340, 71338, 19813, 19792, 70646
16345, 63180, 19508, 19498, 62960, 63181, 19509, 19499, 62961, 71339, 19812, 70647, 71340, 71342, 19814, 70650, 
71343, 71341, 19815, 19794, 70649
16346, 63181, 19509, 19499, 62961, 63182, 19510, 19500, 62962, 71342, 19814, 70650, 71343, 71345, 19816, 70653, 
71346, 71344, 19817, 19796, 70652
16347, 63182, 19510, 19500, 62962, 18089, 1731, 1730, 18067, 71345, 19816, 70653, 71346, 18735, 1753, 18690, 
18734, 71347, 19818, 19797, 70655
16348, 16594, 16593, 16571, 16572, 63183, 63173, 62953, 62963, 17240, 17239, 17195, 17241, 71349, 71319, 70657, 
71350, 71348, 71317, 70625, 70656
16349, 63183, 63173, 62953, 62963, 63184, 63174, 62954, 62964, 71349, 71319, 70657, 71350, 71352, 71322, 70660, 
71353, 71351, 71320, 70628, 70659
16350, 63184, 63174, 62954, 62964, 63185, 63175, 62955, 62965, 71352, 71322, 70660, 71353, 71355, 71325, 70663, 
71356, 71354, 71323, 70631, 70662
16351, 63185, 63175, 62955, 62965, 63186, 63176, 62956, 62966, 71355, 71325, 70663, 71356, 71358, 71328, 70666, 
71359, 71357, 71326, 70634, 70665
16352, 63186, 63176, 62956, 62966, 63187, 63177, 62957, 62967, 71358, 71328, 70666, 71359, 71361, 71331, 70669, 
71362, 71360, 71329, 70637, 70668
16353, 63187, 63177, 62957, 62967, 63188, 63178, 62958, 62968, 71361, 71331, 70669, 71362, 71364, 71334, 70672, 
71365, 71363, 71332, 70640, 70671
16354, 63188, 63178, 62958, 62968, 63189, 63179, 62959, 62969, 71364, 71334, 70672, 71365, 71367, 71337, 70675, 
71368, 71366, 71335, 70643, 70674
16355, 63189, 63179, 62959, 62969, 63190, 63180, 62960, 62970, 71367, 71337, 70675, 71368, 71370, 71340, 70678, 
71371, 71369, 71338, 70646, 70677
16356, 63190, 63180, 62960, 62970, 63191, 63181, 62961, 62971, 71370, 71340, 70678, 71371, 71373, 71343, 70681, 
71374, 71372, 71341, 70649, 70680
16357, 63191, 63181, 62961, 62971, 63192, 63182, 62962, 62972, 71373, 71343, 70681, 71374, 71376, 71346, 70684, 
71377, 71375, 71344, 70652, 70683
16358, 63192, 63182, 62962, 62972, 18090, 18089, 18067, 18068, 71376, 71346, 70684, 71377, 18737, 18734, 18692, 
18736, 71378, 71347, 70655, 70686
16359, 16595, 16594, 16572, 16573, 63193, 63183, 62963, 62973, 17242, 17241, 17197, 17243, 71380, 71350, 70688, 
71381, 71379, 71348, 70656, 70687
16360, 63193, 63183, 62963, 62973, 63194, 63184, 62964, 62974, 71380, 71350, 70688, 71381, 71383, 71353, 70691, 
71384, 71382, 71351, 70659, 70690
16361, 63194, 63184, 62964, 62974, 63195, 63185, 62965, 62975, 71383, 71353, 70691, 71384, 71386, 71356, 70694, 
71387, 71385, 71354, 70662, 70693
16362, 63195, 63185, 62965, 62975, 63196, 63186, 62966, 62976, 71386, 71356, 70694, 71387, 71389, 71359, 70697, 
71390, 71388, 71357, 70665, 70696
16363, 63196, 63186, 62966, 62976, 63197, 63187, 62967, 62977, 71389, 71359, 70697, 71390, 71392, 71362, 70700, 
71393, 71391, 71360, 70668, 70699
16364, 63197, 63187, 62967, 62977, 63198, 63188, 62968, 62978, 71392, 71362, 70700, 71393, 71395, 71365, 70703, 
71396, 71394, 71363, 70671, 70702
16365, 63198, 63188, 62968, 62978, 63199, 63189, 62969, 62979, 71395, 71365, 70703, 71396, 71398, 71368, 70706, 
71399, 71397, 71366, 70674, 70705
16366, 63199, 63189, 62969, 62979, 63200, 63190, 62970, 62980, 71398, 71368, 70706, 71399, 71401, 71371, 70709, 
71402, 71400, 71369, 70677, 70708
16367, 63200, 63190, 62970, 62980, 63201, 63191, 62971, 62981, 71401, 71371, 70709, 71402, 71404, 71374, 70712, 
71405, 71403, 71372, 70680, 70711
16368, 63201, 63191, 62971, 62981, 63202, 63192, 62972, 62982, 71404, 71374, 70712, 71405, 71407, 71377, 70715, 
71408, 71406, 71375, 70683, 70714
16369, 63202, 63192, 62972, 62982, 18091, 18090, 18068, 18069, 71407, 71377, 70715, 71408, 18739, 18736, 18694, 
18738, 71409, 71378, 70686, 70717
16370, 16596, 16595, 16573, 16574, 63203, 63193, 62973, 62983, 17244, 17243, 17199, 17245, 71411, 71381, 70719, 
71412, 71410, 71379, 70687, 70718
16371, 63203, 63193, 62973, 62983, 63204, 63194, 62974, 62984, 71411, 71381, 70719, 71412, 71414, 71384, 70722, 
71415, 71413, 71382, 70690, 70721
16372, 63204, 63194, 62974, 62984, 63205, 63195, 62975, 62985, 71414, 71384, 70722, 71415, 71417, 71387, 70725, 
71418, 71416, 71385, 70693, 70724
16373, 63205, 63195, 62975, 62985, 63206, 63196, 62976, 62986, 71417, 71387, 70725, 71418, 71420, 71390, 70728, 
71421, 71419, 71388, 70696, 70727
16374, 63206, 63196, 62976, 62986, 63207, 63197, 62977, 62987, 71420, 71390, 70728, 71421, 71423, 71393, 70731, 
71424, 71422, 71391, 70699, 70730
16375, 63207, 63197, 62977, 62987, 63208, 63198, 62978, 62988, 71423, 71393, 70731, 71424, 71426, 71396, 70734, 
71427, 71425, 71394, 70702, 70733
16376, 63208, 63198, 62978, 62988, 63209, 63199, 62979, 62989, 71426, 71396, 70734, 71427, 71429, 71399, 70737, 
71430, 71428, 71397, 70705, 70736
16377, 63209, 63199, 62979, 62989, 63210, 63200, 62980, 62990, 71429, 71399, 70737, 71430, 71432, 71402, 70740, 
71433, 71431, 71400, 70708, 70739
16378, 63210, 63200, 62980, 62990, 63211, 63201, 62981, 62991, 71432, 71402, 70740, 71433, 71435, 71405, 70743, 
71436, 71434, 71403, 70711, 70742
16379, 63211, 63201, 62981, 62991, 63212, 63202, 62982, 62992, 71435, 71405, 70743, 71436, 71438, 71408, 70746, 
71439, 71437, 71406, 70714, 70745
16380, 63212, 63202, 62982, 62992, 18092, 18091, 18069, 18070, 71438, 71408, 70746, 71439, 18741, 18738, 18696, 
18740, 71440, 71409, 70717, 70748
16381, 16597, 16596, 16574, 16575, 63213, 63203, 62983, 62993, 17246, 17245, 17201, 17247, 71442, 71412, 70750, 
71443, 71441, 71410, 70718, 70749
16382, 63213, 63203, 62983, 62993, 63214, 63204, 62984, 62994, 71442, 71412, 70750, 71443, 71445, 71415, 70753, 
71446, 71444, 71413, 70721, 70752
16383, 63214, 63204, 62984, 62994, 63215, 63205, 62985, 62995, 71445, 71415, 70753, 71446, 71448, 71418, 70756, 
71449, 71447, 71416, 70724, 70755
16384, 63215, 63205, 62985, 62995, 63216, 63206, 62986, 62996, 71448, 71418, 70756, 71449, 71451, 71421, 70759, 
71452, 71450, 71419, 70727, 70758
16385, 63216, 63206, 62986, 62996, 63217, 63207, 62987, 62997, 71451, 71421, 70759, 71452, 71454, 71424, 70762, 
71455, 71453, 71422, 70730, 70761
16386, 63217, 63207, 62987, 62997, 63218, 63208, 62988, 62998, 71454, 71424, 70762, 71455, 71457, 71427, 70765, 
71458, 71456, 71425, 70733, 70764
16387, 63218, 63208, 62988, 62998, 63219, 63209, 62989, 62999, 71457, 71427, 70765, 71458, 71460, 71430, 70768, 
71461, 71459, 71428, 70736, 70767
16388, 63219, 63209, 62989, 62999, 63220, 63210, 62990, 63000, 71460, 71430, 70768, 71461, 71463, 71433, 70771, 
71464, 71462, 71431, 70739, 70770
16389, 63220, 63210, 62990, 63000, 63221, 63211, 62991, 63001, 71463, 71433, 70771, 71464, 71466, 71436, 70774, 
71467, 71465, 71434, 70742, 70773
16390, 63221, 63211, 62991, 63001, 63222, 63212, 62992, 63002, 71466, 71436, 70774, 71467, 71469, 71439, 70777, 
71470, 71468, 71437, 70745, 70776
16391, 63222, 63212, 62992, 63002, 18093, 18092, 18070, 18071, 71469, 71439, 70777, 71470, 18743, 18740, 18698, 
18742, 71471, 71440, 70748, 70779
16392, 16598, 16597, 16575, 16576, 63223, 63213, 62993, 63003, 17248, 17247, 17203, 17249, 71473, 71443, 70781, 
71474, 71472, 71441, 70749, 70780
16393, 63223, 63213, 62993, 63003, 63224, 63214, 62994, 63004, 71473, 71443, 70781, 71474, 71476, 71446, 70784, 
71477, 71475, 71444, 70752, 70783
16394, 63224, 63214, 62994, 63004, 63225, 63215, 62995, 63005, 71476, 71446, 70784, 71477, 71479, 71449, 70787, 
71480, 71478, 71447, 70755, 70786
16395, 63225, 63215, 62995, 63005, 63226, 63216, 62996, 63006, 71479, 71449, 70787, 71480, 71482, 71452, 70790, 
71483, 71481, 71450, 70758, 70789
16396, 63226, 63216, 62996, 63006, 63227, 63217, 62997, 63007, 71482, 71452, 70790, 71483, 71485, 71455, 70793, 
71486, 71484, 71453, 70761, 70792
16397, 63227, 63217, 62997, 63007, 63228, 63218, 62998, 63008, 71485, 71455, 70793, 71486, 71488, 71458, 70796, 
71489, 71487, 71456, 70764, 70795
16398, 63228, 63218, 62998, 63008, 63229, 63219, 62999, 63009, 71488, 71458, 70796, 71489, 71491, 71461, 70799, 
71492, 71490, 71459, 70767, 70798
16399, 63229, 63219, 62999, 63009, 63230, 63220, 63000, 63010, 71491, 71461, 70799, 71492, 71494, 71464, 70802, 
71495, 71493, 71462, 70770, 70801
16400, 63230, 63220, 63000, 63010, 63231, 63221, 63001, 63011, 71494, 71464, 70802, 71495, 71497, 71467, 70805, 
71498, 71496, 71465, 70773, 70804
16401, 63231, 63221, 63001, 63011, 63232, 63222, 63002, 63012, 71497, 71467, 70805, 71498, 71500, 71470, 70808, 
71501, 71499, 71468, 70776, 70807
16402, 63232, 63222, 63002, 63012, 18094, 18093, 18071, 18072, 71500, 71470, 70808, 71501, 18745, 18742, 18700, 
18744, 71502, 71471, 70779, 70810
16403, 16599, 16598, 16576, 16577, 63233, 63223, 63003, 63013, 17250, 17249, 17205, 17251, 71504, 71474, 70812, 
71505, 71503, 71472, 70780, 70811
16404, 63233, 63223, 63003, 63013, 63234, 63224, 63004, 63014, 71504, 71474, 70812, 71505, 71507, 71477, 70815, 
71508, 71506, 71475, 70783, 70814
16405, 63234, 63224, 63004, 63014, 63235, 63225, 63005, 63015, 71507, 71477, 70815, 71508, 71510, 71480, 70818, 
71511, 71509, 71478, 70786, 70817
16406, 63235, 63225, 63005, 63015, 63236, 63226, 63006, 63016, 71510, 71480, 70818, 71511, 71513, 71483, 70821, 
71514, 71512, 71481, 70789, 70820
16407, 63236, 63226, 63006, 63016, 63237, 63227, 63007, 63017, 71513, 71483, 70821, 71514, 71516, 71486, 70824, 
71517, 71515, 71484, 70792, 70823
16408, 63237, 63227, 63007, 63017, 63238, 63228, 63008, 63018, 71516, 71486, 70824, 71517, 71519, 71489, 70827, 
71520, 71518, 71487, 70795, 70826
16409, 63238, 63228, 63008, 63018, 63239, 63229, 63009, 63019, 71519, 71489, 70827, 71520, 71522, 71492, 70830, 
71523, 71521, 71490, 70798, 70829
16410, 63239, 63229, 63009, 63019, 63240, 63230, 63010, 63020, 71522, 71492, 70830, 71523, 71525, 71495, 70833, 
71526, 71524, 71493, 70801, 70832
16411, 63240, 63230, 63010, 63020, 63241, 63231, 63011, 63021, 71525, 71495, 70833, 71526, 71528, 71498, 70836, 
71529, 71527, 71496, 70804, 70835
16412, 63241, 63231, 63011, 63021, 63242, 63232, 63012, 63022, 71528, 71498, 70836, 71529, 71531, 71501, 70839, 
71532, 71530, 71499, 70807, 70838
16413, 63242, 63232, 63012, 63022, 18095, 18094, 18072, 18073, 71531, 71501, 70839, 71532, 18747, 18744, 18702, 
18746, 71533, 71502, 70810, 70841
16414, 16600, 16599, 16577, 16578, 63243, 63233, 63013, 63023, 17252, 17251, 17207, 17253, 71535, 71505, 70843, 
71536, 71534, 71503, 70811, 70842
16415, 63243, 63233, 63013, 63023, 63244, 63234, 63014, 63024, 71535, 71505, 70843, 71536, 71538, 71508, 70846, 
71539, 71537, 71506, 70814, 70845
16416, 63244, 63234, 63014, 63024, 63245, 63235, 63015, 63025, 71538, 71508, 70846, 71539, 71541, 71511, 70849, 
71542, 71540, 71509, 70817, 70848
16417, 63245, 63235, 63015, 63025, 63246, 63236, 63016, 63026, 71541, 71511, 70849, 71542, 71544, 71514, 70852, 
71545, 71543, 71512, 70820, 70851
16418, 63246, 63236, 63016, 63026, 63247, 63237, 63017, 63027, 71544, 71514, 70852, 71545, 71547, 71517, 70855, 
71548, 71546, 71515, 70823, 70854
16419, 63247, 63237, 63017, 63027, 63248, 63238, 63018, 63028, 71547, 71517, 70855, 71548, 71550, 71520, 70858, 
71551, 71549, 71518, 70826, 70857
16420, 63248, 63238, 63018, 63028, 63249, 63239, 63019, 63029, 71550, 71520, 70858, 71551, 71553, 71523, 70861, 
71554, 71552, 71521, 70829, 70860
16421, 63249, 63239, 63019, 63029, 63250, 63240, 63020, 63030, 71553, 71523, 70861, 71554, 71556, 71526, 70864, 
71557, 71555, 71524, 70832, 70863
16422, 63250, 63240, 63020, 63030, 63251, 63241, 63021, 63031, 71556, 71526, 70864, 71557, 71559, 71529, 70867, 
71560, 71558, 71527, 70835, 70866
16423, 63251, 63241, 63021, 63031, 63252, 63242, 63022, 63032, 71559, 71529, 70867, 71560, 71562, 71532, 70870, 
71563, 71561, 71530, 70838, 70869
16424, 63252, 63242, 63022, 63032, 18096, 18095, 18073, 18074, 71562, 71532, 70870, 71563, 18749, 18746, 18704, 
18748, 71564, 71533, 70841, 70872
16425, 16601, 16600, 16578, 16579, 63253, 63243, 63023, 63033, 17254, 17253, 17209, 17255, 71566, 71536, 70874, 
71567, 71565, 71534, 70842, 70873
16426, 63253, 63243, 63023, 63033, 63254, 63244, 63024, 63034, 71566, 71536, 70874, 71567, 71569, 71539, 70877, 
71570, 71568, 71537, 70845, 70876
16427, 63254, 63244, 63024, 63034, 63255, 63245, 63025, 63035, 71569, 71539, 70877, 71570, 71572, 71542, 70880, 
71573, 71571, 71540, 70848, 70879
16428, 63255, 63245, 63025, 63035, 63256, 63246, 63026, 63036, 71572, 71542, 70880, 71573, 71575, 71545, 70883, 
71576, 71574, 71543, 70851, 70882
16429, 63256, 63246, 63026, 63036, 63257, 63247, 63027, 63037, 71575, 71545, 70883, 71576, 71578, 71548, 70886, 
71579, 71577, 71546, 70854, 70885
16430, 63257, 63247, 63027, 63037, 63258, 63248, 63028, 63038, 71578, 71548, 70886, 71579, 71581, 71551, 70889, 
71582, 71580, 71549, 70857, 70888
16431, 63258, 63248, 63028, 63038, 63259, 63249, 63029, 63039, 71581, 71551, 70889, 71582, 71584, 71554, 70892, 
71585, 71583, 71552, 70860, 70891
16432, 63259, 63249, 63029, 63039, 63260, 63250, 63030, 63040, 71584, 71554, 70892, 71585, 71587, 71557, 70895, 
71588, 71586, 71555, 70863, 70894
16433, 63260, 63250, 63030, 63040, 63261, 63251, 63031, 63041, 71587, 71557, 70895, 71588, 71590, 71560, 70898, 
71591, 71589, 71558, 70866, 70897
16434, 63261, 63251, 63031, 63041, 63262, 63252, 63032, 63042, 71590, 71560, 70898, 71591, 71593, 71563, 70901, 
71594, 71592, 71561, 70869, 70900
16435, 63262, 63252, 63032, 63042, 18097, 18096, 18074, 18075, 71593, 71563, 70901, 71594, 18751, 18748, 18706, 
18750, 71595, 71564, 70872, 70903
16436, 16602, 16601, 16579, 16580, 63263, 63253, 63033, 63043, 17256, 17255, 17211, 17257, 71597, 71567, 70905, 
71598, 71596, 71565, 70873, 70904
16437, 63263, 63253, 63033, 63043, 63264, 63254, 63034, 63044, 71597, 71567, 70905, 71598, 71600, 71570, 70908, 
71601, 71599, 71568, 70876, 70907
16438, 63264, 63254, 63034, 63044, 63265, 63255, 63035, 63045, 71600, 71570, 70908, 71601, 71603, 71573, 70911, 
71604, 71602, 71571, 70879, 70910
16439, 63265, 63255, 63035, 63045, 63266, 63256, 63036, 63046, 71603, 71573, 70911, 71604, 71606, 71576, 70914, 
71607, 71605, 71574, 70882, 70913
16440, 63266, 63256, 63036, 63046, 63267, 63257, 63037, 63047, 71606, 71576, 70914, 71607, 71609, 71579, 70917, 
71610, 71608, 71577, 70885, 70916
16441, 63267, 63257, 63037, 63047, 63268, 63258, 63038, 63048, 71609, 71579, 70917, 71610, 71612, 71582, 70920, 
71613, 71611, 71580, 70888, 70919
16442, 63268, 63258, 63038, 63048, 63269, 63259, 63039, 63049, 71612, 71582, 70920, 71613, 71615, 71585, 70923, 
71616, 71614, 71583, 70891, 70922
16443, 63269, 63259, 63039, 63049, 63270, 63260, 63040, 63050, 71615, 71585, 70923, 71616, 71618, 71588, 70926, 
71619, 71617, 71586, 70894, 70925
16444, 63270, 63260, 63040, 63050, 63271, 63261, 63041, 63051, 71618, 71588, 70926, 71619, 71621, 71591, 70929, 
71622, 71620, 71589, 70897, 70928
16445, 63271, 63261, 63041, 63051, 63272, 63262, 63042, 63052, 71621, 71591, 70929, 71622, 71624, 71594, 70932, 
71625, 71623, 71592, 70900, 70931
16446, 63272, 63262, 63042, 63052, 18098, 18097, 18075, 18076, 71624, 71594, 70932, 71625, 18753, 18750, 18708, 
18752, 71626, 71595, 70903, 70934
16447, 16603, 16602, 16580, 16581, 63273, 63263, 63043, 63053, 17258, 17257, 17213, 17259, 71628, 71598, 70936, 
71629, 71627, 71596, 70904, 70935
16448, 63273, 63263, 63043, 63053, 63274, 63264, 63044, 63054, 71628, 71598, 70936, 71629, 71631, 71601, 70939, 
71632, 71630, 71599, 70907, 70938
16449, 63274, 63264, 63044, 63054, 63275, 63265, 63045, 63055, 71631, 71601, 70939, 71632, 71634, 71604, 70942, 
71635, 71633, 71602, 70910, 70941
16450, 63275, 63265, 63045, 63055, 63276, 63266, 63046, 63056, 71634, 71604, 70942, 71635, 71637, 71607, 70945, 
71638, 71636, 71605, 70913, 70944
16451, 63276, 63266, 63046, 63056, 63277, 63267, 63047, 63057, 71637, 71607, 70945, 71638, 71640, 71610, 70948, 
71641, 71639, 71608, 70916, 70947
16452, 63277, 63267, 63047, 63057, 63278, 63268, 63048, 63058, 71640, 71610, 70948, 71641, 71643, 71613, 70951, 
71644, 71642, 71611, 70919, 70950
16453, 63278, 63268, 63048, 63058, 63279, 63269, 63049, 63059, 71643, 71613, 70951, 71644, 71646, 71616, 70954, 
71647, 71645, 71614, 70922, 70953
16454, 63279, 63269, 63049, 63059, 63280, 63270, 63050, 63060, 71646, 71616, 70954, 71647, 71649, 71619, 70957, 
71650, 71648, 71617, 70925, 70956
16455, 63280, 63270, 63050, 63060, 63281, 63271, 63051, 63061, 71649, 71619, 70957, 71650, 71652, 71622, 70960, 
71653, 71651, 71620, 70928, 70959
16456, 63281, 63271, 63051, 63061, 63282, 63272, 63052, 63062, 71652, 71622, 70960, 71653, 71655, 71625, 70963, 
71656, 71654, 71623, 70931, 70962
16457, 63282, 63272, 63052, 63062, 18099, 18098, 18076, 18077, 71655, 71625, 70963, 71656, 18755, 18752, 18710, 
18754, 71657, 71626, 70934, 70965
16458, 16604, 16603, 16581, 16582, 63283, 63273, 63053, 63063, 17260, 17259, 17215, 17261, 71659, 71629, 70967, 
71660, 71658, 71627, 70935, 70966
16459, 63283, 63273, 63053, 63063, 63284, 63274, 63054, 63064, 71659, 71629, 70967, 71660, 71662, 71632, 70970, 
71663, 71661, 71630, 70938, 70969
16460, 63284, 63274, 63054, 63064, 63285, 63275, 63055, 63065, 71662, 71632, 70970, 71663, 71665, 71635, 70973, 
71666, 71664, 71633, 70941, 70972
16461, 63285, 63275, 63055, 63065, 63286, 63276, 63056, 63066, 71665, 71635, 70973, 71666, 71668, 71638, 70976, 
71669, 71667, 71636, 70944, 70975
16462, 63286, 63276, 63056, 63066, 63287, 63277, 63057, 63067, 71668, 71638, 70976, 71669, 71671, 71641, 70979, 
71672, 71670, 71639, 70947, 70978
16463, 63287, 63277, 63057, 63067, 63288, 63278, 63058, 63068, 71671, 71641, 70979, 71672, 71674, 71644, 70982, 
71675, 71673, 71642, 70950, 70981
16464, 63288, 63278, 63058, 63068, 63289, 63279, 63059, 63069, 71674, 71644, 70982, 71675, 71677, 71647, 70985, 
71678, 71676, 71645, 70953, 70984
16465, 63289, 63279, 63059, 63069, 63290, 63280, 63060, 63070, 71677, 71647, 70985, 71678, 71680, 71650, 70988, 
71681, 71679, 71648, 70956, 70987
16466, 63290, 63280, 63060, 63070, 63291, 63281, 63061, 63071, 71680, 71650, 70988, 71681, 71683, 71653, 70991, 
71684, 71682, 71651, 70959, 70990
16467, 63291, 63281, 63061, 63071, 63292, 63282, 63062, 63072, 71683, 71653, 70991, 71684, 71686, 71656, 70994, 
71687, 71685, 71654, 70962, 70993
16468, 63292, 63282, 63062, 63072, 18100, 18099, 18077, 18078, 71686, 71656, 70994, 71687, 18757, 18754, 18712, 
18756, 71688, 71657, 70965, 70996
16469, 16605, 16604, 16582, 16583, 63293, 63283, 63063, 63073, 17262, 17261, 17217, 17263, 71690, 71660, 70998, 
71691, 71689, 71658, 70966, 70997
16470, 63293, 63283, 63063, 63073, 63294, 63284, 63064, 63074, 71690, 71660, 70998, 71691, 71693, 71663, 71001, 
71694, 71692, 71661, 70969, 71000
16471, 63294, 63284, 63064, 63074, 63295, 63285, 63065, 63075, 71693, 71663, 71001, 71694, 71696, 71666, 71004, 
71697, 71695, 71664, 70972, 71003
16472, 63295, 63285, 63065, 63075, 63296, 63286, 63066, 63076, 71696, 71666, 71004, 71697, 71699, 71669, 71007, 
71700, 71698, 71667, 70975, 71006
16473, 63296, 63286, 63066, 63076, 63297, 63287, 63067, 63077, 71699, 71669, 71007, 71700, 71702, 71672, 71010, 
71703, 71701, 71670, 70978, 71009
16474, 63297, 63287, 63067, 63077, 63298, 63288, 63068, 63078, 71702, 71672, 71010, 71703, 71705, 71675, 71013, 
71706, 71704, 71673, 70981, 71012
16475, 63298, 63288, 63068, 63078, 63299, 63289, 63069, 63079, 71705, 71675, 71013, 71706, 71708, 71678, 71016, 
71709, 71707, 71676, 70984, 71015
16476, 63299, 63289, 63069, 63079, 63300, 63290, 63070, 63080, 71708, 71678, 71016, 71709, 71711, 71681, 71019, 
71712, 71710, 71679, 70987, 71018
16477, 63300, 63290, 63070, 63080, 63301, 63291, 63071, 63081, 71711, 71681, 71019, 71712, 71714, 71684, 71022, 
71715, 71713, 71682, 70990, 71021
16478, 63301, 63291, 63071, 63081, 63302, 63292, 63072, 63082, 71714, 71684, 71022, 71715, 71717, 71687, 71025, 
71718, 71716, 71685, 70993, 71024
16479, 63302, 63292, 63072, 63082, 18101, 18100, 18078, 18079, 71717, 71687, 71025, 71718, 18759, 18756, 18714, 
18758, 71719, 71688, 70996, 71027
16480, 16606, 16605, 16583, 16584, 63303, 63293, 63073, 63083, 17264, 17263, 17219, 17265, 71721, 71691, 71029, 
71722, 71720, 71689, 70997, 71028
16481, 63303, 63293, 63073, 63083, 63304, 63294, 63074, 63084, 71721, 71691, 71029, 71722, 71724, 71694, 71032, 
71725, 71723, 71692, 71000, 71031
16482, 63304, 63294, 63074, 63084, 63305, 63295, 63075, 63085, 71724, 71694, 71032, 71725, 71727, 71697, 71035, 
71728, 71726, 71695, 71003, 71034
16483, 63305, 63295, 63075, 63085, 63306, 63296, 63076, 63086, 71727, 71697, 71035, 71728, 71730, 71700, 71038, 
71731, 71729, 71698, 71006, 71037
16484, 63306, 63296, 63076, 63086, 63307, 63297, 63077, 63087, 71730, 71700, 71038, 71731, 71733, 71703, 71041, 
71734, 71732, 71701, 71009, 71040
16485, 63307, 63297, 63077, 63087, 63308, 63298, 63078, 63088, 71733, 71703, 71041, 71734, 71736, 71706, 71044, 
71737, 71735, 71704, 71012, 71043
16486, 63308, 63298, 63078, 63088, 63309, 63299, 63079, 63089, 71736, 71706, 71044, 71737, 71739, 71709, 71047, 
71740, 71738, 71707, 71015, 71046
16487, 63309, 63299, 63079, 63089, 63310, 63300, 63080, 63090, 71739, 71709, 71047, 71740, 71742, 71712, 71050, 
71743, 71741, 71710, 71018, 71049
16488, 63310, 63300, 63080, 63090, 63311, 63301, 63081, 63091, 71742, 71712, 71050, 71743, 71745, 71715, 71053, 
71746, 71744, 71713, 71021, 71052
16489, 63311, 63301, 63081, 63091, 63312, 63302, 63082, 63092, 71745, 71715, 71053, 71746, 71748, 71718, 71056, 
71749, 71747, 71716, 71024, 71055
16490, 63312, 63302, 63082, 63092, 18102, 18101, 18079, 18080, 71748, 71718, 71056, 71749, 18761, 18758, 18716, 
18760, 71750, 71719, 71027, 71058
16491, 16607, 16606, 16584, 16585, 63313, 63303, 63083, 63093, 17266, 17265, 17221, 17267, 71752, 71722, 71060, 
71753, 71751, 71720, 71028, 71059
16492, 63313, 63303, 63083, 63093, 63314, 63304, 63084, 63094, 71752, 71722, 71060, 71753, 71755, 71725, 71063, 
71756, 71754, 71723, 71031, 71062
16493, 63314, 63304, 63084, 63094, 63315, 63305, 63085, 63095, 71755, 71725, 71063, 71756, 71758, 71728, 71066, 
71759, 71757, 71726, 71034, 71065
16494, 63315, 63305, 63085, 63095, 63316, 63306, 63086, 63096, 71758, 71728, 71066, 71759, 71761, 71731, 71069, 
71762, 71760, 71729, 71037, 71068
16495, 63316, 63306, 63086, 63096, 63317, 63307, 63087, 63097, 71761, 71731, 71069, 71762, 71764, 71734, 71072, 
71765, 71763, 71732, 71040, 71071
16496, 63317, 63307, 63087, 63097, 63318, 63308, 63088, 63098, 71764, 71734, 71072, 71765, 71767, 71737, 71075, 
71768, 71766, 71735, 71043, 71074
16497, 63318, 63308, 63088, 63098, 63319, 63309, 63089, 63099, 71767, 71737, 71075, 71768, 71770, 71740, 71078, 
71771, 71769, 71738, 71046, 71077
16498, 63319, 63309, 63089, 63099, 63320, 63310, 63090, 63100, 71770, 71740, 71078, 71771, 71773, 71743, 71081, 
71774, 71772, 71741, 71049, 71080
16499, 63320, 63310, 63090, 63100, 63321, 63311, 63091, 63101, 71773, 71743, 71081, 71774, 71776, 71746, 71084, 
71777, 71775, 71744, 71052, 71083
16500, 63321, 63311, 63091, 63101, 63322, 63312, 63092, 63102, 71776, 71746, 71084, 71777, 71779, 71749, 71087, 
71780, 71778, 71747, 71055, 71086
16501, 63322, 63312, 63092, 63102, 18103, 18102, 18080, 18081, 71779, 71749, 71087, 71780, 18763, 18760, 18718, 
18762, 71781, 71750, 71058, 71089
16502, 16608, 16607, 16585, 16586, 63323, 63313, 63093, 63103, 17268, 17267, 17223, 17269, 71783, 71753, 71091, 
71784, 71782, 71751, 71059, 71090
16503, 63323, 63313, 63093, 63103, 63324, 63314, 63094, 63104, 71783, 71753, 71091, 71784, 71786, 71756, 71094, 
71787, 71785, 71754, 71062, 71093
16504, 63324, 63314, 63094, 63104, 63325, 63315, 63095, 63105, 71786, 71756, 71094, 71787, 71789, 71759, 71097, 
71790, 71788, 71757, 71065, 71096
16505, 63325, 63315, 63095, 63105, 63326, 63316, 63096, 63106, 71789, 71759, 71097, 71790, 71792, 71762, 71100, 
71793, 71791, 71760, 71068, 71099
16506, 63326, 63316, 63096, 63106, 63327, 63317, 63097, 63107, 71792, 71762, 71100, 71793, 71795, 71765, 71103, 
71796, 71794, 71763, 71071, 71102
16507, 63327, 63317, 63097, 63107, 63328, 63318, 63098, 63108, 71795, 71765, 71103, 71796, 71798, 71768, 71106, 
71799, 71797, 71766, 71074, 71105
16508, 63328, 63318, 63098, 63108, 63329, 63319, 63099, 63109, 71798, 71768, 71106, 71799, 71801, 71771, 71109, 
71802, 71800, 71769, 71077, 71108
16509, 63329, 63319, 63099, 63109, 63330, 63320, 63100, 63110, 71801, 71771, 71109, 71802, 71804, 71774, 71112, 
71805, 71803, 71772, 71080, 71111
16510, 63330, 63320, 63100, 63110, 63331, 63321, 63101, 63111, 71804, 71774, 71112, 71805, 71807, 71777, 71115, 
71808, 71806, 71775, 71083, 71114
16511, 63331, 63321, 63101, 63111, 63332, 63322, 63102, 63112, 71807, 71777, 71115, 71808, 71810, 71780, 71118, 
71811, 71809, 71778, 71086, 71117
16512, 63332, 63322, 63102, 63112, 18104, 18103, 18081, 18082, 71810, 71780, 71118, 71811, 18765, 18762, 18720, 
18764, 71812, 71781, 71089, 71120
16513, 16609, 16608, 16586, 16587, 63333, 63323, 63103, 63113, 17270, 17269, 17225, 17271, 71814, 71784, 71122, 
71815, 71813, 71782, 71090, 71121
16514, 63333, 63323, 63103, 63113, 63334, 63324, 63104, 63114, 71814, 71784, 71122, 71815, 71817, 71787, 71125, 
71818, 71816, 71785, 71093, 71124
16515, 63334, 63324, 63104, 63114, 63335, 63325, 63105, 63115, 71817, 71787, 71125, 71818, 71820, 71790, 71128, 
71821, 71819, 71788, 71096, 71127
16516, 63335, 63325, 63105, 63115, 63336, 63326, 63106, 63116, 71820, 71790, 71128, 71821, 71823, 71793, 71131, 
71824, 71822, 71791, 71099, 71130
16517, 63336, 63326, 63106, 63116, 63337, 63327, 63107, 63117, 71823, 71793, 71131, 71824, 71826, 71796, 71134, 
71827, 71825, 71794, 71102, 71133
16518, 63337, 63327, 63107, 63117, 63338, 63328, 63108, 63118, 71826, 71796, 71134, 71827, 71829, 71799, 71137, 
71830, 71828, 71797, 71105, 71136
16519, 63338, 63328, 63108, 63118, 63339, 63329, 63109, 63119, 71829, 71799, 71137, 71830, 71832, 71802, 71140, 
71833, 71831, 71800, 71108, 71139
16520, 63339, 63329, 63109, 63119, 63340, 63330, 63110, 63120, 71832, 71802, 71140, 71833, 71835, 71805, 71143, 
71836, 71834, 71803, 71111, 71142
16521, 63340, 63330, 63110, 63120, 63341, 63331, 63111, 63121, 71835, 71805, 71143, 71836, 71838, 71808, 71146, 
71839, 71837, 71806, 71114, 71145
16522, 63341, 63331, 63111, 63121, 63342, 63332, 63112, 63122, 71838, 71808, 71146, 71839, 71841, 71811, 71149, 
71842, 71840, 71809, 71117, 71148
16523, 63342, 63332, 63112, 63122, 18105, 18104, 18082, 18083, 71841, 71811, 71149, 71842, 18767, 18764, 18722, 
18766, 71843, 71812, 71120, 71151
16524, 16610, 16609, 16587, 16588, 63343, 63333, 63113, 63123, 17272, 17271, 17227, 17273, 71845, 71815, 71153, 
71846, 71844, 71813, 71121, 71152
16525, 63343, 63333, 63113, 63123, 63344, 63334, 63114, 63124, 71845, 71815, 71153, 71846, 71848, 71818, 71156, 
71849, 71847, 71816, 71124, 71155
16526, 63344, 63334, 63114, 63124, 63345, 63335, 63115, 63125, 71848, 71818, 71156, 71849, 71851, 71821, 71159, 
71852, 71850, 71819, 71127, 71158
16527, 63345, 63335, 63115, 63125, 63346, 63336, 63116, 63126, 71851, 71821, 71159, 71852, 71854, 71824, 71162, 
71855, 71853, 71822, 71130, 71161
16528, 63346, 63336, 63116, 63126, 63347, 63337, 63117, 63127, 71854, 71824, 71162, 71855, 71857, 71827, 71165, 
71858, 71856, 71825, 71133, 71164
16529, 63347, 63337, 63117, 63127, 63348, 63338, 63118, 63128, 71857, 71827, 71165, 71858, 71860, 71830, 71168, 
71861, 71859, 71828, 71136, 71167
16530, 63348, 63338, 63118, 63128, 63349, 63339, 63119, 63129, 71860, 71830, 71168, 71861, 71863, 71833, 71171, 
71864, 71862, 71831, 71139, 71170
16531, 63349, 63339, 63119, 63129, 63350, 63340, 63120, 63130, 71863, 71833, 71171, 71864, 71866, 71836, 71174, 
71867, 71865, 71834, 71142, 71173
16532, 63350, 63340, 63120, 63130, 63351, 63341, 63121, 63131, 71866, 71836, 71174, 71867, 71869, 71839, 71177, 
71870, 71868, 71837, 71145, 71176
16533, 63351, 63341, 63121, 63131, 63352, 63342, 63122, 63132, 71869, 71839, 71177, 71870, 71872, 71842, 71180, 
71873, 71871, 71840, 71148, 71179
16534, 63352, 63342, 63122, 63132, 18106, 18105, 18083, 18084, 71872, 71842, 71180, 71873, 18769, 18766, 18724, 
18768, 71874, 71843, 71151, 71182
16535, 16611, 16610, 16588, 16589, 63353, 63343, 63123, 63133, 17274, 17273, 17229, 17275, 71876, 71846, 71184, 
71877, 71875, 71844, 71152, 71183
16536, 63353, 63343, 63123, 63133, 63354, 63344, 63124, 63134, 71876, 71846, 71184, 71877, 71879, 71849, 71187, 
71880, 71878, 71847, 71155, 71186
16537, 63354, 63344, 63124, 63134, 63355, 63345, 63125, 63135, 71879, 71849, 71187, 71880, 71882, 71852, 71190, 
71883, 71881, 71850, 71158, 71189
16538, 63355, 63345, 63125, 63135, 63356, 63346, 63126, 63136, 71882, 71852, 71190, 71883, 71885, 71855, 71193, 
71886, 71884, 71853, 71161, 71192
16539, 63356, 63346, 63126, 63136, 63357, 63347, 63127, 63137, 71885, 71855, 71193, 71886, 71888, 71858, 71196, 
71889, 71887, 71856, 71164, 71195
16540, 63357, 63347, 63127, 63137, 63358, 63348, 63128, 63138, 71888, 71858, 71196, 71889, 71891, 71861, 71199, 
71892, 71890, 71859, 71167, 71198
16541, 63358, 63348, 63128, 63138, 63359, 63349, 63129, 63139, 71891, 71861, 71199, 71892, 71894, 71864, 71202, 
71895, 71893, 71862, 71170, 71201
16542, 63359, 63349, 63129, 63139, 63360, 63350, 63130, 63140, 71894, 71864, 71202, 71895, 71897, 71867, 71205, 
71898, 71896, 71865, 71173, 71204
16543, 63360, 63350, 63130, 63140, 63361, 63351, 63131, 63141, 71897, 71867, 71205, 71898, 71900, 71870, 71208, 
71901, 71899, 71868, 71176, 71207
16544, 63361, 63351, 63131, 63141, 63362, 63352, 63132, 63142, 71900, 71870, 71208, 71901, 71903, 71873, 71211, 
71904, 71902, 71871, 71179, 71210
16545, 63362, 63352, 63132, 63142, 18107, 18106, 18084, 18085, 71903, 71873, 71211, 71904, 18771, 18768, 18726, 
18770, 71905, 71874, 71182, 71213
16546, 16612, 16611, 16589, 16590, 63363, 63353, 63133, 63143, 17276, 17275, 17231, 17277, 71907, 71877, 71215, 
71908, 71906, 71875, 71183, 71214
16547, 63363, 63353, 63133, 63143, 63364, 63354, 63134, 63144, 71907, 71877, 71215, 71908, 71910, 71880, 71218, 
71911, 71909, 71878, 71186, 71217
16548, 63364, 63354, 63134, 63144, 63365, 63355, 63135, 63145, 71910, 71880, 71218, 71911, 71913, 71883, 71221, 
71914, 71912, 71881, 71189, 71220
16549, 63365, 63355, 63135, 63145, 63366, 63356, 63136, 63146, 71913, 71883, 71221, 71914, 71916, 71886, 71224, 
71917, 71915, 71884, 71192, 71223
16550, 63366, 63356, 63136, 63146, 63367, 63357, 63137, 63147, 71916, 71886, 71224, 71917, 71919, 71889, 71227, 
71920, 71918, 71887, 71195, 71226
16551, 63367, 63357, 63137, 63147, 63368, 63358, 63138, 63148, 71919, 71889, 71227, 71920, 71922, 71892, 71230, 
71923, 71921, 71890, 71198, 71229
16552, 63368, 63358, 63138, 63148, 63369, 63359, 63139, 63149, 71922, 71892, 71230, 71923, 71925, 71895, 71233, 
71926, 71924, 71893, 71201, 71232
16553, 63369, 63359, 63139, 63149, 63370, 63360, 63140, 63150, 71925, 71895, 71233, 71926, 71928, 71898, 71236, 
71929, 71927, 71896, 71204, 71235
16554, 63370, 63360, 63140, 63150, 63371, 63361, 63141, 63151, 71928, 71898, 71236, 71929, 71931, 71901, 71239, 
71932, 71930, 71899, 71207, 71238
16555, 63371, 63361, 63141, 63151, 63372, 63362, 63142, 63152, 71931, 71901, 71239, 71932, 71934, 71904, 71242, 
71935, 71933, 71902, 71210, 71241
16556, 63372, 63362, 63142, 63152, 18108, 18107, 18085, 18086, 71934, 71904, 71242, 71935, 18773, 18770, 18728, 
18772, 71936, 71905, 71213, 71244
