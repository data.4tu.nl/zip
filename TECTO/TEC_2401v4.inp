31720, 14180, 1322, 1323, 14190, 14565, 1345, 14586, 14584
31721, 1228, 14181, 14191, 1229, 14567, 14587, 14588, 1251
31722, 14181, 14182, 14192, 14191, 14569, 14589, 14590, 14587
31723, 14182, 14183, 14193, 14192, 14571, 14591, 14592, 14589
31724, 14183, 14184, 14194, 14193, 14573, 14593, 14594, 14591
31725, 14184, 14185, 14195, 14194, 14575, 14595, 14596, 14593
31726, 14185, 14186, 14196, 14195, 14577, 14597, 14598, 14595
31727, 14186, 14187, 14197, 14196, 14579, 14599, 14600, 14597
31728, 14187, 14188, 14198, 14197, 14581, 14601, 14602, 14599
31729, 14188, 14189, 14199, 14198, 14583, 14603, 14604, 14601
31730, 14189, 14190, 14200, 14199, 14585, 14605, 14606, 14603
31731, 14190, 1323, 1324, 14200, 14586, 1346, 14607, 14605
31732, 1229, 14191, 14201, 1230, 14588, 14608, 14609, 1252
31733, 14191, 14192, 14202, 14201, 14590, 14610, 14611, 14608
31734, 14192, 14193, 14203, 14202, 14592, 14612, 14613, 14610
31735, 14193, 14194, 14204, 14203, 14594, 14614, 14615, 14612
31736, 14194, 14195, 14205, 14204, 14596, 14616, 14617, 14614
31737, 14195, 14196, 14206, 14205, 14598, 14618, 14619, 14616
31738, 14196, 14197, 14207, 14206, 14600, 14620, 14621, 14618
31739, 14197, 14198, 14208, 14207, 14602, 14622, 14623, 14620
31740, 14198, 14199, 14209, 14208, 14604, 14624, 14625, 14622
31741, 14199, 14200, 14210, 14209, 14606, 14626, 14627, 14624
31742, 14200, 1324, 1325, 14210, 14607, 1347, 14628, 14626
31743, 1230, 14201, 14211, 1231, 14609, 14629, 14630, 1253
31744, 14201, 14202, 14212, 14211, 14611, 14631, 14632, 14629
31745, 14202, 14203, 14213, 14212, 14613, 14633, 14634, 14631
31746, 14203, 14204, 14214, 14213, 14615, 14635, 14636, 14633
31747, 14204, 14205, 14215, 14214, 14617, 14637, 14638, 14635
31748, 14205, 14206, 14216, 14215, 14619, 14639, 14640, 14637
31749, 14206, 14207, 14217, 14216, 14621, 14641, 14642, 14639
31750, 14207, 14208, 14218, 14217, 14623, 14643, 14644, 14641
31751, 14208, 14209, 14219, 14218, 14625, 14645, 14646, 14643
31752, 14209, 14210, 14220, 14219, 14627, 14647, 14648, 14645
31753, 14210, 1325, 1326, 14220, 14628, 1348, 14649, 14647
31754, 1231, 14211, 14221, 1232, 14630, 14650, 14651, 1254
31755, 14211, 14212, 14222, 14221, 14632, 14652, 14653, 14650
31756, 14212, 14213, 14223, 14222, 14634, 14654, 14655, 14652
31757, 14213, 14214, 14224, 14223, 14636, 14656, 14657, 14654
31758, 14214, 14215, 14225, 14224, 14638, 14658, 14659, 14656
31759, 14215, 14216, 14226, 14225, 14640, 14660, 14661, 14658
31760, 14216, 14217, 14227, 14226, 14642, 14662, 14663, 14660
31761, 14217, 14218, 14228, 14227, 14644, 14664, 14665, 14662
31762, 14218, 14219, 14229, 14228, 14646, 14666, 14667, 14664
31763, 14219, 14220, 14230, 14229, 14648, 14668, 14669, 14666
31764, 14220, 1326, 1327, 14230, 14649, 1349, 14670, 14668
31765, 1232, 14221, 14231, 1233, 14651, 14671, 14672, 1255
31766, 14221, 14222, 14232, 14231, 14653, 14673, 14674, 14671
31767, 14222, 14223, 14233, 14232, 14655, 14675, 14676, 14673
31768, 14223, 14224, 14234, 14233, 14657, 14677, 14678, 14675
31769, 14224, 14225, 14235, 14234, 14659, 14679, 14680, 14677
31770, 14225, 14226, 14236, 14235, 14661, 14681, 14682, 14679
31771, 14226, 14227, 14237, 14236, 14663, 14683, 14684, 14681
31772, 14227, 14228, 14238, 14237, 14665, 14685, 14686, 14683
31773, 14228, 14229, 14239, 14238, 14667, 14687, 14688, 14685
31774, 14229, 14230, 14240, 14239, 14669, 14689, 14690, 14687
31775, 14230, 1327, 1328, 14240, 14670, 1350, 14691, 14689
31776, 1233, 14231, 14241, 1234, 14672, 14692, 14693, 1256
31777, 14231, 14232, 14242, 14241, 14674, 14694, 14695, 14692
31778, 14232, 14233, 14243, 14242, 14676, 14696, 14697, 14694
31779, 14233, 14234, 14244, 14243, 14678, 14698, 14699, 14696
31780, 14234, 14235, 14245, 14244, 14680, 14700, 14701, 14698
31781, 14235, 14236, 14246, 14245, 14682, 14702, 14703, 14700
31782, 14236, 14237, 14247, 14246, 14684, 14704, 14705, 14702
31783, 14237, 14238, 14248, 14247, 14686, 14706, 14707, 14704
31784, 14238, 14239, 14249, 14248, 14688, 14708, 14709, 14706
31785, 14239, 14240, 14250, 14249, 14690, 14710, 14711, 14708
31786, 14240, 1328, 1329, 14250, 14691, 1351, 14712, 14710
31787, 1234, 14241, 1412, 29, 14693, 14713, 1423, 1257
31788, 14241, 14242, 1411, 1412, 14695, 14714, 1422, 14713
31789, 14242, 14243, 1410, 1411, 14697, 14715, 1421, 14714
31790, 14243, 14244, 1409, 1410, 14699, 14716, 1420, 14715
31791, 14244, 14245, 1408, 1409, 14701, 14717, 1419, 14716
31792, 14245, 14246, 1407, 1408, 14703, 14718, 1418, 14717
31793, 14246, 14247, 1406, 1407, 14705, 14719, 1417, 14718
31794, 14247, 14248, 1405, 1406, 14707, 14720, 1416, 14719
31795, 14248, 14249, 1404, 1405, 14709, 14721, 1415, 14720
31796, 14249, 14250, 1403, 1404, 14711, 14722, 1414, 14721
31797, 14250, 1329, 31, 1403, 14712, 1352, 1413, 14722
*ELEMENT, type=CPS8, ELSET=Surface35
1405, 26, 1258, 14723, 1201, 1280, 14943, 14944, 1212
1406, 1201, 14723, 14724, 1200, 14944, 14945, 14946, 1211
1407, 1200, 14724, 14725, 1199, 14946, 14947, 14948, 1210
1408, 1199, 14725, 14726, 1198, 14948, 14949, 14950, 1209
1409, 1198, 14726, 14727, 1197, 14950, 14951, 14952, 1208
1410, 1197, 14727, 14728, 1196, 14952, 14953, 14954, 1207
1411, 1196, 14728, 14729, 1195, 14954, 14955, 14956, 1206
1412, 1195, 14729, 14730, 1194, 14956, 14957, 14958, 1205
1413, 1194, 14730, 14731, 1193, 14958, 14959, 14960, 1204
1414, 1193, 14731, 14732, 1192, 14960, 14961, 14962, 1203
1415, 1192, 14732, 1353, 28, 14962, 14963, 1375, 1202
1416, 1258, 1259, 14733, 14723, 1281, 14964, 14965, 14943
1417, 14723, 14733, 14734, 14724, 14965, 14966, 14967, 14945
1418, 14724, 14734, 14735, 14725, 14967, 14968, 14969, 14947
1419, 14725, 14735, 14736, 14726, 14969, 14970, 14971, 14949
1420, 14726, 14736, 14737, 14727, 14971, 14972, 14973, 14951
1421, 14727, 14737, 14738, 14728, 14973, 14974, 14975, 14953
1422, 14728, 14738, 14739, 14729, 14975, 14976, 14977, 14955
1423, 14729, 14739, 14740, 14730, 14977, 14978, 14979, 14957
1424, 14730, 14740, 14741, 14731, 14979, 14980, 14981, 14959
1425, 14731, 14741, 14742, 14732, 14981, 14982, 14983, 14961
1426, 14732, 14742, 1354, 1353, 14983, 14984, 1376, 14963
1427, 1259, 1260, 14743, 14733, 1282, 14985, 14986, 14964
1428, 14733, 14743, 14744, 14734, 14986, 14987, 14988, 14966
1429, 14734, 14744, 14745, 14735, 14988, 14989, 14990, 14968
1430, 14735, 14745, 14746, 14736, 14990, 14991, 14992, 14970
1431, 14736, 14746, 14747, 14737, 14992, 14993, 14994, 14972
1432, 14737, 14747, 14748, 14738, 14994, 14995, 14996, 14974
1433, 14738, 14748, 14749, 14739, 14996, 14997, 14998, 14976
1434, 14739, 14749, 14750, 14740, 14998, 14999, 15000, 14978
1435, 14740, 14750, 14751, 14741, 15000, 15001, 15002, 14980
1436, 14741, 14751, 14752, 14742, 15002, 15003, 15004, 14982
1437, 14742, 14752, 1355, 1354, 15004, 15005, 1377, 14984
1438, 1260, 1261, 14753, 14743, 1283, 15006, 15007, 14985
1439, 14743, 14753, 14754, 14744, 15007, 15008, 15009, 14987
1440, 14744, 14754, 14755, 14745, 15009, 15010, 15011, 14989
1441, 14745, 14755, 14756, 14746, 15011, 15012, 15013, 14991
1442, 14746, 14756, 14757, 14747, 15013, 15014, 15015, 14993
1443, 14747, 14757, 14758, 14748, 15015, 15016, 15017, 14995
1444, 14748, 14758, 14759, 14749, 15017, 15018, 15019, 14997
1445, 14749, 14759, 14760, 14750, 15019, 15020, 15021, 14999
1446, 14750, 14760, 14761, 14751, 15021, 15022, 15023, 15001
1447, 14751, 14761, 14762, 14752, 15023, 15024, 15025, 15003
1448, 14752, 14762, 1356, 1355, 15025, 15026, 1378, 15005
1449, 1261, 1262, 14763, 14753, 1284, 15027, 15028, 15006
1450, 14753, 14763, 14764, 14754, 15028, 15029, 15030, 15008
1451, 14754, 14764, 14765, 14755, 15030, 15031, 15032, 15010
1452, 14755, 14765, 14766, 14756, 15032, 15033, 15034, 15012
1453, 14756, 14766, 14767, 14757, 15034, 15035, 15036, 15014
1454, 14757, 14767, 14768, 14758, 15036, 15037, 15038, 15016
1455, 14758, 14768, 14769, 14759, 15038, 15039, 15040, 15018
1456, 14759, 14769, 14770, 14760, 15040, 15041, 15042, 15020
1457, 14760, 14770, 14771, 14761, 15042, 15043, 15044, 15022
1458, 14761, 14771, 14772, 14762, 15044, 15045, 15046, 15024
1459, 14762, 14772, 1357, 1356, 15046, 15047, 1379, 15026
1460, 1262, 1263, 14773, 14763, 1285, 15048, 15049, 15027
1461, 14763, 14773, 14774, 14764, 15049, 15050, 15051, 15029
1462, 14764, 14774, 14775, 14765, 15051, 15052, 15053, 15031
1463, 14765, 14775, 14776, 14766, 15053, 15054, 15055, 15033
1464, 14766, 14776, 14777, 14767, 15055, 15056, 15057, 15035
1465, 14767, 14777, 14778, 14768, 15057, 15058, 15059, 15037
1466, 14768, 14778, 14779, 14769, 15059, 15060, 15061, 15039
1467, 14769, 14779, 14780, 14770, 15061, 15062, 15063, 15041
1468, 14770, 14780, 14781, 14771, 15063, 15064, 15065, 15043
1469, 14771, 14781, 14782, 14772, 15065, 15066, 15067, 15045
1470, 14772, 14782, 1358, 1357, 15067, 15068, 1380, 15047
1471, 1263, 1264, 14783, 14773, 1286, 15069, 15070, 15048
1472, 14773, 14783, 14784, 14774, 15070, 15071, 15072, 15050
1473, 14774, 14784, 14785, 14775, 15072, 15073, 15074, 15052
1474, 14775, 14785, 14786, 14776, 15074, 15075, 15076, 15054
1475, 14776, 14786, 14787, 14777, 15076, 15077, 15078, 15056
1476, 14777, 14787, 14788, 14778, 15078, 15079, 15080, 15058
1477, 14778, 14788, 14789, 14779, 15080, 15081, 15082, 15060
1478, 14779, 14789, 14790, 14780, 15082, 15083, 15084, 15062
1479, 14780, 14790, 14791, 14781, 15084, 15085, 15086, 15064
1480, 14781, 14791, 14792, 14782, 15086, 15087, 15088, 15066
1481, 14782, 14792, 1359, 1358, 15088, 15089, 1381, 15068
1482, 1264, 1265, 14793, 14783, 1287, 15090, 15091, 15069
1483, 14783, 14793, 14794, 14784, 15091, 15092, 15093, 15071
1484, 14784, 14794, 14795, 14785, 15093, 15094, 15095, 15073
1485, 14785, 14795, 14796, 14786, 15095, 15096, 15097, 15075
1486, 14786, 14796, 14797, 14787, 15097, 15098, 15099, 15077
1487, 14787, 14797, 14798, 14788, 15099, 15100, 15101, 15079
1488, 14788, 14798, 14799, 14789, 15101, 15102, 15103, 15081
1489, 14789, 14799, 14800, 14790, 15103, 15104, 15105, 15083
1490, 14790, 14800, 14801, 14791, 15105, 15106, 15107, 15085
1491, 14791, 14801, 14802, 14792, 15107, 15108, 15109, 15087
1492, 14792, 14802, 1360, 1359, 15109, 15110, 1382, 15089
1493, 1265, 1266, 14803, 14793, 1288, 15111, 15112, 15090
1494, 14793, 14803, 14804, 14794, 15112, 15113, 15114, 15092
1495, 14794, 14804, 14805, 14795, 15114, 15115, 15116, 15094
1496, 14795, 14805, 14806, 14796, 15116, 15117, 15118, 15096
1497, 14796, 14806, 14807, 14797, 15118, 15119, 15120, 15098
1498, 14797, 14807, 14808, 14798, 15120, 15121, 15122, 15100
1499, 14798, 14808, 14809, 14799, 15122, 15123, 15124, 15102
1500, 14799, 14809, 14810, 14800, 15124, 15125, 15126, 15104
1501, 14800, 14810, 14811, 14801, 15126, 15127, 15128, 15106
1502, 14801, 14811, 14812, 14802, 15128, 15129, 15130, 15108
1503, 14802, 14812, 1361, 1360, 15130, 15131, 1383, 15110
1504, 1266, 1267, 14813, 14803, 1289, 15132, 15133, 15111
1505, 14803, 14813, 14814, 14804, 15133, 15134, 15135, 15113
1506, 14804, 14814, 14815, 14805, 15135, 15136, 15137, 15115
1507, 14805, 14815, 14816, 14806, 15137, 15138, 15139, 15117
1508, 14806, 14816, 14817, 14807, 15139, 15140, 15141, 15119
1509, 14807, 14817, 14818, 14808, 15141, 15142, 15143, 15121
1510, 14808, 14818, 14819, 14809, 15143, 15144, 15145, 15123
1511, 14809, 14819, 14820, 14810, 15145, 15146, 15147, 15125
1512, 14810, 14820, 14821, 14811, 15147, 15148, 15149, 15127
1513, 14811, 14821, 14822, 14812, 15149, 15150, 15151, 15129
1514, 14812, 14822, 1362, 1361, 15151, 15152, 1384, 15131
1515, 1267, 1268, 14823, 14813, 1290, 15153, 15154, 15132
1516, 14813, 14823, 14824, 14814, 15154, 15155, 15156, 15134
1517, 14814, 14824, 14825, 14815, 15156, 15157, 15158, 15136
1518, 14815, 14825, 14826, 14816, 15158, 15159, 15160, 15138
1519, 14816, 14826, 14827, 14817, 15160, 15161, 15162, 15140
1520, 14817, 14827, 14828, 14818, 15162, 15163, 15164, 15142
1521, 14818, 14828, 14829, 14819, 15164, 15165, 15166, 15144
1522, 14819, 14829, 14830, 14820, 15166, 15167, 15168, 15146
1523, 14820, 14830, 14831, 14821, 15168, 15169, 15170, 15148
1524, 14821, 14831, 14832, 14822, 15170, 15171, 15172, 15150
1525, 14822, 14832, 1363, 1362, 15172, 15173, 1385, 15152
1526, 1268, 1269, 14833, 14823, 1291, 15174, 15175, 15153
1527, 14823, 14833, 14834, 14824, 15175, 15176, 15177, 15155
1528, 14824, 14834, 14835, 14825, 15177, 15178, 15179, 15157
1529, 14825, 14835, 14836, 14826, 15179, 15180, 15181, 15159
1530, 14826, 14836, 14837, 14827, 15181, 15182, 15183, 15161
1531, 14827, 14837, 14838, 14828, 15183, 15184, 15185, 15163
1532, 14828, 14838, 14839, 14829, 15185, 15186, 15187, 15165
1533, 14829, 14839, 14840, 14830, 15187, 15188, 15189, 15167
1534, 14830, 14840, 14841, 14831, 15189, 15190, 15191, 15169
1535, 14831, 14841, 14842, 14832, 15191, 15192, 15193, 15171
1536, 14832, 14842, 1364, 1363, 15193, 15194, 1386, 15173
1537, 1269, 1270, 14843, 14833, 1292, 15195, 15196, 15174
1538, 14833, 14843, 14844, 14834, 15196, 15197, 15198, 15176
1539, 14834, 14844, 14845, 14835, 15198, 15199, 15200, 15178
1540, 14835, 14845, 14846, 14836, 15200, 15201, 15202, 15180
1541, 14836, 14846, 14847, 14837, 15202, 15203, 15204, 15182
1542, 14837, 14847, 14848, 14838, 15204, 15205, 15206, 15184
1543, 14838, 14848, 14849, 14839, 15206, 15207, 15208, 15186
1544, 14839, 14849, 14850, 14840, 15208, 15209, 15210, 15188
1545, 14840, 14850, 14851, 14841, 15210, 15211, 15212, 15190
1546, 14841, 14851, 14852, 14842, 15212, 15213, 15214, 15192
1547, 14842, 14852, 1365, 1364, 15214, 15215, 1387, 15194
1548, 1270, 1271, 14853, 14843, 1293, 15216, 15217, 15195
1549, 14843, 14853, 14854, 14844, 15217, 15218, 15219, 15197
1550, 14844, 14854, 14855, 14845, 15219, 15220, 15221, 15199
1551, 14845, 14855, 14856, 14846, 15221, 15222, 15223, 15201
1552, 14846, 14856, 14857, 14847, 15223, 15224, 15225, 15203
1553, 14847, 14857, 14858, 14848, 15225, 15226, 15227, 15205
1554, 14848, 14858, 14859, 14849, 15227, 15228, 15229, 15207
1555, 14849, 14859, 14860, 14850, 15229, 15230, 15231, 15209
1556, 14850, 14860, 14861, 14851, 15231, 15232, 15233, 15211
1557, 14851, 14861, 14862, 14852, 15233, 15234, 15235, 15213
1558, 14852, 14862, 1366, 1365, 15235, 15236, 1388, 15215
1559, 1271, 1272, 14863, 14853, 1294, 15237, 15238, 15216
1560, 14853, 14863, 14864, 14854, 15238, 15239, 15240, 15218
1561, 14854, 14864, 14865, 14855, 15240, 15241, 15242, 15220
1562, 14855, 14865, 14866, 14856, 15242, 15243, 15244, 15222
1563, 14856, 14866, 14867, 14857, 15244, 15245, 15246, 15224
1564, 14857, 14867, 14868, 14858, 15246, 15247, 15248, 15226
1565, 14858, 14868, 14869, 14859, 15248, 15249, 15250, 15228
1566, 14859, 14869, 14870, 14860, 15250, 15251, 15252, 15230
1567, 14860, 14870, 14871, 14861, 15252, 15253, 15254, 15232
1568, 14861, 14871, 14872, 14862, 15254, 15255, 15256, 15234
1569, 14862, 14872, 1367, 1366, 15256, 15257, 1389, 15236
1570, 1272, 1273, 14873, 14863, 1295, 15258, 15259, 15237
1571, 14863, 14873, 14874, 14864, 15259, 15260, 15261, 15239
1572, 14864, 14874, 14875, 14865, 15261, 15262, 15263, 15241
1573, 14865, 14875, 14876, 14866, 15263, 15264, 15265, 15243
1574, 14866, 14876, 14877, 14867, 15265, 15266, 15267, 15245
1575, 14867, 14877, 14878, 14868, 15267, 15268, 15269, 15247
1576, 14868, 14878, 14879, 14869, 15269, 15270, 15271, 15249
1577, 14869, 14879, 14880, 14870, 15271, 15272, 15273, 15251
1578, 14870, 14880, 14881, 14871, 15273, 15274, 15275, 15253
1579, 14871, 14881, 14882, 14872, 15275, 15276, 15277, 15255
1580, 14872, 14882, 1368, 1367, 15277, 15278, 1390, 15257
1581, 1273, 1274, 14883, 14873, 1296, 15279, 15280, 15258
1582, 14873, 14883, 14884, 14874, 15280, 15281, 15282, 15260
1583, 14874, 14884, 14885, 14875, 15282, 15283, 15284, 15262
1584, 14875, 14885, 14886, 14876, 15284, 15285, 15286, 15264
1585, 14876, 14886, 14887, 14877, 15286, 15287, 15288, 15266
1586, 14877, 14887, 14888, 14878, 15288, 15289, 15290, 15268
1587, 14878, 14888, 14889, 14879, 15290, 15291, 15292, 15270
1588, 14879, 14889, 14890, 14880, 15292, 15293, 15294, 15272
1589, 14880, 14890, 14891, 14881, 15294, 15295, 15296, 15274
1590, 14881, 14891, 14892, 14882, 15296, 15297, 15298, 15276
1591, 14882, 14892, 1369, 1368, 15298, 15299, 1391, 15278
1592, 1274, 1275, 14893, 14883, 1297, 15300, 15301, 15279
1593, 14883, 14893, 14894, 14884, 15301, 15302, 15303, 15281
1594, 14884, 14894, 14895, 14885, 15303, 15304, 15305, 15283
1595, 14885, 14895, 14896, 14886, 15305, 15306, 15307, 15285
1596, 14886, 14896, 14897, 14887, 15307, 15308, 15309, 15287
1597, 14887, 14897, 14898, 14888, 15309, 15310, 15311, 15289
1598, 14888, 14898, 14899, 14889, 15311, 15312, 15313, 15291
1599, 14889, 14899, 14900, 14890, 15313, 15314, 15315, 15293
1600, 14890, 14900, 14901, 14891, 15315, 15316, 15317, 15295
1601, 14891, 14901, 14902, 14892, 15317, 15318, 15319, 15297
1602, 14892, 14902, 1370, 1369, 15319, 15320, 1392, 15299
1603, 1275, 1276, 14903, 14893, 1298, 15321, 15322, 15300
1604, 14893, 14903, 14904, 14894, 15322, 15323, 15324, 15302
1605, 14894, 14904, 14905, 14895, 15324, 15325, 15326, 15304
1606, 14895, 14905, 14906, 14896, 15326, 15327, 15328, 15306
1607, 14896, 14906, 14907, 14897, 15328, 15329, 15330, 15308
1608, 14897, 14907, 14908, 14898, 15330, 15331, 15332, 15310
1609, 14898, 14908, 14909, 14899, 15332, 15333, 15334, 15312
1610, 14899, 14909, 14910, 14900, 15334, 15335, 15336, 15314
1611, 14900, 14910, 14911, 14901, 15336, 15337, 15338, 15316
1612, 14901, 14911, 14912, 14902, 15338, 15339, 15340, 15318
1613, 14902, 14912, 1371, 1370, 15340, 15341, 1393, 15320
1614, 1276, 1277, 14913, 14903, 1299, 15342, 15343, 15321
1615, 14903, 14913, 14914, 14904, 15343, 15344, 15345, 15323
1616, 14904, 14914, 14915, 14905, 15345, 15346, 15347, 15325
1617, 14905, 14915, 14916, 14906, 15347, 15348, 15349, 15327
1618, 14906, 14916, 14917, 14907, 15349, 15350, 15351, 15329
1619, 14907, 14917, 14918, 14908, 15351, 15352, 15353, 15331
1620, 14908, 14918, 14919, 14909, 15353, 15354, 15355, 15333
1621, 14909, 14919, 14920, 14910, 15355, 15356, 15357, 15335
1622, 14910, 14920, 14921, 14911, 15357, 15358, 15359, 15337
1623, 14911, 14921, 14922, 14912, 15359, 15360, 15361, 15339
1624, 14912, 14922, 1372, 1371, 15361, 15362, 1394, 15341
1625, 1277, 1278, 14923, 14913, 1300, 15363, 15364, 15342
1626, 14913, 14923, 14924, 14914, 15364, 15365, 15366, 15344
1627, 14914, 14924, 14925, 14915, 15366, 15367, 15368, 15346
1628, 14915, 14925, 14926, 14916, 15368, 15369, 15370, 15348
1629, 14916, 14926, 14927, 14917, 15370, 15371, 15372, 15350
1630, 14917, 14927, 14928, 14918, 15372, 15373, 15374, 15352
1631, 14918, 14928, 14929, 14919, 15374, 15375, 15376, 15354
1632, 14919, 14929, 14930, 14920, 15376, 15377, 15378, 15356
1633, 14920, 14930, 14931, 14921, 15378, 15379, 15380, 15358
1634, 14921, 14931, 14932, 14922, 15380, 15381, 15382, 15360
1635, 14922, 14932, 1373, 1372, 15382, 15383, 1395, 15362
1636, 1278, 1279, 14933, 14923, 1301, 15384, 15385, 15363
1637, 14923, 14933, 14934, 14924, 15385, 15386, 15387, 15365
1638, 14924, 14934, 14935, 14925, 15387, 15388, 15389, 15367
1639, 14925, 14935, 14936, 14926, 15389, 15390, 15391, 15369
1640, 14926, 14936, 14937, 14927, 15391, 15392, 15393, 15371
1641, 14927, 14937, 14938, 14928, 15393, 15394, 15395, 15373
1642, 14928, 14938, 14939, 14929, 15395, 15396, 15397, 15375
1643, 14929, 14939, 14940, 14930, 15397, 15398, 15399, 15377
1644, 14930, 14940, 14941, 14931, 15399, 15400, 15401, 15379
1645, 14931, 14941, 14942, 14932, 15401, 15402, 15403, 15381
1646, 14932, 14942, 1374, 1373, 15403, 15404, 1396, 15383
1647, 1279, 30, 1433, 14933, 1302, 1444, 15405, 15384
1648, 14933, 1433, 1432, 14934, 15405, 1443, 15406, 15386
1649, 14934, 1432, 1431, 14935, 15406, 1442, 15407, 15388
1650, 14935, 1431, 1430, 14936, 15407, 1441, 15408, 15390
1651, 14936, 1430, 1429, 14937, 15408, 1440, 15409, 15392
1652, 14937, 1429, 1428, 14938, 15409, 1439, 15410, 15394
1653, 14938, 1428, 1427, 14939, 15410, 1438, 15411, 15396
1654, 14939, 1427, 1426, 14940, 15411, 1437, 15412, 15398
1655, 14940, 1426, 1425, 14941, 15412, 1436, 15413, 15400
1656, 14941, 1425, 1424, 14942, 15413, 1435, 15414, 15402
1657, 14942, 1424, 32, 1374, 15414, 1434, 1397, 15404
*ELEMENT, type=CPS8, ELSET=Surface36
31798, 29, 1412, 15415, 1303, 1423, 15435, 15436, 1305
31799, 1412, 1411, 15416, 15415, 1422, 15437, 15438, 15435
31800, 1411, 1410, 15417, 15416, 1421, 15439, 15440, 15437
31801, 1410, 1409, 15418, 15417, 1420, 15441, 15442, 15439
31802, 1409, 1408, 15419, 15418, 1419, 15443, 15444, 15441
31803, 1408, 1407, 15420, 15419, 1418, 15445, 15446, 15443
31804, 1407, 1406, 15421, 15420, 1417, 15447, 15448, 15445
31805, 1406, 1405, 15422, 15421, 1416, 15449, 15450, 15447
31806, 1405, 1404, 15423, 15422, 1415, 15451, 15452, 15449
31807, 1404, 1403, 15424, 15423, 1414, 15453, 15454, 15451
31808, 1403, 31, 1398, 15424, 1413, 1400, 15455, 15453
31809, 1303, 15415, 15425, 1304, 15436, 15456, 15457, 1306
31810, 15415, 15416, 15426, 15425, 15438, 15458, 15459, 15456
31811, 15416, 15417, 15427, 15426, 15440, 15460, 15461, 15458
31812, 15417, 15418, 15428, 15427, 15442, 15462, 15463, 15460
31813, 15418, 15419, 15429, 15428, 15444, 15464, 15465, 15462
31814, 15419, 15420, 15430, 15429, 15446, 15466, 15467, 15464
31815, 15420, 15421, 15431, 15430, 15448, 15468, 15469, 15466
31816, 15421, 15422, 15432, 15431, 15450, 15470, 15471, 15468
31817, 15422, 15423, 15433, 15432, 15452, 15472, 15473, 15470
31818, 15423, 15424, 15434, 15433, 15454, 15474, 15475, 15472
31819, 15424, 1398, 1399, 15434, 15455, 1401, 15476, 15474
31820, 1304, 15425, 1433, 30, 15457, 15477, 1444, 1307
31821, 15425, 15426, 1432, 1433, 15459, 15478, 1443, 15477
31822, 15426, 15427, 1431, 1432, 15461, 15479, 1442, 15478
31823, 15427, 15428, 1430, 1431, 15463, 15480, 1441, 15479
31824, 15428, 15429, 1429, 1430, 15465, 15481, 1440, 15480
31825, 15429, 15430, 1428, 1429, 15467, 15482, 1439, 15481
31826, 15430, 15431, 1427, 1428, 15469, 15483, 1438, 15482
31827, 15431, 15432, 1426, 1427, 15471, 15484, 1437, 15483
31828, 15432, 15433, 1425, 1426, 15473, 15485, 1436, 15484
31829, 15433, 15434, 1424, 1425, 15475, 15486, 1435, 15485
31830, 15434, 1399, 32, 1424, 15476, 1402, 1434, 15486
*ELEMENT, type=CPS8, ELSET=Surface37
1658, 25, 1445, 15487, 1213, 1446, 15509, 15510, 1235
1659, 1213, 15487, 15488, 1214, 15510, 15511, 15512, 1236
1660, 1214, 15488, 15489, 1215, 15512, 15513, 15514, 1237
1661, 1215, 15489, 15490, 1216, 15514, 15515, 15516, 1238
1662, 1216, 15490, 15491, 1217, 15516, 15517, 15518, 1239
1663, 1217, 15491, 15492, 1218, 15518, 15519, 15520, 1240
1664, 1218, 15492, 15493, 1219, 15520, 15521, 15522, 1241
1665, 1219, 15493, 15494, 1220, 15522, 15523, 15524, 1242
1666, 1220, 15494, 15495, 1221, 15524, 15525, 15526, 1243
1667, 1221, 15495, 15496, 1222, 15526, 15527, 15528, 1244
1668, 1222, 15496, 15497, 1223, 15528, 15529, 15530, 1245
1669, 1223, 15497, 15498, 1224, 15530, 15531, 15532, 1246
1670, 1224, 15498, 15499, 1225, 15532, 15533, 15534, 1247
1671, 1225, 15499, 15500, 1226, 15534, 15535, 15536, 1248
1672, 1226, 15500, 15501, 1227, 15536, 15537, 15538, 1249
1673, 1227, 15501, 15502, 1228, 15538, 15539, 15540, 1250
1674, 1228, 15502, 15503, 1229, 15540, 15541, 15542, 1251
1675, 1229, 15503, 15504, 1230, 15542, 15543, 15544, 1252
1676, 1230, 15504, 15505, 1231, 15544, 15545, 15546, 1253
1677, 1231, 15505, 15506, 1232, 15546, 15547, 15548, 1254
1678, 1232, 15506, 15507, 1233, 15548, 15549, 15550, 1255
1679, 1233, 15507, 15508, 1234, 15550, 15551, 15552, 1256
1680, 1234, 15508, 1448, 29, 15552, 15553, 1449, 1257
1681, 1445, 33, 1451, 15487, 1447, 1473, 15554, 15509
1682, 15487, 1451, 1452, 15488, 15554, 1474, 15555, 15511
1683, 15488, 1452, 1453, 15489, 15555, 1475, 15556, 15513
1684, 15489, 1453, 1454, 15490, 15556, 1476, 15557, 15515
1685, 15490, 1454, 1455, 15491, 15557, 1477, 15558, 15517
1686, 15491, 1455, 1456, 15492, 15558, 1478, 15559, 15519
1687, 15492, 1456, 1457, 15493, 15559, 1479, 15560, 15521
1688, 15493, 1457, 1458, 15494, 15560, 1480, 15561, 15523
1689, 15494, 1458, 1459, 15495, 15561, 1481, 15562, 15525
1690, 15495, 1459, 1460, 15496, 15562, 1482, 15563, 15527
1691, 15496, 1460, 1461, 15497, 15563, 1483, 15564, 15529
1692, 15497, 1461, 1462, 15498, 15564, 1484, 15565, 15531
1693, 15498, 1462, 1463, 15499, 15565, 1485, 15566, 15533
1694, 15499, 1463, 1464, 15500, 15566, 1486, 15567, 15535
1695, 15500, 1464, 1465, 15501, 15567, 1487, 15568, 15537
1696, 15501, 1465, 1466, 15502, 15568, 1488, 15569, 15539
1697, 15502, 1466, 1467, 15503, 15569, 1489, 15570, 15541
1698, 15503, 1467, 1468, 15504, 15570, 1490, 15571, 15543
1699, 15504, 1468, 1469, 15505, 15571, 1491, 15572, 15545
1700, 15505, 1469, 1470, 15506, 15572, 1492, 15573, 15547
1701, 15506, 1470, 1471, 15507, 15573, 1493, 15574, 15549
1702, 15507, 1471, 1472, 15508, 15574, 1494, 15575, 15551
1703, 15508, 1472, 34, 1448, 15575, 1495, 1450, 15553
*ELEMENT, type=CPS8, ELSET=Surface38
31831, 27, 1308, 15576, 1496, 1330, 15598, 15599, 1497
31832, 1308, 1309, 15577, 15576, 1331, 15600, 15601, 15598
31833, 1309, 1310, 15578, 15577, 1332, 15602, 15603, 15600
31834, 1310, 1311, 15579, 15578, 1333, 15604, 15605, 15602
31835, 1311, 1312, 15580, 15579, 1334, 15606, 15607, 15604
31836, 1312, 1313, 15581, 15580, 1335, 15608, 15609, 15606
31837, 1313, 1314, 15582, 15581, 1336, 15610, 15611, 15608
31838, 1314, 1315, 15583, 15582, 1337, 15612, 15613, 15610
31839, 1315, 1316, 15584, 15583, 1338, 15614, 15615, 15612
31840, 1316, 1317, 15585, 15584, 1339, 15616, 15617, 15614
31841, 1317, 1318, 15586, 15585, 1340, 15618, 15619, 15616
31842, 1318, 1319, 15587, 15586, 1341, 15620, 15621, 15618
31843, 1319, 1320, 15588, 15587, 1342, 15622, 15623, 15620
31844, 1320, 1321, 15589, 15588, 1343, 15624, 15625, 15622
31845, 1321, 1322, 15590, 15589, 1344, 15626, 15627, 15624
31846, 1322, 1323, 15591, 15590, 1345, 15628, 15629, 15626
31847, 1323, 1324, 15592, 15591, 1346, 15630, 15631, 15628
31848, 1324, 1325, 15593, 15592, 1347, 15632, 15633, 15630
31849, 1325, 1326, 15594, 15593, 1348, 15634, 15635, 15632
31850, 1326, 1327, 15595, 15594, 1349, 15636, 15637, 15634
31851, 1327, 1328, 15596, 15595, 1350, 15638, 15639, 15636
31852, 1328, 1329, 15597, 15596, 1351, 15640, 15641, 15638
31853, 1329, 31, 1499, 15597, 1352, 1500, 15642, 15640
31854, 1496, 15576, 1502, 35, 15599, 15643, 1524, 1498
31855, 15576, 15577, 1503, 1502, 15601, 15644, 1525, 15643
31856, 15577, 15578, 1504, 1503, 15603, 15645, 1526, 15644
31857, 15578, 15579, 1505, 1504, 15605, 15646, 1527, 15645
31858, 15579, 15580, 1506, 1505, 15607, 15647, 1528, 15646
31859, 15580, 15581, 1507, 1506, 15609, 15648, 1529, 15647
31860, 15581, 15582, 1508, 1507, 15611, 15649, 1530, 15648
31861, 15582, 15583, 1509, 1508, 15613, 15650, 1531, 15649
31862, 15583, 15584, 1510, 1509, 15615, 15651, 1532, 15650
31863, 15584, 15585, 1511, 1510, 15617, 15652, 1533, 15651
31864, 15585, 15586, 1512, 1511, 15619, 15653, 1534, 15652
31865, 15586, 15587, 1513, 1512, 15621, 15654, 1535, 15653
31866, 15587, 15588, 1514, 1513, 15623, 15655, 1536, 15654
31867, 15588, 15589, 1515, 1514, 15625, 15656, 1537, 15655
31868, 15589, 15590, 1516, 1515, 15627, 15657, 1538, 15656
31869, 15590, 15591, 1517, 1516, 15629, 15658, 1539, 15657
31870, 15591, 15592, 1518, 1517, 15631, 15659, 1540, 15658
31871, 15592, 15593, 1519, 1518, 15633, 15660, 1541, 15659
31872, 15593, 15594, 1520, 1519, 15635, 15661, 1542, 15660
31873, 15594, 15595, 1521, 1520, 15637, 15662, 1543, 15661
31874, 15595, 15596, 1522, 1521, 15639, 15663, 1544, 15662
31875, 15596, 15597, 1523, 1522, 15641, 15664, 1545, 15663
31876, 15597, 1499, 36, 1523, 15642, 1501, 1546, 15664
*ELEMENT, type=CPS8, ELSET=Surface39
31877, 25, 1180, 15665, 1445, 1191, 15675, 15676, 1446
31878, 1180, 1179, 15666, 15665, 1190, 15677, 15678, 15675
31879, 1179, 1178, 15667, 15666, 1189, 15679, 15680, 15677
31880, 1178, 1177, 15668, 15667, 1188, 15681, 15682, 15679
31881, 1177, 1176, 15669, 15668, 1187, 15683, 15684, 15681
31882, 1176, 1175, 15670, 15669, 1186, 15685, 15686, 15683
31883, 1175, 1174, 15671, 15670, 1185, 15687, 15688, 15685
31884, 1174, 1173, 15672, 15671, 1184, 15689, 15690, 15687
31885, 1173, 1172, 15673, 15672, 1183, 15691, 15692, 15689
31886, 1172, 1171, 15674, 15673, 1182, 15693, 15694, 15691
31887, 1171, 27, 1496, 15674, 1181, 1497, 15695, 15693
31888, 1445, 15665, 1556, 33, 15676, 15696, 1567, 1447
31889, 15665, 15666, 1555, 1556, 15678, 15697, 1566, 15696
31890, 15666, 15667, 1554, 1555, 15680, 15698, 1565, 15697
31891, 15667, 15668, 1553, 1554, 15682, 15699, 1564, 15698
31892, 15668, 15669, 1552, 1553, 15684, 15700, 1563, 15699
31893, 15669, 15670, 1551, 1552, 15686, 15701, 1562, 15700
31894, 15670, 15671, 1550, 1551, 15688, 15702, 1561, 15701
31895, 15671, 15672, 1549, 1550, 15690, 15703, 1560, 15702
31896, 15672, 15673, 1548, 1549, 15692, 15704, 1559, 15703
31897, 15673, 15674, 1547, 1548, 15694, 15705, 1558, 15704
31898, 15674, 1496, 35, 1547, 15695, 1498, 1557, 15705
*ELEMENT, type=CPS8, ELSET=Surface40
31899, 29, 1448, 15706, 1412, 1449, 15716, 15717, 1423
31900, 1412, 15706, 15707, 1411, 15717, 15718, 15719, 1422
31901, 1411, 15707, 15708, 1410, 15719, 15720, 15721, 1421
31902, 1410, 15708, 15709, 1409, 15721, 15722, 15723, 1420
31903, 1409, 15709, 15710, 1408, 15723, 15724, 15725, 1419
31904, 1408, 15710, 15711, 1407, 15725, 15726, 15727, 1418
31905, 1407, 15711, 15712, 1406, 15727, 15728, 15729, 1417
31906, 1406, 15712, 15713, 1405, 15729, 15730, 15731, 1416
31907, 1405, 15713, 15714, 1404, 15731, 15732, 15733, 1415
31908, 1404, 15714, 15715, 1403, 15733, 15734, 15735, 1414
31909, 1403, 15715, 1499, 31, 15735, 15736, 1500, 1413
31910, 1448, 34, 1577, 15706, 1450, 1588, 15737, 15716
31911, 15706, 1577, 1576, 15707, 15737, 1587, 15738, 15718
31912, 15707, 1576, 1575, 15708, 15738, 1586, 15739, 15720
31913, 15708, 1575, 1574, 15709, 15739, 1585, 15740, 15722
31914, 15709, 1574, 1573, 15710, 15740, 1584, 15741, 15724
31915, 15710, 1573, 1572, 15711, 15741, 1583, 15742, 15726
31916, 15711, 1572, 1571, 15712, 15742, 1582, 15743, 15728
31917, 15712, 1571, 1570, 15713, 15743, 1581, 15744, 15730
31918, 15713, 1570, 1569, 15714, 15744, 1580, 15745, 15732
31919, 15714, 1569, 1568, 15715, 15745, 1579, 15746, 15734
31920, 15715, 1568, 36, 1499, 15746, 1578, 1501, 15736
*ELEMENT, type=CPS8, ELSET=Surface41
31921, 33, 1556, 15747, 1451, 1567, 15967, 15968, 1473
31922, 1556, 1555, 15748, 15747, 1566, 15969, 15970, 15967
31923, 1555, 1554, 15749, 15748, 1565, 15971, 15972, 15969
31924, 1554, 1553, 15750, 15749, 1564, 15973, 15974, 15971
31925, 1553, 1552, 15751, 15750, 1563, 15975, 15976, 15973
31926, 1552, 1551, 15752, 15751, 1562, 15977, 15978, 15975
31927, 1551, 1550, 15753, 15752, 1561, 15979, 15980, 15977
31928, 1550, 1549, 15754, 15753, 1560, 15981, 15982, 15979
31929, 1549, 1548, 15755, 15754, 1559, 15983, 15984, 15981
31930, 1548, 1547, 15756, 15755, 1558, 15985, 15986, 15983
31931, 1547, 35, 1502, 15756, 1557, 1524, 15987, 15985
31932, 1451, 15747, 15757, 1452, 15968, 15988, 15989, 1474
31933, 15747, 15748, 15758, 15757, 15970, 15990, 15991, 15988
31934, 15748, 15749, 15759, 15758, 15972, 15992, 15993, 15990
31935, 15749, 15750, 15760, 15759, 15974, 15994, 15995, 15992
31936, 15750, 15751, 15761, 15760, 15976, 15996, 15997, 15994
31937, 15751, 15752, 15762, 15761, 15978, 15998, 15999, 15996
31938, 15752, 15753, 15763, 15762, 15980, 16000, 16001, 15998
31939, 15753, 15754, 15764, 15763, 15982, 16002, 16003, 16000
31940, 15754, 15755, 15765, 15764, 15984, 16004, 16005, 16002
31941, 15755, 15756, 15766, 15765, 15986, 16006, 16007, 16004
31942, 15756, 1502, 1503, 15766, 15987, 1525, 16008, 16006
31943, 1452, 15757, 15767, 1453, 15989, 16009, 16010, 1475
31944, 15757, 15758, 15768, 15767, 15991, 16011, 16012, 16009
31945, 15758, 15759, 15769, 15768, 15993, 16013, 16014, 16011
31946, 15759, 15760, 15770, 15769, 15995, 16015, 16016, 16013
31947, 15760, 15761, 15771, 15770, 15997, 16017, 16018, 16015
31948, 15761, 15762, 15772, 15771, 15999, 16019, 16020, 16017
31949, 15762, 15763, 15773, 15772, 16001, 16021, 16022, 16019
31950, 15763, 15764, 15774, 15773, 16003, 16023, 16024, 16021
31951, 15764, 15765, 15775, 15774, 16005, 16025, 16026, 16023
31952, 15765, 15766, 15776, 15775, 16007, 16027, 16028, 16025
31953, 15766, 1503, 1504, 15776, 16008, 1526, 16029, 16027
31954, 1453, 15767, 15777, 1454, 16010, 16030, 16031, 1476
31955, 15767, 15768, 15778, 15777, 16012, 16032, 16033, 16030
31956, 15768, 15769, 15779, 15778, 16014, 16034, 16035, 16032
31957, 15769, 15770, 15780, 15779, 16016, 16036, 16037, 16034
31958, 15770, 15771, 15781, 15780, 16018, 16038, 16039, 16036
31959, 15771, 15772, 15782, 15781, 16020, 16040, 16041, 16038
31960, 15772, 15773, 15783, 15782, 16022, 16042, 16043, 16040
31961, 15773, 15774, 15784, 15783, 16024, 16044, 16045, 16042
31962, 15774, 15775, 15785, 15784, 16026, 16046, 16047, 16044
31963, 15775, 15776, 15786, 15785, 16028, 16048, 16049, 16046
31964, 15776, 1504, 1505, 15786, 16029, 1527, 16050, 16048
31965, 1454, 15777, 15787, 1455, 16031, 16051, 16052, 1477
31966, 15777, 15778, 15788, 15787, 16033, 16053, 16054, 16051
31967, 15778, 15779, 15789, 15788, 16035, 16055, 16056, 16053
31968, 15779, 15780, 15790, 15789, 16037, 16057, 16058, 16055
31969, 15780, 15781, 15791, 15790, 16039, 16059, 16060, 16057
31970, 15781, 15782, 15792, 15791, 16041, 16061, 16062, 16059
31971, 15782, 15783, 15793, 15792, 16043, 16063, 16064, 16061
31972, 15783, 15784, 15794, 15793, 16045, 16065, 16066, 16063
31973, 15784, 15785, 15795, 15794, 16047, 16067, 16068, 16065
31974, 15785, 15786, 15796, 15795, 16049, 16069, 16070, 16067
31975, 15786, 1505, 1506, 15796, 16050, 1528, 16071, 16069
31976, 1455, 15787, 15797, 1456, 16052, 16072, 16073, 1478
31977, 15787, 15788, 15798, 15797, 16054, 16074, 16075, 16072
31978, 15788, 15789, 15799, 15798, 16056, 16076, 16077, 16074
31979, 15789, 15790, 15800, 15799, 16058, 16078, 16079, 16076
31980, 15790, 15791, 15801, 15800, 16060, 16080, 16081, 16078
31981, 15791, 15792, 15802, 15801, 16062, 16082, 16083, 16080
31982, 15792, 15793, 15803, 15802, 16064, 16084, 16085, 16082
31983, 15793, 15794, 15804, 15803, 16066, 16086, 16087, 16084
31984, 15794, 15795, 15805, 15804, 16068, 16088, 16089, 16086
31985, 15795, 15796, 15806, 15805, 16070, 16090, 16091, 16088
31986, 15796, 1506, 1507, 15806, 16071, 1529, 16092, 16090
31987, 1456, 15797, 15807, 1457, 16073, 16093, 16094, 1479
31988, 15797, 15798, 15808, 15807, 16075, 16095, 16096, 16093
31989, 15798, 15799, 15809, 15808, 16077, 16097, 16098, 16095
31990, 15799, 15800, 15810, 15809, 16079, 16099, 16100, 16097
31991, 15800, 15801, 15811, 15810, 16081, 16101, 16102, 16099
31992, 15801, 15802, 15812, 15811, 16083, 16103, 16104, 16101
31993, 15802, 15803, 15813, 15812, 16085, 16105, 16106, 16103
31994, 15803, 15804, 15814, 15813, 16087, 16107, 16108, 16105
31995, 15804, 15805, 15815, 15814, 16089, 16109, 16110, 16107
31996, 15805, 15806, 15816, 15815, 16091, 16111, 16112, 16109
31997, 15806, 1507, 1508, 15816, 16092, 1530, 16113, 16111
31998, 1457, 15807, 15817, 1458, 16094, 16114, 16115, 1480
31999, 15807, 15808, 15818, 15817, 16096, 16116, 16117, 16114
32000, 15808, 15809, 15819, 15818, 16098, 16118, 16119, 16116
32001, 15809, 15810, 15820, 15819, 16100, 16120, 16121, 16118
32002, 15810, 15811, 15821, 15820, 16102, 16122, 16123, 16120
32003, 15811, 15812, 15822, 15821, 16104, 16124, 16125, 16122
32004, 15812, 15813, 15823, 15822, 16106, 16126, 16127, 16124
32005, 15813, 15814, 15824, 15823, 16108, 16128, 16129, 16126
32006, 15814, 15815, 15825, 15824, 16110, 16130, 16131, 16128
32007, 15815, 15816, 15826, 15825, 16112, 16132, 16133, 16130
32008, 15816, 1508, 1509, 15826, 16113, 1531, 16134, 16132
32009, 1458, 15817, 15827, 1459, 16115, 16135, 16136, 1481
32010, 15817, 15818, 15828, 15827, 16117, 16137, 16138, 16135
32011, 15818, 15819, 15829, 15828, 16119, 16139, 16140, 16137
32012, 15819, 15820, 15830, 15829, 16121, 16141, 16142, 16139
32013, 15820, 15821, 15831, 15830, 16123, 16143, 16144, 16141
32014, 15821, 15822, 15832, 15831, 16125, 16145, 16146, 16143
32015, 15822, 15823, 15833, 15832, 16127, 16147, 16148, 16145
32016, 15823, 15824, 15834, 15833, 16129, 16149, 16150, 16147
32017, 15824, 15825, 15835, 15834, 16131, 16151, 16152, 16149
32018, 15825, 15826, 15836, 15835, 16133, 16153, 16154, 16151
32019, 15826, 1509, 1510, 15836, 16134, 1532, 16155, 16153
32020, 1459, 15827, 15837, 1460, 16136, 16156, 16157, 1482
32021, 15827, 15828, 15838, 15837, 16138, 16158, 16159, 16156
32022, 15828, 15829, 15839, 15838, 16140, 16160, 16161, 16158
32023, 15829, 15830, 15840, 15839, 16142, 16162, 16163, 16160
32024, 15830, 15831, 15841, 15840, 16144, 16164, 16165, 16162
32025, 15831, 15832, 15842, 15841, 16146, 16166, 16167, 16164
32026, 15832, 15833, 15843, 15842, 16148, 16168, 16169, 16166
32027, 15833, 15834, 15844, 15843, 16150, 16170, 16171, 16168
32028, 15834, 15835, 15845, 15844, 16152, 16172, 16173, 16170
32029, 15835, 15836, 15846, 15845, 16154, 16174, 16175, 16172
32030, 15836, 1510, 1511, 15846, 16155, 1533, 16176, 16174
32031, 1460, 15837, 15847, 1461, 16157, 16177, 16178, 1483
32032, 15837, 15838, 15848, 15847, 16159, 16179, 16180, 16177
32033, 15838, 15839, 15849, 15848, 16161, 16181, 16182, 16179
32034, 15839, 15840, 15850, 15849, 16163, 16183, 16184, 16181
32035, 15840, 15841, 15851, 15850, 16165, 16185, 16186, 16183
32036, 15841, 15842, 15852, 15851, 16167, 16187, 16188, 16185
32037, 15842, 15843, 15853, 15852, 16169, 16189, 16190, 16187
32038, 15843, 15844, 15854, 15853, 16171, 16191, 16192, 16189
32039, 15844, 15845, 15855, 15854, 16173, 16193, 16194, 16191
32040, 15845, 15846, 15856, 15855, 16175, 16195, 16196, 16193
32041, 15846, 1511, 1512, 15856, 16176, 1534, 16197, 16195
32042, 1461, 15847, 15857, 1462, 16178, 16198, 16199, 1484
32043, 15847, 15848, 15858, 15857, 16180, 16200, 16201, 16198
32044, 15848, 15849, 15859, 15858, 16182, 16202, 16203, 16200
32045, 15849, 15850, 15860, 15859, 16184, 16204, 16205, 16202
32046, 15850, 15851, 15861, 15860, 16186, 16206, 16207, 16204
32047, 15851, 15852, 15862, 15861, 16188, 16208, 16209, 16206
32048, 15852, 15853, 15863, 15862, 16190, 16210, 16211, 16208
32049, 15853, 15854, 15864, 15863, 16192, 16212, 16213, 16210
32050, 15854, 15855, 15865, 15864, 16194, 16214, 16215, 16212
32051, 15855, 15856, 15866, 15865, 16196, 16216, 16217, 16214
32052, 15856, 1512, 1513, 15866, 16197, 1535, 16218, 16216
32053, 1462, 15857, 15867, 1463, 16199, 16219, 16220, 1485
32054, 15857, 15858, 15868, 15867, 16201, 16221, 16222, 16219
32055, 15858, 15859, 15869, 15868, 16203, 16223, 16224, 16221
32056, 15859, 15860, 15870, 15869, 16205, 16225, 16226, 16223
32057, 15860, 15861, 15871, 15870, 16207, 16227, 16228, 16225
32058, 15861, 15862, 15872, 15871, 16209, 16229, 16230, 16227
32059, 15862, 15863, 15873, 15872, 16211, 16231, 16232, 16229
32060, 15863, 15864, 15874, 15873, 16213, 16233, 16234, 16231
32061, 15864, 15865, 15875, 15874, 16215, 16235, 16236, 16233
32062, 15865, 15866, 15876, 15875, 16217, 16237, 16238, 16235
32063, 15866, 1513, 1514, 15876, 16218, 1536, 16239, 16237
32064, 1463, 15867, 15877, 1464, 16220, 16240, 16241, 1486
32065, 15867, 15868, 15878, 15877, 16222, 16242, 16243, 16240
32066, 15868, 15869, 15879, 15878, 16224, 16244, 16245, 16242
32067, 15869, 15870, 15880, 15879, 16226, 16246, 16247, 16244
32068, 15870, 15871, 15881, 15880, 16228, 16248, 16249, 16246
32069, 15871, 15872, 15882, 15881, 16230, 16250, 16251, 16248
32070, 15872, 15873, 15883, 15882, 16232, 16252, 16253, 16250
32071, 15873, 15874, 15884, 15883, 16234, 16254, 16255, 16252
32072, 15874, 15875, 15885, 15884, 16236, 16256, 16257, 16254
32073, 15875, 15876, 15886, 15885, 16238, 16258, 16259, 16256
32074, 15876, 1514, 1515, 15886, 16239, 1537, 16260, 16258
32075, 1464, 15877, 15887, 1465, 16241, 16261, 16262, 1487
32076, 15877, 15878, 15888, 15887, 16243, 16263, 16264, 16261
32077, 15878, 15879, 15889, 15888, 16245, 16265, 16266, 16263
32078, 15879, 15880, 15890, 15889, 16247, 16267, 16268, 16265
32079, 15880, 15881, 15891, 15890, 16249, 16269, 16270, 16267
32080, 15881, 15882, 15892, 15891, 16251, 16271, 16272, 16269
32081, 15882, 15883, 15893, 15892, 16253, 16273, 16274, 16271
32082, 15883, 15884, 15894, 15893, 16255, 16275, 16276, 16273
32083, 15884, 15885, 15895, 15894, 16257, 16277, 16278, 16275
32084, 15885, 15886, 15896, 15895, 16259, 16279, 16280, 16277
32085, 15886, 1515, 1516, 15896, 16260, 1538, 16281, 16279
32086, 1465, 15887, 15897, 1466, 16262, 16282, 16283, 1488
32087, 15887, 15888, 15898, 15897, 16264, 16284, 16285, 16282
32088, 15888, 15889, 15899, 15898, 16266, 16286, 16287, 16284
32089, 15889, 15890, 15900, 15899, 16268, 16288, 16289, 16286
32090, 15890, 15891, 15901, 15900, 16270, 16290, 16291, 16288
32091, 15891, 15892, 15902, 15901, 16272, 16292, 16293, 16290
32092, 15892, 15893, 15903, 15902, 16274, 16294, 16295, 16292
32093, 15893, 15894, 15904, 15903, 16276, 16296, 16297, 16294
32094, 15894, 15895, 15905, 15904, 16278, 16298, 16299, 16296
32095, 15895, 15896, 15906, 15905, 16280, 16300, 16301, 16298
32096, 15896, 1516, 1517, 15906, 16281, 1539, 16302, 16300
32097, 1466, 15897, 15907, 1467, 16283, 16303, 16304, 1489
32098, 15897, 15898, 15908, 15907, 16285, 16305, 16306, 16303
32099, 15898, 15899, 15909, 15908, 16287, 16307, 16308, 16305
32100, 15899, 15900, 15910, 15909, 16289, 16309, 16310, 16307
32101, 15900, 15901, 15911, 15910, 16291, 16311, 16312, 16309
32102, 15901, 15902, 15912, 15911, 16293, 16313, 16314, 16311
32103, 15902, 15903, 15913, 15912, 16295, 16315, 16316, 16313
32104, 15903, 15904, 15914, 15913, 16297, 16317, 16318, 16315
32105, 15904, 15905, 15915, 15914, 16299, 16319, 16320, 16317
32106, 15905, 15906, 15916, 15915, 16301, 16321, 16322, 16319
32107, 15906, 1517, 1518, 15916, 16302, 1540, 16323, 16321
32108, 1467, 15907, 15917, 1468, 16304, 16324, 16325, 1490
32109, 15907, 15908, 15918, 15917, 16306, 16326, 16327, 16324
32110, 15908, 15909, 15919, 15918, 16308, 16328, 16329, 16326
32111, 15909, 15910, 15920, 15919, 16310, 16330, 16331, 16328
32112, 15910, 15911, 15921, 15920, 16312, 16332, 16333, 16330
32113, 15911, 15912, 15922, 15921, 16314, 16334, 16335, 16332
32114, 15912, 15913, 15923, 15922, 16316, 16336, 16337, 16334
32115, 15913, 15914, 15924, 15923, 16318, 16338, 16339, 16336
32116, 15914, 15915, 15925, 15924, 16320, 16340, 16341, 16338
32117, 15915, 15916, 15926, 15925, 16322, 16342, 16343, 16340
32118, 15916, 1518, 1519, 15926, 16323, 1541, 16344, 16342
32119, 1468, 15917, 15927, 1469, 16325, 16345, 16346, 1491
32120, 15917, 15918, 15928, 15927, 16327, 16347, 16348, 16345
32121, 15918, 15919, 15929, 15928, 16329, 16349, 16350, 16347
32122, 15919, 15920, 15930, 15929, 16331, 16351, 16352, 16349
32123, 15920, 15921, 15931, 15930, 16333, 16353, 16354, 16351
32124, 15921, 15922, 15932, 15931, 16335, 16355, 16356, 16353
32125, 15922, 15923, 15933, 15932, 16337, 16357, 16358, 16355
32126, 15923, 15924, 15934, 15933, 16339, 16359, 16360, 16357
32127, 15924, 15925, 15935, 15934, 16341, 16361, 16362, 16359
32128, 15925, 15926, 15936, 15935, 16343, 16363, 16364, 16361
32129, 15926, 1519, 1520, 15936, 16344, 1542, 16365, 16363
32130, 1469, 15927, 15937, 1470, 16346, 16366, 16367, 1492
32131, 15927, 15928, 15938, 15937, 16348, 16368, 16369, 16366
32132, 15928, 15929, 15939, 15938, 16350, 16370, 16371, 16368
32133, 15929, 15930, 15940, 15939, 16352, 16372, 16373, 16370
32134, 15930, 15931, 15941, 15940, 16354, 16374, 16375, 16372
32135, 15931, 15932, 15942, 15941, 16356, 16376, 16377, 16374
32136, 15932, 15933, 15943, 15942, 16358, 16378, 16379, 16376
32137, 15933, 15934, 15944, 15943, 16360, 16380, 16381, 16378
32138, 15934, 15935, 15945, 15944, 16362, 16382, 16383, 16380
32139, 15935, 15936, 15946, 15945, 16364, 16384, 16385, 16382
32140, 15936, 1520, 1521, 15946, 16365, 1543, 16386, 16384
32141, 1470, 15937, 15947, 1471, 16367, 16387, 16388, 1493
32142, 15937, 15938, 15948, 15947, 16369, 16389, 16390, 16387
32143, 15938, 15939, 15949, 15948, 16371, 16391, 16392, 16389
32144, 15939, 15940, 15950, 15949, 16373, 16393, 16394, 16391
32145, 15940, 15941, 15951, 15950, 16375, 16395, 16396, 16393
32146, 15941, 15942, 15952, 15951, 16377, 16397, 16398, 16395
32147, 15942, 15943, 15953, 15952, 16379, 16399, 16400, 16397
32148, 15943, 15944, 15954, 15953, 16381, 16401, 16402, 16399
32149, 15944, 15945, 15955, 15954, 16383, 16403, 16404, 16401
32150, 15945, 15946, 15956, 15955, 16385, 16405, 16406, 16403
32151, 15946, 1521, 1522, 15956, 16386, 1544, 16407, 16405
32152, 1471, 15947, 15957, 1472, 16388, 16408, 16409, 1494
32153, 15947, 15948, 15958, 15957, 16390, 16410, 16411, 16408
32154, 15948, 15949, 15959, 15958, 16392, 16412, 16413, 16410
32155, 15949, 15950, 15960, 15959, 16394, 16414, 16415, 16412
32156, 15950, 15951, 15961, 15960, 16396, 16416, 16417, 16414
32157, 15951, 15952, 15962, 15961, 16398, 16418, 16419, 16416
32158, 15952, 15953, 15963, 15962, 16400, 16420, 16421, 16418
32159, 15953, 15954, 15964, 15963, 16402, 16422, 16423, 16420
32160, 15954, 15955, 15965, 15964, 16404, 16424, 16425, 16422
32161, 15955, 15956, 15966, 15965, 16406, 16426, 16427, 16424
32162, 15956, 1522, 1523, 15966, 16407, 1545, 16428, 16426
32163, 1472, 15957, 1577, 34, 16409, 16429, 1588, 1495
32164, 15957, 15958, 1576, 1577, 16411, 16430, 1587, 16429
32165, 15958, 15959, 1575, 1576, 16413, 16431, 1586, 16430
32166, 15959, 15960, 1574, 1575, 16415, 16432, 1585, 16431
32167, 15960, 15961, 1573, 1574, 16417, 16433, 1584, 16432
32168, 15961, 15962, 1572, 1573, 16419, 16434, 1583, 16433
32169, 15962, 15963, 1571, 1572, 16421, 16435, 1582, 16434
32170, 15963, 15964, 1570, 1571, 16423, 16436, 1581, 16435
32171, 15964, 15965, 1569, 1570, 16425, 16437, 1580, 16436
32172, 15965, 15966, 1568, 1569, 16427, 16438, 1579, 16437
32173, 15966, 1523, 36, 1568, 16428, 1546, 1578, 16438
*ELEMENT, type=CPS8, ELSET=Surface42
1704, 33, 1589, 16439, 1451, 1611, 16923, 16924, 1473
1705, 1451, 16439, 16440, 1452, 16924, 16925, 16926, 1474
1706, 1452, 16440, 16441, 1453, 16926, 16927, 16928, 1475
1707, 1453, 16441, 16442, 1454, 16928, 16929, 16930, 1476
1708, 1454, 16442, 16443, 1455, 16930, 16931, 16932, 1477
1709, 1455, 16443, 16444, 1456, 16932, 16933, 16934, 1478
1710, 1456, 16444, 16445, 1457, 16934, 16935, 16936, 1479
1711, 1457, 16445, 16446, 1458, 16936, 16937, 16938, 1480
1712, 1458, 16446, 16447, 1459, 16938, 16939, 16940, 1481
1713, 1459, 16447, 16448, 1460, 16940, 16941, 16942, 1482
1714, 1460, 16448, 16449, 1461, 16942, 16943, 16944, 1483
1715, 1461, 16449, 16450, 1462, 16944, 16945, 16946, 1484
1716, 1462, 16450, 16451, 1463, 16946, 16947, 16948, 1485
1717, 1463, 16451, 16452, 1464, 16948, 16949, 16950, 1486
1718, 1464, 16452, 16453, 1465, 16950, 16951, 16952, 1487
1719, 1465, 16453, 16454, 1466, 16952, 16953, 16954, 1488
1720, 1466, 16454, 16455, 1467, 16954, 16955, 16956, 1489
1721, 1467, 16455, 16456, 1468, 16956, 16957, 16958, 1490
1722, 1468, 16456, 16457, 1469, 16958, 16959, 16960, 1491
1723, 1469, 16457, 16458, 1470, 16960, 16961, 16962, 1492
1724, 1470, 16458, 16459, 1471, 16962, 16963, 16964, 1493
1725, 1471, 16459, 16460, 1472, 16964, 16965, 16966, 1494
1726, 1472, 16460, 1634, 34, 16966, 16967, 1656, 1495
1727, 1589, 1590, 16461, 16439, 1612, 16968, 16969, 16923
1728, 16439, 16461, 16462, 16440, 16969, 16970, 16971, 16925
1729, 16440, 16462, 16463, 16441, 16971, 16972, 16973, 16927
1730, 16441, 16463, 16464, 16442, 16973, 16974, 16975, 16929
1731, 16442, 16464, 16465, 16443, 16975, 16976, 16977, 16931
1732, 16443, 16465, 16466, 16444, 16977, 16978, 16979, 16933
1733, 16444, 16466, 16467, 16445, 16979, 16980, 16981, 16935
1734, 16445, 16467, 16468, 16446, 16981, 16982, 16983, 16937
1735, 16446, 16468, 16469, 16447, 16983, 16984, 16985, 16939
1736, 16447, 16469, 16470, 16448, 16985, 16986, 16987, 16941
1737, 16448, 16470, 16471, 16449, 16987, 16988, 16989, 16943
1738, 16449, 16471, 16472, 16450, 16989, 16990, 16991, 16945
1739, 16450, 16472, 16473, 16451, 16991, 16992, 16993, 16947
1740, 16451, 16473, 16474, 16452, 16993, 16994, 16995, 16949
1741, 16452, 16474, 16475, 16453, 16995, 16996, 16997, 16951
1742, 16453, 16475, 16476, 16454, 16997, 16998, 16999, 16953
1743, 16454, 16476, 16477, 16455, 16999, 17000, 17001, 16955
1744, 16455, 16477, 16478, 16456, 17001, 17002, 17003, 16957
1745, 16456, 16478, 16479, 16457, 17003, 17004, 17005, 16959
1746, 16457, 16479, 16480, 16458, 17005, 17006, 17007, 16961
1747, 16458, 16480, 16481, 16459, 17007, 17008, 17009, 16963
1748, 16459, 16481, 16482, 16460, 17009, 17010, 17011, 16965
1749, 16460, 16482, 1635, 1634, 17011, 17012, 1657, 16967
1750, 1590, 1591, 16483, 16461, 1613, 17013, 17014, 16968
1751, 16461, 16483, 16484, 16462, 17014, 17015, 17016, 16970
1752, 16462, 16484, 16485, 16463, 17016, 17017, 17018, 16972
1753, 16463, 16485, 16486, 16464, 17018, 17019, 17020, 16974
1754, 16464, 16486, 16487, 16465, 17020, 17021, 17022, 16976
1755, 16465, 16487, 16488, 16466, 17022, 17023, 17024, 16978
1756, 16466, 16488, 16489, 16467, 17024, 17025, 17026, 16980
1757, 16467, 16489, 16490, 16468, 17026, 17027, 17028, 16982
1758, 16468, 16490, 16491, 16469, 17028, 17029, 17030, 16984
1759, 16469, 16491, 16492, 16470, 17030, 17031, 17032, 16986
1760, 16470, 16492, 16493, 16471, 17032, 17033, 17034, 16988
1761, 16471, 16493, 16494, 16472, 17034, 17035, 17036, 16990
1762, 16472, 16494, 16495, 16473, 17036, 17037, 17038, 16992
1763, 16473, 16495, 16496, 16474, 17038, 17039, 17040, 16994
1764, 16474, 16496, 16497, 16475, 17040, 17041, 17042, 16996
1765, 16475, 16497, 16498, 16476, 17042, 17043, 17044, 16998
1766, 16476, 16498, 16499, 16477, 17044, 17045, 17046, 17000
1767, 16477, 16499, 16500, 16478, 17046, 17047, 17048, 17002
1768, 16478, 16500, 16501, 16479, 17048, 17049, 17050, 17004
1769, 16479, 16501, 16502, 16480, 17050, 17051, 17052, 17006
1770, 16480, 16502, 16503, 16481, 17052, 17053, 17054, 17008
1771, 16481, 16503, 16504, 16482, 17054, 17055, 17056, 17010
1772, 16482, 16504, 1636, 1635, 17056, 17057, 1658, 17012
1773, 1591, 1592, 16505, 16483, 1614, 17058, 17059, 17013
1774, 16483, 16505, 16506, 16484, 17059, 17060, 17061, 17015
1775, 16484, 16506, 16507, 16485, 17061, 17062, 17063, 17017
1776, 16485, 16507, 16508, 16486, 17063, 17064, 17065, 17019
1777, 16486, 16508, 16509, 16487, 17065, 17066, 17067, 17021
1778, 16487, 16509, 16510, 16488, 17067, 17068, 17069, 17023
1779, 16488, 16510, 16511, 16489, 17069, 17070, 17071, 17025
1780, 16489, 16511, 16512, 16490, 17071, 17072, 17073, 17027
1781, 16490, 16512, 16513, 16491, 17073, 17074, 17075, 17029
1782, 16491, 16513, 16514, 16492, 17075, 17076, 17077, 17031
1783, 16492, 16514, 16515, 16493, 17077, 17078, 17079, 17033
1784, 16493, 16515, 16516, 16494, 17079, 17080, 17081, 17035
1785, 16494, 16516, 16517, 16495, 17081, 17082, 17083, 17037
1786, 16495, 16517, 16518, 16496, 17083, 17084, 17085, 17039
1787, 16496, 16518, 16519, 16497, 17085, 17086, 17087, 17041
1788, 16497, 16519, 16520, 16498, 17087, 17088, 17089, 17043
1789, 16498, 16520, 16521, 16499, 17089, 17090, 17091, 17045
1790, 16499, 16521, 16522, 16500, 17091, 17092, 17093, 17047
1791, 16500, 16522, 16523, 16501, 17093, 17094, 17095, 17049
1792, 16501, 16523, 16524, 16502, 17095, 17096, 17097, 17051
1793, 16502, 16524, 16525, 16503, 17097, 17098, 17099, 17053
1794, 16503, 16525, 16526, 16504, 17099, 17100, 17101, 17055
1795, 16504, 16526, 1637, 1636, 17101, 17102, 1659, 17057
1796, 1592, 1593, 16527, 16505, 1615, 17103, 17104, 17058
1797, 16505, 16527, 16528, 16506, 17104, 17105, 17106, 17060
1798, 16506, 16528, 16529, 16507, 17106, 17107, 17108, 17062
1799, 16507, 16529, 16530, 16508, 17108, 17109, 17110, 17064
1800, 16508, 16530, 16531, 16509, 17110, 17111, 17112, 17066
1801, 16509, 16531, 16532, 16510, 17112, 17113, 17114, 17068
1802, 16510, 16532, 16533, 16511, 17114, 17115, 17116, 17070
1803, 16511, 16533, 16534, 16512, 17116, 17117, 17118, 17072
1804, 16512, 16534, 16535, 16513, 17118, 17119, 17120, 17074
1805, 16513, 16535, 16536, 16514, 17120, 17121, 17122, 17076
1806, 16514, 16536, 16537, 16515, 17122, 17123, 17124, 17078
1807, 16515, 16537, 16538, 16516, 17124, 17125, 17126, 17080
1808, 16516, 16538, 16539, 16517, 17126, 17127, 17128, 17082
1809, 16517, 16539, 16540, 16518, 17128, 17129, 17130, 17084
1810, 16518, 16540, 16541, 16519, 17130, 17131, 17132, 17086
1811, 16519, 16541, 16542, 16520, 17132, 17133, 17134, 17088
1812, 16520, 16542, 16543, 16521, 17134, 17135, 17136, 17090
1813, 16521, 16543, 16544, 16522, 17136, 17137, 17138, 17092
1814, 16522, 16544, 16545, 16523, 17138, 17139, 17140, 17094
1815, 16523, 16545, 16546, 16524, 17140, 17141, 17142, 17096
1816, 16524, 16546, 16547, 16525, 17142, 17143, 17144, 17098
1817, 16525, 16547, 16548, 16526, 17144, 17145, 17146, 17100
1818, 16526, 16548, 1638, 1637, 17146, 17147, 1660, 17102
1819, 1593, 1594, 16549, 16527, 1616, 17148, 17149, 17103
1820, 16527, 16549, 16550, 16528, 17149, 17150, 17151, 17105
1821, 16528, 16550, 16551, 16529, 17151, 17152, 17153, 17107
1822, 16529, 16551, 16552, 16530, 17153, 17154, 17155, 17109
1823, 16530, 16552, 16553, 16531, 17155, 17156, 17157, 17111
1824, 16531, 16553, 16554, 16532, 17157, 17158, 17159, 17113
1825, 16532, 16554, 16555, 16533, 17159, 17160, 17161, 17115
1826, 16533, 16555, 16556, 16534, 17161, 17162, 17163, 17117
1827, 16534, 16556, 16557, 16535, 17163, 17164, 17165, 17119
1828, 16535, 16557, 16558, 16536, 17165, 17166, 17167, 17121
1829, 16536, 16558, 16559, 16537, 17167, 17168, 17169, 17123
1830, 16537, 16559, 16560, 16538, 17169, 17170, 17171, 17125
1831, 16538, 16560, 16561, 16539, 17171, 17172, 17173, 17127
1832, 16539, 16561, 16562, 16540, 17173, 17174, 17175, 17129
1833, 16540, 16562, 16563, 16541, 17175, 17176, 17177, 17131
1834, 16541, 16563, 16564, 16542, 17177, 17178, 17179, 17133
1835, 16542, 16564, 16565, 16543, 17179, 17180, 17181, 17135
1836, 16543, 16565, 16566, 16544, 17181, 17182, 17183, 17137
1837, 16544, 16566, 16567, 16545, 17183, 17184, 17185, 17139
1838, 16545, 16567, 16568, 16546, 17185, 17186, 17187, 17141
1839, 16546, 16568, 16569, 16547, 17187, 17188, 17189, 17143
1840, 16547, 16569, 16570, 16548, 17189, 17190, 17191, 17145
1841, 16548, 16570, 1639, 1638, 17191, 17192, 1661, 17147
1842, 1594, 1595, 16571, 16549, 1617, 17193, 17194, 17148
1843, 16549, 16571, 16572, 16550, 17194, 17195, 17196, 17150
1844, 16550, 16572, 16573, 16551, 17196, 17197, 17198, 17152
1845, 16551, 16573, 16574, 16552, 17198, 17199, 17200, 17154
1846, 16552, 16574, 16575, 16553, 17200, 17201, 17202, 17156
1847, 16553, 16575, 16576, 16554, 17202, 17203, 17204, 17158
1848, 16554, 16576, 16577, 16555, 17204, 17205, 17206, 17160
1849, 16555, 16577, 16578, 16556, 17206, 17207, 17208, 17162
1850, 16556, 16578, 16579, 16557, 17208, 17209, 17210, 17164
1851, 16557, 16579, 16580, 16558, 17210, 17211, 17212, 17166
1852, 16558, 16580, 16581, 16559, 17212, 17213, 17214, 17168
1853, 16559, 16581, 16582, 16560, 17214, 17215, 17216, 17170
1854, 16560, 16582, 16583, 16561, 17216, 17217, 17218, 17172
1855, 16561, 16583, 16584, 16562, 17218, 17219, 17220, 17174
1856, 16562, 16584, 16585, 16563, 17220, 17221, 17222, 17176
1857, 16563, 16585, 16586, 16564, 17222, 17223, 17224, 17178
1858, 16564, 16586, 16587, 16565, 17224, 17225, 17226, 17180
1859, 16565, 16587, 16588, 16566, 17226, 17227, 17228, 17182
1860, 16566, 16588, 16589, 16567, 17228, 17229, 17230, 17184
1861, 16567, 16589, 16590, 16568, 17230, 17231, 17232, 17186
1862, 16568, 16590, 16591, 16569, 17232, 17233, 17234, 17188
1863, 16569, 16591, 16592, 16570, 17234, 17235, 17236, 17190
1864, 16570, 16592, 1640, 1639, 17236, 17237, 1662, 17192
1865, 1595, 1596, 16593, 16571, 1618, 17238, 17239, 17193
1866, 16571, 16593, 16594, 16572, 17239, 17240, 17241, 17195
1867, 16572, 16594, 16595, 16573, 17241, 17242, 17243, 17197
1868, 16573, 16595, 16596, 16574, 17243, 17244, 17245, 17199
1869, 16574, 16596, 16597, 16575, 17245, 17246, 17247, 17201
1870, 16575, 16597, 16598, 16576, 17247, 17248, 17249, 17203
1871, 16576, 16598, 16599, 16577, 17249, 17250, 17251, 17205
1872, 16577, 16599, 16600, 16578, 17251, 17252, 17253, 17207
1873, 16578, 16600, 16601, 16579, 17253, 17254, 17255, 17209
1874, 16579, 16601, 16602, 16580, 17255, 17256, 17257, 17211
1875, 16580, 16602, 16603, 16581, 17257, 17258, 17259, 17213
1876, 16581, 16603, 16604, 16582, 17259, 17260, 17261, 17215
1877, 16582, 16604, 16605, 16583, 17261, 17262, 17263, 17217
1878, 16583, 16605, 16606, 16584, 17263, 17264, 17265, 17219
1879, 16584, 16606, 16607, 16585, 17265, 17266, 17267, 17221
1880, 16585, 16607, 16608, 16586, 17267, 17268, 17269, 17223
1881, 16586, 16608, 16609, 16587, 17269, 17270, 17271, 17225
1882, 16587, 16609, 16610, 16588, 17271, 17272, 17273, 17227
1883, 16588, 16610, 16611, 16589, 17273, 17274, 17275, 17229
1884, 16589, 16611, 16612, 16590, 17275, 17276, 17277, 17231
1885, 16590, 16612, 16613, 16591, 17277, 17278, 17279, 17233
1886, 16591, 16613, 16614, 16592, 17279, 17280, 17281, 17235
1887, 16592, 16614, 1641, 1640, 17281, 17282, 1663, 17237
1888, 1596, 1597, 16615, 16593, 1619, 17283, 17284, 17238
1889, 16593, 16615, 16616, 16594, 17284, 17285, 17286, 17240
1890, 16594, 16616, 16617, 16595, 17286, 17287, 17288, 17242
1891, 16595, 16617, 16618, 16596, 17288, 17289, 17290, 17244
1892, 16596, 16618, 16619, 16597, 17290, 17291, 17292, 17246
1893, 16597, 16619, 16620, 16598, 17292, 17293, 17294, 17248
1894, 16598, 16620, 16621, 16599, 17294, 17295, 17296, 17250
1895, 16599, 16621, 16622, 16600, 17296, 17297, 17298, 17252
1896, 16600, 16622, 16623, 16601, 17298, 17299, 17300, 17254
1897, 16601, 16623, 16624, 16602, 17300, 17301, 17302, 17256
1898, 16602, 16624, 16625, 16603, 17302, 17303, 17304, 17258
1899, 16603, 16625, 16626, 16604, 17304, 17305, 17306, 17260
1900, 16604, 16626, 16627, 16605, 17306, 17307, 17308, 17262
1901, 16605, 16627, 16628, 16606, 17308, 17309, 17310, 17264
1902, 16606, 16628, 16629, 16607, 17310, 17311, 17312, 17266
1903, 16607, 16629, 16630, 16608, 17312, 17313, 17314, 17268
1904, 16608, 16630, 16631, 16609, 17314, 17315, 17316, 17270
1905, 16609, 16631, 16632, 16610, 17316, 17317, 17318, 17272
1906, 16610, 16632, 16633, 16611, 17318, 17319, 17320, 17274
1907, 16611, 16633, 16634, 16612, 17320, 17321, 17322, 17276
1908, 16612, 16634, 16635, 16613, 17322, 17323, 17324, 17278
1909, 16613, 16635, 16636, 16614, 17324, 17325, 17326, 17280
1910, 16614, 16636, 1642, 1641, 17326, 17327, 1664, 17282
1911, 1597, 1598, 16637, 16615, 1620, 17328, 17329, 17283
1912, 16615, 16637, 16638, 16616, 17329, 17330, 17331, 17285
1913, 16616, 16638, 16639, 16617, 17331, 17332, 17333, 17287
1914, 16617, 16639, 16640, 16618, 17333, 17334, 17335, 17289
1915, 16618, 16640, 16641, 16619, 17335, 17336, 17337, 17291
1916, 16619, 16641, 16642, 16620, 17337, 17338, 17339, 17293
1917, 16620, 16642, 16643, 16621, 17339, 17340, 17341, 17295
1918, 16621, 16643, 16644, 16622, 17341, 17342, 17343, 17297
1919, 16622, 16644, 16645, 16623, 17343, 17344, 17345, 17299
1920, 16623, 16645, 16646, 16624, 17345, 17346, 17347, 17301
1921, 16624, 16646, 16647, 16625, 17347, 17348, 17349, 17303
1922, 16625, 16647, 16648, 16626, 17349, 17350, 17351, 17305
1923, 16626, 16648, 16649, 16627, 17351, 17352, 17353, 17307
1924, 16627, 16649, 16650, 16628, 17353, 17354, 17355, 17309
1925, 16628, 16650, 16651, 16629, 17355, 17356, 17357, 17311
1926, 16629, 16651, 16652, 16630, 17357, 17358, 17359, 17313
1927, 16630, 16652, 16653, 16631, 17359, 17360, 17361, 17315
1928, 16631, 16653, 16654, 16632, 17361, 17362, 17363, 17317
1929, 16632, 16654, 16655, 16633, 17363, 17364, 17365, 17319
1930, 16633, 16655, 16656, 16634, 17365, 17366, 17367, 17321
1931, 16634, 16656, 16657, 16635, 17367, 17368, 17369, 17323
1932, 16635, 16657, 16658, 16636, 17369, 17370, 17371, 17325
1933, 16636, 16658, 1643, 1642, 17371, 17372, 1665, 17327
1934, 1598, 1599, 16659, 16637, 1621, 17373, 17374, 17328
1935, 16637, 16659, 16660, 16638, 17374, 17375, 17376, 17330
1936, 16638, 16660, 16661, 16639, 17376, 17377, 17378, 17332
1937, 16639, 16661, 16662, 16640, 17378, 17379, 17380, 17334
1938, 16640, 16662, 16663, 16641, 17380, 17381, 17382, 17336
1939, 16641, 16663, 16664, 16642, 17382, 17383, 17384, 17338
1940, 16642, 16664, 16665, 16643, 17384, 17385, 17386, 17340
1941, 16643, 16665, 16666, 16644, 17386, 17387, 17388, 17342
1942, 16644, 16666, 16667, 16645, 17388, 17389, 17390, 17344
1943, 16645, 16667, 16668, 16646, 17390, 17391, 17392, 17346
1944, 16646, 16668, 16669, 16647, 17392, 17393, 17394, 17348
1945, 16647, 16669, 16670, 16648, 17394, 17395, 17396, 17350
1946, 16648, 16670, 16671, 16649, 17396, 17397, 17398, 17352
1947, 16649, 16671, 16672, 16650, 17398, 17399, 17400, 17354
1948, 16650, 16672, 16673, 16651, 17400, 17401, 17402, 17356
1949, 16651, 16673, 16674, 16652, 17402, 17403, 17404, 17358
1950, 16652, 16674, 16675, 16653, 17404, 17405, 17406, 17360
1951, 16653, 16675, 16676, 16654, 17406, 17407, 17408, 17362
1952, 16654, 16676, 16677, 16655, 17408, 17409, 17410, 17364
1953, 16655, 16677, 16678, 16656, 17410, 17411, 17412, 17366
1954, 16656, 16678, 16679, 16657, 17412, 17413, 17414, 17368
1955, 16657, 16679, 16680, 16658, 17414, 17415, 17416, 17370
1956, 16658, 16680, 1644, 1643, 17416, 17417, 1666, 17372
1957, 1599, 1600, 16681, 16659, 1622, 17418, 17419, 17373
1958, 16659, 16681, 16682, 16660, 17419, 17420, 17421, 17375
1959, 16660, 16682, 16683, 16661, 17421, 17422, 17423, 17377
1960, 16661, 16683, 16684, 16662, 17423, 17424, 17425, 17379
1961, 16662, 16684, 16685, 16663, 17425, 17426, 17427, 17381
1962, 16663, 16685, 16686, 16664, 17427, 17428, 17429, 17383
1963, 16664, 16686, 16687, 16665, 17429, 17430, 17431, 17385
1964, 16665, 16687, 16688, 16666, 17431, 17432, 17433, 17387
1965, 16666, 16688, 16689, 16667, 17433, 17434, 17435, 17389
1966, 16667, 16689, 16690, 16668, 17435, 17436, 17437, 17391
1967, 16668, 16690, 16691, 16669, 17437, 17438, 17439, 17393
1968, 16669, 16691, 16692, 16670, 17439, 17440, 17441, 17395
1969, 16670, 16692, 16693, 16671, 17441, 17442, 17443, 17397
1970, 16671, 16693, 16694, 16672, 17443, 17444, 17445, 17399
1971, 16672, 16694, 16695, 16673, 17445, 17446, 17447, 17401
1972, 16673, 16695, 16696, 16674, 17447, 17448, 17449, 17403
1973, 16674, 16696, 16697, 16675, 17449, 17450, 17451, 17405
1974, 16675, 16697, 16698, 16676, 17451, 17452, 17453, 17407
1975, 16676, 16698, 16699, 16677, 17453, 17454, 17455, 17409
1976, 16677, 16699, 16700, 16678, 17455, 17456, 17457, 17411
1977, 16678, 16700, 16701, 16679, 17457, 17458, 17459, 17413
1978, 16679, 16701, 16702, 16680, 17459, 17460, 17461, 17415
1979, 16680, 16702, 1645, 1644, 17461, 17462, 1667, 17417
1980, 1600, 1601, 16703, 16681, 1623, 17463, 17464, 17418
1981, 16681, 16703, 16704, 16682, 17464, 17465, 17466, 17420
1982, 16682, 16704, 16705, 16683, 17466, 17467, 17468, 17422
1983, 16683, 16705, 16706, 16684, 17468, 17469, 17470, 17424
1984, 16684, 16706, 16707, 16685, 17470, 17471, 17472, 17426
1985, 16685, 16707, 16708, 16686, 17472, 17473, 17474, 17428
1986, 16686, 16708, 16709, 16687, 17474, 17475, 17476, 17430
1987, 16687, 16709, 16710, 16688, 17476, 17477, 17478, 17432
1988, 16688, 16710, 16711, 16689, 17478, 17479, 17480, 17434
1989, 16689, 16711, 16712, 16690, 17480, 17481, 17482, 17436
1990, 16690, 16712, 16713, 16691, 17482, 17483, 17484, 17438
1991, 16691, 16713, 16714, 16692, 17484, 17485, 17486, 17440
1992, 16692, 16714, 16715, 16693, 17486, 17487, 17488, 17442
1993, 16693, 16715, 16716, 16694, 17488, 17489, 17490, 17444
1994, 16694, 16716, 16717, 16695, 17490, 17491, 17492, 17446
1995, 16695, 16717, 16718, 16696, 17492, 17493, 17494, 17448
1996, 16696, 16718, 16719, 16697, 17494, 17495, 17496, 17450
1997, 16697, 16719, 16720, 16698, 17496, 17497, 17498, 17452
1998, 16698, 16720, 16721, 16699, 17498, 17499, 17500, 17454
1999, 16699, 16721, 16722, 16700, 17500, 17501, 17502, 17456
2000, 16700, 16722, 16723, 16701, 17502, 17503, 17504, 17458
2001, 16701, 16723, 16724, 16702, 17504, 17505, 17506, 17460
2002, 16702, 16724, 1646, 1645, 17506, 17507, 1668, 17462
2003, 1601, 1602, 16725, 16703, 1624, 17508, 17509, 17463
2004, 16703, 16725, 16726, 16704, 17509, 17510, 17511, 17465
2005, 16704, 16726, 16727, 16705, 17511, 17512, 17513, 17467
2006, 16705, 16727, 16728, 16706, 17513, 17514, 17515, 17469
2007, 16706, 16728, 16729, 16707, 17515, 17516, 17517, 17471
2008, 16707, 16729, 16730, 16708, 17517, 17518, 17519, 17473
2009, 16708, 16730, 16731, 16709, 17519, 17520, 17521, 17475
2010, 16709, 16731, 16732, 16710, 17521, 17522, 17523, 17477
2011, 16710, 16732, 16733, 16711, 17523, 17524, 17525, 17479
2012, 16711, 16733, 16734, 16712, 17525, 17526, 17527, 17481
2013, 16712, 16734, 16735, 16713, 17527, 17528, 17529, 17483
2014, 16713, 16735, 16736, 16714, 17529, 17530, 17531, 17485
2015, 16714, 16736, 16737, 16715, 17531, 17532, 17533, 17487
2016, 16715, 16737, 16738, 16716, 17533, 17534, 17535, 17489
2017, 16716, 16738, 16739, 16717, 17535, 17536, 17537, 17491
2018, 16717, 16739, 16740, 16718, 17537, 17538, 17539, 17493
2019, 16718, 16740, 16741, 16719, 17539, 17540, 17541, 17495
2020, 16719, 16741, 16742, 16720, 17541, 17542, 17543, 17497
2021, 16720, 16742, 16743, 16721, 17543, 17544, 17545, 17499
2022, 16721, 16743, 16744, 16722, 17545, 17546, 17547, 17501
2023, 16722, 16744, 16745, 16723, 17547, 17548, 17549, 17503
2024, 16723, 16745, 16746, 16724, 17549, 17550, 17551, 17505
2025, 16724, 16746, 1647, 1646, 17551, 17552, 1669, 17507
2026, 1602, 1603, 16747, 16725, 1625, 17553, 17554, 17508
2027, 16725, 16747, 16748, 16726, 17554, 17555, 17556, 17510
2028, 16726, 16748, 16749, 16727, 17556, 17557, 17558, 17512
2029, 16727, 16749, 16750, 16728, 17558, 17559, 17560, 17514
2030, 16728, 16750, 16751, 16729, 17560, 17561, 17562, 17516
2031, 16729, 16751, 16752, 16730, 17562, 17563, 17564, 17518
2032, 16730, 16752, 16753, 16731, 17564, 17565, 17566, 17520
2033, 16731, 16753, 16754, 16732, 17566, 17567, 17568, 17522
2034, 16732, 16754, 16755, 16733, 17568, 17569, 17570, 17524
2035, 16733, 16755, 16756, 16734, 17570, 17571, 17572, 17526
2036, 16734, 16756, 16757, 16735, 17572, 17573, 17574, 17528
2037, 16735, 16757, 16758, 16736, 17574, 17575, 17576, 17530
2038, 16736, 16758, 16759, 16737, 17576, 17577, 17578, 17532
2039, 16737, 16759, 16760, 16738, 17578, 17579, 17580, 17534
2040, 16738, 16760, 16761, 16739, 17580, 17581, 17582, 17536
2041, 16739, 16761, 16762, 16740, 17582, 17583, 17584, 17538
2042, 16740, 16762, 16763, 16741, 17584, 17585, 17586, 17540
2043, 16741, 16763, 16764, 16742, 17586, 17587, 17588, 17542
2044, 16742, 16764, 16765, 16743, 17588, 17589, 17590, 17544
2045, 16743, 16765, 16766, 16744, 17590, 17591, 17592, 17546
2046, 16744, 16766, 16767, 16745, 17592, 17593, 17594, 17548
2047, 16745, 16767, 16768, 16746, 17594, 17595, 17596, 17550
2048, 16746, 16768, 1648, 1647, 17596, 17597, 1670, 17552
2049, 1603, 1604, 16769, 16747, 1626, 17598, 17599, 17553
2050, 16747, 16769, 16770, 16748, 17599, 17600, 17601, 17555
2051, 16748, 16770, 16771, 16749, 17601, 17602, 17603, 17557
2052, 16749, 16771, 16772, 16750, 17603, 17604, 17605, 17559
2053, 16750, 16772, 16773, 16751, 17605, 17606, 17607, 17561
2054, 16751, 16773, 16774, 16752, 17607, 17608, 17609, 17563
2055, 16752, 16774, 16775, 16753, 17609, 17610, 17611, 17565
2056, 16753, 16775, 16776, 16754, 17611, 17612, 17613, 17567
2057, 16754, 16776, 16777, 16755, 17613, 17614, 17615, 17569
2058, 16755, 16777, 16778, 16756, 17615, 17616, 17617, 17571
2059, 16756, 16778, 16779, 16757, 17617, 17618, 17619, 17573
2060, 16757, 16779, 16780, 16758, 17619, 17620, 17621, 17575
2061, 16758, 16780, 16781, 16759, 17621, 17622, 17623, 17577
2062, 16759, 16781, 16782, 16760, 17623, 17624, 17625, 17579
2063, 16760, 16782, 16783, 16761, 17625, 17626, 17627, 17581
2064, 16761, 16783, 16784, 16762, 17627, 17628, 17629, 17583
2065, 16762, 16784, 16785, 16763, 17629, 17630, 17631, 17585
2066, 16763, 16785, 16786, 16764, 17631, 17632, 17633, 17587
2067, 16764, 16786, 16787, 16765, 17633, 17634, 17635, 17589
2068, 16765, 16787, 16788, 16766, 17635, 17636, 17637, 17591
2069, 16766, 16788, 16789, 16767, 17637, 17638, 17639, 17593
2070, 16767, 16789, 16790, 16768, 17639, 17640, 17641, 17595
2071, 16768, 16790, 1649, 1648, 17641, 17642, 1671, 17597
2072, 1604, 1605, 16791, 16769, 1627, 17643, 17644, 17598
2073, 16769, 16791, 16792, 16770, 17644, 17645, 17646, 17600
2074, 16770, 16792, 16793, 16771, 17646, 17647, 17648, 17602
2075, 16771, 16793, 16794, 16772, 17648, 17649, 17650, 17604
2076, 16772, 16794, 16795, 16773, 17650, 17651, 17652, 17606
2077, 16773, 16795, 16796, 16774, 17652, 17653, 17654, 17608
2078, 16774, 16796, 16797, 16775, 17654, 17655, 17656, 17610
2079, 16775, 16797, 16798, 16776, 17656, 17657, 17658, 17612
2080, 16776, 16798, 16799, 16777, 17658, 17659, 17660, 17614
2081, 16777, 16799, 16800, 16778, 17660, 17661, 17662, 17616
2082, 16778, 16800, 16801, 16779, 17662, 17663, 17664, 17618
2083, 16779, 16801, 16802, 16780, 17664, 17665, 17666, 17620
2084, 16780, 16802, 16803, 16781, 17666, 17667, 17668, 17622
2085, 16781, 16803, 16804, 16782, 17668, 17669, 17670, 17624
2086, 16782, 16804, 16805, 16783, 17670, 17671, 17672, 17626
2087, 16783, 16805, 16806, 16784, 17672, 17673, 17674, 17628
2088, 16784, 16806, 16807, 16785, 17674, 17675, 17676, 17630
2089, 16785, 16807, 16808, 16786, 17676, 17677, 17678, 17632
2090, 16786, 16808, 16809, 16787, 17678, 17679, 17680, 17634
2091, 16787, 16809, 16810, 16788, 17680, 17681, 17682, 17636
2092, 16788, 16810, 16811, 16789, 17682, 17683, 17684, 17638
2093, 16789, 16811, 16812, 16790, 17684, 17685, 17686, 17640
2094, 16790, 16812, 1650, 1649, 17686, 17687, 1672, 17642
2095, 1605, 1606, 16813, 16791, 1628, 17688, 17689, 17643
2096, 16791, 16813, 16814, 16792, 17689, 17690, 17691, 17645
2097, 16792, 16814, 16815, 16793, 17691, 17692, 17693, 17647
2098, 16793, 16815, 16816, 16794, 17693, 17694, 17695, 17649
2099, 16794, 16816, 16817, 16795, 17695, 17696, 17697, 17651
2100, 16795, 16817, 16818, 16796, 17697, 17698, 17699, 17653
2101, 16796, 16818, 16819, 16797, 17699, 17700, 17701, 17655
2102, 16797, 16819, 16820, 16798, 17701, 17702, 17703, 17657
2103, 16798, 16820, 16821, 16799, 17703, 17704, 17705, 17659
2104, 16799, 16821, 16822, 16800, 17705, 17706, 17707, 17661
2105, 16800, 16822, 16823, 16801, 17707, 17708, 17709, 17663
2106, 16801, 16823, 16824, 16802, 17709, 17710, 17711, 17665
2107, 16802, 16824, 16825, 16803, 17711, 17712, 17713, 17667
2108, 16803, 16825, 16826, 16804, 17713, 17714, 17715, 17669
2109, 16804, 16826, 16827, 16805, 17715, 17716, 17717, 17671
2110, 16805, 16827, 16828, 16806, 17717, 17718, 17719, 17673
2111, 16806, 16828, 16829, 16807, 17719, 17720, 17721, 17675
2112, 16807, 16829, 16830, 16808, 17721, 17722, 17723, 17677
2113, 16808, 16830, 16831, 16809, 17723, 17724, 17725, 17679
2114, 16809, 16831, 16832, 16810, 17725, 17726, 17727, 17681
2115, 16810, 16832, 16833, 16811, 17727, 17728, 17729, 17683
2116, 16811, 16833, 16834, 16812, 17729, 17730, 17731, 17685
2117, 16812, 16834, 1651, 1650, 17731, 17732, 1673, 17687
2118, 1606, 1607, 16835, 16813, 1629, 17733, 17734, 17688
2119, 16813, 16835, 16836, 16814, 17734, 17735, 17736, 17690
2120, 16814, 16836, 16837, 16815, 17736, 17737, 17738, 17692
2121, 16815, 16837, 16838, 16816, 17738, 17739, 17740, 17694
2122, 16816, 16838, 16839, 16817, 17740, 17741, 17742, 17696
2123, 16817, 16839, 16840, 16818, 17742, 17743, 17744, 17698
2124, 16818, 16840, 16841, 16819, 17744, 17745, 17746, 17700
2125, 16819, 16841, 16842, 16820, 17746, 17747, 17748, 17702
2126, 16820, 16842, 16843, 16821, 17748, 17749, 17750, 17704
2127, 16821, 16843, 16844, 16822, 17750, 17751, 17752, 17706
2128, 16822, 16844, 16845, 16823, 17752, 17753, 17754, 17708
2129, 16823, 16845, 16846, 16824, 17754, 17755, 17756, 17710
2130, 16824, 16846, 16847, 16825, 17756, 17757, 17758, 17712
2131, 16825, 16847, 16848, 16826, 17758, 17759, 17760, 17714
2132, 16826, 16848, 16849, 16827, 17760, 17761, 17762, 17716
2133, 16827, 16849, 16850, 16828, 17762, 17763, 17764, 17718
2134, 16828, 16850, 16851, 16829, 17764, 17765, 17766, 17720
2135, 16829, 16851, 16852, 16830, 17766, 17767, 17768, 17722
2136, 16830, 16852, 16853, 16831, 17768, 17769, 17770, 17724
2137, 16831, 16853, 16854, 16832, 17770, 17771, 17772, 17726
2138, 16832, 16854, 16855, 16833, 17772, 17773, 17774, 17728
2139, 16833, 16855, 16856, 16834, 17774, 17775, 17776, 17730
2140, 16834, 16856, 1652, 1651, 17776, 17777, 1674, 17732
2141, 1607, 1608, 16857, 16835, 1630, 17778, 17779, 17733
2142, 16835, 16857, 16858, 16836, 17779, 17780, 17781, 17735
2143, 16836, 16858, 16859, 16837, 17781, 17782, 17783, 17737
2144, 16837, 16859, 16860, 16838, 17783, 17784, 17785, 17739
2145, 16838, 16860, 16861, 16839, 17785, 17786, 17787, 17741
2146, 16839, 16861, 16862, 16840, 17787, 17788, 17789, 17743
2147, 16840, 16862, 16863, 16841, 17789, 17790, 17791, 17745
2148, 16841, 16863, 16864, 16842, 17791, 17792, 17793, 17747
2149, 16842, 16864, 16865, 16843, 17793, 17794, 17795, 17749
2150, 16843, 16865, 16866, 16844, 17795, 17796, 17797, 17751
2151, 16844, 16866, 16867, 16845, 17797, 17798, 17799, 17753
2152, 16845, 16867, 16868, 16846, 17799, 17800, 17801, 17755
2153, 16846, 16868, 16869, 16847, 17801, 17802, 17803, 17757
2154, 16847, 16869, 16870, 16848, 17803, 17804, 17805, 17759
2155, 16848, 16870, 16871, 16849, 17805, 17806, 17807, 17761
2156, 16849, 16871, 16872, 16850, 17807, 17808, 17809, 17763
2157, 16850, 16872, 16873, 16851, 17809, 17810, 17811, 17765
2158, 16851, 16873, 16874, 16852, 17811, 17812, 17813, 17767
2159, 16852, 16874, 16875, 16853, 17813, 17814, 17815, 17769
2160, 16853, 16875, 16876, 16854, 17815, 17816, 17817, 17771
2161, 16854, 16876, 16877, 16855, 17817, 17818, 17819, 17773
2162, 16855, 16877, 16878, 16856, 17819, 17820, 17821, 17775
2163, 16856, 16878, 1653, 1652, 17821, 17822, 1675, 17777
2164, 1608, 1609, 16879, 16857, 1631, 17823, 17824, 17778
2165, 16857, 16879, 16880, 16858, 17824, 17825, 17826, 17780
2166, 16858, 16880, 16881, 16859, 17826, 17827, 17828, 17782
2167, 16859, 16881, 16882, 16860, 17828, 17829, 17830, 17784
2168, 16860, 16882, 16883, 16861, 17830, 17831, 17832, 17786
2169, 16861, 16883, 16884, 16862, 17832, 17833, 17834, 17788
2170, 16862, 16884, 16885, 16863, 17834, 17835, 17836, 17790
2171, 16863, 16885, 16886, 16864, 17836, 17837, 17838, 17792
2172, 16864, 16886, 16887, 16865, 17838, 17839, 17840, 17794
2173, 16865, 16887, 16888, 16866, 17840, 17841, 17842, 17796
2174, 16866, 16888, 16889, 16867, 17842, 17843, 17844, 17798
2175, 16867, 16889, 16890, 16868, 17844, 17845, 17846, 17800
2176, 16868, 16890, 16891, 16869, 17846, 17847, 17848, 17802
2177, 16869, 16891, 16892, 16870, 17848, 17849, 17850, 17804
2178, 16870, 16892, 16893, 16871, 17850, 17851, 17852, 17806
2179, 16871, 16893, 16894, 16872, 17852, 17853, 17854, 17808
2180, 16872, 16894, 16895, 16873, 17854, 17855, 17856, 17810
2181, 16873, 16895, 16896, 16874, 17856, 17857, 17858, 17812
2182, 16874, 16896, 16897, 16875, 17858, 17859, 17860, 17814
2183, 16875, 16897, 16898, 16876, 17860, 17861, 17862, 17816
2184, 16876, 16898, 16899, 16877, 17862, 17863, 17864, 17818
2185, 16877, 16899, 16900, 16878, 17864, 17865, 17866, 17820
2186, 16878, 16900, 1654, 1653, 17866, 17867, 1676, 17822
2187, 1609, 1610, 16901, 16879, 1632, 17868, 17869, 17823
2188, 16879, 16901, 16902, 16880, 17869, 17870, 17871, 17825
2189, 16880, 16902, 16903, 16881, 17871, 17872, 17873, 17827
2190, 16881, 16903, 16904, 16882, 17873, 17874, 17875, 17829
2191, 16882, 16904, 16905, 16883, 17875, 17876, 17877, 17831
2192, 16883, 16905, 16906, 16884, 17877, 17878, 17879, 17833
2193, 16884, 16906, 16907, 16885, 17879, 17880, 17881, 17835
2194, 16885, 16907, 16908, 16886, 17881, 17882, 17883, 17837
2195, 16886, 16908, 16909, 16887, 17883, 17884, 17885, 17839
2196, 16887, 16909, 16910, 16888, 17885, 17886, 17887, 17841
2197, 16888, 16910, 16911, 16889, 17887, 17888, 17889, 17843
2198, 16889, 16911, 16912, 16890, 17889, 17890, 17891, 17845
2199, 16890, 16912, 16913, 16891, 17891, 17892, 17893, 17847
2200, 16891, 16913, 16914, 16892, 17893, 17894, 17895, 17849
2201, 16892, 16914, 16915, 16893, 17895, 17896, 17897, 17851
2202, 16893, 16915, 16916, 16894, 17897, 17898, 17899, 17853
2203, 16894, 16916, 16917, 16895, 17899, 17900, 17901, 17855
2204, 16895, 16917, 16918, 16896, 17901, 17902, 17903, 17857
2205, 16896, 16918, 16919, 16897, 17903, 17904, 17905, 17859
2206, 16897, 16919, 16920, 16898, 17905, 17906, 17907, 17861
2207, 16898, 16920, 16921, 16899, 17907, 17908, 17909, 17863
2208, 16899, 16921, 16922, 16900, 17909, 17910, 17911, 17865
2209, 16900, 16922, 1655, 1654, 17911, 17912, 1677, 17867
2210, 1610, 37, 1679, 16901, 1633, 1701, 17913, 17868
2211, 16901, 1679, 1680, 16902, 17913, 1702, 17914, 17870
2212, 16902, 1680, 1681, 16903, 17914, 1703, 17915, 17872
2213, 16903, 1681, 1682, 16904, 17915, 1704, 17916, 17874
2214, 16904, 1682, 1683, 16905, 17916, 1705, 17917, 17876
2215, 16905, 1683, 1684, 16906, 17917, 1706, 17918, 17878
2216, 16906, 1684, 1685, 16907, 17918, 1707, 17919, 17880
2217, 16907, 1685, 1686, 16908, 17919, 1708, 17920, 17882
2218, 16908, 1686, 1687, 16909, 17920, 1709, 17921, 17884
2219, 16909, 1687, 1688, 16910, 17921, 1710, 17922, 17886
2220, 16910, 1688, 1689, 16911, 17922, 1711, 17923, 17888
2221, 16911, 1689, 1690, 16912, 17923, 1712, 17924, 17890
2222, 16912, 1690, 1691, 16913, 17924, 1713, 17925, 17892
2223, 16913, 1691, 1692, 16914, 17925, 1714, 17926, 17894
2224, 16914, 1692, 1693, 16915, 17926, 1715, 17927, 17896
2225, 16915, 1693, 1694, 16916, 17927, 1716, 17928, 17898
2226, 16916, 1694, 1695, 16917, 17928, 1717, 17929, 17900
2227, 16917, 1695, 1696, 16918, 17929, 1718, 17930, 17902
2228, 16918, 1696, 1697, 16919, 17930, 1719, 17931, 17904
2229, 16919, 1697, 1698, 16920, 17931, 1720, 17932, 17906
2230, 16920, 1698, 1699, 16921, 17932, 1721, 17933, 17908
2231, 16921, 1699, 1700, 16922, 17933, 1722, 17934, 17910
2232, 16922, 1700, 38, 1655, 17934, 1723, 1678, 17912
*ELEMENT, type=CPS8, ELSET=Surface43
32174, 35, 1502, 17935, 1724, 1524, 18419, 18420, 1746
32175, 1502, 1503, 17936, 17935, 1525, 18421, 18422, 18419
32176, 1503, 1504, 17937, 17936, 1526, 18423, 18424, 18421
32177, 1504, 1505, 17938, 17937, 1527, 18425, 18426, 18423
32178, 1505, 1506, 17939, 17938, 1528, 18427, 18428, 18425
32179, 1506, 1507, 17940, 17939, 1529, 18429, 18430, 18427
32180, 1507, 1508, 17941, 17940, 1530, 18431, 18432, 18429
32181, 1508, 1509, 17942, 17941, 1531, 18433, 18434, 18431
32182, 1509, 1510, 17943, 17942, 1532, 18435, 18436, 18433
32183, 1510, 1511, 17944, 17943, 1533, 18437, 18438, 18435
32184, 1511, 1512, 17945, 17944, 1534, 18439, 18440, 18437
32185, 1512, 1513, 17946, 17945, 1535, 18441, 18442, 18439
32186, 1513, 1514, 17947, 17946, 1536, 18443, 18444, 18441
32187, 1514, 1515, 17948, 17947, 1537, 18445, 18446, 18443
32188, 1515, 1516, 17949, 17948, 1538, 18447, 18448, 18445
32189, 1516, 1517, 17950, 17949, 1539, 18449, 18450, 18447
32190, 1517, 1518, 17951, 17950, 1540, 18451, 18452, 18449
32191, 1518, 1519, 17952, 17951, 1541, 18453, 18454, 18451
32192, 1519, 1520, 17953, 17952, 1542, 18455, 18456, 18453
32193, 1520, 1521, 17954, 17953, 1543, 18457, 18458, 18455
32194, 1521, 1522, 17955, 17954, 1544, 18459, 18460, 18457
32195, 1522, 1523, 17956, 17955, 1545, 18461, 18462, 18459
32196, 1523, 36, 1769, 17956, 1546, 1791, 18463, 18461
32197, 1724, 17935, 17957, 1725, 18420, 18464, 18465, 1747
32198, 17935, 17936, 17958, 17957, 18422, 18466, 18467, 18464
32199, 17936, 17937, 17959, 17958, 18424, 18468, 18469, 18466
32200, 17937, 17938, 17960, 17959, 18426, 18470, 18471, 18468
32201, 17938, 17939, 17961, 17960, 18428, 18472, 18473, 18470
32202, 17939, 17940, 17962, 17961, 18430, 18474, 18475, 18472
32203, 17940, 17941, 17963, 17962, 18432, 18476, 18477, 18474
32204, 17941, 17942, 17964, 17963, 18434, 18478, 18479, 18476
32205, 17942, 17943, 17965, 17964, 18436, 18480, 18481, 18478
32206, 17943, 17944, 17966, 17965, 18438, 18482, 18483, 18480
32207, 17944, 17945, 17967, 17966, 18440, 18484, 18485, 18482
32208, 17945, 17946, 17968, 17967, 18442, 18486, 18487, 18484
32209, 17946, 17947, 17969, 17968, 18444, 18488, 18489, 18486
32210, 17947, 17948, 17970, 17969, 18446, 18490, 18491, 18488
32211, 17948, 17949, 17971, 17970, 18448, 18492, 18493, 18490
32212, 17949, 17950, 17972, 17971, 18450, 18494, 18495, 18492
32213, 17950, 17951, 17973, 17972, 18452, 18496, 18497, 18494
32214, 17951, 17952, 17974, 17973, 18454, 18498, 18499, 18496
32215, 17952, 17953, 17975, 17974, 18456, 18500, 18501, 18498
32216, 17953, 17954, 17976, 17975, 18458, 18502, 18503, 18500
32217, 17954, 17955, 17977, 17976, 18460, 18504, 18505, 18502
32218, 17955, 17956, 17978, 17977, 18462, 18506, 18507, 18504
32219, 17956, 1769, 1770, 17978, 18463, 1792, 18508, 18506
32220, 1725, 17957, 17979, 1726, 18465, 18509, 18510, 1748
32221, 17957, 17958, 17980, 17979, 18467, 18511, 18512, 18509
32222, 17958, 17959, 17981, 17980, 18469, 18513, 18514, 18511
32223, 17959, 17960, 17982, 17981, 18471, 18515, 18516, 18513
32224, 17960, 17961, 17983, 17982, 18473, 18517, 18518, 18515
32225, 17961, 17962, 17984, 17983, 18475, 18519, 18520, 18517
32226, 17962, 17963, 17985, 17984, 18477, 18521, 18522, 18519
32227, 17963, 17964, 17986, 17985, 18479, 18523, 18524, 18521
32228, 17964, 17965, 17987, 17986, 18481, 18525, 18526, 18523
32229, 17965, 17966, 17988, 17987, 18483, 18527, 18528, 18525
32230, 17966, 17967, 17989, 17988, 18485, 18529, 18530, 18527
32231, 17967, 17968, 17990, 17989, 18487, 18531, 18532, 18529
32232, 17968, 17969, 17991, 17990, 18489, 18533, 18534, 18531
32233, 17969, 17970, 17992, 17991, 18491, 18535, 18536, 18533
32234, 17970, 17971, 17993, 17992, 18493, 18537, 18538, 18535
32235, 17971, 17972, 17994, 17993, 18495, 18539, 18540, 18537
32236, 17972, 17973, 17995, 17994, 18497, 18541, 18542, 18539
32237, 17973, 17974, 17996, 17995, 18499, 18543, 18544, 18541
32238, 17974, 17975, 17997, 17996, 18501, 18545, 18546, 18543
32239, 17975, 17976, 17998, 17997, 18503, 18547, 18548, 18545
32240, 17976, 17977, 17999, 17998, 18505, 18549, 18550, 18547
32241, 17977, 17978, 18000, 17999, 18507, 18551, 18552, 18549
32242, 17978, 1770, 1771, 18000, 18508, 1793, 18553, 18551
32243, 1726, 17979, 18001, 1727, 18510, 18554, 18555, 1749
32244, 17979, 17980, 18002, 18001, 18512, 18556, 18557, 18554
32245, 17980, 17981, 18003, 18002, 18514, 18558, 18559, 18556
32246, 17981, 17982, 18004, 18003, 18516, 18560, 18561, 18558
32247, 17982, 17983, 18005, 18004, 18518, 18562, 18563, 18560
32248, 17983, 17984, 18006, 18005, 18520, 18564, 18565, 18562
32249, 17984, 17985, 18007, 18006, 18522, 18566, 18567, 18564
32250, 17985, 17986, 18008, 18007, 18524, 18568, 18569, 18566
32251, 17986, 17987, 18009, 18008, 18526, 18570, 18571, 18568
32252, 17987, 17988, 18010, 18009, 18528, 18572, 18573, 18570
32253, 17988, 17989, 18011, 18010, 18530, 18574, 18575, 18572
32254, 17989, 17990, 18012, 18011, 18532, 18576, 18577, 18574
32255, 17990, 17991, 18013, 18012, 18534, 18578, 18579, 18576
32256, 17991, 17992, 18014, 18013, 18536, 18580, 18581, 18578
32257, 17992, 17993, 18015, 18014, 18538, 18582, 18583, 18580
32258, 17993, 17994, 18016, 18015, 18540, 18584, 18585, 18582
32259, 17994, 17995, 18017, 18016, 18542, 18586, 18587, 18584
32260, 17995, 17996, 18018, 18017, 18544, 18588, 18589, 18586
32261, 17996, 17997, 18019, 18018, 18546, 18590, 18591, 18588
32262, 17997, 17998, 18020, 18019, 18548, 18592, 18593, 18590
32263, 17998, 17999, 18021, 18020, 18550, 18594, 18595, 18592
32264, 17999, 18000, 18022, 18021, 18552, 18596, 18597, 18594
32265, 18000, 1771, 1772, 18022, 18553, 1794, 18598, 18596
32266, 1727, 18001, 18023, 1728, 18555, 18599, 18600, 1750
32267, 18001, 18002, 18024, 18023, 18557, 18601, 18602, 18599
32268, 18002, 18003, 18025, 18024, 18559, 18603, 18604, 18601
32269, 18003, 18004, 18026, 18025, 18561, 18605, 18606, 18603
32270, 18004, 18005, 18027, 18026, 18563, 18607, 18608, 18605
32271, 18005, 18006, 18028, 18027, 18565, 18609, 18610, 18607
32272, 18006, 18007, 18029, 18028, 18567, 18611, 18612, 18609
32273, 18007, 18008, 18030, 18029, 18569, 18613, 18614, 18611
32274, 18008, 18009, 18031, 18030, 18571, 18615, 18616, 18613
32275, 18009, 18010, 18032, 18031, 18573, 18617, 18618, 18615
32276, 18010, 18011, 18033, 18032, 18575, 18619, 18620, 18617
32277, 18011, 18012, 18034, 18033, 18577, 18621, 18622, 18619
32278, 18012, 18013, 18035, 18034, 18579, 18623, 18624, 18621
32279, 18013, 18014, 18036, 18035, 18581, 18625, 18626, 18623
32280, 18014, 18015, 18037, 18036, 18583, 18627, 18628, 18625
32281, 18015, 18016, 18038, 18037, 18585, 18629, 18630, 18627
32282, 18016, 18017, 18039, 18038, 18587, 18631, 18632, 18629
32283, 18017, 18018, 18040, 18039, 18589, 18633, 18634, 18631
32284, 18018, 18019, 18041, 18040, 18591, 18635, 18636, 18633
32285, 18019, 18020, 18042, 18041, 18593, 18637, 18638, 18635
32286, 18020, 18021, 18043, 18042, 18595, 18639, 18640, 18637
32287, 18021, 18022, 18044, 18043, 18597, 18641, 18642, 18639
32288, 18022, 1772, 1773, 18044, 18598, 1795, 18643, 18641
32289, 1728, 18023, 18045, 1729, 18600, 18644, 18645, 1751
32290, 18023, 18024, 18046, 18045, 18602, 18646, 18647, 18644
32291, 18024, 18025, 18047, 18046, 18604, 18648, 18649, 18646
32292, 18025, 18026, 18048, 18047, 18606, 18650, 18651, 18648
32293, 18026, 18027, 18049, 18048, 18608, 18652, 18653, 18650
32294, 18027, 18028, 18050, 18049, 18610, 18654, 18655, 18652
32295, 18028, 18029, 18051, 18050, 18612, 18656, 18657, 18654
32296, 18029, 18030, 18052, 18051, 18614, 18658, 18659, 18656
32297, 18030, 18031, 18053, 18052, 18616, 18660, 18661, 18658
32298, 18031, 18032, 18054, 18053, 18618, 18662, 18663, 18660
32299, 18032, 18033, 18055, 18054, 18620, 18664, 18665, 18662
32300, 18033, 18034, 18056, 18055, 18622, 18666, 18667, 18664
32301, 18034, 18035, 18057, 18056, 18624, 18668, 18669, 18666
32302, 18035, 18036, 18058, 18057, 18626, 18670, 18671, 18668
32303, 18036, 18037, 18059, 18058, 18628, 18672, 18673, 18670
32304, 18037, 18038, 18060, 18059, 18630, 18674, 18675, 18672
32305, 18038, 18039, 18061, 18060, 18632, 18676, 18677, 18674
32306, 18039, 18040, 18062, 18061, 18634, 18678, 18679, 18676
32307, 18040, 18041, 18063, 18062, 18636, 18680, 18681, 18678
32308, 18041, 18042, 18064, 18063, 18638, 18682, 18683, 18680
32309, 18042, 18043, 18065, 18064, 18640, 18684, 18685, 18682
32310, 18043, 18044, 18066, 18065, 18642, 18686, 18687, 18684
32311, 18044, 1773, 1774, 18066, 18643, 1796, 18688, 18686
32312, 1729, 18045, 18067, 1730, 18645, 18689, 18690, 1752
32313, 18045, 18046, 18068, 18067, 18647, 18691, 18692, 18689
32314, 18046, 18047, 18069, 18068, 18649, 18693, 18694, 18691
32315, 18047, 18048, 18070, 18069, 18651, 18695, 18696, 18693
32316, 18048, 18049, 18071, 18070, 18653, 18697, 18698, 18695
32317, 18049, 18050, 18072, 18071, 18655, 18699, 18700, 18697
32318, 18050, 18051, 18073, 18072, 18657, 18701, 18702, 18699
32319, 18051, 18052, 18074, 18073, 18659, 18703, 18704, 18701
32320, 18052, 18053, 18075, 18074, 18661, 18705, 18706, 18703
32321, 18053, 18054, 18076, 18075, 18663, 18707, 18708, 18705
32322, 18054, 18055, 18077, 18076, 18665, 18709, 18710, 18707
32323, 18055, 18056, 18078, 18077, 18667, 18711, 18712, 18709
32324, 18056, 18057, 18079, 18078, 18669, 18713, 18714, 18711
32325, 18057, 18058, 18080, 18079, 18671, 18715, 18716, 18713
32326, 18058, 18059, 18081, 18080, 18673, 18717, 18718, 18715
32327, 18059, 18060, 18082, 18081, 18675, 18719, 18720, 18717
32328, 18060, 18061, 18083, 18082, 18677, 18721, 18722, 18719
32329, 18061, 18062, 18084, 18083, 18679, 18723, 18724, 18721
32330, 18062, 18063, 18085, 18084, 18681, 18725, 18726, 18723
32331, 18063, 18064, 18086, 18085, 18683, 18727, 18728, 18725
32332, 18064, 18065, 18087, 18086, 18685, 18729, 18730, 18727
32333, 18065, 18066, 18088, 18087, 18687, 18731, 18732, 18729
32334, 18066, 1774, 1775, 18088, 18688, 1797, 18733, 18731
32335, 1730, 18067, 18089, 1731, 18690, 18734, 18735, 1753
32336, 18067, 18068, 18090, 18089, 18692, 18736, 18737, 18734
32337, 18068, 18069, 18091, 18090, 18694, 18738, 18739, 18736
32338, 18069, 18070, 18092, 18091, 18696, 18740, 18741, 18738
32339, 18070, 18071, 18093, 18092, 18698, 18742, 18743, 18740
32340, 18071, 18072, 18094, 18093, 18700, 18744, 18745, 18742
32341, 18072, 18073, 18095, 18094, 18702, 18746, 18747, 18744
32342, 18073, 18074, 18096, 18095, 18704, 18748, 18749, 18746
32343, 18074, 18075, 18097, 18096, 18706, 18750, 18751, 18748
32344, 18075, 18076, 18098, 18097, 18708, 18752, 18753, 18750
32345, 18076, 18077, 18099, 18098, 18710, 18754, 18755, 18752
32346, 18077, 18078, 18100, 18099, 18712, 18756, 18757, 18754
32347, 18078, 18079, 18101, 18100, 18714, 18758, 18759, 18756
32348, 18079, 18080, 18102, 18101, 18716, 18760, 18761, 18758
32349, 18080, 18081, 18103, 18102, 18718, 18762, 18763, 18760
32350, 18081, 18082, 18104, 18103, 18720, 18764, 18765, 18762
32351, 18082, 18083, 18105, 18104, 18722, 18766, 18767, 18764
32352, 18083, 18084, 18106, 18105, 18724, 18768, 18769, 18766
32353, 18084, 18085, 18107, 18106, 18726, 18770, 18771, 18768
32354, 18085, 18086, 18108, 18107, 18728, 18772, 18773, 18770
32355, 18086, 18087, 18109, 18108, 18730, 18774, 18775, 18772
32356, 18087, 18088, 18110, 18109, 18732, 18776, 18777, 18774
32357, 18088, 1775, 1776, 18110, 18733, 1798, 18778, 18776
32358, 1731, 18089, 18111, 1732, 18735, 18779, 18780, 1754
32359, 18089, 18090, 18112, 18111, 18737, 18781, 18782, 18779
32360, 18090, 18091, 18113, 18112, 18739, 18783, 18784, 18781
32361, 18091, 18092, 18114, 18113, 18741, 18785, 18786, 18783
32362, 18092, 18093, 18115, 18114, 18743, 18787, 18788, 18785
32363, 18093, 18094, 18116, 18115, 18745, 18789, 18790, 18787
32364, 18094, 18095, 18117, 18116, 18747, 18791, 18792, 18789
32365, 18095, 18096, 18118, 18117, 18749, 18793, 18794, 18791
32366, 18096, 18097, 18119, 18118, 18751, 18795, 18796, 18793
32367, 18097, 18098, 18120, 18119, 18753, 18797, 18798, 18795
32368, 18098, 18099, 18121, 18120, 18755, 18799, 18800, 18797
32369, 18099, 18100, 18122, 18121, 18757, 18801, 18802, 18799
32370, 18100, 18101, 18123, 18122, 18759, 18803, 18804, 18801
32371, 18101, 18102, 18124, 18123, 18761, 18805, 18806, 18803
32372, 18102, 18103, 18125, 18124, 18763, 18807, 18808, 18805
32373, 18103, 18104, 18126, 18125, 18765, 18809, 18810, 18807
32374, 18104, 18105, 18127, 18126, 18767, 18811, 18812, 18809
32375, 18105, 18106, 18128, 18127, 18769, 18813, 18814, 18811
32376, 18106, 18107, 18129, 18128, 18771, 18815, 18816, 18813
32377, 18107, 18108, 18130, 18129, 18773, 18817, 18818, 18815
32378, 18108, 18109, 18131, 18130, 18775, 18819, 18820, 18817
32379, 18109, 18110, 18132, 18131, 18777, 18821, 18822, 18819
32380, 18110, 1776, 1777, 18132, 18778, 1799, 18823, 18821
32381, 1732, 18111, 18133, 1733, 18780, 18824, 18825, 1755
32382, 18111, 18112, 18134, 18133, 18782, 18826, 18827, 18824
32383, 18112, 18113, 18135, 18134, 18784, 18828, 18829, 18826
32384, 18113, 18114, 18136, 18135, 18786, 18830, 18831, 18828
32385, 18114, 18115, 18137, 18136, 18788, 18832, 18833, 18830
32386, 18115, 18116, 18138, 18137, 18790, 18834, 18835, 18832
32387, 18116, 18117, 18139, 18138, 18792, 18836, 18837, 18834
32388, 18117, 18118, 18140, 18139, 18794, 18838, 18839, 18836
32389, 18118, 18119, 18141, 18140, 18796, 18840, 18841, 18838
32390, 18119, 18120, 18142, 18141, 18798, 18842, 18843, 18840
32391, 18120, 18121, 18143, 18142, 18800, 18844, 18845, 18842
32392, 18121, 18122, 18144, 18143, 18802, 18846, 18847, 18844
32393, 18122, 18123, 18145, 18144, 18804, 18848, 18849, 18846
32394, 18123, 18124, 18146, 18145, 18806, 18850, 18851, 18848
32395, 18124, 18125, 18147, 18146, 18808, 18852, 18853, 18850
32396, 18125, 18126, 18148, 18147, 18810, 18854, 18855, 18852
32397, 18126, 18127, 18149, 18148, 18812, 18856, 18857, 18854
32398, 18127, 18128, 18150, 18149, 18814, 18858, 18859, 18856
32399, 18128, 18129, 18151, 18150, 18816, 18860, 18861, 18858
32400, 18129, 18130, 18152, 18151, 18818, 18862, 18863, 18860
32401, 18130, 18131, 18153, 18152, 18820, 18864, 18865, 18862
32402, 18131, 18132, 18154, 18153, 18822, 18866, 18867, 18864
32403, 18132, 1777, 1778, 18154, 18823, 1800, 18868, 18866
32404, 1733, 18133, 18155, 1734, 18825, 18869, 18870, 1756
32405, 18133, 18134, 18156, 18155, 18827, 18871, 18872, 18869
32406, 18134, 18135, 18157, 18156, 18829, 18873, 18874, 18871
32407, 18135, 18136, 18158, 18157, 18831, 18875, 18876, 18873
32408, 18136, 18137, 18159, 18158, 18833, 18877, 18878, 18875
32409, 18137, 18138, 18160, 18159, 18835, 18879, 18880, 18877
32410, 18138, 18139, 18161, 18160, 18837, 18881, 18882, 18879
32411, 18139, 18140, 18162, 18161, 18839, 18883, 18884, 18881
32412, 18140, 18141, 18163, 18162, 18841, 18885, 18886, 18883
32413, 18141, 18142, 18164, 18163, 18843, 18887, 18888, 18885
32414, 18142, 18143, 18165, 18164, 18845, 18889, 18890, 18887
32415, 18143, 18144, 18166, 18165, 18847, 18891, 18892, 18889
32416, 18144, 18145, 18167, 18166, 18849, 18893, 18894, 18891
32417, 18145, 18146, 18168, 18167, 18851, 18895, 18896, 18893
32418, 18146, 18147, 18169, 18168, 18853, 18897, 18898, 18895
32419, 18147, 18148, 18170, 18169, 18855, 18899, 18900, 18897
32420, 18148, 18149, 18171, 18170, 18857, 18901, 18902, 18899
32421, 18149, 18150, 18172, 18171, 18859, 18903, 18904, 18901
32422, 18150, 18151, 18173, 18172, 18861, 18905, 18906, 18903
32423, 18151, 18152, 18174, 18173, 18863, 18907, 18908, 18905
32424, 18152, 18153, 18175, 18174, 18865, 18909, 18910, 18907
32425, 18153, 18154, 18176, 18175, 18867, 18911, 18912, 18909
32426, 18154, 1778, 1779, 18176, 18868, 1801, 18913, 18911
32427, 1734, 18155, 18177, 1735, 18870, 18914, 18915, 1757
32428, 18155, 18156, 18178, 18177, 18872, 18916, 18917, 18914
32429, 18156, 18157, 18179, 18178, 18874, 18918, 18919, 18916
32430, 18157, 18158, 18180, 18179, 18876, 18920, 18921, 18918
32431, 18158, 18159, 18181, 18180, 18878, 18922, 18923, 18920
32432, 18159, 18160, 18182, 18181, 18880, 18924, 18925, 18922
32433, 18160, 18161, 18183, 18182, 18882, 18926, 18927, 18924
32434, 18161, 18162, 18184, 18183, 18884, 18928, 18929, 18926
32435, 18162, 18163, 18185, 18184, 18886, 18930, 18931, 18928
32436, 18163, 18164, 18186, 18185, 18888, 18932, 18933, 18930
32437, 18164, 18165, 18187, 18186, 18890, 18934, 18935, 18932
32438, 18165, 18166, 18188, 18187, 18892, 18936, 18937, 18934
32439, 18166, 18167, 18189, 18188, 18894, 18938, 18939, 18936
32440, 18167, 18168, 18190, 18189, 18896, 18940, 18941, 18938
32441, 18168, 18169, 18191, 18190, 18898, 18942, 18943, 18940
32442, 18169, 18170, 18192, 18191, 18900, 18944, 18945, 18942
32443, 18170, 18171, 18193, 18192, 18902, 18946, 18947, 18944
32444, 18171, 18172, 18194, 18193, 18904, 18948, 18949, 18946
32445, 18172, 18173, 18195, 18194, 18906, 18950, 18951, 18948
32446, 18173, 18174, 18196, 18195, 18908, 18952, 18953, 18950
32447, 18174, 18175, 18197, 18196, 18910, 18954, 18955, 18952
32448, 18175, 18176, 18198, 18197, 18912, 18956, 18957, 18954
32449, 18176, 1779, 1780, 18198, 18913, 1802, 18958, 18956
32450, 1735, 18177, 18199, 1736, 18915, 18959, 18960, 1758
32451, 18177, 18178, 18200, 18199, 18917, 18961, 18962, 18959
32452, 18178, 18179, 18201, 18200, 18919, 18963, 18964, 18961
32453, 18179, 18180, 18202, 18201, 18921, 18965, 18966, 18963
32454, 18180, 18181, 18203, 18202, 18923, 18967, 18968, 18965
32455, 18181, 18182, 18204, 18203, 18925, 18969, 18970, 18967
32456, 18182, 18183, 18205, 18204, 18927, 18971, 18972, 18969
32457, 18183, 18184, 18206, 18205, 18929, 18973, 18974, 18971
32458, 18184, 18185, 18207, 18206, 18931, 18975, 18976, 18973
32459, 18185, 18186, 18208, 18207, 18933, 18977, 18978, 18975
32460, 18186, 18187, 18209, 18208, 18935, 18979, 18980, 18977
32461, 18187, 18188, 18210, 18209, 18937, 18981, 18982, 18979
32462, 18188, 18189, 18211, 18210, 18939, 18983, 18984, 18981
32463, 18189, 18190, 18212, 18211, 18941, 18985, 18986, 18983
32464, 18190, 18191, 18213, 18212, 18943, 18987, 18988, 18985
32465, 18191, 18192, 18214, 18213, 18945, 18989, 18990, 18987
32466, 18192, 18193, 18215, 18214, 18947, 18991, 18992, 18989
32467, 18193, 18194, 18216, 18215, 18949, 18993, 18994, 18991
32468, 18194, 18195, 18217, 18216, 18951, 18995, 18996, 18993
32469, 18195, 18196, 18218, 18217, 18953, 18997, 18998, 18995
32470, 18196, 18197, 18219, 18218, 18955, 18999, 19000, 18997
32471, 18197, 18198, 18220, 18219, 18957, 19001, 19002, 18999
32472, 18198, 1780, 1781, 18220, 18958, 1803, 19003, 19001
32473, 1736, 18199, 18221, 1737, 18960, 19004, 19005, 1759
32474, 18199, 18200, 18222, 18221, 18962, 19006, 19007, 19004
32475, 18200, 18201, 18223, 18222, 18964, 19008, 19009, 19006
32476, 18201, 18202, 18224, 18223, 18966, 19010, 19011, 19008
32477, 18202, 18203, 18225, 18224, 18968, 19012, 19013, 19010
32478, 18203, 18204, 18226, 18225, 18970, 19014, 19015, 19012
32479, 18204, 18205, 18227, 18226, 18972, 19016, 19017, 19014
32480, 18205, 18206, 18228, 18227, 18974, 19018, 19019, 19016
32481, 18206, 18207, 18229, 18228, 18976, 19020, 19021, 19018
32482, 18207, 18208, 18230, 18229, 18978, 19022, 19023, 19020
32483, 18208, 18209, 18231, 18230, 18980, 19024, 19025, 19022
32484, 18209, 18210, 18232, 18231, 18982, 19026, 19027, 19024
32485, 18210, 18211, 18233, 18232, 18984, 19028, 19029, 19026
32486, 18211, 18212, 18234, 18233, 18986, 19030, 19031, 19028
32487, 18212, 18213, 18235, 18234, 18988, 19032, 19033, 19030
32488, 18213, 18214, 18236, 18235, 18990, 19034, 19035, 19032
32489, 18214, 18215, 18237, 18236, 18992, 19036, 19037, 19034
32490, 18215, 18216, 18238, 18237, 18994, 19038, 19039, 19036
32491, 18216, 18217, 18239, 18238, 18996, 19040, 19041, 19038
32492, 18217, 18218, 18240, 18239, 18998, 19042, 19043, 19040
32493, 18218, 18219, 18241, 18240, 19000, 19044, 19045, 19042
32494, 18219, 18220, 18242, 18241, 19002, 19046, 19047, 19044
32495, 18220, 1781, 1782, 18242, 19003, 1804, 19048, 19046
32496, 1737, 18221, 18243, 1738, 19005, 19049, 19050, 1760
32497, 18221, 18222, 18244, 18243, 19007, 19051, 19052, 19049
32498, 18222, 18223, 18245, 18244, 19009, 19053, 19054, 19051
32499, 18223, 18224, 18246, 18245, 19011, 19055, 19056, 19053
32500, 18224, 18225, 18247, 18246, 19013, 19057, 19058, 19055
32501, 18225, 18226, 18248, 18247, 19015, 19059, 19060, 19057
32502, 18226, 18227, 18249, 18248, 19017, 19061, 19062, 19059
32503, 18227, 18228, 18250, 18249, 19019, 19063, 19064, 19061
32504, 18228, 18229, 18251, 18250, 19021, 19065, 19066, 19063
32505, 18229, 18230, 18252, 18251, 19023, 19067, 19068, 19065
32506, 18230, 18231, 18253, 18252, 19025, 19069, 19070, 19067
32507, 18231, 18232, 18254, 18253, 19027, 19071, 19072, 19069
32508, 18232, 18233, 18255, 18254, 19029, 19073, 19074, 19071
32509, 18233, 18234, 18256, 18255, 19031, 19075, 19076, 19073
32510, 18234, 18235, 18257, 18256, 19033, 19077, 19078, 19075
32511, 18235, 18236, 18258, 18257, 19035, 19079, 19080, 19077
32512, 18236, 18237, 18259, 18258, 19037, 19081, 19082, 19079
32513, 18237, 18238, 18260, 18259, 19039, 19083, 19084, 19081
32514, 18238, 18239, 18261, 18260, 19041, 19085, 19086, 19083
32515, 18239, 18240, 18262, 18261, 19043, 19087, 19088, 19085
32516, 18240, 18241, 18263, 18262, 19045, 19089, 19090, 19087
32517, 18241, 18242, 18264, 18263, 19047, 19091, 19092, 19089
32518, 18242, 1782, 1783, 18264, 19048, 1805, 19093, 19091
32519, 1738, 18243, 18265, 1739, 19050, 19094, 19095, 1761
32520, 18243, 18244, 18266, 18265, 19052, 19096, 19097, 19094
32521, 18244, 18245, 18267, 18266, 19054, 19098, 19099, 19096
32522, 18245, 18246, 18268, 18267, 19056, 19100, 19101, 19098
32523, 18246, 18247, 18269, 18268, 19058, 19102, 19103, 19100
32524, 18247, 18248, 18270, 18269, 19060, 19104, 19105, 19102
32525, 18248, 18249, 18271, 18270, 19062, 19106, 19107, 19104
32526, 18249, 18250, 18272, 18271, 19064, 19108, 19109, 19106
32527, 18250, 18251, 18273, 18272, 19066, 19110, 19111, 19108
32528, 18251, 18252, 18274, 18273, 19068, 19112, 19113, 19110
32529, 18252, 18253, 18275, 18274, 19070, 19114, 19115, 19112
32530, 18253, 18254, 18276, 18275, 19072, 19116, 19117, 19114
32531, 18254, 18255, 18277, 18276, 19074, 19118, 19119, 19116
32532, 18255, 18256, 18278, 18277, 19076, 19120, 19121, 19118
32533, 18256, 18257, 18279, 18278, 19078, 19122, 19123, 19120
32534, 18257, 18258, 18280, 18279, 19080, 19124, 19125, 19122
32535, 18258, 18259, 18281, 18280, 19082, 19126, 19127, 19124
32536, 18259, 18260, 18282, 18281, 19084, 19128, 19129, 19126
