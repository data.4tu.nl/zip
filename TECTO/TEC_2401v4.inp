99679, 2.2333333333333, 1.625, 0.22727272727273
99680, 2.2166666666667, 1.65, 0.22727272727273
99681, 2.2333333333333, 1.65, 0.20454545454545
99682, 2.2333333333333, 1.625, 0.18181818181818
99683, 2.2166666666667, 1.65, 0.18181818181818
99684, 2.2333333333333, 1.65, 0.15909090909091
99685, 2.2333333333333, 1.625, 0.13636363636364
99686, 2.2166666666667, 1.65, 0.13636363636364
99687, 2.2333333333333, 1.65, 0.11363636363636
99688, 2.2333333333333, 1.625, 0.090909090909091
99689, 2.2166666666667, 1.65, 0.090909090909091
99690, 2.2333333333333, 1.65, 0.068181818181818
99691, 2.2333333333333, 1.625, 0.045454545454545
99692, 2.2166666666667, 1.65, 0.045454545454545
99693, 2.2333333333333, 1.65, 0.022727272727273
99694, 2.2333333333333, 1.675, 0.45454545454545
99695, 2.2333333333333, 1.675, 0.40909090909091
99696, 2.2333333333333, 1.675, 0.36363636363636
99697, 2.2333333333333, 1.675, 0.31818181818182
99698, 2.2333333333333, 1.675, 0.27272727272727
99699, 2.2333333333333, 1.675, 0.22727272727273
99700, 2.2333333333333, 1.675, 0.18181818181818
99701, 2.2333333333333, 1.675, 0.13636363636364
99702, 2.2333333333333, 1.675, 0.090909090909091
99703, 2.2333333333333, 1.675, 0.045454545454545
99704, 2.2666666666667, 1.55, 0.47727272727273
99705, 2.2666666666667, 1.525, 0.45454545454545
99706, 2.25, 1.55, 0.45454545454545
99707, 2.2666666666667, 1.55, 0.43181818181818
99708, 2.2666666666667, 1.525, 0.40909090909091
99709, 2.25, 1.55, 0.40909090909091
99710, 2.2666666666667, 1.55, 0.38636363636364
99711, 2.2666666666667, 1.525, 0.36363636363636
99712, 2.25, 1.55, 0.36363636363636
99713, 2.2666666666667, 1.55, 0.34090909090909
99714, 2.2666666666667, 1.525, 0.31818181818182
99715, 2.25, 1.55, 0.31818181818182
99716, 2.2666666666667, 1.55, 0.29545454545455
99717, 2.2666666666667, 1.525, 0.27272727272727
99718, 2.25, 1.55, 0.27272727272727
99719, 2.2666666666667, 1.55, 0.25
99720, 2.2666666666667, 1.525, 0.22727272727273
99721, 2.25, 1.55, 0.22727272727273
99722, 2.2666666666667, 1.55, 0.20454545454545
99723, 2.2666666666667, 1.525, 0.18181818181818
99724, 2.25, 1.55, 0.18181818181818
99725, 2.2666666666667, 1.55, 0.15909090909091
99726, 2.2666666666667, 1.525, 0.13636363636364
99727, 2.25, 1.55, 0.13636363636364
99728, 2.2666666666667, 1.55, 0.11363636363636
99729, 2.2666666666667, 1.525, 0.090909090909091
99730, 2.25, 1.55, 0.090909090909091
99731, 2.2666666666667, 1.55, 0.068181818181818
99732, 2.2666666666667, 1.525, 0.045454545454545
99733, 2.25, 1.55, 0.045454545454545
99734, 2.2666666666667, 1.55, 0.022727272727273
99735, 2.2666666666667, 1.6, 0.47727272727273
99736, 2.2666666666667, 1.575, 0.45454545454545
99737, 2.25, 1.6, 0.45454545454545
99738, 2.2666666666667, 1.6, 0.43181818181818
99739, 2.2666666666667, 1.575, 0.40909090909091
99740, 2.25, 1.6, 0.40909090909091
99741, 2.2666666666667, 1.6, 0.38636363636364
99742, 2.2666666666667, 1.575, 0.36363636363636
99743, 2.25, 1.6, 0.36363636363636
99744, 2.2666666666667, 1.6, 0.34090909090909
99745, 2.2666666666667, 1.575, 0.31818181818182
99746, 2.25, 1.6, 0.31818181818182
99747, 2.2666666666667, 1.6, 0.29545454545455
99748, 2.2666666666667, 1.575, 0.27272727272727
99749, 2.25, 1.6, 0.27272727272727
99750, 2.2666666666667, 1.6, 0.25
99751, 2.2666666666667, 1.575, 0.22727272727273
99752, 2.25, 1.6, 0.22727272727273
99753, 2.2666666666667, 1.6, 0.20454545454545
99754, 2.2666666666667, 1.575, 0.18181818181818
99755, 2.25, 1.6, 0.18181818181818
99756, 2.2666666666667, 1.6, 0.15909090909091
99757, 2.2666666666667, 1.575, 0.13636363636364
99758, 2.25, 1.6, 0.13636363636364
99759, 2.2666666666667, 1.6, 0.11363636363636
99760, 2.2666666666667, 1.575, 0.090909090909091
99761, 2.25, 1.6, 0.090909090909091
99762, 2.2666666666667, 1.6, 0.068181818181818
99763, 2.2666666666667, 1.575, 0.045454545454545
99764, 2.25, 1.6, 0.045454545454545
99765, 2.2666666666667, 1.6, 0.022727272727273
99766, 2.2666666666667, 1.65, 0.47727272727273
99767, 2.2666666666667, 1.625, 0.45454545454545
99768, 2.25, 1.65, 0.45454545454545
99769, 2.2666666666667, 1.65, 0.43181818181818
99770, 2.2666666666667, 1.625, 0.40909090909091
99771, 2.25, 1.65, 0.40909090909091
99772, 2.2666666666667, 1.65, 0.38636363636364
99773, 2.2666666666667, 1.625, 0.36363636363636
99774, 2.25, 1.65, 0.36363636363636
99775, 2.2666666666667, 1.65, 0.34090909090909
99776, 2.2666666666667, 1.625, 0.31818181818182
99777, 2.25, 1.65, 0.31818181818182
99778, 2.2666666666667, 1.65, 0.29545454545455
99779, 2.2666666666667, 1.625, 0.27272727272727
99780, 2.25, 1.65, 0.27272727272727
99781, 2.2666666666667, 1.65, 0.25
99782, 2.2666666666667, 1.625, 0.22727272727273
99783, 2.25, 1.65, 0.22727272727273
99784, 2.2666666666667, 1.65, 0.20454545454545
99785, 2.2666666666667, 1.625, 0.18181818181818
99786, 2.25, 1.65, 0.18181818181818
99787, 2.2666666666667, 1.65, 0.15909090909091
99788, 2.2666666666667, 1.625, 0.13636363636364
99789, 2.25, 1.65, 0.13636363636364
99790, 2.2666666666667, 1.65, 0.11363636363636
99791, 2.2666666666667, 1.625, 0.090909090909091
99792, 2.25, 1.65, 0.090909090909091
99793, 2.2666666666667, 1.65, 0.068181818181818
99794, 2.2666666666667, 1.625, 0.045454545454545
99795, 2.25, 1.65, 0.045454545454545
99796, 2.2666666666667, 1.65, 0.022727272727273
99797, 2.2666666666667, 1.675, 0.45454545454545
99798, 2.2666666666667, 1.675, 0.40909090909091
99799, 2.2666666666667, 1.675, 0.36363636363636
99800, 2.2666666666667, 1.675, 0.31818181818182
99801, 2.2666666666667, 1.675, 0.27272727272727
99802, 2.2666666666667, 1.675, 0.22727272727273
99803, 2.2666666666667, 1.675, 0.18181818181818
99804, 2.2666666666667, 1.675, 0.13636363636364
99805, 2.2666666666667, 1.675, 0.090909090909091
99806, 2.2666666666667, 1.675, 0.045454545454545
99807, 2.2833333333333, 1.55, 0.45454545454545
99808, 2.2833333333333, 1.55, 0.40909090909091
99809, 2.2833333333333, 1.55, 0.36363636363636
99810, 2.2833333333333, 1.55, 0.31818181818182
99811, 2.2833333333333, 1.55, 0.27272727272727
99812, 2.2833333333333, 1.55, 0.22727272727273
99813, 2.2833333333333, 1.55, 0.18181818181818
99814, 2.2833333333333, 1.55, 0.13636363636364
99815, 2.2833333333333, 1.55, 0.090909090909091
99816, 2.2833333333333, 1.55, 0.045454545454545
99817, 2.2833333333333, 1.6, 0.45454545454545
99818, 2.2833333333333, 1.6, 0.40909090909091
99819, 2.2833333333333, 1.6, 0.36363636363636
99820, 2.2833333333333, 1.6, 0.31818181818182
99821, 2.2833333333333, 1.6, 0.27272727272727
99822, 2.2833333333333, 1.6, 0.22727272727273
99823, 2.2833333333333, 1.6, 0.18181818181818
99824, 2.2833333333333, 1.6, 0.13636363636364
99825, 2.2833333333333, 1.6, 0.090909090909091
99826, 2.2833333333333, 1.6, 0.045454545454545
99827, 2.2833333333333, 1.65, 0.45454545454545
99828, 2.2833333333333, 1.65, 0.40909090909091
99829, 2.2833333333333, 1.65, 0.36363636363636
99830, 2.2833333333333, 1.65, 0.31818181818182
99831, 2.2833333333333, 1.65, 0.27272727272727
99832, 2.2833333333333, 1.65, 0.22727272727273
99833, 2.2833333333333, 1.65, 0.18181818181818
99834, 2.2833333333333, 1.65, 0.13636363636364
99835, 2.2833333333333, 1.65, 0.090909090909091
99836, 2.2833333333333, 1.65, 0.045454545454545
99837, 2.2333333333333, 1.4333333333333, 0.45454545454545
99838, 2.2333333333333, 1.4333333333333, 0.40909090909091
99839, 2.2333333333333, 1.4333333333333, 0.36363636363636
99840, 2.2333333333333, 1.4333333333333, 0.31818181818182
99841, 2.2333333333333, 1.4333333333333, 0.27272727272727
99842, 2.2333333333333, 1.4333333333333, 0.22727272727273
99843, 2.2333333333333, 1.4333333333333, 0.18181818181818
99844, 2.2333333333333, 1.4333333333333, 0.13636363636364
99845, 2.2333333333333, 1.4333333333333, 0.090909090909091
99846, 2.2333333333333, 1.4333333333333, 0.045454545454545
99847, 2.2333333333333, 1.4666666666667, 0.45454545454545
99848, 2.2333333333333, 1.4666666666667, 0.40909090909091
99849, 2.2333333333333, 1.4666666666667, 0.36363636363636
99850, 2.2333333333333, 1.4666666666667, 0.31818181818182
99851, 2.2333333333333, 1.4666666666667, 0.27272727272727
99852, 2.2333333333333, 1.4666666666667, 0.22727272727273
99853, 2.2333333333333, 1.4666666666667, 0.18181818181818
99854, 2.2333333333333, 1.4666666666667, 0.13636363636364
99855, 2.2333333333333, 1.4666666666667, 0.090909090909091
99856, 2.2333333333333, 1.4666666666667, 0.045454545454545
99857, 2.2666666666667, 1.4333333333333, 0.45454545454545
99858, 2.2666666666667, 1.4333333333333, 0.40909090909091
99859, 2.2666666666667, 1.4333333333333, 0.36363636363636
99860, 2.2666666666667, 1.4333333333333, 0.31818181818182
99861, 2.2666666666667, 1.4333333333333, 0.27272727272727
99862, 2.2666666666667, 1.4333333333333, 0.22727272727273
99863, 2.2666666666667, 1.4333333333333, 0.18181818181818
99864, 2.2666666666667, 1.4333333333333, 0.13636363636364
99865, 2.2666666666667, 1.4333333333333, 0.090909090909091
99866, 2.2666666666667, 1.4333333333333, 0.045454545454545
99867, 2.2666666666667, 1.4666666666667, 0.45454545454545
99868, 2.2666666666667, 1.4666666666667, 0.40909090909091
99869, 2.2666666666667, 1.4666666666667, 0.36363636363636
99870, 2.2666666666667, 1.4666666666667, 0.31818181818182
99871, 2.2666666666667, 1.4666666666667, 0.27272727272727
99872, 2.2666666666667, 1.4666666666667, 0.22727272727273
99873, 2.2666666666667, 1.4666666666667, 0.18181818181818
99874, 2.2666666666667, 1.4666666666667, 0.13636363636364
99875, 2.2666666666667, 1.4666666666667, 0.090909090909091
99876, 2.2666666666667, 1.4666666666667, 0.045454545454545
99877, 2.2333333333333, 1.4333333333333, 0.47727272727273
99878, 2.2333333333333, 1.4166666666667, 0.45454545454545
99879, 2.2166666666667, 1.4333333333333, 0.45454545454545
99880, 2.2333333333333, 1.4333333333333, 0.43181818181818
99881, 2.2333333333333, 1.4166666666667, 0.40909090909091
99882, 2.2166666666667, 1.4333333333333, 0.40909090909091
99883, 2.2333333333333, 1.4333333333333, 0.38636363636364
99884, 2.2333333333333, 1.4166666666667, 0.36363636363636
99885, 2.2166666666667, 1.4333333333333, 0.36363636363636
99886, 2.2333333333333, 1.4333333333333, 0.34090909090909
99887, 2.2333333333333, 1.4166666666667, 0.31818181818182
99888, 2.2166666666667, 1.4333333333333, 0.31818181818182
99889, 2.2333333333333, 1.4333333333333, 0.29545454545455
99890, 2.2333333333333, 1.4166666666667, 0.27272727272727
99891, 2.2166666666667, 1.4333333333333, 0.27272727272727
99892, 2.2333333333333, 1.4333333333333, 0.25
99893, 2.2333333333333, 1.4166666666667, 0.22727272727273
99894, 2.2166666666667, 1.4333333333333, 0.22727272727273
99895, 2.2333333333333, 1.4333333333333, 0.20454545454545
99896, 2.2333333333333, 1.4166666666667, 0.18181818181818
99897, 2.2166666666667, 1.4333333333333, 0.18181818181818
99898, 2.2333333333333, 1.4333333333333, 0.15909090909091
99899, 2.2333333333333, 1.4166666666667, 0.13636363636364
99900, 2.2166666666667, 1.4333333333333, 0.13636363636364
99901, 2.2333333333333, 1.4333333333333, 0.11363636363636
99902, 2.2333333333333, 1.4166666666667, 0.090909090909091
99903, 2.2166666666667, 1.4333333333333, 0.090909090909091
99904, 2.2333333333333, 1.4333333333333, 0.068181818181818
99905, 2.2333333333333, 1.4166666666667, 0.045454545454545
99906, 2.2166666666667, 1.4333333333333, 0.045454545454545
99907, 2.2333333333333, 1.4333333333333, 0.022727272727273
99908, 2.2333333333333, 1.4666666666667, 0.47727272727273
99909, 2.2333333333333, 1.45, 0.45454545454545
99910, 2.2166666666667, 1.4666666666667, 0.45454545454545
99911, 2.2333333333333, 1.4666666666667, 0.43181818181818
99912, 2.2333333333333, 1.45, 0.40909090909091
99913, 2.2166666666667, 1.4666666666667, 0.40909090909091
99914, 2.2333333333333, 1.4666666666667, 0.38636363636364
99915, 2.2333333333333, 1.45, 0.36363636363636
99916, 2.2166666666667, 1.4666666666667, 0.36363636363636
99917, 2.2333333333333, 1.4666666666667, 0.34090909090909
99918, 2.2333333333333, 1.45, 0.31818181818182
99919, 2.2166666666667, 1.4666666666667, 0.31818181818182
99920, 2.2333333333333, 1.4666666666667, 0.29545454545455
99921, 2.2333333333333, 1.45, 0.27272727272727
99922, 2.2166666666667, 1.4666666666667, 0.27272727272727
99923, 2.2333333333333, 1.4666666666667, 0.25
99924, 2.2333333333333, 1.45, 0.22727272727273
99925, 2.2166666666667, 1.4666666666667, 0.22727272727273
99926, 2.2333333333333, 1.4666666666667, 0.20454545454545
99927, 2.2333333333333, 1.45, 0.18181818181818
99928, 2.2166666666667, 1.4666666666667, 0.18181818181818
99929, 2.2333333333333, 1.4666666666667, 0.15909090909091
99930, 2.2333333333333, 1.45, 0.13636363636364
99931, 2.2166666666667, 1.4666666666667, 0.13636363636364
99932, 2.2333333333333, 1.4666666666667, 0.11363636363636
99933, 2.2333333333333, 1.45, 0.090909090909091
99934, 2.2166666666667, 1.4666666666667, 0.090909090909091
99935, 2.2333333333333, 1.4666666666667, 0.068181818181818
99936, 2.2333333333333, 1.45, 0.045454545454545
99937, 2.2166666666667, 1.4666666666667, 0.045454545454545
99938, 2.2333333333333, 1.4666666666667, 0.022727272727273
99939, 2.2333333333333, 1.4833333333333, 0.45454545454545
99940, 2.2333333333333, 1.4833333333333, 0.40909090909091
99941, 2.2333333333333, 1.4833333333333, 0.36363636363636
99942, 2.2333333333333, 1.4833333333333, 0.31818181818182
99943, 2.2333333333333, 1.4833333333333, 0.27272727272727
99944, 2.2333333333333, 1.4833333333333, 0.22727272727273
99945, 2.2333333333333, 1.4833333333333, 0.18181818181818
99946, 2.2333333333333, 1.4833333333333, 0.13636363636364
99947, 2.2333333333333, 1.4833333333333, 0.090909090909091
99948, 2.2333333333333, 1.4833333333333, 0.045454545454545
99949, 2.2666666666667, 1.4333333333333, 0.47727272727273
99950, 2.2666666666667, 1.4166666666667, 0.45454545454545
99951, 2.25, 1.4333333333333, 0.45454545454545
99952, 2.2666666666667, 1.4333333333333, 0.43181818181818
99953, 2.2666666666667, 1.4166666666667, 0.40909090909091
99954, 2.25, 1.4333333333333, 0.40909090909091
99955, 2.2666666666667, 1.4333333333333, 0.38636363636364
99956, 2.2666666666667, 1.4166666666667, 0.36363636363636
99957, 2.25, 1.4333333333333, 0.36363636363636
99958, 2.2666666666667, 1.4333333333333, 0.34090909090909
99959, 2.2666666666667, 1.4166666666667, 0.31818181818182
99960, 2.25, 1.4333333333333, 0.31818181818182
99961, 2.2666666666667, 1.4333333333333, 0.29545454545455
99962, 2.2666666666667, 1.4166666666667, 0.27272727272727
99963, 2.25, 1.4333333333333, 0.27272727272727
99964, 2.2666666666667, 1.4333333333333, 0.25
99965, 2.2666666666667, 1.4166666666667, 0.22727272727273
99966, 2.25, 1.4333333333333, 0.22727272727273
99967, 2.2666666666667, 1.4333333333333, 0.20454545454545
99968, 2.2666666666667, 1.4166666666667, 0.18181818181818
99969, 2.25, 1.4333333333333, 0.18181818181818
99970, 2.2666666666667, 1.4333333333333, 0.15909090909091
99971, 2.2666666666667, 1.4166666666667, 0.13636363636364
99972, 2.25, 1.4333333333333, 0.13636363636364
99973, 2.2666666666667, 1.4333333333333, 0.11363636363636
99974, 2.2666666666667, 1.4166666666667, 0.090909090909091
99975, 2.25, 1.4333333333333, 0.090909090909091
99976, 2.2666666666667, 1.4333333333333, 0.068181818181818
99977, 2.2666666666667, 1.4166666666667, 0.045454545454545
99978, 2.25, 1.4333333333333, 0.045454545454545
99979, 2.2666666666667, 1.4333333333333, 0.022727272727273
99980, 2.2666666666667, 1.4666666666667, 0.47727272727273
99981, 2.2666666666667, 1.45, 0.45454545454545
99982, 2.25, 1.4666666666667, 0.45454545454545
99983, 2.2666666666667, 1.4666666666667, 0.43181818181818
99984, 2.2666666666667, 1.45, 0.40909090909091
99985, 2.25, 1.4666666666667, 0.40909090909091
99986, 2.2666666666667, 1.4666666666667, 0.38636363636364
99987, 2.2666666666667, 1.45, 0.36363636363636
99988, 2.25, 1.4666666666667, 0.36363636363636
99989, 2.2666666666667, 1.4666666666667, 0.34090909090909
99990, 2.2666666666667, 1.45, 0.31818181818182
99991, 2.25, 1.4666666666667, 0.31818181818182
99992, 2.2666666666667, 1.4666666666667, 0.29545454545455
99993, 2.2666666666667, 1.45, 0.27272727272727
99994, 2.25, 1.4666666666667, 0.27272727272727
99995, 2.2666666666667, 1.4666666666667, 0.25
99996, 2.2666666666667, 1.45, 0.22727272727273
99997, 2.25, 1.4666666666667, 0.22727272727273
99998, 2.2666666666667, 1.4666666666667, 0.20454545454545
99999, 2.2666666666667, 1.45, 0.18181818181818
100000, 2.25, 1.4666666666667, 0.18181818181818
100001, 2.2666666666667, 1.4666666666667, 0.15909090909091
100002, 2.2666666666667, 1.45, 0.13636363636364
100003, 2.25, 1.4666666666667, 0.13636363636364
100004, 2.2666666666667, 1.4666666666667, 0.11363636363636
100005, 2.2666666666667, 1.45, 0.090909090909091
100006, 2.25, 1.4666666666667, 0.090909090909091
100007, 2.2666666666667, 1.4666666666667, 0.068181818181818
100008, 2.2666666666667, 1.45, 0.045454545454545
100009, 2.25, 1.4666666666667, 0.045454545454545
100010, 2.2666666666667, 1.4666666666667, 0.022727272727273
100011, 2.2666666666667, 1.4833333333333, 0.45454545454545
100012, 2.2666666666667, 1.4833333333333, 0.40909090909091
100013, 2.2666666666667, 1.4833333333333, 0.36363636363636
100014, 2.2666666666667, 1.4833333333333, 0.31818181818182
100015, 2.2666666666667, 1.4833333333333, 0.27272727272727
100016, 2.2666666666667, 1.4833333333333, 0.22727272727273
100017, 2.2666666666667, 1.4833333333333, 0.18181818181818
100018, 2.2666666666667, 1.4833333333333, 0.13636363636364
100019, 2.2666666666667, 1.4833333333333, 0.090909090909091
100020, 2.2666666666667, 1.4833333333333, 0.045454545454545
100021, 2.2833333333333, 1.4333333333333, 0.45454545454545
100022, 2.2833333333333, 1.4333333333333, 0.40909090909091
100023, 2.2833333333333, 1.4333333333333, 0.36363636363636
100024, 2.2833333333333, 1.4333333333333, 0.31818181818182
100025, 2.2833333333333, 1.4333333333333, 0.27272727272727
100026, 2.2833333333333, 1.4333333333333, 0.22727272727273
100027, 2.2833333333333, 1.4333333333333, 0.18181818181818
100028, 2.2833333333333, 1.4333333333333, 0.13636363636364
100029, 2.2833333333333, 1.4333333333333, 0.090909090909091
100030, 2.2833333333333, 1.4333333333333, 0.045454545454545
100031, 2.2833333333333, 1.4666666666667, 0.45454545454545
100032, 2.2833333333333, 1.4666666666667, 0.40909090909091
100033, 2.2833333333333, 1.4666666666667, 0.36363636363636
100034, 2.2833333333333, 1.4666666666667, 0.31818181818182
100035, 2.2833333333333, 1.4666666666667, 0.27272727272727
100036, 2.2833333333333, 1.4666666666667, 0.22727272727273
100037, 2.2833333333333, 1.4666666666667, 0.18181818181818
100038, 2.2833333333333, 1.4666666666667, 0.13636363636364
100039, 2.2833333333333, 1.4666666666667, 0.090909090909091
100040, 2.2833333333333, 1.4666666666667, 0.045454545454545
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line1
27150, 2, 99, 89
27151, 89, 100, 90
27152, 90, 101, 91
27153, 91, 102, 92
27154, 92, 103, 93
27155, 93, 104, 94
27156, 94, 105, 95
27157, 95, 106, 96
27158, 96, 107, 97
27159, 97, 108, 98
27160, 98, 109, 1
*ELEMENT, type=T3D3, ELSET=Line2
27161, 1, 112, 110
27162, 110, 113, 111
27163, 111, 114, 3
*ELEMENT, type=T3D3, ELSET=Line3
27164, 4, 125, 115
27165, 115, 126, 116
27166, 116, 127, 117
27167, 117, 128, 118
27168, 118, 129, 119
27169, 119, 130, 120
27170, 120, 131, 121
27171, 121, 132, 122
27172, 122, 133, 123
27173, 123, 134, 124
27174, 124, 135, 3
*ELEMENT, type=T3D3, ELSET=Line4
27175, 2, 138, 136
27176, 136, 139, 137
27177, 137, 140, 4
*ELEMENT, type=T3D3, ELSET=Line5
27178, 6, 151, 141
27179, 141, 152, 142
27180, 142, 153, 143
27181, 143, 154, 144
27182, 144, 155, 145
27183, 145, 156, 146
27184, 146, 157, 147
27185, 147, 158, 148
27186, 148, 159, 149
27187, 149, 160, 150
27188, 150, 161, 5
*ELEMENT, type=T3D3, ELSET=Line6
27189, 5, 164, 162
27190, 162, 165, 163
27191, 163, 166, 7
*ELEMENT, type=T3D3, ELSET=Line7
27192, 8, 177, 167
27193, 167, 178, 168
27194, 168, 179, 169
27195, 169, 180, 170
27196, 170, 181, 171
27197, 171, 182, 172
27198, 172, 183, 173
27199, 173, 184, 174
27200, 174, 185, 175
27201, 175, 186, 176
27202, 176, 187, 7
*ELEMENT, type=T3D3, ELSET=Line8
27203, 6, 190, 188
27204, 188, 191, 189
27205, 189, 192, 8
*ELEMENT, type=T3D3, ELSET=Line9
27206, 2, 215, 193
27207, 193, 216, 194
27208, 194, 217, 195
27209, 195, 218, 196
27210, 196, 219, 197
27211, 197, 220, 198
27212, 198, 221, 199
27213, 199, 222, 200
27214, 200, 223, 201
27215, 201, 224, 202
27216, 202, 225, 203
27217, 203, 226, 204
27218, 204, 227, 205
27219, 205, 228, 206
27220, 206, 229, 207
27221, 207, 230, 208
27222, 208, 231, 209
27223, 209, 232, 210
27224, 210, 233, 211
27225, 211, 234, 212
27226, 212, 235, 213
27227, 213, 236, 214
27228, 214, 237, 6
*ELEMENT, type=T3D3, ELSET=Line10
27229, 1, 260, 238
27230, 238, 261, 239
27231, 239, 262, 240
27232, 240, 263, 241
27233, 241, 264, 242
27234, 242, 265, 243
27235, 243, 266, 244
27236, 244, 267, 245
27237, 245, 268, 246
27238, 246, 269, 247
27239, 247, 270, 248
27240, 248, 271, 249
27241, 249, 272, 250
27242, 250, 273, 251
27243, 251, 274, 252
27244, 252, 275, 253
27245, 253, 276, 254
27246, 254, 277, 255
27247, 255, 278, 256
27248, 256, 279, 257
27249, 257, 280, 258
27250, 258, 281, 259
27251, 259, 282, 5
*ELEMENT, type=T3D3, ELSET=Line11
27252, 4, 305, 283
27253, 283, 306, 284
27254, 284, 307, 285
27255, 285, 308, 286
27256, 286, 309, 287
27257, 287, 310, 288
27258, 288, 311, 289
27259, 289, 312, 290
27260, 290, 313, 291
27261, 291, 314, 292
27262, 292, 315, 293
27263, 293, 316, 294
27264, 294, 317, 295
27265, 295, 318, 296
27266, 296, 319, 297
27267, 297, 320, 298
27268, 298, 321, 299
27269, 299, 322, 300
27270, 300, 323, 301
27271, 301, 324, 302
27272, 302, 325, 303
27273, 303, 326, 304
27274, 304, 327, 8
*ELEMENT, type=T3D3, ELSET=Line12
27275, 3, 350, 328
27276, 328, 351, 329
27277, 329, 352, 330
27278, 330, 353, 331
27279, 331, 354, 332
27280, 332, 355, 333
27281, 333, 356, 334
27282, 334, 357, 335
27283, 335, 358, 336
27284, 336, 359, 337
27285, 337, 360, 338
27286, 338, 361, 339
27287, 339, 362, 340
27288, 340, 363, 341
27289, 341, 364, 342
27290, 342, 365, 343
27291, 343, 366, 344
27292, 344, 367, 345
27293, 345, 368, 346
27294, 346, 369, 347
27295, 347, 370, 348
27296, 348, 371, 349
27297, 349, 372, 7
*ELEMENT, type=T3D3, ELSET=Line13
27298, 8, 374, 373
27299, 373, 375, 9
*ELEMENT, type=T3D3, ELSET=Line14
27300, 4, 377, 376
27301, 376, 378, 10
*ELEMENT, type=T3D3, ELSET=Line15
27302, 10, 401, 379
27303, 379, 402, 380
27304, 380, 403, 381
27305, 381, 404, 382
27306, 382, 405, 383
27307, 383, 406, 384
27308, 384, 407, 385
27309, 385, 408, 386
27310, 386, 409, 387
27311, 387, 410, 388
27312, 388, 411, 389
27313, 389, 412, 390
27314, 390, 413, 391
27315, 391, 414, 392
27316, 392, 415, 393
27317, 393, 416, 394
27318, 394, 417, 395
27319, 395, 418, 396
27320, 396, 419, 397
27321, 397, 420, 398
27322, 398, 421, 399
27323, 399, 422, 400
27324, 400, 423, 9
*ELEMENT, type=T3D3, ELSET=Line16
27325, 7, 425, 424
27326, 424, 426, 11
*ELEMENT, type=T3D3, ELSET=Line17
27327, 9, 437, 427
27328, 427, 438, 428
27329, 428, 439, 429
27330, 429, 440, 430
27331, 430, 441, 431
27332, 431, 442, 432
27333, 432, 443, 433
27334, 433, 444, 434
27335, 434, 445, 435
27336, 435, 446, 436
27337, 436, 447, 11
*ELEMENT, type=T3D3, ELSET=Line18
27338, 3, 449, 448
27339, 448, 450, 12
*ELEMENT, type=T3D3, ELSET=Line19
27340, 12, 473, 451
27341, 451, 474, 452
27342, 452, 475, 453
27343, 453, 476, 454
27344, 454, 477, 455
27345, 455, 478, 456
27346, 456, 479, 457
27347, 457, 480, 458
27348, 458, 481, 459
27349, 459, 482, 460
27350, 460, 483, 461
27351, 461, 484, 462
27352, 462, 485, 463
27353, 463, 486, 464
27354, 464, 487, 465
27355, 465, 488, 466
27356, 466, 489, 467
27357, 467, 490, 468
27358, 468, 491, 469
27359, 469, 492, 470
27360, 470, 493, 471
27361, 471, 494, 472
27362, 472, 495, 11
*ELEMENT, type=T3D3, ELSET=Line20
27363, 10, 506, 496
27364, 496, 507, 497
27365, 497, 508, 498
27366, 498, 509, 499
27367, 499, 510, 500
27368, 500, 511, 501
27369, 501, 512, 502
27370, 502, 513, 503
27371, 503, 514, 504
27372, 504, 515, 505
27373, 505, 516, 12
*ELEMENT, type=T3D3, ELSET=Line21
27374, 9, 539, 517
27375, 517, 540, 518
27376, 518, 541, 519
27377, 519, 542, 520
27378, 520, 543, 521
27379, 521, 544, 522
27380, 522, 545, 523
27381, 523, 546, 524
27382, 524, 547, 525
27383, 525, 548, 526
27384, 526, 549, 527
27385, 527, 550, 528
27386, 528, 551, 529
27387, 529, 552, 530
27388, 530, 553, 531
27389, 531, 554, 532
27390, 532, 555, 533
27391, 533, 556, 534
27392, 534, 557, 535
27393, 535, 558, 536
27394, 536, 559, 537
27395, 537, 560, 538
27396, 538, 561, 13
*ELEMENT, type=T3D3, ELSET=Line22
27397, 10, 584, 562
27398, 562, 585, 563
27399, 563, 586, 564
27400, 564, 587, 565
27401, 565, 588, 566
27402, 566, 589, 567
27403, 567, 590, 568
27404, 568, 591, 569
27405, 569, 592, 570
27406, 570, 593, 571
27407, 571, 594, 572
27408, 572, 595, 573
27409, 573, 596, 574
27410, 574, 597, 575
27411, 575, 598, 576
27412, 576, 599, 577
27413, 577, 600, 578
27414, 578, 601, 579
27415, 579, 602, 580
27416, 580, 603, 581
27417, 581, 604, 582
27418, 582, 605, 583
27419, 583, 606, 14
*ELEMENT, type=T3D3, ELSET=Line23
27420, 14, 629, 607
27421, 607, 630, 608
27422, 608, 631, 609
27423, 609, 632, 610
27424, 610, 633, 611
27425, 611, 634, 612
27426, 612, 635, 613
27427, 613, 636, 614
27428, 614, 637, 615
27429, 615, 638, 616
27430, 616, 639, 617
27431, 617, 640, 618
27432, 618, 641, 619
27433, 619, 642, 620
27434, 620, 643, 621
27435, 621, 644, 622
27436, 622, 645, 623
27437, 623, 646, 624
27438, 624, 647, 625
27439, 625, 648, 626
27440, 626, 649, 627
27441, 627, 650, 628
27442, 628, 651, 13
*ELEMENT, type=T3D3, ELSET=Line24
27443, 11, 674, 652
27444, 652, 675, 653
27445, 653, 676, 654
27446, 654, 677, 655
27447, 655, 678, 656
27448, 656, 679, 657
27449, 657, 680, 658
27450, 658, 681, 659
27451, 659, 682, 660
27452, 660, 683, 661
27453, 661, 684, 662
27454, 662, 685, 663
27455, 663, 686, 664
27456, 664, 687, 665
27457, 665, 688, 666
27458, 666, 689, 667
27459, 667, 690, 668
27460, 668, 691, 669
27461, 669, 692, 670
27462, 670, 693, 671
27463, 671, 694, 672
27464, 672, 695, 673
27465, 673, 696, 15
*ELEMENT, type=T3D3, ELSET=Line25
27466, 13, 707, 697
27467, 697, 708, 698
27468, 698, 709, 699
27469, 699, 710, 700
27470, 700, 711, 701
27471, 701, 712, 702
27472, 702, 713, 703
27473, 703, 714, 704
27474, 704, 715, 705
27475, 705, 716, 706
27476, 706, 717, 15
*ELEMENT, type=T3D3, ELSET=Line26
27477, 12, 740, 718
27478, 718, 741, 719
27479, 719, 742, 720
27480, 720, 743, 721
27481, 721, 744, 722
27482, 722, 745, 723
27483, 723, 746, 724
27484, 724, 747, 725
27485, 725, 748, 726
27486, 726, 749, 727
27487, 727, 750, 728
27488, 728, 751, 729
27489, 729, 752, 730
27490, 730, 753, 731
27491, 731, 754, 732
27492, 732, 755, 733
27493, 733, 756, 734
27494, 734, 757, 735
27495, 735, 758, 736
27496, 736, 759, 737
27497, 737, 760, 738
27498, 738, 761, 739
27499, 739, 762, 16
*ELEMENT, type=T3D3, ELSET=Line27
27500, 16, 785, 763
27501, 763, 786, 764
27502, 764, 787, 765
27503, 765, 788, 766
27504, 766, 789, 767
27505, 767, 790, 768
27506, 768, 791, 769
27507, 769, 792, 770
27508, 770, 793, 771
27509, 771, 794, 772
27510, 772, 795, 773
27511, 773, 796, 774
27512, 774, 797, 775
27513, 775, 798, 776
27514, 776, 799, 777
27515, 777, 800, 778
27516, 778, 801, 779
27517, 779, 802, 780
27518, 780, 803, 781
27519, 781, 804, 782
27520, 782, 805, 783
27521, 783, 806, 784
27522, 784, 807, 15
*ELEMENT, type=T3D3, ELSET=Line28
27523, 14, 818, 808
27524, 808, 819, 809
27525, 809, 820, 810
27526, 810, 821, 811
27527, 811, 822, 812
27528, 812, 823, 813
27529, 813, 824, 814
27530, 814, 825, 815
27531, 815, 826, 816
27532, 816, 827, 817
27533, 817, 828, 16
*ELEMENT, type=T3D3, ELSET=Line29
27534, 13, 830, 829
27535, 829, 831, 17
*ELEMENT, type=T3D3, ELSET=Line30
27536, 14, 833, 832
27537, 832, 834, 18
*ELEMENT, type=T3D3, ELSET=Line31
27538, 18, 857, 835
27539, 835, 858, 836
27540, 836, 859, 837
27541, 837, 860, 838
27542, 838, 861, 839
27543, 839, 862, 840
27544, 840, 863, 841
27545, 841, 864, 842
27546, 842, 865, 843
27547, 843, 866, 844
27548, 844, 867, 845
27549, 845, 868, 846
27550, 846, 869, 847
27551, 847, 870, 848
27552, 848, 871, 849
27553, 849, 872, 850
27554, 850, 873, 851
27555, 851, 874, 852
27556, 852, 875, 853
27557, 853, 876, 854
27558, 854, 877, 855
27559, 855, 878, 856
27560, 856, 879, 17
*ELEMENT, type=T3D3, ELSET=Line32
27561, 15, 881, 880
27562, 880, 882, 19
*ELEMENT, type=T3D3, ELSET=Line33
27563, 17, 893, 883
27564, 883, 894, 884
27565, 884, 895, 885
27566, 885, 896, 886
27567, 886, 897, 887
27568, 887, 898, 888
27569, 888, 899, 889
27570, 889, 900, 890
27571, 890, 901, 891
27572, 891, 902, 892
27573, 892, 903, 19
*ELEMENT, type=T3D3, ELSET=Line34
27574, 16, 905, 904
27575, 904, 906, 20
*ELEMENT, type=T3D3, ELSET=Line35
27576, 20, 929, 907
27577, 907, 930, 908
27578, 908, 931, 909
27579, 909, 932, 910
27580, 910, 933, 911
27581, 911, 934, 912
27582, 912, 935, 913
27583, 913, 936, 914
27584, 914, 937, 915
27585, 915, 938, 916
27586, 916, 939, 917
27587, 917, 940, 918
27588, 918, 941, 919
27589, 919, 942, 920
27590, 920, 943, 921
27591, 921, 944, 922
27592, 922, 945, 923
27593, 923, 946, 924
27594, 924, 947, 925
27595, 925, 948, 926
27596, 926, 949, 927
27597, 927, 950, 928
27598, 928, 951, 19
*ELEMENT, type=T3D3, ELSET=Line36
27599, 18, 962, 952
27600, 952, 963, 953
27601, 953, 964, 954
27602, 954, 965, 955
27603, 955, 966, 956
27604, 956, 967, 957
27605, 957, 968, 958
27606, 958, 969, 959
27607, 959, 970, 960
27608, 960, 971, 961
27609, 961, 972, 20
*ELEMENT, type=T3D3, ELSET=Line37
27610, 17, 975, 973
27611, 973, 976, 974
27612, 974, 977, 21
*ELEMENT, type=T3D3, ELSET=Line38
27613, 18, 980, 978
27614, 978, 981, 979
27615, 979, 982, 22
*ELEMENT, type=T3D3, ELSET=Line39
27616, 22, 1005, 983
27617, 983, 1006, 984
27618, 984, 1007, 985
27619, 985, 1008, 986
27620, 986, 1009, 987
27621, 987, 1010, 988
27622, 988, 1011, 989
27623, 989, 1012, 990
27624, 990, 1013, 991
27625, 991, 1014, 992
27626, 992, 1015, 993
27627, 993, 1016, 994
27628, 994, 1017, 995
27629, 995, 1018, 996
27630, 996, 1019, 997
27631, 997, 1020, 998
27632, 998, 1021, 999
27633, 999, 1022, 1000
27634, 1000, 1023, 1001
27635, 1001, 1024, 1002
27636, 1002, 1025, 1003
27637, 1003, 1026, 1004
27638, 1004, 1027, 21
*ELEMENT, type=T3D3, ELSET=Line40
27639, 19, 1030, 1028
27640, 1028, 1031, 1029
27641, 1029, 1032, 23
*ELEMENT, type=T3D3, ELSET=Line41
27642, 21, 1043, 1033
27643, 1033, 1044, 1034
27644, 1034, 1045, 1035
27645, 1035, 1046, 1036
27646, 1036, 1047, 1037
27647, 1037, 1048, 1038
27648, 1038, 1049, 1039
27649, 1039, 1050, 1040
27650, 1040, 1051, 1041
27651, 1041, 1052, 1042
27652, 1042, 1053, 23
*ELEMENT, type=T3D3, ELSET=Line42
27653, 20, 1056, 1054
27654, 1054, 1057, 1055
27655, 1055, 1058, 24
*ELEMENT, type=T3D3, ELSET=Line43
27656, 24, 1081, 1059
27657, 1059, 1082, 1060
27658, 1060, 1083, 1061
27659, 1061, 1084, 1062
27660, 1062, 1085, 1063
27661, 1063, 1086, 1064
27662, 1064, 1087, 1065
27663, 1065, 1088, 1066
27664, 1066, 1089, 1067
27665, 1067, 1090, 1068
27666, 1068, 1091, 1069
27667, 1069, 1092, 1070
27668, 1070, 1093, 1071
27669, 1071, 1094, 1072
27670, 1072, 1095, 1073
27671, 1073, 1096, 1074
27672, 1074, 1097, 1075
27673, 1075, 1098, 1076
27674, 1076, 1099, 1077
27675, 1077, 1100, 1078
27676, 1078, 1101, 1079
27677, 1079, 1102, 1080
27678, 1080, 1103, 23
*ELEMENT, type=T3D3, ELSET=Line44
27679, 22, 1114, 1104
27680, 1104, 1115, 1105
27681, 1105, 1116, 1106
27682, 1106, 1117, 1107
27683, 1107, 1118, 1108
27684, 1108, 1119, 1109
27685, 1109, 1120, 1110
27686, 1110, 1121, 1111
27687, 1111, 1122, 1112
27688, 1112, 1123, 1113
27689, 1113, 1124, 24
*ELEMENT, type=T3D3, ELSET=Line45
27690, 19, 1129, 1125
27691, 1125, 1130, 1126
27692, 1126, 1131, 1127
27693, 1127, 1132, 1128
27694, 1128, 1133, 25
*ELEMENT, type=T3D3, ELSET=Line46
27695, 23, 1138, 1134
27696, 1134, 1139, 1135
27697, 1135, 1140, 1136
27698, 1136, 1141, 1137
27699, 1137, 1142, 26
*ELEMENT, type=T3D3, ELSET=Line47
27700, 25, 1145, 1143
27701, 1143, 1146, 1144
27702, 1144, 1147, 26
*ELEMENT, type=T3D3, ELSET=Line48
27703, 17, 1152, 1148
27704, 1148, 1153, 1149
27705, 1149, 1154, 1150
27706, 1150, 1155, 1151
27707, 1151, 1156, 27
*ELEMENT, type=T3D3, ELSET=Line49
27708, 21, 1161, 1157
27709, 1157, 1162, 1158
27710, 1158, 1163, 1159
27711, 1159, 1164, 1160
27712, 1160, 1165, 28
*ELEMENT, type=T3D3, ELSET=Line50
27713, 27, 1168, 1166
27714, 1166, 1169, 1167
27715, 1167, 1170, 28
*ELEMENT, type=T3D3, ELSET=Line51
27716, 27, 1181, 1171
27717, 1171, 1182, 1172
27718, 1172, 1183, 1173
27719, 1173, 1184, 1174
27720, 1174, 1185, 1175
27721, 1175, 1186, 1176
27722, 1176, 1187, 1177
27723, 1177, 1188, 1178
27724, 1178, 1189, 1179
27725, 1179, 1190, 1180
27726, 1180, 1191, 25
*ELEMENT, type=T3D3, ELSET=Line52
27727, 28, 1202, 1192
27728, 1192, 1203, 1193
27729, 1193, 1204, 1194
27730, 1194, 1205, 1195
27731, 1195, 1206, 1196
27732, 1196, 1207, 1197
27733, 1197, 1208, 1198
27734, 1198, 1209, 1199
27735, 1199, 1210, 1200
27736, 1200, 1211, 1201
27737, 1201, 1212, 26
*ELEMENT, type=T3D3, ELSET=Line53
27738, 25, 1235, 1213
27739, 1213, 1236, 1214
27740, 1214, 1237, 1215
27741, 1215, 1238, 1216
27742, 1216, 1239, 1217
27743, 1217, 1240, 1218
27744, 1218, 1241, 1219
27745, 1219, 1242, 1220
27746, 1220, 1243, 1221
27747, 1221, 1244, 1222
27748, 1222, 1245, 1223
27749, 1223, 1246, 1224
27750, 1224, 1247, 1225
27751, 1225, 1248, 1226
27752, 1226, 1249, 1227
27753, 1227, 1250, 1228
27754, 1228, 1251, 1229
27755, 1229, 1252, 1230
27756, 1230, 1253, 1231
27757, 1231, 1254, 1232
27758, 1232, 1255, 1233
27759, 1233, 1256, 1234
27760, 1234, 1257, 29
*ELEMENT, type=T3D3, ELSET=Line54
27761, 26, 1280, 1258
27762, 1258, 1281, 1259
27763, 1259, 1282, 1260
27764, 1260, 1283, 1261
27765, 1261, 1284, 1262
27766, 1262, 1285, 1263
27767, 1263, 1286, 1264
27768, 1264, 1287, 1265
27769, 1265, 1288, 1266
27770, 1266, 1289, 1267
27771, 1267, 1290, 1268
27772, 1268, 1291, 1269
27773, 1269, 1292, 1270
27774, 1270, 1293, 1271
27775, 1271, 1294, 1272
27776, 1272, 1295, 1273
27777, 1273, 1296, 1274
27778, 1274, 1297, 1275
27779, 1275, 1298, 1276
27780, 1276, 1299, 1277
27781, 1277, 1300, 1278
27782, 1278, 1301, 1279
27783, 1279, 1302, 30
*ELEMENT, type=T3D3, ELSET=Line55
27784, 29, 1305, 1303
27785, 1303, 1306, 1304
27786, 1304, 1307, 30
*ELEMENT, type=T3D3, ELSET=Line56
27787, 27, 1330, 1308
27788, 1308, 1331, 1309
27789, 1309, 1332, 1310
27790, 1310, 1333, 1311
27791, 1311, 1334, 1312
27792, 1312, 1335, 1313
27793, 1313, 1336, 1314
27794, 1314, 1337, 1315
27795, 1315, 1338, 1316
27796, 1316, 1339, 1317
27797, 1317, 1340, 1318
27798, 1318, 1341, 1319
27799, 1319, 1342, 1320
27800, 1320, 1343, 1321
27801, 1321, 1344, 1322
27802, 1322, 1345, 1323
27803, 1323, 1346, 1324
27804, 1324, 1347, 1325
27805, 1325, 1348, 1326
27806, 1326, 1349, 1327
27807, 1327, 1350, 1328
27808, 1328, 1351, 1329
27809, 1329, 1352, 31
*ELEMENT, type=T3D3, ELSET=Line57
27810, 28, 1375, 1353
27811, 1353, 1376, 1354
27812, 1354, 1377, 1355
27813, 1355, 1378, 1356
27814, 1356, 1379, 1357
27815, 1357, 1380, 1358
27816, 1358, 1381, 1359
27817, 1359, 1382, 1360
27818, 1360, 1383, 1361
27819, 1361, 1384, 1362
27820, 1362, 1385, 1363
27821, 1363, 1386, 1364
27822, 1364, 1387, 1365
27823, 1365, 1388, 1366
27824, 1366, 1389, 1367
27825, 1367, 1390, 1368
27826, 1368, 1391, 1369
27827, 1369, 1392, 1370
27828, 1370, 1393, 1371
27829, 1371, 1394, 1372
27830, 1372, 1395, 1373
27831, 1373, 1396, 1374
27832, 1374, 1397, 32
*ELEMENT, type=T3D3, ELSET=Line58
27833, 31, 1400, 1398
27834, 1398, 1401, 1399
27835, 1399, 1402, 32
*ELEMENT, type=T3D3, ELSET=Line59
27836, 31, 1413, 1403
27837, 1403, 1414, 1404
27838, 1404, 1415, 1405
27839, 1405, 1416, 1406
27840, 1406, 1417, 1407
27841, 1407, 1418, 1408
27842, 1408, 1419, 1409
27843, 1409, 1420, 1410
27844, 1410, 1421, 1411
27845, 1411, 1422, 1412
27846, 1412, 1423, 29
*ELEMENT, type=T3D3, ELSET=Line60
27847, 32, 1434, 1424
27848, 1424, 1435, 1425
27849, 1425, 1436, 1426
27850, 1426, 1437, 1427
27851, 1427, 1438, 1428
27852, 1428, 1439, 1429
27853, 1429, 1440, 1430
27854, 1430, 1441, 1431
27855, 1431, 1442, 1432
27856, 1432, 1443, 1433
27857, 1433, 1444, 30
*ELEMENT, type=T3D3, ELSET=Line61
27858, 25, 1446, 1445
27859, 1445, 1447, 33
*ELEMENT, type=T3D3, ELSET=Line62
27860, 29, 1449, 1448
27861, 1448, 1450, 34
*ELEMENT, type=T3D3, ELSET=Line63
27862, 33, 1473, 1451
27863, 1451, 1474, 1452
27864, 1452, 1475, 1453
27865, 1453, 1476, 1454
27866, 1454, 1477, 1455
27867, 1455, 1478, 1456
27868, 1456, 1479, 1457
27869, 1457, 1480, 1458
27870, 1458, 1481, 1459
27871, 1459, 1482, 1460
27872, 1460, 1483, 1461
27873, 1461, 1484, 1462
27874, 1462, 1485, 1463
27875, 1463, 1486, 1464
27876, 1464, 1487, 1465
27877, 1465, 1488, 1466
27878, 1466, 1489, 1467
27879, 1467, 1490, 1468
27880, 1468, 1491, 1469
27881, 1469, 1492, 1470
27882, 1470, 1493, 1471
27883, 1471, 1494, 1472
27884, 1472, 1495, 34
*ELEMENT, type=T3D3, ELSET=Line64
27885, 27, 1497, 1496
27886, 1496, 1498, 35
*ELEMENT, type=T3D3, ELSET=Line65
27887, 31, 1500, 1499
27888, 1499, 1501, 36
*ELEMENT, type=T3D3, ELSET=Line66
27889, 35, 1524, 1502
27890, 1502, 1525, 1503
27891, 1503, 1526, 1504
27892, 1504, 1527, 1505
27893, 1505, 1528, 1506
27894, 1506, 1529, 1507
27895, 1507, 1530, 1508
27896, 1508, 1531, 1509
27897, 1509, 1532, 1510
27898, 1510, 1533, 1511
27899, 1511, 1534, 1512
27900, 1512, 1535, 1513
27901, 1513, 1536, 1514
27902, 1514, 1537, 1515
27903, 1515, 1538, 1516
27904, 1516, 1539, 1517
27905, 1517, 1540, 1518
27906, 1518, 1541, 1519
27907, 1519, 1542, 1520
27908, 1520, 1543, 1521
27909, 1521, 1544, 1522
27910, 1522, 1545, 1523
27911, 1523, 1546, 36
*ELEMENT, type=T3D3, ELSET=Line67
27912, 35, 1557, 1547
27913, 1547, 1558, 1548
27914, 1548, 1559, 1549
27915, 1549, 1560, 1550
27916, 1550, 1561, 1551
27917, 1551, 1562, 1552
27918, 1552, 1563, 1553
27919, 1553, 1564, 1554
27920, 1554, 1565, 1555
27921, 1555, 1566, 1556
27922, 1556, 1567, 33
*ELEMENT, type=T3D3, ELSET=Line68
27923, 36, 1578, 1568
27924, 1568, 1579, 1569
27925, 1569, 1580, 1570
27926, 1570, 1581, 1571
27927, 1571, 1582, 1572
27928, 1572, 1583, 1573
27929, 1573, 1584, 1574
27930, 1574, 1585, 1575
27931, 1575, 1586, 1576
27932, 1576, 1587, 1577
27933, 1577, 1588, 34
*ELEMENT, type=T3D3, ELSET=Line69
27934, 33, 1611, 1589
27935, 1589, 1612, 1590
27936, 1590, 1613, 1591
27937, 1591, 1614, 1592
27938, 1592, 1615, 1593
27939, 1593, 1616, 1594
27940, 1594, 1617, 1595
27941, 1595, 1618, 1596
27942, 1596, 1619, 1597
27943, 1597, 1620, 1598
27944, 1598, 1621, 1599
27945, 1599, 1622, 1600
27946, 1600, 1623, 1601
27947, 1601, 1624, 1602
27948, 1602, 1625, 1603
27949, 1603, 1626, 1604
27950, 1604, 1627, 1605
27951, 1605, 1628, 1606
27952, 1606, 1629, 1607
27953, 1607, 1630, 1608
27954, 1608, 1631, 1609
27955, 1609, 1632, 1610
27956, 1610, 1633, 37
*ELEMENT, type=T3D3, ELSET=Line70
27957, 34, 1656, 1634
27958, 1634, 1657, 1635
27959, 1635, 1658, 1636
27960, 1636, 1659, 1637
27961, 1637, 1660, 1638
27962, 1638, 1661, 1639
27963, 1639, 1662, 1640
27964, 1640, 1663, 1641
27965, 1641, 1664, 1642
27966, 1642, 1665, 1643
27967, 1643, 1666, 1644
27968, 1644, 1667, 1645
27969, 1645, 1668, 1646
27970, 1646, 1669, 1647
27971, 1647, 1670, 1648
27972, 1648, 1671, 1649
27973, 1649, 1672, 1650
27974, 1650, 1673, 1651
27975, 1651, 1674, 1652
27976, 1652, 1675, 1653
27977, 1653, 1676, 1654
27978, 1654, 1677, 1655
27979, 1655, 1678, 38
*ELEMENT, type=T3D3, ELSET=Line71
27980, 37, 1701, 1679
27981, 1679, 1702, 1680
27982, 1680, 1703, 1681
27983, 1681, 1704, 1682
27984, 1682, 1705, 1683
27985, 1683, 1706, 1684
27986, 1684, 1707, 1685
27987, 1685, 1708, 1686
27988, 1686, 1709, 1687
27989, 1687, 1710, 1688
27990, 1688, 1711, 1689
27991, 1689, 1712, 1690
27992, 1690, 1713, 1691
27993, 1691, 1714, 1692
27994, 1692, 1715, 1693
27995, 1693, 1716, 1694
27996, 1694, 1717, 1695
27997, 1695, 1718, 1696
27998, 1696, 1719, 1697
27999, 1697, 1720, 1698
28000, 1698, 1721, 1699
28001, 1699, 1722, 1700
28002, 1700, 1723, 38
*ELEMENT, type=T3D3, ELSET=Line72
28003, 35, 1746, 1724
28004, 1724, 1747, 1725
28005, 1725, 1748, 1726
28006, 1726, 1749, 1727
28007, 1727, 1750, 1728
28008, 1728, 1751, 1729
28009, 1729, 1752, 1730
28010, 1730, 1753, 1731
28011, 1731, 1754, 1732
28012, 1732, 1755, 1733
28013, 1733, 1756, 1734
28014, 1734, 1757, 1735
28015, 1735, 1758, 1736
28016, 1736, 1759, 1737
28017, 1737, 1760, 1738
28018, 1738, 1761, 1739
28019, 1739, 1762, 1740
28020, 1740, 1763, 1741
28021, 1741, 1764, 1742
28022, 1742, 1765, 1743
28023, 1743, 1766, 1744
28024, 1744, 1767, 1745
28025, 1745, 1768, 39
*ELEMENT, type=T3D3, ELSET=Line73
28026, 36, 1791, 1769
28027, 1769, 1792, 1770
28028, 1770, 1793, 1771
28029, 1771, 1794, 1772
28030, 1772, 1795, 1773
28031, 1773, 1796, 1774
28032, 1774, 1797, 1775
28033, 1775, 1798, 1776
28034, 1776, 1799, 1777
28035, 1777, 1800, 1778
28036, 1778, 1801, 1779
28037, 1779, 1802, 1780
28038, 1780, 1803, 1781
28039, 1781, 1804, 1782
28040, 1782, 1805, 1783
28041, 1783, 1806, 1784
28042, 1784, 1807, 1785
28043, 1785, 1808, 1786
28044, 1786, 1809, 1787
28045, 1787, 1810, 1788
28046, 1788, 1811, 1789
28047, 1789, 1812, 1790
28048, 1790, 1813, 40
*ELEMENT, type=T3D3, ELSET=Line74
28049, 39, 1836, 1814
28050, 1814, 1837, 1815
28051, 1815, 1838, 1816
28052, 1816, 1839, 1817
28053, 1817, 1840, 1818
28054, 1818, 1841, 1819
28055, 1819, 1842, 1820
28056, 1820, 1843, 1821
28057, 1821, 1844, 1822
28058, 1822, 1845, 1823
28059, 1823, 1846, 1824
28060, 1824, 1847, 1825
28061, 1825, 1848, 1826
28062, 1826, 1849, 1827
28063, 1827, 1850, 1828
28064, 1828, 1851, 1829
28065, 1829, 1852, 1830
28066, 1830, 1853, 1831
28067, 1831, 1854, 1832
28068, 1832, 1855, 1833
28069, 1833, 1856, 1834
28070, 1834, 1857, 1835
28071, 1835, 1858, 40
*ELEMENT, type=T3D3, ELSET=Line75
28072, 39, 1869, 1859
28073, 1859, 1870, 1860
28074, 1860, 1871, 1861
28075, 1861, 1872, 1862
28076, 1862, 1873, 1863
28077, 1863, 1874, 1864
28078, 1864, 1875, 1865
28079, 1865, 1876, 1866
28080, 1866, 1877, 1867
28081, 1867, 1878, 1868
28082, 1868, 1879, 37
*ELEMENT, type=T3D3, ELSET=Line76
28083, 40, 1890, 1880
28084, 1880, 1891, 1881
28085, 1881, 1892, 1882
28086, 1882, 1893, 1883
28087, 1883, 1894, 1884
28088, 1884, 1895, 1885
28089, 1885, 1896, 1886
28090, 1886, 1897, 1887
28091, 1887, 1898, 1888
28092, 1888, 1899, 1889
28093, 1889, 1900, 38
*ELEMENT, type=T3D3, ELSET=Line77
28094, 37, 1902, 1901
28095, 1901, 1903, 41
*ELEMENT, type=T3D3, ELSET=Line78
28096, 38, 1905, 1904
28097, 1904, 1906, 42
*ELEMENT, type=T3D3, ELSET=Line79
28098, 41, 1929, 1907
28099, 1907, 1930, 1908
28100, 1908, 1931, 1909
28101, 1909, 1932, 1910
28102, 1910, 1933, 1911
28103, 1911, 1934, 1912
28104, 1912, 1935, 1913
28105, 1913, 1936, 1914
28106, 1914, 1937, 1915
28107, 1915, 1938, 1916
28108, 1916, 1939, 1917
28109, 1917, 1940, 1918
28110, 1918, 1941, 1919
28111, 1919, 1942, 1920
28112, 1920, 1943, 1921
28113, 1921, 1944, 1922
28114, 1922, 1945, 1923
28115, 1923, 1946, 1924
28116, 1924, 1947, 1925
28117, 1925, 1948, 1926
28118, 1926, 1949, 1927
28119, 1927, 1950, 1928
28120, 1928, 1951, 42
*ELEMENT, type=T3D3, ELSET=Line80
28121, 39, 1953, 1952
28122, 1952, 1954, 43
*ELEMENT, type=T3D3, ELSET=Line81
28123, 40, 1956, 1955
28124, 1955, 1957, 44
*ELEMENT, type=T3D3, ELSET=Line82
28125, 43, 1980, 1958
28126, 1958, 1981, 1959
28127, 1959, 1982, 1960
28128, 1960, 1983, 1961
28129, 1961, 1984, 1962
28130, 1962, 1985, 1963
28131, 1963, 1986, 1964
28132, 1964, 1987, 1965
28133, 1965, 1988, 1966
28134, 1966, 1989, 1967
28135, 1967, 1990, 1968
28136, 1968, 1991, 1969
28137, 1969, 1992, 1970
28138, 1970, 1993, 1971
28139, 1971, 1994, 1972
28140, 1972, 1995, 1973
28141, 1973, 1996, 1974
28142, 1974, 1997, 1975
28143, 1975, 1998, 1976
28144, 1976, 1999, 1977
28145, 1977, 2000, 1978
28146, 1978, 2001, 1979
28147, 1979, 2002, 44
*ELEMENT, type=T3D3, ELSET=Line83
28148, 43, 2013, 2003
28149, 2003, 2014, 2004
28150, 2004, 2015, 2005
28151, 2005, 2016, 2006
28152, 2006, 2017, 2007
28153, 2007, 2018, 2008
28154, 2008, 2019, 2009
28155, 2009, 2020, 2010
28156, 2010, 2021, 2011
28157, 2011, 2022, 2012
28158, 2012, 2023, 41
*ELEMENT, type=T3D3, ELSET=Line84
28159, 44, 2034, 2024
28160, 2024, 2035, 2025
28161, 2025, 2036, 2026
28162, 2026, 2037, 2027
28163, 2027, 2038, 2028
28164, 2028, 2039, 2029
28165, 2029, 2040, 2030
28166, 2030, 2041, 2031
28167, 2031, 2042, 2032
28168, 2032, 2043, 2033
28169, 2033, 2044, 42
*ELEMENT, type=T3D3, ELSET=Line86
28170, 42, 2047, 2045
28171, 2045, 2048, 2046
28172, 2046, 2049, 45
*ELEMENT, type=T3D3, ELSET=Line89
28173, 44, 2052, 2050
28174, 2050, 2053, 2051
28175, 2051, 2054, 46
*ELEMENT, type=T3D3, ELSET=Line92
28176, 46, 2065, 2055
28177, 2055, 2066, 2056
28178, 2056, 2067, 2057
28179, 2057, 2068, 2058
28180, 2058, 2069, 2059
28181, 2059, 2070, 2060
28182, 2060, 2071, 2061
28183, 2061, 2072, 2062
28184, 2062, 2073, 2063
28185, 2063, 2074, 2064
28186, 2064, 2075, 45
*ELEMENT, type=T3D3, ELSET=Line93
28187, 42, 2078, 2076
28188, 2076, 2079, 2077
28189, 2077, 2080, 47
*ELEMENT, type=T3D3, ELSET=Line94
28190, 45, 2083, 2081
28191, 2081, 2084, 2082
28192, 2082, 2085, 48
*ELEMENT, type=T3D3, ELSET=Line95
28193, 47, 2088, 2086
28194, 2086, 2089, 2087
28195, 2087, 2090, 48
*ELEMENT, type=T3D3, ELSET=Line96
28196, 44, 2093, 2091
28197, 2091, 2094, 2092
28198, 2092, 2095, 49
*ELEMENT, type=T3D3, ELSET=Line97
28199, 46, 2098, 2096
28200, 2096, 2099, 2097
28201, 2097, 2100, 50
*ELEMENT, type=T3D3, ELSET=Line98
28202, 49, 2103, 2101
28203, 2101, 2104, 2102
28204, 2102, 2105, 50
*ELEMENT, type=T3D3, ELSET=Line99
28205, 49, 2116, 2106
28206, 2106, 2117, 2107
28207, 2107, 2118, 2108
28208, 2108, 2119, 2109
28209, 2109, 2120, 2110
28210, 2110, 2121, 2111
28211, 2111, 2122, 2112
28212, 2112, 2123, 2113
28213, 2113, 2124, 2114
28214, 2114, 2125, 2115
28215, 2115, 2126, 47
*ELEMENT, type=T3D3, ELSET=Line100
28216, 50, 2137, 2127
28217, 2127, 2138, 2128
28218, 2128, 2139, 2129
28219, 2129, 2140, 2130
28220, 2130, 2141, 2131
28221, 2131, 2142, 2132
28222, 2132, 2143, 2133
28223, 2133, 2144, 2134
28224, 2134, 2145, 2135
28225, 2135, 2146, 2136
28226, 2136, 2147, 48
*ELEMENT, type=T3D3, ELSET=Line101
28227, 1, 2150, 2148
28228, 2148, 2151, 2149
28229, 2149, 2152, 51
*ELEMENT, type=T3D3, ELSET=Line102
28230, 2, 2155, 2153
28231, 2153, 2156, 2154
28232, 2154, 2157, 52
*ELEMENT, type=T3D3, ELSET=Line103
28233, 52, 2168, 2158
28234, 2158, 2169, 2159
28235, 2159, 2170, 2160
28236, 2160, 2171, 2161
28237, 2161, 2172, 2162
28238, 2162, 2173, 2163
28239, 2163, 2174, 2164
28240, 2164, 2175, 2165
28241, 2165, 2176, 2166
28242, 2166, 2177, 2167
28243, 2167, 2178, 51
*ELEMENT, type=T3D3, ELSET=Line104
28244, 3, 2181, 2179
28245, 2179, 2182, 2180
28246, 2180, 2183, 53
*ELEMENT, type=T3D3, ELSET=Line105
28247, 51, 2186, 2184
28248, 2184, 2187, 2185
28249, 2185, 2188, 53
*ELEMENT, type=T3D3, ELSET=Line106
28250, 4, 2191, 2189
28251, 2189, 2192, 2190
28252, 2190, 2193, 54
*ELEMENT, type=T3D3, ELSET=Line107
28253, 54, 2204, 2194
28254, 2194, 2205, 2195
28255, 2195, 2206, 2196
28256, 2196, 2207, 2197
28257, 2197, 2208, 2198
28258, 2198, 2209, 2199
28259, 2199, 2210, 2200
28260, 2200, 2211, 2201
28261, 2201, 2212, 2202
28262, 2202, 2213, 2203
28263, 2203, 2214, 53
*ELEMENT, type=T3D3, ELSET=Line108
28264, 52, 2217, 2215
28265, 2215, 2218, 2216
28266, 2216, 2219, 54
*ELEMENT, type=T3D3, ELSET=Line167
28267, 21, 2223, 2220
28268, 2220, 2224, 2221
28269, 2221, 2225, 2222
28270, 2222, 2226, 55
*ELEMENT, type=T3D3, ELSET=Line168
28271, 22, 2230, 2227
28272, 2227, 2231, 2228
28273, 2228, 2232, 2229
28274, 2229, 2233, 56
*ELEMENT, type=T3D3, ELSET=Line169
28275, 56, 2256, 2234
28276, 2234, 2257, 2235
28277, 2235, 2258, 2236
28278, 2236, 2259, 2237
28279, 2237, 2260, 2238
28280, 2238, 2261, 2239
28281, 2239, 2262, 2240
28282, 2240, 2263, 2241
28283, 2241, 2264, 2242
28284, 2242, 2265, 2243
28285, 2243, 2266, 2244
28286, 2244, 2267, 2245
28287, 2245, 2268, 2246
28288, 2246, 2269, 2247
28289, 2247, 2270, 2248
28290, 2248, 2271, 2249
28291, 2249, 2272, 2250
28292, 2250, 2273, 2251
28293, 2251, 2274, 2252
28294, 2252, 2275, 2253
28295, 2253, 2276, 2254
28296, 2254, 2277, 2255
28297, 2255, 2278, 55
*ELEMENT, type=T3D3, ELSET=Line170
28298, 23, 2282, 2279
28299, 2279, 2283, 2280
28300, 2280, 2284, 2281
28301, 2281, 2285, 57
*ELEMENT, type=T3D3, ELSET=Line171
28302, 55, 2296, 2286
28303, 2286, 2297, 2287
28304, 2287, 2298, 2288
28305, 2288, 2299, 2289
28306, 2289, 2300, 2290
28307, 2290, 2301, 2291
28308, 2291, 2302, 2292
28309, 2292, 2303, 2293
28310, 2293, 2304, 2294
28311, 2294, 2305, 2295
28312, 2295, 2306, 57
*ELEMENT, type=T3D3, ELSET=Line172
28313, 24, 2310, 2307
28314, 2307, 2311, 2308
28315, 2308, 2312, 2309
28316, 2309, 2313, 58
*ELEMENT, type=T3D3, ELSET=Line173
28317, 58, 2336, 2314
28318, 2314, 2337, 2315
28319, 2315, 2338, 2316
28320, 2316, 2339, 2317
28321, 2317, 2340, 2318
28322, 2318, 2341, 2319
28323, 2319, 2342, 2320
28324, 2320, 2343, 2321
28325, 2321, 2344, 2322
28326, 2322, 2345, 2323
28327, 2323, 2346, 2324
28328, 2324, 2347, 2325
28329, 2325, 2348, 2326
28330, 2326, 2349, 2327
28331, 2327, 2350, 2328
28332, 2328, 2351, 2329
28333, 2329, 2352, 2330
28334, 2330, 2353, 2331
28335, 2331, 2354, 2332
28336, 2332, 2355, 2333
28337, 2333, 2356, 2334
28338, 2334, 2357, 2335
28339, 2335, 2358, 57
*ELEMENT, type=T3D3, ELSET=Line174
28340, 56, 2369, 2359
28341, 2359, 2370, 2360
28342, 2360, 2371, 2361
28343, 2361, 2372, 2362
28344, 2362, 2373, 2363
28345, 2363, 2374, 2364
28346, 2364, 2375, 2365
28347, 2365, 2376, 2366
28348, 2366, 2377, 2367
28349, 2367, 2378, 2368
28350, 2368, 2379, 58
*ELEMENT, type=T3D3, ELSET=Line175
28351, 26, 2383, 2380
28352, 2380, 2384, 2381
28353, 2381, 2385, 2382
28354, 2382, 2386, 59
*ELEMENT, type=T3D3, ELSET=Line176
28355, 57, 2391, 2387
28356, 2387, 2392, 2388
28357, 2388, 2393, 2389
28358, 2389, 2394, 2390
28359, 2390, 2395, 59
*ELEMENT, type=T3D3, ELSET=Line177
28360, 28, 2399, 2396
28361, 2396, 2400, 2397
28362, 2397, 2401, 2398
28363, 2398, 2402, 60
*ELEMENT, type=T3D3, ELSET=Line178
28364, 55, 2407, 2403
28365, 2403, 2408, 2404
28366, 2404, 2409, 2405
28367, 2405, 2410, 2406
28368, 2406, 2411, 60
*ELEMENT, type=T3D3, ELSET=Line179
28369, 60, 2422, 2412
28370, 2412, 2423, 2413
28371, 2413, 2424, 2414
28372, 2414, 2425, 2415
28373, 2415, 2426, 2416
28374, 2416, 2427, 2417
28375, 2417, 2428, 2418
28376, 2418, 2429, 2419
28377, 2419, 2430, 2420
28378, 2420, 2431, 2421
28379, 2421, 2432, 59
*ELEMENT, type=T3D3, ELSET=Line180
28380, 30, 2436, 2433
28381, 2433, 2437, 2434
28382, 2434, 2438, 2435
28383, 2435, 2439, 61
*ELEMENT, type=T3D3, ELSET=Line181
28384, 59, 2462, 2440
28385, 2440, 2463, 2441
28386, 2441, 2464, 2442
28387, 2442, 2465, 2443
28388, 2443, 2466, 2444
28389, 2444, 2467, 2445
28390, 2445, 2468, 2446
28391, 2446, 2469, 2447
28392, 2447, 2470, 2448
28393, 2448, 2471, 2449
28394, 2449, 2472, 2450
28395, 2450, 2473, 2451
28396, 2451, 2474, 2452
28397, 2452, 2475, 2453
28398, 2453, 2476, 2454
28399, 2454, 2477, 2455
28400, 2455, 2478, 2456
28401, 2456, 2479, 2457
28402, 2457, 2480, 2458
28403, 2458, 2481, 2459
28404, 2459, 2482, 2460
28405, 2460, 2483, 2461
28406, 2461, 2484, 61
*ELEMENT, type=T3D3, ELSET=Line182
28407, 32, 2488, 2485
28408, 2485, 2489, 2486
28409, 2486, 2490, 2487
28410, 2487, 2491, 62
*ELEMENT, type=T3D3, ELSET=Line183
28411, 60, 2514, 2492
28412, 2492, 2515, 2493
28413, 2493, 2516, 2494
28414, 2494, 2517, 2495
28415, 2495, 2518, 2496
28416, 2496, 2519, 2497
28417, 2497, 2520, 2498
28418, 2498, 2521, 2499
28419, 2499, 2522, 2500
28420, 2500, 2523, 2501
28421, 2501, 2524, 2502
28422, 2502, 2525, 2503
28423, 2503, 2526, 2504
28424, 2504, 2527, 2505
28425, 2505, 2528, 2506
28426, 2506, 2529, 2507
28427, 2507, 2530, 2508
28428, 2508, 2531, 2509
28429, 2509, 2532, 2510
28430, 2510, 2533, 2511
28431, 2511, 2534, 2512
28432, 2512, 2535, 2513
28433, 2513, 2536, 62
*ELEMENT, type=T3D3, ELSET=Line184
28434, 62, 2547, 2537
28435, 2537, 2548, 2538
28436, 2538, 2549, 2539
28437, 2539, 2550, 2540
28438, 2540, 2551, 2541
28439, 2541, 2552, 2542
28440, 2542, 2553, 2543
28441, 2543, 2554, 2544
28442, 2544, 2555, 2545
28443, 2545, 2556, 2546
28444, 2546, 2557, 61
*ELEMENT, type=T3D3, ELSET=Line185
28445, 6, 2561, 2558
28446, 2558, 2562, 2559
28447, 2559, 2563, 2560
28448, 2560, 2564, 63
*ELEMENT, type=T3D3, ELSET=Line186
28449, 2, 2568, 2565
28450, 2565, 2569, 2566
28451, 2566, 2570, 2567
28452, 2567, 2571, 64
*ELEMENT, type=T3D3, ELSET=Line187
28453, 64, 2594, 2572
28454, 2572, 2595, 2573
28455, 2573, 2596, 2574
28456, 2574, 2597, 2575
28457, 2575, 2598, 2576
28458, 2576, 2599, 2577
28459, 2577, 2600, 2578
28460, 2578, 2601, 2579
28461, 2579, 2602, 2580
28462, 2580, 2603, 2581
28463, 2581, 2604, 2582
28464, 2582, 2605, 2583
28465, 2583, 2606, 2584
28466, 2584, 2607, 2585
28467, 2585, 2608, 2586
28468, 2586, 2609, 2587
28469, 2587, 2610, 2588
28470, 2588, 2611, 2589
28471, 2589, 2612, 2590
28472, 2590, 2613, 2591
28473, 2591, 2614, 2592
28474, 2592, 2615, 2593
28475, 2593, 2616, 63
*ELEMENT, type=T3D3, ELSET=Line188
28476, 5, 2620, 2617
28477, 2617, 2621, 2618
28478, 2618, 2622, 2619
28479, 2619, 2623, 65
*ELEMENT, type=T3D3, ELSET=Line189
28480, 63, 2634, 2624
28481, 2624, 2635, 2625
28482, 2625, 2636, 2626
28483, 2626, 2637, 2627
28484, 2627, 2638, 2628
28485, 2628, 2639, 2629
28486, 2629, 2640, 2630
28487, 2630, 2641, 2631
28488, 2631, 2642, 2632
28489, 2632, 2643, 2633
28490, 2633, 2644, 65
*ELEMENT, type=T3D3, ELSET=Line190
28491, 1, 2648, 2645
28492, 2645, 2649, 2646
28493, 2646, 2650, 2647
28494, 2647, 2651, 66
*ELEMENT, type=T3D3, ELSET=Line191
28495, 66, 2674, 2652
28496, 2652, 2675, 2653
28497, 2653, 2676, 2654
28498, 2654, 2677, 2655
28499, 2655, 2678, 2656
28500, 2656, 2679, 2657
28501, 2657, 2680, 2658
28502, 2658, 2681, 2659
28503, 2659, 2682, 2660
28504, 2660, 2683, 2661
28505, 2661, 2684, 2662
28506, 2662, 2685, 2663
28507, 2663, 2686, 2664
28508, 2664, 2687, 2665
28509, 2665, 2688, 2666
28510, 2666, 2689, 2667
28511, 2667, 2690, 2668
28512, 2668, 2691, 2669
28513, 2669, 2692, 2670
28514, 2670, 2693, 2671
28515, 2671, 2694, 2672
28516, 2672, 2695, 2673
28517, 2673, 2696, 65
*ELEMENT, type=T3D3, ELSET=Line192
28518, 64, 2707, 2697
28519, 2697, 2708, 2698
28520, 2698, 2709, 2699
28521, 2699, 2710, 2700
28522, 2700, 2711, 2701
28523, 2701, 2712, 2702
28524, 2702, 2713, 2703
28525, 2703, 2714, 2704
28526, 2704, 2715, 2705
28527, 2705, 2716, 2706
28528, 2706, 2717, 66
*ELEMENT, type=T3D3, ELSET=Line193
28529, 51, 2721, 2718
28530, 2718, 2722, 2719
28531, 2719, 2723, 2720
28532, 2720, 2724, 67
*ELEMENT, type=T3D3, ELSET=Line194
28533, 66, 2727, 2725
28534, 2725, 2728, 2726
28535, 2726, 2729, 67
*ELEMENT, type=T3D3, ELSET=Line195
28536, 52, 2733, 2730
28537, 2730, 2734, 2731
28538, 2731, 2735, 2732
28539, 2732, 2736, 68
*ELEMENT, type=T3D3, ELSET=Line196
28540, 64, 2739, 2737
28541, 2737, 2740, 2738
28542, 2738, 2741, 68
*ELEMENT, type=T3D3, ELSET=Line197
28543, 68, 2752, 2742
28544, 2742, 2753, 2743
28545, 2743, 2754, 2744
28546, 2744, 2755, 2745
28547, 2745, 2756, 2746
28548, 2746, 2757, 2747
28549, 2747, 2758, 2748
28550, 2748, 2759, 2749
28551, 2749, 2760, 2750
28552, 2750, 2761, 2751
28553, 2751, 2762, 67
*ELEMENT, type=T3D3, ELSET=Line199
28554, 45, 2766, 2763
28555, 2763, 2767, 2764
28556, 2764, 2768, 2765
28557, 2765, 2769, 69
*ELEMENT, type=T3D3, ELSET=Line202
28558, 46, 2773, 2770
28559, 2770, 2774, 2771
28560, 2771, 2775, 2772
28561, 2772, 2776, 70
*ELEMENT, type=T3D3, ELSET=Line205
28562, 70, 2787, 2777
28563, 2777, 2788, 2778
28564, 2778, 2789, 2779
28565, 2779, 2790, 2780
28566, 2780, 2791, 2781
28567, 2781, 2792, 2782
28568, 2782, 2793, 2783
28569, 2783, 2794, 2784
28570, 2784, 2795, 2785
28571, 2785, 2796, 2786
28572, 2786, 2797, 69
*ELEMENT, type=T3D3, ELSET=Line206
28573, 48, 2801, 2798
28574, 2798, 2802, 2799
28575, 2799, 2803, 2800
28576, 2800, 2804, 71
*ELEMENT, type=T3D3, ELSET=Line207
28577, 69, 2807, 2805
28578, 2805, 2808, 2806
28579, 2806, 2809, 71
*ELEMENT, type=T3D3, ELSET=Line208
28580, 50, 2813, 2810
28581, 2810, 2814, 2811
28582, 2811, 2815, 2812
28583, 2812, 2816, 72
*ELEMENT, type=T3D3, ELSET=Line209
28584, 70, 2819, 2817
28585, 2817, 2820, 2818
28586, 2818, 2821, 72
*ELEMENT, type=T3D3, ELSET=Line210
28587, 72, 2832, 2822
28588, 2822, 2833, 2823
28589, 2823, 2834, 2824
28590, 2824, 2835, 2825
28591, 2825, 2836, 2826
28592, 2826, 2837, 2827
28593, 2827, 2838, 2828
28594, 2828, 2839, 2829
28595, 2829, 2840, 2830
28596, 2830, 2841, 2831
28597, 2831, 2842, 71
*ELEMENT, type=T3D3, ELSET=Line219
28598, 24, 2845, 2843
28599, 2843, 2846, 2844
28600, 2844, 2847, 73
*ELEMENT, type=T3D3, ELSET=Line220
28601, 58, 2850, 2848
28602, 2848, 2851, 2849
28603, 2849, 2852, 74
*ELEMENT, type=T3D3, ELSET=Line221
28604, 73, 2856, 2853
28605, 2853, 2857, 2854
28606, 2854, 2858, 2855
28607, 2855, 2859, 74
*ELEMENT, type=T3D3, ELSET=Line222
28608, 22, 2862, 2860
28609, 2860, 2863, 2861
28610, 2861, 2864, 75
*ELEMENT, type=T3D3, ELSET=Line223
28611, 56, 2867, 2865
28612, 2865, 2868, 2866
28613, 2866, 2869, 76
*ELEMENT, type=T3D3, ELSET=Line224
28614, 75, 2873, 2870
28615, 2870, 2874, 2871
28616, 2871, 2875, 2872
28617, 2872, 2876, 76
*ELEMENT, type=T3D3, ELSET=Line225
28618, 75, 2887, 2877
28619, 2877, 2888, 2878
28620, 2878, 2889, 2879
28621, 2879, 2890, 2880
28622, 2880, 2891, 2881
28623, 2881, 2892, 2882
28624, 2882, 2893, 2883
28625, 2883, 2894, 2884
28626, 2884, 2895, 2885
28627, 2885, 2896, 2886
28628, 2886, 2897, 73
*ELEMENT, type=T3D3, ELSET=Line226
28629, 76, 2908, 2898
28630, 2898, 2909, 2899
28631, 2899, 2910, 2900
28632, 2900, 2911, 2901
28633, 2901, 2912, 2902
28634, 2902, 2913, 2903
28635, 2903, 2914, 2904
28636, 2904, 2915, 2905
28637, 2905, 2916, 2906
28638, 2906, 2917, 2907
28639, 2907, 2918, 74
*ELEMENT, type=T3D3, ELSET=Line227
28640, 20, 2921, 2919
28641, 2919, 2922, 2920
28642, 2920, 2923, 77
*ELEMENT, type=T3D3, ELSET=Line228
28643, 77, 2926, 2924
28644, 2924, 2927, 2925
28645, 2925, 2928, 73
*ELEMENT, type=T3D3, ELSET=Line229
28646, 18, 2931, 2929
28647, 2929, 2932, 2930
28648, 2930, 2933, 78
*ELEMENT, type=T3D3, ELSET=Line230
28649, 78, 2936, 2934
28650, 2934, 2937, 2935
28651, 2935, 2938, 75
*ELEMENT, type=T3D3, ELSET=Line231
28652, 78, 2949, 2939
28653, 2939, 2950, 2940
28654, 2940, 2951, 2941
28655, 2941, 2952, 2942
28656, 2942, 2953, 2943
28657, 2943, 2954, 2944
28658, 2944, 2955, 2945
28659, 2945, 2956, 2946
28660, 2946, 2957, 2947
28661, 2947, 2958, 2948
28662, 2948, 2959, 77
*ELEMENT, type=T3D3, ELSET=Line232
28663, 30, 2962, 2960
28664, 2960, 2963, 2961
28665, 2961, 2964, 79
*ELEMENT, type=T3D3, ELSET=Line233
28666, 61, 2967, 2965
28667, 2965, 2968, 2966
28668, 2966, 2969, 80
*ELEMENT, type=T3D3, ELSET=Line234
28669, 79, 2973, 2970
28670, 2970, 2974, 2971
28671, 2971, 2975, 2972
28672, 2972, 2976, 80
*ELEMENT, type=T3D3, ELSET=Line235
28673, 32, 2979, 2977
28674, 2977, 2980, 2978
28675, 2978, 2981, 81
*ELEMENT, type=T3D3, ELSET=Line236
28676, 62, 2984, 2982
28677, 2982, 2985, 2983
28678, 2983, 2986, 82
*ELEMENT, type=T3D3, ELSET=Line237
28679, 81, 2990, 2987
28680, 2987, 2991, 2988
28681, 2988, 2992, 2989
28682, 2989, 2993, 82
*ELEMENT, type=T3D3, ELSET=Line238
28683, 81, 3004, 2994
28684, 2994, 3005, 2995
28685, 2995, 3006, 2996
28686, 2996, 3007, 2997
28687, 2997, 3008, 2998
28688, 2998, 3009, 2999
28689, 2999, 3010, 3000
28690, 3000, 3011, 3001
28691, 3001, 3012, 3002
28692, 3002, 3013, 3003
28693, 3003, 3014, 79
*ELEMENT, type=T3D3, ELSET=Line239
28694, 82, 3025, 3015
28695, 3015, 3026, 3016
28696, 3016, 3027, 3017
28697, 3017, 3028, 3018
28698, 3018, 3029, 3019
28699, 3019, 3030, 3020
28700, 3020, 3031, 3021
28701, 3021, 3032, 3022
28702, 3022, 3033, 3023
28703, 3023, 3034, 3024
28704, 3024, 3035, 80
*ELEMENT, type=T3D3, ELSET=Line240
28705, 29, 3038, 3036
28706, 3036, 3039, 3037
28707, 3037, 3040, 83
*ELEMENT, type=T3D3, ELSET=Line241
28708, 83, 3043, 3041
28709, 3041, 3044, 3042
28710, 3042, 3045, 79
*ELEMENT, type=T3D3, ELSET=Line242
28711, 31, 3048, 3046
28712, 3046, 3049, 3047
28713, 3047, 3050, 84
*ELEMENT, type=T3D3, ELSET=Line243
28714, 84, 3053, 3051
28715, 3051, 3054, 3052
28716, 3052, 3055, 81
*ELEMENT, type=T3D3, ELSET=Line244
28717, 84, 3066, 3056
28718, 3056, 3067, 3057
28719, 3057, 3068, 3058
28720, 3058, 3069, 3059
28721, 3059, 3070, 3060
28722, 3060, 3071, 3061
28723, 3061, 3072, 3062
28724, 3062, 3073, 3063
28725, 3063, 3074, 3064
28726, 3064, 3075, 3065
28727, 3065, 3076, 83
*ELEMENT, type=T3D3, ELSET=Line245
28728, 41, 3079, 3077
28729, 3077, 3080, 3078
28730, 3078, 3081, 85
*ELEMENT, type=T3D3, ELSET=Line246
28731, 85, 3104, 3082
28732, 3082, 3105, 3083
28733, 3083, 3106, 3084
28734, 3084, 3107, 3085
28735, 3085, 3108, 3086
28736, 3086, 3109, 3087
28737, 3087, 3110, 3088
28738, 3088, 3111, 3089
28739, 3089, 3112, 3090
28740, 3090, 3113, 3091
28741, 3091, 3114, 3092
28742, 3092, 3115, 3093
28743, 3093, 3116, 3094
28744, 3094, 3117, 3095
28745, 3095, 3118, 3096
28746, 3096, 3119, 3097
28747, 3097, 3120, 3098
28748, 3098, 3121, 3099
28749, 3099, 3122, 3100
28750, 3100, 3123, 3101
28751, 3101, 3124, 3102
28752, 3102, 3125, 3103
28753, 3103, 3126, 45
*ELEMENT, type=T3D3, ELSET=Line247
28754, 43, 3129, 3127
28755, 3127, 3130, 3128
28756, 3128, 3131, 86
*ELEMENT, type=T3D3, ELSET=Line248
28757, 86, 3154, 3132
28758, 3132, 3155, 3133
28759, 3133, 3156, 3134
28760, 3134, 3157, 3135
28761, 3135, 3158, 3136
28762, 3136, 3159, 3137
28763, 3137, 3160, 3138
28764, 3138, 3161, 3139
28765, 3139, 3162, 3140
28766, 3140, 3163, 3141
28767, 3141, 3164, 3142
28768, 3142, 3165, 3143
28769, 3143, 3166, 3144
28770, 3144, 3167, 3145
28771, 3145, 3168, 3146
28772, 3146, 3169, 3147
28773, 3147, 3170, 3148
28774, 3148, 3171, 3149
28775, 3149, 3172, 3150
28776, 3150, 3173, 3151
28777, 3151, 3174, 3152
28778, 3152, 3175, 3153
28779, 3153, 3176, 46
*ELEMENT, type=T3D3, ELSET=Line249
28780, 86, 3187, 3177
28781, 3177, 3188, 3178
28782, 3178, 3189, 3179
28783, 3179, 3190, 3180
28784, 3180, 3191, 3181
28785, 3181, 3192, 3182
28786, 3182, 3193, 3183
28787, 3183, 3194, 3184
28788, 3184, 3195, 3185
28789, 3185, 3196, 3186
28790, 3186, 3197, 85
*ELEMENT, type=T3D3, ELSET=Line250
28791, 85, 3201, 3198
28792, 3198, 3202, 3199
28793, 3199, 3203, 3200
28794, 3200, 3204, 87
*ELEMENT, type=T3D3, ELSET=Line251
28795, 87, 3227, 3205
28796, 3205, 3228, 3206
28797, 3206, 3229, 3207
28798, 3207, 3230, 3208
28799, 3208, 3231, 3209
28800, 3209, 3232, 3210
28801, 3210, 3233, 3211
28802, 3211, 3234, 3212
28803, 3212, 3235, 3213
28804, 3213, 3236, 3214
28805, 3214, 3237, 3215
28806, 3215, 3238, 3216
28807, 3216, 3239, 3217
28808, 3217, 3240, 3218
28809, 3218, 3241, 3219
28810, 3219, 3242, 3220
28811, 3220, 3243, 3221
28812, 3221, 3244, 3222
28813, 3222, 3245, 3223
28814, 3223, 3246, 3224
28815, 3224, 3247, 3225
28816, 3225, 3248, 3226
28817, 3226, 3249, 69
*ELEMENT, type=T3D3, ELSET=Line252
28818, 86, 3253, 3250
28819, 3250, 3254, 3251
28820, 3251, 3255, 3252
28821, 3252, 3256, 88
*ELEMENT, type=T3D3, ELSET=Line253
28822, 88, 3279, 3257
28823, 3257, 3280, 3258
28824, 3258, 3281, 3259
28825, 3259, 3282, 3260
28826, 3260, 3283, 3261
28827, 3261, 3284, 3262
28828, 3262, 3285, 3263
28829, 3263, 3286, 3264
28830, 3264, 3287, 3265
28831, 3265, 3288, 3266
28832, 3266, 3289, 3267
28833, 3267, 3290, 3268
28834, 3268, 3291, 3269
28835, 3269, 3292, 3270
28836, 3270, 3293, 3271
28837, 3271, 3294, 3272
28838, 3272, 3295, 3273
28839, 3273, 3296, 3274
28840, 3274, 3297, 3275
28841, 3275, 3298, 3276
28842, 3276, 3299, 3277
28843, 3277, 3300, 3278
28844, 3278, 3301, 70
*ELEMENT, type=T3D3, ELSET=Line254
28845, 88, 3312, 3302
28846, 3302, 3313, 3303
28847, 3303, 3314, 3304
28848, 3304, 3315, 3305
28849, 3305, 3316, 3306
28850, 3306, 3317, 3307
28851, 3307, 3318, 3308
28852, 3308, 3319, 3309
28853, 3309, 3320, 3310
28854, 3310, 3321, 3311
28855, 3311, 3322, 87
*ELEMENT, type=T3D3, ELSET=Line255
28856, 5, 3327, 3323
28857, 3323, 3328, 3324
28858, 3324, 3329, 3325
28859, 3325, 3330, 3326
28860, 3326, 3331, 85
*ELEMENT, type=T3D3, ELSET=Line256
28861, 65, 3336, 3332
28862, 3332, 3337, 3333
28863, 3333, 3338, 3334
28864, 3334, 3339, 3335
28865, 3335, 3340, 87
*ELEMENT, type=T3D3, ELSET=Line257
28866, 6, 3345, 3341
28867, 3341, 3346, 3342
28868, 3342, 3347, 3343
28869, 3343, 3348, 3344
28870, 3344, 3349, 86
*ELEMENT, type=T3D3, ELSET=Line258
28871, 63, 3354, 3350
28872, 3350, 3355, 3351
28873, 3351, 3356, 3352
28874, 3352, 3357, 3353
28875, 3353, 3358, 88
*ELEMENT, type=CPS8, ELSET=Surface1
28876, 2, 89, 3359, 136, 99, 3379, 3380, 138
28877, 136, 3359, 3360, 137, 3380, 3381, 3382, 139
28878, 137, 3360, 115, 4, 3382, 3383, 125, 140
28879, 89, 90, 3361, 3359, 100, 3384, 3385, 3379
28880, 3359, 3361, 3362, 3360, 3385, 3386, 3387, 3381
28881, 3360, 3362, 116, 115, 3387, 3388, 126, 3383
28882, 90, 91, 3363, 3361, 101, 3389, 3390, 3384
28883, 3361, 3363, 3364, 3362, 3390, 3391, 3392, 3386
28884, 3362, 3364, 117, 116, 3392, 3393, 127, 3388
28885, 91, 92, 3365, 3363, 102, 3394, 3395, 3389
28886, 3363, 3365, 3366, 3364, 3395, 3396, 3397, 3391
28887, 3364, 3366, 118, 117, 3397, 3398, 128, 3393
28888, 92, 93, 3367, 3365, 103, 3399, 3400, 3394
28889, 3365, 3367, 3368, 3366, 3400, 3401, 3402, 3396
28890, 3366, 3368, 119, 118, 3402, 3403, 129, 3398
28891, 93, 94, 3369, 3367, 104, 3404, 3405, 3399
28892, 3367, 3369, 3370, 3368, 3405, 3406, 3407, 3401
28893, 3368, 3370, 120, 119, 3407, 3408, 130, 3403
28894, 94, 95, 3371, 3369, 105, 3409, 3410, 3404
28895, 3369, 3371, 3372, 3370, 3410, 3411, 3412, 3406
28896, 3370, 3372, 121, 120, 3412, 3413, 131, 3408
28897, 95, 96, 3373, 3371, 106, 3414, 3415, 3409
28898, 3371, 3373, 3374, 3372, 3415, 3416, 3417, 3411
28899, 3372, 3374, 122, 121, 3417, 3418, 132, 3413
28900, 96, 97, 3375, 3373, 107, 3419, 3420, 3414
28901, 3373, 3375, 3376, 3374, 3420, 3421, 3422, 3416
28902, 3374, 3376, 123, 122, 3422, 3423, 133, 3418
28903, 97, 98, 3377, 3375, 108, 3424, 3425, 3419
28904, 3375, 3377, 3378, 3376, 3425, 3426, 3427, 3421
28905, 3376, 3378, 124, 123, 3427, 3428, 134, 3423
28906, 98, 1, 110, 3377, 109, 112, 3429, 3424
28907, 3377, 110, 111, 3378, 3429, 113, 3430, 3426
28908, 3378, 111, 3, 124, 3430, 114, 135, 3428
*ELEMENT, type=CPS8, ELSET=Surface2
28909, 6, 188, 3431, 141, 190, 3451, 3452, 151
28910, 188, 189, 3432, 3431, 191, 3453, 3454, 3451
28911, 189, 8, 167, 3432, 192, 177, 3455, 3453
28912, 141, 3431, 3433, 142, 3452, 3456, 3457, 152
28913, 3431, 3432, 3434, 3433, 3454, 3458, 3459, 3456
28914, 3432, 167, 168, 3434, 3455, 178, 3460, 3458
28915, 142, 3433, 3435, 143, 3457, 3461, 3462, 153
28916, 3433, 3434, 3436, 3435, 3459, 3463, 3464, 3461
28917, 3434, 168, 169, 3436, 3460, 179, 3465, 3463
28918, 143, 3435, 3437, 144, 3462, 3466, 3467, 154
28919, 3435, 3436, 3438, 3437, 3464, 3468, 3469, 3466
28920, 3436, 169, 170, 3438, 3465, 180, 3470, 3468
28921, 144, 3437, 3439, 145, 3467, 3471, 3472, 155
28922, 3437, 3438, 3440, 3439, 3469, 3473, 3474, 3471
28923, 3438, 170, 171, 3440, 3470, 181, 3475, 3473
28924, 145, 3439, 3441, 146, 3472, 3476, 3477, 156
28925, 3439, 3440, 3442, 3441, 3474, 3478, 3479, 3476
28926, 3440, 171, 172, 3442, 3475, 182, 3480, 3478
28927, 146, 3441, 3443, 147, 3477, 3481, 3482, 157
28928, 3441, 3442, 3444, 3443, 3479, 3483, 3484, 3481
28929, 3442, 172, 173, 3444, 3480, 183, 3485, 3483
28930, 147, 3443, 3445, 148, 3482, 3486, 3487, 158
28931, 3443, 3444, 3446, 3445, 3484, 3488, 3489, 3486
28932, 3444, 173, 174, 3446, 3485, 184, 3490, 3488
28933, 148, 3445, 3447, 149, 3487, 3491, 3492, 159
28934, 3445, 3446, 3448, 3447, 3489, 3493, 3494, 3491
28935, 3446, 174, 175, 3448, 3490, 185, 3495, 3493
28936, 149, 3447, 3449, 150, 3492, 3496, 3497, 160
28937, 3447, 3448, 3450, 3449, 3494, 3498, 3499, 3496
28938, 3448, 175, 176, 3450, 3495, 186, 3500, 3498
28939, 150, 3449, 162, 5, 3497, 3501, 164, 161
28940, 3449, 3450, 163, 162, 3499, 3502, 165, 3501
28941, 3450, 176, 7, 163, 3500, 187, 166, 3502
*ELEMENT, type=CPS8, ELSET=Surface3
1, 2, 193, 3503, 89, 215, 3723, 3724, 99
2, 89, 3503, 3504, 90, 3724, 3725, 3726, 100
3, 90, 3504, 3505, 91, 3726, 3727, 3728, 101
4, 91, 3505, 3506, 92, 3728, 3729, 3730, 102
5, 92, 3506, 3507, 93, 3730, 3731, 3732, 103
6, 93, 3507, 3508, 94, 3732, 3733, 3734, 104
7, 94, 3508, 3509, 95, 3734, 3735, 3736, 105
8, 95, 3509, 3510, 96, 3736, 3737, 3738, 106
9, 96, 3510, 3511, 97, 3738, 3739, 3740, 107
10, 97, 3511, 3512, 98, 3740, 3741, 3742, 108
11, 98, 3512, 238, 1, 3742, 3743, 260, 109
12, 193, 194, 3513, 3503, 216, 3744, 3745, 3723
13, 3503, 3513, 3514, 3504, 3745, 3746, 3747, 3725
14, 3504, 3514, 3515, 3505, 3747, 3748, 3749, 3727
15, 3505, 3515, 3516, 3506, 3749, 3750, 3751, 3729
16, 3506, 3516, 3517, 3507, 3751, 3752, 3753, 3731
17, 3507, 3517, 3518, 3508, 3753, 3754, 3755, 3733
18, 3508, 3518, 3519, 3509, 3755, 3756, 3757, 3735
19, 3509, 3519, 3520, 3510, 3757, 3758, 3759, 3737
20, 3510, 3520, 3521, 3511, 3759, 3760, 3761, 3739
21, 3511, 3521, 3522, 3512, 3761, 3762, 3763, 3741
22, 3512, 3522, 239, 238, 3763, 3764, 261, 3743
23, 194, 195, 3523, 3513, 217, 3765, 3766, 3744
24, 3513, 3523, 3524, 3514, 3766, 3767, 3768, 3746
25, 3514, 3524, 3525, 3515, 3768, 3769, 3770, 3748
26, 3515, 3525, 3526, 3516, 3770, 3771, 3772, 3750
27, 3516, 3526, 3527, 3517, 3772, 3773, 3774, 3752
28, 3517, 3527, 3528, 3518, 3774, 3775, 3776, 3754
29, 3518, 3528, 3529, 3519, 3776, 3777, 3778, 3756
30, 3519, 3529, 3530, 3520, 3778, 3779, 3780, 3758
31, 3520, 3530, 3531, 3521, 3780, 3781, 3782, 3760
32, 3521, 3531, 3532, 3522, 3782, 3783, 3784, 3762
33, 3522, 3532, 240, 239, 3784, 3785, 262, 3764
34, 195, 196, 3533, 3523, 218, 3786, 3787, 3765
35, 3523, 3533, 3534, 3524, 3787, 3788, 3789, 3767
36, 3524, 3534, 3535, 3525, 3789, 3790, 3791, 3769
37, 3525, 3535, 3536, 3526, 3791, 3792, 3793, 3771
38, 3526, 3536, 3537, 3527, 3793, 3794, 3795, 3773
39, 3527, 3537, 3538, 3528, 3795, 3796, 3797, 3775
40, 3528, 3538, 3539, 3529, 3797, 3798, 3799, 3777
41, 3529, 3539, 3540, 3530, 3799, 3800, 3801, 3779
42, 3530, 3540, 3541, 3531, 3801, 3802, 3803, 3781
43, 3531, 3541, 3542, 3532, 3803, 3804, 3805, 3783
44, 3532, 3542, 241, 240, 3805, 3806, 263, 3785
45, 196, 197, 3543, 3533, 219, 3807, 3808, 3786
46, 3533, 3543, 3544, 3534, 3808, 3809, 3810, 3788
47, 3534, 3544, 3545, 3535, 3810, 3811, 3812, 3790
48, 3535, 3545, 3546, 3536, 3812, 3813, 3814, 3792
49, 3536, 3546, 3547, 3537, 3814, 3815, 3816, 3794
50, 3537, 3547, 3548, 3538, 3816, 3817, 3818, 3796
51, 3538, 3548, 3549, 3539, 3818, 3819, 3820, 3798
52, 3539, 3549, 3550, 3540, 3820, 3821, 3822, 3800
53, 3540, 3550, 3551, 3541, 3822, 3823, 3824, 3802
54, 3541, 3551, 3552, 3542, 3824, 3825, 3826, 3804
55, 3542, 3552, 242, 241, 3826, 3827, 264, 3806
56, 197, 198, 3553, 3543, 220, 3828, 3829, 3807
57, 3543, 3553, 3554, 3544, 3829, 3830, 3831, 3809
58, 3544, 3554, 3555, 3545, 3831, 3832, 3833, 3811
59, 3545, 3555, 3556, 3546, 3833, 3834, 3835, 3813
60, 3546, 3556, 3557, 3547, 3835, 3836, 3837, 3815
61, 3547, 3557, 3558, 3548, 3837, 3838, 3839, 3817
62, 3548, 3558, 3559, 3549, 3839, 3840, 3841, 3819
63, 3549, 3559, 3560, 3550, 3841, 3842, 3843, 3821
64, 3550, 3560, 3561, 3551, 3843, 3844, 3845, 3823
65, 3551, 3561, 3562, 3552, 3845, 3846, 3847, 3825
66, 3552, 3562, 243, 242, 3847, 3848, 265, 3827
67, 198, 199, 3563, 3553, 221, 3849, 3850, 3828
68, 3553, 3563, 3564, 3554, 3850, 3851, 3852, 3830
69, 3554, 3564, 3565, 3555, 3852, 3853, 3854, 3832
70, 3555, 3565, 3566, 3556, 3854, 3855, 3856, 3834
71, 3556, 3566, 3567, 3557, 3856, 3857, 3858, 3836
72, 3557, 3567, 3568, 3558, 3858, 3859, 3860, 3838
73, 3558, 3568, 3569, 3559, 3860, 3861, 3862, 3840
74, 3559, 3569, 3570, 3560, 3862, 3863, 3864, 3842
75, 3560, 3570, 3571, 3561, 3864, 3865, 3866, 3844
76, 3561, 3571, 3572, 3562, 3866, 3867, 3868, 3846
77, 3562, 3572, 244, 243, 3868, 3869, 266, 3848
78, 199, 200, 3573, 3563, 222, 3870, 3871, 3849
79, 3563, 3573, 3574, 3564, 3871, 3872, 3873, 3851
80, 3564, 3574, 3575, 3565, 3873, 3874, 3875, 3853
81, 3565, 3575, 3576, 3566, 3875, 3876, 3877, 3855
82, 3566, 3576, 3577, 3567, 3877, 3878, 3879, 3857
83, 3567, 3577, 3578, 3568, 3879, 3880, 3881, 3859
84, 3568, 3578, 3579, 3569, 3881, 3882, 3883, 3861
85, 3569, 3579, 3580, 3570, 3883, 3884, 3885, 3863
86, 3570, 3580, 3581, 3571, 3885, 3886, 3887, 3865
87, 3571, 3581, 3582, 3572, 3887, 3888, 3889, 3867
88, 3572, 3582, 245, 244, 3889, 3890, 267, 3869
89, 200, 201, 3583, 3573, 223, 3891, 3892, 3870
90, 3573, 3583, 3584, 3574, 3892, 3893, 3894, 3872
91, 3574, 3584, 3585, 3575, 3894, 3895, 3896, 3874
92, 3575, 3585, 3586, 3576, 3896, 3897, 3898, 3876
93, 3576, 3586, 3587, 3577, 3898, 3899, 3900, 3878
94, 3577, 3587, 3588, 3578, 3900, 3901, 3902, 3880
95, 3578, 3588, 3589, 3579, 3902, 3903, 3904, 3882
96, 3579, 3589, 3590, 3580, 3904, 3905, 3906, 3884
97, 3580, 3590, 3591, 3581, 3906, 3907, 3908, 3886
98, 3581, 3591, 3592, 3582, 3908, 3909, 3910, 3888
99, 3582, 3592, 246, 245, 3910, 3911, 268, 3890
100, 201, 202, 3593, 3583, 224, 3912, 3913, 3891
101, 3583, 3593, 3594, 3584, 3913, 3914, 3915, 3893
102, 3584, 3594, 3595, 3585, 3915, 3916, 3917, 3895
103, 3585, 3595, 3596, 3586, 3917, 3918, 3919, 3897
104, 3586, 3596, 3597, 3587, 3919, 3920, 3921, 3899
105, 3587, 3597, 3598, 3588, 3921, 3922, 3923, 3901
106, 3588, 3598, 3599, 3589, 3923, 3924, 3925, 3903
107, 3589, 3599, 3600, 3590, 3925, 3926, 3927, 3905
108, 3590, 3600, 3601, 3591, 3927, 3928, 3929, 3907
109, 3591, 3601, 3602, 3592, 3929, 3930, 3931, 3909
110, 3592, 3602, 247, 246, 3931, 3932, 269, 3911
111, 202, 203, 3603, 3593, 225, 3933, 3934, 3912
112, 3593, 3603, 3604, 3594, 3934, 3935, 3936, 3914
113, 3594, 3604, 3605, 3595, 3936, 3937, 3938, 3916
114, 3595, 3605, 3606, 3596, 3938, 3939, 3940, 3918
115, 3596, 3606, 3607, 3597, 3940, 3941, 3942, 3920
116, 3597, 3607, 3608, 3598, 3942, 3943, 3944, 3922
117, 3598, 3608, 3609, 3599, 3944, 3945, 3946, 3924
118, 3599, 3609, 3610, 3600, 3946, 3947, 3948, 3926
119, 3600, 3610, 3611, 3601, 3948, 3949, 3950, 3928
120, 3601, 3611, 3612, 3602, 3950, 3951, 3952, 3930
121, 3602, 3612, 248, 247, 3952, 3953, 270, 3932
122, 203, 204, 3613, 3603, 226, 3954, 3955, 3933
123, 3603, 3613, 3614, 3604, 3955, 3956, 3957, 3935
124, 3604, 3614, 3615, 3605, 3957, 3958, 3959, 3937
125, 3605, 3615, 3616, 3606, 3959, 3960, 3961, 3939
126, 3606, 3616, 3617, 3607, 3961, 3962, 3963, 3941
127, 3607, 3617, 3618, 3608, 3963, 3964, 3965, 3943
128, 3608, 3618, 3619, 3609, 3965, 3966, 3967, 3945
129, 3609, 3619, 3620, 3610, 3967, 3968, 3969, 3947
130, 3610, 3620, 3621, 3611, 3969, 3970, 3971, 3949
131, 3611, 3621, 3622, 3612, 3971, 3972, 3973, 3951
132, 3612, 3622, 249, 248, 3973, 3974, 271, 3953
133, 204, 205, 3623, 3613, 227, 3975, 3976, 3954
134, 3613, 3623, 3624, 3614, 3976, 3977, 3978, 3956
135, 3614, 3624, 3625, 3615, 3978, 3979, 3980, 3958
136, 3615, 3625, 3626, 3616, 3980, 3981, 3982, 3960
137, 3616, 3626, 3627, 3617, 3982, 3983, 3984, 3962
138, 3617, 3627, 3628, 3618, 3984, 3985, 3986, 3964
139, 3618, 3628, 3629, 3619, 3986, 3987, 3988, 3966
140, 3619, 3629, 3630, 3620, 3988, 3989, 3990, 3968
141, 3620, 3630, 3631, 3621, 3990, 3991, 3992, 3970
142, 3621, 3631, 3632, 3622, 3992, 3993, 3994, 3972
143, 3622, 3632, 250, 249, 3994, 3995, 272, 3974
144, 205, 206, 3633, 3623, 228, 3996, 3997, 3975
145, 3623, 3633, 3634, 3624, 3997, 3998, 3999, 3977
146, 3624, 3634, 3635, 3625, 3999, 4000, 4001, 3979
147, 3625, 3635, 3636, 3626, 4001, 4002, 4003, 3981
148, 3626, 3636, 3637, 3627, 4003, 4004, 4005, 3983
149, 3627, 3637, 3638, 3628, 4005, 4006, 4007, 3985
150, 3628, 3638, 3639, 3629, 4007, 4008, 4009, 3987
151, 3629, 3639, 3640, 3630, 4009, 4010, 4011, 3989
152, 3630, 3640, 3641, 3631, 4011, 4012, 4013, 3991
153, 3631, 3641, 3642, 3632, 4013, 4014, 4015, 3993
154, 3632, 3642, 251, 250, 4015, 4016, 273, 3995
155, 206, 207, 3643, 3633, 229, 4017, 4018, 3996
156, 3633, 3643, 3644, 3634, 4018, 4019, 4020, 3998
157, 3634, 3644, 3645, 3635, 4020, 4021, 4022, 4000
158, 3635, 3645, 3646, 3636, 4022, 4023, 4024, 4002
159, 3636, 3646, 3647, 3637, 4024, 4025, 4026, 4004
160, 3637, 3647, 3648, 3638, 4026, 4027, 4028, 4006
161, 3638, 3648, 3649, 3639, 4028, 4029, 4030, 4008
162, 3639, 3649, 3650, 3640, 4030, 4031, 4032, 4010
163, 3640, 3650, 3651, 3641, 4032, 4033, 4034, 4012
164, 3641, 3651, 3652, 3642, 4034, 4035, 4036, 4014
165, 3642, 3652, 252, 251, 4036, 4037, 274, 4016
166, 207, 208, 3653, 3643, 230, 4038, 4039, 4017
167, 3643, 3653, 3654, 3644, 4039, 4040, 4041, 4019
168, 3644, 3654, 3655, 3645, 4041, 4042, 4043, 4021
169, 3645, 3655, 3656, 3646, 4043, 4044, 4045, 4023
170, 3646, 3656, 3657, 3647, 4045, 4046, 4047, 4025
171, 3647, 3657, 3658, 3648, 4047, 4048, 4049, 4027
172, 3648, 3658, 3659, 3649, 4049, 4050, 4051, 4029
173, 3649, 3659, 3660, 3650, 4051, 4052, 4053, 4031
174, 3650, 3660, 3661, 3651, 4053, 4054, 4055, 4033
175, 3651, 3661, 3662, 3652, 4055, 4056, 4057, 4035
176, 3652, 3662, 253, 252, 4057, 4058, 275, 4037
177, 208, 209, 3663, 3653, 231, 4059, 4060, 4038
178, 3653, 3663, 3664, 3654, 4060, 4061, 4062, 4040
179, 3654, 3664, 3665, 3655, 4062, 4063, 4064, 4042
180, 3655, 3665, 3666, 3656, 4064, 4065, 4066, 4044
181, 3656, 3666, 3667, 3657, 4066, 4067, 4068, 4046
182, 3657, 3667, 3668, 3658, 4068, 4069, 4070, 4048
183, 3658, 3668, 3669, 3659, 4070, 4071, 4072, 4050
184, 3659, 3669, 3670, 3660, 4072, 4073, 4074, 4052
185, 3660, 3670, 3671, 3661, 4074, 4075, 4076, 4054
186, 3661, 3671, 3672, 3662, 4076, 4077, 4078, 4056
187, 3662, 3672, 254, 253, 4078, 4079, 276, 4058
188, 209, 210, 3673, 3663, 232, 4080, 4081, 4059
189, 3663, 3673, 3674, 3664, 4081, 4082, 4083, 4061
190, 3664, 3674, 3675, 3665, 4083, 4084, 4085, 4063
191, 3665, 3675, 3676, 3666, 4085, 4086, 4087, 4065
192, 3666, 3676, 3677, 3667, 4087, 4088, 4089, 4067
193, 3667, 3677, 3678, 3668, 4089, 4090, 4091, 4069
194, 3668, 3678, 3679, 3669, 4091, 4092, 4093, 4071
195, 3669, 3679, 3680, 3670, 4093, 4094, 4095, 4073
196, 3670, 3680, 3681, 3671, 4095, 4096, 4097, 4075
197, 3671, 3681, 3682, 3672, 4097, 4098, 4099, 4077
198, 3672, 3682, 255, 254, 4099, 4100, 277, 4079
199, 210, 211, 3683, 3673, 233, 4101, 4102, 4080
200, 3673, 3683, 3684, 3674, 4102, 4103, 4104, 4082
201, 3674, 3684, 3685, 3675, 4104, 4105, 4106, 4084
202, 3675, 3685, 3686, 3676, 4106, 4107, 4108, 4086
203, 3676, 3686, 3687, 3677, 4108, 4109, 4110, 4088
204, 3677, 3687, 3688, 3678, 4110, 4111, 4112, 4090
205, 3678, 3688, 3689, 3679, 4112, 4113, 4114, 4092
206, 3679, 3689, 3690, 3680, 4114, 4115, 4116, 4094
207, 3680, 3690, 3691, 3681, 4116, 4117, 4118, 4096
208, 3681, 3691, 3692, 3682, 4118, 4119, 4120, 4098
209, 3682, 3692, 256, 255, 4120, 4121, 278, 4100
210, 211, 212, 3693, 3683, 234, 4122, 4123, 4101
211, 3683, 3693, 3694, 3684, 4123, 4124, 4125, 4103
212, 3684, 3694, 3695, 3685, 4125, 4126, 4127, 4105
213, 3685, 3695, 3696, 3686, 4127, 4128, 4129, 4107
214, 3686, 3696, 3697, 3687, 4129, 4130, 4131, 4109
215, 3687, 3697, 3698, 3688, 4131, 4132, 4133, 4111
216, 3688, 3698, 3699, 3689, 4133, 4134, 4135, 4113
217, 3689, 3699, 3700, 3690, 4135, 4136, 4137, 4115
218, 3690, 3700, 3701, 3691, 4137, 4138, 4139, 4117
219, 3691, 3701, 3702, 3692, 4139, 4140, 4141, 4119
220, 3692, 3702, 257, 256, 4141, 4142, 279, 4121
221, 212, 213, 3703, 3693, 235, 4143, 4144, 4122
222, 3693, 3703, 3704, 3694, 4144, 4145, 4146, 4124
223, 3694, 3704, 3705, 3695, 4146, 4147, 4148, 4126
224, 3695, 3705, 3706, 3696, 4148, 4149, 4150, 4128
225, 3696, 3706, 3707, 3697, 4150, 4151, 4152, 4130
226, 3697, 3707, 3708, 3698, 4152, 4153, 4154, 4132
227, 3698, 3708, 3709, 3699, 4154, 4155, 4156, 4134
228, 3699, 3709, 3710, 3700, 4156, 4157, 4158, 4136
229, 3700, 3710, 3711, 3701, 4158, 4159, 4160, 4138
230, 3701, 3711, 3712, 3702, 4160, 4161, 4162, 4140
231, 3702, 3712, 258, 257, 4162, 4163, 280, 4142
232, 213, 214, 3713, 3703, 236, 4164, 4165, 4143
233, 3703, 3713, 3714, 3704, 4165, 4166, 4167, 4145
234, 3704, 3714, 3715, 3705, 4167, 4168, 4169, 4147
235, 3705, 3715, 3716, 3706, 4169, 4170, 4171, 4149
236, 3706, 3716, 3717, 3707, 4171, 4172, 4173, 4151
237, 3707, 3717, 3718, 3708, 4173, 4174, 4175, 4153
238, 3708, 3718, 3719, 3709, 4175, 4176, 4177, 4155
239, 3709, 3719, 3720, 3710, 4177, 4178, 4179, 4157
240, 3710, 3720, 3721, 3711, 4179, 4180, 4181, 4159
241, 3711, 3721, 3722, 3712, 4181, 4182, 4183, 4161
242, 3712, 3722, 259, 258, 4183, 4184, 281, 4163
243, 214, 6, 141, 3713, 237, 151, 4185, 4164
244, 3713, 141, 142, 3714, 4185, 152, 4186, 4166
245, 3714, 142, 143, 3715, 4186, 153, 4187, 4168
246, 3715, 143, 144, 3716, 4187, 154, 4188, 4170
247, 3716, 144, 145, 3717, 4188, 155, 4189, 4172
248, 3717, 145, 146, 3718, 4189, 156, 4190, 4174
249, 3718, 146, 147, 3719, 4190, 157, 4191, 4176
250, 3719, 147, 148, 3720, 4191, 158, 4192, 4178
251, 3720, 148, 149, 3721, 4192, 159, 4193, 4180
252, 3721, 149, 150, 3722, 4193, 160, 4194, 4182
253, 3722, 150, 5, 259, 4194, 161, 282, 4184
*ELEMENT, type=CPS8, ELSET=Surface4
28942, 4, 115, 4195, 283, 125, 4415, 4416, 305
28943, 115, 116, 4196, 4195, 126, 4417, 4418, 4415
28944, 116, 117, 4197, 4196, 127, 4419, 4420, 4417
28945, 117, 118, 4198, 4197, 128, 4421, 4422, 4419
28946, 118, 119, 4199, 4198, 129, 4423, 4424, 4421
28947, 119, 120, 4200, 4199, 130, 4425, 4426, 4423
28948, 120, 121, 4201, 4200, 131, 4427, 4428, 4425
28949, 121, 122, 4202, 4201, 132, 4429, 4430, 4427
28950, 122, 123, 4203, 4202, 133, 4431, 4432, 4429
28951, 123, 124, 4204, 4203, 134, 4433, 4434, 4431
28952, 124, 3, 328, 4204, 135, 350, 4435, 4433
28953, 283, 4195, 4205, 284, 4416, 4436, 4437, 306
28954, 4195, 4196, 4206, 4205, 4418, 4438, 4439, 4436
28955, 4196, 4197, 4207, 4206, 4420, 4440, 4441, 4438
28956, 4197, 4198, 4208, 4207, 4422, 4442, 4443, 4440
28957, 4198, 4199, 4209, 4208, 4424, 4444, 4445, 4442
28958, 4199, 4200, 4210, 4209, 4426, 4446, 4447, 4444
28959, 4200, 4201, 4211, 4210, 4428, 4448, 4449, 4446
28960, 4201, 4202, 4212, 4211, 4430, 4450, 4451, 4448
28961, 4202, 4203, 4213, 4212, 4432, 4452, 4453, 4450
28962, 4203, 4204, 4214, 4213, 4434, 4454, 4455, 4452
28963, 4204, 328, 329, 4214, 4435, 351, 4456, 4454
28964, 284, 4205, 4215, 285, 4437, 4457, 4458, 307
28965, 4205, 4206, 4216, 4215, 4439, 4459, 4460, 4457
28966, 4206, 4207, 4217, 4216, 4441, 4461, 4462, 4459
28967, 4207, 4208, 4218, 4217, 4443, 4463, 4464, 4461
28968, 4208, 4209, 4219, 4218, 4445, 4465, 4466, 4463
28969, 4209, 4210, 4220, 4219, 4447, 4467, 4468, 4465
28970, 4210, 4211, 4221, 4220, 4449, 4469, 4470, 4467
28971, 4211, 4212, 4222, 4221, 4451, 4471, 4472, 4469
28972, 4212, 4213, 4223, 4222, 4453, 4473, 4474, 4471
28973, 4213, 4214, 4224, 4223, 4455, 4475, 4476, 4473
28974, 4214, 329, 330, 4224, 4456, 352, 4477, 4475
28975, 285, 4215, 4225, 286, 4458, 4478, 4479, 308
28976, 4215, 4216, 4226, 4225, 4460, 4480, 4481, 4478
28977, 4216, 4217, 4227, 4226, 4462, 4482, 4483, 4480
28978, 4217, 4218, 4228, 4227, 4464, 4484, 4485, 4482
28979, 4218, 4219, 4229, 4228, 4466, 4486, 4487, 4484
28980, 4219, 4220, 4230, 4229, 4468, 4488, 4489, 4486
28981, 4220, 4221, 4231, 4230, 4470, 4490, 4491, 4488
28982, 4221, 4222, 4232, 4231, 4472, 4492, 4493, 4490
28983, 4222, 4223, 4233, 4232, 4474, 4494, 4495, 4492
28984, 4223, 4224, 4234, 4233, 4476, 4496, 4497, 4494
28985, 4224, 330, 331, 4234, 4477, 353, 4498, 4496
28986, 286, 4225, 4235, 287, 4479, 4499, 4500, 309
28987, 4225, 4226, 4236, 4235, 4481, 4501, 4502, 4499
28988, 4226, 4227, 4237, 4236, 4483, 4503, 4504, 4501
28989, 4227, 4228, 4238, 4237, 4485, 4505, 4506, 4503
28990, 4228, 4229, 4239, 4238, 4487, 4507, 4508, 4505
28991, 4229, 4230, 4240, 4239, 4489, 4509, 4510, 4507
28992, 4230, 4231, 4241, 4240, 4491, 4511, 4512, 4509
28993, 4231, 4232, 4242, 4241, 4493, 4513, 4514, 4511
28994, 4232, 4233, 4243, 4242, 4495, 4515, 4516, 4513
28995, 4233, 4234, 4244, 4243, 4497, 4517, 4518, 4515
28996, 4234, 331, 332, 4244, 4498, 354, 4519, 4517
28997, 287, 4235, 4245, 288, 4500, 4520, 4521, 310
28998, 4235, 4236, 4246, 4245, 4502, 4522, 4523, 4520
28999, 4236, 4237, 4247, 4246, 4504, 4524, 4525, 4522
29000, 4237, 4238, 4248, 4247, 4506, 4526, 4527, 4524
29001, 4238, 4239, 4249, 4248, 4508, 4528, 4529, 4526
29002, 4239, 4240, 4250, 4249, 4510, 4530, 4531, 4528
29003, 4240, 4241, 4251, 4250, 4512, 4532, 4533, 4530
29004, 4241, 4242, 4252, 4251, 4514, 4534, 4535, 4532
29005, 4242, 4243, 4253, 4252, 4516, 4536, 4537, 4534
29006, 4243, 4244, 4254, 4253, 4518, 4538, 4539, 4536
29007, 4244, 332, 333, 4254, 4519, 355, 4540, 4538
29008, 288, 4245, 4255, 289, 4521, 4541, 4542, 311
29009, 4245, 4246, 4256, 4255, 4523, 4543, 4544, 4541
29010, 4246, 4247, 4257, 4256, 4525, 4545, 4546, 4543
29011, 4247, 4248, 4258, 4257, 4527, 4547, 4548, 4545
29012, 4248, 4249, 4259, 4258, 4529, 4549, 4550, 4547
29013, 4249, 4250, 4260, 4259, 4531, 4551, 4552, 4549
29014, 4250, 4251, 4261, 4260, 4533, 4553, 4554, 4551
29015, 4251, 4252, 4262, 4261, 4535, 4555, 4556, 4553
29016, 4252, 4253, 4263, 4262, 4537, 4557, 4558, 4555
29017, 4253, 4254, 4264, 4263, 4539, 4559, 4560, 4557
29018, 4254, 333, 334, 4264, 4540, 356, 4561, 4559
29019, 289, 4255, 4265, 290, 4542, 4562, 4563, 312
29020, 4255, 4256, 4266, 4265, 4544, 4564, 4565, 4562
29021, 4256, 4257, 4267, 4266, 4546, 4566, 4567, 4564
29022, 4257, 4258, 4268, 4267, 4548, 4568, 4569, 4566
29023, 4258, 4259, 4269, 4268, 4550, 4570, 4571, 4568
29024, 4259, 4260, 4270, 4269, 4552, 4572, 4573, 4570
29025, 4260, 4261, 4271, 4270, 4554, 4574, 4575, 4572
29026, 4261, 4262, 4272, 4271, 4556, 4576, 4577, 4574
29027, 4262, 4263, 4273, 4272, 4558, 4578, 4579, 4576
29028, 4263, 4264, 4274, 4273, 4560, 4580, 4581, 4578
29029, 4264, 334, 335, 4274, 4561, 357, 4582, 4580
29030, 290, 4265, 4275, 291, 4563, 4583, 4584, 313
29031, 4265, 4266, 4276, 4275, 4565, 4585, 4586, 4583
29032, 4266, 4267, 4277, 4276, 4567, 4587, 4588, 4585
29033, 4267, 4268, 4278, 4277, 4569, 4589, 4590, 4587
29034, 4268, 4269, 4279, 4278, 4571, 4591, 4592, 4589
29035, 4269, 4270, 4280, 4279, 4573, 4593, 4594, 4591
29036, 4270, 4271, 4281, 4280, 4575, 4595, 4596, 4593
29037, 4271, 4272, 4282, 4281, 4577, 4597, 4598, 4595
29038, 4272, 4273, 4283, 4282, 4579, 4599, 4600, 4597
29039, 4273, 4274, 4284, 4283, 4581, 4601, 4602, 4599
29040, 4274, 335, 336, 4284, 4582, 358, 4603, 4601
29041, 291, 4275, 4285, 292, 4584, 4604, 4605, 314
29042, 4275, 4276, 4286, 4285, 4586, 4606, 4607, 4604
29043, 4276, 4277, 4287, 4286, 4588, 4608, 4609, 4606
29044, 4277, 4278, 4288, 4287, 4590, 4610, 4611, 4608
29045, 4278, 4279, 4289, 4288, 4592, 4612, 4613, 4610
29046, 4279, 4280, 4290, 4289, 4594, 4614, 4615, 4612
29047, 4280, 4281, 4291, 4290, 4596, 4616, 4617, 4614
29048, 4281, 4282, 4292, 4291, 4598, 4618, 4619, 4616
29049, 4282, 4283, 4293, 4292, 4600, 4620, 4621, 4618
29050, 4283, 4284, 4294, 4293, 4602, 4622, 4623, 4620
29051, 4284, 336, 337, 4294, 4603, 359, 4624, 4622
29052, 292, 4285, 4295, 293, 4605, 4625, 4626, 315
29053, 4285, 4286, 4296, 4295, 4607, 4627, 4628, 4625
29054, 4286, 4287, 4297, 4296, 4609, 4629, 4630, 4627
29055, 4287, 4288, 4298, 4297, 4611, 4631, 4632, 4629
29056, 4288, 4289, 4299, 4298, 4613, 4633, 4634, 4631
29057, 4289, 4290, 4300, 4299, 4615, 4635, 4636, 4633
29058, 4290, 4291, 4301, 4300, 4617, 4637, 4638, 4635
29059, 4291, 4292, 4302, 4301, 4619, 4639, 4640, 4637
29060, 4292, 4293, 4303, 4302, 4621, 4641, 4642, 4639
29061, 4293, 4294, 4304, 4303, 4623, 4643, 4644, 4641
29062, 4294, 337, 338, 4304, 4624, 360, 4645, 4643
29063, 293, 4295, 4305, 294, 4626, 4646, 4647, 316
29064, 4295, 4296, 4306, 4305, 4628, 4648, 4649, 4646
29065, 4296, 4297, 4307, 4306, 4630, 4650, 4651, 4648
29066, 4297, 4298, 4308, 4307, 4632, 4652, 4653, 4650
29067, 4298, 4299, 4309, 4308, 4634, 4654, 4655, 4652
29068, 4299, 4300, 4310, 4309, 4636, 4656, 4657, 4654
29069, 4300, 4301, 4311, 4310, 4638, 4658, 4659, 4656
29070, 4301, 4302, 4312, 4311, 4640, 4660, 4661, 4658
29071, 4302, 4303, 4313, 4312, 4642, 4662, 4663, 4660
29072, 4303, 4304, 4314, 4313, 4644, 4664, 4665, 4662
29073, 4304, 338, 339, 4314, 4645, 361, 4666, 4664
29074, 294, 4305, 4315, 295, 4647, 4667, 4668, 317
29075, 4305, 4306, 4316, 4315, 4649, 4669, 4670, 4667
29076, 4306, 4307, 4317, 4316, 4651, 4671, 4672, 4669
29077, 4307, 4308, 4318, 4317, 4653, 4673, 4674, 4671
29078, 4308, 4309, 4319, 4318, 4655, 4675, 4676, 4673
29079, 4309, 4310, 4320, 4319, 4657, 4677, 4678, 4675
29080, 4310, 4311, 4321, 4320, 4659, 4679, 4680, 4677
29081, 4311, 4312, 4322, 4321, 4661, 4681, 4682, 4679
29082, 4312, 4313, 4323, 4322, 4663, 4683, 4684, 4681
29083, 4313, 4314, 4324, 4323, 4665, 4685, 4686, 4683
29084, 4314, 339, 340, 4324, 4666, 362, 4687, 4685
29085, 295, 4315, 4325, 296, 4668, 4688, 4689, 318
29086, 4315, 4316, 4326, 4325, 4670, 4690, 4691, 4688
29087, 4316, 4317, 4327, 4326, 4672, 4692, 4693, 4690
29088, 4317, 4318, 4328, 4327, 4674, 4694, 4695, 4692
29089, 4318, 4319, 4329, 4328, 4676, 4696, 4697, 4694
29090, 4319, 4320, 4330, 4329, 4678, 4698, 4699, 4696
29091, 4320, 4321, 4331, 4330, 4680, 4700, 4701, 4698
29092, 4321, 4322, 4332, 4331, 4682, 4702, 4703, 4700
29093, 4322, 4323, 4333, 4332, 4684, 4704, 4705, 4702
29094, 4323, 4324, 4334, 4333, 4686, 4706, 4707, 4704
29095, 4324, 340, 341, 4334, 4687, 363, 4708, 4706
29096, 296, 4325, 4335, 297, 4689, 4709, 4710, 319
29097, 4325, 4326, 4336, 4335, 4691, 4711, 4712, 4709
29098, 4326, 4327, 4337, 4336, 4693, 4713, 4714, 4711
29099, 4327, 4328, 4338, 4337, 4695, 4715, 4716, 4713
29100, 4328, 4329, 4339, 4338, 4697, 4717, 4718, 4715
29101, 4329, 4330, 4340, 4339, 4699, 4719, 4720, 4717
29102, 4330, 4331, 4341, 4340, 4701, 4721, 4722, 4719
29103, 4331, 4332, 4342, 4341, 4703, 4723, 4724, 4721
29104, 4332, 4333, 4343, 4342, 4705, 4725, 4726, 4723
29105, 4333, 4334, 4344, 4343, 4707, 4727, 4728, 4725
29106, 4334, 341, 342, 4344, 4708, 364, 4729, 4727
29107, 297, 4335, 4345, 298, 4710, 4730, 4731, 320
29108, 4335, 4336, 4346, 4345, 4712, 4732, 4733, 4730
29109, 4336, 4337, 4347, 4346, 4714, 4734, 4735, 4732
29110, 4337, 4338, 4348, 4347, 4716, 4736, 4737, 4734
29111, 4338, 4339, 4349, 4348, 4718, 4738, 4739, 4736
29112, 4339, 4340, 4350, 4349, 4720, 4740, 4741, 4738
29113, 4340, 4341, 4351, 4350, 4722, 4742, 4743, 4740
29114, 4341, 4342, 4352, 4351, 4724, 4744, 4745, 4742
29115, 4342, 4343, 4353, 4352, 4726, 4746, 4747, 4744
29116, 4343, 4344, 4354, 4353, 4728, 4748, 4749, 4746
29117, 4344, 342, 343, 4354, 4729, 365, 4750, 4748
29118, 298, 4345, 4355, 299, 4731, 4751, 4752, 321
29119, 4345, 4346, 4356, 4355, 4733, 4753, 4754, 4751
29120, 4346, 4347, 4357, 4356, 4735, 4755, 4756, 4753
29121, 4347, 4348, 4358, 4357, 4737, 4757, 4758, 4755
29122, 4348, 4349, 4359, 4358, 4739, 4759, 4760, 4757
29123, 4349, 4350, 4360, 4359, 4741, 4761, 4762, 4759
29124, 4350, 4351, 4361, 4360, 4743, 4763, 4764, 4761
29125, 4351, 4352, 4362, 4361, 4745, 4765, 4766, 4763
29126, 4352, 4353, 4363, 4362, 4747, 4767, 4768, 4765
29127, 4353, 4354, 4364, 4363, 4749, 4769, 4770, 4767
29128, 4354, 343, 344, 4364, 4750, 366, 4771, 4769
29129, 299, 4355, 4365, 300, 4752, 4772, 4773, 322
29130, 4355, 4356, 4366, 4365, 4754, 4774, 4775, 4772
29131, 4356, 4357, 4367, 4366, 4756, 4776, 4777, 4774
29132, 4357, 4358, 4368, 4367, 4758, 4778, 4779, 4776
29133, 4358, 4359, 4369, 4368, 4760, 4780, 4781, 4778
29134, 4359, 4360, 4370, 4369, 4762, 4782, 4783, 4780
29135, 4360, 4361, 4371, 4370, 4764, 4784, 4785, 4782
29136, 4361, 4362, 4372, 4371, 4766, 4786, 4787, 4784
29137, 4362, 4363, 4373, 4372, 4768, 4788, 4789, 4786
29138, 4363, 4364, 4374, 4373, 4770, 4790, 4791, 4788
29139, 4364, 344, 345, 4374, 4771, 367, 4792, 4790
29140, 300, 4365, 4375, 301, 4773, 4793, 4794, 323
29141, 4365, 4366, 4376, 4375, 4775, 4795, 4796, 4793
29142, 4366, 4367, 4377, 4376, 4777, 4797, 4798, 4795
29143, 4367, 4368, 4378, 4377, 4779, 4799, 4800, 4797
29144, 4368, 4369, 4379, 4378, 4781, 4801, 4802, 4799
29145, 4369, 4370, 4380, 4379, 4783, 4803, 4804, 4801
29146, 4370, 4371, 4381, 4380, 4785, 4805, 4806, 4803
29147, 4371, 4372, 4382, 4381, 4787, 4807, 4808, 4805
29148, 4372, 4373, 4383, 4382, 4789, 4809, 4810, 4807
29149, 4373, 4374, 4384, 4383, 4791, 4811, 4812, 4809
29150, 4374, 345, 346, 4384, 4792, 368, 4813, 4811
29151, 301, 4375, 4385, 302, 4794, 4814, 4815, 324
29152, 4375, 4376, 4386, 4385, 4796, 4816, 4817, 4814
29153, 4376, 4377, 4387, 4386, 4798, 4818, 4819, 4816
29154, 4377, 4378, 4388, 4387, 4800, 4820, 4821, 4818
29155, 4378, 4379, 4389, 4388, 4802, 4822, 4823, 4820
29156, 4379, 4380, 4390, 4389, 4804, 4824, 4825, 4822
29157, 4380, 4381, 4391, 4390, 4806, 4826, 4827, 4824
29158, 4381, 4382, 4392, 4391, 4808, 4828, 4829, 4826
29159, 4382, 4383, 4393, 4392, 4810, 4830, 4831, 4828
29160, 4383, 4384, 4394, 4393, 4812, 4832, 4833, 4830
29161, 4384, 346, 347, 4394, 4813, 369, 4834, 4832
29162, 302, 4385, 4395, 303, 4815, 4835, 4836, 325
29163, 4385, 4386, 4396, 4395, 4817, 4837, 4838, 4835
29164, 4386, 4387, 4397, 4396, 4819, 4839, 4840, 4837
29165, 4387, 4388, 4398, 4397, 4821, 4841, 4842, 4839
29166, 4388, 4389, 4399, 4398, 4823, 4843, 4844, 4841
29167, 4389, 4390, 4400, 4399, 4825, 4845, 4846, 4843
29168, 4390, 4391, 4401, 4400, 4827, 4847, 4848, 4845
29169, 4391, 4392, 4402, 4401, 4829, 4849, 4850, 4847
29170, 4392, 4393, 4403, 4402, 4831, 4851, 4852, 4849
29171, 4393, 4394, 4404, 4403, 4833, 4853, 4854, 4851
29172, 4394, 347, 348, 4404, 4834, 370, 4855, 4853
29173, 303, 4395, 4405, 304, 4836, 4856, 4857, 326
29174, 4395, 4396, 4406, 4405, 4838, 4858, 4859, 4856
29175, 4396, 4397, 4407, 4406, 4840, 4860, 4861, 4858
29176, 4397, 4398, 4408, 4407, 4842, 4862, 4863, 4860
29177, 4398, 4399, 4409, 4408, 4844, 4864, 4865, 4862
29178, 4399, 4400, 4410, 4409, 4846, 4866, 4867, 4864
29179, 4400, 4401, 4411, 4410, 4848, 4868, 4869, 4866
29180, 4401, 4402, 4412, 4411, 4850, 4870, 4871, 4868
29181, 4402, 4403, 4413, 4412, 4852, 4872, 4873, 4870
29182, 4403, 4404, 4414, 4413, 4854, 4874, 4875, 4872
29183, 4404, 348, 349, 4414, 4855, 371, 4876, 4874
29184, 304, 4405, 167, 8, 4857, 4877, 177, 327
29185, 4405, 4406, 168, 167, 4859, 4878, 178, 4877
29186, 4406, 4407, 169, 168, 4861, 4879, 179, 4878
29187, 4407, 4408, 170, 169, 4863, 4880, 180, 4879
29188, 4408, 4409, 171, 170, 4865, 4881, 181, 4880
29189, 4409, 4410, 172, 171, 4867, 4882, 182, 4881
29190, 4410, 4411, 173, 172, 4869, 4883, 183, 4882
29191, 4411, 4412, 174, 173, 4871, 4884, 184, 4883
29192, 4412, 4413, 175, 174, 4873, 4885, 185, 4884
29193, 4413, 4414, 176, 175, 4875, 4886, 186, 4885
29194, 4414, 349, 7, 176, 4876, 372, 187, 4886
*ELEMENT, type=CPS8, ELSET=Surface5
29195, 2, 136, 4887, 193, 138, 4931, 4932, 215
29196, 193, 4887, 4888, 194, 4932, 4933, 4934, 216
29197, 194, 4888, 4889, 195, 4934, 4935, 4936, 217
29198, 195, 4889, 4890, 196, 4936, 4937, 4938, 218
29199, 196, 4890, 4891, 197, 4938, 4939, 4940, 219
29200, 197, 4891, 4892, 198, 4940, 4941, 4942, 220
29201, 198, 4892, 4893, 199, 4942, 4943, 4944, 221
29202, 199, 4893, 4894, 200, 4944, 4945, 4946, 222
29203, 200, 4894, 4895, 201, 4946, 4947, 4948, 223
29204, 201, 4895, 4896, 202, 4948, 4949, 4950, 224
29205, 202, 4896, 4897, 203, 4950, 4951, 4952, 225
29206, 203, 4897, 4898, 204, 4952, 4953, 4954, 226
29207, 204, 4898, 4899, 205, 4954, 4955, 4956, 227
29208, 205, 4899, 4900, 206, 4956, 4957, 4958, 228
29209, 206, 4900, 4901, 207, 4958, 4959, 4960, 229
29210, 207, 4901, 4902, 208, 4960, 4961, 4962, 230
29211, 208, 4902, 4903, 209, 4962, 4963, 4964, 231
29212, 209, 4903, 4904, 210, 4964, 4965, 4966, 232
29213, 210, 4904, 4905, 211, 4966, 4967, 4968, 233
29214, 211, 4905, 4906, 212, 4968, 4969, 4970, 234
29215, 212, 4906, 4907, 213, 4970, 4971, 4972, 235
29216, 213, 4907, 4908, 214, 4972, 4973, 4974, 236
29217, 214, 4908, 188, 6, 4974, 4975, 190, 237
29218, 136, 137, 4909, 4887, 139, 4976, 4977, 4931
29219, 4887, 4909, 4910, 4888, 4977, 4978, 4979, 4933
29220, 4888, 4910, 4911, 4889, 4979, 4980, 4981, 4935
29221, 4889, 4911, 4912, 4890, 4981, 4982, 4983, 4937
29222, 4890, 4912, 4913, 4891, 4983, 4984, 4985, 4939
29223, 4891, 4913, 4914, 4892, 4985, 4986, 4987, 4941
29224, 4892, 4914, 4915, 4893, 4987, 4988, 4989, 4943
29225, 4893, 4915, 4916, 4894, 4989, 4990, 4991, 4945
29226, 4894, 4916, 4917, 4895, 4991, 4992, 4993, 4947
29227, 4895, 4917, 4918, 4896, 4993, 4994, 4995, 4949
29228, 4896, 4918, 4919, 4897, 4995, 4996, 4997, 4951
29229, 4897, 4919, 4920, 4898, 4997, 4998, 4999, 4953
29230, 4898, 4920, 4921, 4899, 4999, 5000, 5001, 4955
29231, 4899, 4921, 4922, 4900, 5001, 5002, 5003, 4957
29232, 4900, 4922, 4923, 4901, 5003, 5004, 5005, 4959
29233, 4901, 4923, 4924, 4902, 5005, 5006, 5007, 4961
29234, 4902, 4924, 4925, 4903, 5007, 5008, 5009, 4963
29235, 4903, 4925, 4926, 4904, 5009, 5010, 5011, 4965
29236, 4904, 4926, 4927, 4905, 5011, 5012, 5013, 4967
29237, 4905, 4927, 4928, 4906, 5013, 5014, 5015, 4969
29238, 4906, 4928, 4929, 4907, 5015, 5016, 5017, 4971
29239, 4907, 4929, 4930, 4908, 5017, 5018, 5019, 4973
29240, 4908, 4930, 189, 188, 5019, 5020, 191, 4975
29241, 137, 4, 283, 4909, 140, 305, 5021, 4976
29242, 4909, 283, 284, 4910, 5021, 306, 5022, 4978
29243, 4910, 284, 285, 4911, 5022, 307, 5023, 4980
29244, 4911, 285, 286, 4912, 5023, 308, 5024, 4982
29245, 4912, 286, 287, 4913, 5024, 309, 5025, 4984
29246, 4913, 287, 288, 4914, 5025, 310, 5026, 4986
29247, 4914, 288, 289, 4915, 5026, 311, 5027, 4988
29248, 4915, 289, 290, 4916, 5027, 312, 5028, 4990
29249, 4916, 290, 291, 4917, 5028, 313, 5029, 4992
29250, 4917, 291, 292, 4918, 5029, 314, 5030, 4994
29251, 4918, 292, 293, 4919, 5030, 315, 5031, 4996
29252, 4919, 293, 294, 4920, 5031, 316, 5032, 4998
29253, 4920, 294, 295, 4921, 5032, 317, 5033, 5000
29254, 4921, 295, 296, 4922, 5033, 318, 5034, 5002
29255, 4922, 296, 297, 4923, 5034, 319, 5035, 5004
29256, 4923, 297, 298, 4924, 5035, 320, 5036, 5006
29257, 4924, 298, 299, 4925, 5036, 321, 5037, 5008
29258, 4925, 299, 300, 4926, 5037, 322, 5038, 5010
29259, 4926, 300, 301, 4927, 5038, 323, 5039, 5012
29260, 4927, 301, 302, 4928, 5039, 324, 5040, 5014
29261, 4928, 302, 303, 4929, 5040, 325, 5041, 5016
29262, 4929, 303, 304, 4930, 5041, 326, 5042, 5018
29263, 4930, 304, 8, 189, 5042, 327, 192, 5020
*ELEMENT, type=CPS8, ELSET=Surface6
254, 1, 238, 5043, 110, 260, 5087, 5088, 112
255, 238, 239, 5044, 5043, 261, 5089, 5090, 5087
256, 239, 240, 5045, 5044, 262, 5091, 5092, 5089
257, 240, 241, 5046, 5045, 263, 5093, 5094, 5091
258, 241, 242, 5047, 5046, 264, 5095, 5096, 5093
259, 242, 243, 5048, 5047, 265, 5097, 5098, 5095
260, 243, 244, 5049, 5048, 266, 5099, 5100, 5097
261, 244, 245, 5050, 5049, 267, 5101, 5102, 5099
262, 245, 246, 5051, 5050, 268, 5103, 5104, 5101
263, 246, 247, 5052, 5051, 269, 5105, 5106, 5103
264, 247, 248, 5053, 5052, 270, 5107, 5108, 5105
265, 248, 249, 5054, 5053, 271, 5109, 5110, 5107
266, 249, 250, 5055, 5054, 272, 5111, 5112, 5109
267, 250, 251, 5056, 5055, 273, 5113, 5114, 5111
268, 251, 252, 5057, 5056, 274, 5115, 5116, 5113
269, 252, 253, 5058, 5057, 275, 5117, 5118, 5115
270, 253, 254, 5059, 5058, 276, 5119, 5120, 5117
271, 254, 255, 5060, 5059, 277, 5121, 5122, 5119
272, 255, 256, 5061, 5060, 278, 5123, 5124, 5121
273, 256, 257, 5062, 5061, 279, 5125, 5126, 5123
274, 257, 258, 5063, 5062, 280, 5127, 5128, 5125
275, 258, 259, 5064, 5063, 281, 5129, 5130, 5127
276, 259, 5, 162, 5064, 282, 164, 5131, 5129
277, 110, 5043, 5065, 111, 5088, 5132, 5133, 113
278, 5043, 5044, 5066, 5065, 5090, 5134, 5135, 5132
279, 5044, 5045, 5067, 5066, 5092, 5136, 5137, 5134
280, 5045, 5046, 5068, 5067, 5094, 5138, 5139, 5136
281, 5046, 5047, 5069, 5068, 5096, 5140, 5141, 5138
282, 5047, 5048, 5070, 5069, 5098, 5142, 5143, 5140
283, 5048, 5049, 5071, 5070, 5100, 5144, 5145, 5142
284, 5049, 5050, 5072, 5071, 5102, 5146, 5147, 5144
285, 5050, 5051, 5073, 5072, 5104, 5148, 5149, 5146
286, 5051, 5052, 5074, 5073, 5106, 5150, 5151, 5148
287, 5052, 5053, 5075, 5074, 5108, 5152, 5153, 5150
288, 5053, 5054, 5076, 5075, 5110, 5154, 5155, 5152
289, 5054, 5055, 5077, 5076, 5112, 5156, 5157, 5154
290, 5055, 5056, 5078, 5077, 5114, 5158, 5159, 5156
291, 5056, 5057, 5079, 5078, 5116, 5160, 5161, 5158
292, 5057, 5058, 5080, 5079, 5118, 5162, 5163, 5160
293, 5058, 5059, 5081, 5080, 5120, 5164, 5165, 5162
294, 5059, 5060, 5082, 5081, 5122, 5166, 5167, 5164
295, 5060, 5061, 5083, 5082, 5124, 5168, 5169, 5166
296, 5061, 5062, 5084, 5083, 5126, 5170, 5171, 5168
297, 5062, 5063, 5085, 5084, 5128, 5172, 5173, 5170
298, 5063, 5064, 5086, 5085, 5130, 5174, 5175, 5172
299, 5064, 162, 163, 5086, 5131, 165, 5176, 5174
300, 111, 5065, 328, 3, 5133, 5177, 350, 114
301, 5065, 5066, 329, 328, 5135, 5178, 351, 5177
302, 5066, 5067, 330, 329, 5137, 5179, 352, 5178
