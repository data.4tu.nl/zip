*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_2401v4.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.1, 0.5
4, 0, 0.1, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.1, 0.5
8, 1, 0.1, 0
9, 1, 0.15, 0
10, 0, 0.15, 0
11, 1, 0.15, 0.5
12, 0, 0.15, 0.5
13, 1, 1.35, 0
14, 0, 1.35, 0
15, 1, 1.35, 0.5
16, 0, 1.35, 0.5
17, 1, 1.4, 0
18, 0, 1.4, 0
19, 1, 1.4, 0.5
20, 0, 1.4, 0.5
21, 1, 1.5, 0
22, 0, 1.5, 0
23, 1, 1.5, 0.5
24, 0, 1.5, 0.5
25, 1.2, 1.4, 0.5
26, 1.2, 1.5, 0.5
27, 1.2, 1.4, 0
28, 1.2, 1.5, 0
29, 2.2, 1.4, 0.5
30, 2.2, 1.5, 0.5
31, 2.2, 1.4, 0
32, 2.2, 1.5, 0
33, 1.2, 1.35, 0.5
34, 2.2, 1.35, 0.5
35, 1.2, 1.35, 0
36, 2.2, 1.35, 0
37, 1.2, 0.15, 0.5
38, 2.2, 0.15, 0.5
39, 1.2, 0.15, 0
40, 2.2, 0.15, 0
41, 1.2, 0.1, 0.5
42, 2.2, 0.1, 0.5
43, 1.2, 0.1, 0
44, 2.2, 0.1, 0
45, 2.2, -1.2490009027033e-16, 0.5
46, 2.2, -1.2490009027033e-16, 0
47, 2.3, 0.1, 0.5
48, 2.3, -1.2490009027033e-16, 0.5
49, 2.3, 0.1, 0
50, 2.3, -1.2490009027033e-16, 0
51, -0.1, 0, 0.5
52, -0.1, 0, 0
53, -0.1, 0.1, 0.5
54, -0.1, 0.1, 0
55, 1, 1.7, 0
56, 0, 1.7, 0
57, 1, 1.7, 0.5
58, 0, 1.7, 0.5
59, 1.2, 1.7, 0.5
60, 1.2, 1.7, 0
61, 2.2, 1.7, 0.5
62, 2.2, 1.7, 0
63, 1, -0.2, 0
64, 0, -0.2, 0
65, 1, -0.2, 0.5
66, 0, -0.2, 0.5
67, -0.1, -0.2, 0.5
68, -0.1, -0.2, 0
69, 2.2, -0.2, 0.5
70, 2.2, -0.2, 0
71, 2.3, -0.2, 0.5
72, 2.3, -0.2, 0
73, -0.1, 1.5, 0.5
74, -0.1, 1.7, 0.5
75, -0.1, 1.5, 0
76, -0.1, 1.7, 0
77, -0.1, 1.4, 0.5
78, -0.1, 1.4, 0
79, 2.3, 1.5, 0.5
80, 2.3, 1.7, 0.5
81, 2.3, 1.5, 0
82, 2.3, 1.7, 0
83, 2.3, 1.4, 0.5
84, 2.3, 1.4, 0
85, 1.2, -8.3266726846887e-17, 0.5
86, 1.2, -8.3266726846887e-17, 0
87, 1.2, -0.2, 0.5
88, 1.2, -0.2, 0
89, 0, 0, 0.045454545454545
90, 0, 0, 0.090909090909091
91, 0, 0, 0.13636363636364
92, 0, 0, 0.18181818181818
93, 0, 0, 0.22727272727273
94, 0, 0, 0.27272727272727
95, 0, 0, 0.31818181818182
96, 0, 0, 0.36363636363636
97, 0, 0, 0.40909090909091
98, 0, 0, 0.45454545454545
99, 0, 0, 0.022727272727273
100, 0, 0, 0.068181818181818
101, 0, 0, 0.11363636363636
102, 0, 0, 0.15909090909091
103, 0, 0, 0.20454545454545
104, 0, 0, 0.25
105, 0, 0, 0.29545454545455
106, 0, 0, 0.34090909090909
107, 0, 0, 0.38636363636364
108, 0, 0, 0.43181818181818
109, 0, 0, 0.47727272727273
110, 0, 0.033333333333333, 0.5
111, 0, 0.066666666666667, 0.5
112, 0, 0.016666666666667, 0.5
113, 0, 0.05, 0.5
114, 0, 0.083333333333333, 0.5
115, 0, 0.1, 0.045454545454545
116, 0, 0.1, 0.090909090909091
117, 0, 0.1, 0.13636363636364
118, 0, 0.1, 0.18181818181818
119, 0, 0.1, 0.22727272727273
120, 0, 0.1, 0.27272727272727
121, 0, 0.1, 0.31818181818182
122, 0, 0.1, 0.36363636363636
123, 0, 0.1, 0.40909090909091
124, 0, 0.1, 0.45454545454545
125, 0, 0.1, 0.022727272727273
126, 0, 0.1, 0.068181818181818
127, 0, 0.1, 0.11363636363636
128, 0, 0.1, 0.15909090909091
129, 0, 0.1, 0.20454545454545
130, 0, 0.1, 0.25
131, 0, 0.1, 0.29545454545455
132, 0, 0.1, 0.34090909090909
133, 0, 0.1, 0.38636363636364
134, 0, 0.1, 0.43181818181818
135, 0, 0.1, 0.47727272727273
136, 0, 0.033333333333333, 0
137, 0, 0.066666666666667, 0
138, 0, 0.016666666666667, 0
139, 0, 0.05, 0
140, 0, 0.083333333333333, 0
141, 1, 0, 0.045454545454545
142, 1, 0, 0.090909090909091
143, 1, 0, 0.13636363636364
144, 1, 0, 0.18181818181818
145, 1, 0, 0.22727272727273
146, 1, 0, 0.27272727272727
147, 1, 0, 0.31818181818182
148, 1, 0, 0.36363636363636
149, 1, 0, 0.40909090909091
150, 1, 0, 0.45454545454545
151, 1, 0, 0.022727272727273
152, 1, 0, 0.068181818181818
153, 1, 0, 0.11363636363636
154, 1, 0, 0.15909090909091
155, 1, 0, 0.20454545454545
156, 1, 0, 0.25
157, 1, 0, 0.29545454545455
158, 1, 0, 0.34090909090909
159, 1, 0, 0.38636363636364
160, 1, 0, 0.43181818181818
161, 1, 0, 0.47727272727273
162, 1, 0.033333333333333, 0.5
163, 1, 0.066666666666667, 0.5
164, 1, 0.016666666666667, 0.5
165, 1, 0.05, 0.5
166, 1, 0.083333333333333, 0.5
167, 1, 0.1, 0.045454545454545
168, 1, 0.1, 0.090909090909091
169, 1, 0.1, 0.13636363636364
170, 1, 0.1, 0.18181818181818
171, 1, 0.1, 0.22727272727273
172, 1, 0.1, 0.27272727272727
173, 1, 0.1, 0.31818181818182
174, 1, 0.1, 0.36363636363636
175, 1, 0.1, 0.40909090909091
176, 1, 0.1, 0.45454545454545
177, 1, 0.1, 0.022727272727273
178, 1, 0.1, 0.068181818181818
179, 1, 0.1, 0.11363636363636
180, 1, 0.1, 0.15909090909091
181, 1, 0.1, 0.20454545454545
182, 1, 0.1, 0.25
183, 1, 0.1, 0.29545454545455
184, 1, 0.1, 0.34090909090909
185, 1, 0.1, 0.38636363636364
186, 1, 0.1, 0.43181818181818
187, 1, 0.1, 0.47727272727273
188, 1, 0.033333333333333, 0
189, 1, 0.066666666666667, 0
190, 1, 0.016666666666667, 0
191, 1, 0.05, 0
192, 1, 0.083333333333333, 0
193, 0.043478260869565, 0, 0
194, 0.08695652173913, 0, 0
195, 0.1304347826087, 0, 0
196, 0.17391304347826, 0, 0
197, 0.21739130434783, 0, 0
198, 0.26086956521739, 0, 0
199, 0.30434782608696, 0, 0
200, 0.34782608695652, 0, 0
201, 0.39130434782609, 0, 0
202, 0.43478260869565, 0, 0
203, 0.47826086956522, 0, 0
204, 0.52173913043478, 0, 0
205, 0.56521739130435, 0, 0
206, 0.60869565217391, 0, 0
207, 0.65217391304348, 0, 0
208, 0.69565217391304, 0, 0
209, 0.73913043478261, 0, 0
210, 0.78260869565217, 0, 0
211, 0.82608695652174, 0, 0
212, 0.8695652173913, 0, 0
213, 0.91304347826087, 0, 0
214, 0.95652173913043, 0, 0
215, 0.021739130434783, 0, 0
216, 0.065217391304348, 0, 0
217, 0.10869565217391, 0, 0
218, 0.15217391304348, 0, 0
219, 0.19565217391304, 0, 0
220, 0.23913043478261, 0, 0
221, 0.28260869565217, 0, 0
222, 0.32608695652174, 0, 0
223, 0.3695652173913, 0, 0
224, 0.41304347826087, 0, 0
225, 0.45652173913043, 0, 0
226, 0.5, 0, 0
227, 0.54347826086957, 0, 0
228, 0.58695652173913, 0, 0
229, 0.6304347826087, 0, 0
230, 0.67391304347826, 0, 0
231, 0.71739130434783, 0, 0
232, 0.76086956521739, 0, 0
233, 0.80434782608696, 0, 0
234, 0.84782608695652, 0, 0
235, 0.89130434782609, 0, 0
236, 0.93478260869565, 0, 0
237, 0.97826086956522, 0, 0
238, 0.043478260869565, 0, 0.5
239, 0.08695652173913, 0, 0.5
240, 0.1304347826087, 0, 0.5
241, 0.17391304347826, 0, 0.5
242, 0.21739130434783, 0, 0.5
243, 0.26086956521739, 0, 0.5
244, 0.30434782608696, 0, 0.5
245, 0.34782608695652, 0, 0.5
246, 0.39130434782609, 0, 0.5
247, 0.43478260869565, 0, 0.5
248, 0.47826086956522, 0, 0.5
249, 0.52173913043478, 0, 0.5
250, 0.56521739130435, 0, 0.5
251, 0.60869565217391, 0, 0.5
252, 0.65217391304348, 0, 0.5
253, 0.69565217391304, 0, 0.5
254, 0.73913043478261, 0, 0.5
255, 0.78260869565217, 0, 0.5
256, 0.82608695652174, 0, 0.5
257, 0.8695652173913, 0, 0.5
258, 0.91304347826087, 0, 0.5
259, 0.95652173913043, 0, 0.5
260, 0.021739130434783, 0, 0.5
261, 0.065217391304348, 0, 0.5
262, 0.10869565217391, 0, 0.5
263, 0.15217391304348, 0, 0.5
264, 0.19565217391304, 0, 0.5
265, 0.23913043478261, 0, 0.5
266, 0.28260869565217, 0, 0.5
267, 0.32608695652174, 0, 0.5
268, 0.3695652173913, 0, 0.5
269, 0.41304347826087, 0, 0.5
270, 0.45652173913043, 0, 0.5
271, 0.5, 0, 0.5
272, 0.54347826086957, 0, 0.5
273, 0.58695652173913, 0, 0.5
274, 0.6304347826087, 0, 0.5
275, 0.67391304347826, 0, 0.5
276, 0.71739130434783, 0, 0.5
277, 0.76086956521739, 0, 0.5
278, 0.80434782608696, 0, 0.5
279, 0.84782608695652, 0, 0.5
280, 0.89130434782609, 0, 0.5
281, 0.93478260869565, 0, 0.5
282, 0.97826086956522, 0, 0.5
283, 0.043478260869565, 0.1, 0
284, 0.08695652173913, 0.1, 0
285, 0.1304347826087, 0.1, 0
286, 0.17391304347826, 0.1, 0
287, 0.21739130434783, 0.1, 0
288, 0.26086956521739, 0.1, 0
289, 0.30434782608696, 0.1, 0
290, 0.34782608695652, 0.1, 0
291, 0.39130434782609, 0.1, 0
292, 0.43478260869565, 0.1, 0
293, 0.47826086956522, 0.1, 0
294, 0.52173913043478, 0.1, 0
295, 0.56521739130435, 0.1, 0
296, 0.60869565217391, 0.1, 0
297, 0.65217391304348, 0.1, 0
298, 0.69565217391304, 0.1, 0
299, 0.73913043478261, 0.1, 0
300, 0.78260869565217, 0.1, 0
301, 0.82608695652174, 0.1, 0
302, 0.8695652173913, 0.1, 0
303, 0.91304347826087, 0.1, 0
304, 0.95652173913043, 0.1, 0
305, 0.021739130434783, 0.1, 0
306, 0.065217391304348, 0.1, 0
307, 0.10869565217391, 0.1, 0
308, 0.15217391304348, 0.1, 0
309, 0.19565217391304, 0.1, 0
310, 0.23913043478261, 0.1, 0
311, 0.28260869565217, 0.1, 0
312, 0.32608695652174, 0.1, 0
313, 0.3695652173913, 0.1, 0
314, 0.41304347826087, 0.1, 0
315, 0.45652173913043, 0.1, 0
316, 0.5, 0.1, 0
317, 0.54347826086957, 0.1, 0
318, 0.58695652173913, 0.1, 0
319, 0.6304347826087, 0.1, 0
320, 0.67391304347826, 0.1, 0
321, 0.71739130434783, 0.1, 0
322, 0.76086956521739, 0.1, 0
323, 0.80434782608696, 0.1, 0
324, 0.84782608695652, 0.1, 0
325, 0.89130434782609, 0.1, 0
326, 0.93478260869565, 0.1, 0
327, 0.97826086956522, 0.1, 0
328, 0.043478260869565, 0.1, 0.5
329, 0.08695652173913, 0.1, 0.5
330, 0.1304347826087, 0.1, 0.5
331, 0.17391304347826, 0.1, 0.5
332, 0.21739130434783, 0.1, 0.5
333, 0.26086956521739, 0.1, 0.5
334, 0.30434782608696, 0.1, 0.5
335, 0.34782608695652, 0.1, 0.5
336, 0.39130434782609, 0.1, 0.5
337, 0.43478260869565, 0.1, 0.5
338, 0.47826086956522, 0.1, 0.5
339, 0.52173913043478, 0.1, 0.5
340, 0.56521739130435, 0.1, 0.5
341, 0.60869565217391, 0.1, 0.5
342, 0.65217391304348, 0.1, 0.5
343, 0.69565217391304, 0.1, 0.5
344, 0.73913043478261, 0.1, 0.5
345, 0.78260869565217, 0.1, 0.5
346, 0.82608695652174, 0.1, 0.5
347, 0.8695652173913, 0.1, 0.5
348, 0.91304347826087, 0.1, 0.5
349, 0.95652173913043, 0.1, 0.5
350, 0.021739130434783, 0.1, 0.5
351, 0.065217391304348, 0.1, 0.5
352, 0.10869565217391, 0.1, 0.5
353, 0.15217391304348, 0.1, 0.5
354, 0.19565217391304, 0.1, 0.5
355, 0.23913043478261, 0.1, 0.5
356, 0.28260869565217, 0.1, 0.5
357, 0.32608695652174, 0.1, 0.5
358, 0.3695652173913, 0.1, 0.5
359, 0.41304347826087, 0.1, 0.5
360, 0.45652173913043, 0.1, 0.5
361, 0.5, 0.1, 0.5
362, 0.54347826086957, 0.1, 0.5
363, 0.58695652173913, 0.1, 0.5
364, 0.6304347826087, 0.1, 0.5
365, 0.67391304347826, 0.1, 0.5
366, 0.71739130434783, 0.1, 0.5
367, 0.76086956521739, 0.1, 0.5
368, 0.80434782608696, 0.1, 0.5
369, 0.84782608695652, 0.1, 0.5
370, 0.89130434782609, 0.1, 0.5
371, 0.93478260869565, 0.1, 0.5
372, 0.97826086956522, 0.1, 0.5
373, 1, 0.125, 0
374, 1, 0.1125, 0
375, 1, 0.1375, 0
376, 0, 0.125, 0
377, 0, 0.1125, 0
378, 0, 0.1375, 0
379, 0.043478260869565, 0.15, 0
380, 0.08695652173913, 0.15, 0
381, 0.1304347826087, 0.15, 0
382, 0.17391304347826, 0.15, 0
383, 0.21739130434783, 0.15, 0
384, 0.26086956521739, 0.15, 0
385, 0.30434782608696, 0.15, 0
386, 0.34782608695652, 0.15, 0
387, 0.39130434782609, 0.15, 0
388, 0.43478260869565, 0.15, 0
389, 0.47826086956522, 0.15, 0
390, 0.52173913043478, 0.15, 0
391, 0.56521739130435, 0.15, 0
392, 0.60869565217391, 0.15, 0
393, 0.65217391304348, 0.15, 0
394, 0.69565217391304, 0.15, 0
395, 0.73913043478261, 0.15, 0
396, 0.78260869565217, 0.15, 0
397, 0.82608695652174, 0.15, 0
398, 0.8695652173913, 0.15, 0
399, 0.91304347826087, 0.15, 0
400, 0.95652173913043, 0.15, 0
401, 0.021739130434783, 0.15, 0
402, 0.065217391304348, 0.15, 0
403, 0.10869565217391, 0.15, 0
404, 0.15217391304348, 0.15, 0
405, 0.19565217391304, 0.15, 0
406, 0.23913043478261, 0.15, 0
407, 0.28260869565217, 0.15, 0
408, 0.32608695652174, 0.15, 0
409, 0.3695652173913, 0.15, 0
410, 0.41304347826087, 0.15, 0
411, 0.45652173913043, 0.15, 0
412, 0.5, 0.15, 0
413, 0.54347826086957, 0.15, 0
414, 0.58695652173913, 0.15, 0
415, 0.6304347826087, 0.15, 0
416, 0.67391304347826, 0.15, 0
417, 0.71739130434783, 0.15, 0
418, 0.76086956521739, 0.15, 0
419, 0.80434782608696, 0.15, 0
420, 0.84782608695652, 0.15, 0
421, 0.89130434782609, 0.15, 0
422, 0.93478260869565, 0.15, 0
423, 0.97826086956522, 0.15, 0
424, 1, 0.125, 0.5
425, 1, 0.1125, 0.5
426, 1, 0.1375, 0.5
427, 1, 0.15, 0.045454545454545
428, 1, 0.15, 0.090909090909091
429, 1, 0.15, 0.13636363636364
430, 1, 0.15, 0.18181818181818
431, 1, 0.15, 0.22727272727273
432, 1, 0.15, 0.27272727272727
433, 1, 0.15, 0.31818181818182
434, 1, 0.15, 0.36363636363636
435, 1, 0.15, 0.40909090909091
436, 1, 0.15, 0.45454545454545
437, 1, 0.15, 0.022727272727273
438, 1, 0.15, 0.068181818181818
439, 1, 0.15, 0.11363636363636
440, 1, 0.15, 0.15909090909091
441, 1, 0.15, 0.20454545454545
442, 1, 0.15, 0.25
443, 1, 0.15, 0.29545454545455
444, 1, 0.15, 0.34090909090909
445, 1, 0.15, 0.38636363636364
446, 1, 0.15, 0.43181818181818
447, 1, 0.15, 0.47727272727273
448, 0, 0.125, 0.5
449, 0, 0.1125, 0.5
450, 0, 0.1375, 0.5
451, 0.043478260869565, 0.15, 0.5
452, 0.08695652173913, 0.15, 0.5
453, 0.1304347826087, 0.15, 0.5
454, 0.17391304347826, 0.15, 0.5
455, 0.21739130434783, 0.15, 0.5
456, 0.26086956521739, 0.15, 0.5
457, 0.30434782608696, 0.15, 0.5
458, 0.34782608695652, 0.15, 0.5
459, 0.39130434782609, 0.15, 0.5
460, 0.43478260869565, 0.15, 0.5
461, 0.47826086956522, 0.15, 0.5
462, 0.52173913043478, 0.15, 0.5
463, 0.56521739130435, 0.15, 0.5
464, 0.60869565217391, 0.15, 0.5
465, 0.65217391304348, 0.15, 0.5
466, 0.69565217391304, 0.15, 0.5
467, 0.73913043478261, 0.15, 0.5
468, 0.78260869565217, 0.15, 0.5
469, 0.82608695652174, 0.15, 0.5
470, 0.8695652173913, 0.15, 0.5
471, 0.91304347826087, 0.15, 0.5
472, 0.95652173913043, 0.15, 0.5
473, 0.021739130434783, 0.15, 0.5
474, 0.065217391304348, 0.15, 0.5
475, 0.10869565217391, 0.15, 0.5
476, 0.15217391304348, 0.15, 0.5
477, 0.19565217391304, 0.15, 0.5
478, 0.23913043478261, 0.15, 0.5
479, 0.28260869565217, 0.15, 0.5
480, 0.32608695652174, 0.15, 0.5
481, 0.3695652173913, 0.15, 0.5
482, 0.41304347826087, 0.15, 0.5
483, 0.45652173913043, 0.15, 0.5
484, 0.5, 0.15, 0.5
485, 0.54347826086957, 0.15, 0.5
486, 0.58695652173913, 0.15, 0.5
487, 0.6304347826087, 0.15, 0.5
488, 0.67391304347826, 0.15, 0.5
489, 0.71739130434783, 0.15, 0.5
490, 0.76086956521739, 0.15, 0.5
491, 0.80434782608696, 0.15, 0.5
492, 0.84782608695652, 0.15, 0.5
493, 0.89130434782609, 0.15, 0.5
494, 0.93478260869565, 0.15, 0.5
495, 0.97826086956522, 0.15, 0.5
496, 0, 0.15, 0.045454545454545
497, 0, 0.15, 0.090909090909091
498, 0, 0.15, 0.13636363636364
499, 0, 0.15, 0.18181818181818
500, 0, 0.15, 0.22727272727273
501, 0, 0.15, 0.27272727272727
502, 0, 0.15, 0.31818181818182
503, 0, 0.15, 0.36363636363636
504, 0, 0.15, 0.40909090909091
505, 0, 0.15, 0.45454545454545
506, 0, 0.15, 0.022727272727273
507, 0, 0.15, 0.068181818181818
508, 0, 0.15, 0.11363636363636
509, 0, 0.15, 0.15909090909091
510, 0, 0.15, 0.20454545454545
511, 0, 0.15, 0.25
512, 0, 0.15, 0.29545454545455
513, 0, 0.15, 0.34090909090909
514, 0, 0.15, 0.38636363636364
515, 0, 0.15, 0.43181818181818
516, 0, 0.15, 0.47727272727273
517, 1, 0.20217391304348, 0
518, 1, 0.25434782608696, 0
519, 1, 0.30652173913043, 0
520, 1, 0.35869565217391, 0
521, 1, 0.41086956521739, 0
522, 1, 0.46304347826087, 0
523, 1, 0.51521739130435, 0
524, 1, 0.56739130434783, 0
525, 1, 0.6195652173913, 0
526, 1, 0.67173913043478, 0
527, 1, 0.72391304347826, 0
528, 1, 0.77608695652174, 0
529, 1, 0.82826086956522, 0
530, 1, 0.88043478260869, 0
531, 1, 0.93260869565217, 0
532, 1, 0.98478260869565, 0
533, 1, 1.0369565217391, 0
534, 1, 1.0891304347826, 0
535, 1, 1.1413043478261, 0
536, 1, 1.1934782608696, 0
537, 1, 1.245652173913, 0
538, 1, 1.2978260869565, 0
539, 1, 0.17608695652174, 0
540, 1, 0.22826086956522, 0
541, 1, 0.2804347826087, 0
542, 1, 0.33260869565217, 0
543, 1, 0.38478260869565, 0
544, 1, 0.43695652173913, 0
545, 1, 0.48913043478261, 0
546, 1, 0.54130434782609, 0
547, 1, 0.59347826086956, 0
548, 1, 0.64565217391304, 0
549, 1, 0.69782608695652, 0
550, 1, 0.75, 0
551, 1, 0.80217391304348, 0
552, 1, 0.85434782608696, 0
553, 1, 0.90652173913043, 0
554, 1, 0.95869565217391, 0
555, 1, 1.0108695652174, 0
556, 1, 1.0630434782609, 0
557, 1, 1.1152173913043, 0
558, 1, 1.1673913043478, 0
559, 1, 1.2195652173913, 0
560, 1, 1.2717391304348, 0
561, 1, 1.3239130434783, 0
562, 0, 0.20217391304348, 0
563, 0, 0.25434782608696, 0
564, 0, 0.30652173913043, 0
565, 0, 0.35869565217391, 0
566, 0, 0.41086956521739, 0
567, 0, 0.46304347826087, 0
568, 0, 0.51521739130435, 0
569, 0, 0.56739130434783, 0
570, 0, 0.6195652173913, 0
571, 0, 0.67173913043478, 0
572, 0, 0.72391304347826, 0
573, 0, 0.77608695652174, 0
574, 0, 0.82826086956522, 0
575, 0, 0.88043478260869, 0
576, 0, 0.93260869565217, 0
577, 0, 0.98478260869565, 0
578, 0, 1.0369565217391, 0
579, 0, 1.0891304347826, 0
580, 0, 1.1413043478261, 0
581, 0, 1.1934782608696, 0
582, 0, 1.245652173913, 0
583, 0, 1.2978260869565, 0
584, 0, 0.17608695652174, 0
585, 0, 0.22826086956522, 0
586, 0, 0.2804347826087, 0
587, 0, 0.33260869565217, 0
588, 0, 0.38478260869565, 0
589, 0, 0.43695652173913, 0
590, 0, 0.48913043478261, 0
591, 0, 0.54130434782609, 0
592, 0, 0.59347826086956, 0
593, 0, 0.64565217391304, 0
594, 0, 0.69782608695652, 0
595, 0, 0.75, 0
596, 0, 0.80217391304348, 0
597, 0, 0.85434782608696, 0
598, 0, 0.90652173913043, 0
599, 0, 0.95869565217391, 0
600, 0, 1.0108695652174, 0
601, 0, 1.0630434782609, 0
602, 0, 1.1152173913043, 0
603, 0, 1.1673913043478, 0
604, 0, 1.2195652173913, 0
605, 0, 1.2717391304348, 0
606, 0, 1.3239130434783, 0
607, 0.043478260869565, 1.35, 0
608, 0.08695652173913, 1.35, 0
609, 0.1304347826087, 1.35, 0
610, 0.17391304347826, 1.35, 0
611, 0.21739130434783, 1.35, 0
612, 0.26086956521739, 1.35, 0
613, 0.30434782608696, 1.35, 0
614, 0.34782608695652, 1.35, 0
615, 0.39130434782609, 1.35, 0
616, 0.43478260869565, 1.35, 0
617, 0.47826086956522, 1.35, 0
618, 0.52173913043478, 1.35, 0
619, 0.56521739130435, 1.35, 0
620, 0.60869565217391, 1.35, 0
621, 0.65217391304348, 1.35, 0
622, 0.69565217391304, 1.35, 0
623, 0.73913043478261, 1.35, 0
624, 0.78260869565217, 1.35, 0
625, 0.82608695652174, 1.35, 0
626, 0.8695652173913, 1.35, 0
627, 0.91304347826087, 1.35, 0
628, 0.95652173913043, 1.35, 0
629, 0.021739130434783, 1.35, 0
630, 0.065217391304348, 1.35, 0
631, 0.10869565217391, 1.35, 0
632, 0.15217391304348, 1.35, 0
633, 0.19565217391304, 1.35, 0
634, 0.23913043478261, 1.35, 0
635, 0.28260869565217, 1.35, 0
636, 0.32608695652174, 1.35, 0
637, 0.3695652173913, 1.35, 0
638, 0.41304347826087, 1.35, 0
639, 0.45652173913043, 1.35, 0
640, 0.5, 1.35, 0
641, 0.54347826086957, 1.35, 0
642, 0.58695652173913, 1.35, 0
643, 0.6304347826087, 1.35, 0
644, 0.67391304347826, 1.35, 0
645, 0.71739130434783, 1.35, 0
646, 0.76086956521739, 1.35, 0
647, 0.80434782608696, 1.35, 0
648, 0.84782608695652, 1.35, 0
649, 0.89130434782609, 1.35, 0
650, 0.93478260869565, 1.35, 0
651, 0.97826086956522, 1.35, 0
652, 1, 0.20217391304348, 0.5
653, 1, 0.25434782608696, 0.5
654, 1, 0.30652173913043, 0.5
655, 1, 0.35869565217391, 0.5
656, 1, 0.41086956521739, 0.5
657, 1, 0.46304347826087, 0.5
658, 1, 0.51521739130435, 0.5
659, 1, 0.56739130434783, 0.5
660, 1, 0.6195652173913, 0.5
661, 1, 0.67173913043478, 0.5
662, 1, 0.72391304347826, 0.5
663, 1, 0.77608695652174, 0.5
664, 1, 0.82826086956522, 0.5
665, 1, 0.88043478260869, 0.5
666, 1, 0.93260869565217, 0.5
667, 1, 0.98478260869565, 0.5
668, 1, 1.0369565217391, 0.5
669, 1, 1.0891304347826, 0.5
670, 1, 1.1413043478261, 0.5
671, 1, 1.1934782608696, 0.5
672, 1, 1.245652173913, 0.5
673, 1, 1.2978260869565, 0.5
674, 1, 0.17608695652174, 0.5
675, 1, 0.22826086956522, 0.5
676, 1, 0.2804347826087, 0.5
677, 1, 0.33260869565217, 0.5
678, 1, 0.38478260869565, 0.5
679, 1, 0.43695652173913, 0.5
680, 1, 0.48913043478261, 0.5
681, 1, 0.54130434782609, 0.5
682, 1, 0.59347826086956, 0.5
683, 1, 0.64565217391304, 0.5
684, 1, 0.69782608695652, 0.5
685, 1, 0.75, 0.5
686, 1, 0.80217391304348, 0.5
687, 1, 0.85434782608696, 0.5
688, 1, 0.90652173913043, 0.5
689, 1, 0.95869565217391, 0.5
690, 1, 1.0108695652174, 0.5
691, 1, 1.0630434782609, 0.5
692, 1, 1.1152173913043, 0.5
693, 1, 1.1673913043478, 0.5
694, 1, 1.2195652173913, 0.5
695, 1, 1.2717391304348, 0.5
696, 1, 1.3239130434783, 0.5
697, 1, 1.35, 0.045454545454545
698, 1, 1.35, 0.090909090909091
699, 1, 1.35, 0.13636363636364
700, 1, 1.35, 0.18181818181818
701, 1, 1.35, 0.22727272727273
702, 1, 1.35, 0.27272727272727
703, 1, 1.35, 0.31818181818182
704, 1, 1.35, 0.36363636363636
705, 1, 1.35, 0.40909090909091
706, 1, 1.35, 0.45454545454545
707, 1, 1.35, 0.022727272727273
708, 1, 1.35, 0.068181818181818
709, 1, 1.35, 0.11363636363636
710, 1, 1.35, 0.15909090909091
711, 1, 1.35, 0.20454545454545
712, 1, 1.35, 0.25
713, 1, 1.35, 0.29545454545455
714, 1, 1.35, 0.34090909090909
715, 1, 1.35, 0.38636363636364
716, 1, 1.35, 0.43181818181818
717, 1, 1.35, 0.47727272727273
718, 0, 0.20217391304348, 0.5
719, 0, 0.25434782608696, 0.5
720, 0, 0.30652173913043, 0.5
721, 0, 0.35869565217391, 0.5
722, 0, 0.41086956521739, 0.5
723, 0, 0.46304347826087, 0.5
724, 0, 0.51521739130435, 0.5
725, 0, 0.56739130434783, 0.5
726, 0, 0.6195652173913, 0.5
727, 0, 0.67173913043478, 0.5
728, 0, 0.72391304347826, 0.5
729, 0, 0.77608695652174, 0.5
730, 0, 0.82826086956522, 0.5
731, 0, 0.88043478260869, 0.5
732, 0, 0.93260869565217, 0.5
733, 0, 0.98478260869565, 0.5
734, 0, 1.0369565217391, 0.5
735, 0, 1.0891304347826, 0.5
736, 0, 1.1413043478261, 0.5
737, 0, 1.1934782608696, 0.5
738, 0, 1.245652173913, 0.5
739, 0, 1.2978260869565, 0.5
740, 0, 0.17608695652174, 0.5
741, 0, 0.22826086956522, 0.5
742, 0, 0.2804347826087, 0.5
743, 0, 0.33260869565217, 0.5
744, 0, 0.38478260869565, 0.5
745, 0, 0.43695652173913, 0.5
746, 0, 0.48913043478261, 0.5
747, 0, 0.54130434782609, 0.5
748, 0, 0.59347826086956, 0.5
749, 0, 0.64565217391304, 0.5
750, 0, 0.69782608695652, 0.5
751, 0, 0.75, 0.5
752, 0, 0.80217391304348, 0.5
753, 0, 0.85434782608696, 0.5
754, 0, 0.90652173913043, 0.5
755, 0, 0.95869565217391, 0.5
756, 0, 1.0108695652174, 0.5
757, 0, 1.0630434782609, 0.5
758, 0, 1.1152173913043, 0.5
759, 0, 1.1673913043478, 0.5
760, 0, 1.2195652173913, 0.5
761, 0, 1.2717391304348, 0.5
762, 0, 1.3239130434783, 0.5
763, 0.043478260869565, 1.35, 0.5
764, 0.08695652173913, 1.35, 0.5
765, 0.1304347826087, 1.35, 0.5
766, 0.17391304347826, 1.35, 0.5
767, 0.21739130434783, 1.35, 0.5
768, 0.26086956521739, 1.35, 0.5
769, 0.30434782608696, 1.35, 0.5
770, 0.34782608695652, 1.35, 0.5
771, 0.39130434782609, 1.35, 0.5
772, 0.43478260869565, 1.35, 0.5
773, 0.47826086956522, 1.35, 0.5
774, 0.52173913043478, 1.35, 0.5
775, 0.56521739130435, 1.35, 0.5
776, 0.60869565217391, 1.35, 0.5
777, 0.65217391304348, 1.35, 0.5
778, 0.69565217391304, 1.35, 0.5
779, 0.73913043478261, 1.35, 0.5
780, 0.78260869565217, 1.35, 0.5
781, 0.82608695652174, 1.35, 0.5
782, 0.8695652173913, 1.35, 0.5
783, 0.91304347826087, 1.35, 0.5
784, 0.95652173913043, 1.35, 0.5
785, 0.021739130434783, 1.35, 0.5
786, 0.065217391304348, 1.35, 0.5
787, 0.10869565217391, 1.35, 0.5
788, 0.15217391304348, 1.35, 0.5
789, 0.19565217391304, 1.35, 0.5
790, 0.23913043478261, 1.35, 0.5
791, 0.28260869565217, 1.35, 0.5
792, 0.32608695652174, 1.35, 0.5
793, 0.3695652173913, 1.35, 0.5
794, 0.41304347826087, 1.35, 0.5
795, 0.45652173913043, 1.35, 0.5
796, 0.5, 1.35, 0.5
797, 0.54347826086957, 1.35, 0.5
798, 0.58695652173913, 1.35, 0.5
799, 0.6304347826087, 1.35, 0.5
800, 0.67391304347826, 1.35, 0.5
801, 0.71739130434783, 1.35, 0.5
802, 0.76086956521739, 1.35, 0.5
803, 0.80434782608696, 1.35, 0.5
804, 0.84782608695652, 1.35, 0.5
805, 0.89130434782609, 1.35, 0.5
806, 0.93478260869565, 1.35, 0.5
807, 0.97826086956522, 1.35, 0.5
808, 0, 1.35, 0.045454545454545
809, 0, 1.35, 0.090909090909091
810, 0, 1.35, 0.13636363636364
811, 0, 1.35, 0.18181818181818
812, 0, 1.35, 0.22727272727273
813, 0, 1.35, 0.27272727272727
814, 0, 1.35, 0.31818181818182
815, 0, 1.35, 0.36363636363636
816, 0, 1.35, 0.40909090909091
817, 0, 1.35, 0.45454545454545
818, 0, 1.35, 0.022727272727273
819, 0, 1.35, 0.068181818181818
820, 0, 1.35, 0.11363636363636
821, 0, 1.35, 0.15909090909091
822, 0, 1.35, 0.20454545454545
823, 0, 1.35, 0.25
824, 0, 1.35, 0.29545454545455
825, 0, 1.35, 0.34090909090909
826, 0, 1.35, 0.38636363636364
827, 0, 1.35, 0.43181818181818
828, 0, 1.35, 0.47727272727273
829, 1, 1.375, 0
830, 1, 1.3625, 0
831, 1, 1.3875, 0
832, 0, 1.375, 0
833, 0, 1.3625, 0
834, 0, 1.3875, 0
835, 0.043478260869565, 1.4, 0
836, 0.08695652173913, 1.4, 0
837, 0.1304347826087, 1.4, 0
838, 0.17391304347826, 1.4, 0
839, 0.21739130434783, 1.4, 0
840, 0.26086956521739, 1.4, 0
841, 0.30434782608696, 1.4, 0
842, 0.34782608695652, 1.4, 0
843, 0.39130434782609, 1.4, 0
844, 0.43478260869565, 1.4, 0
845, 0.47826086956522, 1.4, 0
846, 0.52173913043478, 1.4, 0
847, 0.56521739130435, 1.4, 0
848, 0.60869565217391, 1.4, 0
849, 0.65217391304348, 1.4, 0
850, 0.69565217391304, 1.4, 0
851, 0.73913043478261, 1.4, 0
852, 0.78260869565217, 1.4, 0
853, 0.82608695652174, 1.4, 0
854, 0.8695652173913, 1.4, 0
855, 0.91304347826087, 1.4, 0
856, 0.95652173913043, 1.4, 0
857, 0.021739130434783, 1.4, 0
858, 0.065217391304348, 1.4, 0
859, 0.10869565217391, 1.4, 0
860, 0.15217391304348, 1.4, 0
861, 0.19565217391304, 1.4, 0
862, 0.23913043478261, 1.4, 0
863, 0.28260869565217, 1.4, 0
864, 0.32608695652174, 1.4, 0
865, 0.3695652173913, 1.4, 0
866, 0.41304347826087, 1.4, 0
867, 0.45652173913043, 1.4, 0
868, 0.5, 1.4, 0
869, 0.54347826086957, 1.4, 0
870, 0.58695652173913, 1.4, 0
871, 0.6304347826087, 1.4, 0
872, 0.67391304347826, 1.4, 0
873, 0.71739130434783, 1.4, 0
874, 0.76086956521739, 1.4, 0
875, 0.80434782608696, 1.4, 0
876, 0.84782608695652, 1.4, 0
877, 0.89130434782609, 1.4, 0
878, 0.93478260869565, 1.4, 0
879, 0.97826086956522, 1.4, 0
880, 1, 1.375, 0.5
881, 1, 1.3625, 0.5
882, 1, 1.3875, 0.5
883, 1, 1.4, 0.045454545454545
884, 1, 1.4, 0.090909090909091
885, 1, 1.4, 0.13636363636364
886, 1, 1.4, 0.18181818181818
887, 1, 1.4, 0.22727272727273
888, 1, 1.4, 0.27272727272727
889, 1, 1.4, 0.31818181818182
890, 1, 1.4, 0.36363636363636
891, 1, 1.4, 0.40909090909091
892, 1, 1.4, 0.45454545454545
893, 1, 1.4, 0.022727272727273
894, 1, 1.4, 0.068181818181818
895, 1, 1.4, 0.11363636363636
896, 1, 1.4, 0.15909090909091
897, 1, 1.4, 0.20454545454545
898, 1, 1.4, 0.25
899, 1, 1.4, 0.29545454545455
900, 1, 1.4, 0.34090909090909
901, 1, 1.4, 0.38636363636364
902, 1, 1.4, 0.43181818181818
903, 1, 1.4, 0.47727272727273
904, 0, 1.375, 0.5
905, 0, 1.3625, 0.5
906, 0, 1.3875, 0.5
907, 0.043478260869565, 1.4, 0.5
908, 0.08695652173913, 1.4, 0.5
909, 0.1304347826087, 1.4, 0.5
910, 0.17391304347826, 1.4, 0.5
911, 0.21739130434783, 1.4, 0.5
912, 0.26086956521739, 1.4, 0.5
913, 0.30434782608696, 1.4, 0.5
914, 0.34782608695652, 1.4, 0.5
915, 0.39130434782609, 1.4, 0.5
916, 0.43478260869565, 1.4, 0.5
917, 0.47826086956522, 1.4, 0.5
918, 0.52173913043478, 1.4, 0.5
919, 0.56521739130435, 1.4, 0.5
920, 0.60869565217391, 1.4, 0.5
921, 0.65217391304348, 1.4, 0.5
922, 0.69565217391304, 1.4, 0.5
923, 0.73913043478261, 1.4, 0.5
924, 0.78260869565217, 1.4, 0.5
925, 0.82608695652174, 1.4, 0.5
926, 0.8695652173913, 1.4, 0.5
927, 0.91304347826087, 1.4, 0.5
928, 0.95652173913043, 1.4, 0.5
929, 0.021739130434783, 1.4, 0.5
930, 0.065217391304348, 1.4, 0.5
931, 0.10869565217391, 1.4, 0.5
932, 0.15217391304348, 1.4, 0.5
933, 0.19565217391304, 1.4, 0.5
934, 0.23913043478261, 1.4, 0.5
935, 0.28260869565217, 1.4, 0.5
936, 0.32608695652174, 1.4, 0.5
937, 0.3695652173913, 1.4, 0.5
938, 0.41304347826087, 1.4, 0.5
939, 0.45652173913043, 1.4, 0.5
940, 0.5, 1.4, 0.5
941, 0.54347826086957, 1.4, 0.5
942, 0.58695652173913, 1.4, 0.5
943, 0.6304347826087, 1.4, 0.5
944, 0.67391304347826, 1.4, 0.5
945, 0.71739130434783, 1.4, 0.5
946, 0.76086956521739, 1.4, 0.5
947, 0.80434782608696, 1.4, 0.5
948, 0.84782608695652, 1.4, 0.5
949, 0.89130434782609, 1.4, 0.5
950, 0.93478260869565, 1.4, 0.5
951, 0.97826086956522, 1.4, 0.5
952, 0, 1.4, 0.045454545454545
953, 0, 1.4, 0.090909090909091
954, 0, 1.4, 0.13636363636364
955, 0, 1.4, 0.18181818181818
956, 0, 1.4, 0.22727272727273
957, 0, 1.4, 0.27272727272727
958, 0, 1.4, 0.31818181818182
959, 0, 1.4, 0.36363636363636
960, 0, 1.4, 0.40909090909091
961, 0, 1.4, 0.45454545454545
962, 0, 1.4, 0.022727272727273
963, 0, 1.4, 0.068181818181818
964, 0, 1.4, 0.11363636363636
965, 0, 1.4, 0.15909090909091
966, 0, 1.4, 0.20454545454545
967, 0, 1.4, 0.25
968, 0, 1.4, 0.29545454545455
969, 0, 1.4, 0.34090909090909
970, 0, 1.4, 0.38636363636364
971, 0, 1.4, 0.43181818181818
972, 0, 1.4, 0.47727272727273
973, 1, 1.4333333333333, 0
974, 1, 1.4666666666667, 0
975, 1, 1.4166666666667, 0
976, 1, 1.45, 0
977, 1, 1.4833333333333, 0
978, 0, 1.4333333333333, 0
979, 0, 1.4666666666667, 0
980, 0, 1.4166666666667, 0
981, 0, 1.45, 0
982, 0, 1.4833333333333, 0
983, 0.043478260869565, 1.5, 0
984, 0.08695652173913, 1.5, 0
985, 0.1304347826087, 1.5, 0
986, 0.17391304347826, 1.5, 0
987, 0.21739130434783, 1.5, 0
988, 0.26086956521739, 1.5, 0
989, 0.30434782608696, 1.5, 0
990, 0.34782608695652, 1.5, 0
991, 0.39130434782609, 1.5, 0
992, 0.43478260869565, 1.5, 0
993, 0.47826086956522, 1.5, 0
994, 0.52173913043478, 1.5, 0
995, 0.56521739130435, 1.5, 0
996, 0.60869565217391, 1.5, 0
997, 0.65217391304348, 1.5, 0
998, 0.69565217391304, 1.5, 0
999, 0.73913043478261, 1.5, 0
1000, 0.78260869565217, 1.5, 0
1001, 0.82608695652174, 1.5, 0
1002, 0.8695652173913, 1.5, 0
1003, 0.91304347826087, 1.5, 0
1004, 0.95652173913043, 1.5, 0
1005, 0.021739130434783, 1.5, 0
1006, 0.065217391304348, 1.5, 0
1007, 0.10869565217391, 1.5, 0
1008, 0.15217391304348, 1.5, 0
1009, 0.19565217391304, 1.5, 0
1010, 0.23913043478261, 1.5, 0
1011, 0.28260869565217, 1.5, 0
1012, 0.32608695652174, 1.5, 0
1013, 0.3695652173913, 1.5, 0
1014, 0.41304347826087, 1.5, 0
1015, 0.45652173913043, 1.5, 0
1016, 0.5, 1.5, 0
1017, 0.54347826086957, 1.5, 0
1018, 0.58695652173913, 1.5, 0
1019, 0.6304347826087, 1.5, 0
1020, 0.67391304347826, 1.5, 0
1021, 0.71739130434783, 1.5, 0
1022, 0.76086956521739, 1.5, 0
1023, 0.80434782608696, 1.5, 0
1024, 0.84782608695652, 1.5, 0
1025, 0.89130434782609, 1.5, 0
1026, 0.93478260869565, 1.5, 0
1027, 0.97826086956522, 1.5, 0
1028, 1, 1.4333333333333, 0.5
1029, 1, 1.4666666666667, 0.5
1030, 1, 1.4166666666667, 0.5
1031, 1, 1.45, 0.5
1032, 1, 1.4833333333333, 0.5
1033, 1, 1.5, 0.045454545454545
1034, 1, 1.5, 0.090909090909091
1035, 1, 1.5, 0.13636363636364
1036, 1, 1.5, 0.18181818181818
1037, 1, 1.5, 0.22727272727273
1038, 1, 1.5, 0.27272727272727
1039, 1, 1.5, 0.31818181818182
1040, 1, 1.5, 0.36363636363636
1041, 1, 1.5, 0.40909090909091
1042, 1, 1.5, 0.45454545454545
1043, 1, 1.5, 0.022727272727273
1044, 1, 1.5, 0.068181818181818
1045, 1, 1.5, 0.11363636363636
1046, 1, 1.5, 0.15909090909091
1047, 1, 1.5, 0.20454545454545
1048, 1, 1.5, 0.25
1049, 1, 1.5, 0.29545454545455
1050, 1, 1.5, 0.34090909090909
1051, 1, 1.5, 0.38636363636364
1052, 1, 1.5, 0.43181818181818
1053, 1, 1.5, 0.47727272727273
1054, 0, 1.4333333333333, 0.5
1055, 0, 1.4666666666667, 0.5
1056, 0, 1.4166666666667, 0.5
1057, 0, 1.45, 0.5
1058, 0, 1.4833333333333, 0.5
1059, 0.043478260869565, 1.5, 0.5
1060, 0.08695652173913, 1.5, 0.5
1061, 0.1304347826087, 1.5, 0.5
1062, 0.17391304347826, 1.5, 0.5
1063, 0.21739130434783, 1.5, 0.5
1064, 0.26086956521739, 1.5, 0.5
1065, 0.30434782608696, 1.5, 0.5
1066, 0.34782608695652, 1.5, 0.5
1067, 0.39130434782609, 1.5, 0.5
1068, 0.43478260869565, 1.5, 0.5
1069, 0.47826086956522, 1.5, 0.5
1070, 0.52173913043478, 1.5, 0.5
1071, 0.56521739130435, 1.5, 0.5
1072, 0.60869565217391, 1.5, 0.5
1073, 0.65217391304348, 1.5, 0.5
1074, 0.69565217391304, 1.5, 0.5
1075, 0.73913043478261, 1.5, 0.5
1076, 0.78260869565217, 1.5, 0.5
1077, 0.82608695652174, 1.5, 0.5
1078, 0.8695652173913, 1.5, 0.5
1079, 0.91304347826087, 1.5, 0.5
1080, 0.95652173913043, 1.5, 0.5
1081, 0.021739130434783, 1.5, 0.5
1082, 0.065217391304348, 1.5, 0.5
1083, 0.10869565217391, 1.5, 0.5
1084, 0.15217391304348, 1.5, 0.5
1085, 0.19565217391304, 1.5, 0.5
1086, 0.23913043478261, 1.5, 0.5
1087, 0.28260869565217, 1.5, 0.5
1088, 0.32608695652174, 1.5, 0.5
1089, 0.3695652173913, 1.5, 0.5
1090, 0.41304347826087, 1.5, 0.5
1091, 0.45652173913043, 1.5, 0.5
1092, 0.5, 1.5, 0.5
1093, 0.54347826086957, 1.5, 0.5
1094, 0.58695652173913, 1.5, 0.5
1095, 0.6304347826087, 1.5, 0.5
1096, 0.67391304347826, 1.5, 0.5
1097, 0.71739130434783, 1.5, 0.5
1098, 0.76086956521739, 1.5, 0.5
1099, 0.80434782608696, 1.5, 0.5
1100, 0.84782608695652, 1.5, 0.5
1101, 0.89130434782609, 1.5, 0.5
1102, 0.93478260869565, 1.5, 0.5
1103, 0.97826086956522, 1.5, 0.5
1104, 0, 1.5, 0.045454545454545
1105, 0, 1.5, 0.090909090909091
1106, 0, 1.5, 0.13636363636364
1107, 0, 1.5, 0.18181818181818
1108, 0, 1.5, 0.22727272727273
1109, 0, 1.5, 0.27272727272727
1110, 0, 1.5, 0.31818181818182
1111, 0, 1.5, 0.36363636363636
1112, 0, 1.5, 0.40909090909091
1113, 0, 1.5, 0.45454545454545
1114, 0, 1.5, 0.022727272727273
1115, 0, 1.5, 0.068181818181818
1116, 0, 1.5, 0.11363636363636
1117, 0, 1.5, 0.15909090909091
1118, 0, 1.5, 0.20454545454545
1119, 0, 1.5, 0.25
1120, 0, 1.5, 0.29545454545455
1121, 0, 1.5, 0.34090909090909
1122, 0, 1.5, 0.38636363636364
1123, 0, 1.5, 0.43181818181818
1124, 0, 1.5, 0.47727272727273
1125, 1.04, 1.4, 0.5
1126, 1.08, 1.4, 0.5
1127, 1.12, 1.4, 0.5
1128, 1.16, 1.4, 0.5
1129, 1.02, 1.4, 0.5
1130, 1.06, 1.4, 0.5
1131, 1.1, 1.4, 0.5
1132, 1.14, 1.4, 0.5
1133, 1.18, 1.4, 0.5
1134, 1.04, 1.5, 0.5
1135, 1.08, 1.5, 0.5
1136, 1.12, 1.5, 0.5
1137, 1.16, 1.5, 0.5
1138, 1.02, 1.5, 0.5
1139, 1.06, 1.5, 0.5
1140, 1.1, 1.5, 0.5
1141, 1.14, 1.5, 0.5
1142, 1.18, 1.5, 0.5
1143, 1.2, 1.4333333333333, 0.5
1144, 1.2, 1.4666666666667, 0.5
1145, 1.2, 1.4166666666667, 0.5
1146, 1.2, 1.45, 0.5
1147, 1.2, 1.4833333333333, 0.5
1148, 1.04, 1.4, 0
1149, 1.08, 1.4, 0
1150, 1.12, 1.4, 0
1151, 1.16, 1.4, 0
1152, 1.02, 1.4, 0
1153, 1.06, 1.4, 0
1154, 1.1, 1.4, 0
1155, 1.14, 1.4, 0
1156, 1.18, 1.4, 0
1157, 1.04, 1.5, 0
1158, 1.08, 1.5, 0
1159, 1.12, 1.5, 0
1160, 1.16, 1.5, 0
1161, 1.02, 1.5, 0
1162, 1.06, 1.5, 0
1163, 1.1, 1.5, 0
1164, 1.14, 1.5, 0
1165, 1.18, 1.5, 0
1166, 1.2, 1.4333333333333, 0
1167, 1.2, 1.4666666666667, 0
1168, 1.2, 1.4166666666667, 0
1169, 1.2, 1.45, 0
1170, 1.2, 1.4833333333333, 0
1171, 1.2, 1.4, 0.045454545454545
1172, 1.2, 1.4, 0.090909090909091
1173, 1.2, 1.4, 0.13636363636364
1174, 1.2, 1.4, 0.18181818181818
1175, 1.2, 1.4, 0.22727272727273
1176, 1.2, 1.4, 0.27272727272727
1177, 1.2, 1.4, 0.31818181818182
1178, 1.2, 1.4, 0.36363636363636
1179, 1.2, 1.4, 0.40909090909091
1180, 1.2, 1.4, 0.45454545454545
1181, 1.2, 1.4, 0.022727272727273
1182, 1.2, 1.4, 0.068181818181818
1183, 1.2, 1.4, 0.11363636363636
1184, 1.2, 1.4, 0.15909090909091
1185, 1.2, 1.4, 0.20454545454545
1186, 1.2, 1.4, 0.25
1187, 1.2, 1.4, 0.29545454545455
1188, 1.2, 1.4, 0.34090909090909
1189, 1.2, 1.4, 0.38636363636364
1190, 1.2, 1.4, 0.43181818181818
1191, 1.2, 1.4, 0.47727272727273
1192, 1.2, 1.5, 0.045454545454545
1193, 1.2, 1.5, 0.090909090909091
1194, 1.2, 1.5, 0.13636363636364
1195, 1.2, 1.5, 0.18181818181818
1196, 1.2, 1.5, 0.22727272727273
1197, 1.2, 1.5, 0.27272727272727
1198, 1.2, 1.5, 0.31818181818182
1199, 1.2, 1.5, 0.36363636363636
1200, 1.2, 1.5, 0.40909090909091
1201, 1.2, 1.5, 0.45454545454545
1202, 1.2, 1.5, 0.022727272727273
1203, 1.2, 1.5, 0.068181818181818
1204, 1.2, 1.5, 0.11363636363636
1205, 1.2, 1.5, 0.15909090909091
1206, 1.2, 1.5, 0.20454545454545
1207, 1.2, 1.5, 0.25
1208, 1.2, 1.5, 0.29545454545455
1209, 1.2, 1.5, 0.34090909090909
1210, 1.2, 1.5, 0.38636363636364
1211, 1.2, 1.5, 0.43181818181818
1212, 1.2, 1.5, 0.47727272727273
1213, 1.2434782608696, 1.4, 0.5
1214, 1.2869565217391, 1.4, 0.5
1215, 1.3304347826087, 1.4, 0.5
1216, 1.3739130434783, 1.4, 0.5
1217, 1.4173913043478, 1.4, 0.5
1218, 1.4608695652174, 1.4, 0.5
1219, 1.504347826087, 1.4, 0.5
1220, 1.5478260869565, 1.4, 0.5
1221, 1.5913043478261, 1.4, 0.5
1222, 1.6347826086957, 1.4, 0.5
1223, 1.6782608695652, 1.4, 0.5
1224, 1.7217391304348, 1.4, 0.5
1225, 1.7652173913043, 1.4, 0.5
1226, 1.8086956521739, 1.4, 0.5
1227, 1.8521739130435, 1.4, 0.5
1228, 1.895652173913, 1.4, 0.5
1229, 1.9391304347826, 1.4, 0.5
1230, 1.9826086956522, 1.4, 0.5
1231, 2.0260869565217, 1.4, 0.5
1232, 2.0695652173913, 1.4, 0.5
1233, 2.1130434782609, 1.4, 0.5
1234, 2.1565217391304, 1.4, 0.5
1235, 1.2217391304348, 1.4, 0.5
1236, 1.2652173913043, 1.4, 0.5
1237, 1.3086956521739, 1.4, 0.5
1238, 1.3521739130435, 1.4, 0.5
1239, 1.395652173913, 1.4, 0.5
1240, 1.4391304347826, 1.4, 0.5
1241, 1.4826086956522, 1.4, 0.5
1242, 1.5260869565217, 1.4, 0.5
1243, 1.5695652173913, 1.4, 0.5
1244, 1.6130434782609, 1.4, 0.5
1245, 1.6565217391304, 1.4, 0.5
1246, 1.7, 1.4, 0.5
1247, 1.7434782608696, 1.4, 0.5
1248, 1.7869565217391, 1.4, 0.5
1249, 1.8304347826087, 1.4, 0.5
1250, 1.8739130434783, 1.4, 0.5
1251, 1.9173913043478, 1.4, 0.5
1252, 1.9608695652174, 1.4, 0.5
1253, 2.004347826087, 1.4, 0.5
1254, 2.0478260869565, 1.4, 0.5
1255, 2.0913043478261, 1.4, 0.5
1256, 2.1347826086957, 1.4, 0.5
1257, 2.1782608695652, 1.4, 0.5
1258, 1.2434782608696, 1.5, 0.5
1259, 1.2869565217391, 1.5, 0.5
1260, 1.3304347826087, 1.5, 0.5
1261, 1.3739130434783, 1.5, 0.5
1262, 1.4173913043478, 1.5, 0.5
1263, 1.4608695652174, 1.5, 0.5
1264, 1.504347826087, 1.5, 0.5
1265, 1.5478260869565, 1.5, 0.5
1266, 1.5913043478261, 1.5, 0.5
1267, 1.6347826086957, 1.5, 0.5
1268, 1.6782608695652, 1.5, 0.5
1269, 1.7217391304348, 1.5, 0.5
1270, 1.7652173913043, 1.5, 0.5
1271, 1.8086956521739, 1.5, 0.5
1272, 1.8521739130435, 1.5, 0.5
1273, 1.895652173913, 1.5, 0.5
1274, 1.9391304347826, 1.5, 0.5
1275, 1.9826086956522, 1.5, 0.5
1276, 2.0260869565217, 1.5, 0.5
1277, 2.0695652173913, 1.5, 0.5
1278, 2.1130434782609, 1.5, 0.5
1279, 2.1565217391304, 1.5, 0.5
1280, 1.2217391304348, 1.5, 0.5
1281, 1.2652173913043, 1.5, 0.5
1282, 1.3086956521739, 1.5, 0.5
1283, 1.3521739130435, 1.5, 0.5
1284, 1.395652173913, 1.5, 0.5
1285, 1.4391304347826, 1.5, 0.5
1286, 1.4826086956522, 1.5, 0.5
1287, 1.5260869565217, 1.5, 0.5
1288, 1.5695652173913, 1.5, 0.5
1289, 1.6130434782609, 1.5, 0.5
1290, 1.6565217391304, 1.5, 0.5
1291, 1.7, 1.5, 0.5
1292, 1.7434782608696, 1.5, 0.5
1293, 1.7869565217391, 1.5, 0.5
1294, 1.8304347826087, 1.5, 0.5
1295, 1.8739130434783, 1.5, 0.5
1296, 1.9173913043478, 1.5, 0.5
1297, 1.9608695652174, 1.5, 0.5
1298, 2.004347826087, 1.5, 0.5
1299, 2.0478260869565, 1.5, 0.5
1300, 2.0913043478261, 1.5, 0.5
1301, 2.1347826086957, 1.5, 0.5
1302, 2.1782608695652, 1.5, 0.5
1303, 2.2, 1.4333333333333, 0.5
1304, 2.2, 1.4666666666667, 0.5
1305, 2.2, 1.4166666666667, 0.5
1306, 2.2, 1.45, 0.5
1307, 2.2, 1.4833333333333, 0.5
1308, 1.2434782608696, 1.4, 0
1309, 1.2869565217391, 1.4, 0
1310, 1.3304347826087, 1.4, 0
1311, 1.3739130434783, 1.4, 0
1312, 1.4173913043478, 1.4, 0
1313, 1.4608695652174, 1.4, 0
1314, 1.504347826087, 1.4, 0
1315, 1.5478260869565, 1.4, 0
1316, 1.5913043478261, 1.4, 0
1317, 1.6347826086957, 1.4, 0
1318, 1.6782608695652, 1.4, 0
1319, 1.7217391304348, 1.4, 0
1320, 1.7652173913043, 1.4, 0
1321, 1.8086956521739, 1.4, 0
1322, 1.8521739130435, 1.4, 0
1323, 1.895652173913, 1.4, 0
1324, 1.9391304347826, 1.4, 0
1325, 1.9826086956522, 1.4, 0
1326, 2.0260869565217, 1.4, 0
1327, 2.0695652173913, 1.4, 0
1328, 2.1130434782609, 1.4, 0
1329, 2.1565217391304, 1.4, 0
1330, 1.2217391304348, 1.4, 0
1331, 1.2652173913043, 1.4, 0
1332, 1.3086956521739, 1.4, 0
1333, 1.3521739130435, 1.4, 0
1334, 1.395652173913, 1.4, 0
1335, 1.4391304347826, 1.4, 0
1336, 1.4826086956522, 1.4, 0
1337, 1.5260869565217, 1.4, 0
1338, 1.5695652173913, 1.4, 0
1339, 1.6130434782609, 1.4, 0
1340, 1.6565217391304, 1.4, 0
1341, 1.7, 1.4, 0
1342, 1.7434782608696, 1.4, 0
1343, 1.7869565217391, 1.4, 0
1344, 1.8304347826087, 1.4, 0
1345, 1.8739130434783, 1.4, 0
1346, 1.9173913043478, 1.4, 0
1347, 1.9608695652174, 1.4, 0
1348, 2.004347826087, 1.4, 0
1349, 2.0478260869565, 1.4, 0
1350, 2.0913043478261, 1.4, 0
1351, 2.1347826086957, 1.4, 0
1352, 2.1782608695652, 1.4, 0
1353, 1.2434782608696, 1.5, 0
1354, 1.2869565217391, 1.5, 0
1355, 1.3304347826087, 1.5, 0
1356, 1.3739130434783, 1.5, 0
1357, 1.4173913043478, 1.5, 0
1358, 1.4608695652174, 1.5, 0
1359, 1.504347826087, 1.5, 0
1360, 1.5478260869565, 1.5, 0
1361, 1.5913043478261, 1.5, 0
1362, 1.6347826086957, 1.5, 0
1363, 1.6782608695652, 1.5, 0
1364, 1.7217391304348, 1.5, 0
1365, 1.7652173913043, 1.5, 0
1366, 1.8086956521739, 1.5, 0
1367, 1.8521739130435, 1.5, 0
1368, 1.895652173913, 1.5, 0
1369, 1.9391304347826, 1.5, 0
1370, 1.9826086956522, 1.5, 0
1371, 2.0260869565217, 1.5, 0
1372, 2.0695652173913, 1.5, 0
1373, 2.1130434782609, 1.5, 0
1374, 2.1565217391304, 1.5, 0
1375, 1.2217391304348, 1.5, 0
1376, 1.2652173913043, 1.5, 0
1377, 1.3086956521739, 1.5, 0
1378, 1.3521739130435, 1.5, 0
1379, 1.395652173913, 1.5, 0
1380, 1.4391304347826, 1.5, 0
1381, 1.4826086956522, 1.5, 0
1382, 1.5260869565217, 1.5, 0
1383, 1.5695652173913, 1.5, 0
1384, 1.6130434782609, 1.5, 0
1385, 1.6565217391304, 1.5, 0
1386, 1.7, 1.5, 0
1387, 1.7434782608696, 1.5, 0
1388, 1.7869565217391, 1.5, 0
1389, 1.8304347826087, 1.5, 0
1390, 1.8739130434783, 1.5, 0
1391, 1.9173913043478, 1.5, 0
1392, 1.9608695652174, 1.5, 0
1393, 2.004347826087, 1.5, 0
1394, 2.0478260869565, 1.5, 0
1395, 2.0913043478261, 1.5, 0
1396, 2.1347826086957, 1.5, 0
1397, 2.1782608695652, 1.5, 0
1398, 2.2, 1.4333333333333, 0
1399, 2.2, 1.4666666666667, 0
1400, 2.2, 1.4166666666667, 0
1401, 2.2, 1.45, 0
1402, 2.2, 1.4833333333333, 0
1403, 2.2, 1.4, 0.045454545454545
1404, 2.2, 1.4, 0.090909090909091
1405, 2.2, 1.4, 0.13636363636364
1406, 2.2, 1.4, 0.18181818181818
1407, 2.2, 1.4, 0.22727272727273
1408, 2.2, 1.4, 0.27272727272727
1409, 2.2, 1.4, 0.31818181818182
1410, 2.2, 1.4, 0.36363636363636
1411, 2.2, 1.4, 0.40909090909091
1412, 2.2, 1.4, 0.45454545454545
1413, 2.2, 1.4, 0.022727272727273
1414, 2.2, 1.4, 0.068181818181818
1415, 2.2, 1.4, 0.11363636363636
1416, 2.2, 1.4, 0.15909090909091
1417, 2.2, 1.4, 0.20454545454545
1418, 2.2, 1.4, 0.25
1419, 2.2, 1.4, 0.29545454545455
1420, 2.2, 1.4, 0.34090909090909
1421, 2.2, 1.4, 0.38636363636364
1422, 2.2, 1.4, 0.43181818181818
1423, 2.2, 1.4, 0.47727272727273
1424, 2.2, 1.5, 0.045454545454545
1425, 2.2, 1.5, 0.090909090909091
1426, 2.2, 1.5, 0.13636363636364
1427, 2.2, 1.5, 0.18181818181818
1428, 2.2, 1.5, 0.22727272727273
1429, 2.2, 1.5, 0.27272727272727
1430, 2.2, 1.5, 0.31818181818182
1431, 2.2, 1.5, 0.36363636363636
1432, 2.2, 1.5, 0.40909090909091
1433, 2.2, 1.5, 0.45454545454545
1434, 2.2, 1.5, 0.022727272727273
1435, 2.2, 1.5, 0.068181818181818
1436, 2.2, 1.5, 0.11363636363636
1437, 2.2, 1.5, 0.15909090909091
1438, 2.2, 1.5, 0.20454545454545
1439, 2.2, 1.5, 0.25
1440, 2.2, 1.5, 0.29545454545455
1441, 2.2, 1.5, 0.34090909090909
1442, 2.2, 1.5, 0.38636363636364
1443, 2.2, 1.5, 0.43181818181818
1444, 2.2, 1.5, 0.47727272727273
1445, 1.2, 1.375, 0.5
1446, 1.2, 1.3875, 0.5
1447, 1.2, 1.3625, 0.5
1448, 2.2, 1.375, 0.5
1449, 2.2, 1.3875, 0.5
1450, 2.2, 1.3625, 0.5
1451, 1.2434782608696, 1.35, 0.5
1452, 1.2869565217391, 1.35, 0.5
1453, 1.3304347826087, 1.35, 0.5
1454, 1.3739130434783, 1.35, 0.5
1455, 1.4173913043478, 1.35, 0.5
1456, 1.4608695652174, 1.35, 0.5
1457, 1.504347826087, 1.35, 0.5
1458, 1.5478260869565, 1.35, 0.5
1459, 1.5913043478261, 1.35, 0.5
1460, 1.6347826086957, 1.35, 0.5
1461, 1.6782608695652, 1.35, 0.5
1462, 1.7217391304348, 1.35, 0.5
1463, 1.7652173913043, 1.35, 0.5
1464, 1.8086956521739, 1.35, 0.5
1465, 1.8521739130435, 1.35, 0.5
1466, 1.895652173913, 1.35, 0.5
1467, 1.9391304347826, 1.35, 0.5
1468, 1.9826086956522, 1.35, 0.5
1469, 2.0260869565217, 1.35, 0.5
1470, 2.0695652173913, 1.35, 0.5
1471, 2.1130434782609, 1.35, 0.5
1472, 2.1565217391304, 1.35, 0.5
1473, 1.2217391304348, 1.35, 0.5
1474, 1.2652173913043, 1.35, 0.5
1475, 1.3086956521739, 1.35, 0.5
1476, 1.3521739130435, 1.35, 0.5
1477, 1.395652173913, 1.35, 0.5
1478, 1.4391304347826, 1.35, 0.5
1479, 1.4826086956522, 1.35, 0.5
1480, 1.5260869565217, 1.35, 0.5
1481, 1.5695652173913, 1.35, 0.5
1482, 1.6130434782609, 1.35, 0.5
1483, 1.6565217391304, 1.35, 0.5
1484, 1.7, 1.35, 0.5
1485, 1.7434782608696, 1.35, 0.5
1486, 1.7869565217391, 1.35, 0.5
1487, 1.8304347826087, 1.35, 0.5
1488, 1.8739130434783, 1.35, 0.5
1489, 1.9173913043478, 1.35, 0.5
1490, 1.9608695652174, 1.35, 0.5
1491, 2.004347826087, 1.35, 0.5
1492, 2.0478260869565, 1.35, 0.5
1493, 2.0913043478261, 1.35, 0.5
1494, 2.1347826086957, 1.35, 0.5
1495, 2.1782608695652, 1.35, 0.5
1496, 1.2, 1.375, 0
1497, 1.2, 1.3875, 0
1498, 1.2, 1.3625, 0
1499, 2.2, 1.375, 0
1500, 2.2, 1.3875, 0
1501, 2.2, 1.3625, 0
1502, 1.2434782608696, 1.35, 0
1503, 1.2869565217391, 1.35, 0
1504, 1.3304347826087, 1.35, 0
1505, 1.3739130434783, 1.35, 0
1506, 1.4173913043478, 1.35, 0
1507, 1.4608695652174, 1.35, 0
1508, 1.504347826087, 1.35, 0
1509, 1.5478260869565, 1.35, 0
1510, 1.5913043478261, 1.35, 0
1511, 1.6347826086957, 1.35, 0
1512, 1.6782608695652, 1.35, 0
1513, 1.7217391304348, 1.35, 0
1514, 1.7652173913043, 1.35, 0
1515, 1.8086956521739, 1.35, 0
1516, 1.8521739130435, 1.35, 0
1517, 1.895652173913, 1.35, 0
1518, 1.9391304347826, 1.35, 0
1519, 1.9826086956522, 1.35, 0
1520, 2.0260869565217, 1.35, 0
1521, 2.0695652173913, 1.35, 0
1522, 2.1130434782609, 1.35, 0
1523, 2.1565217391304, 1.35, 0
1524, 1.2217391304348, 1.35, 0
1525, 1.2652173913043, 1.35, 0
1526, 1.3086956521739, 1.35, 0
1527, 1.3521739130435, 1.35, 0
1528, 1.395652173913, 1.35, 0
1529, 1.4391304347826, 1.35, 0
1530, 1.4826086956522, 1.35, 0
1531, 1.5260869565217, 1.35, 0
1532, 1.5695652173913, 1.35, 0
1533, 1.6130434782609, 1.35, 0
1534, 1.6565217391304, 1.35, 0
1535, 1.7, 1.35, 0
1536, 1.7434782608696, 1.35, 0
1537, 1.7869565217391, 1.35, 0
1538, 1.8304347826087, 1.35, 0
1539, 1.8739130434783, 1.35, 0
1540, 1.9173913043478, 1.35, 0
1541, 1.9608695652174, 1.35, 0
1542, 2.004347826087, 1.35, 0
1543, 2.0478260869565, 1.35, 0
1544, 2.0913043478261, 1.35, 0
1545, 2.1347826086957, 1.35, 0
1546, 2.1782608695652, 1.35, 0
1547, 1.2, 1.35, 0.045454545454545
1548, 1.2, 1.35, 0.090909090909091
1549, 1.2, 1.35, 0.13636363636364
1550, 1.2, 1.35, 0.18181818181818
1551, 1.2, 1.35, 0.22727272727273
1552, 1.2, 1.35, 0.27272727272727
1553, 1.2, 1.35, 0.31818181818182
1554, 1.2, 1.35, 0.36363636363636
1555, 1.2, 1.35, 0.40909090909091
1556, 1.2, 1.35, 0.45454545454545
1557, 1.2, 1.35, 0.022727272727273
1558, 1.2, 1.35, 0.068181818181818
1559, 1.2, 1.35, 0.11363636363636
1560, 1.2, 1.35, 0.15909090909091
1561, 1.2, 1.35, 0.20454545454545
1562, 1.2, 1.35, 0.25
1563, 1.2, 1.35, 0.29545454545455
1564, 1.2, 1.35, 0.34090909090909
1565, 1.2, 1.35, 0.38636363636364
1566, 1.2, 1.35, 0.43181818181818
1567, 1.2, 1.35, 0.47727272727273
1568, 2.2, 1.35, 0.045454545454545
1569, 2.2, 1.35, 0.090909090909091
1570, 2.2, 1.35, 0.13636363636364
1571, 2.2, 1.35, 0.18181818181818
1572, 2.2, 1.35, 0.22727272727273
1573, 2.2, 1.35, 0.27272727272727
1574, 2.2, 1.35, 0.31818181818182
1575, 2.2, 1.35, 0.36363636363636
1576, 2.2, 1.35, 0.40909090909091
1577, 2.2, 1.35, 0.45454545454545
1578, 2.2, 1.35, 0.022727272727273
1579, 2.2, 1.35, 0.068181818181818
1580, 2.2, 1.35, 0.11363636363636
1581, 2.2, 1.35, 0.15909090909091
1582, 2.2, 1.35, 0.20454545454545
1583, 2.2, 1.35, 0.25
1584, 2.2, 1.35, 0.29545454545455
1585, 2.2, 1.35, 0.34090909090909
1586, 2.2, 1.35, 0.38636363636364
1587, 2.2, 1.35, 0.43181818181818
1588, 2.2, 1.35, 0.47727272727273
1589, 1.2, 1.2978260869565, 0.5
1590, 1.2, 1.245652173913, 0.5
1591, 1.2, 1.1934782608696, 0.5
1592, 1.2, 1.1413043478261, 0.5
1593, 1.2, 1.0891304347826, 0.5
1594, 1.2, 1.0369565217391, 0.5
1595, 1.2, 0.98478260869565, 0.5
1596, 1.2, 0.93260869565217, 0.5
1597, 1.2, 0.8804347826087, 0.5
1598, 1.2, 0.82826086956522, 0.5
1599, 1.2, 0.77608695652174, 0.5
1600, 1.2, 0.72391304347826, 0.5
1601, 1.2, 0.67173913043478, 0.5
1602, 1.2, 0.61956521739131, 0.5
1603, 1.2, 0.56739130434783, 0.5
1604, 1.2, 0.51521739130435, 0.5
1605, 1.2, 0.46304347826087, 0.5
1606, 1.2, 0.41086956521739, 0.5
1607, 1.2, 0.35869565217391, 0.5
1608, 1.2, 0.30652173913044, 0.5
1609, 1.2, 0.25434782608696, 0.5
1610, 1.2, 0.20217391304348, 0.5
1611, 1.2, 1.3239130434783, 0.5
1612, 1.2, 1.2717391304348, 0.5
1613, 1.2, 1.2195652173913, 0.5
1614, 1.2, 1.1673913043478, 0.5
1615, 1.2, 1.1152173913043, 0.5
1616, 1.2, 1.0630434782609, 0.5
1617, 1.2, 1.0108695652174, 0.5
1618, 1.2, 0.95869565217391, 0.5
1619, 1.2, 0.90652173913044, 0.5
1620, 1.2, 0.85434782608696, 0.5
1621, 1.2, 0.80217391304348, 0.5
1622, 1.2, 0.75, 0.5
1623, 1.2, 0.69782608695652, 0.5
1624, 1.2, 0.64565217391304, 0.5
1625, 1.2, 0.59347826086957, 0.5
1626, 1.2, 0.54130434782609, 0.5
1627, 1.2, 0.48913043478261, 0.5
1628, 1.2, 0.43695652173913, 0.5
1629, 1.2, 0.38478260869565, 0.5
1630, 1.2, 0.33260869565217, 0.5
1631, 1.2, 0.2804347826087, 0.5
1632, 1.2, 0.22826086956522, 0.5
1633, 1.2, 0.17608695652174, 0.5
1634, 2.2, 1.2978260869565, 0.5
1635, 2.2, 1.245652173913, 0.5
1636, 2.2, 1.1934782608696, 0.5
1637, 2.2, 1.1413043478261, 0.5
1638, 2.2, 1.0891304347826, 0.5
1639, 2.2, 1.0369565217391, 0.5
1640, 2.2, 0.98478260869565, 0.5
1641, 2.2, 0.93260869565217, 0.5
1642, 2.2, 0.8804347826087, 0.5
1643, 2.2, 0.82826086956522, 0.5
1644, 2.2, 0.77608695652174, 0.5
1645, 2.2, 0.72391304347826, 0.5
1646, 2.2, 0.67173913043478, 0.5
1647, 2.2, 0.61956521739131, 0.5
1648, 2.2, 0.56739130434783, 0.5
1649, 2.2, 0.51521739130435, 0.5
1650, 2.2, 0.46304347826087, 0.5
1651, 2.2, 0.41086956521739, 0.5
1652, 2.2, 0.35869565217391, 0.5
1653, 2.2, 0.30652173913044, 0.5
1654, 2.2, 0.25434782608696, 0.5
1655, 2.2, 0.20217391304348, 0.5
1656, 2.2, 1.3239130434783, 0.5
1657, 2.2, 1.2717391304348, 0.5
1658, 2.2, 1.2195652173913, 0.5
1659, 2.2, 1.1673913043478, 0.5
1660, 2.2, 1.1152173913043, 0.5
1661, 2.2, 1.0630434782609, 0.5
1662, 2.2, 1.0108695652174, 0.5
1663, 2.2, 0.95869565217391, 0.5
1664, 2.2, 0.90652173913044, 0.5
1665, 2.2, 0.85434782608696, 0.5
1666, 2.2, 0.80217391304348, 0.5
1667, 2.2, 0.75, 0.5
1668, 2.2, 0.69782608695652, 0.5
1669, 2.2, 0.64565217391304, 0.5
1670, 2.2, 0.59347826086957, 0.5
1671, 2.2, 0.54130434782609, 0.5
1672, 2.2, 0.48913043478261, 0.5
1673, 2.2, 0.43695652173913, 0.5
1674, 2.2, 0.38478260869565, 0.5
1675, 2.2, 0.33260869565217, 0.5
1676, 2.2, 0.2804347826087, 0.5
1677, 2.2, 0.22826086956522, 0.5
1678, 2.2, 0.17608695652174, 0.5
1679, 1.2434782608696, 0.15, 0.5
1680, 1.2869565217391, 0.15, 0.5
1681, 1.3304347826087, 0.15, 0.5
1682, 1.3739130434783, 0.15, 0.5
1683, 1.4173913043478, 0.15, 0.5
1684, 1.4608695652174, 0.15, 0.5
1685, 1.504347826087, 0.15, 0.5
1686, 1.5478260869565, 0.15, 0.5
1687, 1.5913043478261, 0.15, 0.5
1688, 1.6347826086957, 0.15, 0.5
1689, 1.6782608695652, 0.15, 0.5
1690, 1.7217391304348, 0.15, 0.5
1691, 1.7652173913043, 0.15, 0.5
1692, 1.8086956521739, 0.15, 0.5
1693, 1.8521739130435, 0.15, 0.5
1694, 1.895652173913, 0.15, 0.5
1695, 1.9391304347826, 0.15, 0.5
1696, 1.9826086956522, 0.15, 0.5
1697, 2.0260869565217, 0.15, 0.5
1698, 2.0695652173913, 0.15, 0.5
1699, 2.1130434782609, 0.15, 0.5
1700, 2.1565217391304, 0.15, 0.5
1701, 1.2217391304348, 0.15, 0.5
1702, 1.2652173913043, 0.15, 0.5
1703, 1.3086956521739, 0.15, 0.5
1704, 1.3521739130435, 0.15, 0.5
1705, 1.395652173913, 0.15, 0.5
1706, 1.4391304347826, 0.15, 0.5
1707, 1.4826086956522, 0.15, 0.5
1708, 1.5260869565217, 0.15, 0.5
1709, 1.5695652173913, 0.15, 0.5
1710, 1.6130434782609, 0.15, 0.5
1711, 1.6565217391304, 0.15, 0.5
1712, 1.7, 0.15, 0.5
1713, 1.7434782608696, 0.15, 0.5
1714, 1.7869565217391, 0.15, 0.5
1715, 1.8304347826087, 0.15, 0.5
1716, 1.8739130434783, 0.15, 0.5
1717, 1.9173913043478, 0.15, 0.5
1718, 1.9608695652174, 0.15, 0.5
1719, 2.004347826087, 0.15, 0.5
1720, 2.0478260869565, 0.15, 0.5
1721, 2.0913043478261, 0.15, 0.5
1722, 2.1347826086957, 0.15, 0.5
1723, 2.1782608695652, 0.15, 0.5
1724, 1.2, 1.2978260869565, 0
1725, 1.2, 1.245652173913, 0
1726, 1.2, 1.1934782608696, 0
1727, 1.2, 1.1413043478261, 0
1728, 1.2, 1.0891304347826, 0
1729, 1.2, 1.0369565217391, 0
1730, 1.2, 0.98478260869565, 0
1731, 1.2, 0.93260869565217, 0
1732, 1.2, 0.8804347826087, 0
1733, 1.2, 0.82826086956522, 0
1734, 1.2, 0.77608695652174, 0
1735, 1.2, 0.72391304347826, 0
1736, 1.2, 0.67173913043478, 0
1737, 1.2, 0.61956521739131, 0
1738, 1.2, 0.56739130434783, 0
1739, 1.2, 0.51521739130435, 0
1740, 1.2, 0.46304347826087, 0
1741, 1.2, 0.41086956521739, 0
1742, 1.2, 0.35869565217391, 0
1743, 1.2, 0.30652173913044, 0
1744, 1.2, 0.25434782608696, 0
1745, 1.2, 0.20217391304348, 0
1746, 1.2, 1.3239130434783, 0
1747, 1.2, 1.2717391304348, 0
1748, 1.2, 1.2195652173913, 0
1749, 1.2, 1.1673913043478, 0
1750, 1.2, 1.1152173913043, 0
1751, 1.2, 1.0630434782609, 0
1752, 1.2, 1.0108695652174, 0
1753, 1.2, 0.95869565217391, 0
1754, 1.2, 0.90652173913044, 0
1755, 1.2, 0.85434782608696, 0
1756, 1.2, 0.80217391304348, 0
1757, 1.2, 0.75, 0
1758, 1.2, 0.69782608695652, 0
1759, 1.2, 0.64565217391304, 0
1760, 1.2, 0.59347826086957, 0
1761, 1.2, 0.54130434782609, 0
1762, 1.2, 0.48913043478261, 0
1763, 1.2, 0.43695652173913, 0
1764, 1.2, 0.38478260869565, 0
1765, 1.2, 0.33260869565217, 0
1766, 1.2, 0.2804347826087, 0
1767, 1.2, 0.22826086956522, 0
1768, 1.2, 0.17608695652174, 0
1769, 2.2, 1.2978260869565, 0
1770, 2.2, 1.245652173913, 0
1771, 2.2, 1.1934782608696, 0
1772, 2.2, 1.1413043478261, 0
1773, 2.2, 1.0891304347826, 0
1774, 2.2, 1.0369565217391, 0
1775, 2.2, 0.98478260869565, 0
1776, 2.2, 0.93260869565217, 0
1777, 2.2, 0.8804347826087, 0
1778, 2.2, 0.82826086956522, 0
1779, 2.2, 0.77608695652174, 0
1780, 2.2, 0.72391304347826, 0
1781, 2.2, 0.67173913043478, 0
1782, 2.2, 0.61956521739131, 0
1783, 2.2, 0.56739130434783, 0
1784, 2.2, 0.51521739130435, 0
1785, 2.2, 0.46304347826087, 0
1786, 2.2, 0.41086956521739, 0
1787, 2.2, 0.35869565217391, 0
1788, 2.2, 0.30652173913044, 0
1789, 2.2, 0.25434782608696, 0
1790, 2.2, 0.20217391304348, 0
1791, 2.2, 1.3239130434783, 0
1792, 2.2, 1.2717391304348, 0
1793, 2.2, 1.2195652173913, 0
1794, 2.2, 1.1673913043478, 0
1795, 2.2, 1.1152173913043, 0
1796, 2.2, 1.0630434782609, 0
1797, 2.2, 1.0108695652174, 0
1798, 2.2, 0.95869565217391, 0
1799, 2.2, 0.90652173913044, 0
1800, 2.2, 0.85434782608696, 0
1801, 2.2, 0.80217391304348, 0
1802, 2.2, 0.75, 0
1803, 2.2, 0.69782608695652, 0
1804, 2.2, 0.64565217391304, 0
1805, 2.2, 0.59347826086957, 0
1806, 2.2, 0.54130434782609, 0
1807, 2.2, 0.48913043478261, 0
1808, 2.2, 0.43695652173913, 0
1809, 2.2, 0.38478260869565, 0
1810, 2.2, 0.33260869565217, 0
1811, 2.2, 0.2804347826087, 0
1812, 2.2, 0.22826086956522, 0
1813, 2.2, 0.17608695652174, 0
1814, 1.2434782608696, 0.15, 0
1815, 1.2869565217391, 0.15, 0
1816, 1.3304347826087, 0.15, 0
1817, 1.3739130434783, 0.15, 0
1818, 1.4173913043478, 0.15, 0
1819, 1.4608695652174, 0.15, 0
1820, 1.504347826087, 0.15, 0
1821, 1.5478260869565, 0.15, 0
1822, 1.5913043478261, 0.15, 0
1823, 1.6347826086957, 0.15, 0
1824, 1.6782608695652, 0.15, 0
1825, 1.7217391304348, 0.15, 0
1826, 1.7652173913043, 0.15, 0
1827, 1.8086956521739, 0.15, 0
1828, 1.8521739130435, 0.15, 0
1829, 1.895652173913, 0.15, 0
1830, 1.9391304347826, 0.15, 0
1831, 1.9826086956522, 0.15, 0
1832, 2.0260869565217, 0.15, 0
1833, 2.0695652173913, 0.15, 0
1834, 2.1130434782609, 0.15, 0
1835, 2.1565217391304, 0.15, 0
1836, 1.2217391304348, 0.15, 0
1837, 1.2652173913043, 0.15, 0
1838, 1.3086956521739, 0.15, 0
1839, 1.3521739130435, 0.15, 0
1840, 1.395652173913, 0.15, 0
1841, 1.4391304347826, 0.15, 0
1842, 1.4826086956522, 0.15, 0
1843, 1.5260869565217, 0.15, 0
1844, 1.5695652173913, 0.15, 0
1845, 1.6130434782609, 0.15, 0
1846, 1.6565217391304, 0.15, 0
1847, 1.7, 0.15, 0
1848, 1.7434782608696, 0.15, 0
1849, 1.7869565217391, 0.15, 0
1850, 1.8304347826087, 0.15, 0
1851, 1.8739130434783, 0.15, 0
1852, 1.9173913043478, 0.15, 0
1853, 1.9608695652174, 0.15, 0
1854, 2.004347826087, 0.15, 0
1855, 2.0478260869565, 0.15, 0
1856, 2.0913043478261, 0.15, 0
1857, 2.1347826086957, 0.15, 0
1858, 2.1782608695652, 0.15, 0
1859, 1.2, 0.15, 0.045454545454545
1860, 1.2, 0.15, 0.090909090909091
1861, 1.2, 0.15, 0.13636363636364
1862, 1.2, 0.15, 0.18181818181818
1863, 1.2, 0.15, 0.22727272727273
1864, 1.2, 0.15, 0.27272727272727
1865, 1.2, 0.15, 0.31818181818182
1866, 1.2, 0.15, 0.36363636363636
1867, 1.2, 0.15, 0.40909090909091
1868, 1.2, 0.15, 0.45454545454545
1869, 1.2, 0.15, 0.022727272727273
1870, 1.2, 0.15, 0.068181818181818
1871, 1.2, 0.15, 0.11363636363636
1872, 1.2, 0.15, 0.15909090909091
1873, 1.2, 0.15, 0.20454545454545
1874, 1.2, 0.15, 0.25
1875, 1.2, 0.15, 0.29545454545455
1876, 1.2, 0.15, 0.34090909090909
1877, 1.2, 0.15, 0.38636363636364
1878, 1.2, 0.15, 0.43181818181818
1879, 1.2, 0.15, 0.47727272727273
1880, 2.2, 0.15, 0.045454545454545
1881, 2.2, 0.15, 0.090909090909091
1882, 2.2, 0.15, 0.13636363636364
1883, 2.2, 0.15, 0.18181818181818
1884, 2.2, 0.15, 0.22727272727273
1885, 2.2, 0.15, 0.27272727272727
1886, 2.2, 0.15, 0.31818181818182
1887, 2.2, 0.15, 0.36363636363636
1888, 2.2, 0.15, 0.40909090909091
1889, 2.2, 0.15, 0.45454545454545
1890, 2.2, 0.15, 0.022727272727273
1891, 2.2, 0.15, 0.068181818181818
1892, 2.2, 0.15, 0.11363636363636
1893, 2.2, 0.15, 0.15909090909091
1894, 2.2, 0.15, 0.20454545454545
1895, 2.2, 0.15, 0.25
1896, 2.2, 0.15, 0.29545454545455
1897, 2.2, 0.15, 0.34090909090909
1898, 2.2, 0.15, 0.38636363636364
1899, 2.2, 0.15, 0.43181818181818
1900, 2.2, 0.15, 0.47727272727273
1901, 1.2, 0.125, 0.5
1902, 1.2, 0.1375, 0.5
1903, 1.2, 0.1125, 0.5
1904, 2.2, 0.125, 0.5
1905, 2.2, 0.1375, 0.5
1906, 2.2, 0.1125, 0.5
1907, 1.2434782608696, 0.1, 0.5
1908, 1.2869565217391, 0.1, 0.5
1909, 1.3304347826087, 0.1, 0.5
1910, 1.3739130434783, 0.1, 0.5
1911, 1.4173913043478, 0.1, 0.5
1912, 1.4608695652174, 0.1, 0.5
1913, 1.504347826087, 0.1, 0.5
1914, 1.5478260869565, 0.1, 0.5
1915, 1.5913043478261, 0.1, 0.5
1916, 1.6347826086957, 0.1, 0.5
1917, 1.6782608695652, 0.1, 0.5
1918, 1.7217391304348, 0.1, 0.5
1919, 1.7652173913043, 0.1, 0.5
1920, 1.8086956521739, 0.1, 0.5
1921, 1.8521739130435, 0.1, 0.5
1922, 1.895652173913, 0.1, 0.5
1923, 1.9391304347826, 0.1, 0.5
1924, 1.9826086956522, 0.1, 0.5
1925, 2.0260869565217, 0.1, 0.5
1926, 2.0695652173913, 0.1, 0.5
1927, 2.1130434782609, 0.1, 0.5
1928, 2.1565217391304, 0.1, 0.5
1929, 1.2217391304348, 0.1, 0.5
1930, 1.2652173913043, 0.1, 0.5
1931, 1.3086956521739, 0.1, 0.5
1932, 1.3521739130435, 0.1, 0.5
1933, 1.395652173913, 0.1, 0.5
1934, 1.4391304347826, 0.1, 0.5
1935, 1.4826086956522, 0.1, 0.5
1936, 1.5260869565217, 0.1, 0.5
1937, 1.5695652173913, 0.1, 0.5
1938, 1.6130434782609, 0.1, 0.5
1939, 1.6565217391304, 0.1, 0.5
1940, 1.7, 0.1, 0.5
1941, 1.7434782608696, 0.1, 0.5
1942, 1.7869565217391, 0.1, 0.5
1943, 1.8304347826087, 0.1, 0.5
1944, 1.8739130434783, 0.1, 0.5
1945, 1.9173913043478, 0.1, 0.5
1946, 1.9608695652174, 0.1, 0.5
1947, 2.004347826087, 0.1, 0.5
1948, 2.0478260869565, 0.1, 0.5
1949, 2.0913043478261, 0.1, 0.5
1950, 2.1347826086957, 0.1, 0.5
1951, 2.1782608695652, 0.1, 0.5
1952, 1.2, 0.125, 0
1953, 1.2, 0.1375, 0
1954, 1.2, 0.1125, 0
1955, 2.2, 0.125, 0
1956, 2.2, 0.1375, 0
1957, 2.2, 0.1125, 0
1958, 1.2434782608696, 0.1, 0
1959, 1.2869565217391, 0.1, 0
1960, 1.3304347826087, 0.1, 0
1961, 1.3739130434783, 0.1, 0
1962, 1.4173913043478, 0.1, 0
1963, 1.4608695652174, 0.1, 0
1964, 1.504347826087, 0.1, 0
1965, 1.5478260869565, 0.1, 0
1966, 1.5913043478261, 0.1, 0
1967, 1.6347826086957, 0.1, 0
1968, 1.6782608695652, 0.1, 0
1969, 1.7217391304348, 0.1, 0
1970, 1.7652173913043, 0.1, 0
1971, 1.8086956521739, 0.1, 0
1972, 1.8521739130435, 0.1, 0
1973, 1.895652173913, 0.1, 0
1974, 1.9391304347826, 0.1, 0
1975, 1.9826086956522, 0.1, 0
1976, 2.0260869565217, 0.1, 0
1977, 2.0695652173913, 0.1, 0
1978, 2.1130434782609, 0.1, 0
1979, 2.1565217391304, 0.1, 0
1980, 1.2217391304348, 0.1, 0
1981, 1.2652173913043, 0.1, 0
1982, 1.3086956521739, 0.1, 0
1983, 1.3521739130435, 0.1, 0
1984, 1.395652173913, 0.1, 0
1985, 1.4391304347826, 0.1, 0
1986, 1.4826086956522, 0.1, 0
1987, 1.5260869565217, 0.1, 0
1988, 1.5695652173913, 0.1, 0
1989, 1.6130434782609, 0.1, 0
1990, 1.6565217391304, 0.1, 0
1991, 1.7, 0.1, 0
1992, 1.7434782608696, 0.1, 0
1993, 1.7869565217391, 0.1, 0
1994, 1.8304347826087, 0.1, 0
1995, 1.8739130434783, 0.1, 0
1996, 1.9173913043478, 0.1, 0
1997, 1.9608695652174, 0.1, 0
1998, 2.004347826087, 0.1, 0
1999, 2.0478260869565, 0.1, 0
2000, 2.0913043478261, 0.1, 0
2001, 2.1347826086957, 0.1, 0
2002, 2.1782608695652, 0.1, 0
2003, 1.2, 0.1, 0.045454545454545
2004, 1.2, 0.1, 0.090909090909091
2005, 1.2, 0.1, 0.13636363636364
2006, 1.2, 0.1, 0.18181818181818
2007, 1.2, 0.1, 0.22727272727273
2008, 1.2, 0.1, 0.27272727272727
2009, 1.2, 0.1, 0.31818181818182
2010, 1.2, 0.1, 0.36363636363636
2011, 1.2, 0.1, 0.40909090909091
2012, 1.2, 0.1, 0.45454545454545
2013, 1.2, 0.1, 0.022727272727273
2014, 1.2, 0.1, 0.068181818181818
2015, 1.2, 0.1, 0.11363636363636
2016, 1.2, 0.1, 0.15909090909091
2017, 1.2, 0.1, 0.20454545454545
2018, 1.2, 0.1, 0.25
2019, 1.2, 0.1, 0.29545454545455
2020, 1.2, 0.1, 0.34090909090909
2021, 1.2, 0.1, 0.38636363636364
2022, 1.2, 0.1, 0.43181818181818
2023, 1.2, 0.1, 0.47727272727273
2024, 2.2, 0.1, 0.045454545454545
2025, 2.2, 0.1, 0.090909090909091
2026, 2.2, 0.1, 0.13636363636364
2027, 2.2, 0.1, 0.18181818181818
2028, 2.2, 0.1, 0.22727272727273
2029, 2.2, 0.1, 0.27272727272727
2030, 2.2, 0.1, 0.31818181818182
2031, 2.2, 0.1, 0.36363636363636
2032, 2.2, 0.1, 0.40909090909091
2033, 2.2, 0.1, 0.45454545454545
2034, 2.2, 0.1, 0.022727272727273
2035, 2.2, 0.1, 0.068181818181818
2036, 2.2, 0.1, 0.11363636363636
2037, 2.2, 0.1, 0.15909090909091
2038, 2.2, 0.1, 0.20454545454545
2039, 2.2, 0.1, 0.25
2040, 2.2, 0.1, 0.29545454545455
2041, 2.2, 0.1, 0.34090909090909
2042, 2.2, 0.1, 0.38636363636364
2043, 2.2, 0.1, 0.43181818181818
2044, 2.2, 0.1, 0.47727272727273
2045, 2.2, 0.066666666666667, 0.5
2046, 2.2, 0.033333333333333, 0.5
2047, 2.2, 0.083333333333333, 0.5
2048, 2.2, 0.05, 0.5
2049, 2.2, 0.016666666666667, 0.5
2050, 2.2, 0.066666666666667, 0
2051, 2.2, 0.033333333333333, 0
2052, 2.2, 0.083333333333333, 0
2053, 2.2, 0.05, 0
2054, 2.2, 0.016666666666667, 0
2055, 2.2, -1.2490009027033e-16, 0.045454545454545
2056, 2.2, -1.2490009027033e-16, 0.090909090909091
2057, 2.2, -1.2490009027033e-16, 0.13636363636364
2058, 2.2, -1.2490009027033e-16, 0.18181818181818
2059, 2.2, -1.2490009027033e-16, 0.22727272727273
2060, 2.2, -1.2490009027033e-16, 0.27272727272727
2061, 2.2, -1.2490009027033e-16, 0.31818181818182
2062, 2.2, -1.2490009027033e-16, 0.36363636363636
2063, 2.2, -1.2490009027033e-16, 0.40909090909091
2064, 2.2, -1.2490009027033e-16, 0.45454545454545
2065, 2.2, -1.2490009027033e-16, 0.022727272727273
2066, 2.2, -1.2490009027033e-16, 0.068181818181818
2067, 2.2, -1.2490009027033e-16, 0.11363636363636
2068, 2.2, -1.2490009027033e-16, 0.15909090909091
2069, 2.2, -1.2490009027033e-16, 0.20454545454545
2070, 2.2, -1.2490009027033e-16, 0.25
2071, 2.2, -1.2490009027033e-16, 0.29545454545455
2072, 2.2, -1.2490009027033e-16, 0.34090909090909
2073, 2.2, -1.2490009027033e-16, 0.38636363636364
2074, 2.2, -1.2490009027033e-16, 0.43181818181818
2075, 2.2, -1.2490009027033e-16, 0.47727272727273
2076, 2.2333333333333, 0.1, 0.5
2077, 2.2666666666667, 0.1, 0.5
2078, 2.2166666666667, 0.1, 0.5
2079, 2.25, 0.1, 0.5
2080, 2.2833333333333, 0.1, 0.5
2081, 2.2333333333333, -1.2490009027033e-16, 0.5
2082, 2.2666666666667, -1.2490009027033e-16, 0.5
2083, 2.2166666666667, -1.2490009027033e-16, 0.5
2084, 2.25, -1.2490009027033e-16, 0.5
2085, 2.2833333333333, -1.2490009027033e-16, 0.5
2086, 2.3, 0.066666666666667, 0.5
2087, 2.3, 0.033333333333333, 0.5
2088, 2.3, 0.083333333333333, 0.5
2089, 2.3, 0.05, 0.5
2090, 2.3, 0.016666666666667, 0.5
2091, 2.2333333333333, 0.1, 0
2092, 2.2666666666667, 0.1, 0
2093, 2.2166666666667, 0.1, 0
2094, 2.25, 0.1, 0
2095, 2.2833333333333, 0.1, 0
2096, 2.2333333333333, -1.2490009027033e-16, 0
2097, 2.2666666666667, -1.2490009027033e-16, 0
2098, 2.2166666666667, -1.2490009027033e-16, 0
2099, 2.25, -1.2490009027033e-16, 0
2100, 2.2833333333333, -1.2490009027033e-16, 0
2101, 2.3, 0.066666666666667, 0
2102, 2.3, 0.033333333333333, 0
2103, 2.3, 0.083333333333333, 0
2104, 2.3, 0.05, 0
2105, 2.3, 0.016666666666667, 0
2106, 2.3, 0.1, 0.045454545454545
2107, 2.3, 0.1, 0.090909090909091
2108, 2.3, 0.1, 0.13636363636364
2109, 2.3, 0.1, 0.18181818181818
2110, 2.3, 0.1, 0.22727272727273
2111, 2.3, 0.1, 0.27272727272727
2112, 2.3, 0.1, 0.31818181818182
2113, 2.3, 0.1, 0.36363636363636
2114, 2.3, 0.1, 0.40909090909091
2115, 2.3, 0.1, 0.45454545454545
2116, 2.3, 0.1, 0.022727272727273
2117, 2.3, 0.1, 0.068181818181818
2118, 2.3, 0.1, 0.11363636363636
2119, 2.3, 0.1, 0.15909090909091
2120, 2.3, 0.1, 0.20454545454545
2121, 2.3, 0.1, 0.25
2122, 2.3, 0.1, 0.29545454545455
2123, 2.3, 0.1, 0.34090909090909
2124, 2.3, 0.1, 0.38636363636364
2125, 2.3, 0.1, 0.43181818181818
2126, 2.3, 0.1, 0.47727272727273
2127, 2.3, -1.2490009027033e-16, 0.045454545454545
2128, 2.3, -1.2490009027033e-16, 0.090909090909091
2129, 2.3, -1.2490009027033e-16, 0.13636363636364
2130, 2.3, -1.2490009027033e-16, 0.18181818181818
2131, 2.3, -1.2490009027033e-16, 0.22727272727273
2132, 2.3, -1.2490009027033e-16, 0.27272727272727
2133, 2.3, -1.2490009027033e-16, 0.31818181818182
2134, 2.3, -1.2490009027033e-16, 0.36363636363636
2135, 2.3, -1.2490009027033e-16, 0.40909090909091
2136, 2.3, -1.2490009027033e-16, 0.45454545454545
2137, 2.3, -1.2490009027033e-16, 0.022727272727273
2138, 2.3, -1.2490009027033e-16, 0.068181818181818
2139, 2.3, -1.2490009027033e-16, 0.11363636363636
2140, 2.3, -1.2490009027033e-16, 0.15909090909091
2141, 2.3, -1.2490009027033e-16, 0.20454545454545
2142, 2.3, -1.2490009027033e-16, 0.25
2143, 2.3, -1.2490009027033e-16, 0.29545454545455
2144, 2.3, -1.2490009027033e-16, 0.34090909090909
2145, 2.3, -1.2490009027033e-16, 0.38636363636364
2146, 2.3, -1.2490009027033e-16, 0.43181818181818
2147, 2.3, -1.2490009027033e-16, 0.47727272727273
2148, -0.033333333333333, 0, 0.5
2149, -0.066666666666667, 0, 0.5
2150, -0.016666666666667, 0, 0.5
2151, -0.05, 0, 0.5
2152, -0.083333333333333, 0, 0.5
2153, -0.033333333333333, 0, 0
2154, -0.066666666666667, 0, 0
2155, -0.016666666666667, 0, 0
2156, -0.05, 0, 0
2157, -0.083333333333333, 0, 0
2158, -0.1, 0, 0.045454545454545
2159, -0.1, 0, 0.090909090909091
2160, -0.1, 0, 0.13636363636364
2161, -0.1, 0, 0.18181818181818
2162, -0.1, 0, 0.22727272727273
2163, -0.1, 0, 0.27272727272727
2164, -0.1, 0, 0.31818181818182
2165, -0.1, 0, 0.36363636363636
2166, -0.1, 0, 0.40909090909091
2167, -0.1, 0, 0.45454545454545
2168, -0.1, 0, 0.022727272727273
2169, -0.1, 0, 0.068181818181818
2170, -0.1, 0, 0.11363636363636
2171, -0.1, 0, 0.15909090909091
2172, -0.1, 0, 0.20454545454545
2173, -0.1, 0, 0.25
2174, -0.1, 0, 0.29545454545455
2175, -0.1, 0, 0.34090909090909
2176, -0.1, 0, 0.38636363636364
2177, -0.1, 0, 0.43181818181818
2178, -0.1, 0, 0.47727272727273
2179, -0.033333333333333, 0.1, 0.5
2180, -0.066666666666667, 0.1, 0.5
2181, -0.016666666666667, 0.1, 0.5
2182, -0.05, 0.1, 0.5
2183, -0.083333333333333, 0.1, 0.5
2184, -0.1, 0.033333333333333, 0.5
2185, -0.1, 0.066666666666667, 0.5
2186, -0.1, 0.016666666666667, 0.5
2187, -0.1, 0.05, 0.5
2188, -0.1, 0.083333333333333, 0.5
2189, -0.033333333333333, 0.1, 0
2190, -0.066666666666667, 0.1, 0
2191, -0.016666666666667, 0.1, 0
2192, -0.05, 0.1, 0
2193, -0.083333333333333, 0.1, 0
2194, -0.1, 0.1, 0.045454545454545
2195, -0.1, 0.1, 0.090909090909091
2196, -0.1, 0.1, 0.13636363636364
2197, -0.1, 0.1, 0.18181818181818
2198, -0.1, 0.1, 0.22727272727273
2199, -0.1, 0.1, 0.27272727272727
2200, -0.1, 0.1, 0.31818181818182
2201, -0.1, 0.1, 0.36363636363636
2202, -0.1, 0.1, 0.40909090909091
2203, -0.1, 0.1, 0.45454545454545
2204, -0.1, 0.1, 0.022727272727273
2205, -0.1, 0.1, 0.068181818181818
2206, -0.1, 0.1, 0.11363636363636
2207, -0.1, 0.1, 0.15909090909091
2208, -0.1, 0.1, 0.20454545454545
2209, -0.1, 0.1, 0.25
2210, -0.1, 0.1, 0.29545454545455
2211, -0.1, 0.1, 0.34090909090909
2212, -0.1, 0.1, 0.38636363636364
2213, -0.1, 0.1, 0.43181818181818
2214, -0.1, 0.1, 0.47727272727273
2215, -0.1, 0.033333333333333, 0
2216, -0.1, 0.066666666666667, 0
2217, -0.1, 0.016666666666667, 0
2218, -0.1, 0.05, 0
2219, -0.1, 0.083333333333333, 0
2220, 1, 1.55, 0
2221, 1, 1.6, 0
2222, 1, 1.65, 0
2223, 1, 1.525, 0
2224, 1, 1.575, 0
2225, 1, 1.625, 0
2226, 1, 1.675, 0
2227, 0, 1.55, 0
2228, 0, 1.6, 0
2229, 0, 1.65, 0
2230, 0, 1.525, 0
2231, 0, 1.575, 0
2232, 0, 1.625, 0
2233, 0, 1.675, 0
2234, 0.043478260869565, 1.7, 0
2235, 0.08695652173913, 1.7, 0
2236, 0.1304347826087, 1.7, 0
2237, 0.17391304347826, 1.7, 0
2238, 0.21739130434783, 1.7, 0
2239, 0.26086956521739, 1.7, 0
2240, 0.30434782608696, 1.7, 0
2241, 0.34782608695652, 1.7, 0
2242, 0.39130434782609, 1.7, 0
2243, 0.43478260869565, 1.7, 0
2244, 0.47826086956522, 1.7, 0
2245, 0.52173913043478, 1.7, 0
2246, 0.56521739130435, 1.7, 0
2247, 0.60869565217391, 1.7, 0
2248, 0.65217391304348, 1.7, 0
2249, 0.69565217391304, 1.7, 0
2250, 0.73913043478261, 1.7, 0
2251, 0.78260869565217, 1.7, 0
2252, 0.82608695652174, 1.7, 0
2253, 0.8695652173913, 1.7, 0
2254, 0.91304347826087, 1.7, 0
2255, 0.95652173913043, 1.7, 0
2256, 0.021739130434783, 1.7, 0
2257, 0.065217391304348, 1.7, 0
2258, 0.10869565217391, 1.7, 0
2259, 0.15217391304348, 1.7, 0
2260, 0.19565217391304, 1.7, 0
2261, 0.23913043478261, 1.7, 0
2262, 0.28260869565217, 1.7, 0
2263, 0.32608695652174, 1.7, 0
2264, 0.3695652173913, 1.7, 0
2265, 0.41304347826087, 1.7, 0
2266, 0.45652173913043, 1.7, 0
2267, 0.5, 1.7, 0
2268, 0.54347826086957, 1.7, 0
2269, 0.58695652173913, 1.7, 0
2270, 0.6304347826087, 1.7, 0
2271, 0.67391304347826, 1.7, 0
2272, 0.71739130434783, 1.7, 0
2273, 0.76086956521739, 1.7, 0
2274, 0.80434782608696, 1.7, 0
2275, 0.84782608695652, 1.7, 0
2276, 0.89130434782609, 1.7, 0
2277, 0.93478260869565, 1.7, 0
2278, 0.97826086956522, 1.7, 0
2279, 1, 1.55, 0.5
2280, 1, 1.6, 0.5
2281, 1, 1.65, 0.5
2282, 1, 1.525, 0.5
2283, 1, 1.575, 0.5
2284, 1, 1.625, 0.5
2285, 1, 1.675, 0.5
2286, 1, 1.7, 0.045454545454545
2287, 1, 1.7, 0.090909090909091
2288, 1, 1.7, 0.13636363636364
2289, 1, 1.7, 0.18181818181818
2290, 1, 1.7, 0.22727272727273
2291, 1, 1.7, 0.27272727272727
2292, 1, 1.7, 0.31818181818182
2293, 1, 1.7, 0.36363636363636
2294, 1, 1.7, 0.40909090909091
2295, 1, 1.7, 0.45454545454545
2296, 1, 1.7, 0.022727272727273
2297, 1, 1.7, 0.068181818181818
2298, 1, 1.7, 0.11363636363636
2299, 1, 1.7, 0.15909090909091
2300, 1, 1.7, 0.20454545454545
2301, 1, 1.7, 0.25
2302, 1, 1.7, 0.29545454545455
2303, 1, 1.7, 0.34090909090909
2304, 1, 1.7, 0.38636363636364
2305, 1, 1.7, 0.43181818181818
2306, 1, 1.7, 0.47727272727273
2307, 0, 1.55, 0.5
2308, 0, 1.6, 0.5
2309, 0, 1.65, 0.5
2310, 0, 1.525, 0.5
2311, 0, 1.575, 0.5
2312, 0, 1.625, 0.5
2313, 0, 1.675, 0.5
2314, 0.043478260869565, 1.7, 0.5
2315, 0.08695652173913, 1.7, 0.5
2316, 0.1304347826087, 1.7, 0.5
2317, 0.17391304347826, 1.7, 0.5
2318, 0.21739130434783, 1.7, 0.5
2319, 0.26086956521739, 1.7, 0.5
2320, 0.30434782608696, 1.7, 0.5
2321, 0.34782608695652, 1.7, 0.5
2322, 0.39130434782609, 1.7, 0.5
2323, 0.43478260869565, 1.7, 0.5
2324, 0.47826086956522, 1.7, 0.5
2325, 0.52173913043478, 1.7, 0.5
2326, 0.56521739130435, 1.7, 0.5
2327, 0.60869565217391, 1.7, 0.5
2328, 0.65217391304348, 1.7, 0.5
2329, 0.69565217391304, 1.7, 0.5
2330, 0.73913043478261, 1.7, 0.5
2331, 0.78260869565217, 1.7, 0.5
2332, 0.82608695652174, 1.7, 0.5
2333, 0.8695652173913, 1.7, 0.5
2334, 0.91304347826087, 1.7, 0.5
2335, 0.95652173913043, 1.7, 0.5
2336, 0.021739130434783, 1.7, 0.5
2337, 0.065217391304348, 1.7, 0.5
2338, 0.10869565217391, 1.7, 0.5
2339, 0.15217391304348, 1.7, 0.5
2340, 0.19565217391304, 1.7, 0.5
2341, 0.23913043478261, 1.7, 0.5
2342, 0.28260869565217, 1.7, 0.5
2343, 0.32608695652174, 1.7, 0.5
2344, 0.3695652173913, 1.7, 0.5
2345, 0.41304347826087, 1.7, 0.5
2346, 0.45652173913043, 1.7, 0.5
2347, 0.5, 1.7, 0.5
2348, 0.54347826086957, 1.7, 0.5
2349, 0.58695652173913, 1.7, 0.5
2350, 0.6304347826087, 1.7, 0.5
2351, 0.67391304347826, 1.7, 0.5
2352, 0.71739130434783, 1.7, 0.5
2353, 0.76086956521739, 1.7, 0.5
2354, 0.80434782608696, 1.7, 0.5
2355, 0.84782608695652, 1.7, 0.5
2356, 0.89130434782609, 1.7, 0.5
2357, 0.93478260869565, 1.7, 0.5
2358, 0.97826086956522, 1.7, 0.5
2359, 0, 1.7, 0.045454545454545
2360, 0, 1.7, 0.090909090909091
2361, 0, 1.7, 0.13636363636364
2362, 0, 1.7, 0.18181818181818
2363, 0, 1.7, 0.22727272727273
2364, 0, 1.7, 0.27272727272727
2365, 0, 1.7, 0.31818181818182
2366, 0, 1.7, 0.36363636363636
2367, 0, 1.7, 0.40909090909091
2368, 0, 1.7, 0.45454545454545
2369, 0, 1.7, 0.022727272727273
2370, 0, 1.7, 0.068181818181818
2371, 0, 1.7, 0.11363636363636
2372, 0, 1.7, 0.15909090909091
2373, 0, 1.7, 0.20454545454545
2374, 0, 1.7, 0.25
2375, 0, 1.7, 0.29545454545455
2376, 0, 1.7, 0.34090909090909
2377, 0, 1.7, 0.38636363636364
2378, 0, 1.7, 0.43181818181818
2379, 0, 1.7, 0.47727272727273
2380, 1.2, 1.55, 0.5
2381, 1.2, 1.6, 0.5
2382, 1.2, 1.65, 0.5
2383, 1.2, 1.525, 0.5
2384, 1.2, 1.575, 0.5
2385, 1.2, 1.625, 0.5
2386, 1.2, 1.675, 0.5
2387, 1.04, 1.7, 0.5
2388, 1.08, 1.7, 0.5
2389, 1.12, 1.7, 0.5
2390, 1.16, 1.7, 0.5
2391, 1.02, 1.7, 0.5
2392, 1.06, 1.7, 0.5
2393, 1.1, 1.7, 0.5
2394, 1.14, 1.7, 0.5
2395, 1.18, 1.7, 0.5
2396, 1.2, 1.55, 0
2397, 1.2, 1.6, 0
2398, 1.2, 1.65, 0
2399, 1.2, 1.525, 0
2400, 1.2, 1.575, 0
2401, 1.2, 1.625, 0
2402, 1.2, 1.675, 0
2403, 1.04, 1.7, 0
2404, 1.08, 1.7, 0
2405, 1.12, 1.7, 0
2406, 1.16, 1.7, 0
2407, 1.02, 1.7, 0
2408, 1.06, 1.7, 0
2409, 1.1, 1.7, 0
2410, 1.14, 1.7, 0
2411, 1.18, 1.7, 0
2412, 1.2, 1.7, 0.045454545454545
2413, 1.2, 1.7, 0.090909090909091
2414, 1.2, 1.7, 0.13636363636364
2415, 1.2, 1.7, 0.18181818181818
2416, 1.2, 1.7, 0.22727272727273
2417, 1.2, 1.7, 0.27272727272727
2418, 1.2, 1.7, 0.31818181818182
2419, 1.2, 1.7, 0.36363636363636
2420, 1.2, 1.7, 0.40909090909091
2421, 1.2, 1.7, 0.45454545454545
2422, 1.2, 1.7, 0.022727272727273
2423, 1.2, 1.7, 0.068181818181818
2424, 1.2, 1.7, 0.11363636363636
2425, 1.2, 1.7, 0.15909090909091
2426, 1.2, 1.7, 0.20454545454545
2427, 1.2, 1.7, 0.25
2428, 1.2, 1.7, 0.29545454545455
2429, 1.2, 1.7, 0.34090909090909
2430, 1.2, 1.7, 0.38636363636364
2431, 1.2, 1.7, 0.43181818181818
2432, 1.2, 1.7, 0.47727272727273
2433, 2.2, 1.55, 0.5
2434, 2.2, 1.6, 0.5
2435, 2.2, 1.65, 0.5
2436, 2.2, 1.525, 0.5
2437, 2.2, 1.575, 0.5
2438, 2.2, 1.625, 0.5
2439, 2.2, 1.675, 0.5
2440, 1.2434782608696, 1.7, 0.5
2441, 1.2869565217391, 1.7, 0.5
2442, 1.3304347826087, 1.7, 0.5
2443, 1.3739130434783, 1.7, 0.5
2444, 1.4173913043478, 1.7, 0.5
2445, 1.4608695652174, 1.7, 0.5
2446, 1.504347826087, 1.7, 0.5
2447, 1.5478260869565, 1.7, 0.5
2448, 1.5913043478261, 1.7, 0.5
2449, 1.6347826086957, 1.7, 0.5
2450, 1.6782608695652, 1.7, 0.5
2451, 1.7217391304348, 1.7, 0.5
2452, 1.7652173913043, 1.7, 0.5
2453, 1.8086956521739, 1.7, 0.5
2454, 1.8521739130435, 1.7, 0.5
2455, 1.895652173913, 1.7, 0.5
2456, 1.9391304347826, 1.7, 0.5
2457, 1.9826086956522, 1.7, 0.5
2458, 2.0260869565217, 1.7, 0.5
2459, 2.0695652173913, 1.7, 0.5
2460, 2.1130434782609, 1.7, 0.5
2461, 2.1565217391304, 1.7, 0.5
2462, 1.2217391304348, 1.7, 0.5
2463, 1.2652173913043, 1.7, 0.5
2464, 1.3086956521739, 1.7, 0.5
2465, 1.3521739130435, 1.7, 0.5
2466, 1.395652173913, 1.7, 0.5
2467, 1.4391304347826, 1.7, 0.5
2468, 1.4826086956522, 1.7, 0.5
2469, 1.5260869565217, 1.7, 0.5
2470, 1.5695652173913, 1.7, 0.5
2471, 1.6130434782609, 1.7, 0.5
2472, 1.6565217391304, 1.7, 0.5
2473, 1.7, 1.7, 0.5
2474, 1.7434782608696, 1.7, 0.5
2475, 1.7869565217391, 1.7, 0.5
2476, 1.8304347826087, 1.7, 0.5
2477, 1.8739130434783, 1.7, 0.5
2478, 1.9173913043478, 1.7, 0.5
2479, 1.9608695652174, 1.7, 0.5
2480, 2.004347826087, 1.7, 0.5
2481, 2.0478260869565, 1.7, 0.5
2482, 2.0913043478261, 1.7, 0.5
2483, 2.1347826086957, 1.7, 0.5
2484, 2.1782608695652, 1.7, 0.5
2485, 2.2, 1.55, 0
2486, 2.2, 1.6, 0
2487, 2.2, 1.65, 0
2488, 2.2, 1.525, 0
2489, 2.2, 1.575, 0
2490, 2.2, 1.625, 0
2491, 2.2, 1.675, 0
2492, 1.2434782608696, 1.7, 0
2493, 1.2869565217391, 1.7, 0
2494, 1.3304347826087, 1.7, 0
2495, 1.3739130434783, 1.7, 0
2496, 1.4173913043478, 1.7, 0
2497, 1.4608695652174, 1.7, 0
2498, 1.504347826087, 1.7, 0
2499, 1.5478260869565, 1.7, 0
2500, 1.5913043478261, 1.7, 0
2501, 1.6347826086957, 1.7, 0
2502, 1.6782608695652, 1.7, 0
2503, 1.7217391304348, 1.7, 0
2504, 1.7652173913043, 1.7, 0
2505, 1.8086956521739, 1.7, 0
2506, 1.8521739130435, 1.7, 0
2507, 1.895652173913, 1.7, 0
2508, 1.9391304347826, 1.7, 0
2509, 1.9826086956522, 1.7, 0
2510, 2.0260869565217, 1.7, 0
2511, 2.0695652173913, 1.7, 0
2512, 2.1130434782609, 1.7, 0
2513, 2.1565217391304, 1.7, 0
2514, 1.2217391304348, 1.7, 0
2515, 1.2652173913043, 1.7, 0
2516, 1.3086956521739, 1.7, 0
2517, 1.3521739130435, 1.7, 0
2518, 1.395652173913, 1.7, 0
2519, 1.4391304347826, 1.7, 0
2520, 1.4826086956522, 1.7, 0
2521, 1.5260869565217, 1.7, 0
2522, 1.5695652173913, 1.7, 0
2523, 1.6130434782609, 1.7, 0
2524, 1.6565217391304, 1.7, 0
2525, 1.7, 1.7, 0
2526, 1.7434782608696, 1.7, 0
2527, 1.7869565217391, 1.7, 0
2528, 1.8304347826087, 1.7, 0
2529, 1.8739130434783, 1.7, 0
2530, 1.9173913043478, 1.7, 0
2531, 1.9608695652174, 1.7, 0
2532, 2.004347826087, 1.7, 0
2533, 2.0478260869565, 1.7, 0
2534, 2.0913043478261, 1.7, 0
2535, 2.1347826086957, 1.7, 0
2536, 2.1782608695652, 1.7, 0
2537, 2.2, 1.7, 0.045454545454545
2538, 2.2, 1.7, 0.090909090909091
2539, 2.2, 1.7, 0.13636363636364
2540, 2.2, 1.7, 0.18181818181818
2541, 2.2, 1.7, 0.22727272727273
2542, 2.2, 1.7, 0.27272727272727
2543, 2.2, 1.7, 0.31818181818182
2544, 2.2, 1.7, 0.36363636363636
2545, 2.2, 1.7, 0.40909090909091
2546, 2.2, 1.7, 0.45454545454545
2547, 2.2, 1.7, 0.022727272727273
2548, 2.2, 1.7, 0.068181818181818
2549, 2.2, 1.7, 0.11363636363636
2550, 2.2, 1.7, 0.15909090909091
2551, 2.2, 1.7, 0.20454545454545
2552, 2.2, 1.7, 0.25
2553, 2.2, 1.7, 0.29545454545455
2554, 2.2, 1.7, 0.34090909090909
2555, 2.2, 1.7, 0.38636363636364
2556, 2.2, 1.7, 0.43181818181818
2557, 2.2, 1.7, 0.47727272727273
2558, 1, -0.05, 0
2559, 1, -0.1, 0
2560, 1, -0.15, 0
2561, 1, -0.025, 0
2562, 1, -0.075, 0
2563, 1, -0.125, 0
2564, 1, -0.175, 0
2565, 0, -0.05, 0
2566, 0, -0.1, 0
2567, 0, -0.15, 0
2568, 0, -0.025, 0
2569, 0, -0.075, 0
2570, 0, -0.125, 0
2571, 0, -0.175, 0
2572, 0.043478260869565, -0.2, 0
2573, 0.08695652173913, -0.2, 0
2574, 0.1304347826087, -0.2, 0
2575, 0.17391304347826, -0.2, 0
2576, 0.21739130434783, -0.2, 0
2577, 0.26086956521739, -0.2, 0
2578, 0.30434782608696, -0.2, 0
2579, 0.34782608695652, -0.2, 0
2580, 0.39130434782609, -0.2, 0
2581, 0.43478260869565, -0.2, 0
2582, 0.47826086956522, -0.2, 0
2583, 0.52173913043478, -0.2, 0
2584, 0.56521739130435, -0.2, 0
2585, 0.60869565217391, -0.2, 0
2586, 0.65217391304348, -0.2, 0
2587, 0.69565217391304, -0.2, 0
2588, 0.73913043478261, -0.2, 0
2589, 0.78260869565217, -0.2, 0
2590, 0.82608695652174, -0.2, 0
2591, 0.8695652173913, -0.2, 0
2592, 0.91304347826087, -0.2, 0
2593, 0.95652173913043, -0.2, 0
2594, 0.021739130434783, -0.2, 0
2595, 0.065217391304348, -0.2, 0
2596, 0.10869565217391, -0.2, 0
2597, 0.15217391304348, -0.2, 0
2598, 0.19565217391304, -0.2, 0
2599, 0.23913043478261, -0.2, 0
2600, 0.28260869565217, -0.2, 0
2601, 0.32608695652174, -0.2, 0
2602, 0.3695652173913, -0.2, 0
2603, 0.41304347826087, -0.2, 0
2604, 0.45652173913043, -0.2, 0
2605, 0.5, -0.2, 0
2606, 0.54347826086957, -0.2, 0
2607, 0.58695652173913, -0.2, 0
2608, 0.6304347826087, -0.2, 0
2609, 0.67391304347826, -0.2, 0
2610, 0.71739130434783, -0.2, 0
2611, 0.76086956521739, -0.2, 0
2612, 0.80434782608696, -0.2, 0
2613, 0.84782608695652, -0.2, 0
2614, 0.89130434782609, -0.2, 0
2615, 0.93478260869565, -0.2, 0
2616, 0.97826086956522, -0.2, 0
2617, 1, -0.05, 0.5
2618, 1, -0.1, 0.5
2619, 1, -0.15, 0.5
2620, 1, -0.025, 0.5
2621, 1, -0.075, 0.5
2622, 1, -0.125, 0.5
2623, 1, -0.175, 0.5
2624, 1, -0.2, 0.045454545454545
2625, 1, -0.2, 0.090909090909091
2626, 1, -0.2, 0.13636363636364
2627, 1, -0.2, 0.18181818181818
2628, 1, -0.2, 0.22727272727273
2629, 1, -0.2, 0.27272727272727
2630, 1, -0.2, 0.31818181818182
2631, 1, -0.2, 0.36363636363636
2632, 1, -0.2, 0.40909090909091
2633, 1, -0.2, 0.45454545454545
2634, 1, -0.2, 0.022727272727273
2635, 1, -0.2, 0.068181818181818
2636, 1, -0.2, 0.11363636363636
2637, 1, -0.2, 0.15909090909091
2638, 1, -0.2, 0.20454545454545
2639, 1, -0.2, 0.25
2640, 1, -0.2, 0.29545454545455
2641, 1, -0.2, 0.34090909090909
2642, 1, -0.2, 0.38636363636364
2643, 1, -0.2, 0.43181818181818
2644, 1, -0.2, 0.47727272727273
2645, 0, -0.05, 0.5
2646, 0, -0.1, 0.5
2647, 0, -0.15, 0.5
2648, 0, -0.025, 0.5
2649, 0, -0.075, 0.5
2650, 0, -0.125, 0.5
2651, 0, -0.175, 0.5
2652, 0.043478260869565, -0.2, 0.5
2653, 0.08695652173913, -0.2, 0.5
2654, 0.1304347826087, -0.2, 0.5
2655, 0.17391304347826, -0.2, 0.5
2656, 0.21739130434783, -0.2, 0.5
2657, 0.26086956521739, -0.2, 0.5
2658, 0.30434782608696, -0.2, 0.5
2659, 0.34782608695652, -0.2, 0.5
2660, 0.39130434782609, -0.2, 0.5
2661, 0.43478260869565, -0.2, 0.5
2662, 0.47826086956522, -0.2, 0.5
2663, 0.52173913043478, -0.2, 0.5
2664, 0.56521739130435, -0.2, 0.5
2665, 0.60869565217391, -0.2, 0.5
2666, 0.65217391304348, -0.2, 0.5
2667, 0.69565217391304, -0.2, 0.5
2668, 0.73913043478261, -0.2, 0.5
2669, 0.78260869565217, -0.2, 0.5
2670, 0.82608695652174, -0.2, 0.5
2671, 0.8695652173913, -0.2, 0.5
2672, 0.91304347826087, -0.2, 0.5
2673, 0.95652173913043, -0.2, 0.5
2674, 0.021739130434783, -0.2, 0.5
2675, 0.065217391304348, -0.2, 0.5
2676, 0.10869565217391, -0.2, 0.5
2677, 0.15217391304348, -0.2, 0.5
2678, 0.19565217391304, -0.2, 0.5
2679, 0.23913043478261, -0.2, 0.5
2680, 0.28260869565217, -0.2, 0.5
2681, 0.32608695652174, -0.2, 0.5
2682, 0.3695652173913, -0.2, 0.5
2683, 0.41304347826087, -0.2, 0.5
2684, 0.45652173913043, -0.2, 0.5
2685, 0.5, -0.2, 0.5
2686, 0.54347826086957, -0.2, 0.5
2687, 0.58695652173913, -0.2, 0.5
2688, 0.6304347826087, -0.2, 0.5
2689, 0.67391304347826, -0.2, 0.5
2690, 0.71739130434783, -0.2, 0.5
2691, 0.76086956521739, -0.2, 0.5
2692, 0.80434782608696, -0.2, 0.5
2693, 0.84782608695652, -0.2, 0.5
2694, 0.89130434782609, -0.2, 0.5
2695, 0.93478260869565, -0.2, 0.5
2696, 0.97826086956522, -0.2, 0.5
2697, 0, -0.2, 0.045454545454545
2698, 0, -0.2, 0.090909090909091
2699, 0, -0.2, 0.13636363636364
2700, 0, -0.2, 0.18181818181818
2701, 0, -0.2, 0.22727272727273
2702, 0, -0.2, 0.27272727272727
2703, 0, -0.2, 0.31818181818182
2704, 0, -0.2, 0.36363636363636
2705, 0, -0.2, 0.40909090909091
2706, 0, -0.2, 0.45454545454545
2707, 0, -0.2, 0.022727272727273
2708, 0, -0.2, 0.068181818181818
2709, 0, -0.2, 0.11363636363636
2710, 0, -0.2, 0.15909090909091
2711, 0, -0.2, 0.20454545454545
2712, 0, -0.2, 0.25
2713, 0, -0.2, 0.29545454545455
2714, 0, -0.2, 0.34090909090909
2715, 0, -0.2, 0.38636363636364
2716, 0, -0.2, 0.43181818181818
2717, 0, -0.2, 0.47727272727273
2718, -0.1, -0.05, 0.5
2719, -0.1, -0.1, 0.5
2720, -0.1, -0.15, 0.5
2721, -0.1, -0.025, 0.5
2722, -0.1, -0.075, 0.5
2723, -0.1, -0.125, 0.5
2724, -0.1, -0.175, 0.5
2725, -0.033333333333333, -0.2, 0.5
2726, -0.066666666666667, -0.2, 0.5
2727, -0.016666666666667, -0.2, 0.5
2728, -0.05, -0.2, 0.5
2729, -0.083333333333333, -0.2, 0.5
2730, -0.1, -0.05, 0
2731, -0.1, -0.1, 0
2732, -0.1, -0.15, 0
2733, -0.1, -0.025, 0
2734, -0.1, -0.075, 0
2735, -0.1, -0.125, 0
2736, -0.1, -0.175, 0
2737, -0.033333333333333, -0.2, 0
2738, -0.066666666666667, -0.2, 0
2739, -0.016666666666667, -0.2, 0
2740, -0.05, -0.2, 0
2741, -0.083333333333333, -0.2, 0
2742, -0.1, -0.2, 0.045454545454545
2743, -0.1, -0.2, 0.090909090909091
2744, -0.1, -0.2, 0.13636363636364
2745, -0.1, -0.2, 0.18181818181818
2746, -0.1, -0.2, 0.22727272727273
2747, -0.1, -0.2, 0.27272727272727
2748, -0.1, -0.2, 0.31818181818182
2749, -0.1, -0.2, 0.36363636363636
2750, -0.1, -0.2, 0.40909090909091
2751, -0.1, -0.2, 0.45454545454545
2752, -0.1, -0.2, 0.022727272727273
2753, -0.1, -0.2, 0.068181818181818
2754, -0.1, -0.2, 0.11363636363636
2755, -0.1, -0.2, 0.15909090909091
2756, -0.1, -0.2, 0.20454545454545
2757, -0.1, -0.2, 0.25
2758, -0.1, -0.2, 0.29545454545455
2759, -0.1, -0.2, 0.34090909090909
2760, -0.1, -0.2, 0.38636363636364
2761, -0.1, -0.2, 0.43181818181818
2762, -0.1, -0.2, 0.47727272727273
2763, 2.2, -0.05, 0.5
2764, 2.2, -0.1, 0.5
2765, 2.2, -0.15, 0.5
2766, 2.2, -0.025, 0.5
2767, 2.2, -0.075, 0.5
2768, 2.2, -0.125, 0.5
2769, 2.2, -0.175, 0.5
2770, 2.2, -0.05, 0
2771, 2.2, -0.1, 0
2772, 2.2, -0.15, 0
2773, 2.2, -0.025, 0
2774, 2.2, -0.075, 0
2775, 2.2, -0.125, 0
2776, 2.2, -0.175, 0
2777, 2.2, -0.2, 0.045454545454545
2778, 2.2, -0.2, 0.090909090909091
2779, 2.2, -0.2, 0.13636363636364
2780, 2.2, -0.2, 0.18181818181818
2781, 2.2, -0.2, 0.22727272727273
2782, 2.2, -0.2, 0.27272727272727
2783, 2.2, -0.2, 0.31818181818182
2784, 2.2, -0.2, 0.36363636363636
2785, 2.2, -0.2, 0.40909090909091
2786, 2.2, -0.2, 0.45454545454545
2787, 2.2, -0.2, 0.022727272727273
2788, 2.2, -0.2, 0.068181818181818
2789, 2.2, -0.2, 0.11363636363636
2790, 2.2, -0.2, 0.15909090909091
2791, 2.2, -0.2, 0.20454545454545
2792, 2.2, -0.2, 0.25
2793, 2.2, -0.2, 0.29545454545455
2794, 2.2, -0.2, 0.34090909090909
2795, 2.2, -0.2, 0.38636363636364
2796, 2.2, -0.2, 0.43181818181818
2797, 2.2, -0.2, 0.47727272727273
2798, 2.3, -0.05, 0.5
2799, 2.3, -0.1, 0.5
2800, 2.3, -0.15, 0.5
2801, 2.3, -0.025, 0.5
2802, 2.3, -0.075, 0.5
2803, 2.3, -0.125, 0.5
2804, 2.3, -0.175, 0.5
2805, 2.2333333333333, -0.2, 0.5
2806, 2.2666666666667, -0.2, 0.5
2807, 2.2166666666667, -0.2, 0.5
2808, 2.25, -0.2, 0.5
2809, 2.2833333333333, -0.2, 0.5
2810, 2.3, -0.05, 0
2811, 2.3, -0.1, 0
2812, 2.3, -0.15, 0
2813, 2.3, -0.025, 0
2814, 2.3, -0.075, 0
2815, 2.3, -0.125, 0
2816, 2.3, -0.175, 0
2817, 2.2333333333333, -0.2, 0
2818, 2.2666666666667, -0.2, 0
2819, 2.2166666666667, -0.2, 0
2820, 2.25, -0.2, 0
2821, 2.2833333333333, -0.2, 0
2822, 2.3, -0.2, 0.045454545454545
2823, 2.3, -0.2, 0.090909090909091
2824, 2.3, -0.2, 0.13636363636364
2825, 2.3, -0.2, 0.18181818181818
2826, 2.3, -0.2, 0.22727272727273
2827, 2.3, -0.2, 0.27272727272727
2828, 2.3, -0.2, 0.31818181818182
2829, 2.3, -0.2, 0.36363636363636
2830, 2.3, -0.2, 0.40909090909091
2831, 2.3, -0.2, 0.45454545454545
2832, 2.3, -0.2, 0.022727272727273
2833, 2.3, -0.2, 0.068181818181818
2834, 2.3, -0.2, 0.11363636363636
2835, 2.3, -0.2, 0.15909090909091
2836, 2.3, -0.2, 0.20454545454545
2837, 2.3, -0.2, 0.25
2838, 2.3, -0.2, 0.29545454545455
2839, 2.3, -0.2, 0.34090909090909
2840, 2.3, -0.2, 0.38636363636364
2841, 2.3, -0.2, 0.43181818181818
2842, 2.3, -0.2, 0.47727272727273
2843, -0.033333333333333, 1.5, 0.5
2844, -0.066666666666667, 1.5, 0.5
2845, -0.016666666666667, 1.5, 0.5
2846, -0.05, 1.5, 0.5
2847, -0.083333333333333, 1.5, 0.5
2848, -0.033333333333333, 1.7, 0.5
2849, -0.066666666666667, 1.7, 0.5
2850, -0.016666666666667, 1.7, 0.5
2851, -0.05, 1.7, 0.5
2852, -0.083333333333333, 1.7, 0.5
2853, -0.1, 1.55, 0.5
2854, -0.1, 1.6, 0.5
2855, -0.1, 1.65, 0.5
2856, -0.1, 1.525, 0.5
2857, -0.1, 1.575, 0.5
2858, -0.1, 1.625, 0.5
2859, -0.1, 1.675, 0.5
2860, -0.033333333333333, 1.5, 0
2861, -0.066666666666667, 1.5, 0
2862, -0.016666666666667, 1.5, 0
2863, -0.05, 1.5, 0
2864, -0.083333333333333, 1.5, 0
2865, -0.033333333333333, 1.7, 0
2866, -0.066666666666667, 1.7, 0
2867, -0.016666666666667, 1.7, 0
2868, -0.05, 1.7, 0
2869, -0.083333333333333, 1.7, 0
2870, -0.1, 1.55, 0
2871, -0.1, 1.6, 0
2872, -0.1, 1.65, 0
2873, -0.1, 1.525, 0
2874, -0.1, 1.575, 0
2875, -0.1, 1.625, 0
2876, -0.1, 1.675, 0
2877, -0.1, 1.5, 0.045454545454545
2878, -0.1, 1.5, 0.090909090909091
2879, -0.1, 1.5, 0.13636363636364
2880, -0.1, 1.5, 0.18181818181818
2881, -0.1, 1.5, 0.22727272727273
2882, -0.1, 1.5, 0.27272727272727
2883, -0.1, 1.5, 0.31818181818182
2884, -0.1, 1.5, 0.36363636363636
2885, -0.1, 1.5, 0.40909090909091
2886, -0.1, 1.5, 0.45454545454545
2887, -0.1, 1.5, 0.022727272727273
2888, -0.1, 1.5, 0.068181818181818
2889, -0.1, 1.5, 0.11363636363636
2890, -0.1, 1.5, 0.15909090909091
2891, -0.1, 1.5, 0.20454545454545
2892, -0.1, 1.5, 0.25
2893, -0.1, 1.5, 0.29545454545455
2894, -0.1, 1.5, 0.34090909090909
2895, -0.1, 1.5, 0.38636363636364
2896, -0.1, 1.5, 0.43181818181818
2897, -0.1, 1.5, 0.47727272727273
2898, -0.1, 1.7, 0.045454545454545
2899, -0.1, 1.7, 0.090909090909091
2900, -0.1, 1.7, 0.13636363636364
2901, -0.1, 1.7, 0.18181818181818
2902, -0.1, 1.7, 0.22727272727273
2903, -0.1, 1.7, 0.27272727272727
2904, -0.1, 1.7, 0.31818181818182
2905, -0.1, 1.7, 0.36363636363636
2906, -0.1, 1.7, 0.40909090909091
2907, -0.1, 1.7, 0.45454545454545
2908, -0.1, 1.7, 0.022727272727273
2909, -0.1, 1.7, 0.068181818181818
2910, -0.1, 1.7, 0.11363636363636
2911, -0.1, 1.7, 0.15909090909091
2912, -0.1, 1.7, 0.20454545454545
2913, -0.1, 1.7, 0.25
2914, -0.1, 1.7, 0.29545454545455
2915, -0.1, 1.7, 0.34090909090909
2916, -0.1, 1.7, 0.38636363636364
2917, -0.1, 1.7, 0.43181818181818
2918, -0.1, 1.7, 0.47727272727273
2919, -0.033333333333333, 1.4, 0.5
2920, -0.066666666666667, 1.4, 0.5
2921, -0.016666666666667, 1.4, 0.5
2922, -0.05, 1.4, 0.5
2923, -0.083333333333333, 1.4, 0.5
2924, -0.1, 1.4333333333333, 0.5
2925, -0.1, 1.4666666666667, 0.5
2926, -0.1, 1.4166666666667, 0.5
2927, -0.1, 1.45, 0.5
2928, -0.1, 1.4833333333333, 0.5
2929, -0.033333333333333, 1.4, 0
2930, -0.066666666666667, 1.4, 0
2931, -0.016666666666667, 1.4, 0
2932, -0.05, 1.4, 0
2933, -0.083333333333333, 1.4, 0
2934, -0.1, 1.4333333333333, 0
2935, -0.1, 1.4666666666667, 0
2936, -0.1, 1.4166666666667, 0
2937, -0.1, 1.45, 0
2938, -0.1, 1.4833333333333, 0
2939, -0.1, 1.4, 0.045454545454545
2940, -0.1, 1.4, 0.090909090909091
2941, -0.1, 1.4, 0.13636363636364
2942, -0.1, 1.4, 0.18181818181818
2943, -0.1, 1.4, 0.22727272727273
2944, -0.1, 1.4, 0.27272727272727
2945, -0.1, 1.4, 0.31818181818182
2946, -0.1, 1.4, 0.36363636363636
2947, -0.1, 1.4, 0.40909090909091
2948, -0.1, 1.4, 0.45454545454545
2949, -0.1, 1.4, 0.022727272727273
2950, -0.1, 1.4, 0.068181818181818
2951, -0.1, 1.4, 0.11363636363636
2952, -0.1, 1.4, 0.15909090909091
2953, -0.1, 1.4, 0.20454545454545
2954, -0.1, 1.4, 0.25
2955, -0.1, 1.4, 0.29545454545455
2956, -0.1, 1.4, 0.34090909090909
2957, -0.1, 1.4, 0.38636363636364
2958, -0.1, 1.4, 0.43181818181818
2959, -0.1, 1.4, 0.47727272727273
2960, 2.2333333333333, 1.5, 0.5
2961, 2.2666666666667, 1.5, 0.5
2962, 2.2166666666667, 1.5, 0.5
2963, 2.25, 1.5, 0.5
2964, 2.2833333333333, 1.5, 0.5
2965, 2.2333333333333, 1.7, 0.5
2966, 2.2666666666667, 1.7, 0.5
2967, 2.2166666666667, 1.7, 0.5
2968, 2.25, 1.7, 0.5
2969, 2.2833333333333, 1.7, 0.5
2970, 2.3, 1.55, 0.5
2971, 2.3, 1.6, 0.5
2972, 2.3, 1.65, 0.5
2973, 2.3, 1.525, 0.5
2974, 2.3, 1.575, 0.5
2975, 2.3, 1.625, 0.5
2976, 2.3, 1.675, 0.5
2977, 2.2333333333333, 1.5, 0
2978, 2.2666666666667, 1.5, 0
2979, 2.2166666666667, 1.5, 0
2980, 2.25, 1.5, 0
2981, 2.2833333333333, 1.5, 0
2982, 2.2333333333333, 1.7, 0
2983, 2.2666666666667, 1.7, 0
2984, 2.2166666666667, 1.7, 0
2985, 2.25, 1.7, 0
2986, 2.2833333333333, 1.7, 0
2987, 2.3, 1.55, 0
2988, 2.3, 1.6, 0
2989, 2.3, 1.65, 0
2990, 2.3, 1.525, 0
2991, 2.3, 1.575, 0
2992, 2.3, 1.625, 0
2993, 2.3, 1.675, 0
2994, 2.3, 1.5, 0.045454545454545
2995, 2.3, 1.5, 0.090909090909091
2996, 2.3, 1.5, 0.13636363636364
2997, 2.3, 1.5, 0.18181818181818
2998, 2.3, 1.5, 0.22727272727273
2999, 2.3, 1.5, 0.27272727272727
3000, 2.3, 1.5, 0.31818181818182
3001, 2.3, 1.5, 0.36363636363636
3002, 2.3, 1.5, 0.40909090909091
3003, 2.3, 1.5, 0.45454545454545
3004, 2.3, 1.5, 0.022727272727273
3005, 2.3, 1.5, 0.068181818181818
3006, 2.3, 1.5, 0.11363636363636
3007, 2.3, 1.5, 0.15909090909091
3008, 2.3, 1.5, 0.20454545454545
3009, 2.3, 1.5, 0.25
3010, 2.3, 1.5, 0.29545454545455
3011, 2.3, 1.5, 0.34090909090909
3012, 2.3, 1.5, 0.38636363636364
3013, 2.3, 1.5, 0.43181818181818
3014, 2.3, 1.5, 0.47727272727273
3015, 2.3, 1.7, 0.045454545454545
3016, 2.3, 1.7, 0.090909090909091
3017, 2.3, 1.7, 0.13636363636364
3018, 2.3, 1.7, 0.18181818181818
3019, 2.3, 1.7, 0.22727272727273
3020, 2.3, 1.7, 0.27272727272727
3021, 2.3, 1.7, 0.31818181818182
3022, 2.3, 1.7, 0.36363636363636
3023, 2.3, 1.7, 0.40909090909091
3024, 2.3, 1.7, 0.45454545454545
3025, 2.3, 1.7, 0.022727272727273
3026, 2.3, 1.7, 0.068181818181818
3027, 2.3, 1.7, 0.11363636363636
3028, 2.3, 1.7, 0.15909090909091
3029, 2.3, 1.7, 0.20454545454545
3030, 2.3, 1.7, 0.25
3031, 2.3, 1.7, 0.29545454545455
3032, 2.3, 1.7, 0.34090909090909
3033, 2.3, 1.7, 0.38636363636364
3034, 2.3, 1.7, 0.43181818181818
3035, 2.3, 1.7, 0.47727272727273
3036, 2.2333333333333, 1.4, 0.5
3037, 2.2666666666667, 1.4, 0.5
3038, 2.2166666666667, 1.4, 0.5
3039, 2.25, 1.4, 0.5
3040, 2.2833333333333, 1.4, 0.5
3041, 2.3, 1.4333333333333, 0.5
3042, 2.3, 1.4666666666667, 0.5
3043, 2.3, 1.4166666666667, 0.5
3044, 2.3, 1.45, 0.5
3045, 2.3, 1.4833333333333, 0.5
3046, 2.2333333333333, 1.4, 0
3047, 2.2666666666667, 1.4, 0
3048, 2.2166666666667, 1.4, 0
3049, 2.25, 1.4, 0
3050, 2.2833333333333, 1.4, 0
3051, 2.3, 1.4333333333333, 0
3052, 2.3, 1.4666666666667, 0
3053, 2.3, 1.4166666666667, 0
3054, 2.3, 1.45, 0
3055, 2.3, 1.4833333333333, 0
3056, 2.3, 1.4, 0.045454545454545
3057, 2.3, 1.4, 0.090909090909091
3058, 2.3, 1.4, 0.13636363636364
3059, 2.3, 1.4, 0.18181818181818
3060, 2.3, 1.4, 0.22727272727273
3061, 2.3, 1.4, 0.27272727272727
3062, 2.3, 1.4, 0.31818181818182
3063, 2.3, 1.4, 0.36363636363636
3064, 2.3, 1.4, 0.40909090909091
3065, 2.3, 1.4, 0.45454545454545
3066, 2.3, 1.4, 0.022727272727273
3067, 2.3, 1.4, 0.068181818181818
3068, 2.3, 1.4, 0.11363636363636
3069, 2.3, 1.4, 0.15909090909091
3070, 2.3, 1.4, 0.20454545454545
3071, 2.3, 1.4, 0.25
3072, 2.3, 1.4, 0.29545454545455
3073, 2.3, 1.4, 0.34090909090909
3074, 2.3, 1.4, 0.38636363636364
3075, 2.3, 1.4, 0.43181818181818
3076, 2.3, 1.4, 0.47727272727273
3077, 1.2, 0.066666666666667, 0.5
3078, 1.2, 0.033333333333333, 0.5
3079, 1.2, 0.083333333333333, 0.5
3080, 1.2, 0.05, 0.5
3081, 1.2, 0.016666666666667, 0.5
3082, 1.2434782608696, 0, 0.5
3083, 1.2869565217391, 0, 0.5
3084, 1.3304347826087, 0, 0.5
3085, 1.3739130434783, 0, 0.5
3086, 1.4173913043478, 0, 0.5
3087, 1.4608695652174, 0, 0.5
3088, 1.504347826087, 0, 0.5
3089, 1.5478260869565, 0, 0.5
3090, 1.5913043478261, 0, 0.5
3091, 1.6347826086957, 0, 0.5
3092, 1.6782608695652, 0, 0.5
3093, 1.7217391304348, 0, 0.5
3094, 1.7652173913043, 0, 0.5
3095, 1.8086956521739, 0, 0.5
3096, 1.8521739130435, 0, 0.5
3097, 1.895652173913, 0, 0.5
3098, 1.9391304347826, 0, 0.5
3099, 1.9826086956522, 0, 0.5
3100, 2.0260869565217, 0, 0.5
3101, 2.0695652173913, 0, 0.5
3102, 2.1130434782609, 0, 0.5
3103, 2.1565217391304, 0, 0.5
3104, 1.2217391304348, 0, 0.5
3105, 1.2652173913043, 0, 0.5
3106, 1.3086956521739, 0, 0.5
3107, 1.3521739130435, 0, 0.5
3108, 1.395652173913, 0, 0.5
3109, 1.4391304347826, 0, 0.5
3110, 1.4826086956522, 0, 0.5
3111, 1.5260869565217, 0, 0.5
3112, 1.5695652173913, 0, 0.5
3113, 1.6130434782609, 0, 0.5
3114, 1.6565217391304, 0, 0.5
3115, 1.7, 0, 0.5
3116, 1.7434782608696, 0, 0.5
3117, 1.7869565217391, 0, 0.5
3118, 1.8304347826087, 0, 0.5
3119, 1.8739130434783, 0, 0.5
3120, 1.9173913043478, 0, 0.5
3121, 1.9608695652174, 0, 0.5
3122, 2.004347826087, 0, 0.5
3123, 2.0478260869565, 0, 0.5
3124, 2.0913043478261, 0, 0.5
3125, 2.1347826086957, 0, 0.5
3126, 2.1782608695652, 0, 0.5
3127, 1.2, 0.066666666666667, 0
3128, 1.2, 0.033333333333333, 0
3129, 1.2, 0.083333333333333, 0
3130, 1.2, 0.05, 0
3131, 1.2, 0.016666666666667, 0
3132, 1.2434782608696, 0, 0
3133, 1.2869565217391, 0, 0
3134, 1.3304347826087, 0, 0
3135, 1.3739130434783, 0, 0
3136, 1.4173913043478, 0, 0
3137, 1.4608695652174, 0, 0
3138, 1.504347826087, 0, 0
3139, 1.5478260869565, 0, 0
3140, 1.5913043478261, 0, 0
3141, 1.6347826086957, 0, 0
3142, 1.6782608695652, 0, 0
3143, 1.7217391304348, 0, 0
3144, 1.7652173913043, 0, 0
3145, 1.8086956521739, 0, 0
3146, 1.8521739130435, 0, 0
3147, 1.895652173913, 0, 0
3148, 1.9391304347826, 0, 0
3149, 1.9826086956522, 0, 0
3150, 2.0260869565217, 0, 0
3151, 2.0695652173913, 0, 0
3152, 2.1130434782609, 0, 0
3153, 2.1565217391304, 0, 0
3154, 1.2217391304348, 0, 0
3155, 1.2652173913043, 0, 0
3156, 1.3086956521739, 0, 0
3157, 1.3521739130435, 0, 0
3158, 1.395652173913, 0, 0
3159, 1.4391304347826, 0, 0
3160, 1.4826086956522, 0, 0
3161, 1.5260869565217, 0, 0
3162, 1.5695652173913, 0, 0
3163, 1.6130434782609, 0, 0
3164, 1.6565217391304, 0, 0
3165, 1.7, 0, 0
3166, 1.7434782608696, 0, 0
3167, 1.7869565217391, 0, 0
3168, 1.8304347826087, 0, 0
3169, 1.8739130434783, 0, 0
3170, 1.9173913043478, 0, 0
3171, 1.9608695652174, 0, 0
3172, 2.004347826087, 0, 0
3173, 2.0478260869565, 0, 0
3174, 2.0913043478261, 0, 0
3175, 2.1347826086957, 0, 0
3176, 2.1782608695652, 0, 0
3177, 1.2, -1.2490009027033e-16, 0.045454545454545
3178, 1.2, -1.2490009027033e-16, 0.090909090909091
3179, 1.2, -1.2490009027033e-16, 0.13636363636364
3180, 1.2, -1.2490009027033e-16, 0.18181818181818
3181, 1.2, -1.2490009027033e-16, 0.22727272727273
3182, 1.2, -1.2490009027033e-16, 0.27272727272727
3183, 1.2, -1.2490009027033e-16, 0.31818181818182
3184, 1.2, -1.2490009027033e-16, 0.36363636363636
3185, 1.2, -1.2490009027033e-16, 0.40909090909091
3186, 1.2, -1.2490009027033e-16, 0.45454545454545
3187, 1.2, -1.2490009027033e-16, 0.022727272727273
3188, 1.2, -1.2490009027033e-16, 0.068181818181818
3189, 1.2, -1.2490009027033e-16, 0.11363636363636
3190, 1.2, -1.2490009027033e-16, 0.15909090909091
3191, 1.2, -1.2490009027033e-16, 0.20454545454545
3192, 1.2, -1.2490009027033e-16, 0.25
3193, 1.2, -1.2490009027033e-16, 0.29545454545455
3194, 1.2, -1.2490009027033e-16, 0.34090909090909
3195, 1.2, -1.2490009027033e-16, 0.38636363636364
3196, 1.2, -1.2490009027033e-16, 0.43181818181818
3197, 1.2, -1.2490009027033e-16, 0.47727272727273
3198, 1.2, -0.05, 0.5
3199, 1.2, -0.1, 0.5
3200, 1.2, -0.15, 0.5
3201, 1.2, -0.025, 0.5
3202, 1.2, -0.075, 0.5
3203, 1.2, -0.125, 0.5
3204, 1.2, -0.175, 0.5
3205, 1.2434782608696, -0.2, 0.5
3206, 1.2869565217391, -0.2, 0.5
3207, 1.3304347826087, -0.2, 0.5
3208, 1.3739130434783, -0.2, 0.5
3209, 1.4173913043478, -0.2, 0.5
3210, 1.4608695652174, -0.2, 0.5
3211, 1.504347826087, -0.2, 0.5
3212, 1.5478260869565, -0.2, 0.5
3213, 1.5913043478261, -0.2, 0.5
3214, 1.6347826086957, -0.2, 0.5
3215, 1.6782608695652, -0.2, 0.5
3216, 1.7217391304348, -0.2, 0.5
3217, 1.7652173913043, -0.2, 0.5
3218, 1.8086956521739, -0.2, 0.5
3219, 1.8521739130435, -0.2, 0.5
3220, 1.895652173913, -0.2, 0.5
3221, 1.9391304347826, -0.2, 0.5
3222, 1.9826086956522, -0.2, 0.5
3223, 2.0260869565217, -0.2, 0.5
3224, 2.0695652173913, -0.2, 0.5
3225, 2.1130434782609, -0.2, 0.5
3226, 2.1565217391304, -0.2, 0.5
3227, 1.2217391304348, -0.2, 0.5
3228, 1.2652173913043, -0.2, 0.5
3229, 1.3086956521739, -0.2, 0.5
3230, 1.3521739130435, -0.2, 0.5
3231, 1.395652173913, -0.2, 0.5
3232, 1.4391304347826, -0.2, 0.5
3233, 1.4826086956522, -0.2, 0.5
3234, 1.5260869565217, -0.2, 0.5
3235, 1.5695652173913, -0.2, 0.5
3236, 1.6130434782609, -0.2, 0.5
3237, 1.6565217391304, -0.2, 0.5
3238, 1.7, -0.2, 0.5
3239, 1.7434782608696, -0.2, 0.5
3240, 1.7869565217391, -0.2, 0.5
3241, 1.8304347826087, -0.2, 0.5
3242, 1.8739130434783, -0.2, 0.5
3243, 1.9173913043478, -0.2, 0.5
3244, 1.9608695652174, -0.2, 0.5
3245, 2.004347826087, -0.2, 0.5
3246, 2.0478260869565, -0.2, 0.5
3247, 2.0913043478261, -0.2, 0.5
3248, 2.1347826086957, -0.2, 0.5
3249, 2.1782608695652, -0.2, 0.5
3250, 1.2, -0.05, 0
3251, 1.2, -0.1, 0
3252, 1.2, -0.15, 0
3253, 1.2, -0.025, 0
3254, 1.2, -0.075, 0
3255, 1.2, -0.125, 0
3256, 1.2, -0.175, 0
3257, 1.2434782608696, -0.2, 0
3258, 1.2869565217391, -0.2, 0
3259, 1.3304347826087, -0.2, 0
3260, 1.3739130434783, -0.2, 0
3261, 1.4173913043478, -0.2, 0
3262, 1.4608695652174, -0.2, 0
3263, 1.504347826087, -0.2, 0
3264, 1.5478260869565, -0.2, 0
3265, 1.5913043478261, -0.2, 0
3266, 1.6347826086957, -0.2, 0
3267, 1.6782608695652, -0.2, 0
3268, 1.7217391304348, -0.2, 0
3269, 1.7652173913043, -0.2, 0
3270, 1.8086956521739, -0.2, 0
3271, 1.8521739130435, -0.2, 0
3272, 1.895652173913, -0.2, 0
3273, 1.9391304347826, -0.2, 0
3274, 1.9826086956522, -0.2, 0
3275, 2.0260869565217, -0.2, 0
3276, 2.0695652173913, -0.2, 0
3277, 2.1130434782609, -0.2, 0
3278, 2.1565217391304, -0.2, 0
3279, 1.2217391304348, -0.2, 0
3280, 1.2652173913043, -0.2, 0
3281, 1.3086956521739, -0.2, 0
3282, 1.3521739130435, -0.2, 0
3283, 1.395652173913, -0.2, 0
3284, 1.4391304347826, -0.2, 0
3285, 1.4826086956522, -0.2, 0
3286, 1.5260869565217, -0.2, 0
3287, 1.5695652173913, -0.2, 0
3288, 1.6130434782609, -0.2, 0
3289, 1.6565217391304, -0.2, 0
3290, 1.7, -0.2, 0
3291, 1.7434782608696, -0.2, 0
3292, 1.7869565217391, -0.2, 0
3293, 1.8304347826087, -0.2, 0
3294, 1.8739130434783, -0.2, 0
3295, 1.9173913043478, -0.2, 0
3296, 1.9608695652174, -0.2, 0
3297, 2.004347826087, -0.2, 0
3298, 2.0478260869565, -0.2, 0
3299, 2.0913043478261, -0.2, 0
3300, 2.1347826086957, -0.2, 0
3301, 2.1782608695652, -0.2, 0
3302, 1.2, -0.2, 0.045454545454545
3303, 1.2, -0.2, 0.090909090909091
3304, 1.2, -0.2, 0.13636363636364
3305, 1.2, -0.2, 0.18181818181818
3306, 1.2, -0.2, 0.22727272727273
3307, 1.2, -0.2, 0.27272727272727
3308, 1.2, -0.2, 0.31818181818182
3309, 1.2, -0.2, 0.36363636363636
3310, 1.2, -0.2, 0.40909090909091
3311, 1.2, -0.2, 0.45454545454545
3312, 1.2, -0.2, 0.022727272727273
