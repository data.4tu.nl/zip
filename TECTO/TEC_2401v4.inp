18597, 65147, 65137, 64917, 64927, 65148, 65138, 64918, 64928, 77517, 77487, 76825, 77518, 77520, 77490, 76828, 
77521, 77519, 77488, 76796, 76827
18598, 65148, 65138, 64918, 64928, 65149, 65139, 64919, 64929, 77520, 77490, 76828, 77521, 77523, 77493, 76831, 
77524, 77522, 77491, 76799, 76830
18599, 65149, 65139, 64919, 64929, 65150, 65140, 64920, 64930, 77523, 77493, 76831, 77524, 77526, 77496, 76834, 
77527, 77525, 77494, 76802, 76833
18600, 65150, 65140, 64920, 64930, 65151, 65141, 64921, 64931, 77526, 77496, 76834, 77527, 77529, 77499, 76837, 
77530, 77528, 77497, 76805, 76836
18601, 65151, 65141, 64921, 64931, 65152, 65142, 64922, 64932, 77529, 77499, 76837, 77530, 77532, 77502, 76840, 
77533, 77531, 77500, 76808, 76839
18602, 65152, 65142, 64922, 64932, 18286, 18285, 18263, 18264, 77532, 77502, 76840, 77533, 19137, 19134, 19092, 
19136, 77534, 77503, 76811, 76842
18603, 1649, 16790, 16768, 1648, 20273, 65143, 64923, 20263, 17642, 17641, 17597, 1671, 77535, 77506, 76843, 
20659, 20658, 77504, 76812, 20637
18604, 20273, 65143, 64923, 20263, 20274, 65144, 64924, 20264, 77535, 77506, 76843, 20659, 77536, 77509, 76844, 
20661, 20660, 77507, 76815, 20639
18605, 20274, 65144, 64924, 20264, 20275, 65145, 64925, 20265, 77536, 77509, 76844, 20661, 77537, 77512, 76845, 
20663, 20662, 77510, 76818, 20641
18606, 20275, 65145, 64925, 20265, 20276, 65146, 64926, 20266, 77537, 77512, 76845, 20663, 77538, 77515, 76846, 
20665, 20664, 77513, 76821, 20643
18607, 20276, 65146, 64926, 20266, 20277, 65147, 64927, 20267, 77538, 77515, 76846, 20665, 77539, 77518, 76847, 
20667, 20666, 77516, 76824, 20645
18608, 20277, 65147, 64927, 20267, 20278, 65148, 64928, 20268, 77539, 77518, 76847, 20667, 77540, 77521, 76848, 
20669, 20668, 77519, 76827, 20647
18609, 20278, 65148, 64928, 20268, 20279, 65149, 64929, 20269, 77540, 77521, 76848, 20669, 77541, 77524, 76849, 
20671, 20670, 77522, 76830, 20649
18610, 20279, 65149, 64929, 20269, 20280, 65150, 64930, 20270, 77541, 77524, 76849, 20671, 77542, 77527, 76850, 
20673, 20672, 77525, 76833, 20651
18611, 20280, 65150, 64930, 20270, 20281, 65151, 64931, 20271, 77542, 77527, 76850, 20673, 77543, 77530, 76851, 
20675, 20674, 77528, 76836, 20653
18612, 20281, 65151, 64931, 20271, 20282, 65152, 64932, 20272, 77543, 77530, 76851, 20675, 77544, 77533, 76852, 
20677, 20676, 77531, 76839, 20655
18613, 20282, 65152, 64932, 20272, 1784, 18286, 18264, 1783, 77544, 77533, 76852, 20677, 19138, 19136, 19093, 
1806, 20678, 77534, 76842, 20657
18614, 16791, 1605, 1604, 16769, 65153, 19591, 19581, 64933, 17643, 1627, 17598, 17644, 77546, 19987, 76854, 
77547, 77545, 19988, 19967, 76853
18615, 65153, 19591, 19581, 64933, 65154, 19592, 19582, 64934, 77546, 19987, 76854, 77547, 77549, 19989, 76857, 
77550, 77548, 19990, 19969, 76856
18616, 65154, 19592, 19582, 64934, 65155, 19593, 19583, 64935, 77549, 19989, 76857, 77550, 77552, 19991, 76860, 
77553, 77551, 19992, 19971, 76859
18617, 65155, 19593, 19583, 64935, 65156, 19594, 19584, 64936, 77552, 19991, 76860, 77553, 77555, 19993, 76863, 
77556, 77554, 19994, 19973, 76862
18618, 65156, 19594, 19584, 64936, 65157, 19595, 19585, 64937, 77555, 19993, 76863, 77556, 77558, 19995, 76866, 
77559, 77557, 19996, 19975, 76865
18619, 65157, 19595, 19585, 64937, 65158, 19596, 19586, 64938, 77558, 19995, 76866, 77559, 77561, 19997, 76869, 
77562, 77560, 19998, 19977, 76868
18620, 65158, 19596, 19586, 64938, 65159, 19597, 19587, 64939, 77561, 19997, 76869, 77562, 77564, 19999, 76872, 
77565, 77563, 20000, 19979, 76871
18621, 65159, 19597, 19587, 64939, 65160, 19598, 19588, 64940, 77564, 19999, 76872, 77565, 77567, 20001, 76875, 
77568, 77566, 20002, 19981, 76874
18622, 65160, 19598, 19588, 64940, 65161, 19599, 19589, 64941, 77567, 20001, 76875, 77568, 77570, 20003, 76878, 
77571, 77569, 20004, 19983, 76877
18623, 65161, 19599, 19589, 64941, 65162, 19600, 19590, 64942, 77570, 20003, 76878, 77571, 77573, 20005, 76881, 
77574, 77572, 20006, 19985, 76880
18624, 65162, 19600, 19590, 64942, 18287, 1740, 1739, 18265, 77573, 20005, 76881, 77574, 19140, 1762, 19095, 
19139, 77575, 20007, 19986, 76883
18625, 16792, 16791, 16769, 16770, 65163, 65153, 64933, 64943, 17645, 17644, 17600, 17646, 77577, 77547, 76885, 
77578, 77576, 77545, 76853, 76884
18626, 65163, 65153, 64933, 64943, 65164, 65154, 64934, 64944, 77577, 77547, 76885, 77578, 77580, 77550, 76888, 
77581, 77579, 77548, 76856, 76887
18627, 65164, 65154, 64934, 64944, 65165, 65155, 64935, 64945, 77580, 77550, 76888, 77581, 77583, 77553, 76891, 
77584, 77582, 77551, 76859, 76890
18628, 65165, 65155, 64935, 64945, 65166, 65156, 64936, 64946, 77583, 77553, 76891, 77584, 77586, 77556, 76894, 
77587, 77585, 77554, 76862, 76893
18629, 65166, 65156, 64936, 64946, 65167, 65157, 64937, 64947, 77586, 77556, 76894, 77587, 77589, 77559, 76897, 
77590, 77588, 77557, 76865, 76896
18630, 65167, 65157, 64937, 64947, 65168, 65158, 64938, 64948, 77589, 77559, 76897, 77590, 77592, 77562, 76900, 
77593, 77591, 77560, 76868, 76899
18631, 65168, 65158, 64938, 64948, 65169, 65159, 64939, 64949, 77592, 77562, 76900, 77593, 77595, 77565, 76903, 
77596, 77594, 77563, 76871, 76902
18632, 65169, 65159, 64939, 64949, 65170, 65160, 64940, 64950, 77595, 77565, 76903, 77596, 77598, 77568, 76906, 
77599, 77597, 77566, 76874, 76905
18633, 65170, 65160, 64940, 64950, 65171, 65161, 64941, 64951, 77598, 77568, 76906, 77599, 77601, 77571, 76909, 
77602, 77600, 77569, 76877, 76908
18634, 65171, 65161, 64941, 64951, 65172, 65162, 64942, 64952, 77601, 77571, 76909, 77602, 77604, 77574, 76912, 
77605, 77603, 77572, 76880, 76911
18635, 65172, 65162, 64942, 64952, 18288, 18287, 18265, 18266, 77604, 77574, 76912, 77605, 19142, 19139, 19097, 
19141, 77606, 77575, 76883, 76914
18636, 16793, 16792, 16770, 16771, 65173, 65163, 64943, 64953, 17647, 17646, 17602, 17648, 77608, 77578, 76916, 
77609, 77607, 77576, 76884, 76915
18637, 65173, 65163, 64943, 64953, 65174, 65164, 64944, 64954, 77608, 77578, 76916, 77609, 77611, 77581, 76919, 
77612, 77610, 77579, 76887, 76918
18638, 65174, 65164, 64944, 64954, 65175, 65165, 64945, 64955, 77611, 77581, 76919, 77612, 77614, 77584, 76922, 
77615, 77613, 77582, 76890, 76921
18639, 65175, 65165, 64945, 64955, 65176, 65166, 64946, 64956, 77614, 77584, 76922, 77615, 77617, 77587, 76925, 
77618, 77616, 77585, 76893, 76924
18640, 65176, 65166, 64946, 64956, 65177, 65167, 64947, 64957, 77617, 77587, 76925, 77618, 77620, 77590, 76928, 
77621, 77619, 77588, 76896, 76927
18641, 65177, 65167, 64947, 64957, 65178, 65168, 64948, 64958, 77620, 77590, 76928, 77621, 77623, 77593, 76931, 
77624, 77622, 77591, 76899, 76930
18642, 65178, 65168, 64948, 64958, 65179, 65169, 64949, 64959, 77623, 77593, 76931, 77624, 77626, 77596, 76934, 
77627, 77625, 77594, 76902, 76933
18643, 65179, 65169, 64949, 64959, 65180, 65170, 64950, 64960, 77626, 77596, 76934, 77627, 77629, 77599, 76937, 
77630, 77628, 77597, 76905, 76936
18644, 65180, 65170, 64950, 64960, 65181, 65171, 64951, 64961, 77629, 77599, 76937, 77630, 77632, 77602, 76940, 
77633, 77631, 77600, 76908, 76939
18645, 65181, 65171, 64951, 64961, 65182, 65172, 64952, 64962, 77632, 77602, 76940, 77633, 77635, 77605, 76943, 
77636, 77634, 77603, 76911, 76942
18646, 65182, 65172, 64952, 64962, 18289, 18288, 18266, 18267, 77635, 77605, 76943, 77636, 19144, 19141, 19099, 
19143, 77637, 77606, 76914, 76945
18647, 16794, 16793, 16771, 16772, 65183, 65173, 64953, 64963, 17649, 17648, 17604, 17650, 77639, 77609, 76947, 
77640, 77638, 77607, 76915, 76946
18648, 65183, 65173, 64953, 64963, 65184, 65174, 64954, 64964, 77639, 77609, 76947, 77640, 77642, 77612, 76950, 
77643, 77641, 77610, 76918, 76949
18649, 65184, 65174, 64954, 64964, 65185, 65175, 64955, 64965, 77642, 77612, 76950, 77643, 77645, 77615, 76953, 
77646, 77644, 77613, 76921, 76952
18650, 65185, 65175, 64955, 64965, 65186, 65176, 64956, 64966, 77645, 77615, 76953, 77646, 77648, 77618, 76956, 
77649, 77647, 77616, 76924, 76955
18651, 65186, 65176, 64956, 64966, 65187, 65177, 64957, 64967, 77648, 77618, 76956, 77649, 77651, 77621, 76959, 
77652, 77650, 77619, 76927, 76958
18652, 65187, 65177, 64957, 64967, 65188, 65178, 64958, 64968, 77651, 77621, 76959, 77652, 77654, 77624, 76962, 
77655, 77653, 77622, 76930, 76961
18653, 65188, 65178, 64958, 64968, 65189, 65179, 64959, 64969, 77654, 77624, 76962, 77655, 77657, 77627, 76965, 
77658, 77656, 77625, 76933, 76964
18654, 65189, 65179, 64959, 64969, 65190, 65180, 64960, 64970, 77657, 77627, 76965, 77658, 77660, 77630, 76968, 
77661, 77659, 77628, 76936, 76967
18655, 65190, 65180, 64960, 64970, 65191, 65181, 64961, 64971, 77660, 77630, 76968, 77661, 77663, 77633, 76971, 
77664, 77662, 77631, 76939, 76970
18656, 65191, 65181, 64961, 64971, 65192, 65182, 64962, 64972, 77663, 77633, 76971, 77664, 77666, 77636, 76974, 
77667, 77665, 77634, 76942, 76973
18657, 65192, 65182, 64962, 64972, 18290, 18289, 18267, 18268, 77666, 77636, 76974, 77667, 19146, 19143, 19101, 
19145, 77668, 77637, 76945, 76976
18658, 16795, 16794, 16772, 16773, 65193, 65183, 64963, 64973, 17651, 17650, 17606, 17652, 77670, 77640, 76978, 
77671, 77669, 77638, 76946, 76977
18659, 65193, 65183, 64963, 64973, 65194, 65184, 64964, 64974, 77670, 77640, 76978, 77671, 77673, 77643, 76981, 
77674, 77672, 77641, 76949, 76980
18660, 65194, 65184, 64964, 64974, 65195, 65185, 64965, 64975, 77673, 77643, 76981, 77674, 77676, 77646, 76984, 
77677, 77675, 77644, 76952, 76983
18661, 65195, 65185, 64965, 64975, 65196, 65186, 64966, 64976, 77676, 77646, 76984, 77677, 77679, 77649, 76987, 
77680, 77678, 77647, 76955, 76986
18662, 65196, 65186, 64966, 64976, 65197, 65187, 64967, 64977, 77679, 77649, 76987, 77680, 77682, 77652, 76990, 
77683, 77681, 77650, 76958, 76989
18663, 65197, 65187, 64967, 64977, 65198, 65188, 64968, 64978, 77682, 77652, 76990, 77683, 77685, 77655, 76993, 
77686, 77684, 77653, 76961, 76992
18664, 65198, 65188, 64968, 64978, 65199, 65189, 64969, 64979, 77685, 77655, 76993, 77686, 77688, 77658, 76996, 
77689, 77687, 77656, 76964, 76995
18665, 65199, 65189, 64969, 64979, 65200, 65190, 64970, 64980, 77688, 77658, 76996, 77689, 77691, 77661, 76999, 
77692, 77690, 77659, 76967, 76998
18666, 65200, 65190, 64970, 64980, 65201, 65191, 64971, 64981, 77691, 77661, 76999, 77692, 77694, 77664, 77002, 
77695, 77693, 77662, 76970, 77001
18667, 65201, 65191, 64971, 64981, 65202, 65192, 64972, 64982, 77694, 77664, 77002, 77695, 77697, 77667, 77005, 
77698, 77696, 77665, 76973, 77004
18668, 65202, 65192, 64972, 64982, 18291, 18290, 18268, 18269, 77697, 77667, 77005, 77698, 19148, 19145, 19103, 
19147, 77699, 77668, 76976, 77007
18669, 16796, 16795, 16773, 16774, 65203, 65193, 64973, 64983, 17653, 17652, 17608, 17654, 77701, 77671, 77009, 
77702, 77700, 77669, 76977, 77008
18670, 65203, 65193, 64973, 64983, 65204, 65194, 64974, 64984, 77701, 77671, 77009, 77702, 77704, 77674, 77012, 
77705, 77703, 77672, 76980, 77011
18671, 65204, 65194, 64974, 64984, 65205, 65195, 64975, 64985, 77704, 77674, 77012, 77705, 77707, 77677, 77015, 
77708, 77706, 77675, 76983, 77014
18672, 65205, 65195, 64975, 64985, 65206, 65196, 64976, 64986, 77707, 77677, 77015, 77708, 77710, 77680, 77018, 
77711, 77709, 77678, 76986, 77017
18673, 65206, 65196, 64976, 64986, 65207, 65197, 64977, 64987, 77710, 77680, 77018, 77711, 77713, 77683, 77021, 
77714, 77712, 77681, 76989, 77020
18674, 65207, 65197, 64977, 64987, 65208, 65198, 64978, 64988, 77713, 77683, 77021, 77714, 77716, 77686, 77024, 
77717, 77715, 77684, 76992, 77023
18675, 65208, 65198, 64978, 64988, 65209, 65199, 64979, 64989, 77716, 77686, 77024, 77717, 77719, 77689, 77027, 
77720, 77718, 77687, 76995, 77026
18676, 65209, 65199, 64979, 64989, 65210, 65200, 64980, 64990, 77719, 77689, 77027, 77720, 77722, 77692, 77030, 
77723, 77721, 77690, 76998, 77029
18677, 65210, 65200, 64980, 64990, 65211, 65201, 64981, 64991, 77722, 77692, 77030, 77723, 77725, 77695, 77033, 
77726, 77724, 77693, 77001, 77032
18678, 65211, 65201, 64981, 64991, 65212, 65202, 64982, 64992, 77725, 77695, 77033, 77726, 77728, 77698, 77036, 
77729, 77727, 77696, 77004, 77035
18679, 65212, 65202, 64982, 64992, 18292, 18291, 18269, 18270, 77728, 77698, 77036, 77729, 19150, 19147, 19105, 
19149, 77730, 77699, 77007, 77038
18680, 16797, 16796, 16774, 16775, 65213, 65203, 64983, 64993, 17655, 17654, 17610, 17656, 77732, 77702, 77040, 
77733, 77731, 77700, 77008, 77039
18681, 65213, 65203, 64983, 64993, 65214, 65204, 64984, 64994, 77732, 77702, 77040, 77733, 77735, 77705, 77043, 
77736, 77734, 77703, 77011, 77042
18682, 65214, 65204, 64984, 64994, 65215, 65205, 64985, 64995, 77735, 77705, 77043, 77736, 77738, 77708, 77046, 
77739, 77737, 77706, 77014, 77045
18683, 65215, 65205, 64985, 64995, 65216, 65206, 64986, 64996, 77738, 77708, 77046, 77739, 77741, 77711, 77049, 
77742, 77740, 77709, 77017, 77048
18684, 65216, 65206, 64986, 64996, 65217, 65207, 64987, 64997, 77741, 77711, 77049, 77742, 77744, 77714, 77052, 
77745, 77743, 77712, 77020, 77051
18685, 65217, 65207, 64987, 64997, 65218, 65208, 64988, 64998, 77744, 77714, 77052, 77745, 77747, 77717, 77055, 
77748, 77746, 77715, 77023, 77054
18686, 65218, 65208, 64988, 64998, 65219, 65209, 64989, 64999, 77747, 77717, 77055, 77748, 77750, 77720, 77058, 
77751, 77749, 77718, 77026, 77057
18687, 65219, 65209, 64989, 64999, 65220, 65210, 64990, 65000, 77750, 77720, 77058, 77751, 77753, 77723, 77061, 
77754, 77752, 77721, 77029, 77060
18688, 65220, 65210, 64990, 65000, 65221, 65211, 64991, 65001, 77753, 77723, 77061, 77754, 77756, 77726, 77064, 
77757, 77755, 77724, 77032, 77063
18689, 65221, 65211, 64991, 65001, 65222, 65212, 64992, 65002, 77756, 77726, 77064, 77757, 77759, 77729, 77067, 
77760, 77758, 77727, 77035, 77066
18690, 65222, 65212, 64992, 65002, 18293, 18292, 18270, 18271, 77759, 77729, 77067, 77760, 19152, 19149, 19107, 
19151, 77761, 77730, 77038, 77069
18691, 16798, 16797, 16775, 16776, 65223, 65213, 64993, 65003, 17657, 17656, 17612, 17658, 77763, 77733, 77071, 
77764, 77762, 77731, 77039, 77070
18692, 65223, 65213, 64993, 65003, 65224, 65214, 64994, 65004, 77763, 77733, 77071, 77764, 77766, 77736, 77074, 
77767, 77765, 77734, 77042, 77073
18693, 65224, 65214, 64994, 65004, 65225, 65215, 64995, 65005, 77766, 77736, 77074, 77767, 77769, 77739, 77077, 
77770, 77768, 77737, 77045, 77076
18694, 65225, 65215, 64995, 65005, 65226, 65216, 64996, 65006, 77769, 77739, 77077, 77770, 77772, 77742, 77080, 
77773, 77771, 77740, 77048, 77079
18695, 65226, 65216, 64996, 65006, 65227, 65217, 64997, 65007, 77772, 77742, 77080, 77773, 77775, 77745, 77083, 
77776, 77774, 77743, 77051, 77082
18696, 65227, 65217, 64997, 65007, 65228, 65218, 64998, 65008, 77775, 77745, 77083, 77776, 77778, 77748, 77086, 
77779, 77777, 77746, 77054, 77085
18697, 65228, 65218, 64998, 65008, 65229, 65219, 64999, 65009, 77778, 77748, 77086, 77779, 77781, 77751, 77089, 
77782, 77780, 77749, 77057, 77088
18698, 65229, 65219, 64999, 65009, 65230, 65220, 65000, 65010, 77781, 77751, 77089, 77782, 77784, 77754, 77092, 
77785, 77783, 77752, 77060, 77091
18699, 65230, 65220, 65000, 65010, 65231, 65221, 65001, 65011, 77784, 77754, 77092, 77785, 77787, 77757, 77095, 
77788, 77786, 77755, 77063, 77094
18700, 65231, 65221, 65001, 65011, 65232, 65222, 65002, 65012, 77787, 77757, 77095, 77788, 77790, 77760, 77098, 
77791, 77789, 77758, 77066, 77097
18701, 65232, 65222, 65002, 65012, 18294, 18293, 18271, 18272, 77790, 77760, 77098, 77791, 19154, 19151, 19109, 
19153, 77792, 77761, 77069, 77100
18702, 16799, 16798, 16776, 16777, 65233, 65223, 65003, 65013, 17659, 17658, 17614, 17660, 77794, 77764, 77102, 
77795, 77793, 77762, 77070, 77101
18703, 65233, 65223, 65003, 65013, 65234, 65224, 65004, 65014, 77794, 77764, 77102, 77795, 77797, 77767, 77105, 
77798, 77796, 77765, 77073, 77104
18704, 65234, 65224, 65004, 65014, 65235, 65225, 65005, 65015, 77797, 77767, 77105, 77798, 77800, 77770, 77108, 
77801, 77799, 77768, 77076, 77107
18705, 65235, 65225, 65005, 65015, 65236, 65226, 65006, 65016, 77800, 77770, 77108, 77801, 77803, 77773, 77111, 
77804, 77802, 77771, 77079, 77110
18706, 65236, 65226, 65006, 65016, 65237, 65227, 65007, 65017, 77803, 77773, 77111, 77804, 77806, 77776, 77114, 
77807, 77805, 77774, 77082, 77113
18707, 65237, 65227, 65007, 65017, 65238, 65228, 65008, 65018, 77806, 77776, 77114, 77807, 77809, 77779, 77117, 
77810, 77808, 77777, 77085, 77116
18708, 65238, 65228, 65008, 65018, 65239, 65229, 65009, 65019, 77809, 77779, 77117, 77810, 77812, 77782, 77120, 
77813, 77811, 77780, 77088, 77119
18709, 65239, 65229, 65009, 65019, 65240, 65230, 65010, 65020, 77812, 77782, 77120, 77813, 77815, 77785, 77123, 
77816, 77814, 77783, 77091, 77122
18710, 65240, 65230, 65010, 65020, 65241, 65231, 65011, 65021, 77815, 77785, 77123, 77816, 77818, 77788, 77126, 
77819, 77817, 77786, 77094, 77125
18711, 65241, 65231, 65011, 65021, 65242, 65232, 65012, 65022, 77818, 77788, 77126, 77819, 77821, 77791, 77129, 
77822, 77820, 77789, 77097, 77128
18712, 65242, 65232, 65012, 65022, 18295, 18294, 18272, 18273, 77821, 77791, 77129, 77822, 19156, 19153, 19111, 
19155, 77823, 77792, 77100, 77131
18713, 16800, 16799, 16777, 16778, 65243, 65233, 65013, 65023, 17661, 17660, 17616, 17662, 77825, 77795, 77133, 
77826, 77824, 77793, 77101, 77132
18714, 65243, 65233, 65013, 65023, 65244, 65234, 65014, 65024, 77825, 77795, 77133, 77826, 77828, 77798, 77136, 
77829, 77827, 77796, 77104, 77135
18715, 65244, 65234, 65014, 65024, 65245, 65235, 65015, 65025, 77828, 77798, 77136, 77829, 77831, 77801, 77139, 
77832, 77830, 77799, 77107, 77138
18716, 65245, 65235, 65015, 65025, 65246, 65236, 65016, 65026, 77831, 77801, 77139, 77832, 77834, 77804, 77142, 
77835, 77833, 77802, 77110, 77141
18717, 65246, 65236, 65016, 65026, 65247, 65237, 65017, 65027, 77834, 77804, 77142, 77835, 77837, 77807, 77145, 
77838, 77836, 77805, 77113, 77144
18718, 65247, 65237, 65017, 65027, 65248, 65238, 65018, 65028, 77837, 77807, 77145, 77838, 77840, 77810, 77148, 
77841, 77839, 77808, 77116, 77147
18719, 65248, 65238, 65018, 65028, 65249, 65239, 65019, 65029, 77840, 77810, 77148, 77841, 77843, 77813, 77151, 
77844, 77842, 77811, 77119, 77150
18720, 65249, 65239, 65019, 65029, 65250, 65240, 65020, 65030, 77843, 77813, 77151, 77844, 77846, 77816, 77154, 
77847, 77845, 77814, 77122, 77153
18721, 65250, 65240, 65020, 65030, 65251, 65241, 65021, 65031, 77846, 77816, 77154, 77847, 77849, 77819, 77157, 
77850, 77848, 77817, 77125, 77156
18722, 65251, 65241, 65021, 65031, 65252, 65242, 65022, 65032, 77849, 77819, 77157, 77850, 77852, 77822, 77160, 
77853, 77851, 77820, 77128, 77159
18723, 65252, 65242, 65022, 65032, 18296, 18295, 18273, 18274, 77852, 77822, 77160, 77853, 19158, 19155, 19113, 
19157, 77854, 77823, 77131, 77162
18724, 16801, 16800, 16778, 16779, 65253, 65243, 65023, 65033, 17663, 17662, 17618, 17664, 77856, 77826, 77164, 
77857, 77855, 77824, 77132, 77163
18725, 65253, 65243, 65023, 65033, 65254, 65244, 65024, 65034, 77856, 77826, 77164, 77857, 77859, 77829, 77167, 
77860, 77858, 77827, 77135, 77166
18726, 65254, 65244, 65024, 65034, 65255, 65245, 65025, 65035, 77859, 77829, 77167, 77860, 77862, 77832, 77170, 
77863, 77861, 77830, 77138, 77169
18727, 65255, 65245, 65025, 65035, 65256, 65246, 65026, 65036, 77862, 77832, 77170, 77863, 77865, 77835, 77173, 
77866, 77864, 77833, 77141, 77172
18728, 65256, 65246, 65026, 65036, 65257, 65247, 65027, 65037, 77865, 77835, 77173, 77866, 77868, 77838, 77176, 
77869, 77867, 77836, 77144, 77175
18729, 65257, 65247, 65027, 65037, 65258, 65248, 65028, 65038, 77868, 77838, 77176, 77869, 77871, 77841, 77179, 
77872, 77870, 77839, 77147, 77178
18730, 65258, 65248, 65028, 65038, 65259, 65249, 65029, 65039, 77871, 77841, 77179, 77872, 77874, 77844, 77182, 
77875, 77873, 77842, 77150, 77181
18731, 65259, 65249, 65029, 65039, 65260, 65250, 65030, 65040, 77874, 77844, 77182, 77875, 77877, 77847, 77185, 
77878, 77876, 77845, 77153, 77184
18732, 65260, 65250, 65030, 65040, 65261, 65251, 65031, 65041, 77877, 77847, 77185, 77878, 77880, 77850, 77188, 
77881, 77879, 77848, 77156, 77187
18733, 65261, 65251, 65031, 65041, 65262, 65252, 65032, 65042, 77880, 77850, 77188, 77881, 77883, 77853, 77191, 
77884, 77882, 77851, 77159, 77190
18734, 65262, 65252, 65032, 65042, 18297, 18296, 18274, 18275, 77883, 77853, 77191, 77884, 19160, 19157, 19115, 
19159, 77885, 77854, 77162, 77193
18735, 16802, 16801, 16779, 16780, 65263, 65253, 65033, 65043, 17665, 17664, 17620, 17666, 77887, 77857, 77195, 
77888, 77886, 77855, 77163, 77194
18736, 65263, 65253, 65033, 65043, 65264, 65254, 65034, 65044, 77887, 77857, 77195, 77888, 77890, 77860, 77198, 
77891, 77889, 77858, 77166, 77197
18737, 65264, 65254, 65034, 65044, 65265, 65255, 65035, 65045, 77890, 77860, 77198, 77891, 77893, 77863, 77201, 
77894, 77892, 77861, 77169, 77200
18738, 65265, 65255, 65035, 65045, 65266, 65256, 65036, 65046, 77893, 77863, 77201, 77894, 77896, 77866, 77204, 
77897, 77895, 77864, 77172, 77203
18739, 65266, 65256, 65036, 65046, 65267, 65257, 65037, 65047, 77896, 77866, 77204, 77897, 77899, 77869, 77207, 
77900, 77898, 77867, 77175, 77206
18740, 65267, 65257, 65037, 65047, 65268, 65258, 65038, 65048, 77899, 77869, 77207, 77900, 77902, 77872, 77210, 
77903, 77901, 77870, 77178, 77209
18741, 65268, 65258, 65038, 65048, 65269, 65259, 65039, 65049, 77902, 77872, 77210, 77903, 77905, 77875, 77213, 
77906, 77904, 77873, 77181, 77212
18742, 65269, 65259, 65039, 65049, 65270, 65260, 65040, 65050, 77905, 77875, 77213, 77906, 77908, 77878, 77216, 
77909, 77907, 77876, 77184, 77215
18743, 65270, 65260, 65040, 65050, 65271, 65261, 65041, 65051, 77908, 77878, 77216, 77909, 77911, 77881, 77219, 
77912, 77910, 77879, 77187, 77218
18744, 65271, 65261, 65041, 65051, 65272, 65262, 65042, 65052, 77911, 77881, 77219, 77912, 77914, 77884, 77222, 
77915, 77913, 77882, 77190, 77221
18745, 65272, 65262, 65042, 65052, 18298, 18297, 18275, 18276, 77914, 77884, 77222, 77915, 19162, 19159, 19117, 
19161, 77916, 77885, 77193, 77224
18746, 16803, 16802, 16780, 16781, 65273, 65263, 65043, 65053, 17667, 17666, 17622, 17668, 77918, 77888, 77226, 
77919, 77917, 77886, 77194, 77225
18747, 65273, 65263, 65043, 65053, 65274, 65264, 65044, 65054, 77918, 77888, 77226, 77919, 77921, 77891, 77229, 
77922, 77920, 77889, 77197, 77228
18748, 65274, 65264, 65044, 65054, 65275, 65265, 65045, 65055, 77921, 77891, 77229, 77922, 77924, 77894, 77232, 
77925, 77923, 77892, 77200, 77231
18749, 65275, 65265, 65045, 65055, 65276, 65266, 65046, 65056, 77924, 77894, 77232, 77925, 77927, 77897, 77235, 
77928, 77926, 77895, 77203, 77234
18750, 65276, 65266, 65046, 65056, 65277, 65267, 65047, 65057, 77927, 77897, 77235, 77928, 77930, 77900, 77238, 
77931, 77929, 77898, 77206, 77237
18751, 65277, 65267, 65047, 65057, 65278, 65268, 65048, 65058, 77930, 77900, 77238, 77931, 77933, 77903, 77241, 
77934, 77932, 77901, 77209, 77240
18752, 65278, 65268, 65048, 65058, 65279, 65269, 65049, 65059, 77933, 77903, 77241, 77934, 77936, 77906, 77244, 
77937, 77935, 77904, 77212, 77243
18753, 65279, 65269, 65049, 65059, 65280, 65270, 65050, 65060, 77936, 77906, 77244, 77937, 77939, 77909, 77247, 
77940, 77938, 77907, 77215, 77246
18754, 65280, 65270, 65050, 65060, 65281, 65271, 65051, 65061, 77939, 77909, 77247, 77940, 77942, 77912, 77250, 
77943, 77941, 77910, 77218, 77249
18755, 65281, 65271, 65051, 65061, 65282, 65272, 65052, 65062, 77942, 77912, 77250, 77943, 77945, 77915, 77253, 
77946, 77944, 77913, 77221, 77252
18756, 65282, 65272, 65052, 65062, 18299, 18298, 18276, 18277, 77945, 77915, 77253, 77946, 19164, 19161, 19119, 
19163, 77947, 77916, 77224, 77255
18757, 16804, 16803, 16781, 16782, 65283, 65273, 65053, 65063, 17669, 17668, 17624, 17670, 77949, 77919, 77257, 
77950, 77948, 77917, 77225, 77256
18758, 65283, 65273, 65053, 65063, 65284, 65274, 65054, 65064, 77949, 77919, 77257, 77950, 77952, 77922, 77260, 
77953, 77951, 77920, 77228, 77259
18759, 65284, 65274, 65054, 65064, 65285, 65275, 65055, 65065, 77952, 77922, 77260, 77953, 77955, 77925, 77263, 
77956, 77954, 77923, 77231, 77262
18760, 65285, 65275, 65055, 65065, 65286, 65276, 65056, 65066, 77955, 77925, 77263, 77956, 77958, 77928, 77266, 
77959, 77957, 77926, 77234, 77265
18761, 65286, 65276, 65056, 65066, 65287, 65277, 65057, 65067, 77958, 77928, 77266, 77959, 77961, 77931, 77269, 
77962, 77960, 77929, 77237, 77268
18762, 65287, 65277, 65057, 65067, 65288, 65278, 65058, 65068, 77961, 77931, 77269, 77962, 77964, 77934, 77272, 
77965, 77963, 77932, 77240, 77271
18763, 65288, 65278, 65058, 65068, 65289, 65279, 65059, 65069, 77964, 77934, 77272, 77965, 77967, 77937, 77275, 
77968, 77966, 77935, 77243, 77274
18764, 65289, 65279, 65059, 65069, 65290, 65280, 65060, 65070, 77967, 77937, 77275, 77968, 77970, 77940, 77278, 
77971, 77969, 77938, 77246, 77277
18765, 65290, 65280, 65060, 65070, 65291, 65281, 65061, 65071, 77970, 77940, 77278, 77971, 77973, 77943, 77281, 
77974, 77972, 77941, 77249, 77280
18766, 65291, 65281, 65061, 65071, 65292, 65282, 65062, 65072, 77973, 77943, 77281, 77974, 77976, 77946, 77284, 
77977, 77975, 77944, 77252, 77283
18767, 65292, 65282, 65062, 65072, 18300, 18299, 18277, 18278, 77976, 77946, 77284, 77977, 19166, 19163, 19121, 
19165, 77978, 77947, 77255, 77286
18768, 16805, 16804, 16782, 16783, 65293, 65283, 65063, 65073, 17671, 17670, 17626, 17672, 77980, 77950, 77288, 
77981, 77979, 77948, 77256, 77287
18769, 65293, 65283, 65063, 65073, 65294, 65284, 65064, 65074, 77980, 77950, 77288, 77981, 77983, 77953, 77291, 
77984, 77982, 77951, 77259, 77290
18770, 65294, 65284, 65064, 65074, 65295, 65285, 65065, 65075, 77983, 77953, 77291, 77984, 77986, 77956, 77294, 
77987, 77985, 77954, 77262, 77293
18771, 65295, 65285, 65065, 65075, 65296, 65286, 65066, 65076, 77986, 77956, 77294, 77987, 77989, 77959, 77297, 
77990, 77988, 77957, 77265, 77296
18772, 65296, 65286, 65066, 65076, 65297, 65287, 65067, 65077, 77989, 77959, 77297, 77990, 77992, 77962, 77300, 
77993, 77991, 77960, 77268, 77299
18773, 65297, 65287, 65067, 65077, 65298, 65288, 65068, 65078, 77992, 77962, 77300, 77993, 77995, 77965, 77303, 
77996, 77994, 77963, 77271, 77302
18774, 65298, 65288, 65068, 65078, 65299, 65289, 65069, 65079, 77995, 77965, 77303, 77996, 77998, 77968, 77306, 
77999, 77997, 77966, 77274, 77305
18775, 65299, 65289, 65069, 65079, 65300, 65290, 65070, 65080, 77998, 77968, 77306, 77999, 78001, 77971, 77309, 
78002, 78000, 77969, 77277, 77308
18776, 65300, 65290, 65070, 65080, 65301, 65291, 65071, 65081, 78001, 77971, 77309, 78002, 78004, 77974, 77312, 
78005, 78003, 77972, 77280, 77311
18777, 65301, 65291, 65071, 65081, 65302, 65292, 65072, 65082, 78004, 77974, 77312, 78005, 78007, 77977, 77315, 
78008, 78006, 77975, 77283, 77314
18778, 65302, 65292, 65072, 65082, 18301, 18300, 18278, 18279, 78007, 77977, 77315, 78008, 19168, 19165, 19123, 
19167, 78009, 77978, 77286, 77317
18779, 16806, 16805, 16783, 16784, 65303, 65293, 65073, 65083, 17673, 17672, 17628, 17674, 78011, 77981, 77319, 
78012, 78010, 77979, 77287, 77318
18780, 65303, 65293, 65073, 65083, 65304, 65294, 65074, 65084, 78011, 77981, 77319, 78012, 78014, 77984, 77322, 
78015, 78013, 77982, 77290, 77321
18781, 65304, 65294, 65074, 65084, 65305, 65295, 65075, 65085, 78014, 77984, 77322, 78015, 78017, 77987, 77325, 
78018, 78016, 77985, 77293, 77324
18782, 65305, 65295, 65075, 65085, 65306, 65296, 65076, 65086, 78017, 77987, 77325, 78018, 78020, 77990, 77328, 
78021, 78019, 77988, 77296, 77327
18783, 65306, 65296, 65076, 65086, 65307, 65297, 65077, 65087, 78020, 77990, 77328, 78021, 78023, 77993, 77331, 
78024, 78022, 77991, 77299, 77330
18784, 65307, 65297, 65077, 65087, 65308, 65298, 65078, 65088, 78023, 77993, 77331, 78024, 78026, 77996, 77334, 
78027, 78025, 77994, 77302, 77333
18785, 65308, 65298, 65078, 65088, 65309, 65299, 65079, 65089, 78026, 77996, 77334, 78027, 78029, 77999, 77337, 
78030, 78028, 77997, 77305, 77336
18786, 65309, 65299, 65079, 65089, 65310, 65300, 65080, 65090, 78029, 77999, 77337, 78030, 78032, 78002, 77340, 
78033, 78031, 78000, 77308, 77339
18787, 65310, 65300, 65080, 65090, 65311, 65301, 65081, 65091, 78032, 78002, 77340, 78033, 78035, 78005, 77343, 
78036, 78034, 78003, 77311, 77342
18788, 65311, 65301, 65081, 65091, 65312, 65302, 65082, 65092, 78035, 78005, 77343, 78036, 78038, 78008, 77346, 
78039, 78037, 78006, 77314, 77345
18789, 65312, 65302, 65082, 65092, 18302, 18301, 18279, 18280, 78038, 78008, 77346, 78039, 19170, 19167, 19125, 
19169, 78040, 78009, 77317, 77348
18790, 16807, 16806, 16784, 16785, 65313, 65303, 65083, 65093, 17675, 17674, 17630, 17676, 78042, 78012, 77350, 
78043, 78041, 78010, 77318, 77349
18791, 65313, 65303, 65083, 65093, 65314, 65304, 65084, 65094, 78042, 78012, 77350, 78043, 78045, 78015, 77353, 
78046, 78044, 78013, 77321, 77352
18792, 65314, 65304, 65084, 65094, 65315, 65305, 65085, 65095, 78045, 78015, 77353, 78046, 78048, 78018, 77356, 
78049, 78047, 78016, 77324, 77355
18793, 65315, 65305, 65085, 65095, 65316, 65306, 65086, 65096, 78048, 78018, 77356, 78049, 78051, 78021, 77359, 
78052, 78050, 78019, 77327, 77358
18794, 65316, 65306, 65086, 65096, 65317, 65307, 65087, 65097, 78051, 78021, 77359, 78052, 78054, 78024, 77362, 
78055, 78053, 78022, 77330, 77361
18795, 65317, 65307, 65087, 65097, 65318, 65308, 65088, 65098, 78054, 78024, 77362, 78055, 78057, 78027, 77365, 
78058, 78056, 78025, 77333, 77364
18796, 65318, 65308, 65088, 65098, 65319, 65309, 65089, 65099, 78057, 78027, 77365, 78058, 78060, 78030, 77368, 
78061, 78059, 78028, 77336, 77367
18797, 65319, 65309, 65089, 65099, 65320, 65310, 65090, 65100, 78060, 78030, 77368, 78061, 78063, 78033, 77371, 
78064, 78062, 78031, 77339, 77370
18798, 65320, 65310, 65090, 65100, 65321, 65311, 65091, 65101, 78063, 78033, 77371, 78064, 78066, 78036, 77374, 
78067, 78065, 78034, 77342, 77373
18799, 65321, 65311, 65091, 65101, 65322, 65312, 65092, 65102, 78066, 78036, 77374, 78067, 78069, 78039, 77377, 
78070, 78068, 78037, 77345, 77376
18800, 65322, 65312, 65092, 65102, 18303, 18302, 18280, 18281, 78069, 78039, 77377, 78070, 19172, 19169, 19127, 
19171, 78071, 78040, 77348, 77379
18801, 16808, 16807, 16785, 16786, 65323, 65313, 65093, 65103, 17677, 17676, 17632, 17678, 78073, 78043, 77381, 
78074, 78072, 78041, 77349, 77380
18802, 65323, 65313, 65093, 65103, 65324, 65314, 65094, 65104, 78073, 78043, 77381, 78074, 78076, 78046, 77384, 
78077, 78075, 78044, 77352, 77383
18803, 65324, 65314, 65094, 65104, 65325, 65315, 65095, 65105, 78076, 78046, 77384, 78077, 78079, 78049, 77387, 
78080, 78078, 78047, 77355, 77386
18804, 65325, 65315, 65095, 65105, 65326, 65316, 65096, 65106, 78079, 78049, 77387, 78080, 78082, 78052, 77390, 
78083, 78081, 78050, 77358, 77389
18805, 65326, 65316, 65096, 65106, 65327, 65317, 65097, 65107, 78082, 78052, 77390, 78083, 78085, 78055, 77393, 
78086, 78084, 78053, 77361, 77392
18806, 65327, 65317, 65097, 65107, 65328, 65318, 65098, 65108, 78085, 78055, 77393, 78086, 78088, 78058, 77396, 
78089, 78087, 78056, 77364, 77395
18807, 65328, 65318, 65098, 65108, 65329, 65319, 65099, 65109, 78088, 78058, 77396, 78089, 78091, 78061, 77399, 
78092, 78090, 78059, 77367, 77398
18808, 65329, 65319, 65099, 65109, 65330, 65320, 65100, 65110, 78091, 78061, 77399, 78092, 78094, 78064, 77402, 
78095, 78093, 78062, 77370, 77401
18809, 65330, 65320, 65100, 65110, 65331, 65321, 65101, 65111, 78094, 78064, 77402, 78095, 78097, 78067, 77405, 
78098, 78096, 78065, 77373, 77404
18810, 65331, 65321, 65101, 65111, 65332, 65322, 65102, 65112, 78097, 78067, 77405, 78098, 78100, 78070, 77408, 
78101, 78099, 78068, 77376, 77407
18811, 65332, 65322, 65102, 65112, 18304, 18303, 18281, 18282, 78100, 78070, 77408, 78101, 19174, 19171, 19129, 
19173, 78102, 78071, 77379, 77410
18812, 16809, 16808, 16786, 16787, 65333, 65323, 65103, 65113, 17679, 17678, 17634, 17680, 78104, 78074, 77412, 
78105, 78103, 78072, 77380, 77411
18813, 65333, 65323, 65103, 65113, 65334, 65324, 65104, 65114, 78104, 78074, 77412, 78105, 78107, 78077, 77415, 
78108, 78106, 78075, 77383, 77414
18814, 65334, 65324, 65104, 65114, 65335, 65325, 65105, 65115, 78107, 78077, 77415, 78108, 78110, 78080, 77418, 
78111, 78109, 78078, 77386, 77417
18815, 65335, 65325, 65105, 65115, 65336, 65326, 65106, 65116, 78110, 78080, 77418, 78111, 78113, 78083, 77421, 
78114, 78112, 78081, 77389, 77420
18816, 65336, 65326, 65106, 65116, 65337, 65327, 65107, 65117, 78113, 78083, 77421, 78114, 78116, 78086, 77424, 
78117, 78115, 78084, 77392, 77423
18817, 65337, 65327, 65107, 65117, 65338, 65328, 65108, 65118, 78116, 78086, 77424, 78117, 78119, 78089, 77427, 
78120, 78118, 78087, 77395, 77426
18818, 65338, 65328, 65108, 65118, 65339, 65329, 65109, 65119, 78119, 78089, 77427, 78120, 78122, 78092, 77430, 
78123, 78121, 78090, 77398, 77429
18819, 65339, 65329, 65109, 65119, 65340, 65330, 65110, 65120, 78122, 78092, 77430, 78123, 78125, 78095, 77433, 
78126, 78124, 78093, 77401, 77432
18820, 65340, 65330, 65110, 65120, 65341, 65331, 65111, 65121, 78125, 78095, 77433, 78126, 78128, 78098, 77436, 
78129, 78127, 78096, 77404, 77435
18821, 65341, 65331, 65111, 65121, 65342, 65332, 65112, 65122, 78128, 78098, 77436, 78129, 78131, 78101, 77439, 
78132, 78130, 78099, 77407, 77438
18822, 65342, 65332, 65112, 65122, 18305, 18304, 18282, 18283, 78131, 78101, 77439, 78132, 19176, 19173, 19131, 
19175, 78133, 78102, 77410, 77441
18823, 16810, 16809, 16787, 16788, 65343, 65333, 65113, 65123, 17681, 17680, 17636, 17682, 78135, 78105, 77443, 
78136, 78134, 78103, 77411, 77442
18824, 65343, 65333, 65113, 65123, 65344, 65334, 65114, 65124, 78135, 78105, 77443, 78136, 78138, 78108, 77446, 
78139, 78137, 78106, 77414, 77445
18825, 65344, 65334, 65114, 65124, 65345, 65335, 65115, 65125, 78138, 78108, 77446, 78139, 78141, 78111, 77449, 
78142, 78140, 78109, 77417, 77448
18826, 65345, 65335, 65115, 65125, 65346, 65336, 65116, 65126, 78141, 78111, 77449, 78142, 78144, 78114, 77452, 
78145, 78143, 78112, 77420, 77451
18827, 65346, 65336, 65116, 65126, 65347, 65337, 65117, 65127, 78144, 78114, 77452, 78145, 78147, 78117, 77455, 
78148, 78146, 78115, 77423, 77454
18828, 65347, 65337, 65117, 65127, 65348, 65338, 65118, 65128, 78147, 78117, 77455, 78148, 78150, 78120, 77458, 
78151, 78149, 78118, 77426, 77457
18829, 65348, 65338, 65118, 65128, 65349, 65339, 65119, 65129, 78150, 78120, 77458, 78151, 78153, 78123, 77461, 
78154, 78152, 78121, 77429, 77460
18830, 65349, 65339, 65119, 65129, 65350, 65340, 65120, 65130, 78153, 78123, 77461, 78154, 78156, 78126, 77464, 
78157, 78155, 78124, 77432, 77463
18831, 65350, 65340, 65120, 65130, 65351, 65341, 65121, 65131, 78156, 78126, 77464, 78157, 78159, 78129, 77467, 
78160, 78158, 78127, 77435, 77466
18832, 65351, 65341, 65121, 65131, 65352, 65342, 65122, 65132, 78159, 78129, 77467, 78160, 78162, 78132, 77470, 
78163, 78161, 78130, 77438, 77469
18833, 65352, 65342, 65122, 65132, 18306, 18305, 18283, 18284, 78162, 78132, 77470, 78163, 19178, 19175, 19133, 
19177, 78164, 78133, 77441, 77472
18834, 16811, 16810, 16788, 16789, 65353, 65343, 65123, 65133, 17683, 17682, 17638, 17684, 78166, 78136, 77474, 
78167, 78165, 78134, 77442, 77473
18835, 65353, 65343, 65123, 65133, 65354, 65344, 65124, 65134, 78166, 78136, 77474, 78167, 78169, 78139, 77477, 
78170, 78168, 78137, 77445, 77476
18836, 65354, 65344, 65124, 65134, 65355, 65345, 65125, 65135, 78169, 78139, 77477, 78170, 78172, 78142, 77480, 
78173, 78171, 78140, 77448, 77479
18837, 65355, 65345, 65125, 65135, 65356, 65346, 65126, 65136, 78172, 78142, 77480, 78173, 78175, 78145, 77483, 
78176, 78174, 78143, 77451, 77482
18838, 65356, 65346, 65126, 65136, 65357, 65347, 65127, 65137, 78175, 78145, 77483, 78176, 78178, 78148, 77486, 
78179, 78177, 78146, 77454, 77485
18839, 65357, 65347, 65127, 65137, 65358, 65348, 65128, 65138, 78178, 78148, 77486, 78179, 78181, 78151, 77489, 
78182, 78180, 78149, 77457, 77488
18840, 65358, 65348, 65128, 65138, 65359, 65349, 65129, 65139, 78181, 78151, 77489, 78182, 78184, 78154, 77492, 
78185, 78183, 78152, 77460, 77491
18841, 65359, 65349, 65129, 65139, 65360, 65350, 65130, 65140, 78184, 78154, 77492, 78185, 78187, 78157, 77495, 
78188, 78186, 78155, 77463, 77494
18842, 65360, 65350, 65130, 65140, 65361, 65351, 65131, 65141, 78187, 78157, 77495, 78188, 78190, 78160, 77498, 
78191, 78189, 78158, 77466, 77497
18843, 65361, 65351, 65131, 65141, 65362, 65352, 65132, 65142, 78190, 78160, 77498, 78191, 78193, 78163, 77501, 
78194, 78192, 78161, 77469, 77500
18844, 65362, 65352, 65132, 65142, 18307, 18306, 18284, 18285, 78193, 78163, 77501, 78194, 19180, 19177, 19135, 
19179, 78195, 78164, 77472, 77503
18845, 16812, 16811, 16789, 16790, 65363, 65353, 65133, 65143, 17685, 17684, 17640, 17686, 78197, 78167, 77505, 
78198, 78196, 78165, 77473, 77504
18846, 65363, 65353, 65133, 65143, 65364, 65354, 65134, 65144, 78197, 78167, 77505, 78198, 78200, 78170, 77508, 
78201, 78199, 78168, 77476, 77507
18847, 65364, 65354, 65134, 65144, 65365, 65355, 65135, 65145, 78200, 78170, 77508, 78201, 78203, 78173, 77511, 
78204, 78202, 78171, 77479, 77510
18848, 65365, 65355, 65135, 65145, 65366, 65356, 65136, 65146, 78203, 78173, 77511, 78204, 78206, 78176, 77514, 
78207, 78205, 78174, 77482, 77513
18849, 65366, 65356, 65136, 65146, 65367, 65357, 65137, 65147, 78206, 78176, 77514, 78207, 78209, 78179, 77517, 
78210, 78208, 78177, 77485, 77516
18850, 65367, 65357, 65137, 65147, 65368, 65358, 65138, 65148, 78209, 78179, 77517, 78210, 78212, 78182, 77520, 
78213, 78211, 78180, 77488, 77519
18851, 65368, 65358, 65138, 65148, 65369, 65359, 65139, 65149, 78212, 78182, 77520, 78213, 78215, 78185, 77523, 
78216, 78214, 78183, 77491, 77522
18852, 65369, 65359, 65139, 65149, 65370, 65360, 65140, 65150, 78215, 78185, 77523, 78216, 78218, 78188, 77526, 
78219, 78217, 78186, 77494, 77525
18853, 65370, 65360, 65140, 65150, 65371, 65361, 65141, 65151, 78218, 78188, 77526, 78219, 78221, 78191, 77529, 
78222, 78220, 78189, 77497, 77528
18854, 65371, 65361, 65141, 65151, 65372, 65362, 65142, 65152, 78221, 78191, 77529, 78222, 78224, 78194, 77532, 
78225, 78223, 78192, 77500, 77531
18855, 65372, 65362, 65142, 65152, 18308, 18307, 18285, 18286, 78224, 78194, 77532, 78225, 19182, 19179, 19137, 
19181, 78226, 78195, 77503, 77534
18856, 1650, 16812, 16790, 1649, 20283, 65363, 65143, 20273, 17687, 17686, 17642, 1672, 78227, 78198, 77535, 
20680, 20679, 78196, 77504, 20658
18857, 20283, 65363, 65143, 20273, 20284, 65364, 65144, 20274, 78227, 78198, 77535, 20680, 78228, 78201, 77536, 
20682, 20681, 78199, 77507, 20660
18858, 20284, 65364, 65144, 20274, 20285, 65365, 65145, 20275, 78228, 78201, 77536, 20682, 78229, 78204, 77537, 
20684, 20683, 78202, 77510, 20662
18859, 20285, 65365, 65145, 20275, 20286, 65366, 65146, 20276, 78229, 78204, 77537, 20684, 78230, 78207, 77538, 
20686, 20685, 78205, 77513, 20664
18860, 20286, 65366, 65146, 20276, 20287, 65367, 65147, 20277, 78230, 78207, 77538, 20686, 78231, 78210, 77539, 
20688, 20687, 78208, 77516, 20666
18861, 20287, 65367, 65147, 20277, 20288, 65368, 65148, 20278, 78231, 78210, 77539, 20688, 78232, 78213, 77540, 
20690, 20689, 78211, 77519, 20668
18862, 20288, 65368, 65148, 20278, 20289, 65369, 65149, 20279, 78232, 78213, 77540, 20690, 78233, 78216, 77541, 
20692, 20691, 78214, 77522, 20670
18863, 20289, 65369, 65149, 20279, 20290, 65370, 65150, 20280, 78233, 78216, 77541, 20692, 78234, 78219, 77542, 
20694, 20693, 78217, 77525, 20672
18864, 20290, 65370, 65150, 20280, 20291, 65371, 65151, 20281, 78234, 78219, 77542, 20694, 78235, 78222, 77543, 
20696, 20695, 78220, 77528, 20674
18865, 20291, 65371, 65151, 20281, 20292, 65372, 65152, 20282, 78235, 78222, 77543, 20696, 78236, 78225, 77544, 
20698, 20697, 78223, 77531, 20676
18866, 20292, 65372, 65152, 20282, 1785, 18308, 18286, 1784, 78236, 78225, 77544, 20698, 19183, 19181, 19138, 
1807, 20699, 78226, 77534, 20678
18867, 16813, 1606, 1605, 16791, 65373, 19601, 19591, 65153, 17688, 1628, 17643, 17689, 78238, 20008, 77546, 
78239, 78237, 20009, 19988, 77545
18868, 65373, 19601, 19591, 65153, 65374, 19602, 19592, 65154, 78238, 20008, 77546, 78239, 78241, 20010, 77549, 
78242, 78240, 20011, 19990, 77548
18869, 65374, 19602, 19592, 65154, 65375, 19603, 19593, 65155, 78241, 20010, 77549, 78242, 78244, 20012, 77552, 
78245, 78243, 20013, 19992, 77551
18870, 65375, 19603, 19593, 65155, 65376, 19604, 19594, 65156, 78244, 20012, 77552, 78245, 78247, 20014, 77555, 
78248, 78246, 20015, 19994, 77554
18871, 65376, 19604, 19594, 65156, 65377, 19605, 19595, 65157, 78247, 20014, 77555, 78248, 78250, 20016, 77558, 
78251, 78249, 20017, 19996, 77557
18872, 65377, 19605, 19595, 65157, 65378, 19606, 19596, 65158, 78250, 20016, 77558, 78251, 78253, 20018, 77561, 
78254, 78252, 20019, 19998, 77560
18873, 65378, 19606, 19596, 65158, 65379, 19607, 19597, 65159, 78253, 20018, 77561, 78254, 78256, 20020, 77564, 
78257, 78255, 20021, 20000, 77563
18874, 65379, 19607, 19597, 65159, 65380, 19608, 19598, 65160, 78256, 20020, 77564, 78257, 78259, 20022, 77567, 
78260, 78258, 20023, 20002, 77566
18875, 65380, 19608, 19598, 65160, 65381, 19609, 19599, 65161, 78259, 20022, 77567, 78260, 78262, 20024, 77570, 
78263, 78261, 20025, 20004, 77569
18876, 65381, 19609, 19599, 65161, 65382, 19610, 19600, 65162, 78262, 20024, 77570, 78263, 78265, 20026, 77573, 
78266, 78264, 20027, 20006, 77572
18877, 65382, 19610, 19600, 65162, 18309, 1741, 1740, 18287, 78265, 20026, 77573, 78266, 19185, 1763, 19140, 
19184, 78267, 20028, 20007, 77575
18878, 16814, 16813, 16791, 16792, 65383, 65373, 65153, 65163, 17690, 17689, 17645, 17691, 78269, 78239, 77577, 
78270, 78268, 78237, 77545, 77576
18879, 65383, 65373, 65153, 65163, 65384, 65374, 65154, 65164, 78269, 78239, 77577, 78270, 78272, 78242, 77580, 
78273, 78271, 78240, 77548, 77579
18880, 65384, 65374, 65154, 65164, 65385, 65375, 65155, 65165, 78272, 78242, 77580, 78273, 78275, 78245, 77583, 
78276, 78274, 78243, 77551, 77582
18881, 65385, 65375, 65155, 65165, 65386, 65376, 65156, 65166, 78275, 78245, 77583, 78276, 78278, 78248, 77586, 
78279, 78277, 78246, 77554, 77585
18882, 65386, 65376, 65156, 65166, 65387, 65377, 65157, 65167, 78278, 78248, 77586, 78279, 78281, 78251, 77589, 
78282, 78280, 78249, 77557, 77588
18883, 65387, 65377, 65157, 65167, 65388, 65378, 65158, 65168, 78281, 78251, 77589, 78282, 78284, 78254, 77592, 
78285, 78283, 78252, 77560, 77591
18884, 65388, 65378, 65158, 65168, 65389, 65379, 65159, 65169, 78284, 78254, 77592, 78285, 78287, 78257, 77595, 
78288, 78286, 78255, 77563, 77594
18885, 65389, 65379, 65159, 65169, 65390, 65380, 65160, 65170, 78287, 78257, 77595, 78288, 78290, 78260, 77598, 
78291, 78289, 78258, 77566, 77597
18886, 65390, 65380, 65160, 65170, 65391, 65381, 65161, 65171, 78290, 78260, 77598, 78291, 78293, 78263, 77601, 
78294, 78292, 78261, 77569, 77600
18887, 65391, 65381, 65161, 65171, 65392, 65382, 65162, 65172, 78293, 78263, 77601, 78294, 78296, 78266, 77604, 
78297, 78295, 78264, 77572, 77603
18888, 65392, 65382, 65162, 65172, 18310, 18309, 18287, 18288, 78296, 78266, 77604, 78297, 19187, 19184, 19142, 
19186, 78298, 78267, 77575, 77606
18889, 16815, 16814, 16792, 16793, 65393, 65383, 65163, 65173, 17692, 17691, 17647, 17693, 78300, 78270, 77608, 
78301, 78299, 78268, 77576, 77607
18890, 65393, 65383, 65163, 65173, 65394, 65384, 65164, 65174, 78300, 78270, 77608, 78301, 78303, 78273, 77611, 
78304, 78302, 78271, 77579, 77610
18891, 65394, 65384, 65164, 65174, 65395, 65385, 65165, 65175, 78303, 78273, 77611, 78304, 78306, 78276, 77614, 
78307, 78305, 78274, 77582, 77613
18892, 65395, 65385, 65165, 65175, 65396, 65386, 65166, 65176, 78306, 78276, 77614, 78307, 78309, 78279, 77617, 
78310, 78308, 78277, 77585, 77616
18893, 65396, 65386, 65166, 65176, 65397, 65387, 65167, 65177, 78309, 78279, 77617, 78310, 78312, 78282, 77620, 
78313, 78311, 78280, 77588, 77619
18894, 65397, 65387, 65167, 65177, 65398, 65388, 65168, 65178, 78312, 78282, 77620, 78313, 78315, 78285, 77623, 
78316, 78314, 78283, 77591, 77622
18895, 65398, 65388, 65168, 65178, 65399, 65389, 65169, 65179, 78315, 78285, 77623, 78316, 78318, 78288, 77626, 
78319, 78317, 78286, 77594, 77625
18896, 65399, 65389, 65169, 65179, 65400, 65390, 65170, 65180, 78318, 78288, 77626, 78319, 78321, 78291, 77629, 
78322, 78320, 78289, 77597, 77628
18897, 65400, 65390, 65170, 65180, 65401, 65391, 65171, 65181, 78321, 78291, 77629, 78322, 78324, 78294, 77632, 
78325, 78323, 78292, 77600, 77631
18898, 65401, 65391, 65171, 65181, 65402, 65392, 65172, 65182, 78324, 78294, 77632, 78325, 78327, 78297, 77635, 
78328, 78326, 78295, 77603, 77634
18899, 65402, 65392, 65172, 65182, 18311, 18310, 18288, 18289, 78327, 78297, 77635, 78328, 19189, 19186, 19144, 
19188, 78329, 78298, 77606, 77637
18900, 16816, 16815, 16793, 16794, 65403, 65393, 65173, 65183, 17694, 17693, 17649, 17695, 78331, 78301, 77639, 
78332, 78330, 78299, 77607, 77638
18901, 65403, 65393, 65173, 65183, 65404, 65394, 65174, 65184, 78331, 78301, 77639, 78332, 78334, 78304, 77642, 
78335, 78333, 78302, 77610, 77641
18902, 65404, 65394, 65174, 65184, 65405, 65395, 65175, 65185, 78334, 78304, 77642, 78335, 78337, 78307, 77645, 
78338, 78336, 78305, 77613, 77644
18903, 65405, 65395, 65175, 65185, 65406, 65396, 65176, 65186, 78337, 78307, 77645, 78338, 78340, 78310, 77648, 
78341, 78339, 78308, 77616, 77647
18904, 65406, 65396, 65176, 65186, 65407, 65397, 65177, 65187, 78340, 78310, 77648, 78341, 78343, 78313, 77651, 
78344, 78342, 78311, 77619, 77650
18905, 65407, 65397, 65177, 65187, 65408, 65398, 65178, 65188, 78343, 78313, 77651, 78344, 78346, 78316, 77654, 
78347, 78345, 78314, 77622, 77653
18906, 65408, 65398, 65178, 65188, 65409, 65399, 65179, 65189, 78346, 78316, 77654, 78347, 78349, 78319, 77657, 
78350, 78348, 78317, 77625, 77656
18907, 65409, 65399, 65179, 65189, 65410, 65400, 65180, 65190, 78349, 78319, 77657, 78350, 78352, 78322, 77660, 
78353, 78351, 78320, 77628, 77659
18908, 65410, 65400, 65180, 65190, 65411, 65401, 65181, 65191, 78352, 78322, 77660, 78353, 78355, 78325, 77663, 
78356, 78354, 78323, 77631, 77662
18909, 65411, 65401, 65181, 65191, 65412, 65402, 65182, 65192, 78355, 78325, 77663, 78356, 78358, 78328, 77666, 
78359, 78357, 78326, 77634, 77665
18910, 65412, 65402, 65182, 65192, 18312, 18311, 18289, 18290, 78358, 78328, 77666, 78359, 19191, 19188, 19146, 
19190, 78360, 78329, 77637, 77668
18911, 16817, 16816, 16794, 16795, 65413, 65403, 65183, 65193, 17696, 17695, 17651, 17697, 78362, 78332, 77670, 
78363, 78361, 78330, 77638, 77669
18912, 65413, 65403, 65183, 65193, 65414, 65404, 65184, 65194, 78362, 78332, 77670, 78363, 78365, 78335, 77673, 
78366, 78364, 78333, 77641, 77672
18913, 65414, 65404, 65184, 65194, 65415, 65405, 65185, 65195, 78365, 78335, 77673, 78366, 78368, 78338, 77676, 
78369, 78367, 78336, 77644, 77675
18914, 65415, 65405, 65185, 65195, 65416, 65406, 65186, 65196, 78368, 78338, 77676, 78369, 78371, 78341, 77679, 
78372, 78370, 78339, 77647, 77678
18915, 65416, 65406, 65186, 65196, 65417, 65407, 65187, 65197, 78371, 78341, 77679, 78372, 78374, 78344, 77682, 
78375, 78373, 78342, 77650, 77681
18916, 65417, 65407, 65187, 65197, 65418, 65408, 65188, 65198, 78374, 78344, 77682, 78375, 78377, 78347, 77685, 
78378, 78376, 78345, 77653, 77684
18917, 65418, 65408, 65188, 65198, 65419, 65409, 65189, 65199, 78377, 78347, 77685, 78378, 78380, 78350, 77688, 
78381, 78379, 78348, 77656, 77687
18918, 65419, 65409, 65189, 65199, 65420, 65410, 65190, 65200, 78380, 78350, 77688, 78381, 78383, 78353, 77691, 
78384, 78382, 78351, 77659, 77690
18919, 65420, 65410, 65190, 65200, 65421, 65411, 65191, 65201, 78383, 78353, 77691, 78384, 78386, 78356, 77694, 
78387, 78385, 78354, 77662, 77693
18920, 65421, 65411, 65191, 65201, 65422, 65412, 65192, 65202, 78386, 78356, 77694, 78387, 78389, 78359, 77697, 
78390, 78388, 78357, 77665, 77696
18921, 65422, 65412, 65192, 65202, 18313, 18312, 18290, 18291, 78389, 78359, 77697, 78390, 19193, 19190, 19148, 
19192, 78391, 78360, 77668, 77699
18922, 16818, 16817, 16795, 16796, 65423, 65413, 65193, 65203, 17698, 17697, 17653, 17699, 78393, 78363, 77701, 
78394, 78392, 78361, 77669, 77700
18923, 65423, 65413, 65193, 65203, 65424, 65414, 65194, 65204, 78393, 78363, 77701, 78394, 78396, 78366, 77704, 
78397, 78395, 78364, 77672, 77703
18924, 65424, 65414, 65194, 65204, 65425, 65415, 65195, 65205, 78396, 78366, 77704, 78397, 78399, 78369, 77707, 
78400, 78398, 78367, 77675, 77706
18925, 65425, 65415, 65195, 65205, 65426, 65416, 65196, 65206, 78399, 78369, 77707, 78400, 78402, 78372, 77710, 
78403, 78401, 78370, 77678, 77709
18926, 65426, 65416, 65196, 65206, 65427, 65417, 65197, 65207, 78402, 78372, 77710, 78403, 78405, 78375, 77713, 
78406, 78404, 78373, 77681, 77712
18927, 65427, 65417, 65197, 65207, 65428, 65418, 65198, 65208, 78405, 78375, 77713, 78406, 78408, 78378, 77716, 
78409, 78407, 78376, 77684, 77715
18928, 65428, 65418, 65198, 65208, 65429, 65419, 65199, 65209, 78408, 78378, 77716, 78409, 78411, 78381, 77719, 
78412, 78410, 78379, 77687, 77718
18929, 65429, 65419, 65199, 65209, 65430, 65420, 65200, 65210, 78411, 78381, 77719, 78412, 78414, 78384, 77722, 
78415, 78413, 78382, 77690, 77721
18930, 65430, 65420, 65200, 65210, 65431, 65421, 65201, 65211, 78414, 78384, 77722, 78415, 78417, 78387, 77725, 
78418, 78416, 78385, 77693, 77724
18931, 65431, 65421, 65201, 65211, 65432, 65422, 65202, 65212, 78417, 78387, 77725, 78418, 78420, 78390, 77728, 
78421, 78419, 78388, 77696, 77727
18932, 65432, 65422, 65202, 65212, 18314, 18313, 18291, 18292, 78420, 78390, 77728, 78421, 19195, 19192, 19150, 
19194, 78422, 78391, 77699, 77730
18933, 16819, 16818, 16796, 16797, 65433, 65423, 65203, 65213, 17700, 17699, 17655, 17701, 78424, 78394, 77732, 
78425, 78423, 78392, 77700, 77731
18934, 65433, 65423, 65203, 65213, 65434, 65424, 65204, 65214, 78424, 78394, 77732, 78425, 78427, 78397, 77735, 
78428, 78426, 78395, 77703, 77734
18935, 65434, 65424, 65204, 65214, 65435, 65425, 65205, 65215, 78427, 78397, 77735, 78428, 78430, 78400, 77738, 
78431, 78429, 78398, 77706, 77737
18936, 65435, 65425, 65205, 65215, 65436, 65426, 65206, 65216, 78430, 78400, 77738, 78431, 78433, 78403, 77741, 
78434, 78432, 78401, 77709, 77740
18937, 65436, 65426, 65206, 65216, 65437, 65427, 65207, 65217, 78433, 78403, 77741, 78434, 78436, 78406, 77744, 
78437, 78435, 78404, 77712, 77743
18938, 65437, 65427, 65207, 65217, 65438, 65428, 65208, 65218, 78436, 78406, 77744, 78437, 78439, 78409, 77747, 
78440, 78438, 78407, 77715, 77746
18939, 65438, 65428, 65208, 65218, 65439, 65429, 65209, 65219, 78439, 78409, 77747, 78440, 78442, 78412, 77750, 
78443, 78441, 78410, 77718, 77749
18940, 65439, 65429, 65209, 65219, 65440, 65430, 65210, 65220, 78442, 78412, 77750, 78443, 78445, 78415, 77753, 
78446, 78444, 78413, 77721, 77752
18941, 65440, 65430, 65210, 65220, 65441, 65431, 65211, 65221, 78445, 78415, 77753, 78446, 78448, 78418, 77756, 
78449, 78447, 78416, 77724, 77755
18942, 65441, 65431, 65211, 65221, 65442, 65432, 65212, 65222, 78448, 78418, 77756, 78449, 78451, 78421, 77759, 
78452, 78450, 78419, 77727, 77758
18943, 65442, 65432, 65212, 65222, 18315, 18314, 18292, 18293, 78451, 78421, 77759, 78452, 19197, 19194, 19152, 
19196, 78453, 78422, 77730, 77761
18944, 16820, 16819, 16797, 16798, 65443, 65433, 65213, 65223, 17702, 17701, 17657, 17703, 78455, 78425, 77763, 
78456, 78454, 78423, 77731, 77762
18945, 65443, 65433, 65213, 65223, 65444, 65434, 65214, 65224, 78455, 78425, 77763, 78456, 78458, 78428, 77766, 
78459, 78457, 78426, 77734, 77765
18946, 65444, 65434, 65214, 65224, 65445, 65435, 65215, 65225, 78458, 78428, 77766, 78459, 78461, 78431, 77769, 
78462, 78460, 78429, 77737, 77768
18947, 65445, 65435, 65215, 65225, 65446, 65436, 65216, 65226, 78461, 78431, 77769, 78462, 78464, 78434, 77772, 
78465, 78463, 78432, 77740, 77771
18948, 65446, 65436, 65216, 65226, 65447, 65437, 65217, 65227, 78464, 78434, 77772, 78465, 78467, 78437, 77775, 
78468, 78466, 78435, 77743, 77774
18949, 65447, 65437, 65217, 65227, 65448, 65438, 65218, 65228, 78467, 78437, 77775, 78468, 78470, 78440, 77778, 
78471, 78469, 78438, 77746, 77777
18950, 65448, 65438, 65218, 65228, 65449, 65439, 65219, 65229, 78470, 78440, 77778, 78471, 78473, 78443, 77781, 
78474, 78472, 78441, 77749, 77780
18951, 65449, 65439, 65219, 65229, 65450, 65440, 65220, 65230, 78473, 78443, 77781, 78474, 78476, 78446, 77784, 
78477, 78475, 78444, 77752, 77783
18952, 65450, 65440, 65220, 65230, 65451, 65441, 65221, 65231, 78476, 78446, 77784, 78477, 78479, 78449, 77787, 
78480, 78478, 78447, 77755, 77786
18953, 65451, 65441, 65221, 65231, 65452, 65442, 65222, 65232, 78479, 78449, 77787, 78480, 78482, 78452, 77790, 
78483, 78481, 78450, 77758, 77789
18954, 65452, 65442, 65222, 65232, 18316, 18315, 18293, 18294, 78482, 78452, 77790, 78483, 19199, 19196, 19154, 
19198, 78484, 78453, 77761, 77792
18955, 16821, 16820, 16798, 16799, 65453, 65443, 65223, 65233, 17704, 17703, 17659, 17705, 78486, 78456, 77794, 
78487, 78485, 78454, 77762, 77793
18956, 65453, 65443, 65223, 65233, 65454, 65444, 65224, 65234, 78486, 78456, 77794, 78487, 78489, 78459, 77797, 
78490, 78488, 78457, 77765, 77796
18957, 65454, 65444, 65224, 65234, 65455, 65445, 65225, 65235, 78489, 78459, 77797, 78490, 78492, 78462, 77800, 
78493, 78491, 78460, 77768, 77799
18958, 65455, 65445, 65225, 65235, 65456, 65446, 65226, 65236, 78492, 78462, 77800, 78493, 78495, 78465, 77803, 
78496, 78494, 78463, 77771, 77802
18959, 65456, 65446, 65226, 65236, 65457, 65447, 65227, 65237, 78495, 78465, 77803, 78496, 78498, 78468, 77806, 
78499, 78497, 78466, 77774, 77805
18960, 65457, 65447, 65227, 65237, 65458, 65448, 65228, 65238, 78498, 78468, 77806, 78499, 78501, 78471, 77809, 
78502, 78500, 78469, 77777, 77808
18961, 65458, 65448, 65228, 65238, 65459, 65449, 65229, 65239, 78501, 78471, 77809, 78502, 78504, 78474, 77812, 
78505, 78503, 78472, 77780, 77811
18962, 65459, 65449, 65229, 65239, 65460, 65450, 65230, 65240, 78504, 78474, 77812, 78505, 78507, 78477, 77815, 
78508, 78506, 78475, 77783, 77814
18963, 65460, 65450, 65230, 65240, 65461, 65451, 65231, 65241, 78507, 78477, 77815, 78508, 78510, 78480, 77818, 
78511, 78509, 78478, 77786, 77817
18964, 65461, 65451, 65231, 65241, 65462, 65452, 65232, 65242, 78510, 78480, 77818, 78511, 78513, 78483, 77821, 
78514, 78512, 78481, 77789, 77820
18965, 65462, 65452, 65232, 65242, 18317, 18316, 18294, 18295, 78513, 78483, 77821, 78514, 19201, 19198, 19156, 
19200, 78515, 78484, 77792, 77823
18966, 16822, 16821, 16799, 16800, 65463, 65453, 65233, 65243, 17706, 17705, 17661, 17707, 78517, 78487, 77825, 
78518, 78516, 78485, 77793, 77824
18967, 65463, 65453, 65233, 65243, 65464, 65454, 65234, 65244, 78517, 78487, 77825, 78518, 78520, 78490, 77828, 
78521, 78519, 78488, 77796, 77827
18968, 65464, 65454, 65234, 65244, 65465, 65455, 65235, 65245, 78520, 78490, 77828, 78521, 78523, 78493, 77831, 
78524, 78522, 78491, 77799, 77830
18969, 65465, 65455, 65235, 65245, 65466, 65456, 65236, 65246, 78523, 78493, 77831, 78524, 78526, 78496, 77834, 
78527, 78525, 78494, 77802, 77833
18970, 65466, 65456, 65236, 65246, 65467, 65457, 65237, 65247, 78526, 78496, 77834, 78527, 78529, 78499, 77837, 
78530, 78528, 78497, 77805, 77836
18971, 65467, 65457, 65237, 65247, 65468, 65458, 65238, 65248, 78529, 78499, 77837, 78530, 78532, 78502, 77840, 
78533, 78531, 78500, 77808, 77839
18972, 65468, 65458, 65238, 65248, 65469, 65459, 65239, 65249, 78532, 78502, 77840, 78533, 78535, 78505, 77843, 
78536, 78534, 78503, 77811, 77842
18973, 65469, 65459, 65239, 65249, 65470, 65460, 65240, 65250, 78535, 78505, 77843, 78536, 78538, 78508, 77846, 
78539, 78537, 78506, 77814, 77845
18974, 65470, 65460, 65240, 65250, 65471, 65461, 65241, 65251, 78538, 78508, 77846, 78539, 78541, 78511, 77849, 
78542, 78540, 78509, 77817, 77848
18975, 65471, 65461, 65241, 65251, 65472, 65462, 65242, 65252, 78541, 78511, 77849, 78542, 78544, 78514, 77852, 
78545, 78543, 78512, 77820, 77851
18976, 65472, 65462, 65242, 65252, 18318, 18317, 18295, 18296, 78544, 78514, 77852, 78545, 19203, 19200, 19158, 
19202, 78546, 78515, 77823, 77854
18977, 16823, 16822, 16800, 16801, 65473, 65463, 65243, 65253, 17708, 17707, 17663, 17709, 78548, 78518, 77856, 
78549, 78547, 78516, 77824, 77855
18978, 65473, 65463, 65243, 65253, 65474, 65464, 65244, 65254, 78548, 78518, 77856, 78549, 78551, 78521, 77859, 
78552, 78550, 78519, 77827, 77858
18979, 65474, 65464, 65244, 65254, 65475, 65465, 65245, 65255, 78551, 78521, 77859, 78552, 78554, 78524, 77862, 
78555, 78553, 78522, 77830, 77861
18980, 65475, 65465, 65245, 65255, 65476, 65466, 65246, 65256, 78554, 78524, 77862, 78555, 78557, 78527, 77865, 
78558, 78556, 78525, 77833, 77864
18981, 65476, 65466, 65246, 65256, 65477, 65467, 65247, 65257, 78557, 78527, 77865, 78558, 78560, 78530, 77868, 
78561, 78559, 78528, 77836, 77867
18982, 65477, 65467, 65247, 65257, 65478, 65468, 65248, 65258, 78560, 78530, 77868, 78561, 78563, 78533, 77871, 
78564, 78562, 78531, 77839, 77870
18983, 65478, 65468, 65248, 65258, 65479, 65469, 65249, 65259, 78563, 78533, 77871, 78564, 78566, 78536, 77874, 
78567, 78565, 78534, 77842, 77873
18984, 65479, 65469, 65249, 65259, 65480, 65470, 65250, 65260, 78566, 78536, 77874, 78567, 78569, 78539, 77877, 
78570, 78568, 78537, 77845, 77876
18985, 65480, 65470, 65250, 65260, 65481, 65471, 65251, 65261, 78569, 78539, 77877, 78570, 78572, 78542, 77880, 
78573, 78571, 78540, 77848, 77879
18986, 65481, 65471, 65251, 65261, 65482, 65472, 65252, 65262, 78572, 78542, 77880, 78573, 78575, 78545, 77883, 
78576, 78574, 78543, 77851, 77882
18987, 65482, 65472, 65252, 65262, 18319, 18318, 18296, 18297, 78575, 78545, 77883, 78576, 19205, 19202, 19160, 
19204, 78577, 78546, 77854, 77885
18988, 16824, 16823, 16801, 16802, 65483, 65473, 65253, 65263, 17710, 17709, 17665, 17711, 78579, 78549, 77887, 
78580, 78578, 78547, 77855, 77886
18989, 65483, 65473, 65253, 65263, 65484, 65474, 65254, 65264, 78579, 78549, 77887, 78580, 78582, 78552, 77890, 
78583, 78581, 78550, 77858, 77889
18990, 65484, 65474, 65254, 65264, 65485, 65475, 65255, 65265, 78582, 78552, 77890, 78583, 78585, 78555, 77893, 
78586, 78584, 78553, 77861, 77892
18991, 65485, 65475, 65255, 65265, 65486, 65476, 65256, 65266, 78585, 78555, 77893, 78586, 78588, 78558, 77896, 
78589, 78587, 78556, 77864, 77895
18992, 65486, 65476, 65256, 65266, 65487, 65477, 65257, 65267, 78588, 78558, 77896, 78589, 78591, 78561, 77899, 
78592, 78590, 78559, 77867, 77898
18993, 65487, 65477, 65257, 65267, 65488, 65478, 65258, 65268, 78591, 78561, 77899, 78592, 78594, 78564, 77902, 
78595, 78593, 78562, 77870, 77901
18994, 65488, 65478, 65258, 65268, 65489, 65479, 65259, 65269, 78594, 78564, 77902, 78595, 78597, 78567, 77905, 
78598, 78596, 78565, 77873, 77904
18995, 65489, 65479, 65259, 65269, 65490, 65480, 65260, 65270, 78597, 78567, 77905, 78598, 78600, 78570, 77908, 
78601, 78599, 78568, 77876, 77907
18996, 65490, 65480, 65260, 65270, 65491, 65481, 65261, 65271, 78600, 78570, 77908, 78601, 78603, 78573, 77911, 
78604, 78602, 78571, 77879, 77910
18997, 65491, 65481, 65261, 65271, 65492, 65482, 65262, 65272, 78603, 78573, 77911, 78604, 78606, 78576, 77914, 
78607, 78605, 78574, 77882, 77913
18998, 65492, 65482, 65262, 65272, 18320, 18319, 18297, 18298, 78606, 78576, 77914, 78607, 19207, 19204, 19162, 
19206, 78608, 78577, 77885, 77916
18999, 16825, 16824, 16802, 16803, 65493, 65483, 65263, 65273, 17712, 17711, 17667, 17713, 78610, 78580, 77918, 
78611, 78609, 78578, 77886, 77917
19000, 65493, 65483, 65263, 65273, 65494, 65484, 65264, 65274, 78610, 78580, 77918, 78611, 78613, 78583, 77921, 
78614, 78612, 78581, 77889, 77920
19001, 65494, 65484, 65264, 65274, 65495, 65485, 65265, 65275, 78613, 78583, 77921, 78614, 78616, 78586, 77924, 
78617, 78615, 78584, 77892, 77923
19002, 65495, 65485, 65265, 65275, 65496, 65486, 65266, 65276, 78616, 78586, 77924, 78617, 78619, 78589, 77927, 
78620, 78618, 78587, 77895, 77926
19003, 65496, 65486, 65266, 65276, 65497, 65487, 65267, 65277, 78619, 78589, 77927, 78620, 78622, 78592, 77930, 
78623, 78621, 78590, 77898, 77929
19004, 65497, 65487, 65267, 65277, 65498, 65488, 65268, 65278, 78622, 78592, 77930, 78623, 78625, 78595, 77933, 
78626, 78624, 78593, 77901, 77932
19005, 65498, 65488, 65268, 65278, 65499, 65489, 65269, 65279, 78625, 78595, 77933, 78626, 78628, 78598, 77936, 
78629, 78627, 78596, 77904, 77935
19006, 65499, 65489, 65269, 65279, 65500, 65490, 65270, 65280, 78628, 78598, 77936, 78629, 78631, 78601, 77939, 
78632, 78630, 78599, 77907, 77938
19007, 65500, 65490, 65270, 65280, 65501, 65491, 65271, 65281, 78631, 78601, 77939, 78632, 78634, 78604, 77942, 
78635, 78633, 78602, 77910, 77941
19008, 65501, 65491, 65271, 65281, 65502, 65492, 65272, 65282, 78634, 78604, 77942, 78635, 78637, 78607, 77945, 
78638, 78636, 78605, 77913, 77944
19009, 65502, 65492, 65272, 65282, 18321, 18320, 18298, 18299, 78637, 78607, 77945, 78638, 19209, 19206, 19164, 
19208, 78639, 78608, 77916, 77947
19010, 16826, 16825, 16803, 16804, 65503, 65493, 65273, 65283, 17714, 17713, 17669, 17715, 78641, 78611, 77949, 
78642, 78640, 78609, 77917, 77948
19011, 65503, 65493, 65273, 65283, 65504, 65494, 65274, 65284, 78641, 78611, 77949, 78642, 78644, 78614, 77952, 
78645, 78643, 78612, 77920, 77951
19012, 65504, 65494, 65274, 65284, 65505, 65495, 65275, 65285, 78644, 78614, 77952, 78645, 78647, 78617, 77955, 
78648, 78646, 78615, 77923, 77954
19013, 65505, 65495, 65275, 65285, 65506, 65496, 65276, 65286, 78647, 78617, 77955, 78648, 78650, 78620, 77958, 
78651, 78649, 78618, 77926, 77957
19014, 65506, 65496, 65276, 65286, 65507, 65497, 65277, 65287, 78650, 78620, 77958, 78651, 78653, 78623, 77961, 
78654, 78652, 78621, 77929, 77960
19015, 65507, 65497, 65277, 65287, 65508, 65498, 65278, 65288, 78653, 78623, 77961, 78654, 78656, 78626, 77964, 
78657, 78655, 78624, 77932, 77963
19016, 65508, 65498, 65278, 65288, 65509, 65499, 65279, 65289, 78656, 78626, 77964, 78657, 78659, 78629, 77967, 
78660, 78658, 78627, 77935, 77966
19017, 65509, 65499, 65279, 65289, 65510, 65500, 65280, 65290, 78659, 78629, 77967, 78660, 78662, 78632, 77970, 
78663, 78661, 78630, 77938, 77969
19018, 65510, 65500, 65280, 65290, 65511, 65501, 65281, 65291, 78662, 78632, 77970, 78663, 78665, 78635, 77973, 
78666, 78664, 78633, 77941, 77972
19019, 65511, 65501, 65281, 65291, 65512, 65502, 65282, 65292, 78665, 78635, 77973, 78666, 78668, 78638, 77976, 
78669, 78667, 78636, 77944, 77975
19020, 65512, 65502, 65282, 65292, 18322, 18321, 18299, 18300, 78668, 78638, 77976, 78669, 19211, 19208, 19166, 
19210, 78670, 78639, 77947, 77978
19021, 16827, 16826, 16804, 16805, 65513, 65503, 65283, 65293, 17716, 17715, 17671, 17717, 78672, 78642, 77980, 
78673, 78671, 78640, 77948, 77979
19022, 65513, 65503, 65283, 65293, 65514, 65504, 65284, 65294, 78672, 78642, 77980, 78673, 78675, 78645, 77983, 
78676, 78674, 78643, 77951, 77982
19023, 65514, 65504, 65284, 65294, 65515, 65505, 65285, 65295, 78675, 78645, 77983, 78676, 78678, 78648, 77986, 
78679, 78677, 78646, 77954, 77985
19024, 65515, 65505, 65285, 65295, 65516, 65506, 65286, 65296, 78678, 78648, 77986, 78679, 78681, 78651, 77989, 
78682, 78680, 78649, 77957, 77988
19025, 65516, 65506, 65286, 65296, 65517, 65507, 65287, 65297, 78681, 78651, 77989, 78682, 78684, 78654, 77992, 
78685, 78683, 78652, 77960, 77991
19026, 65517, 65507, 65287, 65297, 65518, 65508, 65288, 65298, 78684, 78654, 77992, 78685, 78687, 78657, 77995, 
78688, 78686, 78655, 77963, 77994
19027, 65518, 65508, 65288, 65298, 65519, 65509, 65289, 65299, 78687, 78657, 77995, 78688, 78690, 78660, 77998, 
78691, 78689, 78658, 77966, 77997
19028, 65519, 65509, 65289, 65299, 65520, 65510, 65290, 65300, 78690, 78660, 77998, 78691, 78693, 78663, 78001, 
78694, 78692, 78661, 77969, 78000
19029, 65520, 65510, 65290, 65300, 65521, 65511, 65291, 65301, 78693, 78663, 78001, 78694, 78696, 78666, 78004, 
78697, 78695, 78664, 77972, 78003
19030, 65521, 65511, 65291, 65301, 65522, 65512, 65292, 65302, 78696, 78666, 78004, 78697, 78699, 78669, 78007, 
78700, 78698, 78667, 77975, 78006
19031, 65522, 65512, 65292, 65302, 18323, 18322, 18300, 18301, 78699, 78669, 78007, 78700, 19213, 19210, 19168, 
19212, 78701, 78670, 77978, 78009
19032, 16828, 16827, 16805, 16806, 65523, 65513, 65293, 65303, 17718, 17717, 17673, 17719, 78703, 78673, 78011, 
78704, 78702, 78671, 77979, 78010
19033, 65523, 65513, 65293, 65303, 65524, 65514, 65294, 65304, 78703, 78673, 78011, 78704, 78706, 78676, 78014, 
78707, 78705, 78674, 77982, 78013
19034, 65524, 65514, 65294, 65304, 65525, 65515, 65295, 65305, 78706, 78676, 78014, 78707, 78709, 78679, 78017, 
78710, 78708, 78677, 77985, 78016
19035, 65525, 65515, 65295, 65305, 65526, 65516, 65296, 65306, 78709, 78679, 78017, 78710, 78712, 78682, 78020, 
78713, 78711, 78680, 77988, 78019
19036, 65526, 65516, 65296, 65306, 65527, 65517, 65297, 65307, 78712, 78682, 78020, 78713, 78715, 78685, 78023, 
78716, 78714, 78683, 77991, 78022
19037, 65527, 65517, 65297, 65307, 65528, 65518, 65298, 65308, 78715, 78685, 78023, 78716, 78718, 78688, 78026, 
78719, 78717, 78686, 77994, 78025
19038, 65528, 65518, 65298, 65308, 65529, 65519, 65299, 65309, 78718, 78688, 78026, 78719, 78721, 78691, 78029, 
78722, 78720, 78689, 77997, 78028
19039, 65529, 65519, 65299, 65309, 65530, 65520, 65300, 65310, 78721, 78691, 78029, 78722, 78724, 78694, 78032, 
78725, 78723, 78692, 78000, 78031
19040, 65530, 65520, 65300, 65310, 65531, 65521, 65301, 65311, 78724, 78694, 78032, 78725, 78727, 78697, 78035, 
78728, 78726, 78695, 78003, 78034
19041, 65531, 65521, 65301, 65311, 65532, 65522, 65302, 65312, 78727, 78697, 78035, 78728, 78730, 78700, 78038, 
78731, 78729, 78698, 78006, 78037
19042, 65532, 65522, 65302, 65312, 18324, 18323, 18301, 18302, 78730, 78700, 78038, 78731, 19215, 19212, 19170, 
19214, 78732, 78701, 78009, 78040
19043, 16829, 16828, 16806, 16807, 65533, 65523, 65303, 65313, 17720, 17719, 17675, 17721, 78734, 78704, 78042, 
78735, 78733, 78702, 78010, 78041
19044, 65533, 65523, 65303, 65313, 65534, 65524, 65304, 65314, 78734, 78704, 78042, 78735, 78737, 78707, 78045, 
78738, 78736, 78705, 78013, 78044
19045, 65534, 65524, 65304, 65314, 65535, 65525, 65305, 65315, 78737, 78707, 78045, 78738, 78740, 78710, 78048, 
78741, 78739, 78708, 78016, 78047
19046, 65535, 65525, 65305, 65315, 65536, 65526, 65306, 65316, 78740, 78710, 78048, 78741, 78743, 78713, 78051, 
78744, 78742, 78711, 78019, 78050
19047, 65536, 65526, 65306, 65316, 65537, 65527, 65307, 65317, 78743, 78713, 78051, 78744, 78746, 78716, 78054, 
78747, 78745, 78714, 78022, 78053
19048, 65537, 65527, 65307, 65317, 65538, 65528, 65308, 65318, 78746, 78716, 78054, 78747, 78749, 78719, 78057, 
78750, 78748, 78717, 78025, 78056
19049, 65538, 65528, 65308, 65318, 65539, 65529, 65309, 65319, 78749, 78719, 78057, 78750, 78752, 78722, 78060, 
78753, 78751, 78720, 78028, 78059
19050, 65539, 65529, 65309, 65319, 65540, 65530, 65310, 65320, 78752, 78722, 78060, 78753, 78755, 78725, 78063, 
78756, 78754, 78723, 78031, 78062
19051, 65540, 65530, 65310, 65320, 65541, 65531, 65311, 65321, 78755, 78725, 78063, 78756, 78758, 78728, 78066, 
78759, 78757, 78726, 78034, 78065
19052, 65541, 65531, 65311, 65321, 65542, 65532, 65312, 65322, 78758, 78728, 78066, 78759, 78761, 78731, 78069, 
78762, 78760, 78729, 78037, 78068
19053, 65542, 65532, 65312, 65322, 18325, 18324, 18302, 18303, 78761, 78731, 78069, 78762, 19217, 19214, 19172, 
19216, 78763, 78732, 78040, 78071
19054, 16830, 16829, 16807, 16808, 65543, 65533, 65313, 65323, 17722, 17721, 17677, 17723, 78765, 78735, 78073, 
78766, 78764, 78733, 78041, 78072
19055, 65543, 65533, 65313, 65323, 65544, 65534, 65314, 65324, 78765, 78735, 78073, 78766, 78768, 78738, 78076, 
78769, 78767, 78736, 78044, 78075
19056, 65544, 65534, 65314, 65324, 65545, 65535, 65315, 65325, 78768, 78738, 78076, 78769, 78771, 78741, 78079, 
78772, 78770, 78739, 78047, 78078
19057, 65545, 65535, 65315, 65325, 65546, 65536, 65316, 65326, 78771, 78741, 78079, 78772, 78774, 78744, 78082, 
78775, 78773, 78742, 78050, 78081
19058, 65546, 65536, 65316, 65326, 65547, 65537, 65317, 65327, 78774, 78744, 78082, 78775, 78777, 78747, 78085, 
78778, 78776, 78745, 78053, 78084
19059, 65547, 65537, 65317, 65327, 65548, 65538, 65318, 65328, 78777, 78747, 78085, 78778, 78780, 78750, 78088, 
78781, 78779, 78748, 78056, 78087
19060, 65548, 65538, 65318, 65328, 65549, 65539, 65319, 65329, 78780, 78750, 78088, 78781, 78783, 78753, 78091, 
78784, 78782, 78751, 78059, 78090
19061, 65549, 65539, 65319, 65329, 65550, 65540, 65320, 65330, 78783, 78753, 78091, 78784, 78786, 78756, 78094, 
78787, 78785, 78754, 78062, 78093
19062, 65550, 65540, 65320, 65330, 65551, 65541, 65321, 65331, 78786, 78756, 78094, 78787, 78789, 78759, 78097, 
78790, 78788, 78757, 78065, 78096
19063, 65551, 65541, 65321, 65331, 65552, 65542, 65322, 65332, 78789, 78759, 78097, 78790, 78792, 78762, 78100, 
78793, 78791, 78760, 78068, 78099
19064, 65552, 65542, 65322, 65332, 18326, 18325, 18303, 18304, 78792, 78762, 78100, 78793, 19219, 19216, 19174, 
19218, 78794, 78763, 78071, 78102
19065, 16831, 16830, 16808, 16809, 65553, 65543, 65323, 65333, 17724, 17723, 17679, 17725, 78796, 78766, 78104, 
78797, 78795, 78764, 78072, 78103
19066, 65553, 65543, 65323, 65333, 65554, 65544, 65324, 65334, 78796, 78766, 78104, 78797, 78799, 78769, 78107, 
78800, 78798, 78767, 78075, 78106
19067, 65554, 65544, 65324, 65334, 65555, 65545, 65325, 65335, 78799, 78769, 78107, 78800, 78802, 78772, 78110, 
78803, 78801, 78770, 78078, 78109
19068, 65555, 65545, 65325, 65335, 65556, 65546, 65326, 65336, 78802, 78772, 78110, 78803, 78805, 78775, 78113, 
78806, 78804, 78773, 78081, 78112
19069, 65556, 65546, 65326, 65336, 65557, 65547, 65327, 65337, 78805, 78775, 78113, 78806, 78808, 78778, 78116, 
78809, 78807, 78776, 78084, 78115
19070, 65557, 65547, 65327, 65337, 65558, 65548, 65328, 65338, 78808, 78778, 78116, 78809, 78811, 78781, 78119, 
78812, 78810, 78779, 78087, 78118
19071, 65558, 65548, 65328, 65338, 65559, 65549, 65329, 65339, 78811, 78781, 78119, 78812, 78814, 78784, 78122, 
78815, 78813, 78782, 78090, 78121
19072, 65559, 65549, 65329, 65339, 65560, 65550, 65330, 65340, 78814, 78784, 78122, 78815, 78817, 78787, 78125, 
78818, 78816, 78785, 78093, 78124
19073, 65560, 65550, 65330, 65340, 65561, 65551, 65331, 65341, 78817, 78787, 78125, 78818, 78820, 78790, 78128, 
78821, 78819, 78788, 78096, 78127
19074, 65561, 65551, 65331, 65341, 65562, 65552, 65332, 65342, 78820, 78790, 78128, 78821, 78823, 78793, 78131, 
78824, 78822, 78791, 78099, 78130
19075, 65562, 65552, 65332, 65342, 18327, 18326, 18304, 18305, 78823, 78793, 78131, 78824, 19221, 19218, 19176, 
19220, 78825, 78794, 78102, 78133
19076, 16832, 16831, 16809, 16810, 65563, 65553, 65333, 65343, 17726, 17725, 17681, 17727, 78827, 78797, 78135, 
78828, 78826, 78795, 78103, 78134
19077, 65563, 65553, 65333, 65343, 65564, 65554, 65334, 65344, 78827, 78797, 78135, 78828, 78830, 78800, 78138, 
78831, 78829, 78798, 78106, 78137
19078, 65564, 65554, 65334, 65344, 65565, 65555, 65335, 65345, 78830, 78800, 78138, 78831, 78833, 78803, 78141, 
78834, 78832, 78801, 78109, 78140
19079, 65565, 65555, 65335, 65345, 65566, 65556, 65336, 65346, 78833, 78803, 78141, 78834, 78836, 78806, 78144, 
78837, 78835, 78804, 78112, 78143
19080, 65566, 65556, 65336, 65346, 65567, 65557, 65337, 65347, 78836, 78806, 78144, 78837, 78839, 78809, 78147, 
78840, 78838, 78807, 78115, 78146
19081, 65567, 65557, 65337, 65347, 65568, 65558, 65338, 65348, 78839, 78809, 78147, 78840, 78842, 78812, 78150, 
78843, 78841, 78810, 78118, 78149
19082, 65568, 65558, 65338, 65348, 65569, 65559, 65339, 65349, 78842, 78812, 78150, 78843, 78845, 78815, 78153, 
78846, 78844, 78813, 78121, 78152
19083, 65569, 65559, 65339, 65349, 65570, 65560, 65340, 65350, 78845, 78815, 78153, 78846, 78848, 78818, 78156, 
78849, 78847, 78816, 78124, 78155
19084, 65570, 65560, 65340, 65350, 65571, 65561, 65341, 65351, 78848, 78818, 78156, 78849, 78851, 78821, 78159, 
78852, 78850, 78819, 78127, 78158
19085, 65571, 65561, 65341, 65351, 65572, 65562, 65342, 65352, 78851, 78821, 78159, 78852, 78854, 78824, 78162, 
78855, 78853, 78822, 78130, 78161
19086, 65572, 65562, 65342, 65352, 18328, 18327, 18305, 18306, 78854, 78824, 78162, 78855, 19223, 19220, 19178, 
19222, 78856, 78825, 78133, 78164
19087, 16833, 16832, 16810, 16811, 65573, 65563, 65343, 65353, 17728, 17727, 17683, 17729, 78858, 78828, 78166, 
78859, 78857, 78826, 78134, 78165
19088, 65573, 65563, 65343, 65353, 65574, 65564, 65344, 65354, 78858, 78828, 78166, 78859, 78861, 78831, 78169, 
78862, 78860, 78829, 78137, 78168
19089, 65574, 65564, 65344, 65354, 65575, 65565, 65345, 65355, 78861, 78831, 78169, 78862, 78864, 78834, 78172, 
78865, 78863, 78832, 78140, 78171
19090, 65575, 65565, 65345, 65355, 65576, 65566, 65346, 65356, 78864, 78834, 78172, 78865, 78867, 78837, 78175, 
78868, 78866, 78835, 78143, 78174
19091, 65576, 65566, 65346, 65356, 65577, 65567, 65347, 65357, 78867, 78837, 78175, 78868, 78870, 78840, 78178, 
78871, 78869, 78838, 78146, 78177
19092, 65577, 65567, 65347, 65357, 65578, 65568, 65348, 65358, 78870, 78840, 78178, 78871, 78873, 78843, 78181, 
78874, 78872, 78841, 78149, 78180
19093, 65578, 65568, 65348, 65358, 65579, 65569, 65349, 65359, 78873, 78843, 78181, 78874, 78876, 78846, 78184, 
78877, 78875, 78844, 78152, 78183
19094, 65579, 65569, 65349, 65359, 65580, 65570, 65350, 65360, 78876, 78846, 78184, 78877, 78879, 78849, 78187, 
78880, 78878, 78847, 78155, 78186
19095, 65580, 65570, 65350, 65360, 65581, 65571, 65351, 65361, 78879, 78849, 78187, 78880, 78882, 78852, 78190, 
78883, 78881, 78850, 78158, 78189
19096, 65581, 65571, 65351, 65361, 65582, 65572, 65352, 65362, 78882, 78852, 78190, 78883, 78885, 78855, 78193, 
78886, 78884, 78853, 78161, 78192
19097, 65582, 65572, 65352, 65362, 18329, 18328, 18306, 18307, 78885, 78855, 78193, 78886, 19225, 19222, 19180, 
19224, 78887, 78856, 78164, 78195
19098, 16834, 16833, 16811, 16812, 65583, 65573, 65353, 65363, 17730, 17729, 17685, 17731, 78889, 78859, 78197, 
78890, 78888, 78857, 78165, 78196
19099, 65583, 65573, 65353, 65363, 65584, 65574, 65354, 65364, 78889, 78859, 78197, 78890, 78892, 78862, 78200, 
78893, 78891, 78860, 78168, 78199
19100, 65584, 65574, 65354, 65364, 65585, 65575, 65355, 65365, 78892, 78862, 78200, 78893, 78895, 78865, 78203, 
78896, 78894, 78863, 78171, 78202
19101, 65585, 65575, 65355, 65365, 65586, 65576, 65356, 65366, 78895, 78865, 78203, 78896, 78898, 78868, 78206, 
78899, 78897, 78866, 78174, 78205
19102, 65586, 65576, 65356, 65366, 65587, 65577, 65357, 65367, 78898, 78868, 78206, 78899, 78901, 78871, 78209, 
78902, 78900, 78869, 78177, 78208
19103, 65587, 65577, 65357, 65367, 65588, 65578, 65358, 65368, 78901, 78871, 78209, 78902, 78904, 78874, 78212, 
78905, 78903, 78872, 78180, 78211
19104, 65588, 65578, 65358, 65368, 65589, 65579, 65359, 65369, 78904, 78874, 78212, 78905, 78907, 78877, 78215, 
78908, 78906, 78875, 78183, 78214
19105, 65589, 65579, 65359, 65369, 65590, 65580, 65360, 65370, 78907, 78877, 78215, 78908, 78910, 78880, 78218, 
78911, 78909, 78878, 78186, 78217
19106, 65590, 65580, 65360, 65370, 65591, 65581, 65361, 65371, 78910, 78880, 78218, 78911, 78913, 78883, 78221, 
78914, 78912, 78881, 78189, 78220
19107, 65591, 65581, 65361, 65371, 65592, 65582, 65362, 65372, 78913, 78883, 78221, 78914, 78916, 78886, 78224, 
78917, 78915, 78884, 78192, 78223
19108, 65592, 65582, 65362, 65372, 18330, 18329, 18307, 18308, 78916, 78886, 78224, 78917, 19227, 19224, 19182, 
19226, 78918, 78887, 78195, 78226
19109, 1651, 16834, 16812, 1650, 20293, 65583, 65363, 20283, 17732, 17731, 17687, 1673, 78919, 78890, 78227, 
20701, 20700, 78888, 78196, 20679
19110, 20293, 65583, 65363, 20283, 20294, 65584, 65364, 20284, 78919, 78890, 78227, 20701, 78920, 78893, 78228, 
20703, 20702, 78891, 78199, 20681
19111, 20294, 65584, 65364, 20284, 20295, 65585, 65365, 20285, 78920, 78893, 78228, 20703, 78921, 78896, 78229, 
20705, 20704, 78894, 78202, 20683
19112, 20295, 65585, 65365, 20285, 20296, 65586, 65366, 20286, 78921, 78896, 78229, 20705, 78922, 78899, 78230, 
20707, 20706, 78897, 78205, 20685
19113, 20296, 65586, 65366, 20286, 20297, 65587, 65367, 20287, 78922, 78899, 78230, 20707, 78923, 78902, 78231, 
20709, 20708, 78900, 78208, 20687
19114, 20297, 65587, 65367, 20287, 20298, 65588, 65368, 20288, 78923, 78902, 78231, 20709, 78924, 78905, 78232, 
20711, 20710, 78903, 78211, 20689
19115, 20298, 65588, 65368, 20288, 20299, 65589, 65369, 20289, 78924, 78905, 78232, 20711, 78925, 78908, 78233, 
20713, 20712, 78906, 78214, 20691
19116, 20299, 65589, 65369, 20289, 20300, 65590, 65370, 20290, 78925, 78908, 78233, 20713, 78926, 78911, 78234, 
20715, 20714, 78909, 78217, 20693
19117, 20300, 65590, 65370, 20290, 20301, 65591, 65371, 20291, 78926, 78911, 78234, 20715, 78927, 78914, 78235, 
20717, 20716, 78912, 78220, 20695
19118, 20301, 65591, 65371, 20291, 20302, 65592, 65372, 20292, 78927, 78914, 78235, 20717, 78928, 78917, 78236, 
20719, 20718, 78915, 78223, 20697
19119, 20302, 65592, 65372, 20292, 1786, 18330, 18308, 1785, 78928, 78917, 78236, 20719, 19228, 19226, 19183, 
1808, 20720, 78918, 78226, 20699
19120, 16835, 1607, 1606, 16813, 65593, 19611, 19601, 65373, 17733, 1629, 17688, 17734, 78930, 20029, 78238, 
78931, 78929, 20030, 20009, 78237
19121, 65593, 19611, 19601, 65373, 65594, 19612, 19602, 65374, 78930, 20029, 78238, 78931, 78933, 20031, 78241, 
78934, 78932, 20032, 20011, 78240
19122, 65594, 19612, 19602, 65374, 65595, 19613, 19603, 65375, 78933, 20031, 78241, 78934, 78936, 20033, 78244, 
78937, 78935, 20034, 20013, 78243
19123, 65595, 19613, 19603, 65375, 65596, 19614, 19604, 65376, 78936, 20033, 78244, 78937, 78939, 20035, 78247, 
78940, 78938, 20036, 20015, 78246
19124, 65596, 19614, 19604, 65376, 65597, 19615, 19605, 65377, 78939, 20035, 78247, 78940, 78942, 20037, 78250, 
78943, 78941, 20038, 20017, 78249
19125, 65597, 19615, 19605, 65377, 65598, 19616, 19606, 65378, 78942, 20037, 78250, 78943, 78945, 20039, 78253, 
78946, 78944, 20040, 20019, 78252
19126, 65598, 19616, 19606, 65378, 65599, 19617, 19607, 65379, 78945, 20039, 78253, 78946, 78948, 20041, 78256, 
78949, 78947, 20042, 20021, 78255
19127, 65599, 19617, 19607, 65379, 65600, 19618, 19608, 65380, 78948, 20041, 78256, 78949, 78951, 20043, 78259, 
78952, 78950, 20044, 20023, 78258
19128, 65600, 19618, 19608, 65380, 65601, 19619, 19609, 65381, 78951, 20043, 78259, 78952, 78954, 20045, 78262, 
78955, 78953, 20046, 20025, 78261
19129, 65601, 19619, 19609, 65381, 65602, 19620, 19610, 65382, 78954, 20045, 78262, 78955, 78957, 20047, 78265, 
78958, 78956, 20048, 20027, 78264
19130, 65602, 19620, 19610, 65382, 18331, 1742, 1741, 18309, 78957, 20047, 78265, 78958, 19230, 1764, 19185, 
19229, 78959, 20049, 20028, 78267
19131, 16836, 16835, 16813, 16814, 65603, 65593, 65373, 65383, 17735, 17734, 17690, 17736, 78961, 78931, 78269, 
78962, 78960, 78929, 78237, 78268
19132, 65603, 65593, 65373, 65383, 65604, 65594, 65374, 65384, 78961, 78931, 78269, 78962, 78964, 78934, 78272, 
78965, 78963, 78932, 78240, 78271
19133, 65604, 65594, 65374, 65384, 65605, 65595, 65375, 65385, 78964, 78934, 78272, 78965, 78967, 78937, 78275, 
78968, 78966, 78935, 78243, 78274
19134, 65605, 65595, 65375, 65385, 65606, 65596, 65376, 65386, 78967, 78937, 78275, 78968, 78970, 78940, 78278, 
78971, 78969, 78938, 78246, 78277
19135, 65606, 65596, 65376, 65386, 65607, 65597, 65377, 65387, 78970, 78940, 78278, 78971, 78973, 78943, 78281, 
78974, 78972, 78941, 78249, 78280
19136, 65607, 65597, 65377, 65387, 65608, 65598, 65378, 65388, 78973, 78943, 78281, 78974, 78976, 78946, 78284, 
78977, 78975, 78944, 78252, 78283
19137, 65608, 65598, 65378, 65388, 65609, 65599, 65379, 65389, 78976, 78946, 78284, 78977, 78979, 78949, 78287, 
78980, 78978, 78947, 78255, 78286
19138, 65609, 65599, 65379, 65389, 65610, 65600, 65380, 65390, 78979, 78949, 78287, 78980, 78982, 78952, 78290, 
78983, 78981, 78950, 78258, 78289
19139, 65610, 65600, 65380, 65390, 65611, 65601, 65381, 65391, 78982, 78952, 78290, 78983, 78985, 78955, 78293, 
78986, 78984, 78953, 78261, 78292
19140, 65611, 65601, 65381, 65391, 65612, 65602, 65382, 65392, 78985, 78955, 78293, 78986, 78988, 78958, 78296, 
78989, 78987, 78956, 78264, 78295
19141, 65612, 65602, 65382, 65392, 18332, 18331, 18309, 18310, 78988, 78958, 78296, 78989, 19232, 19229, 19187, 
19231, 78990, 78959, 78267, 78298
19142, 16837, 16836, 16814, 16815, 65613, 65603, 65383, 65393, 17737, 17736, 17692, 17738, 78992, 78962, 78300, 
78993, 78991, 78960, 78268, 78299
19143, 65613, 65603, 65383, 65393, 65614, 65604, 65384, 65394, 78992, 78962, 78300, 78993, 78995, 78965, 78303, 
78996, 78994, 78963, 78271, 78302
19144, 65614, 65604, 65384, 65394, 65615, 65605, 65385, 65395, 78995, 78965, 78303, 78996, 78998, 78968, 78306, 
78999, 78997, 78966, 78274, 78305
19145, 65615, 65605, 65385, 65395, 65616, 65606, 65386, 65396, 78998, 78968, 78306, 78999, 79001, 78971, 78309, 
79002, 79000, 78969, 78277, 78308
19146, 65616, 65606, 65386, 65396, 65617, 65607, 65387, 65397, 79001, 78971, 78309, 79002, 79004, 78974, 78312, 
79005, 79003, 78972, 78280, 78311
19147, 65617, 65607, 65387, 65397, 65618, 65608, 65388, 65398, 79004, 78974, 78312, 79005, 79007, 78977, 78315, 
79008, 79006, 78975, 78283, 78314
19148, 65618, 65608, 65388, 65398, 65619, 65609, 65389, 65399, 79007, 78977, 78315, 79008, 79010, 78980, 78318, 
79011, 79009, 78978, 78286, 78317
19149, 65619, 65609, 65389, 65399, 65620, 65610, 65390, 65400, 79010, 78980, 78318, 79011, 79013, 78983, 78321, 
79014, 79012, 78981, 78289, 78320
19150, 65620, 65610, 65390, 65400, 65621, 65611, 65391, 65401, 79013, 78983, 78321, 79014, 79016, 78986, 78324, 
79017, 79015, 78984, 78292, 78323
19151, 65621, 65611, 65391, 65401, 65622, 65612, 65392, 65402, 79016, 78986, 78324, 79017, 79019, 78989, 78327, 
79020, 79018, 78987, 78295, 78326
19152, 65622, 65612, 65392, 65402, 18333, 18332, 18310, 18311, 79019, 78989, 78327, 79020, 19234, 19231, 19189, 
19233, 79021, 78990, 78298, 78329
19153, 16838, 16837, 16815, 16816, 65623, 65613, 65393, 65403, 17739, 17738, 17694, 17740, 79023, 78993, 78331, 
79024, 79022, 78991, 78299, 78330
19154, 65623, 65613, 65393, 65403, 65624, 65614, 65394, 65404, 79023, 78993, 78331, 79024, 79026, 78996, 78334, 
79027, 79025, 78994, 78302, 78333
19155, 65624, 65614, 65394, 65404, 65625, 65615, 65395, 65405, 79026, 78996, 78334, 79027, 79029, 78999, 78337, 
79030, 79028, 78997, 78305, 78336
19156, 65625, 65615, 65395, 65405, 65626, 65616, 65396, 65406, 79029, 78999, 78337, 79030, 79032, 79002, 78340, 
79033, 79031, 79000, 78308, 78339
19157, 65626, 65616, 65396, 65406, 65627, 65617, 65397, 65407, 79032, 79002, 78340, 79033, 79035, 79005, 78343, 
79036, 79034, 79003, 78311, 78342
19158, 65627, 65617, 65397, 65407, 65628, 65618, 65398, 65408, 79035, 79005, 78343, 79036, 79038, 79008, 78346, 
79039, 79037, 79006, 78314, 78345
19159, 65628, 65618, 65398, 65408, 65629, 65619, 65399, 65409, 79038, 79008, 78346, 79039, 79041, 79011, 78349, 
79042, 79040, 79009, 78317, 78348
19160, 65629, 65619, 65399, 65409, 65630, 65620, 65400, 65410, 79041, 79011, 78349, 79042, 79044, 79014, 78352, 
79045, 79043, 79012, 78320, 78351
19161, 65630, 65620, 65400, 65410, 65631, 65621, 65401, 65411, 79044, 79014, 78352, 79045, 79047, 79017, 78355, 
79048, 79046, 79015, 78323, 78354
19162, 65631, 65621, 65401, 65411, 65632, 65622, 65402, 65412, 79047, 79017, 78355, 79048, 79050, 79020, 78358, 
79051, 79049, 79018, 78326, 78357
19163, 65632, 65622, 65402, 65412, 18334, 18333, 18311, 18312, 79050, 79020, 78358, 79051, 19236, 19233, 19191, 
19235, 79052, 79021, 78329, 78360
19164, 16839, 16838, 16816, 16817, 65633, 65623, 65403, 65413, 17741, 17740, 17696, 17742, 79054, 79024, 78362, 
79055, 79053, 79022, 78330, 78361
19165, 65633, 65623, 65403, 65413, 65634, 65624, 65404, 65414, 79054, 79024, 78362, 79055, 79057, 79027, 78365, 
79058, 79056, 79025, 78333, 78364
19166, 65634, 65624, 65404, 65414, 65635, 65625, 65405, 65415, 79057, 79027, 78365, 79058, 79060, 79030, 78368, 
79061, 79059, 79028, 78336, 78367
19167, 65635, 65625, 65405, 65415, 65636, 65626, 65406, 65416, 79060, 79030, 78368, 79061, 79063, 79033, 78371, 
79064, 79062, 79031, 78339, 78370
19168, 65636, 65626, 65406, 65416, 65637, 65627, 65407, 65417, 79063, 79033, 78371, 79064, 79066, 79036, 78374, 
79067, 79065, 79034, 78342, 78373
19169, 65637, 65627, 65407, 65417, 65638, 65628, 65408, 65418, 79066, 79036, 78374, 79067, 79069, 79039, 78377, 
79070, 79068, 79037, 78345, 78376
19170, 65638, 65628, 65408, 65418, 65639, 65629, 65409, 65419, 79069, 79039, 78377, 79070, 79072, 79042, 78380, 
79073, 79071, 79040, 78348, 78379
19171, 65639, 65629, 65409, 65419, 65640, 65630, 65410, 65420, 79072, 79042, 78380, 79073, 79075, 79045, 78383, 
79076, 79074, 79043, 78351, 78382
19172, 65640, 65630, 65410, 65420, 65641, 65631, 65411, 65421, 79075, 79045, 78383, 79076, 79078, 79048, 78386, 
79079, 79077, 79046, 78354, 78385
19173, 65641, 65631, 65411, 65421, 65642, 65632, 65412, 65422, 79078, 79048, 78386, 79079, 79081, 79051, 78389, 
79082, 79080, 79049, 78357, 78388
19174, 65642, 65632, 65412, 65422, 18335, 18334, 18312, 18313, 79081, 79051, 78389, 79082, 19238, 19235, 19193, 
19237, 79083, 79052, 78360, 78391
19175, 16840, 16839, 16817, 16818, 65643, 65633, 65413, 65423, 17743, 17742, 17698, 17744, 79085, 79055, 78393, 
79086, 79084, 79053, 78361, 78392
19176, 65643, 65633, 65413, 65423, 65644, 65634, 65414, 65424, 79085, 79055, 78393, 79086, 79088, 79058, 78396, 
79089, 79087, 79056, 78364, 78395
19177, 65644, 65634, 65414, 65424, 65645, 65635, 65415, 65425, 79088, 79058, 78396, 79089, 79091, 79061, 78399, 
79092, 79090, 79059, 78367, 78398
19178, 65645, 65635, 65415, 65425, 65646, 65636, 65416, 65426, 79091, 79061, 78399, 79092, 79094, 79064, 78402, 
79095, 79093, 79062, 78370, 78401
19179, 65646, 65636, 65416, 65426, 65647, 65637, 65417, 65427, 79094, 79064, 78402, 79095, 79097, 79067, 78405, 
79098, 79096, 79065, 78373, 78404
19180, 65647, 65637, 65417, 65427, 65648, 65638, 65418, 65428, 79097, 79067, 78405, 79098, 79100, 79070, 78408, 
79101, 79099, 79068, 78376, 78407
19181, 65648, 65638, 65418, 65428, 65649, 65639, 65419, 65429, 79100, 79070, 78408, 79101, 79103, 79073, 78411, 
79104, 79102, 79071, 78379, 78410
19182, 65649, 65639, 65419, 65429, 65650, 65640, 65420, 65430, 79103, 79073, 78411, 79104, 79106, 79076, 78414, 
79107, 79105, 79074, 78382, 78413
19183, 65650, 65640, 65420, 65430, 65651, 65641, 65421, 65431, 79106, 79076, 78414, 79107, 79109, 79079, 78417, 
79110, 79108, 79077, 78385, 78416
19184, 65651, 65641, 65421, 65431, 65652, 65642, 65422, 65432, 79109, 79079, 78417, 79110, 79112, 79082, 78420, 
79113, 79111, 79080, 78388, 78419
19185, 65652, 65642, 65422, 65432, 18336, 18335, 18313, 18314, 79112, 79082, 78420, 79113, 19240, 19237, 19195, 
19239, 79114, 79083, 78391, 78422
19186, 16841, 16840, 16818, 16819, 65653, 65643, 65423, 65433, 17745, 17744, 17700, 17746, 79116, 79086, 78424, 
79117, 79115, 79084, 78392, 78423
19187, 65653, 65643, 65423, 65433, 65654, 65644, 65424, 65434, 79116, 79086, 78424, 79117, 79119, 79089, 78427, 
79120, 79118, 79087, 78395, 78426
19188, 65654, 65644, 65424, 65434, 65655, 65645, 65425, 65435, 79119, 79089, 78427, 79120, 79122, 79092, 78430, 
79123, 79121, 79090, 78398, 78429
19189, 65655, 65645, 65425, 65435, 65656, 65646, 65426, 65436, 79122, 79092, 78430, 79123, 79125, 79095, 78433, 
79126, 79124, 79093, 78401, 78432
19190, 65656, 65646, 65426, 65436, 65657, 65647, 65427, 65437, 79125, 79095, 78433, 79126, 79128, 79098, 78436, 
79129, 79127, 79096, 78404, 78435
19191, 65657, 65647, 65427, 65437, 65658, 65648, 65428, 65438, 79128, 79098, 78436, 79129, 79131, 79101, 78439, 
79132, 79130, 79099, 78407, 78438
19192, 65658, 65648, 65428, 65438, 65659, 65649, 65429, 65439, 79131, 79101, 78439, 79132, 79134, 79104, 78442, 
79135, 79133, 79102, 78410, 78441
19193, 65659, 65649, 65429, 65439, 65660, 65650, 65430, 65440, 79134, 79104, 78442, 79135, 79137, 79107, 78445, 
79138, 79136, 79105, 78413, 78444
19194, 65660, 65650, 65430, 65440, 65661, 65651, 65431, 65441, 79137, 79107, 78445, 79138, 79140, 79110, 78448, 
79141, 79139, 79108, 78416, 78447
19195, 65661, 65651, 65431, 65441, 65662, 65652, 65432, 65442, 79140, 79110, 78448, 79141, 79143, 79113, 78451, 
79144, 79142, 79111, 78419, 78450
19196, 65662, 65652, 65432, 65442, 18337, 18336, 18314, 18315, 79143, 79113, 78451, 79144, 19242, 19239, 19197, 
19241, 79145, 79114, 78422, 78453
19197, 16842, 16841, 16819, 16820, 65663, 65653, 65433, 65443, 17747, 17746, 17702, 17748, 79147, 79117, 78455, 
79148, 79146, 79115, 78423, 78454
19198, 65663, 65653, 65433, 65443, 65664, 65654, 65434, 65444, 79147, 79117, 78455, 79148, 79150, 79120, 78458, 
79151, 79149, 79118, 78426, 78457
19199, 65664, 65654, 65434, 65444, 65665, 65655, 65435, 65445, 79150, 79120, 78458, 79151, 79153, 79123, 78461, 
79154, 79152, 79121, 78429, 78460
19200, 65665, 65655, 65435, 65445, 65666, 65656, 65436, 65446, 79153, 79123, 78461, 79154, 79156, 79126, 78464, 
79157, 79155, 79124, 78432, 78463
19201, 65666, 65656, 65436, 65446, 65667, 65657, 65437, 65447, 79156, 79126, 78464, 79157, 79159, 79129, 78467, 
79160, 79158, 79127, 78435, 78466
19202, 65667, 65657, 65437, 65447, 65668, 65658, 65438, 65448, 79159, 79129, 78467, 79160, 79162, 79132, 78470, 
79163, 79161, 79130, 78438, 78469
19203, 65668, 65658, 65438, 65448, 65669, 65659, 65439, 65449, 79162, 79132, 78470, 79163, 79165, 79135, 78473, 
79166, 79164, 79133, 78441, 78472
19204, 65669, 65659, 65439, 65449, 65670, 65660, 65440, 65450, 79165, 79135, 78473, 79166, 79168, 79138, 78476, 
79169, 79167, 79136, 78444, 78475
19205, 65670, 65660, 65440, 65450, 65671, 65661, 65441, 65451, 79168, 79138, 78476, 79169, 79171, 79141, 78479, 
79172, 79170, 79139, 78447, 78478
19206, 65671, 65661, 65441, 65451, 65672, 65662, 65442, 65452, 79171, 79141, 78479, 79172, 79174, 79144, 78482, 
79175, 79173, 79142, 78450, 78481
19207, 65672, 65662, 65442, 65452, 18338, 18337, 18315, 18316, 79174, 79144, 78482, 79175, 19244, 19241, 19199, 
19243, 79176, 79145, 78453, 78484
19208, 16843, 16842, 16820, 16821, 65673, 65663, 65443, 65453, 17749, 17748, 17704, 17750, 79178, 79148, 78486, 
79179, 79177, 79146, 78454, 78485
19209, 65673, 65663, 65443, 65453, 65674, 65664, 65444, 65454, 79178, 79148, 78486, 79179, 79181, 79151, 78489, 
79182, 79180, 79149, 78457, 78488
19210, 65674, 65664, 65444, 65454, 65675, 65665, 65445, 65455, 79181, 79151, 78489, 79182, 79184, 79154, 78492, 
79185, 79183, 79152, 78460, 78491
19211, 65675, 65665, 65445, 65455, 65676, 65666, 65446, 65456, 79184, 79154, 78492, 79185, 79187, 79157, 78495, 
79188, 79186, 79155, 78463, 78494
19212, 65676, 65666, 65446, 65456, 65677, 65667, 65447, 65457, 79187, 79157, 78495, 79188, 79190, 79160, 78498, 
79191, 79189, 79158, 78466, 78497
19213, 65677, 65667, 65447, 65457, 65678, 65668, 65448, 65458, 79190, 79160, 78498, 79191, 79193, 79163, 78501, 
79194, 79192, 79161, 78469, 78500
19214, 65678, 65668, 65448, 65458, 65679, 65669, 65449, 65459, 79193, 79163, 78501, 79194, 79196, 79166, 78504, 
79197, 79195, 79164, 78472, 78503
19215, 65679, 65669, 65449, 65459, 65680, 65670, 65450, 65460, 79196, 79166, 78504, 79197, 79199, 79169, 78507, 
79200, 79198, 79167, 78475, 78506
19216, 65680, 65670, 65450, 65460, 65681, 65671, 65451, 65461, 79199, 79169, 78507, 79200, 79202, 79172, 78510, 
79203, 79201, 79170, 78478, 78509
19217, 65681, 65671, 65451, 65461, 65682, 65672, 65452, 65462, 79202, 79172, 78510, 79203, 79205, 79175, 78513, 
79206, 79204, 79173, 78481, 78512
19218, 65682, 65672, 65452, 65462, 18339, 18338, 18316, 18317, 79205, 79175, 78513, 79206, 19246, 19243, 19201, 
19245, 79207, 79176, 78484, 78515
19219, 16844, 16843, 16821, 16822, 65683, 65673, 65453, 65463, 17751, 17750, 17706, 17752, 79209, 79179, 78517, 
79210, 79208, 79177, 78485, 78516
19220, 65683, 65673, 65453, 65463, 65684, 65674, 65454, 65464, 79209, 79179, 78517, 79210, 79212, 79182, 78520, 
79213, 79211, 79180, 78488, 78519
19221, 65684, 65674, 65454, 65464, 65685, 65675, 65455, 65465, 79212, 79182, 78520, 79213, 79215, 79185, 78523, 
79216, 79214, 79183, 78491, 78522
19222, 65685, 65675, 65455, 65465, 65686, 65676, 65456, 65466, 79215, 79185, 78523, 79216, 79218, 79188, 78526, 
79219, 79217, 79186, 78494, 78525
19223, 65686, 65676, 65456, 65466, 65687, 65677, 65457, 65467, 79218, 79188, 78526, 79219, 79221, 79191, 78529, 
79222, 79220, 79189, 78497, 78528
19224, 65687, 65677, 65457, 65467, 65688, 65678, 65458, 65468, 79221, 79191, 78529, 79222, 79224, 79194, 78532, 
79225, 79223, 79192, 78500, 78531
19225, 65688, 65678, 65458, 65468, 65689, 65679, 65459, 65469, 79224, 79194, 78532, 79225, 79227, 79197, 78535, 
79228, 79226, 79195, 78503, 78534
19226, 65689, 65679, 65459, 65469, 65690, 65680, 65460, 65470, 79227, 79197, 78535, 79228, 79230, 79200, 78538, 
79231, 79229, 79198, 78506, 78537
19227, 65690, 65680, 65460, 65470, 65691, 65681, 65461, 65471, 79230, 79200, 78538, 79231, 79233, 79203, 78541, 
79234, 79232, 79201, 78509, 78540
19228, 65691, 65681, 65461, 65471, 65692, 65682, 65462, 65472, 79233, 79203, 78541, 79234, 79236, 79206, 78544, 
79237, 79235, 79204, 78512, 78543
19229, 65692, 65682, 65462, 65472, 18340, 18339, 18317, 18318, 79236, 79206, 78544, 79237, 19248, 19245, 19203, 
19247, 79238, 79207, 78515, 78546
19230, 16845, 16844, 16822, 16823, 65693, 65683, 65463, 65473, 17753, 17752, 17708, 17754, 79240, 79210, 78548, 
79241, 79239, 79208, 78516, 78547
19231, 65693, 65683, 65463, 65473, 65694, 65684, 65464, 65474, 79240, 79210, 78548, 79241, 79243, 79213, 78551, 
79244, 79242, 79211, 78519, 78550
19232, 65694, 65684, 65464, 65474, 65695, 65685, 65465, 65475, 79243, 79213, 78551, 79244, 79246, 79216, 78554, 
79247, 79245, 79214, 78522, 78553
19233, 65695, 65685, 65465, 65475, 65696, 65686, 65466, 65476, 79246, 79216, 78554, 79247, 79249, 79219, 78557, 
79250, 79248, 79217, 78525, 78556
19234, 65696, 65686, 65466, 65476, 65697, 65687, 65467, 65477, 79249, 79219, 78557, 79250, 79252, 79222, 78560, 
79253, 79251, 79220, 78528, 78559
19235, 65697, 65687, 65467, 65477, 65698, 65688, 65468, 65478, 79252, 79222, 78560, 79253, 79255, 79225, 78563, 
79256, 79254, 79223, 78531, 78562
19236, 65698, 65688, 65468, 65478, 65699, 65689, 65469, 65479, 79255, 79225, 78563, 79256, 79258, 79228, 78566, 
79259, 79257, 79226, 78534, 78565
19237, 65699, 65689, 65469, 65479, 65700, 65690, 65470, 65480, 79258, 79228, 78566, 79259, 79261, 79231, 78569, 
79262, 79260, 79229, 78537, 78568
19238, 65700, 65690, 65470, 65480, 65701, 65691, 65471, 65481, 79261, 79231, 78569, 79262, 79264, 79234, 78572, 
79265, 79263, 79232, 78540, 78571
19239, 65701, 65691, 65471, 65481, 65702, 65692, 65472, 65482, 79264, 79234, 78572, 79265, 79267, 79237, 78575, 
79268, 79266, 79235, 78543, 78574
19240, 65702, 65692, 65472, 65482, 18341, 18340, 18318, 18319, 79267, 79237, 78575, 79268, 19250, 19247, 19205, 
19249, 79269, 79238, 78546, 78577
19241, 16846, 16845, 16823, 16824, 65703, 65693, 65473, 65483, 17755, 17754, 17710, 17756, 79271, 79241, 78579, 
79272, 79270, 79239, 78547, 78578
19242, 65703, 65693, 65473, 65483, 65704, 65694, 65474, 65484, 79271, 79241, 78579, 79272, 79274, 79244, 78582, 
79275, 79273, 79242, 78550, 78581
19243, 65704, 65694, 65474, 65484, 65705, 65695, 65475, 65485, 79274, 79244, 78582, 79275, 79277, 79247, 78585, 
79278, 79276, 79245, 78553, 78584
19244, 65705, 65695, 65475, 65485, 65706, 65696, 65476, 65486, 79277, 79247, 78585, 79278, 79280, 79250, 78588, 
79281, 79279, 79248, 78556, 78587
19245, 65706, 65696, 65476, 65486, 65707, 65697, 65477, 65487, 79280, 79250, 78588, 79281, 79283, 79253, 78591, 
79284, 79282, 79251, 78559, 78590
19246, 65707, 65697, 65477, 65487, 65708, 65698, 65478, 65488, 79283, 79253, 78591, 79284, 79286, 79256, 78594, 
79287, 79285, 79254, 78562, 78593
19247, 65708, 65698, 65478, 65488, 65709, 65699, 65479, 65489, 79286, 79256, 78594, 79287, 79289, 79259, 78597, 
79290, 79288, 79257, 78565, 78596
19248, 65709, 65699, 65479, 65489, 65710, 65700, 65480, 65490, 79289, 79259, 78597, 79290, 79292, 79262, 78600, 
79293, 79291, 79260, 78568, 78599
19249, 65710, 65700, 65480, 65490, 65711, 65701, 65481, 65491, 79292, 79262, 78600, 79293, 79295, 79265, 78603, 
79296, 79294, 79263, 78571, 78602
19250, 65711, 65701, 65481, 65491, 65712, 65702, 65482, 65492, 79295, 79265, 78603, 79296, 79298, 79268, 78606, 
79299, 79297, 79266, 78574, 78605
19251, 65712, 65702, 65482, 65492, 18342, 18341, 18319, 18320, 79298, 79268, 78606, 79299, 19252, 19249, 19207, 
19251, 79300, 79269, 78577, 78608
19252, 16847, 16846, 16824, 16825, 65713, 65703, 65483, 65493, 17757, 17756, 17712, 17758, 79302, 79272, 78610, 
79303, 79301, 79270, 78578, 78609
19253, 65713, 65703, 65483, 65493, 65714, 65704, 65484, 65494, 79302, 79272, 78610, 79303, 79305, 79275, 78613, 
79306, 79304, 79273, 78581, 78612
19254, 65714, 65704, 65484, 65494, 65715, 65705, 65485, 65495, 79305, 79275, 78613, 79306, 79308, 79278, 78616, 
79309, 79307, 79276, 78584, 78615
19255, 65715, 65705, 65485, 65495, 65716, 65706, 65486, 65496, 79308, 79278, 78616, 79309, 79311, 79281, 78619, 
79312, 79310, 79279, 78587, 78618
19256, 65716, 65706, 65486, 65496, 65717, 65707, 65487, 65497, 79311, 79281, 78619, 79312, 79314, 79284, 78622, 
79315, 79313, 79282, 78590, 78621
19257, 65717, 65707, 65487, 65497, 65718, 65708, 65488, 65498, 79314, 79284, 78622, 79315, 79317, 79287, 78625, 
79318, 79316, 79285, 78593, 78624
19258, 65718, 65708, 65488, 65498, 65719, 65709, 65489, 65499, 79317, 79287, 78625, 79318, 79320, 79290, 78628, 
79321, 79319, 79288, 78596, 78627
19259, 65719, 65709, 65489, 65499, 65720, 65710, 65490, 65500, 79320, 79290, 78628, 79321, 79323, 79293, 78631, 
79324, 79322, 79291, 78599, 78630
19260, 65720, 65710, 65490, 65500, 65721, 65711, 65491, 65501, 79323, 79293, 78631, 79324, 79326, 79296, 78634, 
79327, 79325, 79294, 78602, 78633
19261, 65721, 65711, 65491, 65501, 65722, 65712, 65492, 65502, 79326, 79296, 78634, 79327, 79329, 79299, 78637, 
79330, 79328, 79297, 78605, 78636
19262, 65722, 65712, 65492, 65502, 18343, 18342, 18320, 18321, 79329, 79299, 78637, 79330, 19254, 19251, 19209, 
19253, 79331, 79300, 78608, 78639
19263, 16848, 16847, 16825, 16826, 65723, 65713, 65493, 65503, 17759, 17758, 17714, 17760, 79333, 79303, 78641, 
79334, 79332, 79301, 78609, 78640
19264, 65723, 65713, 65493, 65503, 65724, 65714, 65494, 65504, 79333, 79303, 78641, 79334, 79336, 79306, 78644, 
79337, 79335, 79304, 78612, 78643
19265, 65724, 65714, 65494, 65504, 65725, 65715, 65495, 65505, 79336, 79306, 78644, 79337, 79339, 79309, 78647, 
79340, 79338, 79307, 78615, 78646
19266, 65725, 65715, 65495, 65505, 65726, 65716, 65496, 65506, 79339, 79309, 78647, 79340, 79342, 79312, 78650, 
79343, 79341, 79310, 78618, 78649
19267, 65726, 65716, 65496, 65506, 65727, 65717, 65497, 65507, 79342, 79312, 78650, 79343, 79345, 79315, 78653, 
79346, 79344, 79313, 78621, 78652
19268, 65727, 65717, 65497, 65507, 65728, 65718, 65498, 65508, 79345, 79315, 78653, 79346, 79348, 79318, 78656, 
79349, 79347, 79316, 78624, 78655
19269, 65728, 65718, 65498, 65508, 65729, 65719, 65499, 65509, 79348, 79318, 78656, 79349, 79351, 79321, 78659, 
79352, 79350, 79319, 78627, 78658
19270, 65729, 65719, 65499, 65509, 65730, 65720, 65500, 65510, 79351, 79321, 78659, 79352, 79354, 79324, 78662, 
79355, 79353, 79322, 78630, 78661
19271, 65730, 65720, 65500, 65510, 65731, 65721, 65501, 65511, 79354, 79324, 78662, 79355, 79357, 79327, 78665, 
79358, 79356, 79325, 78633, 78664
19272, 65731, 65721, 65501, 65511, 65732, 65722, 65502, 65512, 79357, 79327, 78665, 79358, 79360, 79330, 78668, 
79361, 79359, 79328, 78636, 78667
19273, 65732, 65722, 65502, 65512, 18344, 18343, 18321, 18322, 79360, 79330, 78668, 79361, 19256, 19253, 19211, 
19255, 79362, 79331, 78639, 78670
19274, 16849, 16848, 16826, 16827, 65733, 65723, 65503, 65513, 17761, 17760, 17716, 17762, 79364, 79334, 78672, 
79365, 79363, 79332, 78640, 78671
19275, 65733, 65723, 65503, 65513, 65734, 65724, 65504, 65514, 79364, 79334, 78672, 79365, 79367, 79337, 78675, 
79368, 79366, 79335, 78643, 78674
19276, 65734, 65724, 65504, 65514, 65735, 65725, 65505, 65515, 79367, 79337, 78675, 79368, 79370, 79340, 78678, 
79371, 79369, 79338, 78646, 78677
