14515, 15930, 15920, 60674, 60684, 15931, 15921, 60675, 60685, 16351, 61586, 61289, 61596, 16353, 61587, 61292, 
61597, 16354, 16333, 61260, 61291
14516, 15931, 15921, 60675, 60685, 15932, 15922, 60676, 60686, 16353, 61587, 61292, 61597, 16355, 61588, 61295, 
61598, 16356, 16335, 61263, 61294
14517, 15932, 15922, 60676, 60686, 15933, 15923, 60677, 60687, 16355, 61588, 61295, 61598, 16357, 61589, 61298, 
61599, 16358, 16337, 61266, 61297
14518, 15933, 15923, 60677, 60687, 15934, 15924, 60678, 60688, 16357, 61589, 61298, 61599, 16359, 61590, 61301, 
61600, 16360, 16339, 61269, 61300
14519, 15934, 15924, 60678, 60688, 15935, 15925, 60679, 60689, 16359, 61590, 61301, 61600, 16361, 61591, 61304, 
61601, 16362, 16341, 61272, 61303
14520, 15935, 15925, 60679, 60689, 15936, 15926, 60680, 60690, 16361, 61591, 61304, 61601, 16363, 61592, 61307, 
61602, 16364, 16343, 61275, 61306
14521, 15936, 15926, 60680, 60690, 1520, 1519, 15593, 15594, 16363, 61592, 61307, 61602, 1542, 15660, 15635, 
15661, 16365, 16344, 61278, 61309
14522, 1470, 1469, 15505, 15506, 15937, 15927, 60681, 60691, 1492, 15572, 15547, 15573, 16366, 61593, 61311, 
61603, 16367, 16346, 61279, 61310
14523, 15937, 15927, 60681, 60691, 15938, 15928, 60682, 60692, 16366, 61593, 61311, 61603, 16368, 61594, 61314, 
61604, 16369, 16348, 61282, 61313
14524, 15938, 15928, 60682, 60692, 15939, 15929, 60683, 60693, 16368, 61594, 61314, 61604, 16370, 61595, 61317, 
61605, 16371, 16350, 61285, 61316
14525, 15939, 15929, 60683, 60693, 15940, 15930, 60684, 60694, 16370, 61595, 61317, 61605, 16372, 61596, 61320, 
61606, 16373, 16352, 61288, 61319
14526, 15940, 15930, 60684, 60694, 15941, 15931, 60685, 60695, 16372, 61596, 61320, 61606, 16374, 61597, 61323, 
61607, 16375, 16354, 61291, 61322
14527, 15941, 15931, 60685, 60695, 15942, 15932, 60686, 60696, 16374, 61597, 61323, 61607, 16376, 61598, 61326, 
61608, 16377, 16356, 61294, 61325
14528, 15942, 15932, 60686, 60696, 15943, 15933, 60687, 60697, 16376, 61598, 61326, 61608, 16378, 61599, 61329, 
61609, 16379, 16358, 61297, 61328
14529, 15943, 15933, 60687, 60697, 15944, 15934, 60688, 60698, 16378, 61599, 61329, 61609, 16380, 61600, 61332, 
61610, 16381, 16360, 61300, 61331
14530, 15944, 15934, 60688, 60698, 15945, 15935, 60689, 60699, 16380, 61600, 61332, 61610, 16382, 61601, 61335, 
61611, 16383, 16362, 61303, 61334
14531, 15945, 15935, 60689, 60699, 15946, 15936, 60690, 60700, 16382, 61601, 61335, 61611, 16384, 61602, 61338, 
61612, 16385, 16364, 61306, 61337
14532, 15946, 15936, 60690, 60700, 1521, 1520, 15594, 15595, 16384, 61602, 61338, 61612, 1543, 15661, 15637, 
15662, 16386, 16365, 61309, 61340
14533, 1471, 1470, 15506, 15507, 15947, 15937, 60691, 60701, 1493, 15573, 15549, 15574, 16387, 61603, 61342, 
61613, 16388, 16367, 61310, 61341
14534, 15947, 15937, 60691, 60701, 15948, 15938, 60692, 60702, 16387, 61603, 61342, 61613, 16389, 61604, 61345, 
61614, 16390, 16369, 61313, 61344
14535, 15948, 15938, 60692, 60702, 15949, 15939, 60693, 60703, 16389, 61604, 61345, 61614, 16391, 61605, 61348, 
61615, 16392, 16371, 61316, 61347
14536, 15949, 15939, 60693, 60703, 15950, 15940, 60694, 60704, 16391, 61605, 61348, 61615, 16393, 61606, 61351, 
61616, 16394, 16373, 61319, 61350
14537, 15950, 15940, 60694, 60704, 15951, 15941, 60695, 60705, 16393, 61606, 61351, 61616, 16395, 61607, 61354, 
61617, 16396, 16375, 61322, 61353
14538, 15951, 15941, 60695, 60705, 15952, 15942, 60696, 60706, 16395, 61607, 61354, 61617, 16397, 61608, 61357, 
61618, 16398, 16377, 61325, 61356
14539, 15952, 15942, 60696, 60706, 15953, 15943, 60697, 60707, 16397, 61608, 61357, 61618, 16399, 61609, 61360, 
61619, 16400, 16379, 61328, 61359
14540, 15953, 15943, 60697, 60707, 15954, 15944, 60698, 60708, 16399, 61609, 61360, 61619, 16401, 61610, 61363, 
61620, 16402, 16381, 61331, 61362
14541, 15954, 15944, 60698, 60708, 15955, 15945, 60699, 60709, 16401, 61610, 61363, 61620, 16403, 61611, 61366, 
61621, 16404, 16383, 61334, 61365
14542, 15955, 15945, 60699, 60709, 15956, 15946, 60700, 60710, 16403, 61611, 61366, 61621, 16405, 61612, 61369, 
61622, 16406, 16385, 61337, 61368
14543, 15956, 15946, 60700, 60710, 1522, 1521, 15595, 15596, 16405, 61612, 61369, 61622, 1544, 15662, 15639, 
15663, 16407, 16386, 61340, 61371
14544, 1472, 1471, 15507, 15508, 15957, 15947, 60701, 60711, 1494, 15574, 15551, 15575, 16408, 61613, 61373, 
61623, 16409, 16388, 61341, 61372
14545, 15957, 15947, 60701, 60711, 15958, 15948, 60702, 60712, 16408, 61613, 61373, 61623, 16410, 61614, 61376, 
61624, 16411, 16390, 61344, 61375
14546, 15958, 15948, 60702, 60712, 15959, 15949, 60703, 60713, 16410, 61614, 61376, 61624, 16412, 61615, 61379, 
61625, 16413, 16392, 61347, 61378
14547, 15959, 15949, 60703, 60713, 15960, 15950, 60704, 60714, 16412, 61615, 61379, 61625, 16414, 61616, 61382, 
61626, 16415, 16394, 61350, 61381
14548, 15960, 15950, 60704, 60714, 15961, 15951, 60705, 60715, 16414, 61616, 61382, 61626, 16416, 61617, 61385, 
61627, 16417, 16396, 61353, 61384
14549, 15961, 15951, 60705, 60715, 15962, 15952, 60706, 60716, 16416, 61617, 61385, 61627, 16418, 61618, 61388, 
61628, 16419, 16398, 61356, 61387
14550, 15962, 15952, 60706, 60716, 15963, 15953, 60707, 60717, 16418, 61618, 61388, 61628, 16420, 61619, 61391, 
61629, 16421, 16400, 61359, 61390
14551, 15963, 15953, 60707, 60717, 15964, 15954, 60708, 60718, 16420, 61619, 61391, 61629, 16422, 61620, 61394, 
61630, 16423, 16402, 61362, 61393
14552, 15964, 15954, 60708, 60718, 15965, 15955, 60709, 60719, 16422, 61620, 61394, 61630, 16424, 61621, 61397, 
61631, 16425, 16404, 61365, 61396
14553, 15965, 15955, 60709, 60719, 15966, 15956, 60710, 60720, 16424, 61621, 61397, 61631, 16426, 61622, 61400, 
61632, 16427, 16406, 61368, 61399
14554, 15966, 15956, 60710, 60720, 1523, 1522, 15596, 15597, 16426, 61622, 61400, 61632, 1545, 15663, 15641, 
15664, 16428, 16407, 61371, 61402
14555, 34, 1472, 15508, 1448, 1577, 15957, 60711, 15706, 1495, 15575, 15553, 1450, 16429, 61623, 61403, 
15737, 1588, 16409, 61372, 15716
14556, 1577, 15957, 60711, 15706, 1576, 15958, 60712, 15707, 16429, 61623, 61403, 15737, 16430, 61624, 61404, 
15738, 1587, 16411, 61375, 15718
14557, 1576, 15958, 60712, 15707, 1575, 15959, 60713, 15708, 16430, 61624, 61404, 15738, 16431, 61625, 61405, 
15739, 1586, 16413, 61378, 15720
14558, 1575, 15959, 60713, 15708, 1574, 15960, 60714, 15709, 16431, 61625, 61405, 15739, 16432, 61626, 61406, 
15740, 1585, 16415, 61381, 15722
14559, 1574, 15960, 60714, 15709, 1573, 15961, 60715, 15710, 16432, 61626, 61406, 15740, 16433, 61627, 61407, 
15741, 1584, 16417, 61384, 15724
14560, 1573, 15961, 60715, 15710, 1572, 15962, 60716, 15711, 16433, 61627, 61407, 15741, 16434, 61628, 61408, 
15742, 1583, 16419, 61387, 15726
14561, 1572, 15962, 60716, 15711, 1571, 15963, 60717, 15712, 16434, 61628, 61408, 15742, 16435, 61629, 61409, 
15743, 1582, 16421, 61390, 15728
14562, 1571, 15963, 60717, 15712, 1570, 15964, 60718, 15713, 16435, 61629, 61409, 15743, 16436, 61630, 61410, 
15744, 1581, 16423, 61393, 15730
14563, 1570, 15964, 60718, 15713, 1569, 15965, 60719, 15714, 16436, 61630, 61410, 15744, 16437, 61631, 61411, 
15745, 1580, 16425, 61396, 15732
14564, 1569, 15965, 60719, 15714, 1568, 15966, 60720, 15715, 16437, 61631, 61411, 15745, 16438, 61632, 61412, 
15746, 1579, 16427, 61399, 15734
14565, 1568, 15966, 60720, 15715, 36, 1523, 15597, 1499, 16438, 61632, 61412, 15746, 1546, 15664, 15642, 
1501, 1578, 16428, 61402, 15736
*ELEMENT, type=C3D20, ELSET=Volume9
14566, 16439, 1589, 33, 1451, 61633, 19431, 1556, 15747, 16923, 1611, 1473, 16924, 66474, 19651, 15967, 
66475, 66473, 19652, 1567, 15968
14567, 61633, 19431, 1556, 15747, 61634, 19432, 1555, 15748, 66474, 19651, 15967, 66475, 66477, 19653, 15969, 
66478, 66476, 19654, 1566, 15970
14568, 61634, 19432, 1555, 15748, 61635, 19433, 1554, 15749, 66477, 19653, 15969, 66478, 66480, 19655, 15971, 
66481, 66479, 19656, 1565, 15972
14569, 61635, 19433, 1554, 15749, 61636, 19434, 1553, 15750, 66480, 19655, 15971, 66481, 66483, 19657, 15973, 
66484, 66482, 19658, 1564, 15974
14570, 61636, 19434, 1553, 15750, 61637, 19435, 1552, 15751, 66483, 19657, 15973, 66484, 66486, 19659, 15975, 
66487, 66485, 19660, 1563, 15976
14571, 61637, 19435, 1552, 15751, 61638, 19436, 1551, 15752, 66486, 19659, 15975, 66487, 66489, 19661, 15977, 
66490, 66488, 19662, 1562, 15978
14572, 61638, 19436, 1551, 15752, 61639, 19437, 1550, 15753, 66489, 19661, 15977, 66490, 66492, 19663, 15979, 
66493, 66491, 19664, 1561, 15980
14573, 61639, 19437, 1550, 15753, 61640, 19438, 1549, 15754, 66492, 19663, 15979, 66493, 66495, 19665, 15981, 
66496, 66494, 19666, 1560, 15982
14574, 61640, 19438, 1549, 15754, 61641, 19439, 1548, 15755, 66495, 19665, 15981, 66496, 66498, 19667, 15983, 
66499, 66497, 19668, 1559, 15984
14575, 61641, 19439, 1548, 15755, 61642, 19440, 1547, 15756, 66498, 19667, 15983, 66499, 66501, 19669, 15985, 
66502, 66500, 19670, 1558, 15986
14576, 61642, 19440, 1547, 15756, 17935, 1724, 35, 1502, 66501, 19669, 15985, 66502, 18420, 1746, 1524, 
18419, 66503, 19671, 1557, 15987
14577, 16440, 16439, 1451, 1452, 61643, 61633, 15747, 15757, 16925, 16924, 1474, 16926, 66505, 66475, 15988, 
66506, 66504, 66473, 15968, 15989
14578, 61643, 61633, 15747, 15757, 61644, 61634, 15748, 15758, 66505, 66475, 15988, 66506, 66508, 66478, 15990, 
66509, 66507, 66476, 15970, 15991
14579, 61644, 61634, 15748, 15758, 61645, 61635, 15749, 15759, 66508, 66478, 15990, 66509, 66511, 66481, 15992, 
66512, 66510, 66479, 15972, 15993
14580, 61645, 61635, 15749, 15759, 61646, 61636, 15750, 15760, 66511, 66481, 15992, 66512, 66514, 66484, 15994, 
66515, 66513, 66482, 15974, 15995
14581, 61646, 61636, 15750, 15760, 61647, 61637, 15751, 15761, 66514, 66484, 15994, 66515, 66517, 66487, 15996, 
66518, 66516, 66485, 15976, 15997
14582, 61647, 61637, 15751, 15761, 61648, 61638, 15752, 15762, 66517, 66487, 15996, 66518, 66520, 66490, 15998, 
66521, 66519, 66488, 15978, 15999
14583, 61648, 61638, 15752, 15762, 61649, 61639, 15753, 15763, 66520, 66490, 15998, 66521, 66523, 66493, 16000, 
66524, 66522, 66491, 15980, 16001
14584, 61649, 61639, 15753, 15763, 61650, 61640, 15754, 15764, 66523, 66493, 16000, 66524, 66526, 66496, 16002, 
66527, 66525, 66494, 15982, 16003
14585, 61650, 61640, 15754, 15764, 61651, 61641, 15755, 15765, 66526, 66496, 16002, 66527, 66529, 66499, 16004, 
66530, 66528, 66497, 15984, 16005
14586, 61651, 61641, 15755, 15765, 61652, 61642, 15756, 15766, 66529, 66499, 16004, 66530, 66532, 66502, 16006, 
66533, 66531, 66500, 15986, 16007
14587, 61652, 61642, 15756, 15766, 17936, 17935, 1502, 1503, 66532, 66502, 16006, 66533, 18422, 18419, 1525, 
18421, 66534, 66503, 15987, 16008
14588, 16441, 16440, 1452, 1453, 61653, 61643, 15757, 15767, 16927, 16926, 1475, 16928, 66536, 66506, 16009, 
66537, 66535, 66504, 15989, 16010
14589, 61653, 61643, 15757, 15767, 61654, 61644, 15758, 15768, 66536, 66506, 16009, 66537, 66539, 66509, 16011, 
66540, 66538, 66507, 15991, 16012
14590, 61654, 61644, 15758, 15768, 61655, 61645, 15759, 15769, 66539, 66509, 16011, 66540, 66542, 66512, 16013, 
66543, 66541, 66510, 15993, 16014
14591, 61655, 61645, 15759, 15769, 61656, 61646, 15760, 15770, 66542, 66512, 16013, 66543, 66545, 66515, 16015, 
66546, 66544, 66513, 15995, 16016
14592, 61656, 61646, 15760, 15770, 61657, 61647, 15761, 15771, 66545, 66515, 16015, 66546, 66548, 66518, 16017, 
66549, 66547, 66516, 15997, 16018
14593, 61657, 61647, 15761, 15771, 61658, 61648, 15762, 15772, 66548, 66518, 16017, 66549, 66551, 66521, 16019, 
66552, 66550, 66519, 15999, 16020
14594, 61658, 61648, 15762, 15772, 61659, 61649, 15763, 15773, 66551, 66521, 16019, 66552, 66554, 66524, 16021, 
66555, 66553, 66522, 16001, 16022
14595, 61659, 61649, 15763, 15773, 61660, 61650, 15764, 15774, 66554, 66524, 16021, 66555, 66557, 66527, 16023, 
66558, 66556, 66525, 16003, 16024
14596, 61660, 61650, 15764, 15774, 61661, 61651, 15765, 15775, 66557, 66527, 16023, 66558, 66560, 66530, 16025, 
66561, 66559, 66528, 16005, 16026
14597, 61661, 61651, 15765, 15775, 61662, 61652, 15766, 15776, 66560, 66530, 16025, 66561, 66563, 66533, 16027, 
66564, 66562, 66531, 16007, 16028
14598, 61662, 61652, 15766, 15776, 17937, 17936, 1503, 1504, 66563, 66533, 16027, 66564, 18424, 18421, 1526, 
18423, 66565, 66534, 16008, 16029
14599, 16442, 16441, 1453, 1454, 61663, 61653, 15767, 15777, 16929, 16928, 1476, 16930, 66567, 66537, 16030, 
66568, 66566, 66535, 16010, 16031
14600, 61663, 61653, 15767, 15777, 61664, 61654, 15768, 15778, 66567, 66537, 16030, 66568, 66570, 66540, 16032, 
66571, 66569, 66538, 16012, 16033
14601, 61664, 61654, 15768, 15778, 61665, 61655, 15769, 15779, 66570, 66540, 16032, 66571, 66573, 66543, 16034, 
66574, 66572, 66541, 16014, 16035
14602, 61665, 61655, 15769, 15779, 61666, 61656, 15770, 15780, 66573, 66543, 16034, 66574, 66576, 66546, 16036, 
66577, 66575, 66544, 16016, 16037
14603, 61666, 61656, 15770, 15780, 61667, 61657, 15771, 15781, 66576, 66546, 16036, 66577, 66579, 66549, 16038, 
66580, 66578, 66547, 16018, 16039
14604, 61667, 61657, 15771, 15781, 61668, 61658, 15772, 15782, 66579, 66549, 16038, 66580, 66582, 66552, 16040, 
66583, 66581, 66550, 16020, 16041
14605, 61668, 61658, 15772, 15782, 61669, 61659, 15773, 15783, 66582, 66552, 16040, 66583, 66585, 66555, 16042, 
66586, 66584, 66553, 16022, 16043
14606, 61669, 61659, 15773, 15783, 61670, 61660, 15774, 15784, 66585, 66555, 16042, 66586, 66588, 66558, 16044, 
66589, 66587, 66556, 16024, 16045
14607, 61670, 61660, 15774, 15784, 61671, 61661, 15775, 15785, 66588, 66558, 16044, 66589, 66591, 66561, 16046, 
66592, 66590, 66559, 16026, 16047
14608, 61671, 61661, 15775, 15785, 61672, 61662, 15776, 15786, 66591, 66561, 16046, 66592, 66594, 66564, 16048, 
66595, 66593, 66562, 16028, 16049
14609, 61672, 61662, 15776, 15786, 17938, 17937, 1504, 1505, 66594, 66564, 16048, 66595, 18426, 18423, 1527, 
18425, 66596, 66565, 16029, 16050
14610, 16443, 16442, 1454, 1455, 61673, 61663, 15777, 15787, 16931, 16930, 1477, 16932, 66598, 66568, 16051, 
66599, 66597, 66566, 16031, 16052
14611, 61673, 61663, 15777, 15787, 61674, 61664, 15778, 15788, 66598, 66568, 16051, 66599, 66601, 66571, 16053, 
66602, 66600, 66569, 16033, 16054
14612, 61674, 61664, 15778, 15788, 61675, 61665, 15779, 15789, 66601, 66571, 16053, 66602, 66604, 66574, 16055, 
66605, 66603, 66572, 16035, 16056
14613, 61675, 61665, 15779, 15789, 61676, 61666, 15780, 15790, 66604, 66574, 16055, 66605, 66607, 66577, 16057, 
66608, 66606, 66575, 16037, 16058
14614, 61676, 61666, 15780, 15790, 61677, 61667, 15781, 15791, 66607, 66577, 16057, 66608, 66610, 66580, 16059, 
66611, 66609, 66578, 16039, 16060
14615, 61677, 61667, 15781, 15791, 61678, 61668, 15782, 15792, 66610, 66580, 16059, 66611, 66613, 66583, 16061, 
66614, 66612, 66581, 16041, 16062
14616, 61678, 61668, 15782, 15792, 61679, 61669, 15783, 15793, 66613, 66583, 16061, 66614, 66616, 66586, 16063, 
66617, 66615, 66584, 16043, 16064
14617, 61679, 61669, 15783, 15793, 61680, 61670, 15784, 15794, 66616, 66586, 16063, 66617, 66619, 66589, 16065, 
66620, 66618, 66587, 16045, 16066
14618, 61680, 61670, 15784, 15794, 61681, 61671, 15785, 15795, 66619, 66589, 16065, 66620, 66622, 66592, 16067, 
66623, 66621, 66590, 16047, 16068
14619, 61681, 61671, 15785, 15795, 61682, 61672, 15786, 15796, 66622, 66592, 16067, 66623, 66625, 66595, 16069, 
66626, 66624, 66593, 16049, 16070
14620, 61682, 61672, 15786, 15796, 17939, 17938, 1505, 1506, 66625, 66595, 16069, 66626, 18428, 18425, 1528, 
18427, 66627, 66596, 16050, 16071
14621, 16444, 16443, 1455, 1456, 61683, 61673, 15787, 15797, 16933, 16932, 1478, 16934, 66629, 66599, 16072, 
66630, 66628, 66597, 16052, 16073
14622, 61683, 61673, 15787, 15797, 61684, 61674, 15788, 15798, 66629, 66599, 16072, 66630, 66632, 66602, 16074, 
66633, 66631, 66600, 16054, 16075
14623, 61684, 61674, 15788, 15798, 61685, 61675, 15789, 15799, 66632, 66602, 16074, 66633, 66635, 66605, 16076, 
66636, 66634, 66603, 16056, 16077
14624, 61685, 61675, 15789, 15799, 61686, 61676, 15790, 15800, 66635, 66605, 16076, 66636, 66638, 66608, 16078, 
66639, 66637, 66606, 16058, 16079
14625, 61686, 61676, 15790, 15800, 61687, 61677, 15791, 15801, 66638, 66608, 16078, 66639, 66641, 66611, 16080, 
66642, 66640, 66609, 16060, 16081
14626, 61687, 61677, 15791, 15801, 61688, 61678, 15792, 15802, 66641, 66611, 16080, 66642, 66644, 66614, 16082, 
66645, 66643, 66612, 16062, 16083
14627, 61688, 61678, 15792, 15802, 61689, 61679, 15793, 15803, 66644, 66614, 16082, 66645, 66647, 66617, 16084, 
66648, 66646, 66615, 16064, 16085
14628, 61689, 61679, 15793, 15803, 61690, 61680, 15794, 15804, 66647, 66617, 16084, 66648, 66650, 66620, 16086, 
66651, 66649, 66618, 16066, 16087
14629, 61690, 61680, 15794, 15804, 61691, 61681, 15795, 15805, 66650, 66620, 16086, 66651, 66653, 66623, 16088, 
66654, 66652, 66621, 16068, 16089
14630, 61691, 61681, 15795, 15805, 61692, 61682, 15796, 15806, 66653, 66623, 16088, 66654, 66656, 66626, 16090, 
66657, 66655, 66624, 16070, 16091
14631, 61692, 61682, 15796, 15806, 17940, 17939, 1506, 1507, 66656, 66626, 16090, 66657, 18430, 18427, 1529, 
18429, 66658, 66627, 16071, 16092
14632, 16445, 16444, 1456, 1457, 61693, 61683, 15797, 15807, 16935, 16934, 1479, 16936, 66660, 66630, 16093, 
66661, 66659, 66628, 16073, 16094
14633, 61693, 61683, 15797, 15807, 61694, 61684, 15798, 15808, 66660, 66630, 16093, 66661, 66663, 66633, 16095, 
66664, 66662, 66631, 16075, 16096
14634, 61694, 61684, 15798, 15808, 61695, 61685, 15799, 15809, 66663, 66633, 16095, 66664, 66666, 66636, 16097, 
66667, 66665, 66634, 16077, 16098
14635, 61695, 61685, 15799, 15809, 61696, 61686, 15800, 15810, 66666, 66636, 16097, 66667, 66669, 66639, 16099, 
66670, 66668, 66637, 16079, 16100
14636, 61696, 61686, 15800, 15810, 61697, 61687, 15801, 15811, 66669, 66639, 16099, 66670, 66672, 66642, 16101, 
66673, 66671, 66640, 16081, 16102
14637, 61697, 61687, 15801, 15811, 61698, 61688, 15802, 15812, 66672, 66642, 16101, 66673, 66675, 66645, 16103, 
66676, 66674, 66643, 16083, 16104
14638, 61698, 61688, 15802, 15812, 61699, 61689, 15803, 15813, 66675, 66645, 16103, 66676, 66678, 66648, 16105, 
66679, 66677, 66646, 16085, 16106
14639, 61699, 61689, 15803, 15813, 61700, 61690, 15804, 15814, 66678, 66648, 16105, 66679, 66681, 66651, 16107, 
66682, 66680, 66649, 16087, 16108
14640, 61700, 61690, 15804, 15814, 61701, 61691, 15805, 15815, 66681, 66651, 16107, 66682, 66684, 66654, 16109, 
66685, 66683, 66652, 16089, 16110
14641, 61701, 61691, 15805, 15815, 61702, 61692, 15806, 15816, 66684, 66654, 16109, 66685, 66687, 66657, 16111, 
66688, 66686, 66655, 16091, 16112
14642, 61702, 61692, 15806, 15816, 17941, 17940, 1507, 1508, 66687, 66657, 16111, 66688, 18432, 18429, 1530, 
18431, 66689, 66658, 16092, 16113
14643, 16446, 16445, 1457, 1458, 61703, 61693, 15807, 15817, 16937, 16936, 1480, 16938, 66691, 66661, 16114, 
66692, 66690, 66659, 16094, 16115
14644, 61703, 61693, 15807, 15817, 61704, 61694, 15808, 15818, 66691, 66661, 16114, 66692, 66694, 66664, 16116, 
66695, 66693, 66662, 16096, 16117
14645, 61704, 61694, 15808, 15818, 61705, 61695, 15809, 15819, 66694, 66664, 16116, 66695, 66697, 66667, 16118, 
66698, 66696, 66665, 16098, 16119
14646, 61705, 61695, 15809, 15819, 61706, 61696, 15810, 15820, 66697, 66667, 16118, 66698, 66700, 66670, 16120, 
66701, 66699, 66668, 16100, 16121
14647, 61706, 61696, 15810, 15820, 61707, 61697, 15811, 15821, 66700, 66670, 16120, 66701, 66703, 66673, 16122, 
66704, 66702, 66671, 16102, 16123
14648, 61707, 61697, 15811, 15821, 61708, 61698, 15812, 15822, 66703, 66673, 16122, 66704, 66706, 66676, 16124, 
66707, 66705, 66674, 16104, 16125
14649, 61708, 61698, 15812, 15822, 61709, 61699, 15813, 15823, 66706, 66676, 16124, 66707, 66709, 66679, 16126, 
66710, 66708, 66677, 16106, 16127
14650, 61709, 61699, 15813, 15823, 61710, 61700, 15814, 15824, 66709, 66679, 16126, 66710, 66712, 66682, 16128, 
66713, 66711, 66680, 16108, 16129
14651, 61710, 61700, 15814, 15824, 61711, 61701, 15815, 15825, 66712, 66682, 16128, 66713, 66715, 66685, 16130, 
66716, 66714, 66683, 16110, 16131
14652, 61711, 61701, 15815, 15825, 61712, 61702, 15816, 15826, 66715, 66685, 16130, 66716, 66718, 66688, 16132, 
66719, 66717, 66686, 16112, 16133
14653, 61712, 61702, 15816, 15826, 17942, 17941, 1508, 1509, 66718, 66688, 16132, 66719, 18434, 18431, 1531, 
18433, 66720, 66689, 16113, 16134
14654, 16447, 16446, 1458, 1459, 61713, 61703, 15817, 15827, 16939, 16938, 1481, 16940, 66722, 66692, 16135, 
66723, 66721, 66690, 16115, 16136
14655, 61713, 61703, 15817, 15827, 61714, 61704, 15818, 15828, 66722, 66692, 16135, 66723, 66725, 66695, 16137, 
66726, 66724, 66693, 16117, 16138
14656, 61714, 61704, 15818, 15828, 61715, 61705, 15819, 15829, 66725, 66695, 16137, 66726, 66728, 66698, 16139, 
66729, 66727, 66696, 16119, 16140
14657, 61715, 61705, 15819, 15829, 61716, 61706, 15820, 15830, 66728, 66698, 16139, 66729, 66731, 66701, 16141, 
66732, 66730, 66699, 16121, 16142
14658, 61716, 61706, 15820, 15830, 61717, 61707, 15821, 15831, 66731, 66701, 16141, 66732, 66734, 66704, 16143, 
66735, 66733, 66702, 16123, 16144
14659, 61717, 61707, 15821, 15831, 61718, 61708, 15822, 15832, 66734, 66704, 16143, 66735, 66737, 66707, 16145, 
66738, 66736, 66705, 16125, 16146
14660, 61718, 61708, 15822, 15832, 61719, 61709, 15823, 15833, 66737, 66707, 16145, 66738, 66740, 66710, 16147, 
66741, 66739, 66708, 16127, 16148
14661, 61719, 61709, 15823, 15833, 61720, 61710, 15824, 15834, 66740, 66710, 16147, 66741, 66743, 66713, 16149, 
66744, 66742, 66711, 16129, 16150
14662, 61720, 61710, 15824, 15834, 61721, 61711, 15825, 15835, 66743, 66713, 16149, 66744, 66746, 66716, 16151, 
66747, 66745, 66714, 16131, 16152
14663, 61721, 61711, 15825, 15835, 61722, 61712, 15826, 15836, 66746, 66716, 16151, 66747, 66749, 66719, 16153, 
66750, 66748, 66717, 16133, 16154
14664, 61722, 61712, 15826, 15836, 17943, 17942, 1509, 1510, 66749, 66719, 16153, 66750, 18436, 18433, 1532, 
18435, 66751, 66720, 16134, 16155
14665, 16448, 16447, 1459, 1460, 61723, 61713, 15827, 15837, 16941, 16940, 1482, 16942, 66753, 66723, 16156, 
66754, 66752, 66721, 16136, 16157
14666, 61723, 61713, 15827, 15837, 61724, 61714, 15828, 15838, 66753, 66723, 16156, 66754, 66756, 66726, 16158, 
66757, 66755, 66724, 16138, 16159
14667, 61724, 61714, 15828, 15838, 61725, 61715, 15829, 15839, 66756, 66726, 16158, 66757, 66759, 66729, 16160, 
66760, 66758, 66727, 16140, 16161
14668, 61725, 61715, 15829, 15839, 61726, 61716, 15830, 15840, 66759, 66729, 16160, 66760, 66762, 66732, 16162, 
66763, 66761, 66730, 16142, 16163
14669, 61726, 61716, 15830, 15840, 61727, 61717, 15831, 15841, 66762, 66732, 16162, 66763, 66765, 66735, 16164, 
66766, 66764, 66733, 16144, 16165
14670, 61727, 61717, 15831, 15841, 61728, 61718, 15832, 15842, 66765, 66735, 16164, 66766, 66768, 66738, 16166, 
66769, 66767, 66736, 16146, 16167
14671, 61728, 61718, 15832, 15842, 61729, 61719, 15833, 15843, 66768, 66738, 16166, 66769, 66771, 66741, 16168, 
66772, 66770, 66739, 16148, 16169
14672, 61729, 61719, 15833, 15843, 61730, 61720, 15834, 15844, 66771, 66741, 16168, 66772, 66774, 66744, 16170, 
66775, 66773, 66742, 16150, 16171
14673, 61730, 61720, 15834, 15844, 61731, 61721, 15835, 15845, 66774, 66744, 16170, 66775, 66777, 66747, 16172, 
66778, 66776, 66745, 16152, 16173
14674, 61731, 61721, 15835, 15845, 61732, 61722, 15836, 15846, 66777, 66747, 16172, 66778, 66780, 66750, 16174, 
66781, 66779, 66748, 16154, 16175
14675, 61732, 61722, 15836, 15846, 17944, 17943, 1510, 1511, 66780, 66750, 16174, 66781, 18438, 18435, 1533, 
18437, 66782, 66751, 16155, 16176
14676, 16449, 16448, 1460, 1461, 61733, 61723, 15837, 15847, 16943, 16942, 1483, 16944, 66784, 66754, 16177, 
66785, 66783, 66752, 16157, 16178
14677, 61733, 61723, 15837, 15847, 61734, 61724, 15838, 15848, 66784, 66754, 16177, 66785, 66787, 66757, 16179, 
66788, 66786, 66755, 16159, 16180
14678, 61734, 61724, 15838, 15848, 61735, 61725, 15839, 15849, 66787, 66757, 16179, 66788, 66790, 66760, 16181, 
66791, 66789, 66758, 16161, 16182
14679, 61735, 61725, 15839, 15849, 61736, 61726, 15840, 15850, 66790, 66760, 16181, 66791, 66793, 66763, 16183, 
66794, 66792, 66761, 16163, 16184
14680, 61736, 61726, 15840, 15850, 61737, 61727, 15841, 15851, 66793, 66763, 16183, 66794, 66796, 66766, 16185, 
66797, 66795, 66764, 16165, 16186
14681, 61737, 61727, 15841, 15851, 61738, 61728, 15842, 15852, 66796, 66766, 16185, 66797, 66799, 66769, 16187, 
66800, 66798, 66767, 16167, 16188
14682, 61738, 61728, 15842, 15852, 61739, 61729, 15843, 15853, 66799, 66769, 16187, 66800, 66802, 66772, 16189, 
66803, 66801, 66770, 16169, 16190
14683, 61739, 61729, 15843, 15853, 61740, 61730, 15844, 15854, 66802, 66772, 16189, 66803, 66805, 66775, 16191, 
66806, 66804, 66773, 16171, 16192
14684, 61740, 61730, 15844, 15854, 61741, 61731, 15845, 15855, 66805, 66775, 16191, 66806, 66808, 66778, 16193, 
66809, 66807, 66776, 16173, 16194
14685, 61741, 61731, 15845, 15855, 61742, 61732, 15846, 15856, 66808, 66778, 16193, 66809, 66811, 66781, 16195, 
66812, 66810, 66779, 16175, 16196
14686, 61742, 61732, 15846, 15856, 17945, 17944, 1511, 1512, 66811, 66781, 16195, 66812, 18440, 18437, 1534, 
18439, 66813, 66782, 16176, 16197
14687, 16450, 16449, 1461, 1462, 61743, 61733, 15847, 15857, 16945, 16944, 1484, 16946, 66815, 66785, 16198, 
66816, 66814, 66783, 16178, 16199
14688, 61743, 61733, 15847, 15857, 61744, 61734, 15848, 15858, 66815, 66785, 16198, 66816, 66818, 66788, 16200, 
66819, 66817, 66786, 16180, 16201
14689, 61744, 61734, 15848, 15858, 61745, 61735, 15849, 15859, 66818, 66788, 16200, 66819, 66821, 66791, 16202, 
66822, 66820, 66789, 16182, 16203
14690, 61745, 61735, 15849, 15859, 61746, 61736, 15850, 15860, 66821, 66791, 16202, 66822, 66824, 66794, 16204, 
66825, 66823, 66792, 16184, 16205
14691, 61746, 61736, 15850, 15860, 61747, 61737, 15851, 15861, 66824, 66794, 16204, 66825, 66827, 66797, 16206, 
66828, 66826, 66795, 16186, 16207
14692, 61747, 61737, 15851, 15861, 61748, 61738, 15852, 15862, 66827, 66797, 16206, 66828, 66830, 66800, 16208, 
66831, 66829, 66798, 16188, 16209
14693, 61748, 61738, 15852, 15862, 61749, 61739, 15853, 15863, 66830, 66800, 16208, 66831, 66833, 66803, 16210, 
66834, 66832, 66801, 16190, 16211
14694, 61749, 61739, 15853, 15863, 61750, 61740, 15854, 15864, 66833, 66803, 16210, 66834, 66836, 66806, 16212, 
66837, 66835, 66804, 16192, 16213
14695, 61750, 61740, 15854, 15864, 61751, 61741, 15855, 15865, 66836, 66806, 16212, 66837, 66839, 66809, 16214, 
66840, 66838, 66807, 16194, 16215
14696, 61751, 61741, 15855, 15865, 61752, 61742, 15856, 15866, 66839, 66809, 16214, 66840, 66842, 66812, 16216, 
66843, 66841, 66810, 16196, 16217
14697, 61752, 61742, 15856, 15866, 17946, 17945, 1512, 1513, 66842, 66812, 16216, 66843, 18442, 18439, 1535, 
18441, 66844, 66813, 16197, 16218
14698, 16451, 16450, 1462, 1463, 61753, 61743, 15857, 15867, 16947, 16946, 1485, 16948, 66846, 66816, 16219, 
66847, 66845, 66814, 16199, 16220
14699, 61753, 61743, 15857, 15867, 61754, 61744, 15858, 15868, 66846, 66816, 16219, 66847, 66849, 66819, 16221, 
66850, 66848, 66817, 16201, 16222
14700, 61754, 61744, 15858, 15868, 61755, 61745, 15859, 15869, 66849, 66819, 16221, 66850, 66852, 66822, 16223, 
66853, 66851, 66820, 16203, 16224
14701, 61755, 61745, 15859, 15869, 61756, 61746, 15860, 15870, 66852, 66822, 16223, 66853, 66855, 66825, 16225, 
66856, 66854, 66823, 16205, 16226
14702, 61756, 61746, 15860, 15870, 61757, 61747, 15861, 15871, 66855, 66825, 16225, 66856, 66858, 66828, 16227, 
66859, 66857, 66826, 16207, 16228
14703, 61757, 61747, 15861, 15871, 61758, 61748, 15862, 15872, 66858, 66828, 16227, 66859, 66861, 66831, 16229, 
66862, 66860, 66829, 16209, 16230
14704, 61758, 61748, 15862, 15872, 61759, 61749, 15863, 15873, 66861, 66831, 16229, 66862, 66864, 66834, 16231, 
66865, 66863, 66832, 16211, 16232
14705, 61759, 61749, 15863, 15873, 61760, 61750, 15864, 15874, 66864, 66834, 16231, 66865, 66867, 66837, 16233, 
66868, 66866, 66835, 16213, 16234
14706, 61760, 61750, 15864, 15874, 61761, 61751, 15865, 15875, 66867, 66837, 16233, 66868, 66870, 66840, 16235, 
66871, 66869, 66838, 16215, 16236
14707, 61761, 61751, 15865, 15875, 61762, 61752, 15866, 15876, 66870, 66840, 16235, 66871, 66873, 66843, 16237, 
66874, 66872, 66841, 16217, 16238
14708, 61762, 61752, 15866, 15876, 17947, 17946, 1513, 1514, 66873, 66843, 16237, 66874, 18444, 18441, 1536, 
18443, 66875, 66844, 16218, 16239
14709, 16452, 16451, 1463, 1464, 61763, 61753, 15867, 15877, 16949, 16948, 1486, 16950, 66877, 66847, 16240, 
66878, 66876, 66845, 16220, 16241
14710, 61763, 61753, 15867, 15877, 61764, 61754, 15868, 15878, 66877, 66847, 16240, 66878, 66880, 66850, 16242, 
66881, 66879, 66848, 16222, 16243
14711, 61764, 61754, 15868, 15878, 61765, 61755, 15869, 15879, 66880, 66850, 16242, 66881, 66883, 66853, 16244, 
66884, 66882, 66851, 16224, 16245
14712, 61765, 61755, 15869, 15879, 61766, 61756, 15870, 15880, 66883, 66853, 16244, 66884, 66886, 66856, 16246, 
66887, 66885, 66854, 16226, 16247
14713, 61766, 61756, 15870, 15880, 61767, 61757, 15871, 15881, 66886, 66856, 16246, 66887, 66889, 66859, 16248, 
66890, 66888, 66857, 16228, 16249
14714, 61767, 61757, 15871, 15881, 61768, 61758, 15872, 15882, 66889, 66859, 16248, 66890, 66892, 66862, 16250, 
66893, 66891, 66860, 16230, 16251
14715, 61768, 61758, 15872, 15882, 61769, 61759, 15873, 15883, 66892, 66862, 16250, 66893, 66895, 66865, 16252, 
66896, 66894, 66863, 16232, 16253
14716, 61769, 61759, 15873, 15883, 61770, 61760, 15874, 15884, 66895, 66865, 16252, 66896, 66898, 66868, 16254, 
66899, 66897, 66866, 16234, 16255
14717, 61770, 61760, 15874, 15884, 61771, 61761, 15875, 15885, 66898, 66868, 16254, 66899, 66901, 66871, 16256, 
66902, 66900, 66869, 16236, 16257
14718, 61771, 61761, 15875, 15885, 61772, 61762, 15876, 15886, 66901, 66871, 16256, 66902, 66904, 66874, 16258, 
66905, 66903, 66872, 16238, 16259
14719, 61772, 61762, 15876, 15886, 17948, 17947, 1514, 1515, 66904, 66874, 16258, 66905, 18446, 18443, 1537, 
18445, 66906, 66875, 16239, 16260
14720, 16453, 16452, 1464, 1465, 61773, 61763, 15877, 15887, 16951, 16950, 1487, 16952, 66908, 66878, 16261, 
66909, 66907, 66876, 16241, 16262
14721, 61773, 61763, 15877, 15887, 61774, 61764, 15878, 15888, 66908, 66878, 16261, 66909, 66911, 66881, 16263, 
66912, 66910, 66879, 16243, 16264
14722, 61774, 61764, 15878, 15888, 61775, 61765, 15879, 15889, 66911, 66881, 16263, 66912, 66914, 66884, 16265, 
66915, 66913, 66882, 16245, 16266
14723, 61775, 61765, 15879, 15889, 61776, 61766, 15880, 15890, 66914, 66884, 16265, 66915, 66917, 66887, 16267, 
66918, 66916, 66885, 16247, 16268
14724, 61776, 61766, 15880, 15890, 61777, 61767, 15881, 15891, 66917, 66887, 16267, 66918, 66920, 66890, 16269, 
66921, 66919, 66888, 16249, 16270
14725, 61777, 61767, 15881, 15891, 61778, 61768, 15882, 15892, 66920, 66890, 16269, 66921, 66923, 66893, 16271, 
66924, 66922, 66891, 16251, 16272
14726, 61778, 61768, 15882, 15892, 61779, 61769, 15883, 15893, 66923, 66893, 16271, 66924, 66926, 66896, 16273, 
66927, 66925, 66894, 16253, 16274
14727, 61779, 61769, 15883, 15893, 61780, 61770, 15884, 15894, 66926, 66896, 16273, 66927, 66929, 66899, 16275, 
66930, 66928, 66897, 16255, 16276
14728, 61780, 61770, 15884, 15894, 61781, 61771, 15885, 15895, 66929, 66899, 16275, 66930, 66932, 66902, 16277, 
66933, 66931, 66900, 16257, 16278
14729, 61781, 61771, 15885, 15895, 61782, 61772, 15886, 15896, 66932, 66902, 16277, 66933, 66935, 66905, 16279, 
66936, 66934, 66903, 16259, 16280
14730, 61782, 61772, 15886, 15896, 17949, 17948, 1515, 1516, 66935, 66905, 16279, 66936, 18448, 18445, 1538, 
18447, 66937, 66906, 16260, 16281
14731, 16454, 16453, 1465, 1466, 61783, 61773, 15887, 15897, 16953, 16952, 1488, 16954, 66939, 66909, 16282, 
66940, 66938, 66907, 16262, 16283
14732, 61783, 61773, 15887, 15897, 61784, 61774, 15888, 15898, 66939, 66909, 16282, 66940, 66942, 66912, 16284, 
66943, 66941, 66910, 16264, 16285
14733, 61784, 61774, 15888, 15898, 61785, 61775, 15889, 15899, 66942, 66912, 16284, 66943, 66945, 66915, 16286, 
66946, 66944, 66913, 16266, 16287
14734, 61785, 61775, 15889, 15899, 61786, 61776, 15890, 15900, 66945, 66915, 16286, 66946, 66948, 66918, 16288, 
66949, 66947, 66916, 16268, 16289
14735, 61786, 61776, 15890, 15900, 61787, 61777, 15891, 15901, 66948, 66918, 16288, 66949, 66951, 66921, 16290, 
66952, 66950, 66919, 16270, 16291
14736, 61787, 61777, 15891, 15901, 61788, 61778, 15892, 15902, 66951, 66921, 16290, 66952, 66954, 66924, 16292, 
66955, 66953, 66922, 16272, 16293
14737, 61788, 61778, 15892, 15902, 61789, 61779, 15893, 15903, 66954, 66924, 16292, 66955, 66957, 66927, 16294, 
66958, 66956, 66925, 16274, 16295
14738, 61789, 61779, 15893, 15903, 61790, 61780, 15894, 15904, 66957, 66927, 16294, 66958, 66960, 66930, 16296, 
66961, 66959, 66928, 16276, 16297
14739, 61790, 61780, 15894, 15904, 61791, 61781, 15895, 15905, 66960, 66930, 16296, 66961, 66963, 66933, 16298, 
66964, 66962, 66931, 16278, 16299
14740, 61791, 61781, 15895, 15905, 61792, 61782, 15896, 15906, 66963, 66933, 16298, 66964, 66966, 66936, 16300, 
66967, 66965, 66934, 16280, 16301
14741, 61792, 61782, 15896, 15906, 17950, 17949, 1516, 1517, 66966, 66936, 16300, 66967, 18450, 18447, 1539, 
18449, 66968, 66937, 16281, 16302
14742, 16455, 16454, 1466, 1467, 61793, 61783, 15897, 15907, 16955, 16954, 1489, 16956, 66970, 66940, 16303, 
66971, 66969, 66938, 16283, 16304
14743, 61793, 61783, 15897, 15907, 61794, 61784, 15898, 15908, 66970, 66940, 16303, 66971, 66973, 66943, 16305, 
66974, 66972, 66941, 16285, 16306
14744, 61794, 61784, 15898, 15908, 61795, 61785, 15899, 15909, 66973, 66943, 16305, 66974, 66976, 66946, 16307, 
66977, 66975, 66944, 16287, 16308
14745, 61795, 61785, 15899, 15909, 61796, 61786, 15900, 15910, 66976, 66946, 16307, 66977, 66979, 66949, 16309, 
66980, 66978, 66947, 16289, 16310
14746, 61796, 61786, 15900, 15910, 61797, 61787, 15901, 15911, 66979, 66949, 16309, 66980, 66982, 66952, 16311, 
66983, 66981, 66950, 16291, 16312
14747, 61797, 61787, 15901, 15911, 61798, 61788, 15902, 15912, 66982, 66952, 16311, 66983, 66985, 66955, 16313, 
66986, 66984, 66953, 16293, 16314
14748, 61798, 61788, 15902, 15912, 61799, 61789, 15903, 15913, 66985, 66955, 16313, 66986, 66988, 66958, 16315, 
66989, 66987, 66956, 16295, 16316
14749, 61799, 61789, 15903, 15913, 61800, 61790, 15904, 15914, 66988, 66958, 16315, 66989, 66991, 66961, 16317, 
66992, 66990, 66959, 16297, 16318
14750, 61800, 61790, 15904, 15914, 61801, 61791, 15905, 15915, 66991, 66961, 16317, 66992, 66994, 66964, 16319, 
66995, 66993, 66962, 16299, 16320
14751, 61801, 61791, 15905, 15915, 61802, 61792, 15906, 15916, 66994, 66964, 16319, 66995, 66997, 66967, 16321, 
66998, 66996, 66965, 16301, 16322
14752, 61802, 61792, 15906, 15916, 17951, 17950, 1517, 1518, 66997, 66967, 16321, 66998, 18452, 18449, 1540, 
18451, 66999, 66968, 16302, 16323
14753, 16456, 16455, 1467, 1468, 61803, 61793, 15907, 15917, 16957, 16956, 1490, 16958, 67001, 66971, 16324, 
67002, 67000, 66969, 16304, 16325
14754, 61803, 61793, 15907, 15917, 61804, 61794, 15908, 15918, 67001, 66971, 16324, 67002, 67004, 66974, 16326, 
67005, 67003, 66972, 16306, 16327
14755, 61804, 61794, 15908, 15918, 61805, 61795, 15909, 15919, 67004, 66974, 16326, 67005, 67007, 66977, 16328, 
67008, 67006, 66975, 16308, 16329
14756, 61805, 61795, 15909, 15919, 61806, 61796, 15910, 15920, 67007, 66977, 16328, 67008, 67010, 66980, 16330, 
67011, 67009, 66978, 16310, 16331
14757, 61806, 61796, 15910, 15920, 61807, 61797, 15911, 15921, 67010, 66980, 16330, 67011, 67013, 66983, 16332, 
67014, 67012, 66981, 16312, 16333
14758, 61807, 61797, 15911, 15921, 61808, 61798, 15912, 15922, 67013, 66983, 16332, 67014, 67016, 66986, 16334, 
67017, 67015, 66984, 16314, 16335
14759, 61808, 61798, 15912, 15922, 61809, 61799, 15913, 15923, 67016, 66986, 16334, 67017, 67019, 66989, 16336, 
67020, 67018, 66987, 16316, 16337
14760, 61809, 61799, 15913, 15923, 61810, 61800, 15914, 15924, 67019, 66989, 16336, 67020, 67022, 66992, 16338, 
67023, 67021, 66990, 16318, 16339
14761, 61810, 61800, 15914, 15924, 61811, 61801, 15915, 15925, 67022, 66992, 16338, 67023, 67025, 66995, 16340, 
67026, 67024, 66993, 16320, 16341
14762, 61811, 61801, 15915, 15925, 61812, 61802, 15916, 15926, 67025, 66995, 16340, 67026, 67028, 66998, 16342, 
67029, 67027, 66996, 16322, 16343
14763, 61812, 61802, 15916, 15926, 17952, 17951, 1518, 1519, 67028, 66998, 16342, 67029, 18454, 18451, 1541, 
18453, 67030, 66999, 16323, 16344
14764, 16457, 16456, 1468, 1469, 61813, 61803, 15917, 15927, 16959, 16958, 1491, 16960, 67032, 67002, 16345, 
67033, 67031, 67000, 16325, 16346
14765, 61813, 61803, 15917, 15927, 61814, 61804, 15918, 15928, 67032, 67002, 16345, 67033, 67035, 67005, 16347, 
67036, 67034, 67003, 16327, 16348
14766, 61814, 61804, 15918, 15928, 61815, 61805, 15919, 15929, 67035, 67005, 16347, 67036, 67038, 67008, 16349, 
67039, 67037, 67006, 16329, 16350
14767, 61815, 61805, 15919, 15929, 61816, 61806, 15920, 15930, 67038, 67008, 16349, 67039, 67041, 67011, 16351, 
67042, 67040, 67009, 16331, 16352
14768, 61816, 61806, 15920, 15930, 61817, 61807, 15921, 15931, 67041, 67011, 16351, 67042, 67044, 67014, 16353, 
67045, 67043, 67012, 16333, 16354
14769, 61817, 61807, 15921, 15931, 61818, 61808, 15922, 15932, 67044, 67014, 16353, 67045, 67047, 67017, 16355, 
67048, 67046, 67015, 16335, 16356
14770, 61818, 61808, 15922, 15932, 61819, 61809, 15923, 15933, 67047, 67017, 16355, 67048, 67050, 67020, 16357, 
67051, 67049, 67018, 16337, 16358
14771, 61819, 61809, 15923, 15933, 61820, 61810, 15924, 15934, 67050, 67020, 16357, 67051, 67053, 67023, 16359, 
67054, 67052, 67021, 16339, 16360
14772, 61820, 61810, 15924, 15934, 61821, 61811, 15925, 15935, 67053, 67023, 16359, 67054, 67056, 67026, 16361, 
67057, 67055, 67024, 16341, 16362
14773, 61821, 61811, 15925, 15935, 61822, 61812, 15926, 15936, 67056, 67026, 16361, 67057, 67059, 67029, 16363, 
67060, 67058, 67027, 16343, 16364
14774, 61822, 61812, 15926, 15936, 17953, 17952, 1519, 1520, 67059, 67029, 16363, 67060, 18456, 18453, 1542, 
18455, 67061, 67030, 16344, 16365
14775, 16458, 16457, 1469, 1470, 61823, 61813, 15927, 15937, 16961, 16960, 1492, 16962, 67063, 67033, 16366, 
67064, 67062, 67031, 16346, 16367
14776, 61823, 61813, 15927, 15937, 61824, 61814, 15928, 15938, 67063, 67033, 16366, 67064, 67066, 67036, 16368, 
67067, 67065, 67034, 16348, 16369
14777, 61824, 61814, 15928, 15938, 61825, 61815, 15929, 15939, 67066, 67036, 16368, 67067, 67069, 67039, 16370, 
67070, 67068, 67037, 16350, 16371
14778, 61825, 61815, 15929, 15939, 61826, 61816, 15930, 15940, 67069, 67039, 16370, 67070, 67072, 67042, 16372, 
67073, 67071, 67040, 16352, 16373
14779, 61826, 61816, 15930, 15940, 61827, 61817, 15931, 15941, 67072, 67042, 16372, 67073, 67075, 67045, 16374, 
67076, 67074, 67043, 16354, 16375
14780, 61827, 61817, 15931, 15941, 61828, 61818, 15932, 15942, 67075, 67045, 16374, 67076, 67078, 67048, 16376, 
67079, 67077, 67046, 16356, 16377
14781, 61828, 61818, 15932, 15942, 61829, 61819, 15933, 15943, 67078, 67048, 16376, 67079, 67081, 67051, 16378, 
67082, 67080, 67049, 16358, 16379
14782, 61829, 61819, 15933, 15943, 61830, 61820, 15934, 15944, 67081, 67051, 16378, 67082, 67084, 67054, 16380, 
67085, 67083, 67052, 16360, 16381
14783, 61830, 61820, 15934, 15944, 61831, 61821, 15935, 15945, 67084, 67054, 16380, 67085, 67087, 67057, 16382, 
67088, 67086, 67055, 16362, 16383
14784, 61831, 61821, 15935, 15945, 61832, 61822, 15936, 15946, 67087, 67057, 16382, 67088, 67090, 67060, 16384, 
67091, 67089, 67058, 16364, 16385
14785, 61832, 61822, 15936, 15946, 17954, 17953, 1520, 1521, 67090, 67060, 16384, 67091, 18458, 18455, 1543, 
18457, 67092, 67061, 16365, 16386
14786, 16459, 16458, 1470, 1471, 61833, 61823, 15937, 15947, 16963, 16962, 1493, 16964, 67094, 67064, 16387, 
67095, 67093, 67062, 16367, 16388
14787, 61833, 61823, 15937, 15947, 61834, 61824, 15938, 15948, 67094, 67064, 16387, 67095, 67097, 67067, 16389, 
67098, 67096, 67065, 16369, 16390
14788, 61834, 61824, 15938, 15948, 61835, 61825, 15939, 15949, 67097, 67067, 16389, 67098, 67100, 67070, 16391, 
67101, 67099, 67068, 16371, 16392
14789, 61835, 61825, 15939, 15949, 61836, 61826, 15940, 15950, 67100, 67070, 16391, 67101, 67103, 67073, 16393, 
67104, 67102, 67071, 16373, 16394
14790, 61836, 61826, 15940, 15950, 61837, 61827, 15941, 15951, 67103, 67073, 16393, 67104, 67106, 67076, 16395, 
67107, 67105, 67074, 16375, 16396
14791, 61837, 61827, 15941, 15951, 61838, 61828, 15942, 15952, 67106, 67076, 16395, 67107, 67109, 67079, 16397, 
67110, 67108, 67077, 16377, 16398
14792, 61838, 61828, 15942, 15952, 61839, 61829, 15943, 15953, 67109, 67079, 16397, 67110, 67112, 67082, 16399, 
67113, 67111, 67080, 16379, 16400
14793, 61839, 61829, 15943, 15953, 61840, 61830, 15944, 15954, 67112, 67082, 16399, 67113, 67115, 67085, 16401, 
67116, 67114, 67083, 16381, 16402
14794, 61840, 61830, 15944, 15954, 61841, 61831, 15945, 15955, 67115, 67085, 16401, 67116, 67118, 67088, 16403, 
67119, 67117, 67086, 16383, 16404
14795, 61841, 61831, 15945, 15955, 61842, 61832, 15946, 15956, 67118, 67088, 16403, 67119, 67121, 67091, 16405, 
67122, 67120, 67089, 16385, 16406
14796, 61842, 61832, 15946, 15956, 17955, 17954, 1521, 1522, 67121, 67091, 16405, 67122, 18460, 18457, 1544, 
18459, 67123, 67092, 16386, 16407
14797, 16460, 16459, 1471, 1472, 61843, 61833, 15947, 15957, 16965, 16964, 1494, 16966, 67125, 67095, 16408, 
67126, 67124, 67093, 16388, 16409
14798, 61843, 61833, 15947, 15957, 61844, 61834, 15948, 15958, 67125, 67095, 16408, 67126, 67128, 67098, 16410, 
67129, 67127, 67096, 16390, 16411
14799, 61844, 61834, 15948, 15958, 61845, 61835, 15949, 15959, 67128, 67098, 16410, 67129, 67131, 67101, 16412, 
67132, 67130, 67099, 16392, 16413
14800, 61845, 61835, 15949, 15959, 61846, 61836, 15950, 15960, 67131, 67101, 16412, 67132, 67134, 67104, 16414, 
67135, 67133, 67102, 16394, 16415
14801, 61846, 61836, 15950, 15960, 61847, 61837, 15951, 15961, 67134, 67104, 16414, 67135, 67137, 67107, 16416, 
67138, 67136, 67105, 16396, 16417
14802, 61847, 61837, 15951, 15961, 61848, 61838, 15952, 15962, 67137, 67107, 16416, 67138, 67140, 67110, 16418, 
67141, 67139, 67108, 16398, 16419
14803, 61848, 61838, 15952, 15962, 61849, 61839, 15953, 15963, 67140, 67110, 16418, 67141, 67143, 67113, 16420, 
67144, 67142, 67111, 16400, 16421
14804, 61849, 61839, 15953, 15963, 61850, 61840, 15954, 15964, 67143, 67113, 16420, 67144, 67146, 67116, 16422, 
67147, 67145, 67114, 16402, 16423
14805, 61850, 61840, 15954, 15964, 61851, 61841, 15955, 15965, 67146, 67116, 16422, 67147, 67149, 67119, 16424, 
67150, 67148, 67117, 16404, 16425
14806, 61851, 61841, 15955, 15965, 61852, 61842, 15956, 15966, 67149, 67119, 16424, 67150, 67152, 67122, 16426, 
67153, 67151, 67120, 16406, 16427
14807, 61852, 61842, 15956, 15966, 17956, 17955, 1522, 1523, 67152, 67122, 16426, 67153, 18462, 18459, 1545, 
18461, 67154, 67123, 16407, 16428
14808, 1634, 16460, 1472, 34, 20123, 61843, 15957, 1577, 16967, 16966, 1495, 1656, 67155, 67126, 16429, 
20344, 20343, 67124, 16409, 1588
14809, 20123, 61843, 15957, 1577, 20124, 61844, 15958, 1576, 67155, 67126, 16429, 20344, 67156, 67129, 16430, 
20346, 20345, 67127, 16411, 1587
14810, 20124, 61844, 15958, 1576, 20125, 61845, 15959, 1575, 67156, 67129, 16430, 20346, 67157, 67132, 16431, 
20348, 20347, 67130, 16413, 1586
14811, 20125, 61845, 15959, 1575, 20126, 61846, 15960, 1574, 67157, 67132, 16431, 20348, 67158, 67135, 16432, 
20350, 20349, 67133, 16415, 1585
14812, 20126, 61846, 15960, 1574, 20127, 61847, 15961, 1573, 67158, 67135, 16432, 20350, 67159, 67138, 16433, 
20352, 20351, 67136, 16417, 1584
14813, 20127, 61847, 15961, 1573, 20128, 61848, 15962, 1572, 67159, 67138, 16433, 20352, 67160, 67141, 16434, 
20354, 20353, 67139, 16419, 1583
14814, 20128, 61848, 15962, 1572, 20129, 61849, 15963, 1571, 67160, 67141, 16434, 20354, 67161, 67144, 16435, 
20356, 20355, 67142, 16421, 1582
14815, 20129, 61849, 15963, 1571, 20130, 61850, 15964, 1570, 67161, 67144, 16435, 20356, 67162, 67147, 16436, 
20358, 20357, 67145, 16423, 1581
14816, 20130, 61850, 15964, 1570, 20131, 61851, 15965, 1569, 67162, 67147, 16436, 20358, 67163, 67150, 16437, 
20360, 20359, 67148, 16425, 1580
14817, 20131, 61851, 15965, 1569, 20132, 61852, 15966, 1568, 67163, 67150, 16437, 20360, 67164, 67153, 16438, 
20362, 20361, 67151, 16427, 1579
14818, 20132, 61852, 15966, 1568, 1769, 17956, 1523, 36, 67164, 67153, 16438, 20362, 18463, 18461, 1546, 
1791, 20363, 67154, 16428, 1578
14819, 16461, 1590, 1589, 16439, 61853, 19441, 19431, 61633, 16968, 1612, 16923, 16969, 67166, 19672, 66474, 
67167, 67165, 19673, 19652, 66473
14820, 61853, 19441, 19431, 61633, 61854, 19442, 19432, 61634, 67166, 19672, 66474, 67167, 67169, 19674, 66477, 
67170, 67168, 19675, 19654, 66476
14821, 61854, 19442, 19432, 61634, 61855, 19443, 19433, 61635, 67169, 19674, 66477, 67170, 67172, 19676, 66480, 
67173, 67171, 19677, 19656, 66479
14822, 61855, 19443, 19433, 61635, 61856, 19444, 19434, 61636, 67172, 19676, 66480, 67173, 67175, 19678, 66483, 
67176, 67174, 19679, 19658, 66482
14823, 61856, 19444, 19434, 61636, 61857, 19445, 19435, 61637, 67175, 19678, 66483, 67176, 67178, 19680, 66486, 
67179, 67177, 19681, 19660, 66485
14824, 61857, 19445, 19435, 61637, 61858, 19446, 19436, 61638, 67178, 19680, 66486, 67179, 67181, 19682, 66489, 
67182, 67180, 19683, 19662, 66488
14825, 61858, 19446, 19436, 61638, 61859, 19447, 19437, 61639, 67181, 19682, 66489, 67182, 67184, 19684, 66492, 
67185, 67183, 19685, 19664, 66491
14826, 61859, 19447, 19437, 61639, 61860, 19448, 19438, 61640, 67184, 19684, 66492, 67185, 67187, 19686, 66495, 
67188, 67186, 19687, 19666, 66494
14827, 61860, 19448, 19438, 61640, 61861, 19449, 19439, 61641, 67187, 19686, 66495, 67188, 67190, 19688, 66498, 
67191, 67189, 19689, 19668, 66497
14828, 61861, 19449, 19439, 61641, 61862, 19450, 19440, 61642, 67190, 19688, 66498, 67191, 67193, 19690, 66501, 
67194, 67192, 19691, 19670, 66500
14829, 61862, 19450, 19440, 61642, 17957, 1725, 1724, 17935, 67193, 19690, 66501, 67194, 18465, 1747, 18420, 
18464, 67195, 19692, 19671, 66503
14830, 16462, 16461, 16439, 16440, 61863, 61853, 61633, 61643, 16970, 16969, 16925, 16971, 67197, 67167, 66505, 
67198, 67196, 67165, 66473, 66504
14831, 61863, 61853, 61633, 61643, 61864, 61854, 61634, 61644, 67197, 67167, 66505, 67198, 67200, 67170, 66508, 
67201, 67199, 67168, 66476, 66507
14832, 61864, 61854, 61634, 61644, 61865, 61855, 61635, 61645, 67200, 67170, 66508, 67201, 67203, 67173, 66511, 
67204, 67202, 67171, 66479, 66510
14833, 61865, 61855, 61635, 61645, 61866, 61856, 61636, 61646, 67203, 67173, 66511, 67204, 67206, 67176, 66514, 
67207, 67205, 67174, 66482, 66513
14834, 61866, 61856, 61636, 61646, 61867, 61857, 61637, 61647, 67206, 67176, 66514, 67207, 67209, 67179, 66517, 
67210, 67208, 67177, 66485, 66516
14835, 61867, 61857, 61637, 61647, 61868, 61858, 61638, 61648, 67209, 67179, 66517, 67210, 67212, 67182, 66520, 
67213, 67211, 67180, 66488, 66519
14836, 61868, 61858, 61638, 61648, 61869, 61859, 61639, 61649, 67212, 67182, 66520, 67213, 67215, 67185, 66523, 
67216, 67214, 67183, 66491, 66522
14837, 61869, 61859, 61639, 61649, 61870, 61860, 61640, 61650, 67215, 67185, 66523, 67216, 67218, 67188, 66526, 
67219, 67217, 67186, 66494, 66525
14838, 61870, 61860, 61640, 61650, 61871, 61861, 61641, 61651, 67218, 67188, 66526, 67219, 67221, 67191, 66529, 
67222, 67220, 67189, 66497, 66528
14839, 61871, 61861, 61641, 61651, 61872, 61862, 61642, 61652, 67221, 67191, 66529, 67222, 67224, 67194, 66532, 
67225, 67223, 67192, 66500, 66531
14840, 61872, 61862, 61642, 61652, 17958, 17957, 17935, 17936, 67224, 67194, 66532, 67225, 18467, 18464, 18422, 
18466, 67226, 67195, 66503, 66534
14841, 16463, 16462, 16440, 16441, 61873, 61863, 61643, 61653, 16972, 16971, 16927, 16973, 67228, 67198, 66536, 
67229, 67227, 67196, 66504, 66535
14842, 61873, 61863, 61643, 61653, 61874, 61864, 61644, 61654, 67228, 67198, 66536, 67229, 67231, 67201, 66539, 
67232, 67230, 67199, 66507, 66538
14843, 61874, 61864, 61644, 61654, 61875, 61865, 61645, 61655, 67231, 67201, 66539, 67232, 67234, 67204, 66542, 
67235, 67233, 67202, 66510, 66541
14844, 61875, 61865, 61645, 61655, 61876, 61866, 61646, 61656, 67234, 67204, 66542, 67235, 67237, 67207, 66545, 
67238, 67236, 67205, 66513, 66544
14845, 61876, 61866, 61646, 61656, 61877, 61867, 61647, 61657, 67237, 67207, 66545, 67238, 67240, 67210, 66548, 
67241, 67239, 67208, 66516, 66547
14846, 61877, 61867, 61647, 61657, 61878, 61868, 61648, 61658, 67240, 67210, 66548, 67241, 67243, 67213, 66551, 
67244, 67242, 67211, 66519, 66550
14847, 61878, 61868, 61648, 61658, 61879, 61869, 61649, 61659, 67243, 67213, 66551, 67244, 67246, 67216, 66554, 
67247, 67245, 67214, 66522, 66553
14848, 61879, 61869, 61649, 61659, 61880, 61870, 61650, 61660, 67246, 67216, 66554, 67247, 67249, 67219, 66557, 
67250, 67248, 67217, 66525, 66556
14849, 61880, 61870, 61650, 61660, 61881, 61871, 61651, 61661, 67249, 67219, 66557, 67250, 67252, 67222, 66560, 
67253, 67251, 67220, 66528, 66559
14850, 61881, 61871, 61651, 61661, 61882, 61872, 61652, 61662, 67252, 67222, 66560, 67253, 67255, 67225, 66563, 
67256, 67254, 67223, 66531, 66562
14851, 61882, 61872, 61652, 61662, 17959, 17958, 17936, 17937, 67255, 67225, 66563, 67256, 18469, 18466, 18424, 
18468, 67257, 67226, 66534, 66565
14852, 16464, 16463, 16441, 16442, 61883, 61873, 61653, 61663, 16974, 16973, 16929, 16975, 67259, 67229, 66567, 
67260, 67258, 67227, 66535, 66566
14853, 61883, 61873, 61653, 61663, 61884, 61874, 61654, 61664, 67259, 67229, 66567, 67260, 67262, 67232, 66570, 
67263, 67261, 67230, 66538, 66569
14854, 61884, 61874, 61654, 61664, 61885, 61875, 61655, 61665, 67262, 67232, 66570, 67263, 67265, 67235, 66573, 
67266, 67264, 67233, 66541, 66572
14855, 61885, 61875, 61655, 61665, 61886, 61876, 61656, 61666, 67265, 67235, 66573, 67266, 67268, 67238, 66576, 
67269, 67267, 67236, 66544, 66575
14856, 61886, 61876, 61656, 61666, 61887, 61877, 61657, 61667, 67268, 67238, 66576, 67269, 67271, 67241, 66579, 
67272, 67270, 67239, 66547, 66578
14857, 61887, 61877, 61657, 61667, 61888, 61878, 61658, 61668, 67271, 67241, 66579, 67272, 67274, 67244, 66582, 
67275, 67273, 67242, 66550, 66581
14858, 61888, 61878, 61658, 61668, 61889, 61879, 61659, 61669, 67274, 67244, 66582, 67275, 67277, 67247, 66585, 
67278, 67276, 67245, 66553, 66584
14859, 61889, 61879, 61659, 61669, 61890, 61880, 61660, 61670, 67277, 67247, 66585, 67278, 67280, 67250, 66588, 
67281, 67279, 67248, 66556, 66587
14860, 61890, 61880, 61660, 61670, 61891, 61881, 61661, 61671, 67280, 67250, 66588, 67281, 67283, 67253, 66591, 
67284, 67282, 67251, 66559, 66590
14861, 61891, 61881, 61661, 61671, 61892, 61882, 61662, 61672, 67283, 67253, 66591, 67284, 67286, 67256, 66594, 
67287, 67285, 67254, 66562, 66593
14862, 61892, 61882, 61662, 61672, 17960, 17959, 17937, 17938, 67286, 67256, 66594, 67287, 18471, 18468, 18426, 
18470, 67288, 67257, 66565, 66596
14863, 16465, 16464, 16442, 16443, 61893, 61883, 61663, 61673, 16976, 16975, 16931, 16977, 67290, 67260, 66598, 
67291, 67289, 67258, 66566, 66597
14864, 61893, 61883, 61663, 61673, 61894, 61884, 61664, 61674, 67290, 67260, 66598, 67291, 67293, 67263, 66601, 
67294, 67292, 67261, 66569, 66600
14865, 61894, 61884, 61664, 61674, 61895, 61885, 61665, 61675, 67293, 67263, 66601, 67294, 67296, 67266, 66604, 
67297, 67295, 67264, 66572, 66603
14866, 61895, 61885, 61665, 61675, 61896, 61886, 61666, 61676, 67296, 67266, 66604, 67297, 67299, 67269, 66607, 
67300, 67298, 67267, 66575, 66606
14867, 61896, 61886, 61666, 61676, 61897, 61887, 61667, 61677, 67299, 67269, 66607, 67300, 67302, 67272, 66610, 
67303, 67301, 67270, 66578, 66609
14868, 61897, 61887, 61667, 61677, 61898, 61888, 61668, 61678, 67302, 67272, 66610, 67303, 67305, 67275, 66613, 
67306, 67304, 67273, 66581, 66612
14869, 61898, 61888, 61668, 61678, 61899, 61889, 61669, 61679, 67305, 67275, 66613, 67306, 67308, 67278, 66616, 
67309, 67307, 67276, 66584, 66615
14870, 61899, 61889, 61669, 61679, 61900, 61890, 61670, 61680, 67308, 67278, 66616, 67309, 67311, 67281, 66619, 
67312, 67310, 67279, 66587, 66618
14871, 61900, 61890, 61670, 61680, 61901, 61891, 61671, 61681, 67311, 67281, 66619, 67312, 67314, 67284, 66622, 
67315, 67313, 67282, 66590, 66621
14872, 61901, 61891, 61671, 61681, 61902, 61892, 61672, 61682, 67314, 67284, 66622, 67315, 67317, 67287, 66625, 
67318, 67316, 67285, 66593, 66624
14873, 61902, 61892, 61672, 61682, 17961, 17960, 17938, 17939, 67317, 67287, 66625, 67318, 18473, 18470, 18428, 
18472, 67319, 67288, 66596, 66627
14874, 16466, 16465, 16443, 16444, 61903, 61893, 61673, 61683, 16978, 16977, 16933, 16979, 67321, 67291, 66629, 
67322, 67320, 67289, 66597, 66628
14875, 61903, 61893, 61673, 61683, 61904, 61894, 61674, 61684, 67321, 67291, 66629, 67322, 67324, 67294, 66632, 
67325, 67323, 67292, 66600, 66631
14876, 61904, 61894, 61674, 61684, 61905, 61895, 61675, 61685, 67324, 67294, 66632, 67325, 67327, 67297, 66635, 
67328, 67326, 67295, 66603, 66634
14877, 61905, 61895, 61675, 61685, 61906, 61896, 61676, 61686, 67327, 67297, 66635, 67328, 67330, 67300, 66638, 
67331, 67329, 67298, 66606, 66637
14878, 61906, 61896, 61676, 61686, 61907, 61897, 61677, 61687, 67330, 67300, 66638, 67331, 67333, 67303, 66641, 
67334, 67332, 67301, 66609, 66640
14879, 61907, 61897, 61677, 61687, 61908, 61898, 61678, 61688, 67333, 67303, 66641, 67334, 67336, 67306, 66644, 
67337, 67335, 67304, 66612, 66643
14880, 61908, 61898, 61678, 61688, 61909, 61899, 61679, 61689, 67336, 67306, 66644, 67337, 67339, 67309, 66647, 
67340, 67338, 67307, 66615, 66646
14881, 61909, 61899, 61679, 61689, 61910, 61900, 61680, 61690, 67339, 67309, 66647, 67340, 67342, 67312, 66650, 
67343, 67341, 67310, 66618, 66649
14882, 61910, 61900, 61680, 61690, 61911, 61901, 61681, 61691, 67342, 67312, 66650, 67343, 67345, 67315, 66653, 
67346, 67344, 67313, 66621, 66652
14883, 61911, 61901, 61681, 61691, 61912, 61902, 61682, 61692, 67345, 67315, 66653, 67346, 67348, 67318, 66656, 
67349, 67347, 67316, 66624, 66655
14884, 61912, 61902, 61682, 61692, 17962, 17961, 17939, 17940, 67348, 67318, 66656, 67349, 18475, 18472, 18430, 
18474, 67350, 67319, 66627, 66658
14885, 16467, 16466, 16444, 16445, 61913, 61903, 61683, 61693, 16980, 16979, 16935, 16981, 67352, 67322, 66660, 
67353, 67351, 67320, 66628, 66659
14886, 61913, 61903, 61683, 61693, 61914, 61904, 61684, 61694, 67352, 67322, 66660, 67353, 67355, 67325, 66663, 
67356, 67354, 67323, 66631, 66662
14887, 61914, 61904, 61684, 61694, 61915, 61905, 61685, 61695, 67355, 67325, 66663, 67356, 67358, 67328, 66666, 
67359, 67357, 67326, 66634, 66665
14888, 61915, 61905, 61685, 61695, 61916, 61906, 61686, 61696, 67358, 67328, 66666, 67359, 67361, 67331, 66669, 
67362, 67360, 67329, 66637, 66668
14889, 61916, 61906, 61686, 61696, 61917, 61907, 61687, 61697, 67361, 67331, 66669, 67362, 67364, 67334, 66672, 
67365, 67363, 67332, 66640, 66671
14890, 61917, 61907, 61687, 61697, 61918, 61908, 61688, 61698, 67364, 67334, 66672, 67365, 67367, 67337, 66675, 
67368, 67366, 67335, 66643, 66674
14891, 61918, 61908, 61688, 61698, 61919, 61909, 61689, 61699, 67367, 67337, 66675, 67368, 67370, 67340, 66678, 
67371, 67369, 67338, 66646, 66677
14892, 61919, 61909, 61689, 61699, 61920, 61910, 61690, 61700, 67370, 67340, 66678, 67371, 67373, 67343, 66681, 
67374, 67372, 67341, 66649, 66680
14893, 61920, 61910, 61690, 61700, 61921, 61911, 61691, 61701, 67373, 67343, 66681, 67374, 67376, 67346, 66684, 
67377, 67375, 67344, 66652, 66683
14894, 61921, 61911, 61691, 61701, 61922, 61912, 61692, 61702, 67376, 67346, 66684, 67377, 67379, 67349, 66687, 
67380, 67378, 67347, 66655, 66686
14895, 61922, 61912, 61692, 61702, 17963, 17962, 17940, 17941, 67379, 67349, 66687, 67380, 18477, 18474, 18432, 
18476, 67381, 67350, 66658, 66689
14896, 16468, 16467, 16445, 16446, 61923, 61913, 61693, 61703, 16982, 16981, 16937, 16983, 67383, 67353, 66691, 
67384, 67382, 67351, 66659, 66690
14897, 61923, 61913, 61693, 61703, 61924, 61914, 61694, 61704, 67383, 67353, 66691, 67384, 67386, 67356, 66694, 
67387, 67385, 67354, 66662, 66693
14898, 61924, 61914, 61694, 61704, 61925, 61915, 61695, 61705, 67386, 67356, 66694, 67387, 67389, 67359, 66697, 
67390, 67388, 67357, 66665, 66696
14899, 61925, 61915, 61695, 61705, 61926, 61916, 61696, 61706, 67389, 67359, 66697, 67390, 67392, 67362, 66700, 
67393, 67391, 67360, 66668, 66699
14900, 61926, 61916, 61696, 61706, 61927, 61917, 61697, 61707, 67392, 67362, 66700, 67393, 67395, 67365, 66703, 
67396, 67394, 67363, 66671, 66702
14901, 61927, 61917, 61697, 61707, 61928, 61918, 61698, 61708, 67395, 67365, 66703, 67396, 67398, 67368, 66706, 
67399, 67397, 67366, 66674, 66705
14902, 61928, 61918, 61698, 61708, 61929, 61919, 61699, 61709, 67398, 67368, 66706, 67399, 67401, 67371, 66709, 
67402, 67400, 67369, 66677, 66708
14903, 61929, 61919, 61699, 61709, 61930, 61920, 61700, 61710, 67401, 67371, 66709, 67402, 67404, 67374, 66712, 
67405, 67403, 67372, 66680, 66711
14904, 61930, 61920, 61700, 61710, 61931, 61921, 61701, 61711, 67404, 67374, 66712, 67405, 67407, 67377, 66715, 
67408, 67406, 67375, 66683, 66714
14905, 61931, 61921, 61701, 61711, 61932, 61922, 61702, 61712, 67407, 67377, 66715, 67408, 67410, 67380, 66718, 
67411, 67409, 67378, 66686, 66717
14906, 61932, 61922, 61702, 61712, 17964, 17963, 17941, 17942, 67410, 67380, 66718, 67411, 18479, 18476, 18434, 
18478, 67412, 67381, 66689, 66720
14907, 16469, 16468, 16446, 16447, 61933, 61923, 61703, 61713, 16984, 16983, 16939, 16985, 67414, 67384, 66722, 
67415, 67413, 67382, 66690, 66721
14908, 61933, 61923, 61703, 61713, 61934, 61924, 61704, 61714, 67414, 67384, 66722, 67415, 67417, 67387, 66725, 
67418, 67416, 67385, 66693, 66724
14909, 61934, 61924, 61704, 61714, 61935, 61925, 61705, 61715, 67417, 67387, 66725, 67418, 67420, 67390, 66728, 
67421, 67419, 67388, 66696, 66727
14910, 61935, 61925, 61705, 61715, 61936, 61926, 61706, 61716, 67420, 67390, 66728, 67421, 67423, 67393, 66731, 
67424, 67422, 67391, 66699, 66730
14911, 61936, 61926, 61706, 61716, 61937, 61927, 61707, 61717, 67423, 67393, 66731, 67424, 67426, 67396, 66734, 
67427, 67425, 67394, 66702, 66733
14912, 61937, 61927, 61707, 61717, 61938, 61928, 61708, 61718, 67426, 67396, 66734, 67427, 67429, 67399, 66737, 
67430, 67428, 67397, 66705, 66736
14913, 61938, 61928, 61708, 61718, 61939, 61929, 61709, 61719, 67429, 67399, 66737, 67430, 67432, 67402, 66740, 
67433, 67431, 67400, 66708, 66739
14914, 61939, 61929, 61709, 61719, 61940, 61930, 61710, 61720, 67432, 67402, 66740, 67433, 67435, 67405, 66743, 
67436, 67434, 67403, 66711, 66742
14915, 61940, 61930, 61710, 61720, 61941, 61931, 61711, 61721, 67435, 67405, 66743, 67436, 67438, 67408, 66746, 
67439, 67437, 67406, 66714, 66745
14916, 61941, 61931, 61711, 61721, 61942, 61932, 61712, 61722, 67438, 67408, 66746, 67439, 67441, 67411, 66749, 
67442, 67440, 67409, 66717, 66748
14917, 61942, 61932, 61712, 61722, 17965, 17964, 17942, 17943, 67441, 67411, 66749, 67442, 18481, 18478, 18436, 
18480, 67443, 67412, 66720, 66751
14918, 16470, 16469, 16447, 16448, 61943, 61933, 61713, 61723, 16986, 16985, 16941, 16987, 67445, 67415, 66753, 
67446, 67444, 67413, 66721, 66752
14919, 61943, 61933, 61713, 61723, 61944, 61934, 61714, 61724, 67445, 67415, 66753, 67446, 67448, 67418, 66756, 
67449, 67447, 67416, 66724, 66755
14920, 61944, 61934, 61714, 61724, 61945, 61935, 61715, 61725, 67448, 67418, 66756, 67449, 67451, 67421, 66759, 
67452, 67450, 67419, 66727, 66758
14921, 61945, 61935, 61715, 61725, 61946, 61936, 61716, 61726, 67451, 67421, 66759, 67452, 67454, 67424, 66762, 
67455, 67453, 67422, 66730, 66761
14922, 61946, 61936, 61716, 61726, 61947, 61937, 61717, 61727, 67454, 67424, 66762, 67455, 67457, 67427, 66765, 
67458, 67456, 67425, 66733, 66764
14923, 61947, 61937, 61717, 61727, 61948, 61938, 61718, 61728, 67457, 67427, 66765, 67458, 67460, 67430, 66768, 
67461, 67459, 67428, 66736, 66767
14924, 61948, 61938, 61718, 61728, 61949, 61939, 61719, 61729, 67460, 67430, 66768, 67461, 67463, 67433, 66771, 
67464, 67462, 67431, 66739, 66770
14925, 61949, 61939, 61719, 61729, 61950, 61940, 61720, 61730, 67463, 67433, 66771, 67464, 67466, 67436, 66774, 
67467, 67465, 67434, 66742, 66773
14926, 61950, 61940, 61720, 61730, 61951, 61941, 61721, 61731, 67466, 67436, 66774, 67467, 67469, 67439, 66777, 
67470, 67468, 67437, 66745, 66776
14927, 61951, 61941, 61721, 61731, 61952, 61942, 61722, 61732, 67469, 67439, 66777, 67470, 67472, 67442, 66780, 
67473, 67471, 67440, 66748, 66779
14928, 61952, 61942, 61722, 61732, 17966, 17965, 17943, 17944, 67472, 67442, 66780, 67473, 18483, 18480, 18438, 
18482, 67474, 67443, 66751, 66782
14929, 16471, 16470, 16448, 16449, 61953, 61943, 61723, 61733, 16988, 16987, 16943, 16989, 67476, 67446, 66784, 
67477, 67475, 67444, 66752, 66783
14930, 61953, 61943, 61723, 61733, 61954, 61944, 61724, 61734, 67476, 67446, 66784, 67477, 67479, 67449, 66787, 
67480, 67478, 67447, 66755, 66786
14931, 61954, 61944, 61724, 61734, 61955, 61945, 61725, 61735, 67479, 67449, 66787, 67480, 67482, 67452, 66790, 
67483, 67481, 67450, 66758, 66789
14932, 61955, 61945, 61725, 61735, 61956, 61946, 61726, 61736, 67482, 67452, 66790, 67483, 67485, 67455, 66793, 
67486, 67484, 67453, 66761, 66792
14933, 61956, 61946, 61726, 61736, 61957, 61947, 61727, 61737, 67485, 67455, 66793, 67486, 67488, 67458, 66796, 
67489, 67487, 67456, 66764, 66795
14934, 61957, 61947, 61727, 61737, 61958, 61948, 61728, 61738, 67488, 67458, 66796, 67489, 67491, 67461, 66799, 
67492, 67490, 67459, 66767, 66798
14935, 61958, 61948, 61728, 61738, 61959, 61949, 61729, 61739, 67491, 67461, 66799, 67492, 67494, 67464, 66802, 
67495, 67493, 67462, 66770, 66801
14936, 61959, 61949, 61729, 61739, 61960, 61950, 61730, 61740, 67494, 67464, 66802, 67495, 67497, 67467, 66805, 
67498, 67496, 67465, 66773, 66804
14937, 61960, 61950, 61730, 61740, 61961, 61951, 61731, 61741, 67497, 67467, 66805, 67498, 67500, 67470, 66808, 
67501, 67499, 67468, 66776, 66807
14938, 61961, 61951, 61731, 61741, 61962, 61952, 61732, 61742, 67500, 67470, 66808, 67501, 67503, 67473, 66811, 
67504, 67502, 67471, 66779, 66810
14939, 61962, 61952, 61732, 61742, 17967, 17966, 17944, 17945, 67503, 67473, 66811, 67504, 18485, 18482, 18440, 
18484, 67505, 67474, 66782, 66813
14940, 16472, 16471, 16449, 16450, 61963, 61953, 61733, 61743, 16990, 16989, 16945, 16991, 67507, 67477, 66815, 
67508, 67506, 67475, 66783, 66814
14941, 61963, 61953, 61733, 61743, 61964, 61954, 61734, 61744, 67507, 67477, 66815, 67508, 67510, 67480, 66818, 
67511, 67509, 67478, 66786, 66817
14942, 61964, 61954, 61734, 61744, 61965, 61955, 61735, 61745, 67510, 67480, 66818, 67511, 67513, 67483, 66821, 
67514, 67512, 67481, 66789, 66820
14943, 61965, 61955, 61735, 61745, 61966, 61956, 61736, 61746, 67513, 67483, 66821, 67514, 67516, 67486, 66824, 
67517, 67515, 67484, 66792, 66823
14944, 61966, 61956, 61736, 61746, 61967, 61957, 61737, 61747, 67516, 67486, 66824, 67517, 67519, 67489, 66827, 
67520, 67518, 67487, 66795, 66826
14945, 61967, 61957, 61737, 61747, 61968, 61958, 61738, 61748, 67519, 67489, 66827, 67520, 67522, 67492, 66830, 
67523, 67521, 67490, 66798, 66829
14946, 61968, 61958, 61738, 61748, 61969, 61959, 61739, 61749, 67522, 67492, 66830, 67523, 67525, 67495, 66833, 
67526, 67524, 67493, 66801, 66832
14947, 61969, 61959, 61739, 61749, 61970, 61960, 61740, 61750, 67525, 67495, 66833, 67526, 67528, 67498, 66836, 
67529, 67527, 67496, 66804, 66835
14948, 61970, 61960, 61740, 61750, 61971, 61961, 61741, 61751, 67528, 67498, 66836, 67529, 67531, 67501, 66839, 
67532, 67530, 67499, 66807, 66838
14949, 61971, 61961, 61741, 61751, 61972, 61962, 61742, 61752, 67531, 67501, 66839, 67532, 67534, 67504, 66842, 
67535, 67533, 67502, 66810, 66841
14950, 61972, 61962, 61742, 61752, 17968, 17967, 17945, 17946, 67534, 67504, 66842, 67535, 18487, 18484, 18442, 
18486, 67536, 67505, 66813, 66844
14951, 16473, 16472, 16450, 16451, 61973, 61963, 61743, 61753, 16992, 16991, 16947, 16993, 67538, 67508, 66846, 
67539, 67537, 67506, 66814, 66845
14952, 61973, 61963, 61743, 61753, 61974, 61964, 61744, 61754, 67538, 67508, 66846, 67539, 67541, 67511, 66849, 
67542, 67540, 67509, 66817, 66848
14953, 61974, 61964, 61744, 61754, 61975, 61965, 61745, 61755, 67541, 67511, 66849, 67542, 67544, 67514, 66852, 
67545, 67543, 67512, 66820, 66851
14954, 61975, 61965, 61745, 61755, 61976, 61966, 61746, 61756, 67544, 67514, 66852, 67545, 67547, 67517, 66855, 
67548, 67546, 67515, 66823, 66854
14955, 61976, 61966, 61746, 61756, 61977, 61967, 61747, 61757, 67547, 67517, 66855, 67548, 67550, 67520, 66858, 
67551, 67549, 67518, 66826, 66857
14956, 61977, 61967, 61747, 61757, 61978, 61968, 61748, 61758, 67550, 67520, 66858, 67551, 67553, 67523, 66861, 
67554, 67552, 67521, 66829, 66860
14957, 61978, 61968, 61748, 61758, 61979, 61969, 61749, 61759, 67553, 67523, 66861, 67554, 67556, 67526, 66864, 
67557, 67555, 67524, 66832, 66863
14958, 61979, 61969, 61749, 61759, 61980, 61970, 61750, 61760, 67556, 67526, 66864, 67557, 67559, 67529, 66867, 
67560, 67558, 67527, 66835, 66866
14959, 61980, 61970, 61750, 61760, 61981, 61971, 61751, 61761, 67559, 67529, 66867, 67560, 67562, 67532, 66870, 
67563, 67561, 67530, 66838, 66869
14960, 61981, 61971, 61751, 61761, 61982, 61972, 61752, 61762, 67562, 67532, 66870, 67563, 67565, 67535, 66873, 
67566, 67564, 67533, 66841, 66872
14961, 61982, 61972, 61752, 61762, 17969, 17968, 17946, 17947, 67565, 67535, 66873, 67566, 18489, 18486, 18444, 
18488, 67567, 67536, 66844, 66875
14962, 16474, 16473, 16451, 16452, 61983, 61973, 61753, 61763, 16994, 16993, 16949, 16995, 67569, 67539, 66877, 
67570, 67568, 67537, 66845, 66876
14963, 61983, 61973, 61753, 61763, 61984, 61974, 61754, 61764, 67569, 67539, 66877, 67570, 67572, 67542, 66880, 
67573, 67571, 67540, 66848, 66879
14964, 61984, 61974, 61754, 61764, 61985, 61975, 61755, 61765, 67572, 67542, 66880, 67573, 67575, 67545, 66883, 
67576, 67574, 67543, 66851, 66882
14965, 61985, 61975, 61755, 61765, 61986, 61976, 61756, 61766, 67575, 67545, 66883, 67576, 67578, 67548, 66886, 
67579, 67577, 67546, 66854, 66885
14966, 61986, 61976, 61756, 61766, 61987, 61977, 61757, 61767, 67578, 67548, 66886, 67579, 67581, 67551, 66889, 
67582, 67580, 67549, 66857, 66888
14967, 61987, 61977, 61757, 61767, 61988, 61978, 61758, 61768, 67581, 67551, 66889, 67582, 67584, 67554, 66892, 
67585, 67583, 67552, 66860, 66891
14968, 61988, 61978, 61758, 61768, 61989, 61979, 61759, 61769, 67584, 67554, 66892, 67585, 67587, 67557, 66895, 
67588, 67586, 67555, 66863, 66894
14969, 61989, 61979, 61759, 61769, 61990, 61980, 61760, 61770, 67587, 67557, 66895, 67588, 67590, 67560, 66898, 
67591, 67589, 67558, 66866, 66897
14970, 61990, 61980, 61760, 61770, 61991, 61981, 61761, 61771, 67590, 67560, 66898, 67591, 67593, 67563, 66901, 
67594, 67592, 67561, 66869, 66900
14971, 61991, 61981, 61761, 61771, 61992, 61982, 61762, 61772, 67593, 67563, 66901, 67594, 67596, 67566, 66904, 
67597, 67595, 67564, 66872, 66903
14972, 61992, 61982, 61762, 61772, 17970, 17969, 17947, 17948, 67596, 67566, 66904, 67597, 18491, 18488, 18446, 
18490, 67598, 67567, 66875, 66906
14973, 16475, 16474, 16452, 16453, 61993, 61983, 61763, 61773, 16996, 16995, 16951, 16997, 67600, 67570, 66908, 
67601, 67599, 67568, 66876, 66907
14974, 61993, 61983, 61763, 61773, 61994, 61984, 61764, 61774, 67600, 67570, 66908, 67601, 67603, 67573, 66911, 
67604, 67602, 67571, 66879, 66910
14975, 61994, 61984, 61764, 61774, 61995, 61985, 61765, 61775, 67603, 67573, 66911, 67604, 67606, 67576, 66914, 
67607, 67605, 67574, 66882, 66913
14976, 61995, 61985, 61765, 61775, 61996, 61986, 61766, 61776, 67606, 67576, 66914, 67607, 67609, 67579, 66917, 
67610, 67608, 67577, 66885, 66916
14977, 61996, 61986, 61766, 61776, 61997, 61987, 61767, 61777, 67609, 67579, 66917, 67610, 67612, 67582, 66920, 
67613, 67611, 67580, 66888, 66919
14978, 61997, 61987, 61767, 61777, 61998, 61988, 61768, 61778, 67612, 67582, 66920, 67613, 67615, 67585, 66923, 
67616, 67614, 67583, 66891, 66922
14979, 61998, 61988, 61768, 61778, 61999, 61989, 61769, 61779, 67615, 67585, 66923, 67616, 67618, 67588, 66926, 
67619, 67617, 67586, 66894, 66925
14980, 61999, 61989, 61769, 61779, 62000, 61990, 61770, 61780, 67618, 67588, 66926, 67619, 67621, 67591, 66929, 
67622, 67620, 67589, 66897, 66928
14981, 62000, 61990, 61770, 61780, 62001, 61991, 61771, 61781, 67621, 67591, 66929, 67622, 67624, 67594, 66932, 
67625, 67623, 67592, 66900, 66931
14982, 62001, 61991, 61771, 61781, 62002, 61992, 61772, 61782, 67624, 67594, 66932, 67625, 67627, 67597, 66935, 
67628, 67626, 67595, 66903, 66934
14983, 62002, 61992, 61772, 61782, 17971, 17970, 17948, 17949, 67627, 67597, 66935, 67628, 18493, 18490, 18448, 
18492, 67629, 67598, 66906, 66937
14984, 16476, 16475, 16453, 16454, 62003, 61993, 61773, 61783, 16998, 16997, 16953, 16999, 67631, 67601, 66939, 
67632, 67630, 67599, 66907, 66938
14985, 62003, 61993, 61773, 61783, 62004, 61994, 61774, 61784, 67631, 67601, 66939, 67632, 67634, 67604, 66942, 
67635, 67633, 67602, 66910, 66941
14986, 62004, 61994, 61774, 61784, 62005, 61995, 61775, 61785, 67634, 67604, 66942, 67635, 67637, 67607, 66945, 
67638, 67636, 67605, 66913, 66944
14987, 62005, 61995, 61775, 61785, 62006, 61996, 61776, 61786, 67637, 67607, 66945, 67638, 67640, 67610, 66948, 
67641, 67639, 67608, 66916, 66947
14988, 62006, 61996, 61776, 61786, 62007, 61997, 61777, 61787, 67640, 67610, 66948, 67641, 67643, 67613, 66951, 
67644, 67642, 67611, 66919, 66950
14989, 62007, 61997, 61777, 61787, 62008, 61998, 61778, 61788, 67643, 67613, 66951, 67644, 67646, 67616, 66954, 
67647, 67645, 67614, 66922, 66953
14990, 62008, 61998, 61778, 61788, 62009, 61999, 61779, 61789, 67646, 67616, 66954, 67647, 67649, 67619, 66957, 
67650, 67648, 67617, 66925, 66956
14991, 62009, 61999, 61779, 61789, 62010, 62000, 61780, 61790, 67649, 67619, 66957, 67650, 67652, 67622, 66960, 
67653, 67651, 67620, 66928, 66959
14992, 62010, 62000, 61780, 61790, 62011, 62001, 61781, 61791, 67652, 67622, 66960, 67653, 67655, 67625, 66963, 
67656, 67654, 67623, 66931, 66962
14993, 62011, 62001, 61781, 61791, 62012, 62002, 61782, 61792, 67655, 67625, 66963, 67656, 67658, 67628, 66966, 
67659, 67657, 67626, 66934, 66965
14994, 62012, 62002, 61782, 61792, 17972, 17971, 17949, 17950, 67658, 67628, 66966, 67659, 18495, 18492, 18450, 
18494, 67660, 67629, 66937, 66968
14995, 16477, 16476, 16454, 16455, 62013, 62003, 61783, 61793, 17000, 16999, 16955, 17001, 67662, 67632, 66970, 
67663, 67661, 67630, 66938, 66969
14996, 62013, 62003, 61783, 61793, 62014, 62004, 61784, 61794, 67662, 67632, 66970, 67663, 67665, 67635, 66973, 
67666, 67664, 67633, 66941, 66972
14997, 62014, 62004, 61784, 61794, 62015, 62005, 61785, 61795, 67665, 67635, 66973, 67666, 67668, 67638, 66976, 
67669, 67667, 67636, 66944, 66975
14998, 62015, 62005, 61785, 61795, 62016, 62006, 61786, 61796, 67668, 67638, 66976, 67669, 67671, 67641, 66979, 
67672, 67670, 67639, 66947, 66978
14999, 62016, 62006, 61786, 61796, 62017, 62007, 61787, 61797, 67671, 67641, 66979, 67672, 67674, 67644, 66982, 
67675, 67673, 67642, 66950, 66981
15000, 62017, 62007, 61787, 61797, 62018, 62008, 61788, 61798, 67674, 67644, 66982, 67675, 67677, 67647, 66985, 
67678, 67676, 67645, 66953, 66984
15001, 62018, 62008, 61788, 61798, 62019, 62009, 61789, 61799, 67677, 67647, 66985, 67678, 67680, 67650, 66988, 
67681, 67679, 67648, 66956, 66987
15002, 62019, 62009, 61789, 61799, 62020, 62010, 61790, 61800, 67680, 67650, 66988, 67681, 67683, 67653, 66991, 
67684, 67682, 67651, 66959, 66990
15003, 62020, 62010, 61790, 61800, 62021, 62011, 61791, 61801, 67683, 67653, 66991, 67684, 67686, 67656, 66994, 
67687, 67685, 67654, 66962, 66993
15004, 62021, 62011, 61791, 61801, 62022, 62012, 61792, 61802, 67686, 67656, 66994, 67687, 67689, 67659, 66997, 
67690, 67688, 67657, 66965, 66996
15005, 62022, 62012, 61792, 61802, 17973, 17972, 17950, 17951, 67689, 67659, 66997, 67690, 18497, 18494, 18452, 
18496, 67691, 67660, 66968, 66999
15006, 16478, 16477, 16455, 16456, 62023, 62013, 61793, 61803, 17002, 17001, 16957, 17003, 67693, 67663, 67001, 
67694, 67692, 67661, 66969, 67000
15007, 62023, 62013, 61793, 61803, 62024, 62014, 61794, 61804, 67693, 67663, 67001, 67694, 67696, 67666, 67004, 
67697, 67695, 67664, 66972, 67003
15008, 62024, 62014, 61794, 61804, 62025, 62015, 61795, 61805, 67696, 67666, 67004, 67697, 67699, 67669, 67007, 
67700, 67698, 67667, 66975, 67006
15009, 62025, 62015, 61795, 61805, 62026, 62016, 61796, 61806, 67699, 67669, 67007, 67700, 67702, 67672, 67010, 
67703, 67701, 67670, 66978, 67009
15010, 62026, 62016, 61796, 61806, 62027, 62017, 61797, 61807, 67702, 67672, 67010, 67703, 67705, 67675, 67013, 
67706, 67704, 67673, 66981, 67012
15011, 62027, 62017, 61797, 61807, 62028, 62018, 61798, 61808, 67705, 67675, 67013, 67706, 67708, 67678, 67016, 
67709, 67707, 67676, 66984, 67015
15012, 62028, 62018, 61798, 61808, 62029, 62019, 61799, 61809, 67708, 67678, 67016, 67709, 67711, 67681, 67019, 
67712, 67710, 67679, 66987, 67018
15013, 62029, 62019, 61799, 61809, 62030, 62020, 61800, 61810, 67711, 67681, 67019, 67712, 67714, 67684, 67022, 
67715, 67713, 67682, 66990, 67021
15014, 62030, 62020, 61800, 61810, 62031, 62021, 61801, 61811, 67714, 67684, 67022, 67715, 67717, 67687, 67025, 
67718, 67716, 67685, 66993, 67024
15015, 62031, 62021, 61801, 61811, 62032, 62022, 61802, 61812, 67717, 67687, 67025, 67718, 67720, 67690, 67028, 
67721, 67719, 67688, 66996, 67027
15016, 62032, 62022, 61802, 61812, 17974, 17973, 17951, 17952, 67720, 67690, 67028, 67721, 18499, 18496, 18454, 
18498, 67722, 67691, 66999, 67030
15017, 16479, 16478, 16456, 16457, 62033, 62023, 61803, 61813, 17004, 17003, 16959, 17005, 67724, 67694, 67032, 
67725, 67723, 67692, 67000, 67031
15018, 62033, 62023, 61803, 61813, 62034, 62024, 61804, 61814, 67724, 67694, 67032, 67725, 67727, 67697, 67035, 
67728, 67726, 67695, 67003, 67034
15019, 62034, 62024, 61804, 61814, 62035, 62025, 61805, 61815, 67727, 67697, 67035, 67728, 67730, 67700, 67038, 
67731, 67729, 67698, 67006, 67037
15020, 62035, 62025, 61805, 61815, 62036, 62026, 61806, 61816, 67730, 67700, 67038, 67731, 67733, 67703, 67041, 
67734, 67732, 67701, 67009, 67040
15021, 62036, 62026, 61806, 61816, 62037, 62027, 61807, 61817, 67733, 67703, 67041, 67734, 67736, 67706, 67044, 
67737, 67735, 67704, 67012, 67043
15022, 62037, 62027, 61807, 61817, 62038, 62028, 61808, 61818, 67736, 67706, 67044, 67737, 67739, 67709, 67047, 
67740, 67738, 67707, 67015, 67046
15023, 62038, 62028, 61808, 61818, 62039, 62029, 61809, 61819, 67739, 67709, 67047, 67740, 67742, 67712, 67050, 
67743, 67741, 67710, 67018, 67049
15024, 62039, 62029, 61809, 61819, 62040, 62030, 61810, 61820, 67742, 67712, 67050, 67743, 67745, 67715, 67053, 
67746, 67744, 67713, 67021, 67052
15025, 62040, 62030, 61810, 61820, 62041, 62031, 61811, 61821, 67745, 67715, 67053, 67746, 67748, 67718, 67056, 
67749, 67747, 67716, 67024, 67055
15026, 62041, 62031, 61811, 61821, 62042, 62032, 61812, 61822, 67748, 67718, 67056, 67749, 67751, 67721, 67059, 
67752, 67750, 67719, 67027, 67058
15027, 62042, 62032, 61812, 61822, 17975, 17974, 17952, 17953, 67751, 67721, 67059, 67752, 18501, 18498, 18456, 
18500, 67753, 67722, 67030, 67061
15028, 16480, 16479, 16457, 16458, 62043, 62033, 61813, 61823, 17006, 17005, 16961, 17007, 67755, 67725, 67063, 
67756, 67754, 67723, 67031, 67062
15029, 62043, 62033, 61813, 61823, 62044, 62034, 61814, 61824, 67755, 67725, 67063, 67756, 67758, 67728, 67066, 
67759, 67757, 67726, 67034, 67065
15030, 62044, 62034, 61814, 61824, 62045, 62035, 61815, 61825, 67758, 67728, 67066, 67759, 67761, 67731, 67069, 
67762, 67760, 67729, 67037, 67068
15031, 62045, 62035, 61815, 61825, 62046, 62036, 61816, 61826, 67761, 67731, 67069, 67762, 67764, 67734, 67072, 
67765, 67763, 67732, 67040, 67071
15032, 62046, 62036, 61816, 61826, 62047, 62037, 61817, 61827, 67764, 67734, 67072, 67765, 67767, 67737, 67075, 
67768, 67766, 67735, 67043, 67074
15033, 62047, 62037, 61817, 61827, 62048, 62038, 61818, 61828, 67767, 67737, 67075, 67768, 67770, 67740, 67078, 
67771, 67769, 67738, 67046, 67077
15034, 62048, 62038, 61818, 61828, 62049, 62039, 61819, 61829, 67770, 67740, 67078, 67771, 67773, 67743, 67081, 
67774, 67772, 67741, 67049, 67080
15035, 62049, 62039, 61819, 61829, 62050, 62040, 61820, 61830, 67773, 67743, 67081, 67774, 67776, 67746, 67084, 
67777, 67775, 67744, 67052, 67083
15036, 62050, 62040, 61820, 61830, 62051, 62041, 61821, 61831, 67776, 67746, 67084, 67777, 67779, 67749, 67087, 
67780, 67778, 67747, 67055, 67086
15037, 62051, 62041, 61821, 61831, 62052, 62042, 61822, 61832, 67779, 67749, 67087, 67780, 67782, 67752, 67090, 
67783, 67781, 67750, 67058, 67089
15038, 62052, 62042, 61822, 61832, 17976, 17975, 17953, 17954, 67782, 67752, 67090, 67783, 18503, 18500, 18458, 
18502, 67784, 67753, 67061, 67092
15039, 16481, 16480, 16458, 16459, 62053, 62043, 61823, 61833, 17008, 17007, 16963, 17009, 67786, 67756, 67094, 
67787, 67785, 67754, 67062, 67093
15040, 62053, 62043, 61823, 61833, 62054, 62044, 61824, 61834, 67786, 67756, 67094, 67787, 67789, 67759, 67097, 
67790, 67788, 67757, 67065, 67096
15041, 62054, 62044, 61824, 61834, 62055, 62045, 61825, 61835, 67789, 67759, 67097, 67790, 67792, 67762, 67100, 
67793, 67791, 67760, 67068, 67099
15042, 62055, 62045, 61825, 61835, 62056, 62046, 61826, 61836, 67792, 67762, 67100, 67793, 67795, 67765, 67103, 
67796, 67794, 67763, 67071, 67102
15043, 62056, 62046, 61826, 61836, 62057, 62047, 61827, 61837, 67795, 67765, 67103, 67796, 67798, 67768, 67106, 
67799, 67797, 67766, 67074, 67105
15044, 62057, 62047, 61827, 61837, 62058, 62048, 61828, 61838, 67798, 67768, 67106, 67799, 67801, 67771, 67109, 
67802, 67800, 67769, 67077, 67108
15045, 62058, 62048, 61828, 61838, 62059, 62049, 61829, 61839, 67801, 67771, 67109, 67802, 67804, 67774, 67112, 
67805, 67803, 67772, 67080, 67111
15046, 62059, 62049, 61829, 61839, 62060, 62050, 61830, 61840, 67804, 67774, 67112, 67805, 67807, 67777, 67115, 
67808, 67806, 67775, 67083, 67114
15047, 62060, 62050, 61830, 61840, 62061, 62051, 61831, 61841, 67807, 67777, 67115, 67808, 67810, 67780, 67118, 
67811, 67809, 67778, 67086, 67117
15048, 62061, 62051, 61831, 61841, 62062, 62052, 61832, 61842, 67810, 67780, 67118, 67811, 67813, 67783, 67121, 
67814, 67812, 67781, 67089, 67120
15049, 62062, 62052, 61832, 61842, 17977, 17976, 17954, 17955, 67813, 67783, 67121, 67814, 18505, 18502, 18460, 
18504, 67815, 67784, 67092, 67123
15050, 16482, 16481, 16459, 16460, 62063, 62053, 61833, 61843, 17010, 17009, 16965, 17011, 67817, 67787, 67125, 
67818, 67816, 67785, 67093, 67124
15051, 62063, 62053, 61833, 61843, 62064, 62054, 61834, 61844, 67817, 67787, 67125, 67818, 67820, 67790, 67128, 
67821, 67819, 67788, 67096, 67127
15052, 62064, 62054, 61834, 61844, 62065, 62055, 61835, 61845, 67820, 67790, 67128, 67821, 67823, 67793, 67131, 
67824, 67822, 67791, 67099, 67130
15053, 62065, 62055, 61835, 61845, 62066, 62056, 61836, 61846, 67823, 67793, 67131, 67824, 67826, 67796, 67134, 
67827, 67825, 67794, 67102, 67133
15054, 62066, 62056, 61836, 61846, 62067, 62057, 61837, 61847, 67826, 67796, 67134, 67827, 67829, 67799, 67137, 
67830, 67828, 67797, 67105, 67136
15055, 62067, 62057, 61837, 61847, 62068, 62058, 61838, 61848, 67829, 67799, 67137, 67830, 67832, 67802, 67140, 
67833, 67831, 67800, 67108, 67139
15056, 62068, 62058, 61838, 61848, 62069, 62059, 61839, 61849, 67832, 67802, 67140, 67833, 67835, 67805, 67143, 
67836, 67834, 67803, 67111, 67142
15057, 62069, 62059, 61839, 61849, 62070, 62060, 61840, 61850, 67835, 67805, 67143, 67836, 67838, 67808, 67146, 
67839, 67837, 67806, 67114, 67145
15058, 62070, 62060, 61840, 61850, 62071, 62061, 61841, 61851, 67838, 67808, 67146, 67839, 67841, 67811, 67149, 
67842, 67840, 67809, 67117, 67148
15059, 62071, 62061, 61841, 61851, 62072, 62062, 61842, 61852, 67841, 67811, 67149, 67842, 67844, 67814, 67152, 
67845, 67843, 67812, 67120, 67151
15060, 62072, 62062, 61842, 61852, 17978, 17977, 17955, 17956, 67844, 67814, 67152, 67845, 18507, 18504, 18462, 
18506, 67846, 67815, 67123, 67154
15061, 1635, 16482, 16460, 1634, 20133, 62063, 61843, 20123, 17012, 17011, 16967, 1657, 67847, 67818, 67155, 
20365, 20364, 67816, 67124, 20343
15062, 20133, 62063, 61843, 20123, 20134, 62064, 61844, 20124, 67847, 67818, 67155, 20365, 67848, 67821, 67156, 
20367, 20366, 67819, 67127, 20345
15063, 20134, 62064, 61844, 20124, 20135, 62065, 61845, 20125, 67848, 67821, 67156, 20367, 67849, 67824, 67157, 
20369, 20368, 67822, 67130, 20347
15064, 20135, 62065, 61845, 20125, 20136, 62066, 61846, 20126, 67849, 67824, 67157, 20369, 67850, 67827, 67158, 
20371, 20370, 67825, 67133, 20349
15065, 20136, 62066, 61846, 20126, 20137, 62067, 61847, 20127, 67850, 67827, 67158, 20371, 67851, 67830, 67159, 
20373, 20372, 67828, 67136, 20351
15066, 20137, 62067, 61847, 20127, 20138, 62068, 61848, 20128, 67851, 67830, 67159, 20373, 67852, 67833, 67160, 
20375, 20374, 67831, 67139, 20353
15067, 20138, 62068, 61848, 20128, 20139, 62069, 61849, 20129, 67852, 67833, 67160, 20375, 67853, 67836, 67161, 
20377, 20376, 67834, 67142, 20355
15068, 20139, 62069, 61849, 20129, 20140, 62070, 61850, 20130, 67853, 67836, 67161, 20377, 67854, 67839, 67162, 
20379, 20378, 67837, 67145, 20357
15069, 20140, 62070, 61850, 20130, 20141, 62071, 61851, 20131, 67854, 67839, 67162, 20379, 67855, 67842, 67163, 
20381, 20380, 67840, 67148, 20359
15070, 20141, 62071, 61851, 20131, 20142, 62072, 61852, 20132, 67855, 67842, 67163, 20381, 67856, 67845, 67164, 
20383, 20382, 67843, 67151, 20361
15071, 20142, 62072, 61852, 20132, 1770, 17978, 17956, 1769, 67856, 67845, 67164, 20383, 18508, 18506, 18463, 
1792, 20384, 67846, 67154, 20363
15072, 16483, 1591, 1590, 16461, 62073, 19451, 19441, 61853, 17013, 1613, 16968, 17014, 67858, 19693, 67166, 
67859, 67857, 19694, 19673, 67165
15073, 62073, 19451, 19441, 61853, 62074, 19452, 19442, 61854, 67858, 19693, 67166, 67859, 67861, 19695, 67169, 
67862, 67860, 19696, 19675, 67168
15074, 62074, 19452, 19442, 61854, 62075, 19453, 19443, 61855, 67861, 19695, 67169, 67862, 67864, 19697, 67172, 
67865, 67863, 19698, 19677, 67171
15075, 62075, 19453, 19443, 61855, 62076, 19454, 19444, 61856, 67864, 19697, 67172, 67865, 67867, 19699, 67175, 
67868, 67866, 19700, 19679, 67174
15076, 62076, 19454, 19444, 61856, 62077, 19455, 19445, 61857, 67867, 19699, 67175, 67868, 67870, 19701, 67178, 
67871, 67869, 19702, 19681, 67177
15077, 62077, 19455, 19445, 61857, 62078, 19456, 19446, 61858, 67870, 19701, 67178, 67871, 67873, 19703, 67181, 
67874, 67872, 19704, 19683, 67180
15078, 62078, 19456, 19446, 61858, 62079, 19457, 19447, 61859, 67873, 19703, 67181, 67874, 67876, 19705, 67184, 
67877, 67875, 19706, 19685, 67183
15079, 62079, 19457, 19447, 61859, 62080, 19458, 19448, 61860, 67876, 19705, 67184, 67877, 67879, 19707, 67187, 
67880, 67878, 19708, 19687, 67186
15080, 62080, 19458, 19448, 61860, 62081, 19459, 19449, 61861, 67879, 19707, 67187, 67880, 67882, 19709, 67190, 
67883, 67881, 19710, 19689, 67189
15081, 62081, 19459, 19449, 61861, 62082, 19460, 19450, 61862, 67882, 19709, 67190, 67883, 67885, 19711, 67193, 
67886, 67884, 19712, 19691, 67192
15082, 62082, 19460, 19450, 61862, 17979, 1726, 1725, 17957, 67885, 19711, 67193, 67886, 18510, 1748, 18465, 
18509, 67887, 19713, 19692, 67195
15083, 16484, 16483, 16461, 16462, 62083, 62073, 61853, 61863, 17015, 17014, 16970, 17016, 67889, 67859, 67197, 
67890, 67888, 67857, 67165, 67196
15084, 62083, 62073, 61853, 61863, 62084, 62074, 61854, 61864, 67889, 67859, 67197, 67890, 67892, 67862, 67200, 
67893, 67891, 67860, 67168, 67199
15085, 62084, 62074, 61854, 61864, 62085, 62075, 61855, 61865, 67892, 67862, 67200, 67893, 67895, 67865, 67203, 
67896, 67894, 67863, 67171, 67202
15086, 62085, 62075, 61855, 61865, 62086, 62076, 61856, 61866, 67895, 67865, 67203, 67896, 67898, 67868, 67206, 
67899, 67897, 67866, 67174, 67205
15087, 62086, 62076, 61856, 61866, 62087, 62077, 61857, 61867, 67898, 67868, 67206, 67899, 67901, 67871, 67209, 
67902, 67900, 67869, 67177, 67208
15088, 62087, 62077, 61857, 61867, 62088, 62078, 61858, 61868, 67901, 67871, 67209, 67902, 67904, 67874, 67212, 
67905, 67903, 67872, 67180, 67211
15089, 62088, 62078, 61858, 61868, 62089, 62079, 61859, 61869, 67904, 67874, 67212, 67905, 67907, 67877, 67215, 
67908, 67906, 67875, 67183, 67214
15090, 62089, 62079, 61859, 61869, 62090, 62080, 61860, 61870, 67907, 67877, 67215, 67908, 67910, 67880, 67218, 
67911, 67909, 67878, 67186, 67217
15091, 62090, 62080, 61860, 61870, 62091, 62081, 61861, 61871, 67910, 67880, 67218, 67911, 67913, 67883, 67221, 
67914, 67912, 67881, 67189, 67220
15092, 62091, 62081, 61861, 61871, 62092, 62082, 61862, 61872, 67913, 67883, 67221, 67914, 67916, 67886, 67224, 
67917, 67915, 67884, 67192, 67223
15093, 62092, 62082, 61862, 61872, 17980, 17979, 17957, 17958, 67916, 67886, 67224, 67917, 18512, 18509, 18467, 
18511, 67918, 67887, 67195, 67226
15094, 16485, 16484, 16462, 16463, 62093, 62083, 61863, 61873, 17017, 17016, 16972, 17018, 67920, 67890, 67228, 
67921, 67919, 67888, 67196, 67227
15095, 62093, 62083, 61863, 61873, 62094, 62084, 61864, 61874, 67920, 67890, 67228, 67921, 67923, 67893, 67231, 
67924, 67922, 67891, 67199, 67230
15096, 62094, 62084, 61864, 61874, 62095, 62085, 61865, 61875, 67923, 67893, 67231, 67924, 67926, 67896, 67234, 
67927, 67925, 67894, 67202, 67233
15097, 62095, 62085, 61865, 61875, 62096, 62086, 61866, 61876, 67926, 67896, 67234, 67927, 67929, 67899, 67237, 
67930, 67928, 67897, 67205, 67236
15098, 62096, 62086, 61866, 61876, 62097, 62087, 61867, 61877, 67929, 67899, 67237, 67930, 67932, 67902, 67240, 
67933, 67931, 67900, 67208, 67239
15099, 62097, 62087, 61867, 61877, 62098, 62088, 61868, 61878, 67932, 67902, 67240, 67933, 67935, 67905, 67243, 
67936, 67934, 67903, 67211, 67242
15100, 62098, 62088, 61868, 61878, 62099, 62089, 61869, 61879, 67935, 67905, 67243, 67936, 67938, 67908, 67246, 
67939, 67937, 67906, 67214, 67245
15101, 62099, 62089, 61869, 61879, 62100, 62090, 61870, 61880, 67938, 67908, 67246, 67939, 67941, 67911, 67249, 
67942, 67940, 67909, 67217, 67248
15102, 62100, 62090, 61870, 61880, 62101, 62091, 61871, 61881, 67941, 67911, 67249, 67942, 67944, 67914, 67252, 
67945, 67943, 67912, 67220, 67251
15103, 62101, 62091, 61871, 61881, 62102, 62092, 61872, 61882, 67944, 67914, 67252, 67945, 67947, 67917, 67255, 
67948, 67946, 67915, 67223, 67254
15104, 62102, 62092, 61872, 61882, 17981, 17980, 17958, 17959, 67947, 67917, 67255, 67948, 18514, 18511, 18469, 
18513, 67949, 67918, 67226, 67257
15105, 16486, 16485, 16463, 16464, 62103, 62093, 61873, 61883, 17019, 17018, 16974, 17020, 67951, 67921, 67259, 
67952, 67950, 67919, 67227, 67258
15106, 62103, 62093, 61873, 61883, 62104, 62094, 61874, 61884, 67951, 67921, 67259, 67952, 67954, 67924, 67262, 
67955, 67953, 67922, 67230, 67261
15107, 62104, 62094, 61874, 61884, 62105, 62095, 61875, 61885, 67954, 67924, 67262, 67955, 67957, 67927, 67265, 
67958, 67956, 67925, 67233, 67264
15108, 62105, 62095, 61875, 61885, 62106, 62096, 61876, 61886, 67957, 67927, 67265, 67958, 67960, 67930, 67268, 
67961, 67959, 67928, 67236, 67267
15109, 62106, 62096, 61876, 61886, 62107, 62097, 61877, 61887, 67960, 67930, 67268, 67961, 67963, 67933, 67271, 
67964, 67962, 67931, 67239, 67270
15110, 62107, 62097, 61877, 61887, 62108, 62098, 61878, 61888, 67963, 67933, 67271, 67964, 67966, 67936, 67274, 
67967, 67965, 67934, 67242, 67273
15111, 62108, 62098, 61878, 61888, 62109, 62099, 61879, 61889, 67966, 67936, 67274, 67967, 67969, 67939, 67277, 
67970, 67968, 67937, 67245, 67276
15112, 62109, 62099, 61879, 61889, 62110, 62100, 61880, 61890, 67969, 67939, 67277, 67970, 67972, 67942, 67280, 
67973, 67971, 67940, 67248, 67279
15113, 62110, 62100, 61880, 61890, 62111, 62101, 61881, 61891, 67972, 67942, 67280, 67973, 67975, 67945, 67283, 
67976, 67974, 67943, 67251, 67282
15114, 62111, 62101, 61881, 61891, 62112, 62102, 61882, 61892, 67975, 67945, 67283, 67976, 67978, 67948, 67286, 
67979, 67977, 67946, 67254, 67285
15115, 62112, 62102, 61882, 61892, 17982, 17981, 17959, 17960, 67978, 67948, 67286, 67979, 18516, 18513, 18471, 
18515, 67980, 67949, 67257, 67288
15116, 16487, 16486, 16464, 16465, 62113, 62103, 61883, 61893, 17021, 17020, 16976, 17022, 67982, 67952, 67290, 
67983, 67981, 67950, 67258, 67289
15117, 62113, 62103, 61883, 61893, 62114, 62104, 61884, 61894, 67982, 67952, 67290, 67983, 67985, 67955, 67293, 
67986, 67984, 67953, 67261, 67292
15118, 62114, 62104, 61884, 61894, 62115, 62105, 61885, 61895, 67985, 67955, 67293, 67986, 67988, 67958, 67296, 
67989, 67987, 67956, 67264, 67295
15119, 62115, 62105, 61885, 61895, 62116, 62106, 61886, 61896, 67988, 67958, 67296, 67989, 67991, 67961, 67299, 
67992, 67990, 67959, 67267, 67298
15120, 62116, 62106, 61886, 61896, 62117, 62107, 61887, 61897, 67991, 67961, 67299, 67992, 67994, 67964, 67302, 
67995, 67993, 67962, 67270, 67301
15121, 62117, 62107, 61887, 61897, 62118, 62108, 61888, 61898, 67994, 67964, 67302, 67995, 67997, 67967, 67305, 
67998, 67996, 67965, 67273, 67304
15122, 62118, 62108, 61888, 61898, 62119, 62109, 61889, 61899, 67997, 67967, 67305, 67998, 68000, 67970, 67308, 
68001, 67999, 67968, 67276, 67307
15123, 62119, 62109, 61889, 61899, 62120, 62110, 61890, 61900, 68000, 67970, 67308, 68001, 68003, 67973, 67311, 
68004, 68002, 67971, 67279, 67310
15124, 62120, 62110, 61890, 61900, 62121, 62111, 61891, 61901, 68003, 67973, 67311, 68004, 68006, 67976, 67314, 
68007, 68005, 67974, 67282, 67313
15125, 62121, 62111, 61891, 61901, 62122, 62112, 61892, 61902, 68006, 67976, 67314, 68007, 68009, 67979, 67317, 
68010, 68008, 67977, 67285, 67316
15126, 62122, 62112, 61892, 61902, 17983, 17982, 17960, 17961, 68009, 67979, 67317, 68010, 18518, 18515, 18473, 
18517, 68011, 67980, 67288, 67319
15127, 16488, 16487, 16465, 16466, 62123, 62113, 61893, 61903, 17023, 17022, 16978, 17024, 68013, 67983, 67321, 
68014, 68012, 67981, 67289, 67320
15128, 62123, 62113, 61893, 61903, 62124, 62114, 61894, 61904, 68013, 67983, 67321, 68014, 68016, 67986, 67324, 
68017, 68015, 67984, 67292, 67323
15129, 62124, 62114, 61894, 61904, 62125, 62115, 61895, 61905, 68016, 67986, 67324, 68017, 68019, 67989, 67327, 
68020, 68018, 67987, 67295, 67326
15130, 62125, 62115, 61895, 61905, 62126, 62116, 61896, 61906, 68019, 67989, 67327, 68020, 68022, 67992, 67330, 
68023, 68021, 67990, 67298, 67329
15131, 62126, 62116, 61896, 61906, 62127, 62117, 61897, 61907, 68022, 67992, 67330, 68023, 68025, 67995, 67333, 
68026, 68024, 67993, 67301, 67332
15132, 62127, 62117, 61897, 61907, 62128, 62118, 61898, 61908, 68025, 67995, 67333, 68026, 68028, 67998, 67336, 
68029, 68027, 67996, 67304, 67335
15133, 62128, 62118, 61898, 61908, 62129, 62119, 61899, 61909, 68028, 67998, 67336, 68029, 68031, 68001, 67339, 
68032, 68030, 67999, 67307, 67338
15134, 62129, 62119, 61899, 61909, 62130, 62120, 61900, 61910, 68031, 68001, 67339, 68032, 68034, 68004, 67342, 
68035, 68033, 68002, 67310, 67341
15135, 62130, 62120, 61900, 61910, 62131, 62121, 61901, 61911, 68034, 68004, 67342, 68035, 68037, 68007, 67345, 
68038, 68036, 68005, 67313, 67344
15136, 62131, 62121, 61901, 61911, 62132, 62122, 61902, 61912, 68037, 68007, 67345, 68038, 68040, 68010, 67348, 
68041, 68039, 68008, 67316, 67347
15137, 62132, 62122, 61902, 61912, 17984, 17983, 17961, 17962, 68040, 68010, 67348, 68041, 18520, 18517, 18475, 
18519, 68042, 68011, 67319, 67350
15138, 16489, 16488, 16466, 16467, 62133, 62123, 61903, 61913, 17025, 17024, 16980, 17026, 68044, 68014, 67352, 
68045, 68043, 68012, 67320, 67351
15139, 62133, 62123, 61903, 61913, 62134, 62124, 61904, 61914, 68044, 68014, 67352, 68045, 68047, 68017, 67355, 
68048, 68046, 68015, 67323, 67354
15140, 62134, 62124, 61904, 61914, 62135, 62125, 61905, 61915, 68047, 68017, 67355, 68048, 68050, 68020, 67358, 
68051, 68049, 68018, 67326, 67357
15141, 62135, 62125, 61905, 61915, 62136, 62126, 61906, 61916, 68050, 68020, 67358, 68051, 68053, 68023, 67361, 
68054, 68052, 68021, 67329, 67360
15142, 62136, 62126, 61906, 61916, 62137, 62127, 61907, 61917, 68053, 68023, 67361, 68054, 68056, 68026, 67364, 
68057, 68055, 68024, 67332, 67363
15143, 62137, 62127, 61907, 61917, 62138, 62128, 61908, 61918, 68056, 68026, 67364, 68057, 68059, 68029, 67367, 
68060, 68058, 68027, 67335, 67366
15144, 62138, 62128, 61908, 61918, 62139, 62129, 61909, 61919, 68059, 68029, 67367, 68060, 68062, 68032, 67370, 
68063, 68061, 68030, 67338, 67369
15145, 62139, 62129, 61909, 61919, 62140, 62130, 61910, 61920, 68062, 68032, 67370, 68063, 68065, 68035, 67373, 
68066, 68064, 68033, 67341, 67372
15146, 62140, 62130, 61910, 61920, 62141, 62131, 61911, 61921, 68065, 68035, 67373, 68066, 68068, 68038, 67376, 
68069, 68067, 68036, 67344, 67375
15147, 62141, 62131, 61911, 61921, 62142, 62132, 61912, 61922, 68068, 68038, 67376, 68069, 68071, 68041, 67379, 
68072, 68070, 68039, 67347, 67378
15148, 62142, 62132, 61912, 61922, 17985, 17984, 17962, 17963, 68071, 68041, 67379, 68072, 18522, 18519, 18477, 
18521, 68073, 68042, 67350, 67381
15149, 16490, 16489, 16467, 16468, 62143, 62133, 61913, 61923, 17027, 17026, 16982, 17028, 68075, 68045, 67383, 
68076, 68074, 68043, 67351, 67382
15150, 62143, 62133, 61913, 61923, 62144, 62134, 61914, 61924, 68075, 68045, 67383, 68076, 68078, 68048, 67386, 
68079, 68077, 68046, 67354, 67385
15151, 62144, 62134, 61914, 61924, 62145, 62135, 61915, 61925, 68078, 68048, 67386, 68079, 68081, 68051, 67389, 
68082, 68080, 68049, 67357, 67388
15152, 62145, 62135, 61915, 61925, 62146, 62136, 61916, 61926, 68081, 68051, 67389, 68082, 68084, 68054, 67392, 
68085, 68083, 68052, 67360, 67391
15153, 62146, 62136, 61916, 61926, 62147, 62137, 61917, 61927, 68084, 68054, 67392, 68085, 68087, 68057, 67395, 
68088, 68086, 68055, 67363, 67394
15154, 62147, 62137, 61917, 61927, 62148, 62138, 61918, 61928, 68087, 68057, 67395, 68088, 68090, 68060, 67398, 
68091, 68089, 68058, 67366, 67397
15155, 62148, 62138, 61918, 61928, 62149, 62139, 61919, 61929, 68090, 68060, 67398, 68091, 68093, 68063, 67401, 
68094, 68092, 68061, 67369, 67400
15156, 62149, 62139, 61919, 61929, 62150, 62140, 61920, 61930, 68093, 68063, 67401, 68094, 68096, 68066, 67404, 
68097, 68095, 68064, 67372, 67403
15157, 62150, 62140, 61920, 61930, 62151, 62141, 61921, 61931, 68096, 68066, 67404, 68097, 68099, 68069, 67407, 
68100, 68098, 68067, 67375, 67406
15158, 62151, 62141, 61921, 61931, 62152, 62142, 61922, 61932, 68099, 68069, 67407, 68100, 68102, 68072, 67410, 
68103, 68101, 68070, 67378, 67409
15159, 62152, 62142, 61922, 61932, 17986, 17985, 17963, 17964, 68102, 68072, 67410, 68103, 18524, 18521, 18479, 
18523, 68104, 68073, 67381, 67412
15160, 16491, 16490, 16468, 16469, 62153, 62143, 61923, 61933, 17029, 17028, 16984, 17030, 68106, 68076, 67414, 
68107, 68105, 68074, 67382, 67413
15161, 62153, 62143, 61923, 61933, 62154, 62144, 61924, 61934, 68106, 68076, 67414, 68107, 68109, 68079, 67417, 
68110, 68108, 68077, 67385, 67416
15162, 62154, 62144, 61924, 61934, 62155, 62145, 61925, 61935, 68109, 68079, 67417, 68110, 68112, 68082, 67420, 
68113, 68111, 68080, 67388, 67419
15163, 62155, 62145, 61925, 61935, 62156, 62146, 61926, 61936, 68112, 68082, 67420, 68113, 68115, 68085, 67423, 
68116, 68114, 68083, 67391, 67422
15164, 62156, 62146, 61926, 61936, 62157, 62147, 61927, 61937, 68115, 68085, 67423, 68116, 68118, 68088, 67426, 
68119, 68117, 68086, 67394, 67425
15165, 62157, 62147, 61927, 61937, 62158, 62148, 61928, 61938, 68118, 68088, 67426, 68119, 68121, 68091, 67429, 
68122, 68120, 68089, 67397, 67428
15166, 62158, 62148, 61928, 61938, 62159, 62149, 61929, 61939, 68121, 68091, 67429, 68122, 68124, 68094, 67432, 
68125, 68123, 68092, 67400, 67431
15167, 62159, 62149, 61929, 61939, 62160, 62150, 61930, 61940, 68124, 68094, 67432, 68125, 68127, 68097, 67435, 
68128, 68126, 68095, 67403, 67434
15168, 62160, 62150, 61930, 61940, 62161, 62151, 61931, 61941, 68127, 68097, 67435, 68128, 68130, 68100, 67438, 
68131, 68129, 68098, 67406, 67437
15169, 62161, 62151, 61931, 61941, 62162, 62152, 61932, 61942, 68130, 68100, 67438, 68131, 68133, 68103, 67441, 
68134, 68132, 68101, 67409, 67440
15170, 62162, 62152, 61932, 61942, 17987, 17986, 17964, 17965, 68133, 68103, 67441, 68134, 18526, 18523, 18481, 
18525, 68135, 68104, 67412, 67443
15171, 16492, 16491, 16469, 16470, 62163, 62153, 61933, 61943, 17031, 17030, 16986, 17032, 68137, 68107, 67445, 
68138, 68136, 68105, 67413, 67444
15172, 62163, 62153, 61933, 61943, 62164, 62154, 61934, 61944, 68137, 68107, 67445, 68138, 68140, 68110, 67448, 
68141, 68139, 68108, 67416, 67447
15173, 62164, 62154, 61934, 61944, 62165, 62155, 61935, 61945, 68140, 68110, 67448, 68141, 68143, 68113, 67451, 
68144, 68142, 68111, 67419, 67450
15174, 62165, 62155, 61935, 61945, 62166, 62156, 61936, 61946, 68143, 68113, 67451, 68144, 68146, 68116, 67454, 
68147, 68145, 68114, 67422, 67453
15175, 62166, 62156, 61936, 61946, 62167, 62157, 61937, 61947, 68146, 68116, 67454, 68147, 68149, 68119, 67457, 
68150, 68148, 68117, 67425, 67456
15176, 62167, 62157, 61937, 61947, 62168, 62158, 61938, 61948, 68149, 68119, 67457, 68150, 68152, 68122, 67460, 
68153, 68151, 68120, 67428, 67459
15177, 62168, 62158, 61938, 61948, 62169, 62159, 61939, 61949, 68152, 68122, 67460, 68153, 68155, 68125, 67463, 
68156, 68154, 68123, 67431, 67462
15178, 62169, 62159, 61939, 61949, 62170, 62160, 61940, 61950, 68155, 68125, 67463, 68156, 68158, 68128, 67466, 
68159, 68157, 68126, 67434, 67465
15179, 62170, 62160, 61940, 61950, 62171, 62161, 61941, 61951, 68158, 68128, 67466, 68159, 68161, 68131, 67469, 
68162, 68160, 68129, 67437, 67468
15180, 62171, 62161, 61941, 61951, 62172, 62162, 61942, 61952, 68161, 68131, 67469, 68162, 68164, 68134, 67472, 
68165, 68163, 68132, 67440, 67471
15181, 62172, 62162, 61942, 61952, 17988, 17987, 17965, 17966, 68164, 68134, 67472, 68165, 18528, 18525, 18483, 
18527, 68166, 68135, 67443, 67474
15182, 16493, 16492, 16470, 16471, 62173, 62163, 61943, 61953, 17033, 17032, 16988, 17034, 68168, 68138, 67476, 
68169, 68167, 68136, 67444, 67475
15183, 62173, 62163, 61943, 61953, 62174, 62164, 61944, 61954, 68168, 68138, 67476, 68169, 68171, 68141, 67479, 
68172, 68170, 68139, 67447, 67478
15184, 62174, 62164, 61944, 61954, 62175, 62165, 61945, 61955, 68171, 68141, 67479, 68172, 68174, 68144, 67482, 
68175, 68173, 68142, 67450, 67481
15185, 62175, 62165, 61945, 61955, 62176, 62166, 61946, 61956, 68174, 68144, 67482, 68175, 68177, 68147, 67485, 
68178, 68176, 68145, 67453, 67484
15186, 62176, 62166, 61946, 61956, 62177, 62167, 61947, 61957, 68177, 68147, 67485, 68178, 68180, 68150, 67488, 
68181, 68179, 68148, 67456, 67487
15187, 62177, 62167, 61947, 61957, 62178, 62168, 61948, 61958, 68180, 68150, 67488, 68181, 68183, 68153, 67491, 
68184, 68182, 68151, 67459, 67490
15188, 62178, 62168, 61948, 61958, 62179, 62169, 61949, 61959, 68183, 68153, 67491, 68184, 68186, 68156, 67494, 
68187, 68185, 68154, 67462, 67493
15189, 62179, 62169, 61949, 61959, 62180, 62170, 61950, 61960, 68186, 68156, 67494, 68187, 68189, 68159, 67497, 
68190, 68188, 68157, 67465, 67496
15190, 62180, 62170, 61950, 61960, 62181, 62171, 61951, 61961, 68189, 68159, 67497, 68190, 68192, 68162, 67500, 
68193, 68191, 68160, 67468, 67499
15191, 62181, 62171, 61951, 61961, 62182, 62172, 61952, 61962, 68192, 68162, 67500, 68193, 68195, 68165, 67503, 
68196, 68194, 68163, 67471, 67502
15192, 62182, 62172, 61952, 61962, 17989, 17988, 17966, 17967, 68195, 68165, 67503, 68196, 18530, 18527, 18485, 
18529, 68197, 68166, 67474, 67505
15193, 16494, 16493, 16471, 16472, 62183, 62173, 61953, 61963, 17035, 17034, 16990, 17036, 68199, 68169, 67507, 
68200, 68198, 68167, 67475, 67506
15194, 62183, 62173, 61953, 61963, 62184, 62174, 61954, 61964, 68199, 68169, 67507, 68200, 68202, 68172, 67510, 
68203, 68201, 68170, 67478, 67509
15195, 62184, 62174, 61954, 61964, 62185, 62175, 61955, 61965, 68202, 68172, 67510, 68203, 68205, 68175, 67513, 
68206, 68204, 68173, 67481, 67512
15196, 62185, 62175, 61955, 61965, 62186, 62176, 61956, 61966, 68205, 68175, 67513, 68206, 68208, 68178, 67516, 
68209, 68207, 68176, 67484, 67515
