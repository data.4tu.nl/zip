30555, 9975, 9985, 9986, 9976, 10371, 10372, 10373, 10351
30556, 9976, 9986, 9987, 9977, 10373, 10374, 10375, 10353
30557, 9977, 9987, 9988, 9978, 10375, 10376, 10377, 10355
30558, 9978, 9988, 9989, 9979, 10377, 10378, 10379, 10357
30559, 9979, 9989, 9990, 9980, 10379, 10380, 10381, 10359
30560, 9980, 9990, 9991, 9981, 10381, 10382, 10383, 10361
30561, 9981, 9991, 9992, 9982, 10383, 10384, 10385, 10363
30562, 9982, 9992, 9993, 9983, 10385, 10386, 10387, 10365
30563, 9983, 9993, 9994, 9984, 10387, 10388, 10389, 10367
30564, 9984, 9994, 577, 576, 10389, 10390, 599, 10369
30565, 733, 734, 9995, 9985, 756, 10391, 10392, 10370
30566, 9985, 9995, 9996, 9986, 10392, 10393, 10394, 10372
30567, 9986, 9996, 9997, 9987, 10394, 10395, 10396, 10374
30568, 9987, 9997, 9998, 9988, 10396, 10397, 10398, 10376
30569, 9988, 9998, 9999, 9989, 10398, 10399, 10400, 10378
30570, 9989, 9999, 10000, 9990, 10400, 10401, 10402, 10380
30571, 9990, 10000, 10001, 9991, 10402, 10403, 10404, 10382
30572, 9991, 10001, 10002, 9992, 10404, 10405, 10406, 10384
30573, 9992, 10002, 10003, 9993, 10406, 10407, 10408, 10386
30574, 9993, 10003, 10004, 9994, 10408, 10409, 10410, 10388
30575, 9994, 10004, 578, 577, 10410, 10411, 600, 10390
30576, 734, 735, 10005, 9995, 757, 10412, 10413, 10391
30577, 9995, 10005, 10006, 9996, 10413, 10414, 10415, 10393
30578, 9996, 10006, 10007, 9997, 10415, 10416, 10417, 10395
30579, 9997, 10007, 10008, 9998, 10417, 10418, 10419, 10397
30580, 9998, 10008, 10009, 9999, 10419, 10420, 10421, 10399
30581, 9999, 10009, 10010, 10000, 10421, 10422, 10423, 10401
30582, 10000, 10010, 10011, 10001, 10423, 10424, 10425, 10403
30583, 10001, 10011, 10012, 10002, 10425, 10426, 10427, 10405
30584, 10002, 10012, 10013, 10003, 10427, 10428, 10429, 10407
30585, 10003, 10013, 10014, 10004, 10429, 10430, 10431, 10409
30586, 10004, 10014, 579, 578, 10431, 10432, 601, 10411
30587, 735, 736, 10015, 10005, 758, 10433, 10434, 10412
30588, 10005, 10015, 10016, 10006, 10434, 10435, 10436, 10414
30589, 10006, 10016, 10017, 10007, 10436, 10437, 10438, 10416
30590, 10007, 10017, 10018, 10008, 10438, 10439, 10440, 10418
30591, 10008, 10018, 10019, 10009, 10440, 10441, 10442, 10420
30592, 10009, 10019, 10020, 10010, 10442, 10443, 10444, 10422
30593, 10010, 10020, 10021, 10011, 10444, 10445, 10446, 10424
30594, 10011, 10021, 10022, 10012, 10446, 10447, 10448, 10426
30595, 10012, 10022, 10023, 10013, 10448, 10449, 10450, 10428
30596, 10013, 10023, 10024, 10014, 10450, 10451, 10452, 10430
30597, 10014, 10024, 580, 579, 10452, 10453, 602, 10432
30598, 736, 737, 10025, 10015, 759, 10454, 10455, 10433
30599, 10015, 10025, 10026, 10016, 10455, 10456, 10457, 10435
30600, 10016, 10026, 10027, 10017, 10457, 10458, 10459, 10437
30601, 10017, 10027, 10028, 10018, 10459, 10460, 10461, 10439
30602, 10018, 10028, 10029, 10019, 10461, 10462, 10463, 10441
30603, 10019, 10029, 10030, 10020, 10463, 10464, 10465, 10443
30604, 10020, 10030, 10031, 10021, 10465, 10466, 10467, 10445
30605, 10021, 10031, 10032, 10022, 10467, 10468, 10469, 10447
30606, 10022, 10032, 10033, 10023, 10469, 10470, 10471, 10449
30607, 10023, 10033, 10034, 10024, 10471, 10472, 10473, 10451
30608, 10024, 10034, 581, 580, 10473, 10474, 603, 10453
30609, 737, 738, 10035, 10025, 760, 10475, 10476, 10454
30610, 10025, 10035, 10036, 10026, 10476, 10477, 10478, 10456
30611, 10026, 10036, 10037, 10027, 10478, 10479, 10480, 10458
30612, 10027, 10037, 10038, 10028, 10480, 10481, 10482, 10460
30613, 10028, 10038, 10039, 10029, 10482, 10483, 10484, 10462
30614, 10029, 10039, 10040, 10030, 10484, 10485, 10486, 10464
30615, 10030, 10040, 10041, 10031, 10486, 10487, 10488, 10466
30616, 10031, 10041, 10042, 10032, 10488, 10489, 10490, 10468
30617, 10032, 10042, 10043, 10033, 10490, 10491, 10492, 10470
30618, 10033, 10043, 10044, 10034, 10492, 10493, 10494, 10472
30619, 10034, 10044, 582, 581, 10494, 10495, 604, 10474
30620, 738, 739, 10045, 10035, 761, 10496, 10497, 10475
30621, 10035, 10045, 10046, 10036, 10497, 10498, 10499, 10477
30622, 10036, 10046, 10047, 10037, 10499, 10500, 10501, 10479
30623, 10037, 10047, 10048, 10038, 10501, 10502, 10503, 10481
30624, 10038, 10048, 10049, 10039, 10503, 10504, 10505, 10483
30625, 10039, 10049, 10050, 10040, 10505, 10506, 10507, 10485
30626, 10040, 10050, 10051, 10041, 10507, 10508, 10509, 10487
30627, 10041, 10051, 10052, 10042, 10509, 10510, 10511, 10489
30628, 10042, 10052, 10053, 10043, 10511, 10512, 10513, 10491
30629, 10043, 10053, 10054, 10044, 10513, 10514, 10515, 10493
30630, 10044, 10054, 583, 582, 10515, 10516, 605, 10495
30631, 739, 16, 817, 10045, 762, 828, 10517, 10496
30632, 10045, 817, 816, 10046, 10517, 827, 10518, 10498
30633, 10046, 816, 815, 10047, 10518, 826, 10519, 10500
30634, 10047, 815, 814, 10048, 10519, 825, 10520, 10502
30635, 10048, 814, 813, 10049, 10520, 824, 10521, 10504
30636, 10049, 813, 812, 10050, 10521, 823, 10522, 10506
30637, 10050, 812, 811, 10051, 10522, 822, 10523, 10508
30638, 10051, 811, 810, 10052, 10523, 821, 10524, 10510
30639, 10052, 810, 809, 10053, 10524, 820, 10525, 10512
30640, 10053, 809, 808, 10054, 10525, 819, 10526, 10514
30641, 10054, 808, 14, 583, 10526, 818, 606, 10516
*ELEMENT, type=CPS8, ELSET=Surface16
30642, 14, 808, 10527, 607, 818, 10747, 10748, 629
30643, 808, 809, 10528, 10527, 819, 10749, 10750, 10747
30644, 809, 810, 10529, 10528, 820, 10751, 10752, 10749
30645, 810, 811, 10530, 10529, 821, 10753, 10754, 10751
30646, 811, 812, 10531, 10530, 822, 10755, 10756, 10753
30647, 812, 813, 10532, 10531, 823, 10757, 10758, 10755
30648, 813, 814, 10533, 10532, 824, 10759, 10760, 10757
30649, 814, 815, 10534, 10533, 825, 10761, 10762, 10759
30650, 815, 816, 10535, 10534, 826, 10763, 10764, 10761
30651, 816, 817, 10536, 10535, 827, 10765, 10766, 10763
30652, 817, 16, 763, 10536, 828, 785, 10767, 10765
30653, 607, 10527, 10537, 608, 10748, 10768, 10769, 630
30654, 10527, 10528, 10538, 10537, 10750, 10770, 10771, 10768
30655, 10528, 10529, 10539, 10538, 10752, 10772, 10773, 10770
30656, 10529, 10530, 10540, 10539, 10754, 10774, 10775, 10772
30657, 10530, 10531, 10541, 10540, 10756, 10776, 10777, 10774
30658, 10531, 10532, 10542, 10541, 10758, 10778, 10779, 10776
30659, 10532, 10533, 10543, 10542, 10760, 10780, 10781, 10778
30660, 10533, 10534, 10544, 10543, 10762, 10782, 10783, 10780
30661, 10534, 10535, 10545, 10544, 10764, 10784, 10785, 10782
30662, 10535, 10536, 10546, 10545, 10766, 10786, 10787, 10784
30663, 10536, 763, 764, 10546, 10767, 786, 10788, 10786
30664, 608, 10537, 10547, 609, 10769, 10789, 10790, 631
30665, 10537, 10538, 10548, 10547, 10771, 10791, 10792, 10789
30666, 10538, 10539, 10549, 10548, 10773, 10793, 10794, 10791
30667, 10539, 10540, 10550, 10549, 10775, 10795, 10796, 10793
30668, 10540, 10541, 10551, 10550, 10777, 10797, 10798, 10795
30669, 10541, 10542, 10552, 10551, 10779, 10799, 10800, 10797
30670, 10542, 10543, 10553, 10552, 10781, 10801, 10802, 10799
30671, 10543, 10544, 10554, 10553, 10783, 10803, 10804, 10801
30672, 10544, 10545, 10555, 10554, 10785, 10805, 10806, 10803
30673, 10545, 10546, 10556, 10555, 10787, 10807, 10808, 10805
30674, 10546, 764, 765, 10556, 10788, 787, 10809, 10807
30675, 609, 10547, 10557, 610, 10790, 10810, 10811, 632
30676, 10547, 10548, 10558, 10557, 10792, 10812, 10813, 10810
30677, 10548, 10549, 10559, 10558, 10794, 10814, 10815, 10812
30678, 10549, 10550, 10560, 10559, 10796, 10816, 10817, 10814
30679, 10550, 10551, 10561, 10560, 10798, 10818, 10819, 10816
30680, 10551, 10552, 10562, 10561, 10800, 10820, 10821, 10818
30681, 10552, 10553, 10563, 10562, 10802, 10822, 10823, 10820
30682, 10553, 10554, 10564, 10563, 10804, 10824, 10825, 10822
30683, 10554, 10555, 10565, 10564, 10806, 10826, 10827, 10824
30684, 10555, 10556, 10566, 10565, 10808, 10828, 10829, 10826
30685, 10556, 765, 766, 10566, 10809, 788, 10830, 10828
30686, 610, 10557, 10567, 611, 10811, 10831, 10832, 633
30687, 10557, 10558, 10568, 10567, 10813, 10833, 10834, 10831
30688, 10558, 10559, 10569, 10568, 10815, 10835, 10836, 10833
30689, 10559, 10560, 10570, 10569, 10817, 10837, 10838, 10835
30690, 10560, 10561, 10571, 10570, 10819, 10839, 10840, 10837
30691, 10561, 10562, 10572, 10571, 10821, 10841, 10842, 10839
30692, 10562, 10563, 10573, 10572, 10823, 10843, 10844, 10841
30693, 10563, 10564, 10574, 10573, 10825, 10845, 10846, 10843
30694, 10564, 10565, 10575, 10574, 10827, 10847, 10848, 10845
30695, 10565, 10566, 10576, 10575, 10829, 10849, 10850, 10847
30696, 10566, 766, 767, 10576, 10830, 789, 10851, 10849
30697, 611, 10567, 10577, 612, 10832, 10852, 10853, 634
30698, 10567, 10568, 10578, 10577, 10834, 10854, 10855, 10852
30699, 10568, 10569, 10579, 10578, 10836, 10856, 10857, 10854
30700, 10569, 10570, 10580, 10579, 10838, 10858, 10859, 10856
30701, 10570, 10571, 10581, 10580, 10840, 10860, 10861, 10858
30702, 10571, 10572, 10582, 10581, 10842, 10862, 10863, 10860
30703, 10572, 10573, 10583, 10582, 10844, 10864, 10865, 10862
30704, 10573, 10574, 10584, 10583, 10846, 10866, 10867, 10864
30705, 10574, 10575, 10585, 10584, 10848, 10868, 10869, 10866
30706, 10575, 10576, 10586, 10585, 10850, 10870, 10871, 10868
30707, 10576, 767, 768, 10586, 10851, 790, 10872, 10870
30708, 612, 10577, 10587, 613, 10853, 10873, 10874, 635
30709, 10577, 10578, 10588, 10587, 10855, 10875, 10876, 10873
30710, 10578, 10579, 10589, 10588, 10857, 10877, 10878, 10875
30711, 10579, 10580, 10590, 10589, 10859, 10879, 10880, 10877
30712, 10580, 10581, 10591, 10590, 10861, 10881, 10882, 10879
30713, 10581, 10582, 10592, 10591, 10863, 10883, 10884, 10881
30714, 10582, 10583, 10593, 10592, 10865, 10885, 10886, 10883
30715, 10583, 10584, 10594, 10593, 10867, 10887, 10888, 10885
30716, 10584, 10585, 10595, 10594, 10869, 10889, 10890, 10887
30717, 10585, 10586, 10596, 10595, 10871, 10891, 10892, 10889
30718, 10586, 768, 769, 10596, 10872, 791, 10893, 10891
30719, 613, 10587, 10597, 614, 10874, 10894, 10895, 636
30720, 10587, 10588, 10598, 10597, 10876, 10896, 10897, 10894
30721, 10588, 10589, 10599, 10598, 10878, 10898, 10899, 10896
30722, 10589, 10590, 10600, 10599, 10880, 10900, 10901, 10898
30723, 10590, 10591, 10601, 10600, 10882, 10902, 10903, 10900
30724, 10591, 10592, 10602, 10601, 10884, 10904, 10905, 10902
30725, 10592, 10593, 10603, 10602, 10886, 10906, 10907, 10904
30726, 10593, 10594, 10604, 10603, 10888, 10908, 10909, 10906
30727, 10594, 10595, 10605, 10604, 10890, 10910, 10911, 10908
30728, 10595, 10596, 10606, 10605, 10892, 10912, 10913, 10910
30729, 10596, 769, 770, 10606, 10893, 792, 10914, 10912
30730, 614, 10597, 10607, 615, 10895, 10915, 10916, 637
30731, 10597, 10598, 10608, 10607, 10897, 10917, 10918, 10915
30732, 10598, 10599, 10609, 10608, 10899, 10919, 10920, 10917
30733, 10599, 10600, 10610, 10609, 10901, 10921, 10922, 10919
30734, 10600, 10601, 10611, 10610, 10903, 10923, 10924, 10921
30735, 10601, 10602, 10612, 10611, 10905, 10925, 10926, 10923
30736, 10602, 10603, 10613, 10612, 10907, 10927, 10928, 10925
30737, 10603, 10604, 10614, 10613, 10909, 10929, 10930, 10927
30738, 10604, 10605, 10615, 10614, 10911, 10931, 10932, 10929
30739, 10605, 10606, 10616, 10615, 10913, 10933, 10934, 10931
30740, 10606, 770, 771, 10616, 10914, 793, 10935, 10933
30741, 615, 10607, 10617, 616, 10916, 10936, 10937, 638
30742, 10607, 10608, 10618, 10617, 10918, 10938, 10939, 10936
30743, 10608, 10609, 10619, 10618, 10920, 10940, 10941, 10938
30744, 10609, 10610, 10620, 10619, 10922, 10942, 10943, 10940
30745, 10610, 10611, 10621, 10620, 10924, 10944, 10945, 10942
30746, 10611, 10612, 10622, 10621, 10926, 10946, 10947, 10944
30747, 10612, 10613, 10623, 10622, 10928, 10948, 10949, 10946
30748, 10613, 10614, 10624, 10623, 10930, 10950, 10951, 10948
30749, 10614, 10615, 10625, 10624, 10932, 10952, 10953, 10950
30750, 10615, 10616, 10626, 10625, 10934, 10954, 10955, 10952
30751, 10616, 771, 772, 10626, 10935, 794, 10956, 10954
30752, 616, 10617, 10627, 617, 10937, 10957, 10958, 639
30753, 10617, 10618, 10628, 10627, 10939, 10959, 10960, 10957
30754, 10618, 10619, 10629, 10628, 10941, 10961, 10962, 10959
30755, 10619, 10620, 10630, 10629, 10943, 10963, 10964, 10961
30756, 10620, 10621, 10631, 10630, 10945, 10965, 10966, 10963
30757, 10621, 10622, 10632, 10631, 10947, 10967, 10968, 10965
30758, 10622, 10623, 10633, 10632, 10949, 10969, 10970, 10967
30759, 10623, 10624, 10634, 10633, 10951, 10971, 10972, 10969
30760, 10624, 10625, 10635, 10634, 10953, 10973, 10974, 10971
30761, 10625, 10626, 10636, 10635, 10955, 10975, 10976, 10973
30762, 10626, 772, 773, 10636, 10956, 795, 10977, 10975
30763, 617, 10627, 10637, 618, 10958, 10978, 10979, 640
30764, 10627, 10628, 10638, 10637, 10960, 10980, 10981, 10978
30765, 10628, 10629, 10639, 10638, 10962, 10982, 10983, 10980
30766, 10629, 10630, 10640, 10639, 10964, 10984, 10985, 10982
30767, 10630, 10631, 10641, 10640, 10966, 10986, 10987, 10984
30768, 10631, 10632, 10642, 10641, 10968, 10988, 10989, 10986
30769, 10632, 10633, 10643, 10642, 10970, 10990, 10991, 10988
30770, 10633, 10634, 10644, 10643, 10972, 10992, 10993, 10990
30771, 10634, 10635, 10645, 10644, 10974, 10994, 10995, 10992
30772, 10635, 10636, 10646, 10645, 10976, 10996, 10997, 10994
30773, 10636, 773, 774, 10646, 10977, 796, 10998, 10996
30774, 618, 10637, 10647, 619, 10979, 10999, 11000, 641
30775, 10637, 10638, 10648, 10647, 10981, 11001, 11002, 10999
30776, 10638, 10639, 10649, 10648, 10983, 11003, 11004, 11001
30777, 10639, 10640, 10650, 10649, 10985, 11005, 11006, 11003
30778, 10640, 10641, 10651, 10650, 10987, 11007, 11008, 11005
30779, 10641, 10642, 10652, 10651, 10989, 11009, 11010, 11007
30780, 10642, 10643, 10653, 10652, 10991, 11011, 11012, 11009
30781, 10643, 10644, 10654, 10653, 10993, 11013, 11014, 11011
30782, 10644, 10645, 10655, 10654, 10995, 11015, 11016, 11013
30783, 10645, 10646, 10656, 10655, 10997, 11017, 11018, 11015
30784, 10646, 774, 775, 10656, 10998, 797, 11019, 11017
30785, 619, 10647, 10657, 620, 11000, 11020, 11021, 642
30786, 10647, 10648, 10658, 10657, 11002, 11022, 11023, 11020
30787, 10648, 10649, 10659, 10658, 11004, 11024, 11025, 11022
30788, 10649, 10650, 10660, 10659, 11006, 11026, 11027, 11024
30789, 10650, 10651, 10661, 10660, 11008, 11028, 11029, 11026
30790, 10651, 10652, 10662, 10661, 11010, 11030, 11031, 11028
30791, 10652, 10653, 10663, 10662, 11012, 11032, 11033, 11030
30792, 10653, 10654, 10664, 10663, 11014, 11034, 11035, 11032
30793, 10654, 10655, 10665, 10664, 11016, 11036, 11037, 11034
30794, 10655, 10656, 10666, 10665, 11018, 11038, 11039, 11036
30795, 10656, 775, 776, 10666, 11019, 798, 11040, 11038
30796, 620, 10657, 10667, 621, 11021, 11041, 11042, 643
30797, 10657, 10658, 10668, 10667, 11023, 11043, 11044, 11041
30798, 10658, 10659, 10669, 10668, 11025, 11045, 11046, 11043
30799, 10659, 10660, 10670, 10669, 11027, 11047, 11048, 11045
30800, 10660, 10661, 10671, 10670, 11029, 11049, 11050, 11047
30801, 10661, 10662, 10672, 10671, 11031, 11051, 11052, 11049
30802, 10662, 10663, 10673, 10672, 11033, 11053, 11054, 11051
30803, 10663, 10664, 10674, 10673, 11035, 11055, 11056, 11053
30804, 10664, 10665, 10675, 10674, 11037, 11057, 11058, 11055
30805, 10665, 10666, 10676, 10675, 11039, 11059, 11060, 11057
30806, 10666, 776, 777, 10676, 11040, 799, 11061, 11059
30807, 621, 10667, 10677, 622, 11042, 11062, 11063, 644
30808, 10667, 10668, 10678, 10677, 11044, 11064, 11065, 11062
30809, 10668, 10669, 10679, 10678, 11046, 11066, 11067, 11064
30810, 10669, 10670, 10680, 10679, 11048, 11068, 11069, 11066
30811, 10670, 10671, 10681, 10680, 11050, 11070, 11071, 11068
30812, 10671, 10672, 10682, 10681, 11052, 11072, 11073, 11070
30813, 10672, 10673, 10683, 10682, 11054, 11074, 11075, 11072
30814, 10673, 10674, 10684, 10683, 11056, 11076, 11077, 11074
30815, 10674, 10675, 10685, 10684, 11058, 11078, 11079, 11076
30816, 10675, 10676, 10686, 10685, 11060, 11080, 11081, 11078
30817, 10676, 777, 778, 10686, 11061, 800, 11082, 11080
30818, 622, 10677, 10687, 623, 11063, 11083, 11084, 645
30819, 10677, 10678, 10688, 10687, 11065, 11085, 11086, 11083
30820, 10678, 10679, 10689, 10688, 11067, 11087, 11088, 11085
30821, 10679, 10680, 10690, 10689, 11069, 11089, 11090, 11087
30822, 10680, 10681, 10691, 10690, 11071, 11091, 11092, 11089
30823, 10681, 10682, 10692, 10691, 11073, 11093, 11094, 11091
30824, 10682, 10683, 10693, 10692, 11075, 11095, 11096, 11093
30825, 10683, 10684, 10694, 10693, 11077, 11097, 11098, 11095
30826, 10684, 10685, 10695, 10694, 11079, 11099, 11100, 11097
30827, 10685, 10686, 10696, 10695, 11081, 11101, 11102, 11099
30828, 10686, 778, 779, 10696, 11082, 801, 11103, 11101
30829, 623, 10687, 10697, 624, 11084, 11104, 11105, 646
30830, 10687, 10688, 10698, 10697, 11086, 11106, 11107, 11104
30831, 10688, 10689, 10699, 10698, 11088, 11108, 11109, 11106
30832, 10689, 10690, 10700, 10699, 11090, 11110, 11111, 11108
30833, 10690, 10691, 10701, 10700, 11092, 11112, 11113, 11110
30834, 10691, 10692, 10702, 10701, 11094, 11114, 11115, 11112
30835, 10692, 10693, 10703, 10702, 11096, 11116, 11117, 11114
30836, 10693, 10694, 10704, 10703, 11098, 11118, 11119, 11116
30837, 10694, 10695, 10705, 10704, 11100, 11120, 11121, 11118
30838, 10695, 10696, 10706, 10705, 11102, 11122, 11123, 11120
30839, 10696, 779, 780, 10706, 11103, 802, 11124, 11122
30840, 624, 10697, 10707, 625, 11105, 11125, 11126, 647
30841, 10697, 10698, 10708, 10707, 11107, 11127, 11128, 11125
30842, 10698, 10699, 10709, 10708, 11109, 11129, 11130, 11127
30843, 10699, 10700, 10710, 10709, 11111, 11131, 11132, 11129
30844, 10700, 10701, 10711, 10710, 11113, 11133, 11134, 11131
30845, 10701, 10702, 10712, 10711, 11115, 11135, 11136, 11133
30846, 10702, 10703, 10713, 10712, 11117, 11137, 11138, 11135
30847, 10703, 10704, 10714, 10713, 11119, 11139, 11140, 11137
30848, 10704, 10705, 10715, 10714, 11121, 11141, 11142, 11139
30849, 10705, 10706, 10716, 10715, 11123, 11143, 11144, 11141
30850, 10706, 780, 781, 10716, 11124, 803, 11145, 11143
30851, 625, 10707, 10717, 626, 11126, 11146, 11147, 648
30852, 10707, 10708, 10718, 10717, 11128, 11148, 11149, 11146
30853, 10708, 10709, 10719, 10718, 11130, 11150, 11151, 11148
30854, 10709, 10710, 10720, 10719, 11132, 11152, 11153, 11150
30855, 10710, 10711, 10721, 10720, 11134, 11154, 11155, 11152
30856, 10711, 10712, 10722, 10721, 11136, 11156, 11157, 11154
30857, 10712, 10713, 10723, 10722, 11138, 11158, 11159, 11156
30858, 10713, 10714, 10724, 10723, 11140, 11160, 11161, 11158
30859, 10714, 10715, 10725, 10724, 11142, 11162, 11163, 11160
30860, 10715, 10716, 10726, 10725, 11144, 11164, 11165, 11162
30861, 10716, 781, 782, 10726, 11145, 804, 11166, 11164
30862, 626, 10717, 10727, 627, 11147, 11167, 11168, 649
30863, 10717, 10718, 10728, 10727, 11149, 11169, 11170, 11167
30864, 10718, 10719, 10729, 10728, 11151, 11171, 11172, 11169
30865, 10719, 10720, 10730, 10729, 11153, 11173, 11174, 11171
30866, 10720, 10721, 10731, 10730, 11155, 11175, 11176, 11173
30867, 10721, 10722, 10732, 10731, 11157, 11177, 11178, 11175
30868, 10722, 10723, 10733, 10732, 11159, 11179, 11180, 11177
30869, 10723, 10724, 10734, 10733, 11161, 11181, 11182, 11179
30870, 10724, 10725, 10735, 10734, 11163, 11183, 11184, 11181
30871, 10725, 10726, 10736, 10735, 11165, 11185, 11186, 11183
30872, 10726, 782, 783, 10736, 11166, 805, 11187, 11185
30873, 627, 10727, 10737, 628, 11168, 11188, 11189, 650
30874, 10727, 10728, 10738, 10737, 11170, 11190, 11191, 11188
30875, 10728, 10729, 10739, 10738, 11172, 11192, 11193, 11190
30876, 10729, 10730, 10740, 10739, 11174, 11194, 11195, 11192
30877, 10730, 10731, 10741, 10740, 11176, 11196, 11197, 11194
30878, 10731, 10732, 10742, 10741, 11178, 11198, 11199, 11196
30879, 10732, 10733, 10743, 10742, 11180, 11200, 11201, 11198
30880, 10733, 10734, 10744, 10743, 11182, 11202, 11203, 11200
30881, 10734, 10735, 10745, 10744, 11184, 11204, 11205, 11202
30882, 10735, 10736, 10746, 10745, 11186, 11206, 11207, 11204
30883, 10736, 783, 784, 10746, 11187, 806, 11208, 11206
30884, 628, 10737, 697, 13, 11189, 11209, 707, 651
30885, 10737, 10738, 698, 697, 11191, 11210, 708, 11209
30886, 10738, 10739, 699, 698, 11193, 11211, 709, 11210
30887, 10739, 10740, 700, 699, 11195, 11212, 710, 11211
30888, 10740, 10741, 701, 700, 11197, 11213, 711, 11212
30889, 10741, 10742, 702, 701, 11199, 11214, 712, 11213
30890, 10742, 10743, 703, 702, 11201, 11215, 713, 11214
30891, 10743, 10744, 704, 703, 11203, 11216, 714, 11215
30892, 10744, 10745, 705, 704, 11205, 11217, 715, 11216
30893, 10745, 10746, 706, 705, 11207, 11218, 716, 11217
30894, 10746, 784, 15, 706, 11208, 807, 717, 11218
*ELEMENT, type=CPS8, ELSET=Surface17
30895, 13, 628, 11219, 829, 651, 11241, 11242, 830
30896, 628, 627, 11220, 11219, 650, 11243, 11244, 11241
30897, 627, 626, 11221, 11220, 649, 11245, 11246, 11243
30898, 626, 625, 11222, 11221, 648, 11247, 11248, 11245
30899, 625, 624, 11223, 11222, 647, 11249, 11250, 11247
30900, 624, 623, 11224, 11223, 646, 11251, 11252, 11249
30901, 623, 622, 11225, 11224, 645, 11253, 11254, 11251
30902, 622, 621, 11226, 11225, 644, 11255, 11256, 11253
30903, 621, 620, 11227, 11226, 643, 11257, 11258, 11255
30904, 620, 619, 11228, 11227, 642, 11259, 11260, 11257
30905, 619, 618, 11229, 11228, 641, 11261, 11262, 11259
30906, 618, 617, 11230, 11229, 640, 11263, 11264, 11261
30907, 617, 616, 11231, 11230, 639, 11265, 11266, 11263
30908, 616, 615, 11232, 11231, 638, 11267, 11268, 11265
30909, 615, 614, 11233, 11232, 637, 11269, 11270, 11267
30910, 614, 613, 11234, 11233, 636, 11271, 11272, 11269
30911, 613, 612, 11235, 11234, 635, 11273, 11274, 11271
30912, 612, 611, 11236, 11235, 634, 11275, 11276, 11273
30913, 611, 610, 11237, 11236, 633, 11277, 11278, 11275
30914, 610, 609, 11238, 11237, 632, 11279, 11280, 11277
30915, 609, 608, 11239, 11238, 631, 11281, 11282, 11279
30916, 608, 607, 11240, 11239, 630, 11283, 11284, 11281
30917, 607, 14, 832, 11240, 629, 833, 11285, 11283
30918, 829, 11219, 856, 17, 11242, 11286, 879, 831
30919, 11219, 11220, 855, 856, 11244, 11287, 878, 11286
30920, 11220, 11221, 854, 855, 11246, 11288, 877, 11287
30921, 11221, 11222, 853, 854, 11248, 11289, 876, 11288
30922, 11222, 11223, 852, 853, 11250, 11290, 875, 11289
30923, 11223, 11224, 851, 852, 11252, 11291, 874, 11290
30924, 11224, 11225, 850, 851, 11254, 11292, 873, 11291
30925, 11225, 11226, 849, 850, 11256, 11293, 872, 11292
30926, 11226, 11227, 848, 849, 11258, 11294, 871, 11293
30927, 11227, 11228, 847, 848, 11260, 11295, 870, 11294
30928, 11228, 11229, 846, 847, 11262, 11296, 869, 11295
30929, 11229, 11230, 845, 846, 11264, 11297, 868, 11296
30930, 11230, 11231, 844, 845, 11266, 11298, 867, 11297
30931, 11231, 11232, 843, 844, 11268, 11299, 866, 11298
30932, 11232, 11233, 842, 843, 11270, 11300, 865, 11299
30933, 11233, 11234, 841, 842, 11272, 11301, 864, 11300
30934, 11234, 11235, 840, 841, 11274, 11302, 863, 11301
30935, 11235, 11236, 839, 840, 11276, 11303, 862, 11302
30936, 11236, 11237, 838, 839, 11278, 11304, 861, 11303
30937, 11237, 11238, 837, 838, 11280, 11305, 860, 11304
30938, 11238, 11239, 836, 837, 11282, 11306, 859, 11305
30939, 11239, 11240, 835, 836, 11284, 11307, 858, 11306
30940, 11240, 832, 18, 835, 11285, 834, 857, 11307
*ELEMENT, type=CPS8, ELSET=Surface18
30941, 15, 706, 11308, 880, 717, 11318, 11319, 881
30942, 706, 705, 11309, 11308, 716, 11320, 11321, 11318
30943, 705, 704, 11310, 11309, 715, 11322, 11323, 11320
30944, 704, 703, 11311, 11310, 714, 11324, 11325, 11322
30945, 703, 702, 11312, 11311, 713, 11326, 11327, 11324
30946, 702, 701, 11313, 11312, 712, 11328, 11329, 11326
30947, 701, 700, 11314, 11313, 711, 11330, 11331, 11328
30948, 700, 699, 11315, 11314, 710, 11332, 11333, 11330
30949, 699, 698, 11316, 11315, 709, 11334, 11335, 11332
30950, 698, 697, 11317, 11316, 708, 11336, 11337, 11334
30951, 697, 13, 829, 11317, 707, 830, 11338, 11336
30952, 880, 11308, 892, 19, 11319, 11339, 903, 882
30953, 11308, 11309, 891, 892, 11321, 11340, 902, 11339
30954, 11309, 11310, 890, 891, 11323, 11341, 901, 11340
30955, 11310, 11311, 889, 890, 11325, 11342, 900, 11341
30956, 11311, 11312, 888, 889, 11327, 11343, 899, 11342
30957, 11312, 11313, 887, 888, 11329, 11344, 898, 11343
30958, 11313, 11314, 886, 887, 11331, 11345, 897, 11344
30959, 11314, 11315, 885, 886, 11333, 11346, 896, 11345
30960, 11315, 11316, 884, 885, 11335, 11347, 895, 11346
30961, 11316, 11317, 883, 884, 11337, 11348, 894, 11347
30962, 11317, 829, 17, 883, 11338, 831, 893, 11348
*ELEMENT, type=CPS8, ELSET=Surface19
898, 15, 880, 11349, 784, 881, 11371, 11372, 807
899, 784, 11349, 11350, 783, 11372, 11373, 11374, 806
900, 783, 11350, 11351, 782, 11374, 11375, 11376, 805
901, 782, 11351, 11352, 781, 11376, 11377, 11378, 804
902, 781, 11352, 11353, 780, 11378, 11379, 11380, 803
903, 780, 11353, 11354, 779, 11380, 11381, 11382, 802
904, 779, 11354, 11355, 778, 11382, 11383, 11384, 801
905, 778, 11355, 11356, 777, 11384, 11385, 11386, 800
906, 777, 11356, 11357, 776, 11386, 11387, 11388, 799
907, 776, 11357, 11358, 775, 11388, 11389, 11390, 798
908, 775, 11358, 11359, 774, 11390, 11391, 11392, 797
909, 774, 11359, 11360, 773, 11392, 11393, 11394, 796
910, 773, 11360, 11361, 772, 11394, 11395, 11396, 795
911, 772, 11361, 11362, 771, 11396, 11397, 11398, 794
912, 771, 11362, 11363, 770, 11398, 11399, 11400, 793
913, 770, 11363, 11364, 769, 11400, 11401, 11402, 792
914, 769, 11364, 11365, 768, 11402, 11403, 11404, 791
915, 768, 11365, 11366, 767, 11404, 11405, 11406, 790
916, 767, 11366, 11367, 766, 11406, 11407, 11408, 789
917, 766, 11367, 11368, 765, 11408, 11409, 11410, 788
918, 765, 11368, 11369, 764, 11410, 11411, 11412, 787
919, 764, 11369, 11370, 763, 11412, 11413, 11414, 786
920, 763, 11370, 904, 16, 11414, 11415, 905, 785
921, 880, 19, 928, 11349, 882, 951, 11416, 11371
922, 11349, 928, 927, 11350, 11416, 950, 11417, 11373
923, 11350, 927, 926, 11351, 11417, 949, 11418, 11375
924, 11351, 926, 925, 11352, 11418, 948, 11419, 11377
925, 11352, 925, 924, 11353, 11419, 947, 11420, 11379
926, 11353, 924, 923, 11354, 11420, 946, 11421, 11381
927, 11354, 923, 922, 11355, 11421, 945, 11422, 11383
928, 11355, 922, 921, 11356, 11422, 944, 11423, 11385
929, 11356, 921, 920, 11357, 11423, 943, 11424, 11387
930, 11357, 920, 919, 11358, 11424, 942, 11425, 11389
931, 11358, 919, 918, 11359, 11425, 941, 11426, 11391
932, 11359, 918, 917, 11360, 11426, 940, 11427, 11393
933, 11360, 917, 916, 11361, 11427, 939, 11428, 11395
934, 11361, 916, 915, 11362, 11428, 938, 11429, 11397
935, 11362, 915, 914, 11363, 11429, 937, 11430, 11399
936, 11363, 914, 913, 11364, 11430, 936, 11431, 11401
937, 11364, 913, 912, 11365, 11431, 935, 11432, 11403
938, 11365, 912, 911, 11366, 11432, 934, 11433, 11405
939, 11366, 911, 910, 11367, 11433, 933, 11434, 11407
940, 11367, 910, 909, 11368, 11434, 932, 11435, 11409
941, 11368, 909, 908, 11369, 11435, 931, 11436, 11411
942, 11369, 908, 907, 11370, 11436, 930, 11437, 11413
943, 11370, 907, 20, 904, 11437, 929, 906, 11415
*ELEMENT, type=CPS8, ELSET=Surface20
30963, 16, 904, 11438, 817, 905, 11448, 11449, 828
30964, 817, 11438, 11439, 816, 11449, 11450, 11451, 827
30965, 816, 11439, 11440, 815, 11451, 11452, 11453, 826
30966, 815, 11440, 11441, 814, 11453, 11454, 11455, 825
30967, 814, 11441, 11442, 813, 11455, 11456, 11457, 824
30968, 813, 11442, 11443, 812, 11457, 11458, 11459, 823
30969, 812, 11443, 11444, 811, 11459, 11460, 11461, 822
30970, 811, 11444, 11445, 810, 11461, 11462, 11463, 821
30971, 810, 11445, 11446, 809, 11463, 11464, 11465, 820
30972, 809, 11446, 11447, 808, 11465, 11466, 11467, 819
30973, 808, 11447, 832, 14, 11467, 11468, 833, 818
30974, 904, 20, 961, 11438, 906, 972, 11469, 11448
30975, 11438, 961, 960, 11439, 11469, 971, 11470, 11450
30976, 11439, 960, 959, 11440, 11470, 970, 11471, 11452
30977, 11440, 959, 958, 11441, 11471, 969, 11472, 11454
30978, 11441, 958, 957, 11442, 11472, 968, 11473, 11456
30979, 11442, 957, 956, 11443, 11473, 967, 11474, 11458
30980, 11443, 956, 955, 11444, 11474, 966, 11475, 11460
30981, 11444, 955, 954, 11445, 11475, 965, 11476, 11462
30982, 11445, 954, 953, 11446, 11476, 964, 11477, 11464
30983, 11446, 953, 952, 11447, 11477, 963, 11478, 11466
30984, 11447, 952, 18, 832, 11478, 962, 834, 11468
*ELEMENT, type=CPS8, ELSET=Surface21
30985, 18, 952, 11479, 835, 962, 11699, 11700, 857
30986, 952, 953, 11480, 11479, 963, 11701, 11702, 11699
30987, 953, 954, 11481, 11480, 964, 11703, 11704, 11701
30988, 954, 955, 11482, 11481, 965, 11705, 11706, 11703
30989, 955, 956, 11483, 11482, 966, 11707, 11708, 11705
30990, 956, 957, 11484, 11483, 967, 11709, 11710, 11707
30991, 957, 958, 11485, 11484, 968, 11711, 11712, 11709
30992, 958, 959, 11486, 11485, 969, 11713, 11714, 11711
30993, 959, 960, 11487, 11486, 970, 11715, 11716, 11713
30994, 960, 961, 11488, 11487, 971, 11717, 11718, 11715
30995, 961, 20, 907, 11488, 972, 929, 11719, 11717
30996, 835, 11479, 11489, 836, 11700, 11720, 11721, 858
30997, 11479, 11480, 11490, 11489, 11702, 11722, 11723, 11720
30998, 11480, 11481, 11491, 11490, 11704, 11724, 11725, 11722
30999, 11481, 11482, 11492, 11491, 11706, 11726, 11727, 11724
31000, 11482, 11483, 11493, 11492, 11708, 11728, 11729, 11726
31001, 11483, 11484, 11494, 11493, 11710, 11730, 11731, 11728
31002, 11484, 11485, 11495, 11494, 11712, 11732, 11733, 11730
31003, 11485, 11486, 11496, 11495, 11714, 11734, 11735, 11732
31004, 11486, 11487, 11497, 11496, 11716, 11736, 11737, 11734
31005, 11487, 11488, 11498, 11497, 11718, 11738, 11739, 11736
31006, 11488, 907, 908, 11498, 11719, 930, 11740, 11738
31007, 836, 11489, 11499, 837, 11721, 11741, 11742, 859
31008, 11489, 11490, 11500, 11499, 11723, 11743, 11744, 11741
31009, 11490, 11491, 11501, 11500, 11725, 11745, 11746, 11743
31010, 11491, 11492, 11502, 11501, 11727, 11747, 11748, 11745
31011, 11492, 11493, 11503, 11502, 11729, 11749, 11750, 11747
31012, 11493, 11494, 11504, 11503, 11731, 11751, 11752, 11749
31013, 11494, 11495, 11505, 11504, 11733, 11753, 11754, 11751
31014, 11495, 11496, 11506, 11505, 11735, 11755, 11756, 11753
31015, 11496, 11497, 11507, 11506, 11737, 11757, 11758, 11755
31016, 11497, 11498, 11508, 11507, 11739, 11759, 11760, 11757
31017, 11498, 908, 909, 11508, 11740, 931, 11761, 11759
31018, 837, 11499, 11509, 838, 11742, 11762, 11763, 860
31019, 11499, 11500, 11510, 11509, 11744, 11764, 11765, 11762
31020, 11500, 11501, 11511, 11510, 11746, 11766, 11767, 11764
31021, 11501, 11502, 11512, 11511, 11748, 11768, 11769, 11766
31022, 11502, 11503, 11513, 11512, 11750, 11770, 11771, 11768
31023, 11503, 11504, 11514, 11513, 11752, 11772, 11773, 11770
31024, 11504, 11505, 11515, 11514, 11754, 11774, 11775, 11772
31025, 11505, 11506, 11516, 11515, 11756, 11776, 11777, 11774
31026, 11506, 11507, 11517, 11516, 11758, 11778, 11779, 11776
31027, 11507, 11508, 11518, 11517, 11760, 11780, 11781, 11778
31028, 11508, 909, 910, 11518, 11761, 932, 11782, 11780
31029, 838, 11509, 11519, 839, 11763, 11783, 11784, 861
31030, 11509, 11510, 11520, 11519, 11765, 11785, 11786, 11783
31031, 11510, 11511, 11521, 11520, 11767, 11787, 11788, 11785
31032, 11511, 11512, 11522, 11521, 11769, 11789, 11790, 11787
31033, 11512, 11513, 11523, 11522, 11771, 11791, 11792, 11789
31034, 11513, 11514, 11524, 11523, 11773, 11793, 11794, 11791
31035, 11514, 11515, 11525, 11524, 11775, 11795, 11796, 11793
31036, 11515, 11516, 11526, 11525, 11777, 11797, 11798, 11795
31037, 11516, 11517, 11527, 11526, 11779, 11799, 11800, 11797
31038, 11517, 11518, 11528, 11527, 11781, 11801, 11802, 11799
31039, 11518, 910, 911, 11528, 11782, 933, 11803, 11801
31040, 839, 11519, 11529, 840, 11784, 11804, 11805, 862
31041, 11519, 11520, 11530, 11529, 11786, 11806, 11807, 11804
31042, 11520, 11521, 11531, 11530, 11788, 11808, 11809, 11806
31043, 11521, 11522, 11532, 11531, 11790, 11810, 11811, 11808
31044, 11522, 11523, 11533, 11532, 11792, 11812, 11813, 11810
31045, 11523, 11524, 11534, 11533, 11794, 11814, 11815, 11812
31046, 11524, 11525, 11535, 11534, 11796, 11816, 11817, 11814
31047, 11525, 11526, 11536, 11535, 11798, 11818, 11819, 11816
31048, 11526, 11527, 11537, 11536, 11800, 11820, 11821, 11818
31049, 11527, 11528, 11538, 11537, 11802, 11822, 11823, 11820
31050, 11528, 911, 912, 11538, 11803, 934, 11824, 11822
31051, 840, 11529, 11539, 841, 11805, 11825, 11826, 863
31052, 11529, 11530, 11540, 11539, 11807, 11827, 11828, 11825
31053, 11530, 11531, 11541, 11540, 11809, 11829, 11830, 11827
31054, 11531, 11532, 11542, 11541, 11811, 11831, 11832, 11829
31055, 11532, 11533, 11543, 11542, 11813, 11833, 11834, 11831
31056, 11533, 11534, 11544, 11543, 11815, 11835, 11836, 11833
31057, 11534, 11535, 11545, 11544, 11817, 11837, 11838, 11835
31058, 11535, 11536, 11546, 11545, 11819, 11839, 11840, 11837
31059, 11536, 11537, 11547, 11546, 11821, 11841, 11842, 11839
31060, 11537, 11538, 11548, 11547, 11823, 11843, 11844, 11841
31061, 11538, 912, 913, 11548, 11824, 935, 11845, 11843
31062, 841, 11539, 11549, 842, 11826, 11846, 11847, 864
31063, 11539, 11540, 11550, 11549, 11828, 11848, 11849, 11846
31064, 11540, 11541, 11551, 11550, 11830, 11850, 11851, 11848
31065, 11541, 11542, 11552, 11551, 11832, 11852, 11853, 11850
31066, 11542, 11543, 11553, 11552, 11834, 11854, 11855, 11852
31067, 11543, 11544, 11554, 11553, 11836, 11856, 11857, 11854
31068, 11544, 11545, 11555, 11554, 11838, 11858, 11859, 11856
31069, 11545, 11546, 11556, 11555, 11840, 11860, 11861, 11858
31070, 11546, 11547, 11557, 11556, 11842, 11862, 11863, 11860
31071, 11547, 11548, 11558, 11557, 11844, 11864, 11865, 11862
31072, 11548, 913, 914, 11558, 11845, 936, 11866, 11864
31073, 842, 11549, 11559, 843, 11847, 11867, 11868, 865
31074, 11549, 11550, 11560, 11559, 11849, 11869, 11870, 11867
31075, 11550, 11551, 11561, 11560, 11851, 11871, 11872, 11869
31076, 11551, 11552, 11562, 11561, 11853, 11873, 11874, 11871
31077, 11552, 11553, 11563, 11562, 11855, 11875, 11876, 11873
31078, 11553, 11554, 11564, 11563, 11857, 11877, 11878, 11875
31079, 11554, 11555, 11565, 11564, 11859, 11879, 11880, 11877
31080, 11555, 11556, 11566, 11565, 11861, 11881, 11882, 11879
31081, 11556, 11557, 11567, 11566, 11863, 11883, 11884, 11881
31082, 11557, 11558, 11568, 11567, 11865, 11885, 11886, 11883
31083, 11558, 914, 915, 11568, 11866, 937, 11887, 11885
31084, 843, 11559, 11569, 844, 11868, 11888, 11889, 866
31085, 11559, 11560, 11570, 11569, 11870, 11890, 11891, 11888
31086, 11560, 11561, 11571, 11570, 11872, 11892, 11893, 11890
31087, 11561, 11562, 11572, 11571, 11874, 11894, 11895, 11892
31088, 11562, 11563, 11573, 11572, 11876, 11896, 11897, 11894
31089, 11563, 11564, 11574, 11573, 11878, 11898, 11899, 11896
31090, 11564, 11565, 11575, 11574, 11880, 11900, 11901, 11898
31091, 11565, 11566, 11576, 11575, 11882, 11902, 11903, 11900
31092, 11566, 11567, 11577, 11576, 11884, 11904, 11905, 11902
31093, 11567, 11568, 11578, 11577, 11886, 11906, 11907, 11904
31094, 11568, 915, 916, 11578, 11887, 938, 11908, 11906
31095, 844, 11569, 11579, 845, 11889, 11909, 11910, 867
31096, 11569, 11570, 11580, 11579, 11891, 11911, 11912, 11909
31097, 11570, 11571, 11581, 11580, 11893, 11913, 11914, 11911
31098, 11571, 11572, 11582, 11581, 11895, 11915, 11916, 11913
31099, 11572, 11573, 11583, 11582, 11897, 11917, 11918, 11915
31100, 11573, 11574, 11584, 11583, 11899, 11919, 11920, 11917
31101, 11574, 11575, 11585, 11584, 11901, 11921, 11922, 11919
31102, 11575, 11576, 11586, 11585, 11903, 11923, 11924, 11921
31103, 11576, 11577, 11587, 11586, 11905, 11925, 11926, 11923
31104, 11577, 11578, 11588, 11587, 11907, 11927, 11928, 11925
31105, 11578, 916, 917, 11588, 11908, 939, 11929, 11927
31106, 845, 11579, 11589, 846, 11910, 11930, 11931, 868
31107, 11579, 11580, 11590, 11589, 11912, 11932, 11933, 11930
31108, 11580, 11581, 11591, 11590, 11914, 11934, 11935, 11932
31109, 11581, 11582, 11592, 11591, 11916, 11936, 11937, 11934
31110, 11582, 11583, 11593, 11592, 11918, 11938, 11939, 11936
31111, 11583, 11584, 11594, 11593, 11920, 11940, 11941, 11938
31112, 11584, 11585, 11595, 11594, 11922, 11942, 11943, 11940
31113, 11585, 11586, 11596, 11595, 11924, 11944, 11945, 11942
31114, 11586, 11587, 11597, 11596, 11926, 11946, 11947, 11944
31115, 11587, 11588, 11598, 11597, 11928, 11948, 11949, 11946
31116, 11588, 917, 918, 11598, 11929, 940, 11950, 11948
31117, 846, 11589, 11599, 847, 11931, 11951, 11952, 869
31118, 11589, 11590, 11600, 11599, 11933, 11953, 11954, 11951
31119, 11590, 11591, 11601, 11600, 11935, 11955, 11956, 11953
31120, 11591, 11592, 11602, 11601, 11937, 11957, 11958, 11955
31121, 11592, 11593, 11603, 11602, 11939, 11959, 11960, 11957
31122, 11593, 11594, 11604, 11603, 11941, 11961, 11962, 11959
31123, 11594, 11595, 11605, 11604, 11943, 11963, 11964, 11961
31124, 11595, 11596, 11606, 11605, 11945, 11965, 11966, 11963
31125, 11596, 11597, 11607, 11606, 11947, 11967, 11968, 11965
31126, 11597, 11598, 11608, 11607, 11949, 11969, 11970, 11967
31127, 11598, 918, 919, 11608, 11950, 941, 11971, 11969
31128, 847, 11599, 11609, 848, 11952, 11972, 11973, 870
31129, 11599, 11600, 11610, 11609, 11954, 11974, 11975, 11972
31130, 11600, 11601, 11611, 11610, 11956, 11976, 11977, 11974
31131, 11601, 11602, 11612, 11611, 11958, 11978, 11979, 11976
31132, 11602, 11603, 11613, 11612, 11960, 11980, 11981, 11978
31133, 11603, 11604, 11614, 11613, 11962, 11982, 11983, 11980
31134, 11604, 11605, 11615, 11614, 11964, 11984, 11985, 11982
31135, 11605, 11606, 11616, 11615, 11966, 11986, 11987, 11984
31136, 11606, 11607, 11617, 11616, 11968, 11988, 11989, 11986
31137, 11607, 11608, 11618, 11617, 11970, 11990, 11991, 11988
31138, 11608, 919, 920, 11618, 11971, 942, 11992, 11990
31139, 848, 11609, 11619, 849, 11973, 11993, 11994, 871
31140, 11609, 11610, 11620, 11619, 11975, 11995, 11996, 11993
31141, 11610, 11611, 11621, 11620, 11977, 11997, 11998, 11995
31142, 11611, 11612, 11622, 11621, 11979, 11999, 12000, 11997
31143, 11612, 11613, 11623, 11622, 11981, 12001, 12002, 11999
31144, 11613, 11614, 11624, 11623, 11983, 12003, 12004, 12001
31145, 11614, 11615, 11625, 11624, 11985, 12005, 12006, 12003
31146, 11615, 11616, 11626, 11625, 11987, 12007, 12008, 12005
31147, 11616, 11617, 11627, 11626, 11989, 12009, 12010, 12007
31148, 11617, 11618, 11628, 11627, 11991, 12011, 12012, 12009
31149, 11618, 920, 921, 11628, 11992, 943, 12013, 12011
31150, 849, 11619, 11629, 850, 11994, 12014, 12015, 872
31151, 11619, 11620, 11630, 11629, 11996, 12016, 12017, 12014
31152, 11620, 11621, 11631, 11630, 11998, 12018, 12019, 12016
31153, 11621, 11622, 11632, 11631, 12000, 12020, 12021, 12018
31154, 11622, 11623, 11633, 11632, 12002, 12022, 12023, 12020
31155, 11623, 11624, 11634, 11633, 12004, 12024, 12025, 12022
31156, 11624, 11625, 11635, 11634, 12006, 12026, 12027, 12024
31157, 11625, 11626, 11636, 11635, 12008, 12028, 12029, 12026
31158, 11626, 11627, 11637, 11636, 12010, 12030, 12031, 12028
31159, 11627, 11628, 11638, 11637, 12012, 12032, 12033, 12030
31160, 11628, 921, 922, 11638, 12013, 944, 12034, 12032
31161, 850, 11629, 11639, 851, 12015, 12035, 12036, 873
31162, 11629, 11630, 11640, 11639, 12017, 12037, 12038, 12035
31163, 11630, 11631, 11641, 11640, 12019, 12039, 12040, 12037
31164, 11631, 11632, 11642, 11641, 12021, 12041, 12042, 12039
31165, 11632, 11633, 11643, 11642, 12023, 12043, 12044, 12041
31166, 11633, 11634, 11644, 11643, 12025, 12045, 12046, 12043
31167, 11634, 11635, 11645, 11644, 12027, 12047, 12048, 12045
31168, 11635, 11636, 11646, 11645, 12029, 12049, 12050, 12047
31169, 11636, 11637, 11647, 11646, 12031, 12051, 12052, 12049
31170, 11637, 11638, 11648, 11647, 12033, 12053, 12054, 12051
31171, 11638, 922, 923, 11648, 12034, 945, 12055, 12053
31172, 851, 11639, 11649, 852, 12036, 12056, 12057, 874
31173, 11639, 11640, 11650, 11649, 12038, 12058, 12059, 12056
31174, 11640, 11641, 11651, 11650, 12040, 12060, 12061, 12058
31175, 11641, 11642, 11652, 11651, 12042, 12062, 12063, 12060
31176, 11642, 11643, 11653, 11652, 12044, 12064, 12065, 12062
31177, 11643, 11644, 11654, 11653, 12046, 12066, 12067, 12064
31178, 11644, 11645, 11655, 11654, 12048, 12068, 12069, 12066
31179, 11645, 11646, 11656, 11655, 12050, 12070, 12071, 12068
31180, 11646, 11647, 11657, 11656, 12052, 12072, 12073, 12070
31181, 11647, 11648, 11658, 11657, 12054, 12074, 12075, 12072
31182, 11648, 923, 924, 11658, 12055, 946, 12076, 12074
31183, 852, 11649, 11659, 853, 12057, 12077, 12078, 875
31184, 11649, 11650, 11660, 11659, 12059, 12079, 12080, 12077
31185, 11650, 11651, 11661, 11660, 12061, 12081, 12082, 12079
31186, 11651, 11652, 11662, 11661, 12063, 12083, 12084, 12081
31187, 11652, 11653, 11663, 11662, 12065, 12085, 12086, 12083
31188, 11653, 11654, 11664, 11663, 12067, 12087, 12088, 12085
31189, 11654, 11655, 11665, 11664, 12069, 12089, 12090, 12087
31190, 11655, 11656, 11666, 11665, 12071, 12091, 12092, 12089
31191, 11656, 11657, 11667, 11666, 12073, 12093, 12094, 12091
31192, 11657, 11658, 11668, 11667, 12075, 12095, 12096, 12093
31193, 11658, 924, 925, 11668, 12076, 947, 12097, 12095
31194, 853, 11659, 11669, 854, 12078, 12098, 12099, 876
31195, 11659, 11660, 11670, 11669, 12080, 12100, 12101, 12098
31196, 11660, 11661, 11671, 11670, 12082, 12102, 12103, 12100
31197, 11661, 11662, 11672, 11671, 12084, 12104, 12105, 12102
31198, 11662, 11663, 11673, 11672, 12086, 12106, 12107, 12104
31199, 11663, 11664, 11674, 11673, 12088, 12108, 12109, 12106
31200, 11664, 11665, 11675, 11674, 12090, 12110, 12111, 12108
31201, 11665, 11666, 11676, 11675, 12092, 12112, 12113, 12110
31202, 11666, 11667, 11677, 11676, 12094, 12114, 12115, 12112
31203, 11667, 11668, 11678, 11677, 12096, 12116, 12117, 12114
31204, 11668, 925, 926, 11678, 12097, 948, 12118, 12116
31205, 854, 11669, 11679, 855, 12099, 12119, 12120, 877
31206, 11669, 11670, 11680, 11679, 12101, 12121, 12122, 12119
31207, 11670, 11671, 11681, 11680, 12103, 12123, 12124, 12121
31208, 11671, 11672, 11682, 11681, 12105, 12125, 12126, 12123
31209, 11672, 11673, 11683, 11682, 12107, 12127, 12128, 12125
31210, 11673, 11674, 11684, 11683, 12109, 12129, 12130, 12127
31211, 11674, 11675, 11685, 11684, 12111, 12131, 12132, 12129
31212, 11675, 11676, 11686, 11685, 12113, 12133, 12134, 12131
31213, 11676, 11677, 11687, 11686, 12115, 12135, 12136, 12133
31214, 11677, 11678, 11688, 11687, 12117, 12137, 12138, 12135
31215, 11678, 926, 927, 11688, 12118, 949, 12139, 12137
31216, 855, 11679, 11689, 856, 12120, 12140, 12141, 878
31217, 11679, 11680, 11690, 11689, 12122, 12142, 12143, 12140
31218, 11680, 11681, 11691, 11690, 12124, 12144, 12145, 12142
31219, 11681, 11682, 11692, 11691, 12126, 12146, 12147, 12144
31220, 11682, 11683, 11693, 11692, 12128, 12148, 12149, 12146
31221, 11683, 11684, 11694, 11693, 12130, 12150, 12151, 12148
31222, 11684, 11685, 11695, 11694, 12132, 12152, 12153, 12150
31223, 11685, 11686, 11696, 11695, 12134, 12154, 12155, 12152
31224, 11686, 11687, 11697, 11696, 12136, 12156, 12157, 12154
31225, 11687, 11688, 11698, 11697, 12138, 12158, 12159, 12156
31226, 11688, 927, 928, 11698, 12139, 950, 12160, 12158
31227, 856, 11689, 883, 17, 12141, 12161, 893, 879
31228, 11689, 11690, 884, 883, 12143, 12162, 894, 12161
31229, 11690, 11691, 885, 884, 12145, 12163, 895, 12162
31230, 11691, 11692, 886, 885, 12147, 12164, 896, 12163
31231, 11692, 11693, 887, 886, 12149, 12165, 897, 12164
31232, 11693, 11694, 888, 887, 12151, 12166, 898, 12165
31233, 11694, 11695, 889, 888, 12153, 12167, 899, 12166
31234, 11695, 11696, 890, 889, 12155, 12168, 900, 12167
31235, 11696, 11697, 891, 890, 12157, 12169, 901, 12168
31236, 11697, 11698, 892, 891, 12159, 12170, 902, 12169
31237, 11698, 928, 19, 892, 12160, 951, 903, 12170
*ELEMENT, type=CPS8, ELSET=Surface22
31238, 17, 856, 12171, 973, 879, 12215, 12216, 975
31239, 856, 855, 12172, 12171, 878, 12217, 12218, 12215
31240, 855, 854, 12173, 12172, 877, 12219, 12220, 12217
31241, 854, 853, 12174, 12173, 876, 12221, 12222, 12219
31242, 853, 852, 12175, 12174, 875, 12223, 12224, 12221
31243, 852, 851, 12176, 12175, 874, 12225, 12226, 12223
31244, 851, 850, 12177, 12176, 873, 12227, 12228, 12225
31245, 850, 849, 12178, 12177, 872, 12229, 12230, 12227
31246, 849, 848, 12179, 12178, 871, 12231, 12232, 12229
31247, 848, 847, 12180, 12179, 870, 12233, 12234, 12231
31248, 847, 846, 12181, 12180, 869, 12235, 12236, 12233
31249, 846, 845, 12182, 12181, 868, 12237, 12238, 12235
31250, 845, 844, 12183, 12182, 867, 12239, 12240, 12237
31251, 844, 843, 12184, 12183, 866, 12241, 12242, 12239
31252, 843, 842, 12185, 12184, 865, 12243, 12244, 12241
31253, 842, 841, 12186, 12185, 864, 12245, 12246, 12243
31254, 841, 840, 12187, 12186, 863, 12247, 12248, 12245
31255, 840, 839, 12188, 12187, 862, 12249, 12250, 12247
31256, 839, 838, 12189, 12188, 861, 12251, 12252, 12249
31257, 838, 837, 12190, 12189, 860, 12253, 12254, 12251
31258, 837, 836, 12191, 12190, 859, 12255, 12256, 12253
31259, 836, 835, 12192, 12191, 858, 12257, 12258, 12255
31260, 835, 18, 978, 12192, 857, 980, 12259, 12257
31261, 973, 12171, 12193, 974, 12216, 12260, 12261, 976
31262, 12171, 12172, 12194, 12193, 12218, 12262, 12263, 12260
31263, 12172, 12173, 12195, 12194, 12220, 12264, 12265, 12262
31264, 12173, 12174, 12196, 12195, 12222, 12266, 12267, 12264
31265, 12174, 12175, 12197, 12196, 12224, 12268, 12269, 12266
31266, 12175, 12176, 12198, 12197, 12226, 12270, 12271, 12268
31267, 12176, 12177, 12199, 12198, 12228, 12272, 12273, 12270
31268, 12177, 12178, 12200, 12199, 12230, 12274, 12275, 12272
31269, 12178, 12179, 12201, 12200, 12232, 12276, 12277, 12274
31270, 12179, 12180, 12202, 12201, 12234, 12278, 12279, 12276
31271, 12180, 12181, 12203, 12202, 12236, 12280, 12281, 12278
31272, 12181, 12182, 12204, 12203, 12238, 12282, 12283, 12280
31273, 12182, 12183, 12205, 12204, 12240, 12284, 12285, 12282
31274, 12183, 12184, 12206, 12205, 12242, 12286, 12287, 12284
31275, 12184, 12185, 12207, 12206, 12244, 12288, 12289, 12286
31276, 12185, 12186, 12208, 12207, 12246, 12290, 12291, 12288
31277, 12186, 12187, 12209, 12208, 12248, 12292, 12293, 12290
31278, 12187, 12188, 12210, 12209, 12250, 12294, 12295, 12292
31279, 12188, 12189, 12211, 12210, 12252, 12296, 12297, 12294
31280, 12189, 12190, 12212, 12211, 12254, 12298, 12299, 12296
31281, 12190, 12191, 12213, 12212, 12256, 12300, 12301, 12298
31282, 12191, 12192, 12214, 12213, 12258, 12302, 12303, 12300
31283, 12192, 978, 979, 12214, 12259, 981, 12304, 12302
31284, 974, 12193, 1004, 21, 12261, 12305, 1027, 977
31285, 12193, 12194, 1003, 1004, 12263, 12306, 1026, 12305
31286, 12194, 12195, 1002, 1003, 12265, 12307, 1025, 12306
31287, 12195, 12196, 1001, 1002, 12267, 12308, 1024, 12307
31288, 12196, 12197, 1000, 1001, 12269, 12309, 1023, 12308
31289, 12197, 12198, 999, 1000, 12271, 12310, 1022, 12309
31290, 12198, 12199, 998, 999, 12273, 12311, 1021, 12310
31291, 12199, 12200, 997, 998, 12275, 12312, 1020, 12311
31292, 12200, 12201, 996, 997, 12277, 12313, 1019, 12312
31293, 12201, 12202, 995, 996, 12279, 12314, 1018, 12313
31294, 12202, 12203, 994, 995, 12281, 12315, 1017, 12314
31295, 12203, 12204, 993, 994, 12283, 12316, 1016, 12315
31296, 12204, 12205, 992, 993, 12285, 12317, 1015, 12316
31297, 12205, 12206, 991, 992, 12287, 12318, 1014, 12317
31298, 12206, 12207, 990, 991, 12289, 12319, 1013, 12318
31299, 12207, 12208, 989, 990, 12291, 12320, 1012, 12319
31300, 12208, 12209, 988, 989, 12293, 12321, 1011, 12320
31301, 12209, 12210, 987, 988, 12295, 12322, 1010, 12321
31302, 12210, 12211, 986, 987, 12297, 12323, 1009, 12322
31303, 12211, 12212, 985, 986, 12299, 12324, 1008, 12323
31304, 12212, 12213, 984, 985, 12301, 12325, 1007, 12324
31305, 12213, 12214, 983, 984, 12303, 12326, 1006, 12325
31306, 12214, 979, 22, 983, 12304, 982, 1005, 12326
*ELEMENT, type=CPS8, ELSET=Surface23
31307, 19, 892, 12327, 1028, 903, 12347, 12348, 1030
31308, 892, 891, 12328, 12327, 902, 12349, 12350, 12347
31309, 891, 890, 12329, 12328, 901, 12351, 12352, 12349
31310, 890, 889, 12330, 12329, 900, 12353, 12354, 12351
31311, 889, 888, 12331, 12330, 899, 12355, 12356, 12353
31312, 888, 887, 12332, 12331, 898, 12357, 12358, 12355
31313, 887, 886, 12333, 12332, 897, 12359, 12360, 12357
31314, 886, 885, 12334, 12333, 896, 12361, 12362, 12359
31315, 885, 884, 12335, 12334, 895, 12363, 12364, 12361
31316, 884, 883, 12336, 12335, 894, 12365, 12366, 12363
31317, 883, 17, 973, 12336, 893, 975, 12367, 12365
31318, 1028, 12327, 12337, 1029, 12348, 12368, 12369, 1031
31319, 12327, 12328, 12338, 12337, 12350, 12370, 12371, 12368
31320, 12328, 12329, 12339, 12338, 12352, 12372, 12373, 12370
31321, 12329, 12330, 12340, 12339, 12354, 12374, 12375, 12372
31322, 12330, 12331, 12341, 12340, 12356, 12376, 12377, 12374
31323, 12331, 12332, 12342, 12341, 12358, 12378, 12379, 12376
31324, 12332, 12333, 12343, 12342, 12360, 12380, 12381, 12378
31325, 12333, 12334, 12344, 12343, 12362, 12382, 12383, 12380
31326, 12334, 12335, 12345, 12344, 12364, 12384, 12385, 12382
31327, 12335, 12336, 12346, 12345, 12366, 12386, 12387, 12384
31328, 12336, 973, 974, 12346, 12367, 976, 12388, 12386
31329, 1029, 12337, 1042, 23, 12369, 12389, 1053, 1032
31330, 12337, 12338, 1041, 1042, 12371, 12390, 1052, 12389
31331, 12338, 12339, 1040, 1041, 12373, 12391, 1051, 12390
31332, 12339, 12340, 1039, 1040, 12375, 12392, 1050, 12391
31333, 12340, 12341, 1038, 1039, 12377, 12393, 1049, 12392
31334, 12341, 12342, 1037, 1038, 12379, 12394, 1048, 12393
31335, 12342, 12343, 1036, 1037, 12381, 12395, 1047, 12394
31336, 12343, 12344, 1035, 1036, 12383, 12396, 1046, 12395
31337, 12344, 12345, 1034, 1035, 12385, 12397, 1045, 12396
31338, 12345, 12346, 1033, 1034, 12387, 12398, 1044, 12397
31339, 12346, 974, 21, 1033, 12388, 977, 1043, 12398
*ELEMENT, type=CPS8, ELSET=Surface24
944, 19, 1028, 12399, 928, 1030, 12443, 12444, 951
945, 928, 12399, 12400, 927, 12444, 12445, 12446, 950
946, 927, 12400, 12401, 926, 12446, 12447, 12448, 949
947, 926, 12401, 12402, 925, 12448, 12449, 12450, 948
948, 925, 12402, 12403, 924, 12450, 12451, 12452, 947
949, 924, 12403, 12404, 923, 12452, 12453, 12454, 946
950, 923, 12404, 12405, 922, 12454, 12455, 12456, 945
951, 922, 12405, 12406, 921, 12456, 12457, 12458, 944
952, 921, 12406, 12407, 920, 12458, 12459, 12460, 943
953, 920, 12407, 12408, 919, 12460, 12461, 12462, 942
954, 919, 12408, 12409, 918, 12462, 12463, 12464, 941
955, 918, 12409, 12410, 917, 12464, 12465, 12466, 940
956, 917, 12410, 12411, 916, 12466, 12467, 12468, 939
957, 916, 12411, 12412, 915, 12468, 12469, 12470, 938
958, 915, 12412, 12413, 914, 12470, 12471, 12472, 937
959, 914, 12413, 12414, 913, 12472, 12473, 12474, 936
960, 913, 12414, 12415, 912, 12474, 12475, 12476, 935
961, 912, 12415, 12416, 911, 12476, 12477, 12478, 934
962, 911, 12416, 12417, 910, 12478, 12479, 12480, 933
963, 910, 12417, 12418, 909, 12480, 12481, 12482, 932
964, 909, 12418, 12419, 908, 12482, 12483, 12484, 931
965, 908, 12419, 12420, 907, 12484, 12485, 12486, 930
966, 907, 12420, 1054, 20, 12486, 12487, 1056, 929
967, 1028, 1029, 12421, 12399, 1031, 12488, 12489, 12443
968, 12399, 12421, 12422, 12400, 12489, 12490, 12491, 12445
969, 12400, 12422, 12423, 12401, 12491, 12492, 12493, 12447
970, 12401, 12423, 12424, 12402, 12493, 12494, 12495, 12449
971, 12402, 12424, 12425, 12403, 12495, 12496, 12497, 12451
972, 12403, 12425, 12426, 12404, 12497, 12498, 12499, 12453
973, 12404, 12426, 12427, 12405, 12499, 12500, 12501, 12455
974, 12405, 12427, 12428, 12406, 12501, 12502, 12503, 12457
975, 12406, 12428, 12429, 12407, 12503, 12504, 12505, 12459
976, 12407, 12429, 12430, 12408, 12505, 12506, 12507, 12461
977, 12408, 12430, 12431, 12409, 12507, 12508, 12509, 12463
978, 12409, 12431, 12432, 12410, 12509, 12510, 12511, 12465
979, 12410, 12432, 12433, 12411, 12511, 12512, 12513, 12467
980, 12411, 12433, 12434, 12412, 12513, 12514, 12515, 12469
981, 12412, 12434, 12435, 12413, 12515, 12516, 12517, 12471
982, 12413, 12435, 12436, 12414, 12517, 12518, 12519, 12473
983, 12414, 12436, 12437, 12415, 12519, 12520, 12521, 12475
984, 12415, 12437, 12438, 12416, 12521, 12522, 12523, 12477
985, 12416, 12438, 12439, 12417, 12523, 12524, 12525, 12479
986, 12417, 12439, 12440, 12418, 12525, 12526, 12527, 12481
987, 12418, 12440, 12441, 12419, 12527, 12528, 12529, 12483
988, 12419, 12441, 12442, 12420, 12529, 12530, 12531, 12485
989, 12420, 12442, 1055, 1054, 12531, 12532, 1057, 12487
990, 1029, 23, 1080, 12421, 1032, 1103, 12533, 12488
991, 12421, 1080, 1079, 12422, 12533, 1102, 12534, 12490
992, 12422, 1079, 1078, 12423, 12534, 1101, 12535, 12492
993, 12423, 1078, 1077, 12424, 12535, 1100, 12536, 12494
994, 12424, 1077, 1076, 12425, 12536, 1099, 12537, 12496
995, 12425, 1076, 1075, 12426, 12537, 1098, 12538, 12498
996, 12426, 1075, 1074, 12427, 12538, 1097, 12539, 12500
997, 12427, 1074, 1073, 12428, 12539, 1096, 12540, 12502
998, 12428, 1073, 1072, 12429, 12540, 1095, 12541, 12504
999, 12429, 1072, 1071, 12430, 12541, 1094, 12542, 12506
1000, 12430, 1071, 1070, 12431, 12542, 1093, 12543, 12508
1001, 12431, 1070, 1069, 12432, 12543, 1092, 12544, 12510
1002, 12432, 1069, 1068, 12433, 12544, 1091, 12545, 12512
1003, 12433, 1068, 1067, 12434, 12545, 1090, 12546, 12514
1004, 12434, 1067, 1066, 12435, 12546, 1089, 12547, 12516
1005, 12435, 1066, 1065, 12436, 12547, 1088, 12548, 12518
1006, 12436, 1065, 1064, 12437, 12548, 1087, 12549, 12520
1007, 12437, 1064, 1063, 12438, 12549, 1086, 12550, 12522
1008, 12438, 1063, 1062, 12439, 12550, 1085, 12551, 12524
1009, 12439, 1062, 1061, 12440, 12551, 1084, 12552, 12526
1010, 12440, 1061, 1060, 12441, 12552, 1083, 12553, 12528
1011, 12441, 1060, 1059, 12442, 12553, 1082, 12554, 12530
1012, 12442, 1059, 24, 1055, 12554, 1081, 1058, 12532
*ELEMENT, type=CPS8, ELSET=Surface25
31340, 20, 1054, 12555, 961, 1056, 12575, 12576, 972
31341, 961, 12555, 12556, 960, 12576, 12577, 12578, 971
31342, 960, 12556, 12557, 959, 12578, 12579, 12580, 970
31343, 959, 12557, 12558, 958, 12580, 12581, 12582, 969
31344, 958, 12558, 12559, 957, 12582, 12583, 12584, 968
31345, 957, 12559, 12560, 956, 12584, 12585, 12586, 967
31346, 956, 12560, 12561, 955, 12586, 12587, 12588, 966
31347, 955, 12561, 12562, 954, 12588, 12589, 12590, 965
31348, 954, 12562, 12563, 953, 12590, 12591, 12592, 964
31349, 953, 12563, 12564, 952, 12592, 12593, 12594, 963
31350, 952, 12564, 978, 18, 12594, 12595, 980, 962
31351, 1054, 1055, 12565, 12555, 1057, 12596, 12597, 12575
31352, 12555, 12565, 12566, 12556, 12597, 12598, 12599, 12577
31353, 12556, 12566, 12567, 12557, 12599, 12600, 12601, 12579
31354, 12557, 12567, 12568, 12558, 12601, 12602, 12603, 12581
31355, 12558, 12568, 12569, 12559, 12603, 12604, 12605, 12583
31356, 12559, 12569, 12570, 12560, 12605, 12606, 12607, 12585
31357, 12560, 12570, 12571, 12561, 12607, 12608, 12609, 12587
31358, 12561, 12571, 12572, 12562, 12609, 12610, 12611, 12589
31359, 12562, 12572, 12573, 12563, 12611, 12612, 12613, 12591
31360, 12563, 12573, 12574, 12564, 12613, 12614, 12615, 12593
31361, 12564, 12574, 979, 978, 12615, 12616, 981, 12595
31362, 1055, 24, 1113, 12565, 1058, 1124, 12617, 12596
31363, 12565, 1113, 1112, 12566, 12617, 1123, 12618, 12598
31364, 12566, 1112, 1111, 12567, 12618, 1122, 12619, 12600
31365, 12567, 1111, 1110, 12568, 12619, 1121, 12620, 12602
31366, 12568, 1110, 1109, 12569, 12620, 1120, 12621, 12604
31367, 12569, 1109, 1108, 12570, 12621, 1119, 12622, 12606
31368, 12570, 1108, 1107, 12571, 12622, 1118, 12623, 12608
31369, 12571, 1107, 1106, 12572, 12623, 1117, 12624, 12610
31370, 12572, 1106, 1105, 12573, 12624, 1116, 12625, 12612
31371, 12573, 1105, 1104, 12574, 12625, 1115, 12626, 12614
31372, 12574, 1104, 22, 979, 12626, 1114, 982, 12616
*ELEMENT, type=CPS8, ELSET=Surface26
1013, 22, 1104, 12627, 983, 1114, 12847, 12848, 1005
1014, 1104, 1105, 12628, 12627, 1115, 12849, 12850, 12847
1015, 1105, 1106, 12629, 12628, 1116, 12851, 12852, 12849
1016, 1106, 1107, 12630, 12629, 1117, 12853, 12854, 12851
1017, 1107, 1108, 12631, 12630, 1118, 12855, 12856, 12853
1018, 1108, 1109, 12632, 12631, 1119, 12857, 12858, 12855
1019, 1109, 1110, 12633, 12632, 1120, 12859, 12860, 12857
1020, 1110, 1111, 12634, 12633, 1121, 12861, 12862, 12859
1021, 1111, 1112, 12635, 12634, 1122, 12863, 12864, 12861
1022, 1112, 1113, 12636, 12635, 1123, 12865, 12866, 12863
1023, 1113, 24, 1059, 12636, 1124, 1081, 12867, 12865
1024, 983, 12627, 12637, 984, 12848, 12868, 12869, 1006
1025, 12627, 12628, 12638, 12637, 12850, 12870, 12871, 12868
1026, 12628, 12629, 12639, 12638, 12852, 12872, 12873, 12870
1027, 12629, 12630, 12640, 12639, 12854, 12874, 12875, 12872
1028, 12630, 12631, 12641, 12640, 12856, 12876, 12877, 12874
1029, 12631, 12632, 12642, 12641, 12858, 12878, 12879, 12876
1030, 12632, 12633, 12643, 12642, 12860, 12880, 12881, 12878
1031, 12633, 12634, 12644, 12643, 12862, 12882, 12883, 12880
1032, 12634, 12635, 12645, 12644, 12864, 12884, 12885, 12882
1033, 12635, 12636, 12646, 12645, 12866, 12886, 12887, 12884
1034, 12636, 1059, 1060, 12646, 12867, 1082, 12888, 12886
1035, 984, 12637, 12647, 985, 12869, 12889, 12890, 1007
1036, 12637, 12638, 12648, 12647, 12871, 12891, 12892, 12889
1037, 12638, 12639, 12649, 12648, 12873, 12893, 12894, 12891
1038, 12639, 12640, 12650, 12649, 12875, 12895, 12896, 12893
1039, 12640, 12641, 12651, 12650, 12877, 12897, 12898, 12895
1040, 12641, 12642, 12652, 12651, 12879, 12899, 12900, 12897
1041, 12642, 12643, 12653, 12652, 12881, 12901, 12902, 12899
1042, 12643, 12644, 12654, 12653, 12883, 12903, 12904, 12901
1043, 12644, 12645, 12655, 12654, 12885, 12905, 12906, 12903
1044, 12645, 12646, 12656, 12655, 12887, 12907, 12908, 12905
1045, 12646, 1060, 1061, 12656, 12888, 1083, 12909, 12907
1046, 985, 12647, 12657, 986, 12890, 12910, 12911, 1008
1047, 12647, 12648, 12658, 12657, 12892, 12912, 12913, 12910
1048, 12648, 12649, 12659, 12658, 12894, 12914, 12915, 12912
1049, 12649, 12650, 12660, 12659, 12896, 12916, 12917, 12914
1050, 12650, 12651, 12661, 12660, 12898, 12918, 12919, 12916
1051, 12651, 12652, 12662, 12661, 12900, 12920, 12921, 12918
1052, 12652, 12653, 12663, 12662, 12902, 12922, 12923, 12920
1053, 12653, 12654, 12664, 12663, 12904, 12924, 12925, 12922
1054, 12654, 12655, 12665, 12664, 12906, 12926, 12927, 12924
1055, 12655, 12656, 12666, 12665, 12908, 12928, 12929, 12926
1056, 12656, 1061, 1062, 12666, 12909, 1084, 12930, 12928
1057, 986, 12657, 12667, 987, 12911, 12931, 12932, 1009
1058, 12657, 12658, 12668, 12667, 12913, 12933, 12934, 12931
1059, 12658, 12659, 12669, 12668, 12915, 12935, 12936, 12933
1060, 12659, 12660, 12670, 12669, 12917, 12937, 12938, 12935
1061, 12660, 12661, 12671, 12670, 12919, 12939, 12940, 12937
1062, 12661, 12662, 12672, 12671, 12921, 12941, 12942, 12939
1063, 12662, 12663, 12673, 12672, 12923, 12943, 12944, 12941
1064, 12663, 12664, 12674, 12673, 12925, 12945, 12946, 12943
1065, 12664, 12665, 12675, 12674, 12927, 12947, 12948, 12945
1066, 12665, 12666, 12676, 12675, 12929, 12949, 12950, 12947
1067, 12666, 1062, 1063, 12676, 12930, 1085, 12951, 12949
1068, 987, 12667, 12677, 988, 12932, 12952, 12953, 1010
1069, 12667, 12668, 12678, 12677, 12934, 12954, 12955, 12952
1070, 12668, 12669, 12679, 12678, 12936, 12956, 12957, 12954
1071, 12669, 12670, 12680, 12679, 12938, 12958, 12959, 12956
1072, 12670, 12671, 12681, 12680, 12940, 12960, 12961, 12958
1073, 12671, 12672, 12682, 12681, 12942, 12962, 12963, 12960
1074, 12672, 12673, 12683, 12682, 12944, 12964, 12965, 12962
1075, 12673, 12674, 12684, 12683, 12946, 12966, 12967, 12964
1076, 12674, 12675, 12685, 12684, 12948, 12968, 12969, 12966
1077, 12675, 12676, 12686, 12685, 12950, 12970, 12971, 12968
1078, 12676, 1063, 1064, 12686, 12951, 1086, 12972, 12970
1079, 988, 12677, 12687, 989, 12953, 12973, 12974, 1011
1080, 12677, 12678, 12688, 12687, 12955, 12975, 12976, 12973
1081, 12678, 12679, 12689, 12688, 12957, 12977, 12978, 12975
1082, 12679, 12680, 12690, 12689, 12959, 12979, 12980, 12977
1083, 12680, 12681, 12691, 12690, 12961, 12981, 12982, 12979
1084, 12681, 12682, 12692, 12691, 12963, 12983, 12984, 12981
1085, 12682, 12683, 12693, 12692, 12965, 12985, 12986, 12983
1086, 12683, 12684, 12694, 12693, 12967, 12987, 12988, 12985
1087, 12684, 12685, 12695, 12694, 12969, 12989, 12990, 12987
1088, 12685, 12686, 12696, 12695, 12971, 12991, 12992, 12989
1089, 12686, 1064, 1065, 12696, 12972, 1087, 12993, 12991
1090, 989, 12687, 12697, 990, 12974, 12994, 12995, 1012
1091, 12687, 12688, 12698, 12697, 12976, 12996, 12997, 12994
1092, 12688, 12689, 12699, 12698, 12978, 12998, 12999, 12996
1093, 12689, 12690, 12700, 12699, 12980, 13000, 13001, 12998
1094, 12690, 12691, 12701, 12700, 12982, 13002, 13003, 13000
1095, 12691, 12692, 12702, 12701, 12984, 13004, 13005, 13002
1096, 12692, 12693, 12703, 12702, 12986, 13006, 13007, 13004
1097, 12693, 12694, 12704, 12703, 12988, 13008, 13009, 13006
1098, 12694, 12695, 12705, 12704, 12990, 13010, 13011, 13008
1099, 12695, 12696, 12706, 12705, 12992, 13012, 13013, 13010
1100, 12696, 1065, 1066, 12706, 12993, 1088, 13014, 13012
1101, 990, 12697, 12707, 991, 12995, 13015, 13016, 1013
1102, 12697, 12698, 12708, 12707, 12997, 13017, 13018, 13015
1103, 12698, 12699, 12709, 12708, 12999, 13019, 13020, 13017
1104, 12699, 12700, 12710, 12709, 13001, 13021, 13022, 13019
1105, 12700, 12701, 12711, 12710, 13003, 13023, 13024, 13021
1106, 12701, 12702, 12712, 12711, 13005, 13025, 13026, 13023
1107, 12702, 12703, 12713, 12712, 13007, 13027, 13028, 13025
1108, 12703, 12704, 12714, 12713, 13009, 13029, 13030, 13027
1109, 12704, 12705, 12715, 12714, 13011, 13031, 13032, 13029
1110, 12705, 12706, 12716, 12715, 13013, 13033, 13034, 13031
1111, 12706, 1066, 1067, 12716, 13014, 1089, 13035, 13033
1112, 991, 12707, 12717, 992, 13016, 13036, 13037, 1014
1113, 12707, 12708, 12718, 12717, 13018, 13038, 13039, 13036
1114, 12708, 12709, 12719, 12718, 13020, 13040, 13041, 13038
1115, 12709, 12710, 12720, 12719, 13022, 13042, 13043, 13040
1116, 12710, 12711, 12721, 12720, 13024, 13044, 13045, 13042
1117, 12711, 12712, 12722, 12721, 13026, 13046, 13047, 13044
1118, 12712, 12713, 12723, 12722, 13028, 13048, 13049, 13046
1119, 12713, 12714, 12724, 12723, 13030, 13050, 13051, 13048
1120, 12714, 12715, 12725, 12724, 13032, 13052, 13053, 13050
1121, 12715, 12716, 12726, 12725, 13034, 13054, 13055, 13052
1122, 12716, 1067, 1068, 12726, 13035, 1090, 13056, 13054
1123, 992, 12717, 12727, 993, 13037, 13057, 13058, 1015
1124, 12717, 12718, 12728, 12727, 13039, 13059, 13060, 13057
1125, 12718, 12719, 12729, 12728, 13041, 13061, 13062, 13059
1126, 12719, 12720, 12730, 12729, 13043, 13063, 13064, 13061
1127, 12720, 12721, 12731, 12730, 13045, 13065, 13066, 13063
1128, 12721, 12722, 12732, 12731, 13047, 13067, 13068, 13065
1129, 12722, 12723, 12733, 12732, 13049, 13069, 13070, 13067
1130, 12723, 12724, 12734, 12733, 13051, 13071, 13072, 13069
1131, 12724, 12725, 12735, 12734, 13053, 13073, 13074, 13071
1132, 12725, 12726, 12736, 12735, 13055, 13075, 13076, 13073
1133, 12726, 1068, 1069, 12736, 13056, 1091, 13077, 13075
1134, 993, 12727, 12737, 994, 13058, 13078, 13079, 1016
1135, 12727, 12728, 12738, 12737, 13060, 13080, 13081, 13078
1136, 12728, 12729, 12739, 12738, 13062, 13082, 13083, 13080
1137, 12729, 12730, 12740, 12739, 13064, 13084, 13085, 13082
1138, 12730, 12731, 12741, 12740, 13066, 13086, 13087, 13084
1139, 12731, 12732, 12742, 12741, 13068, 13088, 13089, 13086
1140, 12732, 12733, 12743, 12742, 13070, 13090, 13091, 13088
1141, 12733, 12734, 12744, 12743, 13072, 13092, 13093, 13090
1142, 12734, 12735, 12745, 12744, 13074, 13094, 13095, 13092
1143, 12735, 12736, 12746, 12745, 13076, 13096, 13097, 13094
1144, 12736, 1069, 1070, 12746, 13077, 1092, 13098, 13096
1145, 994, 12737, 12747, 995, 13079, 13099, 13100, 1017
1146, 12737, 12738, 12748, 12747, 13081, 13101, 13102, 13099
1147, 12738, 12739, 12749, 12748, 13083, 13103, 13104, 13101
1148, 12739, 12740, 12750, 12749, 13085, 13105, 13106, 13103
1149, 12740, 12741, 12751, 12750, 13087, 13107, 13108, 13105
1150, 12741, 12742, 12752, 12751, 13089, 13109, 13110, 13107
1151, 12742, 12743, 12753, 12752, 13091, 13111, 13112, 13109
1152, 12743, 12744, 12754, 12753, 13093, 13113, 13114, 13111
1153, 12744, 12745, 12755, 12754, 13095, 13115, 13116, 13113
1154, 12745, 12746, 12756, 12755, 13097, 13117, 13118, 13115
1155, 12746, 1070, 1071, 12756, 13098, 1093, 13119, 13117
1156, 995, 12747, 12757, 996, 13100, 13120, 13121, 1018
1157, 12747, 12748, 12758, 12757, 13102, 13122, 13123, 13120
1158, 12748, 12749, 12759, 12758, 13104, 13124, 13125, 13122
1159, 12749, 12750, 12760, 12759, 13106, 13126, 13127, 13124
1160, 12750, 12751, 12761, 12760, 13108, 13128, 13129, 13126
1161, 12751, 12752, 12762, 12761, 13110, 13130, 13131, 13128
1162, 12752, 12753, 12763, 12762, 13112, 13132, 13133, 13130
1163, 12753, 12754, 12764, 12763, 13114, 13134, 13135, 13132
1164, 12754, 12755, 12765, 12764, 13116, 13136, 13137, 13134
1165, 12755, 12756, 12766, 12765, 13118, 13138, 13139, 13136
1166, 12756, 1071, 1072, 12766, 13119, 1094, 13140, 13138
1167, 996, 12757, 12767, 997, 13121, 13141, 13142, 1019
1168, 12757, 12758, 12768, 12767, 13123, 13143, 13144, 13141
1169, 12758, 12759, 12769, 12768, 13125, 13145, 13146, 13143
1170, 12759, 12760, 12770, 12769, 13127, 13147, 13148, 13145
1171, 12760, 12761, 12771, 12770, 13129, 13149, 13150, 13147
1172, 12761, 12762, 12772, 12771, 13131, 13151, 13152, 13149
1173, 12762, 12763, 12773, 12772, 13133, 13153, 13154, 13151
1174, 12763, 12764, 12774, 12773, 13135, 13155, 13156, 13153
1175, 12764, 12765, 12775, 12774, 13137, 13157, 13158, 13155
1176, 12765, 12766, 12776, 12775, 13139, 13159, 13160, 13157
1177, 12766, 1072, 1073, 12776, 13140, 1095, 13161, 13159
1178, 997, 12767, 12777, 998, 13142, 13162, 13163, 1020
1179, 12767, 12768, 12778, 12777, 13144, 13164, 13165, 13162
1180, 12768, 12769, 12779, 12778, 13146, 13166, 13167, 13164
1181, 12769, 12770, 12780, 12779, 13148, 13168, 13169, 13166
1182, 12770, 12771, 12781, 12780, 13150, 13170, 13171, 13168
1183, 12771, 12772, 12782, 12781, 13152, 13172, 13173, 13170
1184, 12772, 12773, 12783, 12782, 13154, 13174, 13175, 13172
1185, 12773, 12774, 12784, 12783, 13156, 13176, 13177, 13174
1186, 12774, 12775, 12785, 12784, 13158, 13178, 13179, 13176
1187, 12775, 12776, 12786, 12785, 13160, 13180, 13181, 13178
1188, 12776, 1073, 1074, 12786, 13161, 1096, 13182, 13180
1189, 998, 12777, 12787, 999, 13163, 13183, 13184, 1021
1190, 12777, 12778, 12788, 12787, 13165, 13185, 13186, 13183
1191, 12778, 12779, 12789, 12788, 13167, 13187, 13188, 13185
1192, 12779, 12780, 12790, 12789, 13169, 13189, 13190, 13187
1193, 12780, 12781, 12791, 12790, 13171, 13191, 13192, 13189
1194, 12781, 12782, 12792, 12791, 13173, 13193, 13194, 13191
1195, 12782, 12783, 12793, 12792, 13175, 13195, 13196, 13193
1196, 12783, 12784, 12794, 12793, 13177, 13197, 13198, 13195
1197, 12784, 12785, 12795, 12794, 13179, 13199, 13200, 13197
1198, 12785, 12786, 12796, 12795, 13181, 13201, 13202, 13199
1199, 12786, 1074, 1075, 12796, 13182, 1097, 13203, 13201
1200, 999, 12787, 12797, 1000, 13184, 13204, 13205, 1022
1201, 12787, 12788, 12798, 12797, 13186, 13206, 13207, 13204
1202, 12788, 12789, 12799, 12798, 13188, 13208, 13209, 13206
1203, 12789, 12790, 12800, 12799, 13190, 13210, 13211, 13208
1204, 12790, 12791, 12801, 12800, 13192, 13212, 13213, 13210
1205, 12791, 12792, 12802, 12801, 13194, 13214, 13215, 13212
1206, 12792, 12793, 12803, 12802, 13196, 13216, 13217, 13214
1207, 12793, 12794, 12804, 12803, 13198, 13218, 13219, 13216
1208, 12794, 12795, 12805, 12804, 13200, 13220, 13221, 13218
1209, 12795, 12796, 12806, 12805, 13202, 13222, 13223, 13220
1210, 12796, 1075, 1076, 12806, 13203, 1098, 13224, 13222
1211, 1000, 12797, 12807, 1001, 13205, 13225, 13226, 1023
1212, 12797, 12798, 12808, 12807, 13207, 13227, 13228, 13225
1213, 12798, 12799, 12809, 12808, 13209, 13229, 13230, 13227
1214, 12799, 12800, 12810, 12809, 13211, 13231, 13232, 13229
1215, 12800, 12801, 12811, 12810, 13213, 13233, 13234, 13231
1216, 12801, 12802, 12812, 12811, 13215, 13235, 13236, 13233
1217, 12802, 12803, 12813, 12812, 13217, 13237, 13238, 13235
1218, 12803, 12804, 12814, 12813, 13219, 13239, 13240, 13237
1219, 12804, 12805, 12815, 12814, 13221, 13241, 13242, 13239
1220, 12805, 12806, 12816, 12815, 13223, 13243, 13244, 13241
1221, 12806, 1076, 1077, 12816, 13224, 1099, 13245, 13243
1222, 1001, 12807, 12817, 1002, 13226, 13246, 13247, 1024
1223, 12807, 12808, 12818, 12817, 13228, 13248, 13249, 13246
1224, 12808, 12809, 12819, 12818, 13230, 13250, 13251, 13248
1225, 12809, 12810, 12820, 12819, 13232, 13252, 13253, 13250
1226, 12810, 12811, 12821, 12820, 13234, 13254, 13255, 13252
1227, 12811, 12812, 12822, 12821, 13236, 13256, 13257, 13254
1228, 12812, 12813, 12823, 12822, 13238, 13258, 13259, 13256
1229, 12813, 12814, 12824, 12823, 13240, 13260, 13261, 13258
1230, 12814, 12815, 12825, 12824, 13242, 13262, 13263, 13260
1231, 12815, 12816, 12826, 12825, 13244, 13264, 13265, 13262
1232, 12816, 1077, 1078, 12826, 13245, 1100, 13266, 13264
1233, 1002, 12817, 12827, 1003, 13247, 13267, 13268, 1025
1234, 12817, 12818, 12828, 12827, 13249, 13269, 13270, 13267
1235, 12818, 12819, 12829, 12828, 13251, 13271, 13272, 13269
1236, 12819, 12820, 12830, 12829, 13253, 13273, 13274, 13271
1237, 12820, 12821, 12831, 12830, 13255, 13275, 13276, 13273
1238, 12821, 12822, 12832, 12831, 13257, 13277, 13278, 13275
1239, 12822, 12823, 12833, 12832, 13259, 13279, 13280, 13277
1240, 12823, 12824, 12834, 12833, 13261, 13281, 13282, 13279
1241, 12824, 12825, 12835, 12834, 13263, 13283, 13284, 13281
1242, 12825, 12826, 12836, 12835, 13265, 13285, 13286, 13283
1243, 12826, 1078, 1079, 12836, 13266, 1101, 13287, 13285
1244, 1003, 12827, 12837, 1004, 13268, 13288, 13289, 1026
1245, 12827, 12828, 12838, 12837, 13270, 13290, 13291, 13288
1246, 12828, 12829, 12839, 12838, 13272, 13292, 13293, 13290
1247, 12829, 12830, 12840, 12839, 13274, 13294, 13295, 13292
1248, 12830, 12831, 12841, 12840, 13276, 13296, 13297, 13294
1249, 12831, 12832, 12842, 12841, 13278, 13298, 13299, 13296
1250, 12832, 12833, 12843, 12842, 13280, 13300, 13301, 13298
1251, 12833, 12834, 12844, 12843, 13282, 13302, 13303, 13300
1252, 12834, 12835, 12845, 12844, 13284, 13304, 13305, 13302
1253, 12835, 12836, 12846, 12845, 13286, 13306, 13307, 13304
1254, 12836, 1079, 1080, 12846, 13287, 1102, 13308, 13306
1255, 1004, 12837, 1033, 21, 13289, 13309, 1043, 1027
1256, 12837, 12838, 1034, 1033, 13291, 13310, 1044, 13309
1257, 12838, 12839, 1035, 1034, 13293, 13311, 1045, 13310
1258, 12839, 12840, 1036, 1035, 13295, 13312, 1046, 13311
1259, 12840, 12841, 1037, 1036, 13297, 13313, 1047, 13312
1260, 12841, 12842, 1038, 1037, 13299, 13314, 1048, 13313
1261, 12842, 12843, 1039, 1038, 13301, 13315, 1049, 13314
1262, 12843, 12844, 1040, 1039, 13303, 13316, 1050, 13315
1263, 12844, 12845, 1041, 1040, 13305, 13317, 1051, 13316
1264, 12845, 12846, 1042, 1041, 13307, 13318, 1052, 13317
1265, 12846, 1080, 23, 1042, 13308, 1103, 1053, 13318
*ELEMENT, type=CPS8, ELSET=Surface27
1266, 19, 1125, 13319, 1028, 1129, 13327, 13328, 1030
1267, 1028, 13319, 13320, 1029, 13328, 13329, 13330, 1031
1268, 1029, 13320, 1134, 23, 13330, 13331, 1138, 1032
1269, 1125, 1126, 13321, 13319, 1130, 13332, 13333, 13327
1270, 13319, 13321, 13322, 13320, 13333, 13334, 13335, 13329
1271, 13320, 13322, 1135, 1134, 13335, 13336, 1139, 13331
1272, 1126, 1127, 13323, 13321, 1131, 13337, 13338, 13332
1273, 13321, 13323, 13324, 13322, 13338, 13339, 13340, 13334
1274, 13322, 13324, 1136, 1135, 13340, 13341, 1140, 13336
1275, 1127, 1128, 13325, 13323, 1132, 13342, 13343, 13337
1276, 13323, 13325, 13326, 13324, 13343, 13344, 13345, 13339
1277, 13324, 13326, 1137, 1136, 13345, 13346, 1141, 13341
1278, 1128, 25, 1143, 13325, 1133, 1145, 13347, 13342
1279, 13325, 1143, 1144, 13326, 13347, 1146, 13348, 13344
1280, 13326, 1144, 26, 1137, 13348, 1147, 1142, 13346
*ELEMENT, type=CPS8, ELSET=Surface28
31373, 17, 973, 13349, 1148, 975, 13357, 13358, 1152
31374, 973, 974, 13350, 13349, 976, 13359, 13360, 13357
31375, 974, 21, 1157, 13350, 977, 1161, 13361, 13359
31376, 1148, 13349, 13351, 1149, 13358, 13362, 13363, 1153
31377, 13349, 13350, 13352, 13351, 13360, 13364, 13365, 13362
31378, 13350, 1157, 1158, 13352, 13361, 1162, 13366, 13364
31379, 1149, 13351, 13353, 1150, 13363, 13367, 13368, 1154
31380, 13351, 13352, 13354, 13353, 13365, 13369, 13370, 13367
31381, 13352, 1158, 1159, 13354, 13366, 1163, 13371, 13369
31382, 1150, 13353, 13355, 1151, 13368, 13372, 13373, 1155
31383, 13353, 13354, 13356, 13355, 13370, 13374, 13375, 13372
31384, 13354, 1159, 1160, 13356, 13371, 1164, 13376, 13374
31385, 1151, 13355, 1166, 27, 13373, 13377, 1168, 1156
31386, 13355, 13356, 1167, 1166, 13375, 13378, 1169, 13377
31387, 13356, 1160, 28, 1167, 13376, 1165, 1170, 13378
*ELEMENT, type=CPS8, ELSET=Surface29
31388, 19, 892, 13379, 1125, 903, 13419, 13420, 1129
31389, 892, 891, 13380, 13379, 902, 13421, 13422, 13419
31390, 891, 890, 13381, 13380, 901, 13423, 13424, 13421
31391, 890, 889, 13382, 13381, 900, 13425, 13426, 13423
31392, 889, 888, 13383, 13382, 899, 13427, 13428, 13425
31393, 888, 887, 13384, 13383, 898, 13429, 13430, 13427
31394, 887, 886, 13385, 13384, 897, 13431, 13432, 13429
31395, 886, 885, 13386, 13385, 896, 13433, 13434, 13431
31396, 885, 884, 13387, 13386, 895, 13435, 13436, 13433
31397, 884, 883, 13388, 13387, 894, 13437, 13438, 13435
31398, 883, 17, 1148, 13388, 893, 1152, 13439, 13437
31399, 1125, 13379, 13389, 1126, 13420, 13440, 13441, 1130
31400, 13379, 13380, 13390, 13389, 13422, 13442, 13443, 13440
31401, 13380, 13381, 13391, 13390, 13424, 13444, 13445, 13442
31402, 13381, 13382, 13392, 13391, 13426, 13446, 13447, 13444
31403, 13382, 13383, 13393, 13392, 13428, 13448, 13449, 13446
31404, 13383, 13384, 13394, 13393, 13430, 13450, 13451, 13448
31405, 13384, 13385, 13395, 13394, 13432, 13452, 13453, 13450
31406, 13385, 13386, 13396, 13395, 13434, 13454, 13455, 13452
31407, 13386, 13387, 13397, 13396, 13436, 13456, 13457, 13454
31408, 13387, 13388, 13398, 13397, 13438, 13458, 13459, 13456
31409, 13388, 1148, 1149, 13398, 13439, 1153, 13460, 13458
31410, 1126, 13389, 13399, 1127, 13441, 13461, 13462, 1131
31411, 13389, 13390, 13400, 13399, 13443, 13463, 13464, 13461
31412, 13390, 13391, 13401, 13400, 13445, 13465, 13466, 13463
31413, 13391, 13392, 13402, 13401, 13447, 13467, 13468, 13465
31414, 13392, 13393, 13403, 13402, 13449, 13469, 13470, 13467
31415, 13393, 13394, 13404, 13403, 13451, 13471, 13472, 13469
31416, 13394, 13395, 13405, 13404, 13453, 13473, 13474, 13471
31417, 13395, 13396, 13406, 13405, 13455, 13475, 13476, 13473
31418, 13396, 13397, 13407, 13406, 13457, 13477, 13478, 13475
31419, 13397, 13398, 13408, 13407, 13459, 13479, 13480, 13477
31420, 13398, 1149, 1150, 13408, 13460, 1154, 13481, 13479
31421, 1127, 13399, 13409, 1128, 13462, 13482, 13483, 1132
31422, 13399, 13400, 13410, 13409, 13464, 13484, 13485, 13482
31423, 13400, 13401, 13411, 13410, 13466, 13486, 13487, 13484
31424, 13401, 13402, 13412, 13411, 13468, 13488, 13489, 13486
31425, 13402, 13403, 13413, 13412, 13470, 13490, 13491, 13488
31426, 13403, 13404, 13414, 13413, 13472, 13492, 13493, 13490
31427, 13404, 13405, 13415, 13414, 13474, 13494, 13495, 13492
31428, 13405, 13406, 13416, 13415, 13476, 13496, 13497, 13494
31429, 13406, 13407, 13417, 13416, 13478, 13498, 13499, 13496
31430, 13407, 13408, 13418, 13417, 13480, 13500, 13501, 13498
31431, 13408, 1150, 1151, 13418, 13481, 1155, 13502, 13500
31432, 1128, 13409, 1180, 25, 13483, 13503, 1191, 1133
31433, 13409, 13410, 1179, 1180, 13485, 13504, 1190, 13503
31434, 13410, 13411, 1178, 1179, 13487, 13505, 1189, 13504
31435, 13411, 13412, 1177, 1178, 13489, 13506, 1188, 13505
31436, 13412, 13413, 1176, 1177, 13491, 13507, 1187, 13506
31437, 13413, 13414, 1175, 1176, 13493, 13508, 1186, 13507
31438, 13414, 13415, 1174, 1175, 13495, 13509, 1185, 13508
31439, 13415, 13416, 1173, 1174, 13497, 13510, 1184, 13509
31440, 13416, 13417, 1172, 1173, 13499, 13511, 1183, 13510
31441, 13417, 13418, 1171, 1172, 13501, 13512, 1182, 13511
31442, 13418, 1151, 27, 1171, 13502, 1156, 1181, 13512
*ELEMENT, type=CPS8, ELSET=Surface30
1281, 23, 1134, 13513, 1042, 1138, 13553, 13554, 1053
1282, 1042, 13513, 13514, 1041, 13554, 13555, 13556, 1052
1283, 1041, 13514, 13515, 1040, 13556, 13557, 13558, 1051
1284, 1040, 13515, 13516, 1039, 13558, 13559, 13560, 1050
1285, 1039, 13516, 13517, 1038, 13560, 13561, 13562, 1049
1286, 1038, 13517, 13518, 1037, 13562, 13563, 13564, 1048
1287, 1037, 13518, 13519, 1036, 13564, 13565, 13566, 1047
1288, 1036, 13519, 13520, 1035, 13566, 13567, 13568, 1046
1289, 1035, 13520, 13521, 1034, 13568, 13569, 13570, 1045
1290, 1034, 13521, 13522, 1033, 13570, 13571, 13572, 1044
1291, 1033, 13522, 1157, 21, 13572, 13573, 1161, 1043
1292, 1134, 1135, 13523, 13513, 1139, 13574, 13575, 13553
1293, 13513, 13523, 13524, 13514, 13575, 13576, 13577, 13555
1294, 13514, 13524, 13525, 13515, 13577, 13578, 13579, 13557
1295, 13515, 13525, 13526, 13516, 13579, 13580, 13581, 13559
1296, 13516, 13526, 13527, 13517, 13581, 13582, 13583, 13561
1297, 13517, 13527, 13528, 13518, 13583, 13584, 13585, 13563
1298, 13518, 13528, 13529, 13519, 13585, 13586, 13587, 13565
1299, 13519, 13529, 13530, 13520, 13587, 13588, 13589, 13567
1300, 13520, 13530, 13531, 13521, 13589, 13590, 13591, 13569
1301, 13521, 13531, 13532, 13522, 13591, 13592, 13593, 13571
1302, 13522, 13532, 1158, 1157, 13593, 13594, 1162, 13573
1303, 1135, 1136, 13533, 13523, 1140, 13595, 13596, 13574
1304, 13523, 13533, 13534, 13524, 13596, 13597, 13598, 13576
1305, 13524, 13534, 13535, 13525, 13598, 13599, 13600, 13578
1306, 13525, 13535, 13536, 13526, 13600, 13601, 13602, 13580
1307, 13526, 13536, 13537, 13527, 13602, 13603, 13604, 13582
1308, 13527, 13537, 13538, 13528, 13604, 13605, 13606, 13584
1309, 13528, 13538, 13539, 13529, 13606, 13607, 13608, 13586
1310, 13529, 13539, 13540, 13530, 13608, 13609, 13610, 13588
1311, 13530, 13540, 13541, 13531, 13610, 13611, 13612, 13590
1312, 13531, 13541, 13542, 13532, 13612, 13613, 13614, 13592
1313, 13532, 13542, 1159, 1158, 13614, 13615, 1163, 13594
1314, 1136, 1137, 13543, 13533, 1141, 13616, 13617, 13595
1315, 13533, 13543, 13544, 13534, 13617, 13618, 13619, 13597
1316, 13534, 13544, 13545, 13535, 13619, 13620, 13621, 13599
1317, 13535, 13545, 13546, 13536, 13621, 13622, 13623, 13601
1318, 13536, 13546, 13547, 13537, 13623, 13624, 13625, 13603
1319, 13537, 13547, 13548, 13538, 13625, 13626, 13627, 13605
1320, 13538, 13548, 13549, 13539, 13627, 13628, 13629, 13607
1321, 13539, 13549, 13550, 13540, 13629, 13630, 13631, 13609
1322, 13540, 13550, 13551, 13541, 13631, 13632, 13633, 13611
1323, 13541, 13551, 13552, 13542, 13633, 13634, 13635, 13613
1324, 13542, 13552, 1160, 1159, 13635, 13636, 1164, 13615
1325, 1137, 26, 1201, 13543, 1142, 1212, 13637, 13616
1326, 13543, 1201, 1200, 13544, 13637, 1211, 13638, 13618
1327, 13544, 1200, 1199, 13545, 13638, 1210, 13639, 13620
1328, 13545, 1199, 1198, 13546, 13639, 1209, 13640, 13622
1329, 13546, 1198, 1197, 13547, 13640, 1208, 13641, 13624
1330, 13547, 1197, 1196, 13548, 13641, 1207, 13642, 13626
1331, 13548, 1196, 1195, 13549, 13642, 1206, 13643, 13628
1332, 13549, 1195, 1194, 13550, 13643, 1205, 13644, 13630
1333, 13550, 1194, 1193, 13551, 13644, 1204, 13645, 13632
1334, 13551, 1193, 1192, 13552, 13645, 1203, 13646, 13634
1335, 13552, 1192, 28, 1160, 13646, 1202, 1165, 13636
*ELEMENT, type=CPS8, ELSET=Surface31
31443, 25, 1180, 13647, 1143, 1191, 13667, 13668, 1145
31444, 1180, 1179, 13648, 13647, 1190, 13669, 13670, 13667
31445, 1179, 1178, 13649, 13648, 1189, 13671, 13672, 13669
31446, 1178, 1177, 13650, 13649, 1188, 13673, 13674, 13671
31447, 1177, 1176, 13651, 13650, 1187, 13675, 13676, 13673
31448, 1176, 1175, 13652, 13651, 1186, 13677, 13678, 13675
31449, 1175, 1174, 13653, 13652, 1185, 13679, 13680, 13677
31450, 1174, 1173, 13654, 13653, 1184, 13681, 13682, 13679
31451, 1173, 1172, 13655, 13654, 1183, 13683, 13684, 13681
31452, 1172, 1171, 13656, 13655, 1182, 13685, 13686, 13683
31453, 1171, 27, 1166, 13656, 1181, 1168, 13687, 13685
31454, 1143, 13647, 13657, 1144, 13668, 13688, 13689, 1146
31455, 13647, 13648, 13658, 13657, 13670, 13690, 13691, 13688
31456, 13648, 13649, 13659, 13658, 13672, 13692, 13693, 13690
31457, 13649, 13650, 13660, 13659, 13674, 13694, 13695, 13692
31458, 13650, 13651, 13661, 13660, 13676, 13696, 13697, 13694
31459, 13651, 13652, 13662, 13661, 13678, 13698, 13699, 13696
31460, 13652, 13653, 13663, 13662, 13680, 13700, 13701, 13698
31461, 13653, 13654, 13664, 13663, 13682, 13702, 13703, 13700
31462, 13654, 13655, 13665, 13664, 13684, 13704, 13705, 13702
31463, 13655, 13656, 13666, 13665, 13686, 13706, 13707, 13704
31464, 13656, 1166, 1167, 13666, 13687, 1169, 13708, 13706
31465, 1144, 13657, 1201, 26, 13689, 13709, 1212, 1147
31466, 13657, 13658, 1200, 1201, 13691, 13710, 1211, 13709
31467, 13658, 13659, 1199, 1200, 13693, 13711, 1210, 13710
31468, 13659, 13660, 1198, 1199, 13695, 13712, 1209, 13711
31469, 13660, 13661, 1197, 1198, 13697, 13713, 1208, 13712
31470, 13661, 13662, 1196, 1197, 13699, 13714, 1207, 13713
31471, 13662, 13663, 1195, 1196, 13701, 13715, 1206, 13714
31472, 13663, 13664, 1194, 1195, 13703, 13716, 1205, 13715
31473, 13664, 13665, 1193, 1194, 13705, 13717, 1204, 13716
31474, 13665, 13666, 1192, 1193, 13707, 13718, 1203, 13717
31475, 13666, 1167, 28, 1192, 13708, 1170, 1202, 13718
*ELEMENT, type=CPS8, ELSET=Surface32
1336, 25, 1213, 13719, 1143, 1235, 13763, 13764, 1145
1337, 1143, 13719, 13720, 1144, 13764, 13765, 13766, 1146
1338, 1144, 13720, 1258, 26, 13766, 13767, 1280, 1147
1339, 1213, 1214, 13721, 13719, 1236, 13768, 13769, 13763
1340, 13719, 13721, 13722, 13720, 13769, 13770, 13771, 13765
1341, 13720, 13722, 1259, 1258, 13771, 13772, 1281, 13767
1342, 1214, 1215, 13723, 13721, 1237, 13773, 13774, 13768
1343, 13721, 13723, 13724, 13722, 13774, 13775, 13776, 13770
1344, 13722, 13724, 1260, 1259, 13776, 13777, 1282, 13772
1345, 1215, 1216, 13725, 13723, 1238, 13778, 13779, 13773
1346, 13723, 13725, 13726, 13724, 13779, 13780, 13781, 13775
1347, 13724, 13726, 1261, 1260, 13781, 13782, 1283, 13777
1348, 1216, 1217, 13727, 13725, 1239, 13783, 13784, 13778
1349, 13725, 13727, 13728, 13726, 13784, 13785, 13786, 13780
1350, 13726, 13728, 1262, 1261, 13786, 13787, 1284, 13782
1351, 1217, 1218, 13729, 13727, 1240, 13788, 13789, 13783
1352, 13727, 13729, 13730, 13728, 13789, 13790, 13791, 13785
1353, 13728, 13730, 1263, 1262, 13791, 13792, 1285, 13787
1354, 1218, 1219, 13731, 13729, 1241, 13793, 13794, 13788
1355, 13729, 13731, 13732, 13730, 13794, 13795, 13796, 13790
1356, 13730, 13732, 1264, 1263, 13796, 13797, 1286, 13792
1357, 1219, 1220, 13733, 13731, 1242, 13798, 13799, 13793
1358, 13731, 13733, 13734, 13732, 13799, 13800, 13801, 13795
1359, 13732, 13734, 1265, 1264, 13801, 13802, 1287, 13797
1360, 1220, 1221, 13735, 13733, 1243, 13803, 13804, 13798
1361, 13733, 13735, 13736, 13734, 13804, 13805, 13806, 13800
1362, 13734, 13736, 1266, 1265, 13806, 13807, 1288, 13802
1363, 1221, 1222, 13737, 13735, 1244, 13808, 13809, 13803
1364, 13735, 13737, 13738, 13736, 13809, 13810, 13811, 13805
1365, 13736, 13738, 1267, 1266, 13811, 13812, 1289, 13807
1366, 1222, 1223, 13739, 13737, 1245, 13813, 13814, 13808
1367, 13737, 13739, 13740, 13738, 13814, 13815, 13816, 13810
1368, 13738, 13740, 1268, 1267, 13816, 13817, 1290, 13812
1369, 1223, 1224, 13741, 13739, 1246, 13818, 13819, 13813
1370, 13739, 13741, 13742, 13740, 13819, 13820, 13821, 13815
1371, 13740, 13742, 1269, 1268, 13821, 13822, 1291, 13817
1372, 1224, 1225, 13743, 13741, 1247, 13823, 13824, 13818
1373, 13741, 13743, 13744, 13742, 13824, 13825, 13826, 13820
1374, 13742, 13744, 1270, 1269, 13826, 13827, 1292, 13822
1375, 1225, 1226, 13745, 13743, 1248, 13828, 13829, 13823
1376, 13743, 13745, 13746, 13744, 13829, 13830, 13831, 13825
1377, 13744, 13746, 1271, 1270, 13831, 13832, 1293, 13827
1378, 1226, 1227, 13747, 13745, 1249, 13833, 13834, 13828
1379, 13745, 13747, 13748, 13746, 13834, 13835, 13836, 13830
1380, 13746, 13748, 1272, 1271, 13836, 13837, 1294, 13832
1381, 1227, 1228, 13749, 13747, 1250, 13838, 13839, 13833
1382, 13747, 13749, 13750, 13748, 13839, 13840, 13841, 13835
1383, 13748, 13750, 1273, 1272, 13841, 13842, 1295, 13837
1384, 1228, 1229, 13751, 13749, 1251, 13843, 13844, 13838
1385, 13749, 13751, 13752, 13750, 13844, 13845, 13846, 13840
1386, 13750, 13752, 1274, 1273, 13846, 13847, 1296, 13842
1387, 1229, 1230, 13753, 13751, 1252, 13848, 13849, 13843
1388, 13751, 13753, 13754, 13752, 13849, 13850, 13851, 13845
1389, 13752, 13754, 1275, 1274, 13851, 13852, 1297, 13847
1390, 1230, 1231, 13755, 13753, 1253, 13853, 13854, 13848
1391, 13753, 13755, 13756, 13754, 13854, 13855, 13856, 13850
1392, 13754, 13756, 1276, 1275, 13856, 13857, 1298, 13852
1393, 1231, 1232, 13757, 13755, 1254, 13858, 13859, 13853
1394, 13755, 13757, 13758, 13756, 13859, 13860, 13861, 13855
1395, 13756, 13758, 1277, 1276, 13861, 13862, 1299, 13857
1396, 1232, 1233, 13759, 13757, 1255, 13863, 13864, 13858
1397, 13757, 13759, 13760, 13758, 13864, 13865, 13866, 13860
1398, 13758, 13760, 1278, 1277, 13866, 13867, 1300, 13862
1399, 1233, 1234, 13761, 13759, 1256, 13868, 13869, 13863
1400, 13759, 13761, 13762, 13760, 13869, 13870, 13871, 13865
1401, 13760, 13762, 1279, 1278, 13871, 13872, 1301, 13867
1402, 1234, 29, 1303, 13761, 1257, 1305, 13873, 13868
1403, 13761, 1303, 1304, 13762, 13873, 1306, 13874, 13870
1404, 13762, 1304, 30, 1279, 13874, 1307, 1302, 13872
*ELEMENT, type=CPS8, ELSET=Surface33
31476, 27, 1166, 13875, 1308, 1168, 13919, 13920, 1330
31477, 1166, 1167, 13876, 13875, 1169, 13921, 13922, 13919
31478, 1167, 28, 1353, 13876, 1170, 1375, 13923, 13921
31479, 1308, 13875, 13877, 1309, 13920, 13924, 13925, 1331
31480, 13875, 13876, 13878, 13877, 13922, 13926, 13927, 13924
31481, 13876, 1353, 1354, 13878, 13923, 1376, 13928, 13926
31482, 1309, 13877, 13879, 1310, 13925, 13929, 13930, 1332
31483, 13877, 13878, 13880, 13879, 13927, 13931, 13932, 13929
31484, 13878, 1354, 1355, 13880, 13928, 1377, 13933, 13931
31485, 1310, 13879, 13881, 1311, 13930, 13934, 13935, 1333
31486, 13879, 13880, 13882, 13881, 13932, 13936, 13937, 13934
31487, 13880, 1355, 1356, 13882, 13933, 1378, 13938, 13936
31488, 1311, 13881, 13883, 1312, 13935, 13939, 13940, 1334
31489, 13881, 13882, 13884, 13883, 13937, 13941, 13942, 13939
31490, 13882, 1356, 1357, 13884, 13938, 1379, 13943, 13941
31491, 1312, 13883, 13885, 1313, 13940, 13944, 13945, 1335
31492, 13883, 13884, 13886, 13885, 13942, 13946, 13947, 13944
31493, 13884, 1357, 1358, 13886, 13943, 1380, 13948, 13946
31494, 1313, 13885, 13887, 1314, 13945, 13949, 13950, 1336
31495, 13885, 13886, 13888, 13887, 13947, 13951, 13952, 13949
31496, 13886, 1358, 1359, 13888, 13948, 1381, 13953, 13951
31497, 1314, 13887, 13889, 1315, 13950, 13954, 13955, 1337
31498, 13887, 13888, 13890, 13889, 13952, 13956, 13957, 13954
31499, 13888, 1359, 1360, 13890, 13953, 1382, 13958, 13956
31500, 1315, 13889, 13891, 1316, 13955, 13959, 13960, 1338
31501, 13889, 13890, 13892, 13891, 13957, 13961, 13962, 13959
31502, 13890, 1360, 1361, 13892, 13958, 1383, 13963, 13961
31503, 1316, 13891, 13893, 1317, 13960, 13964, 13965, 1339
31504, 13891, 13892, 13894, 13893, 13962, 13966, 13967, 13964
31505, 13892, 1361, 1362, 13894, 13963, 1384, 13968, 13966
31506, 1317, 13893, 13895, 1318, 13965, 13969, 13970, 1340
31507, 13893, 13894, 13896, 13895, 13967, 13971, 13972, 13969
31508, 13894, 1362, 1363, 13896, 13968, 1385, 13973, 13971
31509, 1318, 13895, 13897, 1319, 13970, 13974, 13975, 1341
31510, 13895, 13896, 13898, 13897, 13972, 13976, 13977, 13974
31511, 13896, 1363, 1364, 13898, 13973, 1386, 13978, 13976
31512, 1319, 13897, 13899, 1320, 13975, 13979, 13980, 1342
31513, 13897, 13898, 13900, 13899, 13977, 13981, 13982, 13979
31514, 13898, 1364, 1365, 13900, 13978, 1387, 13983, 13981
31515, 1320, 13899, 13901, 1321, 13980, 13984, 13985, 1343
31516, 13899, 13900, 13902, 13901, 13982, 13986, 13987, 13984
31517, 13900, 1365, 1366, 13902, 13983, 1388, 13988, 13986
31518, 1321, 13901, 13903, 1322, 13985, 13989, 13990, 1344
31519, 13901, 13902, 13904, 13903, 13987, 13991, 13992, 13989
31520, 13902, 1366, 1367, 13904, 13988, 1389, 13993, 13991
31521, 1322, 13903, 13905, 1323, 13990, 13994, 13995, 1345
31522, 13903, 13904, 13906, 13905, 13992, 13996, 13997, 13994
31523, 13904, 1367, 1368, 13906, 13993, 1390, 13998, 13996
31524, 1323, 13905, 13907, 1324, 13995, 13999, 14000, 1346
31525, 13905, 13906, 13908, 13907, 13997, 14001, 14002, 13999
31526, 13906, 1368, 1369, 13908, 13998, 1391, 14003, 14001
31527, 1324, 13907, 13909, 1325, 14000, 14004, 14005, 1347
31528, 13907, 13908, 13910, 13909, 14002, 14006, 14007, 14004
31529, 13908, 1369, 1370, 13910, 14003, 1392, 14008, 14006
31530, 1325, 13909, 13911, 1326, 14005, 14009, 14010, 1348
31531, 13909, 13910, 13912, 13911, 14007, 14011, 14012, 14009
31532, 13910, 1370, 1371, 13912, 14008, 1393, 14013, 14011
31533, 1326, 13911, 13913, 1327, 14010, 14014, 14015, 1349
31534, 13911, 13912, 13914, 13913, 14012, 14016, 14017, 14014
31535, 13912, 1371, 1372, 13914, 14013, 1394, 14018, 14016
31536, 1327, 13913, 13915, 1328, 14015, 14019, 14020, 1350
31537, 13913, 13914, 13916, 13915, 14017, 14021, 14022, 14019
31538, 13914, 1372, 1373, 13916, 14018, 1395, 14023, 14021
31539, 1328, 13915, 13917, 1329, 14020, 14024, 14025, 1351
31540, 13915, 13916, 13918, 13917, 14022, 14026, 14027, 14024
31541, 13916, 1373, 1374, 13918, 14023, 1396, 14028, 14026
31542, 1329, 13917, 1398, 31, 14025, 14029, 1400, 1352
31543, 13917, 13918, 1399, 1398, 14027, 14030, 1401, 14029
31544, 13918, 1374, 32, 1399, 14028, 1397, 1402, 14030
*ELEMENT, type=CPS8, ELSET=Surface34
31545, 25, 1180, 14031, 1213, 1191, 14251, 14252, 1235
31546, 1180, 1179, 14032, 14031, 1190, 14253, 14254, 14251
31547, 1179, 1178, 14033, 14032, 1189, 14255, 14256, 14253
31548, 1178, 1177, 14034, 14033, 1188, 14257, 14258, 14255
31549, 1177, 1176, 14035, 14034, 1187, 14259, 14260, 14257
31550, 1176, 1175, 14036, 14035, 1186, 14261, 14262, 14259
31551, 1175, 1174, 14037, 14036, 1185, 14263, 14264, 14261
31552, 1174, 1173, 14038, 14037, 1184, 14265, 14266, 14263
31553, 1173, 1172, 14039, 14038, 1183, 14267, 14268, 14265
31554, 1172, 1171, 14040, 14039, 1182, 14269, 14270, 14267
31555, 1171, 27, 1308, 14040, 1181, 1330, 14271, 14269
31556, 1213, 14031, 14041, 1214, 14252, 14272, 14273, 1236
31557, 14031, 14032, 14042, 14041, 14254, 14274, 14275, 14272
31558, 14032, 14033, 14043, 14042, 14256, 14276, 14277, 14274
31559, 14033, 14034, 14044, 14043, 14258, 14278, 14279, 14276
31560, 14034, 14035, 14045, 14044, 14260, 14280, 14281, 14278
31561, 14035, 14036, 14046, 14045, 14262, 14282, 14283, 14280
31562, 14036, 14037, 14047, 14046, 14264, 14284, 14285, 14282
31563, 14037, 14038, 14048, 14047, 14266, 14286, 14287, 14284
31564, 14038, 14039, 14049, 14048, 14268, 14288, 14289, 14286
31565, 14039, 14040, 14050, 14049, 14270, 14290, 14291, 14288
31566, 14040, 1308, 1309, 14050, 14271, 1331, 14292, 14290
31567, 1214, 14041, 14051, 1215, 14273, 14293, 14294, 1237
31568, 14041, 14042, 14052, 14051, 14275, 14295, 14296, 14293
31569, 14042, 14043, 14053, 14052, 14277, 14297, 14298, 14295
31570, 14043, 14044, 14054, 14053, 14279, 14299, 14300, 14297
31571, 14044, 14045, 14055, 14054, 14281, 14301, 14302, 14299
31572, 14045, 14046, 14056, 14055, 14283, 14303, 14304, 14301
31573, 14046, 14047, 14057, 14056, 14285, 14305, 14306, 14303
31574, 14047, 14048, 14058, 14057, 14287, 14307, 14308, 14305
31575, 14048, 14049, 14059, 14058, 14289, 14309, 14310, 14307
31576, 14049, 14050, 14060, 14059, 14291, 14311, 14312, 14309
31577, 14050, 1309, 1310, 14060, 14292, 1332, 14313, 14311
31578, 1215, 14051, 14061, 1216, 14294, 14314, 14315, 1238
31579, 14051, 14052, 14062, 14061, 14296, 14316, 14317, 14314
31580, 14052, 14053, 14063, 14062, 14298, 14318, 14319, 14316
31581, 14053, 14054, 14064, 14063, 14300, 14320, 14321, 14318
31582, 14054, 14055, 14065, 14064, 14302, 14322, 14323, 14320
31583, 14055, 14056, 14066, 14065, 14304, 14324, 14325, 14322
31584, 14056, 14057, 14067, 14066, 14306, 14326, 14327, 14324
31585, 14057, 14058, 14068, 14067, 14308, 14328, 14329, 14326
31586, 14058, 14059, 14069, 14068, 14310, 14330, 14331, 14328
31587, 14059, 14060, 14070, 14069, 14312, 14332, 14333, 14330
31588, 14060, 1310, 1311, 14070, 14313, 1333, 14334, 14332
31589, 1216, 14061, 14071, 1217, 14315, 14335, 14336, 1239
31590, 14061, 14062, 14072, 14071, 14317, 14337, 14338, 14335
31591, 14062, 14063, 14073, 14072, 14319, 14339, 14340, 14337
31592, 14063, 14064, 14074, 14073, 14321, 14341, 14342, 14339
31593, 14064, 14065, 14075, 14074, 14323, 14343, 14344, 14341
31594, 14065, 14066, 14076, 14075, 14325, 14345, 14346, 14343
31595, 14066, 14067, 14077, 14076, 14327, 14347, 14348, 14345
31596, 14067, 14068, 14078, 14077, 14329, 14349, 14350, 14347
31597, 14068, 14069, 14079, 14078, 14331, 14351, 14352, 14349
31598, 14069, 14070, 14080, 14079, 14333, 14353, 14354, 14351
31599, 14070, 1311, 1312, 14080, 14334, 1334, 14355, 14353
31600, 1217, 14071, 14081, 1218, 14336, 14356, 14357, 1240
31601, 14071, 14072, 14082, 14081, 14338, 14358, 14359, 14356
31602, 14072, 14073, 14083, 14082, 14340, 14360, 14361, 14358
31603, 14073, 14074, 14084, 14083, 14342, 14362, 14363, 14360
31604, 14074, 14075, 14085, 14084, 14344, 14364, 14365, 14362
31605, 14075, 14076, 14086, 14085, 14346, 14366, 14367, 14364
31606, 14076, 14077, 14087, 14086, 14348, 14368, 14369, 14366
31607, 14077, 14078, 14088, 14087, 14350, 14370, 14371, 14368
31608, 14078, 14079, 14089, 14088, 14352, 14372, 14373, 14370
31609, 14079, 14080, 14090, 14089, 14354, 14374, 14375, 14372
31610, 14080, 1312, 1313, 14090, 14355, 1335, 14376, 14374
31611, 1218, 14081, 14091, 1219, 14357, 14377, 14378, 1241
31612, 14081, 14082, 14092, 14091, 14359, 14379, 14380, 14377
31613, 14082, 14083, 14093, 14092, 14361, 14381, 14382, 14379
31614, 14083, 14084, 14094, 14093, 14363, 14383, 14384, 14381
31615, 14084, 14085, 14095, 14094, 14365, 14385, 14386, 14383
31616, 14085, 14086, 14096, 14095, 14367, 14387, 14388, 14385
31617, 14086, 14087, 14097, 14096, 14369, 14389, 14390, 14387
31618, 14087, 14088, 14098, 14097, 14371, 14391, 14392, 14389
31619, 14088, 14089, 14099, 14098, 14373, 14393, 14394, 14391
31620, 14089, 14090, 14100, 14099, 14375, 14395, 14396, 14393
31621, 14090, 1313, 1314, 14100, 14376, 1336, 14397, 14395
31622, 1219, 14091, 14101, 1220, 14378, 14398, 14399, 1242
31623, 14091, 14092, 14102, 14101, 14380, 14400, 14401, 14398
31624, 14092, 14093, 14103, 14102, 14382, 14402, 14403, 14400
31625, 14093, 14094, 14104, 14103, 14384, 14404, 14405, 14402
31626, 14094, 14095, 14105, 14104, 14386, 14406, 14407, 14404
31627, 14095, 14096, 14106, 14105, 14388, 14408, 14409, 14406
31628, 14096, 14097, 14107, 14106, 14390, 14410, 14411, 14408
31629, 14097, 14098, 14108, 14107, 14392, 14412, 14413, 14410
31630, 14098, 14099, 14109, 14108, 14394, 14414, 14415, 14412
31631, 14099, 14100, 14110, 14109, 14396, 14416, 14417, 14414
31632, 14100, 1314, 1315, 14110, 14397, 1337, 14418, 14416
31633, 1220, 14101, 14111, 1221, 14399, 14419, 14420, 1243
31634, 14101, 14102, 14112, 14111, 14401, 14421, 14422, 14419
31635, 14102, 14103, 14113, 14112, 14403, 14423, 14424, 14421
31636, 14103, 14104, 14114, 14113, 14405, 14425, 14426, 14423
31637, 14104, 14105, 14115, 14114, 14407, 14427, 14428, 14425
31638, 14105, 14106, 14116, 14115, 14409, 14429, 14430, 14427
31639, 14106, 14107, 14117, 14116, 14411, 14431, 14432, 14429
31640, 14107, 14108, 14118, 14117, 14413, 14433, 14434, 14431
31641, 14108, 14109, 14119, 14118, 14415, 14435, 14436, 14433
31642, 14109, 14110, 14120, 14119, 14417, 14437, 14438, 14435
31643, 14110, 1315, 1316, 14120, 14418, 1338, 14439, 14437
31644, 1221, 14111, 14121, 1222, 14420, 14440, 14441, 1244
31645, 14111, 14112, 14122, 14121, 14422, 14442, 14443, 14440
31646, 14112, 14113, 14123, 14122, 14424, 14444, 14445, 14442
31647, 14113, 14114, 14124, 14123, 14426, 14446, 14447, 14444
31648, 14114, 14115, 14125, 14124, 14428, 14448, 14449, 14446
31649, 14115, 14116, 14126, 14125, 14430, 14450, 14451, 14448
31650, 14116, 14117, 14127, 14126, 14432, 14452, 14453, 14450
31651, 14117, 14118, 14128, 14127, 14434, 14454, 14455, 14452
31652, 14118, 14119, 14129, 14128, 14436, 14456, 14457, 14454
31653, 14119, 14120, 14130, 14129, 14438, 14458, 14459, 14456
31654, 14120, 1316, 1317, 14130, 14439, 1339, 14460, 14458
31655, 1222, 14121, 14131, 1223, 14441, 14461, 14462, 1245
31656, 14121, 14122, 14132, 14131, 14443, 14463, 14464, 14461
31657, 14122, 14123, 14133, 14132, 14445, 14465, 14466, 14463
31658, 14123, 14124, 14134, 14133, 14447, 14467, 14468, 14465
31659, 14124, 14125, 14135, 14134, 14449, 14469, 14470, 14467
31660, 14125, 14126, 14136, 14135, 14451, 14471, 14472, 14469
31661, 14126, 14127, 14137, 14136, 14453, 14473, 14474, 14471
31662, 14127, 14128, 14138, 14137, 14455, 14475, 14476, 14473
31663, 14128, 14129, 14139, 14138, 14457, 14477, 14478, 14475
31664, 14129, 14130, 14140, 14139, 14459, 14479, 14480, 14477
31665, 14130, 1317, 1318, 14140, 14460, 1340, 14481, 14479
31666, 1223, 14131, 14141, 1224, 14462, 14482, 14483, 1246
31667, 14131, 14132, 14142, 14141, 14464, 14484, 14485, 14482
31668, 14132, 14133, 14143, 14142, 14466, 14486, 14487, 14484
31669, 14133, 14134, 14144, 14143, 14468, 14488, 14489, 14486
31670, 14134, 14135, 14145, 14144, 14470, 14490, 14491, 14488
31671, 14135, 14136, 14146, 14145, 14472, 14492, 14493, 14490
31672, 14136, 14137, 14147, 14146, 14474, 14494, 14495, 14492
31673, 14137, 14138, 14148, 14147, 14476, 14496, 14497, 14494
31674, 14138, 14139, 14149, 14148, 14478, 14498, 14499, 14496
31675, 14139, 14140, 14150, 14149, 14480, 14500, 14501, 14498
31676, 14140, 1318, 1319, 14150, 14481, 1341, 14502, 14500
31677, 1224, 14141, 14151, 1225, 14483, 14503, 14504, 1247
31678, 14141, 14142, 14152, 14151, 14485, 14505, 14506, 14503
31679, 14142, 14143, 14153, 14152, 14487, 14507, 14508, 14505
31680, 14143, 14144, 14154, 14153, 14489, 14509, 14510, 14507
31681, 14144, 14145, 14155, 14154, 14491, 14511, 14512, 14509
31682, 14145, 14146, 14156, 14155, 14493, 14513, 14514, 14511
31683, 14146, 14147, 14157, 14156, 14495, 14515, 14516, 14513
31684, 14147, 14148, 14158, 14157, 14497, 14517, 14518, 14515
31685, 14148, 14149, 14159, 14158, 14499, 14519, 14520, 14517
31686, 14149, 14150, 14160, 14159, 14501, 14521, 14522, 14519
31687, 14150, 1319, 1320, 14160, 14502, 1342, 14523, 14521
31688, 1225, 14151, 14161, 1226, 14504, 14524, 14525, 1248
31689, 14151, 14152, 14162, 14161, 14506, 14526, 14527, 14524
31690, 14152, 14153, 14163, 14162, 14508, 14528, 14529, 14526
31691, 14153, 14154, 14164, 14163, 14510, 14530, 14531, 14528
31692, 14154, 14155, 14165, 14164, 14512, 14532, 14533, 14530
31693, 14155, 14156, 14166, 14165, 14514, 14534, 14535, 14532
31694, 14156, 14157, 14167, 14166, 14516, 14536, 14537, 14534
31695, 14157, 14158, 14168, 14167, 14518, 14538, 14539, 14536
31696, 14158, 14159, 14169, 14168, 14520, 14540, 14541, 14538
31697, 14159, 14160, 14170, 14169, 14522, 14542, 14543, 14540
31698, 14160, 1320, 1321, 14170, 14523, 1343, 14544, 14542
31699, 1226, 14161, 14171, 1227, 14525, 14545, 14546, 1249
31700, 14161, 14162, 14172, 14171, 14527, 14547, 14548, 14545
31701, 14162, 14163, 14173, 14172, 14529, 14549, 14550, 14547
31702, 14163, 14164, 14174, 14173, 14531, 14551, 14552, 14549
31703, 14164, 14165, 14175, 14174, 14533, 14553, 14554, 14551
31704, 14165, 14166, 14176, 14175, 14535, 14555, 14556, 14553
31705, 14166, 14167, 14177, 14176, 14537, 14557, 14558, 14555
31706, 14167, 14168, 14178, 14177, 14539, 14559, 14560, 14557
31707, 14168, 14169, 14179, 14178, 14541, 14561, 14562, 14559
31708, 14169, 14170, 14180, 14179, 14543, 14563, 14564, 14561
31709, 14170, 1321, 1322, 14180, 14544, 1344, 14565, 14563
31710, 1227, 14171, 14181, 1228, 14546, 14566, 14567, 1250
31711, 14171, 14172, 14182, 14181, 14548, 14568, 14569, 14566
31712, 14172, 14173, 14183, 14182, 14550, 14570, 14571, 14568
31713, 14173, 14174, 14184, 14183, 14552, 14572, 14573, 14570
31714, 14174, 14175, 14185, 14184, 14554, 14574, 14575, 14572
31715, 14175, 14176, 14186, 14185, 14556, 14576, 14577, 14574
31716, 14176, 14177, 14187, 14186, 14558, 14578, 14579, 14576
31717, 14177, 14178, 14188, 14187, 14560, 14580, 14581, 14578
31718, 14178, 14179, 14189, 14188, 14562, 14582, 14583, 14580
31719, 14179, 14180, 14190, 14189, 14564, 14584, 14585, 14582
