303, 5067, 5068, 331, 330, 5139, 5180, 353, 5179
304, 5068, 5069, 332, 331, 5141, 5181, 354, 5180
305, 5069, 5070, 333, 332, 5143, 5182, 355, 5181
306, 5070, 5071, 334, 333, 5145, 5183, 356, 5182
307, 5071, 5072, 335, 334, 5147, 5184, 357, 5183
308, 5072, 5073, 336, 335, 5149, 5185, 358, 5184
309, 5073, 5074, 337, 336, 5151, 5186, 359, 5185
310, 5074, 5075, 338, 337, 5153, 5187, 360, 5186
311, 5075, 5076, 339, 338, 5155, 5188, 361, 5187
312, 5076, 5077, 340, 339, 5157, 5189, 362, 5188
313, 5077, 5078, 341, 340, 5159, 5190, 363, 5189
314, 5078, 5079, 342, 341, 5161, 5191, 364, 5190
315, 5079, 5080, 343, 342, 5163, 5192, 365, 5191
316, 5080, 5081, 344, 343, 5165, 5193, 366, 5192
317, 5081, 5082, 345, 344, 5167, 5194, 367, 5193
318, 5082, 5083, 346, 345, 5169, 5195, 368, 5194
319, 5083, 5084, 347, 346, 5171, 5196, 369, 5195
320, 5084, 5085, 348, 347, 5173, 5197, 370, 5196
321, 5085, 5086, 349, 348, 5175, 5198, 371, 5197
322, 5086, 163, 7, 349, 5176, 166, 372, 5198
*ELEMENT, type=CPS8, ELSET=Surface7
29264, 8, 304, 5199, 373, 327, 5221, 5222, 374
29265, 304, 303, 5200, 5199, 326, 5223, 5224, 5221
29266, 303, 302, 5201, 5200, 325, 5225, 5226, 5223
29267, 302, 301, 5202, 5201, 324, 5227, 5228, 5225
29268, 301, 300, 5203, 5202, 323, 5229, 5230, 5227
29269, 300, 299, 5204, 5203, 322, 5231, 5232, 5229
29270, 299, 298, 5205, 5204, 321, 5233, 5234, 5231
29271, 298, 297, 5206, 5205, 320, 5235, 5236, 5233
29272, 297, 296, 5207, 5206, 319, 5237, 5238, 5235
29273, 296, 295, 5208, 5207, 318, 5239, 5240, 5237
29274, 295, 294, 5209, 5208, 317, 5241, 5242, 5239
29275, 294, 293, 5210, 5209, 316, 5243, 5244, 5241
29276, 293, 292, 5211, 5210, 315, 5245, 5246, 5243
29277, 292, 291, 5212, 5211, 314, 5247, 5248, 5245
29278, 291, 290, 5213, 5212, 313, 5249, 5250, 5247
29279, 290, 289, 5214, 5213, 312, 5251, 5252, 5249
29280, 289, 288, 5215, 5214, 311, 5253, 5254, 5251
29281, 288, 287, 5216, 5215, 310, 5255, 5256, 5253
29282, 287, 286, 5217, 5216, 309, 5257, 5258, 5255
29283, 286, 285, 5218, 5217, 308, 5259, 5260, 5257
29284, 285, 284, 5219, 5218, 307, 5261, 5262, 5259
29285, 284, 283, 5220, 5219, 306, 5263, 5264, 5261
29286, 283, 4, 376, 5220, 305, 377, 5265, 5263
29287, 373, 5199, 400, 9, 5222, 5266, 423, 375
29288, 5199, 5200, 399, 400, 5224, 5267, 422, 5266
29289, 5200, 5201, 398, 399, 5226, 5268, 421, 5267
29290, 5201, 5202, 397, 398, 5228, 5269, 420, 5268
29291, 5202, 5203, 396, 397, 5230, 5270, 419, 5269
29292, 5203, 5204, 395, 396, 5232, 5271, 418, 5270
29293, 5204, 5205, 394, 395, 5234, 5272, 417, 5271
29294, 5205, 5206, 393, 394, 5236, 5273, 416, 5272
29295, 5206, 5207, 392, 393, 5238, 5274, 415, 5273
29296, 5207, 5208, 391, 392, 5240, 5275, 414, 5274
29297, 5208, 5209, 390, 391, 5242, 5276, 413, 5275
29298, 5209, 5210, 389, 390, 5244, 5277, 412, 5276
29299, 5210, 5211, 388, 389, 5246, 5278, 411, 5277
29300, 5211, 5212, 387, 388, 5248, 5279, 410, 5278
29301, 5212, 5213, 386, 387, 5250, 5280, 409, 5279
29302, 5213, 5214, 385, 386, 5252, 5281, 408, 5280
29303, 5214, 5215, 384, 385, 5254, 5282, 407, 5281
29304, 5215, 5216, 383, 384, 5256, 5283, 406, 5282
29305, 5216, 5217, 382, 383, 5258, 5284, 405, 5283
29306, 5217, 5218, 381, 382, 5260, 5285, 404, 5284
29307, 5218, 5219, 380, 381, 5262, 5286, 403, 5285
29308, 5219, 5220, 379, 380, 5264, 5287, 402, 5286
29309, 5220, 376, 10, 379, 5265, 378, 401, 5287
*ELEMENT, type=CPS8, ELSET=Surface8
29310, 7, 176, 5288, 424, 187, 5298, 5299, 425
29311, 176, 175, 5289, 5288, 186, 5300, 5301, 5298
29312, 175, 174, 5290, 5289, 185, 5302, 5303, 5300
29313, 174, 173, 5291, 5290, 184, 5304, 5305, 5302
29314, 173, 172, 5292, 5291, 183, 5306, 5307, 5304
29315, 172, 171, 5293, 5292, 182, 5308, 5309, 5306
29316, 171, 170, 5294, 5293, 181, 5310, 5311, 5308
29317, 170, 169, 5295, 5294, 180, 5312, 5313, 5310
29318, 169, 168, 5296, 5295, 179, 5314, 5315, 5312
29319, 168, 167, 5297, 5296, 178, 5316, 5317, 5314
29320, 167, 8, 373, 5297, 177, 374, 5318, 5316
29321, 424, 5288, 436, 11, 5299, 5319, 447, 426
29322, 5288, 5289, 435, 436, 5301, 5320, 446, 5319
29323, 5289, 5290, 434, 435, 5303, 5321, 445, 5320
29324, 5290, 5291, 433, 434, 5305, 5322, 444, 5321
29325, 5291, 5292, 432, 433, 5307, 5323, 443, 5322
29326, 5292, 5293, 431, 432, 5309, 5324, 442, 5323
29327, 5293, 5294, 430, 431, 5311, 5325, 441, 5324
29328, 5294, 5295, 429, 430, 5313, 5326, 440, 5325
29329, 5295, 5296, 428, 429, 5315, 5327, 439, 5326
29330, 5296, 5297, 427, 428, 5317, 5328, 438, 5327
29331, 5297, 373, 9, 427, 5318, 375, 437, 5328
*ELEMENT, type=CPS8, ELSET=Surface9
323, 7, 424, 5329, 349, 425, 5351, 5352, 372
324, 349, 5329, 5330, 348, 5352, 5353, 5354, 371
325, 348, 5330, 5331, 347, 5354, 5355, 5356, 370
326, 347, 5331, 5332, 346, 5356, 5357, 5358, 369
327, 346, 5332, 5333, 345, 5358, 5359, 5360, 368
328, 345, 5333, 5334, 344, 5360, 5361, 5362, 367
329, 344, 5334, 5335, 343, 5362, 5363, 5364, 366
330, 343, 5335, 5336, 342, 5364, 5365, 5366, 365
331, 342, 5336, 5337, 341, 5366, 5367, 5368, 364
332, 341, 5337, 5338, 340, 5368, 5369, 5370, 363
333, 340, 5338, 5339, 339, 5370, 5371, 5372, 362
334, 339, 5339, 5340, 338, 5372, 5373, 5374, 361
335, 338, 5340, 5341, 337, 5374, 5375, 5376, 360
336, 337, 5341, 5342, 336, 5376, 5377, 5378, 359
337, 336, 5342, 5343, 335, 5378, 5379, 5380, 358
338, 335, 5343, 5344, 334, 5380, 5381, 5382, 357
339, 334, 5344, 5345, 333, 5382, 5383, 5384, 356
340, 333, 5345, 5346, 332, 5384, 5385, 5386, 355
341, 332, 5346, 5347, 331, 5386, 5387, 5388, 354
342, 331, 5347, 5348, 330, 5388, 5389, 5390, 353
343, 330, 5348, 5349, 329, 5390, 5391, 5392, 352
344, 329, 5349, 5350, 328, 5392, 5393, 5394, 351
345, 328, 5350, 448, 3, 5394, 5395, 449, 350
346, 424, 11, 472, 5329, 426, 495, 5396, 5351
347, 5329, 472, 471, 5330, 5396, 494, 5397, 5353
348, 5330, 471, 470, 5331, 5397, 493, 5398, 5355
349, 5331, 470, 469, 5332, 5398, 492, 5399, 5357
350, 5332, 469, 468, 5333, 5399, 491, 5400, 5359
351, 5333, 468, 467, 5334, 5400, 490, 5401, 5361
352, 5334, 467, 466, 5335, 5401, 489, 5402, 5363
353, 5335, 466, 465, 5336, 5402, 488, 5403, 5365
354, 5336, 465, 464, 5337, 5403, 487, 5404, 5367
355, 5337, 464, 463, 5338, 5404, 486, 5405, 5369
356, 5338, 463, 462, 5339, 5405, 485, 5406, 5371
357, 5339, 462, 461, 5340, 5406, 484, 5407, 5373
358, 5340, 461, 460, 5341, 5407, 483, 5408, 5375
359, 5341, 460, 459, 5342, 5408, 482, 5409, 5377
360, 5342, 459, 458, 5343, 5409, 481, 5410, 5379
361, 5343, 458, 457, 5344, 5410, 480, 5411, 5381
362, 5344, 457, 456, 5345, 5411, 479, 5412, 5383
363, 5345, 456, 455, 5346, 5412, 478, 5413, 5385
364, 5346, 455, 454, 5347, 5413, 477, 5414, 5387
365, 5347, 454, 453, 5348, 5414, 476, 5415, 5389
366, 5348, 453, 452, 5349, 5415, 475, 5416, 5391
367, 5349, 452, 451, 5350, 5416, 474, 5417, 5393
368, 5350, 451, 12, 448, 5417, 473, 450, 5395
*ELEMENT, type=CPS8, ELSET=Surface10
29332, 3, 448, 5418, 124, 449, 5428, 5429, 135
29333, 124, 5418, 5419, 123, 5429, 5430, 5431, 134
29334, 123, 5419, 5420, 122, 5431, 5432, 5433, 133
29335, 122, 5420, 5421, 121, 5433, 5434, 5435, 132
29336, 121, 5421, 5422, 120, 5435, 5436, 5437, 131
29337, 120, 5422, 5423, 119, 5437, 5438, 5439, 130
29338, 119, 5423, 5424, 118, 5439, 5440, 5441, 129
29339, 118, 5424, 5425, 117, 5441, 5442, 5443, 128
29340, 117, 5425, 5426, 116, 5443, 5444, 5445, 127
29341, 116, 5426, 5427, 115, 5445, 5446, 5447, 126
29342, 115, 5427, 376, 4, 5447, 5448, 377, 125
29343, 448, 12, 505, 5418, 450, 516, 5449, 5428
29344, 5418, 505, 504, 5419, 5449, 515, 5450, 5430
29345, 5419, 504, 503, 5420, 5450, 514, 5451, 5432
29346, 5420, 503, 502, 5421, 5451, 513, 5452, 5434
29347, 5421, 502, 501, 5422, 5452, 512, 5453, 5436
29348, 5422, 501, 500, 5423, 5453, 511, 5454, 5438
29349, 5423, 500, 499, 5424, 5454, 510, 5455, 5440
29350, 5424, 499, 498, 5425, 5455, 509, 5456, 5442
29351, 5425, 498, 497, 5426, 5456, 508, 5457, 5444
29352, 5426, 497, 496, 5427, 5457, 507, 5458, 5446
29353, 5427, 496, 10, 376, 5458, 506, 378, 5448
*ELEMENT, type=CPS8, ELSET=Surface11
29354, 10, 496, 5459, 379, 506, 5679, 5680, 401
29355, 496, 497, 5460, 5459, 507, 5681, 5682, 5679
29356, 497, 498, 5461, 5460, 508, 5683, 5684, 5681
29357, 498, 499, 5462, 5461, 509, 5685, 5686, 5683
29358, 499, 500, 5463, 5462, 510, 5687, 5688, 5685
29359, 500, 501, 5464, 5463, 511, 5689, 5690, 5687
29360, 501, 502, 5465, 5464, 512, 5691, 5692, 5689
29361, 502, 503, 5466, 5465, 513, 5693, 5694, 5691
29362, 503, 504, 5467, 5466, 514, 5695, 5696, 5693
29363, 504, 505, 5468, 5467, 515, 5697, 5698, 5695
29364, 505, 12, 451, 5468, 516, 473, 5699, 5697
29365, 379, 5459, 5469, 380, 5680, 5700, 5701, 402
29366, 5459, 5460, 5470, 5469, 5682, 5702, 5703, 5700
29367, 5460, 5461, 5471, 5470, 5684, 5704, 5705, 5702
29368, 5461, 5462, 5472, 5471, 5686, 5706, 5707, 5704
29369, 5462, 5463, 5473, 5472, 5688, 5708, 5709, 5706
29370, 5463, 5464, 5474, 5473, 5690, 5710, 5711, 5708
29371, 5464, 5465, 5475, 5474, 5692, 5712, 5713, 5710
29372, 5465, 5466, 5476, 5475, 5694, 5714, 5715, 5712
29373, 5466, 5467, 5477, 5476, 5696, 5716, 5717, 5714
29374, 5467, 5468, 5478, 5477, 5698, 5718, 5719, 5716
29375, 5468, 451, 452, 5478, 5699, 474, 5720, 5718
29376, 380, 5469, 5479, 381, 5701, 5721, 5722, 403
29377, 5469, 5470, 5480, 5479, 5703, 5723, 5724, 5721
29378, 5470, 5471, 5481, 5480, 5705, 5725, 5726, 5723
29379, 5471, 5472, 5482, 5481, 5707, 5727, 5728, 5725
29380, 5472, 5473, 5483, 5482, 5709, 5729, 5730, 5727
29381, 5473, 5474, 5484, 5483, 5711, 5731, 5732, 5729
29382, 5474, 5475, 5485, 5484, 5713, 5733, 5734, 5731
29383, 5475, 5476, 5486, 5485, 5715, 5735, 5736, 5733
29384, 5476, 5477, 5487, 5486, 5717, 5737, 5738, 5735
29385, 5477, 5478, 5488, 5487, 5719, 5739, 5740, 5737
29386, 5478, 452, 453, 5488, 5720, 475, 5741, 5739
29387, 381, 5479, 5489, 382, 5722, 5742, 5743, 404
29388, 5479, 5480, 5490, 5489, 5724, 5744, 5745, 5742
29389, 5480, 5481, 5491, 5490, 5726, 5746, 5747, 5744
29390, 5481, 5482, 5492, 5491, 5728, 5748, 5749, 5746
29391, 5482, 5483, 5493, 5492, 5730, 5750, 5751, 5748
29392, 5483, 5484, 5494, 5493, 5732, 5752, 5753, 5750
29393, 5484, 5485, 5495, 5494, 5734, 5754, 5755, 5752
29394, 5485, 5486, 5496, 5495, 5736, 5756, 5757, 5754
29395, 5486, 5487, 5497, 5496, 5738, 5758, 5759, 5756
29396, 5487, 5488, 5498, 5497, 5740, 5760, 5761, 5758
29397, 5488, 453, 454, 5498, 5741, 476, 5762, 5760
29398, 382, 5489, 5499, 383, 5743, 5763, 5764, 405
29399, 5489, 5490, 5500, 5499, 5745, 5765, 5766, 5763
29400, 5490, 5491, 5501, 5500, 5747, 5767, 5768, 5765
29401, 5491, 5492, 5502, 5501, 5749, 5769, 5770, 5767
29402, 5492, 5493, 5503, 5502, 5751, 5771, 5772, 5769
29403, 5493, 5494, 5504, 5503, 5753, 5773, 5774, 5771
29404, 5494, 5495, 5505, 5504, 5755, 5775, 5776, 5773
29405, 5495, 5496, 5506, 5505, 5757, 5777, 5778, 5775
29406, 5496, 5497, 5507, 5506, 5759, 5779, 5780, 5777
29407, 5497, 5498, 5508, 5507, 5761, 5781, 5782, 5779
29408, 5498, 454, 455, 5508, 5762, 477, 5783, 5781
29409, 383, 5499, 5509, 384, 5764, 5784, 5785, 406
29410, 5499, 5500, 5510, 5509, 5766, 5786, 5787, 5784
29411, 5500, 5501, 5511, 5510, 5768, 5788, 5789, 5786
29412, 5501, 5502, 5512, 5511, 5770, 5790, 5791, 5788
29413, 5502, 5503, 5513, 5512, 5772, 5792, 5793, 5790
29414, 5503, 5504, 5514, 5513, 5774, 5794, 5795, 5792
29415, 5504, 5505, 5515, 5514, 5776, 5796, 5797, 5794
29416, 5505, 5506, 5516, 5515, 5778, 5798, 5799, 5796
29417, 5506, 5507, 5517, 5516, 5780, 5800, 5801, 5798
29418, 5507, 5508, 5518, 5517, 5782, 5802, 5803, 5800
29419, 5508, 455, 456, 5518, 5783, 478, 5804, 5802
29420, 384, 5509, 5519, 385, 5785, 5805, 5806, 407
29421, 5509, 5510, 5520, 5519, 5787, 5807, 5808, 5805
29422, 5510, 5511, 5521, 5520, 5789, 5809, 5810, 5807
29423, 5511, 5512, 5522, 5521, 5791, 5811, 5812, 5809
29424, 5512, 5513, 5523, 5522, 5793, 5813, 5814, 5811
29425, 5513, 5514, 5524, 5523, 5795, 5815, 5816, 5813
29426, 5514, 5515, 5525, 5524, 5797, 5817, 5818, 5815
29427, 5515, 5516, 5526, 5525, 5799, 5819, 5820, 5817
29428, 5516, 5517, 5527, 5526, 5801, 5821, 5822, 5819
29429, 5517, 5518, 5528, 5527, 5803, 5823, 5824, 5821
29430, 5518, 456, 457, 5528, 5804, 479, 5825, 5823
29431, 385, 5519, 5529, 386, 5806, 5826, 5827, 408
29432, 5519, 5520, 5530, 5529, 5808, 5828, 5829, 5826
29433, 5520, 5521, 5531, 5530, 5810, 5830, 5831, 5828
29434, 5521, 5522, 5532, 5531, 5812, 5832, 5833, 5830
29435, 5522, 5523, 5533, 5532, 5814, 5834, 5835, 5832
29436, 5523, 5524, 5534, 5533, 5816, 5836, 5837, 5834
29437, 5524, 5525, 5535, 5534, 5818, 5838, 5839, 5836
29438, 5525, 5526, 5536, 5535, 5820, 5840, 5841, 5838
29439, 5526, 5527, 5537, 5536, 5822, 5842, 5843, 5840
29440, 5527, 5528, 5538, 5537, 5824, 5844, 5845, 5842
29441, 5528, 457, 458, 5538, 5825, 480, 5846, 5844
29442, 386, 5529, 5539, 387, 5827, 5847, 5848, 409
29443, 5529, 5530, 5540, 5539, 5829, 5849, 5850, 5847
29444, 5530, 5531, 5541, 5540, 5831, 5851, 5852, 5849
29445, 5531, 5532, 5542, 5541, 5833, 5853, 5854, 5851
29446, 5532, 5533, 5543, 5542, 5835, 5855, 5856, 5853
29447, 5533, 5534, 5544, 5543, 5837, 5857, 5858, 5855
29448, 5534, 5535, 5545, 5544, 5839, 5859, 5860, 5857
29449, 5535, 5536, 5546, 5545, 5841, 5861, 5862, 5859
29450, 5536, 5537, 5547, 5546, 5843, 5863, 5864, 5861
29451, 5537, 5538, 5548, 5547, 5845, 5865, 5866, 5863
29452, 5538, 458, 459, 5548, 5846, 481, 5867, 5865
29453, 387, 5539, 5549, 388, 5848, 5868, 5869, 410
29454, 5539, 5540, 5550, 5549, 5850, 5870, 5871, 5868
29455, 5540, 5541, 5551, 5550, 5852, 5872, 5873, 5870
29456, 5541, 5542, 5552, 5551, 5854, 5874, 5875, 5872
29457, 5542, 5543, 5553, 5552, 5856, 5876, 5877, 5874
29458, 5543, 5544, 5554, 5553, 5858, 5878, 5879, 5876
29459, 5544, 5545, 5555, 5554, 5860, 5880, 5881, 5878
29460, 5545, 5546, 5556, 5555, 5862, 5882, 5883, 5880
29461, 5546, 5547, 5557, 5556, 5864, 5884, 5885, 5882
29462, 5547, 5548, 5558, 5557, 5866, 5886, 5887, 5884
29463, 5548, 459, 460, 5558, 5867, 482, 5888, 5886
29464, 388, 5549, 5559, 389, 5869, 5889, 5890, 411
29465, 5549, 5550, 5560, 5559, 5871, 5891, 5892, 5889
29466, 5550, 5551, 5561, 5560, 5873, 5893, 5894, 5891
29467, 5551, 5552, 5562, 5561, 5875, 5895, 5896, 5893
29468, 5552, 5553, 5563, 5562, 5877, 5897, 5898, 5895
29469, 5553, 5554, 5564, 5563, 5879, 5899, 5900, 5897
29470, 5554, 5555, 5565, 5564, 5881, 5901, 5902, 5899
29471, 5555, 5556, 5566, 5565, 5883, 5903, 5904, 5901
29472, 5556, 5557, 5567, 5566, 5885, 5905, 5906, 5903
29473, 5557, 5558, 5568, 5567, 5887, 5907, 5908, 5905
29474, 5558, 460, 461, 5568, 5888, 483, 5909, 5907
29475, 389, 5559, 5569, 390, 5890, 5910, 5911, 412
29476, 5559, 5560, 5570, 5569, 5892, 5912, 5913, 5910
29477, 5560, 5561, 5571, 5570, 5894, 5914, 5915, 5912
29478, 5561, 5562, 5572, 5571, 5896, 5916, 5917, 5914
29479, 5562, 5563, 5573, 5572, 5898, 5918, 5919, 5916
29480, 5563, 5564, 5574, 5573, 5900, 5920, 5921, 5918
29481, 5564, 5565, 5575, 5574, 5902, 5922, 5923, 5920
29482, 5565, 5566, 5576, 5575, 5904, 5924, 5925, 5922
29483, 5566, 5567, 5577, 5576, 5906, 5926, 5927, 5924
29484, 5567, 5568, 5578, 5577, 5908, 5928, 5929, 5926
29485, 5568, 461, 462, 5578, 5909, 484, 5930, 5928
29486, 390, 5569, 5579, 391, 5911, 5931, 5932, 413
29487, 5569, 5570, 5580, 5579, 5913, 5933, 5934, 5931
29488, 5570, 5571, 5581, 5580, 5915, 5935, 5936, 5933
29489, 5571, 5572, 5582, 5581, 5917, 5937, 5938, 5935
29490, 5572, 5573, 5583, 5582, 5919, 5939, 5940, 5937
29491, 5573, 5574, 5584, 5583, 5921, 5941, 5942, 5939
29492, 5574, 5575, 5585, 5584, 5923, 5943, 5944, 5941
29493, 5575, 5576, 5586, 5585, 5925, 5945, 5946, 5943
29494, 5576, 5577, 5587, 5586, 5927, 5947, 5948, 5945
29495, 5577, 5578, 5588, 5587, 5929, 5949, 5950, 5947
29496, 5578, 462, 463, 5588, 5930, 485, 5951, 5949
29497, 391, 5579, 5589, 392, 5932, 5952, 5953, 414
29498, 5579, 5580, 5590, 5589, 5934, 5954, 5955, 5952
29499, 5580, 5581, 5591, 5590, 5936, 5956, 5957, 5954
29500, 5581, 5582, 5592, 5591, 5938, 5958, 5959, 5956
29501, 5582, 5583, 5593, 5592, 5940, 5960, 5961, 5958
29502, 5583, 5584, 5594, 5593, 5942, 5962, 5963, 5960
29503, 5584, 5585, 5595, 5594, 5944, 5964, 5965, 5962
29504, 5585, 5586, 5596, 5595, 5946, 5966, 5967, 5964
29505, 5586, 5587, 5597, 5596, 5948, 5968, 5969, 5966
29506, 5587, 5588, 5598, 5597, 5950, 5970, 5971, 5968
29507, 5588, 463, 464, 5598, 5951, 486, 5972, 5970
29508, 392, 5589, 5599, 393, 5953, 5973, 5974, 415
29509, 5589, 5590, 5600, 5599, 5955, 5975, 5976, 5973
29510, 5590, 5591, 5601, 5600, 5957, 5977, 5978, 5975
29511, 5591, 5592, 5602, 5601, 5959, 5979, 5980, 5977
29512, 5592, 5593, 5603, 5602, 5961, 5981, 5982, 5979
29513, 5593, 5594, 5604, 5603, 5963, 5983, 5984, 5981
29514, 5594, 5595, 5605, 5604, 5965, 5985, 5986, 5983
29515, 5595, 5596, 5606, 5605, 5967, 5987, 5988, 5985
29516, 5596, 5597, 5607, 5606, 5969, 5989, 5990, 5987
29517, 5597, 5598, 5608, 5607, 5971, 5991, 5992, 5989
29518, 5598, 464, 465, 5608, 5972, 487, 5993, 5991
29519, 393, 5599, 5609, 394, 5974, 5994, 5995, 416
29520, 5599, 5600, 5610, 5609, 5976, 5996, 5997, 5994
29521, 5600, 5601, 5611, 5610, 5978, 5998, 5999, 5996
29522, 5601, 5602, 5612, 5611, 5980, 6000, 6001, 5998
29523, 5602, 5603, 5613, 5612, 5982, 6002, 6003, 6000
29524, 5603, 5604, 5614, 5613, 5984, 6004, 6005, 6002
29525, 5604, 5605, 5615, 5614, 5986, 6006, 6007, 6004
29526, 5605, 5606, 5616, 5615, 5988, 6008, 6009, 6006
29527, 5606, 5607, 5617, 5616, 5990, 6010, 6011, 6008
29528, 5607, 5608, 5618, 5617, 5992, 6012, 6013, 6010
29529, 5608, 465, 466, 5618, 5993, 488, 6014, 6012
29530, 394, 5609, 5619, 395, 5995, 6015, 6016, 417
29531, 5609, 5610, 5620, 5619, 5997, 6017, 6018, 6015
29532, 5610, 5611, 5621, 5620, 5999, 6019, 6020, 6017
29533, 5611, 5612, 5622, 5621, 6001, 6021, 6022, 6019
29534, 5612, 5613, 5623, 5622, 6003, 6023, 6024, 6021
29535, 5613, 5614, 5624, 5623, 6005, 6025, 6026, 6023
29536, 5614, 5615, 5625, 5624, 6007, 6027, 6028, 6025
29537, 5615, 5616, 5626, 5625, 6009, 6029, 6030, 6027
29538, 5616, 5617, 5627, 5626, 6011, 6031, 6032, 6029
29539, 5617, 5618, 5628, 5627, 6013, 6033, 6034, 6031
29540, 5618, 466, 467, 5628, 6014, 489, 6035, 6033
29541, 395, 5619, 5629, 396, 6016, 6036, 6037, 418
29542, 5619, 5620, 5630, 5629, 6018, 6038, 6039, 6036
29543, 5620, 5621, 5631, 5630, 6020, 6040, 6041, 6038
29544, 5621, 5622, 5632, 5631, 6022, 6042, 6043, 6040
29545, 5622, 5623, 5633, 5632, 6024, 6044, 6045, 6042
29546, 5623, 5624, 5634, 5633, 6026, 6046, 6047, 6044
29547, 5624, 5625, 5635, 5634, 6028, 6048, 6049, 6046
29548, 5625, 5626, 5636, 5635, 6030, 6050, 6051, 6048
29549, 5626, 5627, 5637, 5636, 6032, 6052, 6053, 6050
29550, 5627, 5628, 5638, 5637, 6034, 6054, 6055, 6052
29551, 5628, 467, 468, 5638, 6035, 490, 6056, 6054
29552, 396, 5629, 5639, 397, 6037, 6057, 6058, 419
29553, 5629, 5630, 5640, 5639, 6039, 6059, 6060, 6057
29554, 5630, 5631, 5641, 5640, 6041, 6061, 6062, 6059
29555, 5631, 5632, 5642, 5641, 6043, 6063, 6064, 6061
29556, 5632, 5633, 5643, 5642, 6045, 6065, 6066, 6063
29557, 5633, 5634, 5644, 5643, 6047, 6067, 6068, 6065
29558, 5634, 5635, 5645, 5644, 6049, 6069, 6070, 6067
29559, 5635, 5636, 5646, 5645, 6051, 6071, 6072, 6069
29560, 5636, 5637, 5647, 5646, 6053, 6073, 6074, 6071
29561, 5637, 5638, 5648, 5647, 6055, 6075, 6076, 6073
29562, 5638, 468, 469, 5648, 6056, 491, 6077, 6075
29563, 397, 5639, 5649, 398, 6058, 6078, 6079, 420
29564, 5639, 5640, 5650, 5649, 6060, 6080, 6081, 6078
29565, 5640, 5641, 5651, 5650, 6062, 6082, 6083, 6080
29566, 5641, 5642, 5652, 5651, 6064, 6084, 6085, 6082
29567, 5642, 5643, 5653, 5652, 6066, 6086, 6087, 6084
29568, 5643, 5644, 5654, 5653, 6068, 6088, 6089, 6086
29569, 5644, 5645, 5655, 5654, 6070, 6090, 6091, 6088
29570, 5645, 5646, 5656, 5655, 6072, 6092, 6093, 6090
29571, 5646, 5647, 5657, 5656, 6074, 6094, 6095, 6092
29572, 5647, 5648, 5658, 5657, 6076, 6096, 6097, 6094
29573, 5648, 469, 470, 5658, 6077, 492, 6098, 6096
29574, 398, 5649, 5659, 399, 6079, 6099, 6100, 421
29575, 5649, 5650, 5660, 5659, 6081, 6101, 6102, 6099
29576, 5650, 5651, 5661, 5660, 6083, 6103, 6104, 6101
29577, 5651, 5652, 5662, 5661, 6085, 6105, 6106, 6103
29578, 5652, 5653, 5663, 5662, 6087, 6107, 6108, 6105
29579, 5653, 5654, 5664, 5663, 6089, 6109, 6110, 6107
29580, 5654, 5655, 5665, 5664, 6091, 6111, 6112, 6109
29581, 5655, 5656, 5666, 5665, 6093, 6113, 6114, 6111
29582, 5656, 5657, 5667, 5666, 6095, 6115, 6116, 6113
29583, 5657, 5658, 5668, 5667, 6097, 6117, 6118, 6115
29584, 5658, 470, 471, 5668, 6098, 493, 6119, 6117
29585, 399, 5659, 5669, 400, 6100, 6120, 6121, 422
29586, 5659, 5660, 5670, 5669, 6102, 6122, 6123, 6120
29587, 5660, 5661, 5671, 5670, 6104, 6124, 6125, 6122
29588, 5661, 5662, 5672, 5671, 6106, 6126, 6127, 6124
29589, 5662, 5663, 5673, 5672, 6108, 6128, 6129, 6126
29590, 5663, 5664, 5674, 5673, 6110, 6130, 6131, 6128
29591, 5664, 5665, 5675, 5674, 6112, 6132, 6133, 6130
29592, 5665, 5666, 5676, 5675, 6114, 6134, 6135, 6132
29593, 5666, 5667, 5677, 5676, 6116, 6136, 6137, 6134
29594, 5667, 5668, 5678, 5677, 6118, 6138, 6139, 6136
29595, 5668, 471, 472, 5678, 6119, 494, 6140, 6138
29596, 400, 5669, 427, 9, 6121, 6141, 437, 423
29597, 5669, 5670, 428, 427, 6123, 6142, 438, 6141
29598, 5670, 5671, 429, 428, 6125, 6143, 439, 6142
29599, 5671, 5672, 430, 429, 6127, 6144, 440, 6143
29600, 5672, 5673, 431, 430, 6129, 6145, 441, 6144
29601, 5673, 5674, 432, 431, 6131, 6146, 442, 6145
29602, 5674, 5675, 433, 432, 6133, 6147, 443, 6146
29603, 5675, 5676, 434, 433, 6135, 6148, 444, 6147
29604, 5676, 5677, 435, 434, 6137, 6149, 445, 6148
29605, 5677, 5678, 436, 435, 6139, 6150, 446, 6149
29606, 5678, 472, 11, 436, 6140, 495, 447, 6150
*ELEMENT, type=CPS8, ELSET=Surface12
29607, 9, 400, 6151, 517, 423, 6635, 6636, 539
29608, 400, 399, 6152, 6151, 422, 6637, 6638, 6635
29609, 399, 398, 6153, 6152, 421, 6639, 6640, 6637
29610, 398, 397, 6154, 6153, 420, 6641, 6642, 6639
29611, 397, 396, 6155, 6154, 419, 6643, 6644, 6641
29612, 396, 395, 6156, 6155, 418, 6645, 6646, 6643
29613, 395, 394, 6157, 6156, 417, 6647, 6648, 6645
29614, 394, 393, 6158, 6157, 416, 6649, 6650, 6647
29615, 393, 392, 6159, 6158, 415, 6651, 6652, 6649
29616, 392, 391, 6160, 6159, 414, 6653, 6654, 6651
29617, 391, 390, 6161, 6160, 413, 6655, 6656, 6653
29618, 390, 389, 6162, 6161, 412, 6657, 6658, 6655
29619, 389, 388, 6163, 6162, 411, 6659, 6660, 6657
29620, 388, 387, 6164, 6163, 410, 6661, 6662, 6659
29621, 387, 386, 6165, 6164, 409, 6663, 6664, 6661
29622, 386, 385, 6166, 6165, 408, 6665, 6666, 6663
29623, 385, 384, 6167, 6166, 407, 6667, 6668, 6665
29624, 384, 383, 6168, 6167, 406, 6669, 6670, 6667
29625, 383, 382, 6169, 6168, 405, 6671, 6672, 6669
29626, 382, 381, 6170, 6169, 404, 6673, 6674, 6671
29627, 381, 380, 6171, 6170, 403, 6675, 6676, 6673
29628, 380, 379, 6172, 6171, 402, 6677, 6678, 6675
29629, 379, 10, 562, 6172, 401, 584, 6679, 6677
29630, 517, 6151, 6173, 518, 6636, 6680, 6681, 540
29631, 6151, 6152, 6174, 6173, 6638, 6682, 6683, 6680
29632, 6152, 6153, 6175, 6174, 6640, 6684, 6685, 6682
29633, 6153, 6154, 6176, 6175, 6642, 6686, 6687, 6684
29634, 6154, 6155, 6177, 6176, 6644, 6688, 6689, 6686
29635, 6155, 6156, 6178, 6177, 6646, 6690, 6691, 6688
29636, 6156, 6157, 6179, 6178, 6648, 6692, 6693, 6690
29637, 6157, 6158, 6180, 6179, 6650, 6694, 6695, 6692
29638, 6158, 6159, 6181, 6180, 6652, 6696, 6697, 6694
29639, 6159, 6160, 6182, 6181, 6654, 6698, 6699, 6696
29640, 6160, 6161, 6183, 6182, 6656, 6700, 6701, 6698
29641, 6161, 6162, 6184, 6183, 6658, 6702, 6703, 6700
29642, 6162, 6163, 6185, 6184, 6660, 6704, 6705, 6702
29643, 6163, 6164, 6186, 6185, 6662, 6706, 6707, 6704
29644, 6164, 6165, 6187, 6186, 6664, 6708, 6709, 6706
29645, 6165, 6166, 6188, 6187, 6666, 6710, 6711, 6708
29646, 6166, 6167, 6189, 6188, 6668, 6712, 6713, 6710
29647, 6167, 6168, 6190, 6189, 6670, 6714, 6715, 6712
29648, 6168, 6169, 6191, 6190, 6672, 6716, 6717, 6714
29649, 6169, 6170, 6192, 6191, 6674, 6718, 6719, 6716
29650, 6170, 6171, 6193, 6192, 6676, 6720, 6721, 6718
29651, 6171, 6172, 6194, 6193, 6678, 6722, 6723, 6720
29652, 6172, 562, 563, 6194, 6679, 585, 6724, 6722
29653, 518, 6173, 6195, 519, 6681, 6725, 6726, 541
29654, 6173, 6174, 6196, 6195, 6683, 6727, 6728, 6725
29655, 6174, 6175, 6197, 6196, 6685, 6729, 6730, 6727
29656, 6175, 6176, 6198, 6197, 6687, 6731, 6732, 6729
29657, 6176, 6177, 6199, 6198, 6689, 6733, 6734, 6731
29658, 6177, 6178, 6200, 6199, 6691, 6735, 6736, 6733
29659, 6178, 6179, 6201, 6200, 6693, 6737, 6738, 6735
29660, 6179, 6180, 6202, 6201, 6695, 6739, 6740, 6737
29661, 6180, 6181, 6203, 6202, 6697, 6741, 6742, 6739
29662, 6181, 6182, 6204, 6203, 6699, 6743, 6744, 6741
29663, 6182, 6183, 6205, 6204, 6701, 6745, 6746, 6743
29664, 6183, 6184, 6206, 6205, 6703, 6747, 6748, 6745
29665, 6184, 6185, 6207, 6206, 6705, 6749, 6750, 6747
29666, 6185, 6186, 6208, 6207, 6707, 6751, 6752, 6749
29667, 6186, 6187, 6209, 6208, 6709, 6753, 6754, 6751
29668, 6187, 6188, 6210, 6209, 6711, 6755, 6756, 6753
29669, 6188, 6189, 6211, 6210, 6713, 6757, 6758, 6755
29670, 6189, 6190, 6212, 6211, 6715, 6759, 6760, 6757
29671, 6190, 6191, 6213, 6212, 6717, 6761, 6762, 6759
29672, 6191, 6192, 6214, 6213, 6719, 6763, 6764, 6761
29673, 6192, 6193, 6215, 6214, 6721, 6765, 6766, 6763
29674, 6193, 6194, 6216, 6215, 6723, 6767, 6768, 6765
29675, 6194, 563, 564, 6216, 6724, 586, 6769, 6767
29676, 519, 6195, 6217, 520, 6726, 6770, 6771, 542
29677, 6195, 6196, 6218, 6217, 6728, 6772, 6773, 6770
29678, 6196, 6197, 6219, 6218, 6730, 6774, 6775, 6772
29679, 6197, 6198, 6220, 6219, 6732, 6776, 6777, 6774
29680, 6198, 6199, 6221, 6220, 6734, 6778, 6779, 6776
29681, 6199, 6200, 6222, 6221, 6736, 6780, 6781, 6778
29682, 6200, 6201, 6223, 6222, 6738, 6782, 6783, 6780
29683, 6201, 6202, 6224, 6223, 6740, 6784, 6785, 6782
29684, 6202, 6203, 6225, 6224, 6742, 6786, 6787, 6784
29685, 6203, 6204, 6226, 6225, 6744, 6788, 6789, 6786
29686, 6204, 6205, 6227, 6226, 6746, 6790, 6791, 6788
29687, 6205, 6206, 6228, 6227, 6748, 6792, 6793, 6790
29688, 6206, 6207, 6229, 6228, 6750, 6794, 6795, 6792
29689, 6207, 6208, 6230, 6229, 6752, 6796, 6797, 6794
29690, 6208, 6209, 6231, 6230, 6754, 6798, 6799, 6796
29691, 6209, 6210, 6232, 6231, 6756, 6800, 6801, 6798
29692, 6210, 6211, 6233, 6232, 6758, 6802, 6803, 6800
29693, 6211, 6212, 6234, 6233, 6760, 6804, 6805, 6802
29694, 6212, 6213, 6235, 6234, 6762, 6806, 6807, 6804
29695, 6213, 6214, 6236, 6235, 6764, 6808, 6809, 6806
29696, 6214, 6215, 6237, 6236, 6766, 6810, 6811, 6808
29697, 6215, 6216, 6238, 6237, 6768, 6812, 6813, 6810
29698, 6216, 564, 565, 6238, 6769, 587, 6814, 6812
29699, 520, 6217, 6239, 521, 6771, 6815, 6816, 543
29700, 6217, 6218, 6240, 6239, 6773, 6817, 6818, 6815
29701, 6218, 6219, 6241, 6240, 6775, 6819, 6820, 6817
29702, 6219, 6220, 6242, 6241, 6777, 6821, 6822, 6819
29703, 6220, 6221, 6243, 6242, 6779, 6823, 6824, 6821
29704, 6221, 6222, 6244, 6243, 6781, 6825, 6826, 6823
29705, 6222, 6223, 6245, 6244, 6783, 6827, 6828, 6825
29706, 6223, 6224, 6246, 6245, 6785, 6829, 6830, 6827
29707, 6224, 6225, 6247, 6246, 6787, 6831, 6832, 6829
29708, 6225, 6226, 6248, 6247, 6789, 6833, 6834, 6831
29709, 6226, 6227, 6249, 6248, 6791, 6835, 6836, 6833
29710, 6227, 6228, 6250, 6249, 6793, 6837, 6838, 6835
29711, 6228, 6229, 6251, 6250, 6795, 6839, 6840, 6837
29712, 6229, 6230, 6252, 6251, 6797, 6841, 6842, 6839
29713, 6230, 6231, 6253, 6252, 6799, 6843, 6844, 6841
29714, 6231, 6232, 6254, 6253, 6801, 6845, 6846, 6843
29715, 6232, 6233, 6255, 6254, 6803, 6847, 6848, 6845
29716, 6233, 6234, 6256, 6255, 6805, 6849, 6850, 6847
29717, 6234, 6235, 6257, 6256, 6807, 6851, 6852, 6849
29718, 6235, 6236, 6258, 6257, 6809, 6853, 6854, 6851
29719, 6236, 6237, 6259, 6258, 6811, 6855, 6856, 6853
29720, 6237, 6238, 6260, 6259, 6813, 6857, 6858, 6855
29721, 6238, 565, 566, 6260, 6814, 588, 6859, 6857
29722, 521, 6239, 6261, 522, 6816, 6860, 6861, 544
29723, 6239, 6240, 6262, 6261, 6818, 6862, 6863, 6860
29724, 6240, 6241, 6263, 6262, 6820, 6864, 6865, 6862
29725, 6241, 6242, 6264, 6263, 6822, 6866, 6867, 6864
29726, 6242, 6243, 6265, 6264, 6824, 6868, 6869, 6866
29727, 6243, 6244, 6266, 6265, 6826, 6870, 6871, 6868
29728, 6244, 6245, 6267, 6266, 6828, 6872, 6873, 6870
29729, 6245, 6246, 6268, 6267, 6830, 6874, 6875, 6872
29730, 6246, 6247, 6269, 6268, 6832, 6876, 6877, 6874
29731, 6247, 6248, 6270, 6269, 6834, 6878, 6879, 6876
29732, 6248, 6249, 6271, 6270, 6836, 6880, 6881, 6878
29733, 6249, 6250, 6272, 6271, 6838, 6882, 6883, 6880
29734, 6250, 6251, 6273, 6272, 6840, 6884, 6885, 6882
29735, 6251, 6252, 6274, 6273, 6842, 6886, 6887, 6884
29736, 6252, 6253, 6275, 6274, 6844, 6888, 6889, 6886
29737, 6253, 6254, 6276, 6275, 6846, 6890, 6891, 6888
29738, 6254, 6255, 6277, 6276, 6848, 6892, 6893, 6890
29739, 6255, 6256, 6278, 6277, 6850, 6894, 6895, 6892
29740, 6256, 6257, 6279, 6278, 6852, 6896, 6897, 6894
29741, 6257, 6258, 6280, 6279, 6854, 6898, 6899, 6896
29742, 6258, 6259, 6281, 6280, 6856, 6900, 6901, 6898
29743, 6259, 6260, 6282, 6281, 6858, 6902, 6903, 6900
29744, 6260, 566, 567, 6282, 6859, 589, 6904, 6902
29745, 522, 6261, 6283, 523, 6861, 6905, 6906, 545
29746, 6261, 6262, 6284, 6283, 6863, 6907, 6908, 6905
29747, 6262, 6263, 6285, 6284, 6865, 6909, 6910, 6907
29748, 6263, 6264, 6286, 6285, 6867, 6911, 6912, 6909
29749, 6264, 6265, 6287, 6286, 6869, 6913, 6914, 6911
29750, 6265, 6266, 6288, 6287, 6871, 6915, 6916, 6913
29751, 6266, 6267, 6289, 6288, 6873, 6917, 6918, 6915
29752, 6267, 6268, 6290, 6289, 6875, 6919, 6920, 6917
29753, 6268, 6269, 6291, 6290, 6877, 6921, 6922, 6919
29754, 6269, 6270, 6292, 6291, 6879, 6923, 6924, 6921
29755, 6270, 6271, 6293, 6292, 6881, 6925, 6926, 6923
29756, 6271, 6272, 6294, 6293, 6883, 6927, 6928, 6925
29757, 6272, 6273, 6295, 6294, 6885, 6929, 6930, 6927
29758, 6273, 6274, 6296, 6295, 6887, 6931, 6932, 6929
29759, 6274, 6275, 6297, 6296, 6889, 6933, 6934, 6931
29760, 6275, 6276, 6298, 6297, 6891, 6935, 6936, 6933
29761, 6276, 6277, 6299, 6298, 6893, 6937, 6938, 6935
29762, 6277, 6278, 6300, 6299, 6895, 6939, 6940, 6937
29763, 6278, 6279, 6301, 6300, 6897, 6941, 6942, 6939
29764, 6279, 6280, 6302, 6301, 6899, 6943, 6944, 6941
29765, 6280, 6281, 6303, 6302, 6901, 6945, 6946, 6943
29766, 6281, 6282, 6304, 6303, 6903, 6947, 6948, 6945
29767, 6282, 567, 568, 6304, 6904, 590, 6949, 6947
29768, 523, 6283, 6305, 524, 6906, 6950, 6951, 546
29769, 6283, 6284, 6306, 6305, 6908, 6952, 6953, 6950
29770, 6284, 6285, 6307, 6306, 6910, 6954, 6955, 6952
29771, 6285, 6286, 6308, 6307, 6912, 6956, 6957, 6954
29772, 6286, 6287, 6309, 6308, 6914, 6958, 6959, 6956
29773, 6287, 6288, 6310, 6309, 6916, 6960, 6961, 6958
29774, 6288, 6289, 6311, 6310, 6918, 6962, 6963, 6960
29775, 6289, 6290, 6312, 6311, 6920, 6964, 6965, 6962
29776, 6290, 6291, 6313, 6312, 6922, 6966, 6967, 6964
29777, 6291, 6292, 6314, 6313, 6924, 6968, 6969, 6966
29778, 6292, 6293, 6315, 6314, 6926, 6970, 6971, 6968
29779, 6293, 6294, 6316, 6315, 6928, 6972, 6973, 6970
29780, 6294, 6295, 6317, 6316, 6930, 6974, 6975, 6972
29781, 6295, 6296, 6318, 6317, 6932, 6976, 6977, 6974
29782, 6296, 6297, 6319, 6318, 6934, 6978, 6979, 6976
29783, 6297, 6298, 6320, 6319, 6936, 6980, 6981, 6978
29784, 6298, 6299, 6321, 6320, 6938, 6982, 6983, 6980
29785, 6299, 6300, 6322, 6321, 6940, 6984, 6985, 6982
29786, 6300, 6301, 6323, 6322, 6942, 6986, 6987, 6984
29787, 6301, 6302, 6324, 6323, 6944, 6988, 6989, 6986
29788, 6302, 6303, 6325, 6324, 6946, 6990, 6991, 6988
29789, 6303, 6304, 6326, 6325, 6948, 6992, 6993, 6990
29790, 6304, 568, 569, 6326, 6949, 591, 6994, 6992
29791, 524, 6305, 6327, 525, 6951, 6995, 6996, 547
29792, 6305, 6306, 6328, 6327, 6953, 6997, 6998, 6995
29793, 6306, 6307, 6329, 6328, 6955, 6999, 7000, 6997
29794, 6307, 6308, 6330, 6329, 6957, 7001, 7002, 6999
29795, 6308, 6309, 6331, 6330, 6959, 7003, 7004, 7001
29796, 6309, 6310, 6332, 6331, 6961, 7005, 7006, 7003
29797, 6310, 6311, 6333, 6332, 6963, 7007, 7008, 7005
29798, 6311, 6312, 6334, 6333, 6965, 7009, 7010, 7007
29799, 6312, 6313, 6335, 6334, 6967, 7011, 7012, 7009
29800, 6313, 6314, 6336, 6335, 6969, 7013, 7014, 7011
29801, 6314, 6315, 6337, 6336, 6971, 7015, 7016, 7013
29802, 6315, 6316, 6338, 6337, 6973, 7017, 7018, 7015
29803, 6316, 6317, 6339, 6338, 6975, 7019, 7020, 7017
29804, 6317, 6318, 6340, 6339, 6977, 7021, 7022, 7019
29805, 6318, 6319, 6341, 6340, 6979, 7023, 7024, 7021
29806, 6319, 6320, 6342, 6341, 6981, 7025, 7026, 7023
29807, 6320, 6321, 6343, 6342, 6983, 7027, 7028, 7025
29808, 6321, 6322, 6344, 6343, 6985, 7029, 7030, 7027
29809, 6322, 6323, 6345, 6344, 6987, 7031, 7032, 7029
29810, 6323, 6324, 6346, 6345, 6989, 7033, 7034, 7031
29811, 6324, 6325, 6347, 6346, 6991, 7035, 7036, 7033
29812, 6325, 6326, 6348, 6347, 6993, 7037, 7038, 7035
29813, 6326, 569, 570, 6348, 6994, 592, 7039, 7037
29814, 525, 6327, 6349, 526, 6996, 7040, 7041, 548
29815, 6327, 6328, 6350, 6349, 6998, 7042, 7043, 7040
29816, 6328, 6329, 6351, 6350, 7000, 7044, 7045, 7042
29817, 6329, 6330, 6352, 6351, 7002, 7046, 7047, 7044
29818, 6330, 6331, 6353, 6352, 7004, 7048, 7049, 7046
29819, 6331, 6332, 6354, 6353, 7006, 7050, 7051, 7048
29820, 6332, 6333, 6355, 6354, 7008, 7052, 7053, 7050
29821, 6333, 6334, 6356, 6355, 7010, 7054, 7055, 7052
29822, 6334, 6335, 6357, 6356, 7012, 7056, 7057, 7054
29823, 6335, 6336, 6358, 6357, 7014, 7058, 7059, 7056
29824, 6336, 6337, 6359, 6358, 7016, 7060, 7061, 7058
29825, 6337, 6338, 6360, 6359, 7018, 7062, 7063, 7060
29826, 6338, 6339, 6361, 6360, 7020, 7064, 7065, 7062
29827, 6339, 6340, 6362, 6361, 7022, 7066, 7067, 7064
29828, 6340, 6341, 6363, 6362, 7024, 7068, 7069, 7066
29829, 6341, 6342, 6364, 6363, 7026, 7070, 7071, 7068
29830, 6342, 6343, 6365, 6364, 7028, 7072, 7073, 7070
29831, 6343, 6344, 6366, 6365, 7030, 7074, 7075, 7072
29832, 6344, 6345, 6367, 6366, 7032, 7076, 7077, 7074
29833, 6345, 6346, 6368, 6367, 7034, 7078, 7079, 7076
29834, 6346, 6347, 6369, 6368, 7036, 7080, 7081, 7078
29835, 6347, 6348, 6370, 6369, 7038, 7082, 7083, 7080
29836, 6348, 570, 571, 6370, 7039, 593, 7084, 7082
29837, 526, 6349, 6371, 527, 7041, 7085, 7086, 549
29838, 6349, 6350, 6372, 6371, 7043, 7087, 7088, 7085
29839, 6350, 6351, 6373, 6372, 7045, 7089, 7090, 7087
29840, 6351, 6352, 6374, 6373, 7047, 7091, 7092, 7089
29841, 6352, 6353, 6375, 6374, 7049, 7093, 7094, 7091
29842, 6353, 6354, 6376, 6375, 7051, 7095, 7096, 7093
29843, 6354, 6355, 6377, 6376, 7053, 7097, 7098, 7095
29844, 6355, 6356, 6378, 6377, 7055, 7099, 7100, 7097
29845, 6356, 6357, 6379, 6378, 7057, 7101, 7102, 7099
29846, 6357, 6358, 6380, 6379, 7059, 7103, 7104, 7101
29847, 6358, 6359, 6381, 6380, 7061, 7105, 7106, 7103
29848, 6359, 6360, 6382, 6381, 7063, 7107, 7108, 7105
29849, 6360, 6361, 6383, 6382, 7065, 7109, 7110, 7107
29850, 6361, 6362, 6384, 6383, 7067, 7111, 7112, 7109
29851, 6362, 6363, 6385, 6384, 7069, 7113, 7114, 7111
29852, 6363, 6364, 6386, 6385, 7071, 7115, 7116, 7113
29853, 6364, 6365, 6387, 6386, 7073, 7117, 7118, 7115
29854, 6365, 6366, 6388, 6387, 7075, 7119, 7120, 7117
29855, 6366, 6367, 6389, 6388, 7077, 7121, 7122, 7119
29856, 6367, 6368, 6390, 6389, 7079, 7123, 7124, 7121
29857, 6368, 6369, 6391, 6390, 7081, 7125, 7126, 7123
29858, 6369, 6370, 6392, 6391, 7083, 7127, 7128, 7125
29859, 6370, 571, 572, 6392, 7084, 594, 7129, 7127
29860, 527, 6371, 6393, 528, 7086, 7130, 7131, 550
29861, 6371, 6372, 6394, 6393, 7088, 7132, 7133, 7130
29862, 6372, 6373, 6395, 6394, 7090, 7134, 7135, 7132
29863, 6373, 6374, 6396, 6395, 7092, 7136, 7137, 7134
29864, 6374, 6375, 6397, 6396, 7094, 7138, 7139, 7136
29865, 6375, 6376, 6398, 6397, 7096, 7140, 7141, 7138
29866, 6376, 6377, 6399, 6398, 7098, 7142, 7143, 7140
29867, 6377, 6378, 6400, 6399, 7100, 7144, 7145, 7142
29868, 6378, 6379, 6401, 6400, 7102, 7146, 7147, 7144
29869, 6379, 6380, 6402, 6401, 7104, 7148, 7149, 7146
29870, 6380, 6381, 6403, 6402, 7106, 7150, 7151, 7148
29871, 6381, 6382, 6404, 6403, 7108, 7152, 7153, 7150
29872, 6382, 6383, 6405, 6404, 7110, 7154, 7155, 7152
29873, 6383, 6384, 6406, 6405, 7112, 7156, 7157, 7154
29874, 6384, 6385, 6407, 6406, 7114, 7158, 7159, 7156
29875, 6385, 6386, 6408, 6407, 7116, 7160, 7161, 7158
29876, 6386, 6387, 6409, 6408, 7118, 7162, 7163, 7160
29877, 6387, 6388, 6410, 6409, 7120, 7164, 7165, 7162
29878, 6388, 6389, 6411, 6410, 7122, 7166, 7167, 7164
29879, 6389, 6390, 6412, 6411, 7124, 7168, 7169, 7166
29880, 6390, 6391, 6413, 6412, 7126, 7170, 7171, 7168
29881, 6391, 6392, 6414, 6413, 7128, 7172, 7173, 7170
29882, 6392, 572, 573, 6414, 7129, 595, 7174, 7172
29883, 528, 6393, 6415, 529, 7131, 7175, 7176, 551
29884, 6393, 6394, 6416, 6415, 7133, 7177, 7178, 7175
29885, 6394, 6395, 6417, 6416, 7135, 7179, 7180, 7177
29886, 6395, 6396, 6418, 6417, 7137, 7181, 7182, 7179
29887, 6396, 6397, 6419, 6418, 7139, 7183, 7184, 7181
29888, 6397, 6398, 6420, 6419, 7141, 7185, 7186, 7183
29889, 6398, 6399, 6421, 6420, 7143, 7187, 7188, 7185
29890, 6399, 6400, 6422, 6421, 7145, 7189, 7190, 7187
29891, 6400, 6401, 6423, 6422, 7147, 7191, 7192, 7189
29892, 6401, 6402, 6424, 6423, 7149, 7193, 7194, 7191
29893, 6402, 6403, 6425, 6424, 7151, 7195, 7196, 7193
29894, 6403, 6404, 6426, 6425, 7153, 7197, 7198, 7195
29895, 6404, 6405, 6427, 6426, 7155, 7199, 7200, 7197
29896, 6405, 6406, 6428, 6427, 7157, 7201, 7202, 7199
29897, 6406, 6407, 6429, 6428, 7159, 7203, 7204, 7201
29898, 6407, 6408, 6430, 6429, 7161, 7205, 7206, 7203
29899, 6408, 6409, 6431, 6430, 7163, 7207, 7208, 7205
29900, 6409, 6410, 6432, 6431, 7165, 7209, 7210, 7207
29901, 6410, 6411, 6433, 6432, 7167, 7211, 7212, 7209
29902, 6411, 6412, 6434, 6433, 7169, 7213, 7214, 7211
29903, 6412, 6413, 6435, 6434, 7171, 7215, 7216, 7213
29904, 6413, 6414, 6436, 6435, 7173, 7217, 7218, 7215
29905, 6414, 573, 574, 6436, 7174, 596, 7219, 7217
29906, 529, 6415, 6437, 530, 7176, 7220, 7221, 552
29907, 6415, 6416, 6438, 6437, 7178, 7222, 7223, 7220
29908, 6416, 6417, 6439, 6438, 7180, 7224, 7225, 7222
29909, 6417, 6418, 6440, 6439, 7182, 7226, 7227, 7224
29910, 6418, 6419, 6441, 6440, 7184, 7228, 7229, 7226
29911, 6419, 6420, 6442, 6441, 7186, 7230, 7231, 7228
29912, 6420, 6421, 6443, 6442, 7188, 7232, 7233, 7230
29913, 6421, 6422, 6444, 6443, 7190, 7234, 7235, 7232
29914, 6422, 6423, 6445, 6444, 7192, 7236, 7237, 7234
29915, 6423, 6424, 6446, 6445, 7194, 7238, 7239, 7236
29916, 6424, 6425, 6447, 6446, 7196, 7240, 7241, 7238
29917, 6425, 6426, 6448, 6447, 7198, 7242, 7243, 7240
29918, 6426, 6427, 6449, 6448, 7200, 7244, 7245, 7242
29919, 6427, 6428, 6450, 6449, 7202, 7246, 7247, 7244
29920, 6428, 6429, 6451, 6450, 7204, 7248, 7249, 7246
29921, 6429, 6430, 6452, 6451, 7206, 7250, 7251, 7248
29922, 6430, 6431, 6453, 6452, 7208, 7252, 7253, 7250
29923, 6431, 6432, 6454, 6453, 7210, 7254, 7255, 7252
29924, 6432, 6433, 6455, 6454, 7212, 7256, 7257, 7254
29925, 6433, 6434, 6456, 6455, 7214, 7258, 7259, 7256
29926, 6434, 6435, 6457, 6456, 7216, 7260, 7261, 7258
29927, 6435, 6436, 6458, 6457, 7218, 7262, 7263, 7260
29928, 6436, 574, 575, 6458, 7219, 597, 7264, 7262
29929, 530, 6437, 6459, 531, 7221, 7265, 7266, 553
29930, 6437, 6438, 6460, 6459, 7223, 7267, 7268, 7265
29931, 6438, 6439, 6461, 6460, 7225, 7269, 7270, 7267
29932, 6439, 6440, 6462, 6461, 7227, 7271, 7272, 7269
29933, 6440, 6441, 6463, 6462, 7229, 7273, 7274, 7271
29934, 6441, 6442, 6464, 6463, 7231, 7275, 7276, 7273
29935, 6442, 6443, 6465, 6464, 7233, 7277, 7278, 7275
29936, 6443, 6444, 6466, 6465, 7235, 7279, 7280, 7277
29937, 6444, 6445, 6467, 6466, 7237, 7281, 7282, 7279
29938, 6445, 6446, 6468, 6467, 7239, 7283, 7284, 7281
29939, 6446, 6447, 6469, 6468, 7241, 7285, 7286, 7283
29940, 6447, 6448, 6470, 6469, 7243, 7287, 7288, 7285
29941, 6448, 6449, 6471, 6470, 7245, 7289, 7290, 7287
29942, 6449, 6450, 6472, 6471, 7247, 7291, 7292, 7289
29943, 6450, 6451, 6473, 6472, 7249, 7293, 7294, 7291
29944, 6451, 6452, 6474, 6473, 7251, 7295, 7296, 7293
29945, 6452, 6453, 6475, 6474, 7253, 7297, 7298, 7295
29946, 6453, 6454, 6476, 6475, 7255, 7299, 7300, 7297
29947, 6454, 6455, 6477, 6476, 7257, 7301, 7302, 7299
29948, 6455, 6456, 6478, 6477, 7259, 7303, 7304, 7301
29949, 6456, 6457, 6479, 6478, 7261, 7305, 7306, 7303
29950, 6457, 6458, 6480, 6479, 7263, 7307, 7308, 7305
29951, 6458, 575, 576, 6480, 7264, 598, 7309, 7307
29952, 531, 6459, 6481, 532, 7266, 7310, 7311, 554
29953, 6459, 6460, 6482, 6481, 7268, 7312, 7313, 7310
29954, 6460, 6461, 6483, 6482, 7270, 7314, 7315, 7312
29955, 6461, 6462, 6484, 6483, 7272, 7316, 7317, 7314
29956, 6462, 6463, 6485, 6484, 7274, 7318, 7319, 7316
29957, 6463, 6464, 6486, 6485, 7276, 7320, 7321, 7318
29958, 6464, 6465, 6487, 6486, 7278, 7322, 7323, 7320
29959, 6465, 6466, 6488, 6487, 7280, 7324, 7325, 7322
29960, 6466, 6467, 6489, 6488, 7282, 7326, 7327, 7324
29961, 6467, 6468, 6490, 6489, 7284, 7328, 7329, 7326
29962, 6468, 6469, 6491, 6490, 7286, 7330, 7331, 7328
29963, 6469, 6470, 6492, 6491, 7288, 7332, 7333, 7330
29964, 6470, 6471, 6493, 6492, 7290, 7334, 7335, 7332
29965, 6471, 6472, 6494, 6493, 7292, 7336, 7337, 7334
29966, 6472, 6473, 6495, 6494, 7294, 7338, 7339, 7336
29967, 6473, 6474, 6496, 6495, 7296, 7340, 7341, 7338
29968, 6474, 6475, 6497, 6496, 7298, 7342, 7343, 7340
29969, 6475, 6476, 6498, 6497, 7300, 7344, 7345, 7342
29970, 6476, 6477, 6499, 6498, 7302, 7346, 7347, 7344
29971, 6477, 6478, 6500, 6499, 7304, 7348, 7349, 7346
29972, 6478, 6479, 6501, 6500, 7306, 7350, 7351, 7348
29973, 6479, 6480, 6502, 6501, 7308, 7352, 7353, 7350
29974, 6480, 576, 577, 6502, 7309, 599, 7354, 7352
29975, 532, 6481, 6503, 533, 7311, 7355, 7356, 555
29976, 6481, 6482, 6504, 6503, 7313, 7357, 7358, 7355
29977, 6482, 6483, 6505, 6504, 7315, 7359, 7360, 7357
29978, 6483, 6484, 6506, 6505, 7317, 7361, 7362, 7359
29979, 6484, 6485, 6507, 6506, 7319, 7363, 7364, 7361
29980, 6485, 6486, 6508, 6507, 7321, 7365, 7366, 7363
29981, 6486, 6487, 6509, 6508, 7323, 7367, 7368, 7365
29982, 6487, 6488, 6510, 6509, 7325, 7369, 7370, 7367
29983, 6488, 6489, 6511, 6510, 7327, 7371, 7372, 7369
29984, 6489, 6490, 6512, 6511, 7329, 7373, 7374, 7371
29985, 6490, 6491, 6513, 6512, 7331, 7375, 7376, 7373
29986, 6491, 6492, 6514, 6513, 7333, 7377, 7378, 7375
29987, 6492, 6493, 6515, 6514, 7335, 7379, 7380, 7377
29988, 6493, 6494, 6516, 6515, 7337, 7381, 7382, 7379
29989, 6494, 6495, 6517, 6516, 7339, 7383, 7384, 7381
29990, 6495, 6496, 6518, 6517, 7341, 7385, 7386, 7383
29991, 6496, 6497, 6519, 6518, 7343, 7387, 7388, 7385
29992, 6497, 6498, 6520, 6519, 7345, 7389, 7390, 7387
29993, 6498, 6499, 6521, 6520, 7347, 7391, 7392, 7389
29994, 6499, 6500, 6522, 6521, 7349, 7393, 7394, 7391
29995, 6500, 6501, 6523, 6522, 7351, 7395, 7396, 7393
29996, 6501, 6502, 6524, 6523, 7353, 7397, 7398, 7395
29997, 6502, 577, 578, 6524, 7354, 600, 7399, 7397
29998, 533, 6503, 6525, 534, 7356, 7400, 7401, 556
29999, 6503, 6504, 6526, 6525, 7358, 7402, 7403, 7400
30000, 6504, 6505, 6527, 6526, 7360, 7404, 7405, 7402
30001, 6505, 6506, 6528, 6527, 7362, 7406, 7407, 7404
30002, 6506, 6507, 6529, 6528, 7364, 7408, 7409, 7406
30003, 6507, 6508, 6530, 6529, 7366, 7410, 7411, 7408
30004, 6508, 6509, 6531, 6530, 7368, 7412, 7413, 7410
30005, 6509, 6510, 6532, 6531, 7370, 7414, 7415, 7412
30006, 6510, 6511, 6533, 6532, 7372, 7416, 7417, 7414
30007, 6511, 6512, 6534, 6533, 7374, 7418, 7419, 7416
30008, 6512, 6513, 6535, 6534, 7376, 7420, 7421, 7418
30009, 6513, 6514, 6536, 6535, 7378, 7422, 7423, 7420
30010, 6514, 6515, 6537, 6536, 7380, 7424, 7425, 7422
30011, 6515, 6516, 6538, 6537, 7382, 7426, 7427, 7424
30012, 6516, 6517, 6539, 6538, 7384, 7428, 7429, 7426
30013, 6517, 6518, 6540, 6539, 7386, 7430, 7431, 7428
30014, 6518, 6519, 6541, 6540, 7388, 7432, 7433, 7430
30015, 6519, 6520, 6542, 6541, 7390, 7434, 7435, 7432
30016, 6520, 6521, 6543, 6542, 7392, 7436, 7437, 7434
30017, 6521, 6522, 6544, 6543, 7394, 7438, 7439, 7436
30018, 6522, 6523, 6545, 6544, 7396, 7440, 7441, 7438
30019, 6523, 6524, 6546, 6545, 7398, 7442, 7443, 7440
30020, 6524, 578, 579, 6546, 7399, 601, 7444, 7442
30021, 534, 6525, 6547, 535, 7401, 7445, 7446, 557
30022, 6525, 6526, 6548, 6547, 7403, 7447, 7448, 7445
30023, 6526, 6527, 6549, 6548, 7405, 7449, 7450, 7447
30024, 6527, 6528, 6550, 6549, 7407, 7451, 7452, 7449
30025, 6528, 6529, 6551, 6550, 7409, 7453, 7454, 7451
30026, 6529, 6530, 6552, 6551, 7411, 7455, 7456, 7453
30027, 6530, 6531, 6553, 6552, 7413, 7457, 7458, 7455
30028, 6531, 6532, 6554, 6553, 7415, 7459, 7460, 7457
30029, 6532, 6533, 6555, 6554, 7417, 7461, 7462, 7459
30030, 6533, 6534, 6556, 6555, 7419, 7463, 7464, 7461
30031, 6534, 6535, 6557, 6556, 7421, 7465, 7466, 7463
30032, 6535, 6536, 6558, 6557, 7423, 7467, 7468, 7465
30033, 6536, 6537, 6559, 6558, 7425, 7469, 7470, 7467
30034, 6537, 6538, 6560, 6559, 7427, 7471, 7472, 7469
30035, 6538, 6539, 6561, 6560, 7429, 7473, 7474, 7471
30036, 6539, 6540, 6562, 6561, 7431, 7475, 7476, 7473
30037, 6540, 6541, 6563, 6562, 7433, 7477, 7478, 7475
30038, 6541, 6542, 6564, 6563, 7435, 7479, 7480, 7477
30039, 6542, 6543, 6565, 6564, 7437, 7481, 7482, 7479
30040, 6543, 6544, 6566, 6565, 7439, 7483, 7484, 7481
30041, 6544, 6545, 6567, 6566, 7441, 7485, 7486, 7483
30042, 6545, 6546, 6568, 6567, 7443, 7487, 7488, 7485
30043, 6546, 579, 580, 6568, 7444, 602, 7489, 7487
30044, 535, 6547, 6569, 536, 7446, 7490, 7491, 558
30045, 6547, 6548, 6570, 6569, 7448, 7492, 7493, 7490
30046, 6548, 6549, 6571, 6570, 7450, 7494, 7495, 7492
30047, 6549, 6550, 6572, 6571, 7452, 7496, 7497, 7494
30048, 6550, 6551, 6573, 6572, 7454, 7498, 7499, 7496
30049, 6551, 6552, 6574, 6573, 7456, 7500, 7501, 7498
30050, 6552, 6553, 6575, 6574, 7458, 7502, 7503, 7500
30051, 6553, 6554, 6576, 6575, 7460, 7504, 7505, 7502
30052, 6554, 6555, 6577, 6576, 7462, 7506, 7507, 7504
30053, 6555, 6556, 6578, 6577, 7464, 7508, 7509, 7506
30054, 6556, 6557, 6579, 6578, 7466, 7510, 7511, 7508
30055, 6557, 6558, 6580, 6579, 7468, 7512, 7513, 7510
30056, 6558, 6559, 6581, 6580, 7470, 7514, 7515, 7512
30057, 6559, 6560, 6582, 6581, 7472, 7516, 7517, 7514
30058, 6560, 6561, 6583, 6582, 7474, 7518, 7519, 7516
30059, 6561, 6562, 6584, 6583, 7476, 7520, 7521, 7518
30060, 6562, 6563, 6585, 6584, 7478, 7522, 7523, 7520
30061, 6563, 6564, 6586, 6585, 7480, 7524, 7525, 7522
30062, 6564, 6565, 6587, 6586, 7482, 7526, 7527, 7524
30063, 6565, 6566, 6588, 6587, 7484, 7528, 7529, 7526
30064, 6566, 6567, 6589, 6588, 7486, 7530, 7531, 7528
30065, 6567, 6568, 6590, 6589, 7488, 7532, 7533, 7530
30066, 6568, 580, 581, 6590, 7489, 603, 7534, 7532
30067, 536, 6569, 6591, 537, 7491, 7535, 7536, 559
30068, 6569, 6570, 6592, 6591, 7493, 7537, 7538, 7535
30069, 6570, 6571, 6593, 6592, 7495, 7539, 7540, 7537
30070, 6571, 6572, 6594, 6593, 7497, 7541, 7542, 7539
30071, 6572, 6573, 6595, 6594, 7499, 7543, 7544, 7541
30072, 6573, 6574, 6596, 6595, 7501, 7545, 7546, 7543
30073, 6574, 6575, 6597, 6596, 7503, 7547, 7548, 7545
30074, 6575, 6576, 6598, 6597, 7505, 7549, 7550, 7547
30075, 6576, 6577, 6599, 6598, 7507, 7551, 7552, 7549
30076, 6577, 6578, 6600, 6599, 7509, 7553, 7554, 7551
30077, 6578, 6579, 6601, 6600, 7511, 7555, 7556, 7553
30078, 6579, 6580, 6602, 6601, 7513, 7557, 7558, 7555
30079, 6580, 6581, 6603, 6602, 7515, 7559, 7560, 7557
30080, 6581, 6582, 6604, 6603, 7517, 7561, 7562, 7559
30081, 6582, 6583, 6605, 6604, 7519, 7563, 7564, 7561
30082, 6583, 6584, 6606, 6605, 7521, 7565, 7566, 7563
30083, 6584, 6585, 6607, 6606, 7523, 7567, 7568, 7565
30084, 6585, 6586, 6608, 6607, 7525, 7569, 7570, 7567
30085, 6586, 6587, 6609, 6608, 7527, 7571, 7572, 7569
30086, 6587, 6588, 6610, 6609, 7529, 7573, 7574, 7571
30087, 6588, 6589, 6611, 6610, 7531, 7575, 7576, 7573
30088, 6589, 6590, 6612, 6611, 7533, 7577, 7578, 7575
30089, 6590, 581, 582, 6612, 7534, 604, 7579, 7577
30090, 537, 6591, 6613, 538, 7536, 7580, 7581, 560
30091, 6591, 6592, 6614, 6613, 7538, 7582, 7583, 7580
30092, 6592, 6593, 6615, 6614, 7540, 7584, 7585, 7582
30093, 6593, 6594, 6616, 6615, 7542, 7586, 7587, 7584
30094, 6594, 6595, 6617, 6616, 7544, 7588, 7589, 7586
30095, 6595, 6596, 6618, 6617, 7546, 7590, 7591, 7588
30096, 6596, 6597, 6619, 6618, 7548, 7592, 7593, 7590
30097, 6597, 6598, 6620, 6619, 7550, 7594, 7595, 7592
30098, 6598, 6599, 6621, 6620, 7552, 7596, 7597, 7594
30099, 6599, 6600, 6622, 6621, 7554, 7598, 7599, 7596
30100, 6600, 6601, 6623, 6622, 7556, 7600, 7601, 7598
30101, 6601, 6602, 6624, 6623, 7558, 7602, 7603, 7600
30102, 6602, 6603, 6625, 6624, 7560, 7604, 7605, 7602
30103, 6603, 6604, 6626, 6625, 7562, 7606, 7607, 7604
30104, 6604, 6605, 6627, 6626, 7564, 7608, 7609, 7606
30105, 6605, 6606, 6628, 6627, 7566, 7610, 7611, 7608
30106, 6606, 6607, 6629, 6628, 7568, 7612, 7613, 7610
30107, 6607, 6608, 6630, 6629, 7570, 7614, 7615, 7612
30108, 6608, 6609, 6631, 6630, 7572, 7616, 7617, 7614
30109, 6609, 6610, 6632, 6631, 7574, 7618, 7619, 7616
30110, 6610, 6611, 6633, 6632, 7576, 7620, 7621, 7618
30111, 6611, 6612, 6634, 6633, 7578, 7622, 7623, 7620
30112, 6612, 582, 583, 6634, 7579, 605, 7624, 7622
30113, 538, 6613, 628, 13, 7581, 7625, 651, 561
30114, 6613, 6614, 627, 628, 7583, 7626, 650, 7625
30115, 6614, 6615, 626, 627, 7585, 7627, 649, 7626
30116, 6615, 6616, 625, 626, 7587, 7628, 648, 7627
30117, 6616, 6617, 624, 625, 7589, 7629, 647, 7628
30118, 6617, 6618, 623, 624, 7591, 7630, 646, 7629
30119, 6618, 6619, 622, 623, 7593, 7631, 645, 7630
30120, 6619, 6620, 621, 622, 7595, 7632, 644, 7631
30121, 6620, 6621, 620, 621, 7597, 7633, 643, 7632
30122, 6621, 6622, 619, 620, 7599, 7634, 642, 7633
30123, 6622, 6623, 618, 619, 7601, 7635, 641, 7634
30124, 6623, 6624, 617, 618, 7603, 7636, 640, 7635
30125, 6624, 6625, 616, 617, 7605, 7637, 639, 7636
30126, 6625, 6626, 615, 616, 7607, 7638, 638, 7637
30127, 6626, 6627, 614, 615, 7609, 7639, 637, 7638
30128, 6627, 6628, 613, 614, 7611, 7640, 636, 7639
30129, 6628, 6629, 612, 613, 7613, 7641, 635, 7640
30130, 6629, 6630, 611, 612, 7615, 7642, 634, 7641
30131, 6630, 6631, 610, 611, 7617, 7643, 633, 7642
30132, 6631, 6632, 609, 610, 7619, 7644, 632, 7643
30133, 6632, 6633, 608, 609, 7621, 7645, 631, 7644
30134, 6633, 6634, 607, 608, 7623, 7646, 630, 7645
30135, 6634, 583, 14, 607, 7624, 606, 629, 7646
*ELEMENT, type=CPS8, ELSET=Surface13
30136, 11, 436, 7647, 652, 447, 7867, 7868, 674
30137, 436, 435, 7648, 7647, 446, 7869, 7870, 7867
30138, 435, 434, 7649, 7648, 445, 7871, 7872, 7869
30139, 434, 433, 7650, 7649, 444, 7873, 7874, 7871
30140, 433, 432, 7651, 7650, 443, 7875, 7876, 7873
30141, 432, 431, 7652, 7651, 442, 7877, 7878, 7875
30142, 431, 430, 7653, 7652, 441, 7879, 7880, 7877
30143, 430, 429, 7654, 7653, 440, 7881, 7882, 7879
30144, 429, 428, 7655, 7654, 439, 7883, 7884, 7881
30145, 428, 427, 7656, 7655, 438, 7885, 7886, 7883
30146, 427, 9, 517, 7656, 437, 539, 7887, 7885
30147, 652, 7647, 7657, 653, 7868, 7888, 7889, 675
30148, 7647, 7648, 7658, 7657, 7870, 7890, 7891, 7888
30149, 7648, 7649, 7659, 7658, 7872, 7892, 7893, 7890
30150, 7649, 7650, 7660, 7659, 7874, 7894, 7895, 7892
30151, 7650, 7651, 7661, 7660, 7876, 7896, 7897, 7894
30152, 7651, 7652, 7662, 7661, 7878, 7898, 7899, 7896
30153, 7652, 7653, 7663, 7662, 7880, 7900, 7901, 7898
30154, 7653, 7654, 7664, 7663, 7882, 7902, 7903, 7900
30155, 7654, 7655, 7665, 7664, 7884, 7904, 7905, 7902
30156, 7655, 7656, 7666, 7665, 7886, 7906, 7907, 7904
30157, 7656, 517, 518, 7666, 7887, 540, 7908, 7906
30158, 653, 7657, 7667, 654, 7889, 7909, 7910, 676
30159, 7657, 7658, 7668, 7667, 7891, 7911, 7912, 7909
30160, 7658, 7659, 7669, 7668, 7893, 7913, 7914, 7911
30161, 7659, 7660, 7670, 7669, 7895, 7915, 7916, 7913
30162, 7660, 7661, 7671, 7670, 7897, 7917, 7918, 7915
30163, 7661, 7662, 7672, 7671, 7899, 7919, 7920, 7917
30164, 7662, 7663, 7673, 7672, 7901, 7921, 7922, 7919
30165, 7663, 7664, 7674, 7673, 7903, 7923, 7924, 7921
30166, 7664, 7665, 7675, 7674, 7905, 7925, 7926, 7923
30167, 7665, 7666, 7676, 7675, 7907, 7927, 7928, 7925
30168, 7666, 518, 519, 7676, 7908, 541, 7929, 7927
30169, 654, 7667, 7677, 655, 7910, 7930, 7931, 677
30170, 7667, 7668, 7678, 7677, 7912, 7932, 7933, 7930
30171, 7668, 7669, 7679, 7678, 7914, 7934, 7935, 7932
30172, 7669, 7670, 7680, 7679, 7916, 7936, 7937, 7934
30173, 7670, 7671, 7681, 7680, 7918, 7938, 7939, 7936
30174, 7671, 7672, 7682, 7681, 7920, 7940, 7941, 7938
30175, 7672, 7673, 7683, 7682, 7922, 7942, 7943, 7940
30176, 7673, 7674, 7684, 7683, 7924, 7944, 7945, 7942
30177, 7674, 7675, 7685, 7684, 7926, 7946, 7947, 7944
30178, 7675, 7676, 7686, 7685, 7928, 7948, 7949, 7946
30179, 7676, 519, 520, 7686, 7929, 542, 7950, 7948
30180, 655, 7677, 7687, 656, 7931, 7951, 7952, 678
30181, 7677, 7678, 7688, 7687, 7933, 7953, 7954, 7951
30182, 7678, 7679, 7689, 7688, 7935, 7955, 7956, 7953
30183, 7679, 7680, 7690, 7689, 7937, 7957, 7958, 7955
30184, 7680, 7681, 7691, 7690, 7939, 7959, 7960, 7957
30185, 7681, 7682, 7692, 7691, 7941, 7961, 7962, 7959
30186, 7682, 7683, 7693, 7692, 7943, 7963, 7964, 7961
30187, 7683, 7684, 7694, 7693, 7945, 7965, 7966, 7963
30188, 7684, 7685, 7695, 7694, 7947, 7967, 7968, 7965
30189, 7685, 7686, 7696, 7695, 7949, 7969, 7970, 7967
30190, 7686, 520, 521, 7696, 7950, 543, 7971, 7969
30191, 656, 7687, 7697, 657, 7952, 7972, 7973, 679
30192, 7687, 7688, 7698, 7697, 7954, 7974, 7975, 7972
30193, 7688, 7689, 7699, 7698, 7956, 7976, 7977, 7974
30194, 7689, 7690, 7700, 7699, 7958, 7978, 7979, 7976
30195, 7690, 7691, 7701, 7700, 7960, 7980, 7981, 7978
30196, 7691, 7692, 7702, 7701, 7962, 7982, 7983, 7980
30197, 7692, 7693, 7703, 7702, 7964, 7984, 7985, 7982
30198, 7693, 7694, 7704, 7703, 7966, 7986, 7987, 7984
30199, 7694, 7695, 7705, 7704, 7968, 7988, 7989, 7986
30200, 7695, 7696, 7706, 7705, 7970, 7990, 7991, 7988
30201, 7696, 521, 522, 7706, 7971, 544, 7992, 7990
30202, 657, 7697, 7707, 658, 7973, 7993, 7994, 680
30203, 7697, 7698, 7708, 7707, 7975, 7995, 7996, 7993
30204, 7698, 7699, 7709, 7708, 7977, 7997, 7998, 7995
30205, 7699, 7700, 7710, 7709, 7979, 7999, 8000, 7997
30206, 7700, 7701, 7711, 7710, 7981, 8001, 8002, 7999
30207, 7701, 7702, 7712, 7711, 7983, 8003, 8004, 8001
30208, 7702, 7703, 7713, 7712, 7985, 8005, 8006, 8003
30209, 7703, 7704, 7714, 7713, 7987, 8007, 8008, 8005
30210, 7704, 7705, 7715, 7714, 7989, 8009, 8010, 8007
30211, 7705, 7706, 7716, 7715, 7991, 8011, 8012, 8009
30212, 7706, 522, 523, 7716, 7992, 545, 8013, 8011
30213, 658, 7707, 7717, 659, 7994, 8014, 8015, 681
30214, 7707, 7708, 7718, 7717, 7996, 8016, 8017, 8014
30215, 7708, 7709, 7719, 7718, 7998, 8018, 8019, 8016
30216, 7709, 7710, 7720, 7719, 8000, 8020, 8021, 8018
30217, 7710, 7711, 7721, 7720, 8002, 8022, 8023, 8020
30218, 7711, 7712, 7722, 7721, 8004, 8024, 8025, 8022
30219, 7712, 7713, 7723, 7722, 8006, 8026, 8027, 8024
30220, 7713, 7714, 7724, 7723, 8008, 8028, 8029, 8026
30221, 7714, 7715, 7725, 7724, 8010, 8030, 8031, 8028
30222, 7715, 7716, 7726, 7725, 8012, 8032, 8033, 8030
30223, 7716, 523, 524, 7726, 8013, 546, 8034, 8032
30224, 659, 7717, 7727, 660, 8015, 8035, 8036, 682
30225, 7717, 7718, 7728, 7727, 8017, 8037, 8038, 8035
30226, 7718, 7719, 7729, 7728, 8019, 8039, 8040, 8037
30227, 7719, 7720, 7730, 7729, 8021, 8041, 8042, 8039
30228, 7720, 7721, 7731, 7730, 8023, 8043, 8044, 8041
30229, 7721, 7722, 7732, 7731, 8025, 8045, 8046, 8043
30230, 7722, 7723, 7733, 7732, 8027, 8047, 8048, 8045
30231, 7723, 7724, 7734, 7733, 8029, 8049, 8050, 8047
30232, 7724, 7725, 7735, 7734, 8031, 8051, 8052, 8049
30233, 7725, 7726, 7736, 7735, 8033, 8053, 8054, 8051
30234, 7726, 524, 525, 7736, 8034, 547, 8055, 8053
30235, 660, 7727, 7737, 661, 8036, 8056, 8057, 683
30236, 7727, 7728, 7738, 7737, 8038, 8058, 8059, 8056
30237, 7728, 7729, 7739, 7738, 8040, 8060, 8061, 8058
30238, 7729, 7730, 7740, 7739, 8042, 8062, 8063, 8060
30239, 7730, 7731, 7741, 7740, 8044, 8064, 8065, 8062
30240, 7731, 7732, 7742, 7741, 8046, 8066, 8067, 8064
30241, 7732, 7733, 7743, 7742, 8048, 8068, 8069, 8066
30242, 7733, 7734, 7744, 7743, 8050, 8070, 8071, 8068
30243, 7734, 7735, 7745, 7744, 8052, 8072, 8073, 8070
30244, 7735, 7736, 7746, 7745, 8054, 8074, 8075, 8072
30245, 7736, 525, 526, 7746, 8055, 548, 8076, 8074
30246, 661, 7737, 7747, 662, 8057, 8077, 8078, 684
30247, 7737, 7738, 7748, 7747, 8059, 8079, 8080, 8077
30248, 7738, 7739, 7749, 7748, 8061, 8081, 8082, 8079
30249, 7739, 7740, 7750, 7749, 8063, 8083, 8084, 8081
30250, 7740, 7741, 7751, 7750, 8065, 8085, 8086, 8083
30251, 7741, 7742, 7752, 7751, 8067, 8087, 8088, 8085
30252, 7742, 7743, 7753, 7752, 8069, 8089, 8090, 8087
30253, 7743, 7744, 7754, 7753, 8071, 8091, 8092, 8089
30254, 7744, 7745, 7755, 7754, 8073, 8093, 8094, 8091
30255, 7745, 7746, 7756, 7755, 8075, 8095, 8096, 8093
30256, 7746, 526, 527, 7756, 8076, 549, 8097, 8095
30257, 662, 7747, 7757, 663, 8078, 8098, 8099, 685
30258, 7747, 7748, 7758, 7757, 8080, 8100, 8101, 8098
30259, 7748, 7749, 7759, 7758, 8082, 8102, 8103, 8100
30260, 7749, 7750, 7760, 7759, 8084, 8104, 8105, 8102
30261, 7750, 7751, 7761, 7760, 8086, 8106, 8107, 8104
30262, 7751, 7752, 7762, 7761, 8088, 8108, 8109, 8106
30263, 7752, 7753, 7763, 7762, 8090, 8110, 8111, 8108
30264, 7753, 7754, 7764, 7763, 8092, 8112, 8113, 8110
30265, 7754, 7755, 7765, 7764, 8094, 8114, 8115, 8112
30266, 7755, 7756, 7766, 7765, 8096, 8116, 8117, 8114
30267, 7756, 527, 528, 7766, 8097, 550, 8118, 8116
30268, 663, 7757, 7767, 664, 8099, 8119, 8120, 686
30269, 7757, 7758, 7768, 7767, 8101, 8121, 8122, 8119
30270, 7758, 7759, 7769, 7768, 8103, 8123, 8124, 8121
30271, 7759, 7760, 7770, 7769, 8105, 8125, 8126, 8123
30272, 7760, 7761, 7771, 7770, 8107, 8127, 8128, 8125
30273, 7761, 7762, 7772, 7771, 8109, 8129, 8130, 8127
30274, 7762, 7763, 7773, 7772, 8111, 8131, 8132, 8129
30275, 7763, 7764, 7774, 7773, 8113, 8133, 8134, 8131
30276, 7764, 7765, 7775, 7774, 8115, 8135, 8136, 8133
30277, 7765, 7766, 7776, 7775, 8117, 8137, 8138, 8135
30278, 7766, 528, 529, 7776, 8118, 551, 8139, 8137
30279, 664, 7767, 7777, 665, 8120, 8140, 8141, 687
30280, 7767, 7768, 7778, 7777, 8122, 8142, 8143, 8140
30281, 7768, 7769, 7779, 7778, 8124, 8144, 8145, 8142
30282, 7769, 7770, 7780, 7779, 8126, 8146, 8147, 8144
30283, 7770, 7771, 7781, 7780, 8128, 8148, 8149, 8146
30284, 7771, 7772, 7782, 7781, 8130, 8150, 8151, 8148
30285, 7772, 7773, 7783, 7782, 8132, 8152, 8153, 8150
30286, 7773, 7774, 7784, 7783, 8134, 8154, 8155, 8152
30287, 7774, 7775, 7785, 7784, 8136, 8156, 8157, 8154
30288, 7775, 7776, 7786, 7785, 8138, 8158, 8159, 8156
30289, 7776, 529, 530, 7786, 8139, 552, 8160, 8158
30290, 665, 7777, 7787, 666, 8141, 8161, 8162, 688
30291, 7777, 7778, 7788, 7787, 8143, 8163, 8164, 8161
30292, 7778, 7779, 7789, 7788, 8145, 8165, 8166, 8163
30293, 7779, 7780, 7790, 7789, 8147, 8167, 8168, 8165
30294, 7780, 7781, 7791, 7790, 8149, 8169, 8170, 8167
30295, 7781, 7782, 7792, 7791, 8151, 8171, 8172, 8169
30296, 7782, 7783, 7793, 7792, 8153, 8173, 8174, 8171
30297, 7783, 7784, 7794, 7793, 8155, 8175, 8176, 8173
30298, 7784, 7785, 7795, 7794, 8157, 8177, 8178, 8175
30299, 7785, 7786, 7796, 7795, 8159, 8179, 8180, 8177
30300, 7786, 530, 531, 7796, 8160, 553, 8181, 8179
30301, 666, 7787, 7797, 667, 8162, 8182, 8183, 689
30302, 7787, 7788, 7798, 7797, 8164, 8184, 8185, 8182
30303, 7788, 7789, 7799, 7798, 8166, 8186, 8187, 8184
30304, 7789, 7790, 7800, 7799, 8168, 8188, 8189, 8186
30305, 7790, 7791, 7801, 7800, 8170, 8190, 8191, 8188
30306, 7791, 7792, 7802, 7801, 8172, 8192, 8193, 8190
30307, 7792, 7793, 7803, 7802, 8174, 8194, 8195, 8192
30308, 7793, 7794, 7804, 7803, 8176, 8196, 8197, 8194
30309, 7794, 7795, 7805, 7804, 8178, 8198, 8199, 8196
30310, 7795, 7796, 7806, 7805, 8180, 8200, 8201, 8198
30311, 7796, 531, 532, 7806, 8181, 554, 8202, 8200
30312, 667, 7797, 7807, 668, 8183, 8203, 8204, 690
30313, 7797, 7798, 7808, 7807, 8185, 8205, 8206, 8203
30314, 7798, 7799, 7809, 7808, 8187, 8207, 8208, 8205
30315, 7799, 7800, 7810, 7809, 8189, 8209, 8210, 8207
30316, 7800, 7801, 7811, 7810, 8191, 8211, 8212, 8209
30317, 7801, 7802, 7812, 7811, 8193, 8213, 8214, 8211
30318, 7802, 7803, 7813, 7812, 8195, 8215, 8216, 8213
30319, 7803, 7804, 7814, 7813, 8197, 8217, 8218, 8215
30320, 7804, 7805, 7815, 7814, 8199, 8219, 8220, 8217
30321, 7805, 7806, 7816, 7815, 8201, 8221, 8222, 8219
30322, 7806, 532, 533, 7816, 8202, 555, 8223, 8221
30323, 668, 7807, 7817, 669, 8204, 8224, 8225, 691
30324, 7807, 7808, 7818, 7817, 8206, 8226, 8227, 8224
30325, 7808, 7809, 7819, 7818, 8208, 8228, 8229, 8226
30326, 7809, 7810, 7820, 7819, 8210, 8230, 8231, 8228
30327, 7810, 7811, 7821, 7820, 8212, 8232, 8233, 8230
30328, 7811, 7812, 7822, 7821, 8214, 8234, 8235, 8232
30329, 7812, 7813, 7823, 7822, 8216, 8236, 8237, 8234
30330, 7813, 7814, 7824, 7823, 8218, 8238, 8239, 8236
30331, 7814, 7815, 7825, 7824, 8220, 8240, 8241, 8238
30332, 7815, 7816, 7826, 7825, 8222, 8242, 8243, 8240
30333, 7816, 533, 534, 7826, 8223, 556, 8244, 8242
30334, 669, 7817, 7827, 670, 8225, 8245, 8246, 692
30335, 7817, 7818, 7828, 7827, 8227, 8247, 8248, 8245
30336, 7818, 7819, 7829, 7828, 8229, 8249, 8250, 8247
30337, 7819, 7820, 7830, 7829, 8231, 8251, 8252, 8249
30338, 7820, 7821, 7831, 7830, 8233, 8253, 8254, 8251
30339, 7821, 7822, 7832, 7831, 8235, 8255, 8256, 8253
30340, 7822, 7823, 7833, 7832, 8237, 8257, 8258, 8255
30341, 7823, 7824, 7834, 7833, 8239, 8259, 8260, 8257
30342, 7824, 7825, 7835, 7834, 8241, 8261, 8262, 8259
30343, 7825, 7826, 7836, 7835, 8243, 8263, 8264, 8261
30344, 7826, 534, 535, 7836, 8244, 557, 8265, 8263
30345, 670, 7827, 7837, 671, 8246, 8266, 8267, 693
30346, 7827, 7828, 7838, 7837, 8248, 8268, 8269, 8266
30347, 7828, 7829, 7839, 7838, 8250, 8270, 8271, 8268
30348, 7829, 7830, 7840, 7839, 8252, 8272, 8273, 8270
30349, 7830, 7831, 7841, 7840, 8254, 8274, 8275, 8272
30350, 7831, 7832, 7842, 7841, 8256, 8276, 8277, 8274
30351, 7832, 7833, 7843, 7842, 8258, 8278, 8279, 8276
30352, 7833, 7834, 7844, 7843, 8260, 8280, 8281, 8278
30353, 7834, 7835, 7845, 7844, 8262, 8282, 8283, 8280
30354, 7835, 7836, 7846, 7845, 8264, 8284, 8285, 8282
30355, 7836, 535, 536, 7846, 8265, 558, 8286, 8284
30356, 671, 7837, 7847, 672, 8267, 8287, 8288, 694
30357, 7837, 7838, 7848, 7847, 8269, 8289, 8290, 8287
30358, 7838, 7839, 7849, 7848, 8271, 8291, 8292, 8289
30359, 7839, 7840, 7850, 7849, 8273, 8293, 8294, 8291
30360, 7840, 7841, 7851, 7850, 8275, 8295, 8296, 8293
30361, 7841, 7842, 7852, 7851, 8277, 8297, 8298, 8295
30362, 7842, 7843, 7853, 7852, 8279, 8299, 8300, 8297
30363, 7843, 7844, 7854, 7853, 8281, 8301, 8302, 8299
30364, 7844, 7845, 7855, 7854, 8283, 8303, 8304, 8301
30365, 7845, 7846, 7856, 7855, 8285, 8305, 8306, 8303
30366, 7846, 536, 537, 7856, 8286, 559, 8307, 8305
30367, 672, 7847, 7857, 673, 8288, 8308, 8309, 695
30368, 7847, 7848, 7858, 7857, 8290, 8310, 8311, 8308
30369, 7848, 7849, 7859, 7858, 8292, 8312, 8313, 8310
30370, 7849, 7850, 7860, 7859, 8294, 8314, 8315, 8312
30371, 7850, 7851, 7861, 7860, 8296, 8316, 8317, 8314
30372, 7851, 7852, 7862, 7861, 8298, 8318, 8319, 8316
30373, 7852, 7853, 7863, 7862, 8300, 8320, 8321, 8318
30374, 7853, 7854, 7864, 7863, 8302, 8322, 8323, 8320
30375, 7854, 7855, 7865, 7864, 8304, 8324, 8325, 8322
30376, 7855, 7856, 7866, 7865, 8306, 8326, 8327, 8324
30377, 7856, 537, 538, 7866, 8307, 560, 8328, 8326
30378, 673, 7857, 706, 15, 8309, 8329, 717, 696
30379, 7857, 7858, 705, 706, 8311, 8330, 716, 8329
30380, 7858, 7859, 704, 705, 8313, 8331, 715, 8330
30381, 7859, 7860, 703, 704, 8315, 8332, 714, 8331
30382, 7860, 7861, 702, 703, 8317, 8333, 713, 8332
30383, 7861, 7862, 701, 702, 8319, 8334, 712, 8333
30384, 7862, 7863, 700, 701, 8321, 8335, 711, 8334
30385, 7863, 7864, 699, 700, 8323, 8336, 710, 8335
30386, 7864, 7865, 698, 699, 8325, 8337, 709, 8336
30387, 7865, 7866, 697, 698, 8327, 8338, 708, 8337
30388, 7866, 538, 13, 697, 8328, 561, 707, 8338
*ELEMENT, type=CPS8, ELSET=Surface14
369, 11, 652, 8339, 472, 674, 8823, 8824, 495
370, 472, 8339, 8340, 471, 8824, 8825, 8826, 494
371, 471, 8340, 8341, 470, 8826, 8827, 8828, 493
372, 470, 8341, 8342, 469, 8828, 8829, 8830, 492
373, 469, 8342, 8343, 468, 8830, 8831, 8832, 491
374, 468, 8343, 8344, 467, 8832, 8833, 8834, 490
375, 467, 8344, 8345, 466, 8834, 8835, 8836, 489
376, 466, 8345, 8346, 465, 8836, 8837, 8838, 488
377, 465, 8346, 8347, 464, 8838, 8839, 8840, 487
378, 464, 8347, 8348, 463, 8840, 8841, 8842, 486
379, 463, 8348, 8349, 462, 8842, 8843, 8844, 485
380, 462, 8349, 8350, 461, 8844, 8845, 8846, 484
381, 461, 8350, 8351, 460, 8846, 8847, 8848, 483
382, 460, 8351, 8352, 459, 8848, 8849, 8850, 482
383, 459, 8352, 8353, 458, 8850, 8851, 8852, 481
384, 458, 8353, 8354, 457, 8852, 8853, 8854, 480
385, 457, 8354, 8355, 456, 8854, 8855, 8856, 479
386, 456, 8355, 8356, 455, 8856, 8857, 8858, 478
387, 455, 8356, 8357, 454, 8858, 8859, 8860, 477
388, 454, 8357, 8358, 453, 8860, 8861, 8862, 476
389, 453, 8358, 8359, 452, 8862, 8863, 8864, 475
390, 452, 8359, 8360, 451, 8864, 8865, 8866, 474
391, 451, 8360, 718, 12, 8866, 8867, 740, 473
392, 652, 653, 8361, 8339, 675, 8868, 8869, 8823
393, 8339, 8361, 8362, 8340, 8869, 8870, 8871, 8825
394, 8340, 8362, 8363, 8341, 8871, 8872, 8873, 8827
395, 8341, 8363, 8364, 8342, 8873, 8874, 8875, 8829
396, 8342, 8364, 8365, 8343, 8875, 8876, 8877, 8831
397, 8343, 8365, 8366, 8344, 8877, 8878, 8879, 8833
398, 8344, 8366, 8367, 8345, 8879, 8880, 8881, 8835
399, 8345, 8367, 8368, 8346, 8881, 8882, 8883, 8837
400, 8346, 8368, 8369, 8347, 8883, 8884, 8885, 8839
401, 8347, 8369, 8370, 8348, 8885, 8886, 8887, 8841
402, 8348, 8370, 8371, 8349, 8887, 8888, 8889, 8843
403, 8349, 8371, 8372, 8350, 8889, 8890, 8891, 8845
404, 8350, 8372, 8373, 8351, 8891, 8892, 8893, 8847
405, 8351, 8373, 8374, 8352, 8893, 8894, 8895, 8849
406, 8352, 8374, 8375, 8353, 8895, 8896, 8897, 8851
407, 8353, 8375, 8376, 8354, 8897, 8898, 8899, 8853
408, 8354, 8376, 8377, 8355, 8899, 8900, 8901, 8855
409, 8355, 8377, 8378, 8356, 8901, 8902, 8903, 8857
410, 8356, 8378, 8379, 8357, 8903, 8904, 8905, 8859
411, 8357, 8379, 8380, 8358, 8905, 8906, 8907, 8861
412, 8358, 8380, 8381, 8359, 8907, 8908, 8909, 8863
413, 8359, 8381, 8382, 8360, 8909, 8910, 8911, 8865
414, 8360, 8382, 719, 718, 8911, 8912, 741, 8867
415, 653, 654, 8383, 8361, 676, 8913, 8914, 8868
416, 8361, 8383, 8384, 8362, 8914, 8915, 8916, 8870
417, 8362, 8384, 8385, 8363, 8916, 8917, 8918, 8872
418, 8363, 8385, 8386, 8364, 8918, 8919, 8920, 8874
419, 8364, 8386, 8387, 8365, 8920, 8921, 8922, 8876
420, 8365, 8387, 8388, 8366, 8922, 8923, 8924, 8878
421, 8366, 8388, 8389, 8367, 8924, 8925, 8926, 8880
422, 8367, 8389, 8390, 8368, 8926, 8927, 8928, 8882
423, 8368, 8390, 8391, 8369, 8928, 8929, 8930, 8884
424, 8369, 8391, 8392, 8370, 8930, 8931, 8932, 8886
425, 8370, 8392, 8393, 8371, 8932, 8933, 8934, 8888
426, 8371, 8393, 8394, 8372, 8934, 8935, 8936, 8890
427, 8372, 8394, 8395, 8373, 8936, 8937, 8938, 8892
428, 8373, 8395, 8396, 8374, 8938, 8939, 8940, 8894
429, 8374, 8396, 8397, 8375, 8940, 8941, 8942, 8896
430, 8375, 8397, 8398, 8376, 8942, 8943, 8944, 8898
431, 8376, 8398, 8399, 8377, 8944, 8945, 8946, 8900
432, 8377, 8399, 8400, 8378, 8946, 8947, 8948, 8902
433, 8378, 8400, 8401, 8379, 8948, 8949, 8950, 8904
434, 8379, 8401, 8402, 8380, 8950, 8951, 8952, 8906
435, 8380, 8402, 8403, 8381, 8952, 8953, 8954, 8908
436, 8381, 8403, 8404, 8382, 8954, 8955, 8956, 8910
437, 8382, 8404, 720, 719, 8956, 8957, 742, 8912
438, 654, 655, 8405, 8383, 677, 8958, 8959, 8913
439, 8383, 8405, 8406, 8384, 8959, 8960, 8961, 8915
440, 8384, 8406, 8407, 8385, 8961, 8962, 8963, 8917
441, 8385, 8407, 8408, 8386, 8963, 8964, 8965, 8919
442, 8386, 8408, 8409, 8387, 8965, 8966, 8967, 8921
443, 8387, 8409, 8410, 8388, 8967, 8968, 8969, 8923
444, 8388, 8410, 8411, 8389, 8969, 8970, 8971, 8925
445, 8389, 8411, 8412, 8390, 8971, 8972, 8973, 8927
446, 8390, 8412, 8413, 8391, 8973, 8974, 8975, 8929
447, 8391, 8413, 8414, 8392, 8975, 8976, 8977, 8931
448, 8392, 8414, 8415, 8393, 8977, 8978, 8979, 8933
449, 8393, 8415, 8416, 8394, 8979, 8980, 8981, 8935
450, 8394, 8416, 8417, 8395, 8981, 8982, 8983, 8937
451, 8395, 8417, 8418, 8396, 8983, 8984, 8985, 8939
452, 8396, 8418, 8419, 8397, 8985, 8986, 8987, 8941
453, 8397, 8419, 8420, 8398, 8987, 8988, 8989, 8943
454, 8398, 8420, 8421, 8399, 8989, 8990, 8991, 8945
455, 8399, 8421, 8422, 8400, 8991, 8992, 8993, 8947
456, 8400, 8422, 8423, 8401, 8993, 8994, 8995, 8949
457, 8401, 8423, 8424, 8402, 8995, 8996, 8997, 8951
458, 8402, 8424, 8425, 8403, 8997, 8998, 8999, 8953
459, 8403, 8425, 8426, 8404, 8999, 9000, 9001, 8955
460, 8404, 8426, 721, 720, 9001, 9002, 743, 8957
461, 655, 656, 8427, 8405, 678, 9003, 9004, 8958
462, 8405, 8427, 8428, 8406, 9004, 9005, 9006, 8960
463, 8406, 8428, 8429, 8407, 9006, 9007, 9008, 8962
464, 8407, 8429, 8430, 8408, 9008, 9009, 9010, 8964
465, 8408, 8430, 8431, 8409, 9010, 9011, 9012, 8966
466, 8409, 8431, 8432, 8410, 9012, 9013, 9014, 8968
467, 8410, 8432, 8433, 8411, 9014, 9015, 9016, 8970
468, 8411, 8433, 8434, 8412, 9016, 9017, 9018, 8972
469, 8412, 8434, 8435, 8413, 9018, 9019, 9020, 8974
470, 8413, 8435, 8436, 8414, 9020, 9021, 9022, 8976
471, 8414, 8436, 8437, 8415, 9022, 9023, 9024, 8978
472, 8415, 8437, 8438, 8416, 9024, 9025, 9026, 8980
473, 8416, 8438, 8439, 8417, 9026, 9027, 9028, 8982
474, 8417, 8439, 8440, 8418, 9028, 9029, 9030, 8984
475, 8418, 8440, 8441, 8419, 9030, 9031, 9032, 8986
476, 8419, 8441, 8442, 8420, 9032, 9033, 9034, 8988
477, 8420, 8442, 8443, 8421, 9034, 9035, 9036, 8990
478, 8421, 8443, 8444, 8422, 9036, 9037, 9038, 8992
479, 8422, 8444, 8445, 8423, 9038, 9039, 9040, 8994
480, 8423, 8445, 8446, 8424, 9040, 9041, 9042, 8996
481, 8424, 8446, 8447, 8425, 9042, 9043, 9044, 8998
482, 8425, 8447, 8448, 8426, 9044, 9045, 9046, 9000
483, 8426, 8448, 722, 721, 9046, 9047, 744, 9002
484, 656, 657, 8449, 8427, 679, 9048, 9049, 9003
485, 8427, 8449, 8450, 8428, 9049, 9050, 9051, 9005
486, 8428, 8450, 8451, 8429, 9051, 9052, 9053, 9007
487, 8429, 8451, 8452, 8430, 9053, 9054, 9055, 9009
488, 8430, 8452, 8453, 8431, 9055, 9056, 9057, 9011
489, 8431, 8453, 8454, 8432, 9057, 9058, 9059, 9013
490, 8432, 8454, 8455, 8433, 9059, 9060, 9061, 9015
491, 8433, 8455, 8456, 8434, 9061, 9062, 9063, 9017
492, 8434, 8456, 8457, 8435, 9063, 9064, 9065, 9019
493, 8435, 8457, 8458, 8436, 9065, 9066, 9067, 9021
494, 8436, 8458, 8459, 8437, 9067, 9068, 9069, 9023
495, 8437, 8459, 8460, 8438, 9069, 9070, 9071, 9025
496, 8438, 8460, 8461, 8439, 9071, 9072, 9073, 9027
497, 8439, 8461, 8462, 8440, 9073, 9074, 9075, 9029
498, 8440, 8462, 8463, 8441, 9075, 9076, 9077, 9031
499, 8441, 8463, 8464, 8442, 9077, 9078, 9079, 9033
500, 8442, 8464, 8465, 8443, 9079, 9080, 9081, 9035
501, 8443, 8465, 8466, 8444, 9081, 9082, 9083, 9037
502, 8444, 8466, 8467, 8445, 9083, 9084, 9085, 9039
503, 8445, 8467, 8468, 8446, 9085, 9086, 9087, 9041
504, 8446, 8468, 8469, 8447, 9087, 9088, 9089, 9043
505, 8447, 8469, 8470, 8448, 9089, 9090, 9091, 9045
506, 8448, 8470, 723, 722, 9091, 9092, 745, 9047
507, 657, 658, 8471, 8449, 680, 9093, 9094, 9048
508, 8449, 8471, 8472, 8450, 9094, 9095, 9096, 9050
509, 8450, 8472, 8473, 8451, 9096, 9097, 9098, 9052
510, 8451, 8473, 8474, 8452, 9098, 9099, 9100, 9054
511, 8452, 8474, 8475, 8453, 9100, 9101, 9102, 9056
512, 8453, 8475, 8476, 8454, 9102, 9103, 9104, 9058
513, 8454, 8476, 8477, 8455, 9104, 9105, 9106, 9060
514, 8455, 8477, 8478, 8456, 9106, 9107, 9108, 9062
515, 8456, 8478, 8479, 8457, 9108, 9109, 9110, 9064
516, 8457, 8479, 8480, 8458, 9110, 9111, 9112, 9066
517, 8458, 8480, 8481, 8459, 9112, 9113, 9114, 9068
518, 8459, 8481, 8482, 8460, 9114, 9115, 9116, 9070
519, 8460, 8482, 8483, 8461, 9116, 9117, 9118, 9072
520, 8461, 8483, 8484, 8462, 9118, 9119, 9120, 9074
521, 8462, 8484, 8485, 8463, 9120, 9121, 9122, 9076
522, 8463, 8485, 8486, 8464, 9122, 9123, 9124, 9078
523, 8464, 8486, 8487, 8465, 9124, 9125, 9126, 9080
524, 8465, 8487, 8488, 8466, 9126, 9127, 9128, 9082
525, 8466, 8488, 8489, 8467, 9128, 9129, 9130, 9084
526, 8467, 8489, 8490, 8468, 9130, 9131, 9132, 9086
527, 8468, 8490, 8491, 8469, 9132, 9133, 9134, 9088
528, 8469, 8491, 8492, 8470, 9134, 9135, 9136, 9090
529, 8470, 8492, 724, 723, 9136, 9137, 746, 9092
530, 658, 659, 8493, 8471, 681, 9138, 9139, 9093
531, 8471, 8493, 8494, 8472, 9139, 9140, 9141, 9095
532, 8472, 8494, 8495, 8473, 9141, 9142, 9143, 9097
533, 8473, 8495, 8496, 8474, 9143, 9144, 9145, 9099
534, 8474, 8496, 8497, 8475, 9145, 9146, 9147, 9101
535, 8475, 8497, 8498, 8476, 9147, 9148, 9149, 9103
536, 8476, 8498, 8499, 8477, 9149, 9150, 9151, 9105
537, 8477, 8499, 8500, 8478, 9151, 9152, 9153, 9107
538, 8478, 8500, 8501, 8479, 9153, 9154, 9155, 9109
539, 8479, 8501, 8502, 8480, 9155, 9156, 9157, 9111
540, 8480, 8502, 8503, 8481, 9157, 9158, 9159, 9113
541, 8481, 8503, 8504, 8482, 9159, 9160, 9161, 9115
542, 8482, 8504, 8505, 8483, 9161, 9162, 9163, 9117
543, 8483, 8505, 8506, 8484, 9163, 9164, 9165, 9119
544, 8484, 8506, 8507, 8485, 9165, 9166, 9167, 9121
545, 8485, 8507, 8508, 8486, 9167, 9168, 9169, 9123
546, 8486, 8508, 8509, 8487, 9169, 9170, 9171, 9125
547, 8487, 8509, 8510, 8488, 9171, 9172, 9173, 9127
548, 8488, 8510, 8511, 8489, 9173, 9174, 9175, 9129
549, 8489, 8511, 8512, 8490, 9175, 9176, 9177, 9131
550, 8490, 8512, 8513, 8491, 9177, 9178, 9179, 9133
551, 8491, 8513, 8514, 8492, 9179, 9180, 9181, 9135
552, 8492, 8514, 725, 724, 9181, 9182, 747, 9137
553, 659, 660, 8515, 8493, 682, 9183, 9184, 9138
554, 8493, 8515, 8516, 8494, 9184, 9185, 9186, 9140
555, 8494, 8516, 8517, 8495, 9186, 9187, 9188, 9142
556, 8495, 8517, 8518, 8496, 9188, 9189, 9190, 9144
557, 8496, 8518, 8519, 8497, 9190, 9191, 9192, 9146
558, 8497, 8519, 8520, 8498, 9192, 9193, 9194, 9148
559, 8498, 8520, 8521, 8499, 9194, 9195, 9196, 9150
560, 8499, 8521, 8522, 8500, 9196, 9197, 9198, 9152
561, 8500, 8522, 8523, 8501, 9198, 9199, 9200, 9154
562, 8501, 8523, 8524, 8502, 9200, 9201, 9202, 9156
563, 8502, 8524, 8525, 8503, 9202, 9203, 9204, 9158
564, 8503, 8525, 8526, 8504, 9204, 9205, 9206, 9160
565, 8504, 8526, 8527, 8505, 9206, 9207, 9208, 9162
566, 8505, 8527, 8528, 8506, 9208, 9209, 9210, 9164
567, 8506, 8528, 8529, 8507, 9210, 9211, 9212, 9166
568, 8507, 8529, 8530, 8508, 9212, 9213, 9214, 9168
569, 8508, 8530, 8531, 8509, 9214, 9215, 9216, 9170
570, 8509, 8531, 8532, 8510, 9216, 9217, 9218, 9172
571, 8510, 8532, 8533, 8511, 9218, 9219, 9220, 9174
572, 8511, 8533, 8534, 8512, 9220, 9221, 9222, 9176
573, 8512, 8534, 8535, 8513, 9222, 9223, 9224, 9178
574, 8513, 8535, 8536, 8514, 9224, 9225, 9226, 9180
575, 8514, 8536, 726, 725, 9226, 9227, 748, 9182
576, 660, 661, 8537, 8515, 683, 9228, 9229, 9183
577, 8515, 8537, 8538, 8516, 9229, 9230, 9231, 9185
578, 8516, 8538, 8539, 8517, 9231, 9232, 9233, 9187
579, 8517, 8539, 8540, 8518, 9233, 9234, 9235, 9189
580, 8518, 8540, 8541, 8519, 9235, 9236, 9237, 9191
581, 8519, 8541, 8542, 8520, 9237, 9238, 9239, 9193
582, 8520, 8542, 8543, 8521, 9239, 9240, 9241, 9195
583, 8521, 8543, 8544, 8522, 9241, 9242, 9243, 9197
584, 8522, 8544, 8545, 8523, 9243, 9244, 9245, 9199
585, 8523, 8545, 8546, 8524, 9245, 9246, 9247, 9201
586, 8524, 8546, 8547, 8525, 9247, 9248, 9249, 9203
587, 8525, 8547, 8548, 8526, 9249, 9250, 9251, 9205
588, 8526, 8548, 8549, 8527, 9251, 9252, 9253, 9207
589, 8527, 8549, 8550, 8528, 9253, 9254, 9255, 9209
590, 8528, 8550, 8551, 8529, 9255, 9256, 9257, 9211
591, 8529, 8551, 8552, 8530, 9257, 9258, 9259, 9213
592, 8530, 8552, 8553, 8531, 9259, 9260, 9261, 9215
593, 8531, 8553, 8554, 8532, 9261, 9262, 9263, 9217
594, 8532, 8554, 8555, 8533, 9263, 9264, 9265, 9219
595, 8533, 8555, 8556, 8534, 9265, 9266, 9267, 9221
596, 8534, 8556, 8557, 8535, 9267, 9268, 9269, 9223
597, 8535, 8557, 8558, 8536, 9269, 9270, 9271, 9225
598, 8536, 8558, 727, 726, 9271, 9272, 749, 9227
599, 661, 662, 8559, 8537, 684, 9273, 9274, 9228
600, 8537, 8559, 8560, 8538, 9274, 9275, 9276, 9230
601, 8538, 8560, 8561, 8539, 9276, 9277, 9278, 9232
602, 8539, 8561, 8562, 8540, 9278, 9279, 9280, 9234
603, 8540, 8562, 8563, 8541, 9280, 9281, 9282, 9236
604, 8541, 8563, 8564, 8542, 9282, 9283, 9284, 9238
605, 8542, 8564, 8565, 8543, 9284, 9285, 9286, 9240
606, 8543, 8565, 8566, 8544, 9286, 9287, 9288, 9242
607, 8544, 8566, 8567, 8545, 9288, 9289, 9290, 9244
608, 8545, 8567, 8568, 8546, 9290, 9291, 9292, 9246
609, 8546, 8568, 8569, 8547, 9292, 9293, 9294, 9248
610, 8547, 8569, 8570, 8548, 9294, 9295, 9296, 9250
611, 8548, 8570, 8571, 8549, 9296, 9297, 9298, 9252
612, 8549, 8571, 8572, 8550, 9298, 9299, 9300, 9254
613, 8550, 8572, 8573, 8551, 9300, 9301, 9302, 9256
614, 8551, 8573, 8574, 8552, 9302, 9303, 9304, 9258
615, 8552, 8574, 8575, 8553, 9304, 9305, 9306, 9260
616, 8553, 8575, 8576, 8554, 9306, 9307, 9308, 9262
617, 8554, 8576, 8577, 8555, 9308, 9309, 9310, 9264
618, 8555, 8577, 8578, 8556, 9310, 9311, 9312, 9266
619, 8556, 8578, 8579, 8557, 9312, 9313, 9314, 9268
620, 8557, 8579, 8580, 8558, 9314, 9315, 9316, 9270
621, 8558, 8580, 728, 727, 9316, 9317, 750, 9272
622, 662, 663, 8581, 8559, 685, 9318, 9319, 9273
623, 8559, 8581, 8582, 8560, 9319, 9320, 9321, 9275
624, 8560, 8582, 8583, 8561, 9321, 9322, 9323, 9277
625, 8561, 8583, 8584, 8562, 9323, 9324, 9325, 9279
626, 8562, 8584, 8585, 8563, 9325, 9326, 9327, 9281
627, 8563, 8585, 8586, 8564, 9327, 9328, 9329, 9283
628, 8564, 8586, 8587, 8565, 9329, 9330, 9331, 9285
629, 8565, 8587, 8588, 8566, 9331, 9332, 9333, 9287
630, 8566, 8588, 8589, 8567, 9333, 9334, 9335, 9289
631, 8567, 8589, 8590, 8568, 9335, 9336, 9337, 9291
632, 8568, 8590, 8591, 8569, 9337, 9338, 9339, 9293
633, 8569, 8591, 8592, 8570, 9339, 9340, 9341, 9295
634, 8570, 8592, 8593, 8571, 9341, 9342, 9343, 9297
635, 8571, 8593, 8594, 8572, 9343, 9344, 9345, 9299
636, 8572, 8594, 8595, 8573, 9345, 9346, 9347, 9301
637, 8573, 8595, 8596, 8574, 9347, 9348, 9349, 9303
638, 8574, 8596, 8597, 8575, 9349, 9350, 9351, 9305
639, 8575, 8597, 8598, 8576, 9351, 9352, 9353, 9307
640, 8576, 8598, 8599, 8577, 9353, 9354, 9355, 9309
641, 8577, 8599, 8600, 8578, 9355, 9356, 9357, 9311
642, 8578, 8600, 8601, 8579, 9357, 9358, 9359, 9313
643, 8579, 8601, 8602, 8580, 9359, 9360, 9361, 9315
644, 8580, 8602, 729, 728, 9361, 9362, 751, 9317
645, 663, 664, 8603, 8581, 686, 9363, 9364, 9318
646, 8581, 8603, 8604, 8582, 9364, 9365, 9366, 9320
647, 8582, 8604, 8605, 8583, 9366, 9367, 9368, 9322
648, 8583, 8605, 8606, 8584, 9368, 9369, 9370, 9324
649, 8584, 8606, 8607, 8585, 9370, 9371, 9372, 9326
650, 8585, 8607, 8608, 8586, 9372, 9373, 9374, 9328
651, 8586, 8608, 8609, 8587, 9374, 9375, 9376, 9330
652, 8587, 8609, 8610, 8588, 9376, 9377, 9378, 9332
653, 8588, 8610, 8611, 8589, 9378, 9379, 9380, 9334
654, 8589, 8611, 8612, 8590, 9380, 9381, 9382, 9336
655, 8590, 8612, 8613, 8591, 9382, 9383, 9384, 9338
656, 8591, 8613, 8614, 8592, 9384, 9385, 9386, 9340
657, 8592, 8614, 8615, 8593, 9386, 9387, 9388, 9342
658, 8593, 8615, 8616, 8594, 9388, 9389, 9390, 9344
659, 8594, 8616, 8617, 8595, 9390, 9391, 9392, 9346
660, 8595, 8617, 8618, 8596, 9392, 9393, 9394, 9348
661, 8596, 8618, 8619, 8597, 9394, 9395, 9396, 9350
662, 8597, 8619, 8620, 8598, 9396, 9397, 9398, 9352
663, 8598, 8620, 8621, 8599, 9398, 9399, 9400, 9354
664, 8599, 8621, 8622, 8600, 9400, 9401, 9402, 9356
665, 8600, 8622, 8623, 8601, 9402, 9403, 9404, 9358
666, 8601, 8623, 8624, 8602, 9404, 9405, 9406, 9360
667, 8602, 8624, 730, 729, 9406, 9407, 752, 9362
668, 664, 665, 8625, 8603, 687, 9408, 9409, 9363
669, 8603, 8625, 8626, 8604, 9409, 9410, 9411, 9365
670, 8604, 8626, 8627, 8605, 9411, 9412, 9413, 9367
671, 8605, 8627, 8628, 8606, 9413, 9414, 9415, 9369
672, 8606, 8628, 8629, 8607, 9415, 9416, 9417, 9371
673, 8607, 8629, 8630, 8608, 9417, 9418, 9419, 9373
674, 8608, 8630, 8631, 8609, 9419, 9420, 9421, 9375
675, 8609, 8631, 8632, 8610, 9421, 9422, 9423, 9377
676, 8610, 8632, 8633, 8611, 9423, 9424, 9425, 9379
677, 8611, 8633, 8634, 8612, 9425, 9426, 9427, 9381
678, 8612, 8634, 8635, 8613, 9427, 9428, 9429, 9383
679, 8613, 8635, 8636, 8614, 9429, 9430, 9431, 9385
680, 8614, 8636, 8637, 8615, 9431, 9432, 9433, 9387
681, 8615, 8637, 8638, 8616, 9433, 9434, 9435, 9389
682, 8616, 8638, 8639, 8617, 9435, 9436, 9437, 9391
683, 8617, 8639, 8640, 8618, 9437, 9438, 9439, 9393
684, 8618, 8640, 8641, 8619, 9439, 9440, 9441, 9395
685, 8619, 8641, 8642, 8620, 9441, 9442, 9443, 9397
686, 8620, 8642, 8643, 8621, 9443, 9444, 9445, 9399
687, 8621, 8643, 8644, 8622, 9445, 9446, 9447, 9401
688, 8622, 8644, 8645, 8623, 9447, 9448, 9449, 9403
689, 8623, 8645, 8646, 8624, 9449, 9450, 9451, 9405
690, 8624, 8646, 731, 730, 9451, 9452, 753, 9407
691, 665, 666, 8647, 8625, 688, 9453, 9454, 9408
692, 8625, 8647, 8648, 8626, 9454, 9455, 9456, 9410
693, 8626, 8648, 8649, 8627, 9456, 9457, 9458, 9412
694, 8627, 8649, 8650, 8628, 9458, 9459, 9460, 9414
695, 8628, 8650, 8651, 8629, 9460, 9461, 9462, 9416
696, 8629, 8651, 8652, 8630, 9462, 9463, 9464, 9418
697, 8630, 8652, 8653, 8631, 9464, 9465, 9466, 9420
698, 8631, 8653, 8654, 8632, 9466, 9467, 9468, 9422
699, 8632, 8654, 8655, 8633, 9468, 9469, 9470, 9424
700, 8633, 8655, 8656, 8634, 9470, 9471, 9472, 9426
701, 8634, 8656, 8657, 8635, 9472, 9473, 9474, 9428
702, 8635, 8657, 8658, 8636, 9474, 9475, 9476, 9430
703, 8636, 8658, 8659, 8637, 9476, 9477, 9478, 9432
704, 8637, 8659, 8660, 8638, 9478, 9479, 9480, 9434
705, 8638, 8660, 8661, 8639, 9480, 9481, 9482, 9436
706, 8639, 8661, 8662, 8640, 9482, 9483, 9484, 9438
707, 8640, 8662, 8663, 8641, 9484, 9485, 9486, 9440
708, 8641, 8663, 8664, 8642, 9486, 9487, 9488, 9442
709, 8642, 8664, 8665, 8643, 9488, 9489, 9490, 9444
710, 8643, 8665, 8666, 8644, 9490, 9491, 9492, 9446
711, 8644, 8666, 8667, 8645, 9492, 9493, 9494, 9448
712, 8645, 8667, 8668, 8646, 9494, 9495, 9496, 9450
713, 8646, 8668, 732, 731, 9496, 9497, 754, 9452
714, 666, 667, 8669, 8647, 689, 9498, 9499, 9453
715, 8647, 8669, 8670, 8648, 9499, 9500, 9501, 9455
716, 8648, 8670, 8671, 8649, 9501, 9502, 9503, 9457
717, 8649, 8671, 8672, 8650, 9503, 9504, 9505, 9459
718, 8650, 8672, 8673, 8651, 9505, 9506, 9507, 9461
719, 8651, 8673, 8674, 8652, 9507, 9508, 9509, 9463
720, 8652, 8674, 8675, 8653, 9509, 9510, 9511, 9465
721, 8653, 8675, 8676, 8654, 9511, 9512, 9513, 9467
722, 8654, 8676, 8677, 8655, 9513, 9514, 9515, 9469
723, 8655, 8677, 8678, 8656, 9515, 9516, 9517, 9471
724, 8656, 8678, 8679, 8657, 9517, 9518, 9519, 9473
725, 8657, 8679, 8680, 8658, 9519, 9520, 9521, 9475
726, 8658, 8680, 8681, 8659, 9521, 9522, 9523, 9477
727, 8659, 8681, 8682, 8660, 9523, 9524, 9525, 9479
728, 8660, 8682, 8683, 8661, 9525, 9526, 9527, 9481
729, 8661, 8683, 8684, 8662, 9527, 9528, 9529, 9483
730, 8662, 8684, 8685, 8663, 9529, 9530, 9531, 9485
731, 8663, 8685, 8686, 8664, 9531, 9532, 9533, 9487
732, 8664, 8686, 8687, 8665, 9533, 9534, 9535, 9489
733, 8665, 8687, 8688, 8666, 9535, 9536, 9537, 9491
734, 8666, 8688, 8689, 8667, 9537, 9538, 9539, 9493
735, 8667, 8689, 8690, 8668, 9539, 9540, 9541, 9495
736, 8668, 8690, 733, 732, 9541, 9542, 755, 9497
737, 667, 668, 8691, 8669, 690, 9543, 9544, 9498
738, 8669, 8691, 8692, 8670, 9544, 9545, 9546, 9500
739, 8670, 8692, 8693, 8671, 9546, 9547, 9548, 9502
740, 8671, 8693, 8694, 8672, 9548, 9549, 9550, 9504
741, 8672, 8694, 8695, 8673, 9550, 9551, 9552, 9506
742, 8673, 8695, 8696, 8674, 9552, 9553, 9554, 9508
743, 8674, 8696, 8697, 8675, 9554, 9555, 9556, 9510
744, 8675, 8697, 8698, 8676, 9556, 9557, 9558, 9512
745, 8676, 8698, 8699, 8677, 9558, 9559, 9560, 9514
746, 8677, 8699, 8700, 8678, 9560, 9561, 9562, 9516
747, 8678, 8700, 8701, 8679, 9562, 9563, 9564, 9518
748, 8679, 8701, 8702, 8680, 9564, 9565, 9566, 9520
749, 8680, 8702, 8703, 8681, 9566, 9567, 9568, 9522
750, 8681, 8703, 8704, 8682, 9568, 9569, 9570, 9524
751, 8682, 8704, 8705, 8683, 9570, 9571, 9572, 9526
752, 8683, 8705, 8706, 8684, 9572, 9573, 9574, 9528
753, 8684, 8706, 8707, 8685, 9574, 9575, 9576, 9530
754, 8685, 8707, 8708, 8686, 9576, 9577, 9578, 9532
755, 8686, 8708, 8709, 8687, 9578, 9579, 9580, 9534
756, 8687, 8709, 8710, 8688, 9580, 9581, 9582, 9536
757, 8688, 8710, 8711, 8689, 9582, 9583, 9584, 9538
758, 8689, 8711, 8712, 8690, 9584, 9585, 9586, 9540
759, 8690, 8712, 734, 733, 9586, 9587, 756, 9542
760, 668, 669, 8713, 8691, 691, 9588, 9589, 9543
761, 8691, 8713, 8714, 8692, 9589, 9590, 9591, 9545
762, 8692, 8714, 8715, 8693, 9591, 9592, 9593, 9547
763, 8693, 8715, 8716, 8694, 9593, 9594, 9595, 9549
764, 8694, 8716, 8717, 8695, 9595, 9596, 9597, 9551
765, 8695, 8717, 8718, 8696, 9597, 9598, 9599, 9553
766, 8696, 8718, 8719, 8697, 9599, 9600, 9601, 9555
767, 8697, 8719, 8720, 8698, 9601, 9602, 9603, 9557
768, 8698, 8720, 8721, 8699, 9603, 9604, 9605, 9559
769, 8699, 8721, 8722, 8700, 9605, 9606, 9607, 9561
770, 8700, 8722, 8723, 8701, 9607, 9608, 9609, 9563
771, 8701, 8723, 8724, 8702, 9609, 9610, 9611, 9565
772, 8702, 8724, 8725, 8703, 9611, 9612, 9613, 9567
773, 8703, 8725, 8726, 8704, 9613, 9614, 9615, 9569
774, 8704, 8726, 8727, 8705, 9615, 9616, 9617, 9571
775, 8705, 8727, 8728, 8706, 9617, 9618, 9619, 9573
776, 8706, 8728, 8729, 8707, 9619, 9620, 9621, 9575
777, 8707, 8729, 8730, 8708, 9621, 9622, 9623, 9577
778, 8708, 8730, 8731, 8709, 9623, 9624, 9625, 9579
779, 8709, 8731, 8732, 8710, 9625, 9626, 9627, 9581
780, 8710, 8732, 8733, 8711, 9627, 9628, 9629, 9583
781, 8711, 8733, 8734, 8712, 9629, 9630, 9631, 9585
782, 8712, 8734, 735, 734, 9631, 9632, 757, 9587
783, 669, 670, 8735, 8713, 692, 9633, 9634, 9588
784, 8713, 8735, 8736, 8714, 9634, 9635, 9636, 9590
785, 8714, 8736, 8737, 8715, 9636, 9637, 9638, 9592
786, 8715, 8737, 8738, 8716, 9638, 9639, 9640, 9594
787, 8716, 8738, 8739, 8717, 9640, 9641, 9642, 9596
788, 8717, 8739, 8740, 8718, 9642, 9643, 9644, 9598
789, 8718, 8740, 8741, 8719, 9644, 9645, 9646, 9600
790, 8719, 8741, 8742, 8720, 9646, 9647, 9648, 9602
791, 8720, 8742, 8743, 8721, 9648, 9649, 9650, 9604
792, 8721, 8743, 8744, 8722, 9650, 9651, 9652, 9606
793, 8722, 8744, 8745, 8723, 9652, 9653, 9654, 9608
794, 8723, 8745, 8746, 8724, 9654, 9655, 9656, 9610
795, 8724, 8746, 8747, 8725, 9656, 9657, 9658, 9612
796, 8725, 8747, 8748, 8726, 9658, 9659, 9660, 9614
797, 8726, 8748, 8749, 8727, 9660, 9661, 9662, 9616
798, 8727, 8749, 8750, 8728, 9662, 9663, 9664, 9618
799, 8728, 8750, 8751, 8729, 9664, 9665, 9666, 9620
800, 8729, 8751, 8752, 8730, 9666, 9667, 9668, 9622
801, 8730, 8752, 8753, 8731, 9668, 9669, 9670, 9624
802, 8731, 8753, 8754, 8732, 9670, 9671, 9672, 9626
803, 8732, 8754, 8755, 8733, 9672, 9673, 9674, 9628
804, 8733, 8755, 8756, 8734, 9674, 9675, 9676, 9630
805, 8734, 8756, 736, 735, 9676, 9677, 758, 9632
806, 670, 671, 8757, 8735, 693, 9678, 9679, 9633
807, 8735, 8757, 8758, 8736, 9679, 9680, 9681, 9635
808, 8736, 8758, 8759, 8737, 9681, 9682, 9683, 9637
809, 8737, 8759, 8760, 8738, 9683, 9684, 9685, 9639
810, 8738, 8760, 8761, 8739, 9685, 9686, 9687, 9641
811, 8739, 8761, 8762, 8740, 9687, 9688, 9689, 9643
812, 8740, 8762, 8763, 8741, 9689, 9690, 9691, 9645
813, 8741, 8763, 8764, 8742, 9691, 9692, 9693, 9647
814, 8742, 8764, 8765, 8743, 9693, 9694, 9695, 9649
815, 8743, 8765, 8766, 8744, 9695, 9696, 9697, 9651
816, 8744, 8766, 8767, 8745, 9697, 9698, 9699, 9653
817, 8745, 8767, 8768, 8746, 9699, 9700, 9701, 9655
818, 8746, 8768, 8769, 8747, 9701, 9702, 9703, 9657
819, 8747, 8769, 8770, 8748, 9703, 9704, 9705, 9659
820, 8748, 8770, 8771, 8749, 9705, 9706, 9707, 9661
821, 8749, 8771, 8772, 8750, 9707, 9708, 9709, 9663
822, 8750, 8772, 8773, 8751, 9709, 9710, 9711, 9665
823, 8751, 8773, 8774, 8752, 9711, 9712, 9713, 9667
824, 8752, 8774, 8775, 8753, 9713, 9714, 9715, 9669
825, 8753, 8775, 8776, 8754, 9715, 9716, 9717, 9671
826, 8754, 8776, 8777, 8755, 9717, 9718, 9719, 9673
827, 8755, 8777, 8778, 8756, 9719, 9720, 9721, 9675
828, 8756, 8778, 737, 736, 9721, 9722, 759, 9677
829, 671, 672, 8779, 8757, 694, 9723, 9724, 9678
830, 8757, 8779, 8780, 8758, 9724, 9725, 9726, 9680
831, 8758, 8780, 8781, 8759, 9726, 9727, 9728, 9682
832, 8759, 8781, 8782, 8760, 9728, 9729, 9730, 9684
833, 8760, 8782, 8783, 8761, 9730, 9731, 9732, 9686
834, 8761, 8783, 8784, 8762, 9732, 9733, 9734, 9688
835, 8762, 8784, 8785, 8763, 9734, 9735, 9736, 9690
836, 8763, 8785, 8786, 8764, 9736, 9737, 9738, 9692
837, 8764, 8786, 8787, 8765, 9738, 9739, 9740, 9694
838, 8765, 8787, 8788, 8766, 9740, 9741, 9742, 9696
839, 8766, 8788, 8789, 8767, 9742, 9743, 9744, 9698
840, 8767, 8789, 8790, 8768, 9744, 9745, 9746, 9700
841, 8768, 8790, 8791, 8769, 9746, 9747, 9748, 9702
842, 8769, 8791, 8792, 8770, 9748, 9749, 9750, 9704
843, 8770, 8792, 8793, 8771, 9750, 9751, 9752, 9706
844, 8771, 8793, 8794, 8772, 9752, 9753, 9754, 9708
845, 8772, 8794, 8795, 8773, 9754, 9755, 9756, 9710
846, 8773, 8795, 8796, 8774, 9756, 9757, 9758, 9712
847, 8774, 8796, 8797, 8775, 9758, 9759, 9760, 9714
848, 8775, 8797, 8798, 8776, 9760, 9761, 9762, 9716
849, 8776, 8798, 8799, 8777, 9762, 9763, 9764, 9718
850, 8777, 8799, 8800, 8778, 9764, 9765, 9766, 9720
851, 8778, 8800, 738, 737, 9766, 9767, 760, 9722
852, 672, 673, 8801, 8779, 695, 9768, 9769, 9723
853, 8779, 8801, 8802, 8780, 9769, 9770, 9771, 9725
854, 8780, 8802, 8803, 8781, 9771, 9772, 9773, 9727
855, 8781, 8803, 8804, 8782, 9773, 9774, 9775, 9729
856, 8782, 8804, 8805, 8783, 9775, 9776, 9777, 9731
857, 8783, 8805, 8806, 8784, 9777, 9778, 9779, 9733
858, 8784, 8806, 8807, 8785, 9779, 9780, 9781, 9735
859, 8785, 8807, 8808, 8786, 9781, 9782, 9783, 9737
860, 8786, 8808, 8809, 8787, 9783, 9784, 9785, 9739
861, 8787, 8809, 8810, 8788, 9785, 9786, 9787, 9741
862, 8788, 8810, 8811, 8789, 9787, 9788, 9789, 9743
863, 8789, 8811, 8812, 8790, 9789, 9790, 9791, 9745
864, 8790, 8812, 8813, 8791, 9791, 9792, 9793, 9747
865, 8791, 8813, 8814, 8792, 9793, 9794, 9795, 9749
866, 8792, 8814, 8815, 8793, 9795, 9796, 9797, 9751
867, 8793, 8815, 8816, 8794, 9797, 9798, 9799, 9753
868, 8794, 8816, 8817, 8795, 9799, 9800, 9801, 9755
869, 8795, 8817, 8818, 8796, 9801, 9802, 9803, 9757
870, 8796, 8818, 8819, 8797, 9803, 9804, 9805, 9759
871, 8797, 8819, 8820, 8798, 9805, 9806, 9807, 9761
872, 8798, 8820, 8821, 8799, 9807, 9808, 9809, 9763
873, 8799, 8821, 8822, 8800, 9809, 9810, 9811, 9765
874, 8800, 8822, 739, 738, 9811, 9812, 761, 9767
875, 673, 15, 784, 8801, 696, 807, 9813, 9768
876, 8801, 784, 783, 8802, 9813, 806, 9814, 9770
877, 8802, 783, 782, 8803, 9814, 805, 9815, 9772
878, 8803, 782, 781, 8804, 9815, 804, 9816, 9774
879, 8804, 781, 780, 8805, 9816, 803, 9817, 9776
880, 8805, 780, 779, 8806, 9817, 802, 9818, 9778
881, 8806, 779, 778, 8807, 9818, 801, 9819, 9780
882, 8807, 778, 777, 8808, 9819, 800, 9820, 9782
883, 8808, 777, 776, 8809, 9820, 799, 9821, 9784
884, 8809, 776, 775, 8810, 9821, 798, 9822, 9786
885, 8810, 775, 774, 8811, 9822, 797, 9823, 9788
886, 8811, 774, 773, 8812, 9823, 796, 9824, 9790
887, 8812, 773, 772, 8813, 9824, 795, 9825, 9792
888, 8813, 772, 771, 8814, 9825, 794, 9826, 9794
889, 8814, 771, 770, 8815, 9826, 793, 9827, 9796
890, 8815, 770, 769, 8816, 9827, 792, 9828, 9798
891, 8816, 769, 768, 8817, 9828, 791, 9829, 9800
892, 8817, 768, 767, 8818, 9829, 790, 9830, 9802
893, 8818, 767, 766, 8819, 9830, 789, 9831, 9804
894, 8819, 766, 765, 8820, 9831, 788, 9832, 9806
895, 8820, 765, 764, 8821, 9832, 787, 9833, 9808
896, 8821, 764, 763, 8822, 9833, 786, 9834, 9810
897, 8822, 763, 16, 739, 9834, 785, 762, 9812
*ELEMENT, type=CPS8, ELSET=Surface15
30389, 12, 718, 9835, 505, 740, 10055, 10056, 516
30390, 505, 9835, 9836, 504, 10056, 10057, 10058, 515
30391, 504, 9836, 9837, 503, 10058, 10059, 10060, 514
30392, 503, 9837, 9838, 502, 10060, 10061, 10062, 513
30393, 502, 9838, 9839, 501, 10062, 10063, 10064, 512
30394, 501, 9839, 9840, 500, 10064, 10065, 10066, 511
30395, 500, 9840, 9841, 499, 10066, 10067, 10068, 510
30396, 499, 9841, 9842, 498, 10068, 10069, 10070, 509
30397, 498, 9842, 9843, 497, 10070, 10071, 10072, 508
30398, 497, 9843, 9844, 496, 10072, 10073, 10074, 507
30399, 496, 9844, 562, 10, 10074, 10075, 584, 506
30400, 718, 719, 9845, 9835, 741, 10076, 10077, 10055
30401, 9835, 9845, 9846, 9836, 10077, 10078, 10079, 10057
30402, 9836, 9846, 9847, 9837, 10079, 10080, 10081, 10059
30403, 9837, 9847, 9848, 9838, 10081, 10082, 10083, 10061
30404, 9838, 9848, 9849, 9839, 10083, 10084, 10085, 10063
30405, 9839, 9849, 9850, 9840, 10085, 10086, 10087, 10065
30406, 9840, 9850, 9851, 9841, 10087, 10088, 10089, 10067
30407, 9841, 9851, 9852, 9842, 10089, 10090, 10091, 10069
30408, 9842, 9852, 9853, 9843, 10091, 10092, 10093, 10071
30409, 9843, 9853, 9854, 9844, 10093, 10094, 10095, 10073
30410, 9844, 9854, 563, 562, 10095, 10096, 585, 10075
30411, 719, 720, 9855, 9845, 742, 10097, 10098, 10076
30412, 9845, 9855, 9856, 9846, 10098, 10099, 10100, 10078
30413, 9846, 9856, 9857, 9847, 10100, 10101, 10102, 10080
30414, 9847, 9857, 9858, 9848, 10102, 10103, 10104, 10082
30415, 9848, 9858, 9859, 9849, 10104, 10105, 10106, 10084
30416, 9849, 9859, 9860, 9850, 10106, 10107, 10108, 10086
30417, 9850, 9860, 9861, 9851, 10108, 10109, 10110, 10088
30418, 9851, 9861, 9862, 9852, 10110, 10111, 10112, 10090
30419, 9852, 9862, 9863, 9853, 10112, 10113, 10114, 10092
30420, 9853, 9863, 9864, 9854, 10114, 10115, 10116, 10094
30421, 9854, 9864, 564, 563, 10116, 10117, 586, 10096
30422, 720, 721, 9865, 9855, 743, 10118, 10119, 10097
30423, 9855, 9865, 9866, 9856, 10119, 10120, 10121, 10099
30424, 9856, 9866, 9867, 9857, 10121, 10122, 10123, 10101
30425, 9857, 9867, 9868, 9858, 10123, 10124, 10125, 10103
30426, 9858, 9868, 9869, 9859, 10125, 10126, 10127, 10105
30427, 9859, 9869, 9870, 9860, 10127, 10128, 10129, 10107
30428, 9860, 9870, 9871, 9861, 10129, 10130, 10131, 10109
30429, 9861, 9871, 9872, 9862, 10131, 10132, 10133, 10111
30430, 9862, 9872, 9873, 9863, 10133, 10134, 10135, 10113
30431, 9863, 9873, 9874, 9864, 10135, 10136, 10137, 10115
30432, 9864, 9874, 565, 564, 10137, 10138, 587, 10117
30433, 721, 722, 9875, 9865, 744, 10139, 10140, 10118
30434, 9865, 9875, 9876, 9866, 10140, 10141, 10142, 10120
30435, 9866, 9876, 9877, 9867, 10142, 10143, 10144, 10122
30436, 9867, 9877, 9878, 9868, 10144, 10145, 10146, 10124
30437, 9868, 9878, 9879, 9869, 10146, 10147, 10148, 10126
30438, 9869, 9879, 9880, 9870, 10148, 10149, 10150, 10128
30439, 9870, 9880, 9881, 9871, 10150, 10151, 10152, 10130
30440, 9871, 9881, 9882, 9872, 10152, 10153, 10154, 10132
30441, 9872, 9882, 9883, 9873, 10154, 10155, 10156, 10134
30442, 9873, 9883, 9884, 9874, 10156, 10157, 10158, 10136
30443, 9874, 9884, 566, 565, 10158, 10159, 588, 10138
30444, 722, 723, 9885, 9875, 745, 10160, 10161, 10139
30445, 9875, 9885, 9886, 9876, 10161, 10162, 10163, 10141
30446, 9876, 9886, 9887, 9877, 10163, 10164, 10165, 10143
30447, 9877, 9887, 9888, 9878, 10165, 10166, 10167, 10145
30448, 9878, 9888, 9889, 9879, 10167, 10168, 10169, 10147
30449, 9879, 9889, 9890, 9880, 10169, 10170, 10171, 10149
30450, 9880, 9890, 9891, 9881, 10171, 10172, 10173, 10151
30451, 9881, 9891, 9892, 9882, 10173, 10174, 10175, 10153
30452, 9882, 9892, 9893, 9883, 10175, 10176, 10177, 10155
30453, 9883, 9893, 9894, 9884, 10177, 10178, 10179, 10157
30454, 9884, 9894, 567, 566, 10179, 10180, 589, 10159
30455, 723, 724, 9895, 9885, 746, 10181, 10182, 10160
30456, 9885, 9895, 9896, 9886, 10182, 10183, 10184, 10162
30457, 9886, 9896, 9897, 9887, 10184, 10185, 10186, 10164
30458, 9887, 9897, 9898, 9888, 10186, 10187, 10188, 10166
30459, 9888, 9898, 9899, 9889, 10188, 10189, 10190, 10168
30460, 9889, 9899, 9900, 9890, 10190, 10191, 10192, 10170
30461, 9890, 9900, 9901, 9891, 10192, 10193, 10194, 10172
30462, 9891, 9901, 9902, 9892, 10194, 10195, 10196, 10174
30463, 9892, 9902, 9903, 9893, 10196, 10197, 10198, 10176
30464, 9893, 9903, 9904, 9894, 10198, 10199, 10200, 10178
30465, 9894, 9904, 568, 567, 10200, 10201, 590, 10180
30466, 724, 725, 9905, 9895, 747, 10202, 10203, 10181
30467, 9895, 9905, 9906, 9896, 10203, 10204, 10205, 10183
30468, 9896, 9906, 9907, 9897, 10205, 10206, 10207, 10185
30469, 9897, 9907, 9908, 9898, 10207, 10208, 10209, 10187
30470, 9898, 9908, 9909, 9899, 10209, 10210, 10211, 10189
30471, 9899, 9909, 9910, 9900, 10211, 10212, 10213, 10191
30472, 9900, 9910, 9911, 9901, 10213, 10214, 10215, 10193
30473, 9901, 9911, 9912, 9902, 10215, 10216, 10217, 10195
30474, 9902, 9912, 9913, 9903, 10217, 10218, 10219, 10197
30475, 9903, 9913, 9914, 9904, 10219, 10220, 10221, 10199
30476, 9904, 9914, 569, 568, 10221, 10222, 591, 10201
30477, 725, 726, 9915, 9905, 748, 10223, 10224, 10202
30478, 9905, 9915, 9916, 9906, 10224, 10225, 10226, 10204
30479, 9906, 9916, 9917, 9907, 10226, 10227, 10228, 10206
30480, 9907, 9917, 9918, 9908, 10228, 10229, 10230, 10208
30481, 9908, 9918, 9919, 9909, 10230, 10231, 10232, 10210
30482, 9909, 9919, 9920, 9910, 10232, 10233, 10234, 10212
30483, 9910, 9920, 9921, 9911, 10234, 10235, 10236, 10214
30484, 9911, 9921, 9922, 9912, 10236, 10237, 10238, 10216
30485, 9912, 9922, 9923, 9913, 10238, 10239, 10240, 10218
30486, 9913, 9923, 9924, 9914, 10240, 10241, 10242, 10220
30487, 9914, 9924, 570, 569, 10242, 10243, 592, 10222
30488, 726, 727, 9925, 9915, 749, 10244, 10245, 10223
30489, 9915, 9925, 9926, 9916, 10245, 10246, 10247, 10225
30490, 9916, 9926, 9927, 9917, 10247, 10248, 10249, 10227
30491, 9917, 9927, 9928, 9918, 10249, 10250, 10251, 10229
30492, 9918, 9928, 9929, 9919, 10251, 10252, 10253, 10231
30493, 9919, 9929, 9930, 9920, 10253, 10254, 10255, 10233
30494, 9920, 9930, 9931, 9921, 10255, 10256, 10257, 10235
30495, 9921, 9931, 9932, 9922, 10257, 10258, 10259, 10237
30496, 9922, 9932, 9933, 9923, 10259, 10260, 10261, 10239
30497, 9923, 9933, 9934, 9924, 10261, 10262, 10263, 10241
30498, 9924, 9934, 571, 570, 10263, 10264, 593, 10243
30499, 727, 728, 9935, 9925, 750, 10265, 10266, 10244
30500, 9925, 9935, 9936, 9926, 10266, 10267, 10268, 10246
30501, 9926, 9936, 9937, 9927, 10268, 10269, 10270, 10248
30502, 9927, 9937, 9938, 9928, 10270, 10271, 10272, 10250
30503, 9928, 9938, 9939, 9929, 10272, 10273, 10274, 10252
30504, 9929, 9939, 9940, 9930, 10274, 10275, 10276, 10254
30505, 9930, 9940, 9941, 9931, 10276, 10277, 10278, 10256
30506, 9931, 9941, 9942, 9932, 10278, 10279, 10280, 10258
30507, 9932, 9942, 9943, 9933, 10280, 10281, 10282, 10260
30508, 9933, 9943, 9944, 9934, 10282, 10283, 10284, 10262
30509, 9934, 9944, 572, 571, 10284, 10285, 594, 10264
30510, 728, 729, 9945, 9935, 751, 10286, 10287, 10265
30511, 9935, 9945, 9946, 9936, 10287, 10288, 10289, 10267
30512, 9936, 9946, 9947, 9937, 10289, 10290, 10291, 10269
30513, 9937, 9947, 9948, 9938, 10291, 10292, 10293, 10271
30514, 9938, 9948, 9949, 9939, 10293, 10294, 10295, 10273
30515, 9939, 9949, 9950, 9940, 10295, 10296, 10297, 10275
30516, 9940, 9950, 9951, 9941, 10297, 10298, 10299, 10277
30517, 9941, 9951, 9952, 9942, 10299, 10300, 10301, 10279
30518, 9942, 9952, 9953, 9943, 10301, 10302, 10303, 10281
30519, 9943, 9953, 9954, 9944, 10303, 10304, 10305, 10283
30520, 9944, 9954, 573, 572, 10305, 10306, 595, 10285
30521, 729, 730, 9955, 9945, 752, 10307, 10308, 10286
30522, 9945, 9955, 9956, 9946, 10308, 10309, 10310, 10288
30523, 9946, 9956, 9957, 9947, 10310, 10311, 10312, 10290
30524, 9947, 9957, 9958, 9948, 10312, 10313, 10314, 10292
30525, 9948, 9958, 9959, 9949, 10314, 10315, 10316, 10294
30526, 9949, 9959, 9960, 9950, 10316, 10317, 10318, 10296
30527, 9950, 9960, 9961, 9951, 10318, 10319, 10320, 10298
30528, 9951, 9961, 9962, 9952, 10320, 10321, 10322, 10300
30529, 9952, 9962, 9963, 9953, 10322, 10323, 10324, 10302
30530, 9953, 9963, 9964, 9954, 10324, 10325, 10326, 10304
30531, 9954, 9964, 574, 573, 10326, 10327, 596, 10306
30532, 730, 731, 9965, 9955, 753, 10328, 10329, 10307
30533, 9955, 9965, 9966, 9956, 10329, 10330, 10331, 10309
30534, 9956, 9966, 9967, 9957, 10331, 10332, 10333, 10311
30535, 9957, 9967, 9968, 9958, 10333, 10334, 10335, 10313
30536, 9958, 9968, 9969, 9959, 10335, 10336, 10337, 10315
30537, 9959, 9969, 9970, 9960, 10337, 10338, 10339, 10317
30538, 9960, 9970, 9971, 9961, 10339, 10340, 10341, 10319
30539, 9961, 9971, 9972, 9962, 10341, 10342, 10343, 10321
30540, 9962, 9972, 9973, 9963, 10343, 10344, 10345, 10323
30541, 9963, 9973, 9974, 9964, 10345, 10346, 10347, 10325
30542, 9964, 9974, 575, 574, 10347, 10348, 597, 10327
30543, 731, 732, 9975, 9965, 754, 10349, 10350, 10328
30544, 9965, 9975, 9976, 9966, 10350, 10351, 10352, 10330
30545, 9966, 9976, 9977, 9967, 10352, 10353, 10354, 10332
30546, 9967, 9977, 9978, 9968, 10354, 10355, 10356, 10334
30547, 9968, 9978, 9979, 9969, 10356, 10357, 10358, 10336
30548, 9969, 9979, 9980, 9970, 10358, 10359, 10360, 10338
30549, 9970, 9980, 9981, 9971, 10360, 10361, 10362, 10340
30550, 9971, 9981, 9982, 9972, 10362, 10363, 10364, 10342
30551, 9972, 9982, 9983, 9973, 10364, 10365, 10366, 10344
30552, 9973, 9983, 9984, 9974, 10366, 10367, 10368, 10346
30553, 9974, 9984, 576, 575, 10368, 10369, 598, 10348
30554, 732, 733, 9985, 9975, 755, 10370, 10371, 10349
