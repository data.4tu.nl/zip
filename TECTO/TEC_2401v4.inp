32537, 18260, 18261, 18283, 18282, 19086, 19130, 19131, 19128
32538, 18261, 18262, 18284, 18283, 19088, 19132, 19133, 19130
32539, 18262, 18263, 18285, 18284, 19090, 19134, 19135, 19132
32540, 18263, 18264, 18286, 18285, 19092, 19136, 19137, 19134
32541, 18264, 1783, 1784, 18286, 19093, 1806, 19138, 19136
32542, 1739, 18265, 18287, 1740, 19095, 19139, 19140, 1762
32543, 18265, 18266, 18288, 18287, 19097, 19141, 19142, 19139
32544, 18266, 18267, 18289, 18288, 19099, 19143, 19144, 19141
32545, 18267, 18268, 18290, 18289, 19101, 19145, 19146, 19143
32546, 18268, 18269, 18291, 18290, 19103, 19147, 19148, 19145
32547, 18269, 18270, 18292, 18291, 19105, 19149, 19150, 19147
32548, 18270, 18271, 18293, 18292, 19107, 19151, 19152, 19149
32549, 18271, 18272, 18294, 18293, 19109, 19153, 19154, 19151
32550, 18272, 18273, 18295, 18294, 19111, 19155, 19156, 19153
32551, 18273, 18274, 18296, 18295, 19113, 19157, 19158, 19155
32552, 18274, 18275, 18297, 18296, 19115, 19159, 19160, 19157
32553, 18275, 18276, 18298, 18297, 19117, 19161, 19162, 19159
32554, 18276, 18277, 18299, 18298, 19119, 19163, 19164, 19161
32555, 18277, 18278, 18300, 18299, 19121, 19165, 19166, 19163
32556, 18278, 18279, 18301, 18300, 19123, 19167, 19168, 19165
32557, 18279, 18280, 18302, 18301, 19125, 19169, 19170, 19167
32558, 18280, 18281, 18303, 18302, 19127, 19171, 19172, 19169
32559, 18281, 18282, 18304, 18303, 19129, 19173, 19174, 19171
32560, 18282, 18283, 18305, 18304, 19131, 19175, 19176, 19173
32561, 18283, 18284, 18306, 18305, 19133, 19177, 19178, 19175
32562, 18284, 18285, 18307, 18306, 19135, 19179, 19180, 19177
32563, 18285, 18286, 18308, 18307, 19137, 19181, 19182, 19179
32564, 18286, 1784, 1785, 18308, 19138, 1807, 19183, 19181
32565, 1740, 18287, 18309, 1741, 19140, 19184, 19185, 1763
32566, 18287, 18288, 18310, 18309, 19142, 19186, 19187, 19184
32567, 18288, 18289, 18311, 18310, 19144, 19188, 19189, 19186
32568, 18289, 18290, 18312, 18311, 19146, 19190, 19191, 19188
32569, 18290, 18291, 18313, 18312, 19148, 19192, 19193, 19190
32570, 18291, 18292, 18314, 18313, 19150, 19194, 19195, 19192
32571, 18292, 18293, 18315, 18314, 19152, 19196, 19197, 19194
32572, 18293, 18294, 18316, 18315, 19154, 19198, 19199, 19196
32573, 18294, 18295, 18317, 18316, 19156, 19200, 19201, 19198
32574, 18295, 18296, 18318, 18317, 19158, 19202, 19203, 19200
32575, 18296, 18297, 18319, 18318, 19160, 19204, 19205, 19202
32576, 18297, 18298, 18320, 18319, 19162, 19206, 19207, 19204
32577, 18298, 18299, 18321, 18320, 19164, 19208, 19209, 19206
32578, 18299, 18300, 18322, 18321, 19166, 19210, 19211, 19208
32579, 18300, 18301, 18323, 18322, 19168, 19212, 19213, 19210
32580, 18301, 18302, 18324, 18323, 19170, 19214, 19215, 19212
32581, 18302, 18303, 18325, 18324, 19172, 19216, 19217, 19214
32582, 18303, 18304, 18326, 18325, 19174, 19218, 19219, 19216
32583, 18304, 18305, 18327, 18326, 19176, 19220, 19221, 19218
32584, 18305, 18306, 18328, 18327, 19178, 19222, 19223, 19220
32585, 18306, 18307, 18329, 18328, 19180, 19224, 19225, 19222
32586, 18307, 18308, 18330, 18329, 19182, 19226, 19227, 19224
32587, 18308, 1785, 1786, 18330, 19183, 1808, 19228, 19226
32588, 1741, 18309, 18331, 1742, 19185, 19229, 19230, 1764
32589, 18309, 18310, 18332, 18331, 19187, 19231, 19232, 19229
32590, 18310, 18311, 18333, 18332, 19189, 19233, 19234, 19231
32591, 18311, 18312, 18334, 18333, 19191, 19235, 19236, 19233
32592, 18312, 18313, 18335, 18334, 19193, 19237, 19238, 19235
32593, 18313, 18314, 18336, 18335, 19195, 19239, 19240, 19237
32594, 18314, 18315, 18337, 18336, 19197, 19241, 19242, 19239
32595, 18315, 18316, 18338, 18337, 19199, 19243, 19244, 19241
32596, 18316, 18317, 18339, 18338, 19201, 19245, 19246, 19243
32597, 18317, 18318, 18340, 18339, 19203, 19247, 19248, 19245
32598, 18318, 18319, 18341, 18340, 19205, 19249, 19250, 19247
32599, 18319, 18320, 18342, 18341, 19207, 19251, 19252, 19249
32600, 18320, 18321, 18343, 18342, 19209, 19253, 19254, 19251
32601, 18321, 18322, 18344, 18343, 19211, 19255, 19256, 19253
32602, 18322, 18323, 18345, 18344, 19213, 19257, 19258, 19255
32603, 18323, 18324, 18346, 18345, 19215, 19259, 19260, 19257
32604, 18324, 18325, 18347, 18346, 19217, 19261, 19262, 19259
32605, 18325, 18326, 18348, 18347, 19219, 19263, 19264, 19261
32606, 18326, 18327, 18349, 18348, 19221, 19265, 19266, 19263
32607, 18327, 18328, 18350, 18349, 19223, 19267, 19268, 19265
32608, 18328, 18329, 18351, 18350, 19225, 19269, 19270, 19267
32609, 18329, 18330, 18352, 18351, 19227, 19271, 19272, 19269
32610, 18330, 1786, 1787, 18352, 19228, 1809, 19273, 19271
32611, 1742, 18331, 18353, 1743, 19230, 19274, 19275, 1765
32612, 18331, 18332, 18354, 18353, 19232, 19276, 19277, 19274
32613, 18332, 18333, 18355, 18354, 19234, 19278, 19279, 19276
32614, 18333, 18334, 18356, 18355, 19236, 19280, 19281, 19278
32615, 18334, 18335, 18357, 18356, 19238, 19282, 19283, 19280
32616, 18335, 18336, 18358, 18357, 19240, 19284, 19285, 19282
32617, 18336, 18337, 18359, 18358, 19242, 19286, 19287, 19284
32618, 18337, 18338, 18360, 18359, 19244, 19288, 19289, 19286
32619, 18338, 18339, 18361, 18360, 19246, 19290, 19291, 19288
32620, 18339, 18340, 18362, 18361, 19248, 19292, 19293, 19290
32621, 18340, 18341, 18363, 18362, 19250, 19294, 19295, 19292
32622, 18341, 18342, 18364, 18363, 19252, 19296, 19297, 19294
32623, 18342, 18343, 18365, 18364, 19254, 19298, 19299, 19296
32624, 18343, 18344, 18366, 18365, 19256, 19300, 19301, 19298
32625, 18344, 18345, 18367, 18366, 19258, 19302, 19303, 19300
32626, 18345, 18346, 18368, 18367, 19260, 19304, 19305, 19302
32627, 18346, 18347, 18369, 18368, 19262, 19306, 19307, 19304
32628, 18347, 18348, 18370, 18369, 19264, 19308, 19309, 19306
32629, 18348, 18349, 18371, 18370, 19266, 19310, 19311, 19308
32630, 18349, 18350, 18372, 18371, 19268, 19312, 19313, 19310
32631, 18350, 18351, 18373, 18372, 19270, 19314, 19315, 19312
32632, 18351, 18352, 18374, 18373, 19272, 19316, 19317, 19314
32633, 18352, 1787, 1788, 18374, 19273, 1810, 19318, 19316
32634, 1743, 18353, 18375, 1744, 19275, 19319, 19320, 1766
32635, 18353, 18354, 18376, 18375, 19277, 19321, 19322, 19319
32636, 18354, 18355, 18377, 18376, 19279, 19323, 19324, 19321
32637, 18355, 18356, 18378, 18377, 19281, 19325, 19326, 19323
32638, 18356, 18357, 18379, 18378, 19283, 19327, 19328, 19325
32639, 18357, 18358, 18380, 18379, 19285, 19329, 19330, 19327
32640, 18358, 18359, 18381, 18380, 19287, 19331, 19332, 19329
32641, 18359, 18360, 18382, 18381, 19289, 19333, 19334, 19331
32642, 18360, 18361, 18383, 18382, 19291, 19335, 19336, 19333
32643, 18361, 18362, 18384, 18383, 19293, 19337, 19338, 19335
32644, 18362, 18363, 18385, 18384, 19295, 19339, 19340, 19337
32645, 18363, 18364, 18386, 18385, 19297, 19341, 19342, 19339
32646, 18364, 18365, 18387, 18386, 19299, 19343, 19344, 19341
32647, 18365, 18366, 18388, 18387, 19301, 19345, 19346, 19343
32648, 18366, 18367, 18389, 18388, 19303, 19347, 19348, 19345
32649, 18367, 18368, 18390, 18389, 19305, 19349, 19350, 19347
32650, 18368, 18369, 18391, 18390, 19307, 19351, 19352, 19349
32651, 18369, 18370, 18392, 18391, 19309, 19353, 19354, 19351
32652, 18370, 18371, 18393, 18392, 19311, 19355, 19356, 19353
32653, 18371, 18372, 18394, 18393, 19313, 19357, 19358, 19355
32654, 18372, 18373, 18395, 18394, 19315, 19359, 19360, 19357
32655, 18373, 18374, 18396, 18395, 19317, 19361, 19362, 19359
32656, 18374, 1788, 1789, 18396, 19318, 1811, 19363, 19361
32657, 1744, 18375, 18397, 1745, 19320, 19364, 19365, 1767
32658, 18375, 18376, 18398, 18397, 19322, 19366, 19367, 19364
32659, 18376, 18377, 18399, 18398, 19324, 19368, 19369, 19366
32660, 18377, 18378, 18400, 18399, 19326, 19370, 19371, 19368
32661, 18378, 18379, 18401, 18400, 19328, 19372, 19373, 19370
32662, 18379, 18380, 18402, 18401, 19330, 19374, 19375, 19372
32663, 18380, 18381, 18403, 18402, 19332, 19376, 19377, 19374
32664, 18381, 18382, 18404, 18403, 19334, 19378, 19379, 19376
32665, 18382, 18383, 18405, 18404, 19336, 19380, 19381, 19378
32666, 18383, 18384, 18406, 18405, 19338, 19382, 19383, 19380
32667, 18384, 18385, 18407, 18406, 19340, 19384, 19385, 19382
32668, 18385, 18386, 18408, 18407, 19342, 19386, 19387, 19384
32669, 18386, 18387, 18409, 18408, 19344, 19388, 19389, 19386
32670, 18387, 18388, 18410, 18409, 19346, 19390, 19391, 19388
32671, 18388, 18389, 18411, 18410, 19348, 19392, 19393, 19390
32672, 18389, 18390, 18412, 18411, 19350, 19394, 19395, 19392
32673, 18390, 18391, 18413, 18412, 19352, 19396, 19397, 19394
32674, 18391, 18392, 18414, 18413, 19354, 19398, 19399, 19396
32675, 18392, 18393, 18415, 18414, 19356, 19400, 19401, 19398
32676, 18393, 18394, 18416, 18415, 19358, 19402, 19403, 19400
32677, 18394, 18395, 18417, 18416, 19360, 19404, 19405, 19402
32678, 18395, 18396, 18418, 18417, 19362, 19406, 19407, 19404
32679, 18396, 1789, 1790, 18418, 19363, 1812, 19408, 19406
32680, 1745, 18397, 1814, 39, 19365, 19409, 1836, 1768
32681, 18397, 18398, 1815, 1814, 19367, 19410, 1837, 19409
32682, 18398, 18399, 1816, 1815, 19369, 19411, 1838, 19410
32683, 18399, 18400, 1817, 1816, 19371, 19412, 1839, 19411
32684, 18400, 18401, 1818, 1817, 19373, 19413, 1840, 19412
32685, 18401, 18402, 1819, 1818, 19375, 19414, 1841, 19413
32686, 18402, 18403, 1820, 1819, 19377, 19415, 1842, 19414
32687, 18403, 18404, 1821, 1820, 19379, 19416, 1843, 19415
32688, 18404, 18405, 1822, 1821, 19381, 19417, 1844, 19416
32689, 18405, 18406, 1823, 1822, 19383, 19418, 1845, 19417
32690, 18406, 18407, 1824, 1823, 19385, 19419, 1846, 19418
32691, 18407, 18408, 1825, 1824, 19387, 19420, 1847, 19419
32692, 18408, 18409, 1826, 1825, 19389, 19421, 1848, 19420
32693, 18409, 18410, 1827, 1826, 19391, 19422, 1849, 19421
32694, 18410, 18411, 1828, 1827, 19393, 19423, 1850, 19422
32695, 18411, 18412, 1829, 1828, 19395, 19424, 1851, 19423
32696, 18412, 18413, 1830, 1829, 19397, 19425, 1852, 19424
32697, 18413, 18414, 1831, 1830, 19399, 19426, 1853, 19425
32698, 18414, 18415, 1832, 1831, 19401, 19427, 1854, 19426
32699, 18415, 18416, 1833, 1832, 19403, 19428, 1855, 19427
32700, 18416, 18417, 1834, 1833, 19405, 19429, 1856, 19428
32701, 18417, 18418, 1835, 1834, 19407, 19430, 1857, 19429
32702, 18418, 1790, 40, 1835, 19408, 1813, 1858, 19430
*ELEMENT, type=CPS8, ELSET=Surface44
32703, 33, 1556, 19431, 1589, 1567, 19651, 19652, 1611
32704, 1556, 1555, 19432, 19431, 1566, 19653, 19654, 19651
32705, 1555, 1554, 19433, 19432, 1565, 19655, 19656, 19653
32706, 1554, 1553, 19434, 19433, 1564, 19657, 19658, 19655
32707, 1553, 1552, 19435, 19434, 1563, 19659, 19660, 19657
32708, 1552, 1551, 19436, 19435, 1562, 19661, 19662, 19659
32709, 1551, 1550, 19437, 19436, 1561, 19663, 19664, 19661
32710, 1550, 1549, 19438, 19437, 1560, 19665, 19666, 19663
32711, 1549, 1548, 19439, 19438, 1559, 19667, 19668, 19665
32712, 1548, 1547, 19440, 19439, 1558, 19669, 19670, 19667
32713, 1547, 35, 1724, 19440, 1557, 1746, 19671, 19669
32714, 1589, 19431, 19441, 1590, 19652, 19672, 19673, 1612
32715, 19431, 19432, 19442, 19441, 19654, 19674, 19675, 19672
32716, 19432, 19433, 19443, 19442, 19656, 19676, 19677, 19674
32717, 19433, 19434, 19444, 19443, 19658, 19678, 19679, 19676
32718, 19434, 19435, 19445, 19444, 19660, 19680, 19681, 19678
32719, 19435, 19436, 19446, 19445, 19662, 19682, 19683, 19680
32720, 19436, 19437, 19447, 19446, 19664, 19684, 19685, 19682
32721, 19437, 19438, 19448, 19447, 19666, 19686, 19687, 19684
32722, 19438, 19439, 19449, 19448, 19668, 19688, 19689, 19686
32723, 19439, 19440, 19450, 19449, 19670, 19690, 19691, 19688
32724, 19440, 1724, 1725, 19450, 19671, 1747, 19692, 19690
32725, 1590, 19441, 19451, 1591, 19673, 19693, 19694, 1613
32726, 19441, 19442, 19452, 19451, 19675, 19695, 19696, 19693
32727, 19442, 19443, 19453, 19452, 19677, 19697, 19698, 19695
32728, 19443, 19444, 19454, 19453, 19679, 19699, 19700, 19697
32729, 19444, 19445, 19455, 19454, 19681, 19701, 19702, 19699
32730, 19445, 19446, 19456, 19455, 19683, 19703, 19704, 19701
32731, 19446, 19447, 19457, 19456, 19685, 19705, 19706, 19703
32732, 19447, 19448, 19458, 19457, 19687, 19707, 19708, 19705
32733, 19448, 19449, 19459, 19458, 19689, 19709, 19710, 19707
32734, 19449, 19450, 19460, 19459, 19691, 19711, 19712, 19709
32735, 19450, 1725, 1726, 19460, 19692, 1748, 19713, 19711
32736, 1591, 19451, 19461, 1592, 19694, 19714, 19715, 1614
32737, 19451, 19452, 19462, 19461, 19696, 19716, 19717, 19714
32738, 19452, 19453, 19463, 19462, 19698, 19718, 19719, 19716
32739, 19453, 19454, 19464, 19463, 19700, 19720, 19721, 19718
32740, 19454, 19455, 19465, 19464, 19702, 19722, 19723, 19720
32741, 19455, 19456, 19466, 19465, 19704, 19724, 19725, 19722
32742, 19456, 19457, 19467, 19466, 19706, 19726, 19727, 19724
32743, 19457, 19458, 19468, 19467, 19708, 19728, 19729, 19726
32744, 19458, 19459, 19469, 19468, 19710, 19730, 19731, 19728
32745, 19459, 19460, 19470, 19469, 19712, 19732, 19733, 19730
32746, 19460, 1726, 1727, 19470, 19713, 1749, 19734, 19732
32747, 1592, 19461, 19471, 1593, 19715, 19735, 19736, 1615
32748, 19461, 19462, 19472, 19471, 19717, 19737, 19738, 19735
32749, 19462, 19463, 19473, 19472, 19719, 19739, 19740, 19737
32750, 19463, 19464, 19474, 19473, 19721, 19741, 19742, 19739
32751, 19464, 19465, 19475, 19474, 19723, 19743, 19744, 19741
32752, 19465, 19466, 19476, 19475, 19725, 19745, 19746, 19743
32753, 19466, 19467, 19477, 19476, 19727, 19747, 19748, 19745
32754, 19467, 19468, 19478, 19477, 19729, 19749, 19750, 19747
32755, 19468, 19469, 19479, 19478, 19731, 19751, 19752, 19749
32756, 19469, 19470, 19480, 19479, 19733, 19753, 19754, 19751
32757, 19470, 1727, 1728, 19480, 19734, 1750, 19755, 19753
32758, 1593, 19471, 19481, 1594, 19736, 19756, 19757, 1616
32759, 19471, 19472, 19482, 19481, 19738, 19758, 19759, 19756
32760, 19472, 19473, 19483, 19482, 19740, 19760, 19761, 19758
32761, 19473, 19474, 19484, 19483, 19742, 19762, 19763, 19760
32762, 19474, 19475, 19485, 19484, 19744, 19764, 19765, 19762
32763, 19475, 19476, 19486, 19485, 19746, 19766, 19767, 19764
32764, 19476, 19477, 19487, 19486, 19748, 19768, 19769, 19766
32765, 19477, 19478, 19488, 19487, 19750, 19770, 19771, 19768
32766, 19478, 19479, 19489, 19488, 19752, 19772, 19773, 19770
32767, 19479, 19480, 19490, 19489, 19754, 19774, 19775, 19772
32768, 19480, 1728, 1729, 19490, 19755, 1751, 19776, 19774
32769, 1594, 19481, 19491, 1595, 19757, 19777, 19778, 1617
32770, 19481, 19482, 19492, 19491, 19759, 19779, 19780, 19777
32771, 19482, 19483, 19493, 19492, 19761, 19781, 19782, 19779
32772, 19483, 19484, 19494, 19493, 19763, 19783, 19784, 19781
32773, 19484, 19485, 19495, 19494, 19765, 19785, 19786, 19783
32774, 19485, 19486, 19496, 19495, 19767, 19787, 19788, 19785
32775, 19486, 19487, 19497, 19496, 19769, 19789, 19790, 19787
32776, 19487, 19488, 19498, 19497, 19771, 19791, 19792, 19789
32777, 19488, 19489, 19499, 19498, 19773, 19793, 19794, 19791
32778, 19489, 19490, 19500, 19499, 19775, 19795, 19796, 19793
32779, 19490, 1729, 1730, 19500, 19776, 1752, 19797, 19795
32780, 1595, 19491, 19501, 1596, 19778, 19798, 19799, 1618
32781, 19491, 19492, 19502, 19501, 19780, 19800, 19801, 19798
32782, 19492, 19493, 19503, 19502, 19782, 19802, 19803, 19800
32783, 19493, 19494, 19504, 19503, 19784, 19804, 19805, 19802
32784, 19494, 19495, 19505, 19504, 19786, 19806, 19807, 19804
32785, 19495, 19496, 19506, 19505, 19788, 19808, 19809, 19806
32786, 19496, 19497, 19507, 19506, 19790, 19810, 19811, 19808
32787, 19497, 19498, 19508, 19507, 19792, 19812, 19813, 19810
32788, 19498, 19499, 19509, 19508, 19794, 19814, 19815, 19812
32789, 19499, 19500, 19510, 19509, 19796, 19816, 19817, 19814
32790, 19500, 1730, 1731, 19510, 19797, 1753, 19818, 19816
32791, 1596, 19501, 19511, 1597, 19799, 19819, 19820, 1619
32792, 19501, 19502, 19512, 19511, 19801, 19821, 19822, 19819
32793, 19502, 19503, 19513, 19512, 19803, 19823, 19824, 19821
32794, 19503, 19504, 19514, 19513, 19805, 19825, 19826, 19823
32795, 19504, 19505, 19515, 19514, 19807, 19827, 19828, 19825
32796, 19505, 19506, 19516, 19515, 19809, 19829, 19830, 19827
32797, 19506, 19507, 19517, 19516, 19811, 19831, 19832, 19829
32798, 19507, 19508, 19518, 19517, 19813, 19833, 19834, 19831
32799, 19508, 19509, 19519, 19518, 19815, 19835, 19836, 19833
32800, 19509, 19510, 19520, 19519, 19817, 19837, 19838, 19835
32801, 19510, 1731, 1732, 19520, 19818, 1754, 19839, 19837
32802, 1597, 19511, 19521, 1598, 19820, 19840, 19841, 1620
32803, 19511, 19512, 19522, 19521, 19822, 19842, 19843, 19840
32804, 19512, 19513, 19523, 19522, 19824, 19844, 19845, 19842
32805, 19513, 19514, 19524, 19523, 19826, 19846, 19847, 19844
32806, 19514, 19515, 19525, 19524, 19828, 19848, 19849, 19846
32807, 19515, 19516, 19526, 19525, 19830, 19850, 19851, 19848
32808, 19516, 19517, 19527, 19526, 19832, 19852, 19853, 19850
32809, 19517, 19518, 19528, 19527, 19834, 19854, 19855, 19852
32810, 19518, 19519, 19529, 19528, 19836, 19856, 19857, 19854
32811, 19519, 19520, 19530, 19529, 19838, 19858, 19859, 19856
32812, 19520, 1732, 1733, 19530, 19839, 1755, 19860, 19858
32813, 1598, 19521, 19531, 1599, 19841, 19861, 19862, 1621
32814, 19521, 19522, 19532, 19531, 19843, 19863, 19864, 19861
32815, 19522, 19523, 19533, 19532, 19845, 19865, 19866, 19863
32816, 19523, 19524, 19534, 19533, 19847, 19867, 19868, 19865
32817, 19524, 19525, 19535, 19534, 19849, 19869, 19870, 19867
32818, 19525, 19526, 19536, 19535, 19851, 19871, 19872, 19869
32819, 19526, 19527, 19537, 19536, 19853, 19873, 19874, 19871
32820, 19527, 19528, 19538, 19537, 19855, 19875, 19876, 19873
32821, 19528, 19529, 19539, 19538, 19857, 19877, 19878, 19875
32822, 19529, 19530, 19540, 19539, 19859, 19879, 19880, 19877
32823, 19530, 1733, 1734, 19540, 19860, 1756, 19881, 19879
32824, 1599, 19531, 19541, 1600, 19862, 19882, 19883, 1622
32825, 19531, 19532, 19542, 19541, 19864, 19884, 19885, 19882
32826, 19532, 19533, 19543, 19542, 19866, 19886, 19887, 19884
32827, 19533, 19534, 19544, 19543, 19868, 19888, 19889, 19886
32828, 19534, 19535, 19545, 19544, 19870, 19890, 19891, 19888
32829, 19535, 19536, 19546, 19545, 19872, 19892, 19893, 19890
32830, 19536, 19537, 19547, 19546, 19874, 19894, 19895, 19892
32831, 19537, 19538, 19548, 19547, 19876, 19896, 19897, 19894
32832, 19538, 19539, 19549, 19548, 19878, 19898, 19899, 19896
32833, 19539, 19540, 19550, 19549, 19880, 19900, 19901, 19898
32834, 19540, 1734, 1735, 19550, 19881, 1757, 19902, 19900
32835, 1600, 19541, 19551, 1601, 19883, 19903, 19904, 1623
32836, 19541, 19542, 19552, 19551, 19885, 19905, 19906, 19903
32837, 19542, 19543, 19553, 19552, 19887, 19907, 19908, 19905
32838, 19543, 19544, 19554, 19553, 19889, 19909, 19910, 19907
32839, 19544, 19545, 19555, 19554, 19891, 19911, 19912, 19909
32840, 19545, 19546, 19556, 19555, 19893, 19913, 19914, 19911
32841, 19546, 19547, 19557, 19556, 19895, 19915, 19916, 19913
32842, 19547, 19548, 19558, 19557, 19897, 19917, 19918, 19915
32843, 19548, 19549, 19559, 19558, 19899, 19919, 19920, 19917
32844, 19549, 19550, 19560, 19559, 19901, 19921, 19922, 19919
32845, 19550, 1735, 1736, 19560, 19902, 1758, 19923, 19921
32846, 1601, 19551, 19561, 1602, 19904, 19924, 19925, 1624
32847, 19551, 19552, 19562, 19561, 19906, 19926, 19927, 19924
32848, 19552, 19553, 19563, 19562, 19908, 19928, 19929, 19926
32849, 19553, 19554, 19564, 19563, 19910, 19930, 19931, 19928
32850, 19554, 19555, 19565, 19564, 19912, 19932, 19933, 19930
32851, 19555, 19556, 19566, 19565, 19914, 19934, 19935, 19932
32852, 19556, 19557, 19567, 19566, 19916, 19936, 19937, 19934
32853, 19557, 19558, 19568, 19567, 19918, 19938, 19939, 19936
32854, 19558, 19559, 19569, 19568, 19920, 19940, 19941, 19938
32855, 19559, 19560, 19570, 19569, 19922, 19942, 19943, 19940
32856, 19560, 1736, 1737, 19570, 19923, 1759, 19944, 19942
32857, 1602, 19561, 19571, 1603, 19925, 19945, 19946, 1625
32858, 19561, 19562, 19572, 19571, 19927, 19947, 19948, 19945
32859, 19562, 19563, 19573, 19572, 19929, 19949, 19950, 19947
32860, 19563, 19564, 19574, 19573, 19931, 19951, 19952, 19949
32861, 19564, 19565, 19575, 19574, 19933, 19953, 19954, 19951
32862, 19565, 19566, 19576, 19575, 19935, 19955, 19956, 19953
32863, 19566, 19567, 19577, 19576, 19937, 19957, 19958, 19955
32864, 19567, 19568, 19578, 19577, 19939, 19959, 19960, 19957
32865, 19568, 19569, 19579, 19578, 19941, 19961, 19962, 19959
32866, 19569, 19570, 19580, 19579, 19943, 19963, 19964, 19961
32867, 19570, 1737, 1738, 19580, 19944, 1760, 19965, 19963
32868, 1603, 19571, 19581, 1604, 19946, 19966, 19967, 1626
32869, 19571, 19572, 19582, 19581, 19948, 19968, 19969, 19966
32870, 19572, 19573, 19583, 19582, 19950, 19970, 19971, 19968
32871, 19573, 19574, 19584, 19583, 19952, 19972, 19973, 19970
32872, 19574, 19575, 19585, 19584, 19954, 19974, 19975, 19972
32873, 19575, 19576, 19586, 19585, 19956, 19976, 19977, 19974
32874, 19576, 19577, 19587, 19586, 19958, 19978, 19979, 19976
32875, 19577, 19578, 19588, 19587, 19960, 19980, 19981, 19978
32876, 19578, 19579, 19589, 19588, 19962, 19982, 19983, 19980
32877, 19579, 19580, 19590, 19589, 19964, 19984, 19985, 19982
32878, 19580, 1738, 1739, 19590, 19965, 1761, 19986, 19984
32879, 1604, 19581, 19591, 1605, 19967, 19987, 19988, 1627
32880, 19581, 19582, 19592, 19591, 19969, 19989, 19990, 19987
32881, 19582, 19583, 19593, 19592, 19971, 19991, 19992, 19989
32882, 19583, 19584, 19594, 19593, 19973, 19993, 19994, 19991
32883, 19584, 19585, 19595, 19594, 19975, 19995, 19996, 19993
32884, 19585, 19586, 19596, 19595, 19977, 19997, 19998, 19995
32885, 19586, 19587, 19597, 19596, 19979, 19999, 20000, 19997
32886, 19587, 19588, 19598, 19597, 19981, 20001, 20002, 19999
32887, 19588, 19589, 19599, 19598, 19983, 20003, 20004, 20001
32888, 19589, 19590, 19600, 19599, 19985, 20005, 20006, 20003
32889, 19590, 1739, 1740, 19600, 19986, 1762, 20007, 20005
32890, 1605, 19591, 19601, 1606, 19988, 20008, 20009, 1628
32891, 19591, 19592, 19602, 19601, 19990, 20010, 20011, 20008
32892, 19592, 19593, 19603, 19602, 19992, 20012, 20013, 20010
32893, 19593, 19594, 19604, 19603, 19994, 20014, 20015, 20012
32894, 19594, 19595, 19605, 19604, 19996, 20016, 20017, 20014
32895, 19595, 19596, 19606, 19605, 19998, 20018, 20019, 20016
32896, 19596, 19597, 19607, 19606, 20000, 20020, 20021, 20018
32897, 19597, 19598, 19608, 19607, 20002, 20022, 20023, 20020
32898, 19598, 19599, 19609, 19608, 20004, 20024, 20025, 20022
32899, 19599, 19600, 19610, 19609, 20006, 20026, 20027, 20024
32900, 19600, 1740, 1741, 19610, 20007, 1763, 20028, 20026
32901, 1606, 19601, 19611, 1607, 20009, 20029, 20030, 1629
32902, 19601, 19602, 19612, 19611, 20011, 20031, 20032, 20029
32903, 19602, 19603, 19613, 19612, 20013, 20033, 20034, 20031
32904, 19603, 19604, 19614, 19613, 20015, 20035, 20036, 20033
32905, 19604, 19605, 19615, 19614, 20017, 20037, 20038, 20035
32906, 19605, 19606, 19616, 19615, 20019, 20039, 20040, 20037
32907, 19606, 19607, 19617, 19616, 20021, 20041, 20042, 20039
32908, 19607, 19608, 19618, 19617, 20023, 20043, 20044, 20041
32909, 19608, 19609, 19619, 19618, 20025, 20045, 20046, 20043
32910, 19609, 19610, 19620, 19619, 20027, 20047, 20048, 20045
32911, 19610, 1741, 1742, 19620, 20028, 1764, 20049, 20047
32912, 1607, 19611, 19621, 1608, 20030, 20050, 20051, 1630
32913, 19611, 19612, 19622, 19621, 20032, 20052, 20053, 20050
32914, 19612, 19613, 19623, 19622, 20034, 20054, 20055, 20052
32915, 19613, 19614, 19624, 19623, 20036, 20056, 20057, 20054
32916, 19614, 19615, 19625, 19624, 20038, 20058, 20059, 20056
32917, 19615, 19616, 19626, 19625, 20040, 20060, 20061, 20058
32918, 19616, 19617, 19627, 19626, 20042, 20062, 20063, 20060
32919, 19617, 19618, 19628, 19627, 20044, 20064, 20065, 20062
32920, 19618, 19619, 19629, 19628, 20046, 20066, 20067, 20064
32921, 19619, 19620, 19630, 19629, 20048, 20068, 20069, 20066
32922, 19620, 1742, 1743, 19630, 20049, 1765, 20070, 20068
32923, 1608, 19621, 19631, 1609, 20051, 20071, 20072, 1631
32924, 19621, 19622, 19632, 19631, 20053, 20073, 20074, 20071
32925, 19622, 19623, 19633, 19632, 20055, 20075, 20076, 20073
32926, 19623, 19624, 19634, 19633, 20057, 20077, 20078, 20075
32927, 19624, 19625, 19635, 19634, 20059, 20079, 20080, 20077
32928, 19625, 19626, 19636, 19635, 20061, 20081, 20082, 20079
32929, 19626, 19627, 19637, 19636, 20063, 20083, 20084, 20081
32930, 19627, 19628, 19638, 19637, 20065, 20085, 20086, 20083
32931, 19628, 19629, 19639, 19638, 20067, 20087, 20088, 20085
32932, 19629, 19630, 19640, 19639, 20069, 20089, 20090, 20087
32933, 19630, 1743, 1744, 19640, 20070, 1766, 20091, 20089
32934, 1609, 19631, 19641, 1610, 20072, 20092, 20093, 1632
32935, 19631, 19632, 19642, 19641, 20074, 20094, 20095, 20092
32936, 19632, 19633, 19643, 19642, 20076, 20096, 20097, 20094
32937, 19633, 19634, 19644, 19643, 20078, 20098, 20099, 20096
32938, 19634, 19635, 19645, 19644, 20080, 20100, 20101, 20098
32939, 19635, 19636, 19646, 19645, 20082, 20102, 20103, 20100
32940, 19636, 19637, 19647, 19646, 20084, 20104, 20105, 20102
32941, 19637, 19638, 19648, 19647, 20086, 20106, 20107, 20104
32942, 19638, 19639, 19649, 19648, 20088, 20108, 20109, 20106
32943, 19639, 19640, 19650, 19649, 20090, 20110, 20111, 20108
32944, 19640, 1744, 1745, 19650, 20091, 1767, 20112, 20110
32945, 1610, 19641, 1868, 37, 20093, 20113, 1879, 1633
32946, 19641, 19642, 1867, 1868, 20095, 20114, 1878, 20113
32947, 19642, 19643, 1866, 1867, 20097, 20115, 1877, 20114
32948, 19643, 19644, 1865, 1866, 20099, 20116, 1876, 20115
32949, 19644, 19645, 1864, 1865, 20101, 20117, 1875, 20116
32950, 19645, 19646, 1863, 1864, 20103, 20118, 1874, 20117
32951, 19646, 19647, 1862, 1863, 20105, 20119, 1873, 20118
32952, 19647, 19648, 1861, 1862, 20107, 20120, 1872, 20119
32953, 19648, 19649, 1860, 1861, 20109, 20121, 1871, 20120
32954, 19649, 19650, 1859, 1860, 20111, 20122, 1870, 20121
32955, 19650, 1745, 39, 1859, 20112, 1768, 1869, 20122
*ELEMENT, type=CPS8, ELSET=Surface45
32956, 34, 1634, 20123, 1577, 1656, 20343, 20344, 1588
32957, 1577, 20123, 20124, 1576, 20344, 20345, 20346, 1587
32958, 1576, 20124, 20125, 1575, 20346, 20347, 20348, 1586
32959, 1575, 20125, 20126, 1574, 20348, 20349, 20350, 1585
32960, 1574, 20126, 20127, 1573, 20350, 20351, 20352, 1584
32961, 1573, 20127, 20128, 1572, 20352, 20353, 20354, 1583
32962, 1572, 20128, 20129, 1571, 20354, 20355, 20356, 1582
32963, 1571, 20129, 20130, 1570, 20356, 20357, 20358, 1581
32964, 1570, 20130, 20131, 1569, 20358, 20359, 20360, 1580
32965, 1569, 20131, 20132, 1568, 20360, 20361, 20362, 1579
32966, 1568, 20132, 1769, 36, 20362, 20363, 1791, 1578
32967, 1634, 1635, 20133, 20123, 1657, 20364, 20365, 20343
32968, 20123, 20133, 20134, 20124, 20365, 20366, 20367, 20345
32969, 20124, 20134, 20135, 20125, 20367, 20368, 20369, 20347
32970, 20125, 20135, 20136, 20126, 20369, 20370, 20371, 20349
32971, 20126, 20136, 20137, 20127, 20371, 20372, 20373, 20351
32972, 20127, 20137, 20138, 20128, 20373, 20374, 20375, 20353
32973, 20128, 20138, 20139, 20129, 20375, 20376, 20377, 20355
32974, 20129, 20139, 20140, 20130, 20377, 20378, 20379, 20357
32975, 20130, 20140, 20141, 20131, 20379, 20380, 20381, 20359
32976, 20131, 20141, 20142, 20132, 20381, 20382, 20383, 20361
32977, 20132, 20142, 1770, 1769, 20383, 20384, 1792, 20363
32978, 1635, 1636, 20143, 20133, 1658, 20385, 20386, 20364
32979, 20133, 20143, 20144, 20134, 20386, 20387, 20388, 20366
32980, 20134, 20144, 20145, 20135, 20388, 20389, 20390, 20368
32981, 20135, 20145, 20146, 20136, 20390, 20391, 20392, 20370
32982, 20136, 20146, 20147, 20137, 20392, 20393, 20394, 20372
32983, 20137, 20147, 20148, 20138, 20394, 20395, 20396, 20374
32984, 20138, 20148, 20149, 20139, 20396, 20397, 20398, 20376
32985, 20139, 20149, 20150, 20140, 20398, 20399, 20400, 20378
32986, 20140, 20150, 20151, 20141, 20400, 20401, 20402, 20380
32987, 20141, 20151, 20152, 20142, 20402, 20403, 20404, 20382
32988, 20142, 20152, 1771, 1770, 20404, 20405, 1793, 20384
32989, 1636, 1637, 20153, 20143, 1659, 20406, 20407, 20385
32990, 20143, 20153, 20154, 20144, 20407, 20408, 20409, 20387
32991, 20144, 20154, 20155, 20145, 20409, 20410, 20411, 20389
32992, 20145, 20155, 20156, 20146, 20411, 20412, 20413, 20391
32993, 20146, 20156, 20157, 20147, 20413, 20414, 20415, 20393
32994, 20147, 20157, 20158, 20148, 20415, 20416, 20417, 20395
32995, 20148, 20158, 20159, 20149, 20417, 20418, 20419, 20397
32996, 20149, 20159, 20160, 20150, 20419, 20420, 20421, 20399
32997, 20150, 20160, 20161, 20151, 20421, 20422, 20423, 20401
32998, 20151, 20161, 20162, 20152, 20423, 20424, 20425, 20403
32999, 20152, 20162, 1772, 1771, 20425, 20426, 1794, 20405
33000, 1637, 1638, 20163, 20153, 1660, 20427, 20428, 20406
33001, 20153, 20163, 20164, 20154, 20428, 20429, 20430, 20408
33002, 20154, 20164, 20165, 20155, 20430, 20431, 20432, 20410
33003, 20155, 20165, 20166, 20156, 20432, 20433, 20434, 20412
33004, 20156, 20166, 20167, 20157, 20434, 20435, 20436, 20414
33005, 20157, 20167, 20168, 20158, 20436, 20437, 20438, 20416
33006, 20158, 20168, 20169, 20159, 20438, 20439, 20440, 20418
33007, 20159, 20169, 20170, 20160, 20440, 20441, 20442, 20420
33008, 20160, 20170, 20171, 20161, 20442, 20443, 20444, 20422
33009, 20161, 20171, 20172, 20162, 20444, 20445, 20446, 20424
33010, 20162, 20172, 1773, 1772, 20446, 20447, 1795, 20426
33011, 1638, 1639, 20173, 20163, 1661, 20448, 20449, 20427
33012, 20163, 20173, 20174, 20164, 20449, 20450, 20451, 20429
33013, 20164, 20174, 20175, 20165, 20451, 20452, 20453, 20431
33014, 20165, 20175, 20176, 20166, 20453, 20454, 20455, 20433
33015, 20166, 20176, 20177, 20167, 20455, 20456, 20457, 20435
33016, 20167, 20177, 20178, 20168, 20457, 20458, 20459, 20437
33017, 20168, 20178, 20179, 20169, 20459, 20460, 20461, 20439
33018, 20169, 20179, 20180, 20170, 20461, 20462, 20463, 20441
33019, 20170, 20180, 20181, 20171, 20463, 20464, 20465, 20443
33020, 20171, 20181, 20182, 20172, 20465, 20466, 20467, 20445
33021, 20172, 20182, 1774, 1773, 20467, 20468, 1796, 20447
33022, 1639, 1640, 20183, 20173, 1662, 20469, 20470, 20448
33023, 20173, 20183, 20184, 20174, 20470, 20471, 20472, 20450
33024, 20174, 20184, 20185, 20175, 20472, 20473, 20474, 20452
33025, 20175, 20185, 20186, 20176, 20474, 20475, 20476, 20454
33026, 20176, 20186, 20187, 20177, 20476, 20477, 20478, 20456
33027, 20177, 20187, 20188, 20178, 20478, 20479, 20480, 20458
33028, 20178, 20188, 20189, 20179, 20480, 20481, 20482, 20460
33029, 20179, 20189, 20190, 20180, 20482, 20483, 20484, 20462
33030, 20180, 20190, 20191, 20181, 20484, 20485, 20486, 20464
33031, 20181, 20191, 20192, 20182, 20486, 20487, 20488, 20466
33032, 20182, 20192, 1775, 1774, 20488, 20489, 1797, 20468
33033, 1640, 1641, 20193, 20183, 1663, 20490, 20491, 20469
33034, 20183, 20193, 20194, 20184, 20491, 20492, 20493, 20471
33035, 20184, 20194, 20195, 20185, 20493, 20494, 20495, 20473
33036, 20185, 20195, 20196, 20186, 20495, 20496, 20497, 20475
33037, 20186, 20196, 20197, 20187, 20497, 20498, 20499, 20477
33038, 20187, 20197, 20198, 20188, 20499, 20500, 20501, 20479
33039, 20188, 20198, 20199, 20189, 20501, 20502, 20503, 20481
33040, 20189, 20199, 20200, 20190, 20503, 20504, 20505, 20483
33041, 20190, 20200, 20201, 20191, 20505, 20506, 20507, 20485
33042, 20191, 20201, 20202, 20192, 20507, 20508, 20509, 20487
33043, 20192, 20202, 1776, 1775, 20509, 20510, 1798, 20489
33044, 1641, 1642, 20203, 20193, 1664, 20511, 20512, 20490
33045, 20193, 20203, 20204, 20194, 20512, 20513, 20514, 20492
33046, 20194, 20204, 20205, 20195, 20514, 20515, 20516, 20494
33047, 20195, 20205, 20206, 20196, 20516, 20517, 20518, 20496
33048, 20196, 20206, 20207, 20197, 20518, 20519, 20520, 20498
33049, 20197, 20207, 20208, 20198, 20520, 20521, 20522, 20500
33050, 20198, 20208, 20209, 20199, 20522, 20523, 20524, 20502
33051, 20199, 20209, 20210, 20200, 20524, 20525, 20526, 20504
33052, 20200, 20210, 20211, 20201, 20526, 20527, 20528, 20506
33053, 20201, 20211, 20212, 20202, 20528, 20529, 20530, 20508
33054, 20202, 20212, 1777, 1776, 20530, 20531, 1799, 20510
33055, 1642, 1643, 20213, 20203, 1665, 20532, 20533, 20511
33056, 20203, 20213, 20214, 20204, 20533, 20534, 20535, 20513
33057, 20204, 20214, 20215, 20205, 20535, 20536, 20537, 20515
33058, 20205, 20215, 20216, 20206, 20537, 20538, 20539, 20517
33059, 20206, 20216, 20217, 20207, 20539, 20540, 20541, 20519
33060, 20207, 20217, 20218, 20208, 20541, 20542, 20543, 20521
33061, 20208, 20218, 20219, 20209, 20543, 20544, 20545, 20523
33062, 20209, 20219, 20220, 20210, 20545, 20546, 20547, 20525
33063, 20210, 20220, 20221, 20211, 20547, 20548, 20549, 20527
33064, 20211, 20221, 20222, 20212, 20549, 20550, 20551, 20529
33065, 20212, 20222, 1778, 1777, 20551, 20552, 1800, 20531
33066, 1643, 1644, 20223, 20213, 1666, 20553, 20554, 20532
33067, 20213, 20223, 20224, 20214, 20554, 20555, 20556, 20534
33068, 20214, 20224, 20225, 20215, 20556, 20557, 20558, 20536
33069, 20215, 20225, 20226, 20216, 20558, 20559, 20560, 20538
33070, 20216, 20226, 20227, 20217, 20560, 20561, 20562, 20540
33071, 20217, 20227, 20228, 20218, 20562, 20563, 20564, 20542
33072, 20218, 20228, 20229, 20219, 20564, 20565, 20566, 20544
33073, 20219, 20229, 20230, 20220, 20566, 20567, 20568, 20546
33074, 20220, 20230, 20231, 20221, 20568, 20569, 20570, 20548
33075, 20221, 20231, 20232, 20222, 20570, 20571, 20572, 20550
33076, 20222, 20232, 1779, 1778, 20572, 20573, 1801, 20552
33077, 1644, 1645, 20233, 20223, 1667, 20574, 20575, 20553
33078, 20223, 20233, 20234, 20224, 20575, 20576, 20577, 20555
33079, 20224, 20234, 20235, 20225, 20577, 20578, 20579, 20557
33080, 20225, 20235, 20236, 20226, 20579, 20580, 20581, 20559
33081, 20226, 20236, 20237, 20227, 20581, 20582, 20583, 20561
33082, 20227, 20237, 20238, 20228, 20583, 20584, 20585, 20563
33083, 20228, 20238, 20239, 20229, 20585, 20586, 20587, 20565
33084, 20229, 20239, 20240, 20230, 20587, 20588, 20589, 20567
33085, 20230, 20240, 20241, 20231, 20589, 20590, 20591, 20569
33086, 20231, 20241, 20242, 20232, 20591, 20592, 20593, 20571
33087, 20232, 20242, 1780, 1779, 20593, 20594, 1802, 20573
33088, 1645, 1646, 20243, 20233, 1668, 20595, 20596, 20574
33089, 20233, 20243, 20244, 20234, 20596, 20597, 20598, 20576
33090, 20234, 20244, 20245, 20235, 20598, 20599, 20600, 20578
33091, 20235, 20245, 20246, 20236, 20600, 20601, 20602, 20580
33092, 20236, 20246, 20247, 20237, 20602, 20603, 20604, 20582
33093, 20237, 20247, 20248, 20238, 20604, 20605, 20606, 20584
33094, 20238, 20248, 20249, 20239, 20606, 20607, 20608, 20586
33095, 20239, 20249, 20250, 20240, 20608, 20609, 20610, 20588
33096, 20240, 20250, 20251, 20241, 20610, 20611, 20612, 20590
33097, 20241, 20251, 20252, 20242, 20612, 20613, 20614, 20592
33098, 20242, 20252, 1781, 1780, 20614, 20615, 1803, 20594
33099, 1646, 1647, 20253, 20243, 1669, 20616, 20617, 20595
33100, 20243, 20253, 20254, 20244, 20617, 20618, 20619, 20597
33101, 20244, 20254, 20255, 20245, 20619, 20620, 20621, 20599
33102, 20245, 20255, 20256, 20246, 20621, 20622, 20623, 20601
33103, 20246, 20256, 20257, 20247, 20623, 20624, 20625, 20603
33104, 20247, 20257, 20258, 20248, 20625, 20626, 20627, 20605
33105, 20248, 20258, 20259, 20249, 20627, 20628, 20629, 20607
33106, 20249, 20259, 20260, 20250, 20629, 20630, 20631, 20609
33107, 20250, 20260, 20261, 20251, 20631, 20632, 20633, 20611
33108, 20251, 20261, 20262, 20252, 20633, 20634, 20635, 20613
33109, 20252, 20262, 1782, 1781, 20635, 20636, 1804, 20615
33110, 1647, 1648, 20263, 20253, 1670, 20637, 20638, 20616
33111, 20253, 20263, 20264, 20254, 20638, 20639, 20640, 20618
33112, 20254, 20264, 20265, 20255, 20640, 20641, 20642, 20620
33113, 20255, 20265, 20266, 20256, 20642, 20643, 20644, 20622
33114, 20256, 20266, 20267, 20257, 20644, 20645, 20646, 20624
33115, 20257, 20267, 20268, 20258, 20646, 20647, 20648, 20626
33116, 20258, 20268, 20269, 20259, 20648, 20649, 20650, 20628
33117, 20259, 20269, 20270, 20260, 20650, 20651, 20652, 20630
33118, 20260, 20270, 20271, 20261, 20652, 20653, 20654, 20632
33119, 20261, 20271, 20272, 20262, 20654, 20655, 20656, 20634
33120, 20262, 20272, 1783, 1782, 20656, 20657, 1805, 20636
33121, 1648, 1649, 20273, 20263, 1671, 20658, 20659, 20637
33122, 20263, 20273, 20274, 20264, 20659, 20660, 20661, 20639
33123, 20264, 20274, 20275, 20265, 20661, 20662, 20663, 20641
33124, 20265, 20275, 20276, 20266, 20663, 20664, 20665, 20643
33125, 20266, 20276, 20277, 20267, 20665, 20666, 20667, 20645
33126, 20267, 20277, 20278, 20268, 20667, 20668, 20669, 20647
33127, 20268, 20278, 20279, 20269, 20669, 20670, 20671, 20649
33128, 20269, 20279, 20280, 20270, 20671, 20672, 20673, 20651
33129, 20270, 20280, 20281, 20271, 20673, 20674, 20675, 20653
33130, 20271, 20281, 20282, 20272, 20675, 20676, 20677, 20655
33131, 20272, 20282, 1784, 1783, 20677, 20678, 1806, 20657
33132, 1649, 1650, 20283, 20273, 1672, 20679, 20680, 20658
33133, 20273, 20283, 20284, 20274, 20680, 20681, 20682, 20660
33134, 20274, 20284, 20285, 20275, 20682, 20683, 20684, 20662
33135, 20275, 20285, 20286, 20276, 20684, 20685, 20686, 20664
33136, 20276, 20286, 20287, 20277, 20686, 20687, 20688, 20666
33137, 20277, 20287, 20288, 20278, 20688, 20689, 20690, 20668
33138, 20278, 20288, 20289, 20279, 20690, 20691, 20692, 20670
33139, 20279, 20289, 20290, 20280, 20692, 20693, 20694, 20672
33140, 20280, 20290, 20291, 20281, 20694, 20695, 20696, 20674
33141, 20281, 20291, 20292, 20282, 20696, 20697, 20698, 20676
33142, 20282, 20292, 1785, 1784, 20698, 20699, 1807, 20678
33143, 1650, 1651, 20293, 20283, 1673, 20700, 20701, 20679
33144, 20283, 20293, 20294, 20284, 20701, 20702, 20703, 20681
33145, 20284, 20294, 20295, 20285, 20703, 20704, 20705, 20683
33146, 20285, 20295, 20296, 20286, 20705, 20706, 20707, 20685
33147, 20286, 20296, 20297, 20287, 20707, 20708, 20709, 20687
33148, 20287, 20297, 20298, 20288, 20709, 20710, 20711, 20689
33149, 20288, 20298, 20299, 20289, 20711, 20712, 20713, 20691
33150, 20289, 20299, 20300, 20290, 20713, 20714, 20715, 20693
33151, 20290, 20300, 20301, 20291, 20715, 20716, 20717, 20695
33152, 20291, 20301, 20302, 20292, 20717, 20718, 20719, 20697
33153, 20292, 20302, 1786, 1785, 20719, 20720, 1808, 20699
33154, 1651, 1652, 20303, 20293, 1674, 20721, 20722, 20700
33155, 20293, 20303, 20304, 20294, 20722, 20723, 20724, 20702
33156, 20294, 20304, 20305, 20295, 20724, 20725, 20726, 20704
33157, 20295, 20305, 20306, 20296, 20726, 20727, 20728, 20706
33158, 20296, 20306, 20307, 20297, 20728, 20729, 20730, 20708
33159, 20297, 20307, 20308, 20298, 20730, 20731, 20732, 20710
33160, 20298, 20308, 20309, 20299, 20732, 20733, 20734, 20712
33161, 20299, 20309, 20310, 20300, 20734, 20735, 20736, 20714
33162, 20300, 20310, 20311, 20301, 20736, 20737, 20738, 20716
33163, 20301, 20311, 20312, 20302, 20738, 20739, 20740, 20718
33164, 20302, 20312, 1787, 1786, 20740, 20741, 1809, 20720
33165, 1652, 1653, 20313, 20303, 1675, 20742, 20743, 20721
33166, 20303, 20313, 20314, 20304, 20743, 20744, 20745, 20723
33167, 20304, 20314, 20315, 20305, 20745, 20746, 20747, 20725
33168, 20305, 20315, 20316, 20306, 20747, 20748, 20749, 20727
33169, 20306, 20316, 20317, 20307, 20749, 20750, 20751, 20729
33170, 20307, 20317, 20318, 20308, 20751, 20752, 20753, 20731
33171, 20308, 20318, 20319, 20309, 20753, 20754, 20755, 20733
33172, 20309, 20319, 20320, 20310, 20755, 20756, 20757, 20735
33173, 20310, 20320, 20321, 20311, 20757, 20758, 20759, 20737
33174, 20311, 20321, 20322, 20312, 20759, 20760, 20761, 20739
33175, 20312, 20322, 1788, 1787, 20761, 20762, 1810, 20741
33176, 1653, 1654, 20323, 20313, 1676, 20763, 20764, 20742
33177, 20313, 20323, 20324, 20314, 20764, 20765, 20766, 20744
33178, 20314, 20324, 20325, 20315, 20766, 20767, 20768, 20746
33179, 20315, 20325, 20326, 20316, 20768, 20769, 20770, 20748
33180, 20316, 20326, 20327, 20317, 20770, 20771, 20772, 20750
33181, 20317, 20327, 20328, 20318, 20772, 20773, 20774, 20752
33182, 20318, 20328, 20329, 20319, 20774, 20775, 20776, 20754
33183, 20319, 20329, 20330, 20320, 20776, 20777, 20778, 20756
33184, 20320, 20330, 20331, 20321, 20778, 20779, 20780, 20758
33185, 20321, 20331, 20332, 20322, 20780, 20781, 20782, 20760
33186, 20322, 20332, 1789, 1788, 20782, 20783, 1811, 20762
33187, 1654, 1655, 20333, 20323, 1677, 20784, 20785, 20763
33188, 20323, 20333, 20334, 20324, 20785, 20786, 20787, 20765
33189, 20324, 20334, 20335, 20325, 20787, 20788, 20789, 20767
33190, 20325, 20335, 20336, 20326, 20789, 20790, 20791, 20769
33191, 20326, 20336, 20337, 20327, 20791, 20792, 20793, 20771
33192, 20327, 20337, 20338, 20328, 20793, 20794, 20795, 20773
33193, 20328, 20338, 20339, 20329, 20795, 20796, 20797, 20775
33194, 20329, 20339, 20340, 20330, 20797, 20798, 20799, 20777
33195, 20330, 20340, 20341, 20331, 20799, 20800, 20801, 20779
33196, 20331, 20341, 20342, 20332, 20801, 20802, 20803, 20781
33197, 20332, 20342, 1790, 1789, 20803, 20804, 1812, 20783
33198, 1655, 38, 1889, 20333, 1678, 1900, 20805, 20784
33199, 20333, 1889, 1888, 20334, 20805, 1899, 20806, 20786
33200, 20334, 1888, 1887, 20335, 20806, 1898, 20807, 20788
33201, 20335, 1887, 1886, 20336, 20807, 1897, 20808, 20790
33202, 20336, 1886, 1885, 20337, 20808, 1896, 20809, 20792
33203, 20337, 1885, 1884, 20338, 20809, 1895, 20810, 20794
33204, 20338, 1884, 1883, 20339, 20810, 1894, 20811, 20796
33205, 20339, 1883, 1882, 20340, 20811, 1893, 20812, 20798
33206, 20340, 1882, 1881, 20341, 20812, 1892, 20813, 20800
33207, 20341, 1881, 1880, 20342, 20813, 1891, 20814, 20802
33208, 20342, 1880, 40, 1790, 20814, 1890, 1813, 20804
*ELEMENT, type=CPS8, ELSET=Surface46
33209, 37, 1868, 20815, 1679, 1879, 21035, 21036, 1701
33210, 1868, 1867, 20816, 20815, 1878, 21037, 21038, 21035
33211, 1867, 1866, 20817, 20816, 1877, 21039, 21040, 21037
33212, 1866, 1865, 20818, 20817, 1876, 21041, 21042, 21039
33213, 1865, 1864, 20819, 20818, 1875, 21043, 21044, 21041
33214, 1864, 1863, 20820, 20819, 1874, 21045, 21046, 21043
33215, 1863, 1862, 20821, 20820, 1873, 21047, 21048, 21045
33216, 1862, 1861, 20822, 20821, 1872, 21049, 21050, 21047
33217, 1861, 1860, 20823, 20822, 1871, 21051, 21052, 21049
33218, 1860, 1859, 20824, 20823, 1870, 21053, 21054, 21051
33219, 1859, 39, 1814, 20824, 1869, 1836, 21055, 21053
33220, 1679, 20815, 20825, 1680, 21036, 21056, 21057, 1702
33221, 20815, 20816, 20826, 20825, 21038, 21058, 21059, 21056
33222, 20816, 20817, 20827, 20826, 21040, 21060, 21061, 21058
33223, 20817, 20818, 20828, 20827, 21042, 21062, 21063, 21060
33224, 20818, 20819, 20829, 20828, 21044, 21064, 21065, 21062
33225, 20819, 20820, 20830, 20829, 21046, 21066, 21067, 21064
33226, 20820, 20821, 20831, 20830, 21048, 21068, 21069, 21066
33227, 20821, 20822, 20832, 20831, 21050, 21070, 21071, 21068
33228, 20822, 20823, 20833, 20832, 21052, 21072, 21073, 21070
33229, 20823, 20824, 20834, 20833, 21054, 21074, 21075, 21072
33230, 20824, 1814, 1815, 20834, 21055, 1837, 21076, 21074
33231, 1680, 20825, 20835, 1681, 21057, 21077, 21078, 1703
33232, 20825, 20826, 20836, 20835, 21059, 21079, 21080, 21077
33233, 20826, 20827, 20837, 20836, 21061, 21081, 21082, 21079
33234, 20827, 20828, 20838, 20837, 21063, 21083, 21084, 21081
33235, 20828, 20829, 20839, 20838, 21065, 21085, 21086, 21083
33236, 20829, 20830, 20840, 20839, 21067, 21087, 21088, 21085
33237, 20830, 20831, 20841, 20840, 21069, 21089, 21090, 21087
33238, 20831, 20832, 20842, 20841, 21071, 21091, 21092, 21089
33239, 20832, 20833, 20843, 20842, 21073, 21093, 21094, 21091
33240, 20833, 20834, 20844, 20843, 21075, 21095, 21096, 21093
33241, 20834, 1815, 1816, 20844, 21076, 1838, 21097, 21095
33242, 1681, 20835, 20845, 1682, 21078, 21098, 21099, 1704
33243, 20835, 20836, 20846, 20845, 21080, 21100, 21101, 21098
33244, 20836, 20837, 20847, 20846, 21082, 21102, 21103, 21100
33245, 20837, 20838, 20848, 20847, 21084, 21104, 21105, 21102
33246, 20838, 20839, 20849, 20848, 21086, 21106, 21107, 21104
33247, 20839, 20840, 20850, 20849, 21088, 21108, 21109, 21106
33248, 20840, 20841, 20851, 20850, 21090, 21110, 21111, 21108
33249, 20841, 20842, 20852, 20851, 21092, 21112, 21113, 21110
33250, 20842, 20843, 20853, 20852, 21094, 21114, 21115, 21112
33251, 20843, 20844, 20854, 20853, 21096, 21116, 21117, 21114
33252, 20844, 1816, 1817, 20854, 21097, 1839, 21118, 21116
33253, 1682, 20845, 20855, 1683, 21099, 21119, 21120, 1705
33254, 20845, 20846, 20856, 20855, 21101, 21121, 21122, 21119
33255, 20846, 20847, 20857, 20856, 21103, 21123, 21124, 21121
33256, 20847, 20848, 20858, 20857, 21105, 21125, 21126, 21123
33257, 20848, 20849, 20859, 20858, 21107, 21127, 21128, 21125
33258, 20849, 20850, 20860, 20859, 21109, 21129, 21130, 21127
33259, 20850, 20851, 20861, 20860, 21111, 21131, 21132, 21129
33260, 20851, 20852, 20862, 20861, 21113, 21133, 21134, 21131
33261, 20852, 20853, 20863, 20862, 21115, 21135, 21136, 21133
33262, 20853, 20854, 20864, 20863, 21117, 21137, 21138, 21135
33263, 20854, 1817, 1818, 20864, 21118, 1840, 21139, 21137
33264, 1683, 20855, 20865, 1684, 21120, 21140, 21141, 1706
33265, 20855, 20856, 20866, 20865, 21122, 21142, 21143, 21140
33266, 20856, 20857, 20867, 20866, 21124, 21144, 21145, 21142
33267, 20857, 20858, 20868, 20867, 21126, 21146, 21147, 21144
33268, 20858, 20859, 20869, 20868, 21128, 21148, 21149, 21146
33269, 20859, 20860, 20870, 20869, 21130, 21150, 21151, 21148
33270, 20860, 20861, 20871, 20870, 21132, 21152, 21153, 21150
33271, 20861, 20862, 20872, 20871, 21134, 21154, 21155, 21152
33272, 20862, 20863, 20873, 20872, 21136, 21156, 21157, 21154
33273, 20863, 20864, 20874, 20873, 21138, 21158, 21159, 21156
33274, 20864, 1818, 1819, 20874, 21139, 1841, 21160, 21158
33275, 1684, 20865, 20875, 1685, 21141, 21161, 21162, 1707
33276, 20865, 20866, 20876, 20875, 21143, 21163, 21164, 21161
33277, 20866, 20867, 20877, 20876, 21145, 21165, 21166, 21163
33278, 20867, 20868, 20878, 20877, 21147, 21167, 21168, 21165
33279, 20868, 20869, 20879, 20878, 21149, 21169, 21170, 21167
33280, 20869, 20870, 20880, 20879, 21151, 21171, 21172, 21169
33281, 20870, 20871, 20881, 20880, 21153, 21173, 21174, 21171
33282, 20871, 20872, 20882, 20881, 21155, 21175, 21176, 21173
33283, 20872, 20873, 20883, 20882, 21157, 21177, 21178, 21175
33284, 20873, 20874, 20884, 20883, 21159, 21179, 21180, 21177
33285, 20874, 1819, 1820, 20884, 21160, 1842, 21181, 21179
33286, 1685, 20875, 20885, 1686, 21162, 21182, 21183, 1708
33287, 20875, 20876, 20886, 20885, 21164, 21184, 21185, 21182
33288, 20876, 20877, 20887, 20886, 21166, 21186, 21187, 21184
33289, 20877, 20878, 20888, 20887, 21168, 21188, 21189, 21186
33290, 20878, 20879, 20889, 20888, 21170, 21190, 21191, 21188
33291, 20879, 20880, 20890, 20889, 21172, 21192, 21193, 21190
33292, 20880, 20881, 20891, 20890, 21174, 21194, 21195, 21192
33293, 20881, 20882, 20892, 20891, 21176, 21196, 21197, 21194
33294, 20882, 20883, 20893, 20892, 21178, 21198, 21199, 21196
33295, 20883, 20884, 20894, 20893, 21180, 21200, 21201, 21198
33296, 20884, 1820, 1821, 20894, 21181, 1843, 21202, 21200
33297, 1686, 20885, 20895, 1687, 21183, 21203, 21204, 1709
33298, 20885, 20886, 20896, 20895, 21185, 21205, 21206, 21203
33299, 20886, 20887, 20897, 20896, 21187, 21207, 21208, 21205
33300, 20887, 20888, 20898, 20897, 21189, 21209, 21210, 21207
33301, 20888, 20889, 20899, 20898, 21191, 21211, 21212, 21209
33302, 20889, 20890, 20900, 20899, 21193, 21213, 21214, 21211
33303, 20890, 20891, 20901, 20900, 21195, 21215, 21216, 21213
33304, 20891, 20892, 20902, 20901, 21197, 21217, 21218, 21215
33305, 20892, 20893, 20903, 20902, 21199, 21219, 21220, 21217
33306, 20893, 20894, 20904, 20903, 21201, 21221, 21222, 21219
33307, 20894, 1821, 1822, 20904, 21202, 1844, 21223, 21221
33308, 1687, 20895, 20905, 1688, 21204, 21224, 21225, 1710
33309, 20895, 20896, 20906, 20905, 21206, 21226, 21227, 21224
33310, 20896, 20897, 20907, 20906, 21208, 21228, 21229, 21226
33311, 20897, 20898, 20908, 20907, 21210, 21230, 21231, 21228
33312, 20898, 20899, 20909, 20908, 21212, 21232, 21233, 21230
33313, 20899, 20900, 20910, 20909, 21214, 21234, 21235, 21232
33314, 20900, 20901, 20911, 20910, 21216, 21236, 21237, 21234
33315, 20901, 20902, 20912, 20911, 21218, 21238, 21239, 21236
33316, 20902, 20903, 20913, 20912, 21220, 21240, 21241, 21238
33317, 20903, 20904, 20914, 20913, 21222, 21242, 21243, 21240
33318, 20904, 1822, 1823, 20914, 21223, 1845, 21244, 21242
33319, 1688, 20905, 20915, 1689, 21225, 21245, 21246, 1711
33320, 20905, 20906, 20916, 20915, 21227, 21247, 21248, 21245
33321, 20906, 20907, 20917, 20916, 21229, 21249, 21250, 21247
33322, 20907, 20908, 20918, 20917, 21231, 21251, 21252, 21249
33323, 20908, 20909, 20919, 20918, 21233, 21253, 21254, 21251
33324, 20909, 20910, 20920, 20919, 21235, 21255, 21256, 21253
33325, 20910, 20911, 20921, 20920, 21237, 21257, 21258, 21255
33326, 20911, 20912, 20922, 20921, 21239, 21259, 21260, 21257
33327, 20912, 20913, 20923, 20922, 21241, 21261, 21262, 21259
33328, 20913, 20914, 20924, 20923, 21243, 21263, 21264, 21261
33329, 20914, 1823, 1824, 20924, 21244, 1846, 21265, 21263
33330, 1689, 20915, 20925, 1690, 21246, 21266, 21267, 1712
33331, 20915, 20916, 20926, 20925, 21248, 21268, 21269, 21266
33332, 20916, 20917, 20927, 20926, 21250, 21270, 21271, 21268
33333, 20917, 20918, 20928, 20927, 21252, 21272, 21273, 21270
33334, 20918, 20919, 20929, 20928, 21254, 21274, 21275, 21272
33335, 20919, 20920, 20930, 20929, 21256, 21276, 21277, 21274
33336, 20920, 20921, 20931, 20930, 21258, 21278, 21279, 21276
33337, 20921, 20922, 20932, 20931, 21260, 21280, 21281, 21278
33338, 20922, 20923, 20933, 20932, 21262, 21282, 21283, 21280
33339, 20923, 20924, 20934, 20933, 21264, 21284, 21285, 21282
33340, 20924, 1824, 1825, 20934, 21265, 1847, 21286, 21284
33341, 1690, 20925, 20935, 1691, 21267, 21287, 21288, 1713
33342, 20925, 20926, 20936, 20935, 21269, 21289, 21290, 21287
33343, 20926, 20927, 20937, 20936, 21271, 21291, 21292, 21289
33344, 20927, 20928, 20938, 20937, 21273, 21293, 21294, 21291
33345, 20928, 20929, 20939, 20938, 21275, 21295, 21296, 21293
33346, 20929, 20930, 20940, 20939, 21277, 21297, 21298, 21295
33347, 20930, 20931, 20941, 20940, 21279, 21299, 21300, 21297
33348, 20931, 20932, 20942, 20941, 21281, 21301, 21302, 21299
33349, 20932, 20933, 20943, 20942, 21283, 21303, 21304, 21301
33350, 20933, 20934, 20944, 20943, 21285, 21305, 21306, 21303
33351, 20934, 1825, 1826, 20944, 21286, 1848, 21307, 21305
33352, 1691, 20935, 20945, 1692, 21288, 21308, 21309, 1714
33353, 20935, 20936, 20946, 20945, 21290, 21310, 21311, 21308
33354, 20936, 20937, 20947, 20946, 21292, 21312, 21313, 21310
33355, 20937, 20938, 20948, 20947, 21294, 21314, 21315, 21312
33356, 20938, 20939, 20949, 20948, 21296, 21316, 21317, 21314
33357, 20939, 20940, 20950, 20949, 21298, 21318, 21319, 21316
33358, 20940, 20941, 20951, 20950, 21300, 21320, 21321, 21318
33359, 20941, 20942, 20952, 20951, 21302, 21322, 21323, 21320
33360, 20942, 20943, 20953, 20952, 21304, 21324, 21325, 21322
33361, 20943, 20944, 20954, 20953, 21306, 21326, 21327, 21324
33362, 20944, 1826, 1827, 20954, 21307, 1849, 21328, 21326
33363, 1692, 20945, 20955, 1693, 21309, 21329, 21330, 1715
33364, 20945, 20946, 20956, 20955, 21311, 21331, 21332, 21329
33365, 20946, 20947, 20957, 20956, 21313, 21333, 21334, 21331
33366, 20947, 20948, 20958, 20957, 21315, 21335, 21336, 21333
33367, 20948, 20949, 20959, 20958, 21317, 21337, 21338, 21335
33368, 20949, 20950, 20960, 20959, 21319, 21339, 21340, 21337
33369, 20950, 20951, 20961, 20960, 21321, 21341, 21342, 21339
33370, 20951, 20952, 20962, 20961, 21323, 21343, 21344, 21341
33371, 20952, 20953, 20963, 20962, 21325, 21345, 21346, 21343
33372, 20953, 20954, 20964, 20963, 21327, 21347, 21348, 21345
33373, 20954, 1827, 1828, 20964, 21328, 1850, 21349, 21347
33374, 1693, 20955, 20965, 1694, 21330, 21350, 21351, 1716
33375, 20955, 20956, 20966, 20965, 21332, 21352, 21353, 21350
33376, 20956, 20957, 20967, 20966, 21334, 21354, 21355, 21352
33377, 20957, 20958, 20968, 20967, 21336, 21356, 21357, 21354
33378, 20958, 20959, 20969, 20968, 21338, 21358, 21359, 21356
33379, 20959, 20960, 20970, 20969, 21340, 21360, 21361, 21358
33380, 20960, 20961, 20971, 20970, 21342, 21362, 21363, 21360
33381, 20961, 20962, 20972, 20971, 21344, 21364, 21365, 21362
33382, 20962, 20963, 20973, 20972, 21346, 21366, 21367, 21364
33383, 20963, 20964, 20974, 20973, 21348, 21368, 21369, 21366
33384, 20964, 1828, 1829, 20974, 21349, 1851, 21370, 21368
33385, 1694, 20965, 20975, 1695, 21351, 21371, 21372, 1717
33386, 20965, 20966, 20976, 20975, 21353, 21373, 21374, 21371
33387, 20966, 20967, 20977, 20976, 21355, 21375, 21376, 21373
33388, 20967, 20968, 20978, 20977, 21357, 21377, 21378, 21375
33389, 20968, 20969, 20979, 20978, 21359, 21379, 21380, 21377
33390, 20969, 20970, 20980, 20979, 21361, 21381, 21382, 21379
33391, 20970, 20971, 20981, 20980, 21363, 21383, 21384, 21381
33392, 20971, 20972, 20982, 20981, 21365, 21385, 21386, 21383
33393, 20972, 20973, 20983, 20982, 21367, 21387, 21388, 21385
33394, 20973, 20974, 20984, 20983, 21369, 21389, 21390, 21387
33395, 20974, 1829, 1830, 20984, 21370, 1852, 21391, 21389
33396, 1695, 20975, 20985, 1696, 21372, 21392, 21393, 1718
33397, 20975, 20976, 20986, 20985, 21374, 21394, 21395, 21392
33398, 20976, 20977, 20987, 20986, 21376, 21396, 21397, 21394
33399, 20977, 20978, 20988, 20987, 21378, 21398, 21399, 21396
33400, 20978, 20979, 20989, 20988, 21380, 21400, 21401, 21398
33401, 20979, 20980, 20990, 20989, 21382, 21402, 21403, 21400
33402, 20980, 20981, 20991, 20990, 21384, 21404, 21405, 21402
33403, 20981, 20982, 20992, 20991, 21386, 21406, 21407, 21404
33404, 20982, 20983, 20993, 20992, 21388, 21408, 21409, 21406
33405, 20983, 20984, 20994, 20993, 21390, 21410, 21411, 21408
33406, 20984, 1830, 1831, 20994, 21391, 1853, 21412, 21410
33407, 1696, 20985, 20995, 1697, 21393, 21413, 21414, 1719
33408, 20985, 20986, 20996, 20995, 21395, 21415, 21416, 21413
33409, 20986, 20987, 20997, 20996, 21397, 21417, 21418, 21415
33410, 20987, 20988, 20998, 20997, 21399, 21419, 21420, 21417
33411, 20988, 20989, 20999, 20998, 21401, 21421, 21422, 21419
33412, 20989, 20990, 21000, 20999, 21403, 21423, 21424, 21421
33413, 20990, 20991, 21001, 21000, 21405, 21425, 21426, 21423
33414, 20991, 20992, 21002, 21001, 21407, 21427, 21428, 21425
33415, 20992, 20993, 21003, 21002, 21409, 21429, 21430, 21427
33416, 20993, 20994, 21004, 21003, 21411, 21431, 21432, 21429
33417, 20994, 1831, 1832, 21004, 21412, 1854, 21433, 21431
33418, 1697, 20995, 21005, 1698, 21414, 21434, 21435, 1720
33419, 20995, 20996, 21006, 21005, 21416, 21436, 21437, 21434
33420, 20996, 20997, 21007, 21006, 21418, 21438, 21439, 21436
33421, 20997, 20998, 21008, 21007, 21420, 21440, 21441, 21438
33422, 20998, 20999, 21009, 21008, 21422, 21442, 21443, 21440
33423, 20999, 21000, 21010, 21009, 21424, 21444, 21445, 21442
33424, 21000, 21001, 21011, 21010, 21426, 21446, 21447, 21444
33425, 21001, 21002, 21012, 21011, 21428, 21448, 21449, 21446
33426, 21002, 21003, 21013, 21012, 21430, 21450, 21451, 21448
33427, 21003, 21004, 21014, 21013, 21432, 21452, 21453, 21450
33428, 21004, 1832, 1833, 21014, 21433, 1855, 21454, 21452
33429, 1698, 21005, 21015, 1699, 21435, 21455, 21456, 1721
33430, 21005, 21006, 21016, 21015, 21437, 21457, 21458, 21455
33431, 21006, 21007, 21017, 21016, 21439, 21459, 21460, 21457
33432, 21007, 21008, 21018, 21017, 21441, 21461, 21462, 21459
33433, 21008, 21009, 21019, 21018, 21443, 21463, 21464, 21461
33434, 21009, 21010, 21020, 21019, 21445, 21465, 21466, 21463
33435, 21010, 21011, 21021, 21020, 21447, 21467, 21468, 21465
33436, 21011, 21012, 21022, 21021, 21449, 21469, 21470, 21467
33437, 21012, 21013, 21023, 21022, 21451, 21471, 21472, 21469
33438, 21013, 21014, 21024, 21023, 21453, 21473, 21474, 21471
33439, 21014, 1833, 1834, 21024, 21454, 1856, 21475, 21473
33440, 1699, 21015, 21025, 1700, 21456, 21476, 21477, 1722
33441, 21015, 21016, 21026, 21025, 21458, 21478, 21479, 21476
33442, 21016, 21017, 21027, 21026, 21460, 21480, 21481, 21478
33443, 21017, 21018, 21028, 21027, 21462, 21482, 21483, 21480
33444, 21018, 21019, 21029, 21028, 21464, 21484, 21485, 21482
33445, 21019, 21020, 21030, 21029, 21466, 21486, 21487, 21484
33446, 21020, 21021, 21031, 21030, 21468, 21488, 21489, 21486
33447, 21021, 21022, 21032, 21031, 21470, 21490, 21491, 21488
33448, 21022, 21023, 21033, 21032, 21472, 21492, 21493, 21490
33449, 21023, 21024, 21034, 21033, 21474, 21494, 21495, 21492
33450, 21024, 1834, 1835, 21034, 21475, 1857, 21496, 21494
33451, 1700, 21025, 1889, 38, 21477, 21497, 1900, 1723
33452, 21025, 21026, 1888, 1889, 21479, 21498, 1899, 21497
33453, 21026, 21027, 1887, 1888, 21481, 21499, 1898, 21498
33454, 21027, 21028, 1886, 1887, 21483, 21500, 1897, 21499
33455, 21028, 21029, 1885, 1886, 21485, 21501, 1896, 21500
33456, 21029, 21030, 1884, 1885, 21487, 21502, 1895, 21501
33457, 21030, 21031, 1883, 1884, 21489, 21503, 1894, 21502
33458, 21031, 21032, 1882, 1883, 21491, 21504, 1893, 21503
33459, 21032, 21033, 1881, 1882, 21493, 21505, 1892, 21504
33460, 21033, 21034, 1880, 1881, 21495, 21506, 1891, 21505
33461, 21034, 1835, 40, 1880, 21496, 1858, 1890, 21506
*ELEMENT, type=CPS8, ELSET=Surface47
2233, 37, 1901, 21507, 1679, 1902, 21529, 21530, 1701
2234, 1679, 21507, 21508, 1680, 21530, 21531, 21532, 1702
2235, 1680, 21508, 21509, 1681, 21532, 21533, 21534, 1703
2236, 1681, 21509, 21510, 1682, 21534, 21535, 21536, 1704
2237, 1682, 21510, 21511, 1683, 21536, 21537, 21538, 1705
2238, 1683, 21511, 21512, 1684, 21538, 21539, 21540, 1706
2239, 1684, 21512, 21513, 1685, 21540, 21541, 21542, 1707
2240, 1685, 21513, 21514, 1686, 21542, 21543, 21544, 1708
2241, 1686, 21514, 21515, 1687, 21544, 21545, 21546, 1709
2242, 1687, 21515, 21516, 1688, 21546, 21547, 21548, 1710
2243, 1688, 21516, 21517, 1689, 21548, 21549, 21550, 1711
2244, 1689, 21517, 21518, 1690, 21550, 21551, 21552, 1712
2245, 1690, 21518, 21519, 1691, 21552, 21553, 21554, 1713
2246, 1691, 21519, 21520, 1692, 21554, 21555, 21556, 1714
2247, 1692, 21520, 21521, 1693, 21556, 21557, 21558, 1715
2248, 1693, 21521, 21522, 1694, 21558, 21559, 21560, 1716
2249, 1694, 21522, 21523, 1695, 21560, 21561, 21562, 1717
2250, 1695, 21523, 21524, 1696, 21562, 21563, 21564, 1718
2251, 1696, 21524, 21525, 1697, 21564, 21565, 21566, 1719
2252, 1697, 21525, 21526, 1698, 21566, 21567, 21568, 1720
2253, 1698, 21526, 21527, 1699, 21568, 21569, 21570, 1721
2254, 1699, 21527, 21528, 1700, 21570, 21571, 21572, 1722
2255, 1700, 21528, 1904, 38, 21572, 21573, 1905, 1723
2256, 1901, 41, 1907, 21507, 1903, 1929, 21574, 21529
2257, 21507, 1907, 1908, 21508, 21574, 1930, 21575, 21531
2258, 21508, 1908, 1909, 21509, 21575, 1931, 21576, 21533
2259, 21509, 1909, 1910, 21510, 21576, 1932, 21577, 21535
2260, 21510, 1910, 1911, 21511, 21577, 1933, 21578, 21537
2261, 21511, 1911, 1912, 21512, 21578, 1934, 21579, 21539
2262, 21512, 1912, 1913, 21513, 21579, 1935, 21580, 21541
2263, 21513, 1913, 1914, 21514, 21580, 1936, 21581, 21543
2264, 21514, 1914, 1915, 21515, 21581, 1937, 21582, 21545
2265, 21515, 1915, 1916, 21516, 21582, 1938, 21583, 21547
2266, 21516, 1916, 1917, 21517, 21583, 1939, 21584, 21549
2267, 21517, 1917, 1918, 21518, 21584, 1940, 21585, 21551
2268, 21518, 1918, 1919, 21519, 21585, 1941, 21586, 21553
2269, 21519, 1919, 1920, 21520, 21586, 1942, 21587, 21555
2270, 21520, 1920, 1921, 21521, 21587, 1943, 21588, 21557
2271, 21521, 1921, 1922, 21522, 21588, 1944, 21589, 21559
2272, 21522, 1922, 1923, 21523, 21589, 1945, 21590, 21561
2273, 21523, 1923, 1924, 21524, 21590, 1946, 21591, 21563
2274, 21524, 1924, 1925, 21525, 21591, 1947, 21592, 21565
2275, 21525, 1925, 1926, 21526, 21592, 1948, 21593, 21567
2276, 21526, 1926, 1927, 21527, 21593, 1949, 21594, 21569
2277, 21527, 1927, 1928, 21528, 21594, 1950, 21595, 21571
2278, 21528, 1928, 42, 1904, 21595, 1951, 1906, 21573
*ELEMENT, type=CPS8, ELSET=Surface48
33462, 39, 1814, 21596, 1952, 1836, 21618, 21619, 1953
33463, 1814, 1815, 21597, 21596, 1837, 21620, 21621, 21618
33464, 1815, 1816, 21598, 21597, 1838, 21622, 21623, 21620
33465, 1816, 1817, 21599, 21598, 1839, 21624, 21625, 21622
33466, 1817, 1818, 21600, 21599, 1840, 21626, 21627, 21624
33467, 1818, 1819, 21601, 21600, 1841, 21628, 21629, 21626
33468, 1819, 1820, 21602, 21601, 1842, 21630, 21631, 21628
33469, 1820, 1821, 21603, 21602, 1843, 21632, 21633, 21630
33470, 1821, 1822, 21604, 21603, 1844, 21634, 21635, 21632
33471, 1822, 1823, 21605, 21604, 1845, 21636, 21637, 21634
33472, 1823, 1824, 21606, 21605, 1846, 21638, 21639, 21636
33473, 1824, 1825, 21607, 21606, 1847, 21640, 21641, 21638
33474, 1825, 1826, 21608, 21607, 1848, 21642, 21643, 21640
33475, 1826, 1827, 21609, 21608, 1849, 21644, 21645, 21642
33476, 1827, 1828, 21610, 21609, 1850, 21646, 21647, 21644
33477, 1828, 1829, 21611, 21610, 1851, 21648, 21649, 21646
33478, 1829, 1830, 21612, 21611, 1852, 21650, 21651, 21648
33479, 1830, 1831, 21613, 21612, 1853, 21652, 21653, 21650
33480, 1831, 1832, 21614, 21613, 1854, 21654, 21655, 21652
33481, 1832, 1833, 21615, 21614, 1855, 21656, 21657, 21654
33482, 1833, 1834, 21616, 21615, 1856, 21658, 21659, 21656
33483, 1834, 1835, 21617, 21616, 1857, 21660, 21661, 21658
33484, 1835, 40, 1955, 21617, 1858, 1956, 21662, 21660
33485, 1952, 21596, 1958, 43, 21619, 21663, 1980, 1954
33486, 21596, 21597, 1959, 1958, 21621, 21664, 1981, 21663
33487, 21597, 21598, 1960, 1959, 21623, 21665, 1982, 21664
33488, 21598, 21599, 1961, 1960, 21625, 21666, 1983, 21665
33489, 21599, 21600, 1962, 1961, 21627, 21667, 1984, 21666
33490, 21600, 21601, 1963, 1962, 21629, 21668, 1985, 21667
33491, 21601, 21602, 1964, 1963, 21631, 21669, 1986, 21668
33492, 21602, 21603, 1965, 1964, 21633, 21670, 1987, 21669
33493, 21603, 21604, 1966, 1965, 21635, 21671, 1988, 21670
33494, 21604, 21605, 1967, 1966, 21637, 21672, 1989, 21671
33495, 21605, 21606, 1968, 1967, 21639, 21673, 1990, 21672
33496, 21606, 21607, 1969, 1968, 21641, 21674, 1991, 21673
33497, 21607, 21608, 1970, 1969, 21643, 21675, 1992, 21674
33498, 21608, 21609, 1971, 1970, 21645, 21676, 1993, 21675
33499, 21609, 21610, 1972, 1971, 21647, 21677, 1994, 21676
33500, 21610, 21611, 1973, 1972, 21649, 21678, 1995, 21677
33501, 21611, 21612, 1974, 1973, 21651, 21679, 1996, 21678
33502, 21612, 21613, 1975, 1974, 21653, 21680, 1997, 21679
33503, 21613, 21614, 1976, 1975, 21655, 21681, 1998, 21680
33504, 21614, 21615, 1977, 1976, 21657, 21682, 1999, 21681
33505, 21615, 21616, 1978, 1977, 21659, 21683, 2000, 21682
33506, 21616, 21617, 1979, 1978, 21661, 21684, 2001, 21683
33507, 21617, 1955, 44, 1979, 21662, 1957, 2002, 21684
*ELEMENT, type=CPS8, ELSET=Surface49
33508, 37, 1868, 21685, 1901, 1879, 21695, 21696, 1902
33509, 1868, 1867, 21686, 21685, 1878, 21697, 21698, 21695
33510, 1867, 1866, 21687, 21686, 1877, 21699, 21700, 21697
33511, 1866, 1865, 21688, 21687, 1876, 21701, 21702, 21699
33512, 1865, 1864, 21689, 21688, 1875, 21703, 21704, 21701
33513, 1864, 1863, 21690, 21689, 1874, 21705, 21706, 21703
33514, 1863, 1862, 21691, 21690, 1873, 21707, 21708, 21705
33515, 1862, 1861, 21692, 21691, 1872, 21709, 21710, 21707
33516, 1861, 1860, 21693, 21692, 1871, 21711, 21712, 21709
33517, 1860, 1859, 21694, 21693, 1870, 21713, 21714, 21711
33518, 1859, 39, 1952, 21694, 1869, 1953, 21715, 21713
33519, 1901, 21685, 2012, 41, 21696, 21716, 2023, 1903
33520, 21685, 21686, 2011, 2012, 21698, 21717, 2022, 21716
33521, 21686, 21687, 2010, 2011, 21700, 21718, 2021, 21717
33522, 21687, 21688, 2009, 2010, 21702, 21719, 2020, 21718
33523, 21688, 21689, 2008, 2009, 21704, 21720, 2019, 21719
33524, 21689, 21690, 2007, 2008, 21706, 21721, 2018, 21720
33525, 21690, 21691, 2006, 2007, 21708, 21722, 2017, 21721
33526, 21691, 21692, 2005, 2006, 21710, 21723, 2016, 21722
33527, 21692, 21693, 2004, 2005, 21712, 21724, 2015, 21723
33528, 21693, 21694, 2003, 2004, 21714, 21725, 2014, 21724
33529, 21694, 1952, 43, 2003, 21715, 1954, 2013, 21725
*ELEMENT, type=CPS8, ELSET=Surface50
33530, 38, 1904, 21726, 1889, 1905, 21736, 21737, 1900
33531, 1889, 21726, 21727, 1888, 21737, 21738, 21739, 1899
33532, 1888, 21727, 21728, 1887, 21739, 21740, 21741, 1898
33533, 1887, 21728, 21729, 1886, 21741, 21742, 21743, 1897
33534, 1886, 21729, 21730, 1885, 21743, 21744, 21745, 1896
33535, 1885, 21730, 21731, 1884, 21745, 21746, 21747, 1895
33536, 1884, 21731, 21732, 1883, 21747, 21748, 21749, 1894
33537, 1883, 21732, 21733, 1882, 21749, 21750, 21751, 1893
33538, 1882, 21733, 21734, 1881, 21751, 21752, 21753, 1892
33539, 1881, 21734, 21735, 1880, 21753, 21754, 21755, 1891
33540, 1880, 21735, 1955, 40, 21755, 21756, 1956, 1890
33541, 1904, 42, 2033, 21726, 1906, 2044, 21757, 21736
33542, 21726, 2033, 2032, 21727, 21757, 2043, 21758, 21738
33543, 21727, 2032, 2031, 21728, 21758, 2042, 21759, 21740
33544, 21728, 2031, 2030, 21729, 21759, 2041, 21760, 21742
33545, 21729, 2030, 2029, 21730, 21760, 2040, 21761, 21744
33546, 21730, 2029, 2028, 21731, 21761, 2039, 21762, 21746
33547, 21731, 2028, 2027, 21732, 21762, 2038, 21763, 21748
33548, 21732, 2027, 2026, 21733, 21763, 2037, 21764, 21750
33549, 21733, 2026, 2025, 21734, 21764, 2036, 21765, 21752
33550, 21734, 2025, 2024, 21735, 21765, 2035, 21766, 21754
33551, 21735, 2024, 44, 1955, 21766, 2034, 1957, 21756
*ELEMENT, type=CPS8, ELSET=Surface51
33552, 41, 2012, 21767, 1907, 2023, 21987, 21988, 1929
33553, 2012, 2011, 21768, 21767, 2022, 21989, 21990, 21987
33554, 2011, 2010, 21769, 21768, 2021, 21991, 21992, 21989
33555, 2010, 2009, 21770, 21769, 2020, 21993, 21994, 21991
33556, 2009, 2008, 21771, 21770, 2019, 21995, 21996, 21993
33557, 2008, 2007, 21772, 21771, 2018, 21997, 21998, 21995
33558, 2007, 2006, 21773, 21772, 2017, 21999, 22000, 21997
33559, 2006, 2005, 21774, 21773, 2016, 22001, 22002, 21999
33560, 2005, 2004, 21775, 21774, 2015, 22003, 22004, 22001
33561, 2004, 2003, 21776, 21775, 2014, 22005, 22006, 22003
33562, 2003, 43, 1958, 21776, 2013, 1980, 22007, 22005
33563, 1907, 21767, 21777, 1908, 21988, 22008, 22009, 1930
33564, 21767, 21768, 21778, 21777, 21990, 22010, 22011, 22008
33565, 21768, 21769, 21779, 21778, 21992, 22012, 22013, 22010
33566, 21769, 21770, 21780, 21779, 21994, 22014, 22015, 22012
33567, 21770, 21771, 21781, 21780, 21996, 22016, 22017, 22014
33568, 21771, 21772, 21782, 21781, 21998, 22018, 22019, 22016
33569, 21772, 21773, 21783, 21782, 22000, 22020, 22021, 22018
33570, 21773, 21774, 21784, 21783, 22002, 22022, 22023, 22020
33571, 21774, 21775, 21785, 21784, 22004, 22024, 22025, 22022
33572, 21775, 21776, 21786, 21785, 22006, 22026, 22027, 22024
33573, 21776, 1958, 1959, 21786, 22007, 1981, 22028, 22026
33574, 1908, 21777, 21787, 1909, 22009, 22029, 22030, 1931
33575, 21777, 21778, 21788, 21787, 22011, 22031, 22032, 22029
33576, 21778, 21779, 21789, 21788, 22013, 22033, 22034, 22031
33577, 21779, 21780, 21790, 21789, 22015, 22035, 22036, 22033
33578, 21780, 21781, 21791, 21790, 22017, 22037, 22038, 22035
33579, 21781, 21782, 21792, 21791, 22019, 22039, 22040, 22037
33580, 21782, 21783, 21793, 21792, 22021, 22041, 22042, 22039
33581, 21783, 21784, 21794, 21793, 22023, 22043, 22044, 22041
33582, 21784, 21785, 21795, 21794, 22025, 22045, 22046, 22043
33583, 21785, 21786, 21796, 21795, 22027, 22047, 22048, 22045
33584, 21786, 1959, 1960, 21796, 22028, 1982, 22049, 22047
33585, 1909, 21787, 21797, 1910, 22030, 22050, 22051, 1932
33586, 21787, 21788, 21798, 21797, 22032, 22052, 22053, 22050
33587, 21788, 21789, 21799, 21798, 22034, 22054, 22055, 22052
33588, 21789, 21790, 21800, 21799, 22036, 22056, 22057, 22054
33589, 21790, 21791, 21801, 21800, 22038, 22058, 22059, 22056
33590, 21791, 21792, 21802, 21801, 22040, 22060, 22061, 22058
33591, 21792, 21793, 21803, 21802, 22042, 22062, 22063, 22060
33592, 21793, 21794, 21804, 21803, 22044, 22064, 22065, 22062
33593, 21794, 21795, 21805, 21804, 22046, 22066, 22067, 22064
33594, 21795, 21796, 21806, 21805, 22048, 22068, 22069, 22066
33595, 21796, 1960, 1961, 21806, 22049, 1983, 22070, 22068
33596, 1910, 21797, 21807, 1911, 22051, 22071, 22072, 1933
33597, 21797, 21798, 21808, 21807, 22053, 22073, 22074, 22071
33598, 21798, 21799, 21809, 21808, 22055, 22075, 22076, 22073
33599, 21799, 21800, 21810, 21809, 22057, 22077, 22078, 22075
33600, 21800, 21801, 21811, 21810, 22059, 22079, 22080, 22077
33601, 21801, 21802, 21812, 21811, 22061, 22081, 22082, 22079
33602, 21802, 21803, 21813, 21812, 22063, 22083, 22084, 22081
33603, 21803, 21804, 21814, 21813, 22065, 22085, 22086, 22083
33604, 21804, 21805, 21815, 21814, 22067, 22087, 22088, 22085
33605, 21805, 21806, 21816, 21815, 22069, 22089, 22090, 22087
33606, 21806, 1961, 1962, 21816, 22070, 1984, 22091, 22089
33607, 1911, 21807, 21817, 1912, 22072, 22092, 22093, 1934
33608, 21807, 21808, 21818, 21817, 22074, 22094, 22095, 22092
33609, 21808, 21809, 21819, 21818, 22076, 22096, 22097, 22094
33610, 21809, 21810, 21820, 21819, 22078, 22098, 22099, 22096
33611, 21810, 21811, 21821, 21820, 22080, 22100, 22101, 22098
33612, 21811, 21812, 21822, 21821, 22082, 22102, 22103, 22100
33613, 21812, 21813, 21823, 21822, 22084, 22104, 22105, 22102
33614, 21813, 21814, 21824, 21823, 22086, 22106, 22107, 22104
33615, 21814, 21815, 21825, 21824, 22088, 22108, 22109, 22106
33616, 21815, 21816, 21826, 21825, 22090, 22110, 22111, 22108
33617, 21816, 1962, 1963, 21826, 22091, 1985, 22112, 22110
33618, 1912, 21817, 21827, 1913, 22093, 22113, 22114, 1935
33619, 21817, 21818, 21828, 21827, 22095, 22115, 22116, 22113
33620, 21818, 21819, 21829, 21828, 22097, 22117, 22118, 22115
33621, 21819, 21820, 21830, 21829, 22099, 22119, 22120, 22117
33622, 21820, 21821, 21831, 21830, 22101, 22121, 22122, 22119
33623, 21821, 21822, 21832, 21831, 22103, 22123, 22124, 22121
33624, 21822, 21823, 21833, 21832, 22105, 22125, 22126, 22123
33625, 21823, 21824, 21834, 21833, 22107, 22127, 22128, 22125
33626, 21824, 21825, 21835, 21834, 22109, 22129, 22130, 22127
33627, 21825, 21826, 21836, 21835, 22111, 22131, 22132, 22129
33628, 21826, 1963, 1964, 21836, 22112, 1986, 22133, 22131
33629, 1913, 21827, 21837, 1914, 22114, 22134, 22135, 1936
33630, 21827, 21828, 21838, 21837, 22116, 22136, 22137, 22134
33631, 21828, 21829, 21839, 21838, 22118, 22138, 22139, 22136
33632, 21829, 21830, 21840, 21839, 22120, 22140, 22141, 22138
33633, 21830, 21831, 21841, 21840, 22122, 22142, 22143, 22140
33634, 21831, 21832, 21842, 21841, 22124, 22144, 22145, 22142
33635, 21832, 21833, 21843, 21842, 22126, 22146, 22147, 22144
33636, 21833, 21834, 21844, 21843, 22128, 22148, 22149, 22146
33637, 21834, 21835, 21845, 21844, 22130, 22150, 22151, 22148
33638, 21835, 21836, 21846, 21845, 22132, 22152, 22153, 22150
33639, 21836, 1964, 1965, 21846, 22133, 1987, 22154, 22152
33640, 1914, 21837, 21847, 1915, 22135, 22155, 22156, 1937
33641, 21837, 21838, 21848, 21847, 22137, 22157, 22158, 22155
33642, 21838, 21839, 21849, 21848, 22139, 22159, 22160, 22157
33643, 21839, 21840, 21850, 21849, 22141, 22161, 22162, 22159
33644, 21840, 21841, 21851, 21850, 22143, 22163, 22164, 22161
33645, 21841, 21842, 21852, 21851, 22145, 22165, 22166, 22163
33646, 21842, 21843, 21853, 21852, 22147, 22167, 22168, 22165
33647, 21843, 21844, 21854, 21853, 22149, 22169, 22170, 22167
33648, 21844, 21845, 21855, 21854, 22151, 22171, 22172, 22169
33649, 21845, 21846, 21856, 21855, 22153, 22173, 22174, 22171
33650, 21846, 1965, 1966, 21856, 22154, 1988, 22175, 22173
33651, 1915, 21847, 21857, 1916, 22156, 22176, 22177, 1938
33652, 21847, 21848, 21858, 21857, 22158, 22178, 22179, 22176
33653, 21848, 21849, 21859, 21858, 22160, 22180, 22181, 22178
33654, 21849, 21850, 21860, 21859, 22162, 22182, 22183, 22180
33655, 21850, 21851, 21861, 21860, 22164, 22184, 22185, 22182
33656, 21851, 21852, 21862, 21861, 22166, 22186, 22187, 22184
33657, 21852, 21853, 21863, 21862, 22168, 22188, 22189, 22186
33658, 21853, 21854, 21864, 21863, 22170, 22190, 22191, 22188
33659, 21854, 21855, 21865, 21864, 22172, 22192, 22193, 22190
33660, 21855, 21856, 21866, 21865, 22174, 22194, 22195, 22192
33661, 21856, 1966, 1967, 21866, 22175, 1989, 22196, 22194
33662, 1916, 21857, 21867, 1917, 22177, 22197, 22198, 1939
33663, 21857, 21858, 21868, 21867, 22179, 22199, 22200, 22197
33664, 21858, 21859, 21869, 21868, 22181, 22201, 22202, 22199
33665, 21859, 21860, 21870, 21869, 22183, 22203, 22204, 22201
33666, 21860, 21861, 21871, 21870, 22185, 22205, 22206, 22203
33667, 21861, 21862, 21872, 21871, 22187, 22207, 22208, 22205
33668, 21862, 21863, 21873, 21872, 22189, 22209, 22210, 22207
33669, 21863, 21864, 21874, 21873, 22191, 22211, 22212, 22209
33670, 21864, 21865, 21875, 21874, 22193, 22213, 22214, 22211
33671, 21865, 21866, 21876, 21875, 22195, 22215, 22216, 22213
33672, 21866, 1967, 1968, 21876, 22196, 1990, 22217, 22215
33673, 1917, 21867, 21877, 1918, 22198, 22218, 22219, 1940
33674, 21867, 21868, 21878, 21877, 22200, 22220, 22221, 22218
33675, 21868, 21869, 21879, 21878, 22202, 22222, 22223, 22220
33676, 21869, 21870, 21880, 21879, 22204, 22224, 22225, 22222
33677, 21870, 21871, 21881, 21880, 22206, 22226, 22227, 22224
33678, 21871, 21872, 21882, 21881, 22208, 22228, 22229, 22226
33679, 21872, 21873, 21883, 21882, 22210, 22230, 22231, 22228
33680, 21873, 21874, 21884, 21883, 22212, 22232, 22233, 22230
33681, 21874, 21875, 21885, 21884, 22214, 22234, 22235, 22232
33682, 21875, 21876, 21886, 21885, 22216, 22236, 22237, 22234
33683, 21876, 1968, 1969, 21886, 22217, 1991, 22238, 22236
33684, 1918, 21877, 21887, 1919, 22219, 22239, 22240, 1941
33685, 21877, 21878, 21888, 21887, 22221, 22241, 22242, 22239
33686, 21878, 21879, 21889, 21888, 22223, 22243, 22244, 22241
33687, 21879, 21880, 21890, 21889, 22225, 22245, 22246, 22243
33688, 21880, 21881, 21891, 21890, 22227, 22247, 22248, 22245
33689, 21881, 21882, 21892, 21891, 22229, 22249, 22250, 22247
33690, 21882, 21883, 21893, 21892, 22231, 22251, 22252, 22249
33691, 21883, 21884, 21894, 21893, 22233, 22253, 22254, 22251
33692, 21884, 21885, 21895, 21894, 22235, 22255, 22256, 22253
33693, 21885, 21886, 21896, 21895, 22237, 22257, 22258, 22255
33694, 21886, 1969, 1970, 21896, 22238, 1992, 22259, 22257
33695, 1919, 21887, 21897, 1920, 22240, 22260, 22261, 1942
33696, 21887, 21888, 21898, 21897, 22242, 22262, 22263, 22260
33697, 21888, 21889, 21899, 21898, 22244, 22264, 22265, 22262
33698, 21889, 21890, 21900, 21899, 22246, 22266, 22267, 22264
33699, 21890, 21891, 21901, 21900, 22248, 22268, 22269, 22266
33700, 21891, 21892, 21902, 21901, 22250, 22270, 22271, 22268
33701, 21892, 21893, 21903, 21902, 22252, 22272, 22273, 22270
33702, 21893, 21894, 21904, 21903, 22254, 22274, 22275, 22272
33703, 21894, 21895, 21905, 21904, 22256, 22276, 22277, 22274
33704, 21895, 21896, 21906, 21905, 22258, 22278, 22279, 22276
33705, 21896, 1970, 1971, 21906, 22259, 1993, 22280, 22278
33706, 1920, 21897, 21907, 1921, 22261, 22281, 22282, 1943
33707, 21897, 21898, 21908, 21907, 22263, 22283, 22284, 22281
33708, 21898, 21899, 21909, 21908, 22265, 22285, 22286, 22283
33709, 21899, 21900, 21910, 21909, 22267, 22287, 22288, 22285
33710, 21900, 21901, 21911, 21910, 22269, 22289, 22290, 22287
33711, 21901, 21902, 21912, 21911, 22271, 22291, 22292, 22289
33712, 21902, 21903, 21913, 21912, 22273, 22293, 22294, 22291
33713, 21903, 21904, 21914, 21913, 22275, 22295, 22296, 22293
33714, 21904, 21905, 21915, 21914, 22277, 22297, 22298, 22295
33715, 21905, 21906, 21916, 21915, 22279, 22299, 22300, 22297
33716, 21906, 1971, 1972, 21916, 22280, 1994, 22301, 22299
33717, 1921, 21907, 21917, 1922, 22282, 22302, 22303, 1944
33718, 21907, 21908, 21918, 21917, 22284, 22304, 22305, 22302
33719, 21908, 21909, 21919, 21918, 22286, 22306, 22307, 22304
33720, 21909, 21910, 21920, 21919, 22288, 22308, 22309, 22306
33721, 21910, 21911, 21921, 21920, 22290, 22310, 22311, 22308
33722, 21911, 21912, 21922, 21921, 22292, 22312, 22313, 22310
33723, 21912, 21913, 21923, 21922, 22294, 22314, 22315, 22312
33724, 21913, 21914, 21924, 21923, 22296, 22316, 22317, 22314
33725, 21914, 21915, 21925, 21924, 22298, 22318, 22319, 22316
33726, 21915, 21916, 21926, 21925, 22300, 22320, 22321, 22318
33727, 21916, 1972, 1973, 21926, 22301, 1995, 22322, 22320
33728, 1922, 21917, 21927, 1923, 22303, 22323, 22324, 1945
33729, 21917, 21918, 21928, 21927, 22305, 22325, 22326, 22323
33730, 21918, 21919, 21929, 21928, 22307, 22327, 22328, 22325
33731, 21919, 21920, 21930, 21929, 22309, 22329, 22330, 22327
33732, 21920, 21921, 21931, 21930, 22311, 22331, 22332, 22329
33733, 21921, 21922, 21932, 21931, 22313, 22333, 22334, 22331
33734, 21922, 21923, 21933, 21932, 22315, 22335, 22336, 22333
33735, 21923, 21924, 21934, 21933, 22317, 22337, 22338, 22335
33736, 21924, 21925, 21935, 21934, 22319, 22339, 22340, 22337
33737, 21925, 21926, 21936, 21935, 22321, 22341, 22342, 22339
33738, 21926, 1973, 1974, 21936, 22322, 1996, 22343, 22341
33739, 1923, 21927, 21937, 1924, 22324, 22344, 22345, 1946
33740, 21927, 21928, 21938, 21937, 22326, 22346, 22347, 22344
33741, 21928, 21929, 21939, 21938, 22328, 22348, 22349, 22346
33742, 21929, 21930, 21940, 21939, 22330, 22350, 22351, 22348
33743, 21930, 21931, 21941, 21940, 22332, 22352, 22353, 22350
33744, 21931, 21932, 21942, 21941, 22334, 22354, 22355, 22352
33745, 21932, 21933, 21943, 21942, 22336, 22356, 22357, 22354
33746, 21933, 21934, 21944, 21943, 22338, 22358, 22359, 22356
33747, 21934, 21935, 21945, 21944, 22340, 22360, 22361, 22358
33748, 21935, 21936, 21946, 21945, 22342, 22362, 22363, 22360
33749, 21936, 1974, 1975, 21946, 22343, 1997, 22364, 22362
33750, 1924, 21937, 21947, 1925, 22345, 22365, 22366, 1947
33751, 21937, 21938, 21948, 21947, 22347, 22367, 22368, 22365
33752, 21938, 21939, 21949, 21948, 22349, 22369, 22370, 22367
33753, 21939, 21940, 21950, 21949, 22351, 22371, 22372, 22369
33754, 21940, 21941, 21951, 21950, 22353, 22373, 22374, 22371
33755, 21941, 21942, 21952, 21951, 22355, 22375, 22376, 22373
33756, 21942, 21943, 21953, 21952, 22357, 22377, 22378, 22375
33757, 21943, 21944, 21954, 21953, 22359, 22379, 22380, 22377
33758, 21944, 21945, 21955, 21954, 22361, 22381, 22382, 22379
33759, 21945, 21946, 21956, 21955, 22363, 22383, 22384, 22381
33760, 21946, 1975, 1976, 21956, 22364, 1998, 22385, 22383
33761, 1925, 21947, 21957, 1926, 22366, 22386, 22387, 1948
33762, 21947, 21948, 21958, 21957, 22368, 22388, 22389, 22386
33763, 21948, 21949, 21959, 21958, 22370, 22390, 22391, 22388
33764, 21949, 21950, 21960, 21959, 22372, 22392, 22393, 22390
33765, 21950, 21951, 21961, 21960, 22374, 22394, 22395, 22392
33766, 21951, 21952, 21962, 21961, 22376, 22396, 22397, 22394
33767, 21952, 21953, 21963, 21962, 22378, 22398, 22399, 22396
33768, 21953, 21954, 21964, 21963, 22380, 22400, 22401, 22398
33769, 21954, 21955, 21965, 21964, 22382, 22402, 22403, 22400
33770, 21955, 21956, 21966, 21965, 22384, 22404, 22405, 22402
33771, 21956, 1976, 1977, 21966, 22385, 1999, 22406, 22404
33772, 1926, 21957, 21967, 1927, 22387, 22407, 22408, 1949
33773, 21957, 21958, 21968, 21967, 22389, 22409, 22410, 22407
33774, 21958, 21959, 21969, 21968, 22391, 22411, 22412, 22409
33775, 21959, 21960, 21970, 21969, 22393, 22413, 22414, 22411
33776, 21960, 21961, 21971, 21970, 22395, 22415, 22416, 22413
33777, 21961, 21962, 21972, 21971, 22397, 22417, 22418, 22415
33778, 21962, 21963, 21973, 21972, 22399, 22419, 22420, 22417
33779, 21963, 21964, 21974, 21973, 22401, 22421, 22422, 22419
33780, 21964, 21965, 21975, 21974, 22403, 22423, 22424, 22421
33781, 21965, 21966, 21976, 21975, 22405, 22425, 22426, 22423
33782, 21966, 1977, 1978, 21976, 22406, 2000, 22427, 22425
33783, 1927, 21967, 21977, 1928, 22408, 22428, 22429, 1950
33784, 21967, 21968, 21978, 21977, 22410, 22430, 22431, 22428
33785, 21968, 21969, 21979, 21978, 22412, 22432, 22433, 22430
33786, 21969, 21970, 21980, 21979, 22414, 22434, 22435, 22432
33787, 21970, 21971, 21981, 21980, 22416, 22436, 22437, 22434
33788, 21971, 21972, 21982, 21981, 22418, 22438, 22439, 22436
33789, 21972, 21973, 21983, 21982, 22420, 22440, 22441, 22438
33790, 21973, 21974, 21984, 21983, 22422, 22442, 22443, 22440
33791, 21974, 21975, 21985, 21984, 22424, 22444, 22445, 22442
33792, 21975, 21976, 21986, 21985, 22426, 22446, 22447, 22444
33793, 21976, 1978, 1979, 21986, 22427, 2001, 22448, 22446
33794, 1928, 21977, 2033, 42, 22429, 22449, 2044, 1951
33795, 21977, 21978, 2032, 2033, 22431, 22450, 2043, 22449
33796, 21978, 21979, 2031, 2032, 22433, 22451, 2042, 22450
33797, 21979, 21980, 2030, 2031, 22435, 22452, 2041, 22451
33798, 21980, 21981, 2029, 2030, 22437, 22453, 2040, 22452
33799, 21981, 21982, 2028, 2029, 22439, 22454, 2039, 22453
33800, 21982, 21983, 2027, 2028, 22441, 22455, 2038, 22454
33801, 21983, 21984, 2026, 2027, 22443, 22456, 2037, 22455
33802, 21984, 21985, 2025, 2026, 22445, 22457, 2036, 22456
33803, 21985, 21986, 2024, 2025, 22447, 22458, 2035, 22457
33804, 21986, 1979, 44, 2024, 22448, 2002, 2034, 22458
*ELEMENT, type=CPS8, ELSET=Surface55
33805, 42, 2045, 22459, 2033, 2047, 22479, 22480, 2044
33806, 2033, 22459, 22460, 2032, 22480, 22481, 22482, 2043
33807, 2032, 22460, 22461, 2031, 22482, 22483, 22484, 2042
33808, 2031, 22461, 22462, 2030, 22484, 22485, 22486, 2041
33809, 2030, 22462, 22463, 2029, 22486, 22487, 22488, 2040
33810, 2029, 22463, 22464, 2028, 22488, 22489, 22490, 2039
33811, 2028, 22464, 22465, 2027, 22490, 22491, 22492, 2038
33812, 2027, 22465, 22466, 2026, 22492, 22493, 22494, 2037
33813, 2026, 22466, 22467, 2025, 22494, 22495, 22496, 2036
33814, 2025, 22467, 22468, 2024, 22496, 22497, 22498, 2035
33815, 2024, 22468, 2050, 44, 22498, 22499, 2052, 2034
33816, 2045, 2046, 22469, 22459, 2048, 22500, 22501, 22479
33817, 22459, 22469, 22470, 22460, 22501, 22502, 22503, 22481
33818, 22460, 22470, 22471, 22461, 22503, 22504, 22505, 22483
33819, 22461, 22471, 22472, 22462, 22505, 22506, 22507, 22485
33820, 22462, 22472, 22473, 22463, 22507, 22508, 22509, 22487
33821, 22463, 22473, 22474, 22464, 22509, 22510, 22511, 22489
33822, 22464, 22474, 22475, 22465, 22511, 22512, 22513, 22491
33823, 22465, 22475, 22476, 22466, 22513, 22514, 22515, 22493
33824, 22466, 22476, 22477, 22467, 22515, 22516, 22517, 22495
33825, 22467, 22477, 22478, 22468, 22517, 22518, 22519, 22497
33826, 22468, 22478, 2051, 2050, 22519, 22520, 2053, 22499
33827, 2046, 45, 2064, 22469, 2049, 2075, 22521, 22500
33828, 22469, 2064, 2063, 22470, 22521, 2074, 22522, 22502
33829, 22470, 2063, 2062, 22471, 22522, 2073, 22523, 22504
33830, 22471, 2062, 2061, 22472, 22523, 2072, 22524, 22506
33831, 22472, 2061, 2060, 22473, 22524, 2071, 22525, 22508
33832, 22473, 2060, 2059, 22474, 22525, 2070, 22526, 22510
33833, 22474, 2059, 2058, 22475, 22526, 2069, 22527, 22512
33834, 22475, 2058, 2057, 22476, 22527, 2068, 22528, 22514
33835, 22476, 2057, 2056, 22477, 22528, 2067, 22529, 22516
33836, 22477, 2056, 2055, 22478, 22529, 2066, 22530, 22518
33837, 22478, 2055, 46, 2051, 22530, 2065, 2054, 22520
*ELEMENT, type=CPS8, ELSET=Surface57
2279, 42, 2045, 22531, 2076, 2047, 22535, 22536, 2078
2280, 2045, 2046, 22532, 22531, 2048, 22537, 22538, 22535
2281, 2046, 45, 2081, 22532, 2049, 2083, 22539, 22537
2282, 2076, 22531, 22533, 2077, 22536, 22540, 22541, 2079
2283, 22531, 22532, 22534, 22533, 22538, 22542, 22543, 22540
2284, 22532, 2081, 2082, 22534, 22539, 2084, 22544, 22542
2285, 2077, 22533, 2086, 47, 22541, 22545, 2088, 2080
2286, 22533, 22534, 2087, 2086, 22543, 22546, 2089, 22545
2287, 22534, 2082, 48, 2087, 22544, 2085, 2090, 22546
*ELEMENT, type=CPS8, ELSET=Surface58
33838, 44, 2091, 22547, 2050, 2093, 22551, 22552, 2052
33839, 2050, 22547, 22548, 2051, 22552, 22553, 22554, 2053
33840, 2051, 22548, 2096, 46, 22554, 22555, 2098, 2054
33841, 2091, 2092, 22549, 22547, 2094, 22556, 22557, 22551
33842, 22547, 22549, 22550, 22548, 22557, 22558, 22559, 22553
33843, 22548, 22550, 2097, 2096, 22559, 22560, 2099, 22555
33844, 2092, 49, 2101, 22549, 2095, 2103, 22561, 22556
33845, 22549, 2101, 2102, 22550, 22561, 2104, 22562, 22558
33846, 22550, 2102, 50, 2097, 22562, 2105, 2100, 22560
*ELEMENT, type=CPS8, ELSET=Surface59
33847, 42, 2076, 22563, 2033, 2078, 22583, 22584, 2044
33848, 2033, 22563, 22564, 2032, 22584, 22585, 22586, 2043
33849, 2032, 22564, 22565, 2031, 22586, 22587, 22588, 2042
33850, 2031, 22565, 22566, 2030, 22588, 22589, 22590, 2041
33851, 2030, 22566, 22567, 2029, 22590, 22591, 22592, 2040
33852, 2029, 22567, 22568, 2028, 22592, 22593, 22594, 2039
33853, 2028, 22568, 22569, 2027, 22594, 22595, 22596, 2038
33854, 2027, 22569, 22570, 2026, 22596, 22597, 22598, 2037
33855, 2026, 22570, 22571, 2025, 22598, 22599, 22600, 2036
33856, 2025, 22571, 22572, 2024, 22600, 22601, 22602, 2035
33857, 2024, 22572, 2091, 44, 22602, 22603, 2093, 2034
33858, 2076, 2077, 22573, 22563, 2079, 22604, 22605, 22583
33859, 22563, 22573, 22574, 22564, 22605, 22606, 22607, 22585
33860, 22564, 22574, 22575, 22565, 22607, 22608, 22609, 22587
33861, 22565, 22575, 22576, 22566, 22609, 22610, 22611, 22589
33862, 22566, 22576, 22577, 22567, 22611, 22612, 22613, 22591
33863, 22567, 22577, 22578, 22568, 22613, 22614, 22615, 22593
33864, 22568, 22578, 22579, 22569, 22615, 22616, 22617, 22595
33865, 22569, 22579, 22580, 22570, 22617, 22618, 22619, 22597
33866, 22570, 22580, 22581, 22571, 22619, 22620, 22621, 22599
33867, 22571, 22581, 22582, 22572, 22621, 22622, 22623, 22601
33868, 22572, 22582, 2092, 2091, 22623, 22624, 2094, 22603
33869, 2077, 47, 2115, 22573, 2080, 2126, 22625, 22604
33870, 22573, 2115, 2114, 22574, 22625, 2125, 22626, 22606
33871, 22574, 2114, 2113, 22575, 22626, 2124, 22627, 22608
33872, 22575, 2113, 2112, 22576, 22627, 2123, 22628, 22610
33873, 22576, 2112, 2111, 22577, 22628, 2122, 22629, 22612
33874, 22577, 2111, 2110, 22578, 22629, 2121, 22630, 22614
33875, 22578, 2110, 2109, 22579, 22630, 2120, 22631, 22616
33876, 22579, 2109, 2108, 22580, 22631, 2119, 22632, 22618
33877, 22580, 2108, 2107, 22581, 22632, 2118, 22633, 22620
33878, 22581, 2107, 2106, 22582, 22633, 2117, 22634, 22622
33879, 22582, 2106, 49, 2092, 22634, 2116, 2095, 22624
*ELEMENT, type=CPS8, ELSET=Surface60
2288, 45, 2064, 22635, 2081, 2075, 22655, 22656, 2083
2289, 2064, 2063, 22636, 22635, 2074, 22657, 22658, 22655
2290, 2063, 2062, 22637, 22636, 2073, 22659, 22660, 22657
2291, 2062, 2061, 22638, 22637, 2072, 22661, 22662, 22659
2292, 2061, 2060, 22639, 22638, 2071, 22663, 22664, 22661
2293, 2060, 2059, 22640, 22639, 2070, 22665, 22666, 22663
2294, 2059, 2058, 22641, 22640, 2069, 22667, 22668, 22665
2295, 2058, 2057, 22642, 22641, 2068, 22669, 22670, 22667
2296, 2057, 2056, 22643, 22642, 2067, 22671, 22672, 22669
2297, 2056, 2055, 22644, 22643, 2066, 22673, 22674, 22671
2298, 2055, 46, 2096, 22644, 2065, 2098, 22675, 22673
2299, 2081, 22635, 22645, 2082, 22656, 22676, 22677, 2084
2300, 22635, 22636, 22646, 22645, 22658, 22678, 22679, 22676
2301, 22636, 22637, 22647, 22646, 22660, 22680, 22681, 22678
2302, 22637, 22638, 22648, 22647, 22662, 22682, 22683, 22680
2303, 22638, 22639, 22649, 22648, 22664, 22684, 22685, 22682
2304, 22639, 22640, 22650, 22649, 22666, 22686, 22687, 22684
2305, 22640, 22641, 22651, 22650, 22668, 22688, 22689, 22686
2306, 22641, 22642, 22652, 22651, 22670, 22690, 22691, 22688
2307, 22642, 22643, 22653, 22652, 22672, 22692, 22693, 22690
2308, 22643, 22644, 22654, 22653, 22674, 22694, 22695, 22692
2309, 22644, 2096, 2097, 22654, 22675, 2099, 22696, 22694
2310, 2082, 22645, 2136, 48, 22677, 22697, 2147, 2085
2311, 22645, 22646, 2135, 2136, 22679, 22698, 2146, 22697
2312, 22646, 22647, 2134, 2135, 22681, 22699, 2145, 22698
2313, 22647, 22648, 2133, 2134, 22683, 22700, 2144, 22699
2314, 22648, 22649, 2132, 2133, 22685, 22701, 2143, 22700
2315, 22649, 22650, 2131, 2132, 22687, 22702, 2142, 22701
2316, 22650, 22651, 2130, 2131, 22689, 22703, 2141, 22702
2317, 22651, 22652, 2129, 2130, 22691, 22704, 2140, 22703
2318, 22652, 22653, 2128, 2129, 22693, 22705, 2139, 22704
2319, 22653, 22654, 2127, 2128, 22695, 22706, 2138, 22705
2320, 22654, 2097, 50, 2127, 22696, 2100, 2137, 22706
*ELEMENT, type=CPS8, ELSET=Surface61
2321, 47, 2086, 22707, 2115, 2088, 22727, 22728, 2126
2322, 2115, 22707, 22708, 2114, 22728, 22729, 22730, 2125
2323, 2114, 22708, 22709, 2113, 22730, 22731, 22732, 2124
2324, 2113, 22709, 22710, 2112, 22732, 22733, 22734, 2123
2325, 2112, 22710, 22711, 2111, 22734, 22735, 22736, 2122
2326, 2111, 22711, 22712, 2110, 22736, 22737, 22738, 2121
2327, 2110, 22712, 22713, 2109, 22738, 22739, 22740, 2120
2328, 2109, 22713, 22714, 2108, 22740, 22741, 22742, 2119
2329, 2108, 22714, 22715, 2107, 22742, 22743, 22744, 2118
2330, 2107, 22715, 22716, 2106, 22744, 22745, 22746, 2117
2331, 2106, 22716, 2101, 49, 22746, 22747, 2103, 2116
2332, 2086, 2087, 22717, 22707, 2089, 22748, 22749, 22727
2333, 22707, 22717, 22718, 22708, 22749, 22750, 22751, 22729
2334, 22708, 22718, 22719, 22709, 22751, 22752, 22753, 22731
2335, 22709, 22719, 22720, 22710, 22753, 22754, 22755, 22733
2336, 22710, 22720, 22721, 22711, 22755, 22756, 22757, 22735
2337, 22711, 22721, 22722, 22712, 22757, 22758, 22759, 22737
2338, 22712, 22722, 22723, 22713, 22759, 22760, 22761, 22739
2339, 22713, 22723, 22724, 22714, 22761, 22762, 22763, 22741
2340, 22714, 22724, 22725, 22715, 22763, 22764, 22765, 22743
2341, 22715, 22725, 22726, 22716, 22765, 22766, 22767, 22745
2342, 22716, 22726, 2102, 2101, 22767, 22768, 2104, 22747
2343, 2087, 48, 2136, 22717, 2090, 2147, 22769, 22748
2344, 22717, 2136, 2135, 22718, 22769, 2146, 22770, 22750
2345, 22718, 2135, 2134, 22719, 22770, 2145, 22771, 22752
2346, 22719, 2134, 2133, 22720, 22771, 2144, 22772, 22754
2347, 22720, 2133, 2132, 22721, 22772, 2143, 22773, 22756
2348, 22721, 2132, 2131, 22722, 22773, 2142, 22774, 22758
2349, 22722, 2131, 2130, 22723, 22774, 2141, 22775, 22760
2350, 22723, 2130, 2129, 22724, 22775, 2140, 22776, 22762
2351, 22724, 2129, 2128, 22725, 22776, 2139, 22777, 22764
2352, 22725, 2128, 2127, 22726, 22777, 2138, 22778, 22766
2353, 22726, 2127, 50, 2102, 22778, 2137, 2105, 22768
*ELEMENT, type=CPS8, ELSET=Surface62
2354, 1, 2148, 22779, 98, 2150, 22799, 22800, 109
2355, 98, 22779, 22780, 97, 22800, 22801, 22802, 108
2356, 97, 22780, 22781, 96, 22802, 22803, 22804, 107
2357, 96, 22781, 22782, 95, 22804, 22805, 22806, 106
2358, 95, 22782, 22783, 94, 22806, 22807, 22808, 105
2359, 94, 22783, 22784, 93, 22808, 22809, 22810, 104
2360, 93, 22784, 22785, 92, 22810, 22811, 22812, 103
2361, 92, 22785, 22786, 91, 22812, 22813, 22814, 102
2362, 91, 22786, 22787, 90, 22814, 22815, 22816, 101
2363, 90, 22787, 22788, 89, 22816, 22817, 22818, 100
2364, 89, 22788, 2153, 2, 22818, 22819, 2155, 99
2365, 2148, 2149, 22789, 22779, 2151, 22820, 22821, 22799
2366, 22779, 22789, 22790, 22780, 22821, 22822, 22823, 22801
2367, 22780, 22790, 22791, 22781, 22823, 22824, 22825, 22803
2368, 22781, 22791, 22792, 22782, 22825, 22826, 22827, 22805
2369, 22782, 22792, 22793, 22783, 22827, 22828, 22829, 22807
2370, 22783, 22793, 22794, 22784, 22829, 22830, 22831, 22809
2371, 22784, 22794, 22795, 22785, 22831, 22832, 22833, 22811
2372, 22785, 22795, 22796, 22786, 22833, 22834, 22835, 22813
2373, 22786, 22796, 22797, 22787, 22835, 22836, 22837, 22815
2374, 22787, 22797, 22798, 22788, 22837, 22838, 22839, 22817
2375, 22788, 22798, 2154, 2153, 22839, 22840, 2156, 22819
2376, 2149, 51, 2167, 22789, 2152, 2178, 22841, 22820
2377, 22789, 2167, 2166, 22790, 22841, 2177, 22842, 22822
2378, 22790, 2166, 2165, 22791, 22842, 2176, 22843, 22824
2379, 22791, 2165, 2164, 22792, 22843, 2175, 22844, 22826
2380, 22792, 2164, 2163, 22793, 22844, 2174, 22845, 22828
2381, 22793, 2163, 2162, 22794, 22845, 2173, 22846, 22830
2382, 22794, 2162, 2161, 22795, 22846, 2172, 22847, 22832
2383, 22795, 2161, 2160, 22796, 22847, 2171, 22848, 22834
2384, 22796, 2160, 2159, 22797, 22848, 2170, 22849, 22836
2385, 22797, 2159, 2158, 22798, 22849, 2169, 22850, 22838
2386, 22798, 2158, 52, 2154, 22850, 2168, 2157, 22840
*ELEMENT, type=CPS8, ELSET=Surface63
2387, 3, 2179, 22851, 111, 2181, 22855, 22856, 114
2388, 111, 22851, 22852, 110, 22856, 22857, 22858, 113
2389, 110, 22852, 2148, 1, 22858, 22859, 2150, 112
2390, 2179, 2180, 22853, 22851, 2182, 22860, 22861, 22855
2391, 22851, 22853, 22854, 22852, 22861, 22862, 22863, 22857
2392, 22852, 22854, 2149, 2148, 22863, 22864, 2151, 22859
2393, 2180, 53, 2185, 22853, 2183, 2188, 22865, 22860
2394, 22853, 2185, 2184, 22854, 22865, 2187, 22866, 22862
2395, 22854, 2184, 51, 2149, 22866, 2186, 2152, 22864
*ELEMENT, type=CPS8, ELSET=Surface64
33880, 3, 124, 22867, 2179, 135, 22887, 22888, 2181
33881, 124, 123, 22868, 22867, 134, 22889, 22890, 22887
33882, 123, 122, 22869, 22868, 133, 22891, 22892, 22889
33883, 122, 121, 22870, 22869, 132, 22893, 22894, 22891
33884, 121, 120, 22871, 22870, 131, 22895, 22896, 22893
33885, 120, 119, 22872, 22871, 130, 22897, 22898, 22895
33886, 119, 118, 22873, 22872, 129, 22899, 22900, 22897
33887, 118, 117, 22874, 22873, 128, 22901, 22902, 22899
33888, 117, 116, 22875, 22874, 127, 22903, 22904, 22901
33889, 116, 115, 22876, 22875, 126, 22905, 22906, 22903
33890, 115, 4, 2189, 22876, 125, 2191, 22907, 22905
33891, 2179, 22867, 22877, 2180, 22888, 22908, 22909, 2182
33892, 22867, 22868, 22878, 22877, 22890, 22910, 22911, 22908
33893, 22868, 22869, 22879, 22878, 22892, 22912, 22913, 22910
33894, 22869, 22870, 22880, 22879, 22894, 22914, 22915, 22912
33895, 22870, 22871, 22881, 22880, 22896, 22916, 22917, 22914
33896, 22871, 22872, 22882, 22881, 22898, 22918, 22919, 22916
33897, 22872, 22873, 22883, 22882, 22900, 22920, 22921, 22918
33898, 22873, 22874, 22884, 22883, 22902, 22922, 22923, 22920
33899, 22874, 22875, 22885, 22884, 22904, 22924, 22925, 22922
33900, 22875, 22876, 22886, 22885, 22906, 22926, 22927, 22924
33901, 22876, 2189, 2190, 22886, 22907, 2192, 22928, 22926
33902, 2180, 22877, 2203, 53, 22909, 22929, 2214, 2183
33903, 22877, 22878, 2202, 2203, 22911, 22930, 2213, 22929
33904, 22878, 22879, 2201, 2202, 22913, 22931, 2212, 22930
33905, 22879, 22880, 2200, 2201, 22915, 22932, 2211, 22931
33906, 22880, 22881, 2199, 2200, 22917, 22933, 2210, 22932
33907, 22881, 22882, 2198, 2199, 22919, 22934, 2209, 22933
33908, 22882, 22883, 2197, 2198, 22921, 22935, 2208, 22934
33909, 22883, 22884, 2196, 2197, 22923, 22936, 2207, 22935
33910, 22884, 22885, 2195, 2196, 22925, 22937, 2206, 22936
33911, 22885, 22886, 2194, 2195, 22927, 22938, 2205, 22937
33912, 22886, 2190, 54, 2194, 22928, 2193, 2204, 22938
*ELEMENT, type=CPS8, ELSET=Surface65
33913, 4, 137, 22939, 2189, 140, 22943, 22944, 2191
33914, 137, 136, 22940, 22939, 139, 22945, 22946, 22943
33915, 136, 2, 2153, 22940, 138, 2155, 22947, 22945
33916, 2189, 22939, 22941, 2190, 22944, 22948, 22949, 2192
33917, 22939, 22940, 22942, 22941, 22946, 22950, 22951, 22948
33918, 22940, 2153, 2154, 22942, 22947, 2156, 22952, 22950
33919, 2190, 22941, 2216, 54, 22949, 22953, 2219, 2193
33920, 22941, 22942, 2215, 2216, 22951, 22954, 2218, 22953
33921, 22942, 2154, 52, 2215, 22952, 2157, 2217, 22954
*ELEMENT, type=CPS8, ELSET=Surface66
2396, 52, 2158, 22955, 2215, 2168, 22975, 22976, 2217
2397, 2215, 22955, 22956, 2216, 22976, 22977, 22978, 2218
2398, 2216, 22956, 2194, 54, 22978, 22979, 2204, 2219
2399, 2158, 2159, 22957, 22955, 2169, 22980, 22981, 22975
2400, 22955, 22957, 22958, 22956, 22981, 22982, 22983, 22977
2401, 22956, 22958, 2195, 2194, 22983, 22984, 2205, 22979
2402, 2159, 2160, 22959, 22957, 2170, 22985, 22986, 22980
2403, 22957, 22959, 22960, 22958, 22986, 22987, 22988, 22982
2404, 22958, 22960, 2196, 2195, 22988, 22989, 2206, 22984
2405, 2160, 2161, 22961, 22959, 2171, 22990, 22991, 22985
2406, 22959, 22961, 22962, 22960, 22991, 22992, 22993, 22987
2407, 22960, 22962, 2197, 2196, 22993, 22994, 2207, 22989
2408, 2161, 2162, 22963, 22961, 2172, 22995, 22996, 22990
2409, 22961, 22963, 22964, 22962, 22996, 22997, 22998, 22992
2410, 22962, 22964, 2198, 2197, 22998, 22999, 2208, 22994
2411, 2162, 2163, 22965, 22963, 2173, 23000, 23001, 22995
2412, 22963, 22965, 22966, 22964, 23001, 23002, 23003, 22997
2413, 22964, 22966, 2199, 2198, 23003, 23004, 2209, 22999
2414, 2163, 2164, 22967, 22965, 2174, 23005, 23006, 23000
2415, 22965, 22967, 22968, 22966, 23006, 23007, 23008, 23002
2416, 22966, 22968, 2200, 2199, 23008, 23009, 2210, 23004
2417, 2164, 2165, 22969, 22967, 2175, 23010, 23011, 23005
2418, 22967, 22969, 22970, 22968, 23011, 23012, 23013, 23007
2419, 22968, 22970, 2201, 2200, 23013, 23014, 2211, 23009
2420, 2165, 2166, 22971, 22969, 2176, 23015, 23016, 23010
2421, 22969, 22971, 22972, 22970, 23016, 23017, 23018, 23012
2422, 22970, 22972, 2202, 2201, 23018, 23019, 2212, 23014
2423, 2166, 2167, 22973, 22971, 2177, 23020, 23021, 23015
2424, 22971, 22973, 22974, 22972, 23021, 23022, 23023, 23017
2425, 22972, 22974, 2203, 2202, 23023, 23024, 2213, 23019
2426, 2167, 51, 2184, 22973, 2178, 2186, 23025, 23020
2427, 22973, 2184, 2185, 22974, 23025, 2187, 23026, 23022
2428, 22974, 2185, 53, 2203, 23026, 2188, 2214, 23024
*ELEMENT, type=CPS8, ELSET=Surface105
33922, 21, 1004, 23027, 2220, 1027, 23093, 23094, 2223
33923, 1004, 1003, 23028, 23027, 1026, 23095, 23096, 23093
33924, 1003, 1002, 23029, 23028, 1025, 23097, 23098, 23095
33925, 1002, 1001, 23030, 23029, 1024, 23099, 23100, 23097
33926, 1001, 1000, 23031, 23030, 1023, 23101, 23102, 23099
33927, 1000, 999, 23032, 23031, 1022, 23103, 23104, 23101
33928, 999, 998, 23033, 23032, 1021, 23105, 23106, 23103
33929, 998, 997, 23034, 23033, 1020, 23107, 23108, 23105
33930, 997, 996, 23035, 23034, 1019, 23109, 23110, 23107
33931, 996, 995, 23036, 23035, 1018, 23111, 23112, 23109
33932, 995, 994, 23037, 23036, 1017, 23113, 23114, 23111
33933, 994, 993, 23038, 23037, 1016, 23115, 23116, 23113
33934, 993, 992, 23039, 23038, 1015, 23117, 23118, 23115
33935, 992, 991, 23040, 23039, 1014, 23119, 23120, 23117
33936, 991, 990, 23041, 23040, 1013, 23121, 23122, 23119
33937, 990, 989, 23042, 23041, 1012, 23123, 23124, 23121
33938, 989, 988, 23043, 23042, 1011, 23125, 23126, 23123
33939, 988, 987, 23044, 23043, 1010, 23127, 23128, 23125
33940, 987, 986, 23045, 23044, 1009, 23129, 23130, 23127
33941, 986, 985, 23046, 23045, 1008, 23131, 23132, 23129
33942, 985, 984, 23047, 23046, 1007, 23133, 23134, 23131
33943, 984, 983, 23048, 23047, 1006, 23135, 23136, 23133
33944, 983, 22, 2227, 23048, 1005, 2230, 23137, 23135
33945, 2220, 23027, 23049, 2221, 23094, 23138, 23139, 2224
33946, 23027, 23028, 23050, 23049, 23096, 23140, 23141, 23138
33947, 23028, 23029, 23051, 23050, 23098, 23142, 23143, 23140
33948, 23029, 23030, 23052, 23051, 23100, 23144, 23145, 23142
33949, 23030, 23031, 23053, 23052, 23102, 23146, 23147, 23144
33950, 23031, 23032, 23054, 23053, 23104, 23148, 23149, 23146
33951, 23032, 23033, 23055, 23054, 23106, 23150, 23151, 23148
33952, 23033, 23034, 23056, 23055, 23108, 23152, 23153, 23150
33953, 23034, 23035, 23057, 23056, 23110, 23154, 23155, 23152
33954, 23035, 23036, 23058, 23057, 23112, 23156, 23157, 23154
33955, 23036, 23037, 23059, 23058, 23114, 23158, 23159, 23156
33956, 23037, 23038, 23060, 23059, 23116, 23160, 23161, 23158
33957, 23038, 23039, 23061, 23060, 23118, 23162, 23163, 23160
33958, 23039, 23040, 23062, 23061, 23120, 23164, 23165, 23162
33959, 23040, 23041, 23063, 23062, 23122, 23166, 23167, 23164
33960, 23041, 23042, 23064, 23063, 23124, 23168, 23169, 23166
33961, 23042, 23043, 23065, 23064, 23126, 23170, 23171, 23168
33962, 23043, 23044, 23066, 23065, 23128, 23172, 23173, 23170
33963, 23044, 23045, 23067, 23066, 23130, 23174, 23175, 23172
33964, 23045, 23046, 23068, 23067, 23132, 23176, 23177, 23174
33965, 23046, 23047, 23069, 23068, 23134, 23178, 23179, 23176
33966, 23047, 23048, 23070, 23069, 23136, 23180, 23181, 23178
33967, 23048, 2227, 2228, 23070, 23137, 2231, 23182, 23180
33968, 2221, 23049, 23071, 2222, 23139, 23183, 23184, 2225
33969, 23049, 23050, 23072, 23071, 23141, 23185, 23186, 23183
33970, 23050, 23051, 23073, 23072, 23143, 23187, 23188, 23185
33971, 23051, 23052, 23074, 23073, 23145, 23189, 23190, 23187
33972, 23052, 23053, 23075, 23074, 23147, 23191, 23192, 23189
33973, 23053, 23054, 23076, 23075, 23149, 23193, 23194, 23191
33974, 23054, 23055, 23077, 23076, 23151, 23195, 23196, 23193
33975, 23055, 23056, 23078, 23077, 23153, 23197, 23198, 23195
33976, 23056, 23057, 23079, 23078, 23155, 23199, 23200, 23197
33977, 23057, 23058, 23080, 23079, 23157, 23201, 23202, 23199
33978, 23058, 23059, 23081, 23080, 23159, 23203, 23204, 23201
33979, 23059, 23060, 23082, 23081, 23161, 23205, 23206, 23203
33980, 23060, 23061, 23083, 23082, 23163, 23207, 23208, 23205
33981, 23061, 23062, 23084, 23083, 23165, 23209, 23210, 23207
33982, 23062, 23063, 23085, 23084, 23167, 23211, 23212, 23209
33983, 23063, 23064, 23086, 23085, 23169, 23213, 23214, 23211
