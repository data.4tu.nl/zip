*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem.inp
*NODE
1, 1, 0.1, 0
2, 0, 0.1, 0
3, 1, 0.1, 1
4, 0, 0.1, 1
5, 1, 0.9, 0
6, 0, 0.9, 0
7, 1, 0.9, 1
8, 0, 0.9, 1
9, 1.2, 0.9, 0
10, 2.2, 0.9, 0
11, 1.2, 0.9, 1
12, 2.2, 0.9, 1
13, 1.2, 0.1, 0
14, 2.2, 0.1, 0
15, 1.2, 0.1, 1
16, 2.2, 0.1, 1
17, 0, 0, 0
18, 1, 0, 0
19, 0, 0, 1
20, 1, 0, 1
21, -0.1, 0, 0
22, -0.1, 0, 1
23, 0, -0.2, 1
24, -0.1, -0.2, 1
25, 0, -0.2, 0
26, -0.1, -0.2, 0
27, 1, -0.2, 1
28, 1, -0.2, 0
29, 0, 1, 0
30, 1, 1, 0
31, 0, 1, 1
32, 1, 1, 1
33, 0, 1.2, 0
34, 1, 1.2, 0
35, 0, 1.2, 1
36, 1, 1.2, 1
37, 1.2, 1.2, 0
38, 1.2, 1, 0
39, 1.2, 1.2, 1
40, 1.2, 1, 1
41, 2.2, 1, 0
42, 2.2, 1, 1
43, 2.2, 1.2, 0
44, 2.2, 1.2, 1
45, 2.2, 9.251858538543e-18, 0
46, 1.2, 9.251858538543e-18, 0
47, 2.2, 9.251858538543e-18, 1
48, 1.2, 9.251858538543e-18, 1
49, 2.2, -0.2, 0
50, 1.2, -0.2, 0
51, 2.2, -0.2, 1
52, 1.2, -0.2, 1
53, 2.3, 9.251858538543e-18, 0
54, 2.3, -0.2, 0
55, 2.3, 9.251858538543e-18, 1
56, 2.3, -0.2, 1
57, 1, 0.5, 0
58, 0, 0.5, 0
59, 1, 0.5, 1
60, 0, 0.5, 1
61, 1.2, 0.5, 0
62, 2.2, 0.5, 0
63, 1.2, 0.5, 1
64, 2.2, 0.5, 1
65, 0, -0.1, 1
66, -0.1, -0.1, 1
67, 0, -0.1, 0
68, -0.1, -0.1, 0
69, 1, -0.1, 1
70, 1, -0.1, 0
71, 0, 1.1, 0
72, 1, 1.1, 0
73, 0, 1.1, 1
74, 1, 1.1, 1
75, 1.2, 1.1, 0
76, 1.2, 1.1, 1
77, 2.2, 1.1, 0
78, 2.2, 1.1, 1
79, 2.2, -0.1, 0
80, 1.2, -0.1, 0
81, 2.2, -0.1, 1
82, 1.2, -0.1, 1
83, 2.3, -0.1, 0
84, 2.3, -0.1, 1
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line67
57, 1, 2
*ELEMENT, type=T3D2, ELSET=Line70
58, 3, 4
*ELEMENT, type=T3D2, ELSET=Line71
59, 1, 3
*ELEMENT, type=T3D2, ELSET=Line72
60, 2, 4
*ELEMENT, type=T3D2, ELSET=Line73
61, 1, 57
62, 57, 5
*ELEMENT, type=T3D2, ELSET=Line74
63, 2, 58
64, 58, 6
*ELEMENT, type=T3D2, ELSET=Line75
65, 5, 6
*ELEMENT, type=T3D2, ELSET=Line76
66, 3, 59
67, 59, 7
*ELEMENT, type=T3D2, ELSET=Line77
68, 4, 60
69, 60, 8
*ELEMENT, type=T3D2, ELSET=Line78
70, 7, 8
*ELEMENT, type=T3D2, ELSET=Line79
71, 5, 7
*ELEMENT, type=T3D2, ELSET=Line80
72, 6, 8
*ELEMENT, type=T3D2, ELSET=Line115
73, 9, 10
*ELEMENT, type=T3D2, ELSET=Line118
74, 11, 12
*ELEMENT, type=T3D2, ELSET=Line119
75, 9, 11
*ELEMENT, type=T3D2, ELSET=Line120
76, 10, 12
*ELEMENT, type=T3D2, ELSET=Line121
77, 9, 61
78, 61, 13
*ELEMENT, type=T3D2, ELSET=Line122
79, 10, 62
80, 62, 14
*ELEMENT, type=T3D2, ELSET=Line123
81, 13, 14
*ELEMENT, type=T3D2, ELSET=Line124
82, 11, 63
83, 63, 15
*ELEMENT, type=T3D2, ELSET=Line125
84, 12, 64
85, 64, 16
*ELEMENT, type=T3D2, ELSET=Line126
86, 15, 16
*ELEMENT, type=T3D2, ELSET=Line127
87, 13, 15
*ELEMENT, type=T3D2, ELSET=Line128
88, 14, 16
*ELEMENT, type=T3D2, ELSET=Line129
89, 17, 2
*ELEMENT, type=T3D2, ELSET=Line130
90, 18, 1
*ELEMENT, type=T3D2, ELSET=Line131
91, 18, 17
*ELEMENT, type=T3D2, ELSET=Line132
92, 19, 4
*ELEMENT, type=T3D2, ELSET=Line133
93, 20, 3
*ELEMENT, type=T3D2, ELSET=Line134
94, 20, 19
*ELEMENT, type=T3D2, ELSET=Line135
95, 18, 20
*ELEMENT, type=T3D2, ELSET=Line136
96, 17, 19
*ELEMENT, type=T3D2, ELSET=Line137
97, 21, 22
*ELEMENT, type=T3D2, ELSET=Line138
98, 22, 19
*ELEMENT, type=T3D2, ELSET=Line139
99, 21, 17
*ELEMENT, type=T3D2, ELSET=Line140
100, 19, 65
101, 65, 23
*ELEMENT, type=T3D2, ELSET=Line141
102, 23, 24
*ELEMENT, type=T3D2, ELSET=Line142
103, 24, 66
104, 66, 22
*ELEMENT, type=T3D2, ELSET=Line143
105, 25, 26
*ELEMENT, type=T3D2, ELSET=Line144
106, 26, 24
*ELEMENT, type=T3D2, ELSET=Line145
107, 25, 23
*ELEMENT, type=T3D2, ELSET=Line146
108, 17, 67
109, 67, 25
*ELEMENT, type=T3D2, ELSET=Line147
110, 26, 68
111, 68, 21
*ELEMENT, type=T3D2, ELSET=Line148
112, 20, 69
113, 69, 27
*ELEMENT, type=T3D2, ELSET=Line149
114, 27, 23
*ELEMENT, type=T3D2, ELSET=Line150
115, 28, 25
*ELEMENT, type=T3D2, ELSET=Line151
116, 28, 27
*ELEMENT, type=T3D2, ELSET=Line152
117, 18, 70
118, 70, 28
*ELEMENT, type=T3D2, ELSET=Line153
119, 6, 29
*ELEMENT, type=T3D2, ELSET=Line154
120, 30, 29
*ELEMENT, type=T3D2, ELSET=Line155
121, 30, 5
*ELEMENT, type=T3D2, ELSET=Line156
122, 8, 31
*ELEMENT, type=T3D2, ELSET=Line157
123, 32, 31
*ELEMENT, type=T3D2, ELSET=Line158
124, 32, 7
*ELEMENT, type=T3D2, ELSET=Line159
125, 30, 32
*ELEMENT, type=T3D2, ELSET=Line160
126, 29, 31
*ELEMENT, type=T3D2, ELSET=Line161
127, 29, 71
128, 71, 33
*ELEMENT, type=T3D2, ELSET=Line162
129, 33, 34
*ELEMENT, type=T3D2, ELSET=Line163
130, 30, 72
131, 72, 34
*ELEMENT, type=T3D2, ELSET=Line164
132, 31, 73
133, 73, 35
*ELEMENT, type=T3D2, ELSET=Line165
134, 35, 36
*ELEMENT, type=T3D2, ELSET=Line166
135, 32, 74
136, 74, 36
*ELEMENT, type=T3D2, ELSET=Line167
137, 34, 36
*ELEMENT, type=T3D2, ELSET=Line168
138, 33, 35
*ELEMENT, type=T3D2, ELSET=Line169
139, 34, 37
*ELEMENT, type=T3D2, ELSET=Line170
140, 38, 75
141, 75, 37
*ELEMENT, type=T3D2, ELSET=Line171
142, 38, 30
*ELEMENT, type=T3D2, ELSET=Line172
143, 36, 39
*ELEMENT, type=T3D2, ELSET=Line173
144, 40, 76
145, 76, 39
*ELEMENT, type=T3D2, ELSET=Line174
146, 40, 32
*ELEMENT, type=T3D2, ELSET=Line175
147, 38, 40
*ELEMENT, type=T3D2, ELSET=Line176
148, 37, 39
*ELEMENT, type=T3D2, ELSET=Line177
149, 38, 41
*ELEMENT, type=T3D2, ELSET=Line178
150, 41, 10
*ELEMENT, type=T3D2, ELSET=Line179
151, 9, 38
*ELEMENT, type=T3D2, ELSET=Line180
152, 40, 42
*ELEMENT, type=T3D2, ELSET=Line181
153, 42, 12
*ELEMENT, type=T3D2, ELSET=Line182
154, 11, 40
*ELEMENT, type=T3D2, ELSET=Line183
155, 41, 42
*ELEMENT, type=T3D2, ELSET=Line184
156, 37, 43
*ELEMENT, type=T3D2, ELSET=Line185
157, 43, 77
158, 77, 41
*ELEMENT, type=T3D2, ELSET=Line186
159, 39, 44
*ELEMENT, type=T3D2, ELSET=Line187
160, 44, 78
161, 78, 42
*ELEMENT, type=T3D2, ELSET=Line188
162, 43, 44
*ELEMENT, type=T3D2, ELSET=Line189
163, 14, 45
*ELEMENT, type=T3D2, ELSET=Line190
164, 46, 45
*ELEMENT, type=T3D2, ELSET=Line191
165, 46, 13
*ELEMENT, type=T3D2, ELSET=Line192
166, 16, 47
*ELEMENT, type=T3D2, ELSET=Line193
167, 48, 47
*ELEMENT, type=T3D2, ELSET=Line194
168, 48, 15
*ELEMENT, type=T3D2, ELSET=Line195
169, 46, 48
*ELEMENT, type=T3D2, ELSET=Line196
170, 45, 47
*ELEMENT, type=T3D2, ELSET=Line197
171, 45, 79
172, 79, 49
*ELEMENT, type=T3D2, ELSET=Line198
173, 49, 50
*ELEMENT, type=T3D2, ELSET=Line199
174, 50, 80
175, 80, 46
*ELEMENT, type=T3D2, ELSET=Line200
176, 47, 81
177, 81, 51
*ELEMENT, type=T3D2, ELSET=Line201
178, 51, 52
*ELEMENT, type=T3D2, ELSET=Line202
179, 52, 82
180, 82, 48
*ELEMENT, type=T3D2, ELSET=Line203
181, 50, 52
*ELEMENT, type=T3D2, ELSET=Line204
182, 49, 51
*ELEMENT, type=T3D2, ELSET=Line205
183, 45, 53
*ELEMENT, type=T3D2, ELSET=Line206
184, 53, 83
185, 83, 54
*ELEMENT, type=T3D2, ELSET=Line207
186, 54, 49
*ELEMENT, type=T3D2, ELSET=Line208
187, 47, 55
*ELEMENT, type=T3D2, ELSET=Line209
188, 55, 84
189, 84, 56
*ELEMENT, type=T3D2, ELSET=Line210
190, 56, 51
*ELEMENT, type=T3D2, ELSET=Line211
191, 53, 55
*ELEMENT, type=T3D2, ELSET=Line212
192, 54, 56
*ELEMENT, type=CPS4, ELSET=Surface33
193, 1, 2, 4, 3
*ELEMENT, type=CPS4, ELSET=Surface34
194, 1, 2, 58, 57
195, 57, 58, 6, 5
*ELEMENT, type=CPS4, ELSET=Surface35
196, 3, 59, 60, 4
197, 59, 7, 8, 60
*ELEMENT, type=CPS4, ELSET=Surface36
198, 1, 57, 59, 3
199, 57, 5, 7, 59
*ELEMENT, type=CPS4, ELSET=Surface37
200, 2, 4, 60, 58
201, 58, 60, 8, 6
*ELEMENT, type=CPS4, ELSET=Surface38
202, 5, 6, 8, 7
*ELEMENT, type=CPS4, ELSET=Surface63
203, 9, 10, 12, 11
*ELEMENT, type=CPS4, ELSET=Surface64
204, 9, 10, 62, 61
205, 61, 62, 14, 13
*ELEMENT, type=CPS4, ELSET=Surface65
206, 11, 63, 64, 12
207, 63, 15, 16, 64
*ELEMENT, type=CPS4, ELSET=Surface66
208, 9, 61, 63, 11
209, 61, 13, 15, 63
*ELEMENT, type=CPS4, ELSET=Surface67
210, 10, 12, 64, 62
211, 62, 64, 16, 14
*ELEMENT, type=CPS4, ELSET=Surface68
212, 13, 14, 16, 15
*ELEMENT, type=CPS4, ELSET=Surface69
213, 18, 17, 2, 1
*ELEMENT, type=CPS4, ELSET=Surface70
214, 20, 3, 4, 19
*ELEMENT, type=CPS4, ELSET=Surface71
215, 18, 1, 3, 20
*ELEMENT, type=CPS4, ELSET=Surface72
216, 17, 19, 4, 2
*ELEMENT, type=CPS4, ELSET=Surface73
217, 18, 20, 19, 17
*ELEMENT, type=CPS4, ELSET=Surface74
218, 17, 21, 22, 19
*ELEMENT, type=CPS4, ELSET=Surface75
219, 19, 22, 66, 65
220, 65, 66, 24, 23
*ELEMENT, type=CPS4, ELSET=Surface76
221, 25, 23, 24, 26
*ELEMENT, type=CPS4, ELSET=Surface77
222, 17, 67, 68, 21
223, 67, 25, 26, 68
*ELEMENT, type=CPS4, ELSET=Surface78
224, 17, 19, 65, 67
225, 67, 65, 23, 25
*ELEMENT, type=CPS4, ELSET=Surface79
226, 26, 24, 66, 68
227, 68, 66, 22, 21
*ELEMENT, type=CPS4, ELSET=Surface80
228, 20, 19, 65, 69
229, 69, 65, 23, 27
*ELEMENT, type=CPS4, ELSET=Surface81
230, 28, 27, 23, 25
*ELEMENT, type=CPS4, ELSET=Surface82
231, 18, 70, 67, 17
232, 70, 28, 25, 67
*ELEMENT, type=CPS4, ELSET=Surface83
233, 18, 20, 69, 70
234, 70, 69, 27, 28
*ELEMENT, type=CPS4, ELSET=Surface84
235, 5, 6, 29, 30
*ELEMENT, type=CPS4, ELSET=Surface85
236, 7, 32, 31, 8
*ELEMENT, type=CPS4, ELSET=Surface86
237, 5, 30, 32, 7
*ELEMENT, type=CPS4, ELSET=Surface87
238, 6, 8, 31, 29
*ELEMENT, type=CPS4, ELSET=Surface88
239, 30, 29, 31, 32
*ELEMENT, type=CPS4, ELSET=Surface89
240, 30, 29, 71, 72
241, 72, 71, 33, 34
*ELEMENT, type=CPS4, ELSET=Surface90
242, 32, 74, 73, 31
243, 74, 36, 35, 73
*ELEMENT, type=CPS4, ELSET=Surface91
244, 30, 72, 74, 32
245, 72, 34, 36, 74
*ELEMENT, type=CPS4, ELSET=Surface92
246, 29, 31, 73, 71
247, 71, 73, 35, 33
*ELEMENT, type=CPS4, ELSET=Surface93
248, 34, 33, 35, 36
*ELEMENT, type=CPS4, ELSET=Surface94
249, 30, 72, 75, 38
250, 72, 34, 37, 75
*ELEMENT, type=CPS4, ELSET=Surface95
251, 32, 40, 76, 74
252, 74, 76, 39, 36
*ELEMENT, type=CPS4, ELSET=Surface96
253, 30, 38, 40, 32
*ELEMENT, type=CPS4, ELSET=Surface97
254, 34, 36, 39, 37
*ELEMENT, type=CPS4, ELSET=Surface98
255, 38, 75, 76, 40
256, 75, 37, 39, 76
*ELEMENT, type=CPS4, ELSET=Surface99
257, 38, 41, 10, 9
*ELEMENT, type=CPS4, ELSET=Surface100
258, 40, 11, 12, 42
*ELEMENT, type=CPS4, ELSET=Surface101
259, 38, 9, 11, 40
*ELEMENT, type=CPS4, ELSET=Surface102
260, 41, 42, 12, 10
*ELEMENT, type=CPS4, ELSET=Surface103
261, 38, 40, 42, 41
*ELEMENT, type=CPS4, ELSET=Surface104
262, 38, 75, 77, 41
263, 75, 37, 43, 77
*ELEMENT, type=CPS4, ELSET=Surface105
264, 40, 42, 78, 76
265, 76, 78, 44, 39
*ELEMENT, type=CPS4, ELSET=Surface106
266, 37, 39, 44, 43
*ELEMENT, type=CPS4, ELSET=Surface107
267, 41, 77, 78, 42
268, 77, 43, 44, 78
*ELEMENT, type=CPS4, ELSET=Surface108
269, 13, 14, 45, 46
*ELEMENT, type=CPS4, ELSET=Surface109
270, 15, 48, 47, 16
*ELEMENT, type=CPS4, ELSET=Surface110
271, 13, 46, 48, 15
*ELEMENT, type=CPS4, ELSET=Surface111
272, 14, 16, 47, 45
*ELEMENT, type=CPS4, ELSET=Surface112
273, 46, 45, 47, 48
*ELEMENT, type=CPS4, ELSET=Surface113
274, 46, 45, 79, 80
275, 80, 79, 49, 50
*ELEMENT, type=CPS4, ELSET=Surface114
276, 48, 82, 81, 47
277, 82, 52, 51, 81
*ELEMENT, type=CPS4, ELSET=Surface115
278, 46, 80, 82, 48
279, 80, 50, 52, 82
*ELEMENT, type=CPS4, ELSET=Surface116
280, 45, 47, 81, 79
281, 79, 81, 51, 49
*ELEMENT, type=CPS4, ELSET=Surface117
282, 50, 49, 51, 52
*ELEMENT, type=CPS4, ELSET=Surface118
283, 45, 53, 83, 79
284, 79, 83, 54, 49
*ELEMENT, type=CPS4, ELSET=Surface119
285, 47, 81, 84, 55
286, 81, 51, 56, 84
*ELEMENT, type=CPS4, ELSET=Surface120
287, 45, 47, 55, 53
*ELEMENT, type=CPS4, ELSET=Surface121
288, 49, 54, 56, 51
*ELEMENT, type=CPS4, ELSET=Surface122
289, 53, 55, 84, 83
290, 83, 84, 56, 54
*ELEMENT, type=C3D8, ELSET=Volume2
291, 69, 20, 18, 70, 65, 19, 17, 67
292, 27, 69, 70, 28, 23, 65, 67, 25
*ELEMENT, type=C3D8, ELSET=Volume3
293, 65, 19, 17, 67, 66, 22, 21, 68
294, 23, 65, 67, 25, 24, 66, 68, 26
*ELEMENT, type=C3D8, ELSET=Volume4
295, 19, 20, 18, 17, 4, 3, 1, 2
*ELEMENT, type=C3D8, ELSET=Volume5
296, 1, 2, 4, 3, 57, 58, 60, 59
297, 57, 58, 60, 59, 5, 6, 8, 7
*ELEMENT, type=C3D8, ELSET=Volume6
298, 5, 6, 8, 7, 30, 29, 31, 32
*ELEMENT, type=C3D8, ELSET=Volume7
299, 30, 29, 31, 32, 72, 71, 73, 74
300, 72, 71, 73, 74, 34, 33, 35, 36
*ELEMENT, type=C3D8, ELSET=Volume8
301, 30, 72, 74, 32, 38, 75, 76, 40
302, 72, 34, 36, 74, 75, 37, 39, 76
*ELEMENT, type=C3D8, ELSET=Volume9
303, 38, 75, 76, 40, 41, 77, 78, 42
304, 75, 37, 39, 76, 77, 43, 44, 78
*ELEMENT, type=C3D8, ELSET=Volume10
305, 42, 40, 38, 41, 12, 11, 9, 10
*ELEMENT, type=C3D8, ELSET=Volume11
306, 9, 10, 12, 11, 61, 62, 64, 63
307, 61, 62, 64, 63, 13, 14, 16, 15
*ELEMENT, type=C3D8, ELSET=Volume12
308, 13, 14, 16, 15, 46, 45, 47, 48
*ELEMENT, type=C3D8, ELSET=Volume13
309, 46, 45, 47, 48, 80, 79, 81, 82
310, 80, 79, 81, 82, 50, 49, 51, 52
*ELEMENT, type=C3D8, ELSET=Volume14
311, 45, 47, 81, 79, 53, 55, 84, 83
312, 79, 81, 51, 49, 83, 84, 56, 54
*ELSET,ELSET=ElectrodeMinX
226, 227, 
*ELSET,ELSET=ElectrodeMaxX
289, 290, 
*ELSET,ELSET=HeatSink
230, 282, 
*ELSET,ELSET=Qin
248, 254, 266, 
*ELSET,ELSET=Force
246, 247, 
*ELSET,ELSET=Volume
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 
*ELSET,ELSET=TO
296, 297, 306, 307, 
*ELSET,ELSET=SemiconductorN-
296, 297, 
*ELSET,ELSET=SemiconductorP+
306, 307, 
*ELSET,ELSET=Copper
291, 292, 293, 294, 299, 300, 301, 302, 303, 304, 
309, 310, 311, 312, 
*ELSET,ELSET=Solder
295, 298, 305, 308, 
*NSET,NSET=ElectrodeMinX
21, 22, 24, 26, 66, 68, 
*NSET,NSET=ElectrodeMaxX
53, 54, 55, 56, 83, 84, 
*NSET,NSET=HeatSink
23, 25, 27, 28, 49, 50, 51, 52, 
*NSET,NSET=Qin
33, 34, 35, 36, 37, 39, 43, 44, 
*NSET,NSET=Force
29, 31, 33, 35, 71, 73, 
*NSET,NSET=Volume
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 
*NSET,NSET=TO
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 57, 58, 59, 60, 
61, 62, 63, 64, 
*NSET,NSET=SemiconductorN-
1, 2, 3, 4, 5, 6, 7, 8, 57, 58, 
59, 60, 
*NSET,NSET=SemiconductorP+
9, 10, 11, 12, 13, 14, 15, 16, 61, 62, 
63, 64, 
*NSET,NSET=Copper
17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 
27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 
37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 
75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 
*NSET,NSET=Solder
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
29, 30, 31, 32, 38, 40, 41, 42, 45, 46, 
47, 48, 
