*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_2D_RndSimp
*NODE
1, 0, 0, 0
2, 1, 0, 0
3, 1, 1.2, 0
4, 0, 1.2, 0
5, 1, 1.3, 0
6, 0, 1.3, 0
7, 1.2, 1.2, 0
8, 1.2, 1.3, 0
9, 2.2, 1.2, 0
10, 2.2, 1.3, 0
11, 1.2, 0, 0
12, 2.2, 0, 0
13, 1.2, -0.1, 0
14, 2.2, -0.1, 0
15, 0, -0.1, 0
16, 1, -0.1, 0
17, 2.3, 0, 0
18, 2.3, -0.1, 0
19, -0.1, 0, 0
20, -0.1, -0.1, 0
21, 0, -0.3, 0
22, 1, -0.3, 0
23, -0.1, -0.3, 0
24, 1.2, -0.3, 0
25, 2.2, -0.3, 0
26, 2.3, -0.3, 0
27, 1, 1.5, 0
28, 0, 1.5, 0
29, 1.2, 1.5, 0
30, 2.2, 1.5, 0
31, 0.1, 0, 0
32, 0.2, 0, 0
33, 0.3, 0, 0
34, 0.4, 0, 0
35, 0.5, 0, 0
36, 0.6, 0, 0
37, 0.7, 0, 0
38, 0.8, 0, 0
39, 0.9, 0, 0
40, 1, 0.12, 0
41, 1, 0.24, 0
42, 1, 0.36, 0
43, 1, 0.48, 0
44, 1, 0.6, 0
45, 1, 0.72, 0
46, 1, 0.84, 0
47, 1, 0.96, 0
48, 1, 1.08, 0
49, 0.9, 1.2, 0
50, 0.8, 1.2, 0
51, 0.7, 1.2, 0
52, 0.6, 1.2, 0
53, 0.5, 1.2, 0
54, 0.4, 1.2, 0
55, 0.3, 1.2, 0
56, 0.2, 1.2, 0
57, 0.1, 1.2, 0
58, 0, 1.08, 0
59, 0, 0.96, 0
60, 0, 0.84, 0
61, 0, 0.72, 0
62, 0, 0.6, 0
63, 0, 0.48, 0
64, 0, 0.36, 0
65, 0, 0.24, 0
66, 0, 0.12, 0
67, 1, 1.2333333333333, 0
68, 1, 1.2666666666667, 0
69, 0, 1.2333333333333, 0
70, 0, 1.2666666666667, 0
71, 0.9, 1.3, 0
72, 0.8, 1.3, 0
73, 0.7, 1.3, 0
74, 0.6, 1.3, 0
75, 0.5, 1.3, 0
76, 0.4, 1.3, 0
77, 0.3, 1.3, 0
78, 0.2, 1.3, 0
79, 0.1, 1.3, 0
80, 1.0666666666667, 1.2, 0
81, 1.1333333333333, 1.2, 0
82, 1.0666666666667, 1.3, 0
83, 1.1333333333333, 1.3, 0
84, 1.2, 1.2333333333333, 0
85, 1.2, 1.2666666666667, 0
86, 1.3, 1.2, 0
87, 1.4, 1.2, 0
88, 1.5, 1.2, 0
89, 1.6, 1.2, 0
90, 1.7, 1.2, 0
91, 1.8, 1.2, 0
92, 1.9, 1.2, 0
93, 2, 1.2, 0
94, 2.1, 1.2, 0
95, 1.3, 1.3, 0
96, 1.4, 1.3, 0
97, 1.5, 1.3, 0
98, 1.6, 1.3, 0
99, 1.7, 1.3, 0
100, 1.8, 1.3, 0
101, 1.9, 1.3, 0
102, 2, 1.3, 0
103, 2.1, 1.3, 0
104, 2.2, 1.2333333333333, 0
105, 2.2, 1.2666666666667, 0
106, 1.2, 1.08, 0
107, 1.2, 0.96, 0
108, 1.2, 0.84, 0
109, 1.2, 0.72, 0
110, 1.2, 0.6, 0
111, 1.2, 0.48, 0
112, 1.2, 0.36, 0
113, 1.2, 0.24, 0
114, 1.2, 0.12, 0
115, 2.2, 1.08, 0
116, 2.2, 0.96, 0
117, 2.2, 0.84, 0
118, 2.2, 0.72, 0
119, 2.2, 0.6, 0
120, 2.2, 0.48, 0
121, 2.2, 0.36, 0
122, 2.2, 0.24, 0
123, 2.2, 0.12, 0
124, 1.3, 0, 0
125, 1.4, 0, 0
126, 1.5, 0, 0
127, 1.6, 0, 0
128, 1.7, 0, 0
129, 1.8, 0, 0
130, 1.9, 0, 0
131, 2, 0, 0
132, 2.1, 0, 0
133, 1.2, -0.033333333333333, 0
134, 1.2, -0.066666666666667, 0
135, 2.2, -0.033333333333333, 0
136, 2.2, -0.066666666666667, 0
137, 1.3, -0.1, 0
138, 1.4, -0.1, 0
139, 1.5, -0.1, 0
140, 1.6, -0.1, 0
141, 1.7, -0.1, 0
142, 1.8, -0.1, 0
143, 1.9, -0.1, 0
144, 2, -0.1, 0
145, 2.1, -0.1, 0
146, 0, -0.033333333333333, 0
147, 0, -0.066666666666667, 0
148, 1, -0.033333333333333, 0
149, 1, -0.066666666666667, 0
150, 0.1, -0.1, 0
151, 0.2, -0.1, 0
152, 0.3, -0.1, 0
153, 0.4, -0.1, 0
154, 0.5, -0.1, 0
155, 0.6, -0.1, 0
156, 0.7, -0.1, 0
157, 0.8, -0.1, 0
158, 0.9, -0.1, 0
159, 2.225, 0, 0
160, 2.225, -0.1, 0
161, 2.3, -0.033333333333333, 0
162, 2.3, -0.066666666666667, 0
163, -0.025, 0, 0
164, -0.025, -0.1, 0
165, -0.1, -0.033333333333333, 0
166, -0.1, -0.066666666666667, 0
167, 0, -0.16666666666667, 0
168, 0, -0.23333333333333, 0
169, 1, -0.16666666666667, 0
170, 1, -0.23333333333333, 0
171, 0.1, -0.3, 0
172, 0.2, -0.3, 0
173, 0.3, -0.3, 0
174, 0.4, -0.3, 0
175, 0.5, -0.3, 0
176, 0.6, -0.3, 0
177, 0.7, -0.3, 0
178, 0.8, -0.3, 0
179, 0.9, -0.3, 0
180, -0.1, -0.16666666666667, 0
181, -0.1, -0.23333333333333, 0
182, -0.025, -0.3, 0
183, 1.2, -0.16666666666667, 0
184, 1.2, -0.23333333333333, 0
185, 2.2, -0.16666666666667, 0
186, 2.2, -0.23333333333333, 0
187, 1.3, -0.3, 0
188, 1.4, -0.3, 0
189, 1.5, -0.3, 0
190, 1.6, -0.3, 0
191, 1.7, -0.3, 0
192, 1.8, -0.3, 0
193, 1.9, -0.3, 0
194, 2, -0.3, 0
195, 2.1, -0.3, 0
196, 2.3, -0.16666666666667, 0
197, 2.3, -0.23333333333333, 0
198, 2.225, -0.3, 0
199, 1, 1.3666666666667, 0
200, 1, 1.4333333333333, 0
201, 0, 1.3666666666667, 0
202, 0, 1.4333333333333, 0
203, 0.9, 1.5, 0
204, 0.8, 1.5, 0
205, 0.7, 1.5, 0
206, 0.6, 1.5, 0
207, 0.5, 1.5, 0
208, 0.4, 1.5, 0
209, 0.3, 1.5, 0
210, 0.2, 1.5, 0
211, 0.1, 1.5, 0
212, 1.2, 1.3666666666667, 0
213, 1.2, 1.4333333333333, 0
214, 1.0666666666667, 1.5, 0
215, 1.1333333333333, 1.5, 0
216, 2.2, 1.3666666666667, 0
217, 2.2, 1.4333333333333, 0
218, 1.3, 1.5, 0
219, 1.4, 1.5, 0
220, 1.5, 1.5, 0
221, 1.6, 1.5, 0
222, 1.7, 1.5, 0
223, 1.8, 1.5, 0
224, 1.9, 1.5, 0
225, 2, 1.5, 0
226, 2.1, 1.5, 0
227, 0.1, 0.12, 0
228, 0.1, 0.24, 0
229, 0.1, 0.36, 0
230, 0.1, 0.48, 0
231, 0.1, 0.6, 0
232, 0.1, 0.72, 0
233, 0.1, 0.84, 0
234, 0.1, 0.96, 0
235, 0.1, 1.08, 0
236, 0.2, 0.12, 0
237, 0.2, 0.24, 0
238, 0.2, 0.36, 0
239, 0.2, 0.48, 0
240, 0.2, 0.6, 0
241, 0.2, 0.72, 0
242, 0.2, 0.84, 0
243, 0.2, 0.96, 0
244, 0.2, 1.08, 0
245, 0.3, 0.12, 0
246, 0.3, 0.24, 0
247, 0.3, 0.36, 0
248, 0.3, 0.48, 0
249, 0.3, 0.6, 0
250, 0.3, 0.72, 0
251, 0.3, 0.84, 0
252, 0.3, 0.96, 0
253, 0.3, 1.08, 0
254, 0.4, 0.12, 0
255, 0.4, 0.24, 0
256, 0.4, 0.36, 0
257, 0.4, 0.48, 0
258, 0.4, 0.6, 0
259, 0.4, 0.72, 0
260, 0.4, 0.84, 0
261, 0.4, 0.96, 0
262, 0.4, 1.08, 0
263, 0.5, 0.12, 0
264, 0.5, 0.24, 0
265, 0.5, 0.36, 0
266, 0.5, 0.48, 0
267, 0.5, 0.6, 0
268, 0.5, 0.72, 0
269, 0.5, 0.84, 0
270, 0.5, 0.96, 0
271, 0.5, 1.08, 0
272, 0.6, 0.12, 0
273, 0.6, 0.24, 0
274, 0.6, 0.36, 0
275, 0.6, 0.48, 0
276, 0.6, 0.6, 0
277, 0.6, 0.72, 0
278, 0.6, 0.84, 0
279, 0.6, 0.96, 0
280, 0.6, 1.08, 0
281, 0.7, 0.12, 0
282, 0.7, 0.24, 0
283, 0.7, 0.36, 0
284, 0.7, 0.48, 0
285, 0.7, 0.6, 0
286, 0.7, 0.72, 0
287, 0.7, 0.84, 0
288, 0.7, 0.96, 0
289, 0.7, 1.08, 0
290, 0.8, 0.12, 0
291, 0.8, 0.24, 0
292, 0.8, 0.36, 0
293, 0.8, 0.48, 0
294, 0.8, 0.6, 0
295, 0.8, 0.72, 0
296, 0.8, 0.84, 0
297, 0.8, 0.96, 0
298, 0.8, 1.08, 0
299, 0.9, 0.12, 0
300, 0.9, 0.24, 0
301, 0.9, 0.36, 0
302, 0.9, 0.48, 0
303, 0.9, 0.6, 0
304, 0.9, 0.72, 0
305, 0.9, 0.84, 0
306, 0.9, 0.96, 0
307, 0.9, 1.08, 0
308, 0.9, 1.2333333333333, 0
309, 0.8, 1.2333333333333, 0
310, 0.7, 1.2333333333333, 0
311, 0.6, 1.2333333333333, 0
312, 0.5, 1.2333333333333, 0
313, 0.4, 1.2333333333333, 0
314, 0.3, 1.2333333333333, 0
315, 0.2, 1.2333333333333, 0
316, 0.1, 1.2333333333333, 0
317, 0.9, 1.2666666666667, 0
318, 0.8, 1.2666666666667, 0
319, 0.7, 1.2666666666667, 0
320, 0.6, 1.2666666666667, 0
321, 0.5, 1.2666666666667, 0
322, 0.4, 1.2666666666667, 0
323, 0.3, 1.2666666666667, 0
324, 0.2, 1.2666666666667, 0
325, 0.1, 1.2666666666667, 0
326, 1.0666666666667, 1.2333333333333, 0
327, 1.0666666666667, 1.2666666666667, 0
328, 1.1333333333333, 1.2333333333333, 0
329, 1.1333333333333, 1.2666666666667, 0
330, 1.3, 1.2333333333333, 0
331, 1.3, 1.2666666666667, 0
332, 1.4, 1.2333333333333, 0
333, 1.4, 1.2666666666667, 0
334, 1.5, 1.2333333333333, 0
335, 1.5, 1.2666666666667, 0
336, 1.6, 1.2333333333333, 0
337, 1.6, 1.2666666666667, 0
338, 1.7, 1.2333333333333, 0
339, 1.7, 1.2666666666667, 0
340, 1.8, 1.2333333333333, 0
341, 1.8, 1.2666666666667, 0
342, 1.9, 1.2333333333333, 0
343, 1.9, 1.2666666666667, 0
344, 2, 1.2333333333333, 0
345, 2, 1.2666666666667, 0
346, 2.1, 1.2333333333333, 0
347, 2.1, 1.2666666666667, 0
348, 1.3, 1.08, 0
349, 1.4, 1.08, 0
350, 1.5, 1.08, 0
351, 1.6, 1.08, 0
352, 1.7, 1.08, 0
353, 1.8, 1.08, 0
354, 1.9, 1.08, 0
355, 2, 1.08, 0
356, 2.1, 1.08, 0
357, 1.3, 0.96, 0
358, 1.4, 0.96, 0
359, 1.5, 0.96, 0
360, 1.6, 0.96, 0
361, 1.7, 0.96, 0
362, 1.8, 0.96, 0
363, 1.9, 0.96, 0
364, 2, 0.96, 0
365, 2.1, 0.96, 0
366, 1.3, 0.84, 0
367, 1.4, 0.84, 0
368, 1.5, 0.84, 0
369, 1.6, 0.84, 0
370, 1.7, 0.84, 0
371, 1.8, 0.84, 0
372, 1.9, 0.84, 0
373, 2, 0.84, 0
374, 2.1, 0.84, 0
375, 1.3, 0.72, 0
376, 1.4, 0.72, 0
377, 1.5, 0.72, 0
378, 1.6, 0.72, 0
379, 1.7, 0.72, 0
380, 1.8, 0.72, 0
381, 1.9, 0.72, 0
382, 2, 0.72, 0
383, 2.1, 0.72, 0
384, 1.3, 0.6, 0
385, 1.4, 0.6, 0
386, 1.5, 0.6, 0
387, 1.6, 0.6, 0
388, 1.7, 0.6, 0
389, 1.8, 0.6, 0
390, 1.9, 0.6, 0
391, 2, 0.6, 0
392, 2.1, 0.6, 0
393, 1.3, 0.48, 0
394, 1.4, 0.48, 0
395, 1.5, 0.48, 0
396, 1.6, 0.48, 0
397, 1.7, 0.48, 0
398, 1.8, 0.48, 0
399, 1.9, 0.48, 0
400, 2, 0.48, 0
401, 2.1, 0.48, 0
402, 1.3, 0.36, 0
403, 1.4, 0.36, 0
404, 1.5, 0.36, 0
405, 1.6, 0.36, 0
406, 1.7, 0.36, 0
407, 1.8, 0.36, 0
408, 1.9, 0.36, 0
409, 2, 0.36, 0
410, 2.1, 0.36, 0
411, 1.3, 0.24, 0
412, 1.4, 0.24, 0
413, 1.5, 0.24, 0
414, 1.6, 0.24, 0
415, 1.7, 0.24, 0
416, 1.8, 0.24, 0
417, 1.9, 0.24, 0
418, 2, 0.24, 0
419, 2.1, 0.24, 0
420, 1.3, 0.12, 0
421, 1.4, 0.12, 0
422, 1.5, 0.12, 0
423, 1.6, 0.12, 0
424, 1.7, 0.12, 0
425, 1.8, 0.12, 0
426, 1.9, 0.12, 0
427, 2, 0.12, 0
428, 2.1, 0.12, 0
429, 1.3, -0.033333333333333, 0
430, 1.4, -0.033333333333333, 0
431, 1.5, -0.033333333333333, 0
432, 1.6, -0.033333333333333, 0
433, 1.7, -0.033333333333333, 0
434, 1.8, -0.033333333333333, 0
435, 1.9, -0.033333333333333, 0
436, 2, -0.033333333333333, 0
437, 2.1, -0.033333333333333, 0
438, 1.3, -0.066666666666667, 0
439, 1.4, -0.066666666666667, 0
440, 1.5, -0.066666666666667, 0
441, 1.6, -0.066666666666667, 0
442, 1.7, -0.066666666666667, 0
443, 1.8, -0.066666666666667, 0
444, 1.9, -0.066666666666667, 0
445, 2, -0.066666666666667, 0
446, 2.1, -0.066666666666667, 0
447, 0.1, -0.033333333333333, 0
448, 0.2, -0.033333333333333, 0
449, 0.3, -0.033333333333333, 0
450, 0.4, -0.033333333333333, 0
451, 0.5, -0.033333333333333, 0
452, 0.6, -0.033333333333333, 0
453, 0.7, -0.033333333333333, 0
454, 0.8, -0.033333333333333, 0
455, 0.9, -0.033333333333333, 0
456, 0.1, -0.066666666666667, 0
457, 0.2, -0.066666666666667, 0
458, 0.3, -0.066666666666667, 0
459, 0.4, -0.066666666666667, 0
460, 0.5, -0.066666666666667, 0
461, 0.6, -0.066666666666667, 0
462, 0.7, -0.066666666666667, 0
463, 0.8, -0.066666666666667, 0
464, 0.9, -0.066666666666667, 0
465, 2.225, -0.033333333333333, 0
466, 2.225, -0.066666666666667, 0
467, -0.025, -0.033333333333333, 0
468, -0.025, -0.066666666666667, 0
469, 0.1, -0.16666666666667, 0
470, 0.2, -0.16666666666667, 0
471, 0.3, -0.16666666666667, 0
472, 0.4, -0.16666666666667, 0
473, 0.5, -0.16666666666667, 0
474, 0.6, -0.16666666666667, 0
475, 0.7, -0.16666666666667, 0
476, 0.8, -0.16666666666667, 0
477, 0.9, -0.16666666666667, 0
478, 0.1, -0.23333333333333, 0
479, 0.2, -0.23333333333333, 0
480, 0.3, -0.23333333333333, 0
481, 0.4, -0.23333333333333, 0
482, 0.5, -0.23333333333333, 0
483, 0.6, -0.23333333333333, 0
484, 0.7, -0.23333333333333, 0
485, 0.8, -0.23333333333333, 0
486, 0.9, -0.23333333333333, 0
487, -0.025, -0.16666666666667, 0
488, -0.025, -0.23333333333333, 0
489, 1.3, -0.16666666666667, 0
490, 1.4, -0.16666666666667, 0
491, 1.5, -0.16666666666667, 0
492, 1.6, -0.16666666666667, 0
493, 1.7, -0.16666666666667, 0
494, 1.8, -0.16666666666667, 0
495, 1.9, -0.16666666666667, 0
496, 2, -0.16666666666667, 0
497, 2.1, -0.16666666666667, 0
498, 1.3, -0.23333333333333, 0
499, 1.4, -0.23333333333333, 0
500, 1.5, -0.23333333333333, 0
501, 1.6, -0.23333333333333, 0
502, 1.7, -0.23333333333333, 0
503, 1.8, -0.23333333333333, 0
504, 1.9, -0.23333333333333, 0
505, 2, -0.23333333333333, 0
506, 2.1, -0.23333333333333, 0
507, 2.225, -0.16666666666667, 0
508, 2.225, -0.23333333333333, 0
509, 0.9, 1.3666666666667, 0
510, 0.8, 1.3666666666667, 0
511, 0.7, 1.3666666666667, 0
512, 0.6, 1.3666666666667, 0
513, 0.5, 1.3666666666667, 0
514, 0.4, 1.3666666666667, 0
515, 0.3, 1.3666666666667, 0
516, 0.2, 1.3666666666667, 0
517, 0.1, 1.3666666666667, 0
518, 0.9, 1.4333333333333, 0
519, 0.8, 1.4333333333333, 0
520, 0.7, 1.4333333333333, 0
521, 0.6, 1.4333333333333, 0
522, 0.5, 1.4333333333333, 0
523, 0.4, 1.4333333333333, 0
524, 0.3, 1.4333333333333, 0
525, 0.2, 1.4333333333333, 0
526, 0.1, 1.4333333333333, 0
527, 1.0666666666667, 1.3666666666667, 0
528, 1.1333333333333, 1.3666666666667, 0
529, 1.0666666666667, 1.4333333333333, 0
530, 1.1333333333333, 1.4333333333333, 0
531, 1.3, 1.3666666666667, 0
532, 1.4, 1.3666666666667, 0
533, 1.5, 1.3666666666667, 0
534, 1.6, 1.3666666666667, 0
535, 1.7, 1.3666666666667, 0
536, 1.8, 1.3666666666667, 0
537, 1.9, 1.3666666666667, 0
538, 2, 1.3666666666667, 0
539, 2.1, 1.3666666666667, 0
540, 1.3, 1.4333333333333, 0
541, 1.4, 1.4333333333333, 0
542, 1.5, 1.4333333333333, 0
543, 1.6, 1.4333333333333, 0
544, 1.7, 1.4333333333333, 0
545, 1.8, 1.4333333333333, 0
546, 1.9, 1.4333333333333, 0
547, 2, 1.4333333333333, 0
548, 2.1, 1.4333333333333, 0
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
613, 1, 31
614, 31, 32
615, 32, 33
616, 33, 34
617, 34, 35
618, 35, 36
619, 36, 37
620, 37, 38
621, 38, 39
622, 39, 2
*ELEMENT, type=T3D2, ELSET=Line2
623, 2, 40
624, 40, 41
625, 41, 42
626, 42, 43
627, 43, 44
628, 44, 45
629, 45, 46
630, 46, 47
631, 47, 48
632, 48, 3
*ELEMENT, type=T3D2, ELSET=Line3
633, 3, 49
634, 49, 50
635, 50, 51
636, 51, 52
637, 52, 53
638, 53, 54
639, 54, 55
640, 55, 56
641, 56, 57
642, 57, 4
*ELEMENT, type=T3D2, ELSET=Line4
643, 4, 58
644, 58, 59
645, 59, 60
646, 60, 61
647, 61, 62
648, 62, 63
649, 63, 64
650, 64, 65
651, 65, 66
652, 66, 1
*ELEMENT, type=T3D2, ELSET=Line5
653, 3, 67
654, 67, 68
655, 68, 5
*ELEMENT, type=T3D2, ELSET=Line6
656, 4, 69
657, 69, 70
658, 70, 6
*ELEMENT, type=T3D2, ELSET=Line7
1, 5, 71
2, 71, 72
3, 72, 73
4, 73, 74
5, 74, 75
6, 75, 76
7, 76, 77
8, 77, 78
9, 78, 79
10, 79, 6
*ELEMENT, type=T3D2, ELSET=Line8
659, 3, 80
660, 80, 81
661, 81, 7
*ELEMENT, type=T3D2, ELSET=Line9
11, 5, 82
12, 82, 83
13, 83, 8
*ELEMENT, type=T3D2, ELSET=Line10
662, 7, 84
663, 84, 85
664, 85, 8
*ELEMENT, type=T3D2, ELSET=Line11
665, 7, 86
666, 86, 87
667, 87, 88
668, 88, 89
669, 89, 90
670, 90, 91
671, 91, 92
672, 92, 93
673, 93, 94
674, 94, 9
*ELEMENT, type=T3D2, ELSET=Line12
14, 8, 95
15, 95, 96
16, 96, 97
17, 97, 98
18, 98, 99
19, 99, 100
20, 100, 101
21, 101, 102
22, 102, 103
23, 103, 10
*ELEMENT, type=T3D2, ELSET=Line13
675, 9, 104
676, 104, 105
677, 105, 10
*ELEMENT, type=T3D2, ELSET=Line14
678, 7, 106
679, 106, 107
680, 107, 108
681, 108, 109
682, 109, 110
683, 110, 111
684, 111, 112
685, 112, 113
686, 113, 114
687, 114, 11
*ELEMENT, type=T3D2, ELSET=Line15
688, 9, 115
689, 115, 116
690, 116, 117
691, 117, 118
692, 118, 119
693, 119, 120
694, 120, 121
695, 121, 122
696, 122, 123
697, 123, 12
*ELEMENT, type=T3D2, ELSET=Line16
698, 11, 124
699, 124, 125
700, 125, 126
701, 126, 127
702, 127, 128
703, 128, 129
704, 129, 130
705, 130, 131
706, 131, 132
707, 132, 12
*ELEMENT, type=T3D2, ELSET=Line17
708, 11, 133
709, 133, 134
710, 134, 13
*ELEMENT, type=T3D2, ELSET=Line18
711, 12, 135
712, 135, 136
713, 136, 14
*ELEMENT, type=T3D2, ELSET=Line19
24, 13, 137
25, 137, 138
26, 138, 139
27, 139, 140
28, 140, 141
29, 141, 142
30, 142, 143
31, 143, 144
32, 144, 145
33, 145, 14
*ELEMENT, type=T3D2, ELSET=Line20
714, 1, 146
715, 146, 147
716, 147, 15
*ELEMENT, type=T3D2, ELSET=Line21
717, 2, 148
718, 148, 149
719, 149, 16
*ELEMENT, type=T3D2, ELSET=Line22
34, 15, 150
35, 150, 151
36, 151, 152
37, 152, 153
38, 153, 154
39, 154, 155
40, 155, 156
41, 156, 157
42, 157, 158
43, 158, 16
*ELEMENT, type=T3D2, ELSET=Line23
720, 12, 159
721, 159, 17
*ELEMENT, type=T3D2, ELSET=Line24
44, 14, 160
45, 160, 18
*ELEMENT, type=T3D2, ELSET=Line25
46, 17, 161
47, 161, 162
48, 162, 18
*ELEMENT, type=T3D2, ELSET=Line26
722, 1, 163
723, 163, 19
*ELEMENT, type=T3D2, ELSET=Line27
49, 15, 164
50, 164, 20
*ELEMENT, type=T3D2, ELSET=Line28
51, 19, 165
52, 165, 166
53, 166, 20
*ELEMENT, type=T3D2, ELSET=Line29
724, 15, 167
725, 167, 168
726, 168, 21
*ELEMENT, type=T3D2, ELSET=Line30
727, 16, 169
728, 169, 170
729, 170, 22
*ELEMENT, type=T3D2, ELSET=Line31
54, 21, 171
55, 171, 172
56, 172, 173
57, 173, 174
58, 174, 175
59, 175, 176
60, 176, 177
61, 177, 178
62, 178, 179
63, 179, 22
*ELEMENT, type=T3D2, ELSET=Line32
730, 20, 180
731, 180, 181
732, 181, 23
*ELEMENT, type=T3D2, ELSET=Line33
64, 21, 182
65, 182, 23
*ELEMENT, type=T3D2, ELSET=Line34
733, 13, 183
734, 183, 184
735, 184, 24
*ELEMENT, type=T3D2, ELSET=Line35
736, 14, 185
737, 185, 186
738, 186, 25
*ELEMENT, type=T3D2, ELSET=Line36
66, 24, 187
67, 187, 188
68, 188, 189
69, 189, 190
70, 190, 191
71, 191, 192
72, 192, 193
73, 193, 194
74, 194, 195
75, 195, 25
*ELEMENT, type=T3D2, ELSET=Line37
739, 18, 196
740, 196, 197
741, 197, 26
*ELEMENT, type=T3D2, ELSET=Line38
76, 25, 198
77, 198, 26
*ELEMENT, type=T3D2, ELSET=Line39
742, 5, 199
743, 199, 200
744, 200, 27
*ELEMENT, type=T3D2, ELSET=Line40
745, 6, 201
746, 201, 202
747, 202, 28
*ELEMENT, type=T3D2, ELSET=Line41
78, 27, 203
79, 203, 204
80, 204, 205
81, 205, 206
82, 206, 207
83, 207, 208
84, 208, 209
85, 209, 210
86, 210, 211
87, 211, 28
*ELEMENT, type=T3D2, ELSET=Line42
748, 8, 212
749, 212, 213
750, 213, 29
*ELEMENT, type=T3D2, ELSET=Line43
88, 27, 214
89, 214, 215
90, 215, 29
*ELEMENT, type=T3D2, ELSET=Line44
751, 10, 216
752, 216, 217
753, 217, 30
*ELEMENT, type=T3D2, ELSET=Line45
91, 29, 218
92, 218, 219
93, 219, 220
94, 220, 221
95, 221, 222
96, 222, 223
97, 223, 224
98, 224, 225
99, 225, 226
100, 226, 30
*ELEMENT, type=CPS4, ELSET=Surface1
101, 1, 31, 227, 66
102, 66, 227, 228, 65
103, 65, 228, 229, 64
104, 64, 229, 230, 63
105, 63, 230, 231, 62
106, 62, 231, 232, 61
107, 61, 232, 233, 60
108, 60, 233, 234, 59
109, 59, 234, 235, 58
110, 58, 235, 57, 4
111, 31, 32, 236, 227
112, 227, 236, 237, 228
113, 228, 237, 238, 229
114, 229, 238, 239, 230
115, 230, 239, 240, 231
116, 231, 240, 241, 232
117, 232, 241, 242, 233
118, 233, 242, 243, 234
119, 234, 243, 244, 235
120, 235, 244, 56, 57
121, 32, 33, 245, 236
122, 236, 245, 246, 237
123, 237, 246, 247, 238
124, 238, 247, 248, 239
125, 239, 248, 249, 240
126, 240, 249, 250, 241
127, 241, 250, 251, 242
128, 242, 251, 252, 243
129, 243, 252, 253, 244
130, 244, 253, 55, 56
131, 33, 34, 254, 245
132, 245, 254, 255, 246
133, 246, 255, 256, 247
134, 247, 256, 257, 248
135, 248, 257, 258, 249
136, 249, 258, 259, 250
137, 250, 259, 260, 251
138, 251, 260, 261, 252
139, 252, 261, 262, 253
140, 253, 262, 54, 55
141, 34, 35, 263, 254
142, 254, 263, 264, 255
143, 255, 264, 265, 256
144, 256, 265, 266, 257
145, 257, 266, 267, 258
146, 258, 267, 268, 259
147, 259, 268, 269, 260
148, 260, 269, 270, 261
149, 261, 270, 271, 262
150, 262, 271, 53, 54
151, 35, 36, 272, 263
152, 263, 272, 273, 264
153, 264, 273, 274, 265
154, 265, 274, 275, 266
155, 266, 275, 276, 267
156, 267, 276, 277, 268
157, 268, 277, 278, 269
158, 269, 278, 279, 270
159, 270, 279, 280, 271
160, 271, 280, 52, 53
161, 36, 37, 281, 272
162, 272, 281, 282, 273
163, 273, 282, 283, 274
164, 274, 283, 284, 275
165, 275, 284, 285, 276
166, 276, 285, 286, 277
167, 277, 286, 287, 278
168, 278, 287, 288, 279
169, 279, 288, 289, 280
170, 280, 289, 51, 52
171, 37, 38, 290, 281
172, 281, 290, 291, 282
173, 282, 291, 292, 283
174, 283, 292, 293, 284
175, 284, 293, 294, 285
176, 285, 294, 295, 286
177, 286, 295, 296, 287
178, 287, 296, 297, 288
179, 288, 297, 298, 289
180, 289, 298, 50, 51
181, 38, 39, 299, 290
182, 290, 299, 300, 291
183, 291, 300, 301, 292
184, 292, 301, 302, 293
185, 293, 302, 303, 294
186, 294, 303, 304, 295
187, 295, 304, 305, 296
188, 296, 305, 306, 297
189, 297, 306, 307, 298
190, 298, 307, 49, 50
191, 39, 2, 40, 299
192, 299, 40, 41, 300
193, 300, 41, 42, 301
194, 301, 42, 43, 302
195, 302, 43, 44, 303
196, 303, 44, 45, 304
197, 304, 45, 46, 305
198, 305, 46, 47, 306
199, 306, 47, 48, 307
200, 307, 48, 3, 49
*ELEMENT, type=CPS4, ELSET=Surface2
201, 3, 67, 308, 49
202, 49, 308, 309, 50
203, 50, 309, 310, 51
204, 51, 310, 311, 52
205, 52, 311, 312, 53
206, 53, 312, 313, 54
207, 54, 313, 314, 55
208, 55, 314, 315, 56
209, 56, 315, 316, 57
210, 57, 316, 69, 4
211, 67, 68, 317, 308
212, 308, 317, 318, 309
213, 309, 318, 319, 310
214, 310, 319, 320, 311
215, 311, 320, 321, 312
216, 312, 321, 322, 313
217, 313, 322, 323, 314
218, 314, 323, 324, 315
219, 315, 324, 325, 316
220, 316, 325, 70, 69
221, 68, 5, 71, 317
222, 317, 71, 72, 318
223, 318, 72, 73, 319
224, 319, 73, 74, 320
225, 320, 74, 75, 321
226, 321, 75, 76, 322
227, 322, 76, 77, 323
228, 323, 77, 78, 324
229, 324, 78, 79, 325
230, 325, 79, 6, 70
*ELEMENT, type=CPS4, ELSET=Surface3
231, 3, 80, 326, 67
232, 67, 326, 327, 68
233, 68, 327, 82, 5
234, 80, 81, 328, 326
235, 326, 328, 329, 327
236, 327, 329, 83, 82
237, 81, 7, 84, 328
238, 328, 84, 85, 329
239, 329, 85, 8, 83
*ELEMENT, type=CPS4, ELSET=Surface4
240, 7, 86, 330, 84
241, 84, 330, 331, 85
242, 85, 331, 95, 8
243, 86, 87, 332, 330
244, 330, 332, 333, 331
245, 331, 333, 96, 95
246, 87, 88, 334, 332
247, 332, 334, 335, 333
248, 333, 335, 97, 96
249, 88, 89, 336, 334
250, 334, 336, 337, 335
251, 335, 337, 98, 97
252, 89, 90, 338, 336
253, 336, 338, 339, 337
254, 337, 339, 99, 98
255, 90, 91, 340, 338
256, 338, 340, 341, 339
257, 339, 341, 100, 99
258, 91, 92, 342, 340
259, 340, 342, 343, 341
260, 341, 343, 101, 100
261, 92, 93, 344, 342
262, 342, 344, 345, 343
263, 343, 345, 102, 101
264, 93, 94, 346, 344
265, 344, 346, 347, 345
266, 345, 347, 103, 102
267, 94, 9, 104, 346
268, 346, 104, 105, 347
269, 347, 105, 10, 103
*ELEMENT, type=CPS4, ELSET=Surface5
270, 7, 106, 348, 86
271, 86, 348, 349, 87
272, 87, 349, 350, 88
273, 88, 350, 351, 89
274, 89, 351, 352, 90
275, 90, 352, 353, 91
276, 91, 353, 354, 92
277, 92, 354, 355, 93
278, 93, 355, 356, 94
279, 94, 356, 115, 9
280, 106, 107, 357, 348
281, 348, 357, 358, 349
282, 349, 358, 359, 350
283, 350, 359, 360, 351
284, 351, 360, 361, 352
285, 352, 361, 362, 353
286, 353, 362, 363, 354
287, 354, 363, 364, 355
288, 355, 364, 365, 356
289, 356, 365, 116, 115
290, 107, 108, 366, 357
291, 357, 366, 367, 358
292, 358, 367, 368, 359
293, 359, 368, 369, 360
294, 360, 369, 370, 361
295, 361, 370, 371, 362
296, 362, 371, 372, 363
297, 363, 372, 373, 364
298, 364, 373, 374, 365
299, 365, 374, 117, 116
300, 108, 109, 375, 366
301, 366, 375, 376, 367
302, 367, 376, 377, 368
303, 368, 377, 378, 369
304, 369, 378, 379, 370
305, 370, 379, 380, 371
306, 371, 380, 381, 372
307, 372, 381, 382, 373
308, 373, 382, 383, 374
309, 374, 383, 118, 117
310, 109, 110, 384, 375
311, 375, 384, 385, 376
312, 376, 385, 386, 377
313, 377, 386, 387, 378
314, 378, 387, 388, 379
315, 379, 388, 389, 380
316, 380, 389, 390, 381
317, 381, 390, 391, 382
318, 382, 391, 392, 383
319, 383, 392, 119, 118
320, 110, 111, 393, 384
321, 384, 393, 394, 385
322, 385, 394, 395, 386
323, 386, 395, 396, 387
324, 387, 396, 397, 388
325, 388, 397, 398, 389
326, 389, 398, 399, 390
327, 390, 399, 400, 391
328, 391, 400, 401, 392
329, 392, 401, 120, 119
330, 111, 112, 402, 393
331, 393, 402, 403, 394
332, 394, 403, 404, 395
333, 395, 404, 405, 396
334, 396, 405, 406, 397
335, 397, 406, 407, 398
336, 398, 407, 408, 399
337, 399, 408, 409, 400
338, 400, 409, 410, 401
339, 401, 410, 121, 120
340, 112, 113, 411, 402
341, 402, 411, 412, 403
342, 403, 412, 413, 404
343, 404, 413, 414, 405
344, 405, 414, 415, 406
345, 406, 415, 416, 407
346, 407, 416, 417, 408
347, 408, 417, 418, 409
348, 409, 418, 419, 410
349, 410, 419, 122, 121
350, 113, 114, 420, 411
351, 411, 420, 421, 412
352, 412, 421, 422, 413
353, 413, 422, 423, 414
354, 414, 423, 424, 415
355, 415, 424, 425, 416
356, 416, 425, 426, 417
357, 417, 426, 427, 418
358, 418, 427, 428, 419
359, 419, 428, 123, 122
360, 114, 11, 124, 420
361, 420, 124, 125, 421
362, 421, 125, 126, 422
363, 422, 126, 127, 423
364, 423, 127, 128, 424
365, 424, 128, 129, 425
366, 425, 129, 130, 426
367, 426, 130, 131, 427
368, 427, 131, 132, 428
369, 428, 132, 12, 123
*ELEMENT, type=CPS4, ELSET=Surface6
370, 11, 133, 429, 124
371, 124, 429, 430, 125
372, 125, 430, 431, 126
373, 126, 431, 432, 127
374, 127, 432, 433, 128
375, 128, 433, 434, 129
376, 129, 434, 435, 130
377, 130, 435, 436, 131
378, 131, 436, 437, 132
379, 132, 437, 135, 12
380, 133, 134, 438, 429
381, 429, 438, 439, 430
382, 430, 439, 440, 431
383, 431, 440, 441, 432
384, 432, 441, 442, 433
385, 433, 442, 443, 434
386, 434, 443, 444, 435
387, 435, 444, 445, 436
388, 436, 445, 446, 437
389, 437, 446, 136, 135
390, 134, 13, 137, 438
391, 438, 137, 138, 439
392, 439, 138, 139, 440
393, 440, 139, 140, 441
394, 441, 140, 141, 442
395, 442, 141, 142, 443
396, 443, 142, 143, 444
397, 444, 143, 144, 445
398, 445, 144, 145, 446
399, 446, 145, 14, 136
*ELEMENT, type=CPS4, ELSET=Surface7
400, 1, 146, 447, 31
401, 31, 447, 448, 32
402, 32, 448, 449, 33
403, 33, 449, 450, 34
404, 34, 450, 451, 35
405, 35, 451, 452, 36
406, 36, 452, 453, 37
407, 37, 453, 454, 38
408, 38, 454, 455, 39
409, 39, 455, 148, 2
410, 146, 147, 456, 447
411, 447, 456, 457, 448
412, 448, 457, 458, 449
413, 449, 458, 459, 450
414, 450, 459, 460, 451
415, 451, 460, 461, 452
416, 452, 461, 462, 453
417, 453, 462, 463, 454
418, 454, 463, 464, 455
419, 455, 464, 149, 148
420, 147, 15, 150, 456
421, 456, 150, 151, 457
422, 457, 151, 152, 458
423, 458, 152, 153, 459
424, 459, 153, 154, 460
425, 460, 154, 155, 461
426, 461, 155, 156, 462
427, 462, 156, 157, 463
428, 463, 157, 158, 464
429, 464, 158, 16, 149
*ELEMENT, type=CPS4, ELSET=Surface8
430, 12, 159, 465, 135
431, 135, 465, 466, 136
432, 136, 466, 160, 14
433, 159, 17, 161, 465
434, 465, 161, 162, 466
435, 466, 162, 18, 160
*ELEMENT, type=CPS4, ELSET=Surface9
436, 1, 163, 467, 146
437, 146, 467, 468, 147
438, 147, 468, 164, 15
439, 163, 19, 165, 467
440, 467, 165, 166, 468
441, 468, 166, 20, 164
*ELEMENT, type=CPS4, ELSET=Surface10
442, 15, 167, 469, 150
443, 150, 469, 470, 151
444, 151, 470, 471, 152
445, 152, 471, 472, 153
446, 153, 472, 473, 154
447, 154, 473, 474, 155
448, 155, 474, 475, 156
449, 156, 475, 476, 157
450, 157, 476, 477, 158
451, 158, 477, 169, 16
452, 167, 168, 478, 469
453, 469, 478, 479, 470
454, 470, 479, 480, 471
455, 471, 480, 481, 472
456, 472, 481, 482, 473
457, 473, 482, 483, 474
458, 474, 483, 484, 475
459, 475, 484, 485, 476
460, 476, 485, 486, 477
461, 477, 486, 170, 169
462, 168, 21, 171, 478
463, 478, 171, 172, 479
464, 479, 172, 173, 480
465, 480, 173, 174, 481
466, 481, 174, 175, 482
467, 482, 175, 176, 483
468, 483, 176, 177, 484
469, 484, 177, 178, 485
470, 485, 178, 179, 486
471, 486, 179, 22, 170
*ELEMENT, type=CPS4, ELSET=Surface11
472, 15, 167, 487, 164
473, 164, 487, 180, 20
474, 167, 168, 488, 487
475, 487, 488, 181, 180
476, 168, 21, 182, 488
477, 488, 182, 23, 181
*ELEMENT, type=CPS4, ELSET=Surface12
478, 13, 183, 489, 137
479, 137, 489, 490, 138
480, 138, 490, 491, 139
481, 139, 491, 492, 140
482, 140, 492, 493, 141
483, 141, 493, 494, 142
484, 142, 494, 495, 143
485, 143, 495, 496, 144
486, 144, 496, 497, 145
487, 145, 497, 185, 14
488, 183, 184, 498, 489
489, 489, 498, 499, 490
490, 490, 499, 500, 491
491, 491, 500, 501, 492
492, 492, 501, 502, 493
493, 493, 502, 503, 494
494, 494, 503, 504, 495
495, 495, 504, 505, 496
496, 496, 505, 506, 497
497, 497, 506, 186, 185
498, 184, 24, 187, 498
499, 498, 187, 188, 499
500, 499, 188, 189, 500
501, 500, 189, 190, 501
502, 501, 190, 191, 502
503, 502, 191, 192, 503
504, 503, 192, 193, 504
505, 504, 193, 194, 505
506, 505, 194, 195, 506
507, 506, 195, 25, 186
*ELEMENT, type=CPS4, ELSET=Surface13
508, 14, 185, 507, 160
509, 160, 507, 196, 18
510, 185, 186, 508, 507
511, 507, 508, 197, 196
512, 186, 25, 198, 508
513, 508, 198, 26, 197
*ELEMENT, type=CPS4, ELSET=Surface14
514, 5, 199, 509, 71
515, 71, 509, 510, 72
516, 72, 510, 511, 73
517, 73, 511, 512, 74
518, 74, 512, 513, 75
519, 75, 513, 514, 76
520, 76, 514, 515, 77
521, 77, 515, 516, 78
522, 78, 516, 517, 79
523, 79, 517, 201, 6
524, 199, 200, 518, 509
525, 509, 518, 519, 510
526, 510, 519, 520, 511
527, 511, 520, 521, 512
528, 512, 521, 522, 513
529, 513, 522, 523, 514
530, 514, 523, 524, 515
531, 515, 524, 525, 516
532, 516, 525, 526, 517
533, 517, 526, 202, 201
534, 200, 27, 203, 518
535, 518, 203, 204, 519
536, 519, 204, 205, 520
537, 520, 205, 206, 521
538, 521, 206, 207, 522
539, 522, 207, 208, 523
540, 523, 208, 209, 524
541, 524, 209, 210, 525
542, 525, 210, 211, 526
543, 526, 211, 28, 202
*ELEMENT, type=CPS4, ELSET=Surface15
544, 5, 199, 527, 82
545, 82, 527, 528, 83
546, 83, 528, 212, 8
547, 199, 200, 529, 527
548, 527, 529, 530, 528
549, 528, 530, 213, 212
550, 200, 27, 214, 529
551, 529, 214, 215, 530
552, 530, 215, 29, 213
*ELEMENT, type=CPS4, ELSET=Surface16
553, 8, 212, 531, 95
554, 95, 531, 532, 96
555, 96, 532, 533, 97
556, 97, 533, 534, 98
557, 98, 534, 535, 99
558, 99, 535, 536, 100
559, 100, 536, 537, 101
560, 101, 537, 538, 102
561, 102, 538, 539, 103
562, 103, 539, 216, 10
563, 212, 213, 540, 531
564, 531, 540, 541, 532
565, 532, 541, 542, 533
566, 533, 542, 543, 534
567, 534, 543, 544, 535
568, 535, 544, 545, 536
569, 536, 545, 546, 537
570, 537, 546, 547, 538
571, 538, 547, 548, 539
572, 539, 548, 217, 216
573, 213, 29, 218, 540
574, 540, 218, 219, 541
575, 541, 219, 220, 542
576, 542, 220, 221, 543
577, 543, 221, 222, 544
578, 544, 222, 223, 545
579, 545, 223, 224, 546
580, 546, 224, 225, 547
581, 547, 225, 226, 548
582, 548, 226, 30, 217
*ELSET,ELSET=Ceramic_Top
78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 
88, 89, 90, 91, 92, 93, 94, 95, 96, 97, 
98, 99, 100, 
*ELSET,ELSET=Ceramic_Bottom
54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 
64, 65, 66, 67, 68, 69, 70, 71, 72, 73, 
74, 75, 76, 77, 
*ELSET,ELSET=Electrode_MinX
51, 52, 53, 
*ELSET,ELSET=Electrode_MaxX
46, 47, 48, 
*ELSET,ELSET=Contact_Ceramic
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 49, 50, 
*ELSET,ELSET=Copper
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 417, 418, 419, 420, 
421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 
*ELSET,ELSET=SemiconductorL
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
*ELSET,ELSET=SemiconductorR
270, 271, 272, 273, 274, 275, 276, 277, 278, 279, 
280, 281, 282, 283, 284, 285, 286, 287, 288, 289, 
290, 291, 292, 293, 294, 295, 296, 297, 298, 299, 
300, 301, 302, 303, 304, 305, 306, 307, 308, 309, 
310, 311, 312, 313, 314, 315, 316, 317, 318, 319, 
320, 321, 322, 323, 324, 325, 326, 327, 328, 329, 
330, 331, 332, 333, 334, 335, 336, 337, 338, 339, 
340, 341, 342, 343, 344, 345, 346, 347, 348, 349, 
350, 351, 352, 353, 354, 355, 356, 357, 358, 359, 
360, 361, 362, 363, 364, 365, 366, 367, 368, 369, 
*ELSET,ELSET=Ceramic
442, 443, 444, 445, 446, 447, 448, 449, 450, 451, 
452, 453, 454, 455, 456, 457, 458, 459, 460, 461, 
462, 463, 464, 465, 466, 467, 468, 469, 470, 471, 
472, 473, 474, 475, 476, 477, 478, 479, 480, 481, 
482, 483, 484, 485, 486, 487, 488, 489, 490, 491, 
492, 493, 494, 495, 496, 497, 498, 499, 500, 501, 
502, 503, 504, 505, 506, 507, 508, 509, 510, 511, 
512, 513, 514, 515, 516, 517, 518, 519, 520, 521, 
522, 523, 524, 525, 526, 527, 528, 529, 530, 531, 
532, 533, 534, 535, 536, 537, 538, 539, 540, 541, 
542, 543, 544, 545, 546, 547, 548, 549, 550, 551, 
552, 553, 554, 555, 556, 557, 558, 559, 560, 561, 
562, 563, 564, 565, 566, 567, 568, 569, 570, 571, 
572, 573, 574, 575, 576, 577, 578, 579, 580, 581, 
582, 
*ELSET,ELSET=Surface
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 417, 418, 419, 420, 
421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 443, 444, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 
461, 462, 463, 464, 465, 466, 467, 468, 469, 470, 
471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 
481, 482, 483, 484, 485, 486, 487, 488, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 549, 550, 
551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 
561, 562, 563, 564, 565, 566, 567, 568, 569, 570, 
571, 572, 573, 574, 575, 576, 577, 578, 579, 580, 
581, 582, 
*ELSET,ELSET=TO
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
270, 271, 272, 273, 274, 275, 276, 277, 278, 279, 
280, 281, 282, 283, 284, 285, 286, 287, 288, 289, 
290, 291, 292, 293, 294, 295, 296, 297, 298, 299, 
300, 301, 302, 303, 304, 305, 306, 307, 308, 309, 
310, 311, 312, 313, 314, 315, 316, 317, 318, 319, 
320, 321, 322, 323, 324, 325, 326, 327, 328, 329, 
330, 331, 332, 333, 334, 335, 336, 337, 338, 339, 
340, 341, 342, 343, 344, 345, 346, 347, 348, 349, 
350, 351, 352, 353, 354, 355, 356, 357, 358, 359, 
360, 361, 362, 363, 364, 365, 366, 367, 368, 369, 
*NSET,NSET=Ceramic_Top
27, 28, 29, 30, 203, 204, 205, 206, 207, 208, 
209, 210, 211, 214, 215, 218, 219, 220, 221, 222, 
223, 224, 225, 226, 
*NSET,NSET=Ceramic_Bottom
21, 22, 23, 24, 25, 26, 171, 172, 173, 174, 
175, 176, 177, 178, 179, 182, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 198, 
*NSET,NSET=Electrode_MinX
19, 20, 165, 166, 
*NSET,NSET=Electrode_MaxX
17, 18, 161, 162, 
*NSET,NSET=Contact_Ceramic
5, 6, 8, 10, 13, 14, 15, 16, 18, 20, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 82, 
83, 95, 96, 97, 98, 99, 100, 101, 102, 103, 
137, 138, 139, 140, 141, 142, 143, 144, 145, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 160, 164, 
*NSET,NSET=Copper
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 49, 
50, 51, 52, 53, 54, 55, 56, 57, 67, 68, 
69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 
79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 
89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 
99, 100, 101, 102, 103, 104, 105, 124, 125, 126, 
127, 128, 129, 130, 131, 132, 133, 134, 135, 136, 
137, 138, 139, 140, 141, 142, 143, 144, 145, 146, 
147, 148, 149, 150, 151, 152, 153, 154, 155, 156, 
157, 158, 159, 160, 161, 162, 163, 164, 165, 166, 
308, 309, 310, 311, 312, 313, 314, 315, 316, 317, 
318, 319, 320, 321, 322, 323, 324, 325, 326, 327, 
328, 329, 330, 331, 332, 333, 334, 335, 336, 337, 
338, 339, 340, 341, 342, 343, 344, 345, 346, 347, 
429, 430, 431, 432, 433, 434, 435, 436, 437, 438, 
439, 440, 441, 442, 443, 444, 445, 446, 447, 448, 
449, 450, 451, 452, 453, 454, 455, 456, 457, 458, 
459, 460, 461, 462, 463, 464, 465, 466, 467, 468, 
*NSET,NSET=SemiconductorL
1, 2, 3, 4, 31, 32, 33, 34, 35, 36, 
37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 
227, 228, 229, 230, 231, 232, 233, 234, 235, 236, 
237, 238, 239, 240, 241, 242, 243, 244, 245, 246, 
247, 248, 249, 250, 251, 252, 253, 254, 255, 256, 
257, 258, 259, 260, 261, 262, 263, 264, 265, 266, 
267, 268, 269, 270, 271, 272, 273, 274, 275, 276, 
277, 278, 279, 280, 281, 282, 283, 284, 285, 286, 
287, 288, 289, 290, 291, 292, 293, 294, 295, 296, 
297, 298, 299, 300, 301, 302, 303, 304, 305, 306, 
307, 
*NSET,NSET=SemiconductorR
7, 9, 11, 12, 86, 87, 88, 89, 90, 91, 
92, 93, 94, 106, 107, 108, 109, 110, 111, 112, 
113, 114, 115, 116, 117, 118, 119, 120, 121, 122, 
123, 124, 125, 126, 127, 128, 129, 130, 131, 132, 
348, 349, 350, 351, 352, 353, 354, 355, 356, 357, 
358, 359, 360, 361, 362, 363, 364, 365, 366, 367, 
368, 369, 370, 371, 372, 373, 374, 375, 376, 377, 
378, 379, 380, 381, 382, 383, 384, 385, 386, 387, 
388, 389, 390, 391, 392, 393, 394, 395, 396, 397, 
398, 399, 400, 401, 402, 403, 404, 405, 406, 407, 
408, 409, 410, 411, 412, 413, 414, 415, 416, 417, 
418, 419, 420, 421, 422, 423, 424, 425, 426, 427, 
428, 
*NSET,NSET=Ceramic
5, 6, 8, 10, 13, 14, 15, 16, 18, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 82, 
83, 95, 96, 97, 98, 99, 100, 101, 102, 103, 
137, 138, 139, 140, 141, 142, 143, 144, 145, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 160, 164, 
167, 168, 169, 170, 171, 172, 173, 174, 175, 176, 
177, 178, 179, 180, 181, 182, 183, 184, 185, 186, 
187, 188, 189, 190, 191, 192, 193, 194, 195, 196, 
197, 198, 199, 200, 201, 202, 203, 204, 205, 206, 
207, 208, 209, 210, 211, 212, 213, 214, 215, 216, 
217, 218, 219, 220, 221, 222, 223, 224, 225, 226, 
469, 470, 471, 472, 473, 474, 475, 476, 477, 478, 
479, 480, 481, 482, 483, 484, 485, 486, 487, 488, 
489, 490, 491, 492, 493, 494, 495, 496, 497, 498, 
499, 500, 501, 502, 503, 504, 505, 506, 507, 508, 
509, 510, 511, 512, 513, 514, 515, 516, 517, 518, 
519, 520, 521, 522, 523, 524, 525, 526, 527, 528, 
529, 530, 531, 532, 533, 534, 535, 536, 537, 538, 
539, 540, 541, 542, 543, 544, 545, 546, 547, 548, 
*NSET,NSET=Surface
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 417, 418, 419, 420, 
421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 443, 444, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 
461, 462, 463, 464, 465, 466, 467, 468, 469, 470, 
471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 
481, 482, 483, 484, 485, 486, 487, 488, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 
*NSET,NSET=TO
1, 2, 3, 4, 7, 9, 11, 12, 31, 32, 
33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 
43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 
53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 
63, 64, 65, 66, 86, 87, 88, 89, 90, 91, 
92, 93, 94, 106, 107, 108, 109, 110, 111, 112, 
113, 114, 115, 116, 117, 118, 119, 120, 121, 122, 
123, 124, 125, 126, 127, 128, 129, 130, 131, 132, 
227, 228, 229, 230, 231, 232, 233, 234, 235, 236, 
237, 238, 239, 240, 241, 242, 243, 244, 245, 246, 
247, 248, 249, 250, 251, 252, 253, 254, 255, 256, 
257, 258, 259, 260, 261, 262, 263, 264, 265, 266, 
267, 268, 269, 270, 271, 272, 273, 274, 275, 276, 
277, 278, 279, 280, 281, 282, 283, 284, 285, 286, 
287, 288, 289, 290, 291, 292, 293, 294, 295, 296, 
297, 298, 299, 300, 301, 302, 303, 304, 305, 306, 
307, 348, 349, 350, 351, 352, 353, 354, 355, 356, 
357, 358, 359, 360, 361, 362, 363, 364, 365, 366, 
367, 368, 369, 370, 371, 372, 373, 374, 375, 376, 
377, 378, 379, 380, 381, 382, 383, 384, 385, 386, 
387, 388, 389, 390, 391, 392, 393, 394, 395, 396, 
397, 398, 399, 400, 401, 402, 403, 404, 405, 406, 
407, 408, 409, 410, 411, 412, 413, 414, 415, 416, 
417, 418, 419, 420, 421, 422, 423, 424, 425, 426, 
427, 428, 
