*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Hex.inp
*NODE
1, 1, 0.1, 0
2, 0, 0.1, 0
3, 1, 0.1, 1
4, 0, 0.1, 1
5, 1, 0.9, 0
6, 0, 0.9, 0
7, 1, 0.9, 1
8, 0, 0.9, 1
9, 1.2, 0.9, 0
10, 2.2, 0.9, 0
11, 1.2, 0.9, 1
12, 2.2, 0.9, 1
13, 1.2, 0.1, 0
14, 2.2, 0.1, 0
15, 1.2, 0.1, 1
16, 2.2, 0.1, 1
17, 0, 0, 0
18, 1, 0, 0
19, 0, 0, 1
20, 1, 0, 1
21, -0.1, 0, 0
22, -0.1, 0, 1
23, 0, -0.2, 1
24, -0.1, -0.2, 1
25, 0, -0.2, 0
26, -0.1, -0.2, 0
27, 1, -0.2, 1
28, 1, -0.2, 0
29, 0, 1, 0
30, 1, 1, 0
31, 0, 1, 1
32, 1, 1, 1
33, 0, 1.2, 0
34, 1, 1.2, 0
35, 0, 1.2, 1
36, 1, 1.2, 1
37, 1.2, 1.2, 0
38, 1.2, 1, 0
39, 1.2, 1.2, 1
40, 1.2, 1, 1
41, 2.2, 1, 0
42, 2.2, 1, 1
43, 2.2, 1.2, 0
44, 2.2, 1.2, 1
45, 2.2, 9.251858538543e-18, 0
46, 1.2, 9.251858538543e-18, 0
47, 2.2, 9.251858538543e-18, 1
48, 1.2, 9.251858538543e-18, 1
49, 2.2, -0.2, 0
50, 1.2, -0.2, 0
51, 2.2, -0.2, 1
52, 1.2, -0.2, 1
53, 2.3, 9.251858538543e-18, 0
54, 2.3, -0.2, 0
55, 2.3, 9.251858538543e-18, 1
56, 2.3, -0.2, 1
57, 0.5, 0.1, 0
58, 0.5, 0.1, 1
59, 1, 0.1, 0.5
60, 0, 0.1, 0.5
61, 1, 0.5, 0
62, 0, 0.5, 0
63, 0.5, 0.9, 0
64, 1, 0.5, 1
65, 0, 0.5, 1
66, 0.5, 0.9, 1
67, 1, 0.9, 0.5
68, 0, 0.9, 0.5
69, 1.7, 0.9, 0
70, 1.7, 0.9, 1
71, 1.2, 0.9, 0.5
72, 2.2, 0.9, 0.5
73, 1.2, 0.5, 0
74, 2.2, 0.5, 0
75, 1.7, 0.1, 0
76, 1.2, 0.5, 1
77, 2.2, 0.5, 1
78, 1.7, 0.1, 1
79, 1.2, 0.1, 0.5
80, 2.2, 0.1, 0.5
81, 0.5, 0, 0
82, 0.5, 0, 1
83, 1, 0, 0.5
84, 0, 0, 0.5
85, -0.1, 0, 0.5
86, 0, -0.1, 1
87, -0.1, -0.1, 1
88, -0.1, -0.2, 0.5
89, 0, -0.2, 0.5
90, 0, -0.1, 0
91, -0.1, -0.1, 0
92, 1, -0.1, 1
93, 0.5, -0.2, 1
94, 0.5, -0.2, 0
95, 1, -0.2, 0.5
96, 1, -0.1, 0
97, 0.5, 1, 0
98, 0.5, 1, 1
99, 1, 1, 0.5
100, 0, 1, 0.5
101, 0, 1.1, 0
102, 0.5, 1.2, 0
103, 1, 1.1, 0
104, 0, 1.1, 1
105, 0.5, 1.2, 1
106, 1, 1.1, 1
107, 1, 1.2, 0.5
108, 0, 1.2, 0.5
109, 1.2, 1.1, 0
110, 1.2, 1.1, 1
111, 1.2, 1, 0.5
112, 1.2, 1.2, 0.5
113, 1.7, 1, 0
114, 1.7, 1, 1
115, 2.2, 1, 0.5
116, 1.7, 1.2, 0
117, 2.2, 1.1, 0
118, 1.7, 1.2, 1
119, 2.2, 1.1, 1
120, 2.2, 1.2, 0.5
121, 1.7, -2.7755575615629e-17, 0
122, 1.7, -2.7755575615629e-17, 1
123, 1.2, -2.7755575615629e-17, 0.5
124, 2.2, -2.7755575615629e-17, 0.5
125, 2.2, -0.1, 0
126, 1.7, -0.2, 0
127, 1.2, -0.1, 0
128, 2.2, -0.1, 1
129, 1.7, -0.2, 1
130, 1.2, -0.1, 1
131, 1.2, -0.2, 0.5
132, 2.2, -0.2, 0.5
133, 2.3, -0.1, 0
134, 2.3, -0.1, 1
135, 2.3, -2.7755575615629e-17, 0.5
136, 2.3, -0.2, 0.5
137, 0.5, 0.1, 0.5
138, 0.5, 0.5, 0
139, 0.5, 0.5, 1
140, 1, 0.5, 0.5
141, 0, 0.5, 0.5
142, 0.5, 0.9, 0.5
143, 1.7, 0.9, 0.5
144, 1.7, 0.5, 0
145, 1.7, 0.5, 1
146, 1.2, 0.5, 0.5
147, 2.2, 0.5, 0.5
148, 1.7, 0.1, 0.5
149, 0.5, 0, 0.5
150, 0, -0.1, 0.5
151, -0.1, -0.1, 0.5
152, 0.5, -0.1, 1
153, 0.5, -0.2, 0.5
154, 0.5, -0.1, 0
155, 1, -0.1, 0.5
156, 0.5, 1, 0.5
157, 0.5, 1.1, 0
158, 0.5, 1.1, 1
159, 1, 1.1, 0.5
160, 0, 1.1, 0.5
161, 0.5, 1.2, 0.5
162, 1.2, 1.1, 0.5
163, 1.7, 1, 0.5
164, 1.7, 1.1, 0
165, 1.7, 1.1, 1
166, 1.7, 1.2, 0.5
167, 2.2, 1.1, 0.5
168, 1.7, -2.7755575615629e-17, 0.5
169, 1.7, -0.1, 0
170, 1.7, -0.1, 1
171, 1.2, -0.1, 0.5
172, 2.2, -0.1, 0.5
173, 1.7, -0.2, 0.5
174, 2.3, -0.1, 0.5
175, 0.5, -0.1, 0.5
176, 0.5, 0.5, 0.5
177, 0.5, 1.1, 0.5
178, 1.7, 1.1, 0.5
179, 1.7, 0.5, 0.5
180, 1.7, -0.1, 0.5
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line67
57, 1, 57
58, 57, 2
*ELEMENT, type=T3D2, ELSET=Line70
59, 3, 58
60, 58, 4
*ELEMENT, type=T3D2, ELSET=Line71
61, 1, 59
62, 59, 3
*ELEMENT, type=T3D2, ELSET=Line72
63, 2, 60
64, 60, 4
*ELEMENT, type=T3D2, ELSET=Line73
65, 1, 61
66, 61, 5
*ELEMENT, type=T3D2, ELSET=Line74
67, 2, 62
68, 62, 6
*ELEMENT, type=T3D2, ELSET=Line75
69, 5, 63
70, 63, 6
*ELEMENT, type=T3D2, ELSET=Line76
71, 3, 64
72, 64, 7
*ELEMENT, type=T3D2, ELSET=Line77
73, 4, 65
74, 65, 8
*ELEMENT, type=T3D2, ELSET=Line78
75, 7, 66
76, 66, 8
*ELEMENT, type=T3D2, ELSET=Line79
77, 5, 67
78, 67, 7
*ELEMENT, type=T3D2, ELSET=Line80
79, 6, 68
80, 68, 8
*ELEMENT, type=T3D2, ELSET=Line115
81, 9, 69
82, 69, 10
*ELEMENT, type=T3D2, ELSET=Line118
83, 11, 70
84, 70, 12
*ELEMENT, type=T3D2, ELSET=Line119
85, 9, 71
86, 71, 11
*ELEMENT, type=T3D2, ELSET=Line120
87, 10, 72
88, 72, 12
*ELEMENT, type=T3D2, ELSET=Line121
89, 9, 73
90, 73, 13
*ELEMENT, type=T3D2, ELSET=Line122
91, 10, 74
92, 74, 14
*ELEMENT, type=T3D2, ELSET=Line123
93, 13, 75
94, 75, 14
*ELEMENT, type=T3D2, ELSET=Line124
95, 11, 76
96, 76, 15
*ELEMENT, type=T3D2, ELSET=Line125
97, 12, 77
98, 77, 16
*ELEMENT, type=T3D2, ELSET=Line126
99, 15, 78
100, 78, 16
*ELEMENT, type=T3D2, ELSET=Line127
101, 13, 79
102, 79, 15
*ELEMENT, type=T3D2, ELSET=Line128
103, 14, 80
104, 80, 16
*ELEMENT, type=T3D2, ELSET=Line129
105, 17, 2
*ELEMENT, type=T3D2, ELSET=Line130
106, 18, 1
*ELEMENT, type=T3D2, ELSET=Line131
107, 18, 81
108, 81, 17
*ELEMENT, type=T3D2, ELSET=Line132
109, 19, 4
*ELEMENT, type=T3D2, ELSET=Line133
110, 20, 3
*ELEMENT, type=T3D2, ELSET=Line134
111, 20, 82
112, 82, 19
*ELEMENT, type=T3D2, ELSET=Line135
113, 18, 83
114, 83, 20
*ELEMENT, type=T3D2, ELSET=Line136
115, 17, 84
116, 84, 19
*ELEMENT, type=T3D2, ELSET=Line137
117, 21, 85
118, 85, 22
*ELEMENT, type=T3D2, ELSET=Line138
119, 22, 19
*ELEMENT, type=T3D2, ELSET=Line139
120, 21, 17
*ELEMENT, type=T3D2, ELSET=Line140
121, 19, 86
122, 86, 23
*ELEMENT, type=T3D2, ELSET=Line141
123, 23, 24
*ELEMENT, type=T3D2, ELSET=Line142
124, 24, 87
125, 87, 22
*ELEMENT, type=T3D2, ELSET=Line143
126, 25, 26
*ELEMENT, type=T3D2, ELSET=Line144
127, 26, 88
128, 88, 24
*ELEMENT, type=T3D2, ELSET=Line145
129, 25, 89
130, 89, 23
*ELEMENT, type=T3D2, ELSET=Line146
131, 17, 90
132, 90, 25
*ELEMENT, type=T3D2, ELSET=Line147
133, 26, 91
134, 91, 21
*ELEMENT, type=T3D2, ELSET=Line148
135, 20, 92
136, 92, 27
*ELEMENT, type=T3D2, ELSET=Line149
137, 27, 93
138, 93, 23
*ELEMENT, type=T3D2, ELSET=Line150
139, 28, 94
140, 94, 25
*ELEMENT, type=T3D2, ELSET=Line151
141, 28, 95
142, 95, 27
*ELEMENT, type=T3D2, ELSET=Line152
143, 18, 96
144, 96, 28
*ELEMENT, type=T3D2, ELSET=Line153
145, 6, 29
*ELEMENT, type=T3D2, ELSET=Line154
146, 30, 97
147, 97, 29
*ELEMENT, type=T3D2, ELSET=Line155
148, 30, 5
*ELEMENT, type=T3D2, ELSET=Line156
149, 8, 31
*ELEMENT, type=T3D2, ELSET=Line157
150, 32, 98
151, 98, 31
*ELEMENT, type=T3D2, ELSET=Line158
152, 32, 7
*ELEMENT, type=T3D2, ELSET=Line159
153, 30, 99
154, 99, 32
*ELEMENT, type=T3D2, ELSET=Line160
155, 29, 100
156, 100, 31
*ELEMENT, type=T3D2, ELSET=Line161
157, 29, 101
158, 101, 33
*ELEMENT, type=T3D2, ELSET=Line162
159, 33, 102
160, 102, 34
*ELEMENT, type=T3D2, ELSET=Line163
161, 30, 103
162, 103, 34
*ELEMENT, type=T3D2, ELSET=Line164
163, 31, 104
164, 104, 35
*ELEMENT, type=T3D2, ELSET=Line165
165, 35, 105
166, 105, 36
*ELEMENT, type=T3D2, ELSET=Line166
167, 32, 106
168, 106, 36
*ELEMENT, type=T3D2, ELSET=Line167
169, 34, 107
170, 107, 36
*ELEMENT, type=T3D2, ELSET=Line168
171, 33, 108
172, 108, 35
*ELEMENT, type=T3D2, ELSET=Line169
173, 34, 37
*ELEMENT, type=T3D2, ELSET=Line170
174, 38, 109
175, 109, 37
*ELEMENT, type=T3D2, ELSET=Line171
176, 38, 30
*ELEMENT, type=T3D2, ELSET=Line172
177, 36, 39
*ELEMENT, type=T3D2, ELSET=Line173
178, 40, 110
179, 110, 39
*ELEMENT, type=T3D2, ELSET=Line174
180, 40, 32
*ELEMENT, type=T3D2, ELSET=Line175
181, 38, 111
182, 111, 40
*ELEMENT, type=T3D2, ELSET=Line176
183, 37, 112
184, 112, 39
*ELEMENT, type=T3D2, ELSET=Line177
185, 38, 113
186, 113, 41
*ELEMENT, type=T3D2, ELSET=Line178
187, 41, 10
*ELEMENT, type=T3D2, ELSET=Line179
188, 9, 38
*ELEMENT, type=T3D2, ELSET=Line180
189, 40, 114
190, 114, 42
*ELEMENT, type=T3D2, ELSET=Line181
191, 42, 12
*ELEMENT, type=T3D2, ELSET=Line182
192, 11, 40
*ELEMENT, type=T3D2, ELSET=Line183
193, 41, 115
194, 115, 42
*ELEMENT, type=T3D2, ELSET=Line184
195, 37, 116
196, 116, 43
*ELEMENT, type=T3D2, ELSET=Line185
197, 43, 117
198, 117, 41
*ELEMENT, type=T3D2, ELSET=Line186
199, 39, 118
200, 118, 44
*ELEMENT, type=T3D2, ELSET=Line187
201, 44, 119
202, 119, 42
*ELEMENT, type=T3D2, ELSET=Line188
203, 43, 120
204, 120, 44
*ELEMENT, type=T3D2, ELSET=Line189
205, 14, 45
*ELEMENT, type=T3D2, ELSET=Line190
206, 46, 121
207, 121, 45
*ELEMENT, type=T3D2, ELSET=Line191
208, 46, 13
*ELEMENT, type=T3D2, ELSET=Line192
209, 16, 47
*ELEMENT, type=T3D2, ELSET=Line193
210, 48, 122
211, 122, 47
*ELEMENT, type=T3D2, ELSET=Line194
212, 48, 15
*ELEMENT, type=T3D2, ELSET=Line195
213, 46, 123
214, 123, 48
*ELEMENT, type=T3D2, ELSET=Line196
215, 45, 124
216, 124, 47
*ELEMENT, type=T3D2, ELSET=Line197
217, 45, 125
218, 125, 49
*ELEMENT, type=T3D2, ELSET=Line198
219, 49, 126
220, 126, 50
*ELEMENT, type=T3D2, ELSET=Line199
221, 50, 127
222, 127, 46
*ELEMENT, type=T3D2, ELSET=Line200
223, 47, 128
224, 128, 51
*ELEMENT, type=T3D2, ELSET=Line201
225, 51, 129
226, 129, 52
*ELEMENT, type=T3D2, ELSET=Line202
227, 52, 130
228, 130, 48
*ELEMENT, type=T3D2, ELSET=Line203
229, 50, 131
230, 131, 52
*ELEMENT, type=T3D2, ELSET=Line204
231, 49, 132
232, 132, 51
*ELEMENT, type=T3D2, ELSET=Line205
233, 45, 53
*ELEMENT, type=T3D2, ELSET=Line206
234, 53, 133
235, 133, 54
*ELEMENT, type=T3D2, ELSET=Line207
236, 54, 49
*ELEMENT, type=T3D2, ELSET=Line208
237, 47, 55
*ELEMENT, type=T3D2, ELSET=Line209
238, 55, 134
239, 134, 56
*ELEMENT, type=T3D2, ELSET=Line210
240, 56, 51
*ELEMENT, type=T3D2, ELSET=Line211
241, 53, 135
242, 135, 55
*ELEMENT, type=T3D2, ELSET=Line212
243, 54, 136
244, 136, 56
*ELEMENT, type=CPS4, ELSET=Surface33
245, 1, 57, 137, 59
246, 57, 2, 60, 137
247, 59, 137, 58, 3
248, 137, 60, 4, 58
*ELEMENT, type=CPS4, ELSET=Surface34
249, 1, 57, 138, 61
250, 61, 138, 63, 5
251, 57, 2, 62, 138
252, 138, 62, 6, 63
*ELEMENT, type=CPS4, ELSET=Surface35
253, 3, 64, 139, 58
254, 64, 7, 66, 139
255, 58, 139, 65, 4
256, 139, 66, 8, 65
*ELEMENT, type=CPS4, ELSET=Surface36
257, 1, 61, 140, 59
258, 61, 5, 67, 140
259, 59, 140, 64, 3
260, 140, 67, 7, 64
*ELEMENT, type=CPS4, ELSET=Surface37
261, 2, 60, 141, 62
262, 62, 141, 68, 6
263, 60, 4, 65, 141
264, 141, 65, 8, 68
*ELEMENT, type=CPS4, ELSET=Surface38
265, 5, 63, 142, 67
266, 63, 6, 68, 142
267, 67, 142, 66, 7
268, 142, 68, 8, 66
*ELEMENT, type=CPS4, ELSET=Surface63
269, 9, 69, 143, 71
270, 69, 10, 72, 143
271, 71, 143, 70, 11
272, 143, 72, 12, 70
*ELEMENT, type=CPS4, ELSET=Surface64
273, 9, 69, 144, 73
274, 73, 144, 75, 13
275, 69, 10, 74, 144
276, 144, 74, 14, 75
*ELEMENT, type=CPS4, ELSET=Surface65
277, 11, 76, 145, 70
278, 76, 15, 78, 145
279, 70, 145, 77, 12
280, 145, 78, 16, 77
*ELEMENT, type=CPS4, ELSET=Surface66
281, 9, 73, 146, 71
282, 73, 13, 79, 146
283, 71, 146, 76, 11
284, 146, 79, 15, 76
*ELEMENT, type=CPS4, ELSET=Surface67
285, 10, 72, 147, 74
286, 74, 147, 80, 14
287, 72, 12, 77, 147
288, 147, 77, 16, 80
*ELEMENT, type=CPS4, ELSET=Surface68
289, 13, 75, 148, 79
290, 75, 14, 80, 148
291, 79, 148, 78, 15
292, 148, 80, 16, 78
*ELEMENT, type=CPS4, ELSET=Surface69
293, 18, 81, 57, 1
294, 81, 17, 2, 57
*ELEMENT, type=CPS4, ELSET=Surface70
295, 20, 3, 58, 82
296, 82, 58, 4, 19
*ELEMENT, type=CPS4, ELSET=Surface71
297, 18, 1, 59, 83
298, 83, 59, 3, 20
*ELEMENT, type=CPS4, ELSET=Surface72
299, 17, 84, 60, 2
300, 84, 19, 4, 60
*ELEMENT, type=CPS4, ELSET=Surface73
301, 18, 83, 149, 81
302, 81, 149, 84, 17
303, 83, 20, 82, 149
304, 149, 82, 19, 84
*ELEMENT, type=CPS4, ELSET=Surface74
305, 17, 21, 85, 84
306, 84, 85, 22, 19
*ELEMENT, type=CPS4, ELSET=Surface75
307, 19, 22, 87, 86
308, 86, 87, 24, 23
*ELEMENT, type=CPS4, ELSET=Surface76
309, 25, 89, 88, 26
310, 89, 23, 24, 88
*ELEMENT, type=CPS4, ELSET=Surface77
311, 17, 90, 91, 21
312, 90, 25, 26, 91
*ELEMENT, type=CPS4, ELSET=Surface78
313, 17, 84, 150, 90
314, 90, 150, 89, 25
315, 84, 19, 86, 150
316, 150, 86, 23, 89
*ELEMENT, type=CPS4, ELSET=Surface79
317, 26, 88, 151, 91
318, 91, 151, 85, 21
319, 88, 24, 87, 151
320, 151, 87, 22, 85
*ELEMENT, type=CPS4, ELSET=Surface80
321, 20, 82, 152, 92
322, 82, 19, 86, 152
323, 92, 152, 93, 27
324, 152, 86, 23, 93
*ELEMENT, type=CPS4, ELSET=Surface81
325, 28, 95, 153, 94
326, 94, 153, 89, 25
327, 95, 27, 93, 153
328, 153, 93, 23, 89
*ELEMENT, type=CPS4, ELSET=Surface82
329, 18, 96, 154, 81
330, 81, 154, 90, 17
331, 96, 28, 94, 154
332, 154, 94, 25, 90
*ELEMENT, type=CPS4, ELSET=Surface83
333, 18, 83, 155, 96
334, 96, 155, 95, 28
335, 83, 20, 92, 155
336, 155, 92, 27, 95
*ELEMENT, type=CPS4, ELSET=Surface84
337, 5, 63, 97, 30
338, 63, 6, 29, 97
*ELEMENT, type=CPS4, ELSET=Surface85
339, 7, 32, 98, 66
340, 66, 98, 31, 8
*ELEMENT, type=CPS4, ELSET=Surface86
341, 5, 30, 99, 67
342, 67, 99, 32, 7
*ELEMENT, type=CPS4, ELSET=Surface87
343, 6, 68, 100, 29
344, 68, 8, 31, 100
*ELEMENT, type=CPS4, ELSET=Surface88
345, 30, 97, 156, 99
346, 97, 29, 100, 156
347, 99, 156, 98, 32
348, 156, 100, 31, 98
*ELEMENT, type=CPS4, ELSET=Surface89
349, 30, 97, 157, 103
350, 103, 157, 102, 34
351, 97, 29, 101, 157
352, 157, 101, 33, 102
*ELEMENT, type=CPS4, ELSET=Surface90
353, 32, 106, 158, 98
354, 106, 36, 105, 158
355, 98, 158, 104, 31
356, 158, 105, 35, 104
*ELEMENT, type=CPS4, ELSET=Surface91
357, 30, 103, 159, 99
358, 103, 34, 107, 159
359, 99, 159, 106, 32
360, 159, 107, 36, 106
*ELEMENT, type=CPS4, ELSET=Surface92
361, 29, 100, 160, 101
362, 101, 160, 108, 33
363, 100, 31, 104, 160
364, 160, 104, 35, 108
*ELEMENT, type=CPS4, ELSET=Surface93
365, 34, 102, 161, 107
366, 102, 33, 108, 161
367, 107, 161, 105, 36
368, 161, 108, 35, 105
*ELEMENT, type=CPS4, ELSET=Surface94
369, 30, 103, 109, 38
370, 103, 34, 37, 109
*ELEMENT, type=CPS4, ELSET=Surface95
371, 32, 40, 110, 106
372, 106, 110, 39, 36
*ELEMENT, type=CPS4, ELSET=Surface96
373, 30, 38, 111, 99
374, 99, 111, 40, 32
*ELEMENT, type=CPS4, ELSET=Surface97
375, 34, 107, 112, 37
376, 107, 36, 39, 112
*ELEMENT, type=CPS4, ELSET=Surface98
377, 38, 109, 162, 111
378, 109, 37, 112, 162
379, 111, 162, 110, 40
380, 162, 112, 39, 110
*ELEMENT, type=CPS4, ELSET=Surface99
381, 38, 113, 69, 9
382, 113, 41, 10, 69
*ELEMENT, type=CPS4, ELSET=Surface100
383, 40, 11, 70, 114
384, 114, 70, 12, 42
*ELEMENT, type=CPS4, ELSET=Surface101
385, 38, 9, 71, 111
386, 111, 71, 11, 40
*ELEMENT, type=CPS4, ELSET=Surface102
387, 41, 115, 72, 10
388, 115, 42, 12, 72
*ELEMENT, type=CPS4, ELSET=Surface103
389, 38, 111, 163, 113
390, 113, 163, 115, 41
391, 111, 40, 114, 163
392, 163, 114, 42, 115
*ELEMENT, type=CPS4, ELSET=Surface104
393, 38, 109, 164, 113
394, 113, 164, 117, 41
395, 109, 37, 116, 164
396, 164, 116, 43, 117
*ELEMENT, type=CPS4, ELSET=Surface105
397, 40, 114, 165, 110
398, 114, 42, 119, 165
399, 110, 165, 118, 39
400, 165, 119, 44, 118
*ELEMENT, type=CPS4, ELSET=Surface106
401, 37, 112, 166, 116
402, 116, 166, 120, 43
403, 112, 39, 118, 166
404, 166, 118, 44, 120
*ELEMENT, type=CPS4, ELSET=Surface107
405, 41, 117, 167, 115
406, 117, 43, 120, 167
407, 115, 167, 119, 42
408, 167, 120, 44, 119
*ELEMENT, type=CPS4, ELSET=Surface108
409, 13, 75, 121, 46
410, 75, 14, 45, 121
*ELEMENT, type=CPS4, ELSET=Surface109
411, 15, 48, 122, 78
412, 78, 122, 47, 16
*ELEMENT, type=CPS4, ELSET=Surface110
413, 13, 46, 123, 79
414, 79, 123, 48, 15
*ELEMENT, type=CPS4, ELSET=Surface111
415, 14, 80, 124, 45
416, 80, 16, 47, 124
*ELEMENT, type=CPS4, ELSET=Surface112
417, 46, 121, 168, 123
418, 121, 45, 124, 168
419, 123, 168, 122, 48
420, 168, 124, 47, 122
*ELEMENT, type=CPS4, ELSET=Surface113
421, 46, 121, 169, 127
422, 127, 169, 126, 50
423, 121, 45, 125, 169
424, 169, 125, 49, 126
*ELEMENT, type=CPS4, ELSET=Surface114
425, 48, 130, 170, 122
426, 130, 52, 129, 170
427, 122, 170, 128, 47
428, 170, 129, 51, 128
*ELEMENT, type=CPS4, ELSET=Surface115
429, 46, 127, 171, 123
430, 127, 50, 131, 171
431, 123, 171, 130, 48
432, 171, 131, 52, 130
*ELEMENT, type=CPS4, ELSET=Surface116
433, 45, 124, 172, 125
434, 125, 172, 132, 49
435, 124, 47, 128, 172
436, 172, 128, 51, 132
*ELEMENT, type=CPS4, ELSET=Surface117
437, 50, 126, 173, 131
438, 126, 49, 132, 173
439, 131, 173, 129, 52
440, 173, 132, 51, 129
*ELEMENT, type=CPS4, ELSET=Surface118
441, 45, 53, 133, 125
442, 125, 133, 54, 49
*ELEMENT, type=CPS4, ELSET=Surface119
443, 47, 128, 134, 55
444, 128, 51, 56, 134
*ELEMENT, type=CPS4, ELSET=Surface120
445, 45, 124, 135, 53
446, 124, 47, 55, 135
*ELEMENT, type=CPS4, ELSET=Surface121
447, 49, 54, 136, 132
448, 132, 136, 56, 51
*ELEMENT, type=CPS4, ELSET=Surface122
449, 53, 135, 174, 133
450, 133, 174, 136, 54
451, 135, 55, 134, 174
452, 174, 134, 56, 136
*ELEMENT, type=C3D8, ELSET=Volume2
453, 155, 83, 18, 96, 175, 149, 81, 154
454, 175, 149, 81, 154, 150, 84, 17, 90
455, 95, 155, 96, 28, 153, 175, 154, 94
456, 153, 175, 154, 94, 89, 150, 90, 25
457, 92, 20, 83, 155, 152, 82, 149, 175
458, 152, 82, 149, 175, 86, 19, 84, 150
459, 27, 92, 155, 95, 93, 152, 175, 153
460, 93, 152, 175, 153, 23, 86, 150, 89
*ELEMENT, type=C3D8, ELSET=Volume3
461, 150, 84, 17, 90, 151, 85, 21, 91
462, 89, 150, 90, 25, 88, 151, 91, 26
463, 86, 19, 84, 150, 87, 22, 85, 151
464, 23, 86, 150, 89, 24, 87, 151, 88
*ELEMENT, type=C3D8, ELSET=Volume4
465, 149, 83, 18, 81, 137, 59, 1, 57
466, 84, 149, 81, 17, 60, 137, 57, 2
467, 82, 20, 83, 149, 58, 3, 59, 137
468, 19, 82, 149, 84, 4, 58, 137, 60
*ELEMENT, type=C3D8, ELSET=Volume5
469, 1, 57, 137, 59, 61, 138, 176, 140
470, 61, 138, 176, 140, 5, 63, 142, 67
471, 57, 2, 60, 137, 138, 62, 141, 176
472, 138, 62, 141, 176, 63, 6, 68, 142
473, 59, 137, 58, 3, 140, 176, 139, 64
474, 140, 176, 139, 64, 67, 142, 66, 7
475, 137, 60, 4, 58, 176, 141, 65, 139
476, 176, 141, 65, 139, 142, 68, 8, 66
*ELEMENT, type=C3D8, ELSET=Volume6
477, 5, 63, 142, 67, 30, 97, 156, 99
478, 63, 6, 68, 142, 97, 29, 100, 156
479, 67, 142, 66, 7, 99, 156, 98, 32
480, 142, 68, 8, 66, 156, 100, 31, 98
*ELEMENT, type=C3D8, ELSET=Volume7
481, 30, 97, 156, 99, 103, 157, 177, 159
482, 103, 157, 177, 159, 34, 102, 161, 107
483, 97, 29, 100, 156, 157, 101, 160, 177
484, 157, 101, 160, 177, 102, 33, 108, 161
485, 99, 156, 98, 32, 159, 177, 158, 106
486, 159, 177, 158, 106, 107, 161, 105, 36
487, 156, 100, 31, 98, 177, 160, 104, 158
488, 177, 160, 104, 158, 161, 108, 35, 105
*ELEMENT, type=C3D8, ELSET=Volume8
489, 30, 103, 159, 99, 38, 109, 162, 111
490, 103, 34, 107, 159, 109, 37, 112, 162
491, 99, 159, 106, 32, 111, 162, 110, 40
492, 159, 107, 36, 106, 162, 112, 39, 110
*ELEMENT, type=C3D8, ELSET=Volume9
493, 38, 109, 162, 111, 113, 164, 178, 163
494, 113, 164, 178, 163, 41, 117, 167, 115
495, 109, 37, 112, 162, 164, 116, 166, 178
496, 164, 116, 166, 178, 117, 43, 120, 167
497, 111, 162, 110, 40, 163, 178, 165, 114
498, 163, 178, 165, 114, 115, 167, 119, 42
499, 162, 112, 39, 110, 178, 166, 118, 165
500, 178, 166, 118, 165, 167, 120, 44, 119
*ELEMENT, type=C3D8, ELSET=Volume10
501, 163, 111, 38, 113, 143, 71, 9, 69
502, 115, 163, 113, 41, 72, 143, 69, 10
503, 114, 40, 111, 163, 70, 11, 71, 143
504, 42, 114, 163, 115, 12, 70, 143, 72
*ELEMENT, type=C3D8, ELSET=Volume11
505, 9, 69, 143, 71, 73, 144, 179, 146
506, 73, 144, 179, 146, 13, 75, 148, 79
507, 69, 10, 72, 143, 144, 74, 147, 179
508, 144, 74, 147, 179, 75, 14, 80, 148
509, 71, 143, 70, 11, 146, 179, 145, 76
510, 146, 179, 145, 76, 79, 148, 78, 15
511, 143, 72, 12, 70, 179, 147, 77, 145
512, 179, 147, 77, 145, 148, 80, 16, 78
*ELEMENT, type=C3D8, ELSET=Volume12
513, 13, 75, 148, 79, 46, 121, 168, 123
514, 75, 14, 80, 148, 121, 45, 124, 168
515, 79, 148, 78, 15, 123, 168, 122, 48
516, 148, 80, 16, 78, 168, 124, 47, 122
*ELEMENT, type=C3D8, ELSET=Volume13
517, 46, 121, 168, 123, 127, 169, 180, 171
518, 127, 169, 180, 171, 50, 126, 173, 131
519, 121, 45, 124, 168, 169, 125, 172, 180
520, 169, 125, 172, 180, 126, 49, 132, 173
521, 123, 168, 122, 48, 171, 180, 170, 130
522, 171, 180, 170, 130, 131, 173, 129, 52
523, 168, 124, 47, 122, 180, 172, 128, 170
524, 180, 172, 128, 170, 173, 132, 51, 129
*ELEMENT, type=C3D8, ELSET=Volume14
525, 45, 124, 172, 125, 53, 135, 174, 133
526, 125, 172, 132, 49, 133, 174, 136, 54
527, 124, 47, 128, 172, 135, 55, 134, 174
528, 172, 128, 51, 132, 174, 134, 56, 136
*ELSET,ELSET=ElectrodeMinX
317, 318, 319, 320, 
*ELSET,ELSET=ElectrodeMaxX
449, 450, 451, 452, 
*ELSET,ELSET=HeatSink
325, 326, 327, 328, 437, 438, 439, 440, 
*ELSET,ELSET=Qin
365, 366, 367, 368, 375, 376, 401, 402, 403, 404, 
*ELSET,ELSET=Force
361, 362, 363, 364, 
*ELSET,ELSET=Volume
453, 454, 455, 456, 457, 458, 459, 460, 461, 462, 
463, 464, 465, 466, 467, 468, 469, 470, 471, 472, 
473, 474, 475, 476, 477, 478, 479, 480, 481, 482, 
483, 484, 485, 486, 487, 488, 489, 490, 491, 492, 
493, 494, 495, 496, 497, 498, 499, 500, 501, 502, 
503, 504, 505, 506, 507, 508, 509, 510, 511, 512, 
513, 514, 515, 516, 517, 518, 519, 520, 521, 522, 
523, 524, 525, 526, 527, 528, 
*ELSET,ELSET=TO
469, 470, 471, 472, 473, 474, 475, 476, 505, 506, 
507, 508, 509, 510, 511, 512, 
*ELSET,ELSET=SemiconductorN-
469, 470, 471, 472, 473, 474, 475, 476, 
*ELSET,ELSET=SemiconductorP+
505, 506, 507, 508, 509, 510, 511, 512, 
*ELSET,ELSET=Copper
453, 454, 455, 456, 457, 458, 459, 460, 461, 462, 
463, 464, 481, 482, 483, 484, 485, 486, 487, 488, 
489, 490, 491, 492, 493, 494, 495, 496, 497, 498, 
499, 500, 517, 518, 519, 520, 521, 522, 523, 524, 
525, 526, 527, 528, 
*ELSET,ELSET=Solder
465, 466, 467, 468, 477, 478, 479, 480, 501, 502, 
503, 504, 513, 514, 515, 516, 
*NSET,NSET=ElectrodeMinX
21, 22, 24, 26, 85, 87, 88, 91, 151, 
*NSET,NSET=ElectrodeMaxX
53, 54, 55, 56, 133, 134, 135, 136, 174, 
*NSET,NSET=HeatSink
23, 25, 27, 28, 49, 50, 51, 52, 89, 93, 
94, 95, 126, 129, 131, 132, 153, 173, 
*NSET,NSET=Qin
33, 34, 35, 36, 37, 39, 43, 44, 102, 105, 
107, 108, 112, 116, 118, 120, 161, 166, 
*NSET,NSET=Force
29, 31, 33, 35, 100, 101, 104, 108, 160, 
*NSET,NSET=Volume
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
*NSET,NSET=TO
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
137, 138, 139, 140, 141, 142, 143, 144, 145, 146, 
147, 148, 176, 179, 
*NSET,NSET=SemiconductorN-
1, 2, 3, 4, 5, 6, 7, 8, 57, 58, 
59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 
137, 138, 139, 140, 141, 142, 176, 
*NSET,NSET=SemiconductorP+
9, 10, 11, 12, 13, 14, 15, 16, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
143, 144, 145, 146, 147, 148, 179, 
*NSET,NSET=Copper
17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 
27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 
37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 149, 150, 151, 152, 
153, 154, 155, 156, 157, 158, 159, 160, 161, 162, 
163, 164, 165, 166, 167, 168, 169, 170, 171, 172, 
173, 174, 175, 177, 178, 180, 
*NSET,NSET=Solder
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
29, 30, 31, 32, 38, 40, 41, 42, 45, 46, 
47, 48, 57, 58, 59, 60, 63, 66, 67, 68, 
69, 70, 71, 72, 75, 78, 79, 80, 81, 82, 
83, 84, 97, 98, 99, 100, 111, 113, 114, 115, 
121, 122, 123, 124, 137, 142, 143, 148, 149, 156, 
163, 168, 
