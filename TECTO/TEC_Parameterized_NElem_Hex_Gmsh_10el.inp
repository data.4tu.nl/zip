8240, 21230, 21253, 21506, 21483, 21231, 21254, 21507, 21484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8241, 21231, 21254, 21507, 21484, 4920, 4921, 4932, 4931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8242, 3104, 280, 281, 3115, 21232, 4177, 4200, 21485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8243, 21232, 4177, 4200, 21485, 21233, 4178, 4201, 21486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8244, 21233, 4178, 4201, 21486, 21234, 4179, 4202, 21487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8245, 21234, 4179, 4202, 21487, 21235, 4180, 4203, 21488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8246, 21235, 4180, 4203, 21488, 21236, 4181, 4204, 21489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8247, 21236, 4181, 4204, 21489, 21237, 4182, 4205, 21490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8248, 21237, 4182, 4205, 21490, 21238, 4183, 4206, 21491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8249, 21238, 4183, 4206, 21491, 21239, 4184, 4207, 21492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8250, 21239, 4184, 4207, 21492, 21240, 4185, 4208, 21493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8251, 21240, 4185, 4208, 21493, 21241, 4186, 4209, 21494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8252, 21241, 4186, 4209, 21494, 21242, 4187, 4210, 21495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8253, 21242, 4187, 4210, 21495, 21243, 4188, 4211, 21496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8254, 21243, 4188, 4211, 21496, 21244, 4189, 4212, 21497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8255, 21244, 4189, 4212, 21497, 21245, 4190, 4213, 21498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8256, 21245, 4190, 4213, 21498, 21246, 4191, 4214, 21499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8257, 21246, 4191, 4214, 21499, 21247, 4192, 4215, 21500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8258, 21247, 4192, 4215, 21500, 21248, 4193, 4216, 21501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8259, 21248, 4193, 4216, 21501, 21249, 4194, 4217, 21502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8260, 21249, 4194, 4217, 21502, 21250, 4195, 4218, 21503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8261, 21250, 4195, 4218, 21503, 21251, 4196, 4219, 21504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8262, 21251, 4196, 4219, 21504, 21252, 4197, 4220, 21505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8263, 21252, 4197, 4220, 21505, 21253, 4198, 4221, 21506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8264, 21253, 4198, 4221, 21506, 21254, 4199, 4222, 21507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8265, 21254, 4199, 4222, 21507, 4921, 440, 441, 4932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8266, 247, 3105, 3116, 248, 3418, 21255, 21508, 3441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8267, 3418, 21255, 21508, 3441, 3419, 21256, 21509, 3442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8268, 3419, 21256, 21509, 3442, 3420, 21257, 21510, 3443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8269, 3420, 21257, 21510, 3443, 3421, 21258, 21511, 3444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8270, 3421, 21258, 21511, 3444, 3422, 21259, 21512, 3445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8271, 3422, 21259, 21512, 3445, 3423, 21260, 21513, 3446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8272, 3423, 21260, 21513, 3446, 3424, 21261, 21514, 3447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8273, 3424, 21261, 21514, 3447, 3425, 21262, 21515, 3448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8274, 3425, 21262, 21515, 3448, 3426, 21263, 21516, 3449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8275, 3426, 21263, 21516, 3449, 3427, 21264, 21517, 3450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8276, 3427, 21264, 21517, 3450, 3428, 21265, 21518, 3451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8277, 3428, 21265, 21518, 3451, 3429, 21266, 21519, 3452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8278, 3429, 21266, 21519, 3452, 3430, 21267, 21520, 3453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8279, 3430, 21267, 21520, 3453, 3431, 21268, 21521, 3454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8280, 3431, 21268, 21521, 3454, 3432, 21269, 21522, 3455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8281, 3432, 21269, 21522, 3455, 3433, 21270, 21523, 3456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8282, 3433, 21270, 21523, 3456, 3434, 21271, 21524, 3457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8283, 3434, 21271, 21524, 3457, 3435, 21272, 21525, 3458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8284, 3435, 21272, 21525, 3458, 3436, 21273, 21526, 3459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8285, 3436, 21273, 21526, 3459, 3437, 21274, 21527, 3460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8286, 3437, 21274, 21527, 3460, 3438, 21275, 21528, 3461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8287, 3438, 21275, 21528, 3461, 3439, 21276, 21529, 3462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8288, 3439, 21276, 21529, 3462, 3440, 21277, 21530, 3463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8289, 3440, 21277, 21530, 3463, 361, 4922, 4933, 362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8290, 3105, 3106, 3117, 3116, 21255, 21278, 21531, 21508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8291, 21255, 21278, 21531, 21508, 21256, 21279, 21532, 21509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8292, 21256, 21279, 21532, 21509, 21257, 21280, 21533, 21510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8293, 21257, 21280, 21533, 21510, 21258, 21281, 21534, 21511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8294, 21258, 21281, 21534, 21511, 21259, 21282, 21535, 21512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8295, 21259, 21282, 21535, 21512, 21260, 21283, 21536, 21513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8296, 21260, 21283, 21536, 21513, 21261, 21284, 21537, 21514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8297, 21261, 21284, 21537, 21514, 21262, 21285, 21538, 21515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8298, 21262, 21285, 21538, 21515, 21263, 21286, 21539, 21516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8299, 21263, 21286, 21539, 21516, 21264, 21287, 21540, 21517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8300, 21264, 21287, 21540, 21517, 21265, 21288, 21541, 21518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8301, 21265, 21288, 21541, 21518, 21266, 21289, 21542, 21519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8302, 21266, 21289, 21542, 21519, 21267, 21290, 21543, 21520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8303, 21267, 21290, 21543, 21520, 21268, 21291, 21544, 21521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8304, 21268, 21291, 21544, 21521, 21269, 21292, 21545, 21522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8305, 21269, 21292, 21545, 21522, 21270, 21293, 21546, 21523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8306, 21270, 21293, 21546, 21523, 21271, 21294, 21547, 21524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8307, 21271, 21294, 21547, 21524, 21272, 21295, 21548, 21525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8308, 21272, 21295, 21548, 21525, 21273, 21296, 21549, 21526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8309, 21273, 21296, 21549, 21526, 21274, 21297, 21550, 21527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8310, 21274, 21297, 21550, 21527, 21275, 21298, 21551, 21528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8311, 21275, 21298, 21551, 21528, 21276, 21299, 21552, 21529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8312, 21276, 21299, 21552, 21529, 21277, 21300, 21553, 21530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8313, 21277, 21300, 21553, 21530, 4922, 4923, 4934, 4933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8314, 3106, 3107, 3118, 3117, 21278, 21301, 21554, 21531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8315, 21278, 21301, 21554, 21531, 21279, 21302, 21555, 21532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8316, 21279, 21302, 21555, 21532, 21280, 21303, 21556, 21533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8317, 21280, 21303, 21556, 21533, 21281, 21304, 21557, 21534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8318, 21281, 21304, 21557, 21534, 21282, 21305, 21558, 21535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8319, 21282, 21305, 21558, 21535, 21283, 21306, 21559, 21536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8320, 21283, 21306, 21559, 21536, 21284, 21307, 21560, 21537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8321, 21284, 21307, 21560, 21537, 21285, 21308, 21561, 21538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8322, 21285, 21308, 21561, 21538, 21286, 21309, 21562, 21539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8323, 21286, 21309, 21562, 21539, 21287, 21310, 21563, 21540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8324, 21287, 21310, 21563, 21540, 21288, 21311, 21564, 21541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8325, 21288, 21311, 21564, 21541, 21289, 21312, 21565, 21542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8326, 21289, 21312, 21565, 21542, 21290, 21313, 21566, 21543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8327, 21290, 21313, 21566, 21543, 21291, 21314, 21567, 21544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8328, 21291, 21314, 21567, 21544, 21292, 21315, 21568, 21545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8329, 21292, 21315, 21568, 21545, 21293, 21316, 21569, 21546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8330, 21293, 21316, 21569, 21546, 21294, 21317, 21570, 21547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8331, 21294, 21317, 21570, 21547, 21295, 21318, 21571, 21548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8332, 21295, 21318, 21571, 21548, 21296, 21319, 21572, 21549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8333, 21296, 21319, 21572, 21549, 21297, 21320, 21573, 21550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8334, 21297, 21320, 21573, 21550, 21298, 21321, 21574, 21551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8335, 21298, 21321, 21574, 21551, 21299, 21322, 21575, 21552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8336, 21299, 21322, 21575, 21552, 21300, 21323, 21576, 21553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8337, 21300, 21323, 21576, 21553, 4923, 4924, 4935, 4934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8338, 3107, 3108, 3119, 3118, 21301, 21324, 21577, 21554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8339, 21301, 21324, 21577, 21554, 21302, 21325, 21578, 21555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8340, 21302, 21325, 21578, 21555, 21303, 21326, 21579, 21556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8341, 21303, 21326, 21579, 21556, 21304, 21327, 21580, 21557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8342, 21304, 21327, 21580, 21557, 21305, 21328, 21581, 21558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8343, 21305, 21328, 21581, 21558, 21306, 21329, 21582, 21559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8344, 21306, 21329, 21582, 21559, 21307, 21330, 21583, 21560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8345, 21307, 21330, 21583, 21560, 21308, 21331, 21584, 21561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8346, 21308, 21331, 21584, 21561, 21309, 21332, 21585, 21562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8347, 21309, 21332, 21585, 21562, 21310, 21333, 21586, 21563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8348, 21310, 21333, 21586, 21563, 21311, 21334, 21587, 21564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8349, 21311, 21334, 21587, 21564, 21312, 21335, 21588, 21565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8350, 21312, 21335, 21588, 21565, 21313, 21336, 21589, 21566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8351, 21313, 21336, 21589, 21566, 21314, 21337, 21590, 21567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8352, 21314, 21337, 21590, 21567, 21315, 21338, 21591, 21568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8353, 21315, 21338, 21591, 21568, 21316, 21339, 21592, 21569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8354, 21316, 21339, 21592, 21569, 21317, 21340, 21593, 21570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8355, 21317, 21340, 21593, 21570, 21318, 21341, 21594, 21571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8356, 21318, 21341, 21594, 21571, 21319, 21342, 21595, 21572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8357, 21319, 21342, 21595, 21572, 21320, 21343, 21596, 21573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8358, 21320, 21343, 21596, 21573, 21321, 21344, 21597, 21574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8359, 21321, 21344, 21597, 21574, 21322, 21345, 21598, 21575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8360, 21322, 21345, 21598, 21575, 21323, 21346, 21599, 21576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8361, 21323, 21346, 21599, 21576, 4924, 4925, 4936, 4935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8362, 3108, 3109, 3120, 3119, 21324, 21347, 21600, 21577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8363, 21324, 21347, 21600, 21577, 21325, 21348, 21601, 21578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8364, 21325, 21348, 21601, 21578, 21326, 21349, 21602, 21579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8365, 21326, 21349, 21602, 21579, 21327, 21350, 21603, 21580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8366, 21327, 21350, 21603, 21580, 21328, 21351, 21604, 21581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8367, 21328, 21351, 21604, 21581, 21329, 21352, 21605, 21582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8368, 21329, 21352, 21605, 21582, 21330, 21353, 21606, 21583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8369, 21330, 21353, 21606, 21583, 21331, 21354, 21607, 21584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8370, 21331, 21354, 21607, 21584, 21332, 21355, 21608, 21585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8371, 21332, 21355, 21608, 21585, 21333, 21356, 21609, 21586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8372, 21333, 21356, 21609, 21586, 21334, 21357, 21610, 21587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8373, 21334, 21357, 21610, 21587, 21335, 21358, 21611, 21588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8374, 21335, 21358, 21611, 21588, 21336, 21359, 21612, 21589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8375, 21336, 21359, 21612, 21589, 21337, 21360, 21613, 21590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8376, 21337, 21360, 21613, 21590, 21338, 21361, 21614, 21591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8377, 21338, 21361, 21614, 21591, 21339, 21362, 21615, 21592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8378, 21339, 21362, 21615, 21592, 21340, 21363, 21616, 21593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8379, 21340, 21363, 21616, 21593, 21341, 21364, 21617, 21594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8380, 21341, 21364, 21617, 21594, 21342, 21365, 21618, 21595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8381, 21342, 21365, 21618, 21595, 21343, 21366, 21619, 21596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8382, 21343, 21366, 21619, 21596, 21344, 21367, 21620, 21597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8383, 21344, 21367, 21620, 21597, 21345, 21368, 21621, 21598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8384, 21345, 21368, 21621, 21598, 21346, 21369, 21622, 21599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8385, 21346, 21369, 21622, 21599, 4925, 4926, 4937, 4936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8386, 3109, 3110, 3121, 3120, 21347, 21370, 21623, 21600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8387, 21347, 21370, 21623, 21600, 21348, 21371, 21624, 21601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8388, 21348, 21371, 21624, 21601, 21349, 21372, 21625, 21602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8389, 21349, 21372, 21625, 21602, 21350, 21373, 21626, 21603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8390, 21350, 21373, 21626, 21603, 21351, 21374, 21627, 21604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8391, 21351, 21374, 21627, 21604, 21352, 21375, 21628, 21605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8392, 21352, 21375, 21628, 21605, 21353, 21376, 21629, 21606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8393, 21353, 21376, 21629, 21606, 21354, 21377, 21630, 21607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8394, 21354, 21377, 21630, 21607, 21355, 21378, 21631, 21608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8395, 21355, 21378, 21631, 21608, 21356, 21379, 21632, 21609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8396, 21356, 21379, 21632, 21609, 21357, 21380, 21633, 21610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8397, 21357, 21380, 21633, 21610, 21358, 21381, 21634, 21611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8398, 21358, 21381, 21634, 21611, 21359, 21382, 21635, 21612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8399, 21359, 21382, 21635, 21612, 21360, 21383, 21636, 21613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8400, 21360, 21383, 21636, 21613, 21361, 21384, 21637, 21614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8401, 21361, 21384, 21637, 21614, 21362, 21385, 21638, 21615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8402, 21362, 21385, 21638, 21615, 21363, 21386, 21639, 21616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8403, 21363, 21386, 21639, 21616, 21364, 21387, 21640, 21617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8404, 21364, 21387, 21640, 21617, 21365, 21388, 21641, 21618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8405, 21365, 21388, 21641, 21618, 21366, 21389, 21642, 21619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8406, 21366, 21389, 21642, 21619, 21367, 21390, 21643, 21620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8407, 21367, 21390, 21643, 21620, 21368, 21391, 21644, 21621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8408, 21368, 21391, 21644, 21621, 21369, 21392, 21645, 21622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8409, 21369, 21392, 21645, 21622, 4926, 4927, 4938, 4937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8410, 3110, 3111, 3122, 3121, 21370, 21393, 21646, 21623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8411, 21370, 21393, 21646, 21623, 21371, 21394, 21647, 21624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8412, 21371, 21394, 21647, 21624, 21372, 21395, 21648, 21625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8413, 21372, 21395, 21648, 21625, 21373, 21396, 21649, 21626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8414, 21373, 21396, 21649, 21626, 21374, 21397, 21650, 21627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8415, 21374, 21397, 21650, 21627, 21375, 21398, 21651, 21628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8416, 21375, 21398, 21651, 21628, 21376, 21399, 21652, 21629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8417, 21376, 21399, 21652, 21629, 21377, 21400, 21653, 21630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8418, 21377, 21400, 21653, 21630, 21378, 21401, 21654, 21631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8419, 21378, 21401, 21654, 21631, 21379, 21402, 21655, 21632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8420, 21379, 21402, 21655, 21632, 21380, 21403, 21656, 21633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8421, 21380, 21403, 21656, 21633, 21381, 21404, 21657, 21634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8422, 21381, 21404, 21657, 21634, 21382, 21405, 21658, 21635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8423, 21382, 21405, 21658, 21635, 21383, 21406, 21659, 21636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8424, 21383, 21406, 21659, 21636, 21384, 21407, 21660, 21637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8425, 21384, 21407, 21660, 21637, 21385, 21408, 21661, 21638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8426, 21385, 21408, 21661, 21638, 21386, 21409, 21662, 21639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8427, 21386, 21409, 21662, 21639, 21387, 21410, 21663, 21640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8428, 21387, 21410, 21663, 21640, 21388, 21411, 21664, 21641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8429, 21388, 21411, 21664, 21641, 21389, 21412, 21665, 21642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8430, 21389, 21412, 21665, 21642, 21390, 21413, 21666, 21643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8431, 21390, 21413, 21666, 21643, 21391, 21414, 21667, 21644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8432, 21391, 21414, 21667, 21644, 21392, 21415, 21668, 21645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8433, 21392, 21415, 21668, 21645, 4927, 4928, 4939, 4938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8434, 3111, 3112, 3123, 3122, 21393, 21416, 21669, 21646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8435, 21393, 21416, 21669, 21646, 21394, 21417, 21670, 21647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8436, 21394, 21417, 21670, 21647, 21395, 21418, 21671, 21648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8437, 21395, 21418, 21671, 21648, 21396, 21419, 21672, 21649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8438, 21396, 21419, 21672, 21649, 21397, 21420, 21673, 21650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8439, 21397, 21420, 21673, 21650, 21398, 21421, 21674, 21651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8440, 21398, 21421, 21674, 21651, 21399, 21422, 21675, 21652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8441, 21399, 21422, 21675, 21652, 21400, 21423, 21676, 21653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8442, 21400, 21423, 21676, 21653, 21401, 21424, 21677, 21654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8443, 21401, 21424, 21677, 21654, 21402, 21425, 21678, 21655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8444, 21402, 21425, 21678, 21655, 21403, 21426, 21679, 21656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8445, 21403, 21426, 21679, 21656, 21404, 21427, 21680, 21657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8446, 21404, 21427, 21680, 21657, 21405, 21428, 21681, 21658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8447, 21405, 21428, 21681, 21658, 21406, 21429, 21682, 21659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8448, 21406, 21429, 21682, 21659, 21407, 21430, 21683, 21660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8449, 21407, 21430, 21683, 21660, 21408, 21431, 21684, 21661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8450, 21408, 21431, 21684, 21661, 21409, 21432, 21685, 21662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8451, 21409, 21432, 21685, 21662, 21410, 21433, 21686, 21663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8452, 21410, 21433, 21686, 21663, 21411, 21434, 21687, 21664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8453, 21411, 21434, 21687, 21664, 21412, 21435, 21688, 21665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8454, 21412, 21435, 21688, 21665, 21413, 21436, 21689, 21666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8455, 21413, 21436, 21689, 21666, 21414, 21437, 21690, 21667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8456, 21414, 21437, 21690, 21667, 21415, 21438, 21691, 21668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8457, 21415, 21438, 21691, 21668, 4928, 4929, 4940, 4939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8458, 3112, 3113, 3124, 3123, 21416, 21439, 21692, 21669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8459, 21416, 21439, 21692, 21669, 21417, 21440, 21693, 21670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8460, 21417, 21440, 21693, 21670, 21418, 21441, 21694, 21671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8461, 21418, 21441, 21694, 21671, 21419, 21442, 21695, 21672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8462, 21419, 21442, 21695, 21672, 21420, 21443, 21696, 21673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8463, 21420, 21443, 21696, 21673, 21421, 21444, 21697, 21674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8464, 21421, 21444, 21697, 21674, 21422, 21445, 21698, 21675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8465, 21422, 21445, 21698, 21675, 21423, 21446, 21699, 21676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8466, 21423, 21446, 21699, 21676, 21424, 21447, 21700, 21677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8467, 21424, 21447, 21700, 21677, 21425, 21448, 21701, 21678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8468, 21425, 21448, 21701, 21678, 21426, 21449, 21702, 21679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8469, 21426, 21449, 21702, 21679, 21427, 21450, 21703, 21680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8470, 21427, 21450, 21703, 21680, 21428, 21451, 21704, 21681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8471, 21428, 21451, 21704, 21681, 21429, 21452, 21705, 21682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8472, 21429, 21452, 21705, 21682, 21430, 21453, 21706, 21683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8473, 21430, 21453, 21706, 21683, 21431, 21454, 21707, 21684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8474, 21431, 21454, 21707, 21684, 21432, 21455, 21708, 21685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8475, 21432, 21455, 21708, 21685, 21433, 21456, 21709, 21686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8476, 21433, 21456, 21709, 21686, 21434, 21457, 21710, 21687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8477, 21434, 21457, 21710, 21687, 21435, 21458, 21711, 21688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8478, 21435, 21458, 21711, 21688, 21436, 21459, 21712, 21689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8479, 21436, 21459, 21712, 21689, 21437, 21460, 21713, 21690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8480, 21437, 21460, 21713, 21690, 21438, 21461, 21714, 21691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8481, 21438, 21461, 21714, 21691, 4929, 4930, 4941, 4940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8482, 3113, 3114, 3125, 3124, 21439, 21462, 21715, 21692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8483, 21439, 21462, 21715, 21692, 21440, 21463, 21716, 21693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8484, 21440, 21463, 21716, 21693, 21441, 21464, 21717, 21694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8485, 21441, 21464, 21717, 21694, 21442, 21465, 21718, 21695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8486, 21442, 21465, 21718, 21695, 21443, 21466, 21719, 21696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8487, 21443, 21466, 21719, 21696, 21444, 21467, 21720, 21697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8488, 21444, 21467, 21720, 21697, 21445, 21468, 21721, 21698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8489, 21445, 21468, 21721, 21698, 21446, 21469, 21722, 21699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8490, 21446, 21469, 21722, 21699, 21447, 21470, 21723, 21700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8491, 21447, 21470, 21723, 21700, 21448, 21471, 21724, 21701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8492, 21448, 21471, 21724, 21701, 21449, 21472, 21725, 21702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8493, 21449, 21472, 21725, 21702, 21450, 21473, 21726, 21703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8494, 21450, 21473, 21726, 21703, 21451, 21474, 21727, 21704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8495, 21451, 21474, 21727, 21704, 21452, 21475, 21728, 21705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8496, 21452, 21475, 21728, 21705, 21453, 21476, 21729, 21706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8497, 21453, 21476, 21729, 21706, 21454, 21477, 21730, 21707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8498, 21454, 21477, 21730, 21707, 21455, 21478, 21731, 21708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8499, 21455, 21478, 21731, 21708, 21456, 21479, 21732, 21709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8500, 21456, 21479, 21732, 21709, 21457, 21480, 21733, 21710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8501, 21457, 21480, 21733, 21710, 21458, 21481, 21734, 21711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8502, 21458, 21481, 21734, 21711, 21459, 21482, 21735, 21712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8503, 21459, 21482, 21735, 21712, 21460, 21483, 21736, 21713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8504, 21460, 21483, 21736, 21713, 21461, 21484, 21737, 21714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8505, 21461, 21484, 21737, 21714, 4930, 4931, 4942, 4941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8506, 3114, 3115, 3126, 3125, 21462, 21485, 21738, 21715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8507, 21462, 21485, 21738, 21715, 21463, 21486, 21739, 21716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8508, 21463, 21486, 21739, 21716, 21464, 21487, 21740, 21717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8509, 21464, 21487, 21740, 21717, 21465, 21488, 21741, 21718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8510, 21465, 21488, 21741, 21718, 21466, 21489, 21742, 21719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8511, 21466, 21489, 21742, 21719, 21467, 21490, 21743, 21720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8512, 21467, 21490, 21743, 21720, 21468, 21491, 21744, 21721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8513, 21468, 21491, 21744, 21721, 21469, 21492, 21745, 21722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8514, 21469, 21492, 21745, 21722, 21470, 21493, 21746, 21723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8515, 21470, 21493, 21746, 21723, 21471, 21494, 21747, 21724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8516, 21471, 21494, 21747, 21724, 21472, 21495, 21748, 21725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8517, 21472, 21495, 21748, 21725, 21473, 21496, 21749, 21726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8518, 21473, 21496, 21749, 21726, 21474, 21497, 21750, 21727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8519, 21474, 21497, 21750, 21727, 21475, 21498, 21751, 21728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8520, 21475, 21498, 21751, 21728, 21476, 21499, 21752, 21729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8521, 21476, 21499, 21752, 21729, 21477, 21500, 21753, 21730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8522, 21477, 21500, 21753, 21730, 21478, 21501, 21754, 21731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8523, 21478, 21501, 21754, 21731, 21479, 21502, 21755, 21732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8524, 21479, 21502, 21755, 21732, 21480, 21503, 21756, 21733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8525, 21480, 21503, 21756, 21733, 21481, 21504, 21757, 21734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8526, 21481, 21504, 21757, 21734, 21482, 21505, 21758, 21735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8527, 21482, 21505, 21758, 21735, 21483, 21506, 21759, 21736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8528, 21483, 21506, 21759, 21736, 21484, 21507, 21760, 21737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8529, 21484, 21507, 21760, 21737, 4931, 4932, 4943, 4942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8530, 3115, 281, 282, 3126, 21485, 4200, 4223, 21738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8531, 21485, 4200, 4223, 21738, 21486, 4201, 4224, 21739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8532, 21486, 4201, 4224, 21739, 21487, 4202, 4225, 21740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8533, 21487, 4202, 4225, 21740, 21488, 4203, 4226, 21741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8534, 21488, 4203, 4226, 21741, 21489, 4204, 4227, 21742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8535, 21489, 4204, 4227, 21742, 21490, 4205, 4228, 21743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8536, 21490, 4205, 4228, 21743, 21491, 4206, 4229, 21744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8537, 21491, 4206, 4229, 21744, 21492, 4207, 4230, 21745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8538, 21492, 4207, 4230, 21745, 21493, 4208, 4231, 21746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8539, 21493, 4208, 4231, 21746, 21494, 4209, 4232, 21747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8540, 21494, 4209, 4232, 21747, 21495, 4210, 4233, 21748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8541, 21495, 4210, 4233, 21748, 21496, 4211, 4234, 21749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8542, 21496, 4211, 4234, 21749, 21497, 4212, 4235, 21750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8543, 21497, 4212, 4235, 21750, 21498, 4213, 4236, 21751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8544, 21498, 4213, 4236, 21751, 21499, 4214, 4237, 21752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8545, 21499, 4214, 4237, 21752, 21500, 4215, 4238, 21753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8546, 21500, 4215, 4238, 21753, 21501, 4216, 4239, 21754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8547, 21501, 4216, 4239, 21754, 21502, 4217, 4240, 21755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8548, 21502, 4217, 4240, 21755, 21503, 4218, 4241, 21756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8549, 21503, 4218, 4241, 21756, 21504, 4219, 4242, 21757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8550, 21504, 4219, 4242, 21757, 21505, 4220, 4243, 21758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8551, 21505, 4220, 4243, 21758, 21506, 4221, 4244, 21759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8552, 21506, 4221, 4244, 21759, 21507, 4222, 4245, 21760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8553, 21507, 4222, 4245, 21760, 4932, 441, 442, 4943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8554, 248, 3116, 3127, 249, 3441, 21508, 21761, 3464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8555, 3441, 21508, 21761, 3464, 3442, 21509, 21762, 3465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8556, 3442, 21509, 21762, 3465, 3443, 21510, 21763, 3466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8557, 3443, 21510, 21763, 3466, 3444, 21511, 21764, 3467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8558, 3444, 21511, 21764, 3467, 3445, 21512, 21765, 3468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8559, 3445, 21512, 21765, 3468, 3446, 21513, 21766, 3469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8560, 3446, 21513, 21766, 3469, 3447, 21514, 21767, 3470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8561, 3447, 21514, 21767, 3470, 3448, 21515, 21768, 3471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8562, 3448, 21515, 21768, 3471, 3449, 21516, 21769, 3472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8563, 3449, 21516, 21769, 3472, 3450, 21517, 21770, 3473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8564, 3450, 21517, 21770, 3473, 3451, 21518, 21771, 3474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8565, 3451, 21518, 21771, 3474, 3452, 21519, 21772, 3475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8566, 3452, 21519, 21772, 3475, 3453, 21520, 21773, 3476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8567, 3453, 21520, 21773, 3476, 3454, 21521, 21774, 3477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8568, 3454, 21521, 21774, 3477, 3455, 21522, 21775, 3478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8569, 3455, 21522, 21775, 3478, 3456, 21523, 21776, 3479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8570, 3456, 21523, 21776, 3479, 3457, 21524, 21777, 3480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8571, 3457, 21524, 21777, 3480, 3458, 21525, 21778, 3481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8572, 3458, 21525, 21778, 3481, 3459, 21526, 21779, 3482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8573, 3459, 21526, 21779, 3482, 3460, 21527, 21780, 3483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8574, 3460, 21527, 21780, 3483, 3461, 21528, 21781, 3484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8575, 3461, 21528, 21781, 3484, 3462, 21529, 21782, 3485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8576, 3462, 21529, 21782, 3485, 3463, 21530, 21783, 3486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8577, 3463, 21530, 21783, 3486, 362, 4933, 4944, 363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8578, 3116, 3117, 3128, 3127, 21508, 21531, 21784, 21761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8579, 21508, 21531, 21784, 21761, 21509, 21532, 21785, 21762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8580, 21509, 21532, 21785, 21762, 21510, 21533, 21786, 21763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8581, 21510, 21533, 21786, 21763, 21511, 21534, 21787, 21764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8582, 21511, 21534, 21787, 21764, 21512, 21535, 21788, 21765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8583, 21512, 21535, 21788, 21765, 21513, 21536, 21789, 21766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8584, 21513, 21536, 21789, 21766, 21514, 21537, 21790, 21767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8585, 21514, 21537, 21790, 21767, 21515, 21538, 21791, 21768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8586, 21515, 21538, 21791, 21768, 21516, 21539, 21792, 21769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8587, 21516, 21539, 21792, 21769, 21517, 21540, 21793, 21770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8588, 21517, 21540, 21793, 21770, 21518, 21541, 21794, 21771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8589, 21518, 21541, 21794, 21771, 21519, 21542, 21795, 21772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8590, 21519, 21542, 21795, 21772, 21520, 21543, 21796, 21773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8591, 21520, 21543, 21796, 21773, 21521, 21544, 21797, 21774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8592, 21521, 21544, 21797, 21774, 21522, 21545, 21798, 21775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8593, 21522, 21545, 21798, 21775, 21523, 21546, 21799, 21776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8594, 21523, 21546, 21799, 21776, 21524, 21547, 21800, 21777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8595, 21524, 21547, 21800, 21777, 21525, 21548, 21801, 21778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8596, 21525, 21548, 21801, 21778, 21526, 21549, 21802, 21779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8597, 21526, 21549, 21802, 21779, 21527, 21550, 21803, 21780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8598, 21527, 21550, 21803, 21780, 21528, 21551, 21804, 21781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8599, 21528, 21551, 21804, 21781, 21529, 21552, 21805, 21782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8600, 21529, 21552, 21805, 21782, 21530, 21553, 21806, 21783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8601, 21530, 21553, 21806, 21783, 4933, 4934, 4945, 4944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8602, 3117, 3118, 3129, 3128, 21531, 21554, 21807, 21784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8603, 21531, 21554, 21807, 21784, 21532, 21555, 21808, 21785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8604, 21532, 21555, 21808, 21785, 21533, 21556, 21809, 21786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8605, 21533, 21556, 21809, 21786, 21534, 21557, 21810, 21787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8606, 21534, 21557, 21810, 21787, 21535, 21558, 21811, 21788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8607, 21535, 21558, 21811, 21788, 21536, 21559, 21812, 21789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8608, 21536, 21559, 21812, 21789, 21537, 21560, 21813, 21790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8609, 21537, 21560, 21813, 21790, 21538, 21561, 21814, 21791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8610, 21538, 21561, 21814, 21791, 21539, 21562, 21815, 21792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8611, 21539, 21562, 21815, 21792, 21540, 21563, 21816, 21793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8612, 21540, 21563, 21816, 21793, 21541, 21564, 21817, 21794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8613, 21541, 21564, 21817, 21794, 21542, 21565, 21818, 21795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8614, 21542, 21565, 21818, 21795, 21543, 21566, 21819, 21796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8615, 21543, 21566, 21819, 21796, 21544, 21567, 21820, 21797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8616, 21544, 21567, 21820, 21797, 21545, 21568, 21821, 21798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8617, 21545, 21568, 21821, 21798, 21546, 21569, 21822, 21799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8618, 21546, 21569, 21822, 21799, 21547, 21570, 21823, 21800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8619, 21547, 21570, 21823, 21800, 21548, 21571, 21824, 21801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8620, 21548, 21571, 21824, 21801, 21549, 21572, 21825, 21802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8621, 21549, 21572, 21825, 21802, 21550, 21573, 21826, 21803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8622, 21550, 21573, 21826, 21803, 21551, 21574, 21827, 21804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8623, 21551, 21574, 21827, 21804, 21552, 21575, 21828, 21805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8624, 21552, 21575, 21828, 21805, 21553, 21576, 21829, 21806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8625, 21553, 21576, 21829, 21806, 4934, 4935, 4946, 4945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8626, 3118, 3119, 3130, 3129, 21554, 21577, 21830, 21807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8627, 21554, 21577, 21830, 21807, 21555, 21578, 21831, 21808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8628, 21555, 21578, 21831, 21808, 21556, 21579, 21832, 21809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8629, 21556, 21579, 21832, 21809, 21557, 21580, 21833, 21810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8630, 21557, 21580, 21833, 21810, 21558, 21581, 21834, 21811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8631, 21558, 21581, 21834, 21811, 21559, 21582, 21835, 21812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8632, 21559, 21582, 21835, 21812, 21560, 21583, 21836, 21813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8633, 21560, 21583, 21836, 21813, 21561, 21584, 21837, 21814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8634, 21561, 21584, 21837, 21814, 21562, 21585, 21838, 21815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8635, 21562, 21585, 21838, 21815, 21563, 21586, 21839, 21816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8636, 21563, 21586, 21839, 21816, 21564, 21587, 21840, 21817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8637, 21564, 21587, 21840, 21817, 21565, 21588, 21841, 21818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8638, 21565, 21588, 21841, 21818, 21566, 21589, 21842, 21819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8639, 21566, 21589, 21842, 21819, 21567, 21590, 21843, 21820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8640, 21567, 21590, 21843, 21820, 21568, 21591, 21844, 21821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8641, 21568, 21591, 21844, 21821, 21569, 21592, 21845, 21822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8642, 21569, 21592, 21845, 21822, 21570, 21593, 21846, 21823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8643, 21570, 21593, 21846, 21823, 21571, 21594, 21847, 21824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8644, 21571, 21594, 21847, 21824, 21572, 21595, 21848, 21825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8645, 21572, 21595, 21848, 21825, 21573, 21596, 21849, 21826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8646, 21573, 21596, 21849, 21826, 21574, 21597, 21850, 21827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8647, 21574, 21597, 21850, 21827, 21575, 21598, 21851, 21828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8648, 21575, 21598, 21851, 21828, 21576, 21599, 21852, 21829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8649, 21576, 21599, 21852, 21829, 4935, 4936, 4947, 4946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8650, 3119, 3120, 3131, 3130, 21577, 21600, 21853, 21830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8651, 21577, 21600, 21853, 21830, 21578, 21601, 21854, 21831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8652, 21578, 21601, 21854, 21831, 21579, 21602, 21855, 21832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8653, 21579, 21602, 21855, 21832, 21580, 21603, 21856, 21833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8654, 21580, 21603, 21856, 21833, 21581, 21604, 21857, 21834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8655, 21581, 21604, 21857, 21834, 21582, 21605, 21858, 21835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8656, 21582, 21605, 21858, 21835, 21583, 21606, 21859, 21836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8657, 21583, 21606, 21859, 21836, 21584, 21607, 21860, 21837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8658, 21584, 21607, 21860, 21837, 21585, 21608, 21861, 21838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8659, 21585, 21608, 21861, 21838, 21586, 21609, 21862, 21839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8660, 21586, 21609, 21862, 21839, 21587, 21610, 21863, 21840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8661, 21587, 21610, 21863, 21840, 21588, 21611, 21864, 21841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8662, 21588, 21611, 21864, 21841, 21589, 21612, 21865, 21842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8663, 21589, 21612, 21865, 21842, 21590, 21613, 21866, 21843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8664, 21590, 21613, 21866, 21843, 21591, 21614, 21867, 21844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8665, 21591, 21614, 21867, 21844, 21592, 21615, 21868, 21845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8666, 21592, 21615, 21868, 21845, 21593, 21616, 21869, 21846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8667, 21593, 21616, 21869, 21846, 21594, 21617, 21870, 21847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8668, 21594, 21617, 21870, 21847, 21595, 21618, 21871, 21848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8669, 21595, 21618, 21871, 21848, 21596, 21619, 21872, 21849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8670, 21596, 21619, 21872, 21849, 21597, 21620, 21873, 21850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8671, 21597, 21620, 21873, 21850, 21598, 21621, 21874, 21851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8672, 21598, 21621, 21874, 21851, 21599, 21622, 21875, 21852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8673, 21599, 21622, 21875, 21852, 4936, 4937, 4948, 4947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8674, 3120, 3121, 3132, 3131, 21600, 21623, 21876, 21853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8675, 21600, 21623, 21876, 21853, 21601, 21624, 21877, 21854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8676, 21601, 21624, 21877, 21854, 21602, 21625, 21878, 21855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8677, 21602, 21625, 21878, 21855, 21603, 21626, 21879, 21856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8678, 21603, 21626, 21879, 21856, 21604, 21627, 21880, 21857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8679, 21604, 21627, 21880, 21857, 21605, 21628, 21881, 21858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8680, 21605, 21628, 21881, 21858, 21606, 21629, 21882, 21859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8681, 21606, 21629, 21882, 21859, 21607, 21630, 21883, 21860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8682, 21607, 21630, 21883, 21860, 21608, 21631, 21884, 21861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8683, 21608, 21631, 21884, 21861, 21609, 21632, 21885, 21862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8684, 21609, 21632, 21885, 21862, 21610, 21633, 21886, 21863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8685, 21610, 21633, 21886, 21863, 21611, 21634, 21887, 21864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8686, 21611, 21634, 21887, 21864, 21612, 21635, 21888, 21865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8687, 21612, 21635, 21888, 21865, 21613, 21636, 21889, 21866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8688, 21613, 21636, 21889, 21866, 21614, 21637, 21890, 21867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8689, 21614, 21637, 21890, 21867, 21615, 21638, 21891, 21868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8690, 21615, 21638, 21891, 21868, 21616, 21639, 21892, 21869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8691, 21616, 21639, 21892, 21869, 21617, 21640, 21893, 21870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8692, 21617, 21640, 21893, 21870, 21618, 21641, 21894, 21871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8693, 21618, 21641, 21894, 21871, 21619, 21642, 21895, 21872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8694, 21619, 21642, 21895, 21872, 21620, 21643, 21896, 21873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8695, 21620, 21643, 21896, 21873, 21621, 21644, 21897, 21874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8696, 21621, 21644, 21897, 21874, 21622, 21645, 21898, 21875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8697, 21622, 21645, 21898, 21875, 4937, 4938, 4949, 4948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8698, 3121, 3122, 3133, 3132, 21623, 21646, 21899, 21876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8699, 21623, 21646, 21899, 21876, 21624, 21647, 21900, 21877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8700, 21624, 21647, 21900, 21877, 21625, 21648, 21901, 21878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8701, 21625, 21648, 21901, 21878, 21626, 21649, 21902, 21879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8702, 21626, 21649, 21902, 21879, 21627, 21650, 21903, 21880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8703, 21627, 21650, 21903, 21880, 21628, 21651, 21904, 21881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8704, 21628, 21651, 21904, 21881, 21629, 21652, 21905, 21882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8705, 21629, 21652, 21905, 21882, 21630, 21653, 21906, 21883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8706, 21630, 21653, 21906, 21883, 21631, 21654, 21907, 21884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8707, 21631, 21654, 21907, 21884, 21632, 21655, 21908, 21885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8708, 21632, 21655, 21908, 21885, 21633, 21656, 21909, 21886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8709, 21633, 21656, 21909, 21886, 21634, 21657, 21910, 21887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8710, 21634, 21657, 21910, 21887, 21635, 21658, 21911, 21888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8711, 21635, 21658, 21911, 21888, 21636, 21659, 21912, 21889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8712, 21636, 21659, 21912, 21889, 21637, 21660, 21913, 21890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8713, 21637, 21660, 21913, 21890, 21638, 21661, 21914, 21891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8714, 21638, 21661, 21914, 21891, 21639, 21662, 21915, 21892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8715, 21639, 21662, 21915, 21892, 21640, 21663, 21916, 21893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8716, 21640, 21663, 21916, 21893, 21641, 21664, 21917, 21894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8717, 21641, 21664, 21917, 21894, 21642, 21665, 21918, 21895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8718, 21642, 21665, 21918, 21895, 21643, 21666, 21919, 21896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8719, 21643, 21666, 21919, 21896, 21644, 21667, 21920, 21897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8720, 21644, 21667, 21920, 21897, 21645, 21668, 21921, 21898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8721, 21645, 21668, 21921, 21898, 4938, 4939, 4950, 4949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8722, 3122, 3123, 3134, 3133, 21646, 21669, 21922, 21899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8723, 21646, 21669, 21922, 21899, 21647, 21670, 21923, 21900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8724, 21647, 21670, 21923, 21900, 21648, 21671, 21924, 21901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8725, 21648, 21671, 21924, 21901, 21649, 21672, 21925, 21902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8726, 21649, 21672, 21925, 21902, 21650, 21673, 21926, 21903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8727, 21650, 21673, 21926, 21903, 21651, 21674, 21927, 21904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8728, 21651, 21674, 21927, 21904, 21652, 21675, 21928, 21905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8729, 21652, 21675, 21928, 21905, 21653, 21676, 21929, 21906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8730, 21653, 21676, 21929, 21906, 21654, 21677, 21930, 21907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8731, 21654, 21677, 21930, 21907, 21655, 21678, 21931, 21908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8732, 21655, 21678, 21931, 21908, 21656, 21679, 21932, 21909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8733, 21656, 21679, 21932, 21909, 21657, 21680, 21933, 21910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8734, 21657, 21680, 21933, 21910, 21658, 21681, 21934, 21911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8735, 21658, 21681, 21934, 21911, 21659, 21682, 21935, 21912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8736, 21659, 21682, 21935, 21912, 21660, 21683, 21936, 21913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8737, 21660, 21683, 21936, 21913, 21661, 21684, 21937, 21914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8738, 21661, 21684, 21937, 21914, 21662, 21685, 21938, 21915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8739, 21662, 21685, 21938, 21915, 21663, 21686, 21939, 21916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8740, 21663, 21686, 21939, 21916, 21664, 21687, 21940, 21917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8741, 21664, 21687, 21940, 21917, 21665, 21688, 21941, 21918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8742, 21665, 21688, 21941, 21918, 21666, 21689, 21942, 21919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8743, 21666, 21689, 21942, 21919, 21667, 21690, 21943, 21920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8744, 21667, 21690, 21943, 21920, 21668, 21691, 21944, 21921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8745, 21668, 21691, 21944, 21921, 4939, 4940, 4951, 4950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8746, 3123, 3124, 3135, 3134, 21669, 21692, 21945, 21922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8747, 21669, 21692, 21945, 21922, 21670, 21693, 21946, 21923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8748, 21670, 21693, 21946, 21923, 21671, 21694, 21947, 21924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8749, 21671, 21694, 21947, 21924, 21672, 21695, 21948, 21925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8750, 21672, 21695, 21948, 21925, 21673, 21696, 21949, 21926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8751, 21673, 21696, 21949, 21926, 21674, 21697, 21950, 21927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8752, 21674, 21697, 21950, 21927, 21675, 21698, 21951, 21928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8753, 21675, 21698, 21951, 21928, 21676, 21699, 21952, 21929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8754, 21676, 21699, 21952, 21929, 21677, 21700, 21953, 21930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8755, 21677, 21700, 21953, 21930, 21678, 21701, 21954, 21931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8756, 21678, 21701, 21954, 21931, 21679, 21702, 21955, 21932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8757, 21679, 21702, 21955, 21932, 21680, 21703, 21956, 21933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8758, 21680, 21703, 21956, 21933, 21681, 21704, 21957, 21934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8759, 21681, 21704, 21957, 21934, 21682, 21705, 21958, 21935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8760, 21682, 21705, 21958, 21935, 21683, 21706, 21959, 21936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8761, 21683, 21706, 21959, 21936, 21684, 21707, 21960, 21937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8762, 21684, 21707, 21960, 21937, 21685, 21708, 21961, 21938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8763, 21685, 21708, 21961, 21938, 21686, 21709, 21962, 21939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8764, 21686, 21709, 21962, 21939, 21687, 21710, 21963, 21940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8765, 21687, 21710, 21963, 21940, 21688, 21711, 21964, 21941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8766, 21688, 21711, 21964, 21941, 21689, 21712, 21965, 21942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8767, 21689, 21712, 21965, 21942, 21690, 21713, 21966, 21943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8768, 21690, 21713, 21966, 21943, 21691, 21714, 21967, 21944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8769, 21691, 21714, 21967, 21944, 4940, 4941, 4952, 4951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8770, 3124, 3125, 3136, 3135, 21692, 21715, 21968, 21945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8771, 21692, 21715, 21968, 21945, 21693, 21716, 21969, 21946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8772, 21693, 21716, 21969, 21946, 21694, 21717, 21970, 21947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8773, 21694, 21717, 21970, 21947, 21695, 21718, 21971, 21948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8774, 21695, 21718, 21971, 21948, 21696, 21719, 21972, 21949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8775, 21696, 21719, 21972, 21949, 21697, 21720, 21973, 21950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8776, 21697, 21720, 21973, 21950, 21698, 21721, 21974, 21951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8777, 21698, 21721, 21974, 21951, 21699, 21722, 21975, 21952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8778, 21699, 21722, 21975, 21952, 21700, 21723, 21976, 21953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8779, 21700, 21723, 21976, 21953, 21701, 21724, 21977, 21954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8780, 21701, 21724, 21977, 21954, 21702, 21725, 21978, 21955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8781, 21702, 21725, 21978, 21955, 21703, 21726, 21979, 21956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8782, 21703, 21726, 21979, 21956, 21704, 21727, 21980, 21957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8783, 21704, 21727, 21980, 21957, 21705, 21728, 21981, 21958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8784, 21705, 21728, 21981, 21958, 21706, 21729, 21982, 21959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8785, 21706, 21729, 21982, 21959, 21707, 21730, 21983, 21960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8786, 21707, 21730, 21983, 21960, 21708, 21731, 21984, 21961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8787, 21708, 21731, 21984, 21961, 21709, 21732, 21985, 21962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8788, 21709, 21732, 21985, 21962, 21710, 21733, 21986, 21963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8789, 21710, 21733, 21986, 21963, 21711, 21734, 21987, 21964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8790, 21711, 21734, 21987, 21964, 21712, 21735, 21988, 21965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8791, 21712, 21735, 21988, 21965, 21713, 21736, 21989, 21966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8792, 21713, 21736, 21989, 21966, 21714, 21737, 21990, 21967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8793, 21714, 21737, 21990, 21967, 4941, 4942, 4953, 4952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8794, 3125, 3126, 3137, 3136, 21715, 21738, 21991, 21968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8795, 21715, 21738, 21991, 21968, 21716, 21739, 21992, 21969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8796, 21716, 21739, 21992, 21969, 21717, 21740, 21993, 21970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8797, 21717, 21740, 21993, 21970, 21718, 21741, 21994, 21971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8798, 21718, 21741, 21994, 21971, 21719, 21742, 21995, 21972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8799, 21719, 21742, 21995, 21972, 21720, 21743, 21996, 21973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8800, 21720, 21743, 21996, 21973, 21721, 21744, 21997, 21974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8801, 21721, 21744, 21997, 21974, 21722, 21745, 21998, 21975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8802, 21722, 21745, 21998, 21975, 21723, 21746, 21999, 21976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8803, 21723, 21746, 21999, 21976, 21724, 21747, 22000, 21977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8804, 21724, 21747, 22000, 21977, 21725, 21748, 22001, 21978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8805, 21725, 21748, 22001, 21978, 21726, 21749, 22002, 21979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8806, 21726, 21749, 22002, 21979, 21727, 21750, 22003, 21980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8807, 21727, 21750, 22003, 21980, 21728, 21751, 22004, 21981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8808, 21728, 21751, 22004, 21981, 21729, 21752, 22005, 21982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8809, 21729, 21752, 22005, 21982, 21730, 21753, 22006, 21983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8810, 21730, 21753, 22006, 21983, 21731, 21754, 22007, 21984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8811, 21731, 21754, 22007, 21984, 21732, 21755, 22008, 21985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8812, 21732, 21755, 22008, 21985, 21733, 21756, 22009, 21986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8813, 21733, 21756, 22009, 21986, 21734, 21757, 22010, 21987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8814, 21734, 21757, 22010, 21987, 21735, 21758, 22011, 21988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8815, 21735, 21758, 22011, 21988, 21736, 21759, 22012, 21989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8816, 21736, 21759, 22012, 21989, 21737, 21760, 22013, 21990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8817, 21737, 21760, 22013, 21990, 4942, 4943, 4954, 4953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8818, 3126, 282, 283, 3137, 21738, 4223, 4246, 21991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8819, 21738, 4223, 4246, 21991, 21739, 4224, 4247, 21992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8820, 21739, 4224, 4247, 21992, 21740, 4225, 4248, 21993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8821, 21740, 4225, 4248, 21993, 21741, 4226, 4249, 21994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8822, 21741, 4226, 4249, 21994, 21742, 4227, 4250, 21995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8823, 21742, 4227, 4250, 21995, 21743, 4228, 4251, 21996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8824, 21743, 4228, 4251, 21996, 21744, 4229, 4252, 21997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8825, 21744, 4229, 4252, 21997, 21745, 4230, 4253, 21998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8826, 21745, 4230, 4253, 21998, 21746, 4231, 4254, 21999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8827, 21746, 4231, 4254, 21999, 21747, 4232, 4255, 22000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8828, 21747, 4232, 4255, 22000, 21748, 4233, 4256, 22001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8829, 21748, 4233, 4256, 22001, 21749, 4234, 4257, 22002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8830, 21749, 4234, 4257, 22002, 21750, 4235, 4258, 22003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8831, 21750, 4235, 4258, 22003, 21751, 4236, 4259, 22004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8832, 21751, 4236, 4259, 22004, 21752, 4237, 4260, 22005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8833, 21752, 4237, 4260, 22005, 21753, 4238, 4261, 22006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8834, 21753, 4238, 4261, 22006, 21754, 4239, 4262, 22007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8835, 21754, 4239, 4262, 22007, 21755, 4240, 4263, 22008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8836, 21755, 4240, 4263, 22008, 21756, 4241, 4264, 22009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8837, 21756, 4241, 4264, 22009, 21757, 4242, 4265, 22010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8838, 21757, 4242, 4265, 22010, 21758, 4243, 4266, 22011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8839, 21758, 4243, 4266, 22011, 21759, 4244, 4267, 22012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8840, 21759, 4244, 4267, 22012, 21760, 4245, 4268, 22013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8841, 21760, 4245, 4268, 22013, 4943, 442, 443, 4954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8842, 249, 3127, 3138, 250, 3464, 21761, 22014, 3487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8843, 3464, 21761, 22014, 3487, 3465, 21762, 22015, 3488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8844, 3465, 21762, 22015, 3488, 3466, 21763, 22016, 3489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8845, 3466, 21763, 22016, 3489, 3467, 21764, 22017, 3490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8846, 3467, 21764, 22017, 3490, 3468, 21765, 22018, 3491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8847, 3468, 21765, 22018, 3491, 3469, 21766, 22019, 3492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8848, 3469, 21766, 22019, 3492, 3470, 21767, 22020, 3493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8849, 3470, 21767, 22020, 3493, 3471, 21768, 22021, 3494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8850, 3471, 21768, 22021, 3494, 3472, 21769, 22022, 3495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8851, 3472, 21769, 22022, 3495, 3473, 21770, 22023, 3496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8852, 3473, 21770, 22023, 3496, 3474, 21771, 22024, 3497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8853, 3474, 21771, 22024, 3497, 3475, 21772, 22025, 3498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8854, 3475, 21772, 22025, 3498, 3476, 21773, 22026, 3499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8855, 3476, 21773, 22026, 3499, 3477, 21774, 22027, 3500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8856, 3477, 21774, 22027, 3500, 3478, 21775, 22028, 3501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8857, 3478, 21775, 22028, 3501, 3479, 21776, 22029, 3502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8858, 3479, 21776, 22029, 3502, 3480, 21777, 22030, 3503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8859, 3480, 21777, 22030, 3503, 3481, 21778, 22031, 3504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8860, 3481, 21778, 22031, 3504, 3482, 21779, 22032, 3505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8861, 3482, 21779, 22032, 3505, 3483, 21780, 22033, 3506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8862, 3483, 21780, 22033, 3506, 3484, 21781, 22034, 3507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8863, 3484, 21781, 22034, 3507, 3485, 21782, 22035, 3508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8864, 3485, 21782, 22035, 3508, 3486, 21783, 22036, 3509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8865, 3486, 21783, 22036, 3509, 363, 4944, 4955, 364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8866, 3127, 3128, 3139, 3138, 21761, 21784, 22037, 22014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8867, 21761, 21784, 22037, 22014, 21762, 21785, 22038, 22015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8868, 21762, 21785, 22038, 22015, 21763, 21786, 22039, 22016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8869, 21763, 21786, 22039, 22016, 21764, 21787, 22040, 22017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8870, 21764, 21787, 22040, 22017, 21765, 21788, 22041, 22018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8871, 21765, 21788, 22041, 22018, 21766, 21789, 22042, 22019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8872, 21766, 21789, 22042, 22019, 21767, 21790, 22043, 22020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8873, 21767, 21790, 22043, 22020, 21768, 21791, 22044, 22021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8874, 21768, 21791, 22044, 22021, 21769, 21792, 22045, 22022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8875, 21769, 21792, 22045, 22022, 21770, 21793, 22046, 22023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8876, 21770, 21793, 22046, 22023, 21771, 21794, 22047, 22024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8877, 21771, 21794, 22047, 22024, 21772, 21795, 22048, 22025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8878, 21772, 21795, 22048, 22025, 21773, 21796, 22049, 22026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8879, 21773, 21796, 22049, 22026, 21774, 21797, 22050, 22027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8880, 21774, 21797, 22050, 22027, 21775, 21798, 22051, 22028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8881, 21775, 21798, 22051, 22028, 21776, 21799, 22052, 22029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8882, 21776, 21799, 22052, 22029, 21777, 21800, 22053, 22030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8883, 21777, 21800, 22053, 22030, 21778, 21801, 22054, 22031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8884, 21778, 21801, 22054, 22031, 21779, 21802, 22055, 22032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8885, 21779, 21802, 22055, 22032, 21780, 21803, 22056, 22033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8886, 21780, 21803, 22056, 22033, 21781, 21804, 22057, 22034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8887, 21781, 21804, 22057, 22034, 21782, 21805, 22058, 22035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8888, 21782, 21805, 22058, 22035, 21783, 21806, 22059, 22036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8889, 21783, 21806, 22059, 22036, 4944, 4945, 4956, 4955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8890, 3128, 3129, 3140, 3139, 21784, 21807, 22060, 22037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8891, 21784, 21807, 22060, 22037, 21785, 21808, 22061, 22038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8892, 21785, 21808, 22061, 22038, 21786, 21809, 22062, 22039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8893, 21786, 21809, 22062, 22039, 21787, 21810, 22063, 22040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8894, 21787, 21810, 22063, 22040, 21788, 21811, 22064, 22041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8895, 21788, 21811, 22064, 22041, 21789, 21812, 22065, 22042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8896, 21789, 21812, 22065, 22042, 21790, 21813, 22066, 22043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8897, 21790, 21813, 22066, 22043, 21791, 21814, 22067, 22044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8898, 21791, 21814, 22067, 22044, 21792, 21815, 22068, 22045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8899, 21792, 21815, 22068, 22045, 21793, 21816, 22069, 22046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8900, 21793, 21816, 22069, 22046, 21794, 21817, 22070, 22047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8901, 21794, 21817, 22070, 22047, 21795, 21818, 22071, 22048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8902, 21795, 21818, 22071, 22048, 21796, 21819, 22072, 22049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8903, 21796, 21819, 22072, 22049, 21797, 21820, 22073, 22050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8904, 21797, 21820, 22073, 22050, 21798, 21821, 22074, 22051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8905, 21798, 21821, 22074, 22051, 21799, 21822, 22075, 22052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8906, 21799, 21822, 22075, 22052, 21800, 21823, 22076, 22053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8907, 21800, 21823, 22076, 22053, 21801, 21824, 22077, 22054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8908, 21801, 21824, 22077, 22054, 21802, 21825, 22078, 22055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8909, 21802, 21825, 22078, 22055, 21803, 21826, 22079, 22056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8910, 21803, 21826, 22079, 22056, 21804, 21827, 22080, 22057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8911, 21804, 21827, 22080, 22057, 21805, 21828, 22081, 22058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8912, 21805, 21828, 22081, 22058, 21806, 21829, 22082, 22059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8913, 21806, 21829, 22082, 22059, 4945, 4946, 4957, 4956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8914, 3129, 3130, 3141, 3140, 21807, 21830, 22083, 22060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8915, 21807, 21830, 22083, 22060, 21808, 21831, 22084, 22061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8916, 21808, 21831, 22084, 22061, 21809, 21832, 22085, 22062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8917, 21809, 21832, 22085, 22062, 21810, 21833, 22086, 22063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8918, 21810, 21833, 22086, 22063, 21811, 21834, 22087, 22064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8919, 21811, 21834, 22087, 22064, 21812, 21835, 22088, 22065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8920, 21812, 21835, 22088, 22065, 21813, 21836, 22089, 22066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8921, 21813, 21836, 22089, 22066, 21814, 21837, 22090, 22067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8922, 21814, 21837, 22090, 22067, 21815, 21838, 22091, 22068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8923, 21815, 21838, 22091, 22068, 21816, 21839, 22092, 22069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8924, 21816, 21839, 22092, 22069, 21817, 21840, 22093, 22070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8925, 21817, 21840, 22093, 22070, 21818, 21841, 22094, 22071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8926, 21818, 21841, 22094, 22071, 21819, 21842, 22095, 22072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8927, 21819, 21842, 22095, 22072, 21820, 21843, 22096, 22073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8928, 21820, 21843, 22096, 22073, 21821, 21844, 22097, 22074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8929, 21821, 21844, 22097, 22074, 21822, 21845, 22098, 22075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8930, 21822, 21845, 22098, 22075, 21823, 21846, 22099, 22076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8931, 21823, 21846, 22099, 22076, 21824, 21847, 22100, 22077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8932, 21824, 21847, 22100, 22077, 21825, 21848, 22101, 22078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8933, 21825, 21848, 22101, 22078, 21826, 21849, 22102, 22079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8934, 21826, 21849, 22102, 22079, 21827, 21850, 22103, 22080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8935, 21827, 21850, 22103, 22080, 21828, 21851, 22104, 22081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8936, 21828, 21851, 22104, 22081, 21829, 21852, 22105, 22082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8937, 21829, 21852, 22105, 22082, 4946, 4947, 4958, 4957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8938, 3130, 3131, 3142, 3141, 21830, 21853, 22106, 22083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8939, 21830, 21853, 22106, 22083, 21831, 21854, 22107, 22084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8940, 21831, 21854, 22107, 22084, 21832, 21855, 22108, 22085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8941, 21832, 21855, 22108, 22085, 21833, 21856, 22109, 22086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8942, 21833, 21856, 22109, 22086, 21834, 21857, 22110, 22087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8943, 21834, 21857, 22110, 22087, 21835, 21858, 22111, 22088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8944, 21835, 21858, 22111, 22088, 21836, 21859, 22112, 22089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8945, 21836, 21859, 22112, 22089, 21837, 21860, 22113, 22090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8946, 21837, 21860, 22113, 22090, 21838, 21861, 22114, 22091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8947, 21838, 21861, 22114, 22091, 21839, 21862, 22115, 22092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8948, 21839, 21862, 22115, 22092, 21840, 21863, 22116, 22093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8949, 21840, 21863, 22116, 22093, 21841, 21864, 22117, 22094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8950, 21841, 21864, 22117, 22094, 21842, 21865, 22118, 22095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8951, 21842, 21865, 22118, 22095, 21843, 21866, 22119, 22096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8952, 21843, 21866, 22119, 22096, 21844, 21867, 22120, 22097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8953, 21844, 21867, 22120, 22097, 21845, 21868, 22121, 22098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8954, 21845, 21868, 22121, 22098, 21846, 21869, 22122, 22099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8955, 21846, 21869, 22122, 22099, 21847, 21870, 22123, 22100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8956, 21847, 21870, 22123, 22100, 21848, 21871, 22124, 22101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8957, 21848, 21871, 22124, 22101, 21849, 21872, 22125, 22102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8958, 21849, 21872, 22125, 22102, 21850, 21873, 22126, 22103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8959, 21850, 21873, 22126, 22103, 21851, 21874, 22127, 22104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8960, 21851, 21874, 22127, 22104, 21852, 21875, 22128, 22105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8961, 21852, 21875, 22128, 22105, 4947, 4948, 4959, 4958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8962, 3131, 3132, 3143, 3142, 21853, 21876, 22129, 22106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8963, 21853, 21876, 22129, 22106, 21854, 21877, 22130, 22107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8964, 21854, 21877, 22130, 22107, 21855, 21878, 22131, 22108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8965, 21855, 21878, 22131, 22108, 21856, 21879, 22132, 22109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8966, 21856, 21879, 22132, 22109, 21857, 21880, 22133, 22110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8967, 21857, 21880, 22133, 22110, 21858, 21881, 22134, 22111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8968, 21858, 21881, 22134, 22111, 21859, 21882, 22135, 22112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8969, 21859, 21882, 22135, 22112, 21860, 21883, 22136, 22113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8970, 21860, 21883, 22136, 22113, 21861, 21884, 22137, 22114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8971, 21861, 21884, 22137, 22114, 21862, 21885, 22138, 22115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8972, 21862, 21885, 22138, 22115, 21863, 21886, 22139, 22116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8973, 21863, 21886, 22139, 22116, 21864, 21887, 22140, 22117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8974, 21864, 21887, 22140, 22117, 21865, 21888, 22141, 22118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8975, 21865, 21888, 22141, 22118, 21866, 21889, 22142, 22119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8976, 21866, 21889, 22142, 22119, 21867, 21890, 22143, 22120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8977, 21867, 21890, 22143, 22120, 21868, 21891, 22144, 22121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8978, 21868, 21891, 22144, 22121, 21869, 21892, 22145, 22122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8979, 21869, 21892, 22145, 22122, 21870, 21893, 22146, 22123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8980, 21870, 21893, 22146, 22123, 21871, 21894, 22147, 22124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8981, 21871, 21894, 22147, 22124, 21872, 21895, 22148, 22125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8982, 21872, 21895, 22148, 22125, 21873, 21896, 22149, 22126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8983, 21873, 21896, 22149, 22126, 21874, 21897, 22150, 22127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8984, 21874, 21897, 22150, 22127, 21875, 21898, 22151, 22128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8985, 21875, 21898, 22151, 22128, 4948, 4949, 4960, 4959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8986, 3132, 3133, 3144, 3143, 21876, 21899, 22152, 22129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8987, 21876, 21899, 22152, 22129, 21877, 21900, 22153, 22130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8988, 21877, 21900, 22153, 22130, 21878, 21901, 22154, 22131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8989, 21878, 21901, 22154, 22131, 21879, 21902, 22155, 22132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8990, 21879, 21902, 22155, 22132, 21880, 21903, 22156, 22133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8991, 21880, 21903, 22156, 22133, 21881, 21904, 22157, 22134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8992, 21881, 21904, 22157, 22134, 21882, 21905, 22158, 22135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8993, 21882, 21905, 22158, 22135, 21883, 21906, 22159, 22136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8994, 21883, 21906, 22159, 22136, 21884, 21907, 22160, 22137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8995, 21884, 21907, 22160, 22137, 21885, 21908, 22161, 22138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8996, 21885, 21908, 22161, 22138, 21886, 21909, 22162, 22139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8997, 21886, 21909, 22162, 22139, 21887, 21910, 22163, 22140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8998, 21887, 21910, 22163, 22140, 21888, 21911, 22164, 22141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8999, 21888, 21911, 22164, 22141, 21889, 21912, 22165, 22142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9000, 21889, 21912, 22165, 22142, 21890, 21913, 22166, 22143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9001, 21890, 21913, 22166, 22143, 21891, 21914, 22167, 22144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9002, 21891, 21914, 22167, 22144, 21892, 21915, 22168, 22145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9003, 21892, 21915, 22168, 22145, 21893, 21916, 22169, 22146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9004, 21893, 21916, 22169, 22146, 21894, 21917, 22170, 22147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9005, 21894, 21917, 22170, 22147, 21895, 21918, 22171, 22148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9006, 21895, 21918, 22171, 22148, 21896, 21919, 22172, 22149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9007, 21896, 21919, 22172, 22149, 21897, 21920, 22173, 22150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9008, 21897, 21920, 22173, 22150, 21898, 21921, 22174, 22151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9009, 21898, 21921, 22174, 22151, 4949, 4950, 4961, 4960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9010, 3133, 3134, 3145, 3144, 21899, 21922, 22175, 22152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9011, 21899, 21922, 22175, 22152, 21900, 21923, 22176, 22153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9012, 21900, 21923, 22176, 22153, 21901, 21924, 22177, 22154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9013, 21901, 21924, 22177, 22154, 21902, 21925, 22178, 22155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9014, 21902, 21925, 22178, 22155, 21903, 21926, 22179, 22156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9015, 21903, 21926, 22179, 22156, 21904, 21927, 22180, 22157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9016, 21904, 21927, 22180, 22157, 21905, 21928, 22181, 22158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9017, 21905, 21928, 22181, 22158, 21906, 21929, 22182, 22159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9018, 21906, 21929, 22182, 22159, 21907, 21930, 22183, 22160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9019, 21907, 21930, 22183, 22160, 21908, 21931, 22184, 22161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9020, 21908, 21931, 22184, 22161, 21909, 21932, 22185, 22162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9021, 21909, 21932, 22185, 22162, 21910, 21933, 22186, 22163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9022, 21910, 21933, 22186, 22163, 21911, 21934, 22187, 22164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9023, 21911, 21934, 22187, 22164, 21912, 21935, 22188, 22165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9024, 21912, 21935, 22188, 22165, 21913, 21936, 22189, 22166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9025, 21913, 21936, 22189, 22166, 21914, 21937, 22190, 22167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9026, 21914, 21937, 22190, 22167, 21915, 21938, 22191, 22168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9027, 21915, 21938, 22191, 22168, 21916, 21939, 22192, 22169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9028, 21916, 21939, 22192, 22169, 21917, 21940, 22193, 22170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9029, 21917, 21940, 22193, 22170, 21918, 21941, 22194, 22171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9030, 21918, 21941, 22194, 22171, 21919, 21942, 22195, 22172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9031, 21919, 21942, 22195, 22172, 21920, 21943, 22196, 22173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9032, 21920, 21943, 22196, 22173, 21921, 21944, 22197, 22174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9033, 21921, 21944, 22197, 22174, 4950, 4951, 4962, 4961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9034, 3134, 3135, 3146, 3145, 21922, 21945, 22198, 22175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9035, 21922, 21945, 22198, 22175, 21923, 21946, 22199, 22176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9036, 21923, 21946, 22199, 22176, 21924, 21947, 22200, 22177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9037, 21924, 21947, 22200, 22177, 21925, 21948, 22201, 22178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9038, 21925, 21948, 22201, 22178, 21926, 21949, 22202, 22179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9039, 21926, 21949, 22202, 22179, 21927, 21950, 22203, 22180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9040, 21927, 21950, 22203, 22180, 21928, 21951, 22204, 22181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9041, 21928, 21951, 22204, 22181, 21929, 21952, 22205, 22182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9042, 21929, 21952, 22205, 22182, 21930, 21953, 22206, 22183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9043, 21930, 21953, 22206, 22183, 21931, 21954, 22207, 22184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9044, 21931, 21954, 22207, 22184, 21932, 21955, 22208, 22185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9045, 21932, 21955, 22208, 22185, 21933, 21956, 22209, 22186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9046, 21933, 21956, 22209, 22186, 21934, 21957, 22210, 22187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9047, 21934, 21957, 22210, 22187, 21935, 21958, 22211, 22188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9048, 21935, 21958, 22211, 22188, 21936, 21959, 22212, 22189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9049, 21936, 21959, 22212, 22189, 21937, 21960, 22213, 22190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9050, 21937, 21960, 22213, 22190, 21938, 21961, 22214, 22191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9051, 21938, 21961, 22214, 22191, 21939, 21962, 22215, 22192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9052, 21939, 21962, 22215, 22192, 21940, 21963, 22216, 22193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9053, 21940, 21963, 22216, 22193, 21941, 21964, 22217, 22194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9054, 21941, 21964, 22217, 22194, 21942, 21965, 22218, 22195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9055, 21942, 21965, 22218, 22195, 21943, 21966, 22219, 22196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9056, 21943, 21966, 22219, 22196, 21944, 21967, 22220, 22197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9057, 21944, 21967, 22220, 22197, 4951, 4952, 4963, 4962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9058, 3135, 3136, 3147, 3146, 21945, 21968, 22221, 22198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9059, 21945, 21968, 22221, 22198, 21946, 21969, 22222, 22199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9060, 21946, 21969, 22222, 22199, 21947, 21970, 22223, 22200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9061, 21947, 21970, 22223, 22200, 21948, 21971, 22224, 22201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9062, 21948, 21971, 22224, 22201, 21949, 21972, 22225, 22202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9063, 21949, 21972, 22225, 22202, 21950, 21973, 22226, 22203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9064, 21950, 21973, 22226, 22203, 21951, 21974, 22227, 22204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9065, 21951, 21974, 22227, 22204, 21952, 21975, 22228, 22205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9066, 21952, 21975, 22228, 22205, 21953, 21976, 22229, 22206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9067, 21953, 21976, 22229, 22206, 21954, 21977, 22230, 22207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9068, 21954, 21977, 22230, 22207, 21955, 21978, 22231, 22208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9069, 21955, 21978, 22231, 22208, 21956, 21979, 22232, 22209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9070, 21956, 21979, 22232, 22209, 21957, 21980, 22233, 22210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9071, 21957, 21980, 22233, 22210, 21958, 21981, 22234, 22211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9072, 21958, 21981, 22234, 22211, 21959, 21982, 22235, 22212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9073, 21959, 21982, 22235, 22212, 21960, 21983, 22236, 22213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9074, 21960, 21983, 22236, 22213, 21961, 21984, 22237, 22214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9075, 21961, 21984, 22237, 22214, 21962, 21985, 22238, 22215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9076, 21962, 21985, 22238, 22215, 21963, 21986, 22239, 22216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9077, 21963, 21986, 22239, 22216, 21964, 21987, 22240, 22217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9078, 21964, 21987, 22240, 22217, 21965, 21988, 22241, 22218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9079, 21965, 21988, 22241, 22218, 21966, 21989, 22242, 22219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9080, 21966, 21989, 22242, 22219, 21967, 21990, 22243, 22220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9081, 21967, 21990, 22243, 22220, 4952, 4953, 4964, 4963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9082, 3136, 3137, 3148, 3147, 21968, 21991, 22244, 22221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9083, 21968, 21991, 22244, 22221, 21969, 21992, 22245, 22222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9084, 21969, 21992, 22245, 22222, 21970, 21993, 22246, 22223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9085, 21970, 21993, 22246, 22223, 21971, 21994, 22247, 22224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9086, 21971, 21994, 22247, 22224, 21972, 21995, 22248, 22225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9087, 21972, 21995, 22248, 22225, 21973, 21996, 22249, 22226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9088, 21973, 21996, 22249, 22226, 21974, 21997, 22250, 22227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9089, 21974, 21997, 22250, 22227, 21975, 21998, 22251, 22228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9090, 21975, 21998, 22251, 22228, 21976, 21999, 22252, 22229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9091, 21976, 21999, 22252, 22229, 21977, 22000, 22253, 22230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9092, 21977, 22000, 22253, 22230, 21978, 22001, 22254, 22231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9093, 21978, 22001, 22254, 22231, 21979, 22002, 22255, 22232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9094, 21979, 22002, 22255, 22232, 21980, 22003, 22256, 22233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9095, 21980, 22003, 22256, 22233, 21981, 22004, 22257, 22234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9096, 21981, 22004, 22257, 22234, 21982, 22005, 22258, 22235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9097, 21982, 22005, 22258, 22235, 21983, 22006, 22259, 22236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9098, 21983, 22006, 22259, 22236, 21984, 22007, 22260, 22237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9099, 21984, 22007, 22260, 22237, 21985, 22008, 22261, 22238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9100, 21985, 22008, 22261, 22238, 21986, 22009, 22262, 22239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9101, 21986, 22009, 22262, 22239, 21987, 22010, 22263, 22240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9102, 21987, 22010, 22263, 22240, 21988, 22011, 22264, 22241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9103, 21988, 22011, 22264, 22241, 21989, 22012, 22265, 22242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9104, 21989, 22012, 22265, 22242, 21990, 22013, 22266, 22243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9105, 21990, 22013, 22266, 22243, 4953, 4954, 4965, 4964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9106, 3137, 283, 284, 3148, 21991, 4246, 4269, 22244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9107, 21991, 4246, 4269, 22244, 21992, 4247, 4270, 22245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9108, 21992, 4247, 4270, 22245, 21993, 4248, 4271, 22246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9109, 21993, 4248, 4271, 22246, 21994, 4249, 4272, 22247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9110, 21994, 4249, 4272, 22247, 21995, 4250, 4273, 22248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9111, 21995, 4250, 4273, 22248, 21996, 4251, 4274, 22249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9112, 21996, 4251, 4274, 22249, 21997, 4252, 4275, 22250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9113, 21997, 4252, 4275, 22250, 21998, 4253, 4276, 22251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9114, 21998, 4253, 4276, 22251, 21999, 4254, 4277, 22252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9115, 21999, 4254, 4277, 22252, 22000, 4255, 4278, 22253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9116, 22000, 4255, 4278, 22253, 22001, 4256, 4279, 22254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9117, 22001, 4256, 4279, 22254, 22002, 4257, 4280, 22255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9118, 22002, 4257, 4280, 22255, 22003, 4258, 4281, 22256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9119, 22003, 4258, 4281, 22256, 22004, 4259, 4282, 22257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9120, 22004, 4259, 4282, 22257, 22005, 4260, 4283, 22258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9121, 22005, 4260, 4283, 22258, 22006, 4261, 4284, 22259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9122, 22006, 4261, 4284, 22259, 22007, 4262, 4285, 22260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9123, 22007, 4262, 4285, 22260, 22008, 4263, 4286, 22261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9124, 22008, 4263, 4286, 22261, 22009, 4264, 4287, 22262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9125, 22009, 4264, 4287, 22262, 22010, 4265, 4288, 22263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9126, 22010, 4265, 4288, 22263, 22011, 4266, 4289, 22264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9127, 22011, 4266, 4289, 22264, 22012, 4267, 4290, 22265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9128, 22012, 4267, 4290, 22265, 22013, 4268, 4291, 22266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9129, 22013, 4268, 4291, 22266, 4954, 443, 444, 4965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9130, 250, 3138, 3149, 251, 3487, 22014, 22267, 3510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9131, 3487, 22014, 22267, 3510, 3488, 22015, 22268, 3511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9132, 3488, 22015, 22268, 3511, 3489, 22016, 22269, 3512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9133, 3489, 22016, 22269, 3512, 3490, 22017, 22270, 3513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9134, 3490, 22017, 22270, 3513, 3491, 22018, 22271, 3514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9135, 3491, 22018, 22271, 3514, 3492, 22019, 22272, 3515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9136, 3492, 22019, 22272, 3515, 3493, 22020, 22273, 3516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9137, 3493, 22020, 22273, 3516, 3494, 22021, 22274, 3517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9138, 3494, 22021, 22274, 3517, 3495, 22022, 22275, 3518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9139, 3495, 22022, 22275, 3518, 3496, 22023, 22276, 3519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9140, 3496, 22023, 22276, 3519, 3497, 22024, 22277, 3520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9141, 3497, 22024, 22277, 3520, 3498, 22025, 22278, 3521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9142, 3498, 22025, 22278, 3521, 3499, 22026, 22279, 3522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9143, 3499, 22026, 22279, 3522, 3500, 22027, 22280, 3523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9144, 3500, 22027, 22280, 3523, 3501, 22028, 22281, 3524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9145, 3501, 22028, 22281, 3524, 3502, 22029, 22282, 3525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9146, 3502, 22029, 22282, 3525, 3503, 22030, 22283, 3526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9147, 3503, 22030, 22283, 3526, 3504, 22031, 22284, 3527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9148, 3504, 22031, 22284, 3527, 3505, 22032, 22285, 3528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9149, 3505, 22032, 22285, 3528, 3506, 22033, 22286, 3529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9150, 3506, 22033, 22286, 3529, 3507, 22034, 22287, 3530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9151, 3507, 22034, 22287, 3530, 3508, 22035, 22288, 3531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9152, 3508, 22035, 22288, 3531, 3509, 22036, 22289, 3532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9153, 3509, 22036, 22289, 3532, 364, 4955, 4966, 365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9154, 3138, 3139, 3150, 3149, 22014, 22037, 22290, 22267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9155, 22014, 22037, 22290, 22267, 22015, 22038, 22291, 22268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9156, 22015, 22038, 22291, 22268, 22016, 22039, 22292, 22269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9157, 22016, 22039, 22292, 22269, 22017, 22040, 22293, 22270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9158, 22017, 22040, 22293, 22270, 22018, 22041, 22294, 22271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9159, 22018, 22041, 22294, 22271, 22019, 22042, 22295, 22272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9160, 22019, 22042, 22295, 22272, 22020, 22043, 22296, 22273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9161, 22020, 22043, 22296, 22273, 22021, 22044, 22297, 22274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9162, 22021, 22044, 22297, 22274, 22022, 22045, 22298, 22275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9163, 22022, 22045, 22298, 22275, 22023, 22046, 22299, 22276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9164, 22023, 22046, 22299, 22276, 22024, 22047, 22300, 22277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9165, 22024, 22047, 22300, 22277, 22025, 22048, 22301, 22278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9166, 22025, 22048, 22301, 22278, 22026, 22049, 22302, 22279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9167, 22026, 22049, 22302, 22279, 22027, 22050, 22303, 22280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9168, 22027, 22050, 22303, 22280, 22028, 22051, 22304, 22281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9169, 22028, 22051, 22304, 22281, 22029, 22052, 22305, 22282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9170, 22029, 22052, 22305, 22282, 22030, 22053, 22306, 22283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9171, 22030, 22053, 22306, 22283, 22031, 22054, 22307, 22284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9172, 22031, 22054, 22307, 22284, 22032, 22055, 22308, 22285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9173, 22032, 22055, 22308, 22285, 22033, 22056, 22309, 22286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9174, 22033, 22056, 22309, 22286, 22034, 22057, 22310, 22287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9175, 22034, 22057, 22310, 22287, 22035, 22058, 22311, 22288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9176, 22035, 22058, 22311, 22288, 22036, 22059, 22312, 22289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9177, 22036, 22059, 22312, 22289, 4955, 4956, 4967, 4966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9178, 3139, 3140, 3151, 3150, 22037, 22060, 22313, 22290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9179, 22037, 22060, 22313, 22290, 22038, 22061, 22314, 22291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9180, 22038, 22061, 22314, 22291, 22039, 22062, 22315, 22292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9181, 22039, 22062, 22315, 22292, 22040, 22063, 22316, 22293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9182, 22040, 22063, 22316, 22293, 22041, 22064, 22317, 22294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9183, 22041, 22064, 22317, 22294, 22042, 22065, 22318, 22295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9184, 22042, 22065, 22318, 22295, 22043, 22066, 22319, 22296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9185, 22043, 22066, 22319, 22296, 22044, 22067, 22320, 22297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9186, 22044, 22067, 22320, 22297, 22045, 22068, 22321, 22298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9187, 22045, 22068, 22321, 22298, 22046, 22069, 22322, 22299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9188, 22046, 22069, 22322, 22299, 22047, 22070, 22323, 22300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9189, 22047, 22070, 22323, 22300, 22048, 22071, 22324, 22301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9190, 22048, 22071, 22324, 22301, 22049, 22072, 22325, 22302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9191, 22049, 22072, 22325, 22302, 22050, 22073, 22326, 22303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9192, 22050, 22073, 22326, 22303, 22051, 22074, 22327, 22304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9193, 22051, 22074, 22327, 22304, 22052, 22075, 22328, 22305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9194, 22052, 22075, 22328, 22305, 22053, 22076, 22329, 22306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9195, 22053, 22076, 22329, 22306, 22054, 22077, 22330, 22307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9196, 22054, 22077, 22330, 22307, 22055, 22078, 22331, 22308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9197, 22055, 22078, 22331, 22308, 22056, 22079, 22332, 22309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9198, 22056, 22079, 22332, 22309, 22057, 22080, 22333, 22310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9199, 22057, 22080, 22333, 22310, 22058, 22081, 22334, 22311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9200, 22058, 22081, 22334, 22311, 22059, 22082, 22335, 22312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9201, 22059, 22082, 22335, 22312, 4956, 4957, 4968, 4967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9202, 3140, 3141, 3152, 3151, 22060, 22083, 22336, 22313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9203, 22060, 22083, 22336, 22313, 22061, 22084, 22337, 22314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9204, 22061, 22084, 22337, 22314, 22062, 22085, 22338, 22315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9205, 22062, 22085, 22338, 22315, 22063, 22086, 22339, 22316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9206, 22063, 22086, 22339, 22316, 22064, 22087, 22340, 22317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9207, 22064, 22087, 22340, 22317, 22065, 22088, 22341, 22318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9208, 22065, 22088, 22341, 22318, 22066, 22089, 22342, 22319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9209, 22066, 22089, 22342, 22319, 22067, 22090, 22343, 22320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9210, 22067, 22090, 22343, 22320, 22068, 22091, 22344, 22321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9211, 22068, 22091, 22344, 22321, 22069, 22092, 22345, 22322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9212, 22069, 22092, 22345, 22322, 22070, 22093, 22346, 22323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9213, 22070, 22093, 22346, 22323, 22071, 22094, 22347, 22324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9214, 22071, 22094, 22347, 22324, 22072, 22095, 22348, 22325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9215, 22072, 22095, 22348, 22325, 22073, 22096, 22349, 22326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9216, 22073, 22096, 22349, 22326, 22074, 22097, 22350, 22327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9217, 22074, 22097, 22350, 22327, 22075, 22098, 22351, 22328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9218, 22075, 22098, 22351, 22328, 22076, 22099, 22352, 22329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9219, 22076, 22099, 22352, 22329, 22077, 22100, 22353, 22330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9220, 22077, 22100, 22353, 22330, 22078, 22101, 22354, 22331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9221, 22078, 22101, 22354, 22331, 22079, 22102, 22355, 22332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9222, 22079, 22102, 22355, 22332, 22080, 22103, 22356, 22333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9223, 22080, 22103, 22356, 22333, 22081, 22104, 22357, 22334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9224, 22081, 22104, 22357, 22334, 22082, 22105, 22358, 22335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9225, 22082, 22105, 22358, 22335, 4957, 4958, 4969, 4968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9226, 3141, 3142, 3153, 3152, 22083, 22106, 22359, 22336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9227, 22083, 22106, 22359, 22336, 22084, 22107, 22360, 22337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9228, 22084, 22107, 22360, 22337, 22085, 22108, 22361, 22338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9229, 22085, 22108, 22361, 22338, 22086, 22109, 22362, 22339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9230, 22086, 22109, 22362, 22339, 22087, 22110, 22363, 22340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9231, 22087, 22110, 22363, 22340, 22088, 22111, 22364, 22341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9232, 22088, 22111, 22364, 22341, 22089, 22112, 22365, 22342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9233, 22089, 22112, 22365, 22342, 22090, 22113, 22366, 22343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9234, 22090, 22113, 22366, 22343, 22091, 22114, 22367, 22344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9235, 22091, 22114, 22367, 22344, 22092, 22115, 22368, 22345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9236, 22092, 22115, 22368, 22345, 22093, 22116, 22369, 22346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9237, 22093, 22116, 22369, 22346, 22094, 22117, 22370, 22347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9238, 22094, 22117, 22370, 22347, 22095, 22118, 22371, 22348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9239, 22095, 22118, 22371, 22348, 22096, 22119, 22372, 22349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9240, 22096, 22119, 22372, 22349, 22097, 22120, 22373, 22350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9241, 22097, 22120, 22373, 22350, 22098, 22121, 22374, 22351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9242, 22098, 22121, 22374, 22351, 22099, 22122, 22375, 22352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9243, 22099, 22122, 22375, 22352, 22100, 22123, 22376, 22353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9244, 22100, 22123, 22376, 22353, 22101, 22124, 22377, 22354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9245, 22101, 22124, 22377, 22354, 22102, 22125, 22378, 22355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9246, 22102, 22125, 22378, 22355, 22103, 22126, 22379, 22356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9247, 22103, 22126, 22379, 22356, 22104, 22127, 22380, 22357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9248, 22104, 22127, 22380, 22357, 22105, 22128, 22381, 22358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9249, 22105, 22128, 22381, 22358, 4958, 4959, 4970, 4969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9250, 3142, 3143, 3154, 3153, 22106, 22129, 22382, 22359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9251, 22106, 22129, 22382, 22359, 22107, 22130, 22383, 22360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9252, 22107, 22130, 22383, 22360, 22108, 22131, 22384, 22361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9253, 22108, 22131, 22384, 22361, 22109, 22132, 22385, 22362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9254, 22109, 22132, 22385, 22362, 22110, 22133, 22386, 22363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9255, 22110, 22133, 22386, 22363, 22111, 22134, 22387, 22364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9256, 22111, 22134, 22387, 22364, 22112, 22135, 22388, 22365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9257, 22112, 22135, 22388, 22365, 22113, 22136, 22389, 22366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9258, 22113, 22136, 22389, 22366, 22114, 22137, 22390, 22367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9259, 22114, 22137, 22390, 22367, 22115, 22138, 22391, 22368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9260, 22115, 22138, 22391, 22368, 22116, 22139, 22392, 22369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9261, 22116, 22139, 22392, 22369, 22117, 22140, 22393, 22370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9262, 22117, 22140, 22393, 22370, 22118, 22141, 22394, 22371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9263, 22118, 22141, 22394, 22371, 22119, 22142, 22395, 22372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9264, 22119, 22142, 22395, 22372, 22120, 22143, 22396, 22373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9265, 22120, 22143, 22396, 22373, 22121, 22144, 22397, 22374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9266, 22121, 22144, 22397, 22374, 22122, 22145, 22398, 22375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9267, 22122, 22145, 22398, 22375, 22123, 22146, 22399, 22376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9268, 22123, 22146, 22399, 22376, 22124, 22147, 22400, 22377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9269, 22124, 22147, 22400, 22377, 22125, 22148, 22401, 22378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9270, 22125, 22148, 22401, 22378, 22126, 22149, 22402, 22379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
