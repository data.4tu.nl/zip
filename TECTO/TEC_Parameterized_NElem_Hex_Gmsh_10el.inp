48574, 48560, 48707, 48720, 48573
29460, 46915, 46959, 46963, 46919, 18054, 18065, 18066, 18055, 48709, 48721, 48722, 48574, 0, 0, 0, 
0, 48563, 48710, 48723, 48576
29461, 2520, 2531, 2532, 2521, 46916, 46960, 46964, 46920, 0, 0, 0, 0, 48713, 48725, 48726, 
48578, 48564, 48711, 48724, 48577
29462, 46916, 46960, 46964, 46920, 46917, 46961, 46965, 46921, 48713, 48725, 48726, 48578, 48716, 48728, 48729, 
48581, 48567, 48714, 48727, 48580
29463, 46917, 46961, 46965, 46921, 46918, 46962, 46966, 46922, 48716, 48728, 48729, 48581, 48719, 48731, 48732, 
48584, 48570, 48717, 48730, 48583
29464, 46918, 46962, 46966, 46922, 46919, 46963, 46967, 46923, 48719, 48731, 48732, 48584, 48722, 48734, 48735, 
48587, 48573, 48720, 48733, 48586
29465, 46919, 46963, 46967, 46923, 18055, 18066, 18067, 18056, 48722, 48734, 48735, 48587, 0, 0, 0, 
0, 48576, 48723, 48736, 48589
29466, 2521, 2532, 2533, 2522, 46920, 46964, 46968, 46924, 0, 0, 0, 0, 48726, 48738, 48739, 
48591, 48577, 48724, 48737, 48590
29467, 46920, 46964, 46968, 46924, 46921, 46965, 46969, 46925, 48726, 48738, 48739, 48591, 48729, 48741, 48742, 
48594, 48580, 48727, 48740, 48593
29468, 46921, 46965, 46969, 46925, 46922, 46966, 46970, 46926, 48729, 48741, 48742, 48594, 48732, 48744, 48745, 
48597, 48583, 48730, 48743, 48596
29469, 46922, 46966, 46970, 46926, 46923, 46967, 46971, 46927, 48732, 48744, 48745, 48597, 48735, 48747, 48748, 
48600, 48586, 48733, 48746, 48599
29470, 46923, 46967, 46971, 46927, 18056, 18067, 18068, 18057, 48735, 48747, 48748, 48600, 0, 0, 0, 
0, 48589, 48736, 48749, 48602
29471, 2522, 2533, 2534, 2523, 46924, 46968, 46972, 46928, 0, 0, 0, 0, 48739, 48751, 48752, 
48604, 48590, 48737, 48750, 48603
29472, 46924, 46968, 46972, 46928, 46925, 46969, 46973, 46929, 48739, 48751, 48752, 48604, 48742, 48754, 48755, 
48607, 48593, 48740, 48753, 48606
29473, 46925, 46969, 46973, 46929, 46926, 46970, 46974, 46930, 48742, 48754, 48755, 48607, 48745, 48757, 48758, 
48610, 48596, 48743, 48756, 48609
29474, 46926, 46970, 46974, 46930, 46927, 46971, 46975, 46931, 48745, 48757, 48758, 48610, 48748, 48760, 48761, 
48613, 48599, 48746, 48759, 48612
29475, 46927, 46971, 46975, 46931, 18057, 18068, 18069, 18058, 48748, 48760, 48761, 48613, 0, 0, 0, 
0, 48602, 48749, 48762, 48615
29476, 2523, 2534, 2535, 2524, 46928, 46972, 46976, 46932, 0, 0, 0, 0, 48752, 48764, 48765, 
48617, 48603, 48750, 48763, 48616
29477, 46928, 46972, 46976, 46932, 46929, 46973, 46977, 46933, 48752, 48764, 48765, 48617, 48755, 48767, 48768, 
48620, 48606, 48753, 48766, 48619
29478, 46929, 46973, 46977, 46933, 46930, 46974, 46978, 46934, 48755, 48767, 48768, 48620, 48758, 48770, 48771, 
48623, 48609, 48756, 48769, 48622
29479, 46930, 46974, 46978, 46934, 46931, 46975, 46979, 46935, 48758, 48770, 48771, 48623, 48761, 48773, 48774, 
48626, 48612, 48759, 48772, 48625
29480, 46931, 46975, 46979, 46935, 18058, 18069, 18070, 18059, 48761, 48773, 48774, 48626, 0, 0, 0, 
0, 48615, 48762, 48775, 48628
29481, 2524, 2535, 2536, 2525, 46932, 46976, 46980, 46936, 0, 0, 0, 0, 48765, 48777, 48778, 
48630, 48616, 48763, 48776, 48629
29482, 46932, 46976, 46980, 46936, 46933, 46977, 46981, 46937, 48765, 48777, 48778, 48630, 48768, 48780, 48781, 
48633, 48619, 48766, 48779, 48632
29483, 46933, 46977, 46981, 46937, 46934, 46978, 46982, 46938, 48768, 48780, 48781, 48633, 48771, 48783, 48784, 
48636, 48622, 48769, 48782, 48635
29484, 46934, 46978, 46982, 46938, 46935, 46979, 46983, 46939, 48771, 48783, 48784, 48636, 48774, 48786, 48787, 
48639, 48625, 48772, 48785, 48638
29485, 46935, 46979, 46983, 46939, 18059, 18070, 18071, 18060, 48774, 48786, 48787, 48639, 0, 0, 0, 
0, 48628, 48775, 48788, 48641
29486, 2525, 2536, 2537, 2526, 46936, 46980, 46984, 46940, 0, 0, 0, 0, 48778, 48790, 48791, 
48643, 48629, 48776, 48789, 48642
29487, 46936, 46980, 46984, 46940, 46937, 46981, 46985, 46941, 48778, 48790, 48791, 48643, 48781, 48793, 48794, 
48646, 48632, 48779, 48792, 48645
29488, 46937, 46981, 46985, 46941, 46938, 46982, 46986, 46942, 48781, 48793, 48794, 48646, 48784, 48796, 48797, 
48649, 48635, 48782, 48795, 48648
29489, 46938, 46982, 46986, 46942, 46939, 46983, 46987, 46943, 48784, 48796, 48797, 48649, 48787, 48799, 48800, 
48652, 48638, 48785, 48798, 48651
29490, 46939, 46983, 46987, 46943, 18060, 18071, 18072, 18061, 48787, 48799, 48800, 48652, 0, 0, 0, 
0, 48641, 48788, 48801, 48654
29491, 2526, 2537, 2538, 2527, 46940, 46984, 46988, 46944, 0, 0, 0, 0, 48791, 48803, 48804, 
48656, 48642, 48789, 48802, 48655
29492, 46940, 46984, 46988, 46944, 46941, 46985, 46989, 46945, 48791, 48803, 48804, 48656, 48794, 48806, 48807, 
48659, 48645, 48792, 48805, 48658
29493, 46941, 46985, 46989, 46945, 46942, 46986, 46990, 46946, 48794, 48806, 48807, 48659, 48797, 48809, 48810, 
48662, 48648, 48795, 48808, 48661
29494, 46942, 46986, 46990, 46946, 46943, 46987, 46991, 46947, 48797, 48809, 48810, 48662, 48800, 48812, 48813, 
48665, 48651, 48798, 48811, 48664
29495, 46943, 46987, 46991, 46947, 18061, 18072, 18073, 18062, 48800, 48812, 48813, 48665, 0, 0, 0, 
0, 48654, 48801, 48814, 48667
29496, 2527, 2538, 2539, 2528, 46944, 46988, 46992, 46948, 0, 0, 0, 0, 48804, 48816, 48817, 
48669, 48655, 48802, 48815, 48668
29497, 46944, 46988, 46992, 46948, 46945, 46989, 46993, 46949, 48804, 48816, 48817, 48669, 48807, 48819, 48820, 
48672, 48658, 48805, 48818, 48671
29498, 46945, 46989, 46993, 46949, 46946, 46990, 46994, 46950, 48807, 48819, 48820, 48672, 48810, 48822, 48823, 
48675, 48661, 48808, 48821, 48674
29499, 46946, 46990, 46994, 46950, 46947, 46991, 46995, 46951, 48810, 48822, 48823, 48675, 48813, 48825, 48826, 
48678, 48664, 48811, 48824, 48677
29500, 46947, 46991, 46995, 46951, 18062, 18073, 18074, 18063, 48813, 48825, 48826, 48678, 0, 0, 0, 
0, 48667, 48814, 48827, 48680
29501, 2528, 2539, 180, 179, 46948, 46992, 17776, 17772, 0, 0, 0, 0, 48817, 48828, 0, 
48681, 48668, 48815, 0, 0
29502, 46948, 46992, 17776, 17772, 46949, 46993, 17777, 17773, 48817, 48828, 0, 48681, 48820, 48829, 0, 
48682, 48671, 48818, 0, 0
29503, 46949, 46993, 17777, 17773, 46950, 46994, 17778, 17774, 48820, 48829, 0, 48682, 48823, 48830, 0, 
48683, 48674, 48821, 0, 0
29504, 46950, 46994, 17778, 17774, 46951, 46995, 17779, 17775, 48823, 48830, 0, 48683, 48826, 48831, 0, 
48684, 48677, 48824, 0, 0
29505, 46951, 46995, 17779, 17775, 18063, 18074, 2239, 2238, 48826, 48831, 0, 48684, 0, 0, 0, 
0, 48680, 48827, 0, 0
29506, 157, 158, 2540, 2529, 17326, 17330, 46996, 46952, 0, 0, 0, 0, 17463, 48833, 48834, 
48686, 17453, 17462, 48832, 48685
29507, 17326, 17330, 46996, 46952, 17327, 17331, 46997, 46953, 17463, 48833, 48834, 48686, 17465, 48836, 48837, 
48689, 17455, 17464, 48835, 48688
29508, 17327, 17331, 46997, 46953, 17328, 17332, 46998, 46954, 17465, 48836, 48837, 48689, 17467, 48839, 48840, 
48692, 17457, 17466, 48838, 48691
29509, 17328, 17332, 46998, 46954, 17329, 17333, 46999, 46955, 17467, 48839, 48840, 48692, 17469, 48842, 48843, 
48695, 17459, 17468, 48841, 48694
29510, 17329, 17333, 46999, 46955, 2197, 2198, 18075, 18064, 17469, 48842, 48843, 48695, 0, 0, 0, 
0, 17461, 17470, 48844, 48697
29511, 2529, 2540, 2541, 2530, 46952, 46996, 47000, 46956, 0, 0, 0, 0, 48834, 48846, 48847, 
48699, 48685, 48832, 48845, 48698
29512, 46952, 46996, 47000, 46956, 46953, 46997, 47001, 46957, 48834, 48846, 48847, 48699, 48837, 48849, 48850, 
48702, 48688, 48835, 48848, 48701
29513, 46953, 46997, 47001, 46957, 46954, 46998, 47002, 46958, 48837, 48849, 48850, 48702, 48840, 48852, 48853, 
48705, 48691, 48838, 48851, 48704
29514, 46954, 46998, 47002, 46958, 46955, 46999, 47003, 46959, 48840, 48852, 48853, 48705, 48843, 48855, 48856, 
48708, 48694, 48841, 48854, 48707
29515, 46955, 46999, 47003, 46959, 18064, 18075, 18076, 18065, 48843, 48855, 48856, 48708, 0, 0, 0, 
0, 48697, 48844, 48857, 48710
29516, 2530, 2541, 2542, 2531, 46956, 47000, 47004, 46960, 0, 0, 0, 0, 48847, 48859, 48860, 
48712, 48698, 48845, 48858, 48711
29517, 46956, 47000, 47004, 46960, 46957, 47001, 47005, 46961, 48847, 48859, 48860, 48712, 48850, 48862, 48863, 
48715, 48701, 48848, 48861, 48714
29518, 46957, 47001, 47005, 46961, 46958, 47002, 47006, 46962, 48850, 48862, 48863, 48715, 48853, 48865, 48866, 
48718, 48704, 48851, 48864, 48717
29519, 46958, 47002, 47006, 46962, 46959, 47003, 47007, 46963, 48853, 48865, 48866, 48718, 48856, 48868, 48869, 
48721, 48707, 48854, 48867, 48720
29520, 46959, 47003, 47007, 46963, 18065, 18076, 18077, 18066, 48856, 48868, 48869, 48721, 0, 0, 0, 
0, 48710, 48857, 48870, 48723
29521, 2531, 2542, 2543, 2532, 46960, 47004, 47008, 46964, 0, 0, 0, 0, 48860, 48872, 48873, 
48725, 48711, 48858, 48871, 48724
29522, 46960, 47004, 47008, 46964, 46961, 47005, 47009, 46965, 48860, 48872, 48873, 48725, 48863, 48875, 48876, 
48728, 48714, 48861, 48874, 48727
29523, 46961, 47005, 47009, 46965, 46962, 47006, 47010, 46966, 48863, 48875, 48876, 48728, 48866, 48878, 48879, 
48731, 48717, 48864, 48877, 48730
29524, 46962, 47006, 47010, 46966, 46963, 47007, 47011, 46967, 48866, 48878, 48879, 48731, 48869, 48881, 48882, 
48734, 48720, 48867, 48880, 48733
29525, 46963, 47007, 47011, 46967, 18066, 18077, 18078, 18067, 48869, 48881, 48882, 48734, 0, 0, 0, 
0, 48723, 48870, 48883, 48736
29526, 2532, 2543, 2544, 2533, 46964, 47008, 47012, 46968, 0, 0, 0, 0, 48873, 48885, 48886, 
48738, 48724, 48871, 48884, 48737
29527, 46964, 47008, 47012, 46968, 46965, 47009, 47013, 46969, 48873, 48885, 48886, 48738, 48876, 48888, 48889, 
48741, 48727, 48874, 48887, 48740
29528, 46965, 47009, 47013, 46969, 46966, 47010, 47014, 46970, 48876, 48888, 48889, 48741, 48879, 48891, 48892, 
48744, 48730, 48877, 48890, 48743
29529, 46966, 47010, 47014, 46970, 46967, 47011, 47015, 46971, 48879, 48891, 48892, 48744, 48882, 48894, 48895, 
48747, 48733, 48880, 48893, 48746
29530, 46967, 47011, 47015, 46971, 18067, 18078, 18079, 18068, 48882, 48894, 48895, 48747, 0, 0, 0, 
0, 48736, 48883, 48896, 48749
29531, 2533, 2544, 2545, 2534, 46968, 47012, 47016, 46972, 0, 0, 0, 0, 48886, 48898, 48899, 
48751, 48737, 48884, 48897, 48750
29532, 46968, 47012, 47016, 46972, 46969, 47013, 47017, 46973, 48886, 48898, 48899, 48751, 48889, 48901, 48902, 
48754, 48740, 48887, 48900, 48753
29533, 46969, 47013, 47017, 46973, 46970, 47014, 47018, 46974, 48889, 48901, 48902, 48754, 48892, 48904, 48905, 
48757, 48743, 48890, 48903, 48756
29534, 46970, 47014, 47018, 46974, 46971, 47015, 47019, 46975, 48892, 48904, 48905, 48757, 48895, 48907, 48908, 
48760, 48746, 48893, 48906, 48759
29535, 46971, 47015, 47019, 46975, 18068, 18079, 18080, 18069, 48895, 48907, 48908, 48760, 0, 0, 0, 
0, 48749, 48896, 48909, 48762
29536, 2534, 2545, 2546, 2535, 46972, 47016, 47020, 46976, 0, 0, 0, 0, 48899, 48911, 48912, 
48764, 48750, 48897, 48910, 48763
29537, 46972, 47016, 47020, 46976, 46973, 47017, 47021, 46977, 48899, 48911, 48912, 48764, 48902, 48914, 48915, 
48767, 48753, 48900, 48913, 48766
29538, 46973, 47017, 47021, 46977, 46974, 47018, 47022, 46978, 48902, 48914, 48915, 48767, 48905, 48917, 48918, 
48770, 48756, 48903, 48916, 48769
29539, 46974, 47018, 47022, 46978, 46975, 47019, 47023, 46979, 48905, 48917, 48918, 48770, 48908, 48920, 48921, 
48773, 48759, 48906, 48919, 48772
29540, 46975, 47019, 47023, 46979, 18069, 18080, 18081, 18070, 48908, 48920, 48921, 48773, 0, 0, 0, 
0, 48762, 48909, 48922, 48775
29541, 2535, 2546, 2547, 2536, 46976, 47020, 47024, 46980, 0, 0, 0, 0, 48912, 48924, 48925, 
48777, 48763, 48910, 48923, 48776
29542, 46976, 47020, 47024, 46980, 46977, 47021, 47025, 46981, 48912, 48924, 48925, 48777, 48915, 48927, 48928, 
48780, 48766, 48913, 48926, 48779
29543, 46977, 47021, 47025, 46981, 46978, 47022, 47026, 46982, 48915, 48927, 48928, 48780, 48918, 48930, 48931, 
48783, 48769, 48916, 48929, 48782
29544, 46978, 47022, 47026, 46982, 46979, 47023, 47027, 46983, 48918, 48930, 48931, 48783, 48921, 48933, 48934, 
48786, 48772, 48919, 48932, 48785
29545, 46979, 47023, 47027, 46983, 18070, 18081, 18082, 18071, 48921, 48933, 48934, 48786, 0, 0, 0, 
0, 48775, 48922, 48935, 48788
29546, 2536, 2547, 2548, 2537, 46980, 47024, 47028, 46984, 0, 0, 0, 0, 48925, 48937, 48938, 
48790, 48776, 48923, 48936, 48789
29547, 46980, 47024, 47028, 46984, 46981, 47025, 47029, 46985, 48925, 48937, 48938, 48790, 48928, 48940, 48941, 
48793, 48779, 48926, 48939, 48792
29548, 46981, 47025, 47029, 46985, 46982, 47026, 47030, 46986, 48928, 48940, 48941, 48793, 48931, 48943, 48944, 
48796, 48782, 48929, 48942, 48795
29549, 46982, 47026, 47030, 46986, 46983, 47027, 47031, 46987, 48931, 48943, 48944, 48796, 48934, 48946, 48947, 
48799, 48785, 48932, 48945, 48798
29550, 46983, 47027, 47031, 46987, 18071, 18082, 18083, 18072, 48934, 48946, 48947, 48799, 0, 0, 0, 
0, 48788, 48935, 48948, 48801
29551, 2537, 2548, 2549, 2538, 46984, 47028, 47032, 46988, 0, 0, 0, 0, 48938, 48950, 48951, 
48803, 48789, 48936, 48949, 48802
29552, 46984, 47028, 47032, 46988, 46985, 47029, 47033, 46989, 48938, 48950, 48951, 48803, 48941, 48953, 48954, 
48806, 48792, 48939, 48952, 48805
29553, 46985, 47029, 47033, 46989, 46986, 47030, 47034, 46990, 48941, 48953, 48954, 48806, 48944, 48956, 48957, 
48809, 48795, 48942, 48955, 48808
29554, 46986, 47030, 47034, 46990, 46987, 47031, 47035, 46991, 48944, 48956, 48957, 48809, 48947, 48959, 48960, 
48812, 48798, 48945, 48958, 48811
29555, 46987, 47031, 47035, 46991, 18072, 18083, 18084, 18073, 48947, 48959, 48960, 48812, 0, 0, 0, 
0, 48801, 48948, 48961, 48814
29556, 2538, 2549, 2550, 2539, 46988, 47032, 47036, 46992, 0, 0, 0, 0, 48951, 48963, 48964, 
48816, 48802, 48949, 48962, 48815
29557, 46988, 47032, 47036, 46992, 46989, 47033, 47037, 46993, 48951, 48963, 48964, 48816, 48954, 48966, 48967, 
48819, 48805, 48952, 48965, 48818
29558, 46989, 47033, 47037, 46993, 46990, 47034, 47038, 46994, 48954, 48966, 48967, 48819, 48957, 48969, 48970, 
48822, 48808, 48955, 48968, 48821
29559, 46990, 47034, 47038, 46994, 46991, 47035, 47039, 46995, 48957, 48969, 48970, 48822, 48960, 48972, 48973, 
48825, 48811, 48958, 48971, 48824
29560, 46991, 47035, 47039, 46995, 18073, 18084, 18085, 18074, 48960, 48972, 48973, 48825, 0, 0, 0, 
0, 48814, 48961, 48974, 48827
29561, 2539, 2550, 181, 180, 46992, 47036, 17780, 17776, 0, 0, 0, 0, 48964, 48975, 0, 
48828, 48815, 48962, 0, 0
29562, 46992, 47036, 17780, 17776, 46993, 47037, 17781, 17777, 48964, 48975, 0, 48828, 48967, 48976, 0, 
48829, 48818, 48965, 0, 0
29563, 46993, 47037, 17781, 17777, 46994, 47038, 17782, 17778, 48967, 48976, 0, 48829, 48970, 48977, 0, 
48830, 48821, 48968, 0, 0
29564, 46994, 47038, 17782, 17778, 46995, 47039, 17783, 17779, 48970, 48977, 0, 48830, 48973, 48978, 0, 
48831, 48824, 48971, 0, 0
29565, 46995, 47039, 17783, 17779, 18074, 18085, 2240, 2239, 48973, 48978, 0, 48831, 0, 0, 0, 
0, 48827, 48974, 0, 0
29566, 158, 159, 2551, 2540, 17330, 17334, 47040, 46996, 0, 0, 0, 0, 17472, 48980, 48981, 
48833, 17462, 17471, 48979, 48832
29567, 17330, 17334, 47040, 46996, 17331, 17335, 47041, 46997, 17472, 48980, 48981, 48833, 17474, 48983, 48984, 
48836, 17464, 17473, 48982, 48835
29568, 17331, 17335, 47041, 46997, 17332, 17336, 47042, 46998, 17474, 48983, 48984, 48836, 17476, 48986, 48987, 
48839, 17466, 17475, 48985, 48838
29569, 17332, 17336, 47042, 46998, 17333, 17337, 47043, 46999, 17476, 48986, 48987, 48839, 17478, 48989, 48990, 
48842, 17468, 17477, 48988, 48841
29570, 17333, 17337, 47043, 46999, 2198, 2199, 18086, 18075, 17478, 48989, 48990, 48842, 0, 0, 0, 
0, 17470, 17479, 48991, 48844
29571, 2540, 2551, 2552, 2541, 46996, 47040, 47044, 47000, 0, 0, 0, 0, 48981, 48993, 48994, 
48846, 48832, 48979, 48992, 48845
29572, 46996, 47040, 47044, 47000, 46997, 47041, 47045, 47001, 48981, 48993, 48994, 48846, 48984, 48996, 48997, 
48849, 48835, 48982, 48995, 48848
29573, 46997, 47041, 47045, 47001, 46998, 47042, 47046, 47002, 48984, 48996, 48997, 48849, 48987, 48999, 49000, 
48852, 48838, 48985, 48998, 48851
29574, 46998, 47042, 47046, 47002, 46999, 47043, 47047, 47003, 48987, 48999, 49000, 48852, 48990, 49002, 49003, 
48855, 48841, 48988, 49001, 48854
29575, 46999, 47043, 47047, 47003, 18075, 18086, 18087, 18076, 48990, 49002, 49003, 48855, 0, 0, 0, 
0, 48844, 48991, 49004, 48857
29576, 2541, 2552, 2553, 2542, 47000, 47044, 47048, 47004, 0, 0, 0, 0, 48994, 49006, 49007, 
48859, 48845, 48992, 49005, 48858
29577, 47000, 47044, 47048, 47004, 47001, 47045, 47049, 47005, 48994, 49006, 49007, 48859, 48997, 49009, 49010, 
48862, 48848, 48995, 49008, 48861
29578, 47001, 47045, 47049, 47005, 47002, 47046, 47050, 47006, 48997, 49009, 49010, 48862, 49000, 49012, 49013, 
48865, 48851, 48998, 49011, 48864
29579, 47002, 47046, 47050, 47006, 47003, 47047, 47051, 47007, 49000, 49012, 49013, 48865, 49003, 49015, 49016, 
48868, 48854, 49001, 49014, 48867
29580, 47003, 47047, 47051, 47007, 18076, 18087, 18088, 18077, 49003, 49015, 49016, 48868, 0, 0, 0, 
0, 48857, 49004, 49017, 48870
29581, 2542, 2553, 2554, 2543, 47004, 47048, 47052, 47008, 0, 0, 0, 0, 49007, 49019, 49020, 
48872, 48858, 49005, 49018, 48871
29582, 47004, 47048, 47052, 47008, 47005, 47049, 47053, 47009, 49007, 49019, 49020, 48872, 49010, 49022, 49023, 
48875, 48861, 49008, 49021, 48874
29583, 47005, 47049, 47053, 47009, 47006, 47050, 47054, 47010, 49010, 49022, 49023, 48875, 49013, 49025, 49026, 
48878, 48864, 49011, 49024, 48877
29584, 47006, 47050, 47054, 47010, 47007, 47051, 47055, 47011, 49013, 49025, 49026, 48878, 49016, 49028, 49029, 
48881, 48867, 49014, 49027, 48880
29585, 47007, 47051, 47055, 47011, 18077, 18088, 18089, 18078, 49016, 49028, 49029, 48881, 0, 0, 0, 
0, 48870, 49017, 49030, 48883
29586, 2543, 2554, 2555, 2544, 47008, 47052, 47056, 47012, 0, 0, 0, 0, 49020, 49032, 49033, 
48885, 48871, 49018, 49031, 48884
29587, 47008, 47052, 47056, 47012, 47009, 47053, 47057, 47013, 49020, 49032, 49033, 48885, 49023, 49035, 49036, 
48888, 48874, 49021, 49034, 48887
29588, 47009, 47053, 47057, 47013, 47010, 47054, 47058, 47014, 49023, 49035, 49036, 48888, 49026, 49038, 49039, 
48891, 48877, 49024, 49037, 48890
29589, 47010, 47054, 47058, 47014, 47011, 47055, 47059, 47015, 49026, 49038, 49039, 48891, 49029, 49041, 49042, 
48894, 48880, 49027, 49040, 48893
29590, 47011, 47055, 47059, 47015, 18078, 18089, 18090, 18079, 49029, 49041, 49042, 48894, 0, 0, 0, 
0, 48883, 49030, 49043, 48896
29591, 2544, 2555, 2556, 2545, 47012, 47056, 47060, 47016, 0, 0, 0, 0, 49033, 49045, 49046, 
48898, 48884, 49031, 49044, 48897
29592, 47012, 47056, 47060, 47016, 47013, 47057, 47061, 47017, 49033, 49045, 49046, 48898, 49036, 49048, 49049, 
48901, 48887, 49034, 49047, 48900
29593, 47013, 47057, 47061, 47017, 47014, 47058, 47062, 47018, 49036, 49048, 49049, 48901, 49039, 49051, 49052, 
48904, 48890, 49037, 49050, 48903
29594, 47014, 47058, 47062, 47018, 47015, 47059, 47063, 47019, 49039, 49051, 49052, 48904, 49042, 49054, 49055, 
48907, 48893, 49040, 49053, 48906
29595, 47015, 47059, 47063, 47019, 18079, 18090, 18091, 18080, 49042, 49054, 49055, 48907, 0, 0, 0, 
0, 48896, 49043, 49056, 48909
29596, 2545, 2556, 2557, 2546, 47016, 47060, 47064, 47020, 0, 0, 0, 0, 49046, 49058, 49059, 
48911, 48897, 49044, 49057, 48910
29597, 47016, 47060, 47064, 47020, 47017, 47061, 47065, 47021, 49046, 49058, 49059, 48911, 49049, 49061, 49062, 
48914, 48900, 49047, 49060, 48913
29598, 47017, 47061, 47065, 47021, 47018, 47062, 47066, 47022, 49049, 49061, 49062, 48914, 49052, 49064, 49065, 
48917, 48903, 49050, 49063, 48916
29599, 47018, 47062, 47066, 47022, 47019, 47063, 47067, 47023, 49052, 49064, 49065, 48917, 49055, 49067, 49068, 
48920, 48906, 49053, 49066, 48919
29600, 47019, 47063, 47067, 47023, 18080, 18091, 18092, 18081, 49055, 49067, 49068, 48920, 0, 0, 0, 
0, 48909, 49056, 49069, 48922
29601, 2546, 2557, 2558, 2547, 47020, 47064, 47068, 47024, 0, 0, 0, 0, 49059, 49071, 49072, 
48924, 48910, 49057, 49070, 48923
29602, 47020, 47064, 47068, 47024, 47021, 47065, 47069, 47025, 49059, 49071, 49072, 48924, 49062, 49074, 49075, 
48927, 48913, 49060, 49073, 48926
29603, 47021, 47065, 47069, 47025, 47022, 47066, 47070, 47026, 49062, 49074, 49075, 48927, 49065, 49077, 49078, 
48930, 48916, 49063, 49076, 48929
29604, 47022, 47066, 47070, 47026, 47023, 47067, 47071, 47027, 49065, 49077, 49078, 48930, 49068, 49080, 49081, 
48933, 48919, 49066, 49079, 48932
29605, 47023, 47067, 47071, 47027, 18081, 18092, 18093, 18082, 49068, 49080, 49081, 48933, 0, 0, 0, 
0, 48922, 49069, 49082, 48935
29606, 2547, 2558, 2559, 2548, 47024, 47068, 47072, 47028, 0, 0, 0, 0, 49072, 49084, 49085, 
48937, 48923, 49070, 49083, 48936
29607, 47024, 47068, 47072, 47028, 47025, 47069, 47073, 47029, 49072, 49084, 49085, 48937, 49075, 49087, 49088, 
48940, 48926, 49073, 49086, 48939
29608, 47025, 47069, 47073, 47029, 47026, 47070, 47074, 47030, 49075, 49087, 49088, 48940, 49078, 49090, 49091, 
48943, 48929, 49076, 49089, 48942
29609, 47026, 47070, 47074, 47030, 47027, 47071, 47075, 47031, 49078, 49090, 49091, 48943, 49081, 49093, 49094, 
48946, 48932, 49079, 49092, 48945
29610, 47027, 47071, 47075, 47031, 18082, 18093, 18094, 18083, 49081, 49093, 49094, 48946, 0, 0, 0, 
0, 48935, 49082, 49095, 48948
29611, 2548, 2559, 2560, 2549, 47028, 47072, 47076, 47032, 0, 0, 0, 0, 49085, 49097, 49098, 
48950, 48936, 49083, 49096, 48949
29612, 47028, 47072, 47076, 47032, 47029, 47073, 47077, 47033, 49085, 49097, 49098, 48950, 49088, 49100, 49101, 
48953, 48939, 49086, 49099, 48952
29613, 47029, 47073, 47077, 47033, 47030, 47074, 47078, 47034, 49088, 49100, 49101, 48953, 49091, 49103, 49104, 
48956, 48942, 49089, 49102, 48955
29614, 47030, 47074, 47078, 47034, 47031, 47075, 47079, 47035, 49091, 49103, 49104, 48956, 49094, 49106, 49107, 
48959, 48945, 49092, 49105, 48958
29615, 47031, 47075, 47079, 47035, 18083, 18094, 18095, 18084, 49094, 49106, 49107, 48959, 0, 0, 0, 
0, 48948, 49095, 49108, 48961
29616, 2549, 2560, 2561, 2550, 47032, 47076, 47080, 47036, 0, 0, 0, 0, 49098, 49110, 49111, 
48963, 48949, 49096, 49109, 48962
29617, 47032, 47076, 47080, 47036, 47033, 47077, 47081, 47037, 49098, 49110, 49111, 48963, 49101, 49113, 49114, 
48966, 48952, 49099, 49112, 48965
29618, 47033, 47077, 47081, 47037, 47034, 47078, 47082, 47038, 49101, 49113, 49114, 48966, 49104, 49116, 49117, 
48969, 48955, 49102, 49115, 48968
29619, 47034, 47078, 47082, 47038, 47035, 47079, 47083, 47039, 49104, 49116, 49117, 48969, 49107, 49119, 49120, 
48972, 48958, 49105, 49118, 48971
29620, 47035, 47079, 47083, 47039, 18084, 18095, 18096, 18085, 49107, 49119, 49120, 48972, 0, 0, 0, 
0, 48961, 49108, 49121, 48974
29621, 2550, 2561, 182, 181, 47036, 47080, 17784, 17780, 0, 0, 0, 0, 49111, 49122, 0, 
48975, 48962, 49109, 0, 0
29622, 47036, 47080, 17784, 17780, 47037, 47081, 17785, 17781, 49111, 49122, 0, 48975, 49114, 49123, 0, 
48976, 48965, 49112, 0, 0
29623, 47037, 47081, 17785, 17781, 47038, 47082, 17786, 17782, 49114, 49123, 0, 48976, 49117, 49124, 0, 
48977, 48968, 49115, 0, 0
29624, 47038, 47082, 17786, 17782, 47039, 47083, 17787, 17783, 49117, 49124, 0, 48977, 49120, 49125, 0, 
48978, 48971, 49118, 0, 0
29625, 47039, 47083, 17787, 17783, 18085, 18096, 2241, 2240, 49120, 49125, 0, 48978, 0, 0, 0, 
0, 48974, 49121, 0, 0
29626, 159, 160, 2562, 2551, 17334, 17338, 47084, 47040, 0, 0, 0, 0, 17481, 49127, 49128, 
48980, 17471, 17480, 49126, 48979
29627, 17334, 17338, 47084, 47040, 17335, 17339, 47085, 47041, 17481, 49127, 49128, 48980, 17483, 49130, 49131, 
48983, 17473, 17482, 49129, 48982
29628, 17335, 17339, 47085, 47041, 17336, 17340, 47086, 47042, 17483, 49130, 49131, 48983, 17485, 49133, 49134, 
48986, 17475, 17484, 49132, 48985
29629, 17336, 17340, 47086, 47042, 17337, 17341, 47087, 47043, 17485, 49133, 49134, 48986, 17487, 49136, 49137, 
48989, 17477, 17486, 49135, 48988
29630, 17337, 17341, 47087, 47043, 2199, 2200, 18097, 18086, 17487, 49136, 49137, 48989, 0, 0, 0, 
0, 17479, 17488, 49138, 48991
29631, 2551, 2562, 2563, 2552, 47040, 47084, 47088, 47044, 0, 0, 0, 0, 49128, 49140, 49141, 
48993, 48979, 49126, 49139, 48992
29632, 47040, 47084, 47088, 47044, 47041, 47085, 47089, 47045, 49128, 49140, 49141, 48993, 49131, 49143, 49144, 
48996, 48982, 49129, 49142, 48995
29633, 47041, 47085, 47089, 47045, 47042, 47086, 47090, 47046, 49131, 49143, 49144, 48996, 49134, 49146, 49147, 
48999, 48985, 49132, 49145, 48998
29634, 47042, 47086, 47090, 47046, 47043, 47087, 47091, 47047, 49134, 49146, 49147, 48999, 49137, 49149, 49150, 
49002, 48988, 49135, 49148, 49001
29635, 47043, 47087, 47091, 47047, 18086, 18097, 18098, 18087, 49137, 49149, 49150, 49002, 0, 0, 0, 
0, 48991, 49138, 49151, 49004
29636, 2552, 2563, 2564, 2553, 47044, 47088, 47092, 47048, 0, 0, 0, 0, 49141, 49153, 49154, 
49006, 48992, 49139, 49152, 49005
29637, 47044, 47088, 47092, 47048, 47045, 47089, 47093, 47049, 49141, 49153, 49154, 49006, 49144, 49156, 49157, 
49009, 48995, 49142, 49155, 49008
29638, 47045, 47089, 47093, 47049, 47046, 47090, 47094, 47050, 49144, 49156, 49157, 49009, 49147, 49159, 49160, 
49012, 48998, 49145, 49158, 49011
29639, 47046, 47090, 47094, 47050, 47047, 47091, 47095, 47051, 49147, 49159, 49160, 49012, 49150, 49162, 49163, 
49015, 49001, 49148, 49161, 49014
29640, 47047, 47091, 47095, 47051, 18087, 18098, 18099, 18088, 49150, 49162, 49163, 49015, 0, 0, 0, 
0, 49004, 49151, 49164, 49017
29641, 2553, 2564, 2565, 2554, 47048, 47092, 47096, 47052, 0, 0, 0, 0, 49154, 49166, 49167, 
49019, 49005, 49152, 49165, 49018
29642, 47048, 47092, 47096, 47052, 47049, 47093, 47097, 47053, 49154, 49166, 49167, 49019, 49157, 49169, 49170, 
49022, 49008, 49155, 49168, 49021
29643, 47049, 47093, 47097, 47053, 47050, 47094, 47098, 47054, 49157, 49169, 49170, 49022, 49160, 49172, 49173, 
49025, 49011, 49158, 49171, 49024
29644, 47050, 47094, 47098, 47054, 47051, 47095, 47099, 47055, 49160, 49172, 49173, 49025, 49163, 49175, 49176, 
49028, 49014, 49161, 49174, 49027
29645, 47051, 47095, 47099, 47055, 18088, 18099, 18100, 18089, 49163, 49175, 49176, 49028, 0, 0, 0, 
0, 49017, 49164, 49177, 49030
29646, 2554, 2565, 2566, 2555, 47052, 47096, 47100, 47056, 0, 0, 0, 0, 49167, 49179, 49180, 
49032, 49018, 49165, 49178, 49031
29647, 47052, 47096, 47100, 47056, 47053, 47097, 47101, 47057, 49167, 49179, 49180, 49032, 49170, 49182, 49183, 
49035, 49021, 49168, 49181, 49034
29648, 47053, 47097, 47101, 47057, 47054, 47098, 47102, 47058, 49170, 49182, 49183, 49035, 49173, 49185, 49186, 
49038, 49024, 49171, 49184, 49037
29649, 47054, 47098, 47102, 47058, 47055, 47099, 47103, 47059, 49173, 49185, 49186, 49038, 49176, 49188, 49189, 
49041, 49027, 49174, 49187, 49040
29650, 47055, 47099, 47103, 47059, 18089, 18100, 18101, 18090, 49176, 49188, 49189, 49041, 0, 0, 0, 
0, 49030, 49177, 49190, 49043
29651, 2555, 2566, 2567, 2556, 47056, 47100, 47104, 47060, 0, 0, 0, 0, 49180, 49192, 49193, 
49045, 49031, 49178, 49191, 49044
29652, 47056, 47100, 47104, 47060, 47057, 47101, 47105, 47061, 49180, 49192, 49193, 49045, 49183, 49195, 49196, 
49048, 49034, 49181, 49194, 49047
29653, 47057, 47101, 47105, 47061, 47058, 47102, 47106, 47062, 49183, 49195, 49196, 49048, 49186, 49198, 49199, 
49051, 49037, 49184, 49197, 49050
29654, 47058, 47102, 47106, 47062, 47059, 47103, 47107, 47063, 49186, 49198, 49199, 49051, 49189, 49201, 49202, 
49054, 49040, 49187, 49200, 49053
29655, 47059, 47103, 47107, 47063, 18090, 18101, 18102, 18091, 49189, 49201, 49202, 49054, 0, 0, 0, 
0, 49043, 49190, 49203, 49056
29656, 2556, 2567, 2568, 2557, 47060, 47104, 47108, 47064, 0, 0, 0, 0, 49193, 49205, 49206, 
49058, 49044, 49191, 49204, 49057
29657, 47060, 47104, 47108, 47064, 47061, 47105, 47109, 47065, 49193, 49205, 49206, 49058, 49196, 49208, 49209, 
49061, 49047, 49194, 49207, 49060
29658, 47061, 47105, 47109, 47065, 47062, 47106, 47110, 47066, 49196, 49208, 49209, 49061, 49199, 49211, 49212, 
49064, 49050, 49197, 49210, 49063
29659, 47062, 47106, 47110, 47066, 47063, 47107, 47111, 47067, 49199, 49211, 49212, 49064, 49202, 49214, 49215, 
49067, 49053, 49200, 49213, 49066
29660, 47063, 47107, 47111, 47067, 18091, 18102, 18103, 18092, 49202, 49214, 49215, 49067, 0, 0, 0, 
0, 49056, 49203, 49216, 49069
29661, 2557, 2568, 2569, 2558, 47064, 47108, 47112, 47068, 0, 0, 0, 0, 49206, 49218, 49219, 
49071, 49057, 49204, 49217, 49070
29662, 47064, 47108, 47112, 47068, 47065, 47109, 47113, 47069, 49206, 49218, 49219, 49071, 49209, 49221, 49222, 
49074, 49060, 49207, 49220, 49073
29663, 47065, 47109, 47113, 47069, 47066, 47110, 47114, 47070, 49209, 49221, 49222, 49074, 49212, 49224, 49225, 
49077, 49063, 49210, 49223, 49076
29664, 47066, 47110, 47114, 47070, 47067, 47111, 47115, 47071, 49212, 49224, 49225, 49077, 49215, 49227, 49228, 
49080, 49066, 49213, 49226, 49079
29665, 47067, 47111, 47115, 47071, 18092, 18103, 18104, 18093, 49215, 49227, 49228, 49080, 0, 0, 0, 
0, 49069, 49216, 49229, 49082
29666, 2558, 2569, 2570, 2559, 47068, 47112, 47116, 47072, 0, 0, 0, 0, 49219, 49231, 49232, 
49084, 49070, 49217, 49230, 49083
29667, 47068, 47112, 47116, 47072, 47069, 47113, 47117, 47073, 49219, 49231, 49232, 49084, 49222, 49234, 49235, 
49087, 49073, 49220, 49233, 49086
29668, 47069, 47113, 47117, 47073, 47070, 47114, 47118, 47074, 49222, 49234, 49235, 49087, 49225, 49237, 49238, 
49090, 49076, 49223, 49236, 49089
29669, 47070, 47114, 47118, 47074, 47071, 47115, 47119, 47075, 49225, 49237, 49238, 49090, 49228, 49240, 49241, 
49093, 49079, 49226, 49239, 49092
29670, 47071, 47115, 47119, 47075, 18093, 18104, 18105, 18094, 49228, 49240, 49241, 49093, 0, 0, 0, 
0, 49082, 49229, 49242, 49095
29671, 2559, 2570, 2571, 2560, 47072, 47116, 47120, 47076, 0, 0, 0, 0, 49232, 49244, 49245, 
49097, 49083, 49230, 49243, 49096
29672, 47072, 47116, 47120, 47076, 47073, 47117, 47121, 47077, 49232, 49244, 49245, 49097, 49235, 49247, 49248, 
49100, 49086, 49233, 49246, 49099
29673, 47073, 47117, 47121, 47077, 47074, 47118, 47122, 47078, 49235, 49247, 49248, 49100, 49238, 49250, 49251, 
49103, 49089, 49236, 49249, 49102
29674, 47074, 47118, 47122, 47078, 47075, 47119, 47123, 47079, 49238, 49250, 49251, 49103, 49241, 49253, 49254, 
49106, 49092, 49239, 49252, 49105
29675, 47075, 47119, 47123, 47079, 18094, 18105, 18106, 18095, 49241, 49253, 49254, 49106, 0, 0, 0, 
0, 49095, 49242, 49255, 49108
29676, 2560, 2571, 2572, 2561, 47076, 47120, 47124, 47080, 0, 0, 0, 0, 49245, 49257, 49258, 
49110, 49096, 49243, 49256, 49109
29677, 47076, 47120, 47124, 47080, 47077, 47121, 47125, 47081, 49245, 49257, 49258, 49110, 49248, 49260, 49261, 
49113, 49099, 49246, 49259, 49112
29678, 47077, 47121, 47125, 47081, 47078, 47122, 47126, 47082, 49248, 49260, 49261, 49113, 49251, 49263, 49264, 
49116, 49102, 49249, 49262, 49115
29679, 47078, 47122, 47126, 47082, 47079, 47123, 47127, 47083, 49251, 49263, 49264, 49116, 49254, 49266, 49267, 
49119, 49105, 49252, 49265, 49118
29680, 47079, 47123, 47127, 47083, 18095, 18106, 18107, 18096, 49254, 49266, 49267, 49119, 0, 0, 0, 
0, 49108, 49255, 49268, 49121
29681, 2561, 2572, 183, 182, 47080, 47124, 17788, 17784, 0, 0, 0, 0, 49258, 49269, 0, 
49122, 49109, 49256, 0, 0
29682, 47080, 47124, 17788, 17784, 47081, 47125, 17789, 17785, 49258, 49269, 0, 49122, 49261, 49270, 0, 
49123, 49112, 49259, 0, 0
29683, 47081, 47125, 17789, 17785, 47082, 47126, 17790, 17786, 49261, 49270, 0, 49123, 49264, 49271, 0, 
49124, 49115, 49262, 0, 0
29684, 47082, 47126, 17790, 17786, 47083, 47127, 17791, 17787, 49264, 49271, 0, 49124, 49267, 49272, 0, 
49125, 49118, 49265, 0, 0
29685, 47083, 47127, 17791, 17787, 18096, 18107, 2242, 2241, 49267, 49272, 0, 49125, 0, 0, 0, 
0, 49121, 49268, 0, 0
29686, 160, 161, 2573, 2562, 17338, 17342, 47128, 47084, 0, 0, 0, 0, 17490, 49274, 49275, 
49127, 17480, 17489, 49273, 49126
29687, 17338, 17342, 47128, 47084, 17339, 17343, 47129, 47085, 17490, 49274, 49275, 49127, 17492, 49277, 49278, 
49130, 17482, 17491, 49276, 49129
29688, 17339, 17343, 47129, 47085, 17340, 17344, 47130, 47086, 17492, 49277, 49278, 49130, 17494, 49280, 49281, 
49133, 17484, 17493, 49279, 49132
29689, 17340, 17344, 47130, 47086, 17341, 17345, 47131, 47087, 17494, 49280, 49281, 49133, 17496, 49283, 49284, 
49136, 17486, 17495, 49282, 49135
29690, 17341, 17345, 47131, 47087, 2200, 2201, 18108, 18097, 17496, 49283, 49284, 49136, 0, 0, 0, 
0, 17488, 17497, 49285, 49138
29691, 2562, 2573, 2574, 2563, 47084, 47128, 47132, 47088, 0, 0, 0, 0, 49275, 49287, 49288, 
49140, 49126, 49273, 49286, 49139
29692, 47084, 47128, 47132, 47088, 47085, 47129, 47133, 47089, 49275, 49287, 49288, 49140, 49278, 49290, 49291, 
49143, 49129, 49276, 49289, 49142
29693, 47085, 47129, 47133, 47089, 47086, 47130, 47134, 47090, 49278, 49290, 49291, 49143, 49281, 49293, 49294, 
49146, 49132, 49279, 49292, 49145
29694, 47086, 47130, 47134, 47090, 47087, 47131, 47135, 47091, 49281, 49293, 49294, 49146, 49284, 49296, 49297, 
49149, 49135, 49282, 49295, 49148
29695, 47087, 47131, 47135, 47091, 18097, 18108, 18109, 18098, 49284, 49296, 49297, 49149, 0, 0, 0, 
0, 49138, 49285, 49298, 49151
29696, 2563, 2574, 2575, 2564, 47088, 47132, 47136, 47092, 0, 0, 0, 0, 49288, 49300, 49301, 
49153, 49139, 49286, 49299, 49152
29697, 47088, 47132, 47136, 47092, 47089, 47133, 47137, 47093, 49288, 49300, 49301, 49153, 49291, 49303, 49304, 
49156, 49142, 49289, 49302, 49155
29698, 47089, 47133, 47137, 47093, 47090, 47134, 47138, 47094, 49291, 49303, 49304, 49156, 49294, 49306, 49307, 
49159, 49145, 49292, 49305, 49158
29699, 47090, 47134, 47138, 47094, 47091, 47135, 47139, 47095, 49294, 49306, 49307, 49159, 49297, 49309, 49310, 
49162, 49148, 49295, 49308, 49161
29700, 47091, 47135, 47139, 47095, 18098, 18109, 18110, 18099, 49297, 49309, 49310, 49162, 0, 0, 0, 
0, 49151, 49298, 49311, 49164
29701, 2564, 2575, 2576, 2565, 47092, 47136, 47140, 47096, 0, 0, 0, 0, 49301, 49313, 49314, 
49166, 49152, 49299, 49312, 49165
29702, 47092, 47136, 47140, 47096, 47093, 47137, 47141, 47097, 49301, 49313, 49314, 49166, 49304, 49316, 49317, 
49169, 49155, 49302, 49315, 49168
29703, 47093, 47137, 47141, 47097, 47094, 47138, 47142, 47098, 49304, 49316, 49317, 49169, 49307, 49319, 49320, 
49172, 49158, 49305, 49318, 49171
29704, 47094, 47138, 47142, 47098, 47095, 47139, 47143, 47099, 49307, 49319, 49320, 49172, 49310, 49322, 49323, 
49175, 49161, 49308, 49321, 49174
29705, 47095, 47139, 47143, 47099, 18099, 18110, 18111, 18100, 49310, 49322, 49323, 49175, 0, 0, 0, 
0, 49164, 49311, 49324, 49177
29706, 2565, 2576, 2577, 2566, 47096, 47140, 47144, 47100, 0, 0, 0, 0, 49314, 49326, 49327, 
49179, 49165, 49312, 49325, 49178
29707, 47096, 47140, 47144, 47100, 47097, 47141, 47145, 47101, 49314, 49326, 49327, 49179, 49317, 49329, 49330, 
49182, 49168, 49315, 49328, 49181
29708, 47097, 47141, 47145, 47101, 47098, 47142, 47146, 47102, 49317, 49329, 49330, 49182, 49320, 49332, 49333, 
49185, 49171, 49318, 49331, 49184
29709, 47098, 47142, 47146, 47102, 47099, 47143, 47147, 47103, 49320, 49332, 49333, 49185, 49323, 49335, 49336, 
49188, 49174, 49321, 49334, 49187
29710, 47099, 47143, 47147, 47103, 18100, 18111, 18112, 18101, 49323, 49335, 49336, 49188, 0, 0, 0, 
0, 49177, 49324, 49337, 49190
29711, 2566, 2577, 2578, 2567, 47100, 47144, 47148, 47104, 0, 0, 0, 0, 49327, 49339, 49340, 
49192, 49178, 49325, 49338, 49191
29712, 47100, 47144, 47148, 47104, 47101, 47145, 47149, 47105, 49327, 49339, 49340, 49192, 49330, 49342, 49343, 
49195, 49181, 49328, 49341, 49194
29713, 47101, 47145, 47149, 47105, 47102, 47146, 47150, 47106, 49330, 49342, 49343, 49195, 49333, 49345, 49346, 
49198, 49184, 49331, 49344, 49197
29714, 47102, 47146, 47150, 47106, 47103, 47147, 47151, 47107, 49333, 49345, 49346, 49198, 49336, 49348, 49349, 
49201, 49187, 49334, 49347, 49200
29715, 47103, 47147, 47151, 47107, 18101, 18112, 18113, 18102, 49336, 49348, 49349, 49201, 0, 0, 0, 
0, 49190, 49337, 49350, 49203
29716, 2567, 2578, 2579, 2568, 47104, 47148, 47152, 47108, 0, 0, 0, 0, 49340, 49352, 49353, 
49205, 49191, 49338, 49351, 49204
29717, 47104, 47148, 47152, 47108, 47105, 47149, 47153, 47109, 49340, 49352, 49353, 49205, 49343, 49355, 49356, 
49208, 49194, 49341, 49354, 49207
29718, 47105, 47149, 47153, 47109, 47106, 47150, 47154, 47110, 49343, 49355, 49356, 49208, 49346, 49358, 49359, 
49211, 49197, 49344, 49357, 49210
29719, 47106, 47150, 47154, 47110, 47107, 47151, 47155, 47111, 49346, 49358, 49359, 49211, 49349, 49361, 49362, 
49214, 49200, 49347, 49360, 49213
29720, 47107, 47151, 47155, 47111, 18102, 18113, 18114, 18103, 49349, 49361, 49362, 49214, 0, 0, 0, 
0, 49203, 49350, 49363, 49216
29721, 2568, 2579, 2580, 2569, 47108, 47152, 47156, 47112, 0, 0, 0, 0, 49353, 49365, 49366, 
49218, 49204, 49351, 49364, 49217
29722, 47108, 47152, 47156, 47112, 47109, 47153, 47157, 47113, 49353, 49365, 49366, 49218, 49356, 49368, 49369, 
49221, 49207, 49354, 49367, 49220
29723, 47109, 47153, 47157, 47113, 47110, 47154, 47158, 47114, 49356, 49368, 49369, 49221, 49359, 49371, 49372, 
49224, 49210, 49357, 49370, 49223
29724, 47110, 47154, 47158, 47114, 47111, 47155, 47159, 47115, 49359, 49371, 49372, 49224, 49362, 49374, 49375, 
49227, 49213, 49360, 49373, 49226
29725, 47111, 47155, 47159, 47115, 18103, 18114, 18115, 18104, 49362, 49374, 49375, 49227, 0, 0, 0, 
0, 49216, 49363, 49376, 49229
29726, 2569, 2580, 2581, 2570, 47112, 47156, 47160, 47116, 0, 0, 0, 0, 49366, 49378, 49379, 
49231, 49217, 49364, 49377, 49230
29727, 47112, 47156, 47160, 47116, 47113, 47157, 47161, 47117, 49366, 49378, 49379, 49231, 49369, 49381, 49382, 
49234, 49220, 49367, 49380, 49233
29728, 47113, 47157, 47161, 47117, 47114, 47158, 47162, 47118, 49369, 49381, 49382, 49234, 49372, 49384, 49385, 
49237, 49223, 49370, 49383, 49236
29729, 47114, 47158, 47162, 47118, 47115, 47159, 47163, 47119, 49372, 49384, 49385, 49237, 49375, 49387, 49388, 
49240, 49226, 49373, 49386, 49239
29730, 47115, 47159, 47163, 47119, 18104, 18115, 18116, 18105, 49375, 49387, 49388, 49240, 0, 0, 0, 
0, 49229, 49376, 49389, 49242
29731, 2570, 2581, 2582, 2571, 47116, 47160, 47164, 47120, 0, 0, 0, 0, 49379, 49391, 49392, 
49244, 49230, 49377, 49390, 49243
29732, 47116, 47160, 47164, 47120, 47117, 47161, 47165, 47121, 49379, 49391, 49392, 49244, 49382, 49394, 49395, 
49247, 49233, 49380, 49393, 49246
29733, 47117, 47161, 47165, 47121, 47118, 47162, 47166, 47122, 49382, 49394, 49395, 49247, 49385, 49397, 49398, 
49250, 49236, 49383, 49396, 49249
29734, 47118, 47162, 47166, 47122, 47119, 47163, 47167, 47123, 49385, 49397, 49398, 49250, 49388, 49400, 49401, 
49253, 49239, 49386, 49399, 49252
29735, 47119, 47163, 47167, 47123, 18105, 18116, 18117, 18106, 49388, 49400, 49401, 49253, 0, 0, 0, 
0, 49242, 49389, 49402, 49255
29736, 2571, 2582, 2583, 2572, 47120, 47164, 47168, 47124, 0, 0, 0, 0, 49392, 49404, 49405, 
49257, 49243, 49390, 49403, 49256
29737, 47120, 47164, 47168, 47124, 47121, 47165, 47169, 47125, 49392, 49404, 49405, 49257, 49395, 49407, 49408, 
49260, 49246, 49393, 49406, 49259
29738, 47121, 47165, 47169, 47125, 47122, 47166, 47170, 47126, 49395, 49407, 49408, 49260, 49398, 49410, 49411, 
49263, 49249, 49396, 49409, 49262
29739, 47122, 47166, 47170, 47126, 47123, 47167, 47171, 47127, 49398, 49410, 49411, 49263, 49401, 49413, 49414, 
49266, 49252, 49399, 49412, 49265
29740, 47123, 47167, 47171, 47127, 18106, 18117, 18118, 18107, 49401, 49413, 49414, 49266, 0, 0, 0, 
0, 49255, 49402, 49415, 49268
29741, 2572, 2583, 184, 183, 47124, 47168, 17792, 17788, 0, 0, 0, 0, 49405, 49416, 0, 
49269, 49256, 49403, 0, 0
29742, 47124, 47168, 17792, 17788, 47125, 47169, 17793, 17789, 49405, 49416, 0, 49269, 49408, 49417, 0, 
49270, 49259, 49406, 0, 0
29743, 47125, 47169, 17793, 17789, 47126, 47170, 17794, 17790, 49408, 49417, 0, 49270, 49411, 49418, 0, 
49271, 49262, 49409, 0, 0
29744, 47126, 47170, 17794, 17790, 47127, 47171, 17795, 17791, 49411, 49418, 0, 49271, 49414, 49419, 0, 
49272, 49265, 49412, 0, 0
29745, 47127, 47171, 17795, 17791, 18107, 18118, 2243, 2242, 49414, 49419, 0, 49272, 0, 0, 0, 
0, 49268, 49415, 0, 0
29746, 161, 162, 2584, 2573, 17342, 17346, 47172, 47128, 0, 0, 0, 0, 17499, 49421, 49422, 
49274, 17489, 17498, 49420, 49273
29747, 17342, 17346, 47172, 47128, 17343, 17347, 47173, 47129, 17499, 49421, 49422, 49274, 17501, 49424, 49425, 
49277, 17491, 17500, 49423, 49276
29748, 17343, 17347, 47173, 47129, 17344, 17348, 47174, 47130, 17501, 49424, 49425, 49277, 17503, 49427, 49428, 
49280, 17493, 17502, 49426, 49279
29749, 17344, 17348, 47174, 47130, 17345, 17349, 47175, 47131, 17503, 49427, 49428, 49280, 17505, 49430, 49431, 
49283, 17495, 17504, 49429, 49282
29750, 17345, 17349, 47175, 47131, 2201, 2202, 18119, 18108, 17505, 49430, 49431, 49283, 0, 0, 0, 
0, 17497, 17506, 49432, 49285
29751, 2573, 2584, 2585, 2574, 47128, 47172, 47176, 47132, 0, 0, 0, 0, 49422, 49434, 49435, 
49287, 49273, 49420, 49433, 49286
29752, 47128, 47172, 47176, 47132, 47129, 47173, 47177, 47133, 49422, 49434, 49435, 49287, 49425, 49437, 49438, 
49290, 49276, 49423, 49436, 49289
29753, 47129, 47173, 47177, 47133, 47130, 47174, 47178, 47134, 49425, 49437, 49438, 49290, 49428, 49440, 49441, 
49293, 49279, 49426, 49439, 49292
29754, 47130, 47174, 47178, 47134, 47131, 47175, 47179, 47135, 49428, 49440, 49441, 49293, 49431, 49443, 49444, 
49296, 49282, 49429, 49442, 49295
29755, 47131, 47175, 47179, 47135, 18108, 18119, 18120, 18109, 49431, 49443, 49444, 49296, 0, 0, 0, 
0, 49285, 49432, 49445, 49298
29756, 2574, 2585, 2586, 2575, 47132, 47176, 47180, 47136, 0, 0, 0, 0, 49435, 49447, 49448, 
49300, 49286, 49433, 49446, 49299
29757, 47132, 47176, 47180, 47136, 47133, 47177, 47181, 47137, 49435, 49447, 49448, 49300, 49438, 49450, 49451, 
49303, 49289, 49436, 49449, 49302
29758, 47133, 47177, 47181, 47137, 47134, 47178, 47182, 47138, 49438, 49450, 49451, 49303, 49441, 49453, 49454, 
49306, 49292, 49439, 49452, 49305
29759, 47134, 47178, 47182, 47138, 47135, 47179, 47183, 47139, 49441, 49453, 49454, 49306, 49444, 49456, 49457, 
49309, 49295, 49442, 49455, 49308
29760, 47135, 47179, 47183, 47139, 18109, 18120, 18121, 18110, 49444, 49456, 49457, 49309, 0, 0, 0, 
0, 49298, 49445, 49458, 49311
29761, 2575, 2586, 2587, 2576, 47136, 47180, 47184, 47140, 0, 0, 0, 0, 49448, 49460, 49461, 
49313, 49299, 49446, 49459, 49312
29762, 47136, 47180, 47184, 47140, 47137, 47181, 47185, 47141, 49448, 49460, 49461, 49313, 49451, 49463, 49464, 
49316, 49302, 49449, 49462, 49315
29763, 47137, 47181, 47185, 47141, 47138, 47182, 47186, 47142, 49451, 49463, 49464, 49316, 49454, 49466, 49467, 
49319, 49305, 49452, 49465, 49318
29764, 47138, 47182, 47186, 47142, 47139, 47183, 47187, 47143, 49454, 49466, 49467, 49319, 49457, 49469, 49470, 
49322, 49308, 49455, 49468, 49321
29765, 47139, 47183, 47187, 47143, 18110, 18121, 18122, 18111, 49457, 49469, 49470, 49322, 0, 0, 0, 
0, 49311, 49458, 49471, 49324
29766, 2576, 2587, 2588, 2577, 47140, 47184, 47188, 47144, 0, 0, 0, 0, 49461, 49473, 49474, 
49326, 49312, 49459, 49472, 49325
29767, 47140, 47184, 47188, 47144, 47141, 47185, 47189, 47145, 49461, 49473, 49474, 49326, 49464, 49476, 49477, 
49329, 49315, 49462, 49475, 49328
29768, 47141, 47185, 47189, 47145, 47142, 47186, 47190, 47146, 49464, 49476, 49477, 49329, 49467, 49479, 49480, 
49332, 49318, 49465, 49478, 49331
29769, 47142, 47186, 47190, 47146, 47143, 47187, 47191, 47147, 49467, 49479, 49480, 49332, 49470, 49482, 49483, 
49335, 49321, 49468, 49481, 49334
29770, 47143, 47187, 47191, 47147, 18111, 18122, 18123, 18112, 49470, 49482, 49483, 49335, 0, 0, 0, 
0, 49324, 49471, 49484, 49337
29771, 2577, 2588, 2589, 2578, 47144, 47188, 47192, 47148, 0, 0, 0, 0, 49474, 49486, 49487, 
49339, 49325, 49472, 49485, 49338
29772, 47144, 47188, 47192, 47148, 47145, 47189, 47193, 47149, 49474, 49486, 49487, 49339, 49477, 49489, 49490, 
49342, 49328, 49475, 49488, 49341
29773, 47145, 47189, 47193, 47149, 47146, 47190, 47194, 47150, 49477, 49489, 49490, 49342, 49480, 49492, 49493, 
49345, 49331, 49478, 49491, 49344
29774, 47146, 47190, 47194, 47150, 47147, 47191, 47195, 47151, 49480, 49492, 49493, 49345, 49483, 49495, 49496, 
49348, 49334, 49481, 49494, 49347
29775, 47147, 47191, 47195, 47151, 18112, 18123, 18124, 18113, 49483, 49495, 49496, 49348, 0, 0, 0, 
0, 49337, 49484, 49497, 49350
29776, 2578, 2589, 2590, 2579, 47148, 47192, 47196, 47152, 0, 0, 0, 0, 49487, 49499, 49500, 
49352, 49338, 49485, 49498, 49351
29777, 47148, 47192, 47196, 47152, 47149, 47193, 47197, 47153, 49487, 49499, 49500, 49352, 49490, 49502, 49503, 
49355, 49341, 49488, 49501, 49354
29778, 47149, 47193, 47197, 47153, 47150, 47194, 47198, 47154, 49490, 49502, 49503, 49355, 49493, 49505, 49506, 
49358, 49344, 49491, 49504, 49357
29779, 47150, 47194, 47198, 47154, 47151, 47195, 47199, 47155, 49493, 49505, 49506, 49358, 49496, 49508, 49509, 
49361, 49347, 49494, 49507, 49360
29780, 47151, 47195, 47199, 47155, 18113, 18124, 18125, 18114, 49496, 49508, 49509, 49361, 0, 0, 0, 
0, 49350, 49497, 49510, 49363
29781, 2579, 2590, 2591, 2580, 47152, 47196, 47200, 47156, 0, 0, 0, 0, 49500, 49512, 49513, 
49365, 49351, 49498, 49511, 49364
29782, 47152, 47196, 47200, 47156, 47153, 47197, 47201, 47157, 49500, 49512, 49513, 49365, 49503, 49515, 49516, 
49368, 49354, 49501, 49514, 49367
29783, 47153, 47197, 47201, 47157, 47154, 47198, 47202, 47158, 49503, 49515, 49516, 49368, 49506, 49518, 49519, 
49371, 49357, 49504, 49517, 49370
29784, 47154, 47198, 47202, 47158, 47155, 47199, 47203, 47159, 49506, 49518, 49519, 49371, 49509, 49521, 49522, 
49374, 49360, 49507, 49520, 49373
29785, 47155, 47199, 47203, 47159, 18114, 18125, 18126, 18115, 49509, 49521, 49522, 49374, 0, 0, 0, 
0, 49363, 49510, 49523, 49376
29786, 2580, 2591, 2592, 2581, 47156, 47200, 47204, 47160, 0, 0, 0, 0, 49513, 49525, 49526, 
49378, 49364, 49511, 49524, 49377
29787, 47156, 47200, 47204, 47160, 47157, 47201, 47205, 47161, 49513, 49525, 49526, 49378, 49516, 49528, 49529, 
49381, 49367, 49514, 49527, 49380
29788, 47157, 47201, 47205, 47161, 47158, 47202, 47206, 47162, 49516, 49528, 49529, 49381, 49519, 49531, 49532, 
49384, 49370, 49517, 49530, 49383
29789, 47158, 47202, 47206, 47162, 47159, 47203, 47207, 47163, 49519, 49531, 49532, 49384, 49522, 49534, 49535, 
49387, 49373, 49520, 49533, 49386
29790, 47159, 47203, 47207, 47163, 18115, 18126, 18127, 18116, 49522, 49534, 49535, 49387, 0, 0, 0, 
0, 49376, 49523, 49536, 49389
29791, 2581, 2592, 2593, 2582, 47160, 47204, 47208, 47164, 0, 0, 0, 0, 49526, 49538, 49539, 
49391, 49377, 49524, 49537, 49390
29792, 47160, 47204, 47208, 47164, 47161, 47205, 47209, 47165, 49526, 49538, 49539, 49391, 49529, 49541, 49542, 
49394, 49380, 49527, 49540, 49393
29793, 47161, 47205, 47209, 47165, 47162, 47206, 47210, 47166, 49529, 49541, 49542, 49394, 49532, 49544, 49545, 
49397, 49383, 49530, 49543, 49396
29794, 47162, 47206, 47210, 47166, 47163, 47207, 47211, 47167, 49532, 49544, 49545, 49397, 49535, 49547, 49548, 
49400, 49386, 49533, 49546, 49399
29795, 47163, 47207, 47211, 47167, 18116, 18127, 18128, 18117, 49535, 49547, 49548, 49400, 0, 0, 0, 
0, 49389, 49536, 49549, 49402
29796, 2582, 2593, 2594, 2583, 47164, 47208, 47212, 47168, 0, 0, 0, 0, 49539, 49551, 49552, 
49404, 49390, 49537, 49550, 49403
29797, 47164, 47208, 47212, 47168, 47165, 47209, 47213, 47169, 49539, 49551, 49552, 49404, 49542, 49554, 49555, 
49407, 49393, 49540, 49553, 49406
29798, 47165, 47209, 47213, 47169, 47166, 47210, 47214, 47170, 49542, 49554, 49555, 49407, 49545, 49557, 49558, 
49410, 49396, 49543, 49556, 49409
29799, 47166, 47210, 47214, 47170, 47167, 47211, 47215, 47171, 49545, 49557, 49558, 49410, 49548, 49560, 49561, 
49413, 49399, 49546, 49559, 49412
29800, 47167, 47211, 47215, 47171, 18117, 18128, 18129, 18118, 49548, 49560, 49561, 49413, 0, 0, 0, 
0, 49402, 49549, 49562, 49415
29801, 2583, 2594, 185, 184, 47168, 47212, 17796, 17792, 0, 0, 0, 0, 49552, 49563, 0, 
49416, 49403, 49550, 0, 0
29802, 47168, 47212, 17796, 17792, 47169, 47213, 17797, 17793, 49552, 49563, 0, 49416, 49555, 49564, 0, 
49417, 49406, 49553, 0, 0
29803, 47169, 47213, 17797, 17793, 47170, 47214, 17798, 17794, 49555, 49564, 0, 49417, 49558, 49565, 0, 
49418, 49409, 49556, 0, 0
29804, 47170, 47214, 17798, 17794, 47171, 47215, 17799, 17795, 49558, 49565, 0, 49418, 49561, 49566, 0, 
49419, 49412, 49559, 0, 0
29805, 47171, 47215, 17799, 17795, 18118, 18129, 2244, 2243, 49561, 49566, 0, 49419, 0, 0, 0, 
0, 49415, 49562, 0, 0
29806, 162, 163, 2595, 2584, 17346, 17350, 47216, 47172, 0, 0, 0, 0, 17508, 49568, 49569, 
49421, 17498, 17507, 49567, 49420
29807, 17346, 17350, 47216, 47172, 17347, 17351, 47217, 47173, 17508, 49568, 49569, 49421, 17510, 49571, 49572, 
49424, 17500, 17509, 49570, 49423
29808, 17347, 17351, 47217, 47173, 17348, 17352, 47218, 47174, 17510, 49571, 49572, 49424, 17512, 49574, 49575, 
49427, 17502, 17511, 49573, 49426
29809, 17348, 17352, 47218, 47174, 17349, 17353, 47219, 47175, 17512, 49574, 49575, 49427, 17514, 49577, 49578, 
49430, 17504, 17513, 49576, 49429
29810, 17349, 17353, 47219, 47175, 2202, 2203, 18130, 18119, 17514, 49577, 49578, 49430, 0, 0, 0, 
0, 17506, 17515, 49579, 49432
29811, 2584, 2595, 2596, 2585, 47172, 47216, 47220, 47176, 0, 0, 0, 0, 49569, 49581, 49582, 
49434, 49420, 49567, 49580, 49433
29812, 47172, 47216, 47220, 47176, 47173, 47217, 47221, 47177, 49569, 49581, 49582, 49434, 49572, 49584, 49585, 
49437, 49423, 49570, 49583, 49436
29813, 47173, 47217, 47221, 47177, 47174, 47218, 47222, 47178, 49572, 49584, 49585, 49437, 49575, 49587, 49588, 
49440, 49426, 49573, 49586, 49439
29814, 47174, 47218, 47222, 47178, 47175, 47219, 47223, 47179, 49575, 49587, 49588, 49440, 49578, 49590, 49591, 
49443, 49429, 49576, 49589, 49442
29815, 47175, 47219, 47223, 47179, 18119, 18130, 18131, 18120, 49578, 49590, 49591, 49443, 0, 0, 0, 
0, 49432, 49579, 49592, 49445
29816, 2585, 2596, 2597, 2586, 47176, 47220, 47224, 47180, 0, 0, 0, 0, 49582, 49594, 49595, 
49447, 49433, 49580, 49593, 49446
29817, 47176, 47220, 47224, 47180, 47177, 47221, 47225, 47181, 49582, 49594, 49595, 49447, 49585, 49597, 49598, 
49450, 49436, 49583, 49596, 49449
29818, 47177, 47221, 47225, 47181, 47178, 47222, 47226, 47182, 49585, 49597, 49598, 49450, 49588, 49600, 49601, 
49453, 49439, 49586, 49599, 49452
29819, 47178, 47222, 47226, 47182, 47179, 47223, 47227, 47183, 49588, 49600, 49601, 49453, 49591, 49603, 49604, 
49456, 49442, 49589, 49602, 49455
29820, 47179, 47223, 47227, 47183, 18120, 18131, 18132, 18121, 49591, 49603, 49604, 49456, 0, 0, 0, 
0, 49445, 49592, 49605, 49458
29821, 2586, 2597, 2598, 2587, 47180, 47224, 47228, 47184, 0, 0, 0, 0, 49595, 49607, 49608, 
49460, 49446, 49593, 49606, 49459
29822, 47180, 47224, 47228, 47184, 47181, 47225, 47229, 47185, 49595, 49607, 49608, 49460, 49598, 49610, 49611, 
49463, 49449, 49596, 49609, 49462
29823, 47181, 47225, 47229, 47185, 47182, 47226, 47230, 47186, 49598, 49610, 49611, 49463, 49601, 49613, 49614, 
49466, 49452, 49599, 49612, 49465
29824, 47182, 47226, 47230, 47186, 47183, 47227, 47231, 47187, 49601, 49613, 49614, 49466, 49604, 49616, 49617, 
49469, 49455, 49602, 49615, 49468
29825, 47183, 47227, 47231, 47187, 18121, 18132, 18133, 18122, 49604, 49616, 49617, 49469, 0, 0, 0, 
0, 49458, 49605, 49618, 49471
29826, 2587, 2598, 2599, 2588, 47184, 47228, 47232, 47188, 0, 0, 0, 0, 49608, 49620, 49621, 
49473, 49459, 49606, 49619, 49472
29827, 47184, 47228, 47232, 47188, 47185, 47229, 47233, 47189, 49608, 49620, 49621, 49473, 49611, 49623, 49624, 
49476, 49462, 49609, 49622, 49475
29828, 47185, 47229, 47233, 47189, 47186, 47230, 47234, 47190, 49611, 49623, 49624, 49476, 49614, 49626, 49627, 
49479, 49465, 49612, 49625, 49478
29829, 47186, 47230, 47234, 47190, 47187, 47231, 47235, 47191, 49614, 49626, 49627, 49479, 49617, 49629, 49630, 
49482, 49468, 49615, 49628, 49481
29830, 47187, 47231, 47235, 47191, 18122, 18133, 18134, 18123, 49617, 49629, 49630, 49482, 0, 0, 0, 
0, 49471, 49618, 49631, 49484
29831, 2588, 2599, 2600, 2589, 47188, 47232, 47236, 47192, 0, 0, 0, 0, 49621, 49633, 49634, 
49486, 49472, 49619, 49632, 49485
29832, 47188, 47232, 47236, 47192, 47189, 47233, 47237, 47193, 49621, 49633, 49634, 49486, 49624, 49636, 49637, 
49489, 49475, 49622, 49635, 49488
29833, 47189, 47233, 47237, 47193, 47190, 47234, 47238, 47194, 49624, 49636, 49637, 49489, 49627, 49639, 49640, 
49492, 49478, 49625, 49638, 49491
29834, 47190, 47234, 47238, 47194, 47191, 47235, 47239, 47195, 49627, 49639, 49640, 49492, 49630, 49642, 49643, 
49495, 49481, 49628, 49641, 49494
29835, 47191, 47235, 47239, 47195, 18123, 18134, 18135, 18124, 49630, 49642, 49643, 49495, 0, 0, 0, 
0, 49484, 49631, 49644, 49497
29836, 2589, 2600, 2601, 2590, 47192, 47236, 47240, 47196, 0, 0, 0, 0, 49634, 49646, 49647, 
49499, 49485, 49632, 49645, 49498
29837, 47192, 47236, 47240, 47196, 47193, 47237, 47241, 47197, 49634, 49646, 49647, 49499, 49637, 49649, 49650, 
49502, 49488, 49635, 49648, 49501
29838, 47193, 47237, 47241, 47197, 47194, 47238, 47242, 47198, 49637, 49649, 49650, 49502, 49640, 49652, 49653, 
49505, 49491, 49638, 49651, 49504
29839, 47194, 47238, 47242, 47198, 47195, 47239, 47243, 47199, 49640, 49652, 49653, 49505, 49643, 49655, 49656, 
49508, 49494, 49641, 49654, 49507
29840, 47195, 47239, 47243, 47199, 18124, 18135, 18136, 18125, 49643, 49655, 49656, 49508, 0, 0, 0, 
0, 49497, 49644, 49657, 49510
29841, 2590, 2601, 2602, 2591, 47196, 47240, 47244, 47200, 0, 0, 0, 0, 49647, 49659, 49660, 
49512, 49498, 49645, 49658, 49511
29842, 47196, 47240, 47244, 47200, 47197, 47241, 47245, 47201, 49647, 49659, 49660, 49512, 49650, 49662, 49663, 
49515, 49501, 49648, 49661, 49514
29843, 47197, 47241, 47245, 47201, 47198, 47242, 47246, 47202, 49650, 49662, 49663, 49515, 49653, 49665, 49666, 
49518, 49504, 49651, 49664, 49517
29844, 47198, 47242, 47246, 47202, 47199, 47243, 47247, 47203, 49653, 49665, 49666, 49518, 49656, 49668, 49669, 
49521, 49507, 49654, 49667, 49520
29845, 47199, 47243, 47247, 47203, 18125, 18136, 18137, 18126, 49656, 49668, 49669, 49521, 0, 0, 0, 
0, 49510, 49657, 49670, 49523
29846, 2591, 2602, 2603, 2592, 47200, 47244, 47248, 47204, 0, 0, 0, 0, 49660, 49672, 49673, 
49525, 49511, 49658, 49671, 49524
29847, 47200, 47244, 47248, 47204, 47201, 47245, 47249, 47205, 49660, 49672, 49673, 49525, 49663, 49675, 49676, 
49528, 49514, 49661, 49674, 49527
29848, 47201, 47245, 47249, 47205, 47202, 47246, 47250, 47206, 49663, 49675, 49676, 49528, 49666, 49678, 49679, 
49531, 49517, 49664, 49677, 49530
29849, 47202, 47246, 47250, 47206, 47203, 47247, 47251, 47207, 49666, 49678, 49679, 49531, 49669, 49681, 49682, 
49534, 49520, 49667, 49680, 49533
29850, 47203, 47247, 47251, 47207, 18126, 18137, 18138, 18127, 49669, 49681, 49682, 49534, 0, 0, 0, 
0, 49523, 49670, 49683, 49536
29851, 2592, 2603, 2604, 2593, 47204, 47248, 47252, 47208, 0, 0, 0, 0, 49673, 49685, 49686, 
49538, 49524, 49671, 49684, 49537
29852, 47204, 47248, 47252, 47208, 47205, 47249, 47253, 47209, 49673, 49685, 49686, 49538, 49676, 49688, 49689, 
49541, 49527, 49674, 49687, 49540
29853, 47205, 47249, 47253, 47209, 47206, 47250, 47254, 47210, 49676, 49688, 49689, 49541, 49679, 49691, 49692, 
49544, 49530, 49677, 49690, 49543
29854, 47206, 47250, 47254, 47210, 47207, 47251, 47255, 47211, 49679, 49691, 49692, 49544, 49682, 49694, 49695, 
49547, 49533, 49680, 49693, 49546
29855, 47207, 47251, 47255, 47211, 18127, 18138, 18139, 18128, 49682, 49694, 49695, 49547, 0, 0, 0, 
0, 49536, 49683, 49696, 49549
29856, 2593, 2604, 2605, 2594, 47208, 47252, 47256, 47212, 0, 0, 0, 0, 49686, 49698, 49699, 
49551, 49537, 49684, 49697, 49550
29857, 47208, 47252, 47256, 47212, 47209, 47253, 47257, 47213, 49686, 49698, 49699, 49551, 49689, 49701, 49702, 
49554, 49540, 49687, 49700, 49553
29858, 47209, 47253, 47257, 47213, 47210, 47254, 47258, 47214, 49689, 49701, 49702, 49554, 49692, 49704, 49705, 
49557, 49543, 49690, 49703, 49556
29859, 47210, 47254, 47258, 47214, 47211, 47255, 47259, 47215, 49692, 49704, 49705, 49557, 49695, 49707, 49708, 
49560, 49546, 49693, 49706, 49559
29860, 47211, 47255, 47259, 47215, 18128, 18139, 18140, 18129, 49695, 49707, 49708, 49560, 0, 0, 0, 
0, 49549, 49696, 49709, 49562
29861, 2594, 2605, 186, 185, 47212, 47256, 17800, 17796, 0, 0, 0, 0, 49699, 49710, 0, 
49563, 49550, 49697, 0, 0
29862, 47212, 47256, 17800, 17796, 47213, 47257, 17801, 17797, 49699, 49710, 0, 49563, 49702, 49711, 0, 
49564, 49553, 49700, 0, 0
29863, 47213, 47257, 17801, 17797, 47214, 47258, 17802, 17798, 49702, 49711, 0, 49564, 49705, 49712, 0, 
49565, 49556, 49703, 0, 0
29864, 47214, 47258, 17802, 17798, 47215, 47259, 17803, 17799, 49705, 49712, 0, 49565, 49708, 49713, 0, 
49566, 49559, 49706, 0, 0
29865, 47215, 47259, 17803, 17799, 18129, 18140, 2245, 2244, 49708, 49713, 0, 49566, 0, 0, 0, 
0, 49562, 49709, 0, 0
29866, 163, 164, 2606, 2595, 17350, 17354, 47260, 47216, 0, 0, 0, 0, 17517, 49715, 49716, 
49568, 17507, 17516, 49714, 49567
29867, 17350, 17354, 47260, 47216, 17351, 17355, 47261, 47217, 17517, 49715, 49716, 49568, 17519, 49718, 49719, 
49571, 17509, 17518, 49717, 49570
29868, 17351, 17355, 47261, 47217, 17352, 17356, 47262, 47218, 17519, 49718, 49719, 49571, 17521, 49721, 49722, 
49574, 17511, 17520, 49720, 49573
29869, 17352, 17356, 47262, 47218, 17353, 17357, 47263, 47219, 17521, 49721, 49722, 49574, 17523, 49724, 49725, 
49577, 17513, 17522, 49723, 49576
29870, 17353, 17357, 47263, 47219, 2203, 2204, 18141, 18130, 17523, 49724, 49725, 49577, 0, 0, 0, 
0, 17515, 17524, 49726, 49579
29871, 2595, 2606, 2607, 2596, 47216, 47260, 47264, 47220, 0, 0, 0, 0, 49716, 49728, 49729, 
49581, 49567, 49714, 49727, 49580
29872, 47216, 47260, 47264, 47220, 47217, 47261, 47265, 47221, 49716, 49728, 49729, 49581, 49719, 49731, 49732, 
49584, 49570, 49717, 49730, 49583
29873, 47217, 47261, 47265, 47221, 47218, 47262, 47266, 47222, 49719, 49731, 49732, 49584, 49722, 49734, 49735, 
49587, 49573, 49720, 49733, 49586
29874, 47218, 47262, 47266, 47222, 47219, 47263, 47267, 47223, 49722, 49734, 49735, 49587, 49725, 49737, 49738, 
49590, 49576, 49723, 49736, 49589
29875, 47219, 47263, 47267, 47223, 18130, 18141, 18142, 18131, 49725, 49737, 49738, 49590, 0, 0, 0, 
0, 49579, 49726, 49739, 49592
29876, 2596, 2607, 2608, 2597, 47220, 47264, 47268, 47224, 0, 0, 0, 0, 49729, 49741, 49742, 
49594, 49580, 49727, 49740, 49593
29877, 47220, 47264, 47268, 47224, 47221, 47265, 47269, 47225, 49729, 49741, 49742, 49594, 49732, 49744, 49745, 
49597, 49583, 49730, 49743, 49596
29878, 47221, 47265, 47269, 47225, 47222, 47266, 47270, 47226, 49732, 49744, 49745, 49597, 49735, 49747, 49748, 
49600, 49586, 49733, 49746, 49599
29879, 47222, 47266, 47270, 47226, 47223, 47267, 47271, 47227, 49735, 49747, 49748, 49600, 49738, 49750, 49751, 
49603, 49589, 49736, 49749, 49602
29880, 47223, 47267, 47271, 47227, 18131, 18142, 18143, 18132, 49738, 49750, 49751, 49603, 0, 0, 0, 
0, 49592, 49739, 49752, 49605
29881, 2597, 2608, 2609, 2598, 47224, 47268, 47272, 47228, 0, 0, 0, 0, 49742, 49754, 49755, 
49607, 49593, 49740, 49753, 49606
29882, 47224, 47268, 47272, 47228, 47225, 47269, 47273, 47229, 49742, 49754, 49755, 49607, 49745, 49757, 49758, 
49610, 49596, 49743, 49756, 49609
29883, 47225, 47269, 47273, 47229, 47226, 47270, 47274, 47230, 49745, 49757, 49758, 49610, 49748, 49760, 49761, 
49613, 49599, 49746, 49759, 49612
29884, 47226, 47270, 47274, 47230, 47227, 47271, 47275, 47231, 49748, 49760, 49761, 49613, 49751, 49763, 49764, 
49616, 49602, 49749, 49762, 49615
29885, 47227, 47271, 47275, 47231, 18132, 18143, 18144, 18133, 49751, 49763, 49764, 49616, 0, 0, 0, 
0, 49605, 49752, 49765, 49618
29886, 2598, 2609, 2610, 2599, 47228, 47272, 47276, 47232, 0, 0, 0, 0, 49755, 49767, 49768, 
49620, 49606, 49753, 49766, 49619
29887, 47228, 47272, 47276, 47232, 47229, 47273, 47277, 47233, 49755, 49767, 49768, 49620, 49758, 49770, 49771, 
49623, 49609, 49756, 49769, 49622
29888, 47229, 47273, 47277, 47233, 47230, 47274, 47278, 47234, 49758, 49770, 49771, 49623, 49761, 49773, 49774, 
49626, 49612, 49759, 49772, 49625
29889, 47230, 47274, 47278, 47234, 47231, 47275, 47279, 47235, 49761, 49773, 49774, 49626, 49764, 49776, 49777, 
49629, 49615, 49762, 49775, 49628
29890, 47231, 47275, 47279, 47235, 18133, 18144, 18145, 18134, 49764, 49776, 49777, 49629, 0, 0, 0, 
0, 49618, 49765, 49778, 49631
29891, 2599, 2610, 2611, 2600, 47232, 47276, 47280, 47236, 0, 0, 0, 0, 49768, 49780, 49781, 
49633, 49619, 49766, 49779, 49632
29892, 47232, 47276, 47280, 47236, 47233, 47277, 47281, 47237, 49768, 49780, 49781, 49633, 49771, 49783, 49784, 
49636, 49622, 49769, 49782, 49635
29893, 47233, 47277, 47281, 47237, 47234, 47278, 47282, 47238, 49771, 49783, 49784, 49636, 49774, 49786, 49787, 
49639, 49625, 49772, 49785, 49638
29894, 47234, 47278, 47282, 47238, 47235, 47279, 47283, 47239, 49774, 49786, 49787, 49639, 49777, 49789, 49790, 
49642, 49628, 49775, 49788, 49641
29895, 47235, 47279, 47283, 47239, 18134, 18145, 18146, 18135, 49777, 49789, 49790, 49642, 0, 0, 0, 
0, 49631, 49778, 49791, 49644
29896, 2600, 2611, 2612, 2601, 47236, 47280, 47284, 47240, 0, 0, 0, 0, 49781, 49793, 49794, 
49646, 49632, 49779, 49792, 49645
29897, 47236, 47280, 47284, 47240, 47237, 47281, 47285, 47241, 49781, 49793, 49794, 49646, 49784, 49796, 49797, 
49649, 49635, 49782, 49795, 49648
29898, 47237, 47281, 47285, 47241, 47238, 47282, 47286, 47242, 49784, 49796, 49797, 49649, 49787, 49799, 49800, 
49652, 49638, 49785, 49798, 49651
29899, 47238, 47282, 47286, 47242, 47239, 47283, 47287, 47243, 49787, 49799, 49800, 49652, 49790, 49802, 49803, 
49655, 49641, 49788, 49801, 49654
29900, 47239, 47283, 47287, 47243, 18135, 18146, 18147, 18136, 49790, 49802, 49803, 49655, 0, 0, 0, 
0, 49644, 49791, 49804, 49657
29901, 2601, 2612, 2613, 2602, 47240, 47284, 47288, 47244, 0, 0, 0, 0, 49794, 49806, 49807, 
49659, 49645, 49792, 49805, 49658
29902, 47240, 47284, 47288, 47244, 47241, 47285, 47289, 47245, 49794, 49806, 49807, 49659, 49797, 49809, 49810, 
49662, 49648, 49795, 49808, 49661
29903, 47241, 47285, 47289, 47245, 47242, 47286, 47290, 47246, 49797, 49809, 49810, 49662, 49800, 49812, 49813, 
49665, 49651, 49798, 49811, 49664
29904, 47242, 47286, 47290, 47246, 47243, 47287, 47291, 47247, 49800, 49812, 49813, 49665, 49803, 49815, 49816, 
49668, 49654, 49801, 49814, 49667
29905, 47243, 47287, 47291, 47247, 18136, 18147, 18148, 18137, 49803, 49815, 49816, 49668, 0, 0, 0, 
0, 49657, 49804, 49817, 49670
29906, 2602, 2613, 2614, 2603, 47244, 47288, 47292, 47248, 0, 0, 0, 0, 49807, 49819, 49820, 
49672, 49658, 49805, 49818, 49671
29907, 47244, 47288, 47292, 47248, 47245, 47289, 47293, 47249, 49807, 49819, 49820, 49672, 49810, 49822, 49823, 
49675, 49661, 49808, 49821, 49674
29908, 47245, 47289, 47293, 47249, 47246, 47290, 47294, 47250, 49810, 49822, 49823, 49675, 49813, 49825, 49826, 
49678, 49664, 49811, 49824, 49677
29909, 47246, 47290, 47294, 47250, 47247, 47291, 47295, 47251, 49813, 49825, 49826, 49678, 49816, 49828, 49829, 
49681, 49667, 49814, 49827, 49680
29910, 47247, 47291, 47295, 47251, 18137, 18148, 18149, 18138, 49816, 49828, 49829, 49681, 0, 0, 0, 
0, 49670, 49817, 49830, 49683
29911, 2603, 2614, 2615, 2604, 47248, 47292, 47296, 47252, 0, 0, 0, 0, 49820, 49832, 49833, 
49685, 49671, 49818, 49831, 49684
29912, 47248, 47292, 47296, 47252, 47249, 47293, 47297, 47253, 49820, 49832, 49833, 49685, 49823, 49835, 49836, 
49688, 49674, 49821, 49834, 49687
29913, 47249, 47293, 47297, 47253, 47250, 47294, 47298, 47254, 49823, 49835, 49836, 49688, 49826, 49838, 49839, 
49691, 49677, 49824, 49837, 49690
29914, 47250, 47294, 47298, 47254, 47251, 47295, 47299, 47255, 49826, 49838, 49839, 49691, 49829, 49841, 49842, 
49694, 49680, 49827, 49840, 49693
29915, 47251, 47295, 47299, 47255, 18138, 18149, 18150, 18139, 49829, 49841, 49842, 49694, 0, 0, 0, 
0, 49683, 49830, 49843, 49696
29916, 2604, 2615, 2616, 2605, 47252, 47296, 47300, 47256, 0, 0, 0, 0, 49833, 49845, 49846, 
49698, 49684, 49831, 49844, 49697
29917, 47252, 47296, 47300, 47256, 47253, 47297, 47301, 47257, 49833, 49845, 49846, 49698, 49836, 49848, 49849, 
49701, 49687, 49834, 49847, 49700
29918, 47253, 47297, 47301, 47257, 47254, 47298, 47302, 47258, 49836, 49848, 49849, 49701, 49839, 49851, 49852, 
49704, 49690, 49837, 49850, 49703
29919, 47254, 47298, 47302, 47258, 47255, 47299, 47303, 47259, 49839, 49851, 49852, 49704, 49842, 49854, 49855, 
49707, 49693, 49840, 49853, 49706
29920, 47255, 47299, 47303, 47259, 18139, 18150, 18151, 18140, 49842, 49854, 49855, 49707, 0, 0, 0, 
0, 49696, 49843, 49856, 49709
29921, 2605, 2616, 187, 186, 47256, 47300, 17804, 17800, 0, 0, 0, 0, 49846, 49857, 0, 
49710, 49697, 49844, 0, 0
29922, 47256, 47300, 17804, 17800, 47257, 47301, 17805, 17801, 49846, 49857, 0, 49710, 49849, 49858, 0, 
49711, 49700, 49847, 0, 0
29923, 47257, 47301, 17805, 17801, 47258, 47302, 17806, 17802, 49849, 49858, 0, 49711, 49852, 49859, 0, 
49712, 49703, 49850, 0, 0
29924, 47258, 47302, 17806, 17802, 47259, 47303, 17807, 17803, 49852, 49859, 0, 49712, 49855, 49860, 0, 
49713, 49706, 49853, 0, 0
29925, 47259, 47303, 17807, 17803, 18140, 18151, 2246, 2245, 49855, 49860, 0, 49713, 0, 0, 0, 
0, 49709, 49856, 0, 0
29926, 164, 165, 2617, 2606, 17354, 17358, 47304, 47260, 0, 0, 0, 0, 17526, 49862, 49863, 
49715, 17516, 17525, 49861, 49714
29927, 17354, 17358, 47304, 47260, 17355, 17359, 47305, 47261, 17526, 49862, 49863, 49715, 17528, 49865, 49866, 
49718, 17518, 17527, 49864, 49717
29928, 17355, 17359, 47305, 47261, 17356, 17360, 47306, 47262, 17528, 49865, 49866, 49718, 17530, 49868, 49869, 
49721, 17520, 17529, 49867, 49720
29929, 17356, 17360, 47306, 47262, 17357, 17361, 47307, 47263, 17530, 49868, 49869, 49721, 17532, 49871, 49872, 
49724, 17522, 17531, 49870, 49723
29930, 17357, 17361, 47307, 47263, 2204, 2205, 18152, 18141, 17532, 49871, 49872, 49724, 0, 0, 0, 
0, 17524, 17533, 49873, 49726
29931, 2606, 2617, 2618, 2607, 47260, 47304, 47308, 47264, 0, 0, 0, 0, 49863, 49875, 49876, 
49728, 49714, 49861, 49874, 49727
29932, 47260, 47304, 47308, 47264, 47261, 47305, 47309, 47265, 49863, 49875, 49876, 49728, 49866, 49878, 49879, 
49731, 49717, 49864, 49877, 49730
29933, 47261, 47305, 47309, 47265, 47262, 47306, 47310, 47266, 49866, 49878, 49879, 49731, 49869, 49881, 49882, 
49734, 49720, 49867, 49880, 49733
29934, 47262, 47306, 47310, 47266, 47263, 47307, 47311, 47267, 49869, 49881, 49882, 49734, 49872, 49884, 49885, 
49737, 49723, 49870, 49883, 49736
29935, 47263, 47307, 47311, 47267, 18141, 18152, 18153, 18142, 49872, 49884, 49885, 49737, 0, 0, 0, 
0, 49726, 49873, 49886, 49739
29936, 2607, 2618, 2619, 2608, 47264, 47308, 47312, 47268, 0, 0, 0, 0, 49876, 49888, 49889, 
49741, 49727, 49874, 49887, 49740
29937, 47264, 47308, 47312, 47268, 47265, 47309, 47313, 47269, 49876, 49888, 49889, 49741, 49879, 49891, 49892, 
49744, 49730, 49877, 49890, 49743
29938, 47265, 47309, 47313, 47269, 47266, 47310, 47314, 47270, 49879, 49891, 49892, 49744, 49882, 49894, 49895, 
49747, 49733, 49880, 49893, 49746
29939, 47266, 47310, 47314, 47270, 47267, 47311, 47315, 47271, 49882, 49894, 49895, 49747, 49885, 49897, 49898, 
49750, 49736, 49883, 49896, 49749
29940, 47267, 47311, 47315, 47271, 18142, 18153, 18154, 18143, 49885, 49897, 49898, 49750, 0, 0, 0, 
0, 49739, 49886, 49899, 49752
29941, 2608, 2619, 2620, 2609, 47268, 47312, 47316, 47272, 0, 0, 0, 0, 49889, 49901, 49902, 
49754, 49740, 49887, 49900, 49753
29942, 47268, 47312, 47316, 47272, 47269, 47313, 47317, 47273, 49889, 49901, 49902, 49754, 49892, 49904, 49905, 
49757, 49743, 49890, 49903, 49756
29943, 47269, 47313, 47317, 47273, 47270, 47314, 47318, 47274, 49892, 49904, 49905, 49757, 49895, 49907, 49908, 
49760, 49746, 49893, 49906, 49759
29944, 47270, 47314, 47318, 47274, 47271, 47315, 47319, 47275, 49895, 49907, 49908, 49760, 49898, 49910, 49911, 
49763, 49749, 49896, 49909, 49762
29945, 47271, 47315, 47319, 47275, 18143, 18154, 18155, 18144, 49898, 49910, 49911, 49763, 0, 0, 0, 
0, 49752, 49899, 49912, 49765
29946, 2609, 2620, 2621, 2610, 47272, 47316, 47320, 47276, 0, 0, 0, 0, 49902, 49914, 49915, 
49767, 49753, 49900, 49913, 49766
29947, 47272, 47316, 47320, 47276, 47273, 47317, 47321, 47277, 49902, 49914, 49915, 49767, 49905, 49917, 49918, 
49770, 49756, 49903, 49916, 49769
29948, 47273, 47317, 47321, 47277, 47274, 47318, 47322, 47278, 49905, 49917, 49918, 49770, 49908, 49920, 49921, 
49773, 49759, 49906, 49919, 49772
29949, 47274, 47318, 47322, 47278, 47275, 47319, 47323, 47279, 49908, 49920, 49921, 49773, 49911, 49923, 49924, 
49776, 49762, 49909, 49922, 49775
29950, 47275, 47319, 47323, 47279, 18144, 18155, 18156, 18145, 49911, 49923, 49924, 49776, 0, 0, 0, 
0, 49765, 49912, 49925, 49778
29951, 2610, 2621, 2622, 2611, 47276, 47320, 47324, 47280, 0, 0, 0, 0, 49915, 49927, 49928, 
49780, 49766, 49913, 49926, 49779
29952, 47276, 47320, 47324, 47280, 47277, 47321, 47325, 47281, 49915, 49927, 49928, 49780, 49918, 49930, 49931, 
49783, 49769, 49916, 49929, 49782
29953, 47277, 47321, 47325, 47281, 47278, 47322, 47326, 47282, 49918, 49930, 49931, 49783, 49921, 49933, 49934, 
49786, 49772, 49919, 49932, 49785
29954, 47278, 47322, 47326, 47282, 47279, 47323, 47327, 47283, 49921, 49933, 49934, 49786, 49924, 49936, 49937, 
49789, 49775, 49922, 49935, 49788
29955, 47279, 47323, 47327, 47283, 18145, 18156, 18157, 18146, 49924, 49936, 49937, 49789, 0, 0, 0, 
0, 49778, 49925, 49938, 49791
29956, 2611, 2622, 2623, 2612, 47280, 47324, 47328, 47284, 0, 0, 0, 0, 49928, 49940, 49941, 
49793, 49779, 49926, 49939, 49792
29957, 47280, 47324, 47328, 47284, 47281, 47325, 47329, 47285, 49928, 49940, 49941, 49793, 49931, 49943, 49944, 
49796, 49782, 49929, 49942, 49795
29958, 47281, 47325, 47329, 47285, 47282, 47326, 47330, 47286, 49931, 49943, 49944, 49796, 49934, 49946, 49947, 
49799, 49785, 49932, 49945, 49798
29959, 47282, 47326, 47330, 47286, 47283, 47327, 47331, 47287, 49934, 49946, 49947, 49799, 49937, 49949, 49950, 
49802, 49788, 49935, 49948, 49801
29960, 47283, 47327, 47331, 47287, 18146, 18157, 18158, 18147, 49937, 49949, 49950, 49802, 0, 0, 0, 
0, 49791, 49938, 49951, 49804
29961, 2612, 2623, 2624, 2613, 47284, 47328, 47332, 47288, 0, 0, 0, 0, 49941, 49953, 49954, 
49806, 49792, 49939, 49952, 49805
29962, 47284, 47328, 47332, 47288, 47285, 47329, 47333, 47289, 49941, 49953, 49954, 49806, 49944, 49956, 49957, 
49809, 49795, 49942, 49955, 49808
29963, 47285, 47329, 47333, 47289, 47286, 47330, 47334, 47290, 49944, 49956, 49957, 49809, 49947, 49959, 49960, 
49812, 49798, 49945, 49958, 49811
29964, 47286, 47330, 47334, 47290, 47287, 47331, 47335, 47291, 49947, 49959, 49960, 49812, 49950, 49962, 49963, 
49815, 49801, 49948, 49961, 49814
29965, 47287, 47331, 47335, 47291, 18147, 18158, 18159, 18148, 49950, 49962, 49963, 49815, 0, 0, 0, 
0, 49804, 49951, 49964, 49817
29966, 2613, 2624, 2625, 2614, 47288, 47332, 47336, 47292, 0, 0, 0, 0, 49954, 49966, 49967, 
49819, 49805, 49952, 49965, 49818
29967, 47288, 47332, 47336, 47292, 47289, 47333, 47337, 47293, 49954, 49966, 49967, 49819, 49957, 49969, 49970, 
49822, 49808, 49955, 49968, 49821
29968, 47289, 47333, 47337, 47293, 47290, 47334, 47338, 47294, 49957, 49969, 49970, 49822, 49960, 49972, 49973, 
49825, 49811, 49958, 49971, 49824
29969, 47290, 47334, 47338, 47294, 47291, 47335, 47339, 47295, 49960, 49972, 49973, 49825, 49963, 49975, 49976, 
49828, 49814, 49961, 49974, 49827
29970, 47291, 47335, 47339, 47295, 18148, 18159, 18160, 18149, 49963, 49975, 49976, 49828, 0, 0, 0, 
0, 49817, 49964, 49977, 49830
29971, 2614, 2625, 2626, 2615, 47292, 47336, 47340, 47296, 0, 0, 0, 0, 49967, 49979, 49980, 
49832, 49818, 49965, 49978, 49831
29972, 47292, 47336, 47340, 47296, 47293, 47337, 47341, 47297, 49967, 49979, 49980, 49832, 49970, 49982, 49983, 
49835, 49821, 49968, 49981, 49834
29973, 47293, 47337, 47341, 47297, 47294, 47338, 47342, 47298, 49970, 49982, 49983, 49835, 49973, 49985, 49986, 
49838, 49824, 49971, 49984, 49837
29974, 47294, 47338, 47342, 47298, 47295, 47339, 47343, 47299, 49973, 49985, 49986, 49838, 49976, 49988, 49989, 
49841, 49827, 49974, 49987, 49840
29975, 47295, 47339, 47343, 47299, 18149, 18160, 18161, 18150, 49976, 49988, 49989, 49841, 0, 0, 0, 
0, 49830, 49977, 49990, 49843
29976, 2615, 2626, 2627, 2616, 47296, 47340, 47344, 47300, 0, 0, 0, 0, 49980, 49992, 49993, 
49845, 49831, 49978, 49991, 49844
29977, 47296, 47340, 47344, 47300, 47297, 47341, 47345, 47301, 49980, 49992, 49993, 49845, 49983, 49995, 49996, 
49848, 49834, 49981, 49994, 49847
29978, 47297, 47341, 47345, 47301, 47298, 47342, 47346, 47302, 49983, 49995, 49996, 49848, 49986, 49998, 49999, 
49851, 49837, 49984, 49997, 49850
29979, 47298, 47342, 47346, 47302, 47299, 47343, 47347, 47303, 49986, 49998, 49999, 49851, 49989, 50001, 50002, 
49854, 49840, 49987, 50000, 49853
29980, 47299, 47343, 47347, 47303, 18150, 18161, 18162, 18151, 49989, 50001, 50002, 49854, 0, 0, 0, 
0, 49843, 49990, 50003, 49856
29981, 2616, 2627, 188, 187, 47300, 47344, 17808, 17804, 0, 0, 0, 0, 49993, 50004, 0, 
49857, 49844, 49991, 0, 0
29982, 47300, 47344, 17808, 17804, 47301, 47345, 17809, 17805, 49993, 50004, 0, 49857, 49996, 50005, 0, 
49858, 49847, 49994, 0, 0
29983, 47301, 47345, 17809, 17805, 47302, 47346, 17810, 17806, 49996, 50005, 0, 49858, 49999, 50006, 0, 
49859, 49850, 49997, 0, 0
29984, 47302, 47346, 17810, 17806, 47303, 47347, 17811, 17807, 49999, 50006, 0, 49859, 50002, 50007, 0, 
49860, 49853, 50000, 0, 0
29985, 47303, 47347, 17811, 17807, 18151, 18162, 2247, 2246, 50002, 50007, 0, 49860, 0, 0, 0, 
0, 49856, 50003, 0, 0
29986, 165, 166, 2628, 2617, 17358, 17362, 47348, 47304, 0, 0, 0, 0, 17535, 50009, 50010, 
49862, 17525, 17534, 50008, 49861
29987, 17358, 17362, 47348, 47304, 17359, 17363, 47349, 47305, 17535, 50009, 50010, 49862, 17537, 50012, 50013, 
49865, 17527, 17536, 50011, 49864
29988, 17359, 17363, 47349, 47305, 17360, 17364, 47350, 47306, 17537, 50012, 50013, 49865, 17539, 50015, 50016, 
49868, 17529, 17538, 50014, 49867
29989, 17360, 17364, 47350, 47306, 17361, 17365, 47351, 47307, 17539, 50015, 50016, 49868, 17541, 50018, 50019, 
49871, 17531, 17540, 50017, 49870
29990, 17361, 17365, 47351, 47307, 2205, 2206, 18163, 18152, 17541, 50018, 50019, 49871, 0, 0, 0, 
0, 17533, 17542, 50020, 49873
29991, 2617, 2628, 2629, 2618, 47304, 47348, 47352, 47308, 0, 0, 0, 0, 50010, 50022, 50023, 
49875, 49861, 50008, 50021, 49874
29992, 47304, 47348, 47352, 47308, 47305, 47349, 47353, 47309, 50010, 50022, 50023, 49875, 50013, 50025, 50026, 
49878, 49864, 50011, 50024, 49877
29993, 47305, 47349, 47353, 47309, 47306, 47350, 47354, 47310, 50013, 50025, 50026, 49878, 50016, 50028, 50029, 
49881, 49867, 50014, 50027, 49880
29994, 47306, 47350, 47354, 47310, 47307, 47351, 47355, 47311, 50016, 50028, 50029, 49881, 50019, 50031, 50032, 
49884, 49870, 50017, 50030, 49883
29995, 47307, 47351, 47355, 47311, 18152, 18163, 18164, 18153, 50019, 50031, 50032, 49884, 0, 0, 0, 
0, 49873, 50020, 50033, 49886
29996, 2618, 2629, 2630, 2619, 47308, 47352, 47356, 47312, 0, 0, 0, 0, 50023, 50035, 50036, 
49888, 49874, 50021, 50034, 49887
29997, 47308, 47352, 47356, 47312, 47309, 47353, 47357, 47313, 50023, 50035, 50036, 49888, 50026, 50038, 50039, 
49891, 49877, 50024, 50037, 49890
29998, 47309, 47353, 47357, 47313, 47310, 47354, 47358, 47314, 50026, 50038, 50039, 49891, 50029, 50041, 50042, 
49894, 49880, 50027, 50040, 49893
29999, 47310, 47354, 47358, 47314, 47311, 47355, 47359, 47315, 50029, 50041, 50042, 49894, 50032, 50044, 50045, 
49897, 49883, 50030, 50043, 49896
30000, 47311, 47355, 47359, 47315, 18153, 18164, 18165, 18154, 50032, 50044, 50045, 49897, 0, 0, 0, 
0, 49886, 50033, 50046, 49899
30001, 2619, 2630, 2631, 2620, 47312, 47356, 47360, 47316, 0, 0, 0, 0, 50036, 50048, 50049, 
49901, 49887, 50034, 50047, 49900
30002, 47312, 47356, 47360, 47316, 47313, 47357, 47361, 47317, 50036, 50048, 50049, 49901, 50039, 50051, 50052, 
49904, 49890, 50037, 50050, 49903
30003, 47313, 47357, 47361, 47317, 47314, 47358, 47362, 47318, 50039, 50051, 50052, 49904, 50042, 50054, 50055, 
49907, 49893, 50040, 50053, 49906
30004, 47314, 47358, 47362, 47318, 47315, 47359, 47363, 47319, 50042, 50054, 50055, 49907, 50045, 50057, 50058, 
49910, 49896, 50043, 50056, 49909
30005, 47315, 47359, 47363, 47319, 18154, 18165, 18166, 18155, 50045, 50057, 50058, 49910, 0, 0, 0, 
0, 49899, 50046, 50059, 49912
30006, 2620, 2631, 2632, 2621, 47316, 47360, 47364, 47320, 0, 0, 0, 0, 50049, 50061, 50062, 
49914, 49900, 50047, 50060, 49913
30007, 47316, 47360, 47364, 47320, 47317, 47361, 47365, 47321, 50049, 50061, 50062, 49914, 50052, 50064, 50065, 
49917, 49903, 50050, 50063, 49916
30008, 47317, 47361, 47365, 47321, 47318, 47362, 47366, 47322, 50052, 50064, 50065, 49917, 50055, 50067, 50068, 
49920, 49906, 50053, 50066, 49919
30009, 47318, 47362, 47366, 47322, 47319, 47363, 47367, 47323, 50055, 50067, 50068, 49920, 50058, 50070, 50071, 
49923, 49909, 50056, 50069, 49922
30010, 47319, 47363, 47367, 47323, 18155, 18166, 18167, 18156, 50058, 50070, 50071, 49923, 0, 0, 0, 
0, 49912, 50059, 50072, 49925
30011, 2621, 2632, 2633, 2622, 47320, 47364, 47368, 47324, 0, 0, 0, 0, 50062, 50074, 50075, 
49927, 49913, 50060, 50073, 49926
30012, 47320, 47364, 47368, 47324, 47321, 47365, 47369, 47325, 50062, 50074, 50075, 49927, 50065, 50077, 50078, 
49930, 49916, 50063, 50076, 49929
30013, 47321, 47365, 47369, 47325, 47322, 47366, 47370, 47326, 50065, 50077, 50078, 49930, 50068, 50080, 50081, 
49933, 49919, 50066, 50079, 49932
30014, 47322, 47366, 47370, 47326, 47323, 47367, 47371, 47327, 50068, 50080, 50081, 49933, 50071, 50083, 50084, 
49936, 49922, 50069, 50082, 49935
30015, 47323, 47367, 47371, 47327, 18156, 18167, 18168, 18157, 50071, 50083, 50084, 49936, 0, 0, 0, 
0, 49925, 50072, 50085, 49938
30016, 2622, 2633, 2634, 2623, 47324, 47368, 47372, 47328, 0, 0, 0, 0, 50075, 50087, 50088, 
49940, 49926, 50073, 50086, 49939
30017, 47324, 47368, 47372, 47328, 47325, 47369, 47373, 47329, 50075, 50087, 50088, 49940, 50078, 50090, 50091, 
49943, 49929, 50076, 50089, 49942
30018, 47325, 47369, 47373, 47329, 47326, 47370, 47374, 47330, 50078, 50090, 50091, 49943, 50081, 50093, 50094, 
49946, 49932, 50079, 50092, 49945
30019, 47326, 47370, 47374, 47330, 47327, 47371, 47375, 47331, 50081, 50093, 50094, 49946, 50084, 50096, 50097, 
49949, 49935, 50082, 50095, 49948
30020, 47327, 47371, 47375, 47331, 18157, 18168, 18169, 18158, 50084, 50096, 50097, 49949, 0, 0, 0, 
0, 49938, 50085, 50098, 49951
30021, 2623, 2634, 2635, 2624, 47328, 47372, 47376, 47332, 0, 0, 0, 0, 50088, 50100, 50101, 
49953, 49939, 50086, 50099, 49952
30022, 47328, 47372, 47376, 47332, 47329, 47373, 47377, 47333, 50088, 50100, 50101, 49953, 50091, 50103, 50104, 
49956, 49942, 50089, 50102, 49955
30023, 47329, 47373, 47377, 47333, 47330, 47374, 47378, 47334, 50091, 50103, 50104, 49956, 50094, 50106, 50107, 
49959, 49945, 50092, 50105, 49958
30024, 47330, 47374, 47378, 47334, 47331, 47375, 47379, 47335, 50094, 50106, 50107, 49959, 50097, 50109, 50110, 
49962, 49948, 50095, 50108, 49961
30025, 47331, 47375, 47379, 47335, 18158, 18169, 18170, 18159, 50097, 50109, 50110, 49962, 0, 0, 0, 
0, 49951, 50098, 50111, 49964
30026, 2624, 2635, 2636, 2625, 47332, 47376, 47380, 47336, 0, 0, 0, 0, 50101, 50113, 50114, 
49966, 49952, 50099, 50112, 49965
30027, 47332, 47376, 47380, 47336, 47333, 47377, 47381, 47337, 50101, 50113, 50114, 49966, 50104, 50116, 50117, 
49969, 49955, 50102, 50115, 49968
30028, 47333, 47377, 47381, 47337, 47334, 47378, 47382, 47338, 50104, 50116, 50117, 49969, 50107, 50119, 50120, 
49972, 49958, 50105, 50118, 49971
30029, 47334, 47378, 47382, 47338, 47335, 47379, 47383, 47339, 50107, 50119, 50120, 49972, 50110, 50122, 50123, 
49975, 49961, 50108, 50121, 49974
30030, 47335, 47379, 47383, 47339, 18159, 18170, 18171, 18160, 50110, 50122, 50123, 49975, 0, 0, 0, 
0, 49964, 50111, 50124, 49977
30031, 2625, 2636, 2637, 2626, 47336, 47380, 47384, 47340, 0, 0, 0, 0, 50114, 50126, 50127, 
49979, 49965, 50112, 50125, 49978
30032, 47336, 47380, 47384, 47340, 47337, 47381, 47385, 47341, 50114, 50126, 50127, 49979, 50117, 50129, 50130, 
49982, 49968, 50115, 50128, 49981
30033, 47337, 47381, 47385, 47341, 47338, 47382, 47386, 47342, 50117, 50129, 50130, 49982, 50120, 50132, 50133, 
49985, 49971, 50118, 50131, 49984
30034, 47338, 47382, 47386, 47342, 47339, 47383, 47387, 47343, 50120, 50132, 50133, 49985, 50123, 50135, 50136, 
49988, 49974, 50121, 50134, 49987
30035, 47339, 47383, 47387, 47343, 18160, 18171, 18172, 18161, 50123, 50135, 50136, 49988, 0, 0, 0, 
0, 49977, 50124, 50137, 49990
30036, 2626, 2637, 2638, 2627, 47340, 47384, 47388, 47344, 0, 0, 0, 0, 50127, 50139, 50140, 
49992, 49978, 50125, 50138, 49991
30037, 47340, 47384, 47388, 47344, 47341, 47385, 47389, 47345, 50127, 50139, 50140, 49992, 50130, 50142, 50143, 
49995, 49981, 50128, 50141, 49994
30038, 47341, 47385, 47389, 47345, 47342, 47386, 47390, 47346, 50130, 50142, 50143, 49995, 50133, 50145, 50146, 
49998, 49984, 50131, 50144, 49997
30039, 47342, 47386, 47390, 47346, 47343, 47387, 47391, 47347, 50133, 50145, 50146, 49998, 50136, 50148, 50149, 
50001, 49987, 50134, 50147, 50000
30040, 47343, 47387, 47391, 47347, 18161, 18172, 18173, 18162, 50136, 50148, 50149, 50001, 0, 0, 0, 
0, 49990, 50137, 50150, 50003
30041, 2627, 2638, 189, 188, 47344, 47388, 17812, 17808, 0, 0, 0, 0, 50140, 50151, 0, 
50004, 49991, 50138, 0, 0
30042, 47344, 47388, 17812, 17808, 47345, 47389, 17813, 17809, 50140, 50151, 0, 50004, 50143, 50152, 0, 
50005, 49994, 50141, 0, 0
30043, 47345, 47389, 17813, 17809, 47346, 47390, 17814, 17810, 50143, 50152, 0, 50005, 50146, 50153, 0, 
50006, 49997, 50144, 0, 0
30044, 47346, 47390, 17814, 17810, 47347, 47391, 17815, 17811, 50146, 50153, 0, 50006, 50149, 50154, 0, 
50007, 50000, 50147, 0, 0
30045, 47347, 47391, 17815, 17811, 18162, 18173, 2248, 2247, 50149, 50154, 0, 50007, 0, 0, 0, 
0, 50003, 50150, 0, 0
30046, 166, 167, 2639, 2628, 17362, 17366, 47392, 47348, 0, 0, 0, 0, 17544, 50156, 50157, 
50009, 17534, 17543, 50155, 50008
30047, 17362, 17366, 47392, 47348, 17363, 17367, 47393, 47349, 17544, 50156, 50157, 50009, 17546, 50159, 50160, 
50012, 17536, 17545, 50158, 50011
30048, 17363, 17367, 47393, 47349, 17364, 17368, 47394, 47350, 17546, 50159, 50160, 50012, 17548, 50162, 50163, 
50015, 17538, 17547, 50161, 50014
30049, 17364, 17368, 47394, 47350, 17365, 17369, 47395, 47351, 17548, 50162, 50163, 50015, 17550, 50165, 50166, 
50018, 17540, 17549, 50164, 50017
30050, 17365, 17369, 47395, 47351, 2206, 2207, 18174, 18163, 17550, 50165, 50166, 50018, 0, 0, 0, 
0, 17542, 17551, 50167, 50020
30051, 2628, 2639, 2640, 2629, 47348, 47392, 47396, 47352, 0, 0, 0, 0, 50157, 50169, 50170, 
50022, 50008, 50155, 50168, 50021
30052, 47348, 47392, 47396, 47352, 47349, 47393, 47397, 47353, 50157, 50169, 50170, 50022, 50160, 50172, 50173, 
50025, 50011, 50158, 50171, 50024
30053, 47349, 47393, 47397, 47353, 47350, 47394, 47398, 47354, 50160, 50172, 50173, 50025, 50163, 50175, 50176, 
50028, 50014, 50161, 50174, 50027
30054, 47350, 47394, 47398, 47354, 47351, 47395, 47399, 47355, 50163, 50175, 50176, 50028, 50166, 50178, 50179, 
50031, 50017, 50164, 50177, 50030
30055, 47351, 47395, 47399, 47355, 18163, 18174, 18175, 18164, 50166, 50178, 50179, 50031, 0, 0, 0, 
0, 50020, 50167, 50180, 50033
30056, 2629, 2640, 2641, 2630, 47352, 47396, 47400, 47356, 0, 0, 0, 0, 50170, 50182, 50183, 
50035, 50021, 50168, 50181, 50034
30057, 47352, 47396, 47400, 47356, 47353, 47397, 47401, 47357, 50170, 50182, 50183, 50035, 50173, 50185, 50186, 
50038, 50024, 50171, 50184, 50037
30058, 47353, 47397, 47401, 47357, 47354, 47398, 47402, 47358, 50173, 50185, 50186, 50038, 50176, 50188, 50189, 
50041, 50027, 50174, 50187, 50040
30059, 47354, 47398, 47402, 47358, 47355, 47399, 47403, 47359, 50176, 50188, 50189, 50041, 50179, 50191, 50192, 
50044, 50030, 50177, 50190, 50043
30060, 47355, 47399, 47403, 47359, 18164, 18175, 18176, 18165, 50179, 50191, 50192, 50044, 0, 0, 0, 
0, 50033, 50180, 50193, 50046
30061, 2630, 2641, 2642, 2631, 47356, 47400, 47404, 47360, 0, 0, 0, 0, 50183, 50195, 50196, 
50048, 50034, 50181, 50194, 50047
30062, 47356, 47400, 47404, 47360, 47357, 47401, 47405, 47361, 50183, 50195, 50196, 50048, 50186, 50198, 50199, 
50051, 50037, 50184, 50197, 50050
30063, 47357, 47401, 47405, 47361, 47358, 47402, 47406, 47362, 50186, 50198, 50199, 50051, 50189, 50201, 50202, 
50054, 50040, 50187, 50200, 50053
30064, 47358, 47402, 47406, 47362, 47359, 47403, 47407, 47363, 50189, 50201, 50202, 50054, 50192, 50204, 50205, 
50057, 50043, 50190, 50203, 50056
30065, 47359, 47403, 47407, 47363, 18165, 18176, 18177, 18166, 50192, 50204, 50205, 50057, 0, 0, 0, 
0, 50046, 50193, 50206, 50059
30066, 2631, 2642, 2643, 2632, 47360, 47404, 47408, 47364, 0, 0, 0, 0, 50196, 50208, 50209, 
50061, 50047, 50194, 50207, 50060
30067, 47360, 47404, 47408, 47364, 47361, 47405, 47409, 47365, 50196, 50208, 50209, 50061, 50199, 50211, 50212, 
50064, 50050, 50197, 50210, 50063
30068, 47361, 47405, 47409, 47365, 47362, 47406, 47410, 47366, 50199, 50211, 50212, 50064, 50202, 50214, 50215, 
50067, 50053, 50200, 50213, 50066
30069, 47362, 47406, 47410, 47366, 47363, 47407, 47411, 47367, 50202, 50214, 50215, 50067, 50205, 50217, 50218, 
50070, 50056, 50203, 50216, 50069
30070, 47363, 47407, 47411, 47367, 18166, 18177, 18178, 18167, 50205, 50217, 50218, 50070, 0, 0, 0, 
0, 50059, 50206, 50219, 50072
30071, 2632, 2643, 2644, 2633, 47364, 47408, 47412, 47368, 0, 0, 0, 0, 50209, 50221, 50222, 
50074, 50060, 50207, 50220, 50073
30072, 47364, 47408, 47412, 47368, 47365, 47409, 47413, 47369, 50209, 50221, 50222, 50074, 50212, 50224, 50225, 
50077, 50063, 50210, 50223, 50076
30073, 47365, 47409, 47413, 47369, 47366, 47410, 47414, 47370, 50212, 50224, 50225, 50077, 50215, 50227, 50228, 
50080, 50066, 50213, 50226, 50079
30074, 47366, 47410, 47414, 47370, 47367, 47411, 47415, 47371, 50215, 50227, 50228, 50080, 50218, 50230, 50231, 
50083, 50069, 50216, 50229, 50082
30075, 47367, 47411, 47415, 47371, 18167, 18178, 18179, 18168, 50218, 50230, 50231, 50083, 0, 0, 0, 
0, 50072, 50219, 50232, 50085
30076, 2633, 2644, 2645, 2634, 47368, 47412, 47416, 47372, 0, 0, 0, 0, 50222, 50234, 50235, 
50087, 50073, 50220, 50233, 50086
30077, 47368, 47412, 47416, 47372, 47369, 47413, 47417, 47373, 50222, 50234, 50235, 50087, 50225, 50237, 50238, 
50090, 50076, 50223, 50236, 50089
30078, 47369, 47413, 47417, 47373, 47370, 47414, 47418, 47374, 50225, 50237, 50238, 50090, 50228, 50240, 50241, 
50093, 50079, 50226, 50239, 50092
30079, 47370, 47414, 47418, 47374, 47371, 47415, 47419, 47375, 50228, 50240, 50241, 50093, 50231, 50243, 50244, 
50096, 50082, 50229, 50242, 50095
30080, 47371, 47415, 47419, 47375, 18168, 18179, 18180, 18169, 50231, 50243, 50244, 50096, 0, 0, 0, 
0, 50085, 50232, 50245, 50098
30081, 2634, 2645, 2646, 2635, 47372, 47416, 47420, 47376, 0, 0, 0, 0, 50235, 50247, 50248, 
50100, 50086, 50233, 50246, 50099
30082, 47372, 47416, 47420, 47376, 47373, 47417, 47421, 47377, 50235, 50247, 50248, 50100, 50238, 50250, 50251, 
50103, 50089, 50236, 50249, 50102
30083, 47373, 47417, 47421, 47377, 47374, 47418, 47422, 47378, 50238, 50250, 50251, 50103, 50241, 50253, 50254, 
50106, 50092, 50239, 50252, 50105
30084, 47374, 47418, 47422, 47378, 47375, 47419, 47423, 47379, 50241, 50253, 50254, 50106, 50244, 50256, 50257, 
50109, 50095, 50242, 50255, 50108
30085, 47375, 47419, 47423, 47379, 18169, 18180, 18181, 18170, 50244, 50256, 50257, 50109, 0, 0, 0, 
0, 50098, 50245, 50258, 50111
30086, 2635, 2646, 2647, 2636, 47376, 47420, 47424, 47380, 0, 0, 0, 0, 50248, 50260, 50261, 
50113, 50099, 50246, 50259, 50112
30087, 47376, 47420, 47424, 47380, 47377, 47421, 47425, 47381, 50248, 50260, 50261, 50113, 50251, 50263, 50264, 
50116, 50102, 50249, 50262, 50115
30088, 47377, 47421, 47425, 47381, 47378, 47422, 47426, 47382, 50251, 50263, 50264, 50116, 50254, 50266, 50267, 
50119, 50105, 50252, 50265, 50118
30089, 47378, 47422, 47426, 47382, 47379, 47423, 47427, 47383, 50254, 50266, 50267, 50119, 50257, 50269, 50270, 
50122, 50108, 50255, 50268, 50121
30090, 47379, 47423, 47427, 47383, 18170, 18181, 18182, 18171, 50257, 50269, 50270, 50122, 0, 0, 0, 
0, 50111, 50258, 50271, 50124
30091, 2636, 2647, 2648, 2637, 47380, 47424, 47428, 47384, 0, 0, 0, 0, 50261, 50273, 50274, 
50126, 50112, 50259, 50272, 50125
30092, 47380, 47424, 47428, 47384, 47381, 47425, 47429, 47385, 50261, 50273, 50274, 50126, 50264, 50276, 50277, 
50129, 50115, 50262, 50275, 50128
30093, 47381, 47425, 47429, 47385, 47382, 47426, 47430, 47386, 50264, 50276, 50277, 50129, 50267, 50279, 50280, 
50132, 50118, 50265, 50278, 50131
30094, 47382, 47426, 47430, 47386, 47383, 47427, 47431, 47387, 50267, 50279, 50280, 50132, 50270, 50282, 50283, 
50135, 50121, 50268, 50281, 50134
30095, 47383, 47427, 47431, 47387, 18171, 18182, 18183, 18172, 50270, 50282, 50283, 50135, 0, 0, 0, 
0, 50124, 50271, 50284, 50137
30096, 2637, 2648, 2649, 2638, 47384, 47428, 47432, 47388, 0, 0, 0, 0, 50274, 50286, 50287, 
50139, 50125, 50272, 50285, 50138
30097, 47384, 47428, 47432, 47388, 47385, 47429, 47433, 47389, 50274, 50286, 50287, 50139, 50277, 50289, 50290, 
50142, 50128, 50275, 50288, 50141
30098, 47385, 47429, 47433, 47389, 47386, 47430, 47434, 47390, 50277, 50289, 50290, 50142, 50280, 50292, 50293, 
50145, 50131, 50278, 50291, 50144
30099, 47386, 47430, 47434, 47390, 47387, 47431, 47435, 47391, 50280, 50292, 50293, 50145, 50283, 50295, 50296, 
50148, 50134, 50281, 50294, 50147
30100, 47387, 47431, 47435, 47391, 18172, 18183, 18184, 18173, 50283, 50295, 50296, 50148, 0, 0, 0, 
0, 50137, 50284, 50297, 50150
30101, 2638, 2649, 190, 189, 47388, 47432, 17816, 17812, 0, 0, 0, 0, 50287, 50298, 0, 
50151, 50138, 50285, 0, 0
30102, 47388, 47432, 17816, 17812, 47389, 47433, 17817, 17813, 50287, 50298, 0, 50151, 50290, 50299, 0, 
50152, 50141, 50288, 0, 0
30103, 47389, 47433, 17817, 17813, 47390, 47434, 17818, 17814, 50290, 50299, 0, 50152, 50293, 50300, 0, 
50153, 50144, 50291, 0, 0
30104, 47390, 47434, 17818, 17814, 47391, 47435, 17819, 17815, 50293, 50300, 0, 50153, 50296, 50301, 0, 
50154, 50147, 50294, 0, 0
30105, 47391, 47435, 17819, 17815, 18173, 18184, 2249, 2248, 50296, 50301, 0, 50154, 0, 0, 0, 
0, 50150, 50297, 0, 0
30106, 167, 168, 2650, 2639, 17366, 17370, 47436, 47392, 0, 0, 0, 0, 17553, 50303, 50304, 
50156, 17543, 17552, 50302, 50155
30107, 17366, 17370, 47436, 47392, 17367, 17371, 47437, 47393, 17553, 50303, 50304, 50156, 17555, 50306, 50307, 
50159, 17545, 17554, 50305, 50158
30108, 17367, 17371, 47437, 47393, 17368, 17372, 47438, 47394, 17555, 50306, 50307, 50159, 17557, 50309, 50310, 
50162, 17547, 17556, 50308, 50161
30109, 17368, 17372, 47438, 47394, 17369, 17373, 47439, 47395, 17557, 50309, 50310, 50162, 17559, 50312, 50313, 
50165, 17549, 17558, 50311, 50164
30110, 17369, 17373, 47439, 47395, 2207, 2208, 18185, 18174, 17559, 50312, 50313, 50165, 0, 0, 0, 
0, 17551, 17560, 50314, 50167
30111, 2639, 2650, 2651, 2640, 47392, 47436, 47440, 47396, 0, 0, 0, 0, 50304, 50316, 50317, 
50169, 50155, 50302, 50315, 50168
30112, 47392, 47436, 47440, 47396, 47393, 47437, 47441, 47397, 50304, 50316, 50317, 50169, 50307, 50319, 50320, 
50172, 50158, 50305, 50318, 50171
30113, 47393, 47437, 47441, 47397, 47394, 47438, 47442, 47398, 50307, 50319, 50320, 50172, 50310, 50322, 50323, 
50175, 50161, 50308, 50321, 50174
30114, 47394, 47438, 47442, 47398, 47395, 47439, 47443, 47399, 50310, 50322, 50323, 50175, 50313, 50325, 50326, 
50178, 50164, 50311, 50324, 50177
30115, 47395, 47439, 47443, 47399, 18174, 18185, 18186, 18175, 50313, 50325, 50326, 50178, 0, 0, 0, 
0, 50167, 50314, 50327, 50180
30116, 2640, 2651, 2652, 2641, 47396, 47440, 47444, 47400, 0, 0, 0, 0, 50317, 50329, 50330, 
50182, 50168, 50315, 50328, 50181
30117, 47396, 47440, 47444, 47400, 47397, 47441, 47445, 47401, 50317, 50329, 50330, 50182, 50320, 50332, 50333, 
50185, 50171, 50318, 50331, 50184
30118, 47397, 47441, 47445, 47401, 47398, 47442, 47446, 47402, 50320, 50332, 50333, 50185, 50323, 50335, 50336, 
50188, 50174, 50321, 50334, 50187
30119, 47398, 47442, 47446, 47402, 47399, 47443, 47447, 47403, 50323, 50335, 50336, 50188, 50326, 50338, 50339, 
50191, 50177, 50324, 50337, 50190
30120, 47399, 47443, 47447, 47403, 18175, 18186, 18187, 18176, 50326, 50338, 50339, 50191, 0, 0, 0, 
0, 50180, 50327, 50340, 50193
30121, 2641, 2652, 2653, 2642, 47400, 47444, 47448, 47404, 0, 0, 0, 0, 50330, 50342, 50343, 
50195, 50181, 50328, 50341, 50194
30122, 47400, 47444, 47448, 47404, 47401, 47445, 47449, 47405, 50330, 50342, 50343, 50195, 50333, 50345, 50346, 
50198, 50184, 50331, 50344, 50197
30123, 47401, 47445, 47449, 47405, 47402, 47446, 47450, 47406, 50333, 50345, 50346, 50198, 50336, 50348, 50349, 
50201, 50187, 50334, 50347, 50200
30124, 47402, 47446, 47450, 47406, 47403, 47447, 47451, 47407, 50336, 50348, 50349, 50201, 50339, 50351, 50352, 
50204, 50190, 50337, 50350, 50203
30125, 47403, 47447, 47451, 47407, 18176, 18187, 18188, 18177, 50339, 50351, 50352, 50204, 0, 0, 0, 
0, 50193, 50340, 50353, 50206
30126, 2642, 2653, 2654, 2643, 47404, 47448, 47452, 47408, 0, 0, 0, 0, 50343, 50355, 50356, 
50208, 50194, 50341, 50354, 50207
30127, 47404, 47448, 47452, 47408, 47405, 47449, 47453, 47409, 50343, 50355, 50356, 50208, 50346, 50358, 50359, 
50211, 50197, 50344, 50357, 50210
30128, 47405, 47449, 47453, 47409, 47406, 47450, 47454, 47410, 50346, 50358, 50359, 50211, 50349, 50361, 50362, 
50214, 50200, 50347, 50360, 50213
30129, 47406, 47450, 47454, 47410, 47407, 47451, 47455, 47411, 50349, 50361, 50362, 50214, 50352, 50364, 50365, 
50217, 50203, 50350, 50363, 50216
30130, 47407, 47451, 47455, 47411, 18177, 18188, 18189, 18178, 50352, 50364, 50365, 50217, 0, 0, 0, 
0, 50206, 50353, 50366, 50219
30131, 2643, 2654, 2655, 2644, 47408, 47452, 47456, 47412, 0, 0, 0, 0, 50356, 50368, 50369, 
50221, 50207, 50354, 50367, 50220
30132, 47408, 47452, 47456, 47412, 47409, 47453, 47457, 47413, 50356, 50368, 50369, 50221, 50359, 50371, 50372, 
50224, 50210, 50357, 50370, 50223
30133, 47409, 47453, 47457, 47413, 47410, 47454, 47458, 47414, 50359, 50371, 50372, 50224, 50362, 50374, 50375, 
50227, 50213, 50360, 50373, 50226
30134, 47410, 47454, 47458, 47414, 47411, 47455, 47459, 47415, 50362, 50374, 50375, 50227, 50365, 50377, 50378, 
50230, 50216, 50363, 50376, 50229
30135, 47411, 47455, 47459, 47415, 18178, 18189, 18190, 18179, 50365, 50377, 50378, 50230, 0, 0, 0, 
0, 50219, 50366, 50379, 50232
30136, 2644, 2655, 2656, 2645, 47412, 47456, 47460, 47416, 0, 0, 0, 0, 50369, 50381, 50382, 
50234, 50220, 50367, 50380, 50233
30137, 47412, 47456, 47460, 47416, 47413, 47457, 47461, 47417, 50369, 50381, 50382, 50234, 50372, 50384, 50385, 
50237, 50223, 50370, 50383, 50236
30138, 47413, 47457, 47461, 47417, 47414, 47458, 47462, 47418, 50372, 50384, 50385, 50237, 50375, 50387, 50388, 
50240, 50226, 50373, 50386, 50239
30139, 47414, 47458, 47462, 47418, 47415, 47459, 47463, 47419, 50375, 50387, 50388, 50240, 50378, 50390, 50391, 
50243, 50229, 50376, 50389, 50242
30140, 47415, 47459, 47463, 47419, 18179, 18190, 18191, 18180, 50378, 50390, 50391, 50243, 0, 0, 0, 
0, 50232, 50379, 50392, 50245
30141, 2645, 2656, 2657, 2646, 47416, 47460, 47464, 47420, 0, 0, 0, 0, 50382, 50394, 50395, 
50247, 50233, 50380, 50393, 50246
30142, 47416, 47460, 47464, 47420, 47417, 47461, 47465, 47421, 50382, 50394, 50395, 50247, 50385, 50397, 50398, 
50250, 50236, 50383, 50396, 50249
30143, 47417, 47461, 47465, 47421, 47418, 47462, 47466, 47422, 50385, 50397, 50398, 50250, 50388, 50400, 50401, 
50253, 50239, 50386, 50399, 50252
30144, 47418, 47462, 47466, 47422, 47419, 47463, 47467, 47423, 50388, 50400, 50401, 50253, 50391, 50403, 50404, 
50256, 50242, 50389, 50402, 50255
30145, 47419, 47463, 47467, 47423, 18180, 18191, 18192, 18181, 50391, 50403, 50404, 50256, 0, 0, 0, 
0, 50245, 50392, 50405, 50258
30146, 2646, 2657, 2658, 2647, 47420, 47464, 47468, 47424, 0, 0, 0, 0, 50395, 50407, 50408, 
50260, 50246, 50393, 50406, 50259
30147, 47420, 47464, 47468, 47424, 47421, 47465, 47469, 47425, 50395, 50407, 50408, 50260, 50398, 50410, 50411, 
50263, 50249, 50396, 50409, 50262
30148, 47421, 47465, 47469, 47425, 47422, 47466, 47470, 47426, 50398, 50410, 50411, 50263, 50401, 50413, 50414, 
50266, 50252, 50399, 50412, 50265
30149, 47422, 47466, 47470, 47426, 47423, 47467, 47471, 47427, 50401, 50413, 50414, 50266, 50404, 50416, 50417, 
50269, 50255, 50402, 50415, 50268
30150, 47423, 47467, 47471, 47427, 18181, 18192, 18193, 18182, 50404, 50416, 50417, 50269, 0, 0, 0, 
0, 50258, 50405, 50418, 50271
30151, 2647, 2658, 2659, 2648, 47424, 47468, 47472, 47428, 0, 0, 0, 0, 50408, 50420, 50421, 
50273, 50259, 50406, 50419, 50272
30152, 47424, 47468, 47472, 47428, 47425, 47469, 47473, 47429, 50408, 50420, 50421, 50273, 50411, 50423, 50424, 
50276, 50262, 50409, 50422, 50275
30153, 47425, 47469, 47473, 47429, 47426, 47470, 47474, 47430, 50411, 50423, 50424, 50276, 50414, 50426, 50427, 
50279, 50265, 50412, 50425, 50278
30154, 47426, 47470, 47474, 47430, 47427, 47471, 47475, 47431, 50414, 50426, 50427, 50279, 50417, 50429, 50430, 
50282, 50268, 50415, 50428, 50281
30155, 47427, 47471, 47475, 47431, 18182, 18193, 18194, 18183, 50417, 50429, 50430, 50282, 0, 0, 0, 
0, 50271, 50418, 50431, 50284
30156, 2648, 2659, 2660, 2649, 47428, 47472, 47476, 47432, 0, 0, 0, 0, 50421, 50433, 50434, 
50286, 50272, 50419, 50432, 50285
30157, 47428, 47472, 47476, 47432, 47429, 47473, 47477, 47433, 50421, 50433, 50434, 50286, 50424, 50436, 50437, 
50289, 50275, 50422, 50435, 50288
30158, 47429, 47473, 47477, 47433, 47430, 47474, 47478, 47434, 50424, 50436, 50437, 50289, 50427, 50439, 50440, 
50292, 50278, 50425, 50438, 50291
30159, 47430, 47474, 47478, 47434, 47431, 47475, 47479, 47435, 50427, 50439, 50440, 50292, 50430, 50442, 50443, 
50295, 50281, 50428, 50441, 50294
30160, 47431, 47475, 47479, 47435, 18183, 18194, 18195, 18184, 50430, 50442, 50443, 50295, 0, 0, 0, 
0, 50284, 50431, 50444, 50297
30161, 2649, 2660, 191, 190, 47432, 47476, 17820, 17816, 0, 0, 0, 0, 50434, 50445, 0, 
50298, 50285, 50432, 0, 0
30162, 47432, 47476, 17820, 17816, 47433, 47477, 17821, 17817, 50434, 50445, 0, 50298, 50437, 50446, 0, 
50299, 50288, 50435, 0, 0
30163, 47433, 47477, 17821, 17817, 47434, 47478, 17822, 17818, 50437, 50446, 0, 50299, 50440, 50447, 0, 
50300, 50291, 50438, 0, 0
30164, 47434, 47478, 17822, 17818, 47435, 47479, 17823, 17819, 50440, 50447, 0, 50300, 50443, 50448, 0, 
50301, 50294, 50441, 0, 0
30165, 47435, 47479, 17823, 17819, 18184, 18195, 2250, 2249, 50443, 50448, 0, 50301, 0, 0, 0, 
0, 50297, 50444, 0, 0
30166, 168, 169, 2661, 2650, 17370, 17374, 47480, 47436, 0, 0, 0, 0, 17562, 50450, 50451, 
50303, 17552, 17561, 50449, 50302
30167, 17370, 17374, 47480, 47436, 17371, 17375, 47481, 47437, 17562, 50450, 50451, 50303, 17564, 50453, 50454, 
50306, 17554, 17563, 50452, 50305
30168, 17371, 17375, 47481, 47437, 17372, 17376, 47482, 47438, 17564, 50453, 50454, 50306, 17566, 50456, 50457, 
50309, 17556, 17565, 50455, 50308
30169, 17372, 17376, 47482, 47438, 17373, 17377, 47483, 47439, 17566, 50456, 50457, 50309, 17568, 50459, 50460, 
50312, 17558, 17567, 50458, 50311
30170, 17373, 17377, 47483, 47439, 2208, 2209, 18196, 18185, 17568, 50459, 50460, 50312, 0, 0, 0, 
0, 17560, 17569, 50461, 50314
30171, 2650, 2661, 2662, 2651, 47436, 47480, 47484, 47440, 0, 0, 0, 0, 50451, 50463, 50464, 
50316, 50302, 50449, 50462, 50315
30172, 47436, 47480, 47484, 47440, 47437, 47481, 47485, 47441, 50451, 50463, 50464, 50316, 50454, 50466, 50467, 
50319, 50305, 50452, 50465, 50318
30173, 47437, 47481, 47485, 47441, 47438, 47482, 47486, 47442, 50454, 50466, 50467, 50319, 50457, 50469, 50470, 
50322, 50308, 50455, 50468, 50321
30174, 47438, 47482, 47486, 47442, 47439, 47483, 47487, 47443, 50457, 50469, 50470, 50322, 50460, 50472, 50473, 
50325, 50311, 50458, 50471, 50324
30175, 47439, 47483, 47487, 47443, 18185, 18196, 18197, 18186, 50460, 50472, 50473, 50325, 0, 0, 0, 
0, 50314, 50461, 50474, 50327
30176, 2651, 2662, 2663, 2652, 47440, 47484, 47488, 47444, 0, 0, 0, 0, 50464, 50476, 50477, 
50329, 50315, 50462, 50475, 50328
30177, 47440, 47484, 47488, 47444, 47441, 47485, 47489, 47445, 50464, 50476, 50477, 50329, 50467, 50479, 50480, 
50332, 50318, 50465, 50478, 50331
30178, 47441, 47485, 47489, 47445, 47442, 47486, 47490, 47446, 50467, 50479, 50480, 50332, 50470, 50482, 50483, 
50335, 50321, 50468, 50481, 50334
30179, 47442, 47486, 47490, 47446, 47443, 47487, 47491, 47447, 50470, 50482, 50483, 50335, 50473, 50485, 50486, 
50338, 50324, 50471, 50484, 50337
30180, 47443, 47487, 47491, 47447, 18186, 18197, 18198, 18187, 50473, 50485, 50486, 50338, 0, 0, 0, 
0, 50327, 50474, 50487, 50340
30181, 2652, 2663, 2664, 2653, 47444, 47488, 47492, 47448, 0, 0, 0, 0, 50477, 50489, 50490, 
50342, 50328, 50475, 50488, 50341
