51808, 1.6166666666667, -0.16, 0.33333333333333
51809, 1.6583333333333, -0.04, 0.33333333333333
51810, 1.6583333333333, -0.08, 0.33333333333333
51811, 1.6583333333333, -0.12, 0.33333333333333
51812, 1.6583333333333, -0.16, 0.33333333333333
51813, 1.7, -0.04, 0.33333333333333
51814, 1.7, -0.08, 0.33333333333333
51815, 1.7, -0.12, 0.33333333333333
51816, 1.7, -0.16, 0.33333333333333
51817, 1.7416666666667, -0.04, 0.33333333333333
51818, 1.7416666666667, -0.08, 0.33333333333333
51819, 1.7416666666667, -0.12, 0.33333333333333
51820, 1.7416666666667, -0.16, 0.33333333333333
51821, 1.7833333333333, -0.04, 0.33333333333333
51822, 1.7833333333333, -0.08, 0.33333333333333
51823, 1.7833333333333, -0.12, 0.33333333333333
51824, 1.7833333333333, -0.16, 0.33333333333333
51825, 1.825, -0.04, 0.33333333333333
51826, 1.825, -0.08, 0.33333333333333
51827, 1.825, -0.12, 0.33333333333333
51828, 1.825, -0.16, 0.33333333333333
51829, 1.8666666666667, -0.04, 0.33333333333333
51830, 1.8666666666667, -0.08, 0.33333333333333
51831, 1.8666666666667, -0.12, 0.33333333333333
51832, 1.8666666666667, -0.16, 0.33333333333333
51833, 1.9083333333333, -0.04, 0.33333333333333
51834, 1.9083333333333, -0.08, 0.33333333333333
51835, 1.9083333333333, -0.12, 0.33333333333333
51836, 1.9083333333333, -0.16, 0.33333333333333
51837, 1.95, -0.04, 0.33333333333333
51838, 1.95, -0.08, 0.33333333333333
51839, 1.95, -0.12, 0.33333333333333
51840, 1.95, -0.16, 0.33333333333333
51841, 1.9916666666667, -0.04, 0.33333333333333
51842, 1.9916666666667, -0.08, 0.33333333333333
51843, 1.9916666666667, -0.12, 0.33333333333333
51844, 1.9916666666667, -0.16, 0.33333333333333
51845, 2.0333333333333, -0.04, 0.33333333333333
51846, 2.0333333333333, -0.08, 0.33333333333333
51847, 2.0333333333333, -0.12, 0.33333333333333
51848, 2.0333333333333, -0.16, 0.33333333333333
51849, 2.075, -0.04, 0.33333333333333
51850, 2.075, -0.08, 0.33333333333333
51851, 2.075, -0.12, 0.33333333333333
51852, 2.075, -0.16, 0.33333333333333
51853, 2.1166666666667, -0.04, 0.33333333333333
51854, 2.1166666666667, -0.08, 0.33333333333333
51855, 2.1166666666667, -0.12, 0.33333333333333
51856, 2.1166666666667, -0.16, 0.33333333333333
51857, 2.1583333333333, -0.04, 0.33333333333333
51858, 2.1583333333333, -0.08, 0.33333333333333
51859, 2.1583333333333, -0.12, 0.33333333333333
51860, 2.1583333333333, -0.16, 0.33333333333333
51861, 1.2416666666667, -0.04, 0.375
51862, 1.2416666666667, -0.08, 0.375
51863, 1.2416666666667, -0.12, 0.375
51864, 1.2416666666667, -0.16, 0.375
51865, 1.2833333333333, -0.04, 0.375
51866, 1.2833333333333, -0.08, 0.375
51867, 1.2833333333333, -0.12, 0.375
51868, 1.2833333333333, -0.16, 0.375
51869, 1.325, -0.04, 0.375
51870, 1.325, -0.08, 0.375
51871, 1.325, -0.12, 0.375
51872, 1.325, -0.16, 0.375
51873, 1.3666666666667, -0.04, 0.375
51874, 1.3666666666667, -0.08, 0.375
51875, 1.3666666666667, -0.12, 0.375
51876, 1.3666666666667, -0.16, 0.375
51877, 1.4083333333333, -0.04, 0.375
51878, 1.4083333333333, -0.08, 0.375
51879, 1.4083333333333, -0.12, 0.375
51880, 1.4083333333333, -0.16, 0.375
51881, 1.45, -0.04, 0.375
51882, 1.45, -0.08, 0.375
51883, 1.45, -0.12, 0.375
51884, 1.45, -0.16, 0.375
51885, 1.4916666666667, -0.04, 0.375
51886, 1.4916666666667, -0.08, 0.375
51887, 1.4916666666667, -0.12, 0.375
51888, 1.4916666666667, -0.16, 0.375
51889, 1.5333333333333, -0.04, 0.375
51890, 1.5333333333333, -0.08, 0.375
51891, 1.5333333333333, -0.12, 0.375
51892, 1.5333333333333, -0.16, 0.375
51893, 1.575, -0.04, 0.375
51894, 1.575, -0.08, 0.375
51895, 1.575, -0.12, 0.375
51896, 1.575, -0.16, 0.375
51897, 1.6166666666667, -0.04, 0.375
51898, 1.6166666666667, -0.08, 0.375
51899, 1.6166666666667, -0.12, 0.375
51900, 1.6166666666667, -0.16, 0.375
51901, 1.6583333333333, -0.04, 0.375
51902, 1.6583333333333, -0.08, 0.375
51903, 1.6583333333333, -0.12, 0.375
51904, 1.6583333333333, -0.16, 0.375
51905, 1.7, -0.04, 0.375
51906, 1.7, -0.08, 0.375
51907, 1.7, -0.12, 0.375
51908, 1.7, -0.16, 0.375
51909, 1.7416666666667, -0.04, 0.375
51910, 1.7416666666667, -0.08, 0.375
51911, 1.7416666666667, -0.12, 0.375
51912, 1.7416666666667, -0.16, 0.375
51913, 1.7833333333333, -0.04, 0.375
51914, 1.7833333333333, -0.08, 0.375
51915, 1.7833333333333, -0.12, 0.375
51916, 1.7833333333333, -0.16, 0.375
51917, 1.825, -0.04, 0.375
51918, 1.825, -0.08, 0.375
51919, 1.825, -0.12, 0.375
51920, 1.825, -0.16, 0.375
51921, 1.8666666666667, -0.04, 0.375
51922, 1.8666666666667, -0.08, 0.375
51923, 1.8666666666667, -0.12, 0.375
51924, 1.8666666666667, -0.16, 0.375
51925, 1.9083333333333, -0.04, 0.375
51926, 1.9083333333333, -0.08, 0.375
51927, 1.9083333333333, -0.12, 0.375
51928, 1.9083333333333, -0.16, 0.375
51929, 1.95, -0.04, 0.375
51930, 1.95, -0.08, 0.375
51931, 1.95, -0.12, 0.375
51932, 1.95, -0.16, 0.375
51933, 1.9916666666667, -0.04, 0.375
51934, 1.9916666666667, -0.08, 0.375
51935, 1.9916666666667, -0.12, 0.375
51936, 1.9916666666667, -0.16, 0.375
51937, 2.0333333333333, -0.04, 0.375
51938, 2.0333333333333, -0.08, 0.375
51939, 2.0333333333333, -0.12, 0.375
51940, 2.0333333333333, -0.16, 0.375
51941, 2.075, -0.04, 0.375
51942, 2.075, -0.08, 0.375
51943, 2.075, -0.12, 0.375
51944, 2.075, -0.16, 0.375
51945, 2.1166666666667, -0.04, 0.375
51946, 2.1166666666667, -0.08, 0.375
51947, 2.1166666666667, -0.12, 0.375
51948, 2.1166666666667, -0.16, 0.375
51949, 2.1583333333333, -0.04, 0.375
51950, 2.1583333333333, -0.08, 0.375
51951, 2.1583333333333, -0.12, 0.375
51952, 2.1583333333333, -0.16, 0.375
51953, 1.2416666666667, -0.04, 0.41666666666667
51954, 1.2416666666667, -0.08, 0.41666666666667
51955, 1.2416666666667, -0.12, 0.41666666666667
51956, 1.2416666666667, -0.16, 0.41666666666667
51957, 1.2833333333333, -0.04, 0.41666666666667
51958, 1.2833333333333, -0.08, 0.41666666666667
51959, 1.2833333333333, -0.12, 0.41666666666667
51960, 1.2833333333333, -0.16, 0.41666666666667
51961, 1.325, -0.04, 0.41666666666667
51962, 1.325, -0.08, 0.41666666666667
51963, 1.325, -0.12, 0.41666666666667
51964, 1.325, -0.16, 0.41666666666667
51965, 1.3666666666667, -0.04, 0.41666666666667
51966, 1.3666666666667, -0.08, 0.41666666666667
51967, 1.3666666666667, -0.12, 0.41666666666667
51968, 1.3666666666667, -0.16, 0.41666666666667
51969, 1.4083333333333, -0.04, 0.41666666666667
51970, 1.4083333333333, -0.08, 0.41666666666667
51971, 1.4083333333333, -0.12, 0.41666666666667
51972, 1.4083333333333, -0.16, 0.41666666666667
51973, 1.45, -0.04, 0.41666666666667
51974, 1.45, -0.08, 0.41666666666667
51975, 1.45, -0.12, 0.41666666666667
51976, 1.45, -0.16, 0.41666666666667
51977, 1.4916666666667, -0.04, 0.41666666666667
51978, 1.4916666666667, -0.08, 0.41666666666667
51979, 1.4916666666667, -0.12, 0.41666666666667
51980, 1.4916666666667, -0.16, 0.41666666666667
51981, 1.5333333333333, -0.04, 0.41666666666667
51982, 1.5333333333333, -0.08, 0.41666666666667
51983, 1.5333333333333, -0.12, 0.41666666666667
51984, 1.5333333333333, -0.16, 0.41666666666667
51985, 1.575, -0.04, 0.41666666666667
51986, 1.575, -0.08, 0.41666666666667
51987, 1.575, -0.12, 0.41666666666667
51988, 1.575, -0.16, 0.41666666666667
51989, 1.6166666666667, -0.04, 0.41666666666667
51990, 1.6166666666667, -0.08, 0.41666666666667
51991, 1.6166666666667, -0.12, 0.41666666666667
51992, 1.6166666666667, -0.16, 0.41666666666667
51993, 1.6583333333333, -0.04, 0.41666666666667
51994, 1.6583333333333, -0.08, 0.41666666666667
51995, 1.6583333333333, -0.12, 0.41666666666667
51996, 1.6583333333333, -0.16, 0.41666666666667
51997, 1.7, -0.04, 0.41666666666667
51998, 1.7, -0.08, 0.41666666666667
51999, 1.7, -0.12, 0.41666666666667
52000, 1.7, -0.16, 0.41666666666667
52001, 1.7416666666667, -0.04, 0.41666666666667
52002, 1.7416666666667, -0.08, 0.41666666666667
52003, 1.7416666666667, -0.12, 0.41666666666667
52004, 1.7416666666667, -0.16, 0.41666666666667
52005, 1.7833333333333, -0.04, 0.41666666666667
52006, 1.7833333333333, -0.08, 0.41666666666667
52007, 1.7833333333333, -0.12, 0.41666666666667
52008, 1.7833333333333, -0.16, 0.41666666666667
52009, 1.825, -0.04, 0.41666666666667
52010, 1.825, -0.08, 0.41666666666667
52011, 1.825, -0.12, 0.41666666666667
52012, 1.825, -0.16, 0.41666666666667
52013, 1.8666666666667, -0.04, 0.41666666666667
52014, 1.8666666666667, -0.08, 0.41666666666667
52015, 1.8666666666667, -0.12, 0.41666666666667
52016, 1.8666666666667, -0.16, 0.41666666666667
52017, 1.9083333333333, -0.04, 0.41666666666667
52018, 1.9083333333333, -0.08, 0.41666666666667
52019, 1.9083333333333, -0.12, 0.41666666666667
52020, 1.9083333333333, -0.16, 0.41666666666667
52021, 1.95, -0.04, 0.41666666666667
52022, 1.95, -0.08, 0.41666666666667
52023, 1.95, -0.12, 0.41666666666667
52024, 1.95, -0.16, 0.41666666666667
52025, 1.9916666666667, -0.04, 0.41666666666667
52026, 1.9916666666667, -0.08, 0.41666666666667
52027, 1.9916666666667, -0.12, 0.41666666666667
52028, 1.9916666666667, -0.16, 0.41666666666667
52029, 2.0333333333333, -0.04, 0.41666666666667
52030, 2.0333333333333, -0.08, 0.41666666666667
52031, 2.0333333333333, -0.12, 0.41666666666667
52032, 2.0333333333333, -0.16, 0.41666666666667
52033, 2.075, -0.04, 0.41666666666667
52034, 2.075, -0.08, 0.41666666666667
52035, 2.075, -0.12, 0.41666666666667
52036, 2.075, -0.16, 0.41666666666667
52037, 2.1166666666667, -0.04, 0.41666666666667
52038, 2.1166666666667, -0.08, 0.41666666666667
52039, 2.1166666666667, -0.12, 0.41666666666667
52040, 2.1166666666667, -0.16, 0.41666666666667
52041, 2.1583333333333, -0.04, 0.41666666666667
52042, 2.1583333333333, -0.08, 0.41666666666667
52043, 2.1583333333333, -0.12, 0.41666666666667
52044, 2.1583333333333, -0.16, 0.41666666666667
52045, 1.2416666666667, -0.04, 0.45833333333333
52046, 1.2416666666667, -0.08, 0.45833333333333
52047, 1.2416666666667, -0.12, 0.45833333333333
52048, 1.2416666666667, -0.16, 0.45833333333333
52049, 1.2833333333333, -0.04, 0.45833333333333
52050, 1.2833333333333, -0.08, 0.45833333333333
52051, 1.2833333333333, -0.12, 0.45833333333333
52052, 1.2833333333333, -0.16, 0.45833333333333
52053, 1.325, -0.04, 0.45833333333333
52054, 1.325, -0.08, 0.45833333333333
52055, 1.325, -0.12, 0.45833333333333
52056, 1.325, -0.16, 0.45833333333333
52057, 1.3666666666667, -0.04, 0.45833333333333
52058, 1.3666666666667, -0.08, 0.45833333333333
52059, 1.3666666666667, -0.12, 0.45833333333333
52060, 1.3666666666667, -0.16, 0.45833333333333
52061, 1.4083333333333, -0.04, 0.45833333333333
52062, 1.4083333333333, -0.08, 0.45833333333333
52063, 1.4083333333333, -0.12, 0.45833333333333
52064, 1.4083333333333, -0.16, 0.45833333333333
52065, 1.45, -0.04, 0.45833333333333
52066, 1.45, -0.08, 0.45833333333333
52067, 1.45, -0.12, 0.45833333333333
52068, 1.45, -0.16, 0.45833333333333
52069, 1.4916666666667, -0.04, 0.45833333333333
52070, 1.4916666666667, -0.08, 0.45833333333333
52071, 1.4916666666667, -0.12, 0.45833333333333
52072, 1.4916666666667, -0.16, 0.45833333333333
52073, 1.5333333333333, -0.04, 0.45833333333333
52074, 1.5333333333333, -0.08, 0.45833333333333
52075, 1.5333333333333, -0.12, 0.45833333333333
52076, 1.5333333333333, -0.16, 0.45833333333333
52077, 1.575, -0.04, 0.45833333333333
52078, 1.575, -0.08, 0.45833333333333
52079, 1.575, -0.12, 0.45833333333333
52080, 1.575, -0.16, 0.45833333333333
52081, 1.6166666666667, -0.04, 0.45833333333333
52082, 1.6166666666667, -0.08, 0.45833333333333
52083, 1.6166666666667, -0.12, 0.45833333333333
52084, 1.6166666666667, -0.16, 0.45833333333333
52085, 1.6583333333333, -0.04, 0.45833333333333
52086, 1.6583333333333, -0.08, 0.45833333333333
52087, 1.6583333333333, -0.12, 0.45833333333333
52088, 1.6583333333333, -0.16, 0.45833333333333
52089, 1.7, -0.04, 0.45833333333333
52090, 1.7, -0.08, 0.45833333333333
52091, 1.7, -0.12, 0.45833333333333
52092, 1.7, -0.16, 0.45833333333333
52093, 1.7416666666667, -0.04, 0.45833333333333
52094, 1.7416666666667, -0.08, 0.45833333333333
52095, 1.7416666666667, -0.12, 0.45833333333333
52096, 1.7416666666667, -0.16, 0.45833333333333
52097, 1.7833333333333, -0.04, 0.45833333333333
52098, 1.7833333333333, -0.08, 0.45833333333333
52099, 1.7833333333333, -0.12, 0.45833333333333
52100, 1.7833333333333, -0.16, 0.45833333333333
52101, 1.825, -0.04, 0.45833333333333
52102, 1.825, -0.08, 0.45833333333333
52103, 1.825, -0.12, 0.45833333333333
52104, 1.825, -0.16, 0.45833333333333
52105, 1.8666666666667, -0.04, 0.45833333333333
52106, 1.8666666666667, -0.08, 0.45833333333333
52107, 1.8666666666667, -0.12, 0.45833333333333
52108, 1.8666666666667, -0.16, 0.45833333333333
52109, 1.9083333333333, -0.04, 0.45833333333333
52110, 1.9083333333333, -0.08, 0.45833333333333
52111, 1.9083333333333, -0.12, 0.45833333333333
52112, 1.9083333333333, -0.16, 0.45833333333333
52113, 1.95, -0.04, 0.45833333333333
52114, 1.95, -0.08, 0.45833333333333
52115, 1.95, -0.12, 0.45833333333333
52116, 1.95, -0.16, 0.45833333333333
52117, 1.9916666666667, -0.04, 0.45833333333333
52118, 1.9916666666667, -0.08, 0.45833333333333
52119, 1.9916666666667, -0.12, 0.45833333333333
52120, 1.9916666666667, -0.16, 0.45833333333333
52121, 2.0333333333333, -0.04, 0.45833333333333
52122, 2.0333333333333, -0.08, 0.45833333333333
52123, 2.0333333333333, -0.12, 0.45833333333333
52124, 2.0333333333333, -0.16, 0.45833333333333
52125, 2.075, -0.04, 0.45833333333333
52126, 2.075, -0.08, 0.45833333333333
52127, 2.075, -0.12, 0.45833333333333
52128, 2.075, -0.16, 0.45833333333333
52129, 2.1166666666667, -0.04, 0.45833333333333
52130, 2.1166666666667, -0.08, 0.45833333333333
52131, 2.1166666666667, -0.12, 0.45833333333333
52132, 2.1166666666667, -0.16, 0.45833333333333
52133, 2.1583333333333, -0.04, 0.45833333333333
52134, 2.1583333333333, -0.08, 0.45833333333333
52135, 2.1583333333333, -0.12, 0.45833333333333
52136, 2.1583333333333, -0.16, 0.45833333333333
52137, 1.2416666666667, -0.02, 0.041666666666667
52138, 1.2416666666667, -0.04, 0.020833333333333
52139, 1.2208333333333, -0.04, 0.041666666666667
52140, 1.2416666666667, -0.06, 0.041666666666667
52141, 1.2416666666667, -0.08, 0.020833333333333
52142, 1.2208333333333, -0.08, 0.041666666666667
52143, 1.2416666666667, -0.1, 0.041666666666667
52144, 1.2416666666667, -0.12, 0.020833333333333
52145, 1.2208333333333, -0.12, 0.041666666666667
52146, 1.2416666666667, -0.14, 0.041666666666667
52147, 1.2416666666667, -0.16, 0.020833333333333
52148, 1.2208333333333, -0.16, 0.041666666666667
52149, 1.2416666666667, -0.18, 0.041666666666667
52150, 1.2833333333333, -0.02, 0.041666666666667
52151, 1.2833333333333, -0.04, 0.020833333333333
52152, 1.2625, -0.04, 0.041666666666667
52153, 1.2833333333333, -0.06, 0.041666666666667
52154, 1.2833333333333, -0.08, 0.020833333333333
52155, 1.2625, -0.08, 0.041666666666667
52156, 1.2833333333333, -0.1, 0.041666666666667
52157, 1.2833333333333, -0.12, 0.020833333333333
52158, 1.2625, -0.12, 0.041666666666667
52159, 1.2833333333333, -0.14, 0.041666666666667
52160, 1.2833333333333, -0.16, 0.020833333333333
52161, 1.2625, -0.16, 0.041666666666667
52162, 1.2833333333333, -0.18, 0.041666666666667
52163, 1.325, -0.02, 0.041666666666667
52164, 1.325, -0.04, 0.020833333333333
52165, 1.3041666666667, -0.04, 0.041666666666667
52166, 1.325, -0.06, 0.041666666666667
52167, 1.325, -0.08, 0.020833333333333
52168, 1.3041666666667, -0.08, 0.041666666666667
52169, 1.325, -0.1, 0.041666666666667
52170, 1.325, -0.12, 0.020833333333333
52171, 1.3041666666667, -0.12, 0.041666666666667
52172, 1.325, -0.14, 0.041666666666667
52173, 1.325, -0.16, 0.020833333333333
52174, 1.3041666666667, -0.16, 0.041666666666667
52175, 1.325, -0.18, 0.041666666666667
52176, 1.3666666666667, -0.02, 0.041666666666667
52177, 1.3666666666667, -0.04, 0.020833333333333
52178, 1.3458333333333, -0.04, 0.041666666666667
52179, 1.3666666666667, -0.06, 0.041666666666667
52180, 1.3666666666667, -0.08, 0.020833333333333
52181, 1.3458333333333, -0.08, 0.041666666666667
52182, 1.3666666666667, -0.1, 0.041666666666667
52183, 1.3666666666667, -0.12, 0.020833333333333
52184, 1.3458333333333, -0.12, 0.041666666666667
52185, 1.3666666666667, -0.14, 0.041666666666667
52186, 1.3666666666667, -0.16, 0.020833333333333
52187, 1.3458333333333, -0.16, 0.041666666666667
52188, 1.3666666666667, -0.18, 0.041666666666667
52189, 1.4083333333333, -0.02, 0.041666666666667
52190, 1.4083333333333, -0.04, 0.020833333333333
52191, 1.3875, -0.04, 0.041666666666667
52192, 1.4083333333333, -0.06, 0.041666666666667
52193, 1.4083333333333, -0.08, 0.020833333333333
52194, 1.3875, -0.08, 0.041666666666667
52195, 1.4083333333333, -0.1, 0.041666666666667
52196, 1.4083333333333, -0.12, 0.020833333333333
52197, 1.3875, -0.12, 0.041666666666667
52198, 1.4083333333333, -0.14, 0.041666666666667
52199, 1.4083333333333, -0.16, 0.020833333333333
52200, 1.3875, -0.16, 0.041666666666667
52201, 1.4083333333333, -0.18, 0.041666666666667
52202, 1.45, -0.02, 0.041666666666667
52203, 1.45, -0.04, 0.020833333333333
52204, 1.4291666666667, -0.04, 0.041666666666667
52205, 1.45, -0.06, 0.041666666666667
52206, 1.45, -0.08, 0.020833333333333
52207, 1.4291666666667, -0.08, 0.041666666666667
52208, 1.45, -0.1, 0.041666666666667
52209, 1.45, -0.12, 0.020833333333333
52210, 1.4291666666667, -0.12, 0.041666666666667
52211, 1.45, -0.14, 0.041666666666667
52212, 1.45, -0.16, 0.020833333333333
52213, 1.4291666666667, -0.16, 0.041666666666667
52214, 1.45, -0.18, 0.041666666666667
52215, 1.4916666666667, -0.02, 0.041666666666667
52216, 1.4916666666667, -0.04, 0.020833333333333
52217, 1.4708333333333, -0.04, 0.041666666666667
52218, 1.4916666666667, -0.06, 0.041666666666667
52219, 1.4916666666667, -0.08, 0.020833333333333
52220, 1.4708333333333, -0.08, 0.041666666666667
52221, 1.4916666666667, -0.1, 0.041666666666667
52222, 1.4916666666667, -0.12, 0.020833333333333
52223, 1.4708333333333, -0.12, 0.041666666666667
52224, 1.4916666666667, -0.14, 0.041666666666667
52225, 1.4916666666667, -0.16, 0.020833333333333
52226, 1.4708333333333, -0.16, 0.041666666666667
52227, 1.4916666666667, -0.18, 0.041666666666667
52228, 1.5333333333333, -0.02, 0.041666666666667
52229, 1.5333333333333, -0.04, 0.020833333333333
52230, 1.5125, -0.04, 0.041666666666667
52231, 1.5333333333333, -0.06, 0.041666666666667
52232, 1.5333333333333, -0.08, 0.020833333333333
52233, 1.5125, -0.08, 0.041666666666667
52234, 1.5333333333333, -0.1, 0.041666666666667
52235, 1.5333333333333, -0.12, 0.020833333333333
52236, 1.5125, -0.12, 0.041666666666667
52237, 1.5333333333333, -0.14, 0.041666666666667
52238, 1.5333333333333, -0.16, 0.020833333333333
52239, 1.5125, -0.16, 0.041666666666667
52240, 1.5333333333333, -0.18, 0.041666666666667
52241, 1.575, -0.02, 0.041666666666667
52242, 1.575, -0.04, 0.020833333333333
52243, 1.5541666666667, -0.04, 0.041666666666667
52244, 1.575, -0.06, 0.041666666666667
52245, 1.575, -0.08, 0.020833333333333
52246, 1.5541666666667, -0.08, 0.041666666666667
52247, 1.575, -0.1, 0.041666666666667
52248, 1.575, -0.12, 0.020833333333333
52249, 1.5541666666667, -0.12, 0.041666666666667
52250, 1.575, -0.14, 0.041666666666667
52251, 1.575, -0.16, 0.020833333333333
52252, 1.5541666666667, -0.16, 0.041666666666667
52253, 1.575, -0.18, 0.041666666666667
52254, 1.6166666666667, -0.02, 0.041666666666667
52255, 1.6166666666667, -0.04, 0.020833333333333
52256, 1.5958333333333, -0.04, 0.041666666666667
52257, 1.6166666666667, -0.06, 0.041666666666667
52258, 1.6166666666667, -0.08, 0.020833333333333
52259, 1.5958333333333, -0.08, 0.041666666666667
52260, 1.6166666666667, -0.1, 0.041666666666667
52261, 1.6166666666667, -0.12, 0.020833333333333
52262, 1.5958333333333, -0.12, 0.041666666666667
52263, 1.6166666666667, -0.14, 0.041666666666667
52264, 1.6166666666667, -0.16, 0.020833333333333
52265, 1.5958333333333, -0.16, 0.041666666666667
52266, 1.6166666666667, -0.18, 0.041666666666667
52267, 1.6583333333333, -0.02, 0.041666666666667
52268, 1.6583333333333, -0.04, 0.020833333333333
52269, 1.6375, -0.04, 0.041666666666667
52270, 1.6583333333333, -0.06, 0.041666666666667
52271, 1.6583333333333, -0.08, 0.020833333333333
52272, 1.6375, -0.08, 0.041666666666667
52273, 1.6583333333333, -0.1, 0.041666666666667
52274, 1.6583333333333, -0.12, 0.020833333333333
52275, 1.6375, -0.12, 0.041666666666667
52276, 1.6583333333333, -0.14, 0.041666666666667
52277, 1.6583333333333, -0.16, 0.020833333333333
52278, 1.6375, -0.16, 0.041666666666667
52279, 1.6583333333333, -0.18, 0.041666666666667
52280, 1.7, -0.02, 0.041666666666667
52281, 1.7, -0.04, 0.020833333333333
52282, 1.6791666666667, -0.04, 0.041666666666667
52283, 1.7, -0.06, 0.041666666666667
52284, 1.7, -0.08, 0.020833333333333
52285, 1.6791666666667, -0.08, 0.041666666666667
52286, 1.7, -0.1, 0.041666666666667
52287, 1.7, -0.12, 0.020833333333333
52288, 1.6791666666667, -0.12, 0.041666666666667
52289, 1.7, -0.14, 0.041666666666667
52290, 1.7, -0.16, 0.020833333333333
52291, 1.6791666666667, -0.16, 0.041666666666667
52292, 1.7, -0.18, 0.041666666666667
52293, 1.7416666666667, -0.02, 0.041666666666667
52294, 1.7416666666667, -0.04, 0.020833333333333
52295, 1.7208333333333, -0.04, 0.041666666666667
52296, 1.7416666666667, -0.06, 0.041666666666667
52297, 1.7416666666667, -0.08, 0.020833333333333
52298, 1.7208333333333, -0.08, 0.041666666666667
52299, 1.7416666666667, -0.1, 0.041666666666667
52300, 1.7416666666667, -0.12, 0.020833333333333
52301, 1.7208333333333, -0.12, 0.041666666666667
52302, 1.7416666666667, -0.14, 0.041666666666667
52303, 1.7416666666667, -0.16, 0.020833333333333
52304, 1.7208333333333, -0.16, 0.041666666666667
52305, 1.7416666666667, -0.18, 0.041666666666667
52306, 1.7833333333333, -0.02, 0.041666666666667
52307, 1.7833333333333, -0.04, 0.020833333333333
52308, 1.7625, -0.04, 0.041666666666667
52309, 1.7833333333333, -0.06, 0.041666666666667
52310, 1.7833333333333, -0.08, 0.020833333333333
52311, 1.7625, -0.08, 0.041666666666667
52312, 1.7833333333333, -0.1, 0.041666666666667
52313, 1.7833333333333, -0.12, 0.020833333333333
52314, 1.7625, -0.12, 0.041666666666667
52315, 1.7833333333333, -0.14, 0.041666666666667
52316, 1.7833333333333, -0.16, 0.020833333333333
52317, 1.7625, -0.16, 0.041666666666667
52318, 1.7833333333333, -0.18, 0.041666666666667
52319, 1.825, -0.02, 0.041666666666667
52320, 1.825, -0.04, 0.020833333333333
52321, 1.8041666666667, -0.04, 0.041666666666667
52322, 1.825, -0.06, 0.041666666666667
52323, 1.825, -0.08, 0.020833333333333
52324, 1.8041666666667, -0.08, 0.041666666666667
52325, 1.825, -0.1, 0.041666666666667
52326, 1.825, -0.12, 0.020833333333333
52327, 1.8041666666667, -0.12, 0.041666666666667
52328, 1.825, -0.14, 0.041666666666667
52329, 1.825, -0.16, 0.020833333333333
52330, 1.8041666666667, -0.16, 0.041666666666667
52331, 1.825, -0.18, 0.041666666666667
52332, 1.8666666666667, -0.02, 0.041666666666667
52333, 1.8666666666667, -0.04, 0.020833333333333
52334, 1.8458333333333, -0.04, 0.041666666666667
52335, 1.8666666666667, -0.06, 0.041666666666667
52336, 1.8666666666667, -0.08, 0.020833333333333
52337, 1.8458333333333, -0.08, 0.041666666666667
52338, 1.8666666666667, -0.1, 0.041666666666667
52339, 1.8666666666667, -0.12, 0.020833333333333
52340, 1.8458333333333, -0.12, 0.041666666666667
52341, 1.8666666666667, -0.14, 0.041666666666667
52342, 1.8666666666667, -0.16, 0.020833333333333
52343, 1.8458333333333, -0.16, 0.041666666666667
52344, 1.8666666666667, -0.18, 0.041666666666667
52345, 1.9083333333333, -0.02, 0.041666666666667
52346, 1.9083333333333, -0.04, 0.020833333333333
52347, 1.8875, -0.04, 0.041666666666667
52348, 1.9083333333333, -0.06, 0.041666666666667
52349, 1.9083333333333, -0.08, 0.020833333333333
52350, 1.8875, -0.08, 0.041666666666667
52351, 1.9083333333333, -0.1, 0.041666666666667
52352, 1.9083333333333, -0.12, 0.020833333333333
52353, 1.8875, -0.12, 0.041666666666667
52354, 1.9083333333333, -0.14, 0.041666666666667
52355, 1.9083333333333, -0.16, 0.020833333333333
52356, 1.8875, -0.16, 0.041666666666667
52357, 1.9083333333333, -0.18, 0.041666666666667
52358, 1.95, -0.02, 0.041666666666667
52359, 1.95, -0.04, 0.020833333333333
52360, 1.9291666666667, -0.04, 0.041666666666667
52361, 1.95, -0.06, 0.041666666666667
52362, 1.95, -0.08, 0.020833333333333
52363, 1.9291666666667, -0.08, 0.041666666666667
52364, 1.95, -0.1, 0.041666666666667
52365, 1.95, -0.12, 0.020833333333333
52366, 1.9291666666667, -0.12, 0.041666666666667
52367, 1.95, -0.14, 0.041666666666667
52368, 1.95, -0.16, 0.020833333333333
52369, 1.9291666666667, -0.16, 0.041666666666667
52370, 1.95, -0.18, 0.041666666666667
52371, 1.9916666666667, -0.02, 0.041666666666667
52372, 1.9916666666667, -0.04, 0.020833333333333
52373, 1.9708333333333, -0.04, 0.041666666666667
52374, 1.9916666666667, -0.06, 0.041666666666667
52375, 1.9916666666667, -0.08, 0.020833333333333
52376, 1.9708333333333, -0.08, 0.041666666666667
52377, 1.9916666666667, -0.1, 0.041666666666667
52378, 1.9916666666667, -0.12, 0.020833333333333
52379, 1.9708333333333, -0.12, 0.041666666666667
52380, 1.9916666666667, -0.14, 0.041666666666667
52381, 1.9916666666667, -0.16, 0.020833333333333
52382, 1.9708333333333, -0.16, 0.041666666666667
52383, 1.9916666666667, -0.18, 0.041666666666667
52384, 2.0333333333333, -0.02, 0.041666666666667
52385, 2.0333333333333, -0.04, 0.020833333333333
52386, 2.0125, -0.04, 0.041666666666667
52387, 2.0333333333333, -0.06, 0.041666666666667
52388, 2.0333333333333, -0.08, 0.020833333333333
52389, 2.0125, -0.08, 0.041666666666667
52390, 2.0333333333333, -0.1, 0.041666666666667
52391, 2.0333333333333, -0.12, 0.020833333333333
52392, 2.0125, -0.12, 0.041666666666667
52393, 2.0333333333333, -0.14, 0.041666666666667
52394, 2.0333333333333, -0.16, 0.020833333333333
52395, 2.0125, -0.16, 0.041666666666667
52396, 2.0333333333333, -0.18, 0.041666666666667
52397, 2.075, -0.02, 0.041666666666667
52398, 2.075, -0.04, 0.020833333333333
52399, 2.0541666666667, -0.04, 0.041666666666667
52400, 2.075, -0.06, 0.041666666666667
52401, 2.075, -0.08, 0.020833333333333
52402, 2.0541666666667, -0.08, 0.041666666666667
52403, 2.075, -0.1, 0.041666666666667
52404, 2.075, -0.12, 0.020833333333333
52405, 2.0541666666667, -0.12, 0.041666666666667
52406, 2.075, -0.14, 0.041666666666667
52407, 2.075, -0.16, 0.020833333333333
52408, 2.0541666666667, -0.16, 0.041666666666667
52409, 2.075, -0.18, 0.041666666666667
52410, 2.1166666666667, -0.02, 0.041666666666667
52411, 2.1166666666667, -0.04, 0.020833333333333
52412, 2.0958333333333, -0.04, 0.041666666666667
52413, 2.1166666666667, -0.06, 0.041666666666667
52414, 2.1166666666667, -0.08, 0.020833333333333
52415, 2.0958333333333, -0.08, 0.041666666666667
52416, 2.1166666666667, -0.1, 0.041666666666667
52417, 2.1166666666667, -0.12, 0.020833333333333
52418, 2.0958333333333, -0.12, 0.041666666666667
52419, 2.1166666666667, -0.14, 0.041666666666667
52420, 2.1166666666667, -0.16, 0.020833333333333
52421, 2.0958333333333, -0.16, 0.041666666666667
52422, 2.1166666666667, -0.18, 0.041666666666667
52423, 2.1583333333333, -0.02, 0.041666666666667
52424, 2.1583333333333, -0.04, 0.020833333333333
52425, 2.1375, -0.04, 0.041666666666667
52426, 2.1583333333333, -0.06, 0.041666666666667
52427, 2.1583333333333, -0.08, 0.020833333333333
52428, 2.1375, -0.08, 0.041666666666667
52429, 2.1583333333333, -0.1, 0.041666666666667
52430, 2.1583333333333, -0.12, 0.020833333333333
52431, 2.1375, -0.12, 0.041666666666667
52432, 2.1583333333333, -0.14, 0.041666666666667
52433, 2.1583333333333, -0.16, 0.020833333333333
52434, 2.1375, -0.16, 0.041666666666667
52435, 2.1583333333333, -0.18, 0.041666666666667
52436, 2.1791666666667, -0.04, 0.041666666666667
52437, 2.1791666666667, -0.08, 0.041666666666667
52438, 2.1791666666667, -0.12, 0.041666666666667
52439, 2.1791666666667, -0.16, 0.041666666666667
52440, 1.2416666666667, -0.02, 0.083333333333333
52441, 1.2416666666667, -0.04, 0.0625
52442, 1.2208333333333, -0.04, 0.083333333333333
52443, 1.2416666666667, -0.06, 0.083333333333333
52444, 1.2416666666667, -0.08, 0.0625
52445, 1.2208333333333, -0.08, 0.083333333333333
52446, 1.2416666666667, -0.1, 0.083333333333333
52447, 1.2416666666667, -0.12, 0.0625
52448, 1.2208333333333, -0.12, 0.083333333333333
52449, 1.2416666666667, -0.14, 0.083333333333333
52450, 1.2416666666667, -0.16, 0.0625
52451, 1.2208333333333, -0.16, 0.083333333333333
52452, 1.2416666666667, -0.18, 0.083333333333333
52453, 1.2833333333333, -0.02, 0.083333333333333
52454, 1.2833333333333, -0.04, 0.0625
52455, 1.2625, -0.04, 0.083333333333333
52456, 1.2833333333333, -0.06, 0.083333333333333
52457, 1.2833333333333, -0.08, 0.0625
52458, 1.2625, -0.08, 0.083333333333333
52459, 1.2833333333333, -0.1, 0.083333333333333
52460, 1.2833333333333, -0.12, 0.0625
52461, 1.2625, -0.12, 0.083333333333333
52462, 1.2833333333333, -0.14, 0.083333333333333
52463, 1.2833333333333, -0.16, 0.0625
52464, 1.2625, -0.16, 0.083333333333333
52465, 1.2833333333333, -0.18, 0.083333333333333
52466, 1.325, -0.02, 0.083333333333333
52467, 1.325, -0.04, 0.0625
52468, 1.3041666666667, -0.04, 0.083333333333333
52469, 1.325, -0.06, 0.083333333333333
52470, 1.325, -0.08, 0.0625
52471, 1.3041666666667, -0.08, 0.083333333333333
52472, 1.325, -0.1, 0.083333333333333
52473, 1.325, -0.12, 0.0625
52474, 1.3041666666667, -0.12, 0.083333333333333
52475, 1.325, -0.14, 0.083333333333333
52476, 1.325, -0.16, 0.0625
52477, 1.3041666666667, -0.16, 0.083333333333333
52478, 1.325, -0.18, 0.083333333333333
52479, 1.3666666666667, -0.02, 0.083333333333333
52480, 1.3666666666667, -0.04, 0.0625
52481, 1.3458333333333, -0.04, 0.083333333333333
52482, 1.3666666666667, -0.06, 0.083333333333333
52483, 1.3666666666667, -0.08, 0.0625
52484, 1.3458333333333, -0.08, 0.083333333333333
52485, 1.3666666666667, -0.1, 0.083333333333333
52486, 1.3666666666667, -0.12, 0.0625
52487, 1.3458333333333, -0.12, 0.083333333333333
52488, 1.3666666666667, -0.14, 0.083333333333333
52489, 1.3666666666667, -0.16, 0.0625
52490, 1.3458333333333, -0.16, 0.083333333333333
52491, 1.3666666666667, -0.18, 0.083333333333333
52492, 1.4083333333333, -0.02, 0.083333333333333
52493, 1.4083333333333, -0.04, 0.0625
52494, 1.3875, -0.04, 0.083333333333333
52495, 1.4083333333333, -0.06, 0.083333333333333
52496, 1.4083333333333, -0.08, 0.0625
52497, 1.3875, -0.08, 0.083333333333333
52498, 1.4083333333333, -0.1, 0.083333333333333
52499, 1.4083333333333, -0.12, 0.0625
52500, 1.3875, -0.12, 0.083333333333333
52501, 1.4083333333333, -0.14, 0.083333333333333
52502, 1.4083333333333, -0.16, 0.0625
52503, 1.3875, -0.16, 0.083333333333333
52504, 1.4083333333333, -0.18, 0.083333333333333
52505, 1.45, -0.02, 0.083333333333333
52506, 1.45, -0.04, 0.0625
52507, 1.4291666666667, -0.04, 0.083333333333333
52508, 1.45, -0.06, 0.083333333333333
52509, 1.45, -0.08, 0.0625
52510, 1.4291666666667, -0.08, 0.083333333333333
52511, 1.45, -0.1, 0.083333333333333
52512, 1.45, -0.12, 0.0625
52513, 1.4291666666667, -0.12, 0.083333333333333
52514, 1.45, -0.14, 0.083333333333333
52515, 1.45, -0.16, 0.0625
52516, 1.4291666666667, -0.16, 0.083333333333333
52517, 1.45, -0.18, 0.083333333333333
52518, 1.4916666666667, -0.02, 0.083333333333333
52519, 1.4916666666667, -0.04, 0.0625
52520, 1.4708333333333, -0.04, 0.083333333333333
52521, 1.4916666666667, -0.06, 0.083333333333333
52522, 1.4916666666667, -0.08, 0.0625
52523, 1.4708333333333, -0.08, 0.083333333333333
52524, 1.4916666666667, -0.1, 0.083333333333333
52525, 1.4916666666667, -0.12, 0.0625
52526, 1.4708333333333, -0.12, 0.083333333333333
52527, 1.4916666666667, -0.14, 0.083333333333333
52528, 1.4916666666667, -0.16, 0.0625
52529, 1.4708333333333, -0.16, 0.083333333333333
52530, 1.4916666666667, -0.18, 0.083333333333333
52531, 1.5333333333333, -0.02, 0.083333333333333
52532, 1.5333333333333, -0.04, 0.0625
52533, 1.5125, -0.04, 0.083333333333333
52534, 1.5333333333333, -0.06, 0.083333333333333
52535, 1.5333333333333, -0.08, 0.0625
52536, 1.5125, -0.08, 0.083333333333333
52537, 1.5333333333333, -0.1, 0.083333333333333
52538, 1.5333333333333, -0.12, 0.0625
52539, 1.5125, -0.12, 0.083333333333333
52540, 1.5333333333333, -0.14, 0.083333333333333
52541, 1.5333333333333, -0.16, 0.0625
52542, 1.5125, -0.16, 0.083333333333333
52543, 1.5333333333333, -0.18, 0.083333333333333
52544, 1.575, -0.02, 0.083333333333333
52545, 1.575, -0.04, 0.0625
52546, 1.5541666666667, -0.04, 0.083333333333333
52547, 1.575, -0.06, 0.083333333333333
52548, 1.575, -0.08, 0.0625
52549, 1.5541666666667, -0.08, 0.083333333333333
52550, 1.575, -0.1, 0.083333333333333
52551, 1.575, -0.12, 0.0625
52552, 1.5541666666667, -0.12, 0.083333333333333
52553, 1.575, -0.14, 0.083333333333333
52554, 1.575, -0.16, 0.0625
52555, 1.5541666666667, -0.16, 0.083333333333333
52556, 1.575, -0.18, 0.083333333333333
52557, 1.6166666666667, -0.02, 0.083333333333333
52558, 1.6166666666667, -0.04, 0.0625
52559, 1.5958333333333, -0.04, 0.083333333333333
52560, 1.6166666666667, -0.06, 0.083333333333333
52561, 1.6166666666667, -0.08, 0.0625
52562, 1.5958333333333, -0.08, 0.083333333333333
52563, 1.6166666666667, -0.1, 0.083333333333333
52564, 1.6166666666667, -0.12, 0.0625
52565, 1.5958333333333, -0.12, 0.083333333333333
52566, 1.6166666666667, -0.14, 0.083333333333333
52567, 1.6166666666667, -0.16, 0.0625
52568, 1.5958333333333, -0.16, 0.083333333333333
52569, 1.6166666666667, -0.18, 0.083333333333333
52570, 1.6583333333333, -0.02, 0.083333333333333
52571, 1.6583333333333, -0.04, 0.0625
52572, 1.6375, -0.04, 0.083333333333333
52573, 1.6583333333333, -0.06, 0.083333333333333
52574, 1.6583333333333, -0.08, 0.0625
52575, 1.6375, -0.08, 0.083333333333333
52576, 1.6583333333333, -0.1, 0.083333333333333
52577, 1.6583333333333, -0.12, 0.0625
52578, 1.6375, -0.12, 0.083333333333333
52579, 1.6583333333333, -0.14, 0.083333333333333
52580, 1.6583333333333, -0.16, 0.0625
52581, 1.6375, -0.16, 0.083333333333333
52582, 1.6583333333333, -0.18, 0.083333333333333
52583, 1.7, -0.02, 0.083333333333333
52584, 1.7, -0.04, 0.0625
52585, 1.6791666666667, -0.04, 0.083333333333333
52586, 1.7, -0.06, 0.083333333333333
52587, 1.7, -0.08, 0.0625
52588, 1.6791666666667, -0.08, 0.083333333333333
52589, 1.7, -0.1, 0.083333333333333
52590, 1.7, -0.12, 0.0625
52591, 1.6791666666667, -0.12, 0.083333333333333
52592, 1.7, -0.14, 0.083333333333333
52593, 1.7, -0.16, 0.0625
52594, 1.6791666666667, -0.16, 0.083333333333333
52595, 1.7, -0.18, 0.083333333333333
52596, 1.7416666666667, -0.02, 0.083333333333333
52597, 1.7416666666667, -0.04, 0.0625
52598, 1.7208333333333, -0.04, 0.083333333333333
52599, 1.7416666666667, -0.06, 0.083333333333333
52600, 1.7416666666667, -0.08, 0.0625
52601, 1.7208333333333, -0.08, 0.083333333333333
52602, 1.7416666666667, -0.1, 0.083333333333333
52603, 1.7416666666667, -0.12, 0.0625
52604, 1.7208333333333, -0.12, 0.083333333333333
52605, 1.7416666666667, -0.14, 0.083333333333333
52606, 1.7416666666667, -0.16, 0.0625
52607, 1.7208333333333, -0.16, 0.083333333333333
52608, 1.7416666666667, -0.18, 0.083333333333333
52609, 1.7833333333333, -0.02, 0.083333333333333
52610, 1.7833333333333, -0.04, 0.0625
52611, 1.7625, -0.04, 0.083333333333333
52612, 1.7833333333333, -0.06, 0.083333333333333
52613, 1.7833333333333, -0.08, 0.0625
52614, 1.7625, -0.08, 0.083333333333333
52615, 1.7833333333333, -0.1, 0.083333333333333
52616, 1.7833333333333, -0.12, 0.0625
52617, 1.7625, -0.12, 0.083333333333333
52618, 1.7833333333333, -0.14, 0.083333333333333
52619, 1.7833333333333, -0.16, 0.0625
52620, 1.7625, -0.16, 0.083333333333333
52621, 1.7833333333333, -0.18, 0.083333333333333
52622, 1.825, -0.02, 0.083333333333333
52623, 1.825, -0.04, 0.0625
52624, 1.8041666666667, -0.04, 0.083333333333333
52625, 1.825, -0.06, 0.083333333333333
52626, 1.825, -0.08, 0.0625
52627, 1.8041666666667, -0.08, 0.083333333333333
52628, 1.825, -0.1, 0.083333333333333
52629, 1.825, -0.12, 0.0625
52630, 1.8041666666667, -0.12, 0.083333333333333
52631, 1.825, -0.14, 0.083333333333333
52632, 1.825, -0.16, 0.0625
52633, 1.8041666666667, -0.16, 0.083333333333333
52634, 1.825, -0.18, 0.083333333333333
52635, 1.8666666666667, -0.02, 0.083333333333333
52636, 1.8666666666667, -0.04, 0.0625
52637, 1.8458333333333, -0.04, 0.083333333333333
52638, 1.8666666666667, -0.06, 0.083333333333333
52639, 1.8666666666667, -0.08, 0.0625
52640, 1.8458333333333, -0.08, 0.083333333333333
52641, 1.8666666666667, -0.1, 0.083333333333333
52642, 1.8666666666667, -0.12, 0.0625
52643, 1.8458333333333, -0.12, 0.083333333333333
52644, 1.8666666666667, -0.14, 0.083333333333333
52645, 1.8666666666667, -0.16, 0.0625
52646, 1.8458333333333, -0.16, 0.083333333333333
52647, 1.8666666666667, -0.18, 0.083333333333333
52648, 1.9083333333333, -0.02, 0.083333333333333
52649, 1.9083333333333, -0.04, 0.0625
52650, 1.8875, -0.04, 0.083333333333333
52651, 1.9083333333333, -0.06, 0.083333333333333
52652, 1.9083333333333, -0.08, 0.0625
52653, 1.8875, -0.08, 0.083333333333333
52654, 1.9083333333333, -0.1, 0.083333333333333
52655, 1.9083333333333, -0.12, 0.0625
52656, 1.8875, -0.12, 0.083333333333333
52657, 1.9083333333333, -0.14, 0.083333333333333
52658, 1.9083333333333, -0.16, 0.0625
52659, 1.8875, -0.16, 0.083333333333333
52660, 1.9083333333333, -0.18, 0.083333333333333
52661, 1.95, -0.02, 0.083333333333333
52662, 1.95, -0.04, 0.0625
52663, 1.9291666666667, -0.04, 0.083333333333333
52664, 1.95, -0.06, 0.083333333333333
52665, 1.95, -0.08, 0.0625
52666, 1.9291666666667, -0.08, 0.083333333333333
52667, 1.95, -0.1, 0.083333333333333
52668, 1.95, -0.12, 0.0625
52669, 1.9291666666667, -0.12, 0.083333333333333
52670, 1.95, -0.14, 0.083333333333333
52671, 1.95, -0.16, 0.0625
52672, 1.9291666666667, -0.16, 0.083333333333333
52673, 1.95, -0.18, 0.083333333333333
52674, 1.9916666666667, -0.02, 0.083333333333333
52675, 1.9916666666667, -0.04, 0.0625
52676, 1.9708333333333, -0.04, 0.083333333333333
52677, 1.9916666666667, -0.06, 0.083333333333333
52678, 1.9916666666667, -0.08, 0.0625
52679, 1.9708333333333, -0.08, 0.083333333333333
52680, 1.9916666666667, -0.1, 0.083333333333333
52681, 1.9916666666667, -0.12, 0.0625
52682, 1.9708333333333, -0.12, 0.083333333333333
52683, 1.9916666666667, -0.14, 0.083333333333333
52684, 1.9916666666667, -0.16, 0.0625
52685, 1.9708333333333, -0.16, 0.083333333333333
52686, 1.9916666666667, -0.18, 0.083333333333333
52687, 2.0333333333333, -0.02, 0.083333333333333
52688, 2.0333333333333, -0.04, 0.0625
52689, 2.0125, -0.04, 0.083333333333333
52690, 2.0333333333333, -0.06, 0.083333333333333
52691, 2.0333333333333, -0.08, 0.0625
52692, 2.0125, -0.08, 0.083333333333333
52693, 2.0333333333333, -0.1, 0.083333333333333
52694, 2.0333333333333, -0.12, 0.0625
52695, 2.0125, -0.12, 0.083333333333333
52696, 2.0333333333333, -0.14, 0.083333333333333
52697, 2.0333333333333, -0.16, 0.0625
52698, 2.0125, -0.16, 0.083333333333333
52699, 2.0333333333333, -0.18, 0.083333333333333
52700, 2.075, -0.02, 0.083333333333333
52701, 2.075, -0.04, 0.0625
52702, 2.0541666666667, -0.04, 0.083333333333333
52703, 2.075, -0.06, 0.083333333333333
52704, 2.075, -0.08, 0.0625
52705, 2.0541666666667, -0.08, 0.083333333333333
52706, 2.075, -0.1, 0.083333333333333
52707, 2.075, -0.12, 0.0625
52708, 2.0541666666667, -0.12, 0.083333333333333
52709, 2.075, -0.14, 0.083333333333333
52710, 2.075, -0.16, 0.0625
52711, 2.0541666666667, -0.16, 0.083333333333333
52712, 2.075, -0.18, 0.083333333333333
52713, 2.1166666666667, -0.02, 0.083333333333333
52714, 2.1166666666667, -0.04, 0.0625
52715, 2.0958333333333, -0.04, 0.083333333333333
52716, 2.1166666666667, -0.06, 0.083333333333333
52717, 2.1166666666667, -0.08, 0.0625
52718, 2.0958333333333, -0.08, 0.083333333333333
52719, 2.1166666666667, -0.1, 0.083333333333333
52720, 2.1166666666667, -0.12, 0.0625
52721, 2.0958333333333, -0.12, 0.083333333333333
52722, 2.1166666666667, -0.14, 0.083333333333333
52723, 2.1166666666667, -0.16, 0.0625
52724, 2.0958333333333, -0.16, 0.083333333333333
52725, 2.1166666666667, -0.18, 0.083333333333333
52726, 2.1583333333333, -0.02, 0.083333333333333
52727, 2.1583333333333, -0.04, 0.0625
52728, 2.1375, -0.04, 0.083333333333333
52729, 2.1583333333333, -0.06, 0.083333333333333
52730, 2.1583333333333, -0.08, 0.0625
52731, 2.1375, -0.08, 0.083333333333333
52732, 2.1583333333333, -0.1, 0.083333333333333
52733, 2.1583333333333, -0.12, 0.0625
52734, 2.1375, -0.12, 0.083333333333333
52735, 2.1583333333333, -0.14, 0.083333333333333
52736, 2.1583333333333, -0.16, 0.0625
52737, 2.1375, -0.16, 0.083333333333333
52738, 2.1583333333333, -0.18, 0.083333333333333
52739, 2.1791666666667, -0.04, 0.083333333333333
52740, 2.1791666666667, -0.08, 0.083333333333333
52741, 2.1791666666667, -0.12, 0.083333333333333
52742, 2.1791666666667, -0.16, 0.083333333333333
52743, 1.2416666666667, -0.02, 0.125
52744, 1.2416666666667, -0.04, 0.10416666666667
52745, 1.2208333333333, -0.04, 0.125
52746, 1.2416666666667, -0.06, 0.125
52747, 1.2416666666667, -0.08, 0.10416666666667
52748, 1.2208333333333, -0.08, 0.125
52749, 1.2416666666667, -0.1, 0.125
52750, 1.2416666666667, -0.12, 0.10416666666667
52751, 1.2208333333333, -0.12, 0.125
52752, 1.2416666666667, -0.14, 0.125
52753, 1.2416666666667, -0.16, 0.10416666666667
52754, 1.2208333333333, -0.16, 0.125
52755, 1.2416666666667, -0.18, 0.125
52756, 1.2833333333333, -0.02, 0.125
52757, 1.2833333333333, -0.04, 0.10416666666667
52758, 1.2625, -0.04, 0.125
52759, 1.2833333333333, -0.06, 0.125
52760, 1.2833333333333, -0.08, 0.10416666666667
52761, 1.2625, -0.08, 0.125
52762, 1.2833333333333, -0.1, 0.125
52763, 1.2833333333333, -0.12, 0.10416666666667
52764, 1.2625, -0.12, 0.125
52765, 1.2833333333333, -0.14, 0.125
52766, 1.2833333333333, -0.16, 0.10416666666667
52767, 1.2625, -0.16, 0.125
52768, 1.2833333333333, -0.18, 0.125
52769, 1.325, -0.02, 0.125
52770, 1.325, -0.04, 0.10416666666667
52771, 1.3041666666667, -0.04, 0.125
52772, 1.325, -0.06, 0.125
52773, 1.325, -0.08, 0.10416666666667
52774, 1.3041666666667, -0.08, 0.125
52775, 1.325, -0.1, 0.125
52776, 1.325, -0.12, 0.10416666666667
52777, 1.3041666666667, -0.12, 0.125
52778, 1.325, -0.14, 0.125
52779, 1.325, -0.16, 0.10416666666667
52780, 1.3041666666667, -0.16, 0.125
52781, 1.325, -0.18, 0.125
52782, 1.3666666666667, -0.02, 0.125
52783, 1.3666666666667, -0.04, 0.10416666666667
52784, 1.3458333333333, -0.04, 0.125
52785, 1.3666666666667, -0.06, 0.125
52786, 1.3666666666667, -0.08, 0.10416666666667
52787, 1.3458333333333, -0.08, 0.125
52788, 1.3666666666667, -0.1, 0.125
52789, 1.3666666666667, -0.12, 0.10416666666667
52790, 1.3458333333333, -0.12, 0.125
52791, 1.3666666666667, -0.14, 0.125
52792, 1.3666666666667, -0.16, 0.10416666666667
52793, 1.3458333333333, -0.16, 0.125
52794, 1.3666666666667, -0.18, 0.125
52795, 1.4083333333333, -0.02, 0.125
52796, 1.4083333333333, -0.04, 0.10416666666667
52797, 1.3875, -0.04, 0.125
52798, 1.4083333333333, -0.06, 0.125
52799, 1.4083333333333, -0.08, 0.10416666666667
52800, 1.3875, -0.08, 0.125
52801, 1.4083333333333, -0.1, 0.125
52802, 1.4083333333333, -0.12, 0.10416666666667
52803, 1.3875, -0.12, 0.125
52804, 1.4083333333333, -0.14, 0.125
52805, 1.4083333333333, -0.16, 0.10416666666667
52806, 1.3875, -0.16, 0.125
52807, 1.4083333333333, -0.18, 0.125
52808, 1.45, -0.02, 0.125
52809, 1.45, -0.04, 0.10416666666667
52810, 1.4291666666667, -0.04, 0.125
52811, 1.45, -0.06, 0.125
52812, 1.45, -0.08, 0.10416666666667
52813, 1.4291666666667, -0.08, 0.125
52814, 1.45, -0.1, 0.125
52815, 1.45, -0.12, 0.10416666666667
52816, 1.4291666666667, -0.12, 0.125
52817, 1.45, -0.14, 0.125
52818, 1.45, -0.16, 0.10416666666667
52819, 1.4291666666667, -0.16, 0.125
52820, 1.45, -0.18, 0.125
52821, 1.4916666666667, -0.02, 0.125
52822, 1.4916666666667, -0.04, 0.10416666666667
52823, 1.4708333333333, -0.04, 0.125
52824, 1.4916666666667, -0.06, 0.125
52825, 1.4916666666667, -0.08, 0.10416666666667
52826, 1.4708333333333, -0.08, 0.125
52827, 1.4916666666667, -0.1, 0.125
52828, 1.4916666666667, -0.12, 0.10416666666667
52829, 1.4708333333333, -0.12, 0.125
52830, 1.4916666666667, -0.14, 0.125
52831, 1.4916666666667, -0.16, 0.10416666666667
52832, 1.4708333333333, -0.16, 0.125
52833, 1.4916666666667, -0.18, 0.125
52834, 1.5333333333333, -0.02, 0.125
52835, 1.5333333333333, -0.04, 0.10416666666667
52836, 1.5125, -0.04, 0.125
52837, 1.5333333333333, -0.06, 0.125
52838, 1.5333333333333, -0.08, 0.10416666666667
52839, 1.5125, -0.08, 0.125
52840, 1.5333333333333, -0.1, 0.125
52841, 1.5333333333333, -0.12, 0.10416666666667
52842, 1.5125, -0.12, 0.125
52843, 1.5333333333333, -0.14, 0.125
52844, 1.5333333333333, -0.16, 0.10416666666667
52845, 1.5125, -0.16, 0.125
52846, 1.5333333333333, -0.18, 0.125
52847, 1.575, -0.02, 0.125
52848, 1.575, -0.04, 0.10416666666667
52849, 1.5541666666667, -0.04, 0.125
52850, 1.575, -0.06, 0.125
52851, 1.575, -0.08, 0.10416666666667
52852, 1.5541666666667, -0.08, 0.125
52853, 1.575, -0.1, 0.125
52854, 1.575, -0.12, 0.10416666666667
52855, 1.5541666666667, -0.12, 0.125
52856, 1.575, -0.14, 0.125
52857, 1.575, -0.16, 0.10416666666667
52858, 1.5541666666667, -0.16, 0.125
52859, 1.575, -0.18, 0.125
52860, 1.6166666666667, -0.02, 0.125
52861, 1.6166666666667, -0.04, 0.10416666666667
52862, 1.5958333333333, -0.04, 0.125
52863, 1.6166666666667, -0.06, 0.125
52864, 1.6166666666667, -0.08, 0.10416666666667
52865, 1.5958333333333, -0.08, 0.125
52866, 1.6166666666667, -0.1, 0.125
52867, 1.6166666666667, -0.12, 0.10416666666667
52868, 1.5958333333333, -0.12, 0.125
52869, 1.6166666666667, -0.14, 0.125
52870, 1.6166666666667, -0.16, 0.10416666666667
52871, 1.5958333333333, -0.16, 0.125
52872, 1.6166666666667, -0.18, 0.125
52873, 1.6583333333333, -0.02, 0.125
52874, 1.6583333333333, -0.04, 0.10416666666667
52875, 1.6375, -0.04, 0.125
52876, 1.6583333333333, -0.06, 0.125
52877, 1.6583333333333, -0.08, 0.10416666666667
52878, 1.6375, -0.08, 0.125
52879, 1.6583333333333, -0.1, 0.125
52880, 1.6583333333333, -0.12, 0.10416666666667
52881, 1.6375, -0.12, 0.125
52882, 1.6583333333333, -0.14, 0.125
52883, 1.6583333333333, -0.16, 0.10416666666667
52884, 1.6375, -0.16, 0.125
52885, 1.6583333333333, -0.18, 0.125
52886, 1.7, -0.02, 0.125
52887, 1.7, -0.04, 0.10416666666667
52888, 1.6791666666667, -0.04, 0.125
52889, 1.7, -0.06, 0.125
52890, 1.7, -0.08, 0.10416666666667
52891, 1.6791666666667, -0.08, 0.125
52892, 1.7, -0.1, 0.125
52893, 1.7, -0.12, 0.10416666666667
52894, 1.6791666666667, -0.12, 0.125
52895, 1.7, -0.14, 0.125
52896, 1.7, -0.16, 0.10416666666667
52897, 1.6791666666667, -0.16, 0.125
52898, 1.7, -0.18, 0.125
52899, 1.7416666666667, -0.02, 0.125
52900, 1.7416666666667, -0.04, 0.10416666666667
52901, 1.7208333333333, -0.04, 0.125
52902, 1.7416666666667, -0.06, 0.125
52903, 1.7416666666667, -0.08, 0.10416666666667
52904, 1.7208333333333, -0.08, 0.125
52905, 1.7416666666667, -0.1, 0.125
52906, 1.7416666666667, -0.12, 0.10416666666667
52907, 1.7208333333333, -0.12, 0.125
52908, 1.7416666666667, -0.14, 0.125
52909, 1.7416666666667, -0.16, 0.10416666666667
52910, 1.7208333333333, -0.16, 0.125
52911, 1.7416666666667, -0.18, 0.125
52912, 1.7833333333333, -0.02, 0.125
52913, 1.7833333333333, -0.04, 0.10416666666667
52914, 1.7625, -0.04, 0.125
52915, 1.7833333333333, -0.06, 0.125
52916, 1.7833333333333, -0.08, 0.10416666666667
52917, 1.7625, -0.08, 0.125
52918, 1.7833333333333, -0.1, 0.125
52919, 1.7833333333333, -0.12, 0.10416666666667
52920, 1.7625, -0.12, 0.125
52921, 1.7833333333333, -0.14, 0.125
52922, 1.7833333333333, -0.16, 0.10416666666667
52923, 1.7625, -0.16, 0.125
52924, 1.7833333333333, -0.18, 0.125
52925, 1.825, -0.02, 0.125
52926, 1.825, -0.04, 0.10416666666667
52927, 1.8041666666667, -0.04, 0.125
52928, 1.825, -0.06, 0.125
52929, 1.825, -0.08, 0.10416666666667
52930, 1.8041666666667, -0.08, 0.125
52931, 1.825, -0.1, 0.125
52932, 1.825, -0.12, 0.10416666666667
52933, 1.8041666666667, -0.12, 0.125
52934, 1.825, -0.14, 0.125
52935, 1.825, -0.16, 0.10416666666667
52936, 1.8041666666667, -0.16, 0.125
52937, 1.825, -0.18, 0.125
52938, 1.8666666666667, -0.02, 0.125
52939, 1.8666666666667, -0.04, 0.10416666666667
52940, 1.8458333333333, -0.04, 0.125
52941, 1.8666666666667, -0.06, 0.125
52942, 1.8666666666667, -0.08, 0.10416666666667
52943, 1.8458333333333, -0.08, 0.125
52944, 1.8666666666667, -0.1, 0.125
52945, 1.8666666666667, -0.12, 0.10416666666667
52946, 1.8458333333333, -0.12, 0.125
52947, 1.8666666666667, -0.14, 0.125
52948, 1.8666666666667, -0.16, 0.10416666666667
52949, 1.8458333333333, -0.16, 0.125
52950, 1.8666666666667, -0.18, 0.125
52951, 1.9083333333333, -0.02, 0.125
52952, 1.9083333333333, -0.04, 0.10416666666667
52953, 1.8875, -0.04, 0.125
52954, 1.9083333333333, -0.06, 0.125
52955, 1.9083333333333, -0.08, 0.10416666666667
52956, 1.8875, -0.08, 0.125
52957, 1.9083333333333, -0.1, 0.125
52958, 1.9083333333333, -0.12, 0.10416666666667
52959, 1.8875, -0.12, 0.125
52960, 1.9083333333333, -0.14, 0.125
52961, 1.9083333333333, -0.16, 0.10416666666667
52962, 1.8875, -0.16, 0.125
52963, 1.9083333333333, -0.18, 0.125
52964, 1.95, -0.02, 0.125
52965, 1.95, -0.04, 0.10416666666667
52966, 1.9291666666667, -0.04, 0.125
52967, 1.95, -0.06, 0.125
52968, 1.95, -0.08, 0.10416666666667
52969, 1.9291666666667, -0.08, 0.125
52970, 1.95, -0.1, 0.125
52971, 1.95, -0.12, 0.10416666666667
52972, 1.9291666666667, -0.12, 0.125
52973, 1.95, -0.14, 0.125
52974, 1.95, -0.16, 0.10416666666667
52975, 1.9291666666667, -0.16, 0.125
52976, 1.95, -0.18, 0.125
52977, 1.9916666666667, -0.02, 0.125
52978, 1.9916666666667, -0.04, 0.10416666666667
52979, 1.9708333333333, -0.04, 0.125
52980, 1.9916666666667, -0.06, 0.125
52981, 1.9916666666667, -0.08, 0.10416666666667
52982, 1.9708333333333, -0.08, 0.125
52983, 1.9916666666667, -0.1, 0.125
52984, 1.9916666666667, -0.12, 0.10416666666667
52985, 1.9708333333333, -0.12, 0.125
52986, 1.9916666666667, -0.14, 0.125
52987, 1.9916666666667, -0.16, 0.10416666666667
52988, 1.9708333333333, -0.16, 0.125
52989, 1.9916666666667, -0.18, 0.125
52990, 2.0333333333333, -0.02, 0.125
52991, 2.0333333333333, -0.04, 0.10416666666667
52992, 2.0125, -0.04, 0.125
52993, 2.0333333333333, -0.06, 0.125
52994, 2.0333333333333, -0.08, 0.10416666666667
52995, 2.0125, -0.08, 0.125
52996, 2.0333333333333, -0.1, 0.125
52997, 2.0333333333333, -0.12, 0.10416666666667
52998, 2.0125, -0.12, 0.125
52999, 2.0333333333333, -0.14, 0.125
53000, 2.0333333333333, -0.16, 0.10416666666667
53001, 2.0125, -0.16, 0.125
53002, 2.0333333333333, -0.18, 0.125
53003, 2.075, -0.02, 0.125
53004, 2.075, -0.04, 0.10416666666667
53005, 2.0541666666667, -0.04, 0.125
53006, 2.075, -0.06, 0.125
53007, 2.075, -0.08, 0.10416666666667
53008, 2.0541666666667, -0.08, 0.125
53009, 2.075, -0.1, 0.125
53010, 2.075, -0.12, 0.10416666666667
53011, 2.0541666666667, -0.12, 0.125
53012, 2.075, -0.14, 0.125
53013, 2.075, -0.16, 0.10416666666667
53014, 2.0541666666667, -0.16, 0.125
53015, 2.075, -0.18, 0.125
53016, 2.1166666666667, -0.02, 0.125
53017, 2.1166666666667, -0.04, 0.10416666666667
53018, 2.0958333333333, -0.04, 0.125
53019, 2.1166666666667, -0.06, 0.125
53020, 2.1166666666667, -0.08, 0.10416666666667
53021, 2.0958333333333, -0.08, 0.125
53022, 2.1166666666667, -0.1, 0.125
53023, 2.1166666666667, -0.12, 0.10416666666667
53024, 2.0958333333333, -0.12, 0.125
53025, 2.1166666666667, -0.14, 0.125
53026, 2.1166666666667, -0.16, 0.10416666666667
53027, 2.0958333333333, -0.16, 0.125
53028, 2.1166666666667, -0.18, 0.125
53029, 2.1583333333333, -0.02, 0.125
53030, 2.1583333333333, -0.04, 0.10416666666667
53031, 2.1375, -0.04, 0.125
53032, 2.1583333333333, -0.06, 0.125
53033, 2.1583333333333, -0.08, 0.10416666666667
53034, 2.1375, -0.08, 0.125
53035, 2.1583333333333, -0.1, 0.125
53036, 2.1583333333333, -0.12, 0.10416666666667
53037, 2.1375, -0.12, 0.125
53038, 2.1583333333333, -0.14, 0.125
53039, 2.1583333333333, -0.16, 0.10416666666667
53040, 2.1375, -0.16, 0.125
53041, 2.1583333333333, -0.18, 0.125
53042, 2.1791666666667, -0.04, 0.125
53043, 2.1791666666667, -0.08, 0.125
53044, 2.1791666666667, -0.12, 0.125
53045, 2.1791666666667, -0.16, 0.125
53046, 1.2416666666667, -0.02, 0.16666666666667
53047, 1.2416666666667, -0.04, 0.14583333333333
53048, 1.2208333333333, -0.04, 0.16666666666667
53049, 1.2416666666667, -0.06, 0.16666666666667
53050, 1.2416666666667, -0.08, 0.14583333333333
53051, 1.2208333333333, -0.08, 0.16666666666667
53052, 1.2416666666667, -0.1, 0.16666666666667
53053, 1.2416666666667, -0.12, 0.14583333333333
53054, 1.2208333333333, -0.12, 0.16666666666667
53055, 1.2416666666667, -0.14, 0.16666666666667
53056, 1.2416666666667, -0.16, 0.14583333333333
53057, 1.2208333333333, -0.16, 0.16666666666667
53058, 1.2416666666667, -0.18, 0.16666666666667
53059, 1.2833333333333, -0.02, 0.16666666666667
53060, 1.2833333333333, -0.04, 0.14583333333333
53061, 1.2625, -0.04, 0.16666666666667
53062, 1.2833333333333, -0.06, 0.16666666666667
53063, 1.2833333333333, -0.08, 0.14583333333333
53064, 1.2625, -0.08, 0.16666666666667
53065, 1.2833333333333, -0.1, 0.16666666666667
53066, 1.2833333333333, -0.12, 0.14583333333333
53067, 1.2625, -0.12, 0.16666666666667
53068, 1.2833333333333, -0.14, 0.16666666666667
53069, 1.2833333333333, -0.16, 0.14583333333333
53070, 1.2625, -0.16, 0.16666666666667
53071, 1.2833333333333, -0.18, 0.16666666666667
53072, 1.325, -0.02, 0.16666666666667
53073, 1.325, -0.04, 0.14583333333333
53074, 1.3041666666667, -0.04, 0.16666666666667
53075, 1.325, -0.06, 0.16666666666667
53076, 1.325, -0.08, 0.14583333333333
53077, 1.3041666666667, -0.08, 0.16666666666667
53078, 1.325, -0.1, 0.16666666666667
53079, 1.325, -0.12, 0.14583333333333
53080, 1.3041666666667, -0.12, 0.16666666666667
53081, 1.325, -0.14, 0.16666666666667
53082, 1.325, -0.16, 0.14583333333333
53083, 1.3041666666667, -0.16, 0.16666666666667
53084, 1.325, -0.18, 0.16666666666667
53085, 1.3666666666667, -0.02, 0.16666666666667
53086, 1.3666666666667, -0.04, 0.14583333333333
53087, 1.3458333333333, -0.04, 0.16666666666667
53088, 1.3666666666667, -0.06, 0.16666666666667
53089, 1.3666666666667, -0.08, 0.14583333333333
53090, 1.3458333333333, -0.08, 0.16666666666667
53091, 1.3666666666667, -0.1, 0.16666666666667
53092, 1.3666666666667, -0.12, 0.14583333333333
53093, 1.3458333333333, -0.12, 0.16666666666667
53094, 1.3666666666667, -0.14, 0.16666666666667
53095, 1.3666666666667, -0.16, 0.14583333333333
53096, 1.3458333333333, -0.16, 0.16666666666667
53097, 1.3666666666667, -0.18, 0.16666666666667
53098, 1.4083333333333, -0.02, 0.16666666666667
53099, 1.4083333333333, -0.04, 0.14583333333333
53100, 1.3875, -0.04, 0.16666666666667
53101, 1.4083333333333, -0.06, 0.16666666666667
53102, 1.4083333333333, -0.08, 0.14583333333333
53103, 1.3875, -0.08, 0.16666666666667
53104, 1.4083333333333, -0.1, 0.16666666666667
53105, 1.4083333333333, -0.12, 0.14583333333333
53106, 1.3875, -0.12, 0.16666666666667
53107, 1.4083333333333, -0.14, 0.16666666666667
53108, 1.4083333333333, -0.16, 0.14583333333333
53109, 1.3875, -0.16, 0.16666666666667
53110, 1.4083333333333, -0.18, 0.16666666666667
53111, 1.45, -0.02, 0.16666666666667
53112, 1.45, -0.04, 0.14583333333333
53113, 1.4291666666667, -0.04, 0.16666666666667
53114, 1.45, -0.06, 0.16666666666667
53115, 1.45, -0.08, 0.14583333333333
53116, 1.4291666666667, -0.08, 0.16666666666667
53117, 1.45, -0.1, 0.16666666666667
53118, 1.45, -0.12, 0.14583333333333
53119, 1.4291666666667, -0.12, 0.16666666666667
53120, 1.45, -0.14, 0.16666666666667
53121, 1.45, -0.16, 0.14583333333333
53122, 1.4291666666667, -0.16, 0.16666666666667
53123, 1.45, -0.18, 0.16666666666667
53124, 1.4916666666667, -0.02, 0.16666666666667
53125, 1.4916666666667, -0.04, 0.14583333333333
53126, 1.4708333333333, -0.04, 0.16666666666667
53127, 1.4916666666667, -0.06, 0.16666666666667
53128, 1.4916666666667, -0.08, 0.14583333333333
53129, 1.4708333333333, -0.08, 0.16666666666667
53130, 1.4916666666667, -0.1, 0.16666666666667
53131, 1.4916666666667, -0.12, 0.14583333333333
53132, 1.4708333333333, -0.12, 0.16666666666667
53133, 1.4916666666667, -0.14, 0.16666666666667
53134, 1.4916666666667, -0.16, 0.14583333333333
53135, 1.4708333333333, -0.16, 0.16666666666667
53136, 1.4916666666667, -0.18, 0.16666666666667
53137, 1.5333333333333, -0.02, 0.16666666666667
53138, 1.5333333333333, -0.04, 0.14583333333333
53139, 1.5125, -0.04, 0.16666666666667
53140, 1.5333333333333, -0.06, 0.16666666666667
53141, 1.5333333333333, -0.08, 0.14583333333333
53142, 1.5125, -0.08, 0.16666666666667
53143, 1.5333333333333, -0.1, 0.16666666666667
53144, 1.5333333333333, -0.12, 0.14583333333333
53145, 1.5125, -0.12, 0.16666666666667
53146, 1.5333333333333, -0.14, 0.16666666666667
53147, 1.5333333333333, -0.16, 0.14583333333333
53148, 1.5125, -0.16, 0.16666666666667
53149, 1.5333333333333, -0.18, 0.16666666666667
53150, 1.575, -0.02, 0.16666666666667
53151, 1.575, -0.04, 0.14583333333333
53152, 1.5541666666667, -0.04, 0.16666666666667
53153, 1.575, -0.06, 0.16666666666667
53154, 1.575, -0.08, 0.14583333333333
53155, 1.5541666666667, -0.08, 0.16666666666667
53156, 1.575, -0.1, 0.16666666666667
53157, 1.575, -0.12, 0.14583333333333
53158, 1.5541666666667, -0.12, 0.16666666666667
53159, 1.575, -0.14, 0.16666666666667
53160, 1.575, -0.16, 0.14583333333333
53161, 1.5541666666667, -0.16, 0.16666666666667
53162, 1.575, -0.18, 0.16666666666667
53163, 1.6166666666667, -0.02, 0.16666666666667
53164, 1.6166666666667, -0.04, 0.14583333333333
53165, 1.5958333333333, -0.04, 0.16666666666667
53166, 1.6166666666667, -0.06, 0.16666666666667
53167, 1.6166666666667, -0.08, 0.14583333333333
53168, 1.5958333333333, -0.08, 0.16666666666667
53169, 1.6166666666667, -0.1, 0.16666666666667
53170, 1.6166666666667, -0.12, 0.14583333333333
53171, 1.5958333333333, -0.12, 0.16666666666667
53172, 1.6166666666667, -0.14, 0.16666666666667
53173, 1.6166666666667, -0.16, 0.14583333333333
53174, 1.5958333333333, -0.16, 0.16666666666667
53175, 1.6166666666667, -0.18, 0.16666666666667
53176, 1.6583333333333, -0.02, 0.16666666666667
53177, 1.6583333333333, -0.04, 0.14583333333333
53178, 1.6375, -0.04, 0.16666666666667
53179, 1.6583333333333, -0.06, 0.16666666666667
53180, 1.6583333333333, -0.08, 0.14583333333333
53181, 1.6375, -0.08, 0.16666666666667
53182, 1.6583333333333, -0.1, 0.16666666666667
53183, 1.6583333333333, -0.12, 0.14583333333333
53184, 1.6375, -0.12, 0.16666666666667
53185, 1.6583333333333, -0.14, 0.16666666666667
53186, 1.6583333333333, -0.16, 0.14583333333333
53187, 1.6375, -0.16, 0.16666666666667
53188, 1.6583333333333, -0.18, 0.16666666666667
53189, 1.7, -0.02, 0.16666666666667
53190, 1.7, -0.04, 0.14583333333333
53191, 1.6791666666667, -0.04, 0.16666666666667
53192, 1.7, -0.06, 0.16666666666667
53193, 1.7, -0.08, 0.14583333333333
53194, 1.6791666666667, -0.08, 0.16666666666667
53195, 1.7, -0.1, 0.16666666666667
53196, 1.7, -0.12, 0.14583333333333
53197, 1.6791666666667, -0.12, 0.16666666666667
53198, 1.7, -0.14, 0.16666666666667
53199, 1.7, -0.16, 0.14583333333333
53200, 1.6791666666667, -0.16, 0.16666666666667
53201, 1.7, -0.18, 0.16666666666667
53202, 1.7416666666667, -0.02, 0.16666666666667
53203, 1.7416666666667, -0.04, 0.14583333333333
53204, 1.7208333333333, -0.04, 0.16666666666667
53205, 1.7416666666667, -0.06, 0.16666666666667
53206, 1.7416666666667, -0.08, 0.14583333333333
53207, 1.7208333333333, -0.08, 0.16666666666667
53208, 1.7416666666667, -0.1, 0.16666666666667
53209, 1.7416666666667, -0.12, 0.14583333333333
53210, 1.7208333333333, -0.12, 0.16666666666667
53211, 1.7416666666667, -0.14, 0.16666666666667
53212, 1.7416666666667, -0.16, 0.14583333333333
53213, 1.7208333333333, -0.16, 0.16666666666667
53214, 1.7416666666667, -0.18, 0.16666666666667
53215, 1.7833333333333, -0.02, 0.16666666666667
53216, 1.7833333333333, -0.04, 0.14583333333333
53217, 1.7625, -0.04, 0.16666666666667
53218, 1.7833333333333, -0.06, 0.16666666666667
53219, 1.7833333333333, -0.08, 0.14583333333333
53220, 1.7625, -0.08, 0.16666666666667
53221, 1.7833333333333, -0.1, 0.16666666666667
53222, 1.7833333333333, -0.12, 0.14583333333333
53223, 1.7625, -0.12, 0.16666666666667
53224, 1.7833333333333, -0.14, 0.16666666666667
53225, 1.7833333333333, -0.16, 0.14583333333333
53226, 1.7625, -0.16, 0.16666666666667
53227, 1.7833333333333, -0.18, 0.16666666666667
53228, 1.825, -0.02, 0.16666666666667
53229, 1.825, -0.04, 0.14583333333333
53230, 1.8041666666667, -0.04, 0.16666666666667
53231, 1.825, -0.06, 0.16666666666667
53232, 1.825, -0.08, 0.14583333333333
53233, 1.8041666666667, -0.08, 0.16666666666667
53234, 1.825, -0.1, 0.16666666666667
53235, 1.825, -0.12, 0.14583333333333
53236, 1.8041666666667, -0.12, 0.16666666666667
53237, 1.825, -0.14, 0.16666666666667
53238, 1.825, -0.16, 0.14583333333333
53239, 1.8041666666667, -0.16, 0.16666666666667
53240, 1.825, -0.18, 0.16666666666667
53241, 1.8666666666667, -0.02, 0.16666666666667
53242, 1.8666666666667, -0.04, 0.14583333333333
53243, 1.8458333333333, -0.04, 0.16666666666667
53244, 1.8666666666667, -0.06, 0.16666666666667
53245, 1.8666666666667, -0.08, 0.14583333333333
53246, 1.8458333333333, -0.08, 0.16666666666667
53247, 1.8666666666667, -0.1, 0.16666666666667
53248, 1.8666666666667, -0.12, 0.14583333333333
53249, 1.8458333333333, -0.12, 0.16666666666667
53250, 1.8666666666667, -0.14, 0.16666666666667
53251, 1.8666666666667, -0.16, 0.14583333333333
53252, 1.8458333333333, -0.16, 0.16666666666667
53253, 1.8666666666667, -0.18, 0.16666666666667
53254, 1.9083333333333, -0.02, 0.16666666666667
53255, 1.9083333333333, -0.04, 0.14583333333333
53256, 1.8875, -0.04, 0.16666666666667
53257, 1.9083333333333, -0.06, 0.16666666666667
53258, 1.9083333333333, -0.08, 0.14583333333333
53259, 1.8875, -0.08, 0.16666666666667
53260, 1.9083333333333, -0.1, 0.16666666666667
53261, 1.9083333333333, -0.12, 0.14583333333333
53262, 1.8875, -0.12, 0.16666666666667
53263, 1.9083333333333, -0.14, 0.16666666666667
53264, 1.9083333333333, -0.16, 0.14583333333333
53265, 1.8875, -0.16, 0.16666666666667
53266, 1.9083333333333, -0.18, 0.16666666666667
53267, 1.95, -0.02, 0.16666666666667
53268, 1.95, -0.04, 0.14583333333333
53269, 1.9291666666667, -0.04, 0.16666666666667
53270, 1.95, -0.06, 0.16666666666667
53271, 1.95, -0.08, 0.14583333333333
53272, 1.9291666666667, -0.08, 0.16666666666667
53273, 1.95, -0.1, 0.16666666666667
53274, 1.95, -0.12, 0.14583333333333
53275, 1.9291666666667, -0.12, 0.16666666666667
53276, 1.95, -0.14, 0.16666666666667
53277, 1.95, -0.16, 0.14583333333333
53278, 1.9291666666667, -0.16, 0.16666666666667
53279, 1.95, -0.18, 0.16666666666667
53280, 1.9916666666667, -0.02, 0.16666666666667
53281, 1.9916666666667, -0.04, 0.14583333333333
53282, 1.9708333333333, -0.04, 0.16666666666667
53283, 1.9916666666667, -0.06, 0.16666666666667
53284, 1.9916666666667, -0.08, 0.14583333333333
53285, 1.9708333333333, -0.08, 0.16666666666667
53286, 1.9916666666667, -0.1, 0.16666666666667
53287, 1.9916666666667, -0.12, 0.14583333333333
53288, 1.9708333333333, -0.12, 0.16666666666667
53289, 1.9916666666667, -0.14, 0.16666666666667
53290, 1.9916666666667, -0.16, 0.14583333333333
53291, 1.9708333333333, -0.16, 0.16666666666667
53292, 1.9916666666667, -0.18, 0.16666666666667
53293, 2.0333333333333, -0.02, 0.16666666666667
53294, 2.0333333333333, -0.04, 0.14583333333333
53295, 2.0125, -0.04, 0.16666666666667
53296, 2.0333333333333, -0.06, 0.16666666666667
53297, 2.0333333333333, -0.08, 0.14583333333333
53298, 2.0125, -0.08, 0.16666666666667
53299, 2.0333333333333, -0.1, 0.16666666666667
53300, 2.0333333333333, -0.12, 0.14583333333333
53301, 2.0125, -0.12, 0.16666666666667
53302, 2.0333333333333, -0.14, 0.16666666666667
53303, 2.0333333333333, -0.16, 0.14583333333333
53304, 2.0125, -0.16, 0.16666666666667
53305, 2.0333333333333, -0.18, 0.16666666666667
53306, 2.075, -0.02, 0.16666666666667
53307, 2.075, -0.04, 0.14583333333333
53308, 2.0541666666667, -0.04, 0.16666666666667
53309, 2.075, -0.06, 0.16666666666667
53310, 2.075, -0.08, 0.14583333333333
53311, 2.0541666666667, -0.08, 0.16666666666667
53312, 2.075, -0.1, 0.16666666666667
53313, 2.075, -0.12, 0.14583333333333
53314, 2.0541666666667, -0.12, 0.16666666666667
53315, 2.075, -0.14, 0.16666666666667
53316, 2.075, -0.16, 0.14583333333333
53317, 2.0541666666667, -0.16, 0.16666666666667
53318, 2.075, -0.18, 0.16666666666667
53319, 2.1166666666667, -0.02, 0.16666666666667
53320, 2.1166666666667, -0.04, 0.14583333333333
53321, 2.0958333333333, -0.04, 0.16666666666667
53322, 2.1166666666667, -0.06, 0.16666666666667
53323, 2.1166666666667, -0.08, 0.14583333333333
53324, 2.0958333333333, -0.08, 0.16666666666667
53325, 2.1166666666667, -0.1, 0.16666666666667
53326, 2.1166666666667, -0.12, 0.14583333333333
53327, 2.0958333333333, -0.12, 0.16666666666667
53328, 2.1166666666667, -0.14, 0.16666666666667
53329, 2.1166666666667, -0.16, 0.14583333333333
53330, 2.0958333333333, -0.16, 0.16666666666667
53331, 2.1166666666667, -0.18, 0.16666666666667
53332, 2.1583333333333, -0.02, 0.16666666666667
53333, 2.1583333333333, -0.04, 0.14583333333333
53334, 2.1375, -0.04, 0.16666666666667
53335, 2.1583333333333, -0.06, 0.16666666666667
53336, 2.1583333333333, -0.08, 0.14583333333333
53337, 2.1375, -0.08, 0.16666666666667
53338, 2.1583333333333, -0.1, 0.16666666666667
53339, 2.1583333333333, -0.12, 0.14583333333333
53340, 2.1375, -0.12, 0.16666666666667
53341, 2.1583333333333, -0.14, 0.16666666666667
53342, 2.1583333333333, -0.16, 0.14583333333333
53343, 2.1375, -0.16, 0.16666666666667
53344, 2.1583333333333, -0.18, 0.16666666666667
53345, 2.1791666666667, -0.04, 0.16666666666667
53346, 2.1791666666667, -0.08, 0.16666666666667
53347, 2.1791666666667, -0.12, 0.16666666666667
53348, 2.1791666666667, -0.16, 0.16666666666667
53349, 1.2416666666667, -0.02, 0.20833333333333
53350, 1.2416666666667, -0.04, 0.1875
53351, 1.2208333333333, -0.04, 0.20833333333333
53352, 1.2416666666667, -0.06, 0.20833333333333
53353, 1.2416666666667, -0.08, 0.1875
53354, 1.2208333333333, -0.08, 0.20833333333333
53355, 1.2416666666667, -0.1, 0.20833333333333
53356, 1.2416666666667, -0.12, 0.1875
53357, 1.2208333333333, -0.12, 0.20833333333333
53358, 1.2416666666667, -0.14, 0.20833333333333
53359, 1.2416666666667, -0.16, 0.1875
53360, 1.2208333333333, -0.16, 0.20833333333333
53361, 1.2416666666667, -0.18, 0.20833333333333
53362, 1.2833333333333, -0.02, 0.20833333333333
53363, 1.2833333333333, -0.04, 0.1875
53364, 1.2625, -0.04, 0.20833333333333
53365, 1.2833333333333, -0.06, 0.20833333333333
53366, 1.2833333333333, -0.08, 0.1875
53367, 1.2625, -0.08, 0.20833333333333
53368, 1.2833333333333, -0.1, 0.20833333333333
53369, 1.2833333333333, -0.12, 0.1875
53370, 1.2625, -0.12, 0.20833333333333
53371, 1.2833333333333, -0.14, 0.20833333333333
53372, 1.2833333333333, -0.16, 0.1875
53373, 1.2625, -0.16, 0.20833333333333
53374, 1.2833333333333, -0.18, 0.20833333333333
53375, 1.325, -0.02, 0.20833333333333
53376, 1.325, -0.04, 0.1875
53377, 1.3041666666667, -0.04, 0.20833333333333
53378, 1.325, -0.06, 0.20833333333333
53379, 1.325, -0.08, 0.1875
53380, 1.3041666666667, -0.08, 0.20833333333333
53381, 1.325, -0.1, 0.20833333333333
53382, 1.325, -0.12, 0.1875
53383, 1.3041666666667, -0.12, 0.20833333333333
53384, 1.325, -0.14, 0.20833333333333
53385, 1.325, -0.16, 0.1875
53386, 1.3041666666667, -0.16, 0.20833333333333
53387, 1.325, -0.18, 0.20833333333333
53388, 1.3666666666667, -0.02, 0.20833333333333
53389, 1.3666666666667, -0.04, 0.1875
53390, 1.3458333333333, -0.04, 0.20833333333333
53391, 1.3666666666667, -0.06, 0.20833333333333
53392, 1.3666666666667, -0.08, 0.1875
53393, 1.3458333333333, -0.08, 0.20833333333333
53394, 1.3666666666667, -0.1, 0.20833333333333
53395, 1.3666666666667, -0.12, 0.1875
53396, 1.3458333333333, -0.12, 0.20833333333333
53397, 1.3666666666667, -0.14, 0.20833333333333
53398, 1.3666666666667, -0.16, 0.1875
53399, 1.3458333333333, -0.16, 0.20833333333333
53400, 1.3666666666667, -0.18, 0.20833333333333
53401, 1.4083333333333, -0.02, 0.20833333333333
53402, 1.4083333333333, -0.04, 0.1875
53403, 1.3875, -0.04, 0.20833333333333
53404, 1.4083333333333, -0.06, 0.20833333333333
53405, 1.4083333333333, -0.08, 0.1875
53406, 1.3875, -0.08, 0.20833333333333
53407, 1.4083333333333, -0.1, 0.20833333333333
53408, 1.4083333333333, -0.12, 0.1875
53409, 1.3875, -0.12, 0.20833333333333
53410, 1.4083333333333, -0.14, 0.20833333333333
53411, 1.4083333333333, -0.16, 0.1875
53412, 1.3875, -0.16, 0.20833333333333
53413, 1.4083333333333, -0.18, 0.20833333333333
53414, 1.45, -0.02, 0.20833333333333
53415, 1.45, -0.04, 0.1875
53416, 1.4291666666667, -0.04, 0.20833333333333
53417, 1.45, -0.06, 0.20833333333333
53418, 1.45, -0.08, 0.1875
53419, 1.4291666666667, -0.08, 0.20833333333333
53420, 1.45, -0.1, 0.20833333333333
53421, 1.45, -0.12, 0.1875
53422, 1.4291666666667, -0.12, 0.20833333333333
53423, 1.45, -0.14, 0.20833333333333
53424, 1.45, -0.16, 0.1875
53425, 1.4291666666667, -0.16, 0.20833333333333
53426, 1.45, -0.18, 0.20833333333333
53427, 1.4916666666667, -0.02, 0.20833333333333
53428, 1.4916666666667, -0.04, 0.1875
53429, 1.4708333333333, -0.04, 0.20833333333333
53430, 1.4916666666667, -0.06, 0.20833333333333
53431, 1.4916666666667, -0.08, 0.1875
53432, 1.4708333333333, -0.08, 0.20833333333333
53433, 1.4916666666667, -0.1, 0.20833333333333
53434, 1.4916666666667, -0.12, 0.1875
53435, 1.4708333333333, -0.12, 0.20833333333333
53436, 1.4916666666667, -0.14, 0.20833333333333
53437, 1.4916666666667, -0.16, 0.1875
53438, 1.4708333333333, -0.16, 0.20833333333333
53439, 1.4916666666667, -0.18, 0.20833333333333
53440, 1.5333333333333, -0.02, 0.20833333333333
53441, 1.5333333333333, -0.04, 0.1875
53442, 1.5125, -0.04, 0.20833333333333
53443, 1.5333333333333, -0.06, 0.20833333333333
53444, 1.5333333333333, -0.08, 0.1875
53445, 1.5125, -0.08, 0.20833333333333
53446, 1.5333333333333, -0.1, 0.20833333333333
53447, 1.5333333333333, -0.12, 0.1875
53448, 1.5125, -0.12, 0.20833333333333
53449, 1.5333333333333, -0.14, 0.20833333333333
53450, 1.5333333333333, -0.16, 0.1875
53451, 1.5125, -0.16, 0.20833333333333
53452, 1.5333333333333, -0.18, 0.20833333333333
53453, 1.575, -0.02, 0.20833333333333
53454, 1.575, -0.04, 0.1875
53455, 1.5541666666667, -0.04, 0.20833333333333
53456, 1.575, -0.06, 0.20833333333333
53457, 1.575, -0.08, 0.1875
53458, 1.5541666666667, -0.08, 0.20833333333333
53459, 1.575, -0.1, 0.20833333333333
53460, 1.575, -0.12, 0.1875
53461, 1.5541666666667, -0.12, 0.20833333333333
53462, 1.575, -0.14, 0.20833333333333
53463, 1.575, -0.16, 0.1875
53464, 1.5541666666667, -0.16, 0.20833333333333
53465, 1.575, -0.18, 0.20833333333333
53466, 1.6166666666667, -0.02, 0.20833333333333
53467, 1.6166666666667, -0.04, 0.1875
53468, 1.5958333333333, -0.04, 0.20833333333333
53469, 1.6166666666667, -0.06, 0.20833333333333
53470, 1.6166666666667, -0.08, 0.1875
53471, 1.5958333333333, -0.08, 0.20833333333333
53472, 1.6166666666667, -0.1, 0.20833333333333
53473, 1.6166666666667, -0.12, 0.1875
53474, 1.5958333333333, -0.12, 0.20833333333333
53475, 1.6166666666667, -0.14, 0.20833333333333
53476, 1.6166666666667, -0.16, 0.1875
53477, 1.5958333333333, -0.16, 0.20833333333333
53478, 1.6166666666667, -0.18, 0.20833333333333
53479, 1.6583333333333, -0.02, 0.20833333333333
53480, 1.6583333333333, -0.04, 0.1875
53481, 1.6375, -0.04, 0.20833333333333
53482, 1.6583333333333, -0.06, 0.20833333333333
53483, 1.6583333333333, -0.08, 0.1875
53484, 1.6375, -0.08, 0.20833333333333
53485, 1.6583333333333, -0.1, 0.20833333333333
53486, 1.6583333333333, -0.12, 0.1875
53487, 1.6375, -0.12, 0.20833333333333
53488, 1.6583333333333, -0.14, 0.20833333333333
53489, 1.6583333333333, -0.16, 0.1875
53490, 1.6375, -0.16, 0.20833333333333
53491, 1.6583333333333, -0.18, 0.20833333333333
53492, 1.7, -0.02, 0.20833333333333
53493, 1.7, -0.04, 0.1875
53494, 1.6791666666667, -0.04, 0.20833333333333
53495, 1.7, -0.06, 0.20833333333333
53496, 1.7, -0.08, 0.1875
53497, 1.6791666666667, -0.08, 0.20833333333333
53498, 1.7, -0.1, 0.20833333333333
53499, 1.7, -0.12, 0.1875
53500, 1.6791666666667, -0.12, 0.20833333333333
53501, 1.7, -0.14, 0.20833333333333
53502, 1.7, -0.16, 0.1875
53503, 1.6791666666667, -0.16, 0.20833333333333
53504, 1.7, -0.18, 0.20833333333333
53505, 1.7416666666667, -0.02, 0.20833333333333
53506, 1.7416666666667, -0.04, 0.1875
53507, 1.7208333333333, -0.04, 0.20833333333333
53508, 1.7416666666667, -0.06, 0.20833333333333
53509, 1.7416666666667, -0.08, 0.1875
53510, 1.7208333333333, -0.08, 0.20833333333333
53511, 1.7416666666667, -0.1, 0.20833333333333
53512, 1.7416666666667, -0.12, 0.1875
53513, 1.7208333333333, -0.12, 0.20833333333333
53514, 1.7416666666667, -0.14, 0.20833333333333
53515, 1.7416666666667, -0.16, 0.1875
53516, 1.7208333333333, -0.16, 0.20833333333333
53517, 1.7416666666667, -0.18, 0.20833333333333
53518, 1.7833333333333, -0.02, 0.20833333333333
53519, 1.7833333333333, -0.04, 0.1875
53520, 1.7625, -0.04, 0.20833333333333
53521, 1.7833333333333, -0.06, 0.20833333333333
53522, 1.7833333333333, -0.08, 0.1875
53523, 1.7625, -0.08, 0.20833333333333
53524, 1.7833333333333, -0.1, 0.20833333333333
53525, 1.7833333333333, -0.12, 0.1875
53526, 1.7625, -0.12, 0.20833333333333
53527, 1.7833333333333, -0.14, 0.20833333333333
53528, 1.7833333333333, -0.16, 0.1875
53529, 1.7625, -0.16, 0.20833333333333
53530, 1.7833333333333, -0.18, 0.20833333333333
53531, 1.825, -0.02, 0.20833333333333
53532, 1.825, -0.04, 0.1875
53533, 1.8041666666667, -0.04, 0.20833333333333
53534, 1.825, -0.06, 0.20833333333333
53535, 1.825, -0.08, 0.1875
53536, 1.8041666666667, -0.08, 0.20833333333333
53537, 1.825, -0.1, 0.20833333333333
53538, 1.825, -0.12, 0.1875
53539, 1.8041666666667, -0.12, 0.20833333333333
53540, 1.825, -0.14, 0.20833333333333
53541, 1.825, -0.16, 0.1875
53542, 1.8041666666667, -0.16, 0.20833333333333
53543, 1.825, -0.18, 0.20833333333333
53544, 1.8666666666667, -0.02, 0.20833333333333
53545, 1.8666666666667, -0.04, 0.1875
53546, 1.8458333333333, -0.04, 0.20833333333333
53547, 1.8666666666667, -0.06, 0.20833333333333
53548, 1.8666666666667, -0.08, 0.1875
53549, 1.8458333333333, -0.08, 0.20833333333333
53550, 1.8666666666667, -0.1, 0.20833333333333
53551, 1.8666666666667, -0.12, 0.1875
53552, 1.8458333333333, -0.12, 0.20833333333333
53553, 1.8666666666667, -0.14, 0.20833333333333
53554, 1.8666666666667, -0.16, 0.1875
53555, 1.8458333333333, -0.16, 0.20833333333333
53556, 1.8666666666667, -0.18, 0.20833333333333
53557, 1.9083333333333, -0.02, 0.20833333333333
53558, 1.9083333333333, -0.04, 0.1875
53559, 1.8875, -0.04, 0.20833333333333
53560, 1.9083333333333, -0.06, 0.20833333333333
53561, 1.9083333333333, -0.08, 0.1875
53562, 1.8875, -0.08, 0.20833333333333
53563, 1.9083333333333, -0.1, 0.20833333333333
53564, 1.9083333333333, -0.12, 0.1875
53565, 1.8875, -0.12, 0.20833333333333
53566, 1.9083333333333, -0.14, 0.20833333333333
53567, 1.9083333333333, -0.16, 0.1875
53568, 1.8875, -0.16, 0.20833333333333
53569, 1.9083333333333, -0.18, 0.20833333333333
53570, 1.95, -0.02, 0.20833333333333
53571, 1.95, -0.04, 0.1875
53572, 1.9291666666667, -0.04, 0.20833333333333
53573, 1.95, -0.06, 0.20833333333333
53574, 1.95, -0.08, 0.1875
53575, 1.9291666666667, -0.08, 0.20833333333333
53576, 1.95, -0.1, 0.20833333333333
53577, 1.95, -0.12, 0.1875
53578, 1.9291666666667, -0.12, 0.20833333333333
53579, 1.95, -0.14, 0.20833333333333
53580, 1.95, -0.16, 0.1875
53581, 1.9291666666667, -0.16, 0.20833333333333
53582, 1.95, -0.18, 0.20833333333333
53583, 1.9916666666667, -0.02, 0.20833333333333
53584, 1.9916666666667, -0.04, 0.1875
53585, 1.9708333333333, -0.04, 0.20833333333333
53586, 1.9916666666667, -0.06, 0.20833333333333
53587, 1.9916666666667, -0.08, 0.1875
53588, 1.9708333333333, -0.08, 0.20833333333333
53589, 1.9916666666667, -0.1, 0.20833333333333
53590, 1.9916666666667, -0.12, 0.1875
53591, 1.9708333333333, -0.12, 0.20833333333333
53592, 1.9916666666667, -0.14, 0.20833333333333
53593, 1.9916666666667, -0.16, 0.1875
53594, 1.9708333333333, -0.16, 0.20833333333333
53595, 1.9916666666667, -0.18, 0.20833333333333
53596, 2.0333333333333, -0.02, 0.20833333333333
53597, 2.0333333333333, -0.04, 0.1875
53598, 2.0125, -0.04, 0.20833333333333
53599, 2.0333333333333, -0.06, 0.20833333333333
53600, 2.0333333333333, -0.08, 0.1875
53601, 2.0125, -0.08, 0.20833333333333
53602, 2.0333333333333, -0.1, 0.20833333333333
53603, 2.0333333333333, -0.12, 0.1875
53604, 2.0125, -0.12, 0.20833333333333
53605, 2.0333333333333, -0.14, 0.20833333333333
53606, 2.0333333333333, -0.16, 0.1875
53607, 2.0125, -0.16, 0.20833333333333
53608, 2.0333333333333, -0.18, 0.20833333333333
53609, 2.075, -0.02, 0.20833333333333
53610, 2.075, -0.04, 0.1875
53611, 2.0541666666667, -0.04, 0.20833333333333
53612, 2.075, -0.06, 0.20833333333333
53613, 2.075, -0.08, 0.1875
53614, 2.0541666666667, -0.08, 0.20833333333333
53615, 2.075, -0.1, 0.20833333333333
53616, 2.075, -0.12, 0.1875
53617, 2.0541666666667, -0.12, 0.20833333333333
53618, 2.075, -0.14, 0.20833333333333
53619, 2.075, -0.16, 0.1875
53620, 2.0541666666667, -0.16, 0.20833333333333
53621, 2.075, -0.18, 0.20833333333333
53622, 2.1166666666667, -0.02, 0.20833333333333
53623, 2.1166666666667, -0.04, 0.1875
53624, 2.0958333333333, -0.04, 0.20833333333333
53625, 2.1166666666667, -0.06, 0.20833333333333
53626, 2.1166666666667, -0.08, 0.1875
53627, 2.0958333333333, -0.08, 0.20833333333333
53628, 2.1166666666667, -0.1, 0.20833333333333
53629, 2.1166666666667, -0.12, 0.1875
53630, 2.0958333333333, -0.12, 0.20833333333333
53631, 2.1166666666667, -0.14, 0.20833333333333
53632, 2.1166666666667, -0.16, 0.1875
53633, 2.0958333333333, -0.16, 0.20833333333333
53634, 2.1166666666667, -0.18, 0.20833333333333
53635, 2.1583333333333, -0.02, 0.20833333333333
53636, 2.1583333333333, -0.04, 0.1875
53637, 2.1375, -0.04, 0.20833333333333
53638, 2.1583333333333, -0.06, 0.20833333333333
53639, 2.1583333333333, -0.08, 0.1875
53640, 2.1375, -0.08, 0.20833333333333
53641, 2.1583333333333, -0.1, 0.20833333333333
53642, 2.1583333333333, -0.12, 0.1875
53643, 2.1375, -0.12, 0.20833333333333
53644, 2.1583333333333, -0.14, 0.20833333333333
53645, 2.1583333333333, -0.16, 0.1875
53646, 2.1375, -0.16, 0.20833333333333
53647, 2.1583333333333, -0.18, 0.20833333333333
53648, 2.1791666666667, -0.04, 0.20833333333333
53649, 2.1791666666667, -0.08, 0.20833333333333
53650, 2.1791666666667, -0.12, 0.20833333333333
53651, 2.1791666666667, -0.16, 0.20833333333333
53652, 1.2416666666667, -0.02, 0.25
53653, 1.2416666666667, -0.04, 0.22916666666667
53654, 1.2208333333333, -0.04, 0.25
53655, 1.2416666666667, -0.06, 0.25
53656, 1.2416666666667, -0.08, 0.22916666666667
53657, 1.2208333333333, -0.08, 0.25
53658, 1.2416666666667, -0.1, 0.25
53659, 1.2416666666667, -0.12, 0.22916666666667
53660, 1.2208333333333, -0.12, 0.25
53661, 1.2416666666667, -0.14, 0.25
53662, 1.2416666666667, -0.16, 0.22916666666667
53663, 1.2208333333333, -0.16, 0.25
53664, 1.2416666666667, -0.18, 0.25
53665, 1.2833333333333, -0.02, 0.25
53666, 1.2833333333333, -0.04, 0.22916666666667
53667, 1.2625, -0.04, 0.25
53668, 1.2833333333333, -0.06, 0.25
53669, 1.2833333333333, -0.08, 0.22916666666667
53670, 1.2625, -0.08, 0.25
53671, 1.2833333333333, -0.1, 0.25
53672, 1.2833333333333, -0.12, 0.22916666666667
53673, 1.2625, -0.12, 0.25
53674, 1.2833333333333, -0.14, 0.25
53675, 1.2833333333333, -0.16, 0.22916666666667
53676, 1.2625, -0.16, 0.25
53677, 1.2833333333333, -0.18, 0.25
53678, 1.325, -0.02, 0.25
53679, 1.325, -0.04, 0.22916666666667
53680, 1.3041666666667, -0.04, 0.25
53681, 1.325, -0.06, 0.25
53682, 1.325, -0.08, 0.22916666666667
53683, 1.3041666666667, -0.08, 0.25
53684, 1.325, -0.1, 0.25
53685, 1.325, -0.12, 0.22916666666667
53686, 1.3041666666667, -0.12, 0.25
53687, 1.325, -0.14, 0.25
53688, 1.325, -0.16, 0.22916666666667
53689, 1.3041666666667, -0.16, 0.25
53690, 1.325, -0.18, 0.25
53691, 1.3666666666667, -0.02, 0.25
53692, 1.3666666666667, -0.04, 0.22916666666667
53693, 1.3458333333333, -0.04, 0.25
53694, 1.3666666666667, -0.06, 0.25
53695, 1.3666666666667, -0.08, 0.22916666666667
53696, 1.3458333333333, -0.08, 0.25
53697, 1.3666666666667, -0.1, 0.25
53698, 1.3666666666667, -0.12, 0.22916666666667
53699, 1.3458333333333, -0.12, 0.25
53700, 1.3666666666667, -0.14, 0.25
53701, 1.3666666666667, -0.16, 0.22916666666667
53702, 1.3458333333333, -0.16, 0.25
53703, 1.3666666666667, -0.18, 0.25
53704, 1.4083333333333, -0.02, 0.25
53705, 1.4083333333333, -0.04, 0.22916666666667
53706, 1.3875, -0.04, 0.25
53707, 1.4083333333333, -0.06, 0.25
53708, 1.4083333333333, -0.08, 0.22916666666667
53709, 1.3875, -0.08, 0.25
53710, 1.4083333333333, -0.1, 0.25
53711, 1.4083333333333, -0.12, 0.22916666666667
53712, 1.3875, -0.12, 0.25
53713, 1.4083333333333, -0.14, 0.25
53714, 1.4083333333333, -0.16, 0.22916666666667
53715, 1.3875, -0.16, 0.25
53716, 1.4083333333333, -0.18, 0.25
53717, 1.45, -0.02, 0.25
53718, 1.45, -0.04, 0.22916666666667
53719, 1.4291666666667, -0.04, 0.25
53720, 1.45, -0.06, 0.25
53721, 1.45, -0.08, 0.22916666666667
53722, 1.4291666666667, -0.08, 0.25
53723, 1.45, -0.1, 0.25
53724, 1.45, -0.12, 0.22916666666667
53725, 1.4291666666667, -0.12, 0.25
53726, 1.45, -0.14, 0.25
53727, 1.45, -0.16, 0.22916666666667
53728, 1.4291666666667, -0.16, 0.25
53729, 1.45, -0.18, 0.25
53730, 1.4916666666667, -0.02, 0.25
53731, 1.4916666666667, -0.04, 0.22916666666667
53732, 1.4708333333333, -0.04, 0.25
53733, 1.4916666666667, -0.06, 0.25
53734, 1.4916666666667, -0.08, 0.22916666666667
53735, 1.4708333333333, -0.08, 0.25
53736, 1.4916666666667, -0.1, 0.25
53737, 1.4916666666667, -0.12, 0.22916666666667
53738, 1.4708333333333, -0.12, 0.25
53739, 1.4916666666667, -0.14, 0.25
53740, 1.4916666666667, -0.16, 0.22916666666667
53741, 1.4708333333333, -0.16, 0.25
53742, 1.4916666666667, -0.18, 0.25
53743, 1.5333333333333, -0.02, 0.25
53744, 1.5333333333333, -0.04, 0.22916666666667
53745, 1.5125, -0.04, 0.25
53746, 1.5333333333333, -0.06, 0.25
53747, 1.5333333333333, -0.08, 0.22916666666667
53748, 1.5125, -0.08, 0.25
53749, 1.5333333333333, -0.1, 0.25
53750, 1.5333333333333, -0.12, 0.22916666666667
53751, 1.5125, -0.12, 0.25
53752, 1.5333333333333, -0.14, 0.25
53753, 1.5333333333333, -0.16, 0.22916666666667
53754, 1.5125, -0.16, 0.25
53755, 1.5333333333333, -0.18, 0.25
53756, 1.575, -0.02, 0.25
53757, 1.575, -0.04, 0.22916666666667
53758, 1.5541666666667, -0.04, 0.25
53759, 1.575, -0.06, 0.25
53760, 1.575, -0.08, 0.22916666666667
53761, 1.5541666666667, -0.08, 0.25
53762, 1.575, -0.1, 0.25
53763, 1.575, -0.12, 0.22916666666667
53764, 1.5541666666667, -0.12, 0.25
53765, 1.575, -0.14, 0.25
53766, 1.575, -0.16, 0.22916666666667
53767, 1.5541666666667, -0.16, 0.25
53768, 1.575, -0.18, 0.25
53769, 1.6166666666667, -0.02, 0.25
53770, 1.6166666666667, -0.04, 0.22916666666667
53771, 1.5958333333333, -0.04, 0.25
53772, 1.6166666666667, -0.06, 0.25
53773, 1.6166666666667, -0.08, 0.22916666666667
53774, 1.5958333333333, -0.08, 0.25
53775, 1.6166666666667, -0.1, 0.25
53776, 1.6166666666667, -0.12, 0.22916666666667
53777, 1.5958333333333, -0.12, 0.25
53778, 1.6166666666667, -0.14, 0.25
53779, 1.6166666666667, -0.16, 0.22916666666667
53780, 1.5958333333333, -0.16, 0.25
53781, 1.6166666666667, -0.18, 0.25
53782, 1.6583333333333, -0.02, 0.25
53783, 1.6583333333333, -0.04, 0.22916666666667
53784, 1.6375, -0.04, 0.25
53785, 1.6583333333333, -0.06, 0.25
53786, 1.6583333333333, -0.08, 0.22916666666667
53787, 1.6375, -0.08, 0.25
53788, 1.6583333333333, -0.1, 0.25
53789, 1.6583333333333, -0.12, 0.22916666666667
53790, 1.6375, -0.12, 0.25
53791, 1.6583333333333, -0.14, 0.25
53792, 1.6583333333333, -0.16, 0.22916666666667
53793, 1.6375, -0.16, 0.25
53794, 1.6583333333333, -0.18, 0.25
53795, 1.7, -0.02, 0.25
53796, 1.7, -0.04, 0.22916666666667
53797, 1.6791666666667, -0.04, 0.25
53798, 1.7, -0.06, 0.25
53799, 1.7, -0.08, 0.22916666666667
53800, 1.6791666666667, -0.08, 0.25
53801, 1.7, -0.1, 0.25
53802, 1.7, -0.12, 0.22916666666667
53803, 1.6791666666667, -0.12, 0.25
53804, 1.7, -0.14, 0.25
53805, 1.7, -0.16, 0.22916666666667
53806, 1.6791666666667, -0.16, 0.25
53807, 1.7, -0.18, 0.25
53808, 1.7416666666667, -0.02, 0.25
53809, 1.7416666666667, -0.04, 0.22916666666667
53810, 1.7208333333333, -0.04, 0.25
53811, 1.7416666666667, -0.06, 0.25
53812, 1.7416666666667, -0.08, 0.22916666666667
53813, 1.7208333333333, -0.08, 0.25
53814, 1.7416666666667, -0.1, 0.25
53815, 1.7416666666667, -0.12, 0.22916666666667
53816, 1.7208333333333, -0.12, 0.25
53817, 1.7416666666667, -0.14, 0.25
53818, 1.7416666666667, -0.16, 0.22916666666667
53819, 1.7208333333333, -0.16, 0.25
53820, 1.7416666666667, -0.18, 0.25
53821, 1.7833333333333, -0.02, 0.25
53822, 1.7833333333333, -0.04, 0.22916666666667
53823, 1.7625, -0.04, 0.25
53824, 1.7833333333333, -0.06, 0.25
53825, 1.7833333333333, -0.08, 0.22916666666667
53826, 1.7625, -0.08, 0.25
53827, 1.7833333333333, -0.1, 0.25
53828, 1.7833333333333, -0.12, 0.22916666666667
53829, 1.7625, -0.12, 0.25
53830, 1.7833333333333, -0.14, 0.25
53831, 1.7833333333333, -0.16, 0.22916666666667
53832, 1.7625, -0.16, 0.25
53833, 1.7833333333333, -0.18, 0.25
53834, 1.825, -0.02, 0.25
53835, 1.825, -0.04, 0.22916666666667
53836, 1.8041666666667, -0.04, 0.25
53837, 1.825, -0.06, 0.25
53838, 1.825, -0.08, 0.22916666666667
53839, 1.8041666666667, -0.08, 0.25
53840, 1.825, -0.1, 0.25
53841, 1.825, -0.12, 0.22916666666667
53842, 1.8041666666667, -0.12, 0.25
53843, 1.825, -0.14, 0.25
53844, 1.825, -0.16, 0.22916666666667
53845, 1.8041666666667, -0.16, 0.25
53846, 1.825, -0.18, 0.25
53847, 1.8666666666667, -0.02, 0.25
53848, 1.8666666666667, -0.04, 0.22916666666667
53849, 1.8458333333333, -0.04, 0.25
53850, 1.8666666666667, -0.06, 0.25
53851, 1.8666666666667, -0.08, 0.22916666666667
53852, 1.8458333333333, -0.08, 0.25
53853, 1.8666666666667, -0.1, 0.25
53854, 1.8666666666667, -0.12, 0.22916666666667
53855, 1.8458333333333, -0.12, 0.25
53856, 1.8666666666667, -0.14, 0.25
53857, 1.8666666666667, -0.16, 0.22916666666667
53858, 1.8458333333333, -0.16, 0.25
53859, 1.8666666666667, -0.18, 0.25
53860, 1.9083333333333, -0.02, 0.25
53861, 1.9083333333333, -0.04, 0.22916666666667
53862, 1.8875, -0.04, 0.25
53863, 1.9083333333333, -0.06, 0.25
53864, 1.9083333333333, -0.08, 0.22916666666667
53865, 1.8875, -0.08, 0.25
53866, 1.9083333333333, -0.1, 0.25
53867, 1.9083333333333, -0.12, 0.22916666666667
53868, 1.8875, -0.12, 0.25
53869, 1.9083333333333, -0.14, 0.25
53870, 1.9083333333333, -0.16, 0.22916666666667
53871, 1.8875, -0.16, 0.25
53872, 1.9083333333333, -0.18, 0.25
53873, 1.95, -0.02, 0.25
53874, 1.95, -0.04, 0.22916666666667
53875, 1.9291666666667, -0.04, 0.25
53876, 1.95, -0.06, 0.25
53877, 1.95, -0.08, 0.22916666666667
53878, 1.9291666666667, -0.08, 0.25
53879, 1.95, -0.1, 0.25
53880, 1.95, -0.12, 0.22916666666667
53881, 1.9291666666667, -0.12, 0.25
53882, 1.95, -0.14, 0.25
53883, 1.95, -0.16, 0.22916666666667
53884, 1.9291666666667, -0.16, 0.25
53885, 1.95, -0.18, 0.25
53886, 1.9916666666667, -0.02, 0.25
53887, 1.9916666666667, -0.04, 0.22916666666667
53888, 1.9708333333333, -0.04, 0.25
53889, 1.9916666666667, -0.06, 0.25
53890, 1.9916666666667, -0.08, 0.22916666666667
53891, 1.9708333333333, -0.08, 0.25
53892, 1.9916666666667, -0.1, 0.25
53893, 1.9916666666667, -0.12, 0.22916666666667
53894, 1.9708333333333, -0.12, 0.25
53895, 1.9916666666667, -0.14, 0.25
53896, 1.9916666666667, -0.16, 0.22916666666667
53897, 1.9708333333333, -0.16, 0.25
53898, 1.9916666666667, -0.18, 0.25
53899, 2.0333333333333, -0.02, 0.25
53900, 2.0333333333333, -0.04, 0.22916666666667
53901, 2.0125, -0.04, 0.25
53902, 2.0333333333333, -0.06, 0.25
53903, 2.0333333333333, -0.08, 0.22916666666667
53904, 2.0125, -0.08, 0.25
53905, 2.0333333333333, -0.1, 0.25
53906, 2.0333333333333, -0.12, 0.22916666666667
53907, 2.0125, -0.12, 0.25
53908, 2.0333333333333, -0.14, 0.25
53909, 2.0333333333333, -0.16, 0.22916666666667
53910, 2.0125, -0.16, 0.25
53911, 2.0333333333333, -0.18, 0.25
53912, 2.075, -0.02, 0.25
53913, 2.075, -0.04, 0.22916666666667
53914, 2.0541666666667, -0.04, 0.25
53915, 2.075, -0.06, 0.25
53916, 2.075, -0.08, 0.22916666666667
53917, 2.0541666666667, -0.08, 0.25
53918, 2.075, -0.1, 0.25
53919, 2.075, -0.12, 0.22916666666667
53920, 2.0541666666667, -0.12, 0.25
53921, 2.075, -0.14, 0.25
53922, 2.075, -0.16, 0.22916666666667
53923, 2.0541666666667, -0.16, 0.25
53924, 2.075, -0.18, 0.25
53925, 2.1166666666667, -0.02, 0.25
53926, 2.1166666666667, -0.04, 0.22916666666667
53927, 2.0958333333333, -0.04, 0.25
53928, 2.1166666666667, -0.06, 0.25
53929, 2.1166666666667, -0.08, 0.22916666666667
53930, 2.0958333333333, -0.08, 0.25
53931, 2.1166666666667, -0.1, 0.25
53932, 2.1166666666667, -0.12, 0.22916666666667
53933, 2.0958333333333, -0.12, 0.25
53934, 2.1166666666667, -0.14, 0.25
53935, 2.1166666666667, -0.16, 0.22916666666667
53936, 2.0958333333333, -0.16, 0.25
53937, 2.1166666666667, -0.18, 0.25
53938, 2.1583333333333, -0.02, 0.25
53939, 2.1583333333333, -0.04, 0.22916666666667
53940, 2.1375, -0.04, 0.25
53941, 2.1583333333333, -0.06, 0.25
53942, 2.1583333333333, -0.08, 0.22916666666667
53943, 2.1375, -0.08, 0.25
53944, 2.1583333333333, -0.1, 0.25
53945, 2.1583333333333, -0.12, 0.22916666666667
53946, 2.1375, -0.12, 0.25
53947, 2.1583333333333, -0.14, 0.25
53948, 2.1583333333333, -0.16, 0.22916666666667
53949, 2.1375, -0.16, 0.25
53950, 2.1583333333333, -0.18, 0.25
53951, 2.1791666666667, -0.04, 0.25
53952, 2.1791666666667, -0.08, 0.25
53953, 2.1791666666667, -0.12, 0.25
53954, 2.1791666666667, -0.16, 0.25
53955, 1.2416666666667, -0.02, 0.29166666666667
53956, 1.2416666666667, -0.04, 0.27083333333333
53957, 1.2208333333333, -0.04, 0.29166666666667
53958, 1.2416666666667, -0.06, 0.29166666666667
53959, 1.2416666666667, -0.08, 0.27083333333333
53960, 1.2208333333333, -0.08, 0.29166666666667
53961, 1.2416666666667, -0.1, 0.29166666666667
53962, 1.2416666666667, -0.12, 0.27083333333333
53963, 1.2208333333333, -0.12, 0.29166666666667
53964, 1.2416666666667, -0.14, 0.29166666666667
53965, 1.2416666666667, -0.16, 0.27083333333333
53966, 1.2208333333333, -0.16, 0.29166666666667
53967, 1.2416666666667, -0.18, 0.29166666666667
53968, 1.2833333333333, -0.02, 0.29166666666667
53969, 1.2833333333333, -0.04, 0.27083333333333
53970, 1.2625, -0.04, 0.29166666666667
53971, 1.2833333333333, -0.06, 0.29166666666667
53972, 1.2833333333333, -0.08, 0.27083333333333
53973, 1.2625, -0.08, 0.29166666666667
53974, 1.2833333333333, -0.1, 0.29166666666667
53975, 1.2833333333333, -0.12, 0.27083333333333
53976, 1.2625, -0.12, 0.29166666666667
53977, 1.2833333333333, -0.14, 0.29166666666667
53978, 1.2833333333333, -0.16, 0.27083333333333
53979, 1.2625, -0.16, 0.29166666666667
53980, 1.2833333333333, -0.18, 0.29166666666667
53981, 1.325, -0.02, 0.29166666666667
53982, 1.325, -0.04, 0.27083333333333
53983, 1.3041666666667, -0.04, 0.29166666666667
53984, 1.325, -0.06, 0.29166666666667
53985, 1.325, -0.08, 0.27083333333333
53986, 1.3041666666667, -0.08, 0.29166666666667
53987, 1.325, -0.1, 0.29166666666667
53988, 1.325, -0.12, 0.27083333333333
53989, 1.3041666666667, -0.12, 0.29166666666667
53990, 1.325, -0.14, 0.29166666666667
53991, 1.325, -0.16, 0.27083333333333
53992, 1.3041666666667, -0.16, 0.29166666666667
53993, 1.325, -0.18, 0.29166666666667
53994, 1.3666666666667, -0.02, 0.29166666666667
53995, 1.3666666666667, -0.04, 0.27083333333333
53996, 1.3458333333333, -0.04, 0.29166666666667
53997, 1.3666666666667, -0.06, 0.29166666666667
53998, 1.3666666666667, -0.08, 0.27083333333333
53999, 1.3458333333333, -0.08, 0.29166666666667
54000, 1.3666666666667, -0.1, 0.29166666666667
54001, 1.3666666666667, -0.12, 0.27083333333333
54002, 1.3458333333333, -0.12, 0.29166666666667
54003, 1.3666666666667, -0.14, 0.29166666666667
54004, 1.3666666666667, -0.16, 0.27083333333333
54005, 1.3458333333333, -0.16, 0.29166666666667
54006, 1.3666666666667, -0.18, 0.29166666666667
54007, 1.4083333333333, -0.02, 0.29166666666667
54008, 1.4083333333333, -0.04, 0.27083333333333
54009, 1.3875, -0.04, 0.29166666666667
54010, 1.4083333333333, -0.06, 0.29166666666667
54011, 1.4083333333333, -0.08, 0.27083333333333
54012, 1.3875, -0.08, 0.29166666666667
54013, 1.4083333333333, -0.1, 0.29166666666667
54014, 1.4083333333333, -0.12, 0.27083333333333
54015, 1.3875, -0.12, 0.29166666666667
54016, 1.4083333333333, -0.14, 0.29166666666667
54017, 1.4083333333333, -0.16, 0.27083333333333
54018, 1.3875, -0.16, 0.29166666666667
54019, 1.4083333333333, -0.18, 0.29166666666667
54020, 1.45, -0.02, 0.29166666666667
54021, 1.45, -0.04, 0.27083333333333
54022, 1.4291666666667, -0.04, 0.29166666666667
54023, 1.45, -0.06, 0.29166666666667
54024, 1.45, -0.08, 0.27083333333333
54025, 1.4291666666667, -0.08, 0.29166666666667
54026, 1.45, -0.1, 0.29166666666667
54027, 1.45, -0.12, 0.27083333333333
54028, 1.4291666666667, -0.12, 0.29166666666667
54029, 1.45, -0.14, 0.29166666666667
54030, 1.45, -0.16, 0.27083333333333
54031, 1.4291666666667, -0.16, 0.29166666666667
54032, 1.45, -0.18, 0.29166666666667
54033, 1.4916666666667, -0.02, 0.29166666666667
54034, 1.4916666666667, -0.04, 0.27083333333333
54035, 1.4708333333333, -0.04, 0.29166666666667
54036, 1.4916666666667, -0.06, 0.29166666666667
54037, 1.4916666666667, -0.08, 0.27083333333333
54038, 1.4708333333333, -0.08, 0.29166666666667
54039, 1.4916666666667, -0.1, 0.29166666666667
54040, 1.4916666666667, -0.12, 0.27083333333333
54041, 1.4708333333333, -0.12, 0.29166666666667
54042, 1.4916666666667, -0.14, 0.29166666666667
54043, 1.4916666666667, -0.16, 0.27083333333333
54044, 1.4708333333333, -0.16, 0.29166666666667
54045, 1.4916666666667, -0.18, 0.29166666666667
54046, 1.5333333333333, -0.02, 0.29166666666667
54047, 1.5333333333333, -0.04, 0.27083333333333
54048, 1.5125, -0.04, 0.29166666666667
54049, 1.5333333333333, -0.06, 0.29166666666667
54050, 1.5333333333333, -0.08, 0.27083333333333
54051, 1.5125, -0.08, 0.29166666666667
54052, 1.5333333333333, -0.1, 0.29166666666667
54053, 1.5333333333333, -0.12, 0.27083333333333
54054, 1.5125, -0.12, 0.29166666666667
54055, 1.5333333333333, -0.14, 0.29166666666667
54056, 1.5333333333333, -0.16, 0.27083333333333
54057, 1.5125, -0.16, 0.29166666666667
54058, 1.5333333333333, -0.18, 0.29166666666667
54059, 1.575, -0.02, 0.29166666666667
54060, 1.575, -0.04, 0.27083333333333
54061, 1.5541666666667, -0.04, 0.29166666666667
54062, 1.575, -0.06, 0.29166666666667
54063, 1.575, -0.08, 0.27083333333333
54064, 1.5541666666667, -0.08, 0.29166666666667
54065, 1.575, -0.1, 0.29166666666667
54066, 1.575, -0.12, 0.27083333333333
54067, 1.5541666666667, -0.12, 0.29166666666667
54068, 1.575, -0.14, 0.29166666666667
54069, 1.575, -0.16, 0.27083333333333
54070, 1.5541666666667, -0.16, 0.29166666666667
54071, 1.575, -0.18, 0.29166666666667
54072, 1.6166666666667, -0.02, 0.29166666666667
54073, 1.6166666666667, -0.04, 0.27083333333333
54074, 1.5958333333333, -0.04, 0.29166666666667
54075, 1.6166666666667, -0.06, 0.29166666666667
54076, 1.6166666666667, -0.08, 0.27083333333333
54077, 1.5958333333333, -0.08, 0.29166666666667
54078, 1.6166666666667, -0.1, 0.29166666666667
54079, 1.6166666666667, -0.12, 0.27083333333333
54080, 1.5958333333333, -0.12, 0.29166666666667
54081, 1.6166666666667, -0.14, 0.29166666666667
54082, 1.6166666666667, -0.16, 0.27083333333333
54083, 1.5958333333333, -0.16, 0.29166666666667
54084, 1.6166666666667, -0.18, 0.29166666666667
54085, 1.6583333333333, -0.02, 0.29166666666667
54086, 1.6583333333333, -0.04, 0.27083333333333
54087, 1.6375, -0.04, 0.29166666666667
54088, 1.6583333333333, -0.06, 0.29166666666667
54089, 1.6583333333333, -0.08, 0.27083333333333
54090, 1.6375, -0.08, 0.29166666666667
54091, 1.6583333333333, -0.1, 0.29166666666667
54092, 1.6583333333333, -0.12, 0.27083333333333
54093, 1.6375, -0.12, 0.29166666666667
54094, 1.6583333333333, -0.14, 0.29166666666667
54095, 1.6583333333333, -0.16, 0.27083333333333
54096, 1.6375, -0.16, 0.29166666666667
54097, 1.6583333333333, -0.18, 0.29166666666667
54098, 1.7, -0.02, 0.29166666666667
54099, 1.7, -0.04, 0.27083333333333
54100, 1.6791666666667, -0.04, 0.29166666666667
54101, 1.7, -0.06, 0.29166666666667
54102, 1.7, -0.08, 0.27083333333333
54103, 1.6791666666667, -0.08, 0.29166666666667
54104, 1.7, -0.1, 0.29166666666667
54105, 1.7, -0.12, 0.27083333333333
54106, 1.6791666666667, -0.12, 0.29166666666667
54107, 1.7, -0.14, 0.29166666666667
54108, 1.7, -0.16, 0.27083333333333
54109, 1.6791666666667, -0.16, 0.29166666666667
54110, 1.7, -0.18, 0.29166666666667
54111, 1.7416666666667, -0.02, 0.29166666666667
54112, 1.7416666666667, -0.04, 0.27083333333333
54113, 1.7208333333333, -0.04, 0.29166666666667
54114, 1.7416666666667, -0.06, 0.29166666666667
54115, 1.7416666666667, -0.08, 0.27083333333333
54116, 1.7208333333333, -0.08, 0.29166666666667
54117, 1.7416666666667, -0.1, 0.29166666666667
54118, 1.7416666666667, -0.12, 0.27083333333333
54119, 1.7208333333333, -0.12, 0.29166666666667
54120, 1.7416666666667, -0.14, 0.29166666666667
54121, 1.7416666666667, -0.16, 0.27083333333333
54122, 1.7208333333333, -0.16, 0.29166666666667
54123, 1.7416666666667, -0.18, 0.29166666666667
54124, 1.7833333333333, -0.02, 0.29166666666667
54125, 1.7833333333333, -0.04, 0.27083333333333
54126, 1.7625, -0.04, 0.29166666666667
54127, 1.7833333333333, -0.06, 0.29166666666667
54128, 1.7833333333333, -0.08, 0.27083333333333
54129, 1.7625, -0.08, 0.29166666666667
54130, 1.7833333333333, -0.1, 0.29166666666667
54131, 1.7833333333333, -0.12, 0.27083333333333
54132, 1.7625, -0.12, 0.29166666666667
54133, 1.7833333333333, -0.14, 0.29166666666667
54134, 1.7833333333333, -0.16, 0.27083333333333
54135, 1.7625, -0.16, 0.29166666666667
54136, 1.7833333333333, -0.18, 0.29166666666667
54137, 1.825, -0.02, 0.29166666666667
54138, 1.825, -0.04, 0.27083333333333
54139, 1.8041666666667, -0.04, 0.29166666666667
54140, 1.825, -0.06, 0.29166666666667
54141, 1.825, -0.08, 0.27083333333333
54142, 1.8041666666667, -0.08, 0.29166666666667
54143, 1.825, -0.1, 0.29166666666667
54144, 1.825, -0.12, 0.27083333333333
54145, 1.8041666666667, -0.12, 0.29166666666667
54146, 1.825, -0.14, 0.29166666666667
54147, 1.825, -0.16, 0.27083333333333
54148, 1.8041666666667, -0.16, 0.29166666666667
54149, 1.825, -0.18, 0.29166666666667
54150, 1.8666666666667, -0.02, 0.29166666666667
54151, 1.8666666666667, -0.04, 0.27083333333333
54152, 1.8458333333333, -0.04, 0.29166666666667
54153, 1.8666666666667, -0.06, 0.29166666666667
54154, 1.8666666666667, -0.08, 0.27083333333333
54155, 1.8458333333333, -0.08, 0.29166666666667
54156, 1.8666666666667, -0.1, 0.29166666666667
54157, 1.8666666666667, -0.12, 0.27083333333333
54158, 1.8458333333333, -0.12, 0.29166666666667
54159, 1.8666666666667, -0.14, 0.29166666666667
54160, 1.8666666666667, -0.16, 0.27083333333333
54161, 1.8458333333333, -0.16, 0.29166666666667
54162, 1.8666666666667, -0.18, 0.29166666666667
54163, 1.9083333333333, -0.02, 0.29166666666667
54164, 1.9083333333333, -0.04, 0.27083333333333
54165, 1.8875, -0.04, 0.29166666666667
54166, 1.9083333333333, -0.06, 0.29166666666667
54167, 1.9083333333333, -0.08, 0.27083333333333
54168, 1.8875, -0.08, 0.29166666666667
54169, 1.9083333333333, -0.1, 0.29166666666667
54170, 1.9083333333333, -0.12, 0.27083333333333
54171, 1.8875, -0.12, 0.29166666666667
54172, 1.9083333333333, -0.14, 0.29166666666667
54173, 1.9083333333333, -0.16, 0.27083333333333
54174, 1.8875, -0.16, 0.29166666666667
54175, 1.9083333333333, -0.18, 0.29166666666667
54176, 1.95, -0.02, 0.29166666666667
54177, 1.95, -0.04, 0.27083333333333
54178, 1.9291666666667, -0.04, 0.29166666666667
54179, 1.95, -0.06, 0.29166666666667
54180, 1.95, -0.08, 0.27083333333333
54181, 1.9291666666667, -0.08, 0.29166666666667
54182, 1.95, -0.1, 0.29166666666667
54183, 1.95, -0.12, 0.27083333333333
54184, 1.9291666666667, -0.12, 0.29166666666667
54185, 1.95, -0.14, 0.29166666666667
54186, 1.95, -0.16, 0.27083333333333
54187, 1.9291666666667, -0.16, 0.29166666666667
54188, 1.95, -0.18, 0.29166666666667
54189, 1.9916666666667, -0.02, 0.29166666666667
54190, 1.9916666666667, -0.04, 0.27083333333333
54191, 1.9708333333333, -0.04, 0.29166666666667
54192, 1.9916666666667, -0.06, 0.29166666666667
54193, 1.9916666666667, -0.08, 0.27083333333333
54194, 1.9708333333333, -0.08, 0.29166666666667
54195, 1.9916666666667, -0.1, 0.29166666666667
54196, 1.9916666666667, -0.12, 0.27083333333333
54197, 1.9708333333333, -0.12, 0.29166666666667
54198, 1.9916666666667, -0.14, 0.29166666666667
54199, 1.9916666666667, -0.16, 0.27083333333333
54200, 1.9708333333333, -0.16, 0.29166666666667
54201, 1.9916666666667, -0.18, 0.29166666666667
