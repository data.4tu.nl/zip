16552, 26926, 26949, 27478, 27455, 26927, 26950, 27479, 27456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16553, 26927, 26950, 27479, 27456, 26928, 26951, 27480, 27457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16554, 26928, 26951, 27480, 27457, 26929, 26952, 27481, 27458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16555, 26929, 26952, 27481, 27458, 26930, 26953, 27482, 27459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16556, 26930, 26953, 27482, 27459, 26931, 26954, 27483, 27460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16557, 26931, 26954, 27483, 27460, 8325, 8326, 8349, 8348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16558, 6509, 6510, 6533, 6532, 26932, 26955, 27484, 27461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16559, 26932, 26955, 27484, 27461, 26933, 26956, 27485, 27462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16560, 26933, 26956, 27485, 27462, 26934, 26957, 27486, 27463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16561, 26934, 26957, 27486, 27463, 26935, 26958, 27487, 27464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16562, 26935, 26958, 27487, 27464, 26936, 26959, 27488, 27465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16563, 26936, 26959, 27488, 27465, 26937, 26960, 27489, 27466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16564, 26937, 26960, 27489, 27466, 26938, 26961, 27490, 27467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16565, 26938, 26961, 27490, 27467, 26939, 26962, 27491, 27468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16566, 26939, 26962, 27491, 27468, 26940, 26963, 27492, 27469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16567, 26940, 26963, 27492, 27469, 26941, 26964, 27493, 27470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16568, 26941, 26964, 27493, 27470, 26942, 26965, 27494, 27471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16569, 26942, 26965, 27494, 27471, 26943, 26966, 27495, 27472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16570, 26943, 26966, 27495, 27472, 26944, 26967, 27496, 27473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16571, 26944, 26967, 27496, 27473, 26945, 26968, 27497, 27474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16572, 26945, 26968, 27497, 27474, 26946, 26969, 27498, 27475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16573, 26946, 26969, 27498, 27475, 26947, 26970, 27499, 27476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16574, 26947, 26970, 27499, 27476, 26948, 26971, 27500, 27477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16575, 26948, 26971, 27500, 27477, 26949, 26972, 27501, 27478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16576, 26949, 26972, 27501, 27478, 26950, 26973, 27502, 27479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16577, 26950, 26973, 27502, 27479, 26951, 26974, 27503, 27480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16578, 26951, 26974, 27503, 27480, 26952, 26975, 27504, 27481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16579, 26952, 26975, 27504, 27481, 26953, 26976, 27505, 27482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16580, 26953, 26976, 27505, 27482, 26954, 26977, 27506, 27483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16581, 26954, 26977, 27506, 27483, 8326, 8327, 8350, 8349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16582, 6510, 6511, 6534, 6533, 26955, 26978, 27507, 27484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16583, 26955, 26978, 27507, 27484, 26956, 26979, 27508, 27485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16584, 26956, 26979, 27508, 27485, 26957, 26980, 27509, 27486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16585, 26957, 26980, 27509, 27486, 26958, 26981, 27510, 27487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16586, 26958, 26981, 27510, 27487, 26959, 26982, 27511, 27488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16587, 26959, 26982, 27511, 27488, 26960, 26983, 27512, 27489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16588, 26960, 26983, 27512, 27489, 26961, 26984, 27513, 27490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16589, 26961, 26984, 27513, 27490, 26962, 26985, 27514, 27491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16590, 26962, 26985, 27514, 27491, 26963, 26986, 27515, 27492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16591, 26963, 26986, 27515, 27492, 26964, 26987, 27516, 27493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16592, 26964, 26987, 27516, 27493, 26965, 26988, 27517, 27494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16593, 26965, 26988, 27517, 27494, 26966, 26989, 27518, 27495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16594, 26966, 26989, 27518, 27495, 26967, 26990, 27519, 27496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16595, 26967, 26990, 27519, 27496, 26968, 26991, 27520, 27497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16596, 26968, 26991, 27520, 27497, 26969, 26992, 27521, 27498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16597, 26969, 26992, 27521, 27498, 26970, 26993, 27522, 27499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16598, 26970, 26993, 27522, 27499, 26971, 26994, 27523, 27500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16599, 26971, 26994, 27523, 27500, 26972, 26995, 27524, 27501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16600, 26972, 26995, 27524, 27501, 26973, 26996, 27525, 27502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16601, 26973, 26996, 27525, 27502, 26974, 26997, 27526, 27503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16602, 26974, 26997, 27526, 27503, 26975, 26998, 27527, 27504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16603, 26975, 26998, 27527, 27504, 26976, 26999, 27528, 27505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16604, 26976, 26999, 27528, 27505, 26977, 27000, 27529, 27506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16605, 26977, 27000, 27529, 27506, 8327, 8328, 8351, 8350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16606, 6511, 6512, 6535, 6534, 26978, 27001, 27530, 27507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16607, 26978, 27001, 27530, 27507, 26979, 27002, 27531, 27508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16608, 26979, 27002, 27531, 27508, 26980, 27003, 27532, 27509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16609, 26980, 27003, 27532, 27509, 26981, 27004, 27533, 27510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16610, 26981, 27004, 27533, 27510, 26982, 27005, 27534, 27511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16611, 26982, 27005, 27534, 27511, 26983, 27006, 27535, 27512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16612, 26983, 27006, 27535, 27512, 26984, 27007, 27536, 27513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16613, 26984, 27007, 27536, 27513, 26985, 27008, 27537, 27514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16614, 26985, 27008, 27537, 27514, 26986, 27009, 27538, 27515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16615, 26986, 27009, 27538, 27515, 26987, 27010, 27539, 27516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16616, 26987, 27010, 27539, 27516, 26988, 27011, 27540, 27517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16617, 26988, 27011, 27540, 27517, 26989, 27012, 27541, 27518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16618, 26989, 27012, 27541, 27518, 26990, 27013, 27542, 27519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16619, 26990, 27013, 27542, 27519, 26991, 27014, 27543, 27520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16620, 26991, 27014, 27543, 27520, 26992, 27015, 27544, 27521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16621, 26992, 27015, 27544, 27521, 26993, 27016, 27545, 27522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16622, 26993, 27016, 27545, 27522, 26994, 27017, 27546, 27523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16623, 26994, 27017, 27546, 27523, 26995, 27018, 27547, 27524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16624, 26995, 27018, 27547, 27524, 26996, 27019, 27548, 27525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16625, 26996, 27019, 27548, 27525, 26997, 27020, 27549, 27526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16626, 26997, 27020, 27549, 27526, 26998, 27021, 27550, 27527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16627, 26998, 27021, 27550, 27527, 26999, 27022, 27551, 27528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16628, 26999, 27022, 27551, 27528, 27000, 27023, 27552, 27529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16629, 27000, 27023, 27552, 27529, 8328, 8329, 8352, 8351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16630, 6512, 6513, 6536, 6535, 27001, 27024, 27553, 27530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16631, 27001, 27024, 27553, 27530, 27002, 27025, 27554, 27531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16632, 27002, 27025, 27554, 27531, 27003, 27026, 27555, 27532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16633, 27003, 27026, 27555, 27532, 27004, 27027, 27556, 27533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16634, 27004, 27027, 27556, 27533, 27005, 27028, 27557, 27534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16635, 27005, 27028, 27557, 27534, 27006, 27029, 27558, 27535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16636, 27006, 27029, 27558, 27535, 27007, 27030, 27559, 27536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16637, 27007, 27030, 27559, 27536, 27008, 27031, 27560, 27537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16638, 27008, 27031, 27560, 27537, 27009, 27032, 27561, 27538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16639, 27009, 27032, 27561, 27538, 27010, 27033, 27562, 27539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16640, 27010, 27033, 27562, 27539, 27011, 27034, 27563, 27540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16641, 27011, 27034, 27563, 27540, 27012, 27035, 27564, 27541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16642, 27012, 27035, 27564, 27541, 27013, 27036, 27565, 27542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16643, 27013, 27036, 27565, 27542, 27014, 27037, 27566, 27543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16644, 27014, 27037, 27566, 27543, 27015, 27038, 27567, 27544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16645, 27015, 27038, 27567, 27544, 27016, 27039, 27568, 27545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16646, 27016, 27039, 27568, 27545, 27017, 27040, 27569, 27546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16647, 27017, 27040, 27569, 27546, 27018, 27041, 27570, 27547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16648, 27018, 27041, 27570, 27547, 27019, 27042, 27571, 27548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16649, 27019, 27042, 27571, 27548, 27020, 27043, 27572, 27549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16650, 27020, 27043, 27572, 27549, 27021, 27044, 27573, 27550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16651, 27021, 27044, 27573, 27550, 27022, 27045, 27574, 27551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16652, 27022, 27045, 27574, 27551, 27023, 27046, 27575, 27552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16653, 27023, 27046, 27575, 27552, 8329, 8330, 8353, 8352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16654, 6513, 6514, 6537, 6536, 27024, 27047, 27576, 27553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16655, 27024, 27047, 27576, 27553, 27025, 27048, 27577, 27554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16656, 27025, 27048, 27577, 27554, 27026, 27049, 27578, 27555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16657, 27026, 27049, 27578, 27555, 27027, 27050, 27579, 27556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16658, 27027, 27050, 27579, 27556, 27028, 27051, 27580, 27557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16659, 27028, 27051, 27580, 27557, 27029, 27052, 27581, 27558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16660, 27029, 27052, 27581, 27558, 27030, 27053, 27582, 27559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16661, 27030, 27053, 27582, 27559, 27031, 27054, 27583, 27560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16662, 27031, 27054, 27583, 27560, 27032, 27055, 27584, 27561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16663, 27032, 27055, 27584, 27561, 27033, 27056, 27585, 27562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16664, 27033, 27056, 27585, 27562, 27034, 27057, 27586, 27563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16665, 27034, 27057, 27586, 27563, 27035, 27058, 27587, 27564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16666, 27035, 27058, 27587, 27564, 27036, 27059, 27588, 27565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16667, 27036, 27059, 27588, 27565, 27037, 27060, 27589, 27566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16668, 27037, 27060, 27589, 27566, 27038, 27061, 27590, 27567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16669, 27038, 27061, 27590, 27567, 27039, 27062, 27591, 27568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16670, 27039, 27062, 27591, 27568, 27040, 27063, 27592, 27569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16671, 27040, 27063, 27592, 27569, 27041, 27064, 27593, 27570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16672, 27041, 27064, 27593, 27570, 27042, 27065, 27594, 27571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16673, 27042, 27065, 27594, 27571, 27043, 27066, 27595, 27572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16674, 27043, 27066, 27595, 27572, 27044, 27067, 27596, 27573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16675, 27044, 27067, 27596, 27573, 27045, 27068, 27597, 27574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16676, 27045, 27068, 27597, 27574, 27046, 27069, 27598, 27575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16677, 27046, 27069, 27598, 27575, 8330, 8331, 8354, 8353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16678, 6514, 6515, 6538, 6537, 27047, 27070, 27599, 27576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16679, 27047, 27070, 27599, 27576, 27048, 27071, 27600, 27577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16680, 27048, 27071, 27600, 27577, 27049, 27072, 27601, 27578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16681, 27049, 27072, 27601, 27578, 27050, 27073, 27602, 27579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16682, 27050, 27073, 27602, 27579, 27051, 27074, 27603, 27580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16683, 27051, 27074, 27603, 27580, 27052, 27075, 27604, 27581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16684, 27052, 27075, 27604, 27581, 27053, 27076, 27605, 27582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16685, 27053, 27076, 27605, 27582, 27054, 27077, 27606, 27583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16686, 27054, 27077, 27606, 27583, 27055, 27078, 27607, 27584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16687, 27055, 27078, 27607, 27584, 27056, 27079, 27608, 27585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16688, 27056, 27079, 27608, 27585, 27057, 27080, 27609, 27586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16689, 27057, 27080, 27609, 27586, 27058, 27081, 27610, 27587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16690, 27058, 27081, 27610, 27587, 27059, 27082, 27611, 27588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16691, 27059, 27082, 27611, 27588, 27060, 27083, 27612, 27589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16692, 27060, 27083, 27612, 27589, 27061, 27084, 27613, 27590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16693, 27061, 27084, 27613, 27590, 27062, 27085, 27614, 27591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16694, 27062, 27085, 27614, 27591, 27063, 27086, 27615, 27592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16695, 27063, 27086, 27615, 27592, 27064, 27087, 27616, 27593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16696, 27064, 27087, 27616, 27593, 27065, 27088, 27617, 27594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16697, 27065, 27088, 27617, 27594, 27066, 27089, 27618, 27595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16698, 27066, 27089, 27618, 27595, 27067, 27090, 27619, 27596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16699, 27067, 27090, 27619, 27596, 27068, 27091, 27620, 27597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16700, 27068, 27091, 27620, 27597, 27069, 27092, 27621, 27598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16701, 27069, 27092, 27621, 27598, 8331, 8332, 8355, 8354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16702, 6515, 6516, 6539, 6538, 27070, 27093, 27622, 27599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16703, 27070, 27093, 27622, 27599, 27071, 27094, 27623, 27600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16704, 27071, 27094, 27623, 27600, 27072, 27095, 27624, 27601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16705, 27072, 27095, 27624, 27601, 27073, 27096, 27625, 27602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16706, 27073, 27096, 27625, 27602, 27074, 27097, 27626, 27603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16707, 27074, 27097, 27626, 27603, 27075, 27098, 27627, 27604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16708, 27075, 27098, 27627, 27604, 27076, 27099, 27628, 27605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16709, 27076, 27099, 27628, 27605, 27077, 27100, 27629, 27606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16710, 27077, 27100, 27629, 27606, 27078, 27101, 27630, 27607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16711, 27078, 27101, 27630, 27607, 27079, 27102, 27631, 27608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16712, 27079, 27102, 27631, 27608, 27080, 27103, 27632, 27609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16713, 27080, 27103, 27632, 27609, 27081, 27104, 27633, 27610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16714, 27081, 27104, 27633, 27610, 27082, 27105, 27634, 27611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16715, 27082, 27105, 27634, 27611, 27083, 27106, 27635, 27612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16716, 27083, 27106, 27635, 27612, 27084, 27107, 27636, 27613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16717, 27084, 27107, 27636, 27613, 27085, 27108, 27637, 27614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16718, 27085, 27108, 27637, 27614, 27086, 27109, 27638, 27615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16719, 27086, 27109, 27638, 27615, 27087, 27110, 27639, 27616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16720, 27087, 27110, 27639, 27616, 27088, 27111, 27640, 27617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16721, 27088, 27111, 27640, 27617, 27089, 27112, 27641, 27618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16722, 27089, 27112, 27641, 27618, 27090, 27113, 27642, 27619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16723, 27090, 27113, 27642, 27619, 27091, 27114, 27643, 27620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16724, 27091, 27114, 27643, 27620, 27092, 27115, 27644, 27621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16725, 27092, 27115, 27644, 27621, 8332, 8333, 8356, 8355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16726, 6516, 6517, 6540, 6539, 27093, 27116, 27645, 27622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16727, 27093, 27116, 27645, 27622, 27094, 27117, 27646, 27623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16728, 27094, 27117, 27646, 27623, 27095, 27118, 27647, 27624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16729, 27095, 27118, 27647, 27624, 27096, 27119, 27648, 27625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16730, 27096, 27119, 27648, 27625, 27097, 27120, 27649, 27626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16731, 27097, 27120, 27649, 27626, 27098, 27121, 27650, 27627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16732, 27098, 27121, 27650, 27627, 27099, 27122, 27651, 27628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16733, 27099, 27122, 27651, 27628, 27100, 27123, 27652, 27629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16734, 27100, 27123, 27652, 27629, 27101, 27124, 27653, 27630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16735, 27101, 27124, 27653, 27630, 27102, 27125, 27654, 27631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16736, 27102, 27125, 27654, 27631, 27103, 27126, 27655, 27632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16737, 27103, 27126, 27655, 27632, 27104, 27127, 27656, 27633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16738, 27104, 27127, 27656, 27633, 27105, 27128, 27657, 27634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16739, 27105, 27128, 27657, 27634, 27106, 27129, 27658, 27635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16740, 27106, 27129, 27658, 27635, 27107, 27130, 27659, 27636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16741, 27107, 27130, 27659, 27636, 27108, 27131, 27660, 27637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16742, 27108, 27131, 27660, 27637, 27109, 27132, 27661, 27638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16743, 27109, 27132, 27661, 27638, 27110, 27133, 27662, 27639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16744, 27110, 27133, 27662, 27639, 27111, 27134, 27663, 27640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16745, 27111, 27134, 27663, 27640, 27112, 27135, 27664, 27641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16746, 27112, 27135, 27664, 27641, 27113, 27136, 27665, 27642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16747, 27113, 27136, 27665, 27642, 27114, 27137, 27666, 27643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16748, 27114, 27137, 27666, 27643, 27115, 27138, 27667, 27644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16749, 27115, 27138, 27667, 27644, 8333, 8334, 8357, 8356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16750, 6517, 6518, 6541, 6540, 27116, 27139, 27668, 27645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16751, 27116, 27139, 27668, 27645, 27117, 27140, 27669, 27646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16752, 27117, 27140, 27669, 27646, 27118, 27141, 27670, 27647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16753, 27118, 27141, 27670, 27647, 27119, 27142, 27671, 27648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16754, 27119, 27142, 27671, 27648, 27120, 27143, 27672, 27649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16755, 27120, 27143, 27672, 27649, 27121, 27144, 27673, 27650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16756, 27121, 27144, 27673, 27650, 27122, 27145, 27674, 27651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16757, 27122, 27145, 27674, 27651, 27123, 27146, 27675, 27652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16758, 27123, 27146, 27675, 27652, 27124, 27147, 27676, 27653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16759, 27124, 27147, 27676, 27653, 27125, 27148, 27677, 27654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16760, 27125, 27148, 27677, 27654, 27126, 27149, 27678, 27655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16761, 27126, 27149, 27678, 27655, 27127, 27150, 27679, 27656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16762, 27127, 27150, 27679, 27656, 27128, 27151, 27680, 27657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16763, 27128, 27151, 27680, 27657, 27129, 27152, 27681, 27658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16764, 27129, 27152, 27681, 27658, 27130, 27153, 27682, 27659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16765, 27130, 27153, 27682, 27659, 27131, 27154, 27683, 27660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16766, 27131, 27154, 27683, 27660, 27132, 27155, 27684, 27661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16767, 27132, 27155, 27684, 27661, 27133, 27156, 27685, 27662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16768, 27133, 27156, 27685, 27662, 27134, 27157, 27686, 27663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16769, 27134, 27157, 27686, 27663, 27135, 27158, 27687, 27664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16770, 27135, 27158, 27687, 27664, 27136, 27159, 27688, 27665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16771, 27136, 27159, 27688, 27665, 27137, 27160, 27689, 27666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16772, 27137, 27160, 27689, 27666, 27138, 27161, 27690, 27667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16773, 27138, 27161, 27690, 27667, 8334, 8335, 8358, 8357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16774, 6518, 6519, 6542, 6541, 27139, 27162, 27691, 27668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16775, 27139, 27162, 27691, 27668, 27140, 27163, 27692, 27669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16776, 27140, 27163, 27692, 27669, 27141, 27164, 27693, 27670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16777, 27141, 27164, 27693, 27670, 27142, 27165, 27694, 27671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16778, 27142, 27165, 27694, 27671, 27143, 27166, 27695, 27672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16779, 27143, 27166, 27695, 27672, 27144, 27167, 27696, 27673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16780, 27144, 27167, 27696, 27673, 27145, 27168, 27697, 27674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16781, 27145, 27168, 27697, 27674, 27146, 27169, 27698, 27675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16782, 27146, 27169, 27698, 27675, 27147, 27170, 27699, 27676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16783, 27147, 27170, 27699, 27676, 27148, 27171, 27700, 27677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16784, 27148, 27171, 27700, 27677, 27149, 27172, 27701, 27678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16785, 27149, 27172, 27701, 27678, 27150, 27173, 27702, 27679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16786, 27150, 27173, 27702, 27679, 27151, 27174, 27703, 27680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16787, 27151, 27174, 27703, 27680, 27152, 27175, 27704, 27681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16788, 27152, 27175, 27704, 27681, 27153, 27176, 27705, 27682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16789, 27153, 27176, 27705, 27682, 27154, 27177, 27706, 27683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16790, 27154, 27177, 27706, 27683, 27155, 27178, 27707, 27684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16791, 27155, 27178, 27707, 27684, 27156, 27179, 27708, 27685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16792, 27156, 27179, 27708, 27685, 27157, 27180, 27709, 27686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16793, 27157, 27180, 27709, 27686, 27158, 27181, 27710, 27687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16794, 27158, 27181, 27710, 27687, 27159, 27182, 27711, 27688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16795, 27159, 27182, 27711, 27688, 27160, 27183, 27712, 27689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16796, 27160, 27183, 27712, 27689, 27161, 27184, 27713, 27690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16797, 27161, 27184, 27713, 27690, 8335, 8336, 8359, 8358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16798, 6519, 6520, 6543, 6542, 27162, 27185, 27714, 27691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16799, 27162, 27185, 27714, 27691, 27163, 27186, 27715, 27692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16800, 27163, 27186, 27715, 27692, 27164, 27187, 27716, 27693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16801, 27164, 27187, 27716, 27693, 27165, 27188, 27717, 27694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16802, 27165, 27188, 27717, 27694, 27166, 27189, 27718, 27695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16803, 27166, 27189, 27718, 27695, 27167, 27190, 27719, 27696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16804, 27167, 27190, 27719, 27696, 27168, 27191, 27720, 27697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16805, 27168, 27191, 27720, 27697, 27169, 27192, 27721, 27698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16806, 27169, 27192, 27721, 27698, 27170, 27193, 27722, 27699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16807, 27170, 27193, 27722, 27699, 27171, 27194, 27723, 27700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16808, 27171, 27194, 27723, 27700, 27172, 27195, 27724, 27701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16809, 27172, 27195, 27724, 27701, 27173, 27196, 27725, 27702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16810, 27173, 27196, 27725, 27702, 27174, 27197, 27726, 27703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16811, 27174, 27197, 27726, 27703, 27175, 27198, 27727, 27704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16812, 27175, 27198, 27727, 27704, 27176, 27199, 27728, 27705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16813, 27176, 27199, 27728, 27705, 27177, 27200, 27729, 27706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16814, 27177, 27200, 27729, 27706, 27178, 27201, 27730, 27707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16815, 27178, 27201, 27730, 27707, 27179, 27202, 27731, 27708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16816, 27179, 27202, 27731, 27708, 27180, 27203, 27732, 27709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16817, 27180, 27203, 27732, 27709, 27181, 27204, 27733, 27710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16818, 27181, 27204, 27733, 27710, 27182, 27205, 27734, 27711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16819, 27182, 27205, 27734, 27711, 27183, 27206, 27735, 27712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16820, 27183, 27206, 27735, 27712, 27184, 27207, 27736, 27713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16821, 27184, 27207, 27736, 27713, 8336, 8337, 8360, 8359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16822, 6520, 6521, 6544, 6543, 27185, 27208, 27737, 27714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16823, 27185, 27208, 27737, 27714, 27186, 27209, 27738, 27715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16824, 27186, 27209, 27738, 27715, 27187, 27210, 27739, 27716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16825, 27187, 27210, 27739, 27716, 27188, 27211, 27740, 27717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16826, 27188, 27211, 27740, 27717, 27189, 27212, 27741, 27718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16827, 27189, 27212, 27741, 27718, 27190, 27213, 27742, 27719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16828, 27190, 27213, 27742, 27719, 27191, 27214, 27743, 27720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16829, 27191, 27214, 27743, 27720, 27192, 27215, 27744, 27721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16830, 27192, 27215, 27744, 27721, 27193, 27216, 27745, 27722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16831, 27193, 27216, 27745, 27722, 27194, 27217, 27746, 27723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16832, 27194, 27217, 27746, 27723, 27195, 27218, 27747, 27724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16833, 27195, 27218, 27747, 27724, 27196, 27219, 27748, 27725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16834, 27196, 27219, 27748, 27725, 27197, 27220, 27749, 27726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16835, 27197, 27220, 27749, 27726, 27198, 27221, 27750, 27727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16836, 27198, 27221, 27750, 27727, 27199, 27222, 27751, 27728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16837, 27199, 27222, 27751, 27728, 27200, 27223, 27752, 27729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16838, 27200, 27223, 27752, 27729, 27201, 27224, 27753, 27730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16839, 27201, 27224, 27753, 27730, 27202, 27225, 27754, 27731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16840, 27202, 27225, 27754, 27731, 27203, 27226, 27755, 27732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16841, 27203, 27226, 27755, 27732, 27204, 27227, 27756, 27733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16842, 27204, 27227, 27756, 27733, 27205, 27228, 27757, 27734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16843, 27205, 27228, 27757, 27734, 27206, 27229, 27758, 27735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16844, 27206, 27229, 27758, 27735, 27207, 27230, 27759, 27736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16845, 27207, 27230, 27759, 27736, 8337, 8338, 8361, 8360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16846, 6521, 6522, 6545, 6544, 27208, 27231, 27760, 27737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16847, 27208, 27231, 27760, 27737, 27209, 27232, 27761, 27738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16848, 27209, 27232, 27761, 27738, 27210, 27233, 27762, 27739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16849, 27210, 27233, 27762, 27739, 27211, 27234, 27763, 27740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16850, 27211, 27234, 27763, 27740, 27212, 27235, 27764, 27741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16851, 27212, 27235, 27764, 27741, 27213, 27236, 27765, 27742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16852, 27213, 27236, 27765, 27742, 27214, 27237, 27766, 27743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16853, 27214, 27237, 27766, 27743, 27215, 27238, 27767, 27744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16854, 27215, 27238, 27767, 27744, 27216, 27239, 27768, 27745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16855, 27216, 27239, 27768, 27745, 27217, 27240, 27769, 27746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16856, 27217, 27240, 27769, 27746, 27218, 27241, 27770, 27747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16857, 27218, 27241, 27770, 27747, 27219, 27242, 27771, 27748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16858, 27219, 27242, 27771, 27748, 27220, 27243, 27772, 27749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16859, 27220, 27243, 27772, 27749, 27221, 27244, 27773, 27750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16860, 27221, 27244, 27773, 27750, 27222, 27245, 27774, 27751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16861, 27222, 27245, 27774, 27751, 27223, 27246, 27775, 27752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16862, 27223, 27246, 27775, 27752, 27224, 27247, 27776, 27753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16863, 27224, 27247, 27776, 27753, 27225, 27248, 27777, 27754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16864, 27225, 27248, 27777, 27754, 27226, 27249, 27778, 27755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16865, 27226, 27249, 27778, 27755, 27227, 27250, 27779, 27756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16866, 27227, 27250, 27779, 27756, 27228, 27251, 27780, 27757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16867, 27228, 27251, 27780, 27757, 27229, 27252, 27781, 27758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16868, 27229, 27252, 27781, 27758, 27230, 27253, 27782, 27759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16869, 27230, 27253, 27782, 27759, 8338, 8339, 8362, 8361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16870, 6522, 6523, 6546, 6545, 27231, 27254, 27783, 27760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16871, 27231, 27254, 27783, 27760, 27232, 27255, 27784, 27761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16872, 27232, 27255, 27784, 27761, 27233, 27256, 27785, 27762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16873, 27233, 27256, 27785, 27762, 27234, 27257, 27786, 27763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16874, 27234, 27257, 27786, 27763, 27235, 27258, 27787, 27764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16875, 27235, 27258, 27787, 27764, 27236, 27259, 27788, 27765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16876, 27236, 27259, 27788, 27765, 27237, 27260, 27789, 27766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16877, 27237, 27260, 27789, 27766, 27238, 27261, 27790, 27767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16878, 27238, 27261, 27790, 27767, 27239, 27262, 27791, 27768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16879, 27239, 27262, 27791, 27768, 27240, 27263, 27792, 27769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16880, 27240, 27263, 27792, 27769, 27241, 27264, 27793, 27770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16881, 27241, 27264, 27793, 27770, 27242, 27265, 27794, 27771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16882, 27242, 27265, 27794, 27771, 27243, 27266, 27795, 27772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16883, 27243, 27266, 27795, 27772, 27244, 27267, 27796, 27773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16884, 27244, 27267, 27796, 27773, 27245, 27268, 27797, 27774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16885, 27245, 27268, 27797, 27774, 27246, 27269, 27798, 27775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16886, 27246, 27269, 27798, 27775, 27247, 27270, 27799, 27776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16887, 27247, 27270, 27799, 27776, 27248, 27271, 27800, 27777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16888, 27248, 27271, 27800, 27777, 27249, 27272, 27801, 27778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16889, 27249, 27272, 27801, 27778, 27250, 27273, 27802, 27779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16890, 27250, 27273, 27802, 27779, 27251, 27274, 27803, 27780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16891, 27251, 27274, 27803, 27780, 27252, 27275, 27804, 27781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16892, 27252, 27275, 27804, 27781, 27253, 27276, 27805, 27782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16893, 27253, 27276, 27805, 27782, 8339, 8340, 8363, 8362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16894, 6523, 6524, 6547, 6546, 27254, 27277, 27806, 27783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16895, 27254, 27277, 27806, 27783, 27255, 27278, 27807, 27784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16896, 27255, 27278, 27807, 27784, 27256, 27279, 27808, 27785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16897, 27256, 27279, 27808, 27785, 27257, 27280, 27809, 27786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16898, 27257, 27280, 27809, 27786, 27258, 27281, 27810, 27787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16899, 27258, 27281, 27810, 27787, 27259, 27282, 27811, 27788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16900, 27259, 27282, 27811, 27788, 27260, 27283, 27812, 27789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16901, 27260, 27283, 27812, 27789, 27261, 27284, 27813, 27790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16902, 27261, 27284, 27813, 27790, 27262, 27285, 27814, 27791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16903, 27262, 27285, 27814, 27791, 27263, 27286, 27815, 27792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16904, 27263, 27286, 27815, 27792, 27264, 27287, 27816, 27793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16905, 27264, 27287, 27816, 27793, 27265, 27288, 27817, 27794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16906, 27265, 27288, 27817, 27794, 27266, 27289, 27818, 27795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16907, 27266, 27289, 27818, 27795, 27267, 27290, 27819, 27796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16908, 27267, 27290, 27819, 27796, 27268, 27291, 27820, 27797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16909, 27268, 27291, 27820, 27797, 27269, 27292, 27821, 27798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16910, 27269, 27292, 27821, 27798, 27270, 27293, 27822, 27799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16911, 27270, 27293, 27822, 27799, 27271, 27294, 27823, 27800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16912, 27271, 27294, 27823, 27800, 27272, 27295, 27824, 27801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16913, 27272, 27295, 27824, 27801, 27273, 27296, 27825, 27802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16914, 27273, 27296, 27825, 27802, 27274, 27297, 27826, 27803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16915, 27274, 27297, 27826, 27803, 27275, 27298, 27827, 27804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16916, 27275, 27298, 27827, 27804, 27276, 27299, 27828, 27805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16917, 27276, 27299, 27828, 27805, 8340, 8341, 8364, 8363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16918, 6524, 6525, 6548, 6547, 27277, 27300, 27829, 27806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16919, 27277, 27300, 27829, 27806, 27278, 27301, 27830, 27807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16920, 27278, 27301, 27830, 27807, 27279, 27302, 27831, 27808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16921, 27279, 27302, 27831, 27808, 27280, 27303, 27832, 27809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16922, 27280, 27303, 27832, 27809, 27281, 27304, 27833, 27810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16923, 27281, 27304, 27833, 27810, 27282, 27305, 27834, 27811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16924, 27282, 27305, 27834, 27811, 27283, 27306, 27835, 27812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16925, 27283, 27306, 27835, 27812, 27284, 27307, 27836, 27813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16926, 27284, 27307, 27836, 27813, 27285, 27308, 27837, 27814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16927, 27285, 27308, 27837, 27814, 27286, 27309, 27838, 27815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16928, 27286, 27309, 27838, 27815, 27287, 27310, 27839, 27816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16929, 27287, 27310, 27839, 27816, 27288, 27311, 27840, 27817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16930, 27288, 27311, 27840, 27817, 27289, 27312, 27841, 27818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16931, 27289, 27312, 27841, 27818, 27290, 27313, 27842, 27819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16932, 27290, 27313, 27842, 27819, 27291, 27314, 27843, 27820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16933, 27291, 27314, 27843, 27820, 27292, 27315, 27844, 27821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16934, 27292, 27315, 27844, 27821, 27293, 27316, 27845, 27822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16935, 27293, 27316, 27845, 27822, 27294, 27317, 27846, 27823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16936, 27294, 27317, 27846, 27823, 27295, 27318, 27847, 27824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16937, 27295, 27318, 27847, 27824, 27296, 27319, 27848, 27825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16938, 27296, 27319, 27848, 27825, 27297, 27320, 27849, 27826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16939, 27297, 27320, 27849, 27826, 27298, 27321, 27850, 27827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16940, 27298, 27321, 27850, 27827, 27299, 27322, 27851, 27828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16941, 27299, 27322, 27851, 27828, 8341, 8342, 8365, 8364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16942, 6525, 6526, 6549, 6548, 27300, 27323, 27852, 27829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16943, 27300, 27323, 27852, 27829, 27301, 27324, 27853, 27830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16944, 27301, 27324, 27853, 27830, 27302, 27325, 27854, 27831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16945, 27302, 27325, 27854, 27831, 27303, 27326, 27855, 27832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16946, 27303, 27326, 27855, 27832, 27304, 27327, 27856, 27833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16947, 27304, 27327, 27856, 27833, 27305, 27328, 27857, 27834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16948, 27305, 27328, 27857, 27834, 27306, 27329, 27858, 27835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16949, 27306, 27329, 27858, 27835, 27307, 27330, 27859, 27836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16950, 27307, 27330, 27859, 27836, 27308, 27331, 27860, 27837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16951, 27308, 27331, 27860, 27837, 27309, 27332, 27861, 27838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16952, 27309, 27332, 27861, 27838, 27310, 27333, 27862, 27839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16953, 27310, 27333, 27862, 27839, 27311, 27334, 27863, 27840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16954, 27311, 27334, 27863, 27840, 27312, 27335, 27864, 27841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16955, 27312, 27335, 27864, 27841, 27313, 27336, 27865, 27842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16956, 27313, 27336, 27865, 27842, 27314, 27337, 27866, 27843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16957, 27314, 27337, 27866, 27843, 27315, 27338, 27867, 27844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16958, 27315, 27338, 27867, 27844, 27316, 27339, 27868, 27845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16959, 27316, 27339, 27868, 27845, 27317, 27340, 27869, 27846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16960, 27317, 27340, 27869, 27846, 27318, 27341, 27870, 27847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16961, 27318, 27341, 27870, 27847, 27319, 27342, 27871, 27848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16962, 27319, 27342, 27871, 27848, 27320, 27343, 27872, 27849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16963, 27320, 27343, 27872, 27849, 27321, 27344, 27873, 27850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16964, 27321, 27344, 27873, 27850, 27322, 27345, 27874, 27851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16965, 27322, 27345, 27874, 27851, 8342, 8343, 8366, 8365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16966, 6526, 6527, 6550, 6549, 27323, 27346, 27875, 27852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16967, 27323, 27346, 27875, 27852, 27324, 27347, 27876, 27853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16968, 27324, 27347, 27876, 27853, 27325, 27348, 27877, 27854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16969, 27325, 27348, 27877, 27854, 27326, 27349, 27878, 27855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16970, 27326, 27349, 27878, 27855, 27327, 27350, 27879, 27856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16971, 27327, 27350, 27879, 27856, 27328, 27351, 27880, 27857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16972, 27328, 27351, 27880, 27857, 27329, 27352, 27881, 27858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16973, 27329, 27352, 27881, 27858, 27330, 27353, 27882, 27859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16974, 27330, 27353, 27882, 27859, 27331, 27354, 27883, 27860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16975, 27331, 27354, 27883, 27860, 27332, 27355, 27884, 27861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16976, 27332, 27355, 27884, 27861, 27333, 27356, 27885, 27862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16977, 27333, 27356, 27885, 27862, 27334, 27357, 27886, 27863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16978, 27334, 27357, 27886, 27863, 27335, 27358, 27887, 27864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16979, 27335, 27358, 27887, 27864, 27336, 27359, 27888, 27865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16980, 27336, 27359, 27888, 27865, 27337, 27360, 27889, 27866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16981, 27337, 27360, 27889, 27866, 27338, 27361, 27890, 27867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16982, 27338, 27361, 27890, 27867, 27339, 27362, 27891, 27868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16983, 27339, 27362, 27891, 27868, 27340, 27363, 27892, 27869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16984, 27340, 27363, 27892, 27869, 27341, 27364, 27893, 27870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16985, 27341, 27364, 27893, 27870, 27342, 27365, 27894, 27871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16986, 27342, 27365, 27894, 27871, 27343, 27366, 27895, 27872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16987, 27343, 27366, 27895, 27872, 27344, 27367, 27896, 27873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16988, 27344, 27367, 27896, 27873, 27345, 27368, 27897, 27874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16989, 27345, 27368, 27897, 27874, 8343, 8344, 8367, 8366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16990, 6527, 6528, 6551, 6550, 27346, 27369, 27898, 27875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16991, 27346, 27369, 27898, 27875, 27347, 27370, 27899, 27876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16992, 27347, 27370, 27899, 27876, 27348, 27371, 27900, 27877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16993, 27348, 27371, 27900, 27877, 27349, 27372, 27901, 27878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16994, 27349, 27372, 27901, 27878, 27350, 27373, 27902, 27879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16995, 27350, 27373, 27902, 27879, 27351, 27374, 27903, 27880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16996, 27351, 27374, 27903, 27880, 27352, 27375, 27904, 27881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16997, 27352, 27375, 27904, 27881, 27353, 27376, 27905, 27882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16998, 27353, 27376, 27905, 27882, 27354, 27377, 27906, 27883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16999, 27354, 27377, 27906, 27883, 27355, 27378, 27907, 27884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17000, 27355, 27378, 27907, 27884, 27356, 27379, 27908, 27885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17001, 27356, 27379, 27908, 27885, 27357, 27380, 27909, 27886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17002, 27357, 27380, 27909, 27886, 27358, 27381, 27910, 27887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17003, 27358, 27381, 27910, 27887, 27359, 27382, 27911, 27888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17004, 27359, 27382, 27911, 27888, 27360, 27383, 27912, 27889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17005, 27360, 27383, 27912, 27889, 27361, 27384, 27913, 27890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17006, 27361, 27384, 27913, 27890, 27362, 27385, 27914, 27891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17007, 27362, 27385, 27914, 27891, 27363, 27386, 27915, 27892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17008, 27363, 27386, 27915, 27892, 27364, 27387, 27916, 27893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17009, 27364, 27387, 27916, 27893, 27365, 27388, 27917, 27894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17010, 27365, 27388, 27917, 27894, 27366, 27389, 27918, 27895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17011, 27366, 27389, 27918, 27895, 27367, 27390, 27919, 27896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17012, 27367, 27390, 27919, 27896, 27368, 27391, 27920, 27897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17013, 27368, 27391, 27920, 27897, 8344, 8345, 8368, 8367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17014, 6528, 6529, 6552, 6551, 27369, 27392, 27921, 27898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17015, 27369, 27392, 27921, 27898, 27370, 27393, 27922, 27899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17016, 27370, 27393, 27922, 27899, 27371, 27394, 27923, 27900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17017, 27371, 27394, 27923, 27900, 27372, 27395, 27924, 27901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17018, 27372, 27395, 27924, 27901, 27373, 27396, 27925, 27902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17019, 27373, 27396, 27925, 27902, 27374, 27397, 27926, 27903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17020, 27374, 27397, 27926, 27903, 27375, 27398, 27927, 27904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17021, 27375, 27398, 27927, 27904, 27376, 27399, 27928, 27905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17022, 27376, 27399, 27928, 27905, 27377, 27400, 27929, 27906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17023, 27377, 27400, 27929, 27906, 27378, 27401, 27930, 27907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17024, 27378, 27401, 27930, 27907, 27379, 27402, 27931, 27908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17025, 27379, 27402, 27931, 27908, 27380, 27403, 27932, 27909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17026, 27380, 27403, 27932, 27909, 27381, 27404, 27933, 27910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17027, 27381, 27404, 27933, 27910, 27382, 27405, 27934, 27911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17028, 27382, 27405, 27934, 27911, 27383, 27406, 27935, 27912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17029, 27383, 27406, 27935, 27912, 27384, 27407, 27936, 27913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17030, 27384, 27407, 27936, 27913, 27385, 27408, 27937, 27914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17031, 27385, 27408, 27937, 27914, 27386, 27409, 27938, 27915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17032, 27386, 27409, 27938, 27915, 27387, 27410, 27939, 27916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17033, 27387, 27410, 27939, 27916, 27388, 27411, 27940, 27917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17034, 27388, 27411, 27940, 27917, 27389, 27412, 27941, 27918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17035, 27389, 27412, 27941, 27918, 27390, 27413, 27942, 27919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17036, 27390, 27413, 27942, 27919, 27391, 27414, 27943, 27920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17037, 27391, 27414, 27943, 27920, 8345, 8346, 8369, 8368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17038, 6529, 6530, 6553, 6552, 27392, 27415, 27944, 27921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17039, 27392, 27415, 27944, 27921, 27393, 27416, 27945, 27922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17040, 27393, 27416, 27945, 27922, 27394, 27417, 27946, 27923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17041, 27394, 27417, 27946, 27923, 27395, 27418, 27947, 27924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17042, 27395, 27418, 27947, 27924, 27396, 27419, 27948, 27925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17043, 27396, 27419, 27948, 27925, 27397, 27420, 27949, 27926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17044, 27397, 27420, 27949, 27926, 27398, 27421, 27950, 27927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17045, 27398, 27421, 27950, 27927, 27399, 27422, 27951, 27928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17046, 27399, 27422, 27951, 27928, 27400, 27423, 27952, 27929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17047, 27400, 27423, 27952, 27929, 27401, 27424, 27953, 27930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17048, 27401, 27424, 27953, 27930, 27402, 27425, 27954, 27931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17049, 27402, 27425, 27954, 27931, 27403, 27426, 27955, 27932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17050, 27403, 27426, 27955, 27932, 27404, 27427, 27956, 27933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17051, 27404, 27427, 27956, 27933, 27405, 27428, 27957, 27934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17052, 27405, 27428, 27957, 27934, 27406, 27429, 27958, 27935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17053, 27406, 27429, 27958, 27935, 27407, 27430, 27959, 27936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17054, 27407, 27430, 27959, 27936, 27408, 27431, 27960, 27937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17055, 27408, 27431, 27960, 27937, 27409, 27432, 27961, 27938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17056, 27409, 27432, 27961, 27938, 27410, 27433, 27962, 27939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17057, 27410, 27433, 27962, 27939, 27411, 27434, 27963, 27940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17058, 27411, 27434, 27963, 27940, 27412, 27435, 27964, 27941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17059, 27412, 27435, 27964, 27941, 27413, 27436, 27965, 27942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17060, 27413, 27436, 27965, 27942, 27414, 27437, 27966, 27943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17061, 27414, 27437, 27966, 27943, 8346, 8347, 8370, 8369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17062, 6530, 831, 832, 6553, 27415, 8072, 8095, 27944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17063, 27415, 8072, 8095, 27944, 27416, 8073, 8096, 27945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17064, 27416, 8073, 8096, 27945, 27417, 8074, 8097, 27946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17065, 27417, 8074, 8097, 27946, 27418, 8075, 8098, 27947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17066, 27418, 8075, 8098, 27947, 27419, 8076, 8099, 27948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17067, 27419, 8076, 8099, 27948, 27420, 8077, 8100, 27949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17068, 27420, 8077, 8100, 27949, 27421, 8078, 8101, 27950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17069, 27421, 8078, 8101, 27950, 27422, 8079, 8102, 27951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17070, 27422, 8079, 8102, 27951, 27423, 8080, 8103, 27952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17071, 27423, 8080, 8103, 27952, 27424, 8081, 8104, 27953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17072, 27424, 8081, 8104, 27953, 27425, 8082, 8105, 27954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17073, 27425, 8082, 8105, 27954, 27426, 8083, 8106, 27955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17074, 27426, 8083, 8106, 27955, 27427, 8084, 8107, 27956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17075, 27427, 8084, 8107, 27956, 27428, 8085, 8108, 27957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17076, 27428, 8085, 8108, 27957, 27429, 8086, 8109, 27958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17077, 27429, 8086, 8109, 27958, 27430, 8087, 8110, 27959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17078, 27430, 8087, 8110, 27959, 27431, 8088, 8111, 27960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17079, 27431, 8088, 8111, 27960, 27432, 8089, 8112, 27961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17080, 27432, 8089, 8112, 27961, 27433, 8090, 8113, 27962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17081, 27433, 8090, 8113, 27962, 27434, 8091, 8114, 27963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17082, 27434, 8091, 8114, 27963, 27435, 8092, 8115, 27964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17083, 27435, 8092, 8115, 27964, 27436, 8093, 8116, 27965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17084, 27436, 8093, 8116, 27965, 27437, 8094, 8117, 27966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17085, 27437, 8094, 8117, 27966, 8347, 991, 992, 8370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17086, 821, 6531, 6554, 822, 7842, 27438, 27967, 7865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17087, 7842, 27438, 27967, 7865, 7843, 27439, 27968, 7866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17088, 7843, 27439, 27968, 7866, 7844, 27440, 27969, 7867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17089, 7844, 27440, 27969, 7867, 7845, 27441, 27970, 7868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17090, 7845, 27441, 27970, 7868, 7846, 27442, 27971, 7869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17091, 7846, 27442, 27971, 7869, 7847, 27443, 27972, 7870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17092, 7847, 27443, 27972, 7870, 7848, 27444, 27973, 7871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17093, 7848, 27444, 27973, 7871, 7849, 27445, 27974, 7872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17094, 7849, 27445, 27974, 7872, 7850, 27446, 27975, 7873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17095, 7850, 27446, 27975, 7873, 7851, 27447, 27976, 7874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17096, 7851, 27447, 27976, 7874, 7852, 27448, 27977, 7875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17097, 7852, 27448, 27977, 7875, 7853, 27449, 27978, 7876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17098, 7853, 27449, 27978, 7876, 7854, 27450, 27979, 7877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17099, 7854, 27450, 27979, 7877, 7855, 27451, 27980, 7878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17100, 7855, 27451, 27980, 7878, 7856, 27452, 27981, 7879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17101, 7856, 27452, 27981, 7879, 7857, 27453, 27982, 7880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17102, 7857, 27453, 27982, 7880, 7858, 27454, 27983, 7881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17103, 7858, 27454, 27983, 7881, 7859, 27455, 27984, 7882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17104, 7859, 27455, 27984, 7882, 7860, 27456, 27985, 7883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17105, 7860, 27456, 27985, 7883, 7861, 27457, 27986, 7884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17106, 7861, 27457, 27986, 7884, 7862, 27458, 27987, 7885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17107, 7862, 27458, 27987, 7885, 7863, 27459, 27988, 7886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17108, 7863, 27459, 27988, 7886, 7864, 27460, 27989, 7887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17109, 7864, 27460, 27989, 7887, 981, 8348, 8371, 982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17110, 6531, 6532, 6555, 6554, 27438, 27461, 27990, 27967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17111, 27438, 27461, 27990, 27967, 27439, 27462, 27991, 27968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17112, 27439, 27462, 27991, 27968, 27440, 27463, 27992, 27969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17113, 27440, 27463, 27992, 27969, 27441, 27464, 27993, 27970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17114, 27441, 27464, 27993, 27970, 27442, 27465, 27994, 27971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17115, 27442, 27465, 27994, 27971, 27443, 27466, 27995, 27972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17116, 27443, 27466, 27995, 27972, 27444, 27467, 27996, 27973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17117, 27444, 27467, 27996, 27973, 27445, 27468, 27997, 27974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17118, 27445, 27468, 27997, 27974, 27446, 27469, 27998, 27975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17119, 27446, 27469, 27998, 27975, 27447, 27470, 27999, 27976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17120, 27447, 27470, 27999, 27976, 27448, 27471, 28000, 27977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17121, 27448, 27471, 28000, 27977, 27449, 27472, 28001, 27978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17122, 27449, 27472, 28001, 27978, 27450, 27473, 28002, 27979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17123, 27450, 27473, 28002, 27979, 27451, 27474, 28003, 27980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17124, 27451, 27474, 28003, 27980, 27452, 27475, 28004, 27981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17125, 27452, 27475, 28004, 27981, 27453, 27476, 28005, 27982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17126, 27453, 27476, 28005, 27982, 27454, 27477, 28006, 27983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17127, 27454, 27477, 28006, 27983, 27455, 27478, 28007, 27984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17128, 27455, 27478, 28007, 27984, 27456, 27479, 28008, 27985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17129, 27456, 27479, 28008, 27985, 27457, 27480, 28009, 27986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17130, 27457, 27480, 28009, 27986, 27458, 27481, 28010, 27987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17131, 27458, 27481, 28010, 27987, 27459, 27482, 28011, 27988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17132, 27459, 27482, 28011, 27988, 27460, 27483, 28012, 27989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17133, 27460, 27483, 28012, 27989, 8348, 8349, 8372, 8371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17134, 6532, 6533, 6556, 6555, 27461, 27484, 28013, 27990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17135, 27461, 27484, 28013, 27990, 27462, 27485, 28014, 27991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17136, 27462, 27485, 28014, 27991, 27463, 27486, 28015, 27992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17137, 27463, 27486, 28015, 27992, 27464, 27487, 28016, 27993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17138, 27464, 27487, 28016, 27993, 27465, 27488, 28017, 27994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17139, 27465, 27488, 28017, 27994, 27466, 27489, 28018, 27995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17140, 27466, 27489, 28018, 27995, 27467, 27490, 28019, 27996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17141, 27467, 27490, 28019, 27996, 27468, 27491, 28020, 27997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17142, 27468, 27491, 28020, 27997, 27469, 27492, 28021, 27998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17143, 27469, 27492, 28021, 27998, 27470, 27493, 28022, 27999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17144, 27470, 27493, 28022, 27999, 27471, 27494, 28023, 28000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17145, 27471, 27494, 28023, 28000, 27472, 27495, 28024, 28001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17146, 27472, 27495, 28024, 28001, 27473, 27496, 28025, 28002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17147, 27473, 27496, 28025, 28002, 27474, 27497, 28026, 28003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17148, 27474, 27497, 28026, 28003, 27475, 27498, 28027, 28004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17149, 27475, 27498, 28027, 28004, 27476, 27499, 28028, 28005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17150, 27476, 27499, 28028, 28005, 27477, 27500, 28029, 28006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17151, 27477, 27500, 28029, 28006, 27478, 27501, 28030, 28007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17152, 27478, 27501, 28030, 28007, 27479, 27502, 28031, 28008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17153, 27479, 27502, 28031, 28008, 27480, 27503, 28032, 28009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17154, 27480, 27503, 28032, 28009, 27481, 27504, 28033, 28010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17155, 27481, 27504, 28033, 28010, 27482, 27505, 28034, 28011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17156, 27482, 27505, 28034, 28011, 27483, 27506, 28035, 28012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17157, 27483, 27506, 28035, 28012, 8349, 8350, 8373, 8372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17158, 6533, 6534, 6557, 6556, 27484, 27507, 28036, 28013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17159, 27484, 27507, 28036, 28013, 27485, 27508, 28037, 28014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17160, 27485, 27508, 28037, 28014, 27486, 27509, 28038, 28015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17161, 27486, 27509, 28038, 28015, 27487, 27510, 28039, 28016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17162, 27487, 27510, 28039, 28016, 27488, 27511, 28040, 28017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17163, 27488, 27511, 28040, 28017, 27489, 27512, 28041, 28018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17164, 27489, 27512, 28041, 28018, 27490, 27513, 28042, 28019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17165, 27490, 27513, 28042, 28019, 27491, 27514, 28043, 28020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17166, 27491, 27514, 28043, 28020, 27492, 27515, 28044, 28021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17167, 27492, 27515, 28044, 28021, 27493, 27516, 28045, 28022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17168, 27493, 27516, 28045, 28022, 27494, 27517, 28046, 28023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17169, 27494, 27517, 28046, 28023, 27495, 27518, 28047, 28024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17170, 27495, 27518, 28047, 28024, 27496, 27519, 28048, 28025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17171, 27496, 27519, 28048, 28025, 27497, 27520, 28049, 28026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17172, 27497, 27520, 28049, 28026, 27498, 27521, 28050, 28027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17173, 27498, 27521, 28050, 28027, 27499, 27522, 28051, 28028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17174, 27499, 27522, 28051, 28028, 27500, 27523, 28052, 28029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17175, 27500, 27523, 28052, 28029, 27501, 27524, 28053, 28030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17176, 27501, 27524, 28053, 28030, 27502, 27525, 28054, 28031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17177, 27502, 27525, 28054, 28031, 27503, 27526, 28055, 28032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17178, 27503, 27526, 28055, 28032, 27504, 27527, 28056, 28033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17179, 27504, 27527, 28056, 28033, 27505, 27528, 28057, 28034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17180, 27505, 27528, 28057, 28034, 27506, 27529, 28058, 28035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17181, 27506, 27529, 28058, 28035, 8350, 8351, 8374, 8373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17182, 6534, 6535, 6558, 6557, 27507, 27530, 28059, 28036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17183, 27507, 27530, 28059, 28036, 27508, 27531, 28060, 28037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17184, 27508, 27531, 28060, 28037, 27509, 27532, 28061, 28038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17185, 27509, 27532, 28061, 28038, 27510, 27533, 28062, 28039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17186, 27510, 27533, 28062, 28039, 27511, 27534, 28063, 28040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17187, 27511, 27534, 28063, 28040, 27512, 27535, 28064, 28041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17188, 27512, 27535, 28064, 28041, 27513, 27536, 28065, 28042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17189, 27513, 27536, 28065, 28042, 27514, 27537, 28066, 28043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17190, 27514, 27537, 28066, 28043, 27515, 27538, 28067, 28044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17191, 27515, 27538, 28067, 28044, 27516, 27539, 28068, 28045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17192, 27516, 27539, 28068, 28045, 27517, 27540, 28069, 28046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17193, 27517, 27540, 28069, 28046, 27518, 27541, 28070, 28047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17194, 27518, 27541, 28070, 28047, 27519, 27542, 28071, 28048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17195, 27519, 27542, 28071, 28048, 27520, 27543, 28072, 28049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17196, 27520, 27543, 28072, 28049, 27521, 27544, 28073, 28050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17197, 27521, 27544, 28073, 28050, 27522, 27545, 28074, 28051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17198, 27522, 27545, 28074, 28051, 27523, 27546, 28075, 28052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17199, 27523, 27546, 28075, 28052, 27524, 27547, 28076, 28053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17200, 27524, 27547, 28076, 28053, 27525, 27548, 28077, 28054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17201, 27525, 27548, 28077, 28054, 27526, 27549, 28078, 28055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17202, 27526, 27549, 28078, 28055, 27527, 27550, 28079, 28056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17203, 27527, 27550, 28079, 28056, 27528, 27551, 28080, 28057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17204, 27528, 27551, 28080, 28057, 27529, 27552, 28081, 28058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17205, 27529, 27552, 28081, 28058, 8351, 8352, 8375, 8374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17206, 6535, 6536, 6559, 6558, 27530, 27553, 28082, 28059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17207, 27530, 27553, 28082, 28059, 27531, 27554, 28083, 28060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17208, 27531, 27554, 28083, 28060, 27532, 27555, 28084, 28061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17209, 27532, 27555, 28084, 28061, 27533, 27556, 28085, 28062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17210, 27533, 27556, 28085, 28062, 27534, 27557, 28086, 28063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17211, 27534, 27557, 28086, 28063, 27535, 27558, 28087, 28064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17212, 27535, 27558, 28087, 28064, 27536, 27559, 28088, 28065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17213, 27536, 27559, 28088, 28065, 27537, 27560, 28089, 28066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17214, 27537, 27560, 28089, 28066, 27538, 27561, 28090, 28067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17215, 27538, 27561, 28090, 28067, 27539, 27562, 28091, 28068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17216, 27539, 27562, 28091, 28068, 27540, 27563, 28092, 28069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17217, 27540, 27563, 28092, 28069, 27541, 27564, 28093, 28070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17218, 27541, 27564, 28093, 28070, 27542, 27565, 28094, 28071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17219, 27542, 27565, 28094, 28071, 27543, 27566, 28095, 28072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17220, 27543, 27566, 28095, 28072, 27544, 27567, 28096, 28073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17221, 27544, 27567, 28096, 28073, 27545, 27568, 28097, 28074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17222, 27545, 27568, 28097, 28074, 27546, 27569, 28098, 28075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17223, 27546, 27569, 28098, 28075, 27547, 27570, 28099, 28076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17224, 27547, 27570, 28099, 28076, 27548, 27571, 28100, 28077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17225, 27548, 27571, 28100, 28077, 27549, 27572, 28101, 28078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17226, 27549, 27572, 28101, 28078, 27550, 27573, 28102, 28079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17227, 27550, 27573, 28102, 28079, 27551, 27574, 28103, 28080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17228, 27551, 27574, 28103, 28080, 27552, 27575, 28104, 28081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17229, 27552, 27575, 28104, 28081, 8352, 8353, 8376, 8375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17230, 6536, 6537, 6560, 6559, 27553, 27576, 28105, 28082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17231, 27553, 27576, 28105, 28082, 27554, 27577, 28106, 28083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17232, 27554, 27577, 28106, 28083, 27555, 27578, 28107, 28084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17233, 27555, 27578, 28107, 28084, 27556, 27579, 28108, 28085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17234, 27556, 27579, 28108, 28085, 27557, 27580, 28109, 28086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17235, 27557, 27580, 28109, 28086, 27558, 27581, 28110, 28087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17236, 27558, 27581, 28110, 28087, 27559, 27582, 28111, 28088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17237, 27559, 27582, 28111, 28088, 27560, 27583, 28112, 28089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17238, 27560, 27583, 28112, 28089, 27561, 27584, 28113, 28090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17239, 27561, 27584, 28113, 28090, 27562, 27585, 28114, 28091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17240, 27562, 27585, 28114, 28091, 27563, 27586, 28115, 28092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17241, 27563, 27586, 28115, 28092, 27564, 27587, 28116, 28093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17242, 27564, 27587, 28116, 28093, 27565, 27588, 28117, 28094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17243, 27565, 27588, 28117, 28094, 27566, 27589, 28118, 28095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17244, 27566, 27589, 28118, 28095, 27567, 27590, 28119, 28096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17245, 27567, 27590, 28119, 28096, 27568, 27591, 28120, 28097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17246, 27568, 27591, 28120, 28097, 27569, 27592, 28121, 28098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17247, 27569, 27592, 28121, 28098, 27570, 27593, 28122, 28099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17248, 27570, 27593, 28122, 28099, 27571, 27594, 28123, 28100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17249, 27571, 27594, 28123, 28100, 27572, 27595, 28124, 28101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17250, 27572, 27595, 28124, 28101, 27573, 27596, 28125, 28102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17251, 27573, 27596, 28125, 28102, 27574, 27597, 28126, 28103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17252, 27574, 27597, 28126, 28103, 27575, 27598, 28127, 28104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17253, 27575, 27598, 28127, 28104, 8353, 8354, 8377, 8376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17254, 6537, 6538, 6561, 6560, 27576, 27599, 28128, 28105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17255, 27576, 27599, 28128, 28105, 27577, 27600, 28129, 28106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17256, 27577, 27600, 28129, 28106, 27578, 27601, 28130, 28107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17257, 27578, 27601, 28130, 28107, 27579, 27602, 28131, 28108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17258, 27579, 27602, 28131, 28108, 27580, 27603, 28132, 28109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17259, 27580, 27603, 28132, 28109, 27581, 27604, 28133, 28110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17260, 27581, 27604, 28133, 28110, 27582, 27605, 28134, 28111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17261, 27582, 27605, 28134, 28111, 27583, 27606, 28135, 28112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17262, 27583, 27606, 28135, 28112, 27584, 27607, 28136, 28113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17263, 27584, 27607, 28136, 28113, 27585, 27608, 28137, 28114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17264, 27585, 27608, 28137, 28114, 27586, 27609, 28138, 28115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17265, 27586, 27609, 28138, 28115, 27587, 27610, 28139, 28116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17266, 27587, 27610, 28139, 28116, 27588, 27611, 28140, 28117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17267, 27588, 27611, 28140, 28117, 27589, 27612, 28141, 28118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17268, 27589, 27612, 28141, 28118, 27590, 27613, 28142, 28119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17269, 27590, 27613, 28142, 28119, 27591, 27614, 28143, 28120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17270, 27591, 27614, 28143, 28120, 27592, 27615, 28144, 28121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17271, 27592, 27615, 28144, 28121, 27593, 27616, 28145, 28122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17272, 27593, 27616, 28145, 28122, 27594, 27617, 28146, 28123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17273, 27594, 27617, 28146, 28123, 27595, 27618, 28147, 28124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17274, 27595, 27618, 28147, 28124, 27596, 27619, 28148, 28125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17275, 27596, 27619, 28148, 28125, 27597, 27620, 28149, 28126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17276, 27597, 27620, 28149, 28126, 27598, 27621, 28150, 28127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17277, 27598, 27621, 28150, 28127, 8354, 8355, 8378, 8377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17278, 6538, 6539, 6562, 6561, 27599, 27622, 28151, 28128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17279, 27599, 27622, 28151, 28128, 27600, 27623, 28152, 28129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17280, 27600, 27623, 28152, 28129, 27601, 27624, 28153, 28130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17281, 27601, 27624, 28153, 28130, 27602, 27625, 28154, 28131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17282, 27602, 27625, 28154, 28131, 27603, 27626, 28155, 28132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17283, 27603, 27626, 28155, 28132, 27604, 27627, 28156, 28133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17284, 27604, 27627, 28156, 28133, 27605, 27628, 28157, 28134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17285, 27605, 27628, 28157, 28134, 27606, 27629, 28158, 28135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17286, 27606, 27629, 28158, 28135, 27607, 27630, 28159, 28136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17287, 27607, 27630, 28159, 28136, 27608, 27631, 28160, 28137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17288, 27608, 27631, 28160, 28137, 27609, 27632, 28161, 28138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17289, 27609, 27632, 28161, 28138, 27610, 27633, 28162, 28139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17290, 27610, 27633, 28162, 28139, 27611, 27634, 28163, 28140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17291, 27611, 27634, 28163, 28140, 27612, 27635, 28164, 28141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17292, 27612, 27635, 28164, 28141, 27613, 27636, 28165, 28142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17293, 27613, 27636, 28165, 28142, 27614, 27637, 28166, 28143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17294, 27614, 27637, 28166, 28143, 27615, 27638, 28167, 28144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17295, 27615, 27638, 28167, 28144, 27616, 27639, 28168, 28145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17296, 27616, 27639, 28168, 28145, 27617, 27640, 28169, 28146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17297, 27617, 27640, 28169, 28146, 27618, 27641, 28170, 28147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17298, 27618, 27641, 28170, 28147, 27619, 27642, 28171, 28148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17299, 27619, 27642, 28171, 28148, 27620, 27643, 28172, 28149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17300, 27620, 27643, 28172, 28149, 27621, 27644, 28173, 28150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17301, 27621, 27644, 28173, 28150, 8355, 8356, 8379, 8378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17302, 6539, 6540, 6563, 6562, 27622, 27645, 28174, 28151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17303, 27622, 27645, 28174, 28151, 27623, 27646, 28175, 28152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17304, 27623, 27646, 28175, 28152, 27624, 27647, 28176, 28153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17305, 27624, 27647, 28176, 28153, 27625, 27648, 28177, 28154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17306, 27625, 27648, 28177, 28154, 27626, 27649, 28178, 28155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17307, 27626, 27649, 28178, 28155, 27627, 27650, 28179, 28156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17308, 27627, 27650, 28179, 28156, 27628, 27651, 28180, 28157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17309, 27628, 27651, 28180, 28157, 27629, 27652, 28181, 28158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17310, 27629, 27652, 28181, 28158, 27630, 27653, 28182, 28159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17311, 27630, 27653, 28182, 28159, 27631, 27654, 28183, 28160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17312, 27631, 27654, 28183, 28160, 27632, 27655, 28184, 28161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17313, 27632, 27655, 28184, 28161, 27633, 27656, 28185, 28162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17314, 27633, 27656, 28185, 28162, 27634, 27657, 28186, 28163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17315, 27634, 27657, 28186, 28163, 27635, 27658, 28187, 28164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17316, 27635, 27658, 28187, 28164, 27636, 27659, 28188, 28165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17317, 27636, 27659, 28188, 28165, 27637, 27660, 28189, 28166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17318, 27637, 27660, 28189, 28166, 27638, 27661, 28190, 28167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17319, 27638, 27661, 28190, 28167, 27639, 27662, 28191, 28168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17320, 27639, 27662, 28191, 28168, 27640, 27663, 28192, 28169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17321, 27640, 27663, 28192, 28169, 27641, 27664, 28193, 28170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17322, 27641, 27664, 28193, 28170, 27642, 27665, 28194, 28171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17323, 27642, 27665, 28194, 28171, 27643, 27666, 28195, 28172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17324, 27643, 27666, 28195, 28172, 27644, 27667, 28196, 28173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17325, 27644, 27667, 28196, 28173, 8356, 8357, 8380, 8379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17326, 6540, 6541, 6564, 6563, 27645, 27668, 28197, 28174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17327, 27645, 27668, 28197, 28174, 27646, 27669, 28198, 28175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17328, 27646, 27669, 28198, 28175, 27647, 27670, 28199, 28176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17329, 27647, 27670, 28199, 28176, 27648, 27671, 28200, 28177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17330, 27648, 27671, 28200, 28177, 27649, 27672, 28201, 28178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17331, 27649, 27672, 28201, 28178, 27650, 27673, 28202, 28179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17332, 27650, 27673, 28202, 28179, 27651, 27674, 28203, 28180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17333, 27651, 27674, 28203, 28180, 27652, 27675, 28204, 28181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17334, 27652, 27675, 28204, 28181, 27653, 27676, 28205, 28182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17335, 27653, 27676, 28205, 28182, 27654, 27677, 28206, 28183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17336, 27654, 27677, 28206, 28183, 27655, 27678, 28207, 28184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17337, 27655, 27678, 28207, 28184, 27656, 27679, 28208, 28185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17338, 27656, 27679, 28208, 28185, 27657, 27680, 28209, 28186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17339, 27657, 27680, 28209, 28186, 27658, 27681, 28210, 28187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17340, 27658, 27681, 28210, 28187, 27659, 27682, 28211, 28188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17341, 27659, 27682, 28211, 28188, 27660, 27683, 28212, 28189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17342, 27660, 27683, 28212, 28189, 27661, 27684, 28213, 28190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17343, 27661, 27684, 28213, 28190, 27662, 27685, 28214, 28191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17344, 27662, 27685, 28214, 28191, 27663, 27686, 28215, 28192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17345, 27663, 27686, 28215, 28192, 27664, 27687, 28216, 28193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17346, 27664, 27687, 28216, 28193, 27665, 27688, 28217, 28194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17347, 27665, 27688, 28217, 28194, 27666, 27689, 28218, 28195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17348, 27666, 27689, 28218, 28195, 27667, 27690, 28219, 28196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17349, 27667, 27690, 28219, 28196, 8357, 8358, 8381, 8380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17350, 6541, 6542, 6565, 6564, 27668, 27691, 28220, 28197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17351, 27668, 27691, 28220, 28197, 27669, 27692, 28221, 28198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17352, 27669, 27692, 28221, 28198, 27670, 27693, 28222, 28199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17353, 27670, 27693, 28222, 28199, 27671, 27694, 28223, 28200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17354, 27671, 27694, 28223, 28200, 27672, 27695, 28224, 28201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17355, 27672, 27695, 28224, 28201, 27673, 27696, 28225, 28202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17356, 27673, 27696, 28225, 28202, 27674, 27697, 28226, 28203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17357, 27674, 27697, 28226, 28203, 27675, 27698, 28227, 28204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17358, 27675, 27698, 28227, 28204, 27676, 27699, 28228, 28205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17359, 27676, 27699, 28228, 28205, 27677, 27700, 28229, 28206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17360, 27677, 27700, 28229, 28206, 27678, 27701, 28230, 28207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17361, 27678, 27701, 28230, 28207, 27679, 27702, 28231, 28208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17362, 27679, 27702, 28231, 28208, 27680, 27703, 28232, 28209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17363, 27680, 27703, 28232, 28209, 27681, 27704, 28233, 28210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17364, 27681, 27704, 28233, 28210, 27682, 27705, 28234, 28211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17365, 27682, 27705, 28234, 28211, 27683, 27706, 28235, 28212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17366, 27683, 27706, 28235, 28212, 27684, 27707, 28236, 28213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17367, 27684, 27707, 28236, 28213, 27685, 27708, 28237, 28214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17368, 27685, 27708, 28237, 28214, 27686, 27709, 28238, 28215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17369, 27686, 27709, 28238, 28215, 27687, 27710, 28239, 28216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17370, 27687, 27710, 28239, 28216, 27688, 27711, 28240, 28217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17371, 27688, 27711, 28240, 28217, 27689, 27712, 28241, 28218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17372, 27689, 27712, 28241, 28218, 27690, 27713, 28242, 28219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17373, 27690, 27713, 28242, 28219, 8358, 8359, 8382, 8381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17374, 6542, 6543, 6566, 6565, 27691, 27714, 28243, 28220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17375, 27691, 27714, 28243, 28220, 27692, 27715, 28244, 28221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17376, 27692, 27715, 28244, 28221, 27693, 27716, 28245, 28222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17377, 27693, 27716, 28245, 28222, 27694, 27717, 28246, 28223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17378, 27694, 27717, 28246, 28223, 27695, 27718, 28247, 28224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17379, 27695, 27718, 28247, 28224, 27696, 27719, 28248, 28225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17380, 27696, 27719, 28248, 28225, 27697, 27720, 28249, 28226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17381, 27697, 27720, 28249, 28226, 27698, 27721, 28250, 28227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17382, 27698, 27721, 28250, 28227, 27699, 27722, 28251, 28228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17383, 27699, 27722, 28251, 28228, 27700, 27723, 28252, 28229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17384, 27700, 27723, 28252, 28229, 27701, 27724, 28253, 28230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17385, 27701, 27724, 28253, 28230, 27702, 27725, 28254, 28231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17386, 27702, 27725, 28254, 28231, 27703, 27726, 28255, 28232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17387, 27703, 27726, 28255, 28232, 27704, 27727, 28256, 28233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17388, 27704, 27727, 28256, 28233, 27705, 27728, 28257, 28234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17389, 27705, 27728, 28257, 28234, 27706, 27729, 28258, 28235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17390, 27706, 27729, 28258, 28235, 27707, 27730, 28259, 28236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17391, 27707, 27730, 28259, 28236, 27708, 27731, 28260, 28237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17392, 27708, 27731, 28260, 28237, 27709, 27732, 28261, 28238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17393, 27709, 27732, 28261, 28238, 27710, 27733, 28262, 28239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17394, 27710, 27733, 28262, 28239, 27711, 27734, 28263, 28240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17395, 27711, 27734, 28263, 28240, 27712, 27735, 28264, 28241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17396, 27712, 27735, 28264, 28241, 27713, 27736, 28265, 28242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17397, 27713, 27736, 28265, 28242, 8359, 8360, 8383, 8382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17398, 6543, 6544, 6567, 6566, 27714, 27737, 28266, 28243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17399, 27714, 27737, 28266, 28243, 27715, 27738, 28267, 28244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17400, 27715, 27738, 28267, 28244, 27716, 27739, 28268, 28245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17401, 27716, 27739, 28268, 28245, 27717, 27740, 28269, 28246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17402, 27717, 27740, 28269, 28246, 27718, 27741, 28270, 28247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17403, 27718, 27741, 28270, 28247, 27719, 27742, 28271, 28248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17404, 27719, 27742, 28271, 28248, 27720, 27743, 28272, 28249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17405, 27720, 27743, 28272, 28249, 27721, 27744, 28273, 28250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17406, 27721, 27744, 28273, 28250, 27722, 27745, 28274, 28251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17407, 27722, 27745, 28274, 28251, 27723, 27746, 28275, 28252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17408, 27723, 27746, 28275, 28252, 27724, 27747, 28276, 28253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17409, 27724, 27747, 28276, 28253, 27725, 27748, 28277, 28254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17410, 27725, 27748, 28277, 28254, 27726, 27749, 28278, 28255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17411, 27726, 27749, 28278, 28255, 27727, 27750, 28279, 28256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17412, 27727, 27750, 28279, 28256, 27728, 27751, 28280, 28257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17413, 27728, 27751, 28280, 28257, 27729, 27752, 28281, 28258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17414, 27729, 27752, 28281, 28258, 27730, 27753, 28282, 28259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17415, 27730, 27753, 28282, 28259, 27731, 27754, 28283, 28260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17416, 27731, 27754, 28283, 28260, 27732, 27755, 28284, 28261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17417, 27732, 27755, 28284, 28261, 27733, 27756, 28285, 28262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17418, 27733, 27756, 28285, 28262, 27734, 27757, 28286, 28263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17419, 27734, 27757, 28286, 28263, 27735, 27758, 28287, 28264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17420, 27735, 27758, 28287, 28264, 27736, 27759, 28288, 28265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17421, 27736, 27759, 28288, 28265, 8360, 8361, 8384, 8383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17422, 6544, 6545, 6568, 6567, 27737, 27760, 28289, 28266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17423, 27737, 27760, 28289, 28266, 27738, 27761, 28290, 28267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17424, 27738, 27761, 28290, 28267, 27739, 27762, 28291, 28268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17425, 27739, 27762, 28291, 28268, 27740, 27763, 28292, 28269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17426, 27740, 27763, 28292, 28269, 27741, 27764, 28293, 28270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17427, 27741, 27764, 28293, 28270, 27742, 27765, 28294, 28271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17428, 27742, 27765, 28294, 28271, 27743, 27766, 28295, 28272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17429, 27743, 27766, 28295, 28272, 27744, 27767, 28296, 28273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17430, 27744, 27767, 28296, 28273, 27745, 27768, 28297, 28274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17431, 27745, 27768, 28297, 28274, 27746, 27769, 28298, 28275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17432, 27746, 27769, 28298, 28275, 27747, 27770, 28299, 28276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17433, 27747, 27770, 28299, 28276, 27748, 27771, 28300, 28277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17434, 27748, 27771, 28300, 28277, 27749, 27772, 28301, 28278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17435, 27749, 27772, 28301, 28278, 27750, 27773, 28302, 28279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17436, 27750, 27773, 28302, 28279, 27751, 27774, 28303, 28280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17437, 27751, 27774, 28303, 28280, 27752, 27775, 28304, 28281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17438, 27752, 27775, 28304, 28281, 27753, 27776, 28305, 28282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17439, 27753, 27776, 28305, 28282, 27754, 27777, 28306, 28283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17440, 27754, 27777, 28306, 28283, 27755, 27778, 28307, 28284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17441, 27755, 27778, 28307, 28284, 27756, 27779, 28308, 28285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17442, 27756, 27779, 28308, 28285, 27757, 27780, 28309, 28286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17443, 27757, 27780, 28309, 28286, 27758, 27781, 28310, 28287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17444, 27758, 27781, 28310, 28287, 27759, 27782, 28311, 28288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17445, 27759, 27782, 28311, 28288, 8361, 8362, 8385, 8384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17446, 6545, 6546, 6569, 6568, 27760, 27783, 28312, 28289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17447, 27760, 27783, 28312, 28289, 27761, 27784, 28313, 28290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17448, 27761, 27784, 28313, 28290, 27762, 27785, 28314, 28291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17449, 27762, 27785, 28314, 28291, 27763, 27786, 28315, 28292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17450, 27763, 27786, 28315, 28292, 27764, 27787, 28316, 28293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17451, 27764, 27787, 28316, 28293, 27765, 27788, 28317, 28294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17452, 27765, 27788, 28317, 28294, 27766, 27789, 28318, 28295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17453, 27766, 27789, 28318, 28295, 27767, 27790, 28319, 28296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17454, 27767, 27790, 28319, 28296, 27768, 27791, 28320, 28297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17455, 27768, 27791, 28320, 28297, 27769, 27792, 28321, 28298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17456, 27769, 27792, 28321, 28298, 27770, 27793, 28322, 28299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17457, 27770, 27793, 28322, 28299, 27771, 27794, 28323, 28300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17458, 27771, 27794, 28323, 28300, 27772, 27795, 28324, 28301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17459, 27772, 27795, 28324, 28301, 27773, 27796, 28325, 28302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17460, 27773, 27796, 28325, 28302, 27774, 27797, 28326, 28303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17461, 27774, 27797, 28326, 28303, 27775, 27798, 28327, 28304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17462, 27775, 27798, 28327, 28304, 27776, 27799, 28328, 28305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17463, 27776, 27799, 28328, 28305, 27777, 27800, 28329, 28306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17464, 27777, 27800, 28329, 28306, 27778, 27801, 28330, 28307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17465, 27778, 27801, 28330, 28307, 27779, 27802, 28331, 28308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17466, 27779, 27802, 28331, 28308, 27780, 27803, 28332, 28309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17467, 27780, 27803, 28332, 28309, 27781, 27804, 28333, 28310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17468, 27781, 27804, 28333, 28310, 27782, 27805, 28334, 28311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17469, 27782, 27805, 28334, 28311, 8362, 8363, 8386, 8385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17470, 6546, 6547, 6570, 6569, 27783, 27806, 28335, 28312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17471, 27783, 27806, 28335, 28312, 27784, 27807, 28336, 28313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17472, 27784, 27807, 28336, 28313, 27785, 27808, 28337, 28314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17473, 27785, 27808, 28337, 28314, 27786, 27809, 28338, 28315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17474, 27786, 27809, 28338, 28315, 27787, 27810, 28339, 28316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17475, 27787, 27810, 28339, 28316, 27788, 27811, 28340, 28317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17476, 27788, 27811, 28340, 28317, 27789, 27812, 28341, 28318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17477, 27789, 27812, 28341, 28318, 27790, 27813, 28342, 28319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17478, 27790, 27813, 28342, 28319, 27791, 27814, 28343, 28320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17479, 27791, 27814, 28343, 28320, 27792, 27815, 28344, 28321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17480, 27792, 27815, 28344, 28321, 27793, 27816, 28345, 28322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17481, 27793, 27816, 28345, 28322, 27794, 27817, 28346, 28323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17482, 27794, 27817, 28346, 28323, 27795, 27818, 28347, 28324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17483, 27795, 27818, 28347, 28324, 27796, 27819, 28348, 28325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17484, 27796, 27819, 28348, 28325, 27797, 27820, 28349, 28326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17485, 27797, 27820, 28349, 28326, 27798, 27821, 28350, 28327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17486, 27798, 27821, 28350, 28327, 27799, 27822, 28351, 28328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17487, 27799, 27822, 28351, 28328, 27800, 27823, 28352, 28329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17488, 27800, 27823, 28352, 28329, 27801, 27824, 28353, 28330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17489, 27801, 27824, 28353, 28330, 27802, 27825, 28354, 28331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17490, 27802, 27825, 28354, 28331, 27803, 27826, 28355, 28332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17491, 27803, 27826, 28355, 28332, 27804, 27827, 28356, 28333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17492, 27804, 27827, 28356, 28333, 27805, 27828, 28357, 28334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17493, 27805, 27828, 28357, 28334, 8363, 8364, 8387, 8386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17494, 6547, 6548, 6571, 6570, 27806, 27829, 28358, 28335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17495, 27806, 27829, 28358, 28335, 27807, 27830, 28359, 28336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17496, 27807, 27830, 28359, 28336, 27808, 27831, 28360, 28337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17497, 27808, 27831, 28360, 28337, 27809, 27832, 28361, 28338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17498, 27809, 27832, 28361, 28338, 27810, 27833, 28362, 28339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17499, 27810, 27833, 28362, 28339, 27811, 27834, 28363, 28340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17500, 27811, 27834, 28363, 28340, 27812, 27835, 28364, 28341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17501, 27812, 27835, 28364, 28341, 27813, 27836, 28365, 28342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17502, 27813, 27836, 28365, 28342, 27814, 27837, 28366, 28343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17503, 27814, 27837, 28366, 28343, 27815, 27838, 28367, 28344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17504, 27815, 27838, 28367, 28344, 27816, 27839, 28368, 28345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17505, 27816, 27839, 28368, 28345, 27817, 27840, 28369, 28346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17506, 27817, 27840, 28369, 28346, 27818, 27841, 28370, 28347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17507, 27818, 27841, 28370, 28347, 27819, 27842, 28371, 28348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17508, 27819, 27842, 28371, 28348, 27820, 27843, 28372, 28349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17509, 27820, 27843, 28372, 28349, 27821, 27844, 28373, 28350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17510, 27821, 27844, 28373, 28350, 27822, 27845, 28374, 28351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17511, 27822, 27845, 28374, 28351, 27823, 27846, 28375, 28352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17512, 27823, 27846, 28375, 28352, 27824, 27847, 28376, 28353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17513, 27824, 27847, 28376, 28353, 27825, 27848, 28377, 28354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17514, 27825, 27848, 28377, 28354, 27826, 27849, 28378, 28355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17515, 27826, 27849, 28378, 28355, 27827, 27850, 28379, 28356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17516, 27827, 27850, 28379, 28356, 27828, 27851, 28380, 28357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17517, 27828, 27851, 28380, 28357, 8364, 8365, 8388, 8387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17518, 6548, 6549, 6572, 6571, 27829, 27852, 28381, 28358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17519, 27829, 27852, 28381, 28358, 27830, 27853, 28382, 28359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17520, 27830, 27853, 28382, 28359, 27831, 27854, 28383, 28360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17521, 27831, 27854, 28383, 28360, 27832, 27855, 28384, 28361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17522, 27832, 27855, 28384, 28361, 27833, 27856, 28385, 28362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17523, 27833, 27856, 28385, 28362, 27834, 27857, 28386, 28363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17524, 27834, 27857, 28386, 28363, 27835, 27858, 28387, 28364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17525, 27835, 27858, 28387, 28364, 27836, 27859, 28388, 28365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17526, 27836, 27859, 28388, 28365, 27837, 27860, 28389, 28366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17527, 27837, 27860, 28389, 28366, 27838, 27861, 28390, 28367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17528, 27838, 27861, 28390, 28367, 27839, 27862, 28391, 28368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17529, 27839, 27862, 28391, 28368, 27840, 27863, 28392, 28369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17530, 27840, 27863, 28392, 28369, 27841, 27864, 28393, 28370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17531, 27841, 27864, 28393, 28370, 27842, 27865, 28394, 28371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17532, 27842, 27865, 28394, 28371, 27843, 27866, 28395, 28372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17533, 27843, 27866, 28395, 28372, 27844, 27867, 28396, 28373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17534, 27844, 27867, 28396, 28373, 27845, 27868, 28397, 28374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17535, 27845, 27868, 28397, 28374, 27846, 27869, 28398, 28375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17536, 27846, 27869, 28398, 28375, 27847, 27870, 28399, 28376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17537, 27847, 27870, 28399, 28376, 27848, 27871, 28400, 28377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17538, 27848, 27871, 28400, 28377, 27849, 27872, 28401, 28378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17539, 27849, 27872, 28401, 28378, 27850, 27873, 28402, 28379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17540, 27850, 27873, 28402, 28379, 27851, 27874, 28403, 28380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17541, 27851, 27874, 28403, 28380, 8365, 8366, 8389, 8388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17542, 6549, 6550, 6573, 6572, 27852, 27875, 28404, 28381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17543, 27852, 27875, 28404, 28381, 27853, 27876, 28405, 28382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17544, 27853, 27876, 28405, 28382, 27854, 27877, 28406, 28383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17545, 27854, 27877, 28406, 28383, 27855, 27878, 28407, 28384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17546, 27855, 27878, 28407, 28384, 27856, 27879, 28408, 28385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17547, 27856, 27879, 28408, 28385, 27857, 27880, 28409, 28386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17548, 27857, 27880, 28409, 28386, 27858, 27881, 28410, 28387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17549, 27858, 27881, 28410, 28387, 27859, 27882, 28411, 28388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17550, 27859, 27882, 28411, 28388, 27860, 27883, 28412, 28389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17551, 27860, 27883, 28412, 28389, 27861, 27884, 28413, 28390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17552, 27861, 27884, 28413, 28390, 27862, 27885, 28414, 28391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17553, 27862, 27885, 28414, 28391, 27863, 27886, 28415, 28392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17554, 27863, 27886, 28415, 28392, 27864, 27887, 28416, 28393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17555, 27864, 27887, 28416, 28393, 27865, 27888, 28417, 28394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17556, 27865, 27888, 28417, 28394, 27866, 27889, 28418, 28395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17557, 27866, 27889, 28418, 28395, 27867, 27890, 28419, 28396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17558, 27867, 27890, 28419, 28396, 27868, 27891, 28420, 28397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17559, 27868, 27891, 28420, 28397, 27869, 27892, 28421, 28398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17560, 27869, 27892, 28421, 28398, 27870, 27893, 28422, 28399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17561, 27870, 27893, 28422, 28399, 27871, 27894, 28423, 28400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17562, 27871, 27894, 28423, 28400, 27872, 27895, 28424, 28401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17563, 27872, 27895, 28424, 28401, 27873, 27896, 28425, 28402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17564, 27873, 27896, 28425, 28402, 27874, 27897, 28426, 28403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17565, 27874, 27897, 28426, 28403, 8366, 8367, 8390, 8389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17566, 6550, 6551, 6574, 6573, 27875, 27898, 28427, 28404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
