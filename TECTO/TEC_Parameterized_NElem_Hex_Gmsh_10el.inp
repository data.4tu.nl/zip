454, 455, 456, 457, 458, 504, 505, 506, 507, 508, 
509, 510, 511, 512, 513, 514, 515, 516, 517, 518, 
519, 520, 521, 522, 523, 524, 525, 526, 565, 566, 
578, 579, 580, 581, 582, 583, 584, 585, 586, 587, 
588, 589, 590, 591, 592, 593, 594, 595, 596, 597, 
598, 599, 600, 601, 602, 614, 615, 616, 617, 618, 
619, 620, 621, 622, 623, 656, 657, 658, 659, 660, 
661, 662, 663, 664, 665, 666, 667, 668, 669, 670, 
671, 672, 673, 674, 675, 676, 677, 678, 679, 680, 
681, 682, 683, 684, 685, 686, 687, 688, 689, 690, 
691, 692, 693, 694, 695, 696, 697, 698, 699, 700, 
701, 702, 703, 774, 775, 776, 777, 778, 779, 780, 
781, 782, 783, 784, 785, 786, 787, 788, 789, 790, 
791, 792, 793, 794, 795, 796, 842, 843, 844, 845, 
846, 847, 848, 849, 850, 851, 852, 853, 854, 855, 
856, 857, 858, 859, 860, 861, 862, 863, 864, 865, 
866, 867, 868, 869, 870, 871, 872, 873, 874, 875, 
876, 877, 878, 879, 880, 881, 882, 883, 884, 885, 
886, 887, 888, 889, 890, 891, 892, 893, 894, 895, 
896, 897, 898, 899, 900, 901, 902, 903, 904, 905, 
906, 907, 908, 909, 910, 1002, 1003, 1004, 1005, 1006, 
1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 1015, 1016, 
1017, 1018, 1019, 1020, 1021, 1022, 1023, 1024, 1120, 1121, 
1122, 1123, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 1131, 
1132, 1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 1141, 
1142, 1143, 1144, 1145, 1146, 1202, 1203, 1239, 1240, 1254, 
1255, 1256, 1257, 1258, 1259, 1260, 1261, 1262, 1263, 1264, 
1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 1273, 1274, 
1275, 1276, 1372, 1373, 1374, 1375, 1376, 1377, 1378, 1379, 
1380, 1381, 1382, 1383, 1384, 1385, 1386, 1387, 1388, 1389, 
1390, 1391, 1392, 1393, 1394, 2017, 2018, 2019, 2020, 2032, 
2033, 2034, 2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 
2043, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 
2053, 2054, 2055, 2056, 2057, 2058, 2070, 2071, 2072, 2073, 
2074, 2075, 2076, 2077, 2102, 2103, 2104, 2105, 2106, 2107, 
2108, 2109, 2110, 2111, 2112, 2113, 2114, 2115, 2116, 2117, 
2118, 2119, 2120, 2121, 2122, 2123, 2124, 2125, 2126, 2127, 
2128, 2213, 2214, 2215, 2216, 2228, 2229, 2230, 2231, 2232, 
2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 2241, 2242, 
2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 2251, 2252, 
2253, 2254, 2266, 2267, 2268, 2269, 2290, 2291, 2292, 2293, 
2294, 2295, 2296, 2297, 2298, 2299, 2300, 2301, 2302, 2303, 
2304, 2305, 2306, 2307, 2308, 2309, 2310, 2311, 2312, 2313, 
2314, 2315, 2316, 2317, 2318, 2319, 2320, 2384, 2385, 2386, 
2387, 3004, 3005, 3006, 3007, 3008, 3009, 3010, 3011, 3012, 
3013, 3014, 3015, 3016, 3017, 3018, 3019, 3020, 3021, 3022, 
3023, 3024, 3025, 3026, 3027, 3028, 3029, 3030, 3031, 3032, 
3033, 3034, 3035, 3036, 3037, 3038, 3039, 3040, 3041, 3042, 
3043, 3044, 3045, 3046, 3047, 3048, 3049, 4085, 4086, 4087, 
4088, 4089, 4090, 4091, 4092, 4093, 4094, 4095, 4096, 4097, 
4098, 4099, 4100, 4101, 4102, 4103, 4104, 4105, 4106, 4107, 
4108, 4109, 4110, 4111, 4112, 4113, 4114, 4115, 4116, 4117, 
4118, 4119, 4120, 4121, 4122, 4123, 4124, 4125, 4126, 4127, 
4128, 4129, 4130, 4131, 4132, 4133, 4134, 4135, 4136, 4137, 
4138, 4139, 4140, 4141, 4142, 4143, 4144, 4145, 4146, 4147, 
4148, 4149, 4150, 4151, 4152, 4153, 4154, 4155, 4156, 4157, 
4158, 4159, 4160, 4161, 4162, 4163, 4164, 4165, 4166, 4167, 
4168, 4169, 4170, 4171, 4172, 4173, 4174, 4175, 4176, 4177, 
4178, 4179, 4180, 4181, 4182, 4183, 4184, 4185, 4186, 4187, 
4188, 4189, 4190, 4191, 4192, 4193, 4194, 4195, 4196, 4197, 
4198, 4199, 4200, 4201, 4202, 4203, 4204, 4205, 4206, 4207, 
4208, 4209, 4210, 4211, 4212, 4213, 4214, 4215, 4216, 4217, 
4218, 4219, 4220, 4221, 4222, 4223, 4224, 4225, 4226, 4227, 
4228, 4229, 4230, 4231, 4232, 4233, 4234, 4235, 4236, 4237, 
4238, 4239, 4240, 4241, 4242, 4243, 4244, 4245, 4246, 4247, 
4248, 4249, 4250, 4251, 4252, 4253, 4254, 4255, 4256, 4257, 
4258, 4259, 4260, 4261, 4262, 4263, 4264, 4265, 4266, 4267, 
4268, 4269, 4270, 4271, 4272, 4273, 4274, 4275, 4276, 4277, 
4278, 4279, 4280, 4281, 4282, 4283, 4284, 4285, 4286, 4287, 
4288, 4289, 4290, 4291, 4292, 4293, 4294, 4295, 4296, 4297, 
4298, 4299, 4300, 4301, 4302, 4303, 4304, 4305, 4306, 4307, 
4308, 4309, 4310, 4311, 4312, 4313, 4314, 4315, 4316, 4317, 
4318, 4319, 4320, 4321, 4322, 4323, 4324, 4325, 4326, 4327, 
4328, 4329, 4330, 4331, 4332, 4333, 4334, 4335, 4336, 4337, 
4338, 4339, 4340, 4341, 4342, 4343, 4344, 4345, 4346, 4347, 
4348, 4349, 4350, 4351, 4352, 4353, 4354, 4355, 4356, 4357, 
4358, 4359, 4360, 4361, 4362, 4363, 4364, 4365, 4366, 4367, 
4368, 4369, 4370, 4371, 4372, 4373, 4374, 4375, 4376, 4377, 
4378, 4379, 4380, 4381, 4382, 4383, 4384, 4385, 4386, 4387, 
4388, 4389, 4390, 4391, 4392, 4393, 4394, 4395, 4396, 4397, 
4398, 4399, 4400, 4401, 4402, 4403, 4404, 4405, 4406, 4407, 
4408, 4409, 4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 
4418, 4419, 4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 
4428, 4429, 4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 
4438, 4439, 4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 
4448, 4449, 4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 
4458, 4459, 4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 
4468, 4469, 4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 
4478, 4479, 4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 
4488, 4489, 4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 
4498, 4499, 4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 
4508, 4509, 4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 
4518, 4519, 4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 
4528, 4529, 4530, 4531, 4532, 4533, 4534, 4535, 4536, 4537, 
4538, 4539, 4540, 4541, 4542, 4543, 4544, 4545, 4546, 4547, 
4548, 4549, 4550, 4551, 4552, 4553, 4554, 4555, 4556, 4557, 
4558, 4559, 4560, 4561, 4562, 4563, 4564, 4565, 4566, 4567, 
4568, 4569, 4570, 4571, 4572, 4573, 4574, 4575, 4576, 4577, 
4578, 4579, 4580, 4581, 4582, 4583, 4584, 4585, 4586, 4587, 
4588, 4589, 4590, 4591, 4592, 4593, 4594, 4595, 4596, 4597, 
4598, 4599, 4600, 4601, 4602, 4603, 4604, 4605, 4606, 4607, 
4608, 4609, 4610, 4611, 4612, 4613, 5441, 5442, 5443, 5444, 
5445, 5446, 5447, 5448, 5449, 5450, 5451, 5452, 5453, 5454, 
5455, 5456, 5457, 5458, 5459, 5460, 5461, 5462, 5463, 5464, 
5465, 5466, 5467, 5468, 5469, 5470, 5471, 5472, 5473, 5474, 
5475, 5476, 5477, 5478, 5479, 5480, 5481, 5482, 5483, 5484, 
5485, 5486, 5762, 5763, 5764, 5765, 5766, 5767, 5768, 5769, 
5888, 5889, 5890, 5891, 5892, 5893, 5894, 5895, 5896, 5897, 
5898, 5899, 5900, 5901, 5902, 5903, 5904, 5905, 5906, 5907, 
5908, 5909, 5910, 5911, 5912, 5913, 5914, 5915, 5916, 5917, 
5918, 5919, 5920, 5921, 5922, 5923, 5924, 5925, 5926, 5927, 
5928, 5929, 5930, 5931, 5932, 5933, 6761, 6762, 6763, 6764, 
6765, 6766, 6767, 6768, 6769, 6770, 6771, 6772, 6773, 6774, 
6775, 6776, 6777, 6778, 6779, 6780, 6781, 6782, 6783, 6784, 
6785, 6786, 6787, 6788, 6789, 6790, 6791, 6792, 6793, 6794, 
6795, 6796, 6797, 6798, 6799, 6800, 6801, 6802, 6803, 6804, 
6805, 6806, 6807, 6808, 6809, 6810, 6811, 6812, 6813, 6814, 
6815, 6816, 6817, 6818, 6819, 6820, 6821, 6822, 6823, 6824, 
6825, 6826, 6827, 6828, 6829, 6830, 6831, 6832, 6833, 6834, 
6835, 6836, 6837, 6838, 6839, 6840, 6841, 6842, 6843, 6844, 
6845, 6846, 6847, 6848, 6849, 6850, 6851, 6852, 6853, 6854, 
6855, 6856, 6857, 6858, 6859, 6860, 6861, 6862, 6863, 6864, 
6865, 6866, 6867, 6868, 6869, 6870, 6871, 6872, 6873, 6874, 
6875, 6876, 6877, 6878, 6879, 6880, 6881, 6882, 6883, 6884, 
6885, 6886, 6887, 6888, 6889, 6890, 6891, 6892, 6893, 6894, 
6895, 6896, 6897, 6898, 6899, 6900, 6901, 6902, 6903, 6904, 
6905, 6906, 6907, 6908, 6909, 6910, 6911, 6912, 6913, 6914, 
6915, 6916, 6917, 6918, 6919, 6920, 6921, 6922, 6923, 6924, 
6925, 6926, 6927, 6928, 6929, 6930, 6931, 6932, 6933, 6934, 
6935, 6936, 6937, 6938, 6939, 6940, 6941, 6942, 6943, 6944, 
6945, 6946, 6947, 6948, 6949, 6950, 6951, 6952, 6953, 6954, 
6955, 6956, 6957, 6958, 6959, 6960, 6961, 6962, 6963, 6964, 
6965, 6966, 6967, 6968, 6969, 6970, 6971, 6972, 6973, 6974, 
6975, 6976, 6977, 6978, 6979, 6980, 6981, 6982, 6983, 6984, 
6985, 6986, 6987, 6988, 6989, 6990, 6991, 6992, 6993, 6994, 
6995, 6996, 6997, 6998, 6999, 7000, 7001, 7002, 7003, 7004, 
7005, 7006, 7007, 7008, 7009, 7010, 7011, 7012, 7013, 7014, 
7015, 7016, 7017, 7018, 7019, 7020, 7021, 7022, 7023, 7024, 
7025, 7026, 7027, 7028, 7029, 7030, 7031, 7032, 7033, 7034, 
7035, 7036, 7037, 7038, 7039, 7040, 7041, 7042, 7043, 7044, 
7045, 7046, 7047, 7048, 7049, 7050, 7051, 7052, 7053, 7054, 
7055, 7056, 7057, 7058, 7059, 7060, 7061, 7062, 7063, 7064, 
7065, 7066, 7067, 7068, 7069, 7070, 7071, 7072, 7073, 7074, 
7075, 7076, 7077, 7078, 7079, 7080, 7081, 7082, 7083, 7084, 
7085, 7086, 7087, 7088, 7089, 7090, 7091, 7092, 7093, 7094, 
7095, 7096, 7097, 7098, 7099, 7100, 7101, 7102, 7103, 7104, 
7105, 7106, 7107, 7108, 7109, 7110, 7111, 7112, 7113, 7114, 
7115, 7116, 7117, 7118, 7119, 7120, 7121, 7122, 7123, 7124, 
7125, 7126, 7127, 7128, 7129, 7130, 7131, 7132, 7133, 7134, 
7135, 7136, 7137, 7138, 7139, 7140, 7141, 7142, 7143, 7144, 
7145, 7146, 7147, 7148, 7149, 7150, 7151, 7152, 7153, 7154, 
7155, 7156, 7157, 7158, 7159, 7160, 7161, 7162, 7163, 7164, 
7165, 7166, 7167, 7168, 7169, 7170, 7171, 7172, 7173, 7174, 
7175, 7176, 7177, 7178, 7179, 7180, 7181, 7182, 7183, 7184, 
7185, 7186, 7187, 7188, 7189, 7190, 7191, 7192, 7193, 7194, 
7195, 7196, 7197, 7198, 7199, 7200, 7201, 7202, 7203, 7204, 
7205, 7206, 7207, 7208, 7209, 7210, 7211, 7212, 7213, 7214, 
7215, 7216, 7217, 7218, 7219, 7220, 7221, 7222, 7223, 7224, 
7225, 7226, 7227, 7228, 7229, 7230, 7231, 7232, 7233, 7234, 
7235, 7236, 7237, 7238, 7239, 7240, 7241, 7242, 7243, 7244, 
7245, 7246, 7247, 7248, 7249, 7250, 7251, 7252, 7253, 7254, 
7255, 7256, 7257, 7258, 7259, 7260, 7261, 7262, 7263, 7264, 
7265, 7266, 7267, 7268, 7269, 7270, 7271, 7272, 7273, 7274, 
7275, 7276, 7277, 7278, 7279, 7280, 7281, 7282, 7283, 7284, 
7285, 7286, 7287, 7288, 7289, 9416, 9417, 9418, 9419, 9420, 
9421, 9422, 9423, 9424, 9425, 9426, 9427, 9428, 9429, 9430, 
9431, 9432, 9433, 9434, 9435, 9436, 9437, 9438, 9439, 9440, 
9441, 9442, 9443, 9444, 9445, 9446, 9447, 9448, 9449, 9450, 
9451, 9452, 9453, 9454, 9455, 9456, 9457, 9458, 9459, 9460, 
9461, 15748, 15749, 15750, 15751, 15752, 15753, 15754, 15755, 15756, 
15757, 15758, 15759, 15760, 15761, 15762, 15763, 15764, 15765, 15766, 
15767, 15768, 15769, 15770, 15771, 15772, 15773, 15774, 15775, 15776, 
15777, 15778, 15779, 15780, 15781, 15782, 15783, 15784, 15785, 15786, 
15787, 15788, 15789, 15790, 15791, 15792, 15793, 15794, 15795, 15796, 
15797, 15798, 15799, 15800, 15801, 15802, 15803, 15804, 15805, 15806, 
15807, 15808, 15809, 15810, 15811, 15812, 15813, 15814, 15815, 15816, 
15817, 15818, 15819, 15820, 15821, 15822, 15823, 15824, 15825, 15826, 
15827, 15828, 15829, 15830, 15831, 15832, 15833, 15834, 15835, 15836, 
15837, 15838, 15839, 16240, 16241, 16242, 16243, 16244, 16245, 16246, 
16247, 16248, 16249, 16250, 16251, 16252, 16253, 16254, 16255, 16503, 
16504, 16505, 16506, 16507, 16508, 16509, 16510, 16511, 16512, 16513, 
16514, 16515, 16516, 16517, 16518, 16519, 16520, 16521, 16522, 16523, 
16524, 16525, 16526, 16527, 16528, 16529, 16530, 16531, 16532, 16533, 
16534, 16535, 16536, 16537, 16538, 16539, 16540, 16541, 16542, 16543, 
16544, 16545, 16546, 16547, 16548, 16549, 16550, 16551, 16552, 16553, 
16554, 16555, 16556, 16557, 16558, 16559, 16560, 16561, 16562, 16563, 
16564, 16565, 16566, 16567, 16568, 16569, 16570, 16571, 16572, 16573, 
16574, 16575, 16576, 16577, 16578, 16579, 16580, 16581, 16582, 16583, 
16584, 16585, 16586, 16587, 16588, 16589, 16590, 16591, 16592, 16593, 
16594, 17748, 17749, 17750, 17751, 17752, 17753, 17754, 17755, 17756, 
17757, 17758, 17759, 17760, 17761, 17762, 17763, 17764, 17765, 17766, 
17767, 17768, 17769, 17770, 17771, 17772, 17773, 17774, 17775, 17776, 
17777, 17778, 17779, 17780, 17781, 17782, 17783, 17784, 17785, 17786, 
17787, 17788, 17789, 17790, 17791, 17792, 17793, 17794, 17795, 17796, 
17797, 17798, 17799, 17800, 17801, 17802, 17803, 17804, 17805, 17806, 
17807, 17808, 17809, 17810, 17811, 17812, 17813, 17814, 17815, 17816, 
17817, 17818, 17819, 17820, 17821, 17822, 17823, 17824, 17825, 17826, 
17827, 17828, 17829, 17830, 17831, 17832, 17833, 17834, 17835, 17836, 
17837, 17838, 17839, 18391, 18392, 18393, 18394, 18395, 18396, 18397, 
18398, 18399, 18400, 18401, 18402, 18403, 18404, 18405, 18406, 18407, 
18408, 18409, 18410, 18411, 18412, 18413, 18414, 18415, 18416, 18417, 
18418, 18419, 18420, 18421, 18422, 18423, 18424, 18425, 18426, 18427, 
18428, 18429, 18430, 18431, 18432, 18433, 18434, 18435, 18436, 18437, 
18438, 18439, 18440, 18441, 18442, 18443, 18444, 18445, 18446, 18447, 
18448, 18449, 18450, 18451, 18452, 18453, 18454, 18455, 18456, 18457, 
18458, 18459, 18460, 18461, 18462, 18463, 18464, 18465, 18466, 18467, 
18468, 18469, 18470, 18471, 18472, 18473, 18474, 18475, 18476, 18477, 
18478, 18479, 18480, 18481, 18482, 
*NSET,NSET=Ceramic_Contact
0, 1, 2, 5, 6, 21, 22, 23, 24, 26, 
28, 30, 32, 45, 46, 47, 48, 50, 52, 53, 
54, 97, 98, 99, 100, 101, 102, 103, 104, 105, 
106, 107, 108, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 150, 151, 152, 153, 154, 155, 
156, 157, 158, 159, 160, 161, 162, 163, 164, 165, 
166, 167, 168, 169, 170, 171, 172, 173, 174, 175, 
176, 177, 178, 179, 180, 181, 182, 183, 184, 185, 
186, 187, 188, 189, 190, 191, 192, 193, 194, 195, 
542, 543, 544, 545, 546, 547, 548, 549, 550, 551, 
552, 553, 554, 555, 556, 557, 558, 559, 560, 561, 
562, 563, 564, 567, 568, 569, 570, 571, 572, 573, 
574, 575, 576, 577, 580, 581, 582, 583, 584, 585, 
586, 587, 588, 589, 590, 591, 592, 593, 594, 595, 
596, 597, 598, 599, 600, 601, 602, 603, 604, 605, 
606, 607, 608, 609, 610, 611, 612, 613, 645, 646, 
647, 648, 649, 650, 651, 652, 653, 654, 655, 679, 
680, 681, 682, 683, 684, 685, 686, 687, 688, 689, 
690, 691, 692, 693, 694, 695, 696, 697, 698, 699, 
700, 701, 727, 728, 729, 730, 731, 732, 733, 734, 
735, 736, 737, 738, 739, 740, 741, 742, 743, 744, 
745, 746, 747, 748, 749, 763, 764, 765, 766, 767, 
768, 769, 770, 771, 772, 773, 1124, 1125, 1126, 1127, 
1128, 1129, 1130, 1131, 1132, 1133, 1134, 1135, 1136, 1137, 
1138, 1139, 1140, 1141, 1142, 1143, 1144, 1145, 1146, 1157, 
1158, 1159, 1160, 1161, 1162, 1163, 1164, 1165, 1166, 1167, 
1168, 1169, 1170, 1171, 1172, 1173, 1174, 1175, 1176, 1177, 
1178, 1179, 1180, 1181, 1182, 1183, 1184, 1185, 1186, 1187, 
1188, 1189, 1190, 1191, 1192, 1193, 1194, 1195, 1196, 1197, 
1198, 1199, 1200, 1201, 1217, 1218, 1219, 1220, 1221, 1222, 
1223, 1224, 1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 
1233, 1234, 1235, 1236, 1237, 1238, 2452, 2453, 2454, 2455, 
2456, 2457, 2458, 2459, 2460, 2461, 2462, 2463, 2464, 2465, 
2466, 2467, 2468, 2469, 2470, 2471, 2472, 2473, 2474, 2475, 
2476, 2477, 2478, 2479, 2480, 2481, 2482, 2483, 2484, 2485, 
2486, 2487, 2488, 2489, 2490, 2491, 2492, 2493, 2494, 2495, 
2496, 2497, 2498, 2499, 2500, 2501, 2502, 2503, 2504, 2505, 
2506, 2507, 2508, 2509, 2510, 2511, 2512, 2513, 2514, 2515, 
2516, 2517, 2518, 2519, 2520, 2521, 2522, 2523, 2524, 2525, 
2526, 2527, 2528, 2529, 2530, 2531, 2532, 2533, 2534, 2535, 
2536, 2537, 2538, 2539, 2540, 2541, 2542, 2543, 2544, 2545, 
2546, 2547, 2548, 2549, 2550, 2551, 2552, 2553, 2554, 2555, 
2556, 2557, 2558, 2559, 2560, 2561, 2562, 2563, 2564, 2565, 
2566, 2567, 2568, 2569, 2570, 2571, 2572, 2573, 2574, 2575, 
2576, 2577, 2578, 2579, 2580, 2581, 2582, 2583, 2584, 2585, 
2586, 2587, 2588, 2589, 2590, 2591, 2592, 2593, 2594, 2595, 
2596, 2597, 2598, 2599, 2600, 2601, 2602, 2603, 2604, 2605, 
2606, 2607, 2608, 2609, 2610, 2611, 2612, 2613, 2614, 2615, 
2616, 2617, 2618, 2619, 2620, 2621, 2622, 2623, 2624, 2625, 
2626, 2627, 2628, 2629, 2630, 2631, 2632, 2633, 2634, 2635, 
2636, 2637, 2638, 2639, 2640, 2641, 2642, 2643, 2644, 2645, 
2646, 2647, 2648, 2649, 2650, 2651, 2652, 2653, 2654, 2655, 
2656, 2657, 2658, 2659, 2660, 2661, 2662, 2663, 2664, 2665, 
2666, 2667, 2668, 2669, 2670, 2671, 2672, 2673, 2674, 2675, 
2676, 2677, 2678, 2679, 2680, 2681, 2682, 2683, 2684, 2685, 
2686, 2687, 2688, 2689, 2690, 2691, 2692, 2693, 2694, 2695, 
2696, 2697, 2698, 2699, 2700, 2701, 2702, 2703, 2704, 5509, 
5510, 5511, 5512, 5513, 5514, 5515, 5516, 5517, 5518, 5519, 
5520, 5521, 5522, 5523, 5524, 5525, 5526, 5527, 5528, 5529, 
5530, 5531, 5532, 5533, 5534, 5535, 5536, 5537, 5538, 5539, 
5540, 5541, 5542, 5543, 5544, 5545, 5546, 5547, 5548, 5549, 
5550, 5551, 5552, 5553, 5554, 5555, 5556, 5557, 5558, 5559, 
5560, 5561, 5562, 5563, 5564, 5565, 5566, 5567, 5568, 5569, 
5570, 5571, 5572, 5573, 5574, 5575, 5576, 5577, 5578, 5579, 
5580, 5581, 5582, 5583, 5584, 5585, 5586, 5587, 5588, 5589, 
5590, 5591, 5592, 5593, 5594, 5595, 5596, 5597, 5598, 5599, 
5600, 5601, 5602, 5603, 5604, 5605, 5606, 5607, 5608, 5609, 
5610, 5611, 5612, 5613, 5614, 5615, 5616, 5617, 5618, 5619, 
5620, 5621, 5622, 5623, 5624, 5625, 5626, 5627, 5628, 5629, 
5630, 5631, 5632, 5633, 5634, 5635, 5636, 5637, 5638, 5639, 
5640, 5641, 5642, 5643, 5644, 5645, 5646, 5647, 5648, 5649, 
5650, 5651, 5652, 5653, 5654, 5655, 5656, 5657, 5658, 5659, 
5660, 5661, 5662, 5663, 5664, 5665, 5666, 5667, 5668, 5669, 
5670, 5671, 5672, 5673, 5674, 5675, 5676, 5677, 5678, 5679, 
5680, 5681, 5682, 5683, 5684, 5685, 5686, 5687, 5688, 5689, 
5690, 5691, 5692, 5693, 5694, 5695, 5696, 5697, 5698, 5699, 
5700, 5701, 5702, 5703, 5704, 5705, 5706, 5707, 5708, 5709, 
5710, 5711, 5712, 5713, 5714, 5715, 5716, 5717, 5718, 5719, 
5720, 5721, 5722, 5723, 5724, 5725, 5726, 5727, 5728, 5729, 
5730, 5731, 5732, 5733, 5734, 5735, 5736, 5737, 5738, 5739, 
5740, 5741, 5742, 5743, 5744, 5745, 5746, 5747, 5748, 5749, 
5750, 5751, 5752, 5753, 5754, 5755, 5756, 5757, 5758, 5759, 
5760, 5761, 6233, 6234, 6235, 6236, 6237, 6238, 6239, 6240, 
6241, 6242, 6243, 6244, 6245, 6246, 6247, 6248, 6249, 6250, 
6251, 6252, 6253, 6254, 6255, 6256, 6257, 6258, 6259, 6260, 
6261, 6262, 6263, 6264, 6265, 6266, 6267, 6268, 6269, 6270, 
6271, 6272, 6273, 6274, 6275, 6276, 6277, 6278, 6279, 6280, 
6281, 6282, 6283, 6284, 6285, 6286, 6287, 6288, 6289, 6290, 
6291, 6292, 6293, 6294, 6295, 6296, 6297, 6298, 6299, 6300, 
6301, 6302, 6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 
6311, 6312, 6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 
6321, 6322, 6323, 6324, 6325, 6326, 6327, 6328, 6329, 6330, 
6331, 6332, 6333, 6334, 6335, 6336, 6337, 6338, 6339, 6340, 
6341, 6342, 6343, 6344, 6345, 6346, 6347, 6348, 6349, 6350, 
6351, 6352, 6353, 6354, 6355, 6356, 6357, 6358, 6359, 6360, 
6361, 6362, 6363, 6364, 6365, 6366, 6367, 6368, 6369, 6370, 
6371, 6372, 6373, 6374, 6375, 6376, 6377, 6378, 6379, 6380, 
6381, 6382, 6383, 6384, 6385, 6386, 6387, 6388, 6389, 6390, 
6391, 6392, 6393, 6394, 6395, 6396, 6397, 6398, 6399, 6400, 
6401, 6402, 6403, 6404, 6405, 6406, 6407, 6408, 6409, 6410, 
6411, 6412, 6413, 6414, 6415, 6416, 6417, 6418, 6419, 6420, 
6421, 6422, 6423, 6424, 6425, 6426, 6427, 6428, 6429, 6430, 
6431, 6432, 6433, 6434, 6435, 6436, 6437, 6438, 6439, 6440, 
6441, 6442, 6443, 6444, 6445, 6446, 6447, 6448, 6449, 6450, 
6451, 6452, 6453, 6454, 6455, 6456, 6457, 6458, 6459, 6460, 
6461, 6462, 6463, 6464, 6465, 6466, 6467, 6468, 6469, 6470, 
6471, 6472, 6473, 6474, 6475, 6476, 6477, 6478, 6479, 6480, 
6481, 6482, 6483, 6484, 6485, 9783, 9784, 9785, 9786, 9787, 
9788, 9789, 9790, 9791, 9792, 9793, 9794, 9795, 9796, 9797, 
9798, 9799, 9800, 9801, 9802, 9803, 9804, 9805, 9806, 9807, 
9808, 9809, 9810, 9811, 9812, 9813, 9814, 9815, 9816, 9817, 
9818, 9819, 9820, 9821, 9822, 9823, 9824, 9825, 9826, 9827, 
9828, 9829, 9830, 9831, 9832, 9833, 9834, 9835, 9836, 9837, 
9838, 9839, 9840, 9841, 9842, 9843, 9844, 9845, 9846, 9847, 
9848, 9849, 9850, 9851, 9852, 9853, 9854, 9855, 9856, 9857, 
9858, 9859, 9860, 9861, 9862, 9863, 9864, 9865, 9866, 9867, 
9868, 9869, 9870, 9871, 9872, 9873, 9874, 9875, 9876, 9877, 
9878, 9879, 9880, 9881, 9882, 9883, 9884, 9885, 9886, 9887, 
9888, 9889, 9890, 9891, 9892, 9893, 9894, 9895, 9896, 9897, 
9898, 9899, 9900, 9901, 9902, 9903, 9904, 9905, 9906, 9907, 
9908, 9909, 9910, 9911, 9912, 9913, 9914, 9915, 9916, 9917, 
9918, 9919, 9920, 9921, 9922, 9923, 9924, 9925, 9926, 9927, 
9928, 9929, 9930, 9931, 9932, 9933, 9934, 9935, 9936, 9937, 
9938, 9939, 9940, 9941, 9942, 9943, 9944, 9945, 9946, 9947, 
9948, 9949, 9950, 9951, 9952, 9953, 9954, 9955, 9956, 9957, 
9958, 9959, 9960, 9961, 9962, 9963, 9964, 9965, 9966, 9967, 
9968, 9969, 9970, 9971, 9972, 9973, 9974, 9975, 9976, 9977, 
9978, 9979, 9980, 9981, 9982, 9983, 9984, 9985, 9986, 9987, 
9988, 9989, 9990, 9991, 9992, 9993, 9994, 9995, 9996, 9997, 
9998, 9999, 10000, 10001, 10002, 10003, 10004, 10005, 10006, 10007, 
10008, 10009, 10010, 10011, 10012, 10013, 10014, 10015, 10016, 10017, 
10018, 10019, 10020, 10021, 10022, 10023, 10024, 10025, 10026, 10027, 
10028, 10029, 10030, 10031, 10032, 10033, 10034, 10035, 
*NSET,NSET=Contact_CeramicTop
0, 21, 22, 23, 24, 26, 28, 30, 32, 542, 
543, 544, 545, 546, 547, 548, 549, 550, 551, 552, 
553, 554, 555, 556, 557, 558, 559, 560, 561, 562, 
563, 564, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 577, 580, 581, 582, 583, 584, 585, 586, 
587, 588, 589, 590, 591, 592, 593, 594, 595, 596, 
597, 598, 599, 600, 601, 602, 603, 604, 605, 606, 
607, 608, 609, 610, 611, 612, 613, 618, 619, 620, 
621, 628, 629, 630, 631, 645, 646, 647, 648, 649, 
650, 651, 652, 653, 654, 655, 679, 680, 681, 682, 
683, 684, 685, 686, 687, 688, 689, 690, 691, 692, 
693, 694, 695, 696, 697, 698, 699, 700, 701, 727, 
728, 729, 730, 731, 732, 733, 734, 735, 736, 737, 
738, 739, 740, 741, 742, 743, 744, 745, 746, 747, 
748, 749, 763, 764, 765, 766, 767, 768, 769, 770, 
771, 772, 773, 5509, 5510, 5511, 5512, 5513, 5514, 5515, 
5516, 5517, 5518, 5519, 5520, 5521, 5522, 5523, 5524, 5525, 
5526, 5527, 5528, 5529, 5530, 5531, 5532, 5533, 5534, 5535, 
5536, 5537, 5538, 5539, 5540, 5541, 5542, 5543, 5544, 5545, 
5546, 5547, 5548, 5549, 5550, 5551, 5552, 5553, 5554, 5555, 
5556, 5557, 5558, 5559, 5560, 5561, 5562, 5563, 5564, 5565, 
5566, 5567, 5568, 5569, 5570, 5571, 5572, 5573, 5574, 5575, 
5576, 5577, 5578, 5579, 5580, 5581, 5582, 5583, 5584, 5585, 
5586, 5587, 5588, 5589, 5590, 5591, 5592, 5593, 5594, 5595, 
5596, 5597, 5598, 5599, 5600, 5601, 5602, 5603, 5604, 5605, 
5606, 5607, 5608, 5609, 5610, 5611, 5612, 5613, 5614, 5615, 
5616, 5617, 5618, 5619, 5620, 5621, 5622, 5623, 5624, 5625, 
5626, 5627, 5628, 5629, 5630, 5631, 5632, 5633, 5634, 5635, 
5636, 5637, 5638, 5639, 5640, 5641, 5642, 5643, 5644, 5645, 
5646, 5647, 5648, 5649, 5650, 5651, 5652, 5653, 5654, 5655, 
5656, 5657, 5658, 5659, 5660, 5661, 5662, 5663, 5664, 5665, 
5666, 5667, 5668, 5669, 5670, 5671, 5672, 5673, 5674, 5675, 
5676, 5677, 5678, 5679, 5680, 5681, 5682, 5683, 5684, 5685, 
5686, 5687, 5688, 5689, 5690, 5691, 5692, 5693, 5694, 5695, 
5696, 5697, 5698, 5699, 5700, 5701, 5702, 5703, 5704, 5705, 
5706, 5707, 5708, 5709, 5710, 5711, 5712, 5713, 5714, 5715, 
5716, 5717, 5718, 5719, 5720, 5721, 5722, 5723, 5724, 5725, 
5726, 5727, 5728, 5729, 5730, 5731, 5732, 5733, 5734, 5735, 
5736, 5737, 5738, 5739, 5740, 5741, 5742, 5743, 5744, 5745, 
5746, 5747, 5748, 5749, 5750, 5751, 5752, 5753, 5754, 5755, 
5756, 5757, 5758, 5759, 5760, 5761, 5822, 5823, 5824, 5825, 
5826, 5827, 5828, 5829, 5830, 5831, 5832, 5833, 5834, 5835, 
5836, 5837, 5838, 5839, 5840, 5841, 5842, 5843, 5844, 5845, 
5846, 5847, 5848, 5849, 5850, 5851, 5852, 5853, 5854, 5855, 
5856, 5857, 5858, 5859, 5860, 5861, 5862, 5863, 5864, 5865, 
6233, 6234, 6235, 6236, 6237, 6238, 6239, 6240, 6241, 6242, 
6243, 6244, 6245, 6246, 6247, 6248, 6249, 6250, 6251, 6252, 
6253, 6254, 6255, 6256, 6257, 6258, 6259, 6260, 6261, 6262, 
6263, 6264, 6265, 6266, 6267, 6268, 6269, 6270, 6271, 6272, 
6273, 6274, 6275, 6276, 6277, 6278, 6279, 6280, 6281, 6282, 
6283, 6284, 6285, 6286, 6287, 6288, 6289, 6290, 6291, 6292, 
6293, 6294, 6295, 6296, 6297, 6298, 6299, 6300, 6301, 6302, 
6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 6311, 6312, 
6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 6321, 6322, 
6323, 6324, 6325, 6326, 6327, 6328, 6329, 6330, 6331, 6332, 
6333, 6334, 6335, 6336, 6337, 6338, 6339, 6340, 6341, 6342, 
6343, 6344, 6345, 6346, 6347, 6348, 6349, 6350, 6351, 6352, 
6353, 6354, 6355, 6356, 6357, 6358, 6359, 6360, 6361, 6362, 
6363, 6364, 6365, 6366, 6367, 6368, 6369, 6370, 6371, 6372, 
6373, 6374, 6375, 6376, 6377, 6378, 6379, 6380, 6381, 6382, 
6383, 6384, 6385, 6386, 6387, 6388, 6389, 6390, 6391, 6392, 
6393, 6394, 6395, 6396, 6397, 6398, 6399, 6400, 6401, 6402, 
6403, 6404, 6405, 6406, 6407, 6408, 6409, 6410, 6411, 6412, 
6413, 6414, 6415, 6416, 6417, 6418, 6419, 6420, 6421, 6422, 
6423, 6424, 6425, 6426, 6427, 6428, 6429, 6430, 6431, 6432, 
6433, 6434, 6435, 6436, 6437, 6438, 6439, 6440, 6441, 6442, 
6443, 6444, 6445, 6446, 6447, 6448, 6449, 6450, 6451, 6452, 
6453, 6454, 6455, 6456, 6457, 6458, 6459, 6460, 6461, 6462, 
6463, 6464, 6465, 6466, 6467, 6468, 6469, 6470, 6471, 6472, 
6473, 6474, 6475, 6476, 6477, 6478, 6479, 6480, 6481, 6482, 
6483, 6484, 6485, 
*NSET,NSET=Contact_CeramicBottom
0, 1, 2, 5, 6, 45, 46, 47, 48, 50, 
52, 53, 54, 97, 98, 99, 100, 101, 102, 103, 
104, 105, 106, 107, 108, 124, 125, 126, 127, 128, 
129, 130, 131, 132, 133, 134, 150, 151, 152, 153, 
154, 155, 156, 157, 158, 159, 160, 161, 162, 163, 
164, 165, 166, 167, 168, 169, 170, 171, 172, 173, 
174, 175, 176, 177, 178, 179, 180, 181, 182, 183, 
184, 185, 186, 187, 188, 189, 190, 191, 192, 193, 
194, 195, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 1131, 
1132, 1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 1141, 
1142, 1143, 1144, 1145, 1146, 1157, 1158, 1159, 1160, 1161, 
1162, 1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 1171, 
1172, 1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180, 1181, 
1182, 1183, 1184, 1185, 1186, 1187, 1188, 1189, 1190, 1191, 
1192, 1193, 1194, 1195, 1196, 1197, 1198, 1199, 1200, 1201, 
1217, 1218, 1219, 1220, 1221, 1222, 1223, 1224, 1225, 1226, 
1227, 1228, 1229, 1230, 1231, 1232, 1233, 1234, 1235, 1236, 
1237, 1238, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 2459, 
2460, 2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 2469, 
2470, 2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 2479, 
2480, 2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 2489, 
2490, 2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 2499, 
2500, 2501, 2502, 2503, 2504, 2505, 2506, 2507, 2508, 2509, 
2510, 2511, 2512, 2513, 2514, 2515, 2516, 2517, 2518, 2519, 
2520, 2521, 2522, 2523, 2524, 2525, 2526, 2527, 2528, 2529, 
2530, 2531, 2532, 2533, 2534, 2535, 2536, 2537, 2538, 2539, 
2540, 2541, 2542, 2543, 2544, 2545, 2546, 2547, 2548, 2549, 
2550, 2551, 2552, 2553, 2554, 2555, 2556, 2557, 2558, 2559, 
2560, 2561, 2562, 2563, 2564, 2565, 2566, 2567, 2568, 2569, 
2570, 2571, 2572, 2573, 2574, 2575, 2576, 2577, 2578, 2579, 
2580, 2581, 2582, 2583, 2584, 2585, 2586, 2587, 2588, 2589, 
2590, 2591, 2592, 2593, 2594, 2595, 2596, 2597, 2598, 2599, 
2600, 2601, 2602, 2603, 2604, 2605, 2606, 2607, 2608, 2609, 
2610, 2611, 2612, 2613, 2614, 2615, 2616, 2617, 2618, 2619, 
2620, 2621, 2622, 2623, 2624, 2625, 2626, 2627, 2628, 2629, 
2630, 2631, 2632, 2633, 2634, 2635, 2636, 2637, 2638, 2639, 
2640, 2641, 2642, 2643, 2644, 2645, 2646, 2647, 2648, 2649, 
2650, 2651, 2652, 2653, 2654, 2655, 2656, 2657, 2658, 2659, 
2660, 2661, 2662, 2663, 2664, 2665, 2666, 2667, 2668, 2669, 
2670, 2671, 2672, 2673, 2674, 2675, 2676, 2677, 2678, 2679, 
2680, 2681, 2682, 2683, 2684, 2685, 2686, 2687, 2688, 2689, 
2690, 2691, 2692, 2693, 2694, 2695, 2696, 2697, 2698, 2699, 
2700, 2701, 2702, 2703, 2704, 9783, 9784, 9785, 9786, 9787, 
9788, 9789, 9790, 9791, 9792, 9793, 9794, 9795, 9796, 9797, 
9798, 9799, 9800, 9801, 9802, 9803, 9804, 9805, 9806, 9807, 
9808, 9809, 9810, 9811, 9812, 9813, 9814, 9815, 9816, 9817, 
9818, 9819, 9820, 9821, 9822, 9823, 9824, 9825, 9826, 9827, 
9828, 9829, 9830, 9831, 9832, 9833, 9834, 9835, 9836, 9837, 
9838, 9839, 9840, 9841, 9842, 9843, 9844, 9845, 9846, 9847, 
9848, 9849, 9850, 9851, 9852, 9853, 9854, 9855, 9856, 9857, 
9858, 9859, 9860, 9861, 9862, 9863, 9864, 9865, 9866, 9867, 
9868, 9869, 9870, 9871, 9872, 9873, 9874, 9875, 9876, 9877, 
9878, 9879, 9880, 9881, 9882, 9883, 9884, 9885, 9886, 9887, 
9888, 9889, 9890, 9891, 9892, 9893, 9894, 9895, 9896, 9897, 
9898, 9899, 9900, 9901, 9902, 9903, 9904, 9905, 9906, 9907, 
9908, 9909, 9910, 9911, 9912, 9913, 9914, 9915, 9916, 9917, 
9918, 9919, 9920, 9921, 9922, 9923, 9924, 9925, 9926, 9927, 
9928, 9929, 9930, 9931, 9932, 9933, 9934, 9935, 9936, 9937, 
9938, 9939, 9940, 9941, 9942, 9943, 9944, 9945, 9946, 9947, 
9948, 9949, 9950, 9951, 9952, 9953, 9954, 9955, 9956, 9957, 
9958, 9959, 9960, 9961, 9962, 9963, 9964, 9965, 9966, 9967, 
9968, 9969, 9970, 9971, 9972, 9973, 9974, 9975, 9976, 9977, 
9978, 9979, 9980, 9981, 9982, 9983, 9984, 9985, 9986, 9987, 
9988, 9989, 9990, 9991, 9992, 9993, 9994, 9995, 9996, 9997, 
9998, 9999, 10000, 10001, 10002, 10003, 10004, 10005, 10006, 10007, 
10008, 10009, 10010, 10011, 10012, 10013, 10014, 10015, 10016, 10017, 
10018, 10019, 10020, 10021, 10022, 10023, 10024, 10025, 10026, 10027, 
10028, 10029, 10030, 10031, 10032, 10033, 10034, 10035, 
*NSET,NSET=Surface_2D
0, 1, 3, 5, 7, 11, 12, 15, 16, 19, 
20, 23, 24, 25, 26, 29, 30, 33, 34, 37, 
38, 41, 42, 45, 46, 49, 50, 53, 55, 79, 
80, 81, 83, 87, 88, 89, 91, 92, 95, 109, 
110, 135, 136, 173, 174, 175, 176, 177, 178, 179, 
180, 181, 182, 183, 184, 185, 186, 187, 188, 189, 
190, 191, 192, 193, 194, 195, 219, 220, 221, 222, 
223, 224, 225, 226, 227, 228, 229, 230, 231, 232, 
233, 234, 235, 236, 237, 238, 239, 240, 241, 276, 
277, 278, 279, 280, 281, 282, 283, 284, 285, 286, 
287, 288, 289, 290, 291, 292, 293, 294, 295, 296, 
297, 298, 379, 380, 381, 382, 383, 384, 385, 386, 
387, 388, 389, 390, 391, 392, 393, 394, 395, 396, 
397, 398, 399, 400, 401, 413, 414, 415, 416, 417, 
418, 419, 420, 421, 422, 423, 424, 425, 426, 427, 
428, 429, 430, 431, 432, 433, 434, 435, 436, 437, 
438, 439, 440, 441, 442, 443, 444, 445, 446, 447, 
448, 449, 450, 451, 452, 453, 454, 455, 456, 457, 
458, 504, 505, 506, 507, 508, 509, 510, 511, 512, 
513, 514, 515, 516, 517, 518, 519, 520, 521, 522, 
523, 524, 525, 526, 565, 566, 578, 579, 580, 581, 
582, 583, 584, 585, 586, 587, 588, 589, 590, 591, 
592, 593, 594, 595, 596, 597, 598, 599, 600, 601, 
602, 614, 615, 616, 617, 618, 619, 620, 621, 622, 
623, 656, 657, 658, 659, 660, 661, 662, 663, 664, 
665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 
675, 676, 677, 678, 679, 680, 681, 682, 683, 684, 
685, 686, 687, 688, 689, 690, 691, 692, 693, 694, 
695, 696, 697, 698, 699, 700, 701, 702, 703, 774, 
775, 776, 777, 778, 779, 780, 781, 782, 783, 784, 
785, 786, 787, 788, 789, 790, 791, 792, 793, 794, 
795, 796, 842, 843, 844, 845, 846, 847, 848, 849, 
850, 851, 852, 853, 854, 855, 856, 857, 858, 859, 
860, 861, 862, 863, 864, 865, 866, 867, 868, 869, 
870, 871, 872, 873, 874, 875, 876, 877, 878, 879, 
880, 881, 882, 883, 884, 885, 886, 887, 888, 889, 
890, 891, 892, 893, 894, 895, 896, 897, 898, 899, 
900, 901, 902, 903, 904, 905, 906, 907, 908, 909, 
910, 1002, 1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 
1011, 1012, 1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 
1021, 1022, 1023, 1024, 1120, 1121, 1122, 1123, 1124, 1125, 
1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 1135, 
1136, 1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 1145, 
1146, 1202, 1203, 1239, 1240, 2017, 2018, 2019, 2020, 2032, 
2033, 2034, 2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 
2043, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 
2053, 2054, 2055, 2056, 2057, 2058, 2070, 2071, 2072, 2073, 
2074, 2075, 2076, 2077, 2102, 2103, 2104, 2105, 2106, 2107, 
2108, 2109, 2110, 2111, 2112, 2113, 2114, 2115, 2116, 2117, 
2118, 2119, 2120, 2121, 2122, 2123, 2124, 2125, 2126, 2127, 
2128, 2213, 2214, 2215, 2216, 2228, 2229, 2230, 2231, 2232, 
2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 2241, 2242, 
2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 2251, 2252, 
2253, 2254, 2266, 2267, 2268, 2269, 2290, 2291, 2292, 2293, 
2294, 2295, 2296, 2297, 2298, 2299, 2300, 2301, 2302, 2303, 
2304, 2305, 2306, 2307, 2308, 2309, 2310, 2311, 2312, 2313, 
2314, 2315, 2316, 2317, 2318, 2319, 2320, 2384, 2385, 2386, 
2387, 3004, 3005, 3006, 3007, 3008, 3009, 3010, 3011, 3012, 
3013, 3014, 3015, 3016, 3017, 3018, 3019, 3020, 3021, 3022, 
3023, 3024, 3025, 3026, 3027, 3028, 3029, 3030, 3031, 3032, 
3033, 3034, 3035, 3036, 3037, 3038, 3039, 3040, 3041, 3042, 
3043, 3044, 3045, 3046, 3047, 3048, 3049, 4085, 4086, 4087, 
4088, 4089, 4090, 4091, 4092, 4093, 4094, 4095, 4096, 4097, 
4098, 4099, 4100, 4101, 4102, 4103, 4104, 4105, 4106, 4107, 
4108, 4109, 4110, 4111, 4112, 4113, 4114, 4115, 4116, 4117, 
4118, 4119, 4120, 4121, 4122, 4123, 4124, 4125, 4126, 4127, 
4128, 4129, 4130, 4131, 4132, 4133, 4134, 4135, 4136, 4137, 
4138, 4139, 4140, 4141, 4142, 4143, 4144, 4145, 4146, 4147, 
4148, 4149, 4150, 4151, 4152, 4153, 4154, 4155, 4156, 4157, 
4158, 4159, 4160, 4161, 4162, 4163, 4164, 4165, 4166, 4167, 
4168, 4169, 4170, 4171, 4172, 4173, 4174, 4175, 4176, 4177, 
4178, 4179, 4180, 4181, 4182, 4183, 4184, 4185, 4186, 4187, 
4188, 4189, 4190, 4191, 4192, 4193, 4194, 4195, 4196, 4197, 
4198, 4199, 4200, 4201, 4202, 4203, 4204, 4205, 4206, 4207, 
4208, 4209, 4210, 4211, 4212, 4213, 4214, 4215, 4216, 4217, 
4218, 4219, 4220, 4221, 4222, 4223, 4224, 4225, 4226, 4227, 
4228, 4229, 4230, 4231, 4232, 4233, 4234, 4235, 4236, 4237, 
4238, 4239, 4240, 4241, 4242, 4243, 4244, 4245, 4246, 4247, 
4248, 4249, 4250, 4251, 4252, 4253, 4254, 4255, 4256, 4257, 
4258, 4259, 4260, 4261, 4262, 4263, 4264, 4265, 4266, 4267, 
4268, 4269, 4270, 4271, 4272, 4273, 4274, 4275, 4276, 4277, 
4278, 4279, 4280, 4281, 4282, 4283, 4284, 4285, 4286, 4287, 
4288, 4289, 4290, 4291, 4292, 4293, 4294, 4295, 4296, 4297, 
4298, 4299, 4300, 4301, 4302, 4303, 4304, 4305, 4306, 4307, 
4308, 4309, 4310, 4311, 4312, 4313, 4314, 4315, 4316, 4317, 
4318, 4319, 4320, 4321, 4322, 4323, 4324, 4325, 4326, 4327, 
4328, 4329, 4330, 4331, 4332, 4333, 4334, 4335, 4336, 4337, 
4338, 4339, 4340, 4341, 4342, 4343, 4344, 4345, 4346, 4347, 
4348, 4349, 4350, 4351, 4352, 4353, 4354, 4355, 4356, 4357, 
4358, 4359, 4360, 4361, 4362, 4363, 4364, 4365, 4366, 4367, 
4368, 4369, 4370, 4371, 4372, 4373, 4374, 4375, 4376, 4377, 
4378, 4379, 4380, 4381, 4382, 4383, 4384, 4385, 4386, 4387, 
4388, 4389, 4390, 4391, 4392, 4393, 4394, 4395, 4396, 4397, 
4398, 4399, 4400, 4401, 4402, 4403, 4404, 4405, 4406, 4407, 
4408, 4409, 4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 
4418, 4419, 4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 
4428, 4429, 4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 
4438, 4439, 4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 
4448, 4449, 4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 
4458, 4459, 4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 
4468, 4469, 4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 
4478, 4479, 4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 
4488, 4489, 4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 
4498, 4499, 4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 
4508, 4509, 4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 
4518, 4519, 4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 
4528, 4529, 4530, 4531, 4532, 4533, 4534, 4535, 4536, 4537, 
4538, 4539, 4540, 4541, 4542, 4543, 4544, 4545, 4546, 4547, 
4548, 4549, 4550, 4551, 4552, 4553, 4554, 4555, 4556, 4557, 
4558, 4559, 4560, 4561, 4562, 4563, 4564, 4565, 4566, 4567, 
4568, 4569, 4570, 4571, 4572, 4573, 4574, 4575, 4576, 4577, 
4578, 4579, 4580, 4581, 4582, 4583, 4584, 4585, 4586, 4587, 
4588, 4589, 4590, 4591, 4592, 4593, 4594, 4595, 4596, 4597, 
4598, 4599, 4600, 4601, 4602, 4603, 4604, 4605, 4606, 4607, 
4608, 4609, 4610, 4611, 4612, 4613, 5441, 5442, 5443, 5444, 
5445, 5446, 5447, 5448, 5449, 5450, 5451, 5452, 5453, 5454, 
5455, 5456, 5457, 5458, 5459, 5460, 5461, 5462, 5463, 5464, 
5465, 5466, 5467, 5468, 5469, 5470, 5471, 5472, 5473, 5474, 
5475, 5476, 5477, 5478, 5479, 5480, 5481, 5482, 5483, 5484, 
5485, 5486, 5762, 5763, 5764, 5765, 5766, 5767, 5768, 5769, 
5888, 5889, 5890, 5891, 5892, 5893, 5894, 5895, 5896, 5897, 
5898, 5899, 5900, 5901, 5902, 5903, 5904, 5905, 5906, 5907, 
5908, 5909, 5910, 5911, 5912, 5913, 5914, 5915, 5916, 5917, 
5918, 5919, 5920, 5921, 5922, 5923, 5924, 5925, 5926, 5927, 
5928, 5929, 5930, 5931, 5932, 5933, 6761, 6762, 6763, 6764, 
6765, 6766, 6767, 6768, 6769, 6770, 6771, 6772, 6773, 6774, 
6775, 6776, 6777, 6778, 6779, 6780, 6781, 6782, 6783, 6784, 
6785, 6786, 6787, 6788, 6789, 6790, 6791, 6792, 6793, 6794, 
6795, 6796, 6797, 6798, 6799, 6800, 6801, 6802, 6803, 6804, 
6805, 6806, 6807, 6808, 6809, 6810, 6811, 6812, 6813, 6814, 
6815, 6816, 6817, 6818, 6819, 6820, 6821, 6822, 6823, 6824, 
6825, 6826, 6827, 6828, 6829, 6830, 6831, 6832, 6833, 6834, 
6835, 6836, 6837, 6838, 6839, 6840, 6841, 6842, 6843, 6844, 
6845, 6846, 6847, 6848, 6849, 6850, 6851, 6852, 6853, 6854, 
6855, 6856, 6857, 6858, 6859, 6860, 6861, 6862, 6863, 6864, 
6865, 6866, 6867, 6868, 6869, 6870, 6871, 6872, 6873, 6874, 
6875, 6876, 6877, 6878, 6879, 6880, 6881, 6882, 6883, 6884, 
6885, 6886, 6887, 6888, 6889, 6890, 6891, 6892, 6893, 6894, 
6895, 6896, 6897, 6898, 6899, 6900, 6901, 6902, 6903, 6904, 
6905, 6906, 6907, 6908, 6909, 6910, 6911, 6912, 6913, 6914, 
6915, 6916, 6917, 6918, 6919, 6920, 6921, 6922, 6923, 6924, 
6925, 6926, 6927, 6928, 6929, 6930, 6931, 6932, 6933, 6934, 
6935, 6936, 6937, 6938, 6939, 6940, 6941, 6942, 6943, 6944, 
6945, 6946, 6947, 6948, 6949, 6950, 6951, 6952, 6953, 6954, 
6955, 6956, 6957, 6958, 6959, 6960, 6961, 6962, 6963, 6964, 
6965, 6966, 6967, 6968, 6969, 6970, 6971, 6972, 6973, 6974, 
6975, 6976, 6977, 6978, 6979, 6980, 6981, 6982, 6983, 6984, 
6985, 6986, 6987, 6988, 6989, 6990, 6991, 6992, 6993, 6994, 
6995, 6996, 6997, 6998, 6999, 7000, 7001, 7002, 7003, 7004, 
7005, 7006, 7007, 7008, 7009, 7010, 7011, 7012, 7013, 7014, 
7015, 7016, 7017, 7018, 7019, 7020, 7021, 7022, 7023, 7024, 
7025, 7026, 7027, 7028, 7029, 7030, 7031, 7032, 7033, 7034, 
7035, 7036, 7037, 7038, 7039, 7040, 7041, 7042, 7043, 7044, 
7045, 7046, 7047, 7048, 7049, 7050, 7051, 7052, 7053, 7054, 
7055, 7056, 7057, 7058, 7059, 7060, 7061, 7062, 7063, 7064, 
7065, 7066, 7067, 7068, 7069, 7070, 7071, 7072, 7073, 7074, 
7075, 7076, 7077, 7078, 7079, 7080, 7081, 7082, 7083, 7084, 
7085, 7086, 7087, 7088, 7089, 7090, 7091, 7092, 7093, 7094, 
7095, 7096, 7097, 7098, 7099, 7100, 7101, 7102, 7103, 7104, 
7105, 7106, 7107, 7108, 7109, 7110, 7111, 7112, 7113, 7114, 
7115, 7116, 7117, 7118, 7119, 7120, 7121, 7122, 7123, 7124, 
7125, 7126, 7127, 7128, 7129, 7130, 7131, 7132, 7133, 7134, 
7135, 7136, 7137, 7138, 7139, 7140, 7141, 7142, 7143, 7144, 
7145, 7146, 7147, 7148, 7149, 7150, 7151, 7152, 7153, 7154, 
7155, 7156, 7157, 7158, 7159, 7160, 7161, 7162, 7163, 7164, 
7165, 7166, 7167, 7168, 7169, 7170, 7171, 7172, 7173, 7174, 
7175, 7176, 7177, 7178, 7179, 7180, 7181, 7182, 7183, 7184, 
7185, 7186, 7187, 7188, 7189, 7190, 7191, 7192, 7193, 7194, 
7195, 7196, 7197, 7198, 7199, 7200, 7201, 7202, 7203, 7204, 
7205, 7206, 7207, 7208, 7209, 7210, 7211, 7212, 7213, 7214, 
7215, 7216, 7217, 7218, 7219, 7220, 7221, 7222, 7223, 7224, 
7225, 7226, 7227, 7228, 7229, 7230, 7231, 7232, 7233, 7234, 
7235, 7236, 7237, 7238, 7239, 7240, 7241, 7242, 7243, 7244, 
7245, 7246, 7247, 7248, 7249, 7250, 7251, 7252, 7253, 7254, 
7255, 7256, 7257, 7258, 7259, 7260, 7261, 7262, 7263, 7264, 
7265, 7266, 7267, 7268, 7269, 7270, 7271, 7272, 7273, 7274, 
7275, 7276, 7277, 7278, 7279, 7280, 7281, 7282, 7283, 7284, 
7285, 7286, 7287, 7288, 7289, 9416, 9417, 9418, 9419, 9420, 
9421, 9422, 9423, 9424, 9425, 9426, 9427, 9428, 9429, 9430, 
9431, 9432, 9433, 9434, 9435, 9436, 9437, 9438, 9439, 9440, 
9441, 9442, 9443, 9444, 9445, 9446, 9447, 9448, 9449, 9450, 
9451, 9452, 9453, 9454, 9455, 9456, 9457, 9458, 9459, 9460, 
9461, 15748, 15749, 15750, 15751, 15752, 15753, 15754, 15755, 15756, 
15757, 15758, 15759, 15760, 15761, 15762, 15763, 15764, 15765, 15766, 
15767, 15768, 15769, 15770, 15771, 15772, 15773, 15774, 15775, 15776, 
15777, 15778, 15779, 15780, 15781, 15782, 15783, 15784, 15785, 15786, 
15787, 15788, 15789, 15790, 15791, 15792, 15793, 15794, 15795, 15796, 
15797, 15798, 15799, 15800, 15801, 15802, 15803, 15804, 15805, 15806, 
15807, 15808, 15809, 15810, 15811, 15812, 15813, 15814, 15815, 15816, 
15817, 15818, 15819, 15820, 15821, 15822, 15823, 15824, 15825, 15826, 
15827, 15828, 15829, 15830, 15831, 15832, 15833, 15834, 15835, 15836, 
15837, 15838, 15839, 16240, 16241, 16242, 16243, 16244, 16245, 16246, 
16247, 16248, 16249, 16250, 16251, 16252, 16253, 16254, 16255, 16503, 
16504, 16505, 16506, 16507, 16508, 16509, 16510, 16511, 16512, 16513, 
16514, 16515, 16516, 16517, 16518, 16519, 16520, 16521, 16522, 16523, 
16524, 16525, 16526, 16527, 16528, 16529, 16530, 16531, 16532, 16533, 
16534, 16535, 16536, 16537, 16538, 16539, 16540, 16541, 16542, 16543, 
16544, 16545, 16546, 16547, 16548, 16549, 16550, 16551, 16552, 16553, 
16554, 16555, 16556, 16557, 16558, 16559, 16560, 16561, 16562, 16563, 
16564, 16565, 16566, 16567, 16568, 16569, 16570, 16571, 16572, 16573, 
16574, 16575, 16576, 16577, 16578, 16579, 16580, 16581, 16582, 16583, 
16584, 16585, 16586, 16587, 16588, 16589, 16590, 16591, 16592, 16593, 
16594, 17748, 17749, 17750, 17751, 17752, 17753, 17754, 17755, 17756, 
17757, 17758, 17759, 17760, 17761, 17762, 17763, 17764, 17765, 17766, 
17767, 17768, 17769, 17770, 17771, 17772, 17773, 17774, 17775, 17776, 
17777, 17778, 17779, 17780, 17781, 17782, 17783, 17784, 17785, 17786, 
17787, 17788, 17789, 17790, 17791, 17792, 17793, 17794, 17795, 17796, 
17797, 17798, 17799, 17800, 17801, 17802, 17803, 17804, 17805, 17806, 
17807, 17808, 17809, 17810, 17811, 17812, 17813, 17814, 17815, 17816, 
17817, 17818, 17819, 17820, 17821, 17822, 17823, 17824, 17825, 17826, 
17827, 17828, 17829, 17830, 17831, 17832, 17833, 17834, 17835, 17836, 
17837, 17838, 17839, 18391, 18392, 18393, 18394, 18395, 18396, 18397, 
18398, 18399, 18400, 18401, 18402, 18403, 18404, 18405, 18406, 18407, 
18408, 18409, 18410, 18411, 18412, 18413, 18414, 18415, 18416, 18417, 
18418, 18419, 18420, 18421, 18422, 18423, 18424, 18425, 18426, 18427, 
18428, 18429, 18430, 18431, 18432, 18433, 18434, 18435, 18436, 18437, 
18438, 18439, 18440, 18441, 18442, 18443, 18444, 18445, 18446, 18447, 
18448, 18449, 18450, 18451, 18452, 18453, 18454, 18455, 18456, 18457, 
18458, 18459, 18460, 18461, 18462, 18463, 18464, 18465, 18466, 18467, 
18468, 18469, 18470, 18471, 18472, 18473, 18474, 18475, 18476, 18477, 
18478, 18479, 18480, 18481, 18482, 
*NSET,NSET=Solder_2D
0, 3, 7, 11, 12, 15, 16, 19, 20, 25, 
29, 33, 34, 37, 38, 41, 42, 219, 220, 221, 
222, 223, 224, 225, 226, 227, 228, 229, 230, 231, 
232, 233, 234, 235, 236, 237, 238, 239, 240, 241, 
276, 277, 278, 279, 280, 281, 282, 283, 284, 285, 
286, 287, 288, 289, 290, 291, 292, 293, 294, 295, 
296, 297, 298, 436, 437, 438, 439, 440, 441, 442, 
443, 444, 445, 446, 447, 448, 449, 450, 451, 452, 
453, 454, 455, 456, 457, 458, 504, 505, 506, 507, 
508, 509, 510, 511, 512, 513, 514, 515, 516, 517, 
518, 519, 520, 521, 522, 523, 524, 525, 526, 656, 
657, 658, 659, 660, 661, 662, 663, 664, 665, 666, 
667, 668, 669, 670, 671, 672, 673, 674, 675, 676, 
677, 678, 774, 775, 776, 777, 778, 779, 780, 781, 
782, 783, 784, 785, 786, 787, 788, 789, 790, 791, 
792, 793, 794, 795, 796, 888, 889, 890, 891, 892, 
893, 894, 895, 896, 897, 898, 899, 900, 901, 902, 
903, 904, 905, 906, 907, 908, 909, 910, 1002, 1003, 
1004, 1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 1013, 
1014, 1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 
1024, 
*NSET,NSET=Copper_2D
0, 1, 3, 5, 7, 19, 20, 23, 24, 25, 
26, 29, 30, 41, 42, 45, 46, 49, 50, 53, 
55, 109, 110, 135, 136, 173, 174, 175, 176, 177, 
178, 179, 180, 181, 182, 183, 184, 185, 186, 187, 
188, 189, 190, 191, 192, 193, 194, 195, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 504, 505, 506, 507, 508, 509, 510, 511, 512, 
513, 514, 515, 516, 517, 518, 519, 520, 521, 522, 
523, 524, 525, 526, 565, 566, 578, 579, 580, 581, 
582, 583, 584, 585, 586, 587, 588, 589, 590, 591, 
592, 593, 594, 595, 596, 597, 598, 599, 600, 601, 
602, 614, 615, 616, 617, 618, 619, 620, 621, 622, 
623, 656, 657, 658, 659, 660, 661, 662, 663, 664, 
665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 
675, 676, 677, 678, 679, 680, 681, 682, 683, 684, 
685, 686, 687, 688, 689, 690, 691, 692, 693, 694, 
695, 696, 697, 698, 699, 700, 701, 702, 703, 1002, 
1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 
1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 
1023, 1024, 1120, 1121, 1122, 1123, 1124, 1125, 1126, 1127, 
1128, 1129, 1130, 1131, 1132, 1133, 1134, 1135, 1136, 1137, 
1138, 1139, 1140, 1141, 1142, 1143, 1144, 1145, 1146, 1202, 
1203, 1239, 1240, 3004, 3005, 3006, 3007, 3008, 3009, 3010, 
3011, 3012, 3013, 3014, 3015, 3016, 3017, 3018, 3019, 3020, 
3021, 3022, 3023, 3024, 3025, 3026, 3027, 3028, 3029, 3030, 
3031, 3032, 3033, 3034, 3035, 3036, 3037, 3038, 3039, 3040, 
3041, 3042, 3043, 3044, 3045, 3046, 3047, 3048, 3049, 5441, 
5442, 5443, 5444, 5445, 5446, 5447, 5448, 5449, 5450, 5451, 
5452, 5453, 5454, 5455, 5456, 5457, 5458, 5459, 5460, 5461, 
5462, 5463, 5464, 5465, 5466, 5467, 5468, 5469, 5470, 5471, 
5472, 5473, 5474, 5475, 5476, 5477, 5478, 5479, 5480, 5481, 
5482, 5483, 5484, 5485, 5486, 5762, 5763, 5764, 5765, 5766, 
5767, 5768, 5769, 5888, 5889, 5890, 5891, 5892, 5893, 5894, 
5895, 5896, 5897, 5898, 5899, 5900, 5901, 5902, 5903, 5904, 
5905, 5906, 5907, 5908, 5909, 5910, 5911, 5912, 5913, 5914, 
5915, 5916, 5917, 5918, 5919, 5920, 5921, 5922, 5923, 5924, 
5925, 5926, 5927, 5928, 5929, 5930, 5931, 5932, 5933, 9416, 
9417, 9418, 9419, 9420, 9421, 9422, 9423, 9424, 9425, 9426, 
9427, 9428, 9429, 9430, 9431, 9432, 9433, 9434, 9435, 9436, 
9437, 9438, 9439, 9440, 9441, 9442, 9443, 9444, 9445, 9446, 
9447, 9448, 9449, 9450, 9451, 9452, 9453, 9454, 9455, 9456, 
9457, 9458, 9459, 9460, 9461, 
*NSET,NSET=Ceramic_2D
0, 1, 5, 23, 24, 26, 30, 45, 46, 50, 
53, 79, 80, 81, 83, 87, 88, 89, 91, 92, 
95, 173, 174, 175, 176, 177, 178, 179, 180, 181, 
182, 183, 184, 185, 186, 187, 188, 189, 190, 191, 
192, 193, 194, 195, 580, 581, 582, 583, 584, 585, 
586, 587, 588, 589, 590, 591, 592, 593, 594, 595, 
596, 597, 598, 599, 600, 601, 602, 618, 619, 620, 
621, 679, 680, 681, 682, 683, 684, 685, 686, 687, 
688, 689, 690, 691, 692, 693, 694, 695, 696, 697, 
698, 699, 700, 701, 1124, 1125, 1126, 1127, 1128, 1129, 
1130, 1131, 1132, 1133, 1134, 1135, 1136, 1137, 1138, 1139, 
1140, 1141, 1142, 1143, 1144, 1145, 1146, 2017, 2018, 2019, 
2020, 2032, 2033, 2034, 2035, 2036, 2037, 2038, 2039, 2040, 
2041, 2042, 2043, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 
2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 2070, 2071, 
2072, 2073, 2074, 2075, 2076, 2077, 2102, 2103, 2104, 2105, 
2106, 2107, 2108, 2109, 2110, 2111, 2112, 2113, 2114, 2115, 
2116, 2117, 2118, 2119, 2120, 2121, 2122, 2123, 2124, 2125, 
2126, 2127, 2128, 2213, 2214, 2215, 2216, 2228, 2229, 2230, 
2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 
2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 
2251, 2252, 2253, 2254, 2266, 2267, 2268, 2269, 2290, 2291, 
2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 2301, 
2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 2311, 
2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 2384, 
2385, 2386, 2387, 15748, 15749, 15750, 15751, 15752, 15753, 15754, 
15755, 15756, 15757, 15758, 15759, 15760, 15761, 15762, 15763, 15764, 
15765, 15766, 15767, 15768, 15769, 15770, 15771, 15772, 15773, 15774, 
15775, 15776, 15777, 15778, 15779, 15780, 15781, 15782, 15783, 15784, 
15785, 15786, 15787, 15788, 15789, 15790, 15791, 15792, 15793, 15794, 
15795, 15796, 15797, 15798, 15799, 15800, 15801, 15802, 15803, 15804, 
15805, 15806, 15807, 15808, 15809, 15810, 15811, 15812, 15813, 15814, 
15815, 15816, 15817, 15818, 15819, 15820, 15821, 15822, 15823, 15824, 
15825, 15826, 15827, 15828, 15829, 15830, 15831, 15832, 15833, 15834, 
15835, 15836, 15837, 15838, 15839, 16240, 16241, 16242, 16243, 16244, 
16245, 16246, 16247, 16248, 16249, 16250, 16251, 16252, 16253, 16254, 
16255, 16503, 16504, 16505, 16506, 16507, 16508, 16509, 16510, 16511, 
16512, 16513, 16514, 16515, 16516, 16517, 16518, 16519, 16520, 16521, 
16522, 16523, 16524, 16525, 16526, 16527, 16528, 16529, 16530, 16531, 
16532, 16533, 16534, 16535, 16536, 16537, 16538, 16539, 16540, 16541, 
16542, 16543, 16544, 16545, 16546, 16547, 16548, 16549, 16550, 16551, 
16552, 16553, 16554, 16555, 16556, 16557, 16558, 16559, 16560, 16561, 
16562, 16563, 16564, 16565, 16566, 16567, 16568, 16569, 16570, 16571, 
16572, 16573, 16574, 16575, 16576, 16577, 16578, 16579, 16580, 16581, 
16582, 16583, 16584, 16585, 16586, 16587, 16588, 16589, 16590, 16591, 
16592, 16593, 16594, 17748, 17749, 17750, 17751, 17752, 17753, 17754, 
17755, 17756, 17757, 17758, 17759, 17760, 17761, 17762, 17763, 17764, 
17765, 17766, 17767, 17768, 17769, 17770, 17771, 17772, 17773, 17774, 
17775, 17776, 17777, 17778, 17779, 17780, 17781, 17782, 17783, 17784, 
17785, 17786, 17787, 17788, 17789, 17790, 17791, 17792, 17793, 17794, 
17795, 17796, 17797, 17798, 17799, 17800, 17801, 17802, 17803, 17804, 
17805, 17806, 17807, 17808, 17809, 17810, 17811, 17812, 17813, 17814, 
17815, 17816, 17817, 17818, 17819, 17820, 17821, 17822, 17823, 17824, 
17825, 17826, 17827, 17828, 17829, 17830, 17831, 17832, 17833, 17834, 
17835, 17836, 17837, 17838, 17839, 18391, 18392, 18393, 18394, 18395, 
18396, 18397, 18398, 18399, 18400, 18401, 18402, 18403, 18404, 18405, 
18406, 18407, 18408, 18409, 18410, 18411, 18412, 18413, 18414, 18415, 
18416, 18417, 18418, 18419, 18420, 18421, 18422, 18423, 18424, 18425, 
18426, 18427, 18428, 18429, 18430, 18431, 18432, 18433, 18434, 18435, 
18436, 18437, 18438, 18439, 18440, 18441, 18442, 18443, 18444, 18445, 
18446, 18447, 18448, 18449, 18450, 18451, 18452, 18453, 18454, 18455, 
18456, 18457, 18458, 18459, 18460, 18461, 18462, 18463, 18464, 18465, 
18466, 18467, 18468, 18469, 18470, 18471, 18472, 18473, 18474, 18475, 
18476, 18477, 18478, 18479, 18480, 18481, 18482, 
*NSET,NSET=SemiconductorL_2D
0, 11, 12, 15, 16, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 413, 414, 415, 416, 417, 418, 419, 420, 421, 
422, 423, 424, 425, 426, 427, 428, 429, 430, 431, 
432, 433, 434, 435, 436, 437, 438, 439, 440, 441, 
442, 443, 444, 445, 446, 447, 448, 449, 450, 451, 
452, 453, 454, 455, 456, 457, 458, 4085, 4086, 4087, 
4088, 4089, 4090, 4091, 4092, 4093, 4094, 4095, 4096, 4097, 
4098, 4099, 4100, 4101, 4102, 4103, 4104, 4105, 4106, 4107, 
4108, 4109, 4110, 4111, 4112, 4113, 4114, 4115, 4116, 4117, 
4118, 4119, 4120, 4121, 4122, 4123, 4124, 4125, 4126, 4127, 
4128, 4129, 4130, 4131, 4132, 4133, 4134, 4135, 4136, 4137, 
4138, 4139, 4140, 4141, 4142, 4143, 4144, 4145, 4146, 4147, 
4148, 4149, 4150, 4151, 4152, 4153, 4154, 4155, 4156, 4157, 
4158, 4159, 4160, 4161, 4162, 4163, 4164, 4165, 4166, 4167, 
4168, 4169, 4170, 4171, 4172, 4173, 4174, 4175, 4176, 4177, 
4178, 4179, 4180, 4181, 4182, 4183, 4184, 4185, 4186, 4187, 
4188, 4189, 4190, 4191, 4192, 4193, 4194, 4195, 4196, 4197, 
4198, 4199, 4200, 4201, 4202, 4203, 4204, 4205, 4206, 4207, 
4208, 4209, 4210, 4211, 4212, 4213, 4214, 4215, 4216, 4217, 
4218, 4219, 4220, 4221, 4222, 4223, 4224, 4225, 4226, 4227, 
4228, 4229, 4230, 4231, 4232, 4233, 4234, 4235, 4236, 4237, 
4238, 4239, 4240, 4241, 4242, 4243, 4244, 4245, 4246, 4247, 
4248, 4249, 4250, 4251, 4252, 4253, 4254, 4255, 4256, 4257, 
4258, 4259, 4260, 4261, 4262, 4263, 4264, 4265, 4266, 4267, 
4268, 4269, 4270, 4271, 4272, 4273, 4274, 4275, 4276, 4277, 
4278, 4279, 4280, 4281, 4282, 4283, 4284, 4285, 4286, 4287, 
4288, 4289, 4290, 4291, 4292, 4293, 4294, 4295, 4296, 4297, 
4298, 4299, 4300, 4301, 4302, 4303, 4304, 4305, 4306, 4307, 
4308, 4309, 4310, 4311, 4312, 4313, 4314, 4315, 4316, 4317, 
4318, 4319, 4320, 4321, 4322, 4323, 4324, 4325, 4326, 4327, 
4328, 4329, 4330, 4331, 4332, 4333, 4334, 4335, 4336, 4337, 
4338, 4339, 4340, 4341, 4342, 4343, 4344, 4345, 4346, 4347, 
4348, 4349, 4350, 4351, 4352, 4353, 4354, 4355, 4356, 4357, 
4358, 4359, 4360, 4361, 4362, 4363, 4364, 4365, 4366, 4367, 
4368, 4369, 4370, 4371, 4372, 4373, 4374, 4375, 4376, 4377, 
4378, 4379, 4380, 4381, 4382, 4383, 4384, 4385, 4386, 4387, 
4388, 4389, 4390, 4391, 4392, 4393, 4394, 4395, 4396, 4397, 
4398, 4399, 4400, 4401, 4402, 4403, 4404, 4405, 4406, 4407, 
4408, 4409, 4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 
4418, 4419, 4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 
4428, 4429, 4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 
4438, 4439, 4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 
4448, 4449, 4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 
4458, 4459, 4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 
4468, 4469, 4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 
4478, 4479, 4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 
4488, 4489, 4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 
4498, 4499, 4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 
4508, 4509, 4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 
4518, 4519, 4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 
4528, 4529, 4530, 4531, 4532, 4533, 4534, 4535, 4536, 4537, 
4538, 4539, 4540, 4541, 4542, 4543, 4544, 4545, 4546, 4547, 
4548, 4549, 4550, 4551, 4552, 4553, 4554, 4555, 4556, 4557, 
4558, 4559, 4560, 4561, 4562, 4563, 4564, 4565, 4566, 4567, 
4568, 4569, 4570, 4571, 4572, 4573, 4574, 4575, 4576, 4577, 
4578, 4579, 4580, 4581, 4582, 4583, 4584, 4585, 4586, 4587, 
4588, 4589, 4590, 4591, 4592, 4593, 4594, 4595, 4596, 4597, 
4598, 4599, 4600, 4601, 4602, 4603, 4604, 4605, 4606, 4607, 
4608, 4609, 4610, 4611, 4612, 4613, 
*NSET,NSET=SemiconductorR_2D
0, 33, 34, 37, 38, 774, 775, 776, 777, 778, 
779, 780, 781, 782, 783, 784, 785, 786, 787, 788, 
789, 790, 791, 792, 793, 794, 795, 796, 842, 843, 
844, 845, 846, 847, 848, 849, 850, 851, 852, 853, 
854, 855, 856, 857, 858, 859, 860, 861, 862, 863, 
864, 865, 866, 867, 868, 869, 870, 871, 872, 873, 
874, 875, 876, 877, 878, 879, 880, 881, 882, 883, 
884, 885, 886, 887, 888, 889, 890, 891, 892, 893, 
894, 895, 896, 897, 898, 899, 900, 901, 902, 903, 
904, 905, 906, 907, 908, 909, 910, 6761, 6762, 6763, 
6764, 6765, 6766, 6767, 6768, 6769, 6770, 6771, 6772, 6773, 
6774, 6775, 6776, 6777, 6778, 6779, 6780, 6781, 6782, 6783, 
6784, 6785, 6786, 6787, 6788, 6789, 6790, 6791, 6792, 6793, 
6794, 6795, 6796, 6797, 6798, 6799, 6800, 6801, 6802, 6803, 
6804, 6805, 6806, 6807, 6808, 6809, 6810, 6811, 6812, 6813, 
6814, 6815, 6816, 6817, 6818, 6819, 6820, 6821, 6822, 6823, 
6824, 6825, 6826, 6827, 6828, 6829, 6830, 6831, 6832, 6833, 
6834, 6835, 6836, 6837, 6838, 6839, 6840, 6841, 6842, 6843, 
6844, 6845, 6846, 6847, 6848, 6849, 6850, 6851, 6852, 6853, 
6854, 6855, 6856, 6857, 6858, 6859, 6860, 6861, 6862, 6863, 
6864, 6865, 6866, 6867, 6868, 6869, 6870, 6871, 6872, 6873, 
6874, 6875, 6876, 6877, 6878, 6879, 6880, 6881, 6882, 6883, 
6884, 6885, 6886, 6887, 6888, 6889, 6890, 6891, 6892, 6893, 
6894, 6895, 6896, 6897, 6898, 6899, 6900, 6901, 6902, 6903, 
6904, 6905, 6906, 6907, 6908, 6909, 6910, 6911, 6912, 6913, 
6914, 6915, 6916, 6917, 6918, 6919, 6920, 6921, 6922, 6923, 
6924, 6925, 6926, 6927, 6928, 6929, 6930, 6931, 6932, 6933, 
6934, 6935, 6936, 6937, 6938, 6939, 6940, 6941, 6942, 6943, 
6944, 6945, 6946, 6947, 6948, 6949, 6950, 6951, 6952, 6953, 
6954, 6955, 6956, 6957, 6958, 6959, 6960, 6961, 6962, 6963, 
6964, 6965, 6966, 6967, 6968, 6969, 6970, 6971, 6972, 6973, 
6974, 6975, 6976, 6977, 6978, 6979, 6980, 6981, 6982, 6983, 
6984, 6985, 6986, 6987, 6988, 6989, 6990, 6991, 6992, 6993, 
6994, 6995, 6996, 6997, 6998, 6999, 7000, 7001, 7002, 7003, 
7004, 7005, 7006, 7007, 7008, 7009, 7010, 7011, 7012, 7013, 
7014, 7015, 7016, 7017, 7018, 7019, 7020, 7021, 7022, 7023, 
7024, 7025, 7026, 7027, 7028, 7029, 7030, 7031, 7032, 7033, 
7034, 7035, 7036, 7037, 7038, 7039, 7040, 7041, 7042, 7043, 
7044, 7045, 7046, 7047, 7048, 7049, 7050, 7051, 7052, 7053, 
7054, 7055, 7056, 7057, 7058, 7059, 7060, 7061, 7062, 7063, 
7064, 7065, 7066, 7067, 7068, 7069, 7070, 7071, 7072, 7073, 
7074, 7075, 7076, 7077, 7078, 7079, 7080, 7081, 7082, 7083, 
7084, 7085, 7086, 7087, 7088, 7089, 7090, 7091, 7092, 7093, 
7094, 7095, 7096, 7097, 7098, 7099, 7100, 7101, 7102, 7103, 
7104, 7105, 7106, 7107, 7108, 7109, 7110, 7111, 7112, 7113, 
7114, 7115, 7116, 7117, 7118, 7119, 7120, 7121, 7122, 7123, 
7124, 7125, 7126, 7127, 7128, 7129, 7130, 7131, 7132, 7133, 
7134, 7135, 7136, 7137, 7138, 7139, 7140, 7141, 7142, 7143, 
7144, 7145, 7146, 7147, 7148, 7149, 7150, 7151, 7152, 7153, 
7154, 7155, 7156, 7157, 7158, 7159, 7160, 7161, 7162, 7163, 
7164, 7165, 7166, 7167, 7168, 7169, 7170, 7171, 7172, 7173, 
7174, 7175, 7176, 7177, 7178, 7179, 7180, 7181, 7182, 7183, 
7184, 7185, 7186, 7187, 7188, 7189, 7190, 7191, 7192, 7193, 
7194, 7195, 7196, 7197, 7198, 7199, 7200, 7201, 7202, 7203, 
7204, 7205, 7206, 7207, 7208, 7209, 7210, 7211, 7212, 7213, 
7214, 7215, 7216, 7217, 7218, 7219, 7220, 7221, 7222, 7223, 
7224, 7225, 7226, 7227, 7228, 7229, 7230, 7231, 7232, 7233, 
7234, 7235, 7236, 7237, 7238, 7239, 7240, 7241, 7242, 7243, 
7244, 7245, 7246, 7247, 7248, 7249, 7250, 7251, 7252, 7253, 
7254, 7255, 7256, 7257, 7258, 7259, 7260, 7261, 7262, 7263, 
7264, 7265, 7266, 7267, 7268, 7269, 7270, 7271, 7272, 7273, 
7274, 7275, 7276, 7277, 7278, 7279, 7280, 7281, 7282, 7283, 
7284, 7285, 7286, 7287, 7288, 7289, 
*NSET,NSET=Symmetry
0, 1, 3, 5, 7, 11, 12, 15, 16, 19, 
20, 23, 24, 25, 26, 29, 30, 33, 34, 37, 
38, 41, 42, 45, 46, 49, 50, 53, 55, 57, 
58, 61, 62, 79, 80, 81, 83, 87, 88, 89, 
91, 92, 95, 109, 110, 135, 136, 173, 174, 175, 
176, 177, 178, 179, 180, 181, 182, 183, 184, 185, 
186, 187, 188, 189, 190, 191, 192, 193, 194, 195, 
219, 220, 221, 222, 223, 224, 225, 226, 227, 228, 
229, 230, 231, 232, 233, 234, 235, 236, 237, 238, 
239, 240, 241, 276, 277, 278, 279, 280, 281, 282, 
283, 284, 285, 286, 287, 288, 289, 290, 291, 292, 
293, 294, 295, 296, 297, 298, 379, 380, 381, 382, 
383, 384, 385, 386, 387, 388, 389, 390, 391, 392, 
393, 394, 395, 396, 397, 398, 399, 400, 401, 413, 
414, 415, 416, 417, 418, 419, 420, 421, 422, 423, 
424, 425, 426, 427, 428, 429, 430, 431, 432, 433, 
434, 435, 436, 437, 438, 439, 440, 441, 442, 443, 
444, 445, 446, 447, 448, 449, 450, 451, 452, 453, 
454, 455, 456, 457, 458, 504, 505, 506, 507, 508, 
509, 510, 511, 512, 513, 514, 515, 516, 517, 518, 
519, 520, 521, 522, 523, 524, 525, 526, 565, 566, 
578, 579, 580, 581, 582, 583, 584, 585, 586, 587, 
588, 589, 590, 591, 592, 593, 594, 595, 596, 597, 
598, 599, 600, 601, 602, 614, 615, 616, 617, 618, 
619, 620, 621, 622, 623, 656, 657, 658, 659, 660, 
661, 662, 663, 664, 665, 666, 667, 668, 669, 670, 
671, 672, 673, 674, 675, 676, 677, 678, 679, 680, 
681, 682, 683, 684, 685, 686, 687, 688, 689, 690, 
691, 692, 693, 694, 695, 696, 697, 698, 699, 700, 
701, 702, 703, 774, 775, 776, 777, 778, 779, 780, 
781, 782, 783, 784, 785, 786, 787, 788, 789, 790, 
791, 792, 793, 794, 795, 796, 842, 843, 844, 845, 
846, 847, 848, 849, 850, 851, 852, 853, 854, 855, 
856, 857, 858, 859, 860, 861, 862, 863, 864, 865, 
866, 867, 868, 869, 870, 871, 872, 873, 874, 875, 
876, 877, 878, 879, 880, 881, 882, 883, 884, 885, 
886, 887, 888, 889, 890, 891, 892, 893, 894, 895, 
896, 897, 898, 899, 900, 901, 902, 903, 904, 905, 
906, 907, 908, 909, 910, 1002, 1003, 1004, 1005, 1006, 
1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 1015, 1016, 
1017, 1018, 1019, 1020, 1021, 1022, 1023, 1024, 1120, 1121, 
1122, 1123, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 1131, 
1132, 1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 1141, 
1142, 1143, 1144, 1145, 1146, 1202, 1203, 1239, 1240, 1254, 
1255, 1256, 1257, 1258, 1259, 1260, 1261, 1262, 1263, 1264, 
1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 1273, 1274, 
1275, 1276, 1372, 1373, 1374, 1375, 1376, 1377, 1378, 1379, 
1380, 1381, 1382, 1383, 1384, 1385, 1386, 1387, 1388, 1389, 
1390, 1391, 1392, 1393, 1394, 2017, 2018, 2019, 2020, 2032, 
2033, 2034, 2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 
2043, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 
2053, 2054, 2055, 2056, 2057, 2058, 2070, 2071, 2072, 2073, 
2074, 2075, 2076, 2077, 2102, 2103, 2104, 2105, 2106, 2107, 
2108, 2109, 2110, 2111, 2112, 2113, 2114, 2115, 2116, 2117, 
2118, 2119, 2120, 2121, 2122, 2123, 2124, 2125, 2126, 2127, 
2128, 2213, 2214, 2215, 2216, 2228, 2229, 2230, 2231, 2232, 
2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 2241, 2242, 
2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 2251, 2252, 
2253, 2254, 2266, 2267, 2268, 2269, 2290, 2291, 2292, 2293, 
2294, 2295, 2296, 2297, 2298, 2299, 2300, 2301, 2302, 2303, 
2304, 2305, 2306, 2307, 2308, 2309, 2310, 2311, 2312, 2313, 
2314, 2315, 2316, 2317, 2318, 2319, 2320, 2384, 2385, 2386, 
2387, 3004, 3005, 3006, 3007, 3008, 3009, 3010, 3011, 3012, 
3013, 3014, 3015, 3016, 3017, 3018, 3019, 3020, 3021, 3022, 
3023, 3024, 3025, 3026, 3027, 3028, 3029, 3030, 3031, 3032, 
3033, 3034, 3035, 3036, 3037, 3038, 3039, 3040, 3041, 3042, 
3043, 3044, 3045, 3046, 3047, 3048, 3049, 4085, 4086, 4087, 
4088, 4089, 4090, 4091, 4092, 4093, 4094, 4095, 4096, 4097, 
4098, 4099, 4100, 4101, 4102, 4103, 4104, 4105, 4106, 4107, 
4108, 4109, 4110, 4111, 4112, 4113, 4114, 4115, 4116, 4117, 
4118, 4119, 4120, 4121, 4122, 4123, 4124, 4125, 4126, 4127, 
4128, 4129, 4130, 4131, 4132, 4133, 4134, 4135, 4136, 4137, 
4138, 4139, 4140, 4141, 4142, 4143, 4144, 4145, 4146, 4147, 
4148, 4149, 4150, 4151, 4152, 4153, 4154, 4155, 4156, 4157, 
4158, 4159, 4160, 4161, 4162, 4163, 4164, 4165, 4166, 4167, 
4168, 4169, 4170, 4171, 4172, 4173, 4174, 4175, 4176, 4177, 
4178, 4179, 4180, 4181, 4182, 4183, 4184, 4185, 4186, 4187, 
4188, 4189, 4190, 4191, 4192, 4193, 4194, 4195, 4196, 4197, 
4198, 4199, 4200, 4201, 4202, 4203, 4204, 4205, 4206, 4207, 
4208, 4209, 4210, 4211, 4212, 4213, 4214, 4215, 4216, 4217, 
4218, 4219, 4220, 4221, 4222, 4223, 4224, 4225, 4226, 4227, 
4228, 4229, 4230, 4231, 4232, 4233, 4234, 4235, 4236, 4237, 
4238, 4239, 4240, 4241, 4242, 4243, 4244, 4245, 4246, 4247, 
4248, 4249, 4250, 4251, 4252, 4253, 4254, 4255, 4256, 4257, 
4258, 4259, 4260, 4261, 4262, 4263, 4264, 4265, 4266, 4267, 
4268, 4269, 4270, 4271, 4272, 4273, 4274, 4275, 4276, 4277, 
4278, 4279, 4280, 4281, 4282, 4283, 4284, 4285, 4286, 4287, 
4288, 4289, 4290, 4291, 4292, 4293, 4294, 4295, 4296, 4297, 
4298, 4299, 4300, 4301, 4302, 4303, 4304, 4305, 4306, 4307, 
4308, 4309, 4310, 4311, 4312, 4313, 4314, 4315, 4316, 4317, 
4318, 4319, 4320, 4321, 4322, 4323, 4324, 4325, 4326, 4327, 
4328, 4329, 4330, 4331, 4332, 4333, 4334, 4335, 4336, 4337, 
4338, 4339, 4340, 4341, 4342, 4343, 4344, 4345, 4346, 4347, 
4348, 4349, 4350, 4351, 4352, 4353, 4354, 4355, 4356, 4357, 
4358, 4359, 4360, 4361, 4362, 4363, 4364, 4365, 4366, 4367, 
4368, 4369, 4370, 4371, 4372, 4373, 4374, 4375, 4376, 4377, 
4378, 4379, 4380, 4381, 4382, 4383, 4384, 4385, 4386, 4387, 
4388, 4389, 4390, 4391, 4392, 4393, 4394, 4395, 4396, 4397, 
4398, 4399, 4400, 4401, 4402, 4403, 4404, 4405, 4406, 4407, 
4408, 4409, 4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 
4418, 4419, 4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 
4428, 4429, 4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 
4438, 4439, 4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 
4448, 4449, 4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 
4458, 4459, 4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 
4468, 4469, 4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 
4478, 4479, 4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 
4488, 4489, 4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 
4498, 4499, 4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 
4508, 4509, 4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 
4518, 4519, 4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 
4528, 4529, 4530, 4531, 4532, 4533, 4534, 4535, 4536, 4537, 
4538, 4539, 4540, 4541, 4542, 4543, 4544, 4545, 4546, 4547, 
4548, 4549, 4550, 4551, 4552, 4553, 4554, 4555, 4556, 4557, 
4558, 4559, 4560, 4561, 4562, 4563, 4564, 4565, 4566, 4567, 
4568, 4569, 4570, 4571, 4572, 4573, 4574, 4575, 4576, 4577, 
4578, 4579, 4580, 4581, 4582, 4583, 4584, 4585, 4586, 4587, 
4588, 4589, 4590, 4591, 4592, 4593, 4594, 4595, 4596, 4597, 
4598, 4599, 4600, 4601, 4602, 4603, 4604, 4605, 4606, 4607, 
4608, 4609, 4610, 4611, 4612, 4613, 5441, 5442, 5443, 5444, 
5445, 5446, 5447, 5448, 5449, 5450, 5451, 5452, 5453, 5454, 
5455, 5456, 5457, 5458, 5459, 5460, 5461, 5462, 5463, 5464, 
5465, 5466, 5467, 5468, 5469, 5470, 5471, 5472, 5473, 5474, 
5475, 5476, 5477, 5478, 5479, 5480, 5481, 5482, 5483, 5484, 
5485, 5486, 5762, 5763, 5764, 5765, 5766, 5767, 5768, 5769, 
5888, 5889, 5890, 5891, 5892, 5893, 5894, 5895, 5896, 5897, 
5898, 5899, 5900, 5901, 5902, 5903, 5904, 5905, 5906, 5907, 
5908, 5909, 5910, 5911, 5912, 5913, 5914, 5915, 5916, 5917, 
5918, 5919, 5920, 5921, 5922, 5923, 5924, 5925, 5926, 5927, 
5928, 5929, 5930, 5931, 5932, 5933, 6761, 6762, 6763, 6764, 
6765, 6766, 6767, 6768, 6769, 6770, 6771, 6772, 6773, 6774, 
6775, 6776, 6777, 6778, 6779, 6780, 6781, 6782, 6783, 6784, 
6785, 6786, 6787, 6788, 6789, 6790, 6791, 6792, 6793, 6794, 
6795, 6796, 6797, 6798, 6799, 6800, 6801, 6802, 6803, 6804, 
6805, 6806, 6807, 6808, 6809, 6810, 6811, 6812, 6813, 6814, 
6815, 6816, 6817, 6818, 6819, 6820, 6821, 6822, 6823, 6824, 
6825, 6826, 6827, 6828, 6829, 6830, 6831, 6832, 6833, 6834, 
6835, 6836, 6837, 6838, 6839, 6840, 6841, 6842, 6843, 6844, 
6845, 6846, 6847, 6848, 6849, 6850, 6851, 6852, 6853, 6854, 
6855, 6856, 6857, 6858, 6859, 6860, 6861, 6862, 6863, 6864, 
6865, 6866, 6867, 6868, 6869, 6870, 6871, 6872, 6873, 6874, 
6875, 6876, 6877, 6878, 6879, 6880, 6881, 6882, 6883, 6884, 
6885, 6886, 6887, 6888, 6889, 6890, 6891, 6892, 6893, 6894, 
6895, 6896, 6897, 6898, 6899, 6900, 6901, 6902, 6903, 6904, 
6905, 6906, 6907, 6908, 6909, 6910, 6911, 6912, 6913, 6914, 
6915, 6916, 6917, 6918, 6919, 6920, 6921, 6922, 6923, 6924, 
6925, 6926, 6927, 6928, 6929, 6930, 6931, 6932, 6933, 6934, 
6935, 6936, 6937, 6938, 6939, 6940, 6941, 6942, 6943, 6944, 
6945, 6946, 6947, 6948, 6949, 6950, 6951, 6952, 6953, 6954, 
6955, 6956, 6957, 6958, 6959, 6960, 6961, 6962, 6963, 6964, 
6965, 6966, 6967, 6968, 6969, 6970, 6971, 6972, 6973, 6974, 
6975, 6976, 6977, 6978, 6979, 6980, 6981, 6982, 6983, 6984, 
6985, 6986, 6987, 6988, 6989, 6990, 6991, 6992, 6993, 6994, 
6995, 6996, 6997, 6998, 6999, 7000, 7001, 7002, 7003, 7004, 
7005, 7006, 7007, 7008, 7009, 7010, 7011, 7012, 7013, 7014, 
7015, 7016, 7017, 7018, 7019, 7020, 7021, 7022, 7023, 7024, 
7025, 7026, 7027, 7028, 7029, 7030, 7031, 7032, 7033, 7034, 
7035, 7036, 7037, 7038, 7039, 7040, 7041, 7042, 7043, 7044, 
7045, 7046, 7047, 7048, 7049, 7050, 7051, 7052, 7053, 7054, 
7055, 7056, 7057, 7058, 7059, 7060, 7061, 7062, 7063, 7064, 
7065, 7066, 7067, 7068, 7069, 7070, 7071, 7072, 7073, 7074, 
7075, 7076, 7077, 7078, 7079, 7080, 7081, 7082, 7083, 7084, 
7085, 7086, 7087, 7088, 7089, 7090, 7091, 7092, 7093, 7094, 
7095, 7096, 7097, 7098, 7099, 7100, 7101, 7102, 7103, 7104, 
7105, 7106, 7107, 7108, 7109, 7110, 7111, 7112, 7113, 7114, 
7115, 7116, 7117, 7118, 7119, 7120, 7121, 7122, 7123, 7124, 
7125, 7126, 7127, 7128, 7129, 7130, 7131, 7132, 7133, 7134, 
7135, 7136, 7137, 7138, 7139, 7140, 7141, 7142, 7143, 7144, 
7145, 7146, 7147, 7148, 7149, 7150, 7151, 7152, 7153, 7154, 
7155, 7156, 7157, 7158, 7159, 7160, 7161, 7162, 7163, 7164, 
7165, 7166, 7167, 7168, 7169, 7170, 7171, 7172, 7173, 7174, 
7175, 7176, 7177, 7178, 7179, 7180, 7181, 7182, 7183, 7184, 
7185, 7186, 7187, 7188, 7189, 7190, 7191, 7192, 7193, 7194, 
7195, 7196, 7197, 7198, 7199, 7200, 7201, 7202, 7203, 7204, 
7205, 7206, 7207, 7208, 7209, 7210, 7211, 7212, 7213, 7214, 
7215, 7216, 7217, 7218, 7219, 7220, 7221, 7222, 7223, 7224, 
7225, 7226, 7227, 7228, 7229, 7230, 7231, 7232, 7233, 7234, 
7235, 7236, 7237, 7238, 7239, 7240, 7241, 7242, 7243, 7244, 
7245, 7246, 7247, 7248, 7249, 7250, 7251, 7252, 7253, 7254, 
7255, 7256, 7257, 7258, 7259, 7260, 7261, 7262, 7263, 7264, 
7265, 7266, 7267, 7268, 7269, 7270, 7271, 7272, 7273, 7274, 
7275, 7276, 7277, 7278, 7279, 7280, 7281, 7282, 7283, 7284, 
7285, 7286, 7287, 7288, 7289, 9416, 9417, 9418, 9419, 9420, 
9421, 9422, 9423, 9424, 9425, 9426, 9427, 9428, 9429, 9430, 
9431, 9432, 9433, 9434, 9435, 9436, 9437, 9438, 9439, 9440, 
9441, 9442, 9443, 9444, 9445, 9446, 9447, 9448, 9449, 9450, 
9451, 9452, 9453, 9454, 9455, 9456, 9457, 9458, 9459, 9460, 
9461, 15748, 15749, 15750, 15751, 15752, 15753, 15754, 15755, 15756, 
15757, 15758, 15759, 15760, 15761, 15762, 15763, 15764, 15765, 15766, 
15767, 15768, 15769, 15770, 15771, 15772, 15773, 15774, 15775, 15776, 
15777, 15778, 15779, 15780, 15781, 15782, 15783, 15784, 15785, 15786, 
15787, 15788, 15789, 15790, 15791, 15792, 15793, 15794, 15795, 15796, 
15797, 15798, 15799, 15800, 15801, 15802, 15803, 15804, 15805, 15806, 
15807, 15808, 15809, 15810, 15811, 15812, 15813, 15814, 15815, 15816, 
15817, 15818, 15819, 15820, 15821, 15822, 15823, 15824, 15825, 15826, 
15827, 15828, 15829, 15830, 15831, 15832, 15833, 15834, 15835, 15836, 
15837, 15838, 15839, 16240, 16241, 16242, 16243, 16244, 16245, 16246, 
16247, 16248, 16249, 16250, 16251, 16252, 16253, 16254, 16255, 16503, 
16504, 16505, 16506, 16507, 16508, 16509, 16510, 16511, 16512, 16513, 
16514, 16515, 16516, 16517, 16518, 16519, 16520, 16521, 16522, 16523, 
16524, 16525, 16526, 16527, 16528, 16529, 16530, 16531, 16532, 16533, 
16534, 16535, 16536, 16537, 16538, 16539, 16540, 16541, 16542, 16543, 
16544, 16545, 16546, 16547, 16548, 16549, 16550, 16551, 16552, 16553, 
16554, 16555, 16556, 16557, 16558, 16559, 16560, 16561, 16562, 16563, 
16564, 16565, 16566, 16567, 16568, 16569, 16570, 16571, 16572, 16573, 
16574, 16575, 16576, 16577, 16578, 16579, 16580, 16581, 16582, 16583, 
16584, 16585, 16586, 16587, 16588, 16589, 16590, 16591, 16592, 16593, 
16594, 17748, 17749, 17750, 17751, 17752, 17753, 17754, 17755, 17756, 
17757, 17758, 17759, 17760, 17761, 17762, 17763, 17764, 17765, 17766, 
17767, 17768, 17769, 17770, 17771, 17772, 17773, 17774, 17775, 17776, 
17777, 17778, 17779, 17780, 17781, 17782, 17783, 17784, 17785, 17786, 
17787, 17788, 17789, 17790, 17791, 17792, 17793, 17794, 17795, 17796, 
17797, 17798, 17799, 17800, 17801, 17802, 17803, 17804, 17805, 17806, 
17807, 17808, 17809, 17810, 17811, 17812, 17813, 17814, 17815, 17816, 
17817, 17818, 17819, 17820, 17821, 17822, 17823, 17824, 17825, 17826, 
17827, 17828, 17829, 17830, 17831, 17832, 17833, 17834, 17835, 17836, 
17837, 17838, 17839, 18391, 18392, 18393, 18394, 18395, 18396, 18397, 
18398, 18399, 18400, 18401, 18402, 18403, 18404, 18405, 18406, 18407, 
18408, 18409, 18410, 18411, 18412, 18413, 18414, 18415, 18416, 18417, 
18418, 18419, 18420, 18421, 18422, 18423, 18424, 18425, 18426, 18427, 
18428, 18429, 18430, 18431, 18432, 18433, 18434, 18435, 18436, 18437, 
18438, 18439, 18440, 18441, 18442, 18443, 18444, 18445, 18446, 18447, 
18448, 18449, 18450, 18451, 18452, 18453, 18454, 18455, 18456, 18457, 
18458, 18459, 18460, 18461, 18462, 18463, 18464, 18465, 18466, 18467, 
18468, 18469, 18470, 18471, 18472, 18473, 18474, 18475, 18476, 18477, 
18478, 18479, 18480, 18481, 18482, 
*NSET,NSET=Copper
0, 1, 2, 3, 4, 5, 6, 7, 8, 17, 
18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 
28, 29, 30, 31, 32, 41, 42, 43, 44, 45, 
46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 
56, 97, 98, 99, 100, 101, 102, 103, 104, 105, 
106, 107, 108, 109, 110, 111, 112, 113, 114, 115, 
116, 117, 118, 119, 120, 121, 122, 123, 124, 125, 
126, 127, 128, 129, 130, 131, 132, 133, 134, 135, 
136, 137, 138, 139, 140, 141, 142, 143, 144, 145, 
146, 147, 148, 149, 150, 151, 152, 153, 154, 155, 
156, 157, 158, 159, 160, 161, 162, 163, 164, 165, 
166, 167, 168, 169, 170, 171, 172, 173, 174, 175, 
176, 177, 178, 179, 180, 181, 182, 183, 184, 185, 
186, 187, 188, 189, 190, 191, 192, 193, 194, 195, 
196, 197, 198, 199, 200, 201, 202, 203, 204, 205, 
206, 207, 208, 209, 210, 211, 212, 213, 214, 215, 
216, 217, 218, 219, 220, 221, 222, 223, 224, 225, 
226, 227, 228, 229, 230, 231, 232, 233, 234, 235, 
236, 237, 238, 239, 240, 241, 470, 471, 472, 473, 
474, 475, 476, 477, 478, 479, 480, 481, 482, 483, 
484, 485, 486, 487, 488, 489, 490, 491, 492, 493, 
494, 495, 496, 497, 498, 499, 500, 501, 502, 503, 
504, 505, 506, 507, 508, 509, 510, 511, 512, 513, 
514, 515, 516, 517, 518, 519, 520, 521, 522, 523, 
524, 525, 526, 527, 528, 529, 530, 531, 532, 533, 
534, 535, 536, 537, 538, 539, 540, 541, 542, 543, 
544, 545, 546, 547, 548, 549, 550, 551, 552, 553, 
554, 555, 556, 557, 558, 559, 560, 561, 562, 563, 
564, 565, 566, 567, 568, 569, 570, 571, 572, 573, 
574, 575, 576, 577, 578, 579, 580, 581, 582, 583, 
584, 585, 586, 587, 588, 589, 590, 591, 592, 593, 
594, 595, 596, 597, 598, 599, 600, 601, 602, 603, 
604, 605, 606, 607, 608, 609, 610, 611, 612, 613, 
614, 615, 616, 617, 618, 619, 620, 621, 622, 623, 
624, 625, 626, 627, 628, 629, 630, 631, 632, 633, 
634, 635, 636, 637, 638, 639, 640, 641, 642, 643, 
644, 645, 646, 647, 648, 649, 650, 651, 652, 653, 
654, 655, 656, 657, 658, 659, 660, 661, 662, 663, 
664, 665, 666, 667, 668, 669, 670, 671, 672, 673, 
674, 675, 676, 677, 678, 679, 680, 681, 682, 683, 
684, 685, 686, 687, 688, 689, 690, 691, 692, 693, 
694, 695, 696, 697, 698, 699, 700, 701, 702, 703, 
704, 705, 706, 707, 708, 709, 710, 711, 712, 713, 
714, 715, 716, 717, 718, 719, 720, 721, 722, 723, 
724, 725, 726, 727, 728, 729, 730, 731, 732, 733, 
734, 735, 736, 737, 738, 739, 740, 741, 742, 743, 
744, 745, 746, 747, 748, 749, 750, 751, 752, 753, 
754, 755, 756, 757, 758, 759, 760, 761, 762, 763, 
764, 765, 766, 767, 768, 769, 770, 771, 772, 773, 
1002, 1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 1011, 
1012, 1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 1021, 
1022, 1023, 1024, 1027, 1028, 1029, 1030, 1031, 1032, 1033, 
1034, 1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 1043, 
1044, 1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053, 
1054, 1055, 1056, 1057, 1058, 1059, 1060, 1061, 1062, 1063, 
1064, 1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 1073, 
1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 1083, 
1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 1093, 
1094, 1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 1103, 
1104, 1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 1113, 
1114, 1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 1123, 
1124, 1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 
1134, 1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 1143, 
1144, 1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 
1154, 1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 1163, 
1164, 1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 1173, 
1174, 1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 1183, 
1184, 1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 1193, 
1194, 1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1203, 
1204, 1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 1213, 
1214, 1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 1223, 
1224, 1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 1233, 
1234, 1235, 1236, 1237, 1238, 1239, 1240, 1241, 1242, 1243, 
1244, 1245, 1246, 1247, 1248, 1249, 1250, 1251, 1252, 1253, 
2408, 2409, 2410, 2411, 2412, 2413, 2414, 2415, 2416, 2417, 
2418, 2419, 2420, 2421, 2422, 2423, 2424, 2425, 2426, 2427, 
2428, 2429, 2430, 2431, 2432, 2433, 2434, 2435, 2436, 2437, 
2438, 2439, 2440, 2441, 2442, 2443, 2444, 2445, 2446, 2447, 
2448, 2449, 2450, 2451, 2452, 2453, 2454, 2455, 2456, 2457, 
2458, 2459, 2460, 2461, 2462, 2463, 2464, 2465, 2466, 2467, 
2468, 2469, 2470, 2471, 2472, 2473, 2474, 2475, 2476, 2477, 
2478, 2479, 2480, 2481, 2482, 2483, 2484, 2485, 2486, 2487, 
2488, 2489, 2490, 2491, 2492, 2493, 2494, 2495, 2496, 2497, 
2498, 2499, 2500, 2501, 2502, 2503, 2504, 2505, 2506, 2507, 
2508, 2509, 2510, 2511, 2512, 2513, 2514, 2515, 2516, 2517, 
2518, 2519, 2520, 2521, 2522, 2523, 2524, 2525, 2526, 2527, 
2528, 2529, 2530, 2531, 2532, 2533, 2534, 2535, 2536, 2537, 
2538, 2539, 2540, 2541, 2542, 2543, 2544, 2545, 2546, 2547, 
2548, 2549, 2550, 2551, 2552, 2553, 2554, 2555, 2556, 2557, 
2558, 2559, 2560, 2561, 2562, 2563, 2564, 2565, 2566, 2567, 
2568, 2569, 2570, 2571, 2572, 2573, 2574, 2575, 2576, 2577, 
2578, 2579, 2580, 2581, 2582, 2583, 2584, 2585, 2586, 2587, 
2588, 2589, 2590, 2591, 2592, 2593, 2594, 2595, 2596, 2597, 
2598, 2599, 2600, 2601, 2602, 2603, 2604, 2605, 2606, 2607, 
2608, 2609, 2610, 2611, 2612, 2613, 2614, 2615, 2616, 2617, 
2618, 2619, 2620, 2621, 2622, 2623, 2624, 2625, 2626, 2627, 
2628, 2629, 2630, 2631, 2632, 2633, 2634, 2635, 2636, 2637, 
2638, 2639, 2640, 2641, 2642, 2643, 2644, 2645, 2646, 2647, 
2648, 2649, 2650, 2651, 2652, 2653, 2654, 2655, 2656, 2657, 
2658, 2659, 2660, 2661, 2662, 2663, 2664, 2665, 2666, 2667, 
2668, 2669, 2670, 2671, 2672, 2673, 2674, 2675, 2676, 2677, 
2678, 2679, 2680, 2681, 2682, 2683, 2684, 2685, 2686, 2687, 
2688, 2689, 2690, 2691, 2692, 2693, 2694, 2695, 2696, 2697, 
2698, 2699, 2700, 2701, 2702, 2703, 2704, 2705, 2706, 2707, 
2708, 2709, 2710, 2711, 2712, 2713, 2714, 2715, 2716, 2717, 
2718, 2719, 2720, 2721, 2722, 2723, 2724, 2725, 2726, 2727, 
2728, 2729, 2730, 2731, 2732, 2733, 2734, 2735, 2736, 2737, 
2738, 2739, 2740, 2741, 2742, 2743, 2744, 2745, 2746, 2747, 
2748, 2749, 2750, 2751, 2752, 2753, 2754, 2755, 2756, 2757, 
2758, 2759, 2760, 2761, 2762, 2763, 2764, 2765, 2766, 2767, 
2768, 2769, 2770, 2771, 2772, 2773, 2774, 2775, 2776, 2777, 
2778, 2779, 2780, 2781, 2782, 2783, 2784, 2785, 2786, 2787, 
2788, 2789, 2790, 2791, 2792, 2793, 2794, 2795, 2796, 2797, 
2798, 2799, 2800, 2801, 2802, 2803, 2804, 2805, 2806, 2807, 
2808, 2809, 2810, 2811, 2812, 2813, 2814, 2815, 2816, 2817, 
2818, 2819, 2820, 2821, 2822, 2823, 2824, 2825, 2826, 2827, 
2828, 2829, 2830, 2831, 2832, 2833, 2834, 2835, 2836, 2837, 
2838, 2839, 2840, 2841, 2842, 2843, 2844, 2845, 2846, 2847, 
2848, 2849, 2850, 2851, 2852, 2853, 2854, 2855, 2856, 2857, 
2858, 2859, 2860, 2861, 2862, 2863, 2864, 2865, 2866, 2867, 
2868, 2869, 2870, 2871, 2872, 2873, 2874, 2875, 2876, 2877, 
2878, 2879, 2880, 2881, 2882, 2883, 2884, 2885, 2886, 2887, 
2888, 2889, 2890, 2891, 2892, 2893, 2894, 2895, 2896, 2897, 
2898, 2899, 2900, 2901, 2902, 2903, 2904, 2905, 2906, 2907, 
2908, 2909, 2910, 2911, 2912, 2913, 2914, 2915, 2916, 2917, 
2918, 2919, 2920, 2921, 2922, 2923, 2924, 2925, 2926, 2927, 
2928, 2929, 2930, 2931, 2932, 2933, 2934, 2935, 2936, 2937, 
2938, 2939, 2940, 2941, 2942, 2943, 2944, 2945, 2946, 2947, 
2948, 2949, 2950, 2951, 2952, 2953, 2954, 2955, 2956, 2957, 
2958, 2959, 2960, 2961, 2962, 2963, 2964, 2965, 2966, 2967, 
2968, 2969, 2970, 2971, 2972, 2973, 2974, 2975, 2976, 2977, 
2978, 2979, 2980, 2981, 2982, 2983, 2984, 2985, 2986, 2987, 
2988, 2989, 2990, 2991, 2992, 2993, 2994, 2995, 2996, 2997, 
2998, 2999, 3000, 3001, 3002, 3003, 3004, 3005, 3006, 3007, 
3008, 3009, 3010, 3011, 3012, 3013, 3014, 3015, 3016, 3017, 
3018, 3019, 3020, 3021, 3022, 3023, 3024, 3025, 3026, 3027, 
3028, 3029, 3030, 3031, 3032, 3033, 3034, 3035, 3036, 3037, 
3038, 3039, 3040, 3041, 3042, 3043, 3044, 3045, 3046, 3047, 
3048, 3049, 5120, 5121, 5122, 5123, 5124, 5125, 5126, 5127, 
5128, 5129, 5130, 5131, 5132, 5133, 5134, 5135, 5136, 5137, 
5138, 5139, 5140, 5141, 5142, 5143, 5144, 5145, 5146, 5147, 
5148, 5149, 5150, 5151, 5152, 5153, 5154, 5155, 5156, 5157, 
5158, 5159, 5160, 5161, 5162, 5163, 5164, 5165, 5166, 5167, 
5168, 5169, 5170, 5171, 5172, 5173, 5174, 5175, 5176, 5177, 
5178, 5179, 5180, 5181, 5182, 5183, 5184, 5185, 5186, 5187, 
5188, 5189, 5190, 5191, 5192, 5193, 5194, 5195, 5196, 5197, 
5198, 5199, 5200, 5201, 5202, 5203, 5204, 5205, 5206, 5207, 
5208, 5209, 5210, 5211, 5212, 5213, 5214, 5215, 5216, 5217, 
5218, 5219, 5220, 5221, 5222, 5223, 5224, 5225, 5226, 5227, 
5228, 5229, 5230, 5231, 5232, 5233, 5234, 5235, 5236, 5237, 
5238, 5239, 5240, 5241, 5242, 5243, 5244, 5245, 5246, 5247, 
5248, 5249, 5250, 5251, 5252, 5253, 5254, 5255, 5256, 5257, 
5258, 5259, 5260, 5261, 5262, 5263, 5264, 5265, 5266, 5267, 
5268, 5269, 5270, 5271, 5272, 5273, 5274, 5275, 5276, 5277, 
5278, 5279, 5280, 5281, 5282, 5283, 5284, 5285, 5286, 5287, 
5288, 5289, 5290, 5291, 5292, 5293, 5294, 5295, 5296, 5297, 
5298, 5299, 5300, 5301, 5302, 5303, 5304, 5305, 5306, 5307, 
5308, 5309, 5310, 5311, 5312, 5313, 5314, 5315, 5316, 5317, 
5318, 5319, 5320, 5321, 5322, 5323, 5324, 5325, 5326, 5327, 
5328, 5329, 5330, 5331, 5332, 5333, 5334, 5335, 5336, 5337, 
5338, 5339, 5340, 5341, 5342, 5343, 5344, 5345, 5346, 5347, 
5348, 5349, 5350, 5351, 5352, 5353, 5354, 5355, 5356, 5357, 
5358, 5359, 5360, 5361, 5362, 5363, 5364, 5365, 5366, 5367, 
5368, 5369, 5370, 5371, 5372, 5373, 5374, 5375, 5376, 5377, 
5378, 5379, 5380, 5381, 5382, 5383, 5384, 5385, 5386, 5387, 
5388, 5389, 5390, 5391, 5392, 5393, 5394, 5395, 5396, 5397, 
5398, 5399, 5400, 5401, 5402, 5403, 5404, 5405, 5406, 5407, 
5408, 5409, 5410, 5411, 5412, 5413, 5414, 5415, 5416, 5417, 
5418, 5419, 5420, 5421, 5422, 5423, 5424, 5425, 5426, 5427, 
5428, 5429, 5430, 5431, 5432, 5433, 5434, 5435, 5436, 5437, 
5438, 5439, 5440, 5441, 5442, 5443, 5444, 5445, 5446, 5447, 
5448, 5449, 5450, 5451, 5452, 5453, 5454, 5455, 5456, 5457, 
5458, 5459, 5460, 5461, 5462, 5463, 5464, 5465, 5466, 5467, 
5468, 5469, 5470, 5471, 5472, 5473, 5474, 5475, 5476, 5477, 
5478, 5479, 5480, 5481, 5482, 5483, 5484, 5485, 5486, 5487, 
5488, 5489, 5490, 5491, 5492, 5493, 5494, 5495, 5496, 5497, 
5498, 5499, 5500, 5501, 5502, 5503, 5504, 5505, 5506, 5507, 
5508, 5509, 5510, 5511, 5512, 5513, 5514, 5515, 5516, 5517, 
5518, 5519, 5520, 5521, 5522, 5523, 5524, 5525, 5526, 5527, 
5528, 5529, 5530, 5531, 5532, 5533, 5534, 5535, 5536, 5537, 
5538, 5539, 5540, 5541, 5542, 5543, 5544, 5545, 5546, 5547, 
5548, 5549, 5550, 5551, 5552, 5553, 5554, 5555, 5556, 5557, 
5558, 5559, 5560, 5561, 5562, 5563, 5564, 5565, 5566, 5567, 
5568, 5569, 5570, 5571, 5572, 5573, 5574, 5575, 5576, 5577, 
5578, 5579, 5580, 5581, 5582, 5583, 5584, 5585, 5586, 5587, 
5588, 5589, 5590, 5591, 5592, 5593, 5594, 5595, 5596, 5597, 
5598, 5599, 5600, 5601, 5602, 5603, 5604, 5605, 5606, 5607, 
5608, 5609, 5610, 5611, 5612, 5613, 5614, 5615, 5616, 5617, 
5618, 5619, 5620, 5621, 5622, 5623, 5624, 5625, 5626, 5627, 
5628, 5629, 5630, 5631, 5632, 5633, 5634, 5635, 5636, 5637, 
5638, 5639, 5640, 5641, 5642, 5643, 5644, 5645, 5646, 5647, 
5648, 5649, 5650, 5651, 5652, 5653, 5654, 5655, 5656, 5657, 
5658, 5659, 5660, 5661, 5662, 5663, 5664, 5665, 5666, 5667, 
5668, 5669, 5670, 5671, 5672, 5673, 5674, 5675, 5676, 5677, 
5678, 5679, 5680, 5681, 5682, 5683, 5684, 5685, 5686, 5687, 
5688, 5689, 5690, 5691, 5692, 5693, 5694, 5695, 5696, 5697, 
5698, 5699, 5700, 5701, 5702, 5703, 5704, 5705, 5706, 5707, 
5708, 5709, 5710, 5711, 5712, 5713, 5714, 5715, 5716, 5717, 
5718, 5719, 5720, 5721, 5722, 5723, 5724, 5725, 5726, 5727, 
5728, 5729, 5730, 5731, 5732, 5733, 5734, 5735, 5736, 5737, 
5738, 5739, 5740, 5741, 5742, 5743, 5744, 5745, 5746, 5747, 
5748, 5749, 5750, 5751, 5752, 5753, 5754, 5755, 5756, 5757, 
5758, 5759, 5760, 5761, 5762, 5763, 5764, 5765, 5766, 5767, 
5768, 5769, 5770, 5771, 5772, 5773, 5774, 5775, 5776, 5777, 
5778, 5779, 5780, 5781, 5782, 5783, 5784, 5785, 5786, 5787, 
5788, 5789, 5790, 5791, 5792, 5793, 5794, 5795, 5796, 5797, 
5798, 5799, 5800, 5801, 5802, 5803, 5804, 5805, 5806, 5807, 
5808, 5809, 5810, 5811, 5812, 5813, 5814, 5815, 5816, 5817, 
5818, 5819, 5820, 5821, 5822, 5823, 5824, 5825, 5826, 5827, 
5828, 5829, 5830, 5831, 5832, 5833, 5834, 5835, 5836, 5837, 
5838, 5839, 5840, 5841, 5842, 5843, 5844, 5845, 5846, 5847, 
5848, 5849, 5850, 5851, 5852, 5853, 5854, 5855, 5856, 5857, 
5858, 5859, 5860, 5861, 5862, 5863, 5864, 5865, 5866, 5867, 
5868, 5869, 5870, 5871, 5872, 5873, 5874, 5875, 5876, 5877, 
5878, 5879, 5880, 5881, 5882, 5883, 5884, 5885, 5886, 5887, 
5888, 5889, 5890, 5891, 5892, 5893, 5894, 5895, 5896, 5897, 
5898, 5899, 5900, 5901, 5902, 5903, 5904, 5905, 5906, 5907, 
5908, 5909, 5910, 5911, 5912, 5913, 5914, 5915, 5916, 5917, 
5918, 5919, 5920, 5921, 5922, 5923, 5924, 5925, 5926, 5927, 
5928, 5929, 5930, 5931, 5932, 5933, 5934, 5935, 5936, 5937, 
5938, 5939, 5940, 5941, 5942, 5943, 5944, 5945, 5946, 5947, 
5948, 5949, 5950, 5951, 5952, 5953, 5954, 5955, 5956, 5957, 
5958, 5959, 5960, 5961, 5962, 5963, 5964, 5965, 5966, 5967, 
5968, 5969, 5970, 5971, 5972, 5973, 5974, 5975, 5976, 5977, 
5978, 5979, 5980, 5981, 5982, 5983, 5984, 5985, 5986, 5987, 
5988, 5989, 5990, 5991, 5992, 5993, 5994, 5995, 5996, 5997, 
5998, 5999, 6000, 6001, 6002, 6003, 6004, 6005, 6006, 6007, 
6008, 6009, 6010, 6011, 6012, 6013, 6014, 6015, 6016, 6017, 
6018, 6019, 6020, 6021, 6022, 6023, 6024, 6025, 6026, 6027, 
6028, 6029, 6030, 6031, 6032, 6033, 6034, 6035, 6036, 6037, 
6038, 6039, 6040, 6041, 6042, 6043, 6044, 6045, 6046, 6047, 
6048, 6049, 6050, 6051, 6052, 6053, 6054, 6055, 6056, 6057, 
6058, 6059, 6060, 6061, 6062, 6063, 6064, 6065, 6066, 6067, 
6068, 6069, 6070, 6071, 6072, 6073, 6074, 6075, 6076, 6077, 
6078, 6079, 6080, 6081, 6082, 6083, 6084, 6085, 6086, 6087, 
6088, 6089, 6090, 6091, 6092, 6093, 6094, 6095, 6096, 6097, 
6098, 6099, 6100, 6101, 6102, 6103, 6104, 6105, 6106, 6107, 
6108, 6109, 6110, 6111, 6112, 6113, 6114, 6115, 6116, 6117, 
6118, 6119, 6120, 6121, 6122, 6123, 6124, 6125, 6126, 6127, 
6128, 6129, 6130, 6131, 6132, 6133, 6134, 6135, 6136, 6137, 
6138, 6139, 6140, 6141, 6142, 6143, 6144, 6145, 6146, 6147, 
6148, 6149, 6150, 6151, 6152, 6153, 6154, 6155, 6156, 6157, 
6158, 6159, 6160, 6161, 6162, 6163, 6164, 6165, 6166, 6167, 
6168, 6169, 6170, 6171, 6172, 6173, 6174, 6175, 6176, 6177, 
6178, 6179, 6180, 6181, 6182, 6183, 6184, 6185, 6186, 6187, 
6188, 6189, 6190, 6191, 6192, 6193, 6194, 6195, 6196, 6197, 
6198, 6199, 6200, 6201, 6202, 6203, 6204, 6205, 6206, 6207, 
6208, 6209, 6210, 6211, 6212, 6213, 6214, 6215, 6216, 6217, 
6218, 6219, 6220, 6221, 6222, 6223, 6224, 6225, 6226, 6227, 
6228, 6229, 6230, 6231, 6232, 6233, 6234, 6235, 6236, 6237, 
6238, 6239, 6240, 6241, 6242, 6243, 6244, 6245, 6246, 6247, 
6248, 6249, 6250, 6251, 6252, 6253, 6254, 6255, 6256, 6257, 
6258, 6259, 6260, 6261, 6262, 6263, 6264, 6265, 6266, 6267, 
6268, 6269, 6270, 6271, 6272, 6273, 6274, 6275, 6276, 6277, 
6278, 6279, 6280, 6281, 6282, 6283, 6284, 6285, 6286, 6287, 
6288, 6289, 6290, 6291, 6292, 6293, 6294, 6295, 6296, 6297, 
6298, 6299, 6300, 6301, 6302, 6303, 6304, 6305, 6306, 6307, 
6308, 6309, 6310, 6311, 6312, 6313, 6314, 6315, 6316, 6317, 
6318, 6319, 6320, 6321, 6322, 6323, 6324, 6325, 6326, 6327, 
6328, 6329, 6330, 6331, 6332, 6333, 6334, 6335, 6336, 6337, 
6338, 6339, 6340, 6341, 6342, 6343, 6344, 6345, 6346, 6347, 
6348, 6349, 6350, 6351, 6352, 6353, 6354, 6355, 6356, 6357, 
6358, 6359, 6360, 6361, 6362, 6363, 6364, 6365, 6366, 6367, 
6368, 6369, 6370, 6371, 6372, 6373, 6374, 6375, 6376, 6377, 
6378, 6379, 6380, 6381, 6382, 6383, 6384, 6385, 6386, 6387, 
6388, 6389, 6390, 6391, 6392, 6393, 6394, 6395, 6396, 6397, 
6398, 6399, 6400, 6401, 6402, 6403, 6404, 6405, 6406, 6407, 
6408, 6409, 6410, 6411, 6412, 6413, 6414, 6415, 6416, 6417, 
6418, 6419, 6420, 6421, 6422, 6423, 6424, 6425, 6426, 6427, 
6428, 6429, 6430, 6431, 6432, 6433, 6434, 6435, 6436, 6437, 
6438, 6439, 6440, 6441, 6442, 6443, 6444, 6445, 6446, 6447, 
6448, 6449, 6450, 6451, 6452, 6453, 6454, 6455, 6456, 6457, 
6458, 6459, 6460, 6461, 6462, 6463, 6464, 6465, 6466, 6467, 
6468, 6469, 6470, 6471, 6472, 6473, 6474, 6475, 6476, 6477, 
6478, 6479, 6480, 6481, 6482, 6483, 6484, 6485, 6486, 6487, 
6488, 6489, 6490, 6491, 6492, 6493, 6494, 6495, 6496, 6497, 
6498, 6499, 6500, 6501, 6502, 6503, 6504, 6505, 6506, 6507, 
8623, 8624, 8625, 8626, 8627, 8628, 8629, 8630, 8631, 8632, 
8633, 8634, 8635, 8636, 8637, 8638, 8639, 8640, 8641, 8642, 
8643, 8644, 8645, 8646, 8647, 8648, 8649, 8650, 8651, 8652, 
8653, 8654, 8655, 8656, 8657, 8658, 8659, 8660, 8661, 8662, 
8663, 8664, 8665, 8666, 8667, 8668, 8669, 8670, 8671, 8672, 
8673, 8674, 8675, 8676, 8677, 8678, 8679, 8680, 8681, 8682, 
8683, 8684, 8685, 8686, 8687, 8688, 8689, 8690, 8691, 8692, 
8693, 8694, 8695, 8696, 8697, 8698, 8699, 8700, 8701, 8702, 
8703, 8704, 8705, 8706, 8707, 8708, 8709, 8710, 8711, 8712, 
8713, 8714, 8715, 8716, 8717, 8718, 8719, 8720, 8721, 8722, 
8723, 8724, 8725, 8726, 8727, 8728, 8729, 8730, 8731, 8732, 
8733, 8734, 8735, 8736, 8737, 8738, 8739, 8740, 8741, 8742, 
8743, 8744, 8745, 8746, 8747, 8748, 8749, 8750, 8751, 8752, 
8753, 8754, 8755, 8756, 8757, 8758, 8759, 8760, 8761, 8762, 
8763, 8764, 8765, 8766, 8767, 8768, 8769, 8770, 8771, 8772, 
8773, 8774, 8775, 8776, 8777, 8778, 8779, 8780, 8781, 8782, 
8783, 8784, 8785, 8786, 8787, 8788, 8789, 8790, 8791, 8792, 
8793, 8794, 8795, 8796, 8797, 8798, 8799, 8800, 8801, 8802, 
8803, 8804, 8805, 8806, 8807, 8808, 8809, 8810, 8811, 8812, 
8813, 8814, 8815, 8816, 8817, 8818, 8819, 8820, 8821, 8822, 
8823, 8824, 8825, 8826, 8827, 8828, 8829, 8830, 8831, 8832, 
8833, 8834, 8835, 8836, 8837, 8838, 8839, 8840, 8841, 8842, 
8843, 8844, 8845, 8846, 8847, 8848, 8849, 8850, 8851, 8852, 
8853, 8854, 8855, 8856, 8857, 8858, 8859, 8860, 8861, 8862, 
8863, 8864, 8865, 8866, 8867, 8868, 8869, 8870, 8871, 8872, 
8873, 8874, 8875, 8876, 8877, 8878, 8879, 8880, 8881, 8882, 
8883, 8884, 8885, 8886, 8887, 8888, 8889, 8890, 8891, 8892, 
8893, 8894, 8895, 8896, 8897, 8898, 8899, 8900, 8901, 8902, 
8903, 8904, 8905, 8906, 8907, 8908, 8909, 8910, 8911, 8912, 
8913, 8914, 8915, 8916, 8917, 8918, 8919, 8920, 8921, 8922, 
8923, 8924, 8925, 8926, 8927, 8928, 8929, 8930, 8931, 8932, 
8933, 8934, 8935, 8936, 8937, 8938, 8939, 8940, 8941, 8942, 
8943, 8944, 8945, 8946, 8947, 8948, 8949, 8950, 8951, 8952, 
8953, 8954, 8955, 8956, 8957, 8958, 8959, 8960, 8961, 8962, 
8963, 8964, 8965, 8966, 8967, 8968, 8969, 8970, 8971, 8972, 
8973, 8974, 8975, 8976, 8977, 8978, 8979, 8980, 8981, 8982, 
8983, 8984, 8985, 8986, 8987, 8988, 8989, 8990, 8991, 8992, 
8993, 8994, 8995, 8996, 8997, 8998, 8999, 9000, 9001, 9002, 
9003, 9004, 9005, 9006, 9007, 9008, 9009, 9010, 9011, 9012, 
9013, 9014, 9015, 9016, 9017, 9018, 9019, 9020, 9021, 9022, 
9023, 9024, 9025, 9026, 9027, 9028, 9029, 9030, 9031, 9032, 
9033, 9034, 9035, 9036, 9037, 9038, 9039, 9040, 9041, 9042, 
9043, 9044, 9045, 9046, 9047, 9048, 9049, 9050, 9051, 9052, 
9053, 9054, 9055, 9056, 9057, 9058, 9059, 9060, 9061, 9062, 
9063, 9064, 9065, 9066, 9067, 9068, 9069, 9070, 9071, 9072, 
9073, 9074, 9075, 9076, 9077, 9078, 9079, 9080, 9081, 9082, 
9083, 9084, 9085, 9086, 9087, 9088, 9089, 9090, 9091, 9092, 
9093, 9094, 9095, 9096, 9097, 9098, 9099, 9100, 9101, 9102, 
9103, 9104, 9105, 9106, 9107, 9108, 9109, 9110, 9111, 9112, 
9113, 9114, 9115, 9116, 9117, 9118, 9119, 9120, 9121, 9122, 
9123, 9124, 9125, 9126, 9127, 9128, 9129, 9130, 9131, 9132, 
9133, 9134, 9135, 9136, 9137, 9138, 9139, 9140, 9141, 9142, 
9143, 9144, 9145, 9146, 9147, 9148, 9149, 9150, 9151, 9152, 
9153, 9154, 9155, 9156, 9157, 9158, 9159, 9160, 9161, 9162, 
9163, 9164, 9165, 9166, 9167, 9168, 9169, 9170, 9171, 9172, 
9173, 9174, 9175, 9176, 9177, 9178, 9179, 9180, 9181, 9182, 
9183, 9184, 9185, 9186, 9187, 9188, 9189, 9190, 9191, 9192, 
9193, 9194, 9195, 9196, 9197, 9198, 9199, 9200, 9201, 9202, 
9203, 9204, 9205, 9206, 9207, 9208, 9209, 9210, 9211, 9212, 
9213, 9214, 9215, 9216, 9217, 9218, 9219, 9220, 9221, 9222, 
9223, 9224, 9225, 9226, 9227, 9228, 9229, 9230, 9231, 9232, 
9233, 9234, 9235, 9236, 9237, 9238, 9239, 9240, 9241, 9242, 
9243, 9244, 9245, 9246, 9247, 9248, 9249, 9250, 9251, 9252, 
9253, 9254, 9255, 9256, 9257, 9258, 9259, 9260, 9261, 9262, 
9263, 9264, 9265, 9266, 9267, 9268, 9269, 9270, 9271, 9272, 
9273, 9274, 9275, 9276, 9277, 9278, 9279, 9280, 9281, 9282, 
9283, 9284, 9285, 9286, 9287, 9288, 9289, 9290, 9291, 9292, 
9293, 9294, 9295, 9296, 9297, 9298, 9299, 9300, 9301, 9302, 
9303, 9304, 9305, 9306, 9307, 9308, 9309, 9310, 9311, 9312, 
9313, 9314, 9315, 9316, 9317, 9318, 9319, 9320, 9321, 9322, 
9323, 9324, 9325, 9326, 9327, 9328, 9329, 9330, 9331, 9332, 
9333, 9334, 9335, 9336, 9337, 9338, 9339, 9340, 9341, 9342, 
9343, 9344, 9345, 9346, 9347, 9348, 9349, 9350, 9351, 9352, 
9353, 9354, 9355, 9356, 9357, 9358, 9359, 9360, 9361, 9362, 
9363, 9364, 9365, 9366, 9367, 9368, 9369, 9370, 9371, 9372, 
9373, 9374, 9375, 9376, 9377, 9378, 9379, 9380, 9381, 9382, 
9383, 9384, 9385, 9386, 9387, 9388, 9389, 9390, 9391, 9392, 
9393, 9394, 9395, 9396, 9397, 9398, 9399, 9400, 9401, 9402, 
9403, 9404, 9405, 9406, 9407, 9408, 9409, 9410, 9411, 9412, 
9413, 9414, 9415, 9416, 9417, 9418, 9419, 9420, 9421, 9422, 
9423, 9424, 9425, 9426, 9427, 9428, 9429, 9430, 9431, 9432, 
9433, 9434, 9435, 9436, 9437, 9438, 9439, 9440, 9441, 9442, 
9443, 9444, 9445, 9446, 9447, 9448, 9449, 9450, 9451, 9452, 
9453, 9454, 9455, 9456, 9457, 9458, 9459, 9460, 9461, 9462, 
9463, 9464, 9465, 9466, 9467, 9468, 9469, 9470, 9471, 9472, 
9473, 9474, 9475, 9476, 9477, 9478, 9479, 9480, 9481, 9482, 
9483, 9484, 9485, 9486, 9487, 9488, 9489, 9490, 9491, 9492, 
9493, 9494, 9495, 9496, 9497, 9498, 9499, 9500, 9501, 9502, 
9503, 9504, 9505, 9506, 9507, 9508, 9509, 9510, 9511, 9512, 
9513, 9514, 9515, 9516, 9517, 9518, 9519, 9520, 9521, 9522, 
9523, 9524, 9525, 9526, 9527, 9528, 9529, 9530, 9531, 9532, 
9533, 9534, 9535, 9536, 9537, 9538, 9539, 9540, 9541, 9542, 
9543, 9544, 9545, 9546, 9547, 9548, 9549, 9550, 9551, 9552, 
9553, 9554, 9555, 9556, 9557, 9558, 9559, 9560, 9561, 9562, 
9563, 9564, 9565, 9566, 9567, 9568, 9569, 9570, 9571, 9572, 
9573, 9574, 9575, 9576, 9577, 9578, 9579, 9580, 9581, 9582, 
9583, 9584, 9585, 9586, 9587, 9588, 9589, 9590, 9591, 9592, 
9593, 9594, 9595, 9596, 9597, 9598, 9599, 9600, 9601, 9602, 
9603, 9604, 9605, 9606, 9607, 9608, 9609, 9610, 9611, 9612, 
9613, 9614, 9615, 9616, 9617, 9618, 9619, 9620, 9621, 9622, 
9623, 9624, 9625, 9626, 9627, 9628, 9629, 9630, 9631, 9632, 
9633, 9634, 9635, 9636, 9637, 9638, 9639, 9640, 9641, 9642, 
9643, 9644, 9645, 9646, 9647, 9648, 9649, 9650, 9651, 9652, 
9653, 9654, 9655, 9656, 9657, 9658, 9659, 9660, 9661, 9662, 
9663, 9664, 9665, 9666, 9667, 9668, 9669, 9670, 9671, 9672, 
9673, 9674, 9675, 9676, 9677, 9678, 9679, 9680, 9681, 9682, 
9683, 9684, 9685, 9686, 9687, 9688, 9689, 9690, 9691, 9692, 
9693, 9694, 9695, 9696, 9697, 9698, 9699, 9700, 9701, 9702, 
9703, 9704, 9705, 9706, 9707, 9708, 9709, 9710, 9711, 9712, 
9713, 9714, 9715, 9716, 9717, 9718, 9719, 9720, 9721, 9722, 
9723, 9724, 9725, 9726, 9727, 9728, 9729, 9730, 9731, 9732, 
9733, 9734, 9735, 9736, 9737, 9738, 9739, 9740, 9741, 9742, 
9743, 9744, 9745, 9746, 9747, 9748, 9749, 9750, 9751, 9752, 
9753, 9754, 9755, 9756, 9757, 9758, 9759, 9760, 9761, 9762, 
9763, 9764, 9765, 9766, 9767, 9768, 9769, 9770, 9771, 9772, 
9773, 9774, 9775, 9776, 9777, 9778, 9779, 9780, 9781, 9782, 
9783, 9784, 9785, 9786, 9787, 9788, 9789, 9790, 9791, 9792, 
9793, 9794, 9795, 9796, 9797, 9798, 9799, 9800, 9801, 9802, 
9803, 9804, 9805, 9806, 9807, 9808, 9809, 9810, 9811, 9812, 
9813, 9814, 9815, 9816, 9817, 9818, 9819, 9820, 9821, 9822, 
9823, 9824, 9825, 9826, 9827, 9828, 9829, 9830, 9831, 9832, 
9833, 9834, 9835, 9836, 9837, 9838, 9839, 9840, 9841, 9842, 
9843, 9844, 9845, 9846, 9847, 9848, 9849, 9850, 9851, 9852, 
9853, 9854, 9855, 9856, 9857, 9858, 9859, 9860, 9861, 9862, 
9863, 9864, 9865, 9866, 9867, 9868, 9869, 9870, 9871, 9872, 
9873, 9874, 9875, 9876, 9877, 9878, 9879, 9880, 9881, 9882, 
9883, 9884, 9885, 9886, 9887, 9888, 9889, 9890, 9891, 9892, 
9893, 9894, 9895, 9896, 9897, 9898, 9899, 9900, 9901, 9902, 
9903, 9904, 9905, 9906, 9907, 9908, 9909, 9910, 9911, 9912, 
9913, 9914, 9915, 9916, 9917, 9918, 9919, 9920, 9921, 9922, 
9923, 9924, 9925, 9926, 9927, 9928, 9929, 9930, 9931, 9932, 
9933, 9934, 9935, 9936, 9937, 9938, 9939, 9940, 9941, 9942, 
9943, 9944, 9945, 9946, 9947, 9948, 9949, 9950, 9951, 9952, 
9953, 9954, 9955, 9956, 9957, 9958, 9959, 9960, 9961, 9962, 
9963, 9964, 9965, 9966, 9967, 9968, 9969, 9970, 9971, 9972, 
9973, 9974, 9975, 9976, 9977, 9978, 9979, 9980, 9981, 9982, 
9983, 9984, 9985, 9986, 9987, 9988, 9989, 9990, 9991, 9992, 
9993, 9994, 9995, 9996, 9997, 9998, 9999, 10000, 10001, 10002, 
10003, 10004, 10005, 10006, 10007, 10008, 10009, 10010, 10011, 10012, 
10013, 10014, 10015, 10016, 10017, 10018, 10019, 10020, 10021, 10022, 
10023, 10024, 10025, 10026, 10027, 10028, 10029, 10030, 10031, 10032, 
10033, 10034, 10035, 10036, 10037, 10038, 10039, 10040, 10041, 10042, 
10043, 10044, 10045, 10046, 10047, 10048, 10049, 10050, 10051, 10052, 
10053, 10054, 10055, 10056, 10057, 10058, 10059, 10060, 10061, 10062, 
10063, 10064, 10065, 10066, 10067, 10068, 10069, 10070, 10071, 10072, 
10073, 10074, 10075, 10076, 10077, 10078, 10079, 19484, 19485, 19486, 
19487, 19488, 19489, 19490, 19491, 19492, 19493, 19494, 19495, 19496, 
19497, 19498, 19499, 19500, 19501, 19502, 19503, 19504, 19505, 19506, 
19507, 19508, 19509, 19510, 19511, 19512, 19513, 19514, 19515, 19516, 
19517, 19518, 19519, 19520, 19521, 19522, 19523, 19524, 19525, 19526, 
19527, 19528, 19529, 19530, 19531, 19532, 19533, 19534, 19535, 19536, 
19537, 19538, 19539, 19540, 19541, 19542, 19543, 19544, 19545, 19546, 
19547, 19548, 19549, 19550, 19551, 19552, 19553, 19554, 19555, 19556, 
19557, 19558, 19559, 19560, 19561, 19562, 19563, 19564, 19565, 19566, 
19567, 19568, 19569, 19570, 19571, 19572, 19573, 19574, 19575, 19576, 
19577, 19578, 19579, 19580, 19581, 19582, 19583, 19584, 19585, 19586, 
19587, 19588, 19589, 19590, 19591, 19592, 19593, 19594, 19595, 19596, 
19597, 19598, 19599, 19600, 19601, 19602, 19603, 19604, 19605, 19606, 
19607, 19608, 19609, 19610, 19611, 19612, 19613, 19614, 19615, 19616, 
19617, 19618, 19619, 19620, 19621, 19622, 19623, 19624, 19625, 19626, 
19627, 19628, 19629, 19630, 19631, 19632, 19633, 19634, 19635, 19636, 
19637, 19638, 19639, 19640, 19641, 19642, 19643, 19644, 19645, 19646, 
19647, 19648, 19649, 19650, 19651, 19652, 19653, 19654, 19655, 19656, 
19657, 19658, 19659, 19660, 19661, 19662, 19663, 19664, 19665, 19666, 
19667, 19668, 19669, 19670, 19671, 19672, 19673, 19674, 19675, 19676, 
19677, 19678, 19679, 19680, 19681, 19682, 19683, 19684, 19685, 19686, 
19687, 19688, 19689, 19690, 19691, 19692, 19693, 19694, 19695, 19696, 
19697, 19698, 19699, 19700, 19701, 19702, 19703, 19704, 19705, 19706, 
19707, 19708, 19709, 19710, 19711, 19712, 19713, 19714, 19715, 19716, 
19717, 19718, 19719, 19720, 19721, 19722, 19723, 19724, 19725, 19726, 
19727, 19728, 19729, 19730, 19731, 19732, 19733, 19734, 19735, 19736, 
19737, 19738, 19739, 19740, 19741, 19742, 19743, 19744, 19745, 19746, 
19747, 19748, 19749, 19750, 19751, 19752, 19753, 19754, 19755, 19756, 
19757, 19758, 19759, 19760, 19761, 19762, 19763, 19764, 19765, 19766, 
19767, 19768, 19769, 19770, 19771, 19772, 19773, 19774, 19775, 19776, 
19777, 19778, 19779, 19780, 19781, 19782, 19783, 19784, 19785, 19786, 
19787, 19788, 19789, 19790, 19791, 19792, 19793, 19794, 19795, 19796, 
19797, 19798, 19799, 19800, 19801, 19802, 19803, 19804, 19805, 19806, 
19807, 19808, 19809, 19810, 19811, 19812, 19813, 19814, 19815, 19816, 
19817, 19818, 19819, 19820, 19821, 19822, 19823, 19824, 19825, 19826, 
19827, 19828, 19829, 19830, 19831, 19832, 19833, 19834, 19835, 19836, 
19837, 19838, 19839, 19840, 19841, 19842, 19843, 19844, 19845, 19846, 
19847, 19848, 19849, 19850, 19851, 19852, 19853, 19854, 19855, 19856, 
19857, 19858, 19859, 19860, 19861, 19862, 19863, 19864, 19865, 19866, 
19867, 19868, 19869, 19870, 19871, 19872, 19873, 19874, 19875, 19876, 
19877, 19878, 19879, 19880, 19881, 19882, 19883, 19884, 19885, 19886, 
19887, 19888, 19889, 19890, 19891, 19892, 19893, 19894, 19895, 19896, 
19897, 19898, 19899, 19900, 19901, 19902, 19903, 19904, 19905, 19906, 
19907, 19908, 19909, 19910, 19911, 19912, 19913, 19914, 19915, 19916, 
19917, 19918, 19919, 19920, 19921, 19922, 19923, 19924, 19925, 19926, 
19927, 19928, 19929, 19930, 19931, 19932, 19933, 19934, 19935, 19936, 
19937, 19938, 19939, 19940, 19941, 19942, 19943, 19944, 19945, 19946, 
19947, 19948, 19949, 19950, 19951, 19952, 19953, 19954, 19955, 19956, 
