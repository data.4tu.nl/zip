9271, 22126, 22149, 22402, 22379, 22127, 22150, 22403, 22380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9272, 22127, 22150, 22403, 22380, 22128, 22151, 22404, 22381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9273, 22128, 22151, 22404, 22381, 4959, 4960, 4971, 4970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9274, 3143, 3144, 3155, 3154, 22129, 22152, 22405, 22382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9275, 22129, 22152, 22405, 22382, 22130, 22153, 22406, 22383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9276, 22130, 22153, 22406, 22383, 22131, 22154, 22407, 22384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9277, 22131, 22154, 22407, 22384, 22132, 22155, 22408, 22385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9278, 22132, 22155, 22408, 22385, 22133, 22156, 22409, 22386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9279, 22133, 22156, 22409, 22386, 22134, 22157, 22410, 22387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9280, 22134, 22157, 22410, 22387, 22135, 22158, 22411, 22388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9281, 22135, 22158, 22411, 22388, 22136, 22159, 22412, 22389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9282, 22136, 22159, 22412, 22389, 22137, 22160, 22413, 22390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9283, 22137, 22160, 22413, 22390, 22138, 22161, 22414, 22391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9284, 22138, 22161, 22414, 22391, 22139, 22162, 22415, 22392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9285, 22139, 22162, 22415, 22392, 22140, 22163, 22416, 22393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9286, 22140, 22163, 22416, 22393, 22141, 22164, 22417, 22394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9287, 22141, 22164, 22417, 22394, 22142, 22165, 22418, 22395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9288, 22142, 22165, 22418, 22395, 22143, 22166, 22419, 22396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9289, 22143, 22166, 22419, 22396, 22144, 22167, 22420, 22397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9290, 22144, 22167, 22420, 22397, 22145, 22168, 22421, 22398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9291, 22145, 22168, 22421, 22398, 22146, 22169, 22422, 22399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9292, 22146, 22169, 22422, 22399, 22147, 22170, 22423, 22400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9293, 22147, 22170, 22423, 22400, 22148, 22171, 22424, 22401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9294, 22148, 22171, 22424, 22401, 22149, 22172, 22425, 22402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9295, 22149, 22172, 22425, 22402, 22150, 22173, 22426, 22403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9296, 22150, 22173, 22426, 22403, 22151, 22174, 22427, 22404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9297, 22151, 22174, 22427, 22404, 4960, 4961, 4972, 4971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9298, 3144, 3145, 3156, 3155, 22152, 22175, 22428, 22405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9299, 22152, 22175, 22428, 22405, 22153, 22176, 22429, 22406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9300, 22153, 22176, 22429, 22406, 22154, 22177, 22430, 22407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9301, 22154, 22177, 22430, 22407, 22155, 22178, 22431, 22408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9302, 22155, 22178, 22431, 22408, 22156, 22179, 22432, 22409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9303, 22156, 22179, 22432, 22409, 22157, 22180, 22433, 22410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9304, 22157, 22180, 22433, 22410, 22158, 22181, 22434, 22411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9305, 22158, 22181, 22434, 22411, 22159, 22182, 22435, 22412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9306, 22159, 22182, 22435, 22412, 22160, 22183, 22436, 22413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9307, 22160, 22183, 22436, 22413, 22161, 22184, 22437, 22414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9308, 22161, 22184, 22437, 22414, 22162, 22185, 22438, 22415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9309, 22162, 22185, 22438, 22415, 22163, 22186, 22439, 22416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9310, 22163, 22186, 22439, 22416, 22164, 22187, 22440, 22417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9311, 22164, 22187, 22440, 22417, 22165, 22188, 22441, 22418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9312, 22165, 22188, 22441, 22418, 22166, 22189, 22442, 22419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9313, 22166, 22189, 22442, 22419, 22167, 22190, 22443, 22420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9314, 22167, 22190, 22443, 22420, 22168, 22191, 22444, 22421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9315, 22168, 22191, 22444, 22421, 22169, 22192, 22445, 22422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9316, 22169, 22192, 22445, 22422, 22170, 22193, 22446, 22423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9317, 22170, 22193, 22446, 22423, 22171, 22194, 22447, 22424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9318, 22171, 22194, 22447, 22424, 22172, 22195, 22448, 22425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9319, 22172, 22195, 22448, 22425, 22173, 22196, 22449, 22426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9320, 22173, 22196, 22449, 22426, 22174, 22197, 22450, 22427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9321, 22174, 22197, 22450, 22427, 4961, 4962, 4973, 4972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9322, 3145, 3146, 3157, 3156, 22175, 22198, 22451, 22428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9323, 22175, 22198, 22451, 22428, 22176, 22199, 22452, 22429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9324, 22176, 22199, 22452, 22429, 22177, 22200, 22453, 22430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9325, 22177, 22200, 22453, 22430, 22178, 22201, 22454, 22431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9326, 22178, 22201, 22454, 22431, 22179, 22202, 22455, 22432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9327, 22179, 22202, 22455, 22432, 22180, 22203, 22456, 22433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9328, 22180, 22203, 22456, 22433, 22181, 22204, 22457, 22434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9329, 22181, 22204, 22457, 22434, 22182, 22205, 22458, 22435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9330, 22182, 22205, 22458, 22435, 22183, 22206, 22459, 22436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9331, 22183, 22206, 22459, 22436, 22184, 22207, 22460, 22437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9332, 22184, 22207, 22460, 22437, 22185, 22208, 22461, 22438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9333, 22185, 22208, 22461, 22438, 22186, 22209, 22462, 22439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9334, 22186, 22209, 22462, 22439, 22187, 22210, 22463, 22440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9335, 22187, 22210, 22463, 22440, 22188, 22211, 22464, 22441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9336, 22188, 22211, 22464, 22441, 22189, 22212, 22465, 22442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9337, 22189, 22212, 22465, 22442, 22190, 22213, 22466, 22443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9338, 22190, 22213, 22466, 22443, 22191, 22214, 22467, 22444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9339, 22191, 22214, 22467, 22444, 22192, 22215, 22468, 22445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9340, 22192, 22215, 22468, 22445, 22193, 22216, 22469, 22446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9341, 22193, 22216, 22469, 22446, 22194, 22217, 22470, 22447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9342, 22194, 22217, 22470, 22447, 22195, 22218, 22471, 22448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9343, 22195, 22218, 22471, 22448, 22196, 22219, 22472, 22449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9344, 22196, 22219, 22472, 22449, 22197, 22220, 22473, 22450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9345, 22197, 22220, 22473, 22450, 4962, 4963, 4974, 4973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9346, 3146, 3147, 3158, 3157, 22198, 22221, 22474, 22451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9347, 22198, 22221, 22474, 22451, 22199, 22222, 22475, 22452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9348, 22199, 22222, 22475, 22452, 22200, 22223, 22476, 22453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9349, 22200, 22223, 22476, 22453, 22201, 22224, 22477, 22454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9350, 22201, 22224, 22477, 22454, 22202, 22225, 22478, 22455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9351, 22202, 22225, 22478, 22455, 22203, 22226, 22479, 22456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9352, 22203, 22226, 22479, 22456, 22204, 22227, 22480, 22457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9353, 22204, 22227, 22480, 22457, 22205, 22228, 22481, 22458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9354, 22205, 22228, 22481, 22458, 22206, 22229, 22482, 22459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9355, 22206, 22229, 22482, 22459, 22207, 22230, 22483, 22460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9356, 22207, 22230, 22483, 22460, 22208, 22231, 22484, 22461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9357, 22208, 22231, 22484, 22461, 22209, 22232, 22485, 22462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9358, 22209, 22232, 22485, 22462, 22210, 22233, 22486, 22463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9359, 22210, 22233, 22486, 22463, 22211, 22234, 22487, 22464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9360, 22211, 22234, 22487, 22464, 22212, 22235, 22488, 22465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9361, 22212, 22235, 22488, 22465, 22213, 22236, 22489, 22466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9362, 22213, 22236, 22489, 22466, 22214, 22237, 22490, 22467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9363, 22214, 22237, 22490, 22467, 22215, 22238, 22491, 22468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9364, 22215, 22238, 22491, 22468, 22216, 22239, 22492, 22469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9365, 22216, 22239, 22492, 22469, 22217, 22240, 22493, 22470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9366, 22217, 22240, 22493, 22470, 22218, 22241, 22494, 22471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9367, 22218, 22241, 22494, 22471, 22219, 22242, 22495, 22472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9368, 22219, 22242, 22495, 22472, 22220, 22243, 22496, 22473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9369, 22220, 22243, 22496, 22473, 4963, 4964, 4975, 4974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9370, 3147, 3148, 3159, 3158, 22221, 22244, 22497, 22474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9371, 22221, 22244, 22497, 22474, 22222, 22245, 22498, 22475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9372, 22222, 22245, 22498, 22475, 22223, 22246, 22499, 22476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9373, 22223, 22246, 22499, 22476, 22224, 22247, 22500, 22477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9374, 22224, 22247, 22500, 22477, 22225, 22248, 22501, 22478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9375, 22225, 22248, 22501, 22478, 22226, 22249, 22502, 22479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9376, 22226, 22249, 22502, 22479, 22227, 22250, 22503, 22480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9377, 22227, 22250, 22503, 22480, 22228, 22251, 22504, 22481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9378, 22228, 22251, 22504, 22481, 22229, 22252, 22505, 22482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9379, 22229, 22252, 22505, 22482, 22230, 22253, 22506, 22483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9380, 22230, 22253, 22506, 22483, 22231, 22254, 22507, 22484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9381, 22231, 22254, 22507, 22484, 22232, 22255, 22508, 22485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9382, 22232, 22255, 22508, 22485, 22233, 22256, 22509, 22486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9383, 22233, 22256, 22509, 22486, 22234, 22257, 22510, 22487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9384, 22234, 22257, 22510, 22487, 22235, 22258, 22511, 22488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9385, 22235, 22258, 22511, 22488, 22236, 22259, 22512, 22489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9386, 22236, 22259, 22512, 22489, 22237, 22260, 22513, 22490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9387, 22237, 22260, 22513, 22490, 22238, 22261, 22514, 22491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9388, 22238, 22261, 22514, 22491, 22239, 22262, 22515, 22492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9389, 22239, 22262, 22515, 22492, 22240, 22263, 22516, 22493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9390, 22240, 22263, 22516, 22493, 22241, 22264, 22517, 22494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9391, 22241, 22264, 22517, 22494, 22242, 22265, 22518, 22495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9392, 22242, 22265, 22518, 22495, 22243, 22266, 22519, 22496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9393, 22243, 22266, 22519, 22496, 4964, 4965, 4976, 4975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9394, 3148, 284, 285, 3159, 22244, 4269, 4292, 22497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9395, 22244, 4269, 4292, 22497, 22245, 4270, 4293, 22498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9396, 22245, 4270, 4293, 22498, 22246, 4271, 4294, 22499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9397, 22246, 4271, 4294, 22499, 22247, 4272, 4295, 22500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9398, 22247, 4272, 4295, 22500, 22248, 4273, 4296, 22501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9399, 22248, 4273, 4296, 22501, 22249, 4274, 4297, 22502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9400, 22249, 4274, 4297, 22502, 22250, 4275, 4298, 22503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9401, 22250, 4275, 4298, 22503, 22251, 4276, 4299, 22504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9402, 22251, 4276, 4299, 22504, 22252, 4277, 4300, 22505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9403, 22252, 4277, 4300, 22505, 22253, 4278, 4301, 22506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9404, 22253, 4278, 4301, 22506, 22254, 4279, 4302, 22507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9405, 22254, 4279, 4302, 22507, 22255, 4280, 4303, 22508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9406, 22255, 4280, 4303, 22508, 22256, 4281, 4304, 22509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9407, 22256, 4281, 4304, 22509, 22257, 4282, 4305, 22510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9408, 22257, 4282, 4305, 22510, 22258, 4283, 4306, 22511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9409, 22258, 4283, 4306, 22511, 22259, 4284, 4307, 22512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9410, 22259, 4284, 4307, 22512, 22260, 4285, 4308, 22513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9411, 22260, 4285, 4308, 22513, 22261, 4286, 4309, 22514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9412, 22261, 4286, 4309, 22514, 22262, 4287, 4310, 22515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9413, 22262, 4287, 4310, 22515, 22263, 4288, 4311, 22516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9414, 22263, 4288, 4311, 22516, 22264, 4289, 4312, 22517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9415, 22264, 4289, 4312, 22517, 22265, 4290, 4313, 22518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9416, 22265, 4290, 4313, 22518, 22266, 4291, 4314, 22519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9417, 22266, 4291, 4314, 22519, 4965, 444, 445, 4976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9418, 251, 3149, 3160, 252, 3510, 22267, 22520, 3533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9419, 3510, 22267, 22520, 3533, 3511, 22268, 22521, 3534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9420, 3511, 22268, 22521, 3534, 3512, 22269, 22522, 3535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9421, 3512, 22269, 22522, 3535, 3513, 22270, 22523, 3536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9422, 3513, 22270, 22523, 3536, 3514, 22271, 22524, 3537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9423, 3514, 22271, 22524, 3537, 3515, 22272, 22525, 3538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9424, 3515, 22272, 22525, 3538, 3516, 22273, 22526, 3539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9425, 3516, 22273, 22526, 3539, 3517, 22274, 22527, 3540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9426, 3517, 22274, 22527, 3540, 3518, 22275, 22528, 3541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9427, 3518, 22275, 22528, 3541, 3519, 22276, 22529, 3542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9428, 3519, 22276, 22529, 3542, 3520, 22277, 22530, 3543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9429, 3520, 22277, 22530, 3543, 3521, 22278, 22531, 3544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9430, 3521, 22278, 22531, 3544, 3522, 22279, 22532, 3545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9431, 3522, 22279, 22532, 3545, 3523, 22280, 22533, 3546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9432, 3523, 22280, 22533, 3546, 3524, 22281, 22534, 3547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9433, 3524, 22281, 22534, 3547, 3525, 22282, 22535, 3548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9434, 3525, 22282, 22535, 3548, 3526, 22283, 22536, 3549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9435, 3526, 22283, 22536, 3549, 3527, 22284, 22537, 3550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9436, 3527, 22284, 22537, 3550, 3528, 22285, 22538, 3551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9437, 3528, 22285, 22538, 3551, 3529, 22286, 22539, 3552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9438, 3529, 22286, 22539, 3552, 3530, 22287, 22540, 3553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9439, 3530, 22287, 22540, 3553, 3531, 22288, 22541, 3554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9440, 3531, 22288, 22541, 3554, 3532, 22289, 22542, 3555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9441, 3532, 22289, 22542, 3555, 365, 4966, 4977, 366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9442, 3149, 3150, 3161, 3160, 22267, 22290, 22543, 22520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9443, 22267, 22290, 22543, 22520, 22268, 22291, 22544, 22521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9444, 22268, 22291, 22544, 22521, 22269, 22292, 22545, 22522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9445, 22269, 22292, 22545, 22522, 22270, 22293, 22546, 22523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9446, 22270, 22293, 22546, 22523, 22271, 22294, 22547, 22524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9447, 22271, 22294, 22547, 22524, 22272, 22295, 22548, 22525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9448, 22272, 22295, 22548, 22525, 22273, 22296, 22549, 22526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9449, 22273, 22296, 22549, 22526, 22274, 22297, 22550, 22527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9450, 22274, 22297, 22550, 22527, 22275, 22298, 22551, 22528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9451, 22275, 22298, 22551, 22528, 22276, 22299, 22552, 22529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9452, 22276, 22299, 22552, 22529, 22277, 22300, 22553, 22530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9453, 22277, 22300, 22553, 22530, 22278, 22301, 22554, 22531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9454, 22278, 22301, 22554, 22531, 22279, 22302, 22555, 22532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9455, 22279, 22302, 22555, 22532, 22280, 22303, 22556, 22533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9456, 22280, 22303, 22556, 22533, 22281, 22304, 22557, 22534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9457, 22281, 22304, 22557, 22534, 22282, 22305, 22558, 22535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9458, 22282, 22305, 22558, 22535, 22283, 22306, 22559, 22536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9459, 22283, 22306, 22559, 22536, 22284, 22307, 22560, 22537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9460, 22284, 22307, 22560, 22537, 22285, 22308, 22561, 22538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9461, 22285, 22308, 22561, 22538, 22286, 22309, 22562, 22539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9462, 22286, 22309, 22562, 22539, 22287, 22310, 22563, 22540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9463, 22287, 22310, 22563, 22540, 22288, 22311, 22564, 22541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9464, 22288, 22311, 22564, 22541, 22289, 22312, 22565, 22542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9465, 22289, 22312, 22565, 22542, 4966, 4967, 4978, 4977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9466, 3150, 3151, 3162, 3161, 22290, 22313, 22566, 22543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9467, 22290, 22313, 22566, 22543, 22291, 22314, 22567, 22544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9468, 22291, 22314, 22567, 22544, 22292, 22315, 22568, 22545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9469, 22292, 22315, 22568, 22545, 22293, 22316, 22569, 22546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9470, 22293, 22316, 22569, 22546, 22294, 22317, 22570, 22547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9471, 22294, 22317, 22570, 22547, 22295, 22318, 22571, 22548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9472, 22295, 22318, 22571, 22548, 22296, 22319, 22572, 22549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9473, 22296, 22319, 22572, 22549, 22297, 22320, 22573, 22550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9474, 22297, 22320, 22573, 22550, 22298, 22321, 22574, 22551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9475, 22298, 22321, 22574, 22551, 22299, 22322, 22575, 22552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9476, 22299, 22322, 22575, 22552, 22300, 22323, 22576, 22553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9477, 22300, 22323, 22576, 22553, 22301, 22324, 22577, 22554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9478, 22301, 22324, 22577, 22554, 22302, 22325, 22578, 22555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9479, 22302, 22325, 22578, 22555, 22303, 22326, 22579, 22556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9480, 22303, 22326, 22579, 22556, 22304, 22327, 22580, 22557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9481, 22304, 22327, 22580, 22557, 22305, 22328, 22581, 22558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9482, 22305, 22328, 22581, 22558, 22306, 22329, 22582, 22559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9483, 22306, 22329, 22582, 22559, 22307, 22330, 22583, 22560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9484, 22307, 22330, 22583, 22560, 22308, 22331, 22584, 22561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9485, 22308, 22331, 22584, 22561, 22309, 22332, 22585, 22562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9486, 22309, 22332, 22585, 22562, 22310, 22333, 22586, 22563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9487, 22310, 22333, 22586, 22563, 22311, 22334, 22587, 22564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9488, 22311, 22334, 22587, 22564, 22312, 22335, 22588, 22565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9489, 22312, 22335, 22588, 22565, 4967, 4968, 4979, 4978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9490, 3151, 3152, 3163, 3162, 22313, 22336, 22589, 22566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9491, 22313, 22336, 22589, 22566, 22314, 22337, 22590, 22567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9492, 22314, 22337, 22590, 22567, 22315, 22338, 22591, 22568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9493, 22315, 22338, 22591, 22568, 22316, 22339, 22592, 22569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9494, 22316, 22339, 22592, 22569, 22317, 22340, 22593, 22570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9495, 22317, 22340, 22593, 22570, 22318, 22341, 22594, 22571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9496, 22318, 22341, 22594, 22571, 22319, 22342, 22595, 22572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9497, 22319, 22342, 22595, 22572, 22320, 22343, 22596, 22573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9498, 22320, 22343, 22596, 22573, 22321, 22344, 22597, 22574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9499, 22321, 22344, 22597, 22574, 22322, 22345, 22598, 22575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9500, 22322, 22345, 22598, 22575, 22323, 22346, 22599, 22576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9501, 22323, 22346, 22599, 22576, 22324, 22347, 22600, 22577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9502, 22324, 22347, 22600, 22577, 22325, 22348, 22601, 22578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9503, 22325, 22348, 22601, 22578, 22326, 22349, 22602, 22579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9504, 22326, 22349, 22602, 22579, 22327, 22350, 22603, 22580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9505, 22327, 22350, 22603, 22580, 22328, 22351, 22604, 22581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9506, 22328, 22351, 22604, 22581, 22329, 22352, 22605, 22582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9507, 22329, 22352, 22605, 22582, 22330, 22353, 22606, 22583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9508, 22330, 22353, 22606, 22583, 22331, 22354, 22607, 22584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9509, 22331, 22354, 22607, 22584, 22332, 22355, 22608, 22585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9510, 22332, 22355, 22608, 22585, 22333, 22356, 22609, 22586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9511, 22333, 22356, 22609, 22586, 22334, 22357, 22610, 22587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9512, 22334, 22357, 22610, 22587, 22335, 22358, 22611, 22588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9513, 22335, 22358, 22611, 22588, 4968, 4969, 4980, 4979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9514, 3152, 3153, 3164, 3163, 22336, 22359, 22612, 22589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9515, 22336, 22359, 22612, 22589, 22337, 22360, 22613, 22590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9516, 22337, 22360, 22613, 22590, 22338, 22361, 22614, 22591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9517, 22338, 22361, 22614, 22591, 22339, 22362, 22615, 22592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9518, 22339, 22362, 22615, 22592, 22340, 22363, 22616, 22593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9519, 22340, 22363, 22616, 22593, 22341, 22364, 22617, 22594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9520, 22341, 22364, 22617, 22594, 22342, 22365, 22618, 22595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9521, 22342, 22365, 22618, 22595, 22343, 22366, 22619, 22596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9522, 22343, 22366, 22619, 22596, 22344, 22367, 22620, 22597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9523, 22344, 22367, 22620, 22597, 22345, 22368, 22621, 22598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9524, 22345, 22368, 22621, 22598, 22346, 22369, 22622, 22599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9525, 22346, 22369, 22622, 22599, 22347, 22370, 22623, 22600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9526, 22347, 22370, 22623, 22600, 22348, 22371, 22624, 22601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9527, 22348, 22371, 22624, 22601, 22349, 22372, 22625, 22602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9528, 22349, 22372, 22625, 22602, 22350, 22373, 22626, 22603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9529, 22350, 22373, 22626, 22603, 22351, 22374, 22627, 22604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9530, 22351, 22374, 22627, 22604, 22352, 22375, 22628, 22605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9531, 22352, 22375, 22628, 22605, 22353, 22376, 22629, 22606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9532, 22353, 22376, 22629, 22606, 22354, 22377, 22630, 22607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9533, 22354, 22377, 22630, 22607, 22355, 22378, 22631, 22608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9534, 22355, 22378, 22631, 22608, 22356, 22379, 22632, 22609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9535, 22356, 22379, 22632, 22609, 22357, 22380, 22633, 22610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9536, 22357, 22380, 22633, 22610, 22358, 22381, 22634, 22611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9537, 22358, 22381, 22634, 22611, 4969, 4970, 4981, 4980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9538, 3153, 3154, 3165, 3164, 22359, 22382, 22635, 22612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9539, 22359, 22382, 22635, 22612, 22360, 22383, 22636, 22613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9540, 22360, 22383, 22636, 22613, 22361, 22384, 22637, 22614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9541, 22361, 22384, 22637, 22614, 22362, 22385, 22638, 22615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9542, 22362, 22385, 22638, 22615, 22363, 22386, 22639, 22616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9543, 22363, 22386, 22639, 22616, 22364, 22387, 22640, 22617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9544, 22364, 22387, 22640, 22617, 22365, 22388, 22641, 22618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9545, 22365, 22388, 22641, 22618, 22366, 22389, 22642, 22619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9546, 22366, 22389, 22642, 22619, 22367, 22390, 22643, 22620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9547, 22367, 22390, 22643, 22620, 22368, 22391, 22644, 22621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9548, 22368, 22391, 22644, 22621, 22369, 22392, 22645, 22622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9549, 22369, 22392, 22645, 22622, 22370, 22393, 22646, 22623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9550, 22370, 22393, 22646, 22623, 22371, 22394, 22647, 22624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9551, 22371, 22394, 22647, 22624, 22372, 22395, 22648, 22625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9552, 22372, 22395, 22648, 22625, 22373, 22396, 22649, 22626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9553, 22373, 22396, 22649, 22626, 22374, 22397, 22650, 22627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9554, 22374, 22397, 22650, 22627, 22375, 22398, 22651, 22628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9555, 22375, 22398, 22651, 22628, 22376, 22399, 22652, 22629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9556, 22376, 22399, 22652, 22629, 22377, 22400, 22653, 22630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9557, 22377, 22400, 22653, 22630, 22378, 22401, 22654, 22631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9558, 22378, 22401, 22654, 22631, 22379, 22402, 22655, 22632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9559, 22379, 22402, 22655, 22632, 22380, 22403, 22656, 22633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9560, 22380, 22403, 22656, 22633, 22381, 22404, 22657, 22634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9561, 22381, 22404, 22657, 22634, 4970, 4971, 4982, 4981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9562, 3154, 3155, 3166, 3165, 22382, 22405, 22658, 22635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9563, 22382, 22405, 22658, 22635, 22383, 22406, 22659, 22636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9564, 22383, 22406, 22659, 22636, 22384, 22407, 22660, 22637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9565, 22384, 22407, 22660, 22637, 22385, 22408, 22661, 22638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9566, 22385, 22408, 22661, 22638, 22386, 22409, 22662, 22639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9567, 22386, 22409, 22662, 22639, 22387, 22410, 22663, 22640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9568, 22387, 22410, 22663, 22640, 22388, 22411, 22664, 22641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9569, 22388, 22411, 22664, 22641, 22389, 22412, 22665, 22642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9570, 22389, 22412, 22665, 22642, 22390, 22413, 22666, 22643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9571, 22390, 22413, 22666, 22643, 22391, 22414, 22667, 22644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9572, 22391, 22414, 22667, 22644, 22392, 22415, 22668, 22645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9573, 22392, 22415, 22668, 22645, 22393, 22416, 22669, 22646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9574, 22393, 22416, 22669, 22646, 22394, 22417, 22670, 22647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9575, 22394, 22417, 22670, 22647, 22395, 22418, 22671, 22648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9576, 22395, 22418, 22671, 22648, 22396, 22419, 22672, 22649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9577, 22396, 22419, 22672, 22649, 22397, 22420, 22673, 22650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9578, 22397, 22420, 22673, 22650, 22398, 22421, 22674, 22651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9579, 22398, 22421, 22674, 22651, 22399, 22422, 22675, 22652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9580, 22399, 22422, 22675, 22652, 22400, 22423, 22676, 22653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9581, 22400, 22423, 22676, 22653, 22401, 22424, 22677, 22654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9582, 22401, 22424, 22677, 22654, 22402, 22425, 22678, 22655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9583, 22402, 22425, 22678, 22655, 22403, 22426, 22679, 22656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9584, 22403, 22426, 22679, 22656, 22404, 22427, 22680, 22657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9585, 22404, 22427, 22680, 22657, 4971, 4972, 4983, 4982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9586, 3155, 3156, 3167, 3166, 22405, 22428, 22681, 22658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9587, 22405, 22428, 22681, 22658, 22406, 22429, 22682, 22659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9588, 22406, 22429, 22682, 22659, 22407, 22430, 22683, 22660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9589, 22407, 22430, 22683, 22660, 22408, 22431, 22684, 22661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9590, 22408, 22431, 22684, 22661, 22409, 22432, 22685, 22662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9591, 22409, 22432, 22685, 22662, 22410, 22433, 22686, 22663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9592, 22410, 22433, 22686, 22663, 22411, 22434, 22687, 22664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9593, 22411, 22434, 22687, 22664, 22412, 22435, 22688, 22665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9594, 22412, 22435, 22688, 22665, 22413, 22436, 22689, 22666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9595, 22413, 22436, 22689, 22666, 22414, 22437, 22690, 22667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9596, 22414, 22437, 22690, 22667, 22415, 22438, 22691, 22668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9597, 22415, 22438, 22691, 22668, 22416, 22439, 22692, 22669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9598, 22416, 22439, 22692, 22669, 22417, 22440, 22693, 22670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9599, 22417, 22440, 22693, 22670, 22418, 22441, 22694, 22671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9600, 22418, 22441, 22694, 22671, 22419, 22442, 22695, 22672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9601, 22419, 22442, 22695, 22672, 22420, 22443, 22696, 22673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9602, 22420, 22443, 22696, 22673, 22421, 22444, 22697, 22674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9603, 22421, 22444, 22697, 22674, 22422, 22445, 22698, 22675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9604, 22422, 22445, 22698, 22675, 22423, 22446, 22699, 22676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9605, 22423, 22446, 22699, 22676, 22424, 22447, 22700, 22677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9606, 22424, 22447, 22700, 22677, 22425, 22448, 22701, 22678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9607, 22425, 22448, 22701, 22678, 22426, 22449, 22702, 22679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9608, 22426, 22449, 22702, 22679, 22427, 22450, 22703, 22680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9609, 22427, 22450, 22703, 22680, 4972, 4973, 4984, 4983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9610, 3156, 3157, 3168, 3167, 22428, 22451, 22704, 22681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9611, 22428, 22451, 22704, 22681, 22429, 22452, 22705, 22682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9612, 22429, 22452, 22705, 22682, 22430, 22453, 22706, 22683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9613, 22430, 22453, 22706, 22683, 22431, 22454, 22707, 22684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9614, 22431, 22454, 22707, 22684, 22432, 22455, 22708, 22685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9615, 22432, 22455, 22708, 22685, 22433, 22456, 22709, 22686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9616, 22433, 22456, 22709, 22686, 22434, 22457, 22710, 22687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9617, 22434, 22457, 22710, 22687, 22435, 22458, 22711, 22688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9618, 22435, 22458, 22711, 22688, 22436, 22459, 22712, 22689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9619, 22436, 22459, 22712, 22689, 22437, 22460, 22713, 22690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9620, 22437, 22460, 22713, 22690, 22438, 22461, 22714, 22691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9621, 22438, 22461, 22714, 22691, 22439, 22462, 22715, 22692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9622, 22439, 22462, 22715, 22692, 22440, 22463, 22716, 22693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9623, 22440, 22463, 22716, 22693, 22441, 22464, 22717, 22694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9624, 22441, 22464, 22717, 22694, 22442, 22465, 22718, 22695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9625, 22442, 22465, 22718, 22695, 22443, 22466, 22719, 22696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9626, 22443, 22466, 22719, 22696, 22444, 22467, 22720, 22697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9627, 22444, 22467, 22720, 22697, 22445, 22468, 22721, 22698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9628, 22445, 22468, 22721, 22698, 22446, 22469, 22722, 22699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9629, 22446, 22469, 22722, 22699, 22447, 22470, 22723, 22700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9630, 22447, 22470, 22723, 22700, 22448, 22471, 22724, 22701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9631, 22448, 22471, 22724, 22701, 22449, 22472, 22725, 22702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9632, 22449, 22472, 22725, 22702, 22450, 22473, 22726, 22703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9633, 22450, 22473, 22726, 22703, 4973, 4974, 4985, 4984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9634, 3157, 3158, 3169, 3168, 22451, 22474, 22727, 22704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9635, 22451, 22474, 22727, 22704, 22452, 22475, 22728, 22705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9636, 22452, 22475, 22728, 22705, 22453, 22476, 22729, 22706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9637, 22453, 22476, 22729, 22706, 22454, 22477, 22730, 22707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9638, 22454, 22477, 22730, 22707, 22455, 22478, 22731, 22708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9639, 22455, 22478, 22731, 22708, 22456, 22479, 22732, 22709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9640, 22456, 22479, 22732, 22709, 22457, 22480, 22733, 22710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9641, 22457, 22480, 22733, 22710, 22458, 22481, 22734, 22711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9642, 22458, 22481, 22734, 22711, 22459, 22482, 22735, 22712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9643, 22459, 22482, 22735, 22712, 22460, 22483, 22736, 22713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9644, 22460, 22483, 22736, 22713, 22461, 22484, 22737, 22714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9645, 22461, 22484, 22737, 22714, 22462, 22485, 22738, 22715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9646, 22462, 22485, 22738, 22715, 22463, 22486, 22739, 22716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9647, 22463, 22486, 22739, 22716, 22464, 22487, 22740, 22717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9648, 22464, 22487, 22740, 22717, 22465, 22488, 22741, 22718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9649, 22465, 22488, 22741, 22718, 22466, 22489, 22742, 22719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9650, 22466, 22489, 22742, 22719, 22467, 22490, 22743, 22720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9651, 22467, 22490, 22743, 22720, 22468, 22491, 22744, 22721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9652, 22468, 22491, 22744, 22721, 22469, 22492, 22745, 22722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9653, 22469, 22492, 22745, 22722, 22470, 22493, 22746, 22723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9654, 22470, 22493, 22746, 22723, 22471, 22494, 22747, 22724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9655, 22471, 22494, 22747, 22724, 22472, 22495, 22748, 22725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9656, 22472, 22495, 22748, 22725, 22473, 22496, 22749, 22726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9657, 22473, 22496, 22749, 22726, 4974, 4975, 4986, 4985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9658, 3158, 3159, 3170, 3169, 22474, 22497, 22750, 22727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9659, 22474, 22497, 22750, 22727, 22475, 22498, 22751, 22728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9660, 22475, 22498, 22751, 22728, 22476, 22499, 22752, 22729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9661, 22476, 22499, 22752, 22729, 22477, 22500, 22753, 22730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9662, 22477, 22500, 22753, 22730, 22478, 22501, 22754, 22731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9663, 22478, 22501, 22754, 22731, 22479, 22502, 22755, 22732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9664, 22479, 22502, 22755, 22732, 22480, 22503, 22756, 22733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9665, 22480, 22503, 22756, 22733, 22481, 22504, 22757, 22734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9666, 22481, 22504, 22757, 22734, 22482, 22505, 22758, 22735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9667, 22482, 22505, 22758, 22735, 22483, 22506, 22759, 22736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9668, 22483, 22506, 22759, 22736, 22484, 22507, 22760, 22737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9669, 22484, 22507, 22760, 22737, 22485, 22508, 22761, 22738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9670, 22485, 22508, 22761, 22738, 22486, 22509, 22762, 22739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9671, 22486, 22509, 22762, 22739, 22487, 22510, 22763, 22740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9672, 22487, 22510, 22763, 22740, 22488, 22511, 22764, 22741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9673, 22488, 22511, 22764, 22741, 22489, 22512, 22765, 22742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9674, 22489, 22512, 22765, 22742, 22490, 22513, 22766, 22743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9675, 22490, 22513, 22766, 22743, 22491, 22514, 22767, 22744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9676, 22491, 22514, 22767, 22744, 22492, 22515, 22768, 22745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9677, 22492, 22515, 22768, 22745, 22493, 22516, 22769, 22746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9678, 22493, 22516, 22769, 22746, 22494, 22517, 22770, 22747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9679, 22494, 22517, 22770, 22747, 22495, 22518, 22771, 22748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9680, 22495, 22518, 22771, 22748, 22496, 22519, 22772, 22749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9681, 22496, 22519, 22772, 22749, 4975, 4976, 4987, 4986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9682, 3159, 285, 286, 3170, 22497, 4292, 4315, 22750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9683, 22497, 4292, 4315, 22750, 22498, 4293, 4316, 22751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9684, 22498, 4293, 4316, 22751, 22499, 4294, 4317, 22752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9685, 22499, 4294, 4317, 22752, 22500, 4295, 4318, 22753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9686, 22500, 4295, 4318, 22753, 22501, 4296, 4319, 22754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9687, 22501, 4296, 4319, 22754, 22502, 4297, 4320, 22755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9688, 22502, 4297, 4320, 22755, 22503, 4298, 4321, 22756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9689, 22503, 4298, 4321, 22756, 22504, 4299, 4322, 22757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9690, 22504, 4299, 4322, 22757, 22505, 4300, 4323, 22758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9691, 22505, 4300, 4323, 22758, 22506, 4301, 4324, 22759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9692, 22506, 4301, 4324, 22759, 22507, 4302, 4325, 22760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9693, 22507, 4302, 4325, 22760, 22508, 4303, 4326, 22761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9694, 22508, 4303, 4326, 22761, 22509, 4304, 4327, 22762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9695, 22509, 4304, 4327, 22762, 22510, 4305, 4328, 22763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9696, 22510, 4305, 4328, 22763, 22511, 4306, 4329, 22764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9697, 22511, 4306, 4329, 22764, 22512, 4307, 4330, 22765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9698, 22512, 4307, 4330, 22765, 22513, 4308, 4331, 22766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9699, 22513, 4308, 4331, 22766, 22514, 4309, 4332, 22767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9700, 22514, 4309, 4332, 22767, 22515, 4310, 4333, 22768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9701, 22515, 4310, 4333, 22768, 22516, 4311, 4334, 22769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9702, 22516, 4311, 4334, 22769, 22517, 4312, 4335, 22770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9703, 22517, 4312, 4335, 22770, 22518, 4313, 4336, 22771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9704, 22518, 4313, 4336, 22771, 22519, 4314, 4337, 22772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9705, 22519, 4314, 4337, 22772, 4976, 445, 446, 4987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9706, 252, 3160, 3171, 253, 3533, 22520, 22773, 3556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9707, 3533, 22520, 22773, 3556, 3534, 22521, 22774, 3557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9708, 3534, 22521, 22774, 3557, 3535, 22522, 22775, 3558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9709, 3535, 22522, 22775, 3558, 3536, 22523, 22776, 3559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9710, 3536, 22523, 22776, 3559, 3537, 22524, 22777, 3560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9711, 3537, 22524, 22777, 3560, 3538, 22525, 22778, 3561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9712, 3538, 22525, 22778, 3561, 3539, 22526, 22779, 3562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9713, 3539, 22526, 22779, 3562, 3540, 22527, 22780, 3563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9714, 3540, 22527, 22780, 3563, 3541, 22528, 22781, 3564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9715, 3541, 22528, 22781, 3564, 3542, 22529, 22782, 3565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9716, 3542, 22529, 22782, 3565, 3543, 22530, 22783, 3566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9717, 3543, 22530, 22783, 3566, 3544, 22531, 22784, 3567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9718, 3544, 22531, 22784, 3567, 3545, 22532, 22785, 3568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9719, 3545, 22532, 22785, 3568, 3546, 22533, 22786, 3569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9720, 3546, 22533, 22786, 3569, 3547, 22534, 22787, 3570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9721, 3547, 22534, 22787, 3570, 3548, 22535, 22788, 3571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9722, 3548, 22535, 22788, 3571, 3549, 22536, 22789, 3572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9723, 3549, 22536, 22789, 3572, 3550, 22537, 22790, 3573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9724, 3550, 22537, 22790, 3573, 3551, 22538, 22791, 3574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9725, 3551, 22538, 22791, 3574, 3552, 22539, 22792, 3575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9726, 3552, 22539, 22792, 3575, 3553, 22540, 22793, 3576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9727, 3553, 22540, 22793, 3576, 3554, 22541, 22794, 3577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9728, 3554, 22541, 22794, 3577, 3555, 22542, 22795, 3578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9729, 3555, 22542, 22795, 3578, 366, 4977, 4988, 367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9730, 3160, 3161, 3172, 3171, 22520, 22543, 22796, 22773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9731, 22520, 22543, 22796, 22773, 22521, 22544, 22797, 22774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9732, 22521, 22544, 22797, 22774, 22522, 22545, 22798, 22775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9733, 22522, 22545, 22798, 22775, 22523, 22546, 22799, 22776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9734, 22523, 22546, 22799, 22776, 22524, 22547, 22800, 22777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9735, 22524, 22547, 22800, 22777, 22525, 22548, 22801, 22778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9736, 22525, 22548, 22801, 22778, 22526, 22549, 22802, 22779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9737, 22526, 22549, 22802, 22779, 22527, 22550, 22803, 22780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9738, 22527, 22550, 22803, 22780, 22528, 22551, 22804, 22781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9739, 22528, 22551, 22804, 22781, 22529, 22552, 22805, 22782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9740, 22529, 22552, 22805, 22782, 22530, 22553, 22806, 22783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9741, 22530, 22553, 22806, 22783, 22531, 22554, 22807, 22784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9742, 22531, 22554, 22807, 22784, 22532, 22555, 22808, 22785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9743, 22532, 22555, 22808, 22785, 22533, 22556, 22809, 22786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9744, 22533, 22556, 22809, 22786, 22534, 22557, 22810, 22787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9745, 22534, 22557, 22810, 22787, 22535, 22558, 22811, 22788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9746, 22535, 22558, 22811, 22788, 22536, 22559, 22812, 22789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9747, 22536, 22559, 22812, 22789, 22537, 22560, 22813, 22790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9748, 22537, 22560, 22813, 22790, 22538, 22561, 22814, 22791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9749, 22538, 22561, 22814, 22791, 22539, 22562, 22815, 22792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9750, 22539, 22562, 22815, 22792, 22540, 22563, 22816, 22793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9751, 22540, 22563, 22816, 22793, 22541, 22564, 22817, 22794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9752, 22541, 22564, 22817, 22794, 22542, 22565, 22818, 22795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9753, 22542, 22565, 22818, 22795, 4977, 4978, 4989, 4988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9754, 3161, 3162, 3173, 3172, 22543, 22566, 22819, 22796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9755, 22543, 22566, 22819, 22796, 22544, 22567, 22820, 22797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9756, 22544, 22567, 22820, 22797, 22545, 22568, 22821, 22798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9757, 22545, 22568, 22821, 22798, 22546, 22569, 22822, 22799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9758, 22546, 22569, 22822, 22799, 22547, 22570, 22823, 22800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9759, 22547, 22570, 22823, 22800, 22548, 22571, 22824, 22801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9760, 22548, 22571, 22824, 22801, 22549, 22572, 22825, 22802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9761, 22549, 22572, 22825, 22802, 22550, 22573, 22826, 22803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9762, 22550, 22573, 22826, 22803, 22551, 22574, 22827, 22804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9763, 22551, 22574, 22827, 22804, 22552, 22575, 22828, 22805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9764, 22552, 22575, 22828, 22805, 22553, 22576, 22829, 22806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9765, 22553, 22576, 22829, 22806, 22554, 22577, 22830, 22807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9766, 22554, 22577, 22830, 22807, 22555, 22578, 22831, 22808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9767, 22555, 22578, 22831, 22808, 22556, 22579, 22832, 22809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9768, 22556, 22579, 22832, 22809, 22557, 22580, 22833, 22810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9769, 22557, 22580, 22833, 22810, 22558, 22581, 22834, 22811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9770, 22558, 22581, 22834, 22811, 22559, 22582, 22835, 22812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9771, 22559, 22582, 22835, 22812, 22560, 22583, 22836, 22813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9772, 22560, 22583, 22836, 22813, 22561, 22584, 22837, 22814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9773, 22561, 22584, 22837, 22814, 22562, 22585, 22838, 22815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9774, 22562, 22585, 22838, 22815, 22563, 22586, 22839, 22816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9775, 22563, 22586, 22839, 22816, 22564, 22587, 22840, 22817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9776, 22564, 22587, 22840, 22817, 22565, 22588, 22841, 22818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9777, 22565, 22588, 22841, 22818, 4978, 4979, 4990, 4989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9778, 3162, 3163, 3174, 3173, 22566, 22589, 22842, 22819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9779, 22566, 22589, 22842, 22819, 22567, 22590, 22843, 22820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9780, 22567, 22590, 22843, 22820, 22568, 22591, 22844, 22821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9781, 22568, 22591, 22844, 22821, 22569, 22592, 22845, 22822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9782, 22569, 22592, 22845, 22822, 22570, 22593, 22846, 22823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9783, 22570, 22593, 22846, 22823, 22571, 22594, 22847, 22824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9784, 22571, 22594, 22847, 22824, 22572, 22595, 22848, 22825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9785, 22572, 22595, 22848, 22825, 22573, 22596, 22849, 22826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9786, 22573, 22596, 22849, 22826, 22574, 22597, 22850, 22827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9787, 22574, 22597, 22850, 22827, 22575, 22598, 22851, 22828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9788, 22575, 22598, 22851, 22828, 22576, 22599, 22852, 22829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9789, 22576, 22599, 22852, 22829, 22577, 22600, 22853, 22830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9790, 22577, 22600, 22853, 22830, 22578, 22601, 22854, 22831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9791, 22578, 22601, 22854, 22831, 22579, 22602, 22855, 22832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9792, 22579, 22602, 22855, 22832, 22580, 22603, 22856, 22833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9793, 22580, 22603, 22856, 22833, 22581, 22604, 22857, 22834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9794, 22581, 22604, 22857, 22834, 22582, 22605, 22858, 22835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9795, 22582, 22605, 22858, 22835, 22583, 22606, 22859, 22836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9796, 22583, 22606, 22859, 22836, 22584, 22607, 22860, 22837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9797, 22584, 22607, 22860, 22837, 22585, 22608, 22861, 22838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9798, 22585, 22608, 22861, 22838, 22586, 22609, 22862, 22839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9799, 22586, 22609, 22862, 22839, 22587, 22610, 22863, 22840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9800, 22587, 22610, 22863, 22840, 22588, 22611, 22864, 22841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9801, 22588, 22611, 22864, 22841, 4979, 4980, 4991, 4990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9802, 3163, 3164, 3175, 3174, 22589, 22612, 22865, 22842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9803, 22589, 22612, 22865, 22842, 22590, 22613, 22866, 22843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9804, 22590, 22613, 22866, 22843, 22591, 22614, 22867, 22844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9805, 22591, 22614, 22867, 22844, 22592, 22615, 22868, 22845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9806, 22592, 22615, 22868, 22845, 22593, 22616, 22869, 22846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9807, 22593, 22616, 22869, 22846, 22594, 22617, 22870, 22847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9808, 22594, 22617, 22870, 22847, 22595, 22618, 22871, 22848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9809, 22595, 22618, 22871, 22848, 22596, 22619, 22872, 22849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9810, 22596, 22619, 22872, 22849, 22597, 22620, 22873, 22850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9811, 22597, 22620, 22873, 22850, 22598, 22621, 22874, 22851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9812, 22598, 22621, 22874, 22851, 22599, 22622, 22875, 22852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9813, 22599, 22622, 22875, 22852, 22600, 22623, 22876, 22853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9814, 22600, 22623, 22876, 22853, 22601, 22624, 22877, 22854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9815, 22601, 22624, 22877, 22854, 22602, 22625, 22878, 22855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9816, 22602, 22625, 22878, 22855, 22603, 22626, 22879, 22856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9817, 22603, 22626, 22879, 22856, 22604, 22627, 22880, 22857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9818, 22604, 22627, 22880, 22857, 22605, 22628, 22881, 22858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9819, 22605, 22628, 22881, 22858, 22606, 22629, 22882, 22859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9820, 22606, 22629, 22882, 22859, 22607, 22630, 22883, 22860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9821, 22607, 22630, 22883, 22860, 22608, 22631, 22884, 22861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9822, 22608, 22631, 22884, 22861, 22609, 22632, 22885, 22862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9823, 22609, 22632, 22885, 22862, 22610, 22633, 22886, 22863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9824, 22610, 22633, 22886, 22863, 22611, 22634, 22887, 22864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9825, 22611, 22634, 22887, 22864, 4980, 4981, 4992, 4991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9826, 3164, 3165, 3176, 3175, 22612, 22635, 22888, 22865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9827, 22612, 22635, 22888, 22865, 22613, 22636, 22889, 22866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9828, 22613, 22636, 22889, 22866, 22614, 22637, 22890, 22867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9829, 22614, 22637, 22890, 22867, 22615, 22638, 22891, 22868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9830, 22615, 22638, 22891, 22868, 22616, 22639, 22892, 22869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9831, 22616, 22639, 22892, 22869, 22617, 22640, 22893, 22870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9832, 22617, 22640, 22893, 22870, 22618, 22641, 22894, 22871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9833, 22618, 22641, 22894, 22871, 22619, 22642, 22895, 22872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9834, 22619, 22642, 22895, 22872, 22620, 22643, 22896, 22873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9835, 22620, 22643, 22896, 22873, 22621, 22644, 22897, 22874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9836, 22621, 22644, 22897, 22874, 22622, 22645, 22898, 22875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9837, 22622, 22645, 22898, 22875, 22623, 22646, 22899, 22876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9838, 22623, 22646, 22899, 22876, 22624, 22647, 22900, 22877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9839, 22624, 22647, 22900, 22877, 22625, 22648, 22901, 22878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9840, 22625, 22648, 22901, 22878, 22626, 22649, 22902, 22879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9841, 22626, 22649, 22902, 22879, 22627, 22650, 22903, 22880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9842, 22627, 22650, 22903, 22880, 22628, 22651, 22904, 22881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9843, 22628, 22651, 22904, 22881, 22629, 22652, 22905, 22882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9844, 22629, 22652, 22905, 22882, 22630, 22653, 22906, 22883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9845, 22630, 22653, 22906, 22883, 22631, 22654, 22907, 22884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9846, 22631, 22654, 22907, 22884, 22632, 22655, 22908, 22885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9847, 22632, 22655, 22908, 22885, 22633, 22656, 22909, 22886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9848, 22633, 22656, 22909, 22886, 22634, 22657, 22910, 22887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9849, 22634, 22657, 22910, 22887, 4981, 4982, 4993, 4992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9850, 3165, 3166, 3177, 3176, 22635, 22658, 22911, 22888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9851, 22635, 22658, 22911, 22888, 22636, 22659, 22912, 22889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9852, 22636, 22659, 22912, 22889, 22637, 22660, 22913, 22890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9853, 22637, 22660, 22913, 22890, 22638, 22661, 22914, 22891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9854, 22638, 22661, 22914, 22891, 22639, 22662, 22915, 22892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9855, 22639, 22662, 22915, 22892, 22640, 22663, 22916, 22893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9856, 22640, 22663, 22916, 22893, 22641, 22664, 22917, 22894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9857, 22641, 22664, 22917, 22894, 22642, 22665, 22918, 22895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9858, 22642, 22665, 22918, 22895, 22643, 22666, 22919, 22896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9859, 22643, 22666, 22919, 22896, 22644, 22667, 22920, 22897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9860, 22644, 22667, 22920, 22897, 22645, 22668, 22921, 22898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9861, 22645, 22668, 22921, 22898, 22646, 22669, 22922, 22899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9862, 22646, 22669, 22922, 22899, 22647, 22670, 22923, 22900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9863, 22647, 22670, 22923, 22900, 22648, 22671, 22924, 22901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9864, 22648, 22671, 22924, 22901, 22649, 22672, 22925, 22902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9865, 22649, 22672, 22925, 22902, 22650, 22673, 22926, 22903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9866, 22650, 22673, 22926, 22903, 22651, 22674, 22927, 22904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9867, 22651, 22674, 22927, 22904, 22652, 22675, 22928, 22905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9868, 22652, 22675, 22928, 22905, 22653, 22676, 22929, 22906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9869, 22653, 22676, 22929, 22906, 22654, 22677, 22930, 22907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9870, 22654, 22677, 22930, 22907, 22655, 22678, 22931, 22908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9871, 22655, 22678, 22931, 22908, 22656, 22679, 22932, 22909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9872, 22656, 22679, 22932, 22909, 22657, 22680, 22933, 22910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9873, 22657, 22680, 22933, 22910, 4982, 4983, 4994, 4993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9874, 3166, 3167, 3178, 3177, 22658, 22681, 22934, 22911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9875, 22658, 22681, 22934, 22911, 22659, 22682, 22935, 22912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9876, 22659, 22682, 22935, 22912, 22660, 22683, 22936, 22913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9877, 22660, 22683, 22936, 22913, 22661, 22684, 22937, 22914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9878, 22661, 22684, 22937, 22914, 22662, 22685, 22938, 22915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9879, 22662, 22685, 22938, 22915, 22663, 22686, 22939, 22916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9880, 22663, 22686, 22939, 22916, 22664, 22687, 22940, 22917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9881, 22664, 22687, 22940, 22917, 22665, 22688, 22941, 22918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9882, 22665, 22688, 22941, 22918, 22666, 22689, 22942, 22919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9883, 22666, 22689, 22942, 22919, 22667, 22690, 22943, 22920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9884, 22667, 22690, 22943, 22920, 22668, 22691, 22944, 22921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9885, 22668, 22691, 22944, 22921, 22669, 22692, 22945, 22922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9886, 22669, 22692, 22945, 22922, 22670, 22693, 22946, 22923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9887, 22670, 22693, 22946, 22923, 22671, 22694, 22947, 22924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9888, 22671, 22694, 22947, 22924, 22672, 22695, 22948, 22925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9889, 22672, 22695, 22948, 22925, 22673, 22696, 22949, 22926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9890, 22673, 22696, 22949, 22926, 22674, 22697, 22950, 22927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9891, 22674, 22697, 22950, 22927, 22675, 22698, 22951, 22928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9892, 22675, 22698, 22951, 22928, 22676, 22699, 22952, 22929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9893, 22676, 22699, 22952, 22929, 22677, 22700, 22953, 22930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9894, 22677, 22700, 22953, 22930, 22678, 22701, 22954, 22931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9895, 22678, 22701, 22954, 22931, 22679, 22702, 22955, 22932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9896, 22679, 22702, 22955, 22932, 22680, 22703, 22956, 22933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9897, 22680, 22703, 22956, 22933, 4983, 4984, 4995, 4994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9898, 3167, 3168, 3179, 3178, 22681, 22704, 22957, 22934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9899, 22681, 22704, 22957, 22934, 22682, 22705, 22958, 22935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9900, 22682, 22705, 22958, 22935, 22683, 22706, 22959, 22936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9901, 22683, 22706, 22959, 22936, 22684, 22707, 22960, 22937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9902, 22684, 22707, 22960, 22937, 22685, 22708, 22961, 22938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9903, 22685, 22708, 22961, 22938, 22686, 22709, 22962, 22939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9904, 22686, 22709, 22962, 22939, 22687, 22710, 22963, 22940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9905, 22687, 22710, 22963, 22940, 22688, 22711, 22964, 22941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9906, 22688, 22711, 22964, 22941, 22689, 22712, 22965, 22942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9907, 22689, 22712, 22965, 22942, 22690, 22713, 22966, 22943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9908, 22690, 22713, 22966, 22943, 22691, 22714, 22967, 22944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9909, 22691, 22714, 22967, 22944, 22692, 22715, 22968, 22945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9910, 22692, 22715, 22968, 22945, 22693, 22716, 22969, 22946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9911, 22693, 22716, 22969, 22946, 22694, 22717, 22970, 22947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9912, 22694, 22717, 22970, 22947, 22695, 22718, 22971, 22948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9913, 22695, 22718, 22971, 22948, 22696, 22719, 22972, 22949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9914, 22696, 22719, 22972, 22949, 22697, 22720, 22973, 22950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9915, 22697, 22720, 22973, 22950, 22698, 22721, 22974, 22951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9916, 22698, 22721, 22974, 22951, 22699, 22722, 22975, 22952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9917, 22699, 22722, 22975, 22952, 22700, 22723, 22976, 22953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9918, 22700, 22723, 22976, 22953, 22701, 22724, 22977, 22954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9919, 22701, 22724, 22977, 22954, 22702, 22725, 22978, 22955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9920, 22702, 22725, 22978, 22955, 22703, 22726, 22979, 22956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9921, 22703, 22726, 22979, 22956, 4984, 4985, 4996, 4995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9922, 3168, 3169, 3180, 3179, 22704, 22727, 22980, 22957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9923, 22704, 22727, 22980, 22957, 22705, 22728, 22981, 22958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9924, 22705, 22728, 22981, 22958, 22706, 22729, 22982, 22959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9925, 22706, 22729, 22982, 22959, 22707, 22730, 22983, 22960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9926, 22707, 22730, 22983, 22960, 22708, 22731, 22984, 22961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9927, 22708, 22731, 22984, 22961, 22709, 22732, 22985, 22962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9928, 22709, 22732, 22985, 22962, 22710, 22733, 22986, 22963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9929, 22710, 22733, 22986, 22963, 22711, 22734, 22987, 22964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9930, 22711, 22734, 22987, 22964, 22712, 22735, 22988, 22965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9931, 22712, 22735, 22988, 22965, 22713, 22736, 22989, 22966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9932, 22713, 22736, 22989, 22966, 22714, 22737, 22990, 22967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9933, 22714, 22737, 22990, 22967, 22715, 22738, 22991, 22968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9934, 22715, 22738, 22991, 22968, 22716, 22739, 22992, 22969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9935, 22716, 22739, 22992, 22969, 22717, 22740, 22993, 22970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9936, 22717, 22740, 22993, 22970, 22718, 22741, 22994, 22971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9937, 22718, 22741, 22994, 22971, 22719, 22742, 22995, 22972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9938, 22719, 22742, 22995, 22972, 22720, 22743, 22996, 22973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9939, 22720, 22743, 22996, 22973, 22721, 22744, 22997, 22974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9940, 22721, 22744, 22997, 22974, 22722, 22745, 22998, 22975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9941, 22722, 22745, 22998, 22975, 22723, 22746, 22999, 22976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9942, 22723, 22746, 22999, 22976, 22724, 22747, 23000, 22977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9943, 22724, 22747, 23000, 22977, 22725, 22748, 23001, 22978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9944, 22725, 22748, 23001, 22978, 22726, 22749, 23002, 22979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9945, 22726, 22749, 23002, 22979, 4985, 4986, 4997, 4996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9946, 3169, 3170, 3181, 3180, 22727, 22750, 23003, 22980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9947, 22727, 22750, 23003, 22980, 22728, 22751, 23004, 22981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9948, 22728, 22751, 23004, 22981, 22729, 22752, 23005, 22982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9949, 22729, 22752, 23005, 22982, 22730, 22753, 23006, 22983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9950, 22730, 22753, 23006, 22983, 22731, 22754, 23007, 22984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9951, 22731, 22754, 23007, 22984, 22732, 22755, 23008, 22985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9952, 22732, 22755, 23008, 22985, 22733, 22756, 23009, 22986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9953, 22733, 22756, 23009, 22986, 22734, 22757, 23010, 22987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9954, 22734, 22757, 23010, 22987, 22735, 22758, 23011, 22988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9955, 22735, 22758, 23011, 22988, 22736, 22759, 23012, 22989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9956, 22736, 22759, 23012, 22989, 22737, 22760, 23013, 22990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9957, 22737, 22760, 23013, 22990, 22738, 22761, 23014, 22991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9958, 22738, 22761, 23014, 22991, 22739, 22762, 23015, 22992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9959, 22739, 22762, 23015, 22992, 22740, 22763, 23016, 22993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9960, 22740, 22763, 23016, 22993, 22741, 22764, 23017, 22994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9961, 22741, 22764, 23017, 22994, 22742, 22765, 23018, 22995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9962, 22742, 22765, 23018, 22995, 22743, 22766, 23019, 22996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9963, 22743, 22766, 23019, 22996, 22744, 22767, 23020, 22997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9964, 22744, 22767, 23020, 22997, 22745, 22768, 23021, 22998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9965, 22745, 22768, 23021, 22998, 22746, 22769, 23022, 22999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9966, 22746, 22769, 23022, 22999, 22747, 22770, 23023, 23000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9967, 22747, 22770, 23023, 23000, 22748, 22771, 23024, 23001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9968, 22748, 22771, 23024, 23001, 22749, 22772, 23025, 23002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9969, 22749, 22772, 23025, 23002, 4986, 4987, 4998, 4997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9970, 3170, 286, 287, 3181, 22750, 4315, 4338, 23003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9971, 22750, 4315, 4338, 23003, 22751, 4316, 4339, 23004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9972, 22751, 4316, 4339, 23004, 22752, 4317, 4340, 23005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9973, 22752, 4317, 4340, 23005, 22753, 4318, 4341, 23006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9974, 22753, 4318, 4341, 23006, 22754, 4319, 4342, 23007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9975, 22754, 4319, 4342, 23007, 22755, 4320, 4343, 23008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9976, 22755, 4320, 4343, 23008, 22756, 4321, 4344, 23009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9977, 22756, 4321, 4344, 23009, 22757, 4322, 4345, 23010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9978, 22757, 4322, 4345, 23010, 22758, 4323, 4346, 23011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9979, 22758, 4323, 4346, 23011, 22759, 4324, 4347, 23012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9980, 22759, 4324, 4347, 23012, 22760, 4325, 4348, 23013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9981, 22760, 4325, 4348, 23013, 22761, 4326, 4349, 23014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9982, 22761, 4326, 4349, 23014, 22762, 4327, 4350, 23015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9983, 22762, 4327, 4350, 23015, 22763, 4328, 4351, 23016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9984, 22763, 4328, 4351, 23016, 22764, 4329, 4352, 23017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9985, 22764, 4329, 4352, 23017, 22765, 4330, 4353, 23018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9986, 22765, 4330, 4353, 23018, 22766, 4331, 4354, 23019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9987, 22766, 4331, 4354, 23019, 22767, 4332, 4355, 23020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9988, 22767, 4332, 4355, 23020, 22768, 4333, 4356, 23021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9989, 22768, 4333, 4356, 23021, 22769, 4334, 4357, 23022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9990, 22769, 4334, 4357, 23022, 22770, 4335, 4358, 23023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9991, 22770, 4335, 4358, 23023, 22771, 4336, 4359, 23024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9992, 22771, 4336, 4359, 23024, 22772, 4337, 4360, 23025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9993, 22772, 4337, 4360, 23025, 4987, 446, 447, 4998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9994, 253, 3171, 3182, 254, 3556, 22773, 23026, 3579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9995, 3556, 22773, 23026, 3579, 3557, 22774, 23027, 3580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9996, 3557, 22774, 23027, 3580, 3558, 22775, 23028, 3581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9997, 3558, 22775, 23028, 3581, 3559, 22776, 23029, 3582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9998, 3559, 22776, 23029, 3582, 3560, 22777, 23030, 3583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
9999, 3560, 22777, 23030, 3583, 3561, 22778, 23031, 3584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10000, 3561, 22778, 23031, 3584, 3562, 22779, 23032, 3585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10001, 3562, 22779, 23032, 3585, 3563, 22780, 23033, 3586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10002, 3563, 22780, 23033, 3586, 3564, 22781, 23034, 3587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10003, 3564, 22781, 23034, 3587, 3565, 22782, 23035, 3588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10004, 3565, 22782, 23035, 3588, 3566, 22783, 23036, 3589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10005, 3566, 22783, 23036, 3589, 3567, 22784, 23037, 3590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10006, 3567, 22784, 23037, 3590, 3568, 22785, 23038, 3591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10007, 3568, 22785, 23038, 3591, 3569, 22786, 23039, 3592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10008, 3569, 22786, 23039, 3592, 3570, 22787, 23040, 3593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10009, 3570, 22787, 23040, 3593, 3571, 22788, 23041, 3594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10010, 3571, 22788, 23041, 3594, 3572, 22789, 23042, 3595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10011, 3572, 22789, 23042, 3595, 3573, 22790, 23043, 3596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10012, 3573, 22790, 23043, 3596, 3574, 22791, 23044, 3597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10013, 3574, 22791, 23044, 3597, 3575, 22792, 23045, 3598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10014, 3575, 22792, 23045, 3598, 3576, 22793, 23046, 3599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10015, 3576, 22793, 23046, 3599, 3577, 22794, 23047, 3600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10016, 3577, 22794, 23047, 3600, 3578, 22795, 23048, 3601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10017, 3578, 22795, 23048, 3601, 367, 4988, 4999, 368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10018, 3171, 3172, 3183, 3182, 22773, 22796, 23049, 23026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10019, 22773, 22796, 23049, 23026, 22774, 22797, 23050, 23027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10020, 22774, 22797, 23050, 23027, 22775, 22798, 23051, 23028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10021, 22775, 22798, 23051, 23028, 22776, 22799, 23052, 23029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10022, 22776, 22799, 23052, 23029, 22777, 22800, 23053, 23030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10023, 22777, 22800, 23053, 23030, 22778, 22801, 23054, 23031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10024, 22778, 22801, 23054, 23031, 22779, 22802, 23055, 23032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10025, 22779, 22802, 23055, 23032, 22780, 22803, 23056, 23033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10026, 22780, 22803, 23056, 23033, 22781, 22804, 23057, 23034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10027, 22781, 22804, 23057, 23034, 22782, 22805, 23058, 23035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10028, 22782, 22805, 23058, 23035, 22783, 22806, 23059, 23036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10029, 22783, 22806, 23059, 23036, 22784, 22807, 23060, 23037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10030, 22784, 22807, 23060, 23037, 22785, 22808, 23061, 23038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10031, 22785, 22808, 23061, 23038, 22786, 22809, 23062, 23039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10032, 22786, 22809, 23062, 23039, 22787, 22810, 23063, 23040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10033, 22787, 22810, 23063, 23040, 22788, 22811, 23064, 23041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10034, 22788, 22811, 23064, 23041, 22789, 22812, 23065, 23042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10035, 22789, 22812, 23065, 23042, 22790, 22813, 23066, 23043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10036, 22790, 22813, 23066, 23043, 22791, 22814, 23067, 23044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10037, 22791, 22814, 23067, 23044, 22792, 22815, 23068, 23045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10038, 22792, 22815, 23068, 23045, 22793, 22816, 23069, 23046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10039, 22793, 22816, 23069, 23046, 22794, 22817, 23070, 23047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10040, 22794, 22817, 23070, 23047, 22795, 22818, 23071, 23048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10041, 22795, 22818, 23071, 23048, 4988, 4989, 5000, 4999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10042, 3172, 3173, 3184, 3183, 22796, 22819, 23072, 23049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10043, 22796, 22819, 23072, 23049, 22797, 22820, 23073, 23050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10044, 22797, 22820, 23073, 23050, 22798, 22821, 23074, 23051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10045, 22798, 22821, 23074, 23051, 22799, 22822, 23075, 23052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10046, 22799, 22822, 23075, 23052, 22800, 22823, 23076, 23053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10047, 22800, 22823, 23076, 23053, 22801, 22824, 23077, 23054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10048, 22801, 22824, 23077, 23054, 22802, 22825, 23078, 23055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10049, 22802, 22825, 23078, 23055, 22803, 22826, 23079, 23056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10050, 22803, 22826, 23079, 23056, 22804, 22827, 23080, 23057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10051, 22804, 22827, 23080, 23057, 22805, 22828, 23081, 23058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10052, 22805, 22828, 23081, 23058, 22806, 22829, 23082, 23059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10053, 22806, 22829, 23082, 23059, 22807, 22830, 23083, 23060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10054, 22807, 22830, 23083, 23060, 22808, 22831, 23084, 23061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10055, 22808, 22831, 23084, 23061, 22809, 22832, 23085, 23062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10056, 22809, 22832, 23085, 23062, 22810, 22833, 23086, 23063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10057, 22810, 22833, 23086, 23063, 22811, 22834, 23087, 23064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10058, 22811, 22834, 23087, 23064, 22812, 22835, 23088, 23065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10059, 22812, 22835, 23088, 23065, 22813, 22836, 23089, 23066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10060, 22813, 22836, 23089, 23066, 22814, 22837, 23090, 23067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10061, 22814, 22837, 23090, 23067, 22815, 22838, 23091, 23068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10062, 22815, 22838, 23091, 23068, 22816, 22839, 23092, 23069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10063, 22816, 22839, 23092, 23069, 22817, 22840, 23093, 23070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10064, 22817, 22840, 23093, 23070, 22818, 22841, 23094, 23071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10065, 22818, 22841, 23094, 23071, 4989, 4990, 5001, 5000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10066, 3173, 3174, 3185, 3184, 22819, 22842, 23095, 23072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10067, 22819, 22842, 23095, 23072, 22820, 22843, 23096, 23073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10068, 22820, 22843, 23096, 23073, 22821, 22844, 23097, 23074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10069, 22821, 22844, 23097, 23074, 22822, 22845, 23098, 23075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10070, 22822, 22845, 23098, 23075, 22823, 22846, 23099, 23076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10071, 22823, 22846, 23099, 23076, 22824, 22847, 23100, 23077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10072, 22824, 22847, 23100, 23077, 22825, 22848, 23101, 23078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10073, 22825, 22848, 23101, 23078, 22826, 22849, 23102, 23079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10074, 22826, 22849, 23102, 23079, 22827, 22850, 23103, 23080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10075, 22827, 22850, 23103, 23080, 22828, 22851, 23104, 23081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10076, 22828, 22851, 23104, 23081, 22829, 22852, 23105, 23082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10077, 22829, 22852, 23105, 23082, 22830, 22853, 23106, 23083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10078, 22830, 22853, 23106, 23083, 22831, 22854, 23107, 23084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10079, 22831, 22854, 23107, 23084, 22832, 22855, 23108, 23085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10080, 22832, 22855, 23108, 23085, 22833, 22856, 23109, 23086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10081, 22833, 22856, 23109, 23086, 22834, 22857, 23110, 23087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10082, 22834, 22857, 23110, 23087, 22835, 22858, 23111, 23088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10083, 22835, 22858, 23111, 23088, 22836, 22859, 23112, 23089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10084, 22836, 22859, 23112, 23089, 22837, 22860, 23113, 23090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10085, 22837, 22860, 23113, 23090, 22838, 22861, 23114, 23091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10086, 22838, 22861, 23114, 23091, 22839, 22862, 23115, 23092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10087, 22839, 22862, 23115, 23092, 22840, 22863, 23116, 23093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10088, 22840, 22863, 23116, 23093, 22841, 22864, 23117, 23094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10089, 22841, 22864, 23117, 23094, 4990, 4991, 5002, 5001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10090, 3174, 3175, 3186, 3185, 22842, 22865, 23118, 23095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10091, 22842, 22865, 23118, 23095, 22843, 22866, 23119, 23096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10092, 22843, 22866, 23119, 23096, 22844, 22867, 23120, 23097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10093, 22844, 22867, 23120, 23097, 22845, 22868, 23121, 23098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10094, 22845, 22868, 23121, 23098, 22846, 22869, 23122, 23099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10095, 22846, 22869, 23122, 23099, 22847, 22870, 23123, 23100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10096, 22847, 22870, 23123, 23100, 22848, 22871, 23124, 23101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10097, 22848, 22871, 23124, 23101, 22849, 22872, 23125, 23102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10098, 22849, 22872, 23125, 23102, 22850, 22873, 23126, 23103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10099, 22850, 22873, 23126, 23103, 22851, 22874, 23127, 23104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10100, 22851, 22874, 23127, 23104, 22852, 22875, 23128, 23105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10101, 22852, 22875, 23128, 23105, 22853, 22876, 23129, 23106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10102, 22853, 22876, 23129, 23106, 22854, 22877, 23130, 23107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10103, 22854, 22877, 23130, 23107, 22855, 22878, 23131, 23108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10104, 22855, 22878, 23131, 23108, 22856, 22879, 23132, 23109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10105, 22856, 22879, 23132, 23109, 22857, 22880, 23133, 23110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10106, 22857, 22880, 23133, 23110, 22858, 22881, 23134, 23111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10107, 22858, 22881, 23134, 23111, 22859, 22882, 23135, 23112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10108, 22859, 22882, 23135, 23112, 22860, 22883, 23136, 23113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10109, 22860, 22883, 23136, 23113, 22861, 22884, 23137, 23114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10110, 22861, 22884, 23137, 23114, 22862, 22885, 23138, 23115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10111, 22862, 22885, 23138, 23115, 22863, 22886, 23139, 23116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10112, 22863, 22886, 23139, 23116, 22864, 22887, 23140, 23117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10113, 22864, 22887, 23140, 23117, 4991, 4992, 5003, 5002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10114, 3175, 3176, 3187, 3186, 22865, 22888, 23141, 23118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10115, 22865, 22888, 23141, 23118, 22866, 22889, 23142, 23119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10116, 22866, 22889, 23142, 23119, 22867, 22890, 23143, 23120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10117, 22867, 22890, 23143, 23120, 22868, 22891, 23144, 23121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10118, 22868, 22891, 23144, 23121, 22869, 22892, 23145, 23122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10119, 22869, 22892, 23145, 23122, 22870, 22893, 23146, 23123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10120, 22870, 22893, 23146, 23123, 22871, 22894, 23147, 23124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10121, 22871, 22894, 23147, 23124, 22872, 22895, 23148, 23125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10122, 22872, 22895, 23148, 23125, 22873, 22896, 23149, 23126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10123, 22873, 22896, 23149, 23126, 22874, 22897, 23150, 23127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10124, 22874, 22897, 23150, 23127, 22875, 22898, 23151, 23128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10125, 22875, 22898, 23151, 23128, 22876, 22899, 23152, 23129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10126, 22876, 22899, 23152, 23129, 22877, 22900, 23153, 23130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10127, 22877, 22900, 23153, 23130, 22878, 22901, 23154, 23131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10128, 22878, 22901, 23154, 23131, 22879, 22902, 23155, 23132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10129, 22879, 22902, 23155, 23132, 22880, 22903, 23156, 23133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10130, 22880, 22903, 23156, 23133, 22881, 22904, 23157, 23134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10131, 22881, 22904, 23157, 23134, 22882, 22905, 23158, 23135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10132, 22882, 22905, 23158, 23135, 22883, 22906, 23159, 23136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10133, 22883, 22906, 23159, 23136, 22884, 22907, 23160, 23137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10134, 22884, 22907, 23160, 23137, 22885, 22908, 23161, 23138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10135, 22885, 22908, 23161, 23138, 22886, 22909, 23162, 23139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10136, 22886, 22909, 23162, 23139, 22887, 22910, 23163, 23140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10137, 22887, 22910, 23163, 23140, 4992, 4993, 5004, 5003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10138, 3176, 3177, 3188, 3187, 22888, 22911, 23164, 23141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10139, 22888, 22911, 23164, 23141, 22889, 22912, 23165, 23142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10140, 22889, 22912, 23165, 23142, 22890, 22913, 23166, 23143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10141, 22890, 22913, 23166, 23143, 22891, 22914, 23167, 23144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10142, 22891, 22914, 23167, 23144, 22892, 22915, 23168, 23145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10143, 22892, 22915, 23168, 23145, 22893, 22916, 23169, 23146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10144, 22893, 22916, 23169, 23146, 22894, 22917, 23170, 23147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10145, 22894, 22917, 23170, 23147, 22895, 22918, 23171, 23148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10146, 22895, 22918, 23171, 23148, 22896, 22919, 23172, 23149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10147, 22896, 22919, 23172, 23149, 22897, 22920, 23173, 23150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10148, 22897, 22920, 23173, 23150, 22898, 22921, 23174, 23151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10149, 22898, 22921, 23174, 23151, 22899, 22922, 23175, 23152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10150, 22899, 22922, 23175, 23152, 22900, 22923, 23176, 23153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10151, 22900, 22923, 23176, 23153, 22901, 22924, 23177, 23154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10152, 22901, 22924, 23177, 23154, 22902, 22925, 23178, 23155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10153, 22902, 22925, 23178, 23155, 22903, 22926, 23179, 23156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10154, 22903, 22926, 23179, 23156, 22904, 22927, 23180, 23157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10155, 22904, 22927, 23180, 23157, 22905, 22928, 23181, 23158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10156, 22905, 22928, 23181, 23158, 22906, 22929, 23182, 23159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10157, 22906, 22929, 23182, 23159, 22907, 22930, 23183, 23160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10158, 22907, 22930, 23183, 23160, 22908, 22931, 23184, 23161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10159, 22908, 22931, 23184, 23161, 22909, 22932, 23185, 23162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10160, 22909, 22932, 23185, 23162, 22910, 22933, 23186, 23163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10161, 22910, 22933, 23186, 23163, 4993, 4994, 5005, 5004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10162, 3177, 3178, 3189, 3188, 22911, 22934, 23187, 23164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10163, 22911, 22934, 23187, 23164, 22912, 22935, 23188, 23165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10164, 22912, 22935, 23188, 23165, 22913, 22936, 23189, 23166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10165, 22913, 22936, 23189, 23166, 22914, 22937, 23190, 23167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10166, 22914, 22937, 23190, 23167, 22915, 22938, 23191, 23168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10167, 22915, 22938, 23191, 23168, 22916, 22939, 23192, 23169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10168, 22916, 22939, 23192, 23169, 22917, 22940, 23193, 23170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10169, 22917, 22940, 23193, 23170, 22918, 22941, 23194, 23171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10170, 22918, 22941, 23194, 23171, 22919, 22942, 23195, 23172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10171, 22919, 22942, 23195, 23172, 22920, 22943, 23196, 23173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10172, 22920, 22943, 23196, 23173, 22921, 22944, 23197, 23174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10173, 22921, 22944, 23197, 23174, 22922, 22945, 23198, 23175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10174, 22922, 22945, 23198, 23175, 22923, 22946, 23199, 23176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10175, 22923, 22946, 23199, 23176, 22924, 22947, 23200, 23177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10176, 22924, 22947, 23200, 23177, 22925, 22948, 23201, 23178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10177, 22925, 22948, 23201, 23178, 22926, 22949, 23202, 23179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10178, 22926, 22949, 23202, 23179, 22927, 22950, 23203, 23180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10179, 22927, 22950, 23203, 23180, 22928, 22951, 23204, 23181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10180, 22928, 22951, 23204, 23181, 22929, 22952, 23205, 23182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10181, 22929, 22952, 23205, 23182, 22930, 22953, 23206, 23183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10182, 22930, 22953, 23206, 23183, 22931, 22954, 23207, 23184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10183, 22931, 22954, 23207, 23184, 22932, 22955, 23208, 23185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10184, 22932, 22955, 23208, 23185, 22933, 22956, 23209, 23186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10185, 22933, 22956, 23209, 23186, 4994, 4995, 5006, 5005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10186, 3178, 3179, 3190, 3189, 22934, 22957, 23210, 23187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10187, 22934, 22957, 23210, 23187, 22935, 22958, 23211, 23188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10188, 22935, 22958, 23211, 23188, 22936, 22959, 23212, 23189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10189, 22936, 22959, 23212, 23189, 22937, 22960, 23213, 23190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10190, 22937, 22960, 23213, 23190, 22938, 22961, 23214, 23191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10191, 22938, 22961, 23214, 23191, 22939, 22962, 23215, 23192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10192, 22939, 22962, 23215, 23192, 22940, 22963, 23216, 23193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10193, 22940, 22963, 23216, 23193, 22941, 22964, 23217, 23194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10194, 22941, 22964, 23217, 23194, 22942, 22965, 23218, 23195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10195, 22942, 22965, 23218, 23195, 22943, 22966, 23219, 23196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10196, 22943, 22966, 23219, 23196, 22944, 22967, 23220, 23197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10197, 22944, 22967, 23220, 23197, 22945, 22968, 23221, 23198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10198, 22945, 22968, 23221, 23198, 22946, 22969, 23222, 23199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10199, 22946, 22969, 23222, 23199, 22947, 22970, 23223, 23200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10200, 22947, 22970, 23223, 23200, 22948, 22971, 23224, 23201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10201, 22948, 22971, 23224, 23201, 22949, 22972, 23225, 23202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10202, 22949, 22972, 23225, 23202, 22950, 22973, 23226, 23203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10203, 22950, 22973, 23226, 23203, 22951, 22974, 23227, 23204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10204, 22951, 22974, 23227, 23204, 22952, 22975, 23228, 23205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10205, 22952, 22975, 23228, 23205, 22953, 22976, 23229, 23206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10206, 22953, 22976, 23229, 23206, 22954, 22977, 23230, 23207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10207, 22954, 22977, 23230, 23207, 22955, 22978, 23231, 23208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10208, 22955, 22978, 23231, 23208, 22956, 22979, 23232, 23209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10209, 22956, 22979, 23232, 23209, 4995, 4996, 5007, 5006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10210, 3179, 3180, 3191, 3190, 22957, 22980, 23233, 23210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10211, 22957, 22980, 23233, 23210, 22958, 22981, 23234, 23211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10212, 22958, 22981, 23234, 23211, 22959, 22982, 23235, 23212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10213, 22959, 22982, 23235, 23212, 22960, 22983, 23236, 23213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10214, 22960, 22983, 23236, 23213, 22961, 22984, 23237, 23214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10215, 22961, 22984, 23237, 23214, 22962, 22985, 23238, 23215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10216, 22962, 22985, 23238, 23215, 22963, 22986, 23239, 23216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10217, 22963, 22986, 23239, 23216, 22964, 22987, 23240, 23217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10218, 22964, 22987, 23240, 23217, 22965, 22988, 23241, 23218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10219, 22965, 22988, 23241, 23218, 22966, 22989, 23242, 23219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10220, 22966, 22989, 23242, 23219, 22967, 22990, 23243, 23220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10221, 22967, 22990, 23243, 23220, 22968, 22991, 23244, 23221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10222, 22968, 22991, 23244, 23221, 22969, 22992, 23245, 23222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10223, 22969, 22992, 23245, 23222, 22970, 22993, 23246, 23223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10224, 22970, 22993, 23246, 23223, 22971, 22994, 23247, 23224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10225, 22971, 22994, 23247, 23224, 22972, 22995, 23248, 23225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10226, 22972, 22995, 23248, 23225, 22973, 22996, 23249, 23226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10227, 22973, 22996, 23249, 23226, 22974, 22997, 23250, 23227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10228, 22974, 22997, 23250, 23227, 22975, 22998, 23251, 23228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10229, 22975, 22998, 23251, 23228, 22976, 22999, 23252, 23229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10230, 22976, 22999, 23252, 23229, 22977, 23000, 23253, 23230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10231, 22977, 23000, 23253, 23230, 22978, 23001, 23254, 23231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10232, 22978, 23001, 23254, 23231, 22979, 23002, 23255, 23232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10233, 22979, 23002, 23255, 23232, 4996, 4997, 5008, 5007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10234, 3180, 3181, 3192, 3191, 22980, 23003, 23256, 23233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10235, 22980, 23003, 23256, 23233, 22981, 23004, 23257, 23234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10236, 22981, 23004, 23257, 23234, 22982, 23005, 23258, 23235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10237, 22982, 23005, 23258, 23235, 22983, 23006, 23259, 23236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10238, 22983, 23006, 23259, 23236, 22984, 23007, 23260, 23237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10239, 22984, 23007, 23260, 23237, 22985, 23008, 23261, 23238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10240, 22985, 23008, 23261, 23238, 22986, 23009, 23262, 23239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10241, 22986, 23009, 23262, 23239, 22987, 23010, 23263, 23240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10242, 22987, 23010, 23263, 23240, 22988, 23011, 23264, 23241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10243, 22988, 23011, 23264, 23241, 22989, 23012, 23265, 23242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10244, 22989, 23012, 23265, 23242, 22990, 23013, 23266, 23243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10245, 22990, 23013, 23266, 23243, 22991, 23014, 23267, 23244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10246, 22991, 23014, 23267, 23244, 22992, 23015, 23268, 23245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10247, 22992, 23015, 23268, 23245, 22993, 23016, 23269, 23246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10248, 22993, 23016, 23269, 23246, 22994, 23017, 23270, 23247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10249, 22994, 23017, 23270, 23247, 22995, 23018, 23271, 23248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10250, 22995, 23018, 23271, 23248, 22996, 23019, 23272, 23249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10251, 22996, 23019, 23272, 23249, 22997, 23020, 23273, 23250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10252, 22997, 23020, 23273, 23250, 22998, 23021, 23274, 23251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10253, 22998, 23021, 23274, 23251, 22999, 23022, 23275, 23252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10254, 22999, 23022, 23275, 23252, 23000, 23023, 23276, 23253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10255, 23000, 23023, 23276, 23253, 23001, 23024, 23277, 23254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10256, 23001, 23024, 23277, 23254, 23002, 23025, 23278, 23255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10257, 23002, 23025, 23278, 23255, 4997, 4998, 5009, 5008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10258, 3181, 287, 288, 3192, 23003, 4338, 4361, 23256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10259, 23003, 4338, 4361, 23256, 23004, 4339, 4362, 23257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10260, 23004, 4339, 4362, 23257, 23005, 4340, 4363, 23258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10261, 23005, 4340, 4363, 23258, 23006, 4341, 4364, 23259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10262, 23006, 4341, 4364, 23259, 23007, 4342, 4365, 23260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10263, 23007, 4342, 4365, 23260, 23008, 4343, 4366, 23261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10264, 23008, 4343, 4366, 23261, 23009, 4344, 4367, 23262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10265, 23009, 4344, 4367, 23262, 23010, 4345, 4368, 23263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10266, 23010, 4345, 4368, 23263, 23011, 4346, 4369, 23264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10267, 23011, 4346, 4369, 23264, 23012, 4347, 4370, 23265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10268, 23012, 4347, 4370, 23265, 23013, 4348, 4371, 23266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10269, 23013, 4348, 4371, 23266, 23014, 4349, 4372, 23267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10270, 23014, 4349, 4372, 23267, 23015, 4350, 4373, 23268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10271, 23015, 4350, 4373, 23268, 23016, 4351, 4374, 23269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10272, 23016, 4351, 4374, 23269, 23017, 4352, 4375, 23270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10273, 23017, 4352, 4375, 23270, 23018, 4353, 4376, 23271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10274, 23018, 4353, 4376, 23271, 23019, 4354, 4377, 23272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10275, 23019, 4354, 4377, 23272, 23020, 4355, 4378, 23273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10276, 23020, 4355, 4378, 23273, 23021, 4356, 4379, 23274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10277, 23021, 4356, 4379, 23274, 23022, 4357, 4380, 23275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10278, 23022, 4357, 4380, 23275, 23023, 4358, 4381, 23276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10279, 23023, 4358, 4381, 23276, 23024, 4359, 4382, 23277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10280, 23024, 4359, 4382, 23277, 23025, 4360, 4383, 23278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10281, 23025, 4360, 4383, 23278, 4998, 447, 448, 5009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10282, 254, 3182, 3193, 255, 3579, 23026, 23279, 3602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10283, 3579, 23026, 23279, 3602, 3580, 23027, 23280, 3603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10284, 3580, 23027, 23280, 3603, 3581, 23028, 23281, 3604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10285, 3581, 23028, 23281, 3604, 3582, 23029, 23282, 3605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10286, 3582, 23029, 23282, 3605, 3583, 23030, 23283, 3606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10287, 3583, 23030, 23283, 3606, 3584, 23031, 23284, 3607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10288, 3584, 23031, 23284, 3607, 3585, 23032, 23285, 3608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10289, 3585, 23032, 23285, 3608, 3586, 23033, 23286, 3609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10290, 3586, 23033, 23286, 3609, 3587, 23034, 23287, 3610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10291, 3587, 23034, 23287, 3610, 3588, 23035, 23288, 3611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10292, 3588, 23035, 23288, 3611, 3589, 23036, 23289, 3612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10293, 3589, 23036, 23289, 3612, 3590, 23037, 23290, 3613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10294, 3590, 23037, 23290, 3613, 3591, 23038, 23291, 3614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10295, 3591, 23038, 23291, 3614, 3592, 23039, 23292, 3615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10296, 3592, 23039, 23292, 3615, 3593, 23040, 23293, 3616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10297, 3593, 23040, 23293, 3616, 3594, 23041, 23294, 3617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10298, 3594, 23041, 23294, 3617, 3595, 23042, 23295, 3618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
