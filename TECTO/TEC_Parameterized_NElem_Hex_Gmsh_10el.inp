30182, 47444, 47488, 47492, 47448, 47445, 47489, 47493, 47449, 50477, 50489, 50490, 50342, 50480, 50492, 50493, 
50345, 50331, 50478, 50491, 50344
30183, 47445, 47489, 47493, 47449, 47446, 47490, 47494, 47450, 50480, 50492, 50493, 50345, 50483, 50495, 50496, 
50348, 50334, 50481, 50494, 50347
30184, 47446, 47490, 47494, 47450, 47447, 47491, 47495, 47451, 50483, 50495, 50496, 50348, 50486, 50498, 50499, 
50351, 50337, 50484, 50497, 50350
30185, 47447, 47491, 47495, 47451, 18187, 18198, 18199, 18188, 50486, 50498, 50499, 50351, 0, 0, 0, 
0, 50340, 50487, 50500, 50353
30186, 2653, 2664, 2665, 2654, 47448, 47492, 47496, 47452, 0, 0, 0, 0, 50490, 50502, 50503, 
50355, 50341, 50488, 50501, 50354
30187, 47448, 47492, 47496, 47452, 47449, 47493, 47497, 47453, 50490, 50502, 50503, 50355, 50493, 50505, 50506, 
50358, 50344, 50491, 50504, 50357
30188, 47449, 47493, 47497, 47453, 47450, 47494, 47498, 47454, 50493, 50505, 50506, 50358, 50496, 50508, 50509, 
50361, 50347, 50494, 50507, 50360
30189, 47450, 47494, 47498, 47454, 47451, 47495, 47499, 47455, 50496, 50508, 50509, 50361, 50499, 50511, 50512, 
50364, 50350, 50497, 50510, 50363
30190, 47451, 47495, 47499, 47455, 18188, 18199, 18200, 18189, 50499, 50511, 50512, 50364, 0, 0, 0, 
0, 50353, 50500, 50513, 50366
30191, 2654, 2665, 2666, 2655, 47452, 47496, 47500, 47456, 0, 0, 0, 0, 50503, 50515, 50516, 
50368, 50354, 50501, 50514, 50367
30192, 47452, 47496, 47500, 47456, 47453, 47497, 47501, 47457, 50503, 50515, 50516, 50368, 50506, 50518, 50519, 
50371, 50357, 50504, 50517, 50370
30193, 47453, 47497, 47501, 47457, 47454, 47498, 47502, 47458, 50506, 50518, 50519, 50371, 50509, 50521, 50522, 
50374, 50360, 50507, 50520, 50373
30194, 47454, 47498, 47502, 47458, 47455, 47499, 47503, 47459, 50509, 50521, 50522, 50374, 50512, 50524, 50525, 
50377, 50363, 50510, 50523, 50376
30195, 47455, 47499, 47503, 47459, 18189, 18200, 18201, 18190, 50512, 50524, 50525, 50377, 0, 0, 0, 
0, 50366, 50513, 50526, 50379
30196, 2655, 2666, 2667, 2656, 47456, 47500, 47504, 47460, 0, 0, 0, 0, 50516, 50528, 50529, 
50381, 50367, 50514, 50527, 50380
30197, 47456, 47500, 47504, 47460, 47457, 47501, 47505, 47461, 50516, 50528, 50529, 50381, 50519, 50531, 50532, 
50384, 50370, 50517, 50530, 50383
30198, 47457, 47501, 47505, 47461, 47458, 47502, 47506, 47462, 50519, 50531, 50532, 50384, 50522, 50534, 50535, 
50387, 50373, 50520, 50533, 50386
30199, 47458, 47502, 47506, 47462, 47459, 47503, 47507, 47463, 50522, 50534, 50535, 50387, 50525, 50537, 50538, 
50390, 50376, 50523, 50536, 50389
30200, 47459, 47503, 47507, 47463, 18190, 18201, 18202, 18191, 50525, 50537, 50538, 50390, 0, 0, 0, 
0, 50379, 50526, 50539, 50392
30201, 2656, 2667, 2668, 2657, 47460, 47504, 47508, 47464, 0, 0, 0, 0, 50529, 50541, 50542, 
50394, 50380, 50527, 50540, 50393
30202, 47460, 47504, 47508, 47464, 47461, 47505, 47509, 47465, 50529, 50541, 50542, 50394, 50532, 50544, 50545, 
50397, 50383, 50530, 50543, 50396
30203, 47461, 47505, 47509, 47465, 47462, 47506, 47510, 47466, 50532, 50544, 50545, 50397, 50535, 50547, 50548, 
50400, 50386, 50533, 50546, 50399
30204, 47462, 47506, 47510, 47466, 47463, 47507, 47511, 47467, 50535, 50547, 50548, 50400, 50538, 50550, 50551, 
50403, 50389, 50536, 50549, 50402
30205, 47463, 47507, 47511, 47467, 18191, 18202, 18203, 18192, 50538, 50550, 50551, 50403, 0, 0, 0, 
0, 50392, 50539, 50552, 50405
30206, 2657, 2668, 2669, 2658, 47464, 47508, 47512, 47468, 0, 0, 0, 0, 50542, 50554, 50555, 
50407, 50393, 50540, 50553, 50406
30207, 47464, 47508, 47512, 47468, 47465, 47509, 47513, 47469, 50542, 50554, 50555, 50407, 50545, 50557, 50558, 
50410, 50396, 50543, 50556, 50409
30208, 47465, 47509, 47513, 47469, 47466, 47510, 47514, 47470, 50545, 50557, 50558, 50410, 50548, 50560, 50561, 
50413, 50399, 50546, 50559, 50412
30209, 47466, 47510, 47514, 47470, 47467, 47511, 47515, 47471, 50548, 50560, 50561, 50413, 50551, 50563, 50564, 
50416, 50402, 50549, 50562, 50415
30210, 47467, 47511, 47515, 47471, 18192, 18203, 18204, 18193, 50551, 50563, 50564, 50416, 0, 0, 0, 
0, 50405, 50552, 50565, 50418
30211, 2658, 2669, 2670, 2659, 47468, 47512, 47516, 47472, 0, 0, 0, 0, 50555, 50567, 50568, 
50420, 50406, 50553, 50566, 50419
30212, 47468, 47512, 47516, 47472, 47469, 47513, 47517, 47473, 50555, 50567, 50568, 50420, 50558, 50570, 50571, 
50423, 50409, 50556, 50569, 50422
30213, 47469, 47513, 47517, 47473, 47470, 47514, 47518, 47474, 50558, 50570, 50571, 50423, 50561, 50573, 50574, 
50426, 50412, 50559, 50572, 50425
30214, 47470, 47514, 47518, 47474, 47471, 47515, 47519, 47475, 50561, 50573, 50574, 50426, 50564, 50576, 50577, 
50429, 50415, 50562, 50575, 50428
30215, 47471, 47515, 47519, 47475, 18193, 18204, 18205, 18194, 50564, 50576, 50577, 50429, 0, 0, 0, 
0, 50418, 50565, 50578, 50431
30216, 2659, 2670, 2671, 2660, 47472, 47516, 47520, 47476, 0, 0, 0, 0, 50568, 50580, 50581, 
50433, 50419, 50566, 50579, 50432
30217, 47472, 47516, 47520, 47476, 47473, 47517, 47521, 47477, 50568, 50580, 50581, 50433, 50571, 50583, 50584, 
50436, 50422, 50569, 50582, 50435
30218, 47473, 47517, 47521, 47477, 47474, 47518, 47522, 47478, 50571, 50583, 50584, 50436, 50574, 50586, 50587, 
50439, 50425, 50572, 50585, 50438
30219, 47474, 47518, 47522, 47478, 47475, 47519, 47523, 47479, 50574, 50586, 50587, 50439, 50577, 50589, 50590, 
50442, 50428, 50575, 50588, 50441
30220, 47475, 47519, 47523, 47479, 18194, 18205, 18206, 18195, 50577, 50589, 50590, 50442, 0, 0, 0, 
0, 50431, 50578, 50591, 50444
30221, 2660, 2671, 192, 191, 47476, 47520, 17824, 17820, 0, 0, 0, 0, 50581, 50592, 0, 
50445, 50432, 50579, 0, 0
30222, 47476, 47520, 17824, 17820, 47477, 47521, 17825, 17821, 50581, 50592, 0, 50445, 50584, 50593, 0, 
50446, 50435, 50582, 0, 0
30223, 47477, 47521, 17825, 17821, 47478, 47522, 17826, 17822, 50584, 50593, 0, 50446, 50587, 50594, 0, 
50447, 50438, 50585, 0, 0
30224, 47478, 47522, 17826, 17822, 47479, 47523, 17827, 17823, 50587, 50594, 0, 50447, 50590, 50595, 0, 
50448, 50441, 50588, 0, 0
30225, 47479, 47523, 17827, 17823, 18195, 18206, 2251, 2250, 50590, 50595, 0, 50448, 0, 0, 0, 
0, 50444, 50591, 0, 0
30226, 169, 170, 2672, 2661, 17374, 17378, 47524, 47480, 0, 0, 0, 0, 17571, 50597, 50598, 
50450, 17561, 17570, 50596, 50449
30227, 17374, 17378, 47524, 47480, 17375, 17379, 47525, 47481, 17571, 50597, 50598, 50450, 17573, 50600, 50601, 
50453, 17563, 17572, 50599, 50452
30228, 17375, 17379, 47525, 47481, 17376, 17380, 47526, 47482, 17573, 50600, 50601, 50453, 17575, 50603, 50604, 
50456, 17565, 17574, 50602, 50455
30229, 17376, 17380, 47526, 47482, 17377, 17381, 47527, 47483, 17575, 50603, 50604, 50456, 17577, 50606, 50607, 
50459, 17567, 17576, 50605, 50458
30230, 17377, 17381, 47527, 47483, 2209, 2210, 18207, 18196, 17577, 50606, 50607, 50459, 0, 0, 0, 
0, 17569, 17578, 50608, 50461
30231, 2661, 2672, 2673, 2662, 47480, 47524, 47528, 47484, 0, 0, 0, 0, 50598, 50610, 50611, 
50463, 50449, 50596, 50609, 50462
30232, 47480, 47524, 47528, 47484, 47481, 47525, 47529, 47485, 50598, 50610, 50611, 50463, 50601, 50613, 50614, 
50466, 50452, 50599, 50612, 50465
30233, 47481, 47525, 47529, 47485, 47482, 47526, 47530, 47486, 50601, 50613, 50614, 50466, 50604, 50616, 50617, 
50469, 50455, 50602, 50615, 50468
30234, 47482, 47526, 47530, 47486, 47483, 47527, 47531, 47487, 50604, 50616, 50617, 50469, 50607, 50619, 50620, 
50472, 50458, 50605, 50618, 50471
30235, 47483, 47527, 47531, 47487, 18196, 18207, 18208, 18197, 50607, 50619, 50620, 50472, 0, 0, 0, 
0, 50461, 50608, 50621, 50474
30236, 2662, 2673, 2674, 2663, 47484, 47528, 47532, 47488, 0, 0, 0, 0, 50611, 50623, 50624, 
50476, 50462, 50609, 50622, 50475
30237, 47484, 47528, 47532, 47488, 47485, 47529, 47533, 47489, 50611, 50623, 50624, 50476, 50614, 50626, 50627, 
50479, 50465, 50612, 50625, 50478
30238, 47485, 47529, 47533, 47489, 47486, 47530, 47534, 47490, 50614, 50626, 50627, 50479, 50617, 50629, 50630, 
50482, 50468, 50615, 50628, 50481
30239, 47486, 47530, 47534, 47490, 47487, 47531, 47535, 47491, 50617, 50629, 50630, 50482, 50620, 50632, 50633, 
50485, 50471, 50618, 50631, 50484
30240, 47487, 47531, 47535, 47491, 18197, 18208, 18209, 18198, 50620, 50632, 50633, 50485, 0, 0, 0, 
0, 50474, 50621, 50634, 50487
30241, 2663, 2674, 2675, 2664, 47488, 47532, 47536, 47492, 0, 0, 0, 0, 50624, 50636, 50637, 
50489, 50475, 50622, 50635, 50488
30242, 47488, 47532, 47536, 47492, 47489, 47533, 47537, 47493, 50624, 50636, 50637, 50489, 50627, 50639, 50640, 
50492, 50478, 50625, 50638, 50491
30243, 47489, 47533, 47537, 47493, 47490, 47534, 47538, 47494, 50627, 50639, 50640, 50492, 50630, 50642, 50643, 
50495, 50481, 50628, 50641, 50494
30244, 47490, 47534, 47538, 47494, 47491, 47535, 47539, 47495, 50630, 50642, 50643, 50495, 50633, 50645, 50646, 
50498, 50484, 50631, 50644, 50497
30245, 47491, 47535, 47539, 47495, 18198, 18209, 18210, 18199, 50633, 50645, 50646, 50498, 0, 0, 0, 
0, 50487, 50634, 50647, 50500
30246, 2664, 2675, 2676, 2665, 47492, 47536, 47540, 47496, 0, 0, 0, 0, 50637, 50649, 50650, 
50502, 50488, 50635, 50648, 50501
30247, 47492, 47536, 47540, 47496, 47493, 47537, 47541, 47497, 50637, 50649, 50650, 50502, 50640, 50652, 50653, 
50505, 50491, 50638, 50651, 50504
30248, 47493, 47537, 47541, 47497, 47494, 47538, 47542, 47498, 50640, 50652, 50653, 50505, 50643, 50655, 50656, 
50508, 50494, 50641, 50654, 50507
30249, 47494, 47538, 47542, 47498, 47495, 47539, 47543, 47499, 50643, 50655, 50656, 50508, 50646, 50658, 50659, 
50511, 50497, 50644, 50657, 50510
30250, 47495, 47539, 47543, 47499, 18199, 18210, 18211, 18200, 50646, 50658, 50659, 50511, 0, 0, 0, 
0, 50500, 50647, 50660, 50513
30251, 2665, 2676, 2677, 2666, 47496, 47540, 47544, 47500, 0, 0, 0, 0, 50650, 50662, 50663, 
50515, 50501, 50648, 50661, 50514
30252, 47496, 47540, 47544, 47500, 47497, 47541, 47545, 47501, 50650, 50662, 50663, 50515, 50653, 50665, 50666, 
50518, 50504, 50651, 50664, 50517
30253, 47497, 47541, 47545, 47501, 47498, 47542, 47546, 47502, 50653, 50665, 50666, 50518, 50656, 50668, 50669, 
50521, 50507, 50654, 50667, 50520
30254, 47498, 47542, 47546, 47502, 47499, 47543, 47547, 47503, 50656, 50668, 50669, 50521, 50659, 50671, 50672, 
50524, 50510, 50657, 50670, 50523
30255, 47499, 47543, 47547, 47503, 18200, 18211, 18212, 18201, 50659, 50671, 50672, 50524, 0, 0, 0, 
0, 50513, 50660, 50673, 50526
30256, 2666, 2677, 2678, 2667, 47500, 47544, 47548, 47504, 0, 0, 0, 0, 50663, 50675, 50676, 
50528, 50514, 50661, 50674, 50527
30257, 47500, 47544, 47548, 47504, 47501, 47545, 47549, 47505, 50663, 50675, 50676, 50528, 50666, 50678, 50679, 
50531, 50517, 50664, 50677, 50530
30258, 47501, 47545, 47549, 47505, 47502, 47546, 47550, 47506, 50666, 50678, 50679, 50531, 50669, 50681, 50682, 
50534, 50520, 50667, 50680, 50533
30259, 47502, 47546, 47550, 47506, 47503, 47547, 47551, 47507, 50669, 50681, 50682, 50534, 50672, 50684, 50685, 
50537, 50523, 50670, 50683, 50536
30260, 47503, 47547, 47551, 47507, 18201, 18212, 18213, 18202, 50672, 50684, 50685, 50537, 0, 0, 0, 
0, 50526, 50673, 50686, 50539
30261, 2667, 2678, 2679, 2668, 47504, 47548, 47552, 47508, 0, 0, 0, 0, 50676, 50688, 50689, 
50541, 50527, 50674, 50687, 50540
30262, 47504, 47548, 47552, 47508, 47505, 47549, 47553, 47509, 50676, 50688, 50689, 50541, 50679, 50691, 50692, 
50544, 50530, 50677, 50690, 50543
30263, 47505, 47549, 47553, 47509, 47506, 47550, 47554, 47510, 50679, 50691, 50692, 50544, 50682, 50694, 50695, 
50547, 50533, 50680, 50693, 50546
30264, 47506, 47550, 47554, 47510, 47507, 47551, 47555, 47511, 50682, 50694, 50695, 50547, 50685, 50697, 50698, 
50550, 50536, 50683, 50696, 50549
30265, 47507, 47551, 47555, 47511, 18202, 18213, 18214, 18203, 50685, 50697, 50698, 50550, 0, 0, 0, 
0, 50539, 50686, 50699, 50552
30266, 2668, 2679, 2680, 2669, 47508, 47552, 47556, 47512, 0, 0, 0, 0, 50689, 50701, 50702, 
50554, 50540, 50687, 50700, 50553
30267, 47508, 47552, 47556, 47512, 47509, 47553, 47557, 47513, 50689, 50701, 50702, 50554, 50692, 50704, 50705, 
50557, 50543, 50690, 50703, 50556
30268, 47509, 47553, 47557, 47513, 47510, 47554, 47558, 47514, 50692, 50704, 50705, 50557, 50695, 50707, 50708, 
50560, 50546, 50693, 50706, 50559
30269, 47510, 47554, 47558, 47514, 47511, 47555, 47559, 47515, 50695, 50707, 50708, 50560, 50698, 50710, 50711, 
50563, 50549, 50696, 50709, 50562
30270, 47511, 47555, 47559, 47515, 18203, 18214, 18215, 18204, 50698, 50710, 50711, 50563, 0, 0, 0, 
0, 50552, 50699, 50712, 50565
30271, 2669, 2680, 2681, 2670, 47512, 47556, 47560, 47516, 0, 0, 0, 0, 50702, 50714, 50715, 
50567, 50553, 50700, 50713, 50566
30272, 47512, 47556, 47560, 47516, 47513, 47557, 47561, 47517, 50702, 50714, 50715, 50567, 50705, 50717, 50718, 
50570, 50556, 50703, 50716, 50569
30273, 47513, 47557, 47561, 47517, 47514, 47558, 47562, 47518, 50705, 50717, 50718, 50570, 50708, 50720, 50721, 
50573, 50559, 50706, 50719, 50572
30274, 47514, 47558, 47562, 47518, 47515, 47559, 47563, 47519, 50708, 50720, 50721, 50573, 50711, 50723, 50724, 
50576, 50562, 50709, 50722, 50575
30275, 47515, 47559, 47563, 47519, 18204, 18215, 18216, 18205, 50711, 50723, 50724, 50576, 0, 0, 0, 
0, 50565, 50712, 50725, 50578
30276, 2670, 2681, 2682, 2671, 47516, 47560, 47564, 47520, 0, 0, 0, 0, 50715, 50727, 50728, 
50580, 50566, 50713, 50726, 50579
30277, 47516, 47560, 47564, 47520, 47517, 47561, 47565, 47521, 50715, 50727, 50728, 50580, 50718, 50730, 50731, 
50583, 50569, 50716, 50729, 50582
30278, 47517, 47561, 47565, 47521, 47518, 47562, 47566, 47522, 50718, 50730, 50731, 50583, 50721, 50733, 50734, 
50586, 50572, 50719, 50732, 50585
30279, 47518, 47562, 47566, 47522, 47519, 47563, 47567, 47523, 50721, 50733, 50734, 50586, 50724, 50736, 50737, 
50589, 50575, 50722, 50735, 50588
30280, 47519, 47563, 47567, 47523, 18205, 18216, 18217, 18206, 50724, 50736, 50737, 50589, 0, 0, 0, 
0, 50578, 50725, 50738, 50591
30281, 2671, 2682, 193, 192, 47520, 47564, 17828, 17824, 0, 0, 0, 0, 50728, 50739, 0, 
50592, 50579, 50726, 0, 0
30282, 47520, 47564, 17828, 17824, 47521, 47565, 17829, 17825, 50728, 50739, 0, 50592, 50731, 50740, 0, 
50593, 50582, 50729, 0, 0
30283, 47521, 47565, 17829, 17825, 47522, 47566, 17830, 17826, 50731, 50740, 0, 50593, 50734, 50741, 0, 
50594, 50585, 50732, 0, 0
30284, 47522, 47566, 17830, 17826, 47523, 47567, 17831, 17827, 50734, 50741, 0, 50594, 50737, 50742, 0, 
50595, 50588, 50735, 0, 0
30285, 47523, 47567, 17831, 17827, 18206, 18217, 2252, 2251, 50737, 50742, 0, 50595, 0, 0, 0, 
0, 50591, 50738, 0, 0
30286, 170, 171, 2683, 2672, 17378, 17382, 47568, 47524, 0, 0, 0, 0, 17580, 50744, 50745, 
50597, 17570, 17579, 50743, 50596
30287, 17378, 17382, 47568, 47524, 17379, 17383, 47569, 47525, 17580, 50744, 50745, 50597, 17582, 50747, 50748, 
50600, 17572, 17581, 50746, 50599
30288, 17379, 17383, 47569, 47525, 17380, 17384, 47570, 47526, 17582, 50747, 50748, 50600, 17584, 50750, 50751, 
50603, 17574, 17583, 50749, 50602
30289, 17380, 17384, 47570, 47526, 17381, 17385, 47571, 47527, 17584, 50750, 50751, 50603, 17586, 50753, 50754, 
50606, 17576, 17585, 50752, 50605
30290, 17381, 17385, 47571, 47527, 2210, 2211, 18218, 18207, 17586, 50753, 50754, 50606, 0, 0, 0, 
0, 17578, 17587, 50755, 50608
30291, 2672, 2683, 2684, 2673, 47524, 47568, 47572, 47528, 0, 0, 0, 0, 50745, 50757, 50758, 
50610, 50596, 50743, 50756, 50609
30292, 47524, 47568, 47572, 47528, 47525, 47569, 47573, 47529, 50745, 50757, 50758, 50610, 50748, 50760, 50761, 
50613, 50599, 50746, 50759, 50612
30293, 47525, 47569, 47573, 47529, 47526, 47570, 47574, 47530, 50748, 50760, 50761, 50613, 50751, 50763, 50764, 
50616, 50602, 50749, 50762, 50615
30294, 47526, 47570, 47574, 47530, 47527, 47571, 47575, 47531, 50751, 50763, 50764, 50616, 50754, 50766, 50767, 
50619, 50605, 50752, 50765, 50618
30295, 47527, 47571, 47575, 47531, 18207, 18218, 18219, 18208, 50754, 50766, 50767, 50619, 0, 0, 0, 
0, 50608, 50755, 50768, 50621
30296, 2673, 2684, 2685, 2674, 47528, 47572, 47576, 47532, 0, 0, 0, 0, 50758, 50770, 50771, 
50623, 50609, 50756, 50769, 50622
30297, 47528, 47572, 47576, 47532, 47529, 47573, 47577, 47533, 50758, 50770, 50771, 50623, 50761, 50773, 50774, 
50626, 50612, 50759, 50772, 50625
30298, 47529, 47573, 47577, 47533, 47530, 47574, 47578, 47534, 50761, 50773, 50774, 50626, 50764, 50776, 50777, 
50629, 50615, 50762, 50775, 50628
30299, 47530, 47574, 47578, 47534, 47531, 47575, 47579, 47535, 50764, 50776, 50777, 50629, 50767, 50779, 50780, 
50632, 50618, 50765, 50778, 50631
30300, 47531, 47575, 47579, 47535, 18208, 18219, 18220, 18209, 50767, 50779, 50780, 50632, 0, 0, 0, 
0, 50621, 50768, 50781, 50634
30301, 2674, 2685, 2686, 2675, 47532, 47576, 47580, 47536, 0, 0, 0, 0, 50771, 50783, 50784, 
50636, 50622, 50769, 50782, 50635
30302, 47532, 47576, 47580, 47536, 47533, 47577, 47581, 47537, 50771, 50783, 50784, 50636, 50774, 50786, 50787, 
50639, 50625, 50772, 50785, 50638
30303, 47533, 47577, 47581, 47537, 47534, 47578, 47582, 47538, 50774, 50786, 50787, 50639, 50777, 50789, 50790, 
50642, 50628, 50775, 50788, 50641
30304, 47534, 47578, 47582, 47538, 47535, 47579, 47583, 47539, 50777, 50789, 50790, 50642, 50780, 50792, 50793, 
50645, 50631, 50778, 50791, 50644
30305, 47535, 47579, 47583, 47539, 18209, 18220, 18221, 18210, 50780, 50792, 50793, 50645, 0, 0, 0, 
0, 50634, 50781, 50794, 50647
30306, 2675, 2686, 2687, 2676, 47536, 47580, 47584, 47540, 0, 0, 0, 0, 50784, 50796, 50797, 
50649, 50635, 50782, 50795, 50648
30307, 47536, 47580, 47584, 47540, 47537, 47581, 47585, 47541, 50784, 50796, 50797, 50649, 50787, 50799, 50800, 
50652, 50638, 50785, 50798, 50651
30308, 47537, 47581, 47585, 47541, 47538, 47582, 47586, 47542, 50787, 50799, 50800, 50652, 50790, 50802, 50803, 
50655, 50641, 50788, 50801, 50654
30309, 47538, 47582, 47586, 47542, 47539, 47583, 47587, 47543, 50790, 50802, 50803, 50655, 50793, 50805, 50806, 
50658, 50644, 50791, 50804, 50657
30310, 47539, 47583, 47587, 47543, 18210, 18221, 18222, 18211, 50793, 50805, 50806, 50658, 0, 0, 0, 
0, 50647, 50794, 50807, 50660
30311, 2676, 2687, 2688, 2677, 47540, 47584, 47588, 47544, 0, 0, 0, 0, 50797, 50809, 50810, 
50662, 50648, 50795, 50808, 50661
30312, 47540, 47584, 47588, 47544, 47541, 47585, 47589, 47545, 50797, 50809, 50810, 50662, 50800, 50812, 50813, 
50665, 50651, 50798, 50811, 50664
30313, 47541, 47585, 47589, 47545, 47542, 47586, 47590, 47546, 50800, 50812, 50813, 50665, 50803, 50815, 50816, 
50668, 50654, 50801, 50814, 50667
30314, 47542, 47586, 47590, 47546, 47543, 47587, 47591, 47547, 50803, 50815, 50816, 50668, 50806, 50818, 50819, 
50671, 50657, 50804, 50817, 50670
30315, 47543, 47587, 47591, 47547, 18211, 18222, 18223, 18212, 50806, 50818, 50819, 50671, 0, 0, 0, 
0, 50660, 50807, 50820, 50673
30316, 2677, 2688, 2689, 2678, 47544, 47588, 47592, 47548, 0, 0, 0, 0, 50810, 50822, 50823, 
50675, 50661, 50808, 50821, 50674
30317, 47544, 47588, 47592, 47548, 47545, 47589, 47593, 47549, 50810, 50822, 50823, 50675, 50813, 50825, 50826, 
50678, 50664, 50811, 50824, 50677
30318, 47545, 47589, 47593, 47549, 47546, 47590, 47594, 47550, 50813, 50825, 50826, 50678, 50816, 50828, 50829, 
50681, 50667, 50814, 50827, 50680
30319, 47546, 47590, 47594, 47550, 47547, 47591, 47595, 47551, 50816, 50828, 50829, 50681, 50819, 50831, 50832, 
50684, 50670, 50817, 50830, 50683
30320, 47547, 47591, 47595, 47551, 18212, 18223, 18224, 18213, 50819, 50831, 50832, 50684, 0, 0, 0, 
0, 50673, 50820, 50833, 50686
30321, 2678, 2689, 2690, 2679, 47548, 47592, 47596, 47552, 0, 0, 0, 0, 50823, 50835, 50836, 
50688, 50674, 50821, 50834, 50687
30322, 47548, 47592, 47596, 47552, 47549, 47593, 47597, 47553, 50823, 50835, 50836, 50688, 50826, 50838, 50839, 
50691, 50677, 50824, 50837, 50690
30323, 47549, 47593, 47597, 47553, 47550, 47594, 47598, 47554, 50826, 50838, 50839, 50691, 50829, 50841, 50842, 
50694, 50680, 50827, 50840, 50693
30324, 47550, 47594, 47598, 47554, 47551, 47595, 47599, 47555, 50829, 50841, 50842, 50694, 50832, 50844, 50845, 
50697, 50683, 50830, 50843, 50696
30325, 47551, 47595, 47599, 47555, 18213, 18224, 18225, 18214, 50832, 50844, 50845, 50697, 0, 0, 0, 
0, 50686, 50833, 50846, 50699
30326, 2679, 2690, 2691, 2680, 47552, 47596, 47600, 47556, 0, 0, 0, 0, 50836, 50848, 50849, 
50701, 50687, 50834, 50847, 50700
30327, 47552, 47596, 47600, 47556, 47553, 47597, 47601, 47557, 50836, 50848, 50849, 50701, 50839, 50851, 50852, 
50704, 50690, 50837, 50850, 50703
30328, 47553, 47597, 47601, 47557, 47554, 47598, 47602, 47558, 50839, 50851, 50852, 50704, 50842, 50854, 50855, 
50707, 50693, 50840, 50853, 50706
30329, 47554, 47598, 47602, 47558, 47555, 47599, 47603, 47559, 50842, 50854, 50855, 50707, 50845, 50857, 50858, 
50710, 50696, 50843, 50856, 50709
30330, 47555, 47599, 47603, 47559, 18214, 18225, 18226, 18215, 50845, 50857, 50858, 50710, 0, 0, 0, 
0, 50699, 50846, 50859, 50712
30331, 2680, 2691, 2692, 2681, 47556, 47600, 47604, 47560, 0, 0, 0, 0, 50849, 50861, 50862, 
50714, 50700, 50847, 50860, 50713
30332, 47556, 47600, 47604, 47560, 47557, 47601, 47605, 47561, 50849, 50861, 50862, 50714, 50852, 50864, 50865, 
50717, 50703, 50850, 50863, 50716
30333, 47557, 47601, 47605, 47561, 47558, 47602, 47606, 47562, 50852, 50864, 50865, 50717, 50855, 50867, 50868, 
50720, 50706, 50853, 50866, 50719
30334, 47558, 47602, 47606, 47562, 47559, 47603, 47607, 47563, 50855, 50867, 50868, 50720, 50858, 50870, 50871, 
50723, 50709, 50856, 50869, 50722
30335, 47559, 47603, 47607, 47563, 18215, 18226, 18227, 18216, 50858, 50870, 50871, 50723, 0, 0, 0, 
0, 50712, 50859, 50872, 50725
30336, 2681, 2692, 2693, 2682, 47560, 47604, 47608, 47564, 0, 0, 0, 0, 50862, 50874, 50875, 
50727, 50713, 50860, 50873, 50726
30337, 47560, 47604, 47608, 47564, 47561, 47605, 47609, 47565, 50862, 50874, 50875, 50727, 50865, 50877, 50878, 
50730, 50716, 50863, 50876, 50729
30338, 47561, 47605, 47609, 47565, 47562, 47606, 47610, 47566, 50865, 50877, 50878, 50730, 50868, 50880, 50881, 
50733, 50719, 50866, 50879, 50732
30339, 47562, 47606, 47610, 47566, 47563, 47607, 47611, 47567, 50868, 50880, 50881, 50733, 50871, 50883, 50884, 
50736, 50722, 50869, 50882, 50735
30340, 47563, 47607, 47611, 47567, 18216, 18227, 18228, 18217, 50871, 50883, 50884, 50736, 0, 0, 0, 
0, 50725, 50872, 50885, 50738
30341, 2682, 2693, 194, 193, 47564, 47608, 17832, 17828, 0, 0, 0, 0, 50875, 50886, 0, 
50739, 50726, 50873, 0, 0
30342, 47564, 47608, 17832, 17828, 47565, 47609, 17833, 17829, 50875, 50886, 0, 50739, 50878, 50887, 0, 
50740, 50729, 50876, 0, 0
30343, 47565, 47609, 17833, 17829, 47566, 47610, 17834, 17830, 50878, 50887, 0, 50740, 50881, 50888, 0, 
50741, 50732, 50879, 0, 0
30344, 47566, 47610, 17834, 17830, 47567, 47611, 17835, 17831, 50881, 50888, 0, 50741, 50884, 50889, 0, 
50742, 50735, 50882, 0, 0
30345, 47567, 47611, 17835, 17831, 18217, 18228, 2253, 2252, 50884, 50889, 0, 50742, 0, 0, 0, 
0, 50738, 50885, 0, 0
30346, 171, 172, 2694, 2683, 17382, 17386, 47612, 47568, 0, 0, 0, 0, 17589, 50891, 50892, 
50744, 17579, 17588, 50890, 50743
30347, 17382, 17386, 47612, 47568, 17383, 17387, 47613, 47569, 17589, 50891, 50892, 50744, 17591, 50894, 50895, 
50747, 17581, 17590, 50893, 50746
30348, 17383, 17387, 47613, 47569, 17384, 17388, 47614, 47570, 17591, 50894, 50895, 50747, 17593, 50897, 50898, 
50750, 17583, 17592, 50896, 50749
30349, 17384, 17388, 47614, 47570, 17385, 17389, 47615, 47571, 17593, 50897, 50898, 50750, 17595, 50900, 50901, 
50753, 17585, 17594, 50899, 50752
30350, 17385, 17389, 47615, 47571, 2211, 2212, 18229, 18218, 17595, 50900, 50901, 50753, 0, 0, 0, 
0, 17587, 17596, 50902, 50755
30351, 2683, 2694, 2695, 2684, 47568, 47612, 47616, 47572, 0, 0, 0, 0, 50892, 50904, 50905, 
50757, 50743, 50890, 50903, 50756
30352, 47568, 47612, 47616, 47572, 47569, 47613, 47617, 47573, 50892, 50904, 50905, 50757, 50895, 50907, 50908, 
50760, 50746, 50893, 50906, 50759
30353, 47569, 47613, 47617, 47573, 47570, 47614, 47618, 47574, 50895, 50907, 50908, 50760, 50898, 50910, 50911, 
50763, 50749, 50896, 50909, 50762
30354, 47570, 47614, 47618, 47574, 47571, 47615, 47619, 47575, 50898, 50910, 50911, 50763, 50901, 50913, 50914, 
50766, 50752, 50899, 50912, 50765
30355, 47571, 47615, 47619, 47575, 18218, 18229, 18230, 18219, 50901, 50913, 50914, 50766, 0, 0, 0, 
0, 50755, 50902, 50915, 50768
30356, 2684, 2695, 2696, 2685, 47572, 47616, 47620, 47576, 0, 0, 0, 0, 50905, 50917, 50918, 
50770, 50756, 50903, 50916, 50769
30357, 47572, 47616, 47620, 47576, 47573, 47617, 47621, 47577, 50905, 50917, 50918, 50770, 50908, 50920, 50921, 
50773, 50759, 50906, 50919, 50772
30358, 47573, 47617, 47621, 47577, 47574, 47618, 47622, 47578, 50908, 50920, 50921, 50773, 50911, 50923, 50924, 
50776, 50762, 50909, 50922, 50775
30359, 47574, 47618, 47622, 47578, 47575, 47619, 47623, 47579, 50911, 50923, 50924, 50776, 50914, 50926, 50927, 
50779, 50765, 50912, 50925, 50778
30360, 47575, 47619, 47623, 47579, 18219, 18230, 18231, 18220, 50914, 50926, 50927, 50779, 0, 0, 0, 
0, 50768, 50915, 50928, 50781
30361, 2685, 2696, 2697, 2686, 47576, 47620, 47624, 47580, 0, 0, 0, 0, 50918, 50930, 50931, 
50783, 50769, 50916, 50929, 50782
30362, 47576, 47620, 47624, 47580, 47577, 47621, 47625, 47581, 50918, 50930, 50931, 50783, 50921, 50933, 50934, 
50786, 50772, 50919, 50932, 50785
30363, 47577, 47621, 47625, 47581, 47578, 47622, 47626, 47582, 50921, 50933, 50934, 50786, 50924, 50936, 50937, 
50789, 50775, 50922, 50935, 50788
30364, 47578, 47622, 47626, 47582, 47579, 47623, 47627, 47583, 50924, 50936, 50937, 50789, 50927, 50939, 50940, 
50792, 50778, 50925, 50938, 50791
30365, 47579, 47623, 47627, 47583, 18220, 18231, 18232, 18221, 50927, 50939, 50940, 50792, 0, 0, 0, 
0, 50781, 50928, 50941, 50794
30366, 2686, 2697, 2698, 2687, 47580, 47624, 47628, 47584, 0, 0, 0, 0, 50931, 50943, 50944, 
50796, 50782, 50929, 50942, 50795
30367, 47580, 47624, 47628, 47584, 47581, 47625, 47629, 47585, 50931, 50943, 50944, 50796, 50934, 50946, 50947, 
50799, 50785, 50932, 50945, 50798
30368, 47581, 47625, 47629, 47585, 47582, 47626, 47630, 47586, 50934, 50946, 50947, 50799, 50937, 50949, 50950, 
50802, 50788, 50935, 50948, 50801
30369, 47582, 47626, 47630, 47586, 47583, 47627, 47631, 47587, 50937, 50949, 50950, 50802, 50940, 50952, 50953, 
50805, 50791, 50938, 50951, 50804
30370, 47583, 47627, 47631, 47587, 18221, 18232, 18233, 18222, 50940, 50952, 50953, 50805, 0, 0, 0, 
0, 50794, 50941, 50954, 50807
30371, 2687, 2698, 2699, 2688, 47584, 47628, 47632, 47588, 0, 0, 0, 0, 50944, 50956, 50957, 
50809, 50795, 50942, 50955, 50808
30372, 47584, 47628, 47632, 47588, 47585, 47629, 47633, 47589, 50944, 50956, 50957, 50809, 50947, 50959, 50960, 
50812, 50798, 50945, 50958, 50811
30373, 47585, 47629, 47633, 47589, 47586, 47630, 47634, 47590, 50947, 50959, 50960, 50812, 50950, 50962, 50963, 
50815, 50801, 50948, 50961, 50814
30374, 47586, 47630, 47634, 47590, 47587, 47631, 47635, 47591, 50950, 50962, 50963, 50815, 50953, 50965, 50966, 
50818, 50804, 50951, 50964, 50817
30375, 47587, 47631, 47635, 47591, 18222, 18233, 18234, 18223, 50953, 50965, 50966, 50818, 0, 0, 0, 
0, 50807, 50954, 50967, 50820
30376, 2688, 2699, 2700, 2689, 47588, 47632, 47636, 47592, 0, 0, 0, 0, 50957, 50969, 50970, 
50822, 50808, 50955, 50968, 50821
30377, 47588, 47632, 47636, 47592, 47589, 47633, 47637, 47593, 50957, 50969, 50970, 50822, 50960, 50972, 50973, 
50825, 50811, 50958, 50971, 50824
30378, 47589, 47633, 47637, 47593, 47590, 47634, 47638, 47594, 50960, 50972, 50973, 50825, 50963, 50975, 50976, 
50828, 50814, 50961, 50974, 50827
30379, 47590, 47634, 47638, 47594, 47591, 47635, 47639, 47595, 50963, 50975, 50976, 50828, 50966, 50978, 50979, 
50831, 50817, 50964, 50977, 50830
30380, 47591, 47635, 47639, 47595, 18223, 18234, 18235, 18224, 50966, 50978, 50979, 50831, 0, 0, 0, 
0, 50820, 50967, 50980, 50833
30381, 2689, 2700, 2701, 2690, 47592, 47636, 47640, 47596, 0, 0, 0, 0, 50970, 50982, 50983, 
50835, 50821, 50968, 50981, 50834
30382, 47592, 47636, 47640, 47596, 47593, 47637, 47641, 47597, 50970, 50982, 50983, 50835, 50973, 50985, 50986, 
50838, 50824, 50971, 50984, 50837
30383, 47593, 47637, 47641, 47597, 47594, 47638, 47642, 47598, 50973, 50985, 50986, 50838, 50976, 50988, 50989, 
50841, 50827, 50974, 50987, 50840
30384, 47594, 47638, 47642, 47598, 47595, 47639, 47643, 47599, 50976, 50988, 50989, 50841, 50979, 50991, 50992, 
50844, 50830, 50977, 50990, 50843
30385, 47595, 47639, 47643, 47599, 18224, 18235, 18236, 18225, 50979, 50991, 50992, 50844, 0, 0, 0, 
0, 50833, 50980, 50993, 50846
30386, 2690, 2701, 2702, 2691, 47596, 47640, 47644, 47600, 0, 0, 0, 0, 50983, 50995, 50996, 
50848, 50834, 50981, 50994, 50847
30387, 47596, 47640, 47644, 47600, 47597, 47641, 47645, 47601, 50983, 50995, 50996, 50848, 50986, 50998, 50999, 
50851, 50837, 50984, 50997, 50850
30388, 47597, 47641, 47645, 47601, 47598, 47642, 47646, 47602, 50986, 50998, 50999, 50851, 50989, 51001, 51002, 
50854, 50840, 50987, 51000, 50853
30389, 47598, 47642, 47646, 47602, 47599, 47643, 47647, 47603, 50989, 51001, 51002, 50854, 50992, 51004, 51005, 
50857, 50843, 50990, 51003, 50856
30390, 47599, 47643, 47647, 47603, 18225, 18236, 18237, 18226, 50992, 51004, 51005, 50857, 0, 0, 0, 
0, 50846, 50993, 51006, 50859
30391, 2691, 2702, 2703, 2692, 47600, 47644, 47648, 47604, 0, 0, 0, 0, 50996, 51008, 51009, 
50861, 50847, 50994, 51007, 50860
30392, 47600, 47644, 47648, 47604, 47601, 47645, 47649, 47605, 50996, 51008, 51009, 50861, 50999, 51011, 51012, 
50864, 50850, 50997, 51010, 50863
30393, 47601, 47645, 47649, 47605, 47602, 47646, 47650, 47606, 50999, 51011, 51012, 50864, 51002, 51014, 51015, 
50867, 50853, 51000, 51013, 50866
30394, 47602, 47646, 47650, 47606, 47603, 47647, 47651, 47607, 51002, 51014, 51015, 50867, 51005, 51017, 51018, 
50870, 50856, 51003, 51016, 50869
30395, 47603, 47647, 47651, 47607, 18226, 18237, 18238, 18227, 51005, 51017, 51018, 50870, 0, 0, 0, 
0, 50859, 51006, 51019, 50872
30396, 2692, 2703, 2704, 2693, 47604, 47648, 47652, 47608, 0, 0, 0, 0, 51009, 51021, 51022, 
50874, 50860, 51007, 51020, 50873
30397, 47604, 47648, 47652, 47608, 47605, 47649, 47653, 47609, 51009, 51021, 51022, 50874, 51012, 51024, 51025, 
50877, 50863, 51010, 51023, 50876
30398, 47605, 47649, 47653, 47609, 47606, 47650, 47654, 47610, 51012, 51024, 51025, 50877, 51015, 51027, 51028, 
50880, 50866, 51013, 51026, 50879
30399, 47606, 47650, 47654, 47610, 47607, 47651, 47655, 47611, 51015, 51027, 51028, 50880, 51018, 51030, 51031, 
50883, 50869, 51016, 51029, 50882
30400, 47607, 47651, 47655, 47611, 18227, 18238, 18239, 18228, 51018, 51030, 51031, 50883, 0, 0, 0, 
0, 50872, 51019, 51032, 50885
30401, 2693, 2704, 195, 194, 47608, 47652, 17836, 17832, 0, 0, 0, 0, 51022, 51033, 0, 
50886, 50873, 51020, 0, 0
30402, 47608, 47652, 17836, 17832, 47609, 47653, 17837, 17833, 51022, 51033, 0, 50886, 51025, 51034, 0, 
50887, 50876, 51023, 0, 0
30403, 47609, 47653, 17837, 17833, 47610, 47654, 17838, 17834, 51025, 51034, 0, 50887, 51028, 51035, 0, 
50888, 50879, 51026, 0, 0
30404, 47610, 47654, 17838, 17834, 47611, 47655, 17839, 17835, 51028, 51035, 0, 50888, 51031, 51036, 0, 
50889, 50882, 51029, 0, 0
30405, 47611, 47655, 17839, 17835, 18228, 18239, 2254, 2253, 51031, 51036, 0, 50889, 0, 0, 0, 
0, 50885, 51032, 0, 0
30406, 172, 6, 124, 2694, 17386, 2172, 17601, 47612, 0, 0, 0, 0, 17597, 17646, 51037, 
50891, 17588, 2176, 17645, 50890
30407, 17386, 2172, 17601, 47612, 17387, 2173, 17602, 47613, 17597, 17646, 51037, 50891, 17598, 17648, 51038, 
50894, 17590, 2177, 17647, 50893
30408, 17387, 2173, 17602, 47613, 17388, 2174, 17603, 47614, 17598, 17648, 51038, 50894, 17599, 17650, 51039, 
50897, 17592, 2178, 17649, 50896
30409, 17388, 2174, 17603, 47614, 17389, 2175, 17604, 47615, 17599, 17650, 51039, 50897, 17600, 17652, 51040, 
50900, 17594, 2179, 17651, 50899
30410, 17389, 2175, 17604, 47615, 2212, 85, 2217, 18229, 17600, 17652, 51040, 50900, 0, 0, 0, 
0, 17596, 2180, 17653, 50902
30411, 2694, 124, 125, 2695, 47612, 17601, 17605, 47616, 0, 0, 0, 0, 51037, 17655, 51041, 
50904, 50890, 17645, 17654, 50903
30412, 47612, 17601, 17605, 47616, 47613, 17602, 17606, 47617, 51037, 17655, 51041, 50904, 51038, 17657, 51042, 
50907, 50893, 17647, 17656, 50906
30413, 47613, 17602, 17606, 47617, 47614, 17603, 17607, 47618, 51038, 17657, 51042, 50907, 51039, 17659, 51043, 
50910, 50896, 17649, 17658, 50909
30414, 47614, 17603, 17607, 47618, 47615, 17604, 17608, 47619, 51039, 17659, 51043, 50910, 51040, 17661, 51044, 
50913, 50899, 17651, 17660, 50912
30415, 47615, 17604, 17608, 47619, 18229, 2217, 2218, 18230, 51040, 17661, 51044, 50913, 0, 0, 0, 
0, 50902, 17653, 17662, 50915
30416, 2695, 125, 126, 2696, 47616, 17605, 17609, 47620, 0, 0, 0, 0, 51041, 17664, 51045, 
50917, 50903, 17654, 17663, 50916
30417, 47616, 17605, 17609, 47620, 47617, 17606, 17610, 47621, 51041, 17664, 51045, 50917, 51042, 17666, 51046, 
50920, 50906, 17656, 17665, 50919
30418, 47617, 17606, 17610, 47621, 47618, 17607, 17611, 47622, 51042, 17666, 51046, 50920, 51043, 17668, 51047, 
50923, 50909, 17658, 17667, 50922
30419, 47618, 17607, 17611, 47622, 47619, 17608, 17612, 47623, 51043, 17668, 51047, 50923, 51044, 17670, 51048, 
50926, 50912, 17660, 17669, 50925
30420, 47619, 17608, 17612, 47623, 18230, 2218, 2219, 18231, 51044, 17670, 51048, 50926, 0, 0, 0, 
0, 50915, 17662, 17671, 50928
30421, 2696, 126, 127, 2697, 47620, 17609, 17613, 47624, 0, 0, 0, 0, 51045, 17673, 51049, 
50930, 50916, 17663, 17672, 50929
30422, 47620, 17609, 17613, 47624, 47621, 17610, 17614, 47625, 51045, 17673, 51049, 50930, 51046, 17675, 51050, 
50933, 50919, 17665, 17674, 50932
30423, 47621, 17610, 17614, 47625, 47622, 17611, 17615, 47626, 51046, 17675, 51050, 50933, 51047, 17677, 51051, 
50936, 50922, 17667, 17676, 50935
30424, 47622, 17611, 17615, 47626, 47623, 17612, 17616, 47627, 51047, 17677, 51051, 50936, 51048, 17679, 51052, 
50939, 50925, 17669, 17678, 50938
30425, 47623, 17612, 17616, 47627, 18231, 2219, 2220, 18232, 51048, 17679, 51052, 50939, 0, 0, 0, 
0, 50928, 17671, 17680, 50941
30426, 2697, 127, 128, 2698, 47624, 17613, 17617, 47628, 0, 0, 0, 0, 51049, 17682, 51053, 
50943, 50929, 17672, 17681, 50942
30427, 47624, 17613, 17617, 47628, 47625, 17614, 17618, 47629, 51049, 17682, 51053, 50943, 51050, 17684, 51054, 
50946, 50932, 17674, 17683, 50945
30428, 47625, 17614, 17618, 47629, 47626, 17615, 17619, 47630, 51050, 17684, 51054, 50946, 51051, 17686, 51055, 
50949, 50935, 17676, 17685, 50948
30429, 47626, 17615, 17619, 47630, 47627, 17616, 17620, 47631, 51051, 17686, 51055, 50949, 51052, 17688, 51056, 
50952, 50938, 17678, 17687, 50951
30430, 47627, 17616, 17620, 47631, 18232, 2220, 2221, 18233, 51052, 17688, 51056, 50952, 0, 0, 0, 
0, 50941, 17680, 17689, 50954
30431, 2698, 128, 129, 2699, 47628, 17617, 17621, 47632, 0, 0, 0, 0, 51053, 17691, 51057, 
50956, 50942, 17681, 17690, 50955
30432, 47628, 17617, 17621, 47632, 47629, 17618, 17622, 47633, 51053, 17691, 51057, 50956, 51054, 17693, 51058, 
50959, 50945, 17683, 17692, 50958
30433, 47629, 17618, 17622, 47633, 47630, 17619, 17623, 47634, 51054, 17693, 51058, 50959, 51055, 17695, 51059, 
50962, 50948, 17685, 17694, 50961
30434, 47630, 17619, 17623, 47634, 47631, 17620, 17624, 47635, 51055, 17695, 51059, 50962, 51056, 17697, 51060, 
50965, 50951, 17687, 17696, 50964
30435, 47631, 17620, 17624, 47635, 18233, 2221, 2222, 18234, 51056, 17697, 51060, 50965, 0, 0, 0, 
0, 50954, 17689, 17698, 50967
30436, 2699, 129, 130, 2700, 47632, 17621, 17625, 47636, 0, 0, 0, 0, 51057, 17700, 51061, 
50969, 50955, 17690, 17699, 50968
30437, 47632, 17621, 17625, 47636, 47633, 17622, 17626, 47637, 51057, 17700, 51061, 50969, 51058, 17702, 51062, 
50972, 50958, 17692, 17701, 50971
30438, 47633, 17622, 17626, 47637, 47634, 17623, 17627, 47638, 51058, 17702, 51062, 50972, 51059, 17704, 51063, 
50975, 50961, 17694, 17703, 50974
30439, 47634, 17623, 17627, 47638, 47635, 17624, 17628, 47639, 51059, 17704, 51063, 50975, 51060, 17706, 51064, 
50978, 50964, 17696, 17705, 50977
30440, 47635, 17624, 17628, 47639, 18234, 2222, 2223, 18235, 51060, 17706, 51064, 50978, 0, 0, 0, 
0, 50967, 17698, 17707, 50980
30441, 2700, 130, 131, 2701, 47636, 17625, 17629, 47640, 0, 0, 0, 0, 51061, 17709, 51065, 
50982, 50968, 17699, 17708, 50981
30442, 47636, 17625, 17629, 47640, 47637, 17626, 17630, 47641, 51061, 17709, 51065, 50982, 51062, 17711, 51066, 
50985, 50971, 17701, 17710, 50984
30443, 47637, 17626, 17630, 47641, 47638, 17627, 17631, 47642, 51062, 17711, 51066, 50985, 51063, 17713, 51067, 
50988, 50974, 17703, 17712, 50987
30444, 47638, 17627, 17631, 47642, 47639, 17628, 17632, 47643, 51063, 17713, 51067, 50988, 51064, 17715, 51068, 
50991, 50977, 17705, 17714, 50990
30445, 47639, 17628, 17632, 47643, 18235, 2223, 2224, 18236, 51064, 17715, 51068, 50991, 0, 0, 0, 
0, 50980, 17707, 17716, 50993
30446, 2701, 131, 132, 2702, 47640, 17629, 17633, 47644, 0, 0, 0, 0, 51065, 17718, 51069, 
50995, 50981, 17708, 17717, 50994
30447, 47640, 17629, 17633, 47644, 47641, 17630, 17634, 47645, 51065, 17718, 51069, 50995, 51066, 17720, 51070, 
50998, 50984, 17710, 17719, 50997
30448, 47641, 17630, 17634, 47645, 47642, 17631, 17635, 47646, 51066, 17720, 51070, 50998, 51067, 17722, 51071, 
51001, 50987, 17712, 17721, 51000
30449, 47642, 17631, 17635, 47646, 47643, 17632, 17636, 47647, 51067, 17722, 51071, 51001, 51068, 17724, 51072, 
51004, 50990, 17714, 17723, 51003
30450, 47643, 17632, 17636, 47647, 18236, 2224, 2225, 18237, 51068, 17724, 51072, 51004, 0, 0, 0, 
0, 50993, 17716, 17725, 51006
30451, 2702, 132, 133, 2703, 47644, 17633, 17637, 47648, 0, 0, 0, 0, 51069, 17727, 51073, 
51008, 50994, 17717, 17726, 51007
30452, 47644, 17633, 17637, 47648, 47645, 17634, 17638, 47649, 51069, 17727, 51073, 51008, 51070, 17729, 51074, 
51011, 50997, 17719, 17728, 51010
30453, 47645, 17634, 17638, 47649, 47646, 17635, 17639, 47650, 51070, 17729, 51074, 51011, 51071, 17731, 51075, 
51014, 51000, 17721, 17730, 51013
30454, 47646, 17635, 17639, 47650, 47647, 17636, 17640, 47651, 51071, 17731, 51075, 51014, 51072, 17733, 51076, 
51017, 51003, 17723, 17732, 51016
30455, 47647, 17636, 17640, 47651, 18237, 2225, 2226, 18238, 51072, 17733, 51076, 51017, 0, 0, 0, 
0, 51006, 17725, 17734, 51019
30456, 2703, 133, 134, 2704, 47648, 17637, 17641, 47652, 0, 0, 0, 0, 51073, 17736, 51077, 
51021, 51007, 17726, 17735, 51020
30457, 47648, 17637, 17641, 47652, 47649, 17638, 17642, 47653, 51073, 17736, 51077, 51021, 51074, 17738, 51078, 
51024, 51010, 17728, 17737, 51023
30458, 47649, 17638, 17642, 47653, 47650, 17639, 17643, 47654, 51074, 17738, 51078, 51024, 51075, 17740, 51079, 
51027, 51013, 17730, 17739, 51026
30459, 47650, 17639, 17643, 47654, 47651, 17640, 17644, 47655, 51075, 17740, 51079, 51027, 51076, 17742, 51080, 
51030, 51016, 17732, 17741, 51029
30460, 47651, 17640, 17644, 47655, 18238, 2226, 2227, 18239, 51076, 17742, 51080, 51030, 0, 0, 0, 
0, 51019, 17734, 17743, 51032
30461, 2704, 134, 5, 195, 47652, 17641, 2213, 17836, 0, 0, 0, 0, 51077, 17744, 0, 
51033, 51020, 17735, 0, 0
30462, 47652, 17641, 2213, 17836, 47653, 17642, 2214, 17837, 51077, 17744, 0, 51033, 51078, 17745, 0, 
51034, 51023, 17737, 0, 0
30463, 47653, 17642, 2214, 17837, 47654, 17643, 2215, 17838, 51078, 17745, 0, 51034, 51079, 17746, 0, 
51035, 51026, 17739, 0, 0
30464, 47654, 17643, 2215, 17838, 47655, 17644, 2216, 17839, 51079, 17746, 0, 51035, 51080, 17747, 0, 
51036, 51029, 17741, 0, 0
30465, 47655, 17644, 2216, 17839, 18239, 2227, 87, 2254, 51080, 17747, 0, 51036, 0, 0, 0, 
0, 51032, 17743, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume24
30466, 2, 98, 1228, 54, 2181, 17840, 18244, 2270, 97, 0, 0, 0, 17884, 51081, 18288, 
18240, 2185, 17885, 18289, 2274
30467, 2181, 17840, 18244, 2270, 2182, 17841, 18245, 2271, 17884, 51081, 18288, 18240, 17886, 51082, 18290, 
18241, 2186, 17887, 18291, 2275
30468, 2182, 17841, 18245, 2271, 2183, 17842, 18246, 2272, 17886, 51082, 18290, 18241, 17888, 51083, 18292, 
18242, 2187, 17889, 18293, 2276
30469, 2183, 17842, 18246, 2272, 2184, 17843, 18247, 2273, 17888, 51083, 18292, 18242, 17890, 51084, 18294, 
18243, 2188, 17891, 18295, 2277
30470, 2184, 17843, 18247, 2273, 86, 2255, 2279, 90, 17890, 51084, 18294, 18243, 0, 0, 0, 
0, 2189, 17892, 18296, 2278
30471, 98, 99, 1229, 1228, 17840, 17844, 18248, 18244, 0, 0, 0, 0, 17893, 51085, 18297, 
51081, 17885, 17894, 18298, 18289
30472, 17840, 17844, 18248, 18244, 17841, 17845, 18249, 18245, 17893, 51085, 18297, 51081, 17895, 51086, 18299, 
51082, 17887, 17896, 18300, 18291
30473, 17841, 17845, 18249, 18245, 17842, 17846, 18250, 18246, 17895, 51086, 18299, 51082, 17897, 51087, 18301, 
51083, 17889, 17898, 18302, 18293
30474, 17842, 17846, 18250, 18246, 17843, 17847, 18251, 18247, 17897, 51087, 18301, 51083, 17899, 51088, 18303, 
51084, 17891, 17900, 18304, 18295
30475, 17843, 17847, 18251, 18247, 2255, 2256, 2280, 2279, 17899, 51088, 18303, 51084, 0, 0, 0, 
0, 17892, 17901, 18305, 18296
30476, 99, 100, 1230, 1229, 17844, 17848, 18252, 18248, 0, 0, 0, 0, 17902, 51089, 18306, 
51085, 17894, 17903, 18307, 18298
30477, 17844, 17848, 18252, 18248, 17845, 17849, 18253, 18249, 17902, 51089, 18306, 51085, 17904, 51090, 18308, 
51086, 17896, 17905, 18309, 18300
30478, 17845, 17849, 18253, 18249, 17846, 17850, 18254, 18250, 17904, 51090, 18308, 51086, 17906, 51091, 18310, 
51087, 17898, 17907, 18311, 18302
30479, 17846, 17850, 18254, 18250, 17847, 17851, 18255, 18251, 17906, 51091, 18310, 51087, 17908, 51092, 18312, 
51088, 17900, 17909, 18313, 18304
30480, 17847, 17851, 18255, 18251, 2256, 2257, 2281, 2280, 17908, 51092, 18312, 51088, 0, 0, 0, 
0, 17901, 17910, 18314, 18305
30481, 100, 101, 1231, 1230, 17848, 17852, 18256, 18252, 0, 0, 0, 0, 17911, 51093, 18315, 
51089, 17903, 17912, 18316, 18307
30482, 17848, 17852, 18256, 18252, 17849, 17853, 18257, 18253, 17911, 51093, 18315, 51089, 17913, 51094, 18317, 
51090, 17905, 17914, 18318, 18309
30483, 17849, 17853, 18257, 18253, 17850, 17854, 18258, 18254, 17913, 51094, 18317, 51090, 17915, 51095, 18319, 
51091, 17907, 17916, 18320, 18311
30484, 17850, 17854, 18258, 18254, 17851, 17855, 18259, 18255, 17915, 51095, 18319, 51091, 17917, 51096, 18321, 
51092, 17909, 17918, 18322, 18313
30485, 17851, 17855, 18259, 18255, 2257, 2258, 2282, 2281, 17917, 51096, 18321, 51092, 0, 0, 0, 
0, 17910, 17919, 18323, 18314
30486, 101, 102, 1232, 1231, 17852, 17856, 18260, 18256, 0, 0, 0, 0, 17920, 51097, 18324, 
51093, 17912, 17921, 18325, 18316
30487, 17852, 17856, 18260, 18256, 17853, 17857, 18261, 18257, 17920, 51097, 18324, 51093, 17922, 51098, 18326, 
51094, 17914, 17923, 18327, 18318
30488, 17853, 17857, 18261, 18257, 17854, 17858, 18262, 18258, 17922, 51098, 18326, 51094, 17924, 51099, 18328, 
51095, 17916, 17925, 18329, 18320
30489, 17854, 17858, 18262, 18258, 17855, 17859, 18263, 18259, 17924, 51099, 18328, 51095, 17926, 51100, 18330, 
51096, 17918, 17927, 18331, 18322
30490, 17855, 17859, 18263, 18259, 2258, 2259, 2283, 2282, 17926, 51100, 18330, 51096, 0, 0, 0, 
0, 17919, 17928, 18332, 18323
30491, 102, 103, 1233, 1232, 17856, 17860, 18264, 18260, 0, 0, 0, 0, 17929, 51101, 18333, 
51097, 17921, 17930, 18334, 18325
30492, 17856, 17860, 18264, 18260, 17857, 17861, 18265, 18261, 17929, 51101, 18333, 51097, 17931, 51102, 18335, 
51098, 17923, 17932, 18336, 18327
30493, 17857, 17861, 18265, 18261, 17858, 17862, 18266, 18262, 17931, 51102, 18335, 51098, 17933, 51103, 18337, 
51099, 17925, 17934, 18338, 18329
30494, 17858, 17862, 18266, 18262, 17859, 17863, 18267, 18263, 17933, 51103, 18337, 51099, 17935, 51104, 18339, 
51100, 17927, 17936, 18340, 18331
30495, 17859, 17863, 18267, 18263, 2259, 2260, 2284, 2283, 17935, 51104, 18339, 51100, 0, 0, 0, 
0, 17928, 17937, 18341, 18332
30496, 103, 104, 1234, 1233, 17860, 17864, 18268, 18264, 0, 0, 0, 0, 17938, 51105, 18342, 
51101, 17930, 17939, 18343, 18334
30497, 17860, 17864, 18268, 18264, 17861, 17865, 18269, 18265, 17938, 51105, 18342, 51101, 17940, 51106, 18344, 
51102, 17932, 17941, 18345, 18336
30498, 17861, 17865, 18269, 18265, 17862, 17866, 18270, 18266, 17940, 51106, 18344, 51102, 17942, 51107, 18346, 
51103, 17934, 17943, 18347, 18338
30499, 17862, 17866, 18270, 18266, 17863, 17867, 18271, 18267, 17942, 51107, 18346, 51103, 17944, 51108, 18348, 
51104, 17936, 17945, 18349, 18340
30500, 17863, 17867, 18271, 18267, 2260, 2261, 2285, 2284, 17944, 51108, 18348, 51104, 0, 0, 0, 
0, 17937, 17946, 18350, 18341
30501, 104, 105, 1235, 1234, 17864, 17868, 18272, 18268, 0, 0, 0, 0, 17947, 51109, 18351, 
51105, 17939, 17948, 18352, 18343
30502, 17864, 17868, 18272, 18268, 17865, 17869, 18273, 18269, 17947, 51109, 18351, 51105, 17949, 51110, 18353, 
51106, 17941, 17950, 18354, 18345
30503, 17865, 17869, 18273, 18269, 17866, 17870, 18274, 18270, 17949, 51110, 18353, 51106, 17951, 51111, 18355, 
51107, 17943, 17952, 18356, 18347
30504, 17866, 17870, 18274, 18270, 17867, 17871, 18275, 18271, 17951, 51111, 18355, 51107, 17953, 51112, 18357, 
51108, 17945, 17954, 18358, 18349
30505, 17867, 17871, 18275, 18271, 2261, 2262, 2286, 2285, 17953, 51112, 18357, 51108, 0, 0, 0, 
0, 17946, 17955, 18359, 18350
30506, 105, 106, 1236, 1235, 17868, 17872, 18276, 18272, 0, 0, 0, 0, 17956, 51113, 18360, 
51109, 17948, 17957, 18361, 18352
30507, 17868, 17872, 18276, 18272, 17869, 17873, 18277, 18273, 17956, 51113, 18360, 51109, 17958, 51114, 18362, 
51110, 17950, 17959, 18363, 18354
30508, 17869, 17873, 18277, 18273, 17870, 17874, 18278, 18274, 17958, 51114, 18362, 51110, 17960, 51115, 18364, 
51111, 17952, 17961, 18365, 18356
30509, 17870, 17874, 18278, 18274, 17871, 17875, 18279, 18275, 17960, 51115, 18364, 51111, 17962, 51116, 18366, 
51112, 17954, 17963, 18367, 18358
30510, 17871, 17875, 18279, 18275, 2262, 2263, 2287, 2286, 17962, 51116, 18366, 51112, 0, 0, 0, 
0, 17955, 17964, 18368, 18359
30511, 106, 107, 1237, 1236, 17872, 17876, 18280, 18276, 0, 0, 0, 0, 17965, 51117, 18369, 
51113, 17957, 17966, 18370, 18361
30512, 17872, 17876, 18280, 18276, 17873, 17877, 18281, 18277, 17965, 51117, 18369, 51113, 17967, 51118, 18371, 
51114, 17959, 17968, 18372, 18363
30513, 17873, 17877, 18281, 18277, 17874, 17878, 18282, 18278, 17967, 51118, 18371, 51114, 17969, 51119, 18373, 
51115, 17961, 17970, 18374, 18365
30514, 17874, 17878, 18282, 18278, 17875, 17879, 18283, 18279, 17969, 51119, 18373, 51115, 17971, 51120, 18375, 
51116, 17963, 17972, 18376, 18367
30515, 17875, 17879, 18283, 18279, 2263, 2264, 2288, 2287, 17971, 51120, 18375, 51116, 0, 0, 0, 
0, 17964, 17973, 18377, 18368
30516, 107, 108, 1238, 1237, 17876, 17880, 18284, 18280, 0, 0, 0, 0, 17974, 51121, 18378, 
51117, 17966, 17975, 18379, 18370
30517, 17876, 17880, 18284, 18280, 17877, 17881, 18285, 18281, 17974, 51121, 18378, 51117, 17976, 51122, 18380, 
51118, 17968, 17977, 18381, 18372
30518, 17877, 17881, 18285, 18281, 17878, 17882, 18286, 18282, 17976, 51122, 18380, 51118, 17978, 51123, 18382, 
51119, 17970, 17979, 18383, 18374
30519, 17878, 17882, 18286, 18282, 17879, 17883, 18287, 18283, 17978, 51123, 18382, 51119, 17980, 51124, 18384, 
51120, 17972, 17981, 18385, 18376
30520, 17879, 17883, 18287, 18283, 2264, 2265, 2289, 2288, 17980, 51124, 18384, 51120, 0, 0, 0, 
0, 17973, 17982, 18386, 18377
30521, 108, 1, 53, 1238, 17880, 2228, 2266, 18284, 0, 0, 0, 0, 17983, 0, 18387, 
51121, 17975, 0, 0, 18379
30522, 17880, 2228, 2266, 18284, 17881, 2229, 2267, 18285, 17983, 0, 18387, 51121, 17984, 0, 18388, 
51122, 17977, 0, 0, 18381
30523, 17881, 2229, 2267, 18285, 17882, 2230, 2268, 18286, 17984, 0, 18388, 51122, 17985, 0, 18389, 
51123, 17979, 0, 0, 18383
30524, 17882, 2230, 2268, 18286, 17883, 2231, 2269, 18287, 17985, 0, 18389, 51123, 17986, 0, 18390, 
51124, 17981, 0, 0, 18385
30525, 17883, 2231, 2269, 18287, 2265, 88, 89, 2289, 17986, 0, 18390, 51124, 0, 0, 0, 
0, 17982, 0, 0, 18386
*ELEMENT, type=C3D20, ELSET=Volume25
30526, 47, 1157, 9783, 1180, 2321, 18483, 51125, 18786, 0, 0, 0, 0, 18576, 52138, 52139, 
18830, 2325, 18575, 52137, 18831
30527, 2321, 18483, 51125, 18786, 2322, 18484, 51126, 18787, 18576, 52138, 52139, 18830, 18578, 52141, 52142, 
18832, 2326, 18577, 52140, 18833
30528, 2322, 18484, 51126, 18787, 2323, 18485, 51127, 18788, 18578, 52141, 52142, 18832, 18580, 52144, 52145, 
18834, 2327, 18579, 52143, 18835
30529, 2323, 18485, 51127, 18788, 2324, 18486, 51128, 18789, 18580, 52144, 52145, 18834, 18582, 52147, 52148, 
18836, 2328, 18581, 52146, 18837
30530, 2324, 18486, 51128, 18789, 93, 2339, 19080, 2362, 18582, 52147, 52148, 18836, 0, 0, 0, 
0, 2329, 18583, 52149, 18838
30531, 1157, 1158, 9784, 9783, 18483, 18487, 51129, 51125, 0, 0, 0, 0, 18585, 52151, 52152, 
52138, 18575, 18584, 52150, 52137
30532, 18483, 18487, 51129, 51125, 18484, 18488, 51130, 51126, 18585, 52151, 52152, 52138, 18587, 52154, 52155, 
52141, 18577, 18586, 52153, 52140
30533, 18484, 18488, 51130, 51126, 18485, 18489, 51131, 51127, 18587, 52154, 52155, 52141, 18589, 52157, 52158, 
52144, 18579, 18588, 52156, 52143
30534, 18485, 18489, 51131, 51127, 18486, 18490, 51132, 51128, 18589, 52157, 52158, 52144, 18591, 52160, 52161, 
52147, 18581, 18590, 52159, 52146
30535, 18486, 18490, 51132, 51128, 2339, 2340, 19081, 19080, 18591, 52160, 52161, 52147, 0, 0, 0, 
0, 18583, 18592, 52162, 52149
30536, 1158, 1159, 9785, 9784, 18487, 18491, 51133, 51129, 0, 0, 0, 0, 18594, 52164, 52165, 
52151, 18584, 18593, 52163, 52150
30537, 18487, 18491, 51133, 51129, 18488, 18492, 51134, 51130, 18594, 52164, 52165, 52151, 18596, 52167, 52168, 
52154, 18586, 18595, 52166, 52153
30538, 18488, 18492, 51134, 51130, 18489, 18493, 51135, 51131, 18596, 52167, 52168, 52154, 18598, 52170, 52171, 
52157, 18588, 18597, 52169, 52156
30539, 18489, 18493, 51135, 51131, 18490, 18494, 51136, 51132, 18598, 52170, 52171, 52157, 18600, 52173, 52174, 
52160, 18590, 18599, 52172, 52159
30540, 18490, 18494, 51136, 51132, 2340, 2341, 19082, 19081, 18600, 52173, 52174, 52160, 0, 0, 0, 
0, 18592, 18601, 52175, 52162
30541, 1159, 1160, 9786, 9785, 18491, 18495, 51137, 51133, 0, 0, 0, 0, 18603, 52177, 52178, 
52164, 18593, 18602, 52176, 52163
30542, 18491, 18495, 51137, 51133, 18492, 18496, 51138, 51134, 18603, 52177, 52178, 52164, 18605, 52180, 52181, 
52167, 18595, 18604, 52179, 52166
30543, 18492, 18496, 51138, 51134, 18493, 18497, 51139, 51135, 18605, 52180, 52181, 52167, 18607, 52183, 52184, 
52170, 18597, 18606, 52182, 52169
30544, 18493, 18497, 51139, 51135, 18494, 18498, 51140, 51136, 18607, 52183, 52184, 52170, 18609, 52186, 52187, 
52173, 18599, 18608, 52185, 52172
30545, 18494, 18498, 51140, 51136, 2341, 2342, 19083, 19082, 18609, 52186, 52187, 52173, 0, 0, 0, 
0, 18601, 18610, 52188, 52175
30546, 1160, 1161, 9787, 9786, 18495, 18499, 51141, 51137, 0, 0, 0, 0, 18612, 52190, 52191, 
52177, 18602, 18611, 52189, 52176
30547, 18495, 18499, 51141, 51137, 18496, 18500, 51142, 51138, 18612, 52190, 52191, 52177, 18614, 52193, 52194, 
52180, 18604, 18613, 52192, 52179
30548, 18496, 18500, 51142, 51138, 18497, 18501, 51143, 51139, 18614, 52193, 52194, 52180, 18616, 52196, 52197, 
52183, 18606, 18615, 52195, 52182
30549, 18497, 18501, 51143, 51139, 18498, 18502, 51144, 51140, 18616, 52196, 52197, 52183, 18618, 52199, 52200, 
52186, 18608, 18617, 52198, 52185
30550, 18498, 18502, 51144, 51140, 2342, 2343, 19084, 19083, 18618, 52199, 52200, 52186, 0, 0, 0, 
0, 18610, 18619, 52201, 52188
30551, 1161, 1162, 9788, 9787, 18499, 18503, 51145, 51141, 0, 0, 0, 0, 18621, 52203, 52204, 
52190, 18611, 18620, 52202, 52189
30552, 18499, 18503, 51145, 51141, 18500, 18504, 51146, 51142, 18621, 52203, 52204, 52190, 18623, 52206, 52207, 
52193, 18613, 18622, 52205, 52192
30553, 18500, 18504, 51146, 51142, 18501, 18505, 51147, 51143, 18623, 52206, 52207, 52193, 18625, 52209, 52210, 
52196, 18615, 18624, 52208, 52195
30554, 18501, 18505, 51147, 51143, 18502, 18506, 51148, 51144, 18625, 52209, 52210, 52196, 18627, 52212, 52213, 
52199, 18617, 18626, 52211, 52198
30555, 18502, 18506, 51148, 51144, 2343, 2344, 19085, 19084, 18627, 52212, 52213, 52199, 0, 0, 0, 
0, 18619, 18628, 52214, 52201
30556, 1162, 1163, 9789, 9788, 18503, 18507, 51149, 51145, 0, 0, 0, 0, 18630, 52216, 52217, 
52203, 18620, 18629, 52215, 52202
30557, 18503, 18507, 51149, 51145, 18504, 18508, 51150, 51146, 18630, 52216, 52217, 52203, 18632, 52219, 52220, 
52206, 18622, 18631, 52218, 52205
30558, 18504, 18508, 51150, 51146, 18505, 18509, 51151, 51147, 18632, 52219, 52220, 52206, 18634, 52222, 52223, 
52209, 18624, 18633, 52221, 52208
30559, 18505, 18509, 51151, 51147, 18506, 18510, 51152, 51148, 18634, 52222, 52223, 52209, 18636, 52225, 52226, 
52212, 18626, 18635, 52224, 52211
30560, 18506, 18510, 51152, 51148, 2344, 2345, 19086, 19085, 18636, 52225, 52226, 52212, 0, 0, 0, 
0, 18628, 18637, 52227, 52214
30561, 1163, 1164, 9790, 9789, 18507, 18511, 51153, 51149, 0, 0, 0, 0, 18639, 52229, 52230, 
52216, 18629, 18638, 52228, 52215
30562, 18507, 18511, 51153, 51149, 18508, 18512, 51154, 51150, 18639, 52229, 52230, 52216, 18641, 52232, 52233, 
52219, 18631, 18640, 52231, 52218
30563, 18508, 18512, 51154, 51150, 18509, 18513, 51155, 51151, 18641, 52232, 52233, 52219, 18643, 52235, 52236, 
52222, 18633, 18642, 52234, 52221
30564, 18509, 18513, 51155, 51151, 18510, 18514, 51156, 51152, 18643, 52235, 52236, 52222, 18645, 52238, 52239, 
52225, 18635, 18644, 52237, 52224
30565, 18510, 18514, 51156, 51152, 2345, 2346, 19087, 19086, 18645, 52238, 52239, 52225, 0, 0, 0, 
0, 18637, 18646, 52240, 52227
30566, 1164, 1165, 9791, 9790, 18511, 18515, 51157, 51153, 0, 0, 0, 0, 18648, 52242, 52243, 
52229, 18638, 18647, 52241, 52228
30567, 18511, 18515, 51157, 51153, 18512, 18516, 51158, 51154, 18648, 52242, 52243, 52229, 18650, 52245, 52246, 
52232, 18640, 18649, 52244, 52231
30568, 18512, 18516, 51158, 51154, 18513, 18517, 51159, 51155, 18650, 52245, 52246, 52232, 18652, 52248, 52249, 
52235, 18642, 18651, 52247, 52234
30569, 18513, 18517, 51159, 51155, 18514, 18518, 51160, 51156, 18652, 52248, 52249, 52235, 18654, 52251, 52252, 
52238, 18644, 18653, 52250, 52237
30570, 18514, 18518, 51160, 51156, 2346, 2347, 19088, 19087, 18654, 52251, 52252, 52238, 0, 0, 0, 
0, 18646, 18655, 52253, 52240
30571, 1165, 1166, 9792, 9791, 18515, 18519, 51161, 51157, 0, 0, 0, 0, 18657, 52255, 52256, 
52242, 18647, 18656, 52254, 52241
30572, 18515, 18519, 51161, 51157, 18516, 18520, 51162, 51158, 18657, 52255, 52256, 52242, 18659, 52258, 52259, 
52245, 18649, 18658, 52257, 52244
30573, 18516, 18520, 51162, 51158, 18517, 18521, 51163, 51159, 18659, 52258, 52259, 52245, 18661, 52261, 52262, 
52248, 18651, 18660, 52260, 52247
30574, 18517, 18521, 51163, 51159, 18518, 18522, 51164, 51160, 18661, 52261, 52262, 52248, 18663, 52264, 52265, 
52251, 18653, 18662, 52263, 52250
30575, 18518, 18522, 51164, 51160, 2347, 2348, 19089, 19088, 18663, 52264, 52265, 52251, 0, 0, 0, 
0, 18655, 18664, 52266, 52253
30576, 1166, 1167, 9793, 9792, 18519, 18523, 51165, 51161, 0, 0, 0, 0, 18666, 52268, 52269, 
52255, 18656, 18665, 52267, 52254
30577, 18519, 18523, 51165, 51161, 18520, 18524, 51166, 51162, 18666, 52268, 52269, 52255, 18668, 52271, 52272, 
52258, 18658, 18667, 52270, 52257
30578, 18520, 18524, 51166, 51162, 18521, 18525, 51167, 51163, 18668, 52271, 52272, 52258, 18670, 52274, 52275, 
52261, 18660, 18669, 52273, 52260
30579, 18521, 18525, 51167, 51163, 18522, 18526, 51168, 51164, 18670, 52274, 52275, 52261, 18672, 52277, 52278, 
52264, 18662, 18671, 52276, 52263
30580, 18522, 18526, 51168, 51164, 2348, 2349, 19090, 19089, 18672, 52277, 52278, 52264, 0, 0, 0, 
0, 18664, 18673, 52279, 52266
30581, 1167, 1168, 9794, 9793, 18523, 18527, 51169, 51165, 0, 0, 0, 0, 18675, 52281, 52282, 
52268, 18665, 18674, 52280, 52267
30582, 18523, 18527, 51169, 51165, 18524, 18528, 51170, 51166, 18675, 52281, 52282, 52268, 18677, 52284, 52285, 
52271, 18667, 18676, 52283, 52270
30583, 18524, 18528, 51170, 51166, 18525, 18529, 51171, 51167, 18677, 52284, 52285, 52271, 18679, 52287, 52288, 
52274, 18669, 18678, 52286, 52273
30584, 18525, 18529, 51171, 51167, 18526, 18530, 51172, 51168, 18679, 52287, 52288, 52274, 18681, 52290, 52291, 
52277, 18671, 18680, 52289, 52276
30585, 18526, 18530, 51172, 51168, 2349, 2350, 19091, 19090, 18681, 52290, 52291, 52277, 0, 0, 0, 
0, 18673, 18682, 52292, 52279
30586, 1168, 1169, 9795, 9794, 18527, 18531, 51173, 51169, 0, 0, 0, 0, 18684, 52294, 52295, 
52281, 18674, 18683, 52293, 52280
30587, 18527, 18531, 51173, 51169, 18528, 18532, 51174, 51170, 18684, 52294, 52295, 52281, 18686, 52297, 52298, 
52284, 18676, 18685, 52296, 52283
30588, 18528, 18532, 51174, 51170, 18529, 18533, 51175, 51171, 18686, 52297, 52298, 52284, 18688, 52300, 52301, 
52287, 18678, 18687, 52299, 52286
30589, 18529, 18533, 51175, 51171, 18530, 18534, 51176, 51172, 18688, 52300, 52301, 52287, 18690, 52303, 52304, 
52290, 18680, 18689, 52302, 52289
30590, 18530, 18534, 51176, 51172, 2350, 2351, 19092, 19091, 18690, 52303, 52304, 52290, 0, 0, 0, 
0, 18682, 18691, 52305, 52292
30591, 1169, 1170, 9796, 9795, 18531, 18535, 51177, 51173, 0, 0, 0, 0, 18693, 52307, 52308, 
52294, 18683, 18692, 52306, 52293
30592, 18531, 18535, 51177, 51173, 18532, 18536, 51178, 51174, 18693, 52307, 52308, 52294, 18695, 52310, 52311, 
52297, 18685, 18694, 52309, 52296
30593, 18532, 18536, 51178, 51174, 18533, 18537, 51179, 51175, 18695, 52310, 52311, 52297, 18697, 52313, 52314, 
52300, 18687, 18696, 52312, 52299
30594, 18533, 18537, 51179, 51175, 18534, 18538, 51180, 51176, 18697, 52313, 52314, 52300, 18699, 52316, 52317, 
52303, 18689, 18698, 52315, 52302
30595, 18534, 18538, 51180, 51176, 2351, 2352, 19093, 19092, 18699, 52316, 52317, 52303, 0, 0, 0, 
0, 18691, 18700, 52318, 52305
30596, 1170, 1171, 9797, 9796, 18535, 18539, 51181, 51177, 0, 0, 0, 0, 18702, 52320, 52321, 
52307, 18692, 18701, 52319, 52306
30597, 18535, 18539, 51181, 51177, 18536, 18540, 51182, 51178, 18702, 52320, 52321, 52307, 18704, 52323, 52324, 
52310, 18694, 18703, 52322, 52309
30598, 18536, 18540, 51182, 51178, 18537, 18541, 51183, 51179, 18704, 52323, 52324, 52310, 18706, 52326, 52327, 
52313, 18696, 18705, 52325, 52312
30599, 18537, 18541, 51183, 51179, 18538, 18542, 51184, 51180, 18706, 52326, 52327, 52313, 18708, 52329, 52330, 
52316, 18698, 18707, 52328, 52315
30600, 18538, 18542, 51184, 51180, 2352, 2353, 19094, 19093, 18708, 52329, 52330, 52316, 0, 0, 0, 
0, 18700, 18709, 52331, 52318
30601, 1171, 1172, 9798, 9797, 18539, 18543, 51185, 51181, 0, 0, 0, 0, 18711, 52333, 52334, 
52320, 18701, 18710, 52332, 52319
30602, 18539, 18543, 51185, 51181, 18540, 18544, 51186, 51182, 18711, 52333, 52334, 52320, 18713, 52336, 52337, 
52323, 18703, 18712, 52335, 52322
30603, 18540, 18544, 51186, 51182, 18541, 18545, 51187, 51183, 18713, 52336, 52337, 52323, 18715, 52339, 52340, 
52326, 18705, 18714, 52338, 52325
30604, 18541, 18545, 51187, 51183, 18542, 18546, 51188, 51184, 18715, 52339, 52340, 52326, 18717, 52342, 52343, 
52329, 18707, 18716, 52341, 52328
30605, 18542, 18546, 51188, 51184, 2353, 2354, 19095, 19094, 18717, 52342, 52343, 52329, 0, 0, 0, 
0, 18709, 18718, 52344, 52331
30606, 1172, 1173, 9799, 9798, 18543, 18547, 51189, 51185, 0, 0, 0, 0, 18720, 52346, 52347, 
52333, 18710, 18719, 52345, 52332
30607, 18543, 18547, 51189, 51185, 18544, 18548, 51190, 51186, 18720, 52346, 52347, 52333, 18722, 52349, 52350, 
52336, 18712, 18721, 52348, 52335
30608, 18544, 18548, 51190, 51186, 18545, 18549, 51191, 51187, 18722, 52349, 52350, 52336, 18724, 52352, 52353, 
52339, 18714, 18723, 52351, 52338
30609, 18545, 18549, 51191, 51187, 18546, 18550, 51192, 51188, 18724, 52352, 52353, 52339, 18726, 52355, 52356, 
52342, 18716, 18725, 52354, 52341
30610, 18546, 18550, 51192, 51188, 2354, 2355, 19096, 19095, 18726, 52355, 52356, 52342, 0, 0, 0, 
0, 18718, 18727, 52357, 52344
30611, 1173, 1174, 9800, 9799, 18547, 18551, 51193, 51189, 0, 0, 0, 0, 18729, 52359, 52360, 
52346, 18719, 18728, 52358, 52345
30612, 18547, 18551, 51193, 51189, 18548, 18552, 51194, 51190, 18729, 52359, 52360, 52346, 18731, 52362, 52363, 
52349, 18721, 18730, 52361, 52348
30613, 18548, 18552, 51194, 51190, 18549, 18553, 51195, 51191, 18731, 52362, 52363, 52349, 18733, 52365, 52366, 
52352, 18723, 18732, 52364, 52351
30614, 18549, 18553, 51195, 51191, 18550, 18554, 51196, 51192, 18733, 52365, 52366, 52352, 18735, 52368, 52369, 
52355, 18725, 18734, 52367, 52354
30615, 18550, 18554, 51196, 51192, 2355, 2356, 19097, 19096, 18735, 52368, 52369, 52355, 0, 0, 0, 
0, 18727, 18736, 52370, 52357
30616, 1174, 1175, 9801, 9800, 18551, 18555, 51197, 51193, 0, 0, 0, 0, 18738, 52372, 52373, 
52359, 18728, 18737, 52371, 52358
30617, 18551, 18555, 51197, 51193, 18552, 18556, 51198, 51194, 18738, 52372, 52373, 52359, 18740, 52375, 52376, 
52362, 18730, 18739, 52374, 52361
30618, 18552, 18556, 51198, 51194, 18553, 18557, 51199, 51195, 18740, 52375, 52376, 52362, 18742, 52378, 52379, 
52365, 18732, 18741, 52377, 52364
30619, 18553, 18557, 51199, 51195, 18554, 18558, 51200, 51196, 18742, 52378, 52379, 52365, 18744, 52381, 52382, 
52368, 18734, 18743, 52380, 52367
30620, 18554, 18558, 51200, 51196, 2356, 2357, 19098, 19097, 18744, 52381, 52382, 52368, 0, 0, 0, 
0, 18736, 18745, 52383, 52370
30621, 1175, 1176, 9802, 9801, 18555, 18559, 51201, 51197, 0, 0, 0, 0, 18747, 52385, 52386, 
52372, 18737, 18746, 52384, 52371
30622, 18555, 18559, 51201, 51197, 18556, 18560, 51202, 51198, 18747, 52385, 52386, 52372, 18749, 52388, 52389, 
52375, 18739, 18748, 52387, 52374
30623, 18556, 18560, 51202, 51198, 18557, 18561, 51203, 51199, 18749, 52388, 52389, 52375, 18751, 52391, 52392, 
52378, 18741, 18750, 52390, 52377
30624, 18557, 18561, 51203, 51199, 18558, 18562, 51204, 51200, 18751, 52391, 52392, 52378, 18753, 52394, 52395, 
52381, 18743, 18752, 52393, 52380
30625, 18558, 18562, 51204, 51200, 2357, 2358, 19099, 19098, 18753, 52394, 52395, 52381, 0, 0, 0, 
0, 18745, 18754, 52396, 52383
30626, 1176, 1177, 9803, 9802, 18559, 18563, 51205, 51201, 0, 0, 0, 0, 18756, 52398, 52399, 
52385, 18746, 18755, 52397, 52384
30627, 18559, 18563, 51205, 51201, 18560, 18564, 51206, 51202, 18756, 52398, 52399, 52385, 18758, 52401, 52402, 
52388, 18748, 18757, 52400, 52387
30628, 18560, 18564, 51206, 51202, 18561, 18565, 51207, 51203, 18758, 52401, 52402, 52388, 18760, 52404, 52405, 
52391, 18750, 18759, 52403, 52390
30629, 18561, 18565, 51207, 51203, 18562, 18566, 51208, 51204, 18760, 52404, 52405, 52391, 18762, 52407, 52408, 
52394, 18752, 18761, 52406, 52393
30630, 18562, 18566, 51208, 51204, 2358, 2359, 19100, 19099, 18762, 52407, 52408, 52394, 0, 0, 0, 
0, 18754, 18763, 52409, 52396
30631, 1177, 1178, 9804, 9803, 18563, 18567, 51209, 51205, 0, 0, 0, 0, 18765, 52411, 52412, 
52398, 18755, 18764, 52410, 52397
30632, 18563, 18567, 51209, 51205, 18564, 18568, 51210, 51206, 18765, 52411, 52412, 52398, 18767, 52414, 52415, 
52401, 18757, 18766, 52413, 52400
30633, 18564, 18568, 51210, 51206, 18565, 18569, 51211, 51207, 18767, 52414, 52415, 52401, 18769, 52417, 52418, 
52404, 18759, 18768, 52416, 52403
30634, 18565, 18569, 51211, 51207, 18566, 18570, 51212, 51208, 18769, 52417, 52418, 52404, 18771, 52420, 52421, 
52407, 18761, 18770, 52419, 52406
30635, 18566, 18570, 51212, 51208, 2359, 2360, 19101, 19100, 18771, 52420, 52421, 52407, 0, 0, 0, 
0, 18763, 18772, 52422, 52409
30636, 1178, 1179, 9805, 9804, 18567, 18571, 51213, 51209, 0, 0, 0, 0, 18774, 52424, 52425, 
52411, 18764, 18773, 52423, 52410
30637, 18567, 18571, 51213, 51209, 18568, 18572, 51214, 51210, 18774, 52424, 52425, 52411, 18776, 52427, 52428, 
52414, 18766, 18775, 52426, 52413
30638, 18568, 18572, 51214, 51210, 18569, 18573, 51215, 51211, 18776, 52427, 52428, 52414, 18778, 52430, 52431, 
52417, 18768, 18777, 52429, 52416
30639, 18569, 18573, 51215, 51211, 18570, 18574, 51216, 51212, 18778, 52430, 52431, 52417, 18780, 52433, 52434, 
52420, 18770, 18779, 52432, 52419
30640, 18570, 18574, 51216, 51212, 2360, 2361, 19102, 19101, 18780, 52433, 52434, 52420, 0, 0, 0, 
0, 18772, 18781, 52435, 52422
30641, 1179, 48, 1191, 9805, 18571, 2330, 18933, 51213, 0, 0, 0, 0, 18782, 18978, 52436, 
52424, 18773, 2334, 18977, 52423
30642, 18571, 2330, 18933, 51213, 18572, 2331, 18934, 51214, 18782, 18978, 52436, 52424, 18783, 18980, 52437, 
52427, 18775, 2335, 18979, 52426
30643, 18572, 2331, 18934, 51214, 18573, 2332, 18935, 51215, 18783, 18980, 52437, 52427, 18784, 18982, 52438, 
52430, 18777, 2336, 18981, 52429
30644, 18573, 2332, 18935, 51215, 18574, 2333, 18936, 51216, 18784, 18982, 52438, 52430, 18785, 18984, 52439, 
52433, 18779, 2337, 18983, 52432
30645, 18574, 2333, 18936, 51216, 2361, 94, 2373, 19102, 18785, 18984, 52439, 52433, 0, 0, 0, 
0, 18781, 2338, 18985, 52435
30646, 1180, 9783, 9806, 1181, 18786, 51125, 51217, 18790, 0, 0, 0, 0, 52139, 52441, 52442, 
18839, 18831, 52137, 52440, 18840
30647, 18786, 51125, 51217, 18790, 18787, 51126, 51218, 18791, 52139, 52441, 52442, 18839, 52142, 52444, 52445, 
18841, 18833, 52140, 52443, 18842
30648, 18787, 51126, 51218, 18791, 18788, 51127, 51219, 18792, 52142, 52444, 52445, 18841, 52145, 52447, 52448, 
18843, 18835, 52143, 52446, 18844
30649, 18788, 51127, 51219, 18792, 18789, 51128, 51220, 18793, 52145, 52447, 52448, 18843, 52148, 52450, 52451, 
18845, 18837, 52146, 52449, 18846
30650, 18789, 51128, 51220, 18793, 2362, 19080, 19103, 2363, 52148, 52450, 52451, 18845, 0, 0, 0, 
0, 18838, 52149, 52452, 18847
30651, 9783, 9784, 9807, 9806, 51125, 51129, 51221, 51217, 0, 0, 0, 0, 52152, 52454, 52455, 
52441, 52137, 52150, 52453, 52440
30652, 51125, 51129, 51221, 51217, 51126, 51130, 51222, 51218, 52152, 52454, 52455, 52441, 52155, 52457, 52458, 
52444, 52140, 52153, 52456, 52443
30653, 51126, 51130, 51222, 51218, 51127, 51131, 51223, 51219, 52155, 52457, 52458, 52444, 52158, 52460, 52461, 
52447, 52143, 52156, 52459, 52446
30654, 51127, 51131, 51223, 51219, 51128, 51132, 51224, 51220, 52158, 52460, 52461, 52447, 52161, 52463, 52464, 
52450, 52146, 52159, 52462, 52449
30655, 51128, 51132, 51224, 51220, 19080, 19081, 19104, 19103, 52161, 52463, 52464, 52450, 0, 0, 0, 
0, 52149, 52162, 52465, 52452
30656, 9784, 9785, 9808, 9807, 51129, 51133, 51225, 51221, 0, 0, 0, 0, 52165, 52467, 52468, 
52454, 52150, 52163, 52466, 52453
30657, 51129, 51133, 51225, 51221, 51130, 51134, 51226, 51222, 52165, 52467, 52468, 52454, 52168, 52470, 52471, 
52457, 52153, 52166, 52469, 52456
30658, 51130, 51134, 51226, 51222, 51131, 51135, 51227, 51223, 52168, 52470, 52471, 52457, 52171, 52473, 52474, 
52460, 52156, 52169, 52472, 52459
30659, 51131, 51135, 51227, 51223, 51132, 51136, 51228, 51224, 52171, 52473, 52474, 52460, 52174, 52476, 52477, 
52463, 52159, 52172, 52475, 52462
30660, 51132, 51136, 51228, 51224, 19081, 19082, 19105, 19104, 52174, 52476, 52477, 52463, 0, 0, 0, 
0, 52162, 52175, 52478, 52465
30661, 9785, 9786, 9809, 9808, 51133, 51137, 51229, 51225, 0, 0, 0, 0, 52178, 52480, 52481, 
52467, 52163, 52176, 52479, 52466
30662, 51133, 51137, 51229, 51225, 51134, 51138, 51230, 51226, 52178, 52480, 52481, 52467, 52181, 52483, 52484, 
52470, 52166, 52179, 52482, 52469
30663, 51134, 51138, 51230, 51226, 51135, 51139, 51231, 51227, 52181, 52483, 52484, 52470, 52184, 52486, 52487, 
52473, 52169, 52182, 52485, 52472
30664, 51135, 51139, 51231, 51227, 51136, 51140, 51232, 51228, 52184, 52486, 52487, 52473, 52187, 52489, 52490, 
52476, 52172, 52185, 52488, 52475
30665, 51136, 51140, 51232, 51228, 19082, 19083, 19106, 19105, 52187, 52489, 52490, 52476, 0, 0, 0, 
0, 52175, 52188, 52491, 52478
30666, 9786, 9787, 9810, 9809, 51137, 51141, 51233, 51229, 0, 0, 0, 0, 52191, 52493, 52494, 
52480, 52176, 52189, 52492, 52479
30667, 51137, 51141, 51233, 51229, 51138, 51142, 51234, 51230, 52191, 52493, 52494, 52480, 52194, 52496, 52497, 
52483, 52179, 52192, 52495, 52482
30668, 51138, 51142, 51234, 51230, 51139, 51143, 51235, 51231, 52194, 52496, 52497, 52483, 52197, 52499, 52500, 
52486, 52182, 52195, 52498, 52485
30669, 51139, 51143, 51235, 51231, 51140, 51144, 51236, 51232, 52197, 52499, 52500, 52486, 52200, 52502, 52503, 
52489, 52185, 52198, 52501, 52488
30670, 51140, 51144, 51236, 51232, 19083, 19084, 19107, 19106, 52200, 52502, 52503, 52489, 0, 0, 0, 
0, 52188, 52201, 52504, 52491
30671, 9787, 9788, 9811, 9810, 51141, 51145, 51237, 51233, 0, 0, 0, 0, 52204, 52506, 52507, 
52493, 52189, 52202, 52505, 52492
30672, 51141, 51145, 51237, 51233, 51142, 51146, 51238, 51234, 52204, 52506, 52507, 52493, 52207, 52509, 52510, 
52496, 52192, 52205, 52508, 52495
30673, 51142, 51146, 51238, 51234, 51143, 51147, 51239, 51235, 52207, 52509, 52510, 52496, 52210, 52512, 52513, 
52499, 52195, 52208, 52511, 52498
30674, 51143, 51147, 51239, 51235, 51144, 51148, 51240, 51236, 52210, 52512, 52513, 52499, 52213, 52515, 52516, 
52502, 52198, 52211, 52514, 52501
30675, 51144, 51148, 51240, 51236, 19084, 19085, 19108, 19107, 52213, 52515, 52516, 52502, 0, 0, 0, 
0, 52201, 52214, 52517, 52504
30676, 9788, 9789, 9812, 9811, 51145, 51149, 51241, 51237, 0, 0, 0, 0, 52217, 52519, 52520, 
52506, 52202, 52215, 52518, 52505
30677, 51145, 51149, 51241, 51237, 51146, 51150, 51242, 51238, 52217, 52519, 52520, 52506, 52220, 52522, 52523, 
52509, 52205, 52218, 52521, 52508
30678, 51146, 51150, 51242, 51238, 51147, 51151, 51243, 51239, 52220, 52522, 52523, 52509, 52223, 52525, 52526, 
52512, 52208, 52221, 52524, 52511
30679, 51147, 51151, 51243, 51239, 51148, 51152, 51244, 51240, 52223, 52525, 52526, 52512, 52226, 52528, 52529, 
52515, 52211, 52224, 52527, 52514
30680, 51148, 51152, 51244, 51240, 19085, 19086, 19109, 19108, 52226, 52528, 52529, 52515, 0, 0, 0, 
0, 52214, 52227, 52530, 52517
30681, 9789, 9790, 9813, 9812, 51149, 51153, 51245, 51241, 0, 0, 0, 0, 52230, 52532, 52533, 
52519, 52215, 52228, 52531, 52518
30682, 51149, 51153, 51245, 51241, 51150, 51154, 51246, 51242, 52230, 52532, 52533, 52519, 52233, 52535, 52536, 
52522, 52218, 52231, 52534, 52521
30683, 51150, 51154, 51246, 51242, 51151, 51155, 51247, 51243, 52233, 52535, 52536, 52522, 52236, 52538, 52539, 
52525, 52221, 52234, 52537, 52524
30684, 51151, 51155, 51247, 51243, 51152, 51156, 51248, 51244, 52236, 52538, 52539, 52525, 52239, 52541, 52542, 
52528, 52224, 52237, 52540, 52527
30685, 51152, 51156, 51248, 51244, 19086, 19087, 19110, 19109, 52239, 52541, 52542, 52528, 0, 0, 0, 
0, 52227, 52240, 52543, 52530
30686, 9790, 9791, 9814, 9813, 51153, 51157, 51249, 51245, 0, 0, 0, 0, 52243, 52545, 52546, 
52532, 52228, 52241, 52544, 52531
30687, 51153, 51157, 51249, 51245, 51154, 51158, 51250, 51246, 52243, 52545, 52546, 52532, 52246, 52548, 52549, 
52535, 52231, 52244, 52547, 52534
30688, 51154, 51158, 51250, 51246, 51155, 51159, 51251, 51247, 52246, 52548, 52549, 52535, 52249, 52551, 52552, 
52538, 52234, 52247, 52550, 52537
30689, 51155, 51159, 51251, 51247, 51156, 51160, 51252, 51248, 52249, 52551, 52552, 52538, 52252, 52554, 52555, 
52541, 52237, 52250, 52553, 52540
30690, 51156, 51160, 51252, 51248, 19087, 19088, 19111, 19110, 52252, 52554, 52555, 52541, 0, 0, 0, 
0, 52240, 52253, 52556, 52543
30691, 9791, 9792, 9815, 9814, 51157, 51161, 51253, 51249, 0, 0, 0, 0, 52256, 52558, 52559, 
52545, 52241, 52254, 52557, 52544
30692, 51157, 51161, 51253, 51249, 51158, 51162, 51254, 51250, 52256, 52558, 52559, 52545, 52259, 52561, 52562, 
52548, 52244, 52257, 52560, 52547
30693, 51158, 51162, 51254, 51250, 51159, 51163, 51255, 51251, 52259, 52561, 52562, 52548, 52262, 52564, 52565, 
52551, 52247, 52260, 52563, 52550
30694, 51159, 51163, 51255, 51251, 51160, 51164, 51256, 51252, 52262, 52564, 52565, 52551, 52265, 52567, 52568, 
52554, 52250, 52263, 52566, 52553
30695, 51160, 51164, 51256, 51252, 19088, 19089, 19112, 19111, 52265, 52567, 52568, 52554, 0, 0, 0, 
0, 52253, 52266, 52569, 52556
30696, 9792, 9793, 9816, 9815, 51161, 51165, 51257, 51253, 0, 0, 0, 0, 52269, 52571, 52572, 
52558, 52254, 52267, 52570, 52557
30697, 51161, 51165, 51257, 51253, 51162, 51166, 51258, 51254, 52269, 52571, 52572, 52558, 52272, 52574, 52575, 
52561, 52257, 52270, 52573, 52560
30698, 51162, 51166, 51258, 51254, 51163, 51167, 51259, 51255, 52272, 52574, 52575, 52561, 52275, 52577, 52578, 
52564, 52260, 52273, 52576, 52563
30699, 51163, 51167, 51259, 51255, 51164, 51168, 51260, 51256, 52275, 52577, 52578, 52564, 52278, 52580, 52581, 
52567, 52263, 52276, 52579, 52566
30700, 51164, 51168, 51260, 51256, 19089, 19090, 19113, 19112, 52278, 52580, 52581, 52567, 0, 0, 0, 
0, 52266, 52279, 52582, 52569
30701, 9793, 9794, 9817, 9816, 51165, 51169, 51261, 51257, 0, 0, 0, 0, 52282, 52584, 52585, 
52571, 52267, 52280, 52583, 52570
30702, 51165, 51169, 51261, 51257, 51166, 51170, 51262, 51258, 52282, 52584, 52585, 52571, 52285, 52587, 52588, 
52574, 52270, 52283, 52586, 52573
30703, 51166, 51170, 51262, 51258, 51167, 51171, 51263, 51259, 52285, 52587, 52588, 52574, 52288, 52590, 52591, 
52577, 52273, 52286, 52589, 52576
30704, 51167, 51171, 51263, 51259, 51168, 51172, 51264, 51260, 52288, 52590, 52591, 52577, 52291, 52593, 52594, 
52580, 52276, 52289, 52592, 52579
30705, 51168, 51172, 51264, 51260, 19090, 19091, 19114, 19113, 52291, 52593, 52594, 52580, 0, 0, 0, 
0, 52279, 52292, 52595, 52582
30706, 9794, 9795, 9818, 9817, 51169, 51173, 51265, 51261, 0, 0, 0, 0, 52295, 52597, 52598, 
52584, 52280, 52293, 52596, 52583
30707, 51169, 51173, 51265, 51261, 51170, 51174, 51266, 51262, 52295, 52597, 52598, 52584, 52298, 52600, 52601, 
52587, 52283, 52296, 52599, 52586
30708, 51170, 51174, 51266, 51262, 51171, 51175, 51267, 51263, 52298, 52600, 52601, 52587, 52301, 52603, 52604, 
52590, 52286, 52299, 52602, 52589
30709, 51171, 51175, 51267, 51263, 51172, 51176, 51268, 51264, 52301, 52603, 52604, 52590, 52304, 52606, 52607, 
52593, 52289, 52302, 52605, 52592
30710, 51172, 51176, 51268, 51264, 19091, 19092, 19115, 19114, 52304, 52606, 52607, 52593, 0, 0, 0, 
0, 52292, 52305, 52608, 52595
30711, 9795, 9796, 9819, 9818, 51173, 51177, 51269, 51265, 0, 0, 0, 0, 52308, 52610, 52611, 
52597, 52293, 52306, 52609, 52596
30712, 51173, 51177, 51269, 51265, 51174, 51178, 51270, 51266, 52308, 52610, 52611, 52597, 52311, 52613, 52614, 
52600, 52296, 52309, 52612, 52599
30713, 51174, 51178, 51270, 51266, 51175, 51179, 51271, 51267, 52311, 52613, 52614, 52600, 52314, 52616, 52617, 
52603, 52299, 52312, 52615, 52602
30714, 51175, 51179, 51271, 51267, 51176, 51180, 51272, 51268, 52314, 52616, 52617, 52603, 52317, 52619, 52620, 
52606, 52302, 52315, 52618, 52605
30715, 51176, 51180, 51272, 51268, 19092, 19093, 19116, 19115, 52317, 52619, 52620, 52606, 0, 0, 0, 
0, 52305, 52318, 52621, 52608
30716, 9796, 9797, 9820, 9819, 51177, 51181, 51273, 51269, 0, 0, 0, 0, 52321, 52623, 52624, 
52610, 52306, 52319, 52622, 52609
30717, 51177, 51181, 51273, 51269, 51178, 51182, 51274, 51270, 52321, 52623, 52624, 52610, 52324, 52626, 52627, 
52613, 52309, 52322, 52625, 52612
30718, 51178, 51182, 51274, 51270, 51179, 51183, 51275, 51271, 52324, 52626, 52627, 52613, 52327, 52629, 52630, 
52616, 52312, 52325, 52628, 52615
30719, 51179, 51183, 51275, 51271, 51180, 51184, 51276, 51272, 52327, 52629, 52630, 52616, 52330, 52632, 52633, 
52619, 52315, 52328, 52631, 52618
30720, 51180, 51184, 51276, 51272, 19093, 19094, 19117, 19116, 52330, 52632, 52633, 52619, 0, 0, 0, 
0, 52318, 52331, 52634, 52621
30721, 9797, 9798, 9821, 9820, 51181, 51185, 51277, 51273, 0, 0, 0, 0, 52334, 52636, 52637, 
52623, 52319, 52332, 52635, 52622
30722, 51181, 51185, 51277, 51273, 51182, 51186, 51278, 51274, 52334, 52636, 52637, 52623, 52337, 52639, 52640, 
52626, 52322, 52335, 52638, 52625
30723, 51182, 51186, 51278, 51274, 51183, 51187, 51279, 51275, 52337, 52639, 52640, 52626, 52340, 52642, 52643, 
52629, 52325, 52338, 52641, 52628
30724, 51183, 51187, 51279, 51275, 51184, 51188, 51280, 51276, 52340, 52642, 52643, 52629, 52343, 52645, 52646, 
52632, 52328, 52341, 52644, 52631
30725, 51184, 51188, 51280, 51276, 19094, 19095, 19118, 19117, 52343, 52645, 52646, 52632, 0, 0, 0, 
0, 52331, 52344, 52647, 52634
30726, 9798, 9799, 9822, 9821, 51185, 51189, 51281, 51277, 0, 0, 0, 0, 52347, 52649, 52650, 
52636, 52332, 52345, 52648, 52635
30727, 51185, 51189, 51281, 51277, 51186, 51190, 51282, 51278, 52347, 52649, 52650, 52636, 52350, 52652, 52653, 
52639, 52335, 52348, 52651, 52638
30728, 51186, 51190, 51282, 51278, 51187, 51191, 51283, 51279, 52350, 52652, 52653, 52639, 52353, 52655, 52656, 
52642, 52338, 52351, 52654, 52641
30729, 51187, 51191, 51283, 51279, 51188, 51192, 51284, 51280, 52353, 52655, 52656, 52642, 52356, 52658, 52659, 
52645, 52341, 52354, 52657, 52644
30730, 51188, 51192, 51284, 51280, 19095, 19096, 19119, 19118, 52356, 52658, 52659, 52645, 0, 0, 0, 
0, 52344, 52357, 52660, 52647
30731, 9799, 9800, 9823, 9822, 51189, 51193, 51285, 51281, 0, 0, 0, 0, 52360, 52662, 52663, 
52649, 52345, 52358, 52661, 52648
30732, 51189, 51193, 51285, 51281, 51190, 51194, 51286, 51282, 52360, 52662, 52663, 52649, 52363, 52665, 52666, 
52652, 52348, 52361, 52664, 52651
30733, 51190, 51194, 51286, 51282, 51191, 51195, 51287, 51283, 52363, 52665, 52666, 52652, 52366, 52668, 52669, 
52655, 52351, 52364, 52667, 52654
30734, 51191, 51195, 51287, 51283, 51192, 51196, 51288, 51284, 52366, 52668, 52669, 52655, 52369, 52671, 52672, 
52658, 52354, 52367, 52670, 52657
30735, 51192, 51196, 51288, 51284, 19096, 19097, 19120, 19119, 52369, 52671, 52672, 52658, 0, 0, 0, 
0, 52357, 52370, 52673, 52660
30736, 9800, 9801, 9824, 9823, 51193, 51197, 51289, 51285, 0, 0, 0, 0, 52373, 52675, 52676, 
52662, 52358, 52371, 52674, 52661
30737, 51193, 51197, 51289, 51285, 51194, 51198, 51290, 51286, 52373, 52675, 52676, 52662, 52376, 52678, 52679, 
52665, 52361, 52374, 52677, 52664
30738, 51194, 51198, 51290, 51286, 51195, 51199, 51291, 51287, 52376, 52678, 52679, 52665, 52379, 52681, 52682, 
52668, 52364, 52377, 52680, 52667
30739, 51195, 51199, 51291, 51287, 51196, 51200, 51292, 51288, 52379, 52681, 52682, 52668, 52382, 52684, 52685, 
52671, 52367, 52380, 52683, 52670
30740, 51196, 51200, 51292, 51288, 19097, 19098, 19121, 19120, 52382, 52684, 52685, 52671, 0, 0, 0, 
0, 52370, 52383, 52686, 52673
30741, 9801, 9802, 9825, 9824, 51197, 51201, 51293, 51289, 0, 0, 0, 0, 52386, 52688, 52689, 
52675, 52371, 52384, 52687, 52674
30742, 51197, 51201, 51293, 51289, 51198, 51202, 51294, 51290, 52386, 52688, 52689, 52675, 52389, 52691, 52692, 
52678, 52374, 52387, 52690, 52677
30743, 51198, 51202, 51294, 51290, 51199, 51203, 51295, 51291, 52389, 52691, 52692, 52678, 52392, 52694, 52695, 
52681, 52377, 52390, 52693, 52680
30744, 51199, 51203, 51295, 51291, 51200, 51204, 51296, 51292, 52392, 52694, 52695, 52681, 52395, 52697, 52698, 
52684, 52380, 52393, 52696, 52683
30745, 51200, 51204, 51296, 51292, 19098, 19099, 19122, 19121, 52395, 52697, 52698, 52684, 0, 0, 0, 
0, 52383, 52396, 52699, 52686
30746, 9802, 9803, 9826, 9825, 51201, 51205, 51297, 51293, 0, 0, 0, 0, 52399, 52701, 52702, 
52688, 52384, 52397, 52700, 52687
30747, 51201, 51205, 51297, 51293, 51202, 51206, 51298, 51294, 52399, 52701, 52702, 52688, 52402, 52704, 52705, 
52691, 52387, 52400, 52703, 52690
30748, 51202, 51206, 51298, 51294, 51203, 51207, 51299, 51295, 52402, 52704, 52705, 52691, 52405, 52707, 52708, 
52694, 52390, 52403, 52706, 52693
30749, 51203, 51207, 51299, 51295, 51204, 51208, 51300, 51296, 52405, 52707, 52708, 52694, 52408, 52710, 52711, 
52697, 52393, 52406, 52709, 52696
30750, 51204, 51208, 51300, 51296, 19099, 19100, 19123, 19122, 52408, 52710, 52711, 52697, 0, 0, 0, 
0, 52396, 52409, 52712, 52699
30751, 9803, 9804, 9827, 9826, 51205, 51209, 51301, 51297, 0, 0, 0, 0, 52412, 52714, 52715, 
52701, 52397, 52410, 52713, 52700
30752, 51205, 51209, 51301, 51297, 51206, 51210, 51302, 51298, 52412, 52714, 52715, 52701, 52415, 52717, 52718, 
52704, 52400, 52413, 52716, 52703
30753, 51206, 51210, 51302, 51298, 51207, 51211, 51303, 51299, 52415, 52717, 52718, 52704, 52418, 52720, 52721, 
52707, 52403, 52416, 52719, 52706
30754, 51207, 51211, 51303, 51299, 51208, 51212, 51304, 51300, 52418, 52720, 52721, 52707, 52421, 52723, 52724, 
52710, 52406, 52419, 52722, 52709
30755, 51208, 51212, 51304, 51300, 19100, 19101, 19124, 19123, 52421, 52723, 52724, 52710, 0, 0, 0, 
0, 52409, 52422, 52725, 52712
30756, 9804, 9805, 9828, 9827, 51209, 51213, 51305, 51301, 0, 0, 0, 0, 52425, 52727, 52728, 
52714, 52410, 52423, 52726, 52713
30757, 51209, 51213, 51305, 51301, 51210, 51214, 51306, 51302, 52425, 52727, 52728, 52714, 52428, 52730, 52731, 
52717, 52413, 52426, 52729, 52716
30758, 51210, 51214, 51306, 51302, 51211, 51215, 51307, 51303, 52428, 52730, 52731, 52717, 52431, 52733, 52734, 
52720, 52416, 52429, 52732, 52719
30759, 51211, 51215, 51307, 51303, 51212, 51216, 51308, 51304, 52431, 52733, 52734, 52720, 52434, 52736, 52737, 
52723, 52419, 52432, 52735, 52722
30760, 51212, 51216, 51308, 51304, 19101, 19102, 19125, 19124, 52434, 52736, 52737, 52723, 0, 0, 0, 
0, 52422, 52435, 52738, 52725
30761, 9805, 1191, 1192, 9828, 51213, 18933, 18937, 51305, 0, 0, 0, 0, 52436, 18987, 52739, 
52727, 52423, 18977, 18986, 52726
30762, 51213, 18933, 18937, 51305, 51214, 18934, 18938, 51306, 52436, 18987, 52739, 52727, 52437, 18989, 52740, 
52730, 52426, 18979, 18988, 52729
30763, 51214, 18934, 18938, 51306, 51215, 18935, 18939, 51307, 52437, 18989, 52740, 52730, 52438, 18991, 52741, 
52733, 52429, 18981, 18990, 52732
30764, 51215, 18935, 18939, 51307, 51216, 18936, 18940, 51308, 52438, 18991, 52741, 52733, 52439, 18993, 52742, 
52736, 52432, 18983, 18992, 52735
30765, 51216, 18936, 18940, 51308, 19102, 2373, 2374, 19125, 52439, 18993, 52742, 52736, 0, 0, 0, 
0, 52435, 18985, 18994, 52738
30766, 1181, 9806, 9829, 1182, 18790, 51217, 51309, 18794, 0, 0, 0, 0, 52442, 52744, 52745, 
18848, 18840, 52440, 52743, 18849
30767, 18790, 51217, 51309, 18794, 18791, 51218, 51310, 18795, 52442, 52744, 52745, 18848, 52445, 52747, 52748, 
18850, 18842, 52443, 52746, 18851
30768, 18791, 51218, 51310, 18795, 18792, 51219, 51311, 18796, 52445, 52747, 52748, 18850, 52448, 52750, 52751, 
18852, 18844, 52446, 52749, 18853
30769, 18792, 51219, 51311, 18796, 18793, 51220, 51312, 18797, 52448, 52750, 52751, 18852, 52451, 52753, 52754, 
18854, 18846, 52449, 52752, 18855
30770, 18793, 51220, 51312, 18797, 2363, 19103, 19126, 2364, 52451, 52753, 52754, 18854, 0, 0, 0, 
0, 18847, 52452, 52755, 18856
30771, 9806, 9807, 9830, 9829, 51217, 51221, 51313, 51309, 0, 0, 0, 0, 52455, 52757, 52758, 
52744, 52440, 52453, 52756, 52743
30772, 51217, 51221, 51313, 51309, 51218, 51222, 51314, 51310, 52455, 52757, 52758, 52744, 52458, 52760, 52761, 
52747, 52443, 52456, 52759, 52746
30773, 51218, 51222, 51314, 51310, 51219, 51223, 51315, 51311, 52458, 52760, 52761, 52747, 52461, 52763, 52764, 
52750, 52446, 52459, 52762, 52749
30774, 51219, 51223, 51315, 51311, 51220, 51224, 51316, 51312, 52461, 52763, 52764, 52750, 52464, 52766, 52767, 
52753, 52449, 52462, 52765, 52752
30775, 51220, 51224, 51316, 51312, 19103, 19104, 19127, 19126, 52464, 52766, 52767, 52753, 0, 0, 0, 
0, 52452, 52465, 52768, 52755
30776, 9807, 9808, 9831, 9830, 51221, 51225, 51317, 51313, 0, 0, 0, 0, 52468, 52770, 52771, 
52757, 52453, 52466, 52769, 52756
30777, 51221, 51225, 51317, 51313, 51222, 51226, 51318, 51314, 52468, 52770, 52771, 52757, 52471, 52773, 52774, 
52760, 52456, 52469, 52772, 52759
30778, 51222, 51226, 51318, 51314, 51223, 51227, 51319, 51315, 52471, 52773, 52774, 52760, 52474, 52776, 52777, 
52763, 52459, 52472, 52775, 52762
30779, 51223, 51227, 51319, 51315, 51224, 51228, 51320, 51316, 52474, 52776, 52777, 52763, 52477, 52779, 52780, 
52766, 52462, 52475, 52778, 52765
30780, 51224, 51228, 51320, 51316, 19104, 19105, 19128, 19127, 52477, 52779, 52780, 52766, 0, 0, 0, 
0, 52465, 52478, 52781, 52768
30781, 9808, 9809, 9832, 9831, 51225, 51229, 51321, 51317, 0, 0, 0, 0, 52481, 52783, 52784, 
52770, 52466, 52479, 52782, 52769
30782, 51225, 51229, 51321, 51317, 51226, 51230, 51322, 51318, 52481, 52783, 52784, 52770, 52484, 52786, 52787, 
52773, 52469, 52482, 52785, 52772
30783, 51226, 51230, 51322, 51318, 51227, 51231, 51323, 51319, 52484, 52786, 52787, 52773, 52487, 52789, 52790, 
52776, 52472, 52485, 52788, 52775
30784, 51227, 51231, 51323, 51319, 51228, 51232, 51324, 51320, 52487, 52789, 52790, 52776, 52490, 52792, 52793, 
52779, 52475, 52488, 52791, 52778
30785, 51228, 51232, 51324, 51320, 19105, 19106, 19129, 19128, 52490, 52792, 52793, 52779, 0, 0, 0, 
0, 52478, 52491, 52794, 52781
30786, 9809, 9810, 9833, 9832, 51229, 51233, 51325, 51321, 0, 0, 0, 0, 52494, 52796, 52797, 
52783, 52479, 52492, 52795, 52782
30787, 51229, 51233, 51325, 51321, 51230, 51234, 51326, 51322, 52494, 52796, 52797, 52783, 52497, 52799, 52800, 
52786, 52482, 52495, 52798, 52785
30788, 51230, 51234, 51326, 51322, 51231, 51235, 51327, 51323, 52497, 52799, 52800, 52786, 52500, 52802, 52803, 
52789, 52485, 52498, 52801, 52788
30789, 51231, 51235, 51327, 51323, 51232, 51236, 51328, 51324, 52500, 52802, 52803, 52789, 52503, 52805, 52806, 
52792, 52488, 52501, 52804, 52791
30790, 51232, 51236, 51328, 51324, 19106, 19107, 19130, 19129, 52503, 52805, 52806, 52792, 0, 0, 0, 
0, 52491, 52504, 52807, 52794
30791, 9810, 9811, 9834, 9833, 51233, 51237, 51329, 51325, 0, 0, 0, 0, 52507, 52809, 52810, 
52796, 52492, 52505, 52808, 52795
30792, 51233, 51237, 51329, 51325, 51234, 51238, 51330, 51326, 52507, 52809, 52810, 52796, 52510, 52812, 52813, 
52799, 52495, 52508, 52811, 52798
30793, 51234, 51238, 51330, 51326, 51235, 51239, 51331, 51327, 52510, 52812, 52813, 52799, 52513, 52815, 52816, 
52802, 52498, 52511, 52814, 52801
30794, 51235, 51239, 51331, 51327, 51236, 51240, 51332, 51328, 52513, 52815, 52816, 52802, 52516, 52818, 52819, 
52805, 52501, 52514, 52817, 52804
30795, 51236, 51240, 51332, 51328, 19107, 19108, 19131, 19130, 52516, 52818, 52819, 52805, 0, 0, 0, 
0, 52504, 52517, 52820, 52807
30796, 9811, 9812, 9835, 9834, 51237, 51241, 51333, 51329, 0, 0, 0, 0, 52520, 52822, 52823, 
52809, 52505, 52518, 52821, 52808
30797, 51237, 51241, 51333, 51329, 51238, 51242, 51334, 51330, 52520, 52822, 52823, 52809, 52523, 52825, 52826, 
52812, 52508, 52521, 52824, 52811
30798, 51238, 51242, 51334, 51330, 51239, 51243, 51335, 51331, 52523, 52825, 52826, 52812, 52526, 52828, 52829, 
52815, 52511, 52524, 52827, 52814
30799, 51239, 51243, 51335, 51331, 51240, 51244, 51336, 51332, 52526, 52828, 52829, 52815, 52529, 52831, 52832, 
52818, 52514, 52527, 52830, 52817
30800, 51240, 51244, 51336, 51332, 19108, 19109, 19132, 19131, 52529, 52831, 52832, 52818, 0, 0, 0, 
0, 52517, 52530, 52833, 52820
30801, 9812, 9813, 9836, 9835, 51241, 51245, 51337, 51333, 0, 0, 0, 0, 52533, 52835, 52836, 
52822, 52518, 52531, 52834, 52821
30802, 51241, 51245, 51337, 51333, 51242, 51246, 51338, 51334, 52533, 52835, 52836, 52822, 52536, 52838, 52839, 
52825, 52521, 52534, 52837, 52824
30803, 51242, 51246, 51338, 51334, 51243, 51247, 51339, 51335, 52536, 52838, 52839, 52825, 52539, 52841, 52842, 
52828, 52524, 52537, 52840, 52827
30804, 51243, 51247, 51339, 51335, 51244, 51248, 51340, 51336, 52539, 52841, 52842, 52828, 52542, 52844, 52845, 
52831, 52527, 52540, 52843, 52830
30805, 51244, 51248, 51340, 51336, 19109, 19110, 19133, 19132, 52542, 52844, 52845, 52831, 0, 0, 0, 
0, 52530, 52543, 52846, 52833
30806, 9813, 9814, 9837, 9836, 51245, 51249, 51341, 51337, 0, 0, 0, 0, 52546, 52848, 52849, 
52835, 52531, 52544, 52847, 52834
30807, 51245, 51249, 51341, 51337, 51246, 51250, 51342, 51338, 52546, 52848, 52849, 52835, 52549, 52851, 52852, 
52838, 52534, 52547, 52850, 52837
30808, 51246, 51250, 51342, 51338, 51247, 51251, 51343, 51339, 52549, 52851, 52852, 52838, 52552, 52854, 52855, 
52841, 52537, 52550, 52853, 52840
30809, 51247, 51251, 51343, 51339, 51248, 51252, 51344, 51340, 52552, 52854, 52855, 52841, 52555, 52857, 52858, 
52844, 52540, 52553, 52856, 52843
30810, 51248, 51252, 51344, 51340, 19110, 19111, 19134, 19133, 52555, 52857, 52858, 52844, 0, 0, 0, 
0, 52543, 52556, 52859, 52846
30811, 9814, 9815, 9838, 9837, 51249, 51253, 51345, 51341, 0, 0, 0, 0, 52559, 52861, 52862, 
52848, 52544, 52557, 52860, 52847
30812, 51249, 51253, 51345, 51341, 51250, 51254, 51346, 51342, 52559, 52861, 52862, 52848, 52562, 52864, 52865, 
52851, 52547, 52560, 52863, 52850
30813, 51250, 51254, 51346, 51342, 51251, 51255, 51347, 51343, 52562, 52864, 52865, 52851, 52565, 52867, 52868, 
52854, 52550, 52563, 52866, 52853
30814, 51251, 51255, 51347, 51343, 51252, 51256, 51348, 51344, 52565, 52867, 52868, 52854, 52568, 52870, 52871, 
52857, 52553, 52566, 52869, 52856
30815, 51252, 51256, 51348, 51344, 19111, 19112, 19135, 19134, 52568, 52870, 52871, 52857, 0, 0, 0, 
0, 52556, 52569, 52872, 52859
30816, 9815, 9816, 9839, 9838, 51253, 51257, 51349, 51345, 0, 0, 0, 0, 52572, 52874, 52875, 
52861, 52557, 52570, 52873, 52860
30817, 51253, 51257, 51349, 51345, 51254, 51258, 51350, 51346, 52572, 52874, 52875, 52861, 52575, 52877, 52878, 
52864, 52560, 52573, 52876, 52863
30818, 51254, 51258, 51350, 51346, 51255, 51259, 51351, 51347, 52575, 52877, 52878, 52864, 52578, 52880, 52881, 
52867, 52563, 52576, 52879, 52866
30819, 51255, 51259, 51351, 51347, 51256, 51260, 51352, 51348, 52578, 52880, 52881, 52867, 52581, 52883, 52884, 
52870, 52566, 52579, 52882, 52869
30820, 51256, 51260, 51352, 51348, 19112, 19113, 19136, 19135, 52581, 52883, 52884, 52870, 0, 0, 0, 
0, 52569, 52582, 52885, 52872
30821, 9816, 9817, 9840, 9839, 51257, 51261, 51353, 51349, 0, 0, 0, 0, 52585, 52887, 52888, 
52874, 52570, 52583, 52886, 52873
30822, 51257, 51261, 51353, 51349, 51258, 51262, 51354, 51350, 52585, 52887, 52888, 52874, 52588, 52890, 52891, 
52877, 52573, 52586, 52889, 52876
30823, 51258, 51262, 51354, 51350, 51259, 51263, 51355, 51351, 52588, 52890, 52891, 52877, 52591, 52893, 52894, 
52880, 52576, 52589, 52892, 52879
30824, 51259, 51263, 51355, 51351, 51260, 51264, 51356, 51352, 52591, 52893, 52894, 52880, 52594, 52896, 52897, 
52883, 52579, 52592, 52895, 52882
30825, 51260, 51264, 51356, 51352, 19113, 19114, 19137, 19136, 52594, 52896, 52897, 52883, 0, 0, 0, 
0, 52582, 52595, 52898, 52885
30826, 9817, 9818, 9841, 9840, 51261, 51265, 51357, 51353, 0, 0, 0, 0, 52598, 52900, 52901, 
52887, 52583, 52596, 52899, 52886
30827, 51261, 51265, 51357, 51353, 51262, 51266, 51358, 51354, 52598, 52900, 52901, 52887, 52601, 52903, 52904, 
52890, 52586, 52599, 52902, 52889
30828, 51262, 51266, 51358, 51354, 51263, 51267, 51359, 51355, 52601, 52903, 52904, 52890, 52604, 52906, 52907, 
52893, 52589, 52602, 52905, 52892
30829, 51263, 51267, 51359, 51355, 51264, 51268, 51360, 51356, 52604, 52906, 52907, 52893, 52607, 52909, 52910, 
52896, 52592, 52605, 52908, 52895
30830, 51264, 51268, 51360, 51356, 19114, 19115, 19138, 19137, 52607, 52909, 52910, 52896, 0, 0, 0, 
0, 52595, 52608, 52911, 52898
30831, 9818, 9819, 9842, 9841, 51265, 51269, 51361, 51357, 0, 0, 0, 0, 52611, 52913, 52914, 
52900, 52596, 52609, 52912, 52899
30832, 51265, 51269, 51361, 51357, 51266, 51270, 51362, 51358, 52611, 52913, 52914, 52900, 52614, 52916, 52917, 
52903, 52599, 52612, 52915, 52902
30833, 51266, 51270, 51362, 51358, 51267, 51271, 51363, 51359, 52614, 52916, 52917, 52903, 52617, 52919, 52920, 
52906, 52602, 52615, 52918, 52905
30834, 51267, 51271, 51363, 51359, 51268, 51272, 51364, 51360, 52617, 52919, 52920, 52906, 52620, 52922, 52923, 
52909, 52605, 52618, 52921, 52908
30835, 51268, 51272, 51364, 51360, 19115, 19116, 19139, 19138, 52620, 52922, 52923, 52909, 0, 0, 0, 
0, 52608, 52621, 52924, 52911
30836, 9819, 9820, 9843, 9842, 51269, 51273, 51365, 51361, 0, 0, 0, 0, 52624, 52926, 52927, 
52913, 52609, 52622, 52925, 52912
30837, 51269, 51273, 51365, 51361, 51270, 51274, 51366, 51362, 52624, 52926, 52927, 52913, 52627, 52929, 52930, 
52916, 52612, 52625, 52928, 52915
30838, 51270, 51274, 51366, 51362, 51271, 51275, 51367, 51363, 52627, 52929, 52930, 52916, 52630, 52932, 52933, 
52919, 52615, 52628, 52931, 52918
30839, 51271, 51275, 51367, 51363, 51272, 51276, 51368, 51364, 52630, 52932, 52933, 52919, 52633, 52935, 52936, 
52922, 52618, 52631, 52934, 52921
30840, 51272, 51276, 51368, 51364, 19116, 19117, 19140, 19139, 52633, 52935, 52936, 52922, 0, 0, 0, 
0, 52621, 52634, 52937, 52924
30841, 9820, 9821, 9844, 9843, 51273, 51277, 51369, 51365, 0, 0, 0, 0, 52637, 52939, 52940, 
52926, 52622, 52635, 52938, 52925
30842, 51273, 51277, 51369, 51365, 51274, 51278, 51370, 51366, 52637, 52939, 52940, 52926, 52640, 52942, 52943, 
52929, 52625, 52638, 52941, 52928
30843, 51274, 51278, 51370, 51366, 51275, 51279, 51371, 51367, 52640, 52942, 52943, 52929, 52643, 52945, 52946, 
52932, 52628, 52641, 52944, 52931
30844, 51275, 51279, 51371, 51367, 51276, 51280, 51372, 51368, 52643, 52945, 52946, 52932, 52646, 52948, 52949, 
52935, 52631, 52644, 52947, 52934
30845, 51276, 51280, 51372, 51368, 19117, 19118, 19141, 19140, 52646, 52948, 52949, 52935, 0, 0, 0, 
0, 52634, 52647, 52950, 52937
30846, 9821, 9822, 9845, 9844, 51277, 51281, 51373, 51369, 0, 0, 0, 0, 52650, 52952, 52953, 
52939, 52635, 52648, 52951, 52938
30847, 51277, 51281, 51373, 51369, 51278, 51282, 51374, 51370, 52650, 52952, 52953, 52939, 52653, 52955, 52956, 
52942, 52638, 52651, 52954, 52941
30848, 51278, 51282, 51374, 51370, 51279, 51283, 51375, 51371, 52653, 52955, 52956, 52942, 52656, 52958, 52959, 
52945, 52641, 52654, 52957, 52944
30849, 51279, 51283, 51375, 51371, 51280, 51284, 51376, 51372, 52656, 52958, 52959, 52945, 52659, 52961, 52962, 
52948, 52644, 52657, 52960, 52947
30850, 51280, 51284, 51376, 51372, 19118, 19119, 19142, 19141, 52659, 52961, 52962, 52948, 0, 0, 0, 
0, 52647, 52660, 52963, 52950
30851, 9822, 9823, 9846, 9845, 51281, 51285, 51377, 51373, 0, 0, 0, 0, 52663, 52965, 52966, 
52952, 52648, 52661, 52964, 52951
30852, 51281, 51285, 51377, 51373, 51282, 51286, 51378, 51374, 52663, 52965, 52966, 52952, 52666, 52968, 52969, 
52955, 52651, 52664, 52967, 52954
30853, 51282, 51286, 51378, 51374, 51283, 51287, 51379, 51375, 52666, 52968, 52969, 52955, 52669, 52971, 52972, 
52958, 52654, 52667, 52970, 52957
30854, 51283, 51287, 51379, 51375, 51284, 51288, 51380, 51376, 52669, 52971, 52972, 52958, 52672, 52974, 52975, 
52961, 52657, 52670, 52973, 52960
30855, 51284, 51288, 51380, 51376, 19119, 19120, 19143, 19142, 52672, 52974, 52975, 52961, 0, 0, 0, 
0, 52660, 52673, 52976, 52963
30856, 9823, 9824, 9847, 9846, 51285, 51289, 51381, 51377, 0, 0, 0, 0, 52676, 52978, 52979, 
52965, 52661, 52674, 52977, 52964
30857, 51285, 51289, 51381, 51377, 51286, 51290, 51382, 51378, 52676, 52978, 52979, 52965, 52679, 52981, 52982, 
52968, 52664, 52677, 52980, 52967
30858, 51286, 51290, 51382, 51378, 51287, 51291, 51383, 51379, 52679, 52981, 52982, 52968, 52682, 52984, 52985, 
52971, 52667, 52680, 52983, 52970
30859, 51287, 51291, 51383, 51379, 51288, 51292, 51384, 51380, 52682, 52984, 52985, 52971, 52685, 52987, 52988, 
52974, 52670, 52683, 52986, 52973
30860, 51288, 51292, 51384, 51380, 19120, 19121, 19144, 19143, 52685, 52987, 52988, 52974, 0, 0, 0, 
0, 52673, 52686, 52989, 52976
30861, 9824, 9825, 9848, 9847, 51289, 51293, 51385, 51381, 0, 0, 0, 0, 52689, 52991, 52992, 
52978, 52674, 52687, 52990, 52977
30862, 51289, 51293, 51385, 51381, 51290, 51294, 51386, 51382, 52689, 52991, 52992, 52978, 52692, 52994, 52995, 
52981, 52677, 52690, 52993, 52980
30863, 51290, 51294, 51386, 51382, 51291, 51295, 51387, 51383, 52692, 52994, 52995, 52981, 52695, 52997, 52998, 
52984, 52680, 52693, 52996, 52983
30864, 51291, 51295, 51387, 51383, 51292, 51296, 51388, 51384, 52695, 52997, 52998, 52984, 52698, 53000, 53001, 
52987, 52683, 52696, 52999, 52986
30865, 51292, 51296, 51388, 51384, 19121, 19122, 19145, 19144, 52698, 53000, 53001, 52987, 0, 0, 0, 
0, 52686, 52699, 53002, 52989
30866, 9825, 9826, 9849, 9848, 51293, 51297, 51389, 51385, 0, 0, 0, 0, 52702, 53004, 53005, 
52991, 52687, 52700, 53003, 52990
30867, 51293, 51297, 51389, 51385, 51294, 51298, 51390, 51386, 52702, 53004, 53005, 52991, 52705, 53007, 53008, 
52994, 52690, 52703, 53006, 52993
30868, 51294, 51298, 51390, 51386, 51295, 51299, 51391, 51387, 52705, 53007, 53008, 52994, 52708, 53010, 53011, 
52997, 52693, 52706, 53009, 52996
30869, 51295, 51299, 51391, 51387, 51296, 51300, 51392, 51388, 52708, 53010, 53011, 52997, 52711, 53013, 53014, 
53000, 52696, 52709, 53012, 52999
30870, 51296, 51300, 51392, 51388, 19122, 19123, 19146, 19145, 52711, 53013, 53014, 53000, 0, 0, 0, 
0, 52699, 52712, 53015, 53002
30871, 9826, 9827, 9850, 9849, 51297, 51301, 51393, 51389, 0, 0, 0, 0, 52715, 53017, 53018, 
53004, 52700, 52713, 53016, 53003
30872, 51297, 51301, 51393, 51389, 51298, 51302, 51394, 51390, 52715, 53017, 53018, 53004, 52718, 53020, 53021, 
53007, 52703, 52716, 53019, 53006
30873, 51298, 51302, 51394, 51390, 51299, 51303, 51395, 51391, 52718, 53020, 53021, 53007, 52721, 53023, 53024, 
53010, 52706, 52719, 53022, 53009
30874, 51299, 51303, 51395, 51391, 51300, 51304, 51396, 51392, 52721, 53023, 53024, 53010, 52724, 53026, 53027, 
53013, 52709, 52722, 53025, 53012
30875, 51300, 51304, 51396, 51392, 19123, 19124, 19147, 19146, 52724, 53026, 53027, 53013, 0, 0, 0, 
0, 52712, 52725, 53028, 53015
30876, 9827, 9828, 9851, 9850, 51301, 51305, 51397, 51393, 0, 0, 0, 0, 52728, 53030, 53031, 
53017, 52713, 52726, 53029, 53016
30877, 51301, 51305, 51397, 51393, 51302, 51306, 51398, 51394, 52728, 53030, 53031, 53017, 52731, 53033, 53034, 
53020, 52716, 52729, 53032, 53019
30878, 51302, 51306, 51398, 51394, 51303, 51307, 51399, 51395, 52731, 53033, 53034, 53020, 52734, 53036, 53037, 
53023, 52719, 52732, 53035, 53022
30879, 51303, 51307, 51399, 51395, 51304, 51308, 51400, 51396, 52734, 53036, 53037, 53023, 52737, 53039, 53040, 
53026, 52722, 52735, 53038, 53025
30880, 51304, 51308, 51400, 51396, 19124, 19125, 19148, 19147, 52737, 53039, 53040, 53026, 0, 0, 0, 
0, 52725, 52738, 53041, 53028
30881, 9828, 1192, 1193, 9851, 51305, 18937, 18941, 51397, 0, 0, 0, 0, 52739, 18996, 53042, 
53030, 52726, 18986, 18995, 53029
30882, 51305, 18937, 18941, 51397, 51306, 18938, 18942, 51398, 52739, 18996, 53042, 53030, 52740, 18998, 53043, 
53033, 52729, 18988, 18997, 53032
30883, 51306, 18938, 18942, 51398, 51307, 18939, 18943, 51399, 52740, 18998, 53043, 53033, 52741, 19000, 53044, 
53036, 52732, 18990, 18999, 53035
30884, 51307, 18939, 18943, 51399, 51308, 18940, 18944, 51400, 52741, 19000, 53044, 53036, 52742, 19002, 53045, 
53039, 52735, 18992, 19001, 53038
30885, 51308, 18940, 18944, 51400, 19125, 2374, 2375, 19148, 52742, 19002, 53045, 53039, 0, 0, 0, 
0, 52738, 18994, 19003, 53041
30886, 1182, 9829, 9852, 1183, 18794, 51309, 51401, 18798, 0, 0, 0, 0, 52745, 53047, 53048, 
18857, 18849, 52743, 53046, 18858
30887, 18794, 51309, 51401, 18798, 18795, 51310, 51402, 18799, 52745, 53047, 53048, 18857, 52748, 53050, 53051, 
18859, 18851, 52746, 53049, 18860
30888, 18795, 51310, 51402, 18799, 18796, 51311, 51403, 18800, 52748, 53050, 53051, 18859, 52751, 53053, 53054, 
18861, 18853, 52749, 53052, 18862
30889, 18796, 51311, 51403, 18800, 18797, 51312, 51404, 18801, 52751, 53053, 53054, 18861, 52754, 53056, 53057, 
18863, 18855, 52752, 53055, 18864
30890, 18797, 51312, 51404, 18801, 2364, 19126, 19149, 2365, 52754, 53056, 53057, 18863, 0, 0, 0, 
0, 18856, 52755, 53058, 18865
30891, 9829, 9830, 9853, 9852, 51309, 51313, 51405, 51401, 0, 0, 0, 0, 52758, 53060, 53061, 
53047, 52743, 52756, 53059, 53046
30892, 51309, 51313, 51405, 51401, 51310, 51314, 51406, 51402, 52758, 53060, 53061, 53047, 52761, 53063, 53064, 
53050, 52746, 52759, 53062, 53049
30893, 51310, 51314, 51406, 51402, 51311, 51315, 51407, 51403, 52761, 53063, 53064, 53050, 52764, 53066, 53067, 
53053, 52749, 52762, 53065, 53052
30894, 51311, 51315, 51407, 51403, 51312, 51316, 51408, 51404, 52764, 53066, 53067, 53053, 52767, 53069, 53070, 
53056, 52752, 52765, 53068, 53055
30895, 51312, 51316, 51408, 51404, 19126, 19127, 19150, 19149, 52767, 53069, 53070, 53056, 0, 0, 0, 
0, 52755, 52768, 53071, 53058
30896, 9830, 9831, 9854, 9853, 51313, 51317, 51409, 51405, 0, 0, 0, 0, 52771, 53073, 53074, 
53060, 52756, 52769, 53072, 53059
30897, 51313, 51317, 51409, 51405, 51314, 51318, 51410, 51406, 52771, 53073, 53074, 53060, 52774, 53076, 53077, 
53063, 52759, 52772, 53075, 53062
30898, 51314, 51318, 51410, 51406, 51315, 51319, 51411, 51407, 52774, 53076, 53077, 53063, 52777, 53079, 53080, 
53066, 52762, 52775, 53078, 53065
30899, 51315, 51319, 51411, 51407, 51316, 51320, 51412, 51408, 52777, 53079, 53080, 53066, 52780, 53082, 53083, 
53069, 52765, 52778, 53081, 53068
30900, 51316, 51320, 51412, 51408, 19127, 19128, 19151, 19150, 52780, 53082, 53083, 53069, 0, 0, 0, 
0, 52768, 52781, 53084, 53071
30901, 9831, 9832, 9855, 9854, 51317, 51321, 51413, 51409, 0, 0, 0, 0, 52784, 53086, 53087, 
53073, 52769, 52782, 53085, 53072
