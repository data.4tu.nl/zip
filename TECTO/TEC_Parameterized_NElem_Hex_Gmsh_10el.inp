21633, 31611, 31634, 32163, 32140, 31612, 31635, 32164, 32141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21634, 31612, 31635, 32164, 32141, 31613, 31636, 32165, 32142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21635, 31613, 31636, 32165, 32142, 31614, 31637, 32166, 32143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21636, 31614, 31637, 32166, 32143, 31615, 31638, 32167, 32144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21637, 31615, 31638, 32167, 32144, 31616, 31639, 32168, 32145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21638, 31616, 31639, 32168, 32145, 31617, 31640, 32169, 32146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21639, 31617, 31640, 32169, 32146, 31618, 31641, 32170, 32147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21640, 31618, 31641, 32170, 32147, 31619, 31642, 32171, 32148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21641, 31619, 31642, 32171, 32148, 31620, 31643, 32172, 32149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21642, 31620, 31643, 32172, 32149, 31621, 31644, 32173, 32150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21643, 31621, 31644, 32173, 32150, 31622, 31645, 32174, 32151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21644, 31622, 31645, 32174, 32151, 31623, 31646, 32175, 32152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21645, 31623, 31646, 32175, 32152, 8529, 8530, 8553, 8552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21646, 6713, 6714, 6737, 6736, 31624, 31647, 32176, 32153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21647, 31624, 31647, 32176, 32153, 31625, 31648, 32177, 32154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21648, 31625, 31648, 32177, 32154, 31626, 31649, 32178, 32155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21649, 31626, 31649, 32178, 32155, 31627, 31650, 32179, 32156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21650, 31627, 31650, 32179, 32156, 31628, 31651, 32180, 32157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21651, 31628, 31651, 32180, 32157, 31629, 31652, 32181, 32158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21652, 31629, 31652, 32181, 32158, 31630, 31653, 32182, 32159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21653, 31630, 31653, 32182, 32159, 31631, 31654, 32183, 32160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21654, 31631, 31654, 32183, 32160, 31632, 31655, 32184, 32161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21655, 31632, 31655, 32184, 32161, 31633, 31656, 32185, 32162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21656, 31633, 31656, 32185, 32162, 31634, 31657, 32186, 32163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21657, 31634, 31657, 32186, 32163, 31635, 31658, 32187, 32164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21658, 31635, 31658, 32187, 32164, 31636, 31659, 32188, 32165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21659, 31636, 31659, 32188, 32165, 31637, 31660, 32189, 32166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21660, 31637, 31660, 32189, 32166, 31638, 31661, 32190, 32167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21661, 31638, 31661, 32190, 32167, 31639, 31662, 32191, 32168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21662, 31639, 31662, 32191, 32168, 31640, 31663, 32192, 32169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21663, 31640, 31663, 32192, 32169, 31641, 31664, 32193, 32170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21664, 31641, 31664, 32193, 32170, 31642, 31665, 32194, 32171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21665, 31642, 31665, 32194, 32171, 31643, 31666, 32195, 32172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21666, 31643, 31666, 32195, 32172, 31644, 31667, 32196, 32173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21667, 31644, 31667, 32196, 32173, 31645, 31668, 32197, 32174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21668, 31645, 31668, 32197, 32174, 31646, 31669, 32198, 32175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21669, 31646, 31669, 32198, 32175, 8530, 8531, 8554, 8553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21670, 6714, 839, 840, 6737, 31647, 8256, 8279, 32176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21671, 31647, 8256, 8279, 32176, 31648, 8257, 8280, 32177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21672, 31648, 8257, 8280, 32177, 31649, 8258, 8281, 32178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21673, 31649, 8258, 8281, 32178, 31650, 8259, 8282, 32179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21674, 31650, 8259, 8282, 32179, 31651, 8260, 8283, 32180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21675, 31651, 8260, 8283, 32180, 31652, 8261, 8284, 32181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21676, 31652, 8261, 8284, 32181, 31653, 8262, 8285, 32182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21677, 31653, 8262, 8285, 32182, 31654, 8263, 8286, 32183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21678, 31654, 8263, 8286, 32183, 31655, 8264, 8287, 32184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21679, 31655, 8264, 8287, 32184, 31656, 8265, 8288, 32185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21680, 31656, 8265, 8288, 32185, 31657, 8266, 8289, 32186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21681, 31657, 8266, 8289, 32186, 31658, 8267, 8290, 32187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21682, 31658, 8267, 8290, 32187, 31659, 8268, 8291, 32188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21683, 31659, 8268, 8291, 32188, 31660, 8269, 8292, 32189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21684, 31660, 8269, 8292, 32189, 31661, 8270, 8293, 32190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21685, 31661, 8270, 8293, 32190, 31662, 8271, 8294, 32191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21686, 31662, 8271, 8294, 32191, 31663, 8272, 8295, 32192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21687, 31663, 8272, 8295, 32192, 31664, 8273, 8296, 32193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21688, 31664, 8273, 8296, 32193, 31665, 8274, 8297, 32194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21689, 31665, 8274, 8297, 32194, 31666, 8275, 8298, 32195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21690, 31666, 8275, 8298, 32195, 31667, 8276, 8299, 32196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21691, 31667, 8276, 8299, 32196, 31668, 8277, 8300, 32197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21692, 31668, 8277, 8300, 32197, 31669, 8278, 8301, 32198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21693, 31669, 8278, 8301, 32198, 8531, 999, 1000, 8554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21694, 829, 6715, 6738, 830, 8026, 31670, 32199, 8049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21695, 8026, 31670, 32199, 8049, 8027, 31671, 32200, 8050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21696, 8027, 31671, 32200, 8050, 8028, 31672, 32201, 8051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21697, 8028, 31672, 32201, 8051, 8029, 31673, 32202, 8052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21698, 8029, 31673, 32202, 8052, 8030, 31674, 32203, 8053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21699, 8030, 31674, 32203, 8053, 8031, 31675, 32204, 8054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21700, 8031, 31675, 32204, 8054, 8032, 31676, 32205, 8055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21701, 8032, 31676, 32205, 8055, 8033, 31677, 32206, 8056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21702, 8033, 31677, 32206, 8056, 8034, 31678, 32207, 8057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21703, 8034, 31678, 32207, 8057, 8035, 31679, 32208, 8058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21704, 8035, 31679, 32208, 8058, 8036, 31680, 32209, 8059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21705, 8036, 31680, 32209, 8059, 8037, 31681, 32210, 8060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21706, 8037, 31681, 32210, 8060, 8038, 31682, 32211, 8061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21707, 8038, 31682, 32211, 8061, 8039, 31683, 32212, 8062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21708, 8039, 31683, 32212, 8062, 8040, 31684, 32213, 8063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21709, 8040, 31684, 32213, 8063, 8041, 31685, 32214, 8064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21710, 8041, 31685, 32214, 8064, 8042, 31686, 32215, 8065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21711, 8042, 31686, 32215, 8065, 8043, 31687, 32216, 8066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21712, 8043, 31687, 32216, 8066, 8044, 31688, 32217, 8067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21713, 8044, 31688, 32217, 8067, 8045, 31689, 32218, 8068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21714, 8045, 31689, 32218, 8068, 8046, 31690, 32219, 8069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21715, 8046, 31690, 32219, 8069, 8047, 31691, 32220, 8070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21716, 8047, 31691, 32220, 8070, 8048, 31692, 32221, 8071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21717, 8048, 31692, 32221, 8071, 989, 8532, 8555, 990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21718, 6715, 6716, 6739, 6738, 31670, 31693, 32222, 32199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21719, 31670, 31693, 32222, 32199, 31671, 31694, 32223, 32200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21720, 31671, 31694, 32223, 32200, 31672, 31695, 32224, 32201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21721, 31672, 31695, 32224, 32201, 31673, 31696, 32225, 32202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21722, 31673, 31696, 32225, 32202, 31674, 31697, 32226, 32203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21723, 31674, 31697, 32226, 32203, 31675, 31698, 32227, 32204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21724, 31675, 31698, 32227, 32204, 31676, 31699, 32228, 32205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21725, 31676, 31699, 32228, 32205, 31677, 31700, 32229, 32206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21726, 31677, 31700, 32229, 32206, 31678, 31701, 32230, 32207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21727, 31678, 31701, 32230, 32207, 31679, 31702, 32231, 32208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21728, 31679, 31702, 32231, 32208, 31680, 31703, 32232, 32209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21729, 31680, 31703, 32232, 32209, 31681, 31704, 32233, 32210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21730, 31681, 31704, 32233, 32210, 31682, 31705, 32234, 32211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21731, 31682, 31705, 32234, 32211, 31683, 31706, 32235, 32212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21732, 31683, 31706, 32235, 32212, 31684, 31707, 32236, 32213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21733, 31684, 31707, 32236, 32213, 31685, 31708, 32237, 32214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21734, 31685, 31708, 32237, 32214, 31686, 31709, 32238, 32215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21735, 31686, 31709, 32238, 32215, 31687, 31710, 32239, 32216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21736, 31687, 31710, 32239, 32216, 31688, 31711, 32240, 32217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21737, 31688, 31711, 32240, 32217, 31689, 31712, 32241, 32218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21738, 31689, 31712, 32241, 32218, 31690, 31713, 32242, 32219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21739, 31690, 31713, 32242, 32219, 31691, 31714, 32243, 32220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21740, 31691, 31714, 32243, 32220, 31692, 31715, 32244, 32221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21741, 31692, 31715, 32244, 32221, 8532, 8533, 8556, 8555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21742, 6716, 6717, 6740, 6739, 31693, 31716, 32245, 32222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21743, 31693, 31716, 32245, 32222, 31694, 31717, 32246, 32223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21744, 31694, 31717, 32246, 32223, 31695, 31718, 32247, 32224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21745, 31695, 31718, 32247, 32224, 31696, 31719, 32248, 32225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21746, 31696, 31719, 32248, 32225, 31697, 31720, 32249, 32226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21747, 31697, 31720, 32249, 32226, 31698, 31721, 32250, 32227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21748, 31698, 31721, 32250, 32227, 31699, 31722, 32251, 32228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21749, 31699, 31722, 32251, 32228, 31700, 31723, 32252, 32229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21750, 31700, 31723, 32252, 32229, 31701, 31724, 32253, 32230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21751, 31701, 31724, 32253, 32230, 31702, 31725, 32254, 32231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21752, 31702, 31725, 32254, 32231, 31703, 31726, 32255, 32232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21753, 31703, 31726, 32255, 32232, 31704, 31727, 32256, 32233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21754, 31704, 31727, 32256, 32233, 31705, 31728, 32257, 32234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21755, 31705, 31728, 32257, 32234, 31706, 31729, 32258, 32235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21756, 31706, 31729, 32258, 32235, 31707, 31730, 32259, 32236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21757, 31707, 31730, 32259, 32236, 31708, 31731, 32260, 32237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21758, 31708, 31731, 32260, 32237, 31709, 31732, 32261, 32238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21759, 31709, 31732, 32261, 32238, 31710, 31733, 32262, 32239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21760, 31710, 31733, 32262, 32239, 31711, 31734, 32263, 32240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21761, 31711, 31734, 32263, 32240, 31712, 31735, 32264, 32241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21762, 31712, 31735, 32264, 32241, 31713, 31736, 32265, 32242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21763, 31713, 31736, 32265, 32242, 31714, 31737, 32266, 32243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21764, 31714, 31737, 32266, 32243, 31715, 31738, 32267, 32244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21765, 31715, 31738, 32267, 32244, 8533, 8534, 8557, 8556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21766, 6717, 6718, 6741, 6740, 31716, 31739, 32268, 32245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21767, 31716, 31739, 32268, 32245, 31717, 31740, 32269, 32246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21768, 31717, 31740, 32269, 32246, 31718, 31741, 32270, 32247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21769, 31718, 31741, 32270, 32247, 31719, 31742, 32271, 32248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21770, 31719, 31742, 32271, 32248, 31720, 31743, 32272, 32249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21771, 31720, 31743, 32272, 32249, 31721, 31744, 32273, 32250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21772, 31721, 31744, 32273, 32250, 31722, 31745, 32274, 32251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21773, 31722, 31745, 32274, 32251, 31723, 31746, 32275, 32252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21774, 31723, 31746, 32275, 32252, 31724, 31747, 32276, 32253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21775, 31724, 31747, 32276, 32253, 31725, 31748, 32277, 32254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21776, 31725, 31748, 32277, 32254, 31726, 31749, 32278, 32255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21777, 31726, 31749, 32278, 32255, 31727, 31750, 32279, 32256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21778, 31727, 31750, 32279, 32256, 31728, 31751, 32280, 32257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21779, 31728, 31751, 32280, 32257, 31729, 31752, 32281, 32258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21780, 31729, 31752, 32281, 32258, 31730, 31753, 32282, 32259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21781, 31730, 31753, 32282, 32259, 31731, 31754, 32283, 32260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21782, 31731, 31754, 32283, 32260, 31732, 31755, 32284, 32261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21783, 31732, 31755, 32284, 32261, 31733, 31756, 32285, 32262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21784, 31733, 31756, 32285, 32262, 31734, 31757, 32286, 32263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21785, 31734, 31757, 32286, 32263, 31735, 31758, 32287, 32264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21786, 31735, 31758, 32287, 32264, 31736, 31759, 32288, 32265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21787, 31736, 31759, 32288, 32265, 31737, 31760, 32289, 32266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21788, 31737, 31760, 32289, 32266, 31738, 31761, 32290, 32267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21789, 31738, 31761, 32290, 32267, 8534, 8535, 8558, 8557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21790, 6718, 6719, 6742, 6741, 31739, 31762, 32291, 32268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21791, 31739, 31762, 32291, 32268, 31740, 31763, 32292, 32269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21792, 31740, 31763, 32292, 32269, 31741, 31764, 32293, 32270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21793, 31741, 31764, 32293, 32270, 31742, 31765, 32294, 32271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21794, 31742, 31765, 32294, 32271, 31743, 31766, 32295, 32272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21795, 31743, 31766, 32295, 32272, 31744, 31767, 32296, 32273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21796, 31744, 31767, 32296, 32273, 31745, 31768, 32297, 32274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21797, 31745, 31768, 32297, 32274, 31746, 31769, 32298, 32275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21798, 31746, 31769, 32298, 32275, 31747, 31770, 32299, 32276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21799, 31747, 31770, 32299, 32276, 31748, 31771, 32300, 32277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21800, 31748, 31771, 32300, 32277, 31749, 31772, 32301, 32278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21801, 31749, 31772, 32301, 32278, 31750, 31773, 32302, 32279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21802, 31750, 31773, 32302, 32279, 31751, 31774, 32303, 32280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21803, 31751, 31774, 32303, 32280, 31752, 31775, 32304, 32281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21804, 31752, 31775, 32304, 32281, 31753, 31776, 32305, 32282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21805, 31753, 31776, 32305, 32282, 31754, 31777, 32306, 32283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21806, 31754, 31777, 32306, 32283, 31755, 31778, 32307, 32284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21807, 31755, 31778, 32307, 32284, 31756, 31779, 32308, 32285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21808, 31756, 31779, 32308, 32285, 31757, 31780, 32309, 32286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21809, 31757, 31780, 32309, 32286, 31758, 31781, 32310, 32287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21810, 31758, 31781, 32310, 32287, 31759, 31782, 32311, 32288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21811, 31759, 31782, 32311, 32288, 31760, 31783, 32312, 32289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21812, 31760, 31783, 32312, 32289, 31761, 31784, 32313, 32290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21813, 31761, 31784, 32313, 32290, 8535, 8536, 8559, 8558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21814, 6719, 6720, 6743, 6742, 31762, 31785, 32314, 32291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21815, 31762, 31785, 32314, 32291, 31763, 31786, 32315, 32292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21816, 31763, 31786, 32315, 32292, 31764, 31787, 32316, 32293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21817, 31764, 31787, 32316, 32293, 31765, 31788, 32317, 32294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21818, 31765, 31788, 32317, 32294, 31766, 31789, 32318, 32295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21819, 31766, 31789, 32318, 32295, 31767, 31790, 32319, 32296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21820, 31767, 31790, 32319, 32296, 31768, 31791, 32320, 32297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21821, 31768, 31791, 32320, 32297, 31769, 31792, 32321, 32298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21822, 31769, 31792, 32321, 32298, 31770, 31793, 32322, 32299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21823, 31770, 31793, 32322, 32299, 31771, 31794, 32323, 32300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21824, 31771, 31794, 32323, 32300, 31772, 31795, 32324, 32301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21825, 31772, 31795, 32324, 32301, 31773, 31796, 32325, 32302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21826, 31773, 31796, 32325, 32302, 31774, 31797, 32326, 32303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21827, 31774, 31797, 32326, 32303, 31775, 31798, 32327, 32304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21828, 31775, 31798, 32327, 32304, 31776, 31799, 32328, 32305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21829, 31776, 31799, 32328, 32305, 31777, 31800, 32329, 32306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21830, 31777, 31800, 32329, 32306, 31778, 31801, 32330, 32307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21831, 31778, 31801, 32330, 32307, 31779, 31802, 32331, 32308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21832, 31779, 31802, 32331, 32308, 31780, 31803, 32332, 32309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21833, 31780, 31803, 32332, 32309, 31781, 31804, 32333, 32310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21834, 31781, 31804, 32333, 32310, 31782, 31805, 32334, 32311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21835, 31782, 31805, 32334, 32311, 31783, 31806, 32335, 32312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21836, 31783, 31806, 32335, 32312, 31784, 31807, 32336, 32313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21837, 31784, 31807, 32336, 32313, 8536, 8537, 8560, 8559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21838, 6720, 6721, 6744, 6743, 31785, 31808, 32337, 32314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21839, 31785, 31808, 32337, 32314, 31786, 31809, 32338, 32315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21840, 31786, 31809, 32338, 32315, 31787, 31810, 32339, 32316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21841, 31787, 31810, 32339, 32316, 31788, 31811, 32340, 32317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21842, 31788, 31811, 32340, 32317, 31789, 31812, 32341, 32318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21843, 31789, 31812, 32341, 32318, 31790, 31813, 32342, 32319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21844, 31790, 31813, 32342, 32319, 31791, 31814, 32343, 32320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21845, 31791, 31814, 32343, 32320, 31792, 31815, 32344, 32321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21846, 31792, 31815, 32344, 32321, 31793, 31816, 32345, 32322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21847, 31793, 31816, 32345, 32322, 31794, 31817, 32346, 32323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21848, 31794, 31817, 32346, 32323, 31795, 31818, 32347, 32324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21849, 31795, 31818, 32347, 32324, 31796, 31819, 32348, 32325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21850, 31796, 31819, 32348, 32325, 31797, 31820, 32349, 32326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21851, 31797, 31820, 32349, 32326, 31798, 31821, 32350, 32327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21852, 31798, 31821, 32350, 32327, 31799, 31822, 32351, 32328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21853, 31799, 31822, 32351, 32328, 31800, 31823, 32352, 32329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21854, 31800, 31823, 32352, 32329, 31801, 31824, 32353, 32330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21855, 31801, 31824, 32353, 32330, 31802, 31825, 32354, 32331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21856, 31802, 31825, 32354, 32331, 31803, 31826, 32355, 32332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21857, 31803, 31826, 32355, 32332, 31804, 31827, 32356, 32333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21858, 31804, 31827, 32356, 32333, 31805, 31828, 32357, 32334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21859, 31805, 31828, 32357, 32334, 31806, 31829, 32358, 32335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21860, 31806, 31829, 32358, 32335, 31807, 31830, 32359, 32336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21861, 31807, 31830, 32359, 32336, 8537, 8538, 8561, 8560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21862, 6721, 6722, 6745, 6744, 31808, 31831, 32360, 32337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21863, 31808, 31831, 32360, 32337, 31809, 31832, 32361, 32338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21864, 31809, 31832, 32361, 32338, 31810, 31833, 32362, 32339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21865, 31810, 31833, 32362, 32339, 31811, 31834, 32363, 32340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21866, 31811, 31834, 32363, 32340, 31812, 31835, 32364, 32341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21867, 31812, 31835, 32364, 32341, 31813, 31836, 32365, 32342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21868, 31813, 31836, 32365, 32342, 31814, 31837, 32366, 32343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21869, 31814, 31837, 32366, 32343, 31815, 31838, 32367, 32344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21870, 31815, 31838, 32367, 32344, 31816, 31839, 32368, 32345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21871, 31816, 31839, 32368, 32345, 31817, 31840, 32369, 32346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21872, 31817, 31840, 32369, 32346, 31818, 31841, 32370, 32347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21873, 31818, 31841, 32370, 32347, 31819, 31842, 32371, 32348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21874, 31819, 31842, 32371, 32348, 31820, 31843, 32372, 32349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21875, 31820, 31843, 32372, 32349, 31821, 31844, 32373, 32350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21876, 31821, 31844, 32373, 32350, 31822, 31845, 32374, 32351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21877, 31822, 31845, 32374, 32351, 31823, 31846, 32375, 32352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21878, 31823, 31846, 32375, 32352, 31824, 31847, 32376, 32353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21879, 31824, 31847, 32376, 32353, 31825, 31848, 32377, 32354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21880, 31825, 31848, 32377, 32354, 31826, 31849, 32378, 32355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21881, 31826, 31849, 32378, 32355, 31827, 31850, 32379, 32356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21882, 31827, 31850, 32379, 32356, 31828, 31851, 32380, 32357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21883, 31828, 31851, 32380, 32357, 31829, 31852, 32381, 32358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21884, 31829, 31852, 32381, 32358, 31830, 31853, 32382, 32359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21885, 31830, 31853, 32382, 32359, 8538, 8539, 8562, 8561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21886, 6722, 6723, 6746, 6745, 31831, 31854, 32383, 32360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21887, 31831, 31854, 32383, 32360, 31832, 31855, 32384, 32361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21888, 31832, 31855, 32384, 32361, 31833, 31856, 32385, 32362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21889, 31833, 31856, 32385, 32362, 31834, 31857, 32386, 32363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21890, 31834, 31857, 32386, 32363, 31835, 31858, 32387, 32364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21891, 31835, 31858, 32387, 32364, 31836, 31859, 32388, 32365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21892, 31836, 31859, 32388, 32365, 31837, 31860, 32389, 32366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21893, 31837, 31860, 32389, 32366, 31838, 31861, 32390, 32367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21894, 31838, 31861, 32390, 32367, 31839, 31862, 32391, 32368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21895, 31839, 31862, 32391, 32368, 31840, 31863, 32392, 32369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21896, 31840, 31863, 32392, 32369, 31841, 31864, 32393, 32370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21897, 31841, 31864, 32393, 32370, 31842, 31865, 32394, 32371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21898, 31842, 31865, 32394, 32371, 31843, 31866, 32395, 32372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21899, 31843, 31866, 32395, 32372, 31844, 31867, 32396, 32373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21900, 31844, 31867, 32396, 32373, 31845, 31868, 32397, 32374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21901, 31845, 31868, 32397, 32374, 31846, 31869, 32398, 32375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21902, 31846, 31869, 32398, 32375, 31847, 31870, 32399, 32376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21903, 31847, 31870, 32399, 32376, 31848, 31871, 32400, 32377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21904, 31848, 31871, 32400, 32377, 31849, 31872, 32401, 32378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21905, 31849, 31872, 32401, 32378, 31850, 31873, 32402, 32379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21906, 31850, 31873, 32402, 32379, 31851, 31874, 32403, 32380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21907, 31851, 31874, 32403, 32380, 31852, 31875, 32404, 32381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21908, 31852, 31875, 32404, 32381, 31853, 31876, 32405, 32382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21909, 31853, 31876, 32405, 32382, 8539, 8540, 8563, 8562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21910, 6723, 6724, 6747, 6746, 31854, 31877, 32406, 32383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21911, 31854, 31877, 32406, 32383, 31855, 31878, 32407, 32384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21912, 31855, 31878, 32407, 32384, 31856, 31879, 32408, 32385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21913, 31856, 31879, 32408, 32385, 31857, 31880, 32409, 32386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21914, 31857, 31880, 32409, 32386, 31858, 31881, 32410, 32387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21915, 31858, 31881, 32410, 32387, 31859, 31882, 32411, 32388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21916, 31859, 31882, 32411, 32388, 31860, 31883, 32412, 32389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21917, 31860, 31883, 32412, 32389, 31861, 31884, 32413, 32390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21918, 31861, 31884, 32413, 32390, 31862, 31885, 32414, 32391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21919, 31862, 31885, 32414, 32391, 31863, 31886, 32415, 32392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21920, 31863, 31886, 32415, 32392, 31864, 31887, 32416, 32393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21921, 31864, 31887, 32416, 32393, 31865, 31888, 32417, 32394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21922, 31865, 31888, 32417, 32394, 31866, 31889, 32418, 32395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21923, 31866, 31889, 32418, 32395, 31867, 31890, 32419, 32396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21924, 31867, 31890, 32419, 32396, 31868, 31891, 32420, 32397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21925, 31868, 31891, 32420, 32397, 31869, 31892, 32421, 32398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21926, 31869, 31892, 32421, 32398, 31870, 31893, 32422, 32399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21927, 31870, 31893, 32422, 32399, 31871, 31894, 32423, 32400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21928, 31871, 31894, 32423, 32400, 31872, 31895, 32424, 32401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21929, 31872, 31895, 32424, 32401, 31873, 31896, 32425, 32402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21930, 31873, 31896, 32425, 32402, 31874, 31897, 32426, 32403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21931, 31874, 31897, 32426, 32403, 31875, 31898, 32427, 32404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21932, 31875, 31898, 32427, 32404, 31876, 31899, 32428, 32405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21933, 31876, 31899, 32428, 32405, 8540, 8541, 8564, 8563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21934, 6724, 6725, 6748, 6747, 31877, 31900, 32429, 32406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21935, 31877, 31900, 32429, 32406, 31878, 31901, 32430, 32407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21936, 31878, 31901, 32430, 32407, 31879, 31902, 32431, 32408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21937, 31879, 31902, 32431, 32408, 31880, 31903, 32432, 32409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21938, 31880, 31903, 32432, 32409, 31881, 31904, 32433, 32410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21939, 31881, 31904, 32433, 32410, 31882, 31905, 32434, 32411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21940, 31882, 31905, 32434, 32411, 31883, 31906, 32435, 32412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21941, 31883, 31906, 32435, 32412, 31884, 31907, 32436, 32413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21942, 31884, 31907, 32436, 32413, 31885, 31908, 32437, 32414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21943, 31885, 31908, 32437, 32414, 31886, 31909, 32438, 32415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21944, 31886, 31909, 32438, 32415, 31887, 31910, 32439, 32416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21945, 31887, 31910, 32439, 32416, 31888, 31911, 32440, 32417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21946, 31888, 31911, 32440, 32417, 31889, 31912, 32441, 32418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21947, 31889, 31912, 32441, 32418, 31890, 31913, 32442, 32419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21948, 31890, 31913, 32442, 32419, 31891, 31914, 32443, 32420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21949, 31891, 31914, 32443, 32420, 31892, 31915, 32444, 32421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21950, 31892, 31915, 32444, 32421, 31893, 31916, 32445, 32422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21951, 31893, 31916, 32445, 32422, 31894, 31917, 32446, 32423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21952, 31894, 31917, 32446, 32423, 31895, 31918, 32447, 32424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21953, 31895, 31918, 32447, 32424, 31896, 31919, 32448, 32425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21954, 31896, 31919, 32448, 32425, 31897, 31920, 32449, 32426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21955, 31897, 31920, 32449, 32426, 31898, 31921, 32450, 32427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21956, 31898, 31921, 32450, 32427, 31899, 31922, 32451, 32428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21957, 31899, 31922, 32451, 32428, 8541, 8542, 8565, 8564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21958, 6725, 6726, 6749, 6748, 31900, 31923, 32452, 32429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21959, 31900, 31923, 32452, 32429, 31901, 31924, 32453, 32430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21960, 31901, 31924, 32453, 32430, 31902, 31925, 32454, 32431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21961, 31902, 31925, 32454, 32431, 31903, 31926, 32455, 32432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21962, 31903, 31926, 32455, 32432, 31904, 31927, 32456, 32433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21963, 31904, 31927, 32456, 32433, 31905, 31928, 32457, 32434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21964, 31905, 31928, 32457, 32434, 31906, 31929, 32458, 32435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21965, 31906, 31929, 32458, 32435, 31907, 31930, 32459, 32436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21966, 31907, 31930, 32459, 32436, 31908, 31931, 32460, 32437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21967, 31908, 31931, 32460, 32437, 31909, 31932, 32461, 32438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21968, 31909, 31932, 32461, 32438, 31910, 31933, 32462, 32439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21969, 31910, 31933, 32462, 32439, 31911, 31934, 32463, 32440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21970, 31911, 31934, 32463, 32440, 31912, 31935, 32464, 32441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21971, 31912, 31935, 32464, 32441, 31913, 31936, 32465, 32442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21972, 31913, 31936, 32465, 32442, 31914, 31937, 32466, 32443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21973, 31914, 31937, 32466, 32443, 31915, 31938, 32467, 32444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21974, 31915, 31938, 32467, 32444, 31916, 31939, 32468, 32445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21975, 31916, 31939, 32468, 32445, 31917, 31940, 32469, 32446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21976, 31917, 31940, 32469, 32446, 31918, 31941, 32470, 32447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21977, 31918, 31941, 32470, 32447, 31919, 31942, 32471, 32448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21978, 31919, 31942, 32471, 32448, 31920, 31943, 32472, 32449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21979, 31920, 31943, 32472, 32449, 31921, 31944, 32473, 32450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21980, 31921, 31944, 32473, 32450, 31922, 31945, 32474, 32451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21981, 31922, 31945, 32474, 32451, 8542, 8543, 8566, 8565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21982, 6726, 6727, 6750, 6749, 31923, 31946, 32475, 32452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21983, 31923, 31946, 32475, 32452, 31924, 31947, 32476, 32453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21984, 31924, 31947, 32476, 32453, 31925, 31948, 32477, 32454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21985, 31925, 31948, 32477, 32454, 31926, 31949, 32478, 32455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21986, 31926, 31949, 32478, 32455, 31927, 31950, 32479, 32456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21987, 31927, 31950, 32479, 32456, 31928, 31951, 32480, 32457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21988, 31928, 31951, 32480, 32457, 31929, 31952, 32481, 32458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21989, 31929, 31952, 32481, 32458, 31930, 31953, 32482, 32459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21990, 31930, 31953, 32482, 32459, 31931, 31954, 32483, 32460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21991, 31931, 31954, 32483, 32460, 31932, 31955, 32484, 32461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21992, 31932, 31955, 32484, 32461, 31933, 31956, 32485, 32462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21993, 31933, 31956, 32485, 32462, 31934, 31957, 32486, 32463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21994, 31934, 31957, 32486, 32463, 31935, 31958, 32487, 32464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21995, 31935, 31958, 32487, 32464, 31936, 31959, 32488, 32465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21996, 31936, 31959, 32488, 32465, 31937, 31960, 32489, 32466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21997, 31937, 31960, 32489, 32466, 31938, 31961, 32490, 32467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21998, 31938, 31961, 32490, 32467, 31939, 31962, 32491, 32468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21999, 31939, 31962, 32491, 32468, 31940, 31963, 32492, 32469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22000, 31940, 31963, 32492, 32469, 31941, 31964, 32493, 32470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22001, 31941, 31964, 32493, 32470, 31942, 31965, 32494, 32471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22002, 31942, 31965, 32494, 32471, 31943, 31966, 32495, 32472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22003, 31943, 31966, 32495, 32472, 31944, 31967, 32496, 32473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22004, 31944, 31967, 32496, 32473, 31945, 31968, 32497, 32474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22005, 31945, 31968, 32497, 32474, 8543, 8544, 8567, 8566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22006, 6727, 6728, 6751, 6750, 31946, 31969, 32498, 32475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22007, 31946, 31969, 32498, 32475, 31947, 31970, 32499, 32476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22008, 31947, 31970, 32499, 32476, 31948, 31971, 32500, 32477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22009, 31948, 31971, 32500, 32477, 31949, 31972, 32501, 32478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22010, 31949, 31972, 32501, 32478, 31950, 31973, 32502, 32479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22011, 31950, 31973, 32502, 32479, 31951, 31974, 32503, 32480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22012, 31951, 31974, 32503, 32480, 31952, 31975, 32504, 32481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22013, 31952, 31975, 32504, 32481, 31953, 31976, 32505, 32482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22014, 31953, 31976, 32505, 32482, 31954, 31977, 32506, 32483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22015, 31954, 31977, 32506, 32483, 31955, 31978, 32507, 32484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22016, 31955, 31978, 32507, 32484, 31956, 31979, 32508, 32485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22017, 31956, 31979, 32508, 32485, 31957, 31980, 32509, 32486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22018, 31957, 31980, 32509, 32486, 31958, 31981, 32510, 32487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22019, 31958, 31981, 32510, 32487, 31959, 31982, 32511, 32488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22020, 31959, 31982, 32511, 32488, 31960, 31983, 32512, 32489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22021, 31960, 31983, 32512, 32489, 31961, 31984, 32513, 32490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22022, 31961, 31984, 32513, 32490, 31962, 31985, 32514, 32491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22023, 31962, 31985, 32514, 32491, 31963, 31986, 32515, 32492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22024, 31963, 31986, 32515, 32492, 31964, 31987, 32516, 32493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22025, 31964, 31987, 32516, 32493, 31965, 31988, 32517, 32494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22026, 31965, 31988, 32517, 32494, 31966, 31989, 32518, 32495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22027, 31966, 31989, 32518, 32495, 31967, 31990, 32519, 32496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22028, 31967, 31990, 32519, 32496, 31968, 31991, 32520, 32497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22029, 31968, 31991, 32520, 32497, 8544, 8545, 8568, 8567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22030, 6728, 6729, 6752, 6751, 31969, 31992, 32521, 32498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22031, 31969, 31992, 32521, 32498, 31970, 31993, 32522, 32499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22032, 31970, 31993, 32522, 32499, 31971, 31994, 32523, 32500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22033, 31971, 31994, 32523, 32500, 31972, 31995, 32524, 32501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22034, 31972, 31995, 32524, 32501, 31973, 31996, 32525, 32502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22035, 31973, 31996, 32525, 32502, 31974, 31997, 32526, 32503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22036, 31974, 31997, 32526, 32503, 31975, 31998, 32527, 32504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22037, 31975, 31998, 32527, 32504, 31976, 31999, 32528, 32505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22038, 31976, 31999, 32528, 32505, 31977, 32000, 32529, 32506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22039, 31977, 32000, 32529, 32506, 31978, 32001, 32530, 32507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22040, 31978, 32001, 32530, 32507, 31979, 32002, 32531, 32508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22041, 31979, 32002, 32531, 32508, 31980, 32003, 32532, 32509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22042, 31980, 32003, 32532, 32509, 31981, 32004, 32533, 32510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22043, 31981, 32004, 32533, 32510, 31982, 32005, 32534, 32511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22044, 31982, 32005, 32534, 32511, 31983, 32006, 32535, 32512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22045, 31983, 32006, 32535, 32512, 31984, 32007, 32536, 32513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22046, 31984, 32007, 32536, 32513, 31985, 32008, 32537, 32514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22047, 31985, 32008, 32537, 32514, 31986, 32009, 32538, 32515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22048, 31986, 32009, 32538, 32515, 31987, 32010, 32539, 32516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22049, 31987, 32010, 32539, 32516, 31988, 32011, 32540, 32517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22050, 31988, 32011, 32540, 32517, 31989, 32012, 32541, 32518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22051, 31989, 32012, 32541, 32518, 31990, 32013, 32542, 32519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22052, 31990, 32013, 32542, 32519, 31991, 32014, 32543, 32520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22053, 31991, 32014, 32543, 32520, 8545, 8546, 8569, 8568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22054, 6729, 6730, 6753, 6752, 31992, 32015, 32544, 32521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22055, 31992, 32015, 32544, 32521, 31993, 32016, 32545, 32522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22056, 31993, 32016, 32545, 32522, 31994, 32017, 32546, 32523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22057, 31994, 32017, 32546, 32523, 31995, 32018, 32547, 32524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22058, 31995, 32018, 32547, 32524, 31996, 32019, 32548, 32525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22059, 31996, 32019, 32548, 32525, 31997, 32020, 32549, 32526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22060, 31997, 32020, 32549, 32526, 31998, 32021, 32550, 32527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22061, 31998, 32021, 32550, 32527, 31999, 32022, 32551, 32528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22062, 31999, 32022, 32551, 32528, 32000, 32023, 32552, 32529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22063, 32000, 32023, 32552, 32529, 32001, 32024, 32553, 32530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22064, 32001, 32024, 32553, 32530, 32002, 32025, 32554, 32531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22065, 32002, 32025, 32554, 32531, 32003, 32026, 32555, 32532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22066, 32003, 32026, 32555, 32532, 32004, 32027, 32556, 32533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22067, 32004, 32027, 32556, 32533, 32005, 32028, 32557, 32534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22068, 32005, 32028, 32557, 32534, 32006, 32029, 32558, 32535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22069, 32006, 32029, 32558, 32535, 32007, 32030, 32559, 32536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22070, 32007, 32030, 32559, 32536, 32008, 32031, 32560, 32537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22071, 32008, 32031, 32560, 32537, 32009, 32032, 32561, 32538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22072, 32009, 32032, 32561, 32538, 32010, 32033, 32562, 32539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22073, 32010, 32033, 32562, 32539, 32011, 32034, 32563, 32540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22074, 32011, 32034, 32563, 32540, 32012, 32035, 32564, 32541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22075, 32012, 32035, 32564, 32541, 32013, 32036, 32565, 32542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22076, 32013, 32036, 32565, 32542, 32014, 32037, 32566, 32543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22077, 32014, 32037, 32566, 32543, 8546, 8547, 8570, 8569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22078, 6730, 6731, 6754, 6753, 32015, 32038, 32567, 32544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22079, 32015, 32038, 32567, 32544, 32016, 32039, 32568, 32545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22080, 32016, 32039, 32568, 32545, 32017, 32040, 32569, 32546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22081, 32017, 32040, 32569, 32546, 32018, 32041, 32570, 32547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22082, 32018, 32041, 32570, 32547, 32019, 32042, 32571, 32548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22083, 32019, 32042, 32571, 32548, 32020, 32043, 32572, 32549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22084, 32020, 32043, 32572, 32549, 32021, 32044, 32573, 32550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22085, 32021, 32044, 32573, 32550, 32022, 32045, 32574, 32551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22086, 32022, 32045, 32574, 32551, 32023, 32046, 32575, 32552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22087, 32023, 32046, 32575, 32552, 32024, 32047, 32576, 32553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22088, 32024, 32047, 32576, 32553, 32025, 32048, 32577, 32554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22089, 32025, 32048, 32577, 32554, 32026, 32049, 32578, 32555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22090, 32026, 32049, 32578, 32555, 32027, 32050, 32579, 32556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22091, 32027, 32050, 32579, 32556, 32028, 32051, 32580, 32557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22092, 32028, 32051, 32580, 32557, 32029, 32052, 32581, 32558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22093, 32029, 32052, 32581, 32558, 32030, 32053, 32582, 32559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22094, 32030, 32053, 32582, 32559, 32031, 32054, 32583, 32560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22095, 32031, 32054, 32583, 32560, 32032, 32055, 32584, 32561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22096, 32032, 32055, 32584, 32561, 32033, 32056, 32585, 32562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22097, 32033, 32056, 32585, 32562, 32034, 32057, 32586, 32563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22098, 32034, 32057, 32586, 32563, 32035, 32058, 32587, 32564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22099, 32035, 32058, 32587, 32564, 32036, 32059, 32588, 32565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22100, 32036, 32059, 32588, 32565, 32037, 32060, 32589, 32566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22101, 32037, 32060, 32589, 32566, 8547, 8548, 8571, 8570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22102, 6731, 6732, 6755, 6754, 32038, 32061, 32590, 32567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22103, 32038, 32061, 32590, 32567, 32039, 32062, 32591, 32568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22104, 32039, 32062, 32591, 32568, 32040, 32063, 32592, 32569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22105, 32040, 32063, 32592, 32569, 32041, 32064, 32593, 32570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22106, 32041, 32064, 32593, 32570, 32042, 32065, 32594, 32571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22107, 32042, 32065, 32594, 32571, 32043, 32066, 32595, 32572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22108, 32043, 32066, 32595, 32572, 32044, 32067, 32596, 32573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22109, 32044, 32067, 32596, 32573, 32045, 32068, 32597, 32574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22110, 32045, 32068, 32597, 32574, 32046, 32069, 32598, 32575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22111, 32046, 32069, 32598, 32575, 32047, 32070, 32599, 32576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22112, 32047, 32070, 32599, 32576, 32048, 32071, 32600, 32577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22113, 32048, 32071, 32600, 32577, 32049, 32072, 32601, 32578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22114, 32049, 32072, 32601, 32578, 32050, 32073, 32602, 32579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22115, 32050, 32073, 32602, 32579, 32051, 32074, 32603, 32580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22116, 32051, 32074, 32603, 32580, 32052, 32075, 32604, 32581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22117, 32052, 32075, 32604, 32581, 32053, 32076, 32605, 32582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22118, 32053, 32076, 32605, 32582, 32054, 32077, 32606, 32583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22119, 32054, 32077, 32606, 32583, 32055, 32078, 32607, 32584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22120, 32055, 32078, 32607, 32584, 32056, 32079, 32608, 32585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22121, 32056, 32079, 32608, 32585, 32057, 32080, 32609, 32586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22122, 32057, 32080, 32609, 32586, 32058, 32081, 32610, 32587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22123, 32058, 32081, 32610, 32587, 32059, 32082, 32611, 32588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22124, 32059, 32082, 32611, 32588, 32060, 32083, 32612, 32589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22125, 32060, 32083, 32612, 32589, 8548, 8549, 8572, 8571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22126, 6732, 6733, 6756, 6755, 32061, 32084, 32613, 32590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22127, 32061, 32084, 32613, 32590, 32062, 32085, 32614, 32591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22128, 32062, 32085, 32614, 32591, 32063, 32086, 32615, 32592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22129, 32063, 32086, 32615, 32592, 32064, 32087, 32616, 32593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22130, 32064, 32087, 32616, 32593, 32065, 32088, 32617, 32594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22131, 32065, 32088, 32617, 32594, 32066, 32089, 32618, 32595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22132, 32066, 32089, 32618, 32595, 32067, 32090, 32619, 32596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22133, 32067, 32090, 32619, 32596, 32068, 32091, 32620, 32597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22134, 32068, 32091, 32620, 32597, 32069, 32092, 32621, 32598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22135, 32069, 32092, 32621, 32598, 32070, 32093, 32622, 32599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22136, 32070, 32093, 32622, 32599, 32071, 32094, 32623, 32600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22137, 32071, 32094, 32623, 32600, 32072, 32095, 32624, 32601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22138, 32072, 32095, 32624, 32601, 32073, 32096, 32625, 32602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22139, 32073, 32096, 32625, 32602, 32074, 32097, 32626, 32603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22140, 32074, 32097, 32626, 32603, 32075, 32098, 32627, 32604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22141, 32075, 32098, 32627, 32604, 32076, 32099, 32628, 32605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22142, 32076, 32099, 32628, 32605, 32077, 32100, 32629, 32606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22143, 32077, 32100, 32629, 32606, 32078, 32101, 32630, 32607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22144, 32078, 32101, 32630, 32607, 32079, 32102, 32631, 32608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22145, 32079, 32102, 32631, 32608, 32080, 32103, 32632, 32609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22146, 32080, 32103, 32632, 32609, 32081, 32104, 32633, 32610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22147, 32081, 32104, 32633, 32610, 32082, 32105, 32634, 32611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22148, 32082, 32105, 32634, 32611, 32083, 32106, 32635, 32612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22149, 32083, 32106, 32635, 32612, 8549, 8550, 8573, 8572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22150, 6733, 6734, 6757, 6756, 32084, 32107, 32636, 32613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22151, 32084, 32107, 32636, 32613, 32085, 32108, 32637, 32614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22152, 32085, 32108, 32637, 32614, 32086, 32109, 32638, 32615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22153, 32086, 32109, 32638, 32615, 32087, 32110, 32639, 32616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22154, 32087, 32110, 32639, 32616, 32088, 32111, 32640, 32617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22155, 32088, 32111, 32640, 32617, 32089, 32112, 32641, 32618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22156, 32089, 32112, 32641, 32618, 32090, 32113, 32642, 32619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22157, 32090, 32113, 32642, 32619, 32091, 32114, 32643, 32620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22158, 32091, 32114, 32643, 32620, 32092, 32115, 32644, 32621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22159, 32092, 32115, 32644, 32621, 32093, 32116, 32645, 32622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22160, 32093, 32116, 32645, 32622, 32094, 32117, 32646, 32623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22161, 32094, 32117, 32646, 32623, 32095, 32118, 32647, 32624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22162, 32095, 32118, 32647, 32624, 32096, 32119, 32648, 32625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22163, 32096, 32119, 32648, 32625, 32097, 32120, 32649, 32626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22164, 32097, 32120, 32649, 32626, 32098, 32121, 32650, 32627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22165, 32098, 32121, 32650, 32627, 32099, 32122, 32651, 32628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22166, 32099, 32122, 32651, 32628, 32100, 32123, 32652, 32629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22167, 32100, 32123, 32652, 32629, 32101, 32124, 32653, 32630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22168, 32101, 32124, 32653, 32630, 32102, 32125, 32654, 32631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22169, 32102, 32125, 32654, 32631, 32103, 32126, 32655, 32632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22170, 32103, 32126, 32655, 32632, 32104, 32127, 32656, 32633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22171, 32104, 32127, 32656, 32633, 32105, 32128, 32657, 32634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22172, 32105, 32128, 32657, 32634, 32106, 32129, 32658, 32635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22173, 32106, 32129, 32658, 32635, 8550, 8551, 8574, 8573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22174, 6734, 6735, 6758, 6757, 32107, 32130, 32659, 32636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22175, 32107, 32130, 32659, 32636, 32108, 32131, 32660, 32637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22176, 32108, 32131, 32660, 32637, 32109, 32132, 32661, 32638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22177, 32109, 32132, 32661, 32638, 32110, 32133, 32662, 32639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22178, 32110, 32133, 32662, 32639, 32111, 32134, 32663, 32640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22179, 32111, 32134, 32663, 32640, 32112, 32135, 32664, 32641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22180, 32112, 32135, 32664, 32641, 32113, 32136, 32665, 32642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22181, 32113, 32136, 32665, 32642, 32114, 32137, 32666, 32643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22182, 32114, 32137, 32666, 32643, 32115, 32138, 32667, 32644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22183, 32115, 32138, 32667, 32644, 32116, 32139, 32668, 32645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22184, 32116, 32139, 32668, 32645, 32117, 32140, 32669, 32646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22185, 32117, 32140, 32669, 32646, 32118, 32141, 32670, 32647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22186, 32118, 32141, 32670, 32647, 32119, 32142, 32671, 32648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22187, 32119, 32142, 32671, 32648, 32120, 32143, 32672, 32649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22188, 32120, 32143, 32672, 32649, 32121, 32144, 32673, 32650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22189, 32121, 32144, 32673, 32650, 32122, 32145, 32674, 32651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22190, 32122, 32145, 32674, 32651, 32123, 32146, 32675, 32652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22191, 32123, 32146, 32675, 32652, 32124, 32147, 32676, 32653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22192, 32124, 32147, 32676, 32653, 32125, 32148, 32677, 32654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22193, 32125, 32148, 32677, 32654, 32126, 32149, 32678, 32655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22194, 32126, 32149, 32678, 32655, 32127, 32150, 32679, 32656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22195, 32127, 32150, 32679, 32656, 32128, 32151, 32680, 32657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22196, 32128, 32151, 32680, 32657, 32129, 32152, 32681, 32658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22197, 32129, 32152, 32681, 32658, 8551, 8552, 8575, 8574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22198, 6735, 6736, 6759, 6758, 32130, 32153, 32682, 32659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22199, 32130, 32153, 32682, 32659, 32131, 32154, 32683, 32660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22200, 32131, 32154, 32683, 32660, 32132, 32155, 32684, 32661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22201, 32132, 32155, 32684, 32661, 32133, 32156, 32685, 32662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22202, 32133, 32156, 32685, 32662, 32134, 32157, 32686, 32663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22203, 32134, 32157, 32686, 32663, 32135, 32158, 32687, 32664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22204, 32135, 32158, 32687, 32664, 32136, 32159, 32688, 32665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22205, 32136, 32159, 32688, 32665, 32137, 32160, 32689, 32666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22206, 32137, 32160, 32689, 32666, 32138, 32161, 32690, 32667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22207, 32138, 32161, 32690, 32667, 32139, 32162, 32691, 32668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22208, 32139, 32162, 32691, 32668, 32140, 32163, 32692, 32669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22209, 32140, 32163, 32692, 32669, 32141, 32164, 32693, 32670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22210, 32141, 32164, 32693, 32670, 32142, 32165, 32694, 32671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22211, 32142, 32165, 32694, 32671, 32143, 32166, 32695, 32672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22212, 32143, 32166, 32695, 32672, 32144, 32167, 32696, 32673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22213, 32144, 32167, 32696, 32673, 32145, 32168, 32697, 32674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22214, 32145, 32168, 32697, 32674, 32146, 32169, 32698, 32675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22215, 32146, 32169, 32698, 32675, 32147, 32170, 32699, 32676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22216, 32147, 32170, 32699, 32676, 32148, 32171, 32700, 32677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22217, 32148, 32171, 32700, 32677, 32149, 32172, 32701, 32678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22218, 32149, 32172, 32701, 32678, 32150, 32173, 32702, 32679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22219, 32150, 32173, 32702, 32679, 32151, 32174, 32703, 32680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22220, 32151, 32174, 32703, 32680, 32152, 32175, 32704, 32681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22221, 32152, 32175, 32704, 32681, 8552, 8553, 8576, 8575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22222, 6736, 6737, 6760, 6759, 32153, 32176, 32705, 32682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22223, 32153, 32176, 32705, 32682, 32154, 32177, 32706, 32683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22224, 32154, 32177, 32706, 32683, 32155, 32178, 32707, 32684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22225, 32155, 32178, 32707, 32684, 32156, 32179, 32708, 32685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22226, 32156, 32179, 32708, 32685, 32157, 32180, 32709, 32686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22227, 32157, 32180, 32709, 32686, 32158, 32181, 32710, 32687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22228, 32158, 32181, 32710, 32687, 32159, 32182, 32711, 32688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22229, 32159, 32182, 32711, 32688, 32160, 32183, 32712, 32689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22230, 32160, 32183, 32712, 32689, 32161, 32184, 32713, 32690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22231, 32161, 32184, 32713, 32690, 32162, 32185, 32714, 32691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22232, 32162, 32185, 32714, 32691, 32163, 32186, 32715, 32692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22233, 32163, 32186, 32715, 32692, 32164, 32187, 32716, 32693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22234, 32164, 32187, 32716, 32693, 32165, 32188, 32717, 32694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22235, 32165, 32188, 32717, 32694, 32166, 32189, 32718, 32695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22236, 32166, 32189, 32718, 32695, 32167, 32190, 32719, 32696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22237, 32167, 32190, 32719, 32696, 32168, 32191, 32720, 32697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22238, 32168, 32191, 32720, 32697, 32169, 32192, 32721, 32698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22239, 32169, 32192, 32721, 32698, 32170, 32193, 32722, 32699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22240, 32170, 32193, 32722, 32699, 32171, 32194, 32723, 32700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22241, 32171, 32194, 32723, 32700, 32172, 32195, 32724, 32701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22242, 32172, 32195, 32724, 32701, 32173, 32196, 32725, 32702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22243, 32173, 32196, 32725, 32702, 32174, 32197, 32726, 32703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22244, 32174, 32197, 32726, 32703, 32175, 32198, 32727, 32704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22245, 32175, 32198, 32727, 32704, 8553, 8554, 8577, 8576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22246, 6737, 840, 841, 6760, 32176, 8279, 8302, 32705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22247, 32176, 8279, 8302, 32705, 32177, 8280, 8303, 32706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22248, 32177, 8280, 8303, 32706, 32178, 8281, 8304, 32707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22249, 32178, 8281, 8304, 32707, 32179, 8282, 8305, 32708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22250, 32179, 8282, 8305, 32708, 32180, 8283, 8306, 32709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22251, 32180, 8283, 8306, 32709, 32181, 8284, 8307, 32710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22252, 32181, 8284, 8307, 32710, 32182, 8285, 8308, 32711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22253, 32182, 8285, 8308, 32711, 32183, 8286, 8309, 32712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22254, 32183, 8286, 8309, 32712, 32184, 8287, 8310, 32713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22255, 32184, 8287, 8310, 32713, 32185, 8288, 8311, 32714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22256, 32185, 8288, 8311, 32714, 32186, 8289, 8312, 32715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22257, 32186, 8289, 8312, 32715, 32187, 8290, 8313, 32716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22258, 32187, 8290, 8313, 32716, 32188, 8291, 8314, 32717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22259, 32188, 8291, 8314, 32717, 32189, 8292, 8315, 32718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22260, 32189, 8292, 8315, 32718, 32190, 8293, 8316, 32719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22261, 32190, 8293, 8316, 32719, 32191, 8294, 8317, 32720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22262, 32191, 8294, 8317, 32720, 32192, 8295, 8318, 32721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22263, 32192, 8295, 8318, 32721, 32193, 8296, 8319, 32722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22264, 32193, 8296, 8319, 32722, 32194, 8297, 8320, 32723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22265, 32194, 8297, 8320, 32723, 32195, 8298, 8321, 32724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22266, 32195, 8298, 8321, 32724, 32196, 8299, 8322, 32725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22267, 32196, 8299, 8322, 32725, 32197, 8300, 8323, 32726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22268, 32197, 8300, 8323, 32726, 32198, 8301, 8324, 32727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22269, 32198, 8301, 8324, 32727, 8554, 1000, 1001, 8577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22270, 830, 6738, 774, 33, 8049, 32199, 6761, 842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22271, 8049, 32199, 6761, 842, 8050, 32200, 6762, 843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22272, 8050, 32200, 6762, 843, 8051, 32201, 6763, 844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22273, 8051, 32201, 6763, 844, 8052, 32202, 6764, 845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22274, 8052, 32202, 6764, 845, 8053, 32203, 6765, 846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22275, 8053, 32203, 6765, 846, 8054, 32204, 6766, 847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22276, 8054, 32204, 6766, 847, 8055, 32205, 6767, 848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22277, 8055, 32205, 6767, 848, 8056, 32206, 6768, 849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22278, 8056, 32206, 6768, 849, 8057, 32207, 6769, 850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22279, 8057, 32207, 6769, 850, 8058, 32208, 6770, 851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22280, 8058, 32208, 6770, 851, 8059, 32209, 6771, 852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22281, 8059, 32209, 6771, 852, 8060, 32210, 6772, 853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22282, 8060, 32210, 6772, 853, 8061, 32211, 6773, 854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22283, 8061, 32211, 6773, 854, 8062, 32212, 6774, 855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22284, 8062, 32212, 6774, 855, 8063, 32213, 6775, 856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22285, 8063, 32213, 6775, 856, 8064, 32214, 6776, 857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22286, 8064, 32214, 6776, 857, 8065, 32215, 6777, 858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22287, 8065, 32215, 6777, 858, 8066, 32216, 6778, 859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22288, 8066, 32216, 6778, 859, 8067, 32217, 6779, 860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22289, 8067, 32217, 6779, 860, 8068, 32218, 6780, 861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22290, 8068, 32218, 6780, 861, 8069, 32219, 6781, 862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22291, 8069, 32219, 6781, 862, 8070, 32220, 6782, 863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22292, 8070, 32220, 6782, 863, 8071, 32221, 6783, 864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22293, 8071, 32221, 6783, 864, 990, 8555, 888, 37, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22294, 6738, 6739, 775, 774, 32199, 32222, 6784, 6761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22295, 32199, 32222, 6784, 6761, 32200, 32223, 6785, 6762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22296, 32200, 32223, 6785, 6762, 32201, 32224, 6786, 6763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22297, 32201, 32224, 6786, 6763, 32202, 32225, 6787, 6764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22298, 32202, 32225, 6787, 6764, 32203, 32226, 6788, 6765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22299, 32203, 32226, 6788, 6765, 32204, 32227, 6789, 6766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22300, 32204, 32227, 6789, 6766, 32205, 32228, 6790, 6767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22301, 32205, 32228, 6790, 6767, 32206, 32229, 6791, 6768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22302, 32206, 32229, 6791, 6768, 32207, 32230, 6792, 6769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22303, 32207, 32230, 6792, 6769, 32208, 32231, 6793, 6770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22304, 32208, 32231, 6793, 6770, 32209, 32232, 6794, 6771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22305, 32209, 32232, 6794, 6771, 32210, 32233, 6795, 6772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22306, 32210, 32233, 6795, 6772, 32211, 32234, 6796, 6773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22307, 32211, 32234, 6796, 6773, 32212, 32235, 6797, 6774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22308, 32212, 32235, 6797, 6774, 32213, 32236, 6798, 6775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22309, 32213, 32236, 6798, 6775, 32214, 32237, 6799, 6776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22310, 32214, 32237, 6799, 6776, 32215, 32238, 6800, 6777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22311, 32215, 32238, 6800, 6777, 32216, 32239, 6801, 6778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22312, 32216, 32239, 6801, 6778, 32217, 32240, 6802, 6779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22313, 32217, 32240, 6802, 6779, 32218, 32241, 6803, 6780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22314, 32218, 32241, 6803, 6780, 32219, 32242, 6804, 6781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22315, 32219, 32242, 6804, 6781, 32220, 32243, 6805, 6782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22316, 32220, 32243, 6805, 6782, 32221, 32244, 6806, 6783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22317, 32221, 32244, 6806, 6783, 8555, 8556, 889, 888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22318, 6739, 6740, 776, 775, 32222, 32245, 6807, 6784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22319, 32222, 32245, 6807, 6784, 32223, 32246, 6808, 6785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22320, 32223, 32246, 6808, 6785, 32224, 32247, 6809, 6786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22321, 32224, 32247, 6809, 6786, 32225, 32248, 6810, 6787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22322, 32225, 32248, 6810, 6787, 32226, 32249, 6811, 6788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22323, 32226, 32249, 6811, 6788, 32227, 32250, 6812, 6789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22324, 32227, 32250, 6812, 6789, 32228, 32251, 6813, 6790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22325, 32228, 32251, 6813, 6790, 32229, 32252, 6814, 6791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22326, 32229, 32252, 6814, 6791, 32230, 32253, 6815, 6792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22327, 32230, 32253, 6815, 6792, 32231, 32254, 6816, 6793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22328, 32231, 32254, 6816, 6793, 32232, 32255, 6817, 6794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22329, 32232, 32255, 6817, 6794, 32233, 32256, 6818, 6795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22330, 32233, 32256, 6818, 6795, 32234, 32257, 6819, 6796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22331, 32234, 32257, 6819, 6796, 32235, 32258, 6820, 6797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22332, 32235, 32258, 6820, 6797, 32236, 32259, 6821, 6798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22333, 32236, 32259, 6821, 6798, 32237, 32260, 6822, 6799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22334, 32237, 32260, 6822, 6799, 32238, 32261, 6823, 6800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22335, 32238, 32261, 6823, 6800, 32239, 32262, 6824, 6801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22336, 32239, 32262, 6824, 6801, 32240, 32263, 6825, 6802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22337, 32240, 32263, 6825, 6802, 32241, 32264, 6826, 6803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22338, 32241, 32264, 6826, 6803, 32242, 32265, 6827, 6804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22339, 32242, 32265, 6827, 6804, 32243, 32266, 6828, 6805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22340, 32243, 32266, 6828, 6805, 32244, 32267, 6829, 6806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22341, 32244, 32267, 6829, 6806, 8556, 8557, 890, 889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22342, 6740, 6741, 777, 776, 32245, 32268, 6830, 6807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22343, 32245, 32268, 6830, 6807, 32246, 32269, 6831, 6808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22344, 32246, 32269, 6831, 6808, 32247, 32270, 6832, 6809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22345, 32247, 32270, 6832, 6809, 32248, 32271, 6833, 6810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22346, 32248, 32271, 6833, 6810, 32249, 32272, 6834, 6811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22347, 32249, 32272, 6834, 6811, 32250, 32273, 6835, 6812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22348, 32250, 32273, 6835, 6812, 32251, 32274, 6836, 6813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22349, 32251, 32274, 6836, 6813, 32252, 32275, 6837, 6814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22350, 32252, 32275, 6837, 6814, 32253, 32276, 6838, 6815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22351, 32253, 32276, 6838, 6815, 32254, 32277, 6839, 6816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22352, 32254, 32277, 6839, 6816, 32255, 32278, 6840, 6817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22353, 32255, 32278, 6840, 6817, 32256, 32279, 6841, 6818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22354, 32256, 32279, 6841, 6818, 32257, 32280, 6842, 6819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22355, 32257, 32280, 6842, 6819, 32258, 32281, 6843, 6820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22356, 32258, 32281, 6843, 6820, 32259, 32282, 6844, 6821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22357, 32259, 32282, 6844, 6821, 32260, 32283, 6845, 6822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22358, 32260, 32283, 6845, 6822, 32261, 32284, 6846, 6823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22359, 32261, 32284, 6846, 6823, 32262, 32285, 6847, 6824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22360, 32262, 32285, 6847, 6824, 32263, 32286, 6848, 6825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22361, 32263, 32286, 6848, 6825, 32264, 32287, 6849, 6826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22362, 32264, 32287, 6849, 6826, 32265, 32288, 6850, 6827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22363, 32265, 32288, 6850, 6827, 32266, 32289, 6851, 6828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22364, 32266, 32289, 6851, 6828, 32267, 32290, 6852, 6829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22365, 32267, 32290, 6852, 6829, 8557, 8558, 891, 890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22366, 6741, 6742, 778, 777, 32268, 32291, 6853, 6830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22367, 32268, 32291, 6853, 6830, 32269, 32292, 6854, 6831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22368, 32269, 32292, 6854, 6831, 32270, 32293, 6855, 6832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22369, 32270, 32293, 6855, 6832, 32271, 32294, 6856, 6833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22370, 32271, 32294, 6856, 6833, 32272, 32295, 6857, 6834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22371, 32272, 32295, 6857, 6834, 32273, 32296, 6858, 6835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22372, 32273, 32296, 6858, 6835, 32274, 32297, 6859, 6836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22373, 32274, 32297, 6859, 6836, 32275, 32298, 6860, 6837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22374, 32275, 32298, 6860, 6837, 32276, 32299, 6861, 6838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22375, 32276, 32299, 6861, 6838, 32277, 32300, 6862, 6839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22376, 32277, 32300, 6862, 6839, 32278, 32301, 6863, 6840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22377, 32278, 32301, 6863, 6840, 32279, 32302, 6864, 6841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22378, 32279, 32302, 6864, 6841, 32280, 32303, 6865, 6842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22379, 32280, 32303, 6865, 6842, 32281, 32304, 6866, 6843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22380, 32281, 32304, 6866, 6843, 32282, 32305, 6867, 6844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22381, 32282, 32305, 6867, 6844, 32283, 32306, 6868, 6845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22382, 32283, 32306, 6868, 6845, 32284, 32307, 6869, 6846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22383, 32284, 32307, 6869, 6846, 32285, 32308, 6870, 6847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22384, 32285, 32308, 6870, 6847, 32286, 32309, 6871, 6848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22385, 32286, 32309, 6871, 6848, 32287, 32310, 6872, 6849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22386, 32287, 32310, 6872, 6849, 32288, 32311, 6873, 6850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22387, 32288, 32311, 6873, 6850, 32289, 32312, 6874, 6851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22388, 32289, 32312, 6874, 6851, 32290, 32313, 6875, 6852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22389, 32290, 32313, 6875, 6852, 8558, 8559, 892, 891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22390, 6742, 6743, 779, 778, 32291, 32314, 6876, 6853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22391, 32291, 32314, 6876, 6853, 32292, 32315, 6877, 6854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22392, 32292, 32315, 6877, 6854, 32293, 32316, 6878, 6855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22393, 32293, 32316, 6878, 6855, 32294, 32317, 6879, 6856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22394, 32294, 32317, 6879, 6856, 32295, 32318, 6880, 6857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22395, 32295, 32318, 6880, 6857, 32296, 32319, 6881, 6858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22396, 32296, 32319, 6881, 6858, 32297, 32320, 6882, 6859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22397, 32297, 32320, 6882, 6859, 32298, 32321, 6883, 6860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22398, 32298, 32321, 6883, 6860, 32299, 32322, 6884, 6861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22399, 32299, 32322, 6884, 6861, 32300, 32323, 6885, 6862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22400, 32300, 32323, 6885, 6862, 32301, 32324, 6886, 6863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22401, 32301, 32324, 6886, 6863, 32302, 32325, 6887, 6864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22402, 32302, 32325, 6887, 6864, 32303, 32326, 6888, 6865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22403, 32303, 32326, 6888, 6865, 32304, 32327, 6889, 6866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22404, 32304, 32327, 6889, 6866, 32305, 32328, 6890, 6867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22405, 32305, 32328, 6890, 6867, 32306, 32329, 6891, 6868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22406, 32306, 32329, 6891, 6868, 32307, 32330, 6892, 6869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22407, 32307, 32330, 6892, 6869, 32308, 32331, 6893, 6870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22408, 32308, 32331, 6893, 6870, 32309, 32332, 6894, 6871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22409, 32309, 32332, 6894, 6871, 32310, 32333, 6895, 6872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22410, 32310, 32333, 6895, 6872, 32311, 32334, 6896, 6873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22411, 32311, 32334, 6896, 6873, 32312, 32335, 6897, 6874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22412, 32312, 32335, 6897, 6874, 32313, 32336, 6898, 6875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22413, 32313, 32336, 6898, 6875, 8559, 8560, 893, 892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22414, 6743, 6744, 780, 779, 32314, 32337, 6899, 6876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22415, 32314, 32337, 6899, 6876, 32315, 32338, 6900, 6877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22416, 32315, 32338, 6900, 6877, 32316, 32339, 6901, 6878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22417, 32316, 32339, 6901, 6878, 32317, 32340, 6902, 6879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22418, 32317, 32340, 6902, 6879, 32318, 32341, 6903, 6880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22419, 32318, 32341, 6903, 6880, 32319, 32342, 6904, 6881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22420, 32319, 32342, 6904, 6881, 32320, 32343, 6905, 6882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22421, 32320, 32343, 6905, 6882, 32321, 32344, 6906, 6883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22422, 32321, 32344, 6906, 6883, 32322, 32345, 6907, 6884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22423, 32322, 32345, 6907, 6884, 32323, 32346, 6908, 6885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22424, 32323, 32346, 6908, 6885, 32324, 32347, 6909, 6886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22425, 32324, 32347, 6909, 6886, 32325, 32348, 6910, 6887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22426, 32325, 32348, 6910, 6887, 32326, 32349, 6911, 6888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22427, 32326, 32349, 6911, 6888, 32327, 32350, 6912, 6889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22428, 32327, 32350, 6912, 6889, 32328, 32351, 6913, 6890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22429, 32328, 32351, 6913, 6890, 32329, 32352, 6914, 6891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22430, 32329, 32352, 6914, 6891, 32330, 32353, 6915, 6892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22431, 32330, 32353, 6915, 6892, 32331, 32354, 6916, 6893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22432, 32331, 32354, 6916, 6893, 32332, 32355, 6917, 6894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22433, 32332, 32355, 6917, 6894, 32333, 32356, 6918, 6895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22434, 32333, 32356, 6918, 6895, 32334, 32357, 6919, 6896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22435, 32334, 32357, 6919, 6896, 32335, 32358, 6920, 6897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22436, 32335, 32358, 6920, 6897, 32336, 32359, 6921, 6898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22437, 32336, 32359, 6921, 6898, 8560, 8561, 894, 893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22438, 6744, 6745, 781, 780, 32337, 32360, 6922, 6899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22439, 32337, 32360, 6922, 6899, 32338, 32361, 6923, 6900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22440, 32338, 32361, 6923, 6900, 32339, 32362, 6924, 6901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22441, 32339, 32362, 6924, 6901, 32340, 32363, 6925, 6902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22442, 32340, 32363, 6925, 6902, 32341, 32364, 6926, 6903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22443, 32341, 32364, 6926, 6903, 32342, 32365, 6927, 6904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22444, 32342, 32365, 6927, 6904, 32343, 32366, 6928, 6905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22445, 32343, 32366, 6928, 6905, 32344, 32367, 6929, 6906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22446, 32344, 32367, 6929, 6906, 32345, 32368, 6930, 6907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22447, 32345, 32368, 6930, 6907, 32346, 32369, 6931, 6908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22448, 32346, 32369, 6931, 6908, 32347, 32370, 6932, 6909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22449, 32347, 32370, 6932, 6909, 32348, 32371, 6933, 6910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22450, 32348, 32371, 6933, 6910, 32349, 32372, 6934, 6911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22451, 32349, 32372, 6934, 6911, 32350, 32373, 6935, 6912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22452, 32350, 32373, 6935, 6912, 32351, 32374, 6936, 6913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22453, 32351, 32374, 6936, 6913, 32352, 32375, 6937, 6914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22454, 32352, 32375, 6937, 6914, 32353, 32376, 6938, 6915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22455, 32353, 32376, 6938, 6915, 32354, 32377, 6939, 6916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22456, 32354, 32377, 6939, 6916, 32355, 32378, 6940, 6917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22457, 32355, 32378, 6940, 6917, 32356, 32379, 6941, 6918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22458, 32356, 32379, 6941, 6918, 32357, 32380, 6942, 6919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22459, 32357, 32380, 6942, 6919, 32358, 32381, 6943, 6920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22460, 32358, 32381, 6943, 6920, 32359, 32382, 6944, 6921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22461, 32359, 32382, 6944, 6921, 8561, 8562, 895, 894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22462, 6745, 6746, 782, 781, 32360, 32383, 6945, 6922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22463, 32360, 32383, 6945, 6922, 32361, 32384, 6946, 6923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22464, 32361, 32384, 6946, 6923, 32362, 32385, 6947, 6924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22465, 32362, 32385, 6947, 6924, 32363, 32386, 6948, 6925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22466, 32363, 32386, 6948, 6925, 32364, 32387, 6949, 6926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22467, 32364, 32387, 6949, 6926, 32365, 32388, 6950, 6927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22468, 32365, 32388, 6950, 6927, 32366, 32389, 6951, 6928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22469, 32366, 32389, 6951, 6928, 32367, 32390, 6952, 6929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22470, 32367, 32390, 6952, 6929, 32368, 32391, 6953, 6930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22471, 32368, 32391, 6953, 6930, 32369, 32392, 6954, 6931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22472, 32369, 32392, 6954, 6931, 32370, 32393, 6955, 6932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22473, 32370, 32393, 6955, 6932, 32371, 32394, 6956, 6933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22474, 32371, 32394, 6956, 6933, 32372, 32395, 6957, 6934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22475, 32372, 32395, 6957, 6934, 32373, 32396, 6958, 6935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22476, 32373, 32396, 6958, 6935, 32374, 32397, 6959, 6936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22477, 32374, 32397, 6959, 6936, 32375, 32398, 6960, 6937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22478, 32375, 32398, 6960, 6937, 32376, 32399, 6961, 6938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22479, 32376, 32399, 6961, 6938, 32377, 32400, 6962, 6939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22480, 32377, 32400, 6962, 6939, 32378, 32401, 6963, 6940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22481, 32378, 32401, 6963, 6940, 32379, 32402, 6964, 6941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22482, 32379, 32402, 6964, 6941, 32380, 32403, 6965, 6942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22483, 32380, 32403, 6965, 6942, 32381, 32404, 6966, 6943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22484, 32381, 32404, 6966, 6943, 32382, 32405, 6967, 6944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22485, 32382, 32405, 6967, 6944, 8562, 8563, 896, 895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22486, 6746, 6747, 783, 782, 32383, 32406, 6968, 6945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22487, 32383, 32406, 6968, 6945, 32384, 32407, 6969, 6946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22488, 32384, 32407, 6969, 6946, 32385, 32408, 6970, 6947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22489, 32385, 32408, 6970, 6947, 32386, 32409, 6971, 6948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22490, 32386, 32409, 6971, 6948, 32387, 32410, 6972, 6949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22491, 32387, 32410, 6972, 6949, 32388, 32411, 6973, 6950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22492, 32388, 32411, 6973, 6950, 32389, 32412, 6974, 6951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22493, 32389, 32412, 6974, 6951, 32390, 32413, 6975, 6952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22494, 32390, 32413, 6975, 6952, 32391, 32414, 6976, 6953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22495, 32391, 32414, 6976, 6953, 32392, 32415, 6977, 6954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22496, 32392, 32415, 6977, 6954, 32393, 32416, 6978, 6955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22497, 32393, 32416, 6978, 6955, 32394, 32417, 6979, 6956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22498, 32394, 32417, 6979, 6956, 32395, 32418, 6980, 6957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22499, 32395, 32418, 6980, 6957, 32396, 32419, 6981, 6958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22500, 32396, 32419, 6981, 6958, 32397, 32420, 6982, 6959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22501, 32397, 32420, 6982, 6959, 32398, 32421, 6983, 6960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22502, 32398, 32421, 6983, 6960, 32399, 32422, 6984, 6961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22503, 32399, 32422, 6984, 6961, 32400, 32423, 6985, 6962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22504, 32400, 32423, 6985, 6962, 32401, 32424, 6986, 6963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22505, 32401, 32424, 6986, 6963, 32402, 32425, 6987, 6964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22506, 32402, 32425, 6987, 6964, 32403, 32426, 6988, 6965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22507, 32403, 32426, 6988, 6965, 32404, 32427, 6989, 6966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22508, 32404, 32427, 6989, 6966, 32405, 32428, 6990, 6967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22509, 32405, 32428, 6990, 6967, 8563, 8564, 897, 896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22510, 6747, 6748, 784, 783, 32406, 32429, 6991, 6968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22511, 32406, 32429, 6991, 6968, 32407, 32430, 6992, 6969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22512, 32407, 32430, 6992, 6969, 32408, 32431, 6993, 6970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22513, 32408, 32431, 6993, 6970, 32409, 32432, 6994, 6971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22514, 32409, 32432, 6994, 6971, 32410, 32433, 6995, 6972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22515, 32410, 32433, 6995, 6972, 32411, 32434, 6996, 6973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22516, 32411, 32434, 6996, 6973, 32412, 32435, 6997, 6974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22517, 32412, 32435, 6997, 6974, 32413, 32436, 6998, 6975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22518, 32413, 32436, 6998, 6975, 32414, 32437, 6999, 6976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22519, 32414, 32437, 6999, 6976, 32415, 32438, 7000, 6977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22520, 32415, 32438, 7000, 6977, 32416, 32439, 7001, 6978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22521, 32416, 32439, 7001, 6978, 32417, 32440, 7002, 6979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22522, 32417, 32440, 7002, 6979, 32418, 32441, 7003, 6980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22523, 32418, 32441, 7003, 6980, 32419, 32442, 7004, 6981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22524, 32419, 32442, 7004, 6981, 32420, 32443, 7005, 6982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22525, 32420, 32443, 7005, 6982, 32421, 32444, 7006, 6983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22526, 32421, 32444, 7006, 6983, 32422, 32445, 7007, 6984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22527, 32422, 32445, 7007, 6984, 32423, 32446, 7008, 6985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22528, 32423, 32446, 7008, 6985, 32424, 32447, 7009, 6986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22529, 32424, 32447, 7009, 6986, 32425, 32448, 7010, 6987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22530, 32425, 32448, 7010, 6987, 32426, 32449, 7011, 6988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22531, 32426, 32449, 7011, 6988, 32427, 32450, 7012, 6989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22532, 32427, 32450, 7012, 6989, 32428, 32451, 7013, 6990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22533, 32428, 32451, 7013, 6990, 8564, 8565, 898, 897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22534, 6748, 6749, 785, 784, 32429, 32452, 7014, 6991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22535, 32429, 32452, 7014, 6991, 32430, 32453, 7015, 6992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22536, 32430, 32453, 7015, 6992, 32431, 32454, 7016, 6993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22537, 32431, 32454, 7016, 6993, 32432, 32455, 7017, 6994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22538, 32432, 32455, 7017, 6994, 32433, 32456, 7018, 6995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22539, 32433, 32456, 7018, 6995, 32434, 32457, 7019, 6996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22540, 32434, 32457, 7019, 6996, 32435, 32458, 7020, 6997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22541, 32435, 32458, 7020, 6997, 32436, 32459, 7021, 6998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22542, 32436, 32459, 7021, 6998, 32437, 32460, 7022, 6999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22543, 32437, 32460, 7022, 6999, 32438, 32461, 7023, 7000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22544, 32438, 32461, 7023, 7000, 32439, 32462, 7024, 7001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22545, 32439, 32462, 7024, 7001, 32440, 32463, 7025, 7002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22546, 32440, 32463, 7025, 7002, 32441, 32464, 7026, 7003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22547, 32441, 32464, 7026, 7003, 32442, 32465, 7027, 7004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22548, 32442, 32465, 7027, 7004, 32443, 32466, 7028, 7005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22549, 32443, 32466, 7028, 7005, 32444, 32467, 7029, 7006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22550, 32444, 32467, 7029, 7006, 32445, 32468, 7030, 7007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22551, 32445, 32468, 7030, 7007, 32446, 32469, 7031, 7008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22552, 32446, 32469, 7031, 7008, 32447, 32470, 7032, 7009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22553, 32447, 32470, 7032, 7009, 32448, 32471, 7033, 7010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22554, 32448, 32471, 7033, 7010, 32449, 32472, 7034, 7011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22555, 32449, 32472, 7034, 7011, 32450, 32473, 7035, 7012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22556, 32450, 32473, 7035, 7012, 32451, 32474, 7036, 7013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22557, 32451, 32474, 7036, 7013, 8565, 8566, 899, 898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22558, 6749, 6750, 786, 785, 32452, 32475, 7037, 7014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22559, 32452, 32475, 7037, 7014, 32453, 32476, 7038, 7015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22560, 32453, 32476, 7038, 7015, 32454, 32477, 7039, 7016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22561, 32454, 32477, 7039, 7016, 32455, 32478, 7040, 7017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22562, 32455, 32478, 7040, 7017, 32456, 32479, 7041, 7018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22563, 32456, 32479, 7041, 7018, 32457, 32480, 7042, 7019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22564, 32457, 32480, 7042, 7019, 32458, 32481, 7043, 7020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22565, 32458, 32481, 7043, 7020, 32459, 32482, 7044, 7021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22566, 32459, 32482, 7044, 7021, 32460, 32483, 7045, 7022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22567, 32460, 32483, 7045, 7022, 32461, 32484, 7046, 7023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22568, 32461, 32484, 7046, 7023, 32462, 32485, 7047, 7024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22569, 32462, 32485, 7047, 7024, 32463, 32486, 7048, 7025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22570, 32463, 32486, 7048, 7025, 32464, 32487, 7049, 7026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22571, 32464, 32487, 7049, 7026, 32465, 32488, 7050, 7027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22572, 32465, 32488, 7050, 7027, 32466, 32489, 7051, 7028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22573, 32466, 32489, 7051, 7028, 32467, 32490, 7052, 7029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22574, 32467, 32490, 7052, 7029, 32468, 32491, 7053, 7030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22575, 32468, 32491, 7053, 7030, 32469, 32492, 7054, 7031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22576, 32469, 32492, 7054, 7031, 32470, 32493, 7055, 7032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22577, 32470, 32493, 7055, 7032, 32471, 32494, 7056, 7033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22578, 32471, 32494, 7056, 7033, 32472, 32495, 7057, 7034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22579, 32472, 32495, 7057, 7034, 32473, 32496, 7058, 7035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22580, 32473, 32496, 7058, 7035, 32474, 32497, 7059, 7036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22581, 32474, 32497, 7059, 7036, 8566, 8567, 900, 899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22582, 6750, 6751, 787, 786, 32475, 32498, 7060, 7037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22583, 32475, 32498, 7060, 7037, 32476, 32499, 7061, 7038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22584, 32476, 32499, 7061, 7038, 32477, 32500, 7062, 7039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22585, 32477, 32500, 7062, 7039, 32478, 32501, 7063, 7040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22586, 32478, 32501, 7063, 7040, 32479, 32502, 7064, 7041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22587, 32479, 32502, 7064, 7041, 32480, 32503, 7065, 7042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22588, 32480, 32503, 7065, 7042, 32481, 32504, 7066, 7043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22589, 32481, 32504, 7066, 7043, 32482, 32505, 7067, 7044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22590, 32482, 32505, 7067, 7044, 32483, 32506, 7068, 7045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22591, 32483, 32506, 7068, 7045, 32484, 32507, 7069, 7046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22592, 32484, 32507, 7069, 7046, 32485, 32508, 7070, 7047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22593, 32485, 32508, 7070, 7047, 32486, 32509, 7071, 7048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22594, 32486, 32509, 7071, 7048, 32487, 32510, 7072, 7049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22595, 32487, 32510, 7072, 7049, 32488, 32511, 7073, 7050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22596, 32488, 32511, 7073, 7050, 32489, 32512, 7074, 7051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22597, 32489, 32512, 7074, 7051, 32490, 32513, 7075, 7052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22598, 32490, 32513, 7075, 7052, 32491, 32514, 7076, 7053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22599, 32491, 32514, 7076, 7053, 32492, 32515, 7077, 7054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22600, 32492, 32515, 7077, 7054, 32493, 32516, 7078, 7055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22601, 32493, 32516, 7078, 7055, 32494, 32517, 7079, 7056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22602, 32494, 32517, 7079, 7056, 32495, 32518, 7080, 7057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22603, 32495, 32518, 7080, 7057, 32496, 32519, 7081, 7058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22604, 32496, 32519, 7081, 7058, 32497, 32520, 7082, 7059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22605, 32497, 32520, 7082, 7059, 8567, 8568, 901, 900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22606, 6751, 6752, 788, 787, 32498, 32521, 7083, 7060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22607, 32498, 32521, 7083, 7060, 32499, 32522, 7084, 7061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22608, 32499, 32522, 7084, 7061, 32500, 32523, 7085, 7062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22609, 32500, 32523, 7085, 7062, 32501, 32524, 7086, 7063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22610, 32501, 32524, 7086, 7063, 32502, 32525, 7087, 7064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22611, 32502, 32525, 7087, 7064, 32503, 32526, 7088, 7065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22612, 32503, 32526, 7088, 7065, 32504, 32527, 7089, 7066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22613, 32504, 32527, 7089, 7066, 32505, 32528, 7090, 7067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22614, 32505, 32528, 7090, 7067, 32506, 32529, 7091, 7068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22615, 32506, 32529, 7091, 7068, 32507, 32530, 7092, 7069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22616, 32507, 32530, 7092, 7069, 32508, 32531, 7093, 7070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22617, 32508, 32531, 7093, 7070, 32509, 32532, 7094, 7071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22618, 32509, 32532, 7094, 7071, 32510, 32533, 7095, 7072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22619, 32510, 32533, 7095, 7072, 32511, 32534, 7096, 7073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22620, 32511, 32534, 7096, 7073, 32512, 32535, 7097, 7074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22621, 32512, 32535, 7097, 7074, 32513, 32536, 7098, 7075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22622, 32513, 32536, 7098, 7075, 32514, 32537, 7099, 7076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22623, 32514, 32537, 7099, 7076, 32515, 32538, 7100, 7077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22624, 32515, 32538, 7100, 7077, 32516, 32539, 7101, 7078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22625, 32516, 32539, 7101, 7078, 32517, 32540, 7102, 7079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22626, 32517, 32540, 7102, 7079, 32518, 32541, 7103, 7080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22627, 32518, 32541, 7103, 7080, 32519, 32542, 7104, 7081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22628, 32519, 32542, 7104, 7081, 32520, 32543, 7105, 7082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22629, 32520, 32543, 7105, 7082, 8568, 8569, 902, 901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22630, 6752, 6753, 789, 788, 32521, 32544, 7106, 7083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22631, 32521, 32544, 7106, 7083, 32522, 32545, 7107, 7084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22632, 32522, 32545, 7107, 7084, 32523, 32546, 7108, 7085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22633, 32523, 32546, 7108, 7085, 32524, 32547, 7109, 7086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22634, 32524, 32547, 7109, 7086, 32525, 32548, 7110, 7087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22635, 32525, 32548, 7110, 7087, 32526, 32549, 7111, 7088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22636, 32526, 32549, 7111, 7088, 32527, 32550, 7112, 7089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22637, 32527, 32550, 7112, 7089, 32528, 32551, 7113, 7090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22638, 32528, 32551, 7113, 7090, 32529, 32552, 7114, 7091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22639, 32529, 32552, 7114, 7091, 32530, 32553, 7115, 7092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22640, 32530, 32553, 7115, 7092, 32531, 32554, 7116, 7093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22641, 32531, 32554, 7116, 7093, 32532, 32555, 7117, 7094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22642, 32532, 32555, 7117, 7094, 32533, 32556, 7118, 7095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22643, 32533, 32556, 7118, 7095, 32534, 32557, 7119, 7096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22644, 32534, 32557, 7119, 7096, 32535, 32558, 7120, 7097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22645, 32535, 32558, 7120, 7097, 32536, 32559, 7121, 7098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22646, 32536, 32559, 7121, 7098, 32537, 32560, 7122, 7099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22647, 32537, 32560, 7122, 7099, 32538, 32561, 7123, 7100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22648, 32538, 32561, 7123, 7100, 32539, 32562, 7124, 7101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22649, 32539, 32562, 7124, 7101, 32540, 32563, 7125, 7102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22650, 32540, 32563, 7125, 7102, 32541, 32564, 7126, 7103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22651, 32541, 32564, 7126, 7103, 32542, 32565, 7127, 7104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22652, 32542, 32565, 7127, 7104, 32543, 32566, 7128, 7105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22653, 32543, 32566, 7128, 7105, 8569, 8570, 903, 902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22654, 6753, 6754, 790, 789, 32544, 32567, 7129, 7106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22655, 32544, 32567, 7129, 7106, 32545, 32568, 7130, 7107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22656, 32545, 32568, 7130, 7107, 32546, 32569, 7131, 7108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22657, 32546, 32569, 7131, 7108, 32547, 32570, 7132, 7109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22658, 32547, 32570, 7132, 7109, 32548, 32571, 7133, 7110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22659, 32548, 32571, 7133, 7110, 32549, 32572, 7134, 7111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22660, 32549, 32572, 7134, 7111, 32550, 32573, 7135, 7112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22661, 32550, 32573, 7135, 7112, 32551, 32574, 7136, 7113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22662, 32551, 32574, 7136, 7113, 32552, 32575, 7137, 7114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22663, 32552, 32575, 7137, 7114, 32553, 32576, 7138, 7115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22664, 32553, 32576, 7138, 7115, 32554, 32577, 7139, 7116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22665, 32554, 32577, 7139, 7116, 32555, 32578, 7140, 7117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
