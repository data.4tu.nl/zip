26570, 15345, 37449, 37493, 15349, 2005, 16108, 16119, 2006, 39602, 39748, 39749, 15504, 0, 0, 0, 
0, 15497, 39603, 39750, 15506
26571, 5630, 5631, 5642, 5641, 37446, 37450, 37494, 37490, 0, 0, 0, 0, 39606, 39752, 39753, 
39739, 39591, 39604, 39751, 39738
26572, 37446, 37450, 37494, 37490, 37447, 37451, 37495, 37491, 39606, 39752, 39753, 39739, 39609, 39755, 39756, 
39742, 39594, 39607, 39754, 39741
26573, 37447, 37451, 37495, 37491, 37448, 37452, 37496, 37492, 39609, 39755, 39756, 39742, 39612, 39758, 39759, 
39745, 39597, 39610, 39757, 39744
26574, 37448, 37452, 37496, 37492, 37449, 37453, 37497, 37493, 39612, 39758, 39759, 39745, 39615, 39761, 39762, 
39748, 39600, 39613, 39760, 39747
26575, 37449, 37453, 37497, 37493, 16108, 16109, 16120, 16119, 39615, 39761, 39762, 39748, 0, 0, 0, 
0, 39603, 39616, 39763, 39750
26576, 5631, 5632, 5643, 5642, 37450, 37454, 37498, 37494, 0, 0, 0, 0, 39619, 39765, 39766, 
39752, 39604, 39617, 39764, 39751
26577, 37450, 37454, 37498, 37494, 37451, 37455, 37499, 37495, 39619, 39765, 39766, 39752, 39622, 39768, 39769, 
39755, 39607, 39620, 39767, 39754
26578, 37451, 37455, 37499, 37495, 37452, 37456, 37500, 37496, 39622, 39768, 39769, 39755, 39625, 39771, 39772, 
39758, 39610, 39623, 39770, 39757
26579, 37452, 37456, 37500, 37496, 37453, 37457, 37501, 37497, 39625, 39771, 39772, 39758, 39628, 39774, 39775, 
39761, 39613, 39626, 39773, 39760
26580, 37453, 37457, 37501, 37497, 16109, 16110, 16121, 16120, 39628, 39774, 39775, 39761, 0, 0, 0, 
0, 39616, 39629, 39776, 39763
26581, 5632, 5633, 5644, 5643, 37454, 37458, 37502, 37498, 0, 0, 0, 0, 39632, 39778, 39779, 
39765, 39617, 39630, 39777, 39764
26582, 37454, 37458, 37502, 37498, 37455, 37459, 37503, 37499, 39632, 39778, 39779, 39765, 39635, 39781, 39782, 
39768, 39620, 39633, 39780, 39767
26583, 37455, 37459, 37503, 37499, 37456, 37460, 37504, 37500, 39635, 39781, 39782, 39768, 39638, 39784, 39785, 
39771, 39623, 39636, 39783, 39770
26584, 37456, 37460, 37504, 37500, 37457, 37461, 37505, 37501, 39638, 39784, 39785, 39771, 39641, 39787, 39788, 
39774, 39626, 39639, 39786, 39773
26585, 37457, 37461, 37505, 37501, 16110, 16111, 16122, 16121, 39641, 39787, 39788, 39774, 0, 0, 0, 
0, 39629, 39642, 39789, 39776
26586, 5633, 5634, 5645, 5644, 37458, 37462, 37506, 37502, 0, 0, 0, 0, 39645, 39791, 39792, 
39778, 39630, 39643, 39790, 39777
26587, 37458, 37462, 37506, 37502, 37459, 37463, 37507, 37503, 39645, 39791, 39792, 39778, 39648, 39794, 39795, 
39781, 39633, 39646, 39793, 39780
26588, 37459, 37463, 37507, 37503, 37460, 37464, 37508, 37504, 39648, 39794, 39795, 39781, 39651, 39797, 39798, 
39784, 39636, 39649, 39796, 39783
26589, 37460, 37464, 37508, 37504, 37461, 37465, 37509, 37505, 39651, 39797, 39798, 39784, 39654, 39800, 39801, 
39787, 39639, 39652, 39799, 39786
26590, 37461, 37465, 37509, 37505, 16111, 16112, 16123, 16122, 39654, 39800, 39801, 39787, 0, 0, 0, 
0, 39642, 39655, 39802, 39789
26591, 5634, 5635, 5646, 5645, 37462, 37466, 37510, 37506, 0, 0, 0, 0, 39658, 39804, 39805, 
39791, 39643, 39656, 39803, 39790
26592, 37462, 37466, 37510, 37506, 37463, 37467, 37511, 37507, 39658, 39804, 39805, 39791, 39661, 39807, 39808, 
39794, 39646, 39659, 39806, 39793
26593, 37463, 37467, 37511, 37507, 37464, 37468, 37512, 37508, 39661, 39807, 39808, 39794, 39664, 39810, 39811, 
39797, 39649, 39662, 39809, 39796
26594, 37464, 37468, 37512, 37508, 37465, 37469, 37513, 37509, 39664, 39810, 39811, 39797, 39667, 39813, 39814, 
39800, 39652, 39665, 39812, 39799
26595, 37465, 37469, 37513, 37509, 16112, 16113, 16124, 16123, 39667, 39813, 39814, 39800, 0, 0, 0, 
0, 39655, 39668, 39815, 39802
26596, 5635, 5636, 5647, 5646, 37466, 37470, 37514, 37510, 0, 0, 0, 0, 39671, 39817, 39818, 
39804, 39656, 39669, 39816, 39803
26597, 37466, 37470, 37514, 37510, 37467, 37471, 37515, 37511, 39671, 39817, 39818, 39804, 39674, 39820, 39821, 
39807, 39659, 39672, 39819, 39806
26598, 37467, 37471, 37515, 37511, 37468, 37472, 37516, 37512, 39674, 39820, 39821, 39807, 39677, 39823, 39824, 
39810, 39662, 39675, 39822, 39809
26599, 37468, 37472, 37516, 37512, 37469, 37473, 37517, 37513, 39677, 39823, 39824, 39810, 39680, 39826, 39827, 
39813, 39665, 39678, 39825, 39812
26600, 37469, 37473, 37517, 37513, 16113, 16114, 16125, 16124, 39680, 39826, 39827, 39813, 0, 0, 0, 
0, 39668, 39681, 39828, 39815
26601, 5636, 5637, 5648, 5647, 37470, 37474, 37518, 37514, 0, 0, 0, 0, 39684, 39830, 39831, 
39817, 39669, 39682, 39829, 39816
26602, 37470, 37474, 37518, 37514, 37471, 37475, 37519, 37515, 39684, 39830, 39831, 39817, 39687, 39833, 39834, 
39820, 39672, 39685, 39832, 39819
26603, 37471, 37475, 37519, 37515, 37472, 37476, 37520, 37516, 39687, 39833, 39834, 39820, 39690, 39836, 39837, 
39823, 39675, 39688, 39835, 39822
26604, 37472, 37476, 37520, 37516, 37473, 37477, 37521, 37517, 39690, 39836, 39837, 39823, 39693, 39839, 39840, 
39826, 39678, 39691, 39838, 39825
26605, 37473, 37477, 37521, 37517, 16114, 16115, 16126, 16125, 39693, 39839, 39840, 39826, 0, 0, 0, 
0, 39681, 39694, 39841, 39828
26606, 5637, 5638, 5649, 5648, 37474, 37478, 37522, 37518, 0, 0, 0, 0, 39697, 39843, 39844, 
39830, 39682, 39695, 39842, 39829
26607, 37474, 37478, 37522, 37518, 37475, 37479, 37523, 37519, 39697, 39843, 39844, 39830, 39700, 39846, 39847, 
39833, 39685, 39698, 39845, 39832
26608, 37475, 37479, 37523, 37519, 37476, 37480, 37524, 37520, 39700, 39846, 39847, 39833, 39703, 39849, 39850, 
39836, 39688, 39701, 39848, 39835
26609, 37476, 37480, 37524, 37520, 37477, 37481, 37525, 37521, 39703, 39849, 39850, 39836, 39706, 39852, 39853, 
39839, 39691, 39704, 39851, 39838
26610, 37477, 37481, 37525, 37521, 16115, 16116, 16127, 16126, 39706, 39852, 39853, 39839, 0, 0, 0, 
0, 39694, 39707, 39854, 39841
26611, 5638, 5639, 5650, 5649, 37478, 37482, 37526, 37522, 0, 0, 0, 0, 39710, 39856, 39857, 
39843, 39695, 39708, 39855, 39842
26612, 37478, 37482, 37526, 37522, 37479, 37483, 37527, 37523, 39710, 39856, 39857, 39843, 39713, 39859, 39860, 
39846, 39698, 39711, 39858, 39845
26613, 37479, 37483, 37527, 37523, 37480, 37484, 37528, 37524, 39713, 39859, 39860, 39846, 39716, 39862, 39863, 
39849, 39701, 39714, 39861, 39848
26614, 37480, 37484, 37528, 37524, 37481, 37485, 37529, 37525, 39716, 39862, 39863, 39849, 39719, 39865, 39866, 
39852, 39704, 39717, 39864, 39851
26615, 37481, 37485, 37529, 37525, 16116, 16117, 16128, 16127, 39719, 39865, 39866, 39852, 0, 0, 0, 
0, 39707, 39720, 39867, 39854
26616, 5639, 5640, 5651, 5650, 37482, 37486, 37530, 37526, 0, 0, 0, 0, 39723, 39869, 39870, 
39856, 39708, 39721, 39868, 39855
26617, 37482, 37486, 37530, 37526, 37483, 37487, 37531, 37527, 39723, 39869, 39870, 39856, 39726, 39872, 39873, 
39859, 39711, 39724, 39871, 39858
26618, 37483, 37487, 37531, 37527, 37484, 37488, 37532, 37528, 39726, 39872, 39873, 39859, 39729, 39875, 39876, 
39862, 39714, 39727, 39874, 39861
26619, 37484, 37488, 37532, 37528, 37485, 37489, 37533, 37529, 39729, 39875, 39876, 39862, 39732, 39878, 39879, 
39865, 39717, 39730, 39877, 39864
26620, 37485, 37489, 37533, 37529, 16117, 16118, 16129, 16128, 39732, 39878, 39879, 39865, 0, 0, 0, 
0, 39720, 39733, 39880, 39867
26621, 5640, 591, 592, 5651, 37486, 15792, 15796, 37530, 0, 0, 0, 0, 39734, 0, 39881, 
39869, 39721, 0, 0, 39868
26622, 37486, 15792, 15796, 37530, 37487, 15793, 15797, 37531, 39734, 0, 39881, 39869, 39735, 0, 39882, 
39872, 39724, 0, 0, 39871
26623, 37487, 15793, 15797, 37531, 37488, 15794, 15798, 37532, 39735, 0, 39882, 39872, 39736, 0, 39883, 
39875, 39727, 0, 0, 39874
26624, 37488, 15794, 15798, 37532, 37489, 15795, 15799, 37533, 39736, 0, 39883, 39875, 39737, 0, 39884, 
39878, 39730, 0, 0, 39877
26625, 37489, 15795, 15799, 37533, 16118, 2047, 2048, 16129, 39737, 0, 39884, 39878, 0, 0, 0, 
0, 39733, 0, 0, 39880
26626, 554, 5641, 5652, 555, 15346, 37490, 37534, 15350, 0, 0, 0, 0, 39740, 39886, 39887, 
15507, 15499, 39738, 39885, 15508
26627, 15346, 37490, 37534, 15350, 15347, 37491, 37535, 15351, 39740, 39886, 39887, 15507, 39743, 39889, 39890, 
15509, 15501, 39741, 39888, 15510
26628, 15347, 37491, 37535, 15351, 15348, 37492, 37536, 15352, 39743, 39889, 39890, 15509, 39746, 39892, 39893, 
15511, 15503, 39744, 39891, 15512
26629, 15348, 37492, 37536, 15352, 15349, 37493, 37537, 15353, 39746, 39892, 39893, 15511, 39749, 39895, 39896, 
15513, 15505, 39747, 39894, 15514
26630, 15349, 37493, 37537, 15353, 2006, 16119, 16130, 2007, 39749, 39895, 39896, 15513, 0, 0, 0, 
0, 15506, 39750, 39897, 15515
26631, 5641, 5642, 5653, 5652, 37490, 37494, 37538, 37534, 0, 0, 0, 0, 39753, 39899, 39900, 
39886, 39738, 39751, 39898, 39885
26632, 37490, 37494, 37538, 37534, 37491, 37495, 37539, 37535, 39753, 39899, 39900, 39886, 39756, 39902, 39903, 
39889, 39741, 39754, 39901, 39888
26633, 37491, 37495, 37539, 37535, 37492, 37496, 37540, 37536, 39756, 39902, 39903, 39889, 39759, 39905, 39906, 
39892, 39744, 39757, 39904, 39891
26634, 37492, 37496, 37540, 37536, 37493, 37497, 37541, 37537, 39759, 39905, 39906, 39892, 39762, 39908, 39909, 
39895, 39747, 39760, 39907, 39894
26635, 37493, 37497, 37541, 37537, 16119, 16120, 16131, 16130, 39762, 39908, 39909, 39895, 0, 0, 0, 
0, 39750, 39763, 39910, 39897
26636, 5642, 5643, 5654, 5653, 37494, 37498, 37542, 37538, 0, 0, 0, 0, 39766, 39912, 39913, 
39899, 39751, 39764, 39911, 39898
26637, 37494, 37498, 37542, 37538, 37495, 37499, 37543, 37539, 39766, 39912, 39913, 39899, 39769, 39915, 39916, 
39902, 39754, 39767, 39914, 39901
26638, 37495, 37499, 37543, 37539, 37496, 37500, 37544, 37540, 39769, 39915, 39916, 39902, 39772, 39918, 39919, 
39905, 39757, 39770, 39917, 39904
26639, 37496, 37500, 37544, 37540, 37497, 37501, 37545, 37541, 39772, 39918, 39919, 39905, 39775, 39921, 39922, 
39908, 39760, 39773, 39920, 39907
26640, 37497, 37501, 37545, 37541, 16120, 16121, 16132, 16131, 39775, 39921, 39922, 39908, 0, 0, 0, 
0, 39763, 39776, 39923, 39910
26641, 5643, 5644, 5655, 5654, 37498, 37502, 37546, 37542, 0, 0, 0, 0, 39779, 39925, 39926, 
39912, 39764, 39777, 39924, 39911
26642, 37498, 37502, 37546, 37542, 37499, 37503, 37547, 37543, 39779, 39925, 39926, 39912, 39782, 39928, 39929, 
39915, 39767, 39780, 39927, 39914
26643, 37499, 37503, 37547, 37543, 37500, 37504, 37548, 37544, 39782, 39928, 39929, 39915, 39785, 39931, 39932, 
39918, 39770, 39783, 39930, 39917
26644, 37500, 37504, 37548, 37544, 37501, 37505, 37549, 37545, 39785, 39931, 39932, 39918, 39788, 39934, 39935, 
39921, 39773, 39786, 39933, 39920
26645, 37501, 37505, 37549, 37545, 16121, 16122, 16133, 16132, 39788, 39934, 39935, 39921, 0, 0, 0, 
0, 39776, 39789, 39936, 39923
26646, 5644, 5645, 5656, 5655, 37502, 37506, 37550, 37546, 0, 0, 0, 0, 39792, 39938, 39939, 
39925, 39777, 39790, 39937, 39924
26647, 37502, 37506, 37550, 37546, 37503, 37507, 37551, 37547, 39792, 39938, 39939, 39925, 39795, 39941, 39942, 
39928, 39780, 39793, 39940, 39927
26648, 37503, 37507, 37551, 37547, 37504, 37508, 37552, 37548, 39795, 39941, 39942, 39928, 39798, 39944, 39945, 
39931, 39783, 39796, 39943, 39930
26649, 37504, 37508, 37552, 37548, 37505, 37509, 37553, 37549, 39798, 39944, 39945, 39931, 39801, 39947, 39948, 
39934, 39786, 39799, 39946, 39933
26650, 37505, 37509, 37553, 37549, 16122, 16123, 16134, 16133, 39801, 39947, 39948, 39934, 0, 0, 0, 
0, 39789, 39802, 39949, 39936
26651, 5645, 5646, 5657, 5656, 37506, 37510, 37554, 37550, 0, 0, 0, 0, 39805, 39951, 39952, 
39938, 39790, 39803, 39950, 39937
26652, 37506, 37510, 37554, 37550, 37507, 37511, 37555, 37551, 39805, 39951, 39952, 39938, 39808, 39954, 39955, 
39941, 39793, 39806, 39953, 39940
26653, 37507, 37511, 37555, 37551, 37508, 37512, 37556, 37552, 39808, 39954, 39955, 39941, 39811, 39957, 39958, 
39944, 39796, 39809, 39956, 39943
26654, 37508, 37512, 37556, 37552, 37509, 37513, 37557, 37553, 39811, 39957, 39958, 39944, 39814, 39960, 39961, 
39947, 39799, 39812, 39959, 39946
26655, 37509, 37513, 37557, 37553, 16123, 16124, 16135, 16134, 39814, 39960, 39961, 39947, 0, 0, 0, 
0, 39802, 39815, 39962, 39949
26656, 5646, 5647, 5658, 5657, 37510, 37514, 37558, 37554, 0, 0, 0, 0, 39818, 39964, 39965, 
39951, 39803, 39816, 39963, 39950
26657, 37510, 37514, 37558, 37554, 37511, 37515, 37559, 37555, 39818, 39964, 39965, 39951, 39821, 39967, 39968, 
39954, 39806, 39819, 39966, 39953
26658, 37511, 37515, 37559, 37555, 37512, 37516, 37560, 37556, 39821, 39967, 39968, 39954, 39824, 39970, 39971, 
39957, 39809, 39822, 39969, 39956
26659, 37512, 37516, 37560, 37556, 37513, 37517, 37561, 37557, 39824, 39970, 39971, 39957, 39827, 39973, 39974, 
39960, 39812, 39825, 39972, 39959
26660, 37513, 37517, 37561, 37557, 16124, 16125, 16136, 16135, 39827, 39973, 39974, 39960, 0, 0, 0, 
0, 39815, 39828, 39975, 39962
26661, 5647, 5648, 5659, 5658, 37514, 37518, 37562, 37558, 0, 0, 0, 0, 39831, 39977, 39978, 
39964, 39816, 39829, 39976, 39963
26662, 37514, 37518, 37562, 37558, 37515, 37519, 37563, 37559, 39831, 39977, 39978, 39964, 39834, 39980, 39981, 
39967, 39819, 39832, 39979, 39966
26663, 37515, 37519, 37563, 37559, 37516, 37520, 37564, 37560, 39834, 39980, 39981, 39967, 39837, 39983, 39984, 
39970, 39822, 39835, 39982, 39969
26664, 37516, 37520, 37564, 37560, 37517, 37521, 37565, 37561, 39837, 39983, 39984, 39970, 39840, 39986, 39987, 
39973, 39825, 39838, 39985, 39972
26665, 37517, 37521, 37565, 37561, 16125, 16126, 16137, 16136, 39840, 39986, 39987, 39973, 0, 0, 0, 
0, 39828, 39841, 39988, 39975
26666, 5648, 5649, 5660, 5659, 37518, 37522, 37566, 37562, 0, 0, 0, 0, 39844, 39990, 39991, 
39977, 39829, 39842, 39989, 39976
26667, 37518, 37522, 37566, 37562, 37519, 37523, 37567, 37563, 39844, 39990, 39991, 39977, 39847, 39993, 39994, 
39980, 39832, 39845, 39992, 39979
26668, 37519, 37523, 37567, 37563, 37520, 37524, 37568, 37564, 39847, 39993, 39994, 39980, 39850, 39996, 39997, 
39983, 39835, 39848, 39995, 39982
26669, 37520, 37524, 37568, 37564, 37521, 37525, 37569, 37565, 39850, 39996, 39997, 39983, 39853, 39999, 40000, 
39986, 39838, 39851, 39998, 39985
26670, 37521, 37525, 37569, 37565, 16126, 16127, 16138, 16137, 39853, 39999, 40000, 39986, 0, 0, 0, 
0, 39841, 39854, 40001, 39988
26671, 5649, 5650, 5661, 5660, 37522, 37526, 37570, 37566, 0, 0, 0, 0, 39857, 40003, 40004, 
39990, 39842, 39855, 40002, 39989
26672, 37522, 37526, 37570, 37566, 37523, 37527, 37571, 37567, 39857, 40003, 40004, 39990, 39860, 40006, 40007, 
39993, 39845, 39858, 40005, 39992
26673, 37523, 37527, 37571, 37567, 37524, 37528, 37572, 37568, 39860, 40006, 40007, 39993, 39863, 40009, 40010, 
39996, 39848, 39861, 40008, 39995
26674, 37524, 37528, 37572, 37568, 37525, 37529, 37573, 37569, 39863, 40009, 40010, 39996, 39866, 40012, 40013, 
39999, 39851, 39864, 40011, 39998
26675, 37525, 37529, 37573, 37569, 16127, 16128, 16139, 16138, 39866, 40012, 40013, 39999, 0, 0, 0, 
0, 39854, 39867, 40014, 40001
26676, 5650, 5651, 5662, 5661, 37526, 37530, 37574, 37570, 0, 0, 0, 0, 39870, 40016, 40017, 
40003, 39855, 39868, 40015, 40002
26677, 37526, 37530, 37574, 37570, 37527, 37531, 37575, 37571, 39870, 40016, 40017, 40003, 39873, 40019, 40020, 
40006, 39858, 39871, 40018, 40005
26678, 37527, 37531, 37575, 37571, 37528, 37532, 37576, 37572, 39873, 40019, 40020, 40006, 39876, 40022, 40023, 
40009, 39861, 39874, 40021, 40008
26679, 37528, 37532, 37576, 37572, 37529, 37533, 37577, 37573, 39876, 40022, 40023, 40009, 39879, 40025, 40026, 
40012, 39864, 39877, 40024, 40011
26680, 37529, 37533, 37577, 37573, 16128, 16129, 16140, 16139, 39879, 40025, 40026, 40012, 0, 0, 0, 
0, 39867, 39880, 40027, 40014
26681, 5651, 592, 593, 5662, 37530, 15796, 15800, 37574, 0, 0, 0, 0, 39881, 0, 40028, 
40016, 39868, 0, 0, 40015
26682, 37530, 15796, 15800, 37574, 37531, 15797, 15801, 37575, 39881, 0, 40028, 40016, 39882, 0, 40029, 
40019, 39871, 0, 0, 40018
26683, 37531, 15797, 15801, 37575, 37532, 15798, 15802, 37576, 39882, 0, 40029, 40019, 39883, 0, 40030, 
40022, 39874, 0, 0, 40021
26684, 37532, 15798, 15802, 37576, 37533, 15799, 15803, 37577, 39883, 0, 40030, 40022, 39884, 0, 40031, 
40025, 39877, 0, 0, 40024
26685, 37533, 15799, 15803, 37577, 16129, 2048, 2049, 16140, 39884, 0, 40031, 40025, 0, 0, 0, 
0, 39880, 0, 0, 40027
26686, 555, 5652, 5663, 556, 15350, 37534, 37578, 15354, 0, 0, 0, 0, 39887, 40033, 40034, 
15516, 15508, 39885, 40032, 15517
26687, 15350, 37534, 37578, 15354, 15351, 37535, 37579, 15355, 39887, 40033, 40034, 15516, 39890, 40036, 40037, 
15518, 15510, 39888, 40035, 15519
26688, 15351, 37535, 37579, 15355, 15352, 37536, 37580, 15356, 39890, 40036, 40037, 15518, 39893, 40039, 40040, 
15520, 15512, 39891, 40038, 15521
26689, 15352, 37536, 37580, 15356, 15353, 37537, 37581, 15357, 39893, 40039, 40040, 15520, 39896, 40042, 40043, 
15522, 15514, 39894, 40041, 15523
26690, 15353, 37537, 37581, 15357, 2007, 16130, 16141, 2008, 39896, 40042, 40043, 15522, 0, 0, 0, 
0, 15515, 39897, 40044, 15524
26691, 5652, 5653, 5664, 5663, 37534, 37538, 37582, 37578, 0, 0, 0, 0, 39900, 40046, 40047, 
40033, 39885, 39898, 40045, 40032
26692, 37534, 37538, 37582, 37578, 37535, 37539, 37583, 37579, 39900, 40046, 40047, 40033, 39903, 40049, 40050, 
40036, 39888, 39901, 40048, 40035
26693, 37535, 37539, 37583, 37579, 37536, 37540, 37584, 37580, 39903, 40049, 40050, 40036, 39906, 40052, 40053, 
40039, 39891, 39904, 40051, 40038
26694, 37536, 37540, 37584, 37580, 37537, 37541, 37585, 37581, 39906, 40052, 40053, 40039, 39909, 40055, 40056, 
40042, 39894, 39907, 40054, 40041
26695, 37537, 37541, 37585, 37581, 16130, 16131, 16142, 16141, 39909, 40055, 40056, 40042, 0, 0, 0, 
0, 39897, 39910, 40057, 40044
26696, 5653, 5654, 5665, 5664, 37538, 37542, 37586, 37582, 0, 0, 0, 0, 39913, 40059, 40060, 
40046, 39898, 39911, 40058, 40045
26697, 37538, 37542, 37586, 37582, 37539, 37543, 37587, 37583, 39913, 40059, 40060, 40046, 39916, 40062, 40063, 
40049, 39901, 39914, 40061, 40048
26698, 37539, 37543, 37587, 37583, 37540, 37544, 37588, 37584, 39916, 40062, 40063, 40049, 39919, 40065, 40066, 
40052, 39904, 39917, 40064, 40051
26699, 37540, 37544, 37588, 37584, 37541, 37545, 37589, 37585, 39919, 40065, 40066, 40052, 39922, 40068, 40069, 
40055, 39907, 39920, 40067, 40054
26700, 37541, 37545, 37589, 37585, 16131, 16132, 16143, 16142, 39922, 40068, 40069, 40055, 0, 0, 0, 
0, 39910, 39923, 40070, 40057
26701, 5654, 5655, 5666, 5665, 37542, 37546, 37590, 37586, 0, 0, 0, 0, 39926, 40072, 40073, 
40059, 39911, 39924, 40071, 40058
26702, 37542, 37546, 37590, 37586, 37543, 37547, 37591, 37587, 39926, 40072, 40073, 40059, 39929, 40075, 40076, 
40062, 39914, 39927, 40074, 40061
26703, 37543, 37547, 37591, 37587, 37544, 37548, 37592, 37588, 39929, 40075, 40076, 40062, 39932, 40078, 40079, 
40065, 39917, 39930, 40077, 40064
26704, 37544, 37548, 37592, 37588, 37545, 37549, 37593, 37589, 39932, 40078, 40079, 40065, 39935, 40081, 40082, 
40068, 39920, 39933, 40080, 40067
26705, 37545, 37549, 37593, 37589, 16132, 16133, 16144, 16143, 39935, 40081, 40082, 40068, 0, 0, 0, 
0, 39923, 39936, 40083, 40070
26706, 5655, 5656, 5667, 5666, 37546, 37550, 37594, 37590, 0, 0, 0, 0, 39939, 40085, 40086, 
40072, 39924, 39937, 40084, 40071
26707, 37546, 37550, 37594, 37590, 37547, 37551, 37595, 37591, 39939, 40085, 40086, 40072, 39942, 40088, 40089, 
40075, 39927, 39940, 40087, 40074
26708, 37547, 37551, 37595, 37591, 37548, 37552, 37596, 37592, 39942, 40088, 40089, 40075, 39945, 40091, 40092, 
40078, 39930, 39943, 40090, 40077
26709, 37548, 37552, 37596, 37592, 37549, 37553, 37597, 37593, 39945, 40091, 40092, 40078, 39948, 40094, 40095, 
40081, 39933, 39946, 40093, 40080
26710, 37549, 37553, 37597, 37593, 16133, 16134, 16145, 16144, 39948, 40094, 40095, 40081, 0, 0, 0, 
0, 39936, 39949, 40096, 40083
26711, 5656, 5657, 5668, 5667, 37550, 37554, 37598, 37594, 0, 0, 0, 0, 39952, 40098, 40099, 
40085, 39937, 39950, 40097, 40084
26712, 37550, 37554, 37598, 37594, 37551, 37555, 37599, 37595, 39952, 40098, 40099, 40085, 39955, 40101, 40102, 
40088, 39940, 39953, 40100, 40087
26713, 37551, 37555, 37599, 37595, 37552, 37556, 37600, 37596, 39955, 40101, 40102, 40088, 39958, 40104, 40105, 
40091, 39943, 39956, 40103, 40090
26714, 37552, 37556, 37600, 37596, 37553, 37557, 37601, 37597, 39958, 40104, 40105, 40091, 39961, 40107, 40108, 
40094, 39946, 39959, 40106, 40093
26715, 37553, 37557, 37601, 37597, 16134, 16135, 16146, 16145, 39961, 40107, 40108, 40094, 0, 0, 0, 
0, 39949, 39962, 40109, 40096
26716, 5657, 5658, 5669, 5668, 37554, 37558, 37602, 37598, 0, 0, 0, 0, 39965, 40111, 40112, 
40098, 39950, 39963, 40110, 40097
26717, 37554, 37558, 37602, 37598, 37555, 37559, 37603, 37599, 39965, 40111, 40112, 40098, 39968, 40114, 40115, 
40101, 39953, 39966, 40113, 40100
26718, 37555, 37559, 37603, 37599, 37556, 37560, 37604, 37600, 39968, 40114, 40115, 40101, 39971, 40117, 40118, 
40104, 39956, 39969, 40116, 40103
26719, 37556, 37560, 37604, 37600, 37557, 37561, 37605, 37601, 39971, 40117, 40118, 40104, 39974, 40120, 40121, 
40107, 39959, 39972, 40119, 40106
26720, 37557, 37561, 37605, 37601, 16135, 16136, 16147, 16146, 39974, 40120, 40121, 40107, 0, 0, 0, 
0, 39962, 39975, 40122, 40109
26721, 5658, 5659, 5670, 5669, 37558, 37562, 37606, 37602, 0, 0, 0, 0, 39978, 40124, 40125, 
40111, 39963, 39976, 40123, 40110
26722, 37558, 37562, 37606, 37602, 37559, 37563, 37607, 37603, 39978, 40124, 40125, 40111, 39981, 40127, 40128, 
40114, 39966, 39979, 40126, 40113
26723, 37559, 37563, 37607, 37603, 37560, 37564, 37608, 37604, 39981, 40127, 40128, 40114, 39984, 40130, 40131, 
40117, 39969, 39982, 40129, 40116
26724, 37560, 37564, 37608, 37604, 37561, 37565, 37609, 37605, 39984, 40130, 40131, 40117, 39987, 40133, 40134, 
40120, 39972, 39985, 40132, 40119
26725, 37561, 37565, 37609, 37605, 16136, 16137, 16148, 16147, 39987, 40133, 40134, 40120, 0, 0, 0, 
0, 39975, 39988, 40135, 40122
26726, 5659, 5660, 5671, 5670, 37562, 37566, 37610, 37606, 0, 0, 0, 0, 39991, 40137, 40138, 
40124, 39976, 39989, 40136, 40123
26727, 37562, 37566, 37610, 37606, 37563, 37567, 37611, 37607, 39991, 40137, 40138, 40124, 39994, 40140, 40141, 
40127, 39979, 39992, 40139, 40126
26728, 37563, 37567, 37611, 37607, 37564, 37568, 37612, 37608, 39994, 40140, 40141, 40127, 39997, 40143, 40144, 
40130, 39982, 39995, 40142, 40129
26729, 37564, 37568, 37612, 37608, 37565, 37569, 37613, 37609, 39997, 40143, 40144, 40130, 40000, 40146, 40147, 
40133, 39985, 39998, 40145, 40132
26730, 37565, 37569, 37613, 37609, 16137, 16138, 16149, 16148, 40000, 40146, 40147, 40133, 0, 0, 0, 
0, 39988, 40001, 40148, 40135
26731, 5660, 5661, 5672, 5671, 37566, 37570, 37614, 37610, 0, 0, 0, 0, 40004, 40150, 40151, 
40137, 39989, 40002, 40149, 40136
26732, 37566, 37570, 37614, 37610, 37567, 37571, 37615, 37611, 40004, 40150, 40151, 40137, 40007, 40153, 40154, 
40140, 39992, 40005, 40152, 40139
26733, 37567, 37571, 37615, 37611, 37568, 37572, 37616, 37612, 40007, 40153, 40154, 40140, 40010, 40156, 40157, 
40143, 39995, 40008, 40155, 40142
26734, 37568, 37572, 37616, 37612, 37569, 37573, 37617, 37613, 40010, 40156, 40157, 40143, 40013, 40159, 40160, 
40146, 39998, 40011, 40158, 40145
26735, 37569, 37573, 37617, 37613, 16138, 16139, 16150, 16149, 40013, 40159, 40160, 40146, 0, 0, 0, 
0, 40001, 40014, 40161, 40148
26736, 5661, 5662, 5673, 5672, 37570, 37574, 37618, 37614, 0, 0, 0, 0, 40017, 40163, 40164, 
40150, 40002, 40015, 40162, 40149
26737, 37570, 37574, 37618, 37614, 37571, 37575, 37619, 37615, 40017, 40163, 40164, 40150, 40020, 40166, 40167, 
40153, 40005, 40018, 40165, 40152
26738, 37571, 37575, 37619, 37615, 37572, 37576, 37620, 37616, 40020, 40166, 40167, 40153, 40023, 40169, 40170, 
40156, 40008, 40021, 40168, 40155
26739, 37572, 37576, 37620, 37616, 37573, 37577, 37621, 37617, 40023, 40169, 40170, 40156, 40026, 40172, 40173, 
40159, 40011, 40024, 40171, 40158
26740, 37573, 37577, 37621, 37617, 16139, 16140, 16151, 16150, 40026, 40172, 40173, 40159, 0, 0, 0, 
0, 40014, 40027, 40174, 40161
26741, 5662, 593, 594, 5673, 37574, 15800, 15804, 37618, 0, 0, 0, 0, 40028, 0, 40175, 
40163, 40015, 0, 0, 40162
26742, 37574, 15800, 15804, 37618, 37575, 15801, 15805, 37619, 40028, 0, 40175, 40163, 40029, 0, 40176, 
40166, 40018, 0, 0, 40165
26743, 37575, 15801, 15805, 37619, 37576, 15802, 15806, 37620, 40029, 0, 40176, 40166, 40030, 0, 40177, 
40169, 40021, 0, 0, 40168
26744, 37576, 15802, 15806, 37620, 37577, 15803, 15807, 37621, 40030, 0, 40177, 40169, 40031, 0, 40178, 
40172, 40024, 0, 0, 40171
26745, 37577, 15803, 15807, 37621, 16140, 2049, 2050, 16151, 40031, 0, 40178, 40172, 0, 0, 0, 
0, 40027, 0, 0, 40174
26746, 556, 5663, 5674, 557, 15354, 37578, 37622, 15358, 0, 0, 0, 0, 40034, 40180, 40181, 
15525, 15517, 40032, 40179, 15526
26747, 15354, 37578, 37622, 15358, 15355, 37579, 37623, 15359, 40034, 40180, 40181, 15525, 40037, 40183, 40184, 
15527, 15519, 40035, 40182, 15528
26748, 15355, 37579, 37623, 15359, 15356, 37580, 37624, 15360, 40037, 40183, 40184, 15527, 40040, 40186, 40187, 
15529, 15521, 40038, 40185, 15530
26749, 15356, 37580, 37624, 15360, 15357, 37581, 37625, 15361, 40040, 40186, 40187, 15529, 40043, 40189, 40190, 
15531, 15523, 40041, 40188, 15532
26750, 15357, 37581, 37625, 15361, 2008, 16141, 16152, 2009, 40043, 40189, 40190, 15531, 0, 0, 0, 
0, 15524, 40044, 40191, 15533
26751, 5663, 5664, 5675, 5674, 37578, 37582, 37626, 37622, 0, 0, 0, 0, 40047, 40193, 40194, 
40180, 40032, 40045, 40192, 40179
26752, 37578, 37582, 37626, 37622, 37579, 37583, 37627, 37623, 40047, 40193, 40194, 40180, 40050, 40196, 40197, 
40183, 40035, 40048, 40195, 40182
26753, 37579, 37583, 37627, 37623, 37580, 37584, 37628, 37624, 40050, 40196, 40197, 40183, 40053, 40199, 40200, 
40186, 40038, 40051, 40198, 40185
26754, 37580, 37584, 37628, 37624, 37581, 37585, 37629, 37625, 40053, 40199, 40200, 40186, 40056, 40202, 40203, 
40189, 40041, 40054, 40201, 40188
26755, 37581, 37585, 37629, 37625, 16141, 16142, 16153, 16152, 40056, 40202, 40203, 40189, 0, 0, 0, 
0, 40044, 40057, 40204, 40191
26756, 5664, 5665, 5676, 5675, 37582, 37586, 37630, 37626, 0, 0, 0, 0, 40060, 40206, 40207, 
40193, 40045, 40058, 40205, 40192
26757, 37582, 37586, 37630, 37626, 37583, 37587, 37631, 37627, 40060, 40206, 40207, 40193, 40063, 40209, 40210, 
40196, 40048, 40061, 40208, 40195
26758, 37583, 37587, 37631, 37627, 37584, 37588, 37632, 37628, 40063, 40209, 40210, 40196, 40066, 40212, 40213, 
40199, 40051, 40064, 40211, 40198
26759, 37584, 37588, 37632, 37628, 37585, 37589, 37633, 37629, 40066, 40212, 40213, 40199, 40069, 40215, 40216, 
40202, 40054, 40067, 40214, 40201
26760, 37585, 37589, 37633, 37629, 16142, 16143, 16154, 16153, 40069, 40215, 40216, 40202, 0, 0, 0, 
0, 40057, 40070, 40217, 40204
26761, 5665, 5666, 5677, 5676, 37586, 37590, 37634, 37630, 0, 0, 0, 0, 40073, 40219, 40220, 
40206, 40058, 40071, 40218, 40205
26762, 37586, 37590, 37634, 37630, 37587, 37591, 37635, 37631, 40073, 40219, 40220, 40206, 40076, 40222, 40223, 
40209, 40061, 40074, 40221, 40208
26763, 37587, 37591, 37635, 37631, 37588, 37592, 37636, 37632, 40076, 40222, 40223, 40209, 40079, 40225, 40226, 
40212, 40064, 40077, 40224, 40211
26764, 37588, 37592, 37636, 37632, 37589, 37593, 37637, 37633, 40079, 40225, 40226, 40212, 40082, 40228, 40229, 
40215, 40067, 40080, 40227, 40214
26765, 37589, 37593, 37637, 37633, 16143, 16144, 16155, 16154, 40082, 40228, 40229, 40215, 0, 0, 0, 
0, 40070, 40083, 40230, 40217
26766, 5666, 5667, 5678, 5677, 37590, 37594, 37638, 37634, 0, 0, 0, 0, 40086, 40232, 40233, 
40219, 40071, 40084, 40231, 40218
26767, 37590, 37594, 37638, 37634, 37591, 37595, 37639, 37635, 40086, 40232, 40233, 40219, 40089, 40235, 40236, 
40222, 40074, 40087, 40234, 40221
26768, 37591, 37595, 37639, 37635, 37592, 37596, 37640, 37636, 40089, 40235, 40236, 40222, 40092, 40238, 40239, 
40225, 40077, 40090, 40237, 40224
26769, 37592, 37596, 37640, 37636, 37593, 37597, 37641, 37637, 40092, 40238, 40239, 40225, 40095, 40241, 40242, 
40228, 40080, 40093, 40240, 40227
26770, 37593, 37597, 37641, 37637, 16144, 16145, 16156, 16155, 40095, 40241, 40242, 40228, 0, 0, 0, 
0, 40083, 40096, 40243, 40230
26771, 5667, 5668, 5679, 5678, 37594, 37598, 37642, 37638, 0, 0, 0, 0, 40099, 40245, 40246, 
40232, 40084, 40097, 40244, 40231
26772, 37594, 37598, 37642, 37638, 37595, 37599, 37643, 37639, 40099, 40245, 40246, 40232, 40102, 40248, 40249, 
40235, 40087, 40100, 40247, 40234
26773, 37595, 37599, 37643, 37639, 37596, 37600, 37644, 37640, 40102, 40248, 40249, 40235, 40105, 40251, 40252, 
40238, 40090, 40103, 40250, 40237
26774, 37596, 37600, 37644, 37640, 37597, 37601, 37645, 37641, 40105, 40251, 40252, 40238, 40108, 40254, 40255, 
40241, 40093, 40106, 40253, 40240
26775, 37597, 37601, 37645, 37641, 16145, 16146, 16157, 16156, 40108, 40254, 40255, 40241, 0, 0, 0, 
0, 40096, 40109, 40256, 40243
26776, 5668, 5669, 5680, 5679, 37598, 37602, 37646, 37642, 0, 0, 0, 0, 40112, 40258, 40259, 
40245, 40097, 40110, 40257, 40244
26777, 37598, 37602, 37646, 37642, 37599, 37603, 37647, 37643, 40112, 40258, 40259, 40245, 40115, 40261, 40262, 
40248, 40100, 40113, 40260, 40247
26778, 37599, 37603, 37647, 37643, 37600, 37604, 37648, 37644, 40115, 40261, 40262, 40248, 40118, 40264, 40265, 
40251, 40103, 40116, 40263, 40250
26779, 37600, 37604, 37648, 37644, 37601, 37605, 37649, 37645, 40118, 40264, 40265, 40251, 40121, 40267, 40268, 
40254, 40106, 40119, 40266, 40253
26780, 37601, 37605, 37649, 37645, 16146, 16147, 16158, 16157, 40121, 40267, 40268, 40254, 0, 0, 0, 
0, 40109, 40122, 40269, 40256
26781, 5669, 5670, 5681, 5680, 37602, 37606, 37650, 37646, 0, 0, 0, 0, 40125, 40271, 40272, 
40258, 40110, 40123, 40270, 40257
26782, 37602, 37606, 37650, 37646, 37603, 37607, 37651, 37647, 40125, 40271, 40272, 40258, 40128, 40274, 40275, 
40261, 40113, 40126, 40273, 40260
26783, 37603, 37607, 37651, 37647, 37604, 37608, 37652, 37648, 40128, 40274, 40275, 40261, 40131, 40277, 40278, 
40264, 40116, 40129, 40276, 40263
26784, 37604, 37608, 37652, 37648, 37605, 37609, 37653, 37649, 40131, 40277, 40278, 40264, 40134, 40280, 40281, 
40267, 40119, 40132, 40279, 40266
26785, 37605, 37609, 37653, 37649, 16147, 16148, 16159, 16158, 40134, 40280, 40281, 40267, 0, 0, 0, 
0, 40122, 40135, 40282, 40269
26786, 5670, 5671, 5682, 5681, 37606, 37610, 37654, 37650, 0, 0, 0, 0, 40138, 40284, 40285, 
40271, 40123, 40136, 40283, 40270
26787, 37606, 37610, 37654, 37650, 37607, 37611, 37655, 37651, 40138, 40284, 40285, 40271, 40141, 40287, 40288, 
40274, 40126, 40139, 40286, 40273
26788, 37607, 37611, 37655, 37651, 37608, 37612, 37656, 37652, 40141, 40287, 40288, 40274, 40144, 40290, 40291, 
40277, 40129, 40142, 40289, 40276
26789, 37608, 37612, 37656, 37652, 37609, 37613, 37657, 37653, 40144, 40290, 40291, 40277, 40147, 40293, 40294, 
40280, 40132, 40145, 40292, 40279
26790, 37609, 37613, 37657, 37653, 16148, 16149, 16160, 16159, 40147, 40293, 40294, 40280, 0, 0, 0, 
0, 40135, 40148, 40295, 40282
26791, 5671, 5672, 5683, 5682, 37610, 37614, 37658, 37654, 0, 0, 0, 0, 40151, 40297, 40298, 
40284, 40136, 40149, 40296, 40283
26792, 37610, 37614, 37658, 37654, 37611, 37615, 37659, 37655, 40151, 40297, 40298, 40284, 40154, 40300, 40301, 
40287, 40139, 40152, 40299, 40286
26793, 37611, 37615, 37659, 37655, 37612, 37616, 37660, 37656, 40154, 40300, 40301, 40287, 40157, 40303, 40304, 
40290, 40142, 40155, 40302, 40289
26794, 37612, 37616, 37660, 37656, 37613, 37617, 37661, 37657, 40157, 40303, 40304, 40290, 40160, 40306, 40307, 
40293, 40145, 40158, 40305, 40292
26795, 37613, 37617, 37661, 37657, 16149, 16150, 16161, 16160, 40160, 40306, 40307, 40293, 0, 0, 0, 
0, 40148, 40161, 40308, 40295
26796, 5672, 5673, 5684, 5683, 37614, 37618, 37662, 37658, 0, 0, 0, 0, 40164, 40310, 40311, 
40297, 40149, 40162, 40309, 40296
26797, 37614, 37618, 37662, 37658, 37615, 37619, 37663, 37659, 40164, 40310, 40311, 40297, 40167, 40313, 40314, 
40300, 40152, 40165, 40312, 40299
26798, 37615, 37619, 37663, 37659, 37616, 37620, 37664, 37660, 40167, 40313, 40314, 40300, 40170, 40316, 40317, 
40303, 40155, 40168, 40315, 40302
26799, 37616, 37620, 37664, 37660, 37617, 37621, 37665, 37661, 40170, 40316, 40317, 40303, 40173, 40319, 40320, 
40306, 40158, 40171, 40318, 40305
26800, 37617, 37621, 37665, 37661, 16150, 16151, 16162, 16161, 40173, 40319, 40320, 40306, 0, 0, 0, 
0, 40161, 40174, 40321, 40308
26801, 5673, 594, 595, 5684, 37618, 15804, 15808, 37662, 0, 0, 0, 0, 40175, 0, 40322, 
40310, 40162, 0, 0, 40309
26802, 37618, 15804, 15808, 37662, 37619, 15805, 15809, 37663, 40175, 0, 40322, 40310, 40176, 0, 40323, 
40313, 40165, 0, 0, 40312
26803, 37619, 15805, 15809, 37663, 37620, 15806, 15810, 37664, 40176, 0, 40323, 40313, 40177, 0, 40324, 
40316, 40168, 0, 0, 40315
26804, 37620, 15806, 15810, 37664, 37621, 15807, 15811, 37665, 40177, 0, 40324, 40316, 40178, 0, 40325, 
40319, 40171, 0, 0, 40318
26805, 37621, 15807, 15811, 37665, 16151, 2050, 2051, 16162, 40178, 0, 40325, 40319, 0, 0, 0, 
0, 40174, 0, 0, 40321
26806, 557, 5674, 5685, 558, 15358, 37622, 37666, 15362, 0, 0, 0, 0, 40181, 40327, 40328, 
15534, 15526, 40179, 40326, 15535
26807, 15358, 37622, 37666, 15362, 15359, 37623, 37667, 15363, 40181, 40327, 40328, 15534, 40184, 40330, 40331, 
15536, 15528, 40182, 40329, 15537
26808, 15359, 37623, 37667, 15363, 15360, 37624, 37668, 15364, 40184, 40330, 40331, 15536, 40187, 40333, 40334, 
15538, 15530, 40185, 40332, 15539
26809, 15360, 37624, 37668, 15364, 15361, 37625, 37669, 15365, 40187, 40333, 40334, 15538, 40190, 40336, 40337, 
15540, 15532, 40188, 40335, 15541
26810, 15361, 37625, 37669, 15365, 2009, 16152, 16163, 2010, 40190, 40336, 40337, 15540, 0, 0, 0, 
0, 15533, 40191, 40338, 15542
26811, 5674, 5675, 5686, 5685, 37622, 37626, 37670, 37666, 0, 0, 0, 0, 40194, 40340, 40341, 
40327, 40179, 40192, 40339, 40326
26812, 37622, 37626, 37670, 37666, 37623, 37627, 37671, 37667, 40194, 40340, 40341, 40327, 40197, 40343, 40344, 
40330, 40182, 40195, 40342, 40329
26813, 37623, 37627, 37671, 37667, 37624, 37628, 37672, 37668, 40197, 40343, 40344, 40330, 40200, 40346, 40347, 
40333, 40185, 40198, 40345, 40332
26814, 37624, 37628, 37672, 37668, 37625, 37629, 37673, 37669, 40200, 40346, 40347, 40333, 40203, 40349, 40350, 
40336, 40188, 40201, 40348, 40335
26815, 37625, 37629, 37673, 37669, 16152, 16153, 16164, 16163, 40203, 40349, 40350, 40336, 0, 0, 0, 
0, 40191, 40204, 40351, 40338
26816, 5675, 5676, 5687, 5686, 37626, 37630, 37674, 37670, 0, 0, 0, 0, 40207, 40353, 40354, 
40340, 40192, 40205, 40352, 40339
26817, 37626, 37630, 37674, 37670, 37627, 37631, 37675, 37671, 40207, 40353, 40354, 40340, 40210, 40356, 40357, 
40343, 40195, 40208, 40355, 40342
26818, 37627, 37631, 37675, 37671, 37628, 37632, 37676, 37672, 40210, 40356, 40357, 40343, 40213, 40359, 40360, 
40346, 40198, 40211, 40358, 40345
26819, 37628, 37632, 37676, 37672, 37629, 37633, 37677, 37673, 40213, 40359, 40360, 40346, 40216, 40362, 40363, 
40349, 40201, 40214, 40361, 40348
26820, 37629, 37633, 37677, 37673, 16153, 16154, 16165, 16164, 40216, 40362, 40363, 40349, 0, 0, 0, 
0, 40204, 40217, 40364, 40351
26821, 5676, 5677, 5688, 5687, 37630, 37634, 37678, 37674, 0, 0, 0, 0, 40220, 40366, 40367, 
40353, 40205, 40218, 40365, 40352
26822, 37630, 37634, 37678, 37674, 37631, 37635, 37679, 37675, 40220, 40366, 40367, 40353, 40223, 40369, 40370, 
40356, 40208, 40221, 40368, 40355
26823, 37631, 37635, 37679, 37675, 37632, 37636, 37680, 37676, 40223, 40369, 40370, 40356, 40226, 40372, 40373, 
40359, 40211, 40224, 40371, 40358
26824, 37632, 37636, 37680, 37676, 37633, 37637, 37681, 37677, 40226, 40372, 40373, 40359, 40229, 40375, 40376, 
40362, 40214, 40227, 40374, 40361
26825, 37633, 37637, 37681, 37677, 16154, 16155, 16166, 16165, 40229, 40375, 40376, 40362, 0, 0, 0, 
0, 40217, 40230, 40377, 40364
26826, 5677, 5678, 5689, 5688, 37634, 37638, 37682, 37678, 0, 0, 0, 0, 40233, 40379, 40380, 
40366, 40218, 40231, 40378, 40365
26827, 37634, 37638, 37682, 37678, 37635, 37639, 37683, 37679, 40233, 40379, 40380, 40366, 40236, 40382, 40383, 
40369, 40221, 40234, 40381, 40368
26828, 37635, 37639, 37683, 37679, 37636, 37640, 37684, 37680, 40236, 40382, 40383, 40369, 40239, 40385, 40386, 
40372, 40224, 40237, 40384, 40371
26829, 37636, 37640, 37684, 37680, 37637, 37641, 37685, 37681, 40239, 40385, 40386, 40372, 40242, 40388, 40389, 
40375, 40227, 40240, 40387, 40374
26830, 37637, 37641, 37685, 37681, 16155, 16156, 16167, 16166, 40242, 40388, 40389, 40375, 0, 0, 0, 
0, 40230, 40243, 40390, 40377
26831, 5678, 5679, 5690, 5689, 37638, 37642, 37686, 37682, 0, 0, 0, 0, 40246, 40392, 40393, 
40379, 40231, 40244, 40391, 40378
26832, 37638, 37642, 37686, 37682, 37639, 37643, 37687, 37683, 40246, 40392, 40393, 40379, 40249, 40395, 40396, 
40382, 40234, 40247, 40394, 40381
26833, 37639, 37643, 37687, 37683, 37640, 37644, 37688, 37684, 40249, 40395, 40396, 40382, 40252, 40398, 40399, 
40385, 40237, 40250, 40397, 40384
26834, 37640, 37644, 37688, 37684, 37641, 37645, 37689, 37685, 40252, 40398, 40399, 40385, 40255, 40401, 40402, 
40388, 40240, 40253, 40400, 40387
26835, 37641, 37645, 37689, 37685, 16156, 16157, 16168, 16167, 40255, 40401, 40402, 40388, 0, 0, 0, 
0, 40243, 40256, 40403, 40390
26836, 5679, 5680, 5691, 5690, 37642, 37646, 37690, 37686, 0, 0, 0, 0, 40259, 40405, 40406, 
40392, 40244, 40257, 40404, 40391
26837, 37642, 37646, 37690, 37686, 37643, 37647, 37691, 37687, 40259, 40405, 40406, 40392, 40262, 40408, 40409, 
40395, 40247, 40260, 40407, 40394
26838, 37643, 37647, 37691, 37687, 37644, 37648, 37692, 37688, 40262, 40408, 40409, 40395, 40265, 40411, 40412, 
40398, 40250, 40263, 40410, 40397
26839, 37644, 37648, 37692, 37688, 37645, 37649, 37693, 37689, 40265, 40411, 40412, 40398, 40268, 40414, 40415, 
40401, 40253, 40266, 40413, 40400
26840, 37645, 37649, 37693, 37689, 16157, 16158, 16169, 16168, 40268, 40414, 40415, 40401, 0, 0, 0, 
0, 40256, 40269, 40416, 40403
26841, 5680, 5681, 5692, 5691, 37646, 37650, 37694, 37690, 0, 0, 0, 0, 40272, 40418, 40419, 
40405, 40257, 40270, 40417, 40404
26842, 37646, 37650, 37694, 37690, 37647, 37651, 37695, 37691, 40272, 40418, 40419, 40405, 40275, 40421, 40422, 
40408, 40260, 40273, 40420, 40407
26843, 37647, 37651, 37695, 37691, 37648, 37652, 37696, 37692, 40275, 40421, 40422, 40408, 40278, 40424, 40425, 
40411, 40263, 40276, 40423, 40410
26844, 37648, 37652, 37696, 37692, 37649, 37653, 37697, 37693, 40278, 40424, 40425, 40411, 40281, 40427, 40428, 
40414, 40266, 40279, 40426, 40413
26845, 37649, 37653, 37697, 37693, 16158, 16159, 16170, 16169, 40281, 40427, 40428, 40414, 0, 0, 0, 
0, 40269, 40282, 40429, 40416
26846, 5681, 5682, 5693, 5692, 37650, 37654, 37698, 37694, 0, 0, 0, 0, 40285, 40431, 40432, 
40418, 40270, 40283, 40430, 40417
26847, 37650, 37654, 37698, 37694, 37651, 37655, 37699, 37695, 40285, 40431, 40432, 40418, 40288, 40434, 40435, 
40421, 40273, 40286, 40433, 40420
26848, 37651, 37655, 37699, 37695, 37652, 37656, 37700, 37696, 40288, 40434, 40435, 40421, 40291, 40437, 40438, 
40424, 40276, 40289, 40436, 40423
26849, 37652, 37656, 37700, 37696, 37653, 37657, 37701, 37697, 40291, 40437, 40438, 40424, 40294, 40440, 40441, 
40427, 40279, 40292, 40439, 40426
26850, 37653, 37657, 37701, 37697, 16159, 16160, 16171, 16170, 40294, 40440, 40441, 40427, 0, 0, 0, 
0, 40282, 40295, 40442, 40429
26851, 5682, 5683, 5694, 5693, 37654, 37658, 37702, 37698, 0, 0, 0, 0, 40298, 40444, 40445, 
40431, 40283, 40296, 40443, 40430
26852, 37654, 37658, 37702, 37698, 37655, 37659, 37703, 37699, 40298, 40444, 40445, 40431, 40301, 40447, 40448, 
40434, 40286, 40299, 40446, 40433
26853, 37655, 37659, 37703, 37699, 37656, 37660, 37704, 37700, 40301, 40447, 40448, 40434, 40304, 40450, 40451, 
40437, 40289, 40302, 40449, 40436
26854, 37656, 37660, 37704, 37700, 37657, 37661, 37705, 37701, 40304, 40450, 40451, 40437, 40307, 40453, 40454, 
40440, 40292, 40305, 40452, 40439
26855, 37657, 37661, 37705, 37701, 16160, 16161, 16172, 16171, 40307, 40453, 40454, 40440, 0, 0, 0, 
0, 40295, 40308, 40455, 40442
26856, 5683, 5684, 5695, 5694, 37658, 37662, 37706, 37702, 0, 0, 0, 0, 40311, 40457, 40458, 
40444, 40296, 40309, 40456, 40443
26857, 37658, 37662, 37706, 37702, 37659, 37663, 37707, 37703, 40311, 40457, 40458, 40444, 40314, 40460, 40461, 
40447, 40299, 40312, 40459, 40446
26858, 37659, 37663, 37707, 37703, 37660, 37664, 37708, 37704, 40314, 40460, 40461, 40447, 40317, 40463, 40464, 
40450, 40302, 40315, 40462, 40449
26859, 37660, 37664, 37708, 37704, 37661, 37665, 37709, 37705, 40317, 40463, 40464, 40450, 40320, 40466, 40467, 
40453, 40305, 40318, 40465, 40452
26860, 37661, 37665, 37709, 37705, 16161, 16162, 16173, 16172, 40320, 40466, 40467, 40453, 0, 0, 0, 
0, 40308, 40321, 40468, 40455
26861, 5684, 595, 596, 5695, 37662, 15808, 15812, 37706, 0, 0, 0, 0, 40322, 0, 40469, 
40457, 40309, 0, 0, 40456
26862, 37662, 15808, 15812, 37706, 37663, 15809, 15813, 37707, 40322, 0, 40469, 40457, 40323, 0, 40470, 
40460, 40312, 0, 0, 40459
26863, 37663, 15809, 15813, 37707, 37664, 15810, 15814, 37708, 40323, 0, 40470, 40460, 40324, 0, 40471, 
40463, 40315, 0, 0, 40462
26864, 37664, 15810, 15814, 37708, 37665, 15811, 15815, 37709, 40324, 0, 40471, 40463, 40325, 0, 40472, 
40466, 40318, 0, 0, 40465
26865, 37665, 15811, 15815, 37709, 16162, 2051, 2052, 16173, 40325, 0, 40472, 40466, 0, 0, 0, 
0, 40321, 0, 0, 40468
26866, 558, 5685, 5696, 559, 15362, 37666, 37710, 15366, 0, 0, 0, 0, 40328, 40474, 40475, 
15543, 15535, 40326, 40473, 15544
26867, 15362, 37666, 37710, 15366, 15363, 37667, 37711, 15367, 40328, 40474, 40475, 15543, 40331, 40477, 40478, 
15545, 15537, 40329, 40476, 15546
26868, 15363, 37667, 37711, 15367, 15364, 37668, 37712, 15368, 40331, 40477, 40478, 15545, 40334, 40480, 40481, 
15547, 15539, 40332, 40479, 15548
26869, 15364, 37668, 37712, 15368, 15365, 37669, 37713, 15369, 40334, 40480, 40481, 15547, 40337, 40483, 40484, 
15549, 15541, 40335, 40482, 15550
26870, 15365, 37669, 37713, 15369, 2010, 16163, 16174, 2011, 40337, 40483, 40484, 15549, 0, 0, 0, 
0, 15542, 40338, 40485, 15551
26871, 5685, 5686, 5697, 5696, 37666, 37670, 37714, 37710, 0, 0, 0, 0, 40341, 40487, 40488, 
40474, 40326, 40339, 40486, 40473
26872, 37666, 37670, 37714, 37710, 37667, 37671, 37715, 37711, 40341, 40487, 40488, 40474, 40344, 40490, 40491, 
40477, 40329, 40342, 40489, 40476
26873, 37667, 37671, 37715, 37711, 37668, 37672, 37716, 37712, 40344, 40490, 40491, 40477, 40347, 40493, 40494, 
40480, 40332, 40345, 40492, 40479
26874, 37668, 37672, 37716, 37712, 37669, 37673, 37717, 37713, 40347, 40493, 40494, 40480, 40350, 40496, 40497, 
40483, 40335, 40348, 40495, 40482
26875, 37669, 37673, 37717, 37713, 16163, 16164, 16175, 16174, 40350, 40496, 40497, 40483, 0, 0, 0, 
0, 40338, 40351, 40498, 40485
26876, 5686, 5687, 5698, 5697, 37670, 37674, 37718, 37714, 0, 0, 0, 0, 40354, 40500, 40501, 
40487, 40339, 40352, 40499, 40486
26877, 37670, 37674, 37718, 37714, 37671, 37675, 37719, 37715, 40354, 40500, 40501, 40487, 40357, 40503, 40504, 
40490, 40342, 40355, 40502, 40489
26878, 37671, 37675, 37719, 37715, 37672, 37676, 37720, 37716, 40357, 40503, 40504, 40490, 40360, 40506, 40507, 
40493, 40345, 40358, 40505, 40492
26879, 37672, 37676, 37720, 37716, 37673, 37677, 37721, 37717, 40360, 40506, 40507, 40493, 40363, 40509, 40510, 
40496, 40348, 40361, 40508, 40495
26880, 37673, 37677, 37721, 37717, 16164, 16165, 16176, 16175, 40363, 40509, 40510, 40496, 0, 0, 0, 
0, 40351, 40364, 40511, 40498
26881, 5687, 5688, 5699, 5698, 37674, 37678, 37722, 37718, 0, 0, 0, 0, 40367, 40513, 40514, 
40500, 40352, 40365, 40512, 40499
26882, 37674, 37678, 37722, 37718, 37675, 37679, 37723, 37719, 40367, 40513, 40514, 40500, 40370, 40516, 40517, 
40503, 40355, 40368, 40515, 40502
26883, 37675, 37679, 37723, 37719, 37676, 37680, 37724, 37720, 40370, 40516, 40517, 40503, 40373, 40519, 40520, 
40506, 40358, 40371, 40518, 40505
26884, 37676, 37680, 37724, 37720, 37677, 37681, 37725, 37721, 40373, 40519, 40520, 40506, 40376, 40522, 40523, 
40509, 40361, 40374, 40521, 40508
26885, 37677, 37681, 37725, 37721, 16165, 16166, 16177, 16176, 40376, 40522, 40523, 40509, 0, 0, 0, 
0, 40364, 40377, 40524, 40511
26886, 5688, 5689, 5700, 5699, 37678, 37682, 37726, 37722, 0, 0, 0, 0, 40380, 40526, 40527, 
40513, 40365, 40378, 40525, 40512
26887, 37678, 37682, 37726, 37722, 37679, 37683, 37727, 37723, 40380, 40526, 40527, 40513, 40383, 40529, 40530, 
40516, 40368, 40381, 40528, 40515
26888, 37679, 37683, 37727, 37723, 37680, 37684, 37728, 37724, 40383, 40529, 40530, 40516, 40386, 40532, 40533, 
40519, 40371, 40384, 40531, 40518
26889, 37680, 37684, 37728, 37724, 37681, 37685, 37729, 37725, 40386, 40532, 40533, 40519, 40389, 40535, 40536, 
40522, 40374, 40387, 40534, 40521
26890, 37681, 37685, 37729, 37725, 16166, 16167, 16178, 16177, 40389, 40535, 40536, 40522, 0, 0, 0, 
0, 40377, 40390, 40537, 40524
26891, 5689, 5690, 5701, 5700, 37682, 37686, 37730, 37726, 0, 0, 0, 0, 40393, 40539, 40540, 
40526, 40378, 40391, 40538, 40525
26892, 37682, 37686, 37730, 37726, 37683, 37687, 37731, 37727, 40393, 40539, 40540, 40526, 40396, 40542, 40543, 
40529, 40381, 40394, 40541, 40528
26893, 37683, 37687, 37731, 37727, 37684, 37688, 37732, 37728, 40396, 40542, 40543, 40529, 40399, 40545, 40546, 
40532, 40384, 40397, 40544, 40531
26894, 37684, 37688, 37732, 37728, 37685, 37689, 37733, 37729, 40399, 40545, 40546, 40532, 40402, 40548, 40549, 
40535, 40387, 40400, 40547, 40534
26895, 37685, 37689, 37733, 37729, 16167, 16168, 16179, 16178, 40402, 40548, 40549, 40535, 0, 0, 0, 
0, 40390, 40403, 40550, 40537
26896, 5690, 5691, 5702, 5701, 37686, 37690, 37734, 37730, 0, 0, 0, 0, 40406, 40552, 40553, 
40539, 40391, 40404, 40551, 40538
26897, 37686, 37690, 37734, 37730, 37687, 37691, 37735, 37731, 40406, 40552, 40553, 40539, 40409, 40555, 40556, 
40542, 40394, 40407, 40554, 40541
26898, 37687, 37691, 37735, 37731, 37688, 37692, 37736, 37732, 40409, 40555, 40556, 40542, 40412, 40558, 40559, 
40545, 40397, 40410, 40557, 40544
26899, 37688, 37692, 37736, 37732, 37689, 37693, 37737, 37733, 40412, 40558, 40559, 40545, 40415, 40561, 40562, 
40548, 40400, 40413, 40560, 40547
26900, 37689, 37693, 37737, 37733, 16168, 16169, 16180, 16179, 40415, 40561, 40562, 40548, 0, 0, 0, 
0, 40403, 40416, 40563, 40550
26901, 5691, 5692, 5703, 5702, 37690, 37694, 37738, 37734, 0, 0, 0, 0, 40419, 40565, 40566, 
40552, 40404, 40417, 40564, 40551
26902, 37690, 37694, 37738, 37734, 37691, 37695, 37739, 37735, 40419, 40565, 40566, 40552, 40422, 40568, 40569, 
40555, 40407, 40420, 40567, 40554
26903, 37691, 37695, 37739, 37735, 37692, 37696, 37740, 37736, 40422, 40568, 40569, 40555, 40425, 40571, 40572, 
40558, 40410, 40423, 40570, 40557
26904, 37692, 37696, 37740, 37736, 37693, 37697, 37741, 37737, 40425, 40571, 40572, 40558, 40428, 40574, 40575, 
40561, 40413, 40426, 40573, 40560
26905, 37693, 37697, 37741, 37737, 16169, 16170, 16181, 16180, 40428, 40574, 40575, 40561, 0, 0, 0, 
0, 40416, 40429, 40576, 40563
26906, 5692, 5693, 5704, 5703, 37694, 37698, 37742, 37738, 0, 0, 0, 0, 40432, 40578, 40579, 
40565, 40417, 40430, 40577, 40564
26907, 37694, 37698, 37742, 37738, 37695, 37699, 37743, 37739, 40432, 40578, 40579, 40565, 40435, 40581, 40582, 
40568, 40420, 40433, 40580, 40567
26908, 37695, 37699, 37743, 37739, 37696, 37700, 37744, 37740, 40435, 40581, 40582, 40568, 40438, 40584, 40585, 
40571, 40423, 40436, 40583, 40570
26909, 37696, 37700, 37744, 37740, 37697, 37701, 37745, 37741, 40438, 40584, 40585, 40571, 40441, 40587, 40588, 
40574, 40426, 40439, 40586, 40573
26910, 37697, 37701, 37745, 37741, 16170, 16171, 16182, 16181, 40441, 40587, 40588, 40574, 0, 0, 0, 
0, 40429, 40442, 40589, 40576
26911, 5693, 5694, 5705, 5704, 37698, 37702, 37746, 37742, 0, 0, 0, 0, 40445, 40591, 40592, 
40578, 40430, 40443, 40590, 40577
26912, 37698, 37702, 37746, 37742, 37699, 37703, 37747, 37743, 40445, 40591, 40592, 40578, 40448, 40594, 40595, 
40581, 40433, 40446, 40593, 40580
26913, 37699, 37703, 37747, 37743, 37700, 37704, 37748, 37744, 40448, 40594, 40595, 40581, 40451, 40597, 40598, 
40584, 40436, 40449, 40596, 40583
26914, 37700, 37704, 37748, 37744, 37701, 37705, 37749, 37745, 40451, 40597, 40598, 40584, 40454, 40600, 40601, 
40587, 40439, 40452, 40599, 40586
26915, 37701, 37705, 37749, 37745, 16171, 16172, 16183, 16182, 40454, 40600, 40601, 40587, 0, 0, 0, 
0, 40442, 40455, 40602, 40589
26916, 5694, 5695, 5706, 5705, 37702, 37706, 37750, 37746, 0, 0, 0, 0, 40458, 40604, 40605, 
40591, 40443, 40456, 40603, 40590
26917, 37702, 37706, 37750, 37746, 37703, 37707, 37751, 37747, 40458, 40604, 40605, 40591, 40461, 40607, 40608, 
40594, 40446, 40459, 40606, 40593
26918, 37703, 37707, 37751, 37747, 37704, 37708, 37752, 37748, 40461, 40607, 40608, 40594, 40464, 40610, 40611, 
40597, 40449, 40462, 40609, 40596
26919, 37704, 37708, 37752, 37748, 37705, 37709, 37753, 37749, 40464, 40610, 40611, 40597, 40467, 40613, 40614, 
40600, 40452, 40465, 40612, 40599
26920, 37705, 37709, 37753, 37749, 16172, 16173, 16184, 16183, 40467, 40613, 40614, 40600, 0, 0, 0, 
0, 40455, 40468, 40615, 40602
26921, 5695, 596, 597, 5706, 37706, 15812, 15816, 37750, 0, 0, 0, 0, 40469, 0, 40616, 
40604, 40456, 0, 0, 40603
26922, 37706, 15812, 15816, 37750, 37707, 15813, 15817, 37751, 40469, 0, 40616, 40604, 40470, 0, 40617, 
40607, 40459, 0, 0, 40606
26923, 37707, 15813, 15817, 37751, 37708, 15814, 15818, 37752, 40470, 0, 40617, 40607, 40471, 0, 40618, 
40610, 40462, 0, 0, 40609
26924, 37708, 15814, 15818, 37752, 37709, 15815, 15819, 37753, 40471, 0, 40618, 40610, 40472, 0, 40619, 
40613, 40465, 0, 0, 40612
26925, 37709, 15815, 15819, 37753, 16173, 2052, 2053, 16184, 40472, 0, 40619, 40613, 0, 0, 0, 
0, 40468, 0, 0, 40615
26926, 559, 5696, 5707, 560, 15366, 37710, 37754, 15370, 0, 0, 0, 0, 40475, 40621, 40622, 
15552, 15544, 40473, 40620, 15553
26927, 15366, 37710, 37754, 15370, 15367, 37711, 37755, 15371, 40475, 40621, 40622, 15552, 40478, 40624, 40625, 
15554, 15546, 40476, 40623, 15555
26928, 15367, 37711, 37755, 15371, 15368, 37712, 37756, 15372, 40478, 40624, 40625, 15554, 40481, 40627, 40628, 
15556, 15548, 40479, 40626, 15557
26929, 15368, 37712, 37756, 15372, 15369, 37713, 37757, 15373, 40481, 40627, 40628, 15556, 40484, 40630, 40631, 
15558, 15550, 40482, 40629, 15559
26930, 15369, 37713, 37757, 15373, 2011, 16174, 16185, 2012, 40484, 40630, 40631, 15558, 0, 0, 0, 
0, 15551, 40485, 40632, 15560
26931, 5696, 5697, 5708, 5707, 37710, 37714, 37758, 37754, 0, 0, 0, 0, 40488, 40634, 40635, 
40621, 40473, 40486, 40633, 40620
26932, 37710, 37714, 37758, 37754, 37711, 37715, 37759, 37755, 40488, 40634, 40635, 40621, 40491, 40637, 40638, 
40624, 40476, 40489, 40636, 40623
26933, 37711, 37715, 37759, 37755, 37712, 37716, 37760, 37756, 40491, 40637, 40638, 40624, 40494, 40640, 40641, 
40627, 40479, 40492, 40639, 40626
26934, 37712, 37716, 37760, 37756, 37713, 37717, 37761, 37757, 40494, 40640, 40641, 40627, 40497, 40643, 40644, 
40630, 40482, 40495, 40642, 40629
26935, 37713, 37717, 37761, 37757, 16174, 16175, 16186, 16185, 40497, 40643, 40644, 40630, 0, 0, 0, 
0, 40485, 40498, 40645, 40632
26936, 5697, 5698, 5709, 5708, 37714, 37718, 37762, 37758, 0, 0, 0, 0, 40501, 40647, 40648, 
40634, 40486, 40499, 40646, 40633
26937, 37714, 37718, 37762, 37758, 37715, 37719, 37763, 37759, 40501, 40647, 40648, 40634, 40504, 40650, 40651, 
40637, 40489, 40502, 40649, 40636
26938, 37715, 37719, 37763, 37759, 37716, 37720, 37764, 37760, 40504, 40650, 40651, 40637, 40507, 40653, 40654, 
40640, 40492, 40505, 40652, 40639
26939, 37716, 37720, 37764, 37760, 37717, 37721, 37765, 37761, 40507, 40653, 40654, 40640, 40510, 40656, 40657, 
40643, 40495, 40508, 40655, 40642
26940, 37717, 37721, 37765, 37761, 16175, 16176, 16187, 16186, 40510, 40656, 40657, 40643, 0, 0, 0, 
0, 40498, 40511, 40658, 40645
26941, 5698, 5699, 5710, 5709, 37718, 37722, 37766, 37762, 0, 0, 0, 0, 40514, 40660, 40661, 
40647, 40499, 40512, 40659, 40646
26942, 37718, 37722, 37766, 37762, 37719, 37723, 37767, 37763, 40514, 40660, 40661, 40647, 40517, 40663, 40664, 
40650, 40502, 40515, 40662, 40649
26943, 37719, 37723, 37767, 37763, 37720, 37724, 37768, 37764, 40517, 40663, 40664, 40650, 40520, 40666, 40667, 
40653, 40505, 40518, 40665, 40652
26944, 37720, 37724, 37768, 37764, 37721, 37725, 37769, 37765, 40520, 40666, 40667, 40653, 40523, 40669, 40670, 
40656, 40508, 40521, 40668, 40655
26945, 37721, 37725, 37769, 37765, 16176, 16177, 16188, 16187, 40523, 40669, 40670, 40656, 0, 0, 0, 
0, 40511, 40524, 40671, 40658
26946, 5699, 5700, 5711, 5710, 37722, 37726, 37770, 37766, 0, 0, 0, 0, 40527, 40673, 40674, 
40660, 40512, 40525, 40672, 40659
26947, 37722, 37726, 37770, 37766, 37723, 37727, 37771, 37767, 40527, 40673, 40674, 40660, 40530, 40676, 40677, 
40663, 40515, 40528, 40675, 40662
26948, 37723, 37727, 37771, 37767, 37724, 37728, 37772, 37768, 40530, 40676, 40677, 40663, 40533, 40679, 40680, 
40666, 40518, 40531, 40678, 40665
26949, 37724, 37728, 37772, 37768, 37725, 37729, 37773, 37769, 40533, 40679, 40680, 40666, 40536, 40682, 40683, 
40669, 40521, 40534, 40681, 40668
26950, 37725, 37729, 37773, 37769, 16177, 16178, 16189, 16188, 40536, 40682, 40683, 40669, 0, 0, 0, 
0, 40524, 40537, 40684, 40671
26951, 5700, 5701, 5712, 5711, 37726, 37730, 37774, 37770, 0, 0, 0, 0, 40540, 40686, 40687, 
40673, 40525, 40538, 40685, 40672
26952, 37726, 37730, 37774, 37770, 37727, 37731, 37775, 37771, 40540, 40686, 40687, 40673, 40543, 40689, 40690, 
40676, 40528, 40541, 40688, 40675
26953, 37727, 37731, 37775, 37771, 37728, 37732, 37776, 37772, 40543, 40689, 40690, 40676, 40546, 40692, 40693, 
40679, 40531, 40544, 40691, 40678
26954, 37728, 37732, 37776, 37772, 37729, 37733, 37777, 37773, 40546, 40692, 40693, 40679, 40549, 40695, 40696, 
40682, 40534, 40547, 40694, 40681
26955, 37729, 37733, 37777, 37773, 16178, 16179, 16190, 16189, 40549, 40695, 40696, 40682, 0, 0, 0, 
0, 40537, 40550, 40697, 40684
26956, 5701, 5702, 5713, 5712, 37730, 37734, 37778, 37774, 0, 0, 0, 0, 40553, 40699, 40700, 
40686, 40538, 40551, 40698, 40685
26957, 37730, 37734, 37778, 37774, 37731, 37735, 37779, 37775, 40553, 40699, 40700, 40686, 40556, 40702, 40703, 
40689, 40541, 40554, 40701, 40688
26958, 37731, 37735, 37779, 37775, 37732, 37736, 37780, 37776, 40556, 40702, 40703, 40689, 40559, 40705, 40706, 
40692, 40544, 40557, 40704, 40691
26959, 37732, 37736, 37780, 37776, 37733, 37737, 37781, 37777, 40559, 40705, 40706, 40692, 40562, 40708, 40709, 
40695, 40547, 40560, 40707, 40694
26960, 37733, 37737, 37781, 37777, 16179, 16180, 16191, 16190, 40562, 40708, 40709, 40695, 0, 0, 0, 
0, 40550, 40563, 40710, 40697
26961, 5702, 5703, 5714, 5713, 37734, 37738, 37782, 37778, 0, 0, 0, 0, 40566, 40712, 40713, 
40699, 40551, 40564, 40711, 40698
26962, 37734, 37738, 37782, 37778, 37735, 37739, 37783, 37779, 40566, 40712, 40713, 40699, 40569, 40715, 40716, 
40702, 40554, 40567, 40714, 40701
26963, 37735, 37739, 37783, 37779, 37736, 37740, 37784, 37780, 40569, 40715, 40716, 40702, 40572, 40718, 40719, 
40705, 40557, 40570, 40717, 40704
26964, 37736, 37740, 37784, 37780, 37737, 37741, 37785, 37781, 40572, 40718, 40719, 40705, 40575, 40721, 40722, 
40708, 40560, 40573, 40720, 40707
26965, 37737, 37741, 37785, 37781, 16180, 16181, 16192, 16191, 40575, 40721, 40722, 40708, 0, 0, 0, 
0, 40563, 40576, 40723, 40710
26966, 5703, 5704, 5715, 5714, 37738, 37742, 37786, 37782, 0, 0, 0, 0, 40579, 40725, 40726, 
40712, 40564, 40577, 40724, 40711
26967, 37738, 37742, 37786, 37782, 37739, 37743, 37787, 37783, 40579, 40725, 40726, 40712, 40582, 40728, 40729, 
40715, 40567, 40580, 40727, 40714
26968, 37739, 37743, 37787, 37783, 37740, 37744, 37788, 37784, 40582, 40728, 40729, 40715, 40585, 40731, 40732, 
40718, 40570, 40583, 40730, 40717
26969, 37740, 37744, 37788, 37784, 37741, 37745, 37789, 37785, 40585, 40731, 40732, 40718, 40588, 40734, 40735, 
40721, 40573, 40586, 40733, 40720
26970, 37741, 37745, 37789, 37785, 16181, 16182, 16193, 16192, 40588, 40734, 40735, 40721, 0, 0, 0, 
0, 40576, 40589, 40736, 40723
26971, 5704, 5705, 5716, 5715, 37742, 37746, 37790, 37786, 0, 0, 0, 0, 40592, 40738, 40739, 
40725, 40577, 40590, 40737, 40724
26972, 37742, 37746, 37790, 37786, 37743, 37747, 37791, 37787, 40592, 40738, 40739, 40725, 40595, 40741, 40742, 
40728, 40580, 40593, 40740, 40727
26973, 37743, 37747, 37791, 37787, 37744, 37748, 37792, 37788, 40595, 40741, 40742, 40728, 40598, 40744, 40745, 
40731, 40583, 40596, 40743, 40730
26974, 37744, 37748, 37792, 37788, 37745, 37749, 37793, 37789, 40598, 40744, 40745, 40731, 40601, 40747, 40748, 
40734, 40586, 40599, 40746, 40733
26975, 37745, 37749, 37793, 37789, 16182, 16183, 16194, 16193, 40601, 40747, 40748, 40734, 0, 0, 0, 
0, 40589, 40602, 40749, 40736
26976, 5705, 5706, 5717, 5716, 37746, 37750, 37794, 37790, 0, 0, 0, 0, 40605, 40751, 40752, 
40738, 40590, 40603, 40750, 40737
26977, 37746, 37750, 37794, 37790, 37747, 37751, 37795, 37791, 40605, 40751, 40752, 40738, 40608, 40754, 40755, 
40741, 40593, 40606, 40753, 40740
26978, 37747, 37751, 37795, 37791, 37748, 37752, 37796, 37792, 40608, 40754, 40755, 40741, 40611, 40757, 40758, 
40744, 40596, 40609, 40756, 40743
26979, 37748, 37752, 37796, 37792, 37749, 37753, 37797, 37793, 40611, 40757, 40758, 40744, 40614, 40760, 40761, 
40747, 40599, 40612, 40759, 40746
26980, 37749, 37753, 37797, 37793, 16183, 16184, 16195, 16194, 40614, 40760, 40761, 40747, 0, 0, 0, 
0, 40602, 40615, 40762, 40749
26981, 5706, 597, 598, 5717, 37750, 15816, 15820, 37794, 0, 0, 0, 0, 40616, 0, 40763, 
40751, 40603, 0, 0, 40750
26982, 37750, 15816, 15820, 37794, 37751, 15817, 15821, 37795, 40616, 0, 40763, 40751, 40617, 0, 40764, 
40754, 40606, 0, 0, 40753
26983, 37751, 15817, 15821, 37795, 37752, 15818, 15822, 37796, 40617, 0, 40764, 40754, 40618, 0, 40765, 
40757, 40609, 0, 0, 40756
26984, 37752, 15818, 15822, 37796, 37753, 15819, 15823, 37797, 40618, 0, 40765, 40757, 40619, 0, 40766, 
40760, 40612, 0, 0, 40759
26985, 37753, 15819, 15823, 37797, 16184, 2053, 2054, 16195, 40619, 0, 40766, 40760, 0, 0, 0, 
0, 40615, 0, 0, 40762
26986, 560, 5707, 5718, 561, 15370, 37754, 37798, 15374, 0, 0, 0, 0, 40622, 40768, 40769, 
15561, 15553, 40620, 40767, 15562
26987, 15370, 37754, 37798, 15374, 15371, 37755, 37799, 15375, 40622, 40768, 40769, 15561, 40625, 40771, 40772, 
15563, 15555, 40623, 40770, 15564
26988, 15371, 37755, 37799, 15375, 15372, 37756, 37800, 15376, 40625, 40771, 40772, 15563, 40628, 40774, 40775, 
15565, 15557, 40626, 40773, 15566
26989, 15372, 37756, 37800, 15376, 15373, 37757, 37801, 15377, 40628, 40774, 40775, 15565, 40631, 40777, 40778, 
15567, 15559, 40629, 40776, 15568
26990, 15373, 37757, 37801, 15377, 2012, 16185, 16196, 2013, 40631, 40777, 40778, 15567, 0, 0, 0, 
0, 15560, 40632, 40779, 15569
26991, 5707, 5708, 5719, 5718, 37754, 37758, 37802, 37798, 0, 0, 0, 0, 40635, 40781, 40782, 
40768, 40620, 40633, 40780, 40767
26992, 37754, 37758, 37802, 37798, 37755, 37759, 37803, 37799, 40635, 40781, 40782, 40768, 40638, 40784, 40785, 
40771, 40623, 40636, 40783, 40770
26993, 37755, 37759, 37803, 37799, 37756, 37760, 37804, 37800, 40638, 40784, 40785, 40771, 40641, 40787, 40788, 
40774, 40626, 40639, 40786, 40773
26994, 37756, 37760, 37804, 37800, 37757, 37761, 37805, 37801, 40641, 40787, 40788, 40774, 40644, 40790, 40791, 
40777, 40629, 40642, 40789, 40776
26995, 37757, 37761, 37805, 37801, 16185, 16186, 16197, 16196, 40644, 40790, 40791, 40777, 0, 0, 0, 
0, 40632, 40645, 40792, 40779
26996, 5708, 5709, 5720, 5719, 37758, 37762, 37806, 37802, 0, 0, 0, 0, 40648, 40794, 40795, 
40781, 40633, 40646, 40793, 40780
26997, 37758, 37762, 37806, 37802, 37759, 37763, 37807, 37803, 40648, 40794, 40795, 40781, 40651, 40797, 40798, 
40784, 40636, 40649, 40796, 40783
26998, 37759, 37763, 37807, 37803, 37760, 37764, 37808, 37804, 40651, 40797, 40798, 40784, 40654, 40800, 40801, 
40787, 40639, 40652, 40799, 40786
26999, 37760, 37764, 37808, 37804, 37761, 37765, 37809, 37805, 40654, 40800, 40801, 40787, 40657, 40803, 40804, 
40790, 40642, 40655, 40802, 40789
27000, 37761, 37765, 37809, 37805, 16186, 16187, 16198, 16197, 40657, 40803, 40804, 40790, 0, 0, 0, 
0, 40645, 40658, 40805, 40792
27001, 5709, 5710, 5721, 5720, 37762, 37766, 37810, 37806, 0, 0, 0, 0, 40661, 40807, 40808, 
40794, 40646, 40659, 40806, 40793
27002, 37762, 37766, 37810, 37806, 37763, 37767, 37811, 37807, 40661, 40807, 40808, 40794, 40664, 40810, 40811, 
40797, 40649, 40662, 40809, 40796
27003, 37763, 37767, 37811, 37807, 37764, 37768, 37812, 37808, 40664, 40810, 40811, 40797, 40667, 40813, 40814, 
40800, 40652, 40665, 40812, 40799
27004, 37764, 37768, 37812, 37808, 37765, 37769, 37813, 37809, 40667, 40813, 40814, 40800, 40670, 40816, 40817, 
40803, 40655, 40668, 40815, 40802
27005, 37765, 37769, 37813, 37809, 16187, 16188, 16199, 16198, 40670, 40816, 40817, 40803, 0, 0, 0, 
0, 40658, 40671, 40818, 40805
27006, 5710, 5711, 5722, 5721, 37766, 37770, 37814, 37810, 0, 0, 0, 0, 40674, 40820, 40821, 
40807, 40659, 40672, 40819, 40806
27007, 37766, 37770, 37814, 37810, 37767, 37771, 37815, 37811, 40674, 40820, 40821, 40807, 40677, 40823, 40824, 
40810, 40662, 40675, 40822, 40809
27008, 37767, 37771, 37815, 37811, 37768, 37772, 37816, 37812, 40677, 40823, 40824, 40810, 40680, 40826, 40827, 
40813, 40665, 40678, 40825, 40812
27009, 37768, 37772, 37816, 37812, 37769, 37773, 37817, 37813, 40680, 40826, 40827, 40813, 40683, 40829, 40830, 
40816, 40668, 40681, 40828, 40815
27010, 37769, 37773, 37817, 37813, 16188, 16189, 16200, 16199, 40683, 40829, 40830, 40816, 0, 0, 0, 
0, 40671, 40684, 40831, 40818
27011, 5711, 5712, 5723, 5722, 37770, 37774, 37818, 37814, 0, 0, 0, 0, 40687, 40833, 40834, 
40820, 40672, 40685, 40832, 40819
27012, 37770, 37774, 37818, 37814, 37771, 37775, 37819, 37815, 40687, 40833, 40834, 40820, 40690, 40836, 40837, 
40823, 40675, 40688, 40835, 40822
27013, 37771, 37775, 37819, 37815, 37772, 37776, 37820, 37816, 40690, 40836, 40837, 40823, 40693, 40839, 40840, 
40826, 40678, 40691, 40838, 40825
27014, 37772, 37776, 37820, 37816, 37773, 37777, 37821, 37817, 40693, 40839, 40840, 40826, 40696, 40842, 40843, 
40829, 40681, 40694, 40841, 40828
27015, 37773, 37777, 37821, 37817, 16189, 16190, 16201, 16200, 40696, 40842, 40843, 40829, 0, 0, 0, 
0, 40684, 40697, 40844, 40831
27016, 5712, 5713, 5724, 5723, 37774, 37778, 37822, 37818, 0, 0, 0, 0, 40700, 40846, 40847, 
40833, 40685, 40698, 40845, 40832
27017, 37774, 37778, 37822, 37818, 37775, 37779, 37823, 37819, 40700, 40846, 40847, 40833, 40703, 40849, 40850, 
40836, 40688, 40701, 40848, 40835
27018, 37775, 37779, 37823, 37819, 37776, 37780, 37824, 37820, 40703, 40849, 40850, 40836, 40706, 40852, 40853, 
40839, 40691, 40704, 40851, 40838
27019, 37776, 37780, 37824, 37820, 37777, 37781, 37825, 37821, 40706, 40852, 40853, 40839, 40709, 40855, 40856, 
40842, 40694, 40707, 40854, 40841
27020, 37777, 37781, 37825, 37821, 16190, 16191, 16202, 16201, 40709, 40855, 40856, 40842, 0, 0, 0, 
0, 40697, 40710, 40857, 40844
27021, 5713, 5714, 5725, 5724, 37778, 37782, 37826, 37822, 0, 0, 0, 0, 40713, 40859, 40860, 
40846, 40698, 40711, 40858, 40845
27022, 37778, 37782, 37826, 37822, 37779, 37783, 37827, 37823, 40713, 40859, 40860, 40846, 40716, 40862, 40863, 
40849, 40701, 40714, 40861, 40848
27023, 37779, 37783, 37827, 37823, 37780, 37784, 37828, 37824, 40716, 40862, 40863, 40849, 40719, 40865, 40866, 
40852, 40704, 40717, 40864, 40851
27024, 37780, 37784, 37828, 37824, 37781, 37785, 37829, 37825, 40719, 40865, 40866, 40852, 40722, 40868, 40869, 
40855, 40707, 40720, 40867, 40854
27025, 37781, 37785, 37829, 37825, 16191, 16192, 16203, 16202, 40722, 40868, 40869, 40855, 0, 0, 0, 
0, 40710, 40723, 40870, 40857
27026, 5714, 5715, 5726, 5725, 37782, 37786, 37830, 37826, 0, 0, 0, 0, 40726, 40872, 40873, 
40859, 40711, 40724, 40871, 40858
27027, 37782, 37786, 37830, 37826, 37783, 37787, 37831, 37827, 40726, 40872, 40873, 40859, 40729, 40875, 40876, 
40862, 40714, 40727, 40874, 40861
27028, 37783, 37787, 37831, 37827, 37784, 37788, 37832, 37828, 40729, 40875, 40876, 40862, 40732, 40878, 40879, 
40865, 40717, 40730, 40877, 40864
27029, 37784, 37788, 37832, 37828, 37785, 37789, 37833, 37829, 40732, 40878, 40879, 40865, 40735, 40881, 40882, 
40868, 40720, 40733, 40880, 40867
27030, 37785, 37789, 37833, 37829, 16192, 16193, 16204, 16203, 40735, 40881, 40882, 40868, 0, 0, 0, 
0, 40723, 40736, 40883, 40870
27031, 5715, 5716, 5727, 5726, 37786, 37790, 37834, 37830, 0, 0, 0, 0, 40739, 40885, 40886, 
40872, 40724, 40737, 40884, 40871
27032, 37786, 37790, 37834, 37830, 37787, 37791, 37835, 37831, 40739, 40885, 40886, 40872, 40742, 40888, 40889, 
40875, 40727, 40740, 40887, 40874
27033, 37787, 37791, 37835, 37831, 37788, 37792, 37836, 37832, 40742, 40888, 40889, 40875, 40745, 40891, 40892, 
40878, 40730, 40743, 40890, 40877
27034, 37788, 37792, 37836, 37832, 37789, 37793, 37837, 37833, 40745, 40891, 40892, 40878, 40748, 40894, 40895, 
40881, 40733, 40746, 40893, 40880
27035, 37789, 37793, 37837, 37833, 16193, 16194, 16205, 16204, 40748, 40894, 40895, 40881, 0, 0, 0, 
0, 40736, 40749, 40896, 40883
27036, 5716, 5717, 5728, 5727, 37790, 37794, 37838, 37834, 0, 0, 0, 0, 40752, 40898, 40899, 
40885, 40737, 40750, 40897, 40884
27037, 37790, 37794, 37838, 37834, 37791, 37795, 37839, 37835, 40752, 40898, 40899, 40885, 40755, 40901, 40902, 
40888, 40740, 40753, 40900, 40887
27038, 37791, 37795, 37839, 37835, 37792, 37796, 37840, 37836, 40755, 40901, 40902, 40888, 40758, 40904, 40905, 
40891, 40743, 40756, 40903, 40890
27039, 37792, 37796, 37840, 37836, 37793, 37797, 37841, 37837, 40758, 40904, 40905, 40891, 40761, 40907, 40908, 
40894, 40746, 40759, 40906, 40893
27040, 37793, 37797, 37841, 37837, 16194, 16195, 16206, 16205, 40761, 40907, 40908, 40894, 0, 0, 0, 
0, 40749, 40762, 40909, 40896
27041, 5717, 598, 599, 5728, 37794, 15820, 15824, 37838, 0, 0, 0, 0, 40763, 0, 40910, 
40898, 40750, 0, 0, 40897
27042, 37794, 15820, 15824, 37838, 37795, 15821, 15825, 37839, 40763, 0, 40910, 40898, 40764, 0, 40911, 
40901, 40753, 0, 0, 40900
27043, 37795, 15821, 15825, 37839, 37796, 15822, 15826, 37840, 40764, 0, 40911, 40901, 40765, 0, 40912, 
40904, 40756, 0, 0, 40903
27044, 37796, 15822, 15826, 37840, 37797, 15823, 15827, 37841, 40765, 0, 40912, 40904, 40766, 0, 40913, 
40907, 40759, 0, 0, 40906
27045, 37797, 15823, 15827, 37841, 16195, 2054, 2055, 16206, 40766, 0, 40913, 40907, 0, 0, 0, 
0, 40762, 0, 0, 40909
27046, 561, 5718, 5729, 562, 15374, 37798, 37842, 15378, 0, 0, 0, 0, 40769, 40915, 40916, 
15570, 15562, 40767, 40914, 15571
27047, 15374, 37798, 37842, 15378, 15375, 37799, 37843, 15379, 40769, 40915, 40916, 15570, 40772, 40918, 40919, 
15572, 15564, 40770, 40917, 15573
27048, 15375, 37799, 37843, 15379, 15376, 37800, 37844, 15380, 40772, 40918, 40919, 15572, 40775, 40921, 40922, 
15574, 15566, 40773, 40920, 15575
27049, 15376, 37800, 37844, 15380, 15377, 37801, 37845, 15381, 40775, 40921, 40922, 15574, 40778, 40924, 40925, 
15576, 15568, 40776, 40923, 15577
27050, 15377, 37801, 37845, 15381, 2013, 16196, 16207, 2014, 40778, 40924, 40925, 15576, 0, 0, 0, 
0, 15569, 40779, 40926, 15578
27051, 5718, 5719, 5730, 5729, 37798, 37802, 37846, 37842, 0, 0, 0, 0, 40782, 40928, 40929, 
40915, 40767, 40780, 40927, 40914
27052, 37798, 37802, 37846, 37842, 37799, 37803, 37847, 37843, 40782, 40928, 40929, 40915, 40785, 40931, 40932, 
40918, 40770, 40783, 40930, 40917
27053, 37799, 37803, 37847, 37843, 37800, 37804, 37848, 37844, 40785, 40931, 40932, 40918, 40788, 40934, 40935, 
40921, 40773, 40786, 40933, 40920
27054, 37800, 37804, 37848, 37844, 37801, 37805, 37849, 37845, 40788, 40934, 40935, 40921, 40791, 40937, 40938, 
40924, 40776, 40789, 40936, 40923
27055, 37801, 37805, 37849, 37845, 16196, 16197, 16208, 16207, 40791, 40937, 40938, 40924, 0, 0, 0, 
0, 40779, 40792, 40939, 40926
27056, 5719, 5720, 5731, 5730, 37802, 37806, 37850, 37846, 0, 0, 0, 0, 40795, 40941, 40942, 
40928, 40780, 40793, 40940, 40927
27057, 37802, 37806, 37850, 37846, 37803, 37807, 37851, 37847, 40795, 40941, 40942, 40928, 40798, 40944, 40945, 
40931, 40783, 40796, 40943, 40930
27058, 37803, 37807, 37851, 37847, 37804, 37808, 37852, 37848, 40798, 40944, 40945, 40931, 40801, 40947, 40948, 
40934, 40786, 40799, 40946, 40933
27059, 37804, 37808, 37852, 37848, 37805, 37809, 37853, 37849, 40801, 40947, 40948, 40934, 40804, 40950, 40951, 
40937, 40789, 40802, 40949, 40936
27060, 37805, 37809, 37853, 37849, 16197, 16198, 16209, 16208, 40804, 40950, 40951, 40937, 0, 0, 0, 
0, 40792, 40805, 40952, 40939
27061, 5720, 5721, 5732, 5731, 37806, 37810, 37854, 37850, 0, 0, 0, 0, 40808, 40954, 40955, 
40941, 40793, 40806, 40953, 40940
27062, 37806, 37810, 37854, 37850, 37807, 37811, 37855, 37851, 40808, 40954, 40955, 40941, 40811, 40957, 40958, 
40944, 40796, 40809, 40956, 40943
27063, 37807, 37811, 37855, 37851, 37808, 37812, 37856, 37852, 40811, 40957, 40958, 40944, 40814, 40960, 40961, 
40947, 40799, 40812, 40959, 40946
27064, 37808, 37812, 37856, 37852, 37809, 37813, 37857, 37853, 40814, 40960, 40961, 40947, 40817, 40963, 40964, 
40950, 40802, 40815, 40962, 40949
27065, 37809, 37813, 37857, 37853, 16198, 16199, 16210, 16209, 40817, 40963, 40964, 40950, 0, 0, 0, 
0, 40805, 40818, 40965, 40952
27066, 5721, 5722, 5733, 5732, 37810, 37814, 37858, 37854, 0, 0, 0, 0, 40821, 40967, 40968, 
40954, 40806, 40819, 40966, 40953
27067, 37810, 37814, 37858, 37854, 37811, 37815, 37859, 37855, 40821, 40967, 40968, 40954, 40824, 40970, 40971, 
40957, 40809, 40822, 40969, 40956
27068, 37811, 37815, 37859, 37855, 37812, 37816, 37860, 37856, 40824, 40970, 40971, 40957, 40827, 40973, 40974, 
40960, 40812, 40825, 40972, 40959
27069, 37812, 37816, 37860, 37856, 37813, 37817, 37861, 37857, 40827, 40973, 40974, 40960, 40830, 40976, 40977, 
40963, 40815, 40828, 40975, 40962
27070, 37813, 37817, 37861, 37857, 16199, 16200, 16211, 16210, 40830, 40976, 40977, 40963, 0, 0, 0, 
0, 40818, 40831, 40978, 40965
27071, 5722, 5723, 5734, 5733, 37814, 37818, 37862, 37858, 0, 0, 0, 0, 40834, 40980, 40981, 
40967, 40819, 40832, 40979, 40966
27072, 37814, 37818, 37862, 37858, 37815, 37819, 37863, 37859, 40834, 40980, 40981, 40967, 40837, 40983, 40984, 
40970, 40822, 40835, 40982, 40969
27073, 37815, 37819, 37863, 37859, 37816, 37820, 37864, 37860, 40837, 40983, 40984, 40970, 40840, 40986, 40987, 
40973, 40825, 40838, 40985, 40972
27074, 37816, 37820, 37864, 37860, 37817, 37821, 37865, 37861, 40840, 40986, 40987, 40973, 40843, 40989, 40990, 
40976, 40828, 40841, 40988, 40975
27075, 37817, 37821, 37865, 37861, 16200, 16201, 16212, 16211, 40843, 40989, 40990, 40976, 0, 0, 0, 
0, 40831, 40844, 40991, 40978
27076, 5723, 5724, 5735, 5734, 37818, 37822, 37866, 37862, 0, 0, 0, 0, 40847, 40993, 40994, 
40980, 40832, 40845, 40992, 40979
27077, 37818, 37822, 37866, 37862, 37819, 37823, 37867, 37863, 40847, 40993, 40994, 40980, 40850, 40996, 40997, 
40983, 40835, 40848, 40995, 40982
27078, 37819, 37823, 37867, 37863, 37820, 37824, 37868, 37864, 40850, 40996, 40997, 40983, 40853, 40999, 41000, 
40986, 40838, 40851, 40998, 40985
27079, 37820, 37824, 37868, 37864, 37821, 37825, 37869, 37865, 40853, 40999, 41000, 40986, 40856, 41002, 41003, 
40989, 40841, 40854, 41001, 40988
27080, 37821, 37825, 37869, 37865, 16201, 16202, 16213, 16212, 40856, 41002, 41003, 40989, 0, 0, 0, 
0, 40844, 40857, 41004, 40991
27081, 5724, 5725, 5736, 5735, 37822, 37826, 37870, 37866, 0, 0, 0, 0, 40860, 41006, 41007, 
40993, 40845, 40858, 41005, 40992
27082, 37822, 37826, 37870, 37866, 37823, 37827, 37871, 37867, 40860, 41006, 41007, 40993, 40863, 41009, 41010, 
40996, 40848, 40861, 41008, 40995
27083, 37823, 37827, 37871, 37867, 37824, 37828, 37872, 37868, 40863, 41009, 41010, 40996, 40866, 41012, 41013, 
40999, 40851, 40864, 41011, 40998
27084, 37824, 37828, 37872, 37868, 37825, 37829, 37873, 37869, 40866, 41012, 41013, 40999, 40869, 41015, 41016, 
41002, 40854, 40867, 41014, 41001
27085, 37825, 37829, 37873, 37869, 16202, 16203, 16214, 16213, 40869, 41015, 41016, 41002, 0, 0, 0, 
0, 40857, 40870, 41017, 41004
27086, 5725, 5726, 5737, 5736, 37826, 37830, 37874, 37870, 0, 0, 0, 0, 40873, 41019, 41020, 
41006, 40858, 40871, 41018, 41005
27087, 37826, 37830, 37874, 37870, 37827, 37831, 37875, 37871, 40873, 41019, 41020, 41006, 40876, 41022, 41023, 
41009, 40861, 40874, 41021, 41008
27088, 37827, 37831, 37875, 37871, 37828, 37832, 37876, 37872, 40876, 41022, 41023, 41009, 40879, 41025, 41026, 
41012, 40864, 40877, 41024, 41011
27089, 37828, 37832, 37876, 37872, 37829, 37833, 37877, 37873, 40879, 41025, 41026, 41012, 40882, 41028, 41029, 
41015, 40867, 40880, 41027, 41014
27090, 37829, 37833, 37877, 37873, 16203, 16204, 16215, 16214, 40882, 41028, 41029, 41015, 0, 0, 0, 
0, 40870, 40883, 41030, 41017
27091, 5726, 5727, 5738, 5737, 37830, 37834, 37878, 37874, 0, 0, 0, 0, 40886, 41032, 41033, 
41019, 40871, 40884, 41031, 41018
27092, 37830, 37834, 37878, 37874, 37831, 37835, 37879, 37875, 40886, 41032, 41033, 41019, 40889, 41035, 41036, 
41022, 40874, 40887, 41034, 41021
27093, 37831, 37835, 37879, 37875, 37832, 37836, 37880, 37876, 40889, 41035, 41036, 41022, 40892, 41038, 41039, 
41025, 40877, 40890, 41037, 41024
27094, 37832, 37836, 37880, 37876, 37833, 37837, 37881, 37877, 40892, 41038, 41039, 41025, 40895, 41041, 41042, 
41028, 40880, 40893, 41040, 41027
27095, 37833, 37837, 37881, 37877, 16204, 16205, 16216, 16215, 40895, 41041, 41042, 41028, 0, 0, 0, 
0, 40883, 40896, 41043, 41030
27096, 5727, 5728, 5739, 5738, 37834, 37838, 37882, 37878, 0, 0, 0, 0, 40899, 41045, 41046, 
41032, 40884, 40897, 41044, 41031
27097, 37834, 37838, 37882, 37878, 37835, 37839, 37883, 37879, 40899, 41045, 41046, 41032, 40902, 41048, 41049, 
41035, 40887, 40900, 41047, 41034
27098, 37835, 37839, 37883, 37879, 37836, 37840, 37884, 37880, 40902, 41048, 41049, 41035, 40905, 41051, 41052, 
41038, 40890, 40903, 41050, 41037
27099, 37836, 37840, 37884, 37880, 37837, 37841, 37885, 37881, 40905, 41051, 41052, 41038, 40908, 41054, 41055, 
41041, 40893, 40906, 41053, 41040
27100, 37837, 37841, 37885, 37881, 16205, 16206, 16217, 16216, 40908, 41054, 41055, 41041, 0, 0, 0, 
0, 40896, 40909, 41056, 41043
27101, 5728, 599, 600, 5739, 37838, 15824, 15828, 37882, 0, 0, 0, 0, 40910, 0, 41057, 
41045, 40897, 0, 0, 41044
27102, 37838, 15824, 15828, 37882, 37839, 15825, 15829, 37883, 40910, 0, 41057, 41045, 40911, 0, 41058, 
41048, 40900, 0, 0, 41047
27103, 37839, 15825, 15829, 37883, 37840, 15826, 15830, 37884, 40911, 0, 41058, 41048, 40912, 0, 41059, 
41051, 40903, 0, 0, 41050
27104, 37840, 15826, 15830, 37884, 37841, 15827, 15831, 37885, 40912, 0, 41059, 41051, 40913, 0, 41060, 
41054, 40906, 0, 0, 41053
27105, 37841, 15827, 15831, 37885, 16206, 2055, 2056, 16217, 40913, 0, 41060, 41054, 0, 0, 0, 
0, 40909, 0, 0, 41056
27106, 562, 5729, 5740, 563, 15378, 37842, 37886, 15382, 0, 0, 0, 0, 40916, 41062, 41063, 
15579, 15571, 40914, 41061, 15580
27107, 15378, 37842, 37886, 15382, 15379, 37843, 37887, 15383, 40916, 41062, 41063, 15579, 40919, 41065, 41066, 
15581, 15573, 40917, 41064, 15582
27108, 15379, 37843, 37887, 15383, 15380, 37844, 37888, 15384, 40919, 41065, 41066, 15581, 40922, 41068, 41069, 
15583, 15575, 40920, 41067, 15584
27109, 15380, 37844, 37888, 15384, 15381, 37845, 37889, 15385, 40922, 41068, 41069, 15583, 40925, 41071, 41072, 
15585, 15577, 40923, 41070, 15586
27110, 15381, 37845, 37889, 15385, 2014, 16207, 16218, 2015, 40925, 41071, 41072, 15585, 0, 0, 0, 
0, 15578, 40926, 41073, 15587
27111, 5729, 5730, 5741, 5740, 37842, 37846, 37890, 37886, 0, 0, 0, 0, 40929, 41075, 41076, 
41062, 40914, 40927, 41074, 41061
27112, 37842, 37846, 37890, 37886, 37843, 37847, 37891, 37887, 40929, 41075, 41076, 41062, 40932, 41078, 41079, 
41065, 40917, 40930, 41077, 41064
27113, 37843, 37847, 37891, 37887, 37844, 37848, 37892, 37888, 40932, 41078, 41079, 41065, 40935, 41081, 41082, 
41068, 40920, 40933, 41080, 41067
27114, 37844, 37848, 37892, 37888, 37845, 37849, 37893, 37889, 40935, 41081, 41082, 41068, 40938, 41084, 41085, 
41071, 40923, 40936, 41083, 41070
27115, 37845, 37849, 37893, 37889, 16207, 16208, 16219, 16218, 40938, 41084, 41085, 41071, 0, 0, 0, 
0, 40926, 40939, 41086, 41073
27116, 5730, 5731, 5742, 5741, 37846, 37850, 37894, 37890, 0, 0, 0, 0, 40942, 41088, 41089, 
41075, 40927, 40940, 41087, 41074
27117, 37846, 37850, 37894, 37890, 37847, 37851, 37895, 37891, 40942, 41088, 41089, 41075, 40945, 41091, 41092, 
41078, 40930, 40943, 41090, 41077
27118, 37847, 37851, 37895, 37891, 37848, 37852, 37896, 37892, 40945, 41091, 41092, 41078, 40948, 41094, 41095, 
41081, 40933, 40946, 41093, 41080
27119, 37848, 37852, 37896, 37892, 37849, 37853, 37897, 37893, 40948, 41094, 41095, 41081, 40951, 41097, 41098, 
41084, 40936, 40949, 41096, 41083
27120, 37849, 37853, 37897, 37893, 16208, 16209, 16220, 16219, 40951, 41097, 41098, 41084, 0, 0, 0, 
0, 40939, 40952, 41099, 41086
27121, 5731, 5732, 5743, 5742, 37850, 37854, 37898, 37894, 0, 0, 0, 0, 40955, 41101, 41102, 
41088, 40940, 40953, 41100, 41087
27122, 37850, 37854, 37898, 37894, 37851, 37855, 37899, 37895, 40955, 41101, 41102, 41088, 40958, 41104, 41105, 
41091, 40943, 40956, 41103, 41090
27123, 37851, 37855, 37899, 37895, 37852, 37856, 37900, 37896, 40958, 41104, 41105, 41091, 40961, 41107, 41108, 
41094, 40946, 40959, 41106, 41093
27124, 37852, 37856, 37900, 37896, 37853, 37857, 37901, 37897, 40961, 41107, 41108, 41094, 40964, 41110, 41111, 
41097, 40949, 40962, 41109, 41096
27125, 37853, 37857, 37901, 37897, 16209, 16210, 16221, 16220, 40964, 41110, 41111, 41097, 0, 0, 0, 
0, 40952, 40965, 41112, 41099
27126, 5732, 5733, 5744, 5743, 37854, 37858, 37902, 37898, 0, 0, 0, 0, 40968, 41114, 41115, 
41101, 40953, 40966, 41113, 41100
27127, 37854, 37858, 37902, 37898, 37855, 37859, 37903, 37899, 40968, 41114, 41115, 41101, 40971, 41117, 41118, 
41104, 40956, 40969, 41116, 41103
27128, 37855, 37859, 37903, 37899, 37856, 37860, 37904, 37900, 40971, 41117, 41118, 41104, 40974, 41120, 41121, 
41107, 40959, 40972, 41119, 41106
27129, 37856, 37860, 37904, 37900, 37857, 37861, 37905, 37901, 40974, 41120, 41121, 41107, 40977, 41123, 41124, 
41110, 40962, 40975, 41122, 41109
27130, 37857, 37861, 37905, 37901, 16210, 16211, 16222, 16221, 40977, 41123, 41124, 41110, 0, 0, 0, 
0, 40965, 40978, 41125, 41112
27131, 5733, 5734, 5745, 5744, 37858, 37862, 37906, 37902, 0, 0, 0, 0, 40981, 41127, 41128, 
41114, 40966, 40979, 41126, 41113
27132, 37858, 37862, 37906, 37902, 37859, 37863, 37907, 37903, 40981, 41127, 41128, 41114, 40984, 41130, 41131, 
41117, 40969, 40982, 41129, 41116
27133, 37859, 37863, 37907, 37903, 37860, 37864, 37908, 37904, 40984, 41130, 41131, 41117, 40987, 41133, 41134, 
41120, 40972, 40985, 41132, 41119
27134, 37860, 37864, 37908, 37904, 37861, 37865, 37909, 37905, 40987, 41133, 41134, 41120, 40990, 41136, 41137, 
41123, 40975, 40988, 41135, 41122
27135, 37861, 37865, 37909, 37905, 16211, 16212, 16223, 16222, 40990, 41136, 41137, 41123, 0, 0, 0, 
0, 40978, 40991, 41138, 41125
27136, 5734, 5735, 5746, 5745, 37862, 37866, 37910, 37906, 0, 0, 0, 0, 40994, 41140, 41141, 
41127, 40979, 40992, 41139, 41126
27137, 37862, 37866, 37910, 37906, 37863, 37867, 37911, 37907, 40994, 41140, 41141, 41127, 40997, 41143, 41144, 
41130, 40982, 40995, 41142, 41129
27138, 37863, 37867, 37911, 37907, 37864, 37868, 37912, 37908, 40997, 41143, 41144, 41130, 41000, 41146, 41147, 
41133, 40985, 40998, 41145, 41132
27139, 37864, 37868, 37912, 37908, 37865, 37869, 37913, 37909, 41000, 41146, 41147, 41133, 41003, 41149, 41150, 
41136, 40988, 41001, 41148, 41135
27140, 37865, 37869, 37913, 37909, 16212, 16213, 16224, 16223, 41003, 41149, 41150, 41136, 0, 0, 0, 
0, 40991, 41004, 41151, 41138
27141, 5735, 5736, 5747, 5746, 37866, 37870, 37914, 37910, 0, 0, 0, 0, 41007, 41153, 41154, 
41140, 40992, 41005, 41152, 41139
27142, 37866, 37870, 37914, 37910, 37867, 37871, 37915, 37911, 41007, 41153, 41154, 41140, 41010, 41156, 41157, 
41143, 40995, 41008, 41155, 41142
27143, 37867, 37871, 37915, 37911, 37868, 37872, 37916, 37912, 41010, 41156, 41157, 41143, 41013, 41159, 41160, 
41146, 40998, 41011, 41158, 41145
27144, 37868, 37872, 37916, 37912, 37869, 37873, 37917, 37913, 41013, 41159, 41160, 41146, 41016, 41162, 41163, 
41149, 41001, 41014, 41161, 41148
27145, 37869, 37873, 37917, 37913, 16213, 16214, 16225, 16224, 41016, 41162, 41163, 41149, 0, 0, 0, 
0, 41004, 41017, 41164, 41151
27146, 5736, 5737, 5748, 5747, 37870, 37874, 37918, 37914, 0, 0, 0, 0, 41020, 41166, 41167, 
41153, 41005, 41018, 41165, 41152
27147, 37870, 37874, 37918, 37914, 37871, 37875, 37919, 37915, 41020, 41166, 41167, 41153, 41023, 41169, 41170, 
41156, 41008, 41021, 41168, 41155
27148, 37871, 37875, 37919, 37915, 37872, 37876, 37920, 37916, 41023, 41169, 41170, 41156, 41026, 41172, 41173, 
41159, 41011, 41024, 41171, 41158
27149, 37872, 37876, 37920, 37916, 37873, 37877, 37921, 37917, 41026, 41172, 41173, 41159, 41029, 41175, 41176, 
41162, 41014, 41027, 41174, 41161
27150, 37873, 37877, 37921, 37917, 16214, 16215, 16226, 16225, 41029, 41175, 41176, 41162, 0, 0, 0, 
0, 41017, 41030, 41177, 41164
27151, 5737, 5738, 5749, 5748, 37874, 37878, 37922, 37918, 0, 0, 0, 0, 41033, 41179, 41180, 
41166, 41018, 41031, 41178, 41165
27152, 37874, 37878, 37922, 37918, 37875, 37879, 37923, 37919, 41033, 41179, 41180, 41166, 41036, 41182, 41183, 
41169, 41021, 41034, 41181, 41168
27153, 37875, 37879, 37923, 37919, 37876, 37880, 37924, 37920, 41036, 41182, 41183, 41169, 41039, 41185, 41186, 
41172, 41024, 41037, 41184, 41171
27154, 37876, 37880, 37924, 37920, 37877, 37881, 37925, 37921, 41039, 41185, 41186, 41172, 41042, 41188, 41189, 
41175, 41027, 41040, 41187, 41174
27155, 37877, 37881, 37925, 37921, 16215, 16216, 16227, 16226, 41042, 41188, 41189, 41175, 0, 0, 0, 
0, 41030, 41043, 41190, 41177
27156, 5738, 5739, 5750, 5749, 37878, 37882, 37926, 37922, 0, 0, 0, 0, 41046, 41192, 41193, 
41179, 41031, 41044, 41191, 41178
27157, 37878, 37882, 37926, 37922, 37879, 37883, 37927, 37923, 41046, 41192, 41193, 41179, 41049, 41195, 41196, 
41182, 41034, 41047, 41194, 41181
27158, 37879, 37883, 37927, 37923, 37880, 37884, 37928, 37924, 41049, 41195, 41196, 41182, 41052, 41198, 41199, 
41185, 41037, 41050, 41197, 41184
27159, 37880, 37884, 37928, 37924, 37881, 37885, 37929, 37925, 41052, 41198, 41199, 41185, 41055, 41201, 41202, 
41188, 41040, 41053, 41200, 41187
27160, 37881, 37885, 37929, 37925, 16216, 16217, 16228, 16227, 41055, 41201, 41202, 41188, 0, 0, 0, 
0, 41043, 41056, 41203, 41190
27161, 5739, 600, 601, 5750, 37882, 15828, 15832, 37926, 0, 0, 0, 0, 41057, 0, 41204, 
41192, 41044, 0, 0, 41191
27162, 37882, 15828, 15832, 37926, 37883, 15829, 15833, 37927, 41057, 0, 41204, 41192, 41058, 0, 41205, 
41195, 41047, 0, 0, 41194
27163, 37883, 15829, 15833, 37927, 37884, 15830, 15834, 37928, 41058, 0, 41205, 41195, 41059, 0, 41206, 
41198, 41050, 0, 0, 41197
27164, 37884, 15830, 15834, 37928, 37885, 15831, 15835, 37929, 41059, 0, 41206, 41198, 41060, 0, 41207, 
41201, 41053, 0, 0, 41200
27165, 37885, 15831, 15835, 37929, 16217, 2056, 2057, 16228, 41060, 0, 41207, 41201, 0, 0, 0, 
0, 41056, 0, 0, 41203
27166, 563, 5740, 5751, 564, 15382, 37886, 37930, 15386, 0, 0, 0, 0, 41063, 41209, 41210, 
15588, 15580, 41061, 41208, 15589
27167, 15382, 37886, 37930, 15386, 15383, 37887, 37931, 15387, 41063, 41209, 41210, 15588, 41066, 41212, 41213, 
15590, 15582, 41064, 41211, 15591
27168, 15383, 37887, 37931, 15387, 15384, 37888, 37932, 15388, 41066, 41212, 41213, 15590, 41069, 41215, 41216, 
15592, 15584, 41067, 41214, 15593
27169, 15384, 37888, 37932, 15388, 15385, 37889, 37933, 15389, 41069, 41215, 41216, 15592, 41072, 41218, 41219, 
15594, 15586, 41070, 41217, 15595
27170, 15385, 37889, 37933, 15389, 2015, 16218, 16229, 2016, 41072, 41218, 41219, 15594, 0, 0, 0, 
0, 15587, 41073, 41220, 15596
27171, 5740, 5741, 5752, 5751, 37886, 37890, 37934, 37930, 0, 0, 0, 0, 41076, 41222, 41223, 
41209, 41061, 41074, 41221, 41208
27172, 37886, 37890, 37934, 37930, 37887, 37891, 37935, 37931, 41076, 41222, 41223, 41209, 41079, 41225, 41226, 
41212, 41064, 41077, 41224, 41211
27173, 37887, 37891, 37935, 37931, 37888, 37892, 37936, 37932, 41079, 41225, 41226, 41212, 41082, 41228, 41229, 
41215, 41067, 41080, 41227, 41214
27174, 37888, 37892, 37936, 37932, 37889, 37893, 37937, 37933, 41082, 41228, 41229, 41215, 41085, 41231, 41232, 
41218, 41070, 41083, 41230, 41217
27175, 37889, 37893, 37937, 37933, 16218, 16219, 16230, 16229, 41085, 41231, 41232, 41218, 0, 0, 0, 
0, 41073, 41086, 41233, 41220
27176, 5741, 5742, 5753, 5752, 37890, 37894, 37938, 37934, 0, 0, 0, 0, 41089, 41235, 41236, 
41222, 41074, 41087, 41234, 41221
27177, 37890, 37894, 37938, 37934, 37891, 37895, 37939, 37935, 41089, 41235, 41236, 41222, 41092, 41238, 41239, 
41225, 41077, 41090, 41237, 41224
27178, 37891, 37895, 37939, 37935, 37892, 37896, 37940, 37936, 41092, 41238, 41239, 41225, 41095, 41241, 41242, 
41228, 41080, 41093, 41240, 41227
27179, 37892, 37896, 37940, 37936, 37893, 37897, 37941, 37937, 41095, 41241, 41242, 41228, 41098, 41244, 41245, 
41231, 41083, 41096, 41243, 41230
27180, 37893, 37897, 37941, 37937, 16219, 16220, 16231, 16230, 41098, 41244, 41245, 41231, 0, 0, 0, 
0, 41086, 41099, 41246, 41233
27181, 5742, 5743, 5754, 5753, 37894, 37898, 37942, 37938, 0, 0, 0, 0, 41102, 41248, 41249, 
41235, 41087, 41100, 41247, 41234
27182, 37894, 37898, 37942, 37938, 37895, 37899, 37943, 37939, 41102, 41248, 41249, 41235, 41105, 41251, 41252, 
41238, 41090, 41103, 41250, 41237
27183, 37895, 37899, 37943, 37939, 37896, 37900, 37944, 37940, 41105, 41251, 41252, 41238, 41108, 41254, 41255, 
41241, 41093, 41106, 41253, 41240
27184, 37896, 37900, 37944, 37940, 37897, 37901, 37945, 37941, 41108, 41254, 41255, 41241, 41111, 41257, 41258, 
41244, 41096, 41109, 41256, 41243
27185, 37897, 37901, 37945, 37941, 16220, 16221, 16232, 16231, 41111, 41257, 41258, 41244, 0, 0, 0, 
0, 41099, 41112, 41259, 41246
27186, 5743, 5744, 5755, 5754, 37898, 37902, 37946, 37942, 0, 0, 0, 0, 41115, 41261, 41262, 
41248, 41100, 41113, 41260, 41247
27187, 37898, 37902, 37946, 37942, 37899, 37903, 37947, 37943, 41115, 41261, 41262, 41248, 41118, 41264, 41265, 
41251, 41103, 41116, 41263, 41250
27188, 37899, 37903, 37947, 37943, 37900, 37904, 37948, 37944, 41118, 41264, 41265, 41251, 41121, 41267, 41268, 
41254, 41106, 41119, 41266, 41253
27189, 37900, 37904, 37948, 37944, 37901, 37905, 37949, 37945, 41121, 41267, 41268, 41254, 41124, 41270, 41271, 
41257, 41109, 41122, 41269, 41256
27190, 37901, 37905, 37949, 37945, 16221, 16222, 16233, 16232, 41124, 41270, 41271, 41257, 0, 0, 0, 
0, 41112, 41125, 41272, 41259
27191, 5744, 5745, 5756, 5755, 37902, 37906, 37950, 37946, 0, 0, 0, 0, 41128, 41274, 41275, 
41261, 41113, 41126, 41273, 41260
27192, 37902, 37906, 37950, 37946, 37903, 37907, 37951, 37947, 41128, 41274, 41275, 41261, 41131, 41277, 41278, 
41264, 41116, 41129, 41276, 41263
27193, 37903, 37907, 37951, 37947, 37904, 37908, 37952, 37948, 41131, 41277, 41278, 41264, 41134, 41280, 41281, 
41267, 41119, 41132, 41279, 41266
27194, 37904, 37908, 37952, 37948, 37905, 37909, 37953, 37949, 41134, 41280, 41281, 41267, 41137, 41283, 41284, 
41270, 41122, 41135, 41282, 41269
27195, 37905, 37909, 37953, 37949, 16222, 16223, 16234, 16233, 41137, 41283, 41284, 41270, 0, 0, 0, 
0, 41125, 41138, 41285, 41272
27196, 5745, 5746, 5757, 5756, 37906, 37910, 37954, 37950, 0, 0, 0, 0, 41141, 41287, 41288, 
41274, 41126, 41139, 41286, 41273
27197, 37906, 37910, 37954, 37950, 37907, 37911, 37955, 37951, 41141, 41287, 41288, 41274, 41144, 41290, 41291, 
41277, 41129, 41142, 41289, 41276
27198, 37907, 37911, 37955, 37951, 37908, 37912, 37956, 37952, 41144, 41290, 41291, 41277, 41147, 41293, 41294, 
41280, 41132, 41145, 41292, 41279
27199, 37908, 37912, 37956, 37952, 37909, 37913, 37957, 37953, 41147, 41293, 41294, 41280, 41150, 41296, 41297, 
41283, 41135, 41148, 41295, 41282
27200, 37909, 37913, 37957, 37953, 16223, 16224, 16235, 16234, 41150, 41296, 41297, 41283, 0, 0, 0, 
0, 41138, 41151, 41298, 41285
27201, 5746, 5747, 5758, 5757, 37910, 37914, 37958, 37954, 0, 0, 0, 0, 41154, 41300, 41301, 
41287, 41139, 41152, 41299, 41286
27202, 37910, 37914, 37958, 37954, 37911, 37915, 37959, 37955, 41154, 41300, 41301, 41287, 41157, 41303, 41304, 
41290, 41142, 41155, 41302, 41289
27203, 37911, 37915, 37959, 37955, 37912, 37916, 37960, 37956, 41157, 41303, 41304, 41290, 41160, 41306, 41307, 
41293, 41145, 41158, 41305, 41292
27204, 37912, 37916, 37960, 37956, 37913, 37917, 37961, 37957, 41160, 41306, 41307, 41293, 41163, 41309, 41310, 
41296, 41148, 41161, 41308, 41295
27205, 37913, 37917, 37961, 37957, 16224, 16225, 16236, 16235, 41163, 41309, 41310, 41296, 0, 0, 0, 
0, 41151, 41164, 41311, 41298
27206, 5747, 5748, 5759, 5758, 37914, 37918, 37962, 37958, 0, 0, 0, 0, 41167, 41313, 41314, 
41300, 41152, 41165, 41312, 41299
27207, 37914, 37918, 37962, 37958, 37915, 37919, 37963, 37959, 41167, 41313, 41314, 41300, 41170, 41316, 41317, 
41303, 41155, 41168, 41315, 41302
27208, 37915, 37919, 37963, 37959, 37916, 37920, 37964, 37960, 41170, 41316, 41317, 41303, 41173, 41319, 41320, 
41306, 41158, 41171, 41318, 41305
27209, 37916, 37920, 37964, 37960, 37917, 37921, 37965, 37961, 41173, 41319, 41320, 41306, 41176, 41322, 41323, 
41309, 41161, 41174, 41321, 41308
27210, 37917, 37921, 37965, 37961, 16225, 16226, 16237, 16236, 41176, 41322, 41323, 41309, 0, 0, 0, 
0, 41164, 41177, 41324, 41311
27211, 5748, 5749, 5760, 5759, 37918, 37922, 37966, 37962, 0, 0, 0, 0, 41180, 41326, 41327, 
41313, 41165, 41178, 41325, 41312
27212, 37918, 37922, 37966, 37962, 37919, 37923, 37967, 37963, 41180, 41326, 41327, 41313, 41183, 41329, 41330, 
41316, 41168, 41181, 41328, 41315
27213, 37919, 37923, 37967, 37963, 37920, 37924, 37968, 37964, 41183, 41329, 41330, 41316, 41186, 41332, 41333, 
41319, 41171, 41184, 41331, 41318
27214, 37920, 37924, 37968, 37964, 37921, 37925, 37969, 37965, 41186, 41332, 41333, 41319, 41189, 41335, 41336, 
41322, 41174, 41187, 41334, 41321
27215, 37921, 37925, 37969, 37965, 16226, 16227, 16238, 16237, 41189, 41335, 41336, 41322, 0, 0, 0, 
0, 41177, 41190, 41337, 41324
27216, 5749, 5750, 5761, 5760, 37922, 37926, 37970, 37966, 0, 0, 0, 0, 41193, 41339, 41340, 
41326, 41178, 41191, 41338, 41325
27217, 37922, 37926, 37970, 37966, 37923, 37927, 37971, 37967, 41193, 41339, 41340, 41326, 41196, 41342, 41343, 
41329, 41181, 41194, 41341, 41328
27218, 37923, 37927, 37971, 37967, 37924, 37928, 37972, 37968, 41196, 41342, 41343, 41329, 41199, 41345, 41346, 
41332, 41184, 41197, 41344, 41331
27219, 37924, 37928, 37972, 37968, 37925, 37929, 37973, 37969, 41199, 41345, 41346, 41332, 41202, 41348, 41349, 
41335, 41187, 41200, 41347, 41334
27220, 37925, 37929, 37973, 37969, 16227, 16228, 16239, 16238, 41202, 41348, 41349, 41335, 0, 0, 0, 
0, 41190, 41203, 41350, 41337
27221, 5750, 601, 602, 5761, 37926, 15832, 15836, 37970, 0, 0, 0, 0, 41204, 0, 41351, 
41339, 41191, 0, 0, 41338
27222, 37926, 15832, 15836, 37970, 37927, 15833, 15837, 37971, 41204, 0, 41351, 41339, 41205, 0, 41352, 
41342, 41194, 0, 0, 41341
27223, 37927, 15833, 15837, 37971, 37928, 15834, 15838, 37972, 41205, 0, 41352, 41342, 41206, 0, 41353, 
41345, 41197, 0, 0, 41344
27224, 37928, 15834, 15838, 37972, 37929, 15835, 15839, 37973, 41206, 0, 41353, 41345, 41207, 0, 41354, 
41348, 41200, 0, 0, 41347
27225, 37929, 15835, 15839, 37973, 16228, 2057, 2058, 16239, 41207, 0, 41354, 41348, 0, 0, 0, 
0, 41203, 0, 0, 41350
27226, 564, 5751, 567, 21, 15386, 37930, 15601, 1976, 0, 0, 0, 0, 41210, 41355, 15645, 
15597, 15589, 41208, 15646, 1980
27227, 15386, 37930, 15601, 1976, 15387, 37931, 15602, 1977, 41210, 41355, 15645, 15597, 41213, 41356, 15647, 
15598, 15591, 41211, 15648, 1981
27228, 15387, 37931, 15602, 1977, 15388, 37932, 15603, 1978, 41213, 41356, 15647, 15598, 41216, 41357, 15649, 
15599, 15593, 41214, 15650, 1982
27229, 15388, 37932, 15603, 1978, 15389, 37933, 15604, 1979, 41216, 41357, 15649, 15599, 41219, 41358, 15651, 
15600, 15595, 41217, 15652, 1983
27230, 15389, 37933, 15604, 1979, 2016, 16229, 2021, 77, 41219, 41358, 15651, 15600, 0, 0, 0, 
0, 15596, 41220, 15653, 1984
27231, 5751, 5752, 568, 567, 37930, 37934, 15605, 15601, 0, 0, 0, 0, 41223, 41359, 15654, 
41355, 41208, 41221, 15655, 15646
27232, 37930, 37934, 15605, 15601, 37931, 37935, 15606, 15602, 41223, 41359, 15654, 41355, 41226, 41360, 15656, 
41356, 41211, 41224, 15657, 15648
27233, 37931, 37935, 15606, 15602, 37932, 37936, 15607, 15603, 41226, 41360, 15656, 41356, 41229, 41361, 15658, 
41357, 41214, 41227, 15659, 15650
27234, 37932, 37936, 15607, 15603, 37933, 37937, 15608, 15604, 41229, 41361, 15658, 41357, 41232, 41362, 15660, 
41358, 41217, 41230, 15661, 15652
27235, 37933, 37937, 15608, 15604, 16229, 16230, 2022, 2021, 41232, 41362, 15660, 41358, 0, 0, 0, 
0, 41220, 41233, 15662, 15653
27236, 5752, 5753, 569, 568, 37934, 37938, 15609, 15605, 0, 0, 0, 0, 41236, 41363, 15663, 
41359, 41221, 41234, 15664, 15655
27237, 37934, 37938, 15609, 15605, 37935, 37939, 15610, 15606, 41236, 41363, 15663, 41359, 41239, 41364, 15665, 
41360, 41224, 41237, 15666, 15657
27238, 37935, 37939, 15610, 15606, 37936, 37940, 15611, 15607, 41239, 41364, 15665, 41360, 41242, 41365, 15667, 
41361, 41227, 41240, 15668, 15659
27239, 37936, 37940, 15611, 15607, 37937, 37941, 15612, 15608, 41242, 41365, 15667, 41361, 41245, 41366, 15669, 
41362, 41230, 41243, 15670, 15661
27240, 37937, 37941, 15612, 15608, 16230, 16231, 2023, 2022, 41245, 41366, 15669, 41362, 0, 0, 0, 
0, 41233, 41246, 15671, 15662
27241, 5753, 5754, 570, 569, 37938, 37942, 15613, 15609, 0, 0, 0, 0, 41249, 41367, 15672, 
41363, 41234, 41247, 15673, 15664
27242, 37938, 37942, 15613, 15609, 37939, 37943, 15614, 15610, 41249, 41367, 15672, 41363, 41252, 41368, 15674, 
41364, 41237, 41250, 15675, 15666
27243, 37939, 37943, 15614, 15610, 37940, 37944, 15615, 15611, 41252, 41368, 15674, 41364, 41255, 41369, 15676, 
41365, 41240, 41253, 15677, 15668
27244, 37940, 37944, 15615, 15611, 37941, 37945, 15616, 15612, 41255, 41369, 15676, 41365, 41258, 41370, 15678, 
41366, 41243, 41256, 15679, 15670
27245, 37941, 37945, 15616, 15612, 16231, 16232, 2024, 2023, 41258, 41370, 15678, 41366, 0, 0, 0, 
0, 41246, 41259, 15680, 15671
27246, 5754, 5755, 571, 570, 37942, 37946, 15617, 15613, 0, 0, 0, 0, 41262, 41371, 15681, 
41367, 41247, 41260, 15682, 15673
27247, 37942, 37946, 15617, 15613, 37943, 37947, 15618, 15614, 41262, 41371, 15681, 41367, 41265, 41372, 15683, 
41368, 41250, 41263, 15684, 15675
27248, 37943, 37947, 15618, 15614, 37944, 37948, 15619, 15615, 41265, 41372, 15683, 41368, 41268, 41373, 15685, 
41369, 41253, 41266, 15686, 15677
27249, 37944, 37948, 15619, 15615, 37945, 37949, 15620, 15616, 41268, 41373, 15685, 41369, 41271, 41374, 15687, 
41370, 41256, 41269, 15688, 15679
27250, 37945, 37949, 15620, 15616, 16232, 16233, 2025, 2024, 41271, 41374, 15687, 41370, 0, 0, 0, 
0, 41259, 41272, 15689, 15680
27251, 5755, 5756, 572, 571, 37946, 37950, 15621, 15617, 0, 0, 0, 0, 41275, 41375, 15690, 
41371, 41260, 41273, 15691, 15682
27252, 37946, 37950, 15621, 15617, 37947, 37951, 15622, 15618, 41275, 41375, 15690, 41371, 41278, 41376, 15692, 
41372, 41263, 41276, 15693, 15684
27253, 37947, 37951, 15622, 15618, 37948, 37952, 15623, 15619, 41278, 41376, 15692, 41372, 41281, 41377, 15694, 
41373, 41266, 41279, 15695, 15686
27254, 37948, 37952, 15623, 15619, 37949, 37953, 15624, 15620, 41281, 41377, 15694, 41373, 41284, 41378, 15696, 
41374, 41269, 41282, 15697, 15688
27255, 37949, 37953, 15624, 15620, 16233, 16234, 2026, 2025, 41284, 41378, 15696, 41374, 0, 0, 0, 
0, 41272, 41285, 15698, 15689
27256, 5756, 5757, 573, 572, 37950, 37954, 15625, 15621, 0, 0, 0, 0, 41288, 41379, 15699, 
41375, 41273, 41286, 15700, 15691
27257, 37950, 37954, 15625, 15621, 37951, 37955, 15626, 15622, 41288, 41379, 15699, 41375, 41291, 41380, 15701, 
41376, 41276, 41289, 15702, 15693
27258, 37951, 37955, 15626, 15622, 37952, 37956, 15627, 15623, 41291, 41380, 15701, 41376, 41294, 41381, 15703, 
41377, 41279, 41292, 15704, 15695
27259, 37952, 37956, 15627, 15623, 37953, 37957, 15628, 15624, 41294, 41381, 15703, 41377, 41297, 41382, 15705, 
41378, 41282, 41295, 15706, 15697
27260, 37953, 37957, 15628, 15624, 16234, 16235, 2027, 2026, 41297, 41382, 15705, 41378, 0, 0, 0, 
0, 41285, 41298, 15707, 15698
27261, 5757, 5758, 574, 573, 37954, 37958, 15629, 15625, 0, 0, 0, 0, 41301, 41383, 15708, 
41379, 41286, 41299, 15709, 15700
27262, 37954, 37958, 15629, 15625, 37955, 37959, 15630, 15626, 41301, 41383, 15708, 41379, 41304, 41384, 15710, 
41380, 41289, 41302, 15711, 15702
27263, 37955, 37959, 15630, 15626, 37956, 37960, 15631, 15627, 41304, 41384, 15710, 41380, 41307, 41385, 15712, 
41381, 41292, 41305, 15713, 15704
27264, 37956, 37960, 15631, 15627, 37957, 37961, 15632, 15628, 41307, 41385, 15712, 41381, 41310, 41386, 15714, 
41382, 41295, 41308, 15715, 15706
27265, 37957, 37961, 15632, 15628, 16235, 16236, 2028, 2027, 41310, 41386, 15714, 41382, 0, 0, 0, 
0, 41298, 41311, 15716, 15707
27266, 5758, 5759, 575, 574, 37958, 37962, 15633, 15629, 0, 0, 0, 0, 41314, 41387, 15717, 
41383, 41299, 41312, 15718, 15709
27267, 37958, 37962, 15633, 15629, 37959, 37963, 15634, 15630, 41314, 41387, 15717, 41383, 41317, 41388, 15719, 
41384, 41302, 41315, 15720, 15711
27268, 37959, 37963, 15634, 15630, 37960, 37964, 15635, 15631, 41317, 41388, 15719, 41384, 41320, 41389, 15721, 
41385, 41305, 41318, 15722, 15713
27269, 37960, 37964, 15635, 15631, 37961, 37965, 15636, 15632, 41320, 41389, 15721, 41385, 41323, 41390, 15723, 
41386, 41308, 41321, 15724, 15715
27270, 37961, 37965, 15636, 15632, 16236, 16237, 2029, 2028, 41323, 41390, 15723, 41386, 0, 0, 0, 
0, 41311, 41324, 15725, 15716
27271, 5759, 5760, 576, 575, 37962, 37966, 15637, 15633, 0, 0, 0, 0, 41327, 41391, 15726, 
41387, 41312, 41325, 15727, 15718
27272, 37962, 37966, 15637, 15633, 37963, 37967, 15638, 15634, 41327, 41391, 15726, 41387, 41330, 41392, 15728, 
41388, 41315, 41328, 15729, 15720
27273, 37963, 37967, 15638, 15634, 37964, 37968, 15639, 15635, 41330, 41392, 15728, 41388, 41333, 41393, 15730, 
41389, 41318, 41331, 15731, 15722
27274, 37964, 37968, 15639, 15635, 37965, 37969, 15640, 15636, 41333, 41393, 15730, 41389, 41336, 41394, 15732, 
41390, 41321, 41334, 15733, 15724
27275, 37965, 37969, 15640, 15636, 16237, 16238, 2030, 2029, 41336, 41394, 15732, 41390, 0, 0, 0, 
0, 41324, 41337, 15734, 15725
27276, 5760, 5761, 577, 576, 37966, 37970, 15641, 15637, 0, 0, 0, 0, 41340, 41395, 15735, 
41391, 41325, 41338, 15736, 15727
27277, 37966, 37970, 15641, 15637, 37967, 37971, 15642, 15638, 41340, 41395, 15735, 41391, 41343, 41396, 15737, 
41392, 41328, 41341, 15738, 15729
27278, 37967, 37971, 15642, 15638, 37968, 37972, 15643, 15639, 41343, 41396, 15737, 41392, 41346, 41397, 15739, 
41393, 41331, 41344, 15740, 15731
27279, 37968, 37972, 15643, 15639, 37969, 37973, 15644, 15640, 41346, 41397, 15739, 41393, 41349, 41398, 15741, 
41394, 41334, 41347, 15742, 15733
27280, 37969, 37973, 15644, 15640, 16238, 16239, 2031, 2030, 41349, 41398, 15741, 41394, 0, 0, 0, 
0, 41337, 41350, 15743, 15734
27281, 5761, 602, 23, 577, 37970, 15836, 2017, 15641, 0, 0, 0, 0, 41351, 0, 15744, 
41395, 41338, 0, 0, 15736
27282, 37970, 15836, 2017, 15641, 37971, 15837, 2018, 15642, 41351, 0, 15744, 41395, 41352, 0, 15745, 
41396, 41341, 0, 0, 15738
27283, 37971, 15837, 2018, 15642, 37972, 15838, 2019, 15643, 41352, 0, 15745, 41396, 41353, 0, 15746, 
41397, 41344, 0, 0, 15740
27284, 37972, 15838, 2019, 15643, 37973, 15839, 2020, 15644, 41353, 0, 15746, 41397, 41354, 0, 15747, 
41398, 41347, 0, 0, 15742
27285, 37973, 15839, 2020, 15644, 16239, 2058, 79, 2031, 41354, 0, 15747, 41398, 0, 0, 0, 
0, 41350, 0, 0, 15743
*ELEMENT, type=C3D20, ELSET=Volume21
27286, 21, 567, 5822, 628, 1976, 15601, 41399, 16256, 0, 0, 0, 0, 15645, 41576, 41577, 
16272, 1980, 15646, 41575, 16273
27287, 1976, 15601, 41399, 16256, 1977, 15602, 41400, 16257, 15645, 41576, 41577, 16272, 15647, 41579, 41580, 
16274, 1981, 15648, 41578, 16275
27288, 1977, 15602, 41400, 16257, 1978, 15603, 41401, 16258, 15647, 41579, 41580, 16274, 15649, 41582, 41583, 
16276, 1982, 15650, 41581, 16277
27289, 1978, 15603, 41401, 16258, 1979, 15604, 41402, 16259, 15649, 41582, 41583, 16276, 15651, 41585, 41586, 
16278, 1983, 15652, 41584, 16279
27290, 1979, 15604, 41402, 16259, 77, 2021, 16459, 2087, 15651, 41585, 41586, 16278, 0, 0, 0, 
0, 1984, 15653, 41587, 16280
27291, 628, 5822, 5823, 629, 16256, 41399, 41403, 16260, 0, 0, 0, 0, 41577, 41589, 41590, 
16281, 16273, 41575, 41588, 16282
