31617, 51865, 51869, 51961, 51957, 51866, 51870, 51962, 51958, 54589, 54891, 54892, 54878, 54592, 54894, 54895, 
54881, 54577, 54590, 54893, 54880
31618, 51866, 51870, 51962, 51958, 51867, 51871, 51963, 51959, 54592, 54894, 54895, 54881, 54595, 54897, 54898, 
54884, 54580, 54593, 54896, 54883
31619, 51867, 51871, 51963, 51959, 51868, 51872, 51964, 51960, 54595, 54897, 54898, 54884, 54598, 54900, 54901, 
54887, 54583, 54596, 54899, 54886
31620, 51868, 51872, 51964, 51960, 19265, 19266, 19289, 19288, 54598, 54900, 54901, 54887, 0, 0, 0, 
0, 54586, 54599, 54902, 54889
31621, 9969, 9970, 9993, 9992, 51869, 51873, 51965, 51961, 0, 0, 0, 0, 54602, 54904, 54905, 
54891, 54587, 54600, 54903, 54890
31622, 51869, 51873, 51965, 51961, 51870, 51874, 51966, 51962, 54602, 54904, 54905, 54891, 54605, 54907, 54908, 
54894, 54590, 54603, 54906, 54893
31623, 51870, 51874, 51966, 51962, 51871, 51875, 51967, 51963, 54605, 54907, 54908, 54894, 54608, 54910, 54911, 
54897, 54593, 54606, 54909, 54896
31624, 51871, 51875, 51967, 51963, 51872, 51876, 51968, 51964, 54608, 54910, 54911, 54897, 54611, 54913, 54914, 
54900, 54596, 54609, 54912, 54899
31625, 51872, 51876, 51968, 51964, 19266, 19267, 19290, 19289, 54611, 54913, 54914, 54900, 0, 0, 0, 
0, 54599, 54612, 54915, 54902
31626, 9970, 9971, 9994, 9993, 51873, 51877, 51969, 51965, 0, 0, 0, 0, 54615, 54917, 54918, 
54904, 54600, 54613, 54916, 54903
31627, 51873, 51877, 51969, 51965, 51874, 51878, 51970, 51966, 54615, 54917, 54918, 54904, 54618, 54920, 54921, 
54907, 54603, 54616, 54919, 54906
31628, 51874, 51878, 51970, 51966, 51875, 51879, 51971, 51967, 54618, 54920, 54921, 54907, 54621, 54923, 54924, 
54910, 54606, 54619, 54922, 54909
31629, 51875, 51879, 51971, 51967, 51876, 51880, 51972, 51968, 54621, 54923, 54924, 54910, 54624, 54926, 54927, 
54913, 54609, 54622, 54925, 54912
31630, 51876, 51880, 51972, 51968, 19267, 19268, 19291, 19290, 54624, 54926, 54927, 54913, 0, 0, 0, 
0, 54612, 54625, 54928, 54915
31631, 9971, 9972, 9995, 9994, 51877, 51881, 51973, 51969, 0, 0, 0, 0, 54628, 54930, 54931, 
54917, 54613, 54626, 54929, 54916
31632, 51877, 51881, 51973, 51969, 51878, 51882, 51974, 51970, 54628, 54930, 54931, 54917, 54631, 54933, 54934, 
54920, 54616, 54629, 54932, 54919
31633, 51878, 51882, 51974, 51970, 51879, 51883, 51975, 51971, 54631, 54933, 54934, 54920, 54634, 54936, 54937, 
54923, 54619, 54632, 54935, 54922
31634, 51879, 51883, 51975, 51971, 51880, 51884, 51976, 51972, 54634, 54936, 54937, 54923, 54637, 54939, 54940, 
54926, 54622, 54635, 54938, 54925
31635, 51880, 51884, 51976, 51972, 19268, 19269, 19292, 19291, 54637, 54939, 54940, 54926, 0, 0, 0, 
0, 54625, 54638, 54941, 54928
31636, 9972, 9973, 9996, 9995, 51881, 51885, 51977, 51973, 0, 0, 0, 0, 54641, 54943, 54944, 
54930, 54626, 54639, 54942, 54929
31637, 51881, 51885, 51977, 51973, 51882, 51886, 51978, 51974, 54641, 54943, 54944, 54930, 54644, 54946, 54947, 
54933, 54629, 54642, 54945, 54932
31638, 51882, 51886, 51978, 51974, 51883, 51887, 51979, 51975, 54644, 54946, 54947, 54933, 54647, 54949, 54950, 
54936, 54632, 54645, 54948, 54935
31639, 51883, 51887, 51979, 51975, 51884, 51888, 51980, 51976, 54647, 54949, 54950, 54936, 54650, 54952, 54953, 
54939, 54635, 54648, 54951, 54938
31640, 51884, 51888, 51980, 51976, 19269, 19270, 19293, 19292, 54650, 54952, 54953, 54939, 0, 0, 0, 
0, 54638, 54651, 54954, 54941
31641, 9973, 9974, 9997, 9996, 51885, 51889, 51981, 51977, 0, 0, 0, 0, 54654, 54956, 54957, 
54943, 54639, 54652, 54955, 54942
31642, 51885, 51889, 51981, 51977, 51886, 51890, 51982, 51978, 54654, 54956, 54957, 54943, 54657, 54959, 54960, 
54946, 54642, 54655, 54958, 54945
31643, 51886, 51890, 51982, 51978, 51887, 51891, 51983, 51979, 54657, 54959, 54960, 54946, 54660, 54962, 54963, 
54949, 54645, 54658, 54961, 54948
31644, 51887, 51891, 51983, 51979, 51888, 51892, 51984, 51980, 54660, 54962, 54963, 54949, 54663, 54965, 54966, 
54952, 54648, 54661, 54964, 54951
31645, 51888, 51892, 51984, 51980, 19270, 19271, 19294, 19293, 54663, 54965, 54966, 54952, 0, 0, 0, 
0, 54651, 54664, 54967, 54954
31646, 9974, 9975, 9998, 9997, 51889, 51893, 51985, 51981, 0, 0, 0, 0, 54667, 54969, 54970, 
54956, 54652, 54665, 54968, 54955
31647, 51889, 51893, 51985, 51981, 51890, 51894, 51986, 51982, 54667, 54969, 54970, 54956, 54670, 54972, 54973, 
54959, 54655, 54668, 54971, 54958
31648, 51890, 51894, 51986, 51982, 51891, 51895, 51987, 51983, 54670, 54972, 54973, 54959, 54673, 54975, 54976, 
54962, 54658, 54671, 54974, 54961
31649, 51891, 51895, 51987, 51983, 51892, 51896, 51988, 51984, 54673, 54975, 54976, 54962, 54676, 54978, 54979, 
54965, 54661, 54674, 54977, 54964
31650, 51892, 51896, 51988, 51984, 19271, 19272, 19295, 19294, 54676, 54978, 54979, 54965, 0, 0, 0, 
0, 54664, 54677, 54980, 54967
31651, 9975, 9976, 9999, 9998, 51893, 51897, 51989, 51985, 0, 0, 0, 0, 54680, 54982, 54983, 
54969, 54665, 54678, 54981, 54968
31652, 51893, 51897, 51989, 51985, 51894, 51898, 51990, 51986, 54680, 54982, 54983, 54969, 54683, 54985, 54986, 
54972, 54668, 54681, 54984, 54971
31653, 51894, 51898, 51990, 51986, 51895, 51899, 51991, 51987, 54683, 54985, 54986, 54972, 54686, 54988, 54989, 
54975, 54671, 54684, 54987, 54974
31654, 51895, 51899, 51991, 51987, 51896, 51900, 51992, 51988, 54686, 54988, 54989, 54975, 54689, 54991, 54992, 
54978, 54674, 54687, 54990, 54977
31655, 51896, 51900, 51992, 51988, 19272, 19273, 19296, 19295, 54689, 54991, 54992, 54978, 0, 0, 0, 
0, 54677, 54690, 54993, 54980
31656, 9976, 9977, 10000, 9999, 51897, 51901, 51993, 51989, 0, 0, 0, 0, 54693, 54995, 54996, 
54982, 54678, 54691, 54994, 54981
31657, 51897, 51901, 51993, 51989, 51898, 51902, 51994, 51990, 54693, 54995, 54996, 54982, 54696, 54998, 54999, 
54985, 54681, 54694, 54997, 54984
31658, 51898, 51902, 51994, 51990, 51899, 51903, 51995, 51991, 54696, 54998, 54999, 54985, 54699, 55001, 55002, 
54988, 54684, 54697, 55000, 54987
31659, 51899, 51903, 51995, 51991, 51900, 51904, 51996, 51992, 54699, 55001, 55002, 54988, 54702, 55004, 55005, 
54991, 54687, 54700, 55003, 54990
31660, 51900, 51904, 51996, 51992, 19273, 19274, 19297, 19296, 54702, 55004, 55005, 54991, 0, 0, 0, 
0, 54690, 54703, 55006, 54993
31661, 9977, 9978, 10001, 10000, 51901, 51905, 51997, 51993, 0, 0, 0, 0, 54706, 55008, 55009, 
54995, 54691, 54704, 55007, 54994
31662, 51901, 51905, 51997, 51993, 51902, 51906, 51998, 51994, 54706, 55008, 55009, 54995, 54709, 55011, 55012, 
54998, 54694, 54707, 55010, 54997
31663, 51902, 51906, 51998, 51994, 51903, 51907, 51999, 51995, 54709, 55011, 55012, 54998, 54712, 55014, 55015, 
55001, 54697, 54710, 55013, 55000
31664, 51903, 51907, 51999, 51995, 51904, 51908, 52000, 51996, 54712, 55014, 55015, 55001, 54715, 55017, 55018, 
55004, 54700, 54713, 55016, 55003
31665, 51904, 51908, 52000, 51996, 19274, 19275, 19298, 19297, 54715, 55017, 55018, 55004, 0, 0, 0, 
0, 54703, 54716, 55019, 55006
31666, 9978, 9979, 10002, 10001, 51905, 51909, 52001, 51997, 0, 0, 0, 0, 54719, 55021, 55022, 
55008, 54704, 54717, 55020, 55007
31667, 51905, 51909, 52001, 51997, 51906, 51910, 52002, 51998, 54719, 55021, 55022, 55008, 54722, 55024, 55025, 
55011, 54707, 54720, 55023, 55010
31668, 51906, 51910, 52002, 51998, 51907, 51911, 52003, 51999, 54722, 55024, 55025, 55011, 54725, 55027, 55028, 
55014, 54710, 54723, 55026, 55013
31669, 51907, 51911, 52003, 51999, 51908, 51912, 52004, 52000, 54725, 55027, 55028, 55014, 54728, 55030, 55031, 
55017, 54713, 54726, 55029, 55016
31670, 51908, 51912, 52004, 52000, 19275, 19276, 19299, 19298, 54728, 55030, 55031, 55017, 0, 0, 0, 
0, 54716, 54729, 55032, 55019
31671, 9979, 9980, 10003, 10002, 51909, 51913, 52005, 52001, 0, 0, 0, 0, 54732, 55034, 55035, 
55021, 54717, 54730, 55033, 55020
31672, 51909, 51913, 52005, 52001, 51910, 51914, 52006, 52002, 54732, 55034, 55035, 55021, 54735, 55037, 55038, 
55024, 54720, 54733, 55036, 55023
31673, 51910, 51914, 52006, 52002, 51911, 51915, 52007, 52003, 54735, 55037, 55038, 55024, 54738, 55040, 55041, 
55027, 54723, 54736, 55039, 55026
31674, 51911, 51915, 52007, 52003, 51912, 51916, 52008, 52004, 54738, 55040, 55041, 55027, 54741, 55043, 55044, 
55030, 54726, 54739, 55042, 55029
31675, 51912, 51916, 52008, 52004, 19276, 19277, 19300, 19299, 54741, 55043, 55044, 55030, 0, 0, 0, 
0, 54729, 54742, 55045, 55032
31676, 9980, 9981, 10004, 10003, 51913, 51917, 52009, 52005, 0, 0, 0, 0, 54745, 55047, 55048, 
55034, 54730, 54743, 55046, 55033
31677, 51913, 51917, 52009, 52005, 51914, 51918, 52010, 52006, 54745, 55047, 55048, 55034, 54748, 55050, 55051, 
55037, 54733, 54746, 55049, 55036
31678, 51914, 51918, 52010, 52006, 51915, 51919, 52011, 52007, 54748, 55050, 55051, 55037, 54751, 55053, 55054, 
55040, 54736, 54749, 55052, 55039
31679, 51915, 51919, 52011, 52007, 51916, 51920, 52012, 52008, 54751, 55053, 55054, 55040, 54754, 55056, 55057, 
55043, 54739, 54752, 55055, 55042
31680, 51916, 51920, 52012, 52008, 19277, 19278, 19301, 19300, 54754, 55056, 55057, 55043, 0, 0, 0, 
0, 54742, 54755, 55058, 55045
31681, 9981, 9982, 10005, 10004, 51917, 51921, 52013, 52009, 0, 0, 0, 0, 54758, 55060, 55061, 
55047, 54743, 54756, 55059, 55046
31682, 51917, 51921, 52013, 52009, 51918, 51922, 52014, 52010, 54758, 55060, 55061, 55047, 54761, 55063, 55064, 
55050, 54746, 54759, 55062, 55049
31683, 51918, 51922, 52014, 52010, 51919, 51923, 52015, 52011, 54761, 55063, 55064, 55050, 54764, 55066, 55067, 
55053, 54749, 54762, 55065, 55052
31684, 51919, 51923, 52015, 52011, 51920, 51924, 52016, 52012, 54764, 55066, 55067, 55053, 54767, 55069, 55070, 
55056, 54752, 54765, 55068, 55055
31685, 51920, 51924, 52016, 52012, 19278, 19279, 19302, 19301, 54767, 55069, 55070, 55056, 0, 0, 0, 
0, 54755, 54768, 55071, 55058
31686, 9982, 9983, 10006, 10005, 51921, 51925, 52017, 52013, 0, 0, 0, 0, 54771, 55073, 55074, 
55060, 54756, 54769, 55072, 55059
31687, 51921, 51925, 52017, 52013, 51922, 51926, 52018, 52014, 54771, 55073, 55074, 55060, 54774, 55076, 55077, 
55063, 54759, 54772, 55075, 55062
31688, 51922, 51926, 52018, 52014, 51923, 51927, 52019, 52015, 54774, 55076, 55077, 55063, 54777, 55079, 55080, 
55066, 54762, 54775, 55078, 55065
31689, 51923, 51927, 52019, 52015, 51924, 51928, 52020, 52016, 54777, 55079, 55080, 55066, 54780, 55082, 55083, 
55069, 54765, 54778, 55081, 55068
31690, 51924, 51928, 52020, 52016, 19279, 19280, 19303, 19302, 54780, 55082, 55083, 55069, 0, 0, 0, 
0, 54768, 54781, 55084, 55071
31691, 9983, 9984, 10007, 10006, 51925, 51929, 52021, 52017, 0, 0, 0, 0, 54784, 55086, 55087, 
55073, 54769, 54782, 55085, 55072
31692, 51925, 51929, 52021, 52017, 51926, 51930, 52022, 52018, 54784, 55086, 55087, 55073, 54787, 55089, 55090, 
55076, 54772, 54785, 55088, 55075
31693, 51926, 51930, 52022, 52018, 51927, 51931, 52023, 52019, 54787, 55089, 55090, 55076, 54790, 55092, 55093, 
55079, 54775, 54788, 55091, 55078
31694, 51927, 51931, 52023, 52019, 51928, 51932, 52024, 52020, 54790, 55092, 55093, 55079, 54793, 55095, 55096, 
55082, 54778, 54791, 55094, 55081
31695, 51928, 51932, 52024, 52020, 19280, 19281, 19304, 19303, 54793, 55095, 55096, 55082, 0, 0, 0, 
0, 54781, 54794, 55097, 55084
31696, 9984, 9985, 10008, 10007, 51929, 51933, 52025, 52021, 0, 0, 0, 0, 54797, 55099, 55100, 
55086, 54782, 54795, 55098, 55085
31697, 51929, 51933, 52025, 52021, 51930, 51934, 52026, 52022, 54797, 55099, 55100, 55086, 54800, 55102, 55103, 
55089, 54785, 54798, 55101, 55088
31698, 51930, 51934, 52026, 52022, 51931, 51935, 52027, 52023, 54800, 55102, 55103, 55089, 54803, 55105, 55106, 
55092, 54788, 54801, 55104, 55091
31699, 51931, 51935, 52027, 52023, 51932, 51936, 52028, 52024, 54803, 55105, 55106, 55092, 54806, 55108, 55109, 
55095, 54791, 54804, 55107, 55094
31700, 51932, 51936, 52028, 52024, 19281, 19282, 19305, 19304, 54806, 55108, 55109, 55095, 0, 0, 0, 
0, 54794, 54807, 55110, 55097
31701, 9985, 9986, 10009, 10008, 51933, 51937, 52029, 52025, 0, 0, 0, 0, 54810, 55112, 55113, 
55099, 54795, 54808, 55111, 55098
31702, 51933, 51937, 52029, 52025, 51934, 51938, 52030, 52026, 54810, 55112, 55113, 55099, 54813, 55115, 55116, 
55102, 54798, 54811, 55114, 55101
31703, 51934, 51938, 52030, 52026, 51935, 51939, 52031, 52027, 54813, 55115, 55116, 55102, 54816, 55118, 55119, 
55105, 54801, 54814, 55117, 55104
31704, 51935, 51939, 52031, 52027, 51936, 51940, 52032, 52028, 54816, 55118, 55119, 55105, 54819, 55121, 55122, 
55108, 54804, 54817, 55120, 55107
31705, 51936, 51940, 52032, 52028, 19282, 19283, 19306, 19305, 54819, 55121, 55122, 55108, 0, 0, 0, 
0, 54807, 54820, 55123, 55110
31706, 9986, 9987, 10010, 10009, 51937, 51941, 52033, 52029, 0, 0, 0, 0, 54823, 55125, 55126, 
55112, 54808, 54821, 55124, 55111
31707, 51937, 51941, 52033, 52029, 51938, 51942, 52034, 52030, 54823, 55125, 55126, 55112, 54826, 55128, 55129, 
55115, 54811, 54824, 55127, 55114
31708, 51938, 51942, 52034, 52030, 51939, 51943, 52035, 52031, 54826, 55128, 55129, 55115, 54829, 55131, 55132, 
55118, 54814, 54827, 55130, 55117
31709, 51939, 51943, 52035, 52031, 51940, 51944, 52036, 52032, 54829, 55131, 55132, 55118, 54832, 55134, 55135, 
55121, 54817, 54830, 55133, 55120
31710, 51940, 51944, 52036, 52032, 19283, 19284, 19307, 19306, 54832, 55134, 55135, 55121, 0, 0, 0, 
0, 54820, 54833, 55136, 55123
31711, 9987, 9988, 10011, 10010, 51941, 51945, 52037, 52033, 0, 0, 0, 0, 54836, 55138, 55139, 
55125, 54821, 54834, 55137, 55124
31712, 51941, 51945, 52037, 52033, 51942, 51946, 52038, 52034, 54836, 55138, 55139, 55125, 54839, 55141, 55142, 
55128, 54824, 54837, 55140, 55127
31713, 51942, 51946, 52038, 52034, 51943, 51947, 52039, 52035, 54839, 55141, 55142, 55128, 54842, 55144, 55145, 
55131, 54827, 54840, 55143, 55130
31714, 51943, 51947, 52039, 52035, 51944, 51948, 52040, 52036, 54842, 55144, 55145, 55131, 54845, 55147, 55148, 
55134, 54830, 54843, 55146, 55133
31715, 51944, 51948, 52040, 52036, 19284, 19285, 19308, 19307, 54845, 55147, 55148, 55134, 0, 0, 0, 
0, 54833, 54846, 55149, 55136
31716, 9988, 9989, 10012, 10011, 51945, 51949, 52041, 52037, 0, 0, 0, 0, 54849, 55151, 55152, 
55138, 54834, 54847, 55150, 55137
31717, 51945, 51949, 52041, 52037, 51946, 51950, 52042, 52038, 54849, 55151, 55152, 55138, 54852, 55154, 55155, 
55141, 54837, 54850, 55153, 55140
31718, 51946, 51950, 52042, 52038, 51947, 51951, 52043, 52039, 54852, 55154, 55155, 55141, 54855, 55157, 55158, 
55144, 54840, 54853, 55156, 55143
31719, 51947, 51951, 52043, 52039, 51948, 51952, 52044, 52040, 54855, 55157, 55158, 55144, 54858, 55160, 55161, 
55147, 54843, 54856, 55159, 55146
31720, 51948, 51952, 52044, 52040, 19285, 19286, 19309, 19308, 54858, 55160, 55161, 55147, 0, 0, 0, 
0, 54846, 54859, 55162, 55149
31721, 9989, 1199, 1200, 10012, 51949, 18965, 18969, 52041, 0, 0, 0, 0, 54860, 19059, 55163, 
55151, 54847, 19049, 19058, 55150
31722, 51949, 18965, 18969, 52041, 51950, 18966, 18970, 52042, 54860, 19059, 55163, 55151, 54861, 19061, 55164, 
55154, 54850, 19051, 19060, 55153
31723, 51950, 18966, 18970, 52042, 51951, 18967, 18971, 52043, 54861, 19061, 55164, 55154, 54862, 19063, 55165, 
55157, 54853, 19053, 19062, 55156
31724, 51951, 18967, 18971, 52043, 51952, 18968, 18972, 52044, 54862, 19063, 55165, 55157, 54863, 19065, 55166, 
55160, 54856, 19055, 19064, 55159
31725, 51952, 18968, 18972, 52044, 19286, 2381, 2382, 19309, 54863, 19065, 55166, 55160, 0, 0, 0, 
0, 54859, 19057, 19066, 55162
31726, 1189, 9990, 10013, 1190, 18822, 51953, 52045, 18826, 0, 0, 0, 0, 54866, 55168, 55169, 
18920, 18912, 54864, 55167, 18921
31727, 18822, 51953, 52045, 18826, 18823, 51954, 52046, 18827, 54866, 55168, 55169, 18920, 54869, 55171, 55172, 
18922, 18914, 54867, 55170, 18923
31728, 18823, 51954, 52046, 18827, 18824, 51955, 52047, 18828, 54869, 55171, 55172, 18922, 54872, 55174, 55175, 
18924, 18916, 54870, 55173, 18925
31729, 18824, 51955, 52047, 18828, 18825, 51956, 52048, 18829, 54872, 55174, 55175, 18924, 54875, 55177, 55178, 
18926, 18918, 54873, 55176, 18927
31730, 18825, 51956, 52048, 18829, 2371, 19287, 19310, 2372, 54875, 55177, 55178, 18926, 0, 0, 0, 
0, 18919, 54876, 55179, 18928
31731, 9990, 9991, 10014, 10013, 51953, 51957, 52049, 52045, 0, 0, 0, 0, 54879, 55181, 55182, 
55168, 54864, 54877, 55180, 55167
31732, 51953, 51957, 52049, 52045, 51954, 51958, 52050, 52046, 54879, 55181, 55182, 55168, 54882, 55184, 55185, 
55171, 54867, 54880, 55183, 55170
31733, 51954, 51958, 52050, 52046, 51955, 51959, 52051, 52047, 54882, 55184, 55185, 55171, 54885, 55187, 55188, 
55174, 54870, 54883, 55186, 55173
31734, 51955, 51959, 52051, 52047, 51956, 51960, 52052, 52048, 54885, 55187, 55188, 55174, 54888, 55190, 55191, 
55177, 54873, 54886, 55189, 55176
31735, 51956, 51960, 52052, 52048, 19287, 19288, 19311, 19310, 54888, 55190, 55191, 55177, 0, 0, 0, 
0, 54876, 54889, 55192, 55179
31736, 9991, 9992, 10015, 10014, 51957, 51961, 52053, 52049, 0, 0, 0, 0, 54892, 55194, 55195, 
55181, 54877, 54890, 55193, 55180
31737, 51957, 51961, 52053, 52049, 51958, 51962, 52054, 52050, 54892, 55194, 55195, 55181, 54895, 55197, 55198, 
55184, 54880, 54893, 55196, 55183
31738, 51958, 51962, 52054, 52050, 51959, 51963, 52055, 52051, 54895, 55197, 55198, 55184, 54898, 55200, 55201, 
55187, 54883, 54896, 55199, 55186
31739, 51959, 51963, 52055, 52051, 51960, 51964, 52056, 52052, 54898, 55200, 55201, 55187, 54901, 55203, 55204, 
55190, 54886, 54899, 55202, 55189
31740, 51960, 51964, 52056, 52052, 19288, 19289, 19312, 19311, 54901, 55203, 55204, 55190, 0, 0, 0, 
0, 54889, 54902, 55205, 55192
31741, 9992, 9993, 10016, 10015, 51961, 51965, 52057, 52053, 0, 0, 0, 0, 54905, 55207, 55208, 
55194, 54890, 54903, 55206, 55193
31742, 51961, 51965, 52057, 52053, 51962, 51966, 52058, 52054, 54905, 55207, 55208, 55194, 54908, 55210, 55211, 
55197, 54893, 54906, 55209, 55196
31743, 51962, 51966, 52058, 52054, 51963, 51967, 52059, 52055, 54908, 55210, 55211, 55197, 54911, 55213, 55214, 
55200, 54896, 54909, 55212, 55199
31744, 51963, 51967, 52059, 52055, 51964, 51968, 52060, 52056, 54911, 55213, 55214, 55200, 54914, 55216, 55217, 
55203, 54899, 54912, 55215, 55202
31745, 51964, 51968, 52060, 52056, 19289, 19290, 19313, 19312, 54914, 55216, 55217, 55203, 0, 0, 0, 
0, 54902, 54915, 55218, 55205
31746, 9993, 9994, 10017, 10016, 51965, 51969, 52061, 52057, 0, 0, 0, 0, 54918, 55220, 55221, 
55207, 54903, 54916, 55219, 55206
31747, 51965, 51969, 52061, 52057, 51966, 51970, 52062, 52058, 54918, 55220, 55221, 55207, 54921, 55223, 55224, 
55210, 54906, 54919, 55222, 55209
31748, 51966, 51970, 52062, 52058, 51967, 51971, 52063, 52059, 54921, 55223, 55224, 55210, 54924, 55226, 55227, 
55213, 54909, 54922, 55225, 55212
31749, 51967, 51971, 52063, 52059, 51968, 51972, 52064, 52060, 54924, 55226, 55227, 55213, 54927, 55229, 55230, 
55216, 54912, 54925, 55228, 55215
31750, 51968, 51972, 52064, 52060, 19290, 19291, 19314, 19313, 54927, 55229, 55230, 55216, 0, 0, 0, 
0, 54915, 54928, 55231, 55218
31751, 9994, 9995, 10018, 10017, 51969, 51973, 52065, 52061, 0, 0, 0, 0, 54931, 55233, 55234, 
55220, 54916, 54929, 55232, 55219
31752, 51969, 51973, 52065, 52061, 51970, 51974, 52066, 52062, 54931, 55233, 55234, 55220, 54934, 55236, 55237, 
55223, 54919, 54932, 55235, 55222
31753, 51970, 51974, 52066, 52062, 51971, 51975, 52067, 52063, 54934, 55236, 55237, 55223, 54937, 55239, 55240, 
55226, 54922, 54935, 55238, 55225
31754, 51971, 51975, 52067, 52063, 51972, 51976, 52068, 52064, 54937, 55239, 55240, 55226, 54940, 55242, 55243, 
55229, 54925, 54938, 55241, 55228
31755, 51972, 51976, 52068, 52064, 19291, 19292, 19315, 19314, 54940, 55242, 55243, 55229, 0, 0, 0, 
0, 54928, 54941, 55244, 55231
31756, 9995, 9996, 10019, 10018, 51973, 51977, 52069, 52065, 0, 0, 0, 0, 54944, 55246, 55247, 
55233, 54929, 54942, 55245, 55232
31757, 51973, 51977, 52069, 52065, 51974, 51978, 52070, 52066, 54944, 55246, 55247, 55233, 54947, 55249, 55250, 
55236, 54932, 54945, 55248, 55235
31758, 51974, 51978, 52070, 52066, 51975, 51979, 52071, 52067, 54947, 55249, 55250, 55236, 54950, 55252, 55253, 
55239, 54935, 54948, 55251, 55238
31759, 51975, 51979, 52071, 52067, 51976, 51980, 52072, 52068, 54950, 55252, 55253, 55239, 54953, 55255, 55256, 
55242, 54938, 54951, 55254, 55241
31760, 51976, 51980, 52072, 52068, 19292, 19293, 19316, 19315, 54953, 55255, 55256, 55242, 0, 0, 0, 
0, 54941, 54954, 55257, 55244
31761, 9996, 9997, 10020, 10019, 51977, 51981, 52073, 52069, 0, 0, 0, 0, 54957, 55259, 55260, 
55246, 54942, 54955, 55258, 55245
31762, 51977, 51981, 52073, 52069, 51978, 51982, 52074, 52070, 54957, 55259, 55260, 55246, 54960, 55262, 55263, 
55249, 54945, 54958, 55261, 55248
31763, 51978, 51982, 52074, 52070, 51979, 51983, 52075, 52071, 54960, 55262, 55263, 55249, 54963, 55265, 55266, 
55252, 54948, 54961, 55264, 55251
31764, 51979, 51983, 52075, 52071, 51980, 51984, 52076, 52072, 54963, 55265, 55266, 55252, 54966, 55268, 55269, 
55255, 54951, 54964, 55267, 55254
31765, 51980, 51984, 52076, 52072, 19293, 19294, 19317, 19316, 54966, 55268, 55269, 55255, 0, 0, 0, 
0, 54954, 54967, 55270, 55257
31766, 9997, 9998, 10021, 10020, 51981, 51985, 52077, 52073, 0, 0, 0, 0, 54970, 55272, 55273, 
55259, 54955, 54968, 55271, 55258
31767, 51981, 51985, 52077, 52073, 51982, 51986, 52078, 52074, 54970, 55272, 55273, 55259, 54973, 55275, 55276, 
55262, 54958, 54971, 55274, 55261
31768, 51982, 51986, 52078, 52074, 51983, 51987, 52079, 52075, 54973, 55275, 55276, 55262, 54976, 55278, 55279, 
55265, 54961, 54974, 55277, 55264
31769, 51983, 51987, 52079, 52075, 51984, 51988, 52080, 52076, 54976, 55278, 55279, 55265, 54979, 55281, 55282, 
55268, 54964, 54977, 55280, 55267
31770, 51984, 51988, 52080, 52076, 19294, 19295, 19318, 19317, 54979, 55281, 55282, 55268, 0, 0, 0, 
0, 54967, 54980, 55283, 55270
31771, 9998, 9999, 10022, 10021, 51985, 51989, 52081, 52077, 0, 0, 0, 0, 54983, 55285, 55286, 
55272, 54968, 54981, 55284, 55271
31772, 51985, 51989, 52081, 52077, 51986, 51990, 52082, 52078, 54983, 55285, 55286, 55272, 54986, 55288, 55289, 
55275, 54971, 54984, 55287, 55274
31773, 51986, 51990, 52082, 52078, 51987, 51991, 52083, 52079, 54986, 55288, 55289, 55275, 54989, 55291, 55292, 
55278, 54974, 54987, 55290, 55277
31774, 51987, 51991, 52083, 52079, 51988, 51992, 52084, 52080, 54989, 55291, 55292, 55278, 54992, 55294, 55295, 
55281, 54977, 54990, 55293, 55280
31775, 51988, 51992, 52084, 52080, 19295, 19296, 19319, 19318, 54992, 55294, 55295, 55281, 0, 0, 0, 
0, 54980, 54993, 55296, 55283
31776, 9999, 10000, 10023, 10022, 51989, 51993, 52085, 52081, 0, 0, 0, 0, 54996, 55298, 55299, 
55285, 54981, 54994, 55297, 55284
31777, 51989, 51993, 52085, 52081, 51990, 51994, 52086, 52082, 54996, 55298, 55299, 55285, 54999, 55301, 55302, 
55288, 54984, 54997, 55300, 55287
31778, 51990, 51994, 52086, 52082, 51991, 51995, 52087, 52083, 54999, 55301, 55302, 55288, 55002, 55304, 55305, 
55291, 54987, 55000, 55303, 55290
31779, 51991, 51995, 52087, 52083, 51992, 51996, 52088, 52084, 55002, 55304, 55305, 55291, 55005, 55307, 55308, 
55294, 54990, 55003, 55306, 55293
31780, 51992, 51996, 52088, 52084, 19296, 19297, 19320, 19319, 55005, 55307, 55308, 55294, 0, 0, 0, 
0, 54993, 55006, 55309, 55296
31781, 10000, 10001, 10024, 10023, 51993, 51997, 52089, 52085, 0, 0, 0, 0, 55009, 55311, 55312, 
55298, 54994, 55007, 55310, 55297
31782, 51993, 51997, 52089, 52085, 51994, 51998, 52090, 52086, 55009, 55311, 55312, 55298, 55012, 55314, 55315, 
55301, 54997, 55010, 55313, 55300
31783, 51994, 51998, 52090, 52086, 51995, 51999, 52091, 52087, 55012, 55314, 55315, 55301, 55015, 55317, 55318, 
55304, 55000, 55013, 55316, 55303
31784, 51995, 51999, 52091, 52087, 51996, 52000, 52092, 52088, 55015, 55317, 55318, 55304, 55018, 55320, 55321, 
55307, 55003, 55016, 55319, 55306
31785, 51996, 52000, 52092, 52088, 19297, 19298, 19321, 19320, 55018, 55320, 55321, 55307, 0, 0, 0, 
0, 55006, 55019, 55322, 55309
31786, 10001, 10002, 10025, 10024, 51997, 52001, 52093, 52089, 0, 0, 0, 0, 55022, 55324, 55325, 
55311, 55007, 55020, 55323, 55310
31787, 51997, 52001, 52093, 52089, 51998, 52002, 52094, 52090, 55022, 55324, 55325, 55311, 55025, 55327, 55328, 
55314, 55010, 55023, 55326, 55313
31788, 51998, 52002, 52094, 52090, 51999, 52003, 52095, 52091, 55025, 55327, 55328, 55314, 55028, 55330, 55331, 
55317, 55013, 55026, 55329, 55316
31789, 51999, 52003, 52095, 52091, 52000, 52004, 52096, 52092, 55028, 55330, 55331, 55317, 55031, 55333, 55334, 
55320, 55016, 55029, 55332, 55319
31790, 52000, 52004, 52096, 52092, 19298, 19299, 19322, 19321, 55031, 55333, 55334, 55320, 0, 0, 0, 
0, 55019, 55032, 55335, 55322
31791, 10002, 10003, 10026, 10025, 52001, 52005, 52097, 52093, 0, 0, 0, 0, 55035, 55337, 55338, 
55324, 55020, 55033, 55336, 55323
31792, 52001, 52005, 52097, 52093, 52002, 52006, 52098, 52094, 55035, 55337, 55338, 55324, 55038, 55340, 55341, 
55327, 55023, 55036, 55339, 55326
31793, 52002, 52006, 52098, 52094, 52003, 52007, 52099, 52095, 55038, 55340, 55341, 55327, 55041, 55343, 55344, 
55330, 55026, 55039, 55342, 55329
31794, 52003, 52007, 52099, 52095, 52004, 52008, 52100, 52096, 55041, 55343, 55344, 55330, 55044, 55346, 55347, 
55333, 55029, 55042, 55345, 55332
31795, 52004, 52008, 52100, 52096, 19299, 19300, 19323, 19322, 55044, 55346, 55347, 55333, 0, 0, 0, 
0, 55032, 55045, 55348, 55335
31796, 10003, 10004, 10027, 10026, 52005, 52009, 52101, 52097, 0, 0, 0, 0, 55048, 55350, 55351, 
55337, 55033, 55046, 55349, 55336
31797, 52005, 52009, 52101, 52097, 52006, 52010, 52102, 52098, 55048, 55350, 55351, 55337, 55051, 55353, 55354, 
55340, 55036, 55049, 55352, 55339
31798, 52006, 52010, 52102, 52098, 52007, 52011, 52103, 52099, 55051, 55353, 55354, 55340, 55054, 55356, 55357, 
55343, 55039, 55052, 55355, 55342
31799, 52007, 52011, 52103, 52099, 52008, 52012, 52104, 52100, 55054, 55356, 55357, 55343, 55057, 55359, 55360, 
55346, 55042, 55055, 55358, 55345
31800, 52008, 52012, 52104, 52100, 19300, 19301, 19324, 19323, 55057, 55359, 55360, 55346, 0, 0, 0, 
0, 55045, 55058, 55361, 55348
31801, 10004, 10005, 10028, 10027, 52009, 52013, 52105, 52101, 0, 0, 0, 0, 55061, 55363, 55364, 
55350, 55046, 55059, 55362, 55349
31802, 52009, 52013, 52105, 52101, 52010, 52014, 52106, 52102, 55061, 55363, 55364, 55350, 55064, 55366, 55367, 
55353, 55049, 55062, 55365, 55352
31803, 52010, 52014, 52106, 52102, 52011, 52015, 52107, 52103, 55064, 55366, 55367, 55353, 55067, 55369, 55370, 
55356, 55052, 55065, 55368, 55355
31804, 52011, 52015, 52107, 52103, 52012, 52016, 52108, 52104, 55067, 55369, 55370, 55356, 55070, 55372, 55373, 
55359, 55055, 55068, 55371, 55358
31805, 52012, 52016, 52108, 52104, 19301, 19302, 19325, 19324, 55070, 55372, 55373, 55359, 0, 0, 0, 
0, 55058, 55071, 55374, 55361
31806, 10005, 10006, 10029, 10028, 52013, 52017, 52109, 52105, 0, 0, 0, 0, 55074, 55376, 55377, 
55363, 55059, 55072, 55375, 55362
31807, 52013, 52017, 52109, 52105, 52014, 52018, 52110, 52106, 55074, 55376, 55377, 55363, 55077, 55379, 55380, 
55366, 55062, 55075, 55378, 55365
31808, 52014, 52018, 52110, 52106, 52015, 52019, 52111, 52107, 55077, 55379, 55380, 55366, 55080, 55382, 55383, 
55369, 55065, 55078, 55381, 55368
31809, 52015, 52019, 52111, 52107, 52016, 52020, 52112, 52108, 55080, 55382, 55383, 55369, 55083, 55385, 55386, 
55372, 55068, 55081, 55384, 55371
31810, 52016, 52020, 52112, 52108, 19302, 19303, 19326, 19325, 55083, 55385, 55386, 55372, 0, 0, 0, 
0, 55071, 55084, 55387, 55374
31811, 10006, 10007, 10030, 10029, 52017, 52021, 52113, 52109, 0, 0, 0, 0, 55087, 55389, 55390, 
55376, 55072, 55085, 55388, 55375
31812, 52017, 52021, 52113, 52109, 52018, 52022, 52114, 52110, 55087, 55389, 55390, 55376, 55090, 55392, 55393, 
55379, 55075, 55088, 55391, 55378
31813, 52018, 52022, 52114, 52110, 52019, 52023, 52115, 52111, 55090, 55392, 55393, 55379, 55093, 55395, 55396, 
55382, 55078, 55091, 55394, 55381
31814, 52019, 52023, 52115, 52111, 52020, 52024, 52116, 52112, 55093, 55395, 55396, 55382, 55096, 55398, 55399, 
55385, 55081, 55094, 55397, 55384
31815, 52020, 52024, 52116, 52112, 19303, 19304, 19327, 19326, 55096, 55398, 55399, 55385, 0, 0, 0, 
0, 55084, 55097, 55400, 55387
31816, 10007, 10008, 10031, 10030, 52021, 52025, 52117, 52113, 0, 0, 0, 0, 55100, 55402, 55403, 
55389, 55085, 55098, 55401, 55388
31817, 52021, 52025, 52117, 52113, 52022, 52026, 52118, 52114, 55100, 55402, 55403, 55389, 55103, 55405, 55406, 
55392, 55088, 55101, 55404, 55391
31818, 52022, 52026, 52118, 52114, 52023, 52027, 52119, 52115, 55103, 55405, 55406, 55392, 55106, 55408, 55409, 
55395, 55091, 55104, 55407, 55394
31819, 52023, 52027, 52119, 52115, 52024, 52028, 52120, 52116, 55106, 55408, 55409, 55395, 55109, 55411, 55412, 
55398, 55094, 55107, 55410, 55397
31820, 52024, 52028, 52120, 52116, 19304, 19305, 19328, 19327, 55109, 55411, 55412, 55398, 0, 0, 0, 
0, 55097, 55110, 55413, 55400
31821, 10008, 10009, 10032, 10031, 52025, 52029, 52121, 52117, 0, 0, 0, 0, 55113, 55415, 55416, 
55402, 55098, 55111, 55414, 55401
31822, 52025, 52029, 52121, 52117, 52026, 52030, 52122, 52118, 55113, 55415, 55416, 55402, 55116, 55418, 55419, 
55405, 55101, 55114, 55417, 55404
31823, 52026, 52030, 52122, 52118, 52027, 52031, 52123, 52119, 55116, 55418, 55419, 55405, 55119, 55421, 55422, 
55408, 55104, 55117, 55420, 55407
31824, 52027, 52031, 52123, 52119, 52028, 52032, 52124, 52120, 55119, 55421, 55422, 55408, 55122, 55424, 55425, 
55411, 55107, 55120, 55423, 55410
31825, 52028, 52032, 52124, 52120, 19305, 19306, 19329, 19328, 55122, 55424, 55425, 55411, 0, 0, 0, 
0, 55110, 55123, 55426, 55413
31826, 10009, 10010, 10033, 10032, 52029, 52033, 52125, 52121, 0, 0, 0, 0, 55126, 55428, 55429, 
55415, 55111, 55124, 55427, 55414
31827, 52029, 52033, 52125, 52121, 52030, 52034, 52126, 52122, 55126, 55428, 55429, 55415, 55129, 55431, 55432, 
55418, 55114, 55127, 55430, 55417
31828, 52030, 52034, 52126, 52122, 52031, 52035, 52127, 52123, 55129, 55431, 55432, 55418, 55132, 55434, 55435, 
55421, 55117, 55130, 55433, 55420
31829, 52031, 52035, 52127, 52123, 52032, 52036, 52128, 52124, 55132, 55434, 55435, 55421, 55135, 55437, 55438, 
55424, 55120, 55133, 55436, 55423
31830, 52032, 52036, 52128, 52124, 19306, 19307, 19330, 19329, 55135, 55437, 55438, 55424, 0, 0, 0, 
0, 55123, 55136, 55439, 55426
31831, 10010, 10011, 10034, 10033, 52033, 52037, 52129, 52125, 0, 0, 0, 0, 55139, 55441, 55442, 
55428, 55124, 55137, 55440, 55427
31832, 52033, 52037, 52129, 52125, 52034, 52038, 52130, 52126, 55139, 55441, 55442, 55428, 55142, 55444, 55445, 
55431, 55127, 55140, 55443, 55430
31833, 52034, 52038, 52130, 52126, 52035, 52039, 52131, 52127, 55142, 55444, 55445, 55431, 55145, 55447, 55448, 
55434, 55130, 55143, 55446, 55433
31834, 52035, 52039, 52131, 52127, 52036, 52040, 52132, 52128, 55145, 55447, 55448, 55434, 55148, 55450, 55451, 
55437, 55133, 55146, 55449, 55436
31835, 52036, 52040, 52132, 52128, 19307, 19308, 19331, 19330, 55148, 55450, 55451, 55437, 0, 0, 0, 
0, 55136, 55149, 55452, 55439
31836, 10011, 10012, 10035, 10034, 52037, 52041, 52133, 52129, 0, 0, 0, 0, 55152, 55454, 55455, 
55441, 55137, 55150, 55453, 55440
31837, 52037, 52041, 52133, 52129, 52038, 52042, 52134, 52130, 55152, 55454, 55455, 55441, 55155, 55457, 55458, 
55444, 55140, 55153, 55456, 55443
31838, 52038, 52042, 52134, 52130, 52039, 52043, 52135, 52131, 55155, 55457, 55458, 55444, 55158, 55460, 55461, 
55447, 55143, 55156, 55459, 55446
31839, 52039, 52043, 52135, 52131, 52040, 52044, 52136, 52132, 55158, 55460, 55461, 55447, 55161, 55463, 55464, 
55450, 55146, 55159, 55462, 55449
31840, 52040, 52044, 52136, 52132, 19308, 19309, 19332, 19331, 55161, 55463, 55464, 55450, 0, 0, 0, 
0, 55149, 55162, 55465, 55452
31841, 10012, 1200, 1201, 10035, 52041, 18969, 18973, 52133, 0, 0, 0, 0, 55163, 19068, 55466, 
55454, 55150, 19058, 19067, 55453
31842, 52041, 18969, 18973, 52133, 52042, 18970, 18974, 52134, 55163, 19068, 55466, 55454, 55164, 19070, 55467, 
55457, 55153, 19060, 19069, 55456
31843, 52042, 18970, 18974, 52134, 52043, 18971, 18975, 52135, 55164, 19070, 55467, 55457, 55165, 19072, 55468, 
55460, 55156, 19062, 19071, 55459
31844, 52043, 18971, 18975, 52135, 52044, 18972, 18976, 52136, 55165, 19072, 55468, 55460, 55166, 19074, 55469, 
55463, 55159, 19064, 19073, 55462
31845, 52044, 18972, 18976, 52136, 19309, 2382, 2383, 19332, 55166, 19074, 55469, 55463, 0, 0, 0, 
0, 55162, 19066, 19075, 55465
31846, 1190, 10013, 1124, 45, 18826, 52045, 18391, 2290, 0, 0, 0, 0, 55169, 55470, 0, 
18929, 18921, 55167, 0, 0
31847, 18826, 52045, 18391, 2290, 18827, 52046, 18392, 2291, 55169, 55470, 0, 18929, 55172, 55471, 0, 
18930, 18923, 55170, 0, 0
31848, 18827, 52046, 18392, 2291, 18828, 52047, 18393, 2292, 55172, 55471, 0, 18930, 55175, 55472, 0, 
18931, 18925, 55173, 0, 0
31849, 18828, 52047, 18393, 2292, 18829, 52048, 18394, 2293, 55175, 55472, 0, 18931, 55178, 55473, 0, 
18932, 18927, 55176, 0, 0
31850, 18829, 52048, 18394, 2293, 2372, 19310, 2298, 91, 55178, 55473, 0, 18932, 0, 0, 0, 
0, 18928, 55179, 0, 0
31851, 10013, 10014, 1125, 1124, 52045, 52049, 18395, 18391, 0, 0, 0, 0, 55182, 55474, 0, 
55470, 55167, 55180, 0, 0
31852, 52045, 52049, 18395, 18391, 52046, 52050, 18396, 18392, 55182, 55474, 0, 55470, 55185, 55475, 0, 
55471, 55170, 55183, 0, 0
31853, 52046, 52050, 18396, 18392, 52047, 52051, 18397, 18393, 55185, 55475, 0, 55471, 55188, 55476, 0, 
55472, 55173, 55186, 0, 0
31854, 52047, 52051, 18397, 18393, 52048, 52052, 18398, 18394, 55188, 55476, 0, 55472, 55191, 55477, 0, 
55473, 55176, 55189, 0, 0
31855, 52048, 52052, 18398, 18394, 19310, 19311, 2299, 2298, 55191, 55477, 0, 55473, 0, 0, 0, 
0, 55179, 55192, 0, 0
31856, 10014, 10015, 1126, 1125, 52049, 52053, 18399, 18395, 0, 0, 0, 0, 55195, 55478, 0, 
55474, 55180, 55193, 0, 0
31857, 52049, 52053, 18399, 18395, 52050, 52054, 18400, 18396, 55195, 55478, 0, 55474, 55198, 55479, 0, 
55475, 55183, 55196, 0, 0
31858, 52050, 52054, 18400, 18396, 52051, 52055, 18401, 18397, 55198, 55479, 0, 55475, 55201, 55480, 0, 
55476, 55186, 55199, 0, 0
31859, 52051, 52055, 18401, 18397, 52052, 52056, 18402, 18398, 55201, 55480, 0, 55476, 55204, 55481, 0, 
55477, 55189, 55202, 0, 0
31860, 52052, 52056, 18402, 18398, 19311, 19312, 2300, 2299, 55204, 55481, 0, 55477, 0, 0, 0, 
0, 55192, 55205, 0, 0
31861, 10015, 10016, 1127, 1126, 52053, 52057, 18403, 18399, 0, 0, 0, 0, 55208, 55482, 0, 
55478, 55193, 55206, 0, 0
31862, 52053, 52057, 18403, 18399, 52054, 52058, 18404, 18400, 55208, 55482, 0, 55478, 55211, 55483, 0, 
55479, 55196, 55209, 0, 0
31863, 52054, 52058, 18404, 18400, 52055, 52059, 18405, 18401, 55211, 55483, 0, 55479, 55214, 55484, 0, 
55480, 55199, 55212, 0, 0
31864, 52055, 52059, 18405, 18401, 52056, 52060, 18406, 18402, 55214, 55484, 0, 55480, 55217, 55485, 0, 
55481, 55202, 55215, 0, 0
31865, 52056, 52060, 18406, 18402, 19312, 19313, 2301, 2300, 55217, 55485, 0, 55481, 0, 0, 0, 
0, 55205, 55218, 0, 0
31866, 10016, 10017, 1128, 1127, 52057, 52061, 18407, 18403, 0, 0, 0, 0, 55221, 55486, 0, 
55482, 55206, 55219, 0, 0
31867, 52057, 52061, 18407, 18403, 52058, 52062, 18408, 18404, 55221, 55486, 0, 55482, 55224, 55487, 0, 
55483, 55209, 55222, 0, 0
31868, 52058, 52062, 18408, 18404, 52059, 52063, 18409, 18405, 55224, 55487, 0, 55483, 55227, 55488, 0, 
55484, 55212, 55225, 0, 0
31869, 52059, 52063, 18409, 18405, 52060, 52064, 18410, 18406, 55227, 55488, 0, 55484, 55230, 55489, 0, 
55485, 55215, 55228, 0, 0
31870, 52060, 52064, 18410, 18406, 19313, 19314, 2302, 2301, 55230, 55489, 0, 55485, 0, 0, 0, 
0, 55218, 55231, 0, 0
31871, 10017, 10018, 1129, 1128, 52061, 52065, 18411, 18407, 0, 0, 0, 0, 55234, 55490, 0, 
55486, 55219, 55232, 0, 0
31872, 52061, 52065, 18411, 18407, 52062, 52066, 18412, 18408, 55234, 55490, 0, 55486, 55237, 55491, 0, 
55487, 55222, 55235, 0, 0
31873, 52062, 52066, 18412, 18408, 52063, 52067, 18413, 18409, 55237, 55491, 0, 55487, 55240, 55492, 0, 
55488, 55225, 55238, 0, 0
31874, 52063, 52067, 18413, 18409, 52064, 52068, 18414, 18410, 55240, 55492, 0, 55488, 55243, 55493, 0, 
55489, 55228, 55241, 0, 0
31875, 52064, 52068, 18414, 18410, 19314, 19315, 2303, 2302, 55243, 55493, 0, 55489, 0, 0, 0, 
0, 55231, 55244, 0, 0
31876, 10018, 10019, 1130, 1129, 52065, 52069, 18415, 18411, 0, 0, 0, 0, 55247, 55494, 0, 
55490, 55232, 55245, 0, 0
31877, 52065, 52069, 18415, 18411, 52066, 52070, 18416, 18412, 55247, 55494, 0, 55490, 55250, 55495, 0, 
55491, 55235, 55248, 0, 0
31878, 52066, 52070, 18416, 18412, 52067, 52071, 18417, 18413, 55250, 55495, 0, 55491, 55253, 55496, 0, 
55492, 55238, 55251, 0, 0
31879, 52067, 52071, 18417, 18413, 52068, 52072, 18418, 18414, 55253, 55496, 0, 55492, 55256, 55497, 0, 
55493, 55241, 55254, 0, 0
31880, 52068, 52072, 18418, 18414, 19315, 19316, 2304, 2303, 55256, 55497, 0, 55493, 0, 0, 0, 
0, 55244, 55257, 0, 0
31881, 10019, 10020, 1131, 1130, 52069, 52073, 18419, 18415, 0, 0, 0, 0, 55260, 55498, 0, 
55494, 55245, 55258, 0, 0
31882, 52069, 52073, 18419, 18415, 52070, 52074, 18420, 18416, 55260, 55498, 0, 55494, 55263, 55499, 0, 
55495, 55248, 55261, 0, 0
31883, 52070, 52074, 18420, 18416, 52071, 52075, 18421, 18417, 55263, 55499, 0, 55495, 55266, 55500, 0, 
55496, 55251, 55264, 0, 0
31884, 52071, 52075, 18421, 18417, 52072, 52076, 18422, 18418, 55266, 55500, 0, 55496, 55269, 55501, 0, 
55497, 55254, 55267, 0, 0
31885, 52072, 52076, 18422, 18418, 19316, 19317, 2305, 2304, 55269, 55501, 0, 55497, 0, 0, 0, 
0, 55257, 55270, 0, 0
31886, 10020, 10021, 1132, 1131, 52073, 52077, 18423, 18419, 0, 0, 0, 0, 55273, 55502, 0, 
55498, 55258, 55271, 0, 0
31887, 52073, 52077, 18423, 18419, 52074, 52078, 18424, 18420, 55273, 55502, 0, 55498, 55276, 55503, 0, 
55499, 55261, 55274, 0, 0
31888, 52074, 52078, 18424, 18420, 52075, 52079, 18425, 18421, 55276, 55503, 0, 55499, 55279, 55504, 0, 
55500, 55264, 55277, 0, 0
31889, 52075, 52079, 18425, 18421, 52076, 52080, 18426, 18422, 55279, 55504, 0, 55500, 55282, 55505, 0, 
55501, 55267, 55280, 0, 0
31890, 52076, 52080, 18426, 18422, 19317, 19318, 2306, 2305, 55282, 55505, 0, 55501, 0, 0, 0, 
0, 55270, 55283, 0, 0
31891, 10021, 10022, 1133, 1132, 52077, 52081, 18427, 18423, 0, 0, 0, 0, 55286, 55506, 0, 
55502, 55271, 55284, 0, 0
31892, 52077, 52081, 18427, 18423, 52078, 52082, 18428, 18424, 55286, 55506, 0, 55502, 55289, 55507, 0, 
55503, 55274, 55287, 0, 0
31893, 52078, 52082, 18428, 18424, 52079, 52083, 18429, 18425, 55289, 55507, 0, 55503, 55292, 55508, 0, 
55504, 55277, 55290, 0, 0
31894, 52079, 52083, 18429, 18425, 52080, 52084, 18430, 18426, 55292, 55508, 0, 55504, 55295, 55509, 0, 
55505, 55280, 55293, 0, 0
31895, 52080, 52084, 18430, 18426, 19318, 19319, 2307, 2306, 55295, 55509, 0, 55505, 0, 0, 0, 
0, 55283, 55296, 0, 0
31896, 10022, 10023, 1134, 1133, 52081, 52085, 18431, 18427, 0, 0, 0, 0, 55299, 55510, 0, 
55506, 55284, 55297, 0, 0
31897, 52081, 52085, 18431, 18427, 52082, 52086, 18432, 18428, 55299, 55510, 0, 55506, 55302, 55511, 0, 
55507, 55287, 55300, 0, 0
31898, 52082, 52086, 18432, 18428, 52083, 52087, 18433, 18429, 55302, 55511, 0, 55507, 55305, 55512, 0, 
55508, 55290, 55303, 0, 0
31899, 52083, 52087, 18433, 18429, 52084, 52088, 18434, 18430, 55305, 55512, 0, 55508, 55308, 55513, 0, 
55509, 55293, 55306, 0, 0
31900, 52084, 52088, 18434, 18430, 19319, 19320, 2308, 2307, 55308, 55513, 0, 55509, 0, 0, 0, 
0, 55296, 55309, 0, 0
31901, 10023, 10024, 1135, 1134, 52085, 52089, 18435, 18431, 0, 0, 0, 0, 55312, 55514, 0, 
55510, 55297, 55310, 0, 0
31902, 52085, 52089, 18435, 18431, 52086, 52090, 18436, 18432, 55312, 55514, 0, 55510, 55315, 55515, 0, 
55511, 55300, 55313, 0, 0
31903, 52086, 52090, 18436, 18432, 52087, 52091, 18437, 18433, 55315, 55515, 0, 55511, 55318, 55516, 0, 
55512, 55303, 55316, 0, 0
31904, 52087, 52091, 18437, 18433, 52088, 52092, 18438, 18434, 55318, 55516, 0, 55512, 55321, 55517, 0, 
55513, 55306, 55319, 0, 0
31905, 52088, 52092, 18438, 18434, 19320, 19321, 2309, 2308, 55321, 55517, 0, 55513, 0, 0, 0, 
0, 55309, 55322, 0, 0
31906, 10024, 10025, 1136, 1135, 52089, 52093, 18439, 18435, 0, 0, 0, 0, 55325, 55518, 0, 
55514, 55310, 55323, 0, 0
31907, 52089, 52093, 18439, 18435, 52090, 52094, 18440, 18436, 55325, 55518, 0, 55514, 55328, 55519, 0, 
55515, 55313, 55326, 0, 0
31908, 52090, 52094, 18440, 18436, 52091, 52095, 18441, 18437, 55328, 55519, 0, 55515, 55331, 55520, 0, 
55516, 55316, 55329, 0, 0
31909, 52091, 52095, 18441, 18437, 52092, 52096, 18442, 18438, 55331, 55520, 0, 55516, 55334, 55521, 0, 
55517, 55319, 55332, 0, 0
31910, 52092, 52096, 18442, 18438, 19321, 19322, 2310, 2309, 55334, 55521, 0, 55517, 0, 0, 0, 
0, 55322, 55335, 0, 0
31911, 10025, 10026, 1137, 1136, 52093, 52097, 18443, 18439, 0, 0, 0, 0, 55338, 55522, 0, 
55518, 55323, 55336, 0, 0
31912, 52093, 52097, 18443, 18439, 52094, 52098, 18444, 18440, 55338, 55522, 0, 55518, 55341, 55523, 0, 
55519, 55326, 55339, 0, 0
31913, 52094, 52098, 18444, 18440, 52095, 52099, 18445, 18441, 55341, 55523, 0, 55519, 55344, 55524, 0, 
55520, 55329, 55342, 0, 0
31914, 52095, 52099, 18445, 18441, 52096, 52100, 18446, 18442, 55344, 55524, 0, 55520, 55347, 55525, 0, 
55521, 55332, 55345, 0, 0
31915, 52096, 52100, 18446, 18442, 19322, 19323, 2311, 2310, 55347, 55525, 0, 55521, 0, 0, 0, 
0, 55335, 55348, 0, 0
31916, 10026, 10027, 1138, 1137, 52097, 52101, 18447, 18443, 0, 0, 0, 0, 55351, 55526, 0, 
55522, 55336, 55349, 0, 0
31917, 52097, 52101, 18447, 18443, 52098, 52102, 18448, 18444, 55351, 55526, 0, 55522, 55354, 55527, 0, 
55523, 55339, 55352, 0, 0
31918, 52098, 52102, 18448, 18444, 52099, 52103, 18449, 18445, 55354, 55527, 0, 55523, 55357, 55528, 0, 
55524, 55342, 55355, 0, 0
31919, 52099, 52103, 18449, 18445, 52100, 52104, 18450, 18446, 55357, 55528, 0, 55524, 55360, 55529, 0, 
55525, 55345, 55358, 0, 0
31920, 52100, 52104, 18450, 18446, 19323, 19324, 2312, 2311, 55360, 55529, 0, 55525, 0, 0, 0, 
0, 55348, 55361, 0, 0
31921, 10027, 10028, 1139, 1138, 52101, 52105, 18451, 18447, 0, 0, 0, 0, 55364, 55530, 0, 
55526, 55349, 55362, 0, 0
31922, 52101, 52105, 18451, 18447, 52102, 52106, 18452, 18448, 55364, 55530, 0, 55526, 55367, 55531, 0, 
55527, 55352, 55365, 0, 0
31923, 52102, 52106, 18452, 18448, 52103, 52107, 18453, 18449, 55367, 55531, 0, 55527, 55370, 55532, 0, 
55528, 55355, 55368, 0, 0
31924, 52103, 52107, 18453, 18449, 52104, 52108, 18454, 18450, 55370, 55532, 0, 55528, 55373, 55533, 0, 
55529, 55358, 55371, 0, 0
31925, 52104, 52108, 18454, 18450, 19324, 19325, 2313, 2312, 55373, 55533, 0, 55529, 0, 0, 0, 
0, 55361, 55374, 0, 0
31926, 10028, 10029, 1140, 1139, 52105, 52109, 18455, 18451, 0, 0, 0, 0, 55377, 55534, 0, 
55530, 55362, 55375, 0, 0
31927, 52105, 52109, 18455, 18451, 52106, 52110, 18456, 18452, 55377, 55534, 0, 55530, 55380, 55535, 0, 
55531, 55365, 55378, 0, 0
31928, 52106, 52110, 18456, 18452, 52107, 52111, 18457, 18453, 55380, 55535, 0, 55531, 55383, 55536, 0, 
55532, 55368, 55381, 0, 0
31929, 52107, 52111, 18457, 18453, 52108, 52112, 18458, 18454, 55383, 55536, 0, 55532, 55386, 55537, 0, 
55533, 55371, 55384, 0, 0
31930, 52108, 52112, 18458, 18454, 19325, 19326, 2314, 2313, 55386, 55537, 0, 55533, 0, 0, 0, 
0, 55374, 55387, 0, 0
31931, 10029, 10030, 1141, 1140, 52109, 52113, 18459, 18455, 0, 0, 0, 0, 55390, 55538, 0, 
55534, 55375, 55388, 0, 0
31932, 52109, 52113, 18459, 18455, 52110, 52114, 18460, 18456, 55390, 55538, 0, 55534, 55393, 55539, 0, 
55535, 55378, 55391, 0, 0
31933, 52110, 52114, 18460, 18456, 52111, 52115, 18461, 18457, 55393, 55539, 0, 55535, 55396, 55540, 0, 
55536, 55381, 55394, 0, 0
31934, 52111, 52115, 18461, 18457, 52112, 52116, 18462, 18458, 55396, 55540, 0, 55536, 55399, 55541, 0, 
55537, 55384, 55397, 0, 0
31935, 52112, 52116, 18462, 18458, 19326, 19327, 2315, 2314, 55399, 55541, 0, 55537, 0, 0, 0, 
0, 55387, 55400, 0, 0
31936, 10030, 10031, 1142, 1141, 52113, 52117, 18463, 18459, 0, 0, 0, 0, 55403, 55542, 0, 
55538, 55388, 55401, 0, 0
31937, 52113, 52117, 18463, 18459, 52114, 52118, 18464, 18460, 55403, 55542, 0, 55538, 55406, 55543, 0, 
55539, 55391, 55404, 0, 0
31938, 52114, 52118, 18464, 18460, 52115, 52119, 18465, 18461, 55406, 55543, 0, 55539, 55409, 55544, 0, 
55540, 55394, 55407, 0, 0
31939, 52115, 52119, 18465, 18461, 52116, 52120, 18466, 18462, 55409, 55544, 0, 55540, 55412, 55545, 0, 
55541, 55397, 55410, 0, 0
31940, 52116, 52120, 18466, 18462, 19327, 19328, 2316, 2315, 55412, 55545, 0, 55541, 0, 0, 0, 
0, 55400, 55413, 0, 0
31941, 10031, 10032, 1143, 1142, 52117, 52121, 18467, 18463, 0, 0, 0, 0, 55416, 55546, 0, 
55542, 55401, 55414, 0, 0
31942, 52117, 52121, 18467, 18463, 52118, 52122, 18468, 18464, 55416, 55546, 0, 55542, 55419, 55547, 0, 
55543, 55404, 55417, 0, 0
31943, 52118, 52122, 18468, 18464, 52119, 52123, 18469, 18465, 55419, 55547, 0, 55543, 55422, 55548, 0, 
55544, 55407, 55420, 0, 0
31944, 52119, 52123, 18469, 18465, 52120, 52124, 18470, 18466, 55422, 55548, 0, 55544, 55425, 55549, 0, 
55545, 55410, 55423, 0, 0
31945, 52120, 52124, 18470, 18466, 19328, 19329, 2317, 2316, 55425, 55549, 0, 55545, 0, 0, 0, 
0, 55413, 55426, 0, 0
31946, 10032, 10033, 1144, 1143, 52121, 52125, 18471, 18467, 0, 0, 0, 0, 55429, 55550, 0, 
55546, 55414, 55427, 0, 0
31947, 52121, 52125, 18471, 18467, 52122, 52126, 18472, 18468, 55429, 55550, 0, 55546, 55432, 55551, 0, 
55547, 55417, 55430, 0, 0
31948, 52122, 52126, 18472, 18468, 52123, 52127, 18473, 18469, 55432, 55551, 0, 55547, 55435, 55552, 0, 
55548, 55420, 55433, 0, 0
31949, 52123, 52127, 18473, 18469, 52124, 52128, 18474, 18470, 55435, 55552, 0, 55548, 55438, 55553, 0, 
55549, 55423, 55436, 0, 0
31950, 52124, 52128, 18474, 18470, 19329, 19330, 2318, 2317, 55438, 55553, 0, 55549, 0, 0, 0, 
0, 55426, 55439, 0, 0
31951, 10033, 10034, 1145, 1144, 52125, 52129, 18475, 18471, 0, 0, 0, 0, 55442, 55554, 0, 
55550, 55427, 55440, 0, 0
31952, 52125, 52129, 18475, 18471, 52126, 52130, 18476, 18472, 55442, 55554, 0, 55550, 55445, 55555, 0, 
55551, 55430, 55443, 0, 0
31953, 52126, 52130, 18476, 18472, 52127, 52131, 18477, 18473, 55445, 55555, 0, 55551, 55448, 55556, 0, 
55552, 55433, 55446, 0, 0
31954, 52127, 52131, 18477, 18473, 52128, 52132, 18478, 18474, 55448, 55556, 0, 55552, 55451, 55557, 0, 
55553, 55436, 55449, 0, 0
31955, 52128, 52132, 18478, 18474, 19330, 19331, 2319, 2318, 55451, 55557, 0, 55553, 0, 0, 0, 
0, 55439, 55452, 0, 0
31956, 10034, 10035, 1146, 1145, 52129, 52133, 18479, 18475, 0, 0, 0, 0, 55455, 55558, 0, 
55554, 55440, 55453, 0, 0
31957, 52129, 52133, 18479, 18475, 52130, 52134, 18480, 18476, 55455, 55558, 0, 55554, 55458, 55559, 0, 
55555, 55443, 55456, 0, 0
31958, 52130, 52134, 18480, 18476, 52131, 52135, 18481, 18477, 55458, 55559, 0, 55555, 55461, 55560, 0, 
55556, 55446, 55459, 0, 0
31959, 52131, 52135, 18481, 18477, 52132, 52136, 18482, 18478, 55461, 55560, 0, 55556, 55464, 55561, 0, 
55557, 55449, 55462, 0, 0
31960, 52132, 52136, 18482, 18478, 19331, 19332, 2320, 2319, 55464, 55561, 0, 55557, 0, 0, 0, 
0, 55452, 55465, 0, 0
31961, 10035, 1201, 46, 1146, 52133, 18973, 2294, 18479, 0, 0, 0, 0, 55466, 19076, 0, 
55558, 55453, 19067, 0, 0
31962, 52133, 18973, 2294, 18479, 52134, 18974, 2295, 18480, 55466, 19076, 0, 55558, 55467, 19077, 0, 
55559, 55456, 19069, 0, 0
31963, 52134, 18974, 2295, 18480, 52135, 18975, 2296, 18481, 55467, 19077, 0, 55559, 55468, 19078, 0, 
55560, 55459, 19071, 0, 0
31964, 52135, 18975, 2296, 18481, 52136, 18976, 2297, 18482, 55468, 19078, 0, 55560, 55469, 19079, 0, 
55561, 55462, 19073, 0, 0
31965, 52136, 18976, 2297, 18482, 19332, 2383, 92, 2320, 55469, 19079, 0, 55561, 0, 0, 0, 
0, 55465, 19075, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume26
31966, 48, 52, 1217, 1191, 2330, 2388, 19337, 18933, 0, 0, 0, 0, 19333, 19382, 55562, 
18978, 2334, 2392, 19381, 18977
31967, 2330, 2388, 19337, 18933, 2331, 2389, 19338, 18934, 19333, 19382, 55562, 18978, 19334, 19384, 55563, 
18980, 2335, 2393, 19383, 18979
31968, 2331, 2389, 19338, 18934, 2332, 2390, 19339, 18935, 19334, 19384, 55563, 18980, 19335, 19386, 55564, 
18982, 2336, 2394, 19385, 18981
31969, 2332, 2390, 19339, 18935, 2333, 2391, 19340, 18936, 19335, 19386, 55564, 18982, 19336, 19388, 55565, 
18984, 2337, 2395, 19387, 18983
31970, 2333, 2391, 19340, 18936, 94, 96, 2397, 2373, 19336, 19388, 55565, 18984, 0, 0, 0, 
0, 2338, 2396, 19389, 18985
31971, 1191, 1217, 1218, 1192, 18933, 19337, 19341, 18937, 0, 0, 0, 0, 55562, 19391, 55566, 
18987, 18977, 19381, 19390, 18986
31972, 18933, 19337, 19341, 18937, 18934, 19338, 19342, 18938, 55562, 19391, 55566, 18987, 55563, 19393, 55567, 
18989, 18979, 19383, 19392, 18988
31973, 18934, 19338, 19342, 18938, 18935, 19339, 19343, 18939, 55563, 19393, 55567, 18989, 55564, 19395, 55568, 
18991, 18981, 19385, 19394, 18990
31974, 18935, 19339, 19343, 18939, 18936, 19340, 19344, 18940, 55564, 19395, 55568, 18991, 55565, 19397, 55569, 
18993, 18983, 19387, 19396, 18992
31975, 18936, 19340, 19344, 18940, 2373, 2397, 2398, 2374, 55565, 19397, 55569, 18993, 0, 0, 0, 
0, 18985, 19389, 19398, 18994
31976, 1192, 1218, 1219, 1193, 18937, 19341, 19345, 18941, 0, 0, 0, 0, 55566, 19400, 55570, 
18996, 18986, 19390, 19399, 18995
31977, 18937, 19341, 19345, 18941, 18938, 19342, 19346, 18942, 55566, 19400, 55570, 18996, 55567, 19402, 55571, 
18998, 18988, 19392, 19401, 18997
31978, 18938, 19342, 19346, 18942, 18939, 19343, 19347, 18943, 55567, 19402, 55571, 18998, 55568, 19404, 55572, 
19000, 18990, 19394, 19403, 18999
31979, 18939, 19343, 19347, 18943, 18940, 19344, 19348, 18944, 55568, 19404, 55572, 19000, 55569, 19406, 55573, 
19002, 18992, 19396, 19405, 19001
31980, 18940, 19344, 19348, 18944, 2374, 2398, 2399, 2375, 55569, 19406, 55573, 19002, 0, 0, 0, 
0, 18994, 19398, 19407, 19003
31981, 1193, 1219, 1220, 1194, 18941, 19345, 19349, 18945, 0, 0, 0, 0, 55570, 19409, 55574, 
19005, 18995, 19399, 19408, 19004
31982, 18941, 19345, 19349, 18945, 18942, 19346, 19350, 18946, 55570, 19409, 55574, 19005, 55571, 19411, 55575, 
19007, 18997, 19401, 19410, 19006
31983, 18942, 19346, 19350, 18946, 18943, 19347, 19351, 18947, 55571, 19411, 55575, 19007, 55572, 19413, 55576, 
19009, 18999, 19403, 19412, 19008
31984, 18943, 19347, 19351, 18947, 18944, 19348, 19352, 18948, 55572, 19413, 55576, 19009, 55573, 19415, 55577, 
19011, 19001, 19405, 19414, 19010
31985, 18944, 19348, 19352, 18948, 2375, 2399, 2400, 2376, 55573, 19415, 55577, 19011, 0, 0, 0, 
0, 19003, 19407, 19416, 19012
31986, 1194, 1220, 1221, 1195, 18945, 19349, 19353, 18949, 0, 0, 0, 0, 55574, 19418, 55578, 
19014, 19004, 19408, 19417, 19013
31987, 18945, 19349, 19353, 18949, 18946, 19350, 19354, 18950, 55574, 19418, 55578, 19014, 55575, 19420, 55579, 
19016, 19006, 19410, 19419, 19015
31988, 18946, 19350, 19354, 18950, 18947, 19351, 19355, 18951, 55575, 19420, 55579, 19016, 55576, 19422, 55580, 
19018, 19008, 19412, 19421, 19017
31989, 18947, 19351, 19355, 18951, 18948, 19352, 19356, 18952, 55576, 19422, 55580, 19018, 55577, 19424, 55581, 
19020, 19010, 19414, 19423, 19019
31990, 18948, 19352, 19356, 18952, 2376, 2400, 2401, 2377, 55577, 19424, 55581, 19020, 0, 0, 0, 
0, 19012, 19416, 19425, 19021
31991, 1195, 1221, 1222, 1196, 18949, 19353, 19357, 18953, 0, 0, 0, 0, 55578, 19427, 55582, 
19023, 19013, 19417, 19426, 19022
31992, 18949, 19353, 19357, 18953, 18950, 19354, 19358, 18954, 55578, 19427, 55582, 19023, 55579, 19429, 55583, 
19025, 19015, 19419, 19428, 19024
31993, 18950, 19354, 19358, 18954, 18951, 19355, 19359, 18955, 55579, 19429, 55583, 19025, 55580, 19431, 55584, 
19027, 19017, 19421, 19430, 19026
31994, 18951, 19355, 19359, 18955, 18952, 19356, 19360, 18956, 55580, 19431, 55584, 19027, 55581, 19433, 55585, 
19029, 19019, 19423, 19432, 19028
31995, 18952, 19356, 19360, 18956, 2377, 2401, 2402, 2378, 55581, 19433, 55585, 19029, 0, 0, 0, 
0, 19021, 19425, 19434, 19030
31996, 1196, 1222, 1223, 1197, 18953, 19357, 19361, 18957, 0, 0, 0, 0, 55582, 19436, 55586, 
19032, 19022, 19426, 19435, 19031
31997, 18953, 19357, 19361, 18957, 18954, 19358, 19362, 18958, 55582, 19436, 55586, 19032, 55583, 19438, 55587, 
19034, 19024, 19428, 19437, 19033
31998, 18954, 19358, 19362, 18958, 18955, 19359, 19363, 18959, 55583, 19438, 55587, 19034, 55584, 19440, 55588, 
19036, 19026, 19430, 19439, 19035
31999, 18955, 19359, 19363, 18959, 18956, 19360, 19364, 18960, 55584, 19440, 55588, 19036, 55585, 19442, 55589, 
19038, 19028, 19432, 19441, 19037
32000, 18956, 19360, 19364, 18960, 2378, 2402, 2403, 2379, 55585, 19442, 55589, 19038, 0, 0, 0, 
0, 19030, 19434, 19443, 19039
32001, 1197, 1223, 1224, 1198, 18957, 19361, 19365, 18961, 0, 0, 0, 0, 55586, 19445, 55590, 
19041, 19031, 19435, 19444, 19040
32002, 18957, 19361, 19365, 18961, 18958, 19362, 19366, 18962, 55586, 19445, 55590, 19041, 55587, 19447, 55591, 
19043, 19033, 19437, 19446, 19042
32003, 18958, 19362, 19366, 18962, 18959, 19363, 19367, 18963, 55587, 19447, 55591, 19043, 55588, 19449, 55592, 
19045, 19035, 19439, 19448, 19044
32004, 18959, 19363, 19367, 18963, 18960, 19364, 19368, 18964, 55588, 19449, 55592, 19045, 55589, 19451, 55593, 
19047, 19037, 19441, 19450, 19046
32005, 18960, 19364, 19368, 18964, 2379, 2403, 2404, 2380, 55589, 19451, 55593, 19047, 0, 0, 0, 
0, 19039, 19443, 19452, 19048
32006, 1198, 1224, 1225, 1199, 18961, 19365, 19369, 18965, 0, 0, 0, 0, 55590, 19454, 55594, 
19050, 19040, 19444, 19453, 19049
32007, 18961, 19365, 19369, 18965, 18962, 19366, 19370, 18966, 55590, 19454, 55594, 19050, 55591, 19456, 55595, 
19052, 19042, 19446, 19455, 19051
32008, 18962, 19366, 19370, 18966, 18963, 19367, 19371, 18967, 55591, 19456, 55595, 19052, 55592, 19458, 55596, 
19054, 19044, 19448, 19457, 19053
32009, 18963, 19367, 19371, 18967, 18964, 19368, 19372, 18968, 55592, 19458, 55596, 19054, 55593, 19460, 55597, 
19056, 19046, 19450, 19459, 19055
32010, 18964, 19368, 19372, 18968, 2380, 2404, 2405, 2381, 55593, 19460, 55597, 19056, 0, 0, 0, 
0, 19048, 19452, 19461, 19057
32011, 1199, 1225, 1226, 1200, 18965, 19369, 19373, 18969, 0, 0, 0, 0, 55594, 19463, 55598, 
19059, 19049, 19453, 19462, 19058
32012, 18965, 19369, 19373, 18969, 18966, 19370, 19374, 18970, 55594, 19463, 55598, 19059, 55595, 19465, 55599, 
19061, 19051, 19455, 19464, 19060
32013, 18966, 19370, 19374, 18970, 18967, 19371, 19375, 18971, 55595, 19465, 55599, 19061, 55596, 19467, 55600, 
19063, 19053, 19457, 19466, 19062
32014, 18967, 19371, 19375, 18971, 18968, 19372, 19376, 18972, 55596, 19467, 55600, 19063, 55597, 19469, 55601, 
19065, 19055, 19459, 19468, 19064
32015, 18968, 19372, 19376, 18972, 2381, 2405, 2406, 2382, 55597, 19469, 55601, 19065, 0, 0, 0, 
0, 19057, 19461, 19470, 19066
32016, 1200, 1226, 1227, 1201, 18969, 19373, 19377, 18973, 0, 0, 0, 0, 55598, 19472, 55602, 
19068, 19058, 19462, 19471, 19067
32017, 18969, 19373, 19377, 18973, 18970, 19374, 19378, 18974, 55598, 19472, 55602, 19068, 55599, 19474, 55603, 
19070, 19060, 19464, 19473, 19069
32018, 18970, 19374, 19378, 18974, 18971, 19375, 19379, 18975, 55599, 19474, 55603, 19070, 55600, 19476, 55604, 
19072, 19062, 19466, 19475, 19071
32019, 18971, 19375, 19379, 18975, 18972, 19376, 19380, 18976, 55600, 19476, 55604, 19072, 55601, 19478, 55605, 
19074, 19064, 19468, 19477, 19073
32020, 18972, 19376, 19380, 18976, 2382, 2406, 2407, 2383, 55601, 19478, 55605, 19074, 0, 0, 0, 
0, 19066, 19470, 19479, 19075
32021, 1201, 1227, 50, 46, 18973, 19377, 2384, 2294, 0, 0, 0, 0, 55602, 19480, 0, 
19076, 19067, 19471, 0, 0
32022, 18973, 19377, 2384, 2294, 18974, 19378, 2385, 2295, 55602, 19480, 0, 19076, 55603, 19481, 0, 
19077, 19069, 19473, 0, 0
32023, 18974, 19378, 2385, 2295, 18975, 19379, 2386, 2296, 55603, 19481, 0, 19077, 55604, 19482, 0, 
19078, 19071, 19475, 0, 0
32024, 18975, 19379, 2386, 2296, 18976, 19380, 2387, 2297, 55604, 19482, 0, 19078, 55605, 19483, 0, 
19079, 19073, 19477, 0, 0
32025, 18976, 19380, 2387, 2297, 2383, 2407, 95, 92, 55605, 19483, 0, 19079, 0, 0, 0, 
0, 19075, 19479, 0, 0
*ELSET,ELSET=VoltageL_2D
4, 5, 6, 
*ELSET,ELSET=VoltageR_2D
1, 2, 3, 
*ELSET,ELSET=TopCeramic_2D
7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 
17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 
27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 
37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
57, 58, 59, 
*ELSET,ELSET=BottomCeramic_2D
60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 
70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 
80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 
90, 91, 92, 93, 94, 95, 96, 97, 98, 99, 
100, 101, 102, 103, 104, 105, 106, 107, 108, 109, 
*ELSET,ELSET=Qin
1490, 1491, 1492, 1493, 1494, 1495, 1496, 1497, 1498, 1499, 
1500, 1501, 1502, 1503, 1504, 1505, 1506, 1507, 1508, 1509, 
1510, 1511, 1512, 1513, 1514, 1515, 1516, 1517, 1518, 1519, 
1520, 1521, 1522, 1523, 1524, 1525, 1526, 1527, 1528, 1529, 
1530, 1531, 1532, 1533, 1534, 1535, 1536, 1537, 1538, 1539, 
1540, 1541, 1542, 1543, 1544, 1545, 1546, 1547, 1548, 1549, 
1550, 1551, 1552, 1553, 1554, 1555, 1556, 1557, 1558, 1559, 
1560, 1561, 1562, 1563, 1564, 1565, 1566, 1567, 1568, 1569, 
1570, 1571, 1572, 1573, 1574, 1575, 1576, 1577, 1578, 1579, 
1580, 1581, 1582, 1583, 1584, 1585, 1586, 1587, 1588, 1589, 
1590, 1591, 1592, 1593, 1594, 1595, 1596, 1597, 1598, 1599, 
1600, 1601, 1602, 1603, 1604, 1605, 1606, 1607, 1608, 1609, 
1610, 1611, 1612, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 
1620, 1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 
1630, 1631, 1632, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 
1640, 1641, 1642, 1643, 1644, 1645, 1646, 1647, 1648, 1649, 
1650, 1651, 1652, 1653, 1654, 1655, 1656, 1657, 1658, 1659, 
1660, 1661, 1662, 1663, 1664, 1665, 1666, 1667, 1668, 1669, 
1670, 1671, 1672, 1673, 1674, 1675, 1676, 1677, 1678, 1679, 
1680, 1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 1689, 
1690, 1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 1699, 
1700, 1701, 1702, 1703, 1704, 1705, 1706, 1707, 1708, 1709, 
1710, 1711, 1712, 1713, 1714, 1715, 1716, 1717, 1718, 1719, 
1720, 1721, 1722, 1723, 1724, 1725, 1726, 1727, 1728, 1729, 
1730, 1731, 1732, 1733, 1734, 1735, 1736, 1737, 1738, 1739, 
1740, 1741, 1742, 1743, 1744, 1745, 1746, 1747, 1748, 1749, 
1750, 1751, 1752, 1753, 1754, 1755, 1756, 1757, 1758, 1759, 
1760, 1761, 1762, 1763, 1764, 1765, 1766, 1767, 1768, 1769, 
1770, 1771, 1772, 1773, 1774, 1775, 1776, 1777, 1793, 1794, 
1795, 1796, 1797, 1798, 1799, 1800, 1801, 1802, 1803, 1804, 
1805, 1806, 1807, 1808, 1809, 1810, 1811, 1812, 1813, 1814, 
1815, 1816, 1817, 1818, 1819, 1820, 1821, 1822, 1823, 1824, 
1825, 1826, 1827, 1828, 1829, 1830, 1831, 1832, 1833, 1834, 
1835, 1836, 1837, 1838, 1839, 1840, 1841, 1842, 1843, 1844, 
1845, 1846, 1847, 1848, 1849, 1850, 1851, 1852, 1925, 1926, 
1927, 1928, 1929, 1930, 1931, 1932, 1933, 1934, 1935, 1936, 
1937, 1938, 1939, 1940, 1941, 1942, 1943, 1944, 1945, 1946, 
1947, 1948, 1949, 1950, 1951, 1952, 1953, 1954, 1955, 1956, 
1957, 1958, 1959, 1960, 1961, 1962, 1963, 1964, 1965, 1966, 
1967, 1968, 1969, 1970, 1971, 1972, 1973, 1974, 1975, 1976, 
1977, 1978, 1979, 1980, 1981, 1982, 1983, 1984, 1985, 1986, 
1987, 1988, 1989, 1990, 1991, 1992, 1993, 1994, 1995, 1996, 
1997, 1998, 1999, 2000, 2001, 2002, 2003, 2004, 2005, 2006, 
2007, 2008, 2009, 2010, 2011, 2012, 2013, 2014, 2015, 2016, 
2017, 2018, 2019, 2020, 2021, 2022, 2023, 2024, 2025, 2026, 
2027, 2028, 2029, 2030, 2031, 2032, 2033, 2034, 2035, 2036, 
2037, 2038, 2039, 2040, 2041, 2042, 2043, 2044, 2045, 2046, 
2047, 2048, 2049, 2050, 2051, 2052, 2053, 2054, 2055, 2056, 
2057, 2058, 2059, 2060, 2061, 2062, 2063, 2064, 2065, 2066, 
2067, 2068, 2069, 2070, 2071, 2072, 2073, 2074, 2075, 2076, 
2077, 2078, 2079, 2080, 2081, 2082, 2083, 2084, 2085, 2086, 
2087, 2088, 2089, 2090, 2091, 2092, 2093, 2094, 2095, 2096, 
2097, 2098, 2099, 2100, 2101, 2102, 2103, 2104, 2105, 2106, 
2107, 2108, 2109, 2110, 2111, 2112, 2113, 2114, 2115, 2116, 
2117, 2118, 2119, 2120, 2121, 2122, 2123, 2124, 2125, 2126, 
2127, 2128, 2129, 2130, 2131, 2132, 2133, 2134, 2135, 2136, 
2137, 2138, 2139, 2140, 2141, 2142, 2143, 2144, 2145, 2146, 
2147, 2148, 2149, 2150, 2151, 2152, 2153, 2154, 2155, 2156, 
2157, 2158, 2159, 2160, 2161, 2162, 2163, 2164, 2165, 2166, 
2167, 2168, 2169, 2170, 2171, 2172, 2173, 2174, 2175, 2176, 
2177, 2178, 2179, 2180, 2181, 2182, 2183, 2184, 2185, 2186, 
2187, 2188, 2189, 2190, 2191, 2192, 2193, 2194, 2195, 2196, 
2197, 2198, 2199, 2200, 2201, 2202, 2203, 2204, 2205, 2206, 
2207, 2208, 2209, 2210, 2211, 2212, 
*ELSET,ELSET=HeatSink
110, 111, 112, 113, 114, 115, 116, 117, 118, 119, 
120, 121, 122, 123, 124, 125, 126, 127, 128, 129, 
130, 131, 132, 133, 134, 135, 136, 137, 138, 139, 
140, 141, 142, 143, 144, 145, 146, 147, 148, 149, 
150, 151, 152, 153, 154, 155, 156, 157, 158, 159, 
160, 161, 162, 163, 164, 165, 166, 167, 168, 169, 
170, 171, 172, 173, 174, 175, 176, 177, 178, 179, 
180, 181, 182, 183, 184, 185, 186, 187, 188, 189, 
190, 191, 192, 193, 194, 195, 196, 197, 198, 199, 
200, 201, 202, 203, 204, 205, 206, 207, 208, 209, 
210, 211, 212, 213, 214, 215, 216, 217, 218, 219, 
220, 221, 222, 223, 224, 225, 226, 227, 228, 229, 
230, 231, 232, 233, 234, 235, 236, 237, 238, 239, 
240, 241, 242, 243, 244, 245, 246, 247, 248, 249, 
250, 251, 252, 253, 254, 255, 256, 257, 258, 259, 
260, 261, 262, 263, 264, 265, 266, 267, 268, 269, 
270, 271, 272, 273, 274, 275, 276, 277, 278, 279, 
280, 281, 282, 283, 284, 285, 286, 287, 288, 289, 
290, 291, 292, 293, 294, 295, 296, 297, 298, 299, 
300, 301, 302, 303, 304, 305, 306, 307, 308, 309, 
310, 311, 312, 313, 314, 315, 316, 317, 318, 319, 
320, 321, 322, 323, 324, 325, 326, 327, 328, 329, 
330, 331, 332, 333, 334, 335, 336, 337, 338, 339, 
340, 341, 342, 343, 344, 345, 346, 347, 348, 349, 
350, 351, 352, 353, 354, 355, 356, 357, 358, 359, 
360, 361, 362, 363, 364, 365, 366, 367, 368, 369, 
370, 371, 372, 373, 374, 375, 376, 377, 378, 379, 
380, 381, 382, 383, 384, 385, 386, 387, 388, 389, 
390, 391, 392, 393, 394, 395, 396, 397, 3197, 3198, 
3199, 3200, 3201, 3202, 3203, 3204, 3205, 3206, 3207, 3208, 
3209, 3210, 3211, 3212, 3213, 3214, 3215, 3216, 3217, 3218, 
3219, 3220, 3221, 3222, 3223, 3224, 3225, 3226, 3227, 3228, 
3229, 3230, 3231, 3232, 3233, 3234, 3235, 3236, 3237, 3238, 
3239, 3240, 3241, 3242, 3243, 3244, 3245, 3246, 3247, 3248, 
3249, 3250, 3251, 3252, 3253, 3254, 3255, 3256, 3257, 3258, 
3259, 3260, 3261, 3262, 3263, 3264, 3265, 3266, 3267, 3268, 
3269, 3270, 3271, 3272, 3273, 3274, 3275, 3276, 3277, 3278, 
3279, 3280, 3281, 3282, 3283, 3284, 3285, 3286, 3287, 3288, 
3289, 3290, 3291, 3292, 3293, 3294, 3295, 3296, 3297, 3298, 
3299, 3300, 3301, 3302, 3303, 3304, 3305, 3306, 3307, 3308, 
3309, 3310, 3311, 3312, 3313, 3314, 3315, 3316, 3317, 3318, 
3319, 3320, 3321, 3322, 3323, 3324, 3325, 3326, 3327, 3328, 
3329, 3330, 3331, 3332, 3333, 3334, 3335, 3336, 3337, 3338, 
3339, 3340, 3341, 3342, 3343, 3344, 3345, 3346, 3347, 3348, 
3349, 3350, 3351, 3352, 3353, 3354, 3355, 3356, 3357, 3358, 
3359, 3360, 3361, 3362, 3363, 3364, 3365, 3366, 3367, 3368, 
3369, 3370, 3371, 3372, 3373, 3374, 3375, 3376, 3377, 3378, 
3379, 3380, 3381, 3382, 3383, 3384, 3385, 3386, 3387, 3388, 
3389, 3390, 3391, 3392, 3393, 3394, 3395, 3396, 3397, 3398, 
3399, 3400, 3401, 3402, 3403, 3404, 3405, 3406, 3407, 3408, 
3409, 3410, 3411, 3412, 3413, 3414, 3415, 3416, 3417, 3418, 
3419, 3420, 3421, 3422, 3423, 3424, 3425, 3426, 3427, 3428, 
3429, 3430, 3431, 3432, 3433, 3434, 3435, 3436, 3437, 3438, 
3439, 3440, 3441, 3442, 3443, 3444, 3445, 3446, 3447, 3448, 
3449, 3450, 3451, 3452, 3453, 3454, 3455, 3456, 3457, 3458, 
3459, 3460, 3461, 3462, 3463, 3464, 3465, 3466, 3467, 3468, 
3469, 3470, 3471, 3472, 3473, 3474, 3475, 3476, 3477, 3478, 
3479, 3480, 3481, 3482, 3483, 3484, 
*ELSET,ELSET=ElectrodeMaxX
3500, 3501, 3502, 3503, 3504, 3505, 3506, 3507, 3508, 3509, 
3510, 3511, 3512, 3513, 3514, 3515, 3516, 3517, 3518, 3519, 
3520, 3521, 3522, 3523, 3524, 3525, 3526, 3527, 3528, 3529, 
3530, 3531, 3532, 3533, 3534, 3535, 
*ELSET,ELSET=ElectrodeMinX
3551, 3552, 3553, 3554, 3555, 3556, 3557, 3558, 3559, 3560, 
3561, 3562, 3563, 3564, 3565, 3566, 3567, 3568, 3569, 3570, 
3571, 3572, 3573, 3574, 3575, 3576, 3577, 3578, 3579, 3580, 
3581, 3582, 3583, 3584, 3585, 3586, 
*ELSET,ELSET=Force
1454, 1455, 1456, 1457, 1458, 1459, 1460, 1461, 1462, 1463, 
1464, 1465, 1466, 1467, 1468, 1469, 1470, 1471, 1472, 1473, 
1474, 1475, 1476, 1477, 1478, 1479, 1480, 1481, 1482, 1483, 
1484, 1485, 1486, 1487, 1488, 1489, 
*ELSET,ELSET=Ceramic_Top
3755, 3756, 3757, 3758, 3759, 3760, 3761, 3762, 3763, 3764, 
3765, 3766, 3767, 3768, 3769, 3770, 3771, 3772, 3773, 3774, 
3775, 3776, 3777, 3778, 3779, 3780, 3781, 3782, 3783, 3784, 
3785, 3786, 3787, 3788, 3789, 3790, 3791, 3792, 3793, 3794, 
3795, 3796, 3797, 3798, 3799, 3800, 3801, 3802, 3803, 3804, 
3805, 3806, 3807, 3808, 3809, 3810, 3811, 3812, 3813, 3814, 
3815, 3816, 3817, 3818, 3819, 3820, 3821, 3822, 3823, 3824, 
3825, 3826, 3827, 3828, 3829, 3830, 3831, 3832, 3833, 3834, 
3835, 3836, 3837, 3838, 3839, 3840, 3841, 3842, 3843, 3844, 
3845, 3846, 3847, 3848, 3849, 3850, 3851, 3852, 3853, 3854, 
3855, 3856, 3857, 3858, 3859, 3860, 3861, 3862, 3863, 3864, 
3865, 3866, 3867, 3868, 3869, 3870, 3871, 3872, 3873, 3874, 
3875, 3876, 3877, 3878, 3879, 3880, 3881, 3882, 3883, 3884, 
3885, 3886, 3887, 3888, 3889, 3890, 3891, 3892, 3893, 3894, 
3895, 3896, 3897, 3898, 3899, 3900, 3901, 3902, 3903, 3904, 
3905, 3906, 3907, 3908, 3909, 3910, 3911, 3912, 3913, 3914, 
3915, 3916, 3917, 3918, 3919, 3920, 3921, 3922, 3923, 3924, 
3925, 3926, 3927, 3928, 3929, 3930, 3931, 3932, 3933, 3934, 
3935, 3936, 3937, 3938, 3939, 3940, 3941, 3942, 3943, 3944, 
3945, 3946, 3947, 3948, 3949, 3950, 3951, 3952, 3953, 3954, 
3955, 3956, 3957, 3958, 3959, 3960, 3961, 3962, 3963, 3964, 
3965, 3966, 3967, 3968, 3969, 3970, 3971, 3972, 3973, 3974, 
3975, 3976, 3977, 3978, 3979, 3980, 3981, 3982, 3983, 3984, 
3985, 3986, 3987, 3988, 3989, 3990, 3991, 3992, 3993, 3994, 
3995, 3996, 3997, 3998, 3999, 4000, 4001, 4002, 4003, 4004, 
4005, 4006, 4007, 4008, 4009, 4010, 4011, 4012, 4013, 4014, 
4015, 4016, 4017, 4018, 4019, 4020, 4021, 4022, 4023, 4024, 
4025, 4026, 4027, 4028, 4029, 4030, 4031, 4032, 4033, 4034, 
4035, 4036, 4037, 4038, 4039, 4040, 4041, 4042, 4068, 4069, 
4070, 4071, 4072, 4073, 4074, 4075, 4076, 4077, 4078, 4079, 
4080, 4081, 4082, 4083, 4084, 4085, 4086, 4087, 4088, 4089, 
4090, 4091, 4092, 4093, 4094, 4095, 4096, 4097, 4098, 4099, 
4100, 4101, 4102, 4103, 4104, 4105, 4106, 4107, 4108, 4109, 
4110, 4111, 4112, 4113, 4114, 4115, 4116, 4117, 4118, 4119, 
4120, 4121, 4122, 4123, 4124, 4125, 4126, 4127, 4248, 4249, 
4250, 4251, 4252, 4253, 4254, 4255, 4256, 4257, 4258, 4259, 
4260, 4261, 4262, 4263, 4264, 4265, 4266, 4267, 4268, 4269, 
4270, 4271, 4272, 4273, 4274, 4275, 4276, 4277, 4278, 4279, 
4280, 4281, 4282, 4283, 4284, 4285, 4286, 4287, 4288, 4289, 
4290, 4291, 4292, 4293, 4294, 4295, 4296, 4297, 4298, 4299, 
4300, 4301, 4302, 4303, 4304, 4305, 4306, 4307, 4308, 4309, 
4310, 4311, 4312, 4313, 4314, 4315, 4316, 4317, 4318, 4319, 
4320, 4321, 4322, 4323, 4324, 4325, 4326, 4327, 4328, 4329, 
4330, 4331, 4332, 4333, 4334, 4335, 4336, 4337, 4338, 4339, 
4340, 4341, 4342, 4343, 4344, 4345, 4346, 4347, 4348, 4349, 
4350, 4351, 4352, 4353, 4354, 4355, 4356, 4357, 4358, 4359, 
4360, 4361, 4362, 4363, 4364, 4365, 4366, 4367, 4368, 4369, 
4370, 4371, 4372, 4373, 4374, 4375, 4376, 4377, 4378, 4379, 
4380, 4381, 4382, 4383, 4384, 4385, 4386, 4387, 4388, 4389, 
4390, 4391, 4392, 4393, 4394, 4395, 4396, 4397, 4398, 4399, 
4400, 4401, 4402, 4403, 4404, 4405, 4406, 4407, 4408, 4409, 
4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 4419, 
4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 4429, 
4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 4439, 
4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 4449, 
4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 4459, 
4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 4469, 
4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 4479, 
4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 4489, 
4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 4499, 
4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 4509, 
4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 4519, 
4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 4529, 
4530, 4531, 4532, 4533, 4534, 4535, 
*ELSET,ELSET=Ceramic_Bottom
4043, 4044, 4045, 4046, 4047, 4048, 4049, 4050, 4051, 4052, 
4053, 4054, 4055, 4056, 4057, 4058, 4059, 4060, 4061, 4062, 
4063, 4064, 4065, 4066, 4067, 4656, 4657, 4658, 4659, 4660, 
4661, 4662, 4663, 4664, 4665, 4666, 4667, 4668, 4669, 4670, 
4671, 4672, 4673, 4674, 4675, 4676, 4677, 4678, 4679, 4680, 
4681, 4682, 4683, 4684, 4685, 4686, 4687, 4688, 4689, 4690, 
4691, 4692, 4693, 4694, 4695, 4696, 4697, 4698, 4699, 4700, 
4701, 4702, 4703, 4704, 4705, 4706, 4707, 4708, 4709, 4710, 
4711, 4712, 4713, 4714, 4715, 4716, 4717, 4718, 4719, 4720, 
4721, 4722, 4723, 4724, 4725, 4726, 4727, 4728, 4729, 4730, 
4731, 4732, 4733, 4734, 4735, 4736, 4737, 4738, 4739, 4740, 
4741, 4742, 4743, 4744, 4745, 4746, 4747, 4748, 4749, 4750, 
4751, 4752, 4753, 4754, 4755, 4756, 4757, 4758, 4759, 4760, 
4761, 4762, 4763, 4764, 4765, 4766, 4767, 4768, 4769, 4770, 
4771, 4772, 4773, 4774, 4775, 4776, 4777, 4778, 4779, 4780, 
4781, 4782, 4783, 4784, 4785, 4786, 4787, 4788, 4789, 4790, 
4791, 4792, 4793, 4794, 4795, 4796, 4797, 4798, 4799, 4800, 
4801, 4802, 4803, 4804, 4805, 4806, 4807, 4808, 4809, 4810, 
4811, 4812, 4813, 4814, 4815, 4816, 4817, 4818, 4819, 4820, 
4821, 4822, 4823, 4824, 4825, 4826, 4827, 4828, 4829, 4830, 
4831, 4832, 4833, 4834, 4835, 4836, 4837, 4838, 4839, 4840, 
4841, 4842, 4843, 4844, 4845, 4846, 4847, 4848, 4849, 4850, 
4851, 4852, 4853, 4854, 4855, 4856, 4857, 4858, 4859, 4860, 
4861, 4862, 4863, 4864, 4865, 4866, 4867, 4868, 4869, 4870, 
4871, 4872, 4873, 4874, 4875, 4876, 4877, 4878, 4879, 4880, 
4881, 4882, 4883, 4884, 4885, 4886, 4887, 4888, 4889, 4890, 
4891, 4892, 4893, 4894, 4895, 4896, 4897, 4898, 4899, 4900, 
4901, 4902, 4903, 4904, 4905, 4906, 4907, 4908, 4909, 4910, 
4911, 4912, 4913, 4914, 4915, 4916, 4917, 4918, 4919, 4920, 
4921, 4922, 4923, 4924, 4925, 4926, 4927, 4928, 4929, 4930, 
4931, 4932, 4933, 4934, 4935, 4936, 4937, 4938, 4939, 4940, 
4941, 4942, 4943, 5081, 5082, 5083, 5084, 5085, 5086, 5087, 
5088, 5089, 5090, 5091, 5092, 5093, 5094, 5095, 5096, 5097, 
5098, 5099, 5100, 5101, 5102, 5103, 5104, 5105, 5106, 5107, 
5108, 5109, 5110, 5111, 5112, 5113, 5114, 5115, 5116, 5117, 
5118, 5119, 5120, 5121, 5122, 5123, 5124, 5125, 5126, 5127, 
5128, 5129, 5130, 5131, 5132, 5133, 5134, 5135, 5136, 5137, 
5138, 5139, 5140, 5141, 5142, 5143, 5144, 5145, 5146, 5147, 
5148, 5149, 5150, 5151, 5152, 5153, 5154, 5155, 5156, 5157, 
5158, 5159, 5160, 5161, 5162, 5163, 5164, 5165, 5166, 5167, 
5168, 5169, 5170, 5171, 5172, 5173, 5174, 5175, 5176, 5177, 
5178, 5179, 5180, 5181, 5182, 5183, 5184, 5185, 5186, 5187, 
5188, 5189, 5190, 5191, 5192, 5193, 5194, 5195, 5196, 5197, 
5198, 5199, 5200, 5201, 5202, 5203, 5204, 5205, 5206, 5207, 
5208, 5209, 5210, 5211, 5212, 5213, 5214, 5215, 5216, 5217, 
5218, 5219, 5220, 5221, 5222, 5223, 5224, 5225, 5226, 5227, 
5228, 5229, 5230, 5231, 5232, 5233, 5234, 5235, 5236, 5237, 
5238, 5239, 5240, 5241, 5242, 5243, 5244, 5245, 5246, 5247, 
5248, 5249, 5250, 5251, 5252, 5253, 5254, 5255, 5256, 5257, 
5258, 5259, 5260, 5261, 5262, 5263, 5264, 5265, 5266, 5267, 
5268, 5269, 5270, 5271, 5272, 5273, 5274, 5275, 5276, 5277, 
5278, 5279, 5280, 5281, 5282, 5283, 5284, 5285, 5286, 5287, 
5288, 5289, 5290, 5291, 5292, 5293, 5294, 5295, 5296, 5297, 
5298, 5299, 5300, 5301, 5302, 5303, 5304, 5305, 5306, 5307, 
5308, 5309, 5310, 5311, 5312, 5313, 5314, 5315, 5316, 5317, 
5318, 5319, 5320, 5321, 5322, 5323, 5324, 5325, 5326, 5327, 
5328, 5329, 5330, 5331, 5332, 5333, 5334, 5335, 5336, 5337, 
5338, 5339, 5340, 5341, 5342, 5343, 5344, 5345, 5346, 5347, 
5348, 5349, 5350, 5351, 5352, 5353, 5354, 5355, 5356, 5357, 
5358, 5359, 5360, 5361, 5362, 5363, 5364, 5365, 5366, 5367, 
5368, 
*ELSET,ELSET=Top_Semiconductors
1070, 1071, 1072, 1073, 1074, 1075, 1076, 1077, 1078, 1079, 
1080, 1081, 1082, 1083, 1084, 1085, 1086, 1087, 1088, 1089, 
1090, 1091, 1092, 1093, 1094, 1095, 1096, 1097, 1098, 1099, 
1100, 1101, 1102, 1103, 1104, 1105, 1106, 1107, 1108, 1109, 
1110, 1111, 1112, 1113, 1114, 1115, 1116, 1117, 1118, 1119, 
1120, 1121, 1122, 1123, 1124, 1125, 1126, 1127, 1128, 1129, 
1130, 1131, 1132, 1133, 1134, 1135, 1136, 1137, 1138, 1139, 
1140, 1141, 1142, 1143, 1144, 1145, 1146, 1147, 1148, 1149, 
1150, 1151, 1152, 1153, 1154, 1155, 1156, 1157, 1158, 1159, 
1160, 1161, 1162, 1163, 1164, 1165, 1166, 1167, 1168, 1169, 
1170, 1171, 1172, 1173, 1174, 1175, 1176, 1177, 1178, 1179, 
1180, 1181, 1182, 1183, 1184, 1185, 1186, 1187, 1188, 1189, 
1190, 1191, 1192, 1193, 1194, 1195, 1196, 1197, 1198, 1199, 
1200, 1201, 1202, 1203, 1204, 1205, 1206, 1207, 1208, 1209, 
1210, 1211, 1212, 1213, 1214, 1215, 1216, 1217, 1218, 1219, 
1220, 1221, 1222, 1223, 1224, 1225, 1226, 1227, 1228, 1229, 
1230, 1231, 1232, 1233, 1234, 1235, 1236, 1237, 1238, 1239, 
1240, 1241, 1242, 1243, 1244, 1245, 1246, 1247, 1248, 1249, 
1250, 1251, 1252, 1253, 1254, 1255, 1256, 1257, 1258, 1259, 
1260, 1261, 1262, 1263, 1264, 1265, 1266, 1267, 1268, 1269, 
1270, 1271, 1272, 1273, 1274, 1275, 1276, 1277, 1278, 1279, 
1280, 1281, 1282, 1283, 1284, 1285, 1286, 1287, 1288, 1289, 
1290, 1291, 1292, 1293, 1294, 1295, 1296, 1297, 1298, 1299, 
1300, 1301, 1302, 1303, 1304, 1305, 1306, 1307, 1308, 1309, 
1310, 1311, 1312, 1313, 1314, 1315, 1316, 1317, 1318, 1319, 
1320, 1321, 1322, 1323, 1324, 1325, 1326, 1327, 1328, 1329, 
1330, 1331, 1332, 1333, 1334, 1335, 1336, 1337, 1338, 1339, 
1340, 1341, 1342, 1343, 1344, 1345, 1346, 1347, 1348, 1349, 
1350, 1351, 1352, 1353, 1354, 1355, 1356, 1357, 2237, 2238, 
2239, 2240, 2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 
2249, 2250, 2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 
2259, 2260, 2261, 2262, 2263, 2264, 2265, 2266, 2267, 2268, 
2269, 2270, 2271, 2272, 2273, 2274, 2275, 2276, 2277, 2278, 
2279, 2280, 2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 
2289, 2290, 2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 
2299, 2300, 2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 
2309, 2310, 2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 
2319, 2320, 2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 
2329, 2330, 2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 
2339, 2340, 2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 
2349, 2350, 2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 
2359, 2360, 2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 
2369, 2370, 2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 
2379, 2380, 2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 
2389, 2390, 2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 
2399, 2400, 2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 
2409, 2410, 2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 
2419, 2420, 2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 
2429, 2430, 2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 
2439, 2440, 2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 
2449, 2450, 2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 
2459, 2460, 2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 
2469, 2470, 2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 
2479, 2480, 2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 
2489, 2490, 2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 
2499, 2500, 2501, 2502, 2503, 2504, 2505, 2506, 2507, 2508, 
2509, 2510, 2511, 2512, 2513, 2514, 2515, 2516, 2517, 2518, 
2519, 2520, 2521, 2522, 2523, 2524, 
*ELSET,ELSET=top
3755, 3756, 3757, 3758, 3759, 3760, 3761, 3762, 3763, 3764, 
3765, 3766, 3767, 3768, 3769, 3770, 3771, 3772, 3773, 3774, 
3775, 3776, 3777, 3778, 3779, 3780, 3781, 3782, 3783, 3784, 
3785, 3786, 3787, 3788, 3789, 3790, 3791, 3792, 3793, 3794, 
3795, 3796, 3797, 3798, 3799, 3800, 3801, 3802, 3803, 3804, 
3805, 3806, 3807, 3808, 3809, 3810, 3811, 3812, 3813, 3814, 
3815, 3816, 3817, 3818, 3819, 3820, 3821, 3822, 3823, 3824, 
3825, 3826, 3827, 3828, 3829, 3830, 3831, 3832, 3833, 3834, 
3835, 3836, 3837, 3838, 3839, 3840, 3841, 3842, 3843, 3844, 
3845, 3846, 3847, 3848, 3849, 3850, 3851, 3852, 3853, 3854, 
3855, 3856, 3857, 3858, 3859, 3860, 3861, 3862, 3863, 3864, 
3865, 3866, 3867, 3868, 3869, 3870, 3871, 3872, 3873, 3874, 
3875, 3876, 3877, 3878, 3879, 3880, 3881, 3882, 3883, 3884, 
3885, 3886, 3887, 3888, 3889, 3890, 3891, 3892, 3893, 3894, 
3895, 3896, 3897, 3898, 3899, 3900, 3901, 3902, 3903, 3904, 
3905, 3906, 3907, 3908, 3909, 3910, 3911, 3912, 3913, 3914, 
3915, 3916, 3917, 3918, 3919, 3920, 3921, 3922, 3923, 3924, 
3925, 3926, 3927, 3928, 3929, 3930, 3931, 3932, 3933, 3934, 
3935, 3936, 3937, 3938, 3939, 3940, 3941, 3942, 3943, 3944, 
3945, 3946, 3947, 3948, 3949, 3950, 3951, 3952, 3953, 3954, 
3955, 3956, 3957, 3958, 3959, 3960, 3961, 3962, 3963, 3964, 
3965, 3966, 3967, 3968, 3969, 3970, 3971, 3972, 3973, 3974, 
3975, 3976, 3977, 3978, 3979, 3980, 3981, 3982, 3983, 3984, 
3985, 3986, 3987, 3988, 3989, 3990, 3991, 3992, 3993, 3994, 
3995, 3996, 3997, 3998, 3999, 4000, 4001, 4002, 4003, 4004, 
4005, 4006, 4007, 4008, 4009, 4010, 4011, 4012, 4013, 4014, 
4015, 4016, 4017, 4018, 4019, 4020, 4021, 4022, 4023, 4024, 
4025, 4026, 4027, 4028, 4029, 4030, 4031, 4032, 4033, 4034, 
4035, 4036, 4037, 4038, 4039, 4040, 4041, 4042, 4068, 4069, 
4070, 4071, 4072, 4073, 4074, 4075, 4076, 4077, 4078, 4079, 
4080, 4081, 4082, 4083, 4084, 4085, 4086, 4087, 4088, 4089, 
4090, 4091, 4092, 4093, 4094, 4095, 4096, 4097, 4098, 4099, 
4100, 4101, 4102, 4103, 4104, 4105, 4106, 4107, 4108, 4109, 
4110, 4111, 4112, 4113, 4114, 4115, 4116, 4117, 4118, 4119, 
4120, 4121, 4122, 4123, 4124, 4125, 4126, 4127, 4248, 4249, 
4250, 4251, 4252, 4253, 4254, 4255, 4256, 4257, 4258, 4259, 
4260, 4261, 4262, 4263, 4264, 4265, 4266, 4267, 4268, 4269, 
4270, 4271, 4272, 4273, 4274, 4275, 4276, 4277, 4278, 4279, 
4280, 4281, 4282, 4283, 4284, 4285, 4286, 4287, 4288, 4289, 
4290, 4291, 4292, 4293, 4294, 4295, 4296, 4297, 4298, 4299, 
4300, 4301, 4302, 4303, 4304, 4305, 4306, 4307, 4308, 4309, 
4310, 4311, 4312, 4313, 4314, 4315, 4316, 4317, 4318, 4319, 
4320, 4321, 4322, 4323, 4324, 4325, 4326, 4327, 4328, 4329, 
4330, 4331, 4332, 4333, 4334, 4335, 4336, 4337, 4338, 4339, 
4340, 4341, 4342, 4343, 4344, 4345, 4346, 4347, 4348, 4349, 
4350, 4351, 4352, 4353, 4354, 4355, 4356, 4357, 4358, 4359, 
4360, 4361, 4362, 4363, 4364, 4365, 4366, 4367, 4368, 4369, 
4370, 4371, 4372, 4373, 4374, 4375, 4376, 4377, 4378, 4379, 
4380, 4381, 4382, 4383, 4384, 4385, 4386, 4387, 4388, 4389, 
4390, 4391, 4392, 4393, 4394, 4395, 4396, 4397, 4398, 4399, 
4400, 4401, 4402, 4403, 4404, 4405, 4406, 4407, 4408, 4409, 
4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 4419, 
4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 4429, 
4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 4439, 
4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 4449, 
4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 4459, 
4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 4469, 
4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 4479, 
4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 4489, 
4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 4499, 
4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 4509, 
4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 4519, 
4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 4529, 
4530, 4531, 4532, 4533, 4534, 4535, 
*ELSET,ELSET=bottom
4656, 4657, 4658, 4659, 4660, 4661, 4662, 4663, 4664, 4665, 
4666, 4667, 4668, 4669, 4670, 4671, 4672, 4673, 4674, 4675, 
4676, 4677, 4678, 4679, 4680, 4681, 4682, 4683, 4684, 4685, 
4686, 4687, 4688, 4689, 4690, 4691, 4692, 4693, 4694, 4695, 
4696, 4697, 4698, 4699, 4700, 4701, 4702, 4703, 4704, 4705, 
4706, 4707, 4708, 4709, 4710, 4711, 4712, 4713, 4714, 4715, 
4716, 4717, 4718, 4719, 4720, 4721, 4722, 4723, 4724, 4725, 
4726, 4727, 4728, 4729, 4730, 4731, 4732, 4733, 4734, 4735, 
4736, 4737, 4738, 4739, 4740, 4741, 4742, 4743, 4744, 4745, 
4746, 4747, 4748, 4749, 4750, 4751, 4752, 4753, 4754, 4755, 
4756, 4757, 4758, 4759, 4760, 4761, 4762, 4763, 4764, 4765, 
4766, 4767, 4768, 4769, 4770, 4771, 4772, 4773, 4774, 4775, 
4776, 4777, 4778, 4779, 4780, 4781, 4782, 4783, 4784, 4785, 
4786, 4787, 4788, 4789, 4790, 4791, 4792, 4793, 4794, 4795, 
4796, 4797, 4798, 4799, 4800, 4801, 4802, 4803, 4804, 4805, 
4806, 4807, 4808, 4809, 4810, 4811, 4812, 4813, 4814, 4815, 
4816, 4817, 4818, 4819, 4820, 4821, 4822, 4823, 4824, 4825, 
4826, 4827, 4828, 4829, 4830, 4831, 4832, 4833, 4834, 4835, 
4836, 4837, 4838, 4839, 4840, 4841, 4842, 4843, 4844, 4845, 
4846, 4847, 4848, 4849, 4850, 4851, 4852, 4853, 4854, 4855, 
4856, 4857, 4858, 4859, 4860, 4861, 4862, 4863, 4864, 4865, 
4866, 4867, 4868, 4869, 4870, 4871, 4872, 4873, 4874, 4875, 
4876, 4877, 4878, 4879, 4880, 4881, 4882, 4883, 4884, 4885, 
4886, 4887, 4888, 4889, 4890, 4891, 4892, 4893, 4894, 4895, 
4896, 4897, 4898, 4899, 4900, 4901, 4902, 4903, 4904, 4905, 
4906, 4907, 4908, 4909, 4910, 4911, 4912, 4913, 4914, 4915, 
4916, 4917, 4918, 4919, 4920, 4921, 4922, 4923, 4924, 4925, 
4926, 4927, 4928, 4929, 4930, 4931, 4932, 4933, 4934, 4935, 
4936, 4937, 4938, 4939, 4940, 4941, 4942, 4943, 4949, 4950, 
4951, 4952, 4953, 4954, 4955, 4956, 4957, 4958, 4959, 4960, 
5081, 5082, 5083, 5084, 5085, 5086, 5087, 5088, 5089, 5090, 
5091, 5092, 5093, 5094, 5095, 5096, 5097, 5098, 5099, 5100, 
5101, 5102, 5103, 5104, 5105, 5106, 5107, 5108, 5109, 5110, 
5111, 5112, 5113, 5114, 5115, 5116, 5117, 5118, 5119, 5120, 
5121, 5122, 5123, 5124, 5125, 5126, 5127, 5128, 5129, 5130, 
5131, 5132, 5133, 5134, 5135, 5136, 5137, 5138, 5139, 5140, 
5141, 5142, 5143, 5144, 5145, 5146, 5147, 5148, 5149, 5150, 
5151, 5152, 5153, 5154, 5155, 5156, 5157, 5158, 5159, 5160, 
5161, 5162, 5163, 5164, 5165, 5166, 5167, 5168, 5169, 5170, 
5171, 5172, 5173, 5174, 5175, 5176, 5177, 5178, 5179, 5180, 
5181, 5182, 5183, 5184, 5185, 5186, 5187, 5188, 5189, 5190, 
5191, 5192, 5193, 5194, 5195, 5196, 5197, 5198, 5199, 5200, 
5201, 5202, 5203, 5204, 5205, 5206, 5207, 5208, 5209, 5210, 
5211, 5212, 5213, 5214, 5215, 5216, 5217, 5218, 5219, 5220, 
5221, 5222, 5223, 5224, 5225, 5226, 5227, 5228, 5229, 5230, 
5231, 5232, 5233, 5234, 5235, 5236, 5237, 5238, 5239, 5240, 
5241, 5242, 5243, 5244, 5245, 5246, 5247, 5248, 5249, 5250, 
5251, 5252, 5253, 5254, 5255, 5256, 5257, 5258, 5259, 5260, 
5261, 5262, 5263, 5264, 5265, 5266, 5267, 5268, 5269, 5270, 
5271, 5272, 5273, 5274, 5275, 5276, 5277, 5278, 5279, 5280, 
5281, 5282, 5283, 5284, 5285, 5286, 5287, 5288, 5289, 5290, 
5291, 5292, 5293, 5294, 5295, 5296, 5297, 5298, 5299, 5300, 
5301, 5302, 5303, 5304, 5305, 5306, 5307, 5308, 5309, 5310, 
5311, 5312, 5313, 5314, 5315, 5316, 5317, 5318, 5319, 5320, 
5321, 5322, 5323, 5324, 5325, 5326, 5327, 5328, 5329, 5330, 
5331, 5332, 5333, 5334, 5335, 5336, 5337, 5338, 5339, 5340, 
5341, 5342, 5343, 5344, 5345, 5346, 5347, 5348, 5349, 5350, 
5351, 5352, 5353, 5354, 5355, 5356, 5357, 5358, 5359, 5360, 
5361, 5362, 5363, 5364, 5365, 5366, 5367, 5368, 5374, 5375, 
5376, 5377, 5378, 5379, 5380, 5381, 5382, 5383, 5384, 5385, 
*ELSET,ELSET=symmetry
398, 399, 400, 401, 402, 403, 404, 405, 406, 407, 
408, 409, 410, 411, 412, 413, 414, 415, 416, 417, 
418, 419, 420, 421, 422, 423, 424, 425, 426, 427, 
428, 429, 430, 431, 432, 433, 434, 435, 436, 437, 
438, 439, 440, 441, 442, 443, 444, 445, 446, 447, 
448, 449, 450, 451, 452, 453, 454, 455, 456, 457, 
458, 459, 460, 461, 462, 463, 464, 465, 466, 467, 
468, 469, 470, 471, 472, 473, 474, 475, 476, 477, 
478, 479, 480, 481, 482, 483, 484, 485, 486, 487, 
488, 489, 490, 491, 492, 493, 494, 495, 496, 497, 
498, 499, 500, 501, 502, 503, 504, 505, 506, 507, 
508, 509, 510, 511, 512, 513, 514, 515, 516, 517, 
518, 519, 520, 521, 522, 523, 524, 525, 526, 527, 
528, 529, 530, 531, 532, 533, 534, 535, 536, 537, 
538, 539, 540, 541, 542, 543, 544, 545, 546, 547, 
548, 549, 550, 551, 552, 553, 554, 555, 556, 557, 
558, 559, 560, 561, 562, 563, 564, 565, 566, 567, 
568, 569, 570, 571, 572, 573, 574, 575, 576, 577, 
578, 579, 580, 581, 582, 583, 584, 585, 586, 587, 
588, 589, 590, 591, 592, 593, 594, 595, 596, 597, 
598, 599, 600, 601, 602, 603, 604, 605, 606, 607, 
608, 609, 610, 611, 612, 613, 614, 615, 616, 617, 
618, 619, 620, 621, 622, 623, 624, 625, 626, 627, 
628, 629, 630, 631, 632, 633, 634, 635, 636, 637, 
638, 639, 640, 641, 642, 643, 644, 645, 646, 647, 
648, 649, 650, 651, 652, 653, 654, 655, 656, 657, 
658, 659, 660, 661, 662, 663, 664, 665, 666, 667, 
668, 669, 670, 671, 672, 673, 674, 675, 676, 677, 
678, 679, 680, 681, 682, 683, 684, 685, 686, 687, 
688, 689, 690, 691, 692, 693, 694, 695, 696, 697, 
698, 699, 700, 701, 702, 703, 704, 705, 706, 707, 
708, 709, 710, 711, 712, 713, 714, 715, 716, 717, 
718, 719, 720, 721, 722, 723, 724, 725, 726, 727, 
728, 729, 730, 731, 732, 733, 734, 735, 736, 737, 
738, 739, 740, 741, 742, 743, 744, 745, 746, 747, 
748, 749, 750, 751, 752, 753, 754, 755, 756, 757, 
758, 759, 760, 761, 762, 763, 764, 765, 766, 767, 
768, 769, 770, 771, 772, 773, 774, 775, 776, 777, 
778, 779, 780, 781, 782, 783, 784, 785, 786, 787, 
788, 789, 790, 791, 792, 793, 794, 795, 796, 797, 
798, 799, 800, 801, 802, 803, 804, 805, 806, 807, 
808, 809, 810, 811, 812, 813, 814, 815, 816, 817, 
818, 819, 820, 821, 822, 823, 824, 825, 826, 827, 
828, 829, 830, 831, 832, 833, 834, 835, 836, 837, 
838, 839, 840, 841, 842, 843, 844, 845, 846, 847, 
848, 849, 850, 851, 852, 853, 854, 855, 856, 857, 
858, 859, 860, 861, 862, 863, 864, 865, 866, 867, 
868, 869, 870, 871, 872, 873, 874, 875, 876, 877, 
878, 879, 880, 881, 882, 883, 884, 885, 886, 887, 
888, 889, 890, 891, 892, 893, 894, 895, 896, 897, 
898, 899, 900, 901, 902, 903, 904, 905, 906, 907, 
908, 909, 910, 911, 912, 913, 914, 915, 916, 917, 
918, 919, 920, 921, 922, 923, 924, 925, 926, 927, 
928, 929, 930, 931, 932, 933, 934, 935, 936, 937, 
938, 939, 940, 941, 942, 943, 944, 945, 946, 947, 
948, 949, 950, 951, 952, 953, 954, 955, 956, 957, 
958, 959, 960, 961, 962, 963, 964, 965, 966, 967, 
968, 969, 970, 971, 972, 973, 974, 975, 976, 977, 
978, 979, 980, 981, 982, 983, 984, 985, 986, 987, 
988, 989, 990, 991, 992, 993, 994, 995, 996, 997, 
998, 999, 1000, 1001, 1002, 1003, 1004, 1005, 1006, 1007, 
1008, 1009, 1010, 1011, 1012, 1013, 1014, 1015, 1016, 1017, 
1018, 1019, 1020, 1021, 1022, 1023, 1024, 1025, 1026, 1027, 
1028, 1029, 1030, 1031, 1032, 1033, 1034, 1035, 1036, 1037, 
1038, 1039, 1040, 1041, 1042, 1043, 1044, 1045, 1046, 1047, 
1048, 1049, 1050, 1051, 1052, 1053, 1054, 1055, 1056, 1057, 
1058, 1059, 1060, 1061, 1062, 1063, 1064, 1065, 1066, 1067, 
1068, 1069, 1358, 1359, 1360, 1361, 1362, 1363, 1364, 1365, 
1366, 1367, 1368, 1369, 1370, 1371, 1372, 1373, 1374, 1375, 
1376, 1377, 1378, 1379, 1380, 1381, 1382, 1383, 1384, 1385, 
1386, 1387, 1388, 1389, 1390, 1391, 1392, 1393, 1394, 1395, 
1396, 1397, 1398, 1399, 1400, 1401, 1402, 1403, 1404, 1405, 
1406, 1407, 1408, 1409, 1410, 1411, 1412, 1413, 1414, 1415, 
1416, 1417, 1418, 1419, 1420, 1421, 1422, 1423, 1424, 1425, 
1426, 1427, 1428, 1429, 1430, 1431, 1432, 1433, 1434, 1435, 
1436, 1437, 1438, 1439, 1440, 1441, 1442, 1443, 1444, 1445, 
1446, 1447, 1448, 1449, 1450, 1451, 1452, 1453, 1778, 1779, 
1780, 1781, 1782, 1783, 1784, 1785, 1786, 1787, 1788, 1789, 
1790, 1791, 1792, 1853, 1854, 1855, 1856, 1857, 1858, 1859, 
1860, 1861, 1862, 1863, 1864, 1865, 1866, 1867, 1868, 1869, 
1870, 1871, 1872, 1873, 1874, 1875, 1876, 1877, 1878, 1879, 
1880, 1881, 1882, 1883, 1884, 1885, 1886, 1887, 1888, 1889, 
1890, 1891, 1892, 1893, 1894, 1895, 1896, 1897, 1898, 1899, 
1900, 1901, 1902, 1903, 1904, 1905, 1906, 1907, 1908, 1909, 
1910, 1911, 1912, 1913, 1914, 1915, 1916, 1917, 1918, 1919, 
1920, 1921, 1922, 1923, 1924, 2213, 2214, 2215, 2216, 2217, 
2218, 2219, 2220, 2221, 2222, 2223, 2224, 2225, 2226, 2227, 
2228, 2229, 2230, 2231, 2232, 2233, 2234, 2235, 2236, 2525, 
2526, 2527, 2528, 2529, 2530, 2531, 2532, 2533, 2534, 2535, 
2536, 2537, 2538, 2539, 2540, 2541, 2542, 2543, 2544, 2545, 
2546, 2547, 2548, 2549, 2550, 2551, 2552, 2553, 2554, 2555, 
2556, 2557, 2558, 2559, 2560, 2561, 2562, 2563, 2564, 2565, 
2566, 2567, 2568, 2569, 2570, 2571, 2572, 2573, 2574, 2575, 
2576, 2577, 2578, 2579, 2580, 2581, 2582, 2583, 2584, 2585, 
2586, 2587, 2588, 2589, 2590, 2591, 2592, 2593, 2594, 2595, 
2596, 2597, 2598, 2599, 2600, 2601, 2602, 2603, 2604, 2605, 
2606, 2607, 2608, 2609, 2610, 2611, 2612, 2613, 2614, 2615, 
2616, 2617, 2618, 2619, 2620, 2621, 2622, 2623, 2624, 2625, 
2626, 2627, 2628, 2629, 2630, 2631, 2632, 2633, 2634, 2635, 
2636, 2637, 2638, 2639, 2640, 2641, 2642, 2643, 2644, 2645, 
2646, 2647, 2648, 2649, 2650, 2651, 2652, 2653, 2654, 2655, 
2656, 2657, 2658, 2659, 2660, 2661, 2662, 2663, 2664, 2665, 
2666, 2667, 2668, 2669, 2670, 2671, 2672, 2673, 2674, 2675, 
2676, 2677, 2678, 2679, 2680, 2681, 2682, 2683, 2684, 2685, 
2686, 2687, 2688, 2689, 2690, 2691, 2692, 2693, 2694, 2695, 
2696, 2697, 2698, 2699, 2700, 2701, 2702, 2703, 2704, 2705, 
2706, 2707, 2708, 2709, 2710, 2711, 2712, 2713, 2714, 2715, 
2716, 2717, 2718, 2719, 2720, 2721, 2722, 2723, 2724, 2725, 
2726, 2727, 2728, 2729, 2730, 2731, 2732, 2733, 2734, 2735, 
2736, 2737, 2738, 2739, 2740, 2741, 2742, 2743, 2744, 2745, 
2746, 2747, 2748, 2749, 2750, 2751, 2752, 2753, 2754, 2755, 
2756, 2757, 2758, 2759, 2760, 2761, 2762, 2763, 2764, 2765, 
2766, 2767, 2768, 2769, 2770, 2771, 2772, 2773, 2774, 2775, 
2776, 2777, 2778, 2779, 2780, 2781, 2782, 2783, 2784, 2785, 
2786, 2787, 2788, 2789, 2790, 2791, 2792, 2793, 2794, 2795, 
2796, 2797, 2798, 2799, 2800, 2801, 2802, 2803, 2804, 2805, 
2806, 2807, 2808, 2809, 2810, 2811, 2812, 2813, 2814, 2815, 
2816, 2817, 2818, 2819, 2820, 2821, 2822, 2823, 2824, 2825, 
2826, 2827, 2828, 2829, 2830, 2831, 2832, 2833, 2834, 2835, 
2836, 2837, 2838, 2839, 2840, 2841, 2842, 2843, 2844, 2845, 
2846, 2847, 2848, 2849, 2850, 2851, 2852, 2853, 2854, 2855, 
2856, 2857, 2858, 2859, 2860, 2861, 2862, 2863, 2864, 2865, 
2866, 2867, 2868, 2869, 2870, 2871, 2872, 2873, 2874, 2875, 
2876, 2877, 2878, 2879, 2880, 2881, 2882, 2883, 2884, 2885, 
2886, 2887, 2888, 2889, 2890, 2891, 2892, 2893, 2894, 2895, 
2896, 2897, 2898, 2899, 2900, 2901, 2902, 2903, 2904, 2905, 
2906, 2907, 2908, 2909, 2910, 2911, 2912, 2913, 2914, 2915, 
2916, 2917, 2918, 2919, 2920, 2921, 2922, 2923, 2924, 2925, 
2926, 2927, 2928, 2929, 2930, 2931, 2932, 2933, 2934, 2935, 
2936, 2937, 2938, 2939, 2940, 2941, 2942, 2943, 2944, 2945, 
2946, 2947, 2948, 2949, 2950, 2951, 2952, 2953, 2954, 2955, 
2956, 2957, 2958, 2959, 2960, 2961, 2962, 2963, 2964, 2965, 
2966, 2967, 2968, 2969, 2970, 2971, 2972, 2973, 2974, 2975, 
2976, 2977, 2978, 2979, 2980, 2981, 2982, 2983, 2984, 2985, 
2986, 2987, 2988, 2989, 2990, 2991, 2992, 2993, 2994, 2995, 
2996, 2997, 2998, 2999, 3000, 3001, 3002, 3003, 3004, 3005, 
3006, 3007, 3008, 3009, 3010, 3011, 3012, 3013, 3014, 3015, 
3016, 3017, 3018, 3019, 3020, 3021, 3022, 3023, 3024, 3025, 
3026, 3027, 3028, 3029, 3030, 3031, 3032, 3033, 3034, 3035, 
3036, 3037, 3038, 3039, 3040, 3041, 3042, 3043, 3044, 3045, 
3046, 3047, 3048, 3049, 3050, 3051, 3052, 3053, 3054, 3055, 
3056, 3057, 3058, 3059, 3060, 3061, 3062, 3063, 3064, 3065, 
3066, 3067, 3068, 3069, 3070, 3071, 3072, 3073, 3074, 3075, 
3076, 3077, 3078, 3079, 3080, 3081, 3082, 3083, 3084, 3085, 
3086, 3087, 3088, 3089, 3090, 3091, 3092, 3093, 3094, 3095, 
3096, 3097, 3098, 3099, 3100, 3101, 3102, 3103, 3104, 3105, 
3106, 3107, 3108, 3109, 3110, 3111, 3112, 3113, 3114, 3115, 
3116, 3117, 3118, 3119, 3120, 3121, 3122, 3123, 3124, 3125, 
3126, 3127, 3128, 3129, 3130, 3131, 3132, 3133, 3134, 3135, 
3136, 3137, 3138, 3139, 3140, 3141, 3142, 3143, 3144, 3145, 
3146, 3147, 3148, 3149, 3150, 3151, 3152, 3153, 3154, 3155, 
3156, 3157, 3158, 3159, 3160, 3161, 3162, 3163, 3164, 3165, 
3166, 3167, 3168, 3169, 3170, 3171, 3172, 3173, 3174, 3175, 
3176, 3177, 3178, 3179, 3180, 3181, 3182, 3183, 3184, 3185, 
3186, 3187, 3188, 3189, 3190, 3191, 3192, 3193, 3194, 3195, 
3196, 3485, 3486, 3487, 3548, 3549, 3550, 3587, 3588, 3589, 
3590, 3591, 3592, 3593, 3594, 3595, 3596, 3597, 3598, 3599, 
3600, 3601, 3602, 3603, 3604, 3605, 3606, 3607, 3608, 3609, 
3610, 3611, 3612, 3613, 3614, 3615, 3616, 3617, 3618, 3619, 
3620, 3621, 3622, 3623, 3624, 3625, 3626, 3627, 3628, 3629, 
3630, 3631, 3632, 3633, 3634, 3635, 3636, 3637, 3638, 3639, 
3640, 3641, 3642, 3643, 3644, 3645, 3646, 3647, 3648, 3649, 
3650, 3651, 3652, 3653, 3654, 3655, 3656, 3657, 3658, 3659, 
3660, 3661, 3662, 3663, 3664, 3665, 3666, 3667, 3668, 3669, 
3670, 3671, 3672, 3673, 3674, 3675, 3676, 3677, 3678, 3679, 
3680, 3681, 3682, 3683, 3684, 3685, 3686, 3687, 3688, 3689, 
3690, 3691, 3692, 3693, 3694, 3695, 3696, 3697, 3698, 3699, 
3700, 3701, 3702, 3703, 3704, 3705, 3706, 3707, 3708, 3709, 
3710, 3711, 3712, 3713, 3714, 3715, 3716, 3717, 3718, 3719, 
3720, 3721, 3722, 3723, 3724, 3725, 3726, 3727, 3728, 3729, 
3730, 3731, 3732, 3733, 3734, 3735, 3736, 3737, 3738, 3739, 
3740, 3741, 3742, 3743, 3744, 3745, 3746, 3747, 3748, 3749, 
3750, 3751, 3752, 3753, 3754, 4043, 4044, 4045, 4046, 4047, 
4048, 4049, 4050, 4051, 4052, 4053, 4054, 4055, 4056, 4057, 
4058, 4059, 4060, 4061, 4062, 4063, 4064, 4065, 4066, 4067, 
4128, 4129, 4130, 4131, 4132, 4133, 4134, 4135, 4136, 4137, 
4138, 4139, 4140, 4141, 4142, 4143, 4144, 4145, 4146, 4147, 
4148, 4149, 4150, 4151, 4152, 4153, 4154, 4155, 4156, 4157, 
4158, 4159, 4160, 4161, 4162, 4163, 4164, 4165, 4166, 4167, 
4168, 4169, 4170, 4171, 4172, 4173, 4174, 4175, 4176, 4177, 
4178, 4179, 4180, 4181, 4182, 4183, 4184, 4185, 4186, 4187, 
4188, 4189, 4190, 4191, 4192, 4193, 4194, 4195, 4196, 4197, 
4198, 4199, 4200, 4201, 4202, 4203, 4204, 4205, 4206, 4207, 
4208, 4209, 4210, 4211, 4212, 4213, 4214, 4215, 4216, 4217, 
4218, 4219, 4220, 4221, 4222, 4223, 4224, 4225, 4226, 4227, 
4228, 4229, 4230, 4231, 4232, 4233, 4234, 4235, 4236, 4237, 
4238, 4239, 4240, 4241, 4242, 4243, 4244, 4245, 4246, 4247, 
4536, 4537, 4538, 4539, 4540, 4541, 4542, 4543, 4544, 4545, 
4546, 4547, 4548, 4549, 4550, 4551, 4552, 4553, 4554, 4555, 
4556, 4557, 4558, 4559, 4560, 4561, 4562, 4563, 4564, 4565, 
4566, 4567, 4568, 4569, 4570, 4571, 4572, 4573, 4574, 4575, 
4576, 4577, 4578, 4579, 4580, 4581, 4582, 4583, 4584, 4585, 
4586, 4587, 4588, 4589, 4590, 4591, 4592, 4593, 4594, 4595, 
4596, 4597, 4598, 4599, 4600, 4601, 4602, 4603, 4604, 4605, 
4606, 4607, 4608, 4609, 4610, 4611, 4612, 4613, 4614, 4615, 
4616, 4617, 4618, 4619, 4620, 4621, 4622, 4623, 4624, 4625, 
4626, 4627, 4628, 4629, 4630, 4631, 4632, 4633, 4634, 4635, 
4636, 4637, 4638, 4639, 4640, 4641, 4642, 4643, 4644, 4645, 
4646, 4647, 4648, 4649, 4650, 4651, 4652, 4653, 4654, 4655, 
4944, 4945, 4946, 4947, 4948, 4961, 4962, 4963, 4964, 4965, 
4966, 4967, 4968, 4969, 4970, 4971, 4972, 4973, 4974, 4975, 
4976, 4977, 4978, 4979, 4980, 4981, 4982, 4983, 4984, 4985, 
4986, 4987, 4988, 4989, 4990, 4991, 4992, 4993, 4994, 4995, 
4996, 4997, 4998, 4999, 5000, 5001, 5002, 5003, 5004, 5005, 
5006, 5007, 5008, 5009, 5010, 5011, 5012, 5013, 5014, 5015, 
5016, 5017, 5018, 5019, 5020, 5021, 5022, 5023, 5024, 5025, 
5026, 5027, 5028, 5029, 5030, 5031, 5032, 5033, 5034, 5035, 
5036, 5037, 5038, 5039, 5040, 5041, 5042, 5043, 5044, 5045, 
5046, 5047, 5048, 5049, 5050, 5051, 5052, 5053, 5054, 5055, 
5056, 5057, 5058, 5059, 5060, 5061, 5062, 5063, 5064, 5065, 
5066, 5067, 5068, 5069, 5070, 5071, 5072, 5073, 5074, 5075, 
5076, 5077, 5078, 5079, 5080, 5369, 5370, 5371, 5372, 5373, 
*ELSET,ELSET=Ceramic_Contact
110, 111, 112, 113, 114, 115, 116, 117, 118, 119, 
120, 121, 122, 123, 124, 125, 126, 127, 128, 129, 
130, 131, 132, 133, 134, 135, 136, 137, 138, 139, 
140, 141, 142, 143, 144, 145, 146, 147, 148, 149, 
150, 151, 152, 153, 154, 155, 156, 157, 158, 159, 
160, 161, 162, 163, 164, 165, 166, 167, 168, 169, 
170, 171, 172, 173, 174, 175, 176, 177, 178, 179, 
180, 181, 182, 183, 184, 185, 186, 187, 188, 189, 
190, 191, 192, 193, 194, 195, 196, 197, 198, 199, 
200, 201, 202, 203, 204, 205, 206, 207, 208, 209, 
210, 211, 212, 213, 214, 215, 216, 217, 218, 219, 
220, 221, 222, 223, 224, 225, 226, 227, 228, 229, 
230, 231, 232, 233, 234, 235, 236, 237, 238, 239, 
240, 241, 242, 243, 244, 245, 246, 247, 248, 249, 
250, 251, 252, 253, 254, 255, 256, 257, 258, 259, 
260, 261, 262, 263, 264, 265, 266, 267, 268, 269, 
270, 271, 272, 273, 274, 275, 276, 277, 278, 279, 
280, 281, 282, 283, 284, 285, 286, 287, 288, 289, 
290, 291, 292, 293, 294, 295, 296, 297, 298, 299, 
300, 301, 302, 303, 304, 305, 306, 307, 308, 309, 
310, 311, 312, 313, 314, 315, 316, 317, 318, 319, 
320, 321, 322, 323, 324, 325, 326, 327, 328, 329, 
330, 331, 332, 333, 334, 335, 336, 337, 338, 339, 
340, 341, 342, 343, 344, 345, 346, 347, 348, 349, 
350, 351, 352, 353, 354, 355, 356, 357, 358, 359, 
360, 361, 362, 363, 364, 365, 366, 367, 368, 369, 
370, 371, 372, 373, 374, 375, 376, 377, 378, 379, 
380, 381, 382, 383, 384, 385, 386, 387, 388, 389, 
390, 391, 392, 393, 394, 395, 396, 397, 1490, 1491, 
1492, 1493, 1494, 1495, 1496, 1497, 1498, 1499, 1500, 1501, 
1502, 1503, 1504, 1505, 1506, 1507, 1508, 1509, 1510, 1511, 
1512, 1513, 1514, 1515, 1516, 1517, 1518, 1519, 1520, 1521, 
1522, 1523, 1524, 1525, 1526, 1527, 1528, 1529, 1530, 1531, 
1532, 1533, 1534, 1535, 1536, 1537, 1538, 1539, 1540, 1541, 
1542, 1543, 1544, 1545, 1546, 1547, 1548, 1549, 1550, 1551, 
1552, 1553, 1554, 1555, 1556, 1557, 1558, 1559, 1560, 1561, 
1562, 1563, 1564, 1565, 1566, 1567, 1568, 1569, 1570, 1571, 
1572, 1573, 1574, 1575, 1576, 1577, 1578, 1579, 1580, 1581, 
1582, 1583, 1584, 1585, 1586, 1587, 1588, 1589, 1590, 1591, 
1592, 1593, 1594, 1595, 1596, 1597, 1598, 1599, 1600, 1601, 
1602, 1603, 1604, 1605, 1606, 1607, 1608, 1609, 1610, 1611, 
1612, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 1621, 
1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 1631, 
1632, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 1641, 
1642, 1643, 1644, 1645, 1646, 1647, 1648, 1649, 1650, 1651, 
1652, 1653, 1654, 1655, 1656, 1657, 1658, 1659, 1660, 1661, 
1662, 1663, 1664, 1665, 1666, 1667, 1668, 1669, 1670, 1671, 
1672, 1673, 1674, 1675, 1676, 1677, 1678, 1679, 1680, 1681, 
1682, 1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 1691, 
1692, 1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 1701, 
1702, 1703, 1704, 1705, 1706, 1707, 1708, 1709, 1710, 1711, 
1712, 1713, 1714, 1715, 1716, 1717, 1718, 1719, 1720, 1721, 
1722, 1723, 1724, 1725, 1726, 1727, 1728, 1729, 1730, 1731, 
1732, 1733, 1734, 1735, 1736, 1737, 1738, 1739, 1740, 1741, 
1742, 1743, 1744, 1745, 1746, 1747, 1748, 1749, 1750, 1751, 
1752, 1753, 1754, 1755, 1756, 1757, 1758, 1759, 1760, 1761, 
1762, 1763, 1764, 1765, 1766, 1767, 1768, 1769, 1770, 1771, 
1772, 1773, 1774, 1775, 1776, 1777, 1925, 1926, 1927, 1928, 
1929, 1930, 1931, 1932, 1933, 1934, 1935, 1936, 1937, 1938, 
1939, 1940, 1941, 1942, 1943, 1944, 1945, 1946, 1947, 1948, 
1949, 1950, 1951, 1952, 1953, 1954, 1955, 1956, 1957, 1958, 
1959, 1960, 1961, 1962, 1963, 1964, 1965, 1966, 1967, 1968, 
1969, 1970, 1971, 1972, 1973, 1974, 1975, 1976, 1977, 1978, 
1979, 1980, 1981, 1982, 1983, 1984, 1985, 1986, 1987, 1988, 
1989, 1990, 1991, 1992, 1993, 1994, 1995, 1996, 1997, 1998, 
1999, 2000, 2001, 2002, 2003, 2004, 2005, 2006, 2007, 2008, 
2009, 2010, 2011, 2012, 2013, 2014, 2015, 2016, 2017, 2018, 
2019, 2020, 2021, 2022, 2023, 2024, 2025, 2026, 2027, 2028, 
2029, 2030, 2031, 2032, 2033, 2034, 2035, 2036, 2037, 2038, 
2039, 2040, 2041, 2042, 2043, 2044, 2045, 2046, 2047, 2048, 
2049, 2050, 2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 
2059, 2060, 2061, 2062, 2063, 2064, 2065, 2066, 2067, 2068, 
2069, 2070, 2071, 2072, 2073, 2074, 2075, 2076, 2077, 2078, 
2079, 2080, 2081, 2082, 2083, 2084, 2085, 2086, 2087, 2088, 
2089, 2090, 2091, 2092, 2093, 2094, 2095, 2096, 2097, 2098, 
2099, 2100, 2101, 2102, 2103, 2104, 2105, 2106, 2107, 2108, 
2109, 2110, 2111, 2112, 2113, 2114, 2115, 2116, 2117, 2118, 
2119, 2120, 2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 
2129, 2130, 2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 
2139, 2140, 2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 
2149, 2150, 2151, 2152, 2153, 2154, 2155, 2156, 2157, 2158, 
2159, 2160, 2161, 2162, 2163, 2164, 2165, 2166, 2167, 2168, 
2169, 2170, 2171, 2172, 2173, 2174, 2175, 2176, 2177, 2178, 
2179, 2180, 2181, 2182, 2183, 2184, 2185, 2186, 2187, 2188, 
2189, 2190, 2191, 2192, 2193, 2194, 2195, 2196, 2197, 2198, 
2199, 2200, 2201, 2202, 2203, 2204, 2205, 2206, 2207, 2208, 
2209, 2210, 2211, 2212, 3197, 3198, 3199, 3200, 3201, 3202, 
