11318, 23926, 23949, 24202, 24179, 23927, 23950, 24203, 24180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11319, 23927, 23950, 24203, 24180, 23928, 23951, 24204, 24181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11320, 23928, 23951, 24204, 24181, 23929, 23952, 24205, 24182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11321, 23929, 23952, 24205, 24182, 23930, 23953, 24206, 24183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11322, 23930, 23953, 24206, 24183, 23931, 23954, 24207, 24184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11323, 23931, 23954, 24207, 24184, 23932, 23955, 24208, 24185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11324, 23932, 23955, 24208, 24185, 23933, 23956, 24209, 24186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11325, 23933, 23956, 24209, 24186, 23934, 23957, 24210, 24187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11326, 23934, 23957, 24210, 24187, 23935, 23958, 24211, 24188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11327, 23935, 23958, 24211, 24188, 23936, 23959, 24212, 24189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11328, 23936, 23959, 24212, 24189, 23937, 23960, 24213, 24190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11329, 23937, 23960, 24213, 24190, 23938, 23961, 24214, 24191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11330, 23938, 23961, 24214, 24191, 23939, 23962, 24215, 24192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11331, 23939, 23962, 24215, 24192, 23940, 23963, 24216, 24193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11332, 23940, 23963, 24216, 24193, 23941, 23964, 24217, 24194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11333, 23941, 23964, 24217, 24194, 23942, 23965, 24218, 24195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11334, 23942, 23965, 24218, 24195, 23943, 23966, 24219, 24196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11335, 23943, 23966, 24219, 24196, 23944, 23967, 24220, 24197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11336, 23944, 23967, 24220, 24197, 23945, 23968, 24221, 24198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11337, 23945, 23968, 24221, 24198, 5038, 5039, 5050, 5049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11338, 3222, 3223, 3234, 3233, 23946, 23969, 24222, 24199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11339, 23946, 23969, 24222, 24199, 23947, 23970, 24223, 24200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11340, 23947, 23970, 24223, 24200, 23948, 23971, 24224, 24201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11341, 23948, 23971, 24224, 24201, 23949, 23972, 24225, 24202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11342, 23949, 23972, 24225, 24202, 23950, 23973, 24226, 24203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11343, 23950, 23973, 24226, 24203, 23951, 23974, 24227, 24204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11344, 23951, 23974, 24227, 24204, 23952, 23975, 24228, 24205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11345, 23952, 23975, 24228, 24205, 23953, 23976, 24229, 24206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11346, 23953, 23976, 24229, 24206, 23954, 23977, 24230, 24207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11347, 23954, 23977, 24230, 24207, 23955, 23978, 24231, 24208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11348, 23955, 23978, 24231, 24208, 23956, 23979, 24232, 24209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11349, 23956, 23979, 24232, 24209, 23957, 23980, 24233, 24210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11350, 23957, 23980, 24233, 24210, 23958, 23981, 24234, 24211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11351, 23958, 23981, 24234, 24211, 23959, 23982, 24235, 24212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11352, 23959, 23982, 24235, 24212, 23960, 23983, 24236, 24213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11353, 23960, 23983, 24236, 24213, 23961, 23984, 24237, 24214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11354, 23961, 23984, 24237, 24214, 23962, 23985, 24238, 24215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11355, 23962, 23985, 24238, 24215, 23963, 23986, 24239, 24216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11356, 23963, 23986, 24239, 24216, 23964, 23987, 24240, 24217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11357, 23964, 23987, 24240, 24217, 23965, 23988, 24241, 24218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11358, 23965, 23988, 24241, 24218, 23966, 23989, 24242, 24219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11359, 23966, 23989, 24242, 24219, 23967, 23990, 24243, 24220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11360, 23967, 23990, 24243, 24220, 23968, 23991, 24244, 24221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11361, 23968, 23991, 24244, 24221, 5039, 5040, 5051, 5050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11362, 3223, 3224, 3235, 3234, 23969, 23992, 24245, 24222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11363, 23969, 23992, 24245, 24222, 23970, 23993, 24246, 24223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11364, 23970, 23993, 24246, 24223, 23971, 23994, 24247, 24224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11365, 23971, 23994, 24247, 24224, 23972, 23995, 24248, 24225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11366, 23972, 23995, 24248, 24225, 23973, 23996, 24249, 24226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11367, 23973, 23996, 24249, 24226, 23974, 23997, 24250, 24227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11368, 23974, 23997, 24250, 24227, 23975, 23998, 24251, 24228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11369, 23975, 23998, 24251, 24228, 23976, 23999, 24252, 24229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11370, 23976, 23999, 24252, 24229, 23977, 24000, 24253, 24230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11371, 23977, 24000, 24253, 24230, 23978, 24001, 24254, 24231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11372, 23978, 24001, 24254, 24231, 23979, 24002, 24255, 24232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11373, 23979, 24002, 24255, 24232, 23980, 24003, 24256, 24233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11374, 23980, 24003, 24256, 24233, 23981, 24004, 24257, 24234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11375, 23981, 24004, 24257, 24234, 23982, 24005, 24258, 24235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11376, 23982, 24005, 24258, 24235, 23983, 24006, 24259, 24236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11377, 23983, 24006, 24259, 24236, 23984, 24007, 24260, 24237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11378, 23984, 24007, 24260, 24237, 23985, 24008, 24261, 24238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11379, 23985, 24008, 24261, 24238, 23986, 24009, 24262, 24239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11380, 23986, 24009, 24262, 24239, 23987, 24010, 24263, 24240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11381, 23987, 24010, 24263, 24240, 23988, 24011, 24264, 24241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11382, 23988, 24011, 24264, 24241, 23989, 24012, 24265, 24242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11383, 23989, 24012, 24265, 24242, 23990, 24013, 24266, 24243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11384, 23990, 24013, 24266, 24243, 23991, 24014, 24267, 24244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11385, 23991, 24014, 24267, 24244, 5040, 5041, 5052, 5051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11386, 3224, 3225, 3236, 3235, 23992, 24015, 24268, 24245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11387, 23992, 24015, 24268, 24245, 23993, 24016, 24269, 24246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11388, 23993, 24016, 24269, 24246, 23994, 24017, 24270, 24247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11389, 23994, 24017, 24270, 24247, 23995, 24018, 24271, 24248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11390, 23995, 24018, 24271, 24248, 23996, 24019, 24272, 24249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11391, 23996, 24019, 24272, 24249, 23997, 24020, 24273, 24250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11392, 23997, 24020, 24273, 24250, 23998, 24021, 24274, 24251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11393, 23998, 24021, 24274, 24251, 23999, 24022, 24275, 24252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11394, 23999, 24022, 24275, 24252, 24000, 24023, 24276, 24253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11395, 24000, 24023, 24276, 24253, 24001, 24024, 24277, 24254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11396, 24001, 24024, 24277, 24254, 24002, 24025, 24278, 24255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11397, 24002, 24025, 24278, 24255, 24003, 24026, 24279, 24256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11398, 24003, 24026, 24279, 24256, 24004, 24027, 24280, 24257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11399, 24004, 24027, 24280, 24257, 24005, 24028, 24281, 24258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11400, 24005, 24028, 24281, 24258, 24006, 24029, 24282, 24259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11401, 24006, 24029, 24282, 24259, 24007, 24030, 24283, 24260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11402, 24007, 24030, 24283, 24260, 24008, 24031, 24284, 24261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11403, 24008, 24031, 24284, 24261, 24009, 24032, 24285, 24262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11404, 24009, 24032, 24285, 24262, 24010, 24033, 24286, 24263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11405, 24010, 24033, 24286, 24263, 24011, 24034, 24287, 24264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11406, 24011, 24034, 24287, 24264, 24012, 24035, 24288, 24265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11407, 24012, 24035, 24288, 24265, 24013, 24036, 24289, 24266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11408, 24013, 24036, 24289, 24266, 24014, 24037, 24290, 24267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11409, 24014, 24037, 24290, 24267, 5041, 5042, 5053, 5052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11410, 3225, 291, 292, 3236, 24015, 4430, 4453, 24268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11411, 24015, 4430, 4453, 24268, 24016, 4431, 4454, 24269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11412, 24016, 4431, 4454, 24269, 24017, 4432, 4455, 24270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11413, 24017, 4432, 4455, 24270, 24018, 4433, 4456, 24271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11414, 24018, 4433, 4456, 24271, 24019, 4434, 4457, 24272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11415, 24019, 4434, 4457, 24272, 24020, 4435, 4458, 24273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11416, 24020, 4435, 4458, 24273, 24021, 4436, 4459, 24274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11417, 24021, 4436, 4459, 24274, 24022, 4437, 4460, 24275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11418, 24022, 4437, 4460, 24275, 24023, 4438, 4461, 24276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11419, 24023, 4438, 4461, 24276, 24024, 4439, 4462, 24277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11420, 24024, 4439, 4462, 24277, 24025, 4440, 4463, 24278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11421, 24025, 4440, 4463, 24278, 24026, 4441, 4464, 24279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11422, 24026, 4441, 4464, 24279, 24027, 4442, 4465, 24280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11423, 24027, 4442, 4465, 24280, 24028, 4443, 4466, 24281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11424, 24028, 4443, 4466, 24281, 24029, 4444, 4467, 24282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11425, 24029, 4444, 4467, 24282, 24030, 4445, 4468, 24283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11426, 24030, 4445, 4468, 24283, 24031, 4446, 4469, 24284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11427, 24031, 4446, 4469, 24284, 24032, 4447, 4470, 24285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11428, 24032, 4447, 4470, 24285, 24033, 4448, 4471, 24286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11429, 24033, 4448, 4471, 24286, 24034, 4449, 4472, 24287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11430, 24034, 4449, 4472, 24287, 24035, 4450, 4473, 24288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11431, 24035, 4450, 4473, 24288, 24036, 4451, 4474, 24289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11432, 24036, 4451, 4474, 24289, 24037, 4452, 4475, 24290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11433, 24037, 4452, 4475, 24290, 5042, 451, 452, 5053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11434, 258, 3226, 3237, 259, 3671, 24038, 24291, 3694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11435, 3671, 24038, 24291, 3694, 3672, 24039, 24292, 3695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11436, 3672, 24039, 24292, 3695, 3673, 24040, 24293, 3696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11437, 3673, 24040, 24293, 3696, 3674, 24041, 24294, 3697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11438, 3674, 24041, 24294, 3697, 3675, 24042, 24295, 3698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11439, 3675, 24042, 24295, 3698, 3676, 24043, 24296, 3699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11440, 3676, 24043, 24296, 3699, 3677, 24044, 24297, 3700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11441, 3677, 24044, 24297, 3700, 3678, 24045, 24298, 3701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11442, 3678, 24045, 24298, 3701, 3679, 24046, 24299, 3702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11443, 3679, 24046, 24299, 3702, 3680, 24047, 24300, 3703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11444, 3680, 24047, 24300, 3703, 3681, 24048, 24301, 3704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11445, 3681, 24048, 24301, 3704, 3682, 24049, 24302, 3705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11446, 3682, 24049, 24302, 3705, 3683, 24050, 24303, 3706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11447, 3683, 24050, 24303, 3706, 3684, 24051, 24304, 3707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11448, 3684, 24051, 24304, 3707, 3685, 24052, 24305, 3708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11449, 3685, 24052, 24305, 3708, 3686, 24053, 24306, 3709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11450, 3686, 24053, 24306, 3709, 3687, 24054, 24307, 3710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11451, 3687, 24054, 24307, 3710, 3688, 24055, 24308, 3711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11452, 3688, 24055, 24308, 3711, 3689, 24056, 24309, 3712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11453, 3689, 24056, 24309, 3712, 3690, 24057, 24310, 3713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11454, 3690, 24057, 24310, 3713, 3691, 24058, 24311, 3714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11455, 3691, 24058, 24311, 3714, 3692, 24059, 24312, 3715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11456, 3692, 24059, 24312, 3715, 3693, 24060, 24313, 3716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11457, 3693, 24060, 24313, 3716, 372, 5043, 5054, 373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11458, 3226, 3227, 3238, 3237, 24038, 24061, 24314, 24291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11459, 24038, 24061, 24314, 24291, 24039, 24062, 24315, 24292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11460, 24039, 24062, 24315, 24292, 24040, 24063, 24316, 24293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11461, 24040, 24063, 24316, 24293, 24041, 24064, 24317, 24294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11462, 24041, 24064, 24317, 24294, 24042, 24065, 24318, 24295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11463, 24042, 24065, 24318, 24295, 24043, 24066, 24319, 24296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11464, 24043, 24066, 24319, 24296, 24044, 24067, 24320, 24297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11465, 24044, 24067, 24320, 24297, 24045, 24068, 24321, 24298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11466, 24045, 24068, 24321, 24298, 24046, 24069, 24322, 24299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11467, 24046, 24069, 24322, 24299, 24047, 24070, 24323, 24300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11468, 24047, 24070, 24323, 24300, 24048, 24071, 24324, 24301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11469, 24048, 24071, 24324, 24301, 24049, 24072, 24325, 24302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11470, 24049, 24072, 24325, 24302, 24050, 24073, 24326, 24303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11471, 24050, 24073, 24326, 24303, 24051, 24074, 24327, 24304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11472, 24051, 24074, 24327, 24304, 24052, 24075, 24328, 24305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11473, 24052, 24075, 24328, 24305, 24053, 24076, 24329, 24306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11474, 24053, 24076, 24329, 24306, 24054, 24077, 24330, 24307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11475, 24054, 24077, 24330, 24307, 24055, 24078, 24331, 24308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11476, 24055, 24078, 24331, 24308, 24056, 24079, 24332, 24309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11477, 24056, 24079, 24332, 24309, 24057, 24080, 24333, 24310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11478, 24057, 24080, 24333, 24310, 24058, 24081, 24334, 24311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11479, 24058, 24081, 24334, 24311, 24059, 24082, 24335, 24312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11480, 24059, 24082, 24335, 24312, 24060, 24083, 24336, 24313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11481, 24060, 24083, 24336, 24313, 5043, 5044, 5055, 5054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11482, 3227, 3228, 3239, 3238, 24061, 24084, 24337, 24314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11483, 24061, 24084, 24337, 24314, 24062, 24085, 24338, 24315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11484, 24062, 24085, 24338, 24315, 24063, 24086, 24339, 24316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11485, 24063, 24086, 24339, 24316, 24064, 24087, 24340, 24317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11486, 24064, 24087, 24340, 24317, 24065, 24088, 24341, 24318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11487, 24065, 24088, 24341, 24318, 24066, 24089, 24342, 24319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11488, 24066, 24089, 24342, 24319, 24067, 24090, 24343, 24320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11489, 24067, 24090, 24343, 24320, 24068, 24091, 24344, 24321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11490, 24068, 24091, 24344, 24321, 24069, 24092, 24345, 24322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11491, 24069, 24092, 24345, 24322, 24070, 24093, 24346, 24323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11492, 24070, 24093, 24346, 24323, 24071, 24094, 24347, 24324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11493, 24071, 24094, 24347, 24324, 24072, 24095, 24348, 24325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11494, 24072, 24095, 24348, 24325, 24073, 24096, 24349, 24326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11495, 24073, 24096, 24349, 24326, 24074, 24097, 24350, 24327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11496, 24074, 24097, 24350, 24327, 24075, 24098, 24351, 24328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11497, 24075, 24098, 24351, 24328, 24076, 24099, 24352, 24329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11498, 24076, 24099, 24352, 24329, 24077, 24100, 24353, 24330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11499, 24077, 24100, 24353, 24330, 24078, 24101, 24354, 24331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11500, 24078, 24101, 24354, 24331, 24079, 24102, 24355, 24332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11501, 24079, 24102, 24355, 24332, 24080, 24103, 24356, 24333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11502, 24080, 24103, 24356, 24333, 24081, 24104, 24357, 24334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11503, 24081, 24104, 24357, 24334, 24082, 24105, 24358, 24335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11504, 24082, 24105, 24358, 24335, 24083, 24106, 24359, 24336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11505, 24083, 24106, 24359, 24336, 5044, 5045, 5056, 5055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11506, 3228, 3229, 3240, 3239, 24084, 24107, 24360, 24337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11507, 24084, 24107, 24360, 24337, 24085, 24108, 24361, 24338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11508, 24085, 24108, 24361, 24338, 24086, 24109, 24362, 24339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11509, 24086, 24109, 24362, 24339, 24087, 24110, 24363, 24340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11510, 24087, 24110, 24363, 24340, 24088, 24111, 24364, 24341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11511, 24088, 24111, 24364, 24341, 24089, 24112, 24365, 24342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11512, 24089, 24112, 24365, 24342, 24090, 24113, 24366, 24343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11513, 24090, 24113, 24366, 24343, 24091, 24114, 24367, 24344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11514, 24091, 24114, 24367, 24344, 24092, 24115, 24368, 24345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11515, 24092, 24115, 24368, 24345, 24093, 24116, 24369, 24346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11516, 24093, 24116, 24369, 24346, 24094, 24117, 24370, 24347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11517, 24094, 24117, 24370, 24347, 24095, 24118, 24371, 24348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11518, 24095, 24118, 24371, 24348, 24096, 24119, 24372, 24349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11519, 24096, 24119, 24372, 24349, 24097, 24120, 24373, 24350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11520, 24097, 24120, 24373, 24350, 24098, 24121, 24374, 24351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11521, 24098, 24121, 24374, 24351, 24099, 24122, 24375, 24352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11522, 24099, 24122, 24375, 24352, 24100, 24123, 24376, 24353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11523, 24100, 24123, 24376, 24353, 24101, 24124, 24377, 24354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11524, 24101, 24124, 24377, 24354, 24102, 24125, 24378, 24355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11525, 24102, 24125, 24378, 24355, 24103, 24126, 24379, 24356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11526, 24103, 24126, 24379, 24356, 24104, 24127, 24380, 24357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11527, 24104, 24127, 24380, 24357, 24105, 24128, 24381, 24358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11528, 24105, 24128, 24381, 24358, 24106, 24129, 24382, 24359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11529, 24106, 24129, 24382, 24359, 5045, 5046, 5057, 5056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11530, 3229, 3230, 3241, 3240, 24107, 24130, 24383, 24360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11531, 24107, 24130, 24383, 24360, 24108, 24131, 24384, 24361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11532, 24108, 24131, 24384, 24361, 24109, 24132, 24385, 24362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11533, 24109, 24132, 24385, 24362, 24110, 24133, 24386, 24363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11534, 24110, 24133, 24386, 24363, 24111, 24134, 24387, 24364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11535, 24111, 24134, 24387, 24364, 24112, 24135, 24388, 24365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11536, 24112, 24135, 24388, 24365, 24113, 24136, 24389, 24366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11537, 24113, 24136, 24389, 24366, 24114, 24137, 24390, 24367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11538, 24114, 24137, 24390, 24367, 24115, 24138, 24391, 24368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11539, 24115, 24138, 24391, 24368, 24116, 24139, 24392, 24369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11540, 24116, 24139, 24392, 24369, 24117, 24140, 24393, 24370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11541, 24117, 24140, 24393, 24370, 24118, 24141, 24394, 24371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11542, 24118, 24141, 24394, 24371, 24119, 24142, 24395, 24372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11543, 24119, 24142, 24395, 24372, 24120, 24143, 24396, 24373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11544, 24120, 24143, 24396, 24373, 24121, 24144, 24397, 24374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11545, 24121, 24144, 24397, 24374, 24122, 24145, 24398, 24375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11546, 24122, 24145, 24398, 24375, 24123, 24146, 24399, 24376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11547, 24123, 24146, 24399, 24376, 24124, 24147, 24400, 24377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11548, 24124, 24147, 24400, 24377, 24125, 24148, 24401, 24378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11549, 24125, 24148, 24401, 24378, 24126, 24149, 24402, 24379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11550, 24126, 24149, 24402, 24379, 24127, 24150, 24403, 24380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11551, 24127, 24150, 24403, 24380, 24128, 24151, 24404, 24381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11552, 24128, 24151, 24404, 24381, 24129, 24152, 24405, 24382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11553, 24129, 24152, 24405, 24382, 5046, 5047, 5058, 5057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11554, 3230, 3231, 3242, 3241, 24130, 24153, 24406, 24383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11555, 24130, 24153, 24406, 24383, 24131, 24154, 24407, 24384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11556, 24131, 24154, 24407, 24384, 24132, 24155, 24408, 24385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11557, 24132, 24155, 24408, 24385, 24133, 24156, 24409, 24386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11558, 24133, 24156, 24409, 24386, 24134, 24157, 24410, 24387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11559, 24134, 24157, 24410, 24387, 24135, 24158, 24411, 24388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11560, 24135, 24158, 24411, 24388, 24136, 24159, 24412, 24389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11561, 24136, 24159, 24412, 24389, 24137, 24160, 24413, 24390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11562, 24137, 24160, 24413, 24390, 24138, 24161, 24414, 24391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11563, 24138, 24161, 24414, 24391, 24139, 24162, 24415, 24392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11564, 24139, 24162, 24415, 24392, 24140, 24163, 24416, 24393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11565, 24140, 24163, 24416, 24393, 24141, 24164, 24417, 24394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11566, 24141, 24164, 24417, 24394, 24142, 24165, 24418, 24395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11567, 24142, 24165, 24418, 24395, 24143, 24166, 24419, 24396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11568, 24143, 24166, 24419, 24396, 24144, 24167, 24420, 24397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11569, 24144, 24167, 24420, 24397, 24145, 24168, 24421, 24398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11570, 24145, 24168, 24421, 24398, 24146, 24169, 24422, 24399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11571, 24146, 24169, 24422, 24399, 24147, 24170, 24423, 24400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11572, 24147, 24170, 24423, 24400, 24148, 24171, 24424, 24401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11573, 24148, 24171, 24424, 24401, 24149, 24172, 24425, 24402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11574, 24149, 24172, 24425, 24402, 24150, 24173, 24426, 24403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11575, 24150, 24173, 24426, 24403, 24151, 24174, 24427, 24404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11576, 24151, 24174, 24427, 24404, 24152, 24175, 24428, 24405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11577, 24152, 24175, 24428, 24405, 5047, 5048, 5059, 5058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11578, 3231, 3232, 3243, 3242, 24153, 24176, 24429, 24406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11579, 24153, 24176, 24429, 24406, 24154, 24177, 24430, 24407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11580, 24154, 24177, 24430, 24407, 24155, 24178, 24431, 24408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11581, 24155, 24178, 24431, 24408, 24156, 24179, 24432, 24409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11582, 24156, 24179, 24432, 24409, 24157, 24180, 24433, 24410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11583, 24157, 24180, 24433, 24410, 24158, 24181, 24434, 24411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11584, 24158, 24181, 24434, 24411, 24159, 24182, 24435, 24412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11585, 24159, 24182, 24435, 24412, 24160, 24183, 24436, 24413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11586, 24160, 24183, 24436, 24413, 24161, 24184, 24437, 24414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11587, 24161, 24184, 24437, 24414, 24162, 24185, 24438, 24415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11588, 24162, 24185, 24438, 24415, 24163, 24186, 24439, 24416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11589, 24163, 24186, 24439, 24416, 24164, 24187, 24440, 24417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11590, 24164, 24187, 24440, 24417, 24165, 24188, 24441, 24418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11591, 24165, 24188, 24441, 24418, 24166, 24189, 24442, 24419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11592, 24166, 24189, 24442, 24419, 24167, 24190, 24443, 24420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11593, 24167, 24190, 24443, 24420, 24168, 24191, 24444, 24421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11594, 24168, 24191, 24444, 24421, 24169, 24192, 24445, 24422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11595, 24169, 24192, 24445, 24422, 24170, 24193, 24446, 24423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11596, 24170, 24193, 24446, 24423, 24171, 24194, 24447, 24424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11597, 24171, 24194, 24447, 24424, 24172, 24195, 24448, 24425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11598, 24172, 24195, 24448, 24425, 24173, 24196, 24449, 24426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11599, 24173, 24196, 24449, 24426, 24174, 24197, 24450, 24427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11600, 24174, 24197, 24450, 24427, 24175, 24198, 24451, 24428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11601, 24175, 24198, 24451, 24428, 5048, 5049, 5060, 5059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11602, 3232, 3233, 3244, 3243, 24176, 24199, 24452, 24429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11603, 24176, 24199, 24452, 24429, 24177, 24200, 24453, 24430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11604, 24177, 24200, 24453, 24430, 24178, 24201, 24454, 24431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11605, 24178, 24201, 24454, 24431, 24179, 24202, 24455, 24432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11606, 24179, 24202, 24455, 24432, 24180, 24203, 24456, 24433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11607, 24180, 24203, 24456, 24433, 24181, 24204, 24457, 24434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11608, 24181, 24204, 24457, 24434, 24182, 24205, 24458, 24435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11609, 24182, 24205, 24458, 24435, 24183, 24206, 24459, 24436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11610, 24183, 24206, 24459, 24436, 24184, 24207, 24460, 24437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11611, 24184, 24207, 24460, 24437, 24185, 24208, 24461, 24438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11612, 24185, 24208, 24461, 24438, 24186, 24209, 24462, 24439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11613, 24186, 24209, 24462, 24439, 24187, 24210, 24463, 24440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11614, 24187, 24210, 24463, 24440, 24188, 24211, 24464, 24441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11615, 24188, 24211, 24464, 24441, 24189, 24212, 24465, 24442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11616, 24189, 24212, 24465, 24442, 24190, 24213, 24466, 24443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11617, 24190, 24213, 24466, 24443, 24191, 24214, 24467, 24444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11618, 24191, 24214, 24467, 24444, 24192, 24215, 24468, 24445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11619, 24192, 24215, 24468, 24445, 24193, 24216, 24469, 24446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11620, 24193, 24216, 24469, 24446, 24194, 24217, 24470, 24447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11621, 24194, 24217, 24470, 24447, 24195, 24218, 24471, 24448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11622, 24195, 24218, 24471, 24448, 24196, 24219, 24472, 24449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11623, 24196, 24219, 24472, 24449, 24197, 24220, 24473, 24450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11624, 24197, 24220, 24473, 24450, 24198, 24221, 24474, 24451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11625, 24198, 24221, 24474, 24451, 5049, 5050, 5061, 5060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11626, 3233, 3234, 3245, 3244, 24199, 24222, 24475, 24452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11627, 24199, 24222, 24475, 24452, 24200, 24223, 24476, 24453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11628, 24200, 24223, 24476, 24453, 24201, 24224, 24477, 24454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11629, 24201, 24224, 24477, 24454, 24202, 24225, 24478, 24455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11630, 24202, 24225, 24478, 24455, 24203, 24226, 24479, 24456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11631, 24203, 24226, 24479, 24456, 24204, 24227, 24480, 24457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11632, 24204, 24227, 24480, 24457, 24205, 24228, 24481, 24458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11633, 24205, 24228, 24481, 24458, 24206, 24229, 24482, 24459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11634, 24206, 24229, 24482, 24459, 24207, 24230, 24483, 24460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11635, 24207, 24230, 24483, 24460, 24208, 24231, 24484, 24461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11636, 24208, 24231, 24484, 24461, 24209, 24232, 24485, 24462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11637, 24209, 24232, 24485, 24462, 24210, 24233, 24486, 24463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11638, 24210, 24233, 24486, 24463, 24211, 24234, 24487, 24464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11639, 24211, 24234, 24487, 24464, 24212, 24235, 24488, 24465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11640, 24212, 24235, 24488, 24465, 24213, 24236, 24489, 24466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11641, 24213, 24236, 24489, 24466, 24214, 24237, 24490, 24467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11642, 24214, 24237, 24490, 24467, 24215, 24238, 24491, 24468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11643, 24215, 24238, 24491, 24468, 24216, 24239, 24492, 24469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11644, 24216, 24239, 24492, 24469, 24217, 24240, 24493, 24470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11645, 24217, 24240, 24493, 24470, 24218, 24241, 24494, 24471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11646, 24218, 24241, 24494, 24471, 24219, 24242, 24495, 24472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11647, 24219, 24242, 24495, 24472, 24220, 24243, 24496, 24473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11648, 24220, 24243, 24496, 24473, 24221, 24244, 24497, 24474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11649, 24221, 24244, 24497, 24474, 5050, 5051, 5062, 5061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11650, 3234, 3235, 3246, 3245, 24222, 24245, 24498, 24475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11651, 24222, 24245, 24498, 24475, 24223, 24246, 24499, 24476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11652, 24223, 24246, 24499, 24476, 24224, 24247, 24500, 24477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11653, 24224, 24247, 24500, 24477, 24225, 24248, 24501, 24478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11654, 24225, 24248, 24501, 24478, 24226, 24249, 24502, 24479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11655, 24226, 24249, 24502, 24479, 24227, 24250, 24503, 24480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11656, 24227, 24250, 24503, 24480, 24228, 24251, 24504, 24481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11657, 24228, 24251, 24504, 24481, 24229, 24252, 24505, 24482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11658, 24229, 24252, 24505, 24482, 24230, 24253, 24506, 24483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11659, 24230, 24253, 24506, 24483, 24231, 24254, 24507, 24484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11660, 24231, 24254, 24507, 24484, 24232, 24255, 24508, 24485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11661, 24232, 24255, 24508, 24485, 24233, 24256, 24509, 24486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11662, 24233, 24256, 24509, 24486, 24234, 24257, 24510, 24487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11663, 24234, 24257, 24510, 24487, 24235, 24258, 24511, 24488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11664, 24235, 24258, 24511, 24488, 24236, 24259, 24512, 24489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11665, 24236, 24259, 24512, 24489, 24237, 24260, 24513, 24490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11666, 24237, 24260, 24513, 24490, 24238, 24261, 24514, 24491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11667, 24238, 24261, 24514, 24491, 24239, 24262, 24515, 24492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11668, 24239, 24262, 24515, 24492, 24240, 24263, 24516, 24493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11669, 24240, 24263, 24516, 24493, 24241, 24264, 24517, 24494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11670, 24241, 24264, 24517, 24494, 24242, 24265, 24518, 24495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11671, 24242, 24265, 24518, 24495, 24243, 24266, 24519, 24496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11672, 24243, 24266, 24519, 24496, 24244, 24267, 24520, 24497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11673, 24244, 24267, 24520, 24497, 5051, 5052, 5063, 5062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11674, 3235, 3236, 3247, 3246, 24245, 24268, 24521, 24498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11675, 24245, 24268, 24521, 24498, 24246, 24269, 24522, 24499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11676, 24246, 24269, 24522, 24499, 24247, 24270, 24523, 24500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11677, 24247, 24270, 24523, 24500, 24248, 24271, 24524, 24501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11678, 24248, 24271, 24524, 24501, 24249, 24272, 24525, 24502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11679, 24249, 24272, 24525, 24502, 24250, 24273, 24526, 24503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11680, 24250, 24273, 24526, 24503, 24251, 24274, 24527, 24504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11681, 24251, 24274, 24527, 24504, 24252, 24275, 24528, 24505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11682, 24252, 24275, 24528, 24505, 24253, 24276, 24529, 24506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11683, 24253, 24276, 24529, 24506, 24254, 24277, 24530, 24507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11684, 24254, 24277, 24530, 24507, 24255, 24278, 24531, 24508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11685, 24255, 24278, 24531, 24508, 24256, 24279, 24532, 24509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11686, 24256, 24279, 24532, 24509, 24257, 24280, 24533, 24510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11687, 24257, 24280, 24533, 24510, 24258, 24281, 24534, 24511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11688, 24258, 24281, 24534, 24511, 24259, 24282, 24535, 24512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11689, 24259, 24282, 24535, 24512, 24260, 24283, 24536, 24513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11690, 24260, 24283, 24536, 24513, 24261, 24284, 24537, 24514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11691, 24261, 24284, 24537, 24514, 24262, 24285, 24538, 24515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11692, 24262, 24285, 24538, 24515, 24263, 24286, 24539, 24516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11693, 24263, 24286, 24539, 24516, 24264, 24287, 24540, 24517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11694, 24264, 24287, 24540, 24517, 24265, 24288, 24541, 24518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11695, 24265, 24288, 24541, 24518, 24266, 24289, 24542, 24519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11696, 24266, 24289, 24542, 24519, 24267, 24290, 24543, 24520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11697, 24267, 24290, 24543, 24520, 5052, 5053, 5064, 5063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11698, 3236, 292, 293, 3247, 24268, 4453, 4476, 24521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11699, 24268, 4453, 4476, 24521, 24269, 4454, 4477, 24522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11700, 24269, 4454, 4477, 24522, 24270, 4455, 4478, 24523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11701, 24270, 4455, 4478, 24523, 24271, 4456, 4479, 24524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11702, 24271, 4456, 4479, 24524, 24272, 4457, 4480, 24525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11703, 24272, 4457, 4480, 24525, 24273, 4458, 4481, 24526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11704, 24273, 4458, 4481, 24526, 24274, 4459, 4482, 24527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11705, 24274, 4459, 4482, 24527, 24275, 4460, 4483, 24528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11706, 24275, 4460, 4483, 24528, 24276, 4461, 4484, 24529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11707, 24276, 4461, 4484, 24529, 24277, 4462, 4485, 24530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11708, 24277, 4462, 4485, 24530, 24278, 4463, 4486, 24531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11709, 24278, 4463, 4486, 24531, 24279, 4464, 4487, 24532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11710, 24279, 4464, 4487, 24532, 24280, 4465, 4488, 24533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11711, 24280, 4465, 4488, 24533, 24281, 4466, 4489, 24534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11712, 24281, 4466, 4489, 24534, 24282, 4467, 4490, 24535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11713, 24282, 4467, 4490, 24535, 24283, 4468, 4491, 24536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11714, 24283, 4468, 4491, 24536, 24284, 4469, 4492, 24537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11715, 24284, 4469, 4492, 24537, 24285, 4470, 4493, 24538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11716, 24285, 4470, 4493, 24538, 24286, 4471, 4494, 24539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11717, 24286, 4471, 4494, 24539, 24287, 4472, 4495, 24540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11718, 24287, 4472, 4495, 24540, 24288, 4473, 4496, 24541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11719, 24288, 4473, 4496, 24541, 24289, 4474, 4497, 24542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11720, 24289, 4474, 4497, 24542, 24290, 4475, 4498, 24543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11721, 24290, 4475, 4498, 24543, 5053, 452, 453, 5064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11722, 259, 3237, 3248, 260, 3694, 24291, 24544, 3717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11723, 3694, 24291, 24544, 3717, 3695, 24292, 24545, 3718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11724, 3695, 24292, 24545, 3718, 3696, 24293, 24546, 3719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11725, 3696, 24293, 24546, 3719, 3697, 24294, 24547, 3720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11726, 3697, 24294, 24547, 3720, 3698, 24295, 24548, 3721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11727, 3698, 24295, 24548, 3721, 3699, 24296, 24549, 3722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11728, 3699, 24296, 24549, 3722, 3700, 24297, 24550, 3723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11729, 3700, 24297, 24550, 3723, 3701, 24298, 24551, 3724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11730, 3701, 24298, 24551, 3724, 3702, 24299, 24552, 3725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11731, 3702, 24299, 24552, 3725, 3703, 24300, 24553, 3726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11732, 3703, 24300, 24553, 3726, 3704, 24301, 24554, 3727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11733, 3704, 24301, 24554, 3727, 3705, 24302, 24555, 3728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11734, 3705, 24302, 24555, 3728, 3706, 24303, 24556, 3729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11735, 3706, 24303, 24556, 3729, 3707, 24304, 24557, 3730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11736, 3707, 24304, 24557, 3730, 3708, 24305, 24558, 3731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11737, 3708, 24305, 24558, 3731, 3709, 24306, 24559, 3732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11738, 3709, 24306, 24559, 3732, 3710, 24307, 24560, 3733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11739, 3710, 24307, 24560, 3733, 3711, 24308, 24561, 3734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11740, 3711, 24308, 24561, 3734, 3712, 24309, 24562, 3735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11741, 3712, 24309, 24562, 3735, 3713, 24310, 24563, 3736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11742, 3713, 24310, 24563, 3736, 3714, 24311, 24564, 3737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11743, 3714, 24311, 24564, 3737, 3715, 24312, 24565, 3738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11744, 3715, 24312, 24565, 3738, 3716, 24313, 24566, 3739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11745, 3716, 24313, 24566, 3739, 373, 5054, 5065, 374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11746, 3237, 3238, 3249, 3248, 24291, 24314, 24567, 24544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11747, 24291, 24314, 24567, 24544, 24292, 24315, 24568, 24545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11748, 24292, 24315, 24568, 24545, 24293, 24316, 24569, 24546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11749, 24293, 24316, 24569, 24546, 24294, 24317, 24570, 24547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11750, 24294, 24317, 24570, 24547, 24295, 24318, 24571, 24548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11751, 24295, 24318, 24571, 24548, 24296, 24319, 24572, 24549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11752, 24296, 24319, 24572, 24549, 24297, 24320, 24573, 24550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11753, 24297, 24320, 24573, 24550, 24298, 24321, 24574, 24551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11754, 24298, 24321, 24574, 24551, 24299, 24322, 24575, 24552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11755, 24299, 24322, 24575, 24552, 24300, 24323, 24576, 24553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11756, 24300, 24323, 24576, 24553, 24301, 24324, 24577, 24554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11757, 24301, 24324, 24577, 24554, 24302, 24325, 24578, 24555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11758, 24302, 24325, 24578, 24555, 24303, 24326, 24579, 24556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11759, 24303, 24326, 24579, 24556, 24304, 24327, 24580, 24557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11760, 24304, 24327, 24580, 24557, 24305, 24328, 24581, 24558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11761, 24305, 24328, 24581, 24558, 24306, 24329, 24582, 24559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11762, 24306, 24329, 24582, 24559, 24307, 24330, 24583, 24560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11763, 24307, 24330, 24583, 24560, 24308, 24331, 24584, 24561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11764, 24308, 24331, 24584, 24561, 24309, 24332, 24585, 24562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11765, 24309, 24332, 24585, 24562, 24310, 24333, 24586, 24563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11766, 24310, 24333, 24586, 24563, 24311, 24334, 24587, 24564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11767, 24311, 24334, 24587, 24564, 24312, 24335, 24588, 24565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11768, 24312, 24335, 24588, 24565, 24313, 24336, 24589, 24566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11769, 24313, 24336, 24589, 24566, 5054, 5055, 5066, 5065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11770, 3238, 3239, 3250, 3249, 24314, 24337, 24590, 24567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11771, 24314, 24337, 24590, 24567, 24315, 24338, 24591, 24568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11772, 24315, 24338, 24591, 24568, 24316, 24339, 24592, 24569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11773, 24316, 24339, 24592, 24569, 24317, 24340, 24593, 24570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11774, 24317, 24340, 24593, 24570, 24318, 24341, 24594, 24571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11775, 24318, 24341, 24594, 24571, 24319, 24342, 24595, 24572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11776, 24319, 24342, 24595, 24572, 24320, 24343, 24596, 24573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11777, 24320, 24343, 24596, 24573, 24321, 24344, 24597, 24574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11778, 24321, 24344, 24597, 24574, 24322, 24345, 24598, 24575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11779, 24322, 24345, 24598, 24575, 24323, 24346, 24599, 24576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11780, 24323, 24346, 24599, 24576, 24324, 24347, 24600, 24577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11781, 24324, 24347, 24600, 24577, 24325, 24348, 24601, 24578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11782, 24325, 24348, 24601, 24578, 24326, 24349, 24602, 24579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11783, 24326, 24349, 24602, 24579, 24327, 24350, 24603, 24580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11784, 24327, 24350, 24603, 24580, 24328, 24351, 24604, 24581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11785, 24328, 24351, 24604, 24581, 24329, 24352, 24605, 24582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11786, 24329, 24352, 24605, 24582, 24330, 24353, 24606, 24583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11787, 24330, 24353, 24606, 24583, 24331, 24354, 24607, 24584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11788, 24331, 24354, 24607, 24584, 24332, 24355, 24608, 24585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11789, 24332, 24355, 24608, 24585, 24333, 24356, 24609, 24586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11790, 24333, 24356, 24609, 24586, 24334, 24357, 24610, 24587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11791, 24334, 24357, 24610, 24587, 24335, 24358, 24611, 24588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11792, 24335, 24358, 24611, 24588, 24336, 24359, 24612, 24589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11793, 24336, 24359, 24612, 24589, 5055, 5056, 5067, 5066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11794, 3239, 3240, 3251, 3250, 24337, 24360, 24613, 24590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11795, 24337, 24360, 24613, 24590, 24338, 24361, 24614, 24591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11796, 24338, 24361, 24614, 24591, 24339, 24362, 24615, 24592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11797, 24339, 24362, 24615, 24592, 24340, 24363, 24616, 24593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11798, 24340, 24363, 24616, 24593, 24341, 24364, 24617, 24594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11799, 24341, 24364, 24617, 24594, 24342, 24365, 24618, 24595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11800, 24342, 24365, 24618, 24595, 24343, 24366, 24619, 24596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11801, 24343, 24366, 24619, 24596, 24344, 24367, 24620, 24597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11802, 24344, 24367, 24620, 24597, 24345, 24368, 24621, 24598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11803, 24345, 24368, 24621, 24598, 24346, 24369, 24622, 24599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11804, 24346, 24369, 24622, 24599, 24347, 24370, 24623, 24600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11805, 24347, 24370, 24623, 24600, 24348, 24371, 24624, 24601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11806, 24348, 24371, 24624, 24601, 24349, 24372, 24625, 24602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11807, 24349, 24372, 24625, 24602, 24350, 24373, 24626, 24603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11808, 24350, 24373, 24626, 24603, 24351, 24374, 24627, 24604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11809, 24351, 24374, 24627, 24604, 24352, 24375, 24628, 24605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11810, 24352, 24375, 24628, 24605, 24353, 24376, 24629, 24606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11811, 24353, 24376, 24629, 24606, 24354, 24377, 24630, 24607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11812, 24354, 24377, 24630, 24607, 24355, 24378, 24631, 24608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11813, 24355, 24378, 24631, 24608, 24356, 24379, 24632, 24609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11814, 24356, 24379, 24632, 24609, 24357, 24380, 24633, 24610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11815, 24357, 24380, 24633, 24610, 24358, 24381, 24634, 24611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11816, 24358, 24381, 24634, 24611, 24359, 24382, 24635, 24612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11817, 24359, 24382, 24635, 24612, 5056, 5057, 5068, 5067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11818, 3240, 3241, 3252, 3251, 24360, 24383, 24636, 24613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11819, 24360, 24383, 24636, 24613, 24361, 24384, 24637, 24614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11820, 24361, 24384, 24637, 24614, 24362, 24385, 24638, 24615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11821, 24362, 24385, 24638, 24615, 24363, 24386, 24639, 24616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11822, 24363, 24386, 24639, 24616, 24364, 24387, 24640, 24617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11823, 24364, 24387, 24640, 24617, 24365, 24388, 24641, 24618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11824, 24365, 24388, 24641, 24618, 24366, 24389, 24642, 24619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11825, 24366, 24389, 24642, 24619, 24367, 24390, 24643, 24620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11826, 24367, 24390, 24643, 24620, 24368, 24391, 24644, 24621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11827, 24368, 24391, 24644, 24621, 24369, 24392, 24645, 24622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11828, 24369, 24392, 24645, 24622, 24370, 24393, 24646, 24623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11829, 24370, 24393, 24646, 24623, 24371, 24394, 24647, 24624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11830, 24371, 24394, 24647, 24624, 24372, 24395, 24648, 24625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11831, 24372, 24395, 24648, 24625, 24373, 24396, 24649, 24626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11832, 24373, 24396, 24649, 24626, 24374, 24397, 24650, 24627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11833, 24374, 24397, 24650, 24627, 24375, 24398, 24651, 24628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11834, 24375, 24398, 24651, 24628, 24376, 24399, 24652, 24629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11835, 24376, 24399, 24652, 24629, 24377, 24400, 24653, 24630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11836, 24377, 24400, 24653, 24630, 24378, 24401, 24654, 24631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11837, 24378, 24401, 24654, 24631, 24379, 24402, 24655, 24632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11838, 24379, 24402, 24655, 24632, 24380, 24403, 24656, 24633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11839, 24380, 24403, 24656, 24633, 24381, 24404, 24657, 24634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11840, 24381, 24404, 24657, 24634, 24382, 24405, 24658, 24635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11841, 24382, 24405, 24658, 24635, 5057, 5058, 5069, 5068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11842, 3241, 3242, 3253, 3252, 24383, 24406, 24659, 24636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11843, 24383, 24406, 24659, 24636, 24384, 24407, 24660, 24637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11844, 24384, 24407, 24660, 24637, 24385, 24408, 24661, 24638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11845, 24385, 24408, 24661, 24638, 24386, 24409, 24662, 24639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11846, 24386, 24409, 24662, 24639, 24387, 24410, 24663, 24640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11847, 24387, 24410, 24663, 24640, 24388, 24411, 24664, 24641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11848, 24388, 24411, 24664, 24641, 24389, 24412, 24665, 24642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11849, 24389, 24412, 24665, 24642, 24390, 24413, 24666, 24643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11850, 24390, 24413, 24666, 24643, 24391, 24414, 24667, 24644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11851, 24391, 24414, 24667, 24644, 24392, 24415, 24668, 24645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11852, 24392, 24415, 24668, 24645, 24393, 24416, 24669, 24646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11853, 24393, 24416, 24669, 24646, 24394, 24417, 24670, 24647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11854, 24394, 24417, 24670, 24647, 24395, 24418, 24671, 24648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11855, 24395, 24418, 24671, 24648, 24396, 24419, 24672, 24649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11856, 24396, 24419, 24672, 24649, 24397, 24420, 24673, 24650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11857, 24397, 24420, 24673, 24650, 24398, 24421, 24674, 24651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11858, 24398, 24421, 24674, 24651, 24399, 24422, 24675, 24652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11859, 24399, 24422, 24675, 24652, 24400, 24423, 24676, 24653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11860, 24400, 24423, 24676, 24653, 24401, 24424, 24677, 24654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11861, 24401, 24424, 24677, 24654, 24402, 24425, 24678, 24655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11862, 24402, 24425, 24678, 24655, 24403, 24426, 24679, 24656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11863, 24403, 24426, 24679, 24656, 24404, 24427, 24680, 24657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11864, 24404, 24427, 24680, 24657, 24405, 24428, 24681, 24658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11865, 24405, 24428, 24681, 24658, 5058, 5059, 5070, 5069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11866, 3242, 3243, 3254, 3253, 24406, 24429, 24682, 24659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11867, 24406, 24429, 24682, 24659, 24407, 24430, 24683, 24660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11868, 24407, 24430, 24683, 24660, 24408, 24431, 24684, 24661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11869, 24408, 24431, 24684, 24661, 24409, 24432, 24685, 24662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11870, 24409, 24432, 24685, 24662, 24410, 24433, 24686, 24663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11871, 24410, 24433, 24686, 24663, 24411, 24434, 24687, 24664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11872, 24411, 24434, 24687, 24664, 24412, 24435, 24688, 24665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11873, 24412, 24435, 24688, 24665, 24413, 24436, 24689, 24666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11874, 24413, 24436, 24689, 24666, 24414, 24437, 24690, 24667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11875, 24414, 24437, 24690, 24667, 24415, 24438, 24691, 24668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11876, 24415, 24438, 24691, 24668, 24416, 24439, 24692, 24669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11877, 24416, 24439, 24692, 24669, 24417, 24440, 24693, 24670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11878, 24417, 24440, 24693, 24670, 24418, 24441, 24694, 24671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11879, 24418, 24441, 24694, 24671, 24419, 24442, 24695, 24672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11880, 24419, 24442, 24695, 24672, 24420, 24443, 24696, 24673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11881, 24420, 24443, 24696, 24673, 24421, 24444, 24697, 24674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11882, 24421, 24444, 24697, 24674, 24422, 24445, 24698, 24675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11883, 24422, 24445, 24698, 24675, 24423, 24446, 24699, 24676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11884, 24423, 24446, 24699, 24676, 24424, 24447, 24700, 24677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11885, 24424, 24447, 24700, 24677, 24425, 24448, 24701, 24678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11886, 24425, 24448, 24701, 24678, 24426, 24449, 24702, 24679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11887, 24426, 24449, 24702, 24679, 24427, 24450, 24703, 24680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11888, 24427, 24450, 24703, 24680, 24428, 24451, 24704, 24681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11889, 24428, 24451, 24704, 24681, 5059, 5060, 5071, 5070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11890, 3243, 3244, 3255, 3254, 24429, 24452, 24705, 24682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11891, 24429, 24452, 24705, 24682, 24430, 24453, 24706, 24683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11892, 24430, 24453, 24706, 24683, 24431, 24454, 24707, 24684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11893, 24431, 24454, 24707, 24684, 24432, 24455, 24708, 24685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11894, 24432, 24455, 24708, 24685, 24433, 24456, 24709, 24686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11895, 24433, 24456, 24709, 24686, 24434, 24457, 24710, 24687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11896, 24434, 24457, 24710, 24687, 24435, 24458, 24711, 24688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11897, 24435, 24458, 24711, 24688, 24436, 24459, 24712, 24689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11898, 24436, 24459, 24712, 24689, 24437, 24460, 24713, 24690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11899, 24437, 24460, 24713, 24690, 24438, 24461, 24714, 24691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11900, 24438, 24461, 24714, 24691, 24439, 24462, 24715, 24692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11901, 24439, 24462, 24715, 24692, 24440, 24463, 24716, 24693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11902, 24440, 24463, 24716, 24693, 24441, 24464, 24717, 24694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11903, 24441, 24464, 24717, 24694, 24442, 24465, 24718, 24695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11904, 24442, 24465, 24718, 24695, 24443, 24466, 24719, 24696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11905, 24443, 24466, 24719, 24696, 24444, 24467, 24720, 24697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11906, 24444, 24467, 24720, 24697, 24445, 24468, 24721, 24698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11907, 24445, 24468, 24721, 24698, 24446, 24469, 24722, 24699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11908, 24446, 24469, 24722, 24699, 24447, 24470, 24723, 24700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11909, 24447, 24470, 24723, 24700, 24448, 24471, 24724, 24701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11910, 24448, 24471, 24724, 24701, 24449, 24472, 24725, 24702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11911, 24449, 24472, 24725, 24702, 24450, 24473, 24726, 24703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11912, 24450, 24473, 24726, 24703, 24451, 24474, 24727, 24704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11913, 24451, 24474, 24727, 24704, 5060, 5061, 5072, 5071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11914, 3244, 3245, 3256, 3255, 24452, 24475, 24728, 24705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11915, 24452, 24475, 24728, 24705, 24453, 24476, 24729, 24706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11916, 24453, 24476, 24729, 24706, 24454, 24477, 24730, 24707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11917, 24454, 24477, 24730, 24707, 24455, 24478, 24731, 24708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11918, 24455, 24478, 24731, 24708, 24456, 24479, 24732, 24709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11919, 24456, 24479, 24732, 24709, 24457, 24480, 24733, 24710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11920, 24457, 24480, 24733, 24710, 24458, 24481, 24734, 24711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11921, 24458, 24481, 24734, 24711, 24459, 24482, 24735, 24712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11922, 24459, 24482, 24735, 24712, 24460, 24483, 24736, 24713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11923, 24460, 24483, 24736, 24713, 24461, 24484, 24737, 24714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11924, 24461, 24484, 24737, 24714, 24462, 24485, 24738, 24715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11925, 24462, 24485, 24738, 24715, 24463, 24486, 24739, 24716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11926, 24463, 24486, 24739, 24716, 24464, 24487, 24740, 24717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11927, 24464, 24487, 24740, 24717, 24465, 24488, 24741, 24718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11928, 24465, 24488, 24741, 24718, 24466, 24489, 24742, 24719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11929, 24466, 24489, 24742, 24719, 24467, 24490, 24743, 24720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11930, 24467, 24490, 24743, 24720, 24468, 24491, 24744, 24721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11931, 24468, 24491, 24744, 24721, 24469, 24492, 24745, 24722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11932, 24469, 24492, 24745, 24722, 24470, 24493, 24746, 24723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11933, 24470, 24493, 24746, 24723, 24471, 24494, 24747, 24724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11934, 24471, 24494, 24747, 24724, 24472, 24495, 24748, 24725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11935, 24472, 24495, 24748, 24725, 24473, 24496, 24749, 24726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11936, 24473, 24496, 24749, 24726, 24474, 24497, 24750, 24727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11937, 24474, 24497, 24750, 24727, 5061, 5062, 5073, 5072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11938, 3245, 3246, 3257, 3256, 24475, 24498, 24751, 24728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11939, 24475, 24498, 24751, 24728, 24476, 24499, 24752, 24729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11940, 24476, 24499, 24752, 24729, 24477, 24500, 24753, 24730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11941, 24477, 24500, 24753, 24730, 24478, 24501, 24754, 24731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11942, 24478, 24501, 24754, 24731, 24479, 24502, 24755, 24732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11943, 24479, 24502, 24755, 24732, 24480, 24503, 24756, 24733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11944, 24480, 24503, 24756, 24733, 24481, 24504, 24757, 24734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11945, 24481, 24504, 24757, 24734, 24482, 24505, 24758, 24735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11946, 24482, 24505, 24758, 24735, 24483, 24506, 24759, 24736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11947, 24483, 24506, 24759, 24736, 24484, 24507, 24760, 24737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11948, 24484, 24507, 24760, 24737, 24485, 24508, 24761, 24738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11949, 24485, 24508, 24761, 24738, 24486, 24509, 24762, 24739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11950, 24486, 24509, 24762, 24739, 24487, 24510, 24763, 24740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11951, 24487, 24510, 24763, 24740, 24488, 24511, 24764, 24741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11952, 24488, 24511, 24764, 24741, 24489, 24512, 24765, 24742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11953, 24489, 24512, 24765, 24742, 24490, 24513, 24766, 24743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11954, 24490, 24513, 24766, 24743, 24491, 24514, 24767, 24744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11955, 24491, 24514, 24767, 24744, 24492, 24515, 24768, 24745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11956, 24492, 24515, 24768, 24745, 24493, 24516, 24769, 24746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11957, 24493, 24516, 24769, 24746, 24494, 24517, 24770, 24747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11958, 24494, 24517, 24770, 24747, 24495, 24518, 24771, 24748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11959, 24495, 24518, 24771, 24748, 24496, 24519, 24772, 24749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11960, 24496, 24519, 24772, 24749, 24497, 24520, 24773, 24750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11961, 24497, 24520, 24773, 24750, 5062, 5063, 5074, 5073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11962, 3246, 3247, 3258, 3257, 24498, 24521, 24774, 24751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11963, 24498, 24521, 24774, 24751, 24499, 24522, 24775, 24752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11964, 24499, 24522, 24775, 24752, 24500, 24523, 24776, 24753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11965, 24500, 24523, 24776, 24753, 24501, 24524, 24777, 24754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11966, 24501, 24524, 24777, 24754, 24502, 24525, 24778, 24755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11967, 24502, 24525, 24778, 24755, 24503, 24526, 24779, 24756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11968, 24503, 24526, 24779, 24756, 24504, 24527, 24780, 24757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11969, 24504, 24527, 24780, 24757, 24505, 24528, 24781, 24758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11970, 24505, 24528, 24781, 24758, 24506, 24529, 24782, 24759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11971, 24506, 24529, 24782, 24759, 24507, 24530, 24783, 24760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11972, 24507, 24530, 24783, 24760, 24508, 24531, 24784, 24761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11973, 24508, 24531, 24784, 24761, 24509, 24532, 24785, 24762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11974, 24509, 24532, 24785, 24762, 24510, 24533, 24786, 24763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11975, 24510, 24533, 24786, 24763, 24511, 24534, 24787, 24764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11976, 24511, 24534, 24787, 24764, 24512, 24535, 24788, 24765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11977, 24512, 24535, 24788, 24765, 24513, 24536, 24789, 24766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11978, 24513, 24536, 24789, 24766, 24514, 24537, 24790, 24767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11979, 24514, 24537, 24790, 24767, 24515, 24538, 24791, 24768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11980, 24515, 24538, 24791, 24768, 24516, 24539, 24792, 24769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11981, 24516, 24539, 24792, 24769, 24517, 24540, 24793, 24770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11982, 24517, 24540, 24793, 24770, 24518, 24541, 24794, 24771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11983, 24518, 24541, 24794, 24771, 24519, 24542, 24795, 24772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11984, 24519, 24542, 24795, 24772, 24520, 24543, 24796, 24773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11985, 24520, 24543, 24796, 24773, 5063, 5064, 5075, 5074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11986, 3247, 293, 294, 3258, 24521, 4476, 4499, 24774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11987, 24521, 4476, 4499, 24774, 24522, 4477, 4500, 24775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11988, 24522, 4477, 4500, 24775, 24523, 4478, 4501, 24776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11989, 24523, 4478, 4501, 24776, 24524, 4479, 4502, 24777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11990, 24524, 4479, 4502, 24777, 24525, 4480, 4503, 24778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11991, 24525, 4480, 4503, 24778, 24526, 4481, 4504, 24779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11992, 24526, 4481, 4504, 24779, 24527, 4482, 4505, 24780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11993, 24527, 4482, 4505, 24780, 24528, 4483, 4506, 24781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11994, 24528, 4483, 4506, 24781, 24529, 4484, 4507, 24782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11995, 24529, 4484, 4507, 24782, 24530, 4485, 4508, 24783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11996, 24530, 4485, 4508, 24783, 24531, 4486, 4509, 24784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11997, 24531, 4486, 4509, 24784, 24532, 4487, 4510, 24785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11998, 24532, 4487, 4510, 24785, 24533, 4488, 4511, 24786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11999, 24533, 4488, 4511, 24786, 24534, 4489, 4512, 24787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12000, 24534, 4489, 4512, 24787, 24535, 4490, 4513, 24788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12001, 24535, 4490, 4513, 24788, 24536, 4491, 4514, 24789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12002, 24536, 4491, 4514, 24789, 24537, 4492, 4515, 24790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12003, 24537, 4492, 4515, 24790, 24538, 4493, 4516, 24791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12004, 24538, 4493, 4516, 24791, 24539, 4494, 4517, 24792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12005, 24539, 4494, 4517, 24792, 24540, 4495, 4518, 24793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12006, 24540, 4495, 4518, 24793, 24541, 4496, 4519, 24794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12007, 24541, 4496, 4519, 24794, 24542, 4497, 4520, 24795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12008, 24542, 4497, 4520, 24795, 24543, 4498, 4521, 24796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12009, 24543, 4498, 4521, 24796, 5064, 453, 454, 5075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12010, 260, 3248, 3259, 261, 3717, 24544, 24797, 3740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12011, 3717, 24544, 24797, 3740, 3718, 24545, 24798, 3741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12012, 3718, 24545, 24798, 3741, 3719, 24546, 24799, 3742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12013, 3719, 24546, 24799, 3742, 3720, 24547, 24800, 3743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12014, 3720, 24547, 24800, 3743, 3721, 24548, 24801, 3744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12015, 3721, 24548, 24801, 3744, 3722, 24549, 24802, 3745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12016, 3722, 24549, 24802, 3745, 3723, 24550, 24803, 3746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12017, 3723, 24550, 24803, 3746, 3724, 24551, 24804, 3747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12018, 3724, 24551, 24804, 3747, 3725, 24552, 24805, 3748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12019, 3725, 24552, 24805, 3748, 3726, 24553, 24806, 3749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12020, 3726, 24553, 24806, 3749, 3727, 24554, 24807, 3750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12021, 3727, 24554, 24807, 3750, 3728, 24555, 24808, 3751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12022, 3728, 24555, 24808, 3751, 3729, 24556, 24809, 3752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12023, 3729, 24556, 24809, 3752, 3730, 24557, 24810, 3753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12024, 3730, 24557, 24810, 3753, 3731, 24558, 24811, 3754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12025, 3731, 24558, 24811, 3754, 3732, 24559, 24812, 3755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12026, 3732, 24559, 24812, 3755, 3733, 24560, 24813, 3756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12027, 3733, 24560, 24813, 3756, 3734, 24561, 24814, 3757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12028, 3734, 24561, 24814, 3757, 3735, 24562, 24815, 3758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12029, 3735, 24562, 24815, 3758, 3736, 24563, 24816, 3759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12030, 3736, 24563, 24816, 3759, 3737, 24564, 24817, 3760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12031, 3737, 24564, 24817, 3760, 3738, 24565, 24818, 3761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12032, 3738, 24565, 24818, 3761, 3739, 24566, 24819, 3762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12033, 3739, 24566, 24819, 3762, 374, 5065, 5076, 375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12034, 3248, 3249, 3260, 3259, 24544, 24567, 24820, 24797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12035, 24544, 24567, 24820, 24797, 24545, 24568, 24821, 24798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12036, 24545, 24568, 24821, 24798, 24546, 24569, 24822, 24799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12037, 24546, 24569, 24822, 24799, 24547, 24570, 24823, 24800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12038, 24547, 24570, 24823, 24800, 24548, 24571, 24824, 24801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12039, 24548, 24571, 24824, 24801, 24549, 24572, 24825, 24802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12040, 24549, 24572, 24825, 24802, 24550, 24573, 24826, 24803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12041, 24550, 24573, 24826, 24803, 24551, 24574, 24827, 24804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12042, 24551, 24574, 24827, 24804, 24552, 24575, 24828, 24805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12043, 24552, 24575, 24828, 24805, 24553, 24576, 24829, 24806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12044, 24553, 24576, 24829, 24806, 24554, 24577, 24830, 24807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12045, 24554, 24577, 24830, 24807, 24555, 24578, 24831, 24808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12046, 24555, 24578, 24831, 24808, 24556, 24579, 24832, 24809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12047, 24556, 24579, 24832, 24809, 24557, 24580, 24833, 24810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12048, 24557, 24580, 24833, 24810, 24558, 24581, 24834, 24811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12049, 24558, 24581, 24834, 24811, 24559, 24582, 24835, 24812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12050, 24559, 24582, 24835, 24812, 24560, 24583, 24836, 24813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12051, 24560, 24583, 24836, 24813, 24561, 24584, 24837, 24814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12052, 24561, 24584, 24837, 24814, 24562, 24585, 24838, 24815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12053, 24562, 24585, 24838, 24815, 24563, 24586, 24839, 24816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12054, 24563, 24586, 24839, 24816, 24564, 24587, 24840, 24817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12055, 24564, 24587, 24840, 24817, 24565, 24588, 24841, 24818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12056, 24565, 24588, 24841, 24818, 24566, 24589, 24842, 24819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12057, 24566, 24589, 24842, 24819, 5065, 5066, 5077, 5076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12058, 3249, 3250, 3261, 3260, 24567, 24590, 24843, 24820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12059, 24567, 24590, 24843, 24820, 24568, 24591, 24844, 24821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12060, 24568, 24591, 24844, 24821, 24569, 24592, 24845, 24822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12061, 24569, 24592, 24845, 24822, 24570, 24593, 24846, 24823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12062, 24570, 24593, 24846, 24823, 24571, 24594, 24847, 24824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12063, 24571, 24594, 24847, 24824, 24572, 24595, 24848, 24825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12064, 24572, 24595, 24848, 24825, 24573, 24596, 24849, 24826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12065, 24573, 24596, 24849, 24826, 24574, 24597, 24850, 24827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12066, 24574, 24597, 24850, 24827, 24575, 24598, 24851, 24828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12067, 24575, 24598, 24851, 24828, 24576, 24599, 24852, 24829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12068, 24576, 24599, 24852, 24829, 24577, 24600, 24853, 24830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12069, 24577, 24600, 24853, 24830, 24578, 24601, 24854, 24831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12070, 24578, 24601, 24854, 24831, 24579, 24602, 24855, 24832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12071, 24579, 24602, 24855, 24832, 24580, 24603, 24856, 24833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12072, 24580, 24603, 24856, 24833, 24581, 24604, 24857, 24834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12073, 24581, 24604, 24857, 24834, 24582, 24605, 24858, 24835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12074, 24582, 24605, 24858, 24835, 24583, 24606, 24859, 24836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12075, 24583, 24606, 24859, 24836, 24584, 24607, 24860, 24837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12076, 24584, 24607, 24860, 24837, 24585, 24608, 24861, 24838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12077, 24585, 24608, 24861, 24838, 24586, 24609, 24862, 24839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12078, 24586, 24609, 24862, 24839, 24587, 24610, 24863, 24840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12079, 24587, 24610, 24863, 24840, 24588, 24611, 24864, 24841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12080, 24588, 24611, 24864, 24841, 24589, 24612, 24865, 24842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12081, 24589, 24612, 24865, 24842, 5066, 5067, 5078, 5077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12082, 3250, 3251, 3262, 3261, 24590, 24613, 24866, 24843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12083, 24590, 24613, 24866, 24843, 24591, 24614, 24867, 24844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12084, 24591, 24614, 24867, 24844, 24592, 24615, 24868, 24845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12085, 24592, 24615, 24868, 24845, 24593, 24616, 24869, 24846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12086, 24593, 24616, 24869, 24846, 24594, 24617, 24870, 24847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12087, 24594, 24617, 24870, 24847, 24595, 24618, 24871, 24848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12088, 24595, 24618, 24871, 24848, 24596, 24619, 24872, 24849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12089, 24596, 24619, 24872, 24849, 24597, 24620, 24873, 24850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12090, 24597, 24620, 24873, 24850, 24598, 24621, 24874, 24851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12091, 24598, 24621, 24874, 24851, 24599, 24622, 24875, 24852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12092, 24599, 24622, 24875, 24852, 24600, 24623, 24876, 24853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12093, 24600, 24623, 24876, 24853, 24601, 24624, 24877, 24854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12094, 24601, 24624, 24877, 24854, 24602, 24625, 24878, 24855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12095, 24602, 24625, 24878, 24855, 24603, 24626, 24879, 24856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12096, 24603, 24626, 24879, 24856, 24604, 24627, 24880, 24857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12097, 24604, 24627, 24880, 24857, 24605, 24628, 24881, 24858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12098, 24605, 24628, 24881, 24858, 24606, 24629, 24882, 24859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12099, 24606, 24629, 24882, 24859, 24607, 24630, 24883, 24860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12100, 24607, 24630, 24883, 24860, 24608, 24631, 24884, 24861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12101, 24608, 24631, 24884, 24861, 24609, 24632, 24885, 24862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12102, 24609, 24632, 24885, 24862, 24610, 24633, 24886, 24863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12103, 24610, 24633, 24886, 24863, 24611, 24634, 24887, 24864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12104, 24611, 24634, 24887, 24864, 24612, 24635, 24888, 24865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12105, 24612, 24635, 24888, 24865, 5067, 5068, 5079, 5078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12106, 3251, 3252, 3263, 3262, 24613, 24636, 24889, 24866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12107, 24613, 24636, 24889, 24866, 24614, 24637, 24890, 24867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12108, 24614, 24637, 24890, 24867, 24615, 24638, 24891, 24868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12109, 24615, 24638, 24891, 24868, 24616, 24639, 24892, 24869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12110, 24616, 24639, 24892, 24869, 24617, 24640, 24893, 24870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12111, 24617, 24640, 24893, 24870, 24618, 24641, 24894, 24871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12112, 24618, 24641, 24894, 24871, 24619, 24642, 24895, 24872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12113, 24619, 24642, 24895, 24872, 24620, 24643, 24896, 24873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12114, 24620, 24643, 24896, 24873, 24621, 24644, 24897, 24874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12115, 24621, 24644, 24897, 24874, 24622, 24645, 24898, 24875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12116, 24622, 24645, 24898, 24875, 24623, 24646, 24899, 24876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12117, 24623, 24646, 24899, 24876, 24624, 24647, 24900, 24877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12118, 24624, 24647, 24900, 24877, 24625, 24648, 24901, 24878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12119, 24625, 24648, 24901, 24878, 24626, 24649, 24902, 24879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12120, 24626, 24649, 24902, 24879, 24627, 24650, 24903, 24880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12121, 24627, 24650, 24903, 24880, 24628, 24651, 24904, 24881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12122, 24628, 24651, 24904, 24881, 24629, 24652, 24905, 24882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12123, 24629, 24652, 24905, 24882, 24630, 24653, 24906, 24883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12124, 24630, 24653, 24906, 24883, 24631, 24654, 24907, 24884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12125, 24631, 24654, 24907, 24884, 24632, 24655, 24908, 24885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12126, 24632, 24655, 24908, 24885, 24633, 24656, 24909, 24886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12127, 24633, 24656, 24909, 24886, 24634, 24657, 24910, 24887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12128, 24634, 24657, 24910, 24887, 24635, 24658, 24911, 24888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12129, 24635, 24658, 24911, 24888, 5068, 5069, 5080, 5079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12130, 3252, 3253, 3264, 3263, 24636, 24659, 24912, 24889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12131, 24636, 24659, 24912, 24889, 24637, 24660, 24913, 24890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12132, 24637, 24660, 24913, 24890, 24638, 24661, 24914, 24891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12133, 24638, 24661, 24914, 24891, 24639, 24662, 24915, 24892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12134, 24639, 24662, 24915, 24892, 24640, 24663, 24916, 24893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12135, 24640, 24663, 24916, 24893, 24641, 24664, 24917, 24894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12136, 24641, 24664, 24917, 24894, 24642, 24665, 24918, 24895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12137, 24642, 24665, 24918, 24895, 24643, 24666, 24919, 24896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12138, 24643, 24666, 24919, 24896, 24644, 24667, 24920, 24897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12139, 24644, 24667, 24920, 24897, 24645, 24668, 24921, 24898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12140, 24645, 24668, 24921, 24898, 24646, 24669, 24922, 24899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12141, 24646, 24669, 24922, 24899, 24647, 24670, 24923, 24900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12142, 24647, 24670, 24923, 24900, 24648, 24671, 24924, 24901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12143, 24648, 24671, 24924, 24901, 24649, 24672, 24925, 24902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12144, 24649, 24672, 24925, 24902, 24650, 24673, 24926, 24903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12145, 24650, 24673, 24926, 24903, 24651, 24674, 24927, 24904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12146, 24651, 24674, 24927, 24904, 24652, 24675, 24928, 24905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12147, 24652, 24675, 24928, 24905, 24653, 24676, 24929, 24906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12148, 24653, 24676, 24929, 24906, 24654, 24677, 24930, 24907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12149, 24654, 24677, 24930, 24907, 24655, 24678, 24931, 24908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12150, 24655, 24678, 24931, 24908, 24656, 24679, 24932, 24909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12151, 24656, 24679, 24932, 24909, 24657, 24680, 24933, 24910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12152, 24657, 24680, 24933, 24910, 24658, 24681, 24934, 24911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12153, 24658, 24681, 24934, 24911, 5069, 5070, 5081, 5080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12154, 3253, 3254, 3265, 3264, 24659, 24682, 24935, 24912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12155, 24659, 24682, 24935, 24912, 24660, 24683, 24936, 24913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12156, 24660, 24683, 24936, 24913, 24661, 24684, 24937, 24914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12157, 24661, 24684, 24937, 24914, 24662, 24685, 24938, 24915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12158, 24662, 24685, 24938, 24915, 24663, 24686, 24939, 24916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12159, 24663, 24686, 24939, 24916, 24664, 24687, 24940, 24917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12160, 24664, 24687, 24940, 24917, 24665, 24688, 24941, 24918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12161, 24665, 24688, 24941, 24918, 24666, 24689, 24942, 24919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12162, 24666, 24689, 24942, 24919, 24667, 24690, 24943, 24920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12163, 24667, 24690, 24943, 24920, 24668, 24691, 24944, 24921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12164, 24668, 24691, 24944, 24921, 24669, 24692, 24945, 24922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12165, 24669, 24692, 24945, 24922, 24670, 24693, 24946, 24923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12166, 24670, 24693, 24946, 24923, 24671, 24694, 24947, 24924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12167, 24671, 24694, 24947, 24924, 24672, 24695, 24948, 24925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12168, 24672, 24695, 24948, 24925, 24673, 24696, 24949, 24926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12169, 24673, 24696, 24949, 24926, 24674, 24697, 24950, 24927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12170, 24674, 24697, 24950, 24927, 24675, 24698, 24951, 24928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12171, 24675, 24698, 24951, 24928, 24676, 24699, 24952, 24929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12172, 24676, 24699, 24952, 24929, 24677, 24700, 24953, 24930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12173, 24677, 24700, 24953, 24930, 24678, 24701, 24954, 24931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12174, 24678, 24701, 24954, 24931, 24679, 24702, 24955, 24932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12175, 24679, 24702, 24955, 24932, 24680, 24703, 24956, 24933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12176, 24680, 24703, 24956, 24933, 24681, 24704, 24957, 24934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12177, 24681, 24704, 24957, 24934, 5070, 5071, 5082, 5081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12178, 3254, 3255, 3266, 3265, 24682, 24705, 24958, 24935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12179, 24682, 24705, 24958, 24935, 24683, 24706, 24959, 24936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12180, 24683, 24706, 24959, 24936, 24684, 24707, 24960, 24937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12181, 24684, 24707, 24960, 24937, 24685, 24708, 24961, 24938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12182, 24685, 24708, 24961, 24938, 24686, 24709, 24962, 24939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12183, 24686, 24709, 24962, 24939, 24687, 24710, 24963, 24940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12184, 24687, 24710, 24963, 24940, 24688, 24711, 24964, 24941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12185, 24688, 24711, 24964, 24941, 24689, 24712, 24965, 24942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12186, 24689, 24712, 24965, 24942, 24690, 24713, 24966, 24943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12187, 24690, 24713, 24966, 24943, 24691, 24714, 24967, 24944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12188, 24691, 24714, 24967, 24944, 24692, 24715, 24968, 24945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12189, 24692, 24715, 24968, 24945, 24693, 24716, 24969, 24946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12190, 24693, 24716, 24969, 24946, 24694, 24717, 24970, 24947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12191, 24694, 24717, 24970, 24947, 24695, 24718, 24971, 24948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12192, 24695, 24718, 24971, 24948, 24696, 24719, 24972, 24949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12193, 24696, 24719, 24972, 24949, 24697, 24720, 24973, 24950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12194, 24697, 24720, 24973, 24950, 24698, 24721, 24974, 24951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12195, 24698, 24721, 24974, 24951, 24699, 24722, 24975, 24952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12196, 24699, 24722, 24975, 24952, 24700, 24723, 24976, 24953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12197, 24700, 24723, 24976, 24953, 24701, 24724, 24977, 24954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12198, 24701, 24724, 24977, 24954, 24702, 24725, 24978, 24955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12199, 24702, 24725, 24978, 24955, 24703, 24726, 24979, 24956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12200, 24703, 24726, 24979, 24956, 24704, 24727, 24980, 24957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12201, 24704, 24727, 24980, 24957, 5071, 5072, 5083, 5082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12202, 3255, 3256, 3267, 3266, 24705, 24728, 24981, 24958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12203, 24705, 24728, 24981, 24958, 24706, 24729, 24982, 24959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12204, 24706, 24729, 24982, 24959, 24707, 24730, 24983, 24960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12205, 24707, 24730, 24983, 24960, 24708, 24731, 24984, 24961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12206, 24708, 24731, 24984, 24961, 24709, 24732, 24985, 24962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12207, 24709, 24732, 24985, 24962, 24710, 24733, 24986, 24963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12208, 24710, 24733, 24986, 24963, 24711, 24734, 24987, 24964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12209, 24711, 24734, 24987, 24964, 24712, 24735, 24988, 24965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12210, 24712, 24735, 24988, 24965, 24713, 24736, 24989, 24966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12211, 24713, 24736, 24989, 24966, 24714, 24737, 24990, 24967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12212, 24714, 24737, 24990, 24967, 24715, 24738, 24991, 24968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12213, 24715, 24738, 24991, 24968, 24716, 24739, 24992, 24969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12214, 24716, 24739, 24992, 24969, 24717, 24740, 24993, 24970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12215, 24717, 24740, 24993, 24970, 24718, 24741, 24994, 24971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12216, 24718, 24741, 24994, 24971, 24719, 24742, 24995, 24972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12217, 24719, 24742, 24995, 24972, 24720, 24743, 24996, 24973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12218, 24720, 24743, 24996, 24973, 24721, 24744, 24997, 24974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12219, 24721, 24744, 24997, 24974, 24722, 24745, 24998, 24975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12220, 24722, 24745, 24998, 24975, 24723, 24746, 24999, 24976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12221, 24723, 24746, 24999, 24976, 24724, 24747, 25000, 24977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12222, 24724, 24747, 25000, 24977, 24725, 24748, 25001, 24978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12223, 24725, 24748, 25001, 24978, 24726, 24749, 25002, 24979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12224, 24726, 24749, 25002, 24979, 24727, 24750, 25003, 24980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12225, 24727, 24750, 25003, 24980, 5072, 5073, 5084, 5083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12226, 3256, 3257, 3268, 3267, 24728, 24751, 25004, 24981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12227, 24728, 24751, 25004, 24981, 24729, 24752, 25005, 24982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12228, 24729, 24752, 25005, 24982, 24730, 24753, 25006, 24983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12229, 24730, 24753, 25006, 24983, 24731, 24754, 25007, 24984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12230, 24731, 24754, 25007, 24984, 24732, 24755, 25008, 24985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12231, 24732, 24755, 25008, 24985, 24733, 24756, 25009, 24986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12232, 24733, 24756, 25009, 24986, 24734, 24757, 25010, 24987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12233, 24734, 24757, 25010, 24987, 24735, 24758, 25011, 24988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12234, 24735, 24758, 25011, 24988, 24736, 24759, 25012, 24989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12235, 24736, 24759, 25012, 24989, 24737, 24760, 25013, 24990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12236, 24737, 24760, 25013, 24990, 24738, 24761, 25014, 24991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12237, 24738, 24761, 25014, 24991, 24739, 24762, 25015, 24992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12238, 24739, 24762, 25015, 24992, 24740, 24763, 25016, 24993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12239, 24740, 24763, 25016, 24993, 24741, 24764, 25017, 24994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12240, 24741, 24764, 25017, 24994, 24742, 24765, 25018, 24995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12241, 24742, 24765, 25018, 24995, 24743, 24766, 25019, 24996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12242, 24743, 24766, 25019, 24996, 24744, 24767, 25020, 24997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12243, 24744, 24767, 25020, 24997, 24745, 24768, 25021, 24998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12244, 24745, 24768, 25021, 24998, 24746, 24769, 25022, 24999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12245, 24746, 24769, 25022, 24999, 24747, 24770, 25023, 25000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12246, 24747, 24770, 25023, 25000, 24748, 24771, 25024, 25001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12247, 24748, 24771, 25024, 25001, 24749, 24772, 25025, 25002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12248, 24749, 24772, 25025, 25002, 24750, 24773, 25026, 25003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12249, 24750, 24773, 25026, 25003, 5073, 5074, 5085, 5084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12250, 3257, 3258, 3269, 3268, 24751, 24774, 25027, 25004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12251, 24751, 24774, 25027, 25004, 24752, 24775, 25028, 25005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12252, 24752, 24775, 25028, 25005, 24753, 24776, 25029, 25006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12253, 24753, 24776, 25029, 25006, 24754, 24777, 25030, 25007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12254, 24754, 24777, 25030, 25007, 24755, 24778, 25031, 25008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12255, 24755, 24778, 25031, 25008, 24756, 24779, 25032, 25009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12256, 24756, 24779, 25032, 25009, 24757, 24780, 25033, 25010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12257, 24757, 24780, 25033, 25010, 24758, 24781, 25034, 25011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12258, 24758, 24781, 25034, 25011, 24759, 24782, 25035, 25012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12259, 24759, 24782, 25035, 25012, 24760, 24783, 25036, 25013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12260, 24760, 24783, 25036, 25013, 24761, 24784, 25037, 25014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12261, 24761, 24784, 25037, 25014, 24762, 24785, 25038, 25015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12262, 24762, 24785, 25038, 25015, 24763, 24786, 25039, 25016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12263, 24763, 24786, 25039, 25016, 24764, 24787, 25040, 25017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12264, 24764, 24787, 25040, 25017, 24765, 24788, 25041, 25018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12265, 24765, 24788, 25041, 25018, 24766, 24789, 25042, 25019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12266, 24766, 24789, 25042, 25019, 24767, 24790, 25043, 25020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12267, 24767, 24790, 25043, 25020, 24768, 24791, 25044, 25021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12268, 24768, 24791, 25044, 25021, 24769, 24792, 25045, 25022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12269, 24769, 24792, 25045, 25022, 24770, 24793, 25046, 25023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12270, 24770, 24793, 25046, 25023, 24771, 24794, 25047, 25024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12271, 24771, 24794, 25047, 25024, 24772, 24795, 25048, 25025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12272, 24772, 24795, 25048, 25025, 24773, 24796, 25049, 25026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12273, 24773, 24796, 25049, 25026, 5074, 5075, 5086, 5085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12274, 3258, 294, 295, 3269, 24774, 4499, 4522, 25027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12275, 24774, 4499, 4522, 25027, 24775, 4500, 4523, 25028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12276, 24775, 4500, 4523, 25028, 24776, 4501, 4524, 25029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12277, 24776, 4501, 4524, 25029, 24777, 4502, 4525, 25030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12278, 24777, 4502, 4525, 25030, 24778, 4503, 4526, 25031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12279, 24778, 4503, 4526, 25031, 24779, 4504, 4527, 25032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12280, 24779, 4504, 4527, 25032, 24780, 4505, 4528, 25033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12281, 24780, 4505, 4528, 25033, 24781, 4506, 4529, 25034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12282, 24781, 4506, 4529, 25034, 24782, 4507, 4530, 25035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12283, 24782, 4507, 4530, 25035, 24783, 4508, 4531, 25036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12284, 24783, 4508, 4531, 25036, 24784, 4509, 4532, 25037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12285, 24784, 4509, 4532, 25037, 24785, 4510, 4533, 25038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12286, 24785, 4510, 4533, 25038, 24786, 4511, 4534, 25039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12287, 24786, 4511, 4534, 25039, 24787, 4512, 4535, 25040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12288, 24787, 4512, 4535, 25040, 24788, 4513, 4536, 25041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12289, 24788, 4513, 4536, 25041, 24789, 4514, 4537, 25042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12290, 24789, 4514, 4537, 25042, 24790, 4515, 4538, 25043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12291, 24790, 4515, 4538, 25043, 24791, 4516, 4539, 25044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12292, 24791, 4516, 4539, 25044, 24792, 4517, 4540, 25045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12293, 24792, 4517, 4540, 25045, 24793, 4518, 4541, 25046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12294, 24793, 4518, 4541, 25046, 24794, 4519, 4542, 25047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12295, 24794, 4519, 4542, 25047, 24795, 4520, 4543, 25048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12296, 24795, 4520, 4543, 25048, 24796, 4521, 4544, 25049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12297, 24796, 4521, 4544, 25049, 5075, 454, 455, 5086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12298, 261, 3259, 3270, 262, 3740, 24797, 25050, 3763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12299, 3740, 24797, 25050, 3763, 3741, 24798, 25051, 3764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12300, 3741, 24798, 25051, 3764, 3742, 24799, 25052, 3765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12301, 3742, 24799, 25052, 3765, 3743, 24800, 25053, 3766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12302, 3743, 24800, 25053, 3766, 3744, 24801, 25054, 3767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12303, 3744, 24801, 25054, 3767, 3745, 24802, 25055, 3768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12304, 3745, 24802, 25055, 3768, 3746, 24803, 25056, 3769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12305, 3746, 24803, 25056, 3769, 3747, 24804, 25057, 3770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12306, 3747, 24804, 25057, 3770, 3748, 24805, 25058, 3771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12307, 3748, 24805, 25058, 3771, 3749, 24806, 25059, 3772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12308, 3749, 24806, 25059, 3772, 3750, 24807, 25060, 3773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12309, 3750, 24807, 25060, 3773, 3751, 24808, 25061, 3774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12310, 3751, 24808, 25061, 3774, 3752, 24809, 25062, 3775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12311, 3752, 24809, 25062, 3775, 3753, 24810, 25063, 3776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12312, 3753, 24810, 25063, 3776, 3754, 24811, 25064, 3777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12313, 3754, 24811, 25064, 3777, 3755, 24812, 25065, 3778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12314, 3755, 24812, 25065, 3778, 3756, 24813, 25066, 3779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12315, 3756, 24813, 25066, 3779, 3757, 24814, 25067, 3780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12316, 3757, 24814, 25067, 3780, 3758, 24815, 25068, 3781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12317, 3758, 24815, 25068, 3781, 3759, 24816, 25069, 3782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12318, 3759, 24816, 25069, 3782, 3760, 24817, 25070, 3783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12319, 3760, 24817, 25070, 3783, 3761, 24818, 25071, 3784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12320, 3761, 24818, 25071, 3784, 3762, 24819, 25072, 3785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12321, 3762, 24819, 25072, 3785, 375, 5076, 5087, 376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12322, 3259, 3260, 3271, 3270, 24797, 24820, 25073, 25050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12323, 24797, 24820, 25073, 25050, 24798, 24821, 25074, 25051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12324, 24798, 24821, 25074, 25051, 24799, 24822, 25075, 25052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12325, 24799, 24822, 25075, 25052, 24800, 24823, 25076, 25053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12326, 24800, 24823, 25076, 25053, 24801, 24824, 25077, 25054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12327, 24801, 24824, 25077, 25054, 24802, 24825, 25078, 25055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12328, 24802, 24825, 25078, 25055, 24803, 24826, 25079, 25056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12329, 24803, 24826, 25079, 25056, 24804, 24827, 25080, 25057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12330, 24804, 24827, 25080, 25057, 24805, 24828, 25081, 25058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12331, 24805, 24828, 25081, 25058, 24806, 24829, 25082, 25059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12332, 24806, 24829, 25082, 25059, 24807, 24830, 25083, 25060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12333, 24807, 24830, 25083, 25060, 24808, 24831, 25084, 25061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12334, 24808, 24831, 25084, 25061, 24809, 24832, 25085, 25062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12335, 24809, 24832, 25085, 25062, 24810, 24833, 25086, 25063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12336, 24810, 24833, 25086, 25063, 24811, 24834, 25087, 25064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12337, 24811, 24834, 25087, 25064, 24812, 24835, 25088, 25065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12338, 24812, 24835, 25088, 25065, 24813, 24836, 25089, 25066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
