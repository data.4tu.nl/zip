27292, 16256, 41399, 41403, 16260, 16257, 41400, 41404, 16261, 41577, 41589, 41590, 16281, 41580, 41592, 41593, 
16283, 16275, 41578, 41591, 16284
27293, 16257, 41400, 41404, 16261, 16258, 41401, 41405, 16262, 41580, 41592, 41593, 16283, 41583, 41595, 41596, 
16285, 16277, 41581, 41594, 16286
27294, 16258, 41401, 41405, 16262, 16259, 41402, 41406, 16263, 41583, 41595, 41596, 16285, 41586, 41598, 41599, 
16287, 16279, 41584, 41597, 16288
27295, 16259, 41402, 41406, 16263, 2087, 16459, 16460, 2088, 41586, 41598, 41599, 16287, 0, 0, 0, 
0, 16280, 41587, 41600, 16289
27296, 629, 5823, 5824, 630, 16260, 41403, 41407, 16264, 0, 0, 0, 0, 41590, 41602, 41603, 
16290, 16282, 41588, 41601, 16291
27297, 16260, 41403, 41407, 16264, 16261, 41404, 41408, 16265, 41590, 41602, 41603, 16290, 41593, 41605, 41606, 
16292, 16284, 41591, 41604, 16293
27298, 16261, 41404, 41408, 16265, 16262, 41405, 41409, 16266, 41593, 41605, 41606, 16292, 41596, 41608, 41609, 
16294, 16286, 41594, 41607, 16295
27299, 16262, 41405, 41409, 16266, 16263, 41406, 41410, 16267, 41596, 41608, 41609, 16294, 41599, 41611, 41612, 
16296, 16288, 41597, 41610, 16297
27300, 16263, 41406, 41410, 16267, 2088, 16460, 16461, 2089, 41599, 41611, 41612, 16296, 0, 0, 0, 
0, 16289, 41600, 41613, 16298
27301, 630, 5824, 5825, 631, 16264, 41407, 41411, 16268, 0, 0, 0, 0, 41603, 41615, 41616, 
16299, 16291, 41601, 41614, 16300
27302, 16264, 41407, 41411, 16268, 16265, 41408, 41412, 16269, 41603, 41615, 41616, 16299, 41606, 41618, 41619, 
16301, 16293, 41604, 41617, 16302
27303, 16265, 41408, 41412, 16269, 16266, 41409, 41413, 16270, 41606, 41618, 41619, 16301, 41609, 41621, 41622, 
16303, 16295, 41607, 41620, 16304
27304, 16266, 41409, 41413, 16270, 16267, 41410, 41414, 16271, 41609, 41621, 41622, 16303, 41612, 41624, 41625, 
16305, 16297, 41610, 41623, 16306
27305, 16267, 41410, 41414, 16271, 2089, 16461, 16462, 2090, 41612, 41624, 41625, 16305, 0, 0, 0, 
0, 16298, 41613, 41626, 16307
27306, 631, 5825, 645, 28, 16268, 41411, 16312, 2078, 0, 0, 0, 0, 41616, 41627, 16356, 
16308, 16300, 41614, 16357, 2082
27307, 16268, 41411, 16312, 2078, 16269, 41412, 16313, 2079, 41616, 41627, 16356, 16308, 41619, 41628, 16358, 
16309, 16302, 41617, 16359, 2083
27308, 16269, 41412, 16313, 2079, 16270, 41413, 16314, 2080, 41619, 41628, 16358, 16309, 41622, 41629, 16360, 
16310, 16304, 41620, 16361, 2084
27309, 16270, 41413, 16314, 2080, 16271, 41414, 16315, 2081, 41622, 41629, 16360, 16310, 41625, 41630, 16362, 
16311, 16306, 41623, 16363, 2085
27310, 16271, 41414, 16315, 2081, 2090, 16462, 2091, 82, 41625, 41630, 16362, 16311, 0, 0, 0, 
0, 16307, 41626, 16364, 2086
27311, 567, 568, 5826, 5822, 15601, 15605, 41415, 41399, 0, 0, 0, 0, 15654, 41632, 41633, 
41576, 15646, 15655, 41631, 41575
27312, 15601, 15605, 41415, 41399, 15602, 15606, 41416, 41400, 15654, 41632, 41633, 41576, 15656, 41635, 41636, 
41579, 15648, 15657, 41634, 41578
27313, 15602, 15606, 41416, 41400, 15603, 15607, 41417, 41401, 15656, 41635, 41636, 41579, 15658, 41638, 41639, 
41582, 15650, 15659, 41637, 41581
27314, 15603, 15607, 41417, 41401, 15604, 15608, 41418, 41402, 15658, 41638, 41639, 41582, 15660, 41641, 41642, 
41585, 15652, 15661, 41640, 41584
27315, 15604, 15608, 41418, 41402, 2021, 2022, 16463, 16459, 15660, 41641, 41642, 41585, 0, 0, 0, 
0, 15653, 15662, 41643, 41587
27316, 5822, 5826, 5827, 5823, 41399, 41415, 41419, 41403, 0, 0, 0, 0, 41633, 41645, 41646, 
41589, 41575, 41631, 41644, 41588
27317, 41399, 41415, 41419, 41403, 41400, 41416, 41420, 41404, 41633, 41645, 41646, 41589, 41636, 41648, 41649, 
41592, 41578, 41634, 41647, 41591
27318, 41400, 41416, 41420, 41404, 41401, 41417, 41421, 41405, 41636, 41648, 41649, 41592, 41639, 41651, 41652, 
41595, 41581, 41637, 41650, 41594
27319, 41401, 41417, 41421, 41405, 41402, 41418, 41422, 41406, 41639, 41651, 41652, 41595, 41642, 41654, 41655, 
41598, 41584, 41640, 41653, 41597
27320, 41402, 41418, 41422, 41406, 16459, 16463, 16464, 16460, 41642, 41654, 41655, 41598, 0, 0, 0, 
0, 41587, 41643, 41656, 41600
27321, 5823, 5827, 5828, 5824, 41403, 41419, 41423, 41407, 0, 0, 0, 0, 41646, 41658, 41659, 
41602, 41588, 41644, 41657, 41601
27322, 41403, 41419, 41423, 41407, 41404, 41420, 41424, 41408, 41646, 41658, 41659, 41602, 41649, 41661, 41662, 
41605, 41591, 41647, 41660, 41604
27323, 41404, 41420, 41424, 41408, 41405, 41421, 41425, 41409, 41649, 41661, 41662, 41605, 41652, 41664, 41665, 
41608, 41594, 41650, 41663, 41607
27324, 41405, 41421, 41425, 41409, 41406, 41422, 41426, 41410, 41652, 41664, 41665, 41608, 41655, 41667, 41668, 
41611, 41597, 41653, 41666, 41610
27325, 41406, 41422, 41426, 41410, 16460, 16464, 16465, 16461, 41655, 41667, 41668, 41611, 0, 0, 0, 
0, 41600, 41656, 41669, 41613
27326, 5824, 5828, 5829, 5825, 41407, 41423, 41427, 41411, 0, 0, 0, 0, 41659, 41671, 41672, 
41615, 41601, 41657, 41670, 41614
27327, 41407, 41423, 41427, 41411, 41408, 41424, 41428, 41412, 41659, 41671, 41672, 41615, 41662, 41674, 41675, 
41618, 41604, 41660, 41673, 41617
27328, 41408, 41424, 41428, 41412, 41409, 41425, 41429, 41413, 41662, 41674, 41675, 41618, 41665, 41677, 41678, 
41621, 41607, 41663, 41676, 41620
27329, 41409, 41425, 41429, 41413, 41410, 41426, 41430, 41414, 41665, 41677, 41678, 41621, 41668, 41680, 41681, 
41624, 41610, 41666, 41679, 41623
27330, 41410, 41426, 41430, 41414, 16461, 16465, 16466, 16462, 41668, 41680, 41681, 41624, 0, 0, 0, 
0, 41613, 41669, 41682, 41626
27331, 5825, 5829, 646, 645, 41411, 41427, 16316, 16312, 0, 0, 0, 0, 41672, 41683, 16365, 
41627, 41614, 41670, 16366, 16357
27332, 41411, 41427, 16316, 16312, 41412, 41428, 16317, 16313, 41672, 41683, 16365, 41627, 41675, 41684, 16367, 
41628, 41617, 41673, 16368, 16359
27333, 41412, 41428, 16317, 16313, 41413, 41429, 16318, 16314, 41675, 41684, 16367, 41628, 41678, 41685, 16369, 
41629, 41620, 41676, 16370, 16361
27334, 41413, 41429, 16318, 16314, 41414, 41430, 16319, 16315, 41678, 41685, 16369, 41629, 41681, 41686, 16371, 
41630, 41623, 41679, 16372, 16363
27335, 41414, 41430, 16319, 16315, 16462, 16466, 2092, 2091, 41681, 41686, 16371, 41630, 0, 0, 0, 
0, 41626, 41682, 16373, 16364
27336, 568, 569, 5830, 5826, 15605, 15609, 41431, 41415, 0, 0, 0, 0, 15663, 41688, 41689, 
41632, 15655, 15664, 41687, 41631
27337, 15605, 15609, 41431, 41415, 15606, 15610, 41432, 41416, 15663, 41688, 41689, 41632, 15665, 41691, 41692, 
41635, 15657, 15666, 41690, 41634
27338, 15606, 15610, 41432, 41416, 15607, 15611, 41433, 41417, 15665, 41691, 41692, 41635, 15667, 41694, 41695, 
41638, 15659, 15668, 41693, 41637
27339, 15607, 15611, 41433, 41417, 15608, 15612, 41434, 41418, 15667, 41694, 41695, 41638, 15669, 41697, 41698, 
41641, 15661, 15670, 41696, 41640
27340, 15608, 15612, 41434, 41418, 2022, 2023, 16467, 16463, 15669, 41697, 41698, 41641, 0, 0, 0, 
0, 15662, 15671, 41699, 41643
27341, 5826, 5830, 5831, 5827, 41415, 41431, 41435, 41419, 0, 0, 0, 0, 41689, 41701, 41702, 
41645, 41631, 41687, 41700, 41644
27342, 41415, 41431, 41435, 41419, 41416, 41432, 41436, 41420, 41689, 41701, 41702, 41645, 41692, 41704, 41705, 
41648, 41634, 41690, 41703, 41647
27343, 41416, 41432, 41436, 41420, 41417, 41433, 41437, 41421, 41692, 41704, 41705, 41648, 41695, 41707, 41708, 
41651, 41637, 41693, 41706, 41650
27344, 41417, 41433, 41437, 41421, 41418, 41434, 41438, 41422, 41695, 41707, 41708, 41651, 41698, 41710, 41711, 
41654, 41640, 41696, 41709, 41653
27345, 41418, 41434, 41438, 41422, 16463, 16467, 16468, 16464, 41698, 41710, 41711, 41654, 0, 0, 0, 
0, 41643, 41699, 41712, 41656
27346, 5827, 5831, 5832, 5828, 41419, 41435, 41439, 41423, 0, 0, 0, 0, 41702, 41714, 41715, 
41658, 41644, 41700, 41713, 41657
27347, 41419, 41435, 41439, 41423, 41420, 41436, 41440, 41424, 41702, 41714, 41715, 41658, 41705, 41717, 41718, 
41661, 41647, 41703, 41716, 41660
27348, 41420, 41436, 41440, 41424, 41421, 41437, 41441, 41425, 41705, 41717, 41718, 41661, 41708, 41720, 41721, 
41664, 41650, 41706, 41719, 41663
27349, 41421, 41437, 41441, 41425, 41422, 41438, 41442, 41426, 41708, 41720, 41721, 41664, 41711, 41723, 41724, 
41667, 41653, 41709, 41722, 41666
27350, 41422, 41438, 41442, 41426, 16464, 16468, 16469, 16465, 41711, 41723, 41724, 41667, 0, 0, 0, 
0, 41656, 41712, 41725, 41669
27351, 5828, 5832, 5833, 5829, 41423, 41439, 41443, 41427, 0, 0, 0, 0, 41715, 41727, 41728, 
41671, 41657, 41713, 41726, 41670
27352, 41423, 41439, 41443, 41427, 41424, 41440, 41444, 41428, 41715, 41727, 41728, 41671, 41718, 41730, 41731, 
41674, 41660, 41716, 41729, 41673
27353, 41424, 41440, 41444, 41428, 41425, 41441, 41445, 41429, 41718, 41730, 41731, 41674, 41721, 41733, 41734, 
41677, 41663, 41719, 41732, 41676
27354, 41425, 41441, 41445, 41429, 41426, 41442, 41446, 41430, 41721, 41733, 41734, 41677, 41724, 41736, 41737, 
41680, 41666, 41722, 41735, 41679
27355, 41426, 41442, 41446, 41430, 16465, 16469, 16470, 16466, 41724, 41736, 41737, 41680, 0, 0, 0, 
0, 41669, 41725, 41738, 41682
27356, 5829, 5833, 647, 646, 41427, 41443, 16320, 16316, 0, 0, 0, 0, 41728, 41739, 16374, 
41683, 41670, 41726, 16375, 16366
27357, 41427, 41443, 16320, 16316, 41428, 41444, 16321, 16317, 41728, 41739, 16374, 41683, 41731, 41740, 16376, 
41684, 41673, 41729, 16377, 16368
27358, 41428, 41444, 16321, 16317, 41429, 41445, 16322, 16318, 41731, 41740, 16376, 41684, 41734, 41741, 16378, 
41685, 41676, 41732, 16379, 16370
27359, 41429, 41445, 16322, 16318, 41430, 41446, 16323, 16319, 41734, 41741, 16378, 41685, 41737, 41742, 16380, 
41686, 41679, 41735, 16381, 16372
27360, 41430, 41446, 16323, 16319, 16466, 16470, 2093, 2092, 41737, 41742, 16380, 41686, 0, 0, 0, 
0, 41682, 41738, 16382, 16373
27361, 569, 570, 5834, 5830, 15609, 15613, 41447, 41431, 0, 0, 0, 0, 15672, 41744, 41745, 
41688, 15664, 15673, 41743, 41687
27362, 15609, 15613, 41447, 41431, 15610, 15614, 41448, 41432, 15672, 41744, 41745, 41688, 15674, 41747, 41748, 
41691, 15666, 15675, 41746, 41690
27363, 15610, 15614, 41448, 41432, 15611, 15615, 41449, 41433, 15674, 41747, 41748, 41691, 15676, 41750, 41751, 
41694, 15668, 15677, 41749, 41693
27364, 15611, 15615, 41449, 41433, 15612, 15616, 41450, 41434, 15676, 41750, 41751, 41694, 15678, 41753, 41754, 
41697, 15670, 15679, 41752, 41696
27365, 15612, 15616, 41450, 41434, 2023, 2024, 16471, 16467, 15678, 41753, 41754, 41697, 0, 0, 0, 
0, 15671, 15680, 41755, 41699
27366, 5830, 5834, 5835, 5831, 41431, 41447, 41451, 41435, 0, 0, 0, 0, 41745, 41757, 41758, 
41701, 41687, 41743, 41756, 41700
27367, 41431, 41447, 41451, 41435, 41432, 41448, 41452, 41436, 41745, 41757, 41758, 41701, 41748, 41760, 41761, 
41704, 41690, 41746, 41759, 41703
27368, 41432, 41448, 41452, 41436, 41433, 41449, 41453, 41437, 41748, 41760, 41761, 41704, 41751, 41763, 41764, 
41707, 41693, 41749, 41762, 41706
27369, 41433, 41449, 41453, 41437, 41434, 41450, 41454, 41438, 41751, 41763, 41764, 41707, 41754, 41766, 41767, 
41710, 41696, 41752, 41765, 41709
27370, 41434, 41450, 41454, 41438, 16467, 16471, 16472, 16468, 41754, 41766, 41767, 41710, 0, 0, 0, 
0, 41699, 41755, 41768, 41712
27371, 5831, 5835, 5836, 5832, 41435, 41451, 41455, 41439, 0, 0, 0, 0, 41758, 41770, 41771, 
41714, 41700, 41756, 41769, 41713
27372, 41435, 41451, 41455, 41439, 41436, 41452, 41456, 41440, 41758, 41770, 41771, 41714, 41761, 41773, 41774, 
41717, 41703, 41759, 41772, 41716
27373, 41436, 41452, 41456, 41440, 41437, 41453, 41457, 41441, 41761, 41773, 41774, 41717, 41764, 41776, 41777, 
41720, 41706, 41762, 41775, 41719
27374, 41437, 41453, 41457, 41441, 41438, 41454, 41458, 41442, 41764, 41776, 41777, 41720, 41767, 41779, 41780, 
41723, 41709, 41765, 41778, 41722
27375, 41438, 41454, 41458, 41442, 16468, 16472, 16473, 16469, 41767, 41779, 41780, 41723, 0, 0, 0, 
0, 41712, 41768, 41781, 41725
27376, 5832, 5836, 5837, 5833, 41439, 41455, 41459, 41443, 0, 0, 0, 0, 41771, 41783, 41784, 
41727, 41713, 41769, 41782, 41726
27377, 41439, 41455, 41459, 41443, 41440, 41456, 41460, 41444, 41771, 41783, 41784, 41727, 41774, 41786, 41787, 
41730, 41716, 41772, 41785, 41729
27378, 41440, 41456, 41460, 41444, 41441, 41457, 41461, 41445, 41774, 41786, 41787, 41730, 41777, 41789, 41790, 
41733, 41719, 41775, 41788, 41732
27379, 41441, 41457, 41461, 41445, 41442, 41458, 41462, 41446, 41777, 41789, 41790, 41733, 41780, 41792, 41793, 
41736, 41722, 41778, 41791, 41735
27380, 41442, 41458, 41462, 41446, 16469, 16473, 16474, 16470, 41780, 41792, 41793, 41736, 0, 0, 0, 
0, 41725, 41781, 41794, 41738
27381, 5833, 5837, 648, 647, 41443, 41459, 16324, 16320, 0, 0, 0, 0, 41784, 41795, 16383, 
41739, 41726, 41782, 16384, 16375
27382, 41443, 41459, 16324, 16320, 41444, 41460, 16325, 16321, 41784, 41795, 16383, 41739, 41787, 41796, 16385, 
41740, 41729, 41785, 16386, 16377
27383, 41444, 41460, 16325, 16321, 41445, 41461, 16326, 16322, 41787, 41796, 16385, 41740, 41790, 41797, 16387, 
41741, 41732, 41788, 16388, 16379
27384, 41445, 41461, 16326, 16322, 41446, 41462, 16327, 16323, 41790, 41797, 16387, 41741, 41793, 41798, 16389, 
41742, 41735, 41791, 16390, 16381
27385, 41446, 41462, 16327, 16323, 16470, 16474, 2094, 2093, 41793, 41798, 16389, 41742, 0, 0, 0, 
0, 41738, 41794, 16391, 16382
27386, 570, 571, 5838, 5834, 15613, 15617, 41463, 41447, 0, 0, 0, 0, 15681, 41800, 41801, 
41744, 15673, 15682, 41799, 41743
27387, 15613, 15617, 41463, 41447, 15614, 15618, 41464, 41448, 15681, 41800, 41801, 41744, 15683, 41803, 41804, 
41747, 15675, 15684, 41802, 41746
27388, 15614, 15618, 41464, 41448, 15615, 15619, 41465, 41449, 15683, 41803, 41804, 41747, 15685, 41806, 41807, 
41750, 15677, 15686, 41805, 41749
27389, 15615, 15619, 41465, 41449, 15616, 15620, 41466, 41450, 15685, 41806, 41807, 41750, 15687, 41809, 41810, 
41753, 15679, 15688, 41808, 41752
27390, 15616, 15620, 41466, 41450, 2024, 2025, 16475, 16471, 15687, 41809, 41810, 41753, 0, 0, 0, 
0, 15680, 15689, 41811, 41755
27391, 5834, 5838, 5839, 5835, 41447, 41463, 41467, 41451, 0, 0, 0, 0, 41801, 41813, 41814, 
41757, 41743, 41799, 41812, 41756
27392, 41447, 41463, 41467, 41451, 41448, 41464, 41468, 41452, 41801, 41813, 41814, 41757, 41804, 41816, 41817, 
41760, 41746, 41802, 41815, 41759
27393, 41448, 41464, 41468, 41452, 41449, 41465, 41469, 41453, 41804, 41816, 41817, 41760, 41807, 41819, 41820, 
41763, 41749, 41805, 41818, 41762
27394, 41449, 41465, 41469, 41453, 41450, 41466, 41470, 41454, 41807, 41819, 41820, 41763, 41810, 41822, 41823, 
41766, 41752, 41808, 41821, 41765
27395, 41450, 41466, 41470, 41454, 16471, 16475, 16476, 16472, 41810, 41822, 41823, 41766, 0, 0, 0, 
0, 41755, 41811, 41824, 41768
27396, 5835, 5839, 5840, 5836, 41451, 41467, 41471, 41455, 0, 0, 0, 0, 41814, 41826, 41827, 
41770, 41756, 41812, 41825, 41769
27397, 41451, 41467, 41471, 41455, 41452, 41468, 41472, 41456, 41814, 41826, 41827, 41770, 41817, 41829, 41830, 
41773, 41759, 41815, 41828, 41772
27398, 41452, 41468, 41472, 41456, 41453, 41469, 41473, 41457, 41817, 41829, 41830, 41773, 41820, 41832, 41833, 
41776, 41762, 41818, 41831, 41775
27399, 41453, 41469, 41473, 41457, 41454, 41470, 41474, 41458, 41820, 41832, 41833, 41776, 41823, 41835, 41836, 
41779, 41765, 41821, 41834, 41778
27400, 41454, 41470, 41474, 41458, 16472, 16476, 16477, 16473, 41823, 41835, 41836, 41779, 0, 0, 0, 
0, 41768, 41824, 41837, 41781
27401, 5836, 5840, 5841, 5837, 41455, 41471, 41475, 41459, 0, 0, 0, 0, 41827, 41839, 41840, 
41783, 41769, 41825, 41838, 41782
27402, 41455, 41471, 41475, 41459, 41456, 41472, 41476, 41460, 41827, 41839, 41840, 41783, 41830, 41842, 41843, 
41786, 41772, 41828, 41841, 41785
27403, 41456, 41472, 41476, 41460, 41457, 41473, 41477, 41461, 41830, 41842, 41843, 41786, 41833, 41845, 41846, 
41789, 41775, 41831, 41844, 41788
27404, 41457, 41473, 41477, 41461, 41458, 41474, 41478, 41462, 41833, 41845, 41846, 41789, 41836, 41848, 41849, 
41792, 41778, 41834, 41847, 41791
27405, 41458, 41474, 41478, 41462, 16473, 16477, 16478, 16474, 41836, 41848, 41849, 41792, 0, 0, 0, 
0, 41781, 41837, 41850, 41794
27406, 5837, 5841, 649, 648, 41459, 41475, 16328, 16324, 0, 0, 0, 0, 41840, 41851, 16392, 
41795, 41782, 41838, 16393, 16384
27407, 41459, 41475, 16328, 16324, 41460, 41476, 16329, 16325, 41840, 41851, 16392, 41795, 41843, 41852, 16394, 
41796, 41785, 41841, 16395, 16386
27408, 41460, 41476, 16329, 16325, 41461, 41477, 16330, 16326, 41843, 41852, 16394, 41796, 41846, 41853, 16396, 
41797, 41788, 41844, 16397, 16388
27409, 41461, 41477, 16330, 16326, 41462, 41478, 16331, 16327, 41846, 41853, 16396, 41797, 41849, 41854, 16398, 
41798, 41791, 41847, 16399, 16390
27410, 41462, 41478, 16331, 16327, 16474, 16478, 2095, 2094, 41849, 41854, 16398, 41798, 0, 0, 0, 
0, 41794, 41850, 16400, 16391
27411, 571, 572, 5842, 5838, 15617, 15621, 41479, 41463, 0, 0, 0, 0, 15690, 41856, 41857, 
41800, 15682, 15691, 41855, 41799
27412, 15617, 15621, 41479, 41463, 15618, 15622, 41480, 41464, 15690, 41856, 41857, 41800, 15692, 41859, 41860, 
41803, 15684, 15693, 41858, 41802
27413, 15618, 15622, 41480, 41464, 15619, 15623, 41481, 41465, 15692, 41859, 41860, 41803, 15694, 41862, 41863, 
41806, 15686, 15695, 41861, 41805
27414, 15619, 15623, 41481, 41465, 15620, 15624, 41482, 41466, 15694, 41862, 41863, 41806, 15696, 41865, 41866, 
41809, 15688, 15697, 41864, 41808
27415, 15620, 15624, 41482, 41466, 2025, 2026, 16479, 16475, 15696, 41865, 41866, 41809, 0, 0, 0, 
0, 15689, 15698, 41867, 41811
27416, 5838, 5842, 5843, 5839, 41463, 41479, 41483, 41467, 0, 0, 0, 0, 41857, 41869, 41870, 
41813, 41799, 41855, 41868, 41812
27417, 41463, 41479, 41483, 41467, 41464, 41480, 41484, 41468, 41857, 41869, 41870, 41813, 41860, 41872, 41873, 
41816, 41802, 41858, 41871, 41815
27418, 41464, 41480, 41484, 41468, 41465, 41481, 41485, 41469, 41860, 41872, 41873, 41816, 41863, 41875, 41876, 
41819, 41805, 41861, 41874, 41818
27419, 41465, 41481, 41485, 41469, 41466, 41482, 41486, 41470, 41863, 41875, 41876, 41819, 41866, 41878, 41879, 
41822, 41808, 41864, 41877, 41821
27420, 41466, 41482, 41486, 41470, 16475, 16479, 16480, 16476, 41866, 41878, 41879, 41822, 0, 0, 0, 
0, 41811, 41867, 41880, 41824
27421, 5839, 5843, 5844, 5840, 41467, 41483, 41487, 41471, 0, 0, 0, 0, 41870, 41882, 41883, 
41826, 41812, 41868, 41881, 41825
27422, 41467, 41483, 41487, 41471, 41468, 41484, 41488, 41472, 41870, 41882, 41883, 41826, 41873, 41885, 41886, 
41829, 41815, 41871, 41884, 41828
27423, 41468, 41484, 41488, 41472, 41469, 41485, 41489, 41473, 41873, 41885, 41886, 41829, 41876, 41888, 41889, 
41832, 41818, 41874, 41887, 41831
27424, 41469, 41485, 41489, 41473, 41470, 41486, 41490, 41474, 41876, 41888, 41889, 41832, 41879, 41891, 41892, 
41835, 41821, 41877, 41890, 41834
27425, 41470, 41486, 41490, 41474, 16476, 16480, 16481, 16477, 41879, 41891, 41892, 41835, 0, 0, 0, 
0, 41824, 41880, 41893, 41837
27426, 5840, 5844, 5845, 5841, 41471, 41487, 41491, 41475, 0, 0, 0, 0, 41883, 41895, 41896, 
41839, 41825, 41881, 41894, 41838
27427, 41471, 41487, 41491, 41475, 41472, 41488, 41492, 41476, 41883, 41895, 41896, 41839, 41886, 41898, 41899, 
41842, 41828, 41884, 41897, 41841
27428, 41472, 41488, 41492, 41476, 41473, 41489, 41493, 41477, 41886, 41898, 41899, 41842, 41889, 41901, 41902, 
41845, 41831, 41887, 41900, 41844
27429, 41473, 41489, 41493, 41477, 41474, 41490, 41494, 41478, 41889, 41901, 41902, 41845, 41892, 41904, 41905, 
41848, 41834, 41890, 41903, 41847
27430, 41474, 41490, 41494, 41478, 16477, 16481, 16482, 16478, 41892, 41904, 41905, 41848, 0, 0, 0, 
0, 41837, 41893, 41906, 41850
27431, 5841, 5845, 650, 649, 41475, 41491, 16332, 16328, 0, 0, 0, 0, 41896, 41907, 16401, 
41851, 41838, 41894, 16402, 16393
27432, 41475, 41491, 16332, 16328, 41476, 41492, 16333, 16329, 41896, 41907, 16401, 41851, 41899, 41908, 16403, 
41852, 41841, 41897, 16404, 16395
27433, 41476, 41492, 16333, 16329, 41477, 41493, 16334, 16330, 41899, 41908, 16403, 41852, 41902, 41909, 16405, 
41853, 41844, 41900, 16406, 16397
27434, 41477, 41493, 16334, 16330, 41478, 41494, 16335, 16331, 41902, 41909, 16405, 41853, 41905, 41910, 16407, 
41854, 41847, 41903, 16408, 16399
27435, 41478, 41494, 16335, 16331, 16478, 16482, 2096, 2095, 41905, 41910, 16407, 41854, 0, 0, 0, 
0, 41850, 41906, 16409, 16400
27436, 572, 573, 5846, 5842, 15621, 15625, 41495, 41479, 0, 0, 0, 0, 15699, 41912, 41913, 
41856, 15691, 15700, 41911, 41855
27437, 15621, 15625, 41495, 41479, 15622, 15626, 41496, 41480, 15699, 41912, 41913, 41856, 15701, 41915, 41916, 
41859, 15693, 15702, 41914, 41858
27438, 15622, 15626, 41496, 41480, 15623, 15627, 41497, 41481, 15701, 41915, 41916, 41859, 15703, 41918, 41919, 
41862, 15695, 15704, 41917, 41861
27439, 15623, 15627, 41497, 41481, 15624, 15628, 41498, 41482, 15703, 41918, 41919, 41862, 15705, 41921, 41922, 
41865, 15697, 15706, 41920, 41864
27440, 15624, 15628, 41498, 41482, 2026, 2027, 16483, 16479, 15705, 41921, 41922, 41865, 0, 0, 0, 
0, 15698, 15707, 41923, 41867
27441, 5842, 5846, 5847, 5843, 41479, 41495, 41499, 41483, 0, 0, 0, 0, 41913, 41925, 41926, 
41869, 41855, 41911, 41924, 41868
27442, 41479, 41495, 41499, 41483, 41480, 41496, 41500, 41484, 41913, 41925, 41926, 41869, 41916, 41928, 41929, 
41872, 41858, 41914, 41927, 41871
27443, 41480, 41496, 41500, 41484, 41481, 41497, 41501, 41485, 41916, 41928, 41929, 41872, 41919, 41931, 41932, 
41875, 41861, 41917, 41930, 41874
27444, 41481, 41497, 41501, 41485, 41482, 41498, 41502, 41486, 41919, 41931, 41932, 41875, 41922, 41934, 41935, 
41878, 41864, 41920, 41933, 41877
27445, 41482, 41498, 41502, 41486, 16479, 16483, 16484, 16480, 41922, 41934, 41935, 41878, 0, 0, 0, 
0, 41867, 41923, 41936, 41880
27446, 5843, 5847, 5848, 5844, 41483, 41499, 41503, 41487, 0, 0, 0, 0, 41926, 41938, 41939, 
41882, 41868, 41924, 41937, 41881
27447, 41483, 41499, 41503, 41487, 41484, 41500, 41504, 41488, 41926, 41938, 41939, 41882, 41929, 41941, 41942, 
41885, 41871, 41927, 41940, 41884
27448, 41484, 41500, 41504, 41488, 41485, 41501, 41505, 41489, 41929, 41941, 41942, 41885, 41932, 41944, 41945, 
41888, 41874, 41930, 41943, 41887
27449, 41485, 41501, 41505, 41489, 41486, 41502, 41506, 41490, 41932, 41944, 41945, 41888, 41935, 41947, 41948, 
41891, 41877, 41933, 41946, 41890
27450, 41486, 41502, 41506, 41490, 16480, 16484, 16485, 16481, 41935, 41947, 41948, 41891, 0, 0, 0, 
0, 41880, 41936, 41949, 41893
27451, 5844, 5848, 5849, 5845, 41487, 41503, 41507, 41491, 0, 0, 0, 0, 41939, 41951, 41952, 
41895, 41881, 41937, 41950, 41894
27452, 41487, 41503, 41507, 41491, 41488, 41504, 41508, 41492, 41939, 41951, 41952, 41895, 41942, 41954, 41955, 
41898, 41884, 41940, 41953, 41897
27453, 41488, 41504, 41508, 41492, 41489, 41505, 41509, 41493, 41942, 41954, 41955, 41898, 41945, 41957, 41958, 
41901, 41887, 41943, 41956, 41900
27454, 41489, 41505, 41509, 41493, 41490, 41506, 41510, 41494, 41945, 41957, 41958, 41901, 41948, 41960, 41961, 
41904, 41890, 41946, 41959, 41903
27455, 41490, 41506, 41510, 41494, 16481, 16485, 16486, 16482, 41948, 41960, 41961, 41904, 0, 0, 0, 
0, 41893, 41949, 41962, 41906
27456, 5845, 5849, 651, 650, 41491, 41507, 16336, 16332, 0, 0, 0, 0, 41952, 41963, 16410, 
41907, 41894, 41950, 16411, 16402
27457, 41491, 41507, 16336, 16332, 41492, 41508, 16337, 16333, 41952, 41963, 16410, 41907, 41955, 41964, 16412, 
41908, 41897, 41953, 16413, 16404
27458, 41492, 41508, 16337, 16333, 41493, 41509, 16338, 16334, 41955, 41964, 16412, 41908, 41958, 41965, 16414, 
41909, 41900, 41956, 16415, 16406
27459, 41493, 41509, 16338, 16334, 41494, 41510, 16339, 16335, 41958, 41965, 16414, 41909, 41961, 41966, 16416, 
41910, 41903, 41959, 16417, 16408
27460, 41494, 41510, 16339, 16335, 16482, 16486, 2097, 2096, 41961, 41966, 16416, 41910, 0, 0, 0, 
0, 41906, 41962, 16418, 16409
27461, 573, 574, 5850, 5846, 15625, 15629, 41511, 41495, 0, 0, 0, 0, 15708, 41968, 41969, 
41912, 15700, 15709, 41967, 41911
27462, 15625, 15629, 41511, 41495, 15626, 15630, 41512, 41496, 15708, 41968, 41969, 41912, 15710, 41971, 41972, 
41915, 15702, 15711, 41970, 41914
27463, 15626, 15630, 41512, 41496, 15627, 15631, 41513, 41497, 15710, 41971, 41972, 41915, 15712, 41974, 41975, 
41918, 15704, 15713, 41973, 41917
27464, 15627, 15631, 41513, 41497, 15628, 15632, 41514, 41498, 15712, 41974, 41975, 41918, 15714, 41977, 41978, 
41921, 15706, 15715, 41976, 41920
27465, 15628, 15632, 41514, 41498, 2027, 2028, 16487, 16483, 15714, 41977, 41978, 41921, 0, 0, 0, 
0, 15707, 15716, 41979, 41923
27466, 5846, 5850, 5851, 5847, 41495, 41511, 41515, 41499, 0, 0, 0, 0, 41969, 41981, 41982, 
41925, 41911, 41967, 41980, 41924
27467, 41495, 41511, 41515, 41499, 41496, 41512, 41516, 41500, 41969, 41981, 41982, 41925, 41972, 41984, 41985, 
41928, 41914, 41970, 41983, 41927
27468, 41496, 41512, 41516, 41500, 41497, 41513, 41517, 41501, 41972, 41984, 41985, 41928, 41975, 41987, 41988, 
41931, 41917, 41973, 41986, 41930
27469, 41497, 41513, 41517, 41501, 41498, 41514, 41518, 41502, 41975, 41987, 41988, 41931, 41978, 41990, 41991, 
41934, 41920, 41976, 41989, 41933
27470, 41498, 41514, 41518, 41502, 16483, 16487, 16488, 16484, 41978, 41990, 41991, 41934, 0, 0, 0, 
0, 41923, 41979, 41992, 41936
27471, 5847, 5851, 5852, 5848, 41499, 41515, 41519, 41503, 0, 0, 0, 0, 41982, 41994, 41995, 
41938, 41924, 41980, 41993, 41937
27472, 41499, 41515, 41519, 41503, 41500, 41516, 41520, 41504, 41982, 41994, 41995, 41938, 41985, 41997, 41998, 
41941, 41927, 41983, 41996, 41940
27473, 41500, 41516, 41520, 41504, 41501, 41517, 41521, 41505, 41985, 41997, 41998, 41941, 41988, 42000, 42001, 
41944, 41930, 41986, 41999, 41943
27474, 41501, 41517, 41521, 41505, 41502, 41518, 41522, 41506, 41988, 42000, 42001, 41944, 41991, 42003, 42004, 
41947, 41933, 41989, 42002, 41946
27475, 41502, 41518, 41522, 41506, 16484, 16488, 16489, 16485, 41991, 42003, 42004, 41947, 0, 0, 0, 
0, 41936, 41992, 42005, 41949
27476, 5848, 5852, 5853, 5849, 41503, 41519, 41523, 41507, 0, 0, 0, 0, 41995, 42007, 42008, 
41951, 41937, 41993, 42006, 41950
27477, 41503, 41519, 41523, 41507, 41504, 41520, 41524, 41508, 41995, 42007, 42008, 41951, 41998, 42010, 42011, 
41954, 41940, 41996, 42009, 41953
27478, 41504, 41520, 41524, 41508, 41505, 41521, 41525, 41509, 41998, 42010, 42011, 41954, 42001, 42013, 42014, 
41957, 41943, 41999, 42012, 41956
27479, 41505, 41521, 41525, 41509, 41506, 41522, 41526, 41510, 42001, 42013, 42014, 41957, 42004, 42016, 42017, 
41960, 41946, 42002, 42015, 41959
27480, 41506, 41522, 41526, 41510, 16485, 16489, 16490, 16486, 42004, 42016, 42017, 41960, 0, 0, 0, 
0, 41949, 42005, 42018, 41962
27481, 5849, 5853, 652, 651, 41507, 41523, 16340, 16336, 0, 0, 0, 0, 42008, 42019, 16419, 
41963, 41950, 42006, 16420, 16411
27482, 41507, 41523, 16340, 16336, 41508, 41524, 16341, 16337, 42008, 42019, 16419, 41963, 42011, 42020, 16421, 
41964, 41953, 42009, 16422, 16413
27483, 41508, 41524, 16341, 16337, 41509, 41525, 16342, 16338, 42011, 42020, 16421, 41964, 42014, 42021, 16423, 
41965, 41956, 42012, 16424, 16415
27484, 41509, 41525, 16342, 16338, 41510, 41526, 16343, 16339, 42014, 42021, 16423, 41965, 42017, 42022, 16425, 
41966, 41959, 42015, 16426, 16417
27485, 41510, 41526, 16343, 16339, 16486, 16490, 2098, 2097, 42017, 42022, 16425, 41966, 0, 0, 0, 
0, 41962, 42018, 16427, 16418
27486, 574, 575, 5854, 5850, 15629, 15633, 41527, 41511, 0, 0, 0, 0, 15717, 42024, 42025, 
41968, 15709, 15718, 42023, 41967
27487, 15629, 15633, 41527, 41511, 15630, 15634, 41528, 41512, 15717, 42024, 42025, 41968, 15719, 42027, 42028, 
41971, 15711, 15720, 42026, 41970
27488, 15630, 15634, 41528, 41512, 15631, 15635, 41529, 41513, 15719, 42027, 42028, 41971, 15721, 42030, 42031, 
41974, 15713, 15722, 42029, 41973
27489, 15631, 15635, 41529, 41513, 15632, 15636, 41530, 41514, 15721, 42030, 42031, 41974, 15723, 42033, 42034, 
41977, 15715, 15724, 42032, 41976
27490, 15632, 15636, 41530, 41514, 2028, 2029, 16491, 16487, 15723, 42033, 42034, 41977, 0, 0, 0, 
0, 15716, 15725, 42035, 41979
27491, 5850, 5854, 5855, 5851, 41511, 41527, 41531, 41515, 0, 0, 0, 0, 42025, 42037, 42038, 
41981, 41967, 42023, 42036, 41980
27492, 41511, 41527, 41531, 41515, 41512, 41528, 41532, 41516, 42025, 42037, 42038, 41981, 42028, 42040, 42041, 
41984, 41970, 42026, 42039, 41983
27493, 41512, 41528, 41532, 41516, 41513, 41529, 41533, 41517, 42028, 42040, 42041, 41984, 42031, 42043, 42044, 
41987, 41973, 42029, 42042, 41986
27494, 41513, 41529, 41533, 41517, 41514, 41530, 41534, 41518, 42031, 42043, 42044, 41987, 42034, 42046, 42047, 
41990, 41976, 42032, 42045, 41989
27495, 41514, 41530, 41534, 41518, 16487, 16491, 16492, 16488, 42034, 42046, 42047, 41990, 0, 0, 0, 
0, 41979, 42035, 42048, 41992
27496, 5851, 5855, 5856, 5852, 41515, 41531, 41535, 41519, 0, 0, 0, 0, 42038, 42050, 42051, 
41994, 41980, 42036, 42049, 41993
27497, 41515, 41531, 41535, 41519, 41516, 41532, 41536, 41520, 42038, 42050, 42051, 41994, 42041, 42053, 42054, 
41997, 41983, 42039, 42052, 41996
27498, 41516, 41532, 41536, 41520, 41517, 41533, 41537, 41521, 42041, 42053, 42054, 41997, 42044, 42056, 42057, 
42000, 41986, 42042, 42055, 41999
27499, 41517, 41533, 41537, 41521, 41518, 41534, 41538, 41522, 42044, 42056, 42057, 42000, 42047, 42059, 42060, 
42003, 41989, 42045, 42058, 42002
27500, 41518, 41534, 41538, 41522, 16488, 16492, 16493, 16489, 42047, 42059, 42060, 42003, 0, 0, 0, 
0, 41992, 42048, 42061, 42005
27501, 5852, 5856, 5857, 5853, 41519, 41535, 41539, 41523, 0, 0, 0, 0, 42051, 42063, 42064, 
42007, 41993, 42049, 42062, 42006
27502, 41519, 41535, 41539, 41523, 41520, 41536, 41540, 41524, 42051, 42063, 42064, 42007, 42054, 42066, 42067, 
42010, 41996, 42052, 42065, 42009
27503, 41520, 41536, 41540, 41524, 41521, 41537, 41541, 41525, 42054, 42066, 42067, 42010, 42057, 42069, 42070, 
42013, 41999, 42055, 42068, 42012
27504, 41521, 41537, 41541, 41525, 41522, 41538, 41542, 41526, 42057, 42069, 42070, 42013, 42060, 42072, 42073, 
42016, 42002, 42058, 42071, 42015
27505, 41522, 41538, 41542, 41526, 16489, 16493, 16494, 16490, 42060, 42072, 42073, 42016, 0, 0, 0, 
0, 42005, 42061, 42074, 42018
27506, 5853, 5857, 653, 652, 41523, 41539, 16344, 16340, 0, 0, 0, 0, 42064, 42075, 16428, 
42019, 42006, 42062, 16429, 16420
27507, 41523, 41539, 16344, 16340, 41524, 41540, 16345, 16341, 42064, 42075, 16428, 42019, 42067, 42076, 16430, 
42020, 42009, 42065, 16431, 16422
27508, 41524, 41540, 16345, 16341, 41525, 41541, 16346, 16342, 42067, 42076, 16430, 42020, 42070, 42077, 16432, 
42021, 42012, 42068, 16433, 16424
27509, 41525, 41541, 16346, 16342, 41526, 41542, 16347, 16343, 42070, 42077, 16432, 42021, 42073, 42078, 16434, 
42022, 42015, 42071, 16435, 16426
27510, 41526, 41542, 16347, 16343, 16490, 16494, 2099, 2098, 42073, 42078, 16434, 42022, 0, 0, 0, 
0, 42018, 42074, 16436, 16427
27511, 575, 576, 5858, 5854, 15633, 15637, 41543, 41527, 0, 0, 0, 0, 15726, 42080, 42081, 
42024, 15718, 15727, 42079, 42023
27512, 15633, 15637, 41543, 41527, 15634, 15638, 41544, 41528, 15726, 42080, 42081, 42024, 15728, 42083, 42084, 
42027, 15720, 15729, 42082, 42026
27513, 15634, 15638, 41544, 41528, 15635, 15639, 41545, 41529, 15728, 42083, 42084, 42027, 15730, 42086, 42087, 
42030, 15722, 15731, 42085, 42029
27514, 15635, 15639, 41545, 41529, 15636, 15640, 41546, 41530, 15730, 42086, 42087, 42030, 15732, 42089, 42090, 
42033, 15724, 15733, 42088, 42032
27515, 15636, 15640, 41546, 41530, 2029, 2030, 16495, 16491, 15732, 42089, 42090, 42033, 0, 0, 0, 
0, 15725, 15734, 42091, 42035
27516, 5854, 5858, 5859, 5855, 41527, 41543, 41547, 41531, 0, 0, 0, 0, 42081, 42093, 42094, 
42037, 42023, 42079, 42092, 42036
27517, 41527, 41543, 41547, 41531, 41528, 41544, 41548, 41532, 42081, 42093, 42094, 42037, 42084, 42096, 42097, 
42040, 42026, 42082, 42095, 42039
27518, 41528, 41544, 41548, 41532, 41529, 41545, 41549, 41533, 42084, 42096, 42097, 42040, 42087, 42099, 42100, 
42043, 42029, 42085, 42098, 42042
27519, 41529, 41545, 41549, 41533, 41530, 41546, 41550, 41534, 42087, 42099, 42100, 42043, 42090, 42102, 42103, 
42046, 42032, 42088, 42101, 42045
27520, 41530, 41546, 41550, 41534, 16491, 16495, 16496, 16492, 42090, 42102, 42103, 42046, 0, 0, 0, 
0, 42035, 42091, 42104, 42048
27521, 5855, 5859, 5860, 5856, 41531, 41547, 41551, 41535, 0, 0, 0, 0, 42094, 42106, 42107, 
42050, 42036, 42092, 42105, 42049
27522, 41531, 41547, 41551, 41535, 41532, 41548, 41552, 41536, 42094, 42106, 42107, 42050, 42097, 42109, 42110, 
42053, 42039, 42095, 42108, 42052
27523, 41532, 41548, 41552, 41536, 41533, 41549, 41553, 41537, 42097, 42109, 42110, 42053, 42100, 42112, 42113, 
42056, 42042, 42098, 42111, 42055
27524, 41533, 41549, 41553, 41537, 41534, 41550, 41554, 41538, 42100, 42112, 42113, 42056, 42103, 42115, 42116, 
42059, 42045, 42101, 42114, 42058
27525, 41534, 41550, 41554, 41538, 16492, 16496, 16497, 16493, 42103, 42115, 42116, 42059, 0, 0, 0, 
0, 42048, 42104, 42117, 42061
27526, 5856, 5860, 5861, 5857, 41535, 41551, 41555, 41539, 0, 0, 0, 0, 42107, 42119, 42120, 
42063, 42049, 42105, 42118, 42062
27527, 41535, 41551, 41555, 41539, 41536, 41552, 41556, 41540, 42107, 42119, 42120, 42063, 42110, 42122, 42123, 
42066, 42052, 42108, 42121, 42065
27528, 41536, 41552, 41556, 41540, 41537, 41553, 41557, 41541, 42110, 42122, 42123, 42066, 42113, 42125, 42126, 
42069, 42055, 42111, 42124, 42068
27529, 41537, 41553, 41557, 41541, 41538, 41554, 41558, 41542, 42113, 42125, 42126, 42069, 42116, 42128, 42129, 
42072, 42058, 42114, 42127, 42071
27530, 41538, 41554, 41558, 41542, 16493, 16497, 16498, 16494, 42116, 42128, 42129, 42072, 0, 0, 0, 
0, 42061, 42117, 42130, 42074
27531, 5857, 5861, 654, 653, 41539, 41555, 16348, 16344, 0, 0, 0, 0, 42120, 42131, 16437, 
42075, 42062, 42118, 16438, 16429
27532, 41539, 41555, 16348, 16344, 41540, 41556, 16349, 16345, 42120, 42131, 16437, 42075, 42123, 42132, 16439, 
42076, 42065, 42121, 16440, 16431
27533, 41540, 41556, 16349, 16345, 41541, 41557, 16350, 16346, 42123, 42132, 16439, 42076, 42126, 42133, 16441, 
42077, 42068, 42124, 16442, 16433
27534, 41541, 41557, 16350, 16346, 41542, 41558, 16351, 16347, 42126, 42133, 16441, 42077, 42129, 42134, 16443, 
42078, 42071, 42127, 16444, 16435
27535, 41542, 41558, 16351, 16347, 16494, 16498, 2100, 2099, 42129, 42134, 16443, 42078, 0, 0, 0, 
0, 42074, 42130, 16445, 16436
27536, 576, 577, 5862, 5858, 15637, 15641, 41559, 41543, 0, 0, 0, 0, 15735, 42136, 42137, 
42080, 15727, 15736, 42135, 42079
27537, 15637, 15641, 41559, 41543, 15638, 15642, 41560, 41544, 15735, 42136, 42137, 42080, 15737, 42139, 42140, 
42083, 15729, 15738, 42138, 42082
27538, 15638, 15642, 41560, 41544, 15639, 15643, 41561, 41545, 15737, 42139, 42140, 42083, 15739, 42142, 42143, 
42086, 15731, 15740, 42141, 42085
27539, 15639, 15643, 41561, 41545, 15640, 15644, 41562, 41546, 15739, 42142, 42143, 42086, 15741, 42145, 42146, 
42089, 15733, 15742, 42144, 42088
27540, 15640, 15644, 41562, 41546, 2030, 2031, 16499, 16495, 15741, 42145, 42146, 42089, 0, 0, 0, 
0, 15734, 15743, 42147, 42091
27541, 5858, 5862, 5863, 5859, 41543, 41559, 41563, 41547, 0, 0, 0, 0, 42137, 42149, 42150, 
42093, 42079, 42135, 42148, 42092
27542, 41543, 41559, 41563, 41547, 41544, 41560, 41564, 41548, 42137, 42149, 42150, 42093, 42140, 42152, 42153, 
42096, 42082, 42138, 42151, 42095
27543, 41544, 41560, 41564, 41548, 41545, 41561, 41565, 41549, 42140, 42152, 42153, 42096, 42143, 42155, 42156, 
42099, 42085, 42141, 42154, 42098
27544, 41545, 41561, 41565, 41549, 41546, 41562, 41566, 41550, 42143, 42155, 42156, 42099, 42146, 42158, 42159, 
42102, 42088, 42144, 42157, 42101
27545, 41546, 41562, 41566, 41550, 16495, 16499, 16500, 16496, 42146, 42158, 42159, 42102, 0, 0, 0, 
0, 42091, 42147, 42160, 42104
27546, 5859, 5863, 5864, 5860, 41547, 41563, 41567, 41551, 0, 0, 0, 0, 42150, 42162, 42163, 
42106, 42092, 42148, 42161, 42105
27547, 41547, 41563, 41567, 41551, 41548, 41564, 41568, 41552, 42150, 42162, 42163, 42106, 42153, 42165, 42166, 
42109, 42095, 42151, 42164, 42108
27548, 41548, 41564, 41568, 41552, 41549, 41565, 41569, 41553, 42153, 42165, 42166, 42109, 42156, 42168, 42169, 
42112, 42098, 42154, 42167, 42111
27549, 41549, 41565, 41569, 41553, 41550, 41566, 41570, 41554, 42156, 42168, 42169, 42112, 42159, 42171, 42172, 
42115, 42101, 42157, 42170, 42114
27550, 41550, 41566, 41570, 41554, 16496, 16500, 16501, 16497, 42159, 42171, 42172, 42115, 0, 0, 0, 
0, 42104, 42160, 42173, 42117
27551, 5860, 5864, 5865, 5861, 41551, 41567, 41571, 41555, 0, 0, 0, 0, 42163, 42175, 42176, 
42119, 42105, 42161, 42174, 42118
27552, 41551, 41567, 41571, 41555, 41552, 41568, 41572, 41556, 42163, 42175, 42176, 42119, 42166, 42178, 42179, 
42122, 42108, 42164, 42177, 42121
27553, 41552, 41568, 41572, 41556, 41553, 41569, 41573, 41557, 42166, 42178, 42179, 42122, 42169, 42181, 42182, 
42125, 42111, 42167, 42180, 42124
27554, 41553, 41569, 41573, 41557, 41554, 41570, 41574, 41558, 42169, 42181, 42182, 42125, 42172, 42184, 42185, 
42128, 42114, 42170, 42183, 42127
27555, 41554, 41570, 41574, 41558, 16497, 16501, 16502, 16498, 42172, 42184, 42185, 42128, 0, 0, 0, 
0, 42117, 42173, 42186, 42130
27556, 5861, 5865, 655, 654, 41555, 41571, 16352, 16348, 0, 0, 0, 0, 42176, 42187, 16446, 
42131, 42118, 42174, 16447, 16438
27557, 41555, 41571, 16352, 16348, 41556, 41572, 16353, 16349, 42176, 42187, 16446, 42131, 42179, 42188, 16448, 
42132, 42121, 42177, 16449, 16440
27558, 41556, 41572, 16353, 16349, 41557, 41573, 16354, 16350, 42179, 42188, 16448, 42132, 42182, 42189, 16450, 
42133, 42124, 42180, 16451, 16442
27559, 41557, 41573, 16354, 16350, 41558, 41574, 16355, 16351, 42182, 42189, 16450, 42133, 42185, 42190, 16452, 
42134, 42127, 42183, 16453, 16444
27560, 41558, 41574, 16355, 16351, 16498, 16502, 2101, 2100, 42185, 42190, 16452, 42134, 0, 0, 0, 
0, 42130, 42186, 16454, 16445
27561, 577, 23, 618, 5862, 15641, 2017, 16240, 41559, 0, 0, 0, 0, 15744, 0, 42191, 
42136, 15736, 0, 0, 42135
27562, 15641, 2017, 16240, 41559, 15642, 2018, 16241, 41560, 15744, 0, 42191, 42136, 15745, 0, 42192, 
42139, 15738, 0, 0, 42138
27563, 15642, 2018, 16241, 41560, 15643, 2019, 16242, 41561, 15745, 0, 42192, 42139, 15746, 0, 42193, 
42142, 15740, 0, 0, 42141
27564, 15643, 2019, 16242, 41561, 15644, 2020, 16243, 41562, 15746, 0, 42193, 42142, 15747, 0, 42194, 
42145, 15742, 0, 0, 42144
27565, 15644, 2020, 16243, 41562, 2031, 79, 2074, 16499, 15747, 0, 42194, 42145, 0, 0, 0, 
0, 15743, 0, 0, 42147
27566, 5862, 618, 619, 5863, 41559, 16240, 16244, 41563, 0, 0, 0, 0, 42191, 0, 42195, 
42149, 42135, 0, 0, 42148
27567, 41559, 16240, 16244, 41563, 41560, 16241, 16245, 41564, 42191, 0, 42195, 42149, 42192, 0, 42196, 
42152, 42138, 0, 0, 42151
27568, 41560, 16241, 16245, 41564, 41561, 16242, 16246, 41565, 42192, 0, 42196, 42152, 42193, 0, 42197, 
42155, 42141, 0, 0, 42154
27569, 41561, 16242, 16246, 41565, 41562, 16243, 16247, 41566, 42193, 0, 42197, 42155, 42194, 0, 42198, 
42158, 42144, 0, 0, 42157
27570, 41562, 16243, 16247, 41566, 16499, 2074, 2075, 16500, 42194, 0, 42198, 42158, 0, 0, 0, 
0, 42147, 0, 0, 42160
27571, 5863, 619, 620, 5864, 41563, 16244, 16248, 41567, 0, 0, 0, 0, 42195, 0, 42199, 
42162, 42148, 0, 0, 42161
27572, 41563, 16244, 16248, 41567, 41564, 16245, 16249, 41568, 42195, 0, 42199, 42162, 42196, 0, 42200, 
42165, 42151, 0, 0, 42164
27573, 41564, 16245, 16249, 41568, 41565, 16246, 16250, 41569, 42196, 0, 42200, 42165, 42197, 0, 42201, 
42168, 42154, 0, 0, 42167
27574, 41565, 16246, 16250, 41569, 41566, 16247, 16251, 41570, 42197, 0, 42201, 42168, 42198, 0, 42202, 
42171, 42157, 0, 0, 42170
27575, 41566, 16247, 16251, 41570, 16500, 2075, 2076, 16501, 42198, 0, 42202, 42171, 0, 0, 0, 
0, 42160, 0, 0, 42173
27576, 5864, 620, 621, 5865, 41567, 16248, 16252, 41571, 0, 0, 0, 0, 42199, 0, 42203, 
42175, 42161, 0, 0, 42174
27577, 41567, 16248, 16252, 41571, 41568, 16249, 16253, 41572, 42199, 0, 42203, 42175, 42200, 0, 42204, 
42178, 42164, 0, 0, 42177
27578, 41568, 16249, 16253, 41572, 41569, 16250, 16254, 41573, 42200, 0, 42204, 42178, 42201, 0, 42205, 
42181, 42167, 0, 0, 42180
27579, 41569, 16250, 16254, 41573, 41570, 16251, 16255, 41574, 42201, 0, 42205, 42181, 42202, 0, 42206, 
42184, 42170, 0, 0, 42183
27580, 41570, 16251, 16255, 41574, 16501, 2076, 2077, 16502, 42202, 0, 42206, 42184, 0, 0, 0, 
0, 42173, 0, 0, 42186
27581, 5865, 621, 26, 655, 41571, 16252, 2070, 16352, 0, 0, 0, 0, 42203, 0, 16455, 
42187, 42174, 0, 0, 16447
27582, 41571, 16252, 2070, 16352, 41572, 16253, 2071, 16353, 42203, 0, 16455, 42187, 42204, 0, 16456, 
42188, 42177, 0, 0, 16449
27583, 41572, 16253, 2071, 16353, 41573, 16254, 2072, 16354, 42204, 0, 16456, 42188, 42205, 0, 16457, 
42189, 42180, 0, 0, 16451
27584, 41573, 16254, 2072, 16354, 41574, 16255, 2073, 16355, 42205, 0, 16457, 42189, 42206, 0, 16458, 
42190, 42183, 0, 0, 16453
27585, 41574, 16255, 2073, 16355, 16502, 2077, 81, 2101, 42206, 0, 16458, 42190, 0, 0, 0, 
0, 42186, 0, 0, 16454
*ELEMENT, type=C3D20, ELSET=Volume22
27586, 28, 645, 6233, 727, 2078, 16312, 42207, 16595, 0, 0, 0, 0, 16356, 43220, 43221, 
16687, 2082, 16357, 43219, 16688
27587, 2078, 16312, 42207, 16595, 2079, 16313, 42208, 16596, 16356, 43220, 43221, 16687, 16358, 43223, 43224, 
16689, 2083, 16359, 43222, 16690
27588, 2079, 16313, 42208, 16596, 2080, 16314, 42209, 16597, 16358, 43223, 43224, 16689, 16360, 43226, 43227, 
16691, 2084, 16361, 43225, 16692
27589, 2080, 16314, 42209, 16597, 2081, 16315, 42210, 16598, 16360, 43226, 43227, 16691, 16362, 43229, 43230, 
16693, 2085, 16363, 43228, 16694
27590, 2081, 16315, 42210, 16598, 82, 2091, 17045, 2138, 16362, 43229, 43230, 16693, 0, 0, 0, 
0, 2086, 16364, 43231, 16695
27591, 727, 6233, 6234, 728, 16595, 42207, 42211, 16599, 0, 0, 0, 0, 43221, 43233, 43234, 
16696, 16688, 43219, 43232, 16697
27592, 16595, 42207, 42211, 16599, 16596, 42208, 42212, 16600, 43221, 43233, 43234, 16696, 43224, 43236, 43237, 
16698, 16690, 43222, 43235, 16699
27593, 16596, 42208, 42212, 16600, 16597, 42209, 42213, 16601, 43224, 43236, 43237, 16698, 43227, 43239, 43240, 
16700, 16692, 43225, 43238, 16701
27594, 16597, 42209, 42213, 16601, 16598, 42210, 42214, 16602, 43227, 43239, 43240, 16700, 43230, 43242, 43243, 
16702, 16694, 43228, 43241, 16703
27595, 16598, 42210, 42214, 16602, 2138, 17045, 17046, 2139, 43230, 43242, 43243, 16702, 0, 0, 0, 
0, 16695, 43231, 43244, 16704
27596, 728, 6234, 6235, 729, 16599, 42211, 42215, 16603, 0, 0, 0, 0, 43234, 43246, 43247, 
16705, 16697, 43232, 43245, 16706
27597, 16599, 42211, 42215, 16603, 16600, 42212, 42216, 16604, 43234, 43246, 43247, 16705, 43237, 43249, 43250, 
16707, 16699, 43235, 43248, 16708
27598, 16600, 42212, 42216, 16604, 16601, 42213, 42217, 16605, 43237, 43249, 43250, 16707, 43240, 43252, 43253, 
16709, 16701, 43238, 43251, 16710
27599, 16601, 42213, 42217, 16605, 16602, 42214, 42218, 16606, 43240, 43252, 43253, 16709, 43243, 43255, 43256, 
16711, 16703, 43241, 43254, 16712
27600, 16602, 42214, 42218, 16606, 2139, 17046, 17047, 2140, 43243, 43255, 43256, 16711, 0, 0, 0, 
0, 16704, 43244, 43257, 16713
27601, 729, 6235, 6236, 730, 16603, 42215, 42219, 16607, 0, 0, 0, 0, 43247, 43259, 43260, 
16714, 16706, 43245, 43258, 16715
27602, 16603, 42215, 42219, 16607, 16604, 42216, 42220, 16608, 43247, 43259, 43260, 16714, 43250, 43262, 43263, 
16716, 16708, 43248, 43261, 16717
27603, 16604, 42216, 42220, 16608, 16605, 42217, 42221, 16609, 43250, 43262, 43263, 16716, 43253, 43265, 43266, 
16718, 16710, 43251, 43264, 16719
27604, 16605, 42217, 42221, 16609, 16606, 42218, 42222, 16610, 43253, 43265, 43266, 16718, 43256, 43268, 43269, 
16720, 16712, 43254, 43267, 16721
27605, 16606, 42218, 42222, 16610, 2140, 17047, 17048, 2141, 43256, 43268, 43269, 16720, 0, 0, 0, 
0, 16713, 43257, 43270, 16722
27606, 730, 6236, 6237, 731, 16607, 42219, 42223, 16611, 0, 0, 0, 0, 43260, 43272, 43273, 
16723, 16715, 43258, 43271, 16724
27607, 16607, 42219, 42223, 16611, 16608, 42220, 42224, 16612, 43260, 43272, 43273, 16723, 43263, 43275, 43276, 
16725, 16717, 43261, 43274, 16726
27608, 16608, 42220, 42224, 16612, 16609, 42221, 42225, 16613, 43263, 43275, 43276, 16725, 43266, 43278, 43279, 
16727, 16719, 43264, 43277, 16728
27609, 16609, 42221, 42225, 16613, 16610, 42222, 42226, 16614, 43266, 43278, 43279, 16727, 43269, 43281, 43282, 
16729, 16721, 43267, 43280, 16730
27610, 16610, 42222, 42226, 16614, 2141, 17048, 17049, 2142, 43269, 43281, 43282, 16729, 0, 0, 0, 
0, 16722, 43270, 43283, 16731
27611, 731, 6237, 6238, 732, 16611, 42223, 42227, 16615, 0, 0, 0, 0, 43273, 43285, 43286, 
16732, 16724, 43271, 43284, 16733
27612, 16611, 42223, 42227, 16615, 16612, 42224, 42228, 16616, 43273, 43285, 43286, 16732, 43276, 43288, 43289, 
16734, 16726, 43274, 43287, 16735
27613, 16612, 42224, 42228, 16616, 16613, 42225, 42229, 16617, 43276, 43288, 43289, 16734, 43279, 43291, 43292, 
16736, 16728, 43277, 43290, 16737
27614, 16613, 42225, 42229, 16617, 16614, 42226, 42230, 16618, 43279, 43291, 43292, 16736, 43282, 43294, 43295, 
16738, 16730, 43280, 43293, 16739
27615, 16614, 42226, 42230, 16618, 2142, 17049, 17050, 2143, 43282, 43294, 43295, 16738, 0, 0, 0, 
0, 16731, 43283, 43296, 16740
27616, 732, 6238, 6239, 733, 16615, 42227, 42231, 16619, 0, 0, 0, 0, 43286, 43298, 43299, 
16741, 16733, 43284, 43297, 16742
27617, 16615, 42227, 42231, 16619, 16616, 42228, 42232, 16620, 43286, 43298, 43299, 16741, 43289, 43301, 43302, 
16743, 16735, 43287, 43300, 16744
27618, 16616, 42228, 42232, 16620, 16617, 42229, 42233, 16621, 43289, 43301, 43302, 16743, 43292, 43304, 43305, 
16745, 16737, 43290, 43303, 16746
27619, 16617, 42229, 42233, 16621, 16618, 42230, 42234, 16622, 43292, 43304, 43305, 16745, 43295, 43307, 43308, 
16747, 16739, 43293, 43306, 16748
27620, 16618, 42230, 42234, 16622, 2143, 17050, 17051, 2144, 43295, 43307, 43308, 16747, 0, 0, 0, 
0, 16740, 43296, 43309, 16749
27621, 733, 6239, 6240, 734, 16619, 42231, 42235, 16623, 0, 0, 0, 0, 43299, 43311, 43312, 
16750, 16742, 43297, 43310, 16751
27622, 16619, 42231, 42235, 16623, 16620, 42232, 42236, 16624, 43299, 43311, 43312, 16750, 43302, 43314, 43315, 
16752, 16744, 43300, 43313, 16753
27623, 16620, 42232, 42236, 16624, 16621, 42233, 42237, 16625, 43302, 43314, 43315, 16752, 43305, 43317, 43318, 
16754, 16746, 43303, 43316, 16755
27624, 16621, 42233, 42237, 16625, 16622, 42234, 42238, 16626, 43305, 43317, 43318, 16754, 43308, 43320, 43321, 
16756, 16748, 43306, 43319, 16757
27625, 16622, 42234, 42238, 16626, 2144, 17051, 17052, 2145, 43308, 43320, 43321, 16756, 0, 0, 0, 
0, 16749, 43309, 43322, 16758
27626, 734, 6240, 6241, 735, 16623, 42235, 42239, 16627, 0, 0, 0, 0, 43312, 43324, 43325, 
16759, 16751, 43310, 43323, 16760
27627, 16623, 42235, 42239, 16627, 16624, 42236, 42240, 16628, 43312, 43324, 43325, 16759, 43315, 43327, 43328, 
16761, 16753, 43313, 43326, 16762
27628, 16624, 42236, 42240, 16628, 16625, 42237, 42241, 16629, 43315, 43327, 43328, 16761, 43318, 43330, 43331, 
16763, 16755, 43316, 43329, 16764
27629, 16625, 42237, 42241, 16629, 16626, 42238, 42242, 16630, 43318, 43330, 43331, 16763, 43321, 43333, 43334, 
16765, 16757, 43319, 43332, 16766
27630, 16626, 42238, 42242, 16630, 2145, 17052, 17053, 2146, 43321, 43333, 43334, 16765, 0, 0, 0, 
0, 16758, 43322, 43335, 16767
27631, 735, 6241, 6242, 736, 16627, 42239, 42243, 16631, 0, 0, 0, 0, 43325, 43337, 43338, 
16768, 16760, 43323, 43336, 16769
27632, 16627, 42239, 42243, 16631, 16628, 42240, 42244, 16632, 43325, 43337, 43338, 16768, 43328, 43340, 43341, 
16770, 16762, 43326, 43339, 16771
27633, 16628, 42240, 42244, 16632, 16629, 42241, 42245, 16633, 43328, 43340, 43341, 16770, 43331, 43343, 43344, 
16772, 16764, 43329, 43342, 16773
27634, 16629, 42241, 42245, 16633, 16630, 42242, 42246, 16634, 43331, 43343, 43344, 16772, 43334, 43346, 43347, 
16774, 16766, 43332, 43345, 16775
27635, 16630, 42242, 42246, 16634, 2146, 17053, 17054, 2147, 43334, 43346, 43347, 16774, 0, 0, 0, 
0, 16767, 43335, 43348, 16776
27636, 736, 6242, 6243, 737, 16631, 42243, 42247, 16635, 0, 0, 0, 0, 43338, 43350, 43351, 
16777, 16769, 43336, 43349, 16778
27637, 16631, 42243, 42247, 16635, 16632, 42244, 42248, 16636, 43338, 43350, 43351, 16777, 43341, 43353, 43354, 
16779, 16771, 43339, 43352, 16780
27638, 16632, 42244, 42248, 16636, 16633, 42245, 42249, 16637, 43341, 43353, 43354, 16779, 43344, 43356, 43357, 
16781, 16773, 43342, 43355, 16782
27639, 16633, 42245, 42249, 16637, 16634, 42246, 42250, 16638, 43344, 43356, 43357, 16781, 43347, 43359, 43360, 
16783, 16775, 43345, 43358, 16784
27640, 16634, 42246, 42250, 16638, 2147, 17054, 17055, 2148, 43347, 43359, 43360, 16783, 0, 0, 0, 
0, 16776, 43348, 43361, 16785
27641, 737, 6243, 6244, 738, 16635, 42247, 42251, 16639, 0, 0, 0, 0, 43351, 43363, 43364, 
16786, 16778, 43349, 43362, 16787
27642, 16635, 42247, 42251, 16639, 16636, 42248, 42252, 16640, 43351, 43363, 43364, 16786, 43354, 43366, 43367, 
16788, 16780, 43352, 43365, 16789
27643, 16636, 42248, 42252, 16640, 16637, 42249, 42253, 16641, 43354, 43366, 43367, 16788, 43357, 43369, 43370, 
16790, 16782, 43355, 43368, 16791
27644, 16637, 42249, 42253, 16641, 16638, 42250, 42254, 16642, 43357, 43369, 43370, 16790, 43360, 43372, 43373, 
16792, 16784, 43358, 43371, 16793
27645, 16638, 42250, 42254, 16642, 2148, 17055, 17056, 2149, 43360, 43372, 43373, 16792, 0, 0, 0, 
0, 16785, 43361, 43374, 16794
27646, 738, 6244, 6245, 739, 16639, 42251, 42255, 16643, 0, 0, 0, 0, 43364, 43376, 43377, 
16795, 16787, 43362, 43375, 16796
27647, 16639, 42251, 42255, 16643, 16640, 42252, 42256, 16644, 43364, 43376, 43377, 16795, 43367, 43379, 43380, 
16797, 16789, 43365, 43378, 16798
27648, 16640, 42252, 42256, 16644, 16641, 42253, 42257, 16645, 43367, 43379, 43380, 16797, 43370, 43382, 43383, 
16799, 16791, 43368, 43381, 16800
27649, 16641, 42253, 42257, 16645, 16642, 42254, 42258, 16646, 43370, 43382, 43383, 16799, 43373, 43385, 43386, 
16801, 16793, 43371, 43384, 16802
27650, 16642, 42254, 42258, 16646, 2149, 17056, 17057, 2150, 43373, 43385, 43386, 16801, 0, 0, 0, 
0, 16794, 43374, 43387, 16803
27651, 739, 6245, 6246, 740, 16643, 42255, 42259, 16647, 0, 0, 0, 0, 43377, 43389, 43390, 
16804, 16796, 43375, 43388, 16805
27652, 16643, 42255, 42259, 16647, 16644, 42256, 42260, 16648, 43377, 43389, 43390, 16804, 43380, 43392, 43393, 
16806, 16798, 43378, 43391, 16807
27653, 16644, 42256, 42260, 16648, 16645, 42257, 42261, 16649, 43380, 43392, 43393, 16806, 43383, 43395, 43396, 
16808, 16800, 43381, 43394, 16809
27654, 16645, 42257, 42261, 16649, 16646, 42258, 42262, 16650, 43383, 43395, 43396, 16808, 43386, 43398, 43399, 
16810, 16802, 43384, 43397, 16811
27655, 16646, 42258, 42262, 16650, 2150, 17057, 17058, 2151, 43386, 43398, 43399, 16810, 0, 0, 0, 
0, 16803, 43387, 43400, 16812
27656, 740, 6246, 6247, 741, 16647, 42259, 42263, 16651, 0, 0, 0, 0, 43390, 43402, 43403, 
16813, 16805, 43388, 43401, 16814
27657, 16647, 42259, 42263, 16651, 16648, 42260, 42264, 16652, 43390, 43402, 43403, 16813, 43393, 43405, 43406, 
16815, 16807, 43391, 43404, 16816
27658, 16648, 42260, 42264, 16652, 16649, 42261, 42265, 16653, 43393, 43405, 43406, 16815, 43396, 43408, 43409, 
16817, 16809, 43394, 43407, 16818
27659, 16649, 42261, 42265, 16653, 16650, 42262, 42266, 16654, 43396, 43408, 43409, 16817, 43399, 43411, 43412, 
16819, 16811, 43397, 43410, 16820
27660, 16650, 42262, 42266, 16654, 2151, 17058, 17059, 2152, 43399, 43411, 43412, 16819, 0, 0, 0, 
0, 16812, 43400, 43413, 16821
27661, 741, 6247, 6248, 742, 16651, 42263, 42267, 16655, 0, 0, 0, 0, 43403, 43415, 43416, 
16822, 16814, 43401, 43414, 16823
27662, 16651, 42263, 42267, 16655, 16652, 42264, 42268, 16656, 43403, 43415, 43416, 16822, 43406, 43418, 43419, 
16824, 16816, 43404, 43417, 16825
27663, 16652, 42264, 42268, 16656, 16653, 42265, 42269, 16657, 43406, 43418, 43419, 16824, 43409, 43421, 43422, 
16826, 16818, 43407, 43420, 16827
27664, 16653, 42265, 42269, 16657, 16654, 42266, 42270, 16658, 43409, 43421, 43422, 16826, 43412, 43424, 43425, 
16828, 16820, 43410, 43423, 16829
27665, 16654, 42266, 42270, 16658, 2152, 17059, 17060, 2153, 43412, 43424, 43425, 16828, 0, 0, 0, 
0, 16821, 43413, 43426, 16830
27666, 742, 6248, 6249, 743, 16655, 42267, 42271, 16659, 0, 0, 0, 0, 43416, 43428, 43429, 
16831, 16823, 43414, 43427, 16832
27667, 16655, 42267, 42271, 16659, 16656, 42268, 42272, 16660, 43416, 43428, 43429, 16831, 43419, 43431, 43432, 
16833, 16825, 43417, 43430, 16834
27668, 16656, 42268, 42272, 16660, 16657, 42269, 42273, 16661, 43419, 43431, 43432, 16833, 43422, 43434, 43435, 
16835, 16827, 43420, 43433, 16836
27669, 16657, 42269, 42273, 16661, 16658, 42270, 42274, 16662, 43422, 43434, 43435, 16835, 43425, 43437, 43438, 
16837, 16829, 43423, 43436, 16838
27670, 16658, 42270, 42274, 16662, 2153, 17060, 17061, 2154, 43425, 43437, 43438, 16837, 0, 0, 0, 
0, 16830, 43426, 43439, 16839
27671, 743, 6249, 6250, 744, 16659, 42271, 42275, 16663, 0, 0, 0, 0, 43429, 43441, 43442, 
16840, 16832, 43427, 43440, 16841
27672, 16659, 42271, 42275, 16663, 16660, 42272, 42276, 16664, 43429, 43441, 43442, 16840, 43432, 43444, 43445, 
16842, 16834, 43430, 43443, 16843
27673, 16660, 42272, 42276, 16664, 16661, 42273, 42277, 16665, 43432, 43444, 43445, 16842, 43435, 43447, 43448, 
16844, 16836, 43433, 43446, 16845
27674, 16661, 42273, 42277, 16665, 16662, 42274, 42278, 16666, 43435, 43447, 43448, 16844, 43438, 43450, 43451, 
16846, 16838, 43436, 43449, 16847
27675, 16662, 42274, 42278, 16666, 2154, 17061, 17062, 2155, 43438, 43450, 43451, 16846, 0, 0, 0, 
0, 16839, 43439, 43452, 16848
27676, 744, 6250, 6251, 745, 16663, 42275, 42279, 16667, 0, 0, 0, 0, 43442, 43454, 43455, 
16849, 16841, 43440, 43453, 16850
27677, 16663, 42275, 42279, 16667, 16664, 42276, 42280, 16668, 43442, 43454, 43455, 16849, 43445, 43457, 43458, 
16851, 16843, 43443, 43456, 16852
27678, 16664, 42276, 42280, 16668, 16665, 42277, 42281, 16669, 43445, 43457, 43458, 16851, 43448, 43460, 43461, 
16853, 16845, 43446, 43459, 16854
27679, 16665, 42277, 42281, 16669, 16666, 42278, 42282, 16670, 43448, 43460, 43461, 16853, 43451, 43463, 43464, 
16855, 16847, 43449, 43462, 16856
27680, 16666, 42278, 42282, 16670, 2155, 17062, 17063, 2156, 43451, 43463, 43464, 16855, 0, 0, 0, 
0, 16848, 43452, 43465, 16857
27681, 745, 6251, 6252, 746, 16667, 42279, 42283, 16671, 0, 0, 0, 0, 43455, 43467, 43468, 
16858, 16850, 43453, 43466, 16859
27682, 16667, 42279, 42283, 16671, 16668, 42280, 42284, 16672, 43455, 43467, 43468, 16858, 43458, 43470, 43471, 
16860, 16852, 43456, 43469, 16861
27683, 16668, 42280, 42284, 16672, 16669, 42281, 42285, 16673, 43458, 43470, 43471, 16860, 43461, 43473, 43474, 
16862, 16854, 43459, 43472, 16863
27684, 16669, 42281, 42285, 16673, 16670, 42282, 42286, 16674, 43461, 43473, 43474, 16862, 43464, 43476, 43477, 
16864, 16856, 43462, 43475, 16865
27685, 16670, 42282, 42286, 16674, 2156, 17063, 17064, 2157, 43464, 43476, 43477, 16864, 0, 0, 0, 
0, 16857, 43465, 43478, 16866
27686, 746, 6252, 6253, 747, 16671, 42283, 42287, 16675, 0, 0, 0, 0, 43468, 43480, 43481, 
16867, 16859, 43466, 43479, 16868
27687, 16671, 42283, 42287, 16675, 16672, 42284, 42288, 16676, 43468, 43480, 43481, 16867, 43471, 43483, 43484, 
16869, 16861, 43469, 43482, 16870
27688, 16672, 42284, 42288, 16676, 16673, 42285, 42289, 16677, 43471, 43483, 43484, 16869, 43474, 43486, 43487, 
16871, 16863, 43472, 43485, 16872
27689, 16673, 42285, 42289, 16677, 16674, 42286, 42290, 16678, 43474, 43486, 43487, 16871, 43477, 43489, 43490, 
16873, 16865, 43475, 43488, 16874
27690, 16674, 42286, 42290, 16678, 2157, 17064, 17065, 2158, 43477, 43489, 43490, 16873, 0, 0, 0, 
0, 16866, 43478, 43491, 16875
27691, 747, 6253, 6254, 748, 16675, 42287, 42291, 16679, 0, 0, 0, 0, 43481, 43493, 43494, 
16876, 16868, 43479, 43492, 16877
27692, 16675, 42287, 42291, 16679, 16676, 42288, 42292, 16680, 43481, 43493, 43494, 16876, 43484, 43496, 43497, 
16878, 16870, 43482, 43495, 16879
27693, 16676, 42288, 42292, 16680, 16677, 42289, 42293, 16681, 43484, 43496, 43497, 16878, 43487, 43499, 43500, 
16880, 16872, 43485, 43498, 16881
27694, 16677, 42289, 42293, 16681, 16678, 42290, 42294, 16682, 43487, 43499, 43500, 16880, 43490, 43502, 43503, 
16882, 16874, 43488, 43501, 16883
27695, 16678, 42290, 42294, 16682, 2158, 17065, 17066, 2159, 43490, 43502, 43503, 16882, 0, 0, 0, 
0, 16875, 43491, 43504, 16884
27696, 748, 6254, 6255, 749, 16679, 42291, 42295, 16683, 0, 0, 0, 0, 43494, 43506, 43507, 
16885, 16877, 43492, 43505, 16886
27697, 16679, 42291, 42295, 16683, 16680, 42292, 42296, 16684, 43494, 43506, 43507, 16885, 43497, 43509, 43510, 
16887, 16879, 43495, 43508, 16888
27698, 16680, 42292, 42296, 16684, 16681, 42293, 42297, 16685, 43497, 43509, 43510, 16887, 43500, 43512, 43513, 
16889, 16881, 43498, 43511, 16890
27699, 16681, 42293, 42297, 16685, 16682, 42294, 42298, 16686, 43500, 43512, 43513, 16889, 43503, 43515, 43516, 
16891, 16883, 43501, 43514, 16892
27700, 16682, 42294, 42298, 16686, 2159, 17066, 17067, 2160, 43503, 43515, 43516, 16891, 0, 0, 0, 
0, 16884, 43504, 43517, 16893
27701, 749, 6255, 763, 32, 16683, 42295, 16898, 2129, 0, 0, 0, 0, 43507, 43518, 16942, 
16894, 16886, 43505, 16943, 2133
27702, 16683, 42295, 16898, 2129, 16684, 42296, 16899, 2130, 43507, 43518, 16942, 16894, 43510, 43519, 16944, 
16895, 16888, 43508, 16945, 2134
27703, 16684, 42296, 16899, 2130, 16685, 42297, 16900, 2131, 43510, 43519, 16944, 16895, 43513, 43520, 16946, 
16896, 16890, 43511, 16947, 2135
27704, 16685, 42297, 16900, 2131, 16686, 42298, 16901, 2132, 43513, 43520, 16946, 16896, 43516, 43521, 16948, 
16897, 16892, 43514, 16949, 2136
27705, 16686, 42298, 16901, 2132, 2160, 17067, 2161, 84, 43516, 43521, 16948, 16897, 0, 0, 0, 
0, 16893, 43517, 16950, 2137
27706, 645, 646, 6256, 6233, 16312, 16316, 42299, 42207, 0, 0, 0, 0, 16365, 43523, 43524, 
43220, 16357, 16366, 43522, 43219
27707, 16312, 16316, 42299, 42207, 16313, 16317, 42300, 42208, 16365, 43523, 43524, 43220, 16367, 43526, 43527, 
43223, 16359, 16368, 43525, 43222
27708, 16313, 16317, 42300, 42208, 16314, 16318, 42301, 42209, 16367, 43526, 43527, 43223, 16369, 43529, 43530, 
43226, 16361, 16370, 43528, 43225
27709, 16314, 16318, 42301, 42209, 16315, 16319, 42302, 42210, 16369, 43529, 43530, 43226, 16371, 43532, 43533, 
43229, 16363, 16372, 43531, 43228
27710, 16315, 16319, 42302, 42210, 2091, 2092, 17068, 17045, 16371, 43532, 43533, 43229, 0, 0, 0, 
0, 16364, 16373, 43534, 43231
27711, 6233, 6256, 6257, 6234, 42207, 42299, 42303, 42211, 0, 0, 0, 0, 43524, 43536, 43537, 
43233, 43219, 43522, 43535, 43232
27712, 42207, 42299, 42303, 42211, 42208, 42300, 42304, 42212, 43524, 43536, 43537, 43233, 43527, 43539, 43540, 
43236, 43222, 43525, 43538, 43235
27713, 42208, 42300, 42304, 42212, 42209, 42301, 42305, 42213, 43527, 43539, 43540, 43236, 43530, 43542, 43543, 
43239, 43225, 43528, 43541, 43238
27714, 42209, 42301, 42305, 42213, 42210, 42302, 42306, 42214, 43530, 43542, 43543, 43239, 43533, 43545, 43546, 
43242, 43228, 43531, 43544, 43241
27715, 42210, 42302, 42306, 42214, 17045, 17068, 17069, 17046, 43533, 43545, 43546, 43242, 0, 0, 0, 
0, 43231, 43534, 43547, 43244
27716, 6234, 6257, 6258, 6235, 42211, 42303, 42307, 42215, 0, 0, 0, 0, 43537, 43549, 43550, 
43246, 43232, 43535, 43548, 43245
27717, 42211, 42303, 42307, 42215, 42212, 42304, 42308, 42216, 43537, 43549, 43550, 43246, 43540, 43552, 43553, 
43249, 43235, 43538, 43551, 43248
27718, 42212, 42304, 42308, 42216, 42213, 42305, 42309, 42217, 43540, 43552, 43553, 43249, 43543, 43555, 43556, 
43252, 43238, 43541, 43554, 43251
27719, 42213, 42305, 42309, 42217, 42214, 42306, 42310, 42218, 43543, 43555, 43556, 43252, 43546, 43558, 43559, 
43255, 43241, 43544, 43557, 43254
27720, 42214, 42306, 42310, 42218, 17046, 17069, 17070, 17047, 43546, 43558, 43559, 43255, 0, 0, 0, 
0, 43244, 43547, 43560, 43257
27721, 6235, 6258, 6259, 6236, 42215, 42307, 42311, 42219, 0, 0, 0, 0, 43550, 43562, 43563, 
43259, 43245, 43548, 43561, 43258
27722, 42215, 42307, 42311, 42219, 42216, 42308, 42312, 42220, 43550, 43562, 43563, 43259, 43553, 43565, 43566, 
43262, 43248, 43551, 43564, 43261
27723, 42216, 42308, 42312, 42220, 42217, 42309, 42313, 42221, 43553, 43565, 43566, 43262, 43556, 43568, 43569, 
43265, 43251, 43554, 43567, 43264
27724, 42217, 42309, 42313, 42221, 42218, 42310, 42314, 42222, 43556, 43568, 43569, 43265, 43559, 43571, 43572, 
43268, 43254, 43557, 43570, 43267
27725, 42218, 42310, 42314, 42222, 17047, 17070, 17071, 17048, 43559, 43571, 43572, 43268, 0, 0, 0, 
0, 43257, 43560, 43573, 43270
27726, 6236, 6259, 6260, 6237, 42219, 42311, 42315, 42223, 0, 0, 0, 0, 43563, 43575, 43576, 
43272, 43258, 43561, 43574, 43271
27727, 42219, 42311, 42315, 42223, 42220, 42312, 42316, 42224, 43563, 43575, 43576, 43272, 43566, 43578, 43579, 
43275, 43261, 43564, 43577, 43274
27728, 42220, 42312, 42316, 42224, 42221, 42313, 42317, 42225, 43566, 43578, 43579, 43275, 43569, 43581, 43582, 
43278, 43264, 43567, 43580, 43277
27729, 42221, 42313, 42317, 42225, 42222, 42314, 42318, 42226, 43569, 43581, 43582, 43278, 43572, 43584, 43585, 
43281, 43267, 43570, 43583, 43280
27730, 42222, 42314, 42318, 42226, 17048, 17071, 17072, 17049, 43572, 43584, 43585, 43281, 0, 0, 0, 
0, 43270, 43573, 43586, 43283
27731, 6237, 6260, 6261, 6238, 42223, 42315, 42319, 42227, 0, 0, 0, 0, 43576, 43588, 43589, 
43285, 43271, 43574, 43587, 43284
27732, 42223, 42315, 42319, 42227, 42224, 42316, 42320, 42228, 43576, 43588, 43589, 43285, 43579, 43591, 43592, 
43288, 43274, 43577, 43590, 43287
27733, 42224, 42316, 42320, 42228, 42225, 42317, 42321, 42229, 43579, 43591, 43592, 43288, 43582, 43594, 43595, 
43291, 43277, 43580, 43593, 43290
27734, 42225, 42317, 42321, 42229, 42226, 42318, 42322, 42230, 43582, 43594, 43595, 43291, 43585, 43597, 43598, 
43294, 43280, 43583, 43596, 43293
27735, 42226, 42318, 42322, 42230, 17049, 17072, 17073, 17050, 43585, 43597, 43598, 43294, 0, 0, 0, 
0, 43283, 43586, 43599, 43296
27736, 6238, 6261, 6262, 6239, 42227, 42319, 42323, 42231, 0, 0, 0, 0, 43589, 43601, 43602, 
43298, 43284, 43587, 43600, 43297
27737, 42227, 42319, 42323, 42231, 42228, 42320, 42324, 42232, 43589, 43601, 43602, 43298, 43592, 43604, 43605, 
43301, 43287, 43590, 43603, 43300
27738, 42228, 42320, 42324, 42232, 42229, 42321, 42325, 42233, 43592, 43604, 43605, 43301, 43595, 43607, 43608, 
43304, 43290, 43593, 43606, 43303
27739, 42229, 42321, 42325, 42233, 42230, 42322, 42326, 42234, 43595, 43607, 43608, 43304, 43598, 43610, 43611, 
43307, 43293, 43596, 43609, 43306
27740, 42230, 42322, 42326, 42234, 17050, 17073, 17074, 17051, 43598, 43610, 43611, 43307, 0, 0, 0, 
0, 43296, 43599, 43612, 43309
27741, 6239, 6262, 6263, 6240, 42231, 42323, 42327, 42235, 0, 0, 0, 0, 43602, 43614, 43615, 
43311, 43297, 43600, 43613, 43310
27742, 42231, 42323, 42327, 42235, 42232, 42324, 42328, 42236, 43602, 43614, 43615, 43311, 43605, 43617, 43618, 
43314, 43300, 43603, 43616, 43313
27743, 42232, 42324, 42328, 42236, 42233, 42325, 42329, 42237, 43605, 43617, 43618, 43314, 43608, 43620, 43621, 
43317, 43303, 43606, 43619, 43316
27744, 42233, 42325, 42329, 42237, 42234, 42326, 42330, 42238, 43608, 43620, 43621, 43317, 43611, 43623, 43624, 
43320, 43306, 43609, 43622, 43319
27745, 42234, 42326, 42330, 42238, 17051, 17074, 17075, 17052, 43611, 43623, 43624, 43320, 0, 0, 0, 
0, 43309, 43612, 43625, 43322
27746, 6240, 6263, 6264, 6241, 42235, 42327, 42331, 42239, 0, 0, 0, 0, 43615, 43627, 43628, 
43324, 43310, 43613, 43626, 43323
27747, 42235, 42327, 42331, 42239, 42236, 42328, 42332, 42240, 43615, 43627, 43628, 43324, 43618, 43630, 43631, 
43327, 43313, 43616, 43629, 43326
27748, 42236, 42328, 42332, 42240, 42237, 42329, 42333, 42241, 43618, 43630, 43631, 43327, 43621, 43633, 43634, 
43330, 43316, 43619, 43632, 43329
27749, 42237, 42329, 42333, 42241, 42238, 42330, 42334, 42242, 43621, 43633, 43634, 43330, 43624, 43636, 43637, 
43333, 43319, 43622, 43635, 43332
27750, 42238, 42330, 42334, 42242, 17052, 17075, 17076, 17053, 43624, 43636, 43637, 43333, 0, 0, 0, 
0, 43322, 43625, 43638, 43335
27751, 6241, 6264, 6265, 6242, 42239, 42331, 42335, 42243, 0, 0, 0, 0, 43628, 43640, 43641, 
43337, 43323, 43626, 43639, 43336
27752, 42239, 42331, 42335, 42243, 42240, 42332, 42336, 42244, 43628, 43640, 43641, 43337, 43631, 43643, 43644, 
43340, 43326, 43629, 43642, 43339
27753, 42240, 42332, 42336, 42244, 42241, 42333, 42337, 42245, 43631, 43643, 43644, 43340, 43634, 43646, 43647, 
43343, 43329, 43632, 43645, 43342
27754, 42241, 42333, 42337, 42245, 42242, 42334, 42338, 42246, 43634, 43646, 43647, 43343, 43637, 43649, 43650, 
43346, 43332, 43635, 43648, 43345
27755, 42242, 42334, 42338, 42246, 17053, 17076, 17077, 17054, 43637, 43649, 43650, 43346, 0, 0, 0, 
0, 43335, 43638, 43651, 43348
27756, 6242, 6265, 6266, 6243, 42243, 42335, 42339, 42247, 0, 0, 0, 0, 43641, 43653, 43654, 
43350, 43336, 43639, 43652, 43349
27757, 42243, 42335, 42339, 42247, 42244, 42336, 42340, 42248, 43641, 43653, 43654, 43350, 43644, 43656, 43657, 
43353, 43339, 43642, 43655, 43352
27758, 42244, 42336, 42340, 42248, 42245, 42337, 42341, 42249, 43644, 43656, 43657, 43353, 43647, 43659, 43660, 
43356, 43342, 43645, 43658, 43355
27759, 42245, 42337, 42341, 42249, 42246, 42338, 42342, 42250, 43647, 43659, 43660, 43356, 43650, 43662, 43663, 
43359, 43345, 43648, 43661, 43358
27760, 42246, 42338, 42342, 42250, 17054, 17077, 17078, 17055, 43650, 43662, 43663, 43359, 0, 0, 0, 
0, 43348, 43651, 43664, 43361
27761, 6243, 6266, 6267, 6244, 42247, 42339, 42343, 42251, 0, 0, 0, 0, 43654, 43666, 43667, 
43363, 43349, 43652, 43665, 43362
27762, 42247, 42339, 42343, 42251, 42248, 42340, 42344, 42252, 43654, 43666, 43667, 43363, 43657, 43669, 43670, 
43366, 43352, 43655, 43668, 43365
27763, 42248, 42340, 42344, 42252, 42249, 42341, 42345, 42253, 43657, 43669, 43670, 43366, 43660, 43672, 43673, 
43369, 43355, 43658, 43671, 43368
27764, 42249, 42341, 42345, 42253, 42250, 42342, 42346, 42254, 43660, 43672, 43673, 43369, 43663, 43675, 43676, 
43372, 43358, 43661, 43674, 43371
27765, 42250, 42342, 42346, 42254, 17055, 17078, 17079, 17056, 43663, 43675, 43676, 43372, 0, 0, 0, 
0, 43361, 43664, 43677, 43374
27766, 6244, 6267, 6268, 6245, 42251, 42343, 42347, 42255, 0, 0, 0, 0, 43667, 43679, 43680, 
43376, 43362, 43665, 43678, 43375
27767, 42251, 42343, 42347, 42255, 42252, 42344, 42348, 42256, 43667, 43679, 43680, 43376, 43670, 43682, 43683, 
43379, 43365, 43668, 43681, 43378
27768, 42252, 42344, 42348, 42256, 42253, 42345, 42349, 42257, 43670, 43682, 43683, 43379, 43673, 43685, 43686, 
43382, 43368, 43671, 43684, 43381
27769, 42253, 42345, 42349, 42257, 42254, 42346, 42350, 42258, 43673, 43685, 43686, 43382, 43676, 43688, 43689, 
43385, 43371, 43674, 43687, 43384
27770, 42254, 42346, 42350, 42258, 17056, 17079, 17080, 17057, 43676, 43688, 43689, 43385, 0, 0, 0, 
0, 43374, 43677, 43690, 43387
27771, 6245, 6268, 6269, 6246, 42255, 42347, 42351, 42259, 0, 0, 0, 0, 43680, 43692, 43693, 
43389, 43375, 43678, 43691, 43388
27772, 42255, 42347, 42351, 42259, 42256, 42348, 42352, 42260, 43680, 43692, 43693, 43389, 43683, 43695, 43696, 
43392, 43378, 43681, 43694, 43391
27773, 42256, 42348, 42352, 42260, 42257, 42349, 42353, 42261, 43683, 43695, 43696, 43392, 43686, 43698, 43699, 
43395, 43381, 43684, 43697, 43394
27774, 42257, 42349, 42353, 42261, 42258, 42350, 42354, 42262, 43686, 43698, 43699, 43395, 43689, 43701, 43702, 
43398, 43384, 43687, 43700, 43397
27775, 42258, 42350, 42354, 42262, 17057, 17080, 17081, 17058, 43689, 43701, 43702, 43398, 0, 0, 0, 
0, 43387, 43690, 43703, 43400
27776, 6246, 6269, 6270, 6247, 42259, 42351, 42355, 42263, 0, 0, 0, 0, 43693, 43705, 43706, 
43402, 43388, 43691, 43704, 43401
27777, 42259, 42351, 42355, 42263, 42260, 42352, 42356, 42264, 43693, 43705, 43706, 43402, 43696, 43708, 43709, 
43405, 43391, 43694, 43707, 43404
27778, 42260, 42352, 42356, 42264, 42261, 42353, 42357, 42265, 43696, 43708, 43709, 43405, 43699, 43711, 43712, 
43408, 43394, 43697, 43710, 43407
27779, 42261, 42353, 42357, 42265, 42262, 42354, 42358, 42266, 43699, 43711, 43712, 43408, 43702, 43714, 43715, 
43411, 43397, 43700, 43713, 43410
27780, 42262, 42354, 42358, 42266, 17058, 17081, 17082, 17059, 43702, 43714, 43715, 43411, 0, 0, 0, 
0, 43400, 43703, 43716, 43413
27781, 6247, 6270, 6271, 6248, 42263, 42355, 42359, 42267, 0, 0, 0, 0, 43706, 43718, 43719, 
43415, 43401, 43704, 43717, 43414
27782, 42263, 42355, 42359, 42267, 42264, 42356, 42360, 42268, 43706, 43718, 43719, 43415, 43709, 43721, 43722, 
43418, 43404, 43707, 43720, 43417
27783, 42264, 42356, 42360, 42268, 42265, 42357, 42361, 42269, 43709, 43721, 43722, 43418, 43712, 43724, 43725, 
43421, 43407, 43710, 43723, 43420
27784, 42265, 42357, 42361, 42269, 42266, 42358, 42362, 42270, 43712, 43724, 43725, 43421, 43715, 43727, 43728, 
43424, 43410, 43713, 43726, 43423
27785, 42266, 42358, 42362, 42270, 17059, 17082, 17083, 17060, 43715, 43727, 43728, 43424, 0, 0, 0, 
0, 43413, 43716, 43729, 43426
27786, 6248, 6271, 6272, 6249, 42267, 42359, 42363, 42271, 0, 0, 0, 0, 43719, 43731, 43732, 
43428, 43414, 43717, 43730, 43427
27787, 42267, 42359, 42363, 42271, 42268, 42360, 42364, 42272, 43719, 43731, 43732, 43428, 43722, 43734, 43735, 
43431, 43417, 43720, 43733, 43430
27788, 42268, 42360, 42364, 42272, 42269, 42361, 42365, 42273, 43722, 43734, 43735, 43431, 43725, 43737, 43738, 
43434, 43420, 43723, 43736, 43433
27789, 42269, 42361, 42365, 42273, 42270, 42362, 42366, 42274, 43725, 43737, 43738, 43434, 43728, 43740, 43741, 
43437, 43423, 43726, 43739, 43436
27790, 42270, 42362, 42366, 42274, 17060, 17083, 17084, 17061, 43728, 43740, 43741, 43437, 0, 0, 0, 
0, 43426, 43729, 43742, 43439
27791, 6249, 6272, 6273, 6250, 42271, 42363, 42367, 42275, 0, 0, 0, 0, 43732, 43744, 43745, 
43441, 43427, 43730, 43743, 43440
27792, 42271, 42363, 42367, 42275, 42272, 42364, 42368, 42276, 43732, 43744, 43745, 43441, 43735, 43747, 43748, 
43444, 43430, 43733, 43746, 43443
27793, 42272, 42364, 42368, 42276, 42273, 42365, 42369, 42277, 43735, 43747, 43748, 43444, 43738, 43750, 43751, 
43447, 43433, 43736, 43749, 43446
27794, 42273, 42365, 42369, 42277, 42274, 42366, 42370, 42278, 43738, 43750, 43751, 43447, 43741, 43753, 43754, 
43450, 43436, 43739, 43752, 43449
27795, 42274, 42366, 42370, 42278, 17061, 17084, 17085, 17062, 43741, 43753, 43754, 43450, 0, 0, 0, 
0, 43439, 43742, 43755, 43452
27796, 6250, 6273, 6274, 6251, 42275, 42367, 42371, 42279, 0, 0, 0, 0, 43745, 43757, 43758, 
43454, 43440, 43743, 43756, 43453
27797, 42275, 42367, 42371, 42279, 42276, 42368, 42372, 42280, 43745, 43757, 43758, 43454, 43748, 43760, 43761, 
43457, 43443, 43746, 43759, 43456
27798, 42276, 42368, 42372, 42280, 42277, 42369, 42373, 42281, 43748, 43760, 43761, 43457, 43751, 43763, 43764, 
43460, 43446, 43749, 43762, 43459
27799, 42277, 42369, 42373, 42281, 42278, 42370, 42374, 42282, 43751, 43763, 43764, 43460, 43754, 43766, 43767, 
43463, 43449, 43752, 43765, 43462
27800, 42278, 42370, 42374, 42282, 17062, 17085, 17086, 17063, 43754, 43766, 43767, 43463, 0, 0, 0, 
0, 43452, 43755, 43768, 43465
27801, 6251, 6274, 6275, 6252, 42279, 42371, 42375, 42283, 0, 0, 0, 0, 43758, 43770, 43771, 
43467, 43453, 43756, 43769, 43466
27802, 42279, 42371, 42375, 42283, 42280, 42372, 42376, 42284, 43758, 43770, 43771, 43467, 43761, 43773, 43774, 
43470, 43456, 43759, 43772, 43469
27803, 42280, 42372, 42376, 42284, 42281, 42373, 42377, 42285, 43761, 43773, 43774, 43470, 43764, 43776, 43777, 
43473, 43459, 43762, 43775, 43472
27804, 42281, 42373, 42377, 42285, 42282, 42374, 42378, 42286, 43764, 43776, 43777, 43473, 43767, 43779, 43780, 
43476, 43462, 43765, 43778, 43475
27805, 42282, 42374, 42378, 42286, 17063, 17086, 17087, 17064, 43767, 43779, 43780, 43476, 0, 0, 0, 
0, 43465, 43768, 43781, 43478
27806, 6252, 6275, 6276, 6253, 42283, 42375, 42379, 42287, 0, 0, 0, 0, 43771, 43783, 43784, 
43480, 43466, 43769, 43782, 43479
27807, 42283, 42375, 42379, 42287, 42284, 42376, 42380, 42288, 43771, 43783, 43784, 43480, 43774, 43786, 43787, 
43483, 43469, 43772, 43785, 43482
27808, 42284, 42376, 42380, 42288, 42285, 42377, 42381, 42289, 43774, 43786, 43787, 43483, 43777, 43789, 43790, 
43486, 43472, 43775, 43788, 43485
27809, 42285, 42377, 42381, 42289, 42286, 42378, 42382, 42290, 43777, 43789, 43790, 43486, 43780, 43792, 43793, 
43489, 43475, 43778, 43791, 43488
27810, 42286, 42378, 42382, 42290, 17064, 17087, 17088, 17065, 43780, 43792, 43793, 43489, 0, 0, 0, 
0, 43478, 43781, 43794, 43491
27811, 6253, 6276, 6277, 6254, 42287, 42379, 42383, 42291, 0, 0, 0, 0, 43784, 43796, 43797, 
43493, 43479, 43782, 43795, 43492
27812, 42287, 42379, 42383, 42291, 42288, 42380, 42384, 42292, 43784, 43796, 43797, 43493, 43787, 43799, 43800, 
43496, 43482, 43785, 43798, 43495
27813, 42288, 42380, 42384, 42292, 42289, 42381, 42385, 42293, 43787, 43799, 43800, 43496, 43790, 43802, 43803, 
43499, 43485, 43788, 43801, 43498
27814, 42289, 42381, 42385, 42293, 42290, 42382, 42386, 42294, 43790, 43802, 43803, 43499, 43793, 43805, 43806, 
43502, 43488, 43791, 43804, 43501
27815, 42290, 42382, 42386, 42294, 17065, 17088, 17089, 17066, 43793, 43805, 43806, 43502, 0, 0, 0, 
0, 43491, 43794, 43807, 43504
27816, 6254, 6277, 6278, 6255, 42291, 42383, 42387, 42295, 0, 0, 0, 0, 43797, 43809, 43810, 
43506, 43492, 43795, 43808, 43505
27817, 42291, 42383, 42387, 42295, 42292, 42384, 42388, 42296, 43797, 43809, 43810, 43506, 43800, 43812, 43813, 
43509, 43495, 43798, 43811, 43508
27818, 42292, 42384, 42388, 42296, 42293, 42385, 42389, 42297, 43800, 43812, 43813, 43509, 43803, 43815, 43816, 
43512, 43498, 43801, 43814, 43511
27819, 42293, 42385, 42389, 42297, 42294, 42386, 42390, 42298, 43803, 43815, 43816, 43512, 43806, 43818, 43819, 
43515, 43501, 43804, 43817, 43514
27820, 42294, 42386, 42390, 42298, 17066, 17089, 17090, 17067, 43806, 43818, 43819, 43515, 0, 0, 0, 
0, 43504, 43807, 43820, 43517
27821, 6255, 6278, 764, 763, 42295, 42387, 16902, 16898, 0, 0, 0, 0, 43810, 43821, 16951, 
43518, 43505, 43808, 16952, 16943
27822, 42295, 42387, 16902, 16898, 42296, 42388, 16903, 16899, 43810, 43821, 16951, 43518, 43813, 43822, 16953, 
43519, 43508, 43811, 16954, 16945
27823, 42296, 42388, 16903, 16899, 42297, 42389, 16904, 16900, 43813, 43822, 16953, 43519, 43816, 43823, 16955, 
43520, 43511, 43814, 16956, 16947
27824, 42297, 42389, 16904, 16900, 42298, 42390, 16905, 16901, 43816, 43823, 16955, 43520, 43819, 43824, 16957, 
43521, 43514, 43817, 16958, 16949
27825, 42298, 42390, 16905, 16901, 17067, 17090, 2162, 2161, 43819, 43824, 16957, 43521, 0, 0, 0, 
0, 43517, 43820, 16959, 16950
27826, 646, 647, 6279, 6256, 16316, 16320, 42391, 42299, 0, 0, 0, 0, 16374, 43826, 43827, 
43523, 16366, 16375, 43825, 43522
27827, 16316, 16320, 42391, 42299, 16317, 16321, 42392, 42300, 16374, 43826, 43827, 43523, 16376, 43829, 43830, 
43526, 16368, 16377, 43828, 43525
27828, 16317, 16321, 42392, 42300, 16318, 16322, 42393, 42301, 16376, 43829, 43830, 43526, 16378, 43832, 43833, 
43529, 16370, 16379, 43831, 43528
27829, 16318, 16322, 42393, 42301, 16319, 16323, 42394, 42302, 16378, 43832, 43833, 43529, 16380, 43835, 43836, 
43532, 16372, 16381, 43834, 43531
27830, 16319, 16323, 42394, 42302, 2092, 2093, 17091, 17068, 16380, 43835, 43836, 43532, 0, 0, 0, 
0, 16373, 16382, 43837, 43534
27831, 6256, 6279, 6280, 6257, 42299, 42391, 42395, 42303, 0, 0, 0, 0, 43827, 43839, 43840, 
43536, 43522, 43825, 43838, 43535
27832, 42299, 42391, 42395, 42303, 42300, 42392, 42396, 42304, 43827, 43839, 43840, 43536, 43830, 43842, 43843, 
43539, 43525, 43828, 43841, 43538
27833, 42300, 42392, 42396, 42304, 42301, 42393, 42397, 42305, 43830, 43842, 43843, 43539, 43833, 43845, 43846, 
43542, 43528, 43831, 43844, 43541
27834, 42301, 42393, 42397, 42305, 42302, 42394, 42398, 42306, 43833, 43845, 43846, 43542, 43836, 43848, 43849, 
43545, 43531, 43834, 43847, 43544
27835, 42302, 42394, 42398, 42306, 17068, 17091, 17092, 17069, 43836, 43848, 43849, 43545, 0, 0, 0, 
0, 43534, 43837, 43850, 43547
27836, 6257, 6280, 6281, 6258, 42303, 42395, 42399, 42307, 0, 0, 0, 0, 43840, 43852, 43853, 
43549, 43535, 43838, 43851, 43548
27837, 42303, 42395, 42399, 42307, 42304, 42396, 42400, 42308, 43840, 43852, 43853, 43549, 43843, 43855, 43856, 
43552, 43538, 43841, 43854, 43551
27838, 42304, 42396, 42400, 42308, 42305, 42397, 42401, 42309, 43843, 43855, 43856, 43552, 43846, 43858, 43859, 
43555, 43541, 43844, 43857, 43554
27839, 42305, 42397, 42401, 42309, 42306, 42398, 42402, 42310, 43846, 43858, 43859, 43555, 43849, 43861, 43862, 
43558, 43544, 43847, 43860, 43557
27840, 42306, 42398, 42402, 42310, 17069, 17092, 17093, 17070, 43849, 43861, 43862, 43558, 0, 0, 0, 
0, 43547, 43850, 43863, 43560
27841, 6258, 6281, 6282, 6259, 42307, 42399, 42403, 42311, 0, 0, 0, 0, 43853, 43865, 43866, 
43562, 43548, 43851, 43864, 43561
27842, 42307, 42399, 42403, 42311, 42308, 42400, 42404, 42312, 43853, 43865, 43866, 43562, 43856, 43868, 43869, 
43565, 43551, 43854, 43867, 43564
27843, 42308, 42400, 42404, 42312, 42309, 42401, 42405, 42313, 43856, 43868, 43869, 43565, 43859, 43871, 43872, 
43568, 43554, 43857, 43870, 43567
27844, 42309, 42401, 42405, 42313, 42310, 42402, 42406, 42314, 43859, 43871, 43872, 43568, 43862, 43874, 43875, 
43571, 43557, 43860, 43873, 43570
27845, 42310, 42402, 42406, 42314, 17070, 17093, 17094, 17071, 43862, 43874, 43875, 43571, 0, 0, 0, 
0, 43560, 43863, 43876, 43573
27846, 6259, 6282, 6283, 6260, 42311, 42403, 42407, 42315, 0, 0, 0, 0, 43866, 43878, 43879, 
43575, 43561, 43864, 43877, 43574
27847, 42311, 42403, 42407, 42315, 42312, 42404, 42408, 42316, 43866, 43878, 43879, 43575, 43869, 43881, 43882, 
43578, 43564, 43867, 43880, 43577
27848, 42312, 42404, 42408, 42316, 42313, 42405, 42409, 42317, 43869, 43881, 43882, 43578, 43872, 43884, 43885, 
43581, 43567, 43870, 43883, 43580
27849, 42313, 42405, 42409, 42317, 42314, 42406, 42410, 42318, 43872, 43884, 43885, 43581, 43875, 43887, 43888, 
43584, 43570, 43873, 43886, 43583
27850, 42314, 42406, 42410, 42318, 17071, 17094, 17095, 17072, 43875, 43887, 43888, 43584, 0, 0, 0, 
0, 43573, 43876, 43889, 43586
27851, 6260, 6283, 6284, 6261, 42315, 42407, 42411, 42319, 0, 0, 0, 0, 43879, 43891, 43892, 
43588, 43574, 43877, 43890, 43587
27852, 42315, 42407, 42411, 42319, 42316, 42408, 42412, 42320, 43879, 43891, 43892, 43588, 43882, 43894, 43895, 
43591, 43577, 43880, 43893, 43590
27853, 42316, 42408, 42412, 42320, 42317, 42409, 42413, 42321, 43882, 43894, 43895, 43591, 43885, 43897, 43898, 
43594, 43580, 43883, 43896, 43593
27854, 42317, 42409, 42413, 42321, 42318, 42410, 42414, 42322, 43885, 43897, 43898, 43594, 43888, 43900, 43901, 
43597, 43583, 43886, 43899, 43596
27855, 42318, 42410, 42414, 42322, 17072, 17095, 17096, 17073, 43888, 43900, 43901, 43597, 0, 0, 0, 
0, 43586, 43889, 43902, 43599
27856, 6261, 6284, 6285, 6262, 42319, 42411, 42415, 42323, 0, 0, 0, 0, 43892, 43904, 43905, 
43601, 43587, 43890, 43903, 43600
27857, 42319, 42411, 42415, 42323, 42320, 42412, 42416, 42324, 43892, 43904, 43905, 43601, 43895, 43907, 43908, 
43604, 43590, 43893, 43906, 43603
27858, 42320, 42412, 42416, 42324, 42321, 42413, 42417, 42325, 43895, 43907, 43908, 43604, 43898, 43910, 43911, 
43607, 43593, 43896, 43909, 43606
27859, 42321, 42413, 42417, 42325, 42322, 42414, 42418, 42326, 43898, 43910, 43911, 43607, 43901, 43913, 43914, 
43610, 43596, 43899, 43912, 43609
27860, 42322, 42414, 42418, 42326, 17073, 17096, 17097, 17074, 43901, 43913, 43914, 43610, 0, 0, 0, 
0, 43599, 43902, 43915, 43612
27861, 6262, 6285, 6286, 6263, 42323, 42415, 42419, 42327, 0, 0, 0, 0, 43905, 43917, 43918, 
43614, 43600, 43903, 43916, 43613
27862, 42323, 42415, 42419, 42327, 42324, 42416, 42420, 42328, 43905, 43917, 43918, 43614, 43908, 43920, 43921, 
43617, 43603, 43906, 43919, 43616
27863, 42324, 42416, 42420, 42328, 42325, 42417, 42421, 42329, 43908, 43920, 43921, 43617, 43911, 43923, 43924, 
43620, 43606, 43909, 43922, 43619
27864, 42325, 42417, 42421, 42329, 42326, 42418, 42422, 42330, 43911, 43923, 43924, 43620, 43914, 43926, 43927, 
43623, 43609, 43912, 43925, 43622
27865, 42326, 42418, 42422, 42330, 17074, 17097, 17098, 17075, 43914, 43926, 43927, 43623, 0, 0, 0, 
0, 43612, 43915, 43928, 43625
27866, 6263, 6286, 6287, 6264, 42327, 42419, 42423, 42331, 0, 0, 0, 0, 43918, 43930, 43931, 
43627, 43613, 43916, 43929, 43626
27867, 42327, 42419, 42423, 42331, 42328, 42420, 42424, 42332, 43918, 43930, 43931, 43627, 43921, 43933, 43934, 
43630, 43616, 43919, 43932, 43629
27868, 42328, 42420, 42424, 42332, 42329, 42421, 42425, 42333, 43921, 43933, 43934, 43630, 43924, 43936, 43937, 
43633, 43619, 43922, 43935, 43632
27869, 42329, 42421, 42425, 42333, 42330, 42422, 42426, 42334, 43924, 43936, 43937, 43633, 43927, 43939, 43940, 
43636, 43622, 43925, 43938, 43635
27870, 42330, 42422, 42426, 42334, 17075, 17098, 17099, 17076, 43927, 43939, 43940, 43636, 0, 0, 0, 
0, 43625, 43928, 43941, 43638
27871, 6264, 6287, 6288, 6265, 42331, 42423, 42427, 42335, 0, 0, 0, 0, 43931, 43943, 43944, 
43640, 43626, 43929, 43942, 43639
27872, 42331, 42423, 42427, 42335, 42332, 42424, 42428, 42336, 43931, 43943, 43944, 43640, 43934, 43946, 43947, 
43643, 43629, 43932, 43945, 43642
27873, 42332, 42424, 42428, 42336, 42333, 42425, 42429, 42337, 43934, 43946, 43947, 43643, 43937, 43949, 43950, 
43646, 43632, 43935, 43948, 43645
27874, 42333, 42425, 42429, 42337, 42334, 42426, 42430, 42338, 43937, 43949, 43950, 43646, 43940, 43952, 43953, 
43649, 43635, 43938, 43951, 43648
27875, 42334, 42426, 42430, 42338, 17076, 17099, 17100, 17077, 43940, 43952, 43953, 43649, 0, 0, 0, 
0, 43638, 43941, 43954, 43651
27876, 6265, 6288, 6289, 6266, 42335, 42427, 42431, 42339, 0, 0, 0, 0, 43944, 43956, 43957, 
43653, 43639, 43942, 43955, 43652
27877, 42335, 42427, 42431, 42339, 42336, 42428, 42432, 42340, 43944, 43956, 43957, 43653, 43947, 43959, 43960, 
43656, 43642, 43945, 43958, 43655
27878, 42336, 42428, 42432, 42340, 42337, 42429, 42433, 42341, 43947, 43959, 43960, 43656, 43950, 43962, 43963, 
43659, 43645, 43948, 43961, 43658
27879, 42337, 42429, 42433, 42341, 42338, 42430, 42434, 42342, 43950, 43962, 43963, 43659, 43953, 43965, 43966, 
43662, 43648, 43951, 43964, 43661
27880, 42338, 42430, 42434, 42342, 17077, 17100, 17101, 17078, 43953, 43965, 43966, 43662, 0, 0, 0, 
0, 43651, 43954, 43967, 43664
27881, 6266, 6289, 6290, 6267, 42339, 42431, 42435, 42343, 0, 0, 0, 0, 43957, 43969, 43970, 
43666, 43652, 43955, 43968, 43665
27882, 42339, 42431, 42435, 42343, 42340, 42432, 42436, 42344, 43957, 43969, 43970, 43666, 43960, 43972, 43973, 
43669, 43655, 43958, 43971, 43668
27883, 42340, 42432, 42436, 42344, 42341, 42433, 42437, 42345, 43960, 43972, 43973, 43669, 43963, 43975, 43976, 
43672, 43658, 43961, 43974, 43671
27884, 42341, 42433, 42437, 42345, 42342, 42434, 42438, 42346, 43963, 43975, 43976, 43672, 43966, 43978, 43979, 
43675, 43661, 43964, 43977, 43674
27885, 42342, 42434, 42438, 42346, 17078, 17101, 17102, 17079, 43966, 43978, 43979, 43675, 0, 0, 0, 
0, 43664, 43967, 43980, 43677
27886, 6267, 6290, 6291, 6268, 42343, 42435, 42439, 42347, 0, 0, 0, 0, 43970, 43982, 43983, 
43679, 43665, 43968, 43981, 43678
27887, 42343, 42435, 42439, 42347, 42344, 42436, 42440, 42348, 43970, 43982, 43983, 43679, 43973, 43985, 43986, 
43682, 43668, 43971, 43984, 43681
27888, 42344, 42436, 42440, 42348, 42345, 42437, 42441, 42349, 43973, 43985, 43986, 43682, 43976, 43988, 43989, 
43685, 43671, 43974, 43987, 43684
27889, 42345, 42437, 42441, 42349, 42346, 42438, 42442, 42350, 43976, 43988, 43989, 43685, 43979, 43991, 43992, 
43688, 43674, 43977, 43990, 43687
27890, 42346, 42438, 42442, 42350, 17079, 17102, 17103, 17080, 43979, 43991, 43992, 43688, 0, 0, 0, 
0, 43677, 43980, 43993, 43690
27891, 6268, 6291, 6292, 6269, 42347, 42439, 42443, 42351, 0, 0, 0, 0, 43983, 43995, 43996, 
43692, 43678, 43981, 43994, 43691
27892, 42347, 42439, 42443, 42351, 42348, 42440, 42444, 42352, 43983, 43995, 43996, 43692, 43986, 43998, 43999, 
43695, 43681, 43984, 43997, 43694
27893, 42348, 42440, 42444, 42352, 42349, 42441, 42445, 42353, 43986, 43998, 43999, 43695, 43989, 44001, 44002, 
43698, 43684, 43987, 44000, 43697
27894, 42349, 42441, 42445, 42353, 42350, 42442, 42446, 42354, 43989, 44001, 44002, 43698, 43992, 44004, 44005, 
43701, 43687, 43990, 44003, 43700
27895, 42350, 42442, 42446, 42354, 17080, 17103, 17104, 17081, 43992, 44004, 44005, 43701, 0, 0, 0, 
0, 43690, 43993, 44006, 43703
27896, 6269, 6292, 6293, 6270, 42351, 42443, 42447, 42355, 0, 0, 0, 0, 43996, 44008, 44009, 
43705, 43691, 43994, 44007, 43704
27897, 42351, 42443, 42447, 42355, 42352, 42444, 42448, 42356, 43996, 44008, 44009, 43705, 43999, 44011, 44012, 
43708, 43694, 43997, 44010, 43707
27898, 42352, 42444, 42448, 42356, 42353, 42445, 42449, 42357, 43999, 44011, 44012, 43708, 44002, 44014, 44015, 
43711, 43697, 44000, 44013, 43710
27899, 42353, 42445, 42449, 42357, 42354, 42446, 42450, 42358, 44002, 44014, 44015, 43711, 44005, 44017, 44018, 
43714, 43700, 44003, 44016, 43713
27900, 42354, 42446, 42450, 42358, 17081, 17104, 17105, 17082, 44005, 44017, 44018, 43714, 0, 0, 0, 
0, 43703, 44006, 44019, 43716
27901, 6270, 6293, 6294, 6271, 42355, 42447, 42451, 42359, 0, 0, 0, 0, 44009, 44021, 44022, 
43718, 43704, 44007, 44020, 43717
27902, 42355, 42447, 42451, 42359, 42356, 42448, 42452, 42360, 44009, 44021, 44022, 43718, 44012, 44024, 44025, 
43721, 43707, 44010, 44023, 43720
27903, 42356, 42448, 42452, 42360, 42357, 42449, 42453, 42361, 44012, 44024, 44025, 43721, 44015, 44027, 44028, 
43724, 43710, 44013, 44026, 43723
27904, 42357, 42449, 42453, 42361, 42358, 42450, 42454, 42362, 44015, 44027, 44028, 43724, 44018, 44030, 44031, 
43727, 43713, 44016, 44029, 43726
27905, 42358, 42450, 42454, 42362, 17082, 17105, 17106, 17083, 44018, 44030, 44031, 43727, 0, 0, 0, 
0, 43716, 44019, 44032, 43729
27906, 6271, 6294, 6295, 6272, 42359, 42451, 42455, 42363, 0, 0, 0, 0, 44022, 44034, 44035, 
43731, 43717, 44020, 44033, 43730
27907, 42359, 42451, 42455, 42363, 42360, 42452, 42456, 42364, 44022, 44034, 44035, 43731, 44025, 44037, 44038, 
43734, 43720, 44023, 44036, 43733
27908, 42360, 42452, 42456, 42364, 42361, 42453, 42457, 42365, 44025, 44037, 44038, 43734, 44028, 44040, 44041, 
43737, 43723, 44026, 44039, 43736
27909, 42361, 42453, 42457, 42365, 42362, 42454, 42458, 42366, 44028, 44040, 44041, 43737, 44031, 44043, 44044, 
43740, 43726, 44029, 44042, 43739
27910, 42362, 42454, 42458, 42366, 17083, 17106, 17107, 17084, 44031, 44043, 44044, 43740, 0, 0, 0, 
0, 43729, 44032, 44045, 43742
27911, 6272, 6295, 6296, 6273, 42363, 42455, 42459, 42367, 0, 0, 0, 0, 44035, 44047, 44048, 
43744, 43730, 44033, 44046, 43743
27912, 42363, 42455, 42459, 42367, 42364, 42456, 42460, 42368, 44035, 44047, 44048, 43744, 44038, 44050, 44051, 
43747, 43733, 44036, 44049, 43746
27913, 42364, 42456, 42460, 42368, 42365, 42457, 42461, 42369, 44038, 44050, 44051, 43747, 44041, 44053, 44054, 
43750, 43736, 44039, 44052, 43749
27914, 42365, 42457, 42461, 42369, 42366, 42458, 42462, 42370, 44041, 44053, 44054, 43750, 44044, 44056, 44057, 
43753, 43739, 44042, 44055, 43752
27915, 42366, 42458, 42462, 42370, 17084, 17107, 17108, 17085, 44044, 44056, 44057, 43753, 0, 0, 0, 
0, 43742, 44045, 44058, 43755
27916, 6273, 6296, 6297, 6274, 42367, 42459, 42463, 42371, 0, 0, 0, 0, 44048, 44060, 44061, 
43757, 43743, 44046, 44059, 43756
27917, 42367, 42459, 42463, 42371, 42368, 42460, 42464, 42372, 44048, 44060, 44061, 43757, 44051, 44063, 44064, 
43760, 43746, 44049, 44062, 43759
27918, 42368, 42460, 42464, 42372, 42369, 42461, 42465, 42373, 44051, 44063, 44064, 43760, 44054, 44066, 44067, 
43763, 43749, 44052, 44065, 43762
27919, 42369, 42461, 42465, 42373, 42370, 42462, 42466, 42374, 44054, 44066, 44067, 43763, 44057, 44069, 44070, 
43766, 43752, 44055, 44068, 43765
27920, 42370, 42462, 42466, 42374, 17085, 17108, 17109, 17086, 44057, 44069, 44070, 43766, 0, 0, 0, 
0, 43755, 44058, 44071, 43768
27921, 6274, 6297, 6298, 6275, 42371, 42463, 42467, 42375, 0, 0, 0, 0, 44061, 44073, 44074, 
43770, 43756, 44059, 44072, 43769
27922, 42371, 42463, 42467, 42375, 42372, 42464, 42468, 42376, 44061, 44073, 44074, 43770, 44064, 44076, 44077, 
43773, 43759, 44062, 44075, 43772
27923, 42372, 42464, 42468, 42376, 42373, 42465, 42469, 42377, 44064, 44076, 44077, 43773, 44067, 44079, 44080, 
43776, 43762, 44065, 44078, 43775
27924, 42373, 42465, 42469, 42377, 42374, 42466, 42470, 42378, 44067, 44079, 44080, 43776, 44070, 44082, 44083, 
43779, 43765, 44068, 44081, 43778
27925, 42374, 42466, 42470, 42378, 17086, 17109, 17110, 17087, 44070, 44082, 44083, 43779, 0, 0, 0, 
0, 43768, 44071, 44084, 43781
27926, 6275, 6298, 6299, 6276, 42375, 42467, 42471, 42379, 0, 0, 0, 0, 44074, 44086, 44087, 
43783, 43769, 44072, 44085, 43782
27927, 42375, 42467, 42471, 42379, 42376, 42468, 42472, 42380, 44074, 44086, 44087, 43783, 44077, 44089, 44090, 
43786, 43772, 44075, 44088, 43785
27928, 42376, 42468, 42472, 42380, 42377, 42469, 42473, 42381, 44077, 44089, 44090, 43786, 44080, 44092, 44093, 
43789, 43775, 44078, 44091, 43788
27929, 42377, 42469, 42473, 42381, 42378, 42470, 42474, 42382, 44080, 44092, 44093, 43789, 44083, 44095, 44096, 
43792, 43778, 44081, 44094, 43791
27930, 42378, 42470, 42474, 42382, 17087, 17110, 17111, 17088, 44083, 44095, 44096, 43792, 0, 0, 0, 
0, 43781, 44084, 44097, 43794
27931, 6276, 6299, 6300, 6277, 42379, 42471, 42475, 42383, 0, 0, 0, 0, 44087, 44099, 44100, 
43796, 43782, 44085, 44098, 43795
27932, 42379, 42471, 42475, 42383, 42380, 42472, 42476, 42384, 44087, 44099, 44100, 43796, 44090, 44102, 44103, 
43799, 43785, 44088, 44101, 43798
27933, 42380, 42472, 42476, 42384, 42381, 42473, 42477, 42385, 44090, 44102, 44103, 43799, 44093, 44105, 44106, 
43802, 43788, 44091, 44104, 43801
27934, 42381, 42473, 42477, 42385, 42382, 42474, 42478, 42386, 44093, 44105, 44106, 43802, 44096, 44108, 44109, 
43805, 43791, 44094, 44107, 43804
27935, 42382, 42474, 42478, 42386, 17088, 17111, 17112, 17089, 44096, 44108, 44109, 43805, 0, 0, 0, 
0, 43794, 44097, 44110, 43807
27936, 6277, 6300, 6301, 6278, 42383, 42475, 42479, 42387, 0, 0, 0, 0, 44100, 44112, 44113, 
43809, 43795, 44098, 44111, 43808
27937, 42383, 42475, 42479, 42387, 42384, 42476, 42480, 42388, 44100, 44112, 44113, 43809, 44103, 44115, 44116, 
43812, 43798, 44101, 44114, 43811
27938, 42384, 42476, 42480, 42388, 42385, 42477, 42481, 42389, 44103, 44115, 44116, 43812, 44106, 44118, 44119, 
43815, 43801, 44104, 44117, 43814
27939, 42385, 42477, 42481, 42389, 42386, 42478, 42482, 42390, 44106, 44118, 44119, 43815, 44109, 44121, 44122, 
43818, 43804, 44107, 44120, 43817
27940, 42386, 42478, 42482, 42390, 17089, 17112, 17113, 17090, 44109, 44121, 44122, 43818, 0, 0, 0, 
0, 43807, 44110, 44123, 43820
27941, 6278, 6301, 765, 764, 42387, 42479, 16906, 16902, 0, 0, 0, 0, 44113, 44124, 16960, 
43821, 43808, 44111, 16961, 16952
27942, 42387, 42479, 16906, 16902, 42388, 42480, 16907, 16903, 44113, 44124, 16960, 43821, 44116, 44125, 16962, 
43822, 43811, 44114, 16963, 16954
27943, 42388, 42480, 16907, 16903, 42389, 42481, 16908, 16904, 44116, 44125, 16962, 43822, 44119, 44126, 16964, 
43823, 43814, 44117, 16965, 16956
27944, 42389, 42481, 16908, 16904, 42390, 42482, 16909, 16905, 44119, 44126, 16964, 43823, 44122, 44127, 16966, 
43824, 43817, 44120, 16967, 16958
27945, 42390, 42482, 16909, 16905, 17090, 17113, 2163, 2162, 44122, 44127, 16966, 43824, 0, 0, 0, 
0, 43820, 44123, 16968, 16959
27946, 647, 648, 6302, 6279, 16320, 16324, 42483, 42391, 0, 0, 0, 0, 16383, 44129, 44130, 
43826, 16375, 16384, 44128, 43825
27947, 16320, 16324, 42483, 42391, 16321, 16325, 42484, 42392, 16383, 44129, 44130, 43826, 16385, 44132, 44133, 
43829, 16377, 16386, 44131, 43828
27948, 16321, 16325, 42484, 42392, 16322, 16326, 42485, 42393, 16385, 44132, 44133, 43829, 16387, 44135, 44136, 
43832, 16379, 16388, 44134, 43831
27949, 16322, 16326, 42485, 42393, 16323, 16327, 42486, 42394, 16387, 44135, 44136, 43832, 16389, 44138, 44139, 
43835, 16381, 16390, 44137, 43834
27950, 16323, 16327, 42486, 42394, 2093, 2094, 17114, 17091, 16389, 44138, 44139, 43835, 0, 0, 0, 
0, 16382, 16391, 44140, 43837
27951, 6279, 6302, 6303, 6280, 42391, 42483, 42487, 42395, 0, 0, 0, 0, 44130, 44142, 44143, 
43839, 43825, 44128, 44141, 43838
27952, 42391, 42483, 42487, 42395, 42392, 42484, 42488, 42396, 44130, 44142, 44143, 43839, 44133, 44145, 44146, 
43842, 43828, 44131, 44144, 43841
27953, 42392, 42484, 42488, 42396, 42393, 42485, 42489, 42397, 44133, 44145, 44146, 43842, 44136, 44148, 44149, 
43845, 43831, 44134, 44147, 43844
27954, 42393, 42485, 42489, 42397, 42394, 42486, 42490, 42398, 44136, 44148, 44149, 43845, 44139, 44151, 44152, 
43848, 43834, 44137, 44150, 43847
27955, 42394, 42486, 42490, 42398, 17091, 17114, 17115, 17092, 44139, 44151, 44152, 43848, 0, 0, 0, 
0, 43837, 44140, 44153, 43850
27956, 6280, 6303, 6304, 6281, 42395, 42487, 42491, 42399, 0, 0, 0, 0, 44143, 44155, 44156, 
43852, 43838, 44141, 44154, 43851
27957, 42395, 42487, 42491, 42399, 42396, 42488, 42492, 42400, 44143, 44155, 44156, 43852, 44146, 44158, 44159, 
43855, 43841, 44144, 44157, 43854
27958, 42396, 42488, 42492, 42400, 42397, 42489, 42493, 42401, 44146, 44158, 44159, 43855, 44149, 44161, 44162, 
43858, 43844, 44147, 44160, 43857
27959, 42397, 42489, 42493, 42401, 42398, 42490, 42494, 42402, 44149, 44161, 44162, 43858, 44152, 44164, 44165, 
43861, 43847, 44150, 44163, 43860
27960, 42398, 42490, 42494, 42402, 17092, 17115, 17116, 17093, 44152, 44164, 44165, 43861, 0, 0, 0, 
0, 43850, 44153, 44166, 43863
27961, 6281, 6304, 6305, 6282, 42399, 42491, 42495, 42403, 0, 0, 0, 0, 44156, 44168, 44169, 
43865, 43851, 44154, 44167, 43864
27962, 42399, 42491, 42495, 42403, 42400, 42492, 42496, 42404, 44156, 44168, 44169, 43865, 44159, 44171, 44172, 
43868, 43854, 44157, 44170, 43867
27963, 42400, 42492, 42496, 42404, 42401, 42493, 42497, 42405, 44159, 44171, 44172, 43868, 44162, 44174, 44175, 
43871, 43857, 44160, 44173, 43870
27964, 42401, 42493, 42497, 42405, 42402, 42494, 42498, 42406, 44162, 44174, 44175, 43871, 44165, 44177, 44178, 
43874, 43860, 44163, 44176, 43873
27965, 42402, 42494, 42498, 42406, 17093, 17116, 17117, 17094, 44165, 44177, 44178, 43874, 0, 0, 0, 
0, 43863, 44166, 44179, 43876
27966, 6282, 6305, 6306, 6283, 42403, 42495, 42499, 42407, 0, 0, 0, 0, 44169, 44181, 44182, 
43878, 43864, 44167, 44180, 43877
27967, 42403, 42495, 42499, 42407, 42404, 42496, 42500, 42408, 44169, 44181, 44182, 43878, 44172, 44184, 44185, 
43881, 43867, 44170, 44183, 43880
27968, 42404, 42496, 42500, 42408, 42405, 42497, 42501, 42409, 44172, 44184, 44185, 43881, 44175, 44187, 44188, 
43884, 43870, 44173, 44186, 43883
27969, 42405, 42497, 42501, 42409, 42406, 42498, 42502, 42410, 44175, 44187, 44188, 43884, 44178, 44190, 44191, 
43887, 43873, 44176, 44189, 43886
27970, 42406, 42498, 42502, 42410, 17094, 17117, 17118, 17095, 44178, 44190, 44191, 43887, 0, 0, 0, 
0, 43876, 44179, 44192, 43889
27971, 6283, 6306, 6307, 6284, 42407, 42499, 42503, 42411, 0, 0, 0, 0, 44182, 44194, 44195, 
43891, 43877, 44180, 44193, 43890
27972, 42407, 42499, 42503, 42411, 42408, 42500, 42504, 42412, 44182, 44194, 44195, 43891, 44185, 44197, 44198, 
43894, 43880, 44183, 44196, 43893
27973, 42408, 42500, 42504, 42412, 42409, 42501, 42505, 42413, 44185, 44197, 44198, 43894, 44188, 44200, 44201, 
43897, 43883, 44186, 44199, 43896
27974, 42409, 42501, 42505, 42413, 42410, 42502, 42506, 42414, 44188, 44200, 44201, 43897, 44191, 44203, 44204, 
43900, 43886, 44189, 44202, 43899
27975, 42410, 42502, 42506, 42414, 17095, 17118, 17119, 17096, 44191, 44203, 44204, 43900, 0, 0, 0, 
0, 43889, 44192, 44205, 43902
27976, 6284, 6307, 6308, 6285, 42411, 42503, 42507, 42415, 0, 0, 0, 0, 44195, 44207, 44208, 
43904, 43890, 44193, 44206, 43903
27977, 42411, 42503, 42507, 42415, 42412, 42504, 42508, 42416, 44195, 44207, 44208, 43904, 44198, 44210, 44211, 
43907, 43893, 44196, 44209, 43906
27978, 42412, 42504, 42508, 42416, 42413, 42505, 42509, 42417, 44198, 44210, 44211, 43907, 44201, 44213, 44214, 
43910, 43896, 44199, 44212, 43909
27979, 42413, 42505, 42509, 42417, 42414, 42506, 42510, 42418, 44201, 44213, 44214, 43910, 44204, 44216, 44217, 
43913, 43899, 44202, 44215, 43912
27980, 42414, 42506, 42510, 42418, 17096, 17119, 17120, 17097, 44204, 44216, 44217, 43913, 0, 0, 0, 
0, 43902, 44205, 44218, 43915
27981, 6285, 6308, 6309, 6286, 42415, 42507, 42511, 42419, 0, 0, 0, 0, 44208, 44220, 44221, 
43917, 43903, 44206, 44219, 43916
27982, 42415, 42507, 42511, 42419, 42416, 42508, 42512, 42420, 44208, 44220, 44221, 43917, 44211, 44223, 44224, 
43920, 43906, 44209, 44222, 43919
27983, 42416, 42508, 42512, 42420, 42417, 42509, 42513, 42421, 44211, 44223, 44224, 43920, 44214, 44226, 44227, 
43923, 43909, 44212, 44225, 43922
27984, 42417, 42509, 42513, 42421, 42418, 42510, 42514, 42422, 44214, 44226, 44227, 43923, 44217, 44229, 44230, 
43926, 43912, 44215, 44228, 43925
27985, 42418, 42510, 42514, 42422, 17097, 17120, 17121, 17098, 44217, 44229, 44230, 43926, 0, 0, 0, 
0, 43915, 44218, 44231, 43928
27986, 6286, 6309, 6310, 6287, 42419, 42511, 42515, 42423, 0, 0, 0, 0, 44221, 44233, 44234, 
43930, 43916, 44219, 44232, 43929
27987, 42419, 42511, 42515, 42423, 42420, 42512, 42516, 42424, 44221, 44233, 44234, 43930, 44224, 44236, 44237, 
43933, 43919, 44222, 44235, 43932
27988, 42420, 42512, 42516, 42424, 42421, 42513, 42517, 42425, 44224, 44236, 44237, 43933, 44227, 44239, 44240, 
43936, 43922, 44225, 44238, 43935
27989, 42421, 42513, 42517, 42425, 42422, 42514, 42518, 42426, 44227, 44239, 44240, 43936, 44230, 44242, 44243, 
43939, 43925, 44228, 44241, 43938
27990, 42422, 42514, 42518, 42426, 17098, 17121, 17122, 17099, 44230, 44242, 44243, 43939, 0, 0, 0, 
0, 43928, 44231, 44244, 43941
27991, 6287, 6310, 6311, 6288, 42423, 42515, 42519, 42427, 0, 0, 0, 0, 44234, 44246, 44247, 
43943, 43929, 44232, 44245, 43942
27992, 42423, 42515, 42519, 42427, 42424, 42516, 42520, 42428, 44234, 44246, 44247, 43943, 44237, 44249, 44250, 
43946, 43932, 44235, 44248, 43945
27993, 42424, 42516, 42520, 42428, 42425, 42517, 42521, 42429, 44237, 44249, 44250, 43946, 44240, 44252, 44253, 
43949, 43935, 44238, 44251, 43948
27994, 42425, 42517, 42521, 42429, 42426, 42518, 42522, 42430, 44240, 44252, 44253, 43949, 44243, 44255, 44256, 
43952, 43938, 44241, 44254, 43951
27995, 42426, 42518, 42522, 42430, 17099, 17122, 17123, 17100, 44243, 44255, 44256, 43952, 0, 0, 0, 
0, 43941, 44244, 44257, 43954
27996, 6288, 6311, 6312, 6289, 42427, 42519, 42523, 42431, 0, 0, 0, 0, 44247, 44259, 44260, 
43956, 43942, 44245, 44258, 43955
27997, 42427, 42519, 42523, 42431, 42428, 42520, 42524, 42432, 44247, 44259, 44260, 43956, 44250, 44262, 44263, 
43959, 43945, 44248, 44261, 43958
27998, 42428, 42520, 42524, 42432, 42429, 42521, 42525, 42433, 44250, 44262, 44263, 43959, 44253, 44265, 44266, 
43962, 43948, 44251, 44264, 43961
27999, 42429, 42521, 42525, 42433, 42430, 42522, 42526, 42434, 44253, 44265, 44266, 43962, 44256, 44268, 44269, 
43965, 43951, 44254, 44267, 43964
28000, 42430, 42522, 42526, 42434, 17100, 17123, 17124, 17101, 44256, 44268, 44269, 43965, 0, 0, 0, 
0, 43954, 44257, 44270, 43967
28001, 6289, 6312, 6313, 6290, 42431, 42523, 42527, 42435, 0, 0, 0, 0, 44260, 44272, 44273, 
43969, 43955, 44258, 44271, 43968
28002, 42431, 42523, 42527, 42435, 42432, 42524, 42528, 42436, 44260, 44272, 44273, 43969, 44263, 44275, 44276, 
43972, 43958, 44261, 44274, 43971
28003, 42432, 42524, 42528, 42436, 42433, 42525, 42529, 42437, 44263, 44275, 44276, 43972, 44266, 44278, 44279, 
43975, 43961, 44264, 44277, 43974
28004, 42433, 42525, 42529, 42437, 42434, 42526, 42530, 42438, 44266, 44278, 44279, 43975, 44269, 44281, 44282, 
43978, 43964, 44267, 44280, 43977
28005, 42434, 42526, 42530, 42438, 17101, 17124, 17125, 17102, 44269, 44281, 44282, 43978, 0, 0, 0, 
0, 43967, 44270, 44283, 43980
28006, 6290, 6313, 6314, 6291, 42435, 42527, 42531, 42439, 0, 0, 0, 0, 44273, 44285, 44286, 
43982, 43968, 44271, 44284, 43981
28007, 42435, 42527, 42531, 42439, 42436, 42528, 42532, 42440, 44273, 44285, 44286, 43982, 44276, 44288, 44289, 
43985, 43971, 44274, 44287, 43984
28008, 42436, 42528, 42532, 42440, 42437, 42529, 42533, 42441, 44276, 44288, 44289, 43985, 44279, 44291, 44292, 
43988, 43974, 44277, 44290, 43987
28009, 42437, 42529, 42533, 42441, 42438, 42530, 42534, 42442, 44279, 44291, 44292, 43988, 44282, 44294, 44295, 
43991, 43977, 44280, 44293, 43990
28010, 42438, 42530, 42534, 42442, 17102, 17125, 17126, 17103, 44282, 44294, 44295, 43991, 0, 0, 0, 
0, 43980, 44283, 44296, 43993
28011, 6291, 6314, 6315, 6292, 42439, 42531, 42535, 42443, 0, 0, 0, 0, 44286, 44298, 44299, 
