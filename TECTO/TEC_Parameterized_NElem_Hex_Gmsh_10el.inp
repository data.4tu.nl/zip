44636, 1.8458333333333, 1.66, 0.20833333333333
44637, 1.8666666666667, 1.66, 0.1875
44638, 1.8666666666667, 1.68, 0.20833333333333
44639, 1.9083333333333, 1.52, 0.20833333333333
44640, 1.8875, 1.54, 0.20833333333333
44641, 1.9083333333333, 1.54, 0.1875
44642, 1.9083333333333, 1.56, 0.20833333333333
44643, 1.8875, 1.58, 0.20833333333333
44644, 1.9083333333333, 1.58, 0.1875
44645, 1.9083333333333, 1.6, 0.20833333333333
44646, 1.8875, 1.62, 0.20833333333333
44647, 1.9083333333333, 1.62, 0.1875
44648, 1.9083333333333, 1.64, 0.20833333333333
44649, 1.8875, 1.66, 0.20833333333333
44650, 1.9083333333333, 1.66, 0.1875
44651, 1.9083333333333, 1.68, 0.20833333333333
44652, 1.95, 1.52, 0.20833333333333
44653, 1.9291666666667, 1.54, 0.20833333333333
44654, 1.95, 1.54, 0.1875
44655, 1.95, 1.56, 0.20833333333333
44656, 1.9291666666667, 1.58, 0.20833333333333
44657, 1.95, 1.58, 0.1875
44658, 1.95, 1.6, 0.20833333333333
44659, 1.9291666666667, 1.62, 0.20833333333333
44660, 1.95, 1.62, 0.1875
44661, 1.95, 1.64, 0.20833333333333
44662, 1.9291666666667, 1.66, 0.20833333333333
44663, 1.95, 1.66, 0.1875
44664, 1.95, 1.68, 0.20833333333333
44665, 1.9916666666667, 1.52, 0.20833333333333
44666, 1.9708333333333, 1.54, 0.20833333333333
44667, 1.9916666666667, 1.54, 0.1875
44668, 1.9916666666667, 1.56, 0.20833333333333
44669, 1.9708333333333, 1.58, 0.20833333333333
44670, 1.9916666666667, 1.58, 0.1875
44671, 1.9916666666667, 1.6, 0.20833333333333
44672, 1.9708333333333, 1.62, 0.20833333333333
44673, 1.9916666666667, 1.62, 0.1875
44674, 1.9916666666667, 1.64, 0.20833333333333
44675, 1.9708333333333, 1.66, 0.20833333333333
44676, 1.9916666666667, 1.66, 0.1875
44677, 1.9916666666667, 1.68, 0.20833333333333
44678, 2.0333333333333, 1.52, 0.20833333333333
44679, 2.0125, 1.54, 0.20833333333333
44680, 2.0333333333333, 1.54, 0.1875
44681, 2.0333333333333, 1.56, 0.20833333333333
44682, 2.0125, 1.58, 0.20833333333333
44683, 2.0333333333333, 1.58, 0.1875
44684, 2.0333333333333, 1.6, 0.20833333333333
44685, 2.0125, 1.62, 0.20833333333333
44686, 2.0333333333333, 1.62, 0.1875
44687, 2.0333333333333, 1.64, 0.20833333333333
44688, 2.0125, 1.66, 0.20833333333333
44689, 2.0333333333333, 1.66, 0.1875
44690, 2.0333333333333, 1.68, 0.20833333333333
44691, 2.075, 1.52, 0.20833333333333
44692, 2.0541666666667, 1.54, 0.20833333333333
44693, 2.075, 1.54, 0.1875
44694, 2.075, 1.56, 0.20833333333333
44695, 2.0541666666667, 1.58, 0.20833333333333
44696, 2.075, 1.58, 0.1875
44697, 2.075, 1.6, 0.20833333333333
44698, 2.0541666666667, 1.62, 0.20833333333333
44699, 2.075, 1.62, 0.1875
44700, 2.075, 1.64, 0.20833333333333
44701, 2.0541666666667, 1.66, 0.20833333333333
44702, 2.075, 1.66, 0.1875
44703, 2.075, 1.68, 0.20833333333333
44704, 2.1166666666667, 1.52, 0.20833333333333
44705, 2.0958333333333, 1.54, 0.20833333333333
44706, 2.1166666666667, 1.54, 0.1875
44707, 2.1166666666667, 1.56, 0.20833333333333
44708, 2.0958333333333, 1.58, 0.20833333333333
44709, 2.1166666666667, 1.58, 0.1875
44710, 2.1166666666667, 1.6, 0.20833333333333
44711, 2.0958333333333, 1.62, 0.20833333333333
44712, 2.1166666666667, 1.62, 0.1875
44713, 2.1166666666667, 1.64, 0.20833333333333
44714, 2.0958333333333, 1.66, 0.20833333333333
44715, 2.1166666666667, 1.66, 0.1875
44716, 2.1166666666667, 1.68, 0.20833333333333
44717, 2.1583333333333, 1.52, 0.20833333333333
44718, 2.1375, 1.54, 0.20833333333333
44719, 2.1583333333333, 1.54, 0.1875
44720, 2.1583333333333, 1.56, 0.20833333333333
44721, 2.1375, 1.58, 0.20833333333333
44722, 2.1583333333333, 1.58, 0.1875
44723, 2.1583333333333, 1.6, 0.20833333333333
44724, 2.1375, 1.62, 0.20833333333333
44725, 2.1583333333333, 1.62, 0.1875
44726, 2.1583333333333, 1.64, 0.20833333333333
44727, 2.1375, 1.66, 0.20833333333333
44728, 2.1583333333333, 1.66, 0.1875
44729, 2.1583333333333, 1.68, 0.20833333333333
44730, 2.1791666666667, 1.54, 0.20833333333333
44731, 2.1791666666667, 1.58, 0.20833333333333
44732, 2.1791666666667, 1.62, 0.20833333333333
44733, 2.1791666666667, 1.66, 0.20833333333333
44734, 1.2416666666667, 1.52, 0.25
44735, 1.2208333333333, 1.54, 0.25
44736, 1.2416666666667, 1.54, 0.22916666666667
44737, 1.2416666666667, 1.56, 0.25
44738, 1.2208333333333, 1.58, 0.25
44739, 1.2416666666667, 1.58, 0.22916666666667
44740, 1.2416666666667, 1.6, 0.25
44741, 1.2208333333333, 1.62, 0.25
44742, 1.2416666666667, 1.62, 0.22916666666667
44743, 1.2416666666667, 1.64, 0.25
44744, 1.2208333333333, 1.66, 0.25
44745, 1.2416666666667, 1.66, 0.22916666666667
44746, 1.2416666666667, 1.68, 0.25
44747, 1.2833333333333, 1.52, 0.25
44748, 1.2625, 1.54, 0.25
44749, 1.2833333333333, 1.54, 0.22916666666667
44750, 1.2833333333333, 1.56, 0.25
44751, 1.2625, 1.58, 0.25
44752, 1.2833333333333, 1.58, 0.22916666666667
44753, 1.2833333333333, 1.6, 0.25
44754, 1.2625, 1.62, 0.25
44755, 1.2833333333333, 1.62, 0.22916666666667
44756, 1.2833333333333, 1.64, 0.25
44757, 1.2625, 1.66, 0.25
44758, 1.2833333333333, 1.66, 0.22916666666667
44759, 1.2833333333333, 1.68, 0.25
44760, 1.325, 1.52, 0.25
44761, 1.3041666666667, 1.54, 0.25
44762, 1.325, 1.54, 0.22916666666667
44763, 1.325, 1.56, 0.25
44764, 1.3041666666667, 1.58, 0.25
44765, 1.325, 1.58, 0.22916666666667
44766, 1.325, 1.6, 0.25
44767, 1.3041666666667, 1.62, 0.25
44768, 1.325, 1.62, 0.22916666666667
44769, 1.325, 1.64, 0.25
44770, 1.3041666666667, 1.66, 0.25
44771, 1.325, 1.66, 0.22916666666667
44772, 1.325, 1.68, 0.25
44773, 1.3666666666667, 1.52, 0.25
44774, 1.3458333333333, 1.54, 0.25
44775, 1.3666666666667, 1.54, 0.22916666666667
44776, 1.3666666666667, 1.56, 0.25
44777, 1.3458333333333, 1.58, 0.25
44778, 1.3666666666667, 1.58, 0.22916666666667
44779, 1.3666666666667, 1.6, 0.25
44780, 1.3458333333333, 1.62, 0.25
44781, 1.3666666666667, 1.62, 0.22916666666667
44782, 1.3666666666667, 1.64, 0.25
44783, 1.3458333333333, 1.66, 0.25
44784, 1.3666666666667, 1.66, 0.22916666666667
44785, 1.3666666666667, 1.68, 0.25
44786, 1.4083333333333, 1.52, 0.25
44787, 1.3875, 1.54, 0.25
44788, 1.4083333333333, 1.54, 0.22916666666667
44789, 1.4083333333333, 1.56, 0.25
44790, 1.3875, 1.58, 0.25
44791, 1.4083333333333, 1.58, 0.22916666666667
44792, 1.4083333333333, 1.6, 0.25
44793, 1.3875, 1.62, 0.25
44794, 1.4083333333333, 1.62, 0.22916666666667
44795, 1.4083333333333, 1.64, 0.25
44796, 1.3875, 1.66, 0.25
44797, 1.4083333333333, 1.66, 0.22916666666667
44798, 1.4083333333333, 1.68, 0.25
44799, 1.45, 1.52, 0.25
44800, 1.4291666666667, 1.54, 0.25
44801, 1.45, 1.54, 0.22916666666667
44802, 1.45, 1.56, 0.25
44803, 1.4291666666667, 1.58, 0.25
44804, 1.45, 1.58, 0.22916666666667
44805, 1.45, 1.6, 0.25
44806, 1.4291666666667, 1.62, 0.25
44807, 1.45, 1.62, 0.22916666666667
44808, 1.45, 1.64, 0.25
44809, 1.4291666666667, 1.66, 0.25
44810, 1.45, 1.66, 0.22916666666667
44811, 1.45, 1.68, 0.25
44812, 1.4916666666667, 1.52, 0.25
44813, 1.4708333333333, 1.54, 0.25
44814, 1.4916666666667, 1.54, 0.22916666666667
44815, 1.4916666666667, 1.56, 0.25
44816, 1.4708333333333, 1.58, 0.25
44817, 1.4916666666667, 1.58, 0.22916666666667
44818, 1.4916666666667, 1.6, 0.25
44819, 1.4708333333333, 1.62, 0.25
44820, 1.4916666666667, 1.62, 0.22916666666667
44821, 1.4916666666667, 1.64, 0.25
44822, 1.4708333333333, 1.66, 0.25
44823, 1.4916666666667, 1.66, 0.22916666666667
44824, 1.4916666666667, 1.68, 0.25
44825, 1.5333333333333, 1.52, 0.25
44826, 1.5125, 1.54, 0.25
44827, 1.5333333333333, 1.54, 0.22916666666667
44828, 1.5333333333333, 1.56, 0.25
44829, 1.5125, 1.58, 0.25
44830, 1.5333333333333, 1.58, 0.22916666666667
44831, 1.5333333333333, 1.6, 0.25
44832, 1.5125, 1.62, 0.25
44833, 1.5333333333333, 1.62, 0.22916666666667
44834, 1.5333333333333, 1.64, 0.25
44835, 1.5125, 1.66, 0.25
44836, 1.5333333333333, 1.66, 0.22916666666667
44837, 1.5333333333333, 1.68, 0.25
44838, 1.575, 1.52, 0.25
44839, 1.5541666666667, 1.54, 0.25
44840, 1.575, 1.54, 0.22916666666667
44841, 1.575, 1.56, 0.25
44842, 1.5541666666667, 1.58, 0.25
44843, 1.575, 1.58, 0.22916666666667
44844, 1.575, 1.6, 0.25
44845, 1.5541666666667, 1.62, 0.25
44846, 1.575, 1.62, 0.22916666666667
44847, 1.575, 1.64, 0.25
44848, 1.5541666666667, 1.66, 0.25
44849, 1.575, 1.66, 0.22916666666667
44850, 1.575, 1.68, 0.25
44851, 1.6166666666667, 1.52, 0.25
44852, 1.5958333333333, 1.54, 0.25
44853, 1.6166666666667, 1.54, 0.22916666666667
44854, 1.6166666666667, 1.56, 0.25
44855, 1.5958333333333, 1.58, 0.25
44856, 1.6166666666667, 1.58, 0.22916666666667
44857, 1.6166666666667, 1.6, 0.25
44858, 1.5958333333333, 1.62, 0.25
44859, 1.6166666666667, 1.62, 0.22916666666667
44860, 1.6166666666667, 1.64, 0.25
44861, 1.5958333333333, 1.66, 0.25
44862, 1.6166666666667, 1.66, 0.22916666666667
44863, 1.6166666666667, 1.68, 0.25
44864, 1.6583333333333, 1.52, 0.25
44865, 1.6375, 1.54, 0.25
44866, 1.6583333333333, 1.54, 0.22916666666667
44867, 1.6583333333333, 1.56, 0.25
44868, 1.6375, 1.58, 0.25
44869, 1.6583333333333, 1.58, 0.22916666666667
44870, 1.6583333333333, 1.6, 0.25
44871, 1.6375, 1.62, 0.25
44872, 1.6583333333333, 1.62, 0.22916666666667
44873, 1.6583333333333, 1.64, 0.25
44874, 1.6375, 1.66, 0.25
44875, 1.6583333333333, 1.66, 0.22916666666667
44876, 1.6583333333333, 1.68, 0.25
44877, 1.7, 1.52, 0.25
44878, 1.6791666666667, 1.54, 0.25
44879, 1.7, 1.54, 0.22916666666667
44880, 1.7, 1.56, 0.25
44881, 1.6791666666667, 1.58, 0.25
44882, 1.7, 1.58, 0.22916666666667
44883, 1.7, 1.6, 0.25
44884, 1.6791666666667, 1.62, 0.25
44885, 1.7, 1.62, 0.22916666666667
44886, 1.7, 1.64, 0.25
44887, 1.6791666666667, 1.66, 0.25
44888, 1.7, 1.66, 0.22916666666667
44889, 1.7, 1.68, 0.25
44890, 1.7416666666667, 1.52, 0.25
44891, 1.7208333333333, 1.54, 0.25
44892, 1.7416666666667, 1.54, 0.22916666666667
44893, 1.7416666666667, 1.56, 0.25
44894, 1.7208333333333, 1.58, 0.25
44895, 1.7416666666667, 1.58, 0.22916666666667
44896, 1.7416666666667, 1.6, 0.25
44897, 1.7208333333333, 1.62, 0.25
44898, 1.7416666666667, 1.62, 0.22916666666667
44899, 1.7416666666667, 1.64, 0.25
44900, 1.7208333333333, 1.66, 0.25
44901, 1.7416666666667, 1.66, 0.22916666666667
44902, 1.7416666666667, 1.68, 0.25
44903, 1.7833333333333, 1.52, 0.25
44904, 1.7625, 1.54, 0.25
44905, 1.7833333333333, 1.54, 0.22916666666667
44906, 1.7833333333333, 1.56, 0.25
44907, 1.7625, 1.58, 0.25
44908, 1.7833333333333, 1.58, 0.22916666666667
44909, 1.7833333333333, 1.6, 0.25
44910, 1.7625, 1.62, 0.25
44911, 1.7833333333333, 1.62, 0.22916666666667
44912, 1.7833333333333, 1.64, 0.25
44913, 1.7625, 1.66, 0.25
44914, 1.7833333333333, 1.66, 0.22916666666667
44915, 1.7833333333333, 1.68, 0.25
44916, 1.825, 1.52, 0.25
44917, 1.8041666666667, 1.54, 0.25
44918, 1.825, 1.54, 0.22916666666667
44919, 1.825, 1.56, 0.25
44920, 1.8041666666667, 1.58, 0.25
44921, 1.825, 1.58, 0.22916666666667
44922, 1.825, 1.6, 0.25
44923, 1.8041666666667, 1.62, 0.25
44924, 1.825, 1.62, 0.22916666666667
44925, 1.825, 1.64, 0.25
44926, 1.8041666666667, 1.66, 0.25
44927, 1.825, 1.66, 0.22916666666667
44928, 1.825, 1.68, 0.25
44929, 1.8666666666667, 1.52, 0.25
44930, 1.8458333333333, 1.54, 0.25
44931, 1.8666666666667, 1.54, 0.22916666666667
44932, 1.8666666666667, 1.56, 0.25
44933, 1.8458333333333, 1.58, 0.25
44934, 1.8666666666667, 1.58, 0.22916666666667
44935, 1.8666666666667, 1.6, 0.25
44936, 1.8458333333333, 1.62, 0.25
44937, 1.8666666666667, 1.62, 0.22916666666667
44938, 1.8666666666667, 1.64, 0.25
44939, 1.8458333333333, 1.66, 0.25
44940, 1.8666666666667, 1.66, 0.22916666666667
44941, 1.8666666666667, 1.68, 0.25
44942, 1.9083333333333, 1.52, 0.25
44943, 1.8875, 1.54, 0.25
44944, 1.9083333333333, 1.54, 0.22916666666667
44945, 1.9083333333333, 1.56, 0.25
44946, 1.8875, 1.58, 0.25
44947, 1.9083333333333, 1.58, 0.22916666666667
44948, 1.9083333333333, 1.6, 0.25
44949, 1.8875, 1.62, 0.25
44950, 1.9083333333333, 1.62, 0.22916666666667
44951, 1.9083333333333, 1.64, 0.25
44952, 1.8875, 1.66, 0.25
44953, 1.9083333333333, 1.66, 0.22916666666667
44954, 1.9083333333333, 1.68, 0.25
44955, 1.95, 1.52, 0.25
44956, 1.9291666666667, 1.54, 0.25
44957, 1.95, 1.54, 0.22916666666667
44958, 1.95, 1.56, 0.25
44959, 1.9291666666667, 1.58, 0.25
44960, 1.95, 1.58, 0.22916666666667
44961, 1.95, 1.6, 0.25
44962, 1.9291666666667, 1.62, 0.25
44963, 1.95, 1.62, 0.22916666666667
44964, 1.95, 1.64, 0.25
44965, 1.9291666666667, 1.66, 0.25
44966, 1.95, 1.66, 0.22916666666667
44967, 1.95, 1.68, 0.25
44968, 1.9916666666667, 1.52, 0.25
44969, 1.9708333333333, 1.54, 0.25
44970, 1.9916666666667, 1.54, 0.22916666666667
44971, 1.9916666666667, 1.56, 0.25
44972, 1.9708333333333, 1.58, 0.25
44973, 1.9916666666667, 1.58, 0.22916666666667
44974, 1.9916666666667, 1.6, 0.25
44975, 1.9708333333333, 1.62, 0.25
44976, 1.9916666666667, 1.62, 0.22916666666667
44977, 1.9916666666667, 1.64, 0.25
44978, 1.9708333333333, 1.66, 0.25
44979, 1.9916666666667, 1.66, 0.22916666666667
44980, 1.9916666666667, 1.68, 0.25
44981, 2.0333333333333, 1.52, 0.25
44982, 2.0125, 1.54, 0.25
44983, 2.0333333333333, 1.54, 0.22916666666667
44984, 2.0333333333333, 1.56, 0.25
44985, 2.0125, 1.58, 0.25
44986, 2.0333333333333, 1.58, 0.22916666666667
44987, 2.0333333333333, 1.6, 0.25
44988, 2.0125, 1.62, 0.25
44989, 2.0333333333333, 1.62, 0.22916666666667
44990, 2.0333333333333, 1.64, 0.25
44991, 2.0125, 1.66, 0.25
44992, 2.0333333333333, 1.66, 0.22916666666667
44993, 2.0333333333333, 1.68, 0.25
44994, 2.075, 1.52, 0.25
44995, 2.0541666666667, 1.54, 0.25
44996, 2.075, 1.54, 0.22916666666667
44997, 2.075, 1.56, 0.25
44998, 2.0541666666667, 1.58, 0.25
44999, 2.075, 1.58, 0.22916666666667
45000, 2.075, 1.6, 0.25
45001, 2.0541666666667, 1.62, 0.25
45002, 2.075, 1.62, 0.22916666666667
45003, 2.075, 1.64, 0.25
45004, 2.0541666666667, 1.66, 0.25
45005, 2.075, 1.66, 0.22916666666667
45006, 2.075, 1.68, 0.25
45007, 2.1166666666667, 1.52, 0.25
45008, 2.0958333333333, 1.54, 0.25
45009, 2.1166666666667, 1.54, 0.22916666666667
45010, 2.1166666666667, 1.56, 0.25
45011, 2.0958333333333, 1.58, 0.25
45012, 2.1166666666667, 1.58, 0.22916666666667
45013, 2.1166666666667, 1.6, 0.25
45014, 2.0958333333333, 1.62, 0.25
45015, 2.1166666666667, 1.62, 0.22916666666667
45016, 2.1166666666667, 1.64, 0.25
45017, 2.0958333333333, 1.66, 0.25
45018, 2.1166666666667, 1.66, 0.22916666666667
45019, 2.1166666666667, 1.68, 0.25
45020, 2.1583333333333, 1.52, 0.25
45021, 2.1375, 1.54, 0.25
45022, 2.1583333333333, 1.54, 0.22916666666667
45023, 2.1583333333333, 1.56, 0.25
45024, 2.1375, 1.58, 0.25
45025, 2.1583333333333, 1.58, 0.22916666666667
45026, 2.1583333333333, 1.6, 0.25
45027, 2.1375, 1.62, 0.25
45028, 2.1583333333333, 1.62, 0.22916666666667
45029, 2.1583333333333, 1.64, 0.25
45030, 2.1375, 1.66, 0.25
45031, 2.1583333333333, 1.66, 0.22916666666667
45032, 2.1583333333333, 1.68, 0.25
45033, 2.1791666666667, 1.54, 0.25
45034, 2.1791666666667, 1.58, 0.25
45035, 2.1791666666667, 1.62, 0.25
45036, 2.1791666666667, 1.66, 0.25
45037, 1.2416666666667, 1.52, 0.29166666666667
45038, 1.2208333333333, 1.54, 0.29166666666667
45039, 1.2416666666667, 1.54, 0.27083333333333
45040, 1.2416666666667, 1.56, 0.29166666666667
45041, 1.2208333333333, 1.58, 0.29166666666667
45042, 1.2416666666667, 1.58, 0.27083333333333
45043, 1.2416666666667, 1.6, 0.29166666666667
45044, 1.2208333333333, 1.62, 0.29166666666667
45045, 1.2416666666667, 1.62, 0.27083333333333
45046, 1.2416666666667, 1.64, 0.29166666666667
45047, 1.2208333333333, 1.66, 0.29166666666667
45048, 1.2416666666667, 1.66, 0.27083333333333
45049, 1.2416666666667, 1.68, 0.29166666666667
45050, 1.2833333333333, 1.52, 0.29166666666667
45051, 1.2625, 1.54, 0.29166666666667
45052, 1.2833333333333, 1.54, 0.27083333333333
45053, 1.2833333333333, 1.56, 0.29166666666667
45054, 1.2625, 1.58, 0.29166666666667
45055, 1.2833333333333, 1.58, 0.27083333333333
45056, 1.2833333333333, 1.6, 0.29166666666667
45057, 1.2625, 1.62, 0.29166666666667
45058, 1.2833333333333, 1.62, 0.27083333333333
45059, 1.2833333333333, 1.64, 0.29166666666667
45060, 1.2625, 1.66, 0.29166666666667
45061, 1.2833333333333, 1.66, 0.27083333333333
45062, 1.2833333333333, 1.68, 0.29166666666667
45063, 1.325, 1.52, 0.29166666666667
45064, 1.3041666666667, 1.54, 0.29166666666667
45065, 1.325, 1.54, 0.27083333333333
45066, 1.325, 1.56, 0.29166666666667
45067, 1.3041666666667, 1.58, 0.29166666666667
45068, 1.325, 1.58, 0.27083333333333
45069, 1.325, 1.6, 0.29166666666667
45070, 1.3041666666667, 1.62, 0.29166666666667
45071, 1.325, 1.62, 0.27083333333333
45072, 1.325, 1.64, 0.29166666666667
45073, 1.3041666666667, 1.66, 0.29166666666667
45074, 1.325, 1.66, 0.27083333333333
45075, 1.325, 1.68, 0.29166666666667
45076, 1.3666666666667, 1.52, 0.29166666666667
45077, 1.3458333333333, 1.54, 0.29166666666667
45078, 1.3666666666667, 1.54, 0.27083333333333
45079, 1.3666666666667, 1.56, 0.29166666666667
45080, 1.3458333333333, 1.58, 0.29166666666667
45081, 1.3666666666667, 1.58, 0.27083333333333
45082, 1.3666666666667, 1.6, 0.29166666666667
45083, 1.3458333333333, 1.62, 0.29166666666667
45084, 1.3666666666667, 1.62, 0.27083333333333
45085, 1.3666666666667, 1.64, 0.29166666666667
45086, 1.3458333333333, 1.66, 0.29166666666667
45087, 1.3666666666667, 1.66, 0.27083333333333
45088, 1.3666666666667, 1.68, 0.29166666666667
45089, 1.4083333333333, 1.52, 0.29166666666667
45090, 1.3875, 1.54, 0.29166666666667
45091, 1.4083333333333, 1.54, 0.27083333333333
45092, 1.4083333333333, 1.56, 0.29166666666667
45093, 1.3875, 1.58, 0.29166666666667
45094, 1.4083333333333, 1.58, 0.27083333333333
45095, 1.4083333333333, 1.6, 0.29166666666667
45096, 1.3875, 1.62, 0.29166666666667
45097, 1.4083333333333, 1.62, 0.27083333333333
45098, 1.4083333333333, 1.64, 0.29166666666667
45099, 1.3875, 1.66, 0.29166666666667
45100, 1.4083333333333, 1.66, 0.27083333333333
45101, 1.4083333333333, 1.68, 0.29166666666667
45102, 1.45, 1.52, 0.29166666666667
45103, 1.4291666666667, 1.54, 0.29166666666667
45104, 1.45, 1.54, 0.27083333333333
45105, 1.45, 1.56, 0.29166666666667
45106, 1.4291666666667, 1.58, 0.29166666666667
45107, 1.45, 1.58, 0.27083333333333
45108, 1.45, 1.6, 0.29166666666667
45109, 1.4291666666667, 1.62, 0.29166666666667
45110, 1.45, 1.62, 0.27083333333333
45111, 1.45, 1.64, 0.29166666666667
45112, 1.4291666666667, 1.66, 0.29166666666667
45113, 1.45, 1.66, 0.27083333333333
45114, 1.45, 1.68, 0.29166666666667
45115, 1.4916666666667, 1.52, 0.29166666666667
45116, 1.4708333333333, 1.54, 0.29166666666667
45117, 1.4916666666667, 1.54, 0.27083333333333
45118, 1.4916666666667, 1.56, 0.29166666666667
45119, 1.4708333333333, 1.58, 0.29166666666667
45120, 1.4916666666667, 1.58, 0.27083333333333
45121, 1.4916666666667, 1.6, 0.29166666666667
45122, 1.4708333333333, 1.62, 0.29166666666667
45123, 1.4916666666667, 1.62, 0.27083333333333
45124, 1.4916666666667, 1.64, 0.29166666666667
45125, 1.4708333333333, 1.66, 0.29166666666667
45126, 1.4916666666667, 1.66, 0.27083333333333
45127, 1.4916666666667, 1.68, 0.29166666666667
45128, 1.5333333333333, 1.52, 0.29166666666667
45129, 1.5125, 1.54, 0.29166666666667
45130, 1.5333333333333, 1.54, 0.27083333333333
45131, 1.5333333333333, 1.56, 0.29166666666667
45132, 1.5125, 1.58, 0.29166666666667
45133, 1.5333333333333, 1.58, 0.27083333333333
45134, 1.5333333333333, 1.6, 0.29166666666667
45135, 1.5125, 1.62, 0.29166666666667
45136, 1.5333333333333, 1.62, 0.27083333333333
45137, 1.5333333333333, 1.64, 0.29166666666667
45138, 1.5125, 1.66, 0.29166666666667
45139, 1.5333333333333, 1.66, 0.27083333333333
45140, 1.5333333333333, 1.68, 0.29166666666667
45141, 1.575, 1.52, 0.29166666666667
45142, 1.5541666666667, 1.54, 0.29166666666667
45143, 1.575, 1.54, 0.27083333333333
45144, 1.575, 1.56, 0.29166666666667
45145, 1.5541666666667, 1.58, 0.29166666666667
45146, 1.575, 1.58, 0.27083333333333
45147, 1.575, 1.6, 0.29166666666667
45148, 1.5541666666667, 1.62, 0.29166666666667
45149, 1.575, 1.62, 0.27083333333333
45150, 1.575, 1.64, 0.29166666666667
45151, 1.5541666666667, 1.66, 0.29166666666667
45152, 1.575, 1.66, 0.27083333333333
45153, 1.575, 1.68, 0.29166666666667
45154, 1.6166666666667, 1.52, 0.29166666666667
45155, 1.5958333333333, 1.54, 0.29166666666667
45156, 1.6166666666667, 1.54, 0.27083333333333
45157, 1.6166666666667, 1.56, 0.29166666666667
45158, 1.5958333333333, 1.58, 0.29166666666667
45159, 1.6166666666667, 1.58, 0.27083333333333
45160, 1.6166666666667, 1.6, 0.29166666666667
45161, 1.5958333333333, 1.62, 0.29166666666667
45162, 1.6166666666667, 1.62, 0.27083333333333
45163, 1.6166666666667, 1.64, 0.29166666666667
45164, 1.5958333333333, 1.66, 0.29166666666667
45165, 1.6166666666667, 1.66, 0.27083333333333
45166, 1.6166666666667, 1.68, 0.29166666666667
45167, 1.6583333333333, 1.52, 0.29166666666667
45168, 1.6375, 1.54, 0.29166666666667
45169, 1.6583333333333, 1.54, 0.27083333333333
45170, 1.6583333333333, 1.56, 0.29166666666667
45171, 1.6375, 1.58, 0.29166666666667
45172, 1.6583333333333, 1.58, 0.27083333333333
45173, 1.6583333333333, 1.6, 0.29166666666667
45174, 1.6375, 1.62, 0.29166666666667
45175, 1.6583333333333, 1.62, 0.27083333333333
45176, 1.6583333333333, 1.64, 0.29166666666667
45177, 1.6375, 1.66, 0.29166666666667
45178, 1.6583333333333, 1.66, 0.27083333333333
45179, 1.6583333333333, 1.68, 0.29166666666667
45180, 1.7, 1.52, 0.29166666666667
45181, 1.6791666666667, 1.54, 0.29166666666667
45182, 1.7, 1.54, 0.27083333333333
45183, 1.7, 1.56, 0.29166666666667
45184, 1.6791666666667, 1.58, 0.29166666666667
45185, 1.7, 1.58, 0.27083333333333
45186, 1.7, 1.6, 0.29166666666667
45187, 1.6791666666667, 1.62, 0.29166666666667
45188, 1.7, 1.62, 0.27083333333333
45189, 1.7, 1.64, 0.29166666666667
45190, 1.6791666666667, 1.66, 0.29166666666667
45191, 1.7, 1.66, 0.27083333333333
45192, 1.7, 1.68, 0.29166666666667
45193, 1.7416666666667, 1.52, 0.29166666666667
45194, 1.7208333333333, 1.54, 0.29166666666667
45195, 1.7416666666667, 1.54, 0.27083333333333
45196, 1.7416666666667, 1.56, 0.29166666666667
45197, 1.7208333333333, 1.58, 0.29166666666667
45198, 1.7416666666667, 1.58, 0.27083333333333
45199, 1.7416666666667, 1.6, 0.29166666666667
45200, 1.7208333333333, 1.62, 0.29166666666667
45201, 1.7416666666667, 1.62, 0.27083333333333
45202, 1.7416666666667, 1.64, 0.29166666666667
45203, 1.7208333333333, 1.66, 0.29166666666667
45204, 1.7416666666667, 1.66, 0.27083333333333
45205, 1.7416666666667, 1.68, 0.29166666666667
45206, 1.7833333333333, 1.52, 0.29166666666667
45207, 1.7625, 1.54, 0.29166666666667
45208, 1.7833333333333, 1.54, 0.27083333333333
45209, 1.7833333333333, 1.56, 0.29166666666667
45210, 1.7625, 1.58, 0.29166666666667
45211, 1.7833333333333, 1.58, 0.27083333333333
45212, 1.7833333333333, 1.6, 0.29166666666667
45213, 1.7625, 1.62, 0.29166666666667
45214, 1.7833333333333, 1.62, 0.27083333333333
45215, 1.7833333333333, 1.64, 0.29166666666667
45216, 1.7625, 1.66, 0.29166666666667
45217, 1.7833333333333, 1.66, 0.27083333333333
45218, 1.7833333333333, 1.68, 0.29166666666667
45219, 1.825, 1.52, 0.29166666666667
45220, 1.8041666666667, 1.54, 0.29166666666667
45221, 1.825, 1.54, 0.27083333333333
45222, 1.825, 1.56, 0.29166666666667
45223, 1.8041666666667, 1.58, 0.29166666666667
45224, 1.825, 1.58, 0.27083333333333
45225, 1.825, 1.6, 0.29166666666667
45226, 1.8041666666667, 1.62, 0.29166666666667
45227, 1.825, 1.62, 0.27083333333333
45228, 1.825, 1.64, 0.29166666666667
45229, 1.8041666666667, 1.66, 0.29166666666667
45230, 1.825, 1.66, 0.27083333333333
45231, 1.825, 1.68, 0.29166666666667
45232, 1.8666666666667, 1.52, 0.29166666666667
45233, 1.8458333333333, 1.54, 0.29166666666667
45234, 1.8666666666667, 1.54, 0.27083333333333
45235, 1.8666666666667, 1.56, 0.29166666666667
45236, 1.8458333333333, 1.58, 0.29166666666667
45237, 1.8666666666667, 1.58, 0.27083333333333
45238, 1.8666666666667, 1.6, 0.29166666666667
45239, 1.8458333333333, 1.62, 0.29166666666667
45240, 1.8666666666667, 1.62, 0.27083333333333
45241, 1.8666666666667, 1.64, 0.29166666666667
45242, 1.8458333333333, 1.66, 0.29166666666667
45243, 1.8666666666667, 1.66, 0.27083333333333
45244, 1.8666666666667, 1.68, 0.29166666666667
45245, 1.9083333333333, 1.52, 0.29166666666667
45246, 1.8875, 1.54, 0.29166666666667
45247, 1.9083333333333, 1.54, 0.27083333333333
45248, 1.9083333333333, 1.56, 0.29166666666667
45249, 1.8875, 1.58, 0.29166666666667
45250, 1.9083333333333, 1.58, 0.27083333333333
45251, 1.9083333333333, 1.6, 0.29166666666667
45252, 1.8875, 1.62, 0.29166666666667
45253, 1.9083333333333, 1.62, 0.27083333333333
45254, 1.9083333333333, 1.64, 0.29166666666667
45255, 1.8875, 1.66, 0.29166666666667
45256, 1.9083333333333, 1.66, 0.27083333333333
45257, 1.9083333333333, 1.68, 0.29166666666667
45258, 1.95, 1.52, 0.29166666666667
45259, 1.9291666666667, 1.54, 0.29166666666667
45260, 1.95, 1.54, 0.27083333333333
45261, 1.95, 1.56, 0.29166666666667
45262, 1.9291666666667, 1.58, 0.29166666666667
45263, 1.95, 1.58, 0.27083333333333
45264, 1.95, 1.6, 0.29166666666667
45265, 1.9291666666667, 1.62, 0.29166666666667
45266, 1.95, 1.62, 0.27083333333333
45267, 1.95, 1.64, 0.29166666666667
45268, 1.9291666666667, 1.66, 0.29166666666667
45269, 1.95, 1.66, 0.27083333333333
45270, 1.95, 1.68, 0.29166666666667
45271, 1.9916666666667, 1.52, 0.29166666666667
45272, 1.9708333333333, 1.54, 0.29166666666667
45273, 1.9916666666667, 1.54, 0.27083333333333
45274, 1.9916666666667, 1.56, 0.29166666666667
45275, 1.9708333333333, 1.58, 0.29166666666667
45276, 1.9916666666667, 1.58, 0.27083333333333
45277, 1.9916666666667, 1.6, 0.29166666666667
45278, 1.9708333333333, 1.62, 0.29166666666667
45279, 1.9916666666667, 1.62, 0.27083333333333
45280, 1.9916666666667, 1.64, 0.29166666666667
45281, 1.9708333333333, 1.66, 0.29166666666667
45282, 1.9916666666667, 1.66, 0.27083333333333
45283, 1.9916666666667, 1.68, 0.29166666666667
45284, 2.0333333333333, 1.52, 0.29166666666667
45285, 2.0125, 1.54, 0.29166666666667
45286, 2.0333333333333, 1.54, 0.27083333333333
45287, 2.0333333333333, 1.56, 0.29166666666667
45288, 2.0125, 1.58, 0.29166666666667
45289, 2.0333333333333, 1.58, 0.27083333333333
45290, 2.0333333333333, 1.6, 0.29166666666667
45291, 2.0125, 1.62, 0.29166666666667
45292, 2.0333333333333, 1.62, 0.27083333333333
45293, 2.0333333333333, 1.64, 0.29166666666667
45294, 2.0125, 1.66, 0.29166666666667
45295, 2.0333333333333, 1.66, 0.27083333333333
45296, 2.0333333333333, 1.68, 0.29166666666667
45297, 2.075, 1.52, 0.29166666666667
45298, 2.0541666666667, 1.54, 0.29166666666667
45299, 2.075, 1.54, 0.27083333333333
45300, 2.075, 1.56, 0.29166666666667
45301, 2.0541666666667, 1.58, 0.29166666666667
45302, 2.075, 1.58, 0.27083333333333
45303, 2.075, 1.6, 0.29166666666667
45304, 2.0541666666667, 1.62, 0.29166666666667
45305, 2.075, 1.62, 0.27083333333333
45306, 2.075, 1.64, 0.29166666666667
45307, 2.0541666666667, 1.66, 0.29166666666667
45308, 2.075, 1.66, 0.27083333333333
45309, 2.075, 1.68, 0.29166666666667
45310, 2.1166666666667, 1.52, 0.29166666666667
45311, 2.0958333333333, 1.54, 0.29166666666667
45312, 2.1166666666667, 1.54, 0.27083333333333
45313, 2.1166666666667, 1.56, 0.29166666666667
45314, 2.0958333333333, 1.58, 0.29166666666667
45315, 2.1166666666667, 1.58, 0.27083333333333
45316, 2.1166666666667, 1.6, 0.29166666666667
45317, 2.0958333333333, 1.62, 0.29166666666667
45318, 2.1166666666667, 1.62, 0.27083333333333
45319, 2.1166666666667, 1.64, 0.29166666666667
45320, 2.0958333333333, 1.66, 0.29166666666667
45321, 2.1166666666667, 1.66, 0.27083333333333
45322, 2.1166666666667, 1.68, 0.29166666666667
45323, 2.1583333333333, 1.52, 0.29166666666667
45324, 2.1375, 1.54, 0.29166666666667
45325, 2.1583333333333, 1.54, 0.27083333333333
45326, 2.1583333333333, 1.56, 0.29166666666667
45327, 2.1375, 1.58, 0.29166666666667
45328, 2.1583333333333, 1.58, 0.27083333333333
45329, 2.1583333333333, 1.6, 0.29166666666667
45330, 2.1375, 1.62, 0.29166666666667
45331, 2.1583333333333, 1.62, 0.27083333333333
45332, 2.1583333333333, 1.64, 0.29166666666667
45333, 2.1375, 1.66, 0.29166666666667
45334, 2.1583333333333, 1.66, 0.27083333333333
45335, 2.1583333333333, 1.68, 0.29166666666667
45336, 2.1791666666667, 1.54, 0.29166666666667
45337, 2.1791666666667, 1.58, 0.29166666666667
45338, 2.1791666666667, 1.62, 0.29166666666667
45339, 2.1791666666667, 1.66, 0.29166666666667
45340, 1.2416666666667, 1.52, 0.33333333333333
45341, 1.2208333333333, 1.54, 0.33333333333333
45342, 1.2416666666667, 1.54, 0.3125
45343, 1.2416666666667, 1.56, 0.33333333333333
45344, 1.2208333333333, 1.58, 0.33333333333333
45345, 1.2416666666667, 1.58, 0.3125
45346, 1.2416666666667, 1.6, 0.33333333333333
45347, 1.2208333333333, 1.62, 0.33333333333333
45348, 1.2416666666667, 1.62, 0.3125
45349, 1.2416666666667, 1.64, 0.33333333333333
45350, 1.2208333333333, 1.66, 0.33333333333333
45351, 1.2416666666667, 1.66, 0.3125
45352, 1.2416666666667, 1.68, 0.33333333333333
45353, 1.2833333333333, 1.52, 0.33333333333333
45354, 1.2625, 1.54, 0.33333333333333
45355, 1.2833333333333, 1.54, 0.3125
45356, 1.2833333333333, 1.56, 0.33333333333333
45357, 1.2625, 1.58, 0.33333333333333
45358, 1.2833333333333, 1.58, 0.3125
45359, 1.2833333333333, 1.6, 0.33333333333333
45360, 1.2625, 1.62, 0.33333333333333
45361, 1.2833333333333, 1.62, 0.3125
45362, 1.2833333333333, 1.64, 0.33333333333333
45363, 1.2625, 1.66, 0.33333333333333
45364, 1.2833333333333, 1.66, 0.3125
45365, 1.2833333333333, 1.68, 0.33333333333333
45366, 1.325, 1.52, 0.33333333333333
45367, 1.3041666666667, 1.54, 0.33333333333333
45368, 1.325, 1.54, 0.3125
45369, 1.325, 1.56, 0.33333333333333
45370, 1.3041666666667, 1.58, 0.33333333333333
45371, 1.325, 1.58, 0.3125
45372, 1.325, 1.6, 0.33333333333333
45373, 1.3041666666667, 1.62, 0.33333333333333
45374, 1.325, 1.62, 0.3125
45375, 1.325, 1.64, 0.33333333333333
45376, 1.3041666666667, 1.66, 0.33333333333333
45377, 1.325, 1.66, 0.3125
45378, 1.325, 1.68, 0.33333333333333
45379, 1.3666666666667, 1.52, 0.33333333333333
45380, 1.3458333333333, 1.54, 0.33333333333333
45381, 1.3666666666667, 1.54, 0.3125
45382, 1.3666666666667, 1.56, 0.33333333333333
45383, 1.3458333333333, 1.58, 0.33333333333333
45384, 1.3666666666667, 1.58, 0.3125
45385, 1.3666666666667, 1.6, 0.33333333333333
45386, 1.3458333333333, 1.62, 0.33333333333333
45387, 1.3666666666667, 1.62, 0.3125
45388, 1.3666666666667, 1.64, 0.33333333333333
45389, 1.3458333333333, 1.66, 0.33333333333333
45390, 1.3666666666667, 1.66, 0.3125
45391, 1.3666666666667, 1.68, 0.33333333333333
45392, 1.4083333333333, 1.52, 0.33333333333333
45393, 1.3875, 1.54, 0.33333333333333
45394, 1.4083333333333, 1.54, 0.3125
45395, 1.4083333333333, 1.56, 0.33333333333333
45396, 1.3875, 1.58, 0.33333333333333
45397, 1.4083333333333, 1.58, 0.3125
45398, 1.4083333333333, 1.6, 0.33333333333333
45399, 1.3875, 1.62, 0.33333333333333
45400, 1.4083333333333, 1.62, 0.3125
45401, 1.4083333333333, 1.64, 0.33333333333333
45402, 1.3875, 1.66, 0.33333333333333
45403, 1.4083333333333, 1.66, 0.3125
45404, 1.4083333333333, 1.68, 0.33333333333333
45405, 1.45, 1.52, 0.33333333333333
45406, 1.4291666666667, 1.54, 0.33333333333333
45407, 1.45, 1.54, 0.3125
45408, 1.45, 1.56, 0.33333333333333
45409, 1.4291666666667, 1.58, 0.33333333333333
45410, 1.45, 1.58, 0.3125
45411, 1.45, 1.6, 0.33333333333333
45412, 1.4291666666667, 1.62, 0.33333333333333
45413, 1.45, 1.62, 0.3125
45414, 1.45, 1.64, 0.33333333333333
45415, 1.4291666666667, 1.66, 0.33333333333333
45416, 1.45, 1.66, 0.3125
45417, 1.45, 1.68, 0.33333333333333
45418, 1.4916666666667, 1.52, 0.33333333333333
45419, 1.4708333333333, 1.54, 0.33333333333333
45420, 1.4916666666667, 1.54, 0.3125
45421, 1.4916666666667, 1.56, 0.33333333333333
45422, 1.4708333333333, 1.58, 0.33333333333333
45423, 1.4916666666667, 1.58, 0.3125
45424, 1.4916666666667, 1.6, 0.33333333333333
45425, 1.4708333333333, 1.62, 0.33333333333333
45426, 1.4916666666667, 1.62, 0.3125
45427, 1.4916666666667, 1.64, 0.33333333333333
45428, 1.4708333333333, 1.66, 0.33333333333333
45429, 1.4916666666667, 1.66, 0.3125
45430, 1.4916666666667, 1.68, 0.33333333333333
45431, 1.5333333333333, 1.52, 0.33333333333333
45432, 1.5125, 1.54, 0.33333333333333
45433, 1.5333333333333, 1.54, 0.3125
45434, 1.5333333333333, 1.56, 0.33333333333333
45435, 1.5125, 1.58, 0.33333333333333
45436, 1.5333333333333, 1.58, 0.3125
45437, 1.5333333333333, 1.6, 0.33333333333333
45438, 1.5125, 1.62, 0.33333333333333
45439, 1.5333333333333, 1.62, 0.3125
45440, 1.5333333333333, 1.64, 0.33333333333333
45441, 1.5125, 1.66, 0.33333333333333
45442, 1.5333333333333, 1.66, 0.3125
45443, 1.5333333333333, 1.68, 0.33333333333333
45444, 1.575, 1.52, 0.33333333333333
45445, 1.5541666666667, 1.54, 0.33333333333333
45446, 1.575, 1.54, 0.3125
45447, 1.575, 1.56, 0.33333333333333
45448, 1.5541666666667, 1.58, 0.33333333333333
45449, 1.575, 1.58, 0.3125
45450, 1.575, 1.6, 0.33333333333333
45451, 1.5541666666667, 1.62, 0.33333333333333
45452, 1.575, 1.62, 0.3125
45453, 1.575, 1.64, 0.33333333333333
45454, 1.5541666666667, 1.66, 0.33333333333333
45455, 1.575, 1.66, 0.3125
45456, 1.575, 1.68, 0.33333333333333
45457, 1.6166666666667, 1.52, 0.33333333333333
45458, 1.5958333333333, 1.54, 0.33333333333333
45459, 1.6166666666667, 1.54, 0.3125
45460, 1.6166666666667, 1.56, 0.33333333333333
45461, 1.5958333333333, 1.58, 0.33333333333333
45462, 1.6166666666667, 1.58, 0.3125
45463, 1.6166666666667, 1.6, 0.33333333333333
45464, 1.5958333333333, 1.62, 0.33333333333333
45465, 1.6166666666667, 1.62, 0.3125
45466, 1.6166666666667, 1.64, 0.33333333333333
45467, 1.5958333333333, 1.66, 0.33333333333333
45468, 1.6166666666667, 1.66, 0.3125
45469, 1.6166666666667, 1.68, 0.33333333333333
45470, 1.6583333333333, 1.52, 0.33333333333333
45471, 1.6375, 1.54, 0.33333333333333
45472, 1.6583333333333, 1.54, 0.3125
45473, 1.6583333333333, 1.56, 0.33333333333333
45474, 1.6375, 1.58, 0.33333333333333
45475, 1.6583333333333, 1.58, 0.3125
45476, 1.6583333333333, 1.6, 0.33333333333333
45477, 1.6375, 1.62, 0.33333333333333
45478, 1.6583333333333, 1.62, 0.3125
45479, 1.6583333333333, 1.64, 0.33333333333333
45480, 1.6375, 1.66, 0.33333333333333
45481, 1.6583333333333, 1.66, 0.3125
45482, 1.6583333333333, 1.68, 0.33333333333333
45483, 1.7, 1.52, 0.33333333333333
45484, 1.6791666666667, 1.54, 0.33333333333333
45485, 1.7, 1.54, 0.3125
45486, 1.7, 1.56, 0.33333333333333
45487, 1.6791666666667, 1.58, 0.33333333333333
45488, 1.7, 1.58, 0.3125
45489, 1.7, 1.6, 0.33333333333333
45490, 1.6791666666667, 1.62, 0.33333333333333
45491, 1.7, 1.62, 0.3125
45492, 1.7, 1.64, 0.33333333333333
45493, 1.6791666666667, 1.66, 0.33333333333333
45494, 1.7, 1.66, 0.3125
45495, 1.7, 1.68, 0.33333333333333
45496, 1.7416666666667, 1.52, 0.33333333333333
45497, 1.7208333333333, 1.54, 0.33333333333333
45498, 1.7416666666667, 1.54, 0.3125
45499, 1.7416666666667, 1.56, 0.33333333333333
45500, 1.7208333333333, 1.58, 0.33333333333333
45501, 1.7416666666667, 1.58, 0.3125
45502, 1.7416666666667, 1.6, 0.33333333333333
45503, 1.7208333333333, 1.62, 0.33333333333333
45504, 1.7416666666667, 1.62, 0.3125
45505, 1.7416666666667, 1.64, 0.33333333333333
45506, 1.7208333333333, 1.66, 0.33333333333333
45507, 1.7416666666667, 1.66, 0.3125
45508, 1.7416666666667, 1.68, 0.33333333333333
45509, 1.7833333333333, 1.52, 0.33333333333333
45510, 1.7625, 1.54, 0.33333333333333
45511, 1.7833333333333, 1.54, 0.3125
45512, 1.7833333333333, 1.56, 0.33333333333333
45513, 1.7625, 1.58, 0.33333333333333
45514, 1.7833333333333, 1.58, 0.3125
45515, 1.7833333333333, 1.6, 0.33333333333333
45516, 1.7625, 1.62, 0.33333333333333
45517, 1.7833333333333, 1.62, 0.3125
45518, 1.7833333333333, 1.64, 0.33333333333333
45519, 1.7625, 1.66, 0.33333333333333
45520, 1.7833333333333, 1.66, 0.3125
45521, 1.7833333333333, 1.68, 0.33333333333333
45522, 1.825, 1.52, 0.33333333333333
45523, 1.8041666666667, 1.54, 0.33333333333333
45524, 1.825, 1.54, 0.3125
45525, 1.825, 1.56, 0.33333333333333
45526, 1.8041666666667, 1.58, 0.33333333333333
45527, 1.825, 1.58, 0.3125
45528, 1.825, 1.6, 0.33333333333333
45529, 1.8041666666667, 1.62, 0.33333333333333
45530, 1.825, 1.62, 0.3125
45531, 1.825, 1.64, 0.33333333333333
45532, 1.8041666666667, 1.66, 0.33333333333333
45533, 1.825, 1.66, 0.3125
45534, 1.825, 1.68, 0.33333333333333
45535, 1.8666666666667, 1.52, 0.33333333333333
45536, 1.8458333333333, 1.54, 0.33333333333333
45537, 1.8666666666667, 1.54, 0.3125
45538, 1.8666666666667, 1.56, 0.33333333333333
45539, 1.8458333333333, 1.58, 0.33333333333333
45540, 1.8666666666667, 1.58, 0.3125
45541, 1.8666666666667, 1.6, 0.33333333333333
45542, 1.8458333333333, 1.62, 0.33333333333333
45543, 1.8666666666667, 1.62, 0.3125
45544, 1.8666666666667, 1.64, 0.33333333333333
45545, 1.8458333333333, 1.66, 0.33333333333333
45546, 1.8666666666667, 1.66, 0.3125
45547, 1.8666666666667, 1.68, 0.33333333333333
45548, 1.9083333333333, 1.52, 0.33333333333333
45549, 1.8875, 1.54, 0.33333333333333
45550, 1.9083333333333, 1.54, 0.3125
45551, 1.9083333333333, 1.56, 0.33333333333333
45552, 1.8875, 1.58, 0.33333333333333
45553, 1.9083333333333, 1.58, 0.3125
45554, 1.9083333333333, 1.6, 0.33333333333333
45555, 1.8875, 1.62, 0.33333333333333
45556, 1.9083333333333, 1.62, 0.3125
45557, 1.9083333333333, 1.64, 0.33333333333333
45558, 1.8875, 1.66, 0.33333333333333
45559, 1.9083333333333, 1.66, 0.3125
45560, 1.9083333333333, 1.68, 0.33333333333333
45561, 1.95, 1.52, 0.33333333333333
45562, 1.9291666666667, 1.54, 0.33333333333333
45563, 1.95, 1.54, 0.3125
45564, 1.95, 1.56, 0.33333333333333
45565, 1.9291666666667, 1.58, 0.33333333333333
45566, 1.95, 1.58, 0.3125
45567, 1.95, 1.6, 0.33333333333333
45568, 1.9291666666667, 1.62, 0.33333333333333
45569, 1.95, 1.62, 0.3125
45570, 1.95, 1.64, 0.33333333333333
45571, 1.9291666666667, 1.66, 0.33333333333333
45572, 1.95, 1.66, 0.3125
45573, 1.95, 1.68, 0.33333333333333
45574, 1.9916666666667, 1.52, 0.33333333333333
45575, 1.9708333333333, 1.54, 0.33333333333333
45576, 1.9916666666667, 1.54, 0.3125
45577, 1.9916666666667, 1.56, 0.33333333333333
45578, 1.9708333333333, 1.58, 0.33333333333333
45579, 1.9916666666667, 1.58, 0.3125
45580, 1.9916666666667, 1.6, 0.33333333333333
45581, 1.9708333333333, 1.62, 0.33333333333333
45582, 1.9916666666667, 1.62, 0.3125
45583, 1.9916666666667, 1.64, 0.33333333333333
45584, 1.9708333333333, 1.66, 0.33333333333333
45585, 1.9916666666667, 1.66, 0.3125
45586, 1.9916666666667, 1.68, 0.33333333333333
45587, 2.0333333333333, 1.52, 0.33333333333333
45588, 2.0125, 1.54, 0.33333333333333
45589, 2.0333333333333, 1.54, 0.3125
45590, 2.0333333333333, 1.56, 0.33333333333333
45591, 2.0125, 1.58, 0.33333333333333
45592, 2.0333333333333, 1.58, 0.3125
45593, 2.0333333333333, 1.6, 0.33333333333333
45594, 2.0125, 1.62, 0.33333333333333
45595, 2.0333333333333, 1.62, 0.3125
45596, 2.0333333333333, 1.64, 0.33333333333333
45597, 2.0125, 1.66, 0.33333333333333
45598, 2.0333333333333, 1.66, 0.3125
45599, 2.0333333333333, 1.68, 0.33333333333333
45600, 2.075, 1.52, 0.33333333333333
45601, 2.0541666666667, 1.54, 0.33333333333333
45602, 2.075, 1.54, 0.3125
45603, 2.075, 1.56, 0.33333333333333
45604, 2.0541666666667, 1.58, 0.33333333333333
45605, 2.075, 1.58, 0.3125
45606, 2.075, 1.6, 0.33333333333333
45607, 2.0541666666667, 1.62, 0.33333333333333
45608, 2.075, 1.62, 0.3125
45609, 2.075, 1.64, 0.33333333333333
45610, 2.0541666666667, 1.66, 0.33333333333333
45611, 2.075, 1.66, 0.3125
45612, 2.075, 1.68, 0.33333333333333
45613, 2.1166666666667, 1.52, 0.33333333333333
45614, 2.0958333333333, 1.54, 0.33333333333333
45615, 2.1166666666667, 1.54, 0.3125
45616, 2.1166666666667, 1.56, 0.33333333333333
45617, 2.0958333333333, 1.58, 0.33333333333333
45618, 2.1166666666667, 1.58, 0.3125
45619, 2.1166666666667, 1.6, 0.33333333333333
45620, 2.0958333333333, 1.62, 0.33333333333333
45621, 2.1166666666667, 1.62, 0.3125
45622, 2.1166666666667, 1.64, 0.33333333333333
45623, 2.0958333333333, 1.66, 0.33333333333333
45624, 2.1166666666667, 1.66, 0.3125
45625, 2.1166666666667, 1.68, 0.33333333333333
45626, 2.1583333333333, 1.52, 0.33333333333333
45627, 2.1375, 1.54, 0.33333333333333
45628, 2.1583333333333, 1.54, 0.3125
45629, 2.1583333333333, 1.56, 0.33333333333333
45630, 2.1375, 1.58, 0.33333333333333
45631, 2.1583333333333, 1.58, 0.3125
45632, 2.1583333333333, 1.6, 0.33333333333333
45633, 2.1375, 1.62, 0.33333333333333
45634, 2.1583333333333, 1.62, 0.3125
45635, 2.1583333333333, 1.64, 0.33333333333333
45636, 2.1375, 1.66, 0.33333333333333
45637, 2.1583333333333, 1.66, 0.3125
45638, 2.1583333333333, 1.68, 0.33333333333333
45639, 2.1791666666667, 1.54, 0.33333333333333
45640, 2.1791666666667, 1.58, 0.33333333333333
45641, 2.1791666666667, 1.62, 0.33333333333333
45642, 2.1791666666667, 1.66, 0.33333333333333
45643, 1.2416666666667, 1.52, 0.375
45644, 1.2208333333333, 1.54, 0.375
45645, 1.2416666666667, 1.54, 0.35416666666667
45646, 1.2416666666667, 1.56, 0.375
45647, 1.2208333333333, 1.58, 0.375
45648, 1.2416666666667, 1.58, 0.35416666666667
45649, 1.2416666666667, 1.6, 0.375
45650, 1.2208333333333, 1.62, 0.375
45651, 1.2416666666667, 1.62, 0.35416666666667
45652, 1.2416666666667, 1.64, 0.375
45653, 1.2208333333333, 1.66, 0.375
45654, 1.2416666666667, 1.66, 0.35416666666667
45655, 1.2416666666667, 1.68, 0.375
45656, 1.2833333333333, 1.52, 0.375
45657, 1.2625, 1.54, 0.375
45658, 1.2833333333333, 1.54, 0.35416666666667
45659, 1.2833333333333, 1.56, 0.375
45660, 1.2625, 1.58, 0.375
45661, 1.2833333333333, 1.58, 0.35416666666667
45662, 1.2833333333333, 1.6, 0.375
45663, 1.2625, 1.62, 0.375
45664, 1.2833333333333, 1.62, 0.35416666666667
45665, 1.2833333333333, 1.64, 0.375
45666, 1.2625, 1.66, 0.375
45667, 1.2833333333333, 1.66, 0.35416666666667
45668, 1.2833333333333, 1.68, 0.375
45669, 1.325, 1.52, 0.375
45670, 1.3041666666667, 1.54, 0.375
45671, 1.325, 1.54, 0.35416666666667
45672, 1.325, 1.56, 0.375
45673, 1.3041666666667, 1.58, 0.375
45674, 1.325, 1.58, 0.35416666666667
45675, 1.325, 1.6, 0.375
45676, 1.3041666666667, 1.62, 0.375
45677, 1.325, 1.62, 0.35416666666667
45678, 1.325, 1.64, 0.375
45679, 1.3041666666667, 1.66, 0.375
45680, 1.325, 1.66, 0.35416666666667
45681, 1.325, 1.68, 0.375
45682, 1.3666666666667, 1.52, 0.375
45683, 1.3458333333333, 1.54, 0.375
45684, 1.3666666666667, 1.54, 0.35416666666667
45685, 1.3666666666667, 1.56, 0.375
45686, 1.3458333333333, 1.58, 0.375
45687, 1.3666666666667, 1.58, 0.35416666666667
45688, 1.3666666666667, 1.6, 0.375
45689, 1.3458333333333, 1.62, 0.375
45690, 1.3666666666667, 1.62, 0.35416666666667
45691, 1.3666666666667, 1.64, 0.375
45692, 1.3458333333333, 1.66, 0.375
45693, 1.3666666666667, 1.66, 0.35416666666667
45694, 1.3666666666667, 1.68, 0.375
45695, 1.4083333333333, 1.52, 0.375
45696, 1.3875, 1.54, 0.375
45697, 1.4083333333333, 1.54, 0.35416666666667
45698, 1.4083333333333, 1.56, 0.375
45699, 1.3875, 1.58, 0.375
45700, 1.4083333333333, 1.58, 0.35416666666667
45701, 1.4083333333333, 1.6, 0.375
45702, 1.3875, 1.62, 0.375
45703, 1.4083333333333, 1.62, 0.35416666666667
45704, 1.4083333333333, 1.64, 0.375
45705, 1.3875, 1.66, 0.375
45706, 1.4083333333333, 1.66, 0.35416666666667
45707, 1.4083333333333, 1.68, 0.375
45708, 1.45, 1.52, 0.375
45709, 1.4291666666667, 1.54, 0.375
45710, 1.45, 1.54, 0.35416666666667
45711, 1.45, 1.56, 0.375
45712, 1.4291666666667, 1.58, 0.375
45713, 1.45, 1.58, 0.35416666666667
45714, 1.45, 1.6, 0.375
45715, 1.4291666666667, 1.62, 0.375
45716, 1.45, 1.62, 0.35416666666667
45717, 1.45, 1.64, 0.375
45718, 1.4291666666667, 1.66, 0.375
45719, 1.45, 1.66, 0.35416666666667
45720, 1.45, 1.68, 0.375
45721, 1.4916666666667, 1.52, 0.375
45722, 1.4708333333333, 1.54, 0.375
45723, 1.4916666666667, 1.54, 0.35416666666667
45724, 1.4916666666667, 1.56, 0.375
45725, 1.4708333333333, 1.58, 0.375
45726, 1.4916666666667, 1.58, 0.35416666666667
45727, 1.4916666666667, 1.6, 0.375
45728, 1.4708333333333, 1.62, 0.375
45729, 1.4916666666667, 1.62, 0.35416666666667
45730, 1.4916666666667, 1.64, 0.375
45731, 1.4708333333333, 1.66, 0.375
45732, 1.4916666666667, 1.66, 0.35416666666667
45733, 1.4916666666667, 1.68, 0.375
45734, 1.5333333333333, 1.52, 0.375
45735, 1.5125, 1.54, 0.375
45736, 1.5333333333333, 1.54, 0.35416666666667
45737, 1.5333333333333, 1.56, 0.375
45738, 1.5125, 1.58, 0.375
45739, 1.5333333333333, 1.58, 0.35416666666667
45740, 1.5333333333333, 1.6, 0.375
45741, 1.5125, 1.62, 0.375
45742, 1.5333333333333, 1.62, 0.35416666666667
45743, 1.5333333333333, 1.64, 0.375
45744, 1.5125, 1.66, 0.375
45745, 1.5333333333333, 1.66, 0.35416666666667
45746, 1.5333333333333, 1.68, 0.375
45747, 1.575, 1.52, 0.375
45748, 1.5541666666667, 1.54, 0.375
45749, 1.575, 1.54, 0.35416666666667
45750, 1.575, 1.56, 0.375
45751, 1.5541666666667, 1.58, 0.375
45752, 1.575, 1.58, 0.35416666666667
45753, 1.575, 1.6, 0.375
45754, 1.5541666666667, 1.62, 0.375
45755, 1.575, 1.62, 0.35416666666667
45756, 1.575, 1.64, 0.375
45757, 1.5541666666667, 1.66, 0.375
45758, 1.575, 1.66, 0.35416666666667
45759, 1.575, 1.68, 0.375
45760, 1.6166666666667, 1.52, 0.375
45761, 1.5958333333333, 1.54, 0.375
45762, 1.6166666666667, 1.54, 0.35416666666667
45763, 1.6166666666667, 1.56, 0.375
45764, 1.5958333333333, 1.58, 0.375
45765, 1.6166666666667, 1.58, 0.35416666666667
45766, 1.6166666666667, 1.6, 0.375
45767, 1.5958333333333, 1.62, 0.375
45768, 1.6166666666667, 1.62, 0.35416666666667
45769, 1.6166666666667, 1.64, 0.375
45770, 1.5958333333333, 1.66, 0.375
45771, 1.6166666666667, 1.66, 0.35416666666667
45772, 1.6166666666667, 1.68, 0.375
45773, 1.6583333333333, 1.52, 0.375
45774, 1.6375, 1.54, 0.375
45775, 1.6583333333333, 1.54, 0.35416666666667
45776, 1.6583333333333, 1.56, 0.375
45777, 1.6375, 1.58, 0.375
45778, 1.6583333333333, 1.58, 0.35416666666667
45779, 1.6583333333333, 1.6, 0.375
45780, 1.6375, 1.62, 0.375
45781, 1.6583333333333, 1.62, 0.35416666666667
45782, 1.6583333333333, 1.64, 0.375
45783, 1.6375, 1.66, 0.375
45784, 1.6583333333333, 1.66, 0.35416666666667
45785, 1.6583333333333, 1.68, 0.375
45786, 1.7, 1.52, 0.375
45787, 1.6791666666667, 1.54, 0.375
45788, 1.7, 1.54, 0.35416666666667
45789, 1.7, 1.56, 0.375
45790, 1.6791666666667, 1.58, 0.375
45791, 1.7, 1.58, 0.35416666666667
45792, 1.7, 1.6, 0.375
45793, 1.6791666666667, 1.62, 0.375
45794, 1.7, 1.62, 0.35416666666667
45795, 1.7, 1.64, 0.375
45796, 1.6791666666667, 1.66, 0.375
45797, 1.7, 1.66, 0.35416666666667
45798, 1.7, 1.68, 0.375
45799, 1.7416666666667, 1.52, 0.375
45800, 1.7208333333333, 1.54, 0.375
45801, 1.7416666666667, 1.54, 0.35416666666667
45802, 1.7416666666667, 1.56, 0.375
45803, 1.7208333333333, 1.58, 0.375
45804, 1.7416666666667, 1.58, 0.35416666666667
45805, 1.7416666666667, 1.6, 0.375
45806, 1.7208333333333, 1.62, 0.375
45807, 1.7416666666667, 1.62, 0.35416666666667
45808, 1.7416666666667, 1.64, 0.375
45809, 1.7208333333333, 1.66, 0.375
45810, 1.7416666666667, 1.66, 0.35416666666667
45811, 1.7416666666667, 1.68, 0.375
45812, 1.7833333333333, 1.52, 0.375
45813, 1.7625, 1.54, 0.375
45814, 1.7833333333333, 1.54, 0.35416666666667
45815, 1.7833333333333, 1.56, 0.375
45816, 1.7625, 1.58, 0.375
45817, 1.7833333333333, 1.58, 0.35416666666667
45818, 1.7833333333333, 1.6, 0.375
45819, 1.7625, 1.62, 0.375
45820, 1.7833333333333, 1.62, 0.35416666666667
45821, 1.7833333333333, 1.64, 0.375
45822, 1.7625, 1.66, 0.375
45823, 1.7833333333333, 1.66, 0.35416666666667
45824, 1.7833333333333, 1.68, 0.375
45825, 1.825, 1.52, 0.375
45826, 1.8041666666667, 1.54, 0.375
45827, 1.825, 1.54, 0.35416666666667
45828, 1.825, 1.56, 0.375
45829, 1.8041666666667, 1.58, 0.375
45830, 1.825, 1.58, 0.35416666666667
45831, 1.825, 1.6, 0.375
45832, 1.8041666666667, 1.62, 0.375
45833, 1.825, 1.62, 0.35416666666667
45834, 1.825, 1.64, 0.375
45835, 1.8041666666667, 1.66, 0.375
45836, 1.825, 1.66, 0.35416666666667
45837, 1.825, 1.68, 0.375
45838, 1.8666666666667, 1.52, 0.375
45839, 1.8458333333333, 1.54, 0.375
45840, 1.8666666666667, 1.54, 0.35416666666667
45841, 1.8666666666667, 1.56, 0.375
45842, 1.8458333333333, 1.58, 0.375
45843, 1.8666666666667, 1.58, 0.35416666666667
45844, 1.8666666666667, 1.6, 0.375
45845, 1.8458333333333, 1.62, 0.375
45846, 1.8666666666667, 1.62, 0.35416666666667
45847, 1.8666666666667, 1.64, 0.375
45848, 1.8458333333333, 1.66, 0.375
45849, 1.8666666666667, 1.66, 0.35416666666667
45850, 1.8666666666667, 1.68, 0.375
45851, 1.9083333333333, 1.52, 0.375
45852, 1.8875, 1.54, 0.375
45853, 1.9083333333333, 1.54, 0.35416666666667
45854, 1.9083333333333, 1.56, 0.375
45855, 1.8875, 1.58, 0.375
45856, 1.9083333333333, 1.58, 0.35416666666667
45857, 1.9083333333333, 1.6, 0.375
45858, 1.8875, 1.62, 0.375
45859, 1.9083333333333, 1.62, 0.35416666666667
45860, 1.9083333333333, 1.64, 0.375
45861, 1.8875, 1.66, 0.375
45862, 1.9083333333333, 1.66, 0.35416666666667
45863, 1.9083333333333, 1.68, 0.375
45864, 1.95, 1.52, 0.375
45865, 1.9291666666667, 1.54, 0.375
45866, 1.95, 1.54, 0.35416666666667
45867, 1.95, 1.56, 0.375
45868, 1.9291666666667, 1.58, 0.375
45869, 1.95, 1.58, 0.35416666666667
45870, 1.95, 1.6, 0.375
45871, 1.9291666666667, 1.62, 0.375
45872, 1.95, 1.62, 0.35416666666667
45873, 1.95, 1.64, 0.375
45874, 1.9291666666667, 1.66, 0.375
45875, 1.95, 1.66, 0.35416666666667
45876, 1.95, 1.68, 0.375
45877, 1.9916666666667, 1.52, 0.375
45878, 1.9708333333333, 1.54, 0.375
45879, 1.9916666666667, 1.54, 0.35416666666667
45880, 1.9916666666667, 1.56, 0.375
45881, 1.9708333333333, 1.58, 0.375
45882, 1.9916666666667, 1.58, 0.35416666666667
45883, 1.9916666666667, 1.6, 0.375
45884, 1.9708333333333, 1.62, 0.375
45885, 1.9916666666667, 1.62, 0.35416666666667
45886, 1.9916666666667, 1.64, 0.375
45887, 1.9708333333333, 1.66, 0.375
45888, 1.9916666666667, 1.66, 0.35416666666667
45889, 1.9916666666667, 1.68, 0.375
45890, 2.0333333333333, 1.52, 0.375
45891, 2.0125, 1.54, 0.375
45892, 2.0333333333333, 1.54, 0.35416666666667
45893, 2.0333333333333, 1.56, 0.375
45894, 2.0125, 1.58, 0.375
45895, 2.0333333333333, 1.58, 0.35416666666667
45896, 2.0333333333333, 1.6, 0.375
45897, 2.0125, 1.62, 0.375
45898, 2.0333333333333, 1.62, 0.35416666666667
45899, 2.0333333333333, 1.64, 0.375
45900, 2.0125, 1.66, 0.375
45901, 2.0333333333333, 1.66, 0.35416666666667
45902, 2.0333333333333, 1.68, 0.375
45903, 2.075, 1.52, 0.375
45904, 2.0541666666667, 1.54, 0.375
45905, 2.075, 1.54, 0.35416666666667
45906, 2.075, 1.56, 0.375
45907, 2.0541666666667, 1.58, 0.375
45908, 2.075, 1.58, 0.35416666666667
45909, 2.075, 1.6, 0.375
45910, 2.0541666666667, 1.62, 0.375
45911, 2.075, 1.62, 0.35416666666667
45912, 2.075, 1.64, 0.375
45913, 2.0541666666667, 1.66, 0.375
45914, 2.075, 1.66, 0.35416666666667
45915, 2.075, 1.68, 0.375
45916, 2.1166666666667, 1.52, 0.375
45917, 2.0958333333333, 1.54, 0.375
45918, 2.1166666666667, 1.54, 0.35416666666667
45919, 2.1166666666667, 1.56, 0.375
45920, 2.0958333333333, 1.58, 0.375
45921, 2.1166666666667, 1.58, 0.35416666666667
45922, 2.1166666666667, 1.6, 0.375
45923, 2.0958333333333, 1.62, 0.375
45924, 2.1166666666667, 1.62, 0.35416666666667
45925, 2.1166666666667, 1.64, 0.375
45926, 2.0958333333333, 1.66, 0.375
45927, 2.1166666666667, 1.66, 0.35416666666667
45928, 2.1166666666667, 1.68, 0.375
45929, 2.1583333333333, 1.52, 0.375
45930, 2.1375, 1.54, 0.375
45931, 2.1583333333333, 1.54, 0.35416666666667
45932, 2.1583333333333, 1.56, 0.375
45933, 2.1375, 1.58, 0.375
45934, 2.1583333333333, 1.58, 0.35416666666667
45935, 2.1583333333333, 1.6, 0.375
45936, 2.1375, 1.62, 0.375
45937, 2.1583333333333, 1.62, 0.35416666666667
45938, 2.1583333333333, 1.64, 0.375
45939, 2.1375, 1.66, 0.375
45940, 2.1583333333333, 1.66, 0.35416666666667
45941, 2.1583333333333, 1.68, 0.375
45942, 2.1791666666667, 1.54, 0.375
45943, 2.1791666666667, 1.58, 0.375
45944, 2.1791666666667, 1.62, 0.375
45945, 2.1791666666667, 1.66, 0.375
45946, 1.2416666666667, 1.52, 0.41666666666667
45947, 1.2208333333333, 1.54, 0.41666666666667
45948, 1.2416666666667, 1.54, 0.39583333333333
45949, 1.2416666666667, 1.56, 0.41666666666667
45950, 1.2208333333333, 1.58, 0.41666666666667
45951, 1.2416666666667, 1.58, 0.39583333333333
45952, 1.2416666666667, 1.6, 0.41666666666667
45953, 1.2208333333333, 1.62, 0.41666666666667
45954, 1.2416666666667, 1.62, 0.39583333333333
45955, 1.2416666666667, 1.64, 0.41666666666667
45956, 1.2208333333333, 1.66, 0.41666666666667
45957, 1.2416666666667, 1.66, 0.39583333333333
45958, 1.2416666666667, 1.68, 0.41666666666667
45959, 1.2833333333333, 1.52, 0.41666666666667
45960, 1.2625, 1.54, 0.41666666666667
45961, 1.2833333333333, 1.54, 0.39583333333333
45962, 1.2833333333333, 1.56, 0.41666666666667
45963, 1.2625, 1.58, 0.41666666666667
45964, 1.2833333333333, 1.58, 0.39583333333333
45965, 1.2833333333333, 1.6, 0.41666666666667
45966, 1.2625, 1.62, 0.41666666666667
45967, 1.2833333333333, 1.62, 0.39583333333333
45968, 1.2833333333333, 1.64, 0.41666666666667
45969, 1.2625, 1.66, 0.41666666666667
45970, 1.2833333333333, 1.66, 0.39583333333333
45971, 1.2833333333333, 1.68, 0.41666666666667
45972, 1.325, 1.52, 0.41666666666667
45973, 1.3041666666667, 1.54, 0.41666666666667
45974, 1.325, 1.54, 0.39583333333333
45975, 1.325, 1.56, 0.41666666666667
45976, 1.3041666666667, 1.58, 0.41666666666667
45977, 1.325, 1.58, 0.39583333333333
45978, 1.325, 1.6, 0.41666666666667
45979, 1.3041666666667, 1.62, 0.41666666666667
45980, 1.325, 1.62, 0.39583333333333
45981, 1.325, 1.64, 0.41666666666667
45982, 1.3041666666667, 1.66, 0.41666666666667
45983, 1.325, 1.66, 0.39583333333333
45984, 1.325, 1.68, 0.41666666666667
45985, 1.3666666666667, 1.52, 0.41666666666667
45986, 1.3458333333333, 1.54, 0.41666666666667
45987, 1.3666666666667, 1.54, 0.39583333333333
45988, 1.3666666666667, 1.56, 0.41666666666667
45989, 1.3458333333333, 1.58, 0.41666666666667
45990, 1.3666666666667, 1.58, 0.39583333333333
45991, 1.3666666666667, 1.6, 0.41666666666667
45992, 1.3458333333333, 1.62, 0.41666666666667
45993, 1.3666666666667, 1.62, 0.39583333333333
45994, 1.3666666666667, 1.64, 0.41666666666667
45995, 1.3458333333333, 1.66, 0.41666666666667
45996, 1.3666666666667, 1.66, 0.39583333333333
45997, 1.3666666666667, 1.68, 0.41666666666667
45998, 1.4083333333333, 1.52, 0.41666666666667
45999, 1.3875, 1.54, 0.41666666666667
46000, 1.4083333333333, 1.54, 0.39583333333333
46001, 1.4083333333333, 1.56, 0.41666666666667
46002, 1.3875, 1.58, 0.41666666666667
46003, 1.4083333333333, 1.58, 0.39583333333333
46004, 1.4083333333333, 1.6, 0.41666666666667
46005, 1.3875, 1.62, 0.41666666666667
46006, 1.4083333333333, 1.62, 0.39583333333333
46007, 1.4083333333333, 1.64, 0.41666666666667
46008, 1.3875, 1.66, 0.41666666666667
46009, 1.4083333333333, 1.66, 0.39583333333333
46010, 1.4083333333333, 1.68, 0.41666666666667
46011, 1.45, 1.52, 0.41666666666667
46012, 1.4291666666667, 1.54, 0.41666666666667
46013, 1.45, 1.54, 0.39583333333333
46014, 1.45, 1.56, 0.41666666666667
46015, 1.4291666666667, 1.58, 0.41666666666667
46016, 1.45, 1.58, 0.39583333333333
46017, 1.45, 1.6, 0.41666666666667
46018, 1.4291666666667, 1.62, 0.41666666666667
46019, 1.45, 1.62, 0.39583333333333
46020, 1.45, 1.64, 0.41666666666667
46021, 1.4291666666667, 1.66, 0.41666666666667
46022, 1.45, 1.66, 0.39583333333333
46023, 1.45, 1.68, 0.41666666666667
46024, 1.4916666666667, 1.52, 0.41666666666667
46025, 1.4708333333333, 1.54, 0.41666666666667
46026, 1.4916666666667, 1.54, 0.39583333333333
46027, 1.4916666666667, 1.56, 0.41666666666667
46028, 1.4708333333333, 1.58, 0.41666666666667
46029, 1.4916666666667, 1.58, 0.39583333333333
46030, 1.4916666666667, 1.6, 0.41666666666667
46031, 1.4708333333333, 1.62, 0.41666666666667
46032, 1.4916666666667, 1.62, 0.39583333333333
46033, 1.4916666666667, 1.64, 0.41666666666667
46034, 1.4708333333333, 1.66, 0.41666666666667
46035, 1.4916666666667, 1.66, 0.39583333333333
46036, 1.4916666666667, 1.68, 0.41666666666667
46037, 1.5333333333333, 1.52, 0.41666666666667
46038, 1.5125, 1.54, 0.41666666666667
46039, 1.5333333333333, 1.54, 0.39583333333333
46040, 1.5333333333333, 1.56, 0.41666666666667
46041, 1.5125, 1.58, 0.41666666666667
46042, 1.5333333333333, 1.58, 0.39583333333333
46043, 1.5333333333333, 1.6, 0.41666666666667
46044, 1.5125, 1.62, 0.41666666666667
46045, 1.5333333333333, 1.62, 0.39583333333333
46046, 1.5333333333333, 1.64, 0.41666666666667
46047, 1.5125, 1.66, 0.41666666666667
46048, 1.5333333333333, 1.66, 0.39583333333333
46049, 1.5333333333333, 1.68, 0.41666666666667
46050, 1.575, 1.52, 0.41666666666667
46051, 1.5541666666667, 1.54, 0.41666666666667
46052, 1.575, 1.54, 0.39583333333333
46053, 1.575, 1.56, 0.41666666666667
46054, 1.5541666666667, 1.58, 0.41666666666667
46055, 1.575, 1.58, 0.39583333333333
46056, 1.575, 1.6, 0.41666666666667
46057, 1.5541666666667, 1.62, 0.41666666666667
46058, 1.575, 1.62, 0.39583333333333
46059, 1.575, 1.64, 0.41666666666667
46060, 1.5541666666667, 1.66, 0.41666666666667
46061, 1.575, 1.66, 0.39583333333333
46062, 1.575, 1.68, 0.41666666666667
46063, 1.6166666666667, 1.52, 0.41666666666667
46064, 1.5958333333333, 1.54, 0.41666666666667
46065, 1.6166666666667, 1.54, 0.39583333333333
46066, 1.6166666666667, 1.56, 0.41666666666667
46067, 1.5958333333333, 1.58, 0.41666666666667
46068, 1.6166666666667, 1.58, 0.39583333333333
46069, 1.6166666666667, 1.6, 0.41666666666667
46070, 1.5958333333333, 1.62, 0.41666666666667
46071, 1.6166666666667, 1.62, 0.39583333333333
46072, 1.6166666666667, 1.64, 0.41666666666667
46073, 1.5958333333333, 1.66, 0.41666666666667
46074, 1.6166666666667, 1.66, 0.39583333333333
46075, 1.6166666666667, 1.68, 0.41666666666667
46076, 1.6583333333333, 1.52, 0.41666666666667
46077, 1.6375, 1.54, 0.41666666666667
46078, 1.6583333333333, 1.54, 0.39583333333333
46079, 1.6583333333333, 1.56, 0.41666666666667
46080, 1.6375, 1.58, 0.41666666666667
46081, 1.6583333333333, 1.58, 0.39583333333333
46082, 1.6583333333333, 1.6, 0.41666666666667
46083, 1.6375, 1.62, 0.41666666666667
46084, 1.6583333333333, 1.62, 0.39583333333333
46085, 1.6583333333333, 1.64, 0.41666666666667
46086, 1.6375, 1.66, 0.41666666666667
46087, 1.6583333333333, 1.66, 0.39583333333333
46088, 1.6583333333333, 1.68, 0.41666666666667
46089, 1.7, 1.52, 0.41666666666667
46090, 1.6791666666667, 1.54, 0.41666666666667
46091, 1.7, 1.54, 0.39583333333333
46092, 1.7, 1.56, 0.41666666666667
46093, 1.6791666666667, 1.58, 0.41666666666667
46094, 1.7, 1.58, 0.39583333333333
46095, 1.7, 1.6, 0.41666666666667
46096, 1.6791666666667, 1.62, 0.41666666666667
46097, 1.7, 1.62, 0.39583333333333
46098, 1.7, 1.64, 0.41666666666667
46099, 1.6791666666667, 1.66, 0.41666666666667
46100, 1.7, 1.66, 0.39583333333333
46101, 1.7, 1.68, 0.41666666666667
46102, 1.7416666666667, 1.52, 0.41666666666667
46103, 1.7208333333333, 1.54, 0.41666666666667
46104, 1.7416666666667, 1.54, 0.39583333333333
46105, 1.7416666666667, 1.56, 0.41666666666667
46106, 1.7208333333333, 1.58, 0.41666666666667
46107, 1.7416666666667, 1.58, 0.39583333333333
46108, 1.7416666666667, 1.6, 0.41666666666667
46109, 1.7208333333333, 1.62, 0.41666666666667
46110, 1.7416666666667, 1.62, 0.39583333333333
46111, 1.7416666666667, 1.64, 0.41666666666667
46112, 1.7208333333333, 1.66, 0.41666666666667
46113, 1.7416666666667, 1.66, 0.39583333333333
46114, 1.7416666666667, 1.68, 0.41666666666667
46115, 1.7833333333333, 1.52, 0.41666666666667
46116, 1.7625, 1.54, 0.41666666666667
46117, 1.7833333333333, 1.54, 0.39583333333333
46118, 1.7833333333333, 1.56, 0.41666666666667
46119, 1.7625, 1.58, 0.41666666666667
46120, 1.7833333333333, 1.58, 0.39583333333333
46121, 1.7833333333333, 1.6, 0.41666666666667
46122, 1.7625, 1.62, 0.41666666666667
46123, 1.7833333333333, 1.62, 0.39583333333333
46124, 1.7833333333333, 1.64, 0.41666666666667
46125, 1.7625, 1.66, 0.41666666666667
46126, 1.7833333333333, 1.66, 0.39583333333333
46127, 1.7833333333333, 1.68, 0.41666666666667
46128, 1.825, 1.52, 0.41666666666667
46129, 1.8041666666667, 1.54, 0.41666666666667
46130, 1.825, 1.54, 0.39583333333333
46131, 1.825, 1.56, 0.41666666666667
46132, 1.8041666666667, 1.58, 0.41666666666667
46133, 1.825, 1.58, 0.39583333333333
46134, 1.825, 1.6, 0.41666666666667
46135, 1.8041666666667, 1.62, 0.41666666666667
46136, 1.825, 1.62, 0.39583333333333
46137, 1.825, 1.64, 0.41666666666667
46138, 1.8041666666667, 1.66, 0.41666666666667
46139, 1.825, 1.66, 0.39583333333333
46140, 1.825, 1.68, 0.41666666666667
46141, 1.8666666666667, 1.52, 0.41666666666667
46142, 1.8458333333333, 1.54, 0.41666666666667
46143, 1.8666666666667, 1.54, 0.39583333333333
46144, 1.8666666666667, 1.56, 0.41666666666667
46145, 1.8458333333333, 1.58, 0.41666666666667
46146, 1.8666666666667, 1.58, 0.39583333333333
46147, 1.8666666666667, 1.6, 0.41666666666667
46148, 1.8458333333333, 1.62, 0.41666666666667
46149, 1.8666666666667, 1.62, 0.39583333333333
46150, 1.8666666666667, 1.64, 0.41666666666667
46151, 1.8458333333333, 1.66, 0.41666666666667
46152, 1.8666666666667, 1.66, 0.39583333333333
46153, 1.8666666666667, 1.68, 0.41666666666667
46154, 1.9083333333333, 1.52, 0.41666666666667
46155, 1.8875, 1.54, 0.41666666666667
46156, 1.9083333333333, 1.54, 0.39583333333333
46157, 1.9083333333333, 1.56, 0.41666666666667
46158, 1.8875, 1.58, 0.41666666666667
46159, 1.9083333333333, 1.58, 0.39583333333333
46160, 1.9083333333333, 1.6, 0.41666666666667
46161, 1.8875, 1.62, 0.41666666666667
46162, 1.9083333333333, 1.62, 0.39583333333333
46163, 1.9083333333333, 1.64, 0.41666666666667
46164, 1.8875, 1.66, 0.41666666666667
46165, 1.9083333333333, 1.66, 0.39583333333333
46166, 1.9083333333333, 1.68, 0.41666666666667
46167, 1.95, 1.52, 0.41666666666667
46168, 1.9291666666667, 1.54, 0.41666666666667
46169, 1.95, 1.54, 0.39583333333333
46170, 1.95, 1.56, 0.41666666666667
46171, 1.9291666666667, 1.58, 0.41666666666667
46172, 1.95, 1.58, 0.39583333333333
46173, 1.95, 1.6, 0.41666666666667
46174, 1.9291666666667, 1.62, 0.41666666666667
46175, 1.95, 1.62, 0.39583333333333
46176, 1.95, 1.64, 0.41666666666667
46177, 1.9291666666667, 1.66, 0.41666666666667
46178, 1.95, 1.66, 0.39583333333333
46179, 1.95, 1.68, 0.41666666666667
46180, 1.9916666666667, 1.52, 0.41666666666667
46181, 1.9708333333333, 1.54, 0.41666666666667
46182, 1.9916666666667, 1.54, 0.39583333333333
46183, 1.9916666666667, 1.56, 0.41666666666667
46184, 1.9708333333333, 1.58, 0.41666666666667
46185, 1.9916666666667, 1.58, 0.39583333333333
46186, 1.9916666666667, 1.6, 0.41666666666667
46187, 1.9708333333333, 1.62, 0.41666666666667
46188, 1.9916666666667, 1.62, 0.39583333333333
46189, 1.9916666666667, 1.64, 0.41666666666667
46190, 1.9708333333333, 1.66, 0.41666666666667
46191, 1.9916666666667, 1.66, 0.39583333333333
46192, 1.9916666666667, 1.68, 0.41666666666667
46193, 2.0333333333333, 1.52, 0.41666666666667
46194, 2.0125, 1.54, 0.41666666666667
46195, 2.0333333333333, 1.54, 0.39583333333333
46196, 2.0333333333333, 1.56, 0.41666666666667
46197, 2.0125, 1.58, 0.41666666666667
46198, 2.0333333333333, 1.58, 0.39583333333333
46199, 2.0333333333333, 1.6, 0.41666666666667
46200, 2.0125, 1.62, 0.41666666666667
46201, 2.0333333333333, 1.62, 0.39583333333333
46202, 2.0333333333333, 1.64, 0.41666666666667
46203, 2.0125, 1.66, 0.41666666666667
46204, 2.0333333333333, 1.66, 0.39583333333333
46205, 2.0333333333333, 1.68, 0.41666666666667
46206, 2.075, 1.52, 0.41666666666667
46207, 2.0541666666667, 1.54, 0.41666666666667
46208, 2.075, 1.54, 0.39583333333333
46209, 2.075, 1.56, 0.41666666666667
46210, 2.0541666666667, 1.58, 0.41666666666667
46211, 2.075, 1.58, 0.39583333333333
46212, 2.075, 1.6, 0.41666666666667
46213, 2.0541666666667, 1.62, 0.41666666666667
46214, 2.075, 1.62, 0.39583333333333
46215, 2.075, 1.64, 0.41666666666667
46216, 2.0541666666667, 1.66, 0.41666666666667
46217, 2.075, 1.66, 0.39583333333333
46218, 2.075, 1.68, 0.41666666666667
46219, 2.1166666666667, 1.52, 0.41666666666667
46220, 2.0958333333333, 1.54, 0.41666666666667
46221, 2.1166666666667, 1.54, 0.39583333333333
46222, 2.1166666666667, 1.56, 0.41666666666667
46223, 2.0958333333333, 1.58, 0.41666666666667
46224, 2.1166666666667, 1.58, 0.39583333333333
46225, 2.1166666666667, 1.6, 0.41666666666667
46226, 2.0958333333333, 1.62, 0.41666666666667
46227, 2.1166666666667, 1.62, 0.39583333333333
46228, 2.1166666666667, 1.64, 0.41666666666667
46229, 2.0958333333333, 1.66, 0.41666666666667
46230, 2.1166666666667, 1.66, 0.39583333333333
46231, 2.1166666666667, 1.68, 0.41666666666667
46232, 2.1583333333333, 1.52, 0.41666666666667
46233, 2.1375, 1.54, 0.41666666666667
46234, 2.1583333333333, 1.54, 0.39583333333333
46235, 2.1583333333333, 1.56, 0.41666666666667
46236, 2.1375, 1.58, 0.41666666666667
46237, 2.1583333333333, 1.58, 0.39583333333333
46238, 2.1583333333333, 1.6, 0.41666666666667
46239, 2.1375, 1.62, 0.41666666666667
46240, 2.1583333333333, 1.62, 0.39583333333333
46241, 2.1583333333333, 1.64, 0.41666666666667
46242, 2.1375, 1.66, 0.41666666666667
46243, 2.1583333333333, 1.66, 0.39583333333333
46244, 2.1583333333333, 1.68, 0.41666666666667
46245, 2.1791666666667, 1.54, 0.41666666666667
46246, 2.1791666666667, 1.58, 0.41666666666667
46247, 2.1791666666667, 1.62, 0.41666666666667
46248, 2.1791666666667, 1.66, 0.41666666666667
46249, 1.2416666666667, 1.52, 0.45833333333333
46250, 1.2208333333333, 1.54, 0.45833333333333
46251, 1.2416666666667, 1.54, 0.4375
46252, 1.2416666666667, 1.56, 0.45833333333333
46253, 1.2208333333333, 1.58, 0.45833333333333
46254, 1.2416666666667, 1.58, 0.4375
46255, 1.2416666666667, 1.6, 0.45833333333333
46256, 1.2208333333333, 1.62, 0.45833333333333
46257, 1.2416666666667, 1.62, 0.4375
46258, 1.2416666666667, 1.64, 0.45833333333333
46259, 1.2208333333333, 1.66, 0.45833333333333
46260, 1.2416666666667, 1.66, 0.4375
46261, 1.2416666666667, 1.68, 0.45833333333333
46262, 1.2833333333333, 1.52, 0.45833333333333
46263, 1.2625, 1.54, 0.45833333333333
46264, 1.2833333333333, 1.54, 0.4375
46265, 1.2833333333333, 1.56, 0.45833333333333
46266, 1.2625, 1.58, 0.45833333333333
46267, 1.2833333333333, 1.58, 0.4375
46268, 1.2833333333333, 1.6, 0.45833333333333
46269, 1.2625, 1.62, 0.45833333333333
46270, 1.2833333333333, 1.62, 0.4375
46271, 1.2833333333333, 1.64, 0.45833333333333
46272, 1.2625, 1.66, 0.45833333333333
46273, 1.2833333333333, 1.66, 0.4375
46274, 1.2833333333333, 1.68, 0.45833333333333
46275, 1.325, 1.52, 0.45833333333333
46276, 1.3041666666667, 1.54, 0.45833333333333
46277, 1.325, 1.54, 0.4375
46278, 1.325, 1.56, 0.45833333333333
46279, 1.3041666666667, 1.58, 0.45833333333333
46280, 1.325, 1.58, 0.4375
46281, 1.325, 1.6, 0.45833333333333
46282, 1.3041666666667, 1.62, 0.45833333333333
46283, 1.325, 1.62, 0.4375
46284, 1.325, 1.64, 0.45833333333333
46285, 1.3041666666667, 1.66, 0.45833333333333
46286, 1.325, 1.66, 0.4375
46287, 1.325, 1.68, 0.45833333333333
46288, 1.3666666666667, 1.52, 0.45833333333333
46289, 1.3458333333333, 1.54, 0.45833333333333
46290, 1.3666666666667, 1.54, 0.4375
46291, 1.3666666666667, 1.56, 0.45833333333333
46292, 1.3458333333333, 1.58, 0.45833333333333
46293, 1.3666666666667, 1.58, 0.4375
46294, 1.3666666666667, 1.6, 0.45833333333333
46295, 1.3458333333333, 1.62, 0.45833333333333
46296, 1.3666666666667, 1.62, 0.4375
46297, 1.3666666666667, 1.64, 0.45833333333333
46298, 1.3458333333333, 1.66, 0.45833333333333
46299, 1.3666666666667, 1.66, 0.4375
46300, 1.3666666666667, 1.68, 0.45833333333333
46301, 1.4083333333333, 1.52, 0.45833333333333
46302, 1.3875, 1.54, 0.45833333333333
46303, 1.4083333333333, 1.54, 0.4375
46304, 1.4083333333333, 1.56, 0.45833333333333
46305, 1.3875, 1.58, 0.45833333333333
46306, 1.4083333333333, 1.58, 0.4375
46307, 1.4083333333333, 1.6, 0.45833333333333
46308, 1.3875, 1.62, 0.45833333333333
46309, 1.4083333333333, 1.62, 0.4375
46310, 1.4083333333333, 1.64, 0.45833333333333
46311, 1.3875, 1.66, 0.45833333333333
46312, 1.4083333333333, 1.66, 0.4375
46313, 1.4083333333333, 1.68, 0.45833333333333
46314, 1.45, 1.52, 0.45833333333333
46315, 1.4291666666667, 1.54, 0.45833333333333
46316, 1.45, 1.54, 0.4375
46317, 1.45, 1.56, 0.45833333333333
46318, 1.4291666666667, 1.58, 0.45833333333333
46319, 1.45, 1.58, 0.4375
46320, 1.45, 1.6, 0.45833333333333
46321, 1.4291666666667, 1.62, 0.45833333333333
46322, 1.45, 1.62, 0.4375
46323, 1.45, 1.64, 0.45833333333333
46324, 1.4291666666667, 1.66, 0.45833333333333
46325, 1.45, 1.66, 0.4375
46326, 1.45, 1.68, 0.45833333333333
46327, 1.4916666666667, 1.52, 0.45833333333333
46328, 1.4708333333333, 1.54, 0.45833333333333
46329, 1.4916666666667, 1.54, 0.4375
46330, 1.4916666666667, 1.56, 0.45833333333333
46331, 1.4708333333333, 1.58, 0.45833333333333
46332, 1.4916666666667, 1.58, 0.4375
46333, 1.4916666666667, 1.6, 0.45833333333333
46334, 1.4708333333333, 1.62, 0.45833333333333
46335, 1.4916666666667, 1.62, 0.4375
46336, 1.4916666666667, 1.64, 0.45833333333333
46337, 1.4708333333333, 1.66, 0.45833333333333
46338, 1.4916666666667, 1.66, 0.4375
46339, 1.4916666666667, 1.68, 0.45833333333333
46340, 1.5333333333333, 1.52, 0.45833333333333
46341, 1.5125, 1.54, 0.45833333333333
46342, 1.5333333333333, 1.54, 0.4375
46343, 1.5333333333333, 1.56, 0.45833333333333
46344, 1.5125, 1.58, 0.45833333333333
46345, 1.5333333333333, 1.58, 0.4375
46346, 1.5333333333333, 1.6, 0.45833333333333
46347, 1.5125, 1.62, 0.45833333333333
46348, 1.5333333333333, 1.62, 0.4375
46349, 1.5333333333333, 1.64, 0.45833333333333
46350, 1.5125, 1.66, 0.45833333333333
46351, 1.5333333333333, 1.66, 0.4375
46352, 1.5333333333333, 1.68, 0.45833333333333
46353, 1.575, 1.52, 0.45833333333333
46354, 1.5541666666667, 1.54, 0.45833333333333
46355, 1.575, 1.54, 0.4375
46356, 1.575, 1.56, 0.45833333333333
46357, 1.5541666666667, 1.58, 0.45833333333333
46358, 1.575, 1.58, 0.4375
46359, 1.575, 1.6, 0.45833333333333
46360, 1.5541666666667, 1.62, 0.45833333333333
46361, 1.575, 1.62, 0.4375
46362, 1.575, 1.64, 0.45833333333333
46363, 1.5541666666667, 1.66, 0.45833333333333
46364, 1.575, 1.66, 0.4375
46365, 1.575, 1.68, 0.45833333333333
46366, 1.6166666666667, 1.52, 0.45833333333333
46367, 1.5958333333333, 1.54, 0.45833333333333
46368, 1.6166666666667, 1.54, 0.4375
46369, 1.6166666666667, 1.56, 0.45833333333333
46370, 1.5958333333333, 1.58, 0.45833333333333
46371, 1.6166666666667, 1.58, 0.4375
46372, 1.6166666666667, 1.6, 0.45833333333333
46373, 1.5958333333333, 1.62, 0.45833333333333
46374, 1.6166666666667, 1.62, 0.4375
46375, 1.6166666666667, 1.64, 0.45833333333333
46376, 1.5958333333333, 1.66, 0.45833333333333
46377, 1.6166666666667, 1.66, 0.4375
46378, 1.6166666666667, 1.68, 0.45833333333333
46379, 1.6583333333333, 1.52, 0.45833333333333
46380, 1.6375, 1.54, 0.45833333333333
46381, 1.6583333333333, 1.54, 0.4375
46382, 1.6583333333333, 1.56, 0.45833333333333
46383, 1.6375, 1.58, 0.45833333333333
46384, 1.6583333333333, 1.58, 0.4375
46385, 1.6583333333333, 1.6, 0.45833333333333
46386, 1.6375, 1.62, 0.45833333333333
46387, 1.6583333333333, 1.62, 0.4375
46388, 1.6583333333333, 1.64, 0.45833333333333
46389, 1.6375, 1.66, 0.45833333333333
46390, 1.6583333333333, 1.66, 0.4375
46391, 1.6583333333333, 1.68, 0.45833333333333
46392, 1.7, 1.52, 0.45833333333333
46393, 1.6791666666667, 1.54, 0.45833333333333
46394, 1.7, 1.54, 0.4375
46395, 1.7, 1.56, 0.45833333333333
46396, 1.6791666666667, 1.58, 0.45833333333333
46397, 1.7, 1.58, 0.4375
46398, 1.7, 1.6, 0.45833333333333
46399, 1.6791666666667, 1.62, 0.45833333333333
46400, 1.7, 1.62, 0.4375
46401, 1.7, 1.64, 0.45833333333333
46402, 1.6791666666667, 1.66, 0.45833333333333
46403, 1.7, 1.66, 0.4375
46404, 1.7, 1.68, 0.45833333333333
46405, 1.7416666666667, 1.52, 0.45833333333333
46406, 1.7208333333333, 1.54, 0.45833333333333
46407, 1.7416666666667, 1.54, 0.4375
46408, 1.7416666666667, 1.56, 0.45833333333333
46409, 1.7208333333333, 1.58, 0.45833333333333
46410, 1.7416666666667, 1.58, 0.4375
46411, 1.7416666666667, 1.6, 0.45833333333333
46412, 1.7208333333333, 1.62, 0.45833333333333
46413, 1.7416666666667, 1.62, 0.4375
46414, 1.7416666666667, 1.64, 0.45833333333333
46415, 1.7208333333333, 1.66, 0.45833333333333
46416, 1.7416666666667, 1.66, 0.4375
46417, 1.7416666666667, 1.68, 0.45833333333333
46418, 1.7833333333333, 1.52, 0.45833333333333
46419, 1.7625, 1.54, 0.45833333333333
46420, 1.7833333333333, 1.54, 0.4375
46421, 1.7833333333333, 1.56, 0.45833333333333
46422, 1.7625, 1.58, 0.45833333333333
46423, 1.7833333333333, 1.58, 0.4375
46424, 1.7833333333333, 1.6, 0.45833333333333
46425, 1.7625, 1.62, 0.45833333333333
46426, 1.7833333333333, 1.62, 0.4375
46427, 1.7833333333333, 1.64, 0.45833333333333
46428, 1.7625, 1.66, 0.45833333333333
46429, 1.7833333333333, 1.66, 0.4375
46430, 1.7833333333333, 1.68, 0.45833333333333
46431, 1.825, 1.52, 0.45833333333333
46432, 1.8041666666667, 1.54, 0.45833333333333
46433, 1.825, 1.54, 0.4375
46434, 1.825, 1.56, 0.45833333333333
46435, 1.8041666666667, 1.58, 0.45833333333333
46436, 1.825, 1.58, 0.4375
46437, 1.825, 1.6, 0.45833333333333
46438, 1.8041666666667, 1.62, 0.45833333333333
46439, 1.825, 1.62, 0.4375
46440, 1.825, 1.64, 0.45833333333333
46441, 1.8041666666667, 1.66, 0.45833333333333
46442, 1.825, 1.66, 0.4375
46443, 1.825, 1.68, 0.45833333333333
46444, 1.8666666666667, 1.52, 0.45833333333333
46445, 1.8458333333333, 1.54, 0.45833333333333
46446, 1.8666666666667, 1.54, 0.4375
46447, 1.8666666666667, 1.56, 0.45833333333333
46448, 1.8458333333333, 1.58, 0.45833333333333
46449, 1.8666666666667, 1.58, 0.4375
46450, 1.8666666666667, 1.6, 0.45833333333333
46451, 1.8458333333333, 1.62, 0.45833333333333
46452, 1.8666666666667, 1.62, 0.4375
46453, 1.8666666666667, 1.64, 0.45833333333333
46454, 1.8458333333333, 1.66, 0.45833333333333
46455, 1.8666666666667, 1.66, 0.4375
46456, 1.8666666666667, 1.68, 0.45833333333333
46457, 1.9083333333333, 1.52, 0.45833333333333
46458, 1.8875, 1.54, 0.45833333333333
46459, 1.9083333333333, 1.54, 0.4375
46460, 1.9083333333333, 1.56, 0.45833333333333
46461, 1.8875, 1.58, 0.45833333333333
46462, 1.9083333333333, 1.58, 0.4375
46463, 1.9083333333333, 1.6, 0.45833333333333
46464, 1.8875, 1.62, 0.45833333333333
46465, 1.9083333333333, 1.62, 0.4375
46466, 1.9083333333333, 1.64, 0.45833333333333
46467, 1.8875, 1.66, 0.45833333333333
46468, 1.9083333333333, 1.66, 0.4375
46469, 1.9083333333333, 1.68, 0.45833333333333
46470, 1.95, 1.52, 0.45833333333333
46471, 1.9291666666667, 1.54, 0.45833333333333
46472, 1.95, 1.54, 0.4375
46473, 1.95, 1.56, 0.45833333333333
46474, 1.9291666666667, 1.58, 0.45833333333333
46475, 1.95, 1.58, 0.4375
46476, 1.95, 1.6, 0.45833333333333
46477, 1.9291666666667, 1.62, 0.45833333333333
46478, 1.95, 1.62, 0.4375
46479, 1.95, 1.64, 0.45833333333333
46480, 1.9291666666667, 1.66, 0.45833333333333
46481, 1.95, 1.66, 0.4375
46482, 1.95, 1.68, 0.45833333333333
46483, 1.9916666666667, 1.52, 0.45833333333333
46484, 1.9708333333333, 1.54, 0.45833333333333
46485, 1.9916666666667, 1.54, 0.4375
46486, 1.9916666666667, 1.56, 0.45833333333333
46487, 1.9708333333333, 1.58, 0.45833333333333
46488, 1.9916666666667, 1.58, 0.4375
46489, 1.9916666666667, 1.6, 0.45833333333333
46490, 1.9708333333333, 1.62, 0.45833333333333
46491, 1.9916666666667, 1.62, 0.4375
46492, 1.9916666666667, 1.64, 0.45833333333333
46493, 1.9708333333333, 1.66, 0.45833333333333
46494, 1.9916666666667, 1.66, 0.4375
46495, 1.9916666666667, 1.68, 0.45833333333333
46496, 2.0333333333333, 1.52, 0.45833333333333
46497, 2.0125, 1.54, 0.45833333333333
46498, 2.0333333333333, 1.54, 0.4375
46499, 2.0333333333333, 1.56, 0.45833333333333
46500, 2.0125, 1.58, 0.45833333333333
46501, 2.0333333333333, 1.58, 0.4375
46502, 2.0333333333333, 1.6, 0.45833333333333
46503, 2.0125, 1.62, 0.45833333333333
46504, 2.0333333333333, 1.62, 0.4375
46505, 2.0333333333333, 1.64, 0.45833333333333
46506, 2.0125, 1.66, 0.45833333333333
46507, 2.0333333333333, 1.66, 0.4375
46508, 2.0333333333333, 1.68, 0.45833333333333
46509, 2.075, 1.52, 0.45833333333333
46510, 2.0541666666667, 1.54, 0.45833333333333
46511, 2.075, 1.54, 0.4375
46512, 2.075, 1.56, 0.45833333333333
46513, 2.0541666666667, 1.58, 0.45833333333333
46514, 2.075, 1.58, 0.4375
46515, 2.075, 1.6, 0.45833333333333
46516, 2.0541666666667, 1.62, 0.45833333333333
46517, 2.075, 1.62, 0.4375
46518, 2.075, 1.64, 0.45833333333333
46519, 2.0541666666667, 1.66, 0.45833333333333
46520, 2.075, 1.66, 0.4375
46521, 2.075, 1.68, 0.45833333333333
46522, 2.1166666666667, 1.52, 0.45833333333333
46523, 2.0958333333333, 1.54, 0.45833333333333
46524, 2.1166666666667, 1.54, 0.4375
46525, 2.1166666666667, 1.56, 0.45833333333333
46526, 2.0958333333333, 1.58, 0.45833333333333
46527, 2.1166666666667, 1.58, 0.4375
46528, 2.1166666666667, 1.6, 0.45833333333333
46529, 2.0958333333333, 1.62, 0.45833333333333
46530, 2.1166666666667, 1.62, 0.4375
46531, 2.1166666666667, 1.64, 0.45833333333333
46532, 2.0958333333333, 1.66, 0.45833333333333
46533, 2.1166666666667, 1.66, 0.4375
46534, 2.1166666666667, 1.68, 0.45833333333333
46535, 2.1583333333333, 1.52, 0.45833333333333
46536, 2.1375, 1.54, 0.45833333333333
46537, 2.1583333333333, 1.54, 0.4375
46538, 2.1583333333333, 1.56, 0.45833333333333
46539, 2.1375, 1.58, 0.45833333333333
46540, 2.1583333333333, 1.58, 0.4375
46541, 2.1583333333333, 1.6, 0.45833333333333
46542, 2.1375, 1.62, 0.45833333333333
46543, 2.1583333333333, 1.62, 0.4375
46544, 2.1583333333333, 1.64, 0.45833333333333
46545, 2.1375, 1.66, 0.45833333333333
46546, 2.1583333333333, 1.66, 0.4375
46547, 2.1583333333333, 1.68, 0.45833333333333
46548, 2.1791666666667, 1.54, 0.45833333333333
46549, 2.1791666666667, 1.58, 0.45833333333333
46550, 2.1791666666667, 1.62, 0.45833333333333
46551, 2.1791666666667, 1.66, 0.45833333333333
46552, 1.2416666666667, 1.54, 0.47916666666667
46553, 1.2416666666667, 1.58, 0.47916666666667
46554, 1.2416666666667, 1.62, 0.47916666666667
46555, 1.2416666666667, 1.66, 0.47916666666667
46556, 1.2833333333333, 1.54, 0.47916666666667
46557, 1.2833333333333, 1.58, 0.47916666666667
46558, 1.2833333333333, 1.62, 0.47916666666667
46559, 1.2833333333333, 1.66, 0.47916666666667
46560, 1.325, 1.54, 0.47916666666667
46561, 1.325, 1.58, 0.47916666666667
46562, 1.325, 1.62, 0.47916666666667
46563, 1.325, 1.66, 0.47916666666667
46564, 1.3666666666667, 1.54, 0.47916666666667
46565, 1.3666666666667, 1.58, 0.47916666666667
46566, 1.3666666666667, 1.62, 0.47916666666667
46567, 1.3666666666667, 1.66, 0.47916666666667
46568, 1.4083333333333, 1.54, 0.47916666666667
46569, 1.4083333333333, 1.58, 0.47916666666667
46570, 1.4083333333333, 1.62, 0.47916666666667
46571, 1.4083333333333, 1.66, 0.47916666666667
46572, 1.45, 1.54, 0.47916666666667
46573, 1.45, 1.58, 0.47916666666667
46574, 1.45, 1.62, 0.47916666666667
46575, 1.45, 1.66, 0.47916666666667
46576, 1.4916666666667, 1.54, 0.47916666666667
46577, 1.4916666666667, 1.58, 0.47916666666667
46578, 1.4916666666667, 1.62, 0.47916666666667
46579, 1.4916666666667, 1.66, 0.47916666666667
46580, 1.5333333333333, 1.54, 0.47916666666667
46581, 1.5333333333333, 1.58, 0.47916666666667
46582, 1.5333333333333, 1.62, 0.47916666666667
46583, 1.5333333333333, 1.66, 0.47916666666667
46584, 1.575, 1.54, 0.47916666666667
46585, 1.575, 1.58, 0.47916666666667
46586, 1.575, 1.62, 0.47916666666667
46587, 1.575, 1.66, 0.47916666666667
46588, 1.6166666666667, 1.54, 0.47916666666667
46589, 1.6166666666667, 1.58, 0.47916666666667
46590, 1.6166666666667, 1.62, 0.47916666666667
46591, 1.6166666666667, 1.66, 0.47916666666667
46592, 1.6583333333333, 1.54, 0.47916666666667
46593, 1.6583333333333, 1.58, 0.47916666666667
46594, 1.6583333333333, 1.62, 0.47916666666667
46595, 1.6583333333333, 1.66, 0.47916666666667
46596, 1.7, 1.54, 0.47916666666667
46597, 1.7, 1.58, 0.47916666666667
46598, 1.7, 1.62, 0.47916666666667
46599, 1.7, 1.66, 0.47916666666667
46600, 1.7416666666667, 1.54, 0.47916666666667
46601, 1.7416666666667, 1.58, 0.47916666666667
46602, 1.7416666666667, 1.62, 0.47916666666667
46603, 1.7416666666667, 1.66, 0.47916666666667
46604, 1.7833333333333, 1.54, 0.47916666666667
46605, 1.7833333333333, 1.58, 0.47916666666667
46606, 1.7833333333333, 1.62, 0.47916666666667
46607, 1.7833333333333, 1.66, 0.47916666666667
46608, 1.825, 1.54, 0.47916666666667
46609, 1.825, 1.58, 0.47916666666667
46610, 1.825, 1.62, 0.47916666666667
46611, 1.825, 1.66, 0.47916666666667
46612, 1.8666666666667, 1.54, 0.47916666666667
46613, 1.8666666666667, 1.58, 0.47916666666667
46614, 1.8666666666667, 1.62, 0.47916666666667
46615, 1.8666666666667, 1.66, 0.47916666666667
46616, 1.9083333333333, 1.54, 0.47916666666667
46617, 1.9083333333333, 1.58, 0.47916666666667
46618, 1.9083333333333, 1.62, 0.47916666666667
46619, 1.9083333333333, 1.66, 0.47916666666667
46620, 1.95, 1.54, 0.47916666666667
46621, 1.95, 1.58, 0.47916666666667
46622, 1.95, 1.62, 0.47916666666667
46623, 1.95, 1.66, 0.47916666666667
46624, 1.9916666666667, 1.54, 0.47916666666667
46625, 1.9916666666667, 1.58, 0.47916666666667
46626, 1.9916666666667, 1.62, 0.47916666666667
46627, 1.9916666666667, 1.66, 0.47916666666667
46628, 2.0333333333333, 1.54, 0.47916666666667
46629, 2.0333333333333, 1.58, 0.47916666666667
46630, 2.0333333333333, 1.62, 0.47916666666667
46631, 2.0333333333333, 1.66, 0.47916666666667
46632, 2.075, 1.54, 0.47916666666667
46633, 2.075, 1.58, 0.47916666666667
46634, 2.075, 1.62, 0.47916666666667
46635, 2.075, 1.66, 0.47916666666667
46636, 2.1166666666667, 1.54, 0.47916666666667
46637, 2.1166666666667, 1.58, 0.47916666666667
46638, 2.1166666666667, 1.62, 0.47916666666667
46639, 2.1166666666667, 1.66, 0.47916666666667
46640, 2.1583333333333, 1.54, 0.47916666666667
46641, 2.1583333333333, 1.58, 0.47916666666667
46642, 2.1583333333333, 1.62, 0.47916666666667
46643, 2.1583333333333, 1.66, 0.47916666666667
46644, 0.041666666666667, -0.04, 0.041666666666667
46645, 0.041666666666667, -0.08, 0.041666666666667
46646, 0.041666666666667, -0.12, 0.041666666666667
46647, 0.041666666666667, -0.16, 0.041666666666667
46648, 0.041666666666667, -0.04, 0.083333333333333
46649, 0.041666666666667, -0.08, 0.083333333333333
46650, 0.041666666666667, -0.12, 0.083333333333333
46651, 0.041666666666667, -0.16, 0.083333333333333
46652, 0.041666666666667, -0.04, 0.125
46653, 0.041666666666667, -0.08, 0.125
46654, 0.041666666666667, -0.12, 0.125
46655, 0.041666666666667, -0.16, 0.125
46656, 0.041666666666667, -0.04, 0.16666666666667
46657, 0.041666666666667, -0.08, 0.16666666666667
46658, 0.041666666666667, -0.12, 0.16666666666667
46659, 0.041666666666667, -0.16, 0.16666666666667
46660, 0.041666666666667, -0.04, 0.20833333333333
46661, 0.041666666666667, -0.08, 0.20833333333333
46662, 0.041666666666667, -0.12, 0.20833333333333
46663, 0.041666666666667, -0.16, 0.20833333333333
46664, 0.041666666666667, -0.04, 0.25
46665, 0.041666666666667, -0.08, 0.25
46666, 0.041666666666667, -0.12, 0.25
46667, 0.041666666666667, -0.16, 0.25
46668, 0.041666666666667, -0.04, 0.29166666666667
46669, 0.041666666666667, -0.08, 0.29166666666667
46670, 0.041666666666667, -0.12, 0.29166666666667
46671, 0.041666666666667, -0.16, 0.29166666666667
46672, 0.041666666666667, -0.04, 0.33333333333333
46673, 0.041666666666667, -0.08, 0.33333333333333
46674, 0.041666666666667, -0.12, 0.33333333333333
46675, 0.041666666666667, -0.16, 0.33333333333333
46676, 0.041666666666667, -0.04, 0.375
46677, 0.041666666666667, -0.08, 0.375
46678, 0.041666666666667, -0.12, 0.375
46679, 0.041666666666667, -0.16, 0.375
46680, 0.041666666666667, -0.04, 0.41666666666667
46681, 0.041666666666667, -0.08, 0.41666666666667
46682, 0.041666666666667, -0.12, 0.41666666666667
46683, 0.041666666666667, -0.16, 0.41666666666667
46684, 0.041666666666667, -0.04, 0.45833333333333
46685, 0.041666666666667, -0.08, 0.45833333333333
46686, 0.041666666666667, -0.12, 0.45833333333333
46687, 0.041666666666667, -0.16, 0.45833333333333
46688, 0.083333333333333, -0.04, 0.041666666666667
46689, 0.083333333333333, -0.08, 0.041666666666667
46690, 0.083333333333333, -0.12, 0.041666666666667
46691, 0.083333333333333, -0.16, 0.041666666666667
46692, 0.083333333333333, -0.04, 0.083333333333333
46693, 0.083333333333333, -0.08, 0.083333333333333
46694, 0.083333333333333, -0.12, 0.083333333333333
46695, 0.083333333333333, -0.16, 0.083333333333333
46696, 0.083333333333333, -0.04, 0.125
46697, 0.083333333333333, -0.08, 0.125
46698, 0.083333333333333, -0.12, 0.125
46699, 0.083333333333333, -0.16, 0.125
46700, 0.083333333333333, -0.04, 0.16666666666667
46701, 0.083333333333333, -0.08, 0.16666666666667
46702, 0.083333333333333, -0.12, 0.16666666666667
46703, 0.083333333333333, -0.16, 0.16666666666667
46704, 0.083333333333333, -0.04, 0.20833333333333
46705, 0.083333333333333, -0.08, 0.20833333333333
46706, 0.083333333333333, -0.12, 0.20833333333333
46707, 0.083333333333333, -0.16, 0.20833333333333
46708, 0.083333333333333, -0.04, 0.25
46709, 0.083333333333333, -0.08, 0.25
46710, 0.083333333333333, -0.12, 0.25
46711, 0.083333333333333, -0.16, 0.25
46712, 0.083333333333333, -0.04, 0.29166666666667
46713, 0.083333333333333, -0.08, 0.29166666666667
46714, 0.083333333333333, -0.12, 0.29166666666667
46715, 0.083333333333333, -0.16, 0.29166666666667
46716, 0.083333333333333, -0.04, 0.33333333333333
46717, 0.083333333333333, -0.08, 0.33333333333333
46718, 0.083333333333333, -0.12, 0.33333333333333
46719, 0.083333333333333, -0.16, 0.33333333333333
46720, 0.083333333333333, -0.04, 0.375
46721, 0.083333333333333, -0.08, 0.375
46722, 0.083333333333333, -0.12, 0.375
46723, 0.083333333333333, -0.16, 0.375
46724, 0.083333333333333, -0.04, 0.41666666666667
46725, 0.083333333333333, -0.08, 0.41666666666667
46726, 0.083333333333333, -0.12, 0.41666666666667
46727, 0.083333333333333, -0.16, 0.41666666666667
46728, 0.083333333333333, -0.04, 0.45833333333333
46729, 0.083333333333333, -0.08, 0.45833333333333
46730, 0.083333333333333, -0.12, 0.45833333333333
46731, 0.083333333333333, -0.16, 0.45833333333333
46732, 0.125, -0.04, 0.041666666666667
46733, 0.125, -0.08, 0.041666666666667
46734, 0.125, -0.12, 0.041666666666667
46735, 0.125, -0.16, 0.041666666666667
46736, 0.125, -0.04, 0.083333333333333
46737, 0.125, -0.08, 0.083333333333333
46738, 0.125, -0.12, 0.083333333333333
46739, 0.125, -0.16, 0.083333333333333
46740, 0.125, -0.04, 0.125
46741, 0.125, -0.08, 0.125
46742, 0.125, -0.12, 0.125
46743, 0.125, -0.16, 0.125
46744, 0.125, -0.04, 0.16666666666667
46745, 0.125, -0.08, 0.16666666666667
46746, 0.125, -0.12, 0.16666666666667
46747, 0.125, -0.16, 0.16666666666667
46748, 0.125, -0.04, 0.20833333333333
46749, 0.125, -0.08, 0.20833333333333
46750, 0.125, -0.12, 0.20833333333333
46751, 0.125, -0.16, 0.20833333333333
46752, 0.125, -0.04, 0.25
46753, 0.125, -0.08, 0.25
46754, 0.125, -0.12, 0.25
46755, 0.125, -0.16, 0.25
46756, 0.125, -0.04, 0.29166666666667
46757, 0.125, -0.08, 0.29166666666667
46758, 0.125, -0.12, 0.29166666666667
46759, 0.125, -0.16, 0.29166666666667
46760, 0.125, -0.04, 0.33333333333333
46761, 0.125, -0.08, 0.33333333333333
46762, 0.125, -0.12, 0.33333333333333
46763, 0.125, -0.16, 0.33333333333333
46764, 0.125, -0.04, 0.375
46765, 0.125, -0.08, 0.375
46766, 0.125, -0.12, 0.375
46767, 0.125, -0.16, 0.375
46768, 0.125, -0.04, 0.41666666666667
46769, 0.125, -0.08, 0.41666666666667
46770, 0.125, -0.12, 0.41666666666667
46771, 0.125, -0.16, 0.41666666666667
46772, 0.125, -0.04, 0.45833333333333
46773, 0.125, -0.08, 0.45833333333333
46774, 0.125, -0.12, 0.45833333333333
46775, 0.125, -0.16, 0.45833333333333
46776, 0.16666666666667, -0.04, 0.041666666666667
46777, 0.16666666666667, -0.08, 0.041666666666667
46778, 0.16666666666667, -0.12, 0.041666666666667
46779, 0.16666666666667, -0.16, 0.041666666666667
46780, 0.16666666666667, -0.04, 0.083333333333333
46781, 0.16666666666667, -0.08, 0.083333333333333
46782, 0.16666666666667, -0.12, 0.083333333333333
46783, 0.16666666666667, -0.16, 0.083333333333333
46784, 0.16666666666667, -0.04, 0.125
46785, 0.16666666666667, -0.08, 0.125
46786, 0.16666666666667, -0.12, 0.125
46787, 0.16666666666667, -0.16, 0.125
46788, 0.16666666666667, -0.04, 0.16666666666667
46789, 0.16666666666667, -0.08, 0.16666666666667
46790, 0.16666666666667, -0.12, 0.16666666666667
46791, 0.16666666666667, -0.16, 0.16666666666667
46792, 0.16666666666667, -0.04, 0.20833333333333
46793, 0.16666666666667, -0.08, 0.20833333333333
46794, 0.16666666666667, -0.12, 0.20833333333333
46795, 0.16666666666667, -0.16, 0.20833333333333
46796, 0.16666666666667, -0.04, 0.25
46797, 0.16666666666667, -0.08, 0.25
46798, 0.16666666666667, -0.12, 0.25
46799, 0.16666666666667, -0.16, 0.25
46800, 0.16666666666667, -0.04, 0.29166666666667
46801, 0.16666666666667, -0.08, 0.29166666666667
46802, 0.16666666666667, -0.12, 0.29166666666667
46803, 0.16666666666667, -0.16, 0.29166666666667
46804, 0.16666666666667, -0.04, 0.33333333333333
46805, 0.16666666666667, -0.08, 0.33333333333333
46806, 0.16666666666667, -0.12, 0.33333333333333
46807, 0.16666666666667, -0.16, 0.33333333333333
46808, 0.16666666666667, -0.04, 0.375
46809, 0.16666666666667, -0.08, 0.375
46810, 0.16666666666667, -0.12, 0.375
46811, 0.16666666666667, -0.16, 0.375
46812, 0.16666666666667, -0.04, 0.41666666666667
46813, 0.16666666666667, -0.08, 0.41666666666667
46814, 0.16666666666667, -0.12, 0.41666666666667
46815, 0.16666666666667, -0.16, 0.41666666666667
46816, 0.16666666666667, -0.04, 0.45833333333333
46817, 0.16666666666667, -0.08, 0.45833333333333
46818, 0.16666666666667, -0.12, 0.45833333333333
46819, 0.16666666666667, -0.16, 0.45833333333333
46820, 0.20833333333333, -0.04, 0.041666666666667
46821, 0.20833333333333, -0.08, 0.041666666666667
46822, 0.20833333333333, -0.12, 0.041666666666667
46823, 0.20833333333333, -0.16, 0.041666666666667
46824, 0.20833333333333, -0.04, 0.083333333333333
46825, 0.20833333333333, -0.08, 0.083333333333333
46826, 0.20833333333333, -0.12, 0.083333333333333
46827, 0.20833333333333, -0.16, 0.083333333333333
46828, 0.20833333333333, -0.04, 0.125
46829, 0.20833333333333, -0.08, 0.125
46830, 0.20833333333333, -0.12, 0.125
46831, 0.20833333333333, -0.16, 0.125
46832, 0.20833333333333, -0.04, 0.16666666666667
46833, 0.20833333333333, -0.08, 0.16666666666667
46834, 0.20833333333333, -0.12, 0.16666666666667
46835, 0.20833333333333, -0.16, 0.16666666666667
46836, 0.20833333333333, -0.04, 0.20833333333333
46837, 0.20833333333333, -0.08, 0.20833333333333
46838, 0.20833333333333, -0.12, 0.20833333333333
46839, 0.20833333333333, -0.16, 0.20833333333333
46840, 0.20833333333333, -0.04, 0.25
46841, 0.20833333333333, -0.08, 0.25
46842, 0.20833333333333, -0.12, 0.25
46843, 0.20833333333333, -0.16, 0.25
46844, 0.20833333333333, -0.04, 0.29166666666667
46845, 0.20833333333333, -0.08, 0.29166666666667
46846, 0.20833333333333, -0.12, 0.29166666666667
46847, 0.20833333333333, -0.16, 0.29166666666667
46848, 0.20833333333333, -0.04, 0.33333333333333
46849, 0.20833333333333, -0.08, 0.33333333333333
46850, 0.20833333333333, -0.12, 0.33333333333333
46851, 0.20833333333333, -0.16, 0.33333333333333
46852, 0.20833333333333, -0.04, 0.375
46853, 0.20833333333333, -0.08, 0.375
46854, 0.20833333333333, -0.12, 0.375
46855, 0.20833333333333, -0.16, 0.375
46856, 0.20833333333333, -0.04, 0.41666666666667
46857, 0.20833333333333, -0.08, 0.41666666666667
46858, 0.20833333333333, -0.12, 0.41666666666667
46859, 0.20833333333333, -0.16, 0.41666666666667
46860, 0.20833333333333, -0.04, 0.45833333333333
46861, 0.20833333333333, -0.08, 0.45833333333333
46862, 0.20833333333333, -0.12, 0.45833333333333
46863, 0.20833333333333, -0.16, 0.45833333333333
46864, 0.25, -0.04, 0.041666666666667
46865, 0.25, -0.08, 0.041666666666667
46866, 0.25, -0.12, 0.041666666666667
46867, 0.25, -0.16, 0.041666666666667
46868, 0.25, -0.04, 0.083333333333333
46869, 0.25, -0.08, 0.083333333333333
46870, 0.25, -0.12, 0.083333333333333
46871, 0.25, -0.16, 0.083333333333333
46872, 0.25, -0.04, 0.125
46873, 0.25, -0.08, 0.125
46874, 0.25, -0.12, 0.125
46875, 0.25, -0.16, 0.125
46876, 0.25, -0.04, 0.16666666666667
46877, 0.25, -0.08, 0.16666666666667
46878, 0.25, -0.12, 0.16666666666667
46879, 0.25, -0.16, 0.16666666666667
46880, 0.25, -0.04, 0.20833333333333
46881, 0.25, -0.08, 0.20833333333333
46882, 0.25, -0.12, 0.20833333333333
46883, 0.25, -0.16, 0.20833333333333
46884, 0.25, -0.04, 0.25
46885, 0.25, -0.08, 0.25
46886, 0.25, -0.12, 0.25
46887, 0.25, -0.16, 0.25
46888, 0.25, -0.04, 0.29166666666667
46889, 0.25, -0.08, 0.29166666666667
46890, 0.25, -0.12, 0.29166666666667
46891, 0.25, -0.16, 0.29166666666667
46892, 0.25, -0.04, 0.33333333333333
46893, 0.25, -0.08, 0.33333333333333
46894, 0.25, -0.12, 0.33333333333333
46895, 0.25, -0.16, 0.33333333333333
46896, 0.25, -0.04, 0.375
46897, 0.25, -0.08, 0.375
46898, 0.25, -0.12, 0.375
46899, 0.25, -0.16, 0.375
46900, 0.25, -0.04, 0.41666666666667
46901, 0.25, -0.08, 0.41666666666667
46902, 0.25, -0.12, 0.41666666666667
46903, 0.25, -0.16, 0.41666666666667
46904, 0.25, -0.04, 0.45833333333333
46905, 0.25, -0.08, 0.45833333333333
46906, 0.25, -0.12, 0.45833333333333
46907, 0.25, -0.16, 0.45833333333333
46908, 0.29166666666667, -0.04, 0.041666666666667
46909, 0.29166666666667, -0.08, 0.041666666666667
46910, 0.29166666666667, -0.12, 0.041666666666667
46911, 0.29166666666667, -0.16, 0.041666666666667
46912, 0.29166666666667, -0.04, 0.083333333333333
46913, 0.29166666666667, -0.08, 0.083333333333333
46914, 0.29166666666667, -0.12, 0.083333333333333
46915, 0.29166666666667, -0.16, 0.083333333333333
46916, 0.29166666666667, -0.04, 0.125
46917, 0.29166666666667, -0.08, 0.125
46918, 0.29166666666667, -0.12, 0.125
46919, 0.29166666666667, -0.16, 0.125
46920, 0.29166666666667, -0.04, 0.16666666666667
46921, 0.29166666666667, -0.08, 0.16666666666667
46922, 0.29166666666667, -0.12, 0.16666666666667
46923, 0.29166666666667, -0.16, 0.16666666666667
46924, 0.29166666666667, -0.04, 0.20833333333333
46925, 0.29166666666667, -0.08, 0.20833333333333
46926, 0.29166666666667, -0.12, 0.20833333333333
46927, 0.29166666666667, -0.16, 0.20833333333333
46928, 0.29166666666667, -0.04, 0.25
46929, 0.29166666666667, -0.08, 0.25
46930, 0.29166666666667, -0.12, 0.25
46931, 0.29166666666667, -0.16, 0.25
46932, 0.29166666666667, -0.04, 0.29166666666667
46933, 0.29166666666667, -0.08, 0.29166666666667
46934, 0.29166666666667, -0.12, 0.29166666666667
46935, 0.29166666666667, -0.16, 0.29166666666667
46936, 0.29166666666667, -0.04, 0.33333333333333
46937, 0.29166666666667, -0.08, 0.33333333333333
46938, 0.29166666666667, -0.12, 0.33333333333333
46939, 0.29166666666667, -0.16, 0.33333333333333
46940, 0.29166666666667, -0.04, 0.375
46941, 0.29166666666667, -0.08, 0.375
46942, 0.29166666666667, -0.12, 0.375
46943, 0.29166666666667, -0.16, 0.375
46944, 0.29166666666667, -0.04, 0.41666666666667
46945, 0.29166666666667, -0.08, 0.41666666666667
46946, 0.29166666666667, -0.12, 0.41666666666667
46947, 0.29166666666667, -0.16, 0.41666666666667
46948, 0.29166666666667, -0.04, 0.45833333333333
46949, 0.29166666666667, -0.08, 0.45833333333333
46950, 0.29166666666667, -0.12, 0.45833333333333
46951, 0.29166666666667, -0.16, 0.45833333333333
46952, 0.33333333333333, -0.04, 0.041666666666667
46953, 0.33333333333333, -0.08, 0.041666666666667
46954, 0.33333333333333, -0.12, 0.041666666666667
46955, 0.33333333333333, -0.16, 0.041666666666667
46956, 0.33333333333333, -0.04, 0.083333333333333
46957, 0.33333333333333, -0.08, 0.083333333333333
46958, 0.33333333333333, -0.12, 0.083333333333333
46959, 0.33333333333333, -0.16, 0.083333333333333
46960, 0.33333333333333, -0.04, 0.125
46961, 0.33333333333333, -0.08, 0.125
46962, 0.33333333333333, -0.12, 0.125
46963, 0.33333333333333, -0.16, 0.125
46964, 0.33333333333333, -0.04, 0.16666666666667
46965, 0.33333333333333, -0.08, 0.16666666666667
46966, 0.33333333333333, -0.12, 0.16666666666667
46967, 0.33333333333333, -0.16, 0.16666666666667
46968, 0.33333333333333, -0.04, 0.20833333333333
46969, 0.33333333333333, -0.08, 0.20833333333333
46970, 0.33333333333333, -0.12, 0.20833333333333
46971, 0.33333333333333, -0.16, 0.20833333333333
46972, 0.33333333333333, -0.04, 0.25
46973, 0.33333333333333, -0.08, 0.25
46974, 0.33333333333333, -0.12, 0.25
46975, 0.33333333333333, -0.16, 0.25
46976, 0.33333333333333, -0.04, 0.29166666666667
46977, 0.33333333333333, -0.08, 0.29166666666667
46978, 0.33333333333333, -0.12, 0.29166666666667
46979, 0.33333333333333, -0.16, 0.29166666666667
46980, 0.33333333333333, -0.04, 0.33333333333333
46981, 0.33333333333333, -0.08, 0.33333333333333
46982, 0.33333333333333, -0.12, 0.33333333333333
46983, 0.33333333333333, -0.16, 0.33333333333333
46984, 0.33333333333333, -0.04, 0.375
46985, 0.33333333333333, -0.08, 0.375
46986, 0.33333333333333, -0.12, 0.375
46987, 0.33333333333333, -0.16, 0.375
46988, 0.33333333333333, -0.04, 0.41666666666667
46989, 0.33333333333333, -0.08, 0.41666666666667
46990, 0.33333333333333, -0.12, 0.41666666666667
46991, 0.33333333333333, -0.16, 0.41666666666667
46992, 0.33333333333333, -0.04, 0.45833333333333
46993, 0.33333333333333, -0.08, 0.45833333333333
46994, 0.33333333333333, -0.12, 0.45833333333333
46995, 0.33333333333333, -0.16, 0.45833333333333
46996, 0.375, -0.04, 0.041666666666667
46997, 0.375, -0.08, 0.041666666666667
46998, 0.375, -0.12, 0.041666666666667
46999, 0.375, -0.16, 0.041666666666667
47000, 0.375, -0.04, 0.083333333333333
47001, 0.375, -0.08, 0.083333333333333
47002, 0.375, -0.12, 0.083333333333333
47003, 0.375, -0.16, 0.083333333333333
47004, 0.375, -0.04, 0.125
47005, 0.375, -0.08, 0.125
47006, 0.375, -0.12, 0.125
47007, 0.375, -0.16, 0.125
47008, 0.375, -0.04, 0.16666666666667
47009, 0.375, -0.08, 0.16666666666667
47010, 0.375, -0.12, 0.16666666666667
47011, 0.375, -0.16, 0.16666666666667
47012, 0.375, -0.04, 0.20833333333333
47013, 0.375, -0.08, 0.20833333333333
47014, 0.375, -0.12, 0.20833333333333
47015, 0.375, -0.16, 0.20833333333333
47016, 0.375, -0.04, 0.25
47017, 0.375, -0.08, 0.25
47018, 0.375, -0.12, 0.25
47019, 0.375, -0.16, 0.25
47020, 0.375, -0.04, 0.29166666666667
47021, 0.375, -0.08, 0.29166666666667
47022, 0.375, -0.12, 0.29166666666667
47023, 0.375, -0.16, 0.29166666666667
47024, 0.375, -0.04, 0.33333333333333
47025, 0.375, -0.08, 0.33333333333333
47026, 0.375, -0.12, 0.33333333333333
47027, 0.375, -0.16, 0.33333333333333
47028, 0.375, -0.04, 0.375
47029, 0.375, -0.08, 0.375
47030, 0.375, -0.12, 0.375
47031, 0.375, -0.16, 0.375
47032, 0.375, -0.04, 0.41666666666667
47033, 0.375, -0.08, 0.41666666666667
47034, 0.375, -0.12, 0.41666666666667
47035, 0.375, -0.16, 0.41666666666667
47036, 0.375, -0.04, 0.45833333333333
47037, 0.375, -0.08, 0.45833333333333
47038, 0.375, -0.12, 0.45833333333333
47039, 0.375, -0.16, 0.45833333333333
47040, 0.41666666666667, -0.04, 0.041666666666667
47041, 0.41666666666667, -0.08, 0.041666666666667
47042, 0.41666666666667, -0.12, 0.041666666666667
47043, 0.41666666666667, -0.16, 0.041666666666667
47044, 0.41666666666667, -0.04, 0.083333333333333
47045, 0.41666666666667, -0.08, 0.083333333333333
47046, 0.41666666666667, -0.12, 0.083333333333333
47047, 0.41666666666667, -0.16, 0.083333333333333
47048, 0.41666666666667, -0.04, 0.125
47049, 0.41666666666667, -0.08, 0.125
47050, 0.41666666666667, -0.12, 0.125
47051, 0.41666666666667, -0.16, 0.125
47052, 0.41666666666667, -0.04, 0.16666666666667
47053, 0.41666666666667, -0.08, 0.16666666666667
47054, 0.41666666666667, -0.12, 0.16666666666667
47055, 0.41666666666667, -0.16, 0.16666666666667
47056, 0.41666666666667, -0.04, 0.20833333333333
47057, 0.41666666666667, -0.08, 0.20833333333333
47058, 0.41666666666667, -0.12, 0.20833333333333
47059, 0.41666666666667, -0.16, 0.20833333333333
47060, 0.41666666666667, -0.04, 0.25
47061, 0.41666666666667, -0.08, 0.25
47062, 0.41666666666667, -0.12, 0.25
47063, 0.41666666666667, -0.16, 0.25
47064, 0.41666666666667, -0.04, 0.29166666666667
47065, 0.41666666666667, -0.08, 0.29166666666667
47066, 0.41666666666667, -0.12, 0.29166666666667
47067, 0.41666666666667, -0.16, 0.29166666666667
47068, 0.41666666666667, -0.04, 0.33333333333333
47069, 0.41666666666667, -0.08, 0.33333333333333
47070, 0.41666666666667, -0.12, 0.33333333333333
47071, 0.41666666666667, -0.16, 0.33333333333333
47072, 0.41666666666667, -0.04, 0.375
47073, 0.41666666666667, -0.08, 0.375
47074, 0.41666666666667, -0.12, 0.375
47075, 0.41666666666667, -0.16, 0.375
47076, 0.41666666666667, -0.04, 0.41666666666667
47077, 0.41666666666667, -0.08, 0.41666666666667
47078, 0.41666666666667, -0.12, 0.41666666666667
47079, 0.41666666666667, -0.16, 0.41666666666667
47080, 0.41666666666667, -0.04, 0.45833333333333
47081, 0.41666666666667, -0.08, 0.45833333333333
47082, 0.41666666666667, -0.12, 0.45833333333333
47083, 0.41666666666667, -0.16, 0.45833333333333
47084, 0.45833333333333, -0.04, 0.041666666666667
47085, 0.45833333333333, -0.08, 0.041666666666667
47086, 0.45833333333333, -0.12, 0.041666666666667
