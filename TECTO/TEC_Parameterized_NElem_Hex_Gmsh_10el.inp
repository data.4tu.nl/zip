20618, 30661, 30684, 31213, 31190, 30662, 30685, 31214, 31191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20619, 30662, 30685, 31214, 31191, 30663, 30686, 31215, 31192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20620, 30663, 30686, 31215, 31192, 30664, 30687, 31216, 31193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20621, 30664, 30687, 31216, 31193, 30665, 30688, 31217, 31194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20622, 30665, 30688, 31217, 31194, 30666, 30689, 31218, 31195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20623, 30666, 30689, 31218, 31195, 30667, 30690, 31219, 31196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20624, 30667, 30690, 31219, 31196, 30668, 30691, 31220, 31197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20625, 30668, 30691, 31220, 31197, 30669, 30692, 31221, 31198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20626, 30669, 30692, 31221, 31198, 30670, 30693, 31222, 31199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20627, 30670, 30693, 31222, 31199, 30671, 30694, 31223, 31200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20628, 30671, 30694, 31223, 31200, 30672, 30695, 31224, 31201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20629, 30672, 30695, 31224, 31201, 30673, 30696, 31225, 31202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20630, 30673, 30696, 31225, 31202, 30674, 30697, 31226, 31203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20631, 30674, 30697, 31226, 31203, 30675, 30698, 31227, 31204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20632, 30675, 30698, 31227, 31204, 30676, 30699, 31228, 31205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20633, 30676, 30699, 31228, 31205, 30677, 30700, 31229, 31206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20634, 30677, 30700, 31229, 31206, 30678, 30701, 31230, 31207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20635, 30678, 30701, 31230, 31207, 30679, 30702, 31231, 31208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20636, 30679, 30702, 31231, 31208, 30680, 30703, 31232, 31209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20637, 30680, 30703, 31232, 31209, 8488, 8489, 8512, 8511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20638, 6672, 6673, 6696, 6695, 30681, 30704, 31233, 31210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20639, 30681, 30704, 31233, 31210, 30682, 30705, 31234, 31211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20640, 30682, 30705, 31234, 31211, 30683, 30706, 31235, 31212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20641, 30683, 30706, 31235, 31212, 30684, 30707, 31236, 31213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20642, 30684, 30707, 31236, 31213, 30685, 30708, 31237, 31214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20643, 30685, 30708, 31237, 31214, 30686, 30709, 31238, 31215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20644, 30686, 30709, 31238, 31215, 30687, 30710, 31239, 31216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20645, 30687, 30710, 31239, 31216, 30688, 30711, 31240, 31217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20646, 30688, 30711, 31240, 31217, 30689, 30712, 31241, 31218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20647, 30689, 30712, 31241, 31218, 30690, 30713, 31242, 31219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20648, 30690, 30713, 31242, 31219, 30691, 30714, 31243, 31220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20649, 30691, 30714, 31243, 31220, 30692, 30715, 31244, 31221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20650, 30692, 30715, 31244, 31221, 30693, 30716, 31245, 31222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20651, 30693, 30716, 31245, 31222, 30694, 30717, 31246, 31223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20652, 30694, 30717, 31246, 31223, 30695, 30718, 31247, 31224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20653, 30695, 30718, 31247, 31224, 30696, 30719, 31248, 31225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20654, 30696, 30719, 31248, 31225, 30697, 30720, 31249, 31226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20655, 30697, 30720, 31249, 31226, 30698, 30721, 31250, 31227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20656, 30698, 30721, 31250, 31227, 30699, 30722, 31251, 31228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20657, 30699, 30722, 31251, 31228, 30700, 30723, 31252, 31229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20658, 30700, 30723, 31252, 31229, 30701, 30724, 31253, 31230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20659, 30701, 30724, 31253, 31230, 30702, 30725, 31254, 31231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20660, 30702, 30725, 31254, 31231, 30703, 30726, 31255, 31232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20661, 30703, 30726, 31255, 31232, 8489, 8490, 8513, 8512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20662, 6673, 6674, 6697, 6696, 30704, 30727, 31256, 31233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20663, 30704, 30727, 31256, 31233, 30705, 30728, 31257, 31234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20664, 30705, 30728, 31257, 31234, 30706, 30729, 31258, 31235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20665, 30706, 30729, 31258, 31235, 30707, 30730, 31259, 31236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20666, 30707, 30730, 31259, 31236, 30708, 30731, 31260, 31237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20667, 30708, 30731, 31260, 31237, 30709, 30732, 31261, 31238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20668, 30709, 30732, 31261, 31238, 30710, 30733, 31262, 31239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20669, 30710, 30733, 31262, 31239, 30711, 30734, 31263, 31240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20670, 30711, 30734, 31263, 31240, 30712, 30735, 31264, 31241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20671, 30712, 30735, 31264, 31241, 30713, 30736, 31265, 31242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20672, 30713, 30736, 31265, 31242, 30714, 30737, 31266, 31243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20673, 30714, 30737, 31266, 31243, 30715, 30738, 31267, 31244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20674, 30715, 30738, 31267, 31244, 30716, 30739, 31268, 31245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20675, 30716, 30739, 31268, 31245, 30717, 30740, 31269, 31246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20676, 30717, 30740, 31269, 31246, 30718, 30741, 31270, 31247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20677, 30718, 30741, 31270, 31247, 30719, 30742, 31271, 31248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20678, 30719, 30742, 31271, 31248, 30720, 30743, 31272, 31249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20679, 30720, 30743, 31272, 31249, 30721, 30744, 31273, 31250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20680, 30721, 30744, 31273, 31250, 30722, 30745, 31274, 31251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20681, 30722, 30745, 31274, 31251, 30723, 30746, 31275, 31252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20682, 30723, 30746, 31275, 31252, 30724, 30747, 31276, 31253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20683, 30724, 30747, 31276, 31253, 30725, 30748, 31277, 31254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20684, 30725, 30748, 31277, 31254, 30726, 30749, 31278, 31255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20685, 30726, 30749, 31278, 31255, 8490, 8491, 8514, 8513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20686, 6674, 6675, 6698, 6697, 30727, 30750, 31279, 31256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20687, 30727, 30750, 31279, 31256, 30728, 30751, 31280, 31257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20688, 30728, 30751, 31280, 31257, 30729, 30752, 31281, 31258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20689, 30729, 30752, 31281, 31258, 30730, 30753, 31282, 31259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20690, 30730, 30753, 31282, 31259, 30731, 30754, 31283, 31260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20691, 30731, 30754, 31283, 31260, 30732, 30755, 31284, 31261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20692, 30732, 30755, 31284, 31261, 30733, 30756, 31285, 31262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20693, 30733, 30756, 31285, 31262, 30734, 30757, 31286, 31263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20694, 30734, 30757, 31286, 31263, 30735, 30758, 31287, 31264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20695, 30735, 30758, 31287, 31264, 30736, 30759, 31288, 31265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20696, 30736, 30759, 31288, 31265, 30737, 30760, 31289, 31266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20697, 30737, 30760, 31289, 31266, 30738, 30761, 31290, 31267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20698, 30738, 30761, 31290, 31267, 30739, 30762, 31291, 31268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20699, 30739, 30762, 31291, 31268, 30740, 30763, 31292, 31269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20700, 30740, 30763, 31292, 31269, 30741, 30764, 31293, 31270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20701, 30741, 30764, 31293, 31270, 30742, 30765, 31294, 31271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20702, 30742, 30765, 31294, 31271, 30743, 30766, 31295, 31272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20703, 30743, 30766, 31295, 31272, 30744, 30767, 31296, 31273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20704, 30744, 30767, 31296, 31273, 30745, 30768, 31297, 31274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20705, 30745, 30768, 31297, 31274, 30746, 30769, 31298, 31275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20706, 30746, 30769, 31298, 31275, 30747, 30770, 31299, 31276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20707, 30747, 30770, 31299, 31276, 30748, 30771, 31300, 31277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20708, 30748, 30771, 31300, 31277, 30749, 30772, 31301, 31278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20709, 30749, 30772, 31301, 31278, 8491, 8492, 8515, 8514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20710, 6675, 6676, 6699, 6698, 30750, 30773, 31302, 31279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20711, 30750, 30773, 31302, 31279, 30751, 30774, 31303, 31280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20712, 30751, 30774, 31303, 31280, 30752, 30775, 31304, 31281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20713, 30752, 30775, 31304, 31281, 30753, 30776, 31305, 31282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20714, 30753, 30776, 31305, 31282, 30754, 30777, 31306, 31283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20715, 30754, 30777, 31306, 31283, 30755, 30778, 31307, 31284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20716, 30755, 30778, 31307, 31284, 30756, 30779, 31308, 31285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20717, 30756, 30779, 31308, 31285, 30757, 30780, 31309, 31286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20718, 30757, 30780, 31309, 31286, 30758, 30781, 31310, 31287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20719, 30758, 30781, 31310, 31287, 30759, 30782, 31311, 31288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20720, 30759, 30782, 31311, 31288, 30760, 30783, 31312, 31289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20721, 30760, 30783, 31312, 31289, 30761, 30784, 31313, 31290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20722, 30761, 30784, 31313, 31290, 30762, 30785, 31314, 31291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20723, 30762, 30785, 31314, 31291, 30763, 30786, 31315, 31292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20724, 30763, 30786, 31315, 31292, 30764, 30787, 31316, 31293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20725, 30764, 30787, 31316, 31293, 30765, 30788, 31317, 31294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20726, 30765, 30788, 31317, 31294, 30766, 30789, 31318, 31295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20727, 30766, 30789, 31318, 31295, 30767, 30790, 31319, 31296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20728, 30767, 30790, 31319, 31296, 30768, 30791, 31320, 31297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20729, 30768, 30791, 31320, 31297, 30769, 30792, 31321, 31298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20730, 30769, 30792, 31321, 31298, 30770, 30793, 31322, 31299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20731, 30770, 30793, 31322, 31299, 30771, 30794, 31323, 31300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20732, 30771, 30794, 31323, 31300, 30772, 30795, 31324, 31301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20733, 30772, 30795, 31324, 31301, 8492, 8493, 8516, 8515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20734, 6676, 6677, 6700, 6699, 30773, 30796, 31325, 31302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20735, 30773, 30796, 31325, 31302, 30774, 30797, 31326, 31303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20736, 30774, 30797, 31326, 31303, 30775, 30798, 31327, 31304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20737, 30775, 30798, 31327, 31304, 30776, 30799, 31328, 31305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20738, 30776, 30799, 31328, 31305, 30777, 30800, 31329, 31306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20739, 30777, 30800, 31329, 31306, 30778, 30801, 31330, 31307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20740, 30778, 30801, 31330, 31307, 30779, 30802, 31331, 31308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20741, 30779, 30802, 31331, 31308, 30780, 30803, 31332, 31309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20742, 30780, 30803, 31332, 31309, 30781, 30804, 31333, 31310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20743, 30781, 30804, 31333, 31310, 30782, 30805, 31334, 31311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20744, 30782, 30805, 31334, 31311, 30783, 30806, 31335, 31312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20745, 30783, 30806, 31335, 31312, 30784, 30807, 31336, 31313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20746, 30784, 30807, 31336, 31313, 30785, 30808, 31337, 31314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20747, 30785, 30808, 31337, 31314, 30786, 30809, 31338, 31315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20748, 30786, 30809, 31338, 31315, 30787, 30810, 31339, 31316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20749, 30787, 30810, 31339, 31316, 30788, 30811, 31340, 31317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20750, 30788, 30811, 31340, 31317, 30789, 30812, 31341, 31318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20751, 30789, 30812, 31341, 31318, 30790, 30813, 31342, 31319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20752, 30790, 30813, 31342, 31319, 30791, 30814, 31343, 31320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20753, 30791, 30814, 31343, 31320, 30792, 30815, 31344, 31321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20754, 30792, 30815, 31344, 31321, 30793, 30816, 31345, 31322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20755, 30793, 30816, 31345, 31322, 30794, 30817, 31346, 31323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20756, 30794, 30817, 31346, 31323, 30795, 30818, 31347, 31324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20757, 30795, 30818, 31347, 31324, 8493, 8494, 8517, 8516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20758, 6677, 6678, 6701, 6700, 30796, 30819, 31348, 31325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20759, 30796, 30819, 31348, 31325, 30797, 30820, 31349, 31326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20760, 30797, 30820, 31349, 31326, 30798, 30821, 31350, 31327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20761, 30798, 30821, 31350, 31327, 30799, 30822, 31351, 31328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20762, 30799, 30822, 31351, 31328, 30800, 30823, 31352, 31329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20763, 30800, 30823, 31352, 31329, 30801, 30824, 31353, 31330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20764, 30801, 30824, 31353, 31330, 30802, 30825, 31354, 31331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20765, 30802, 30825, 31354, 31331, 30803, 30826, 31355, 31332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20766, 30803, 30826, 31355, 31332, 30804, 30827, 31356, 31333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20767, 30804, 30827, 31356, 31333, 30805, 30828, 31357, 31334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20768, 30805, 30828, 31357, 31334, 30806, 30829, 31358, 31335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20769, 30806, 30829, 31358, 31335, 30807, 30830, 31359, 31336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20770, 30807, 30830, 31359, 31336, 30808, 30831, 31360, 31337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20771, 30808, 30831, 31360, 31337, 30809, 30832, 31361, 31338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20772, 30809, 30832, 31361, 31338, 30810, 30833, 31362, 31339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20773, 30810, 30833, 31362, 31339, 30811, 30834, 31363, 31340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20774, 30811, 30834, 31363, 31340, 30812, 30835, 31364, 31341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20775, 30812, 30835, 31364, 31341, 30813, 30836, 31365, 31342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20776, 30813, 30836, 31365, 31342, 30814, 30837, 31366, 31343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20777, 30814, 30837, 31366, 31343, 30815, 30838, 31367, 31344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20778, 30815, 30838, 31367, 31344, 30816, 30839, 31368, 31345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20779, 30816, 30839, 31368, 31345, 30817, 30840, 31369, 31346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20780, 30817, 30840, 31369, 31346, 30818, 30841, 31370, 31347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20781, 30818, 30841, 31370, 31347, 8494, 8495, 8518, 8517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20782, 6678, 6679, 6702, 6701, 30819, 30842, 31371, 31348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20783, 30819, 30842, 31371, 31348, 30820, 30843, 31372, 31349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20784, 30820, 30843, 31372, 31349, 30821, 30844, 31373, 31350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20785, 30821, 30844, 31373, 31350, 30822, 30845, 31374, 31351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20786, 30822, 30845, 31374, 31351, 30823, 30846, 31375, 31352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20787, 30823, 30846, 31375, 31352, 30824, 30847, 31376, 31353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20788, 30824, 30847, 31376, 31353, 30825, 30848, 31377, 31354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20789, 30825, 30848, 31377, 31354, 30826, 30849, 31378, 31355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20790, 30826, 30849, 31378, 31355, 30827, 30850, 31379, 31356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20791, 30827, 30850, 31379, 31356, 30828, 30851, 31380, 31357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20792, 30828, 30851, 31380, 31357, 30829, 30852, 31381, 31358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20793, 30829, 30852, 31381, 31358, 30830, 30853, 31382, 31359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20794, 30830, 30853, 31382, 31359, 30831, 30854, 31383, 31360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20795, 30831, 30854, 31383, 31360, 30832, 30855, 31384, 31361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20796, 30832, 30855, 31384, 31361, 30833, 30856, 31385, 31362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20797, 30833, 30856, 31385, 31362, 30834, 30857, 31386, 31363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20798, 30834, 30857, 31386, 31363, 30835, 30858, 31387, 31364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20799, 30835, 30858, 31387, 31364, 30836, 30859, 31388, 31365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20800, 30836, 30859, 31388, 31365, 30837, 30860, 31389, 31366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20801, 30837, 30860, 31389, 31366, 30838, 30861, 31390, 31367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20802, 30838, 30861, 31390, 31367, 30839, 30862, 31391, 31368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20803, 30839, 30862, 31391, 31368, 30840, 30863, 31392, 31369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20804, 30840, 30863, 31392, 31369, 30841, 30864, 31393, 31370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20805, 30841, 30864, 31393, 31370, 8495, 8496, 8519, 8518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20806, 6679, 6680, 6703, 6702, 30842, 30865, 31394, 31371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20807, 30842, 30865, 31394, 31371, 30843, 30866, 31395, 31372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20808, 30843, 30866, 31395, 31372, 30844, 30867, 31396, 31373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20809, 30844, 30867, 31396, 31373, 30845, 30868, 31397, 31374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20810, 30845, 30868, 31397, 31374, 30846, 30869, 31398, 31375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20811, 30846, 30869, 31398, 31375, 30847, 30870, 31399, 31376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20812, 30847, 30870, 31399, 31376, 30848, 30871, 31400, 31377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20813, 30848, 30871, 31400, 31377, 30849, 30872, 31401, 31378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20814, 30849, 30872, 31401, 31378, 30850, 30873, 31402, 31379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20815, 30850, 30873, 31402, 31379, 30851, 30874, 31403, 31380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20816, 30851, 30874, 31403, 31380, 30852, 30875, 31404, 31381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20817, 30852, 30875, 31404, 31381, 30853, 30876, 31405, 31382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20818, 30853, 30876, 31405, 31382, 30854, 30877, 31406, 31383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20819, 30854, 30877, 31406, 31383, 30855, 30878, 31407, 31384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20820, 30855, 30878, 31407, 31384, 30856, 30879, 31408, 31385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20821, 30856, 30879, 31408, 31385, 30857, 30880, 31409, 31386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20822, 30857, 30880, 31409, 31386, 30858, 30881, 31410, 31387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20823, 30858, 30881, 31410, 31387, 30859, 30882, 31411, 31388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20824, 30859, 30882, 31411, 31388, 30860, 30883, 31412, 31389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20825, 30860, 30883, 31412, 31389, 30861, 30884, 31413, 31390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20826, 30861, 30884, 31413, 31390, 30862, 30885, 31414, 31391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20827, 30862, 30885, 31414, 31391, 30863, 30886, 31415, 31392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20828, 30863, 30886, 31415, 31392, 30864, 30887, 31416, 31393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20829, 30864, 30887, 31416, 31393, 8496, 8497, 8520, 8519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20830, 6680, 6681, 6704, 6703, 30865, 30888, 31417, 31394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20831, 30865, 30888, 31417, 31394, 30866, 30889, 31418, 31395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20832, 30866, 30889, 31418, 31395, 30867, 30890, 31419, 31396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20833, 30867, 30890, 31419, 31396, 30868, 30891, 31420, 31397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20834, 30868, 30891, 31420, 31397, 30869, 30892, 31421, 31398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20835, 30869, 30892, 31421, 31398, 30870, 30893, 31422, 31399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20836, 30870, 30893, 31422, 31399, 30871, 30894, 31423, 31400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20837, 30871, 30894, 31423, 31400, 30872, 30895, 31424, 31401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20838, 30872, 30895, 31424, 31401, 30873, 30896, 31425, 31402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20839, 30873, 30896, 31425, 31402, 30874, 30897, 31426, 31403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20840, 30874, 30897, 31426, 31403, 30875, 30898, 31427, 31404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20841, 30875, 30898, 31427, 31404, 30876, 30899, 31428, 31405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20842, 30876, 30899, 31428, 31405, 30877, 30900, 31429, 31406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20843, 30877, 30900, 31429, 31406, 30878, 30901, 31430, 31407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20844, 30878, 30901, 31430, 31407, 30879, 30902, 31431, 31408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20845, 30879, 30902, 31431, 31408, 30880, 30903, 31432, 31409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20846, 30880, 30903, 31432, 31409, 30881, 30904, 31433, 31410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20847, 30881, 30904, 31433, 31410, 30882, 30905, 31434, 31411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20848, 30882, 30905, 31434, 31411, 30883, 30906, 31435, 31412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20849, 30883, 30906, 31435, 31412, 30884, 30907, 31436, 31413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20850, 30884, 30907, 31436, 31413, 30885, 30908, 31437, 31414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20851, 30885, 30908, 31437, 31414, 30886, 30909, 31438, 31415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20852, 30886, 30909, 31438, 31415, 30887, 30910, 31439, 31416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20853, 30887, 30910, 31439, 31416, 8497, 8498, 8521, 8520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20854, 6681, 6682, 6705, 6704, 30888, 30911, 31440, 31417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20855, 30888, 30911, 31440, 31417, 30889, 30912, 31441, 31418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20856, 30889, 30912, 31441, 31418, 30890, 30913, 31442, 31419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20857, 30890, 30913, 31442, 31419, 30891, 30914, 31443, 31420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20858, 30891, 30914, 31443, 31420, 30892, 30915, 31444, 31421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20859, 30892, 30915, 31444, 31421, 30893, 30916, 31445, 31422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20860, 30893, 30916, 31445, 31422, 30894, 30917, 31446, 31423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20861, 30894, 30917, 31446, 31423, 30895, 30918, 31447, 31424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20862, 30895, 30918, 31447, 31424, 30896, 30919, 31448, 31425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20863, 30896, 30919, 31448, 31425, 30897, 30920, 31449, 31426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20864, 30897, 30920, 31449, 31426, 30898, 30921, 31450, 31427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20865, 30898, 30921, 31450, 31427, 30899, 30922, 31451, 31428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20866, 30899, 30922, 31451, 31428, 30900, 30923, 31452, 31429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20867, 30900, 30923, 31452, 31429, 30901, 30924, 31453, 31430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20868, 30901, 30924, 31453, 31430, 30902, 30925, 31454, 31431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20869, 30902, 30925, 31454, 31431, 30903, 30926, 31455, 31432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20870, 30903, 30926, 31455, 31432, 30904, 30927, 31456, 31433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20871, 30904, 30927, 31456, 31433, 30905, 30928, 31457, 31434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20872, 30905, 30928, 31457, 31434, 30906, 30929, 31458, 31435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20873, 30906, 30929, 31458, 31435, 30907, 30930, 31459, 31436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20874, 30907, 30930, 31459, 31436, 30908, 30931, 31460, 31437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20875, 30908, 30931, 31460, 31437, 30909, 30932, 31461, 31438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20876, 30909, 30932, 31461, 31438, 30910, 30933, 31462, 31439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20877, 30910, 30933, 31462, 31439, 8498, 8499, 8522, 8521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20878, 6682, 6683, 6706, 6705, 30911, 30934, 31463, 31440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20879, 30911, 30934, 31463, 31440, 30912, 30935, 31464, 31441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20880, 30912, 30935, 31464, 31441, 30913, 30936, 31465, 31442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20881, 30913, 30936, 31465, 31442, 30914, 30937, 31466, 31443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20882, 30914, 30937, 31466, 31443, 30915, 30938, 31467, 31444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20883, 30915, 30938, 31467, 31444, 30916, 30939, 31468, 31445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20884, 30916, 30939, 31468, 31445, 30917, 30940, 31469, 31446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20885, 30917, 30940, 31469, 31446, 30918, 30941, 31470, 31447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20886, 30918, 30941, 31470, 31447, 30919, 30942, 31471, 31448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20887, 30919, 30942, 31471, 31448, 30920, 30943, 31472, 31449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20888, 30920, 30943, 31472, 31449, 30921, 30944, 31473, 31450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20889, 30921, 30944, 31473, 31450, 30922, 30945, 31474, 31451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20890, 30922, 30945, 31474, 31451, 30923, 30946, 31475, 31452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20891, 30923, 30946, 31475, 31452, 30924, 30947, 31476, 31453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20892, 30924, 30947, 31476, 31453, 30925, 30948, 31477, 31454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20893, 30925, 30948, 31477, 31454, 30926, 30949, 31478, 31455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20894, 30926, 30949, 31478, 31455, 30927, 30950, 31479, 31456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20895, 30927, 30950, 31479, 31456, 30928, 30951, 31480, 31457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20896, 30928, 30951, 31480, 31457, 30929, 30952, 31481, 31458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20897, 30929, 30952, 31481, 31458, 30930, 30953, 31482, 31459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20898, 30930, 30953, 31482, 31459, 30931, 30954, 31483, 31460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20899, 30931, 30954, 31483, 31460, 30932, 30955, 31484, 31461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20900, 30932, 30955, 31484, 31461, 30933, 30956, 31485, 31462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20901, 30933, 30956, 31485, 31462, 8499, 8500, 8523, 8522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20902, 6683, 6684, 6707, 6706, 30934, 30957, 31486, 31463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20903, 30934, 30957, 31486, 31463, 30935, 30958, 31487, 31464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20904, 30935, 30958, 31487, 31464, 30936, 30959, 31488, 31465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20905, 30936, 30959, 31488, 31465, 30937, 30960, 31489, 31466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20906, 30937, 30960, 31489, 31466, 30938, 30961, 31490, 31467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20907, 30938, 30961, 31490, 31467, 30939, 30962, 31491, 31468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20908, 30939, 30962, 31491, 31468, 30940, 30963, 31492, 31469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20909, 30940, 30963, 31492, 31469, 30941, 30964, 31493, 31470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20910, 30941, 30964, 31493, 31470, 30942, 30965, 31494, 31471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20911, 30942, 30965, 31494, 31471, 30943, 30966, 31495, 31472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20912, 30943, 30966, 31495, 31472, 30944, 30967, 31496, 31473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20913, 30944, 30967, 31496, 31473, 30945, 30968, 31497, 31474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20914, 30945, 30968, 31497, 31474, 30946, 30969, 31498, 31475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20915, 30946, 30969, 31498, 31475, 30947, 30970, 31499, 31476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20916, 30947, 30970, 31499, 31476, 30948, 30971, 31500, 31477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20917, 30948, 30971, 31500, 31477, 30949, 30972, 31501, 31478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20918, 30949, 30972, 31501, 31478, 30950, 30973, 31502, 31479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20919, 30950, 30973, 31502, 31479, 30951, 30974, 31503, 31480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20920, 30951, 30974, 31503, 31480, 30952, 30975, 31504, 31481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20921, 30952, 30975, 31504, 31481, 30953, 30976, 31505, 31482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20922, 30953, 30976, 31505, 31482, 30954, 30977, 31506, 31483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20923, 30954, 30977, 31506, 31483, 30955, 30978, 31507, 31484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20924, 30955, 30978, 31507, 31484, 30956, 30979, 31508, 31485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20925, 30956, 30979, 31508, 31485, 8500, 8501, 8524, 8523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20926, 6684, 6685, 6708, 6707, 30957, 30980, 31509, 31486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20927, 30957, 30980, 31509, 31486, 30958, 30981, 31510, 31487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20928, 30958, 30981, 31510, 31487, 30959, 30982, 31511, 31488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20929, 30959, 30982, 31511, 31488, 30960, 30983, 31512, 31489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20930, 30960, 30983, 31512, 31489, 30961, 30984, 31513, 31490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20931, 30961, 30984, 31513, 31490, 30962, 30985, 31514, 31491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20932, 30962, 30985, 31514, 31491, 30963, 30986, 31515, 31492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20933, 30963, 30986, 31515, 31492, 30964, 30987, 31516, 31493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20934, 30964, 30987, 31516, 31493, 30965, 30988, 31517, 31494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20935, 30965, 30988, 31517, 31494, 30966, 30989, 31518, 31495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20936, 30966, 30989, 31518, 31495, 30967, 30990, 31519, 31496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20937, 30967, 30990, 31519, 31496, 30968, 30991, 31520, 31497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20938, 30968, 30991, 31520, 31497, 30969, 30992, 31521, 31498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20939, 30969, 30992, 31521, 31498, 30970, 30993, 31522, 31499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20940, 30970, 30993, 31522, 31499, 30971, 30994, 31523, 31500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20941, 30971, 30994, 31523, 31500, 30972, 30995, 31524, 31501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20942, 30972, 30995, 31524, 31501, 30973, 30996, 31525, 31502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20943, 30973, 30996, 31525, 31502, 30974, 30997, 31526, 31503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20944, 30974, 30997, 31526, 31503, 30975, 30998, 31527, 31504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20945, 30975, 30998, 31527, 31504, 30976, 30999, 31528, 31505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20946, 30976, 30999, 31528, 31505, 30977, 31000, 31529, 31506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20947, 30977, 31000, 31529, 31506, 30978, 31001, 31530, 31507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20948, 30978, 31001, 31530, 31507, 30979, 31002, 31531, 31508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20949, 30979, 31002, 31531, 31508, 8501, 8502, 8525, 8524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20950, 6685, 6686, 6709, 6708, 30980, 31003, 31532, 31509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20951, 30980, 31003, 31532, 31509, 30981, 31004, 31533, 31510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20952, 30981, 31004, 31533, 31510, 30982, 31005, 31534, 31511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20953, 30982, 31005, 31534, 31511, 30983, 31006, 31535, 31512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20954, 30983, 31006, 31535, 31512, 30984, 31007, 31536, 31513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20955, 30984, 31007, 31536, 31513, 30985, 31008, 31537, 31514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20956, 30985, 31008, 31537, 31514, 30986, 31009, 31538, 31515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20957, 30986, 31009, 31538, 31515, 30987, 31010, 31539, 31516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20958, 30987, 31010, 31539, 31516, 30988, 31011, 31540, 31517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20959, 30988, 31011, 31540, 31517, 30989, 31012, 31541, 31518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20960, 30989, 31012, 31541, 31518, 30990, 31013, 31542, 31519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20961, 30990, 31013, 31542, 31519, 30991, 31014, 31543, 31520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20962, 30991, 31014, 31543, 31520, 30992, 31015, 31544, 31521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20963, 30992, 31015, 31544, 31521, 30993, 31016, 31545, 31522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20964, 30993, 31016, 31545, 31522, 30994, 31017, 31546, 31523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20965, 30994, 31017, 31546, 31523, 30995, 31018, 31547, 31524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20966, 30995, 31018, 31547, 31524, 30996, 31019, 31548, 31525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20967, 30996, 31019, 31548, 31525, 30997, 31020, 31549, 31526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20968, 30997, 31020, 31549, 31526, 30998, 31021, 31550, 31527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20969, 30998, 31021, 31550, 31527, 30999, 31022, 31551, 31528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20970, 30999, 31022, 31551, 31528, 31000, 31023, 31552, 31529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20971, 31000, 31023, 31552, 31529, 31001, 31024, 31553, 31530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20972, 31001, 31024, 31553, 31530, 31002, 31025, 31554, 31531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20973, 31002, 31025, 31554, 31531, 8502, 8503, 8526, 8525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20974, 6686, 6687, 6710, 6709, 31003, 31026, 31555, 31532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20975, 31003, 31026, 31555, 31532, 31004, 31027, 31556, 31533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20976, 31004, 31027, 31556, 31533, 31005, 31028, 31557, 31534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20977, 31005, 31028, 31557, 31534, 31006, 31029, 31558, 31535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20978, 31006, 31029, 31558, 31535, 31007, 31030, 31559, 31536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20979, 31007, 31030, 31559, 31536, 31008, 31031, 31560, 31537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20980, 31008, 31031, 31560, 31537, 31009, 31032, 31561, 31538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20981, 31009, 31032, 31561, 31538, 31010, 31033, 31562, 31539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20982, 31010, 31033, 31562, 31539, 31011, 31034, 31563, 31540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20983, 31011, 31034, 31563, 31540, 31012, 31035, 31564, 31541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20984, 31012, 31035, 31564, 31541, 31013, 31036, 31565, 31542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20985, 31013, 31036, 31565, 31542, 31014, 31037, 31566, 31543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20986, 31014, 31037, 31566, 31543, 31015, 31038, 31567, 31544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20987, 31015, 31038, 31567, 31544, 31016, 31039, 31568, 31545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20988, 31016, 31039, 31568, 31545, 31017, 31040, 31569, 31546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20989, 31017, 31040, 31569, 31546, 31018, 31041, 31570, 31547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20990, 31018, 31041, 31570, 31547, 31019, 31042, 31571, 31548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20991, 31019, 31042, 31571, 31548, 31020, 31043, 31572, 31549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20992, 31020, 31043, 31572, 31549, 31021, 31044, 31573, 31550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20993, 31021, 31044, 31573, 31550, 31022, 31045, 31574, 31551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20994, 31022, 31045, 31574, 31551, 31023, 31046, 31575, 31552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20995, 31023, 31046, 31575, 31552, 31024, 31047, 31576, 31553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20996, 31024, 31047, 31576, 31553, 31025, 31048, 31577, 31554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20997, 31025, 31048, 31577, 31554, 8503, 8504, 8527, 8526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20998, 6687, 6688, 6711, 6710, 31026, 31049, 31578, 31555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20999, 31026, 31049, 31578, 31555, 31027, 31050, 31579, 31556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21000, 31027, 31050, 31579, 31556, 31028, 31051, 31580, 31557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21001, 31028, 31051, 31580, 31557, 31029, 31052, 31581, 31558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21002, 31029, 31052, 31581, 31558, 31030, 31053, 31582, 31559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21003, 31030, 31053, 31582, 31559, 31031, 31054, 31583, 31560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21004, 31031, 31054, 31583, 31560, 31032, 31055, 31584, 31561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21005, 31032, 31055, 31584, 31561, 31033, 31056, 31585, 31562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21006, 31033, 31056, 31585, 31562, 31034, 31057, 31586, 31563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21007, 31034, 31057, 31586, 31563, 31035, 31058, 31587, 31564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21008, 31035, 31058, 31587, 31564, 31036, 31059, 31588, 31565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21009, 31036, 31059, 31588, 31565, 31037, 31060, 31589, 31566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21010, 31037, 31060, 31589, 31566, 31038, 31061, 31590, 31567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21011, 31038, 31061, 31590, 31567, 31039, 31062, 31591, 31568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21012, 31039, 31062, 31591, 31568, 31040, 31063, 31592, 31569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21013, 31040, 31063, 31592, 31569, 31041, 31064, 31593, 31570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21014, 31041, 31064, 31593, 31570, 31042, 31065, 31594, 31571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21015, 31042, 31065, 31594, 31571, 31043, 31066, 31595, 31572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21016, 31043, 31066, 31595, 31572, 31044, 31067, 31596, 31573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21017, 31044, 31067, 31596, 31573, 31045, 31068, 31597, 31574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21018, 31045, 31068, 31597, 31574, 31046, 31069, 31598, 31575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21019, 31046, 31069, 31598, 31575, 31047, 31070, 31599, 31576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21020, 31047, 31070, 31599, 31576, 31048, 31071, 31600, 31577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21021, 31048, 31071, 31600, 31577, 8504, 8505, 8528, 8527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21022, 6688, 6689, 6712, 6711, 31049, 31072, 31601, 31578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21023, 31049, 31072, 31601, 31578, 31050, 31073, 31602, 31579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21024, 31050, 31073, 31602, 31579, 31051, 31074, 31603, 31580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21025, 31051, 31074, 31603, 31580, 31052, 31075, 31604, 31581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21026, 31052, 31075, 31604, 31581, 31053, 31076, 31605, 31582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21027, 31053, 31076, 31605, 31582, 31054, 31077, 31606, 31583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21028, 31054, 31077, 31606, 31583, 31055, 31078, 31607, 31584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21029, 31055, 31078, 31607, 31584, 31056, 31079, 31608, 31585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21030, 31056, 31079, 31608, 31585, 31057, 31080, 31609, 31586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21031, 31057, 31080, 31609, 31586, 31058, 31081, 31610, 31587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21032, 31058, 31081, 31610, 31587, 31059, 31082, 31611, 31588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21033, 31059, 31082, 31611, 31588, 31060, 31083, 31612, 31589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21034, 31060, 31083, 31612, 31589, 31061, 31084, 31613, 31590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21035, 31061, 31084, 31613, 31590, 31062, 31085, 31614, 31591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21036, 31062, 31085, 31614, 31591, 31063, 31086, 31615, 31592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21037, 31063, 31086, 31615, 31592, 31064, 31087, 31616, 31593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21038, 31064, 31087, 31616, 31593, 31065, 31088, 31617, 31594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21039, 31065, 31088, 31617, 31594, 31066, 31089, 31618, 31595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21040, 31066, 31089, 31618, 31595, 31067, 31090, 31619, 31596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21041, 31067, 31090, 31619, 31596, 31068, 31091, 31620, 31597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21042, 31068, 31091, 31620, 31597, 31069, 31092, 31621, 31598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21043, 31069, 31092, 31621, 31598, 31070, 31093, 31622, 31599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21044, 31070, 31093, 31622, 31599, 31071, 31094, 31623, 31600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21045, 31071, 31094, 31623, 31600, 8505, 8506, 8529, 8528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21046, 6689, 6690, 6713, 6712, 31072, 31095, 31624, 31601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21047, 31072, 31095, 31624, 31601, 31073, 31096, 31625, 31602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21048, 31073, 31096, 31625, 31602, 31074, 31097, 31626, 31603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21049, 31074, 31097, 31626, 31603, 31075, 31098, 31627, 31604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21050, 31075, 31098, 31627, 31604, 31076, 31099, 31628, 31605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21051, 31076, 31099, 31628, 31605, 31077, 31100, 31629, 31606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21052, 31077, 31100, 31629, 31606, 31078, 31101, 31630, 31607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21053, 31078, 31101, 31630, 31607, 31079, 31102, 31631, 31608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21054, 31079, 31102, 31631, 31608, 31080, 31103, 31632, 31609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21055, 31080, 31103, 31632, 31609, 31081, 31104, 31633, 31610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21056, 31081, 31104, 31633, 31610, 31082, 31105, 31634, 31611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21057, 31082, 31105, 31634, 31611, 31083, 31106, 31635, 31612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21058, 31083, 31106, 31635, 31612, 31084, 31107, 31636, 31613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21059, 31084, 31107, 31636, 31613, 31085, 31108, 31637, 31614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21060, 31085, 31108, 31637, 31614, 31086, 31109, 31638, 31615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21061, 31086, 31109, 31638, 31615, 31087, 31110, 31639, 31616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21062, 31087, 31110, 31639, 31616, 31088, 31111, 31640, 31617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21063, 31088, 31111, 31640, 31617, 31089, 31112, 31641, 31618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21064, 31089, 31112, 31641, 31618, 31090, 31113, 31642, 31619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21065, 31090, 31113, 31642, 31619, 31091, 31114, 31643, 31620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21066, 31091, 31114, 31643, 31620, 31092, 31115, 31644, 31621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21067, 31092, 31115, 31644, 31621, 31093, 31116, 31645, 31622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21068, 31093, 31116, 31645, 31622, 31094, 31117, 31646, 31623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21069, 31094, 31117, 31646, 31623, 8506, 8507, 8530, 8529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21070, 6690, 6691, 6714, 6713, 31095, 31118, 31647, 31624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21071, 31095, 31118, 31647, 31624, 31096, 31119, 31648, 31625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21072, 31096, 31119, 31648, 31625, 31097, 31120, 31649, 31626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21073, 31097, 31120, 31649, 31626, 31098, 31121, 31650, 31627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21074, 31098, 31121, 31650, 31627, 31099, 31122, 31651, 31628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21075, 31099, 31122, 31651, 31628, 31100, 31123, 31652, 31629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21076, 31100, 31123, 31652, 31629, 31101, 31124, 31653, 31630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21077, 31101, 31124, 31653, 31630, 31102, 31125, 31654, 31631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21078, 31102, 31125, 31654, 31631, 31103, 31126, 31655, 31632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21079, 31103, 31126, 31655, 31632, 31104, 31127, 31656, 31633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21080, 31104, 31127, 31656, 31633, 31105, 31128, 31657, 31634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21081, 31105, 31128, 31657, 31634, 31106, 31129, 31658, 31635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21082, 31106, 31129, 31658, 31635, 31107, 31130, 31659, 31636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21083, 31107, 31130, 31659, 31636, 31108, 31131, 31660, 31637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21084, 31108, 31131, 31660, 31637, 31109, 31132, 31661, 31638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21085, 31109, 31132, 31661, 31638, 31110, 31133, 31662, 31639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21086, 31110, 31133, 31662, 31639, 31111, 31134, 31663, 31640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21087, 31111, 31134, 31663, 31640, 31112, 31135, 31664, 31641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21088, 31112, 31135, 31664, 31641, 31113, 31136, 31665, 31642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21089, 31113, 31136, 31665, 31642, 31114, 31137, 31666, 31643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21090, 31114, 31137, 31666, 31643, 31115, 31138, 31667, 31644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21091, 31115, 31138, 31667, 31644, 31116, 31139, 31668, 31645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21092, 31116, 31139, 31668, 31645, 31117, 31140, 31669, 31646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21093, 31117, 31140, 31669, 31646, 8507, 8508, 8531, 8530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21094, 6691, 838, 839, 6714, 31118, 8233, 8256, 31647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21095, 31118, 8233, 8256, 31647, 31119, 8234, 8257, 31648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21096, 31119, 8234, 8257, 31648, 31120, 8235, 8258, 31649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21097, 31120, 8235, 8258, 31649, 31121, 8236, 8259, 31650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21098, 31121, 8236, 8259, 31650, 31122, 8237, 8260, 31651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21099, 31122, 8237, 8260, 31651, 31123, 8238, 8261, 31652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21100, 31123, 8238, 8261, 31652, 31124, 8239, 8262, 31653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21101, 31124, 8239, 8262, 31653, 31125, 8240, 8263, 31654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21102, 31125, 8240, 8263, 31654, 31126, 8241, 8264, 31655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21103, 31126, 8241, 8264, 31655, 31127, 8242, 8265, 31656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21104, 31127, 8242, 8265, 31656, 31128, 8243, 8266, 31657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21105, 31128, 8243, 8266, 31657, 31129, 8244, 8267, 31658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21106, 31129, 8244, 8267, 31658, 31130, 8245, 8268, 31659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21107, 31130, 8245, 8268, 31659, 31131, 8246, 8269, 31660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21108, 31131, 8246, 8269, 31660, 31132, 8247, 8270, 31661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21109, 31132, 8247, 8270, 31661, 31133, 8248, 8271, 31662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21110, 31133, 8248, 8271, 31662, 31134, 8249, 8272, 31663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21111, 31134, 8249, 8272, 31663, 31135, 8250, 8273, 31664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21112, 31135, 8250, 8273, 31664, 31136, 8251, 8274, 31665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21113, 31136, 8251, 8274, 31665, 31137, 8252, 8275, 31666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21114, 31137, 8252, 8275, 31666, 31138, 8253, 8276, 31667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21115, 31138, 8253, 8276, 31667, 31139, 8254, 8277, 31668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21116, 31139, 8254, 8277, 31668, 31140, 8255, 8278, 31669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21117, 31140, 8255, 8278, 31669, 8508, 998, 999, 8531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21118, 828, 6692, 6715, 829, 8003, 31141, 31670, 8026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21119, 8003, 31141, 31670, 8026, 8004, 31142, 31671, 8027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21120, 8004, 31142, 31671, 8027, 8005, 31143, 31672, 8028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21121, 8005, 31143, 31672, 8028, 8006, 31144, 31673, 8029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21122, 8006, 31144, 31673, 8029, 8007, 31145, 31674, 8030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21123, 8007, 31145, 31674, 8030, 8008, 31146, 31675, 8031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21124, 8008, 31146, 31675, 8031, 8009, 31147, 31676, 8032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21125, 8009, 31147, 31676, 8032, 8010, 31148, 31677, 8033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21126, 8010, 31148, 31677, 8033, 8011, 31149, 31678, 8034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21127, 8011, 31149, 31678, 8034, 8012, 31150, 31679, 8035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21128, 8012, 31150, 31679, 8035, 8013, 31151, 31680, 8036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21129, 8013, 31151, 31680, 8036, 8014, 31152, 31681, 8037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21130, 8014, 31152, 31681, 8037, 8015, 31153, 31682, 8038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21131, 8015, 31153, 31682, 8038, 8016, 31154, 31683, 8039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21132, 8016, 31154, 31683, 8039, 8017, 31155, 31684, 8040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21133, 8017, 31155, 31684, 8040, 8018, 31156, 31685, 8041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21134, 8018, 31156, 31685, 8041, 8019, 31157, 31686, 8042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21135, 8019, 31157, 31686, 8042, 8020, 31158, 31687, 8043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21136, 8020, 31158, 31687, 8043, 8021, 31159, 31688, 8044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21137, 8021, 31159, 31688, 8044, 8022, 31160, 31689, 8045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21138, 8022, 31160, 31689, 8045, 8023, 31161, 31690, 8046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21139, 8023, 31161, 31690, 8046, 8024, 31162, 31691, 8047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21140, 8024, 31162, 31691, 8047, 8025, 31163, 31692, 8048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21141, 8025, 31163, 31692, 8048, 988, 8509, 8532, 989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21142, 6692, 6693, 6716, 6715, 31141, 31164, 31693, 31670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21143, 31141, 31164, 31693, 31670, 31142, 31165, 31694, 31671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21144, 31142, 31165, 31694, 31671, 31143, 31166, 31695, 31672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21145, 31143, 31166, 31695, 31672, 31144, 31167, 31696, 31673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21146, 31144, 31167, 31696, 31673, 31145, 31168, 31697, 31674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21147, 31145, 31168, 31697, 31674, 31146, 31169, 31698, 31675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21148, 31146, 31169, 31698, 31675, 31147, 31170, 31699, 31676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21149, 31147, 31170, 31699, 31676, 31148, 31171, 31700, 31677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21150, 31148, 31171, 31700, 31677, 31149, 31172, 31701, 31678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21151, 31149, 31172, 31701, 31678, 31150, 31173, 31702, 31679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21152, 31150, 31173, 31702, 31679, 31151, 31174, 31703, 31680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21153, 31151, 31174, 31703, 31680, 31152, 31175, 31704, 31681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21154, 31152, 31175, 31704, 31681, 31153, 31176, 31705, 31682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21155, 31153, 31176, 31705, 31682, 31154, 31177, 31706, 31683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21156, 31154, 31177, 31706, 31683, 31155, 31178, 31707, 31684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21157, 31155, 31178, 31707, 31684, 31156, 31179, 31708, 31685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21158, 31156, 31179, 31708, 31685, 31157, 31180, 31709, 31686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21159, 31157, 31180, 31709, 31686, 31158, 31181, 31710, 31687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21160, 31158, 31181, 31710, 31687, 31159, 31182, 31711, 31688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21161, 31159, 31182, 31711, 31688, 31160, 31183, 31712, 31689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21162, 31160, 31183, 31712, 31689, 31161, 31184, 31713, 31690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21163, 31161, 31184, 31713, 31690, 31162, 31185, 31714, 31691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21164, 31162, 31185, 31714, 31691, 31163, 31186, 31715, 31692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21165, 31163, 31186, 31715, 31692, 8509, 8510, 8533, 8532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21166, 6693, 6694, 6717, 6716, 31164, 31187, 31716, 31693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21167, 31164, 31187, 31716, 31693, 31165, 31188, 31717, 31694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21168, 31165, 31188, 31717, 31694, 31166, 31189, 31718, 31695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21169, 31166, 31189, 31718, 31695, 31167, 31190, 31719, 31696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21170, 31167, 31190, 31719, 31696, 31168, 31191, 31720, 31697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21171, 31168, 31191, 31720, 31697, 31169, 31192, 31721, 31698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21172, 31169, 31192, 31721, 31698, 31170, 31193, 31722, 31699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21173, 31170, 31193, 31722, 31699, 31171, 31194, 31723, 31700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21174, 31171, 31194, 31723, 31700, 31172, 31195, 31724, 31701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21175, 31172, 31195, 31724, 31701, 31173, 31196, 31725, 31702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21176, 31173, 31196, 31725, 31702, 31174, 31197, 31726, 31703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21177, 31174, 31197, 31726, 31703, 31175, 31198, 31727, 31704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21178, 31175, 31198, 31727, 31704, 31176, 31199, 31728, 31705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21179, 31176, 31199, 31728, 31705, 31177, 31200, 31729, 31706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21180, 31177, 31200, 31729, 31706, 31178, 31201, 31730, 31707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21181, 31178, 31201, 31730, 31707, 31179, 31202, 31731, 31708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21182, 31179, 31202, 31731, 31708, 31180, 31203, 31732, 31709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21183, 31180, 31203, 31732, 31709, 31181, 31204, 31733, 31710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21184, 31181, 31204, 31733, 31710, 31182, 31205, 31734, 31711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21185, 31182, 31205, 31734, 31711, 31183, 31206, 31735, 31712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21186, 31183, 31206, 31735, 31712, 31184, 31207, 31736, 31713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21187, 31184, 31207, 31736, 31713, 31185, 31208, 31737, 31714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21188, 31185, 31208, 31737, 31714, 31186, 31209, 31738, 31715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21189, 31186, 31209, 31738, 31715, 8510, 8511, 8534, 8533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21190, 6694, 6695, 6718, 6717, 31187, 31210, 31739, 31716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21191, 31187, 31210, 31739, 31716, 31188, 31211, 31740, 31717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21192, 31188, 31211, 31740, 31717, 31189, 31212, 31741, 31718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21193, 31189, 31212, 31741, 31718, 31190, 31213, 31742, 31719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21194, 31190, 31213, 31742, 31719, 31191, 31214, 31743, 31720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21195, 31191, 31214, 31743, 31720, 31192, 31215, 31744, 31721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21196, 31192, 31215, 31744, 31721, 31193, 31216, 31745, 31722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21197, 31193, 31216, 31745, 31722, 31194, 31217, 31746, 31723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21198, 31194, 31217, 31746, 31723, 31195, 31218, 31747, 31724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21199, 31195, 31218, 31747, 31724, 31196, 31219, 31748, 31725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21200, 31196, 31219, 31748, 31725, 31197, 31220, 31749, 31726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21201, 31197, 31220, 31749, 31726, 31198, 31221, 31750, 31727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21202, 31198, 31221, 31750, 31727, 31199, 31222, 31751, 31728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21203, 31199, 31222, 31751, 31728, 31200, 31223, 31752, 31729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21204, 31200, 31223, 31752, 31729, 31201, 31224, 31753, 31730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21205, 31201, 31224, 31753, 31730, 31202, 31225, 31754, 31731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21206, 31202, 31225, 31754, 31731, 31203, 31226, 31755, 31732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21207, 31203, 31226, 31755, 31732, 31204, 31227, 31756, 31733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21208, 31204, 31227, 31756, 31733, 31205, 31228, 31757, 31734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21209, 31205, 31228, 31757, 31734, 31206, 31229, 31758, 31735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21210, 31206, 31229, 31758, 31735, 31207, 31230, 31759, 31736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21211, 31207, 31230, 31759, 31736, 31208, 31231, 31760, 31737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21212, 31208, 31231, 31760, 31737, 31209, 31232, 31761, 31738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21213, 31209, 31232, 31761, 31738, 8511, 8512, 8535, 8534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21214, 6695, 6696, 6719, 6718, 31210, 31233, 31762, 31739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21215, 31210, 31233, 31762, 31739, 31211, 31234, 31763, 31740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21216, 31211, 31234, 31763, 31740, 31212, 31235, 31764, 31741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21217, 31212, 31235, 31764, 31741, 31213, 31236, 31765, 31742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21218, 31213, 31236, 31765, 31742, 31214, 31237, 31766, 31743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21219, 31214, 31237, 31766, 31743, 31215, 31238, 31767, 31744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21220, 31215, 31238, 31767, 31744, 31216, 31239, 31768, 31745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21221, 31216, 31239, 31768, 31745, 31217, 31240, 31769, 31746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21222, 31217, 31240, 31769, 31746, 31218, 31241, 31770, 31747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21223, 31218, 31241, 31770, 31747, 31219, 31242, 31771, 31748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21224, 31219, 31242, 31771, 31748, 31220, 31243, 31772, 31749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21225, 31220, 31243, 31772, 31749, 31221, 31244, 31773, 31750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21226, 31221, 31244, 31773, 31750, 31222, 31245, 31774, 31751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21227, 31222, 31245, 31774, 31751, 31223, 31246, 31775, 31752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21228, 31223, 31246, 31775, 31752, 31224, 31247, 31776, 31753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21229, 31224, 31247, 31776, 31753, 31225, 31248, 31777, 31754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21230, 31225, 31248, 31777, 31754, 31226, 31249, 31778, 31755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21231, 31226, 31249, 31778, 31755, 31227, 31250, 31779, 31756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21232, 31227, 31250, 31779, 31756, 31228, 31251, 31780, 31757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21233, 31228, 31251, 31780, 31757, 31229, 31252, 31781, 31758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21234, 31229, 31252, 31781, 31758, 31230, 31253, 31782, 31759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21235, 31230, 31253, 31782, 31759, 31231, 31254, 31783, 31760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21236, 31231, 31254, 31783, 31760, 31232, 31255, 31784, 31761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21237, 31232, 31255, 31784, 31761, 8512, 8513, 8536, 8535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21238, 6696, 6697, 6720, 6719, 31233, 31256, 31785, 31762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21239, 31233, 31256, 31785, 31762, 31234, 31257, 31786, 31763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21240, 31234, 31257, 31786, 31763, 31235, 31258, 31787, 31764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21241, 31235, 31258, 31787, 31764, 31236, 31259, 31788, 31765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21242, 31236, 31259, 31788, 31765, 31237, 31260, 31789, 31766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21243, 31237, 31260, 31789, 31766, 31238, 31261, 31790, 31767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21244, 31238, 31261, 31790, 31767, 31239, 31262, 31791, 31768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21245, 31239, 31262, 31791, 31768, 31240, 31263, 31792, 31769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21246, 31240, 31263, 31792, 31769, 31241, 31264, 31793, 31770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21247, 31241, 31264, 31793, 31770, 31242, 31265, 31794, 31771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21248, 31242, 31265, 31794, 31771, 31243, 31266, 31795, 31772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21249, 31243, 31266, 31795, 31772, 31244, 31267, 31796, 31773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21250, 31244, 31267, 31796, 31773, 31245, 31268, 31797, 31774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21251, 31245, 31268, 31797, 31774, 31246, 31269, 31798, 31775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21252, 31246, 31269, 31798, 31775, 31247, 31270, 31799, 31776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21253, 31247, 31270, 31799, 31776, 31248, 31271, 31800, 31777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21254, 31248, 31271, 31800, 31777, 31249, 31272, 31801, 31778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21255, 31249, 31272, 31801, 31778, 31250, 31273, 31802, 31779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21256, 31250, 31273, 31802, 31779, 31251, 31274, 31803, 31780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21257, 31251, 31274, 31803, 31780, 31252, 31275, 31804, 31781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21258, 31252, 31275, 31804, 31781, 31253, 31276, 31805, 31782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21259, 31253, 31276, 31805, 31782, 31254, 31277, 31806, 31783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21260, 31254, 31277, 31806, 31783, 31255, 31278, 31807, 31784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21261, 31255, 31278, 31807, 31784, 8513, 8514, 8537, 8536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21262, 6697, 6698, 6721, 6720, 31256, 31279, 31808, 31785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21263, 31256, 31279, 31808, 31785, 31257, 31280, 31809, 31786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21264, 31257, 31280, 31809, 31786, 31258, 31281, 31810, 31787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21265, 31258, 31281, 31810, 31787, 31259, 31282, 31811, 31788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21266, 31259, 31282, 31811, 31788, 31260, 31283, 31812, 31789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21267, 31260, 31283, 31812, 31789, 31261, 31284, 31813, 31790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21268, 31261, 31284, 31813, 31790, 31262, 31285, 31814, 31791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21269, 31262, 31285, 31814, 31791, 31263, 31286, 31815, 31792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21270, 31263, 31286, 31815, 31792, 31264, 31287, 31816, 31793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21271, 31264, 31287, 31816, 31793, 31265, 31288, 31817, 31794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21272, 31265, 31288, 31817, 31794, 31266, 31289, 31818, 31795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21273, 31266, 31289, 31818, 31795, 31267, 31290, 31819, 31796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21274, 31267, 31290, 31819, 31796, 31268, 31291, 31820, 31797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21275, 31268, 31291, 31820, 31797, 31269, 31292, 31821, 31798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21276, 31269, 31292, 31821, 31798, 31270, 31293, 31822, 31799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21277, 31270, 31293, 31822, 31799, 31271, 31294, 31823, 31800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21278, 31271, 31294, 31823, 31800, 31272, 31295, 31824, 31801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21279, 31272, 31295, 31824, 31801, 31273, 31296, 31825, 31802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21280, 31273, 31296, 31825, 31802, 31274, 31297, 31826, 31803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21281, 31274, 31297, 31826, 31803, 31275, 31298, 31827, 31804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21282, 31275, 31298, 31827, 31804, 31276, 31299, 31828, 31805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21283, 31276, 31299, 31828, 31805, 31277, 31300, 31829, 31806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21284, 31277, 31300, 31829, 31806, 31278, 31301, 31830, 31807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21285, 31278, 31301, 31830, 31807, 8514, 8515, 8538, 8537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21286, 6698, 6699, 6722, 6721, 31279, 31302, 31831, 31808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21287, 31279, 31302, 31831, 31808, 31280, 31303, 31832, 31809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21288, 31280, 31303, 31832, 31809, 31281, 31304, 31833, 31810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21289, 31281, 31304, 31833, 31810, 31282, 31305, 31834, 31811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21290, 31282, 31305, 31834, 31811, 31283, 31306, 31835, 31812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21291, 31283, 31306, 31835, 31812, 31284, 31307, 31836, 31813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21292, 31284, 31307, 31836, 31813, 31285, 31308, 31837, 31814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21293, 31285, 31308, 31837, 31814, 31286, 31309, 31838, 31815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21294, 31286, 31309, 31838, 31815, 31287, 31310, 31839, 31816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21295, 31287, 31310, 31839, 31816, 31288, 31311, 31840, 31817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21296, 31288, 31311, 31840, 31817, 31289, 31312, 31841, 31818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21297, 31289, 31312, 31841, 31818, 31290, 31313, 31842, 31819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21298, 31290, 31313, 31842, 31819, 31291, 31314, 31843, 31820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21299, 31291, 31314, 31843, 31820, 31292, 31315, 31844, 31821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21300, 31292, 31315, 31844, 31821, 31293, 31316, 31845, 31822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21301, 31293, 31316, 31845, 31822, 31294, 31317, 31846, 31823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21302, 31294, 31317, 31846, 31823, 31295, 31318, 31847, 31824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21303, 31295, 31318, 31847, 31824, 31296, 31319, 31848, 31825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21304, 31296, 31319, 31848, 31825, 31297, 31320, 31849, 31826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21305, 31297, 31320, 31849, 31826, 31298, 31321, 31850, 31827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21306, 31298, 31321, 31850, 31827, 31299, 31322, 31851, 31828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21307, 31299, 31322, 31851, 31828, 31300, 31323, 31852, 31829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21308, 31300, 31323, 31852, 31829, 31301, 31324, 31853, 31830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21309, 31301, 31324, 31853, 31830, 8515, 8516, 8539, 8538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21310, 6699, 6700, 6723, 6722, 31302, 31325, 31854, 31831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21311, 31302, 31325, 31854, 31831, 31303, 31326, 31855, 31832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21312, 31303, 31326, 31855, 31832, 31304, 31327, 31856, 31833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21313, 31304, 31327, 31856, 31833, 31305, 31328, 31857, 31834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21314, 31305, 31328, 31857, 31834, 31306, 31329, 31858, 31835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21315, 31306, 31329, 31858, 31835, 31307, 31330, 31859, 31836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21316, 31307, 31330, 31859, 31836, 31308, 31331, 31860, 31837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21317, 31308, 31331, 31860, 31837, 31309, 31332, 31861, 31838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21318, 31309, 31332, 31861, 31838, 31310, 31333, 31862, 31839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21319, 31310, 31333, 31862, 31839, 31311, 31334, 31863, 31840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21320, 31311, 31334, 31863, 31840, 31312, 31335, 31864, 31841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21321, 31312, 31335, 31864, 31841, 31313, 31336, 31865, 31842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21322, 31313, 31336, 31865, 31842, 31314, 31337, 31866, 31843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21323, 31314, 31337, 31866, 31843, 31315, 31338, 31867, 31844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21324, 31315, 31338, 31867, 31844, 31316, 31339, 31868, 31845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21325, 31316, 31339, 31868, 31845, 31317, 31340, 31869, 31846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21326, 31317, 31340, 31869, 31846, 31318, 31341, 31870, 31847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21327, 31318, 31341, 31870, 31847, 31319, 31342, 31871, 31848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21328, 31319, 31342, 31871, 31848, 31320, 31343, 31872, 31849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21329, 31320, 31343, 31872, 31849, 31321, 31344, 31873, 31850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21330, 31321, 31344, 31873, 31850, 31322, 31345, 31874, 31851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21331, 31322, 31345, 31874, 31851, 31323, 31346, 31875, 31852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21332, 31323, 31346, 31875, 31852, 31324, 31347, 31876, 31853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21333, 31324, 31347, 31876, 31853, 8516, 8517, 8540, 8539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21334, 6700, 6701, 6724, 6723, 31325, 31348, 31877, 31854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21335, 31325, 31348, 31877, 31854, 31326, 31349, 31878, 31855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21336, 31326, 31349, 31878, 31855, 31327, 31350, 31879, 31856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21337, 31327, 31350, 31879, 31856, 31328, 31351, 31880, 31857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21338, 31328, 31351, 31880, 31857, 31329, 31352, 31881, 31858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21339, 31329, 31352, 31881, 31858, 31330, 31353, 31882, 31859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21340, 31330, 31353, 31882, 31859, 31331, 31354, 31883, 31860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21341, 31331, 31354, 31883, 31860, 31332, 31355, 31884, 31861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21342, 31332, 31355, 31884, 31861, 31333, 31356, 31885, 31862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21343, 31333, 31356, 31885, 31862, 31334, 31357, 31886, 31863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21344, 31334, 31357, 31886, 31863, 31335, 31358, 31887, 31864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21345, 31335, 31358, 31887, 31864, 31336, 31359, 31888, 31865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21346, 31336, 31359, 31888, 31865, 31337, 31360, 31889, 31866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21347, 31337, 31360, 31889, 31866, 31338, 31361, 31890, 31867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21348, 31338, 31361, 31890, 31867, 31339, 31362, 31891, 31868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21349, 31339, 31362, 31891, 31868, 31340, 31363, 31892, 31869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21350, 31340, 31363, 31892, 31869, 31341, 31364, 31893, 31870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21351, 31341, 31364, 31893, 31870, 31342, 31365, 31894, 31871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21352, 31342, 31365, 31894, 31871, 31343, 31366, 31895, 31872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21353, 31343, 31366, 31895, 31872, 31344, 31367, 31896, 31873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21354, 31344, 31367, 31896, 31873, 31345, 31368, 31897, 31874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21355, 31345, 31368, 31897, 31874, 31346, 31369, 31898, 31875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21356, 31346, 31369, 31898, 31875, 31347, 31370, 31899, 31876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21357, 31347, 31370, 31899, 31876, 8517, 8518, 8541, 8540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21358, 6701, 6702, 6725, 6724, 31348, 31371, 31900, 31877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21359, 31348, 31371, 31900, 31877, 31349, 31372, 31901, 31878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21360, 31349, 31372, 31901, 31878, 31350, 31373, 31902, 31879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21361, 31350, 31373, 31902, 31879, 31351, 31374, 31903, 31880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21362, 31351, 31374, 31903, 31880, 31352, 31375, 31904, 31881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21363, 31352, 31375, 31904, 31881, 31353, 31376, 31905, 31882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21364, 31353, 31376, 31905, 31882, 31354, 31377, 31906, 31883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21365, 31354, 31377, 31906, 31883, 31355, 31378, 31907, 31884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21366, 31355, 31378, 31907, 31884, 31356, 31379, 31908, 31885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21367, 31356, 31379, 31908, 31885, 31357, 31380, 31909, 31886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21368, 31357, 31380, 31909, 31886, 31358, 31381, 31910, 31887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21369, 31358, 31381, 31910, 31887, 31359, 31382, 31911, 31888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21370, 31359, 31382, 31911, 31888, 31360, 31383, 31912, 31889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21371, 31360, 31383, 31912, 31889, 31361, 31384, 31913, 31890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21372, 31361, 31384, 31913, 31890, 31362, 31385, 31914, 31891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21373, 31362, 31385, 31914, 31891, 31363, 31386, 31915, 31892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21374, 31363, 31386, 31915, 31892, 31364, 31387, 31916, 31893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21375, 31364, 31387, 31916, 31893, 31365, 31388, 31917, 31894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21376, 31365, 31388, 31917, 31894, 31366, 31389, 31918, 31895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21377, 31366, 31389, 31918, 31895, 31367, 31390, 31919, 31896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21378, 31367, 31390, 31919, 31896, 31368, 31391, 31920, 31897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21379, 31368, 31391, 31920, 31897, 31369, 31392, 31921, 31898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21380, 31369, 31392, 31921, 31898, 31370, 31393, 31922, 31899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21381, 31370, 31393, 31922, 31899, 8518, 8519, 8542, 8541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21382, 6702, 6703, 6726, 6725, 31371, 31394, 31923, 31900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21383, 31371, 31394, 31923, 31900, 31372, 31395, 31924, 31901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21384, 31372, 31395, 31924, 31901, 31373, 31396, 31925, 31902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21385, 31373, 31396, 31925, 31902, 31374, 31397, 31926, 31903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21386, 31374, 31397, 31926, 31903, 31375, 31398, 31927, 31904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21387, 31375, 31398, 31927, 31904, 31376, 31399, 31928, 31905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21388, 31376, 31399, 31928, 31905, 31377, 31400, 31929, 31906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21389, 31377, 31400, 31929, 31906, 31378, 31401, 31930, 31907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21390, 31378, 31401, 31930, 31907, 31379, 31402, 31931, 31908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21391, 31379, 31402, 31931, 31908, 31380, 31403, 31932, 31909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21392, 31380, 31403, 31932, 31909, 31381, 31404, 31933, 31910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21393, 31381, 31404, 31933, 31910, 31382, 31405, 31934, 31911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21394, 31382, 31405, 31934, 31911, 31383, 31406, 31935, 31912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21395, 31383, 31406, 31935, 31912, 31384, 31407, 31936, 31913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21396, 31384, 31407, 31936, 31913, 31385, 31408, 31937, 31914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21397, 31385, 31408, 31937, 31914, 31386, 31409, 31938, 31915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21398, 31386, 31409, 31938, 31915, 31387, 31410, 31939, 31916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21399, 31387, 31410, 31939, 31916, 31388, 31411, 31940, 31917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21400, 31388, 31411, 31940, 31917, 31389, 31412, 31941, 31918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21401, 31389, 31412, 31941, 31918, 31390, 31413, 31942, 31919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21402, 31390, 31413, 31942, 31919, 31391, 31414, 31943, 31920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21403, 31391, 31414, 31943, 31920, 31392, 31415, 31944, 31921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21404, 31392, 31415, 31944, 31921, 31393, 31416, 31945, 31922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21405, 31393, 31416, 31945, 31922, 8519, 8520, 8543, 8542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21406, 6703, 6704, 6727, 6726, 31394, 31417, 31946, 31923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21407, 31394, 31417, 31946, 31923, 31395, 31418, 31947, 31924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21408, 31395, 31418, 31947, 31924, 31396, 31419, 31948, 31925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21409, 31396, 31419, 31948, 31925, 31397, 31420, 31949, 31926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21410, 31397, 31420, 31949, 31926, 31398, 31421, 31950, 31927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21411, 31398, 31421, 31950, 31927, 31399, 31422, 31951, 31928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21412, 31399, 31422, 31951, 31928, 31400, 31423, 31952, 31929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21413, 31400, 31423, 31952, 31929, 31401, 31424, 31953, 31930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21414, 31401, 31424, 31953, 31930, 31402, 31425, 31954, 31931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21415, 31402, 31425, 31954, 31931, 31403, 31426, 31955, 31932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21416, 31403, 31426, 31955, 31932, 31404, 31427, 31956, 31933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21417, 31404, 31427, 31956, 31933, 31405, 31428, 31957, 31934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21418, 31405, 31428, 31957, 31934, 31406, 31429, 31958, 31935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21419, 31406, 31429, 31958, 31935, 31407, 31430, 31959, 31936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21420, 31407, 31430, 31959, 31936, 31408, 31431, 31960, 31937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21421, 31408, 31431, 31960, 31937, 31409, 31432, 31961, 31938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21422, 31409, 31432, 31961, 31938, 31410, 31433, 31962, 31939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21423, 31410, 31433, 31962, 31939, 31411, 31434, 31963, 31940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21424, 31411, 31434, 31963, 31940, 31412, 31435, 31964, 31941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21425, 31412, 31435, 31964, 31941, 31413, 31436, 31965, 31942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21426, 31413, 31436, 31965, 31942, 31414, 31437, 31966, 31943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21427, 31414, 31437, 31966, 31943, 31415, 31438, 31967, 31944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21428, 31415, 31438, 31967, 31944, 31416, 31439, 31968, 31945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21429, 31416, 31439, 31968, 31945, 8520, 8521, 8544, 8543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21430, 6704, 6705, 6728, 6727, 31417, 31440, 31969, 31946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21431, 31417, 31440, 31969, 31946, 31418, 31441, 31970, 31947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21432, 31418, 31441, 31970, 31947, 31419, 31442, 31971, 31948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21433, 31419, 31442, 31971, 31948, 31420, 31443, 31972, 31949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21434, 31420, 31443, 31972, 31949, 31421, 31444, 31973, 31950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21435, 31421, 31444, 31973, 31950, 31422, 31445, 31974, 31951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21436, 31422, 31445, 31974, 31951, 31423, 31446, 31975, 31952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21437, 31423, 31446, 31975, 31952, 31424, 31447, 31976, 31953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21438, 31424, 31447, 31976, 31953, 31425, 31448, 31977, 31954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21439, 31425, 31448, 31977, 31954, 31426, 31449, 31978, 31955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21440, 31426, 31449, 31978, 31955, 31427, 31450, 31979, 31956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21441, 31427, 31450, 31979, 31956, 31428, 31451, 31980, 31957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21442, 31428, 31451, 31980, 31957, 31429, 31452, 31981, 31958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21443, 31429, 31452, 31981, 31958, 31430, 31453, 31982, 31959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21444, 31430, 31453, 31982, 31959, 31431, 31454, 31983, 31960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21445, 31431, 31454, 31983, 31960, 31432, 31455, 31984, 31961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21446, 31432, 31455, 31984, 31961, 31433, 31456, 31985, 31962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21447, 31433, 31456, 31985, 31962, 31434, 31457, 31986, 31963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21448, 31434, 31457, 31986, 31963, 31435, 31458, 31987, 31964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21449, 31435, 31458, 31987, 31964, 31436, 31459, 31988, 31965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21450, 31436, 31459, 31988, 31965, 31437, 31460, 31989, 31966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21451, 31437, 31460, 31989, 31966, 31438, 31461, 31990, 31967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21452, 31438, 31461, 31990, 31967, 31439, 31462, 31991, 31968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21453, 31439, 31462, 31991, 31968, 8521, 8522, 8545, 8544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21454, 6705, 6706, 6729, 6728, 31440, 31463, 31992, 31969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21455, 31440, 31463, 31992, 31969, 31441, 31464, 31993, 31970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21456, 31441, 31464, 31993, 31970, 31442, 31465, 31994, 31971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21457, 31442, 31465, 31994, 31971, 31443, 31466, 31995, 31972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21458, 31443, 31466, 31995, 31972, 31444, 31467, 31996, 31973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21459, 31444, 31467, 31996, 31973, 31445, 31468, 31997, 31974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21460, 31445, 31468, 31997, 31974, 31446, 31469, 31998, 31975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21461, 31446, 31469, 31998, 31975, 31447, 31470, 31999, 31976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21462, 31447, 31470, 31999, 31976, 31448, 31471, 32000, 31977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21463, 31448, 31471, 32000, 31977, 31449, 31472, 32001, 31978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21464, 31449, 31472, 32001, 31978, 31450, 31473, 32002, 31979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21465, 31450, 31473, 32002, 31979, 31451, 31474, 32003, 31980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21466, 31451, 31474, 32003, 31980, 31452, 31475, 32004, 31981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21467, 31452, 31475, 32004, 31981, 31453, 31476, 32005, 31982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21468, 31453, 31476, 32005, 31982, 31454, 31477, 32006, 31983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21469, 31454, 31477, 32006, 31983, 31455, 31478, 32007, 31984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21470, 31455, 31478, 32007, 31984, 31456, 31479, 32008, 31985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21471, 31456, 31479, 32008, 31985, 31457, 31480, 32009, 31986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21472, 31457, 31480, 32009, 31986, 31458, 31481, 32010, 31987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21473, 31458, 31481, 32010, 31987, 31459, 31482, 32011, 31988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21474, 31459, 31482, 32011, 31988, 31460, 31483, 32012, 31989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21475, 31460, 31483, 32012, 31989, 31461, 31484, 32013, 31990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21476, 31461, 31484, 32013, 31990, 31462, 31485, 32014, 31991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21477, 31462, 31485, 32014, 31991, 8522, 8523, 8546, 8545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21478, 6706, 6707, 6730, 6729, 31463, 31486, 32015, 31992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21479, 31463, 31486, 32015, 31992, 31464, 31487, 32016, 31993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21480, 31464, 31487, 32016, 31993, 31465, 31488, 32017, 31994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21481, 31465, 31488, 32017, 31994, 31466, 31489, 32018, 31995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21482, 31466, 31489, 32018, 31995, 31467, 31490, 32019, 31996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21483, 31467, 31490, 32019, 31996, 31468, 31491, 32020, 31997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21484, 31468, 31491, 32020, 31997, 31469, 31492, 32021, 31998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21485, 31469, 31492, 32021, 31998, 31470, 31493, 32022, 31999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21486, 31470, 31493, 32022, 31999, 31471, 31494, 32023, 32000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21487, 31471, 31494, 32023, 32000, 31472, 31495, 32024, 32001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21488, 31472, 31495, 32024, 32001, 31473, 31496, 32025, 32002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21489, 31473, 31496, 32025, 32002, 31474, 31497, 32026, 32003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21490, 31474, 31497, 32026, 32003, 31475, 31498, 32027, 32004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21491, 31475, 31498, 32027, 32004, 31476, 31499, 32028, 32005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21492, 31476, 31499, 32028, 32005, 31477, 31500, 32029, 32006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21493, 31477, 31500, 32029, 32006, 31478, 31501, 32030, 32007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21494, 31478, 31501, 32030, 32007, 31479, 31502, 32031, 32008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21495, 31479, 31502, 32031, 32008, 31480, 31503, 32032, 32009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21496, 31480, 31503, 32032, 32009, 31481, 31504, 32033, 32010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21497, 31481, 31504, 32033, 32010, 31482, 31505, 32034, 32011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21498, 31482, 31505, 32034, 32011, 31483, 31506, 32035, 32012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21499, 31483, 31506, 32035, 32012, 31484, 31507, 32036, 32013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21500, 31484, 31507, 32036, 32013, 31485, 31508, 32037, 32014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21501, 31485, 31508, 32037, 32014, 8523, 8524, 8547, 8546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21502, 6707, 6708, 6731, 6730, 31486, 31509, 32038, 32015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21503, 31486, 31509, 32038, 32015, 31487, 31510, 32039, 32016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21504, 31487, 31510, 32039, 32016, 31488, 31511, 32040, 32017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21505, 31488, 31511, 32040, 32017, 31489, 31512, 32041, 32018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21506, 31489, 31512, 32041, 32018, 31490, 31513, 32042, 32019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21507, 31490, 31513, 32042, 32019, 31491, 31514, 32043, 32020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21508, 31491, 31514, 32043, 32020, 31492, 31515, 32044, 32021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21509, 31492, 31515, 32044, 32021, 31493, 31516, 32045, 32022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21510, 31493, 31516, 32045, 32022, 31494, 31517, 32046, 32023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21511, 31494, 31517, 32046, 32023, 31495, 31518, 32047, 32024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21512, 31495, 31518, 32047, 32024, 31496, 31519, 32048, 32025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21513, 31496, 31519, 32048, 32025, 31497, 31520, 32049, 32026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21514, 31497, 31520, 32049, 32026, 31498, 31521, 32050, 32027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21515, 31498, 31521, 32050, 32027, 31499, 31522, 32051, 32028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21516, 31499, 31522, 32051, 32028, 31500, 31523, 32052, 32029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21517, 31500, 31523, 32052, 32029, 31501, 31524, 32053, 32030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21518, 31501, 31524, 32053, 32030, 31502, 31525, 32054, 32031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21519, 31502, 31525, 32054, 32031, 31503, 31526, 32055, 32032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21520, 31503, 31526, 32055, 32032, 31504, 31527, 32056, 32033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21521, 31504, 31527, 32056, 32033, 31505, 31528, 32057, 32034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21522, 31505, 31528, 32057, 32034, 31506, 31529, 32058, 32035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21523, 31506, 31529, 32058, 32035, 31507, 31530, 32059, 32036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21524, 31507, 31530, 32059, 32036, 31508, 31531, 32060, 32037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21525, 31508, 31531, 32060, 32037, 8524, 8525, 8548, 8547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21526, 6708, 6709, 6732, 6731, 31509, 31532, 32061, 32038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21527, 31509, 31532, 32061, 32038, 31510, 31533, 32062, 32039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21528, 31510, 31533, 32062, 32039, 31511, 31534, 32063, 32040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21529, 31511, 31534, 32063, 32040, 31512, 31535, 32064, 32041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21530, 31512, 31535, 32064, 32041, 31513, 31536, 32065, 32042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21531, 31513, 31536, 32065, 32042, 31514, 31537, 32066, 32043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21532, 31514, 31537, 32066, 32043, 31515, 31538, 32067, 32044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21533, 31515, 31538, 32067, 32044, 31516, 31539, 32068, 32045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21534, 31516, 31539, 32068, 32045, 31517, 31540, 32069, 32046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21535, 31517, 31540, 32069, 32046, 31518, 31541, 32070, 32047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21536, 31518, 31541, 32070, 32047, 31519, 31542, 32071, 32048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21537, 31519, 31542, 32071, 32048, 31520, 31543, 32072, 32049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21538, 31520, 31543, 32072, 32049, 31521, 31544, 32073, 32050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21539, 31521, 31544, 32073, 32050, 31522, 31545, 32074, 32051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21540, 31522, 31545, 32074, 32051, 31523, 31546, 32075, 32052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21541, 31523, 31546, 32075, 32052, 31524, 31547, 32076, 32053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21542, 31524, 31547, 32076, 32053, 31525, 31548, 32077, 32054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21543, 31525, 31548, 32077, 32054, 31526, 31549, 32078, 32055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21544, 31526, 31549, 32078, 32055, 31527, 31550, 32079, 32056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21545, 31527, 31550, 32079, 32056, 31528, 31551, 32080, 32057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21546, 31528, 31551, 32080, 32057, 31529, 31552, 32081, 32058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21547, 31529, 31552, 32081, 32058, 31530, 31553, 32082, 32059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21548, 31530, 31553, 32082, 32059, 31531, 31554, 32083, 32060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21549, 31531, 31554, 32083, 32060, 8525, 8526, 8549, 8548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21550, 6709, 6710, 6733, 6732, 31532, 31555, 32084, 32061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21551, 31532, 31555, 32084, 32061, 31533, 31556, 32085, 32062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21552, 31533, 31556, 32085, 32062, 31534, 31557, 32086, 32063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21553, 31534, 31557, 32086, 32063, 31535, 31558, 32087, 32064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21554, 31535, 31558, 32087, 32064, 31536, 31559, 32088, 32065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21555, 31536, 31559, 32088, 32065, 31537, 31560, 32089, 32066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21556, 31537, 31560, 32089, 32066, 31538, 31561, 32090, 32067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21557, 31538, 31561, 32090, 32067, 31539, 31562, 32091, 32068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21558, 31539, 31562, 32091, 32068, 31540, 31563, 32092, 32069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21559, 31540, 31563, 32092, 32069, 31541, 31564, 32093, 32070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21560, 31541, 31564, 32093, 32070, 31542, 31565, 32094, 32071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21561, 31542, 31565, 32094, 32071, 31543, 31566, 32095, 32072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21562, 31543, 31566, 32095, 32072, 31544, 31567, 32096, 32073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21563, 31544, 31567, 32096, 32073, 31545, 31568, 32097, 32074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21564, 31545, 31568, 32097, 32074, 31546, 31569, 32098, 32075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21565, 31546, 31569, 32098, 32075, 31547, 31570, 32099, 32076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21566, 31547, 31570, 32099, 32076, 31548, 31571, 32100, 32077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21567, 31548, 31571, 32100, 32077, 31549, 31572, 32101, 32078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21568, 31549, 31572, 32101, 32078, 31550, 31573, 32102, 32079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21569, 31550, 31573, 32102, 32079, 31551, 31574, 32103, 32080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21570, 31551, 31574, 32103, 32080, 31552, 31575, 32104, 32081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21571, 31552, 31575, 32104, 32081, 31553, 31576, 32105, 32082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21572, 31553, 31576, 32105, 32082, 31554, 31577, 32106, 32083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21573, 31554, 31577, 32106, 32083, 8526, 8527, 8550, 8549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21574, 6710, 6711, 6734, 6733, 31555, 31578, 32107, 32084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21575, 31555, 31578, 32107, 32084, 31556, 31579, 32108, 32085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21576, 31556, 31579, 32108, 32085, 31557, 31580, 32109, 32086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21577, 31557, 31580, 32109, 32086, 31558, 31581, 32110, 32087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21578, 31558, 31581, 32110, 32087, 31559, 31582, 32111, 32088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21579, 31559, 31582, 32111, 32088, 31560, 31583, 32112, 32089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21580, 31560, 31583, 32112, 32089, 31561, 31584, 32113, 32090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21581, 31561, 31584, 32113, 32090, 31562, 31585, 32114, 32091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21582, 31562, 31585, 32114, 32091, 31563, 31586, 32115, 32092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21583, 31563, 31586, 32115, 32092, 31564, 31587, 32116, 32093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21584, 31564, 31587, 32116, 32093, 31565, 31588, 32117, 32094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21585, 31565, 31588, 32117, 32094, 31566, 31589, 32118, 32095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21586, 31566, 31589, 32118, 32095, 31567, 31590, 32119, 32096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21587, 31567, 31590, 32119, 32096, 31568, 31591, 32120, 32097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21588, 31568, 31591, 32120, 32097, 31569, 31592, 32121, 32098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21589, 31569, 31592, 32121, 32098, 31570, 31593, 32122, 32099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21590, 31570, 31593, 32122, 32099, 31571, 31594, 32123, 32100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21591, 31571, 31594, 32123, 32100, 31572, 31595, 32124, 32101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21592, 31572, 31595, 32124, 32101, 31573, 31596, 32125, 32102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21593, 31573, 31596, 32125, 32102, 31574, 31597, 32126, 32103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21594, 31574, 31597, 32126, 32103, 31575, 31598, 32127, 32104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21595, 31575, 31598, 32127, 32104, 31576, 31599, 32128, 32105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21596, 31576, 31599, 32128, 32105, 31577, 31600, 32129, 32106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21597, 31577, 31600, 32129, 32106, 8527, 8528, 8551, 8550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21598, 6711, 6712, 6735, 6734, 31578, 31601, 32130, 32107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21599, 31578, 31601, 32130, 32107, 31579, 31602, 32131, 32108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21600, 31579, 31602, 32131, 32108, 31580, 31603, 32132, 32109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21601, 31580, 31603, 32132, 32109, 31581, 31604, 32133, 32110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21602, 31581, 31604, 32133, 32110, 31582, 31605, 32134, 32111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21603, 31582, 31605, 32134, 32111, 31583, 31606, 32135, 32112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21604, 31583, 31606, 32135, 32112, 31584, 31607, 32136, 32113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21605, 31584, 31607, 32136, 32113, 31585, 31608, 32137, 32114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21606, 31585, 31608, 32137, 32114, 31586, 31609, 32138, 32115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21607, 31586, 31609, 32138, 32115, 31587, 31610, 32139, 32116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21608, 31587, 31610, 32139, 32116, 31588, 31611, 32140, 32117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21609, 31588, 31611, 32140, 32117, 31589, 31612, 32141, 32118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21610, 31589, 31612, 32141, 32118, 31590, 31613, 32142, 32119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21611, 31590, 31613, 32142, 32119, 31591, 31614, 32143, 32120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21612, 31591, 31614, 32143, 32120, 31592, 31615, 32144, 32121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21613, 31592, 31615, 32144, 32121, 31593, 31616, 32145, 32122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21614, 31593, 31616, 32145, 32122, 31594, 31617, 32146, 32123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21615, 31594, 31617, 32146, 32123, 31595, 31618, 32147, 32124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21616, 31595, 31618, 32147, 32124, 31596, 31619, 32148, 32125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21617, 31596, 31619, 32148, 32125, 31597, 31620, 32149, 32126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21618, 31597, 31620, 32149, 32126, 31598, 31621, 32150, 32127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21619, 31598, 31621, 32150, 32127, 31599, 31622, 32151, 32128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21620, 31599, 31622, 32151, 32128, 31600, 31623, 32152, 32129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21621, 31600, 31623, 32152, 32129, 8528, 8529, 8552, 8551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21622, 6712, 6713, 6736, 6735, 31601, 31624, 32153, 32130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21623, 31601, 31624, 32153, 32130, 31602, 31625, 32154, 32131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21624, 31602, 31625, 32154, 32131, 31603, 31626, 32155, 32132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21625, 31603, 31626, 32155, 32132, 31604, 31627, 32156, 32133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21626, 31604, 31627, 32156, 32133, 31605, 31628, 32157, 32134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21627, 31605, 31628, 32157, 32134, 31606, 31629, 32158, 32135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21628, 31606, 31629, 32158, 32135, 31607, 31630, 32159, 32136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21629, 31607, 31630, 32159, 32136, 31608, 31631, 32160, 32137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21630, 31608, 31631, 32160, 32137, 31609, 31632, 32161, 32138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21631, 31609, 31632, 32161, 32138, 31610, 31633, 32162, 32139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
21632, 31610, 31633, 32162, 32139, 31611, 31634, 32163, 32140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
