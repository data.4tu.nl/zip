41903, 18521, 18525, 18526, 18522, 18670, 18671, 18672, 18662
41904, 18522, 18526, 2349, 2348, 18672, 18673, 0, 18664
41905, 1167, 1168, 18527, 18523, 0, 18674, 18675, 18665
41906, 18523, 18527, 18528, 18524, 18675, 18676, 18677, 18667
41907, 18524, 18528, 18529, 18525, 18677, 18678, 18679, 18669
41908, 18525, 18529, 18530, 18526, 18679, 18680, 18681, 18671
41909, 18526, 18530, 2350, 2349, 18681, 18682, 0, 18673
41910, 1168, 1169, 18531, 18527, 0, 18683, 18684, 18674
41911, 18527, 18531, 18532, 18528, 18684, 18685, 18686, 18676
41912, 18528, 18532, 18533, 18529, 18686, 18687, 18688, 18678
41913, 18529, 18533, 18534, 18530, 18688, 18689, 18690, 18680
41914, 18530, 18534, 2351, 2350, 18690, 18691, 0, 18682
41915, 1169, 1170, 18535, 18531, 0, 18692, 18693, 18683
41916, 18531, 18535, 18536, 18532, 18693, 18694, 18695, 18685
41917, 18532, 18536, 18537, 18533, 18695, 18696, 18697, 18687
41918, 18533, 18537, 18538, 18534, 18697, 18698, 18699, 18689
41919, 18534, 18538, 2352, 2351, 18699, 18700, 0, 18691
41920, 1170, 1171, 18539, 18535, 0, 18701, 18702, 18692
41921, 18535, 18539, 18540, 18536, 18702, 18703, 18704, 18694
41922, 18536, 18540, 18541, 18537, 18704, 18705, 18706, 18696
41923, 18537, 18541, 18542, 18538, 18706, 18707, 18708, 18698
41924, 18538, 18542, 2353, 2352, 18708, 18709, 0, 18700
41925, 1171, 1172, 18543, 18539, 0, 18710, 18711, 18701
41926, 18539, 18543, 18544, 18540, 18711, 18712, 18713, 18703
41927, 18540, 18544, 18545, 18541, 18713, 18714, 18715, 18705
41928, 18541, 18545, 18546, 18542, 18715, 18716, 18717, 18707
41929, 18542, 18546, 2354, 2353, 18717, 18718, 0, 18709
41930, 1172, 1173, 18547, 18543, 0, 18719, 18720, 18710
41931, 18543, 18547, 18548, 18544, 18720, 18721, 18722, 18712
41932, 18544, 18548, 18549, 18545, 18722, 18723, 18724, 18714
41933, 18545, 18549, 18550, 18546, 18724, 18725, 18726, 18716
41934, 18546, 18550, 2355, 2354, 18726, 18727, 0, 18718
41935, 1173, 1174, 18551, 18547, 0, 18728, 18729, 18719
41936, 18547, 18551, 18552, 18548, 18729, 18730, 18731, 18721
41937, 18548, 18552, 18553, 18549, 18731, 18732, 18733, 18723
41938, 18549, 18553, 18554, 18550, 18733, 18734, 18735, 18725
41939, 18550, 18554, 2356, 2355, 18735, 18736, 0, 18727
41940, 1174, 1175, 18555, 18551, 0, 18737, 18738, 18728
41941, 18551, 18555, 18556, 18552, 18738, 18739, 18740, 18730
41942, 18552, 18556, 18557, 18553, 18740, 18741, 18742, 18732
41943, 18553, 18557, 18558, 18554, 18742, 18743, 18744, 18734
41944, 18554, 18558, 2357, 2356, 18744, 18745, 0, 18736
41945, 1175, 1176, 18559, 18555, 0, 18746, 18747, 18737
41946, 18555, 18559, 18560, 18556, 18747, 18748, 18749, 18739
41947, 18556, 18560, 18561, 18557, 18749, 18750, 18751, 18741
41948, 18557, 18561, 18562, 18558, 18751, 18752, 18753, 18743
41949, 18558, 18562, 2358, 2357, 18753, 18754, 0, 18745
41950, 1176, 1177, 18563, 18559, 0, 18755, 18756, 18746
41951, 18559, 18563, 18564, 18560, 18756, 18757, 18758, 18748
41952, 18560, 18564, 18565, 18561, 18758, 18759, 18760, 18750
41953, 18561, 18565, 18566, 18562, 18760, 18761, 18762, 18752
41954, 18562, 18566, 2359, 2358, 18762, 18763, 0, 18754
41955, 1177, 1178, 18567, 18563, 0, 18764, 18765, 18755
41956, 18563, 18567, 18568, 18564, 18765, 18766, 18767, 18757
41957, 18564, 18568, 18569, 18565, 18767, 18768, 18769, 18759
41958, 18565, 18569, 18570, 18566, 18769, 18770, 18771, 18761
41959, 18566, 18570, 2360, 2359, 18771, 18772, 0, 18763
41960, 1178, 1179, 18571, 18567, 0, 18773, 18774, 18764
41961, 18567, 18571, 18572, 18568, 18774, 18775, 18776, 18766
41962, 18568, 18572, 18573, 18569, 18776, 18777, 18778, 18768
41963, 18569, 18573, 18574, 18570, 18778, 18779, 18780, 18770
41964, 18570, 18574, 2361, 2360, 18780, 18781, 0, 18772
41965, 1179, 48, 2330, 18571, 0, 2334, 18782, 18773
41966, 18571, 2330, 2331, 18572, 18782, 2335, 18783, 18775
41967, 18572, 2331, 2332, 18573, 18783, 2336, 18784, 18777
41968, 18573, 2332, 2333, 18574, 18784, 2337, 18785, 18779
41969, 18574, 2333, 94, 2361, 18785, 2338, 0, 18781
*ELEMENT, type=CPS8, ELSET=Surface129
41970, 47, 2321, 18786, 1180, 2325, 18830, 18831, 0
41971, 2321, 2322, 18787, 18786, 2326, 18832, 18833, 18830
41972, 2322, 2323, 18788, 18787, 2327, 18834, 18835, 18832
41973, 2323, 2324, 18789, 18788, 2328, 18836, 18837, 18834
41974, 2324, 93, 2362, 18789, 2329, 0, 18838, 18836
41975, 1180, 18786, 18790, 1181, 18831, 18839, 18840, 0
41976, 18786, 18787, 18791, 18790, 18833, 18841, 18842, 18839
41977, 18787, 18788, 18792, 18791, 18835, 18843, 18844, 18841
41978, 18788, 18789, 18793, 18792, 18837, 18845, 18846, 18843
41979, 18789, 2362, 2363, 18793, 18838, 0, 18847, 18845
41980, 1181, 18790, 18794, 1182, 18840, 18848, 18849, 0
41981, 18790, 18791, 18795, 18794, 18842, 18850, 18851, 18848
41982, 18791, 18792, 18796, 18795, 18844, 18852, 18853, 18850
41983, 18792, 18793, 18797, 18796, 18846, 18854, 18855, 18852
41984, 18793, 2363, 2364, 18797, 18847, 0, 18856, 18854
41985, 1182, 18794, 18798, 1183, 18849, 18857, 18858, 0
41986, 18794, 18795, 18799, 18798, 18851, 18859, 18860, 18857
41987, 18795, 18796, 18800, 18799, 18853, 18861, 18862, 18859
41988, 18796, 18797, 18801, 18800, 18855, 18863, 18864, 18861
41989, 18797, 2364, 2365, 18801, 18856, 0, 18865, 18863
41990, 1183, 18798, 18802, 1184, 18858, 18866, 18867, 0
41991, 18798, 18799, 18803, 18802, 18860, 18868, 18869, 18866
41992, 18799, 18800, 18804, 18803, 18862, 18870, 18871, 18868
41993, 18800, 18801, 18805, 18804, 18864, 18872, 18873, 18870
41994, 18801, 2365, 2366, 18805, 18865, 0, 18874, 18872
41995, 1184, 18802, 18806, 1185, 18867, 18875, 18876, 0
41996, 18802, 18803, 18807, 18806, 18869, 18877, 18878, 18875
41997, 18803, 18804, 18808, 18807, 18871, 18879, 18880, 18877
41998, 18804, 18805, 18809, 18808, 18873, 18881, 18882, 18879
41999, 18805, 2366, 2367, 18809, 18874, 0, 18883, 18881
42000, 1185, 18806, 18810, 1186, 18876, 18884, 18885, 0
42001, 18806, 18807, 18811, 18810, 18878, 18886, 18887, 18884
42002, 18807, 18808, 18812, 18811, 18880, 18888, 18889, 18886
42003, 18808, 18809, 18813, 18812, 18882, 18890, 18891, 18888
42004, 18809, 2367, 2368, 18813, 18883, 0, 18892, 18890
42005, 1186, 18810, 18814, 1187, 18885, 18893, 18894, 0
42006, 18810, 18811, 18815, 18814, 18887, 18895, 18896, 18893
42007, 18811, 18812, 18816, 18815, 18889, 18897, 18898, 18895
42008, 18812, 18813, 18817, 18816, 18891, 18899, 18900, 18897
42009, 18813, 2368, 2369, 18817, 18892, 0, 18901, 18899
42010, 1187, 18814, 18818, 1188, 18894, 18902, 18903, 0
42011, 18814, 18815, 18819, 18818, 18896, 18904, 18905, 18902
42012, 18815, 18816, 18820, 18819, 18898, 18906, 18907, 18904
42013, 18816, 18817, 18821, 18820, 18900, 18908, 18909, 18906
42014, 18817, 2369, 2370, 18821, 18901, 0, 18910, 18908
42015, 1188, 18818, 18822, 1189, 18903, 18911, 18912, 0
42016, 18818, 18819, 18823, 18822, 18905, 18913, 18914, 18911
42017, 18819, 18820, 18824, 18823, 18907, 18915, 18916, 18913
42018, 18820, 18821, 18825, 18824, 18909, 18917, 18918, 18915
42019, 18821, 2370, 2371, 18825, 18910, 0, 18919, 18917
42020, 1189, 18822, 18826, 1190, 18912, 18920, 18921, 0
42021, 18822, 18823, 18827, 18826, 18914, 18922, 18923, 18920
42022, 18823, 18824, 18828, 18827, 18916, 18924, 18925, 18922
42023, 18824, 18825, 18829, 18828, 18918, 18926, 18927, 18924
42024, 18825, 2371, 2372, 18829, 18919, 0, 18928, 18926
42025, 1190, 18826, 2290, 45, 18921, 18929, 0, 0
42026, 18826, 18827, 2291, 2290, 18923, 18930, 0, 18929
42027, 18827, 18828, 2292, 2291, 18925, 18931, 0, 18930
42028, 18828, 18829, 2293, 2292, 18927, 18932, 0, 18931
42029, 18829, 2372, 91, 2293, 18928, 0, 0, 18932
*ELEMENT, type=CPS8, ELSET=Surface130
42030, 48, 1191, 18933, 2330, 0, 18977, 18978, 2334
42031, 2330, 18933, 18934, 2331, 18978, 18979, 18980, 2335
42032, 2331, 18934, 18935, 2332, 18980, 18981, 18982, 2336
42033, 2332, 18935, 18936, 2333, 18982, 18983, 18984, 2337
42034, 2333, 18936, 2373, 94, 18984, 18985, 0, 2338
42035, 1191, 1192, 18937, 18933, 0, 18986, 18987, 18977
42036, 18933, 18937, 18938, 18934, 18987, 18988, 18989, 18979
42037, 18934, 18938, 18939, 18935, 18989, 18990, 18991, 18981
42038, 18935, 18939, 18940, 18936, 18991, 18992, 18993, 18983
42039, 18936, 18940, 2374, 2373, 18993, 18994, 0, 18985
42040, 1192, 1193, 18941, 18937, 0, 18995, 18996, 18986
42041, 18937, 18941, 18942, 18938, 18996, 18997, 18998, 18988
42042, 18938, 18942, 18943, 18939, 18998, 18999, 19000, 18990
42043, 18939, 18943, 18944, 18940, 19000, 19001, 19002, 18992
42044, 18940, 18944, 2375, 2374, 19002, 19003, 0, 18994
42045, 1193, 1194, 18945, 18941, 0, 19004, 19005, 18995
42046, 18941, 18945, 18946, 18942, 19005, 19006, 19007, 18997
42047, 18942, 18946, 18947, 18943, 19007, 19008, 19009, 18999
42048, 18943, 18947, 18948, 18944, 19009, 19010, 19011, 19001
42049, 18944, 18948, 2376, 2375, 19011, 19012, 0, 19003
42050, 1194, 1195, 18949, 18945, 0, 19013, 19014, 19004
42051, 18945, 18949, 18950, 18946, 19014, 19015, 19016, 19006
42052, 18946, 18950, 18951, 18947, 19016, 19017, 19018, 19008
42053, 18947, 18951, 18952, 18948, 19018, 19019, 19020, 19010
42054, 18948, 18952, 2377, 2376, 19020, 19021, 0, 19012
42055, 1195, 1196, 18953, 18949, 0, 19022, 19023, 19013
42056, 18949, 18953, 18954, 18950, 19023, 19024, 19025, 19015
42057, 18950, 18954, 18955, 18951, 19025, 19026, 19027, 19017
42058, 18951, 18955, 18956, 18952, 19027, 19028, 19029, 19019
42059, 18952, 18956, 2378, 2377, 19029, 19030, 0, 19021
42060, 1196, 1197, 18957, 18953, 0, 19031, 19032, 19022
42061, 18953, 18957, 18958, 18954, 19032, 19033, 19034, 19024
42062, 18954, 18958, 18959, 18955, 19034, 19035, 19036, 19026
42063, 18955, 18959, 18960, 18956, 19036, 19037, 19038, 19028
42064, 18956, 18960, 2379, 2378, 19038, 19039, 0, 19030
42065, 1197, 1198, 18961, 18957, 0, 19040, 19041, 19031
42066, 18957, 18961, 18962, 18958, 19041, 19042, 19043, 19033
42067, 18958, 18962, 18963, 18959, 19043, 19044, 19045, 19035
42068, 18959, 18963, 18964, 18960, 19045, 19046, 19047, 19037
42069, 18960, 18964, 2380, 2379, 19047, 19048, 0, 19039
42070, 1198, 1199, 18965, 18961, 0, 19049, 19050, 19040
42071, 18961, 18965, 18966, 18962, 19050, 19051, 19052, 19042
42072, 18962, 18966, 18967, 18963, 19052, 19053, 19054, 19044
42073, 18963, 18967, 18968, 18964, 19054, 19055, 19056, 19046
42074, 18964, 18968, 2381, 2380, 19056, 19057, 0, 19048
42075, 1199, 1200, 18969, 18965, 0, 19058, 19059, 19049
42076, 18965, 18969, 18970, 18966, 19059, 19060, 19061, 19051
42077, 18966, 18970, 18971, 18967, 19061, 19062, 19063, 19053
42078, 18967, 18971, 18972, 18968, 19063, 19064, 19065, 19055
42079, 18968, 18972, 2382, 2381, 19065, 19066, 0, 19057
42080, 1200, 1201, 18973, 18969, 0, 19067, 19068, 19058
42081, 18969, 18973, 18974, 18970, 19068, 19069, 19070, 19060
42082, 18970, 18974, 18975, 18971, 19070, 19071, 19072, 19062
42083, 18971, 18975, 18976, 18972, 19072, 19073, 19074, 19064
42084, 18972, 18976, 2383, 2382, 19074, 19075, 0, 19066
42085, 1201, 46, 2294, 18973, 0, 0, 19076, 19067
42086, 18973, 2294, 2295, 18974, 19076, 0, 19077, 19069
42087, 18974, 2295, 2296, 18975, 19077, 0, 19078, 19071
42088, 18975, 2296, 2297, 18976, 19078, 0, 19079, 19073
42089, 18976, 2297, 92, 2383, 19079, 0, 0, 19075
*ELEMENT, type=CPS8, ELSET=Surface131
5081, 93, 2339, 19080, 2362, 0, 0, 0, 0
5082, 2339, 2340, 19081, 19080, 0, 0, 0, 0
5083, 2340, 2341, 19082, 19081, 0, 0, 0, 0
5084, 2341, 2342, 19083, 19082, 0, 0, 0, 0
5085, 2342, 2343, 19084, 19083, 0, 0, 0, 0
5086, 2343, 2344, 19085, 19084, 0, 0, 0, 0
5087, 2344, 2345, 19086, 19085, 0, 0, 0, 0
5088, 2345, 2346, 19087, 19086, 0, 0, 0, 0
5089, 2346, 2347, 19088, 19087, 0, 0, 0, 0
5090, 2347, 2348, 19089, 19088, 0, 0, 0, 0
5091, 2348, 2349, 19090, 19089, 0, 0, 0, 0
5092, 2349, 2350, 19091, 19090, 0, 0, 0, 0
5093, 2350, 2351, 19092, 19091, 0, 0, 0, 0
5094, 2351, 2352, 19093, 19092, 0, 0, 0, 0
5095, 2352, 2353, 19094, 19093, 0, 0, 0, 0
5096, 2353, 2354, 19095, 19094, 0, 0, 0, 0
5097, 2354, 2355, 19096, 19095, 0, 0, 0, 0
5098, 2355, 2356, 19097, 19096, 0, 0, 0, 0
5099, 2356, 2357, 19098, 19097, 0, 0, 0, 0
5100, 2357, 2358, 19099, 19098, 0, 0, 0, 0
5101, 2358, 2359, 19100, 19099, 0, 0, 0, 0
5102, 2359, 2360, 19101, 19100, 0, 0, 0, 0
5103, 2360, 2361, 19102, 19101, 0, 0, 0, 0
5104, 2361, 94, 2373, 19102, 0, 0, 0, 0
5105, 2362, 19080, 19103, 2363, 0, 0, 0, 0
5106, 19080, 19081, 19104, 19103, 0, 0, 0, 0
5107, 19081, 19082, 19105, 19104, 0, 0, 0, 0
5108, 19082, 19083, 19106, 19105, 0, 0, 0, 0
5109, 19083, 19084, 19107, 19106, 0, 0, 0, 0
5110, 19084, 19085, 19108, 19107, 0, 0, 0, 0
5111, 19085, 19086, 19109, 19108, 0, 0, 0, 0
5112, 19086, 19087, 19110, 19109, 0, 0, 0, 0
5113, 19087, 19088, 19111, 19110, 0, 0, 0, 0
5114, 19088, 19089, 19112, 19111, 0, 0, 0, 0
5115, 19089, 19090, 19113, 19112, 0, 0, 0, 0
5116, 19090, 19091, 19114, 19113, 0, 0, 0, 0
5117, 19091, 19092, 19115, 19114, 0, 0, 0, 0
5118, 19092, 19093, 19116, 19115, 0, 0, 0, 0
5119, 19093, 19094, 19117, 19116, 0, 0, 0, 0
5120, 19094, 19095, 19118, 19117, 0, 0, 0, 0
5121, 19095, 19096, 19119, 19118, 0, 0, 0, 0
5122, 19096, 19097, 19120, 19119, 0, 0, 0, 0
5123, 19097, 19098, 19121, 19120, 0, 0, 0, 0
5124, 19098, 19099, 19122, 19121, 0, 0, 0, 0
5125, 19099, 19100, 19123, 19122, 0, 0, 0, 0
5126, 19100, 19101, 19124, 19123, 0, 0, 0, 0
5127, 19101, 19102, 19125, 19124, 0, 0, 0, 0
5128, 19102, 2373, 2374, 19125, 0, 0, 0, 0
5129, 2363, 19103, 19126, 2364, 0, 0, 0, 0
5130, 19103, 19104, 19127, 19126, 0, 0, 0, 0
5131, 19104, 19105, 19128, 19127, 0, 0, 0, 0
5132, 19105, 19106, 19129, 19128, 0, 0, 0, 0
5133, 19106, 19107, 19130, 19129, 0, 0, 0, 0
5134, 19107, 19108, 19131, 19130, 0, 0, 0, 0
5135, 19108, 19109, 19132, 19131, 0, 0, 0, 0
5136, 19109, 19110, 19133, 19132, 0, 0, 0, 0
5137, 19110, 19111, 19134, 19133, 0, 0, 0, 0
5138, 19111, 19112, 19135, 19134, 0, 0, 0, 0
5139, 19112, 19113, 19136, 19135, 0, 0, 0, 0
5140, 19113, 19114, 19137, 19136, 0, 0, 0, 0
5141, 19114, 19115, 19138, 19137, 0, 0, 0, 0
5142, 19115, 19116, 19139, 19138, 0, 0, 0, 0
5143, 19116, 19117, 19140, 19139, 0, 0, 0, 0
5144, 19117, 19118, 19141, 19140, 0, 0, 0, 0
5145, 19118, 19119, 19142, 19141, 0, 0, 0, 0
5146, 19119, 19120, 19143, 19142, 0, 0, 0, 0
5147, 19120, 19121, 19144, 19143, 0, 0, 0, 0
5148, 19121, 19122, 19145, 19144, 0, 0, 0, 0
5149, 19122, 19123, 19146, 19145, 0, 0, 0, 0
5150, 19123, 19124, 19147, 19146, 0, 0, 0, 0
5151, 19124, 19125, 19148, 19147, 0, 0, 0, 0
5152, 19125, 2374, 2375, 19148, 0, 0, 0, 0
5153, 2364, 19126, 19149, 2365, 0, 0, 0, 0
5154, 19126, 19127, 19150, 19149, 0, 0, 0, 0
5155, 19127, 19128, 19151, 19150, 0, 0, 0, 0
5156, 19128, 19129, 19152, 19151, 0, 0, 0, 0
5157, 19129, 19130, 19153, 19152, 0, 0, 0, 0
5158, 19130, 19131, 19154, 19153, 0, 0, 0, 0
5159, 19131, 19132, 19155, 19154, 0, 0, 0, 0
5160, 19132, 19133, 19156, 19155, 0, 0, 0, 0
5161, 19133, 19134, 19157, 19156, 0, 0, 0, 0
5162, 19134, 19135, 19158, 19157, 0, 0, 0, 0
5163, 19135, 19136, 19159, 19158, 0, 0, 0, 0
5164, 19136, 19137, 19160, 19159, 0, 0, 0, 0
5165, 19137, 19138, 19161, 19160, 0, 0, 0, 0
5166, 19138, 19139, 19162, 19161, 0, 0, 0, 0
5167, 19139, 19140, 19163, 19162, 0, 0, 0, 0
5168, 19140, 19141, 19164, 19163, 0, 0, 0, 0
5169, 19141, 19142, 19165, 19164, 0, 0, 0, 0
5170, 19142, 19143, 19166, 19165, 0, 0, 0, 0
5171, 19143, 19144, 19167, 19166, 0, 0, 0, 0
5172, 19144, 19145, 19168, 19167, 0, 0, 0, 0
5173, 19145, 19146, 19169, 19168, 0, 0, 0, 0
5174, 19146, 19147, 19170, 19169, 0, 0, 0, 0
5175, 19147, 19148, 19171, 19170, 0, 0, 0, 0
5176, 19148, 2375, 2376, 19171, 0, 0, 0, 0
5177, 2365, 19149, 19172, 2366, 0, 0, 0, 0
5178, 19149, 19150, 19173, 19172, 0, 0, 0, 0
5179, 19150, 19151, 19174, 19173, 0, 0, 0, 0
5180, 19151, 19152, 19175, 19174, 0, 0, 0, 0
5181, 19152, 19153, 19176, 19175, 0, 0, 0, 0
5182, 19153, 19154, 19177, 19176, 0, 0, 0, 0
5183, 19154, 19155, 19178, 19177, 0, 0, 0, 0
5184, 19155, 19156, 19179, 19178, 0, 0, 0, 0
5185, 19156, 19157, 19180, 19179, 0, 0, 0, 0
5186, 19157, 19158, 19181, 19180, 0, 0, 0, 0
5187, 19158, 19159, 19182, 19181, 0, 0, 0, 0
5188, 19159, 19160, 19183, 19182, 0, 0, 0, 0
5189, 19160, 19161, 19184, 19183, 0, 0, 0, 0
5190, 19161, 19162, 19185, 19184, 0, 0, 0, 0
5191, 19162, 19163, 19186, 19185, 0, 0, 0, 0
5192, 19163, 19164, 19187, 19186, 0, 0, 0, 0
5193, 19164, 19165, 19188, 19187, 0, 0, 0, 0
5194, 19165, 19166, 19189, 19188, 0, 0, 0, 0
5195, 19166, 19167, 19190, 19189, 0, 0, 0, 0
5196, 19167, 19168, 19191, 19190, 0, 0, 0, 0
5197, 19168, 19169, 19192, 19191, 0, 0, 0, 0
5198, 19169, 19170, 19193, 19192, 0, 0, 0, 0
5199, 19170, 19171, 19194, 19193, 0, 0, 0, 0
5200, 19171, 2376, 2377, 19194, 0, 0, 0, 0
5201, 2366, 19172, 19195, 2367, 0, 0, 0, 0
5202, 19172, 19173, 19196, 19195, 0, 0, 0, 0
5203, 19173, 19174, 19197, 19196, 0, 0, 0, 0
5204, 19174, 19175, 19198, 19197, 0, 0, 0, 0
5205, 19175, 19176, 19199, 19198, 0, 0, 0, 0
5206, 19176, 19177, 19200, 19199, 0, 0, 0, 0
5207, 19177, 19178, 19201, 19200, 0, 0, 0, 0
5208, 19178, 19179, 19202, 19201, 0, 0, 0, 0
5209, 19179, 19180, 19203, 19202, 0, 0, 0, 0
5210, 19180, 19181, 19204, 19203, 0, 0, 0, 0
5211, 19181, 19182, 19205, 19204, 0, 0, 0, 0
5212, 19182, 19183, 19206, 19205, 0, 0, 0, 0
5213, 19183, 19184, 19207, 19206, 0, 0, 0, 0
5214, 19184, 19185, 19208, 19207, 0, 0, 0, 0
5215, 19185, 19186, 19209, 19208, 0, 0, 0, 0
5216, 19186, 19187, 19210, 19209, 0, 0, 0, 0
5217, 19187, 19188, 19211, 19210, 0, 0, 0, 0
5218, 19188, 19189, 19212, 19211, 0, 0, 0, 0
5219, 19189, 19190, 19213, 19212, 0, 0, 0, 0
5220, 19190, 19191, 19214, 19213, 0, 0, 0, 0
5221, 19191, 19192, 19215, 19214, 0, 0, 0, 0
5222, 19192, 19193, 19216, 19215, 0, 0, 0, 0
5223, 19193, 19194, 19217, 19216, 0, 0, 0, 0
5224, 19194, 2377, 2378, 19217, 0, 0, 0, 0
5225, 2367, 19195, 19218, 2368, 0, 0, 0, 0
5226, 19195, 19196, 19219, 19218, 0, 0, 0, 0
5227, 19196, 19197, 19220, 19219, 0, 0, 0, 0
5228, 19197, 19198, 19221, 19220, 0, 0, 0, 0
5229, 19198, 19199, 19222, 19221, 0, 0, 0, 0
5230, 19199, 19200, 19223, 19222, 0, 0, 0, 0
5231, 19200, 19201, 19224, 19223, 0, 0, 0, 0
5232, 19201, 19202, 19225, 19224, 0, 0, 0, 0
5233, 19202, 19203, 19226, 19225, 0, 0, 0, 0
5234, 19203, 19204, 19227, 19226, 0, 0, 0, 0
5235, 19204, 19205, 19228, 19227, 0, 0, 0, 0
5236, 19205, 19206, 19229, 19228, 0, 0, 0, 0
5237, 19206, 19207, 19230, 19229, 0, 0, 0, 0
5238, 19207, 19208, 19231, 19230, 0, 0, 0, 0
5239, 19208, 19209, 19232, 19231, 0, 0, 0, 0
5240, 19209, 19210, 19233, 19232, 0, 0, 0, 0
5241, 19210, 19211, 19234, 19233, 0, 0, 0, 0
5242, 19211, 19212, 19235, 19234, 0, 0, 0, 0
5243, 19212, 19213, 19236, 19235, 0, 0, 0, 0
5244, 19213, 19214, 19237, 19236, 0, 0, 0, 0
5245, 19214, 19215, 19238, 19237, 0, 0, 0, 0
5246, 19215, 19216, 19239, 19238, 0, 0, 0, 0
5247, 19216, 19217, 19240, 19239, 0, 0, 0, 0
5248, 19217, 2378, 2379, 19240, 0, 0, 0, 0
5249, 2368, 19218, 19241, 2369, 0, 0, 0, 0
5250, 19218, 19219, 19242, 19241, 0, 0, 0, 0
5251, 19219, 19220, 19243, 19242, 0, 0, 0, 0
5252, 19220, 19221, 19244, 19243, 0, 0, 0, 0
5253, 19221, 19222, 19245, 19244, 0, 0, 0, 0
5254, 19222, 19223, 19246, 19245, 0, 0, 0, 0
5255, 19223, 19224, 19247, 19246, 0, 0, 0, 0
5256, 19224, 19225, 19248, 19247, 0, 0, 0, 0
5257, 19225, 19226, 19249, 19248, 0, 0, 0, 0
5258, 19226, 19227, 19250, 19249, 0, 0, 0, 0
5259, 19227, 19228, 19251, 19250, 0, 0, 0, 0
5260, 19228, 19229, 19252, 19251, 0, 0, 0, 0
5261, 19229, 19230, 19253, 19252, 0, 0, 0, 0
5262, 19230, 19231, 19254, 19253, 0, 0, 0, 0
5263, 19231, 19232, 19255, 19254, 0, 0, 0, 0
5264, 19232, 19233, 19256, 19255, 0, 0, 0, 0
5265, 19233, 19234, 19257, 19256, 0, 0, 0, 0
5266, 19234, 19235, 19258, 19257, 0, 0, 0, 0
5267, 19235, 19236, 19259, 19258, 0, 0, 0, 0
5268, 19236, 19237, 19260, 19259, 0, 0, 0, 0
5269, 19237, 19238, 19261, 19260, 0, 0, 0, 0
5270, 19238, 19239, 19262, 19261, 0, 0, 0, 0
5271, 19239, 19240, 19263, 19262, 0, 0, 0, 0
5272, 19240, 2379, 2380, 19263, 0, 0, 0, 0
5273, 2369, 19241, 19264, 2370, 0, 0, 0, 0
5274, 19241, 19242, 19265, 19264, 0, 0, 0, 0
5275, 19242, 19243, 19266, 19265, 0, 0, 0, 0
5276, 19243, 19244, 19267, 19266, 0, 0, 0, 0
5277, 19244, 19245, 19268, 19267, 0, 0, 0, 0
5278, 19245, 19246, 19269, 19268, 0, 0, 0, 0
5279, 19246, 19247, 19270, 19269, 0, 0, 0, 0
5280, 19247, 19248, 19271, 19270, 0, 0, 0, 0
5281, 19248, 19249, 19272, 19271, 0, 0, 0, 0
5282, 19249, 19250, 19273, 19272, 0, 0, 0, 0
5283, 19250, 19251, 19274, 19273, 0, 0, 0, 0
5284, 19251, 19252, 19275, 19274, 0, 0, 0, 0
5285, 19252, 19253, 19276, 19275, 0, 0, 0, 0
5286, 19253, 19254, 19277, 19276, 0, 0, 0, 0
5287, 19254, 19255, 19278, 19277, 0, 0, 0, 0
5288, 19255, 19256, 19279, 19278, 0, 0, 0, 0
5289, 19256, 19257, 19280, 19279, 0, 0, 0, 0
5290, 19257, 19258, 19281, 19280, 0, 0, 0, 0
5291, 19258, 19259, 19282, 19281, 0, 0, 0, 0
5292, 19259, 19260, 19283, 19282, 0, 0, 0, 0
5293, 19260, 19261, 19284, 19283, 0, 0, 0, 0
5294, 19261, 19262, 19285, 19284, 0, 0, 0, 0
5295, 19262, 19263, 19286, 19285, 0, 0, 0, 0
5296, 19263, 2380, 2381, 19286, 0, 0, 0, 0
5297, 2370, 19264, 19287, 2371, 0, 0, 0, 0
5298, 19264, 19265, 19288, 19287, 0, 0, 0, 0
5299, 19265, 19266, 19289, 19288, 0, 0, 0, 0
5300, 19266, 19267, 19290, 19289, 0, 0, 0, 0
5301, 19267, 19268, 19291, 19290, 0, 0, 0, 0
5302, 19268, 19269, 19292, 19291, 0, 0, 0, 0
5303, 19269, 19270, 19293, 19292, 0, 0, 0, 0
5304, 19270, 19271, 19294, 19293, 0, 0, 0, 0
5305, 19271, 19272, 19295, 19294, 0, 0, 0, 0
5306, 19272, 19273, 19296, 19295, 0, 0, 0, 0
5307, 19273, 19274, 19297, 19296, 0, 0, 0, 0
5308, 19274, 19275, 19298, 19297, 0, 0, 0, 0
5309, 19275, 19276, 19299, 19298, 0, 0, 0, 0
5310, 19276, 19277, 19300, 19299, 0, 0, 0, 0
5311, 19277, 19278, 19301, 19300, 0, 0, 0, 0
5312, 19278, 19279, 19302, 19301, 0, 0, 0, 0
5313, 19279, 19280, 19303, 19302, 0, 0, 0, 0
5314, 19280, 19281, 19304, 19303, 0, 0, 0, 0
5315, 19281, 19282, 19305, 19304, 0, 0, 0, 0
5316, 19282, 19283, 19306, 19305, 0, 0, 0, 0
5317, 19283, 19284, 19307, 19306, 0, 0, 0, 0
5318, 19284, 19285, 19308, 19307, 0, 0, 0, 0
5319, 19285, 19286, 19309, 19308, 0, 0, 0, 0
5320, 19286, 2381, 2382, 19309, 0, 0, 0, 0
5321, 2371, 19287, 19310, 2372, 0, 0, 0, 0
5322, 19287, 19288, 19311, 19310, 0, 0, 0, 0
5323, 19288, 19289, 19312, 19311, 0, 0, 0, 0
5324, 19289, 19290, 19313, 19312, 0, 0, 0, 0
5325, 19290, 19291, 19314, 19313, 0, 0, 0, 0
5326, 19291, 19292, 19315, 19314, 0, 0, 0, 0
5327, 19292, 19293, 19316, 19315, 0, 0, 0, 0
5328, 19293, 19294, 19317, 19316, 0, 0, 0, 0
5329, 19294, 19295, 19318, 19317, 0, 0, 0, 0
5330, 19295, 19296, 19319, 19318, 0, 0, 0, 0
5331, 19296, 19297, 19320, 19319, 0, 0, 0, 0
5332, 19297, 19298, 19321, 19320, 0, 0, 0, 0
5333, 19298, 19299, 19322, 19321, 0, 0, 0, 0
5334, 19299, 19300, 19323, 19322, 0, 0, 0, 0
5335, 19300, 19301, 19324, 19323, 0, 0, 0, 0
5336, 19301, 19302, 19325, 19324, 0, 0, 0, 0
5337, 19302, 19303, 19326, 19325, 0, 0, 0, 0
5338, 19303, 19304, 19327, 19326, 0, 0, 0, 0
5339, 19304, 19305, 19328, 19327, 0, 0, 0, 0
5340, 19305, 19306, 19329, 19328, 0, 0, 0, 0
5341, 19306, 19307, 19330, 19329, 0, 0, 0, 0
5342, 19307, 19308, 19331, 19330, 0, 0, 0, 0
5343, 19308, 19309, 19332, 19331, 0, 0, 0, 0
5344, 19309, 2382, 2383, 19332, 0, 0, 0, 0
5345, 2372, 19310, 2298, 91, 0, 0, 0, 0
5346, 19310, 19311, 2299, 2298, 0, 0, 0, 0
5347, 19311, 19312, 2300, 2299, 0, 0, 0, 0
5348, 19312, 19313, 2301, 2300, 0, 0, 0, 0
5349, 19313, 19314, 2302, 2301, 0, 0, 0, 0
5350, 19314, 19315, 2303, 2302, 0, 0, 0, 0
5351, 19315, 19316, 2304, 2303, 0, 0, 0, 0
5352, 19316, 19317, 2305, 2304, 0, 0, 0, 0
5353, 19317, 19318, 2306, 2305, 0, 0, 0, 0
5354, 19318, 19319, 2307, 2306, 0, 0, 0, 0
5355, 19319, 19320, 2308, 2307, 0, 0, 0, 0
5356, 19320, 19321, 2309, 2308, 0, 0, 0, 0
5357, 19321, 19322, 2310, 2309, 0, 0, 0, 0
5358, 19322, 19323, 2311, 2310, 0, 0, 0, 0
5359, 19323, 19324, 2312, 2311, 0, 0, 0, 0
5360, 19324, 19325, 2313, 2312, 0, 0, 0, 0
5361, 19325, 19326, 2314, 2313, 0, 0, 0, 0
5362, 19326, 19327, 2315, 2314, 0, 0, 0, 0
5363, 19327, 19328, 2316, 2315, 0, 0, 0, 0
5364, 19328, 19329, 2317, 2316, 0, 0, 0, 0
5365, 19329, 19330, 2318, 2317, 0, 0, 0, 0
5366, 19330, 19331, 2319, 2318, 0, 0, 0, 0
5367, 19331, 19332, 2320, 2319, 0, 0, 0, 0
5368, 19332, 2383, 92, 2320, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface132
5369, 46, 2294, 2384, 50, 0, 0, 0, 0
5370, 2294, 2295, 2385, 2384, 0, 0, 0, 0
5371, 2295, 2296, 2386, 2385, 0, 0, 0, 0
5372, 2296, 2297, 2387, 2386, 0, 0, 0, 0
5373, 2297, 92, 95, 2387, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface133
42090, 48, 52, 2388, 2330, 0, 2392, 19333, 2334
42091, 2330, 2388, 2389, 2331, 19333, 2393, 19334, 2335
42092, 2331, 2389, 2390, 2332, 19334, 2394, 19335, 2336
42093, 2332, 2390, 2391, 2333, 19335, 2395, 19336, 2337
42094, 2333, 2391, 96, 94, 19336, 2396, 0, 2338
*ELEMENT, type=CPS8, ELSET=Surface134
42095, 52, 1217, 19337, 2388, 0, 19381, 19382, 2392
42096, 2388, 19337, 19338, 2389, 19382, 19383, 19384, 2393
42097, 2389, 19338, 19339, 2390, 19384, 19385, 19386, 2394
42098, 2390, 19339, 19340, 2391, 19386, 19387, 19388, 2395
42099, 2391, 19340, 2397, 96, 19388, 19389, 0, 2396
42100, 1217, 1218, 19341, 19337, 0, 19390, 19391, 19381
42101, 19337, 19341, 19342, 19338, 19391, 19392, 19393, 19383
42102, 19338, 19342, 19343, 19339, 19393, 19394, 19395, 19385
42103, 19339, 19343, 19344, 19340, 19395, 19396, 19397, 19387
42104, 19340, 19344, 2398, 2397, 19397, 19398, 0, 19389
42105, 1218, 1219, 19345, 19341, 0, 19399, 19400, 19390
42106, 19341, 19345, 19346, 19342, 19400, 19401, 19402, 19392
42107, 19342, 19346, 19347, 19343, 19402, 19403, 19404, 19394
42108, 19343, 19347, 19348, 19344, 19404, 19405, 19406, 19396
42109, 19344, 19348, 2399, 2398, 19406, 19407, 0, 19398
42110, 1219, 1220, 19349, 19345, 0, 19408, 19409, 19399
42111, 19345, 19349, 19350, 19346, 19409, 19410, 19411, 19401
42112, 19346, 19350, 19351, 19347, 19411, 19412, 19413, 19403
42113, 19347, 19351, 19352, 19348, 19413, 19414, 19415, 19405
42114, 19348, 19352, 2400, 2399, 19415, 19416, 0, 19407
42115, 1220, 1221, 19353, 19349, 0, 19417, 19418, 19408
42116, 19349, 19353, 19354, 19350, 19418, 19419, 19420, 19410
42117, 19350, 19354, 19355, 19351, 19420, 19421, 19422, 19412
42118, 19351, 19355, 19356, 19352, 19422, 19423, 19424, 19414
42119, 19352, 19356, 2401, 2400, 19424, 19425, 0, 19416
42120, 1221, 1222, 19357, 19353, 0, 19426, 19427, 19417
42121, 19353, 19357, 19358, 19354, 19427, 19428, 19429, 19419
42122, 19354, 19358, 19359, 19355, 19429, 19430, 19431, 19421
42123, 19355, 19359, 19360, 19356, 19431, 19432, 19433, 19423
42124, 19356, 19360, 2402, 2401, 19433, 19434, 0, 19425
42125, 1222, 1223, 19361, 19357, 0, 19435, 19436, 19426
42126, 19357, 19361, 19362, 19358, 19436, 19437, 19438, 19428
42127, 19358, 19362, 19363, 19359, 19438, 19439, 19440, 19430
42128, 19359, 19363, 19364, 19360, 19440, 19441, 19442, 19432
42129, 19360, 19364, 2403, 2402, 19442, 19443, 0, 19434
42130, 1223, 1224, 19365, 19361, 0, 19444, 19445, 19435
42131, 19361, 19365, 19366, 19362, 19445, 19446, 19447, 19437
42132, 19362, 19366, 19367, 19363, 19447, 19448, 19449, 19439
42133, 19363, 19367, 19368, 19364, 19449, 19450, 19451, 19441
42134, 19364, 19368, 2404, 2403, 19451, 19452, 0, 19443
42135, 1224, 1225, 19369, 19365, 0, 19453, 19454, 19444
42136, 19365, 19369, 19370, 19366, 19454, 19455, 19456, 19446
42137, 19366, 19370, 19371, 19367, 19456, 19457, 19458, 19448
42138, 19367, 19371, 19372, 19368, 19458, 19459, 19460, 19450
42139, 19368, 19372, 2405, 2404, 19460, 19461, 0, 19452
42140, 1225, 1226, 19373, 19369, 0, 19462, 19463, 19453
42141, 19369, 19373, 19374, 19370, 19463, 19464, 19465, 19455
42142, 19370, 19374, 19375, 19371, 19465, 19466, 19467, 19457
42143, 19371, 19375, 19376, 19372, 19467, 19468, 19469, 19459
42144, 19372, 19376, 2406, 2405, 19469, 19470, 0, 19461
42145, 1226, 1227, 19377, 19373, 0, 19471, 19472, 19462
42146, 19373, 19377, 19378, 19374, 19472, 19473, 19474, 19464
42147, 19374, 19378, 19379, 19375, 19474, 19475, 19476, 19466
42148, 19375, 19379, 19380, 19376, 19476, 19477, 19478, 19468
42149, 19376, 19380, 2407, 2406, 19478, 19479, 0, 19470
42150, 1227, 50, 2384, 19377, 0, 0, 19480, 19471
42151, 19377, 2384, 2385, 19378, 19480, 0, 19481, 19473
42152, 19378, 2385, 2386, 19379, 19481, 0, 19482, 19475
42153, 19379, 2386, 2387, 19380, 19482, 0, 19483, 19477
42154, 19380, 2387, 95, 2407, 19483, 0, 0, 19479
*ELEMENT, type=CPS8, ELSET=Surface135
5374, 94, 96, 2397, 2373, 0, 0, 0, 0
5375, 2373, 2397, 2398, 2374, 0, 0, 0, 0
5376, 2374, 2398, 2399, 2375, 0, 0, 0, 0
5377, 2375, 2399, 2400, 2376, 0, 0, 0, 0
5378, 2376, 2400, 2401, 2377, 0, 0, 0, 0
5379, 2377, 2401, 2402, 2378, 0, 0, 0, 0
5380, 2378, 2402, 2403, 2379, 0, 0, 0, 0
5381, 2379, 2403, 2404, 2380, 0, 0, 0, 0
5382, 2380, 2404, 2405, 2381, 0, 0, 0, 0
5383, 2381, 2405, 2406, 2382, 0, 0, 0, 0
5384, 2382, 2406, 2407, 2383, 0, 0, 0, 0
5385, 2383, 2407, 95, 92, 0, 0, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume1
5386, 2408, 98, 2, 122, 19484, 2452, 150, 2958, 0, 97, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5387, 19484, 2452, 150, 2958, 19485, 2463, 151, 2959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5388, 19485, 2463, 151, 2959, 19486, 2474, 152, 2960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5389, 19486, 2474, 152, 2960, 19487, 2485, 153, 2961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5390, 19487, 2485, 153, 2961, 19488, 2496, 154, 2962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5391, 19488, 2496, 154, 2962, 19489, 2507, 155, 2963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5392, 19489, 2507, 155, 2963, 19490, 2518, 156, 2964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5393, 19490, 2518, 156, 2964, 19491, 2529, 157, 2965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5394, 19491, 2529, 157, 2965, 19492, 2540, 158, 2966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5395, 19492, 2540, 158, 2966, 19493, 2551, 159, 2967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5396, 19493, 2551, 159, 2967, 19494, 2562, 160, 2968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5397, 19494, 2562, 160, 2968, 19495, 2573, 161, 2969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5398, 19495, 2573, 161, 2969, 19496, 2584, 162, 2970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5399, 19496, 2584, 162, 2970, 19497, 2595, 163, 2971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5400, 19497, 2595, 163, 2971, 19498, 2606, 164, 2972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5401, 19498, 2606, 164, 2972, 19499, 2617, 165, 2973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5402, 19499, 2617, 165, 2973, 19500, 2628, 166, 2974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5403, 19500, 2628, 166, 2974, 19501, 2639, 167, 2975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5404, 19501, 2639, 167, 2975, 19502, 2650, 168, 2976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5405, 19502, 2650, 168, 2976, 19503, 2661, 169, 2977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5406, 19503, 2661, 169, 2977, 19504, 2672, 170, 2978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5407, 19504, 2672, 170, 2978, 19505, 2683, 171, 2979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5408, 19505, 2683, 171, 2979, 19506, 2694, 172, 2980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5409, 19506, 2694, 172, 2980, 2430, 124, 6, 148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5410, 2409, 2408, 122, 123, 19507, 19484, 2958, 2981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5411, 19507, 19484, 2958, 2981, 19508, 19485, 2959, 2982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5412, 19508, 19485, 2959, 2982, 19509, 19486, 2960, 2983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5413, 19509, 19486, 2960, 2983, 19510, 19487, 2961, 2984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5414, 19510, 19487, 2961, 2984, 19511, 19488, 2962, 2985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5415, 19511, 19488, 2962, 2985, 19512, 19489, 2963, 2986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5416, 19512, 19489, 2963, 2986, 19513, 19490, 2964, 2987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5417, 19513, 19490, 2964, 2987, 19514, 19491, 2965, 2988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5418, 19514, 19491, 2965, 2988, 19515, 19492, 2966, 2989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5419, 19515, 19492, 2966, 2989, 19516, 19493, 2967, 2990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5420, 19516, 19493, 2967, 2990, 19517, 19494, 2968, 2991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5421, 19517, 19494, 2968, 2991, 19518, 19495, 2969, 2992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5422, 19518, 19495, 2969, 2992, 19519, 19496, 2970, 2993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5423, 19519, 19496, 2970, 2993, 19520, 19497, 2971, 2994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5424, 19520, 19497, 2971, 2994, 19521, 19498, 2972, 2995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5425, 19521, 19498, 2972, 2995, 19522, 19499, 2973, 2996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5426, 19522, 19499, 2973, 2996, 19523, 19500, 2974, 2997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5427, 19523, 19500, 2974, 2997, 19524, 19501, 2975, 2998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5428, 19524, 19501, 2975, 2998, 19525, 19502, 2976, 2999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5429, 19525, 19502, 2976, 2999, 19526, 19503, 2977, 3000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5430, 19526, 19503, 2977, 3000, 19527, 19504, 2978, 3001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5431, 19527, 19504, 2978, 3001, 19528, 19505, 2979, 3002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5432, 19528, 19505, 2979, 3002, 19529, 19506, 2980, 3003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5433, 19529, 19506, 2980, 3003, 2431, 2430, 148, 149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5434, 111, 2409, 123, 4, 2705, 19507, 2981, 196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5435, 2705, 19507, 2981, 196, 2716, 19508, 2982, 197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5436, 2716, 19508, 2982, 197, 2727, 19509, 2983, 198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5437, 2727, 19509, 2983, 198, 2738, 19510, 2984, 199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5438, 2738, 19510, 2984, 199, 2749, 19511, 2985, 200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5439, 2749, 19511, 2985, 200, 2760, 19512, 2986, 201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5440, 2760, 19512, 2986, 201, 2771, 19513, 2987, 202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5441, 2771, 19513, 2987, 202, 2782, 19514, 2988, 203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5442, 2782, 19514, 2988, 203, 2793, 19515, 2989, 204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5443, 2793, 19515, 2989, 204, 2804, 19516, 2990, 205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5444, 2804, 19516, 2990, 205, 2815, 19517, 2991, 206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5445, 2815, 19517, 2991, 206, 2826, 19518, 2992, 207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5446, 2826, 19518, 2992, 207, 2837, 19519, 2993, 208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5447, 2837, 19519, 2993, 208, 2848, 19520, 2994, 209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5448, 2848, 19520, 2994, 209, 2859, 19521, 2995, 210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5449, 2859, 19521, 2995, 210, 2870, 19522, 2996, 211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5450, 2870, 19522, 2996, 211, 2881, 19523, 2997, 212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5451, 2881, 19523, 2997, 212, 2892, 19524, 2998, 213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5452, 2892, 19524, 2998, 213, 2903, 19525, 2999, 214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5453, 2903, 19525, 2999, 214, 2914, 19526, 3000, 215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5454, 2914, 19526, 3000, 215, 2925, 19527, 3001, 216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5455, 2925, 19527, 3001, 216, 2936, 19528, 3002, 217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5456, 2936, 19528, 3002, 217, 2947, 19529, 3003, 218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5457, 2947, 19529, 3003, 218, 137, 2431, 149, 8, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5458, 2410, 99, 98, 2408, 19530, 2453, 2452, 19484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5459, 19530, 2453, 2452, 19484, 19531, 2464, 2463, 19485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5460, 19531, 2464, 2463, 19485, 19532, 2475, 2474, 19486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5461, 19532, 2475, 2474, 19486, 19533, 2486, 2485, 19487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5462, 19533, 2486, 2485, 19487, 19534, 2497, 2496, 19488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5463, 19534, 2497, 2496, 19488, 19535, 2508, 2507, 19489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5464, 19535, 2508, 2507, 19489, 19536, 2519, 2518, 19490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5465, 19536, 2519, 2518, 19490, 19537, 2530, 2529, 19491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5466, 19537, 2530, 2529, 19491, 19538, 2541, 2540, 19492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5467, 19538, 2541, 2540, 19492, 19539, 2552, 2551, 19493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5468, 19539, 2552, 2551, 19493, 19540, 2563, 2562, 19494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5469, 19540, 2563, 2562, 19494, 19541, 2574, 2573, 19495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5470, 19541, 2574, 2573, 19495, 19542, 2585, 2584, 19496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5471, 19542, 2585, 2584, 19496, 19543, 2596, 2595, 19497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5472, 19543, 2596, 2595, 19497, 19544, 2607, 2606, 19498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5473, 19544, 2607, 2606, 19498, 19545, 2618, 2617, 19499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5474, 19545, 2618, 2617, 19499, 19546, 2629, 2628, 19500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5475, 19546, 2629, 2628, 19500, 19547, 2640, 2639, 19501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5476, 19547, 2640, 2639, 19501, 19548, 2651, 2650, 19502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5477, 19548, 2651, 2650, 19502, 19549, 2662, 2661, 19503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5478, 19549, 2662, 2661, 19503, 19550, 2673, 2672, 19504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5479, 19550, 2673, 2672, 19504, 19551, 2684, 2683, 19505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5480, 19551, 2684, 2683, 19505, 19552, 2695, 2694, 19506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5481, 19552, 2695, 2694, 19506, 2432, 125, 124, 2430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5482, 2411, 2410, 2408, 2409, 19553, 19530, 19484, 19507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5483, 19553, 19530, 19484, 19507, 19554, 19531, 19485, 19508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5484, 19554, 19531, 19485, 19508, 19555, 19532, 19486, 19509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5485, 19555, 19532, 19486, 19509, 19556, 19533, 19487, 19510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5486, 19556, 19533, 19487, 19510, 19557, 19534, 19488, 19511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5487, 19557, 19534, 19488, 19511, 19558, 19535, 19489, 19512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5488, 19558, 19535, 19489, 19512, 19559, 19536, 19490, 19513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5489, 19559, 19536, 19490, 19513, 19560, 19537, 19491, 19514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5490, 19560, 19537, 19491, 19514, 19561, 19538, 19492, 19515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5491, 19561, 19538, 19492, 19515, 19562, 19539, 19493, 19516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5492, 19562, 19539, 19493, 19516, 19563, 19540, 19494, 19517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5493, 19563, 19540, 19494, 19517, 19564, 19541, 19495, 19518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5494, 19564, 19541, 19495, 19518, 19565, 19542, 19496, 19519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5495, 19565, 19542, 19496, 19519, 19566, 19543, 19497, 19520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5496, 19566, 19543, 19497, 19520, 19567, 19544, 19498, 19521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5497, 19567, 19544, 19498, 19521, 19568, 19545, 19499, 19522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5498, 19568, 19545, 19499, 19522, 19569, 19546, 19500, 19523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5499, 19569, 19546, 19500, 19523, 19570, 19547, 19501, 19524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5500, 19570, 19547, 19501, 19524, 19571, 19548, 19502, 19525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5501, 19571, 19548, 19502, 19525, 19572, 19549, 19503, 19526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5502, 19572, 19549, 19503, 19526, 19573, 19550, 19504, 19527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5503, 19573, 19550, 19504, 19527, 19574, 19551, 19505, 19528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5504, 19574, 19551, 19505, 19528, 19575, 19552, 19506, 19529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5505, 19575, 19552, 19506, 19529, 2433, 2432, 2430, 2431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5506, 112, 2411, 2409, 111, 2706, 19553, 19507, 2705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5507, 2706, 19553, 19507, 2705, 2717, 19554, 19508, 2716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5508, 2717, 19554, 19508, 2716, 2728, 19555, 19509, 2727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5509, 2728, 19555, 19509, 2727, 2739, 19556, 19510, 2738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5510, 2739, 19556, 19510, 2738, 2750, 19557, 19511, 2749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5511, 2750, 19557, 19511, 2749, 2761, 19558, 19512, 2760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5512, 2761, 19558, 19512, 2760, 2772, 19559, 19513, 2771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5513, 2772, 19559, 19513, 2771, 2783, 19560, 19514, 2782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5514, 2783, 19560, 19514, 2782, 2794, 19561, 19515, 2793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5515, 2794, 19561, 19515, 2793, 2805, 19562, 19516, 2804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5516, 2805, 19562, 19516, 2804, 2816, 19563, 19517, 2815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5517, 2816, 19563, 19517, 2815, 2827, 19564, 19518, 2826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5518, 2827, 19564, 19518, 2826, 2838, 19565, 19519, 2837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5519, 2838, 19565, 19519, 2837, 2849, 19566, 19520, 2848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5520, 2849, 19566, 19520, 2848, 2860, 19567, 19521, 2859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5521, 2860, 19567, 19521, 2859, 2871, 19568, 19522, 2870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5522, 2871, 19568, 19522, 2870, 2882, 19569, 19523, 2881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5523, 2882, 19569, 19523, 2881, 2893, 19570, 19524, 2892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5524, 2893, 19570, 19524, 2892, 2904, 19571, 19525, 2903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5525, 2904, 19571, 19525, 2903, 2915, 19572, 19526, 2914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5526, 2915, 19572, 19526, 2914, 2926, 19573, 19527, 2925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5527, 2926, 19573, 19527, 2925, 2937, 19574, 19528, 2936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5528, 2937, 19574, 19528, 2936, 2948, 19575, 19529, 2947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5529, 2948, 19575, 19529, 2947, 138, 2433, 2431, 137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5530, 2412, 100, 99, 2410, 19576, 2454, 2453, 19530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5531, 19576, 2454, 2453, 19530, 19577, 2465, 2464, 19531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5532, 19577, 2465, 2464, 19531, 19578, 2476, 2475, 19532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5533, 19578, 2476, 2475, 19532, 19579, 2487, 2486, 19533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5534, 19579, 2487, 2486, 19533, 19580, 2498, 2497, 19534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5535, 19580, 2498, 2497, 19534, 19581, 2509, 2508, 19535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5536, 19581, 2509, 2508, 19535, 19582, 2520, 2519, 19536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5537, 19582, 2520, 2519, 19536, 19583, 2531, 2530, 19537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5538, 19583, 2531, 2530, 19537, 19584, 2542, 2541, 19538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5539, 19584, 2542, 2541, 19538, 19585, 2553, 2552, 19539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5540, 19585, 2553, 2552, 19539, 19586, 2564, 2563, 19540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5541, 19586, 2564, 2563, 19540, 19587, 2575, 2574, 19541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5542, 19587, 2575, 2574, 19541, 19588, 2586, 2585, 19542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5543, 19588, 2586, 2585, 19542, 19589, 2597, 2596, 19543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5544, 19589, 2597, 2596, 19543, 19590, 2608, 2607, 19544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5545, 19590, 2608, 2607, 19544, 19591, 2619, 2618, 19545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5546, 19591, 2619, 2618, 19545, 19592, 2630, 2629, 19546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5547, 19592, 2630, 2629, 19546, 19593, 2641, 2640, 19547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5548, 19593, 2641, 2640, 19547, 19594, 2652, 2651, 19548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5549, 19594, 2652, 2651, 19548, 19595, 2663, 2662, 19549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5550, 19595, 2663, 2662, 19549, 19596, 2674, 2673, 19550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5551, 19596, 2674, 2673, 19550, 19597, 2685, 2684, 19551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5552, 19597, 2685, 2684, 19551, 19598, 2696, 2695, 19552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5553, 19598, 2696, 2695, 19552, 2434, 126, 125, 2432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5554, 2413, 2412, 2410, 2411, 19599, 19576, 19530, 19553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5555, 19599, 19576, 19530, 19553, 19600, 19577, 19531, 19554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5556, 19600, 19577, 19531, 19554, 19601, 19578, 19532, 19555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5557, 19601, 19578, 19532, 19555, 19602, 19579, 19533, 19556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5558, 19602, 19579, 19533, 19556, 19603, 19580, 19534, 19557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5559, 19603, 19580, 19534, 19557, 19604, 19581, 19535, 19558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5560, 19604, 19581, 19535, 19558, 19605, 19582, 19536, 19559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5561, 19605, 19582, 19536, 19559, 19606, 19583, 19537, 19560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5562, 19606, 19583, 19537, 19560, 19607, 19584, 19538, 19561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5563, 19607, 19584, 19538, 19561, 19608, 19585, 19539, 19562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5564, 19608, 19585, 19539, 19562, 19609, 19586, 19540, 19563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5565, 19609, 19586, 19540, 19563, 19610, 19587, 19541, 19564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5566, 19610, 19587, 19541, 19564, 19611, 19588, 19542, 19565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5567, 19611, 19588, 19542, 19565, 19612, 19589, 19543, 19566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5568, 19612, 19589, 19543, 19566, 19613, 19590, 19544, 19567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5569, 19613, 19590, 19544, 19567, 19614, 19591, 19545, 19568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5570, 19614, 19591, 19545, 19568, 19615, 19592, 19546, 19569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5571, 19615, 19592, 19546, 19569, 19616, 19593, 19547, 19570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5572, 19616, 19593, 19547, 19570, 19617, 19594, 19548, 19571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5573, 19617, 19594, 19548, 19571, 19618, 19595, 19549, 19572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5574, 19618, 19595, 19549, 19572, 19619, 19596, 19550, 19573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5575, 19619, 19596, 19550, 19573, 19620, 19597, 19551, 19574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5576, 19620, 19597, 19551, 19574, 19621, 19598, 19552, 19575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5577, 19621, 19598, 19552, 19575, 2435, 2434, 2432, 2433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5578, 113, 2413, 2411, 112, 2707, 19599, 19553, 2706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5579, 2707, 19599, 19553, 2706, 2718, 19600, 19554, 2717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5580, 2718, 19600, 19554, 2717, 2729, 19601, 19555, 2728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5581, 2729, 19601, 19555, 2728, 2740, 19602, 19556, 2739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5582, 2740, 19602, 19556, 2739, 2751, 19603, 19557, 2750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5583, 2751, 19603, 19557, 2750, 2762, 19604, 19558, 2761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5584, 2762, 19604, 19558, 2761, 2773, 19605, 19559, 2772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5585, 2773, 19605, 19559, 2772, 2784, 19606, 19560, 2783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5586, 2784, 19606, 19560, 2783, 2795, 19607, 19561, 2794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5587, 2795, 19607, 19561, 2794, 2806, 19608, 19562, 2805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5588, 2806, 19608, 19562, 2805, 2817, 19609, 19563, 2816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5589, 2817, 19609, 19563, 2816, 2828, 19610, 19564, 2827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5590, 2828, 19610, 19564, 2827, 2839, 19611, 19565, 2838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5591, 2839, 19611, 19565, 2838, 2850, 19612, 19566, 2849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5592, 2850, 19612, 19566, 2849, 2861, 19613, 19567, 2860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5593, 2861, 19613, 19567, 2860, 2872, 19614, 19568, 2871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5594, 2872, 19614, 19568, 2871, 2883, 19615, 19569, 2882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5595, 2883, 19615, 19569, 2882, 2894, 19616, 19570, 2893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5596, 2894, 19616, 19570, 2893, 2905, 19617, 19571, 2904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5597, 2905, 19617, 19571, 2904, 2916, 19618, 19572, 2915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5598, 2916, 19618, 19572, 2915, 2927, 19619, 19573, 2926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5599, 2927, 19619, 19573, 2926, 2938, 19620, 19574, 2937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5600, 2938, 19620, 19574, 2937, 2949, 19621, 19575, 2948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5601, 2949, 19621, 19575, 2948, 139, 2435, 2433, 138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5602, 2414, 101, 100, 2412, 19622, 2455, 2454, 19576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5603, 19622, 2455, 2454, 19576, 19623, 2466, 2465, 19577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5604, 19623, 2466, 2465, 19577, 19624, 2477, 2476, 19578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5605, 19624, 2477, 2476, 19578, 19625, 2488, 2487, 19579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5606, 19625, 2488, 2487, 19579, 19626, 2499, 2498, 19580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5607, 19626, 2499, 2498, 19580, 19627, 2510, 2509, 19581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5608, 19627, 2510, 2509, 19581, 19628, 2521, 2520, 19582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5609, 19628, 2521, 2520, 19582, 19629, 2532, 2531, 19583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5610, 19629, 2532, 2531, 19583, 19630, 2543, 2542, 19584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5611, 19630, 2543, 2542, 19584, 19631, 2554, 2553, 19585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5612, 19631, 2554, 2553, 19585, 19632, 2565, 2564, 19586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5613, 19632, 2565, 2564, 19586, 19633, 2576, 2575, 19587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5614, 19633, 2576, 2575, 19587, 19634, 2587, 2586, 19588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5615, 19634, 2587, 2586, 19588, 19635, 2598, 2597, 19589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5616, 19635, 2598, 2597, 19589, 19636, 2609, 2608, 19590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5617, 19636, 2609, 2608, 19590, 19637, 2620, 2619, 19591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5618, 19637, 2620, 2619, 19591, 19638, 2631, 2630, 19592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5619, 19638, 2631, 2630, 19592, 19639, 2642, 2641, 19593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5620, 19639, 2642, 2641, 19593, 19640, 2653, 2652, 19594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5621, 19640, 2653, 2652, 19594, 19641, 2664, 2663, 19595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5622, 19641, 2664, 2663, 19595, 19642, 2675, 2674, 19596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5623, 19642, 2675, 2674, 19596, 19643, 2686, 2685, 19597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5624, 19643, 2686, 2685, 19597, 19644, 2697, 2696, 19598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5625, 19644, 2697, 2696, 19598, 2436, 127, 126, 2434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5626, 2415, 2414, 2412, 2413, 19645, 19622, 19576, 19599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5627, 19645, 19622, 19576, 19599, 19646, 19623, 19577, 19600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5628, 19646, 19623, 19577, 19600, 19647, 19624, 19578, 19601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5629, 19647, 19624, 19578, 19601, 19648, 19625, 19579, 19602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5630, 19648, 19625, 19579, 19602, 19649, 19626, 19580, 19603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5631, 19649, 19626, 19580, 19603, 19650, 19627, 19581, 19604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5632, 19650, 19627, 19581, 19604, 19651, 19628, 19582, 19605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5633, 19651, 19628, 19582, 19605, 19652, 19629, 19583, 19606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5634, 19652, 19629, 19583, 19606, 19653, 19630, 19584, 19607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5635, 19653, 19630, 19584, 19607, 19654, 19631, 19585, 19608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5636, 19654, 19631, 19585, 19608, 19655, 19632, 19586, 19609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5637, 19655, 19632, 19586, 19609, 19656, 19633, 19587, 19610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5638, 19656, 19633, 19587, 19610, 19657, 19634, 19588, 19611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5639, 19657, 19634, 19588, 19611, 19658, 19635, 19589, 19612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5640, 19658, 19635, 19589, 19612, 19659, 19636, 19590, 19613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5641, 19659, 19636, 19590, 19613, 19660, 19637, 19591, 19614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5642, 19660, 19637, 19591, 19614, 19661, 19638, 19592, 19615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5643, 19661, 19638, 19592, 19615, 19662, 19639, 19593, 19616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5644, 19662, 19639, 19593, 19616, 19663, 19640, 19594, 19617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5645, 19663, 19640, 19594, 19617, 19664, 19641, 19595, 19618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5646, 19664, 19641, 19595, 19618, 19665, 19642, 19596, 19619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5647, 19665, 19642, 19596, 19619, 19666, 19643, 19597, 19620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5648, 19666, 19643, 19597, 19620, 19667, 19644, 19598, 19621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5649, 19667, 19644, 19598, 19621, 2437, 2436, 2434, 2435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5650, 114, 2415, 2413, 113, 2708, 19645, 19599, 2707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5651, 2708, 19645, 19599, 2707, 2719, 19646, 19600, 2718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5652, 2719, 19646, 19600, 2718, 2730, 19647, 19601, 2729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5653, 2730, 19647, 19601, 2729, 2741, 19648, 19602, 2740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5654, 2741, 19648, 19602, 2740, 2752, 19649, 19603, 2751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5655, 2752, 19649, 19603, 2751, 2763, 19650, 19604, 2762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5656, 2763, 19650, 19604, 2762, 2774, 19651, 19605, 2773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5657, 2774, 19651, 19605, 2773, 2785, 19652, 19606, 2784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5658, 2785, 19652, 19606, 2784, 2796, 19653, 19607, 2795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5659, 2796, 19653, 19607, 2795, 2807, 19654, 19608, 2806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5660, 2807, 19654, 19608, 2806, 2818, 19655, 19609, 2817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5661, 2818, 19655, 19609, 2817, 2829, 19656, 19610, 2828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5662, 2829, 19656, 19610, 2828, 2840, 19657, 19611, 2839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5663, 2840, 19657, 19611, 2839, 2851, 19658, 19612, 2850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5664, 2851, 19658, 19612, 2850, 2862, 19659, 19613, 2861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5665, 2862, 19659, 19613, 2861, 2873, 19660, 19614, 2872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5666, 2873, 19660, 19614, 2872, 2884, 19661, 19615, 2883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5667, 2884, 19661, 19615, 2883, 2895, 19662, 19616, 2894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5668, 2895, 19662, 19616, 2894, 2906, 19663, 19617, 2905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5669, 2906, 19663, 19617, 2905, 2917, 19664, 19618, 2916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5670, 2917, 19664, 19618, 2916, 2928, 19665, 19619, 2927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5671, 2928, 19665, 19619, 2927, 2939, 19666, 19620, 2938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5672, 2939, 19666, 19620, 2938, 2950, 19667, 19621, 2949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5673, 2950, 19667, 19621, 2949, 140, 2437, 2435, 139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5674, 2416, 102, 101, 2414, 19668, 2456, 2455, 19622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5675, 19668, 2456, 2455, 19622, 19669, 2467, 2466, 19623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5676, 19669, 2467, 2466, 19623, 19670, 2478, 2477, 19624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5677, 19670, 2478, 2477, 19624, 19671, 2489, 2488, 19625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5678, 19671, 2489, 2488, 19625, 19672, 2500, 2499, 19626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5679, 19672, 2500, 2499, 19626, 19673, 2511, 2510, 19627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5680, 19673, 2511, 2510, 19627, 19674, 2522, 2521, 19628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5681, 19674, 2522, 2521, 19628, 19675, 2533, 2532, 19629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5682, 19675, 2533, 2532, 19629, 19676, 2544, 2543, 19630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5683, 19676, 2544, 2543, 19630, 19677, 2555, 2554, 19631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5684, 19677, 2555, 2554, 19631, 19678, 2566, 2565, 19632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5685, 19678, 2566, 2565, 19632, 19679, 2577, 2576, 19633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5686, 19679, 2577, 2576, 19633, 19680, 2588, 2587, 19634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5687, 19680, 2588, 2587, 19634, 19681, 2599, 2598, 19635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5688, 19681, 2599, 2598, 19635, 19682, 2610, 2609, 19636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5689, 19682, 2610, 2609, 19636, 19683, 2621, 2620, 19637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5690, 19683, 2621, 2620, 19637, 19684, 2632, 2631, 19638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5691, 19684, 2632, 2631, 19638, 19685, 2643, 2642, 19639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5692, 19685, 2643, 2642, 19639, 19686, 2654, 2653, 19640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5693, 19686, 2654, 2653, 19640, 19687, 2665, 2664, 19641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5694, 19687, 2665, 2664, 19641, 19688, 2676, 2675, 19642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5695, 19688, 2676, 2675, 19642, 19689, 2687, 2686, 19643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5696, 19689, 2687, 2686, 19643, 19690, 2698, 2697, 19644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5697, 19690, 2698, 2697, 19644, 2438, 128, 127, 2436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5698, 2417, 2416, 2414, 2415, 19691, 19668, 19622, 19645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5699, 19691, 19668, 19622, 19645, 19692, 19669, 19623, 19646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5700, 19692, 19669, 19623, 19646, 19693, 19670, 19624, 19647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5701, 19693, 19670, 19624, 19647, 19694, 19671, 19625, 19648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5702, 19694, 19671, 19625, 19648, 19695, 19672, 19626, 19649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5703, 19695, 19672, 19626, 19649, 19696, 19673, 19627, 19650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5704, 19696, 19673, 19627, 19650, 19697, 19674, 19628, 19651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5705, 19697, 19674, 19628, 19651, 19698, 19675, 19629, 19652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5706, 19698, 19675, 19629, 19652, 19699, 19676, 19630, 19653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5707, 19699, 19676, 19630, 19653, 19700, 19677, 19631, 19654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5708, 19700, 19677, 19631, 19654, 19701, 19678, 19632, 19655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5709, 19701, 19678, 19632, 19655, 19702, 19679, 19633, 19656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5710, 19702, 19679, 19633, 19656, 19703, 19680, 19634, 19657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5711, 19703, 19680, 19634, 19657, 19704, 19681, 19635, 19658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5712, 19704, 19681, 19635, 19658, 19705, 19682, 19636, 19659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5713, 19705, 19682, 19636, 19659, 19706, 19683, 19637, 19660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5714, 19706, 19683, 19637, 19660, 19707, 19684, 19638, 19661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5715, 19707, 19684, 19638, 19661, 19708, 19685, 19639, 19662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5716, 19708, 19685, 19639, 19662, 19709, 19686, 19640, 19663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5717, 19709, 19686, 19640, 19663, 19710, 19687, 19641, 19664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5718, 19710, 19687, 19641, 19664, 19711, 19688, 19642, 19665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5719, 19711, 19688, 19642, 19665, 19712, 19689, 19643, 19666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5720, 19712, 19689, 19643, 19666, 19713, 19690, 19644, 19667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5721, 19713, 19690, 19644, 19667, 2439, 2438, 2436, 2437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5722, 115, 2417, 2415, 114, 2709, 19691, 19645, 2708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5723, 2709, 19691, 19645, 2708, 2720, 19692, 19646, 2719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5724, 2720, 19692, 19646, 2719, 2731, 19693, 19647, 2730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5725, 2731, 19693, 19647, 2730, 2742, 19694, 19648, 2741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5726, 2742, 19694, 19648, 2741, 2753, 19695, 19649, 2752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5727, 2753, 19695, 19649, 2752, 2764, 19696, 19650, 2763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5728, 2764, 19696, 19650, 2763, 2775, 19697, 19651, 2774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5729, 2775, 19697, 19651, 2774, 2786, 19698, 19652, 2785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5730, 2786, 19698, 19652, 2785, 2797, 19699, 19653, 2796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5731, 2797, 19699, 19653, 2796, 2808, 19700, 19654, 2807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5732, 2808, 19700, 19654, 2807, 2819, 19701, 19655, 2818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5733, 2819, 19701, 19655, 2818, 2830, 19702, 19656, 2829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5734, 2830, 19702, 19656, 2829, 2841, 19703, 19657, 2840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5735, 2841, 19703, 19657, 2840, 2852, 19704, 19658, 2851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5736, 2852, 19704, 19658, 2851, 2863, 19705, 19659, 2862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5737, 2863, 19705, 19659, 2862, 2874, 19706, 19660, 2873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5738, 2874, 19706, 19660, 2873, 2885, 19707, 19661, 2884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5739, 2885, 19707, 19661, 2884, 2896, 19708, 19662, 2895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5740, 2896, 19708, 19662, 2895, 2907, 19709, 19663, 2906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5741, 2907, 19709, 19663, 2906, 2918, 19710, 19664, 2917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5742, 2918, 19710, 19664, 2917, 2929, 19711, 19665, 2928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5743, 2929, 19711, 19665, 2928, 2940, 19712, 19666, 2939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5744, 2940, 19712, 19666, 2939, 2951, 19713, 19667, 2950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5745, 2951, 19713, 19667, 2950, 141, 2439, 2437, 140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5746, 2418, 103, 102, 2416, 19714, 2457, 2456, 19668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5747, 19714, 2457, 2456, 19668, 19715, 2468, 2467, 19669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5748, 19715, 2468, 2467, 19669, 19716, 2479, 2478, 19670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5749, 19716, 2479, 2478, 19670, 19717, 2490, 2489, 19671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5750, 19717, 2490, 2489, 19671, 19718, 2501, 2500, 19672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5751, 19718, 2501, 2500, 19672, 19719, 2512, 2511, 19673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5752, 19719, 2512, 2511, 19673, 19720, 2523, 2522, 19674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5753, 19720, 2523, 2522, 19674, 19721, 2534, 2533, 19675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5754, 19721, 2534, 2533, 19675, 19722, 2545, 2544, 19676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5755, 19722, 2545, 2544, 19676, 19723, 2556, 2555, 19677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5756, 19723, 2556, 2555, 19677, 19724, 2567, 2566, 19678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5757, 19724, 2567, 2566, 19678, 19725, 2578, 2577, 19679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5758, 19725, 2578, 2577, 19679, 19726, 2589, 2588, 19680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5759, 19726, 2589, 2588, 19680, 19727, 2600, 2599, 19681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5760, 19727, 2600, 2599, 19681, 19728, 2611, 2610, 19682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5761, 19728, 2611, 2610, 19682, 19729, 2622, 2621, 19683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5762, 19729, 2622, 2621, 19683, 19730, 2633, 2632, 19684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5763, 19730, 2633, 2632, 19684, 19731, 2644, 2643, 19685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5764, 19731, 2644, 2643, 19685, 19732, 2655, 2654, 19686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5765, 19732, 2655, 2654, 19686, 19733, 2666, 2665, 19687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5766, 19733, 2666, 2665, 19687, 19734, 2677, 2676, 19688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5767, 19734, 2677, 2676, 19688, 19735, 2688, 2687, 19689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5768, 19735, 2688, 2687, 19689, 19736, 2699, 2698, 19690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5769, 19736, 2699, 2698, 19690, 2440, 129, 128, 2438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5770, 2419, 2418, 2416, 2417, 19737, 19714, 19668, 19691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5771, 19737, 19714, 19668, 19691, 19738, 19715, 19669, 19692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5772, 19738, 19715, 19669, 19692, 19739, 19716, 19670, 19693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5773, 19739, 19716, 19670, 19693, 19740, 19717, 19671, 19694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5774, 19740, 19717, 19671, 19694, 19741, 19718, 19672, 19695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5775, 19741, 19718, 19672, 19695, 19742, 19719, 19673, 19696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5776, 19742, 19719, 19673, 19696, 19743, 19720, 19674, 19697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5777, 19743, 19720, 19674, 19697, 19744, 19721, 19675, 19698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5778, 19744, 19721, 19675, 19698, 19745, 19722, 19676, 19699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5779, 19745, 19722, 19676, 19699, 19746, 19723, 19677, 19700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5780, 19746, 19723, 19677, 19700, 19747, 19724, 19678, 19701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5781, 19747, 19724, 19678, 19701, 19748, 19725, 19679, 19702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5782, 19748, 19725, 19679, 19702, 19749, 19726, 19680, 19703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5783, 19749, 19726, 19680, 19703, 19750, 19727, 19681, 19704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5784, 19750, 19727, 19681, 19704, 19751, 19728, 19682, 19705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5785, 19751, 19728, 19682, 19705, 19752, 19729, 19683, 19706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5786, 19752, 19729, 19683, 19706, 19753, 19730, 19684, 19707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5787, 19753, 19730, 19684, 19707, 19754, 19731, 19685, 19708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5788, 19754, 19731, 19685, 19708, 19755, 19732, 19686, 19709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5789, 19755, 19732, 19686, 19709, 19756, 19733, 19687, 19710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5790, 19756, 19733, 19687, 19710, 19757, 19734, 19688, 19711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5791, 19757, 19734, 19688, 19711, 19758, 19735, 19689, 19712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5792, 19758, 19735, 19689, 19712, 19759, 19736, 19690, 19713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5793, 19759, 19736, 19690, 19713, 2441, 2440, 2438, 2439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5794, 116, 2419, 2417, 115, 2710, 19737, 19691, 2709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5795, 2710, 19737, 19691, 2709, 2721, 19738, 19692, 2720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5796, 2721, 19738, 19692, 2720, 2732, 19739, 19693, 2731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5797, 2732, 19739, 19693, 2731, 2743, 19740, 19694, 2742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5798, 2743, 19740, 19694, 2742, 2754, 19741, 19695, 2753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5799, 2754, 19741, 19695, 2753, 2765, 19742, 19696, 2764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5800, 2765, 19742, 19696, 2764, 2776, 19743, 19697, 2775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5801, 2776, 19743, 19697, 2775, 2787, 19744, 19698, 2786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5802, 2787, 19744, 19698, 2786, 2798, 19745, 19699, 2797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5803, 2798, 19745, 19699, 2797, 2809, 19746, 19700, 2808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5804, 2809, 19746, 19700, 2808, 2820, 19747, 19701, 2819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5805, 2820, 19747, 19701, 2819, 2831, 19748, 19702, 2830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5806, 2831, 19748, 19702, 2830, 2842, 19749, 19703, 2841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5807, 2842, 19749, 19703, 2841, 2853, 19750, 19704, 2852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5808, 2853, 19750, 19704, 2852, 2864, 19751, 19705, 2863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5809, 2864, 19751, 19705, 2863, 2875, 19752, 19706, 2874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5810, 2875, 19752, 19706, 2874, 2886, 19753, 19707, 2885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5811, 2886, 19753, 19707, 2885, 2897, 19754, 19708, 2896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5812, 2897, 19754, 19708, 2896, 2908, 19755, 19709, 2907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5813, 2908, 19755, 19709, 2907, 2919, 19756, 19710, 2918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5814, 2919, 19756, 19710, 2918, 2930, 19757, 19711, 2929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5815, 2930, 19757, 19711, 2929, 2941, 19758, 19712, 2940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5816, 2941, 19758, 19712, 2940, 2952, 19759, 19713, 2951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5817, 2952, 19759, 19713, 2951, 142, 2441, 2439, 141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5818, 2420, 104, 103, 2418, 19760, 2458, 2457, 19714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5819, 19760, 2458, 2457, 19714, 19761, 2469, 2468, 19715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5820, 19761, 2469, 2468, 19715, 19762, 2480, 2479, 19716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5821, 19762, 2480, 2479, 19716, 19763, 2491, 2490, 19717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5822, 19763, 2491, 2490, 19717, 19764, 2502, 2501, 19718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5823, 19764, 2502, 2501, 19718, 19765, 2513, 2512, 19719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5824, 19765, 2513, 2512, 19719, 19766, 2524, 2523, 19720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5825, 19766, 2524, 2523, 19720, 19767, 2535, 2534, 19721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5826, 19767, 2535, 2534, 19721, 19768, 2546, 2545, 19722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5827, 19768, 2546, 2545, 19722, 19769, 2557, 2556, 19723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5828, 19769, 2557, 2556, 19723, 19770, 2568, 2567, 19724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5829, 19770, 2568, 2567, 19724, 19771, 2579, 2578, 19725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5830, 19771, 2579, 2578, 19725, 19772, 2590, 2589, 19726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5831, 19772, 2590, 2589, 19726, 19773, 2601, 2600, 19727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5832, 19773, 2601, 2600, 19727, 19774, 2612, 2611, 19728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5833, 19774, 2612, 2611, 19728, 19775, 2623, 2622, 19729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5834, 19775, 2623, 2622, 19729, 19776, 2634, 2633, 19730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5835, 19776, 2634, 2633, 19730, 19777, 2645, 2644, 19731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5836, 19777, 2645, 2644, 19731, 19778, 2656, 2655, 19732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5837, 19778, 2656, 2655, 19732, 19779, 2667, 2666, 19733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5838, 19779, 2667, 2666, 19733, 19780, 2678, 2677, 19734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5839, 19780, 2678, 2677, 19734, 19781, 2689, 2688, 19735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5840, 19781, 2689, 2688, 19735, 19782, 2700, 2699, 19736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5841, 19782, 2700, 2699, 19736, 2442, 130, 129, 2440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5842, 2421, 2420, 2418, 2419, 19783, 19760, 19714, 19737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5843, 19783, 19760, 19714, 19737, 19784, 19761, 19715, 19738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5844, 19784, 19761, 19715, 19738, 19785, 19762, 19716, 19739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5845, 19785, 19762, 19716, 19739, 19786, 19763, 19717, 19740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5846, 19786, 19763, 19717, 19740, 19787, 19764, 19718, 19741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5847, 19787, 19764, 19718, 19741, 19788, 19765, 19719, 19742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5848, 19788, 19765, 19719, 19742, 19789, 19766, 19720, 19743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5849, 19789, 19766, 19720, 19743, 19790, 19767, 19721, 19744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5850, 19790, 19767, 19721, 19744, 19791, 19768, 19722, 19745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5851, 19791, 19768, 19722, 19745, 19792, 19769, 19723, 19746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5852, 19792, 19769, 19723, 19746, 19793, 19770, 19724, 19747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5853, 19793, 19770, 19724, 19747, 19794, 19771, 19725, 19748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5854, 19794, 19771, 19725, 19748, 19795, 19772, 19726, 19749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5855, 19795, 19772, 19726, 19749, 19796, 19773, 19727, 19750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5856, 19796, 19773, 19727, 19750, 19797, 19774, 19728, 19751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5857, 19797, 19774, 19728, 19751, 19798, 19775, 19729, 19752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5858, 19798, 19775, 19729, 19752, 19799, 19776, 19730, 19753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5859, 19799, 19776, 19730, 19753, 19800, 19777, 19731, 19754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5860, 19800, 19777, 19731, 19754, 19801, 19778, 19732, 19755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5861, 19801, 19778, 19732, 19755, 19802, 19779, 19733, 19756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5862, 19802, 19779, 19733, 19756, 19803, 19780, 19734, 19757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5863, 19803, 19780, 19734, 19757, 19804, 19781, 19735, 19758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5864, 19804, 19781, 19735, 19758, 19805, 19782, 19736, 19759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5865, 19805, 19782, 19736, 19759, 2443, 2442, 2440, 2441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5866, 117, 2421, 2419, 116, 2711, 19783, 19737, 2710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5867, 2711, 19783, 19737, 2710, 2722, 19784, 19738, 2721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5868, 2722, 19784, 19738, 2721, 2733, 19785, 19739, 2732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5869, 2733, 19785, 19739, 2732, 2744, 19786, 19740, 2743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5870, 2744, 19786, 19740, 2743, 2755, 19787, 19741, 2754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5871, 2755, 19787, 19741, 2754, 2766, 19788, 19742, 2765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5872, 2766, 19788, 19742, 2765, 2777, 19789, 19743, 2776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5873, 2777, 19789, 19743, 2776, 2788, 19790, 19744, 2787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5874, 2788, 19790, 19744, 2787, 2799, 19791, 19745, 2798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5875, 2799, 19791, 19745, 2798, 2810, 19792, 19746, 2809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5876, 2810, 19792, 19746, 2809, 2821, 19793, 19747, 2820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5877, 2821, 19793, 19747, 2820, 2832, 19794, 19748, 2831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5878, 2832, 19794, 19748, 2831, 2843, 19795, 19749, 2842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5879, 2843, 19795, 19749, 2842, 2854, 19796, 19750, 2853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5880, 2854, 19796, 19750, 2853, 2865, 19797, 19751, 2864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5881, 2865, 19797, 19751, 2864, 2876, 19798, 19752, 2875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5882, 2876, 19798, 19752, 2875, 2887, 19799, 19753, 2886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5883, 2887, 19799, 19753, 2886, 2898, 19800, 19754, 2897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5884, 2898, 19800, 19754, 2897, 2909, 19801, 19755, 2908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5885, 2909, 19801, 19755, 2908, 2920, 19802, 19756, 2919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5886, 2920, 19802, 19756, 2919, 2931, 19803, 19757, 2930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5887, 2931, 19803, 19757, 2930, 2942, 19804, 19758, 2941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5888, 2942, 19804, 19758, 2941, 2953, 19805, 19759, 2952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5889, 2953, 19805, 19759, 2952, 143, 2443, 2441, 142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5890, 2422, 105, 104, 2420, 19806, 2459, 2458, 19760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5891, 19806, 2459, 2458, 19760, 19807, 2470, 2469, 19761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5892, 19807, 2470, 2469, 19761, 19808, 2481, 2480, 19762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5893, 19808, 2481, 2480, 19762, 19809, 2492, 2491, 19763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5894, 19809, 2492, 2491, 19763, 19810, 2503, 2502, 19764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5895, 19810, 2503, 2502, 19764, 19811, 2514, 2513, 19765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5896, 19811, 2514, 2513, 19765, 19812, 2525, 2524, 19766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5897, 19812, 2525, 2524, 19766, 19813, 2536, 2535, 19767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5898, 19813, 2536, 2535, 19767, 19814, 2547, 2546, 19768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5899, 19814, 2547, 2546, 19768, 19815, 2558, 2557, 19769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5900, 19815, 2558, 2557, 19769, 19816, 2569, 2568, 19770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5901, 19816, 2569, 2568, 19770, 19817, 2580, 2579, 19771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5902, 19817, 2580, 2579, 19771, 19818, 2591, 2590, 19772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5903, 19818, 2591, 2590, 19772, 19819, 2602, 2601, 19773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5904, 19819, 2602, 2601, 19773, 19820, 2613, 2612, 19774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5905, 19820, 2613, 2612, 19774, 19821, 2624, 2623, 19775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5906, 19821, 2624, 2623, 19775, 19822, 2635, 2634, 19776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5907, 19822, 2635, 2634, 19776, 19823, 2646, 2645, 19777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5908, 19823, 2646, 2645, 19777, 19824, 2657, 2656, 19778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5909, 19824, 2657, 2656, 19778, 19825, 2668, 2667, 19779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5910, 19825, 2668, 2667, 19779, 19826, 2679, 2678, 19780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5911, 19826, 2679, 2678, 19780, 19827, 2690, 2689, 19781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5912, 19827, 2690, 2689, 19781, 19828, 2701, 2700, 19782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5913, 19828, 2701, 2700, 19782, 2444, 131, 130, 2442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5914, 2423, 2422, 2420, 2421, 19829, 19806, 19760, 19783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5915, 19829, 19806, 19760, 19783, 19830, 19807, 19761, 19784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5916, 19830, 19807, 19761, 19784, 19831, 19808, 19762, 19785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5917, 19831, 19808, 19762, 19785, 19832, 19809, 19763, 19786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5918, 19832, 19809, 19763, 19786, 19833, 19810, 19764, 19787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5919, 19833, 19810, 19764, 19787, 19834, 19811, 19765, 19788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5920, 19834, 19811, 19765, 19788, 19835, 19812, 19766, 19789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5921, 19835, 19812, 19766, 19789, 19836, 19813, 19767, 19790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5922, 19836, 19813, 19767, 19790, 19837, 19814, 19768, 19791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5923, 19837, 19814, 19768, 19791, 19838, 19815, 19769, 19792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5924, 19838, 19815, 19769, 19792, 19839, 19816, 19770, 19793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5925, 19839, 19816, 19770, 19793, 19840, 19817, 19771, 19794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5926, 19840, 19817, 19771, 19794, 19841, 19818, 19772, 19795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5927, 19841, 19818, 19772, 19795, 19842, 19819, 19773, 19796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5928, 19842, 19819, 19773, 19796, 19843, 19820, 19774, 19797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5929, 19843, 19820, 19774, 19797, 19844, 19821, 19775, 19798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5930, 19844, 19821, 19775, 19798, 19845, 19822, 19776, 19799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5931, 19845, 19822, 19776, 19799, 19846, 19823, 19777, 19800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5932, 19846, 19823, 19777, 19800, 19847, 19824, 19778, 19801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5933, 19847, 19824, 19778, 19801, 19848, 19825, 19779, 19802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5934, 19848, 19825, 19779, 19802, 19849, 19826, 19780, 19803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5935, 19849, 19826, 19780, 19803, 19850, 19827, 19781, 19804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5936, 19850, 19827, 19781, 19804, 19851, 19828, 19782, 19805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5937, 19851, 19828, 19782, 19805, 2445, 2444, 2442, 2443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5938, 118, 2423, 2421, 117, 2712, 19829, 19783, 2711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5939, 2712, 19829, 19783, 2711, 2723, 19830, 19784, 2722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5940, 2723, 19830, 19784, 2722, 2734, 19831, 19785, 2733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5941, 2734, 19831, 19785, 2733, 2745, 19832, 19786, 2744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5942, 2745, 19832, 19786, 2744, 2756, 19833, 19787, 2755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5943, 2756, 19833, 19787, 2755, 2767, 19834, 19788, 2766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5944, 2767, 19834, 19788, 2766, 2778, 19835, 19789, 2777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5945, 2778, 19835, 19789, 2777, 2789, 19836, 19790, 2788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5946, 2789, 19836, 19790, 2788, 2800, 19837, 19791, 2799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5947, 2800, 19837, 19791, 2799, 2811, 19838, 19792, 2810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5948, 2811, 19838, 19792, 2810, 2822, 19839, 19793, 2821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5949, 2822, 19839, 19793, 2821, 2833, 19840, 19794, 2832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5950, 2833, 19840, 19794, 2832, 2844, 19841, 19795, 2843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5951, 2844, 19841, 19795, 2843, 2855, 19842, 19796, 2854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5952, 2855, 19842, 19796, 2854, 2866, 19843, 19797, 2865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5953, 2866, 19843, 19797, 2865, 2877, 19844, 19798, 2876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5954, 2877, 19844, 19798, 2876, 2888, 19845, 19799, 2887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5955, 2888, 19845, 19799, 2887, 2899, 19846, 19800, 2898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5956, 2899, 19846, 19800, 2898, 2910, 19847, 19801, 2909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5957, 2910, 19847, 19801, 2909, 2921, 19848, 19802, 2920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5958, 2921, 19848, 19802, 2920, 2932, 19849, 19803, 2931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5959, 2932, 19849, 19803, 2931, 2943, 19850, 19804, 2942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5960, 2943, 19850, 19804, 2942, 2954, 19851, 19805, 2953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5961, 2954, 19851, 19805, 2953, 144, 2445, 2443, 143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5962, 2424, 106, 105, 2422, 19852, 2460, 2459, 19806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5963, 19852, 2460, 2459, 19806, 19853, 2471, 2470, 19807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5964, 19853, 2471, 2470, 19807, 19854, 2482, 2481, 19808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5965, 19854, 2482, 2481, 19808, 19855, 2493, 2492, 19809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5966, 19855, 2493, 2492, 19809, 19856, 2504, 2503, 19810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5967, 19856, 2504, 2503, 19810, 19857, 2515, 2514, 19811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5968, 19857, 2515, 2514, 19811, 19858, 2526, 2525, 19812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5969, 19858, 2526, 2525, 19812, 19859, 2537, 2536, 19813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5970, 19859, 2537, 2536, 19813, 19860, 2548, 2547, 19814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5971, 19860, 2548, 2547, 19814, 19861, 2559, 2558, 19815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5972, 19861, 2559, 2558, 19815, 19862, 2570, 2569, 19816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5973, 19862, 2570, 2569, 19816, 19863, 2581, 2580, 19817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5974, 19863, 2581, 2580, 19817, 19864, 2592, 2591, 19818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5975, 19864, 2592, 2591, 19818, 19865, 2603, 2602, 19819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5976, 19865, 2603, 2602, 19819, 19866, 2614, 2613, 19820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5977, 19866, 2614, 2613, 19820, 19867, 2625, 2624, 19821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5978, 19867, 2625, 2624, 19821, 19868, 2636, 2635, 19822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5979, 19868, 2636, 2635, 19822, 19869, 2647, 2646, 19823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5980, 19869, 2647, 2646, 19823, 19870, 2658, 2657, 19824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5981, 19870, 2658, 2657, 19824, 19871, 2669, 2668, 19825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5982, 19871, 2669, 2668, 19825, 19872, 2680, 2679, 19826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5983, 19872, 2680, 2679, 19826, 19873, 2691, 2690, 19827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5984, 19873, 2691, 2690, 19827, 19874, 2702, 2701, 19828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5985, 19874, 2702, 2701, 19828, 2446, 132, 131, 2444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5986, 2425, 2424, 2422, 2423, 19875, 19852, 19806, 19829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5987, 19875, 19852, 19806, 19829, 19876, 19853, 19807, 19830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5988, 19876, 19853, 19807, 19830, 19877, 19854, 19808, 19831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5989, 19877, 19854, 19808, 19831, 19878, 19855, 19809, 19832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5990, 19878, 19855, 19809, 19832, 19879, 19856, 19810, 19833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5991, 19879, 19856, 19810, 19833, 19880, 19857, 19811, 19834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5992, 19880, 19857, 19811, 19834, 19881, 19858, 19812, 19835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5993, 19881, 19858, 19812, 19835, 19882, 19859, 19813, 19836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5994, 19882, 19859, 19813, 19836, 19883, 19860, 19814, 19837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5995, 19883, 19860, 19814, 19837, 19884, 19861, 19815, 19838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5996, 19884, 19861, 19815, 19838, 19885, 19862, 19816, 19839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5997, 19885, 19862, 19816, 19839, 19886, 19863, 19817, 19840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5998, 19886, 19863, 19817, 19840, 19887, 19864, 19818, 19841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
5999, 19887, 19864, 19818, 19841, 19888, 19865, 19819, 19842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6000, 19888, 19865, 19819, 19842, 19889, 19866, 19820, 19843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6001, 19889, 19866, 19820, 19843, 19890, 19867, 19821, 19844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6002, 19890, 19867, 19821, 19844, 19891, 19868, 19822, 19845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6003, 19891, 19868, 19822, 19845, 19892, 19869, 19823, 19846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6004, 19892, 19869, 19823, 19846, 19893, 19870, 19824, 19847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6005, 19893, 19870, 19824, 19847, 19894, 19871, 19825, 19848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6006, 19894, 19871, 19825, 19848, 19895, 19872, 19826, 19849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6007, 19895, 19872, 19826, 19849, 19896, 19873, 19827, 19850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6008, 19896, 19873, 19827, 19850, 19897, 19874, 19828, 19851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6009, 19897, 19874, 19828, 19851, 2447, 2446, 2444, 2445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6010, 119, 2425, 2423, 118, 2713, 19875, 19829, 2712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6011, 2713, 19875, 19829, 2712, 2724, 19876, 19830, 2723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6012, 2724, 19876, 19830, 2723, 2735, 19877, 19831, 2734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6013, 2735, 19877, 19831, 2734, 2746, 19878, 19832, 2745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6014, 2746, 19878, 19832, 2745, 2757, 19879, 19833, 2756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6015, 2757, 19879, 19833, 2756, 2768, 19880, 19834, 2767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6016, 2768, 19880, 19834, 2767, 2779, 19881, 19835, 2778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6017, 2779, 19881, 19835, 2778, 2790, 19882, 19836, 2789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6018, 2790, 19882, 19836, 2789, 2801, 19883, 19837, 2800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6019, 2801, 19883, 19837, 2800, 2812, 19884, 19838, 2811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6020, 2812, 19884, 19838, 2811, 2823, 19885, 19839, 2822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6021, 2823, 19885, 19839, 2822, 2834, 19886, 19840, 2833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6022, 2834, 19886, 19840, 2833, 2845, 19887, 19841, 2844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6023, 2845, 19887, 19841, 2844, 2856, 19888, 19842, 2855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6024, 2856, 19888, 19842, 2855, 2867, 19889, 19843, 2866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6025, 2867, 19889, 19843, 2866, 2878, 19890, 19844, 2877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6026, 2878, 19890, 19844, 2877, 2889, 19891, 19845, 2888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6027, 2889, 19891, 19845, 2888, 2900, 19892, 19846, 2899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6028, 2900, 19892, 19846, 2899, 2911, 19893, 19847, 2910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6029, 2911, 19893, 19847, 2910, 2922, 19894, 19848, 2921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6030, 2922, 19894, 19848, 2921, 2933, 19895, 19849, 2932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6031, 2933, 19895, 19849, 2932, 2944, 19896, 19850, 2943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6032, 2944, 19896, 19850, 2943, 2955, 19897, 19851, 2954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6033, 2955, 19897, 19851, 2954, 145, 2447, 2445, 144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6034, 2426, 107, 106, 2424, 19898, 2461, 2460, 19852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6035, 19898, 2461, 2460, 19852, 19899, 2472, 2471, 19853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6036, 19899, 2472, 2471, 19853, 19900, 2483, 2482, 19854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6037, 19900, 2483, 2482, 19854, 19901, 2494, 2493, 19855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6038, 19901, 2494, 2493, 19855, 19902, 2505, 2504, 19856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6039, 19902, 2505, 2504, 19856, 19903, 2516, 2515, 19857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6040, 19903, 2516, 2515, 19857, 19904, 2527, 2526, 19858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6041, 19904, 2527, 2526, 19858, 19905, 2538, 2537, 19859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6042, 19905, 2538, 2537, 19859, 19906, 2549, 2548, 19860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6043, 19906, 2549, 2548, 19860, 19907, 2560, 2559, 19861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6044, 19907, 2560, 2559, 19861, 19908, 2571, 2570, 19862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6045, 19908, 2571, 2570, 19862, 19909, 2582, 2581, 19863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6046, 19909, 2582, 2581, 19863, 19910, 2593, 2592, 19864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6047, 19910, 2593, 2592, 19864, 19911, 2604, 2603, 19865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6048, 19911, 2604, 2603, 19865, 19912, 2615, 2614, 19866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6049, 19912, 2615, 2614, 19866, 19913, 2626, 2625, 19867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6050, 19913, 2626, 2625, 19867, 19914, 2637, 2636, 19868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6051, 19914, 2637, 2636, 19868, 19915, 2648, 2647, 19869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6052, 19915, 2648, 2647, 19869, 19916, 2659, 2658, 19870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6053, 19916, 2659, 2658, 19870, 19917, 2670, 2669, 19871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6054, 19917, 2670, 2669, 19871, 19918, 2681, 2680, 19872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6055, 19918, 2681, 2680, 19872, 19919, 2692, 2691, 19873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6056, 19919, 2692, 2691, 19873, 19920, 2703, 2702, 19874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6057, 19920, 2703, 2702, 19874, 2448, 133, 132, 2446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6058, 2427, 2426, 2424, 2425, 19921, 19898, 19852, 19875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6059, 19921, 19898, 19852, 19875, 19922, 19899, 19853, 19876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6060, 19922, 19899, 19853, 19876, 19923, 19900, 19854, 19877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6061, 19923, 19900, 19854, 19877, 19924, 19901, 19855, 19878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6062, 19924, 19901, 19855, 19878, 19925, 19902, 19856, 19879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6063, 19925, 19902, 19856, 19879, 19926, 19903, 19857, 19880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6064, 19926, 19903, 19857, 19880, 19927, 19904, 19858, 19881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6065, 19927, 19904, 19858, 19881, 19928, 19905, 19859, 19882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6066, 19928, 19905, 19859, 19882, 19929, 19906, 19860, 19883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6067, 19929, 19906, 19860, 19883, 19930, 19907, 19861, 19884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6068, 19930, 19907, 19861, 19884, 19931, 19908, 19862, 19885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6069, 19931, 19908, 19862, 19885, 19932, 19909, 19863, 19886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6070, 19932, 19909, 19863, 19886, 19933, 19910, 19864, 19887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6071, 19933, 19910, 19864, 19887, 19934, 19911, 19865, 19888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6072, 19934, 19911, 19865, 19888, 19935, 19912, 19866, 19889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6073, 19935, 19912, 19866, 19889, 19936, 19913, 19867, 19890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6074, 19936, 19913, 19867, 19890, 19937, 19914, 19868, 19891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6075, 19937, 19914, 19868, 19891, 19938, 19915, 19869, 19892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6076, 19938, 19915, 19869, 19892, 19939, 19916, 19870, 19893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6077, 19939, 19916, 19870, 19893, 19940, 19917, 19871, 19894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6078, 19940, 19917, 19871, 19894, 19941, 19918, 19872, 19895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6079, 19941, 19918, 19872, 19895, 19942, 19919, 19873, 19896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6080, 19942, 19919, 19873, 19896, 19943, 19920, 19874, 19897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6081, 19943, 19920, 19874, 19897, 2449, 2448, 2446, 2447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6082, 120, 2427, 2425, 119, 2714, 19921, 19875, 2713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6083, 2714, 19921, 19875, 2713, 2725, 19922, 19876, 2724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6084, 2725, 19922, 19876, 2724, 2736, 19923, 19877, 2735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6085, 2736, 19923, 19877, 2735, 2747, 19924, 19878, 2746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6086, 2747, 19924, 19878, 2746, 2758, 19925, 19879, 2757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6087, 2758, 19925, 19879, 2757, 2769, 19926, 19880, 2768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6088, 2769, 19926, 19880, 2768, 2780, 19927, 19881, 2779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6089, 2780, 19927, 19881, 2779, 2791, 19928, 19882, 2790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6090, 2791, 19928, 19882, 2790, 2802, 19929, 19883, 2801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6091, 2802, 19929, 19883, 2801, 2813, 19930, 19884, 2812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6092, 2813, 19930, 19884, 2812, 2824, 19931, 19885, 2823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6093, 2824, 19931, 19885, 2823, 2835, 19932, 19886, 2834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6094, 2835, 19932, 19886, 2834, 2846, 19933, 19887, 2845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6095, 2846, 19933, 19887, 2845, 2857, 19934, 19888, 2856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6096, 2857, 19934, 19888, 2856, 2868, 19935, 19889, 2867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6097, 2868, 19935, 19889, 2867, 2879, 19936, 19890, 2878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6098, 2879, 19936, 19890, 2878, 2890, 19937, 19891, 2889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6099, 2890, 19937, 19891, 2889, 2901, 19938, 19892, 2900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6100, 2901, 19938, 19892, 2900, 2912, 19939, 19893, 2911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6101, 2912, 19939, 19893, 2911, 2923, 19940, 19894, 2922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6102, 2923, 19940, 19894, 2922, 2934, 19941, 19895, 2933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6103, 2934, 19941, 19895, 2933, 2945, 19942, 19896, 2944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6104, 2945, 19942, 19896, 2944, 2956, 19943, 19897, 2955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6105, 2956, 19943, 19897, 2955, 146, 2449, 2447, 145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6106, 2428, 108, 107, 2426, 19944, 2462, 2461, 19898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6107, 19944, 2462, 2461, 19898, 19945, 2473, 2472, 19899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6108, 19945, 2473, 2472, 19899, 19946, 2484, 2483, 19900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6109, 19946, 2484, 2483, 19900, 19947, 2495, 2494, 19901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6110, 19947, 2495, 2494, 19901, 19948, 2506, 2505, 19902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6111, 19948, 2506, 2505, 19902, 19949, 2517, 2516, 19903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6112, 19949, 2517, 2516, 19903, 19950, 2528, 2527, 19904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6113, 19950, 2528, 2527, 19904, 19951, 2539, 2538, 19905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6114, 19951, 2539, 2538, 19905, 19952, 2550, 2549, 19906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6115, 19952, 2550, 2549, 19906, 19953, 2561, 2560, 19907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6116, 19953, 2561, 2560, 19907, 19954, 2572, 2571, 19908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6117, 19954, 2572, 2571, 19908, 19955, 2583, 2582, 19909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6118, 19955, 2583, 2582, 19909, 19956, 2594, 2593, 19910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6119, 19956, 2594, 2593, 19910, 19957, 2605, 2604, 19911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6120, 19957, 2605, 2604, 19911, 19958, 2616, 2615, 19912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6121, 19958, 2616, 2615, 19912, 19959, 2627, 2626, 19913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6122, 19959, 2627, 2626, 19913, 19960, 2638, 2637, 19914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6123, 19960, 2638, 2637, 19914, 19961, 2649, 2648, 19915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6124, 19961, 2649, 2648, 19915, 19962, 2660, 2659, 19916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6125, 19962, 2660, 2659, 19916, 19963, 2671, 2670, 19917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6126, 19963, 2671, 2670, 19917, 19964, 2682, 2681, 19918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6127, 19964, 2682, 2681, 19918, 19965, 2693, 2692, 19919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6128, 19965, 2693, 2692, 19919, 19966, 2704, 2703, 19920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6129, 19966, 2704, 2703, 19920, 2450, 134, 133, 2448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6130, 2429, 2428, 2426, 2427, 19967, 19944, 19898, 19921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6131, 19967, 19944, 19898, 19921, 19968, 19945, 19899, 19922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6132, 19968, 19945, 19899, 19922, 19969, 19946, 19900, 19923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6133, 19969, 19946, 19900, 19923, 19970, 19947, 19901, 19924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6134, 19970, 19947, 19901, 19924, 19971, 19948, 19902, 19925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6135, 19971, 19948, 19902, 19925, 19972, 19949, 19903, 19926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6136, 19972, 19949, 19903, 19926, 19973, 19950, 19904, 19927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6137, 19973, 19950, 19904, 19927, 19974, 19951, 19905, 19928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6138, 19974, 19951, 19905, 19928, 19975, 19952, 19906, 19929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6139, 19975, 19952, 19906, 19929, 19976, 19953, 19907, 19930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
