39625, 0.5, 1.62, 0.10416666666667
39626, 0.5, 1.64, 0.125
39627, 0.47916666666667, 1.66, 0.125
39628, 0.5, 1.66, 0.10416666666667
39629, 0.5, 1.68, 0.125
39630, 0.5, 1.52, 0.16666666666667
39631, 0.47916666666667, 1.54, 0.16666666666667
39632, 0.5, 1.54, 0.14583333333333
39633, 0.5, 1.56, 0.16666666666667
39634, 0.47916666666667, 1.58, 0.16666666666667
39635, 0.5, 1.58, 0.14583333333333
39636, 0.5, 1.6, 0.16666666666667
39637, 0.47916666666667, 1.62, 0.16666666666667
39638, 0.5, 1.62, 0.14583333333333
39639, 0.5, 1.64, 0.16666666666667
39640, 0.47916666666667, 1.66, 0.16666666666667
39641, 0.5, 1.66, 0.14583333333333
39642, 0.5, 1.68, 0.16666666666667
39643, 0.5, 1.52, 0.20833333333333
39644, 0.47916666666667, 1.54, 0.20833333333333
39645, 0.5, 1.54, 0.1875
39646, 0.5, 1.56, 0.20833333333333
39647, 0.47916666666667, 1.58, 0.20833333333333
39648, 0.5, 1.58, 0.1875
39649, 0.5, 1.6, 0.20833333333333
39650, 0.47916666666667, 1.62, 0.20833333333333
39651, 0.5, 1.62, 0.1875
39652, 0.5, 1.64, 0.20833333333333
39653, 0.47916666666667, 1.66, 0.20833333333333
39654, 0.5, 1.66, 0.1875
39655, 0.5, 1.68, 0.20833333333333
39656, 0.5, 1.52, 0.25
39657, 0.47916666666667, 1.54, 0.25
39658, 0.5, 1.54, 0.22916666666667
39659, 0.5, 1.56, 0.25
39660, 0.47916666666667, 1.58, 0.25
39661, 0.5, 1.58, 0.22916666666667
39662, 0.5, 1.6, 0.25
39663, 0.47916666666667, 1.62, 0.25
39664, 0.5, 1.62, 0.22916666666667
39665, 0.5, 1.64, 0.25
39666, 0.47916666666667, 1.66, 0.25
39667, 0.5, 1.66, 0.22916666666667
39668, 0.5, 1.68, 0.25
39669, 0.5, 1.52, 0.29166666666667
39670, 0.47916666666667, 1.54, 0.29166666666667
39671, 0.5, 1.54, 0.27083333333333
39672, 0.5, 1.56, 0.29166666666667
39673, 0.47916666666667, 1.58, 0.29166666666667
39674, 0.5, 1.58, 0.27083333333333
39675, 0.5, 1.6, 0.29166666666667
39676, 0.47916666666667, 1.62, 0.29166666666667
39677, 0.5, 1.62, 0.27083333333333
39678, 0.5, 1.64, 0.29166666666667
39679, 0.47916666666667, 1.66, 0.29166666666667
39680, 0.5, 1.66, 0.27083333333333
39681, 0.5, 1.68, 0.29166666666667
39682, 0.5, 1.52, 0.33333333333333
39683, 0.47916666666667, 1.54, 0.33333333333333
39684, 0.5, 1.54, 0.3125
39685, 0.5, 1.56, 0.33333333333333
39686, 0.47916666666667, 1.58, 0.33333333333333
39687, 0.5, 1.58, 0.3125
39688, 0.5, 1.6, 0.33333333333333
39689, 0.47916666666667, 1.62, 0.33333333333333
39690, 0.5, 1.62, 0.3125
39691, 0.5, 1.64, 0.33333333333333
39692, 0.47916666666667, 1.66, 0.33333333333333
39693, 0.5, 1.66, 0.3125
39694, 0.5, 1.68, 0.33333333333333
39695, 0.5, 1.52, 0.375
39696, 0.47916666666667, 1.54, 0.375
39697, 0.5, 1.54, 0.35416666666667
39698, 0.5, 1.56, 0.375
39699, 0.47916666666667, 1.58, 0.375
39700, 0.5, 1.58, 0.35416666666667
39701, 0.5, 1.6, 0.375
39702, 0.47916666666667, 1.62, 0.375
39703, 0.5, 1.62, 0.35416666666667
39704, 0.5, 1.64, 0.375
39705, 0.47916666666667, 1.66, 0.375
39706, 0.5, 1.66, 0.35416666666667
39707, 0.5, 1.68, 0.375
39708, 0.5, 1.52, 0.41666666666667
39709, 0.47916666666667, 1.54, 0.41666666666667
39710, 0.5, 1.54, 0.39583333333333
39711, 0.5, 1.56, 0.41666666666667
39712, 0.47916666666667, 1.58, 0.41666666666667
39713, 0.5, 1.58, 0.39583333333333
39714, 0.5, 1.6, 0.41666666666667
39715, 0.47916666666667, 1.62, 0.41666666666667
39716, 0.5, 1.62, 0.39583333333333
39717, 0.5, 1.64, 0.41666666666667
39718, 0.47916666666667, 1.66, 0.41666666666667
39719, 0.5, 1.66, 0.39583333333333
39720, 0.5, 1.68, 0.41666666666667
39721, 0.5, 1.52, 0.45833333333333
39722, 0.47916666666667, 1.54, 0.45833333333333
39723, 0.5, 1.54, 0.4375
39724, 0.5, 1.56, 0.45833333333333
39725, 0.47916666666667, 1.58, 0.45833333333333
39726, 0.5, 1.58, 0.4375
39727, 0.5, 1.6, 0.45833333333333
39728, 0.47916666666667, 1.62, 0.45833333333333
39729, 0.5, 1.62, 0.4375
39730, 0.5, 1.64, 0.45833333333333
39731, 0.47916666666667, 1.66, 0.45833333333333
39732, 0.5, 1.66, 0.4375
39733, 0.5, 1.68, 0.45833333333333
39734, 0.5, 1.54, 0.47916666666667
39735, 0.5, 1.58, 0.47916666666667
39736, 0.5, 1.62, 0.47916666666667
39737, 0.5, 1.66, 0.47916666666667
39738, 0.54166666666667, 1.52, 0.041666666666667
39739, 0.52083333333333, 1.54, 0.041666666666667
39740, 0.54166666666667, 1.54, 0.020833333333333
39741, 0.54166666666667, 1.56, 0.041666666666667
39742, 0.52083333333333, 1.58, 0.041666666666667
39743, 0.54166666666667, 1.58, 0.020833333333333
39744, 0.54166666666667, 1.6, 0.041666666666667
39745, 0.52083333333333, 1.62, 0.041666666666667
39746, 0.54166666666667, 1.62, 0.020833333333333
39747, 0.54166666666667, 1.64, 0.041666666666667
39748, 0.52083333333333, 1.66, 0.041666666666667
39749, 0.54166666666667, 1.66, 0.020833333333333
39750, 0.54166666666667, 1.68, 0.041666666666667
39751, 0.54166666666667, 1.52, 0.083333333333333
39752, 0.52083333333333, 1.54, 0.083333333333333
39753, 0.54166666666667, 1.54, 0.0625
39754, 0.54166666666667, 1.56, 0.083333333333333
39755, 0.52083333333333, 1.58, 0.083333333333333
39756, 0.54166666666667, 1.58, 0.0625
39757, 0.54166666666667, 1.6, 0.083333333333333
39758, 0.52083333333333, 1.62, 0.083333333333333
39759, 0.54166666666667, 1.62, 0.0625
39760, 0.54166666666667, 1.64, 0.083333333333333
39761, 0.52083333333333, 1.66, 0.083333333333333
39762, 0.54166666666667, 1.66, 0.0625
39763, 0.54166666666667, 1.68, 0.083333333333333
39764, 0.54166666666667, 1.52, 0.125
39765, 0.52083333333333, 1.54, 0.125
39766, 0.54166666666667, 1.54, 0.10416666666667
39767, 0.54166666666667, 1.56, 0.125
39768, 0.52083333333333, 1.58, 0.125
39769, 0.54166666666667, 1.58, 0.10416666666667
39770, 0.54166666666667, 1.6, 0.125
39771, 0.52083333333333, 1.62, 0.125
39772, 0.54166666666667, 1.62, 0.10416666666667
39773, 0.54166666666667, 1.64, 0.125
39774, 0.52083333333333, 1.66, 0.125
39775, 0.54166666666667, 1.66, 0.10416666666667
39776, 0.54166666666667, 1.68, 0.125
39777, 0.54166666666667, 1.52, 0.16666666666667
39778, 0.52083333333333, 1.54, 0.16666666666667
39779, 0.54166666666667, 1.54, 0.14583333333333
39780, 0.54166666666667, 1.56, 0.16666666666667
39781, 0.52083333333333, 1.58, 0.16666666666667
39782, 0.54166666666667, 1.58, 0.14583333333333
39783, 0.54166666666667, 1.6, 0.16666666666667
39784, 0.52083333333333, 1.62, 0.16666666666667
39785, 0.54166666666667, 1.62, 0.14583333333333
39786, 0.54166666666667, 1.64, 0.16666666666667
39787, 0.52083333333333, 1.66, 0.16666666666667
39788, 0.54166666666667, 1.66, 0.14583333333333
39789, 0.54166666666667, 1.68, 0.16666666666667
39790, 0.54166666666667, 1.52, 0.20833333333333
39791, 0.52083333333333, 1.54, 0.20833333333333
39792, 0.54166666666667, 1.54, 0.1875
39793, 0.54166666666667, 1.56, 0.20833333333333
39794, 0.52083333333333, 1.58, 0.20833333333333
39795, 0.54166666666667, 1.58, 0.1875
39796, 0.54166666666667, 1.6, 0.20833333333333
39797, 0.52083333333333, 1.62, 0.20833333333333
39798, 0.54166666666667, 1.62, 0.1875
39799, 0.54166666666667, 1.64, 0.20833333333333
39800, 0.52083333333333, 1.66, 0.20833333333333
39801, 0.54166666666667, 1.66, 0.1875
39802, 0.54166666666667, 1.68, 0.20833333333333
39803, 0.54166666666667, 1.52, 0.25
39804, 0.52083333333333, 1.54, 0.25
39805, 0.54166666666667, 1.54, 0.22916666666667
39806, 0.54166666666667, 1.56, 0.25
39807, 0.52083333333333, 1.58, 0.25
39808, 0.54166666666667, 1.58, 0.22916666666667
39809, 0.54166666666667, 1.6, 0.25
39810, 0.52083333333333, 1.62, 0.25
39811, 0.54166666666667, 1.62, 0.22916666666667
39812, 0.54166666666667, 1.64, 0.25
39813, 0.52083333333333, 1.66, 0.25
39814, 0.54166666666667, 1.66, 0.22916666666667
39815, 0.54166666666667, 1.68, 0.25
39816, 0.54166666666667, 1.52, 0.29166666666667
39817, 0.52083333333333, 1.54, 0.29166666666667
39818, 0.54166666666667, 1.54, 0.27083333333333
39819, 0.54166666666667, 1.56, 0.29166666666667
39820, 0.52083333333333, 1.58, 0.29166666666667
39821, 0.54166666666667, 1.58, 0.27083333333333
39822, 0.54166666666667, 1.6, 0.29166666666667
39823, 0.52083333333333, 1.62, 0.29166666666667
39824, 0.54166666666667, 1.62, 0.27083333333333
39825, 0.54166666666667, 1.64, 0.29166666666667
39826, 0.52083333333333, 1.66, 0.29166666666667
39827, 0.54166666666667, 1.66, 0.27083333333333
39828, 0.54166666666667, 1.68, 0.29166666666667
39829, 0.54166666666667, 1.52, 0.33333333333333
39830, 0.52083333333333, 1.54, 0.33333333333333
39831, 0.54166666666667, 1.54, 0.3125
39832, 0.54166666666667, 1.56, 0.33333333333333
39833, 0.52083333333333, 1.58, 0.33333333333333
39834, 0.54166666666667, 1.58, 0.3125
39835, 0.54166666666667, 1.6, 0.33333333333333
39836, 0.52083333333333, 1.62, 0.33333333333333
39837, 0.54166666666667, 1.62, 0.3125
39838, 0.54166666666667, 1.64, 0.33333333333333
39839, 0.52083333333333, 1.66, 0.33333333333333
39840, 0.54166666666667, 1.66, 0.3125
39841, 0.54166666666667, 1.68, 0.33333333333333
39842, 0.54166666666667, 1.52, 0.375
39843, 0.52083333333333, 1.54, 0.375
39844, 0.54166666666667, 1.54, 0.35416666666667
39845, 0.54166666666667, 1.56, 0.375
39846, 0.52083333333333, 1.58, 0.375
39847, 0.54166666666667, 1.58, 0.35416666666667
39848, 0.54166666666667, 1.6, 0.375
39849, 0.52083333333333, 1.62, 0.375
39850, 0.54166666666667, 1.62, 0.35416666666667
39851, 0.54166666666667, 1.64, 0.375
39852, 0.52083333333333, 1.66, 0.375
39853, 0.54166666666667, 1.66, 0.35416666666667
39854, 0.54166666666667, 1.68, 0.375
39855, 0.54166666666667, 1.52, 0.41666666666667
39856, 0.52083333333333, 1.54, 0.41666666666667
39857, 0.54166666666667, 1.54, 0.39583333333333
39858, 0.54166666666667, 1.56, 0.41666666666667
39859, 0.52083333333333, 1.58, 0.41666666666667
39860, 0.54166666666667, 1.58, 0.39583333333333
39861, 0.54166666666667, 1.6, 0.41666666666667
39862, 0.52083333333333, 1.62, 0.41666666666667
39863, 0.54166666666667, 1.62, 0.39583333333333
39864, 0.54166666666667, 1.64, 0.41666666666667
39865, 0.52083333333333, 1.66, 0.41666666666667
39866, 0.54166666666667, 1.66, 0.39583333333333
39867, 0.54166666666667, 1.68, 0.41666666666667
39868, 0.54166666666667, 1.52, 0.45833333333333
39869, 0.52083333333333, 1.54, 0.45833333333333
39870, 0.54166666666667, 1.54, 0.4375
39871, 0.54166666666667, 1.56, 0.45833333333333
39872, 0.52083333333333, 1.58, 0.45833333333333
39873, 0.54166666666667, 1.58, 0.4375
39874, 0.54166666666667, 1.6, 0.45833333333333
39875, 0.52083333333333, 1.62, 0.45833333333333
39876, 0.54166666666667, 1.62, 0.4375
39877, 0.54166666666667, 1.64, 0.45833333333333
39878, 0.52083333333333, 1.66, 0.45833333333333
39879, 0.54166666666667, 1.66, 0.4375
39880, 0.54166666666667, 1.68, 0.45833333333333
39881, 0.54166666666667, 1.54, 0.47916666666667
39882, 0.54166666666667, 1.58, 0.47916666666667
39883, 0.54166666666667, 1.62, 0.47916666666667
39884, 0.54166666666667, 1.66, 0.47916666666667
39885, 0.58333333333333, 1.52, 0.041666666666667
39886, 0.5625, 1.54, 0.041666666666667
39887, 0.58333333333333, 1.54, 0.020833333333333
39888, 0.58333333333333, 1.56, 0.041666666666667
39889, 0.5625, 1.58, 0.041666666666667
39890, 0.58333333333333, 1.58, 0.020833333333333
39891, 0.58333333333333, 1.6, 0.041666666666667
39892, 0.5625, 1.62, 0.041666666666667
39893, 0.58333333333333, 1.62, 0.020833333333333
39894, 0.58333333333333, 1.64, 0.041666666666667
39895, 0.5625, 1.66, 0.041666666666667
39896, 0.58333333333333, 1.66, 0.020833333333333
39897, 0.58333333333333, 1.68, 0.041666666666667
39898, 0.58333333333333, 1.52, 0.083333333333333
39899, 0.5625, 1.54, 0.083333333333333
39900, 0.58333333333333, 1.54, 0.0625
39901, 0.58333333333333, 1.56, 0.083333333333333
39902, 0.5625, 1.58, 0.083333333333333
39903, 0.58333333333333, 1.58, 0.0625
39904, 0.58333333333333, 1.6, 0.083333333333333
39905, 0.5625, 1.62, 0.083333333333333
39906, 0.58333333333333, 1.62, 0.0625
39907, 0.58333333333333, 1.64, 0.083333333333333
39908, 0.5625, 1.66, 0.083333333333333
39909, 0.58333333333333, 1.66, 0.0625
39910, 0.58333333333333, 1.68, 0.083333333333333
39911, 0.58333333333333, 1.52, 0.125
39912, 0.5625, 1.54, 0.125
39913, 0.58333333333333, 1.54, 0.10416666666667
39914, 0.58333333333333, 1.56, 0.125
39915, 0.5625, 1.58, 0.125
39916, 0.58333333333333, 1.58, 0.10416666666667
39917, 0.58333333333333, 1.6, 0.125
39918, 0.5625, 1.62, 0.125
39919, 0.58333333333333, 1.62, 0.10416666666667
39920, 0.58333333333333, 1.64, 0.125
39921, 0.5625, 1.66, 0.125
39922, 0.58333333333333, 1.66, 0.10416666666667
39923, 0.58333333333333, 1.68, 0.125
39924, 0.58333333333333, 1.52, 0.16666666666667
39925, 0.5625, 1.54, 0.16666666666667
39926, 0.58333333333333, 1.54, 0.14583333333333
39927, 0.58333333333333, 1.56, 0.16666666666667
39928, 0.5625, 1.58, 0.16666666666667
39929, 0.58333333333333, 1.58, 0.14583333333333
39930, 0.58333333333333, 1.6, 0.16666666666667
39931, 0.5625, 1.62, 0.16666666666667
39932, 0.58333333333333, 1.62, 0.14583333333333
39933, 0.58333333333333, 1.64, 0.16666666666667
39934, 0.5625, 1.66, 0.16666666666667
39935, 0.58333333333333, 1.66, 0.14583333333333
39936, 0.58333333333333, 1.68, 0.16666666666667
39937, 0.58333333333333, 1.52, 0.20833333333333
39938, 0.5625, 1.54, 0.20833333333333
39939, 0.58333333333333, 1.54, 0.1875
39940, 0.58333333333333, 1.56, 0.20833333333333
39941, 0.5625, 1.58, 0.20833333333333
39942, 0.58333333333333, 1.58, 0.1875
39943, 0.58333333333333, 1.6, 0.20833333333333
39944, 0.5625, 1.62, 0.20833333333333
39945, 0.58333333333333, 1.62, 0.1875
39946, 0.58333333333333, 1.64, 0.20833333333333
39947, 0.5625, 1.66, 0.20833333333333
39948, 0.58333333333333, 1.66, 0.1875
39949, 0.58333333333333, 1.68, 0.20833333333333
39950, 0.58333333333333, 1.52, 0.25
39951, 0.5625, 1.54, 0.25
39952, 0.58333333333333, 1.54, 0.22916666666667
39953, 0.58333333333333, 1.56, 0.25
39954, 0.5625, 1.58, 0.25
39955, 0.58333333333333, 1.58, 0.22916666666667
39956, 0.58333333333333, 1.6, 0.25
39957, 0.5625, 1.62, 0.25
39958, 0.58333333333333, 1.62, 0.22916666666667
39959, 0.58333333333333, 1.64, 0.25
39960, 0.5625, 1.66, 0.25
39961, 0.58333333333333, 1.66, 0.22916666666667
39962, 0.58333333333333, 1.68, 0.25
39963, 0.58333333333333, 1.52, 0.29166666666667
39964, 0.5625, 1.54, 0.29166666666667
39965, 0.58333333333333, 1.54, 0.27083333333333
39966, 0.58333333333333, 1.56, 0.29166666666667
39967, 0.5625, 1.58, 0.29166666666667
39968, 0.58333333333333, 1.58, 0.27083333333333
39969, 0.58333333333333, 1.6, 0.29166666666667
39970, 0.5625, 1.62, 0.29166666666667
39971, 0.58333333333333, 1.62, 0.27083333333333
39972, 0.58333333333333, 1.64, 0.29166666666667
39973, 0.5625, 1.66, 0.29166666666667
39974, 0.58333333333333, 1.66, 0.27083333333333
39975, 0.58333333333333, 1.68, 0.29166666666667
39976, 0.58333333333333, 1.52, 0.33333333333333
39977, 0.5625, 1.54, 0.33333333333333
39978, 0.58333333333333, 1.54, 0.3125
39979, 0.58333333333333, 1.56, 0.33333333333333
39980, 0.5625, 1.58, 0.33333333333333
39981, 0.58333333333333, 1.58, 0.3125
39982, 0.58333333333333, 1.6, 0.33333333333333
39983, 0.5625, 1.62, 0.33333333333333
39984, 0.58333333333333, 1.62, 0.3125
39985, 0.58333333333333, 1.64, 0.33333333333333
39986, 0.5625, 1.66, 0.33333333333333
39987, 0.58333333333333, 1.66, 0.3125
39988, 0.58333333333333, 1.68, 0.33333333333333
39989, 0.58333333333333, 1.52, 0.375
39990, 0.5625, 1.54, 0.375
39991, 0.58333333333333, 1.54, 0.35416666666667
39992, 0.58333333333333, 1.56, 0.375
39993, 0.5625, 1.58, 0.375
39994, 0.58333333333333, 1.58, 0.35416666666667
39995, 0.58333333333333, 1.6, 0.375
39996, 0.5625, 1.62, 0.375
39997, 0.58333333333333, 1.62, 0.35416666666667
39998, 0.58333333333333, 1.64, 0.375
39999, 0.5625, 1.66, 0.375
40000, 0.58333333333333, 1.66, 0.35416666666667
40001, 0.58333333333333, 1.68, 0.375
40002, 0.58333333333333, 1.52, 0.41666666666667
40003, 0.5625, 1.54, 0.41666666666667
40004, 0.58333333333333, 1.54, 0.39583333333333
40005, 0.58333333333333, 1.56, 0.41666666666667
40006, 0.5625, 1.58, 0.41666666666667
40007, 0.58333333333333, 1.58, 0.39583333333333
40008, 0.58333333333333, 1.6, 0.41666666666667
40009, 0.5625, 1.62, 0.41666666666667
40010, 0.58333333333333, 1.62, 0.39583333333333
40011, 0.58333333333333, 1.64, 0.41666666666667
40012, 0.5625, 1.66, 0.41666666666667
40013, 0.58333333333333, 1.66, 0.39583333333333
40014, 0.58333333333333, 1.68, 0.41666666666667
40015, 0.58333333333333, 1.52, 0.45833333333333
40016, 0.5625, 1.54, 0.45833333333333
40017, 0.58333333333333, 1.54, 0.4375
40018, 0.58333333333333, 1.56, 0.45833333333333
40019, 0.5625, 1.58, 0.45833333333333
40020, 0.58333333333333, 1.58, 0.4375
40021, 0.58333333333333, 1.6, 0.45833333333333
40022, 0.5625, 1.62, 0.45833333333333
40023, 0.58333333333333, 1.62, 0.4375
40024, 0.58333333333333, 1.64, 0.45833333333333
40025, 0.5625, 1.66, 0.45833333333333
40026, 0.58333333333333, 1.66, 0.4375
40027, 0.58333333333333, 1.68, 0.45833333333333
40028, 0.58333333333333, 1.54, 0.47916666666667
40029, 0.58333333333333, 1.58, 0.47916666666667
40030, 0.58333333333333, 1.62, 0.47916666666667
40031, 0.58333333333333, 1.66, 0.47916666666667
40032, 0.625, 1.52, 0.041666666666667
40033, 0.60416666666667, 1.54, 0.041666666666667
40034, 0.625, 1.54, 0.020833333333333
40035, 0.625, 1.56, 0.041666666666667
40036, 0.60416666666667, 1.58, 0.041666666666667
40037, 0.625, 1.58, 0.020833333333333
40038, 0.625, 1.6, 0.041666666666667
40039, 0.60416666666667, 1.62, 0.041666666666667
40040, 0.625, 1.62, 0.020833333333333
40041, 0.625, 1.64, 0.041666666666667
40042, 0.60416666666667, 1.66, 0.041666666666667
40043, 0.625, 1.66, 0.020833333333333
40044, 0.625, 1.68, 0.041666666666667
40045, 0.625, 1.52, 0.083333333333333
40046, 0.60416666666667, 1.54, 0.083333333333333
40047, 0.625, 1.54, 0.0625
40048, 0.625, 1.56, 0.083333333333333
40049, 0.60416666666667, 1.58, 0.083333333333333
40050, 0.625, 1.58, 0.0625
40051, 0.625, 1.6, 0.083333333333333
40052, 0.60416666666667, 1.62, 0.083333333333333
40053, 0.625, 1.62, 0.0625
40054, 0.625, 1.64, 0.083333333333333
40055, 0.60416666666667, 1.66, 0.083333333333333
40056, 0.625, 1.66, 0.0625
40057, 0.625, 1.68, 0.083333333333333
40058, 0.625, 1.52, 0.125
40059, 0.60416666666667, 1.54, 0.125
40060, 0.625, 1.54, 0.10416666666667
40061, 0.625, 1.56, 0.125
40062, 0.60416666666667, 1.58, 0.125
40063, 0.625, 1.58, 0.10416666666667
40064, 0.625, 1.6, 0.125
40065, 0.60416666666667, 1.62, 0.125
40066, 0.625, 1.62, 0.10416666666667
40067, 0.625, 1.64, 0.125
40068, 0.60416666666667, 1.66, 0.125
40069, 0.625, 1.66, 0.10416666666667
40070, 0.625, 1.68, 0.125
40071, 0.625, 1.52, 0.16666666666667
40072, 0.60416666666667, 1.54, 0.16666666666667
40073, 0.625, 1.54, 0.14583333333333
40074, 0.625, 1.56, 0.16666666666667
40075, 0.60416666666667, 1.58, 0.16666666666667
40076, 0.625, 1.58, 0.14583333333333
40077, 0.625, 1.6, 0.16666666666667
40078, 0.60416666666667, 1.62, 0.16666666666667
40079, 0.625, 1.62, 0.14583333333333
40080, 0.625, 1.64, 0.16666666666667
40081, 0.60416666666667, 1.66, 0.16666666666667
40082, 0.625, 1.66, 0.14583333333333
40083, 0.625, 1.68, 0.16666666666667
40084, 0.625, 1.52, 0.20833333333333
40085, 0.60416666666667, 1.54, 0.20833333333333
40086, 0.625, 1.54, 0.1875
40087, 0.625, 1.56, 0.20833333333333
40088, 0.60416666666667, 1.58, 0.20833333333333
40089, 0.625, 1.58, 0.1875
40090, 0.625, 1.6, 0.20833333333333
40091, 0.60416666666667, 1.62, 0.20833333333333
40092, 0.625, 1.62, 0.1875
40093, 0.625, 1.64, 0.20833333333333
40094, 0.60416666666667, 1.66, 0.20833333333333
40095, 0.625, 1.66, 0.1875
40096, 0.625, 1.68, 0.20833333333333
40097, 0.625, 1.52, 0.25
40098, 0.60416666666667, 1.54, 0.25
40099, 0.625, 1.54, 0.22916666666667
40100, 0.625, 1.56, 0.25
40101, 0.60416666666667, 1.58, 0.25
40102, 0.625, 1.58, 0.22916666666667
40103, 0.625, 1.6, 0.25
40104, 0.60416666666667, 1.62, 0.25
40105, 0.625, 1.62, 0.22916666666667
40106, 0.625, 1.64, 0.25
40107, 0.60416666666667, 1.66, 0.25
40108, 0.625, 1.66, 0.22916666666667
40109, 0.625, 1.68, 0.25
40110, 0.625, 1.52, 0.29166666666667
40111, 0.60416666666667, 1.54, 0.29166666666667
40112, 0.625, 1.54, 0.27083333333333
40113, 0.625, 1.56, 0.29166666666667
40114, 0.60416666666667, 1.58, 0.29166666666667
40115, 0.625, 1.58, 0.27083333333333
40116, 0.625, 1.6, 0.29166666666667
40117, 0.60416666666667, 1.62, 0.29166666666667
40118, 0.625, 1.62, 0.27083333333333
40119, 0.625, 1.64, 0.29166666666667
40120, 0.60416666666667, 1.66, 0.29166666666667
40121, 0.625, 1.66, 0.27083333333333
40122, 0.625, 1.68, 0.29166666666667
40123, 0.625, 1.52, 0.33333333333333
40124, 0.60416666666667, 1.54, 0.33333333333333
40125, 0.625, 1.54, 0.3125
40126, 0.625, 1.56, 0.33333333333333
40127, 0.60416666666667, 1.58, 0.33333333333333
40128, 0.625, 1.58, 0.3125
40129, 0.625, 1.6, 0.33333333333333
40130, 0.60416666666667, 1.62, 0.33333333333333
40131, 0.625, 1.62, 0.3125
40132, 0.625, 1.64, 0.33333333333333
40133, 0.60416666666667, 1.66, 0.33333333333333
40134, 0.625, 1.66, 0.3125
40135, 0.625, 1.68, 0.33333333333333
40136, 0.625, 1.52, 0.375
40137, 0.60416666666667, 1.54, 0.375
40138, 0.625, 1.54, 0.35416666666667
40139, 0.625, 1.56, 0.375
40140, 0.60416666666667, 1.58, 0.375
40141, 0.625, 1.58, 0.35416666666667
40142, 0.625, 1.6, 0.375
40143, 0.60416666666667, 1.62, 0.375
40144, 0.625, 1.62, 0.35416666666667
40145, 0.625, 1.64, 0.375
40146, 0.60416666666667, 1.66, 0.375
40147, 0.625, 1.66, 0.35416666666667
40148, 0.625, 1.68, 0.375
40149, 0.625, 1.52, 0.41666666666667
40150, 0.60416666666667, 1.54, 0.41666666666667
40151, 0.625, 1.54, 0.39583333333333
40152, 0.625, 1.56, 0.41666666666667
40153, 0.60416666666667, 1.58, 0.41666666666667
40154, 0.625, 1.58, 0.39583333333333
40155, 0.625, 1.6, 0.41666666666667
40156, 0.60416666666667, 1.62, 0.41666666666667
40157, 0.625, 1.62, 0.39583333333333
40158, 0.625, 1.64, 0.41666666666667
40159, 0.60416666666667, 1.66, 0.41666666666667
40160, 0.625, 1.66, 0.39583333333333
40161, 0.625, 1.68, 0.41666666666667
40162, 0.625, 1.52, 0.45833333333333
40163, 0.60416666666667, 1.54, 0.45833333333333
40164, 0.625, 1.54, 0.4375
40165, 0.625, 1.56, 0.45833333333333
40166, 0.60416666666667, 1.58, 0.45833333333333
40167, 0.625, 1.58, 0.4375
40168, 0.625, 1.6, 0.45833333333333
40169, 0.60416666666667, 1.62, 0.45833333333333
40170, 0.625, 1.62, 0.4375
40171, 0.625, 1.64, 0.45833333333333
40172, 0.60416666666667, 1.66, 0.45833333333333
40173, 0.625, 1.66, 0.4375
40174, 0.625, 1.68, 0.45833333333333
40175, 0.625, 1.54, 0.47916666666667
40176, 0.625, 1.58, 0.47916666666667
40177, 0.625, 1.62, 0.47916666666667
40178, 0.625, 1.66, 0.47916666666667
40179, 0.66666666666667, 1.52, 0.041666666666667
40180, 0.64583333333333, 1.54, 0.041666666666667
40181, 0.66666666666667, 1.54, 0.020833333333333
40182, 0.66666666666667, 1.56, 0.041666666666667
40183, 0.64583333333333, 1.58, 0.041666666666667
40184, 0.66666666666667, 1.58, 0.020833333333333
40185, 0.66666666666667, 1.6, 0.041666666666667
40186, 0.64583333333333, 1.62, 0.041666666666667
40187, 0.66666666666667, 1.62, 0.020833333333333
40188, 0.66666666666667, 1.64, 0.041666666666667
40189, 0.64583333333333, 1.66, 0.041666666666667
40190, 0.66666666666667, 1.66, 0.020833333333333
40191, 0.66666666666667, 1.68, 0.041666666666667
40192, 0.66666666666667, 1.52, 0.083333333333333
40193, 0.64583333333333, 1.54, 0.083333333333333
40194, 0.66666666666667, 1.54, 0.0625
40195, 0.66666666666667, 1.56, 0.083333333333333
40196, 0.64583333333333, 1.58, 0.083333333333333
40197, 0.66666666666667, 1.58, 0.0625
40198, 0.66666666666667, 1.6, 0.083333333333333
40199, 0.64583333333333, 1.62, 0.083333333333333
40200, 0.66666666666667, 1.62, 0.0625
40201, 0.66666666666667, 1.64, 0.083333333333333
40202, 0.64583333333333, 1.66, 0.083333333333333
40203, 0.66666666666667, 1.66, 0.0625
40204, 0.66666666666667, 1.68, 0.083333333333333
40205, 0.66666666666667, 1.52, 0.125
40206, 0.64583333333333, 1.54, 0.125
40207, 0.66666666666667, 1.54, 0.10416666666667
40208, 0.66666666666667, 1.56, 0.125
40209, 0.64583333333333, 1.58, 0.125
40210, 0.66666666666667, 1.58, 0.10416666666667
40211, 0.66666666666667, 1.6, 0.125
40212, 0.64583333333333, 1.62, 0.125
40213, 0.66666666666667, 1.62, 0.10416666666667
40214, 0.66666666666667, 1.64, 0.125
40215, 0.64583333333333, 1.66, 0.125
40216, 0.66666666666667, 1.66, 0.10416666666667
40217, 0.66666666666667, 1.68, 0.125
40218, 0.66666666666667, 1.52, 0.16666666666667
40219, 0.64583333333333, 1.54, 0.16666666666667
40220, 0.66666666666667, 1.54, 0.14583333333333
40221, 0.66666666666667, 1.56, 0.16666666666667
40222, 0.64583333333333, 1.58, 0.16666666666667
40223, 0.66666666666667, 1.58, 0.14583333333333
40224, 0.66666666666667, 1.6, 0.16666666666667
40225, 0.64583333333333, 1.62, 0.16666666666667
40226, 0.66666666666667, 1.62, 0.14583333333333
40227, 0.66666666666667, 1.64, 0.16666666666667
40228, 0.64583333333333, 1.66, 0.16666666666667
40229, 0.66666666666667, 1.66, 0.14583333333333
40230, 0.66666666666667, 1.68, 0.16666666666667
40231, 0.66666666666667, 1.52, 0.20833333333333
40232, 0.64583333333333, 1.54, 0.20833333333333
40233, 0.66666666666667, 1.54, 0.1875
40234, 0.66666666666667, 1.56, 0.20833333333333
40235, 0.64583333333333, 1.58, 0.20833333333333
40236, 0.66666666666667, 1.58, 0.1875
40237, 0.66666666666667, 1.6, 0.20833333333333
40238, 0.64583333333333, 1.62, 0.20833333333333
40239, 0.66666666666667, 1.62, 0.1875
40240, 0.66666666666667, 1.64, 0.20833333333333
40241, 0.64583333333333, 1.66, 0.20833333333333
40242, 0.66666666666667, 1.66, 0.1875
40243, 0.66666666666667, 1.68, 0.20833333333333
40244, 0.66666666666667, 1.52, 0.25
40245, 0.64583333333333, 1.54, 0.25
40246, 0.66666666666667, 1.54, 0.22916666666667
40247, 0.66666666666667, 1.56, 0.25
40248, 0.64583333333333, 1.58, 0.25
40249, 0.66666666666667, 1.58, 0.22916666666667
40250, 0.66666666666667, 1.6, 0.25
40251, 0.64583333333333, 1.62, 0.25
40252, 0.66666666666667, 1.62, 0.22916666666667
40253, 0.66666666666667, 1.64, 0.25
40254, 0.64583333333333, 1.66, 0.25
40255, 0.66666666666667, 1.66, 0.22916666666667
40256, 0.66666666666667, 1.68, 0.25
40257, 0.66666666666667, 1.52, 0.29166666666667
40258, 0.64583333333333, 1.54, 0.29166666666667
40259, 0.66666666666667, 1.54, 0.27083333333333
40260, 0.66666666666667, 1.56, 0.29166666666667
40261, 0.64583333333333, 1.58, 0.29166666666667
40262, 0.66666666666667, 1.58, 0.27083333333333
40263, 0.66666666666667, 1.6, 0.29166666666667
40264, 0.64583333333333, 1.62, 0.29166666666667
40265, 0.66666666666667, 1.62, 0.27083333333333
40266, 0.66666666666667, 1.64, 0.29166666666667
40267, 0.64583333333333, 1.66, 0.29166666666667
40268, 0.66666666666667, 1.66, 0.27083333333333
40269, 0.66666666666667, 1.68, 0.29166666666667
40270, 0.66666666666667, 1.52, 0.33333333333333
40271, 0.64583333333333, 1.54, 0.33333333333333
40272, 0.66666666666667, 1.54, 0.3125
40273, 0.66666666666667, 1.56, 0.33333333333333
40274, 0.64583333333333, 1.58, 0.33333333333333
40275, 0.66666666666667, 1.58, 0.3125
40276, 0.66666666666667, 1.6, 0.33333333333333
40277, 0.64583333333333, 1.62, 0.33333333333333
40278, 0.66666666666667, 1.62, 0.3125
40279, 0.66666666666667, 1.64, 0.33333333333333
40280, 0.64583333333333, 1.66, 0.33333333333333
40281, 0.66666666666667, 1.66, 0.3125
40282, 0.66666666666667, 1.68, 0.33333333333333
40283, 0.66666666666667, 1.52, 0.375
40284, 0.64583333333333, 1.54, 0.375
40285, 0.66666666666667, 1.54, 0.35416666666667
40286, 0.66666666666667, 1.56, 0.375
40287, 0.64583333333333, 1.58, 0.375
40288, 0.66666666666667, 1.58, 0.35416666666667
40289, 0.66666666666667, 1.6, 0.375
40290, 0.64583333333333, 1.62, 0.375
40291, 0.66666666666667, 1.62, 0.35416666666667
40292, 0.66666666666667, 1.64, 0.375
40293, 0.64583333333333, 1.66, 0.375
40294, 0.66666666666667, 1.66, 0.35416666666667
40295, 0.66666666666667, 1.68, 0.375
40296, 0.66666666666667, 1.52, 0.41666666666667
40297, 0.64583333333333, 1.54, 0.41666666666667
40298, 0.66666666666667, 1.54, 0.39583333333333
40299, 0.66666666666667, 1.56, 0.41666666666667
40300, 0.64583333333333, 1.58, 0.41666666666667
40301, 0.66666666666667, 1.58, 0.39583333333333
40302, 0.66666666666667, 1.6, 0.41666666666667
40303, 0.64583333333333, 1.62, 0.41666666666667
40304, 0.66666666666667, 1.62, 0.39583333333333
40305, 0.66666666666667, 1.64, 0.41666666666667
40306, 0.64583333333333, 1.66, 0.41666666666667
40307, 0.66666666666667, 1.66, 0.39583333333333
40308, 0.66666666666667, 1.68, 0.41666666666667
40309, 0.66666666666667, 1.52, 0.45833333333333
40310, 0.64583333333333, 1.54, 0.45833333333333
40311, 0.66666666666667, 1.54, 0.4375
40312, 0.66666666666667, 1.56, 0.45833333333333
40313, 0.64583333333333, 1.58, 0.45833333333333
40314, 0.66666666666667, 1.58, 0.4375
40315, 0.66666666666667, 1.6, 0.45833333333333
40316, 0.64583333333333, 1.62, 0.45833333333333
40317, 0.66666666666667, 1.62, 0.4375
40318, 0.66666666666667, 1.64, 0.45833333333333
40319, 0.64583333333333, 1.66, 0.45833333333333
40320, 0.66666666666667, 1.66, 0.4375
40321, 0.66666666666667, 1.68, 0.45833333333333
40322, 0.66666666666667, 1.54, 0.47916666666667
40323, 0.66666666666667, 1.58, 0.47916666666667
40324, 0.66666666666667, 1.62, 0.47916666666667
40325, 0.66666666666667, 1.66, 0.47916666666667
40326, 0.70833333333333, 1.52, 0.041666666666667
40327, 0.6875, 1.54, 0.041666666666667
40328, 0.70833333333333, 1.54, 0.020833333333333
40329, 0.70833333333333, 1.56, 0.041666666666667
40330, 0.6875, 1.58, 0.041666666666667
40331, 0.70833333333333, 1.58, 0.020833333333333
40332, 0.70833333333333, 1.6, 0.041666666666667
40333, 0.6875, 1.62, 0.041666666666667
40334, 0.70833333333333, 1.62, 0.020833333333333
40335, 0.70833333333333, 1.64, 0.041666666666667
40336, 0.6875, 1.66, 0.041666666666667
40337, 0.70833333333333, 1.66, 0.020833333333333
40338, 0.70833333333333, 1.68, 0.041666666666667
40339, 0.70833333333333, 1.52, 0.083333333333333
40340, 0.6875, 1.54, 0.083333333333333
40341, 0.70833333333333, 1.54, 0.0625
40342, 0.70833333333333, 1.56, 0.083333333333333
40343, 0.6875, 1.58, 0.083333333333333
40344, 0.70833333333333, 1.58, 0.0625
40345, 0.70833333333333, 1.6, 0.083333333333333
40346, 0.6875, 1.62, 0.083333333333333
40347, 0.70833333333333, 1.62, 0.0625
40348, 0.70833333333333, 1.64, 0.083333333333333
40349, 0.6875, 1.66, 0.083333333333333
40350, 0.70833333333333, 1.66, 0.0625
40351, 0.70833333333333, 1.68, 0.083333333333333
40352, 0.70833333333333, 1.52, 0.125
40353, 0.6875, 1.54, 0.125
40354, 0.70833333333333, 1.54, 0.10416666666667
40355, 0.70833333333333, 1.56, 0.125
40356, 0.6875, 1.58, 0.125
40357, 0.70833333333333, 1.58, 0.10416666666667
40358, 0.70833333333333, 1.6, 0.125
40359, 0.6875, 1.62, 0.125
40360, 0.70833333333333, 1.62, 0.10416666666667
40361, 0.70833333333333, 1.64, 0.125
40362, 0.6875, 1.66, 0.125
40363, 0.70833333333333, 1.66, 0.10416666666667
40364, 0.70833333333333, 1.68, 0.125
40365, 0.70833333333333, 1.52, 0.16666666666667
40366, 0.6875, 1.54, 0.16666666666667
40367, 0.70833333333333, 1.54, 0.14583333333333
40368, 0.70833333333333, 1.56, 0.16666666666667
40369, 0.6875, 1.58, 0.16666666666667
40370, 0.70833333333333, 1.58, 0.14583333333333
40371, 0.70833333333333, 1.6, 0.16666666666667
40372, 0.6875, 1.62, 0.16666666666667
40373, 0.70833333333333, 1.62, 0.14583333333333
40374, 0.70833333333333, 1.64, 0.16666666666667
40375, 0.6875, 1.66, 0.16666666666667
40376, 0.70833333333333, 1.66, 0.14583333333333
40377, 0.70833333333333, 1.68, 0.16666666666667
40378, 0.70833333333333, 1.52, 0.20833333333333
40379, 0.6875, 1.54, 0.20833333333333
40380, 0.70833333333333, 1.54, 0.1875
40381, 0.70833333333333, 1.56, 0.20833333333333
40382, 0.6875, 1.58, 0.20833333333333
40383, 0.70833333333333, 1.58, 0.1875
40384, 0.70833333333333, 1.6, 0.20833333333333
40385, 0.6875, 1.62, 0.20833333333333
40386, 0.70833333333333, 1.62, 0.1875
40387, 0.70833333333333, 1.64, 0.20833333333333
40388, 0.6875, 1.66, 0.20833333333333
40389, 0.70833333333333, 1.66, 0.1875
40390, 0.70833333333333, 1.68, 0.20833333333333
40391, 0.70833333333333, 1.52, 0.25
40392, 0.6875, 1.54, 0.25
40393, 0.70833333333333, 1.54, 0.22916666666667
40394, 0.70833333333333, 1.56, 0.25
40395, 0.6875, 1.58, 0.25
40396, 0.70833333333333, 1.58, 0.22916666666667
40397, 0.70833333333333, 1.6, 0.25
40398, 0.6875, 1.62, 0.25
40399, 0.70833333333333, 1.62, 0.22916666666667
40400, 0.70833333333333, 1.64, 0.25
40401, 0.6875, 1.66, 0.25
40402, 0.70833333333333, 1.66, 0.22916666666667
40403, 0.70833333333333, 1.68, 0.25
40404, 0.70833333333333, 1.52, 0.29166666666667
40405, 0.6875, 1.54, 0.29166666666667
40406, 0.70833333333333, 1.54, 0.27083333333333
40407, 0.70833333333333, 1.56, 0.29166666666667
40408, 0.6875, 1.58, 0.29166666666667
40409, 0.70833333333333, 1.58, 0.27083333333333
40410, 0.70833333333333, 1.6, 0.29166666666667
40411, 0.6875, 1.62, 0.29166666666667
40412, 0.70833333333333, 1.62, 0.27083333333333
40413, 0.70833333333333, 1.64, 0.29166666666667
40414, 0.6875, 1.66, 0.29166666666667
40415, 0.70833333333333, 1.66, 0.27083333333333
40416, 0.70833333333333, 1.68, 0.29166666666667
40417, 0.70833333333333, 1.52, 0.33333333333333
40418, 0.6875, 1.54, 0.33333333333333
40419, 0.70833333333333, 1.54, 0.3125
40420, 0.70833333333333, 1.56, 0.33333333333333
40421, 0.6875, 1.58, 0.33333333333333
40422, 0.70833333333333, 1.58, 0.3125
40423, 0.70833333333333, 1.6, 0.33333333333333
40424, 0.6875, 1.62, 0.33333333333333
40425, 0.70833333333333, 1.62, 0.3125
40426, 0.70833333333333, 1.64, 0.33333333333333
40427, 0.6875, 1.66, 0.33333333333333
40428, 0.70833333333333, 1.66, 0.3125
40429, 0.70833333333333, 1.68, 0.33333333333333
40430, 0.70833333333333, 1.52, 0.375
40431, 0.6875, 1.54, 0.375
40432, 0.70833333333333, 1.54, 0.35416666666667
40433, 0.70833333333333, 1.56, 0.375
40434, 0.6875, 1.58, 0.375
40435, 0.70833333333333, 1.58, 0.35416666666667
40436, 0.70833333333333, 1.6, 0.375
40437, 0.6875, 1.62, 0.375
40438, 0.70833333333333, 1.62, 0.35416666666667
40439, 0.70833333333333, 1.64, 0.375
40440, 0.6875, 1.66, 0.375
40441, 0.70833333333333, 1.66, 0.35416666666667
40442, 0.70833333333333, 1.68, 0.375
40443, 0.70833333333333, 1.52, 0.41666666666667
40444, 0.6875, 1.54, 0.41666666666667
40445, 0.70833333333333, 1.54, 0.39583333333333
40446, 0.70833333333333, 1.56, 0.41666666666667
40447, 0.6875, 1.58, 0.41666666666667
40448, 0.70833333333333, 1.58, 0.39583333333333
40449, 0.70833333333333, 1.6, 0.41666666666667
40450, 0.6875, 1.62, 0.41666666666667
40451, 0.70833333333333, 1.62, 0.39583333333333
40452, 0.70833333333333, 1.64, 0.41666666666667
40453, 0.6875, 1.66, 0.41666666666667
40454, 0.70833333333333, 1.66, 0.39583333333333
40455, 0.70833333333333, 1.68, 0.41666666666667
40456, 0.70833333333333, 1.52, 0.45833333333333
40457, 0.6875, 1.54, 0.45833333333333
40458, 0.70833333333333, 1.54, 0.4375
40459, 0.70833333333333, 1.56, 0.45833333333333
40460, 0.6875, 1.58, 0.45833333333333
40461, 0.70833333333333, 1.58, 0.4375
40462, 0.70833333333333, 1.6, 0.45833333333333
40463, 0.6875, 1.62, 0.45833333333333
40464, 0.70833333333333, 1.62, 0.4375
40465, 0.70833333333333, 1.64, 0.45833333333333
40466, 0.6875, 1.66, 0.45833333333333
40467, 0.70833333333333, 1.66, 0.4375
40468, 0.70833333333333, 1.68, 0.45833333333333
40469, 0.70833333333333, 1.54, 0.47916666666667
40470, 0.70833333333333, 1.58, 0.47916666666667
40471, 0.70833333333333, 1.62, 0.47916666666667
40472, 0.70833333333333, 1.66, 0.47916666666667
40473, 0.75, 1.52, 0.041666666666667
40474, 0.72916666666667, 1.54, 0.041666666666667
40475, 0.75, 1.54, 0.020833333333333
40476, 0.75, 1.56, 0.041666666666667
40477, 0.72916666666667, 1.58, 0.041666666666667
40478, 0.75, 1.58, 0.020833333333333
40479, 0.75, 1.6, 0.041666666666667
40480, 0.72916666666667, 1.62, 0.041666666666667
40481, 0.75, 1.62, 0.020833333333333
40482, 0.75, 1.64, 0.041666666666667
40483, 0.72916666666667, 1.66, 0.041666666666667
40484, 0.75, 1.66, 0.020833333333333
40485, 0.75, 1.68, 0.041666666666667
40486, 0.75, 1.52, 0.083333333333333
40487, 0.72916666666667, 1.54, 0.083333333333333
40488, 0.75, 1.54, 0.0625
40489, 0.75, 1.56, 0.083333333333333
40490, 0.72916666666667, 1.58, 0.083333333333333
40491, 0.75, 1.58, 0.0625
40492, 0.75, 1.6, 0.083333333333333
40493, 0.72916666666667, 1.62, 0.083333333333333
40494, 0.75, 1.62, 0.0625
40495, 0.75, 1.64, 0.083333333333333
40496, 0.72916666666667, 1.66, 0.083333333333333
40497, 0.75, 1.66, 0.0625
40498, 0.75, 1.68, 0.083333333333333
40499, 0.75, 1.52, 0.125
40500, 0.72916666666667, 1.54, 0.125
40501, 0.75, 1.54, 0.10416666666667
40502, 0.75, 1.56, 0.125
40503, 0.72916666666667, 1.58, 0.125
40504, 0.75, 1.58, 0.10416666666667
40505, 0.75, 1.6, 0.125
40506, 0.72916666666667, 1.62, 0.125
40507, 0.75, 1.62, 0.10416666666667
40508, 0.75, 1.64, 0.125
40509, 0.72916666666667, 1.66, 0.125
40510, 0.75, 1.66, 0.10416666666667
40511, 0.75, 1.68, 0.125
40512, 0.75, 1.52, 0.16666666666667
40513, 0.72916666666667, 1.54, 0.16666666666667
40514, 0.75, 1.54, 0.14583333333333
40515, 0.75, 1.56, 0.16666666666667
40516, 0.72916666666667, 1.58, 0.16666666666667
40517, 0.75, 1.58, 0.14583333333333
40518, 0.75, 1.6, 0.16666666666667
40519, 0.72916666666667, 1.62, 0.16666666666667
40520, 0.75, 1.62, 0.14583333333333
40521, 0.75, 1.64, 0.16666666666667
40522, 0.72916666666667, 1.66, 0.16666666666667
40523, 0.75, 1.66, 0.14583333333333
40524, 0.75, 1.68, 0.16666666666667
40525, 0.75, 1.52, 0.20833333333333
40526, 0.72916666666667, 1.54, 0.20833333333333
40527, 0.75, 1.54, 0.1875
40528, 0.75, 1.56, 0.20833333333333
40529, 0.72916666666667, 1.58, 0.20833333333333
40530, 0.75, 1.58, 0.1875
40531, 0.75, 1.6, 0.20833333333333
40532, 0.72916666666667, 1.62, 0.20833333333333
40533, 0.75, 1.62, 0.1875
40534, 0.75, 1.64, 0.20833333333333
40535, 0.72916666666667, 1.66, 0.20833333333333
40536, 0.75, 1.66, 0.1875
40537, 0.75, 1.68, 0.20833333333333
40538, 0.75, 1.52, 0.25
40539, 0.72916666666667, 1.54, 0.25
40540, 0.75, 1.54, 0.22916666666667
40541, 0.75, 1.56, 0.25
40542, 0.72916666666667, 1.58, 0.25
40543, 0.75, 1.58, 0.22916666666667
40544, 0.75, 1.6, 0.25
40545, 0.72916666666667, 1.62, 0.25
40546, 0.75, 1.62, 0.22916666666667
40547, 0.75, 1.64, 0.25
40548, 0.72916666666667, 1.66, 0.25
40549, 0.75, 1.66, 0.22916666666667
40550, 0.75, 1.68, 0.25
40551, 0.75, 1.52, 0.29166666666667
40552, 0.72916666666667, 1.54, 0.29166666666667
40553, 0.75, 1.54, 0.27083333333333
40554, 0.75, 1.56, 0.29166666666667
40555, 0.72916666666667, 1.58, 0.29166666666667
40556, 0.75, 1.58, 0.27083333333333
40557, 0.75, 1.6, 0.29166666666667
40558, 0.72916666666667, 1.62, 0.29166666666667
40559, 0.75, 1.62, 0.27083333333333
40560, 0.75, 1.64, 0.29166666666667
40561, 0.72916666666667, 1.66, 0.29166666666667
40562, 0.75, 1.66, 0.27083333333333
40563, 0.75, 1.68, 0.29166666666667
40564, 0.75, 1.52, 0.33333333333333
40565, 0.72916666666667, 1.54, 0.33333333333333
40566, 0.75, 1.54, 0.3125
40567, 0.75, 1.56, 0.33333333333333
40568, 0.72916666666667, 1.58, 0.33333333333333
40569, 0.75, 1.58, 0.3125
40570, 0.75, 1.6, 0.33333333333333
40571, 0.72916666666667, 1.62, 0.33333333333333
40572, 0.75, 1.62, 0.3125
40573, 0.75, 1.64, 0.33333333333333
40574, 0.72916666666667, 1.66, 0.33333333333333
40575, 0.75, 1.66, 0.3125
40576, 0.75, 1.68, 0.33333333333333
40577, 0.75, 1.52, 0.375
40578, 0.72916666666667, 1.54, 0.375
40579, 0.75, 1.54, 0.35416666666667
40580, 0.75, 1.56, 0.375
40581, 0.72916666666667, 1.58, 0.375
40582, 0.75, 1.58, 0.35416666666667
40583, 0.75, 1.6, 0.375
40584, 0.72916666666667, 1.62, 0.375
40585, 0.75, 1.62, 0.35416666666667
40586, 0.75, 1.64, 0.375
40587, 0.72916666666667, 1.66, 0.375
40588, 0.75, 1.66, 0.35416666666667
40589, 0.75, 1.68, 0.375
40590, 0.75, 1.52, 0.41666666666667
40591, 0.72916666666667, 1.54, 0.41666666666667
40592, 0.75, 1.54, 0.39583333333333
40593, 0.75, 1.56, 0.41666666666667
40594, 0.72916666666667, 1.58, 0.41666666666667
40595, 0.75, 1.58, 0.39583333333333
40596, 0.75, 1.6, 0.41666666666667
40597, 0.72916666666667, 1.62, 0.41666666666667
40598, 0.75, 1.62, 0.39583333333333
40599, 0.75, 1.64, 0.41666666666667
40600, 0.72916666666667, 1.66, 0.41666666666667
40601, 0.75, 1.66, 0.39583333333333
40602, 0.75, 1.68, 0.41666666666667
40603, 0.75, 1.52, 0.45833333333333
40604, 0.72916666666667, 1.54, 0.45833333333333
40605, 0.75, 1.54, 0.4375
40606, 0.75, 1.56, 0.45833333333333
40607, 0.72916666666667, 1.58, 0.45833333333333
40608, 0.75, 1.58, 0.4375
40609, 0.75, 1.6, 0.45833333333333
40610, 0.72916666666667, 1.62, 0.45833333333333
40611, 0.75, 1.62, 0.4375
40612, 0.75, 1.64, 0.45833333333333
40613, 0.72916666666667, 1.66, 0.45833333333333
40614, 0.75, 1.66, 0.4375
40615, 0.75, 1.68, 0.45833333333333
40616, 0.75, 1.54, 0.47916666666667
40617, 0.75, 1.58, 0.47916666666667
40618, 0.75, 1.62, 0.47916666666667
40619, 0.75, 1.66, 0.47916666666667
40620, 0.79166666666667, 1.52, 0.041666666666667
40621, 0.77083333333333, 1.54, 0.041666666666667
40622, 0.79166666666667, 1.54, 0.020833333333333
40623, 0.79166666666667, 1.56, 0.041666666666667
40624, 0.77083333333333, 1.58, 0.041666666666667
40625, 0.79166666666667, 1.58, 0.020833333333333
40626, 0.79166666666667, 1.6, 0.041666666666667
40627, 0.77083333333333, 1.62, 0.041666666666667
40628, 0.79166666666667, 1.62, 0.020833333333333
40629, 0.79166666666667, 1.64, 0.041666666666667
40630, 0.77083333333333, 1.66, 0.041666666666667
40631, 0.79166666666667, 1.66, 0.020833333333333
40632, 0.79166666666667, 1.68, 0.041666666666667
40633, 0.79166666666667, 1.52, 0.083333333333333
40634, 0.77083333333333, 1.54, 0.083333333333333
40635, 0.79166666666667, 1.54, 0.0625
40636, 0.79166666666667, 1.56, 0.083333333333333
40637, 0.77083333333333, 1.58, 0.083333333333333
40638, 0.79166666666667, 1.58, 0.0625
40639, 0.79166666666667, 1.6, 0.083333333333333
40640, 0.77083333333333, 1.62, 0.083333333333333
40641, 0.79166666666667, 1.62, 0.0625
40642, 0.79166666666667, 1.64, 0.083333333333333
40643, 0.77083333333333, 1.66, 0.083333333333333
40644, 0.79166666666667, 1.66, 0.0625
40645, 0.79166666666667, 1.68, 0.083333333333333
40646, 0.79166666666667, 1.52, 0.125
40647, 0.77083333333333, 1.54, 0.125
40648, 0.79166666666667, 1.54, 0.10416666666667
40649, 0.79166666666667, 1.56, 0.125
40650, 0.77083333333333, 1.58, 0.125
40651, 0.79166666666667, 1.58, 0.10416666666667
40652, 0.79166666666667, 1.6, 0.125
40653, 0.77083333333333, 1.62, 0.125
40654, 0.79166666666667, 1.62, 0.10416666666667
40655, 0.79166666666667, 1.64, 0.125
40656, 0.77083333333333, 1.66, 0.125
40657, 0.79166666666667, 1.66, 0.10416666666667
40658, 0.79166666666667, 1.68, 0.125
40659, 0.79166666666667, 1.52, 0.16666666666667
40660, 0.77083333333333, 1.54, 0.16666666666667
40661, 0.79166666666667, 1.54, 0.14583333333333
40662, 0.79166666666667, 1.56, 0.16666666666667
40663, 0.77083333333333, 1.58, 0.16666666666667
40664, 0.79166666666667, 1.58, 0.14583333333333
40665, 0.79166666666667, 1.6, 0.16666666666667
40666, 0.77083333333333, 1.62, 0.16666666666667
40667, 0.79166666666667, 1.62, 0.14583333333333
40668, 0.79166666666667, 1.64, 0.16666666666667
40669, 0.77083333333333, 1.66, 0.16666666666667
40670, 0.79166666666667, 1.66, 0.14583333333333
40671, 0.79166666666667, 1.68, 0.16666666666667
40672, 0.79166666666667, 1.52, 0.20833333333333
40673, 0.77083333333333, 1.54, 0.20833333333333
40674, 0.79166666666667, 1.54, 0.1875
40675, 0.79166666666667, 1.56, 0.20833333333333
40676, 0.77083333333333, 1.58, 0.20833333333333
40677, 0.79166666666667, 1.58, 0.1875
40678, 0.79166666666667, 1.6, 0.20833333333333
40679, 0.77083333333333, 1.62, 0.20833333333333
40680, 0.79166666666667, 1.62, 0.1875
40681, 0.79166666666667, 1.64, 0.20833333333333
40682, 0.77083333333333, 1.66, 0.20833333333333
40683, 0.79166666666667, 1.66, 0.1875
40684, 0.79166666666667, 1.68, 0.20833333333333
40685, 0.79166666666667, 1.52, 0.25
40686, 0.77083333333333, 1.54, 0.25
40687, 0.79166666666667, 1.54, 0.22916666666667
40688, 0.79166666666667, 1.56, 0.25
40689, 0.77083333333333, 1.58, 0.25
40690, 0.79166666666667, 1.58, 0.22916666666667
40691, 0.79166666666667, 1.6, 0.25
40692, 0.77083333333333, 1.62, 0.25
40693, 0.79166666666667, 1.62, 0.22916666666667
40694, 0.79166666666667, 1.64, 0.25
40695, 0.77083333333333, 1.66, 0.25
40696, 0.79166666666667, 1.66, 0.22916666666667
40697, 0.79166666666667, 1.68, 0.25
40698, 0.79166666666667, 1.52, 0.29166666666667
40699, 0.77083333333333, 1.54, 0.29166666666667
40700, 0.79166666666667, 1.54, 0.27083333333333
40701, 0.79166666666667, 1.56, 0.29166666666667
40702, 0.77083333333333, 1.58, 0.29166666666667
40703, 0.79166666666667, 1.58, 0.27083333333333
40704, 0.79166666666667, 1.6, 0.29166666666667
40705, 0.77083333333333, 1.62, 0.29166666666667
40706, 0.79166666666667, 1.62, 0.27083333333333
40707, 0.79166666666667, 1.64, 0.29166666666667
40708, 0.77083333333333, 1.66, 0.29166666666667
40709, 0.79166666666667, 1.66, 0.27083333333333
40710, 0.79166666666667, 1.68, 0.29166666666667
40711, 0.79166666666667, 1.52, 0.33333333333333
40712, 0.77083333333333, 1.54, 0.33333333333333
40713, 0.79166666666667, 1.54, 0.3125
40714, 0.79166666666667, 1.56, 0.33333333333333
40715, 0.77083333333333, 1.58, 0.33333333333333
40716, 0.79166666666667, 1.58, 0.3125
40717, 0.79166666666667, 1.6, 0.33333333333333
40718, 0.77083333333333, 1.62, 0.33333333333333
40719, 0.79166666666667, 1.62, 0.3125
40720, 0.79166666666667, 1.64, 0.33333333333333
40721, 0.77083333333333, 1.66, 0.33333333333333
40722, 0.79166666666667, 1.66, 0.3125
40723, 0.79166666666667, 1.68, 0.33333333333333
40724, 0.79166666666667, 1.52, 0.375
40725, 0.77083333333333, 1.54, 0.375
40726, 0.79166666666667, 1.54, 0.35416666666667
40727, 0.79166666666667, 1.56, 0.375
40728, 0.77083333333333, 1.58, 0.375
40729, 0.79166666666667, 1.58, 0.35416666666667
40730, 0.79166666666667, 1.6, 0.375
40731, 0.77083333333333, 1.62, 0.375
40732, 0.79166666666667, 1.62, 0.35416666666667
40733, 0.79166666666667, 1.64, 0.375
40734, 0.77083333333333, 1.66, 0.375
40735, 0.79166666666667, 1.66, 0.35416666666667
40736, 0.79166666666667, 1.68, 0.375
40737, 0.79166666666667, 1.52, 0.41666666666667
40738, 0.77083333333333, 1.54, 0.41666666666667
40739, 0.79166666666667, 1.54, 0.39583333333333
40740, 0.79166666666667, 1.56, 0.41666666666667
40741, 0.77083333333333, 1.58, 0.41666666666667
40742, 0.79166666666667, 1.58, 0.39583333333333
40743, 0.79166666666667, 1.6, 0.41666666666667
40744, 0.77083333333333, 1.62, 0.41666666666667
40745, 0.79166666666667, 1.62, 0.39583333333333
40746, 0.79166666666667, 1.64, 0.41666666666667
40747, 0.77083333333333, 1.66, 0.41666666666667
40748, 0.79166666666667, 1.66, 0.39583333333333
40749, 0.79166666666667, 1.68, 0.41666666666667
40750, 0.79166666666667, 1.52, 0.45833333333333
40751, 0.77083333333333, 1.54, 0.45833333333333
40752, 0.79166666666667, 1.54, 0.4375
40753, 0.79166666666667, 1.56, 0.45833333333333
40754, 0.77083333333333, 1.58, 0.45833333333333
40755, 0.79166666666667, 1.58, 0.4375
40756, 0.79166666666667, 1.6, 0.45833333333333
40757, 0.77083333333333, 1.62, 0.45833333333333
40758, 0.79166666666667, 1.62, 0.4375
40759, 0.79166666666667, 1.64, 0.45833333333333
40760, 0.77083333333333, 1.66, 0.45833333333333
40761, 0.79166666666667, 1.66, 0.4375
40762, 0.79166666666667, 1.68, 0.45833333333333
40763, 0.79166666666667, 1.54, 0.47916666666667
40764, 0.79166666666667, 1.58, 0.47916666666667
40765, 0.79166666666667, 1.62, 0.47916666666667
40766, 0.79166666666667, 1.66, 0.47916666666667
40767, 0.83333333333333, 1.52, 0.041666666666667
40768, 0.8125, 1.54, 0.041666666666667
40769, 0.83333333333333, 1.54, 0.020833333333333
40770, 0.83333333333333, 1.56, 0.041666666666667
40771, 0.8125, 1.58, 0.041666666666667
40772, 0.83333333333333, 1.58, 0.020833333333333
40773, 0.83333333333333, 1.6, 0.041666666666667
40774, 0.8125, 1.62, 0.041666666666667
40775, 0.83333333333333, 1.62, 0.020833333333333
40776, 0.83333333333333, 1.64, 0.041666666666667
40777, 0.8125, 1.66, 0.041666666666667
40778, 0.83333333333333, 1.66, 0.020833333333333
40779, 0.83333333333333, 1.68, 0.041666666666667
40780, 0.83333333333333, 1.52, 0.083333333333333
40781, 0.8125, 1.54, 0.083333333333333
40782, 0.83333333333333, 1.54, 0.0625
40783, 0.83333333333333, 1.56, 0.083333333333333
40784, 0.8125, 1.58, 0.083333333333333
40785, 0.83333333333333, 1.58, 0.0625
40786, 0.83333333333333, 1.6, 0.083333333333333
40787, 0.8125, 1.62, 0.083333333333333
40788, 0.83333333333333, 1.62, 0.0625
40789, 0.83333333333333, 1.64, 0.083333333333333
40790, 0.8125, 1.66, 0.083333333333333
40791, 0.83333333333333, 1.66, 0.0625
40792, 0.83333333333333, 1.68, 0.083333333333333
40793, 0.83333333333333, 1.52, 0.125
40794, 0.8125, 1.54, 0.125
40795, 0.83333333333333, 1.54, 0.10416666666667
40796, 0.83333333333333, 1.56, 0.125
40797, 0.8125, 1.58, 0.125
40798, 0.83333333333333, 1.58, 0.10416666666667
40799, 0.83333333333333, 1.6, 0.125
40800, 0.8125, 1.62, 0.125
40801, 0.83333333333333, 1.62, 0.10416666666667
40802, 0.83333333333333, 1.64, 0.125
40803, 0.8125, 1.66, 0.125
40804, 0.83333333333333, 1.66, 0.10416666666667
40805, 0.83333333333333, 1.68, 0.125
40806, 0.83333333333333, 1.52, 0.16666666666667
40807, 0.8125, 1.54, 0.16666666666667
40808, 0.83333333333333, 1.54, 0.14583333333333
40809, 0.83333333333333, 1.56, 0.16666666666667
40810, 0.8125, 1.58, 0.16666666666667
40811, 0.83333333333333, 1.58, 0.14583333333333
40812, 0.83333333333333, 1.6, 0.16666666666667
40813, 0.8125, 1.62, 0.16666666666667
40814, 0.83333333333333, 1.62, 0.14583333333333
40815, 0.83333333333333, 1.64, 0.16666666666667
40816, 0.8125, 1.66, 0.16666666666667
40817, 0.83333333333333, 1.66, 0.14583333333333
40818, 0.83333333333333, 1.68, 0.16666666666667
40819, 0.83333333333333, 1.52, 0.20833333333333
40820, 0.8125, 1.54, 0.20833333333333
40821, 0.83333333333333, 1.54, 0.1875
40822, 0.83333333333333, 1.56, 0.20833333333333
40823, 0.8125, 1.58, 0.20833333333333
40824, 0.83333333333333, 1.58, 0.1875
40825, 0.83333333333333, 1.6, 0.20833333333333
40826, 0.8125, 1.62, 0.20833333333333
40827, 0.83333333333333, 1.62, 0.1875
40828, 0.83333333333333, 1.64, 0.20833333333333
40829, 0.8125, 1.66, 0.20833333333333
40830, 0.83333333333333, 1.66, 0.1875
40831, 0.83333333333333, 1.68, 0.20833333333333
40832, 0.83333333333333, 1.52, 0.25
40833, 0.8125, 1.54, 0.25
40834, 0.83333333333333, 1.54, 0.22916666666667
40835, 0.83333333333333, 1.56, 0.25
40836, 0.8125, 1.58, 0.25
40837, 0.83333333333333, 1.58, 0.22916666666667
40838, 0.83333333333333, 1.6, 0.25
40839, 0.8125, 1.62, 0.25
40840, 0.83333333333333, 1.62, 0.22916666666667
40841, 0.83333333333333, 1.64, 0.25
40842, 0.8125, 1.66, 0.25
40843, 0.83333333333333, 1.66, 0.22916666666667
40844, 0.83333333333333, 1.68, 0.25
40845, 0.83333333333333, 1.52, 0.29166666666667
40846, 0.8125, 1.54, 0.29166666666667
40847, 0.83333333333333, 1.54, 0.27083333333333
40848, 0.83333333333333, 1.56, 0.29166666666667
40849, 0.8125, 1.58, 0.29166666666667
40850, 0.83333333333333, 1.58, 0.27083333333333
40851, 0.83333333333333, 1.6, 0.29166666666667
40852, 0.8125, 1.62, 0.29166666666667
40853, 0.83333333333333, 1.62, 0.27083333333333
40854, 0.83333333333333, 1.64, 0.29166666666667
40855, 0.8125, 1.66, 0.29166666666667
40856, 0.83333333333333, 1.66, 0.27083333333333
40857, 0.83333333333333, 1.68, 0.29166666666667
40858, 0.83333333333333, 1.52, 0.33333333333333
40859, 0.8125, 1.54, 0.33333333333333
40860, 0.83333333333333, 1.54, 0.3125
40861, 0.83333333333333, 1.56, 0.33333333333333
40862, 0.8125, 1.58, 0.33333333333333
40863, 0.83333333333333, 1.58, 0.3125
40864, 0.83333333333333, 1.6, 0.33333333333333
40865, 0.8125, 1.62, 0.33333333333333
40866, 0.83333333333333, 1.62, 0.3125
40867, 0.83333333333333, 1.64, 0.33333333333333
40868, 0.8125, 1.66, 0.33333333333333
40869, 0.83333333333333, 1.66, 0.3125
40870, 0.83333333333333, 1.68, 0.33333333333333
40871, 0.83333333333333, 1.52, 0.375
40872, 0.8125, 1.54, 0.375
40873, 0.83333333333333, 1.54, 0.35416666666667
40874, 0.83333333333333, 1.56, 0.375
40875, 0.8125, 1.58, 0.375
40876, 0.83333333333333, 1.58, 0.35416666666667
40877, 0.83333333333333, 1.6, 0.375
40878, 0.8125, 1.62, 0.375
40879, 0.83333333333333, 1.62, 0.35416666666667
40880, 0.83333333333333, 1.64, 0.375
40881, 0.8125, 1.66, 0.375
40882, 0.83333333333333, 1.66, 0.35416666666667
40883, 0.83333333333333, 1.68, 0.375
40884, 0.83333333333333, 1.52, 0.41666666666667
40885, 0.8125, 1.54, 0.41666666666667
40886, 0.83333333333333, 1.54, 0.39583333333333
40887, 0.83333333333333, 1.56, 0.41666666666667
40888, 0.8125, 1.58, 0.41666666666667
40889, 0.83333333333333, 1.58, 0.39583333333333
40890, 0.83333333333333, 1.6, 0.41666666666667
40891, 0.8125, 1.62, 0.41666666666667
40892, 0.83333333333333, 1.62, 0.39583333333333
40893, 0.83333333333333, 1.64, 0.41666666666667
40894, 0.8125, 1.66, 0.41666666666667
40895, 0.83333333333333, 1.66, 0.39583333333333
40896, 0.83333333333333, 1.68, 0.41666666666667
40897, 0.83333333333333, 1.52, 0.45833333333333
40898, 0.8125, 1.54, 0.45833333333333
40899, 0.83333333333333, 1.54, 0.4375
40900, 0.83333333333333, 1.56, 0.45833333333333
40901, 0.8125, 1.58, 0.45833333333333
40902, 0.83333333333333, 1.58, 0.4375
40903, 0.83333333333333, 1.6, 0.45833333333333
40904, 0.8125, 1.62, 0.45833333333333
40905, 0.83333333333333, 1.62, 0.4375
40906, 0.83333333333333, 1.64, 0.45833333333333
40907, 0.8125, 1.66, 0.45833333333333
40908, 0.83333333333333, 1.66, 0.4375
40909, 0.83333333333333, 1.68, 0.45833333333333
40910, 0.83333333333333, 1.54, 0.47916666666667
40911, 0.83333333333333, 1.58, 0.47916666666667
40912, 0.83333333333333, 1.62, 0.47916666666667
40913, 0.83333333333333, 1.66, 0.47916666666667
40914, 0.875, 1.52, 0.041666666666667
40915, 0.85416666666667, 1.54, 0.041666666666667
40916, 0.875, 1.54, 0.020833333333333
40917, 0.875, 1.56, 0.041666666666667
40918, 0.85416666666667, 1.58, 0.041666666666667
40919, 0.875, 1.58, 0.020833333333333
40920, 0.875, 1.6, 0.041666666666667
40921, 0.85416666666667, 1.62, 0.041666666666667
40922, 0.875, 1.62, 0.020833333333333
40923, 0.875, 1.64, 0.041666666666667
40924, 0.85416666666667, 1.66, 0.041666666666667
40925, 0.875, 1.66, 0.020833333333333
40926, 0.875, 1.68, 0.041666666666667
40927, 0.875, 1.52, 0.083333333333333
40928, 0.85416666666667, 1.54, 0.083333333333333
40929, 0.875, 1.54, 0.0625
40930, 0.875, 1.56, 0.083333333333333
40931, 0.85416666666667, 1.58, 0.083333333333333
40932, 0.875, 1.58, 0.0625
40933, 0.875, 1.6, 0.083333333333333
40934, 0.85416666666667, 1.62, 0.083333333333333
40935, 0.875, 1.62, 0.0625
40936, 0.875, 1.64, 0.083333333333333
40937, 0.85416666666667, 1.66, 0.083333333333333
40938, 0.875, 1.66, 0.0625
40939, 0.875, 1.68, 0.083333333333333
40940, 0.875, 1.52, 0.125
40941, 0.85416666666667, 1.54, 0.125
40942, 0.875, 1.54, 0.10416666666667
40943, 0.875, 1.56, 0.125
40944, 0.85416666666667, 1.58, 0.125
40945, 0.875, 1.58, 0.10416666666667
40946, 0.875, 1.6, 0.125
40947, 0.85416666666667, 1.62, 0.125
40948, 0.875, 1.62, 0.10416666666667
40949, 0.875, 1.64, 0.125
40950, 0.85416666666667, 1.66, 0.125
40951, 0.875, 1.66, 0.10416666666667
40952, 0.875, 1.68, 0.125
40953, 0.875, 1.52, 0.16666666666667
40954, 0.85416666666667, 1.54, 0.16666666666667
40955, 0.875, 1.54, 0.14583333333333
40956, 0.875, 1.56, 0.16666666666667
40957, 0.85416666666667, 1.58, 0.16666666666667
40958, 0.875, 1.58, 0.14583333333333
40959, 0.875, 1.6, 0.16666666666667
40960, 0.85416666666667, 1.62, 0.16666666666667
40961, 0.875, 1.62, 0.14583333333333
40962, 0.875, 1.64, 0.16666666666667
40963, 0.85416666666667, 1.66, 0.16666666666667
40964, 0.875, 1.66, 0.14583333333333
40965, 0.875, 1.68, 0.16666666666667
40966, 0.875, 1.52, 0.20833333333333
40967, 0.85416666666667, 1.54, 0.20833333333333
40968, 0.875, 1.54, 0.1875
40969, 0.875, 1.56, 0.20833333333333
40970, 0.85416666666667, 1.58, 0.20833333333333
40971, 0.875, 1.58, 0.1875
40972, 0.875, 1.6, 0.20833333333333
40973, 0.85416666666667, 1.62, 0.20833333333333
40974, 0.875, 1.62, 0.1875
40975, 0.875, 1.64, 0.20833333333333
40976, 0.85416666666667, 1.66, 0.20833333333333
40977, 0.875, 1.66, 0.1875
40978, 0.875, 1.68, 0.20833333333333
40979, 0.875, 1.52, 0.25
40980, 0.85416666666667, 1.54, 0.25
40981, 0.875, 1.54, 0.22916666666667
40982, 0.875, 1.56, 0.25
40983, 0.85416666666667, 1.58, 0.25
40984, 0.875, 1.58, 0.22916666666667
40985, 0.875, 1.6, 0.25
40986, 0.85416666666667, 1.62, 0.25
40987, 0.875, 1.62, 0.22916666666667
40988, 0.875, 1.64, 0.25
40989, 0.85416666666667, 1.66, 0.25
40990, 0.875, 1.66, 0.22916666666667
40991, 0.875, 1.68, 0.25
40992, 0.875, 1.52, 0.29166666666667
40993, 0.85416666666667, 1.54, 0.29166666666667
40994, 0.875, 1.54, 0.27083333333333
40995, 0.875, 1.56, 0.29166666666667
40996, 0.85416666666667, 1.58, 0.29166666666667
40997, 0.875, 1.58, 0.27083333333333
40998, 0.875, 1.6, 0.29166666666667
40999, 0.85416666666667, 1.62, 0.29166666666667
41000, 0.875, 1.62, 0.27083333333333
41001, 0.875, 1.64, 0.29166666666667
41002, 0.85416666666667, 1.66, 0.29166666666667
41003, 0.875, 1.66, 0.27083333333333
41004, 0.875, 1.68, 0.29166666666667
41005, 0.875, 1.52, 0.33333333333333
41006, 0.85416666666667, 1.54, 0.33333333333333
41007, 0.875, 1.54, 0.3125
41008, 0.875, 1.56, 0.33333333333333
41009, 0.85416666666667, 1.58, 0.33333333333333
41010, 0.875, 1.58, 0.3125
41011, 0.875, 1.6, 0.33333333333333
41012, 0.85416666666667, 1.62, 0.33333333333333
41013, 0.875, 1.62, 0.3125
41014, 0.875, 1.64, 0.33333333333333
41015, 0.85416666666667, 1.66, 0.33333333333333
41016, 0.875, 1.66, 0.3125
41017, 0.875, 1.68, 0.33333333333333
41018, 0.875, 1.52, 0.375
41019, 0.85416666666667, 1.54, 0.375
41020, 0.875, 1.54, 0.35416666666667
41021, 0.875, 1.56, 0.375
41022, 0.85416666666667, 1.58, 0.375
41023, 0.875, 1.58, 0.35416666666667
41024, 0.875, 1.6, 0.375
41025, 0.85416666666667, 1.62, 0.375
41026, 0.875, 1.62, 0.35416666666667
41027, 0.875, 1.64, 0.375
41028, 0.85416666666667, 1.66, 0.375
41029, 0.875, 1.66, 0.35416666666667
41030, 0.875, 1.68, 0.375
41031, 0.875, 1.52, 0.41666666666667
41032, 0.85416666666667, 1.54, 0.41666666666667
41033, 0.875, 1.54, 0.39583333333333
41034, 0.875, 1.56, 0.41666666666667
41035, 0.85416666666667, 1.58, 0.41666666666667
41036, 0.875, 1.58, 0.39583333333333
41037, 0.875, 1.6, 0.41666666666667
41038, 0.85416666666667, 1.62, 0.41666666666667
41039, 0.875, 1.62, 0.39583333333333
41040, 0.875, 1.64, 0.41666666666667
41041, 0.85416666666667, 1.66, 0.41666666666667
41042, 0.875, 1.66, 0.39583333333333
41043, 0.875, 1.68, 0.41666666666667
41044, 0.875, 1.52, 0.45833333333333
41045, 0.85416666666667, 1.54, 0.45833333333333
41046, 0.875, 1.54, 0.4375
41047, 0.875, 1.56, 0.45833333333333
41048, 0.85416666666667, 1.58, 0.45833333333333
41049, 0.875, 1.58, 0.4375
41050, 0.875, 1.6, 0.45833333333333
41051, 0.85416666666667, 1.62, 0.45833333333333
41052, 0.875, 1.62, 0.4375
41053, 0.875, 1.64, 0.45833333333333
41054, 0.85416666666667, 1.66, 0.45833333333333
41055, 0.875, 1.66, 0.4375
41056, 0.875, 1.68, 0.45833333333333
41057, 0.875, 1.54, 0.47916666666667
41058, 0.875, 1.58, 0.47916666666667
41059, 0.875, 1.62, 0.47916666666667
41060, 0.875, 1.66, 0.47916666666667
41061, 0.91666666666667, 1.52, 0.041666666666667
41062, 0.89583333333333, 1.54, 0.041666666666667
41063, 0.91666666666667, 1.54, 0.020833333333333
41064, 0.91666666666667, 1.56, 0.041666666666667
41065, 0.89583333333333, 1.58, 0.041666666666667
41066, 0.91666666666667, 1.58, 0.020833333333333
41067, 0.91666666666667, 1.6, 0.041666666666667
41068, 0.89583333333333, 1.62, 0.041666666666667
41069, 0.91666666666667, 1.62, 0.020833333333333
41070, 0.91666666666667, 1.64, 0.041666666666667
41071, 0.89583333333333, 1.66, 0.041666666666667
41072, 0.91666666666667, 1.66, 0.020833333333333
41073, 0.91666666666667, 1.68, 0.041666666666667
41074, 0.91666666666667, 1.52, 0.083333333333333
41075, 0.89583333333333, 1.54, 0.083333333333333
41076, 0.91666666666667, 1.54, 0.0625
41077, 0.91666666666667, 1.56, 0.083333333333333
41078, 0.89583333333333, 1.58, 0.083333333333333
41079, 0.91666666666667, 1.58, 0.0625
41080, 0.91666666666667, 1.6, 0.083333333333333
41081, 0.89583333333333, 1.62, 0.083333333333333
41082, 0.91666666666667, 1.62, 0.0625
41083, 0.91666666666667, 1.64, 0.083333333333333
41084, 0.89583333333333, 1.66, 0.083333333333333
41085, 0.91666666666667, 1.66, 0.0625
41086, 0.91666666666667, 1.68, 0.083333333333333
41087, 0.91666666666667, 1.52, 0.125
41088, 0.89583333333333, 1.54, 0.125
41089, 0.91666666666667, 1.54, 0.10416666666667
41090, 0.91666666666667, 1.56, 0.125
41091, 0.89583333333333, 1.58, 0.125
41092, 0.91666666666667, 1.58, 0.10416666666667
41093, 0.91666666666667, 1.6, 0.125
41094, 0.89583333333333, 1.62, 0.125
41095, 0.91666666666667, 1.62, 0.10416666666667
41096, 0.91666666666667, 1.64, 0.125
41097, 0.89583333333333, 1.66, 0.125
41098, 0.91666666666667, 1.66, 0.10416666666667
41099, 0.91666666666667, 1.68, 0.125
41100, 0.91666666666667, 1.52, 0.16666666666667
41101, 0.89583333333333, 1.54, 0.16666666666667
41102, 0.91666666666667, 1.54, 0.14583333333333
41103, 0.91666666666667, 1.56, 0.16666666666667
41104, 0.89583333333333, 1.58, 0.16666666666667
41105, 0.91666666666667, 1.58, 0.14583333333333
41106, 0.91666666666667, 1.6, 0.16666666666667
41107, 0.89583333333333, 1.62, 0.16666666666667
41108, 0.91666666666667, 1.62, 0.14583333333333
41109, 0.91666666666667, 1.64, 0.16666666666667
41110, 0.89583333333333, 1.66, 0.16666666666667
41111, 0.91666666666667, 1.66, 0.14583333333333
41112, 0.91666666666667, 1.68, 0.16666666666667
41113, 0.91666666666667, 1.52, 0.20833333333333
41114, 0.89583333333333, 1.54, 0.20833333333333
41115, 0.91666666666667, 1.54, 0.1875
41116, 0.91666666666667, 1.56, 0.20833333333333
41117, 0.89583333333333, 1.58, 0.20833333333333
41118, 0.91666666666667, 1.58, 0.1875
41119, 0.91666666666667, 1.6, 0.20833333333333
41120, 0.89583333333333, 1.62, 0.20833333333333
41121, 0.91666666666667, 1.62, 0.1875
41122, 0.91666666666667, 1.64, 0.20833333333333
41123, 0.89583333333333, 1.66, 0.20833333333333
41124, 0.91666666666667, 1.66, 0.1875
41125, 0.91666666666667, 1.68, 0.20833333333333
41126, 0.91666666666667, 1.52, 0.25
41127, 0.89583333333333, 1.54, 0.25
41128, 0.91666666666667, 1.54, 0.22916666666667
41129, 0.91666666666667, 1.56, 0.25
41130, 0.89583333333333, 1.58, 0.25
41131, 0.91666666666667, 1.58, 0.22916666666667
41132, 0.91666666666667, 1.6, 0.25
41133, 0.89583333333333, 1.62, 0.25
41134, 0.91666666666667, 1.62, 0.22916666666667
41135, 0.91666666666667, 1.64, 0.25
41136, 0.89583333333333, 1.66, 0.25
41137, 0.91666666666667, 1.66, 0.22916666666667
41138, 0.91666666666667, 1.68, 0.25
41139, 0.91666666666667, 1.52, 0.29166666666667
41140, 0.89583333333333, 1.54, 0.29166666666667
41141, 0.91666666666667, 1.54, 0.27083333333333
41142, 0.91666666666667, 1.56, 0.29166666666667
41143, 0.89583333333333, 1.58, 0.29166666666667
41144, 0.91666666666667, 1.58, 0.27083333333333
41145, 0.91666666666667, 1.6, 0.29166666666667
41146, 0.89583333333333, 1.62, 0.29166666666667
41147, 0.91666666666667, 1.62, 0.27083333333333
41148, 0.91666666666667, 1.64, 0.29166666666667
41149, 0.89583333333333, 1.66, 0.29166666666667
41150, 0.91666666666667, 1.66, 0.27083333333333
41151, 0.91666666666667, 1.68, 0.29166666666667
41152, 0.91666666666667, 1.52, 0.33333333333333
41153, 0.89583333333333, 1.54, 0.33333333333333
41154, 0.91666666666667, 1.54, 0.3125
41155, 0.91666666666667, 1.56, 0.33333333333333
41156, 0.89583333333333, 1.58, 0.33333333333333
41157, 0.91666666666667, 1.58, 0.3125
41158, 0.91666666666667, 1.6, 0.33333333333333
41159, 0.89583333333333, 1.62, 0.33333333333333
41160, 0.91666666666667, 1.62, 0.3125
41161, 0.91666666666667, 1.64, 0.33333333333333
41162, 0.89583333333333, 1.66, 0.33333333333333
41163, 0.91666666666667, 1.66, 0.3125
41164, 0.91666666666667, 1.68, 0.33333333333333
41165, 0.91666666666667, 1.52, 0.375
41166, 0.89583333333333, 1.54, 0.375
41167, 0.91666666666667, 1.54, 0.35416666666667
41168, 0.91666666666667, 1.56, 0.375
41169, 0.89583333333333, 1.58, 0.375
41170, 0.91666666666667, 1.58, 0.35416666666667
41171, 0.91666666666667, 1.6, 0.375
41172, 0.89583333333333, 1.62, 0.375
41173, 0.91666666666667, 1.62, 0.35416666666667
41174, 0.91666666666667, 1.64, 0.375
41175, 0.89583333333333, 1.66, 0.375
41176, 0.91666666666667, 1.66, 0.35416666666667
41177, 0.91666666666667, 1.68, 0.375
41178, 0.91666666666667, 1.52, 0.41666666666667
41179, 0.89583333333333, 1.54, 0.41666666666667
41180, 0.91666666666667, 1.54, 0.39583333333333
41181, 0.91666666666667, 1.56, 0.41666666666667
41182, 0.89583333333333, 1.58, 0.41666666666667
41183, 0.91666666666667, 1.58, 0.39583333333333
41184, 0.91666666666667, 1.6, 0.41666666666667
41185, 0.89583333333333, 1.62, 0.41666666666667
41186, 0.91666666666667, 1.62, 0.39583333333333
41187, 0.91666666666667, 1.64, 0.41666666666667
41188, 0.89583333333333, 1.66, 0.41666666666667
41189, 0.91666666666667, 1.66, 0.39583333333333
41190, 0.91666666666667, 1.68, 0.41666666666667
41191, 0.91666666666667, 1.52, 0.45833333333333
41192, 0.89583333333333, 1.54, 0.45833333333333
41193, 0.91666666666667, 1.54, 0.4375
41194, 0.91666666666667, 1.56, 0.45833333333333
41195, 0.89583333333333, 1.58, 0.45833333333333
41196, 0.91666666666667, 1.58, 0.4375
41197, 0.91666666666667, 1.6, 0.45833333333333
41198, 0.89583333333333, 1.62, 0.45833333333333
41199, 0.91666666666667, 1.62, 0.4375
41200, 0.91666666666667, 1.64, 0.45833333333333
41201, 0.89583333333333, 1.66, 0.45833333333333
41202, 0.91666666666667, 1.66, 0.4375
41203, 0.91666666666667, 1.68, 0.45833333333333
41204, 0.91666666666667, 1.54, 0.47916666666667
41205, 0.91666666666667, 1.58, 0.47916666666667
41206, 0.91666666666667, 1.62, 0.47916666666667
41207, 0.91666666666667, 1.66, 0.47916666666667
41208, 0.95833333333333, 1.52, 0.041666666666667
41209, 0.9375, 1.54, 0.041666666666667
41210, 0.95833333333333, 1.54, 0.020833333333333
41211, 0.95833333333333, 1.56, 0.041666666666667
41212, 0.9375, 1.58, 0.041666666666667
41213, 0.95833333333333, 1.58, 0.020833333333333
41214, 0.95833333333333, 1.6, 0.041666666666667
41215, 0.9375, 1.62, 0.041666666666667
41216, 0.95833333333333, 1.62, 0.020833333333333
41217, 0.95833333333333, 1.64, 0.041666666666667
41218, 0.9375, 1.66, 0.041666666666667
41219, 0.95833333333333, 1.66, 0.020833333333333
41220, 0.95833333333333, 1.68, 0.041666666666667
41221, 0.95833333333333, 1.52, 0.083333333333333
41222, 0.9375, 1.54, 0.083333333333333
41223, 0.95833333333333, 1.54, 0.0625
41224, 0.95833333333333, 1.56, 0.083333333333333
41225, 0.9375, 1.58, 0.083333333333333
41226, 0.95833333333333, 1.58, 0.0625
41227, 0.95833333333333, 1.6, 0.083333333333333
41228, 0.9375, 1.62, 0.083333333333333
41229, 0.95833333333333, 1.62, 0.0625
41230, 0.95833333333333, 1.64, 0.083333333333333
41231, 0.9375, 1.66, 0.083333333333333
41232, 0.95833333333333, 1.66, 0.0625
41233, 0.95833333333333, 1.68, 0.083333333333333
41234, 0.95833333333333, 1.52, 0.125
41235, 0.9375, 1.54, 0.125
41236, 0.95833333333333, 1.54, 0.10416666666667
41237, 0.95833333333333, 1.56, 0.125
41238, 0.9375, 1.58, 0.125
41239, 0.95833333333333, 1.58, 0.10416666666667
41240, 0.95833333333333, 1.6, 0.125
41241, 0.9375, 1.62, 0.125
41242, 0.95833333333333, 1.62, 0.10416666666667
41243, 0.95833333333333, 1.64, 0.125
41244, 0.9375, 1.66, 0.125
41245, 0.95833333333333, 1.66, 0.10416666666667
41246, 0.95833333333333, 1.68, 0.125
41247, 0.95833333333333, 1.52, 0.16666666666667
41248, 0.9375, 1.54, 0.16666666666667
41249, 0.95833333333333, 1.54, 0.14583333333333
41250, 0.95833333333333, 1.56, 0.16666666666667
41251, 0.9375, 1.58, 0.16666666666667
41252, 0.95833333333333, 1.58, 0.14583333333333
41253, 0.95833333333333, 1.6, 0.16666666666667
41254, 0.9375, 1.62, 0.16666666666667
41255, 0.95833333333333, 1.62, 0.14583333333333
41256, 0.95833333333333, 1.64, 0.16666666666667
41257, 0.9375, 1.66, 0.16666666666667
41258, 0.95833333333333, 1.66, 0.14583333333333
41259, 0.95833333333333, 1.68, 0.16666666666667
41260, 0.95833333333333, 1.52, 0.20833333333333
41261, 0.9375, 1.54, 0.20833333333333
41262, 0.95833333333333, 1.54, 0.1875
41263, 0.95833333333333, 1.56, 0.20833333333333
41264, 0.9375, 1.58, 0.20833333333333
41265, 0.95833333333333, 1.58, 0.1875
41266, 0.95833333333333, 1.6, 0.20833333333333
41267, 0.9375, 1.62, 0.20833333333333
41268, 0.95833333333333, 1.62, 0.1875
41269, 0.95833333333333, 1.64, 0.20833333333333
41270, 0.9375, 1.66, 0.20833333333333
41271, 0.95833333333333, 1.66, 0.1875
41272, 0.95833333333333, 1.68, 0.20833333333333
41273, 0.95833333333333, 1.52, 0.25
41274, 0.9375, 1.54, 0.25
41275, 0.95833333333333, 1.54, 0.22916666666667
41276, 0.95833333333333, 1.56, 0.25
41277, 0.9375, 1.58, 0.25
41278, 0.95833333333333, 1.58, 0.22916666666667
41279, 0.95833333333333, 1.6, 0.25
41280, 0.9375, 1.62, 0.25
41281, 0.95833333333333, 1.62, 0.22916666666667
41282, 0.95833333333333, 1.64, 0.25
41283, 0.9375, 1.66, 0.25
41284, 0.95833333333333, 1.66, 0.22916666666667
41285, 0.95833333333333, 1.68, 0.25
41286, 0.95833333333333, 1.52, 0.29166666666667
41287, 0.9375, 1.54, 0.29166666666667
41288, 0.95833333333333, 1.54, 0.27083333333333
41289, 0.95833333333333, 1.56, 0.29166666666667
41290, 0.9375, 1.58, 0.29166666666667
41291, 0.95833333333333, 1.58, 0.27083333333333
41292, 0.95833333333333, 1.6, 0.29166666666667
41293, 0.9375, 1.62, 0.29166666666667
41294, 0.95833333333333, 1.62, 0.27083333333333
41295, 0.95833333333333, 1.64, 0.29166666666667
41296, 0.9375, 1.66, 0.29166666666667
41297, 0.95833333333333, 1.66, 0.27083333333333
41298, 0.95833333333333, 1.68, 0.29166666666667
41299, 0.95833333333333, 1.52, 0.33333333333333
41300, 0.9375, 1.54, 0.33333333333333
41301, 0.95833333333333, 1.54, 0.3125
41302, 0.95833333333333, 1.56, 0.33333333333333
41303, 0.9375, 1.58, 0.33333333333333
41304, 0.95833333333333, 1.58, 0.3125
41305, 0.95833333333333, 1.6, 0.33333333333333
41306, 0.9375, 1.62, 0.33333333333333
41307, 0.95833333333333, 1.62, 0.3125
41308, 0.95833333333333, 1.64, 0.33333333333333
41309, 0.9375, 1.66, 0.33333333333333
41310, 0.95833333333333, 1.66, 0.3125
41311, 0.95833333333333, 1.68, 0.33333333333333
41312, 0.95833333333333, 1.52, 0.375
41313, 0.9375, 1.54, 0.375
41314, 0.95833333333333, 1.54, 0.35416666666667
41315, 0.95833333333333, 1.56, 0.375
41316, 0.9375, 1.58, 0.375
41317, 0.95833333333333, 1.58, 0.35416666666667
41318, 0.95833333333333, 1.6, 0.375
41319, 0.9375, 1.62, 0.375
41320, 0.95833333333333, 1.62, 0.35416666666667
41321, 0.95833333333333, 1.64, 0.375
41322, 0.9375, 1.66, 0.375
41323, 0.95833333333333, 1.66, 0.35416666666667
41324, 0.95833333333333, 1.68, 0.375
41325, 0.95833333333333, 1.52, 0.41666666666667
41326, 0.9375, 1.54, 0.41666666666667
41327, 0.95833333333333, 1.54, 0.39583333333333
41328, 0.95833333333333, 1.56, 0.41666666666667
41329, 0.9375, 1.58, 0.41666666666667
41330, 0.95833333333333, 1.58, 0.39583333333333
41331, 0.95833333333333, 1.6, 0.41666666666667
41332, 0.9375, 1.62, 0.41666666666667
41333, 0.95833333333333, 1.62, 0.39583333333333
41334, 0.95833333333333, 1.64, 0.41666666666667
41335, 0.9375, 1.66, 0.41666666666667
41336, 0.95833333333333, 1.66, 0.39583333333333
41337, 0.95833333333333, 1.68, 0.41666666666667
41338, 0.95833333333333, 1.52, 0.45833333333333
41339, 0.9375, 1.54, 0.45833333333333
41340, 0.95833333333333, 1.54, 0.4375
41341, 0.95833333333333, 1.56, 0.45833333333333
41342, 0.9375, 1.58, 0.45833333333333
41343, 0.95833333333333, 1.58, 0.4375
41344, 0.95833333333333, 1.6, 0.45833333333333
41345, 0.9375, 1.62, 0.45833333333333
41346, 0.95833333333333, 1.62, 0.4375
41347, 0.95833333333333, 1.64, 0.45833333333333
41348, 0.9375, 1.66, 0.45833333333333
41349, 0.95833333333333, 1.66, 0.4375
41350, 0.95833333333333, 1.68, 0.45833333333333
41351, 0.95833333333333, 1.54, 0.47916666666667
41352, 0.95833333333333, 1.58, 0.47916666666667
41353, 0.95833333333333, 1.62, 0.47916666666667
41354, 0.95833333333333, 1.66, 0.47916666666667
41355, 0.97916666666667, 1.54, 0.041666666666667
41356, 0.97916666666667, 1.58, 0.041666666666667
41357, 0.97916666666667, 1.62, 0.041666666666667
41358, 0.97916666666667, 1.66, 0.041666666666667
41359, 0.97916666666667, 1.54, 0.083333333333333
41360, 0.97916666666667, 1.58, 0.083333333333333
41361, 0.97916666666667, 1.62, 0.083333333333333
41362, 0.97916666666667, 1.66, 0.083333333333333
41363, 0.97916666666667, 1.54, 0.125
41364, 0.97916666666667, 1.58, 0.125
41365, 0.97916666666667, 1.62, 0.125
41366, 0.97916666666667, 1.66, 0.125
41367, 0.97916666666667, 1.54, 0.16666666666667
41368, 0.97916666666667, 1.58, 0.16666666666667
41369, 0.97916666666667, 1.62, 0.16666666666667
41370, 0.97916666666667, 1.66, 0.16666666666667
41371, 0.97916666666667, 1.54, 0.20833333333333
41372, 0.97916666666667, 1.58, 0.20833333333333
41373, 0.97916666666667, 1.62, 0.20833333333333
41374, 0.97916666666667, 1.66, 0.20833333333333
41375, 0.97916666666667, 1.54, 0.25
41376, 0.97916666666667, 1.58, 0.25
41377, 0.97916666666667, 1.62, 0.25
41378, 0.97916666666667, 1.66, 0.25
41379, 0.97916666666667, 1.54, 0.29166666666667
41380, 0.97916666666667, 1.58, 0.29166666666667
41381, 0.97916666666667, 1.62, 0.29166666666667
41382, 0.97916666666667, 1.66, 0.29166666666667
41383, 0.97916666666667, 1.54, 0.33333333333333
41384, 0.97916666666667, 1.58, 0.33333333333333
41385, 0.97916666666667, 1.62, 0.33333333333333
41386, 0.97916666666667, 1.66, 0.33333333333333
41387, 0.97916666666667, 1.54, 0.375
41388, 0.97916666666667, 1.58, 0.375
41389, 0.97916666666667, 1.62, 0.375
41390, 0.97916666666667, 1.66, 0.375
41391, 0.97916666666667, 1.54, 0.41666666666667
41392, 0.97916666666667, 1.58, 0.41666666666667
41393, 0.97916666666667, 1.62, 0.41666666666667
41394, 0.97916666666667, 1.66, 0.41666666666667
41395, 0.97916666666667, 1.54, 0.45833333333333
41396, 0.97916666666667, 1.58, 0.45833333333333
41397, 0.97916666666667, 1.62, 0.45833333333333
41398, 0.97916666666667, 1.66, 0.45833333333333
41399, 1.04, 1.54, 0.041666666666667
41400, 1.04, 1.58, 0.041666666666667
41401, 1.04, 1.62, 0.041666666666667
41402, 1.04, 1.66, 0.041666666666667
41403, 1.08, 1.54, 0.041666666666667
41404, 1.08, 1.58, 0.041666666666667
41405, 1.08, 1.62, 0.041666666666667
41406, 1.08, 1.66, 0.041666666666667
41407, 1.12, 1.54, 0.041666666666667
41408, 1.12, 1.58, 0.041666666666667
41409, 1.12, 1.62, 0.041666666666667
41410, 1.12, 1.66, 0.041666666666667
41411, 1.16, 1.54, 0.041666666666667
41412, 1.16, 1.58, 0.041666666666667
41413, 1.16, 1.62, 0.041666666666667
41414, 1.16, 1.66, 0.041666666666667
41415, 1.04, 1.54, 0.083333333333333
41416, 1.04, 1.58, 0.083333333333333
41417, 1.04, 1.62, 0.083333333333333
41418, 1.04, 1.66, 0.083333333333333
41419, 1.08, 1.54, 0.083333333333333
41420, 1.08, 1.58, 0.083333333333333
41421, 1.08, 1.62, 0.083333333333333
41422, 1.08, 1.66, 0.083333333333333
41423, 1.12, 1.54, 0.083333333333333
41424, 1.12, 1.58, 0.083333333333333
41425, 1.12, 1.62, 0.083333333333333
41426, 1.12, 1.66, 0.083333333333333
41427, 1.16, 1.54, 0.083333333333333
41428, 1.16, 1.58, 0.083333333333333
41429, 1.16, 1.62, 0.083333333333333
41430, 1.16, 1.66, 0.083333333333333
41431, 1.04, 1.54, 0.125
41432, 1.04, 1.58, 0.125
41433, 1.04, 1.62, 0.125
41434, 1.04, 1.66, 0.125
41435, 1.08, 1.54, 0.125
41436, 1.08, 1.58, 0.125
41437, 1.08, 1.62, 0.125
41438, 1.08, 1.66, 0.125
41439, 1.12, 1.54, 0.125
41440, 1.12, 1.58, 0.125
41441, 1.12, 1.62, 0.125
41442, 1.12, 1.66, 0.125
41443, 1.16, 1.54, 0.125
41444, 1.16, 1.58, 0.125
41445, 1.16, 1.62, 0.125
41446, 1.16, 1.66, 0.125
41447, 1.04, 1.54, 0.16666666666667
41448, 1.04, 1.58, 0.16666666666667
41449, 1.04, 1.62, 0.16666666666667
41450, 1.04, 1.66, 0.16666666666667
41451, 1.08, 1.54, 0.16666666666667
41452, 1.08, 1.58, 0.16666666666667
41453, 1.08, 1.62, 0.16666666666667
41454, 1.08, 1.66, 0.16666666666667
41455, 1.12, 1.54, 0.16666666666667
41456, 1.12, 1.58, 0.16666666666667
41457, 1.12, 1.62, 0.16666666666667
41458, 1.12, 1.66, 0.16666666666667
41459, 1.16, 1.54, 0.16666666666667
41460, 1.16, 1.58, 0.16666666666667
41461, 1.16, 1.62, 0.16666666666667
41462, 1.16, 1.66, 0.16666666666667
41463, 1.04, 1.54, 0.20833333333333
41464, 1.04, 1.58, 0.20833333333333
41465, 1.04, 1.62, 0.20833333333333
41466, 1.04, 1.66, 0.20833333333333
41467, 1.08, 1.54, 0.20833333333333
41468, 1.08, 1.58, 0.20833333333333
41469, 1.08, 1.62, 0.20833333333333
41470, 1.08, 1.66, 0.20833333333333
41471, 1.12, 1.54, 0.20833333333333
41472, 1.12, 1.58, 0.20833333333333
41473, 1.12, 1.62, 0.20833333333333
41474, 1.12, 1.66, 0.20833333333333
41475, 1.16, 1.54, 0.20833333333333
41476, 1.16, 1.58, 0.20833333333333
41477, 1.16, 1.62, 0.20833333333333
41478, 1.16, 1.66, 0.20833333333333
41479, 1.04, 1.54, 0.25
41480, 1.04, 1.58, 0.25
41481, 1.04, 1.62, 0.25
41482, 1.04, 1.66, 0.25
41483, 1.08, 1.54, 0.25
41484, 1.08, 1.58, 0.25
41485, 1.08, 1.62, 0.25
41486, 1.08, 1.66, 0.25
41487, 1.12, 1.54, 0.25
41488, 1.12, 1.58, 0.25
41489, 1.12, 1.62, 0.25
41490, 1.12, 1.66, 0.25
41491, 1.16, 1.54, 0.25
41492, 1.16, 1.58, 0.25
41493, 1.16, 1.62, 0.25
41494, 1.16, 1.66, 0.25
41495, 1.04, 1.54, 0.29166666666667
41496, 1.04, 1.58, 0.29166666666667
41497, 1.04, 1.62, 0.29166666666667
41498, 1.04, 1.66, 0.29166666666667
41499, 1.08, 1.54, 0.29166666666667
41500, 1.08, 1.58, 0.29166666666667
41501, 1.08, 1.62, 0.29166666666667
41502, 1.08, 1.66, 0.29166666666667
41503, 1.12, 1.54, 0.29166666666667
41504, 1.12, 1.58, 0.29166666666667
41505, 1.12, 1.62, 0.29166666666667
41506, 1.12, 1.66, 0.29166666666667
41507, 1.16, 1.54, 0.29166666666667
41508, 1.16, 1.58, 0.29166666666667
41509, 1.16, 1.62, 0.29166666666667
41510, 1.16, 1.66, 0.29166666666667
41511, 1.04, 1.54, 0.33333333333333
41512, 1.04, 1.58, 0.33333333333333
41513, 1.04, 1.62, 0.33333333333333
41514, 1.04, 1.66, 0.33333333333333
41515, 1.08, 1.54, 0.33333333333333
41516, 1.08, 1.58, 0.33333333333333
41517, 1.08, 1.62, 0.33333333333333
41518, 1.08, 1.66, 0.33333333333333
41519, 1.12, 1.54, 0.33333333333333
41520, 1.12, 1.58, 0.33333333333333
41521, 1.12, 1.62, 0.33333333333333
41522, 1.12, 1.66, 0.33333333333333
41523, 1.16, 1.54, 0.33333333333333
41524, 1.16, 1.58, 0.33333333333333
41525, 1.16, 1.62, 0.33333333333333
41526, 1.16, 1.66, 0.33333333333333
41527, 1.04, 1.54, 0.375
41528, 1.04, 1.58, 0.375
41529, 1.04, 1.62, 0.375
41530, 1.04, 1.66, 0.375
41531, 1.08, 1.54, 0.375
41532, 1.08, 1.58, 0.375
41533, 1.08, 1.62, 0.375
41534, 1.08, 1.66, 0.375
41535, 1.12, 1.54, 0.375
41536, 1.12, 1.58, 0.375
41537, 1.12, 1.62, 0.375
41538, 1.12, 1.66, 0.375
41539, 1.16, 1.54, 0.375
41540, 1.16, 1.58, 0.375
41541, 1.16, 1.62, 0.375
41542, 1.16, 1.66, 0.375
41543, 1.04, 1.54, 0.41666666666667
41544, 1.04, 1.58, 0.41666666666667
41545, 1.04, 1.62, 0.41666666666667
41546, 1.04, 1.66, 0.41666666666667
41547, 1.08, 1.54, 0.41666666666667
41548, 1.08, 1.58, 0.41666666666667
41549, 1.08, 1.62, 0.41666666666667
41550, 1.08, 1.66, 0.41666666666667
41551, 1.12, 1.54, 0.41666666666667
41552, 1.12, 1.58, 0.41666666666667
41553, 1.12, 1.62, 0.41666666666667
41554, 1.12, 1.66, 0.41666666666667
41555, 1.16, 1.54, 0.41666666666667
41556, 1.16, 1.58, 0.41666666666667
41557, 1.16, 1.62, 0.41666666666667
41558, 1.16, 1.66, 0.41666666666667
41559, 1.04, 1.54, 0.45833333333333
41560, 1.04, 1.58, 0.45833333333333
41561, 1.04, 1.62, 0.45833333333333
41562, 1.04, 1.66, 0.45833333333333
41563, 1.08, 1.54, 0.45833333333333
41564, 1.08, 1.58, 0.45833333333333
41565, 1.08, 1.62, 0.45833333333333
41566, 1.08, 1.66, 0.45833333333333
41567, 1.12, 1.54, 0.45833333333333
41568, 1.12, 1.58, 0.45833333333333
41569, 1.12, 1.62, 0.45833333333333
41570, 1.12, 1.66, 0.45833333333333
41571, 1.16, 1.54, 0.45833333333333
41572, 1.16, 1.58, 0.45833333333333
41573, 1.16, 1.62, 0.45833333333333
41574, 1.16, 1.66, 0.45833333333333
41575, 1.04, 1.52, 0.041666666666667
41576, 1.02, 1.54, 0.041666666666667
41577, 1.04, 1.54, 0.020833333333333
41578, 1.04, 1.56, 0.041666666666667
41579, 1.02, 1.58, 0.041666666666667
41580, 1.04, 1.58, 0.020833333333333
41581, 1.04, 1.6, 0.041666666666667
41582, 1.02, 1.62, 0.041666666666667
41583, 1.04, 1.62, 0.020833333333333
41584, 1.04, 1.64, 0.041666666666667
41585, 1.02, 1.66, 0.041666666666667
41586, 1.04, 1.66, 0.020833333333333
41587, 1.04, 1.68, 0.041666666666667
41588, 1.08, 1.52, 0.041666666666667
41589, 1.06, 1.54, 0.041666666666667
41590, 1.08, 1.54, 0.020833333333333
41591, 1.08, 1.56, 0.041666666666667
41592, 1.06, 1.58, 0.041666666666667
41593, 1.08, 1.58, 0.020833333333333
41594, 1.08, 1.6, 0.041666666666667
41595, 1.06, 1.62, 0.041666666666667
41596, 1.08, 1.62, 0.020833333333333
41597, 1.08, 1.64, 0.041666666666667
41598, 1.06, 1.66, 0.041666666666667
41599, 1.08, 1.66, 0.020833333333333
41600, 1.08, 1.68, 0.041666666666667
41601, 1.12, 1.52, 0.041666666666667
41602, 1.1, 1.54, 0.041666666666667
41603, 1.12, 1.54, 0.020833333333333
41604, 1.12, 1.56, 0.041666666666667
41605, 1.1, 1.58, 0.041666666666667
41606, 1.12, 1.58, 0.020833333333333
41607, 1.12, 1.6, 0.041666666666667
41608, 1.1, 1.62, 0.041666666666667
41609, 1.12, 1.62, 0.020833333333333
41610, 1.12, 1.64, 0.041666666666667
41611, 1.1, 1.66, 0.041666666666667
41612, 1.12, 1.66, 0.020833333333333
41613, 1.12, 1.68, 0.041666666666667
41614, 1.16, 1.52, 0.041666666666667
41615, 1.14, 1.54, 0.041666666666667
41616, 1.16, 1.54, 0.020833333333333
41617, 1.16, 1.56, 0.041666666666667
41618, 1.14, 1.58, 0.041666666666667
41619, 1.16, 1.58, 0.020833333333333
41620, 1.16, 1.6, 0.041666666666667
41621, 1.14, 1.62, 0.041666666666667
41622, 1.16, 1.62, 0.020833333333333
41623, 1.16, 1.64, 0.041666666666667
41624, 1.14, 1.66, 0.041666666666667
41625, 1.16, 1.66, 0.020833333333333
41626, 1.16, 1.68, 0.041666666666667
41627, 1.18, 1.54, 0.041666666666667
41628, 1.18, 1.58, 0.041666666666667
41629, 1.18, 1.62, 0.041666666666667
41630, 1.18, 1.66, 0.041666666666667
41631, 1.04, 1.52, 0.083333333333333
41632, 1.02, 1.54, 0.083333333333333
41633, 1.04, 1.54, 0.0625
41634, 1.04, 1.56, 0.083333333333333
41635, 1.02, 1.58, 0.083333333333333
41636, 1.04, 1.58, 0.0625
41637, 1.04, 1.6, 0.083333333333333
41638, 1.02, 1.62, 0.083333333333333
41639, 1.04, 1.62, 0.0625
41640, 1.04, 1.64, 0.083333333333333
41641, 1.02, 1.66, 0.083333333333333
41642, 1.04, 1.66, 0.0625
41643, 1.04, 1.68, 0.083333333333333
41644, 1.08, 1.52, 0.083333333333333
41645, 1.06, 1.54, 0.083333333333333
41646, 1.08, 1.54, 0.0625
41647, 1.08, 1.56, 0.083333333333333
41648, 1.06, 1.58, 0.083333333333333
41649, 1.08, 1.58, 0.0625
41650, 1.08, 1.6, 0.083333333333333
41651, 1.06, 1.62, 0.083333333333333
41652, 1.08, 1.62, 0.0625
41653, 1.08, 1.64, 0.083333333333333
41654, 1.06, 1.66, 0.083333333333333
41655, 1.08, 1.66, 0.0625
41656, 1.08, 1.68, 0.083333333333333
41657, 1.12, 1.52, 0.083333333333333
41658, 1.1, 1.54, 0.083333333333333
41659, 1.12, 1.54, 0.0625
41660, 1.12, 1.56, 0.083333333333333
41661, 1.1, 1.58, 0.083333333333333
41662, 1.12, 1.58, 0.0625
41663, 1.12, 1.6, 0.083333333333333
41664, 1.1, 1.62, 0.083333333333333
41665, 1.12, 1.62, 0.0625
41666, 1.12, 1.64, 0.083333333333333
41667, 1.1, 1.66, 0.083333333333333
41668, 1.12, 1.66, 0.0625
41669, 1.12, 1.68, 0.083333333333333
41670, 1.16, 1.52, 0.083333333333333
41671, 1.14, 1.54, 0.083333333333333
41672, 1.16, 1.54, 0.0625
41673, 1.16, 1.56, 0.083333333333333
41674, 1.14, 1.58, 0.083333333333333
41675, 1.16, 1.58, 0.0625
41676, 1.16, 1.6, 0.083333333333333
41677, 1.14, 1.62, 0.083333333333333
41678, 1.16, 1.62, 0.0625
41679, 1.16, 1.64, 0.083333333333333
41680, 1.14, 1.66, 0.083333333333333
41681, 1.16, 1.66, 0.0625
41682, 1.16, 1.68, 0.083333333333333
41683, 1.18, 1.54, 0.083333333333333
41684, 1.18, 1.58, 0.083333333333333
41685, 1.18, 1.62, 0.083333333333333
41686, 1.18, 1.66, 0.083333333333333
41687, 1.04, 1.52, 0.125
41688, 1.02, 1.54, 0.125
41689, 1.04, 1.54, 0.10416666666667
41690, 1.04, 1.56, 0.125
41691, 1.02, 1.58, 0.125
41692, 1.04, 1.58, 0.10416666666667
41693, 1.04, 1.6, 0.125
41694, 1.02, 1.62, 0.125
41695, 1.04, 1.62, 0.10416666666667
41696, 1.04, 1.64, 0.125
41697, 1.02, 1.66, 0.125
41698, 1.04, 1.66, 0.10416666666667
41699, 1.04, 1.68, 0.125
41700, 1.08, 1.52, 0.125
41701, 1.06, 1.54, 0.125
41702, 1.08, 1.54, 0.10416666666667
41703, 1.08, 1.56, 0.125
41704, 1.06, 1.58, 0.125
41705, 1.08, 1.58, 0.10416666666667
41706, 1.08, 1.6, 0.125
41707, 1.06, 1.62, 0.125
41708, 1.08, 1.62, 0.10416666666667
41709, 1.08, 1.64, 0.125
41710, 1.06, 1.66, 0.125
41711, 1.08, 1.66, 0.10416666666667
41712, 1.08, 1.68, 0.125
41713, 1.12, 1.52, 0.125
41714, 1.1, 1.54, 0.125
41715, 1.12, 1.54, 0.10416666666667
41716, 1.12, 1.56, 0.125
41717, 1.1, 1.58, 0.125
41718, 1.12, 1.58, 0.10416666666667
41719, 1.12, 1.6, 0.125
41720, 1.1, 1.62, 0.125
41721, 1.12, 1.62, 0.10416666666667
41722, 1.12, 1.64, 0.125
41723, 1.1, 1.66, 0.125
41724, 1.12, 1.66, 0.10416666666667
41725, 1.12, 1.68, 0.125
41726, 1.16, 1.52, 0.125
41727, 1.14, 1.54, 0.125
41728, 1.16, 1.54, 0.10416666666667
41729, 1.16, 1.56, 0.125
41730, 1.14, 1.58, 0.125
41731, 1.16, 1.58, 0.10416666666667
41732, 1.16, 1.6, 0.125
41733, 1.14, 1.62, 0.125
41734, 1.16, 1.62, 0.10416666666667
41735, 1.16, 1.64, 0.125
41736, 1.14, 1.66, 0.125
41737, 1.16, 1.66, 0.10416666666667
41738, 1.16, 1.68, 0.125
41739, 1.18, 1.54, 0.125
41740, 1.18, 1.58, 0.125
41741, 1.18, 1.62, 0.125
41742, 1.18, 1.66, 0.125
41743, 1.04, 1.52, 0.16666666666667
41744, 1.02, 1.54, 0.16666666666667
41745, 1.04, 1.54, 0.14583333333333
41746, 1.04, 1.56, 0.16666666666667
41747, 1.02, 1.58, 0.16666666666667
41748, 1.04, 1.58, 0.14583333333333
41749, 1.04, 1.6, 0.16666666666667
41750, 1.02, 1.62, 0.16666666666667
41751, 1.04, 1.62, 0.14583333333333
41752, 1.04, 1.64, 0.16666666666667
41753, 1.02, 1.66, 0.16666666666667
41754, 1.04, 1.66, 0.14583333333333
41755, 1.04, 1.68, 0.16666666666667
41756, 1.08, 1.52, 0.16666666666667
41757, 1.06, 1.54, 0.16666666666667
41758, 1.08, 1.54, 0.14583333333333
41759, 1.08, 1.56, 0.16666666666667
41760, 1.06, 1.58, 0.16666666666667
41761, 1.08, 1.58, 0.14583333333333
41762, 1.08, 1.6, 0.16666666666667
41763, 1.06, 1.62, 0.16666666666667
41764, 1.08, 1.62, 0.14583333333333
41765, 1.08, 1.64, 0.16666666666667
41766, 1.06, 1.66, 0.16666666666667
41767, 1.08, 1.66, 0.14583333333333
41768, 1.08, 1.68, 0.16666666666667
41769, 1.12, 1.52, 0.16666666666667
41770, 1.1, 1.54, 0.16666666666667
41771, 1.12, 1.54, 0.14583333333333
41772, 1.12, 1.56, 0.16666666666667
41773, 1.1, 1.58, 0.16666666666667
41774, 1.12, 1.58, 0.14583333333333
41775, 1.12, 1.6, 0.16666666666667
41776, 1.1, 1.62, 0.16666666666667
41777, 1.12, 1.62, 0.14583333333333
41778, 1.12, 1.64, 0.16666666666667
41779, 1.1, 1.66, 0.16666666666667
41780, 1.12, 1.66, 0.14583333333333
41781, 1.12, 1.68, 0.16666666666667
41782, 1.16, 1.52, 0.16666666666667
41783, 1.14, 1.54, 0.16666666666667
41784, 1.16, 1.54, 0.14583333333333
41785, 1.16, 1.56, 0.16666666666667
41786, 1.14, 1.58, 0.16666666666667
41787, 1.16, 1.58, 0.14583333333333
41788, 1.16, 1.6, 0.16666666666667
41789, 1.14, 1.62, 0.16666666666667
41790, 1.16, 1.62, 0.14583333333333
41791, 1.16, 1.64, 0.16666666666667
41792, 1.14, 1.66, 0.16666666666667
41793, 1.16, 1.66, 0.14583333333333
41794, 1.16, 1.68, 0.16666666666667
41795, 1.18, 1.54, 0.16666666666667
41796, 1.18, 1.58, 0.16666666666667
41797, 1.18, 1.62, 0.16666666666667
41798, 1.18, 1.66, 0.16666666666667
41799, 1.04, 1.52, 0.20833333333333
41800, 1.02, 1.54, 0.20833333333333
41801, 1.04, 1.54, 0.1875
41802, 1.04, 1.56, 0.20833333333333
41803, 1.02, 1.58, 0.20833333333333
41804, 1.04, 1.58, 0.1875
41805, 1.04, 1.6, 0.20833333333333
41806, 1.02, 1.62, 0.20833333333333
41807, 1.04, 1.62, 0.1875
41808, 1.04, 1.64, 0.20833333333333
41809, 1.02, 1.66, 0.20833333333333
41810, 1.04, 1.66, 0.1875
41811, 1.04, 1.68, 0.20833333333333
41812, 1.08, 1.52, 0.20833333333333
41813, 1.06, 1.54, 0.20833333333333
41814, 1.08, 1.54, 0.1875
41815, 1.08, 1.56, 0.20833333333333
41816, 1.06, 1.58, 0.20833333333333
41817, 1.08, 1.58, 0.1875
41818, 1.08, 1.6, 0.20833333333333
41819, 1.06, 1.62, 0.20833333333333
41820, 1.08, 1.62, 0.1875
41821, 1.08, 1.64, 0.20833333333333
41822, 1.06, 1.66, 0.20833333333333
41823, 1.08, 1.66, 0.1875
41824, 1.08, 1.68, 0.20833333333333
41825, 1.12, 1.52, 0.20833333333333
41826, 1.1, 1.54, 0.20833333333333
41827, 1.12, 1.54, 0.1875
41828, 1.12, 1.56, 0.20833333333333
41829, 1.1, 1.58, 0.20833333333333
41830, 1.12, 1.58, 0.1875
41831, 1.12, 1.6, 0.20833333333333
41832, 1.1, 1.62, 0.20833333333333
41833, 1.12, 1.62, 0.1875
41834, 1.12, 1.64, 0.20833333333333
41835, 1.1, 1.66, 0.20833333333333
41836, 1.12, 1.66, 0.1875
41837, 1.12, 1.68, 0.20833333333333
41838, 1.16, 1.52, 0.20833333333333
41839, 1.14, 1.54, 0.20833333333333
41840, 1.16, 1.54, 0.1875
41841, 1.16, 1.56, 0.20833333333333
41842, 1.14, 1.58, 0.20833333333333
41843, 1.16, 1.58, 0.1875
41844, 1.16, 1.6, 0.20833333333333
41845, 1.14, 1.62, 0.20833333333333
41846, 1.16, 1.62, 0.1875
41847, 1.16, 1.64, 0.20833333333333
41848, 1.14, 1.66, 0.20833333333333
41849, 1.16, 1.66, 0.1875
41850, 1.16, 1.68, 0.20833333333333
41851, 1.18, 1.54, 0.20833333333333
41852, 1.18, 1.58, 0.20833333333333
41853, 1.18, 1.62, 0.20833333333333
41854, 1.18, 1.66, 0.20833333333333
41855, 1.04, 1.52, 0.25
41856, 1.02, 1.54, 0.25
41857, 1.04, 1.54, 0.22916666666667
41858, 1.04, 1.56, 0.25
41859, 1.02, 1.58, 0.25
41860, 1.04, 1.58, 0.22916666666667
41861, 1.04, 1.6, 0.25
41862, 1.02, 1.62, 0.25
41863, 1.04, 1.62, 0.22916666666667
41864, 1.04, 1.64, 0.25
41865, 1.02, 1.66, 0.25
41866, 1.04, 1.66, 0.22916666666667
41867, 1.04, 1.68, 0.25
41868, 1.08, 1.52, 0.25
41869, 1.06, 1.54, 0.25
41870, 1.08, 1.54, 0.22916666666667
41871, 1.08, 1.56, 0.25
41872, 1.06, 1.58, 0.25
41873, 1.08, 1.58, 0.22916666666667
41874, 1.08, 1.6, 0.25
41875, 1.06, 1.62, 0.25
41876, 1.08, 1.62, 0.22916666666667
41877, 1.08, 1.64, 0.25
41878, 1.06, 1.66, 0.25
41879, 1.08, 1.66, 0.22916666666667
41880, 1.08, 1.68, 0.25
41881, 1.12, 1.52, 0.25
41882, 1.1, 1.54, 0.25
41883, 1.12, 1.54, 0.22916666666667
41884, 1.12, 1.56, 0.25
41885, 1.1, 1.58, 0.25
41886, 1.12, 1.58, 0.22916666666667
41887, 1.12, 1.6, 0.25
41888, 1.1, 1.62, 0.25
41889, 1.12, 1.62, 0.22916666666667
41890, 1.12, 1.64, 0.25
41891, 1.1, 1.66, 0.25
41892, 1.12, 1.66, 0.22916666666667
41893, 1.12, 1.68, 0.25
41894, 1.16, 1.52, 0.25
41895, 1.14, 1.54, 0.25
41896, 1.16, 1.54, 0.22916666666667
41897, 1.16, 1.56, 0.25
41898, 1.14, 1.58, 0.25
41899, 1.16, 1.58, 0.22916666666667
41900, 1.16, 1.6, 0.25
41901, 1.14, 1.62, 0.25
41902, 1.16, 1.62, 0.22916666666667
41903, 1.16, 1.64, 0.25
41904, 1.14, 1.66, 0.25
41905, 1.16, 1.66, 0.22916666666667
41906, 1.16, 1.68, 0.25
41907, 1.18, 1.54, 0.25
41908, 1.18, 1.58, 0.25
41909, 1.18, 1.62, 0.25
41910, 1.18, 1.66, 0.25
41911, 1.04, 1.52, 0.29166666666667
41912, 1.02, 1.54, 0.29166666666667
41913, 1.04, 1.54, 0.27083333333333
41914, 1.04, 1.56, 0.29166666666667
41915, 1.02, 1.58, 0.29166666666667
41916, 1.04, 1.58, 0.27083333333333
41917, 1.04, 1.6, 0.29166666666667
41918, 1.02, 1.62, 0.29166666666667
41919, 1.04, 1.62, 0.27083333333333
41920, 1.04, 1.64, 0.29166666666667
41921, 1.02, 1.66, 0.29166666666667
41922, 1.04, 1.66, 0.27083333333333
41923, 1.04, 1.68, 0.29166666666667
41924, 1.08, 1.52, 0.29166666666667
41925, 1.06, 1.54, 0.29166666666667
41926, 1.08, 1.54, 0.27083333333333
41927, 1.08, 1.56, 0.29166666666667
41928, 1.06, 1.58, 0.29166666666667
41929, 1.08, 1.58, 0.27083333333333
41930, 1.08, 1.6, 0.29166666666667
41931, 1.06, 1.62, 0.29166666666667
41932, 1.08, 1.62, 0.27083333333333
41933, 1.08, 1.64, 0.29166666666667
41934, 1.06, 1.66, 0.29166666666667
41935, 1.08, 1.66, 0.27083333333333
41936, 1.08, 1.68, 0.29166666666667
41937, 1.12, 1.52, 0.29166666666667
41938, 1.1, 1.54, 0.29166666666667
41939, 1.12, 1.54, 0.27083333333333
41940, 1.12, 1.56, 0.29166666666667
41941, 1.1, 1.58, 0.29166666666667
41942, 1.12, 1.58, 0.27083333333333
41943, 1.12, 1.6, 0.29166666666667
41944, 1.1, 1.62, 0.29166666666667
41945, 1.12, 1.62, 0.27083333333333
41946, 1.12, 1.64, 0.29166666666667
41947, 1.1, 1.66, 0.29166666666667
41948, 1.12, 1.66, 0.27083333333333
41949, 1.12, 1.68, 0.29166666666667
41950, 1.16, 1.52, 0.29166666666667
41951, 1.14, 1.54, 0.29166666666667
41952, 1.16, 1.54, 0.27083333333333
41953, 1.16, 1.56, 0.29166666666667
41954, 1.14, 1.58, 0.29166666666667
41955, 1.16, 1.58, 0.27083333333333
41956, 1.16, 1.6, 0.29166666666667
41957, 1.14, 1.62, 0.29166666666667
41958, 1.16, 1.62, 0.27083333333333
41959, 1.16, 1.64, 0.29166666666667
41960, 1.14, 1.66, 0.29166666666667
41961, 1.16, 1.66, 0.27083333333333
41962, 1.16, 1.68, 0.29166666666667
41963, 1.18, 1.54, 0.29166666666667
41964, 1.18, 1.58, 0.29166666666667
41965, 1.18, 1.62, 0.29166666666667
41966, 1.18, 1.66, 0.29166666666667
41967, 1.04, 1.52, 0.33333333333333
41968, 1.02, 1.54, 0.33333333333333
41969, 1.04, 1.54, 0.3125
41970, 1.04, 1.56, 0.33333333333333
41971, 1.02, 1.58, 0.33333333333333
41972, 1.04, 1.58, 0.3125
41973, 1.04, 1.6, 0.33333333333333
41974, 1.02, 1.62, 0.33333333333333
41975, 1.04, 1.62, 0.3125
41976, 1.04, 1.64, 0.33333333333333
41977, 1.02, 1.66, 0.33333333333333
41978, 1.04, 1.66, 0.3125
41979, 1.04, 1.68, 0.33333333333333
41980, 1.08, 1.52, 0.33333333333333
41981, 1.06, 1.54, 0.33333333333333
41982, 1.08, 1.54, 0.3125
41983, 1.08, 1.56, 0.33333333333333
41984, 1.06, 1.58, 0.33333333333333
41985, 1.08, 1.58, 0.3125
41986, 1.08, 1.6, 0.33333333333333
41987, 1.06, 1.62, 0.33333333333333
41988, 1.08, 1.62, 0.3125
41989, 1.08, 1.64, 0.33333333333333
41990, 1.06, 1.66, 0.33333333333333
41991, 1.08, 1.66, 0.3125
41992, 1.08, 1.68, 0.33333333333333
41993, 1.12, 1.52, 0.33333333333333
41994, 1.1, 1.54, 0.33333333333333
41995, 1.12, 1.54, 0.3125
41996, 1.12, 1.56, 0.33333333333333
41997, 1.1, 1.58, 0.33333333333333
41998, 1.12, 1.58, 0.3125
41999, 1.12, 1.6, 0.33333333333333
42000, 1.1, 1.62, 0.33333333333333
42001, 1.12, 1.62, 0.3125
42002, 1.12, 1.64, 0.33333333333333
42003, 1.1, 1.66, 0.33333333333333
42004, 1.12, 1.66, 0.3125
42005, 1.12, 1.68, 0.33333333333333
42006, 1.16, 1.52, 0.33333333333333
42007, 1.14, 1.54, 0.33333333333333
42008, 1.16, 1.54, 0.3125
42009, 1.16, 1.56, 0.33333333333333
42010, 1.14, 1.58, 0.33333333333333
42011, 1.16, 1.58, 0.3125
42012, 1.16, 1.6, 0.33333333333333
42013, 1.14, 1.62, 0.33333333333333
42014, 1.16, 1.62, 0.3125
42015, 1.16, 1.64, 0.33333333333333
42016, 1.14, 1.66, 0.33333333333333
42017, 1.16, 1.66, 0.3125
42018, 1.16, 1.68, 0.33333333333333
42019, 1.18, 1.54, 0.33333333333333
42020, 1.18, 1.58, 0.33333333333333
42021, 1.18, 1.62, 0.33333333333333
42022, 1.18, 1.66, 0.33333333333333
42023, 1.04, 1.52, 0.375
42024, 1.02, 1.54, 0.375
42025, 1.04, 1.54, 0.35416666666667
42026, 1.04, 1.56, 0.375
42027, 1.02, 1.58, 0.375
42028, 1.04, 1.58, 0.35416666666667
42029, 1.04, 1.6, 0.375
42030, 1.02, 1.62, 0.375
42031, 1.04, 1.62, 0.35416666666667
42032, 1.04, 1.64, 0.375
42033, 1.02, 1.66, 0.375
42034, 1.04, 1.66, 0.35416666666667
42035, 1.04, 1.68, 0.375
42036, 1.08, 1.52, 0.375
42037, 1.06, 1.54, 0.375
42038, 1.08, 1.54, 0.35416666666667
42039, 1.08, 1.56, 0.375
42040, 1.06, 1.58, 0.375
42041, 1.08, 1.58, 0.35416666666667
42042, 1.08, 1.6, 0.375
42043, 1.06, 1.62, 0.375
42044, 1.08, 1.62, 0.35416666666667
42045, 1.08, 1.64, 0.375
42046, 1.06, 1.66, 0.375
42047, 1.08, 1.66, 0.35416666666667
42048, 1.08, 1.68, 0.375
42049, 1.12, 1.52, 0.375
42050, 1.1, 1.54, 0.375
42051, 1.12, 1.54, 0.35416666666667
42052, 1.12, 1.56, 0.375
42053, 1.1, 1.58, 0.375
42054, 1.12, 1.58, 0.35416666666667
42055, 1.12, 1.6, 0.375
42056, 1.1, 1.62, 0.375
42057, 1.12, 1.62, 0.35416666666667
42058, 1.12, 1.64, 0.375
42059, 1.1, 1.66, 0.375
42060, 1.12, 1.66, 0.35416666666667
42061, 1.12, 1.68, 0.375
42062, 1.16, 1.52, 0.375
42063, 1.14, 1.54, 0.375
42064, 1.16, 1.54, 0.35416666666667
42065, 1.16, 1.56, 0.375
42066, 1.14, 1.58, 0.375
42067, 1.16, 1.58, 0.35416666666667
42068, 1.16, 1.6, 0.375
42069, 1.14, 1.62, 0.375
42070, 1.16, 1.62, 0.35416666666667
42071, 1.16, 1.64, 0.375
42072, 1.14, 1.66, 0.375
42073, 1.16, 1.66, 0.35416666666667
42074, 1.16, 1.68, 0.375
42075, 1.18, 1.54, 0.375
42076, 1.18, 1.58, 0.375
42077, 1.18, 1.62, 0.375
42078, 1.18, 1.66, 0.375
42079, 1.04, 1.52, 0.41666666666667
42080, 1.02, 1.54, 0.41666666666667
42081, 1.04, 1.54, 0.39583333333333
42082, 1.04, 1.56, 0.41666666666667
42083, 1.02, 1.58, 0.41666666666667
42084, 1.04, 1.58, 0.39583333333333
42085, 1.04, 1.6, 0.41666666666667
42086, 1.02, 1.62, 0.41666666666667
42087, 1.04, 1.62, 0.39583333333333
42088, 1.04, 1.64, 0.41666666666667
42089, 1.02, 1.66, 0.41666666666667
42090, 1.04, 1.66, 0.39583333333333
42091, 1.04, 1.68, 0.41666666666667
42092, 1.08, 1.52, 0.41666666666667
42093, 1.06, 1.54, 0.41666666666667
42094, 1.08, 1.54, 0.39583333333333
42095, 1.08, 1.56, 0.41666666666667
42096, 1.06, 1.58, 0.41666666666667
42097, 1.08, 1.58, 0.39583333333333
42098, 1.08, 1.6, 0.41666666666667
42099, 1.06, 1.62, 0.41666666666667
42100, 1.08, 1.62, 0.39583333333333
42101, 1.08, 1.64, 0.41666666666667
42102, 1.06, 1.66, 0.41666666666667
42103, 1.08, 1.66, 0.39583333333333
42104, 1.08, 1.68, 0.41666666666667
42105, 1.12, 1.52, 0.41666666666667
42106, 1.1, 1.54, 0.41666666666667
42107, 1.12, 1.54, 0.39583333333333
42108, 1.12, 1.56, 0.41666666666667
42109, 1.1, 1.58, 0.41666666666667
42110, 1.12, 1.58, 0.39583333333333
42111, 1.12, 1.6, 0.41666666666667
42112, 1.1, 1.62, 0.41666666666667
42113, 1.12, 1.62, 0.39583333333333
42114, 1.12, 1.64, 0.41666666666667
42115, 1.1, 1.66, 0.41666666666667
42116, 1.12, 1.66, 0.39583333333333
42117, 1.12, 1.68, 0.41666666666667
42118, 1.16, 1.52, 0.41666666666667
42119, 1.14, 1.54, 0.41666666666667
42120, 1.16, 1.54, 0.39583333333333
42121, 1.16, 1.56, 0.41666666666667
42122, 1.14, 1.58, 0.41666666666667
42123, 1.16, 1.58, 0.39583333333333
42124, 1.16, 1.6, 0.41666666666667
42125, 1.14, 1.62, 0.41666666666667
42126, 1.16, 1.62, 0.39583333333333
42127, 1.16, 1.64, 0.41666666666667
42128, 1.14, 1.66, 0.41666666666667
42129, 1.16, 1.66, 0.39583333333333
42130, 1.16, 1.68, 0.41666666666667
42131, 1.18, 1.54, 0.41666666666667
42132, 1.18, 1.58, 0.41666666666667
42133, 1.18, 1.62, 0.41666666666667
42134, 1.18, 1.66, 0.41666666666667
42135, 1.04, 1.52, 0.45833333333333
42136, 1.02, 1.54, 0.45833333333333
42137, 1.04, 1.54, 0.4375
42138, 1.04, 1.56, 0.45833333333333
42139, 1.02, 1.58, 0.45833333333333
42140, 1.04, 1.58, 0.4375
42141, 1.04, 1.6, 0.45833333333333
42142, 1.02, 1.62, 0.45833333333333
42143, 1.04, 1.62, 0.4375
42144, 1.04, 1.64, 0.45833333333333
42145, 1.02, 1.66, 0.45833333333333
42146, 1.04, 1.66, 0.4375
42147, 1.04, 1.68, 0.45833333333333
42148, 1.08, 1.52, 0.45833333333333
42149, 1.06, 1.54, 0.45833333333333
42150, 1.08, 1.54, 0.4375
42151, 1.08, 1.56, 0.45833333333333
42152, 1.06, 1.58, 0.45833333333333
42153, 1.08, 1.58, 0.4375
42154, 1.08, 1.6, 0.45833333333333
42155, 1.06, 1.62, 0.45833333333333
42156, 1.08, 1.62, 0.4375
42157, 1.08, 1.64, 0.45833333333333
42158, 1.06, 1.66, 0.45833333333333
42159, 1.08, 1.66, 0.4375
42160, 1.08, 1.68, 0.45833333333333
42161, 1.12, 1.52, 0.45833333333333
42162, 1.1, 1.54, 0.45833333333333
42163, 1.12, 1.54, 0.4375
42164, 1.12, 1.56, 0.45833333333333
42165, 1.1, 1.58, 0.45833333333333
42166, 1.12, 1.58, 0.4375
42167, 1.12, 1.6, 0.45833333333333
42168, 1.1, 1.62, 0.45833333333333
42169, 1.12, 1.62, 0.4375
42170, 1.12, 1.64, 0.45833333333333
42171, 1.1, 1.66, 0.45833333333333
42172, 1.12, 1.66, 0.4375
42173, 1.12, 1.68, 0.45833333333333
42174, 1.16, 1.52, 0.45833333333333
42175, 1.14, 1.54, 0.45833333333333
42176, 1.16, 1.54, 0.4375
42177, 1.16, 1.56, 0.45833333333333
42178, 1.14, 1.58, 0.45833333333333
42179, 1.16, 1.58, 0.4375
42180, 1.16, 1.6, 0.45833333333333
42181, 1.14, 1.62, 0.45833333333333
42182, 1.16, 1.62, 0.4375
42183, 1.16, 1.64, 0.45833333333333
42184, 1.14, 1.66, 0.45833333333333
42185, 1.16, 1.66, 0.4375
42186, 1.16, 1.68, 0.45833333333333
42187, 1.18, 1.54, 0.45833333333333
42188, 1.18, 1.58, 0.45833333333333
42189, 1.18, 1.62, 0.45833333333333
42190, 1.18, 1.66, 0.45833333333333
42191, 1.04, 1.54, 0.47916666666667
42192, 1.04, 1.58, 0.47916666666667
42193, 1.04, 1.62, 0.47916666666667
42194, 1.04, 1.66, 0.47916666666667
42195, 1.08, 1.54, 0.47916666666667
42196, 1.08, 1.58, 0.47916666666667
42197, 1.08, 1.62, 0.47916666666667
42198, 1.08, 1.66, 0.47916666666667
42199, 1.12, 1.54, 0.47916666666667
42200, 1.12, 1.58, 0.47916666666667
42201, 1.12, 1.62, 0.47916666666667
42202, 1.12, 1.66, 0.47916666666667
42203, 1.16, 1.54, 0.47916666666667
42204, 1.16, 1.58, 0.47916666666667
42205, 1.16, 1.62, 0.47916666666667
42206, 1.16, 1.66, 0.47916666666667
42207, 1.2416666666667, 1.54, 0.041666666666667
