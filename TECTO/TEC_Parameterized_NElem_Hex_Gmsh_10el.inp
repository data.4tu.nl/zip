47087, 0.45833333333333, -0.16, 0.041666666666667
47088, 0.45833333333333, -0.04, 0.083333333333333
47089, 0.45833333333333, -0.08, 0.083333333333333
47090, 0.45833333333333, -0.12, 0.083333333333333
47091, 0.45833333333333, -0.16, 0.083333333333333
47092, 0.45833333333333, -0.04, 0.125
47093, 0.45833333333333, -0.08, 0.125
47094, 0.45833333333333, -0.12, 0.125
47095, 0.45833333333333, -0.16, 0.125
47096, 0.45833333333333, -0.04, 0.16666666666667
47097, 0.45833333333333, -0.08, 0.16666666666667
47098, 0.45833333333333, -0.12, 0.16666666666667
47099, 0.45833333333333, -0.16, 0.16666666666667
47100, 0.45833333333333, -0.04, 0.20833333333333
47101, 0.45833333333333, -0.08, 0.20833333333333
47102, 0.45833333333333, -0.12, 0.20833333333333
47103, 0.45833333333333, -0.16, 0.20833333333333
47104, 0.45833333333333, -0.04, 0.25
47105, 0.45833333333333, -0.08, 0.25
47106, 0.45833333333333, -0.12, 0.25
47107, 0.45833333333333, -0.16, 0.25
47108, 0.45833333333333, -0.04, 0.29166666666667
47109, 0.45833333333333, -0.08, 0.29166666666667
47110, 0.45833333333333, -0.12, 0.29166666666667
47111, 0.45833333333333, -0.16, 0.29166666666667
47112, 0.45833333333333, -0.04, 0.33333333333333
47113, 0.45833333333333, -0.08, 0.33333333333333
47114, 0.45833333333333, -0.12, 0.33333333333333
47115, 0.45833333333333, -0.16, 0.33333333333333
47116, 0.45833333333333, -0.04, 0.375
47117, 0.45833333333333, -0.08, 0.375
47118, 0.45833333333333, -0.12, 0.375
47119, 0.45833333333333, -0.16, 0.375
47120, 0.45833333333333, -0.04, 0.41666666666667
47121, 0.45833333333333, -0.08, 0.41666666666667
47122, 0.45833333333333, -0.12, 0.41666666666667
47123, 0.45833333333333, -0.16, 0.41666666666667
47124, 0.45833333333333, -0.04, 0.45833333333333
47125, 0.45833333333333, -0.08, 0.45833333333333
47126, 0.45833333333333, -0.12, 0.45833333333333
47127, 0.45833333333333, -0.16, 0.45833333333333
47128, 0.5, -0.04, 0.041666666666667
47129, 0.5, -0.08, 0.041666666666667
47130, 0.5, -0.12, 0.041666666666667
47131, 0.5, -0.16, 0.041666666666667
47132, 0.5, -0.04, 0.083333333333333
47133, 0.5, -0.08, 0.083333333333333
47134, 0.5, -0.12, 0.083333333333333
47135, 0.5, -0.16, 0.083333333333333
47136, 0.5, -0.04, 0.125
47137, 0.5, -0.08, 0.125
47138, 0.5, -0.12, 0.125
47139, 0.5, -0.16, 0.125
47140, 0.5, -0.04, 0.16666666666667
47141, 0.5, -0.08, 0.16666666666667
47142, 0.5, -0.12, 0.16666666666667
47143, 0.5, -0.16, 0.16666666666667
47144, 0.5, -0.04, 0.20833333333333
47145, 0.5, -0.08, 0.20833333333333
47146, 0.5, -0.12, 0.20833333333333
47147, 0.5, -0.16, 0.20833333333333
47148, 0.5, -0.04, 0.25
47149, 0.5, -0.08, 0.25
47150, 0.5, -0.12, 0.25
47151, 0.5, -0.16, 0.25
47152, 0.5, -0.04, 0.29166666666667
47153, 0.5, -0.08, 0.29166666666667
47154, 0.5, -0.12, 0.29166666666667
47155, 0.5, -0.16, 0.29166666666667
47156, 0.5, -0.04, 0.33333333333333
47157, 0.5, -0.08, 0.33333333333333
47158, 0.5, -0.12, 0.33333333333333
47159, 0.5, -0.16, 0.33333333333333
47160, 0.5, -0.04, 0.375
47161, 0.5, -0.08, 0.375
47162, 0.5, -0.12, 0.375
47163, 0.5, -0.16, 0.375
47164, 0.5, -0.04, 0.41666666666667
47165, 0.5, -0.08, 0.41666666666667
47166, 0.5, -0.12, 0.41666666666667
47167, 0.5, -0.16, 0.41666666666667
47168, 0.5, -0.04, 0.45833333333333
47169, 0.5, -0.08, 0.45833333333333
47170, 0.5, -0.12, 0.45833333333333
47171, 0.5, -0.16, 0.45833333333333
47172, 0.54166666666667, -0.04, 0.041666666666667
47173, 0.54166666666667, -0.08, 0.041666666666667
47174, 0.54166666666667, -0.12, 0.041666666666667
47175, 0.54166666666667, -0.16, 0.041666666666667
47176, 0.54166666666667, -0.04, 0.083333333333333
47177, 0.54166666666667, -0.08, 0.083333333333333
47178, 0.54166666666667, -0.12, 0.083333333333333
47179, 0.54166666666667, -0.16, 0.083333333333333
47180, 0.54166666666667, -0.04, 0.125
47181, 0.54166666666667, -0.08, 0.125
47182, 0.54166666666667, -0.12, 0.125
47183, 0.54166666666667, -0.16, 0.125
47184, 0.54166666666667, -0.04, 0.16666666666667
47185, 0.54166666666667, -0.08, 0.16666666666667
47186, 0.54166666666667, -0.12, 0.16666666666667
47187, 0.54166666666667, -0.16, 0.16666666666667
47188, 0.54166666666667, -0.04, 0.20833333333333
47189, 0.54166666666667, -0.08, 0.20833333333333
47190, 0.54166666666667, -0.12, 0.20833333333333
47191, 0.54166666666667, -0.16, 0.20833333333333
47192, 0.54166666666667, -0.04, 0.25
47193, 0.54166666666667, -0.08, 0.25
47194, 0.54166666666667, -0.12, 0.25
47195, 0.54166666666667, -0.16, 0.25
47196, 0.54166666666667, -0.04, 0.29166666666667
47197, 0.54166666666667, -0.08, 0.29166666666667
47198, 0.54166666666667, -0.12, 0.29166666666667
47199, 0.54166666666667, -0.16, 0.29166666666667
47200, 0.54166666666667, -0.04, 0.33333333333333
47201, 0.54166666666667, -0.08, 0.33333333333333
47202, 0.54166666666667, -0.12, 0.33333333333333
47203, 0.54166666666667, -0.16, 0.33333333333333
47204, 0.54166666666667, -0.04, 0.375
47205, 0.54166666666667, -0.08, 0.375
47206, 0.54166666666667, -0.12, 0.375
47207, 0.54166666666667, -0.16, 0.375
47208, 0.54166666666667, -0.04, 0.41666666666667
47209, 0.54166666666667, -0.08, 0.41666666666667
47210, 0.54166666666667, -0.12, 0.41666666666667
47211, 0.54166666666667, -0.16, 0.41666666666667
47212, 0.54166666666667, -0.04, 0.45833333333333
47213, 0.54166666666667, -0.08, 0.45833333333333
47214, 0.54166666666667, -0.12, 0.45833333333333
47215, 0.54166666666667, -0.16, 0.45833333333333
47216, 0.58333333333333, -0.04, 0.041666666666667
47217, 0.58333333333333, -0.08, 0.041666666666667
47218, 0.58333333333333, -0.12, 0.041666666666667
47219, 0.58333333333333, -0.16, 0.041666666666667
47220, 0.58333333333333, -0.04, 0.083333333333333
47221, 0.58333333333333, -0.08, 0.083333333333333
47222, 0.58333333333333, -0.12, 0.083333333333333
47223, 0.58333333333333, -0.16, 0.083333333333333
47224, 0.58333333333333, -0.04, 0.125
47225, 0.58333333333333, -0.08, 0.125
47226, 0.58333333333333, -0.12, 0.125
47227, 0.58333333333333, -0.16, 0.125
47228, 0.58333333333333, -0.04, 0.16666666666667
47229, 0.58333333333333, -0.08, 0.16666666666667
47230, 0.58333333333333, -0.12, 0.16666666666667
47231, 0.58333333333333, -0.16, 0.16666666666667
47232, 0.58333333333333, -0.04, 0.20833333333333
47233, 0.58333333333333, -0.08, 0.20833333333333
47234, 0.58333333333333, -0.12, 0.20833333333333
47235, 0.58333333333333, -0.16, 0.20833333333333
47236, 0.58333333333333, -0.04, 0.25
47237, 0.58333333333333, -0.08, 0.25
47238, 0.58333333333333, -0.12, 0.25
47239, 0.58333333333333, -0.16, 0.25
47240, 0.58333333333333, -0.04, 0.29166666666667
47241, 0.58333333333333, -0.08, 0.29166666666667
47242, 0.58333333333333, -0.12, 0.29166666666667
47243, 0.58333333333333, -0.16, 0.29166666666667
47244, 0.58333333333333, -0.04, 0.33333333333333
47245, 0.58333333333333, -0.08, 0.33333333333333
47246, 0.58333333333333, -0.12, 0.33333333333333
47247, 0.58333333333333, -0.16, 0.33333333333333
47248, 0.58333333333333, -0.04, 0.375
47249, 0.58333333333333, -0.08, 0.375
47250, 0.58333333333333, -0.12, 0.375
47251, 0.58333333333333, -0.16, 0.375
47252, 0.58333333333333, -0.04, 0.41666666666667
47253, 0.58333333333333, -0.08, 0.41666666666667
47254, 0.58333333333333, -0.12, 0.41666666666667
47255, 0.58333333333333, -0.16, 0.41666666666667
47256, 0.58333333333333, -0.04, 0.45833333333333
47257, 0.58333333333333, -0.08, 0.45833333333333
47258, 0.58333333333333, -0.12, 0.45833333333333
47259, 0.58333333333333, -0.16, 0.45833333333333
47260, 0.625, -0.04, 0.041666666666667
47261, 0.625, -0.08, 0.041666666666667
47262, 0.625, -0.12, 0.041666666666667
47263, 0.625, -0.16, 0.041666666666667
47264, 0.625, -0.04, 0.083333333333333
47265, 0.625, -0.08, 0.083333333333333
47266, 0.625, -0.12, 0.083333333333333
47267, 0.625, -0.16, 0.083333333333333
47268, 0.625, -0.04, 0.125
47269, 0.625, -0.08, 0.125
47270, 0.625, -0.12, 0.125
47271, 0.625, -0.16, 0.125
47272, 0.625, -0.04, 0.16666666666667
47273, 0.625, -0.08, 0.16666666666667
47274, 0.625, -0.12, 0.16666666666667
47275, 0.625, -0.16, 0.16666666666667
47276, 0.625, -0.04, 0.20833333333333
47277, 0.625, -0.08, 0.20833333333333
47278, 0.625, -0.12, 0.20833333333333
47279, 0.625, -0.16, 0.20833333333333
47280, 0.625, -0.04, 0.25
47281, 0.625, -0.08, 0.25
47282, 0.625, -0.12, 0.25
47283, 0.625, -0.16, 0.25
47284, 0.625, -0.04, 0.29166666666667
47285, 0.625, -0.08, 0.29166666666667
47286, 0.625, -0.12, 0.29166666666667
47287, 0.625, -0.16, 0.29166666666667
47288, 0.625, -0.04, 0.33333333333333
47289, 0.625, -0.08, 0.33333333333333
47290, 0.625, -0.12, 0.33333333333333
47291, 0.625, -0.16, 0.33333333333333
47292, 0.625, -0.04, 0.375
47293, 0.625, -0.08, 0.375
47294, 0.625, -0.12, 0.375
47295, 0.625, -0.16, 0.375
47296, 0.625, -0.04, 0.41666666666667
47297, 0.625, -0.08, 0.41666666666667
47298, 0.625, -0.12, 0.41666666666667
47299, 0.625, -0.16, 0.41666666666667
47300, 0.625, -0.04, 0.45833333333333
47301, 0.625, -0.08, 0.45833333333333
47302, 0.625, -0.12, 0.45833333333333
47303, 0.625, -0.16, 0.45833333333333
47304, 0.66666666666667, -0.04, 0.041666666666667
47305, 0.66666666666667, -0.08, 0.041666666666667
47306, 0.66666666666667, -0.12, 0.041666666666667
47307, 0.66666666666667, -0.16, 0.041666666666667
47308, 0.66666666666667, -0.04, 0.083333333333333
47309, 0.66666666666667, -0.08, 0.083333333333333
47310, 0.66666666666667, -0.12, 0.083333333333333
47311, 0.66666666666667, -0.16, 0.083333333333333
47312, 0.66666666666667, -0.04, 0.125
47313, 0.66666666666667, -0.08, 0.125
47314, 0.66666666666667, -0.12, 0.125
47315, 0.66666666666667, -0.16, 0.125
47316, 0.66666666666667, -0.04, 0.16666666666667
47317, 0.66666666666667, -0.08, 0.16666666666667
47318, 0.66666666666667, -0.12, 0.16666666666667
47319, 0.66666666666667, -0.16, 0.16666666666667
47320, 0.66666666666667, -0.04, 0.20833333333333
47321, 0.66666666666667, -0.08, 0.20833333333333
47322, 0.66666666666667, -0.12, 0.20833333333333
47323, 0.66666666666667, -0.16, 0.20833333333333
47324, 0.66666666666667, -0.04, 0.25
47325, 0.66666666666667, -0.08, 0.25
47326, 0.66666666666667, -0.12, 0.25
47327, 0.66666666666667, -0.16, 0.25
47328, 0.66666666666667, -0.04, 0.29166666666667
47329, 0.66666666666667, -0.08, 0.29166666666667
47330, 0.66666666666667, -0.12, 0.29166666666667
47331, 0.66666666666667, -0.16, 0.29166666666667
47332, 0.66666666666667, -0.04, 0.33333333333333
47333, 0.66666666666667, -0.08, 0.33333333333333
47334, 0.66666666666667, -0.12, 0.33333333333333
47335, 0.66666666666667, -0.16, 0.33333333333333
47336, 0.66666666666667, -0.04, 0.375
47337, 0.66666666666667, -0.08, 0.375
47338, 0.66666666666667, -0.12, 0.375
47339, 0.66666666666667, -0.16, 0.375
47340, 0.66666666666667, -0.04, 0.41666666666667
47341, 0.66666666666667, -0.08, 0.41666666666667
47342, 0.66666666666667, -0.12, 0.41666666666667
47343, 0.66666666666667, -0.16, 0.41666666666667
47344, 0.66666666666667, -0.04, 0.45833333333333
47345, 0.66666666666667, -0.08, 0.45833333333333
47346, 0.66666666666667, -0.12, 0.45833333333333
47347, 0.66666666666667, -0.16, 0.45833333333333
47348, 0.70833333333333, -0.04, 0.041666666666667
47349, 0.70833333333333, -0.08, 0.041666666666667
47350, 0.70833333333333, -0.12, 0.041666666666667
47351, 0.70833333333333, -0.16, 0.041666666666667
47352, 0.70833333333333, -0.04, 0.083333333333333
47353, 0.70833333333333, -0.08, 0.083333333333333
47354, 0.70833333333333, -0.12, 0.083333333333333
47355, 0.70833333333333, -0.16, 0.083333333333333
47356, 0.70833333333333, -0.04, 0.125
47357, 0.70833333333333, -0.08, 0.125
47358, 0.70833333333333, -0.12, 0.125
47359, 0.70833333333333, -0.16, 0.125
47360, 0.70833333333333, -0.04, 0.16666666666667
47361, 0.70833333333333, -0.08, 0.16666666666667
47362, 0.70833333333333, -0.12, 0.16666666666667
47363, 0.70833333333333, -0.16, 0.16666666666667
47364, 0.70833333333333, -0.04, 0.20833333333333
47365, 0.70833333333333, -0.08, 0.20833333333333
47366, 0.70833333333333, -0.12, 0.20833333333333
47367, 0.70833333333333, -0.16, 0.20833333333333
47368, 0.70833333333333, -0.04, 0.25
47369, 0.70833333333333, -0.08, 0.25
47370, 0.70833333333333, -0.12, 0.25
47371, 0.70833333333333, -0.16, 0.25
47372, 0.70833333333333, -0.04, 0.29166666666667
47373, 0.70833333333333, -0.08, 0.29166666666667
47374, 0.70833333333333, -0.12, 0.29166666666667
47375, 0.70833333333333, -0.16, 0.29166666666667
47376, 0.70833333333333, -0.04, 0.33333333333333
47377, 0.70833333333333, -0.08, 0.33333333333333
47378, 0.70833333333333, -0.12, 0.33333333333333
47379, 0.70833333333333, -0.16, 0.33333333333333
47380, 0.70833333333333, -0.04, 0.375
47381, 0.70833333333333, -0.08, 0.375
47382, 0.70833333333333, -0.12, 0.375
47383, 0.70833333333333, -0.16, 0.375
47384, 0.70833333333333, -0.04, 0.41666666666667
47385, 0.70833333333333, -0.08, 0.41666666666667
47386, 0.70833333333333, -0.12, 0.41666666666667
47387, 0.70833333333333, -0.16, 0.41666666666667
47388, 0.70833333333333, -0.04, 0.45833333333333
47389, 0.70833333333333, -0.08, 0.45833333333333
47390, 0.70833333333333, -0.12, 0.45833333333333
47391, 0.70833333333333, -0.16, 0.45833333333333
47392, 0.75, -0.04, 0.041666666666667
47393, 0.75, -0.08, 0.041666666666667
47394, 0.75, -0.12, 0.041666666666667
47395, 0.75, -0.16, 0.041666666666667
47396, 0.75, -0.04, 0.083333333333333
47397, 0.75, -0.08, 0.083333333333333
47398, 0.75, -0.12, 0.083333333333333
47399, 0.75, -0.16, 0.083333333333333
47400, 0.75, -0.04, 0.125
47401, 0.75, -0.08, 0.125
47402, 0.75, -0.12, 0.125
47403, 0.75, -0.16, 0.125
47404, 0.75, -0.04, 0.16666666666667
47405, 0.75, -0.08, 0.16666666666667
47406, 0.75, -0.12, 0.16666666666667
47407, 0.75, -0.16, 0.16666666666667
47408, 0.75, -0.04, 0.20833333333333
47409, 0.75, -0.08, 0.20833333333333
47410, 0.75, -0.12, 0.20833333333333
47411, 0.75, -0.16, 0.20833333333333
47412, 0.75, -0.04, 0.25
47413, 0.75, -0.08, 0.25
47414, 0.75, -0.12, 0.25
47415, 0.75, -0.16, 0.25
47416, 0.75, -0.04, 0.29166666666667
47417, 0.75, -0.08, 0.29166666666667
47418, 0.75, -0.12, 0.29166666666667
47419, 0.75, -0.16, 0.29166666666667
47420, 0.75, -0.04, 0.33333333333333
47421, 0.75, -0.08, 0.33333333333333
47422, 0.75, -0.12, 0.33333333333333
47423, 0.75, -0.16, 0.33333333333333
47424, 0.75, -0.04, 0.375
47425, 0.75, -0.08, 0.375
47426, 0.75, -0.12, 0.375
47427, 0.75, -0.16, 0.375
47428, 0.75, -0.04, 0.41666666666667
47429, 0.75, -0.08, 0.41666666666667
47430, 0.75, -0.12, 0.41666666666667
47431, 0.75, -0.16, 0.41666666666667
47432, 0.75, -0.04, 0.45833333333333
47433, 0.75, -0.08, 0.45833333333333
47434, 0.75, -0.12, 0.45833333333333
47435, 0.75, -0.16, 0.45833333333333
47436, 0.79166666666667, -0.04, 0.041666666666667
47437, 0.79166666666667, -0.08, 0.041666666666667
47438, 0.79166666666667, -0.12, 0.041666666666667
47439, 0.79166666666667, -0.16, 0.041666666666667
47440, 0.79166666666667, -0.04, 0.083333333333333
47441, 0.79166666666667, -0.08, 0.083333333333333
47442, 0.79166666666667, -0.12, 0.083333333333333
47443, 0.79166666666667, -0.16, 0.083333333333333
47444, 0.79166666666667, -0.04, 0.125
47445, 0.79166666666667, -0.08, 0.125
47446, 0.79166666666667, -0.12, 0.125
47447, 0.79166666666667, -0.16, 0.125
47448, 0.79166666666667, -0.04, 0.16666666666667
47449, 0.79166666666667, -0.08, 0.16666666666667
47450, 0.79166666666667, -0.12, 0.16666666666667
47451, 0.79166666666667, -0.16, 0.16666666666667
47452, 0.79166666666667, -0.04, 0.20833333333333
47453, 0.79166666666667, -0.08, 0.20833333333333
47454, 0.79166666666667, -0.12, 0.20833333333333
47455, 0.79166666666667, -0.16, 0.20833333333333
47456, 0.79166666666667, -0.04, 0.25
47457, 0.79166666666667, -0.08, 0.25
47458, 0.79166666666667, -0.12, 0.25
47459, 0.79166666666667, -0.16, 0.25
47460, 0.79166666666667, -0.04, 0.29166666666667
47461, 0.79166666666667, -0.08, 0.29166666666667
47462, 0.79166666666667, -0.12, 0.29166666666667
47463, 0.79166666666667, -0.16, 0.29166666666667
47464, 0.79166666666667, -0.04, 0.33333333333333
47465, 0.79166666666667, -0.08, 0.33333333333333
47466, 0.79166666666667, -0.12, 0.33333333333333
47467, 0.79166666666667, -0.16, 0.33333333333333
47468, 0.79166666666667, -0.04, 0.375
47469, 0.79166666666667, -0.08, 0.375
47470, 0.79166666666667, -0.12, 0.375
47471, 0.79166666666667, -0.16, 0.375
47472, 0.79166666666667, -0.04, 0.41666666666667
47473, 0.79166666666667, -0.08, 0.41666666666667
47474, 0.79166666666667, -0.12, 0.41666666666667
47475, 0.79166666666667, -0.16, 0.41666666666667
47476, 0.79166666666667, -0.04, 0.45833333333333
47477, 0.79166666666667, -0.08, 0.45833333333333
47478, 0.79166666666667, -0.12, 0.45833333333333
47479, 0.79166666666667, -0.16, 0.45833333333333
47480, 0.83333333333333, -0.04, 0.041666666666667
47481, 0.83333333333333, -0.08, 0.041666666666667
47482, 0.83333333333333, -0.12, 0.041666666666667
47483, 0.83333333333333, -0.16, 0.041666666666667
47484, 0.83333333333333, -0.04, 0.083333333333333
47485, 0.83333333333333, -0.08, 0.083333333333333
47486, 0.83333333333333, -0.12, 0.083333333333333
47487, 0.83333333333333, -0.16, 0.083333333333333
47488, 0.83333333333333, -0.04, 0.125
47489, 0.83333333333333, -0.08, 0.125
47490, 0.83333333333333, -0.12, 0.125
47491, 0.83333333333333, -0.16, 0.125
47492, 0.83333333333333, -0.04, 0.16666666666667
47493, 0.83333333333333, -0.08, 0.16666666666667
47494, 0.83333333333333, -0.12, 0.16666666666667
47495, 0.83333333333333, -0.16, 0.16666666666667
47496, 0.83333333333333, -0.04, 0.20833333333333
47497, 0.83333333333333, -0.08, 0.20833333333333
47498, 0.83333333333333, -0.12, 0.20833333333333
47499, 0.83333333333333, -0.16, 0.20833333333333
47500, 0.83333333333333, -0.04, 0.25
47501, 0.83333333333333, -0.08, 0.25
47502, 0.83333333333333, -0.12, 0.25
47503, 0.83333333333333, -0.16, 0.25
47504, 0.83333333333333, -0.04, 0.29166666666667
47505, 0.83333333333333, -0.08, 0.29166666666667
47506, 0.83333333333333, -0.12, 0.29166666666667
47507, 0.83333333333333, -0.16, 0.29166666666667
47508, 0.83333333333333, -0.04, 0.33333333333333
47509, 0.83333333333333, -0.08, 0.33333333333333
47510, 0.83333333333333, -0.12, 0.33333333333333
47511, 0.83333333333333, -0.16, 0.33333333333333
47512, 0.83333333333333, -0.04, 0.375
47513, 0.83333333333333, -0.08, 0.375
47514, 0.83333333333333, -0.12, 0.375
47515, 0.83333333333333, -0.16, 0.375
47516, 0.83333333333333, -0.04, 0.41666666666667
47517, 0.83333333333333, -0.08, 0.41666666666667
47518, 0.83333333333333, -0.12, 0.41666666666667
47519, 0.83333333333333, -0.16, 0.41666666666667
47520, 0.83333333333333, -0.04, 0.45833333333333
47521, 0.83333333333333, -0.08, 0.45833333333333
47522, 0.83333333333333, -0.12, 0.45833333333333
47523, 0.83333333333333, -0.16, 0.45833333333333
47524, 0.875, -0.04, 0.041666666666667
47525, 0.875, -0.08, 0.041666666666667
47526, 0.875, -0.12, 0.041666666666667
47527, 0.875, -0.16, 0.041666666666667
47528, 0.875, -0.04, 0.083333333333333
47529, 0.875, -0.08, 0.083333333333333
47530, 0.875, -0.12, 0.083333333333333
47531, 0.875, -0.16, 0.083333333333333
47532, 0.875, -0.04, 0.125
47533, 0.875, -0.08, 0.125
47534, 0.875, -0.12, 0.125
47535, 0.875, -0.16, 0.125
47536, 0.875, -0.04, 0.16666666666667
47537, 0.875, -0.08, 0.16666666666667
47538, 0.875, -0.12, 0.16666666666667
47539, 0.875, -0.16, 0.16666666666667
47540, 0.875, -0.04, 0.20833333333333
47541, 0.875, -0.08, 0.20833333333333
47542, 0.875, -0.12, 0.20833333333333
47543, 0.875, -0.16, 0.20833333333333
47544, 0.875, -0.04, 0.25
47545, 0.875, -0.08, 0.25
47546, 0.875, -0.12, 0.25
47547, 0.875, -0.16, 0.25
47548, 0.875, -0.04, 0.29166666666667
47549, 0.875, -0.08, 0.29166666666667
47550, 0.875, -0.12, 0.29166666666667
47551, 0.875, -0.16, 0.29166666666667
47552, 0.875, -0.04, 0.33333333333333
47553, 0.875, -0.08, 0.33333333333333
47554, 0.875, -0.12, 0.33333333333333
47555, 0.875, -0.16, 0.33333333333333
47556, 0.875, -0.04, 0.375
47557, 0.875, -0.08, 0.375
47558, 0.875, -0.12, 0.375
47559, 0.875, -0.16, 0.375
47560, 0.875, -0.04, 0.41666666666667
47561, 0.875, -0.08, 0.41666666666667
47562, 0.875, -0.12, 0.41666666666667
47563, 0.875, -0.16, 0.41666666666667
47564, 0.875, -0.04, 0.45833333333333
47565, 0.875, -0.08, 0.45833333333333
47566, 0.875, -0.12, 0.45833333333333
47567, 0.875, -0.16, 0.45833333333333
47568, 0.91666666666667, -0.04, 0.041666666666667
47569, 0.91666666666667, -0.08, 0.041666666666667
47570, 0.91666666666667, -0.12, 0.041666666666667
47571, 0.91666666666667, -0.16, 0.041666666666667
47572, 0.91666666666667, -0.04, 0.083333333333333
47573, 0.91666666666667, -0.08, 0.083333333333333
47574, 0.91666666666667, -0.12, 0.083333333333333
47575, 0.91666666666667, -0.16, 0.083333333333333
47576, 0.91666666666667, -0.04, 0.125
47577, 0.91666666666667, -0.08, 0.125
47578, 0.91666666666667, -0.12, 0.125
47579, 0.91666666666667, -0.16, 0.125
47580, 0.91666666666667, -0.04, 0.16666666666667
47581, 0.91666666666667, -0.08, 0.16666666666667
47582, 0.91666666666667, -0.12, 0.16666666666667
47583, 0.91666666666667, -0.16, 0.16666666666667
47584, 0.91666666666667, -0.04, 0.20833333333333
47585, 0.91666666666667, -0.08, 0.20833333333333
47586, 0.91666666666667, -0.12, 0.20833333333333
47587, 0.91666666666667, -0.16, 0.20833333333333
47588, 0.91666666666667, -0.04, 0.25
47589, 0.91666666666667, -0.08, 0.25
47590, 0.91666666666667, -0.12, 0.25
47591, 0.91666666666667, -0.16, 0.25
47592, 0.91666666666667, -0.04, 0.29166666666667
47593, 0.91666666666667, -0.08, 0.29166666666667
47594, 0.91666666666667, -0.12, 0.29166666666667
47595, 0.91666666666667, -0.16, 0.29166666666667
47596, 0.91666666666667, -0.04, 0.33333333333333
47597, 0.91666666666667, -0.08, 0.33333333333333
47598, 0.91666666666667, -0.12, 0.33333333333333
47599, 0.91666666666667, -0.16, 0.33333333333333
47600, 0.91666666666667, -0.04, 0.375
47601, 0.91666666666667, -0.08, 0.375
47602, 0.91666666666667, -0.12, 0.375
47603, 0.91666666666667, -0.16, 0.375
47604, 0.91666666666667, -0.04, 0.41666666666667
47605, 0.91666666666667, -0.08, 0.41666666666667
47606, 0.91666666666667, -0.12, 0.41666666666667
47607, 0.91666666666667, -0.16, 0.41666666666667
47608, 0.91666666666667, -0.04, 0.45833333333333
47609, 0.91666666666667, -0.08, 0.45833333333333
47610, 0.91666666666667, -0.12, 0.45833333333333
47611, 0.91666666666667, -0.16, 0.45833333333333
47612, 0.95833333333333, -0.04, 0.041666666666667
47613, 0.95833333333333, -0.08, 0.041666666666667
47614, 0.95833333333333, -0.12, 0.041666666666667
47615, 0.95833333333333, -0.16, 0.041666666666667
47616, 0.95833333333333, -0.04, 0.083333333333333
47617, 0.95833333333333, -0.08, 0.083333333333333
47618, 0.95833333333333, -0.12, 0.083333333333333
47619, 0.95833333333333, -0.16, 0.083333333333333
47620, 0.95833333333333, -0.04, 0.125
47621, 0.95833333333333, -0.08, 0.125
47622, 0.95833333333333, -0.12, 0.125
47623, 0.95833333333333, -0.16, 0.125
47624, 0.95833333333333, -0.04, 0.16666666666667
47625, 0.95833333333333, -0.08, 0.16666666666667
47626, 0.95833333333333, -0.12, 0.16666666666667
47627, 0.95833333333333, -0.16, 0.16666666666667
47628, 0.95833333333333, -0.04, 0.20833333333333
47629, 0.95833333333333, -0.08, 0.20833333333333
47630, 0.95833333333333, -0.12, 0.20833333333333
47631, 0.95833333333333, -0.16, 0.20833333333333
47632, 0.95833333333333, -0.04, 0.25
47633, 0.95833333333333, -0.08, 0.25
47634, 0.95833333333333, -0.12, 0.25
47635, 0.95833333333333, -0.16, 0.25
47636, 0.95833333333333, -0.04, 0.29166666666667
47637, 0.95833333333333, -0.08, 0.29166666666667
47638, 0.95833333333333, -0.12, 0.29166666666667
47639, 0.95833333333333, -0.16, 0.29166666666667
47640, 0.95833333333333, -0.04, 0.33333333333333
47641, 0.95833333333333, -0.08, 0.33333333333333
47642, 0.95833333333333, -0.12, 0.33333333333333
47643, 0.95833333333333, -0.16, 0.33333333333333
47644, 0.95833333333333, -0.04, 0.375
47645, 0.95833333333333, -0.08, 0.375
47646, 0.95833333333333, -0.12, 0.375
47647, 0.95833333333333, -0.16, 0.375
47648, 0.95833333333333, -0.04, 0.41666666666667
47649, 0.95833333333333, -0.08, 0.41666666666667
47650, 0.95833333333333, -0.12, 0.41666666666667
47651, 0.95833333333333, -0.16, 0.41666666666667
47652, 0.95833333333333, -0.04, 0.45833333333333
47653, 0.95833333333333, -0.08, 0.45833333333333
47654, 0.95833333333333, -0.12, 0.45833333333333
47655, 0.95833333333333, -0.16, 0.45833333333333
47656, 0.041666666666667, -0.02, 0.041666666666667
47657, 0.041666666666667, -0.04, 0.020833333333333
47658, 0.020833333333333, -0.04, 0.041666666666667
47659, 0.041666666666667, -0.06, 0.041666666666667
47660, 0.041666666666667, -0.08, 0.020833333333333
47661, 0.020833333333333, -0.08, 0.041666666666667
47662, 0.041666666666667, -0.1, 0.041666666666667
47663, 0.041666666666667, -0.12, 0.020833333333333
47664, 0.020833333333333, -0.12, 0.041666666666667
47665, 0.041666666666667, -0.14, 0.041666666666667
47666, 0.041666666666667, -0.16, 0.020833333333333
47667, 0.020833333333333, -0.16, 0.041666666666667
47668, 0.041666666666667, -0.18, 0.041666666666667
47669, 0.041666666666667, -0.02, 0.083333333333333
47670, 0.041666666666667, -0.04, 0.0625
47671, 0.020833333333333, -0.04, 0.083333333333333
47672, 0.041666666666667, -0.06, 0.083333333333333
47673, 0.041666666666667, -0.08, 0.0625
47674, 0.020833333333333, -0.08, 0.083333333333333
47675, 0.041666666666667, -0.1, 0.083333333333333
47676, 0.041666666666667, -0.12, 0.0625
47677, 0.020833333333333, -0.12, 0.083333333333333
47678, 0.041666666666667, -0.14, 0.083333333333333
47679, 0.041666666666667, -0.16, 0.0625
47680, 0.020833333333333, -0.16, 0.083333333333333
47681, 0.041666666666667, -0.18, 0.083333333333333
47682, 0.041666666666667, -0.02, 0.125
47683, 0.041666666666667, -0.04, 0.10416666666667
47684, 0.020833333333333, -0.04, 0.125
47685, 0.041666666666667, -0.06, 0.125
47686, 0.041666666666667, -0.08, 0.10416666666667
47687, 0.020833333333333, -0.08, 0.125
47688, 0.041666666666667, -0.1, 0.125
47689, 0.041666666666667, -0.12, 0.10416666666667
47690, 0.020833333333333, -0.12, 0.125
47691, 0.041666666666667, -0.14, 0.125
47692, 0.041666666666667, -0.16, 0.10416666666667
47693, 0.020833333333333, -0.16, 0.125
47694, 0.041666666666667, -0.18, 0.125
47695, 0.041666666666667, -0.02, 0.16666666666667
47696, 0.041666666666667, -0.04, 0.14583333333333
47697, 0.020833333333333, -0.04, 0.16666666666667
47698, 0.041666666666667, -0.06, 0.16666666666667
47699, 0.041666666666667, -0.08, 0.14583333333333
47700, 0.020833333333333, -0.08, 0.16666666666667
47701, 0.041666666666667, -0.1, 0.16666666666667
47702, 0.041666666666667, -0.12, 0.14583333333333
47703, 0.020833333333333, -0.12, 0.16666666666667
47704, 0.041666666666667, -0.14, 0.16666666666667
47705, 0.041666666666667, -0.16, 0.14583333333333
47706, 0.020833333333333, -0.16, 0.16666666666667
47707, 0.041666666666667, -0.18, 0.16666666666667
47708, 0.041666666666667, -0.02, 0.20833333333333
47709, 0.041666666666667, -0.04, 0.1875
47710, 0.020833333333333, -0.04, 0.20833333333333
47711, 0.041666666666667, -0.06, 0.20833333333333
47712, 0.041666666666667, -0.08, 0.1875
47713, 0.020833333333333, -0.08, 0.20833333333333
47714, 0.041666666666667, -0.1, 0.20833333333333
47715, 0.041666666666667, -0.12, 0.1875
47716, 0.020833333333333, -0.12, 0.20833333333333
47717, 0.041666666666667, -0.14, 0.20833333333333
47718, 0.041666666666667, -0.16, 0.1875
47719, 0.020833333333333, -0.16, 0.20833333333333
47720, 0.041666666666667, -0.18, 0.20833333333333
47721, 0.041666666666667, -0.02, 0.25
47722, 0.041666666666667, -0.04, 0.22916666666667
47723, 0.020833333333333, -0.04, 0.25
47724, 0.041666666666667, -0.06, 0.25
47725, 0.041666666666667, -0.08, 0.22916666666667
47726, 0.020833333333333, -0.08, 0.25
47727, 0.041666666666667, -0.1, 0.25
47728, 0.041666666666667, -0.12, 0.22916666666667
47729, 0.020833333333333, -0.12, 0.25
47730, 0.041666666666667, -0.14, 0.25
47731, 0.041666666666667, -0.16, 0.22916666666667
47732, 0.020833333333333, -0.16, 0.25
47733, 0.041666666666667, -0.18, 0.25
47734, 0.041666666666667, -0.02, 0.29166666666667
47735, 0.041666666666667, -0.04, 0.27083333333333
47736, 0.020833333333333, -0.04, 0.29166666666667
47737, 0.041666666666667, -0.06, 0.29166666666667
47738, 0.041666666666667, -0.08, 0.27083333333333
47739, 0.020833333333333, -0.08, 0.29166666666667
47740, 0.041666666666667, -0.1, 0.29166666666667
47741, 0.041666666666667, -0.12, 0.27083333333333
47742, 0.020833333333333, -0.12, 0.29166666666667
47743, 0.041666666666667, -0.14, 0.29166666666667
47744, 0.041666666666667, -0.16, 0.27083333333333
47745, 0.020833333333333, -0.16, 0.29166666666667
47746, 0.041666666666667, -0.18, 0.29166666666667
47747, 0.041666666666667, -0.02, 0.33333333333333
47748, 0.041666666666667, -0.04, 0.3125
47749, 0.020833333333333, -0.04, 0.33333333333333
47750, 0.041666666666667, -0.06, 0.33333333333333
47751, 0.041666666666667, -0.08, 0.3125
47752, 0.020833333333333, -0.08, 0.33333333333333
47753, 0.041666666666667, -0.1, 0.33333333333333
47754, 0.041666666666667, -0.12, 0.3125
47755, 0.020833333333333, -0.12, 0.33333333333333
47756, 0.041666666666667, -0.14, 0.33333333333333
47757, 0.041666666666667, -0.16, 0.3125
47758, 0.020833333333333, -0.16, 0.33333333333333
47759, 0.041666666666667, -0.18, 0.33333333333333
47760, 0.041666666666667, -0.02, 0.375
47761, 0.041666666666667, -0.04, 0.35416666666667
47762, 0.020833333333333, -0.04, 0.375
47763, 0.041666666666667, -0.06, 0.375
47764, 0.041666666666667, -0.08, 0.35416666666667
47765, 0.020833333333333, -0.08, 0.375
47766, 0.041666666666667, -0.1, 0.375
47767, 0.041666666666667, -0.12, 0.35416666666667
47768, 0.020833333333333, -0.12, 0.375
47769, 0.041666666666667, -0.14, 0.375
47770, 0.041666666666667, -0.16, 0.35416666666667
47771, 0.020833333333333, -0.16, 0.375
47772, 0.041666666666667, -0.18, 0.375
47773, 0.041666666666667, -0.02, 0.41666666666667
47774, 0.041666666666667, -0.04, 0.39583333333333
47775, 0.020833333333333, -0.04, 0.41666666666667
47776, 0.041666666666667, -0.06, 0.41666666666667
47777, 0.041666666666667, -0.08, 0.39583333333333
47778, 0.020833333333333, -0.08, 0.41666666666667
47779, 0.041666666666667, -0.1, 0.41666666666667
47780, 0.041666666666667, -0.12, 0.39583333333333
47781, 0.020833333333333, -0.12, 0.41666666666667
47782, 0.041666666666667, -0.14, 0.41666666666667
47783, 0.041666666666667, -0.16, 0.39583333333333
47784, 0.020833333333333, -0.16, 0.41666666666667
47785, 0.041666666666667, -0.18, 0.41666666666667
47786, 0.041666666666667, -0.02, 0.45833333333333
47787, 0.041666666666667, -0.04, 0.4375
47788, 0.020833333333333, -0.04, 0.45833333333333
47789, 0.041666666666667, -0.06, 0.45833333333333
47790, 0.041666666666667, -0.08, 0.4375
47791, 0.020833333333333, -0.08, 0.45833333333333
47792, 0.041666666666667, -0.1, 0.45833333333333
47793, 0.041666666666667, -0.12, 0.4375
47794, 0.020833333333333, -0.12, 0.45833333333333
47795, 0.041666666666667, -0.14, 0.45833333333333
47796, 0.041666666666667, -0.16, 0.4375
47797, 0.020833333333333, -0.16, 0.45833333333333
47798, 0.041666666666667, -0.18, 0.45833333333333
47799, 0.041666666666667, -0.04, 0.47916666666667
47800, 0.041666666666667, -0.08, 0.47916666666667
47801, 0.041666666666667, -0.12, 0.47916666666667
47802, 0.041666666666667, -0.16, 0.47916666666667
47803, 0.083333333333333, -0.02, 0.041666666666667
47804, 0.083333333333333, -0.04, 0.020833333333333
47805, 0.0625, -0.04, 0.041666666666667
47806, 0.083333333333333, -0.06, 0.041666666666667
47807, 0.083333333333333, -0.08, 0.020833333333333
47808, 0.0625, -0.08, 0.041666666666667
47809, 0.083333333333333, -0.1, 0.041666666666667
47810, 0.083333333333333, -0.12, 0.020833333333333
47811, 0.0625, -0.12, 0.041666666666667
47812, 0.083333333333333, -0.14, 0.041666666666667
47813, 0.083333333333333, -0.16, 0.020833333333333
47814, 0.0625, -0.16, 0.041666666666667
47815, 0.083333333333333, -0.18, 0.041666666666667
47816, 0.083333333333333, -0.02, 0.083333333333333
47817, 0.083333333333333, -0.04, 0.0625
47818, 0.0625, -0.04, 0.083333333333333
47819, 0.083333333333333, -0.06, 0.083333333333333
47820, 0.083333333333333, -0.08, 0.0625
47821, 0.0625, -0.08, 0.083333333333333
47822, 0.083333333333333, -0.1, 0.083333333333333
47823, 0.083333333333333, -0.12, 0.0625
47824, 0.0625, -0.12, 0.083333333333333
47825, 0.083333333333333, -0.14, 0.083333333333333
47826, 0.083333333333333, -0.16, 0.0625
47827, 0.0625, -0.16, 0.083333333333333
47828, 0.083333333333333, -0.18, 0.083333333333333
47829, 0.083333333333333, -0.02, 0.125
47830, 0.083333333333333, -0.04, 0.10416666666667
47831, 0.0625, -0.04, 0.125
47832, 0.083333333333333, -0.06, 0.125
47833, 0.083333333333333, -0.08, 0.10416666666667
47834, 0.0625, -0.08, 0.125
47835, 0.083333333333333, -0.1, 0.125
47836, 0.083333333333333, -0.12, 0.10416666666667
47837, 0.0625, -0.12, 0.125
47838, 0.083333333333333, -0.14, 0.125
47839, 0.083333333333333, -0.16, 0.10416666666667
47840, 0.0625, -0.16, 0.125
47841, 0.083333333333333, -0.18, 0.125
47842, 0.083333333333333, -0.02, 0.16666666666667
47843, 0.083333333333333, -0.04, 0.14583333333333
47844, 0.0625, -0.04, 0.16666666666667
47845, 0.083333333333333, -0.06, 0.16666666666667
47846, 0.083333333333333, -0.08, 0.14583333333333
47847, 0.0625, -0.08, 0.16666666666667
47848, 0.083333333333333, -0.1, 0.16666666666667
47849, 0.083333333333333, -0.12, 0.14583333333333
47850, 0.0625, -0.12, 0.16666666666667
47851, 0.083333333333333, -0.14, 0.16666666666667
47852, 0.083333333333333, -0.16, 0.14583333333333
47853, 0.0625, -0.16, 0.16666666666667
47854, 0.083333333333333, -0.18, 0.16666666666667
47855, 0.083333333333333, -0.02, 0.20833333333333
47856, 0.083333333333333, -0.04, 0.1875
47857, 0.0625, -0.04, 0.20833333333333
47858, 0.083333333333333, -0.06, 0.20833333333333
47859, 0.083333333333333, -0.08, 0.1875
47860, 0.0625, -0.08, 0.20833333333333
47861, 0.083333333333333, -0.1, 0.20833333333333
47862, 0.083333333333333, -0.12, 0.1875
47863, 0.0625, -0.12, 0.20833333333333
47864, 0.083333333333333, -0.14, 0.20833333333333
47865, 0.083333333333333, -0.16, 0.1875
47866, 0.0625, -0.16, 0.20833333333333
47867, 0.083333333333333, -0.18, 0.20833333333333
47868, 0.083333333333333, -0.02, 0.25
47869, 0.083333333333333, -0.04, 0.22916666666667
47870, 0.0625, -0.04, 0.25
47871, 0.083333333333333, -0.06, 0.25
47872, 0.083333333333333, -0.08, 0.22916666666667
47873, 0.0625, -0.08, 0.25
47874, 0.083333333333333, -0.1, 0.25
47875, 0.083333333333333, -0.12, 0.22916666666667
47876, 0.0625, -0.12, 0.25
47877, 0.083333333333333, -0.14, 0.25
47878, 0.083333333333333, -0.16, 0.22916666666667
47879, 0.0625, -0.16, 0.25
47880, 0.083333333333333, -0.18, 0.25
47881, 0.083333333333333, -0.02, 0.29166666666667
47882, 0.083333333333333, -0.04, 0.27083333333333
47883, 0.0625, -0.04, 0.29166666666667
47884, 0.083333333333333, -0.06, 0.29166666666667
47885, 0.083333333333333, -0.08, 0.27083333333333
47886, 0.0625, -0.08, 0.29166666666667
47887, 0.083333333333333, -0.1, 0.29166666666667
47888, 0.083333333333333, -0.12, 0.27083333333333
47889, 0.0625, -0.12, 0.29166666666667
47890, 0.083333333333333, -0.14, 0.29166666666667
47891, 0.083333333333333, -0.16, 0.27083333333333
47892, 0.0625, -0.16, 0.29166666666667
47893, 0.083333333333333, -0.18, 0.29166666666667
47894, 0.083333333333333, -0.02, 0.33333333333333
47895, 0.083333333333333, -0.04, 0.3125
47896, 0.0625, -0.04, 0.33333333333333
47897, 0.083333333333333, -0.06, 0.33333333333333
47898, 0.083333333333333, -0.08, 0.3125
47899, 0.0625, -0.08, 0.33333333333333
47900, 0.083333333333333, -0.1, 0.33333333333333
47901, 0.083333333333333, -0.12, 0.3125
47902, 0.0625, -0.12, 0.33333333333333
47903, 0.083333333333333, -0.14, 0.33333333333333
47904, 0.083333333333333, -0.16, 0.3125
47905, 0.0625, -0.16, 0.33333333333333
47906, 0.083333333333333, -0.18, 0.33333333333333
47907, 0.083333333333333, -0.02, 0.375
47908, 0.083333333333333, -0.04, 0.35416666666667
47909, 0.0625, -0.04, 0.375
47910, 0.083333333333333, -0.06, 0.375
47911, 0.083333333333333, -0.08, 0.35416666666667
47912, 0.0625, -0.08, 0.375
47913, 0.083333333333333, -0.1, 0.375
47914, 0.083333333333333, -0.12, 0.35416666666667
47915, 0.0625, -0.12, 0.375
47916, 0.083333333333333, -0.14, 0.375
47917, 0.083333333333333, -0.16, 0.35416666666667
47918, 0.0625, -0.16, 0.375
47919, 0.083333333333333, -0.18, 0.375
47920, 0.083333333333333, -0.02, 0.41666666666667
47921, 0.083333333333333, -0.04, 0.39583333333333
47922, 0.0625, -0.04, 0.41666666666667
47923, 0.083333333333333, -0.06, 0.41666666666667
47924, 0.083333333333333, -0.08, 0.39583333333333
47925, 0.0625, -0.08, 0.41666666666667
47926, 0.083333333333333, -0.1, 0.41666666666667
47927, 0.083333333333333, -0.12, 0.39583333333333
47928, 0.0625, -0.12, 0.41666666666667
47929, 0.083333333333333, -0.14, 0.41666666666667
47930, 0.083333333333333, -0.16, 0.39583333333333
47931, 0.0625, -0.16, 0.41666666666667
47932, 0.083333333333333, -0.18, 0.41666666666667
47933, 0.083333333333333, -0.02, 0.45833333333333
47934, 0.083333333333333, -0.04, 0.4375
47935, 0.0625, -0.04, 0.45833333333333
47936, 0.083333333333333, -0.06, 0.45833333333333
47937, 0.083333333333333, -0.08, 0.4375
47938, 0.0625, -0.08, 0.45833333333333
47939, 0.083333333333333, -0.1, 0.45833333333333
47940, 0.083333333333333, -0.12, 0.4375
47941, 0.0625, -0.12, 0.45833333333333
47942, 0.083333333333333, -0.14, 0.45833333333333
47943, 0.083333333333333, -0.16, 0.4375
47944, 0.0625, -0.16, 0.45833333333333
47945, 0.083333333333333, -0.18, 0.45833333333333
47946, 0.083333333333333, -0.04, 0.47916666666667
47947, 0.083333333333333, -0.08, 0.47916666666667
47948, 0.083333333333333, -0.12, 0.47916666666667
47949, 0.083333333333333, -0.16, 0.47916666666667
47950, 0.125, -0.02, 0.041666666666667
47951, 0.125, -0.04, 0.020833333333333
47952, 0.10416666666667, -0.04, 0.041666666666667
47953, 0.125, -0.06, 0.041666666666667
47954, 0.125, -0.08, 0.020833333333333
47955, 0.10416666666667, -0.08, 0.041666666666667
47956, 0.125, -0.1, 0.041666666666667
47957, 0.125, -0.12, 0.020833333333333
47958, 0.10416666666667, -0.12, 0.041666666666667
47959, 0.125, -0.14, 0.041666666666667
47960, 0.125, -0.16, 0.020833333333333
47961, 0.10416666666667, -0.16, 0.041666666666667
47962, 0.125, -0.18, 0.041666666666667
47963, 0.125, -0.02, 0.083333333333333
47964, 0.125, -0.04, 0.0625
47965, 0.10416666666667, -0.04, 0.083333333333333
47966, 0.125, -0.06, 0.083333333333333
47967, 0.125, -0.08, 0.0625
47968, 0.10416666666667, -0.08, 0.083333333333333
47969, 0.125, -0.1, 0.083333333333333
47970, 0.125, -0.12, 0.0625
47971, 0.10416666666667, -0.12, 0.083333333333333
47972, 0.125, -0.14, 0.083333333333333
47973, 0.125, -0.16, 0.0625
47974, 0.10416666666667, -0.16, 0.083333333333333
47975, 0.125, -0.18, 0.083333333333333
47976, 0.125, -0.02, 0.125
47977, 0.125, -0.04, 0.10416666666667
47978, 0.10416666666667, -0.04, 0.125
47979, 0.125, -0.06, 0.125
47980, 0.125, -0.08, 0.10416666666667
47981, 0.10416666666667, -0.08, 0.125
47982, 0.125, -0.1, 0.125
47983, 0.125, -0.12, 0.10416666666667
47984, 0.10416666666667, -0.12, 0.125
47985, 0.125, -0.14, 0.125
47986, 0.125, -0.16, 0.10416666666667
47987, 0.10416666666667, -0.16, 0.125
47988, 0.125, -0.18, 0.125
47989, 0.125, -0.02, 0.16666666666667
47990, 0.125, -0.04, 0.14583333333333
47991, 0.10416666666667, -0.04, 0.16666666666667
47992, 0.125, -0.06, 0.16666666666667
47993, 0.125, -0.08, 0.14583333333333
47994, 0.10416666666667, -0.08, 0.16666666666667
47995, 0.125, -0.1, 0.16666666666667
47996, 0.125, -0.12, 0.14583333333333
47997, 0.10416666666667, -0.12, 0.16666666666667
47998, 0.125, -0.14, 0.16666666666667
47999, 0.125, -0.16, 0.14583333333333
48000, 0.10416666666667, -0.16, 0.16666666666667
48001, 0.125, -0.18, 0.16666666666667
48002, 0.125, -0.02, 0.20833333333333
48003, 0.125, -0.04, 0.1875
48004, 0.10416666666667, -0.04, 0.20833333333333
48005, 0.125, -0.06, 0.20833333333333
48006, 0.125, -0.08, 0.1875
48007, 0.10416666666667, -0.08, 0.20833333333333
48008, 0.125, -0.1, 0.20833333333333
48009, 0.125, -0.12, 0.1875
48010, 0.10416666666667, -0.12, 0.20833333333333
48011, 0.125, -0.14, 0.20833333333333
48012, 0.125, -0.16, 0.1875
48013, 0.10416666666667, -0.16, 0.20833333333333
48014, 0.125, -0.18, 0.20833333333333
48015, 0.125, -0.02, 0.25
48016, 0.125, -0.04, 0.22916666666667
48017, 0.10416666666667, -0.04, 0.25
48018, 0.125, -0.06, 0.25
48019, 0.125, -0.08, 0.22916666666667
48020, 0.10416666666667, -0.08, 0.25
48021, 0.125, -0.1, 0.25
48022, 0.125, -0.12, 0.22916666666667
48023, 0.10416666666667, -0.12, 0.25
48024, 0.125, -0.14, 0.25
48025, 0.125, -0.16, 0.22916666666667
48026, 0.10416666666667, -0.16, 0.25
48027, 0.125, -0.18, 0.25
48028, 0.125, -0.02, 0.29166666666667
48029, 0.125, -0.04, 0.27083333333333
48030, 0.10416666666667, -0.04, 0.29166666666667
48031, 0.125, -0.06, 0.29166666666667
48032, 0.125, -0.08, 0.27083333333333
48033, 0.10416666666667, -0.08, 0.29166666666667
48034, 0.125, -0.1, 0.29166666666667
48035, 0.125, -0.12, 0.27083333333333
48036, 0.10416666666667, -0.12, 0.29166666666667
48037, 0.125, -0.14, 0.29166666666667
48038, 0.125, -0.16, 0.27083333333333
48039, 0.10416666666667, -0.16, 0.29166666666667
48040, 0.125, -0.18, 0.29166666666667
48041, 0.125, -0.02, 0.33333333333333
48042, 0.125, -0.04, 0.3125
48043, 0.10416666666667, -0.04, 0.33333333333333
48044, 0.125, -0.06, 0.33333333333333
48045, 0.125, -0.08, 0.3125
48046, 0.10416666666667, -0.08, 0.33333333333333
48047, 0.125, -0.1, 0.33333333333333
48048, 0.125, -0.12, 0.3125
48049, 0.10416666666667, -0.12, 0.33333333333333
48050, 0.125, -0.14, 0.33333333333333
48051, 0.125, -0.16, 0.3125
48052, 0.10416666666667, -0.16, 0.33333333333333
48053, 0.125, -0.18, 0.33333333333333
48054, 0.125, -0.02, 0.375
48055, 0.125, -0.04, 0.35416666666667
48056, 0.10416666666667, -0.04, 0.375
48057, 0.125, -0.06, 0.375
48058, 0.125, -0.08, 0.35416666666667
48059, 0.10416666666667, -0.08, 0.375
48060, 0.125, -0.1, 0.375
48061, 0.125, -0.12, 0.35416666666667
48062, 0.10416666666667, -0.12, 0.375
48063, 0.125, -0.14, 0.375
48064, 0.125, -0.16, 0.35416666666667
48065, 0.10416666666667, -0.16, 0.375
48066, 0.125, -0.18, 0.375
48067, 0.125, -0.02, 0.41666666666667
48068, 0.125, -0.04, 0.39583333333333
48069, 0.10416666666667, -0.04, 0.41666666666667
48070, 0.125, -0.06, 0.41666666666667
48071, 0.125, -0.08, 0.39583333333333
48072, 0.10416666666667, -0.08, 0.41666666666667
48073, 0.125, -0.1, 0.41666666666667
48074, 0.125, -0.12, 0.39583333333333
48075, 0.10416666666667, -0.12, 0.41666666666667
48076, 0.125, -0.14, 0.41666666666667
48077, 0.125, -0.16, 0.39583333333333
48078, 0.10416666666667, -0.16, 0.41666666666667
48079, 0.125, -0.18, 0.41666666666667
48080, 0.125, -0.02, 0.45833333333333
48081, 0.125, -0.04, 0.4375
48082, 0.10416666666667, -0.04, 0.45833333333333
48083, 0.125, -0.06, 0.45833333333333
48084, 0.125, -0.08, 0.4375
48085, 0.10416666666667, -0.08, 0.45833333333333
48086, 0.125, -0.1, 0.45833333333333
48087, 0.125, -0.12, 0.4375
48088, 0.10416666666667, -0.12, 0.45833333333333
48089, 0.125, -0.14, 0.45833333333333
48090, 0.125, -0.16, 0.4375
48091, 0.10416666666667, -0.16, 0.45833333333333
48092, 0.125, -0.18, 0.45833333333333
48093, 0.125, -0.04, 0.47916666666667
48094, 0.125, -0.08, 0.47916666666667
48095, 0.125, -0.12, 0.47916666666667
48096, 0.125, -0.16, 0.47916666666667
48097, 0.16666666666667, -0.02, 0.041666666666667
48098, 0.16666666666667, -0.04, 0.020833333333333
48099, 0.14583333333333, -0.04, 0.041666666666667
48100, 0.16666666666667, -0.06, 0.041666666666667
48101, 0.16666666666667, -0.08, 0.020833333333333
48102, 0.14583333333333, -0.08, 0.041666666666667
48103, 0.16666666666667, -0.1, 0.041666666666667
48104, 0.16666666666667, -0.12, 0.020833333333333
48105, 0.14583333333333, -0.12, 0.041666666666667
48106, 0.16666666666667, -0.14, 0.041666666666667
48107, 0.16666666666667, -0.16, 0.020833333333333
48108, 0.14583333333333, -0.16, 0.041666666666667
48109, 0.16666666666667, -0.18, 0.041666666666667
48110, 0.16666666666667, -0.02, 0.083333333333333
48111, 0.16666666666667, -0.04, 0.0625
48112, 0.14583333333333, -0.04, 0.083333333333333
48113, 0.16666666666667, -0.06, 0.083333333333333
48114, 0.16666666666667, -0.08, 0.0625
48115, 0.14583333333333, -0.08, 0.083333333333333
48116, 0.16666666666667, -0.1, 0.083333333333333
48117, 0.16666666666667, -0.12, 0.0625
48118, 0.14583333333333, -0.12, 0.083333333333333
48119, 0.16666666666667, -0.14, 0.083333333333333
48120, 0.16666666666667, -0.16, 0.0625
48121, 0.14583333333333, -0.16, 0.083333333333333
48122, 0.16666666666667, -0.18, 0.083333333333333
48123, 0.16666666666667, -0.02, 0.125
48124, 0.16666666666667, -0.04, 0.10416666666667
48125, 0.14583333333333, -0.04, 0.125
48126, 0.16666666666667, -0.06, 0.125
48127, 0.16666666666667, -0.08, 0.10416666666667
48128, 0.14583333333333, -0.08, 0.125
48129, 0.16666666666667, -0.1, 0.125
48130, 0.16666666666667, -0.12, 0.10416666666667
48131, 0.14583333333333, -0.12, 0.125
48132, 0.16666666666667, -0.14, 0.125
48133, 0.16666666666667, -0.16, 0.10416666666667
48134, 0.14583333333333, -0.16, 0.125
48135, 0.16666666666667, -0.18, 0.125
48136, 0.16666666666667, -0.02, 0.16666666666667
48137, 0.16666666666667, -0.04, 0.14583333333333
48138, 0.14583333333333, -0.04, 0.16666666666667
48139, 0.16666666666667, -0.06, 0.16666666666667
48140, 0.16666666666667, -0.08, 0.14583333333333
48141, 0.14583333333333, -0.08, 0.16666666666667
48142, 0.16666666666667, -0.1, 0.16666666666667
48143, 0.16666666666667, -0.12, 0.14583333333333
48144, 0.14583333333333, -0.12, 0.16666666666667
48145, 0.16666666666667, -0.14, 0.16666666666667
48146, 0.16666666666667, -0.16, 0.14583333333333
48147, 0.14583333333333, -0.16, 0.16666666666667
48148, 0.16666666666667, -0.18, 0.16666666666667
48149, 0.16666666666667, -0.02, 0.20833333333333
48150, 0.16666666666667, -0.04, 0.1875
48151, 0.14583333333333, -0.04, 0.20833333333333
48152, 0.16666666666667, -0.06, 0.20833333333333
48153, 0.16666666666667, -0.08, 0.1875
48154, 0.14583333333333, -0.08, 0.20833333333333
48155, 0.16666666666667, -0.1, 0.20833333333333
48156, 0.16666666666667, -0.12, 0.1875
48157, 0.14583333333333, -0.12, 0.20833333333333
48158, 0.16666666666667, -0.14, 0.20833333333333
48159, 0.16666666666667, -0.16, 0.1875
48160, 0.14583333333333, -0.16, 0.20833333333333
48161, 0.16666666666667, -0.18, 0.20833333333333
48162, 0.16666666666667, -0.02, 0.25
48163, 0.16666666666667, -0.04, 0.22916666666667
48164, 0.14583333333333, -0.04, 0.25
48165, 0.16666666666667, -0.06, 0.25
48166, 0.16666666666667, -0.08, 0.22916666666667
48167, 0.14583333333333, -0.08, 0.25
48168, 0.16666666666667, -0.1, 0.25
48169, 0.16666666666667, -0.12, 0.22916666666667
48170, 0.14583333333333, -0.12, 0.25
48171, 0.16666666666667, -0.14, 0.25
48172, 0.16666666666667, -0.16, 0.22916666666667
48173, 0.14583333333333, -0.16, 0.25
48174, 0.16666666666667, -0.18, 0.25
48175, 0.16666666666667, -0.02, 0.29166666666667
48176, 0.16666666666667, -0.04, 0.27083333333333
48177, 0.14583333333333, -0.04, 0.29166666666667
48178, 0.16666666666667, -0.06, 0.29166666666667
48179, 0.16666666666667, -0.08, 0.27083333333333
48180, 0.14583333333333, -0.08, 0.29166666666667
48181, 0.16666666666667, -0.1, 0.29166666666667
48182, 0.16666666666667, -0.12, 0.27083333333333
48183, 0.14583333333333, -0.12, 0.29166666666667
48184, 0.16666666666667, -0.14, 0.29166666666667
48185, 0.16666666666667, -0.16, 0.27083333333333
48186, 0.14583333333333, -0.16, 0.29166666666667
48187, 0.16666666666667, -0.18, 0.29166666666667
48188, 0.16666666666667, -0.02, 0.33333333333333
48189, 0.16666666666667, -0.04, 0.3125
48190, 0.14583333333333, -0.04, 0.33333333333333
48191, 0.16666666666667, -0.06, 0.33333333333333
48192, 0.16666666666667, -0.08, 0.3125
48193, 0.14583333333333, -0.08, 0.33333333333333
48194, 0.16666666666667, -0.1, 0.33333333333333
48195, 0.16666666666667, -0.12, 0.3125
48196, 0.14583333333333, -0.12, 0.33333333333333
48197, 0.16666666666667, -0.14, 0.33333333333333
48198, 0.16666666666667, -0.16, 0.3125
48199, 0.14583333333333, -0.16, 0.33333333333333
48200, 0.16666666666667, -0.18, 0.33333333333333
48201, 0.16666666666667, -0.02, 0.375
48202, 0.16666666666667, -0.04, 0.35416666666667
48203, 0.14583333333333, -0.04, 0.375
48204, 0.16666666666667, -0.06, 0.375
48205, 0.16666666666667, -0.08, 0.35416666666667
48206, 0.14583333333333, -0.08, 0.375
48207, 0.16666666666667, -0.1, 0.375
48208, 0.16666666666667, -0.12, 0.35416666666667
48209, 0.14583333333333, -0.12, 0.375
48210, 0.16666666666667, -0.14, 0.375
48211, 0.16666666666667, -0.16, 0.35416666666667
48212, 0.14583333333333, -0.16, 0.375
48213, 0.16666666666667, -0.18, 0.375
48214, 0.16666666666667, -0.02, 0.41666666666667
48215, 0.16666666666667, -0.04, 0.39583333333333
48216, 0.14583333333333, -0.04, 0.41666666666667
48217, 0.16666666666667, -0.06, 0.41666666666667
48218, 0.16666666666667, -0.08, 0.39583333333333
48219, 0.14583333333333, -0.08, 0.41666666666667
48220, 0.16666666666667, -0.1, 0.41666666666667
48221, 0.16666666666667, -0.12, 0.39583333333333
48222, 0.14583333333333, -0.12, 0.41666666666667
48223, 0.16666666666667, -0.14, 0.41666666666667
48224, 0.16666666666667, -0.16, 0.39583333333333
48225, 0.14583333333333, -0.16, 0.41666666666667
48226, 0.16666666666667, -0.18, 0.41666666666667
48227, 0.16666666666667, -0.02, 0.45833333333333
48228, 0.16666666666667, -0.04, 0.4375
48229, 0.14583333333333, -0.04, 0.45833333333333
48230, 0.16666666666667, -0.06, 0.45833333333333
48231, 0.16666666666667, -0.08, 0.4375
48232, 0.14583333333333, -0.08, 0.45833333333333
48233, 0.16666666666667, -0.1, 0.45833333333333
48234, 0.16666666666667, -0.12, 0.4375
48235, 0.14583333333333, -0.12, 0.45833333333333
48236, 0.16666666666667, -0.14, 0.45833333333333
48237, 0.16666666666667, -0.16, 0.4375
48238, 0.14583333333333, -0.16, 0.45833333333333
48239, 0.16666666666667, -0.18, 0.45833333333333
48240, 0.16666666666667, -0.04, 0.47916666666667
48241, 0.16666666666667, -0.08, 0.47916666666667
48242, 0.16666666666667, -0.12, 0.47916666666667
48243, 0.16666666666667, -0.16, 0.47916666666667
48244, 0.20833333333333, -0.02, 0.041666666666667
48245, 0.20833333333333, -0.04, 0.020833333333333
48246, 0.1875, -0.04, 0.041666666666667
48247, 0.20833333333333, -0.06, 0.041666666666667
48248, 0.20833333333333, -0.08, 0.020833333333333
48249, 0.1875, -0.08, 0.041666666666667
48250, 0.20833333333333, -0.1, 0.041666666666667
48251, 0.20833333333333, -0.12, 0.020833333333333
48252, 0.1875, -0.12, 0.041666666666667
48253, 0.20833333333333, -0.14, 0.041666666666667
48254, 0.20833333333333, -0.16, 0.020833333333333
48255, 0.1875, -0.16, 0.041666666666667
48256, 0.20833333333333, -0.18, 0.041666666666667
48257, 0.20833333333333, -0.02, 0.083333333333333
48258, 0.20833333333333, -0.04, 0.0625
48259, 0.1875, -0.04, 0.083333333333333
48260, 0.20833333333333, -0.06, 0.083333333333333
48261, 0.20833333333333, -0.08, 0.0625
48262, 0.1875, -0.08, 0.083333333333333
48263, 0.20833333333333, -0.1, 0.083333333333333
48264, 0.20833333333333, -0.12, 0.0625
48265, 0.1875, -0.12, 0.083333333333333
48266, 0.20833333333333, -0.14, 0.083333333333333
48267, 0.20833333333333, -0.16, 0.0625
48268, 0.1875, -0.16, 0.083333333333333
48269, 0.20833333333333, -0.18, 0.083333333333333
48270, 0.20833333333333, -0.02, 0.125
48271, 0.20833333333333, -0.04, 0.10416666666667
48272, 0.1875, -0.04, 0.125
48273, 0.20833333333333, -0.06, 0.125
48274, 0.20833333333333, -0.08, 0.10416666666667
48275, 0.1875, -0.08, 0.125
48276, 0.20833333333333, -0.1, 0.125
48277, 0.20833333333333, -0.12, 0.10416666666667
48278, 0.1875, -0.12, 0.125
48279, 0.20833333333333, -0.14, 0.125
48280, 0.20833333333333, -0.16, 0.10416666666667
48281, 0.1875, -0.16, 0.125
48282, 0.20833333333333, -0.18, 0.125
48283, 0.20833333333333, -0.02, 0.16666666666667
48284, 0.20833333333333, -0.04, 0.14583333333333
48285, 0.1875, -0.04, 0.16666666666667
48286, 0.20833333333333, -0.06, 0.16666666666667
48287, 0.20833333333333, -0.08, 0.14583333333333
48288, 0.1875, -0.08, 0.16666666666667
48289, 0.20833333333333, -0.1, 0.16666666666667
48290, 0.20833333333333, -0.12, 0.14583333333333
48291, 0.1875, -0.12, 0.16666666666667
48292, 0.20833333333333, -0.14, 0.16666666666667
48293, 0.20833333333333, -0.16, 0.14583333333333
48294, 0.1875, -0.16, 0.16666666666667
48295, 0.20833333333333, -0.18, 0.16666666666667
48296, 0.20833333333333, -0.02, 0.20833333333333
48297, 0.20833333333333, -0.04, 0.1875
48298, 0.1875, -0.04, 0.20833333333333
48299, 0.20833333333333, -0.06, 0.20833333333333
48300, 0.20833333333333, -0.08, 0.1875
48301, 0.1875, -0.08, 0.20833333333333
48302, 0.20833333333333, -0.1, 0.20833333333333
48303, 0.20833333333333, -0.12, 0.1875
48304, 0.1875, -0.12, 0.20833333333333
48305, 0.20833333333333, -0.14, 0.20833333333333
48306, 0.20833333333333, -0.16, 0.1875
48307, 0.1875, -0.16, 0.20833333333333
48308, 0.20833333333333, -0.18, 0.20833333333333
48309, 0.20833333333333, -0.02, 0.25
48310, 0.20833333333333, -0.04, 0.22916666666667
48311, 0.1875, -0.04, 0.25
48312, 0.20833333333333, -0.06, 0.25
48313, 0.20833333333333, -0.08, 0.22916666666667
48314, 0.1875, -0.08, 0.25
48315, 0.20833333333333, -0.1, 0.25
48316, 0.20833333333333, -0.12, 0.22916666666667
48317, 0.1875, -0.12, 0.25
48318, 0.20833333333333, -0.14, 0.25
48319, 0.20833333333333, -0.16, 0.22916666666667
48320, 0.1875, -0.16, 0.25
48321, 0.20833333333333, -0.18, 0.25
48322, 0.20833333333333, -0.02, 0.29166666666667
48323, 0.20833333333333, -0.04, 0.27083333333333
48324, 0.1875, -0.04, 0.29166666666667
48325, 0.20833333333333, -0.06, 0.29166666666667
48326, 0.20833333333333, -0.08, 0.27083333333333
48327, 0.1875, -0.08, 0.29166666666667
48328, 0.20833333333333, -0.1, 0.29166666666667
48329, 0.20833333333333, -0.12, 0.27083333333333
48330, 0.1875, -0.12, 0.29166666666667
48331, 0.20833333333333, -0.14, 0.29166666666667
48332, 0.20833333333333, -0.16, 0.27083333333333
48333, 0.1875, -0.16, 0.29166666666667
48334, 0.20833333333333, -0.18, 0.29166666666667
48335, 0.20833333333333, -0.02, 0.33333333333333
48336, 0.20833333333333, -0.04, 0.3125
48337, 0.1875, -0.04, 0.33333333333333
48338, 0.20833333333333, -0.06, 0.33333333333333
48339, 0.20833333333333, -0.08, 0.3125
48340, 0.1875, -0.08, 0.33333333333333
48341, 0.20833333333333, -0.1, 0.33333333333333
48342, 0.20833333333333, -0.12, 0.3125
48343, 0.1875, -0.12, 0.33333333333333
48344, 0.20833333333333, -0.14, 0.33333333333333
48345, 0.20833333333333, -0.16, 0.3125
48346, 0.1875, -0.16, 0.33333333333333
48347, 0.20833333333333, -0.18, 0.33333333333333
48348, 0.20833333333333, -0.02, 0.375
48349, 0.20833333333333, -0.04, 0.35416666666667
48350, 0.1875, -0.04, 0.375
48351, 0.20833333333333, -0.06, 0.375
48352, 0.20833333333333, -0.08, 0.35416666666667
48353, 0.1875, -0.08, 0.375
48354, 0.20833333333333, -0.1, 0.375
48355, 0.20833333333333, -0.12, 0.35416666666667
48356, 0.1875, -0.12, 0.375
48357, 0.20833333333333, -0.14, 0.375
48358, 0.20833333333333, -0.16, 0.35416666666667
48359, 0.1875, -0.16, 0.375
48360, 0.20833333333333, -0.18, 0.375
48361, 0.20833333333333, -0.02, 0.41666666666667
48362, 0.20833333333333, -0.04, 0.39583333333333
48363, 0.1875, -0.04, 0.41666666666667
48364, 0.20833333333333, -0.06, 0.41666666666667
48365, 0.20833333333333, -0.08, 0.39583333333333
48366, 0.1875, -0.08, 0.41666666666667
48367, 0.20833333333333, -0.1, 0.41666666666667
48368, 0.20833333333333, -0.12, 0.39583333333333
48369, 0.1875, -0.12, 0.41666666666667
48370, 0.20833333333333, -0.14, 0.41666666666667
48371, 0.20833333333333, -0.16, 0.39583333333333
48372, 0.1875, -0.16, 0.41666666666667
48373, 0.20833333333333, -0.18, 0.41666666666667
48374, 0.20833333333333, -0.02, 0.45833333333333
48375, 0.20833333333333, -0.04, 0.4375
48376, 0.1875, -0.04, 0.45833333333333
48377, 0.20833333333333, -0.06, 0.45833333333333
48378, 0.20833333333333, -0.08, 0.4375
48379, 0.1875, -0.08, 0.45833333333333
48380, 0.20833333333333, -0.1, 0.45833333333333
48381, 0.20833333333333, -0.12, 0.4375
48382, 0.1875, -0.12, 0.45833333333333
48383, 0.20833333333333, -0.14, 0.45833333333333
48384, 0.20833333333333, -0.16, 0.4375
48385, 0.1875, -0.16, 0.45833333333333
48386, 0.20833333333333, -0.18, 0.45833333333333
48387, 0.20833333333333, -0.04, 0.47916666666667
48388, 0.20833333333333, -0.08, 0.47916666666667
48389, 0.20833333333333, -0.12, 0.47916666666667
48390, 0.20833333333333, -0.16, 0.47916666666667
48391, 0.25, -0.02, 0.041666666666667
48392, 0.25, -0.04, 0.020833333333333
48393, 0.22916666666667, -0.04, 0.041666666666667
48394, 0.25, -0.06, 0.041666666666667
48395, 0.25, -0.08, 0.020833333333333
48396, 0.22916666666667, -0.08, 0.041666666666667
48397, 0.25, -0.1, 0.041666666666667
48398, 0.25, -0.12, 0.020833333333333
48399, 0.22916666666667, -0.12, 0.041666666666667
48400, 0.25, -0.14, 0.041666666666667
48401, 0.25, -0.16, 0.020833333333333
48402, 0.22916666666667, -0.16, 0.041666666666667
48403, 0.25, -0.18, 0.041666666666667
48404, 0.25, -0.02, 0.083333333333333
48405, 0.25, -0.04, 0.0625
48406, 0.22916666666667, -0.04, 0.083333333333333
48407, 0.25, -0.06, 0.083333333333333
48408, 0.25, -0.08, 0.0625
48409, 0.22916666666667, -0.08, 0.083333333333333
48410, 0.25, -0.1, 0.083333333333333
48411, 0.25, -0.12, 0.0625
48412, 0.22916666666667, -0.12, 0.083333333333333
48413, 0.25, -0.14, 0.083333333333333
48414, 0.25, -0.16, 0.0625
48415, 0.22916666666667, -0.16, 0.083333333333333
48416, 0.25, -0.18, 0.083333333333333
48417, 0.25, -0.02, 0.125
48418, 0.25, -0.04, 0.10416666666667
48419, 0.22916666666667, -0.04, 0.125
48420, 0.25, -0.06, 0.125
48421, 0.25, -0.08, 0.10416666666667
48422, 0.22916666666667, -0.08, 0.125
48423, 0.25, -0.1, 0.125
48424, 0.25, -0.12, 0.10416666666667
48425, 0.22916666666667, -0.12, 0.125
48426, 0.25, -0.14, 0.125
48427, 0.25, -0.16, 0.10416666666667
48428, 0.22916666666667, -0.16, 0.125
48429, 0.25, -0.18, 0.125
48430, 0.25, -0.02, 0.16666666666667
48431, 0.25, -0.04, 0.14583333333333
48432, 0.22916666666667, -0.04, 0.16666666666667
48433, 0.25, -0.06, 0.16666666666667
48434, 0.25, -0.08, 0.14583333333333
48435, 0.22916666666667, -0.08, 0.16666666666667
48436, 0.25, -0.1, 0.16666666666667
48437, 0.25, -0.12, 0.14583333333333
48438, 0.22916666666667, -0.12, 0.16666666666667
48439, 0.25, -0.14, 0.16666666666667
48440, 0.25, -0.16, 0.14583333333333
48441, 0.22916666666667, -0.16, 0.16666666666667
48442, 0.25, -0.18, 0.16666666666667
48443, 0.25, -0.02, 0.20833333333333
48444, 0.25, -0.04, 0.1875
48445, 0.22916666666667, -0.04, 0.20833333333333
48446, 0.25, -0.06, 0.20833333333333
48447, 0.25, -0.08, 0.1875
48448, 0.22916666666667, -0.08, 0.20833333333333
48449, 0.25, -0.1, 0.20833333333333
48450, 0.25, -0.12, 0.1875
48451, 0.22916666666667, -0.12, 0.20833333333333
48452, 0.25, -0.14, 0.20833333333333
48453, 0.25, -0.16, 0.1875
48454, 0.22916666666667, -0.16, 0.20833333333333
48455, 0.25, -0.18, 0.20833333333333
48456, 0.25, -0.02, 0.25
48457, 0.25, -0.04, 0.22916666666667
48458, 0.22916666666667, -0.04, 0.25
48459, 0.25, -0.06, 0.25
48460, 0.25, -0.08, 0.22916666666667
48461, 0.22916666666667, -0.08, 0.25
48462, 0.25, -0.1, 0.25
48463, 0.25, -0.12, 0.22916666666667
48464, 0.22916666666667, -0.12, 0.25
48465, 0.25, -0.14, 0.25
48466, 0.25, -0.16, 0.22916666666667
48467, 0.22916666666667, -0.16, 0.25
48468, 0.25, -0.18, 0.25
48469, 0.25, -0.02, 0.29166666666667
48470, 0.25, -0.04, 0.27083333333333
48471, 0.22916666666667, -0.04, 0.29166666666667
48472, 0.25, -0.06, 0.29166666666667
48473, 0.25, -0.08, 0.27083333333333
48474, 0.22916666666667, -0.08, 0.29166666666667
48475, 0.25, -0.1, 0.29166666666667
48476, 0.25, -0.12, 0.27083333333333
48477, 0.22916666666667, -0.12, 0.29166666666667
48478, 0.25, -0.14, 0.29166666666667
48479, 0.25, -0.16, 0.27083333333333
48480, 0.22916666666667, -0.16, 0.29166666666667
48481, 0.25, -0.18, 0.29166666666667
48482, 0.25, -0.02, 0.33333333333333
48483, 0.25, -0.04, 0.3125
48484, 0.22916666666667, -0.04, 0.33333333333333
48485, 0.25, -0.06, 0.33333333333333
48486, 0.25, -0.08, 0.3125
48487, 0.22916666666667, -0.08, 0.33333333333333
48488, 0.25, -0.1, 0.33333333333333
48489, 0.25, -0.12, 0.3125
48490, 0.22916666666667, -0.12, 0.33333333333333
48491, 0.25, -0.14, 0.33333333333333
48492, 0.25, -0.16, 0.3125
48493, 0.22916666666667, -0.16, 0.33333333333333
48494, 0.25, -0.18, 0.33333333333333
48495, 0.25, -0.02, 0.375
48496, 0.25, -0.04, 0.35416666666667
48497, 0.22916666666667, -0.04, 0.375
48498, 0.25, -0.06, 0.375
48499, 0.25, -0.08, 0.35416666666667
48500, 0.22916666666667, -0.08, 0.375
48501, 0.25, -0.1, 0.375
48502, 0.25, -0.12, 0.35416666666667
48503, 0.22916666666667, -0.12, 0.375
48504, 0.25, -0.14, 0.375
48505, 0.25, -0.16, 0.35416666666667
48506, 0.22916666666667, -0.16, 0.375
48507, 0.25, -0.18, 0.375
48508, 0.25, -0.02, 0.41666666666667
48509, 0.25, -0.04, 0.39583333333333
48510, 0.22916666666667, -0.04, 0.41666666666667
48511, 0.25, -0.06, 0.41666666666667
48512, 0.25, -0.08, 0.39583333333333
48513, 0.22916666666667, -0.08, 0.41666666666667
48514, 0.25, -0.1, 0.41666666666667
48515, 0.25, -0.12, 0.39583333333333
48516, 0.22916666666667, -0.12, 0.41666666666667
48517, 0.25, -0.14, 0.41666666666667
48518, 0.25, -0.16, 0.39583333333333
48519, 0.22916666666667, -0.16, 0.41666666666667
48520, 0.25, -0.18, 0.41666666666667
48521, 0.25, -0.02, 0.45833333333333
48522, 0.25, -0.04, 0.4375
48523, 0.22916666666667, -0.04, 0.45833333333333
48524, 0.25, -0.06, 0.45833333333333
48525, 0.25, -0.08, 0.4375
48526, 0.22916666666667, -0.08, 0.45833333333333
48527, 0.25, -0.1, 0.45833333333333
48528, 0.25, -0.12, 0.4375
48529, 0.22916666666667, -0.12, 0.45833333333333
48530, 0.25, -0.14, 0.45833333333333
48531, 0.25, -0.16, 0.4375
48532, 0.22916666666667, -0.16, 0.45833333333333
48533, 0.25, -0.18, 0.45833333333333
48534, 0.25, -0.04, 0.47916666666667
48535, 0.25, -0.08, 0.47916666666667
48536, 0.25, -0.12, 0.47916666666667
48537, 0.25, -0.16, 0.47916666666667
48538, 0.29166666666667, -0.02, 0.041666666666667
48539, 0.29166666666667, -0.04, 0.020833333333333
48540, 0.27083333333333, -0.04, 0.041666666666667
48541, 0.29166666666667, -0.06, 0.041666666666667
48542, 0.29166666666667, -0.08, 0.020833333333333
48543, 0.27083333333333, -0.08, 0.041666666666667
48544, 0.29166666666667, -0.1, 0.041666666666667
48545, 0.29166666666667, -0.12, 0.020833333333333
48546, 0.27083333333333, -0.12, 0.041666666666667
48547, 0.29166666666667, -0.14, 0.041666666666667
48548, 0.29166666666667, -0.16, 0.020833333333333
48549, 0.27083333333333, -0.16, 0.041666666666667
48550, 0.29166666666667, -0.18, 0.041666666666667
48551, 0.29166666666667, -0.02, 0.083333333333333
48552, 0.29166666666667, -0.04, 0.0625
48553, 0.27083333333333, -0.04, 0.083333333333333
48554, 0.29166666666667, -0.06, 0.083333333333333
48555, 0.29166666666667, -0.08, 0.0625
48556, 0.27083333333333, -0.08, 0.083333333333333
48557, 0.29166666666667, -0.1, 0.083333333333333
48558, 0.29166666666667, -0.12, 0.0625
48559, 0.27083333333333, -0.12, 0.083333333333333
48560, 0.29166666666667, -0.14, 0.083333333333333
48561, 0.29166666666667, -0.16, 0.0625
48562, 0.27083333333333, -0.16, 0.083333333333333
48563, 0.29166666666667, -0.18, 0.083333333333333
48564, 0.29166666666667, -0.02, 0.125
48565, 0.29166666666667, -0.04, 0.10416666666667
48566, 0.27083333333333, -0.04, 0.125
48567, 0.29166666666667, -0.06, 0.125
48568, 0.29166666666667, -0.08, 0.10416666666667
48569, 0.27083333333333, -0.08, 0.125
48570, 0.29166666666667, -0.1, 0.125
48571, 0.29166666666667, -0.12, 0.10416666666667
48572, 0.27083333333333, -0.12, 0.125
48573, 0.29166666666667, -0.14, 0.125
48574, 0.29166666666667, -0.16, 0.10416666666667
48575, 0.27083333333333, -0.16, 0.125
48576, 0.29166666666667, -0.18, 0.125
48577, 0.29166666666667, -0.02, 0.16666666666667
48578, 0.29166666666667, -0.04, 0.14583333333333
48579, 0.27083333333333, -0.04, 0.16666666666667
48580, 0.29166666666667, -0.06, 0.16666666666667
48581, 0.29166666666667, -0.08, 0.14583333333333
48582, 0.27083333333333, -0.08, 0.16666666666667
48583, 0.29166666666667, -0.1, 0.16666666666667
48584, 0.29166666666667, -0.12, 0.14583333333333
48585, 0.27083333333333, -0.12, 0.16666666666667
48586, 0.29166666666667, -0.14, 0.16666666666667
48587, 0.29166666666667, -0.16, 0.14583333333333
48588, 0.27083333333333, -0.16, 0.16666666666667
48589, 0.29166666666667, -0.18, 0.16666666666667
48590, 0.29166666666667, -0.02, 0.20833333333333
48591, 0.29166666666667, -0.04, 0.1875
48592, 0.27083333333333, -0.04, 0.20833333333333
48593, 0.29166666666667, -0.06, 0.20833333333333
48594, 0.29166666666667, -0.08, 0.1875
48595, 0.27083333333333, -0.08, 0.20833333333333
48596, 0.29166666666667, -0.1, 0.20833333333333
48597, 0.29166666666667, -0.12, 0.1875
48598, 0.27083333333333, -0.12, 0.20833333333333
48599, 0.29166666666667, -0.14, 0.20833333333333
48600, 0.29166666666667, -0.16, 0.1875
48601, 0.27083333333333, -0.16, 0.20833333333333
48602, 0.29166666666667, -0.18, 0.20833333333333
48603, 0.29166666666667, -0.02, 0.25
48604, 0.29166666666667, -0.04, 0.22916666666667
48605, 0.27083333333333, -0.04, 0.25
48606, 0.29166666666667, -0.06, 0.25
48607, 0.29166666666667, -0.08, 0.22916666666667
48608, 0.27083333333333, -0.08, 0.25
48609, 0.29166666666667, -0.1, 0.25
48610, 0.29166666666667, -0.12, 0.22916666666667
48611, 0.27083333333333, -0.12, 0.25
48612, 0.29166666666667, -0.14, 0.25
48613, 0.29166666666667, -0.16, 0.22916666666667
48614, 0.27083333333333, -0.16, 0.25
48615, 0.29166666666667, -0.18, 0.25
48616, 0.29166666666667, -0.02, 0.29166666666667
48617, 0.29166666666667, -0.04, 0.27083333333333
48618, 0.27083333333333, -0.04, 0.29166666666667
48619, 0.29166666666667, -0.06, 0.29166666666667
48620, 0.29166666666667, -0.08, 0.27083333333333
48621, 0.27083333333333, -0.08, 0.29166666666667
48622, 0.29166666666667, -0.1, 0.29166666666667
48623, 0.29166666666667, -0.12, 0.27083333333333
48624, 0.27083333333333, -0.12, 0.29166666666667
48625, 0.29166666666667, -0.14, 0.29166666666667
48626, 0.29166666666667, -0.16, 0.27083333333333
48627, 0.27083333333333, -0.16, 0.29166666666667
48628, 0.29166666666667, -0.18, 0.29166666666667
48629, 0.29166666666667, -0.02, 0.33333333333333
48630, 0.29166666666667, -0.04, 0.3125
48631, 0.27083333333333, -0.04, 0.33333333333333
48632, 0.29166666666667, -0.06, 0.33333333333333
48633, 0.29166666666667, -0.08, 0.3125
48634, 0.27083333333333, -0.08, 0.33333333333333
48635, 0.29166666666667, -0.1, 0.33333333333333
48636, 0.29166666666667, -0.12, 0.3125
48637, 0.27083333333333, -0.12, 0.33333333333333
48638, 0.29166666666667, -0.14, 0.33333333333333
48639, 0.29166666666667, -0.16, 0.3125
48640, 0.27083333333333, -0.16, 0.33333333333333
48641, 0.29166666666667, -0.18, 0.33333333333333
48642, 0.29166666666667, -0.02, 0.375
48643, 0.29166666666667, -0.04, 0.35416666666667
48644, 0.27083333333333, -0.04, 0.375
48645, 0.29166666666667, -0.06, 0.375
48646, 0.29166666666667, -0.08, 0.35416666666667
48647, 0.27083333333333, -0.08, 0.375
48648, 0.29166666666667, -0.1, 0.375
48649, 0.29166666666667, -0.12, 0.35416666666667
48650, 0.27083333333333, -0.12, 0.375
48651, 0.29166666666667, -0.14, 0.375
48652, 0.29166666666667, -0.16, 0.35416666666667
48653, 0.27083333333333, -0.16, 0.375
48654, 0.29166666666667, -0.18, 0.375
48655, 0.29166666666667, -0.02, 0.41666666666667
48656, 0.29166666666667, -0.04, 0.39583333333333
48657, 0.27083333333333, -0.04, 0.41666666666667
48658, 0.29166666666667, -0.06, 0.41666666666667
48659, 0.29166666666667, -0.08, 0.39583333333333
48660, 0.27083333333333, -0.08, 0.41666666666667
48661, 0.29166666666667, -0.1, 0.41666666666667
48662, 0.29166666666667, -0.12, 0.39583333333333
48663, 0.27083333333333, -0.12, 0.41666666666667
48664, 0.29166666666667, -0.14, 0.41666666666667
48665, 0.29166666666667, -0.16, 0.39583333333333
48666, 0.27083333333333, -0.16, 0.41666666666667
48667, 0.29166666666667, -0.18, 0.41666666666667
48668, 0.29166666666667, -0.02, 0.45833333333333
48669, 0.29166666666667, -0.04, 0.4375
48670, 0.27083333333333, -0.04, 0.45833333333333
48671, 0.29166666666667, -0.06, 0.45833333333333
48672, 0.29166666666667, -0.08, 0.4375
48673, 0.27083333333333, -0.08, 0.45833333333333
48674, 0.29166666666667, -0.1, 0.45833333333333
48675, 0.29166666666667, -0.12, 0.4375
48676, 0.27083333333333, -0.12, 0.45833333333333
48677, 0.29166666666667, -0.14, 0.45833333333333
48678, 0.29166666666667, -0.16, 0.4375
48679, 0.27083333333333, -0.16, 0.45833333333333
48680, 0.29166666666667, -0.18, 0.45833333333333
48681, 0.29166666666667, -0.04, 0.47916666666667
48682, 0.29166666666667, -0.08, 0.47916666666667
48683, 0.29166666666667, -0.12, 0.47916666666667
48684, 0.29166666666667, -0.16, 0.47916666666667
48685, 0.33333333333333, -0.02, 0.041666666666667
48686, 0.33333333333333, -0.04, 0.020833333333333
48687, 0.3125, -0.04, 0.041666666666667
48688, 0.33333333333333, -0.06, 0.041666666666667
48689, 0.33333333333333, -0.08, 0.020833333333333
48690, 0.3125, -0.08, 0.041666666666667
48691, 0.33333333333333, -0.1, 0.041666666666667
48692, 0.33333333333333, -0.12, 0.020833333333333
48693, 0.3125, -0.12, 0.041666666666667
48694, 0.33333333333333, -0.14, 0.041666666666667
48695, 0.33333333333333, -0.16, 0.020833333333333
48696, 0.3125, -0.16, 0.041666666666667
48697, 0.33333333333333, -0.18, 0.041666666666667
48698, 0.33333333333333, -0.02, 0.083333333333333
48699, 0.33333333333333, -0.04, 0.0625
48700, 0.3125, -0.04, 0.083333333333333
48701, 0.33333333333333, -0.06, 0.083333333333333
48702, 0.33333333333333, -0.08, 0.0625
48703, 0.3125, -0.08, 0.083333333333333
48704, 0.33333333333333, -0.1, 0.083333333333333
48705, 0.33333333333333, -0.12, 0.0625
48706, 0.3125, -0.12, 0.083333333333333
48707, 0.33333333333333, -0.14, 0.083333333333333
48708, 0.33333333333333, -0.16, 0.0625
48709, 0.3125, -0.16, 0.083333333333333
48710, 0.33333333333333, -0.18, 0.083333333333333
48711, 0.33333333333333, -0.02, 0.125
48712, 0.33333333333333, -0.04, 0.10416666666667
48713, 0.3125, -0.04, 0.125
48714, 0.33333333333333, -0.06, 0.125
48715, 0.33333333333333, -0.08, 0.10416666666667
48716, 0.3125, -0.08, 0.125
48717, 0.33333333333333, -0.1, 0.125
48718, 0.33333333333333, -0.12, 0.10416666666667
48719, 0.3125, -0.12, 0.125
48720, 0.33333333333333, -0.14, 0.125
48721, 0.33333333333333, -0.16, 0.10416666666667
48722, 0.3125, -0.16, 0.125
48723, 0.33333333333333, -0.18, 0.125
48724, 0.33333333333333, -0.02, 0.16666666666667
48725, 0.33333333333333, -0.04, 0.14583333333333
48726, 0.3125, -0.04, 0.16666666666667
48727, 0.33333333333333, -0.06, 0.16666666666667
48728, 0.33333333333333, -0.08, 0.14583333333333
48729, 0.3125, -0.08, 0.16666666666667
48730, 0.33333333333333, -0.1, 0.16666666666667
48731, 0.33333333333333, -0.12, 0.14583333333333
48732, 0.3125, -0.12, 0.16666666666667
48733, 0.33333333333333, -0.14, 0.16666666666667
48734, 0.33333333333333, -0.16, 0.14583333333333
48735, 0.3125, -0.16, 0.16666666666667
48736, 0.33333333333333, -0.18, 0.16666666666667
48737, 0.33333333333333, -0.02, 0.20833333333333
48738, 0.33333333333333, -0.04, 0.1875
48739, 0.3125, -0.04, 0.20833333333333
48740, 0.33333333333333, -0.06, 0.20833333333333
48741, 0.33333333333333, -0.08, 0.1875
48742, 0.3125, -0.08, 0.20833333333333
48743, 0.33333333333333, -0.1, 0.20833333333333
48744, 0.33333333333333, -0.12, 0.1875
48745, 0.3125, -0.12, 0.20833333333333
48746, 0.33333333333333, -0.14, 0.20833333333333
48747, 0.33333333333333, -0.16, 0.1875
48748, 0.3125, -0.16, 0.20833333333333
48749, 0.33333333333333, -0.18, 0.20833333333333
48750, 0.33333333333333, -0.02, 0.25
48751, 0.33333333333333, -0.04, 0.22916666666667
48752, 0.3125, -0.04, 0.25
48753, 0.33333333333333, -0.06, 0.25
48754, 0.33333333333333, -0.08, 0.22916666666667
48755, 0.3125, -0.08, 0.25
48756, 0.33333333333333, -0.1, 0.25
48757, 0.33333333333333, -0.12, 0.22916666666667
48758, 0.3125, -0.12, 0.25
48759, 0.33333333333333, -0.14, 0.25
48760, 0.33333333333333, -0.16, 0.22916666666667
48761, 0.3125, -0.16, 0.25
48762, 0.33333333333333, -0.18, 0.25
48763, 0.33333333333333, -0.02, 0.29166666666667
48764, 0.33333333333333, -0.04, 0.27083333333333
48765, 0.3125, -0.04, 0.29166666666667
48766, 0.33333333333333, -0.06, 0.29166666666667
48767, 0.33333333333333, -0.08, 0.27083333333333
48768, 0.3125, -0.08, 0.29166666666667
48769, 0.33333333333333, -0.1, 0.29166666666667
48770, 0.33333333333333, -0.12, 0.27083333333333
48771, 0.3125, -0.12, 0.29166666666667
48772, 0.33333333333333, -0.14, 0.29166666666667
48773, 0.33333333333333, -0.16, 0.27083333333333
48774, 0.3125, -0.16, 0.29166666666667
48775, 0.33333333333333, -0.18, 0.29166666666667
48776, 0.33333333333333, -0.02, 0.33333333333333
48777, 0.33333333333333, -0.04, 0.3125
48778, 0.3125, -0.04, 0.33333333333333
48779, 0.33333333333333, -0.06, 0.33333333333333
48780, 0.33333333333333, -0.08, 0.3125
48781, 0.3125, -0.08, 0.33333333333333
48782, 0.33333333333333, -0.1, 0.33333333333333
48783, 0.33333333333333, -0.12, 0.3125
48784, 0.3125, -0.12, 0.33333333333333
48785, 0.33333333333333, -0.14, 0.33333333333333
48786, 0.33333333333333, -0.16, 0.3125
48787, 0.3125, -0.16, 0.33333333333333
48788, 0.33333333333333, -0.18, 0.33333333333333
48789, 0.33333333333333, -0.02, 0.375
48790, 0.33333333333333, -0.04, 0.35416666666667
48791, 0.3125, -0.04, 0.375
48792, 0.33333333333333, -0.06, 0.375
48793, 0.33333333333333, -0.08, 0.35416666666667
48794, 0.3125, -0.08, 0.375
48795, 0.33333333333333, -0.1, 0.375
48796, 0.33333333333333, -0.12, 0.35416666666667
48797, 0.3125, -0.12, 0.375
48798, 0.33333333333333, -0.14, 0.375
48799, 0.33333333333333, -0.16, 0.35416666666667
48800, 0.3125, -0.16, 0.375
48801, 0.33333333333333, -0.18, 0.375
48802, 0.33333333333333, -0.02, 0.41666666666667
48803, 0.33333333333333, -0.04, 0.39583333333333
48804, 0.3125, -0.04, 0.41666666666667
48805, 0.33333333333333, -0.06, 0.41666666666667
48806, 0.33333333333333, -0.08, 0.39583333333333
48807, 0.3125, -0.08, 0.41666666666667
48808, 0.33333333333333, -0.1, 0.41666666666667
48809, 0.33333333333333, -0.12, 0.39583333333333
48810, 0.3125, -0.12, 0.41666666666667
48811, 0.33333333333333, -0.14, 0.41666666666667
48812, 0.33333333333333, -0.16, 0.39583333333333
48813, 0.3125, -0.16, 0.41666666666667
48814, 0.33333333333333, -0.18, 0.41666666666667
48815, 0.33333333333333, -0.02, 0.45833333333333
48816, 0.33333333333333, -0.04, 0.4375
48817, 0.3125, -0.04, 0.45833333333333
48818, 0.33333333333333, -0.06, 0.45833333333333
48819, 0.33333333333333, -0.08, 0.4375
48820, 0.3125, -0.08, 0.45833333333333
48821, 0.33333333333333, -0.1, 0.45833333333333
48822, 0.33333333333333, -0.12, 0.4375
48823, 0.3125, -0.12, 0.45833333333333
48824, 0.33333333333333, -0.14, 0.45833333333333
48825, 0.33333333333333, -0.16, 0.4375
48826, 0.3125, -0.16, 0.45833333333333
48827, 0.33333333333333, -0.18, 0.45833333333333
48828, 0.33333333333333, -0.04, 0.47916666666667
48829, 0.33333333333333, -0.08, 0.47916666666667
48830, 0.33333333333333, -0.12, 0.47916666666667
48831, 0.33333333333333, -0.16, 0.47916666666667
48832, 0.375, -0.02, 0.041666666666667
48833, 0.375, -0.04, 0.020833333333333
48834, 0.35416666666667, -0.04, 0.041666666666667
48835, 0.375, -0.06, 0.041666666666667
48836, 0.375, -0.08, 0.020833333333333
48837, 0.35416666666667, -0.08, 0.041666666666667
48838, 0.375, -0.1, 0.041666666666667
48839, 0.375, -0.12, 0.020833333333333
48840, 0.35416666666667, -0.12, 0.041666666666667
48841, 0.375, -0.14, 0.041666666666667
48842, 0.375, -0.16, 0.020833333333333
48843, 0.35416666666667, -0.16, 0.041666666666667
48844, 0.375, -0.18, 0.041666666666667
48845, 0.375, -0.02, 0.083333333333333
48846, 0.375, -0.04, 0.0625
48847, 0.35416666666667, -0.04, 0.083333333333333
48848, 0.375, -0.06, 0.083333333333333
48849, 0.375, -0.08, 0.0625
48850, 0.35416666666667, -0.08, 0.083333333333333
48851, 0.375, -0.1, 0.083333333333333
48852, 0.375, -0.12, 0.0625
48853, 0.35416666666667, -0.12, 0.083333333333333
48854, 0.375, -0.14, 0.083333333333333
48855, 0.375, -0.16, 0.0625
48856, 0.35416666666667, -0.16, 0.083333333333333
48857, 0.375, -0.18, 0.083333333333333
48858, 0.375, -0.02, 0.125
48859, 0.375, -0.04, 0.10416666666667
48860, 0.35416666666667, -0.04, 0.125
48861, 0.375, -0.06, 0.125
48862, 0.375, -0.08, 0.10416666666667
48863, 0.35416666666667, -0.08, 0.125
48864, 0.375, -0.1, 0.125
48865, 0.375, -0.12, 0.10416666666667
48866, 0.35416666666667, -0.12, 0.125
48867, 0.375, -0.14, 0.125
48868, 0.375, -0.16, 0.10416666666667
48869, 0.35416666666667, -0.16, 0.125
48870, 0.375, -0.18, 0.125
48871, 0.375, -0.02, 0.16666666666667
48872, 0.375, -0.04, 0.14583333333333
48873, 0.35416666666667, -0.04, 0.16666666666667
48874, 0.375, -0.06, 0.16666666666667
48875, 0.375, -0.08, 0.14583333333333
48876, 0.35416666666667, -0.08, 0.16666666666667
48877, 0.375, -0.1, 0.16666666666667
48878, 0.375, -0.12, 0.14583333333333
48879, 0.35416666666667, -0.12, 0.16666666666667
48880, 0.375, -0.14, 0.16666666666667
48881, 0.375, -0.16, 0.14583333333333
48882, 0.35416666666667, -0.16, 0.16666666666667
48883, 0.375, -0.18, 0.16666666666667
48884, 0.375, -0.02, 0.20833333333333
48885, 0.375, -0.04, 0.1875
48886, 0.35416666666667, -0.04, 0.20833333333333
48887, 0.375, -0.06, 0.20833333333333
48888, 0.375, -0.08, 0.1875
48889, 0.35416666666667, -0.08, 0.20833333333333
48890, 0.375, -0.1, 0.20833333333333
48891, 0.375, -0.12, 0.1875
48892, 0.35416666666667, -0.12, 0.20833333333333
48893, 0.375, -0.14, 0.20833333333333
48894, 0.375, -0.16, 0.1875
48895, 0.35416666666667, -0.16, 0.20833333333333
48896, 0.375, -0.18, 0.20833333333333
48897, 0.375, -0.02, 0.25
48898, 0.375, -0.04, 0.22916666666667
48899, 0.35416666666667, -0.04, 0.25
48900, 0.375, -0.06, 0.25
48901, 0.375, -0.08, 0.22916666666667
48902, 0.35416666666667, -0.08, 0.25
48903, 0.375, -0.1, 0.25
48904, 0.375, -0.12, 0.22916666666667
48905, 0.35416666666667, -0.12, 0.25
48906, 0.375, -0.14, 0.25
48907, 0.375, -0.16, 0.22916666666667
48908, 0.35416666666667, -0.16, 0.25
48909, 0.375, -0.18, 0.25
48910, 0.375, -0.02, 0.29166666666667
48911, 0.375, -0.04, 0.27083333333333
48912, 0.35416666666667, -0.04, 0.29166666666667
48913, 0.375, -0.06, 0.29166666666667
48914, 0.375, -0.08, 0.27083333333333
48915, 0.35416666666667, -0.08, 0.29166666666667
48916, 0.375, -0.1, 0.29166666666667
48917, 0.375, -0.12, 0.27083333333333
48918, 0.35416666666667, -0.12, 0.29166666666667
48919, 0.375, -0.14, 0.29166666666667
48920, 0.375, -0.16, 0.27083333333333
48921, 0.35416666666667, -0.16, 0.29166666666667
48922, 0.375, -0.18, 0.29166666666667
48923, 0.375, -0.02, 0.33333333333333
48924, 0.375, -0.04, 0.3125
48925, 0.35416666666667, -0.04, 0.33333333333333
48926, 0.375, -0.06, 0.33333333333333
48927, 0.375, -0.08, 0.3125
48928, 0.35416666666667, -0.08, 0.33333333333333
48929, 0.375, -0.1, 0.33333333333333
48930, 0.375, -0.12, 0.3125
48931, 0.35416666666667, -0.12, 0.33333333333333
48932, 0.375, -0.14, 0.33333333333333
48933, 0.375, -0.16, 0.3125
48934, 0.35416666666667, -0.16, 0.33333333333333
48935, 0.375, -0.18, 0.33333333333333
48936, 0.375, -0.02, 0.375
48937, 0.375, -0.04, 0.35416666666667
48938, 0.35416666666667, -0.04, 0.375
48939, 0.375, -0.06, 0.375
48940, 0.375, -0.08, 0.35416666666667
48941, 0.35416666666667, -0.08, 0.375
48942, 0.375, -0.1, 0.375
48943, 0.375, -0.12, 0.35416666666667
48944, 0.35416666666667, -0.12, 0.375
48945, 0.375, -0.14, 0.375
48946, 0.375, -0.16, 0.35416666666667
48947, 0.35416666666667, -0.16, 0.375
48948, 0.375, -0.18, 0.375
48949, 0.375, -0.02, 0.41666666666667
48950, 0.375, -0.04, 0.39583333333333
48951, 0.35416666666667, -0.04, 0.41666666666667
48952, 0.375, -0.06, 0.41666666666667
48953, 0.375, -0.08, 0.39583333333333
48954, 0.35416666666667, -0.08, 0.41666666666667
48955, 0.375, -0.1, 0.41666666666667
48956, 0.375, -0.12, 0.39583333333333
48957, 0.35416666666667, -0.12, 0.41666666666667
48958, 0.375, -0.14, 0.41666666666667
48959, 0.375, -0.16, 0.39583333333333
48960, 0.35416666666667, -0.16, 0.41666666666667
48961, 0.375, -0.18, 0.41666666666667
48962, 0.375, -0.02, 0.45833333333333
48963, 0.375, -0.04, 0.4375
48964, 0.35416666666667, -0.04, 0.45833333333333
48965, 0.375, -0.06, 0.45833333333333
48966, 0.375, -0.08, 0.4375
48967, 0.35416666666667, -0.08, 0.45833333333333
48968, 0.375, -0.1, 0.45833333333333
48969, 0.375, -0.12, 0.4375
48970, 0.35416666666667, -0.12, 0.45833333333333
48971, 0.375, -0.14, 0.45833333333333
48972, 0.375, -0.16, 0.4375
48973, 0.35416666666667, -0.16, 0.45833333333333
48974, 0.375, -0.18, 0.45833333333333
48975, 0.375, -0.04, 0.47916666666667
48976, 0.375, -0.08, 0.47916666666667
48977, 0.375, -0.12, 0.47916666666667
48978, 0.375, -0.16, 0.47916666666667
48979, 0.41666666666667, -0.02, 0.041666666666667
48980, 0.41666666666667, -0.04, 0.020833333333333
48981, 0.39583333333333, -0.04, 0.041666666666667
48982, 0.41666666666667, -0.06, 0.041666666666667
48983, 0.41666666666667, -0.08, 0.020833333333333
48984, 0.39583333333333, -0.08, 0.041666666666667
48985, 0.41666666666667, -0.1, 0.041666666666667
48986, 0.41666666666667, -0.12, 0.020833333333333
48987, 0.39583333333333, -0.12, 0.041666666666667
48988, 0.41666666666667, -0.14, 0.041666666666667
48989, 0.41666666666667, -0.16, 0.020833333333333
48990, 0.39583333333333, -0.16, 0.041666666666667
48991, 0.41666666666667, -0.18, 0.041666666666667
48992, 0.41666666666667, -0.02, 0.083333333333333
48993, 0.41666666666667, -0.04, 0.0625
48994, 0.39583333333333, -0.04, 0.083333333333333
48995, 0.41666666666667, -0.06, 0.083333333333333
48996, 0.41666666666667, -0.08, 0.0625
48997, 0.39583333333333, -0.08, 0.083333333333333
48998, 0.41666666666667, -0.1, 0.083333333333333
48999, 0.41666666666667, -0.12, 0.0625
49000, 0.39583333333333, -0.12, 0.083333333333333
49001, 0.41666666666667, -0.14, 0.083333333333333
49002, 0.41666666666667, -0.16, 0.0625
49003, 0.39583333333333, -0.16, 0.083333333333333
49004, 0.41666666666667, -0.18, 0.083333333333333
49005, 0.41666666666667, -0.02, 0.125
49006, 0.41666666666667, -0.04, 0.10416666666667
49007, 0.39583333333333, -0.04, 0.125
49008, 0.41666666666667, -0.06, 0.125
49009, 0.41666666666667, -0.08, 0.10416666666667
49010, 0.39583333333333, -0.08, 0.125
49011, 0.41666666666667, -0.1, 0.125
49012, 0.41666666666667, -0.12, 0.10416666666667
49013, 0.39583333333333, -0.12, 0.125
49014, 0.41666666666667, -0.14, 0.125
49015, 0.41666666666667, -0.16, 0.10416666666667
49016, 0.39583333333333, -0.16, 0.125
49017, 0.41666666666667, -0.18, 0.125
49018, 0.41666666666667, -0.02, 0.16666666666667
49019, 0.41666666666667, -0.04, 0.14583333333333
49020, 0.39583333333333, -0.04, 0.16666666666667
49021, 0.41666666666667, -0.06, 0.16666666666667
49022, 0.41666666666667, -0.08, 0.14583333333333
49023, 0.39583333333333, -0.08, 0.16666666666667
49024, 0.41666666666667, -0.1, 0.16666666666667
49025, 0.41666666666667, -0.12, 0.14583333333333
49026, 0.39583333333333, -0.12, 0.16666666666667
49027, 0.41666666666667, -0.14, 0.16666666666667
49028, 0.41666666666667, -0.16, 0.14583333333333
49029, 0.39583333333333, -0.16, 0.16666666666667
49030, 0.41666666666667, -0.18, 0.16666666666667
49031, 0.41666666666667, -0.02, 0.20833333333333
49032, 0.41666666666667, -0.04, 0.1875
49033, 0.39583333333333, -0.04, 0.20833333333333
49034, 0.41666666666667, -0.06, 0.20833333333333
49035, 0.41666666666667, -0.08, 0.1875
49036, 0.39583333333333, -0.08, 0.20833333333333
49037, 0.41666666666667, -0.1, 0.20833333333333
49038, 0.41666666666667, -0.12, 0.1875
49039, 0.39583333333333, -0.12, 0.20833333333333
49040, 0.41666666666667, -0.14, 0.20833333333333
49041, 0.41666666666667, -0.16, 0.1875
49042, 0.39583333333333, -0.16, 0.20833333333333
49043, 0.41666666666667, -0.18, 0.20833333333333
49044, 0.41666666666667, -0.02, 0.25
49045, 0.41666666666667, -0.04, 0.22916666666667
49046, 0.39583333333333, -0.04, 0.25
49047, 0.41666666666667, -0.06, 0.25
49048, 0.41666666666667, -0.08, 0.22916666666667
49049, 0.39583333333333, -0.08, 0.25
49050, 0.41666666666667, -0.1, 0.25
49051, 0.41666666666667, -0.12, 0.22916666666667
49052, 0.39583333333333, -0.12, 0.25
49053, 0.41666666666667, -0.14, 0.25
49054, 0.41666666666667, -0.16, 0.22916666666667
49055, 0.39583333333333, -0.16, 0.25
49056, 0.41666666666667, -0.18, 0.25
49057, 0.41666666666667, -0.02, 0.29166666666667
49058, 0.41666666666667, -0.04, 0.27083333333333
49059, 0.39583333333333, -0.04, 0.29166666666667
49060, 0.41666666666667, -0.06, 0.29166666666667
49061, 0.41666666666667, -0.08, 0.27083333333333
49062, 0.39583333333333, -0.08, 0.29166666666667
49063, 0.41666666666667, -0.1, 0.29166666666667
49064, 0.41666666666667, -0.12, 0.27083333333333
49065, 0.39583333333333, -0.12, 0.29166666666667
49066, 0.41666666666667, -0.14, 0.29166666666667
49067, 0.41666666666667, -0.16, 0.27083333333333
49068, 0.39583333333333, -0.16, 0.29166666666667
49069, 0.41666666666667, -0.18, 0.29166666666667
49070, 0.41666666666667, -0.02, 0.33333333333333
49071, 0.41666666666667, -0.04, 0.3125
49072, 0.39583333333333, -0.04, 0.33333333333333
49073, 0.41666666666667, -0.06, 0.33333333333333
49074, 0.41666666666667, -0.08, 0.3125
49075, 0.39583333333333, -0.08, 0.33333333333333
49076, 0.41666666666667, -0.1, 0.33333333333333
49077, 0.41666666666667, -0.12, 0.3125
49078, 0.39583333333333, -0.12, 0.33333333333333
49079, 0.41666666666667, -0.14, 0.33333333333333
49080, 0.41666666666667, -0.16, 0.3125
49081, 0.39583333333333, -0.16, 0.33333333333333
49082, 0.41666666666667, -0.18, 0.33333333333333
49083, 0.41666666666667, -0.02, 0.375
49084, 0.41666666666667, -0.04, 0.35416666666667
49085, 0.39583333333333, -0.04, 0.375
49086, 0.41666666666667, -0.06, 0.375
49087, 0.41666666666667, -0.08, 0.35416666666667
49088, 0.39583333333333, -0.08, 0.375
49089, 0.41666666666667, -0.1, 0.375
49090, 0.41666666666667, -0.12, 0.35416666666667
49091, 0.39583333333333, -0.12, 0.375
49092, 0.41666666666667, -0.14, 0.375
49093, 0.41666666666667, -0.16, 0.35416666666667
49094, 0.39583333333333, -0.16, 0.375
49095, 0.41666666666667, -0.18, 0.375
49096, 0.41666666666667, -0.02, 0.41666666666667
49097, 0.41666666666667, -0.04, 0.39583333333333
49098, 0.39583333333333, -0.04, 0.41666666666667
49099, 0.41666666666667, -0.06, 0.41666666666667
49100, 0.41666666666667, -0.08, 0.39583333333333
49101, 0.39583333333333, -0.08, 0.41666666666667
49102, 0.41666666666667, -0.1, 0.41666666666667
49103, 0.41666666666667, -0.12, 0.39583333333333
49104, 0.39583333333333, -0.12, 0.41666666666667
49105, 0.41666666666667, -0.14, 0.41666666666667
49106, 0.41666666666667, -0.16, 0.39583333333333
49107, 0.39583333333333, -0.16, 0.41666666666667
49108, 0.41666666666667, -0.18, 0.41666666666667
49109, 0.41666666666667, -0.02, 0.45833333333333
49110, 0.41666666666667, -0.04, 0.4375
49111, 0.39583333333333, -0.04, 0.45833333333333
49112, 0.41666666666667, -0.06, 0.45833333333333
49113, 0.41666666666667, -0.08, 0.4375
49114, 0.39583333333333, -0.08, 0.45833333333333
49115, 0.41666666666667, -0.1, 0.45833333333333
49116, 0.41666666666667, -0.12, 0.4375
49117, 0.39583333333333, -0.12, 0.45833333333333
49118, 0.41666666666667, -0.14, 0.45833333333333
49119, 0.41666666666667, -0.16, 0.4375
49120, 0.39583333333333, -0.16, 0.45833333333333
49121, 0.41666666666667, -0.18, 0.45833333333333
49122, 0.41666666666667, -0.04, 0.47916666666667
49123, 0.41666666666667, -0.08, 0.47916666666667
49124, 0.41666666666667, -0.12, 0.47916666666667
49125, 0.41666666666667, -0.16, 0.47916666666667
49126, 0.45833333333333, -0.02, 0.041666666666667
49127, 0.45833333333333, -0.04, 0.020833333333333
49128, 0.4375, -0.04, 0.041666666666667
49129, 0.45833333333333, -0.06, 0.041666666666667
49130, 0.45833333333333, -0.08, 0.020833333333333
49131, 0.4375, -0.08, 0.041666666666667
49132, 0.45833333333333, -0.1, 0.041666666666667
49133, 0.45833333333333, -0.12, 0.020833333333333
49134, 0.4375, -0.12, 0.041666666666667
49135, 0.45833333333333, -0.14, 0.041666666666667
49136, 0.45833333333333, -0.16, 0.020833333333333
49137, 0.4375, -0.16, 0.041666666666667
49138, 0.45833333333333, -0.18, 0.041666666666667
49139, 0.45833333333333, -0.02, 0.083333333333333
49140, 0.45833333333333, -0.04, 0.0625
49141, 0.4375, -0.04, 0.083333333333333
49142, 0.45833333333333, -0.06, 0.083333333333333
49143, 0.45833333333333, -0.08, 0.0625
49144, 0.4375, -0.08, 0.083333333333333
49145, 0.45833333333333, -0.1, 0.083333333333333
49146, 0.45833333333333, -0.12, 0.0625
49147, 0.4375, -0.12, 0.083333333333333
49148, 0.45833333333333, -0.14, 0.083333333333333
49149, 0.45833333333333, -0.16, 0.0625
49150, 0.4375, -0.16, 0.083333333333333
49151, 0.45833333333333, -0.18, 0.083333333333333
49152, 0.45833333333333, -0.02, 0.125
49153, 0.45833333333333, -0.04, 0.10416666666667
49154, 0.4375, -0.04, 0.125
49155, 0.45833333333333, -0.06, 0.125
49156, 0.45833333333333, -0.08, 0.10416666666667
49157, 0.4375, -0.08, 0.125
49158, 0.45833333333333, -0.1, 0.125
49159, 0.45833333333333, -0.12, 0.10416666666667
49160, 0.4375, -0.12, 0.125
49161, 0.45833333333333, -0.14, 0.125
49162, 0.45833333333333, -0.16, 0.10416666666667
49163, 0.4375, -0.16, 0.125
49164, 0.45833333333333, -0.18, 0.125
49165, 0.45833333333333, -0.02, 0.16666666666667
49166, 0.45833333333333, -0.04, 0.14583333333333
49167, 0.4375, -0.04, 0.16666666666667
49168, 0.45833333333333, -0.06, 0.16666666666667
49169, 0.45833333333333, -0.08, 0.14583333333333
49170, 0.4375, -0.08, 0.16666666666667
49171, 0.45833333333333, -0.1, 0.16666666666667
49172, 0.45833333333333, -0.12, 0.14583333333333
49173, 0.4375, -0.12, 0.16666666666667
49174, 0.45833333333333, -0.14, 0.16666666666667
49175, 0.45833333333333, -0.16, 0.14583333333333
49176, 0.4375, -0.16, 0.16666666666667
49177, 0.45833333333333, -0.18, 0.16666666666667
49178, 0.45833333333333, -0.02, 0.20833333333333
49179, 0.45833333333333, -0.04, 0.1875
49180, 0.4375, -0.04, 0.20833333333333
49181, 0.45833333333333, -0.06, 0.20833333333333
49182, 0.45833333333333, -0.08, 0.1875
49183, 0.4375, -0.08, 0.20833333333333
49184, 0.45833333333333, -0.1, 0.20833333333333
49185, 0.45833333333333, -0.12, 0.1875
49186, 0.4375, -0.12, 0.20833333333333
49187, 0.45833333333333, -0.14, 0.20833333333333
49188, 0.45833333333333, -0.16, 0.1875
49189, 0.4375, -0.16, 0.20833333333333
49190, 0.45833333333333, -0.18, 0.20833333333333
49191, 0.45833333333333, -0.02, 0.25
49192, 0.45833333333333, -0.04, 0.22916666666667
49193, 0.4375, -0.04, 0.25
49194, 0.45833333333333, -0.06, 0.25
49195, 0.45833333333333, -0.08, 0.22916666666667
49196, 0.4375, -0.08, 0.25
49197, 0.45833333333333, -0.1, 0.25
49198, 0.45833333333333, -0.12, 0.22916666666667
49199, 0.4375, -0.12, 0.25
49200, 0.45833333333333, -0.14, 0.25
49201, 0.45833333333333, -0.16, 0.22916666666667
49202, 0.4375, -0.16, 0.25
49203, 0.45833333333333, -0.18, 0.25
49204, 0.45833333333333, -0.02, 0.29166666666667
49205, 0.45833333333333, -0.04, 0.27083333333333
49206, 0.4375, -0.04, 0.29166666666667
49207, 0.45833333333333, -0.06, 0.29166666666667
49208, 0.45833333333333, -0.08, 0.27083333333333
49209, 0.4375, -0.08, 0.29166666666667
49210, 0.45833333333333, -0.1, 0.29166666666667
49211, 0.45833333333333, -0.12, 0.27083333333333
49212, 0.4375, -0.12, 0.29166666666667
49213, 0.45833333333333, -0.14, 0.29166666666667
49214, 0.45833333333333, -0.16, 0.27083333333333
49215, 0.4375, -0.16, 0.29166666666667
49216, 0.45833333333333, -0.18, 0.29166666666667
49217, 0.45833333333333, -0.02, 0.33333333333333
49218, 0.45833333333333, -0.04, 0.3125
49219, 0.4375, -0.04, 0.33333333333333
49220, 0.45833333333333, -0.06, 0.33333333333333
49221, 0.45833333333333, -0.08, 0.3125
49222, 0.4375, -0.08, 0.33333333333333
49223, 0.45833333333333, -0.1, 0.33333333333333
49224, 0.45833333333333, -0.12, 0.3125
49225, 0.4375, -0.12, 0.33333333333333
49226, 0.45833333333333, -0.14, 0.33333333333333
49227, 0.45833333333333, -0.16, 0.3125
49228, 0.4375, -0.16, 0.33333333333333
49229, 0.45833333333333, -0.18, 0.33333333333333
49230, 0.45833333333333, -0.02, 0.375
49231, 0.45833333333333, -0.04, 0.35416666666667
49232, 0.4375, -0.04, 0.375
49233, 0.45833333333333, -0.06, 0.375
49234, 0.45833333333333, -0.08, 0.35416666666667
49235, 0.4375, -0.08, 0.375
49236, 0.45833333333333, -0.1, 0.375
49237, 0.45833333333333, -0.12, 0.35416666666667
49238, 0.4375, -0.12, 0.375
49239, 0.45833333333333, -0.14, 0.375
49240, 0.45833333333333, -0.16, 0.35416666666667
49241, 0.4375, -0.16, 0.375
49242, 0.45833333333333, -0.18, 0.375
49243, 0.45833333333333, -0.02, 0.41666666666667
49244, 0.45833333333333, -0.04, 0.39583333333333
49245, 0.4375, -0.04, 0.41666666666667
49246, 0.45833333333333, -0.06, 0.41666666666667
49247, 0.45833333333333, -0.08, 0.39583333333333
49248, 0.4375, -0.08, 0.41666666666667
49249, 0.45833333333333, -0.1, 0.41666666666667
49250, 0.45833333333333, -0.12, 0.39583333333333
49251, 0.4375, -0.12, 0.41666666666667
49252, 0.45833333333333, -0.14, 0.41666666666667
49253, 0.45833333333333, -0.16, 0.39583333333333
49254, 0.4375, -0.16, 0.41666666666667
49255, 0.45833333333333, -0.18, 0.41666666666667
49256, 0.45833333333333, -0.02, 0.45833333333333
49257, 0.45833333333333, -0.04, 0.4375
49258, 0.4375, -0.04, 0.45833333333333
49259, 0.45833333333333, -0.06, 0.45833333333333
49260, 0.45833333333333, -0.08, 0.4375
49261, 0.4375, -0.08, 0.45833333333333
49262, 0.45833333333333, -0.1, 0.45833333333333
49263, 0.45833333333333, -0.12, 0.4375
49264, 0.4375, -0.12, 0.45833333333333
49265, 0.45833333333333, -0.14, 0.45833333333333
49266, 0.45833333333333, -0.16, 0.4375
49267, 0.4375, -0.16, 0.45833333333333
49268, 0.45833333333333, -0.18, 0.45833333333333
49269, 0.45833333333333, -0.04, 0.47916666666667
49270, 0.45833333333333, -0.08, 0.47916666666667
49271, 0.45833333333333, -0.12, 0.47916666666667
49272, 0.45833333333333, -0.16, 0.47916666666667
49273, 0.5, -0.02, 0.041666666666667
49274, 0.5, -0.04, 0.020833333333333
49275, 0.47916666666667, -0.04, 0.041666666666667
49276, 0.5, -0.06, 0.041666666666667
49277, 0.5, -0.08, 0.020833333333333
49278, 0.47916666666667, -0.08, 0.041666666666667
49279, 0.5, -0.1, 0.041666666666667
49280, 0.5, -0.12, 0.020833333333333
49281, 0.47916666666667, -0.12, 0.041666666666667
49282, 0.5, -0.14, 0.041666666666667
49283, 0.5, -0.16, 0.020833333333333
49284, 0.47916666666667, -0.16, 0.041666666666667
49285, 0.5, -0.18, 0.041666666666667
49286, 0.5, -0.02, 0.083333333333333
49287, 0.5, -0.04, 0.0625
49288, 0.47916666666667, -0.04, 0.083333333333333
49289, 0.5, -0.06, 0.083333333333333
49290, 0.5, -0.08, 0.0625
49291, 0.47916666666667, -0.08, 0.083333333333333
49292, 0.5, -0.1, 0.083333333333333
49293, 0.5, -0.12, 0.0625
49294, 0.47916666666667, -0.12, 0.083333333333333
49295, 0.5, -0.14, 0.083333333333333
49296, 0.5, -0.16, 0.0625
49297, 0.47916666666667, -0.16, 0.083333333333333
49298, 0.5, -0.18, 0.083333333333333
49299, 0.5, -0.02, 0.125
49300, 0.5, -0.04, 0.10416666666667
49301, 0.47916666666667, -0.04, 0.125
49302, 0.5, -0.06, 0.125
49303, 0.5, -0.08, 0.10416666666667
49304, 0.47916666666667, -0.08, 0.125
49305, 0.5, -0.1, 0.125
49306, 0.5, -0.12, 0.10416666666667
49307, 0.47916666666667, -0.12, 0.125
49308, 0.5, -0.14, 0.125
49309, 0.5, -0.16, 0.10416666666667
49310, 0.47916666666667, -0.16, 0.125
49311, 0.5, -0.18, 0.125
49312, 0.5, -0.02, 0.16666666666667
49313, 0.5, -0.04, 0.14583333333333
49314, 0.47916666666667, -0.04, 0.16666666666667
49315, 0.5, -0.06, 0.16666666666667
49316, 0.5, -0.08, 0.14583333333333
49317, 0.47916666666667, -0.08, 0.16666666666667
49318, 0.5, -0.1, 0.16666666666667
49319, 0.5, -0.12, 0.14583333333333
49320, 0.47916666666667, -0.12, 0.16666666666667
49321, 0.5, -0.14, 0.16666666666667
49322, 0.5, -0.16, 0.14583333333333
49323, 0.47916666666667, -0.16, 0.16666666666667
49324, 0.5, -0.18, 0.16666666666667
49325, 0.5, -0.02, 0.20833333333333
49326, 0.5, -0.04, 0.1875
49327, 0.47916666666667, -0.04, 0.20833333333333
49328, 0.5, -0.06, 0.20833333333333
49329, 0.5, -0.08, 0.1875
49330, 0.47916666666667, -0.08, 0.20833333333333
49331, 0.5, -0.1, 0.20833333333333
49332, 0.5, -0.12, 0.1875
49333, 0.47916666666667, -0.12, 0.20833333333333
49334, 0.5, -0.14, 0.20833333333333
49335, 0.5, -0.16, 0.1875
49336, 0.47916666666667, -0.16, 0.20833333333333
49337, 0.5, -0.18, 0.20833333333333
49338, 0.5, -0.02, 0.25
49339, 0.5, -0.04, 0.22916666666667
49340, 0.47916666666667, -0.04, 0.25
49341, 0.5, -0.06, 0.25
49342, 0.5, -0.08, 0.22916666666667
49343, 0.47916666666667, -0.08, 0.25
49344, 0.5, -0.1, 0.25
49345, 0.5, -0.12, 0.22916666666667
49346, 0.47916666666667, -0.12, 0.25
49347, 0.5, -0.14, 0.25
49348, 0.5, -0.16, 0.22916666666667
49349, 0.47916666666667, -0.16, 0.25
49350, 0.5, -0.18, 0.25
49351, 0.5, -0.02, 0.29166666666667
49352, 0.5, -0.04, 0.27083333333333
49353, 0.47916666666667, -0.04, 0.29166666666667
49354, 0.5, -0.06, 0.29166666666667
49355, 0.5, -0.08, 0.27083333333333
49356, 0.47916666666667, -0.08, 0.29166666666667
49357, 0.5, -0.1, 0.29166666666667
49358, 0.5, -0.12, 0.27083333333333
49359, 0.47916666666667, -0.12, 0.29166666666667
49360, 0.5, -0.14, 0.29166666666667
49361, 0.5, -0.16, 0.27083333333333
49362, 0.47916666666667, -0.16, 0.29166666666667
49363, 0.5, -0.18, 0.29166666666667
49364, 0.5, -0.02, 0.33333333333333
49365, 0.5, -0.04, 0.3125
49366, 0.47916666666667, -0.04, 0.33333333333333
49367, 0.5, -0.06, 0.33333333333333
49368, 0.5, -0.08, 0.3125
49369, 0.47916666666667, -0.08, 0.33333333333333
49370, 0.5, -0.1, 0.33333333333333
49371, 0.5, -0.12, 0.3125
49372, 0.47916666666667, -0.12, 0.33333333333333
49373, 0.5, -0.14, 0.33333333333333
49374, 0.5, -0.16, 0.3125
49375, 0.47916666666667, -0.16, 0.33333333333333
49376, 0.5, -0.18, 0.33333333333333
49377, 0.5, -0.02, 0.375
49378, 0.5, -0.04, 0.35416666666667
49379, 0.47916666666667, -0.04, 0.375
49380, 0.5, -0.06, 0.375
49381, 0.5, -0.08, 0.35416666666667
49382, 0.47916666666667, -0.08, 0.375
49383, 0.5, -0.1, 0.375
49384, 0.5, -0.12, 0.35416666666667
49385, 0.47916666666667, -0.12, 0.375
49386, 0.5, -0.14, 0.375
49387, 0.5, -0.16, 0.35416666666667
49388, 0.47916666666667, -0.16, 0.375
49389, 0.5, -0.18, 0.375
49390, 0.5, -0.02, 0.41666666666667
49391, 0.5, -0.04, 0.39583333333333
49392, 0.47916666666667, -0.04, 0.41666666666667
49393, 0.5, -0.06, 0.41666666666667
49394, 0.5, -0.08, 0.39583333333333
49395, 0.47916666666667, -0.08, 0.41666666666667
49396, 0.5, -0.1, 0.41666666666667
49397, 0.5, -0.12, 0.39583333333333
49398, 0.47916666666667, -0.12, 0.41666666666667
49399, 0.5, -0.14, 0.41666666666667
49400, 0.5, -0.16, 0.39583333333333
49401, 0.47916666666667, -0.16, 0.41666666666667
49402, 0.5, -0.18, 0.41666666666667
49403, 0.5, -0.02, 0.45833333333333
49404, 0.5, -0.04, 0.4375
49405, 0.47916666666667, -0.04, 0.45833333333333
49406, 0.5, -0.06, 0.45833333333333
49407, 0.5, -0.08, 0.4375
49408, 0.47916666666667, -0.08, 0.45833333333333
49409, 0.5, -0.1, 0.45833333333333
49410, 0.5, -0.12, 0.4375
49411, 0.47916666666667, -0.12, 0.45833333333333
49412, 0.5, -0.14, 0.45833333333333
49413, 0.5, -0.16, 0.4375
49414, 0.47916666666667, -0.16, 0.45833333333333
49415, 0.5, -0.18, 0.45833333333333
49416, 0.5, -0.04, 0.47916666666667
49417, 0.5, -0.08, 0.47916666666667
49418, 0.5, -0.12, 0.47916666666667
49419, 0.5, -0.16, 0.47916666666667
49420, 0.54166666666667, -0.02, 0.041666666666667
49421, 0.54166666666667, -0.04, 0.020833333333333
49422, 0.52083333333333, -0.04, 0.041666666666667
49423, 0.54166666666667, -0.06, 0.041666666666667
49424, 0.54166666666667, -0.08, 0.020833333333333
49425, 0.52083333333333, -0.08, 0.041666666666667
49426, 0.54166666666667, -0.1, 0.041666666666667
49427, 0.54166666666667, -0.12, 0.020833333333333
49428, 0.52083333333333, -0.12, 0.041666666666667
49429, 0.54166666666667, -0.14, 0.041666666666667
49430, 0.54166666666667, -0.16, 0.020833333333333
49431, 0.52083333333333, -0.16, 0.041666666666667
49432, 0.54166666666667, -0.18, 0.041666666666667
49433, 0.54166666666667, -0.02, 0.083333333333333
49434, 0.54166666666667, -0.04, 0.0625
49435, 0.52083333333333, -0.04, 0.083333333333333
49436, 0.54166666666667, -0.06, 0.083333333333333
49437, 0.54166666666667, -0.08, 0.0625
49438, 0.52083333333333, -0.08, 0.083333333333333
49439, 0.54166666666667, -0.1, 0.083333333333333
49440, 0.54166666666667, -0.12, 0.0625
49441, 0.52083333333333, -0.12, 0.083333333333333
49442, 0.54166666666667, -0.14, 0.083333333333333
49443, 0.54166666666667, -0.16, 0.0625
49444, 0.52083333333333, -0.16, 0.083333333333333
