6303, 1.2833333333333, 1.5, 0.16666666666667
6304, 1.325, 1.5, 0.16666666666667
6305, 1.3666666666667, 1.5, 0.16666666666667
6306, 1.4083333333333, 1.5, 0.16666666666667
6307, 1.45, 1.5, 0.16666666666667
6308, 1.4916666666667, 1.5, 0.16666666666667
6309, 1.5333333333333, 1.5, 0.16666666666667
6310, 1.575, 1.5, 0.16666666666667
6311, 1.6166666666667, 1.5, 0.16666666666667
6312, 1.6583333333333, 1.5, 0.16666666666667
6313, 1.7, 1.5, 0.16666666666667
6314, 1.7416666666667, 1.5, 0.16666666666667
6315, 1.7833333333333, 1.5, 0.16666666666667
6316, 1.825, 1.5, 0.16666666666667
6317, 1.8666666666667, 1.5, 0.16666666666667
6318, 1.9083333333333, 1.5, 0.16666666666667
6319, 1.95, 1.5, 0.16666666666667
6320, 1.9916666666667, 1.5, 0.16666666666667
6321, 2.0333333333333, 1.5, 0.16666666666667
6322, 2.075, 1.5, 0.16666666666667
6323, 2.1166666666667, 1.5, 0.16666666666667
6324, 2.1583333333333, 1.5, 0.16666666666667
6325, 1.2416666666667, 1.5, 0.20833333333333
6326, 1.2833333333333, 1.5, 0.20833333333333
6327, 1.325, 1.5, 0.20833333333333
6328, 1.3666666666667, 1.5, 0.20833333333333
6329, 1.4083333333333, 1.5, 0.20833333333333
6330, 1.45, 1.5, 0.20833333333333
6331, 1.4916666666667, 1.5, 0.20833333333333
6332, 1.5333333333333, 1.5, 0.20833333333333
6333, 1.575, 1.5, 0.20833333333333
6334, 1.6166666666667, 1.5, 0.20833333333333
6335, 1.6583333333333, 1.5, 0.20833333333333
6336, 1.7, 1.5, 0.20833333333333
6337, 1.7416666666667, 1.5, 0.20833333333333
6338, 1.7833333333333, 1.5, 0.20833333333333
6339, 1.825, 1.5, 0.20833333333333
6340, 1.8666666666667, 1.5, 0.20833333333333
6341, 1.9083333333333, 1.5, 0.20833333333333
6342, 1.95, 1.5, 0.20833333333333
6343, 1.9916666666667, 1.5, 0.20833333333333
6344, 2.0333333333333, 1.5, 0.20833333333333
6345, 2.075, 1.5, 0.20833333333333
6346, 2.1166666666667, 1.5, 0.20833333333333
6347, 2.1583333333333, 1.5, 0.20833333333333
6348, 1.2416666666667, 1.5, 0.25
6349, 1.2833333333333, 1.5, 0.25
6350, 1.325, 1.5, 0.25
6351, 1.3666666666667, 1.5, 0.25
6352, 1.4083333333333, 1.5, 0.25
6353, 1.45, 1.5, 0.25
6354, 1.4916666666667, 1.5, 0.25
6355, 1.5333333333333, 1.5, 0.25
6356, 1.575, 1.5, 0.25
6357, 1.6166666666667, 1.5, 0.25
6358, 1.6583333333333, 1.5, 0.25
6359, 1.7, 1.5, 0.25
6360, 1.7416666666667, 1.5, 0.25
6361, 1.7833333333333, 1.5, 0.25
6362, 1.825, 1.5, 0.25
6363, 1.8666666666667, 1.5, 0.25
6364, 1.9083333333333, 1.5, 0.25
6365, 1.95, 1.5, 0.25
6366, 1.9916666666667, 1.5, 0.25
6367, 2.0333333333333, 1.5, 0.25
6368, 2.075, 1.5, 0.25
6369, 2.1166666666667, 1.5, 0.25
6370, 2.1583333333333, 1.5, 0.25
6371, 1.2416666666667, 1.5, 0.29166666666667
6372, 1.2833333333333, 1.5, 0.29166666666667
6373, 1.325, 1.5, 0.29166666666667
6374, 1.3666666666667, 1.5, 0.29166666666667
6375, 1.4083333333333, 1.5, 0.29166666666667
6376, 1.45, 1.5, 0.29166666666667
6377, 1.4916666666667, 1.5, 0.29166666666667
6378, 1.5333333333333, 1.5, 0.29166666666667
6379, 1.575, 1.5, 0.29166666666667
6380, 1.6166666666667, 1.5, 0.29166666666667
6381, 1.6583333333333, 1.5, 0.29166666666667
6382, 1.7, 1.5, 0.29166666666667
6383, 1.7416666666667, 1.5, 0.29166666666667
6384, 1.7833333333333, 1.5, 0.29166666666667
6385, 1.825, 1.5, 0.29166666666667
6386, 1.8666666666667, 1.5, 0.29166666666667
6387, 1.9083333333333, 1.5, 0.29166666666667
6388, 1.95, 1.5, 0.29166666666667
6389, 1.9916666666667, 1.5, 0.29166666666667
6390, 2.0333333333333, 1.5, 0.29166666666667
6391, 2.075, 1.5, 0.29166666666667
6392, 2.1166666666667, 1.5, 0.29166666666667
6393, 2.1583333333333, 1.5, 0.29166666666667
6394, 1.2416666666667, 1.5, 0.33333333333333
6395, 1.2833333333333, 1.5, 0.33333333333333
6396, 1.325, 1.5, 0.33333333333333
6397, 1.3666666666667, 1.5, 0.33333333333333
6398, 1.4083333333333, 1.5, 0.33333333333333
6399, 1.45, 1.5, 0.33333333333333
6400, 1.4916666666667, 1.5, 0.33333333333333
6401, 1.5333333333333, 1.5, 0.33333333333333
6402, 1.575, 1.5, 0.33333333333333
6403, 1.6166666666667, 1.5, 0.33333333333333
6404, 1.6583333333333, 1.5, 0.33333333333333
6405, 1.7, 1.5, 0.33333333333333
6406, 1.7416666666667, 1.5, 0.33333333333333
6407, 1.7833333333333, 1.5, 0.33333333333333
6408, 1.825, 1.5, 0.33333333333333
6409, 1.8666666666667, 1.5, 0.33333333333333
6410, 1.9083333333333, 1.5, 0.33333333333333
6411, 1.95, 1.5, 0.33333333333333
6412, 1.9916666666667, 1.5, 0.33333333333333
6413, 2.0333333333333, 1.5, 0.33333333333333
6414, 2.075, 1.5, 0.33333333333333
6415, 2.1166666666667, 1.5, 0.33333333333333
6416, 2.1583333333333, 1.5, 0.33333333333333
6417, 1.2416666666667, 1.5, 0.375
6418, 1.2833333333333, 1.5, 0.375
6419, 1.325, 1.5, 0.375
6420, 1.3666666666667, 1.5, 0.375
6421, 1.4083333333333, 1.5, 0.375
6422, 1.45, 1.5, 0.375
6423, 1.4916666666667, 1.5, 0.375
6424, 1.5333333333333, 1.5, 0.375
6425, 1.575, 1.5, 0.375
6426, 1.6166666666667, 1.5, 0.375
6427, 1.6583333333333, 1.5, 0.375
6428, 1.7, 1.5, 0.375
6429, 1.7416666666667, 1.5, 0.375
6430, 1.7833333333333, 1.5, 0.375
6431, 1.825, 1.5, 0.375
6432, 1.8666666666667, 1.5, 0.375
6433, 1.9083333333333, 1.5, 0.375
6434, 1.95, 1.5, 0.375
6435, 1.9916666666667, 1.5, 0.375
6436, 2.0333333333333, 1.5, 0.375
6437, 2.075, 1.5, 0.375
6438, 2.1166666666667, 1.5, 0.375
6439, 2.1583333333333, 1.5, 0.375
6440, 1.2416666666667, 1.5, 0.41666666666667
6441, 1.2833333333333, 1.5, 0.41666666666667
6442, 1.325, 1.5, 0.41666666666667
6443, 1.3666666666667, 1.5, 0.41666666666667
6444, 1.4083333333333, 1.5, 0.41666666666667
6445, 1.45, 1.5, 0.41666666666667
6446, 1.4916666666667, 1.5, 0.41666666666667
6447, 1.5333333333333, 1.5, 0.41666666666667
6448, 1.575, 1.5, 0.41666666666667
6449, 1.6166666666667, 1.5, 0.41666666666667
6450, 1.6583333333333, 1.5, 0.41666666666667
6451, 1.7, 1.5, 0.41666666666667
6452, 1.7416666666667, 1.5, 0.41666666666667
6453, 1.7833333333333, 1.5, 0.41666666666667
6454, 1.825, 1.5, 0.41666666666667
6455, 1.8666666666667, 1.5, 0.41666666666667
6456, 1.9083333333333, 1.5, 0.41666666666667
6457, 1.95, 1.5, 0.41666666666667
6458, 1.9916666666667, 1.5, 0.41666666666667
6459, 2.0333333333333, 1.5, 0.41666666666667
6460, 2.075, 1.5, 0.41666666666667
6461, 2.1166666666667, 1.5, 0.41666666666667
6462, 2.1583333333333, 1.5, 0.41666666666667
6463, 1.2416666666667, 1.5, 0.45833333333333
6464, 1.2833333333333, 1.5, 0.45833333333333
6465, 1.325, 1.5, 0.45833333333333
6466, 1.3666666666667, 1.5, 0.45833333333333
6467, 1.4083333333333, 1.5, 0.45833333333333
6468, 1.45, 1.5, 0.45833333333333
6469, 1.4916666666667, 1.5, 0.45833333333333
6470, 1.5333333333333, 1.5, 0.45833333333333
6471, 1.575, 1.5, 0.45833333333333
6472, 1.6166666666667, 1.5, 0.45833333333333
6473, 1.6583333333333, 1.5, 0.45833333333333
6474, 1.7, 1.5, 0.45833333333333
6475, 1.7416666666667, 1.5, 0.45833333333333
6476, 1.7833333333333, 1.5, 0.45833333333333
6477, 1.825, 1.5, 0.45833333333333
6478, 1.8666666666667, 1.5, 0.45833333333333
6479, 1.9083333333333, 1.5, 0.45833333333333
6480, 1.95, 1.5, 0.45833333333333
6481, 1.9916666666667, 1.5, 0.45833333333333
6482, 2.0333333333333, 1.5, 0.45833333333333
6483, 2.075, 1.5, 0.45833333333333
6484, 2.1166666666667, 1.5, 0.45833333333333
6485, 2.1583333333333, 1.5, 0.45833333333333
6486, 2.2, 1.4333333333333, 0.041666666666667
6487, 2.2, 1.4666666666667, 0.041666666666667
6488, 2.2, 1.4333333333333, 0.083333333333333
6489, 2.2, 1.4666666666667, 0.083333333333333
6490, 2.2, 1.4333333333333, 0.125
6491, 2.2, 1.4666666666667, 0.125
6492, 2.2, 1.4333333333333, 0.16666666666667
6493, 2.2, 1.4666666666667, 0.16666666666667
6494, 2.2, 1.4333333333333, 0.20833333333333
6495, 2.2, 1.4666666666667, 0.20833333333333
6496, 2.2, 1.4333333333333, 0.25
6497, 2.2, 1.4666666666667, 0.25
6498, 2.2, 1.4333333333333, 0.29166666666667
6499, 2.2, 1.4666666666667, 0.29166666666667
6500, 2.2, 1.4333333333333, 0.33333333333333
6501, 2.2, 1.4666666666667, 0.33333333333333
6502, 2.2, 1.4333333333333, 0.375
6503, 2.2, 1.4666666666667, 0.375
6504, 2.2, 1.4333333333333, 0.41666666666667
6505, 2.2, 1.4666666666667, 0.41666666666667
6506, 2.2, 1.4333333333333, 0.45833333333333
6507, 2.2, 1.4666666666667, 0.45833333333333
6508, 1.2416666666667, 1.35, 0.041666666666667
6509, 1.2833333333333, 1.35, 0.041666666666667
6510, 1.325, 1.35, 0.041666666666667
6511, 1.3666666666667, 1.35, 0.041666666666667
6512, 1.4083333333333, 1.35, 0.041666666666667
6513, 1.45, 1.35, 0.041666666666667
6514, 1.4916666666667, 1.35, 0.041666666666667
6515, 1.5333333333333, 1.35, 0.041666666666667
6516, 1.575, 1.35, 0.041666666666667
6517, 1.6166666666667, 1.35, 0.041666666666667
6518, 1.6583333333333, 1.35, 0.041666666666667
6519, 1.7, 1.35, 0.041666666666667
6520, 1.7416666666667, 1.35, 0.041666666666667
6521, 1.7833333333333, 1.35, 0.041666666666667
6522, 1.825, 1.35, 0.041666666666667
6523, 1.8666666666667, 1.35, 0.041666666666667
6524, 1.9083333333333, 1.35, 0.041666666666667
6525, 1.95, 1.35, 0.041666666666667
6526, 1.9916666666667, 1.35, 0.041666666666667
6527, 2.0333333333333, 1.35, 0.041666666666667
6528, 2.075, 1.35, 0.041666666666667
6529, 2.1166666666667, 1.35, 0.041666666666667
6530, 2.1583333333333, 1.35, 0.041666666666667
6531, 1.2416666666667, 1.35, 0.083333333333333
6532, 1.2833333333333, 1.35, 0.083333333333333
6533, 1.325, 1.35, 0.083333333333333
6534, 1.3666666666667, 1.35, 0.083333333333333
6535, 1.4083333333333, 1.35, 0.083333333333333
6536, 1.45, 1.35, 0.083333333333333
6537, 1.4916666666667, 1.35, 0.083333333333333
6538, 1.5333333333333, 1.35, 0.083333333333333
6539, 1.575, 1.35, 0.083333333333333
6540, 1.6166666666667, 1.35, 0.083333333333333
6541, 1.6583333333333, 1.35, 0.083333333333333
6542, 1.7, 1.35, 0.083333333333333
6543, 1.7416666666667, 1.35, 0.083333333333333
6544, 1.7833333333333, 1.35, 0.083333333333333
6545, 1.825, 1.35, 0.083333333333333
6546, 1.8666666666667, 1.35, 0.083333333333333
6547, 1.9083333333333, 1.35, 0.083333333333333
6548, 1.95, 1.35, 0.083333333333333
6549, 1.9916666666667, 1.35, 0.083333333333333
6550, 2.0333333333333, 1.35, 0.083333333333333
6551, 2.075, 1.35, 0.083333333333333
6552, 2.1166666666667, 1.35, 0.083333333333333
6553, 2.1583333333333, 1.35, 0.083333333333333
6554, 1.2416666666667, 1.35, 0.125
6555, 1.2833333333333, 1.35, 0.125
6556, 1.325, 1.35, 0.125
6557, 1.3666666666667, 1.35, 0.125
6558, 1.4083333333333, 1.35, 0.125
6559, 1.45, 1.35, 0.125
6560, 1.4916666666667, 1.35, 0.125
6561, 1.5333333333333, 1.35, 0.125
6562, 1.575, 1.35, 0.125
6563, 1.6166666666667, 1.35, 0.125
6564, 1.6583333333333, 1.35, 0.125
6565, 1.7, 1.35, 0.125
6566, 1.7416666666667, 1.35, 0.125
6567, 1.7833333333333, 1.35, 0.125
6568, 1.825, 1.35, 0.125
6569, 1.8666666666667, 1.35, 0.125
6570, 1.9083333333333, 1.35, 0.125
6571, 1.95, 1.35, 0.125
6572, 1.9916666666667, 1.35, 0.125
6573, 2.0333333333333, 1.35, 0.125
6574, 2.075, 1.35, 0.125
6575, 2.1166666666667, 1.35, 0.125
6576, 2.1583333333333, 1.35, 0.125
6577, 1.2416666666667, 1.35, 0.16666666666667
6578, 1.2833333333333, 1.35, 0.16666666666667
6579, 1.325, 1.35, 0.16666666666667
6580, 1.3666666666667, 1.35, 0.16666666666667
6581, 1.4083333333333, 1.35, 0.16666666666667
6582, 1.45, 1.35, 0.16666666666667
6583, 1.4916666666667, 1.35, 0.16666666666667
6584, 1.5333333333333, 1.35, 0.16666666666667
6585, 1.575, 1.35, 0.16666666666667
6586, 1.6166666666667, 1.35, 0.16666666666667
6587, 1.6583333333333, 1.35, 0.16666666666667
6588, 1.7, 1.35, 0.16666666666667
6589, 1.7416666666667, 1.35, 0.16666666666667
6590, 1.7833333333333, 1.35, 0.16666666666667
6591, 1.825, 1.35, 0.16666666666667
6592, 1.8666666666667, 1.35, 0.16666666666667
6593, 1.9083333333333, 1.35, 0.16666666666667
6594, 1.95, 1.35, 0.16666666666667
6595, 1.9916666666667, 1.35, 0.16666666666667
6596, 2.0333333333333, 1.35, 0.16666666666667
6597, 2.075, 1.35, 0.16666666666667
6598, 2.1166666666667, 1.35, 0.16666666666667
6599, 2.1583333333333, 1.35, 0.16666666666667
6600, 1.2416666666667, 1.35, 0.20833333333333
6601, 1.2833333333333, 1.35, 0.20833333333333
6602, 1.325, 1.35, 0.20833333333333
6603, 1.3666666666667, 1.35, 0.20833333333333
6604, 1.4083333333333, 1.35, 0.20833333333333
6605, 1.45, 1.35, 0.20833333333333
6606, 1.4916666666667, 1.35, 0.20833333333333
6607, 1.5333333333333, 1.35, 0.20833333333333
6608, 1.575, 1.35, 0.20833333333333
6609, 1.6166666666667, 1.35, 0.20833333333333
6610, 1.6583333333333, 1.35, 0.20833333333333
6611, 1.7, 1.35, 0.20833333333333
6612, 1.7416666666667, 1.35, 0.20833333333333
6613, 1.7833333333333, 1.35, 0.20833333333333
6614, 1.825, 1.35, 0.20833333333333
6615, 1.8666666666667, 1.35, 0.20833333333333
6616, 1.9083333333333, 1.35, 0.20833333333333
6617, 1.95, 1.35, 0.20833333333333
6618, 1.9916666666667, 1.35, 0.20833333333333
6619, 2.0333333333333, 1.35, 0.20833333333333
6620, 2.075, 1.35, 0.20833333333333
6621, 2.1166666666667, 1.35, 0.20833333333333
6622, 2.1583333333333, 1.35, 0.20833333333333
6623, 1.2416666666667, 1.35, 0.25
6624, 1.2833333333333, 1.35, 0.25
6625, 1.325, 1.35, 0.25
6626, 1.3666666666667, 1.35, 0.25
6627, 1.4083333333333, 1.35, 0.25
6628, 1.45, 1.35, 0.25
6629, 1.4916666666667, 1.35, 0.25
6630, 1.5333333333333, 1.35, 0.25
6631, 1.575, 1.35, 0.25
6632, 1.6166666666667, 1.35, 0.25
6633, 1.6583333333333, 1.35, 0.25
6634, 1.7, 1.35, 0.25
6635, 1.7416666666667, 1.35, 0.25
6636, 1.7833333333333, 1.35, 0.25
6637, 1.825, 1.35, 0.25
6638, 1.8666666666667, 1.35, 0.25
6639, 1.9083333333333, 1.35, 0.25
6640, 1.95, 1.35, 0.25
6641, 1.9916666666667, 1.35, 0.25
6642, 2.0333333333333, 1.35, 0.25
6643, 2.075, 1.35, 0.25
6644, 2.1166666666667, 1.35, 0.25
6645, 2.1583333333333, 1.35, 0.25
6646, 1.2416666666667, 1.35, 0.29166666666667
6647, 1.2833333333333, 1.35, 0.29166666666667
6648, 1.325, 1.35, 0.29166666666667
6649, 1.3666666666667, 1.35, 0.29166666666667
6650, 1.4083333333333, 1.35, 0.29166666666667
6651, 1.45, 1.35, 0.29166666666667
6652, 1.4916666666667, 1.35, 0.29166666666667
6653, 1.5333333333333, 1.35, 0.29166666666667
6654, 1.575, 1.35, 0.29166666666667
6655, 1.6166666666667, 1.35, 0.29166666666667
6656, 1.6583333333333, 1.35, 0.29166666666667
6657, 1.7, 1.35, 0.29166666666667
6658, 1.7416666666667, 1.35, 0.29166666666667
6659, 1.7833333333333, 1.35, 0.29166666666667
6660, 1.825, 1.35, 0.29166666666667
6661, 1.8666666666667, 1.35, 0.29166666666667
6662, 1.9083333333333, 1.35, 0.29166666666667
6663, 1.95, 1.35, 0.29166666666667
6664, 1.9916666666667, 1.35, 0.29166666666667
6665, 2.0333333333333, 1.35, 0.29166666666667
6666, 2.075, 1.35, 0.29166666666667
6667, 2.1166666666667, 1.35, 0.29166666666667
6668, 2.1583333333333, 1.35, 0.29166666666667
6669, 1.2416666666667, 1.35, 0.33333333333333
6670, 1.2833333333333, 1.35, 0.33333333333333
6671, 1.325, 1.35, 0.33333333333333
6672, 1.3666666666667, 1.35, 0.33333333333333
6673, 1.4083333333333, 1.35, 0.33333333333333
6674, 1.45, 1.35, 0.33333333333333
6675, 1.4916666666667, 1.35, 0.33333333333333
6676, 1.5333333333333, 1.35, 0.33333333333333
6677, 1.575, 1.35, 0.33333333333333
6678, 1.6166666666667, 1.35, 0.33333333333333
6679, 1.6583333333333, 1.35, 0.33333333333333
6680, 1.7, 1.35, 0.33333333333333
6681, 1.7416666666667, 1.35, 0.33333333333333
6682, 1.7833333333333, 1.35, 0.33333333333333
6683, 1.825, 1.35, 0.33333333333333
6684, 1.8666666666667, 1.35, 0.33333333333333
6685, 1.9083333333333, 1.35, 0.33333333333333
6686, 1.95, 1.35, 0.33333333333333
6687, 1.9916666666667, 1.35, 0.33333333333333
6688, 2.0333333333333, 1.35, 0.33333333333333
6689, 2.075, 1.35, 0.33333333333333
6690, 2.1166666666667, 1.35, 0.33333333333333
6691, 2.1583333333333, 1.35, 0.33333333333333
6692, 1.2416666666667, 1.35, 0.375
6693, 1.2833333333333, 1.35, 0.375
6694, 1.325, 1.35, 0.375
6695, 1.3666666666667, 1.35, 0.375
6696, 1.4083333333333, 1.35, 0.375
6697, 1.45, 1.35, 0.375
6698, 1.4916666666667, 1.35, 0.375
6699, 1.5333333333333, 1.35, 0.375
6700, 1.575, 1.35, 0.375
6701, 1.6166666666667, 1.35, 0.375
6702, 1.6583333333333, 1.35, 0.375
6703, 1.7, 1.35, 0.375
6704, 1.7416666666667, 1.35, 0.375
6705, 1.7833333333333, 1.35, 0.375
6706, 1.825, 1.35, 0.375
6707, 1.8666666666667, 1.35, 0.375
6708, 1.9083333333333, 1.35, 0.375
6709, 1.95, 1.35, 0.375
6710, 1.9916666666667, 1.35, 0.375
6711, 2.0333333333333, 1.35, 0.375
6712, 2.075, 1.35, 0.375
6713, 2.1166666666667, 1.35, 0.375
6714, 2.1583333333333, 1.35, 0.375
6715, 1.2416666666667, 1.35, 0.41666666666667
6716, 1.2833333333333, 1.35, 0.41666666666667
6717, 1.325, 1.35, 0.41666666666667
6718, 1.3666666666667, 1.35, 0.41666666666667
6719, 1.4083333333333, 1.35, 0.41666666666667
6720, 1.45, 1.35, 0.41666666666667
6721, 1.4916666666667, 1.35, 0.41666666666667
6722, 1.5333333333333, 1.35, 0.41666666666667
6723, 1.575, 1.35, 0.41666666666667
6724, 1.6166666666667, 1.35, 0.41666666666667
6725, 1.6583333333333, 1.35, 0.41666666666667
6726, 1.7, 1.35, 0.41666666666667
6727, 1.7416666666667, 1.35, 0.41666666666667
6728, 1.7833333333333, 1.35, 0.41666666666667
6729, 1.825, 1.35, 0.41666666666667
6730, 1.8666666666667, 1.35, 0.41666666666667
6731, 1.9083333333333, 1.35, 0.41666666666667
6732, 1.95, 1.35, 0.41666666666667
6733, 1.9916666666667, 1.35, 0.41666666666667
6734, 2.0333333333333, 1.35, 0.41666666666667
6735, 2.075, 1.35, 0.41666666666667
6736, 2.1166666666667, 1.35, 0.41666666666667
6737, 2.1583333333333, 1.35, 0.41666666666667
6738, 1.2416666666667, 1.35, 0.45833333333333
6739, 1.2833333333333, 1.35, 0.45833333333333
6740, 1.325, 1.35, 0.45833333333333
6741, 1.3666666666667, 1.35, 0.45833333333333
6742, 1.4083333333333, 1.35, 0.45833333333333
6743, 1.45, 1.35, 0.45833333333333
6744, 1.4916666666667, 1.35, 0.45833333333333
6745, 1.5333333333333, 1.35, 0.45833333333333
6746, 1.575, 1.35, 0.45833333333333
6747, 1.6166666666667, 1.35, 0.45833333333333
6748, 1.6583333333333, 1.35, 0.45833333333333
6749, 1.7, 1.35, 0.45833333333333
6750, 1.7416666666667, 1.35, 0.45833333333333
6751, 1.7833333333333, 1.35, 0.45833333333333
6752, 1.825, 1.35, 0.45833333333333
6753, 1.8666666666667, 1.35, 0.45833333333333
6754, 1.9083333333333, 1.35, 0.45833333333333
6755, 1.95, 1.35, 0.45833333333333
6756, 1.9916666666667, 1.35, 0.45833333333333
6757, 2.0333333333333, 1.35, 0.45833333333333
6758, 2.075, 1.35, 0.45833333333333
6759, 2.1166666666667, 1.35, 0.45833333333333
6760, 2.1583333333333, 1.35, 0.45833333333333
6761, 1.2416666666667, 1.3, 0.5
6762, 1.2416666666667, 1.25, 0.5
6763, 1.2416666666667, 1.2, 0.5
6764, 1.2416666666667, 1.15, 0.5
6765, 1.2416666666667, 1.1, 0.5
6766, 1.2416666666667, 1.05, 0.5
6767, 1.2416666666667, 1, 0.5
6768, 1.2416666666667, 0.95, 0.5
6769, 1.2416666666667, 0.9, 0.5
6770, 1.2416666666667, 0.85, 0.5
6771, 1.2416666666667, 0.8, 0.5
6772, 1.2416666666667, 0.75, 0.5
6773, 1.2416666666667, 0.7, 0.5
6774, 1.2416666666667, 0.65, 0.5
6775, 1.2416666666667, 0.6, 0.5
6776, 1.2416666666667, 0.55, 0.5
6777, 1.2416666666667, 0.5, 0.5
6778, 1.2416666666667, 0.45, 0.5
6779, 1.2416666666667, 0.4, 0.5
6780, 1.2416666666667, 0.35, 0.5
6781, 1.2416666666667, 0.3, 0.5
6782, 1.2416666666667, 0.25, 0.5
6783, 1.2416666666667, 0.2, 0.5
6784, 1.2833333333333, 1.3, 0.5
6785, 1.2833333333333, 1.25, 0.5
6786, 1.2833333333333, 1.2, 0.5
6787, 1.2833333333333, 1.15, 0.5
6788, 1.2833333333333, 1.1, 0.5
6789, 1.2833333333333, 1.05, 0.5
6790, 1.2833333333333, 1, 0.5
6791, 1.2833333333333, 0.95, 0.5
6792, 1.2833333333333, 0.9, 0.5
6793, 1.2833333333333, 0.85, 0.5
6794, 1.2833333333333, 0.8, 0.5
6795, 1.2833333333333, 0.75, 0.5
6796, 1.2833333333333, 0.7, 0.5
6797, 1.2833333333333, 0.65, 0.5
6798, 1.2833333333333, 0.6, 0.5
6799, 1.2833333333333, 0.55, 0.5
6800, 1.2833333333333, 0.5, 0.5
6801, 1.2833333333333, 0.45, 0.5
6802, 1.2833333333333, 0.4, 0.5
6803, 1.2833333333333, 0.35, 0.5
6804, 1.2833333333333, 0.3, 0.5
6805, 1.2833333333333, 0.25, 0.5
6806, 1.2833333333333, 0.2, 0.5
6807, 1.325, 1.3, 0.5
6808, 1.325, 1.25, 0.5
6809, 1.325, 1.2, 0.5
6810, 1.325, 1.15, 0.5
6811, 1.325, 1.1, 0.5
6812, 1.325, 1.05, 0.5
6813, 1.325, 1, 0.5
6814, 1.325, 0.95, 0.5
6815, 1.325, 0.9, 0.5
6816, 1.325, 0.85, 0.5
6817, 1.325, 0.8, 0.5
6818, 1.325, 0.75, 0.5
6819, 1.325, 0.7, 0.5
6820, 1.325, 0.65, 0.5
6821, 1.325, 0.6, 0.5
6822, 1.325, 0.55, 0.5
6823, 1.325, 0.5, 0.5
6824, 1.325, 0.45, 0.5
6825, 1.325, 0.4, 0.5
6826, 1.325, 0.35, 0.5
6827, 1.325, 0.3, 0.5
6828, 1.325, 0.25, 0.5
6829, 1.325, 0.2, 0.5
6830, 1.3666666666667, 1.3, 0.5
6831, 1.3666666666667, 1.25, 0.5
6832, 1.3666666666667, 1.2, 0.5
6833, 1.3666666666667, 1.15, 0.5
6834, 1.3666666666667, 1.1, 0.5
6835, 1.3666666666667, 1.05, 0.5
6836, 1.3666666666667, 1, 0.5
6837, 1.3666666666667, 0.95, 0.5
6838, 1.3666666666667, 0.9, 0.5
6839, 1.3666666666667, 0.85, 0.5
6840, 1.3666666666667, 0.8, 0.5
6841, 1.3666666666667, 0.75, 0.5
6842, 1.3666666666667, 0.7, 0.5
6843, 1.3666666666667, 0.65, 0.5
6844, 1.3666666666667, 0.6, 0.5
6845, 1.3666666666667, 0.55, 0.5
6846, 1.3666666666667, 0.5, 0.5
6847, 1.3666666666667, 0.45, 0.5
6848, 1.3666666666667, 0.4, 0.5
6849, 1.3666666666667, 0.35, 0.5
6850, 1.3666666666667, 0.3, 0.5
6851, 1.3666666666667, 0.25, 0.5
6852, 1.3666666666667, 0.2, 0.5
6853, 1.4083333333333, 1.3, 0.5
6854, 1.4083333333333, 1.25, 0.5
6855, 1.4083333333333, 1.2, 0.5
6856, 1.4083333333333, 1.15, 0.5
6857, 1.4083333333333, 1.1, 0.5
6858, 1.4083333333333, 1.05, 0.5
6859, 1.4083333333333, 1, 0.5
6860, 1.4083333333333, 0.95, 0.5
6861, 1.4083333333333, 0.9, 0.5
6862, 1.4083333333333, 0.85, 0.5
6863, 1.4083333333333, 0.8, 0.5
6864, 1.4083333333333, 0.75, 0.5
6865, 1.4083333333333, 0.7, 0.5
6866, 1.4083333333333, 0.65, 0.5
6867, 1.4083333333333, 0.6, 0.5
6868, 1.4083333333333, 0.55, 0.5
6869, 1.4083333333333, 0.5, 0.5
6870, 1.4083333333333, 0.45, 0.5
6871, 1.4083333333333, 0.4, 0.5
6872, 1.4083333333333, 0.35, 0.5
6873, 1.4083333333333, 0.3, 0.5
6874, 1.4083333333333, 0.25, 0.5
6875, 1.4083333333333, 0.2, 0.5
6876, 1.45, 1.3, 0.5
6877, 1.45, 1.25, 0.5
6878, 1.45, 1.2, 0.5
6879, 1.45, 1.15, 0.5
6880, 1.45, 1.1, 0.5
6881, 1.45, 1.05, 0.5
6882, 1.45, 1, 0.5
6883, 1.45, 0.95, 0.5
6884, 1.45, 0.9, 0.5
6885, 1.45, 0.85, 0.5
6886, 1.45, 0.8, 0.5
6887, 1.45, 0.75, 0.5
6888, 1.45, 0.7, 0.5
6889, 1.45, 0.65, 0.5
6890, 1.45, 0.6, 0.5
6891, 1.45, 0.55, 0.5
6892, 1.45, 0.5, 0.5
6893, 1.45, 0.45, 0.5
6894, 1.45, 0.4, 0.5
6895, 1.45, 0.35, 0.5
6896, 1.45, 0.3, 0.5
6897, 1.45, 0.25, 0.5
6898, 1.45, 0.2, 0.5
6899, 1.4916666666667, 1.3, 0.5
6900, 1.4916666666667, 1.25, 0.5
6901, 1.4916666666667, 1.2, 0.5
6902, 1.4916666666667, 1.15, 0.5
6903, 1.4916666666667, 1.1, 0.5
6904, 1.4916666666667, 1.05, 0.5
6905, 1.4916666666667, 1, 0.5
6906, 1.4916666666667, 0.95, 0.5
6907, 1.4916666666667, 0.9, 0.5
6908, 1.4916666666667, 0.85, 0.5
6909, 1.4916666666667, 0.8, 0.5
6910, 1.4916666666667, 0.75, 0.5
6911, 1.4916666666667, 0.7, 0.5
6912, 1.4916666666667, 0.65, 0.5
6913, 1.4916666666667, 0.6, 0.5
6914, 1.4916666666667, 0.55, 0.5
6915, 1.4916666666667, 0.5, 0.5
6916, 1.4916666666667, 0.45, 0.5
6917, 1.4916666666667, 0.4, 0.5
6918, 1.4916666666667, 0.35, 0.5
6919, 1.4916666666667, 0.3, 0.5
6920, 1.4916666666667, 0.25, 0.5
6921, 1.4916666666667, 0.2, 0.5
6922, 1.5333333333333, 1.3, 0.5
6923, 1.5333333333333, 1.25, 0.5
6924, 1.5333333333333, 1.2, 0.5
6925, 1.5333333333333, 1.15, 0.5
6926, 1.5333333333333, 1.1, 0.5
6927, 1.5333333333333, 1.05, 0.5
6928, 1.5333333333333, 1, 0.5
6929, 1.5333333333333, 0.95, 0.5
6930, 1.5333333333333, 0.9, 0.5
6931, 1.5333333333333, 0.85, 0.5
6932, 1.5333333333333, 0.8, 0.5
6933, 1.5333333333333, 0.75, 0.5
6934, 1.5333333333333, 0.7, 0.5
6935, 1.5333333333333, 0.65, 0.5
6936, 1.5333333333333, 0.6, 0.5
6937, 1.5333333333333, 0.55, 0.5
6938, 1.5333333333333, 0.5, 0.5
6939, 1.5333333333333, 0.45, 0.5
6940, 1.5333333333333, 0.4, 0.5
6941, 1.5333333333333, 0.35, 0.5
6942, 1.5333333333333, 0.3, 0.5
6943, 1.5333333333333, 0.25, 0.5
6944, 1.5333333333333, 0.2, 0.5
6945, 1.575, 1.3, 0.5
6946, 1.575, 1.25, 0.5
6947, 1.575, 1.2, 0.5
6948, 1.575, 1.15, 0.5
6949, 1.575, 1.1, 0.5
6950, 1.575, 1.05, 0.5
6951, 1.575, 1, 0.5
6952, 1.575, 0.95, 0.5
6953, 1.575, 0.9, 0.5
6954, 1.575, 0.85, 0.5
6955, 1.575, 0.8, 0.5
6956, 1.575, 0.75, 0.5
6957, 1.575, 0.7, 0.5
6958, 1.575, 0.65, 0.5
6959, 1.575, 0.6, 0.5
6960, 1.575, 0.55, 0.5
6961, 1.575, 0.5, 0.5
6962, 1.575, 0.45, 0.5
6963, 1.575, 0.4, 0.5
6964, 1.575, 0.35, 0.5
6965, 1.575, 0.3, 0.5
6966, 1.575, 0.25, 0.5
6967, 1.575, 0.2, 0.5
6968, 1.6166666666667, 1.3, 0.5
6969, 1.6166666666667, 1.25, 0.5
6970, 1.6166666666667, 1.2, 0.5
6971, 1.6166666666667, 1.15, 0.5
6972, 1.6166666666667, 1.1, 0.5
6973, 1.6166666666667, 1.05, 0.5
6974, 1.6166666666667, 1, 0.5
6975, 1.6166666666667, 0.95, 0.5
6976, 1.6166666666667, 0.9, 0.5
6977, 1.6166666666667, 0.85, 0.5
6978, 1.6166666666667, 0.8, 0.5
6979, 1.6166666666667, 0.75, 0.5
6980, 1.6166666666667, 0.7, 0.5
6981, 1.6166666666667, 0.65, 0.5
6982, 1.6166666666667, 0.6, 0.5
6983, 1.6166666666667, 0.55, 0.5
6984, 1.6166666666667, 0.5, 0.5
6985, 1.6166666666667, 0.45, 0.5
6986, 1.6166666666667, 0.4, 0.5
6987, 1.6166666666667, 0.35, 0.5
6988, 1.6166666666667, 0.3, 0.5
6989, 1.6166666666667, 0.25, 0.5
6990, 1.6166666666667, 0.2, 0.5
6991, 1.6583333333333, 1.3, 0.5
6992, 1.6583333333333, 1.25, 0.5
6993, 1.6583333333333, 1.2, 0.5
6994, 1.6583333333333, 1.15, 0.5
6995, 1.6583333333333, 1.1, 0.5
6996, 1.6583333333333, 1.05, 0.5
6997, 1.6583333333333, 1, 0.5
6998, 1.6583333333333, 0.95, 0.5
6999, 1.6583333333333, 0.9, 0.5
7000, 1.6583333333333, 0.85, 0.5
7001, 1.6583333333333, 0.8, 0.5
7002, 1.6583333333333, 0.75, 0.5
7003, 1.6583333333333, 0.7, 0.5
7004, 1.6583333333333, 0.65, 0.5
7005, 1.6583333333333, 0.6, 0.5
7006, 1.6583333333333, 0.55, 0.5
7007, 1.6583333333333, 0.5, 0.5
7008, 1.6583333333333, 0.45, 0.5
7009, 1.6583333333333, 0.4, 0.5
7010, 1.6583333333333, 0.35, 0.5
7011, 1.6583333333333, 0.3, 0.5
7012, 1.6583333333333, 0.25, 0.5
7013, 1.6583333333333, 0.2, 0.5
7014, 1.7, 1.3, 0.5
7015, 1.7, 1.25, 0.5
7016, 1.7, 1.2, 0.5
7017, 1.7, 1.15, 0.5
7018, 1.7, 1.1, 0.5
7019, 1.7, 1.05, 0.5
7020, 1.7, 1, 0.5
7021, 1.7, 0.95, 0.5
7022, 1.7, 0.9, 0.5
7023, 1.7, 0.85, 0.5
7024, 1.7, 0.8, 0.5
7025, 1.7, 0.75, 0.5
7026, 1.7, 0.7, 0.5
7027, 1.7, 0.65, 0.5
7028, 1.7, 0.6, 0.5
7029, 1.7, 0.55, 0.5
7030, 1.7, 0.5, 0.5
7031, 1.7, 0.45, 0.5
7032, 1.7, 0.4, 0.5
7033, 1.7, 0.35, 0.5
7034, 1.7, 0.3, 0.5
7035, 1.7, 0.25, 0.5
7036, 1.7, 0.2, 0.5
7037, 1.7416666666667, 1.3, 0.5
7038, 1.7416666666667, 1.25, 0.5
7039, 1.7416666666667, 1.2, 0.5
7040, 1.7416666666667, 1.15, 0.5
7041, 1.7416666666667, 1.1, 0.5
7042, 1.7416666666667, 1.05, 0.5
7043, 1.7416666666667, 1, 0.5
7044, 1.7416666666667, 0.95, 0.5
7045, 1.7416666666667, 0.9, 0.5
7046, 1.7416666666667, 0.85, 0.5
7047, 1.7416666666667, 0.8, 0.5
7048, 1.7416666666667, 0.75, 0.5
7049, 1.7416666666667, 0.7, 0.5
7050, 1.7416666666667, 0.65, 0.5
7051, 1.7416666666667, 0.6, 0.5
7052, 1.7416666666667, 0.55, 0.5
7053, 1.7416666666667, 0.5, 0.5
7054, 1.7416666666667, 0.45, 0.5
7055, 1.7416666666667, 0.4, 0.5
7056, 1.7416666666667, 0.35, 0.5
7057, 1.7416666666667, 0.3, 0.5
7058, 1.7416666666667, 0.25, 0.5
7059, 1.7416666666667, 0.2, 0.5
7060, 1.7833333333333, 1.3, 0.5
7061, 1.7833333333333, 1.25, 0.5
7062, 1.7833333333333, 1.2, 0.5
7063, 1.7833333333333, 1.15, 0.5
7064, 1.7833333333333, 1.1, 0.5
7065, 1.7833333333333, 1.05, 0.5
7066, 1.7833333333333, 1, 0.5
7067, 1.7833333333333, 0.95, 0.5
7068, 1.7833333333333, 0.9, 0.5
7069, 1.7833333333333, 0.85, 0.5
7070, 1.7833333333333, 0.8, 0.5
7071, 1.7833333333333, 0.75, 0.5
7072, 1.7833333333333, 0.7, 0.5
7073, 1.7833333333333, 0.65, 0.5
7074, 1.7833333333333, 0.6, 0.5
7075, 1.7833333333333, 0.55, 0.5
7076, 1.7833333333333, 0.5, 0.5
7077, 1.7833333333333, 0.45, 0.5
7078, 1.7833333333333, 0.4, 0.5
7079, 1.7833333333333, 0.35, 0.5
7080, 1.7833333333333, 0.3, 0.5
7081, 1.7833333333333, 0.25, 0.5
7082, 1.7833333333333, 0.2, 0.5
7083, 1.825, 1.3, 0.5
7084, 1.825, 1.25, 0.5
7085, 1.825, 1.2, 0.5
7086, 1.825, 1.15, 0.5
7087, 1.825, 1.1, 0.5
7088, 1.825, 1.05, 0.5
7089, 1.825, 1, 0.5
7090, 1.825, 0.95, 0.5
7091, 1.825, 0.9, 0.5
7092, 1.825, 0.85, 0.5
7093, 1.825, 0.8, 0.5
7094, 1.825, 0.75, 0.5
7095, 1.825, 0.7, 0.5
7096, 1.825, 0.65, 0.5
7097, 1.825, 0.6, 0.5
7098, 1.825, 0.55, 0.5
7099, 1.825, 0.5, 0.5
7100, 1.825, 0.45, 0.5
7101, 1.825, 0.4, 0.5
7102, 1.825, 0.35, 0.5
7103, 1.825, 0.3, 0.5
7104, 1.825, 0.25, 0.5
7105, 1.825, 0.2, 0.5
7106, 1.8666666666667, 1.3, 0.5
7107, 1.8666666666667, 1.25, 0.5
7108, 1.8666666666667, 1.2, 0.5
7109, 1.8666666666667, 1.15, 0.5
7110, 1.8666666666667, 1.1, 0.5
7111, 1.8666666666667, 1.05, 0.5
7112, 1.8666666666667, 1, 0.5
7113, 1.8666666666667, 0.95, 0.5
7114, 1.8666666666667, 0.9, 0.5
7115, 1.8666666666667, 0.85, 0.5
7116, 1.8666666666667, 0.8, 0.5
7117, 1.8666666666667, 0.75, 0.5
7118, 1.8666666666667, 0.7, 0.5
7119, 1.8666666666667, 0.65, 0.5
7120, 1.8666666666667, 0.6, 0.5
7121, 1.8666666666667, 0.55, 0.5
7122, 1.8666666666667, 0.5, 0.5
7123, 1.8666666666667, 0.45, 0.5
7124, 1.8666666666667, 0.4, 0.5
7125, 1.8666666666667, 0.35, 0.5
7126, 1.8666666666667, 0.3, 0.5
7127, 1.8666666666667, 0.25, 0.5
7128, 1.8666666666667, 0.2, 0.5
7129, 1.9083333333333, 1.3, 0.5
7130, 1.9083333333333, 1.25, 0.5
7131, 1.9083333333333, 1.2, 0.5
7132, 1.9083333333333, 1.15, 0.5
7133, 1.9083333333333, 1.1, 0.5
7134, 1.9083333333333, 1.05, 0.5
7135, 1.9083333333333, 1, 0.5
7136, 1.9083333333333, 0.95, 0.5
7137, 1.9083333333333, 0.9, 0.5
7138, 1.9083333333333, 0.85, 0.5
7139, 1.9083333333333, 0.8, 0.5
7140, 1.9083333333333, 0.75, 0.5
7141, 1.9083333333333, 0.7, 0.5
7142, 1.9083333333333, 0.65, 0.5
7143, 1.9083333333333, 0.6, 0.5
7144, 1.9083333333333, 0.55, 0.5
7145, 1.9083333333333, 0.5, 0.5
7146, 1.9083333333333, 0.45, 0.5
7147, 1.9083333333333, 0.4, 0.5
7148, 1.9083333333333, 0.35, 0.5
7149, 1.9083333333333, 0.3, 0.5
7150, 1.9083333333333, 0.25, 0.5
7151, 1.9083333333333, 0.2, 0.5
7152, 1.95, 1.3, 0.5
7153, 1.95, 1.25, 0.5
7154, 1.95, 1.2, 0.5
7155, 1.95, 1.15, 0.5
7156, 1.95, 1.1, 0.5
7157, 1.95, 1.05, 0.5
7158, 1.95, 1, 0.5
7159, 1.95, 0.95, 0.5
7160, 1.95, 0.9, 0.5
7161, 1.95, 0.85, 0.5
7162, 1.95, 0.8, 0.5
7163, 1.95, 0.75, 0.5
7164, 1.95, 0.7, 0.5
7165, 1.95, 0.65, 0.5
7166, 1.95, 0.6, 0.5
7167, 1.95, 0.55, 0.5
7168, 1.95, 0.5, 0.5
7169, 1.95, 0.45, 0.5
7170, 1.95, 0.4, 0.5
7171, 1.95, 0.35, 0.5
7172, 1.95, 0.3, 0.5
7173, 1.95, 0.25, 0.5
7174, 1.95, 0.2, 0.5
7175, 1.9916666666667, 1.3, 0.5
7176, 1.9916666666667, 1.25, 0.5
7177, 1.9916666666667, 1.2, 0.5
7178, 1.9916666666667, 1.15, 0.5
7179, 1.9916666666667, 1.1, 0.5
7180, 1.9916666666667, 1.05, 0.5
7181, 1.9916666666667, 1, 0.5
7182, 1.9916666666667, 0.95, 0.5
7183, 1.9916666666667, 0.9, 0.5
7184, 1.9916666666667, 0.85, 0.5
7185, 1.9916666666667, 0.8, 0.5
7186, 1.9916666666667, 0.75, 0.5
7187, 1.9916666666667, 0.7, 0.5
7188, 1.9916666666667, 0.65, 0.5
7189, 1.9916666666667, 0.6, 0.5
7190, 1.9916666666667, 0.55, 0.5
7191, 1.9916666666667, 0.5, 0.5
7192, 1.9916666666667, 0.45, 0.5
7193, 1.9916666666667, 0.4, 0.5
7194, 1.9916666666667, 0.35, 0.5
7195, 1.9916666666667, 0.3, 0.5
7196, 1.9916666666667, 0.25, 0.5
7197, 1.9916666666667, 0.2, 0.5
7198, 2.0333333333333, 1.3, 0.5
7199, 2.0333333333333, 1.25, 0.5
7200, 2.0333333333333, 1.2, 0.5
7201, 2.0333333333333, 1.15, 0.5
7202, 2.0333333333333, 1.1, 0.5
7203, 2.0333333333333, 1.05, 0.5
7204, 2.0333333333333, 1, 0.5
7205, 2.0333333333333, 0.95, 0.5
7206, 2.0333333333333, 0.9, 0.5
7207, 2.0333333333333, 0.85, 0.5
7208, 2.0333333333333, 0.8, 0.5
7209, 2.0333333333333, 0.75, 0.5
7210, 2.0333333333333, 0.7, 0.5
7211, 2.0333333333333, 0.65, 0.5
7212, 2.0333333333333, 0.6, 0.5
7213, 2.0333333333333, 0.55, 0.5
7214, 2.0333333333333, 0.5, 0.5
7215, 2.0333333333333, 0.45, 0.5
7216, 2.0333333333333, 0.4, 0.5
7217, 2.0333333333333, 0.35, 0.5
7218, 2.0333333333333, 0.3, 0.5
7219, 2.0333333333333, 0.25, 0.5
7220, 2.0333333333333, 0.2, 0.5
7221, 2.075, 1.3, 0.5
7222, 2.075, 1.25, 0.5
7223, 2.075, 1.2, 0.5
7224, 2.075, 1.15, 0.5
7225, 2.075, 1.1, 0.5
7226, 2.075, 1.05, 0.5
7227, 2.075, 1, 0.5
7228, 2.075, 0.95, 0.5
7229, 2.075, 0.9, 0.5
7230, 2.075, 0.85, 0.5
7231, 2.075, 0.8, 0.5
7232, 2.075, 0.75, 0.5
7233, 2.075, 0.7, 0.5
7234, 2.075, 0.65, 0.5
7235, 2.075, 0.6, 0.5
7236, 2.075, 0.55, 0.5
7237, 2.075, 0.5, 0.5
7238, 2.075, 0.45, 0.5
7239, 2.075, 0.4, 0.5
7240, 2.075, 0.35, 0.5
7241, 2.075, 0.3, 0.5
7242, 2.075, 0.25, 0.5
7243, 2.075, 0.2, 0.5
7244, 2.1166666666667, 1.3, 0.5
7245, 2.1166666666667, 1.25, 0.5
7246, 2.1166666666667, 1.2, 0.5
7247, 2.1166666666667, 1.15, 0.5
7248, 2.1166666666667, 1.1, 0.5
7249, 2.1166666666667, 1.05, 0.5
7250, 2.1166666666667, 1, 0.5
7251, 2.1166666666667, 0.95, 0.5
7252, 2.1166666666667, 0.9, 0.5
7253, 2.1166666666667, 0.85, 0.5
7254, 2.1166666666667, 0.8, 0.5
7255, 2.1166666666667, 0.75, 0.5
7256, 2.1166666666667, 0.7, 0.5
7257, 2.1166666666667, 0.65, 0.5
7258, 2.1166666666667, 0.6, 0.5
7259, 2.1166666666667, 0.55, 0.5
7260, 2.1166666666667, 0.5, 0.5
7261, 2.1166666666667, 0.45, 0.5
7262, 2.1166666666667, 0.4, 0.5
7263, 2.1166666666667, 0.35, 0.5
7264, 2.1166666666667, 0.3, 0.5
7265, 2.1166666666667, 0.25, 0.5
7266, 2.1166666666667, 0.2, 0.5
7267, 2.1583333333333, 1.3, 0.5
7268, 2.1583333333333, 1.25, 0.5
7269, 2.1583333333333, 1.2, 0.5
7270, 2.1583333333333, 1.15, 0.5
7271, 2.1583333333333, 1.1, 0.5
7272, 2.1583333333333, 1.05, 0.5
7273, 2.1583333333333, 1, 0.5
7274, 2.1583333333333, 0.95, 0.5
7275, 2.1583333333333, 0.9, 0.5
7276, 2.1583333333333, 0.85, 0.5
7277, 2.1583333333333, 0.8, 0.5
7278, 2.1583333333333, 0.75, 0.5
7279, 2.1583333333333, 0.7, 0.5
7280, 2.1583333333333, 0.65, 0.5
7281, 2.1583333333333, 0.6, 0.5
7282, 2.1583333333333, 0.55, 0.5
7283, 2.1583333333333, 0.5, 0.5
7284, 2.1583333333333, 0.45, 0.5
7285, 2.1583333333333, 0.4, 0.5
7286, 2.1583333333333, 0.35, 0.5
7287, 2.1583333333333, 0.3, 0.5
7288, 2.1583333333333, 0.25, 0.5
7289, 2.1583333333333, 0.2, 0.5
7290, 1.2416666666667, 1.3, 0
7291, 1.2416666666667, 1.25, 0
7292, 1.2416666666667, 1.2, 0
7293, 1.2416666666667, 1.15, 0
7294, 1.2416666666667, 1.1, 0
7295, 1.2416666666667, 1.05, 0
7296, 1.2416666666667, 1, 0
7297, 1.2416666666667, 0.95, 0
7298, 1.2416666666667, 0.9, 0
7299, 1.2416666666667, 0.85, 0
7300, 1.2416666666667, 0.8, 0
7301, 1.2416666666667, 0.75, 0
7302, 1.2416666666667, 0.7, 0
7303, 1.2416666666667, 0.65, 0
7304, 1.2416666666667, 0.6, 0
7305, 1.2416666666667, 0.55, 0
7306, 1.2416666666667, 0.5, 0
7307, 1.2416666666667, 0.45, 0
7308, 1.2416666666667, 0.4, 0
7309, 1.2416666666667, 0.35, 0
7310, 1.2416666666667, 0.3, 0
7311, 1.2416666666667, 0.25, 0
7312, 1.2416666666667, 0.2, 0
7313, 1.2833333333333, 1.3, 0
7314, 1.2833333333333, 1.25, 0
7315, 1.2833333333333, 1.2, 0
7316, 1.2833333333333, 1.15, 0
7317, 1.2833333333333, 1.1, 0
7318, 1.2833333333333, 1.05, 0
7319, 1.2833333333333, 1, 0
7320, 1.2833333333333, 0.95, 0
7321, 1.2833333333333, 0.9, 0
7322, 1.2833333333333, 0.85, 0
7323, 1.2833333333333, 0.8, 0
7324, 1.2833333333333, 0.75, 0
7325, 1.2833333333333, 0.7, 0
7326, 1.2833333333333, 0.65, 0
7327, 1.2833333333333, 0.6, 0
7328, 1.2833333333333, 0.55, 0
7329, 1.2833333333333, 0.5, 0
7330, 1.2833333333333, 0.45, 0
7331, 1.2833333333333, 0.4, 0
7332, 1.2833333333333, 0.35, 0
7333, 1.2833333333333, 0.3, 0
7334, 1.2833333333333, 0.25, 0
7335, 1.2833333333333, 0.2, 0
7336, 1.325, 1.3, 0
7337, 1.325, 1.25, 0
7338, 1.325, 1.2, 0
7339, 1.325, 1.15, 0
7340, 1.325, 1.1, 0
7341, 1.325, 1.05, 0
7342, 1.325, 1, 0
7343, 1.325, 0.95, 0
7344, 1.325, 0.9, 0
7345, 1.325, 0.85, 0
7346, 1.325, 0.8, 0
7347, 1.325, 0.75, 0
7348, 1.325, 0.7, 0
7349, 1.325, 0.65, 0
7350, 1.325, 0.6, 0
7351, 1.325, 0.55, 0
7352, 1.325, 0.5, 0
7353, 1.325, 0.45, 0
7354, 1.325, 0.4, 0
7355, 1.325, 0.35, 0
7356, 1.325, 0.3, 0
7357, 1.325, 0.25, 0
7358, 1.325, 0.2, 0
7359, 1.3666666666667, 1.3, 0
7360, 1.3666666666667, 1.25, 0
7361, 1.3666666666667, 1.2, 0
7362, 1.3666666666667, 1.15, 0
7363, 1.3666666666667, 1.1, 0
7364, 1.3666666666667, 1.05, 0
7365, 1.3666666666667, 1, 0
7366, 1.3666666666667, 0.95, 0
7367, 1.3666666666667, 0.9, 0
7368, 1.3666666666667, 0.85, 0
7369, 1.3666666666667, 0.8, 0
7370, 1.3666666666667, 0.75, 0
7371, 1.3666666666667, 0.7, 0
7372, 1.3666666666667, 0.65, 0
7373, 1.3666666666667, 0.6, 0
7374, 1.3666666666667, 0.55, 0
7375, 1.3666666666667, 0.5, 0
7376, 1.3666666666667, 0.45, 0
7377, 1.3666666666667, 0.4, 0
7378, 1.3666666666667, 0.35, 0
7379, 1.3666666666667, 0.3, 0
7380, 1.3666666666667, 0.25, 0
7381, 1.3666666666667, 0.2, 0
7382, 1.4083333333333, 1.3, 0
7383, 1.4083333333333, 1.25, 0
7384, 1.4083333333333, 1.2, 0
7385, 1.4083333333333, 1.15, 0
7386, 1.4083333333333, 1.1, 0
7387, 1.4083333333333, 1.05, 0
7388, 1.4083333333333, 1, 0
7389, 1.4083333333333, 0.95, 0
7390, 1.4083333333333, 0.9, 0
7391, 1.4083333333333, 0.85, 0
7392, 1.4083333333333, 0.8, 0
7393, 1.4083333333333, 0.75, 0
7394, 1.4083333333333, 0.7, 0
7395, 1.4083333333333, 0.65, 0
7396, 1.4083333333333, 0.6, 0
7397, 1.4083333333333, 0.55, 0
7398, 1.4083333333333, 0.5, 0
7399, 1.4083333333333, 0.45, 0
7400, 1.4083333333333, 0.4, 0
7401, 1.4083333333333, 0.35, 0
7402, 1.4083333333333, 0.3, 0
7403, 1.4083333333333, 0.25, 0
7404, 1.4083333333333, 0.2, 0
7405, 1.45, 1.3, 0
7406, 1.45, 1.25, 0
7407, 1.45, 1.2, 0
7408, 1.45, 1.15, 0
7409, 1.45, 1.1, 0
7410, 1.45, 1.05, 0
7411, 1.45, 1, 0
7412, 1.45, 0.95, 0
7413, 1.45, 0.9, 0
7414, 1.45, 0.85, 0
7415, 1.45, 0.8, 0
7416, 1.45, 0.75, 0
7417, 1.45, 0.7, 0
7418, 1.45, 0.65, 0
7419, 1.45, 0.6, 0
7420, 1.45, 0.55, 0
7421, 1.45, 0.5, 0
7422, 1.45, 0.45, 0
7423, 1.45, 0.4, 0
7424, 1.45, 0.35, 0
7425, 1.45, 0.3, 0
7426, 1.45, 0.25, 0
7427, 1.45, 0.2, 0
7428, 1.4916666666667, 1.3, 0
7429, 1.4916666666667, 1.25, 0
7430, 1.4916666666667, 1.2, 0
7431, 1.4916666666667, 1.15, 0
7432, 1.4916666666667, 1.1, 0
7433, 1.4916666666667, 1.05, 0
7434, 1.4916666666667, 1, 0
7435, 1.4916666666667, 0.95, 0
7436, 1.4916666666667, 0.9, 0
7437, 1.4916666666667, 0.85, 0
7438, 1.4916666666667, 0.8, 0
7439, 1.4916666666667, 0.75, 0
7440, 1.4916666666667, 0.7, 0
7441, 1.4916666666667, 0.65, 0
7442, 1.4916666666667, 0.6, 0
7443, 1.4916666666667, 0.55, 0
7444, 1.4916666666667, 0.5, 0
7445, 1.4916666666667, 0.45, 0
7446, 1.4916666666667, 0.4, 0
7447, 1.4916666666667, 0.35, 0
7448, 1.4916666666667, 0.3, 0
7449, 1.4916666666667, 0.25, 0
7450, 1.4916666666667, 0.2, 0
7451, 1.5333333333333, 1.3, 0
7452, 1.5333333333333, 1.25, 0
7453, 1.5333333333333, 1.2, 0
7454, 1.5333333333333, 1.15, 0
7455, 1.5333333333333, 1.1, 0
7456, 1.5333333333333, 1.05, 0
7457, 1.5333333333333, 1, 0
7458, 1.5333333333333, 0.95, 0
7459, 1.5333333333333, 0.9, 0
7460, 1.5333333333333, 0.85, 0
7461, 1.5333333333333, 0.8, 0
7462, 1.5333333333333, 0.75, 0
7463, 1.5333333333333, 0.7, 0
7464, 1.5333333333333, 0.65, 0
7465, 1.5333333333333, 0.6, 0
7466, 1.5333333333333, 0.55, 0
7467, 1.5333333333333, 0.5, 0
7468, 1.5333333333333, 0.45, 0
7469, 1.5333333333333, 0.4, 0
7470, 1.5333333333333, 0.35, 0
7471, 1.5333333333333, 0.3, 0
7472, 1.5333333333333, 0.25, 0
7473, 1.5333333333333, 0.2, 0
7474, 1.575, 1.3, 0
7475, 1.575, 1.25, 0
7476, 1.575, 1.2, 0
7477, 1.575, 1.15, 0
7478, 1.575, 1.1, 0
7479, 1.575, 1.05, 0
7480, 1.575, 1, 0
7481, 1.575, 0.95, 0
7482, 1.575, 0.9, 0
7483, 1.575, 0.85, 0
7484, 1.575, 0.8, 0
7485, 1.575, 0.75, 0
7486, 1.575, 0.7, 0
7487, 1.575, 0.65, 0
7488, 1.575, 0.6, 0
7489, 1.575, 0.55, 0
7490, 1.575, 0.5, 0
7491, 1.575, 0.45, 0
7492, 1.575, 0.4, 0
7493, 1.575, 0.35, 0
7494, 1.575, 0.3, 0
7495, 1.575, 0.25, 0
7496, 1.575, 0.2, 0
7497, 1.6166666666667, 1.3, 0
7498, 1.6166666666667, 1.25, 0
7499, 1.6166666666667, 1.2, 0
7500, 1.6166666666667, 1.15, 0
7501, 1.6166666666667, 1.1, 0
7502, 1.6166666666667, 1.05, 0
7503, 1.6166666666667, 1, 0
7504, 1.6166666666667, 0.95, 0
7505, 1.6166666666667, 0.9, 0
7506, 1.6166666666667, 0.85, 0
7507, 1.6166666666667, 0.8, 0
7508, 1.6166666666667, 0.75, 0
7509, 1.6166666666667, 0.7, 0
7510, 1.6166666666667, 0.65, 0
7511, 1.6166666666667, 0.6, 0
7512, 1.6166666666667, 0.55, 0
7513, 1.6166666666667, 0.5, 0
7514, 1.6166666666667, 0.45, 0
7515, 1.6166666666667, 0.4, 0
7516, 1.6166666666667, 0.35, 0
7517, 1.6166666666667, 0.3, 0
7518, 1.6166666666667, 0.25, 0
7519, 1.6166666666667, 0.2, 0
7520, 1.6583333333333, 1.3, 0
7521, 1.6583333333333, 1.25, 0
7522, 1.6583333333333, 1.2, 0
7523, 1.6583333333333, 1.15, 0
7524, 1.6583333333333, 1.1, 0
7525, 1.6583333333333, 1.05, 0
7526, 1.6583333333333, 1, 0
7527, 1.6583333333333, 0.95, 0
7528, 1.6583333333333, 0.9, 0
7529, 1.6583333333333, 0.85, 0
7530, 1.6583333333333, 0.8, 0
7531, 1.6583333333333, 0.75, 0
7532, 1.6583333333333, 0.7, 0
7533, 1.6583333333333, 0.65, 0
7534, 1.6583333333333, 0.6, 0
7535, 1.6583333333333, 0.55, 0
7536, 1.6583333333333, 0.5, 0
7537, 1.6583333333333, 0.45, 0
7538, 1.6583333333333, 0.4, 0
7539, 1.6583333333333, 0.35, 0
7540, 1.6583333333333, 0.3, 0
7541, 1.6583333333333, 0.25, 0
7542, 1.6583333333333, 0.2, 0
7543, 1.7, 1.3, 0
7544, 1.7, 1.25, 0
7545, 1.7, 1.2, 0
7546, 1.7, 1.15, 0
7547, 1.7, 1.1, 0
7548, 1.7, 1.05, 0
7549, 1.7, 1, 0
7550, 1.7, 0.95, 0
7551, 1.7, 0.9, 0
7552, 1.7, 0.85, 0
7553, 1.7, 0.8, 0
7554, 1.7, 0.75, 0
7555, 1.7, 0.7, 0
7556, 1.7, 0.65, 0
7557, 1.7, 0.6, 0
7558, 1.7, 0.55, 0
7559, 1.7, 0.5, 0
7560, 1.7, 0.45, 0
7561, 1.7, 0.4, 0
7562, 1.7, 0.35, 0
7563, 1.7, 0.3, 0
7564, 1.7, 0.25, 0
7565, 1.7, 0.2, 0
7566, 1.7416666666667, 1.3, 0
7567, 1.7416666666667, 1.25, 0
7568, 1.7416666666667, 1.2, 0
7569, 1.7416666666667, 1.15, 0
7570, 1.7416666666667, 1.1, 0
7571, 1.7416666666667, 1.05, 0
7572, 1.7416666666667, 1, 0
7573, 1.7416666666667, 0.95, 0
7574, 1.7416666666667, 0.9, 0
7575, 1.7416666666667, 0.85, 0
7576, 1.7416666666667, 0.8, 0
7577, 1.7416666666667, 0.75, 0
7578, 1.7416666666667, 0.7, 0
7579, 1.7416666666667, 0.65, 0
7580, 1.7416666666667, 0.6, 0
7581, 1.7416666666667, 0.55, 0
7582, 1.7416666666667, 0.5, 0
7583, 1.7416666666667, 0.45, 0
7584, 1.7416666666667, 0.4, 0
7585, 1.7416666666667, 0.35, 0
7586, 1.7416666666667, 0.3, 0
7587, 1.7416666666667, 0.25, 0
7588, 1.7416666666667, 0.2, 0
7589, 1.7833333333333, 1.3, 0
7590, 1.7833333333333, 1.25, 0
7591, 1.7833333333333, 1.2, 0
7592, 1.7833333333333, 1.15, 0
7593, 1.7833333333333, 1.1, 0
7594, 1.7833333333333, 1.05, 0
7595, 1.7833333333333, 1, 0
7596, 1.7833333333333, 0.95, 0
7597, 1.7833333333333, 0.9, 0
7598, 1.7833333333333, 0.85, 0
7599, 1.7833333333333, 0.8, 0
7600, 1.7833333333333, 0.75, 0
7601, 1.7833333333333, 0.7, 0
7602, 1.7833333333333, 0.65, 0
7603, 1.7833333333333, 0.6, 0
7604, 1.7833333333333, 0.55, 0
7605, 1.7833333333333, 0.5, 0
7606, 1.7833333333333, 0.45, 0
7607, 1.7833333333333, 0.4, 0
7608, 1.7833333333333, 0.35, 0
7609, 1.7833333333333, 0.3, 0
7610, 1.7833333333333, 0.25, 0
7611, 1.7833333333333, 0.2, 0
7612, 1.825, 1.3, 0
7613, 1.825, 1.25, 0
7614, 1.825, 1.2, 0
7615, 1.825, 1.15, 0
7616, 1.825, 1.1, 0
7617, 1.825, 1.05, 0
7618, 1.825, 1, 0
7619, 1.825, 0.95, 0
7620, 1.825, 0.9, 0
7621, 1.825, 0.85, 0
7622, 1.825, 0.8, 0
7623, 1.825, 0.75, 0
7624, 1.825, 0.7, 0
7625, 1.825, 0.65, 0
7626, 1.825, 0.6, 0
7627, 1.825, 0.55, 0
7628, 1.825, 0.5, 0
7629, 1.825, 0.45, 0
7630, 1.825, 0.4, 0
7631, 1.825, 0.35, 0
7632, 1.825, 0.3, 0
7633, 1.825, 0.25, 0
7634, 1.825, 0.2, 0
7635, 1.8666666666667, 1.3, 0
7636, 1.8666666666667, 1.25, 0
7637, 1.8666666666667, 1.2, 0
7638, 1.8666666666667, 1.15, 0
7639, 1.8666666666667, 1.1, 0
7640, 1.8666666666667, 1.05, 0
7641, 1.8666666666667, 1, 0
7642, 1.8666666666667, 0.95, 0
7643, 1.8666666666667, 0.9, 0
7644, 1.8666666666667, 0.85, 0
7645, 1.8666666666667, 0.8, 0
7646, 1.8666666666667, 0.75, 0
7647, 1.8666666666667, 0.7, 0
7648, 1.8666666666667, 0.65, 0
7649, 1.8666666666667, 0.6, 0
7650, 1.8666666666667, 0.55, 0
7651, 1.8666666666667, 0.5, 0
7652, 1.8666666666667, 0.45, 0
7653, 1.8666666666667, 0.4, 0
7654, 1.8666666666667, 0.35, 0
7655, 1.8666666666667, 0.3, 0
7656, 1.8666666666667, 0.25, 0
7657, 1.8666666666667, 0.2, 0
7658, 1.9083333333333, 1.3, 0
7659, 1.9083333333333, 1.25, 0
7660, 1.9083333333333, 1.2, 0
7661, 1.9083333333333, 1.15, 0
7662, 1.9083333333333, 1.1, 0
7663, 1.9083333333333, 1.05, 0
7664, 1.9083333333333, 1, 0
7665, 1.9083333333333, 0.95, 0
7666, 1.9083333333333, 0.9, 0
7667, 1.9083333333333, 0.85, 0
7668, 1.9083333333333, 0.8, 0
7669, 1.9083333333333, 0.75, 0
7670, 1.9083333333333, 0.7, 0
7671, 1.9083333333333, 0.65, 0
7672, 1.9083333333333, 0.6, 0
7673, 1.9083333333333, 0.55, 0
7674, 1.9083333333333, 0.5, 0
7675, 1.9083333333333, 0.45, 0
7676, 1.9083333333333, 0.4, 0
7677, 1.9083333333333, 0.35, 0
7678, 1.9083333333333, 0.3, 0
7679, 1.9083333333333, 0.25, 0
7680, 1.9083333333333, 0.2, 0
7681, 1.95, 1.3, 0
7682, 1.95, 1.25, 0
7683, 1.95, 1.2, 0
7684, 1.95, 1.15, 0
7685, 1.95, 1.1, 0
7686, 1.95, 1.05, 0
7687, 1.95, 1, 0
7688, 1.95, 0.95, 0
7689, 1.95, 0.9, 0
7690, 1.95, 0.85, 0
7691, 1.95, 0.8, 0
7692, 1.95, 0.75, 0
7693, 1.95, 0.7, 0
7694, 1.95, 0.65, 0
7695, 1.95, 0.6, 0
7696, 1.95, 0.55, 0
7697, 1.95, 0.5, 0
7698, 1.95, 0.45, 0
7699, 1.95, 0.4, 0
7700, 1.95, 0.35, 0
7701, 1.95, 0.3, 0
7702, 1.95, 0.25, 0
7703, 1.95, 0.2, 0
7704, 1.9916666666667, 1.3, 0
7705, 1.9916666666667, 1.25, 0
7706, 1.9916666666667, 1.2, 0
7707, 1.9916666666667, 1.15, 0
7708, 1.9916666666667, 1.1, 0
7709, 1.9916666666667, 1.05, 0
7710, 1.9916666666667, 1, 0
7711, 1.9916666666667, 0.95, 0
7712, 1.9916666666667, 0.9, 0
7713, 1.9916666666667, 0.85, 0
7714, 1.9916666666667, 0.8, 0
7715, 1.9916666666667, 0.75, 0
7716, 1.9916666666667, 0.7, 0
7717, 1.9916666666667, 0.65, 0
7718, 1.9916666666667, 0.6, 0
7719, 1.9916666666667, 0.55, 0
7720, 1.9916666666667, 0.5, 0
7721, 1.9916666666667, 0.45, 0
7722, 1.9916666666667, 0.4, 0
7723, 1.9916666666667, 0.35, 0
7724, 1.9916666666667, 0.3, 0
7725, 1.9916666666667, 0.25, 0
7726, 1.9916666666667, 0.2, 0
7727, 2.0333333333333, 1.3, 0
7728, 2.0333333333333, 1.25, 0
7729, 2.0333333333333, 1.2, 0
7730, 2.0333333333333, 1.15, 0
7731, 2.0333333333333, 1.1, 0
7732, 2.0333333333333, 1.05, 0
7733, 2.0333333333333, 1, 0
7734, 2.0333333333333, 0.95, 0
7735, 2.0333333333333, 0.9, 0
7736, 2.0333333333333, 0.85, 0
7737, 2.0333333333333, 0.8, 0
7738, 2.0333333333333, 0.75, 0
7739, 2.0333333333333, 0.7, 0
7740, 2.0333333333333, 0.65, 0
7741, 2.0333333333333, 0.6, 0
7742, 2.0333333333333, 0.55, 0
7743, 2.0333333333333, 0.5, 0
7744, 2.0333333333333, 0.45, 0
7745, 2.0333333333333, 0.4, 0
7746, 2.0333333333333, 0.35, 0
7747, 2.0333333333333, 0.3, 0
7748, 2.0333333333333, 0.25, 0
7749, 2.0333333333333, 0.2, 0
7750, 2.075, 1.3, 0
7751, 2.075, 1.25, 0
7752, 2.075, 1.2, 0
7753, 2.075, 1.15, 0
7754, 2.075, 1.1, 0
7755, 2.075, 1.05, 0
7756, 2.075, 1, 0
7757, 2.075, 0.95, 0
7758, 2.075, 0.9, 0
7759, 2.075, 0.85, 0
7760, 2.075, 0.8, 0
7761, 2.075, 0.75, 0
7762, 2.075, 0.7, 0
7763, 2.075, 0.65, 0
7764, 2.075, 0.6, 0
7765, 2.075, 0.55, 0
7766, 2.075, 0.5, 0
7767, 2.075, 0.45, 0
7768, 2.075, 0.4, 0
7769, 2.075, 0.35, 0
7770, 2.075, 0.3, 0
7771, 2.075, 0.25, 0
7772, 2.075, 0.2, 0
7773, 2.1166666666667, 1.3, 0
7774, 2.1166666666667, 1.25, 0
7775, 2.1166666666667, 1.2, 0
7776, 2.1166666666667, 1.15, 0
7777, 2.1166666666667, 1.1, 0
7778, 2.1166666666667, 1.05, 0
7779, 2.1166666666667, 1, 0
7780, 2.1166666666667, 0.95, 0
7781, 2.1166666666667, 0.9, 0
7782, 2.1166666666667, 0.85, 0
7783, 2.1166666666667, 0.8, 0
7784, 2.1166666666667, 0.75, 0
7785, 2.1166666666667, 0.7, 0
7786, 2.1166666666667, 0.65, 0
7787, 2.1166666666667, 0.6, 0
7788, 2.1166666666667, 0.55, 0
7789, 2.1166666666667, 0.5, 0
7790, 2.1166666666667, 0.45, 0
7791, 2.1166666666667, 0.4, 0
7792, 2.1166666666667, 0.35, 0
7793, 2.1166666666667, 0.3, 0
7794, 2.1166666666667, 0.25, 0
7795, 2.1166666666667, 0.2, 0
7796, 2.1583333333333, 1.3, 0
7797, 2.1583333333333, 1.25, 0
7798, 2.1583333333333, 1.2, 0
7799, 2.1583333333333, 1.15, 0
7800, 2.1583333333333, 1.1, 0
7801, 2.1583333333333, 1.05, 0
7802, 2.1583333333333, 1, 0
7803, 2.1583333333333, 0.95, 0
7804, 2.1583333333333, 0.9, 0
7805, 2.1583333333333, 0.85, 0
7806, 2.1583333333333, 0.8, 0
7807, 2.1583333333333, 0.75, 0
7808, 2.1583333333333, 0.7, 0
7809, 2.1583333333333, 0.65, 0
7810, 2.1583333333333, 0.6, 0
7811, 2.1583333333333, 0.55, 0
7812, 2.1583333333333, 0.5, 0
7813, 2.1583333333333, 0.45, 0
7814, 2.1583333333333, 0.4, 0
7815, 2.1583333333333, 0.35, 0
7816, 2.1583333333333, 0.3, 0
7817, 2.1583333333333, 0.25, 0
7818, 2.1583333333333, 0.2, 0
7819, 1.2, 1.3, 0.041666666666667
7820, 1.2, 1.25, 0.041666666666667
7821, 1.2, 1.2, 0.041666666666667
7822, 1.2, 1.15, 0.041666666666667
7823, 1.2, 1.1, 0.041666666666667
7824, 1.2, 1.05, 0.041666666666667
7825, 1.2, 1, 0.041666666666667
7826, 1.2, 0.95, 0.041666666666667
7827, 1.2, 0.9, 0.041666666666667
7828, 1.2, 0.85, 0.041666666666667
7829, 1.2, 0.8, 0.041666666666667
7830, 1.2, 0.75, 0.041666666666667
7831, 1.2, 0.7, 0.041666666666667
7832, 1.2, 0.65, 0.041666666666667
7833, 1.2, 0.6, 0.041666666666667
7834, 1.2, 0.55, 0.041666666666667
7835, 1.2, 0.5, 0.041666666666667
7836, 1.2, 0.45, 0.041666666666667
7837, 1.2, 0.4, 0.041666666666667
7838, 1.2, 0.35, 0.041666666666667
7839, 1.2, 0.3, 0.041666666666667
7840, 1.2, 0.25, 0.041666666666667
7841, 1.2, 0.2, 0.041666666666667
7842, 1.2, 1.3, 0.083333333333333
7843, 1.2, 1.25, 0.083333333333333
7844, 1.2, 1.2, 0.083333333333333
7845, 1.2, 1.15, 0.083333333333333
7846, 1.2, 1.1, 0.083333333333333
7847, 1.2, 1.05, 0.083333333333333
7848, 1.2, 1, 0.083333333333333
7849, 1.2, 0.95, 0.083333333333333
7850, 1.2, 0.9, 0.083333333333333
7851, 1.2, 0.85, 0.083333333333333
7852, 1.2, 0.8, 0.083333333333333
7853, 1.2, 0.75, 0.083333333333333
7854, 1.2, 0.7, 0.083333333333333
7855, 1.2, 0.65, 0.083333333333333
7856, 1.2, 0.6, 0.083333333333333
7857, 1.2, 0.55, 0.083333333333333
7858, 1.2, 0.5, 0.083333333333333
7859, 1.2, 0.45, 0.083333333333333
7860, 1.2, 0.4, 0.083333333333333
7861, 1.2, 0.35, 0.083333333333333
7862, 1.2, 0.3, 0.083333333333333
7863, 1.2, 0.25, 0.083333333333333
7864, 1.2, 0.2, 0.083333333333333
7865, 1.2, 1.3, 0.125
7866, 1.2, 1.25, 0.125
7867, 1.2, 1.2, 0.125
7868, 1.2, 1.15, 0.125
7869, 1.2, 1.1, 0.125
7870, 1.2, 1.05, 0.125
7871, 1.2, 1, 0.125
7872, 1.2, 0.95, 0.125
7873, 1.2, 0.9, 0.125
7874, 1.2, 0.85, 0.125
7875, 1.2, 0.8, 0.125
7876, 1.2, 0.75, 0.125
7877, 1.2, 0.7, 0.125
7878, 1.2, 0.65, 0.125
7879, 1.2, 0.6, 0.125
7880, 1.2, 0.55, 0.125
7881, 1.2, 0.5, 0.125
7882, 1.2, 0.45, 0.125
7883, 1.2, 0.4, 0.125
7884, 1.2, 0.35, 0.125
7885, 1.2, 0.3, 0.125
7886, 1.2, 0.25, 0.125
7887, 1.2, 0.2, 0.125
7888, 1.2, 1.3, 0.16666666666667
7889, 1.2, 1.25, 0.16666666666667
7890, 1.2, 1.2, 0.16666666666667
7891, 1.2, 1.15, 0.16666666666667
7892, 1.2, 1.1, 0.16666666666667
7893, 1.2, 1.05, 0.16666666666667
7894, 1.2, 1, 0.16666666666667
7895, 1.2, 0.95, 0.16666666666667
7896, 1.2, 0.9, 0.16666666666667
7897, 1.2, 0.85, 0.16666666666667
7898, 1.2, 0.8, 0.16666666666667
7899, 1.2, 0.75, 0.16666666666667
7900, 1.2, 0.7, 0.16666666666667
7901, 1.2, 0.65, 0.16666666666667
7902, 1.2, 0.6, 0.16666666666667
7903, 1.2, 0.55, 0.16666666666667
7904, 1.2, 0.5, 0.16666666666667
7905, 1.2, 0.45, 0.16666666666667
7906, 1.2, 0.4, 0.16666666666667
7907, 1.2, 0.35, 0.16666666666667
7908, 1.2, 0.3, 0.16666666666667
7909, 1.2, 0.25, 0.16666666666667
7910, 1.2, 0.2, 0.16666666666667
7911, 1.2, 1.3, 0.20833333333333
7912, 1.2, 1.25, 0.20833333333333
7913, 1.2, 1.2, 0.20833333333333
7914, 1.2, 1.15, 0.20833333333333
7915, 1.2, 1.1, 0.20833333333333
7916, 1.2, 1.05, 0.20833333333333
7917, 1.2, 1, 0.20833333333333
7918, 1.2, 0.95, 0.20833333333333
7919, 1.2, 0.9, 0.20833333333333
7920, 1.2, 0.85, 0.20833333333333
7921, 1.2, 0.8, 0.20833333333333
7922, 1.2, 0.75, 0.20833333333333
7923, 1.2, 0.7, 0.20833333333333
7924, 1.2, 0.65, 0.20833333333333
7925, 1.2, 0.6, 0.20833333333333
7926, 1.2, 0.55, 0.20833333333333
7927, 1.2, 0.5, 0.20833333333333
7928, 1.2, 0.45, 0.20833333333333
7929, 1.2, 0.4, 0.20833333333333
7930, 1.2, 0.35, 0.20833333333333
7931, 1.2, 0.3, 0.20833333333333
7932, 1.2, 0.25, 0.20833333333333
7933, 1.2, 0.2, 0.20833333333333
7934, 1.2, 1.3, 0.25
7935, 1.2, 1.25, 0.25
7936, 1.2, 1.2, 0.25
7937, 1.2, 1.15, 0.25
7938, 1.2, 1.1, 0.25
7939, 1.2, 1.05, 0.25
7940, 1.2, 1, 0.25
7941, 1.2, 0.95, 0.25
7942, 1.2, 0.9, 0.25
7943, 1.2, 0.85, 0.25
7944, 1.2, 0.8, 0.25
7945, 1.2, 0.75, 0.25
7946, 1.2, 0.7, 0.25
7947, 1.2, 0.65, 0.25
7948, 1.2, 0.6, 0.25
7949, 1.2, 0.55, 0.25
7950, 1.2, 0.5, 0.25
7951, 1.2, 0.45, 0.25
7952, 1.2, 0.4, 0.25
7953, 1.2, 0.35, 0.25
7954, 1.2, 0.3, 0.25
7955, 1.2, 0.25, 0.25
7956, 1.2, 0.2, 0.25
7957, 1.2, 1.3, 0.29166666666667
7958, 1.2, 1.25, 0.29166666666667
7959, 1.2, 1.2, 0.29166666666667
7960, 1.2, 1.15, 0.29166666666667
7961, 1.2, 1.1, 0.29166666666667
7962, 1.2, 1.05, 0.29166666666667
7963, 1.2, 1, 0.29166666666667
7964, 1.2, 0.95, 0.29166666666667
7965, 1.2, 0.9, 0.29166666666667
7966, 1.2, 0.85, 0.29166666666667
7967, 1.2, 0.8, 0.29166666666667
7968, 1.2, 0.75, 0.29166666666667
7969, 1.2, 0.7, 0.29166666666667
7970, 1.2, 0.65, 0.29166666666667
7971, 1.2, 0.6, 0.29166666666667
7972, 1.2, 0.55, 0.29166666666667
7973, 1.2, 0.5, 0.29166666666667
7974, 1.2, 0.45, 0.29166666666667
7975, 1.2, 0.4, 0.29166666666667
7976, 1.2, 0.35, 0.29166666666667
7977, 1.2, 0.3, 0.29166666666667
7978, 1.2, 0.25, 0.29166666666667
7979, 1.2, 0.2, 0.29166666666667
7980, 1.2, 1.3, 0.33333333333333
7981, 1.2, 1.25, 0.33333333333333
7982, 1.2, 1.2, 0.33333333333333
7983, 1.2, 1.15, 0.33333333333333
7984, 1.2, 1.1, 0.33333333333333
7985, 1.2, 1.05, 0.33333333333333
7986, 1.2, 1, 0.33333333333333
7987, 1.2, 0.95, 0.33333333333333
7988, 1.2, 0.9, 0.33333333333333
7989, 1.2, 0.85, 0.33333333333333
7990, 1.2, 0.8, 0.33333333333333
7991, 1.2, 0.75, 0.33333333333333
7992, 1.2, 0.7, 0.33333333333333
7993, 1.2, 0.65, 0.33333333333333
7994, 1.2, 0.6, 0.33333333333333
7995, 1.2, 0.55, 0.33333333333333
7996, 1.2, 0.5, 0.33333333333333
7997, 1.2, 0.45, 0.33333333333333
7998, 1.2, 0.4, 0.33333333333333
7999, 1.2, 0.35, 0.33333333333333
8000, 1.2, 0.3, 0.33333333333333
8001, 1.2, 0.25, 0.33333333333333
8002, 1.2, 0.2, 0.33333333333333
8003, 1.2, 1.3, 0.375
8004, 1.2, 1.25, 0.375
8005, 1.2, 1.2, 0.375
8006, 1.2, 1.15, 0.375
8007, 1.2, 1.1, 0.375
8008, 1.2, 1.05, 0.375
8009, 1.2, 1, 0.375
8010, 1.2, 0.95, 0.375
8011, 1.2, 0.9, 0.375
8012, 1.2, 0.85, 0.375
8013, 1.2, 0.8, 0.375
8014, 1.2, 0.75, 0.375
8015, 1.2, 0.7, 0.375
8016, 1.2, 0.65, 0.375
8017, 1.2, 0.6, 0.375
8018, 1.2, 0.55, 0.375
8019, 1.2, 0.5, 0.375
8020, 1.2, 0.45, 0.375
8021, 1.2, 0.4, 0.375
8022, 1.2, 0.35, 0.375
8023, 1.2, 0.3, 0.375
8024, 1.2, 0.25, 0.375
8025, 1.2, 0.2, 0.375
8026, 1.2, 1.3, 0.41666666666667
8027, 1.2, 1.25, 0.41666666666667
8028, 1.2, 1.2, 0.41666666666667
8029, 1.2, 1.15, 0.41666666666667
8030, 1.2, 1.1, 0.41666666666667
8031, 1.2, 1.05, 0.41666666666667
8032, 1.2, 1, 0.41666666666667
8033, 1.2, 0.95, 0.41666666666667
8034, 1.2, 0.9, 0.41666666666667
8035, 1.2, 0.85, 0.41666666666667
8036, 1.2, 0.8, 0.41666666666667
8037, 1.2, 0.75, 0.41666666666667
8038, 1.2, 0.7, 0.41666666666667
8039, 1.2, 0.65, 0.41666666666667
8040, 1.2, 0.6, 0.41666666666667
8041, 1.2, 0.55, 0.41666666666667
8042, 1.2, 0.5, 0.41666666666667
8043, 1.2, 0.45, 0.41666666666667
8044, 1.2, 0.4, 0.41666666666667
8045, 1.2, 0.35, 0.41666666666667
8046, 1.2, 0.3, 0.41666666666667
8047, 1.2, 0.25, 0.41666666666667
8048, 1.2, 0.2, 0.41666666666667
8049, 1.2, 1.3, 0.45833333333333
8050, 1.2, 1.25, 0.45833333333333
8051, 1.2, 1.2, 0.45833333333333
8052, 1.2, 1.15, 0.45833333333333
8053, 1.2, 1.1, 0.45833333333333
8054, 1.2, 1.05, 0.45833333333333
8055, 1.2, 1, 0.45833333333333
8056, 1.2, 0.95, 0.45833333333333
8057, 1.2, 0.9, 0.45833333333333
8058, 1.2, 0.85, 0.45833333333333
8059, 1.2, 0.8, 0.45833333333333
8060, 1.2, 0.75, 0.45833333333333
8061, 1.2, 0.7, 0.45833333333333
8062, 1.2, 0.65, 0.45833333333333
8063, 1.2, 0.6, 0.45833333333333
8064, 1.2, 0.55, 0.45833333333333
8065, 1.2, 0.5, 0.45833333333333
8066, 1.2, 0.45, 0.45833333333333
8067, 1.2, 0.4, 0.45833333333333
8068, 1.2, 0.35, 0.45833333333333
8069, 1.2, 0.3, 0.45833333333333
8070, 1.2, 0.25, 0.45833333333333
8071, 1.2, 0.2, 0.45833333333333
8072, 2.2, 1.3, 0.041666666666667
8073, 2.2, 1.25, 0.041666666666667
8074, 2.2, 1.2, 0.041666666666667
8075, 2.2, 1.15, 0.041666666666667
8076, 2.2, 1.1, 0.041666666666667
8077, 2.2, 1.05, 0.041666666666667
8078, 2.2, 1, 0.041666666666667
8079, 2.2, 0.95, 0.041666666666667
8080, 2.2, 0.9, 0.041666666666667
8081, 2.2, 0.85, 0.041666666666667
8082, 2.2, 0.8, 0.041666666666667
8083, 2.2, 0.75, 0.041666666666667
8084, 2.2, 0.7, 0.041666666666667
8085, 2.2, 0.65, 0.041666666666667
8086, 2.2, 0.6, 0.041666666666667
8087, 2.2, 0.55, 0.041666666666667
8088, 2.2, 0.5, 0.041666666666667
8089, 2.2, 0.45, 0.041666666666667
8090, 2.2, 0.4, 0.041666666666667
8091, 2.2, 0.35, 0.041666666666667
8092, 2.2, 0.3, 0.041666666666667
8093, 2.2, 0.25, 0.041666666666667
8094, 2.2, 0.2, 0.041666666666667
8095, 2.2, 1.3, 0.083333333333333
8096, 2.2, 1.25, 0.083333333333333
8097, 2.2, 1.2, 0.083333333333333
8098, 2.2, 1.15, 0.083333333333333
8099, 2.2, 1.1, 0.083333333333333
8100, 2.2, 1.05, 0.083333333333333
8101, 2.2, 1, 0.083333333333333
8102, 2.2, 0.95, 0.083333333333333
8103, 2.2, 0.9, 0.083333333333333
8104, 2.2, 0.85, 0.083333333333333
8105, 2.2, 0.8, 0.083333333333333
8106, 2.2, 0.75, 0.083333333333333
8107, 2.2, 0.7, 0.083333333333333
8108, 2.2, 0.65, 0.083333333333333
8109, 2.2, 0.6, 0.083333333333333
8110, 2.2, 0.55, 0.083333333333333
8111, 2.2, 0.5, 0.083333333333333
8112, 2.2, 0.45, 0.083333333333333
8113, 2.2, 0.4, 0.083333333333333
8114, 2.2, 0.35, 0.083333333333333
8115, 2.2, 0.3, 0.083333333333333
8116, 2.2, 0.25, 0.083333333333333
8117, 2.2, 0.2, 0.083333333333333
8118, 2.2, 1.3, 0.125
8119, 2.2, 1.25, 0.125
8120, 2.2, 1.2, 0.125
8121, 2.2, 1.15, 0.125
8122, 2.2, 1.1, 0.125
8123, 2.2, 1.05, 0.125
8124, 2.2, 1, 0.125
8125, 2.2, 0.95, 0.125
8126, 2.2, 0.9, 0.125
8127, 2.2, 0.85, 0.125
8128, 2.2, 0.8, 0.125
8129, 2.2, 0.75, 0.125
8130, 2.2, 0.7, 0.125
8131, 2.2, 0.65, 0.125
8132, 2.2, 0.6, 0.125
8133, 2.2, 0.55, 0.125
8134, 2.2, 0.5, 0.125
8135, 2.2, 0.45, 0.125
8136, 2.2, 0.4, 0.125
8137, 2.2, 0.35, 0.125
8138, 2.2, 0.3, 0.125
8139, 2.2, 0.25, 0.125
8140, 2.2, 0.2, 0.125
8141, 2.2, 1.3, 0.16666666666667
8142, 2.2, 1.25, 0.16666666666667
8143, 2.2, 1.2, 0.16666666666667
8144, 2.2, 1.15, 0.16666666666667
8145, 2.2, 1.1, 0.16666666666667
8146, 2.2, 1.05, 0.16666666666667
8147, 2.2, 1, 0.16666666666667
8148, 2.2, 0.95, 0.16666666666667
8149, 2.2, 0.9, 0.16666666666667
8150, 2.2, 0.85, 0.16666666666667
8151, 2.2, 0.8, 0.16666666666667
8152, 2.2, 0.75, 0.16666666666667
8153, 2.2, 0.7, 0.16666666666667
8154, 2.2, 0.65, 0.16666666666667
8155, 2.2, 0.6, 0.16666666666667
8156, 2.2, 0.55, 0.16666666666667
8157, 2.2, 0.5, 0.16666666666667
8158, 2.2, 0.45, 0.16666666666667
8159, 2.2, 0.4, 0.16666666666667
8160, 2.2, 0.35, 0.16666666666667
8161, 2.2, 0.3, 0.16666666666667
8162, 2.2, 0.25, 0.16666666666667
8163, 2.2, 0.2, 0.16666666666667
8164, 2.2, 1.3, 0.20833333333333
8165, 2.2, 1.25, 0.20833333333333
8166, 2.2, 1.2, 0.20833333333333
8167, 2.2, 1.15, 0.20833333333333
8168, 2.2, 1.1, 0.20833333333333
8169, 2.2, 1.05, 0.20833333333333
8170, 2.2, 1, 0.20833333333333
8171, 2.2, 0.95, 0.20833333333333
8172, 2.2, 0.9, 0.20833333333333
8173, 2.2, 0.85, 0.20833333333333
8174, 2.2, 0.8, 0.20833333333333
8175, 2.2, 0.75, 0.20833333333333
8176, 2.2, 0.7, 0.20833333333333
8177, 2.2, 0.65, 0.20833333333333
8178, 2.2, 0.6, 0.20833333333333
8179, 2.2, 0.55, 0.20833333333333
8180, 2.2, 0.5, 0.20833333333333
8181, 2.2, 0.45, 0.20833333333333
8182, 2.2, 0.4, 0.20833333333333
8183, 2.2, 0.35, 0.20833333333333
8184, 2.2, 0.3, 0.20833333333333
8185, 2.2, 0.25, 0.20833333333333
8186, 2.2, 0.2, 0.20833333333333
8187, 2.2, 1.3, 0.25
8188, 2.2, 1.25, 0.25
8189, 2.2, 1.2, 0.25
8190, 2.2, 1.15, 0.25
8191, 2.2, 1.1, 0.25
8192, 2.2, 1.05, 0.25
8193, 2.2, 1, 0.25
8194, 2.2, 0.95, 0.25
8195, 2.2, 0.9, 0.25
8196, 2.2, 0.85, 0.25
8197, 2.2, 0.8, 0.25
8198, 2.2, 0.75, 0.25
8199, 2.2, 0.7, 0.25
8200, 2.2, 0.65, 0.25
8201, 2.2, 0.6, 0.25
8202, 2.2, 0.55, 0.25
8203, 2.2, 0.5, 0.25
8204, 2.2, 0.45, 0.25
8205, 2.2, 0.4, 0.25
8206, 2.2, 0.35, 0.25
8207, 2.2, 0.3, 0.25
8208, 2.2, 0.25, 0.25
8209, 2.2, 0.2, 0.25
8210, 2.2, 1.3, 0.29166666666667
8211, 2.2, 1.25, 0.29166666666667
8212, 2.2, 1.2, 0.29166666666667
8213, 2.2, 1.15, 0.29166666666667
8214, 2.2, 1.1, 0.29166666666667
8215, 2.2, 1.05, 0.29166666666667
8216, 2.2, 1, 0.29166666666667
8217, 2.2, 0.95, 0.29166666666667
8218, 2.2, 0.9, 0.29166666666667
8219, 2.2, 0.85, 0.29166666666667
8220, 2.2, 0.8, 0.29166666666667
8221, 2.2, 0.75, 0.29166666666667
8222, 2.2, 0.7, 0.29166666666667
8223, 2.2, 0.65, 0.29166666666667
8224, 2.2, 0.6, 0.29166666666667
8225, 2.2, 0.55, 0.29166666666667
8226, 2.2, 0.5, 0.29166666666667
8227, 2.2, 0.45, 0.29166666666667
8228, 2.2, 0.4, 0.29166666666667
8229, 2.2, 0.35, 0.29166666666667
8230, 2.2, 0.3, 0.29166666666667
8231, 2.2, 0.25, 0.29166666666667
8232, 2.2, 0.2, 0.29166666666667
8233, 2.2, 1.3, 0.33333333333333
8234, 2.2, 1.25, 0.33333333333333
8235, 2.2, 1.2, 0.33333333333333
8236, 2.2, 1.15, 0.33333333333333
8237, 2.2, 1.1, 0.33333333333333
8238, 2.2, 1.05, 0.33333333333333
8239, 2.2, 1, 0.33333333333333
8240, 2.2, 0.95, 0.33333333333333
8241, 2.2, 0.9, 0.33333333333333
8242, 2.2, 0.85, 0.33333333333333
8243, 2.2, 0.8, 0.33333333333333
8244, 2.2, 0.75, 0.33333333333333
8245, 2.2, 0.7, 0.33333333333333
8246, 2.2, 0.65, 0.33333333333333
8247, 2.2, 0.6, 0.33333333333333
8248, 2.2, 0.55, 0.33333333333333
8249, 2.2, 0.5, 0.33333333333333
8250, 2.2, 0.45, 0.33333333333333
8251, 2.2, 0.4, 0.33333333333333
8252, 2.2, 0.35, 0.33333333333333
8253, 2.2, 0.3, 0.33333333333333
8254, 2.2, 0.25, 0.33333333333333
8255, 2.2, 0.2, 0.33333333333333
8256, 2.2, 1.3, 0.375
8257, 2.2, 1.25, 0.375
8258, 2.2, 1.2, 0.375
8259, 2.2, 1.15, 0.375
8260, 2.2, 1.1, 0.375
8261, 2.2, 1.05, 0.375
8262, 2.2, 1, 0.375
8263, 2.2, 0.95, 0.375
8264, 2.2, 0.9, 0.375
8265, 2.2, 0.85, 0.375
8266, 2.2, 0.8, 0.375
8267, 2.2, 0.75, 0.375
8268, 2.2, 0.7, 0.375
8269, 2.2, 0.65, 0.375
8270, 2.2, 0.6, 0.375
8271, 2.2, 0.55, 0.375
8272, 2.2, 0.5, 0.375
8273, 2.2, 0.45, 0.375
8274, 2.2, 0.4, 0.375
8275, 2.2, 0.35, 0.375
8276, 2.2, 0.3, 0.375
8277, 2.2, 0.25, 0.375
8278, 2.2, 0.2, 0.375
8279, 2.2, 1.3, 0.41666666666667
8280, 2.2, 1.25, 0.41666666666667
8281, 2.2, 1.2, 0.41666666666667
8282, 2.2, 1.15, 0.41666666666667
8283, 2.2, 1.1, 0.41666666666667
8284, 2.2, 1.05, 0.41666666666667
8285, 2.2, 1, 0.41666666666667
8286, 2.2, 0.95, 0.41666666666667
8287, 2.2, 0.9, 0.41666666666667
8288, 2.2, 0.85, 0.41666666666667
8289, 2.2, 0.8, 0.41666666666667
8290, 2.2, 0.75, 0.41666666666667
8291, 2.2, 0.7, 0.41666666666667
8292, 2.2, 0.65, 0.41666666666667
8293, 2.2, 0.6, 0.41666666666667
8294, 2.2, 0.55, 0.41666666666667
8295, 2.2, 0.5, 0.41666666666667
8296, 2.2, 0.45, 0.41666666666667
8297, 2.2, 0.4, 0.41666666666667
8298, 2.2, 0.35, 0.41666666666667
8299, 2.2, 0.3, 0.41666666666667
8300, 2.2, 0.25, 0.41666666666667
8301, 2.2, 0.2, 0.41666666666667
8302, 2.2, 1.3, 0.45833333333333
8303, 2.2, 1.25, 0.45833333333333
8304, 2.2, 1.2, 0.45833333333333
8305, 2.2, 1.15, 0.45833333333333
8306, 2.2, 1.1, 0.45833333333333
8307, 2.2, 1.05, 0.45833333333333
8308, 2.2, 1, 0.45833333333333
8309, 2.2, 0.95, 0.45833333333333
8310, 2.2, 0.9, 0.45833333333333
8311, 2.2, 0.85, 0.45833333333333
8312, 2.2, 0.8, 0.45833333333333
8313, 2.2, 0.75, 0.45833333333333
8314, 2.2, 0.7, 0.45833333333333
8315, 2.2, 0.65, 0.45833333333333
8316, 2.2, 0.6, 0.45833333333333
8317, 2.2, 0.55, 0.45833333333333
8318, 2.2, 0.5, 0.45833333333333
8319, 2.2, 0.45, 0.45833333333333
8320, 2.2, 0.4, 0.45833333333333
8321, 2.2, 0.35, 0.45833333333333
8322, 2.2, 0.3, 0.45833333333333
8323, 2.2, 0.25, 0.45833333333333
8324, 2.2, 0.2, 0.45833333333333
8325, 1.2416666666667, 0.15, 0.041666666666667
8326, 1.2833333333333, 0.15, 0.041666666666667
8327, 1.325, 0.15, 0.041666666666667
8328, 1.3666666666667, 0.15, 0.041666666666667
8329, 1.4083333333333, 0.15, 0.041666666666667
8330, 1.45, 0.15, 0.041666666666667
8331, 1.4916666666667, 0.15, 0.041666666666667
8332, 1.5333333333333, 0.15, 0.041666666666667
8333, 1.575, 0.15, 0.041666666666667
8334, 1.6166666666667, 0.15, 0.041666666666667
8335, 1.6583333333333, 0.15, 0.041666666666667
8336, 1.7, 0.15, 0.041666666666667
8337, 1.7416666666667, 0.15, 0.041666666666667
8338, 1.7833333333333, 0.15, 0.041666666666667
8339, 1.825, 0.15, 0.041666666666667
8340, 1.8666666666667, 0.15, 0.041666666666667
8341, 1.9083333333333, 0.15, 0.041666666666667
8342, 1.95, 0.15, 0.041666666666667
8343, 1.9916666666667, 0.15, 0.041666666666667
8344, 2.0333333333333, 0.15, 0.041666666666667
8345, 2.075, 0.15, 0.041666666666667
8346, 2.1166666666667, 0.15, 0.041666666666667
8347, 2.1583333333333, 0.15, 0.041666666666667
8348, 1.2416666666667, 0.15, 0.083333333333333
8349, 1.2833333333333, 0.15, 0.083333333333333
8350, 1.325, 0.15, 0.083333333333333
8351, 1.3666666666667, 0.15, 0.083333333333333
8352, 1.4083333333333, 0.15, 0.083333333333333
8353, 1.45, 0.15, 0.083333333333333
8354, 1.4916666666667, 0.15, 0.083333333333333
8355, 1.5333333333333, 0.15, 0.083333333333333
8356, 1.575, 0.15, 0.083333333333333
8357, 1.6166666666667, 0.15, 0.083333333333333
8358, 1.6583333333333, 0.15, 0.083333333333333
8359, 1.7, 0.15, 0.083333333333333
8360, 1.7416666666667, 0.15, 0.083333333333333
8361, 1.7833333333333, 0.15, 0.083333333333333
8362, 1.825, 0.15, 0.083333333333333
8363, 1.8666666666667, 0.15, 0.083333333333333
8364, 1.9083333333333, 0.15, 0.083333333333333
8365, 1.95, 0.15, 0.083333333333333
8366, 1.9916666666667, 0.15, 0.083333333333333
8367, 2.0333333333333, 0.15, 0.083333333333333
8368, 2.075, 0.15, 0.083333333333333
8369, 2.1166666666667, 0.15, 0.083333333333333
8370, 2.1583333333333, 0.15, 0.083333333333333
8371, 1.2416666666667, 0.15, 0.125
8372, 1.2833333333333, 0.15, 0.125
8373, 1.325, 0.15, 0.125
8374, 1.3666666666667, 0.15, 0.125
8375, 1.4083333333333, 0.15, 0.125
8376, 1.45, 0.15, 0.125
8377, 1.4916666666667, 0.15, 0.125
8378, 1.5333333333333, 0.15, 0.125
8379, 1.575, 0.15, 0.125
8380, 1.6166666666667, 0.15, 0.125
8381, 1.6583333333333, 0.15, 0.125
8382, 1.7, 0.15, 0.125
8383, 1.7416666666667, 0.15, 0.125
8384, 1.7833333333333, 0.15, 0.125
8385, 1.825, 0.15, 0.125
8386, 1.8666666666667, 0.15, 0.125
8387, 1.9083333333333, 0.15, 0.125
8388, 1.95, 0.15, 0.125
8389, 1.9916666666667, 0.15, 0.125
8390, 2.0333333333333, 0.15, 0.125
8391, 2.075, 0.15, 0.125
8392, 2.1166666666667, 0.15, 0.125
8393, 2.1583333333333, 0.15, 0.125
8394, 1.2416666666667, 0.15, 0.16666666666667
8395, 1.2833333333333, 0.15, 0.16666666666667
8396, 1.325, 0.15, 0.16666666666667
8397, 1.3666666666667, 0.15, 0.16666666666667
8398, 1.4083333333333, 0.15, 0.16666666666667
8399, 1.45, 0.15, 0.16666666666667
8400, 1.4916666666667, 0.15, 0.16666666666667
8401, 1.5333333333333, 0.15, 0.16666666666667
8402, 1.575, 0.15, 0.16666666666667
8403, 1.6166666666667, 0.15, 0.16666666666667
8404, 1.6583333333333, 0.15, 0.16666666666667
8405, 1.7, 0.15, 0.16666666666667
8406, 1.7416666666667, 0.15, 0.16666666666667
8407, 1.7833333333333, 0.15, 0.16666666666667
8408, 1.825, 0.15, 0.16666666666667
8409, 1.8666666666667, 0.15, 0.16666666666667
8410, 1.9083333333333, 0.15, 0.16666666666667
8411, 1.95, 0.15, 0.16666666666667
8412, 1.9916666666667, 0.15, 0.16666666666667
8413, 2.0333333333333, 0.15, 0.16666666666667
8414, 2.075, 0.15, 0.16666666666667
8415, 2.1166666666667, 0.15, 0.16666666666667
8416, 2.1583333333333, 0.15, 0.16666666666667
8417, 1.2416666666667, 0.15, 0.20833333333333
8418, 1.2833333333333, 0.15, 0.20833333333333
8419, 1.325, 0.15, 0.20833333333333
8420, 1.3666666666667, 0.15, 0.20833333333333
8421, 1.4083333333333, 0.15, 0.20833333333333
8422, 1.45, 0.15, 0.20833333333333
8423, 1.4916666666667, 0.15, 0.20833333333333
8424, 1.5333333333333, 0.15, 0.20833333333333
8425, 1.575, 0.15, 0.20833333333333
8426, 1.6166666666667, 0.15, 0.20833333333333
8427, 1.6583333333333, 0.15, 0.20833333333333
8428, 1.7, 0.15, 0.20833333333333
8429, 1.7416666666667, 0.15, 0.20833333333333
8430, 1.7833333333333, 0.15, 0.20833333333333
8431, 1.825, 0.15, 0.20833333333333
8432, 1.8666666666667, 0.15, 0.20833333333333
8433, 1.9083333333333, 0.15, 0.20833333333333
8434, 1.95, 0.15, 0.20833333333333
8435, 1.9916666666667, 0.15, 0.20833333333333
8436, 2.0333333333333, 0.15, 0.20833333333333
8437, 2.075, 0.15, 0.20833333333333
8438, 2.1166666666667, 0.15, 0.20833333333333
8439, 2.1583333333333, 0.15, 0.20833333333333
8440, 1.2416666666667, 0.15, 0.25
8441, 1.2833333333333, 0.15, 0.25
8442, 1.325, 0.15, 0.25
8443, 1.3666666666667, 0.15, 0.25
8444, 1.4083333333333, 0.15, 0.25
8445, 1.45, 0.15, 0.25
8446, 1.4916666666667, 0.15, 0.25
8447, 1.5333333333333, 0.15, 0.25
8448, 1.575, 0.15, 0.25
8449, 1.6166666666667, 0.15, 0.25
8450, 1.6583333333333, 0.15, 0.25
8451, 1.7, 0.15, 0.25
8452, 1.7416666666667, 0.15, 0.25
8453, 1.7833333333333, 0.15, 0.25
8454, 1.825, 0.15, 0.25
8455, 1.8666666666667, 0.15, 0.25
8456, 1.9083333333333, 0.15, 0.25
8457, 1.95, 0.15, 0.25
8458, 1.9916666666667, 0.15, 0.25
8459, 2.0333333333333, 0.15, 0.25
8460, 2.075, 0.15, 0.25
8461, 2.1166666666667, 0.15, 0.25
8462, 2.1583333333333, 0.15, 0.25
8463, 1.2416666666667, 0.15, 0.29166666666667
8464, 1.2833333333333, 0.15, 0.29166666666667
8465, 1.325, 0.15, 0.29166666666667
8466, 1.3666666666667, 0.15, 0.29166666666667
8467, 1.4083333333333, 0.15, 0.29166666666667
8468, 1.45, 0.15, 0.29166666666667
8469, 1.4916666666667, 0.15, 0.29166666666667
8470, 1.5333333333333, 0.15, 0.29166666666667
8471, 1.575, 0.15, 0.29166666666667
8472, 1.6166666666667, 0.15, 0.29166666666667
8473, 1.6583333333333, 0.15, 0.29166666666667
8474, 1.7, 0.15, 0.29166666666667
8475, 1.7416666666667, 0.15, 0.29166666666667
8476, 1.7833333333333, 0.15, 0.29166666666667
8477, 1.825, 0.15, 0.29166666666667
8478, 1.8666666666667, 0.15, 0.29166666666667
8479, 1.9083333333333, 0.15, 0.29166666666667
8480, 1.95, 0.15, 0.29166666666667
8481, 1.9916666666667, 0.15, 0.29166666666667
8482, 2.0333333333333, 0.15, 0.29166666666667
8483, 2.075, 0.15, 0.29166666666667
8484, 2.1166666666667, 0.15, 0.29166666666667
8485, 2.1583333333333, 0.15, 0.29166666666667
8486, 1.2416666666667, 0.15, 0.33333333333333
8487, 1.2833333333333, 0.15, 0.33333333333333
8488, 1.325, 0.15, 0.33333333333333
8489, 1.3666666666667, 0.15, 0.33333333333333
8490, 1.4083333333333, 0.15, 0.33333333333333
8491, 1.45, 0.15, 0.33333333333333
8492, 1.4916666666667, 0.15, 0.33333333333333
8493, 1.5333333333333, 0.15, 0.33333333333333
8494, 1.575, 0.15, 0.33333333333333
8495, 1.6166666666667, 0.15, 0.33333333333333
8496, 1.6583333333333, 0.15, 0.33333333333333
8497, 1.7, 0.15, 0.33333333333333
8498, 1.7416666666667, 0.15, 0.33333333333333
8499, 1.7833333333333, 0.15, 0.33333333333333
8500, 1.825, 0.15, 0.33333333333333
8501, 1.8666666666667, 0.15, 0.33333333333333
8502, 1.9083333333333, 0.15, 0.33333333333333
8503, 1.95, 0.15, 0.33333333333333
8504, 1.9916666666667, 0.15, 0.33333333333333
8505, 2.0333333333333, 0.15, 0.33333333333333
8506, 2.075, 0.15, 0.33333333333333
8507, 2.1166666666667, 0.15, 0.33333333333333
8508, 2.1583333333333, 0.15, 0.33333333333333
8509, 1.2416666666667, 0.15, 0.375
8510, 1.2833333333333, 0.15, 0.375
8511, 1.325, 0.15, 0.375
8512, 1.3666666666667, 0.15, 0.375
8513, 1.4083333333333, 0.15, 0.375
8514, 1.45, 0.15, 0.375
8515, 1.4916666666667, 0.15, 0.375
8516, 1.5333333333333, 0.15, 0.375
8517, 1.575, 0.15, 0.375
8518, 1.6166666666667, 0.15, 0.375
8519, 1.6583333333333, 0.15, 0.375
8520, 1.7, 0.15, 0.375
8521, 1.7416666666667, 0.15, 0.375
8522, 1.7833333333333, 0.15, 0.375
8523, 1.825, 0.15, 0.375
8524, 1.8666666666667, 0.15, 0.375
8525, 1.9083333333333, 0.15, 0.375
8526, 1.95, 0.15, 0.375
8527, 1.9916666666667, 0.15, 0.375
8528, 2.0333333333333, 0.15, 0.375
8529, 2.075, 0.15, 0.375
8530, 2.1166666666667, 0.15, 0.375
8531, 2.1583333333333, 0.15, 0.375
8532, 1.2416666666667, 0.15, 0.41666666666667
8533, 1.2833333333333, 0.15, 0.41666666666667
8534, 1.325, 0.15, 0.41666666666667
8535, 1.3666666666667, 0.15, 0.41666666666667
8536, 1.4083333333333, 0.15, 0.41666666666667
8537, 1.45, 0.15, 0.41666666666667
8538, 1.4916666666667, 0.15, 0.41666666666667
8539, 1.5333333333333, 0.15, 0.41666666666667
8540, 1.575, 0.15, 0.41666666666667
8541, 1.6166666666667, 0.15, 0.41666666666667
8542, 1.6583333333333, 0.15, 0.41666666666667
8543, 1.7, 0.15, 0.41666666666667
8544, 1.7416666666667, 0.15, 0.41666666666667
8545, 1.7833333333333, 0.15, 0.41666666666667
8546, 1.825, 0.15, 0.41666666666667
8547, 1.8666666666667, 0.15, 0.41666666666667
8548, 1.9083333333333, 0.15, 0.41666666666667
8549, 1.95, 0.15, 0.41666666666667
8550, 1.9916666666667, 0.15, 0.41666666666667
8551, 2.0333333333333, 0.15, 0.41666666666667
8552, 2.075, 0.15, 0.41666666666667
8553, 2.1166666666667, 0.15, 0.41666666666667
8554, 2.1583333333333, 0.15, 0.41666666666667
8555, 1.2416666666667, 0.15, 0.45833333333333
8556, 1.2833333333333, 0.15, 0.45833333333333
8557, 1.325, 0.15, 0.45833333333333
8558, 1.3666666666667, 0.15, 0.45833333333333
8559, 1.4083333333333, 0.15, 0.45833333333333
8560, 1.45, 0.15, 0.45833333333333
8561, 1.4916666666667, 0.15, 0.45833333333333
8562, 1.5333333333333, 0.15, 0.45833333333333
8563, 1.575, 0.15, 0.45833333333333
8564, 1.6166666666667, 0.15, 0.45833333333333
8565, 1.6583333333333, 0.15, 0.45833333333333
8566, 1.7, 0.15, 0.45833333333333
8567, 1.7416666666667, 0.15, 0.45833333333333
8568, 1.7833333333333, 0.15, 0.45833333333333
8569, 1.825, 0.15, 0.45833333333333
8570, 1.8666666666667, 0.15, 0.45833333333333
8571, 1.9083333333333, 0.15, 0.45833333333333
8572, 1.95, 0.15, 0.45833333333333
8573, 1.9916666666667, 0.15, 0.45833333333333
8574, 2.0333333333333, 0.15, 0.45833333333333
8575, 2.075, 0.15, 0.45833333333333
8576, 2.1166666666667, 0.15, 0.45833333333333
8577, 2.1583333333333, 0.15, 0.45833333333333
8578, 1.2416666666667, 0.125, 0
8579, 1.2833333333333, 0.125, 0
8580, 1.325, 0.125, 0
8581, 1.3666666666667, 0.125, 0
8582, 1.4083333333333, 0.125, 0
8583, 1.45, 0.125, 0
8584, 1.4916666666667, 0.125, 0
8585, 1.5333333333333, 0.125, 0
8586, 1.575, 0.125, 0
8587, 1.6166666666667, 0.125, 0
8588, 1.6583333333333, 0.125, 0
8589, 1.7, 0.125, 0
8590, 1.7416666666667, 0.125, 0
8591, 1.7833333333333, 0.125, 0
8592, 1.825, 0.125, 0
8593, 1.8666666666667, 0.125, 0
8594, 1.9083333333333, 0.125, 0
8595, 1.95, 0.125, 0
8596, 1.9916666666667, 0.125, 0
8597, 2.0333333333333, 0.125, 0
8598, 2.075, 0.125, 0
8599, 2.1166666666667, 0.125, 0
8600, 2.1583333333333, 0.125, 0
8601, 1.2, 0.125, 0.041666666666667
8602, 1.2, 0.125, 0.083333333333333
8603, 1.2, 0.125, 0.125
8604, 1.2, 0.125, 0.16666666666667
8605, 1.2, 0.125, 0.20833333333333
8606, 1.2, 0.125, 0.25
8607, 1.2, 0.125, 0.29166666666667
8608, 1.2, 0.125, 0.33333333333333
8609, 1.2, 0.125, 0.375
8610, 1.2, 0.125, 0.41666666666667
8611, 1.2, 0.125, 0.45833333333333
8612, 2.2, 0.125, 0.041666666666667
8613, 2.2, 0.125, 0.083333333333333
8614, 2.2, 0.125, 0.125
8615, 2.2, 0.125, 0.16666666666667
8616, 2.2, 0.125, 0.20833333333333
8617, 2.2, 0.125, 0.25
8618, 2.2, 0.125, 0.29166666666667
8619, 2.2, 0.125, 0.33333333333333
8620, 2.2, 0.125, 0.375
8621, 2.2, 0.125, 0.41666666666667
8622, 2.2, 0.125, 0.45833333333333
8623, 1.2416666666667, 0.1, 0.041666666666667
8624, 1.2833333333333, 0.1, 0.041666666666667
8625, 1.325, 0.1, 0.041666666666667
8626, 1.3666666666667, 0.1, 0.041666666666667
8627, 1.4083333333333, 0.1, 0.041666666666667
8628, 1.45, 0.1, 0.041666666666667
8629, 1.4916666666667, 0.1, 0.041666666666667
8630, 1.5333333333333, 0.1, 0.041666666666667
8631, 1.575, 0.1, 0.041666666666667
8632, 1.6166666666667, 0.1, 0.041666666666667
8633, 1.6583333333333, 0.1, 0.041666666666667
8634, 1.7, 0.1, 0.041666666666667
8635, 1.7416666666667, 0.1, 0.041666666666667
8636, 1.7833333333333, 0.1, 0.041666666666667
8637, 1.825, 0.1, 0.041666666666667
8638, 1.8666666666667, 0.1, 0.041666666666667
8639, 1.9083333333333, 0.1, 0.041666666666667
8640, 1.95, 0.1, 0.041666666666667
8641, 1.9916666666667, 0.1, 0.041666666666667
8642, 2.0333333333333, 0.1, 0.041666666666667
8643, 2.075, 0.1, 0.041666666666667
8644, 2.1166666666667, 0.1, 0.041666666666667
8645, 2.1583333333333, 0.1, 0.041666666666667
8646, 1.2416666666667, 0.1, 0.083333333333333
8647, 1.2833333333333, 0.1, 0.083333333333333
8648, 1.325, 0.1, 0.083333333333333
8649, 1.3666666666667, 0.1, 0.083333333333333
8650, 1.4083333333333, 0.1, 0.083333333333333
8651, 1.45, 0.1, 0.083333333333333
8652, 1.4916666666667, 0.1, 0.083333333333333
8653, 1.5333333333333, 0.1, 0.083333333333333
8654, 1.575, 0.1, 0.083333333333333
8655, 1.6166666666667, 0.1, 0.083333333333333
8656, 1.6583333333333, 0.1, 0.083333333333333
8657, 1.7, 0.1, 0.083333333333333
8658, 1.7416666666667, 0.1, 0.083333333333333
8659, 1.7833333333333, 0.1, 0.083333333333333
8660, 1.825, 0.1, 0.083333333333333
8661, 1.8666666666667, 0.1, 0.083333333333333
8662, 1.9083333333333, 0.1, 0.083333333333333
8663, 1.95, 0.1, 0.083333333333333
8664, 1.9916666666667, 0.1, 0.083333333333333
8665, 2.0333333333333, 0.1, 0.083333333333333
8666, 2.075, 0.1, 0.083333333333333
8667, 2.1166666666667, 0.1, 0.083333333333333
8668, 2.1583333333333, 0.1, 0.083333333333333
8669, 1.2416666666667, 0.1, 0.125
8670, 1.2833333333333, 0.1, 0.125
8671, 1.325, 0.1, 0.125
8672, 1.3666666666667, 0.1, 0.125
8673, 1.4083333333333, 0.1, 0.125
8674, 1.45, 0.1, 0.125
8675, 1.4916666666667, 0.1, 0.125
8676, 1.5333333333333, 0.1, 0.125
8677, 1.575, 0.1, 0.125
8678, 1.6166666666667, 0.1, 0.125
8679, 1.6583333333333, 0.1, 0.125
8680, 1.7, 0.1, 0.125
8681, 1.7416666666667, 0.1, 0.125
8682, 1.7833333333333, 0.1, 0.125
8683, 1.825, 0.1, 0.125
8684, 1.8666666666667, 0.1, 0.125
8685, 1.9083333333333, 0.1, 0.125
8686, 1.95, 0.1, 0.125
8687, 1.9916666666667, 0.1, 0.125
8688, 2.0333333333333, 0.1, 0.125
8689, 2.075, 0.1, 0.125
8690, 2.1166666666667, 0.1, 0.125
8691, 2.1583333333333, 0.1, 0.125
8692, 1.2416666666667, 0.1, 0.16666666666667
8693, 1.2833333333333, 0.1, 0.16666666666667
8694, 1.325, 0.1, 0.16666666666667
8695, 1.3666666666667, 0.1, 0.16666666666667
8696, 1.4083333333333, 0.1, 0.16666666666667
8697, 1.45, 0.1, 0.16666666666667
8698, 1.4916666666667, 0.1, 0.16666666666667
8699, 1.5333333333333, 0.1, 0.16666666666667
8700, 1.575, 0.1, 0.16666666666667
8701, 1.6166666666667, 0.1, 0.16666666666667
8702, 1.6583333333333, 0.1, 0.16666666666667
8703, 1.7, 0.1, 0.16666666666667
8704, 1.7416666666667, 0.1, 0.16666666666667
8705, 1.7833333333333, 0.1, 0.16666666666667
8706, 1.825, 0.1, 0.16666666666667
8707, 1.8666666666667, 0.1, 0.16666666666667
8708, 1.9083333333333, 0.1, 0.16666666666667
8709, 1.95, 0.1, 0.16666666666667
8710, 1.9916666666667, 0.1, 0.16666666666667
8711, 2.0333333333333, 0.1, 0.16666666666667
8712, 2.075, 0.1, 0.16666666666667
8713, 2.1166666666667, 0.1, 0.16666666666667
8714, 2.1583333333333, 0.1, 0.16666666666667
8715, 1.2416666666667, 0.1, 0.20833333333333
8716, 1.2833333333333, 0.1, 0.20833333333333
8717, 1.325, 0.1, 0.20833333333333
8718, 1.3666666666667, 0.1, 0.20833333333333
8719, 1.4083333333333, 0.1, 0.20833333333333
8720, 1.45, 0.1, 0.20833333333333
8721, 1.4916666666667, 0.1, 0.20833333333333
8722, 1.5333333333333, 0.1, 0.20833333333333
8723, 1.575, 0.1, 0.20833333333333
8724, 1.6166666666667, 0.1, 0.20833333333333
8725, 1.6583333333333, 0.1, 0.20833333333333
8726, 1.7, 0.1, 0.20833333333333
8727, 1.7416666666667, 0.1, 0.20833333333333
8728, 1.7833333333333, 0.1, 0.20833333333333
8729, 1.825, 0.1, 0.20833333333333
8730, 1.8666666666667, 0.1, 0.20833333333333
8731, 1.9083333333333, 0.1, 0.20833333333333
8732, 1.95, 0.1, 0.20833333333333
8733, 1.9916666666667, 0.1, 0.20833333333333
8734, 2.0333333333333, 0.1, 0.20833333333333
8735, 2.075, 0.1, 0.20833333333333
8736, 2.1166666666667, 0.1, 0.20833333333333
8737, 2.1583333333333, 0.1, 0.20833333333333
8738, 1.2416666666667, 0.1, 0.25
8739, 1.2833333333333, 0.1, 0.25
8740, 1.325, 0.1, 0.25
8741, 1.3666666666667, 0.1, 0.25
8742, 1.4083333333333, 0.1, 0.25
8743, 1.45, 0.1, 0.25
8744, 1.4916666666667, 0.1, 0.25
8745, 1.5333333333333, 0.1, 0.25
8746, 1.575, 0.1, 0.25
8747, 1.6166666666667, 0.1, 0.25
8748, 1.6583333333333, 0.1, 0.25
8749, 1.7, 0.1, 0.25
8750, 1.7416666666667, 0.1, 0.25
8751, 1.7833333333333, 0.1, 0.25
8752, 1.825, 0.1, 0.25
8753, 1.8666666666667, 0.1, 0.25
8754, 1.9083333333333, 0.1, 0.25
8755, 1.95, 0.1, 0.25
8756, 1.9916666666667, 0.1, 0.25
8757, 2.0333333333333, 0.1, 0.25
8758, 2.075, 0.1, 0.25
8759, 2.1166666666667, 0.1, 0.25
8760, 2.1583333333333, 0.1, 0.25
8761, 1.2416666666667, 0.1, 0.29166666666667
8762, 1.2833333333333, 0.1, 0.29166666666667
8763, 1.325, 0.1, 0.29166666666667
8764, 1.3666666666667, 0.1, 0.29166666666667
8765, 1.4083333333333, 0.1, 0.29166666666667
8766, 1.45, 0.1, 0.29166666666667
8767, 1.4916666666667, 0.1, 0.29166666666667
8768, 1.5333333333333, 0.1, 0.29166666666667
8769, 1.575, 0.1, 0.29166666666667
8770, 1.6166666666667, 0.1, 0.29166666666667
8771, 1.6583333333333, 0.1, 0.29166666666667
8772, 1.7, 0.1, 0.29166666666667
8773, 1.7416666666667, 0.1, 0.29166666666667
8774, 1.7833333333333, 0.1, 0.29166666666667
8775, 1.825, 0.1, 0.29166666666667
8776, 1.8666666666667, 0.1, 0.29166666666667
8777, 1.9083333333333, 0.1, 0.29166666666667
8778, 1.95, 0.1, 0.29166666666667
8779, 1.9916666666667, 0.1, 0.29166666666667
8780, 2.0333333333333, 0.1, 0.29166666666667
8781, 2.075, 0.1, 0.29166666666667
8782, 2.1166666666667, 0.1, 0.29166666666667
8783, 2.1583333333333, 0.1, 0.29166666666667
8784, 1.2416666666667, 0.1, 0.33333333333333
8785, 1.2833333333333, 0.1, 0.33333333333333
8786, 1.325, 0.1, 0.33333333333333
8787, 1.3666666666667, 0.1, 0.33333333333333
8788, 1.4083333333333, 0.1, 0.33333333333333
8789, 1.45, 0.1, 0.33333333333333
8790, 1.4916666666667, 0.1, 0.33333333333333
8791, 1.5333333333333, 0.1, 0.33333333333333
8792, 1.575, 0.1, 0.33333333333333
8793, 1.6166666666667, 0.1, 0.33333333333333
8794, 1.6583333333333, 0.1, 0.33333333333333
8795, 1.7, 0.1, 0.33333333333333
8796, 1.7416666666667, 0.1, 0.33333333333333
8797, 1.7833333333333, 0.1, 0.33333333333333
8798, 1.825, 0.1, 0.33333333333333
8799, 1.8666666666667, 0.1, 0.33333333333333
8800, 1.9083333333333, 0.1, 0.33333333333333
8801, 1.95, 0.1, 0.33333333333333
8802, 1.9916666666667, 0.1, 0.33333333333333
8803, 2.0333333333333, 0.1, 0.33333333333333
8804, 2.075, 0.1, 0.33333333333333
8805, 2.1166666666667, 0.1, 0.33333333333333
8806, 2.1583333333333, 0.1, 0.33333333333333
8807, 1.2416666666667, 0.1, 0.375
8808, 1.2833333333333, 0.1, 0.375
8809, 1.325, 0.1, 0.375
8810, 1.3666666666667, 0.1, 0.375
8811, 1.4083333333333, 0.1, 0.375
8812, 1.45, 0.1, 0.375
8813, 1.4916666666667, 0.1, 0.375
8814, 1.5333333333333, 0.1, 0.375
8815, 1.575, 0.1, 0.375
8816, 1.6166666666667, 0.1, 0.375
8817, 1.6583333333333, 0.1, 0.375
8818, 1.7, 0.1, 0.375
8819, 1.7416666666667, 0.1, 0.375
8820, 1.7833333333333, 0.1, 0.375
8821, 1.825, 0.1, 0.375
8822, 1.8666666666667, 0.1, 0.375
8823, 1.9083333333333, 0.1, 0.375
8824, 1.95, 0.1, 0.375
8825, 1.9916666666667, 0.1, 0.375
8826, 2.0333333333333, 0.1, 0.375
8827, 2.075, 0.1, 0.375
8828, 2.1166666666667, 0.1, 0.375
8829, 2.1583333333333, 0.1, 0.375
8830, 1.2416666666667, 0.1, 0.41666666666667
8831, 1.2833333333333, 0.1, 0.41666666666667
8832, 1.325, 0.1, 0.41666666666667
8833, 1.3666666666667, 0.1, 0.41666666666667
8834, 1.4083333333333, 0.1, 0.41666666666667
8835, 1.45, 0.1, 0.41666666666667
8836, 1.4916666666667, 0.1, 0.41666666666667
8837, 1.5333333333333, 0.1, 0.41666666666667
8838, 1.575, 0.1, 0.41666666666667
8839, 1.6166666666667, 0.1, 0.41666666666667
8840, 1.6583333333333, 0.1, 0.41666666666667
8841, 1.7, 0.1, 0.41666666666667
8842, 1.7416666666667, 0.1, 0.41666666666667
8843, 1.7833333333333, 0.1, 0.41666666666667
8844, 1.825, 0.1, 0.41666666666667
8845, 1.8666666666667, 0.1, 0.41666666666667
8846, 1.9083333333333, 0.1, 0.41666666666667
8847, 1.95, 0.1, 0.41666666666667
8848, 1.9916666666667, 0.1, 0.41666666666667
8849, 2.0333333333333, 0.1, 0.41666666666667
8850, 2.075, 0.1, 0.41666666666667
8851, 2.1166666666667, 0.1, 0.41666666666667
8852, 2.1583333333333, 0.1, 0.41666666666667
8853, 1.2416666666667, 0.1, 0.45833333333333
8854, 1.2833333333333, 0.1, 0.45833333333333
8855, 1.325, 0.1, 0.45833333333333
8856, 1.3666666666667, 0.1, 0.45833333333333
8857, 1.4083333333333, 0.1, 0.45833333333333
8858, 1.45, 0.1, 0.45833333333333
8859, 1.4916666666667, 0.1, 0.45833333333333
8860, 1.5333333333333, 0.1, 0.45833333333333
8861, 1.575, 0.1, 0.45833333333333
8862, 1.6166666666667, 0.1, 0.45833333333333
8863, 1.6583333333333, 0.1, 0.45833333333333
8864, 1.7, 0.1, 0.45833333333333
8865, 1.7416666666667, 0.1, 0.45833333333333
8866, 1.7833333333333, 0.1, 0.45833333333333
8867, 1.825, 0.1, 0.45833333333333
8868, 1.8666666666667, 0.1, 0.45833333333333
8869, 1.9083333333333, 0.1, 0.45833333333333
8870, 1.95, 0.1, 0.45833333333333
8871, 1.9916666666667, 0.1, 0.45833333333333
8872, 2.0333333333333, 0.1, 0.45833333333333
8873, 2.075, 0.1, 0.45833333333333
8874, 2.1166666666667, 0.1, 0.45833333333333
8875, 2.1583333333333, 0.1, 0.45833333333333
8876, 1.2416666666667, 0.1, 0.020833333333333
8877, 1.2208333333333, 0.1, 0.041666666666667
8878, 1.2833333333333, 0.1, 0.020833333333333
8879, 1.2625, 0.1, 0.041666666666667
8880, 1.325, 0.1, 0.020833333333333
8881, 1.3041666666667, 0.1, 0.041666666666667
8882, 1.3666666666667, 0.1, 0.020833333333333
8883, 1.3458333333333, 0.1, 0.041666666666667
8884, 1.4083333333333, 0.1, 0.020833333333333
8885, 1.3875, 0.1, 0.041666666666667
8886, 1.45, 0.1, 0.020833333333333
8887, 1.4291666666667, 0.1, 0.041666666666667
8888, 1.4916666666667, 0.1, 0.020833333333333
8889, 1.4708333333333, 0.1, 0.041666666666667
8890, 1.5333333333333, 0.1, 0.020833333333333
8891, 1.5125, 0.1, 0.041666666666667
8892, 1.575, 0.1, 0.020833333333333
8893, 1.5541666666667, 0.1, 0.041666666666667
8894, 1.6166666666667, 0.1, 0.020833333333333
8895, 1.5958333333333, 0.1, 0.041666666666667
8896, 1.6583333333333, 0.1, 0.020833333333333
8897, 1.6375, 0.1, 0.041666666666667
8898, 1.7, 0.1, 0.020833333333333
8899, 1.6791666666667, 0.1, 0.041666666666667
8900, 1.7416666666667, 0.1, 0.020833333333333
8901, 1.7208333333333, 0.1, 0.041666666666667
8902, 1.7833333333333, 0.1, 0.020833333333333
8903, 1.7625, 0.1, 0.041666666666667
8904, 1.825, 0.1, 0.020833333333333
8905, 1.8041666666667, 0.1, 0.041666666666667
8906, 1.8666666666667, 0.1, 0.020833333333333
8907, 1.8458333333333, 0.1, 0.041666666666667
8908, 1.9083333333333, 0.1, 0.020833333333333
8909, 1.8875, 0.1, 0.041666666666667
8910, 1.95, 0.1, 0.020833333333333
8911, 1.9291666666667, 0.1, 0.041666666666667
8912, 1.9916666666667, 0.1, 0.020833333333333
8913, 1.9708333333333, 0.1, 0.041666666666667
8914, 2.0333333333333, 0.1, 0.020833333333333
8915, 2.0125, 0.1, 0.041666666666667
8916, 2.075, 0.1, 0.020833333333333
8917, 2.0541666666667, 0.1, 0.041666666666667
8918, 2.1166666666667, 0.1, 0.020833333333333
8919, 2.0958333333333, 0.1, 0.041666666666667
8920, 2.1583333333333, 0.1, 0.020833333333333
8921, 2.1375, 0.1, 0.041666666666667
8922, 2.1791666666667, 0.1, 0.041666666666667
8923, 1.2416666666667, 0.1, 0.0625
8924, 1.2208333333333, 0.1, 0.083333333333333
8925, 1.2833333333333, 0.1, 0.0625
8926, 1.2625, 0.1, 0.083333333333333
8927, 1.325, 0.1, 0.0625
8928, 1.3041666666667, 0.1, 0.083333333333333
8929, 1.3666666666667, 0.1, 0.0625
8930, 1.3458333333333, 0.1, 0.083333333333333
8931, 1.4083333333333, 0.1, 0.0625
8932, 1.3875, 0.1, 0.083333333333333
8933, 1.45, 0.1, 0.0625
8934, 1.4291666666667, 0.1, 0.083333333333333
8935, 1.4916666666667, 0.1, 0.0625
8936, 1.4708333333333, 0.1, 0.083333333333333
8937, 1.5333333333333, 0.1, 0.0625
8938, 1.5125, 0.1, 0.083333333333333
8939, 1.575, 0.1, 0.0625
8940, 1.5541666666667, 0.1, 0.083333333333333
8941, 1.6166666666667, 0.1, 0.0625
8942, 1.5958333333333, 0.1, 0.083333333333333
8943, 1.6583333333333, 0.1, 0.0625
8944, 1.6375, 0.1, 0.083333333333333
8945, 1.7, 0.1, 0.0625
8946, 1.6791666666667, 0.1, 0.083333333333333
8947, 1.7416666666667, 0.1, 0.0625
8948, 1.7208333333333, 0.1, 0.083333333333333
8949, 1.7833333333333, 0.1, 0.0625
8950, 1.7625, 0.1, 0.083333333333333
8951, 1.825, 0.1, 0.0625
8952, 1.8041666666667, 0.1, 0.083333333333333
8953, 1.8666666666667, 0.1, 0.0625
8954, 1.8458333333333, 0.1, 0.083333333333333
8955, 1.9083333333333, 0.1, 0.0625
8956, 1.8875, 0.1, 0.083333333333333
8957, 1.95, 0.1, 0.0625
8958, 1.9291666666667, 0.1, 0.083333333333333
8959, 1.9916666666667, 0.1, 0.0625
8960, 1.9708333333333, 0.1, 0.083333333333333
8961, 2.0333333333333, 0.1, 0.0625
8962, 2.0125, 0.1, 0.083333333333333
8963, 2.075, 0.1, 0.0625
8964, 2.0541666666667, 0.1, 0.083333333333333
8965, 2.1166666666667, 0.1, 0.0625
8966, 2.0958333333333, 0.1, 0.083333333333333
8967, 2.1583333333333, 0.1, 0.0625
8968, 2.1375, 0.1, 0.083333333333333
8969, 2.1791666666667, 0.1, 0.083333333333333
8970, 1.2416666666667, 0.1, 0.10416666666667
8971, 1.2208333333333, 0.1, 0.125
8972, 1.2833333333333, 0.1, 0.10416666666667
8973, 1.2625, 0.1, 0.125
8974, 1.325, 0.1, 0.10416666666667
8975, 1.3041666666667, 0.1, 0.125
8976, 1.3666666666667, 0.1, 0.10416666666667
8977, 1.3458333333333, 0.1, 0.125
8978, 1.4083333333333, 0.1, 0.10416666666667
8979, 1.3875, 0.1, 0.125
8980, 1.45, 0.1, 0.10416666666667
8981, 1.4291666666667, 0.1, 0.125
8982, 1.4916666666667, 0.1, 0.10416666666667
8983, 1.4708333333333, 0.1, 0.125
8984, 1.5333333333333, 0.1, 0.10416666666667
8985, 1.5125, 0.1, 0.125
8986, 1.575, 0.1, 0.10416666666667
8987, 1.5541666666667, 0.1, 0.125
8988, 1.6166666666667, 0.1, 0.10416666666667
8989, 1.5958333333333, 0.1, 0.125
8990, 1.6583333333333, 0.1, 0.10416666666667
8991, 1.6375, 0.1, 0.125
8992, 1.7, 0.1, 0.10416666666667
8993, 1.6791666666667, 0.1, 0.125
8994, 1.7416666666667, 0.1, 0.10416666666667
8995, 1.7208333333333, 0.1, 0.125
8996, 1.7833333333333, 0.1, 0.10416666666667
8997, 1.7625, 0.1, 0.125
8998, 1.825, 0.1, 0.10416666666667
8999, 1.8041666666667, 0.1, 0.125
9000, 1.8666666666667, 0.1, 0.10416666666667
9001, 1.8458333333333, 0.1, 0.125
9002, 1.9083333333333, 0.1, 0.10416666666667
9003, 1.8875, 0.1, 0.125
9004, 1.95, 0.1, 0.10416666666667
9005, 1.9291666666667, 0.1, 0.125
9006, 1.9916666666667, 0.1, 0.10416666666667
9007, 1.9708333333333, 0.1, 0.125
9008, 2.0333333333333, 0.1, 0.10416666666667
9009, 2.0125, 0.1, 0.125
9010, 2.075, 0.1, 0.10416666666667
9011, 2.0541666666667, 0.1, 0.125
9012, 2.1166666666667, 0.1, 0.10416666666667
9013, 2.0958333333333, 0.1, 0.125
9014, 2.1583333333333, 0.1, 0.10416666666667
9015, 2.1375, 0.1, 0.125
9016, 2.1791666666667, 0.1, 0.125
9017, 1.2416666666667, 0.1, 0.14583333333333
9018, 1.2208333333333, 0.1, 0.16666666666667
9019, 1.2833333333333, 0.1, 0.14583333333333
9020, 1.2625, 0.1, 0.16666666666667
9021, 1.325, 0.1, 0.14583333333333
9022, 1.3041666666667, 0.1, 0.16666666666667
9023, 1.3666666666667, 0.1, 0.14583333333333
9024, 1.3458333333333, 0.1, 0.16666666666667
9025, 1.4083333333333, 0.1, 0.14583333333333
9026, 1.3875, 0.1, 0.16666666666667
9027, 1.45, 0.1, 0.14583333333333
9028, 1.4291666666667, 0.1, 0.16666666666667
9029, 1.4916666666667, 0.1, 0.14583333333333
9030, 1.4708333333333, 0.1, 0.16666666666667
9031, 1.5333333333333, 0.1, 0.14583333333333
9032, 1.5125, 0.1, 0.16666666666667
9033, 1.575, 0.1, 0.14583333333333
9034, 1.5541666666667, 0.1, 0.16666666666667
9035, 1.6166666666667, 0.1, 0.14583333333333
9036, 1.5958333333333, 0.1, 0.16666666666667
9037, 1.6583333333333, 0.1, 0.14583333333333
9038, 1.6375, 0.1, 0.16666666666667
9039, 1.7, 0.1, 0.14583333333333
9040, 1.6791666666667, 0.1, 0.16666666666667
9041, 1.7416666666667, 0.1, 0.14583333333333
9042, 1.7208333333333, 0.1, 0.16666666666667
9043, 1.7833333333333, 0.1, 0.14583333333333
9044, 1.7625, 0.1, 0.16666666666667
9045, 1.825, 0.1, 0.14583333333333
9046, 1.8041666666667, 0.1, 0.16666666666667
9047, 1.8666666666667, 0.1, 0.14583333333333
9048, 1.8458333333333, 0.1, 0.16666666666667
9049, 1.9083333333333, 0.1, 0.14583333333333
9050, 1.8875, 0.1, 0.16666666666667
9051, 1.95, 0.1, 0.14583333333333
9052, 1.9291666666667, 0.1, 0.16666666666667
9053, 1.9916666666667, 0.1, 0.14583333333333
9054, 1.9708333333333, 0.1, 0.16666666666667
9055, 2.0333333333333, 0.1, 0.14583333333333
9056, 2.0125, 0.1, 0.16666666666667
9057, 2.075, 0.1, 0.14583333333333
9058, 2.0541666666667, 0.1, 0.16666666666667
9059, 2.1166666666667, 0.1, 0.14583333333333
9060, 2.0958333333333, 0.1, 0.16666666666667
9061, 2.1583333333333, 0.1, 0.14583333333333
9062, 2.1375, 0.1, 0.16666666666667
9063, 2.1791666666667, 0.1, 0.16666666666667
9064, 1.2416666666667, 0.1, 0.1875
9065, 1.2208333333333, 0.1, 0.20833333333333
9066, 1.2833333333333, 0.1, 0.1875
9067, 1.2625, 0.1, 0.20833333333333
9068, 1.325, 0.1, 0.1875
9069, 1.3041666666667, 0.1, 0.20833333333333
9070, 1.3666666666667, 0.1, 0.1875
9071, 1.3458333333333, 0.1, 0.20833333333333
9072, 1.4083333333333, 0.1, 0.1875
9073, 1.3875, 0.1, 0.20833333333333
9074, 1.45, 0.1, 0.1875
9075, 1.4291666666667, 0.1, 0.20833333333333
9076, 1.4916666666667, 0.1, 0.1875
9077, 1.4708333333333, 0.1, 0.20833333333333
9078, 1.5333333333333, 0.1, 0.1875
9079, 1.5125, 0.1, 0.20833333333333
9080, 1.575, 0.1, 0.1875
9081, 1.5541666666667, 0.1, 0.20833333333333
9082, 1.6166666666667, 0.1, 0.1875
9083, 1.5958333333333, 0.1, 0.20833333333333
9084, 1.6583333333333, 0.1, 0.1875
9085, 1.6375, 0.1, 0.20833333333333
9086, 1.7, 0.1, 0.1875
9087, 1.6791666666667, 0.1, 0.20833333333333
9088, 1.7416666666667, 0.1, 0.1875
9089, 1.7208333333333, 0.1, 0.20833333333333
9090, 1.7833333333333, 0.1, 0.1875
9091, 1.7625, 0.1, 0.20833333333333
9092, 1.825, 0.1, 0.1875
9093, 1.8041666666667, 0.1, 0.20833333333333
9094, 1.8666666666667, 0.1, 0.1875
9095, 1.8458333333333, 0.1, 0.20833333333333
9096, 1.9083333333333, 0.1, 0.1875
9097, 1.8875, 0.1, 0.20833333333333
9098, 1.95, 0.1, 0.1875
9099, 1.9291666666667, 0.1, 0.20833333333333
9100, 1.9916666666667, 0.1, 0.1875
9101, 1.9708333333333, 0.1, 0.20833333333333
9102, 2.0333333333333, 0.1, 0.1875
9103, 2.0125, 0.1, 0.20833333333333
9104, 2.075, 0.1, 0.1875
9105, 2.0541666666667, 0.1, 0.20833333333333
9106, 2.1166666666667, 0.1, 0.1875
9107, 2.0958333333333, 0.1, 0.20833333333333
9108, 2.1583333333333, 0.1, 0.1875
9109, 2.1375, 0.1, 0.20833333333333
9110, 2.1791666666667, 0.1, 0.20833333333333
9111, 1.2416666666667, 0.1, 0.22916666666667
9112, 1.2208333333333, 0.1, 0.25
9113, 1.2833333333333, 0.1, 0.22916666666667
9114, 1.2625, 0.1, 0.25
9115, 1.325, 0.1, 0.22916666666667
9116, 1.3041666666667, 0.1, 0.25
9117, 1.3666666666667, 0.1, 0.22916666666667
9118, 1.3458333333333, 0.1, 0.25
9119, 1.4083333333333, 0.1, 0.22916666666667
9120, 1.3875, 0.1, 0.25
9121, 1.45, 0.1, 0.22916666666667
9122, 1.4291666666667, 0.1, 0.25
9123, 1.4916666666667, 0.1, 0.22916666666667
9124, 1.4708333333333, 0.1, 0.25
9125, 1.5333333333333, 0.1, 0.22916666666667
9126, 1.5125, 0.1, 0.25
9127, 1.575, 0.1, 0.22916666666667
9128, 1.5541666666667, 0.1, 0.25
9129, 1.6166666666667, 0.1, 0.22916666666667
9130, 1.5958333333333, 0.1, 0.25
9131, 1.6583333333333, 0.1, 0.22916666666667
9132, 1.6375, 0.1, 0.25
9133, 1.7, 0.1, 0.22916666666667
9134, 1.6791666666667, 0.1, 0.25
9135, 1.7416666666667, 0.1, 0.22916666666667
9136, 1.7208333333333, 0.1, 0.25
9137, 1.7833333333333, 0.1, 0.22916666666667
9138, 1.7625, 0.1, 0.25
9139, 1.825, 0.1, 0.22916666666667
9140, 1.8041666666667, 0.1, 0.25
9141, 1.8666666666667, 0.1, 0.22916666666667
9142, 1.8458333333333, 0.1, 0.25
9143, 1.9083333333333, 0.1, 0.22916666666667
9144, 1.8875, 0.1, 0.25
9145, 1.95, 0.1, 0.22916666666667
9146, 1.9291666666667, 0.1, 0.25
9147, 1.9916666666667, 0.1, 0.22916666666667
9148, 1.9708333333333, 0.1, 0.25
9149, 2.0333333333333, 0.1, 0.22916666666667
9150, 2.0125, 0.1, 0.25
9151, 2.075, 0.1, 0.22916666666667
9152, 2.0541666666667, 0.1, 0.25
9153, 2.1166666666667, 0.1, 0.22916666666667
9154, 2.0958333333333, 0.1, 0.25
9155, 2.1583333333333, 0.1, 0.22916666666667
9156, 2.1375, 0.1, 0.25
9157, 2.1791666666667, 0.1, 0.25
9158, 1.2416666666667, 0.1, 0.27083333333333
9159, 1.2208333333333, 0.1, 0.29166666666667
9160, 1.2833333333333, 0.1, 0.27083333333333
9161, 1.2625, 0.1, 0.29166666666667
9162, 1.325, 0.1, 0.27083333333333
9163, 1.3041666666667, 0.1, 0.29166666666667
9164, 1.3666666666667, 0.1, 0.27083333333333
9165, 1.3458333333333, 0.1, 0.29166666666667
9166, 1.4083333333333, 0.1, 0.27083333333333
9167, 1.3875, 0.1, 0.29166666666667
9168, 1.45, 0.1, 0.27083333333333
9169, 1.4291666666667, 0.1, 0.29166666666667
9170, 1.4916666666667, 0.1, 0.27083333333333
9171, 1.4708333333333, 0.1, 0.29166666666667
9172, 1.5333333333333, 0.1, 0.27083333333333
9173, 1.5125, 0.1, 0.29166666666667
9174, 1.575, 0.1, 0.27083333333333
9175, 1.5541666666667, 0.1, 0.29166666666667
9176, 1.6166666666667, 0.1, 0.27083333333333
9177, 1.5958333333333, 0.1, 0.29166666666667
9178, 1.6583333333333, 0.1, 0.27083333333333
9179, 1.6375, 0.1, 0.29166666666667
9180, 1.7, 0.1, 0.27083333333333
9181, 1.6791666666667, 0.1, 0.29166666666667
9182, 1.7416666666667, 0.1, 0.27083333333333
9183, 1.7208333333333, 0.1, 0.29166666666667
9184, 1.7833333333333, 0.1, 0.27083333333333
9185, 1.7625, 0.1, 0.29166666666667
9186, 1.825, 0.1, 0.27083333333333
9187, 1.8041666666667, 0.1, 0.29166666666667
9188, 1.8666666666667, 0.1, 0.27083333333333
9189, 1.8458333333333, 0.1, 0.29166666666667
9190, 1.9083333333333, 0.1, 0.27083333333333
9191, 1.8875, 0.1, 0.29166666666667
9192, 1.95, 0.1, 0.27083333333333
9193, 1.9291666666667, 0.1, 0.29166666666667
9194, 1.9916666666667, 0.1, 0.27083333333333
9195, 1.9708333333333, 0.1, 0.29166666666667
9196, 2.0333333333333, 0.1, 0.27083333333333
9197, 2.0125, 0.1, 0.29166666666667
9198, 2.075, 0.1, 0.27083333333333
9199, 2.0541666666667, 0.1, 0.29166666666667
9200, 2.1166666666667, 0.1, 0.27083333333333
9201, 2.0958333333333, 0.1, 0.29166666666667
9202, 2.1583333333333, 0.1, 0.27083333333333
9203, 2.1375, 0.1, 0.29166666666667
9204, 2.1791666666667, 0.1, 0.29166666666667
9205, 1.2416666666667, 0.1, 0.3125
9206, 1.2208333333333, 0.1, 0.33333333333333
9207, 1.2833333333333, 0.1, 0.3125
9208, 1.2625, 0.1, 0.33333333333333
9209, 1.325, 0.1, 0.3125
9210, 1.3041666666667, 0.1, 0.33333333333333
9211, 1.3666666666667, 0.1, 0.3125
9212, 1.3458333333333, 0.1, 0.33333333333333
9213, 1.4083333333333, 0.1, 0.3125
9214, 1.3875, 0.1, 0.33333333333333
9215, 1.45, 0.1, 0.3125
9216, 1.4291666666667, 0.1, 0.33333333333333
9217, 1.4916666666667, 0.1, 0.3125
9218, 1.4708333333333, 0.1, 0.33333333333333
9219, 1.5333333333333, 0.1, 0.3125
9220, 1.5125, 0.1, 0.33333333333333
9221, 1.575, 0.1, 0.3125
9222, 1.5541666666667, 0.1, 0.33333333333333
9223, 1.6166666666667, 0.1, 0.3125
9224, 1.5958333333333, 0.1, 0.33333333333333
9225, 1.6583333333333, 0.1, 0.3125
9226, 1.6375, 0.1, 0.33333333333333
9227, 1.7, 0.1, 0.3125
9228, 1.6791666666667, 0.1, 0.33333333333333
9229, 1.7416666666667, 0.1, 0.3125
9230, 1.7208333333333, 0.1, 0.33333333333333
9231, 1.7833333333333, 0.1, 0.3125
9232, 1.7625, 0.1, 0.33333333333333
9233, 1.825, 0.1, 0.3125
9234, 1.8041666666667, 0.1, 0.33333333333333
9235, 1.8666666666667, 0.1, 0.3125
9236, 1.8458333333333, 0.1, 0.33333333333333
9237, 1.9083333333333, 0.1, 0.3125
9238, 1.8875, 0.1, 0.33333333333333
9239, 1.95, 0.1, 0.3125
9240, 1.9291666666667, 0.1, 0.33333333333333
9241, 1.9916666666667, 0.1, 0.3125
9242, 1.9708333333333, 0.1, 0.33333333333333
9243, 2.0333333333333, 0.1, 0.3125
9244, 2.0125, 0.1, 0.33333333333333
9245, 2.075, 0.1, 0.3125
9246, 2.0541666666667, 0.1, 0.33333333333333
9247, 2.1166666666667, 0.1, 0.3125
9248, 2.0958333333333, 0.1, 0.33333333333333
9249, 2.1583333333333, 0.1, 0.3125
9250, 2.1375, 0.1, 0.33333333333333
9251, 2.1791666666667, 0.1, 0.33333333333333
9252, 1.2416666666667, 0.1, 0.35416666666667
9253, 1.2208333333333, 0.1, 0.375
9254, 1.2833333333333, 0.1, 0.35416666666667
9255, 1.2625, 0.1, 0.375
9256, 1.325, 0.1, 0.35416666666667
9257, 1.3041666666667, 0.1, 0.375
9258, 1.3666666666667, 0.1, 0.35416666666667
9259, 1.3458333333333, 0.1, 0.375
9260, 1.4083333333333, 0.1, 0.35416666666667
9261, 1.3875, 0.1, 0.375
9262, 1.45, 0.1, 0.35416666666667
9263, 1.4291666666667, 0.1, 0.375
9264, 1.4916666666667, 0.1, 0.35416666666667
9265, 1.4708333333333, 0.1, 0.375
9266, 1.5333333333333, 0.1, 0.35416666666667
9267, 1.5125, 0.1, 0.375
9268, 1.575, 0.1, 0.35416666666667
9269, 1.5541666666667, 0.1, 0.375
9270, 1.6166666666667, 0.1, 0.35416666666667
9271, 1.5958333333333, 0.1, 0.375
