13366, 25728, 25751, 4027, 4004, 25729, 25752, 4028, 4005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13367, 25729, 25752, 4028, 4005, 25730, 25753, 4029, 4006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13368, 25730, 25753, 4029, 4006, 25731, 25754, 4030, 4007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13369, 25731, 25754, 4030, 4007, 25732, 25755, 4031, 4008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13370, 25732, 25755, 4031, 4008, 25733, 25756, 4032, 4009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13371, 25733, 25756, 4032, 4009, 25734, 25757, 4033, 4010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13372, 25734, 25757, 4033, 4010, 25735, 25758, 4034, 4011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13373, 25735, 25758, 4034, 4011, 25736, 25759, 4035, 4012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13374, 25736, 25759, 4035, 4012, 25737, 25760, 4036, 4013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13375, 25737, 25760, 4036, 4013, 25738, 25761, 4037, 4014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13376, 25738, 25761, 4037, 4014, 25739, 25762, 4038, 4015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13377, 25739, 25762, 4038, 4015, 5116, 5117, 410, 409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13378, 3300, 3301, 274, 273, 25740, 25763, 4039, 4016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13379, 25740, 25763, 4039, 4016, 25741, 25764, 4040, 4017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13380, 25741, 25764, 4040, 4017, 25742, 25765, 4041, 4018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13381, 25742, 25765, 4041, 4018, 25743, 25766, 4042, 4019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13382, 25743, 25766, 4042, 4019, 25744, 25767, 4043, 4020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13383, 25744, 25767, 4043, 4020, 25745, 25768, 4044, 4021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13384, 25745, 25768, 4044, 4021, 25746, 25769, 4045, 4022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13385, 25746, 25769, 4045, 4022, 25747, 25770, 4046, 4023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13386, 25747, 25770, 4046, 4023, 25748, 25771, 4047, 4024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13387, 25748, 25771, 4047, 4024, 25749, 25772, 4048, 4025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13388, 25749, 25772, 4048, 4025, 25750, 25773, 4049, 4026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13389, 25750, 25773, 4049, 4026, 25751, 25774, 4050, 4027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13390, 25751, 25774, 4050, 4027, 25752, 25775, 4051, 4028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13391, 25752, 25775, 4051, 4028, 25753, 25776, 4052, 4029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13392, 25753, 25776, 4052, 4029, 25754, 25777, 4053, 4030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13393, 25754, 25777, 4053, 4030, 25755, 25778, 4054, 4031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13394, 25755, 25778, 4054, 4031, 25756, 25779, 4055, 4032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13395, 25756, 25779, 4055, 4032, 25757, 25780, 4056, 4033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13396, 25757, 25780, 4056, 4033, 25758, 25781, 4057, 4034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13397, 25758, 25781, 4057, 4034, 25759, 25782, 4058, 4035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13398, 25759, 25782, 4058, 4035, 25760, 25783, 4059, 4036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13399, 25760, 25783, 4059, 4036, 25761, 25784, 4060, 4037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13400, 25761, 25784, 4060, 4037, 25762, 25785, 4061, 4038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13401, 25762, 25785, 4061, 4038, 5117, 5118, 411, 410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13402, 3301, 3302, 275, 274, 25763, 25786, 4062, 4039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13403, 25763, 25786, 4062, 4039, 25764, 25787, 4063, 4040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13404, 25764, 25787, 4063, 4040, 25765, 25788, 4064, 4041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13405, 25765, 25788, 4064, 4041, 25766, 25789, 4065, 4042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13406, 25766, 25789, 4065, 4042, 25767, 25790, 4066, 4043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13407, 25767, 25790, 4066, 4043, 25768, 25791, 4067, 4044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13408, 25768, 25791, 4067, 4044, 25769, 25792, 4068, 4045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13409, 25769, 25792, 4068, 4045, 25770, 25793, 4069, 4046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13410, 25770, 25793, 4069, 4046, 25771, 25794, 4070, 4047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13411, 25771, 25794, 4070, 4047, 25772, 25795, 4071, 4048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13412, 25772, 25795, 4071, 4048, 25773, 25796, 4072, 4049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13413, 25773, 25796, 4072, 4049, 25774, 25797, 4073, 4050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13414, 25774, 25797, 4073, 4050, 25775, 25798, 4074, 4051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13415, 25775, 25798, 4074, 4051, 25776, 25799, 4075, 4052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13416, 25776, 25799, 4075, 4052, 25777, 25800, 4076, 4053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13417, 25777, 25800, 4076, 4053, 25778, 25801, 4077, 4054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13418, 25778, 25801, 4077, 4054, 25779, 25802, 4078, 4055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13419, 25779, 25802, 4078, 4055, 25780, 25803, 4079, 4056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13420, 25780, 25803, 4079, 4056, 25781, 25804, 4080, 4057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13421, 25781, 25804, 4080, 4057, 25782, 25805, 4081, 4058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13422, 25782, 25805, 4081, 4058, 25783, 25806, 4082, 4059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13423, 25783, 25806, 4082, 4059, 25784, 25807, 4083, 4060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13424, 25784, 25807, 4083, 4060, 25785, 25808, 4084, 4061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13425, 25785, 25808, 4084, 4061, 5118, 5119, 412, 411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13426, 3302, 298, 11, 275, 25786, 4591, 379, 4062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13427, 25786, 4591, 379, 4062, 25787, 4592, 380, 4063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13428, 25787, 4592, 380, 4063, 25788, 4593, 381, 4064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13429, 25788, 4593, 381, 4064, 25789, 4594, 382, 4065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13430, 25789, 4594, 382, 4065, 25790, 4595, 383, 4066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13431, 25790, 4595, 383, 4066, 25791, 4596, 384, 4067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13432, 25791, 4596, 384, 4067, 25792, 4597, 385, 4068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13433, 25792, 4597, 385, 4068, 25793, 4598, 386, 4069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13434, 25793, 4598, 386, 4069, 25794, 4599, 387, 4070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13435, 25794, 4599, 387, 4070, 25795, 4600, 388, 4071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13436, 25795, 4600, 388, 4071, 25796, 4601, 389, 4072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13437, 25796, 4601, 389, 4072, 25797, 4602, 390, 4073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13438, 25797, 4602, 390, 4073, 25798, 4603, 391, 4074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13439, 25798, 4603, 391, 4074, 25799, 4604, 392, 4075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13440, 25799, 4604, 392, 4075, 25800, 4605, 393, 4076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13441, 25800, 4605, 393, 4076, 25801, 4606, 394, 4077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13442, 25801, 4606, 394, 4077, 25802, 4607, 395, 4078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13443, 25802, 4607, 395, 4078, 25803, 4608, 396, 4079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13444, 25803, 4608, 396, 4079, 25804, 4609, 397, 4080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13445, 25804, 4609, 397, 4080, 25805, 4610, 398, 4081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13446, 25805, 4610, 398, 4081, 25806, 4611, 399, 4082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13447, 25806, 4611, 399, 4082, 25807, 4612, 400, 4083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13448, 25807, 4612, 400, 4083, 25808, 4613, 401, 4084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13449, 25808, 4613, 401, 4084, 5119, 458, 15, 412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume4
13450, 14, 459, 4867, 356, 18, 527, 5120, 470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13451, 459, 460, 4868, 4867, 527, 528, 5121, 5120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13452, 460, 461, 4869, 4868, 528, 529, 5122, 5121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13453, 461, 462, 4870, 4869, 529, 530, 5123, 5122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13454, 462, 463, 4871, 4870, 530, 531, 5124, 5123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13455, 463, 464, 4872, 4871, 531, 532, 5125, 5124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13456, 464, 465, 4873, 4872, 532, 533, 5126, 5125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13457, 465, 466, 4874, 4873, 533, 534, 5127, 5126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13458, 466, 467, 4875, 4874, 534, 535, 5128, 5127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13459, 467, 468, 4876, 4875, 535, 536, 5129, 5128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13460, 468, 469, 4877, 4876, 536, 537, 5130, 5129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13461, 469, 16, 436, 4877, 537, 20, 504, 5130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13462, 356, 4867, 4878, 357, 470, 5120, 5131, 471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13463, 4867, 4868, 4879, 4878, 5120, 5121, 5132, 5131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13464, 4868, 4869, 4880, 4879, 5121, 5122, 5133, 5132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13465, 4869, 4870, 4881, 4880, 5122, 5123, 5134, 5133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13466, 4870, 4871, 4882, 4881, 5123, 5124, 5135, 5134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13467, 4871, 4872, 4883, 4882, 5124, 5125, 5136, 5135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13468, 4872, 4873, 4884, 4883, 5125, 5126, 5137, 5136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13469, 4873, 4874, 4885, 4884, 5126, 5127, 5138, 5137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13470, 4874, 4875, 4886, 4885, 5127, 5128, 5139, 5138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13471, 4875, 4876, 4887, 4886, 5128, 5129, 5140, 5139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13472, 4876, 4877, 4888, 4887, 5129, 5130, 5141, 5140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13473, 4877, 436, 437, 4888, 5130, 504, 505, 5141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13474, 357, 4878, 4889, 358, 471, 5131, 5142, 472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13475, 4878, 4879, 4890, 4889, 5131, 5132, 5143, 5142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13476, 4879, 4880, 4891, 4890, 5132, 5133, 5144, 5143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13477, 4880, 4881, 4892, 4891, 5133, 5134, 5145, 5144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13478, 4881, 4882, 4893, 4892, 5134, 5135, 5146, 5145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13479, 4882, 4883, 4894, 4893, 5135, 5136, 5147, 5146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13480, 4883, 4884, 4895, 4894, 5136, 5137, 5148, 5147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13481, 4884, 4885, 4896, 4895, 5137, 5138, 5149, 5148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13482, 4885, 4886, 4897, 4896, 5138, 5139, 5150, 5149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13483, 4886, 4887, 4898, 4897, 5139, 5140, 5151, 5150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13484, 4887, 4888, 4899, 4898, 5140, 5141, 5152, 5151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13485, 4888, 437, 438, 4899, 5141, 505, 506, 5152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13486, 358, 4889, 4900, 359, 472, 5142, 5153, 473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13487, 4889, 4890, 4901, 4900, 5142, 5143, 5154, 5153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13488, 4890, 4891, 4902, 4901, 5143, 5144, 5155, 5154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13489, 4891, 4892, 4903, 4902, 5144, 5145, 5156, 5155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13490, 4892, 4893, 4904, 4903, 5145, 5146, 5157, 5156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13491, 4893, 4894, 4905, 4904, 5146, 5147, 5158, 5157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13492, 4894, 4895, 4906, 4905, 5147, 5148, 5159, 5158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13493, 4895, 4896, 4907, 4906, 5148, 5149, 5160, 5159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13494, 4896, 4897, 4908, 4907, 5149, 5150, 5161, 5160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13495, 4897, 4898, 4909, 4908, 5150, 5151, 5162, 5161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13496, 4898, 4899, 4910, 4909, 5151, 5152, 5163, 5162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13497, 4899, 438, 439, 4910, 5152, 506, 507, 5163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13498, 359, 4900, 4911, 360, 473, 5153, 5164, 474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13499, 4900, 4901, 4912, 4911, 5153, 5154, 5165, 5164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13500, 4901, 4902, 4913, 4912, 5154, 5155, 5166, 5165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13501, 4902, 4903, 4914, 4913, 5155, 5156, 5167, 5166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13502, 4903, 4904, 4915, 4914, 5156, 5157, 5168, 5167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13503, 4904, 4905, 4916, 4915, 5157, 5158, 5169, 5168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13504, 4905, 4906, 4917, 4916, 5158, 5159, 5170, 5169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13505, 4906, 4907, 4918, 4917, 5159, 5160, 5171, 5170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13506, 4907, 4908, 4919, 4918, 5160, 5161, 5172, 5171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13507, 4908, 4909, 4920, 4919, 5161, 5162, 5173, 5172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13508, 4909, 4910, 4921, 4920, 5162, 5163, 5174, 5173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13509, 4910, 439, 440, 4921, 5163, 507, 508, 5174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13510, 360, 4911, 4922, 361, 474, 5164, 5175, 475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13511, 4911, 4912, 4923, 4922, 5164, 5165, 5176, 5175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13512, 4912, 4913, 4924, 4923, 5165, 5166, 5177, 5176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13513, 4913, 4914, 4925, 4924, 5166, 5167, 5178, 5177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13514, 4914, 4915, 4926, 4925, 5167, 5168, 5179, 5178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13515, 4915, 4916, 4927, 4926, 5168, 5169, 5180, 5179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13516, 4916, 4917, 4928, 4927, 5169, 5170, 5181, 5180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13517, 4917, 4918, 4929, 4928, 5170, 5171, 5182, 5181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13518, 4918, 4919, 4930, 4929, 5171, 5172, 5183, 5182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13519, 4919, 4920, 4931, 4930, 5172, 5173, 5184, 5183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13520, 4920, 4921, 4932, 4931, 5173, 5174, 5185, 5184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13521, 4921, 440, 441, 4932, 5174, 508, 509, 5185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13522, 361, 4922, 4933, 362, 475, 5175, 5186, 476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13523, 4922, 4923, 4934, 4933, 5175, 5176, 5187, 5186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13524, 4923, 4924, 4935, 4934, 5176, 5177, 5188, 5187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13525, 4924, 4925, 4936, 4935, 5177, 5178, 5189, 5188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13526, 4925, 4926, 4937, 4936, 5178, 5179, 5190, 5189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13527, 4926, 4927, 4938, 4937, 5179, 5180, 5191, 5190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13528, 4927, 4928, 4939, 4938, 5180, 5181, 5192, 5191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13529, 4928, 4929, 4940, 4939, 5181, 5182, 5193, 5192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13530, 4929, 4930, 4941, 4940, 5182, 5183, 5194, 5193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13531, 4930, 4931, 4942, 4941, 5183, 5184, 5195, 5194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13532, 4931, 4932, 4943, 4942, 5184, 5185, 5196, 5195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13533, 4932, 441, 442, 4943, 5185, 509, 510, 5196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13534, 362, 4933, 4944, 363, 476, 5186, 5197, 477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13535, 4933, 4934, 4945, 4944, 5186, 5187, 5198, 5197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13536, 4934, 4935, 4946, 4945, 5187, 5188, 5199, 5198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13537, 4935, 4936, 4947, 4946, 5188, 5189, 5200, 5199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13538, 4936, 4937, 4948, 4947, 5189, 5190, 5201, 5200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13539, 4937, 4938, 4949, 4948, 5190, 5191, 5202, 5201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13540, 4938, 4939, 4950, 4949, 5191, 5192, 5203, 5202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13541, 4939, 4940, 4951, 4950, 5192, 5193, 5204, 5203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13542, 4940, 4941, 4952, 4951, 5193, 5194, 5205, 5204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13543, 4941, 4942, 4953, 4952, 5194, 5195, 5206, 5205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13544, 4942, 4943, 4954, 4953, 5195, 5196, 5207, 5206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13545, 4943, 442, 443, 4954, 5196, 510, 511, 5207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13546, 363, 4944, 4955, 364, 477, 5197, 5208, 478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13547, 4944, 4945, 4956, 4955, 5197, 5198, 5209, 5208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13548, 4945, 4946, 4957, 4956, 5198, 5199, 5210, 5209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13549, 4946, 4947, 4958, 4957, 5199, 5200, 5211, 5210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13550, 4947, 4948, 4959, 4958, 5200, 5201, 5212, 5211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13551, 4948, 4949, 4960, 4959, 5201, 5202, 5213, 5212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13552, 4949, 4950, 4961, 4960, 5202, 5203, 5214, 5213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13553, 4950, 4951, 4962, 4961, 5203, 5204, 5215, 5214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13554, 4951, 4952, 4963, 4962, 5204, 5205, 5216, 5215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13555, 4952, 4953, 4964, 4963, 5205, 5206, 5217, 5216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13556, 4953, 4954, 4965, 4964, 5206, 5207, 5218, 5217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13557, 4954, 443, 444, 4965, 5207, 511, 512, 5218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13558, 364, 4955, 4966, 365, 478, 5208, 5219, 479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13559, 4955, 4956, 4967, 4966, 5208, 5209, 5220, 5219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13560, 4956, 4957, 4968, 4967, 5209, 5210, 5221, 5220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13561, 4957, 4958, 4969, 4968, 5210, 5211, 5222, 5221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13562, 4958, 4959, 4970, 4969, 5211, 5212, 5223, 5222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13563, 4959, 4960, 4971, 4970, 5212, 5213, 5224, 5223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13564, 4960, 4961, 4972, 4971, 5213, 5214, 5225, 5224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13565, 4961, 4962, 4973, 4972, 5214, 5215, 5226, 5225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13566, 4962, 4963, 4974, 4973, 5215, 5216, 5227, 5226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13567, 4963, 4964, 4975, 4974, 5216, 5217, 5228, 5227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13568, 4964, 4965, 4976, 4975, 5217, 5218, 5229, 5228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13569, 4965, 444, 445, 4976, 5218, 512, 513, 5229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13570, 365, 4966, 4977, 366, 479, 5219, 5230, 480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13571, 4966, 4967, 4978, 4977, 5219, 5220, 5231, 5230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13572, 4967, 4968, 4979, 4978, 5220, 5221, 5232, 5231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13573, 4968, 4969, 4980, 4979, 5221, 5222, 5233, 5232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13574, 4969, 4970, 4981, 4980, 5222, 5223, 5234, 5233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13575, 4970, 4971, 4982, 4981, 5223, 5224, 5235, 5234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13576, 4971, 4972, 4983, 4982, 5224, 5225, 5236, 5235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13577, 4972, 4973, 4984, 4983, 5225, 5226, 5237, 5236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13578, 4973, 4974, 4985, 4984, 5226, 5227, 5238, 5237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13579, 4974, 4975, 4986, 4985, 5227, 5228, 5239, 5238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13580, 4975, 4976, 4987, 4986, 5228, 5229, 5240, 5239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13581, 4976, 445, 446, 4987, 5229, 513, 514, 5240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13582, 366, 4977, 4988, 367, 480, 5230, 5241, 481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13583, 4977, 4978, 4989, 4988, 5230, 5231, 5242, 5241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13584, 4978, 4979, 4990, 4989, 5231, 5232, 5243, 5242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13585, 4979, 4980, 4991, 4990, 5232, 5233, 5244, 5243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13586, 4980, 4981, 4992, 4991, 5233, 5234, 5245, 5244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13587, 4981, 4982, 4993, 4992, 5234, 5235, 5246, 5245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13588, 4982, 4983, 4994, 4993, 5235, 5236, 5247, 5246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13589, 4983, 4984, 4995, 4994, 5236, 5237, 5248, 5247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13590, 4984, 4985, 4996, 4995, 5237, 5238, 5249, 5248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13591, 4985, 4986, 4997, 4996, 5238, 5239, 5250, 5249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13592, 4986, 4987, 4998, 4997, 5239, 5240, 5251, 5250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13593, 4987, 446, 447, 4998, 5240, 514, 515, 5251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13594, 367, 4988, 4999, 368, 481, 5241, 5252, 482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13595, 4988, 4989, 5000, 4999, 5241, 5242, 5253, 5252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13596, 4989, 4990, 5001, 5000, 5242, 5243, 5254, 5253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13597, 4990, 4991, 5002, 5001, 5243, 5244, 5255, 5254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13598, 4991, 4992, 5003, 5002, 5244, 5245, 5256, 5255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13599, 4992, 4993, 5004, 5003, 5245, 5246, 5257, 5256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13600, 4993, 4994, 5005, 5004, 5246, 5247, 5258, 5257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13601, 4994, 4995, 5006, 5005, 5247, 5248, 5259, 5258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13602, 4995, 4996, 5007, 5006, 5248, 5249, 5260, 5259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13603, 4996, 4997, 5008, 5007, 5249, 5250, 5261, 5260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13604, 4997, 4998, 5009, 5008, 5250, 5251, 5262, 5261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13605, 4998, 447, 448, 5009, 5251, 515, 516, 5262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13606, 368, 4999, 5010, 369, 482, 5252, 5263, 483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13607, 4999, 5000, 5011, 5010, 5252, 5253, 5264, 5263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13608, 5000, 5001, 5012, 5011, 5253, 5254, 5265, 5264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13609, 5001, 5002, 5013, 5012, 5254, 5255, 5266, 5265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13610, 5002, 5003, 5014, 5013, 5255, 5256, 5267, 5266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13611, 5003, 5004, 5015, 5014, 5256, 5257, 5268, 5267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13612, 5004, 5005, 5016, 5015, 5257, 5258, 5269, 5268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13613, 5005, 5006, 5017, 5016, 5258, 5259, 5270, 5269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13614, 5006, 5007, 5018, 5017, 5259, 5260, 5271, 5270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13615, 5007, 5008, 5019, 5018, 5260, 5261, 5272, 5271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13616, 5008, 5009, 5020, 5019, 5261, 5262, 5273, 5272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13617, 5009, 448, 449, 5020, 5262, 516, 517, 5273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13618, 369, 5010, 5021, 370, 483, 5263, 5274, 484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13619, 5010, 5011, 5022, 5021, 5263, 5264, 5275, 5274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13620, 5011, 5012, 5023, 5022, 5264, 5265, 5276, 5275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13621, 5012, 5013, 5024, 5023, 5265, 5266, 5277, 5276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13622, 5013, 5014, 5025, 5024, 5266, 5267, 5278, 5277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13623, 5014, 5015, 5026, 5025, 5267, 5268, 5279, 5278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13624, 5015, 5016, 5027, 5026, 5268, 5269, 5280, 5279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13625, 5016, 5017, 5028, 5027, 5269, 5270, 5281, 5280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13626, 5017, 5018, 5029, 5028, 5270, 5271, 5282, 5281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13627, 5018, 5019, 5030, 5029, 5271, 5272, 5283, 5282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13628, 5019, 5020, 5031, 5030, 5272, 5273, 5284, 5283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13629, 5020, 449, 450, 5031, 5273, 517, 518, 5284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13630, 370, 5021, 5032, 371, 484, 5274, 5285, 485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13631, 5021, 5022, 5033, 5032, 5274, 5275, 5286, 5285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13632, 5022, 5023, 5034, 5033, 5275, 5276, 5287, 5286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13633, 5023, 5024, 5035, 5034, 5276, 5277, 5288, 5287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13634, 5024, 5025, 5036, 5035, 5277, 5278, 5289, 5288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13635, 5025, 5026, 5037, 5036, 5278, 5279, 5290, 5289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13636, 5026, 5027, 5038, 5037, 5279, 5280, 5291, 5290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13637, 5027, 5028, 5039, 5038, 5280, 5281, 5292, 5291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13638, 5028, 5029, 5040, 5039, 5281, 5282, 5293, 5292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13639, 5029, 5030, 5041, 5040, 5282, 5283, 5294, 5293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13640, 5030, 5031, 5042, 5041, 5283, 5284, 5295, 5294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13641, 5031, 450, 451, 5042, 5284, 518, 519, 5295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13642, 371, 5032, 5043, 372, 485, 5285, 5296, 486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13643, 5032, 5033, 5044, 5043, 5285, 5286, 5297, 5296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13644, 5033, 5034, 5045, 5044, 5286, 5287, 5298, 5297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13645, 5034, 5035, 5046, 5045, 5287, 5288, 5299, 5298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13646, 5035, 5036, 5047, 5046, 5288, 5289, 5300, 5299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13647, 5036, 5037, 5048, 5047, 5289, 5290, 5301, 5300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13648, 5037, 5038, 5049, 5048, 5290, 5291, 5302, 5301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13649, 5038, 5039, 5050, 5049, 5291, 5292, 5303, 5302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13650, 5039, 5040, 5051, 5050, 5292, 5293, 5304, 5303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13651, 5040, 5041, 5052, 5051, 5293, 5294, 5305, 5304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13652, 5041, 5042, 5053, 5052, 5294, 5295, 5306, 5305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13653, 5042, 451, 452, 5053, 5295, 519, 520, 5306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13654, 372, 5043, 5054, 373, 486, 5296, 5307, 487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13655, 5043, 5044, 5055, 5054, 5296, 5297, 5308, 5307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13656, 5044, 5045, 5056, 5055, 5297, 5298, 5309, 5308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13657, 5045, 5046, 5057, 5056, 5298, 5299, 5310, 5309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13658, 5046, 5047, 5058, 5057, 5299, 5300, 5311, 5310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13659, 5047, 5048, 5059, 5058, 5300, 5301, 5312, 5311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13660, 5048, 5049, 5060, 5059, 5301, 5302, 5313, 5312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13661, 5049, 5050, 5061, 5060, 5302, 5303, 5314, 5313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13662, 5050, 5051, 5062, 5061, 5303, 5304, 5315, 5314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13663, 5051, 5052, 5063, 5062, 5304, 5305, 5316, 5315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13664, 5052, 5053, 5064, 5063, 5305, 5306, 5317, 5316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13665, 5053, 452, 453, 5064, 5306, 520, 521, 5317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13666, 373, 5054, 5065, 374, 487, 5307, 5318, 488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13667, 5054, 5055, 5066, 5065, 5307, 5308, 5319, 5318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13668, 5055, 5056, 5067, 5066, 5308, 5309, 5320, 5319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13669, 5056, 5057, 5068, 5067, 5309, 5310, 5321, 5320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13670, 5057, 5058, 5069, 5068, 5310, 5311, 5322, 5321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13671, 5058, 5059, 5070, 5069, 5311, 5312, 5323, 5322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13672, 5059, 5060, 5071, 5070, 5312, 5313, 5324, 5323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13673, 5060, 5061, 5072, 5071, 5313, 5314, 5325, 5324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13674, 5061, 5062, 5073, 5072, 5314, 5315, 5326, 5325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13675, 5062, 5063, 5074, 5073, 5315, 5316, 5327, 5326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13676, 5063, 5064, 5075, 5074, 5316, 5317, 5328, 5327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13677, 5064, 453, 454, 5075, 5317, 521, 522, 5328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13678, 374, 5065, 5076, 375, 488, 5318, 5329, 489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13679, 5065, 5066, 5077, 5076, 5318, 5319, 5330, 5329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13680, 5066, 5067, 5078, 5077, 5319, 5320, 5331, 5330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13681, 5067, 5068, 5079, 5078, 5320, 5321, 5332, 5331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13682, 5068, 5069, 5080, 5079, 5321, 5322, 5333, 5332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13683, 5069, 5070, 5081, 5080, 5322, 5323, 5334, 5333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13684, 5070, 5071, 5082, 5081, 5323, 5324, 5335, 5334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13685, 5071, 5072, 5083, 5082, 5324, 5325, 5336, 5335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13686, 5072, 5073, 5084, 5083, 5325, 5326, 5337, 5336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13687, 5073, 5074, 5085, 5084, 5326, 5327, 5338, 5337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13688, 5074, 5075, 5086, 5085, 5327, 5328, 5339, 5338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13689, 5075, 454, 455, 5086, 5328, 522, 523, 5339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13690, 375, 5076, 5087, 376, 489, 5329, 5340, 490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13691, 5076, 5077, 5088, 5087, 5329, 5330, 5341, 5340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13692, 5077, 5078, 5089, 5088, 5330, 5331, 5342, 5341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13693, 5078, 5079, 5090, 5089, 5331, 5332, 5343, 5342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13694, 5079, 5080, 5091, 5090, 5332, 5333, 5344, 5343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13695, 5080, 5081, 5092, 5091, 5333, 5334, 5345, 5344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13696, 5081, 5082, 5093, 5092, 5334, 5335, 5346, 5345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13697, 5082, 5083, 5094, 5093, 5335, 5336, 5347, 5346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13698, 5083, 5084, 5095, 5094, 5336, 5337, 5348, 5347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13699, 5084, 5085, 5096, 5095, 5337, 5338, 5349, 5348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13700, 5085, 5086, 5097, 5096, 5338, 5339, 5350, 5349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13701, 5086, 455, 456, 5097, 5339, 523, 524, 5350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13702, 376, 5087, 5098, 377, 490, 5340, 5351, 491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13703, 5087, 5088, 5099, 5098, 5340, 5341, 5352, 5351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13704, 5088, 5089, 5100, 5099, 5341, 5342, 5353, 5352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13705, 5089, 5090, 5101, 5100, 5342, 5343, 5354, 5353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13706, 5090, 5091, 5102, 5101, 5343, 5344, 5355, 5354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13707, 5091, 5092, 5103, 5102, 5344, 5345, 5356, 5355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13708, 5092, 5093, 5104, 5103, 5345, 5346, 5357, 5356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13709, 5093, 5094, 5105, 5104, 5346, 5347, 5358, 5357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13710, 5094, 5095, 5106, 5105, 5347, 5348, 5359, 5358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13711, 5095, 5096, 5107, 5106, 5348, 5349, 5360, 5359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13712, 5096, 5097, 5108, 5107, 5349, 5350, 5361, 5360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13713, 5097, 456, 457, 5108, 5350, 524, 525, 5361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13714, 377, 5098, 5109, 378, 491, 5351, 5362, 492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13715, 5098, 5099, 5110, 5109, 5351, 5352, 5363, 5362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13716, 5099, 5100, 5111, 5110, 5352, 5353, 5364, 5363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13717, 5100, 5101, 5112, 5111, 5353, 5354, 5365, 5364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13718, 5101, 5102, 5113, 5112, 5354, 5355, 5366, 5365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13719, 5102, 5103, 5114, 5113, 5355, 5356, 5367, 5366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13720, 5103, 5104, 5115, 5114, 5356, 5357, 5368, 5367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13721, 5104, 5105, 5116, 5115, 5357, 5358, 5369, 5368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13722, 5105, 5106, 5117, 5116, 5358, 5359, 5370, 5369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13723, 5106, 5107, 5118, 5117, 5359, 5360, 5371, 5370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13724, 5107, 5108, 5119, 5118, 5360, 5361, 5372, 5371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13725, 5108, 457, 458, 5119, 5361, 525, 526, 5372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13726, 378, 5109, 402, 13, 492, 5362, 493, 17, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13727, 5109, 5110, 403, 402, 5362, 5363, 494, 493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13728, 5110, 5111, 404, 403, 5363, 5364, 495, 494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13729, 5111, 5112, 405, 404, 5364, 5365, 496, 495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13730, 5112, 5113, 406, 405, 5365, 5366, 497, 496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13731, 5113, 5114, 407, 406, 5366, 5367, 498, 497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13732, 5114, 5115, 408, 407, 5367, 5368, 499, 498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13733, 5115, 5116, 409, 408, 5368, 5369, 500, 499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13734, 5116, 5117, 410, 409, 5369, 5370, 501, 500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13735, 5117, 5118, 411, 410, 5370, 5371, 502, 501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13736, 5118, 5119, 412, 411, 5371, 5372, 503, 502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13737, 5119, 458, 15, 412, 5372, 526, 19, 503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume5
13738, 18, 527, 5120, 470, 540, 5487, 25809, 5373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13739, 540, 5487, 25809, 5373, 541, 5488, 25810, 5374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13740, 541, 5488, 25810, 5374, 22, 603, 5509, 542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13741, 527, 528, 5121, 5120, 5487, 5489, 25811, 25809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13742, 5487, 5489, 25811, 25809, 5488, 5490, 25812, 25810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13743, 5488, 5490, 25812, 25810, 603, 604, 5510, 5509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13744, 528, 529, 5122, 5121, 5489, 5491, 25813, 25811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13745, 5489, 5491, 25813, 25811, 5490, 5492, 25814, 25812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13746, 5490, 5492, 25814, 25812, 604, 605, 5511, 5510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13747, 529, 530, 5123, 5122, 5491, 5493, 25815, 25813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13748, 5491, 5493, 25815, 25813, 5492, 5494, 25816, 25814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13749, 5492, 5494, 25816, 25814, 605, 606, 5512, 5511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13750, 530, 531, 5124, 5123, 5493, 5495, 25817, 25815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13751, 5493, 5495, 25817, 25815, 5494, 5496, 25818, 25816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13752, 5494, 5496, 25818, 25816, 606, 607, 5513, 5512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13753, 531, 532, 5125, 5124, 5495, 5497, 25819, 25817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13754, 5495, 5497, 25819, 25817, 5496, 5498, 25820, 25818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13755, 5496, 5498, 25820, 25818, 607, 608, 5514, 5513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13756, 532, 533, 5126, 5125, 5497, 5499, 25821, 25819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13757, 5497, 5499, 25821, 25819, 5498, 5500, 25822, 25820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13758, 5498, 5500, 25822, 25820, 608, 609, 5515, 5514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13759, 533, 534, 5127, 5126, 5499, 5501, 25823, 25821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13760, 5499, 5501, 25823, 25821, 5500, 5502, 25824, 25822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13761, 5500, 5502, 25824, 25822, 609, 610, 5516, 5515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13762, 534, 535, 5128, 5127, 5501, 5503, 25825, 25823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13763, 5501, 5503, 25825, 25823, 5502, 5504, 25826, 25824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13764, 5502, 5504, 25826, 25824, 610, 611, 5517, 5516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13765, 535, 536, 5129, 5128, 5503, 5505, 25827, 25825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13766, 5503, 5505, 25827, 25825, 5504, 5506, 25828, 25826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13767, 5504, 5506, 25828, 25826, 611, 612, 5518, 5517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13768, 536, 537, 5130, 5129, 5505, 5507, 25829, 25827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13769, 5505, 5507, 25829, 25827, 5506, 5508, 25830, 25828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13770, 5506, 5508, 25830, 25828, 612, 613, 5519, 5518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13771, 537, 20, 504, 5130, 5507, 578, 5441, 25829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13772, 5507, 578, 5441, 25829, 5508, 579, 5442, 25830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13773, 5508, 579, 5442, 25830, 613, 24, 580, 5519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13774, 470, 5120, 5131, 471, 5373, 25809, 25831, 5375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13775, 5373, 25809, 25831, 5375, 5374, 25810, 25832, 5376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13776, 5374, 25810, 25832, 5376, 542, 5509, 5520, 543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13777, 5120, 5121, 5132, 5131, 25809, 25811, 25833, 25831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13778, 25809, 25811, 25833, 25831, 25810, 25812, 25834, 25832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13779, 25810, 25812, 25834, 25832, 5509, 5510, 5521, 5520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13780, 5121, 5122, 5133, 5132, 25811, 25813, 25835, 25833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13781, 25811, 25813, 25835, 25833, 25812, 25814, 25836, 25834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13782, 25812, 25814, 25836, 25834, 5510, 5511, 5522, 5521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13783, 5122, 5123, 5134, 5133, 25813, 25815, 25837, 25835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13784, 25813, 25815, 25837, 25835, 25814, 25816, 25838, 25836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13785, 25814, 25816, 25838, 25836, 5511, 5512, 5523, 5522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13786, 5123, 5124, 5135, 5134, 25815, 25817, 25839, 25837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13787, 25815, 25817, 25839, 25837, 25816, 25818, 25840, 25838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13788, 25816, 25818, 25840, 25838, 5512, 5513, 5524, 5523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13789, 5124, 5125, 5136, 5135, 25817, 25819, 25841, 25839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13790, 25817, 25819, 25841, 25839, 25818, 25820, 25842, 25840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13791, 25818, 25820, 25842, 25840, 5513, 5514, 5525, 5524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13792, 5125, 5126, 5137, 5136, 25819, 25821, 25843, 25841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13793, 25819, 25821, 25843, 25841, 25820, 25822, 25844, 25842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13794, 25820, 25822, 25844, 25842, 5514, 5515, 5526, 5525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13795, 5126, 5127, 5138, 5137, 25821, 25823, 25845, 25843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13796, 25821, 25823, 25845, 25843, 25822, 25824, 25846, 25844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13797, 25822, 25824, 25846, 25844, 5515, 5516, 5527, 5526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13798, 5127, 5128, 5139, 5138, 25823, 25825, 25847, 25845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13799, 25823, 25825, 25847, 25845, 25824, 25826, 25848, 25846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13800, 25824, 25826, 25848, 25846, 5516, 5517, 5528, 5527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13801, 5128, 5129, 5140, 5139, 25825, 25827, 25849, 25847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13802, 25825, 25827, 25849, 25847, 25826, 25828, 25850, 25848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13803, 25826, 25828, 25850, 25848, 5517, 5518, 5529, 5528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13804, 5129, 5130, 5141, 5140, 25827, 25829, 25851, 25849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13805, 25827, 25829, 25851, 25849, 25828, 25830, 25852, 25850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13806, 25828, 25830, 25852, 25850, 5518, 5519, 5530, 5529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13807, 5130, 504, 505, 5141, 25829, 5441, 5443, 25851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13808, 25829, 5441, 5443, 25851, 25830, 5442, 5444, 25852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13809, 25830, 5442, 5444, 25852, 5519, 580, 581, 5530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13810, 471, 5131, 5142, 472, 5375, 25831, 25853, 5377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13811, 5375, 25831, 25853, 5377, 5376, 25832, 25854, 5378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13812, 5376, 25832, 25854, 5378, 543, 5520, 5531, 544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13813, 5131, 5132, 5143, 5142, 25831, 25833, 25855, 25853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13814, 25831, 25833, 25855, 25853, 25832, 25834, 25856, 25854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13815, 25832, 25834, 25856, 25854, 5520, 5521, 5532, 5531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13816, 5132, 5133, 5144, 5143, 25833, 25835, 25857, 25855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13817, 25833, 25835, 25857, 25855, 25834, 25836, 25858, 25856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13818, 25834, 25836, 25858, 25856, 5521, 5522, 5533, 5532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13819, 5133, 5134, 5145, 5144, 25835, 25837, 25859, 25857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13820, 25835, 25837, 25859, 25857, 25836, 25838, 25860, 25858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13821, 25836, 25838, 25860, 25858, 5522, 5523, 5534, 5533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13822, 5134, 5135, 5146, 5145, 25837, 25839, 25861, 25859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13823, 25837, 25839, 25861, 25859, 25838, 25840, 25862, 25860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13824, 25838, 25840, 25862, 25860, 5523, 5524, 5535, 5534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13825, 5135, 5136, 5147, 5146, 25839, 25841, 25863, 25861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13826, 25839, 25841, 25863, 25861, 25840, 25842, 25864, 25862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13827, 25840, 25842, 25864, 25862, 5524, 5525, 5536, 5535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13828, 5136, 5137, 5148, 5147, 25841, 25843, 25865, 25863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13829, 25841, 25843, 25865, 25863, 25842, 25844, 25866, 25864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13830, 25842, 25844, 25866, 25864, 5525, 5526, 5537, 5536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13831, 5137, 5138, 5149, 5148, 25843, 25845, 25867, 25865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13832, 25843, 25845, 25867, 25865, 25844, 25846, 25868, 25866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13833, 25844, 25846, 25868, 25866, 5526, 5527, 5538, 5537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13834, 5138, 5139, 5150, 5149, 25845, 25847, 25869, 25867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13835, 25845, 25847, 25869, 25867, 25846, 25848, 25870, 25868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13836, 25846, 25848, 25870, 25868, 5527, 5528, 5539, 5538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13837, 5139, 5140, 5151, 5150, 25847, 25849, 25871, 25869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13838, 25847, 25849, 25871, 25869, 25848, 25850, 25872, 25870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13839, 25848, 25850, 25872, 25870, 5528, 5529, 5540, 5539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13840, 5140, 5141, 5152, 5151, 25849, 25851, 25873, 25871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13841, 25849, 25851, 25873, 25871, 25850, 25852, 25874, 25872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13842, 25850, 25852, 25874, 25872, 5529, 5530, 5541, 5540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13843, 5141, 505, 506, 5152, 25851, 5443, 5445, 25873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13844, 25851, 5443, 5445, 25873, 25852, 5444, 5446, 25874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13845, 25852, 5444, 5446, 25874, 5530, 581, 582, 5541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13846, 472, 5142, 5153, 473, 5377, 25853, 25875, 5379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13847, 5377, 25853, 25875, 5379, 5378, 25854, 25876, 5380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13848, 5378, 25854, 25876, 5380, 544, 5531, 5542, 545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13849, 5142, 5143, 5154, 5153, 25853, 25855, 25877, 25875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13850, 25853, 25855, 25877, 25875, 25854, 25856, 25878, 25876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13851, 25854, 25856, 25878, 25876, 5531, 5532, 5543, 5542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13852, 5143, 5144, 5155, 5154, 25855, 25857, 25879, 25877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13853, 25855, 25857, 25879, 25877, 25856, 25858, 25880, 25878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13854, 25856, 25858, 25880, 25878, 5532, 5533, 5544, 5543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13855, 5144, 5145, 5156, 5155, 25857, 25859, 25881, 25879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13856, 25857, 25859, 25881, 25879, 25858, 25860, 25882, 25880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13857, 25858, 25860, 25882, 25880, 5533, 5534, 5545, 5544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13858, 5145, 5146, 5157, 5156, 25859, 25861, 25883, 25881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13859, 25859, 25861, 25883, 25881, 25860, 25862, 25884, 25882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13860, 25860, 25862, 25884, 25882, 5534, 5535, 5546, 5545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13861, 5146, 5147, 5158, 5157, 25861, 25863, 25885, 25883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13862, 25861, 25863, 25885, 25883, 25862, 25864, 25886, 25884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13863, 25862, 25864, 25886, 25884, 5535, 5536, 5547, 5546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13864, 5147, 5148, 5159, 5158, 25863, 25865, 25887, 25885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13865, 25863, 25865, 25887, 25885, 25864, 25866, 25888, 25886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13866, 25864, 25866, 25888, 25886, 5536, 5537, 5548, 5547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13867, 5148, 5149, 5160, 5159, 25865, 25867, 25889, 25887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13868, 25865, 25867, 25889, 25887, 25866, 25868, 25890, 25888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13869, 25866, 25868, 25890, 25888, 5537, 5538, 5549, 5548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13870, 5149, 5150, 5161, 5160, 25867, 25869, 25891, 25889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13871, 25867, 25869, 25891, 25889, 25868, 25870, 25892, 25890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13872, 25868, 25870, 25892, 25890, 5538, 5539, 5550, 5549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13873, 5150, 5151, 5162, 5161, 25869, 25871, 25893, 25891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13874, 25869, 25871, 25893, 25891, 25870, 25872, 25894, 25892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13875, 25870, 25872, 25894, 25892, 5539, 5540, 5551, 5550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13876, 5151, 5152, 5163, 5162, 25871, 25873, 25895, 25893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13877, 25871, 25873, 25895, 25893, 25872, 25874, 25896, 25894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13878, 25872, 25874, 25896, 25894, 5540, 5541, 5552, 5551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13879, 5152, 506, 507, 5163, 25873, 5445, 5447, 25895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13880, 25873, 5445, 5447, 25895, 25874, 5446, 5448, 25896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13881, 25874, 5446, 5448, 25896, 5541, 582, 583, 5552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13882, 473, 5153, 5164, 474, 5379, 25875, 25897, 5381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13883, 5379, 25875, 25897, 5381, 5380, 25876, 25898, 5382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13884, 5380, 25876, 25898, 5382, 545, 5542, 5553, 546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13885, 5153, 5154, 5165, 5164, 25875, 25877, 25899, 25897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13886, 25875, 25877, 25899, 25897, 25876, 25878, 25900, 25898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13887, 25876, 25878, 25900, 25898, 5542, 5543, 5554, 5553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13888, 5154, 5155, 5166, 5165, 25877, 25879, 25901, 25899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13889, 25877, 25879, 25901, 25899, 25878, 25880, 25902, 25900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13890, 25878, 25880, 25902, 25900, 5543, 5544, 5555, 5554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13891, 5155, 5156, 5167, 5166, 25879, 25881, 25903, 25901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13892, 25879, 25881, 25903, 25901, 25880, 25882, 25904, 25902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13893, 25880, 25882, 25904, 25902, 5544, 5545, 5556, 5555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13894, 5156, 5157, 5168, 5167, 25881, 25883, 25905, 25903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13895, 25881, 25883, 25905, 25903, 25882, 25884, 25906, 25904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13896, 25882, 25884, 25906, 25904, 5545, 5546, 5557, 5556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13897, 5157, 5158, 5169, 5168, 25883, 25885, 25907, 25905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13898, 25883, 25885, 25907, 25905, 25884, 25886, 25908, 25906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13899, 25884, 25886, 25908, 25906, 5546, 5547, 5558, 5557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13900, 5158, 5159, 5170, 5169, 25885, 25887, 25909, 25907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13901, 25885, 25887, 25909, 25907, 25886, 25888, 25910, 25908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13902, 25886, 25888, 25910, 25908, 5547, 5548, 5559, 5558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13903, 5159, 5160, 5171, 5170, 25887, 25889, 25911, 25909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13904, 25887, 25889, 25911, 25909, 25888, 25890, 25912, 25910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13905, 25888, 25890, 25912, 25910, 5548, 5549, 5560, 5559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13906, 5160, 5161, 5172, 5171, 25889, 25891, 25913, 25911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13907, 25889, 25891, 25913, 25911, 25890, 25892, 25914, 25912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13908, 25890, 25892, 25914, 25912, 5549, 5550, 5561, 5560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13909, 5161, 5162, 5173, 5172, 25891, 25893, 25915, 25913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13910, 25891, 25893, 25915, 25913, 25892, 25894, 25916, 25914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13911, 25892, 25894, 25916, 25914, 5550, 5551, 5562, 5561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13912, 5162, 5163, 5174, 5173, 25893, 25895, 25917, 25915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13913, 25893, 25895, 25917, 25915, 25894, 25896, 25918, 25916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13914, 25894, 25896, 25918, 25916, 5551, 5552, 5563, 5562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13915, 5163, 507, 508, 5174, 25895, 5447, 5449, 25917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13916, 25895, 5447, 5449, 25917, 25896, 5448, 5450, 25918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13917, 25896, 5448, 5450, 25918, 5552, 583, 584, 5563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13918, 474, 5164, 5175, 475, 5381, 25897, 25919, 5383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13919, 5381, 25897, 25919, 5383, 5382, 25898, 25920, 5384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13920, 5382, 25898, 25920, 5384, 546, 5553, 5564, 547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13921, 5164, 5165, 5176, 5175, 25897, 25899, 25921, 25919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13922, 25897, 25899, 25921, 25919, 25898, 25900, 25922, 25920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13923, 25898, 25900, 25922, 25920, 5553, 5554, 5565, 5564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13924, 5165, 5166, 5177, 5176, 25899, 25901, 25923, 25921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13925, 25899, 25901, 25923, 25921, 25900, 25902, 25924, 25922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13926, 25900, 25902, 25924, 25922, 5554, 5555, 5566, 5565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13927, 5166, 5167, 5178, 5177, 25901, 25903, 25925, 25923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13928, 25901, 25903, 25925, 25923, 25902, 25904, 25926, 25924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13929, 25902, 25904, 25926, 25924, 5555, 5556, 5567, 5566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13930, 5167, 5168, 5179, 5178, 25903, 25905, 25927, 25925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13931, 25903, 25905, 25927, 25925, 25904, 25906, 25928, 25926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13932, 25904, 25906, 25928, 25926, 5556, 5557, 5568, 5567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13933, 5168, 5169, 5180, 5179, 25905, 25907, 25929, 25927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13934, 25905, 25907, 25929, 25927, 25906, 25908, 25930, 25928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13935, 25906, 25908, 25930, 25928, 5557, 5558, 5569, 5568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13936, 5169, 5170, 5181, 5180, 25907, 25909, 25931, 25929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13937, 25907, 25909, 25931, 25929, 25908, 25910, 25932, 25930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13938, 25908, 25910, 25932, 25930, 5558, 5559, 5570, 5569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13939, 5170, 5171, 5182, 5181, 25909, 25911, 25933, 25931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13940, 25909, 25911, 25933, 25931, 25910, 25912, 25934, 25932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13941, 25910, 25912, 25934, 25932, 5559, 5560, 5571, 5570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13942, 5171, 5172, 5183, 5182, 25911, 25913, 25935, 25933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13943, 25911, 25913, 25935, 25933, 25912, 25914, 25936, 25934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13944, 25912, 25914, 25936, 25934, 5560, 5561, 5572, 5571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13945, 5172, 5173, 5184, 5183, 25913, 25915, 25937, 25935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13946, 25913, 25915, 25937, 25935, 25914, 25916, 25938, 25936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13947, 25914, 25916, 25938, 25936, 5561, 5562, 5573, 5572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13948, 5173, 5174, 5185, 5184, 25915, 25917, 25939, 25937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13949, 25915, 25917, 25939, 25937, 25916, 25918, 25940, 25938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13950, 25916, 25918, 25940, 25938, 5562, 5563, 5574, 5573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13951, 5174, 508, 509, 5185, 25917, 5449, 5451, 25939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13952, 25917, 5449, 5451, 25939, 25918, 5450, 5452, 25940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13953, 25918, 5450, 5452, 25940, 5563, 584, 585, 5574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13954, 475, 5175, 5186, 476, 5383, 25919, 25941, 5385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13955, 5383, 25919, 25941, 5385, 5384, 25920, 25942, 5386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13956, 5384, 25920, 25942, 5386, 547, 5564, 5575, 548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13957, 5175, 5176, 5187, 5186, 25919, 25921, 25943, 25941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13958, 25919, 25921, 25943, 25941, 25920, 25922, 25944, 25942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13959, 25920, 25922, 25944, 25942, 5564, 5565, 5576, 5575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13960, 5176, 5177, 5188, 5187, 25921, 25923, 25945, 25943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13961, 25921, 25923, 25945, 25943, 25922, 25924, 25946, 25944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13962, 25922, 25924, 25946, 25944, 5565, 5566, 5577, 5576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13963, 5177, 5178, 5189, 5188, 25923, 25925, 25947, 25945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13964, 25923, 25925, 25947, 25945, 25924, 25926, 25948, 25946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13965, 25924, 25926, 25948, 25946, 5566, 5567, 5578, 5577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13966, 5178, 5179, 5190, 5189, 25925, 25927, 25949, 25947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13967, 25925, 25927, 25949, 25947, 25926, 25928, 25950, 25948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13968, 25926, 25928, 25950, 25948, 5567, 5568, 5579, 5578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13969, 5179, 5180, 5191, 5190, 25927, 25929, 25951, 25949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13970, 25927, 25929, 25951, 25949, 25928, 25930, 25952, 25950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13971, 25928, 25930, 25952, 25950, 5568, 5569, 5580, 5579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13972, 5180, 5181, 5192, 5191, 25929, 25931, 25953, 25951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13973, 25929, 25931, 25953, 25951, 25930, 25932, 25954, 25952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13974, 25930, 25932, 25954, 25952, 5569, 5570, 5581, 5580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13975, 5181, 5182, 5193, 5192, 25931, 25933, 25955, 25953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13976, 25931, 25933, 25955, 25953, 25932, 25934, 25956, 25954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13977, 25932, 25934, 25956, 25954, 5570, 5571, 5582, 5581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13978, 5182, 5183, 5194, 5193, 25933, 25935, 25957, 25955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13979, 25933, 25935, 25957, 25955, 25934, 25936, 25958, 25956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13980, 25934, 25936, 25958, 25956, 5571, 5572, 5583, 5582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13981, 5183, 5184, 5195, 5194, 25935, 25937, 25959, 25957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13982, 25935, 25937, 25959, 25957, 25936, 25938, 25960, 25958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13983, 25936, 25938, 25960, 25958, 5572, 5573, 5584, 5583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13984, 5184, 5185, 5196, 5195, 25937, 25939, 25961, 25959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13985, 25937, 25939, 25961, 25959, 25938, 25940, 25962, 25960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13986, 25938, 25940, 25962, 25960, 5573, 5574, 5585, 5584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13987, 5185, 509, 510, 5196, 25939, 5451, 5453, 25961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13988, 25939, 5451, 5453, 25961, 25940, 5452, 5454, 25962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13989, 25940, 5452, 5454, 25962, 5574, 585, 586, 5585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13990, 476, 5186, 5197, 477, 5385, 25941, 25963, 5387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13991, 5385, 25941, 25963, 5387, 5386, 25942, 25964, 5388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13992, 5386, 25942, 25964, 5388, 548, 5575, 5586, 549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13993, 5186, 5187, 5198, 5197, 25941, 25943, 25965, 25963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13994, 25941, 25943, 25965, 25963, 25942, 25944, 25966, 25964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13995, 25942, 25944, 25966, 25964, 5575, 5576, 5587, 5586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13996, 5187, 5188, 5199, 5198, 25943, 25945, 25967, 25965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13997, 25943, 25945, 25967, 25965, 25944, 25946, 25968, 25966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13998, 25944, 25946, 25968, 25966, 5576, 5577, 5588, 5587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13999, 5188, 5189, 5200, 5199, 25945, 25947, 25969, 25967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14000, 25945, 25947, 25969, 25967, 25946, 25948, 25970, 25968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14001, 25946, 25948, 25970, 25968, 5577, 5578, 5589, 5588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14002, 5189, 5190, 5201, 5200, 25947, 25949, 25971, 25969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14003, 25947, 25949, 25971, 25969, 25948, 25950, 25972, 25970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14004, 25948, 25950, 25972, 25970, 5578, 5579, 5590, 5589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14005, 5190, 5191, 5202, 5201, 25949, 25951, 25973, 25971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14006, 25949, 25951, 25973, 25971, 25950, 25952, 25974, 25972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14007, 25950, 25952, 25974, 25972, 5579, 5580, 5591, 5590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14008, 5191, 5192, 5203, 5202, 25951, 25953, 25975, 25973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14009, 25951, 25953, 25975, 25973, 25952, 25954, 25976, 25974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14010, 25952, 25954, 25976, 25974, 5580, 5581, 5592, 5591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14011, 5192, 5193, 5204, 5203, 25953, 25955, 25977, 25975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14012, 25953, 25955, 25977, 25975, 25954, 25956, 25978, 25976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14013, 25954, 25956, 25978, 25976, 5581, 5582, 5593, 5592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14014, 5193, 5194, 5205, 5204, 25955, 25957, 25979, 25977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14015, 25955, 25957, 25979, 25977, 25956, 25958, 25980, 25978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14016, 25956, 25958, 25980, 25978, 5582, 5583, 5594, 5593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14017, 5194, 5195, 5206, 5205, 25957, 25959, 25981, 25979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14018, 25957, 25959, 25981, 25979, 25958, 25960, 25982, 25980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14019, 25958, 25960, 25982, 25980, 5583, 5584, 5595, 5594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14020, 5195, 5196, 5207, 5206, 25959, 25961, 25983, 25981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14021, 25959, 25961, 25983, 25981, 25960, 25962, 25984, 25982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14022, 25960, 25962, 25984, 25982, 5584, 5585, 5596, 5595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14023, 5196, 510, 511, 5207, 25961, 5453, 5455, 25983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14024, 25961, 5453, 5455, 25983, 25962, 5454, 5456, 25984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14025, 25962, 5454, 5456, 25984, 5585, 586, 587, 5596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14026, 477, 5197, 5208, 478, 5387, 25963, 25985, 5389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14027, 5387, 25963, 25985, 5389, 5388, 25964, 25986, 5390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14028, 5388, 25964, 25986, 5390, 549, 5586, 5597, 550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14029, 5197, 5198, 5209, 5208, 25963, 25965, 25987, 25985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14030, 25963, 25965, 25987, 25985, 25964, 25966, 25988, 25986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14031, 25964, 25966, 25988, 25986, 5586, 5587, 5598, 5597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14032, 5198, 5199, 5210, 5209, 25965, 25967, 25989, 25987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14033, 25965, 25967, 25989, 25987, 25966, 25968, 25990, 25988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14034, 25966, 25968, 25990, 25988, 5587, 5588, 5599, 5598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14035, 5199, 5200, 5211, 5210, 25967, 25969, 25991, 25989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14036, 25967, 25969, 25991, 25989, 25968, 25970, 25992, 25990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14037, 25968, 25970, 25992, 25990, 5588, 5589, 5600, 5599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14038, 5200, 5201, 5212, 5211, 25969, 25971, 25993, 25991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14039, 25969, 25971, 25993, 25991, 25970, 25972, 25994, 25992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14040, 25970, 25972, 25994, 25992, 5589, 5590, 5601, 5600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14041, 5201, 5202, 5213, 5212, 25971, 25973, 25995, 25993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14042, 25971, 25973, 25995, 25993, 25972, 25974, 25996, 25994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14043, 25972, 25974, 25996, 25994, 5590, 5591, 5602, 5601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14044, 5202, 5203, 5214, 5213, 25973, 25975, 25997, 25995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14045, 25973, 25975, 25997, 25995, 25974, 25976, 25998, 25996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14046, 25974, 25976, 25998, 25996, 5591, 5592, 5603, 5602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14047, 5203, 5204, 5215, 5214, 25975, 25977, 25999, 25997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14048, 25975, 25977, 25999, 25997, 25976, 25978, 26000, 25998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14049, 25976, 25978, 26000, 25998, 5592, 5593, 5604, 5603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14050, 5204, 5205, 5216, 5215, 25977, 25979, 26001, 25999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14051, 25977, 25979, 26001, 25999, 25978, 25980, 26002, 26000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14052, 25978, 25980, 26002, 26000, 5593, 5594, 5605, 5604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14053, 5205, 5206, 5217, 5216, 25979, 25981, 26003, 26001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14054, 25979, 25981, 26003, 26001, 25980, 25982, 26004, 26002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14055, 25980, 25982, 26004, 26002, 5594, 5595, 5606, 5605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14056, 5206, 5207, 5218, 5217, 25981, 25983, 26005, 26003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14057, 25981, 25983, 26005, 26003, 25982, 25984, 26006, 26004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14058, 25982, 25984, 26006, 26004, 5595, 5596, 5607, 5606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14059, 5207, 511, 512, 5218, 25983, 5455, 5457, 26005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14060, 25983, 5455, 5457, 26005, 25984, 5456, 5458, 26006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14061, 25984, 5456, 5458, 26006, 5596, 587, 588, 5607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14062, 478, 5208, 5219, 479, 5389, 25985, 26007, 5391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14063, 5389, 25985, 26007, 5391, 5390, 25986, 26008, 5392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14064, 5390, 25986, 26008, 5392, 550, 5597, 5608, 551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14065, 5208, 5209, 5220, 5219, 25985, 25987, 26009, 26007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14066, 25985, 25987, 26009, 26007, 25986, 25988, 26010, 26008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14067, 25986, 25988, 26010, 26008, 5597, 5598, 5609, 5608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14068, 5209, 5210, 5221, 5220, 25987, 25989, 26011, 26009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14069, 25987, 25989, 26011, 26009, 25988, 25990, 26012, 26010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14070, 25988, 25990, 26012, 26010, 5598, 5599, 5610, 5609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14071, 5210, 5211, 5222, 5221, 25989, 25991, 26013, 26011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14072, 25989, 25991, 26013, 26011, 25990, 25992, 26014, 26012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14073, 25990, 25992, 26014, 26012, 5599, 5600, 5611, 5610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14074, 5211, 5212, 5223, 5222, 25991, 25993, 26015, 26013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14075, 25991, 25993, 26015, 26013, 25992, 25994, 26016, 26014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14076, 25992, 25994, 26016, 26014, 5600, 5601, 5612, 5611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14077, 5212, 5213, 5224, 5223, 25993, 25995, 26017, 26015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14078, 25993, 25995, 26017, 26015, 25994, 25996, 26018, 26016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14079, 25994, 25996, 26018, 26016, 5601, 5602, 5613, 5612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14080, 5213, 5214, 5225, 5224, 25995, 25997, 26019, 26017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14081, 25995, 25997, 26019, 26017, 25996, 25998, 26020, 26018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14082, 25996, 25998, 26020, 26018, 5602, 5603, 5614, 5613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14083, 5214, 5215, 5226, 5225, 25997, 25999, 26021, 26019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14084, 25997, 25999, 26021, 26019, 25998, 26000, 26022, 26020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14085, 25998, 26000, 26022, 26020, 5603, 5604, 5615, 5614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14086, 5215, 5216, 5227, 5226, 25999, 26001, 26023, 26021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14087, 25999, 26001, 26023, 26021, 26000, 26002, 26024, 26022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14088, 26000, 26002, 26024, 26022, 5604, 5605, 5616, 5615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14089, 5216, 5217, 5228, 5227, 26001, 26003, 26025, 26023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14090, 26001, 26003, 26025, 26023, 26002, 26004, 26026, 26024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14091, 26002, 26004, 26026, 26024, 5605, 5606, 5617, 5616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14092, 5217, 5218, 5229, 5228, 26003, 26005, 26027, 26025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14093, 26003, 26005, 26027, 26025, 26004, 26006, 26028, 26026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14094, 26004, 26006, 26028, 26026, 5606, 5607, 5618, 5617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14095, 5218, 512, 513, 5229, 26005, 5457, 5459, 26027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14096, 26005, 5457, 5459, 26027, 26006, 5458, 5460, 26028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14097, 26006, 5458, 5460, 26028, 5607, 588, 589, 5618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14098, 479, 5219, 5230, 480, 5391, 26007, 26029, 5393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14099, 5391, 26007, 26029, 5393, 5392, 26008, 26030, 5394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14100, 5392, 26008, 26030, 5394, 551, 5608, 5619, 552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14101, 5219, 5220, 5231, 5230, 26007, 26009, 26031, 26029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14102, 26007, 26009, 26031, 26029, 26008, 26010, 26032, 26030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14103, 26008, 26010, 26032, 26030, 5608, 5609, 5620, 5619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14104, 5220, 5221, 5232, 5231, 26009, 26011, 26033, 26031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14105, 26009, 26011, 26033, 26031, 26010, 26012, 26034, 26032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14106, 26010, 26012, 26034, 26032, 5609, 5610, 5621, 5620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14107, 5221, 5222, 5233, 5232, 26011, 26013, 26035, 26033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14108, 26011, 26013, 26035, 26033, 26012, 26014, 26036, 26034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14109, 26012, 26014, 26036, 26034, 5610, 5611, 5622, 5621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14110, 5222, 5223, 5234, 5233, 26013, 26015, 26037, 26035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14111, 26013, 26015, 26037, 26035, 26014, 26016, 26038, 26036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14112, 26014, 26016, 26038, 26036, 5611, 5612, 5623, 5622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14113, 5223, 5224, 5235, 5234, 26015, 26017, 26039, 26037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14114, 26015, 26017, 26039, 26037, 26016, 26018, 26040, 26038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14115, 26016, 26018, 26040, 26038, 5612, 5613, 5624, 5623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14116, 5224, 5225, 5236, 5235, 26017, 26019, 26041, 26039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14117, 26017, 26019, 26041, 26039, 26018, 26020, 26042, 26040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14118, 26018, 26020, 26042, 26040, 5613, 5614, 5625, 5624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14119, 5225, 5226, 5237, 5236, 26019, 26021, 26043, 26041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14120, 26019, 26021, 26043, 26041, 26020, 26022, 26044, 26042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14121, 26020, 26022, 26044, 26042, 5614, 5615, 5626, 5625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14122, 5226, 5227, 5238, 5237, 26021, 26023, 26045, 26043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14123, 26021, 26023, 26045, 26043, 26022, 26024, 26046, 26044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14124, 26022, 26024, 26046, 26044, 5615, 5616, 5627, 5626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14125, 5227, 5228, 5239, 5238, 26023, 26025, 26047, 26045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14126, 26023, 26025, 26047, 26045, 26024, 26026, 26048, 26046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14127, 26024, 26026, 26048, 26046, 5616, 5617, 5628, 5627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14128, 5228, 5229, 5240, 5239, 26025, 26027, 26049, 26047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14129, 26025, 26027, 26049, 26047, 26026, 26028, 26050, 26048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14130, 26026, 26028, 26050, 26048, 5617, 5618, 5629, 5628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14131, 5229, 513, 514, 5240, 26027, 5459, 5461, 26049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14132, 26027, 5459, 5461, 26049, 26028, 5460, 5462, 26050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14133, 26028, 5460, 5462, 26050, 5618, 589, 590, 5629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14134, 480, 5230, 5241, 481, 5393, 26029, 26051, 5395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14135, 5393, 26029, 26051, 5395, 5394, 26030, 26052, 5396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14136, 5394, 26030, 26052, 5396, 552, 5619, 5630, 553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14137, 5230, 5231, 5242, 5241, 26029, 26031, 26053, 26051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14138, 26029, 26031, 26053, 26051, 26030, 26032, 26054, 26052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14139, 26030, 26032, 26054, 26052, 5619, 5620, 5631, 5630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14140, 5231, 5232, 5243, 5242, 26031, 26033, 26055, 26053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14141, 26031, 26033, 26055, 26053, 26032, 26034, 26056, 26054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14142, 26032, 26034, 26056, 26054, 5620, 5621, 5632, 5631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14143, 5232, 5233, 5244, 5243, 26033, 26035, 26057, 26055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14144, 26033, 26035, 26057, 26055, 26034, 26036, 26058, 26056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14145, 26034, 26036, 26058, 26056, 5621, 5622, 5633, 5632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14146, 5233, 5234, 5245, 5244, 26035, 26037, 26059, 26057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14147, 26035, 26037, 26059, 26057, 26036, 26038, 26060, 26058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14148, 26036, 26038, 26060, 26058, 5622, 5623, 5634, 5633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14149, 5234, 5235, 5246, 5245, 26037, 26039, 26061, 26059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14150, 26037, 26039, 26061, 26059, 26038, 26040, 26062, 26060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14151, 26038, 26040, 26062, 26060, 5623, 5624, 5635, 5634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14152, 5235, 5236, 5247, 5246, 26039, 26041, 26063, 26061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14153, 26039, 26041, 26063, 26061, 26040, 26042, 26064, 26062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14154, 26040, 26042, 26064, 26062, 5624, 5625, 5636, 5635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14155, 5236, 5237, 5248, 5247, 26041, 26043, 26065, 26063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14156, 26041, 26043, 26065, 26063, 26042, 26044, 26066, 26064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14157, 26042, 26044, 26066, 26064, 5625, 5626, 5637, 5636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14158, 5237, 5238, 5249, 5248, 26043, 26045, 26067, 26065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14159, 26043, 26045, 26067, 26065, 26044, 26046, 26068, 26066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14160, 26044, 26046, 26068, 26066, 5626, 5627, 5638, 5637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14161, 5238, 5239, 5250, 5249, 26045, 26047, 26069, 26067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14162, 26045, 26047, 26069, 26067, 26046, 26048, 26070, 26068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14163, 26046, 26048, 26070, 26068, 5627, 5628, 5639, 5638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14164, 5239, 5240, 5251, 5250, 26047, 26049, 26071, 26069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14165, 26047, 26049, 26071, 26069, 26048, 26050, 26072, 26070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14166, 26048, 26050, 26072, 26070, 5628, 5629, 5640, 5639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14167, 5240, 514, 515, 5251, 26049, 5461, 5463, 26071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14168, 26049, 5461, 5463, 26071, 26050, 5462, 5464, 26072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14169, 26050, 5462, 5464, 26072, 5629, 590, 591, 5640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14170, 481, 5241, 5252, 482, 5395, 26051, 26073, 5397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14171, 5395, 26051, 26073, 5397, 5396, 26052, 26074, 5398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14172, 5396, 26052, 26074, 5398, 553, 5630, 5641, 554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14173, 5241, 5242, 5253, 5252, 26051, 26053, 26075, 26073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14174, 26051, 26053, 26075, 26073, 26052, 26054, 26076, 26074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14175, 26052, 26054, 26076, 26074, 5630, 5631, 5642, 5641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14176, 5242, 5243, 5254, 5253, 26053, 26055, 26077, 26075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14177, 26053, 26055, 26077, 26075, 26054, 26056, 26078, 26076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14178, 26054, 26056, 26078, 26076, 5631, 5632, 5643, 5642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14179, 5243, 5244, 5255, 5254, 26055, 26057, 26079, 26077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14180, 26055, 26057, 26079, 26077, 26056, 26058, 26080, 26078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14181, 26056, 26058, 26080, 26078, 5632, 5633, 5644, 5643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14182, 5244, 5245, 5256, 5255, 26057, 26059, 26081, 26079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14183, 26057, 26059, 26081, 26079, 26058, 26060, 26082, 26080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14184, 26058, 26060, 26082, 26080, 5633, 5634, 5645, 5644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14185, 5245, 5246, 5257, 5256, 26059, 26061, 26083, 26081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14186, 26059, 26061, 26083, 26081, 26060, 26062, 26084, 26082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14187, 26060, 26062, 26084, 26082, 5634, 5635, 5646, 5645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14188, 5246, 5247, 5258, 5257, 26061, 26063, 26085, 26083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14189, 26061, 26063, 26085, 26083, 26062, 26064, 26086, 26084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14190, 26062, 26064, 26086, 26084, 5635, 5636, 5647, 5646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14191, 5247, 5248, 5259, 5258, 26063, 26065, 26087, 26085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14192, 26063, 26065, 26087, 26085, 26064, 26066, 26088, 26086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14193, 26064, 26066, 26088, 26086, 5636, 5637, 5648, 5647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14194, 5248, 5249, 5260, 5259, 26065, 26067, 26089, 26087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14195, 26065, 26067, 26089, 26087, 26066, 26068, 26090, 26088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14196, 26066, 26068, 26090, 26088, 5637, 5638, 5649, 5648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14197, 5249, 5250, 5261, 5260, 26067, 26069, 26091, 26089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14198, 26067, 26069, 26091, 26089, 26068, 26070, 26092, 26090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14199, 26068, 26070, 26092, 26090, 5638, 5639, 5650, 5649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14200, 5250, 5251, 5262, 5261, 26069, 26071, 26093, 26091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14201, 26069, 26071, 26093, 26091, 26070, 26072, 26094, 26092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14202, 26070, 26072, 26094, 26092, 5639, 5640, 5651, 5650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14203, 5251, 515, 516, 5262, 26071, 5463, 5465, 26093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14204, 26071, 5463, 5465, 26093, 26072, 5464, 5466, 26094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14205, 26072, 5464, 5466, 26094, 5640, 591, 592, 5651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14206, 482, 5252, 5263, 483, 5397, 26073, 26095, 5399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14207, 5397, 26073, 26095, 5399, 5398, 26074, 26096, 5400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14208, 5398, 26074, 26096, 5400, 554, 5641, 5652, 555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14209, 5252, 5253, 5264, 5263, 26073, 26075, 26097, 26095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14210, 26073, 26075, 26097, 26095, 26074, 26076, 26098, 26096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14211, 26074, 26076, 26098, 26096, 5641, 5642, 5653, 5652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14212, 5253, 5254, 5265, 5264, 26075, 26077, 26099, 26097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14213, 26075, 26077, 26099, 26097, 26076, 26078, 26100, 26098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14214, 26076, 26078, 26100, 26098, 5642, 5643, 5654, 5653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14215, 5254, 5255, 5266, 5265, 26077, 26079, 26101, 26099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14216, 26077, 26079, 26101, 26099, 26078, 26080, 26102, 26100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14217, 26078, 26080, 26102, 26100, 5643, 5644, 5655, 5654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14218, 5255, 5256, 5267, 5266, 26079, 26081, 26103, 26101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14219, 26079, 26081, 26103, 26101, 26080, 26082, 26104, 26102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14220, 26080, 26082, 26104, 26102, 5644, 5645, 5656, 5655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14221, 5256, 5257, 5268, 5267, 26081, 26083, 26105, 26103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14222, 26081, 26083, 26105, 26103, 26082, 26084, 26106, 26104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14223, 26082, 26084, 26106, 26104, 5645, 5646, 5657, 5656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14224, 5257, 5258, 5269, 5268, 26083, 26085, 26107, 26105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14225, 26083, 26085, 26107, 26105, 26084, 26086, 26108, 26106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14226, 26084, 26086, 26108, 26106, 5646, 5647, 5658, 5657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14227, 5258, 5259, 5270, 5269, 26085, 26087, 26109, 26107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14228, 26085, 26087, 26109, 26107, 26086, 26088, 26110, 26108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14229, 26086, 26088, 26110, 26108, 5647, 5648, 5659, 5658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14230, 5259, 5260, 5271, 5270, 26087, 26089, 26111, 26109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14231, 26087, 26089, 26111, 26109, 26088, 26090, 26112, 26110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14232, 26088, 26090, 26112, 26110, 5648, 5649, 5660, 5659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14233, 5260, 5261, 5272, 5271, 26089, 26091, 26113, 26111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14234, 26089, 26091, 26113, 26111, 26090, 26092, 26114, 26112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14235, 26090, 26092, 26114, 26112, 5649, 5650, 5661, 5660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14236, 5261, 5262, 5273, 5272, 26091, 26093, 26115, 26113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14237, 26091, 26093, 26115, 26113, 26092, 26094, 26116, 26114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14238, 26092, 26094, 26116, 26114, 5650, 5651, 5662, 5661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14239, 5262, 516, 517, 5273, 26093, 5465, 5467, 26115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14240, 26093, 5465, 5467, 26115, 26094, 5466, 5468, 26116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14241, 26094, 5466, 5468, 26116, 5651, 592, 593, 5662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14242, 483, 5263, 5274, 484, 5399, 26095, 26117, 5401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14243, 5399, 26095, 26117, 5401, 5400, 26096, 26118, 5402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14244, 5400, 26096, 26118, 5402, 555, 5652, 5663, 556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14245, 5263, 5264, 5275, 5274, 26095, 26097, 26119, 26117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14246, 26095, 26097, 26119, 26117, 26096, 26098, 26120, 26118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14247, 26096, 26098, 26120, 26118, 5652, 5653, 5664, 5663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14248, 5264, 5265, 5276, 5275, 26097, 26099, 26121, 26119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14249, 26097, 26099, 26121, 26119, 26098, 26100, 26122, 26120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14250, 26098, 26100, 26122, 26120, 5653, 5654, 5665, 5664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14251, 5265, 5266, 5277, 5276, 26099, 26101, 26123, 26121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14252, 26099, 26101, 26123, 26121, 26100, 26102, 26124, 26122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14253, 26100, 26102, 26124, 26122, 5654, 5655, 5666, 5665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14254, 5266, 5267, 5278, 5277, 26101, 26103, 26125, 26123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14255, 26101, 26103, 26125, 26123, 26102, 26104, 26126, 26124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14256, 26102, 26104, 26126, 26124, 5655, 5656, 5667, 5666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14257, 5267, 5268, 5279, 5278, 26103, 26105, 26127, 26125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14258, 26103, 26105, 26127, 26125, 26104, 26106, 26128, 26126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14259, 26104, 26106, 26128, 26126, 5656, 5657, 5668, 5667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14260, 5268, 5269, 5280, 5279, 26105, 26107, 26129, 26127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14261, 26105, 26107, 26129, 26127, 26106, 26108, 26130, 26128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14262, 26106, 26108, 26130, 26128, 5657, 5658, 5669, 5668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14263, 5269, 5270, 5281, 5280, 26107, 26109, 26131, 26129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14264, 26107, 26109, 26131, 26129, 26108, 26110, 26132, 26130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14265, 26108, 26110, 26132, 26130, 5658, 5659, 5670, 5669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14266, 5270, 5271, 5282, 5281, 26109, 26111, 26133, 26131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14267, 26109, 26111, 26133, 26131, 26110, 26112, 26134, 26132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14268, 26110, 26112, 26134, 26132, 5659, 5660, 5671, 5670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14269, 5271, 5272, 5283, 5282, 26111, 26113, 26135, 26133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14270, 26111, 26113, 26135, 26133, 26112, 26114, 26136, 26134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14271, 26112, 26114, 26136, 26134, 5660, 5661, 5672, 5671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14272, 5272, 5273, 5284, 5283, 26113, 26115, 26137, 26135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14273, 26113, 26115, 26137, 26135, 26114, 26116, 26138, 26136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14274, 26114, 26116, 26138, 26136, 5661, 5662, 5673, 5672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14275, 5273, 517, 518, 5284, 26115, 5467, 5469, 26137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14276, 26115, 5467, 5469, 26137, 26116, 5468, 5470, 26138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14277, 26116, 5468, 5470, 26138, 5662, 593, 594, 5673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14278, 484, 5274, 5285, 485, 5401, 26117, 26139, 5403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14279, 5401, 26117, 26139, 5403, 5402, 26118, 26140, 5404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14280, 5402, 26118, 26140, 5404, 556, 5663, 5674, 557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14281, 5274, 5275, 5286, 5285, 26117, 26119, 26141, 26139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14282, 26117, 26119, 26141, 26139, 26118, 26120, 26142, 26140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14283, 26118, 26120, 26142, 26140, 5663, 5664, 5675, 5674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14284, 5275, 5276, 5287, 5286, 26119, 26121, 26143, 26141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14285, 26119, 26121, 26143, 26141, 26120, 26122, 26144, 26142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14286, 26120, 26122, 26144, 26142, 5664, 5665, 5676, 5675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14287, 5276, 5277, 5288, 5287, 26121, 26123, 26145, 26143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14288, 26121, 26123, 26145, 26143, 26122, 26124, 26146, 26144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14289, 26122, 26124, 26146, 26144, 5665, 5666, 5677, 5676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14290, 5277, 5278, 5289, 5288, 26123, 26125, 26147, 26145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14291, 26123, 26125, 26147, 26145, 26124, 26126, 26148, 26146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14292, 26124, 26126, 26148, 26146, 5666, 5667, 5678, 5677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14293, 5278, 5279, 5290, 5289, 26125, 26127, 26149, 26147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14294, 26125, 26127, 26149, 26147, 26126, 26128, 26150, 26148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14295, 26126, 26128, 26150, 26148, 5667, 5668, 5679, 5678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14296, 5279, 5280, 5291, 5290, 26127, 26129, 26151, 26149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14297, 26127, 26129, 26151, 26149, 26128, 26130, 26152, 26150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14298, 26128, 26130, 26152, 26150, 5668, 5669, 5680, 5679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14299, 5280, 5281, 5292, 5291, 26129, 26131, 26153, 26151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14300, 26129, 26131, 26153, 26151, 26130, 26132, 26154, 26152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14301, 26130, 26132, 26154, 26152, 5669, 5670, 5681, 5680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14302, 5281, 5282, 5293, 5292, 26131, 26133, 26155, 26153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14303, 26131, 26133, 26155, 26153, 26132, 26134, 26156, 26154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14304, 26132, 26134, 26156, 26154, 5670, 5671, 5682, 5681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14305, 5282, 5283, 5294, 5293, 26133, 26135, 26157, 26155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14306, 26133, 26135, 26157, 26155, 26134, 26136, 26158, 26156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14307, 26134, 26136, 26158, 26156, 5671, 5672, 5683, 5682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14308, 5283, 5284, 5295, 5294, 26135, 26137, 26159, 26157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14309, 26135, 26137, 26159, 26157, 26136, 26138, 26160, 26158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14310, 26136, 26138, 26160, 26158, 5672, 5673, 5684, 5683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14311, 5284, 518, 519, 5295, 26137, 5469, 5471, 26159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14312, 26137, 5469, 5471, 26159, 26138, 5470, 5472, 26160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14313, 26138, 5470, 5472, 26160, 5673, 594, 595, 5684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14314, 485, 5285, 5296, 486, 5403, 26139, 26161, 5405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14315, 5403, 26139, 26161, 5405, 5404, 26140, 26162, 5406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14316, 5404, 26140, 26162, 5406, 557, 5674, 5685, 558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14317, 5285, 5286, 5297, 5296, 26139, 26141, 26163, 26161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14318, 26139, 26141, 26163, 26161, 26140, 26142, 26164, 26162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14319, 26140, 26142, 26164, 26162, 5674, 5675, 5686, 5685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14320, 5286, 5287, 5298, 5297, 26141, 26143, 26165, 26163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14321, 26141, 26143, 26165, 26163, 26142, 26144, 26166, 26164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14322, 26142, 26144, 26166, 26164, 5675, 5676, 5687, 5686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14323, 5287, 5288, 5299, 5298, 26143, 26145, 26167, 26165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14324, 26143, 26145, 26167, 26165, 26144, 26146, 26168, 26166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14325, 26144, 26146, 26168, 26166, 5676, 5677, 5688, 5687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14326, 5288, 5289, 5300, 5299, 26145, 26147, 26169, 26167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14327, 26145, 26147, 26169, 26167, 26146, 26148, 26170, 26168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14328, 26146, 26148, 26170, 26168, 5677, 5678, 5689, 5688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14329, 5289, 5290, 5301, 5300, 26147, 26149, 26171, 26169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14330, 26147, 26149, 26171, 26169, 26148, 26150, 26172, 26170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14331, 26148, 26150, 26172, 26170, 5678, 5679, 5690, 5689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14332, 5290, 5291, 5302, 5301, 26149, 26151, 26173, 26171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14333, 26149, 26151, 26173, 26171, 26150, 26152, 26174, 26172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14334, 26150, 26152, 26174, 26172, 5679, 5680, 5691, 5690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14335, 5291, 5292, 5303, 5302, 26151, 26153, 26175, 26173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14336, 26151, 26153, 26175, 26173, 26152, 26154, 26176, 26174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14337, 26152, 26154, 26176, 26174, 5680, 5681, 5692, 5691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14338, 5292, 5293, 5304, 5303, 26153, 26155, 26177, 26175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14339, 26153, 26155, 26177, 26175, 26154, 26156, 26178, 26176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14340, 26154, 26156, 26178, 26176, 5681, 5682, 5693, 5692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14341, 5293, 5294, 5305, 5304, 26155, 26157, 26179, 26177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14342, 26155, 26157, 26179, 26177, 26156, 26158, 26180, 26178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14343, 26156, 26158, 26180, 26178, 5682, 5683, 5694, 5693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14344, 5294, 5295, 5306, 5305, 26157, 26159, 26181, 26179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14345, 26157, 26159, 26181, 26179, 26158, 26160, 26182, 26180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14346, 26158, 26160, 26182, 26180, 5683, 5684, 5695, 5694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14347, 5295, 519, 520, 5306, 26159, 5471, 5473, 26181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14348, 26159, 5471, 5473, 26181, 26160, 5472, 5474, 26182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14349, 26160, 5472, 5474, 26182, 5684, 595, 596, 5695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14350, 486, 5296, 5307, 487, 5405, 26161, 26183, 5407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14351, 5405, 26161, 26183, 5407, 5406, 26162, 26184, 5408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14352, 5406, 26162, 26184, 5408, 558, 5685, 5696, 559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14353, 5296, 5297, 5308, 5307, 26161, 26163, 26185, 26183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14354, 26161, 26163, 26185, 26183, 26162, 26164, 26186, 26184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14355, 26162, 26164, 26186, 26184, 5685, 5686, 5697, 5696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14356, 5297, 5298, 5309, 5308, 26163, 26165, 26187, 26185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14357, 26163, 26165, 26187, 26185, 26164, 26166, 26188, 26186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14358, 26164, 26166, 26188, 26186, 5686, 5687, 5698, 5697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14359, 5298, 5299, 5310, 5309, 26165, 26167, 26189, 26187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14360, 26165, 26167, 26189, 26187, 26166, 26168, 26190, 26188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14361, 26166, 26168, 26190, 26188, 5687, 5688, 5699, 5698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14362, 5299, 5300, 5311, 5310, 26167, 26169, 26191, 26189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14363, 26167, 26169, 26191, 26189, 26168, 26170, 26192, 26190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14364, 26168, 26170, 26192, 26190, 5688, 5689, 5700, 5699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14365, 5300, 5301, 5312, 5311, 26169, 26171, 26193, 26191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14366, 26169, 26171, 26193, 26191, 26170, 26172, 26194, 26192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14367, 26170, 26172, 26194, 26192, 5689, 5690, 5701, 5700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14368, 5301, 5302, 5313, 5312, 26171, 26173, 26195, 26193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14369, 26171, 26173, 26195, 26193, 26172, 26174, 26196, 26194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14370, 26172, 26174, 26196, 26194, 5690, 5691, 5702, 5701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14371, 5302, 5303, 5314, 5313, 26173, 26175, 26197, 26195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14372, 26173, 26175, 26197, 26195, 26174, 26176, 26198, 26196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14373, 26174, 26176, 26198, 26196, 5691, 5692, 5703, 5702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14374, 5303, 5304, 5315, 5314, 26175, 26177, 26199, 26197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14375, 26175, 26177, 26199, 26197, 26176, 26178, 26200, 26198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14376, 26176, 26178, 26200, 26198, 5692, 5693, 5704, 5703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14377, 5304, 5305, 5316, 5315, 26177, 26179, 26201, 26199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14378, 26177, 26179, 26201, 26199, 26178, 26180, 26202, 26200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14379, 26178, 26180, 26202, 26200, 5693, 5694, 5705, 5704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14380, 5305, 5306, 5317, 5316, 26179, 26181, 26203, 26201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14381, 26179, 26181, 26203, 26201, 26180, 26182, 26204, 26202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14382, 26180, 26182, 26204, 26202, 5694, 5695, 5706, 5705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14383, 5306, 520, 521, 5317, 26181, 5473, 5475, 26203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14384, 26181, 5473, 5475, 26203, 26182, 5474, 5476, 26204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14385, 26182, 5474, 5476, 26204, 5695, 596, 597, 5706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14386, 487, 5307, 5318, 488, 5407, 26183, 26205, 5409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14387, 5407, 26183, 26205, 5409, 5408, 26184, 26206, 5410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14388, 5408, 26184, 26206, 5410, 559, 5696, 5707, 560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14389, 5307, 5308, 5319, 5318, 26183, 26185, 26207, 26205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14390, 26183, 26185, 26207, 26205, 26184, 26186, 26208, 26206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14391, 26184, 26186, 26208, 26206, 5696, 5697, 5708, 5707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14392, 5308, 5309, 5320, 5319, 26185, 26187, 26209, 26207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14393, 26185, 26187, 26209, 26207, 26186, 26188, 26210, 26208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14394, 26186, 26188, 26210, 26208, 5697, 5698, 5709, 5708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14395, 5309, 5310, 5321, 5320, 26187, 26189, 26211, 26209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14396, 26187, 26189, 26211, 26209, 26188, 26190, 26212, 26210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14397, 26188, 26190, 26212, 26210, 5698, 5699, 5710, 5709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14398, 5310, 5311, 5322, 5321, 26189, 26191, 26213, 26211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14399, 26189, 26191, 26213, 26211, 26190, 26192, 26214, 26212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14400, 26190, 26192, 26214, 26212, 5699, 5700, 5711, 5710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14401, 5311, 5312, 5323, 5322, 26191, 26193, 26215, 26213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14402, 26191, 26193, 26215, 26213, 26192, 26194, 26216, 26214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14403, 26192, 26194, 26216, 26214, 5700, 5701, 5712, 5711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14404, 5312, 5313, 5324, 5323, 26193, 26195, 26217, 26215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14405, 26193, 26195, 26217, 26215, 26194, 26196, 26218, 26216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14406, 26194, 26196, 26218, 26216, 5701, 5702, 5713, 5712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14407, 5313, 5314, 5325, 5324, 26195, 26197, 26219, 26217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14408, 26195, 26197, 26219, 26217, 26196, 26198, 26220, 26218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14409, 26196, 26198, 26220, 26218, 5702, 5703, 5714, 5713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14410, 5314, 5315, 5326, 5325, 26197, 26199, 26221, 26219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14411, 26197, 26199, 26221, 26219, 26198, 26200, 26222, 26220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14412, 26198, 26200, 26222, 26220, 5703, 5704, 5715, 5714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14413, 5315, 5316, 5327, 5326, 26199, 26201, 26223, 26221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14414, 26199, 26201, 26223, 26221, 26200, 26202, 26224, 26222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14415, 26200, 26202, 26224, 26222, 5704, 5705, 5716, 5715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14416, 5316, 5317, 5328, 5327, 26201, 26203, 26225, 26223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14417, 26201, 26203, 26225, 26223, 26202, 26204, 26226, 26224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14418, 26202, 26204, 26226, 26224, 5705, 5706, 5717, 5716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14419, 5317, 521, 522, 5328, 26203, 5475, 5477, 26225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14420, 26203, 5475, 5477, 26225, 26204, 5476, 5478, 26226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14421, 26204, 5476, 5478, 26226, 5706, 597, 598, 5717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14422, 488, 5318, 5329, 489, 5409, 26205, 26227, 5411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14423, 5409, 26205, 26227, 5411, 5410, 26206, 26228, 5412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14424, 5410, 26206, 26228, 5412, 560, 5707, 5718, 561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14425, 5318, 5319, 5330, 5329, 26205, 26207, 26229, 26227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14426, 26205, 26207, 26229, 26227, 26206, 26208, 26230, 26228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14427, 26206, 26208, 26230, 26228, 5707, 5708, 5719, 5718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14428, 5319, 5320, 5331, 5330, 26207, 26209, 26231, 26229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14429, 26207, 26209, 26231, 26229, 26208, 26210, 26232, 26230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14430, 26208, 26210, 26232, 26230, 5708, 5709, 5720, 5719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
