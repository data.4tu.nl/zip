18209, 0.875, -0.2, 0.125
18210, 0.875, -0.2, 0.16666666666667
18211, 0.875, -0.2, 0.20833333333333
18212, 0.875, -0.2, 0.25
18213, 0.875, -0.2, 0.29166666666667
18214, 0.875, -0.2, 0.33333333333333
18215, 0.875, -0.2, 0.375
18216, 0.875, -0.2, 0.41666666666667
18217, 0.875, -0.2, 0.45833333333333
18218, 0.91666666666667, -0.2, 0.041666666666667
18219, 0.91666666666667, -0.2, 0.083333333333333
18220, 0.91666666666667, -0.2, 0.125
18221, 0.91666666666667, -0.2, 0.16666666666667
18222, 0.91666666666667, -0.2, 0.20833333333333
18223, 0.91666666666667, -0.2, 0.25
18224, 0.91666666666667, -0.2, 0.29166666666667
18225, 0.91666666666667, -0.2, 0.33333333333333
18226, 0.91666666666667, -0.2, 0.375
18227, 0.91666666666667, -0.2, 0.41666666666667
18228, 0.91666666666667, -0.2, 0.45833333333333
18229, 0.95833333333333, -0.2, 0.041666666666667
18230, 0.95833333333333, -0.2, 0.083333333333333
18231, 0.95833333333333, -0.2, 0.125
18232, 0.95833333333333, -0.2, 0.16666666666667
18233, 0.95833333333333, -0.2, 0.20833333333333
18234, 0.95833333333333, -0.2, 0.25
18235, 0.95833333333333, -0.2, 0.29166666666667
18236, 0.95833333333333, -0.2, 0.33333333333333
18237, 0.95833333333333, -0.2, 0.375
18238, 0.95833333333333, -0.2, 0.41666666666667
18239, 0.95833333333333, -0.2, 0.45833333333333
18240, -0.05, -0.04, 0
18241, -0.05, -0.08, 0
18242, -0.05, -0.12, 0
18243, -0.05, -0.16, 0
18244, -0.1, -0.04, 0.041666666666667
18245, -0.1, -0.08, 0.041666666666667
18246, -0.1, -0.12, 0.041666666666667
18247, -0.1, -0.16, 0.041666666666667
18248, -0.1, -0.04, 0.083333333333333
18249, -0.1, -0.08, 0.083333333333333
18250, -0.1, -0.12, 0.083333333333333
18251, -0.1, -0.16, 0.083333333333333
18252, -0.1, -0.04, 0.125
18253, -0.1, -0.08, 0.125
18254, -0.1, -0.12, 0.125
18255, -0.1, -0.16, 0.125
18256, -0.1, -0.04, 0.16666666666667
18257, -0.1, -0.08, 0.16666666666667
18258, -0.1, -0.12, 0.16666666666667
18259, -0.1, -0.16, 0.16666666666667
18260, -0.1, -0.04, 0.20833333333333
18261, -0.1, -0.08, 0.20833333333333
18262, -0.1, -0.12, 0.20833333333333
18263, -0.1, -0.16, 0.20833333333333
18264, -0.1, -0.04, 0.25
18265, -0.1, -0.08, 0.25
18266, -0.1, -0.12, 0.25
18267, -0.1, -0.16, 0.25
18268, -0.1, -0.04, 0.29166666666667
18269, -0.1, -0.08, 0.29166666666667
18270, -0.1, -0.12, 0.29166666666667
18271, -0.1, -0.16, 0.29166666666667
18272, -0.1, -0.04, 0.33333333333333
18273, -0.1, -0.08, 0.33333333333333
18274, -0.1, -0.12, 0.33333333333333
18275, -0.1, -0.16, 0.33333333333333
18276, -0.1, -0.04, 0.375
18277, -0.1, -0.08, 0.375
18278, -0.1, -0.12, 0.375
18279, -0.1, -0.16, 0.375
18280, -0.1, -0.04, 0.41666666666667
18281, -0.1, -0.08, 0.41666666666667
18282, -0.1, -0.12, 0.41666666666667
18283, -0.1, -0.16, 0.41666666666667
18284, -0.1, -0.04, 0.45833333333333
18285, -0.1, -0.08, 0.45833333333333
18286, -0.1, -0.12, 0.45833333333333
18287, -0.1, -0.16, 0.45833333333333
18288, -0.1, -0.04, 0.020833333333333
18289, -0.1, -0.02, 0.041666666666667
18290, -0.1, -0.08, 0.020833333333333
18291, -0.1, -0.06, 0.041666666666667
18292, -0.1, -0.12, 0.020833333333333
18293, -0.1, -0.1, 0.041666666666667
18294, -0.1, -0.16, 0.020833333333333
18295, -0.1, -0.14, 0.041666666666667
18296, -0.1, -0.18, 0.041666666666667
18297, -0.1, -0.04, 0.0625
18298, -0.1, -0.02, 0.083333333333333
18299, -0.1, -0.08, 0.0625
18300, -0.1, -0.06, 0.083333333333333
18301, -0.1, -0.12, 0.0625
18302, -0.1, -0.1, 0.083333333333333
18303, -0.1, -0.16, 0.0625
18304, -0.1, -0.14, 0.083333333333333
18305, -0.1, -0.18, 0.083333333333333
18306, -0.1, -0.04, 0.10416666666667
18307, -0.1, -0.02, 0.125
18308, -0.1, -0.08, 0.10416666666667
18309, -0.1, -0.06, 0.125
18310, -0.1, -0.12, 0.10416666666667
18311, -0.1, -0.1, 0.125
18312, -0.1, -0.16, 0.10416666666667
18313, -0.1, -0.14, 0.125
18314, -0.1, -0.18, 0.125
18315, -0.1, -0.04, 0.14583333333333
18316, -0.1, -0.02, 0.16666666666667
18317, -0.1, -0.08, 0.14583333333333
18318, -0.1, -0.06, 0.16666666666667
18319, -0.1, -0.12, 0.14583333333333
18320, -0.1, -0.1, 0.16666666666667
18321, -0.1, -0.16, 0.14583333333333
18322, -0.1, -0.14, 0.16666666666667
18323, -0.1, -0.18, 0.16666666666667
18324, -0.1, -0.04, 0.1875
18325, -0.1, -0.02, 0.20833333333333
18326, -0.1, -0.08, 0.1875
18327, -0.1, -0.06, 0.20833333333333
18328, -0.1, -0.12, 0.1875
18329, -0.1, -0.1, 0.20833333333333
18330, -0.1, -0.16, 0.1875
18331, -0.1, -0.14, 0.20833333333333
18332, -0.1, -0.18, 0.20833333333333
18333, -0.1, -0.04, 0.22916666666667
18334, -0.1, -0.02, 0.25
18335, -0.1, -0.08, 0.22916666666667
18336, -0.1, -0.06, 0.25
18337, -0.1, -0.12, 0.22916666666667
18338, -0.1, -0.1, 0.25
18339, -0.1, -0.16, 0.22916666666667
18340, -0.1, -0.14, 0.25
18341, -0.1, -0.18, 0.25
18342, -0.1, -0.04, 0.27083333333333
18343, -0.1, -0.02, 0.29166666666667
18344, -0.1, -0.08, 0.27083333333333
18345, -0.1, -0.06, 0.29166666666667
18346, -0.1, -0.12, 0.27083333333333
18347, -0.1, -0.1, 0.29166666666667
18348, -0.1, -0.16, 0.27083333333333
18349, -0.1, -0.14, 0.29166666666667
18350, -0.1, -0.18, 0.29166666666667
18351, -0.1, -0.04, 0.3125
18352, -0.1, -0.02, 0.33333333333333
18353, -0.1, -0.08, 0.3125
18354, -0.1, -0.06, 0.33333333333333
18355, -0.1, -0.12, 0.3125
18356, -0.1, -0.1, 0.33333333333333
18357, -0.1, -0.16, 0.3125
18358, -0.1, -0.14, 0.33333333333333
18359, -0.1, -0.18, 0.33333333333333
18360, -0.1, -0.04, 0.35416666666667
18361, -0.1, -0.02, 0.375
18362, -0.1, -0.08, 0.35416666666667
18363, -0.1, -0.06, 0.375
18364, -0.1, -0.12, 0.35416666666667
18365, -0.1, -0.1, 0.375
18366, -0.1, -0.16, 0.35416666666667
18367, -0.1, -0.14, 0.375
18368, -0.1, -0.18, 0.375
18369, -0.1, -0.04, 0.39583333333333
18370, -0.1, -0.02, 0.41666666666667
18371, -0.1, -0.08, 0.39583333333333
18372, -0.1, -0.06, 0.41666666666667
18373, -0.1, -0.12, 0.39583333333333
18374, -0.1, -0.1, 0.41666666666667
18375, -0.1, -0.16, 0.39583333333333
18376, -0.1, -0.14, 0.41666666666667
18377, -0.1, -0.18, 0.41666666666667
18378, -0.1, -0.04, 0.4375
18379, -0.1, -0.02, 0.45833333333333
18380, -0.1, -0.08, 0.4375
18381, -0.1, -0.06, 0.45833333333333
18382, -0.1, -0.12, 0.4375
18383, -0.1, -0.1, 0.45833333333333
18384, -0.1, -0.16, 0.4375
18385, -0.1, -0.14, 0.45833333333333
18386, -0.1, -0.18, 0.45833333333333
18387, -0.1, -0.04, 0.47916666666667
18388, -0.1, -0.08, 0.47916666666667
18389, -0.1, -0.12, 0.47916666666667
18390, -0.1, -0.16, 0.47916666666667
18391, 1.2416666666667, -0.04, 0.5
18392, 1.2416666666667, -0.08, 0.5
18393, 1.2416666666667, -0.12, 0.5
18394, 1.2416666666667, -0.16, 0.5
18395, 1.2833333333333, -0.04, 0.5
18396, 1.2833333333333, -0.08, 0.5
18397, 1.2833333333333, -0.12, 0.5
18398, 1.2833333333333, -0.16, 0.5
18399, 1.325, -0.04, 0.5
18400, 1.325, -0.08, 0.5
18401, 1.325, -0.12, 0.5
18402, 1.325, -0.16, 0.5
18403, 1.3666666666667, -0.04, 0.5
18404, 1.3666666666667, -0.08, 0.5
18405, 1.3666666666667, -0.12, 0.5
18406, 1.3666666666667, -0.16, 0.5
18407, 1.4083333333333, -0.04, 0.5
18408, 1.4083333333333, -0.08, 0.5
18409, 1.4083333333333, -0.12, 0.5
18410, 1.4083333333333, -0.16, 0.5
18411, 1.45, -0.04, 0.5
18412, 1.45, -0.08, 0.5
18413, 1.45, -0.12, 0.5
18414, 1.45, -0.16, 0.5
18415, 1.4916666666667, -0.04, 0.5
18416, 1.4916666666667, -0.08, 0.5
18417, 1.4916666666667, -0.12, 0.5
18418, 1.4916666666667, -0.16, 0.5
18419, 1.5333333333333, -0.04, 0.5
18420, 1.5333333333333, -0.08, 0.5
18421, 1.5333333333333, -0.12, 0.5
18422, 1.5333333333333, -0.16, 0.5
18423, 1.575, -0.04, 0.5
18424, 1.575, -0.08, 0.5
18425, 1.575, -0.12, 0.5
18426, 1.575, -0.16, 0.5
18427, 1.6166666666667, -0.04, 0.5
18428, 1.6166666666667, -0.08, 0.5
18429, 1.6166666666667, -0.12, 0.5
18430, 1.6166666666667, -0.16, 0.5
18431, 1.6583333333333, -0.04, 0.5
18432, 1.6583333333333, -0.08, 0.5
18433, 1.6583333333333, -0.12, 0.5
18434, 1.6583333333333, -0.16, 0.5
18435, 1.7, -0.04, 0.5
18436, 1.7, -0.08, 0.5
18437, 1.7, -0.12, 0.5
18438, 1.7, -0.16, 0.5
18439, 1.7416666666667, -0.04, 0.5
18440, 1.7416666666667, -0.08, 0.5
18441, 1.7416666666667, -0.12, 0.5
18442, 1.7416666666667, -0.16, 0.5
18443, 1.7833333333333, -0.04, 0.5
18444, 1.7833333333333, -0.08, 0.5
18445, 1.7833333333333, -0.12, 0.5
18446, 1.7833333333333, -0.16, 0.5
18447, 1.825, -0.04, 0.5
18448, 1.825, -0.08, 0.5
18449, 1.825, -0.12, 0.5
18450, 1.825, -0.16, 0.5
18451, 1.8666666666667, -0.04, 0.5
18452, 1.8666666666667, -0.08, 0.5
18453, 1.8666666666667, -0.12, 0.5
18454, 1.8666666666667, -0.16, 0.5
18455, 1.9083333333333, -0.04, 0.5
18456, 1.9083333333333, -0.08, 0.5
18457, 1.9083333333333, -0.12, 0.5
18458, 1.9083333333333, -0.16, 0.5
18459, 1.95, -0.04, 0.5
18460, 1.95, -0.08, 0.5
18461, 1.95, -0.12, 0.5
18462, 1.95, -0.16, 0.5
18463, 1.9916666666667, -0.04, 0.5
18464, 1.9916666666667, -0.08, 0.5
18465, 1.9916666666667, -0.12, 0.5
18466, 1.9916666666667, -0.16, 0.5
18467, 2.0333333333333, -0.04, 0.5
18468, 2.0333333333333, -0.08, 0.5
18469, 2.0333333333333, -0.12, 0.5
18470, 2.0333333333333, -0.16, 0.5
18471, 2.075, -0.04, 0.5
18472, 2.075, -0.08, 0.5
18473, 2.075, -0.12, 0.5
18474, 2.075, -0.16, 0.5
18475, 2.1166666666667, -0.04, 0.5
18476, 2.1166666666667, -0.08, 0.5
18477, 2.1166666666667, -0.12, 0.5
18478, 2.1166666666667, -0.16, 0.5
18479, 2.1583333333333, -0.04, 0.5
18480, 2.1583333333333, -0.08, 0.5
18481, 2.1583333333333, -0.12, 0.5
18482, 2.1583333333333, -0.16, 0.5
18483, 1.2416666666667, -0.04, 0
18484, 1.2416666666667, -0.08, 0
18485, 1.2416666666667, -0.12, 0
18486, 1.2416666666667, -0.16, 0
18487, 1.2833333333333, -0.04, 0
18488, 1.2833333333333, -0.08, 0
18489, 1.2833333333333, -0.12, 0
18490, 1.2833333333333, -0.16, 0
18491, 1.325, -0.04, 0
18492, 1.325, -0.08, 0
18493, 1.325, -0.12, 0
18494, 1.325, -0.16, 0
18495, 1.3666666666667, -0.04, 0
18496, 1.3666666666667, -0.08, 0
18497, 1.3666666666667, -0.12, 0
18498, 1.3666666666667, -0.16, 0
18499, 1.4083333333333, -0.04, 0
18500, 1.4083333333333, -0.08, 0
18501, 1.4083333333333, -0.12, 0
18502, 1.4083333333333, -0.16, 0
18503, 1.45, -0.04, 0
18504, 1.45, -0.08, 0
18505, 1.45, -0.12, 0
18506, 1.45, -0.16, 0
18507, 1.4916666666667, -0.04, 0
18508, 1.4916666666667, -0.08, 0
18509, 1.4916666666667, -0.12, 0
18510, 1.4916666666667, -0.16, 0
18511, 1.5333333333333, -0.04, 0
18512, 1.5333333333333, -0.08, 0
18513, 1.5333333333333, -0.12, 0
18514, 1.5333333333333, -0.16, 0
18515, 1.575, -0.04, 0
18516, 1.575, -0.08, 0
18517, 1.575, -0.12, 0
18518, 1.575, -0.16, 0
18519, 1.6166666666667, -0.04, 0
18520, 1.6166666666667, -0.08, 0
18521, 1.6166666666667, -0.12, 0
18522, 1.6166666666667, -0.16, 0
18523, 1.6583333333333, -0.04, 0
18524, 1.6583333333333, -0.08, 0
18525, 1.6583333333333, -0.12, 0
18526, 1.6583333333333, -0.16, 0
18527, 1.7, -0.04, 0
18528, 1.7, -0.08, 0
18529, 1.7, -0.12, 0
18530, 1.7, -0.16, 0
18531, 1.7416666666667, -0.04, 0
18532, 1.7416666666667, -0.08, 0
18533, 1.7416666666667, -0.12, 0
18534, 1.7416666666667, -0.16, 0
18535, 1.7833333333333, -0.04, 0
18536, 1.7833333333333, -0.08, 0
18537, 1.7833333333333, -0.12, 0
18538, 1.7833333333333, -0.16, 0
18539, 1.825, -0.04, 0
18540, 1.825, -0.08, 0
18541, 1.825, -0.12, 0
18542, 1.825, -0.16, 0
18543, 1.8666666666667, -0.04, 0
18544, 1.8666666666667, -0.08, 0
18545, 1.8666666666667, -0.12, 0
18546, 1.8666666666667, -0.16, 0
18547, 1.9083333333333, -0.04, 0
18548, 1.9083333333333, -0.08, 0
18549, 1.9083333333333, -0.12, 0
18550, 1.9083333333333, -0.16, 0
18551, 1.95, -0.04, 0
18552, 1.95, -0.08, 0
18553, 1.95, -0.12, 0
18554, 1.95, -0.16, 0
18555, 1.9916666666667, -0.04, 0
18556, 1.9916666666667, -0.08, 0
18557, 1.9916666666667, -0.12, 0
18558, 1.9916666666667, -0.16, 0
18559, 2.0333333333333, -0.04, 0
18560, 2.0333333333333, -0.08, 0
18561, 2.0333333333333, -0.12, 0
18562, 2.0333333333333, -0.16, 0
18563, 2.075, -0.04, 0
18564, 2.075, -0.08, 0
18565, 2.075, -0.12, 0
18566, 2.075, -0.16, 0
18567, 2.1166666666667, -0.04, 0
18568, 2.1166666666667, -0.08, 0
18569, 2.1166666666667, -0.12, 0
18570, 2.1166666666667, -0.16, 0
18571, 2.1583333333333, -0.04, 0
18572, 2.1583333333333, -0.08, 0
18573, 2.1583333333333, -0.12, 0
18574, 2.1583333333333, -0.16, 0
18575, 1.2416666666667, -0.02, 0
18576, 1.2208333333333, -0.04, 0
18577, 1.2416666666667, -0.06, 0
18578, 1.2208333333333, -0.08, 0
18579, 1.2416666666667, -0.1, 0
18580, 1.2208333333333, -0.12, 0
18581, 1.2416666666667, -0.14, 0
18582, 1.2208333333333, -0.16, 0
18583, 1.2416666666667, -0.18, 0
18584, 1.2833333333333, -0.02, 0
18585, 1.2625, -0.04, 0
18586, 1.2833333333333, -0.06, 0
18587, 1.2625, -0.08, 0
18588, 1.2833333333333, -0.1, 0
18589, 1.2625, -0.12, 0
18590, 1.2833333333333, -0.14, 0
18591, 1.2625, -0.16, 0
18592, 1.2833333333333, -0.18, 0
18593, 1.325, -0.02, 0
18594, 1.3041666666667, -0.04, 0
18595, 1.325, -0.06, 0
18596, 1.3041666666667, -0.08, 0
18597, 1.325, -0.1, 0
18598, 1.3041666666667, -0.12, 0
18599, 1.325, -0.14, 0
18600, 1.3041666666667, -0.16, 0
18601, 1.325, -0.18, 0
18602, 1.3666666666667, -0.02, 0
18603, 1.3458333333333, -0.04, 0
18604, 1.3666666666667, -0.06, 0
18605, 1.3458333333333, -0.08, 0
18606, 1.3666666666667, -0.1, 0
18607, 1.3458333333333, -0.12, 0
18608, 1.3666666666667, -0.14, 0
18609, 1.3458333333333, -0.16, 0
18610, 1.3666666666667, -0.18, 0
18611, 1.4083333333333, -0.02, 0
18612, 1.3875, -0.04, 0
18613, 1.4083333333333, -0.06, 0
18614, 1.3875, -0.08, 0
18615, 1.4083333333333, -0.1, 0
18616, 1.3875, -0.12, 0
18617, 1.4083333333333, -0.14, 0
18618, 1.3875, -0.16, 0
18619, 1.4083333333333, -0.18, 0
18620, 1.45, -0.02, 0
18621, 1.4291666666667, -0.04, 0
18622, 1.45, -0.06, 0
18623, 1.4291666666667, -0.08, 0
18624, 1.45, -0.1, 0
18625, 1.4291666666667, -0.12, 0
18626, 1.45, -0.14, 0
18627, 1.4291666666667, -0.16, 0
18628, 1.45, -0.18, 0
18629, 1.4916666666667, -0.02, 0
18630, 1.4708333333333, -0.04, 0
18631, 1.4916666666667, -0.06, 0
18632, 1.4708333333333, -0.08, 0
18633, 1.4916666666667, -0.1, 0
18634, 1.4708333333333, -0.12, 0
18635, 1.4916666666667, -0.14, 0
18636, 1.4708333333333, -0.16, 0
18637, 1.4916666666667, -0.18, 0
18638, 1.5333333333333, -0.02, 0
18639, 1.5125, -0.04, 0
18640, 1.5333333333333, -0.06, 0
18641, 1.5125, -0.08, 0
18642, 1.5333333333333, -0.1, 0
18643, 1.5125, -0.12, 0
18644, 1.5333333333333, -0.14, 0
18645, 1.5125, -0.16, 0
18646, 1.5333333333333, -0.18, 0
18647, 1.575, -0.02, 0
18648, 1.5541666666667, -0.04, 0
18649, 1.575, -0.06, 0
18650, 1.5541666666667, -0.08, 0
18651, 1.575, -0.1, 0
18652, 1.5541666666667, -0.12, 0
18653, 1.575, -0.14, 0
18654, 1.5541666666667, -0.16, 0
18655, 1.575, -0.18, 0
18656, 1.6166666666667, -0.02, 0
18657, 1.5958333333333, -0.04, 0
18658, 1.6166666666667, -0.06, 0
18659, 1.5958333333333, -0.08, 0
18660, 1.6166666666667, -0.1, 0
18661, 1.5958333333333, -0.12, 0
18662, 1.6166666666667, -0.14, 0
18663, 1.5958333333333, -0.16, 0
18664, 1.6166666666667, -0.18, 0
18665, 1.6583333333333, -0.02, 0
18666, 1.6375, -0.04, 0
18667, 1.6583333333333, -0.06, 0
18668, 1.6375, -0.08, 0
18669, 1.6583333333333, -0.1, 0
18670, 1.6375, -0.12, 0
18671, 1.6583333333333, -0.14, 0
18672, 1.6375, -0.16, 0
18673, 1.6583333333333, -0.18, 0
18674, 1.7, -0.02, 0
18675, 1.6791666666667, -0.04, 0
18676, 1.7, -0.06, 0
18677, 1.6791666666667, -0.08, 0
18678, 1.7, -0.1, 0
18679, 1.6791666666667, -0.12, 0
18680, 1.7, -0.14, 0
18681, 1.6791666666667, -0.16, 0
18682, 1.7, -0.18, 0
18683, 1.7416666666667, -0.02, 0
18684, 1.7208333333333, -0.04, 0
18685, 1.7416666666667, -0.06, 0
18686, 1.7208333333333, -0.08, 0
18687, 1.7416666666667, -0.1, 0
18688, 1.7208333333333, -0.12, 0
18689, 1.7416666666667, -0.14, 0
18690, 1.7208333333333, -0.16, 0
18691, 1.7416666666667, -0.18, 0
18692, 1.7833333333333, -0.02, 0
18693, 1.7625, -0.04, 0
18694, 1.7833333333333, -0.06, 0
18695, 1.7625, -0.08, 0
18696, 1.7833333333333, -0.1, 0
18697, 1.7625, -0.12, 0
18698, 1.7833333333333, -0.14, 0
18699, 1.7625, -0.16, 0
18700, 1.7833333333333, -0.18, 0
18701, 1.825, -0.02, 0
18702, 1.8041666666667, -0.04, 0
18703, 1.825, -0.06, 0
18704, 1.8041666666667, -0.08, 0
18705, 1.825, -0.1, 0
18706, 1.8041666666667, -0.12, 0
18707, 1.825, -0.14, 0
18708, 1.8041666666667, -0.16, 0
18709, 1.825, -0.18, 0
18710, 1.8666666666667, -0.02, 0
18711, 1.8458333333333, -0.04, 0
18712, 1.8666666666667, -0.06, 0
18713, 1.8458333333333, -0.08, 0
18714, 1.8666666666667, -0.1, 0
18715, 1.8458333333333, -0.12, 0
18716, 1.8666666666667, -0.14, 0
18717, 1.8458333333333, -0.16, 0
18718, 1.8666666666667, -0.18, 0
18719, 1.9083333333333, -0.02, 0
18720, 1.8875, -0.04, 0
18721, 1.9083333333333, -0.06, 0
18722, 1.8875, -0.08, 0
18723, 1.9083333333333, -0.1, 0
18724, 1.8875, -0.12, 0
18725, 1.9083333333333, -0.14, 0
18726, 1.8875, -0.16, 0
18727, 1.9083333333333, -0.18, 0
18728, 1.95, -0.02, 0
18729, 1.9291666666667, -0.04, 0
18730, 1.95, -0.06, 0
18731, 1.9291666666667, -0.08, 0
18732, 1.95, -0.1, 0
18733, 1.9291666666667, -0.12, 0
18734, 1.95, -0.14, 0
18735, 1.9291666666667, -0.16, 0
18736, 1.95, -0.18, 0
18737, 1.9916666666667, -0.02, 0
18738, 1.9708333333333, -0.04, 0
18739, 1.9916666666667, -0.06, 0
18740, 1.9708333333333, -0.08, 0
18741, 1.9916666666667, -0.1, 0
18742, 1.9708333333333, -0.12, 0
18743, 1.9916666666667, -0.14, 0
18744, 1.9708333333333, -0.16, 0
18745, 1.9916666666667, -0.18, 0
18746, 2.0333333333333, -0.02, 0
18747, 2.0125, -0.04, 0
18748, 2.0333333333333, -0.06, 0
18749, 2.0125, -0.08, 0
18750, 2.0333333333333, -0.1, 0
18751, 2.0125, -0.12, 0
18752, 2.0333333333333, -0.14, 0
18753, 2.0125, -0.16, 0
18754, 2.0333333333333, -0.18, 0
18755, 2.075, -0.02, 0
18756, 2.0541666666667, -0.04, 0
18757, 2.075, -0.06, 0
18758, 2.0541666666667, -0.08, 0
18759, 2.075, -0.1, 0
18760, 2.0541666666667, -0.12, 0
18761, 2.075, -0.14, 0
18762, 2.0541666666667, -0.16, 0
18763, 2.075, -0.18, 0
18764, 2.1166666666667, -0.02, 0
18765, 2.0958333333333, -0.04, 0
18766, 2.1166666666667, -0.06, 0
18767, 2.0958333333333, -0.08, 0
18768, 2.1166666666667, -0.1, 0
18769, 2.0958333333333, -0.12, 0
18770, 2.1166666666667, -0.14, 0
18771, 2.0958333333333, -0.16, 0
18772, 2.1166666666667, -0.18, 0
18773, 2.1583333333333, -0.02, 0
18774, 2.1375, -0.04, 0
18775, 2.1583333333333, -0.06, 0
18776, 2.1375, -0.08, 0
18777, 2.1583333333333, -0.1, 0
18778, 2.1375, -0.12, 0
18779, 2.1583333333333, -0.14, 0
18780, 2.1375, -0.16, 0
18781, 2.1583333333333, -0.18, 0
18782, 2.1791666666667, -0.04, 0
18783, 2.1791666666667, -0.08, 0
18784, 2.1791666666667, -0.12, 0
18785, 2.1791666666667, -0.16, 0
18786, 1.2, -0.04, 0.041666666666667
18787, 1.2, -0.08, 0.041666666666667
18788, 1.2, -0.12, 0.041666666666667
18789, 1.2, -0.16, 0.041666666666667
18790, 1.2, -0.04, 0.083333333333333
18791, 1.2, -0.08, 0.083333333333333
18792, 1.2, -0.12, 0.083333333333333
18793, 1.2, -0.16, 0.083333333333333
18794, 1.2, -0.04, 0.125
18795, 1.2, -0.08, 0.125
18796, 1.2, -0.12, 0.125
18797, 1.2, -0.16, 0.125
18798, 1.2, -0.04, 0.16666666666667
18799, 1.2, -0.08, 0.16666666666667
18800, 1.2, -0.12, 0.16666666666667
18801, 1.2, -0.16, 0.16666666666667
18802, 1.2, -0.04, 0.20833333333333
18803, 1.2, -0.08, 0.20833333333333
18804, 1.2, -0.12, 0.20833333333333
18805, 1.2, -0.16, 0.20833333333333
18806, 1.2, -0.04, 0.25
18807, 1.2, -0.08, 0.25
18808, 1.2, -0.12, 0.25
18809, 1.2, -0.16, 0.25
18810, 1.2, -0.04, 0.29166666666667
18811, 1.2, -0.08, 0.29166666666667
18812, 1.2, -0.12, 0.29166666666667
18813, 1.2, -0.16, 0.29166666666667
18814, 1.2, -0.04, 0.33333333333333
18815, 1.2, -0.08, 0.33333333333333
18816, 1.2, -0.12, 0.33333333333333
18817, 1.2, -0.16, 0.33333333333333
18818, 1.2, -0.04, 0.375
18819, 1.2, -0.08, 0.375
18820, 1.2, -0.12, 0.375
18821, 1.2, -0.16, 0.375
18822, 1.2, -0.04, 0.41666666666667
18823, 1.2, -0.08, 0.41666666666667
18824, 1.2, -0.12, 0.41666666666667
18825, 1.2, -0.16, 0.41666666666667
18826, 1.2, -0.04, 0.45833333333333
18827, 1.2, -0.08, 0.45833333333333
18828, 1.2, -0.12, 0.45833333333333
18829, 1.2, -0.16, 0.45833333333333
18830, 1.2, -0.04, 0.020833333333333
18831, 1.2, -0.02, 0.041666666666667
18832, 1.2, -0.08, 0.020833333333333
18833, 1.2, -0.06, 0.041666666666667
18834, 1.2, -0.12, 0.020833333333333
18835, 1.2, -0.1, 0.041666666666667
18836, 1.2, -0.16, 0.020833333333333
18837, 1.2, -0.14, 0.041666666666667
18838, 1.2, -0.18, 0.041666666666667
18839, 1.2, -0.04, 0.0625
18840, 1.2, -0.02, 0.083333333333333
18841, 1.2, -0.08, 0.0625
18842, 1.2, -0.06, 0.083333333333333
18843, 1.2, -0.12, 0.0625
18844, 1.2, -0.1, 0.083333333333333
18845, 1.2, -0.16, 0.0625
18846, 1.2, -0.14, 0.083333333333333
18847, 1.2, -0.18, 0.083333333333333
18848, 1.2, -0.04, 0.10416666666667
18849, 1.2, -0.02, 0.125
18850, 1.2, -0.08, 0.10416666666667
18851, 1.2, -0.06, 0.125
18852, 1.2, -0.12, 0.10416666666667
18853, 1.2, -0.1, 0.125
18854, 1.2, -0.16, 0.10416666666667
18855, 1.2, -0.14, 0.125
18856, 1.2, -0.18, 0.125
18857, 1.2, -0.04, 0.14583333333333
18858, 1.2, -0.02, 0.16666666666667
18859, 1.2, -0.08, 0.14583333333333
18860, 1.2, -0.06, 0.16666666666667
18861, 1.2, -0.12, 0.14583333333333
18862, 1.2, -0.1, 0.16666666666667
18863, 1.2, -0.16, 0.14583333333333
18864, 1.2, -0.14, 0.16666666666667
18865, 1.2, -0.18, 0.16666666666667
18866, 1.2, -0.04, 0.1875
18867, 1.2, -0.02, 0.20833333333333
18868, 1.2, -0.08, 0.1875
18869, 1.2, -0.06, 0.20833333333333
18870, 1.2, -0.12, 0.1875
18871, 1.2, -0.1, 0.20833333333333
18872, 1.2, -0.16, 0.1875
18873, 1.2, -0.14, 0.20833333333333
18874, 1.2, -0.18, 0.20833333333333
18875, 1.2, -0.04, 0.22916666666667
18876, 1.2, -0.02, 0.25
18877, 1.2, -0.08, 0.22916666666667
18878, 1.2, -0.06, 0.25
18879, 1.2, -0.12, 0.22916666666667
18880, 1.2, -0.1, 0.25
18881, 1.2, -0.16, 0.22916666666667
18882, 1.2, -0.14, 0.25
18883, 1.2, -0.18, 0.25
18884, 1.2, -0.04, 0.27083333333333
18885, 1.2, -0.02, 0.29166666666667
18886, 1.2, -0.08, 0.27083333333333
18887, 1.2, -0.06, 0.29166666666667
18888, 1.2, -0.12, 0.27083333333333
18889, 1.2, -0.1, 0.29166666666667
18890, 1.2, -0.16, 0.27083333333333
18891, 1.2, -0.14, 0.29166666666667
18892, 1.2, -0.18, 0.29166666666667
18893, 1.2, -0.04, 0.3125
18894, 1.2, -0.02, 0.33333333333333
18895, 1.2, -0.08, 0.3125
18896, 1.2, -0.06, 0.33333333333333
18897, 1.2, -0.12, 0.3125
18898, 1.2, -0.1, 0.33333333333333
18899, 1.2, -0.16, 0.3125
18900, 1.2, -0.14, 0.33333333333333
18901, 1.2, -0.18, 0.33333333333333
18902, 1.2, -0.04, 0.35416666666667
18903, 1.2, -0.02, 0.375
18904, 1.2, -0.08, 0.35416666666667
18905, 1.2, -0.06, 0.375
18906, 1.2, -0.12, 0.35416666666667
18907, 1.2, -0.1, 0.375
18908, 1.2, -0.16, 0.35416666666667
18909, 1.2, -0.14, 0.375
18910, 1.2, -0.18, 0.375
18911, 1.2, -0.04, 0.39583333333333
18912, 1.2, -0.02, 0.41666666666667
18913, 1.2, -0.08, 0.39583333333333
18914, 1.2, -0.06, 0.41666666666667
18915, 1.2, -0.12, 0.39583333333333
18916, 1.2, -0.1, 0.41666666666667
18917, 1.2, -0.16, 0.39583333333333
18918, 1.2, -0.14, 0.41666666666667
18919, 1.2, -0.18, 0.41666666666667
18920, 1.2, -0.04, 0.4375
18921, 1.2, -0.02, 0.45833333333333
18922, 1.2, -0.08, 0.4375
18923, 1.2, -0.06, 0.45833333333333
18924, 1.2, -0.12, 0.4375
18925, 1.2, -0.1, 0.45833333333333
18926, 1.2, -0.16, 0.4375
18927, 1.2, -0.14, 0.45833333333333
18928, 1.2, -0.18, 0.45833333333333
18929, 1.2, -0.04, 0.47916666666667
18930, 1.2, -0.08, 0.47916666666667
18931, 1.2, -0.12, 0.47916666666667
18932, 1.2, -0.16, 0.47916666666667
18933, 2.2, -0.04, 0.041666666666667
18934, 2.2, -0.08, 0.041666666666667
18935, 2.2, -0.12, 0.041666666666667
18936, 2.2, -0.16, 0.041666666666667
18937, 2.2, -0.04, 0.083333333333333
18938, 2.2, -0.08, 0.083333333333333
18939, 2.2, -0.12, 0.083333333333333
18940, 2.2, -0.16, 0.083333333333333
18941, 2.2, -0.04, 0.125
18942, 2.2, -0.08, 0.125
18943, 2.2, -0.12, 0.125
18944, 2.2, -0.16, 0.125
18945, 2.2, -0.04, 0.16666666666667
18946, 2.2, -0.08, 0.16666666666667
18947, 2.2, -0.12, 0.16666666666667
18948, 2.2, -0.16, 0.16666666666667
18949, 2.2, -0.04, 0.20833333333333
18950, 2.2, -0.08, 0.20833333333333
18951, 2.2, -0.12, 0.20833333333333
18952, 2.2, -0.16, 0.20833333333333
18953, 2.2, -0.04, 0.25
18954, 2.2, -0.08, 0.25
18955, 2.2, -0.12, 0.25
18956, 2.2, -0.16, 0.25
18957, 2.2, -0.04, 0.29166666666667
18958, 2.2, -0.08, 0.29166666666667
18959, 2.2, -0.12, 0.29166666666667
18960, 2.2, -0.16, 0.29166666666667
18961, 2.2, -0.04, 0.33333333333333
18962, 2.2, -0.08, 0.33333333333333
18963, 2.2, -0.12, 0.33333333333333
18964, 2.2, -0.16, 0.33333333333333
18965, 2.2, -0.04, 0.375
18966, 2.2, -0.08, 0.375
18967, 2.2, -0.12, 0.375
18968, 2.2, -0.16, 0.375
18969, 2.2, -0.04, 0.41666666666667
18970, 2.2, -0.08, 0.41666666666667
18971, 2.2, -0.12, 0.41666666666667
18972, 2.2, -0.16, 0.41666666666667
18973, 2.2, -0.04, 0.45833333333333
18974, 2.2, -0.08, 0.45833333333333
18975, 2.2, -0.12, 0.45833333333333
18976, 2.2, -0.16, 0.45833333333333
18977, 2.2, -0.02, 0.041666666666667
18978, 2.2, -0.04, 0.020833333333333
18979, 2.2, -0.06, 0.041666666666667
18980, 2.2, -0.08, 0.020833333333333
18981, 2.2, -0.1, 0.041666666666667
18982, 2.2, -0.12, 0.020833333333333
18983, 2.2, -0.14, 0.041666666666667
18984, 2.2, -0.16, 0.020833333333333
18985, 2.2, -0.18, 0.041666666666667
18986, 2.2, -0.02, 0.083333333333333
18987, 2.2, -0.04, 0.0625
18988, 2.2, -0.06, 0.083333333333333
18989, 2.2, -0.08, 0.0625
18990, 2.2, -0.1, 0.083333333333333
18991, 2.2, -0.12, 0.0625
18992, 2.2, -0.14, 0.083333333333333
18993, 2.2, -0.16, 0.0625
18994, 2.2, -0.18, 0.083333333333333
18995, 2.2, -0.02, 0.125
18996, 2.2, -0.04, 0.10416666666667
18997, 2.2, -0.06, 0.125
18998, 2.2, -0.08, 0.10416666666667
18999, 2.2, -0.1, 0.125
19000, 2.2, -0.12, 0.10416666666667
19001, 2.2, -0.14, 0.125
19002, 2.2, -0.16, 0.10416666666667
19003, 2.2, -0.18, 0.125
19004, 2.2, -0.02, 0.16666666666667
19005, 2.2, -0.04, 0.14583333333333
19006, 2.2, -0.06, 0.16666666666667
19007, 2.2, -0.08, 0.14583333333333
19008, 2.2, -0.1, 0.16666666666667
19009, 2.2, -0.12, 0.14583333333333
19010, 2.2, -0.14, 0.16666666666667
19011, 2.2, -0.16, 0.14583333333333
19012, 2.2, -0.18, 0.16666666666667
19013, 2.2, -0.02, 0.20833333333333
19014, 2.2, -0.04, 0.1875
19015, 2.2, -0.06, 0.20833333333333
19016, 2.2, -0.08, 0.1875
19017, 2.2, -0.1, 0.20833333333333
19018, 2.2, -0.12, 0.1875
19019, 2.2, -0.14, 0.20833333333333
19020, 2.2, -0.16, 0.1875
19021, 2.2, -0.18, 0.20833333333333
19022, 2.2, -0.02, 0.25
19023, 2.2, -0.04, 0.22916666666667
19024, 2.2, -0.06, 0.25
19025, 2.2, -0.08, 0.22916666666667
19026, 2.2, -0.1, 0.25
19027, 2.2, -0.12, 0.22916666666667
19028, 2.2, -0.14, 0.25
19029, 2.2, -0.16, 0.22916666666667
19030, 2.2, -0.18, 0.25
19031, 2.2, -0.02, 0.29166666666667
19032, 2.2, -0.04, 0.27083333333333
19033, 2.2, -0.06, 0.29166666666667
19034, 2.2, -0.08, 0.27083333333333
19035, 2.2, -0.1, 0.29166666666667
19036, 2.2, -0.12, 0.27083333333333
19037, 2.2, -0.14, 0.29166666666667
19038, 2.2, -0.16, 0.27083333333333
19039, 2.2, -0.18, 0.29166666666667
19040, 2.2, -0.02, 0.33333333333333
19041, 2.2, -0.04, 0.3125
19042, 2.2, -0.06, 0.33333333333333
19043, 2.2, -0.08, 0.3125
19044, 2.2, -0.1, 0.33333333333333
19045, 2.2, -0.12, 0.3125
19046, 2.2, -0.14, 0.33333333333333
19047, 2.2, -0.16, 0.3125
19048, 2.2, -0.18, 0.33333333333333
19049, 2.2, -0.02, 0.375
19050, 2.2, -0.04, 0.35416666666667
19051, 2.2, -0.06, 0.375
19052, 2.2, -0.08, 0.35416666666667
19053, 2.2, -0.1, 0.375
19054, 2.2, -0.12, 0.35416666666667
19055, 2.2, -0.14, 0.375
19056, 2.2, -0.16, 0.35416666666667
19057, 2.2, -0.18, 0.375
19058, 2.2, -0.02, 0.41666666666667
19059, 2.2, -0.04, 0.39583333333333
19060, 2.2, -0.06, 0.41666666666667
19061, 2.2, -0.08, 0.39583333333333
19062, 2.2, -0.1, 0.41666666666667
19063, 2.2, -0.12, 0.39583333333333
19064, 2.2, -0.14, 0.41666666666667
19065, 2.2, -0.16, 0.39583333333333
19066, 2.2, -0.18, 0.41666666666667
19067, 2.2, -0.02, 0.45833333333333
19068, 2.2, -0.04, 0.4375
19069, 2.2, -0.06, 0.45833333333333
19070, 2.2, -0.08, 0.4375
19071, 2.2, -0.1, 0.45833333333333
19072, 2.2, -0.12, 0.4375
19073, 2.2, -0.14, 0.45833333333333
19074, 2.2, -0.16, 0.4375
19075, 2.2, -0.18, 0.45833333333333
19076, 2.2, -0.04, 0.47916666666667
19077, 2.2, -0.08, 0.47916666666667
19078, 2.2, -0.12, 0.47916666666667
19079, 2.2, -0.16, 0.47916666666667
19080, 1.2416666666667, -0.2, 0.041666666666667
19081, 1.2833333333333, -0.2, 0.041666666666667
19082, 1.325, -0.2, 0.041666666666667
19083, 1.3666666666667, -0.2, 0.041666666666667
19084, 1.4083333333333, -0.2, 0.041666666666667
19085, 1.45, -0.2, 0.041666666666667
19086, 1.4916666666667, -0.2, 0.041666666666667
19087, 1.5333333333333, -0.2, 0.041666666666667
19088, 1.575, -0.2, 0.041666666666667
19089, 1.6166666666667, -0.2, 0.041666666666667
19090, 1.6583333333333, -0.2, 0.041666666666667
19091, 1.7, -0.2, 0.041666666666667
19092, 1.7416666666667, -0.2, 0.041666666666667
19093, 1.7833333333333, -0.2, 0.041666666666667
19094, 1.825, -0.2, 0.041666666666667
19095, 1.8666666666667, -0.2, 0.041666666666667
19096, 1.9083333333333, -0.2, 0.041666666666667
19097, 1.95, -0.2, 0.041666666666667
19098, 1.9916666666667, -0.2, 0.041666666666667
19099, 2.0333333333333, -0.2, 0.041666666666667
19100, 2.075, -0.2, 0.041666666666667
19101, 2.1166666666667, -0.2, 0.041666666666667
19102, 2.1583333333333, -0.2, 0.041666666666667
19103, 1.2416666666667, -0.2, 0.083333333333333
19104, 1.2833333333333, -0.2, 0.083333333333333
19105, 1.325, -0.2, 0.083333333333333
19106, 1.3666666666667, -0.2, 0.083333333333333
19107, 1.4083333333333, -0.2, 0.083333333333333
19108, 1.45, -0.2, 0.083333333333333
19109, 1.4916666666667, -0.2, 0.083333333333333
19110, 1.5333333333333, -0.2, 0.083333333333333
19111, 1.575, -0.2, 0.083333333333333
19112, 1.6166666666667, -0.2, 0.083333333333333
19113, 1.6583333333333, -0.2, 0.083333333333333
19114, 1.7, -0.2, 0.083333333333333
19115, 1.7416666666667, -0.2, 0.083333333333333
19116, 1.7833333333333, -0.2, 0.083333333333333
19117, 1.825, -0.2, 0.083333333333333
19118, 1.8666666666667, -0.2, 0.083333333333333
19119, 1.9083333333333, -0.2, 0.083333333333333
19120, 1.95, -0.2, 0.083333333333333
19121, 1.9916666666667, -0.2, 0.083333333333333
19122, 2.0333333333333, -0.2, 0.083333333333333
19123, 2.075, -0.2, 0.083333333333333
19124, 2.1166666666667, -0.2, 0.083333333333333
19125, 2.1583333333333, -0.2, 0.083333333333333
19126, 1.2416666666667, -0.2, 0.125
19127, 1.2833333333333, -0.2, 0.125
19128, 1.325, -0.2, 0.125
19129, 1.3666666666667, -0.2, 0.125
19130, 1.4083333333333, -0.2, 0.125
19131, 1.45, -0.2, 0.125
19132, 1.4916666666667, -0.2, 0.125
19133, 1.5333333333333, -0.2, 0.125
19134, 1.575, -0.2, 0.125
19135, 1.6166666666667, -0.2, 0.125
19136, 1.6583333333333, -0.2, 0.125
19137, 1.7, -0.2, 0.125
19138, 1.7416666666667, -0.2, 0.125
19139, 1.7833333333333, -0.2, 0.125
19140, 1.825, -0.2, 0.125
19141, 1.8666666666667, -0.2, 0.125
19142, 1.9083333333333, -0.2, 0.125
19143, 1.95, -0.2, 0.125
19144, 1.9916666666667, -0.2, 0.125
19145, 2.0333333333333, -0.2, 0.125
19146, 2.075, -0.2, 0.125
19147, 2.1166666666667, -0.2, 0.125
19148, 2.1583333333333, -0.2, 0.125
19149, 1.2416666666667, -0.2, 0.16666666666667
19150, 1.2833333333333, -0.2, 0.16666666666667
19151, 1.325, -0.2, 0.16666666666667
19152, 1.3666666666667, -0.2, 0.16666666666667
19153, 1.4083333333333, -0.2, 0.16666666666667
19154, 1.45, -0.2, 0.16666666666667
19155, 1.4916666666667, -0.2, 0.16666666666667
19156, 1.5333333333333, -0.2, 0.16666666666667
19157, 1.575, -0.2, 0.16666666666667
19158, 1.6166666666667, -0.2, 0.16666666666667
19159, 1.6583333333333, -0.2, 0.16666666666667
19160, 1.7, -0.2, 0.16666666666667
19161, 1.7416666666667, -0.2, 0.16666666666667
19162, 1.7833333333333, -0.2, 0.16666666666667
19163, 1.825, -0.2, 0.16666666666667
19164, 1.8666666666667, -0.2, 0.16666666666667
19165, 1.9083333333333, -0.2, 0.16666666666667
19166, 1.95, -0.2, 0.16666666666667
19167, 1.9916666666667, -0.2, 0.16666666666667
19168, 2.0333333333333, -0.2, 0.16666666666667
19169, 2.075, -0.2, 0.16666666666667
19170, 2.1166666666667, -0.2, 0.16666666666667
19171, 2.1583333333333, -0.2, 0.16666666666667
19172, 1.2416666666667, -0.2, 0.20833333333333
19173, 1.2833333333333, -0.2, 0.20833333333333
19174, 1.325, -0.2, 0.20833333333333
19175, 1.3666666666667, -0.2, 0.20833333333333
19176, 1.4083333333333, -0.2, 0.20833333333333
19177, 1.45, -0.2, 0.20833333333333
19178, 1.4916666666667, -0.2, 0.20833333333333
19179, 1.5333333333333, -0.2, 0.20833333333333
19180, 1.575, -0.2, 0.20833333333333
19181, 1.6166666666667, -0.2, 0.20833333333333
19182, 1.6583333333333, -0.2, 0.20833333333333
19183, 1.7, -0.2, 0.20833333333333
19184, 1.7416666666667, -0.2, 0.20833333333333
19185, 1.7833333333333, -0.2, 0.20833333333333
19186, 1.825, -0.2, 0.20833333333333
19187, 1.8666666666667, -0.2, 0.20833333333333
19188, 1.9083333333333, -0.2, 0.20833333333333
19189, 1.95, -0.2, 0.20833333333333
19190, 1.9916666666667, -0.2, 0.20833333333333
19191, 2.0333333333333, -0.2, 0.20833333333333
19192, 2.075, -0.2, 0.20833333333333
19193, 2.1166666666667, -0.2, 0.20833333333333
19194, 2.1583333333333, -0.2, 0.20833333333333
19195, 1.2416666666667, -0.2, 0.25
19196, 1.2833333333333, -0.2, 0.25
19197, 1.325, -0.2, 0.25
19198, 1.3666666666667, -0.2, 0.25
19199, 1.4083333333333, -0.2, 0.25
19200, 1.45, -0.2, 0.25
19201, 1.4916666666667, -0.2, 0.25
19202, 1.5333333333333, -0.2, 0.25
19203, 1.575, -0.2, 0.25
19204, 1.6166666666667, -0.2, 0.25
19205, 1.6583333333333, -0.2, 0.25
19206, 1.7, -0.2, 0.25
19207, 1.7416666666667, -0.2, 0.25
19208, 1.7833333333333, -0.2, 0.25
19209, 1.825, -0.2, 0.25
19210, 1.8666666666667, -0.2, 0.25
19211, 1.9083333333333, -0.2, 0.25
19212, 1.95, -0.2, 0.25
19213, 1.9916666666667, -0.2, 0.25
19214, 2.0333333333333, -0.2, 0.25
19215, 2.075, -0.2, 0.25
19216, 2.1166666666667, -0.2, 0.25
19217, 2.1583333333333, -0.2, 0.25
19218, 1.2416666666667, -0.2, 0.29166666666667
19219, 1.2833333333333, -0.2, 0.29166666666667
19220, 1.325, -0.2, 0.29166666666667
19221, 1.3666666666667, -0.2, 0.29166666666667
19222, 1.4083333333333, -0.2, 0.29166666666667
19223, 1.45, -0.2, 0.29166666666667
19224, 1.4916666666667, -0.2, 0.29166666666667
19225, 1.5333333333333, -0.2, 0.29166666666667
19226, 1.575, -0.2, 0.29166666666667
19227, 1.6166666666667, -0.2, 0.29166666666667
19228, 1.6583333333333, -0.2, 0.29166666666667
19229, 1.7, -0.2, 0.29166666666667
19230, 1.7416666666667, -0.2, 0.29166666666667
19231, 1.7833333333333, -0.2, 0.29166666666667
19232, 1.825, -0.2, 0.29166666666667
19233, 1.8666666666667, -0.2, 0.29166666666667
19234, 1.9083333333333, -0.2, 0.29166666666667
19235, 1.95, -0.2, 0.29166666666667
19236, 1.9916666666667, -0.2, 0.29166666666667
19237, 2.0333333333333, -0.2, 0.29166666666667
19238, 2.075, -0.2, 0.29166666666667
19239, 2.1166666666667, -0.2, 0.29166666666667
19240, 2.1583333333333, -0.2, 0.29166666666667
19241, 1.2416666666667, -0.2, 0.33333333333333
19242, 1.2833333333333, -0.2, 0.33333333333333
19243, 1.325, -0.2, 0.33333333333333
19244, 1.3666666666667, -0.2, 0.33333333333333
19245, 1.4083333333333, -0.2, 0.33333333333333
19246, 1.45, -0.2, 0.33333333333333
19247, 1.4916666666667, -0.2, 0.33333333333333
19248, 1.5333333333333, -0.2, 0.33333333333333
19249, 1.575, -0.2, 0.33333333333333
19250, 1.6166666666667, -0.2, 0.33333333333333
19251, 1.6583333333333, -0.2, 0.33333333333333
19252, 1.7, -0.2, 0.33333333333333
19253, 1.7416666666667, -0.2, 0.33333333333333
19254, 1.7833333333333, -0.2, 0.33333333333333
19255, 1.825, -0.2, 0.33333333333333
19256, 1.8666666666667, -0.2, 0.33333333333333
19257, 1.9083333333333, -0.2, 0.33333333333333
19258, 1.95, -0.2, 0.33333333333333
19259, 1.9916666666667, -0.2, 0.33333333333333
19260, 2.0333333333333, -0.2, 0.33333333333333
19261, 2.075, -0.2, 0.33333333333333
19262, 2.1166666666667, -0.2, 0.33333333333333
19263, 2.1583333333333, -0.2, 0.33333333333333
19264, 1.2416666666667, -0.2, 0.375
19265, 1.2833333333333, -0.2, 0.375
19266, 1.325, -0.2, 0.375
19267, 1.3666666666667, -0.2, 0.375
19268, 1.4083333333333, -0.2, 0.375
19269, 1.45, -0.2, 0.375
19270, 1.4916666666667, -0.2, 0.375
19271, 1.5333333333333, -0.2, 0.375
19272, 1.575, -0.2, 0.375
19273, 1.6166666666667, -0.2, 0.375
19274, 1.6583333333333, -0.2, 0.375
19275, 1.7, -0.2, 0.375
19276, 1.7416666666667, -0.2, 0.375
19277, 1.7833333333333, -0.2, 0.375
19278, 1.825, -0.2, 0.375
19279, 1.8666666666667, -0.2, 0.375
19280, 1.9083333333333, -0.2, 0.375
19281, 1.95, -0.2, 0.375
19282, 1.9916666666667, -0.2, 0.375
19283, 2.0333333333333, -0.2, 0.375
19284, 2.075, -0.2, 0.375
19285, 2.1166666666667, -0.2, 0.375
19286, 2.1583333333333, -0.2, 0.375
19287, 1.2416666666667, -0.2, 0.41666666666667
19288, 1.2833333333333, -0.2, 0.41666666666667
19289, 1.325, -0.2, 0.41666666666667
19290, 1.3666666666667, -0.2, 0.41666666666667
19291, 1.4083333333333, -0.2, 0.41666666666667
19292, 1.45, -0.2, 0.41666666666667
19293, 1.4916666666667, -0.2, 0.41666666666667
19294, 1.5333333333333, -0.2, 0.41666666666667
19295, 1.575, -0.2, 0.41666666666667
19296, 1.6166666666667, -0.2, 0.41666666666667
19297, 1.6583333333333, -0.2, 0.41666666666667
19298, 1.7, -0.2, 0.41666666666667
19299, 1.7416666666667, -0.2, 0.41666666666667
19300, 1.7833333333333, -0.2, 0.41666666666667
19301, 1.825, -0.2, 0.41666666666667
19302, 1.8666666666667, -0.2, 0.41666666666667
19303, 1.9083333333333, -0.2, 0.41666666666667
19304, 1.95, -0.2, 0.41666666666667
19305, 1.9916666666667, -0.2, 0.41666666666667
19306, 2.0333333333333, -0.2, 0.41666666666667
19307, 2.075, -0.2, 0.41666666666667
19308, 2.1166666666667, -0.2, 0.41666666666667
19309, 2.1583333333333, -0.2, 0.41666666666667
19310, 1.2416666666667, -0.2, 0.45833333333333
19311, 1.2833333333333, -0.2, 0.45833333333333
19312, 1.325, -0.2, 0.45833333333333
19313, 1.3666666666667, -0.2, 0.45833333333333
19314, 1.4083333333333, -0.2, 0.45833333333333
19315, 1.45, -0.2, 0.45833333333333
19316, 1.4916666666667, -0.2, 0.45833333333333
19317, 1.5333333333333, -0.2, 0.45833333333333
19318, 1.575, -0.2, 0.45833333333333
19319, 1.6166666666667, -0.2, 0.45833333333333
19320, 1.6583333333333, -0.2, 0.45833333333333
19321, 1.7, -0.2, 0.45833333333333
19322, 1.7416666666667, -0.2, 0.45833333333333
19323, 1.7833333333333, -0.2, 0.45833333333333
19324, 1.825, -0.2, 0.45833333333333
19325, 1.8666666666667, -0.2, 0.45833333333333
19326, 1.9083333333333, -0.2, 0.45833333333333
19327, 1.95, -0.2, 0.45833333333333
19328, 1.9916666666667, -0.2, 0.45833333333333
19329, 2.0333333333333, -0.2, 0.45833333333333
19330, 2.075, -0.2, 0.45833333333333
19331, 2.1166666666667, -0.2, 0.45833333333333
19332, 2.1583333333333, -0.2, 0.45833333333333
19333, 2.25, -0.04, 0
19334, 2.25, -0.08, 0
19335, 2.25, -0.12, 0
19336, 2.25, -0.16, 0
19337, 2.3, -0.04, 0.041666666666667
19338, 2.3, -0.08, 0.041666666666667
19339, 2.3, -0.12, 0.041666666666667
19340, 2.3, -0.16, 0.041666666666667
19341, 2.3, -0.04, 0.083333333333333
19342, 2.3, -0.08, 0.083333333333333
19343, 2.3, -0.12, 0.083333333333333
19344, 2.3, -0.16, 0.083333333333333
19345, 2.3, -0.04, 0.125
19346, 2.3, -0.08, 0.125
19347, 2.3, -0.12, 0.125
19348, 2.3, -0.16, 0.125
19349, 2.3, -0.04, 0.16666666666667
19350, 2.3, -0.08, 0.16666666666667
19351, 2.3, -0.12, 0.16666666666667
19352, 2.3, -0.16, 0.16666666666667
19353, 2.3, -0.04, 0.20833333333333
19354, 2.3, -0.08, 0.20833333333333
19355, 2.3, -0.12, 0.20833333333333
19356, 2.3, -0.16, 0.20833333333333
19357, 2.3, -0.04, 0.25
19358, 2.3, -0.08, 0.25
19359, 2.3, -0.12, 0.25
19360, 2.3, -0.16, 0.25
19361, 2.3, -0.04, 0.29166666666667
19362, 2.3, -0.08, 0.29166666666667
19363, 2.3, -0.12, 0.29166666666667
19364, 2.3, -0.16, 0.29166666666667
19365, 2.3, -0.04, 0.33333333333333
19366, 2.3, -0.08, 0.33333333333333
19367, 2.3, -0.12, 0.33333333333333
19368, 2.3, -0.16, 0.33333333333333
19369, 2.3, -0.04, 0.375
19370, 2.3, -0.08, 0.375
19371, 2.3, -0.12, 0.375
19372, 2.3, -0.16, 0.375
19373, 2.3, -0.04, 0.41666666666667
19374, 2.3, -0.08, 0.41666666666667
19375, 2.3, -0.12, 0.41666666666667
19376, 2.3, -0.16, 0.41666666666667
19377, 2.3, -0.04, 0.45833333333333
19378, 2.3, -0.08, 0.45833333333333
19379, 2.3, -0.12, 0.45833333333333
19380, 2.3, -0.16, 0.45833333333333
19381, 2.3, -0.02, 0.041666666666667
19382, 2.3, -0.04, 0.020833333333333
19383, 2.3, -0.06, 0.041666666666667
19384, 2.3, -0.08, 0.020833333333333
19385, 2.3, -0.1, 0.041666666666667
19386, 2.3, -0.12, 0.020833333333333
19387, 2.3, -0.14, 0.041666666666667
19388, 2.3, -0.16, 0.020833333333333
19389, 2.3, -0.18, 0.041666666666667
19390, 2.3, -0.02, 0.083333333333333
19391, 2.3, -0.04, 0.0625
19392, 2.3, -0.06, 0.083333333333333
19393, 2.3, -0.08, 0.0625
19394, 2.3, -0.1, 0.083333333333333
19395, 2.3, -0.12, 0.0625
19396, 2.3, -0.14, 0.083333333333333
19397, 2.3, -0.16, 0.0625
19398, 2.3, -0.18, 0.083333333333333
19399, 2.3, -0.02, 0.125
19400, 2.3, -0.04, 0.10416666666667
19401, 2.3, -0.06, 0.125
19402, 2.3, -0.08, 0.10416666666667
19403, 2.3, -0.1, 0.125
19404, 2.3, -0.12, 0.10416666666667
19405, 2.3, -0.14, 0.125
19406, 2.3, -0.16, 0.10416666666667
19407, 2.3, -0.18, 0.125
19408, 2.3, -0.02, 0.16666666666667
19409, 2.3, -0.04, 0.14583333333333
19410, 2.3, -0.06, 0.16666666666667
19411, 2.3, -0.08, 0.14583333333333
19412, 2.3, -0.1, 0.16666666666667
19413, 2.3, -0.12, 0.14583333333333
19414, 2.3, -0.14, 0.16666666666667
19415, 2.3, -0.16, 0.14583333333333
19416, 2.3, -0.18, 0.16666666666667
19417, 2.3, -0.02, 0.20833333333333
19418, 2.3, -0.04, 0.1875
19419, 2.3, -0.06, 0.20833333333333
19420, 2.3, -0.08, 0.1875
19421, 2.3, -0.1, 0.20833333333333
19422, 2.3, -0.12, 0.1875
19423, 2.3, -0.14, 0.20833333333333
19424, 2.3, -0.16, 0.1875
19425, 2.3, -0.18, 0.20833333333333
19426, 2.3, -0.02, 0.25
19427, 2.3, -0.04, 0.22916666666667
19428, 2.3, -0.06, 0.25
19429, 2.3, -0.08, 0.22916666666667
19430, 2.3, -0.1, 0.25
19431, 2.3, -0.12, 0.22916666666667
19432, 2.3, -0.14, 0.25
19433, 2.3, -0.16, 0.22916666666667
19434, 2.3, -0.18, 0.25
19435, 2.3, -0.02, 0.29166666666667
19436, 2.3, -0.04, 0.27083333333333
19437, 2.3, -0.06, 0.29166666666667
19438, 2.3, -0.08, 0.27083333333333
19439, 2.3, -0.1, 0.29166666666667
19440, 2.3, -0.12, 0.27083333333333
19441, 2.3, -0.14, 0.29166666666667
19442, 2.3, -0.16, 0.27083333333333
19443, 2.3, -0.18, 0.29166666666667
19444, 2.3, -0.02, 0.33333333333333
19445, 2.3, -0.04, 0.3125
19446, 2.3, -0.06, 0.33333333333333
19447, 2.3, -0.08, 0.3125
19448, 2.3, -0.1, 0.33333333333333
19449, 2.3, -0.12, 0.3125
19450, 2.3, -0.14, 0.33333333333333
19451, 2.3, -0.16, 0.3125
19452, 2.3, -0.18, 0.33333333333333
19453, 2.3, -0.02, 0.375
19454, 2.3, -0.04, 0.35416666666667
19455, 2.3, -0.06, 0.375
19456, 2.3, -0.08, 0.35416666666667
19457, 2.3, -0.1, 0.375
19458, 2.3, -0.12, 0.35416666666667
19459, 2.3, -0.14, 0.375
19460, 2.3, -0.16, 0.35416666666667
19461, 2.3, -0.18, 0.375
19462, 2.3, -0.02, 0.41666666666667
19463, 2.3, -0.04, 0.39583333333333
19464, 2.3, -0.06, 0.41666666666667
19465, 2.3, -0.08, 0.39583333333333
19466, 2.3, -0.1, 0.41666666666667
19467, 2.3, -0.12, 0.39583333333333
19468, 2.3, -0.14, 0.41666666666667
19469, 2.3, -0.16, 0.39583333333333
19470, 2.3, -0.18, 0.41666666666667
19471, 2.3, -0.02, 0.45833333333333
19472, 2.3, -0.04, 0.4375
19473, 2.3, -0.06, 0.45833333333333
19474, 2.3, -0.08, 0.4375
19475, 2.3, -0.1, 0.45833333333333
19476, 2.3, -0.12, 0.4375
19477, 2.3, -0.14, 0.45833333333333
19478, 2.3, -0.16, 0.4375
19479, 2.3, -0.18, 0.45833333333333
19480, 2.3, -0.04, 0.47916666666667
19481, 2.3, -0.08, 0.47916666666667
19482, 2.3, -0.12, 0.47916666666667
19483, 2.3, -0.16, 0.47916666666667
19484, 0.041666666666667, 0.033333333333333, 0.041666666666667
19485, 0.083333333333333, 0.033333333333333, 0.041666666666667
19486, 0.125, 0.033333333333333, 0.041666666666667
19487, 0.16666666666667, 0.033333333333333, 0.041666666666667
19488, 0.20833333333333, 0.033333333333333, 0.041666666666667
19489, 0.25, 0.033333333333333, 0.041666666666667
19490, 0.29166666666667, 0.033333333333333, 0.041666666666667
19491, 0.33333333333333, 0.033333333333333, 0.041666666666667
19492, 0.375, 0.033333333333333, 0.041666666666667
19493, 0.41666666666667, 0.033333333333333, 0.041666666666667
19494, 0.45833333333333, 0.033333333333333, 0.041666666666667
19495, 0.5, 0.033333333333333, 0.041666666666667
19496, 0.54166666666667, 0.033333333333333, 0.041666666666667
19497, 0.58333333333333, 0.033333333333333, 0.041666666666667
19498, 0.625, 0.033333333333333, 0.041666666666667
19499, 0.66666666666667, 0.033333333333333, 0.041666666666667
19500, 0.70833333333333, 0.033333333333333, 0.041666666666667
19501, 0.75, 0.033333333333333, 0.041666666666667
19502, 0.79166666666667, 0.033333333333333, 0.041666666666667
19503, 0.83333333333333, 0.033333333333333, 0.041666666666667
19504, 0.875, 0.033333333333333, 0.041666666666667
19505, 0.91666666666667, 0.033333333333333, 0.041666666666667
19506, 0.95833333333333, 0.033333333333333, 0.041666666666667
19507, 0.041666666666667, 0.066666666666667, 0.041666666666667
19508, 0.083333333333333, 0.066666666666667, 0.041666666666667
19509, 0.125, 0.066666666666667, 0.041666666666667
19510, 0.16666666666667, 0.066666666666667, 0.041666666666667
19511, 0.20833333333333, 0.066666666666667, 0.041666666666667
19512, 0.25, 0.066666666666667, 0.041666666666667
19513, 0.29166666666667, 0.066666666666667, 0.041666666666667
19514, 0.33333333333333, 0.066666666666667, 0.041666666666667
19515, 0.375, 0.066666666666667, 0.041666666666667
19516, 0.41666666666667, 0.066666666666667, 0.041666666666667
19517, 0.45833333333333, 0.066666666666667, 0.041666666666667
19518, 0.5, 0.066666666666667, 0.041666666666667
19519, 0.54166666666667, 0.066666666666667, 0.041666666666667
19520, 0.58333333333333, 0.066666666666667, 0.041666666666667
19521, 0.625, 0.066666666666667, 0.041666666666667
19522, 0.66666666666667, 0.066666666666667, 0.041666666666667
19523, 0.70833333333333, 0.066666666666667, 0.041666666666667
19524, 0.75, 0.066666666666667, 0.041666666666667
19525, 0.79166666666667, 0.066666666666667, 0.041666666666667
19526, 0.83333333333333, 0.066666666666667, 0.041666666666667
19527, 0.875, 0.066666666666667, 0.041666666666667
19528, 0.91666666666667, 0.066666666666667, 0.041666666666667
19529, 0.95833333333333, 0.066666666666667, 0.041666666666667
19530, 0.041666666666667, 0.033333333333333, 0.083333333333333
19531, 0.083333333333333, 0.033333333333333, 0.083333333333333
19532, 0.125, 0.033333333333333, 0.083333333333333
19533, 0.16666666666667, 0.033333333333333, 0.083333333333333
19534, 0.20833333333333, 0.033333333333333, 0.083333333333333
19535, 0.25, 0.033333333333333, 0.083333333333333
19536, 0.29166666666667, 0.033333333333333, 0.083333333333333
19537, 0.33333333333333, 0.033333333333333, 0.083333333333333
19538, 0.375, 0.033333333333333, 0.083333333333333
19539, 0.41666666666667, 0.033333333333333, 0.083333333333333
19540, 0.45833333333333, 0.033333333333333, 0.083333333333333
19541, 0.5, 0.033333333333333, 0.083333333333333
19542, 0.54166666666667, 0.033333333333333, 0.083333333333333
19543, 0.58333333333333, 0.033333333333333, 0.083333333333333
19544, 0.625, 0.033333333333333, 0.083333333333333
19545, 0.66666666666667, 0.033333333333333, 0.083333333333333
19546, 0.70833333333333, 0.033333333333333, 0.083333333333333
19547, 0.75, 0.033333333333333, 0.083333333333333
19548, 0.79166666666667, 0.033333333333333, 0.083333333333333
19549, 0.83333333333333, 0.033333333333333, 0.083333333333333
19550, 0.875, 0.033333333333333, 0.083333333333333
19551, 0.91666666666667, 0.033333333333333, 0.083333333333333
19552, 0.95833333333333, 0.033333333333333, 0.083333333333333
19553, 0.041666666666667, 0.066666666666667, 0.083333333333333
19554, 0.083333333333333, 0.066666666666667, 0.083333333333333
19555, 0.125, 0.066666666666667, 0.083333333333333
19556, 0.16666666666667, 0.066666666666667, 0.083333333333333
19557, 0.20833333333333, 0.066666666666667, 0.083333333333333
19558, 0.25, 0.066666666666667, 0.083333333333333
19559, 0.29166666666667, 0.066666666666667, 0.083333333333333
19560, 0.33333333333333, 0.066666666666667, 0.083333333333333
19561, 0.375, 0.066666666666667, 0.083333333333333
19562, 0.41666666666667, 0.066666666666667, 0.083333333333333
19563, 0.45833333333333, 0.066666666666667, 0.083333333333333
19564, 0.5, 0.066666666666667, 0.083333333333333
19565, 0.54166666666667, 0.066666666666667, 0.083333333333333
19566, 0.58333333333333, 0.066666666666667, 0.083333333333333
19567, 0.625, 0.066666666666667, 0.083333333333333
19568, 0.66666666666667, 0.066666666666667, 0.083333333333333
19569, 0.70833333333333, 0.066666666666667, 0.083333333333333
19570, 0.75, 0.066666666666667, 0.083333333333333
19571, 0.79166666666667, 0.066666666666667, 0.083333333333333
19572, 0.83333333333333, 0.066666666666667, 0.083333333333333
19573, 0.875, 0.066666666666667, 0.083333333333333
19574, 0.91666666666667, 0.066666666666667, 0.083333333333333
19575, 0.95833333333333, 0.066666666666667, 0.083333333333333
19576, 0.041666666666667, 0.033333333333333, 0.125
19577, 0.083333333333333, 0.033333333333333, 0.125
19578, 0.125, 0.033333333333333, 0.125
19579, 0.16666666666667, 0.033333333333333, 0.125
19580, 0.20833333333333, 0.033333333333333, 0.125
19581, 0.25, 0.033333333333333, 0.125
19582, 0.29166666666667, 0.033333333333333, 0.125
19583, 0.33333333333333, 0.033333333333333, 0.125
19584, 0.375, 0.033333333333333, 0.125
19585, 0.41666666666667, 0.033333333333333, 0.125
19586, 0.45833333333333, 0.033333333333333, 0.125
19587, 0.5, 0.033333333333333, 0.125
19588, 0.54166666666667, 0.033333333333333, 0.125
19589, 0.58333333333333, 0.033333333333333, 0.125
19590, 0.625, 0.033333333333333, 0.125
19591, 0.66666666666667, 0.033333333333333, 0.125
19592, 0.70833333333333, 0.033333333333333, 0.125
19593, 0.75, 0.033333333333333, 0.125
19594, 0.79166666666667, 0.033333333333333, 0.125
19595, 0.83333333333333, 0.033333333333333, 0.125
19596, 0.875, 0.033333333333333, 0.125
19597, 0.91666666666667, 0.033333333333333, 0.125
19598, 0.95833333333333, 0.033333333333333, 0.125
19599, 0.041666666666667, 0.066666666666667, 0.125
19600, 0.083333333333333, 0.066666666666667, 0.125
19601, 0.125, 0.066666666666667, 0.125
19602, 0.16666666666667, 0.066666666666667, 0.125
19603, 0.20833333333333, 0.066666666666667, 0.125
19604, 0.25, 0.066666666666667, 0.125
19605, 0.29166666666667, 0.066666666666667, 0.125
19606, 0.33333333333333, 0.066666666666667, 0.125
19607, 0.375, 0.066666666666667, 0.125
19608, 0.41666666666667, 0.066666666666667, 0.125
19609, 0.45833333333333, 0.066666666666667, 0.125
19610, 0.5, 0.066666666666667, 0.125
19611, 0.54166666666667, 0.066666666666667, 0.125
19612, 0.58333333333333, 0.066666666666667, 0.125
19613, 0.625, 0.066666666666667, 0.125
19614, 0.66666666666667, 0.066666666666667, 0.125
19615, 0.70833333333333, 0.066666666666667, 0.125
19616, 0.75, 0.066666666666667, 0.125
19617, 0.79166666666667, 0.066666666666667, 0.125
19618, 0.83333333333333, 0.066666666666667, 0.125
19619, 0.875, 0.066666666666667, 0.125
19620, 0.91666666666667, 0.066666666666667, 0.125
19621, 0.95833333333333, 0.066666666666667, 0.125
19622, 0.041666666666667, 0.033333333333333, 0.16666666666667
19623, 0.083333333333333, 0.033333333333333, 0.16666666666667
19624, 0.125, 0.033333333333333, 0.16666666666667
19625, 0.16666666666667, 0.033333333333333, 0.16666666666667
19626, 0.20833333333333, 0.033333333333333, 0.16666666666667
19627, 0.25, 0.033333333333333, 0.16666666666667
19628, 0.29166666666667, 0.033333333333333, 0.16666666666667
19629, 0.33333333333333, 0.033333333333333, 0.16666666666667
19630, 0.375, 0.033333333333333, 0.16666666666667
19631, 0.41666666666667, 0.033333333333333, 0.16666666666667
19632, 0.45833333333333, 0.033333333333333, 0.16666666666667
19633, 0.5, 0.033333333333333, 0.16666666666667
19634, 0.54166666666667, 0.033333333333333, 0.16666666666667
19635, 0.58333333333333, 0.033333333333333, 0.16666666666667
19636, 0.625, 0.033333333333333, 0.16666666666667
19637, 0.66666666666667, 0.033333333333333, 0.16666666666667
19638, 0.70833333333333, 0.033333333333333, 0.16666666666667
19639, 0.75, 0.033333333333333, 0.16666666666667
19640, 0.79166666666667, 0.033333333333333, 0.16666666666667
19641, 0.83333333333333, 0.033333333333333, 0.16666666666667
19642, 0.875, 0.033333333333333, 0.16666666666667
19643, 0.91666666666667, 0.033333333333333, 0.16666666666667
19644, 0.95833333333333, 0.033333333333333, 0.16666666666667
19645, 0.041666666666667, 0.066666666666667, 0.16666666666667
19646, 0.083333333333333, 0.066666666666667, 0.16666666666667
19647, 0.125, 0.066666666666667, 0.16666666666667
19648, 0.16666666666667, 0.066666666666667, 0.16666666666667
19649, 0.20833333333333, 0.066666666666667, 0.16666666666667
19650, 0.25, 0.066666666666667, 0.16666666666667
19651, 0.29166666666667, 0.066666666666667, 0.16666666666667
19652, 0.33333333333333, 0.066666666666667, 0.16666666666667
19653, 0.375, 0.066666666666667, 0.16666666666667
19654, 0.41666666666667, 0.066666666666667, 0.16666666666667
19655, 0.45833333333333, 0.066666666666667, 0.16666666666667
19656, 0.5, 0.066666666666667, 0.16666666666667
19657, 0.54166666666667, 0.066666666666667, 0.16666666666667
19658, 0.58333333333333, 0.066666666666667, 0.16666666666667
19659, 0.625, 0.066666666666667, 0.16666666666667
19660, 0.66666666666667, 0.066666666666667, 0.16666666666667
19661, 0.70833333333333, 0.066666666666667, 0.16666666666667
19662, 0.75, 0.066666666666667, 0.16666666666667
19663, 0.79166666666667, 0.066666666666667, 0.16666666666667
19664, 0.83333333333333, 0.066666666666667, 0.16666666666667
19665, 0.875, 0.066666666666667, 0.16666666666667
19666, 0.91666666666667, 0.066666666666667, 0.16666666666667
19667, 0.95833333333333, 0.066666666666667, 0.16666666666667
19668, 0.041666666666667, 0.033333333333333, 0.20833333333333
19669, 0.083333333333333, 0.033333333333333, 0.20833333333333
19670, 0.125, 0.033333333333333, 0.20833333333333
19671, 0.16666666666667, 0.033333333333333, 0.20833333333333
19672, 0.20833333333333, 0.033333333333333, 0.20833333333333
19673, 0.25, 0.033333333333333, 0.20833333333333
19674, 0.29166666666667, 0.033333333333333, 0.20833333333333
19675, 0.33333333333333, 0.033333333333333, 0.20833333333333
19676, 0.375, 0.033333333333333, 0.20833333333333
19677, 0.41666666666667, 0.033333333333333, 0.20833333333333
19678, 0.45833333333333, 0.033333333333333, 0.20833333333333
19679, 0.5, 0.033333333333333, 0.20833333333333
19680, 0.54166666666667, 0.033333333333333, 0.20833333333333
19681, 0.58333333333333, 0.033333333333333, 0.20833333333333
19682, 0.625, 0.033333333333333, 0.20833333333333
19683, 0.66666666666667, 0.033333333333333, 0.20833333333333
19684, 0.70833333333333, 0.033333333333333, 0.20833333333333
19685, 0.75, 0.033333333333333, 0.20833333333333
19686, 0.79166666666667, 0.033333333333333, 0.20833333333333
19687, 0.83333333333333, 0.033333333333333, 0.20833333333333
19688, 0.875, 0.033333333333333, 0.20833333333333
19689, 0.91666666666667, 0.033333333333333, 0.20833333333333
19690, 0.95833333333333, 0.033333333333333, 0.20833333333333
19691, 0.041666666666667, 0.066666666666667, 0.20833333333333
19692, 0.083333333333333, 0.066666666666667, 0.20833333333333
19693, 0.125, 0.066666666666667, 0.20833333333333
19694, 0.16666666666667, 0.066666666666667, 0.20833333333333
19695, 0.20833333333333, 0.066666666666667, 0.20833333333333
19696, 0.25, 0.066666666666667, 0.20833333333333
19697, 0.29166666666667, 0.066666666666667, 0.20833333333333
19698, 0.33333333333333, 0.066666666666667, 0.20833333333333
19699, 0.375, 0.066666666666667, 0.20833333333333
19700, 0.41666666666667, 0.066666666666667, 0.20833333333333
19701, 0.45833333333333, 0.066666666666667, 0.20833333333333
19702, 0.5, 0.066666666666667, 0.20833333333333
19703, 0.54166666666667, 0.066666666666667, 0.20833333333333
19704, 0.58333333333333, 0.066666666666667, 0.20833333333333
19705, 0.625, 0.066666666666667, 0.20833333333333
19706, 0.66666666666667, 0.066666666666667, 0.20833333333333
19707, 0.70833333333333, 0.066666666666667, 0.20833333333333
19708, 0.75, 0.066666666666667, 0.20833333333333
19709, 0.79166666666667, 0.066666666666667, 0.20833333333333
19710, 0.83333333333333, 0.066666666666667, 0.20833333333333
19711, 0.875, 0.066666666666667, 0.20833333333333
19712, 0.91666666666667, 0.066666666666667, 0.20833333333333
19713, 0.95833333333333, 0.066666666666667, 0.20833333333333
19714, 0.041666666666667, 0.033333333333333, 0.25
19715, 0.083333333333333, 0.033333333333333, 0.25
19716, 0.125, 0.033333333333333, 0.25
19717, 0.16666666666667, 0.033333333333333, 0.25
19718, 0.20833333333333, 0.033333333333333, 0.25
19719, 0.25, 0.033333333333333, 0.25
19720, 0.29166666666667, 0.033333333333333, 0.25
19721, 0.33333333333333, 0.033333333333333, 0.25
19722, 0.375, 0.033333333333333, 0.25
19723, 0.41666666666667, 0.033333333333333, 0.25
19724, 0.45833333333333, 0.033333333333333, 0.25
19725, 0.5, 0.033333333333333, 0.25
19726, 0.54166666666667, 0.033333333333333, 0.25
19727, 0.58333333333333, 0.033333333333333, 0.25
19728, 0.625, 0.033333333333333, 0.25
19729, 0.66666666666667, 0.033333333333333, 0.25
19730, 0.70833333333333, 0.033333333333333, 0.25
19731, 0.75, 0.033333333333333, 0.25
19732, 0.79166666666667, 0.033333333333333, 0.25
19733, 0.83333333333333, 0.033333333333333, 0.25
19734, 0.875, 0.033333333333333, 0.25
19735, 0.91666666666667, 0.033333333333333, 0.25
19736, 0.95833333333333, 0.033333333333333, 0.25
19737, 0.041666666666667, 0.066666666666667, 0.25
19738, 0.083333333333333, 0.066666666666667, 0.25
19739, 0.125, 0.066666666666667, 0.25
19740, 0.16666666666667, 0.066666666666667, 0.25
19741, 0.20833333333333, 0.066666666666667, 0.25
19742, 0.25, 0.066666666666667, 0.25
19743, 0.29166666666667, 0.066666666666667, 0.25
19744, 0.33333333333333, 0.066666666666667, 0.25
19745, 0.375, 0.066666666666667, 0.25
19746, 0.41666666666667, 0.066666666666667, 0.25
19747, 0.45833333333333, 0.066666666666667, 0.25
19748, 0.5, 0.066666666666667, 0.25
19749, 0.54166666666667, 0.066666666666667, 0.25
19750, 0.58333333333333, 0.066666666666667, 0.25
19751, 0.625, 0.066666666666667, 0.25
19752, 0.66666666666667, 0.066666666666667, 0.25
19753, 0.70833333333333, 0.066666666666667, 0.25
19754, 0.75, 0.066666666666667, 0.25
19755, 0.79166666666667, 0.066666666666667, 0.25
19756, 0.83333333333333, 0.066666666666667, 0.25
19757, 0.875, 0.066666666666667, 0.25
19758, 0.91666666666667, 0.066666666666667, 0.25
19759, 0.95833333333333, 0.066666666666667, 0.25
19760, 0.041666666666667, 0.033333333333333, 0.29166666666667
19761, 0.083333333333333, 0.033333333333333, 0.29166666666667
19762, 0.125, 0.033333333333333, 0.29166666666667
19763, 0.16666666666667, 0.033333333333333, 0.29166666666667
19764, 0.20833333333333, 0.033333333333333, 0.29166666666667
19765, 0.25, 0.033333333333333, 0.29166666666667
19766, 0.29166666666667, 0.033333333333333, 0.29166666666667
19767, 0.33333333333333, 0.033333333333333, 0.29166666666667
19768, 0.375, 0.033333333333333, 0.29166666666667
19769, 0.41666666666667, 0.033333333333333, 0.29166666666667
19770, 0.45833333333333, 0.033333333333333, 0.29166666666667
19771, 0.5, 0.033333333333333, 0.29166666666667
19772, 0.54166666666667, 0.033333333333333, 0.29166666666667
19773, 0.58333333333333, 0.033333333333333, 0.29166666666667
19774, 0.625, 0.033333333333333, 0.29166666666667
19775, 0.66666666666667, 0.033333333333333, 0.29166666666667
19776, 0.70833333333333, 0.033333333333333, 0.29166666666667
19777, 0.75, 0.033333333333333, 0.29166666666667
19778, 0.79166666666667, 0.033333333333333, 0.29166666666667
19779, 0.83333333333333, 0.033333333333333, 0.29166666666667
19780, 0.875, 0.033333333333333, 0.29166666666667
19781, 0.91666666666667, 0.033333333333333, 0.29166666666667
19782, 0.95833333333333, 0.033333333333333, 0.29166666666667
19783, 0.041666666666667, 0.066666666666667, 0.29166666666667
19784, 0.083333333333333, 0.066666666666667, 0.29166666666667
19785, 0.125, 0.066666666666667, 0.29166666666667
19786, 0.16666666666667, 0.066666666666667, 0.29166666666667
19787, 0.20833333333333, 0.066666666666667, 0.29166666666667
19788, 0.25, 0.066666666666667, 0.29166666666667
19789, 0.29166666666667, 0.066666666666667, 0.29166666666667
19790, 0.33333333333333, 0.066666666666667, 0.29166666666667
19791, 0.375, 0.066666666666667, 0.29166666666667
19792, 0.41666666666667, 0.066666666666667, 0.29166666666667
19793, 0.45833333333333, 0.066666666666667, 0.29166666666667
19794, 0.5, 0.066666666666667, 0.29166666666667
19795, 0.54166666666667, 0.066666666666667, 0.29166666666667
19796, 0.58333333333333, 0.066666666666667, 0.29166666666667
19797, 0.625, 0.066666666666667, 0.29166666666667
19798, 0.66666666666667, 0.066666666666667, 0.29166666666667
19799, 0.70833333333333, 0.066666666666667, 0.29166666666667
19800, 0.75, 0.066666666666667, 0.29166666666667
19801, 0.79166666666667, 0.066666666666667, 0.29166666666667
19802, 0.83333333333333, 0.066666666666667, 0.29166666666667
19803, 0.875, 0.066666666666667, 0.29166666666667
19804, 0.91666666666667, 0.066666666666667, 0.29166666666667
19805, 0.95833333333333, 0.066666666666667, 0.29166666666667
19806, 0.041666666666667, 0.033333333333333, 0.33333333333333
19807, 0.083333333333333, 0.033333333333333, 0.33333333333333
19808, 0.125, 0.033333333333333, 0.33333333333333
19809, 0.16666666666667, 0.033333333333333, 0.33333333333333
19810, 0.20833333333333, 0.033333333333333, 0.33333333333333
19811, 0.25, 0.033333333333333, 0.33333333333333
19812, 0.29166666666667, 0.033333333333333, 0.33333333333333
19813, 0.33333333333333, 0.033333333333333, 0.33333333333333
19814, 0.375, 0.033333333333333, 0.33333333333333
19815, 0.41666666666667, 0.033333333333333, 0.33333333333333
19816, 0.45833333333333, 0.033333333333333, 0.33333333333333
19817, 0.5, 0.033333333333333, 0.33333333333333
19818, 0.54166666666667, 0.033333333333333, 0.33333333333333
19819, 0.58333333333333, 0.033333333333333, 0.33333333333333
19820, 0.625, 0.033333333333333, 0.33333333333333
19821, 0.66666666666667, 0.033333333333333, 0.33333333333333
19822, 0.70833333333333, 0.033333333333333, 0.33333333333333
19823, 0.75, 0.033333333333333, 0.33333333333333
19824, 0.79166666666667, 0.033333333333333, 0.33333333333333
19825, 0.83333333333333, 0.033333333333333, 0.33333333333333
19826, 0.875, 0.033333333333333, 0.33333333333333
19827, 0.91666666666667, 0.033333333333333, 0.33333333333333
19828, 0.95833333333333, 0.033333333333333, 0.33333333333333
19829, 0.041666666666667, 0.066666666666667, 0.33333333333333
19830, 0.083333333333333, 0.066666666666667, 0.33333333333333
19831, 0.125, 0.066666666666667, 0.33333333333333
19832, 0.16666666666667, 0.066666666666667, 0.33333333333333
19833, 0.20833333333333, 0.066666666666667, 0.33333333333333
19834, 0.25, 0.066666666666667, 0.33333333333333
19835, 0.29166666666667, 0.066666666666667, 0.33333333333333
19836, 0.33333333333333, 0.066666666666667, 0.33333333333333
19837, 0.375, 0.066666666666667, 0.33333333333333
19838, 0.41666666666667, 0.066666666666667, 0.33333333333333
19839, 0.45833333333333, 0.066666666666667, 0.33333333333333
19840, 0.5, 0.066666666666667, 0.33333333333333
19841, 0.54166666666667, 0.066666666666667, 0.33333333333333
19842, 0.58333333333333, 0.066666666666667, 0.33333333333333
19843, 0.625, 0.066666666666667, 0.33333333333333
19844, 0.66666666666667, 0.066666666666667, 0.33333333333333
19845, 0.70833333333333, 0.066666666666667, 0.33333333333333
19846, 0.75, 0.066666666666667, 0.33333333333333
19847, 0.79166666666667, 0.066666666666667, 0.33333333333333
19848, 0.83333333333333, 0.066666666666667, 0.33333333333333
19849, 0.875, 0.066666666666667, 0.33333333333333
19850, 0.91666666666667, 0.066666666666667, 0.33333333333333
19851, 0.95833333333333, 0.066666666666667, 0.33333333333333
19852, 0.041666666666667, 0.033333333333333, 0.375
19853, 0.083333333333333, 0.033333333333333, 0.375
19854, 0.125, 0.033333333333333, 0.375
19855, 0.16666666666667, 0.033333333333333, 0.375
19856, 0.20833333333333, 0.033333333333333, 0.375
19857, 0.25, 0.033333333333333, 0.375
19858, 0.29166666666667, 0.033333333333333, 0.375
19859, 0.33333333333333, 0.033333333333333, 0.375
19860, 0.375, 0.033333333333333, 0.375
19861, 0.41666666666667, 0.033333333333333, 0.375
19862, 0.45833333333333, 0.033333333333333, 0.375
19863, 0.5, 0.033333333333333, 0.375
19864, 0.54166666666667, 0.033333333333333, 0.375
19865, 0.58333333333333, 0.033333333333333, 0.375
19866, 0.625, 0.033333333333333, 0.375
19867, 0.66666666666667, 0.033333333333333, 0.375
19868, 0.70833333333333, 0.033333333333333, 0.375
19869, 0.75, 0.033333333333333, 0.375
19870, 0.79166666666667, 0.033333333333333, 0.375
19871, 0.83333333333333, 0.033333333333333, 0.375
19872, 0.875, 0.033333333333333, 0.375
19873, 0.91666666666667, 0.033333333333333, 0.375
19874, 0.95833333333333, 0.033333333333333, 0.375
19875, 0.041666666666667, 0.066666666666667, 0.375
19876, 0.083333333333333, 0.066666666666667, 0.375
19877, 0.125, 0.066666666666667, 0.375
19878, 0.16666666666667, 0.066666666666667, 0.375
19879, 0.20833333333333, 0.066666666666667, 0.375
19880, 0.25, 0.066666666666667, 0.375
19881, 0.29166666666667, 0.066666666666667, 0.375
19882, 0.33333333333333, 0.066666666666667, 0.375
19883, 0.375, 0.066666666666667, 0.375
19884, 0.41666666666667, 0.066666666666667, 0.375
19885, 0.45833333333333, 0.066666666666667, 0.375
19886, 0.5, 0.066666666666667, 0.375
19887, 0.54166666666667, 0.066666666666667, 0.375
19888, 0.58333333333333, 0.066666666666667, 0.375
19889, 0.625, 0.066666666666667, 0.375
19890, 0.66666666666667, 0.066666666666667, 0.375
19891, 0.70833333333333, 0.066666666666667, 0.375
19892, 0.75, 0.066666666666667, 0.375
19893, 0.79166666666667, 0.066666666666667, 0.375
19894, 0.83333333333333, 0.066666666666667, 0.375
19895, 0.875, 0.066666666666667, 0.375
19896, 0.91666666666667, 0.066666666666667, 0.375
19897, 0.95833333333333, 0.066666666666667, 0.375
19898, 0.041666666666667, 0.033333333333333, 0.41666666666667
19899, 0.083333333333333, 0.033333333333333, 0.41666666666667
19900, 0.125, 0.033333333333333, 0.41666666666667
19901, 0.16666666666667, 0.033333333333333, 0.41666666666667
19902, 0.20833333333333, 0.033333333333333, 0.41666666666667
19903, 0.25, 0.033333333333333, 0.41666666666667
19904, 0.29166666666667, 0.033333333333333, 0.41666666666667
19905, 0.33333333333333, 0.033333333333333, 0.41666666666667
19906, 0.375, 0.033333333333333, 0.41666666666667
19907, 0.41666666666667, 0.033333333333333, 0.41666666666667
19908, 0.45833333333333, 0.033333333333333, 0.41666666666667
19909, 0.5, 0.033333333333333, 0.41666666666667
19910, 0.54166666666667, 0.033333333333333, 0.41666666666667
19911, 0.58333333333333, 0.033333333333333, 0.41666666666667
19912, 0.625, 0.033333333333333, 0.41666666666667
19913, 0.66666666666667, 0.033333333333333, 0.41666666666667
19914, 0.70833333333333, 0.033333333333333, 0.41666666666667
19915, 0.75, 0.033333333333333, 0.41666666666667
19916, 0.79166666666667, 0.033333333333333, 0.41666666666667
19917, 0.83333333333333, 0.033333333333333, 0.41666666666667
19918, 0.875, 0.033333333333333, 0.41666666666667
19919, 0.91666666666667, 0.033333333333333, 0.41666666666667
19920, 0.95833333333333, 0.033333333333333, 0.41666666666667
19921, 0.041666666666667, 0.066666666666667, 0.41666666666667
19922, 0.083333333333333, 0.066666666666667, 0.41666666666667
19923, 0.125, 0.066666666666667, 0.41666666666667
19924, 0.16666666666667, 0.066666666666667, 0.41666666666667
19925, 0.20833333333333, 0.066666666666667, 0.41666666666667
19926, 0.25, 0.066666666666667, 0.41666666666667
19927, 0.29166666666667, 0.066666666666667, 0.41666666666667
19928, 0.33333333333333, 0.066666666666667, 0.41666666666667
19929, 0.375, 0.066666666666667, 0.41666666666667
19930, 0.41666666666667, 0.066666666666667, 0.41666666666667
19931, 0.45833333333333, 0.066666666666667, 0.41666666666667
19932, 0.5, 0.066666666666667, 0.41666666666667
19933, 0.54166666666667, 0.066666666666667, 0.41666666666667
19934, 0.58333333333333, 0.066666666666667, 0.41666666666667
19935, 0.625, 0.066666666666667, 0.41666666666667
19936, 0.66666666666667, 0.066666666666667, 0.41666666666667
19937, 0.70833333333333, 0.066666666666667, 0.41666666666667
19938, 0.75, 0.066666666666667, 0.41666666666667
19939, 0.79166666666667, 0.066666666666667, 0.41666666666667
19940, 0.83333333333333, 0.066666666666667, 0.41666666666667
19941, 0.875, 0.066666666666667, 0.41666666666667
19942, 0.91666666666667, 0.066666666666667, 0.41666666666667
19943, 0.95833333333333, 0.066666666666667, 0.41666666666667
19944, 0.041666666666667, 0.033333333333333, 0.45833333333333
19945, 0.083333333333333, 0.033333333333333, 0.45833333333333
19946, 0.125, 0.033333333333333, 0.45833333333333
19947, 0.16666666666667, 0.033333333333333, 0.45833333333333
19948, 0.20833333333333, 0.033333333333333, 0.45833333333333
19949, 0.25, 0.033333333333333, 0.45833333333333
19950, 0.29166666666667, 0.033333333333333, 0.45833333333333
19951, 0.33333333333333, 0.033333333333333, 0.45833333333333
19952, 0.375, 0.033333333333333, 0.45833333333333
19953, 0.41666666666667, 0.033333333333333, 0.45833333333333
19954, 0.45833333333333, 0.033333333333333, 0.45833333333333
19955, 0.5, 0.033333333333333, 0.45833333333333
19956, 0.54166666666667, 0.033333333333333, 0.45833333333333
19957, 0.58333333333333, 0.033333333333333, 0.45833333333333
19958, 0.625, 0.033333333333333, 0.45833333333333
19959, 0.66666666666667, 0.033333333333333, 0.45833333333333
19960, 0.70833333333333, 0.033333333333333, 0.45833333333333
19961, 0.75, 0.033333333333333, 0.45833333333333
19962, 0.79166666666667, 0.033333333333333, 0.45833333333333
19963, 0.83333333333333, 0.033333333333333, 0.45833333333333
19964, 0.875, 0.033333333333333, 0.45833333333333
19965, 0.91666666666667, 0.033333333333333, 0.45833333333333
19966, 0.95833333333333, 0.033333333333333, 0.45833333333333
19967, 0.041666666666667, 0.066666666666667, 0.45833333333333
19968, 0.083333333333333, 0.066666666666667, 0.45833333333333
19969, 0.125, 0.066666666666667, 0.45833333333333
19970, 0.16666666666667, 0.066666666666667, 0.45833333333333
19971, 0.20833333333333, 0.066666666666667, 0.45833333333333
19972, 0.25, 0.066666666666667, 0.45833333333333
19973, 0.29166666666667, 0.066666666666667, 0.45833333333333
19974, 0.33333333333333, 0.066666666666667, 0.45833333333333
19975, 0.375, 0.066666666666667, 0.45833333333333
19976, 0.41666666666667, 0.066666666666667, 0.45833333333333
19977, 0.45833333333333, 0.066666666666667, 0.45833333333333
19978, 0.5, 0.066666666666667, 0.45833333333333
19979, 0.54166666666667, 0.066666666666667, 0.45833333333333
19980, 0.58333333333333, 0.066666666666667, 0.45833333333333
19981, 0.625, 0.066666666666667, 0.45833333333333
19982, 0.66666666666667, 0.066666666666667, 0.45833333333333
19983, 0.70833333333333, 0.066666666666667, 0.45833333333333
19984, 0.75, 0.066666666666667, 0.45833333333333
19985, 0.79166666666667, 0.066666666666667, 0.45833333333333
19986, 0.83333333333333, 0.066666666666667, 0.45833333333333
19987, 0.875, 0.066666666666667, 0.45833333333333
19988, 0.91666666666667, 0.066666666666667, 0.45833333333333
19989, 0.95833333333333, 0.066666666666667, 0.45833333333333
19990, 0.041666666666667, 0.2, 0.041666666666667
19991, 0.041666666666667, 0.25, 0.041666666666667
19992, 0.041666666666667, 0.3, 0.041666666666667
19993, 0.041666666666667, 0.35, 0.041666666666667
19994, 0.041666666666667, 0.4, 0.041666666666667
19995, 0.041666666666667, 0.45, 0.041666666666667
19996, 0.041666666666667, 0.5, 0.041666666666667
19997, 0.041666666666667, 0.55, 0.041666666666667
19998, 0.041666666666667, 0.6, 0.041666666666667
19999, 0.041666666666667, 0.65, 0.041666666666667
20000, 0.041666666666667, 0.7, 0.041666666666667
20001, 0.041666666666667, 0.75, 0.041666666666667
20002, 0.041666666666667, 0.8, 0.041666666666667
20003, 0.041666666666667, 0.85, 0.041666666666667
20004, 0.041666666666667, 0.9, 0.041666666666667
20005, 0.041666666666667, 0.95, 0.041666666666667
20006, 0.041666666666667, 1, 0.041666666666667
20007, 0.041666666666667, 1.05, 0.041666666666667
20008, 0.041666666666667, 1.1, 0.041666666666667
20009, 0.041666666666667, 1.15, 0.041666666666667
20010, 0.041666666666667, 1.2, 0.041666666666667
20011, 0.041666666666667, 1.25, 0.041666666666667
20012, 0.041666666666667, 1.3, 0.041666666666667
20013, 0.041666666666667, 0.2, 0.083333333333333
20014, 0.041666666666667, 0.25, 0.083333333333333
20015, 0.041666666666667, 0.3, 0.083333333333333
20016, 0.041666666666667, 0.35, 0.083333333333333
20017, 0.041666666666667, 0.4, 0.083333333333333
20018, 0.041666666666667, 0.45, 0.083333333333333
20019, 0.041666666666667, 0.5, 0.083333333333333
20020, 0.041666666666667, 0.55, 0.083333333333333
20021, 0.041666666666667, 0.6, 0.083333333333333
20022, 0.041666666666667, 0.65, 0.083333333333333
20023, 0.041666666666667, 0.7, 0.083333333333333
20024, 0.041666666666667, 0.75, 0.083333333333333
20025, 0.041666666666667, 0.8, 0.083333333333333
20026, 0.041666666666667, 0.85, 0.083333333333333
20027, 0.041666666666667, 0.9, 0.083333333333333
20028, 0.041666666666667, 0.95, 0.083333333333333
20029, 0.041666666666667, 1, 0.083333333333333
20030, 0.041666666666667, 1.05, 0.083333333333333
20031, 0.041666666666667, 1.1, 0.083333333333333
20032, 0.041666666666667, 1.15, 0.083333333333333
20033, 0.041666666666667, 1.2, 0.083333333333333
20034, 0.041666666666667, 1.25, 0.083333333333333
20035, 0.041666666666667, 1.3, 0.083333333333333
20036, 0.041666666666667, 0.2, 0.125
20037, 0.041666666666667, 0.25, 0.125
20038, 0.041666666666667, 0.3, 0.125
20039, 0.041666666666667, 0.35, 0.125
20040, 0.041666666666667, 0.4, 0.125
20041, 0.041666666666667, 0.45, 0.125
20042, 0.041666666666667, 0.5, 0.125
20043, 0.041666666666667, 0.55, 0.125
20044, 0.041666666666667, 0.6, 0.125
20045, 0.041666666666667, 0.65, 0.125
20046, 0.041666666666667, 0.7, 0.125
20047, 0.041666666666667, 0.75, 0.125
20048, 0.041666666666667, 0.8, 0.125
20049, 0.041666666666667, 0.85, 0.125
20050, 0.041666666666667, 0.9, 0.125
20051, 0.041666666666667, 0.95, 0.125
20052, 0.041666666666667, 1, 0.125
20053, 0.041666666666667, 1.05, 0.125
20054, 0.041666666666667, 1.1, 0.125
20055, 0.041666666666667, 1.15, 0.125
20056, 0.041666666666667, 1.2, 0.125
20057, 0.041666666666667, 1.25, 0.125
20058, 0.041666666666667, 1.3, 0.125
20059, 0.041666666666667, 0.2, 0.16666666666667
20060, 0.041666666666667, 0.25, 0.16666666666667
20061, 0.041666666666667, 0.3, 0.16666666666667
20062, 0.041666666666667, 0.35, 0.16666666666667
20063, 0.041666666666667, 0.4, 0.16666666666667
20064, 0.041666666666667, 0.45, 0.16666666666667
20065, 0.041666666666667, 0.5, 0.16666666666667
20066, 0.041666666666667, 0.55, 0.16666666666667
20067, 0.041666666666667, 0.6, 0.16666666666667
20068, 0.041666666666667, 0.65, 0.16666666666667
20069, 0.041666666666667, 0.7, 0.16666666666667
20070, 0.041666666666667, 0.75, 0.16666666666667
20071, 0.041666666666667, 0.8, 0.16666666666667
20072, 0.041666666666667, 0.85, 0.16666666666667
20073, 0.041666666666667, 0.9, 0.16666666666667
20074, 0.041666666666667, 0.95, 0.16666666666667
20075, 0.041666666666667, 1, 0.16666666666667
20076, 0.041666666666667, 1.05, 0.16666666666667
20077, 0.041666666666667, 1.1, 0.16666666666667
20078, 0.041666666666667, 1.15, 0.16666666666667
20079, 0.041666666666667, 1.2, 0.16666666666667
20080, 0.041666666666667, 1.25, 0.16666666666667
20081, 0.041666666666667, 1.3, 0.16666666666667
20082, 0.041666666666667, 0.2, 0.20833333333333
20083, 0.041666666666667, 0.25, 0.20833333333333
20084, 0.041666666666667, 0.3, 0.20833333333333
20085, 0.041666666666667, 0.35, 0.20833333333333
20086, 0.041666666666667, 0.4, 0.20833333333333
20087, 0.041666666666667, 0.45, 0.20833333333333
20088, 0.041666666666667, 0.5, 0.20833333333333
20089, 0.041666666666667, 0.55, 0.20833333333333
20090, 0.041666666666667, 0.6, 0.20833333333333
20091, 0.041666666666667, 0.65, 0.20833333333333
20092, 0.041666666666667, 0.7, 0.20833333333333
20093, 0.041666666666667, 0.75, 0.20833333333333
20094, 0.041666666666667, 0.8, 0.20833333333333
20095, 0.041666666666667, 0.85, 0.20833333333333
20096, 0.041666666666667, 0.9, 0.20833333333333
20097, 0.041666666666667, 0.95, 0.20833333333333
20098, 0.041666666666667, 1, 0.20833333333333
20099, 0.041666666666667, 1.05, 0.20833333333333
20100, 0.041666666666667, 1.1, 0.20833333333333
20101, 0.041666666666667, 1.15, 0.20833333333333
20102, 0.041666666666667, 1.2, 0.20833333333333
20103, 0.041666666666667, 1.25, 0.20833333333333
20104, 0.041666666666667, 1.3, 0.20833333333333
20105, 0.041666666666667, 0.2, 0.25
20106, 0.041666666666667, 0.25, 0.25
20107, 0.041666666666667, 0.3, 0.25
20108, 0.041666666666667, 0.35, 0.25
20109, 0.041666666666667, 0.4, 0.25
20110, 0.041666666666667, 0.45, 0.25
20111, 0.041666666666667, 0.5, 0.25
20112, 0.041666666666667, 0.55, 0.25
20113, 0.041666666666667, 0.6, 0.25
20114, 0.041666666666667, 0.65, 0.25
20115, 0.041666666666667, 0.7, 0.25
20116, 0.041666666666667, 0.75, 0.25
20117, 0.041666666666667, 0.8, 0.25
20118, 0.041666666666667, 0.85, 0.25
20119, 0.041666666666667, 0.9, 0.25
20120, 0.041666666666667, 0.95, 0.25
20121, 0.041666666666667, 1, 0.25
20122, 0.041666666666667, 1.05, 0.25
20123, 0.041666666666667, 1.1, 0.25
20124, 0.041666666666667, 1.15, 0.25
20125, 0.041666666666667, 1.2, 0.25
20126, 0.041666666666667, 1.25, 0.25
20127, 0.041666666666667, 1.3, 0.25
20128, 0.041666666666667, 0.2, 0.29166666666667
20129, 0.041666666666667, 0.25, 0.29166666666667
20130, 0.041666666666667, 0.3, 0.29166666666667
20131, 0.041666666666667, 0.35, 0.29166666666667
20132, 0.041666666666667, 0.4, 0.29166666666667
20133, 0.041666666666667, 0.45, 0.29166666666667
20134, 0.041666666666667, 0.5, 0.29166666666667
20135, 0.041666666666667, 0.55, 0.29166666666667
20136, 0.041666666666667, 0.6, 0.29166666666667
20137, 0.041666666666667, 0.65, 0.29166666666667
20138, 0.041666666666667, 0.7, 0.29166666666667
20139, 0.041666666666667, 0.75, 0.29166666666667
20140, 0.041666666666667, 0.8, 0.29166666666667
20141, 0.041666666666667, 0.85, 0.29166666666667
20142, 0.041666666666667, 0.9, 0.29166666666667
20143, 0.041666666666667, 0.95, 0.29166666666667
20144, 0.041666666666667, 1, 0.29166666666667
20145, 0.041666666666667, 1.05, 0.29166666666667
20146, 0.041666666666667, 1.1, 0.29166666666667
20147, 0.041666666666667, 1.15, 0.29166666666667
20148, 0.041666666666667, 1.2, 0.29166666666667
20149, 0.041666666666667, 1.25, 0.29166666666667
20150, 0.041666666666667, 1.3, 0.29166666666667
20151, 0.041666666666667, 0.2, 0.33333333333333
20152, 0.041666666666667, 0.25, 0.33333333333333
20153, 0.041666666666667, 0.3, 0.33333333333333
20154, 0.041666666666667, 0.35, 0.33333333333333
20155, 0.041666666666667, 0.4, 0.33333333333333
20156, 0.041666666666667, 0.45, 0.33333333333333
20157, 0.041666666666667, 0.5, 0.33333333333333
20158, 0.041666666666667, 0.55, 0.33333333333333
20159, 0.041666666666667, 0.6, 0.33333333333333
20160, 0.041666666666667, 0.65, 0.33333333333333
20161, 0.041666666666667, 0.7, 0.33333333333333
20162, 0.041666666666667, 0.75, 0.33333333333333
20163, 0.041666666666667, 0.8, 0.33333333333333
20164, 0.041666666666667, 0.85, 0.33333333333333
20165, 0.041666666666667, 0.9, 0.33333333333333
20166, 0.041666666666667, 0.95, 0.33333333333333
20167, 0.041666666666667, 1, 0.33333333333333
20168, 0.041666666666667, 1.05, 0.33333333333333
20169, 0.041666666666667, 1.1, 0.33333333333333
20170, 0.041666666666667, 1.15, 0.33333333333333
20171, 0.041666666666667, 1.2, 0.33333333333333
20172, 0.041666666666667, 1.25, 0.33333333333333
20173, 0.041666666666667, 1.3, 0.33333333333333
20174, 0.041666666666667, 0.2, 0.375
20175, 0.041666666666667, 0.25, 0.375
20176, 0.041666666666667, 0.3, 0.375
20177, 0.041666666666667, 0.35, 0.375
20178, 0.041666666666667, 0.4, 0.375
20179, 0.041666666666667, 0.45, 0.375
20180, 0.041666666666667, 0.5, 0.375
20181, 0.041666666666667, 0.55, 0.375
20182, 0.041666666666667, 0.6, 0.375
20183, 0.041666666666667, 0.65, 0.375
20184, 0.041666666666667, 0.7, 0.375
20185, 0.041666666666667, 0.75, 0.375
20186, 0.041666666666667, 0.8, 0.375
20187, 0.041666666666667, 0.85, 0.375
20188, 0.041666666666667, 0.9, 0.375
20189, 0.041666666666667, 0.95, 0.375
20190, 0.041666666666667, 1, 0.375
20191, 0.041666666666667, 1.05, 0.375
20192, 0.041666666666667, 1.1, 0.375
20193, 0.041666666666667, 1.15, 0.375
20194, 0.041666666666667, 1.2, 0.375
20195, 0.041666666666667, 1.25, 0.375
20196, 0.041666666666667, 1.3, 0.375
20197, 0.041666666666667, 0.2, 0.41666666666667
20198, 0.041666666666667, 0.25, 0.41666666666667
20199, 0.041666666666667, 0.3, 0.41666666666667
20200, 0.041666666666667, 0.35, 0.41666666666667
20201, 0.041666666666667, 0.4, 0.41666666666667
20202, 0.041666666666667, 0.45, 0.41666666666667
20203, 0.041666666666667, 0.5, 0.41666666666667
20204, 0.041666666666667, 0.55, 0.41666666666667
20205, 0.041666666666667, 0.6, 0.41666666666667
20206, 0.041666666666667, 0.65, 0.41666666666667
20207, 0.041666666666667, 0.7, 0.41666666666667
20208, 0.041666666666667, 0.75, 0.41666666666667
20209, 0.041666666666667, 0.8, 0.41666666666667
20210, 0.041666666666667, 0.85, 0.41666666666667
20211, 0.041666666666667, 0.9, 0.41666666666667
20212, 0.041666666666667, 0.95, 0.41666666666667
20213, 0.041666666666667, 1, 0.41666666666667
20214, 0.041666666666667, 1.05, 0.41666666666667
20215, 0.041666666666667, 1.1, 0.41666666666667
20216, 0.041666666666667, 1.15, 0.41666666666667
20217, 0.041666666666667, 1.2, 0.41666666666667
20218, 0.041666666666667, 1.25, 0.41666666666667
20219, 0.041666666666667, 1.3, 0.41666666666667
20220, 0.041666666666667, 0.2, 0.45833333333333
20221, 0.041666666666667, 0.25, 0.45833333333333
20222, 0.041666666666667, 0.3, 0.45833333333333
20223, 0.041666666666667, 0.35, 0.45833333333333
20224, 0.041666666666667, 0.4, 0.45833333333333
20225, 0.041666666666667, 0.45, 0.45833333333333
20226, 0.041666666666667, 0.5, 0.45833333333333
20227, 0.041666666666667, 0.55, 0.45833333333333
20228, 0.041666666666667, 0.6, 0.45833333333333
20229, 0.041666666666667, 0.65, 0.45833333333333
20230, 0.041666666666667, 0.7, 0.45833333333333
20231, 0.041666666666667, 0.75, 0.45833333333333
20232, 0.041666666666667, 0.8, 0.45833333333333
20233, 0.041666666666667, 0.85, 0.45833333333333
20234, 0.041666666666667, 0.9, 0.45833333333333
20235, 0.041666666666667, 0.95, 0.45833333333333
20236, 0.041666666666667, 1, 0.45833333333333
20237, 0.041666666666667, 1.05, 0.45833333333333
20238, 0.041666666666667, 1.1, 0.45833333333333
20239, 0.041666666666667, 1.15, 0.45833333333333
20240, 0.041666666666667, 1.2, 0.45833333333333
20241, 0.041666666666667, 1.25, 0.45833333333333
20242, 0.041666666666667, 1.3, 0.45833333333333
20243, 0.083333333333333, 0.2, 0.041666666666667
20244, 0.083333333333333, 0.25, 0.041666666666667
20245, 0.083333333333333, 0.3, 0.041666666666667
20246, 0.083333333333333, 0.35, 0.041666666666667
20247, 0.083333333333333, 0.4, 0.041666666666667
20248, 0.083333333333333, 0.45, 0.041666666666667
20249, 0.083333333333333, 0.5, 0.041666666666667
20250, 0.083333333333333, 0.55, 0.041666666666667
20251, 0.083333333333333, 0.6, 0.041666666666667
20252, 0.083333333333333, 0.65, 0.041666666666667
20253, 0.083333333333333, 0.7, 0.041666666666667
20254, 0.083333333333333, 0.75, 0.041666666666667
20255, 0.083333333333333, 0.8, 0.041666666666667
20256, 0.083333333333333, 0.85, 0.041666666666667
20257, 0.083333333333333, 0.9, 0.041666666666667
20258, 0.083333333333333, 0.95, 0.041666666666667
20259, 0.083333333333333, 1, 0.041666666666667
20260, 0.083333333333333, 1.05, 0.041666666666667
20261, 0.083333333333333, 1.1, 0.041666666666667
20262, 0.083333333333333, 1.15, 0.041666666666667
20263, 0.083333333333333, 1.2, 0.041666666666667
20264, 0.083333333333333, 1.25, 0.041666666666667
20265, 0.083333333333333, 1.3, 0.041666666666667
20266, 0.083333333333333, 0.2, 0.083333333333333
20267, 0.083333333333333, 0.25, 0.083333333333333
20268, 0.083333333333333, 0.3, 0.083333333333333
20269, 0.083333333333333, 0.35, 0.083333333333333
20270, 0.083333333333333, 0.4, 0.083333333333333
20271, 0.083333333333333, 0.45, 0.083333333333333
20272, 0.083333333333333, 0.5, 0.083333333333333
20273, 0.083333333333333, 0.55, 0.083333333333333
20274, 0.083333333333333, 0.6, 0.083333333333333
20275, 0.083333333333333, 0.65, 0.083333333333333
20276, 0.083333333333333, 0.7, 0.083333333333333
20277, 0.083333333333333, 0.75, 0.083333333333333
20278, 0.083333333333333, 0.8, 0.083333333333333
20279, 0.083333333333333, 0.85, 0.083333333333333
20280, 0.083333333333333, 0.9, 0.083333333333333
20281, 0.083333333333333, 0.95, 0.083333333333333
20282, 0.083333333333333, 1, 0.083333333333333
20283, 0.083333333333333, 1.05, 0.083333333333333
20284, 0.083333333333333, 1.1, 0.083333333333333
20285, 0.083333333333333, 1.15, 0.083333333333333
20286, 0.083333333333333, 1.2, 0.083333333333333
20287, 0.083333333333333, 1.25, 0.083333333333333
20288, 0.083333333333333, 1.3, 0.083333333333333
20289, 0.083333333333333, 0.2, 0.125
20290, 0.083333333333333, 0.25, 0.125
20291, 0.083333333333333, 0.3, 0.125
20292, 0.083333333333333, 0.35, 0.125
20293, 0.083333333333333, 0.4, 0.125
20294, 0.083333333333333, 0.45, 0.125
20295, 0.083333333333333, 0.5, 0.125
20296, 0.083333333333333, 0.55, 0.125
20297, 0.083333333333333, 0.6, 0.125
20298, 0.083333333333333, 0.65, 0.125
20299, 0.083333333333333, 0.7, 0.125
20300, 0.083333333333333, 0.75, 0.125
20301, 0.083333333333333, 0.8, 0.125
20302, 0.083333333333333, 0.85, 0.125
20303, 0.083333333333333, 0.9, 0.125
20304, 0.083333333333333, 0.95, 0.125
20305, 0.083333333333333, 1, 0.125
20306, 0.083333333333333, 1.05, 0.125
20307, 0.083333333333333, 1.1, 0.125
20308, 0.083333333333333, 1.15, 0.125
20309, 0.083333333333333, 1.2, 0.125
20310, 0.083333333333333, 1.25, 0.125
20311, 0.083333333333333, 1.3, 0.125
20312, 0.083333333333333, 0.2, 0.16666666666667
20313, 0.083333333333333, 0.25, 0.16666666666667
20314, 0.083333333333333, 0.3, 0.16666666666667
20315, 0.083333333333333, 0.35, 0.16666666666667
20316, 0.083333333333333, 0.4, 0.16666666666667
20317, 0.083333333333333, 0.45, 0.16666666666667
20318, 0.083333333333333, 0.5, 0.16666666666667
20319, 0.083333333333333, 0.55, 0.16666666666667
20320, 0.083333333333333, 0.6, 0.16666666666667
20321, 0.083333333333333, 0.65, 0.16666666666667
20322, 0.083333333333333, 0.7, 0.16666666666667
20323, 0.083333333333333, 0.75, 0.16666666666667
20324, 0.083333333333333, 0.8, 0.16666666666667
20325, 0.083333333333333, 0.85, 0.16666666666667
20326, 0.083333333333333, 0.9, 0.16666666666667
20327, 0.083333333333333, 0.95, 0.16666666666667
20328, 0.083333333333333, 1, 0.16666666666667
20329, 0.083333333333333, 1.05, 0.16666666666667
20330, 0.083333333333333, 1.1, 0.16666666666667
20331, 0.083333333333333, 1.15, 0.16666666666667
20332, 0.083333333333333, 1.2, 0.16666666666667
20333, 0.083333333333333, 1.25, 0.16666666666667
20334, 0.083333333333333, 1.3, 0.16666666666667
20335, 0.083333333333333, 0.2, 0.20833333333333
20336, 0.083333333333333, 0.25, 0.20833333333333
20337, 0.083333333333333, 0.3, 0.20833333333333
20338, 0.083333333333333, 0.35, 0.20833333333333
20339, 0.083333333333333, 0.4, 0.20833333333333
20340, 0.083333333333333, 0.45, 0.20833333333333
20341, 0.083333333333333, 0.5, 0.20833333333333
20342, 0.083333333333333, 0.55, 0.20833333333333
20343, 0.083333333333333, 0.6, 0.20833333333333
20344, 0.083333333333333, 0.65, 0.20833333333333
20345, 0.083333333333333, 0.7, 0.20833333333333
20346, 0.083333333333333, 0.75, 0.20833333333333
20347, 0.083333333333333, 0.8, 0.20833333333333
20348, 0.083333333333333, 0.85, 0.20833333333333
20349, 0.083333333333333, 0.9, 0.20833333333333
20350, 0.083333333333333, 0.95, 0.20833333333333
20351, 0.083333333333333, 1, 0.20833333333333
20352, 0.083333333333333, 1.05, 0.20833333333333
20353, 0.083333333333333, 1.1, 0.20833333333333
20354, 0.083333333333333, 1.15, 0.20833333333333
20355, 0.083333333333333, 1.2, 0.20833333333333
20356, 0.083333333333333, 1.25, 0.20833333333333
20357, 0.083333333333333, 1.3, 0.20833333333333
20358, 0.083333333333333, 0.2, 0.25
20359, 0.083333333333333, 0.25, 0.25
20360, 0.083333333333333, 0.3, 0.25
20361, 0.083333333333333, 0.35, 0.25
20362, 0.083333333333333, 0.4, 0.25
20363, 0.083333333333333, 0.45, 0.25
20364, 0.083333333333333, 0.5, 0.25
20365, 0.083333333333333, 0.55, 0.25
20366, 0.083333333333333, 0.6, 0.25
20367, 0.083333333333333, 0.65, 0.25
20368, 0.083333333333333, 0.7, 0.25
20369, 0.083333333333333, 0.75, 0.25
20370, 0.083333333333333, 0.8, 0.25
20371, 0.083333333333333, 0.85, 0.25
20372, 0.083333333333333, 0.9, 0.25
20373, 0.083333333333333, 0.95, 0.25
20374, 0.083333333333333, 1, 0.25
20375, 0.083333333333333, 1.05, 0.25
20376, 0.083333333333333, 1.1, 0.25
20377, 0.083333333333333, 1.15, 0.25
20378, 0.083333333333333, 1.2, 0.25
20379, 0.083333333333333, 1.25, 0.25
20380, 0.083333333333333, 1.3, 0.25
20381, 0.083333333333333, 0.2, 0.29166666666667
20382, 0.083333333333333, 0.25, 0.29166666666667
20383, 0.083333333333333, 0.3, 0.29166666666667
20384, 0.083333333333333, 0.35, 0.29166666666667
20385, 0.083333333333333, 0.4, 0.29166666666667
20386, 0.083333333333333, 0.45, 0.29166666666667
20387, 0.083333333333333, 0.5, 0.29166666666667
20388, 0.083333333333333, 0.55, 0.29166666666667
20389, 0.083333333333333, 0.6, 0.29166666666667
20390, 0.083333333333333, 0.65, 0.29166666666667
20391, 0.083333333333333, 0.7, 0.29166666666667
20392, 0.083333333333333, 0.75, 0.29166666666667
20393, 0.083333333333333, 0.8, 0.29166666666667
20394, 0.083333333333333, 0.85, 0.29166666666667
20395, 0.083333333333333, 0.9, 0.29166666666667
20396, 0.083333333333333, 0.95, 0.29166666666667
20397, 0.083333333333333, 1, 0.29166666666667
20398, 0.083333333333333, 1.05, 0.29166666666667
20399, 0.083333333333333, 1.1, 0.29166666666667
20400, 0.083333333333333, 1.15, 0.29166666666667
20401, 0.083333333333333, 1.2, 0.29166666666667
20402, 0.083333333333333, 1.25, 0.29166666666667
20403, 0.083333333333333, 1.3, 0.29166666666667
20404, 0.083333333333333, 0.2, 0.33333333333333
20405, 0.083333333333333, 0.25, 0.33333333333333
20406, 0.083333333333333, 0.3, 0.33333333333333
20407, 0.083333333333333, 0.35, 0.33333333333333
20408, 0.083333333333333, 0.4, 0.33333333333333
20409, 0.083333333333333, 0.45, 0.33333333333333
20410, 0.083333333333333, 0.5, 0.33333333333333
20411, 0.083333333333333, 0.55, 0.33333333333333
20412, 0.083333333333333, 0.6, 0.33333333333333
20413, 0.083333333333333, 0.65, 0.33333333333333
20414, 0.083333333333333, 0.7, 0.33333333333333
20415, 0.083333333333333, 0.75, 0.33333333333333
20416, 0.083333333333333, 0.8, 0.33333333333333
20417, 0.083333333333333, 0.85, 0.33333333333333
20418, 0.083333333333333, 0.9, 0.33333333333333
20419, 0.083333333333333, 0.95, 0.33333333333333
20420, 0.083333333333333, 1, 0.33333333333333
20421, 0.083333333333333, 1.05, 0.33333333333333
20422, 0.083333333333333, 1.1, 0.33333333333333
20423, 0.083333333333333, 1.15, 0.33333333333333
20424, 0.083333333333333, 1.2, 0.33333333333333
20425, 0.083333333333333, 1.25, 0.33333333333333
20426, 0.083333333333333, 1.3, 0.33333333333333
20427, 0.083333333333333, 0.2, 0.375
20428, 0.083333333333333, 0.25, 0.375
20429, 0.083333333333333, 0.3, 0.375
20430, 0.083333333333333, 0.35, 0.375
20431, 0.083333333333333, 0.4, 0.375
20432, 0.083333333333333, 0.45, 0.375
20433, 0.083333333333333, 0.5, 0.375
20434, 0.083333333333333, 0.55, 0.375
20435, 0.083333333333333, 0.6, 0.375
20436, 0.083333333333333, 0.65, 0.375
20437, 0.083333333333333, 0.7, 0.375
20438, 0.083333333333333, 0.75, 0.375
20439, 0.083333333333333, 0.8, 0.375
20440, 0.083333333333333, 0.85, 0.375
20441, 0.083333333333333, 0.9, 0.375
20442, 0.083333333333333, 0.95, 0.375
20443, 0.083333333333333, 1, 0.375
20444, 0.083333333333333, 1.05, 0.375
20445, 0.083333333333333, 1.1, 0.375
20446, 0.083333333333333, 1.15, 0.375
20447, 0.083333333333333, 1.2, 0.375
20448, 0.083333333333333, 1.25, 0.375
20449, 0.083333333333333, 1.3, 0.375
20450, 0.083333333333333, 0.2, 0.41666666666667
20451, 0.083333333333333, 0.25, 0.41666666666667
20452, 0.083333333333333, 0.3, 0.41666666666667
20453, 0.083333333333333, 0.35, 0.41666666666667
20454, 0.083333333333333, 0.4, 0.41666666666667
20455, 0.083333333333333, 0.45, 0.41666666666667
20456, 0.083333333333333, 0.5, 0.41666666666667
20457, 0.083333333333333, 0.55, 0.41666666666667
20458, 0.083333333333333, 0.6, 0.41666666666667
20459, 0.083333333333333, 0.65, 0.41666666666667
20460, 0.083333333333333, 0.7, 0.41666666666667
20461, 0.083333333333333, 0.75, 0.41666666666667
20462, 0.083333333333333, 0.8, 0.41666666666667
20463, 0.083333333333333, 0.85, 0.41666666666667
20464, 0.083333333333333, 0.9, 0.41666666666667
20465, 0.083333333333333, 0.95, 0.41666666666667
20466, 0.083333333333333, 1, 0.41666666666667
20467, 0.083333333333333, 1.05, 0.41666666666667
20468, 0.083333333333333, 1.1, 0.41666666666667
20469, 0.083333333333333, 1.15, 0.41666666666667
20470, 0.083333333333333, 1.2, 0.41666666666667
20471, 0.083333333333333, 1.25, 0.41666666666667
20472, 0.083333333333333, 1.3, 0.41666666666667
20473, 0.083333333333333, 0.2, 0.45833333333333
20474, 0.083333333333333, 0.25, 0.45833333333333
20475, 0.083333333333333, 0.3, 0.45833333333333
20476, 0.083333333333333, 0.35, 0.45833333333333
20477, 0.083333333333333, 0.4, 0.45833333333333
20478, 0.083333333333333, 0.45, 0.45833333333333
20479, 0.083333333333333, 0.5, 0.45833333333333
20480, 0.083333333333333, 0.55, 0.45833333333333
20481, 0.083333333333333, 0.6, 0.45833333333333
20482, 0.083333333333333, 0.65, 0.45833333333333
20483, 0.083333333333333, 0.7, 0.45833333333333
20484, 0.083333333333333, 0.75, 0.45833333333333
20485, 0.083333333333333, 0.8, 0.45833333333333
20486, 0.083333333333333, 0.85, 0.45833333333333
20487, 0.083333333333333, 0.9, 0.45833333333333
20488, 0.083333333333333, 0.95, 0.45833333333333
20489, 0.083333333333333, 1, 0.45833333333333
20490, 0.083333333333333, 1.05, 0.45833333333333
20491, 0.083333333333333, 1.1, 0.45833333333333
20492, 0.083333333333333, 1.15, 0.45833333333333
20493, 0.083333333333333, 1.2, 0.45833333333333
20494, 0.083333333333333, 1.25, 0.45833333333333
20495, 0.083333333333333, 1.3, 0.45833333333333
20496, 0.125, 0.2, 0.041666666666667
20497, 0.125, 0.25, 0.041666666666667
20498, 0.125, 0.3, 0.041666666666667
20499, 0.125, 0.35, 0.041666666666667
20500, 0.125, 0.4, 0.041666666666667
20501, 0.125, 0.45, 0.041666666666667
20502, 0.125, 0.5, 0.041666666666667
20503, 0.125, 0.55, 0.041666666666667
20504, 0.125, 0.6, 0.041666666666667
20505, 0.125, 0.65, 0.041666666666667
20506, 0.125, 0.7, 0.041666666666667
20507, 0.125, 0.75, 0.041666666666667
20508, 0.125, 0.8, 0.041666666666667
20509, 0.125, 0.85, 0.041666666666667
20510, 0.125, 0.9, 0.041666666666667
20511, 0.125, 0.95, 0.041666666666667
20512, 0.125, 1, 0.041666666666667
20513, 0.125, 1.05, 0.041666666666667
20514, 0.125, 1.1, 0.041666666666667
20515, 0.125, 1.15, 0.041666666666667
20516, 0.125, 1.2, 0.041666666666667
20517, 0.125, 1.25, 0.041666666666667
20518, 0.125, 1.3, 0.041666666666667
20519, 0.125, 0.2, 0.083333333333333
20520, 0.125, 0.25, 0.083333333333333
20521, 0.125, 0.3, 0.083333333333333
20522, 0.125, 0.35, 0.083333333333333
20523, 0.125, 0.4, 0.083333333333333
20524, 0.125, 0.45, 0.083333333333333
20525, 0.125, 0.5, 0.083333333333333
20526, 0.125, 0.55, 0.083333333333333
20527, 0.125, 0.6, 0.083333333333333
20528, 0.125, 0.65, 0.083333333333333
20529, 0.125, 0.7, 0.083333333333333
20530, 0.125, 0.75, 0.083333333333333
20531, 0.125, 0.8, 0.083333333333333
20532, 0.125, 0.85, 0.083333333333333
20533, 0.125, 0.9, 0.083333333333333
20534, 0.125, 0.95, 0.083333333333333
20535, 0.125, 1, 0.083333333333333
20536, 0.125, 1.05, 0.083333333333333
20537, 0.125, 1.1, 0.083333333333333
20538, 0.125, 1.15, 0.083333333333333
20539, 0.125, 1.2, 0.083333333333333
20540, 0.125, 1.25, 0.083333333333333
20541, 0.125, 1.3, 0.083333333333333
20542, 0.125, 0.2, 0.125
20543, 0.125, 0.25, 0.125
20544, 0.125, 0.3, 0.125
20545, 0.125, 0.35, 0.125
20546, 0.125, 0.4, 0.125
20547, 0.125, 0.45, 0.125
20548, 0.125, 0.5, 0.125
20549, 0.125, 0.55, 0.125
20550, 0.125, 0.6, 0.125
20551, 0.125, 0.65, 0.125
20552, 0.125, 0.7, 0.125
20553, 0.125, 0.75, 0.125
20554, 0.125, 0.8, 0.125
20555, 0.125, 0.85, 0.125
20556, 0.125, 0.9, 0.125
20557, 0.125, 0.95, 0.125
20558, 0.125, 1, 0.125
20559, 0.125, 1.05, 0.125
20560, 0.125, 1.1, 0.125
20561, 0.125, 1.15, 0.125
20562, 0.125, 1.2, 0.125
20563, 0.125, 1.25, 0.125
20564, 0.125, 1.3, 0.125
20565, 0.125, 0.2, 0.16666666666667
20566, 0.125, 0.25, 0.16666666666667
20567, 0.125, 0.3, 0.16666666666667
20568, 0.125, 0.35, 0.16666666666667
20569, 0.125, 0.4, 0.16666666666667
20570, 0.125, 0.45, 0.16666666666667
20571, 0.125, 0.5, 0.16666666666667
20572, 0.125, 0.55, 0.16666666666667
20573, 0.125, 0.6, 0.16666666666667
20574, 0.125, 0.65, 0.16666666666667
20575, 0.125, 0.7, 0.16666666666667
20576, 0.125, 0.75, 0.16666666666667
20577, 0.125, 0.8, 0.16666666666667
20578, 0.125, 0.85, 0.16666666666667
20579, 0.125, 0.9, 0.16666666666667
20580, 0.125, 0.95, 0.16666666666667
20581, 0.125, 1, 0.16666666666667
20582, 0.125, 1.05, 0.16666666666667
20583, 0.125, 1.1, 0.16666666666667
20584, 0.125, 1.15, 0.16666666666667
20585, 0.125, 1.2, 0.16666666666667
20586, 0.125, 1.25, 0.16666666666667
20587, 0.125, 1.3, 0.16666666666667
20588, 0.125, 0.2, 0.20833333333333
20589, 0.125, 0.25, 0.20833333333333
20590, 0.125, 0.3, 0.20833333333333
20591, 0.125, 0.35, 0.20833333333333
20592, 0.125, 0.4, 0.20833333333333
20593, 0.125, 0.45, 0.20833333333333
20594, 0.125, 0.5, 0.20833333333333
20595, 0.125, 0.55, 0.20833333333333
20596, 0.125, 0.6, 0.20833333333333
20597, 0.125, 0.65, 0.20833333333333
20598, 0.125, 0.7, 0.20833333333333
20599, 0.125, 0.75, 0.20833333333333
20600, 0.125, 0.8, 0.20833333333333
20601, 0.125, 0.85, 0.20833333333333
20602, 0.125, 0.9, 0.20833333333333
20603, 0.125, 0.95, 0.20833333333333
20604, 0.125, 1, 0.20833333333333
20605, 0.125, 1.05, 0.20833333333333
20606, 0.125, 1.1, 0.20833333333333
20607, 0.125, 1.15, 0.20833333333333
20608, 0.125, 1.2, 0.20833333333333
20609, 0.125, 1.25, 0.20833333333333
20610, 0.125, 1.3, 0.20833333333333
20611, 0.125, 0.2, 0.25
20612, 0.125, 0.25, 0.25
20613, 0.125, 0.3, 0.25
20614, 0.125, 0.35, 0.25
20615, 0.125, 0.4, 0.25
20616, 0.125, 0.45, 0.25
20617, 0.125, 0.5, 0.25
20618, 0.125, 0.55, 0.25
20619, 0.125, 0.6, 0.25
20620, 0.125, 0.65, 0.25
20621, 0.125, 0.7, 0.25
20622, 0.125, 0.75, 0.25
20623, 0.125, 0.8, 0.25
20624, 0.125, 0.85, 0.25
20625, 0.125, 0.9, 0.25
20626, 0.125, 0.95, 0.25
20627, 0.125, 1, 0.25
20628, 0.125, 1.05, 0.25
20629, 0.125, 1.1, 0.25
20630, 0.125, 1.15, 0.25
20631, 0.125, 1.2, 0.25
20632, 0.125, 1.25, 0.25
20633, 0.125, 1.3, 0.25
20634, 0.125, 0.2, 0.29166666666667
20635, 0.125, 0.25, 0.29166666666667
20636, 0.125, 0.3, 0.29166666666667
20637, 0.125, 0.35, 0.29166666666667
20638, 0.125, 0.4, 0.29166666666667
20639, 0.125, 0.45, 0.29166666666667
20640, 0.125, 0.5, 0.29166666666667
20641, 0.125, 0.55, 0.29166666666667
20642, 0.125, 0.6, 0.29166666666667
20643, 0.125, 0.65, 0.29166666666667
20644, 0.125, 0.7, 0.29166666666667
20645, 0.125, 0.75, 0.29166666666667
20646, 0.125, 0.8, 0.29166666666667
20647, 0.125, 0.85, 0.29166666666667
20648, 0.125, 0.9, 0.29166666666667
20649, 0.125, 0.95, 0.29166666666667
20650, 0.125, 1, 0.29166666666667
20651, 0.125, 1.05, 0.29166666666667
20652, 0.125, 1.1, 0.29166666666667
20653, 0.125, 1.15, 0.29166666666667
20654, 0.125, 1.2, 0.29166666666667
20655, 0.125, 1.25, 0.29166666666667
20656, 0.125, 1.3, 0.29166666666667
20657, 0.125, 0.2, 0.33333333333333
20658, 0.125, 0.25, 0.33333333333333
20659, 0.125, 0.3, 0.33333333333333
20660, 0.125, 0.35, 0.33333333333333
20661, 0.125, 0.4, 0.33333333333333
20662, 0.125, 0.45, 0.33333333333333
20663, 0.125, 0.5, 0.33333333333333
20664, 0.125, 0.55, 0.33333333333333
20665, 0.125, 0.6, 0.33333333333333
20666, 0.125, 0.65, 0.33333333333333
20667, 0.125, 0.7, 0.33333333333333
20668, 0.125, 0.75, 0.33333333333333
20669, 0.125, 0.8, 0.33333333333333
20670, 0.125, 0.85, 0.33333333333333
20671, 0.125, 0.9, 0.33333333333333
20672, 0.125, 0.95, 0.33333333333333
20673, 0.125, 1, 0.33333333333333
20674, 0.125, 1.05, 0.33333333333333
20675, 0.125, 1.1, 0.33333333333333
