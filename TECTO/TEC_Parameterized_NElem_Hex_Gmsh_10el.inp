10299, 3595, 23042, 23295, 3618, 3596, 23043, 23296, 3619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10300, 3596, 23043, 23296, 3619, 3597, 23044, 23297, 3620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10301, 3597, 23044, 23297, 3620, 3598, 23045, 23298, 3621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10302, 3598, 23045, 23298, 3621, 3599, 23046, 23299, 3622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10303, 3599, 23046, 23299, 3622, 3600, 23047, 23300, 3623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10304, 3600, 23047, 23300, 3623, 3601, 23048, 23301, 3624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10305, 3601, 23048, 23301, 3624, 368, 4999, 5010, 369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10306, 3182, 3183, 3194, 3193, 23026, 23049, 23302, 23279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10307, 23026, 23049, 23302, 23279, 23027, 23050, 23303, 23280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10308, 23027, 23050, 23303, 23280, 23028, 23051, 23304, 23281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10309, 23028, 23051, 23304, 23281, 23029, 23052, 23305, 23282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10310, 23029, 23052, 23305, 23282, 23030, 23053, 23306, 23283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10311, 23030, 23053, 23306, 23283, 23031, 23054, 23307, 23284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10312, 23031, 23054, 23307, 23284, 23032, 23055, 23308, 23285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10313, 23032, 23055, 23308, 23285, 23033, 23056, 23309, 23286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10314, 23033, 23056, 23309, 23286, 23034, 23057, 23310, 23287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10315, 23034, 23057, 23310, 23287, 23035, 23058, 23311, 23288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10316, 23035, 23058, 23311, 23288, 23036, 23059, 23312, 23289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10317, 23036, 23059, 23312, 23289, 23037, 23060, 23313, 23290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10318, 23037, 23060, 23313, 23290, 23038, 23061, 23314, 23291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10319, 23038, 23061, 23314, 23291, 23039, 23062, 23315, 23292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10320, 23039, 23062, 23315, 23292, 23040, 23063, 23316, 23293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10321, 23040, 23063, 23316, 23293, 23041, 23064, 23317, 23294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10322, 23041, 23064, 23317, 23294, 23042, 23065, 23318, 23295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10323, 23042, 23065, 23318, 23295, 23043, 23066, 23319, 23296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10324, 23043, 23066, 23319, 23296, 23044, 23067, 23320, 23297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10325, 23044, 23067, 23320, 23297, 23045, 23068, 23321, 23298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10326, 23045, 23068, 23321, 23298, 23046, 23069, 23322, 23299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10327, 23046, 23069, 23322, 23299, 23047, 23070, 23323, 23300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10328, 23047, 23070, 23323, 23300, 23048, 23071, 23324, 23301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10329, 23048, 23071, 23324, 23301, 4999, 5000, 5011, 5010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10330, 3183, 3184, 3195, 3194, 23049, 23072, 23325, 23302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10331, 23049, 23072, 23325, 23302, 23050, 23073, 23326, 23303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10332, 23050, 23073, 23326, 23303, 23051, 23074, 23327, 23304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10333, 23051, 23074, 23327, 23304, 23052, 23075, 23328, 23305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10334, 23052, 23075, 23328, 23305, 23053, 23076, 23329, 23306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10335, 23053, 23076, 23329, 23306, 23054, 23077, 23330, 23307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10336, 23054, 23077, 23330, 23307, 23055, 23078, 23331, 23308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10337, 23055, 23078, 23331, 23308, 23056, 23079, 23332, 23309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10338, 23056, 23079, 23332, 23309, 23057, 23080, 23333, 23310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10339, 23057, 23080, 23333, 23310, 23058, 23081, 23334, 23311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10340, 23058, 23081, 23334, 23311, 23059, 23082, 23335, 23312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10341, 23059, 23082, 23335, 23312, 23060, 23083, 23336, 23313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10342, 23060, 23083, 23336, 23313, 23061, 23084, 23337, 23314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10343, 23061, 23084, 23337, 23314, 23062, 23085, 23338, 23315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10344, 23062, 23085, 23338, 23315, 23063, 23086, 23339, 23316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10345, 23063, 23086, 23339, 23316, 23064, 23087, 23340, 23317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10346, 23064, 23087, 23340, 23317, 23065, 23088, 23341, 23318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10347, 23065, 23088, 23341, 23318, 23066, 23089, 23342, 23319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10348, 23066, 23089, 23342, 23319, 23067, 23090, 23343, 23320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10349, 23067, 23090, 23343, 23320, 23068, 23091, 23344, 23321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10350, 23068, 23091, 23344, 23321, 23069, 23092, 23345, 23322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10351, 23069, 23092, 23345, 23322, 23070, 23093, 23346, 23323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10352, 23070, 23093, 23346, 23323, 23071, 23094, 23347, 23324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10353, 23071, 23094, 23347, 23324, 5000, 5001, 5012, 5011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10354, 3184, 3185, 3196, 3195, 23072, 23095, 23348, 23325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10355, 23072, 23095, 23348, 23325, 23073, 23096, 23349, 23326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10356, 23073, 23096, 23349, 23326, 23074, 23097, 23350, 23327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10357, 23074, 23097, 23350, 23327, 23075, 23098, 23351, 23328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10358, 23075, 23098, 23351, 23328, 23076, 23099, 23352, 23329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10359, 23076, 23099, 23352, 23329, 23077, 23100, 23353, 23330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10360, 23077, 23100, 23353, 23330, 23078, 23101, 23354, 23331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10361, 23078, 23101, 23354, 23331, 23079, 23102, 23355, 23332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10362, 23079, 23102, 23355, 23332, 23080, 23103, 23356, 23333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10363, 23080, 23103, 23356, 23333, 23081, 23104, 23357, 23334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10364, 23081, 23104, 23357, 23334, 23082, 23105, 23358, 23335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10365, 23082, 23105, 23358, 23335, 23083, 23106, 23359, 23336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10366, 23083, 23106, 23359, 23336, 23084, 23107, 23360, 23337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10367, 23084, 23107, 23360, 23337, 23085, 23108, 23361, 23338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10368, 23085, 23108, 23361, 23338, 23086, 23109, 23362, 23339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10369, 23086, 23109, 23362, 23339, 23087, 23110, 23363, 23340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10370, 23087, 23110, 23363, 23340, 23088, 23111, 23364, 23341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10371, 23088, 23111, 23364, 23341, 23089, 23112, 23365, 23342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10372, 23089, 23112, 23365, 23342, 23090, 23113, 23366, 23343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10373, 23090, 23113, 23366, 23343, 23091, 23114, 23367, 23344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10374, 23091, 23114, 23367, 23344, 23092, 23115, 23368, 23345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10375, 23092, 23115, 23368, 23345, 23093, 23116, 23369, 23346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10376, 23093, 23116, 23369, 23346, 23094, 23117, 23370, 23347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10377, 23094, 23117, 23370, 23347, 5001, 5002, 5013, 5012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10378, 3185, 3186, 3197, 3196, 23095, 23118, 23371, 23348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10379, 23095, 23118, 23371, 23348, 23096, 23119, 23372, 23349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10380, 23096, 23119, 23372, 23349, 23097, 23120, 23373, 23350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10381, 23097, 23120, 23373, 23350, 23098, 23121, 23374, 23351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10382, 23098, 23121, 23374, 23351, 23099, 23122, 23375, 23352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10383, 23099, 23122, 23375, 23352, 23100, 23123, 23376, 23353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10384, 23100, 23123, 23376, 23353, 23101, 23124, 23377, 23354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10385, 23101, 23124, 23377, 23354, 23102, 23125, 23378, 23355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10386, 23102, 23125, 23378, 23355, 23103, 23126, 23379, 23356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10387, 23103, 23126, 23379, 23356, 23104, 23127, 23380, 23357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10388, 23104, 23127, 23380, 23357, 23105, 23128, 23381, 23358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10389, 23105, 23128, 23381, 23358, 23106, 23129, 23382, 23359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10390, 23106, 23129, 23382, 23359, 23107, 23130, 23383, 23360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10391, 23107, 23130, 23383, 23360, 23108, 23131, 23384, 23361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10392, 23108, 23131, 23384, 23361, 23109, 23132, 23385, 23362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10393, 23109, 23132, 23385, 23362, 23110, 23133, 23386, 23363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10394, 23110, 23133, 23386, 23363, 23111, 23134, 23387, 23364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10395, 23111, 23134, 23387, 23364, 23112, 23135, 23388, 23365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10396, 23112, 23135, 23388, 23365, 23113, 23136, 23389, 23366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10397, 23113, 23136, 23389, 23366, 23114, 23137, 23390, 23367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10398, 23114, 23137, 23390, 23367, 23115, 23138, 23391, 23368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10399, 23115, 23138, 23391, 23368, 23116, 23139, 23392, 23369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10400, 23116, 23139, 23392, 23369, 23117, 23140, 23393, 23370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10401, 23117, 23140, 23393, 23370, 5002, 5003, 5014, 5013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10402, 3186, 3187, 3198, 3197, 23118, 23141, 23394, 23371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10403, 23118, 23141, 23394, 23371, 23119, 23142, 23395, 23372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10404, 23119, 23142, 23395, 23372, 23120, 23143, 23396, 23373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10405, 23120, 23143, 23396, 23373, 23121, 23144, 23397, 23374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10406, 23121, 23144, 23397, 23374, 23122, 23145, 23398, 23375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10407, 23122, 23145, 23398, 23375, 23123, 23146, 23399, 23376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10408, 23123, 23146, 23399, 23376, 23124, 23147, 23400, 23377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10409, 23124, 23147, 23400, 23377, 23125, 23148, 23401, 23378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10410, 23125, 23148, 23401, 23378, 23126, 23149, 23402, 23379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10411, 23126, 23149, 23402, 23379, 23127, 23150, 23403, 23380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10412, 23127, 23150, 23403, 23380, 23128, 23151, 23404, 23381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10413, 23128, 23151, 23404, 23381, 23129, 23152, 23405, 23382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10414, 23129, 23152, 23405, 23382, 23130, 23153, 23406, 23383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10415, 23130, 23153, 23406, 23383, 23131, 23154, 23407, 23384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10416, 23131, 23154, 23407, 23384, 23132, 23155, 23408, 23385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10417, 23132, 23155, 23408, 23385, 23133, 23156, 23409, 23386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10418, 23133, 23156, 23409, 23386, 23134, 23157, 23410, 23387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10419, 23134, 23157, 23410, 23387, 23135, 23158, 23411, 23388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10420, 23135, 23158, 23411, 23388, 23136, 23159, 23412, 23389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10421, 23136, 23159, 23412, 23389, 23137, 23160, 23413, 23390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10422, 23137, 23160, 23413, 23390, 23138, 23161, 23414, 23391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10423, 23138, 23161, 23414, 23391, 23139, 23162, 23415, 23392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10424, 23139, 23162, 23415, 23392, 23140, 23163, 23416, 23393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10425, 23140, 23163, 23416, 23393, 5003, 5004, 5015, 5014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10426, 3187, 3188, 3199, 3198, 23141, 23164, 23417, 23394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10427, 23141, 23164, 23417, 23394, 23142, 23165, 23418, 23395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10428, 23142, 23165, 23418, 23395, 23143, 23166, 23419, 23396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10429, 23143, 23166, 23419, 23396, 23144, 23167, 23420, 23397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10430, 23144, 23167, 23420, 23397, 23145, 23168, 23421, 23398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10431, 23145, 23168, 23421, 23398, 23146, 23169, 23422, 23399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10432, 23146, 23169, 23422, 23399, 23147, 23170, 23423, 23400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10433, 23147, 23170, 23423, 23400, 23148, 23171, 23424, 23401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10434, 23148, 23171, 23424, 23401, 23149, 23172, 23425, 23402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10435, 23149, 23172, 23425, 23402, 23150, 23173, 23426, 23403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10436, 23150, 23173, 23426, 23403, 23151, 23174, 23427, 23404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10437, 23151, 23174, 23427, 23404, 23152, 23175, 23428, 23405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10438, 23152, 23175, 23428, 23405, 23153, 23176, 23429, 23406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10439, 23153, 23176, 23429, 23406, 23154, 23177, 23430, 23407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10440, 23154, 23177, 23430, 23407, 23155, 23178, 23431, 23408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10441, 23155, 23178, 23431, 23408, 23156, 23179, 23432, 23409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10442, 23156, 23179, 23432, 23409, 23157, 23180, 23433, 23410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10443, 23157, 23180, 23433, 23410, 23158, 23181, 23434, 23411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10444, 23158, 23181, 23434, 23411, 23159, 23182, 23435, 23412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10445, 23159, 23182, 23435, 23412, 23160, 23183, 23436, 23413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10446, 23160, 23183, 23436, 23413, 23161, 23184, 23437, 23414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10447, 23161, 23184, 23437, 23414, 23162, 23185, 23438, 23415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10448, 23162, 23185, 23438, 23415, 23163, 23186, 23439, 23416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10449, 23163, 23186, 23439, 23416, 5004, 5005, 5016, 5015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10450, 3188, 3189, 3200, 3199, 23164, 23187, 23440, 23417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10451, 23164, 23187, 23440, 23417, 23165, 23188, 23441, 23418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10452, 23165, 23188, 23441, 23418, 23166, 23189, 23442, 23419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10453, 23166, 23189, 23442, 23419, 23167, 23190, 23443, 23420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10454, 23167, 23190, 23443, 23420, 23168, 23191, 23444, 23421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10455, 23168, 23191, 23444, 23421, 23169, 23192, 23445, 23422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10456, 23169, 23192, 23445, 23422, 23170, 23193, 23446, 23423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10457, 23170, 23193, 23446, 23423, 23171, 23194, 23447, 23424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10458, 23171, 23194, 23447, 23424, 23172, 23195, 23448, 23425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10459, 23172, 23195, 23448, 23425, 23173, 23196, 23449, 23426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10460, 23173, 23196, 23449, 23426, 23174, 23197, 23450, 23427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10461, 23174, 23197, 23450, 23427, 23175, 23198, 23451, 23428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10462, 23175, 23198, 23451, 23428, 23176, 23199, 23452, 23429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10463, 23176, 23199, 23452, 23429, 23177, 23200, 23453, 23430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10464, 23177, 23200, 23453, 23430, 23178, 23201, 23454, 23431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10465, 23178, 23201, 23454, 23431, 23179, 23202, 23455, 23432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10466, 23179, 23202, 23455, 23432, 23180, 23203, 23456, 23433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10467, 23180, 23203, 23456, 23433, 23181, 23204, 23457, 23434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10468, 23181, 23204, 23457, 23434, 23182, 23205, 23458, 23435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10469, 23182, 23205, 23458, 23435, 23183, 23206, 23459, 23436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10470, 23183, 23206, 23459, 23436, 23184, 23207, 23460, 23437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10471, 23184, 23207, 23460, 23437, 23185, 23208, 23461, 23438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10472, 23185, 23208, 23461, 23438, 23186, 23209, 23462, 23439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10473, 23186, 23209, 23462, 23439, 5005, 5006, 5017, 5016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10474, 3189, 3190, 3201, 3200, 23187, 23210, 23463, 23440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10475, 23187, 23210, 23463, 23440, 23188, 23211, 23464, 23441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10476, 23188, 23211, 23464, 23441, 23189, 23212, 23465, 23442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10477, 23189, 23212, 23465, 23442, 23190, 23213, 23466, 23443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10478, 23190, 23213, 23466, 23443, 23191, 23214, 23467, 23444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10479, 23191, 23214, 23467, 23444, 23192, 23215, 23468, 23445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10480, 23192, 23215, 23468, 23445, 23193, 23216, 23469, 23446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10481, 23193, 23216, 23469, 23446, 23194, 23217, 23470, 23447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10482, 23194, 23217, 23470, 23447, 23195, 23218, 23471, 23448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10483, 23195, 23218, 23471, 23448, 23196, 23219, 23472, 23449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10484, 23196, 23219, 23472, 23449, 23197, 23220, 23473, 23450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10485, 23197, 23220, 23473, 23450, 23198, 23221, 23474, 23451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10486, 23198, 23221, 23474, 23451, 23199, 23222, 23475, 23452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10487, 23199, 23222, 23475, 23452, 23200, 23223, 23476, 23453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10488, 23200, 23223, 23476, 23453, 23201, 23224, 23477, 23454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10489, 23201, 23224, 23477, 23454, 23202, 23225, 23478, 23455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10490, 23202, 23225, 23478, 23455, 23203, 23226, 23479, 23456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10491, 23203, 23226, 23479, 23456, 23204, 23227, 23480, 23457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10492, 23204, 23227, 23480, 23457, 23205, 23228, 23481, 23458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10493, 23205, 23228, 23481, 23458, 23206, 23229, 23482, 23459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10494, 23206, 23229, 23482, 23459, 23207, 23230, 23483, 23460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10495, 23207, 23230, 23483, 23460, 23208, 23231, 23484, 23461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10496, 23208, 23231, 23484, 23461, 23209, 23232, 23485, 23462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10497, 23209, 23232, 23485, 23462, 5006, 5007, 5018, 5017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10498, 3190, 3191, 3202, 3201, 23210, 23233, 23486, 23463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10499, 23210, 23233, 23486, 23463, 23211, 23234, 23487, 23464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10500, 23211, 23234, 23487, 23464, 23212, 23235, 23488, 23465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10501, 23212, 23235, 23488, 23465, 23213, 23236, 23489, 23466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10502, 23213, 23236, 23489, 23466, 23214, 23237, 23490, 23467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10503, 23214, 23237, 23490, 23467, 23215, 23238, 23491, 23468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10504, 23215, 23238, 23491, 23468, 23216, 23239, 23492, 23469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10505, 23216, 23239, 23492, 23469, 23217, 23240, 23493, 23470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10506, 23217, 23240, 23493, 23470, 23218, 23241, 23494, 23471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10507, 23218, 23241, 23494, 23471, 23219, 23242, 23495, 23472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10508, 23219, 23242, 23495, 23472, 23220, 23243, 23496, 23473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10509, 23220, 23243, 23496, 23473, 23221, 23244, 23497, 23474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10510, 23221, 23244, 23497, 23474, 23222, 23245, 23498, 23475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10511, 23222, 23245, 23498, 23475, 23223, 23246, 23499, 23476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10512, 23223, 23246, 23499, 23476, 23224, 23247, 23500, 23477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10513, 23224, 23247, 23500, 23477, 23225, 23248, 23501, 23478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10514, 23225, 23248, 23501, 23478, 23226, 23249, 23502, 23479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10515, 23226, 23249, 23502, 23479, 23227, 23250, 23503, 23480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10516, 23227, 23250, 23503, 23480, 23228, 23251, 23504, 23481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10517, 23228, 23251, 23504, 23481, 23229, 23252, 23505, 23482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10518, 23229, 23252, 23505, 23482, 23230, 23253, 23506, 23483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10519, 23230, 23253, 23506, 23483, 23231, 23254, 23507, 23484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10520, 23231, 23254, 23507, 23484, 23232, 23255, 23508, 23485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10521, 23232, 23255, 23508, 23485, 5007, 5008, 5019, 5018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10522, 3191, 3192, 3203, 3202, 23233, 23256, 23509, 23486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10523, 23233, 23256, 23509, 23486, 23234, 23257, 23510, 23487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10524, 23234, 23257, 23510, 23487, 23235, 23258, 23511, 23488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10525, 23235, 23258, 23511, 23488, 23236, 23259, 23512, 23489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10526, 23236, 23259, 23512, 23489, 23237, 23260, 23513, 23490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10527, 23237, 23260, 23513, 23490, 23238, 23261, 23514, 23491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10528, 23238, 23261, 23514, 23491, 23239, 23262, 23515, 23492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10529, 23239, 23262, 23515, 23492, 23240, 23263, 23516, 23493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10530, 23240, 23263, 23516, 23493, 23241, 23264, 23517, 23494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10531, 23241, 23264, 23517, 23494, 23242, 23265, 23518, 23495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10532, 23242, 23265, 23518, 23495, 23243, 23266, 23519, 23496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10533, 23243, 23266, 23519, 23496, 23244, 23267, 23520, 23497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10534, 23244, 23267, 23520, 23497, 23245, 23268, 23521, 23498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10535, 23245, 23268, 23521, 23498, 23246, 23269, 23522, 23499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10536, 23246, 23269, 23522, 23499, 23247, 23270, 23523, 23500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10537, 23247, 23270, 23523, 23500, 23248, 23271, 23524, 23501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10538, 23248, 23271, 23524, 23501, 23249, 23272, 23525, 23502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10539, 23249, 23272, 23525, 23502, 23250, 23273, 23526, 23503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10540, 23250, 23273, 23526, 23503, 23251, 23274, 23527, 23504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10541, 23251, 23274, 23527, 23504, 23252, 23275, 23528, 23505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10542, 23252, 23275, 23528, 23505, 23253, 23276, 23529, 23506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10543, 23253, 23276, 23529, 23506, 23254, 23277, 23530, 23507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10544, 23254, 23277, 23530, 23507, 23255, 23278, 23531, 23508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10545, 23255, 23278, 23531, 23508, 5008, 5009, 5020, 5019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10546, 3192, 288, 289, 3203, 23256, 4361, 4384, 23509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10547, 23256, 4361, 4384, 23509, 23257, 4362, 4385, 23510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10548, 23257, 4362, 4385, 23510, 23258, 4363, 4386, 23511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10549, 23258, 4363, 4386, 23511, 23259, 4364, 4387, 23512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10550, 23259, 4364, 4387, 23512, 23260, 4365, 4388, 23513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10551, 23260, 4365, 4388, 23513, 23261, 4366, 4389, 23514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10552, 23261, 4366, 4389, 23514, 23262, 4367, 4390, 23515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10553, 23262, 4367, 4390, 23515, 23263, 4368, 4391, 23516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10554, 23263, 4368, 4391, 23516, 23264, 4369, 4392, 23517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10555, 23264, 4369, 4392, 23517, 23265, 4370, 4393, 23518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10556, 23265, 4370, 4393, 23518, 23266, 4371, 4394, 23519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10557, 23266, 4371, 4394, 23519, 23267, 4372, 4395, 23520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10558, 23267, 4372, 4395, 23520, 23268, 4373, 4396, 23521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10559, 23268, 4373, 4396, 23521, 23269, 4374, 4397, 23522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10560, 23269, 4374, 4397, 23522, 23270, 4375, 4398, 23523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10561, 23270, 4375, 4398, 23523, 23271, 4376, 4399, 23524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10562, 23271, 4376, 4399, 23524, 23272, 4377, 4400, 23525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10563, 23272, 4377, 4400, 23525, 23273, 4378, 4401, 23526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10564, 23273, 4378, 4401, 23526, 23274, 4379, 4402, 23527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10565, 23274, 4379, 4402, 23527, 23275, 4380, 4403, 23528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10566, 23275, 4380, 4403, 23528, 23276, 4381, 4404, 23529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10567, 23276, 4381, 4404, 23529, 23277, 4382, 4405, 23530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10568, 23277, 4382, 4405, 23530, 23278, 4383, 4406, 23531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10569, 23278, 4383, 4406, 23531, 5009, 448, 449, 5020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10570, 255, 3193, 3204, 256, 3602, 23279, 23532, 3625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10571, 3602, 23279, 23532, 3625, 3603, 23280, 23533, 3626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10572, 3603, 23280, 23533, 3626, 3604, 23281, 23534, 3627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10573, 3604, 23281, 23534, 3627, 3605, 23282, 23535, 3628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10574, 3605, 23282, 23535, 3628, 3606, 23283, 23536, 3629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10575, 3606, 23283, 23536, 3629, 3607, 23284, 23537, 3630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10576, 3607, 23284, 23537, 3630, 3608, 23285, 23538, 3631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10577, 3608, 23285, 23538, 3631, 3609, 23286, 23539, 3632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10578, 3609, 23286, 23539, 3632, 3610, 23287, 23540, 3633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10579, 3610, 23287, 23540, 3633, 3611, 23288, 23541, 3634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10580, 3611, 23288, 23541, 3634, 3612, 23289, 23542, 3635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10581, 3612, 23289, 23542, 3635, 3613, 23290, 23543, 3636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10582, 3613, 23290, 23543, 3636, 3614, 23291, 23544, 3637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10583, 3614, 23291, 23544, 3637, 3615, 23292, 23545, 3638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10584, 3615, 23292, 23545, 3638, 3616, 23293, 23546, 3639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10585, 3616, 23293, 23546, 3639, 3617, 23294, 23547, 3640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10586, 3617, 23294, 23547, 3640, 3618, 23295, 23548, 3641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10587, 3618, 23295, 23548, 3641, 3619, 23296, 23549, 3642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10588, 3619, 23296, 23549, 3642, 3620, 23297, 23550, 3643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10589, 3620, 23297, 23550, 3643, 3621, 23298, 23551, 3644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10590, 3621, 23298, 23551, 3644, 3622, 23299, 23552, 3645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10591, 3622, 23299, 23552, 3645, 3623, 23300, 23553, 3646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10592, 3623, 23300, 23553, 3646, 3624, 23301, 23554, 3647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10593, 3624, 23301, 23554, 3647, 369, 5010, 5021, 370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10594, 3193, 3194, 3205, 3204, 23279, 23302, 23555, 23532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10595, 23279, 23302, 23555, 23532, 23280, 23303, 23556, 23533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10596, 23280, 23303, 23556, 23533, 23281, 23304, 23557, 23534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10597, 23281, 23304, 23557, 23534, 23282, 23305, 23558, 23535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10598, 23282, 23305, 23558, 23535, 23283, 23306, 23559, 23536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10599, 23283, 23306, 23559, 23536, 23284, 23307, 23560, 23537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10600, 23284, 23307, 23560, 23537, 23285, 23308, 23561, 23538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10601, 23285, 23308, 23561, 23538, 23286, 23309, 23562, 23539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10602, 23286, 23309, 23562, 23539, 23287, 23310, 23563, 23540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10603, 23287, 23310, 23563, 23540, 23288, 23311, 23564, 23541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10604, 23288, 23311, 23564, 23541, 23289, 23312, 23565, 23542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10605, 23289, 23312, 23565, 23542, 23290, 23313, 23566, 23543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10606, 23290, 23313, 23566, 23543, 23291, 23314, 23567, 23544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10607, 23291, 23314, 23567, 23544, 23292, 23315, 23568, 23545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10608, 23292, 23315, 23568, 23545, 23293, 23316, 23569, 23546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10609, 23293, 23316, 23569, 23546, 23294, 23317, 23570, 23547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10610, 23294, 23317, 23570, 23547, 23295, 23318, 23571, 23548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10611, 23295, 23318, 23571, 23548, 23296, 23319, 23572, 23549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10612, 23296, 23319, 23572, 23549, 23297, 23320, 23573, 23550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10613, 23297, 23320, 23573, 23550, 23298, 23321, 23574, 23551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10614, 23298, 23321, 23574, 23551, 23299, 23322, 23575, 23552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10615, 23299, 23322, 23575, 23552, 23300, 23323, 23576, 23553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10616, 23300, 23323, 23576, 23553, 23301, 23324, 23577, 23554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10617, 23301, 23324, 23577, 23554, 5010, 5011, 5022, 5021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10618, 3194, 3195, 3206, 3205, 23302, 23325, 23578, 23555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10619, 23302, 23325, 23578, 23555, 23303, 23326, 23579, 23556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10620, 23303, 23326, 23579, 23556, 23304, 23327, 23580, 23557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10621, 23304, 23327, 23580, 23557, 23305, 23328, 23581, 23558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10622, 23305, 23328, 23581, 23558, 23306, 23329, 23582, 23559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10623, 23306, 23329, 23582, 23559, 23307, 23330, 23583, 23560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10624, 23307, 23330, 23583, 23560, 23308, 23331, 23584, 23561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10625, 23308, 23331, 23584, 23561, 23309, 23332, 23585, 23562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10626, 23309, 23332, 23585, 23562, 23310, 23333, 23586, 23563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10627, 23310, 23333, 23586, 23563, 23311, 23334, 23587, 23564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10628, 23311, 23334, 23587, 23564, 23312, 23335, 23588, 23565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10629, 23312, 23335, 23588, 23565, 23313, 23336, 23589, 23566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10630, 23313, 23336, 23589, 23566, 23314, 23337, 23590, 23567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10631, 23314, 23337, 23590, 23567, 23315, 23338, 23591, 23568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10632, 23315, 23338, 23591, 23568, 23316, 23339, 23592, 23569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10633, 23316, 23339, 23592, 23569, 23317, 23340, 23593, 23570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10634, 23317, 23340, 23593, 23570, 23318, 23341, 23594, 23571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10635, 23318, 23341, 23594, 23571, 23319, 23342, 23595, 23572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10636, 23319, 23342, 23595, 23572, 23320, 23343, 23596, 23573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10637, 23320, 23343, 23596, 23573, 23321, 23344, 23597, 23574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10638, 23321, 23344, 23597, 23574, 23322, 23345, 23598, 23575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10639, 23322, 23345, 23598, 23575, 23323, 23346, 23599, 23576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10640, 23323, 23346, 23599, 23576, 23324, 23347, 23600, 23577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10641, 23324, 23347, 23600, 23577, 5011, 5012, 5023, 5022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10642, 3195, 3196, 3207, 3206, 23325, 23348, 23601, 23578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10643, 23325, 23348, 23601, 23578, 23326, 23349, 23602, 23579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10644, 23326, 23349, 23602, 23579, 23327, 23350, 23603, 23580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10645, 23327, 23350, 23603, 23580, 23328, 23351, 23604, 23581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10646, 23328, 23351, 23604, 23581, 23329, 23352, 23605, 23582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10647, 23329, 23352, 23605, 23582, 23330, 23353, 23606, 23583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10648, 23330, 23353, 23606, 23583, 23331, 23354, 23607, 23584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10649, 23331, 23354, 23607, 23584, 23332, 23355, 23608, 23585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10650, 23332, 23355, 23608, 23585, 23333, 23356, 23609, 23586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10651, 23333, 23356, 23609, 23586, 23334, 23357, 23610, 23587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10652, 23334, 23357, 23610, 23587, 23335, 23358, 23611, 23588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10653, 23335, 23358, 23611, 23588, 23336, 23359, 23612, 23589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10654, 23336, 23359, 23612, 23589, 23337, 23360, 23613, 23590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10655, 23337, 23360, 23613, 23590, 23338, 23361, 23614, 23591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10656, 23338, 23361, 23614, 23591, 23339, 23362, 23615, 23592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10657, 23339, 23362, 23615, 23592, 23340, 23363, 23616, 23593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10658, 23340, 23363, 23616, 23593, 23341, 23364, 23617, 23594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10659, 23341, 23364, 23617, 23594, 23342, 23365, 23618, 23595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10660, 23342, 23365, 23618, 23595, 23343, 23366, 23619, 23596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10661, 23343, 23366, 23619, 23596, 23344, 23367, 23620, 23597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10662, 23344, 23367, 23620, 23597, 23345, 23368, 23621, 23598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10663, 23345, 23368, 23621, 23598, 23346, 23369, 23622, 23599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10664, 23346, 23369, 23622, 23599, 23347, 23370, 23623, 23600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10665, 23347, 23370, 23623, 23600, 5012, 5013, 5024, 5023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10666, 3196, 3197, 3208, 3207, 23348, 23371, 23624, 23601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10667, 23348, 23371, 23624, 23601, 23349, 23372, 23625, 23602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10668, 23349, 23372, 23625, 23602, 23350, 23373, 23626, 23603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10669, 23350, 23373, 23626, 23603, 23351, 23374, 23627, 23604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10670, 23351, 23374, 23627, 23604, 23352, 23375, 23628, 23605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10671, 23352, 23375, 23628, 23605, 23353, 23376, 23629, 23606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10672, 23353, 23376, 23629, 23606, 23354, 23377, 23630, 23607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10673, 23354, 23377, 23630, 23607, 23355, 23378, 23631, 23608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10674, 23355, 23378, 23631, 23608, 23356, 23379, 23632, 23609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10675, 23356, 23379, 23632, 23609, 23357, 23380, 23633, 23610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10676, 23357, 23380, 23633, 23610, 23358, 23381, 23634, 23611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10677, 23358, 23381, 23634, 23611, 23359, 23382, 23635, 23612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10678, 23359, 23382, 23635, 23612, 23360, 23383, 23636, 23613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10679, 23360, 23383, 23636, 23613, 23361, 23384, 23637, 23614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10680, 23361, 23384, 23637, 23614, 23362, 23385, 23638, 23615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10681, 23362, 23385, 23638, 23615, 23363, 23386, 23639, 23616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10682, 23363, 23386, 23639, 23616, 23364, 23387, 23640, 23617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10683, 23364, 23387, 23640, 23617, 23365, 23388, 23641, 23618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10684, 23365, 23388, 23641, 23618, 23366, 23389, 23642, 23619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10685, 23366, 23389, 23642, 23619, 23367, 23390, 23643, 23620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10686, 23367, 23390, 23643, 23620, 23368, 23391, 23644, 23621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10687, 23368, 23391, 23644, 23621, 23369, 23392, 23645, 23622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10688, 23369, 23392, 23645, 23622, 23370, 23393, 23646, 23623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10689, 23370, 23393, 23646, 23623, 5013, 5014, 5025, 5024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10690, 3197, 3198, 3209, 3208, 23371, 23394, 23647, 23624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10691, 23371, 23394, 23647, 23624, 23372, 23395, 23648, 23625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10692, 23372, 23395, 23648, 23625, 23373, 23396, 23649, 23626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10693, 23373, 23396, 23649, 23626, 23374, 23397, 23650, 23627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10694, 23374, 23397, 23650, 23627, 23375, 23398, 23651, 23628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10695, 23375, 23398, 23651, 23628, 23376, 23399, 23652, 23629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10696, 23376, 23399, 23652, 23629, 23377, 23400, 23653, 23630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10697, 23377, 23400, 23653, 23630, 23378, 23401, 23654, 23631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10698, 23378, 23401, 23654, 23631, 23379, 23402, 23655, 23632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10699, 23379, 23402, 23655, 23632, 23380, 23403, 23656, 23633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10700, 23380, 23403, 23656, 23633, 23381, 23404, 23657, 23634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10701, 23381, 23404, 23657, 23634, 23382, 23405, 23658, 23635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10702, 23382, 23405, 23658, 23635, 23383, 23406, 23659, 23636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10703, 23383, 23406, 23659, 23636, 23384, 23407, 23660, 23637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10704, 23384, 23407, 23660, 23637, 23385, 23408, 23661, 23638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10705, 23385, 23408, 23661, 23638, 23386, 23409, 23662, 23639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10706, 23386, 23409, 23662, 23639, 23387, 23410, 23663, 23640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10707, 23387, 23410, 23663, 23640, 23388, 23411, 23664, 23641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10708, 23388, 23411, 23664, 23641, 23389, 23412, 23665, 23642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10709, 23389, 23412, 23665, 23642, 23390, 23413, 23666, 23643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10710, 23390, 23413, 23666, 23643, 23391, 23414, 23667, 23644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10711, 23391, 23414, 23667, 23644, 23392, 23415, 23668, 23645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10712, 23392, 23415, 23668, 23645, 23393, 23416, 23669, 23646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10713, 23393, 23416, 23669, 23646, 5014, 5015, 5026, 5025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10714, 3198, 3199, 3210, 3209, 23394, 23417, 23670, 23647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10715, 23394, 23417, 23670, 23647, 23395, 23418, 23671, 23648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10716, 23395, 23418, 23671, 23648, 23396, 23419, 23672, 23649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10717, 23396, 23419, 23672, 23649, 23397, 23420, 23673, 23650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10718, 23397, 23420, 23673, 23650, 23398, 23421, 23674, 23651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10719, 23398, 23421, 23674, 23651, 23399, 23422, 23675, 23652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10720, 23399, 23422, 23675, 23652, 23400, 23423, 23676, 23653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10721, 23400, 23423, 23676, 23653, 23401, 23424, 23677, 23654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10722, 23401, 23424, 23677, 23654, 23402, 23425, 23678, 23655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10723, 23402, 23425, 23678, 23655, 23403, 23426, 23679, 23656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10724, 23403, 23426, 23679, 23656, 23404, 23427, 23680, 23657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10725, 23404, 23427, 23680, 23657, 23405, 23428, 23681, 23658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10726, 23405, 23428, 23681, 23658, 23406, 23429, 23682, 23659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10727, 23406, 23429, 23682, 23659, 23407, 23430, 23683, 23660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10728, 23407, 23430, 23683, 23660, 23408, 23431, 23684, 23661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10729, 23408, 23431, 23684, 23661, 23409, 23432, 23685, 23662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10730, 23409, 23432, 23685, 23662, 23410, 23433, 23686, 23663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10731, 23410, 23433, 23686, 23663, 23411, 23434, 23687, 23664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10732, 23411, 23434, 23687, 23664, 23412, 23435, 23688, 23665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10733, 23412, 23435, 23688, 23665, 23413, 23436, 23689, 23666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10734, 23413, 23436, 23689, 23666, 23414, 23437, 23690, 23667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10735, 23414, 23437, 23690, 23667, 23415, 23438, 23691, 23668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10736, 23415, 23438, 23691, 23668, 23416, 23439, 23692, 23669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10737, 23416, 23439, 23692, 23669, 5015, 5016, 5027, 5026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10738, 3199, 3200, 3211, 3210, 23417, 23440, 23693, 23670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10739, 23417, 23440, 23693, 23670, 23418, 23441, 23694, 23671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10740, 23418, 23441, 23694, 23671, 23419, 23442, 23695, 23672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10741, 23419, 23442, 23695, 23672, 23420, 23443, 23696, 23673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10742, 23420, 23443, 23696, 23673, 23421, 23444, 23697, 23674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10743, 23421, 23444, 23697, 23674, 23422, 23445, 23698, 23675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10744, 23422, 23445, 23698, 23675, 23423, 23446, 23699, 23676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10745, 23423, 23446, 23699, 23676, 23424, 23447, 23700, 23677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10746, 23424, 23447, 23700, 23677, 23425, 23448, 23701, 23678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10747, 23425, 23448, 23701, 23678, 23426, 23449, 23702, 23679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10748, 23426, 23449, 23702, 23679, 23427, 23450, 23703, 23680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10749, 23427, 23450, 23703, 23680, 23428, 23451, 23704, 23681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10750, 23428, 23451, 23704, 23681, 23429, 23452, 23705, 23682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10751, 23429, 23452, 23705, 23682, 23430, 23453, 23706, 23683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10752, 23430, 23453, 23706, 23683, 23431, 23454, 23707, 23684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10753, 23431, 23454, 23707, 23684, 23432, 23455, 23708, 23685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10754, 23432, 23455, 23708, 23685, 23433, 23456, 23709, 23686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10755, 23433, 23456, 23709, 23686, 23434, 23457, 23710, 23687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10756, 23434, 23457, 23710, 23687, 23435, 23458, 23711, 23688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10757, 23435, 23458, 23711, 23688, 23436, 23459, 23712, 23689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10758, 23436, 23459, 23712, 23689, 23437, 23460, 23713, 23690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10759, 23437, 23460, 23713, 23690, 23438, 23461, 23714, 23691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10760, 23438, 23461, 23714, 23691, 23439, 23462, 23715, 23692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10761, 23439, 23462, 23715, 23692, 5016, 5017, 5028, 5027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10762, 3200, 3201, 3212, 3211, 23440, 23463, 23716, 23693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10763, 23440, 23463, 23716, 23693, 23441, 23464, 23717, 23694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10764, 23441, 23464, 23717, 23694, 23442, 23465, 23718, 23695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10765, 23442, 23465, 23718, 23695, 23443, 23466, 23719, 23696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10766, 23443, 23466, 23719, 23696, 23444, 23467, 23720, 23697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10767, 23444, 23467, 23720, 23697, 23445, 23468, 23721, 23698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10768, 23445, 23468, 23721, 23698, 23446, 23469, 23722, 23699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10769, 23446, 23469, 23722, 23699, 23447, 23470, 23723, 23700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10770, 23447, 23470, 23723, 23700, 23448, 23471, 23724, 23701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10771, 23448, 23471, 23724, 23701, 23449, 23472, 23725, 23702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10772, 23449, 23472, 23725, 23702, 23450, 23473, 23726, 23703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10773, 23450, 23473, 23726, 23703, 23451, 23474, 23727, 23704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10774, 23451, 23474, 23727, 23704, 23452, 23475, 23728, 23705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10775, 23452, 23475, 23728, 23705, 23453, 23476, 23729, 23706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10776, 23453, 23476, 23729, 23706, 23454, 23477, 23730, 23707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10777, 23454, 23477, 23730, 23707, 23455, 23478, 23731, 23708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10778, 23455, 23478, 23731, 23708, 23456, 23479, 23732, 23709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10779, 23456, 23479, 23732, 23709, 23457, 23480, 23733, 23710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10780, 23457, 23480, 23733, 23710, 23458, 23481, 23734, 23711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10781, 23458, 23481, 23734, 23711, 23459, 23482, 23735, 23712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10782, 23459, 23482, 23735, 23712, 23460, 23483, 23736, 23713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10783, 23460, 23483, 23736, 23713, 23461, 23484, 23737, 23714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10784, 23461, 23484, 23737, 23714, 23462, 23485, 23738, 23715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10785, 23462, 23485, 23738, 23715, 5017, 5018, 5029, 5028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10786, 3201, 3202, 3213, 3212, 23463, 23486, 23739, 23716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10787, 23463, 23486, 23739, 23716, 23464, 23487, 23740, 23717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10788, 23464, 23487, 23740, 23717, 23465, 23488, 23741, 23718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10789, 23465, 23488, 23741, 23718, 23466, 23489, 23742, 23719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10790, 23466, 23489, 23742, 23719, 23467, 23490, 23743, 23720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10791, 23467, 23490, 23743, 23720, 23468, 23491, 23744, 23721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10792, 23468, 23491, 23744, 23721, 23469, 23492, 23745, 23722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10793, 23469, 23492, 23745, 23722, 23470, 23493, 23746, 23723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10794, 23470, 23493, 23746, 23723, 23471, 23494, 23747, 23724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10795, 23471, 23494, 23747, 23724, 23472, 23495, 23748, 23725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10796, 23472, 23495, 23748, 23725, 23473, 23496, 23749, 23726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10797, 23473, 23496, 23749, 23726, 23474, 23497, 23750, 23727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10798, 23474, 23497, 23750, 23727, 23475, 23498, 23751, 23728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10799, 23475, 23498, 23751, 23728, 23476, 23499, 23752, 23729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10800, 23476, 23499, 23752, 23729, 23477, 23500, 23753, 23730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10801, 23477, 23500, 23753, 23730, 23478, 23501, 23754, 23731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10802, 23478, 23501, 23754, 23731, 23479, 23502, 23755, 23732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10803, 23479, 23502, 23755, 23732, 23480, 23503, 23756, 23733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10804, 23480, 23503, 23756, 23733, 23481, 23504, 23757, 23734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10805, 23481, 23504, 23757, 23734, 23482, 23505, 23758, 23735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10806, 23482, 23505, 23758, 23735, 23483, 23506, 23759, 23736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10807, 23483, 23506, 23759, 23736, 23484, 23507, 23760, 23737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10808, 23484, 23507, 23760, 23737, 23485, 23508, 23761, 23738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10809, 23485, 23508, 23761, 23738, 5018, 5019, 5030, 5029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10810, 3202, 3203, 3214, 3213, 23486, 23509, 23762, 23739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10811, 23486, 23509, 23762, 23739, 23487, 23510, 23763, 23740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10812, 23487, 23510, 23763, 23740, 23488, 23511, 23764, 23741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10813, 23488, 23511, 23764, 23741, 23489, 23512, 23765, 23742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10814, 23489, 23512, 23765, 23742, 23490, 23513, 23766, 23743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10815, 23490, 23513, 23766, 23743, 23491, 23514, 23767, 23744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10816, 23491, 23514, 23767, 23744, 23492, 23515, 23768, 23745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10817, 23492, 23515, 23768, 23745, 23493, 23516, 23769, 23746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10818, 23493, 23516, 23769, 23746, 23494, 23517, 23770, 23747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10819, 23494, 23517, 23770, 23747, 23495, 23518, 23771, 23748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10820, 23495, 23518, 23771, 23748, 23496, 23519, 23772, 23749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10821, 23496, 23519, 23772, 23749, 23497, 23520, 23773, 23750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10822, 23497, 23520, 23773, 23750, 23498, 23521, 23774, 23751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10823, 23498, 23521, 23774, 23751, 23499, 23522, 23775, 23752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10824, 23499, 23522, 23775, 23752, 23500, 23523, 23776, 23753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10825, 23500, 23523, 23776, 23753, 23501, 23524, 23777, 23754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10826, 23501, 23524, 23777, 23754, 23502, 23525, 23778, 23755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10827, 23502, 23525, 23778, 23755, 23503, 23526, 23779, 23756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10828, 23503, 23526, 23779, 23756, 23504, 23527, 23780, 23757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10829, 23504, 23527, 23780, 23757, 23505, 23528, 23781, 23758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10830, 23505, 23528, 23781, 23758, 23506, 23529, 23782, 23759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10831, 23506, 23529, 23782, 23759, 23507, 23530, 23783, 23760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10832, 23507, 23530, 23783, 23760, 23508, 23531, 23784, 23761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10833, 23508, 23531, 23784, 23761, 5019, 5020, 5031, 5030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10834, 3203, 289, 290, 3214, 23509, 4384, 4407, 23762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10835, 23509, 4384, 4407, 23762, 23510, 4385, 4408, 23763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10836, 23510, 4385, 4408, 23763, 23511, 4386, 4409, 23764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10837, 23511, 4386, 4409, 23764, 23512, 4387, 4410, 23765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10838, 23512, 4387, 4410, 23765, 23513, 4388, 4411, 23766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10839, 23513, 4388, 4411, 23766, 23514, 4389, 4412, 23767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10840, 23514, 4389, 4412, 23767, 23515, 4390, 4413, 23768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10841, 23515, 4390, 4413, 23768, 23516, 4391, 4414, 23769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10842, 23516, 4391, 4414, 23769, 23517, 4392, 4415, 23770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10843, 23517, 4392, 4415, 23770, 23518, 4393, 4416, 23771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10844, 23518, 4393, 4416, 23771, 23519, 4394, 4417, 23772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10845, 23519, 4394, 4417, 23772, 23520, 4395, 4418, 23773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10846, 23520, 4395, 4418, 23773, 23521, 4396, 4419, 23774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10847, 23521, 4396, 4419, 23774, 23522, 4397, 4420, 23775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10848, 23522, 4397, 4420, 23775, 23523, 4398, 4421, 23776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10849, 23523, 4398, 4421, 23776, 23524, 4399, 4422, 23777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10850, 23524, 4399, 4422, 23777, 23525, 4400, 4423, 23778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10851, 23525, 4400, 4423, 23778, 23526, 4401, 4424, 23779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10852, 23526, 4401, 4424, 23779, 23527, 4402, 4425, 23780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10853, 23527, 4402, 4425, 23780, 23528, 4403, 4426, 23781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10854, 23528, 4403, 4426, 23781, 23529, 4404, 4427, 23782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10855, 23529, 4404, 4427, 23782, 23530, 4405, 4428, 23783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10856, 23530, 4405, 4428, 23783, 23531, 4406, 4429, 23784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10857, 23531, 4406, 4429, 23784, 5020, 449, 450, 5031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10858, 256, 3204, 3215, 257, 3625, 23532, 23785, 3648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10859, 3625, 23532, 23785, 3648, 3626, 23533, 23786, 3649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10860, 3626, 23533, 23786, 3649, 3627, 23534, 23787, 3650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10861, 3627, 23534, 23787, 3650, 3628, 23535, 23788, 3651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10862, 3628, 23535, 23788, 3651, 3629, 23536, 23789, 3652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10863, 3629, 23536, 23789, 3652, 3630, 23537, 23790, 3653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10864, 3630, 23537, 23790, 3653, 3631, 23538, 23791, 3654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10865, 3631, 23538, 23791, 3654, 3632, 23539, 23792, 3655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10866, 3632, 23539, 23792, 3655, 3633, 23540, 23793, 3656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10867, 3633, 23540, 23793, 3656, 3634, 23541, 23794, 3657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10868, 3634, 23541, 23794, 3657, 3635, 23542, 23795, 3658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10869, 3635, 23542, 23795, 3658, 3636, 23543, 23796, 3659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10870, 3636, 23543, 23796, 3659, 3637, 23544, 23797, 3660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10871, 3637, 23544, 23797, 3660, 3638, 23545, 23798, 3661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10872, 3638, 23545, 23798, 3661, 3639, 23546, 23799, 3662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10873, 3639, 23546, 23799, 3662, 3640, 23547, 23800, 3663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10874, 3640, 23547, 23800, 3663, 3641, 23548, 23801, 3664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10875, 3641, 23548, 23801, 3664, 3642, 23549, 23802, 3665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10876, 3642, 23549, 23802, 3665, 3643, 23550, 23803, 3666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10877, 3643, 23550, 23803, 3666, 3644, 23551, 23804, 3667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10878, 3644, 23551, 23804, 3667, 3645, 23552, 23805, 3668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10879, 3645, 23552, 23805, 3668, 3646, 23553, 23806, 3669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10880, 3646, 23553, 23806, 3669, 3647, 23554, 23807, 3670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10881, 3647, 23554, 23807, 3670, 370, 5021, 5032, 371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10882, 3204, 3205, 3216, 3215, 23532, 23555, 23808, 23785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10883, 23532, 23555, 23808, 23785, 23533, 23556, 23809, 23786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10884, 23533, 23556, 23809, 23786, 23534, 23557, 23810, 23787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10885, 23534, 23557, 23810, 23787, 23535, 23558, 23811, 23788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10886, 23535, 23558, 23811, 23788, 23536, 23559, 23812, 23789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10887, 23536, 23559, 23812, 23789, 23537, 23560, 23813, 23790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10888, 23537, 23560, 23813, 23790, 23538, 23561, 23814, 23791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10889, 23538, 23561, 23814, 23791, 23539, 23562, 23815, 23792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10890, 23539, 23562, 23815, 23792, 23540, 23563, 23816, 23793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10891, 23540, 23563, 23816, 23793, 23541, 23564, 23817, 23794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10892, 23541, 23564, 23817, 23794, 23542, 23565, 23818, 23795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10893, 23542, 23565, 23818, 23795, 23543, 23566, 23819, 23796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10894, 23543, 23566, 23819, 23796, 23544, 23567, 23820, 23797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10895, 23544, 23567, 23820, 23797, 23545, 23568, 23821, 23798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10896, 23545, 23568, 23821, 23798, 23546, 23569, 23822, 23799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10897, 23546, 23569, 23822, 23799, 23547, 23570, 23823, 23800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10898, 23547, 23570, 23823, 23800, 23548, 23571, 23824, 23801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10899, 23548, 23571, 23824, 23801, 23549, 23572, 23825, 23802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10900, 23549, 23572, 23825, 23802, 23550, 23573, 23826, 23803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10901, 23550, 23573, 23826, 23803, 23551, 23574, 23827, 23804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10902, 23551, 23574, 23827, 23804, 23552, 23575, 23828, 23805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10903, 23552, 23575, 23828, 23805, 23553, 23576, 23829, 23806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10904, 23553, 23576, 23829, 23806, 23554, 23577, 23830, 23807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10905, 23554, 23577, 23830, 23807, 5021, 5022, 5033, 5032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10906, 3205, 3206, 3217, 3216, 23555, 23578, 23831, 23808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10907, 23555, 23578, 23831, 23808, 23556, 23579, 23832, 23809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10908, 23556, 23579, 23832, 23809, 23557, 23580, 23833, 23810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10909, 23557, 23580, 23833, 23810, 23558, 23581, 23834, 23811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10910, 23558, 23581, 23834, 23811, 23559, 23582, 23835, 23812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10911, 23559, 23582, 23835, 23812, 23560, 23583, 23836, 23813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10912, 23560, 23583, 23836, 23813, 23561, 23584, 23837, 23814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10913, 23561, 23584, 23837, 23814, 23562, 23585, 23838, 23815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10914, 23562, 23585, 23838, 23815, 23563, 23586, 23839, 23816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10915, 23563, 23586, 23839, 23816, 23564, 23587, 23840, 23817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10916, 23564, 23587, 23840, 23817, 23565, 23588, 23841, 23818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10917, 23565, 23588, 23841, 23818, 23566, 23589, 23842, 23819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10918, 23566, 23589, 23842, 23819, 23567, 23590, 23843, 23820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10919, 23567, 23590, 23843, 23820, 23568, 23591, 23844, 23821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10920, 23568, 23591, 23844, 23821, 23569, 23592, 23845, 23822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10921, 23569, 23592, 23845, 23822, 23570, 23593, 23846, 23823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10922, 23570, 23593, 23846, 23823, 23571, 23594, 23847, 23824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10923, 23571, 23594, 23847, 23824, 23572, 23595, 23848, 23825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10924, 23572, 23595, 23848, 23825, 23573, 23596, 23849, 23826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10925, 23573, 23596, 23849, 23826, 23574, 23597, 23850, 23827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10926, 23574, 23597, 23850, 23827, 23575, 23598, 23851, 23828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10927, 23575, 23598, 23851, 23828, 23576, 23599, 23852, 23829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10928, 23576, 23599, 23852, 23829, 23577, 23600, 23853, 23830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10929, 23577, 23600, 23853, 23830, 5022, 5023, 5034, 5033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10930, 3206, 3207, 3218, 3217, 23578, 23601, 23854, 23831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10931, 23578, 23601, 23854, 23831, 23579, 23602, 23855, 23832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10932, 23579, 23602, 23855, 23832, 23580, 23603, 23856, 23833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10933, 23580, 23603, 23856, 23833, 23581, 23604, 23857, 23834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10934, 23581, 23604, 23857, 23834, 23582, 23605, 23858, 23835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10935, 23582, 23605, 23858, 23835, 23583, 23606, 23859, 23836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10936, 23583, 23606, 23859, 23836, 23584, 23607, 23860, 23837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10937, 23584, 23607, 23860, 23837, 23585, 23608, 23861, 23838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10938, 23585, 23608, 23861, 23838, 23586, 23609, 23862, 23839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10939, 23586, 23609, 23862, 23839, 23587, 23610, 23863, 23840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10940, 23587, 23610, 23863, 23840, 23588, 23611, 23864, 23841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10941, 23588, 23611, 23864, 23841, 23589, 23612, 23865, 23842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10942, 23589, 23612, 23865, 23842, 23590, 23613, 23866, 23843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10943, 23590, 23613, 23866, 23843, 23591, 23614, 23867, 23844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10944, 23591, 23614, 23867, 23844, 23592, 23615, 23868, 23845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10945, 23592, 23615, 23868, 23845, 23593, 23616, 23869, 23846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10946, 23593, 23616, 23869, 23846, 23594, 23617, 23870, 23847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10947, 23594, 23617, 23870, 23847, 23595, 23618, 23871, 23848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10948, 23595, 23618, 23871, 23848, 23596, 23619, 23872, 23849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10949, 23596, 23619, 23872, 23849, 23597, 23620, 23873, 23850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10950, 23597, 23620, 23873, 23850, 23598, 23621, 23874, 23851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10951, 23598, 23621, 23874, 23851, 23599, 23622, 23875, 23852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10952, 23599, 23622, 23875, 23852, 23600, 23623, 23876, 23853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10953, 23600, 23623, 23876, 23853, 5023, 5024, 5035, 5034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10954, 3207, 3208, 3219, 3218, 23601, 23624, 23877, 23854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10955, 23601, 23624, 23877, 23854, 23602, 23625, 23878, 23855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10956, 23602, 23625, 23878, 23855, 23603, 23626, 23879, 23856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10957, 23603, 23626, 23879, 23856, 23604, 23627, 23880, 23857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10958, 23604, 23627, 23880, 23857, 23605, 23628, 23881, 23858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10959, 23605, 23628, 23881, 23858, 23606, 23629, 23882, 23859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10960, 23606, 23629, 23882, 23859, 23607, 23630, 23883, 23860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10961, 23607, 23630, 23883, 23860, 23608, 23631, 23884, 23861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10962, 23608, 23631, 23884, 23861, 23609, 23632, 23885, 23862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10963, 23609, 23632, 23885, 23862, 23610, 23633, 23886, 23863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10964, 23610, 23633, 23886, 23863, 23611, 23634, 23887, 23864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10965, 23611, 23634, 23887, 23864, 23612, 23635, 23888, 23865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10966, 23612, 23635, 23888, 23865, 23613, 23636, 23889, 23866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10967, 23613, 23636, 23889, 23866, 23614, 23637, 23890, 23867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10968, 23614, 23637, 23890, 23867, 23615, 23638, 23891, 23868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10969, 23615, 23638, 23891, 23868, 23616, 23639, 23892, 23869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10970, 23616, 23639, 23892, 23869, 23617, 23640, 23893, 23870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10971, 23617, 23640, 23893, 23870, 23618, 23641, 23894, 23871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10972, 23618, 23641, 23894, 23871, 23619, 23642, 23895, 23872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10973, 23619, 23642, 23895, 23872, 23620, 23643, 23896, 23873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10974, 23620, 23643, 23896, 23873, 23621, 23644, 23897, 23874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10975, 23621, 23644, 23897, 23874, 23622, 23645, 23898, 23875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10976, 23622, 23645, 23898, 23875, 23623, 23646, 23899, 23876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10977, 23623, 23646, 23899, 23876, 5024, 5025, 5036, 5035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10978, 3208, 3209, 3220, 3219, 23624, 23647, 23900, 23877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10979, 23624, 23647, 23900, 23877, 23625, 23648, 23901, 23878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10980, 23625, 23648, 23901, 23878, 23626, 23649, 23902, 23879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10981, 23626, 23649, 23902, 23879, 23627, 23650, 23903, 23880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10982, 23627, 23650, 23903, 23880, 23628, 23651, 23904, 23881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10983, 23628, 23651, 23904, 23881, 23629, 23652, 23905, 23882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10984, 23629, 23652, 23905, 23882, 23630, 23653, 23906, 23883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10985, 23630, 23653, 23906, 23883, 23631, 23654, 23907, 23884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10986, 23631, 23654, 23907, 23884, 23632, 23655, 23908, 23885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10987, 23632, 23655, 23908, 23885, 23633, 23656, 23909, 23886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10988, 23633, 23656, 23909, 23886, 23634, 23657, 23910, 23887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10989, 23634, 23657, 23910, 23887, 23635, 23658, 23911, 23888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10990, 23635, 23658, 23911, 23888, 23636, 23659, 23912, 23889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10991, 23636, 23659, 23912, 23889, 23637, 23660, 23913, 23890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10992, 23637, 23660, 23913, 23890, 23638, 23661, 23914, 23891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10993, 23638, 23661, 23914, 23891, 23639, 23662, 23915, 23892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10994, 23639, 23662, 23915, 23892, 23640, 23663, 23916, 23893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10995, 23640, 23663, 23916, 23893, 23641, 23664, 23917, 23894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10996, 23641, 23664, 23917, 23894, 23642, 23665, 23918, 23895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10997, 23642, 23665, 23918, 23895, 23643, 23666, 23919, 23896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10998, 23643, 23666, 23919, 23896, 23644, 23667, 23920, 23897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
10999, 23644, 23667, 23920, 23897, 23645, 23668, 23921, 23898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11000, 23645, 23668, 23921, 23898, 23646, 23669, 23922, 23899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11001, 23646, 23669, 23922, 23899, 5025, 5026, 5037, 5036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11002, 3209, 3210, 3221, 3220, 23647, 23670, 23923, 23900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11003, 23647, 23670, 23923, 23900, 23648, 23671, 23924, 23901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11004, 23648, 23671, 23924, 23901, 23649, 23672, 23925, 23902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11005, 23649, 23672, 23925, 23902, 23650, 23673, 23926, 23903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11006, 23650, 23673, 23926, 23903, 23651, 23674, 23927, 23904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11007, 23651, 23674, 23927, 23904, 23652, 23675, 23928, 23905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11008, 23652, 23675, 23928, 23905, 23653, 23676, 23929, 23906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11009, 23653, 23676, 23929, 23906, 23654, 23677, 23930, 23907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11010, 23654, 23677, 23930, 23907, 23655, 23678, 23931, 23908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11011, 23655, 23678, 23931, 23908, 23656, 23679, 23932, 23909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11012, 23656, 23679, 23932, 23909, 23657, 23680, 23933, 23910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11013, 23657, 23680, 23933, 23910, 23658, 23681, 23934, 23911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11014, 23658, 23681, 23934, 23911, 23659, 23682, 23935, 23912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11015, 23659, 23682, 23935, 23912, 23660, 23683, 23936, 23913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11016, 23660, 23683, 23936, 23913, 23661, 23684, 23937, 23914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11017, 23661, 23684, 23937, 23914, 23662, 23685, 23938, 23915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11018, 23662, 23685, 23938, 23915, 23663, 23686, 23939, 23916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11019, 23663, 23686, 23939, 23916, 23664, 23687, 23940, 23917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11020, 23664, 23687, 23940, 23917, 23665, 23688, 23941, 23918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11021, 23665, 23688, 23941, 23918, 23666, 23689, 23942, 23919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11022, 23666, 23689, 23942, 23919, 23667, 23690, 23943, 23920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11023, 23667, 23690, 23943, 23920, 23668, 23691, 23944, 23921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11024, 23668, 23691, 23944, 23921, 23669, 23692, 23945, 23922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11025, 23669, 23692, 23945, 23922, 5026, 5027, 5038, 5037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11026, 3210, 3211, 3222, 3221, 23670, 23693, 23946, 23923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11027, 23670, 23693, 23946, 23923, 23671, 23694, 23947, 23924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11028, 23671, 23694, 23947, 23924, 23672, 23695, 23948, 23925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11029, 23672, 23695, 23948, 23925, 23673, 23696, 23949, 23926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11030, 23673, 23696, 23949, 23926, 23674, 23697, 23950, 23927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11031, 23674, 23697, 23950, 23927, 23675, 23698, 23951, 23928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11032, 23675, 23698, 23951, 23928, 23676, 23699, 23952, 23929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11033, 23676, 23699, 23952, 23929, 23677, 23700, 23953, 23930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11034, 23677, 23700, 23953, 23930, 23678, 23701, 23954, 23931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11035, 23678, 23701, 23954, 23931, 23679, 23702, 23955, 23932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11036, 23679, 23702, 23955, 23932, 23680, 23703, 23956, 23933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11037, 23680, 23703, 23956, 23933, 23681, 23704, 23957, 23934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11038, 23681, 23704, 23957, 23934, 23682, 23705, 23958, 23935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11039, 23682, 23705, 23958, 23935, 23683, 23706, 23959, 23936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11040, 23683, 23706, 23959, 23936, 23684, 23707, 23960, 23937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11041, 23684, 23707, 23960, 23937, 23685, 23708, 23961, 23938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11042, 23685, 23708, 23961, 23938, 23686, 23709, 23962, 23939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11043, 23686, 23709, 23962, 23939, 23687, 23710, 23963, 23940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11044, 23687, 23710, 23963, 23940, 23688, 23711, 23964, 23941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11045, 23688, 23711, 23964, 23941, 23689, 23712, 23965, 23942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11046, 23689, 23712, 23965, 23942, 23690, 23713, 23966, 23943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11047, 23690, 23713, 23966, 23943, 23691, 23714, 23967, 23944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11048, 23691, 23714, 23967, 23944, 23692, 23715, 23968, 23945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11049, 23692, 23715, 23968, 23945, 5027, 5028, 5039, 5038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11050, 3211, 3212, 3223, 3222, 23693, 23716, 23969, 23946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11051, 23693, 23716, 23969, 23946, 23694, 23717, 23970, 23947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11052, 23694, 23717, 23970, 23947, 23695, 23718, 23971, 23948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11053, 23695, 23718, 23971, 23948, 23696, 23719, 23972, 23949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11054, 23696, 23719, 23972, 23949, 23697, 23720, 23973, 23950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11055, 23697, 23720, 23973, 23950, 23698, 23721, 23974, 23951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11056, 23698, 23721, 23974, 23951, 23699, 23722, 23975, 23952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11057, 23699, 23722, 23975, 23952, 23700, 23723, 23976, 23953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11058, 23700, 23723, 23976, 23953, 23701, 23724, 23977, 23954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11059, 23701, 23724, 23977, 23954, 23702, 23725, 23978, 23955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11060, 23702, 23725, 23978, 23955, 23703, 23726, 23979, 23956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11061, 23703, 23726, 23979, 23956, 23704, 23727, 23980, 23957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11062, 23704, 23727, 23980, 23957, 23705, 23728, 23981, 23958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11063, 23705, 23728, 23981, 23958, 23706, 23729, 23982, 23959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11064, 23706, 23729, 23982, 23959, 23707, 23730, 23983, 23960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11065, 23707, 23730, 23983, 23960, 23708, 23731, 23984, 23961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11066, 23708, 23731, 23984, 23961, 23709, 23732, 23985, 23962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11067, 23709, 23732, 23985, 23962, 23710, 23733, 23986, 23963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11068, 23710, 23733, 23986, 23963, 23711, 23734, 23987, 23964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11069, 23711, 23734, 23987, 23964, 23712, 23735, 23988, 23965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11070, 23712, 23735, 23988, 23965, 23713, 23736, 23989, 23966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11071, 23713, 23736, 23989, 23966, 23714, 23737, 23990, 23967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11072, 23714, 23737, 23990, 23967, 23715, 23738, 23991, 23968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11073, 23715, 23738, 23991, 23968, 5028, 5029, 5040, 5039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11074, 3212, 3213, 3224, 3223, 23716, 23739, 23992, 23969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11075, 23716, 23739, 23992, 23969, 23717, 23740, 23993, 23970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11076, 23717, 23740, 23993, 23970, 23718, 23741, 23994, 23971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11077, 23718, 23741, 23994, 23971, 23719, 23742, 23995, 23972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11078, 23719, 23742, 23995, 23972, 23720, 23743, 23996, 23973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11079, 23720, 23743, 23996, 23973, 23721, 23744, 23997, 23974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11080, 23721, 23744, 23997, 23974, 23722, 23745, 23998, 23975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11081, 23722, 23745, 23998, 23975, 23723, 23746, 23999, 23976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11082, 23723, 23746, 23999, 23976, 23724, 23747, 24000, 23977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11083, 23724, 23747, 24000, 23977, 23725, 23748, 24001, 23978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11084, 23725, 23748, 24001, 23978, 23726, 23749, 24002, 23979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11085, 23726, 23749, 24002, 23979, 23727, 23750, 24003, 23980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11086, 23727, 23750, 24003, 23980, 23728, 23751, 24004, 23981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11087, 23728, 23751, 24004, 23981, 23729, 23752, 24005, 23982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11088, 23729, 23752, 24005, 23982, 23730, 23753, 24006, 23983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11089, 23730, 23753, 24006, 23983, 23731, 23754, 24007, 23984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11090, 23731, 23754, 24007, 23984, 23732, 23755, 24008, 23985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11091, 23732, 23755, 24008, 23985, 23733, 23756, 24009, 23986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11092, 23733, 23756, 24009, 23986, 23734, 23757, 24010, 23987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11093, 23734, 23757, 24010, 23987, 23735, 23758, 24011, 23988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11094, 23735, 23758, 24011, 23988, 23736, 23759, 24012, 23989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11095, 23736, 23759, 24012, 23989, 23737, 23760, 24013, 23990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11096, 23737, 23760, 24013, 23990, 23738, 23761, 24014, 23991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11097, 23738, 23761, 24014, 23991, 5029, 5030, 5041, 5040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11098, 3213, 3214, 3225, 3224, 23739, 23762, 24015, 23992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11099, 23739, 23762, 24015, 23992, 23740, 23763, 24016, 23993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11100, 23740, 23763, 24016, 23993, 23741, 23764, 24017, 23994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11101, 23741, 23764, 24017, 23994, 23742, 23765, 24018, 23995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11102, 23742, 23765, 24018, 23995, 23743, 23766, 24019, 23996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11103, 23743, 23766, 24019, 23996, 23744, 23767, 24020, 23997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11104, 23744, 23767, 24020, 23997, 23745, 23768, 24021, 23998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11105, 23745, 23768, 24021, 23998, 23746, 23769, 24022, 23999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11106, 23746, 23769, 24022, 23999, 23747, 23770, 24023, 24000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11107, 23747, 23770, 24023, 24000, 23748, 23771, 24024, 24001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11108, 23748, 23771, 24024, 24001, 23749, 23772, 24025, 24002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11109, 23749, 23772, 24025, 24002, 23750, 23773, 24026, 24003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11110, 23750, 23773, 24026, 24003, 23751, 23774, 24027, 24004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11111, 23751, 23774, 24027, 24004, 23752, 23775, 24028, 24005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11112, 23752, 23775, 24028, 24005, 23753, 23776, 24029, 24006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11113, 23753, 23776, 24029, 24006, 23754, 23777, 24030, 24007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11114, 23754, 23777, 24030, 24007, 23755, 23778, 24031, 24008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11115, 23755, 23778, 24031, 24008, 23756, 23779, 24032, 24009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11116, 23756, 23779, 24032, 24009, 23757, 23780, 24033, 24010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11117, 23757, 23780, 24033, 24010, 23758, 23781, 24034, 24011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11118, 23758, 23781, 24034, 24011, 23759, 23782, 24035, 24012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11119, 23759, 23782, 24035, 24012, 23760, 23783, 24036, 24013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11120, 23760, 23783, 24036, 24013, 23761, 23784, 24037, 24014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11121, 23761, 23784, 24037, 24014, 5030, 5031, 5042, 5041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11122, 3214, 290, 291, 3225, 23762, 4407, 4430, 24015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11123, 23762, 4407, 4430, 24015, 23763, 4408, 4431, 24016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11124, 23763, 4408, 4431, 24016, 23764, 4409, 4432, 24017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11125, 23764, 4409, 4432, 24017, 23765, 4410, 4433, 24018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11126, 23765, 4410, 4433, 24018, 23766, 4411, 4434, 24019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11127, 23766, 4411, 4434, 24019, 23767, 4412, 4435, 24020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11128, 23767, 4412, 4435, 24020, 23768, 4413, 4436, 24021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11129, 23768, 4413, 4436, 24021, 23769, 4414, 4437, 24022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11130, 23769, 4414, 4437, 24022, 23770, 4415, 4438, 24023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11131, 23770, 4415, 4438, 24023, 23771, 4416, 4439, 24024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11132, 23771, 4416, 4439, 24024, 23772, 4417, 4440, 24025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11133, 23772, 4417, 4440, 24025, 23773, 4418, 4441, 24026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11134, 23773, 4418, 4441, 24026, 23774, 4419, 4442, 24027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11135, 23774, 4419, 4442, 24027, 23775, 4420, 4443, 24028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11136, 23775, 4420, 4443, 24028, 23776, 4421, 4444, 24029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11137, 23776, 4421, 4444, 24029, 23777, 4422, 4445, 24030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11138, 23777, 4422, 4445, 24030, 23778, 4423, 4446, 24031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11139, 23778, 4423, 4446, 24031, 23779, 4424, 4447, 24032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11140, 23779, 4424, 4447, 24032, 23780, 4425, 4448, 24033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11141, 23780, 4425, 4448, 24033, 23781, 4426, 4449, 24034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11142, 23781, 4426, 4449, 24034, 23782, 4427, 4450, 24035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11143, 23782, 4427, 4450, 24035, 23783, 4428, 4451, 24036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11144, 23783, 4428, 4451, 24036, 23784, 4429, 4452, 24037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11145, 23784, 4429, 4452, 24037, 5031, 450, 451, 5042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11146, 257, 3215, 3226, 258, 3648, 23785, 24038, 3671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11147, 3648, 23785, 24038, 3671, 3649, 23786, 24039, 3672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11148, 3649, 23786, 24039, 3672, 3650, 23787, 24040, 3673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11149, 3650, 23787, 24040, 3673, 3651, 23788, 24041, 3674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11150, 3651, 23788, 24041, 3674, 3652, 23789, 24042, 3675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11151, 3652, 23789, 24042, 3675, 3653, 23790, 24043, 3676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11152, 3653, 23790, 24043, 3676, 3654, 23791, 24044, 3677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11153, 3654, 23791, 24044, 3677, 3655, 23792, 24045, 3678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11154, 3655, 23792, 24045, 3678, 3656, 23793, 24046, 3679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11155, 3656, 23793, 24046, 3679, 3657, 23794, 24047, 3680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11156, 3657, 23794, 24047, 3680, 3658, 23795, 24048, 3681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11157, 3658, 23795, 24048, 3681, 3659, 23796, 24049, 3682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11158, 3659, 23796, 24049, 3682, 3660, 23797, 24050, 3683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11159, 3660, 23797, 24050, 3683, 3661, 23798, 24051, 3684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11160, 3661, 23798, 24051, 3684, 3662, 23799, 24052, 3685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11161, 3662, 23799, 24052, 3685, 3663, 23800, 24053, 3686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11162, 3663, 23800, 24053, 3686, 3664, 23801, 24054, 3687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11163, 3664, 23801, 24054, 3687, 3665, 23802, 24055, 3688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11164, 3665, 23802, 24055, 3688, 3666, 23803, 24056, 3689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11165, 3666, 23803, 24056, 3689, 3667, 23804, 24057, 3690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11166, 3667, 23804, 24057, 3690, 3668, 23805, 24058, 3691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11167, 3668, 23805, 24058, 3691, 3669, 23806, 24059, 3692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11168, 3669, 23806, 24059, 3692, 3670, 23807, 24060, 3693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11169, 3670, 23807, 24060, 3693, 371, 5032, 5043, 372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11170, 3215, 3216, 3227, 3226, 23785, 23808, 24061, 24038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11171, 23785, 23808, 24061, 24038, 23786, 23809, 24062, 24039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11172, 23786, 23809, 24062, 24039, 23787, 23810, 24063, 24040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11173, 23787, 23810, 24063, 24040, 23788, 23811, 24064, 24041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11174, 23788, 23811, 24064, 24041, 23789, 23812, 24065, 24042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11175, 23789, 23812, 24065, 24042, 23790, 23813, 24066, 24043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11176, 23790, 23813, 24066, 24043, 23791, 23814, 24067, 24044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11177, 23791, 23814, 24067, 24044, 23792, 23815, 24068, 24045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11178, 23792, 23815, 24068, 24045, 23793, 23816, 24069, 24046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11179, 23793, 23816, 24069, 24046, 23794, 23817, 24070, 24047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11180, 23794, 23817, 24070, 24047, 23795, 23818, 24071, 24048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11181, 23795, 23818, 24071, 24048, 23796, 23819, 24072, 24049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11182, 23796, 23819, 24072, 24049, 23797, 23820, 24073, 24050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11183, 23797, 23820, 24073, 24050, 23798, 23821, 24074, 24051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11184, 23798, 23821, 24074, 24051, 23799, 23822, 24075, 24052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11185, 23799, 23822, 24075, 24052, 23800, 23823, 24076, 24053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11186, 23800, 23823, 24076, 24053, 23801, 23824, 24077, 24054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11187, 23801, 23824, 24077, 24054, 23802, 23825, 24078, 24055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11188, 23802, 23825, 24078, 24055, 23803, 23826, 24079, 24056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11189, 23803, 23826, 24079, 24056, 23804, 23827, 24080, 24057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11190, 23804, 23827, 24080, 24057, 23805, 23828, 24081, 24058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11191, 23805, 23828, 24081, 24058, 23806, 23829, 24082, 24059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11192, 23806, 23829, 24082, 24059, 23807, 23830, 24083, 24060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11193, 23807, 23830, 24083, 24060, 5032, 5033, 5044, 5043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11194, 3216, 3217, 3228, 3227, 23808, 23831, 24084, 24061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11195, 23808, 23831, 24084, 24061, 23809, 23832, 24085, 24062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11196, 23809, 23832, 24085, 24062, 23810, 23833, 24086, 24063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11197, 23810, 23833, 24086, 24063, 23811, 23834, 24087, 24064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11198, 23811, 23834, 24087, 24064, 23812, 23835, 24088, 24065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11199, 23812, 23835, 24088, 24065, 23813, 23836, 24089, 24066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11200, 23813, 23836, 24089, 24066, 23814, 23837, 24090, 24067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11201, 23814, 23837, 24090, 24067, 23815, 23838, 24091, 24068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11202, 23815, 23838, 24091, 24068, 23816, 23839, 24092, 24069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11203, 23816, 23839, 24092, 24069, 23817, 23840, 24093, 24070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11204, 23817, 23840, 24093, 24070, 23818, 23841, 24094, 24071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11205, 23818, 23841, 24094, 24071, 23819, 23842, 24095, 24072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11206, 23819, 23842, 24095, 24072, 23820, 23843, 24096, 24073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11207, 23820, 23843, 24096, 24073, 23821, 23844, 24097, 24074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11208, 23821, 23844, 24097, 24074, 23822, 23845, 24098, 24075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11209, 23822, 23845, 24098, 24075, 23823, 23846, 24099, 24076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11210, 23823, 23846, 24099, 24076, 23824, 23847, 24100, 24077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11211, 23824, 23847, 24100, 24077, 23825, 23848, 24101, 24078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11212, 23825, 23848, 24101, 24078, 23826, 23849, 24102, 24079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11213, 23826, 23849, 24102, 24079, 23827, 23850, 24103, 24080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11214, 23827, 23850, 24103, 24080, 23828, 23851, 24104, 24081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11215, 23828, 23851, 24104, 24081, 23829, 23852, 24105, 24082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11216, 23829, 23852, 24105, 24082, 23830, 23853, 24106, 24083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11217, 23830, 23853, 24106, 24083, 5033, 5034, 5045, 5044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11218, 3217, 3218, 3229, 3228, 23831, 23854, 24107, 24084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11219, 23831, 23854, 24107, 24084, 23832, 23855, 24108, 24085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11220, 23832, 23855, 24108, 24085, 23833, 23856, 24109, 24086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11221, 23833, 23856, 24109, 24086, 23834, 23857, 24110, 24087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11222, 23834, 23857, 24110, 24087, 23835, 23858, 24111, 24088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11223, 23835, 23858, 24111, 24088, 23836, 23859, 24112, 24089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11224, 23836, 23859, 24112, 24089, 23837, 23860, 24113, 24090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11225, 23837, 23860, 24113, 24090, 23838, 23861, 24114, 24091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11226, 23838, 23861, 24114, 24091, 23839, 23862, 24115, 24092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11227, 23839, 23862, 24115, 24092, 23840, 23863, 24116, 24093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11228, 23840, 23863, 24116, 24093, 23841, 23864, 24117, 24094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11229, 23841, 23864, 24117, 24094, 23842, 23865, 24118, 24095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11230, 23842, 23865, 24118, 24095, 23843, 23866, 24119, 24096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11231, 23843, 23866, 24119, 24096, 23844, 23867, 24120, 24097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11232, 23844, 23867, 24120, 24097, 23845, 23868, 24121, 24098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11233, 23845, 23868, 24121, 24098, 23846, 23869, 24122, 24099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11234, 23846, 23869, 24122, 24099, 23847, 23870, 24123, 24100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11235, 23847, 23870, 24123, 24100, 23848, 23871, 24124, 24101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11236, 23848, 23871, 24124, 24101, 23849, 23872, 24125, 24102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11237, 23849, 23872, 24125, 24102, 23850, 23873, 24126, 24103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11238, 23850, 23873, 24126, 24103, 23851, 23874, 24127, 24104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11239, 23851, 23874, 24127, 24104, 23852, 23875, 24128, 24105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11240, 23852, 23875, 24128, 24105, 23853, 23876, 24129, 24106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11241, 23853, 23876, 24129, 24106, 5034, 5035, 5046, 5045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11242, 3218, 3219, 3230, 3229, 23854, 23877, 24130, 24107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11243, 23854, 23877, 24130, 24107, 23855, 23878, 24131, 24108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11244, 23855, 23878, 24131, 24108, 23856, 23879, 24132, 24109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11245, 23856, 23879, 24132, 24109, 23857, 23880, 24133, 24110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11246, 23857, 23880, 24133, 24110, 23858, 23881, 24134, 24111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11247, 23858, 23881, 24134, 24111, 23859, 23882, 24135, 24112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11248, 23859, 23882, 24135, 24112, 23860, 23883, 24136, 24113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11249, 23860, 23883, 24136, 24113, 23861, 23884, 24137, 24114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11250, 23861, 23884, 24137, 24114, 23862, 23885, 24138, 24115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11251, 23862, 23885, 24138, 24115, 23863, 23886, 24139, 24116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11252, 23863, 23886, 24139, 24116, 23864, 23887, 24140, 24117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11253, 23864, 23887, 24140, 24117, 23865, 23888, 24141, 24118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11254, 23865, 23888, 24141, 24118, 23866, 23889, 24142, 24119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11255, 23866, 23889, 24142, 24119, 23867, 23890, 24143, 24120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11256, 23867, 23890, 24143, 24120, 23868, 23891, 24144, 24121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11257, 23868, 23891, 24144, 24121, 23869, 23892, 24145, 24122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11258, 23869, 23892, 24145, 24122, 23870, 23893, 24146, 24123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11259, 23870, 23893, 24146, 24123, 23871, 23894, 24147, 24124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11260, 23871, 23894, 24147, 24124, 23872, 23895, 24148, 24125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11261, 23872, 23895, 24148, 24125, 23873, 23896, 24149, 24126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11262, 23873, 23896, 24149, 24126, 23874, 23897, 24150, 24127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11263, 23874, 23897, 24150, 24127, 23875, 23898, 24151, 24128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11264, 23875, 23898, 24151, 24128, 23876, 23899, 24152, 24129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11265, 23876, 23899, 24152, 24129, 5035, 5036, 5047, 5046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11266, 3219, 3220, 3231, 3230, 23877, 23900, 24153, 24130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11267, 23877, 23900, 24153, 24130, 23878, 23901, 24154, 24131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11268, 23878, 23901, 24154, 24131, 23879, 23902, 24155, 24132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11269, 23879, 23902, 24155, 24132, 23880, 23903, 24156, 24133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11270, 23880, 23903, 24156, 24133, 23881, 23904, 24157, 24134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11271, 23881, 23904, 24157, 24134, 23882, 23905, 24158, 24135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11272, 23882, 23905, 24158, 24135, 23883, 23906, 24159, 24136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11273, 23883, 23906, 24159, 24136, 23884, 23907, 24160, 24137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11274, 23884, 23907, 24160, 24137, 23885, 23908, 24161, 24138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11275, 23885, 23908, 24161, 24138, 23886, 23909, 24162, 24139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11276, 23886, 23909, 24162, 24139, 23887, 23910, 24163, 24140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11277, 23887, 23910, 24163, 24140, 23888, 23911, 24164, 24141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11278, 23888, 23911, 24164, 24141, 23889, 23912, 24165, 24142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11279, 23889, 23912, 24165, 24142, 23890, 23913, 24166, 24143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11280, 23890, 23913, 24166, 24143, 23891, 23914, 24167, 24144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11281, 23891, 23914, 24167, 24144, 23892, 23915, 24168, 24145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11282, 23892, 23915, 24168, 24145, 23893, 23916, 24169, 24146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11283, 23893, 23916, 24169, 24146, 23894, 23917, 24170, 24147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11284, 23894, 23917, 24170, 24147, 23895, 23918, 24171, 24148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11285, 23895, 23918, 24171, 24148, 23896, 23919, 24172, 24149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11286, 23896, 23919, 24172, 24149, 23897, 23920, 24173, 24150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11287, 23897, 23920, 24173, 24150, 23898, 23921, 24174, 24151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11288, 23898, 23921, 24174, 24151, 23899, 23922, 24175, 24152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11289, 23899, 23922, 24175, 24152, 5036, 5037, 5048, 5047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11290, 3220, 3221, 3232, 3231, 23900, 23923, 24176, 24153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11291, 23900, 23923, 24176, 24153, 23901, 23924, 24177, 24154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11292, 23901, 23924, 24177, 24154, 23902, 23925, 24178, 24155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11293, 23902, 23925, 24178, 24155, 23903, 23926, 24179, 24156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11294, 23903, 23926, 24179, 24156, 23904, 23927, 24180, 24157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11295, 23904, 23927, 24180, 24157, 23905, 23928, 24181, 24158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11296, 23905, 23928, 24181, 24158, 23906, 23929, 24182, 24159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11297, 23906, 23929, 24182, 24159, 23907, 23930, 24183, 24160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11298, 23907, 23930, 24183, 24160, 23908, 23931, 24184, 24161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11299, 23908, 23931, 24184, 24161, 23909, 23932, 24185, 24162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11300, 23909, 23932, 24185, 24162, 23910, 23933, 24186, 24163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11301, 23910, 23933, 24186, 24163, 23911, 23934, 24187, 24164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11302, 23911, 23934, 24187, 24164, 23912, 23935, 24188, 24165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11303, 23912, 23935, 24188, 24165, 23913, 23936, 24189, 24166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11304, 23913, 23936, 24189, 24166, 23914, 23937, 24190, 24167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11305, 23914, 23937, 24190, 24167, 23915, 23938, 24191, 24168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11306, 23915, 23938, 24191, 24168, 23916, 23939, 24192, 24169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11307, 23916, 23939, 24192, 24169, 23917, 23940, 24193, 24170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11308, 23917, 23940, 24193, 24170, 23918, 23941, 24194, 24171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11309, 23918, 23941, 24194, 24171, 23919, 23942, 24195, 24172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11310, 23919, 23942, 24195, 24172, 23920, 23943, 24196, 24173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11311, 23920, 23943, 24196, 24173, 23921, 23944, 24197, 24174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11312, 23921, 23944, 24197, 24174, 23922, 23945, 24198, 24175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11313, 23922, 23945, 24198, 24175, 5037, 5038, 5049, 5048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11314, 3221, 3222, 3233, 3232, 23923, 23946, 24199, 24176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11315, 23923, 23946, 24199, 24176, 23924, 23947, 24200, 24177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11316, 23924, 23947, 24200, 24177, 23925, 23948, 24201, 24178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
11317, 23925, 23948, 24201, 24178, 23926, 23949, 24202, 24179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
