9674, 9670, 34142, 34305, 9675
23496, 9634, 33166, 33212, 9636, 1184, 9875, 9898, 1185, 34144, 34306, 34307, 9674, 0, 0, 0, 
0, 9671, 34145, 34308, 9676
23497, 8715, 8716, 8739, 8738, 33165, 33167, 33213, 33211, 9067, 9113, 9114, 9111, 34148, 34310, 34311, 
34303, 34139, 34146, 34309, 34302
23498, 33165, 33167, 33213, 33211, 33166, 33168, 33214, 33212, 34148, 34310, 34311, 34303, 34151, 34313, 34314, 
34306, 34142, 34149, 34312, 34305
23499, 33166, 33168, 33214, 33212, 9875, 9876, 9899, 9898, 34151, 34313, 34314, 34306, 0, 0, 0, 
0, 34145, 34152, 34315, 34308
23500, 8716, 8717, 8740, 8739, 33167, 33169, 33215, 33213, 9069, 9115, 9116, 9113, 34155, 34317, 34318, 
34310, 34146, 34153, 34316, 34309
23501, 33167, 33169, 33215, 33213, 33168, 33170, 33216, 33214, 34155, 34317, 34318, 34310, 34158, 34320, 34321, 
34313, 34149, 34156, 34319, 34312
23502, 33168, 33170, 33216, 33214, 9876, 9877, 9900, 9899, 34158, 34320, 34321, 34313, 0, 0, 0, 
0, 34152, 34159, 34322, 34315
23503, 8717, 8718, 8741, 8740, 33169, 33171, 33217, 33215, 9071, 9117, 9118, 9115, 34162, 34324, 34325, 
34317, 34153, 34160, 34323, 34316
23504, 33169, 33171, 33217, 33215, 33170, 33172, 33218, 33216, 34162, 34324, 34325, 34317, 34165, 34327, 34328, 
34320, 34156, 34163, 34326, 34319
23505, 33170, 33172, 33218, 33216, 9877, 9878, 9901, 9900, 34165, 34327, 34328, 34320, 0, 0, 0, 
0, 34159, 34166, 34329, 34322
23506, 8718, 8719, 8742, 8741, 33171, 33173, 33219, 33217, 9073, 9119, 9120, 9117, 34169, 34331, 34332, 
34324, 34160, 34167, 34330, 34323
23507, 33171, 33173, 33219, 33217, 33172, 33174, 33220, 33218, 34169, 34331, 34332, 34324, 34172, 34334, 34335, 
34327, 34163, 34170, 34333, 34326
23508, 33172, 33174, 33220, 33218, 9878, 9879, 9902, 9901, 34172, 34334, 34335, 34327, 0, 0, 0, 
0, 34166, 34173, 34336, 34329
23509, 8719, 8720, 8743, 8742, 33173, 33175, 33221, 33219, 9075, 9121, 9122, 9119, 34176, 34338, 34339, 
34331, 34167, 34174, 34337, 34330
23510, 33173, 33175, 33221, 33219, 33174, 33176, 33222, 33220, 34176, 34338, 34339, 34331, 34179, 34341, 34342, 
34334, 34170, 34177, 34340, 34333
23511, 33174, 33176, 33222, 33220, 9879, 9880, 9903, 9902, 34179, 34341, 34342, 34334, 0, 0, 0, 
0, 34173, 34180, 34343, 34336
23512, 8720, 8721, 8744, 8743, 33175, 33177, 33223, 33221, 9077, 9123, 9124, 9121, 34183, 34345, 34346, 
34338, 34174, 34181, 34344, 34337
23513, 33175, 33177, 33223, 33221, 33176, 33178, 33224, 33222, 34183, 34345, 34346, 34338, 34186, 34348, 34349, 
34341, 34177, 34184, 34347, 34340
23514, 33176, 33178, 33224, 33222, 9880, 9881, 9904, 9903, 34186, 34348, 34349, 34341, 0, 0, 0, 
0, 34180, 34187, 34350, 34343
23515, 8721, 8722, 8745, 8744, 33177, 33179, 33225, 33223, 9079, 9125, 9126, 9123, 34190, 34352, 34353, 
34345, 34181, 34188, 34351, 34344
23516, 33177, 33179, 33225, 33223, 33178, 33180, 33226, 33224, 34190, 34352, 34353, 34345, 34193, 34355, 34356, 
34348, 34184, 34191, 34354, 34347
23517, 33178, 33180, 33226, 33224, 9881, 9882, 9905, 9904, 34193, 34355, 34356, 34348, 0, 0, 0, 
0, 34187, 34194, 34357, 34350
23518, 8722, 8723, 8746, 8745, 33179, 33181, 33227, 33225, 9081, 9127, 9128, 9125, 34197, 34359, 34360, 
34352, 34188, 34195, 34358, 34351
23519, 33179, 33181, 33227, 33225, 33180, 33182, 33228, 33226, 34197, 34359, 34360, 34352, 34200, 34362, 34363, 
34355, 34191, 34198, 34361, 34354
23520, 33180, 33182, 33228, 33226, 9882, 9883, 9906, 9905, 34200, 34362, 34363, 34355, 0, 0, 0, 
0, 34194, 34201, 34364, 34357
23521, 8723, 8724, 8747, 8746, 33181, 33183, 33229, 33227, 9083, 9129, 9130, 9127, 34204, 34366, 34367, 
34359, 34195, 34202, 34365, 34358
23522, 33181, 33183, 33229, 33227, 33182, 33184, 33230, 33228, 34204, 34366, 34367, 34359, 34207, 34369, 34370, 
34362, 34198, 34205, 34368, 34361
23523, 33182, 33184, 33230, 33228, 9883, 9884, 9907, 9906, 34207, 34369, 34370, 34362, 0, 0, 0, 
0, 34201, 34208, 34371, 34364
23524, 8724, 8725, 8748, 8747, 33183, 33185, 33231, 33229, 9085, 9131, 9132, 9129, 34211, 34373, 34374, 
34366, 34202, 34209, 34372, 34365
23525, 33183, 33185, 33231, 33229, 33184, 33186, 33232, 33230, 34211, 34373, 34374, 34366, 34214, 34376, 34377, 
34369, 34205, 34212, 34375, 34368
23526, 33184, 33186, 33232, 33230, 9884, 9885, 9908, 9907, 34214, 34376, 34377, 34369, 0, 0, 0, 
0, 34208, 34215, 34378, 34371
23527, 8725, 8726, 8749, 8748, 33185, 33187, 33233, 33231, 9087, 9133, 9134, 9131, 34218, 34380, 34381, 
34373, 34209, 34216, 34379, 34372
23528, 33185, 33187, 33233, 33231, 33186, 33188, 33234, 33232, 34218, 34380, 34381, 34373, 34221, 34383, 34384, 
34376, 34212, 34219, 34382, 34375
23529, 33186, 33188, 33234, 33232, 9885, 9886, 9909, 9908, 34221, 34383, 34384, 34376, 0, 0, 0, 
0, 34215, 34222, 34385, 34378
23530, 8726, 8727, 8750, 8749, 33187, 33189, 33235, 33233, 9089, 9135, 9136, 9133, 34225, 34387, 34388, 
34380, 34216, 34223, 34386, 34379
23531, 33187, 33189, 33235, 33233, 33188, 33190, 33236, 33234, 34225, 34387, 34388, 34380, 34228, 34390, 34391, 
34383, 34219, 34226, 34389, 34382
23532, 33188, 33190, 33236, 33234, 9886, 9887, 9910, 9909, 34228, 34390, 34391, 34383, 0, 0, 0, 
0, 34222, 34229, 34392, 34385
23533, 8727, 8728, 8751, 8750, 33189, 33191, 33237, 33235, 9091, 9137, 9138, 9135, 34232, 34394, 34395, 
34387, 34223, 34230, 34393, 34386
23534, 33189, 33191, 33237, 33235, 33190, 33192, 33238, 33236, 34232, 34394, 34395, 34387, 34235, 34397, 34398, 
34390, 34226, 34233, 34396, 34389
23535, 33190, 33192, 33238, 33236, 9887, 9888, 9911, 9910, 34235, 34397, 34398, 34390, 0, 0, 0, 
0, 34229, 34236, 34399, 34392
23536, 8728, 8729, 8752, 8751, 33191, 33193, 33239, 33237, 9093, 9139, 9140, 9137, 34239, 34401, 34402, 
34394, 34230, 34237, 34400, 34393
23537, 33191, 33193, 33239, 33237, 33192, 33194, 33240, 33238, 34239, 34401, 34402, 34394, 34242, 34404, 34405, 
34397, 34233, 34240, 34403, 34396
23538, 33192, 33194, 33240, 33238, 9888, 9889, 9912, 9911, 34242, 34404, 34405, 34397, 0, 0, 0, 
0, 34236, 34243, 34406, 34399
23539, 8729, 8730, 8753, 8752, 33193, 33195, 33241, 33239, 9095, 9141, 9142, 9139, 34246, 34408, 34409, 
34401, 34237, 34244, 34407, 34400
23540, 33193, 33195, 33241, 33239, 33194, 33196, 33242, 33240, 34246, 34408, 34409, 34401, 34249, 34411, 34412, 
34404, 34240, 34247, 34410, 34403
23541, 33194, 33196, 33242, 33240, 9889, 9890, 9913, 9912, 34249, 34411, 34412, 34404, 0, 0, 0, 
0, 34243, 34250, 34413, 34406
23542, 8730, 8731, 8754, 8753, 33195, 33197, 33243, 33241, 9097, 9143, 9144, 9141, 34253, 34415, 34416, 
34408, 34244, 34251, 34414, 34407
23543, 33195, 33197, 33243, 33241, 33196, 33198, 33244, 33242, 34253, 34415, 34416, 34408, 34256, 34418, 34419, 
34411, 34247, 34254, 34417, 34410
23544, 33196, 33198, 33244, 33242, 9890, 9891, 9914, 9913, 34256, 34418, 34419, 34411, 0, 0, 0, 
0, 34250, 34257, 34420, 34413
23545, 8731, 8732, 8755, 8754, 33197, 33199, 33245, 33243, 9099, 9145, 9146, 9143, 34260, 34422, 34423, 
34415, 34251, 34258, 34421, 34414
23546, 33197, 33199, 33245, 33243, 33198, 33200, 33246, 33244, 34260, 34422, 34423, 34415, 34263, 34425, 34426, 
34418, 34254, 34261, 34424, 34417
23547, 33198, 33200, 33246, 33244, 9891, 9892, 9915, 9914, 34263, 34425, 34426, 34418, 0, 0, 0, 
0, 34257, 34264, 34427, 34420
23548, 8732, 8733, 8756, 8755, 33199, 33201, 33247, 33245, 9101, 9147, 9148, 9145, 34267, 34429, 34430, 
34422, 34258, 34265, 34428, 34421
23549, 33199, 33201, 33247, 33245, 33200, 33202, 33248, 33246, 34267, 34429, 34430, 34422, 34270, 34432, 34433, 
34425, 34261, 34268, 34431, 34424
23550, 33200, 33202, 33248, 33246, 9892, 9893, 9916, 9915, 34270, 34432, 34433, 34425, 0, 0, 0, 
0, 34264, 34271, 34434, 34427
23551, 8733, 8734, 8757, 8756, 33201, 33203, 33249, 33247, 9103, 9149, 9150, 9147, 34274, 34436, 34437, 
34429, 34265, 34272, 34435, 34428
23552, 33201, 33203, 33249, 33247, 33202, 33204, 33250, 33248, 34274, 34436, 34437, 34429, 34277, 34439, 34440, 
34432, 34268, 34275, 34438, 34431
23553, 33202, 33204, 33250, 33248, 9893, 9894, 9917, 9916, 34277, 34439, 34440, 34432, 0, 0, 0, 
0, 34271, 34278, 34441, 34434
23554, 8734, 8735, 8758, 8757, 33203, 33205, 33251, 33249, 9105, 9151, 9152, 9149, 34281, 34443, 34444, 
34436, 34272, 34279, 34442, 34435
23555, 33203, 33205, 33251, 33249, 33204, 33206, 33252, 33250, 34281, 34443, 34444, 34436, 34284, 34446, 34447, 
34439, 34275, 34282, 34445, 34438
23556, 33204, 33206, 33252, 33250, 9894, 9895, 9918, 9917, 34284, 34446, 34447, 34439, 0, 0, 0, 
0, 34278, 34285, 34448, 34441
23557, 8735, 8736, 8759, 8758, 33205, 33207, 33253, 33251, 9107, 9153, 9154, 9151, 34288, 34450, 34451, 
34443, 34279, 34286, 34449, 34442
23558, 33205, 33207, 33253, 33251, 33206, 33208, 33254, 33252, 34288, 34450, 34451, 34443, 34291, 34453, 34454, 
34446, 34282, 34289, 34452, 34445
23559, 33206, 33208, 33254, 33252, 9895, 9896, 9919, 9918, 34291, 34453, 34454, 34446, 0, 0, 0, 
0, 34285, 34292, 34455, 34448
23560, 8736, 8737, 8760, 8759, 33207, 33209, 33255, 33253, 9109, 9155, 9156, 9153, 34295, 34457, 34458, 
34450, 34286, 34293, 34456, 34449
23561, 33207, 33209, 33255, 33253, 33208, 33210, 33256, 33254, 34295, 34457, 34458, 34450, 34298, 34460, 34461, 
34453, 34289, 34296, 34459, 34452
23562, 33208, 33210, 33256, 33254, 9896, 9897, 9920, 9919, 34298, 34460, 34461, 34453, 0, 0, 0, 
0, 34292, 34299, 34462, 34455
23563, 8737, 1101, 1102, 8760, 33209, 9712, 9714, 33255, 9110, 1113, 9157, 9155, 34300, 9752, 34463, 
34457, 34293, 9746, 9751, 34456
23564, 33209, 9712, 9714, 33255, 33210, 9713, 9715, 33256, 34300, 9752, 34463, 34457, 34301, 9754, 34464, 
34460, 34296, 9748, 9753, 34459
23565, 33210, 9713, 9715, 33256, 9897, 1195, 1196, 9920, 34301, 9754, 34464, 34460, 0, 0, 0, 
0, 34299, 9750, 9755, 34462
23566, 1079, 8738, 8761, 1080, 9635, 33211, 33257, 9637, 9112, 9158, 9159, 1091, 34304, 34466, 34467, 
9677, 9673, 34302, 34465, 9678
23567, 9635, 33211, 33257, 9637, 9636, 33212, 33258, 9638, 34304, 34466, 34467, 9677, 34307, 34469, 34470, 
9679, 9675, 34305, 34468, 9680
23568, 9636, 33212, 33258, 9638, 1185, 9898, 9921, 1186, 34307, 34469, 34470, 9679, 0, 0, 0, 
0, 9676, 34308, 34471, 9681
23569, 8738, 8739, 8762, 8761, 33211, 33213, 33259, 33257, 9114, 9160, 9161, 9158, 34311, 34473, 34474, 
34466, 34302, 34309, 34472, 34465
23570, 33211, 33213, 33259, 33257, 33212, 33214, 33260, 33258, 34311, 34473, 34474, 34466, 34314, 34476, 34477, 
34469, 34305, 34312, 34475, 34468
23571, 33212, 33214, 33260, 33258, 9898, 9899, 9922, 9921, 34314, 34476, 34477, 34469, 0, 0, 0, 
0, 34308, 34315, 34478, 34471
23572, 8739, 8740, 8763, 8762, 33213, 33215, 33261, 33259, 9116, 9162, 9163, 9160, 34318, 34480, 34481, 
34473, 34309, 34316, 34479, 34472
23573, 33213, 33215, 33261, 33259, 33214, 33216, 33262, 33260, 34318, 34480, 34481, 34473, 34321, 34483, 34484, 
34476, 34312, 34319, 34482, 34475
23574, 33214, 33216, 33262, 33260, 9899, 9900, 9923, 9922, 34321, 34483, 34484, 34476, 0, 0, 0, 
0, 34315, 34322, 34485, 34478
23575, 8740, 8741, 8764, 8763, 33215, 33217, 33263, 33261, 9118, 9164, 9165, 9162, 34325, 34487, 34488, 
34480, 34316, 34323, 34486, 34479
23576, 33215, 33217, 33263, 33261, 33216, 33218, 33264, 33262, 34325, 34487, 34488, 34480, 34328, 34490, 34491, 
34483, 34319, 34326, 34489, 34482
23577, 33216, 33218, 33264, 33262, 9900, 9901, 9924, 9923, 34328, 34490, 34491, 34483, 0, 0, 0, 
0, 34322, 34329, 34492, 34485
23578, 8741, 8742, 8765, 8764, 33217, 33219, 33265, 33263, 9120, 9166, 9167, 9164, 34332, 34494, 34495, 
34487, 34323, 34330, 34493, 34486
23579, 33217, 33219, 33265, 33263, 33218, 33220, 33266, 33264, 34332, 34494, 34495, 34487, 34335, 34497, 34498, 
34490, 34326, 34333, 34496, 34489
23580, 33218, 33220, 33266, 33264, 9901, 9902, 9925, 9924, 34335, 34497, 34498, 34490, 0, 0, 0, 
0, 34329, 34336, 34499, 34492
23581, 8742, 8743, 8766, 8765, 33219, 33221, 33267, 33265, 9122, 9168, 9169, 9166, 34339, 34501, 34502, 
34494, 34330, 34337, 34500, 34493
23582, 33219, 33221, 33267, 33265, 33220, 33222, 33268, 33266, 34339, 34501, 34502, 34494, 34342, 34504, 34505, 
34497, 34333, 34340, 34503, 34496
23583, 33220, 33222, 33268, 33266, 9902, 9903, 9926, 9925, 34342, 34504, 34505, 34497, 0, 0, 0, 
0, 34336, 34343, 34506, 34499
23584, 8743, 8744, 8767, 8766, 33221, 33223, 33269, 33267, 9124, 9170, 9171, 9168, 34346, 34508, 34509, 
34501, 34337, 34344, 34507, 34500
23585, 33221, 33223, 33269, 33267, 33222, 33224, 33270, 33268, 34346, 34508, 34509, 34501, 34349, 34511, 34512, 
34504, 34340, 34347, 34510, 34503
23586, 33222, 33224, 33270, 33268, 9903, 9904, 9927, 9926, 34349, 34511, 34512, 34504, 0, 0, 0, 
0, 34343, 34350, 34513, 34506
23587, 8744, 8745, 8768, 8767, 33223, 33225, 33271, 33269, 9126, 9172, 9173, 9170, 34353, 34515, 34516, 
34508, 34344, 34351, 34514, 34507
23588, 33223, 33225, 33271, 33269, 33224, 33226, 33272, 33270, 34353, 34515, 34516, 34508, 34356, 34518, 34519, 
34511, 34347, 34354, 34517, 34510
23589, 33224, 33226, 33272, 33270, 9904, 9905, 9928, 9927, 34356, 34518, 34519, 34511, 0, 0, 0, 
0, 34350, 34357, 34520, 34513
23590, 8745, 8746, 8769, 8768, 33225, 33227, 33273, 33271, 9128, 9174, 9175, 9172, 34360, 34522, 34523, 
34515, 34351, 34358, 34521, 34514
23591, 33225, 33227, 33273, 33271, 33226, 33228, 33274, 33272, 34360, 34522, 34523, 34515, 34363, 34525, 34526, 
34518, 34354, 34361, 34524, 34517
23592, 33226, 33228, 33274, 33272, 9905, 9906, 9929, 9928, 34363, 34525, 34526, 34518, 0, 0, 0, 
0, 34357, 34364, 34527, 34520
23593, 8746, 8747, 8770, 8769, 33227, 33229, 33275, 33273, 9130, 9176, 9177, 9174, 34367, 34529, 34530, 
34522, 34358, 34365, 34528, 34521
23594, 33227, 33229, 33275, 33273, 33228, 33230, 33276, 33274, 34367, 34529, 34530, 34522, 34370, 34532, 34533, 
34525, 34361, 34368, 34531, 34524
23595, 33228, 33230, 33276, 33274, 9906, 9907, 9930, 9929, 34370, 34532, 34533, 34525, 0, 0, 0, 
0, 34364, 34371, 34534, 34527
23596, 8747, 8748, 8771, 8770, 33229, 33231, 33277, 33275, 9132, 9178, 9179, 9176, 34374, 34536, 34537, 
34529, 34365, 34372, 34535, 34528
23597, 33229, 33231, 33277, 33275, 33230, 33232, 33278, 33276, 34374, 34536, 34537, 34529, 34377, 34539, 34540, 
34532, 34368, 34375, 34538, 34531
23598, 33230, 33232, 33278, 33276, 9907, 9908, 9931, 9930, 34377, 34539, 34540, 34532, 0, 0, 0, 
0, 34371, 34378, 34541, 34534
23599, 8748, 8749, 8772, 8771, 33231, 33233, 33279, 33277, 9134, 9180, 9181, 9178, 34381, 34543, 34544, 
34536, 34372, 34379, 34542, 34535
23600, 33231, 33233, 33279, 33277, 33232, 33234, 33280, 33278, 34381, 34543, 34544, 34536, 34384, 34546, 34547, 
34539, 34375, 34382, 34545, 34538
23601, 33232, 33234, 33280, 33278, 9908, 9909, 9932, 9931, 34384, 34546, 34547, 34539, 0, 0, 0, 
0, 34378, 34385, 34548, 34541
23602, 8749, 8750, 8773, 8772, 33233, 33235, 33281, 33279, 9136, 9182, 9183, 9180, 34388, 34550, 34551, 
34543, 34379, 34386, 34549, 34542
23603, 33233, 33235, 33281, 33279, 33234, 33236, 33282, 33280, 34388, 34550, 34551, 34543, 34391, 34553, 34554, 
34546, 34382, 34389, 34552, 34545
23604, 33234, 33236, 33282, 33280, 9909, 9910, 9933, 9932, 34391, 34553, 34554, 34546, 0, 0, 0, 
0, 34385, 34392, 34555, 34548
23605, 8750, 8751, 8774, 8773, 33235, 33237, 33283, 33281, 9138, 9184, 9185, 9182, 34395, 34557, 34558, 
34550, 34386, 34393, 34556, 34549
23606, 33235, 33237, 33283, 33281, 33236, 33238, 33284, 33282, 34395, 34557, 34558, 34550, 34398, 34560, 34561, 
34553, 34389, 34396, 34559, 34552
23607, 33236, 33238, 33284, 33282, 9910, 9911, 9934, 9933, 34398, 34560, 34561, 34553, 0, 0, 0, 
0, 34392, 34399, 34562, 34555
23608, 8751, 8752, 8775, 8774, 33237, 33239, 33285, 33283, 9140, 9186, 9187, 9184, 34402, 34564, 34565, 
34557, 34393, 34400, 34563, 34556
23609, 33237, 33239, 33285, 33283, 33238, 33240, 33286, 33284, 34402, 34564, 34565, 34557, 34405, 34567, 34568, 
34560, 34396, 34403, 34566, 34559
23610, 33238, 33240, 33286, 33284, 9911, 9912, 9935, 9934, 34405, 34567, 34568, 34560, 0, 0, 0, 
0, 34399, 34406, 34569, 34562
23611, 8752, 8753, 8776, 8775, 33239, 33241, 33287, 33285, 9142, 9188, 9189, 9186, 34409, 34571, 34572, 
34564, 34400, 34407, 34570, 34563
23612, 33239, 33241, 33287, 33285, 33240, 33242, 33288, 33286, 34409, 34571, 34572, 34564, 34412, 34574, 34575, 
34567, 34403, 34410, 34573, 34566
23613, 33240, 33242, 33288, 33286, 9912, 9913, 9936, 9935, 34412, 34574, 34575, 34567, 0, 0, 0, 
0, 34406, 34413, 34576, 34569
23614, 8753, 8754, 8777, 8776, 33241, 33243, 33289, 33287, 9144, 9190, 9191, 9188, 34416, 34578, 34579, 
34571, 34407, 34414, 34577, 34570
23615, 33241, 33243, 33289, 33287, 33242, 33244, 33290, 33288, 34416, 34578, 34579, 34571, 34419, 34581, 34582, 
34574, 34410, 34417, 34580, 34573
23616, 33242, 33244, 33290, 33288, 9913, 9914, 9937, 9936, 34419, 34581, 34582, 34574, 0, 0, 0, 
0, 34413, 34420, 34583, 34576
23617, 8754, 8755, 8778, 8777, 33243, 33245, 33291, 33289, 9146, 9192, 9193, 9190, 34423, 34585, 34586, 
34578, 34414, 34421, 34584, 34577
23618, 33243, 33245, 33291, 33289, 33244, 33246, 33292, 33290, 34423, 34585, 34586, 34578, 34426, 34588, 34589, 
34581, 34417, 34424, 34587, 34580
23619, 33244, 33246, 33292, 33290, 9914, 9915, 9938, 9937, 34426, 34588, 34589, 34581, 0, 0, 0, 
0, 34420, 34427, 34590, 34583
23620, 8755, 8756, 8779, 8778, 33245, 33247, 33293, 33291, 9148, 9194, 9195, 9192, 34430, 34592, 34593, 
34585, 34421, 34428, 34591, 34584
23621, 33245, 33247, 33293, 33291, 33246, 33248, 33294, 33292, 34430, 34592, 34593, 34585, 34433, 34595, 34596, 
34588, 34424, 34431, 34594, 34587
23622, 33246, 33248, 33294, 33292, 9915, 9916, 9939, 9938, 34433, 34595, 34596, 34588, 0, 0, 0, 
0, 34427, 34434, 34597, 34590
23623, 8756, 8757, 8780, 8779, 33247, 33249, 33295, 33293, 9150, 9196, 9197, 9194, 34437, 34599, 34600, 
34592, 34428, 34435, 34598, 34591
23624, 33247, 33249, 33295, 33293, 33248, 33250, 33296, 33294, 34437, 34599, 34600, 34592, 34440, 34602, 34603, 
34595, 34431, 34438, 34601, 34594
23625, 33248, 33250, 33296, 33294, 9916, 9917, 9940, 9939, 34440, 34602, 34603, 34595, 0, 0, 0, 
0, 34434, 34441, 34604, 34597
23626, 8757, 8758, 8781, 8780, 33249, 33251, 33297, 33295, 9152, 9198, 9199, 9196, 34444, 34606, 34607, 
34599, 34435, 34442, 34605, 34598
23627, 33249, 33251, 33297, 33295, 33250, 33252, 33298, 33296, 34444, 34606, 34607, 34599, 34447, 34609, 34610, 
34602, 34438, 34445, 34608, 34601
23628, 33250, 33252, 33298, 33296, 9917, 9918, 9941, 9940, 34447, 34609, 34610, 34602, 0, 0, 0, 
0, 34441, 34448, 34611, 34604
23629, 8758, 8759, 8782, 8781, 33251, 33253, 33299, 33297, 9154, 9200, 9201, 9198, 34451, 34613, 34614, 
34606, 34442, 34449, 34612, 34605
23630, 33251, 33253, 33299, 33297, 33252, 33254, 33300, 33298, 34451, 34613, 34614, 34606, 34454, 34616, 34617, 
34609, 34445, 34452, 34615, 34608
23631, 33252, 33254, 33300, 33298, 9918, 9919, 9942, 9941, 34454, 34616, 34617, 34609, 0, 0, 0, 
0, 34448, 34455, 34618, 34611
23632, 8759, 8760, 8783, 8782, 33253, 33255, 33301, 33299, 9156, 9202, 9203, 9200, 34458, 34620, 34621, 
34613, 34449, 34456, 34619, 34612
23633, 33253, 33255, 33301, 33299, 33254, 33256, 33302, 33300, 34458, 34620, 34621, 34613, 34461, 34623, 34624, 
34616, 34452, 34459, 34622, 34615
23634, 33254, 33256, 33302, 33300, 9919, 9920, 9943, 9942, 34461, 34623, 34624, 34616, 0, 0, 0, 
0, 34455, 34462, 34625, 34618
23635, 8760, 1102, 1103, 8783, 33255, 9714, 9716, 33301, 9157, 1114, 9204, 9202, 34463, 9757, 34626, 
34620, 34456, 9751, 9756, 34619
23636, 33255, 9714, 9716, 33301, 33256, 9715, 9717, 33302, 34463, 9757, 34626, 34620, 34464, 9759, 34627, 
34623, 34459, 9753, 9758, 34622
23637, 33256, 9715, 9717, 33302, 9920, 1196, 1197, 9943, 34464, 9759, 34627, 34623, 0, 0, 0, 
0, 34462, 9755, 9760, 34625
23638, 1080, 8761, 8784, 1081, 9637, 33257, 33303, 9639, 9159, 9205, 9206, 1092, 34467, 34629, 34630, 
9682, 9678, 34465, 34628, 9683
23639, 9637, 33257, 33303, 9639, 9638, 33258, 33304, 9640, 34467, 34629, 34630, 9682, 34470, 34632, 34633, 
9684, 9680, 34468, 34631, 9685
23640, 9638, 33258, 33304, 9640, 1186, 9921, 9944, 1187, 34470, 34632, 34633, 9684, 0, 0, 0, 
0, 9681, 34471, 34634, 9686
23641, 8761, 8762, 8785, 8784, 33257, 33259, 33305, 33303, 9161, 9207, 9208, 9205, 34474, 34636, 34637, 
34629, 34465, 34472, 34635, 34628
23642, 33257, 33259, 33305, 33303, 33258, 33260, 33306, 33304, 34474, 34636, 34637, 34629, 34477, 34639, 34640, 
34632, 34468, 34475, 34638, 34631
23643, 33258, 33260, 33306, 33304, 9921, 9922, 9945, 9944, 34477, 34639, 34640, 34632, 0, 0, 0, 
0, 34471, 34478, 34641, 34634
23644, 8762, 8763, 8786, 8785, 33259, 33261, 33307, 33305, 9163, 9209, 9210, 9207, 34481, 34643, 34644, 
34636, 34472, 34479, 34642, 34635
23645, 33259, 33261, 33307, 33305, 33260, 33262, 33308, 33306, 34481, 34643, 34644, 34636, 34484, 34646, 34647, 
34639, 34475, 34482, 34645, 34638
23646, 33260, 33262, 33308, 33306, 9922, 9923, 9946, 9945, 34484, 34646, 34647, 34639, 0, 0, 0, 
0, 34478, 34485, 34648, 34641
23647, 8763, 8764, 8787, 8786, 33261, 33263, 33309, 33307, 9165, 9211, 9212, 9209, 34488, 34650, 34651, 
34643, 34479, 34486, 34649, 34642
23648, 33261, 33263, 33309, 33307, 33262, 33264, 33310, 33308, 34488, 34650, 34651, 34643, 34491, 34653, 34654, 
34646, 34482, 34489, 34652, 34645
23649, 33262, 33264, 33310, 33308, 9923, 9924, 9947, 9946, 34491, 34653, 34654, 34646, 0, 0, 0, 
0, 34485, 34492, 34655, 34648
23650, 8764, 8765, 8788, 8787, 33263, 33265, 33311, 33309, 9167, 9213, 9214, 9211, 34495, 34657, 34658, 
34650, 34486, 34493, 34656, 34649
23651, 33263, 33265, 33311, 33309, 33264, 33266, 33312, 33310, 34495, 34657, 34658, 34650, 34498, 34660, 34661, 
34653, 34489, 34496, 34659, 34652
23652, 33264, 33266, 33312, 33310, 9924, 9925, 9948, 9947, 34498, 34660, 34661, 34653, 0, 0, 0, 
0, 34492, 34499, 34662, 34655
23653, 8765, 8766, 8789, 8788, 33265, 33267, 33313, 33311, 9169, 9215, 9216, 9213, 34502, 34664, 34665, 
34657, 34493, 34500, 34663, 34656
23654, 33265, 33267, 33313, 33311, 33266, 33268, 33314, 33312, 34502, 34664, 34665, 34657, 34505, 34667, 34668, 
34660, 34496, 34503, 34666, 34659
23655, 33266, 33268, 33314, 33312, 9925, 9926, 9949, 9948, 34505, 34667, 34668, 34660, 0, 0, 0, 
0, 34499, 34506, 34669, 34662
23656, 8766, 8767, 8790, 8789, 33267, 33269, 33315, 33313, 9171, 9217, 9218, 9215, 34509, 34671, 34672, 
34664, 34500, 34507, 34670, 34663
23657, 33267, 33269, 33315, 33313, 33268, 33270, 33316, 33314, 34509, 34671, 34672, 34664, 34512, 34674, 34675, 
34667, 34503, 34510, 34673, 34666
23658, 33268, 33270, 33316, 33314, 9926, 9927, 9950, 9949, 34512, 34674, 34675, 34667, 0, 0, 0, 
0, 34506, 34513, 34676, 34669
23659, 8767, 8768, 8791, 8790, 33269, 33271, 33317, 33315, 9173, 9219, 9220, 9217, 34516, 34678, 34679, 
34671, 34507, 34514, 34677, 34670
23660, 33269, 33271, 33317, 33315, 33270, 33272, 33318, 33316, 34516, 34678, 34679, 34671, 34519, 34681, 34682, 
34674, 34510, 34517, 34680, 34673
23661, 33270, 33272, 33318, 33316, 9927, 9928, 9951, 9950, 34519, 34681, 34682, 34674, 0, 0, 0, 
0, 34513, 34520, 34683, 34676
23662, 8768, 8769, 8792, 8791, 33271, 33273, 33319, 33317, 9175, 9221, 9222, 9219, 34523, 34685, 34686, 
34678, 34514, 34521, 34684, 34677
23663, 33271, 33273, 33319, 33317, 33272, 33274, 33320, 33318, 34523, 34685, 34686, 34678, 34526, 34688, 34689, 
34681, 34517, 34524, 34687, 34680
23664, 33272, 33274, 33320, 33318, 9928, 9929, 9952, 9951, 34526, 34688, 34689, 34681, 0, 0, 0, 
0, 34520, 34527, 34690, 34683
23665, 8769, 8770, 8793, 8792, 33273, 33275, 33321, 33319, 9177, 9223, 9224, 9221, 34530, 34692, 34693, 
34685, 34521, 34528, 34691, 34684
23666, 33273, 33275, 33321, 33319, 33274, 33276, 33322, 33320, 34530, 34692, 34693, 34685, 34533, 34695, 34696, 
34688, 34524, 34531, 34694, 34687
23667, 33274, 33276, 33322, 33320, 9929, 9930, 9953, 9952, 34533, 34695, 34696, 34688, 0, 0, 0, 
0, 34527, 34534, 34697, 34690
23668, 8770, 8771, 8794, 8793, 33275, 33277, 33323, 33321, 9179, 9225, 9226, 9223, 34537, 34699, 34700, 
34692, 34528, 34535, 34698, 34691
23669, 33275, 33277, 33323, 33321, 33276, 33278, 33324, 33322, 34537, 34699, 34700, 34692, 34540, 34702, 34703, 
34695, 34531, 34538, 34701, 34694
23670, 33276, 33278, 33324, 33322, 9930, 9931, 9954, 9953, 34540, 34702, 34703, 34695, 0, 0, 0, 
0, 34534, 34541, 34704, 34697
23671, 8771, 8772, 8795, 8794, 33277, 33279, 33325, 33323, 9181, 9227, 9228, 9225, 34544, 34706, 34707, 
34699, 34535, 34542, 34705, 34698
23672, 33277, 33279, 33325, 33323, 33278, 33280, 33326, 33324, 34544, 34706, 34707, 34699, 34547, 34709, 34710, 
34702, 34538, 34545, 34708, 34701
23673, 33278, 33280, 33326, 33324, 9931, 9932, 9955, 9954, 34547, 34709, 34710, 34702, 0, 0, 0, 
0, 34541, 34548, 34711, 34704
23674, 8772, 8773, 8796, 8795, 33279, 33281, 33327, 33325, 9183, 9229, 9230, 9227, 34551, 34713, 34714, 
34706, 34542, 34549, 34712, 34705
23675, 33279, 33281, 33327, 33325, 33280, 33282, 33328, 33326, 34551, 34713, 34714, 34706, 34554, 34716, 34717, 
34709, 34545, 34552, 34715, 34708
23676, 33280, 33282, 33328, 33326, 9932, 9933, 9956, 9955, 34554, 34716, 34717, 34709, 0, 0, 0, 
0, 34548, 34555, 34718, 34711
23677, 8773, 8774, 8797, 8796, 33281, 33283, 33329, 33327, 9185, 9231, 9232, 9229, 34558, 34720, 34721, 
34713, 34549, 34556, 34719, 34712
23678, 33281, 33283, 33329, 33327, 33282, 33284, 33330, 33328, 34558, 34720, 34721, 34713, 34561, 34723, 34724, 
34716, 34552, 34559, 34722, 34715
23679, 33282, 33284, 33330, 33328, 9933, 9934, 9957, 9956, 34561, 34723, 34724, 34716, 0, 0, 0, 
0, 34555, 34562, 34725, 34718
23680, 8774, 8775, 8798, 8797, 33283, 33285, 33331, 33329, 9187, 9233, 9234, 9231, 34565, 34727, 34728, 
34720, 34556, 34563, 34726, 34719
23681, 33283, 33285, 33331, 33329, 33284, 33286, 33332, 33330, 34565, 34727, 34728, 34720, 34568, 34730, 34731, 
34723, 34559, 34566, 34729, 34722
23682, 33284, 33286, 33332, 33330, 9934, 9935, 9958, 9957, 34568, 34730, 34731, 34723, 0, 0, 0, 
0, 34562, 34569, 34732, 34725
23683, 8775, 8776, 8799, 8798, 33285, 33287, 33333, 33331, 9189, 9235, 9236, 9233, 34572, 34734, 34735, 
34727, 34563, 34570, 34733, 34726
23684, 33285, 33287, 33333, 33331, 33286, 33288, 33334, 33332, 34572, 34734, 34735, 34727, 34575, 34737, 34738, 
34730, 34566, 34573, 34736, 34729
23685, 33286, 33288, 33334, 33332, 9935, 9936, 9959, 9958, 34575, 34737, 34738, 34730, 0, 0, 0, 
0, 34569, 34576, 34739, 34732
23686, 8776, 8777, 8800, 8799, 33287, 33289, 33335, 33333, 9191, 9237, 9238, 9235, 34579, 34741, 34742, 
34734, 34570, 34577, 34740, 34733
23687, 33287, 33289, 33335, 33333, 33288, 33290, 33336, 33334, 34579, 34741, 34742, 34734, 34582, 34744, 34745, 
34737, 34573, 34580, 34743, 34736
23688, 33288, 33290, 33336, 33334, 9936, 9937, 9960, 9959, 34582, 34744, 34745, 34737, 0, 0, 0, 
0, 34576, 34583, 34746, 34739
23689, 8777, 8778, 8801, 8800, 33289, 33291, 33337, 33335, 9193, 9239, 9240, 9237, 34586, 34748, 34749, 
34741, 34577, 34584, 34747, 34740
23690, 33289, 33291, 33337, 33335, 33290, 33292, 33338, 33336, 34586, 34748, 34749, 34741, 34589, 34751, 34752, 
34744, 34580, 34587, 34750, 34743
23691, 33290, 33292, 33338, 33336, 9937, 9938, 9961, 9960, 34589, 34751, 34752, 34744, 0, 0, 0, 
0, 34583, 34590, 34753, 34746
23692, 8778, 8779, 8802, 8801, 33291, 33293, 33339, 33337, 9195, 9241, 9242, 9239, 34593, 34755, 34756, 
34748, 34584, 34591, 34754, 34747
23693, 33291, 33293, 33339, 33337, 33292, 33294, 33340, 33338, 34593, 34755, 34756, 34748, 34596, 34758, 34759, 
34751, 34587, 34594, 34757, 34750
23694, 33292, 33294, 33340, 33338, 9938, 9939, 9962, 9961, 34596, 34758, 34759, 34751, 0, 0, 0, 
0, 34590, 34597, 34760, 34753
23695, 8779, 8780, 8803, 8802, 33293, 33295, 33341, 33339, 9197, 9243, 9244, 9241, 34600, 34762, 34763, 
34755, 34591, 34598, 34761, 34754
23696, 33293, 33295, 33341, 33339, 33294, 33296, 33342, 33340, 34600, 34762, 34763, 34755, 34603, 34765, 34766, 
34758, 34594, 34601, 34764, 34757
23697, 33294, 33296, 33342, 33340, 9939, 9940, 9963, 9962, 34603, 34765, 34766, 34758, 0, 0, 0, 
0, 34597, 34604, 34767, 34760
23698, 8780, 8781, 8804, 8803, 33295, 33297, 33343, 33341, 9199, 9245, 9246, 9243, 34607, 34769, 34770, 
34762, 34598, 34605, 34768, 34761
23699, 33295, 33297, 33343, 33341, 33296, 33298, 33344, 33342, 34607, 34769, 34770, 34762, 34610, 34772, 34773, 
34765, 34601, 34608, 34771, 34764
23700, 33296, 33298, 33344, 33342, 9940, 9941, 9964, 9963, 34610, 34772, 34773, 34765, 0, 0, 0, 
0, 34604, 34611, 34774, 34767
23701, 8781, 8782, 8805, 8804, 33297, 33299, 33345, 33343, 9201, 9247, 9248, 9245, 34614, 34776, 34777, 
34769, 34605, 34612, 34775, 34768
23702, 33297, 33299, 33345, 33343, 33298, 33300, 33346, 33344, 34614, 34776, 34777, 34769, 34617, 34779, 34780, 
34772, 34608, 34615, 34778, 34771
23703, 33298, 33300, 33346, 33344, 9941, 9942, 9965, 9964, 34617, 34779, 34780, 34772, 0, 0, 0, 
0, 34611, 34618, 34781, 34774
23704, 8782, 8783, 8806, 8805, 33299, 33301, 33347, 33345, 9203, 9249, 9250, 9247, 34621, 34783, 34784, 
34776, 34612, 34619, 34782, 34775
23705, 33299, 33301, 33347, 33345, 33300, 33302, 33348, 33346, 34621, 34783, 34784, 34776, 34624, 34786, 34787, 
34779, 34615, 34622, 34785, 34778
23706, 33300, 33302, 33348, 33346, 9942, 9943, 9966, 9965, 34624, 34786, 34787, 34779, 0, 0, 0, 
0, 34618, 34625, 34788, 34781
23707, 8783, 1103, 1104, 8806, 33301, 9716, 9718, 33347, 9204, 1115, 9251, 9249, 34626, 9762, 34789, 
34783, 34619, 9756, 9761, 34782
23708, 33301, 9716, 9718, 33347, 33302, 9717, 9719, 33348, 34626, 9762, 34789, 34783, 34627, 9764, 34790, 
34786, 34622, 9758, 9763, 34785
23709, 33302, 9717, 9719, 33348, 9943, 1197, 1198, 9966, 34627, 9764, 34790, 34786, 0, 0, 0, 
0, 34625, 9760, 9765, 34788
23710, 1081, 8784, 8807, 1082, 9639, 33303, 33349, 9641, 9206, 9252, 9253, 1093, 34630, 34792, 34793, 
9687, 9683, 34628, 34791, 9688
23711, 9639, 33303, 33349, 9641, 9640, 33304, 33350, 9642, 34630, 34792, 34793, 9687, 34633, 34795, 34796, 
9689, 9685, 34631, 34794, 9690
23712, 9640, 33304, 33350, 9642, 1187, 9944, 9967, 1188, 34633, 34795, 34796, 9689, 0, 0, 0, 
0, 9686, 34634, 34797, 9691
23713, 8784, 8785, 8808, 8807, 33303, 33305, 33351, 33349, 9208, 9254, 9255, 9252, 34637, 34799, 34800, 
34792, 34628, 34635, 34798, 34791
23714, 33303, 33305, 33351, 33349, 33304, 33306, 33352, 33350, 34637, 34799, 34800, 34792, 34640, 34802, 34803, 
34795, 34631, 34638, 34801, 34794
23715, 33304, 33306, 33352, 33350, 9944, 9945, 9968, 9967, 34640, 34802, 34803, 34795, 0, 0, 0, 
0, 34634, 34641, 34804, 34797
23716, 8785, 8786, 8809, 8808, 33305, 33307, 33353, 33351, 9210, 9256, 9257, 9254, 34644, 34806, 34807, 
34799, 34635, 34642, 34805, 34798
23717, 33305, 33307, 33353, 33351, 33306, 33308, 33354, 33352, 34644, 34806, 34807, 34799, 34647, 34809, 34810, 
34802, 34638, 34645, 34808, 34801
23718, 33306, 33308, 33354, 33352, 9945, 9946, 9969, 9968, 34647, 34809, 34810, 34802, 0, 0, 0, 
0, 34641, 34648, 34811, 34804
23719, 8786, 8787, 8810, 8809, 33307, 33309, 33355, 33353, 9212, 9258, 9259, 9256, 34651, 34813, 34814, 
34806, 34642, 34649, 34812, 34805
23720, 33307, 33309, 33355, 33353, 33308, 33310, 33356, 33354, 34651, 34813, 34814, 34806, 34654, 34816, 34817, 
34809, 34645, 34652, 34815, 34808
23721, 33308, 33310, 33356, 33354, 9946, 9947, 9970, 9969, 34654, 34816, 34817, 34809, 0, 0, 0, 
0, 34648, 34655, 34818, 34811
23722, 8787, 8788, 8811, 8810, 33309, 33311, 33357, 33355, 9214, 9260, 9261, 9258, 34658, 34820, 34821, 
34813, 34649, 34656, 34819, 34812
23723, 33309, 33311, 33357, 33355, 33310, 33312, 33358, 33356, 34658, 34820, 34821, 34813, 34661, 34823, 34824, 
34816, 34652, 34659, 34822, 34815
23724, 33310, 33312, 33358, 33356, 9947, 9948, 9971, 9970, 34661, 34823, 34824, 34816, 0, 0, 0, 
0, 34655, 34662, 34825, 34818
23725, 8788, 8789, 8812, 8811, 33311, 33313, 33359, 33357, 9216, 9262, 9263, 9260, 34665, 34827, 34828, 
34820, 34656, 34663, 34826, 34819
23726, 33311, 33313, 33359, 33357, 33312, 33314, 33360, 33358, 34665, 34827, 34828, 34820, 34668, 34830, 34831, 
34823, 34659, 34666, 34829, 34822
23727, 33312, 33314, 33360, 33358, 9948, 9949, 9972, 9971, 34668, 34830, 34831, 34823, 0, 0, 0, 
0, 34662, 34669, 34832, 34825
23728, 8789, 8790, 8813, 8812, 33313, 33315, 33361, 33359, 9218, 9264, 9265, 9262, 34672, 34834, 34835, 
34827, 34663, 34670, 34833, 34826
23729, 33313, 33315, 33361, 33359, 33314, 33316, 33362, 33360, 34672, 34834, 34835, 34827, 34675, 34837, 34838, 
34830, 34666, 34673, 34836, 34829
23730, 33314, 33316, 33362, 33360, 9949, 9950, 9973, 9972, 34675, 34837, 34838, 34830, 0, 0, 0, 
0, 34669, 34676, 34839, 34832
23731, 8790, 8791, 8814, 8813, 33315, 33317, 33363, 33361, 9220, 9266, 9267, 9264, 34679, 34841, 34842, 
34834, 34670, 34677, 34840, 34833
23732, 33315, 33317, 33363, 33361, 33316, 33318, 33364, 33362, 34679, 34841, 34842, 34834, 34682, 34844, 34845, 
34837, 34673, 34680, 34843, 34836
23733, 33316, 33318, 33364, 33362, 9950, 9951, 9974, 9973, 34682, 34844, 34845, 34837, 0, 0, 0, 
0, 34676, 34683, 34846, 34839
23734, 8791, 8792, 8815, 8814, 33317, 33319, 33365, 33363, 9222, 9268, 9269, 9266, 34686, 34848, 34849, 
34841, 34677, 34684, 34847, 34840
23735, 33317, 33319, 33365, 33363, 33318, 33320, 33366, 33364, 34686, 34848, 34849, 34841, 34689, 34851, 34852, 
34844, 34680, 34687, 34850, 34843
23736, 33318, 33320, 33366, 33364, 9951, 9952, 9975, 9974, 34689, 34851, 34852, 34844, 0, 0, 0, 
0, 34683, 34690, 34853, 34846
23737, 8792, 8793, 8816, 8815, 33319, 33321, 33367, 33365, 9224, 9270, 9271, 9268, 34693, 34855, 34856, 
34848, 34684, 34691, 34854, 34847
23738, 33319, 33321, 33367, 33365, 33320, 33322, 33368, 33366, 34693, 34855, 34856, 34848, 34696, 34858, 34859, 
34851, 34687, 34694, 34857, 34850
23739, 33320, 33322, 33368, 33366, 9952, 9953, 9976, 9975, 34696, 34858, 34859, 34851, 0, 0, 0, 
0, 34690, 34697, 34860, 34853
23740, 8793, 8794, 8817, 8816, 33321, 33323, 33369, 33367, 9226, 9272, 9273, 9270, 34700, 34862, 34863, 
34855, 34691, 34698, 34861, 34854
23741, 33321, 33323, 33369, 33367, 33322, 33324, 33370, 33368, 34700, 34862, 34863, 34855, 34703, 34865, 34866, 
34858, 34694, 34701, 34864, 34857
23742, 33322, 33324, 33370, 33368, 9953, 9954, 9977, 9976, 34703, 34865, 34866, 34858, 0, 0, 0, 
0, 34697, 34704, 34867, 34860
23743, 8794, 8795, 8818, 8817, 33323, 33325, 33371, 33369, 9228, 9274, 9275, 9272, 34707, 34869, 34870, 
34862, 34698, 34705, 34868, 34861
23744, 33323, 33325, 33371, 33369, 33324, 33326, 33372, 33370, 34707, 34869, 34870, 34862, 34710, 34872, 34873, 
34865, 34701, 34708, 34871, 34864
23745, 33324, 33326, 33372, 33370, 9954, 9955, 9978, 9977, 34710, 34872, 34873, 34865, 0, 0, 0, 
0, 34704, 34711, 34874, 34867
23746, 8795, 8796, 8819, 8818, 33325, 33327, 33373, 33371, 9230, 9276, 9277, 9274, 34714, 34876, 34877, 
34869, 34705, 34712, 34875, 34868
23747, 33325, 33327, 33373, 33371, 33326, 33328, 33374, 33372, 34714, 34876, 34877, 34869, 34717, 34879, 34880, 
34872, 34708, 34715, 34878, 34871
23748, 33326, 33328, 33374, 33372, 9955, 9956, 9979, 9978, 34717, 34879, 34880, 34872, 0, 0, 0, 
0, 34711, 34718, 34881, 34874
23749, 8796, 8797, 8820, 8819, 33327, 33329, 33375, 33373, 9232, 9278, 9279, 9276, 34721, 34883, 34884, 
34876, 34712, 34719, 34882, 34875
23750, 33327, 33329, 33375, 33373, 33328, 33330, 33376, 33374, 34721, 34883, 34884, 34876, 34724, 34886, 34887, 
34879, 34715, 34722, 34885, 34878
23751, 33328, 33330, 33376, 33374, 9956, 9957, 9980, 9979, 34724, 34886, 34887, 34879, 0, 0, 0, 
0, 34718, 34725, 34888, 34881
23752, 8797, 8798, 8821, 8820, 33329, 33331, 33377, 33375, 9234, 9280, 9281, 9278, 34728, 34890, 34891, 
34883, 34719, 34726, 34889, 34882
23753, 33329, 33331, 33377, 33375, 33330, 33332, 33378, 33376, 34728, 34890, 34891, 34883, 34731, 34893, 34894, 
34886, 34722, 34729, 34892, 34885
23754, 33330, 33332, 33378, 33376, 9957, 9958, 9981, 9980, 34731, 34893, 34894, 34886, 0, 0, 0, 
0, 34725, 34732, 34895, 34888
23755, 8798, 8799, 8822, 8821, 33331, 33333, 33379, 33377, 9236, 9282, 9283, 9280, 34735, 34897, 34898, 
34890, 34726, 34733, 34896, 34889
23756, 33331, 33333, 33379, 33377, 33332, 33334, 33380, 33378, 34735, 34897, 34898, 34890, 34738, 34900, 34901, 
34893, 34729, 34736, 34899, 34892
23757, 33332, 33334, 33380, 33378, 9958, 9959, 9982, 9981, 34738, 34900, 34901, 34893, 0, 0, 0, 
0, 34732, 34739, 34902, 34895
23758, 8799, 8800, 8823, 8822, 33333, 33335, 33381, 33379, 9238, 9284, 9285, 9282, 34742, 34904, 34905, 
34897, 34733, 34740, 34903, 34896
23759, 33333, 33335, 33381, 33379, 33334, 33336, 33382, 33380, 34742, 34904, 34905, 34897, 34745, 34907, 34908, 
34900, 34736, 34743, 34906, 34899
23760, 33334, 33336, 33382, 33380, 9959, 9960, 9983, 9982, 34745, 34907, 34908, 34900, 0, 0, 0, 
0, 34739, 34746, 34909, 34902
23761, 8800, 8801, 8824, 8823, 33335, 33337, 33383, 33381, 9240, 9286, 9287, 9284, 34749, 34911, 34912, 
34904, 34740, 34747, 34910, 34903
23762, 33335, 33337, 33383, 33381, 33336, 33338, 33384, 33382, 34749, 34911, 34912, 34904, 34752, 34914, 34915, 
34907, 34743, 34750, 34913, 34906
23763, 33336, 33338, 33384, 33382, 9960, 9961, 9984, 9983, 34752, 34914, 34915, 34907, 0, 0, 0, 
0, 34746, 34753, 34916, 34909
23764, 8801, 8802, 8825, 8824, 33337, 33339, 33385, 33383, 9242, 9288, 9289, 9286, 34756, 34918, 34919, 
34911, 34747, 34754, 34917, 34910
23765, 33337, 33339, 33385, 33383, 33338, 33340, 33386, 33384, 34756, 34918, 34919, 34911, 34759, 34921, 34922, 
34914, 34750, 34757, 34920, 34913
23766, 33338, 33340, 33386, 33384, 9961, 9962, 9985, 9984, 34759, 34921, 34922, 34914, 0, 0, 0, 
0, 34753, 34760, 34923, 34916
23767, 8802, 8803, 8826, 8825, 33339, 33341, 33387, 33385, 9244, 9290, 9291, 9288, 34763, 34925, 34926, 
34918, 34754, 34761, 34924, 34917
23768, 33339, 33341, 33387, 33385, 33340, 33342, 33388, 33386, 34763, 34925, 34926, 34918, 34766, 34928, 34929, 
34921, 34757, 34764, 34927, 34920
23769, 33340, 33342, 33388, 33386, 9962, 9963, 9986, 9985, 34766, 34928, 34929, 34921, 0, 0, 0, 
0, 34760, 34767, 34930, 34923
23770, 8803, 8804, 8827, 8826, 33341, 33343, 33389, 33387, 9246, 9292, 9293, 9290, 34770, 34932, 34933, 
34925, 34761, 34768, 34931, 34924
23771, 33341, 33343, 33389, 33387, 33342, 33344, 33390, 33388, 34770, 34932, 34933, 34925, 34773, 34935, 34936, 
34928, 34764, 34771, 34934, 34927
23772, 33342, 33344, 33390, 33388, 9963, 9964, 9987, 9986, 34773, 34935, 34936, 34928, 0, 0, 0, 
0, 34767, 34774, 34937, 34930
23773, 8804, 8805, 8828, 8827, 33343, 33345, 33391, 33389, 9248, 9294, 9295, 9292, 34777, 34939, 34940, 
34932, 34768, 34775, 34938, 34931
23774, 33343, 33345, 33391, 33389, 33344, 33346, 33392, 33390, 34777, 34939, 34940, 34932, 34780, 34942, 34943, 
34935, 34771, 34778, 34941, 34934
23775, 33344, 33346, 33392, 33390, 9964, 9965, 9988, 9987, 34780, 34942, 34943, 34935, 0, 0, 0, 
0, 34774, 34781, 34944, 34937
23776, 8805, 8806, 8829, 8828, 33345, 33347, 33393, 33391, 9250, 9296, 9297, 9294, 34784, 34946, 34947, 
34939, 34775, 34782, 34945, 34938
23777, 33345, 33347, 33393, 33391, 33346, 33348, 33394, 33392, 34784, 34946, 34947, 34939, 34787, 34949, 34950, 
34942, 34778, 34785, 34948, 34941
23778, 33346, 33348, 33394, 33392, 9965, 9966, 9989, 9988, 34787, 34949, 34950, 34942, 0, 0, 0, 
0, 34781, 34788, 34951, 34944
23779, 8806, 1104, 1105, 8829, 33347, 9718, 9720, 33393, 9251, 1116, 9298, 9296, 34789, 9767, 34952, 
34946, 34782, 9761, 9766, 34945
23780, 33347, 9718, 9720, 33393, 33348, 9719, 9721, 33394, 34789, 9767, 34952, 34946, 34790, 9769, 34953, 
34949, 34785, 9763, 9768, 34948
23781, 33348, 9719, 9721, 33394, 9966, 1198, 1199, 9989, 34790, 9769, 34953, 34949, 0, 0, 0, 
0, 34788, 9765, 9770, 34951
23782, 1082, 8807, 8830, 1083, 9641, 33349, 33395, 9643, 9253, 9299, 9300, 1094, 34793, 34955, 34956, 
9692, 9688, 34791, 34954, 9693
23783, 9641, 33349, 33395, 9643, 9642, 33350, 33396, 9644, 34793, 34955, 34956, 9692, 34796, 34958, 34959, 
9694, 9690, 34794, 34957, 9695
23784, 9642, 33350, 33396, 9644, 1188, 9967, 9990, 1189, 34796, 34958, 34959, 9694, 0, 0, 0, 
0, 9691, 34797, 34960, 9696
23785, 8807, 8808, 8831, 8830, 33349, 33351, 33397, 33395, 9255, 9301, 9302, 9299, 34800, 34962, 34963, 
34955, 34791, 34798, 34961, 34954
23786, 33349, 33351, 33397, 33395, 33350, 33352, 33398, 33396, 34800, 34962, 34963, 34955, 34803, 34965, 34966, 
34958, 34794, 34801, 34964, 34957
23787, 33350, 33352, 33398, 33396, 9967, 9968, 9991, 9990, 34803, 34965, 34966, 34958, 0, 0, 0, 
0, 34797, 34804, 34967, 34960
23788, 8808, 8809, 8832, 8831, 33351, 33353, 33399, 33397, 9257, 9303, 9304, 9301, 34807, 34969, 34970, 
34962, 34798, 34805, 34968, 34961
23789, 33351, 33353, 33399, 33397, 33352, 33354, 33400, 33398, 34807, 34969, 34970, 34962, 34810, 34972, 34973, 
34965, 34801, 34808, 34971, 34964
23790, 33352, 33354, 33400, 33398, 9968, 9969, 9992, 9991, 34810, 34972, 34973, 34965, 0, 0, 0, 
0, 34804, 34811, 34974, 34967
23791, 8809, 8810, 8833, 8832, 33353, 33355, 33401, 33399, 9259, 9305, 9306, 9303, 34814, 34976, 34977, 
34969, 34805, 34812, 34975, 34968
23792, 33353, 33355, 33401, 33399, 33354, 33356, 33402, 33400, 34814, 34976, 34977, 34969, 34817, 34979, 34980, 
34972, 34808, 34815, 34978, 34971
23793, 33354, 33356, 33402, 33400, 9969, 9970, 9993, 9992, 34817, 34979, 34980, 34972, 0, 0, 0, 
0, 34811, 34818, 34981, 34974
23794, 8810, 8811, 8834, 8833, 33355, 33357, 33403, 33401, 9261, 9307, 9308, 9305, 34821, 34983, 34984, 
34976, 34812, 34819, 34982, 34975
23795, 33355, 33357, 33403, 33401, 33356, 33358, 33404, 33402, 34821, 34983, 34984, 34976, 34824, 34986, 34987, 
34979, 34815, 34822, 34985, 34978
23796, 33356, 33358, 33404, 33402, 9970, 9971, 9994, 9993, 34824, 34986, 34987, 34979, 0, 0, 0, 
0, 34818, 34825, 34988, 34981
23797, 8811, 8812, 8835, 8834, 33357, 33359, 33405, 33403, 9263, 9309, 9310, 9307, 34828, 34990, 34991, 
34983, 34819, 34826, 34989, 34982
23798, 33357, 33359, 33405, 33403, 33358, 33360, 33406, 33404, 34828, 34990, 34991, 34983, 34831, 34993, 34994, 
34986, 34822, 34829, 34992, 34985
23799, 33358, 33360, 33406, 33404, 9971, 9972, 9995, 9994, 34831, 34993, 34994, 34986, 0, 0, 0, 
0, 34825, 34832, 34995, 34988
23800, 8812, 8813, 8836, 8835, 33359, 33361, 33407, 33405, 9265, 9311, 9312, 9309, 34835, 34997, 34998, 
34990, 34826, 34833, 34996, 34989
23801, 33359, 33361, 33407, 33405, 33360, 33362, 33408, 33406, 34835, 34997, 34998, 34990, 34838, 35000, 35001, 
34993, 34829, 34836, 34999, 34992
23802, 33360, 33362, 33408, 33406, 9972, 9973, 9996, 9995, 34838, 35000, 35001, 34993, 0, 0, 0, 
0, 34832, 34839, 35002, 34995
23803, 8813, 8814, 8837, 8836, 33361, 33363, 33409, 33407, 9267, 9313, 9314, 9311, 34842, 35004, 35005, 
34997, 34833, 34840, 35003, 34996
23804, 33361, 33363, 33409, 33407, 33362, 33364, 33410, 33408, 34842, 35004, 35005, 34997, 34845, 35007, 35008, 
35000, 34836, 34843, 35006, 34999
23805, 33362, 33364, 33410, 33408, 9973, 9974, 9997, 9996, 34845, 35007, 35008, 35000, 0, 0, 0, 
0, 34839, 34846, 35009, 35002
23806, 8814, 8815, 8838, 8837, 33363, 33365, 33411, 33409, 9269, 9315, 9316, 9313, 34849, 35011, 35012, 
35004, 34840, 34847, 35010, 35003
23807, 33363, 33365, 33411, 33409, 33364, 33366, 33412, 33410, 34849, 35011, 35012, 35004, 34852, 35014, 35015, 
35007, 34843, 34850, 35013, 35006
23808, 33364, 33366, 33412, 33410, 9974, 9975, 9998, 9997, 34852, 35014, 35015, 35007, 0, 0, 0, 
0, 34846, 34853, 35016, 35009
23809, 8815, 8816, 8839, 8838, 33365, 33367, 33413, 33411, 9271, 9317, 9318, 9315, 34856, 35018, 35019, 
35011, 34847, 34854, 35017, 35010
23810, 33365, 33367, 33413, 33411, 33366, 33368, 33414, 33412, 34856, 35018, 35019, 35011, 34859, 35021, 35022, 
35014, 34850, 34857, 35020, 35013
23811, 33366, 33368, 33414, 33412, 9975, 9976, 9999, 9998, 34859, 35021, 35022, 35014, 0, 0, 0, 
0, 34853, 34860, 35023, 35016
23812, 8816, 8817, 8840, 8839, 33367, 33369, 33415, 33413, 9273, 9319, 9320, 9317, 34863, 35025, 35026, 
35018, 34854, 34861, 35024, 35017
23813, 33367, 33369, 33415, 33413, 33368, 33370, 33416, 33414, 34863, 35025, 35026, 35018, 34866, 35028, 35029, 
35021, 34857, 34864, 35027, 35020
23814, 33368, 33370, 33416, 33414, 9976, 9977, 10000, 9999, 34866, 35028, 35029, 35021, 0, 0, 0, 
0, 34860, 34867, 35030, 35023
23815, 8817, 8818, 8841, 8840, 33369, 33371, 33417, 33415, 9275, 9321, 9322, 9319, 34870, 35032, 35033, 
35025, 34861, 34868, 35031, 35024
23816, 33369, 33371, 33417, 33415, 33370, 33372, 33418, 33416, 34870, 35032, 35033, 35025, 34873, 35035, 35036, 
35028, 34864, 34871, 35034, 35027
23817, 33370, 33372, 33418, 33416, 9977, 9978, 10001, 10000, 34873, 35035, 35036, 35028, 0, 0, 0, 
0, 34867, 34874, 35037, 35030
23818, 8818, 8819, 8842, 8841, 33371, 33373, 33419, 33417, 9277, 9323, 9324, 9321, 34877, 35039, 35040, 
35032, 34868, 34875, 35038, 35031
23819, 33371, 33373, 33419, 33417, 33372, 33374, 33420, 33418, 34877, 35039, 35040, 35032, 34880, 35042, 35043, 
35035, 34871, 34878, 35041, 35034
23820, 33372, 33374, 33420, 33418, 9978, 9979, 10002, 10001, 34880, 35042, 35043, 35035, 0, 0, 0, 
0, 34874, 34881, 35044, 35037
23821, 8819, 8820, 8843, 8842, 33373, 33375, 33421, 33419, 9279, 9325, 9326, 9323, 34884, 35046, 35047, 
35039, 34875, 34882, 35045, 35038
23822, 33373, 33375, 33421, 33419, 33374, 33376, 33422, 33420, 34884, 35046, 35047, 35039, 34887, 35049, 35050, 
35042, 34878, 34885, 35048, 35041
23823, 33374, 33376, 33422, 33420, 9979, 9980, 10003, 10002, 34887, 35049, 35050, 35042, 0, 0, 0, 
0, 34881, 34888, 35051, 35044
23824, 8820, 8821, 8844, 8843, 33375, 33377, 33423, 33421, 9281, 9327, 9328, 9325, 34891, 35053, 35054, 
35046, 34882, 34889, 35052, 35045
23825, 33375, 33377, 33423, 33421, 33376, 33378, 33424, 33422, 34891, 35053, 35054, 35046, 34894, 35056, 35057, 
35049, 34885, 34892, 35055, 35048
23826, 33376, 33378, 33424, 33422, 9980, 9981, 10004, 10003, 34894, 35056, 35057, 35049, 0, 0, 0, 
0, 34888, 34895, 35058, 35051
23827, 8821, 8822, 8845, 8844, 33377, 33379, 33425, 33423, 9283, 9329, 9330, 9327, 34898, 35060, 35061, 
35053, 34889, 34896, 35059, 35052
23828, 33377, 33379, 33425, 33423, 33378, 33380, 33426, 33424, 34898, 35060, 35061, 35053, 34901, 35063, 35064, 
35056, 34892, 34899, 35062, 35055
23829, 33378, 33380, 33426, 33424, 9981, 9982, 10005, 10004, 34901, 35063, 35064, 35056, 0, 0, 0, 
0, 34895, 34902, 35065, 35058
23830, 8822, 8823, 8846, 8845, 33379, 33381, 33427, 33425, 9285, 9331, 9332, 9329, 34905, 35067, 35068, 
35060, 34896, 34903, 35066, 35059
23831, 33379, 33381, 33427, 33425, 33380, 33382, 33428, 33426, 34905, 35067, 35068, 35060, 34908, 35070, 35071, 
35063, 34899, 34906, 35069, 35062
23832, 33380, 33382, 33428, 33426, 9982, 9983, 10006, 10005, 34908, 35070, 35071, 35063, 0, 0, 0, 
0, 34902, 34909, 35072, 35065
23833, 8823, 8824, 8847, 8846, 33381, 33383, 33429, 33427, 9287, 9333, 9334, 9331, 34912, 35074, 35075, 
35067, 34903, 34910, 35073, 35066
23834, 33381, 33383, 33429, 33427, 33382, 33384, 33430, 33428, 34912, 35074, 35075, 35067, 34915, 35077, 35078, 
35070, 34906, 34913, 35076, 35069
23835, 33382, 33384, 33430, 33428, 9983, 9984, 10007, 10006, 34915, 35077, 35078, 35070, 0, 0, 0, 
0, 34909, 34916, 35079, 35072
23836, 8824, 8825, 8848, 8847, 33383, 33385, 33431, 33429, 9289, 9335, 9336, 9333, 34919, 35081, 35082, 
35074, 34910, 34917, 35080, 35073
23837, 33383, 33385, 33431, 33429, 33384, 33386, 33432, 33430, 34919, 35081, 35082, 35074, 34922, 35084, 35085, 
35077, 34913, 34920, 35083, 35076
23838, 33384, 33386, 33432, 33430, 9984, 9985, 10008, 10007, 34922, 35084, 35085, 35077, 0, 0, 0, 
0, 34916, 34923, 35086, 35079
23839, 8825, 8826, 8849, 8848, 33385, 33387, 33433, 33431, 9291, 9337, 9338, 9335, 34926, 35088, 35089, 
35081, 34917, 34924, 35087, 35080
23840, 33385, 33387, 33433, 33431, 33386, 33388, 33434, 33432, 34926, 35088, 35089, 35081, 34929, 35091, 35092, 
35084, 34920, 34927, 35090, 35083
23841, 33386, 33388, 33434, 33432, 9985, 9986, 10009, 10008, 34929, 35091, 35092, 35084, 0, 0, 0, 
0, 34923, 34930, 35093, 35086
23842, 8826, 8827, 8850, 8849, 33387, 33389, 33435, 33433, 9293, 9339, 9340, 9337, 34933, 35095, 35096, 
35088, 34924, 34931, 35094, 35087
23843, 33387, 33389, 33435, 33433, 33388, 33390, 33436, 33434, 34933, 35095, 35096, 35088, 34936, 35098, 35099, 
35091, 34927, 34934, 35097, 35090
23844, 33388, 33390, 33436, 33434, 9986, 9987, 10010, 10009, 34936, 35098, 35099, 35091, 0, 0, 0, 
0, 34930, 34937, 35100, 35093
23845, 8827, 8828, 8851, 8850, 33389, 33391, 33437, 33435, 9295, 9341, 9342, 9339, 34940, 35102, 35103, 
35095, 34931, 34938, 35101, 35094
23846, 33389, 33391, 33437, 33435, 33390, 33392, 33438, 33436, 34940, 35102, 35103, 35095, 34943, 35105, 35106, 
35098, 34934, 34941, 35104, 35097
23847, 33390, 33392, 33438, 33436, 9987, 9988, 10011, 10010, 34943, 35105, 35106, 35098, 0, 0, 0, 
0, 34937, 34944, 35107, 35100
23848, 8828, 8829, 8852, 8851, 33391, 33393, 33439, 33437, 9297, 9343, 9344, 9341, 34947, 35109, 35110, 
35102, 34938, 34945, 35108, 35101
23849, 33391, 33393, 33439, 33437, 33392, 33394, 33440, 33438, 34947, 35109, 35110, 35102, 34950, 35112, 35113, 
35105, 34941, 34948, 35111, 35104
23850, 33392, 33394, 33440, 33438, 9988, 9989, 10012, 10011, 34950, 35112, 35113, 35105, 0, 0, 0, 
0, 34944, 34951, 35114, 35107
23851, 8829, 1105, 1106, 8852, 33393, 9720, 9722, 33439, 9298, 1117, 9345, 9343, 34952, 9772, 35115, 
35109, 34945, 9766, 9771, 35108
23852, 33393, 9720, 9722, 33439, 33394, 9721, 9723, 33440, 34952, 9772, 35115, 35109, 34953, 9774, 35116, 
35112, 34948, 9768, 9773, 35111
23853, 33394, 9721, 9723, 33440, 9989, 1199, 1200, 10012, 34953, 9774, 35116, 35112, 0, 0, 0, 
0, 34951, 9770, 9775, 35114
23854, 1083, 8830, 8853, 1084, 9643, 33395, 33441, 9645, 9300, 9346, 9347, 1095, 34956, 35118, 35119, 
9697, 9693, 34954, 35117, 9698
23855, 9643, 33395, 33441, 9645, 9644, 33396, 33442, 9646, 34956, 35118, 35119, 9697, 34959, 35121, 35122, 
9699, 9695, 34957, 35120, 9700
23856, 9644, 33396, 33442, 9646, 1189, 9990, 10013, 1190, 34959, 35121, 35122, 9699, 0, 0, 0, 
0, 9696, 34960, 35123, 9701
23857, 8830, 8831, 8854, 8853, 33395, 33397, 33443, 33441, 9302, 9348, 9349, 9346, 34963, 35125, 35126, 
35118, 34954, 34961, 35124, 35117
23858, 33395, 33397, 33443, 33441, 33396, 33398, 33444, 33442, 34963, 35125, 35126, 35118, 34966, 35128, 35129, 
35121, 34957, 34964, 35127, 35120
23859, 33396, 33398, 33444, 33442, 9990, 9991, 10014, 10013, 34966, 35128, 35129, 35121, 0, 0, 0, 
0, 34960, 34967, 35130, 35123
23860, 8831, 8832, 8855, 8854, 33397, 33399, 33445, 33443, 9304, 9350, 9351, 9348, 34970, 35132, 35133, 
35125, 34961, 34968, 35131, 35124
23861, 33397, 33399, 33445, 33443, 33398, 33400, 33446, 33444, 34970, 35132, 35133, 35125, 34973, 35135, 35136, 
35128, 34964, 34971, 35134, 35127
23862, 33398, 33400, 33446, 33444, 9991, 9992, 10015, 10014, 34973, 35135, 35136, 35128, 0, 0, 0, 
0, 34967, 34974, 35137, 35130
23863, 8832, 8833, 8856, 8855, 33399, 33401, 33447, 33445, 9306, 9352, 9353, 9350, 34977, 35139, 35140, 
35132, 34968, 34975, 35138, 35131
23864, 33399, 33401, 33447, 33445, 33400, 33402, 33448, 33446, 34977, 35139, 35140, 35132, 34980, 35142, 35143, 
35135, 34971, 34978, 35141, 35134
23865, 33400, 33402, 33448, 33446, 9992, 9993, 10016, 10015, 34980, 35142, 35143, 35135, 0, 0, 0, 
0, 34974, 34981, 35144, 35137
23866, 8833, 8834, 8857, 8856, 33401, 33403, 33449, 33447, 9308, 9354, 9355, 9352, 34984, 35146, 35147, 
35139, 34975, 34982, 35145, 35138
23867, 33401, 33403, 33449, 33447, 33402, 33404, 33450, 33448, 34984, 35146, 35147, 35139, 34987, 35149, 35150, 
35142, 34978, 34985, 35148, 35141
23868, 33402, 33404, 33450, 33448, 9993, 9994, 10017, 10016, 34987, 35149, 35150, 35142, 0, 0, 0, 
0, 34981, 34988, 35151, 35144
23869, 8834, 8835, 8858, 8857, 33403, 33405, 33451, 33449, 9310, 9356, 9357, 9354, 34991, 35153, 35154, 
35146, 34982, 34989, 35152, 35145
23870, 33403, 33405, 33451, 33449, 33404, 33406, 33452, 33450, 34991, 35153, 35154, 35146, 34994, 35156, 35157, 
35149, 34985, 34992, 35155, 35148
23871, 33404, 33406, 33452, 33450, 9994, 9995, 10018, 10017, 34994, 35156, 35157, 35149, 0, 0, 0, 
0, 34988, 34995, 35158, 35151
23872, 8835, 8836, 8859, 8858, 33405, 33407, 33453, 33451, 9312, 9358, 9359, 9356, 34998, 35160, 35161, 
35153, 34989, 34996, 35159, 35152
23873, 33405, 33407, 33453, 33451, 33406, 33408, 33454, 33452, 34998, 35160, 35161, 35153, 35001, 35163, 35164, 
35156, 34992, 34999, 35162, 35155
23874, 33406, 33408, 33454, 33452, 9995, 9996, 10019, 10018, 35001, 35163, 35164, 35156, 0, 0, 0, 
0, 34995, 35002, 35165, 35158
23875, 8836, 8837, 8860, 8859, 33407, 33409, 33455, 33453, 9314, 9360, 9361, 9358, 35005, 35167, 35168, 
35160, 34996, 35003, 35166, 35159
23876, 33407, 33409, 33455, 33453, 33408, 33410, 33456, 33454, 35005, 35167, 35168, 35160, 35008, 35170, 35171, 
35163, 34999, 35006, 35169, 35162
23877, 33408, 33410, 33456, 33454, 9996, 9997, 10020, 10019, 35008, 35170, 35171, 35163, 0, 0, 0, 
0, 35002, 35009, 35172, 35165
23878, 8837, 8838, 8861, 8860, 33409, 33411, 33457, 33455, 9316, 9362, 9363, 9360, 35012, 35174, 35175, 
35167, 35003, 35010, 35173, 35166
23879, 33409, 33411, 33457, 33455, 33410, 33412, 33458, 33456, 35012, 35174, 35175, 35167, 35015, 35177, 35178, 
35170, 35006, 35013, 35176, 35169
23880, 33410, 33412, 33458, 33456, 9997, 9998, 10021, 10020, 35015, 35177, 35178, 35170, 0, 0, 0, 
0, 35009, 35016, 35179, 35172
23881, 8838, 8839, 8862, 8861, 33411, 33413, 33459, 33457, 9318, 9364, 9365, 9362, 35019, 35181, 35182, 
35174, 35010, 35017, 35180, 35173
23882, 33411, 33413, 33459, 33457, 33412, 33414, 33460, 33458, 35019, 35181, 35182, 35174, 35022, 35184, 35185, 
35177, 35013, 35020, 35183, 35176
23883, 33412, 33414, 33460, 33458, 9998, 9999, 10022, 10021, 35022, 35184, 35185, 35177, 0, 0, 0, 
0, 35016, 35023, 35186, 35179
23884, 8839, 8840, 8863, 8862, 33413, 33415, 33461, 33459, 9320, 9366, 9367, 9364, 35026, 35188, 35189, 
35181, 35017, 35024, 35187, 35180
23885, 33413, 33415, 33461, 33459, 33414, 33416, 33462, 33460, 35026, 35188, 35189, 35181, 35029, 35191, 35192, 
35184, 35020, 35027, 35190, 35183
23886, 33414, 33416, 33462, 33460, 9999, 10000, 10023, 10022, 35029, 35191, 35192, 35184, 0, 0, 0, 
0, 35023, 35030, 35193, 35186
23887, 8840, 8841, 8864, 8863, 33415, 33417, 33463, 33461, 9322, 9368, 9369, 9366, 35033, 35195, 35196, 
35188, 35024, 35031, 35194, 35187
23888, 33415, 33417, 33463, 33461, 33416, 33418, 33464, 33462, 35033, 35195, 35196, 35188, 35036, 35198, 35199, 
35191, 35027, 35034, 35197, 35190
23889, 33416, 33418, 33464, 33462, 10000, 10001, 10024, 10023, 35036, 35198, 35199, 35191, 0, 0, 0, 
0, 35030, 35037, 35200, 35193
23890, 8841, 8842, 8865, 8864, 33417, 33419, 33465, 33463, 9324, 9370, 9371, 9368, 35040, 35202, 35203, 
35195, 35031, 35038, 35201, 35194
23891, 33417, 33419, 33465, 33463, 33418, 33420, 33466, 33464, 35040, 35202, 35203, 35195, 35043, 35205, 35206, 
35198, 35034, 35041, 35204, 35197
23892, 33418, 33420, 33466, 33464, 10001, 10002, 10025, 10024, 35043, 35205, 35206, 35198, 0, 0, 0, 
0, 35037, 35044, 35207, 35200
23893, 8842, 8843, 8866, 8865, 33419, 33421, 33467, 33465, 9326, 9372, 9373, 9370, 35047, 35209, 35210, 
35202, 35038, 35045, 35208, 35201
23894, 33419, 33421, 33467, 33465, 33420, 33422, 33468, 33466, 35047, 35209, 35210, 35202, 35050, 35212, 35213, 
35205, 35041, 35048, 35211, 35204
23895, 33420, 33422, 33468, 33466, 10002, 10003, 10026, 10025, 35050, 35212, 35213, 35205, 0, 0, 0, 
0, 35044, 35051, 35214, 35207
23896, 8843, 8844, 8867, 8866, 33421, 33423, 33469, 33467, 9328, 9374, 9375, 9372, 35054, 35216, 35217, 
35209, 35045, 35052, 35215, 35208
23897, 33421, 33423, 33469, 33467, 33422, 33424, 33470, 33468, 35054, 35216, 35217, 35209, 35057, 35219, 35220, 
35212, 35048, 35055, 35218, 35211
23898, 33422, 33424, 33470, 33468, 10003, 10004, 10027, 10026, 35057, 35219, 35220, 35212, 0, 0, 0, 
0, 35051, 35058, 35221, 35214
23899, 8844, 8845, 8868, 8867, 33423, 33425, 33471, 33469, 9330, 9376, 9377, 9374, 35061, 35223, 35224, 
35216, 35052, 35059, 35222, 35215
23900, 33423, 33425, 33471, 33469, 33424, 33426, 33472, 33470, 35061, 35223, 35224, 35216, 35064, 35226, 35227, 
35219, 35055, 35062, 35225, 35218
23901, 33424, 33426, 33472, 33470, 10004, 10005, 10028, 10027, 35064, 35226, 35227, 35219, 0, 0, 0, 
0, 35058, 35065, 35228, 35221
23902, 8845, 8846, 8869, 8868, 33425, 33427, 33473, 33471, 9332, 9378, 9379, 9376, 35068, 35230, 35231, 
35223, 35059, 35066, 35229, 35222
23903, 33425, 33427, 33473, 33471, 33426, 33428, 33474, 33472, 35068, 35230, 35231, 35223, 35071, 35233, 35234, 
35226, 35062, 35069, 35232, 35225
23904, 33426, 33428, 33474, 33472, 10005, 10006, 10029, 10028, 35071, 35233, 35234, 35226, 0, 0, 0, 
0, 35065, 35072, 35235, 35228
23905, 8846, 8847, 8870, 8869, 33427, 33429, 33475, 33473, 9334, 9380, 9381, 9378, 35075, 35237, 35238, 
35230, 35066, 35073, 35236, 35229
23906, 33427, 33429, 33475, 33473, 33428, 33430, 33476, 33474, 35075, 35237, 35238, 35230, 35078, 35240, 35241, 
35233, 35069, 35076, 35239, 35232
23907, 33428, 33430, 33476, 33474, 10006, 10007, 10030, 10029, 35078, 35240, 35241, 35233, 0, 0, 0, 
0, 35072, 35079, 35242, 35235
23908, 8847, 8848, 8871, 8870, 33429, 33431, 33477, 33475, 9336, 9382, 9383, 9380, 35082, 35244, 35245, 
35237, 35073, 35080, 35243, 35236
23909, 33429, 33431, 33477, 33475, 33430, 33432, 33478, 33476, 35082, 35244, 35245, 35237, 35085, 35247, 35248, 
35240, 35076, 35083, 35246, 35239
23910, 33430, 33432, 33478, 33476, 10007, 10008, 10031, 10030, 35085, 35247, 35248, 35240, 0, 0, 0, 
0, 35079, 35086, 35249, 35242
23911, 8848, 8849, 8872, 8871, 33431, 33433, 33479, 33477, 9338, 9384, 9385, 9382, 35089, 35251, 35252, 
35244, 35080, 35087, 35250, 35243
23912, 33431, 33433, 33479, 33477, 33432, 33434, 33480, 33478, 35089, 35251, 35252, 35244, 35092, 35254, 35255, 
35247, 35083, 35090, 35253, 35246
23913, 33432, 33434, 33480, 33478, 10008, 10009, 10032, 10031, 35092, 35254, 35255, 35247, 0, 0, 0, 
0, 35086, 35093, 35256, 35249
23914, 8849, 8850, 8873, 8872, 33433, 33435, 33481, 33479, 9340, 9386, 9387, 9384, 35096, 35258, 35259, 
35251, 35087, 35094, 35257, 35250
23915, 33433, 33435, 33481, 33479, 33434, 33436, 33482, 33480, 35096, 35258, 35259, 35251, 35099, 35261, 35262, 
35254, 35090, 35097, 35260, 35253
23916, 33434, 33436, 33482, 33480, 10009, 10010, 10033, 10032, 35099, 35261, 35262, 35254, 0, 0, 0, 
0, 35093, 35100, 35263, 35256
23917, 8850, 8851, 8874, 8873, 33435, 33437, 33483, 33481, 9342, 9388, 9389, 9386, 35103, 35265, 35266, 
35258, 35094, 35101, 35264, 35257
23918, 33435, 33437, 33483, 33481, 33436, 33438, 33484, 33482, 35103, 35265, 35266, 35258, 35106, 35268, 35269, 
35261, 35097, 35104, 35267, 35260
23919, 33436, 33438, 33484, 33482, 10010, 10011, 10034, 10033, 35106, 35268, 35269, 35261, 0, 0, 0, 
0, 35100, 35107, 35270, 35263
23920, 8851, 8852, 8875, 8874, 33437, 33439, 33485, 33483, 9344, 9390, 9391, 9388, 35110, 35272, 35273, 
35265, 35101, 35108, 35271, 35264
23921, 33437, 33439, 33485, 33483, 33438, 33440, 33486, 33484, 35110, 35272, 35273, 35265, 35113, 35275, 35276, 
35268, 35104, 35111, 35274, 35267
23922, 33438, 33440, 33486, 33484, 10011, 10012, 10035, 10034, 35113, 35275, 35276, 35268, 0, 0, 0, 
0, 35107, 35114, 35277, 35270
23923, 8852, 1106, 1107, 8875, 33439, 9722, 9724, 33485, 9345, 1118, 9392, 9390, 35115, 9777, 35278, 
35272, 35108, 9771, 9776, 35271
23924, 33439, 9722, 9724, 33485, 33440, 9723, 9725, 33486, 35115, 9777, 35278, 35272, 35116, 9779, 35279, 
35275, 35111, 9773, 9778, 35274
23925, 33440, 9723, 9725, 33486, 10012, 1200, 1201, 10035, 35116, 9779, 35279, 35275, 0, 0, 0, 
0, 35114, 9775, 9780, 35277
23926, 1084, 8853, 1002, 41, 9645, 33441, 9416, 1120, 9347, 9393, 0, 1096, 35119, 35280, 0, 
9702, 9698, 35117, 0, 0
23927, 9645, 33441, 9416, 1120, 9646, 33442, 9417, 1121, 35119, 35280, 0, 9702, 35122, 35281, 0, 
9703, 9700, 35120, 0, 0
23928, 9646, 33442, 9417, 1121, 1190, 10013, 1124, 45, 35122, 35281, 0, 9703, 0, 0, 0, 
0, 9701, 35123, 0, 0
23929, 8853, 8854, 1003, 1002, 33441, 33443, 9418, 9416, 9349, 9394, 0, 9393, 35126, 35282, 0, 
35280, 35117, 35124, 0, 0
23930, 33441, 33443, 9418, 9416, 33442, 33444, 9419, 9417, 35126, 35282, 0, 35280, 35129, 35283, 0, 
35281, 35120, 35127, 0, 0
23931, 33442, 33444, 9419, 9417, 10013, 10014, 1125, 1124, 35129, 35283, 0, 35281, 0, 0, 0, 
0, 35123, 35130, 0, 0
23932, 8854, 8855, 1004, 1003, 33443, 33445, 9420, 9418, 9351, 9395, 0, 9394, 35133, 35284, 0, 
35282, 35124, 35131, 0, 0
23933, 33443, 33445, 9420, 9418, 33444, 33446, 9421, 9419, 35133, 35284, 0, 35282, 35136, 35285, 0, 
35283, 35127, 35134, 0, 0
23934, 33444, 33446, 9421, 9419, 10014, 10015, 1126, 1125, 35136, 35285, 0, 35283, 0, 0, 0, 
0, 35130, 35137, 0, 0
23935, 8855, 8856, 1005, 1004, 33445, 33447, 9422, 9420, 9353, 9396, 0, 9395, 35140, 35286, 0, 
35284, 35131, 35138, 0, 0
23936, 33445, 33447, 9422, 9420, 33446, 33448, 9423, 9421, 35140, 35286, 0, 35284, 35143, 35287, 0, 
35285, 35134, 35141, 0, 0
23937, 33446, 33448, 9423, 9421, 10015, 10016, 1127, 1126, 35143, 35287, 0, 35285, 0, 0, 0, 
0, 35137, 35144, 0, 0
23938, 8856, 8857, 1006, 1005, 33447, 33449, 9424, 9422, 9355, 9397, 0, 9396, 35147, 35288, 0, 
35286, 35138, 35145, 0, 0
23939, 33447, 33449, 9424, 9422, 33448, 33450, 9425, 9423, 35147, 35288, 0, 35286, 35150, 35289, 0, 
35287, 35141, 35148, 0, 0
23940, 33448, 33450, 9425, 9423, 10016, 10017, 1128, 1127, 35150, 35289, 0, 35287, 0, 0, 0, 
0, 35144, 35151, 0, 0
23941, 8857, 8858, 1007, 1006, 33449, 33451, 9426, 9424, 9357, 9398, 0, 9397, 35154, 35290, 0, 
35288, 35145, 35152, 0, 0
23942, 33449, 33451, 9426, 9424, 33450, 33452, 9427, 9425, 35154, 35290, 0, 35288, 35157, 35291, 0, 
35289, 35148, 35155, 0, 0
23943, 33450, 33452, 9427, 9425, 10017, 10018, 1129, 1128, 35157, 35291, 0, 35289, 0, 0, 0, 
0, 35151, 35158, 0, 0
23944, 8858, 8859, 1008, 1007, 33451, 33453, 9428, 9426, 9359, 9399, 0, 9398, 35161, 35292, 0, 
35290, 35152, 35159, 0, 0
23945, 33451, 33453, 9428, 9426, 33452, 33454, 9429, 9427, 35161, 35292, 0, 35290, 35164, 35293, 0, 
35291, 35155, 35162, 0, 0
23946, 33452, 33454, 9429, 9427, 10018, 10019, 1130, 1129, 35164, 35293, 0, 35291, 0, 0, 0, 
0, 35158, 35165, 0, 0
23947, 8859, 8860, 1009, 1008, 33453, 33455, 9430, 9428, 9361, 9400, 0, 9399, 35168, 35294, 0, 
35292, 35159, 35166, 0, 0
23948, 33453, 33455, 9430, 9428, 33454, 33456, 9431, 9429, 35168, 35294, 0, 35292, 35171, 35295, 0, 
35293, 35162, 35169, 0, 0
23949, 33454, 33456, 9431, 9429, 10019, 10020, 1131, 1130, 35171, 35295, 0, 35293, 0, 0, 0, 
0, 35165, 35172, 0, 0
23950, 8860, 8861, 1010, 1009, 33455, 33457, 9432, 9430, 9363, 9401, 0, 9400, 35175, 35296, 0, 
35294, 35166, 35173, 0, 0
23951, 33455, 33457, 9432, 9430, 33456, 33458, 9433, 9431, 35175, 35296, 0, 35294, 35178, 35297, 0, 
35295, 35169, 35176, 0, 0
23952, 33456, 33458, 9433, 9431, 10020, 10021, 1132, 1131, 35178, 35297, 0, 35295, 0, 0, 0, 
0, 35172, 35179, 0, 0
23953, 8861, 8862, 1011, 1010, 33457, 33459, 9434, 9432, 9365, 9402, 0, 9401, 35182, 35298, 0, 
35296, 35173, 35180, 0, 0
23954, 33457, 33459, 9434, 9432, 33458, 33460, 9435, 9433, 35182, 35298, 0, 35296, 35185, 35299, 0, 
35297, 35176, 35183, 0, 0
23955, 33458, 33460, 9435, 9433, 10021, 10022, 1133, 1132, 35185, 35299, 0, 35297, 0, 0, 0, 
0, 35179, 35186, 0, 0
23956, 8862, 8863, 1012, 1011, 33459, 33461, 9436, 9434, 9367, 9403, 0, 9402, 35189, 35300, 0, 
35298, 35180, 35187, 0, 0
23957, 33459, 33461, 9436, 9434, 33460, 33462, 9437, 9435, 35189, 35300, 0, 35298, 35192, 35301, 0, 
35299, 35183, 35190, 0, 0
23958, 33460, 33462, 9437, 9435, 10022, 10023, 1134, 1133, 35192, 35301, 0, 35299, 0, 0, 0, 
0, 35186, 35193, 0, 0
23959, 8863, 8864, 1013, 1012, 33461, 33463, 9438, 9436, 9369, 9404, 0, 9403, 35196, 35302, 0, 
35300, 35187, 35194, 0, 0
23960, 33461, 33463, 9438, 9436, 33462, 33464, 9439, 9437, 35196, 35302, 0, 35300, 35199, 35303, 0, 
35301, 35190, 35197, 0, 0
23961, 33462, 33464, 9439, 9437, 10023, 10024, 1135, 1134, 35199, 35303, 0, 35301, 0, 0, 0, 
0, 35193, 35200, 0, 0
23962, 8864, 8865, 1014, 1013, 33463, 33465, 9440, 9438, 9371, 9405, 0, 9404, 35203, 35304, 0, 
35302, 35194, 35201, 0, 0
23963, 33463, 33465, 9440, 9438, 33464, 33466, 9441, 9439, 35203, 35304, 0, 35302, 35206, 35305, 0, 
35303, 35197, 35204, 0, 0
23964, 33464, 33466, 9441, 9439, 10024, 10025, 1136, 1135, 35206, 35305, 0, 35303, 0, 0, 0, 
0, 35200, 35207, 0, 0
23965, 8865, 8866, 1015, 1014, 33465, 33467, 9442, 9440, 9373, 9406, 0, 9405, 35210, 35306, 0, 
35304, 35201, 35208, 0, 0
23966, 33465, 33467, 9442, 9440, 33466, 33468, 9443, 9441, 35210, 35306, 0, 35304, 35213, 35307, 0, 
35305, 35204, 35211, 0, 0
23967, 33466, 33468, 9443, 9441, 10025, 10026, 1137, 1136, 35213, 35307, 0, 35305, 0, 0, 0, 
0, 35207, 35214, 0, 0
23968, 8866, 8867, 1016, 1015, 33467, 33469, 9444, 9442, 9375, 9407, 0, 9406, 35217, 35308, 0, 
35306, 35208, 35215, 0, 0
23969, 33467, 33469, 9444, 9442, 33468, 33470, 9445, 9443, 35217, 35308, 0, 35306, 35220, 35309, 0, 
35307, 35211, 35218, 0, 0
23970, 33468, 33470, 9445, 9443, 10026, 10027, 1138, 1137, 35220, 35309, 0, 35307, 0, 0, 0, 
0, 35214, 35221, 0, 0
23971, 8867, 8868, 1017, 1016, 33469, 33471, 9446, 9444, 9377, 9408, 0, 9407, 35224, 35310, 0, 
35308, 35215, 35222, 0, 0
23972, 33469, 33471, 9446, 9444, 33470, 33472, 9447, 9445, 35224, 35310, 0, 35308, 35227, 35311, 0, 
35309, 35218, 35225, 0, 0
23973, 33470, 33472, 9447, 9445, 10027, 10028, 1139, 1138, 35227, 35311, 0, 35309, 0, 0, 0, 
0, 35221, 35228, 0, 0
23974, 8868, 8869, 1018, 1017, 33471, 33473, 9448, 9446, 9379, 9409, 0, 9408, 35231, 35312, 0, 
35310, 35222, 35229, 0, 0
23975, 33471, 33473, 9448, 9446, 33472, 33474, 9449, 9447, 35231, 35312, 0, 35310, 35234, 35313, 0, 
35311, 35225, 35232, 0, 0
23976, 33472, 33474, 9449, 9447, 10028, 10029, 1140, 1139, 35234, 35313, 0, 35311, 0, 0, 0, 
0, 35228, 35235, 0, 0
23977, 8869, 8870, 1019, 1018, 33473, 33475, 9450, 9448, 9381, 9410, 0, 9409, 35238, 35314, 0, 
35312, 35229, 35236, 0, 0
23978, 33473, 33475, 9450, 9448, 33474, 33476, 9451, 9449, 35238, 35314, 0, 35312, 35241, 35315, 0, 
35313, 35232, 35239, 0, 0
23979, 33474, 33476, 9451, 9449, 10029, 10030, 1141, 1140, 35241, 35315, 0, 35313, 0, 0, 0, 
0, 35235, 35242, 0, 0
23980, 8870, 8871, 1020, 1019, 33475, 33477, 9452, 9450, 9383, 9411, 0, 9410, 35245, 35316, 0, 
35314, 35236, 35243, 0, 0
23981, 33475, 33477, 9452, 9450, 33476, 33478, 9453, 9451, 35245, 35316, 0, 35314, 35248, 35317, 0, 
35315, 35239, 35246, 0, 0
23982, 33476, 33478, 9453, 9451, 10030, 10031, 1142, 1141, 35248, 35317, 0, 35315, 0, 0, 0, 
0, 35242, 35249, 0, 0
23983, 8871, 8872, 1021, 1020, 33477, 33479, 9454, 9452, 9385, 9412, 0, 9411, 35252, 35318, 0, 
35316, 35243, 35250, 0, 0
23984, 33477, 33479, 9454, 9452, 33478, 33480, 9455, 9453, 35252, 35318, 0, 35316, 35255, 35319, 0, 
35317, 35246, 35253, 0, 0
23985, 33478, 33480, 9455, 9453, 10031, 10032, 1143, 1142, 35255, 35319, 0, 35317, 0, 0, 0, 
0, 35249, 35256, 0, 0
23986, 8872, 8873, 1022, 1021, 33479, 33481, 9456, 9454, 9387, 9413, 0, 9412, 35259, 35320, 0, 
35318, 35250, 35257, 0, 0
23987, 33479, 33481, 9456, 9454, 33480, 33482, 9457, 9455, 35259, 35320, 0, 35318, 35262, 35321, 0, 
35319, 35253, 35260, 0, 0
23988, 33480, 33482, 9457, 9455, 10032, 10033, 1144, 1143, 35262, 35321, 0, 35319, 0, 0, 0, 
0, 35256, 35263, 0, 0
23989, 8873, 8874, 1023, 1022, 33481, 33483, 9458, 9456, 9389, 9414, 0, 9413, 35266, 35322, 0, 
35320, 35257, 35264, 0, 0
23990, 33481, 33483, 9458, 9456, 33482, 33484, 9459, 9457, 35266, 35322, 0, 35320, 35269, 35323, 0, 
35321, 35260, 35267, 0, 0
23991, 33482, 33484, 9459, 9457, 10033, 10034, 1145, 1144, 35269, 35323, 0, 35321, 0, 0, 0, 
0, 35263, 35270, 0, 0
23992, 8874, 8875, 1024, 1023, 33483, 33485, 9460, 9458, 9391, 9415, 0, 9414, 35273, 35324, 0, 
35322, 35264, 35271, 0, 0
23993, 33483, 33485, 9460, 9458, 33484, 33486, 9461, 9459, 35273, 35324, 0, 35322, 35276, 35325, 0, 
35323, 35267, 35274, 0, 0
23994, 33484, 33486, 9461, 9459, 10034, 10035, 1146, 1145, 35276, 35325, 0, 35323, 0, 0, 0, 
0, 35270, 35277, 0, 0
23995, 8875, 1107, 42, 1024, 33485, 9724, 1122, 9460, 9392, 1119, 0, 9415, 35278, 9781, 0, 
35324, 35271, 9776, 0, 0
23996, 33485, 9724, 1122, 9460, 33486, 9725, 1123, 9461, 35278, 9781, 0, 35324, 35279, 9782, 0, 
35325, 35274, 9778, 0, 0
23997, 33486, 9725, 1123, 9461, 10035, 1201, 46, 1146, 35279, 9782, 0, 35325, 0, 0, 0, 
0, 35277, 9780, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume12
23998, 44, 1097, 9704, 1152, 51, 1206, 10036, 1204, 1108, 9726, 9727, 1154, 0, 0, 0, 
0, 35326, 35327, 35328, 35329
23999, 1152, 9704, 9705, 1153, 1204, 10036, 10037, 1205, 9727, 9728, 9729, 1155, 0, 0, 0, 
0, 35329, 35328, 35330, 35331
24000, 1153, 9705, 1191, 48, 1205, 10037, 1217, 52, 9729, 9730, 0, 1156, 0, 0, 0, 
0, 35331, 35330, 0, 0
24001, 1097, 1098, 9706, 9704, 1206, 1207, 10038, 10036, 1109, 9731, 9732, 9726, 0, 0, 0, 
0, 35327, 35332, 35333, 35328
24002, 9704, 9706, 9707, 9705, 10036, 10038, 10039, 10037, 9732, 9733, 9734, 9728, 0, 0, 0, 
0, 35328, 35333, 35334, 35330
24003, 9705, 9707, 1192, 1191, 10037, 10039, 1218, 1217, 9734, 9735, 0, 9730, 0, 0, 0, 
0, 35330, 35334, 0, 0
24004, 1098, 1099, 9708, 9706, 1207, 1208, 10040, 10038, 1110, 9736, 9737, 9731, 0, 0, 0, 
0, 35332, 35335, 35336, 35333
24005, 9706, 9708, 9709, 9707, 10038, 10040, 10041, 10039, 9737, 9738, 9739, 9733, 0, 0, 0, 
0, 35333, 35336, 35337, 35334
24006, 9707, 9709, 1193, 1192, 10039, 10041, 1219, 1218, 9739, 9740, 0, 9735, 0, 0, 0, 
0, 35334, 35337, 0, 0
24007, 1099, 1100, 9710, 9708, 1208, 1209, 10042, 10040, 1111, 9741, 9742, 9736, 0, 0, 0, 
0, 35335, 35338, 35339, 35336
24008, 9708, 9710, 9711, 9709, 10040, 10042, 10043, 10041, 9742, 9743, 9744, 9738, 0, 0, 0, 
0, 35336, 35339, 35340, 35337
24009, 9709, 9711, 1194, 1193, 10041, 10043, 1220, 1219, 9744, 9745, 0, 9740, 0, 0, 0, 
0, 35337, 35340, 0, 0
24010, 1100, 1101, 9712, 9710, 1209, 1210, 10044, 10042, 1112, 9746, 9747, 9741, 0, 0, 0, 
0, 35338, 35341, 35342, 35339
24011, 9710, 9712, 9713, 9711, 10042, 10044, 10045, 10043, 9747, 9748, 9749, 9743, 0, 0, 0, 
0, 35339, 35342, 35343, 35340
24012, 9711, 9713, 1195, 1194, 10043, 10045, 1221, 1220, 9749, 9750, 0, 9745, 0, 0, 0, 
0, 35340, 35343, 0, 0
24013, 1101, 1102, 9714, 9712, 1210, 1211, 10046, 10044, 1113, 9751, 9752, 9746, 0, 0, 0, 
0, 35341, 35344, 35345, 35342
24014, 9712, 9714, 9715, 9713, 10044, 10046, 10047, 10045, 9752, 9753, 9754, 9748, 0, 0, 0, 
0, 35342, 35345, 35346, 35343
24015, 9713, 9715, 1196, 1195, 10045, 10047, 1222, 1221, 9754, 9755, 0, 9750, 0, 0, 0, 
0, 35343, 35346, 0, 0
24016, 1102, 1103, 9716, 9714, 1211, 1212, 10048, 10046, 1114, 9756, 9757, 9751, 0, 0, 0, 
0, 35344, 35347, 35348, 35345
24017, 9714, 9716, 9717, 9715, 10046, 10048, 10049, 10047, 9757, 9758, 9759, 9753, 0, 0, 0, 
0, 35345, 35348, 35349, 35346
24018, 9715, 9717, 1197, 1196, 10047, 10049, 1223, 1222, 9759, 9760, 0, 9755, 0, 0, 0, 
0, 35346, 35349, 0, 0
24019, 1103, 1104, 9718, 9716, 1212, 1213, 10050, 10048, 1115, 9761, 9762, 9756, 0, 0, 0, 
0, 35347, 35350, 35351, 35348
24020, 9716, 9718, 9719, 9717, 10048, 10050, 10051, 10049, 9762, 9763, 9764, 9758, 0, 0, 0, 
0, 35348, 35351, 35352, 35349
24021, 9717, 9719, 1198, 1197, 10049, 10051, 1224, 1223, 9764, 9765, 0, 9760, 0, 0, 0, 
0, 35349, 35352, 0, 0
24022, 1104, 1105, 9720, 9718, 1213, 1214, 10052, 10050, 1116, 9766, 9767, 9761, 0, 0, 0, 
0, 35350, 35353, 35354, 35351
24023, 9718, 9720, 9721, 9719, 10050, 10052, 10053, 10051, 9767, 9768, 9769, 9763, 0, 0, 0, 
0, 35351, 35354, 35355, 35352
24024, 9719, 9721, 1199, 1198, 10051, 10053, 1225, 1224, 9769, 9770, 0, 9765, 0, 0, 0, 
0, 35352, 35355, 0, 0
24025, 1105, 1106, 9722, 9720, 1214, 1215, 10054, 10052, 1117, 9771, 9772, 9766, 0, 0, 0, 
0, 35353, 35356, 35357, 35354
24026, 9720, 9722, 9723, 9721, 10052, 10054, 10055, 10053, 9772, 9773, 9774, 9768, 0, 0, 0, 
0, 35354, 35357, 35358, 35355
24027, 9721, 9723, 1200, 1199, 10053, 10055, 1226, 1225, 9774, 9775, 0, 9770, 0, 0, 0, 
0, 35355, 35358, 0, 0
24028, 1106, 1107, 9724, 9722, 1215, 1216, 10056, 10054, 1118, 9776, 9777, 9771, 0, 0, 0, 
0, 35356, 35359, 35360, 35357
24029, 9722, 9724, 9725, 9723, 10054, 10056, 10057, 10055, 9777, 9778, 9779, 9773, 0, 0, 0, 
0, 35357, 35360, 35361, 35358
24030, 9723, 9725, 1201, 1200, 10055, 10057, 1227, 1226, 9779, 9780, 0, 9775, 0, 0, 0, 
0, 35358, 35361, 0, 0
24031, 1107, 42, 1122, 9724, 1216, 49, 1202, 10056, 1119, 0, 9781, 9776, 0, 0, 0, 
0, 35359, 0, 0, 35360
24032, 9724, 1122, 1123, 9725, 10056, 1202, 1203, 10057, 9781, 0, 9782, 9778, 0, 0, 0, 
0, 35360, 0, 0, 35361
24033, 9725, 1123, 46, 1201, 10057, 1203, 50, 1227, 9782, 0, 0, 9780, 0, 0, 0, 
0, 35361, 0, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume13
24034, 2, 98, 2408, 122, 54, 1228, 10058, 1252, 97, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 35362, 35363
24035, 122, 2408, 2409, 123, 1252, 10058, 10059, 1253, 0, 0, 0, 0, 0, 0, 0, 
0, 35363, 35362, 35364, 35365
24036, 123, 2409, 111, 4, 1253, 10059, 1241, 56, 0, 0, 0, 0, 0, 0, 0, 
0, 35365, 35364, 35366, 35367
24037, 98, 99, 2410, 2408, 1228, 1229, 10060, 10058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 35368, 35362
24038, 2408, 2410, 2411, 2409, 10058, 10060, 10061, 10059, 0, 0, 0, 0, 0, 0, 0, 
0, 35362, 35368, 35369, 35364
24039, 2409, 2411, 112, 111, 10059, 10061, 1242, 1241, 0, 0, 0, 0, 0, 0, 0, 
0, 35364, 35369, 35370, 35366
24040, 99, 100, 2412, 2410, 1229, 1230, 10062, 10060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 35371, 35368
24041, 2410, 2412, 2413, 2411, 10060, 10062, 10063, 10061, 0, 0, 0, 0, 0, 0, 0, 
0, 35368, 35371, 35372, 35369
24042, 2411, 2413, 113, 112, 10061, 10063, 1243, 1242, 0, 0, 0, 0, 0, 0, 0, 
0, 35369, 35372, 35373, 35370
24043, 100, 101, 2414, 2412, 1230, 1231, 10064, 10062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 35374, 35371
24044, 2412, 2414, 2415, 2413, 10062, 10064, 10065, 10063, 0, 0, 0, 0, 0, 0, 0, 
0, 35371, 35374, 35375, 35372
24045, 2413, 2415, 114, 113, 10063, 10065, 1244, 1243, 0, 0, 0, 0, 0, 0, 0, 
0, 35372, 35375, 35376, 35373
24046, 101, 102, 2416, 2414, 1231, 1232, 10066, 10064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 35377, 35374
24047, 2414, 2416, 2417, 2415, 10064, 10066, 10067, 10065, 0, 0, 0, 0, 0, 0, 0, 
0, 35374, 35377, 35378, 35375
24048, 2415, 2417, 115, 114, 10065, 10067, 1245, 1244, 0, 0, 0, 0, 0, 0, 0, 
0, 35375, 35378, 35379, 35376
24049, 102, 103, 2418, 2416, 1232, 1233, 10068, 10066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 35380, 35377
24050, 2416, 2418, 2419, 2417, 10066, 10068, 10069, 10067, 0, 0, 0, 0, 0, 0, 0, 
0, 35377, 35380, 35381, 35378
24051, 2417, 2419, 116, 115, 10067, 10069, 1246, 1245, 0, 0, 0, 0, 0, 0, 0, 
0, 35378, 35381, 35382, 35379
24052, 103, 104, 2420, 2418, 1233, 1234, 10070, 10068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 35383, 35380
24053, 2418, 2420, 2421, 2419, 10068, 10070, 10071, 10069, 0, 0, 0, 0, 0, 0, 0, 
0, 35380, 35383, 35384, 35381
24054, 2419, 2421, 117, 116, 10069, 10071, 1247, 1246, 0, 0, 0, 0, 0, 0, 0, 
0, 35381, 35384, 35385, 35382
24055, 104, 105, 2422, 2420, 1234, 1235, 10072, 10070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 35386, 35383
24056, 2420, 2422, 2423, 2421, 10070, 10072, 10073, 10071, 0, 0, 0, 0, 0, 0, 0, 
0, 35383, 35386, 35387, 35384
24057, 2421, 2423, 118, 117, 10071, 10073, 1248, 1247, 0, 0, 0, 0, 0, 0, 0, 
0, 35384, 35387, 35388, 35385
24058, 105, 106, 2424, 2422, 1235, 1236, 10074, 10072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 35389, 35386
24059, 2422, 2424, 2425, 2423, 10072, 10074, 10075, 10073, 0, 0, 0, 0, 0, 0, 0, 
0, 35386, 35389, 35390, 35387
24060, 2423, 2425, 119, 118, 10073, 10075, 1249, 1248, 0, 0, 0, 0, 0, 0, 0, 
0, 35387, 35390, 35391, 35388
24061, 106, 107, 2426, 2424, 1236, 1237, 10076, 10074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 35392, 35389
24062, 2424, 2426, 2427, 2425, 10074, 10076, 10077, 10075, 0, 0, 0, 0, 0, 0, 0, 
0, 35389, 35392, 35393, 35390
24063, 2425, 2427, 120, 119, 10075, 10077, 1250, 1249, 0, 0, 0, 0, 0, 0, 0, 
0, 35390, 35393, 35394, 35391
24064, 107, 108, 2428, 2426, 1237, 1238, 10078, 10076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 35395, 35392
24065, 2426, 2428, 2429, 2427, 10076, 10078, 10079, 10077, 0, 0, 0, 0, 0, 0, 0, 
0, 35392, 35395, 35396, 35393
24066, 2427, 2429, 121, 120, 10077, 10079, 1251, 1250, 0, 0, 0, 0, 0, 0, 0, 
0, 35393, 35396, 35397, 35394
24067, 108, 1, 109, 2428, 1238, 53, 1239, 10078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 35395
24068, 2428, 109, 110, 2429, 10078, 1239, 1240, 10079, 0, 0, 0, 0, 0, 0, 0, 
0, 35395, 0, 0, 35396
24069, 2429, 110, 3, 121, 10079, 1240, 55, 1251, 0, 0, 0, 0, 0, 0, 0, 
0, 35396, 0, 0, 35397
*ELEMENT, type=C3D20, ELSET=Volume14
24070, 10, 333, 3303, 242, 67, 1541, 11848, 1588, 0, 0, 0, 0, 1564, 12377, 12378, 
1611, 1539, 11779, 35398, 11802
24071, 333, 334, 3304, 3303, 1541, 1542, 11849, 11848, 0, 0, 0, 0, 1565, 12379, 12380, 
12377, 11779, 11780, 35399, 35398
24072, 334, 335, 3305, 3304, 1542, 1543, 11850, 11849, 0, 0, 0, 0, 1566, 12381, 12382, 
12379, 11780, 11781, 35400, 35399
24073, 335, 336, 3306, 3305, 1543, 1544, 11851, 11850, 0, 0, 0, 0, 1567, 12383, 12384, 
12381, 11781, 11782, 35401, 35400
24074, 336, 337, 3307, 3306, 1544, 1545, 11852, 11851, 0, 0, 0, 0, 1568, 12385, 12386, 
12383, 11782, 11783, 35402, 35401
24075, 337, 338, 3308, 3307, 1545, 1546, 11853, 11852, 0, 0, 0, 0, 1569, 12387, 12388, 
12385, 11783, 11784, 35403, 35402
24076, 338, 339, 3309, 3308, 1546, 1547, 11854, 11853, 0, 0, 0, 0, 1570, 12389, 12390, 
12387, 11784, 11785, 35404, 35403
24077, 339, 340, 3310, 3309, 1547, 1548, 11855, 11854, 0, 0, 0, 0, 1571, 12391, 12392, 
12389, 11785, 11786, 35405, 35404
24078, 340, 341, 3311, 3310, 1548, 1549, 11856, 11855, 0, 0, 0, 0, 1572, 12393, 12394, 
12391, 11786, 11787, 35406, 35405
24079, 341, 342, 3312, 3311, 1549, 1550, 11857, 11856, 0, 0, 0, 0, 1573, 12395, 12396, 
12393, 11787, 11788, 35407, 35406
24080, 342, 343, 3313, 3312, 1550, 1551, 11858, 11857, 0, 0, 0, 0, 1574, 12397, 12398, 
12395, 11788, 11789, 35408, 35407
24081, 343, 344, 3314, 3313, 1551, 1552, 11859, 11858, 0, 0, 0, 0, 1575, 12399, 12400, 
12397, 11789, 11790, 35409, 35408
24082, 344, 345, 3315, 3314, 1552, 1553, 11860, 11859, 0, 0, 0, 0, 1576, 12401, 12402, 
12399, 11790, 11791, 35410, 35409
24083, 345, 346, 3316, 3315, 1553, 1554, 11861, 11860, 0, 0, 0, 0, 1577, 12403, 12404, 
12401, 11791, 11792, 35411, 35410
24084, 346, 347, 3317, 3316, 1554, 1555, 11862, 11861, 0, 0, 0, 0, 1578, 12405, 12406, 
12403, 11792, 11793, 35412, 35411
24085, 347, 348, 3318, 3317, 1555, 1556, 11863, 11862, 0, 0, 0, 0, 1579, 12407, 12408, 
12405, 11793, 11794, 35413, 35412
24086, 348, 349, 3319, 3318, 1556, 1557, 11864, 11863, 0, 0, 0, 0, 1580, 12409, 12410, 
12407, 11794, 11795, 35414, 35413
24087, 349, 350, 3320, 3319, 1557, 1558, 11865, 11864, 0, 0, 0, 0, 1581, 12411, 12412, 
12409, 11795, 11796, 35415, 35414
24088, 350, 351, 3321, 3320, 1558, 1559, 11866, 11865, 0, 0, 0, 0, 1582, 12413, 12414, 
12411, 11796, 11797, 35416, 35415
24089, 351, 352, 3322, 3321, 1559, 1560, 11867, 11866, 0, 0, 0, 0, 1583, 12415, 12416, 
12413, 11797, 11798, 35417, 35416
24090, 352, 353, 3323, 3322, 1560, 1561, 11868, 11867, 0, 0, 0, 0, 1584, 12417, 12418, 
12415, 11798, 11799, 35418, 35417
24091, 353, 354, 3324, 3323, 1561, 1562, 11869, 11868, 0, 0, 0, 0, 1585, 12419, 12420, 
12417, 11799, 11800, 35419, 35418
24092, 354, 355, 3325, 3324, 1562, 1563, 11870, 11869, 0, 0, 0, 0, 1586, 12421, 12422, 
12419, 11800, 11801, 35420, 35419
24093, 355, 14, 356, 3325, 1563, 68, 1635, 11870, 0, 0, 0, 0, 1587, 1658, 12423, 
12421, 11801, 1540, 11825, 35420
24094, 242, 3303, 3326, 243, 1588, 11848, 11871, 1589, 0, 0, 0, 0, 12378, 12424, 12425, 
1612, 11802, 35398, 35421, 11803
24095, 3303, 3304, 3327, 3326, 11848, 11849, 11872, 11871, 0, 0, 0, 0, 12380, 12426, 12427, 
12424, 35398, 35399, 35422, 35421
24096, 3304, 3305, 3328, 3327, 11849, 11850, 11873, 11872, 0, 0, 0, 0, 12382, 12428, 12429, 
12426, 35399, 35400, 35423, 35422
24097, 3305, 3306, 3329, 3328, 11850, 11851, 11874, 11873, 0, 0, 0, 0, 12384, 12430, 12431, 
12428, 35400, 35401, 35424, 35423
24098, 3306, 3307, 3330, 3329, 11851, 11852, 11875, 11874, 0, 0, 0, 0, 12386, 12432, 12433, 
12430, 35401, 35402, 35425, 35424
24099, 3307, 3308, 3331, 3330, 11852, 11853, 11876, 11875, 0, 0, 0, 0, 12388, 12434, 12435, 
12432, 35402, 35403, 35426, 35425
24100, 3308, 3309, 3332, 3331, 11853, 11854, 11877, 11876, 0, 0, 0, 0, 12390, 12436, 12437, 
12434, 35403, 35404, 35427, 35426
24101, 3309, 3310, 3333, 3332, 11854, 11855, 11878, 11877, 0, 0, 0, 0, 12392, 12438, 12439, 
12436, 35404, 35405, 35428, 35427
24102, 3310, 3311, 3334, 3333, 11855, 11856, 11879, 11878, 0, 0, 0, 0, 12394, 12440, 12441, 
12438, 35405, 35406, 35429, 35428
24103, 3311, 3312, 3335, 3334, 11856, 11857, 11880, 11879, 0, 0, 0, 0, 12396, 12442, 12443, 
12440, 35406, 35407, 35430, 35429
24104, 3312, 3313, 3336, 3335, 11857, 11858, 11881, 11880, 0, 0, 0, 0, 12398, 12444, 12445, 
12442, 35407, 35408, 35431, 35430
24105, 3313, 3314, 3337, 3336, 11858, 11859, 11882, 11881, 0, 0, 0, 0, 12400, 12446, 12447, 
12444, 35408, 35409, 35432, 35431
24106, 3314, 3315, 3338, 3337, 11859, 11860, 11883, 11882, 0, 0, 0, 0, 12402, 12448, 12449, 
12446, 35409, 35410, 35433, 35432
24107, 3315, 3316, 3339, 3338, 11860, 11861, 11884, 11883, 0, 0, 0, 0, 12404, 12450, 12451, 
12448, 35410, 35411, 35434, 35433
24108, 3316, 3317, 3340, 3339, 11861, 11862, 11885, 11884, 0, 0, 0, 0, 12406, 12452, 12453, 
12450, 35411, 35412, 35435, 35434
24109, 3317, 3318, 3341, 3340, 11862, 11863, 11886, 11885, 0, 0, 0, 0, 12408, 12454, 12455, 
12452, 35412, 35413, 35436, 35435
24110, 3318, 3319, 3342, 3341, 11863, 11864, 11887, 11886, 0, 0, 0, 0, 12410, 12456, 12457, 
12454, 35413, 35414, 35437, 35436
24111, 3319, 3320, 3343, 3342, 11864, 11865, 11888, 11887, 0, 0, 0, 0, 12412, 12458, 12459, 
12456, 35414, 35415, 35438, 35437
24112, 3320, 3321, 3344, 3343, 11865, 11866, 11889, 11888, 0, 0, 0, 0, 12414, 12460, 12461, 
12458, 35415, 35416, 35439, 35438
24113, 3321, 3322, 3345, 3344, 11866, 11867, 11890, 11889, 0, 0, 0, 0, 12416, 12462, 12463, 
12460, 35416, 35417, 35440, 35439
24114, 3322, 3323, 3346, 3345, 11867, 11868, 11891, 11890, 0, 0, 0, 0, 12418, 12464, 12465, 
12462, 35417, 35418, 35441, 35440
24115, 3323, 3324, 3347, 3346, 11868, 11869, 11892, 11891, 0, 0, 0, 0, 12420, 12466, 12467, 
12464, 35418, 35419, 35442, 35441
24116, 3324, 3325, 3348, 3347, 11869, 11870, 11893, 11892, 0, 0, 0, 0, 12422, 12468, 12469, 
12466, 35419, 35420, 35443, 35442
24117, 3325, 356, 357, 3348, 11870, 1635, 1636, 11893, 0, 0, 0, 0, 12423, 1659, 12470, 
12468, 35420, 11825, 11826, 35443
24118, 243, 3326, 3349, 244, 1589, 11871, 11894, 1590, 0, 0, 0, 0, 12425, 12471, 12472, 
1613, 11803, 35421, 35444, 11804
24119, 3326, 3327, 3350, 3349, 11871, 11872, 11895, 11894, 0, 0, 0, 0, 12427, 12473, 12474, 
12471, 35421, 35422, 35445, 35444
24120, 3327, 3328, 3351, 3350, 11872, 11873, 11896, 11895, 0, 0, 0, 0, 12429, 12475, 12476, 
12473, 35422, 35423, 35446, 35445
24121, 3328, 3329, 3352, 3351, 11873, 11874, 11897, 11896, 0, 0, 0, 0, 12431, 12477, 12478, 
12475, 35423, 35424, 35447, 35446
24122, 3329, 3330, 3353, 3352, 11874, 11875, 11898, 11897, 0, 0, 0, 0, 12433, 12479, 12480, 
12477, 35424, 35425, 35448, 35447
24123, 3330, 3331, 3354, 3353, 11875, 11876, 11899, 11898, 0, 0, 0, 0, 12435, 12481, 12482, 
12479, 35425, 35426, 35449, 35448
24124, 3331, 3332, 3355, 3354, 11876, 11877, 11900, 11899, 0, 0, 0, 0, 12437, 12483, 12484, 
12481, 35426, 35427, 35450, 35449
24125, 3332, 3333, 3356, 3355, 11877, 11878, 11901, 11900, 0, 0, 0, 0, 12439, 12485, 12486, 
12483, 35427, 35428, 35451, 35450
24126, 3333, 3334, 3357, 3356, 11878, 11879, 11902, 11901, 0, 0, 0, 0, 12441, 12487, 12488, 
12485, 35428, 35429, 35452, 35451
24127, 3334, 3335, 3358, 3357, 11879, 11880, 11903, 11902, 0, 0, 0, 0, 12443, 12489, 12490, 
12487, 35429, 35430, 35453, 35452
24128, 3335, 3336, 3359, 3358, 11880, 11881, 11904, 11903, 0, 0, 0, 0, 12445, 12491, 12492, 
12489, 35430, 35431, 35454, 35453
24129, 3336, 3337, 3360, 3359, 11881, 11882, 11905, 11904, 0, 0, 0, 0, 12447, 12493, 12494, 
12491, 35431, 35432, 35455, 35454
24130, 3337, 3338, 3361, 3360, 11882, 11883, 11906, 11905, 0, 0, 0, 0, 12449, 12495, 12496, 
12493, 35432, 35433, 35456, 35455
24131, 3338, 3339, 3362, 3361, 11883, 11884, 11907, 11906, 0, 0, 0, 0, 12451, 12497, 12498, 
12495, 35433, 35434, 35457, 35456
24132, 3339, 3340, 3363, 3362, 11884, 11885, 11908, 11907, 0, 0, 0, 0, 12453, 12499, 12500, 
12497, 35434, 35435, 35458, 35457
24133, 3340, 3341, 3364, 3363, 11885, 11886, 11909, 11908, 0, 0, 0, 0, 12455, 12501, 12502, 
12499, 35435, 35436, 35459, 35458
24134, 3341, 3342, 3365, 3364, 11886, 11887, 11910, 11909, 0, 0, 0, 0, 12457, 12503, 12504, 
12501, 35436, 35437, 35460, 35459
24135, 3342, 3343, 3366, 3365, 11887, 11888, 11911, 11910, 0, 0, 0, 0, 12459, 12505, 12506, 
12503, 35437, 35438, 35461, 35460
24136, 3343, 3344, 3367, 3366, 11888, 11889, 11912, 11911, 0, 0, 0, 0, 12461, 12507, 12508, 
12505, 35438, 35439, 35462, 35461
24137, 3344, 3345, 3368, 3367, 11889, 11890, 11913, 11912, 0, 0, 0, 0, 12463, 12509, 12510, 
12507, 35439, 35440, 35463, 35462
24138, 3345, 3346, 3369, 3368, 11890, 11891, 11914, 11913, 0, 0, 0, 0, 12465, 12511, 12512, 
12509, 35440, 35441, 35464, 35463
24139, 3346, 3347, 3370, 3369, 11891, 11892, 11915, 11914, 0, 0, 0, 0, 12467, 12513, 12514, 
12511, 35441, 35442, 35465, 35464
24140, 3347, 3348, 3371, 3370, 11892, 11893, 11916, 11915, 0, 0, 0, 0, 12469, 12515, 12516, 
12513, 35442, 35443, 35466, 35465
24141, 3348, 357, 358, 3371, 11893, 1636, 1637, 11916, 0, 0, 0, 0, 12470, 1660, 12517, 
12515, 35443, 11826, 11827, 35466
24142, 244, 3349, 3372, 245, 1590, 11894, 11917, 1591, 0, 0, 0, 0, 12472, 12518, 12519, 
1614, 11804, 35444, 35467, 11805
24143, 3349, 3350, 3373, 3372, 11894, 11895, 11918, 11917, 0, 0, 0, 0, 12474, 12520, 12521, 
12518, 35444, 35445, 35468, 35467
24144, 3350, 3351, 3374, 3373, 11895, 11896, 11919, 11918, 0, 0, 0, 0, 12476, 12522, 12523, 
12520, 35445, 35446, 35469, 35468
24145, 3351, 3352, 3375, 3374, 11896, 11897, 11920, 11919, 0, 0, 0, 0, 12478, 12524, 12525, 
12522, 35446, 35447, 35470, 35469
24146, 3352, 3353, 3376, 3375, 11897, 11898, 11921, 11920, 0, 0, 0, 0, 12480, 12526, 12527, 
12524, 35447, 35448, 35471, 35470
24147, 3353, 3354, 3377, 3376, 11898, 11899, 11922, 11921, 0, 0, 0, 0, 12482, 12528, 12529, 
12526, 35448, 35449, 35472, 35471
24148, 3354, 3355, 3378, 3377, 11899, 11900, 11923, 11922, 0, 0, 0, 0, 12484, 12530, 12531, 
12528, 35449, 35450, 35473, 35472
24149, 3355, 3356, 3379, 3378, 11900, 11901, 11924, 11923, 0, 0, 0, 0, 12486, 12532, 12533, 
12530, 35450, 35451, 35474, 35473
24150, 3356, 3357, 3380, 3379, 11901, 11902, 11925, 11924, 0, 0, 0, 0, 12488, 12534, 12535, 
12532, 35451, 35452, 35475, 35474
24151, 3357, 3358, 3381, 3380, 11902, 11903, 11926, 11925, 0, 0, 0, 0, 12490, 12536, 12537, 
12534, 35452, 35453, 35476, 35475
24152, 3358, 3359, 3382, 3381, 11903, 11904, 11927, 11926, 0, 0, 0, 0, 12492, 12538, 12539, 
12536, 35453, 35454, 35477, 35476
24153, 3359, 3360, 3383, 3382, 11904, 11905, 11928, 11927, 0, 0, 0, 0, 12494, 12540, 12541, 
12538, 35454, 35455, 35478, 35477
24154, 3360, 3361, 3384, 3383, 11905, 11906, 11929, 11928, 0, 0, 0, 0, 12496, 12542, 12543, 
12540, 35455, 35456, 35479, 35478
24155, 3361, 3362, 3385, 3384, 11906, 11907, 11930, 11929, 0, 0, 0, 0, 12498, 12544, 12545, 
12542, 35456, 35457, 35480, 35479
24156, 3362, 3363, 3386, 3385, 11907, 11908, 11931, 11930, 0, 0, 0, 0, 12500, 12546, 12547, 
12544, 35457, 35458, 35481, 35480
24157, 3363, 3364, 3387, 3386, 11908, 11909, 11932, 11931, 0, 0, 0, 0, 12502, 12548, 12549, 
12546, 35458, 35459, 35482, 35481
24158, 3364, 3365, 3388, 3387, 11909, 11910, 11933, 11932, 0, 0, 0, 0, 12504, 12550, 12551, 
12548, 35459, 35460, 35483, 35482
24159, 3365, 3366, 3389, 3388, 11910, 11911, 11934, 11933, 0, 0, 0, 0, 12506, 12552, 12553, 
12550, 35460, 35461, 35484, 35483
24160, 3366, 3367, 3390, 3389, 11911, 11912, 11935, 11934, 0, 0, 0, 0, 12508, 12554, 12555, 
12552, 35461, 35462, 35485, 35484
24161, 3367, 3368, 3391, 3390, 11912, 11913, 11936, 11935, 0, 0, 0, 0, 12510, 12556, 12557, 
12554, 35462, 35463, 35486, 35485
24162, 3368, 3369, 3392, 3391, 11913, 11914, 11937, 11936, 0, 0, 0, 0, 12512, 12558, 12559, 
12556, 35463, 35464, 35487, 35486
24163, 3369, 3370, 3393, 3392, 11914, 11915, 11938, 11937, 0, 0, 0, 0, 12514, 12560, 12561, 
12558, 35464, 35465, 35488, 35487
24164, 3370, 3371, 3394, 3393, 11915, 11916, 11939, 11938, 0, 0, 0, 0, 12516, 12562, 12563, 
12560, 35465, 35466, 35489, 35488
24165, 3371, 358, 359, 3394, 11916, 1637, 1638, 11939, 0, 0, 0, 0, 12517, 1661, 12564, 
12562, 35466, 11827, 11828, 35489
24166, 245, 3372, 3395, 246, 1591, 11917, 11940, 1592, 0, 0, 0, 0, 12519, 12565, 12566, 
1615, 11805, 35467, 35490, 11806
24167, 3372, 3373, 3396, 3395, 11917, 11918, 11941, 11940, 0, 0, 0, 0, 12521, 12567, 12568, 
12565, 35467, 35468, 35491, 35490
24168, 3373, 3374, 3397, 3396, 11918, 11919, 11942, 11941, 0, 0, 0, 0, 12523, 12569, 12570, 
12567, 35468, 35469, 35492, 35491
24169, 3374, 3375, 3398, 3397, 11919, 11920, 11943, 11942, 0, 0, 0, 0, 12525, 12571, 12572, 
12569, 35469, 35470, 35493, 35492
24170, 3375, 3376, 3399, 3398, 11920, 11921, 11944, 11943, 0, 0, 0, 0, 12527, 12573, 12574, 
12571, 35470, 35471, 35494, 35493
24171, 3376, 3377, 3400, 3399, 11921, 11922, 11945, 11944, 0, 0, 0, 0, 12529, 12575, 12576, 
12573, 35471, 35472, 35495, 35494
24172, 3377, 3378, 3401, 3400, 11922, 11923, 11946, 11945, 0, 0, 0, 0, 12531, 12577, 12578, 
12575, 35472, 35473, 35496, 35495
24173, 3378, 3379, 3402, 3401, 11923, 11924, 11947, 11946, 0, 0, 0, 0, 12533, 12579, 12580, 
12577, 35473, 35474, 35497, 35496
24174, 3379, 3380, 3403, 3402, 11924, 11925, 11948, 11947, 0, 0, 0, 0, 12535, 12581, 12582, 
12579, 35474, 35475, 35498, 35497
24175, 3380, 3381, 3404, 3403, 11925, 11926, 11949, 11948, 0, 0, 0, 0, 12537, 12583, 12584, 
12581, 35475, 35476, 35499, 35498
24176, 3381, 3382, 3405, 3404, 11926, 11927, 11950, 11949, 0, 0, 0, 0, 12539, 12585, 12586, 
12583, 35476, 35477, 35500, 35499
24177, 3382, 3383, 3406, 3405, 11927, 11928, 11951, 11950, 0, 0, 0, 0, 12541, 12587, 12588, 
12585, 35477, 35478, 35501, 35500
24178, 3383, 3384, 3407, 3406, 11928, 11929, 11952, 11951, 0, 0, 0, 0, 12543, 12589, 12590, 
12587, 35478, 35479, 35502, 35501
24179, 3384, 3385, 3408, 3407, 11929, 11930, 11953, 11952, 0, 0, 0, 0, 12545, 12591, 12592, 
12589, 35479, 35480, 35503, 35502
24180, 3385, 3386, 3409, 3408, 11930, 11931, 11954, 11953, 0, 0, 0, 0, 12547, 12593, 12594, 
12591, 35480, 35481, 35504, 35503
24181, 3386, 3387, 3410, 3409, 11931, 11932, 11955, 11954, 0, 0, 0, 0, 12549, 12595, 12596, 
12593, 35481, 35482, 35505, 35504
24182, 3387, 3388, 3411, 3410, 11932, 11933, 11956, 11955, 0, 0, 0, 0, 12551, 12597, 12598, 
12595, 35482, 35483, 35506, 35505
24183, 3388, 3389, 3412, 3411, 11933, 11934, 11957, 11956, 0, 0, 0, 0, 12553, 12599, 12600, 
12597, 35483, 35484, 35507, 35506
24184, 3389, 3390, 3413, 3412, 11934, 11935, 11958, 11957, 0, 0, 0, 0, 12555, 12601, 12602, 
12599, 35484, 35485, 35508, 35507
24185, 3390, 3391, 3414, 3413, 11935, 11936, 11959, 11958, 0, 0, 0, 0, 12557, 12603, 12604, 
12601, 35485, 35486, 35509, 35508
24186, 3391, 3392, 3415, 3414, 11936, 11937, 11960, 11959, 0, 0, 0, 0, 12559, 12605, 12606, 
12603, 35486, 35487, 35510, 35509
24187, 3392, 3393, 3416, 3415, 11937, 11938, 11961, 11960, 0, 0, 0, 0, 12561, 12607, 12608, 
12605, 35487, 35488, 35511, 35510
24188, 3393, 3394, 3417, 3416, 11938, 11939, 11962, 11961, 0, 0, 0, 0, 12563, 12609, 12610, 
12607, 35488, 35489, 35512, 35511
24189, 3394, 359, 360, 3417, 11939, 1638, 1639, 11962, 0, 0, 0, 0, 12564, 1662, 12611, 
12609, 35489, 11828, 11829, 35512
24190, 246, 3395, 3418, 247, 1592, 11940, 11963, 1593, 0, 0, 0, 0, 12566, 12612, 12613, 
1616, 11806, 35490, 35513, 11807
24191, 3395, 3396, 3419, 3418, 11940, 11941, 11964, 11963, 0, 0, 0, 0, 12568, 12614, 12615, 
12612, 35490, 35491, 35514, 35513
24192, 3396, 3397, 3420, 3419, 11941, 11942, 11965, 11964, 0, 0, 0, 0, 12570, 12616, 12617, 
12614, 35491, 35492, 35515, 35514
24193, 3397, 3398, 3421, 3420, 11942, 11943, 11966, 11965, 0, 0, 0, 0, 12572, 12618, 12619, 
12616, 35492, 35493, 35516, 35515
24194, 3398, 3399, 3422, 3421, 11943, 11944, 11967, 11966, 0, 0, 0, 0, 12574, 12620, 12621, 
12618, 35493, 35494, 35517, 35516
24195, 3399, 3400, 3423, 3422, 11944, 11945, 11968, 11967, 0, 0, 0, 0, 12576, 12622, 12623, 
12620, 35494, 35495, 35518, 35517
24196, 3400, 3401, 3424, 3423, 11945, 11946, 11969, 11968, 0, 0, 0, 0, 12578, 12624, 12625, 
12622, 35495, 35496, 35519, 35518
24197, 3401, 3402, 3425, 3424, 11946, 11947, 11970, 11969, 0, 0, 0, 0, 12580, 12626, 12627, 
12624, 35496, 35497, 35520, 35519
24198, 3402, 3403, 3426, 3425, 11947, 11948, 11971, 11970, 0, 0, 0, 0, 12582, 12628, 12629, 
12626, 35497, 35498, 35521, 35520
24199, 3403, 3404, 3427, 3426, 11948, 11949, 11972, 11971, 0, 0, 0, 0, 12584, 12630, 12631, 
12628, 35498, 35499, 35522, 35521
24200, 3404, 3405, 3428, 3427, 11949, 11950, 11973, 11972, 0, 0, 0, 0, 12586, 12632, 12633, 
12630, 35499, 35500, 35523, 35522
24201, 3405, 3406, 3429, 3428, 11950, 11951, 11974, 11973, 0, 0, 0, 0, 12588, 12634, 12635, 
12632, 35500, 35501, 35524, 35523
24202, 3406, 3407, 3430, 3429, 11951, 11952, 11975, 11974, 0, 0, 0, 0, 12590, 12636, 12637, 
12634, 35501, 35502, 35525, 35524
24203, 3407, 3408, 3431, 3430, 11952, 11953, 11976, 11975, 0, 0, 0, 0, 12592, 12638, 12639, 
12636, 35502, 35503, 35526, 35525
24204, 3408, 3409, 3432, 3431, 11953, 11954, 11977, 11976, 0, 0, 0, 0, 12594, 12640, 12641, 
12638, 35503, 35504, 35527, 35526
24205, 3409, 3410, 3433, 3432, 11954, 11955, 11978, 11977, 0, 0, 0, 0, 12596, 12642, 12643, 
12640, 35504, 35505, 35528, 35527
24206, 3410, 3411, 3434, 3433, 11955, 11956, 11979, 11978, 0, 0, 0, 0, 12598, 12644, 12645, 
12642, 35505, 35506, 35529, 35528
24207, 3411, 3412, 3435, 3434, 11956, 11957, 11980, 11979, 0, 0, 0, 0, 12600, 12646, 12647, 
12644, 35506, 35507, 35530, 35529
24208, 3412, 3413, 3436, 3435, 11957, 11958, 11981, 11980, 0, 0, 0, 0, 12602, 12648, 12649, 
12646, 35507, 35508, 35531, 35530
24209, 3413, 3414, 3437, 3436, 11958, 11959, 11982, 11981, 0, 0, 0, 0, 12604, 12650, 12651, 
12648, 35508, 35509, 35532, 35531
24210, 3414, 3415, 3438, 3437, 11959, 11960, 11983, 11982, 0, 0, 0, 0, 12606, 12652, 12653, 
12650, 35509, 35510, 35533, 35532
24211, 3415, 3416, 3439, 3438, 11960, 11961, 11984, 11983, 0, 0, 0, 0, 12608, 12654, 12655, 
12652, 35510, 35511, 35534, 35533
24212, 3416, 3417, 3440, 3439, 11961, 11962, 11985, 11984, 0, 0, 0, 0, 12610, 12656, 12657, 
12654, 35511, 35512, 35535, 35534
24213, 3417, 360, 361, 3440, 11962, 1639, 1640, 11985, 0, 0, 0, 0, 12611, 1663, 12658, 
12656, 35512, 11829, 11830, 35535
24214, 247, 3418, 3441, 248, 1593, 11963, 11986, 1594, 0, 0, 0, 0, 12613, 12659, 12660, 
1617, 11807, 35513, 35536, 11808
24215, 3418, 3419, 3442, 3441, 11963, 11964, 11987, 11986, 0, 0, 0, 0, 12615, 12661, 12662, 
12659, 35513, 35514, 35537, 35536
24216, 3419, 3420, 3443, 3442, 11964, 11965, 11988, 11987, 0, 0, 0, 0, 12617, 12663, 12664, 
12661, 35514, 35515, 35538, 35537
24217, 3420, 3421, 3444, 3443, 11965, 11966, 11989, 11988, 0, 0, 0, 0, 12619, 12665, 12666, 
12663, 35515, 35516, 35539, 35538
24218, 3421, 3422, 3445, 3444, 11966, 11967, 11990, 11989, 0, 0, 0, 0, 12621, 12667, 12668, 
12665, 35516, 35517, 35540, 35539
24219, 3422, 3423, 3446, 3445, 11967, 11968, 11991, 11990, 0, 0, 0, 0, 12623, 12669, 12670, 
12667, 35517, 35518, 35541, 35540
24220, 3423, 3424, 3447, 3446, 11968, 11969, 11992, 11991, 0, 0, 0, 0, 12625, 12671, 12672, 
12669, 35518, 35519, 35542, 35541
24221, 3424, 3425, 3448, 3447, 11969, 11970, 11993, 11992, 0, 0, 0, 0, 12627, 12673, 12674, 
12671, 35519, 35520, 35543, 35542
24222, 3425, 3426, 3449, 3448, 11970, 11971, 11994, 11993, 0, 0, 0, 0, 12629, 12675, 12676, 
12673, 35520, 35521, 35544, 35543
24223, 3426, 3427, 3450, 3449, 11971, 11972, 11995, 11994, 0, 0, 0, 0, 12631, 12677, 12678, 
12675, 35521, 35522, 35545, 35544
24224, 3427, 3428, 3451, 3450, 11972, 11973, 11996, 11995, 0, 0, 0, 0, 12633, 12679, 12680, 
12677, 35522, 35523, 35546, 35545
24225, 3428, 3429, 3452, 3451, 11973, 11974, 11997, 11996, 0, 0, 0, 0, 12635, 12681, 12682, 
12679, 35523, 35524, 35547, 35546
24226, 3429, 3430, 3453, 3452, 11974, 11975, 11998, 11997, 0, 0, 0, 0, 12637, 12683, 12684, 
12681, 35524, 35525, 35548, 35547
24227, 3430, 3431, 3454, 3453, 11975, 11976, 11999, 11998, 0, 0, 0, 0, 12639, 12685, 12686, 
12683, 35525, 35526, 35549, 35548
24228, 3431, 3432, 3455, 3454, 11976, 11977, 12000, 11999, 0, 0, 0, 0, 12641, 12687, 12688, 
12685, 35526, 35527, 35550, 35549
24229, 3432, 3433, 3456, 3455, 11977, 11978, 12001, 12000, 0, 0, 0, 0, 12643, 12689, 12690, 
12687, 35527, 35528, 35551, 35550
24230, 3433, 3434, 3457, 3456, 11978, 11979, 12002, 12001, 0, 0, 0, 0, 12645, 12691, 12692, 
12689, 35528, 35529, 35552, 35551
24231, 3434, 3435, 3458, 3457, 11979, 11980, 12003, 12002, 0, 0, 0, 0, 12647, 12693, 12694, 
12691, 35529, 35530, 35553, 35552
24232, 3435, 3436, 3459, 3458, 11980, 11981, 12004, 12003, 0, 0, 0, 0, 12649, 12695, 12696, 
12693, 35530, 35531, 35554, 35553
24233, 3436, 3437, 3460, 3459, 11981, 11982, 12005, 12004, 0, 0, 0, 0, 12651, 12697, 12698, 
12695, 35531, 35532, 35555, 35554
24234, 3437, 3438, 3461, 3460, 11982, 11983, 12006, 12005, 0, 0, 0, 0, 12653, 12699, 12700, 
12697, 35532, 35533, 35556, 35555
24235, 3438, 3439, 3462, 3461, 11983, 11984, 12007, 12006, 0, 0, 0, 0, 12655, 12701, 12702, 
12699, 35533, 35534, 35557, 35556
24236, 3439, 3440, 3463, 3462, 11984, 11985, 12008, 12007, 0, 0, 0, 0, 12657, 12703, 12704, 
12701, 35534, 35535, 35558, 35557
24237, 3440, 361, 362, 3463, 11985, 1640, 1641, 12008, 0, 0, 0, 0, 12658, 1664, 12705, 
12703, 35535, 11830, 11831, 35558
24238, 248, 3441, 3464, 249, 1594, 11986, 12009, 1595, 0, 0, 0, 0, 12660, 12706, 12707, 
1618, 11808, 35536, 35559, 11809
24239, 3441, 3442, 3465, 3464, 11986, 11987, 12010, 12009, 0, 0, 0, 0, 12662, 12708, 12709, 
12706, 35536, 35537, 35560, 35559
24240, 3442, 3443, 3466, 3465, 11987, 11988, 12011, 12010, 0, 0, 0, 0, 12664, 12710, 12711, 
12708, 35537, 35538, 35561, 35560
24241, 3443, 3444, 3467, 3466, 11988, 11989, 12012, 12011, 0, 0, 0, 0, 12666, 12712, 12713, 
12710, 35538, 35539, 35562, 35561
24242, 3444, 3445, 3468, 3467, 11989, 11990, 12013, 12012, 0, 0, 0, 0, 12668, 12714, 12715, 
12712, 35539, 35540, 35563, 35562
24243, 3445, 3446, 3469, 3468, 11990, 11991, 12014, 12013, 0, 0, 0, 0, 12670, 12716, 12717, 
12714, 35540, 35541, 35564, 35563
24244, 3446, 3447, 3470, 3469, 11991, 11992, 12015, 12014, 0, 0, 0, 0, 12672, 12718, 12719, 
12716, 35541, 35542, 35565, 35564
24245, 3447, 3448, 3471, 3470, 11992, 11993, 12016, 12015, 0, 0, 0, 0, 12674, 12720, 12721, 
12718, 35542, 35543, 35566, 35565
24246, 3448, 3449, 3472, 3471, 11993, 11994, 12017, 12016, 0, 0, 0, 0, 12676, 12722, 12723, 
12720, 35543, 35544, 35567, 35566
24247, 3449, 3450, 3473, 3472, 11994, 11995, 12018, 12017, 0, 0, 0, 0, 12678, 12724, 12725, 
12722, 35544, 35545, 35568, 35567
24248, 3450, 3451, 3474, 3473, 11995, 11996, 12019, 12018, 0, 0, 0, 0, 12680, 12726, 12727, 
12724, 35545, 35546, 35569, 35568
24249, 3451, 3452, 3475, 3474, 11996, 11997, 12020, 12019, 0, 0, 0, 0, 12682, 12728, 12729, 
12726, 35546, 35547, 35570, 35569
24250, 3452, 3453, 3476, 3475, 11997, 11998, 12021, 12020, 0, 0, 0, 0, 12684, 12730, 12731, 
12728, 35547, 35548, 35571, 35570
24251, 3453, 3454, 3477, 3476, 11998, 11999, 12022, 12021, 0, 0, 0, 0, 12686, 12732, 12733, 
12730, 35548, 35549, 35572, 35571
24252, 3454, 3455, 3478, 3477, 11999, 12000, 12023, 12022, 0, 0, 0, 0, 12688, 12734, 12735, 
12732, 35549, 35550, 35573, 35572
24253, 3455, 3456, 3479, 3478, 12000, 12001, 12024, 12023, 0, 0, 0, 0, 12690, 12736, 12737, 
12734, 35550, 35551, 35574, 35573
24254, 3456, 3457, 3480, 3479, 12001, 12002, 12025, 12024, 0, 0, 0, 0, 12692, 12738, 12739, 
12736, 35551, 35552, 35575, 35574
24255, 3457, 3458, 3481, 3480, 12002, 12003, 12026, 12025, 0, 0, 0, 0, 12694, 12740, 12741, 
12738, 35552, 35553, 35576, 35575
24256, 3458, 3459, 3482, 3481, 12003, 12004, 12027, 12026, 0, 0, 0, 0, 12696, 12742, 12743, 
12740, 35553, 35554, 35577, 35576
24257, 3459, 3460, 3483, 3482, 12004, 12005, 12028, 12027, 0, 0, 0, 0, 12698, 12744, 12745, 
12742, 35554, 35555, 35578, 35577
24258, 3460, 3461, 3484, 3483, 12005, 12006, 12029, 12028, 0, 0, 0, 0, 12700, 12746, 12747, 
12744, 35555, 35556, 35579, 35578
24259, 3461, 3462, 3485, 3484, 12006, 12007, 12030, 12029, 0, 0, 0, 0, 12702, 12748, 12749, 
12746, 35556, 35557, 35580, 35579
24260, 3462, 3463, 3486, 3485, 12007, 12008, 12031, 12030, 0, 0, 0, 0, 12704, 12750, 12751, 
12748, 35557, 35558, 35581, 35580
