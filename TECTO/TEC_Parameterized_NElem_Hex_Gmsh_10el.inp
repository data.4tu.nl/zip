25585, 0.95833333333333, 0.5, 0.083333333333333
25586, 0.95833333333333, 0.55, 0.083333333333333
25587, 0.95833333333333, 0.6, 0.083333333333333
25588, 0.95833333333333, 0.65, 0.083333333333333
25589, 0.95833333333333, 0.7, 0.083333333333333
25590, 0.95833333333333, 0.75, 0.083333333333333
25591, 0.95833333333333, 0.8, 0.083333333333333
25592, 0.95833333333333, 0.85, 0.083333333333333
25593, 0.95833333333333, 0.9, 0.083333333333333
25594, 0.95833333333333, 0.95, 0.083333333333333
25595, 0.95833333333333, 1, 0.083333333333333
25596, 0.95833333333333, 1.05, 0.083333333333333
25597, 0.95833333333333, 1.1, 0.083333333333333
25598, 0.95833333333333, 1.15, 0.083333333333333
25599, 0.95833333333333, 1.2, 0.083333333333333
25600, 0.95833333333333, 1.25, 0.083333333333333
25601, 0.95833333333333, 1.3, 0.083333333333333
25602, 0.95833333333333, 0.2, 0.125
25603, 0.95833333333333, 0.25, 0.125
25604, 0.95833333333333, 0.3, 0.125
25605, 0.95833333333333, 0.35, 0.125
25606, 0.95833333333333, 0.4, 0.125
25607, 0.95833333333333, 0.45, 0.125
25608, 0.95833333333333, 0.5, 0.125
25609, 0.95833333333333, 0.55, 0.125
25610, 0.95833333333333, 0.6, 0.125
25611, 0.95833333333333, 0.65, 0.125
25612, 0.95833333333333, 0.7, 0.125
25613, 0.95833333333333, 0.75, 0.125
25614, 0.95833333333333, 0.8, 0.125
25615, 0.95833333333333, 0.85, 0.125
25616, 0.95833333333333, 0.9, 0.125
25617, 0.95833333333333, 0.95, 0.125
25618, 0.95833333333333, 1, 0.125
25619, 0.95833333333333, 1.05, 0.125
25620, 0.95833333333333, 1.1, 0.125
25621, 0.95833333333333, 1.15, 0.125
25622, 0.95833333333333, 1.2, 0.125
25623, 0.95833333333333, 1.25, 0.125
25624, 0.95833333333333, 1.3, 0.125
25625, 0.95833333333333, 0.2, 0.16666666666667
25626, 0.95833333333333, 0.25, 0.16666666666667
25627, 0.95833333333333, 0.3, 0.16666666666667
25628, 0.95833333333333, 0.35, 0.16666666666667
25629, 0.95833333333333, 0.4, 0.16666666666667
25630, 0.95833333333333, 0.45, 0.16666666666667
25631, 0.95833333333333, 0.5, 0.16666666666667
25632, 0.95833333333333, 0.55, 0.16666666666667
25633, 0.95833333333333, 0.6, 0.16666666666667
25634, 0.95833333333333, 0.65, 0.16666666666667
25635, 0.95833333333333, 0.7, 0.16666666666667
25636, 0.95833333333333, 0.75, 0.16666666666667
25637, 0.95833333333333, 0.8, 0.16666666666667
25638, 0.95833333333333, 0.85, 0.16666666666667
25639, 0.95833333333333, 0.9, 0.16666666666667
25640, 0.95833333333333, 0.95, 0.16666666666667
25641, 0.95833333333333, 1, 0.16666666666667
25642, 0.95833333333333, 1.05, 0.16666666666667
25643, 0.95833333333333, 1.1, 0.16666666666667
25644, 0.95833333333333, 1.15, 0.16666666666667
25645, 0.95833333333333, 1.2, 0.16666666666667
25646, 0.95833333333333, 1.25, 0.16666666666667
25647, 0.95833333333333, 1.3, 0.16666666666667
25648, 0.95833333333333, 0.2, 0.20833333333333
25649, 0.95833333333333, 0.25, 0.20833333333333
25650, 0.95833333333333, 0.3, 0.20833333333333
25651, 0.95833333333333, 0.35, 0.20833333333333
25652, 0.95833333333333, 0.4, 0.20833333333333
25653, 0.95833333333333, 0.45, 0.20833333333333
25654, 0.95833333333333, 0.5, 0.20833333333333
25655, 0.95833333333333, 0.55, 0.20833333333333
25656, 0.95833333333333, 0.6, 0.20833333333333
25657, 0.95833333333333, 0.65, 0.20833333333333
25658, 0.95833333333333, 0.7, 0.20833333333333
25659, 0.95833333333333, 0.75, 0.20833333333333
25660, 0.95833333333333, 0.8, 0.20833333333333
25661, 0.95833333333333, 0.85, 0.20833333333333
25662, 0.95833333333333, 0.9, 0.20833333333333
25663, 0.95833333333333, 0.95, 0.20833333333333
25664, 0.95833333333333, 1, 0.20833333333333
25665, 0.95833333333333, 1.05, 0.20833333333333
25666, 0.95833333333333, 1.1, 0.20833333333333
25667, 0.95833333333333, 1.15, 0.20833333333333
25668, 0.95833333333333, 1.2, 0.20833333333333
25669, 0.95833333333333, 1.25, 0.20833333333333
25670, 0.95833333333333, 1.3, 0.20833333333333
25671, 0.95833333333333, 0.2, 0.25
25672, 0.95833333333333, 0.25, 0.25
25673, 0.95833333333333, 0.3, 0.25
25674, 0.95833333333333, 0.35, 0.25
25675, 0.95833333333333, 0.4, 0.25
25676, 0.95833333333333, 0.45, 0.25
25677, 0.95833333333333, 0.5, 0.25
25678, 0.95833333333333, 0.55, 0.25
25679, 0.95833333333333, 0.6, 0.25
25680, 0.95833333333333, 0.65, 0.25
25681, 0.95833333333333, 0.7, 0.25
25682, 0.95833333333333, 0.75, 0.25
25683, 0.95833333333333, 0.8, 0.25
25684, 0.95833333333333, 0.85, 0.25
25685, 0.95833333333333, 0.9, 0.25
25686, 0.95833333333333, 0.95, 0.25
25687, 0.95833333333333, 1, 0.25
25688, 0.95833333333333, 1.05, 0.25
25689, 0.95833333333333, 1.1, 0.25
25690, 0.95833333333333, 1.15, 0.25
25691, 0.95833333333333, 1.2, 0.25
25692, 0.95833333333333, 1.25, 0.25
25693, 0.95833333333333, 1.3, 0.25
25694, 0.95833333333333, 0.2, 0.29166666666667
25695, 0.95833333333333, 0.25, 0.29166666666667
25696, 0.95833333333333, 0.3, 0.29166666666667
25697, 0.95833333333333, 0.35, 0.29166666666667
25698, 0.95833333333333, 0.4, 0.29166666666667
25699, 0.95833333333333, 0.45, 0.29166666666667
25700, 0.95833333333333, 0.5, 0.29166666666667
25701, 0.95833333333333, 0.55, 0.29166666666667
25702, 0.95833333333333, 0.6, 0.29166666666667
25703, 0.95833333333333, 0.65, 0.29166666666667
25704, 0.95833333333333, 0.7, 0.29166666666667
25705, 0.95833333333333, 0.75, 0.29166666666667
25706, 0.95833333333333, 0.8, 0.29166666666667
25707, 0.95833333333333, 0.85, 0.29166666666667
25708, 0.95833333333333, 0.9, 0.29166666666667
25709, 0.95833333333333, 0.95, 0.29166666666667
25710, 0.95833333333333, 1, 0.29166666666667
25711, 0.95833333333333, 1.05, 0.29166666666667
25712, 0.95833333333333, 1.1, 0.29166666666667
25713, 0.95833333333333, 1.15, 0.29166666666667
25714, 0.95833333333333, 1.2, 0.29166666666667
25715, 0.95833333333333, 1.25, 0.29166666666667
25716, 0.95833333333333, 1.3, 0.29166666666667
25717, 0.95833333333333, 0.2, 0.33333333333333
25718, 0.95833333333333, 0.25, 0.33333333333333
25719, 0.95833333333333, 0.3, 0.33333333333333
25720, 0.95833333333333, 0.35, 0.33333333333333
25721, 0.95833333333333, 0.4, 0.33333333333333
25722, 0.95833333333333, 0.45, 0.33333333333333
25723, 0.95833333333333, 0.5, 0.33333333333333
25724, 0.95833333333333, 0.55, 0.33333333333333
25725, 0.95833333333333, 0.6, 0.33333333333333
25726, 0.95833333333333, 0.65, 0.33333333333333
25727, 0.95833333333333, 0.7, 0.33333333333333
25728, 0.95833333333333, 0.75, 0.33333333333333
25729, 0.95833333333333, 0.8, 0.33333333333333
25730, 0.95833333333333, 0.85, 0.33333333333333
25731, 0.95833333333333, 0.9, 0.33333333333333
25732, 0.95833333333333, 0.95, 0.33333333333333
25733, 0.95833333333333, 1, 0.33333333333333
25734, 0.95833333333333, 1.05, 0.33333333333333
25735, 0.95833333333333, 1.1, 0.33333333333333
25736, 0.95833333333333, 1.15, 0.33333333333333
25737, 0.95833333333333, 1.2, 0.33333333333333
25738, 0.95833333333333, 1.25, 0.33333333333333
25739, 0.95833333333333, 1.3, 0.33333333333333
25740, 0.95833333333333, 0.2, 0.375
25741, 0.95833333333333, 0.25, 0.375
25742, 0.95833333333333, 0.3, 0.375
25743, 0.95833333333333, 0.35, 0.375
25744, 0.95833333333333, 0.4, 0.375
25745, 0.95833333333333, 0.45, 0.375
25746, 0.95833333333333, 0.5, 0.375
25747, 0.95833333333333, 0.55, 0.375
25748, 0.95833333333333, 0.6, 0.375
25749, 0.95833333333333, 0.65, 0.375
25750, 0.95833333333333, 0.7, 0.375
25751, 0.95833333333333, 0.75, 0.375
25752, 0.95833333333333, 0.8, 0.375
25753, 0.95833333333333, 0.85, 0.375
25754, 0.95833333333333, 0.9, 0.375
25755, 0.95833333333333, 0.95, 0.375
25756, 0.95833333333333, 1, 0.375
25757, 0.95833333333333, 1.05, 0.375
25758, 0.95833333333333, 1.1, 0.375
25759, 0.95833333333333, 1.15, 0.375
25760, 0.95833333333333, 1.2, 0.375
25761, 0.95833333333333, 1.25, 0.375
25762, 0.95833333333333, 1.3, 0.375
25763, 0.95833333333333, 0.2, 0.41666666666667
25764, 0.95833333333333, 0.25, 0.41666666666667
25765, 0.95833333333333, 0.3, 0.41666666666667
25766, 0.95833333333333, 0.35, 0.41666666666667
25767, 0.95833333333333, 0.4, 0.41666666666667
25768, 0.95833333333333, 0.45, 0.41666666666667
25769, 0.95833333333333, 0.5, 0.41666666666667
25770, 0.95833333333333, 0.55, 0.41666666666667
25771, 0.95833333333333, 0.6, 0.41666666666667
25772, 0.95833333333333, 0.65, 0.41666666666667
25773, 0.95833333333333, 0.7, 0.41666666666667
25774, 0.95833333333333, 0.75, 0.41666666666667
25775, 0.95833333333333, 0.8, 0.41666666666667
25776, 0.95833333333333, 0.85, 0.41666666666667
25777, 0.95833333333333, 0.9, 0.41666666666667
25778, 0.95833333333333, 0.95, 0.41666666666667
25779, 0.95833333333333, 1, 0.41666666666667
25780, 0.95833333333333, 1.05, 0.41666666666667
25781, 0.95833333333333, 1.1, 0.41666666666667
25782, 0.95833333333333, 1.15, 0.41666666666667
25783, 0.95833333333333, 1.2, 0.41666666666667
25784, 0.95833333333333, 1.25, 0.41666666666667
25785, 0.95833333333333, 1.3, 0.41666666666667
25786, 0.95833333333333, 0.2, 0.45833333333333
25787, 0.95833333333333, 0.25, 0.45833333333333
25788, 0.95833333333333, 0.3, 0.45833333333333
25789, 0.95833333333333, 0.35, 0.45833333333333
25790, 0.95833333333333, 0.4, 0.45833333333333
25791, 0.95833333333333, 0.45, 0.45833333333333
25792, 0.95833333333333, 0.5, 0.45833333333333
25793, 0.95833333333333, 0.55, 0.45833333333333
25794, 0.95833333333333, 0.6, 0.45833333333333
25795, 0.95833333333333, 0.65, 0.45833333333333
25796, 0.95833333333333, 0.7, 0.45833333333333
25797, 0.95833333333333, 0.75, 0.45833333333333
25798, 0.95833333333333, 0.8, 0.45833333333333
25799, 0.95833333333333, 0.85, 0.45833333333333
25800, 0.95833333333333, 0.9, 0.45833333333333
25801, 0.95833333333333, 0.95, 0.45833333333333
25802, 0.95833333333333, 1, 0.45833333333333
25803, 0.95833333333333, 1.05, 0.45833333333333
25804, 0.95833333333333, 1.1, 0.45833333333333
25805, 0.95833333333333, 1.15, 0.45833333333333
25806, 0.95833333333333, 1.2, 0.45833333333333
25807, 0.95833333333333, 1.25, 0.45833333333333
25808, 0.95833333333333, 1.3, 0.45833333333333
25809, 0.041666666666667, 1.4333333333333, 0.041666666666667
25810, 0.041666666666667, 1.4666666666667, 0.041666666666667
25811, 0.041666666666667, 1.4333333333333, 0.083333333333333
25812, 0.041666666666667, 1.4666666666667, 0.083333333333333
25813, 0.041666666666667, 1.4333333333333, 0.125
25814, 0.041666666666667, 1.4666666666667, 0.125
25815, 0.041666666666667, 1.4333333333333, 0.16666666666667
25816, 0.041666666666667, 1.4666666666667, 0.16666666666667
25817, 0.041666666666667, 1.4333333333333, 0.20833333333333
25818, 0.041666666666667, 1.4666666666667, 0.20833333333333
25819, 0.041666666666667, 1.4333333333333, 0.25
25820, 0.041666666666667, 1.4666666666667, 0.25
25821, 0.041666666666667, 1.4333333333333, 0.29166666666667
25822, 0.041666666666667, 1.4666666666667, 0.29166666666667
25823, 0.041666666666667, 1.4333333333333, 0.33333333333333
25824, 0.041666666666667, 1.4666666666667, 0.33333333333333
25825, 0.041666666666667, 1.4333333333333, 0.375
25826, 0.041666666666667, 1.4666666666667, 0.375
25827, 0.041666666666667, 1.4333333333333, 0.41666666666667
25828, 0.041666666666667, 1.4666666666667, 0.41666666666667
25829, 0.041666666666667, 1.4333333333333, 0.45833333333333
25830, 0.041666666666667, 1.4666666666667, 0.45833333333333
25831, 0.083333333333333, 1.4333333333333, 0.041666666666667
25832, 0.083333333333333, 1.4666666666667, 0.041666666666667
25833, 0.083333333333333, 1.4333333333333, 0.083333333333333
25834, 0.083333333333333, 1.4666666666667, 0.083333333333333
25835, 0.083333333333333, 1.4333333333333, 0.125
25836, 0.083333333333333, 1.4666666666667, 0.125
25837, 0.083333333333333, 1.4333333333333, 0.16666666666667
25838, 0.083333333333333, 1.4666666666667, 0.16666666666667
25839, 0.083333333333333, 1.4333333333333, 0.20833333333333
25840, 0.083333333333333, 1.4666666666667, 0.20833333333333
25841, 0.083333333333333, 1.4333333333333, 0.25
25842, 0.083333333333333, 1.4666666666667, 0.25
25843, 0.083333333333333, 1.4333333333333, 0.29166666666667
25844, 0.083333333333333, 1.4666666666667, 0.29166666666667
25845, 0.083333333333333, 1.4333333333333, 0.33333333333333
25846, 0.083333333333333, 1.4666666666667, 0.33333333333333
25847, 0.083333333333333, 1.4333333333333, 0.375
25848, 0.083333333333333, 1.4666666666667, 0.375
25849, 0.083333333333333, 1.4333333333333, 0.41666666666667
25850, 0.083333333333333, 1.4666666666667, 0.41666666666667
25851, 0.083333333333333, 1.4333333333333, 0.45833333333333
25852, 0.083333333333333, 1.4666666666667, 0.45833333333333
25853, 0.125, 1.4333333333333, 0.041666666666667
25854, 0.125, 1.4666666666667, 0.041666666666667
25855, 0.125, 1.4333333333333, 0.083333333333333
25856, 0.125, 1.4666666666667, 0.083333333333333
25857, 0.125, 1.4333333333333, 0.125
25858, 0.125, 1.4666666666667, 0.125
25859, 0.125, 1.4333333333333, 0.16666666666667
25860, 0.125, 1.4666666666667, 0.16666666666667
25861, 0.125, 1.4333333333333, 0.20833333333333
25862, 0.125, 1.4666666666667, 0.20833333333333
25863, 0.125, 1.4333333333333, 0.25
25864, 0.125, 1.4666666666667, 0.25
25865, 0.125, 1.4333333333333, 0.29166666666667
25866, 0.125, 1.4666666666667, 0.29166666666667
25867, 0.125, 1.4333333333333, 0.33333333333333
25868, 0.125, 1.4666666666667, 0.33333333333333
25869, 0.125, 1.4333333333333, 0.375
25870, 0.125, 1.4666666666667, 0.375
25871, 0.125, 1.4333333333333, 0.41666666666667
25872, 0.125, 1.4666666666667, 0.41666666666667
25873, 0.125, 1.4333333333333, 0.45833333333333
25874, 0.125, 1.4666666666667, 0.45833333333333
25875, 0.16666666666667, 1.4333333333333, 0.041666666666667
25876, 0.16666666666667, 1.4666666666667, 0.041666666666667
25877, 0.16666666666667, 1.4333333333333, 0.083333333333333
25878, 0.16666666666667, 1.4666666666667, 0.083333333333333
25879, 0.16666666666667, 1.4333333333333, 0.125
25880, 0.16666666666667, 1.4666666666667, 0.125
25881, 0.16666666666667, 1.4333333333333, 0.16666666666667
25882, 0.16666666666667, 1.4666666666667, 0.16666666666667
25883, 0.16666666666667, 1.4333333333333, 0.20833333333333
25884, 0.16666666666667, 1.4666666666667, 0.20833333333333
25885, 0.16666666666667, 1.4333333333333, 0.25
25886, 0.16666666666667, 1.4666666666667, 0.25
25887, 0.16666666666667, 1.4333333333333, 0.29166666666667
25888, 0.16666666666667, 1.4666666666667, 0.29166666666667
25889, 0.16666666666667, 1.4333333333333, 0.33333333333333
25890, 0.16666666666667, 1.4666666666667, 0.33333333333333
25891, 0.16666666666667, 1.4333333333333, 0.375
25892, 0.16666666666667, 1.4666666666667, 0.375
25893, 0.16666666666667, 1.4333333333333, 0.41666666666667
25894, 0.16666666666667, 1.4666666666667, 0.41666666666667
25895, 0.16666666666667, 1.4333333333333, 0.45833333333333
25896, 0.16666666666667, 1.4666666666667, 0.45833333333333
25897, 0.20833333333333, 1.4333333333333, 0.041666666666667
25898, 0.20833333333333, 1.4666666666667, 0.041666666666667
25899, 0.20833333333333, 1.4333333333333, 0.083333333333333
25900, 0.20833333333333, 1.4666666666667, 0.083333333333333
25901, 0.20833333333333, 1.4333333333333, 0.125
25902, 0.20833333333333, 1.4666666666667, 0.125
25903, 0.20833333333333, 1.4333333333333, 0.16666666666667
25904, 0.20833333333333, 1.4666666666667, 0.16666666666667
25905, 0.20833333333333, 1.4333333333333, 0.20833333333333
25906, 0.20833333333333, 1.4666666666667, 0.20833333333333
25907, 0.20833333333333, 1.4333333333333, 0.25
25908, 0.20833333333333, 1.4666666666667, 0.25
25909, 0.20833333333333, 1.4333333333333, 0.29166666666667
25910, 0.20833333333333, 1.4666666666667, 0.29166666666667
25911, 0.20833333333333, 1.4333333333333, 0.33333333333333
25912, 0.20833333333333, 1.4666666666667, 0.33333333333333
25913, 0.20833333333333, 1.4333333333333, 0.375
25914, 0.20833333333333, 1.4666666666667, 0.375
25915, 0.20833333333333, 1.4333333333333, 0.41666666666667
25916, 0.20833333333333, 1.4666666666667, 0.41666666666667
25917, 0.20833333333333, 1.4333333333333, 0.45833333333333
25918, 0.20833333333333, 1.4666666666667, 0.45833333333333
25919, 0.25, 1.4333333333333, 0.041666666666667
25920, 0.25, 1.4666666666667, 0.041666666666667
25921, 0.25, 1.4333333333333, 0.083333333333333
25922, 0.25, 1.4666666666667, 0.083333333333333
25923, 0.25, 1.4333333333333, 0.125
25924, 0.25, 1.4666666666667, 0.125
25925, 0.25, 1.4333333333333, 0.16666666666667
25926, 0.25, 1.4666666666667, 0.16666666666667
25927, 0.25, 1.4333333333333, 0.20833333333333
25928, 0.25, 1.4666666666667, 0.20833333333333
25929, 0.25, 1.4333333333333, 0.25
25930, 0.25, 1.4666666666667, 0.25
25931, 0.25, 1.4333333333333, 0.29166666666667
25932, 0.25, 1.4666666666667, 0.29166666666667
25933, 0.25, 1.4333333333333, 0.33333333333333
25934, 0.25, 1.4666666666667, 0.33333333333333
25935, 0.25, 1.4333333333333, 0.375
25936, 0.25, 1.4666666666667, 0.375
25937, 0.25, 1.4333333333333, 0.41666666666667
25938, 0.25, 1.4666666666667, 0.41666666666667
25939, 0.25, 1.4333333333333, 0.45833333333333
25940, 0.25, 1.4666666666667, 0.45833333333333
25941, 0.29166666666667, 1.4333333333333, 0.041666666666667
25942, 0.29166666666667, 1.4666666666667, 0.041666666666667
25943, 0.29166666666667, 1.4333333333333, 0.083333333333333
25944, 0.29166666666667, 1.4666666666667, 0.083333333333333
25945, 0.29166666666667, 1.4333333333333, 0.125
25946, 0.29166666666667, 1.4666666666667, 0.125
25947, 0.29166666666667, 1.4333333333333, 0.16666666666667
25948, 0.29166666666667, 1.4666666666667, 0.16666666666667
25949, 0.29166666666667, 1.4333333333333, 0.20833333333333
25950, 0.29166666666667, 1.4666666666667, 0.20833333333333
25951, 0.29166666666667, 1.4333333333333, 0.25
25952, 0.29166666666667, 1.4666666666667, 0.25
25953, 0.29166666666667, 1.4333333333333, 0.29166666666667
25954, 0.29166666666667, 1.4666666666667, 0.29166666666667
25955, 0.29166666666667, 1.4333333333333, 0.33333333333333
25956, 0.29166666666667, 1.4666666666667, 0.33333333333333
25957, 0.29166666666667, 1.4333333333333, 0.375
25958, 0.29166666666667, 1.4666666666667, 0.375
25959, 0.29166666666667, 1.4333333333333, 0.41666666666667
25960, 0.29166666666667, 1.4666666666667, 0.41666666666667
25961, 0.29166666666667, 1.4333333333333, 0.45833333333333
25962, 0.29166666666667, 1.4666666666667, 0.45833333333333
25963, 0.33333333333333, 1.4333333333333, 0.041666666666667
25964, 0.33333333333333, 1.4666666666667, 0.041666666666667
25965, 0.33333333333333, 1.4333333333333, 0.083333333333333
25966, 0.33333333333333, 1.4666666666667, 0.083333333333333
25967, 0.33333333333333, 1.4333333333333, 0.125
25968, 0.33333333333333, 1.4666666666667, 0.125
25969, 0.33333333333333, 1.4333333333333, 0.16666666666667
25970, 0.33333333333333, 1.4666666666667, 0.16666666666667
25971, 0.33333333333333, 1.4333333333333, 0.20833333333333
25972, 0.33333333333333, 1.4666666666667, 0.20833333333333
25973, 0.33333333333333, 1.4333333333333, 0.25
25974, 0.33333333333333, 1.4666666666667, 0.25
25975, 0.33333333333333, 1.4333333333333, 0.29166666666667
25976, 0.33333333333333, 1.4666666666667, 0.29166666666667
25977, 0.33333333333333, 1.4333333333333, 0.33333333333333
25978, 0.33333333333333, 1.4666666666667, 0.33333333333333
25979, 0.33333333333333, 1.4333333333333, 0.375
25980, 0.33333333333333, 1.4666666666667, 0.375
25981, 0.33333333333333, 1.4333333333333, 0.41666666666667
25982, 0.33333333333333, 1.4666666666667, 0.41666666666667
25983, 0.33333333333333, 1.4333333333333, 0.45833333333333
25984, 0.33333333333333, 1.4666666666667, 0.45833333333333
25985, 0.375, 1.4333333333333, 0.041666666666667
25986, 0.375, 1.4666666666667, 0.041666666666667
25987, 0.375, 1.4333333333333, 0.083333333333333
25988, 0.375, 1.4666666666667, 0.083333333333333
25989, 0.375, 1.4333333333333, 0.125
25990, 0.375, 1.4666666666667, 0.125
25991, 0.375, 1.4333333333333, 0.16666666666667
25992, 0.375, 1.4666666666667, 0.16666666666667
25993, 0.375, 1.4333333333333, 0.20833333333333
25994, 0.375, 1.4666666666667, 0.20833333333333
25995, 0.375, 1.4333333333333, 0.25
25996, 0.375, 1.4666666666667, 0.25
25997, 0.375, 1.4333333333333, 0.29166666666667
25998, 0.375, 1.4666666666667, 0.29166666666667
25999, 0.375, 1.4333333333333, 0.33333333333333
26000, 0.375, 1.4666666666667, 0.33333333333333
26001, 0.375, 1.4333333333333, 0.375
26002, 0.375, 1.4666666666667, 0.375
26003, 0.375, 1.4333333333333, 0.41666666666667
26004, 0.375, 1.4666666666667, 0.41666666666667
26005, 0.375, 1.4333333333333, 0.45833333333333
26006, 0.375, 1.4666666666667, 0.45833333333333
26007, 0.41666666666667, 1.4333333333333, 0.041666666666667
26008, 0.41666666666667, 1.4666666666667, 0.041666666666667
26009, 0.41666666666667, 1.4333333333333, 0.083333333333333
26010, 0.41666666666667, 1.4666666666667, 0.083333333333333
26011, 0.41666666666667, 1.4333333333333, 0.125
26012, 0.41666666666667, 1.4666666666667, 0.125
26013, 0.41666666666667, 1.4333333333333, 0.16666666666667
26014, 0.41666666666667, 1.4666666666667, 0.16666666666667
26015, 0.41666666666667, 1.4333333333333, 0.20833333333333
26016, 0.41666666666667, 1.4666666666667, 0.20833333333333
26017, 0.41666666666667, 1.4333333333333, 0.25
26018, 0.41666666666667, 1.4666666666667, 0.25
26019, 0.41666666666667, 1.4333333333333, 0.29166666666667
26020, 0.41666666666667, 1.4666666666667, 0.29166666666667
26021, 0.41666666666667, 1.4333333333333, 0.33333333333333
26022, 0.41666666666667, 1.4666666666667, 0.33333333333333
26023, 0.41666666666667, 1.4333333333333, 0.375
26024, 0.41666666666667, 1.4666666666667, 0.375
26025, 0.41666666666667, 1.4333333333333, 0.41666666666667
26026, 0.41666666666667, 1.4666666666667, 0.41666666666667
26027, 0.41666666666667, 1.4333333333333, 0.45833333333333
26028, 0.41666666666667, 1.4666666666667, 0.45833333333333
26029, 0.45833333333333, 1.4333333333333, 0.041666666666667
26030, 0.45833333333333, 1.4666666666667, 0.041666666666667
26031, 0.45833333333333, 1.4333333333333, 0.083333333333333
26032, 0.45833333333333, 1.4666666666667, 0.083333333333333
26033, 0.45833333333333, 1.4333333333333, 0.125
26034, 0.45833333333333, 1.4666666666667, 0.125
26035, 0.45833333333333, 1.4333333333333, 0.16666666666667
26036, 0.45833333333333, 1.4666666666667, 0.16666666666667
26037, 0.45833333333333, 1.4333333333333, 0.20833333333333
26038, 0.45833333333333, 1.4666666666667, 0.20833333333333
26039, 0.45833333333333, 1.4333333333333, 0.25
26040, 0.45833333333333, 1.4666666666667, 0.25
26041, 0.45833333333333, 1.4333333333333, 0.29166666666667
26042, 0.45833333333333, 1.4666666666667, 0.29166666666667
26043, 0.45833333333333, 1.4333333333333, 0.33333333333333
26044, 0.45833333333333, 1.4666666666667, 0.33333333333333
26045, 0.45833333333333, 1.4333333333333, 0.375
26046, 0.45833333333333, 1.4666666666667, 0.375
26047, 0.45833333333333, 1.4333333333333, 0.41666666666667
26048, 0.45833333333333, 1.4666666666667, 0.41666666666667
26049, 0.45833333333333, 1.4333333333333, 0.45833333333333
26050, 0.45833333333333, 1.4666666666667, 0.45833333333333
26051, 0.5, 1.4333333333333, 0.041666666666667
26052, 0.5, 1.4666666666667, 0.041666666666667
26053, 0.5, 1.4333333333333, 0.083333333333333
26054, 0.5, 1.4666666666667, 0.083333333333333
26055, 0.5, 1.4333333333333, 0.125
26056, 0.5, 1.4666666666667, 0.125
26057, 0.5, 1.4333333333333, 0.16666666666667
26058, 0.5, 1.4666666666667, 0.16666666666667
26059, 0.5, 1.4333333333333, 0.20833333333333
26060, 0.5, 1.4666666666667, 0.20833333333333
26061, 0.5, 1.4333333333333, 0.25
26062, 0.5, 1.4666666666667, 0.25
26063, 0.5, 1.4333333333333, 0.29166666666667
26064, 0.5, 1.4666666666667, 0.29166666666667
26065, 0.5, 1.4333333333333, 0.33333333333333
26066, 0.5, 1.4666666666667, 0.33333333333333
26067, 0.5, 1.4333333333333, 0.375
26068, 0.5, 1.4666666666667, 0.375
26069, 0.5, 1.4333333333333, 0.41666666666667
26070, 0.5, 1.4666666666667, 0.41666666666667
26071, 0.5, 1.4333333333333, 0.45833333333333
26072, 0.5, 1.4666666666667, 0.45833333333333
26073, 0.54166666666667, 1.4333333333333, 0.041666666666667
26074, 0.54166666666667, 1.4666666666667, 0.041666666666667
26075, 0.54166666666667, 1.4333333333333, 0.083333333333333
26076, 0.54166666666667, 1.4666666666667, 0.083333333333333
26077, 0.54166666666667, 1.4333333333333, 0.125
26078, 0.54166666666667, 1.4666666666667, 0.125
26079, 0.54166666666667, 1.4333333333333, 0.16666666666667
26080, 0.54166666666667, 1.4666666666667, 0.16666666666667
26081, 0.54166666666667, 1.4333333333333, 0.20833333333333
26082, 0.54166666666667, 1.4666666666667, 0.20833333333333
26083, 0.54166666666667, 1.4333333333333, 0.25
26084, 0.54166666666667, 1.4666666666667, 0.25
26085, 0.54166666666667, 1.4333333333333, 0.29166666666667
26086, 0.54166666666667, 1.4666666666667, 0.29166666666667
26087, 0.54166666666667, 1.4333333333333, 0.33333333333333
26088, 0.54166666666667, 1.4666666666667, 0.33333333333333
26089, 0.54166666666667, 1.4333333333333, 0.375
26090, 0.54166666666667, 1.4666666666667, 0.375
26091, 0.54166666666667, 1.4333333333333, 0.41666666666667
26092, 0.54166666666667, 1.4666666666667, 0.41666666666667
26093, 0.54166666666667, 1.4333333333333, 0.45833333333333
26094, 0.54166666666667, 1.4666666666667, 0.45833333333333
26095, 0.58333333333333, 1.4333333333333, 0.041666666666667
26096, 0.58333333333333, 1.4666666666667, 0.041666666666667
26097, 0.58333333333333, 1.4333333333333, 0.083333333333333
26098, 0.58333333333333, 1.4666666666667, 0.083333333333333
26099, 0.58333333333333, 1.4333333333333, 0.125
26100, 0.58333333333333, 1.4666666666667, 0.125
26101, 0.58333333333333, 1.4333333333333, 0.16666666666667
26102, 0.58333333333333, 1.4666666666667, 0.16666666666667
26103, 0.58333333333333, 1.4333333333333, 0.20833333333333
26104, 0.58333333333333, 1.4666666666667, 0.20833333333333
26105, 0.58333333333333, 1.4333333333333, 0.25
26106, 0.58333333333333, 1.4666666666667, 0.25
26107, 0.58333333333333, 1.4333333333333, 0.29166666666667
26108, 0.58333333333333, 1.4666666666667, 0.29166666666667
26109, 0.58333333333333, 1.4333333333333, 0.33333333333333
26110, 0.58333333333333, 1.4666666666667, 0.33333333333333
26111, 0.58333333333333, 1.4333333333333, 0.375
26112, 0.58333333333333, 1.4666666666667, 0.375
26113, 0.58333333333333, 1.4333333333333, 0.41666666666667
26114, 0.58333333333333, 1.4666666666667, 0.41666666666667
26115, 0.58333333333333, 1.4333333333333, 0.45833333333333
26116, 0.58333333333333, 1.4666666666667, 0.45833333333333
26117, 0.625, 1.4333333333333, 0.041666666666667
26118, 0.625, 1.4666666666667, 0.041666666666667
26119, 0.625, 1.4333333333333, 0.083333333333333
26120, 0.625, 1.4666666666667, 0.083333333333333
26121, 0.625, 1.4333333333333, 0.125
26122, 0.625, 1.4666666666667, 0.125
26123, 0.625, 1.4333333333333, 0.16666666666667
26124, 0.625, 1.4666666666667, 0.16666666666667
26125, 0.625, 1.4333333333333, 0.20833333333333
26126, 0.625, 1.4666666666667, 0.20833333333333
26127, 0.625, 1.4333333333333, 0.25
26128, 0.625, 1.4666666666667, 0.25
26129, 0.625, 1.4333333333333, 0.29166666666667
26130, 0.625, 1.4666666666667, 0.29166666666667
26131, 0.625, 1.4333333333333, 0.33333333333333
26132, 0.625, 1.4666666666667, 0.33333333333333
26133, 0.625, 1.4333333333333, 0.375
26134, 0.625, 1.4666666666667, 0.375
26135, 0.625, 1.4333333333333, 0.41666666666667
26136, 0.625, 1.4666666666667, 0.41666666666667
26137, 0.625, 1.4333333333333, 0.45833333333333
26138, 0.625, 1.4666666666667, 0.45833333333333
26139, 0.66666666666667, 1.4333333333333, 0.041666666666667
26140, 0.66666666666667, 1.4666666666667, 0.041666666666667
26141, 0.66666666666667, 1.4333333333333, 0.083333333333333
26142, 0.66666666666667, 1.4666666666667, 0.083333333333333
26143, 0.66666666666667, 1.4333333333333, 0.125
26144, 0.66666666666667, 1.4666666666667, 0.125
26145, 0.66666666666667, 1.4333333333333, 0.16666666666667
26146, 0.66666666666667, 1.4666666666667, 0.16666666666667
26147, 0.66666666666667, 1.4333333333333, 0.20833333333333
26148, 0.66666666666667, 1.4666666666667, 0.20833333333333
26149, 0.66666666666667, 1.4333333333333, 0.25
26150, 0.66666666666667, 1.4666666666667, 0.25
26151, 0.66666666666667, 1.4333333333333, 0.29166666666667
26152, 0.66666666666667, 1.4666666666667, 0.29166666666667
26153, 0.66666666666667, 1.4333333333333, 0.33333333333333
26154, 0.66666666666667, 1.4666666666667, 0.33333333333333
26155, 0.66666666666667, 1.4333333333333, 0.375
26156, 0.66666666666667, 1.4666666666667, 0.375
26157, 0.66666666666667, 1.4333333333333, 0.41666666666667
26158, 0.66666666666667, 1.4666666666667, 0.41666666666667
26159, 0.66666666666667, 1.4333333333333, 0.45833333333333
26160, 0.66666666666667, 1.4666666666667, 0.45833333333333
26161, 0.70833333333333, 1.4333333333333, 0.041666666666667
26162, 0.70833333333333, 1.4666666666667, 0.041666666666667
26163, 0.70833333333333, 1.4333333333333, 0.083333333333333
26164, 0.70833333333333, 1.4666666666667, 0.083333333333333
26165, 0.70833333333333, 1.4333333333333, 0.125
26166, 0.70833333333333, 1.4666666666667, 0.125
26167, 0.70833333333333, 1.4333333333333, 0.16666666666667
26168, 0.70833333333333, 1.4666666666667, 0.16666666666667
26169, 0.70833333333333, 1.4333333333333, 0.20833333333333
26170, 0.70833333333333, 1.4666666666667, 0.20833333333333
26171, 0.70833333333333, 1.4333333333333, 0.25
26172, 0.70833333333333, 1.4666666666667, 0.25
26173, 0.70833333333333, 1.4333333333333, 0.29166666666667
26174, 0.70833333333333, 1.4666666666667, 0.29166666666667
26175, 0.70833333333333, 1.4333333333333, 0.33333333333333
26176, 0.70833333333333, 1.4666666666667, 0.33333333333333
26177, 0.70833333333333, 1.4333333333333, 0.375
26178, 0.70833333333333, 1.4666666666667, 0.375
26179, 0.70833333333333, 1.4333333333333, 0.41666666666667
26180, 0.70833333333333, 1.4666666666667, 0.41666666666667
26181, 0.70833333333333, 1.4333333333333, 0.45833333333333
26182, 0.70833333333333, 1.4666666666667, 0.45833333333333
26183, 0.75, 1.4333333333333, 0.041666666666667
26184, 0.75, 1.4666666666667, 0.041666666666667
26185, 0.75, 1.4333333333333, 0.083333333333333
26186, 0.75, 1.4666666666667, 0.083333333333333
26187, 0.75, 1.4333333333333, 0.125
26188, 0.75, 1.4666666666667, 0.125
26189, 0.75, 1.4333333333333, 0.16666666666667
26190, 0.75, 1.4666666666667, 0.16666666666667
26191, 0.75, 1.4333333333333, 0.20833333333333
26192, 0.75, 1.4666666666667, 0.20833333333333
26193, 0.75, 1.4333333333333, 0.25
26194, 0.75, 1.4666666666667, 0.25
26195, 0.75, 1.4333333333333, 0.29166666666667
26196, 0.75, 1.4666666666667, 0.29166666666667
26197, 0.75, 1.4333333333333, 0.33333333333333
26198, 0.75, 1.4666666666667, 0.33333333333333
26199, 0.75, 1.4333333333333, 0.375
26200, 0.75, 1.4666666666667, 0.375
26201, 0.75, 1.4333333333333, 0.41666666666667
26202, 0.75, 1.4666666666667, 0.41666666666667
26203, 0.75, 1.4333333333333, 0.45833333333333
26204, 0.75, 1.4666666666667, 0.45833333333333
26205, 0.79166666666667, 1.4333333333333, 0.041666666666667
26206, 0.79166666666667, 1.4666666666667, 0.041666666666667
26207, 0.79166666666667, 1.4333333333333, 0.083333333333333
26208, 0.79166666666667, 1.4666666666667, 0.083333333333333
26209, 0.79166666666667, 1.4333333333333, 0.125
26210, 0.79166666666667, 1.4666666666667, 0.125
26211, 0.79166666666667, 1.4333333333333, 0.16666666666667
26212, 0.79166666666667, 1.4666666666667, 0.16666666666667
26213, 0.79166666666667, 1.4333333333333, 0.20833333333333
26214, 0.79166666666667, 1.4666666666667, 0.20833333333333
26215, 0.79166666666667, 1.4333333333333, 0.25
26216, 0.79166666666667, 1.4666666666667, 0.25
26217, 0.79166666666667, 1.4333333333333, 0.29166666666667
26218, 0.79166666666667, 1.4666666666667, 0.29166666666667
26219, 0.79166666666667, 1.4333333333333, 0.33333333333333
26220, 0.79166666666667, 1.4666666666667, 0.33333333333333
26221, 0.79166666666667, 1.4333333333333, 0.375
26222, 0.79166666666667, 1.4666666666667, 0.375
26223, 0.79166666666667, 1.4333333333333, 0.41666666666667
26224, 0.79166666666667, 1.4666666666667, 0.41666666666667
26225, 0.79166666666667, 1.4333333333333, 0.45833333333333
26226, 0.79166666666667, 1.4666666666667, 0.45833333333333
26227, 0.83333333333333, 1.4333333333333, 0.041666666666667
26228, 0.83333333333333, 1.4666666666667, 0.041666666666667
26229, 0.83333333333333, 1.4333333333333, 0.083333333333333
26230, 0.83333333333333, 1.4666666666667, 0.083333333333333
26231, 0.83333333333333, 1.4333333333333, 0.125
26232, 0.83333333333333, 1.4666666666667, 0.125
26233, 0.83333333333333, 1.4333333333333, 0.16666666666667
26234, 0.83333333333333, 1.4666666666667, 0.16666666666667
26235, 0.83333333333333, 1.4333333333333, 0.20833333333333
26236, 0.83333333333333, 1.4666666666667, 0.20833333333333
26237, 0.83333333333333, 1.4333333333333, 0.25
26238, 0.83333333333333, 1.4666666666667, 0.25
26239, 0.83333333333333, 1.4333333333333, 0.29166666666667
26240, 0.83333333333333, 1.4666666666667, 0.29166666666667
26241, 0.83333333333333, 1.4333333333333, 0.33333333333333
26242, 0.83333333333333, 1.4666666666667, 0.33333333333333
26243, 0.83333333333333, 1.4333333333333, 0.375
26244, 0.83333333333333, 1.4666666666667, 0.375
26245, 0.83333333333333, 1.4333333333333, 0.41666666666667
26246, 0.83333333333333, 1.4666666666667, 0.41666666666667
26247, 0.83333333333333, 1.4333333333333, 0.45833333333333
26248, 0.83333333333333, 1.4666666666667, 0.45833333333333
26249, 0.875, 1.4333333333333, 0.041666666666667
26250, 0.875, 1.4666666666667, 0.041666666666667
26251, 0.875, 1.4333333333333, 0.083333333333333
26252, 0.875, 1.4666666666667, 0.083333333333333
26253, 0.875, 1.4333333333333, 0.125
26254, 0.875, 1.4666666666667, 0.125
26255, 0.875, 1.4333333333333, 0.16666666666667
26256, 0.875, 1.4666666666667, 0.16666666666667
26257, 0.875, 1.4333333333333, 0.20833333333333
26258, 0.875, 1.4666666666667, 0.20833333333333
26259, 0.875, 1.4333333333333, 0.25
26260, 0.875, 1.4666666666667, 0.25
26261, 0.875, 1.4333333333333, 0.29166666666667
26262, 0.875, 1.4666666666667, 0.29166666666667
26263, 0.875, 1.4333333333333, 0.33333333333333
26264, 0.875, 1.4666666666667, 0.33333333333333
26265, 0.875, 1.4333333333333, 0.375
26266, 0.875, 1.4666666666667, 0.375
26267, 0.875, 1.4333333333333, 0.41666666666667
26268, 0.875, 1.4666666666667, 0.41666666666667
26269, 0.875, 1.4333333333333, 0.45833333333333
26270, 0.875, 1.4666666666667, 0.45833333333333
26271, 0.91666666666667, 1.4333333333333, 0.041666666666667
26272, 0.91666666666667, 1.4666666666667, 0.041666666666667
26273, 0.91666666666667, 1.4333333333333, 0.083333333333333
26274, 0.91666666666667, 1.4666666666667, 0.083333333333333
26275, 0.91666666666667, 1.4333333333333, 0.125
26276, 0.91666666666667, 1.4666666666667, 0.125
26277, 0.91666666666667, 1.4333333333333, 0.16666666666667
26278, 0.91666666666667, 1.4666666666667, 0.16666666666667
26279, 0.91666666666667, 1.4333333333333, 0.20833333333333
26280, 0.91666666666667, 1.4666666666667, 0.20833333333333
26281, 0.91666666666667, 1.4333333333333, 0.25
26282, 0.91666666666667, 1.4666666666667, 0.25
26283, 0.91666666666667, 1.4333333333333, 0.29166666666667
26284, 0.91666666666667, 1.4666666666667, 0.29166666666667
26285, 0.91666666666667, 1.4333333333333, 0.33333333333333
26286, 0.91666666666667, 1.4666666666667, 0.33333333333333
26287, 0.91666666666667, 1.4333333333333, 0.375
26288, 0.91666666666667, 1.4666666666667, 0.375
26289, 0.91666666666667, 1.4333333333333, 0.41666666666667
26290, 0.91666666666667, 1.4666666666667, 0.41666666666667
26291, 0.91666666666667, 1.4333333333333, 0.45833333333333
26292, 0.91666666666667, 1.4666666666667, 0.45833333333333
26293, 0.95833333333333, 1.4333333333333, 0.041666666666667
26294, 0.95833333333333, 1.4666666666667, 0.041666666666667
26295, 0.95833333333333, 1.4333333333333, 0.083333333333333
26296, 0.95833333333333, 1.4666666666667, 0.083333333333333
26297, 0.95833333333333, 1.4333333333333, 0.125
26298, 0.95833333333333, 1.4666666666667, 0.125
26299, 0.95833333333333, 1.4333333333333, 0.16666666666667
26300, 0.95833333333333, 1.4666666666667, 0.16666666666667
26301, 0.95833333333333, 1.4333333333333, 0.20833333333333
26302, 0.95833333333333, 1.4666666666667, 0.20833333333333
26303, 0.95833333333333, 1.4333333333333, 0.25
26304, 0.95833333333333, 1.4666666666667, 0.25
26305, 0.95833333333333, 1.4333333333333, 0.29166666666667
26306, 0.95833333333333, 1.4666666666667, 0.29166666666667
26307, 0.95833333333333, 1.4333333333333, 0.33333333333333
26308, 0.95833333333333, 1.4666666666667, 0.33333333333333
26309, 0.95833333333333, 1.4333333333333, 0.375
26310, 0.95833333333333, 1.4666666666667, 0.375
26311, 0.95833333333333, 1.4333333333333, 0.41666666666667
26312, 0.95833333333333, 1.4666666666667, 0.41666666666667
26313, 0.95833333333333, 1.4333333333333, 0.45833333333333
26314, 0.95833333333333, 1.4666666666667, 0.45833333333333
26315, 1.04, 1.4333333333333, 0.041666666666667
26316, 1.08, 1.4333333333333, 0.041666666666667
26317, 1.12, 1.4333333333333, 0.041666666666667
26318, 1.16, 1.4333333333333, 0.041666666666667
26319, 1.04, 1.4666666666667, 0.041666666666667
26320, 1.08, 1.4666666666667, 0.041666666666667
26321, 1.12, 1.4666666666667, 0.041666666666667
26322, 1.16, 1.4666666666667, 0.041666666666667
26323, 1.04, 1.4333333333333, 0.083333333333333
26324, 1.08, 1.4333333333333, 0.083333333333333
26325, 1.12, 1.4333333333333, 0.083333333333333
26326, 1.16, 1.4333333333333, 0.083333333333333
26327, 1.04, 1.4666666666667, 0.083333333333333
26328, 1.08, 1.4666666666667, 0.083333333333333
26329, 1.12, 1.4666666666667, 0.083333333333333
26330, 1.16, 1.4666666666667, 0.083333333333333
26331, 1.04, 1.4333333333333, 0.125
26332, 1.08, 1.4333333333333, 0.125
26333, 1.12, 1.4333333333333, 0.125
26334, 1.16, 1.4333333333333, 0.125
26335, 1.04, 1.4666666666667, 0.125
26336, 1.08, 1.4666666666667, 0.125
26337, 1.12, 1.4666666666667, 0.125
26338, 1.16, 1.4666666666667, 0.125
26339, 1.04, 1.4333333333333, 0.16666666666667
26340, 1.08, 1.4333333333333, 0.16666666666667
26341, 1.12, 1.4333333333333, 0.16666666666667
26342, 1.16, 1.4333333333333, 0.16666666666667
26343, 1.04, 1.4666666666667, 0.16666666666667
26344, 1.08, 1.4666666666667, 0.16666666666667
26345, 1.12, 1.4666666666667, 0.16666666666667
26346, 1.16, 1.4666666666667, 0.16666666666667
26347, 1.04, 1.4333333333333, 0.20833333333333
26348, 1.08, 1.4333333333333, 0.20833333333333
26349, 1.12, 1.4333333333333, 0.20833333333333
26350, 1.16, 1.4333333333333, 0.20833333333333
26351, 1.04, 1.4666666666667, 0.20833333333333
26352, 1.08, 1.4666666666667, 0.20833333333333
26353, 1.12, 1.4666666666667, 0.20833333333333
26354, 1.16, 1.4666666666667, 0.20833333333333
26355, 1.04, 1.4333333333333, 0.25
26356, 1.08, 1.4333333333333, 0.25
26357, 1.12, 1.4333333333333, 0.25
26358, 1.16, 1.4333333333333, 0.25
26359, 1.04, 1.4666666666667, 0.25
26360, 1.08, 1.4666666666667, 0.25
26361, 1.12, 1.4666666666667, 0.25
26362, 1.16, 1.4666666666667, 0.25
26363, 1.04, 1.4333333333333, 0.29166666666667
26364, 1.08, 1.4333333333333, 0.29166666666667
26365, 1.12, 1.4333333333333, 0.29166666666667
26366, 1.16, 1.4333333333333, 0.29166666666667
26367, 1.04, 1.4666666666667, 0.29166666666667
26368, 1.08, 1.4666666666667, 0.29166666666667
26369, 1.12, 1.4666666666667, 0.29166666666667
26370, 1.16, 1.4666666666667, 0.29166666666667
26371, 1.04, 1.4333333333333, 0.33333333333333
26372, 1.08, 1.4333333333333, 0.33333333333333
26373, 1.12, 1.4333333333333, 0.33333333333333
26374, 1.16, 1.4333333333333, 0.33333333333333
26375, 1.04, 1.4666666666667, 0.33333333333333
26376, 1.08, 1.4666666666667, 0.33333333333333
26377, 1.12, 1.4666666666667, 0.33333333333333
26378, 1.16, 1.4666666666667, 0.33333333333333
26379, 1.04, 1.4333333333333, 0.375
26380, 1.08, 1.4333333333333, 0.375
26381, 1.12, 1.4333333333333, 0.375
26382, 1.16, 1.4333333333333, 0.375
26383, 1.04, 1.4666666666667, 0.375
26384, 1.08, 1.4666666666667, 0.375
26385, 1.12, 1.4666666666667, 0.375
26386, 1.16, 1.4666666666667, 0.375
26387, 1.04, 1.4333333333333, 0.41666666666667
26388, 1.08, 1.4333333333333, 0.41666666666667
26389, 1.12, 1.4333333333333, 0.41666666666667
26390, 1.16, 1.4333333333333, 0.41666666666667
26391, 1.04, 1.4666666666667, 0.41666666666667
26392, 1.08, 1.4666666666667, 0.41666666666667
26393, 1.12, 1.4666666666667, 0.41666666666667
26394, 1.16, 1.4666666666667, 0.41666666666667
26395, 1.04, 1.4333333333333, 0.45833333333333
26396, 1.08, 1.4333333333333, 0.45833333333333
26397, 1.12, 1.4333333333333, 0.45833333333333
26398, 1.16, 1.4333333333333, 0.45833333333333
26399, 1.04, 1.4666666666667, 0.45833333333333
26400, 1.08, 1.4666666666667, 0.45833333333333
26401, 1.12, 1.4666666666667, 0.45833333333333
26402, 1.16, 1.4666666666667, 0.45833333333333
26403, 1.2416666666667, 1.4333333333333, 0.041666666666667
26404, 1.2833333333333, 1.4333333333333, 0.041666666666667
26405, 1.325, 1.4333333333333, 0.041666666666667
26406, 1.3666666666667, 1.4333333333333, 0.041666666666667
26407, 1.4083333333333, 1.4333333333333, 0.041666666666667
26408, 1.45, 1.4333333333333, 0.041666666666667
26409, 1.4916666666667, 1.4333333333333, 0.041666666666667
26410, 1.5333333333333, 1.4333333333333, 0.041666666666667
26411, 1.575, 1.4333333333333, 0.041666666666667
26412, 1.6166666666667, 1.4333333333333, 0.041666666666667
26413, 1.6583333333333, 1.4333333333333, 0.041666666666667
26414, 1.7, 1.4333333333333, 0.041666666666667
26415, 1.7416666666667, 1.4333333333333, 0.041666666666667
26416, 1.7833333333333, 1.4333333333333, 0.041666666666667
26417, 1.825, 1.4333333333333, 0.041666666666667
26418, 1.8666666666667, 1.4333333333333, 0.041666666666667
26419, 1.9083333333333, 1.4333333333333, 0.041666666666667
26420, 1.95, 1.4333333333333, 0.041666666666667
26421, 1.9916666666667, 1.4333333333333, 0.041666666666667
26422, 2.0333333333333, 1.4333333333333, 0.041666666666667
26423, 2.075, 1.4333333333333, 0.041666666666667
26424, 2.1166666666667, 1.4333333333333, 0.041666666666667
26425, 2.1583333333333, 1.4333333333333, 0.041666666666667
26426, 1.2416666666667, 1.4666666666667, 0.041666666666667
26427, 1.2833333333333, 1.4666666666667, 0.041666666666667
26428, 1.325, 1.4666666666667, 0.041666666666667
26429, 1.3666666666667, 1.4666666666667, 0.041666666666667
26430, 1.4083333333333, 1.4666666666667, 0.041666666666667
26431, 1.45, 1.4666666666667, 0.041666666666667
26432, 1.4916666666667, 1.4666666666667, 0.041666666666667
26433, 1.5333333333333, 1.4666666666667, 0.041666666666667
26434, 1.575, 1.4666666666667, 0.041666666666667
26435, 1.6166666666667, 1.4666666666667, 0.041666666666667
26436, 1.6583333333333, 1.4666666666667, 0.041666666666667
26437, 1.7, 1.4666666666667, 0.041666666666667
26438, 1.7416666666667, 1.4666666666667, 0.041666666666667
26439, 1.7833333333333, 1.4666666666667, 0.041666666666667
26440, 1.825, 1.4666666666667, 0.041666666666667
26441, 1.8666666666667, 1.4666666666667, 0.041666666666667
26442, 1.9083333333333, 1.4666666666667, 0.041666666666667
26443, 1.95, 1.4666666666667, 0.041666666666667
26444, 1.9916666666667, 1.4666666666667, 0.041666666666667
26445, 2.0333333333333, 1.4666666666667, 0.041666666666667
26446, 2.075, 1.4666666666667, 0.041666666666667
26447, 2.1166666666667, 1.4666666666667, 0.041666666666667
26448, 2.1583333333333, 1.4666666666667, 0.041666666666667
26449, 1.2416666666667, 1.4333333333333, 0.083333333333333
26450, 1.2833333333333, 1.4333333333333, 0.083333333333333
26451, 1.325, 1.4333333333333, 0.083333333333333
26452, 1.3666666666667, 1.4333333333333, 0.083333333333333
26453, 1.4083333333333, 1.4333333333333, 0.083333333333333
26454, 1.45, 1.4333333333333, 0.083333333333333
26455, 1.4916666666667, 1.4333333333333, 0.083333333333333
26456, 1.5333333333333, 1.4333333333333, 0.083333333333333
26457, 1.575, 1.4333333333333, 0.083333333333333
26458, 1.6166666666667, 1.4333333333333, 0.083333333333333
26459, 1.6583333333333, 1.4333333333333, 0.083333333333333
26460, 1.7, 1.4333333333333, 0.083333333333333
26461, 1.7416666666667, 1.4333333333333, 0.083333333333333
26462, 1.7833333333333, 1.4333333333333, 0.083333333333333
26463, 1.825, 1.4333333333333, 0.083333333333333
26464, 1.8666666666667, 1.4333333333333, 0.083333333333333
26465, 1.9083333333333, 1.4333333333333, 0.083333333333333
26466, 1.95, 1.4333333333333, 0.083333333333333
26467, 1.9916666666667, 1.4333333333333, 0.083333333333333
26468, 2.0333333333333, 1.4333333333333, 0.083333333333333
26469, 2.075, 1.4333333333333, 0.083333333333333
26470, 2.1166666666667, 1.4333333333333, 0.083333333333333
26471, 2.1583333333333, 1.4333333333333, 0.083333333333333
26472, 1.2416666666667, 1.4666666666667, 0.083333333333333
26473, 1.2833333333333, 1.4666666666667, 0.083333333333333
26474, 1.325, 1.4666666666667, 0.083333333333333
26475, 1.3666666666667, 1.4666666666667, 0.083333333333333
26476, 1.4083333333333, 1.4666666666667, 0.083333333333333
26477, 1.45, 1.4666666666667, 0.083333333333333
26478, 1.4916666666667, 1.4666666666667, 0.083333333333333
26479, 1.5333333333333, 1.4666666666667, 0.083333333333333
26480, 1.575, 1.4666666666667, 0.083333333333333
26481, 1.6166666666667, 1.4666666666667, 0.083333333333333
26482, 1.6583333333333, 1.4666666666667, 0.083333333333333
26483, 1.7, 1.4666666666667, 0.083333333333333
26484, 1.7416666666667, 1.4666666666667, 0.083333333333333
26485, 1.7833333333333, 1.4666666666667, 0.083333333333333
26486, 1.825, 1.4666666666667, 0.083333333333333
26487, 1.8666666666667, 1.4666666666667, 0.083333333333333
26488, 1.9083333333333, 1.4666666666667, 0.083333333333333
26489, 1.95, 1.4666666666667, 0.083333333333333
26490, 1.9916666666667, 1.4666666666667, 0.083333333333333
26491, 2.0333333333333, 1.4666666666667, 0.083333333333333
26492, 2.075, 1.4666666666667, 0.083333333333333
26493, 2.1166666666667, 1.4666666666667, 0.083333333333333
26494, 2.1583333333333, 1.4666666666667, 0.083333333333333
26495, 1.2416666666667, 1.4333333333333, 0.125
26496, 1.2833333333333, 1.4333333333333, 0.125
26497, 1.325, 1.4333333333333, 0.125
26498, 1.3666666666667, 1.4333333333333, 0.125
26499, 1.4083333333333, 1.4333333333333, 0.125
26500, 1.45, 1.4333333333333, 0.125
26501, 1.4916666666667, 1.4333333333333, 0.125
26502, 1.5333333333333, 1.4333333333333, 0.125
26503, 1.575, 1.4333333333333, 0.125
26504, 1.6166666666667, 1.4333333333333, 0.125
26505, 1.6583333333333, 1.4333333333333, 0.125
26506, 1.7, 1.4333333333333, 0.125
26507, 1.7416666666667, 1.4333333333333, 0.125
26508, 1.7833333333333, 1.4333333333333, 0.125
26509, 1.825, 1.4333333333333, 0.125
26510, 1.8666666666667, 1.4333333333333, 0.125
26511, 1.9083333333333, 1.4333333333333, 0.125
26512, 1.95, 1.4333333333333, 0.125
26513, 1.9916666666667, 1.4333333333333, 0.125
26514, 2.0333333333333, 1.4333333333333, 0.125
26515, 2.075, 1.4333333333333, 0.125
26516, 2.1166666666667, 1.4333333333333, 0.125
26517, 2.1583333333333, 1.4333333333333, 0.125
26518, 1.2416666666667, 1.4666666666667, 0.125
26519, 1.2833333333333, 1.4666666666667, 0.125
26520, 1.325, 1.4666666666667, 0.125
26521, 1.3666666666667, 1.4666666666667, 0.125
26522, 1.4083333333333, 1.4666666666667, 0.125
26523, 1.45, 1.4666666666667, 0.125
26524, 1.4916666666667, 1.4666666666667, 0.125
26525, 1.5333333333333, 1.4666666666667, 0.125
26526, 1.575, 1.4666666666667, 0.125
26527, 1.6166666666667, 1.4666666666667, 0.125
26528, 1.6583333333333, 1.4666666666667, 0.125
26529, 1.7, 1.4666666666667, 0.125
26530, 1.7416666666667, 1.4666666666667, 0.125
26531, 1.7833333333333, 1.4666666666667, 0.125
26532, 1.825, 1.4666666666667, 0.125
26533, 1.8666666666667, 1.4666666666667, 0.125
26534, 1.9083333333333, 1.4666666666667, 0.125
26535, 1.95, 1.4666666666667, 0.125
26536, 1.9916666666667, 1.4666666666667, 0.125
26537, 2.0333333333333, 1.4666666666667, 0.125
26538, 2.075, 1.4666666666667, 0.125
26539, 2.1166666666667, 1.4666666666667, 0.125
26540, 2.1583333333333, 1.4666666666667, 0.125
26541, 1.2416666666667, 1.4333333333333, 0.16666666666667
26542, 1.2833333333333, 1.4333333333333, 0.16666666666667
26543, 1.325, 1.4333333333333, 0.16666666666667
26544, 1.3666666666667, 1.4333333333333, 0.16666666666667
26545, 1.4083333333333, 1.4333333333333, 0.16666666666667
26546, 1.45, 1.4333333333333, 0.16666666666667
26547, 1.4916666666667, 1.4333333333333, 0.16666666666667
26548, 1.5333333333333, 1.4333333333333, 0.16666666666667
26549, 1.575, 1.4333333333333, 0.16666666666667
26550, 1.6166666666667, 1.4333333333333, 0.16666666666667
26551, 1.6583333333333, 1.4333333333333, 0.16666666666667
26552, 1.7, 1.4333333333333, 0.16666666666667
26553, 1.7416666666667, 1.4333333333333, 0.16666666666667
26554, 1.7833333333333, 1.4333333333333, 0.16666666666667
26555, 1.825, 1.4333333333333, 0.16666666666667
26556, 1.8666666666667, 1.4333333333333, 0.16666666666667
26557, 1.9083333333333, 1.4333333333333, 0.16666666666667
26558, 1.95, 1.4333333333333, 0.16666666666667
26559, 1.9916666666667, 1.4333333333333, 0.16666666666667
26560, 2.0333333333333, 1.4333333333333, 0.16666666666667
26561, 2.075, 1.4333333333333, 0.16666666666667
26562, 2.1166666666667, 1.4333333333333, 0.16666666666667
26563, 2.1583333333333, 1.4333333333333, 0.16666666666667
26564, 1.2416666666667, 1.4666666666667, 0.16666666666667
26565, 1.2833333333333, 1.4666666666667, 0.16666666666667
26566, 1.325, 1.4666666666667, 0.16666666666667
26567, 1.3666666666667, 1.4666666666667, 0.16666666666667
26568, 1.4083333333333, 1.4666666666667, 0.16666666666667
26569, 1.45, 1.4666666666667, 0.16666666666667
26570, 1.4916666666667, 1.4666666666667, 0.16666666666667
26571, 1.5333333333333, 1.4666666666667, 0.16666666666667
26572, 1.575, 1.4666666666667, 0.16666666666667
26573, 1.6166666666667, 1.4666666666667, 0.16666666666667
26574, 1.6583333333333, 1.4666666666667, 0.16666666666667
26575, 1.7, 1.4666666666667, 0.16666666666667
26576, 1.7416666666667, 1.4666666666667, 0.16666666666667
26577, 1.7833333333333, 1.4666666666667, 0.16666666666667
26578, 1.825, 1.4666666666667, 0.16666666666667
26579, 1.8666666666667, 1.4666666666667, 0.16666666666667
26580, 1.9083333333333, 1.4666666666667, 0.16666666666667
26581, 1.95, 1.4666666666667, 0.16666666666667
26582, 1.9916666666667, 1.4666666666667, 0.16666666666667
26583, 2.0333333333333, 1.4666666666667, 0.16666666666667
26584, 2.075, 1.4666666666667, 0.16666666666667
26585, 2.1166666666667, 1.4666666666667, 0.16666666666667
26586, 2.1583333333333, 1.4666666666667, 0.16666666666667
26587, 1.2416666666667, 1.4333333333333, 0.20833333333333
26588, 1.2833333333333, 1.4333333333333, 0.20833333333333
26589, 1.325, 1.4333333333333, 0.20833333333333
26590, 1.3666666666667, 1.4333333333333, 0.20833333333333
26591, 1.4083333333333, 1.4333333333333, 0.20833333333333
26592, 1.45, 1.4333333333333, 0.20833333333333
26593, 1.4916666666667, 1.4333333333333, 0.20833333333333
26594, 1.5333333333333, 1.4333333333333, 0.20833333333333
26595, 1.575, 1.4333333333333, 0.20833333333333
26596, 1.6166666666667, 1.4333333333333, 0.20833333333333
26597, 1.6583333333333, 1.4333333333333, 0.20833333333333
26598, 1.7, 1.4333333333333, 0.20833333333333
26599, 1.7416666666667, 1.4333333333333, 0.20833333333333
26600, 1.7833333333333, 1.4333333333333, 0.20833333333333
26601, 1.825, 1.4333333333333, 0.20833333333333
26602, 1.8666666666667, 1.4333333333333, 0.20833333333333
26603, 1.9083333333333, 1.4333333333333, 0.20833333333333
26604, 1.95, 1.4333333333333, 0.20833333333333
26605, 1.9916666666667, 1.4333333333333, 0.20833333333333
26606, 2.0333333333333, 1.4333333333333, 0.20833333333333
26607, 2.075, 1.4333333333333, 0.20833333333333
26608, 2.1166666666667, 1.4333333333333, 0.20833333333333
26609, 2.1583333333333, 1.4333333333333, 0.20833333333333
26610, 1.2416666666667, 1.4666666666667, 0.20833333333333
26611, 1.2833333333333, 1.4666666666667, 0.20833333333333
26612, 1.325, 1.4666666666667, 0.20833333333333
26613, 1.3666666666667, 1.4666666666667, 0.20833333333333
26614, 1.4083333333333, 1.4666666666667, 0.20833333333333
26615, 1.45, 1.4666666666667, 0.20833333333333
26616, 1.4916666666667, 1.4666666666667, 0.20833333333333
26617, 1.5333333333333, 1.4666666666667, 0.20833333333333
26618, 1.575, 1.4666666666667, 0.20833333333333
26619, 1.6166666666667, 1.4666666666667, 0.20833333333333
26620, 1.6583333333333, 1.4666666666667, 0.20833333333333
26621, 1.7, 1.4666666666667, 0.20833333333333
26622, 1.7416666666667, 1.4666666666667, 0.20833333333333
26623, 1.7833333333333, 1.4666666666667, 0.20833333333333
26624, 1.825, 1.4666666666667, 0.20833333333333
26625, 1.8666666666667, 1.4666666666667, 0.20833333333333
26626, 1.9083333333333, 1.4666666666667, 0.20833333333333
26627, 1.95, 1.4666666666667, 0.20833333333333
26628, 1.9916666666667, 1.4666666666667, 0.20833333333333
26629, 2.0333333333333, 1.4666666666667, 0.20833333333333
26630, 2.075, 1.4666666666667, 0.20833333333333
26631, 2.1166666666667, 1.4666666666667, 0.20833333333333
26632, 2.1583333333333, 1.4666666666667, 0.20833333333333
26633, 1.2416666666667, 1.4333333333333, 0.25
26634, 1.2833333333333, 1.4333333333333, 0.25
26635, 1.325, 1.4333333333333, 0.25
26636, 1.3666666666667, 1.4333333333333, 0.25
26637, 1.4083333333333, 1.4333333333333, 0.25
26638, 1.45, 1.4333333333333, 0.25
26639, 1.4916666666667, 1.4333333333333, 0.25
26640, 1.5333333333333, 1.4333333333333, 0.25
26641, 1.575, 1.4333333333333, 0.25
26642, 1.6166666666667, 1.4333333333333, 0.25
26643, 1.6583333333333, 1.4333333333333, 0.25
26644, 1.7, 1.4333333333333, 0.25
26645, 1.7416666666667, 1.4333333333333, 0.25
26646, 1.7833333333333, 1.4333333333333, 0.25
26647, 1.825, 1.4333333333333, 0.25
26648, 1.8666666666667, 1.4333333333333, 0.25
26649, 1.9083333333333, 1.4333333333333, 0.25
26650, 1.95, 1.4333333333333, 0.25
26651, 1.9916666666667, 1.4333333333333, 0.25
26652, 2.0333333333333, 1.4333333333333, 0.25
26653, 2.075, 1.4333333333333, 0.25
26654, 2.1166666666667, 1.4333333333333, 0.25
26655, 2.1583333333333, 1.4333333333333, 0.25
26656, 1.2416666666667, 1.4666666666667, 0.25
26657, 1.2833333333333, 1.4666666666667, 0.25
26658, 1.325, 1.4666666666667, 0.25
26659, 1.3666666666667, 1.4666666666667, 0.25
26660, 1.4083333333333, 1.4666666666667, 0.25
26661, 1.45, 1.4666666666667, 0.25
26662, 1.4916666666667, 1.4666666666667, 0.25
26663, 1.5333333333333, 1.4666666666667, 0.25
26664, 1.575, 1.4666666666667, 0.25
26665, 1.6166666666667, 1.4666666666667, 0.25
26666, 1.6583333333333, 1.4666666666667, 0.25
26667, 1.7, 1.4666666666667, 0.25
26668, 1.7416666666667, 1.4666666666667, 0.25
26669, 1.7833333333333, 1.4666666666667, 0.25
26670, 1.825, 1.4666666666667, 0.25
26671, 1.8666666666667, 1.4666666666667, 0.25
26672, 1.9083333333333, 1.4666666666667, 0.25
26673, 1.95, 1.4666666666667, 0.25
26674, 1.9916666666667, 1.4666666666667, 0.25
26675, 2.0333333333333, 1.4666666666667, 0.25
26676, 2.075, 1.4666666666667, 0.25
26677, 2.1166666666667, 1.4666666666667, 0.25
26678, 2.1583333333333, 1.4666666666667, 0.25
26679, 1.2416666666667, 1.4333333333333, 0.29166666666667
26680, 1.2833333333333, 1.4333333333333, 0.29166666666667
26681, 1.325, 1.4333333333333, 0.29166666666667
26682, 1.3666666666667, 1.4333333333333, 0.29166666666667
26683, 1.4083333333333, 1.4333333333333, 0.29166666666667
26684, 1.45, 1.4333333333333, 0.29166666666667
26685, 1.4916666666667, 1.4333333333333, 0.29166666666667
26686, 1.5333333333333, 1.4333333333333, 0.29166666666667
26687, 1.575, 1.4333333333333, 0.29166666666667
26688, 1.6166666666667, 1.4333333333333, 0.29166666666667
26689, 1.6583333333333, 1.4333333333333, 0.29166666666667
26690, 1.7, 1.4333333333333, 0.29166666666667
26691, 1.7416666666667, 1.4333333333333, 0.29166666666667
26692, 1.7833333333333, 1.4333333333333, 0.29166666666667
26693, 1.825, 1.4333333333333, 0.29166666666667
26694, 1.8666666666667, 1.4333333333333, 0.29166666666667
26695, 1.9083333333333, 1.4333333333333, 0.29166666666667
26696, 1.95, 1.4333333333333, 0.29166666666667
26697, 1.9916666666667, 1.4333333333333, 0.29166666666667
26698, 2.0333333333333, 1.4333333333333, 0.29166666666667
26699, 2.075, 1.4333333333333, 0.29166666666667
26700, 2.1166666666667, 1.4333333333333, 0.29166666666667
26701, 2.1583333333333, 1.4333333333333, 0.29166666666667
26702, 1.2416666666667, 1.4666666666667, 0.29166666666667
26703, 1.2833333333333, 1.4666666666667, 0.29166666666667
26704, 1.325, 1.4666666666667, 0.29166666666667
26705, 1.3666666666667, 1.4666666666667, 0.29166666666667
26706, 1.4083333333333, 1.4666666666667, 0.29166666666667
26707, 1.45, 1.4666666666667, 0.29166666666667
26708, 1.4916666666667, 1.4666666666667, 0.29166666666667
26709, 1.5333333333333, 1.4666666666667, 0.29166666666667
26710, 1.575, 1.4666666666667, 0.29166666666667
26711, 1.6166666666667, 1.4666666666667, 0.29166666666667
26712, 1.6583333333333, 1.4666666666667, 0.29166666666667
26713, 1.7, 1.4666666666667, 0.29166666666667
26714, 1.7416666666667, 1.4666666666667, 0.29166666666667
26715, 1.7833333333333, 1.4666666666667, 0.29166666666667
26716, 1.825, 1.4666666666667, 0.29166666666667
26717, 1.8666666666667, 1.4666666666667, 0.29166666666667
26718, 1.9083333333333, 1.4666666666667, 0.29166666666667
26719, 1.95, 1.4666666666667, 0.29166666666667
26720, 1.9916666666667, 1.4666666666667, 0.29166666666667
26721, 2.0333333333333, 1.4666666666667, 0.29166666666667
26722, 2.075, 1.4666666666667, 0.29166666666667
26723, 2.1166666666667, 1.4666666666667, 0.29166666666667
26724, 2.1583333333333, 1.4666666666667, 0.29166666666667
26725, 1.2416666666667, 1.4333333333333, 0.33333333333333
26726, 1.2833333333333, 1.4333333333333, 0.33333333333333
26727, 1.325, 1.4333333333333, 0.33333333333333
26728, 1.3666666666667, 1.4333333333333, 0.33333333333333
26729, 1.4083333333333, 1.4333333333333, 0.33333333333333
26730, 1.45, 1.4333333333333, 0.33333333333333
26731, 1.4916666666667, 1.4333333333333, 0.33333333333333
26732, 1.5333333333333, 1.4333333333333, 0.33333333333333
26733, 1.575, 1.4333333333333, 0.33333333333333
26734, 1.6166666666667, 1.4333333333333, 0.33333333333333
26735, 1.6583333333333, 1.4333333333333, 0.33333333333333
26736, 1.7, 1.4333333333333, 0.33333333333333
26737, 1.7416666666667, 1.4333333333333, 0.33333333333333
26738, 1.7833333333333, 1.4333333333333, 0.33333333333333
26739, 1.825, 1.4333333333333, 0.33333333333333
26740, 1.8666666666667, 1.4333333333333, 0.33333333333333
26741, 1.9083333333333, 1.4333333333333, 0.33333333333333
26742, 1.95, 1.4333333333333, 0.33333333333333
26743, 1.9916666666667, 1.4333333333333, 0.33333333333333
26744, 2.0333333333333, 1.4333333333333, 0.33333333333333
26745, 2.075, 1.4333333333333, 0.33333333333333
26746, 2.1166666666667, 1.4333333333333, 0.33333333333333
26747, 2.1583333333333, 1.4333333333333, 0.33333333333333
26748, 1.2416666666667, 1.4666666666667, 0.33333333333333
26749, 1.2833333333333, 1.4666666666667, 0.33333333333333
26750, 1.325, 1.4666666666667, 0.33333333333333
26751, 1.3666666666667, 1.4666666666667, 0.33333333333333
26752, 1.4083333333333, 1.4666666666667, 0.33333333333333
26753, 1.45, 1.4666666666667, 0.33333333333333
26754, 1.4916666666667, 1.4666666666667, 0.33333333333333
26755, 1.5333333333333, 1.4666666666667, 0.33333333333333
26756, 1.575, 1.4666666666667, 0.33333333333333
26757, 1.6166666666667, 1.4666666666667, 0.33333333333333
26758, 1.6583333333333, 1.4666666666667, 0.33333333333333
26759, 1.7, 1.4666666666667, 0.33333333333333
26760, 1.7416666666667, 1.4666666666667, 0.33333333333333
26761, 1.7833333333333, 1.4666666666667, 0.33333333333333
26762, 1.825, 1.4666666666667, 0.33333333333333
26763, 1.8666666666667, 1.4666666666667, 0.33333333333333
26764, 1.9083333333333, 1.4666666666667, 0.33333333333333
26765, 1.95, 1.4666666666667, 0.33333333333333
26766, 1.9916666666667, 1.4666666666667, 0.33333333333333
26767, 2.0333333333333, 1.4666666666667, 0.33333333333333
26768, 2.075, 1.4666666666667, 0.33333333333333
26769, 2.1166666666667, 1.4666666666667, 0.33333333333333
26770, 2.1583333333333, 1.4666666666667, 0.33333333333333
26771, 1.2416666666667, 1.4333333333333, 0.375
26772, 1.2833333333333, 1.4333333333333, 0.375
26773, 1.325, 1.4333333333333, 0.375
26774, 1.3666666666667, 1.4333333333333, 0.375
26775, 1.4083333333333, 1.4333333333333, 0.375
26776, 1.45, 1.4333333333333, 0.375
26777, 1.4916666666667, 1.4333333333333, 0.375
26778, 1.5333333333333, 1.4333333333333, 0.375
26779, 1.575, 1.4333333333333, 0.375
26780, 1.6166666666667, 1.4333333333333, 0.375
26781, 1.6583333333333, 1.4333333333333, 0.375
26782, 1.7, 1.4333333333333, 0.375
26783, 1.7416666666667, 1.4333333333333, 0.375
26784, 1.7833333333333, 1.4333333333333, 0.375
26785, 1.825, 1.4333333333333, 0.375
26786, 1.8666666666667, 1.4333333333333, 0.375
26787, 1.9083333333333, 1.4333333333333, 0.375
26788, 1.95, 1.4333333333333, 0.375
26789, 1.9916666666667, 1.4333333333333, 0.375
26790, 2.0333333333333, 1.4333333333333, 0.375
26791, 2.075, 1.4333333333333, 0.375
26792, 2.1166666666667, 1.4333333333333, 0.375
26793, 2.1583333333333, 1.4333333333333, 0.375
26794, 1.2416666666667, 1.4666666666667, 0.375
26795, 1.2833333333333, 1.4666666666667, 0.375
26796, 1.325, 1.4666666666667, 0.375
26797, 1.3666666666667, 1.4666666666667, 0.375
26798, 1.4083333333333, 1.4666666666667, 0.375
26799, 1.45, 1.4666666666667, 0.375
26800, 1.4916666666667, 1.4666666666667, 0.375
26801, 1.5333333333333, 1.4666666666667, 0.375
26802, 1.575, 1.4666666666667, 0.375
26803, 1.6166666666667, 1.4666666666667, 0.375
26804, 1.6583333333333, 1.4666666666667, 0.375
26805, 1.7, 1.4666666666667, 0.375
26806, 1.7416666666667, 1.4666666666667, 0.375
26807, 1.7833333333333, 1.4666666666667, 0.375
26808, 1.825, 1.4666666666667, 0.375
26809, 1.8666666666667, 1.4666666666667, 0.375
26810, 1.9083333333333, 1.4666666666667, 0.375
26811, 1.95, 1.4666666666667, 0.375
26812, 1.9916666666667, 1.4666666666667, 0.375
26813, 2.0333333333333, 1.4666666666667, 0.375
26814, 2.075, 1.4666666666667, 0.375
26815, 2.1166666666667, 1.4666666666667, 0.375
26816, 2.1583333333333, 1.4666666666667, 0.375
26817, 1.2416666666667, 1.4333333333333, 0.41666666666667
26818, 1.2833333333333, 1.4333333333333, 0.41666666666667
26819, 1.325, 1.4333333333333, 0.41666666666667
26820, 1.3666666666667, 1.4333333333333, 0.41666666666667
26821, 1.4083333333333, 1.4333333333333, 0.41666666666667
26822, 1.45, 1.4333333333333, 0.41666666666667
26823, 1.4916666666667, 1.4333333333333, 0.41666666666667
26824, 1.5333333333333, 1.4333333333333, 0.41666666666667
26825, 1.575, 1.4333333333333, 0.41666666666667
26826, 1.6166666666667, 1.4333333333333, 0.41666666666667
26827, 1.6583333333333, 1.4333333333333, 0.41666666666667
26828, 1.7, 1.4333333333333, 0.41666666666667
26829, 1.7416666666667, 1.4333333333333, 0.41666666666667
26830, 1.7833333333333, 1.4333333333333, 0.41666666666667
26831, 1.825, 1.4333333333333, 0.41666666666667
26832, 1.8666666666667, 1.4333333333333, 0.41666666666667
26833, 1.9083333333333, 1.4333333333333, 0.41666666666667
26834, 1.95, 1.4333333333333, 0.41666666666667
26835, 1.9916666666667, 1.4333333333333, 0.41666666666667
26836, 2.0333333333333, 1.4333333333333, 0.41666666666667
26837, 2.075, 1.4333333333333, 0.41666666666667
26838, 2.1166666666667, 1.4333333333333, 0.41666666666667
26839, 2.1583333333333, 1.4333333333333, 0.41666666666667
26840, 1.2416666666667, 1.4666666666667, 0.41666666666667
26841, 1.2833333333333, 1.4666666666667, 0.41666666666667
26842, 1.325, 1.4666666666667, 0.41666666666667
26843, 1.3666666666667, 1.4666666666667, 0.41666666666667
26844, 1.4083333333333, 1.4666666666667, 0.41666666666667
26845, 1.45, 1.4666666666667, 0.41666666666667
26846, 1.4916666666667, 1.4666666666667, 0.41666666666667
26847, 1.5333333333333, 1.4666666666667, 0.41666666666667
26848, 1.575, 1.4666666666667, 0.41666666666667
26849, 1.6166666666667, 1.4666666666667, 0.41666666666667
26850, 1.6583333333333, 1.4666666666667, 0.41666666666667
26851, 1.7, 1.4666666666667, 0.41666666666667
26852, 1.7416666666667, 1.4666666666667, 0.41666666666667
26853, 1.7833333333333, 1.4666666666667, 0.41666666666667
26854, 1.825, 1.4666666666667, 0.41666666666667
26855, 1.8666666666667, 1.4666666666667, 0.41666666666667
26856, 1.9083333333333, 1.4666666666667, 0.41666666666667
26857, 1.95, 1.4666666666667, 0.41666666666667
26858, 1.9916666666667, 1.4666666666667, 0.41666666666667
26859, 2.0333333333333, 1.4666666666667, 0.41666666666667
26860, 2.075, 1.4666666666667, 0.41666666666667
26861, 2.1166666666667, 1.4666666666667, 0.41666666666667
26862, 2.1583333333333, 1.4666666666667, 0.41666666666667
26863, 1.2416666666667, 1.4333333333333, 0.45833333333333
26864, 1.2833333333333, 1.4333333333333, 0.45833333333333
26865, 1.325, 1.4333333333333, 0.45833333333333
26866, 1.3666666666667, 1.4333333333333, 0.45833333333333
26867, 1.4083333333333, 1.4333333333333, 0.45833333333333
26868, 1.45, 1.4333333333333, 0.45833333333333
26869, 1.4916666666667, 1.4333333333333, 0.45833333333333
26870, 1.5333333333333, 1.4333333333333, 0.45833333333333
26871, 1.575, 1.4333333333333, 0.45833333333333
26872, 1.6166666666667, 1.4333333333333, 0.45833333333333
26873, 1.6583333333333, 1.4333333333333, 0.45833333333333
26874, 1.7, 1.4333333333333, 0.45833333333333
26875, 1.7416666666667, 1.4333333333333, 0.45833333333333
26876, 1.7833333333333, 1.4333333333333, 0.45833333333333
26877, 1.825, 1.4333333333333, 0.45833333333333
26878, 1.8666666666667, 1.4333333333333, 0.45833333333333
26879, 1.9083333333333, 1.4333333333333, 0.45833333333333
26880, 1.95, 1.4333333333333, 0.45833333333333
26881, 1.9916666666667, 1.4333333333333, 0.45833333333333
26882, 2.0333333333333, 1.4333333333333, 0.45833333333333
26883, 2.075, 1.4333333333333, 0.45833333333333
26884, 2.1166666666667, 1.4333333333333, 0.45833333333333
26885, 2.1583333333333, 1.4333333333333, 0.45833333333333
26886, 1.2416666666667, 1.4666666666667, 0.45833333333333
26887, 1.2833333333333, 1.4666666666667, 0.45833333333333
26888, 1.325, 1.4666666666667, 0.45833333333333
26889, 1.3666666666667, 1.4666666666667, 0.45833333333333
26890, 1.4083333333333, 1.4666666666667, 0.45833333333333
26891, 1.45, 1.4666666666667, 0.45833333333333
26892, 1.4916666666667, 1.4666666666667, 0.45833333333333
26893, 1.5333333333333, 1.4666666666667, 0.45833333333333
26894, 1.575, 1.4666666666667, 0.45833333333333
26895, 1.6166666666667, 1.4666666666667, 0.45833333333333
26896, 1.6583333333333, 1.4666666666667, 0.45833333333333
26897, 1.7, 1.4666666666667, 0.45833333333333
26898, 1.7416666666667, 1.4666666666667, 0.45833333333333
26899, 1.7833333333333, 1.4666666666667, 0.45833333333333
26900, 1.825, 1.4666666666667, 0.45833333333333
26901, 1.8666666666667, 1.4666666666667, 0.45833333333333
26902, 1.9083333333333, 1.4666666666667, 0.45833333333333
26903, 1.95, 1.4666666666667, 0.45833333333333
26904, 1.9916666666667, 1.4666666666667, 0.45833333333333
26905, 2.0333333333333, 1.4666666666667, 0.45833333333333
26906, 2.075, 1.4666666666667, 0.45833333333333
26907, 2.1166666666667, 1.4666666666667, 0.45833333333333
26908, 2.1583333333333, 1.4666666666667, 0.45833333333333
26909, 1.2416666666667, 1.3, 0.041666666666667
26910, 1.2416666666667, 1.25, 0.041666666666667
26911, 1.2416666666667, 1.2, 0.041666666666667
26912, 1.2416666666667, 1.15, 0.041666666666667
26913, 1.2416666666667, 1.1, 0.041666666666667
26914, 1.2416666666667, 1.05, 0.041666666666667
26915, 1.2416666666667, 1, 0.041666666666667
26916, 1.2416666666667, 0.95, 0.041666666666667
26917, 1.2416666666667, 0.9, 0.041666666666667
26918, 1.2416666666667, 0.85, 0.041666666666667
26919, 1.2416666666667, 0.8, 0.041666666666667
26920, 1.2416666666667, 0.75, 0.041666666666667
26921, 1.2416666666667, 0.7, 0.041666666666667
26922, 1.2416666666667, 0.65, 0.041666666666667
26923, 1.2416666666667, 0.6, 0.041666666666667
26924, 1.2416666666667, 0.55, 0.041666666666667
26925, 1.2416666666667, 0.5, 0.041666666666667
26926, 1.2416666666667, 0.45, 0.041666666666667
26927, 1.2416666666667, 0.4, 0.041666666666667
26928, 1.2416666666667, 0.35, 0.041666666666667
26929, 1.2416666666667, 0.3, 0.041666666666667
26930, 1.2416666666667, 0.25, 0.041666666666667
26931, 1.2416666666667, 0.2, 0.041666666666667
26932, 1.2833333333333, 1.3, 0.041666666666667
26933, 1.2833333333333, 1.25, 0.041666666666667
26934, 1.2833333333333, 1.2, 0.041666666666667
26935, 1.2833333333333, 1.15, 0.041666666666667
26936, 1.2833333333333, 1.1, 0.041666666666667
26937, 1.2833333333333, 1.05, 0.041666666666667
26938, 1.2833333333333, 1, 0.041666666666667
26939, 1.2833333333333, 0.95, 0.041666666666667
26940, 1.2833333333333, 0.9, 0.041666666666667
26941, 1.2833333333333, 0.85, 0.041666666666667
26942, 1.2833333333333, 0.8, 0.041666666666667
26943, 1.2833333333333, 0.75, 0.041666666666667
26944, 1.2833333333333, 0.7, 0.041666666666667
26945, 1.2833333333333, 0.65, 0.041666666666667
26946, 1.2833333333333, 0.6, 0.041666666666667
26947, 1.2833333333333, 0.55, 0.041666666666667
26948, 1.2833333333333, 0.5, 0.041666666666667
26949, 1.2833333333333, 0.45, 0.041666666666667
26950, 1.2833333333333, 0.4, 0.041666666666667
26951, 1.2833333333333, 0.35, 0.041666666666667
26952, 1.2833333333333, 0.3, 0.041666666666667
26953, 1.2833333333333, 0.25, 0.041666666666667
26954, 1.2833333333333, 0.2, 0.041666666666667
26955, 1.325, 1.3, 0.041666666666667
26956, 1.325, 1.25, 0.041666666666667
26957, 1.325, 1.2, 0.041666666666667
26958, 1.325, 1.15, 0.041666666666667
26959, 1.325, 1.1, 0.041666666666667
26960, 1.325, 1.05, 0.041666666666667
26961, 1.325, 1, 0.041666666666667
26962, 1.325, 0.95, 0.041666666666667
26963, 1.325, 0.9, 0.041666666666667
26964, 1.325, 0.85, 0.041666666666667
26965, 1.325, 0.8, 0.041666666666667
26966, 1.325, 0.75, 0.041666666666667
26967, 1.325, 0.7, 0.041666666666667
26968, 1.325, 0.65, 0.041666666666667
26969, 1.325, 0.6, 0.041666666666667
26970, 1.325, 0.55, 0.041666666666667
26971, 1.325, 0.5, 0.041666666666667
26972, 1.325, 0.45, 0.041666666666667
26973, 1.325, 0.4, 0.041666666666667
26974, 1.325, 0.35, 0.041666666666667
26975, 1.325, 0.3, 0.041666666666667
26976, 1.325, 0.25, 0.041666666666667
26977, 1.325, 0.2, 0.041666666666667
26978, 1.3666666666667, 1.3, 0.041666666666667
26979, 1.3666666666667, 1.25, 0.041666666666667
26980, 1.3666666666667, 1.2, 0.041666666666667
26981, 1.3666666666667, 1.15, 0.041666666666667
26982, 1.3666666666667, 1.1, 0.041666666666667
26983, 1.3666666666667, 1.05, 0.041666666666667
26984, 1.3666666666667, 1, 0.041666666666667
26985, 1.3666666666667, 0.95, 0.041666666666667
26986, 1.3666666666667, 0.9, 0.041666666666667
26987, 1.3666666666667, 0.85, 0.041666666666667
26988, 1.3666666666667, 0.8, 0.041666666666667
26989, 1.3666666666667, 0.75, 0.041666666666667
26990, 1.3666666666667, 0.7, 0.041666666666667
26991, 1.3666666666667, 0.65, 0.041666666666667
26992, 1.3666666666667, 0.6, 0.041666666666667
26993, 1.3666666666667, 0.55, 0.041666666666667
26994, 1.3666666666667, 0.5, 0.041666666666667
26995, 1.3666666666667, 0.45, 0.041666666666667
26996, 1.3666666666667, 0.4, 0.041666666666667
26997, 1.3666666666667, 0.35, 0.041666666666667
26998, 1.3666666666667, 0.3, 0.041666666666667
26999, 1.3666666666667, 0.25, 0.041666666666667
27000, 1.3666666666667, 0.2, 0.041666666666667
27001, 1.4083333333333, 1.3, 0.041666666666667
27002, 1.4083333333333, 1.25, 0.041666666666667
27003, 1.4083333333333, 1.2, 0.041666666666667
27004, 1.4083333333333, 1.15, 0.041666666666667
27005, 1.4083333333333, 1.1, 0.041666666666667
27006, 1.4083333333333, 1.05, 0.041666666666667
27007, 1.4083333333333, 1, 0.041666666666667
27008, 1.4083333333333, 0.95, 0.041666666666667
27009, 1.4083333333333, 0.9, 0.041666666666667
27010, 1.4083333333333, 0.85, 0.041666666666667
27011, 1.4083333333333, 0.8, 0.041666666666667
27012, 1.4083333333333, 0.75, 0.041666666666667
27013, 1.4083333333333, 0.7, 0.041666666666667
27014, 1.4083333333333, 0.65, 0.041666666666667
27015, 1.4083333333333, 0.6, 0.041666666666667
27016, 1.4083333333333, 0.55, 0.041666666666667
27017, 1.4083333333333, 0.5, 0.041666666666667
27018, 1.4083333333333, 0.45, 0.041666666666667
27019, 1.4083333333333, 0.4, 0.041666666666667
27020, 1.4083333333333, 0.35, 0.041666666666667
27021, 1.4083333333333, 0.3, 0.041666666666667
27022, 1.4083333333333, 0.25, 0.041666666666667
27023, 1.4083333333333, 0.2, 0.041666666666667
27024, 1.45, 1.3, 0.041666666666667
27025, 1.45, 1.25, 0.041666666666667
27026, 1.45, 1.2, 0.041666666666667
27027, 1.45, 1.15, 0.041666666666667
27028, 1.45, 1.1, 0.041666666666667
27029, 1.45, 1.05, 0.041666666666667
27030, 1.45, 1, 0.041666666666667
27031, 1.45, 0.95, 0.041666666666667
27032, 1.45, 0.9, 0.041666666666667
27033, 1.45, 0.85, 0.041666666666667
27034, 1.45, 0.8, 0.041666666666667
27035, 1.45, 0.75, 0.041666666666667
27036, 1.45, 0.7, 0.041666666666667
27037, 1.45, 0.65, 0.041666666666667
27038, 1.45, 0.6, 0.041666666666667
27039, 1.45, 0.55, 0.041666666666667
27040, 1.45, 0.5, 0.041666666666667
27041, 1.45, 0.45, 0.041666666666667
27042, 1.45, 0.4, 0.041666666666667
27043, 1.45, 0.35, 0.041666666666667
27044, 1.45, 0.3, 0.041666666666667
27045, 1.45, 0.25, 0.041666666666667
27046, 1.45, 0.2, 0.041666666666667
27047, 1.4916666666667, 1.3, 0.041666666666667
27048, 1.4916666666667, 1.25, 0.041666666666667
27049, 1.4916666666667, 1.2, 0.041666666666667
27050, 1.4916666666667, 1.15, 0.041666666666667
27051, 1.4916666666667, 1.1, 0.041666666666667
27052, 1.4916666666667, 1.05, 0.041666666666667
27053, 1.4916666666667, 1, 0.041666666666667
27054, 1.4916666666667, 0.95, 0.041666666666667
27055, 1.4916666666667, 0.9, 0.041666666666667
27056, 1.4916666666667, 0.85, 0.041666666666667
27057, 1.4916666666667, 0.8, 0.041666666666667
27058, 1.4916666666667, 0.75, 0.041666666666667
27059, 1.4916666666667, 0.7, 0.041666666666667
27060, 1.4916666666667, 0.65, 0.041666666666667
27061, 1.4916666666667, 0.6, 0.041666666666667
27062, 1.4916666666667, 0.55, 0.041666666666667
27063, 1.4916666666667, 0.5, 0.041666666666667
27064, 1.4916666666667, 0.45, 0.041666666666667
27065, 1.4916666666667, 0.4, 0.041666666666667
27066, 1.4916666666667, 0.35, 0.041666666666667
27067, 1.4916666666667, 0.3, 0.041666666666667
27068, 1.4916666666667, 0.25, 0.041666666666667
27069, 1.4916666666667, 0.2, 0.041666666666667
27070, 1.5333333333333, 1.3, 0.041666666666667
27071, 1.5333333333333, 1.25, 0.041666666666667
27072, 1.5333333333333, 1.2, 0.041666666666667
27073, 1.5333333333333, 1.15, 0.041666666666667
27074, 1.5333333333333, 1.1, 0.041666666666667
27075, 1.5333333333333, 1.05, 0.041666666666667
27076, 1.5333333333333, 1, 0.041666666666667
27077, 1.5333333333333, 0.95, 0.041666666666667
27078, 1.5333333333333, 0.9, 0.041666666666667
27079, 1.5333333333333, 0.85, 0.041666666666667
27080, 1.5333333333333, 0.8, 0.041666666666667
27081, 1.5333333333333, 0.75, 0.041666666666667
27082, 1.5333333333333, 0.7, 0.041666666666667
27083, 1.5333333333333, 0.65, 0.041666666666667
27084, 1.5333333333333, 0.6, 0.041666666666667
27085, 1.5333333333333, 0.55, 0.041666666666667
27086, 1.5333333333333, 0.5, 0.041666666666667
27087, 1.5333333333333, 0.45, 0.041666666666667
27088, 1.5333333333333, 0.4, 0.041666666666667
27089, 1.5333333333333, 0.35, 0.041666666666667
27090, 1.5333333333333, 0.3, 0.041666666666667
27091, 1.5333333333333, 0.25, 0.041666666666667
27092, 1.5333333333333, 0.2, 0.041666666666667
27093, 1.575, 1.3, 0.041666666666667
27094, 1.575, 1.25, 0.041666666666667
27095, 1.575, 1.2, 0.041666666666667
27096, 1.575, 1.15, 0.041666666666667
27097, 1.575, 1.1, 0.041666666666667
27098, 1.575, 1.05, 0.041666666666667
27099, 1.575, 1, 0.041666666666667
27100, 1.575, 0.95, 0.041666666666667
27101, 1.575, 0.9, 0.041666666666667
27102, 1.575, 0.85, 0.041666666666667
27103, 1.575, 0.8, 0.041666666666667
27104, 1.575, 0.75, 0.041666666666667
27105, 1.575, 0.7, 0.041666666666667
27106, 1.575, 0.65, 0.041666666666667
27107, 1.575, 0.6, 0.041666666666667
27108, 1.575, 0.55, 0.041666666666667
27109, 1.575, 0.5, 0.041666666666667
27110, 1.575, 0.45, 0.041666666666667
27111, 1.575, 0.4, 0.041666666666667
27112, 1.575, 0.35, 0.041666666666667
27113, 1.575, 0.3, 0.041666666666667
27114, 1.575, 0.25, 0.041666666666667
27115, 1.575, 0.2, 0.041666666666667
27116, 1.6166666666667, 1.3, 0.041666666666667
27117, 1.6166666666667, 1.25, 0.041666666666667
27118, 1.6166666666667, 1.2, 0.041666666666667
27119, 1.6166666666667, 1.15, 0.041666666666667
27120, 1.6166666666667, 1.1, 0.041666666666667
27121, 1.6166666666667, 1.05, 0.041666666666667
27122, 1.6166666666667, 1, 0.041666666666667
27123, 1.6166666666667, 0.95, 0.041666666666667
27124, 1.6166666666667, 0.9, 0.041666666666667
27125, 1.6166666666667, 0.85, 0.041666666666667
27126, 1.6166666666667, 0.8, 0.041666666666667
27127, 1.6166666666667, 0.75, 0.041666666666667
27128, 1.6166666666667, 0.7, 0.041666666666667
27129, 1.6166666666667, 0.65, 0.041666666666667
27130, 1.6166666666667, 0.6, 0.041666666666667
27131, 1.6166666666667, 0.55, 0.041666666666667
27132, 1.6166666666667, 0.5, 0.041666666666667
27133, 1.6166666666667, 0.45, 0.041666666666667
27134, 1.6166666666667, 0.4, 0.041666666666667
27135, 1.6166666666667, 0.35, 0.041666666666667
27136, 1.6166666666667, 0.3, 0.041666666666667
27137, 1.6166666666667, 0.25, 0.041666666666667
27138, 1.6166666666667, 0.2, 0.041666666666667
27139, 1.6583333333333, 1.3, 0.041666666666667
27140, 1.6583333333333, 1.25, 0.041666666666667
27141, 1.6583333333333, 1.2, 0.041666666666667
27142, 1.6583333333333, 1.15, 0.041666666666667
27143, 1.6583333333333, 1.1, 0.041666666666667
27144, 1.6583333333333, 1.05, 0.041666666666667
27145, 1.6583333333333, 1, 0.041666666666667
27146, 1.6583333333333, 0.95, 0.041666666666667
27147, 1.6583333333333, 0.9, 0.041666666666667
27148, 1.6583333333333, 0.85, 0.041666666666667
27149, 1.6583333333333, 0.8, 0.041666666666667
27150, 1.6583333333333, 0.75, 0.041666666666667
27151, 1.6583333333333, 0.7, 0.041666666666667
27152, 1.6583333333333, 0.65, 0.041666666666667
27153, 1.6583333333333, 0.6, 0.041666666666667
27154, 1.6583333333333, 0.55, 0.041666666666667
27155, 1.6583333333333, 0.5, 0.041666666666667
27156, 1.6583333333333, 0.45, 0.041666666666667
27157, 1.6583333333333, 0.4, 0.041666666666667
27158, 1.6583333333333, 0.35, 0.041666666666667
27159, 1.6583333333333, 0.3, 0.041666666666667
27160, 1.6583333333333, 0.25, 0.041666666666667
27161, 1.6583333333333, 0.2, 0.041666666666667
27162, 1.7, 1.3, 0.041666666666667
27163, 1.7, 1.25, 0.041666666666667
27164, 1.7, 1.2, 0.041666666666667
27165, 1.7, 1.15, 0.041666666666667
27166, 1.7, 1.1, 0.041666666666667
27167, 1.7, 1.05, 0.041666666666667
27168, 1.7, 1, 0.041666666666667
27169, 1.7, 0.95, 0.041666666666667
27170, 1.7, 0.9, 0.041666666666667
27171, 1.7, 0.85, 0.041666666666667
27172, 1.7, 0.8, 0.041666666666667
27173, 1.7, 0.75, 0.041666666666667
27174, 1.7, 0.7, 0.041666666666667
27175, 1.7, 0.65, 0.041666666666667
27176, 1.7, 0.6, 0.041666666666667
27177, 1.7, 0.55, 0.041666666666667
27178, 1.7, 0.5, 0.041666666666667
27179, 1.7, 0.45, 0.041666666666667
27180, 1.7, 0.4, 0.041666666666667
27181, 1.7, 0.35, 0.041666666666667
27182, 1.7, 0.3, 0.041666666666667
27183, 1.7, 0.25, 0.041666666666667
27184, 1.7, 0.2, 0.041666666666667
27185, 1.7416666666667, 1.3, 0.041666666666667
27186, 1.7416666666667, 1.25, 0.041666666666667
27187, 1.7416666666667, 1.2, 0.041666666666667
27188, 1.7416666666667, 1.15, 0.041666666666667
27189, 1.7416666666667, 1.1, 0.041666666666667
27190, 1.7416666666667, 1.05, 0.041666666666667
27191, 1.7416666666667, 1, 0.041666666666667
27192, 1.7416666666667, 0.95, 0.041666666666667
27193, 1.7416666666667, 0.9, 0.041666666666667
27194, 1.7416666666667, 0.85, 0.041666666666667
27195, 1.7416666666667, 0.8, 0.041666666666667
27196, 1.7416666666667, 0.75, 0.041666666666667
27197, 1.7416666666667, 0.7, 0.041666666666667
27198, 1.7416666666667, 0.65, 0.041666666666667
27199, 1.7416666666667, 0.6, 0.041666666666667
27200, 1.7416666666667, 0.55, 0.041666666666667
27201, 1.7416666666667, 0.5, 0.041666666666667
27202, 1.7416666666667, 0.45, 0.041666666666667
27203, 1.7416666666667, 0.4, 0.041666666666667
27204, 1.7416666666667, 0.35, 0.041666666666667
27205, 1.7416666666667, 0.3, 0.041666666666667
27206, 1.7416666666667, 0.25, 0.041666666666667
27207, 1.7416666666667, 0.2, 0.041666666666667
27208, 1.7833333333333, 1.3, 0.041666666666667
27209, 1.7833333333333, 1.25, 0.041666666666667
27210, 1.7833333333333, 1.2, 0.041666666666667
27211, 1.7833333333333, 1.15, 0.041666666666667
27212, 1.7833333333333, 1.1, 0.041666666666667
27213, 1.7833333333333, 1.05, 0.041666666666667
27214, 1.7833333333333, 1, 0.041666666666667
27215, 1.7833333333333, 0.95, 0.041666666666667
27216, 1.7833333333333, 0.9, 0.041666666666667
27217, 1.7833333333333, 0.85, 0.041666666666667
27218, 1.7833333333333, 0.8, 0.041666666666667
27219, 1.7833333333333, 0.75, 0.041666666666667
27220, 1.7833333333333, 0.7, 0.041666666666667
27221, 1.7833333333333, 0.65, 0.041666666666667
27222, 1.7833333333333, 0.6, 0.041666666666667
27223, 1.7833333333333, 0.55, 0.041666666666667
27224, 1.7833333333333, 0.5, 0.041666666666667
27225, 1.7833333333333, 0.45, 0.041666666666667
27226, 1.7833333333333, 0.4, 0.041666666666667
27227, 1.7833333333333, 0.35, 0.041666666666667
27228, 1.7833333333333, 0.3, 0.041666666666667
27229, 1.7833333333333, 0.25, 0.041666666666667
27230, 1.7833333333333, 0.2, 0.041666666666667
27231, 1.825, 1.3, 0.041666666666667
27232, 1.825, 1.25, 0.041666666666667
27233, 1.825, 1.2, 0.041666666666667
27234, 1.825, 1.15, 0.041666666666667
27235, 1.825, 1.1, 0.041666666666667
27236, 1.825, 1.05, 0.041666666666667
27237, 1.825, 1, 0.041666666666667
27238, 1.825, 0.95, 0.041666666666667
27239, 1.825, 0.9, 0.041666666666667
27240, 1.825, 0.85, 0.041666666666667
27241, 1.825, 0.8, 0.041666666666667
27242, 1.825, 0.75, 0.041666666666667
27243, 1.825, 0.7, 0.041666666666667
27244, 1.825, 0.65, 0.041666666666667
27245, 1.825, 0.6, 0.041666666666667
27246, 1.825, 0.55, 0.041666666666667
27247, 1.825, 0.5, 0.041666666666667
27248, 1.825, 0.45, 0.041666666666667
27249, 1.825, 0.4, 0.041666666666667
27250, 1.825, 0.35, 0.041666666666667
27251, 1.825, 0.3, 0.041666666666667
27252, 1.825, 0.25, 0.041666666666667
27253, 1.825, 0.2, 0.041666666666667
27254, 1.8666666666667, 1.3, 0.041666666666667
27255, 1.8666666666667, 1.25, 0.041666666666667
27256, 1.8666666666667, 1.2, 0.041666666666667
27257, 1.8666666666667, 1.15, 0.041666666666667
27258, 1.8666666666667, 1.1, 0.041666666666667
27259, 1.8666666666667, 1.05, 0.041666666666667
27260, 1.8666666666667, 1, 0.041666666666667
27261, 1.8666666666667, 0.95, 0.041666666666667
27262, 1.8666666666667, 0.9, 0.041666666666667
27263, 1.8666666666667, 0.85, 0.041666666666667
27264, 1.8666666666667, 0.8, 0.041666666666667
27265, 1.8666666666667, 0.75, 0.041666666666667
27266, 1.8666666666667, 0.7, 0.041666666666667
27267, 1.8666666666667, 0.65, 0.041666666666667
27268, 1.8666666666667, 0.6, 0.041666666666667
27269, 1.8666666666667, 0.55, 0.041666666666667
27270, 1.8666666666667, 0.5, 0.041666666666667
27271, 1.8666666666667, 0.45, 0.041666666666667
27272, 1.8666666666667, 0.4, 0.041666666666667
27273, 1.8666666666667, 0.35, 0.041666666666667
27274, 1.8666666666667, 0.3, 0.041666666666667
27275, 1.8666666666667, 0.25, 0.041666666666667
27276, 1.8666666666667, 0.2, 0.041666666666667
27277, 1.9083333333333, 1.3, 0.041666666666667
27278, 1.9083333333333, 1.25, 0.041666666666667
27279, 1.9083333333333, 1.2, 0.041666666666667
27280, 1.9083333333333, 1.15, 0.041666666666667
27281, 1.9083333333333, 1.1, 0.041666666666667
27282, 1.9083333333333, 1.05, 0.041666666666667
27283, 1.9083333333333, 1, 0.041666666666667
27284, 1.9083333333333, 0.95, 0.041666666666667
27285, 1.9083333333333, 0.9, 0.041666666666667
27286, 1.9083333333333, 0.85, 0.041666666666667
27287, 1.9083333333333, 0.8, 0.041666666666667
27288, 1.9083333333333, 0.75, 0.041666666666667
27289, 1.9083333333333, 0.7, 0.041666666666667
27290, 1.9083333333333, 0.65, 0.041666666666667
27291, 1.9083333333333, 0.6, 0.041666666666667
27292, 1.9083333333333, 0.55, 0.041666666666667
27293, 1.9083333333333, 0.5, 0.041666666666667
27294, 1.9083333333333, 0.45, 0.041666666666667
27295, 1.9083333333333, 0.4, 0.041666666666667
27296, 1.9083333333333, 0.35, 0.041666666666667
27297, 1.9083333333333, 0.3, 0.041666666666667
27298, 1.9083333333333, 0.25, 0.041666666666667
27299, 1.9083333333333, 0.2, 0.041666666666667
27300, 1.95, 1.3, 0.041666666666667
27301, 1.95, 1.25, 0.041666666666667
27302, 1.95, 1.2, 0.041666666666667
27303, 1.95, 1.15, 0.041666666666667
27304, 1.95, 1.1, 0.041666666666667
27305, 1.95, 1.05, 0.041666666666667
27306, 1.95, 1, 0.041666666666667
27307, 1.95, 0.95, 0.041666666666667
27308, 1.95, 0.9, 0.041666666666667
27309, 1.95, 0.85, 0.041666666666667
27310, 1.95, 0.8, 0.041666666666667
27311, 1.95, 0.75, 0.041666666666667
27312, 1.95, 0.7, 0.041666666666667
27313, 1.95, 0.65, 0.041666666666667
27314, 1.95, 0.6, 0.041666666666667
27315, 1.95, 0.55, 0.041666666666667
27316, 1.95, 0.5, 0.041666666666667
27317, 1.95, 0.45, 0.041666666666667
27318, 1.95, 0.4, 0.041666666666667
27319, 1.95, 0.35, 0.041666666666667
27320, 1.95, 0.3, 0.041666666666667
27321, 1.95, 0.25, 0.041666666666667
27322, 1.95, 0.2, 0.041666666666667
27323, 1.9916666666667, 1.3, 0.041666666666667
27324, 1.9916666666667, 1.25, 0.041666666666667
27325, 1.9916666666667, 1.2, 0.041666666666667
27326, 1.9916666666667, 1.15, 0.041666666666667
27327, 1.9916666666667, 1.1, 0.041666666666667
27328, 1.9916666666667, 1.05, 0.041666666666667
27329, 1.9916666666667, 1, 0.041666666666667
27330, 1.9916666666667, 0.95, 0.041666666666667
27331, 1.9916666666667, 0.9, 0.041666666666667
27332, 1.9916666666667, 0.85, 0.041666666666667
27333, 1.9916666666667, 0.8, 0.041666666666667
27334, 1.9916666666667, 0.75, 0.041666666666667
27335, 1.9916666666667, 0.7, 0.041666666666667
27336, 1.9916666666667, 0.65, 0.041666666666667
27337, 1.9916666666667, 0.6, 0.041666666666667
27338, 1.9916666666667, 0.55, 0.041666666666667
27339, 1.9916666666667, 0.5, 0.041666666666667
27340, 1.9916666666667, 0.45, 0.041666666666667
27341, 1.9916666666667, 0.4, 0.041666666666667
27342, 1.9916666666667, 0.35, 0.041666666666667
27343, 1.9916666666667, 0.3, 0.041666666666667
27344, 1.9916666666667, 0.25, 0.041666666666667
27345, 1.9916666666667, 0.2, 0.041666666666667
27346, 2.0333333333333, 1.3, 0.041666666666667
27347, 2.0333333333333, 1.25, 0.041666666666667
27348, 2.0333333333333, 1.2, 0.041666666666667
27349, 2.0333333333333, 1.15, 0.041666666666667
27350, 2.0333333333333, 1.1, 0.041666666666667
27351, 2.0333333333333, 1.05, 0.041666666666667
27352, 2.0333333333333, 1, 0.041666666666667
27353, 2.0333333333333, 0.95, 0.041666666666667
27354, 2.0333333333333, 0.9, 0.041666666666667
27355, 2.0333333333333, 0.85, 0.041666666666667
27356, 2.0333333333333, 0.8, 0.041666666666667
27357, 2.0333333333333, 0.75, 0.041666666666667
27358, 2.0333333333333, 0.7, 0.041666666666667
27359, 2.0333333333333, 0.65, 0.041666666666667
27360, 2.0333333333333, 0.6, 0.041666666666667
27361, 2.0333333333333, 0.55, 0.041666666666667
27362, 2.0333333333333, 0.5, 0.041666666666667
27363, 2.0333333333333, 0.45, 0.041666666666667
27364, 2.0333333333333, 0.4, 0.041666666666667
27365, 2.0333333333333, 0.35, 0.041666666666667
27366, 2.0333333333333, 0.3, 0.041666666666667
27367, 2.0333333333333, 0.25, 0.041666666666667
27368, 2.0333333333333, 0.2, 0.041666666666667
27369, 2.075, 1.3, 0.041666666666667
27370, 2.075, 1.25, 0.041666666666667
27371, 2.075, 1.2, 0.041666666666667
27372, 2.075, 1.15, 0.041666666666667
27373, 2.075, 1.1, 0.041666666666667
27374, 2.075, 1.05, 0.041666666666667
27375, 2.075, 1, 0.041666666666667
27376, 2.075, 0.95, 0.041666666666667
27377, 2.075, 0.9, 0.041666666666667
27378, 2.075, 0.85, 0.041666666666667
27379, 2.075, 0.8, 0.041666666666667
27380, 2.075, 0.75, 0.041666666666667
27381, 2.075, 0.7, 0.041666666666667
27382, 2.075, 0.65, 0.041666666666667
27383, 2.075, 0.6, 0.041666666666667
27384, 2.075, 0.55, 0.041666666666667
27385, 2.075, 0.5, 0.041666666666667
27386, 2.075, 0.45, 0.041666666666667
27387, 2.075, 0.4, 0.041666666666667
27388, 2.075, 0.35, 0.041666666666667
27389, 2.075, 0.3, 0.041666666666667
27390, 2.075, 0.25, 0.041666666666667
27391, 2.075, 0.2, 0.041666666666667
27392, 2.1166666666667, 1.3, 0.041666666666667
27393, 2.1166666666667, 1.25, 0.041666666666667
27394, 2.1166666666667, 1.2, 0.041666666666667
27395, 2.1166666666667, 1.15, 0.041666666666667
27396, 2.1166666666667, 1.1, 0.041666666666667
27397, 2.1166666666667, 1.05, 0.041666666666667
27398, 2.1166666666667, 1, 0.041666666666667
27399, 2.1166666666667, 0.95, 0.041666666666667
27400, 2.1166666666667, 0.9, 0.041666666666667
27401, 2.1166666666667, 0.85, 0.041666666666667
27402, 2.1166666666667, 0.8, 0.041666666666667
27403, 2.1166666666667, 0.75, 0.041666666666667
27404, 2.1166666666667, 0.7, 0.041666666666667
27405, 2.1166666666667, 0.65, 0.041666666666667
27406, 2.1166666666667, 0.6, 0.041666666666667
27407, 2.1166666666667, 0.55, 0.041666666666667
27408, 2.1166666666667, 0.5, 0.041666666666667
27409, 2.1166666666667, 0.45, 0.041666666666667
27410, 2.1166666666667, 0.4, 0.041666666666667
27411, 2.1166666666667, 0.35, 0.041666666666667
27412, 2.1166666666667, 0.3, 0.041666666666667
27413, 2.1166666666667, 0.25, 0.041666666666667
27414, 2.1166666666667, 0.2, 0.041666666666667
27415, 2.1583333333333, 1.3, 0.041666666666667
27416, 2.1583333333333, 1.25, 0.041666666666667
27417, 2.1583333333333, 1.2, 0.041666666666667
27418, 2.1583333333333, 1.15, 0.041666666666667
27419, 2.1583333333333, 1.1, 0.041666666666667
27420, 2.1583333333333, 1.05, 0.041666666666667
27421, 2.1583333333333, 1, 0.041666666666667
27422, 2.1583333333333, 0.95, 0.041666666666667
27423, 2.1583333333333, 0.9, 0.041666666666667
27424, 2.1583333333333, 0.85, 0.041666666666667
27425, 2.1583333333333, 0.8, 0.041666666666667
27426, 2.1583333333333, 0.75, 0.041666666666667
27427, 2.1583333333333, 0.7, 0.041666666666667
27428, 2.1583333333333, 0.65, 0.041666666666667
27429, 2.1583333333333, 0.6, 0.041666666666667
27430, 2.1583333333333, 0.55, 0.041666666666667
27431, 2.1583333333333, 0.5, 0.041666666666667
27432, 2.1583333333333, 0.45, 0.041666666666667
27433, 2.1583333333333, 0.4, 0.041666666666667
27434, 2.1583333333333, 0.35, 0.041666666666667
27435, 2.1583333333333, 0.3, 0.041666666666667
27436, 2.1583333333333, 0.25, 0.041666666666667
27437, 2.1583333333333, 0.2, 0.041666666666667
27438, 1.2416666666667, 1.3, 0.083333333333333
27439, 1.2416666666667, 1.25, 0.083333333333333
27440, 1.2416666666667, 1.2, 0.083333333333333
27441, 1.2416666666667, 1.15, 0.083333333333333
27442, 1.2416666666667, 1.1, 0.083333333333333
27443, 1.2416666666667, 1.05, 0.083333333333333
27444, 1.2416666666667, 1, 0.083333333333333
27445, 1.2416666666667, 0.95, 0.083333333333333
27446, 1.2416666666667, 0.9, 0.083333333333333
27447, 1.2416666666667, 0.85, 0.083333333333333
27448, 1.2416666666667, 0.8, 0.083333333333333
27449, 1.2416666666667, 0.75, 0.083333333333333
27450, 1.2416666666667, 0.7, 0.083333333333333
27451, 1.2416666666667, 0.65, 0.083333333333333
27452, 1.2416666666667, 0.6, 0.083333333333333
27453, 1.2416666666667, 0.55, 0.083333333333333
27454, 1.2416666666667, 0.5, 0.083333333333333
27455, 1.2416666666667, 0.45, 0.083333333333333
27456, 1.2416666666667, 0.4, 0.083333333333333
27457, 1.2416666666667, 0.35, 0.083333333333333
27458, 1.2416666666667, 0.3, 0.083333333333333
27459, 1.2416666666667, 0.25, 0.083333333333333
27460, 1.2416666666667, 0.2, 0.083333333333333
27461, 1.2833333333333, 1.3, 0.083333333333333
27462, 1.2833333333333, 1.25, 0.083333333333333
27463, 1.2833333333333, 1.2, 0.083333333333333
27464, 1.2833333333333, 1.15, 0.083333333333333
27465, 1.2833333333333, 1.1, 0.083333333333333
27466, 1.2833333333333, 1.05, 0.083333333333333
27467, 1.2833333333333, 1, 0.083333333333333
27468, 1.2833333333333, 0.95, 0.083333333333333
27469, 1.2833333333333, 0.9, 0.083333333333333
27470, 1.2833333333333, 0.85, 0.083333333333333
27471, 1.2833333333333, 0.8, 0.083333333333333
27472, 1.2833333333333, 0.75, 0.083333333333333
27473, 1.2833333333333, 0.7, 0.083333333333333
27474, 1.2833333333333, 0.65, 0.083333333333333
27475, 1.2833333333333, 0.6, 0.083333333333333
27476, 1.2833333333333, 0.55, 0.083333333333333
27477, 1.2833333333333, 0.5, 0.083333333333333
27478, 1.2833333333333, 0.45, 0.083333333333333
27479, 1.2833333333333, 0.4, 0.083333333333333
27480, 1.2833333333333, 0.35, 0.083333333333333
27481, 1.2833333333333, 0.3, 0.083333333333333
27482, 1.2833333333333, 0.25, 0.083333333333333
27483, 1.2833333333333, 0.2, 0.083333333333333
27484, 1.325, 1.3, 0.083333333333333
27485, 1.325, 1.25, 0.083333333333333
27486, 1.325, 1.2, 0.083333333333333
27487, 1.325, 1.15, 0.083333333333333
27488, 1.325, 1.1, 0.083333333333333
27489, 1.325, 1.05, 0.083333333333333
27490, 1.325, 1, 0.083333333333333
27491, 1.325, 0.95, 0.083333333333333
27492, 1.325, 0.9, 0.083333333333333
27493, 1.325, 0.85, 0.083333333333333
27494, 1.325, 0.8, 0.083333333333333
27495, 1.325, 0.75, 0.083333333333333
27496, 1.325, 0.7, 0.083333333333333
27497, 1.325, 0.65, 0.083333333333333
27498, 1.325, 0.6, 0.083333333333333
27499, 1.325, 0.55, 0.083333333333333
27500, 1.325, 0.5, 0.083333333333333
27501, 1.325, 0.45, 0.083333333333333
27502, 1.325, 0.4, 0.083333333333333
27503, 1.325, 0.35, 0.083333333333333
27504, 1.325, 0.3, 0.083333333333333
27505, 1.325, 0.25, 0.083333333333333
27506, 1.325, 0.2, 0.083333333333333
27507, 1.3666666666667, 1.3, 0.083333333333333
27508, 1.3666666666667, 1.25, 0.083333333333333
27509, 1.3666666666667, 1.2, 0.083333333333333
27510, 1.3666666666667, 1.15, 0.083333333333333
27511, 1.3666666666667, 1.1, 0.083333333333333
27512, 1.3666666666667, 1.05, 0.083333333333333
27513, 1.3666666666667, 1, 0.083333333333333
27514, 1.3666666666667, 0.95, 0.083333333333333
27515, 1.3666666666667, 0.9, 0.083333333333333
27516, 1.3666666666667, 0.85, 0.083333333333333
27517, 1.3666666666667, 0.8, 0.083333333333333
27518, 1.3666666666667, 0.75, 0.083333333333333
27519, 1.3666666666667, 0.7, 0.083333333333333
27520, 1.3666666666667, 0.65, 0.083333333333333
27521, 1.3666666666667, 0.6, 0.083333333333333
27522, 1.3666666666667, 0.55, 0.083333333333333
27523, 1.3666666666667, 0.5, 0.083333333333333
27524, 1.3666666666667, 0.45, 0.083333333333333
27525, 1.3666666666667, 0.4, 0.083333333333333
27526, 1.3666666666667, 0.35, 0.083333333333333
27527, 1.3666666666667, 0.3, 0.083333333333333
27528, 1.3666666666667, 0.25, 0.083333333333333
27529, 1.3666666666667, 0.2, 0.083333333333333
27530, 1.4083333333333, 1.3, 0.083333333333333
27531, 1.4083333333333, 1.25, 0.083333333333333
27532, 1.4083333333333, 1.2, 0.083333333333333
27533, 1.4083333333333, 1.15, 0.083333333333333
27534, 1.4083333333333, 1.1, 0.083333333333333
27535, 1.4083333333333, 1.05, 0.083333333333333
27536, 1.4083333333333, 1, 0.083333333333333
27537, 1.4083333333333, 0.95, 0.083333333333333
27538, 1.4083333333333, 0.9, 0.083333333333333
27539, 1.4083333333333, 0.85, 0.083333333333333
27540, 1.4083333333333, 0.8, 0.083333333333333
27541, 1.4083333333333, 0.75, 0.083333333333333
27542, 1.4083333333333, 0.7, 0.083333333333333
27543, 1.4083333333333, 0.65, 0.083333333333333
27544, 1.4083333333333, 0.6, 0.083333333333333
27545, 1.4083333333333, 0.55, 0.083333333333333
27546, 1.4083333333333, 0.5, 0.083333333333333
27547, 1.4083333333333, 0.45, 0.083333333333333
27548, 1.4083333333333, 0.4, 0.083333333333333
27549, 1.4083333333333, 0.35, 0.083333333333333
27550, 1.4083333333333, 0.3, 0.083333333333333
27551, 1.4083333333333, 0.25, 0.083333333333333
27552, 1.4083333333333, 0.2, 0.083333333333333
27553, 1.45, 1.3, 0.083333333333333
27554, 1.45, 1.25, 0.083333333333333
27555, 1.45, 1.2, 0.083333333333333
27556, 1.45, 1.15, 0.083333333333333
27557, 1.45, 1.1, 0.083333333333333
27558, 1.45, 1.05, 0.083333333333333
27559, 1.45, 1, 0.083333333333333
27560, 1.45, 0.95, 0.083333333333333
27561, 1.45, 0.9, 0.083333333333333
27562, 1.45, 0.85, 0.083333333333333
27563, 1.45, 0.8, 0.083333333333333
27564, 1.45, 0.75, 0.083333333333333
27565, 1.45, 0.7, 0.083333333333333
27566, 1.45, 0.65, 0.083333333333333
27567, 1.45, 0.6, 0.083333333333333
27568, 1.45, 0.55, 0.083333333333333
27569, 1.45, 0.5, 0.083333333333333
27570, 1.45, 0.45, 0.083333333333333
27571, 1.45, 0.4, 0.083333333333333
27572, 1.45, 0.35, 0.083333333333333
27573, 1.45, 0.3, 0.083333333333333
27574, 1.45, 0.25, 0.083333333333333
27575, 1.45, 0.2, 0.083333333333333
27576, 1.4916666666667, 1.3, 0.083333333333333
27577, 1.4916666666667, 1.25, 0.083333333333333
27578, 1.4916666666667, 1.2, 0.083333333333333
27579, 1.4916666666667, 1.15, 0.083333333333333
27580, 1.4916666666667, 1.1, 0.083333333333333
27581, 1.4916666666667, 1.05, 0.083333333333333
27582, 1.4916666666667, 1, 0.083333333333333
27583, 1.4916666666667, 0.95, 0.083333333333333
27584, 1.4916666666667, 0.9, 0.083333333333333
27585, 1.4916666666667, 0.85, 0.083333333333333
27586, 1.4916666666667, 0.8, 0.083333333333333
27587, 1.4916666666667, 0.75, 0.083333333333333
27588, 1.4916666666667, 0.7, 0.083333333333333
27589, 1.4916666666667, 0.65, 0.083333333333333
27590, 1.4916666666667, 0.6, 0.083333333333333
27591, 1.4916666666667, 0.55, 0.083333333333333
27592, 1.4916666666667, 0.5, 0.083333333333333
27593, 1.4916666666667, 0.45, 0.083333333333333
27594, 1.4916666666667, 0.4, 0.083333333333333
27595, 1.4916666666667, 0.35, 0.083333333333333
27596, 1.4916666666667, 0.3, 0.083333333333333
27597, 1.4916666666667, 0.25, 0.083333333333333
27598, 1.4916666666667, 0.2, 0.083333333333333
27599, 1.5333333333333, 1.3, 0.083333333333333
27600, 1.5333333333333, 1.25, 0.083333333333333
27601, 1.5333333333333, 1.2, 0.083333333333333
27602, 1.5333333333333, 1.15, 0.083333333333333
27603, 1.5333333333333, 1.1, 0.083333333333333
27604, 1.5333333333333, 1.05, 0.083333333333333
27605, 1.5333333333333, 1, 0.083333333333333
27606, 1.5333333333333, 0.95, 0.083333333333333
27607, 1.5333333333333, 0.9, 0.083333333333333
27608, 1.5333333333333, 0.85, 0.083333333333333
27609, 1.5333333333333, 0.8, 0.083333333333333
27610, 1.5333333333333, 0.75, 0.083333333333333
27611, 1.5333333333333, 0.7, 0.083333333333333
27612, 1.5333333333333, 0.65, 0.083333333333333
27613, 1.5333333333333, 0.6, 0.083333333333333
27614, 1.5333333333333, 0.55, 0.083333333333333
27615, 1.5333333333333, 0.5, 0.083333333333333
27616, 1.5333333333333, 0.45, 0.083333333333333
27617, 1.5333333333333, 0.4, 0.083333333333333
27618, 1.5333333333333, 0.35, 0.083333333333333
27619, 1.5333333333333, 0.3, 0.083333333333333
27620, 1.5333333333333, 0.25, 0.083333333333333
27621, 1.5333333333333, 0.2, 0.083333333333333
27622, 1.575, 1.3, 0.083333333333333
27623, 1.575, 1.25, 0.083333333333333
27624, 1.575, 1.2, 0.083333333333333
27625, 1.575, 1.15, 0.083333333333333
27626, 1.575, 1.1, 0.083333333333333
27627, 1.575, 1.05, 0.083333333333333
27628, 1.575, 1, 0.083333333333333
27629, 1.575, 0.95, 0.083333333333333
27630, 1.575, 0.9, 0.083333333333333
27631, 1.575, 0.85, 0.083333333333333
27632, 1.575, 0.8, 0.083333333333333
27633, 1.575, 0.75, 0.083333333333333
27634, 1.575, 0.7, 0.083333333333333
27635, 1.575, 0.65, 0.083333333333333
27636, 1.575, 0.6, 0.083333333333333
27637, 1.575, 0.55, 0.083333333333333
27638, 1.575, 0.5, 0.083333333333333
27639, 1.575, 0.45, 0.083333333333333
27640, 1.575, 0.4, 0.083333333333333
27641, 1.575, 0.35, 0.083333333333333
27642, 1.575, 0.3, 0.083333333333333
27643, 1.575, 0.25, 0.083333333333333
27644, 1.575, 0.2, 0.083333333333333
27645, 1.6166666666667, 1.3, 0.083333333333333
27646, 1.6166666666667, 1.25, 0.083333333333333
27647, 1.6166666666667, 1.2, 0.083333333333333
27648, 1.6166666666667, 1.15, 0.083333333333333
27649, 1.6166666666667, 1.1, 0.083333333333333
27650, 1.6166666666667, 1.05, 0.083333333333333
27651, 1.6166666666667, 1, 0.083333333333333
27652, 1.6166666666667, 0.95, 0.083333333333333
27653, 1.6166666666667, 0.9, 0.083333333333333
27654, 1.6166666666667, 0.85, 0.083333333333333
27655, 1.6166666666667, 0.8, 0.083333333333333
27656, 1.6166666666667, 0.75, 0.083333333333333
27657, 1.6166666666667, 0.7, 0.083333333333333
27658, 1.6166666666667, 0.65, 0.083333333333333
27659, 1.6166666666667, 0.6, 0.083333333333333
27660, 1.6166666666667, 0.55, 0.083333333333333
27661, 1.6166666666667, 0.5, 0.083333333333333
27662, 1.6166666666667, 0.45, 0.083333333333333
27663, 1.6166666666667, 0.4, 0.083333333333333
