2006, 6287, 6310, 6311, 6288, 0, 0, 0, 0
2007, 6288, 6311, 6312, 6289, 0, 0, 0, 0
2008, 6289, 6312, 6313, 6290, 0, 0, 0, 0
2009, 6290, 6313, 6314, 6291, 0, 0, 0, 0
2010, 6291, 6314, 6315, 6292, 0, 0, 0, 0
2011, 6292, 6315, 6316, 6293, 0, 0, 0, 0
2012, 6293, 6316, 6317, 6294, 0, 0, 0, 0
2013, 6294, 6317, 6318, 6295, 0, 0, 0, 0
2014, 6295, 6318, 6319, 6296, 0, 0, 0, 0
2015, 6296, 6319, 6320, 6297, 0, 0, 0, 0
2016, 6297, 6320, 6321, 6298, 0, 0, 0, 0
2017, 6298, 6321, 6322, 6299, 0, 0, 0, 0
2018, 6299, 6322, 6323, 6300, 0, 0, 0, 0
2019, 6300, 6323, 6324, 6301, 0, 0, 0, 0
2020, 6301, 6324, 766, 765, 0, 0, 0, 0
2021, 648, 649, 6325, 6302, 0, 0, 0, 0
2022, 6302, 6325, 6326, 6303, 0, 0, 0, 0
2023, 6303, 6326, 6327, 6304, 0, 0, 0, 0
2024, 6304, 6327, 6328, 6305, 0, 0, 0, 0
2025, 6305, 6328, 6329, 6306, 0, 0, 0, 0
2026, 6306, 6329, 6330, 6307, 0, 0, 0, 0
2027, 6307, 6330, 6331, 6308, 0, 0, 0, 0
2028, 6308, 6331, 6332, 6309, 0, 0, 0, 0
2029, 6309, 6332, 6333, 6310, 0, 0, 0, 0
2030, 6310, 6333, 6334, 6311, 0, 0, 0, 0
2031, 6311, 6334, 6335, 6312, 0, 0, 0, 0
2032, 6312, 6335, 6336, 6313, 0, 0, 0, 0
2033, 6313, 6336, 6337, 6314, 0, 0, 0, 0
2034, 6314, 6337, 6338, 6315, 0, 0, 0, 0
2035, 6315, 6338, 6339, 6316, 0, 0, 0, 0
2036, 6316, 6339, 6340, 6317, 0, 0, 0, 0
2037, 6317, 6340, 6341, 6318, 0, 0, 0, 0
2038, 6318, 6341, 6342, 6319, 0, 0, 0, 0
2039, 6319, 6342, 6343, 6320, 0, 0, 0, 0
2040, 6320, 6343, 6344, 6321, 0, 0, 0, 0
2041, 6321, 6344, 6345, 6322, 0, 0, 0, 0
2042, 6322, 6345, 6346, 6323, 0, 0, 0, 0
2043, 6323, 6346, 6347, 6324, 0, 0, 0, 0
2044, 6324, 6347, 767, 766, 0, 0, 0, 0
2045, 649, 650, 6348, 6325, 0, 0, 0, 0
2046, 6325, 6348, 6349, 6326, 0, 0, 0, 0
2047, 6326, 6349, 6350, 6327, 0, 0, 0, 0
2048, 6327, 6350, 6351, 6328, 0, 0, 0, 0
2049, 6328, 6351, 6352, 6329, 0, 0, 0, 0
2050, 6329, 6352, 6353, 6330, 0, 0, 0, 0
2051, 6330, 6353, 6354, 6331, 0, 0, 0, 0
2052, 6331, 6354, 6355, 6332, 0, 0, 0, 0
2053, 6332, 6355, 6356, 6333, 0, 0, 0, 0
2054, 6333, 6356, 6357, 6334, 0, 0, 0, 0
2055, 6334, 6357, 6358, 6335, 0, 0, 0, 0
2056, 6335, 6358, 6359, 6336, 0, 0, 0, 0
2057, 6336, 6359, 6360, 6337, 0, 0, 0, 0
2058, 6337, 6360, 6361, 6338, 0, 0, 0, 0
2059, 6338, 6361, 6362, 6339, 0, 0, 0, 0
2060, 6339, 6362, 6363, 6340, 0, 0, 0, 0
2061, 6340, 6363, 6364, 6341, 0, 0, 0, 0
2062, 6341, 6364, 6365, 6342, 0, 0, 0, 0
2063, 6342, 6365, 6366, 6343, 0, 0, 0, 0
2064, 6343, 6366, 6367, 6344, 0, 0, 0, 0
2065, 6344, 6367, 6368, 6345, 0, 0, 0, 0
2066, 6345, 6368, 6369, 6346, 0, 0, 0, 0
2067, 6346, 6369, 6370, 6347, 0, 0, 0, 0
2068, 6347, 6370, 768, 767, 0, 0, 0, 0
2069, 650, 651, 6371, 6348, 0, 0, 0, 0
2070, 6348, 6371, 6372, 6349, 0, 0, 0, 0
2071, 6349, 6372, 6373, 6350, 0, 0, 0, 0
2072, 6350, 6373, 6374, 6351, 0, 0, 0, 0
2073, 6351, 6374, 6375, 6352, 0, 0, 0, 0
2074, 6352, 6375, 6376, 6353, 0, 0, 0, 0
2075, 6353, 6376, 6377, 6354, 0, 0, 0, 0
2076, 6354, 6377, 6378, 6355, 0, 0, 0, 0
2077, 6355, 6378, 6379, 6356, 0, 0, 0, 0
2078, 6356, 6379, 6380, 6357, 0, 0, 0, 0
2079, 6357, 6380, 6381, 6358, 0, 0, 0, 0
2080, 6358, 6381, 6382, 6359, 0, 0, 0, 0
2081, 6359, 6382, 6383, 6360, 0, 0, 0, 0
2082, 6360, 6383, 6384, 6361, 0, 0, 0, 0
2083, 6361, 6384, 6385, 6362, 0, 0, 0, 0
2084, 6362, 6385, 6386, 6363, 0, 0, 0, 0
2085, 6363, 6386, 6387, 6364, 0, 0, 0, 0
2086, 6364, 6387, 6388, 6365, 0, 0, 0, 0
2087, 6365, 6388, 6389, 6366, 0, 0, 0, 0
2088, 6366, 6389, 6390, 6367, 0, 0, 0, 0
2089, 6367, 6390, 6391, 6368, 0, 0, 0, 0
2090, 6368, 6391, 6392, 6369, 0, 0, 0, 0
2091, 6369, 6392, 6393, 6370, 0, 0, 0, 0
2092, 6370, 6393, 769, 768, 0, 0, 0, 0
2093, 651, 652, 6394, 6371, 0, 0, 0, 0
2094, 6371, 6394, 6395, 6372, 0, 0, 0, 0
2095, 6372, 6395, 6396, 6373, 0, 0, 0, 0
2096, 6373, 6396, 6397, 6374, 0, 0, 0, 0
2097, 6374, 6397, 6398, 6375, 0, 0, 0, 0
2098, 6375, 6398, 6399, 6376, 0, 0, 0, 0
2099, 6376, 6399, 6400, 6377, 0, 0, 0, 0
2100, 6377, 6400, 6401, 6378, 0, 0, 0, 0
2101, 6378, 6401, 6402, 6379, 0, 0, 0, 0
2102, 6379, 6402, 6403, 6380, 0, 0, 0, 0
2103, 6380, 6403, 6404, 6381, 0, 0, 0, 0
2104, 6381, 6404, 6405, 6382, 0, 0, 0, 0
2105, 6382, 6405, 6406, 6383, 0, 0, 0, 0
2106, 6383, 6406, 6407, 6384, 0, 0, 0, 0
2107, 6384, 6407, 6408, 6385, 0, 0, 0, 0
2108, 6385, 6408, 6409, 6386, 0, 0, 0, 0
2109, 6386, 6409, 6410, 6387, 0, 0, 0, 0
2110, 6387, 6410, 6411, 6388, 0, 0, 0, 0
2111, 6388, 6411, 6412, 6389, 0, 0, 0, 0
2112, 6389, 6412, 6413, 6390, 0, 0, 0, 0
2113, 6390, 6413, 6414, 6391, 0, 0, 0, 0
2114, 6391, 6414, 6415, 6392, 0, 0, 0, 0
2115, 6392, 6415, 6416, 6393, 0, 0, 0, 0
2116, 6393, 6416, 770, 769, 0, 0, 0, 0
2117, 652, 653, 6417, 6394, 0, 0, 0, 0
2118, 6394, 6417, 6418, 6395, 0, 0, 0, 0
2119, 6395, 6418, 6419, 6396, 0, 0, 0, 0
2120, 6396, 6419, 6420, 6397, 0, 0, 0, 0
2121, 6397, 6420, 6421, 6398, 0, 0, 0, 0
2122, 6398, 6421, 6422, 6399, 0, 0, 0, 0
2123, 6399, 6422, 6423, 6400, 0, 0, 0, 0
2124, 6400, 6423, 6424, 6401, 0, 0, 0, 0
2125, 6401, 6424, 6425, 6402, 0, 0, 0, 0
2126, 6402, 6425, 6426, 6403, 0, 0, 0, 0
2127, 6403, 6426, 6427, 6404, 0, 0, 0, 0
2128, 6404, 6427, 6428, 6405, 0, 0, 0, 0
2129, 6405, 6428, 6429, 6406, 0, 0, 0, 0
2130, 6406, 6429, 6430, 6407, 0, 0, 0, 0
2131, 6407, 6430, 6431, 6408, 0, 0, 0, 0
2132, 6408, 6431, 6432, 6409, 0, 0, 0, 0
2133, 6409, 6432, 6433, 6410, 0, 0, 0, 0
2134, 6410, 6433, 6434, 6411, 0, 0, 0, 0
2135, 6411, 6434, 6435, 6412, 0, 0, 0, 0
2136, 6412, 6435, 6436, 6413, 0, 0, 0, 0
2137, 6413, 6436, 6437, 6414, 0, 0, 0, 0
2138, 6414, 6437, 6438, 6415, 0, 0, 0, 0
2139, 6415, 6438, 6439, 6416, 0, 0, 0, 0
2140, 6416, 6439, 771, 770, 0, 0, 0, 0
2141, 653, 654, 6440, 6417, 0, 0, 0, 0
2142, 6417, 6440, 6441, 6418, 0, 0, 0, 0
2143, 6418, 6441, 6442, 6419, 0, 0, 0, 0
2144, 6419, 6442, 6443, 6420, 0, 0, 0, 0
2145, 6420, 6443, 6444, 6421, 0, 0, 0, 0
2146, 6421, 6444, 6445, 6422, 0, 0, 0, 0
2147, 6422, 6445, 6446, 6423, 0, 0, 0, 0
2148, 6423, 6446, 6447, 6424, 0, 0, 0, 0
2149, 6424, 6447, 6448, 6425, 0, 0, 0, 0
2150, 6425, 6448, 6449, 6426, 0, 0, 0, 0
2151, 6426, 6449, 6450, 6427, 0, 0, 0, 0
2152, 6427, 6450, 6451, 6428, 0, 0, 0, 0
2153, 6428, 6451, 6452, 6429, 0, 0, 0, 0
2154, 6429, 6452, 6453, 6430, 0, 0, 0, 0
2155, 6430, 6453, 6454, 6431, 0, 0, 0, 0
2156, 6431, 6454, 6455, 6432, 0, 0, 0, 0
2157, 6432, 6455, 6456, 6433, 0, 0, 0, 0
2158, 6433, 6456, 6457, 6434, 0, 0, 0, 0
2159, 6434, 6457, 6458, 6435, 0, 0, 0, 0
2160, 6435, 6458, 6459, 6436, 0, 0, 0, 0
2161, 6436, 6459, 6460, 6437, 0, 0, 0, 0
2162, 6437, 6460, 6461, 6438, 0, 0, 0, 0
2163, 6438, 6461, 6462, 6439, 0, 0, 0, 0
2164, 6439, 6462, 772, 771, 0, 0, 0, 0
2165, 654, 655, 6463, 6440, 0, 0, 0, 0
2166, 6440, 6463, 6464, 6441, 0, 0, 0, 0
2167, 6441, 6464, 6465, 6442, 0, 0, 0, 0
2168, 6442, 6465, 6466, 6443, 0, 0, 0, 0
2169, 6443, 6466, 6467, 6444, 0, 0, 0, 0
2170, 6444, 6467, 6468, 6445, 0, 0, 0, 0
2171, 6445, 6468, 6469, 6446, 0, 0, 0, 0
2172, 6446, 6469, 6470, 6447, 0, 0, 0, 0
2173, 6447, 6470, 6471, 6448, 0, 0, 0, 0
2174, 6448, 6471, 6472, 6449, 0, 0, 0, 0
2175, 6449, 6472, 6473, 6450, 0, 0, 0, 0
2176, 6450, 6473, 6474, 6451, 0, 0, 0, 0
2177, 6451, 6474, 6475, 6452, 0, 0, 0, 0
2178, 6452, 6475, 6476, 6453, 0, 0, 0, 0
2179, 6453, 6476, 6477, 6454, 0, 0, 0, 0
2180, 6454, 6477, 6478, 6455, 0, 0, 0, 0
2181, 6455, 6478, 6479, 6456, 0, 0, 0, 0
2182, 6456, 6479, 6480, 6457, 0, 0, 0, 0
2183, 6457, 6480, 6481, 6458, 0, 0, 0, 0
2184, 6458, 6481, 6482, 6459, 0, 0, 0, 0
2185, 6459, 6482, 6483, 6460, 0, 0, 0, 0
2186, 6460, 6483, 6484, 6461, 0, 0, 0, 0
2187, 6461, 6484, 6485, 6462, 0, 0, 0, 0
2188, 6462, 6485, 773, 772, 0, 0, 0, 0
2189, 655, 26, 679, 6463, 0, 0, 0, 0
2190, 6463, 679, 680, 6464, 0, 0, 0, 0
2191, 6464, 680, 681, 6465, 0, 0, 0, 0
2192, 6465, 681, 682, 6466, 0, 0, 0, 0
2193, 6466, 682, 683, 6467, 0, 0, 0, 0
2194, 6467, 683, 684, 6468, 0, 0, 0, 0
2195, 6468, 684, 685, 6469, 0, 0, 0, 0
2196, 6469, 685, 686, 6470, 0, 0, 0, 0
2197, 6470, 686, 687, 6471, 0, 0, 0, 0
2198, 6471, 687, 688, 6472, 0, 0, 0, 0
2199, 6472, 688, 689, 6473, 0, 0, 0, 0
2200, 6473, 689, 690, 6474, 0, 0, 0, 0
2201, 6474, 690, 691, 6475, 0, 0, 0, 0
2202, 6475, 691, 692, 6476, 0, 0, 0, 0
2203, 6476, 692, 693, 6477, 0, 0, 0, 0
2204, 6477, 693, 694, 6478, 0, 0, 0, 0
2205, 6478, 694, 695, 6479, 0, 0, 0, 0
2206, 6479, 695, 696, 6480, 0, 0, 0, 0
2207, 6480, 696, 697, 6481, 0, 0, 0, 0
2208, 6481, 697, 698, 6482, 0, 0, 0, 0
2209, 6482, 698, 699, 6483, 0, 0, 0, 0
2210, 6483, 699, 700, 6484, 0, 0, 0, 0
2211, 6484, 700, 701, 6485, 0, 0, 0, 0
2212, 6485, 701, 30, 773, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface36
36890, 31, 750, 6486, 752, 0, 0, 0, 0
36891, 750, 751, 6487, 6486, 0, 0, 0, 0
36892, 751, 32, 763, 6487, 0, 0, 0, 0
36893, 752, 6486, 6488, 753, 0, 0, 0, 0
36894, 6486, 6487, 6489, 6488, 0, 0, 0, 0
36895, 6487, 763, 764, 6489, 0, 0, 0, 0
36896, 753, 6488, 6490, 754, 0, 0, 0, 0
36897, 6488, 6489, 6491, 6490, 0, 0, 0, 0
36898, 6489, 764, 765, 6491, 0, 0, 0, 0
36899, 754, 6490, 6492, 755, 0, 0, 0, 0
36900, 6490, 6491, 6493, 6492, 0, 0, 0, 0
36901, 6491, 765, 766, 6493, 0, 0, 0, 0
36902, 755, 6492, 6494, 756, 0, 0, 0, 0
36903, 6492, 6493, 6495, 6494, 0, 0, 0, 0
36904, 6493, 766, 767, 6495, 0, 0, 0, 0
36905, 756, 6494, 6496, 757, 0, 0, 0, 0
36906, 6494, 6495, 6497, 6496, 0, 0, 0, 0
36907, 6495, 767, 768, 6497, 0, 0, 0, 0
36908, 757, 6496, 6498, 758, 0, 0, 0, 0
36909, 6496, 6497, 6499, 6498, 0, 0, 0, 0
36910, 6497, 768, 769, 6499, 0, 0, 0, 0
36911, 758, 6498, 6500, 759, 0, 0, 0, 0
36912, 6498, 6499, 6501, 6500, 0, 0, 0, 0
36913, 6499, 769, 770, 6501, 0, 0, 0, 0
36914, 759, 6500, 6502, 760, 0, 0, 0, 0
36915, 6500, 6501, 6503, 6502, 0, 0, 0, 0
36916, 6501, 770, 771, 6503, 0, 0, 0, 0
36917, 760, 6502, 6504, 761, 0, 0, 0, 0
36918, 6502, 6503, 6505, 6504, 0, 0, 0, 0
36919, 6503, 771, 772, 6505, 0, 0, 0, 0
36920, 761, 6504, 6506, 762, 0, 0, 0, 0
36921, 6504, 6505, 6507, 6506, 0, 0, 0, 0
36922, 6505, 772, 773, 6507, 0, 0, 0, 0
36923, 762, 6506, 702, 29, 0, 0, 0, 0
36924, 6506, 6507, 703, 702, 0, 0, 0, 0
36925, 6507, 773, 30, 703, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface37
2213, 25, 33, 774, 656, 0, 0, 0, 0
2214, 656, 774, 775, 657, 0, 0, 0, 0
2215, 657, 775, 776, 658, 0, 0, 0, 0
2216, 658, 776, 777, 659, 0, 0, 0, 0
2217, 659, 777, 778, 660, 0, 0, 0, 0
2218, 660, 778, 779, 661, 0, 0, 0, 0
2219, 661, 779, 780, 662, 0, 0, 0, 0
2220, 662, 780, 781, 663, 0, 0, 0, 0
2221, 663, 781, 782, 664, 0, 0, 0, 0
2222, 664, 782, 783, 665, 0, 0, 0, 0
2223, 665, 783, 784, 666, 0, 0, 0, 0
2224, 666, 784, 785, 667, 0, 0, 0, 0
2225, 667, 785, 786, 668, 0, 0, 0, 0
2226, 668, 786, 787, 669, 0, 0, 0, 0
2227, 669, 787, 788, 670, 0, 0, 0, 0
2228, 670, 788, 789, 671, 0, 0, 0, 0
2229, 671, 789, 790, 672, 0, 0, 0, 0
2230, 672, 790, 791, 673, 0, 0, 0, 0
2231, 673, 791, 792, 674, 0, 0, 0, 0
2232, 674, 792, 793, 675, 0, 0, 0, 0
2233, 675, 793, 794, 676, 0, 0, 0, 0
2234, 676, 794, 795, 677, 0, 0, 0, 0
2235, 677, 795, 796, 678, 0, 0, 0, 0
2236, 678, 796, 34, 29, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface38
36926, 27, 704, 797, 35, 0, 0, 0, 0
36927, 704, 705, 798, 797, 0, 0, 0, 0
36928, 705, 706, 799, 798, 0, 0, 0, 0
36929, 706, 707, 800, 799, 0, 0, 0, 0
36930, 707, 708, 801, 800, 0, 0, 0, 0
36931, 708, 709, 802, 801, 0, 0, 0, 0
36932, 709, 710, 803, 802, 0, 0, 0, 0
36933, 710, 711, 804, 803, 0, 0, 0, 0
36934, 711, 712, 805, 804, 0, 0, 0, 0
36935, 712, 713, 806, 805, 0, 0, 0, 0
36936, 713, 714, 807, 806, 0, 0, 0, 0
36937, 714, 715, 808, 807, 0, 0, 0, 0
36938, 715, 716, 809, 808, 0, 0, 0, 0
36939, 716, 717, 810, 809, 0, 0, 0, 0
36940, 717, 718, 811, 810, 0, 0, 0, 0
36941, 718, 719, 812, 811, 0, 0, 0, 0
36942, 719, 720, 813, 812, 0, 0, 0, 0
36943, 720, 721, 814, 813, 0, 0, 0, 0
36944, 721, 722, 815, 814, 0, 0, 0, 0
36945, 722, 723, 816, 815, 0, 0, 0, 0
36946, 723, 724, 817, 816, 0, 0, 0, 0
36947, 724, 725, 818, 817, 0, 0, 0, 0
36948, 725, 726, 819, 818, 0, 0, 0, 0
36949, 726, 31, 36, 819, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface39
36950, 27, 35, 820, 634, 0, 0, 0, 0
36951, 634, 820, 821, 635, 0, 0, 0, 0
36952, 635, 821, 822, 636, 0, 0, 0, 0
36953, 636, 822, 823, 637, 0, 0, 0, 0
36954, 637, 823, 824, 638, 0, 0, 0, 0
36955, 638, 824, 825, 639, 0, 0, 0, 0
36956, 639, 825, 826, 640, 0, 0, 0, 0
36957, 640, 826, 827, 641, 0, 0, 0, 0
36958, 641, 827, 828, 642, 0, 0, 0, 0
36959, 642, 828, 829, 643, 0, 0, 0, 0
36960, 643, 829, 830, 644, 0, 0, 0, 0
36961, 644, 830, 33, 25, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface40
36962, 31, 752, 831, 36, 0, 0, 0, 0
36963, 752, 753, 832, 831, 0, 0, 0, 0
36964, 753, 754, 833, 832, 0, 0, 0, 0
36965, 754, 755, 834, 833, 0, 0, 0, 0
36966, 755, 756, 835, 834, 0, 0, 0, 0
36967, 756, 757, 836, 835, 0, 0, 0, 0
36968, 757, 758, 837, 836, 0, 0, 0, 0
36969, 758, 759, 838, 837, 0, 0, 0, 0
36970, 759, 760, 839, 838, 0, 0, 0, 0
36971, 760, 761, 840, 839, 0, 0, 0, 0
36972, 761, 762, 841, 840, 0, 0, 0, 0
36973, 762, 29, 34, 841, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface41
2237, 35, 797, 6508, 820, 0, 0, 0, 0
2238, 797, 798, 6509, 6508, 0, 0, 0, 0
2239, 798, 799, 6510, 6509, 0, 0, 0, 0
2240, 799, 800, 6511, 6510, 0, 0, 0, 0
2241, 800, 801, 6512, 6511, 0, 0, 0, 0
2242, 801, 802, 6513, 6512, 0, 0, 0, 0
2243, 802, 803, 6514, 6513, 0, 0, 0, 0
2244, 803, 804, 6515, 6514, 0, 0, 0, 0
2245, 804, 805, 6516, 6515, 0, 0, 0, 0
2246, 805, 806, 6517, 6516, 0, 0, 0, 0
2247, 806, 807, 6518, 6517, 0, 0, 0, 0
2248, 807, 808, 6519, 6518, 0, 0, 0, 0
2249, 808, 809, 6520, 6519, 0, 0, 0, 0
2250, 809, 810, 6521, 6520, 0, 0, 0, 0
2251, 810, 811, 6522, 6521, 0, 0, 0, 0
2252, 811, 812, 6523, 6522, 0, 0, 0, 0
2253, 812, 813, 6524, 6523, 0, 0, 0, 0
2254, 813, 814, 6525, 6524, 0, 0, 0, 0
2255, 814, 815, 6526, 6525, 0, 0, 0, 0
2256, 815, 816, 6527, 6526, 0, 0, 0, 0
2257, 816, 817, 6528, 6527, 0, 0, 0, 0
2258, 817, 818, 6529, 6528, 0, 0, 0, 0
2259, 818, 819, 6530, 6529, 0, 0, 0, 0
2260, 819, 36, 831, 6530, 0, 0, 0, 0
2261, 820, 6508, 6531, 821, 0, 0, 0, 0
2262, 6508, 6509, 6532, 6531, 0, 0, 0, 0
2263, 6509, 6510, 6533, 6532, 0, 0, 0, 0
2264, 6510, 6511, 6534, 6533, 0, 0, 0, 0
2265, 6511, 6512, 6535, 6534, 0, 0, 0, 0
2266, 6512, 6513, 6536, 6535, 0, 0, 0, 0
2267, 6513, 6514, 6537, 6536, 0, 0, 0, 0
2268, 6514, 6515, 6538, 6537, 0, 0, 0, 0
2269, 6515, 6516, 6539, 6538, 0, 0, 0, 0
2270, 6516, 6517, 6540, 6539, 0, 0, 0, 0
2271, 6517, 6518, 6541, 6540, 0, 0, 0, 0
2272, 6518, 6519, 6542, 6541, 0, 0, 0, 0
2273, 6519, 6520, 6543, 6542, 0, 0, 0, 0
2274, 6520, 6521, 6544, 6543, 0, 0, 0, 0
2275, 6521, 6522, 6545, 6544, 0, 0, 0, 0
2276, 6522, 6523, 6546, 6545, 0, 0, 0, 0
2277, 6523, 6524, 6547, 6546, 0, 0, 0, 0
2278, 6524, 6525, 6548, 6547, 0, 0, 0, 0
2279, 6525, 6526, 6549, 6548, 0, 0, 0, 0
2280, 6526, 6527, 6550, 6549, 0, 0, 0, 0
2281, 6527, 6528, 6551, 6550, 0, 0, 0, 0
2282, 6528, 6529, 6552, 6551, 0, 0, 0, 0
2283, 6529, 6530, 6553, 6552, 0, 0, 0, 0
2284, 6530, 831, 832, 6553, 0, 0, 0, 0
2285, 821, 6531, 6554, 822, 0, 0, 0, 0
2286, 6531, 6532, 6555, 6554, 0, 0, 0, 0
2287, 6532, 6533, 6556, 6555, 0, 0, 0, 0
2288, 6533, 6534, 6557, 6556, 0, 0, 0, 0
2289, 6534, 6535, 6558, 6557, 0, 0, 0, 0
2290, 6535, 6536, 6559, 6558, 0, 0, 0, 0
2291, 6536, 6537, 6560, 6559, 0, 0, 0, 0
2292, 6537, 6538, 6561, 6560, 0, 0, 0, 0
2293, 6538, 6539, 6562, 6561, 0, 0, 0, 0
2294, 6539, 6540, 6563, 6562, 0, 0, 0, 0
2295, 6540, 6541, 6564, 6563, 0, 0, 0, 0
2296, 6541, 6542, 6565, 6564, 0, 0, 0, 0
2297, 6542, 6543, 6566, 6565, 0, 0, 0, 0
2298, 6543, 6544, 6567, 6566, 0, 0, 0, 0
2299, 6544, 6545, 6568, 6567, 0, 0, 0, 0
2300, 6545, 6546, 6569, 6568, 0, 0, 0, 0
2301, 6546, 6547, 6570, 6569, 0, 0, 0, 0
2302, 6547, 6548, 6571, 6570, 0, 0, 0, 0
2303, 6548, 6549, 6572, 6571, 0, 0, 0, 0
2304, 6549, 6550, 6573, 6572, 0, 0, 0, 0
2305, 6550, 6551, 6574, 6573, 0, 0, 0, 0
2306, 6551, 6552, 6575, 6574, 0, 0, 0, 0
2307, 6552, 6553, 6576, 6575, 0, 0, 0, 0
2308, 6553, 832, 833, 6576, 0, 0, 0, 0
2309, 822, 6554, 6577, 823, 0, 0, 0, 0
2310, 6554, 6555, 6578, 6577, 0, 0, 0, 0
2311, 6555, 6556, 6579, 6578, 0, 0, 0, 0
2312, 6556, 6557, 6580, 6579, 0, 0, 0, 0
2313, 6557, 6558, 6581, 6580, 0, 0, 0, 0
2314, 6558, 6559, 6582, 6581, 0, 0, 0, 0
2315, 6559, 6560, 6583, 6582, 0, 0, 0, 0
2316, 6560, 6561, 6584, 6583, 0, 0, 0, 0
2317, 6561, 6562, 6585, 6584, 0, 0, 0, 0
2318, 6562, 6563, 6586, 6585, 0, 0, 0, 0
2319, 6563, 6564, 6587, 6586, 0, 0, 0, 0
2320, 6564, 6565, 6588, 6587, 0, 0, 0, 0
2321, 6565, 6566, 6589, 6588, 0, 0, 0, 0
2322, 6566, 6567, 6590, 6589, 0, 0, 0, 0
2323, 6567, 6568, 6591, 6590, 0, 0, 0, 0
2324, 6568, 6569, 6592, 6591, 0, 0, 0, 0
2325, 6569, 6570, 6593, 6592, 0, 0, 0, 0
2326, 6570, 6571, 6594, 6593, 0, 0, 0, 0
2327, 6571, 6572, 6595, 6594, 0, 0, 0, 0
2328, 6572, 6573, 6596, 6595, 0, 0, 0, 0
2329, 6573, 6574, 6597, 6596, 0, 0, 0, 0
2330, 6574, 6575, 6598, 6597, 0, 0, 0, 0
2331, 6575, 6576, 6599, 6598, 0, 0, 0, 0
2332, 6576, 833, 834, 6599, 0, 0, 0, 0
2333, 823, 6577, 6600, 824, 0, 0, 0, 0
2334, 6577, 6578, 6601, 6600, 0, 0, 0, 0
2335, 6578, 6579, 6602, 6601, 0, 0, 0, 0
2336, 6579, 6580, 6603, 6602, 0, 0, 0, 0
2337, 6580, 6581, 6604, 6603, 0, 0, 0, 0
2338, 6581, 6582, 6605, 6604, 0, 0, 0, 0
2339, 6582, 6583, 6606, 6605, 0, 0, 0, 0
2340, 6583, 6584, 6607, 6606, 0, 0, 0, 0
2341, 6584, 6585, 6608, 6607, 0, 0, 0, 0
2342, 6585, 6586, 6609, 6608, 0, 0, 0, 0
2343, 6586, 6587, 6610, 6609, 0, 0, 0, 0
2344, 6587, 6588, 6611, 6610, 0, 0, 0, 0
2345, 6588, 6589, 6612, 6611, 0, 0, 0, 0
2346, 6589, 6590, 6613, 6612, 0, 0, 0, 0
2347, 6590, 6591, 6614, 6613, 0, 0, 0, 0
2348, 6591, 6592, 6615, 6614, 0, 0, 0, 0
2349, 6592, 6593, 6616, 6615, 0, 0, 0, 0
2350, 6593, 6594, 6617, 6616, 0, 0, 0, 0
2351, 6594, 6595, 6618, 6617, 0, 0, 0, 0
2352, 6595, 6596, 6619, 6618, 0, 0, 0, 0
2353, 6596, 6597, 6620, 6619, 0, 0, 0, 0
2354, 6597, 6598, 6621, 6620, 0, 0, 0, 0
2355, 6598, 6599, 6622, 6621, 0, 0, 0, 0
2356, 6599, 834, 835, 6622, 0, 0, 0, 0
2357, 824, 6600, 6623, 825, 0, 0, 0, 0
2358, 6600, 6601, 6624, 6623, 0, 0, 0, 0
2359, 6601, 6602, 6625, 6624, 0, 0, 0, 0
2360, 6602, 6603, 6626, 6625, 0, 0, 0, 0
2361, 6603, 6604, 6627, 6626, 0, 0, 0, 0
2362, 6604, 6605, 6628, 6627, 0, 0, 0, 0
2363, 6605, 6606, 6629, 6628, 0, 0, 0, 0
2364, 6606, 6607, 6630, 6629, 0, 0, 0, 0
2365, 6607, 6608, 6631, 6630, 0, 0, 0, 0
2366, 6608, 6609, 6632, 6631, 0, 0, 0, 0
2367, 6609, 6610, 6633, 6632, 0, 0, 0, 0
2368, 6610, 6611, 6634, 6633, 0, 0, 0, 0
2369, 6611, 6612, 6635, 6634, 0, 0, 0, 0
2370, 6612, 6613, 6636, 6635, 0, 0, 0, 0
2371, 6613, 6614, 6637, 6636, 0, 0, 0, 0
2372, 6614, 6615, 6638, 6637, 0, 0, 0, 0
2373, 6615, 6616, 6639, 6638, 0, 0, 0, 0
2374, 6616, 6617, 6640, 6639, 0, 0, 0, 0
2375, 6617, 6618, 6641, 6640, 0, 0, 0, 0
2376, 6618, 6619, 6642, 6641, 0, 0, 0, 0
2377, 6619, 6620, 6643, 6642, 0, 0, 0, 0
2378, 6620, 6621, 6644, 6643, 0, 0, 0, 0
2379, 6621, 6622, 6645, 6644, 0, 0, 0, 0
2380, 6622, 835, 836, 6645, 0, 0, 0, 0
2381, 825, 6623, 6646, 826, 0, 0, 0, 0
2382, 6623, 6624, 6647, 6646, 0, 0, 0, 0
2383, 6624, 6625, 6648, 6647, 0, 0, 0, 0
2384, 6625, 6626, 6649, 6648, 0, 0, 0, 0
2385, 6626, 6627, 6650, 6649, 0, 0, 0, 0
2386, 6627, 6628, 6651, 6650, 0, 0, 0, 0
2387, 6628, 6629, 6652, 6651, 0, 0, 0, 0
2388, 6629, 6630, 6653, 6652, 0, 0, 0, 0
2389, 6630, 6631, 6654, 6653, 0, 0, 0, 0
2390, 6631, 6632, 6655, 6654, 0, 0, 0, 0
2391, 6632, 6633, 6656, 6655, 0, 0, 0, 0
2392, 6633, 6634, 6657, 6656, 0, 0, 0, 0
2393, 6634, 6635, 6658, 6657, 0, 0, 0, 0
2394, 6635, 6636, 6659, 6658, 0, 0, 0, 0
2395, 6636, 6637, 6660, 6659, 0, 0, 0, 0
2396, 6637, 6638, 6661, 6660, 0, 0, 0, 0
2397, 6638, 6639, 6662, 6661, 0, 0, 0, 0
2398, 6639, 6640, 6663, 6662, 0, 0, 0, 0
2399, 6640, 6641, 6664, 6663, 0, 0, 0, 0
2400, 6641, 6642, 6665, 6664, 0, 0, 0, 0
2401, 6642, 6643, 6666, 6665, 0, 0, 0, 0
2402, 6643, 6644, 6667, 6666, 0, 0, 0, 0
2403, 6644, 6645, 6668, 6667, 0, 0, 0, 0
2404, 6645, 836, 837, 6668, 0, 0, 0, 0
2405, 826, 6646, 6669, 827, 0, 0, 0, 0
2406, 6646, 6647, 6670, 6669, 0, 0, 0, 0
2407, 6647, 6648, 6671, 6670, 0, 0, 0, 0
2408, 6648, 6649, 6672, 6671, 0, 0, 0, 0
2409, 6649, 6650, 6673, 6672, 0, 0, 0, 0
2410, 6650, 6651, 6674, 6673, 0, 0, 0, 0
2411, 6651, 6652, 6675, 6674, 0, 0, 0, 0
2412, 6652, 6653, 6676, 6675, 0, 0, 0, 0
2413, 6653, 6654, 6677, 6676, 0, 0, 0, 0
2414, 6654, 6655, 6678, 6677, 0, 0, 0, 0
2415, 6655, 6656, 6679, 6678, 0, 0, 0, 0
2416, 6656, 6657, 6680, 6679, 0, 0, 0, 0
2417, 6657, 6658, 6681, 6680, 0, 0, 0, 0
2418, 6658, 6659, 6682, 6681, 0, 0, 0, 0
2419, 6659, 6660, 6683, 6682, 0, 0, 0, 0
2420, 6660, 6661, 6684, 6683, 0, 0, 0, 0
2421, 6661, 6662, 6685, 6684, 0, 0, 0, 0
2422, 6662, 6663, 6686, 6685, 0, 0, 0, 0
2423, 6663, 6664, 6687, 6686, 0, 0, 0, 0
2424, 6664, 6665, 6688, 6687, 0, 0, 0, 0
2425, 6665, 6666, 6689, 6688, 0, 0, 0, 0
2426, 6666, 6667, 6690, 6689, 0, 0, 0, 0
2427, 6667, 6668, 6691, 6690, 0, 0, 0, 0
2428, 6668, 837, 838, 6691, 0, 0, 0, 0
2429, 827, 6669, 6692, 828, 0, 0, 0, 0
2430, 6669, 6670, 6693, 6692, 0, 0, 0, 0
2431, 6670, 6671, 6694, 6693, 0, 0, 0, 0
2432, 6671, 6672, 6695, 6694, 0, 0, 0, 0
2433, 6672, 6673, 6696, 6695, 0, 0, 0, 0
2434, 6673, 6674, 6697, 6696, 0, 0, 0, 0
2435, 6674, 6675, 6698, 6697, 0, 0, 0, 0
2436, 6675, 6676, 6699, 6698, 0, 0, 0, 0
2437, 6676, 6677, 6700, 6699, 0, 0, 0, 0
2438, 6677, 6678, 6701, 6700, 0, 0, 0, 0
2439, 6678, 6679, 6702, 6701, 0, 0, 0, 0
2440, 6679, 6680, 6703, 6702, 0, 0, 0, 0
2441, 6680, 6681, 6704, 6703, 0, 0, 0, 0
2442, 6681, 6682, 6705, 6704, 0, 0, 0, 0
2443, 6682, 6683, 6706, 6705, 0, 0, 0, 0
2444, 6683, 6684, 6707, 6706, 0, 0, 0, 0
2445, 6684, 6685, 6708, 6707, 0, 0, 0, 0
2446, 6685, 6686, 6709, 6708, 0, 0, 0, 0
2447, 6686, 6687, 6710, 6709, 0, 0, 0, 0
2448, 6687, 6688, 6711, 6710, 0, 0, 0, 0
2449, 6688, 6689, 6712, 6711, 0, 0, 0, 0
2450, 6689, 6690, 6713, 6712, 0, 0, 0, 0
2451, 6690, 6691, 6714, 6713, 0, 0, 0, 0
2452, 6691, 838, 839, 6714, 0, 0, 0, 0
2453, 828, 6692, 6715, 829, 0, 0, 0, 0
2454, 6692, 6693, 6716, 6715, 0, 0, 0, 0
2455, 6693, 6694, 6717, 6716, 0, 0, 0, 0
2456, 6694, 6695, 6718, 6717, 0, 0, 0, 0
2457, 6695, 6696, 6719, 6718, 0, 0, 0, 0
2458, 6696, 6697, 6720, 6719, 0, 0, 0, 0
2459, 6697, 6698, 6721, 6720, 0, 0, 0, 0
2460, 6698, 6699, 6722, 6721, 0, 0, 0, 0
2461, 6699, 6700, 6723, 6722, 0, 0, 0, 0
2462, 6700, 6701, 6724, 6723, 0, 0, 0, 0
2463, 6701, 6702, 6725, 6724, 0, 0, 0, 0
2464, 6702, 6703, 6726, 6725, 0, 0, 0, 0
2465, 6703, 6704, 6727, 6726, 0, 0, 0, 0
2466, 6704, 6705, 6728, 6727, 0, 0, 0, 0
2467, 6705, 6706, 6729, 6728, 0, 0, 0, 0
2468, 6706, 6707, 6730, 6729, 0, 0, 0, 0
2469, 6707, 6708, 6731, 6730, 0, 0, 0, 0
2470, 6708, 6709, 6732, 6731, 0, 0, 0, 0
2471, 6709, 6710, 6733, 6732, 0, 0, 0, 0
2472, 6710, 6711, 6734, 6733, 0, 0, 0, 0
2473, 6711, 6712, 6735, 6734, 0, 0, 0, 0
2474, 6712, 6713, 6736, 6735, 0, 0, 0, 0
2475, 6713, 6714, 6737, 6736, 0, 0, 0, 0
2476, 6714, 839, 840, 6737, 0, 0, 0, 0
2477, 829, 6715, 6738, 830, 0, 0, 0, 0
2478, 6715, 6716, 6739, 6738, 0, 0, 0, 0
2479, 6716, 6717, 6740, 6739, 0, 0, 0, 0
2480, 6717, 6718, 6741, 6740, 0, 0, 0, 0
2481, 6718, 6719, 6742, 6741, 0, 0, 0, 0
2482, 6719, 6720, 6743, 6742, 0, 0, 0, 0
2483, 6720, 6721, 6744, 6743, 0, 0, 0, 0
2484, 6721, 6722, 6745, 6744, 0, 0, 0, 0
2485, 6722, 6723, 6746, 6745, 0, 0, 0, 0
2486, 6723, 6724, 6747, 6746, 0, 0, 0, 0
2487, 6724, 6725, 6748, 6747, 0, 0, 0, 0
2488, 6725, 6726, 6749, 6748, 0, 0, 0, 0
2489, 6726, 6727, 6750, 6749, 0, 0, 0, 0
2490, 6727, 6728, 6751, 6750, 0, 0, 0, 0
2491, 6728, 6729, 6752, 6751, 0, 0, 0, 0
2492, 6729, 6730, 6753, 6752, 0, 0, 0, 0
2493, 6730, 6731, 6754, 6753, 0, 0, 0, 0
2494, 6731, 6732, 6755, 6754, 0, 0, 0, 0
2495, 6732, 6733, 6756, 6755, 0, 0, 0, 0
2496, 6733, 6734, 6757, 6756, 0, 0, 0, 0
2497, 6734, 6735, 6758, 6757, 0, 0, 0, 0
2498, 6735, 6736, 6759, 6758, 0, 0, 0, 0
2499, 6736, 6737, 6760, 6759, 0, 0, 0, 0
2500, 6737, 840, 841, 6760, 0, 0, 0, 0
2501, 830, 6738, 774, 33, 0, 0, 0, 0
2502, 6738, 6739, 775, 774, 0, 0, 0, 0
2503, 6739, 6740, 776, 775, 0, 0, 0, 0
2504, 6740, 6741, 777, 776, 0, 0, 0, 0
2505, 6741, 6742, 778, 777, 0, 0, 0, 0
2506, 6742, 6743, 779, 778, 0, 0, 0, 0
2507, 6743, 6744, 780, 779, 0, 0, 0, 0
2508, 6744, 6745, 781, 780, 0, 0, 0, 0
2509, 6745, 6746, 782, 781, 0, 0, 0, 0
2510, 6746, 6747, 783, 782, 0, 0, 0, 0
2511, 6747, 6748, 784, 783, 0, 0, 0, 0
2512, 6748, 6749, 785, 784, 0, 0, 0, 0
2513, 6749, 6750, 786, 785, 0, 0, 0, 0
2514, 6750, 6751, 787, 786, 0, 0, 0, 0
2515, 6751, 6752, 788, 787, 0, 0, 0, 0
2516, 6752, 6753, 789, 788, 0, 0, 0, 0
2517, 6753, 6754, 790, 789, 0, 0, 0, 0
2518, 6754, 6755, 791, 790, 0, 0, 0, 0
2519, 6755, 6756, 792, 791, 0, 0, 0, 0
2520, 6756, 6757, 793, 792, 0, 0, 0, 0
2521, 6757, 6758, 794, 793, 0, 0, 0, 0
2522, 6758, 6759, 795, 794, 0, 0, 0, 0
2523, 6759, 6760, 796, 795, 0, 0, 0, 0
2524, 6760, 841, 34, 796, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface42
2525, 33, 842, 6761, 774, 0, 0, 0, 0
2526, 842, 843, 6762, 6761, 0, 0, 0, 0
2527, 843, 844, 6763, 6762, 0, 0, 0, 0
2528, 844, 845, 6764, 6763, 0, 0, 0, 0
2529, 845, 846, 6765, 6764, 0, 0, 0, 0
2530, 846, 847, 6766, 6765, 0, 0, 0, 0
2531, 847, 848, 6767, 6766, 0, 0, 0, 0
2532, 848, 849, 6768, 6767, 0, 0, 0, 0
2533, 849, 850, 6769, 6768, 0, 0, 0, 0
2534, 850, 851, 6770, 6769, 0, 0, 0, 0
2535, 851, 852, 6771, 6770, 0, 0, 0, 0
2536, 852, 853, 6772, 6771, 0, 0, 0, 0
2537, 853, 854, 6773, 6772, 0, 0, 0, 0
2538, 854, 855, 6774, 6773, 0, 0, 0, 0
2539, 855, 856, 6775, 6774, 0, 0, 0, 0
2540, 856, 857, 6776, 6775, 0, 0, 0, 0
2541, 857, 858, 6777, 6776, 0, 0, 0, 0
2542, 858, 859, 6778, 6777, 0, 0, 0, 0
2543, 859, 860, 6779, 6778, 0, 0, 0, 0
2544, 860, 861, 6780, 6779, 0, 0, 0, 0
2545, 861, 862, 6781, 6780, 0, 0, 0, 0
2546, 862, 863, 6782, 6781, 0, 0, 0, 0
2547, 863, 864, 6783, 6782, 0, 0, 0, 0
2548, 864, 37, 888, 6783, 0, 0, 0, 0
2549, 774, 6761, 6784, 775, 0, 0, 0, 0
2550, 6761, 6762, 6785, 6784, 0, 0, 0, 0
2551, 6762, 6763, 6786, 6785, 0, 0, 0, 0
2552, 6763, 6764, 6787, 6786, 0, 0, 0, 0
2553, 6764, 6765, 6788, 6787, 0, 0, 0, 0
2554, 6765, 6766, 6789, 6788, 0, 0, 0, 0
2555, 6766, 6767, 6790, 6789, 0, 0, 0, 0
2556, 6767, 6768, 6791, 6790, 0, 0, 0, 0
2557, 6768, 6769, 6792, 6791, 0, 0, 0, 0
2558, 6769, 6770, 6793, 6792, 0, 0, 0, 0
2559, 6770, 6771, 6794, 6793, 0, 0, 0, 0
2560, 6771, 6772, 6795, 6794, 0, 0, 0, 0
2561, 6772, 6773, 6796, 6795, 0, 0, 0, 0
2562, 6773, 6774, 6797, 6796, 0, 0, 0, 0
2563, 6774, 6775, 6798, 6797, 0, 0, 0, 0
2564, 6775, 6776, 6799, 6798, 0, 0, 0, 0
2565, 6776, 6777, 6800, 6799, 0, 0, 0, 0
2566, 6777, 6778, 6801, 6800, 0, 0, 0, 0
2567, 6778, 6779, 6802, 6801, 0, 0, 0, 0
2568, 6779, 6780, 6803, 6802, 0, 0, 0, 0
2569, 6780, 6781, 6804, 6803, 0, 0, 0, 0
2570, 6781, 6782, 6805, 6804, 0, 0, 0, 0
2571, 6782, 6783, 6806, 6805, 0, 0, 0, 0
2572, 6783, 888, 889, 6806, 0, 0, 0, 0
2573, 775, 6784, 6807, 776, 0, 0, 0, 0
2574, 6784, 6785, 6808, 6807, 0, 0, 0, 0
2575, 6785, 6786, 6809, 6808, 0, 0, 0, 0
2576, 6786, 6787, 6810, 6809, 0, 0, 0, 0
2577, 6787, 6788, 6811, 6810, 0, 0, 0, 0
2578, 6788, 6789, 6812, 6811, 0, 0, 0, 0
2579, 6789, 6790, 6813, 6812, 0, 0, 0, 0
2580, 6790, 6791, 6814, 6813, 0, 0, 0, 0
2581, 6791, 6792, 6815, 6814, 0, 0, 0, 0
2582, 6792, 6793, 6816, 6815, 0, 0, 0, 0
2583, 6793, 6794, 6817, 6816, 0, 0, 0, 0
2584, 6794, 6795, 6818, 6817, 0, 0, 0, 0
2585, 6795, 6796, 6819, 6818, 0, 0, 0, 0
2586, 6796, 6797, 6820, 6819, 0, 0, 0, 0
2587, 6797, 6798, 6821, 6820, 0, 0, 0, 0
2588, 6798, 6799, 6822, 6821, 0, 0, 0, 0
2589, 6799, 6800, 6823, 6822, 0, 0, 0, 0
2590, 6800, 6801, 6824, 6823, 0, 0, 0, 0
2591, 6801, 6802, 6825, 6824, 0, 0, 0, 0
2592, 6802, 6803, 6826, 6825, 0, 0, 0, 0
2593, 6803, 6804, 6827, 6826, 0, 0, 0, 0
2594, 6804, 6805, 6828, 6827, 0, 0, 0, 0
2595, 6805, 6806, 6829, 6828, 0, 0, 0, 0
2596, 6806, 889, 890, 6829, 0, 0, 0, 0
2597, 776, 6807, 6830, 777, 0, 0, 0, 0
2598, 6807, 6808, 6831, 6830, 0, 0, 0, 0
2599, 6808, 6809, 6832, 6831, 0, 0, 0, 0
2600, 6809, 6810, 6833, 6832, 0, 0, 0, 0
2601, 6810, 6811, 6834, 6833, 0, 0, 0, 0
2602, 6811, 6812, 6835, 6834, 0, 0, 0, 0
2603, 6812, 6813, 6836, 6835, 0, 0, 0, 0
2604, 6813, 6814, 6837, 6836, 0, 0, 0, 0
2605, 6814, 6815, 6838, 6837, 0, 0, 0, 0
2606, 6815, 6816, 6839, 6838, 0, 0, 0, 0
2607, 6816, 6817, 6840, 6839, 0, 0, 0, 0
2608, 6817, 6818, 6841, 6840, 0, 0, 0, 0
2609, 6818, 6819, 6842, 6841, 0, 0, 0, 0
2610, 6819, 6820, 6843, 6842, 0, 0, 0, 0
2611, 6820, 6821, 6844, 6843, 0, 0, 0, 0
2612, 6821, 6822, 6845, 6844, 0, 0, 0, 0
2613, 6822, 6823, 6846, 6845, 0, 0, 0, 0
2614, 6823, 6824, 6847, 6846, 0, 0, 0, 0
2615, 6824, 6825, 6848, 6847, 0, 0, 0, 0
2616, 6825, 6826, 6849, 6848, 0, 0, 0, 0
2617, 6826, 6827, 6850, 6849, 0, 0, 0, 0
2618, 6827, 6828, 6851, 6850, 0, 0, 0, 0
2619, 6828, 6829, 6852, 6851, 0, 0, 0, 0
2620, 6829, 890, 891, 6852, 0, 0, 0, 0
2621, 777, 6830, 6853, 778, 0, 0, 0, 0
2622, 6830, 6831, 6854, 6853, 0, 0, 0, 0
2623, 6831, 6832, 6855, 6854, 0, 0, 0, 0
2624, 6832, 6833, 6856, 6855, 0, 0, 0, 0
2625, 6833, 6834, 6857, 6856, 0, 0, 0, 0
2626, 6834, 6835, 6858, 6857, 0, 0, 0, 0
2627, 6835, 6836, 6859, 6858, 0, 0, 0, 0
2628, 6836, 6837, 6860, 6859, 0, 0, 0, 0
2629, 6837, 6838, 6861, 6860, 0, 0, 0, 0
2630, 6838, 6839, 6862, 6861, 0, 0, 0, 0
2631, 6839, 6840, 6863, 6862, 0, 0, 0, 0
2632, 6840, 6841, 6864, 6863, 0, 0, 0, 0
2633, 6841, 6842, 6865, 6864, 0, 0, 0, 0
2634, 6842, 6843, 6866, 6865, 0, 0, 0, 0
2635, 6843, 6844, 6867, 6866, 0, 0, 0, 0
2636, 6844, 6845, 6868, 6867, 0, 0, 0, 0
2637, 6845, 6846, 6869, 6868, 0, 0, 0, 0
2638, 6846, 6847, 6870, 6869, 0, 0, 0, 0
2639, 6847, 6848, 6871, 6870, 0, 0, 0, 0
2640, 6848, 6849, 6872, 6871, 0, 0, 0, 0
2641, 6849, 6850, 6873, 6872, 0, 0, 0, 0
2642, 6850, 6851, 6874, 6873, 0, 0, 0, 0
2643, 6851, 6852, 6875, 6874, 0, 0, 0, 0
2644, 6852, 891, 892, 6875, 0, 0, 0, 0
2645, 778, 6853, 6876, 779, 0, 0, 0, 0
2646, 6853, 6854, 6877, 6876, 0, 0, 0, 0
2647, 6854, 6855, 6878, 6877, 0, 0, 0, 0
2648, 6855, 6856, 6879, 6878, 0, 0, 0, 0
2649, 6856, 6857, 6880, 6879, 0, 0, 0, 0
2650, 6857, 6858, 6881, 6880, 0, 0, 0, 0
2651, 6858, 6859, 6882, 6881, 0, 0, 0, 0
2652, 6859, 6860, 6883, 6882, 0, 0, 0, 0
2653, 6860, 6861, 6884, 6883, 0, 0, 0, 0
2654, 6861, 6862, 6885, 6884, 0, 0, 0, 0
2655, 6862, 6863, 6886, 6885, 0, 0, 0, 0
2656, 6863, 6864, 6887, 6886, 0, 0, 0, 0
2657, 6864, 6865, 6888, 6887, 0, 0, 0, 0
2658, 6865, 6866, 6889, 6888, 0, 0, 0, 0
2659, 6866, 6867, 6890, 6889, 0, 0, 0, 0
2660, 6867, 6868, 6891, 6890, 0, 0, 0, 0
2661, 6868, 6869, 6892, 6891, 0, 0, 0, 0
2662, 6869, 6870, 6893, 6892, 0, 0, 0, 0
2663, 6870, 6871, 6894, 6893, 0, 0, 0, 0
2664, 6871, 6872, 6895, 6894, 0, 0, 0, 0
2665, 6872, 6873, 6896, 6895, 0, 0, 0, 0
2666, 6873, 6874, 6897, 6896, 0, 0, 0, 0
2667, 6874, 6875, 6898, 6897, 0, 0, 0, 0
2668, 6875, 892, 893, 6898, 0, 0, 0, 0
2669, 779, 6876, 6899, 780, 0, 0, 0, 0
2670, 6876, 6877, 6900, 6899, 0, 0, 0, 0
2671, 6877, 6878, 6901, 6900, 0, 0, 0, 0
2672, 6878, 6879, 6902, 6901, 0, 0, 0, 0
2673, 6879, 6880, 6903, 6902, 0, 0, 0, 0
2674, 6880, 6881, 6904, 6903, 0, 0, 0, 0
2675, 6881, 6882, 6905, 6904, 0, 0, 0, 0
2676, 6882, 6883, 6906, 6905, 0, 0, 0, 0
2677, 6883, 6884, 6907, 6906, 0, 0, 0, 0
2678, 6884, 6885, 6908, 6907, 0, 0, 0, 0
2679, 6885, 6886, 6909, 6908, 0, 0, 0, 0
2680, 6886, 6887, 6910, 6909, 0, 0, 0, 0
2681, 6887, 6888, 6911, 6910, 0, 0, 0, 0
2682, 6888, 6889, 6912, 6911, 0, 0, 0, 0
2683, 6889, 6890, 6913, 6912, 0, 0, 0, 0
2684, 6890, 6891, 6914, 6913, 0, 0, 0, 0
2685, 6891, 6892, 6915, 6914, 0, 0, 0, 0
2686, 6892, 6893, 6916, 6915, 0, 0, 0, 0
2687, 6893, 6894, 6917, 6916, 0, 0, 0, 0
2688, 6894, 6895, 6918, 6917, 0, 0, 0, 0
2689, 6895, 6896, 6919, 6918, 0, 0, 0, 0
2690, 6896, 6897, 6920, 6919, 0, 0, 0, 0
2691, 6897, 6898, 6921, 6920, 0, 0, 0, 0
2692, 6898, 893, 894, 6921, 0, 0, 0, 0
2693, 780, 6899, 6922, 781, 0, 0, 0, 0
2694, 6899, 6900, 6923, 6922, 0, 0, 0, 0
2695, 6900, 6901, 6924, 6923, 0, 0, 0, 0
2696, 6901, 6902, 6925, 6924, 0, 0, 0, 0
2697, 6902, 6903, 6926, 6925, 0, 0, 0, 0
2698, 6903, 6904, 6927, 6926, 0, 0, 0, 0
2699, 6904, 6905, 6928, 6927, 0, 0, 0, 0
2700, 6905, 6906, 6929, 6928, 0, 0, 0, 0
2701, 6906, 6907, 6930, 6929, 0, 0, 0, 0
2702, 6907, 6908, 6931, 6930, 0, 0, 0, 0
2703, 6908, 6909, 6932, 6931, 0, 0, 0, 0
2704, 6909, 6910, 6933, 6932, 0, 0, 0, 0
2705, 6910, 6911, 6934, 6933, 0, 0, 0, 0
2706, 6911, 6912, 6935, 6934, 0, 0, 0, 0
2707, 6912, 6913, 6936, 6935, 0, 0, 0, 0
2708, 6913, 6914, 6937, 6936, 0, 0, 0, 0
2709, 6914, 6915, 6938, 6937, 0, 0, 0, 0
2710, 6915, 6916, 6939, 6938, 0, 0, 0, 0
2711, 6916, 6917, 6940, 6939, 0, 0, 0, 0
2712, 6917, 6918, 6941, 6940, 0, 0, 0, 0
2713, 6918, 6919, 6942, 6941, 0, 0, 0, 0
2714, 6919, 6920, 6943, 6942, 0, 0, 0, 0
2715, 6920, 6921, 6944, 6943, 0, 0, 0, 0
2716, 6921, 894, 895, 6944, 0, 0, 0, 0
2717, 781, 6922, 6945, 782, 0, 0, 0, 0
2718, 6922, 6923, 6946, 6945, 0, 0, 0, 0
2719, 6923, 6924, 6947, 6946, 0, 0, 0, 0
2720, 6924, 6925, 6948, 6947, 0, 0, 0, 0
2721, 6925, 6926, 6949, 6948, 0, 0, 0, 0
2722, 6926, 6927, 6950, 6949, 0, 0, 0, 0
2723, 6927, 6928, 6951, 6950, 0, 0, 0, 0
2724, 6928, 6929, 6952, 6951, 0, 0, 0, 0
2725, 6929, 6930, 6953, 6952, 0, 0, 0, 0
2726, 6930, 6931, 6954, 6953, 0, 0, 0, 0
2727, 6931, 6932, 6955, 6954, 0, 0, 0, 0
2728, 6932, 6933, 6956, 6955, 0, 0, 0, 0
2729, 6933, 6934, 6957, 6956, 0, 0, 0, 0
2730, 6934, 6935, 6958, 6957, 0, 0, 0, 0
2731, 6935, 6936, 6959, 6958, 0, 0, 0, 0
2732, 6936, 6937, 6960, 6959, 0, 0, 0, 0
2733, 6937, 6938, 6961, 6960, 0, 0, 0, 0
2734, 6938, 6939, 6962, 6961, 0, 0, 0, 0
2735, 6939, 6940, 6963, 6962, 0, 0, 0, 0
2736, 6940, 6941, 6964, 6963, 0, 0, 0, 0
2737, 6941, 6942, 6965, 6964, 0, 0, 0, 0
2738, 6942, 6943, 6966, 6965, 0, 0, 0, 0
2739, 6943, 6944, 6967, 6966, 0, 0, 0, 0
2740, 6944, 895, 896, 6967, 0, 0, 0, 0
2741, 782, 6945, 6968, 783, 0, 0, 0, 0
2742, 6945, 6946, 6969, 6968, 0, 0, 0, 0
2743, 6946, 6947, 6970, 6969, 0, 0, 0, 0
2744, 6947, 6948, 6971, 6970, 0, 0, 0, 0
2745, 6948, 6949, 6972, 6971, 0, 0, 0, 0
2746, 6949, 6950, 6973, 6972, 0, 0, 0, 0
2747, 6950, 6951, 6974, 6973, 0, 0, 0, 0
2748, 6951, 6952, 6975, 6974, 0, 0, 0, 0
2749, 6952, 6953, 6976, 6975, 0, 0, 0, 0
2750, 6953, 6954, 6977, 6976, 0, 0, 0, 0
2751, 6954, 6955, 6978, 6977, 0, 0, 0, 0
2752, 6955, 6956, 6979, 6978, 0, 0, 0, 0
2753, 6956, 6957, 6980, 6979, 0, 0, 0, 0
2754, 6957, 6958, 6981, 6980, 0, 0, 0, 0
2755, 6958, 6959, 6982, 6981, 0, 0, 0, 0
2756, 6959, 6960, 6983, 6982, 0, 0, 0, 0
2757, 6960, 6961, 6984, 6983, 0, 0, 0, 0
2758, 6961, 6962, 6985, 6984, 0, 0, 0, 0
2759, 6962, 6963, 6986, 6985, 0, 0, 0, 0
2760, 6963, 6964, 6987, 6986, 0, 0, 0, 0
2761, 6964, 6965, 6988, 6987, 0, 0, 0, 0
2762, 6965, 6966, 6989, 6988, 0, 0, 0, 0
2763, 6966, 6967, 6990, 6989, 0, 0, 0, 0
2764, 6967, 896, 897, 6990, 0, 0, 0, 0
2765, 783, 6968, 6991, 784, 0, 0, 0, 0
2766, 6968, 6969, 6992, 6991, 0, 0, 0, 0
2767, 6969, 6970, 6993, 6992, 0, 0, 0, 0
2768, 6970, 6971, 6994, 6993, 0, 0, 0, 0
2769, 6971, 6972, 6995, 6994, 0, 0, 0, 0
2770, 6972, 6973, 6996, 6995, 0, 0, 0, 0
2771, 6973, 6974, 6997, 6996, 0, 0, 0, 0
2772, 6974, 6975, 6998, 6997, 0, 0, 0, 0
2773, 6975, 6976, 6999, 6998, 0, 0, 0, 0
2774, 6976, 6977, 7000, 6999, 0, 0, 0, 0
2775, 6977, 6978, 7001, 7000, 0, 0, 0, 0
2776, 6978, 6979, 7002, 7001, 0, 0, 0, 0
2777, 6979, 6980, 7003, 7002, 0, 0, 0, 0
2778, 6980, 6981, 7004, 7003, 0, 0, 0, 0
2779, 6981, 6982, 7005, 7004, 0, 0, 0, 0
2780, 6982, 6983, 7006, 7005, 0, 0, 0, 0
2781, 6983, 6984, 7007, 7006, 0, 0, 0, 0
2782, 6984, 6985, 7008, 7007, 0, 0, 0, 0
2783, 6985, 6986, 7009, 7008, 0, 0, 0, 0
2784, 6986, 6987, 7010, 7009, 0, 0, 0, 0
2785, 6987, 6988, 7011, 7010, 0, 0, 0, 0
2786, 6988, 6989, 7012, 7011, 0, 0, 0, 0
2787, 6989, 6990, 7013, 7012, 0, 0, 0, 0
2788, 6990, 897, 898, 7013, 0, 0, 0, 0
2789, 784, 6991, 7014, 785, 0, 0, 0, 0
2790, 6991, 6992, 7015, 7014, 0, 0, 0, 0
2791, 6992, 6993, 7016, 7015, 0, 0, 0, 0
2792, 6993, 6994, 7017, 7016, 0, 0, 0, 0
2793, 6994, 6995, 7018, 7017, 0, 0, 0, 0
2794, 6995, 6996, 7019, 7018, 0, 0, 0, 0
2795, 6996, 6997, 7020, 7019, 0, 0, 0, 0
2796, 6997, 6998, 7021, 7020, 0, 0, 0, 0
2797, 6998, 6999, 7022, 7021, 0, 0, 0, 0
2798, 6999, 7000, 7023, 7022, 0, 0, 0, 0
2799, 7000, 7001, 7024, 7023, 0, 0, 0, 0
2800, 7001, 7002, 7025, 7024, 0, 0, 0, 0
2801, 7002, 7003, 7026, 7025, 0, 0, 0, 0
2802, 7003, 7004, 7027, 7026, 0, 0, 0, 0
2803, 7004, 7005, 7028, 7027, 0, 0, 0, 0
2804, 7005, 7006, 7029, 7028, 0, 0, 0, 0
2805, 7006, 7007, 7030, 7029, 0, 0, 0, 0
2806, 7007, 7008, 7031, 7030, 0, 0, 0, 0
2807, 7008, 7009, 7032, 7031, 0, 0, 0, 0
2808, 7009, 7010, 7033, 7032, 0, 0, 0, 0
2809, 7010, 7011, 7034, 7033, 0, 0, 0, 0
2810, 7011, 7012, 7035, 7034, 0, 0, 0, 0
2811, 7012, 7013, 7036, 7035, 0, 0, 0, 0
2812, 7013, 898, 899, 7036, 0, 0, 0, 0
2813, 785, 7014, 7037, 786, 0, 0, 0, 0
2814, 7014, 7015, 7038, 7037, 0, 0, 0, 0
2815, 7015, 7016, 7039, 7038, 0, 0, 0, 0
2816, 7016, 7017, 7040, 7039, 0, 0, 0, 0
2817, 7017, 7018, 7041, 7040, 0, 0, 0, 0
2818, 7018, 7019, 7042, 7041, 0, 0, 0, 0
2819, 7019, 7020, 7043, 7042, 0, 0, 0, 0
2820, 7020, 7021, 7044, 7043, 0, 0, 0, 0
2821, 7021, 7022, 7045, 7044, 0, 0, 0, 0
2822, 7022, 7023, 7046, 7045, 0, 0, 0, 0
2823, 7023, 7024, 7047, 7046, 0, 0, 0, 0
2824, 7024, 7025, 7048, 7047, 0, 0, 0, 0
2825, 7025, 7026, 7049, 7048, 0, 0, 0, 0
2826, 7026, 7027, 7050, 7049, 0, 0, 0, 0
2827, 7027, 7028, 7051, 7050, 0, 0, 0, 0
2828, 7028, 7029, 7052, 7051, 0, 0, 0, 0
2829, 7029, 7030, 7053, 7052, 0, 0, 0, 0
2830, 7030, 7031, 7054, 7053, 0, 0, 0, 0
2831, 7031, 7032, 7055, 7054, 0, 0, 0, 0
2832, 7032, 7033, 7056, 7055, 0, 0, 0, 0
2833, 7033, 7034, 7057, 7056, 0, 0, 0, 0
2834, 7034, 7035, 7058, 7057, 0, 0, 0, 0
2835, 7035, 7036, 7059, 7058, 0, 0, 0, 0
2836, 7036, 899, 900, 7059, 0, 0, 0, 0
2837, 786, 7037, 7060, 787, 0, 0, 0, 0
2838, 7037, 7038, 7061, 7060, 0, 0, 0, 0
2839, 7038, 7039, 7062, 7061, 0, 0, 0, 0
2840, 7039, 7040, 7063, 7062, 0, 0, 0, 0
2841, 7040, 7041, 7064, 7063, 0, 0, 0, 0
2842, 7041, 7042, 7065, 7064, 0, 0, 0, 0
2843, 7042, 7043, 7066, 7065, 0, 0, 0, 0
2844, 7043, 7044, 7067, 7066, 0, 0, 0, 0
2845, 7044, 7045, 7068, 7067, 0, 0, 0, 0
2846, 7045, 7046, 7069, 7068, 0, 0, 0, 0
2847, 7046, 7047, 7070, 7069, 0, 0, 0, 0
2848, 7047, 7048, 7071, 7070, 0, 0, 0, 0
2849, 7048, 7049, 7072, 7071, 0, 0, 0, 0
2850, 7049, 7050, 7073, 7072, 0, 0, 0, 0
2851, 7050, 7051, 7074, 7073, 0, 0, 0, 0
2852, 7051, 7052, 7075, 7074, 0, 0, 0, 0
2853, 7052, 7053, 7076, 7075, 0, 0, 0, 0
2854, 7053, 7054, 7077, 7076, 0, 0, 0, 0
2855, 7054, 7055, 7078, 7077, 0, 0, 0, 0
2856, 7055, 7056, 7079, 7078, 0, 0, 0, 0
2857, 7056, 7057, 7080, 7079, 0, 0, 0, 0
2858, 7057, 7058, 7081, 7080, 0, 0, 0, 0
2859, 7058, 7059, 7082, 7081, 0, 0, 0, 0
2860, 7059, 900, 901, 7082, 0, 0, 0, 0
2861, 787, 7060, 7083, 788, 0, 0, 0, 0
2862, 7060, 7061, 7084, 7083, 0, 0, 0, 0
2863, 7061, 7062, 7085, 7084, 0, 0, 0, 0
2864, 7062, 7063, 7086, 7085, 0, 0, 0, 0
2865, 7063, 7064, 7087, 7086, 0, 0, 0, 0
2866, 7064, 7065, 7088, 7087, 0, 0, 0, 0
2867, 7065, 7066, 7089, 7088, 0, 0, 0, 0
2868, 7066, 7067, 7090, 7089, 0, 0, 0, 0
2869, 7067, 7068, 7091, 7090, 0, 0, 0, 0
2870, 7068, 7069, 7092, 7091, 0, 0, 0, 0
2871, 7069, 7070, 7093, 7092, 0, 0, 0, 0
2872, 7070, 7071, 7094, 7093, 0, 0, 0, 0
2873, 7071, 7072, 7095, 7094, 0, 0, 0, 0
2874, 7072, 7073, 7096, 7095, 0, 0, 0, 0
2875, 7073, 7074, 7097, 7096, 0, 0, 0, 0
2876, 7074, 7075, 7098, 7097, 0, 0, 0, 0
2877, 7075, 7076, 7099, 7098, 0, 0, 0, 0
2878, 7076, 7077, 7100, 7099, 0, 0, 0, 0
2879, 7077, 7078, 7101, 7100, 0, 0, 0, 0
2880, 7078, 7079, 7102, 7101, 0, 0, 0, 0
2881, 7079, 7080, 7103, 7102, 0, 0, 0, 0
2882, 7080, 7081, 7104, 7103, 0, 0, 0, 0
2883, 7081, 7082, 7105, 7104, 0, 0, 0, 0
2884, 7082, 901, 902, 7105, 0, 0, 0, 0
2885, 788, 7083, 7106, 789, 0, 0, 0, 0
2886, 7083, 7084, 7107, 7106, 0, 0, 0, 0
2887, 7084, 7085, 7108, 7107, 0, 0, 0, 0
2888, 7085, 7086, 7109, 7108, 0, 0, 0, 0
2889, 7086, 7087, 7110, 7109, 0, 0, 0, 0
2890, 7087, 7088, 7111, 7110, 0, 0, 0, 0
2891, 7088, 7089, 7112, 7111, 0, 0, 0, 0
2892, 7089, 7090, 7113, 7112, 0, 0, 0, 0
2893, 7090, 7091, 7114, 7113, 0, 0, 0, 0
2894, 7091, 7092, 7115, 7114, 0, 0, 0, 0
2895, 7092, 7093, 7116, 7115, 0, 0, 0, 0
2896, 7093, 7094, 7117, 7116, 0, 0, 0, 0
2897, 7094, 7095, 7118, 7117, 0, 0, 0, 0
2898, 7095, 7096, 7119, 7118, 0, 0, 0, 0
2899, 7096, 7097, 7120, 7119, 0, 0, 0, 0
2900, 7097, 7098, 7121, 7120, 0, 0, 0, 0
2901, 7098, 7099, 7122, 7121, 0, 0, 0, 0
2902, 7099, 7100, 7123, 7122, 0, 0, 0, 0
2903, 7100, 7101, 7124, 7123, 0, 0, 0, 0
2904, 7101, 7102, 7125, 7124, 0, 0, 0, 0
2905, 7102, 7103, 7126, 7125, 0, 0, 0, 0
2906, 7103, 7104, 7127, 7126, 0, 0, 0, 0
2907, 7104, 7105, 7128, 7127, 0, 0, 0, 0
2908, 7105, 902, 903, 7128, 0, 0, 0, 0
2909, 789, 7106, 7129, 790, 0, 0, 0, 0
2910, 7106, 7107, 7130, 7129, 0, 0, 0, 0
2911, 7107, 7108, 7131, 7130, 0, 0, 0, 0
2912, 7108, 7109, 7132, 7131, 0, 0, 0, 0
2913, 7109, 7110, 7133, 7132, 0, 0, 0, 0
2914, 7110, 7111, 7134, 7133, 0, 0, 0, 0
2915, 7111, 7112, 7135, 7134, 0, 0, 0, 0
2916, 7112, 7113, 7136, 7135, 0, 0, 0, 0
2917, 7113, 7114, 7137, 7136, 0, 0, 0, 0
2918, 7114, 7115, 7138, 7137, 0, 0, 0, 0
2919, 7115, 7116, 7139, 7138, 0, 0, 0, 0
2920, 7116, 7117, 7140, 7139, 0, 0, 0, 0
2921, 7117, 7118, 7141, 7140, 0, 0, 0, 0
2922, 7118, 7119, 7142, 7141, 0, 0, 0, 0
2923, 7119, 7120, 7143, 7142, 0, 0, 0, 0
2924, 7120, 7121, 7144, 7143, 0, 0, 0, 0
2925, 7121, 7122, 7145, 7144, 0, 0, 0, 0
2926, 7122, 7123, 7146, 7145, 0, 0, 0, 0
2927, 7123, 7124, 7147, 7146, 0, 0, 0, 0
2928, 7124, 7125, 7148, 7147, 0, 0, 0, 0
2929, 7125, 7126, 7149, 7148, 0, 0, 0, 0
2930, 7126, 7127, 7150, 7149, 0, 0, 0, 0
2931, 7127, 7128, 7151, 7150, 0, 0, 0, 0
2932, 7128, 903, 904, 7151, 0, 0, 0, 0
2933, 790, 7129, 7152, 791, 0, 0, 0, 0
2934, 7129, 7130, 7153, 7152, 0, 0, 0, 0
2935, 7130, 7131, 7154, 7153, 0, 0, 0, 0
2936, 7131, 7132, 7155, 7154, 0, 0, 0, 0
2937, 7132, 7133, 7156, 7155, 0, 0, 0, 0
2938, 7133, 7134, 7157, 7156, 0, 0, 0, 0
2939, 7134, 7135, 7158, 7157, 0, 0, 0, 0
2940, 7135, 7136, 7159, 7158, 0, 0, 0, 0
2941, 7136, 7137, 7160, 7159, 0, 0, 0, 0
2942, 7137, 7138, 7161, 7160, 0, 0, 0, 0
2943, 7138, 7139, 7162, 7161, 0, 0, 0, 0
2944, 7139, 7140, 7163, 7162, 0, 0, 0, 0
2945, 7140, 7141, 7164, 7163, 0, 0, 0, 0
2946, 7141, 7142, 7165, 7164, 0, 0, 0, 0
2947, 7142, 7143, 7166, 7165, 0, 0, 0, 0
2948, 7143, 7144, 7167, 7166, 0, 0, 0, 0
2949, 7144, 7145, 7168, 7167, 0, 0, 0, 0
2950, 7145, 7146, 7169, 7168, 0, 0, 0, 0
2951, 7146, 7147, 7170, 7169, 0, 0, 0, 0
2952, 7147, 7148, 7171, 7170, 0, 0, 0, 0
2953, 7148, 7149, 7172, 7171, 0, 0, 0, 0
2954, 7149, 7150, 7173, 7172, 0, 0, 0, 0
2955, 7150, 7151, 7174, 7173, 0, 0, 0, 0
2956, 7151, 904, 905, 7174, 0, 0, 0, 0
2957, 791, 7152, 7175, 792, 0, 0, 0, 0
2958, 7152, 7153, 7176, 7175, 0, 0, 0, 0
2959, 7153, 7154, 7177, 7176, 0, 0, 0, 0
2960, 7154, 7155, 7178, 7177, 0, 0, 0, 0
2961, 7155, 7156, 7179, 7178, 0, 0, 0, 0
2962, 7156, 7157, 7180, 7179, 0, 0, 0, 0
2963, 7157, 7158, 7181, 7180, 0, 0, 0, 0
2964, 7158, 7159, 7182, 7181, 0, 0, 0, 0
2965, 7159, 7160, 7183, 7182, 0, 0, 0, 0
2966, 7160, 7161, 7184, 7183, 0, 0, 0, 0
2967, 7161, 7162, 7185, 7184, 0, 0, 0, 0
2968, 7162, 7163, 7186, 7185, 0, 0, 0, 0
2969, 7163, 7164, 7187, 7186, 0, 0, 0, 0
2970, 7164, 7165, 7188, 7187, 0, 0, 0, 0
2971, 7165, 7166, 7189, 7188, 0, 0, 0, 0
2972, 7166, 7167, 7190, 7189, 0, 0, 0, 0
2973, 7167, 7168, 7191, 7190, 0, 0, 0, 0
2974, 7168, 7169, 7192, 7191, 0, 0, 0, 0
2975, 7169, 7170, 7193, 7192, 0, 0, 0, 0
2976, 7170, 7171, 7194, 7193, 0, 0, 0, 0
2977, 7171, 7172, 7195, 7194, 0, 0, 0, 0
2978, 7172, 7173, 7196, 7195, 0, 0, 0, 0
2979, 7173, 7174, 7197, 7196, 0, 0, 0, 0
2980, 7174, 905, 906, 7197, 0, 0, 0, 0
2981, 792, 7175, 7198, 793, 0, 0, 0, 0
2982, 7175, 7176, 7199, 7198, 0, 0, 0, 0
2983, 7176, 7177, 7200, 7199, 0, 0, 0, 0
2984, 7177, 7178, 7201, 7200, 0, 0, 0, 0
2985, 7178, 7179, 7202, 7201, 0, 0, 0, 0
2986, 7179, 7180, 7203, 7202, 0, 0, 0, 0
2987, 7180, 7181, 7204, 7203, 0, 0, 0, 0
2988, 7181, 7182, 7205, 7204, 0, 0, 0, 0
2989, 7182, 7183, 7206, 7205, 0, 0, 0, 0
2990, 7183, 7184, 7207, 7206, 0, 0, 0, 0
2991, 7184, 7185, 7208, 7207, 0, 0, 0, 0
2992, 7185, 7186, 7209, 7208, 0, 0, 0, 0
2993, 7186, 7187, 7210, 7209, 0, 0, 0, 0
2994, 7187, 7188, 7211, 7210, 0, 0, 0, 0
2995, 7188, 7189, 7212, 7211, 0, 0, 0, 0
2996, 7189, 7190, 7213, 7212, 0, 0, 0, 0
2997, 7190, 7191, 7214, 7213, 0, 0, 0, 0
2998, 7191, 7192, 7215, 7214, 0, 0, 0, 0
2999, 7192, 7193, 7216, 7215, 0, 0, 0, 0
3000, 7193, 7194, 7217, 7216, 0, 0, 0, 0
3001, 7194, 7195, 7218, 7217, 0, 0, 0, 0
3002, 7195, 7196, 7219, 7218, 0, 0, 0, 0
3003, 7196, 7197, 7220, 7219, 0, 0, 0, 0
3004, 7197, 906, 907, 7220, 0, 0, 0, 0
3005, 793, 7198, 7221, 794, 0, 0, 0, 0
3006, 7198, 7199, 7222, 7221, 0, 0, 0, 0
3007, 7199, 7200, 7223, 7222, 0, 0, 0, 0
3008, 7200, 7201, 7224, 7223, 0, 0, 0, 0
3009, 7201, 7202, 7225, 7224, 0, 0, 0, 0
3010, 7202, 7203, 7226, 7225, 0, 0, 0, 0
3011, 7203, 7204, 7227, 7226, 0, 0, 0, 0
3012, 7204, 7205, 7228, 7227, 0, 0, 0, 0
3013, 7205, 7206, 7229, 7228, 0, 0, 0, 0
3014, 7206, 7207, 7230, 7229, 0, 0, 0, 0
3015, 7207, 7208, 7231, 7230, 0, 0, 0, 0
3016, 7208, 7209, 7232, 7231, 0, 0, 0, 0
3017, 7209, 7210, 7233, 7232, 0, 0, 0, 0
3018, 7210, 7211, 7234, 7233, 0, 0, 0, 0
3019, 7211, 7212, 7235, 7234, 0, 0, 0, 0
3020, 7212, 7213, 7236, 7235, 0, 0, 0, 0
3021, 7213, 7214, 7237, 7236, 0, 0, 0, 0
3022, 7214, 7215, 7238, 7237, 0, 0, 0, 0
3023, 7215, 7216, 7239, 7238, 0, 0, 0, 0
3024, 7216, 7217, 7240, 7239, 0, 0, 0, 0
3025, 7217, 7218, 7241, 7240, 0, 0, 0, 0
3026, 7218, 7219, 7242, 7241, 0, 0, 0, 0
3027, 7219, 7220, 7243, 7242, 0, 0, 0, 0
3028, 7220, 907, 908, 7243, 0, 0, 0, 0
3029, 794, 7221, 7244, 795, 0, 0, 0, 0
3030, 7221, 7222, 7245, 7244, 0, 0, 0, 0
3031, 7222, 7223, 7246, 7245, 0, 0, 0, 0
3032, 7223, 7224, 7247, 7246, 0, 0, 0, 0
3033, 7224, 7225, 7248, 7247, 0, 0, 0, 0
3034, 7225, 7226, 7249, 7248, 0, 0, 0, 0
3035, 7226, 7227, 7250, 7249, 0, 0, 0, 0
3036, 7227, 7228, 7251, 7250, 0, 0, 0, 0
3037, 7228, 7229, 7252, 7251, 0, 0, 0, 0
3038, 7229, 7230, 7253, 7252, 0, 0, 0, 0
3039, 7230, 7231, 7254, 7253, 0, 0, 0, 0
3040, 7231, 7232, 7255, 7254, 0, 0, 0, 0
3041, 7232, 7233, 7256, 7255, 0, 0, 0, 0
3042, 7233, 7234, 7257, 7256, 0, 0, 0, 0
3043, 7234, 7235, 7258, 7257, 0, 0, 0, 0
3044, 7235, 7236, 7259, 7258, 0, 0, 0, 0
3045, 7236, 7237, 7260, 7259, 0, 0, 0, 0
3046, 7237, 7238, 7261, 7260, 0, 0, 0, 0
3047, 7238, 7239, 7262, 7261, 0, 0, 0, 0
3048, 7239, 7240, 7263, 7262, 0, 0, 0, 0
3049, 7240, 7241, 7264, 7263, 0, 0, 0, 0
3050, 7241, 7242, 7265, 7264, 0, 0, 0, 0
3051, 7242, 7243, 7266, 7265, 0, 0, 0, 0
3052, 7243, 908, 909, 7266, 0, 0, 0, 0
3053, 795, 7244, 7267, 796, 0, 0, 0, 0
3054, 7244, 7245, 7268, 7267, 0, 0, 0, 0
3055, 7245, 7246, 7269, 7268, 0, 0, 0, 0
3056, 7246, 7247, 7270, 7269, 0, 0, 0, 0
3057, 7247, 7248, 7271, 7270, 0, 0, 0, 0
3058, 7248, 7249, 7272, 7271, 0, 0, 0, 0
3059, 7249, 7250, 7273, 7272, 0, 0, 0, 0
3060, 7250, 7251, 7274, 7273, 0, 0, 0, 0
3061, 7251, 7252, 7275, 7274, 0, 0, 0, 0
3062, 7252, 7253, 7276, 7275, 0, 0, 0, 0
3063, 7253, 7254, 7277, 7276, 0, 0, 0, 0
3064, 7254, 7255, 7278, 7277, 0, 0, 0, 0
3065, 7255, 7256, 7279, 7278, 0, 0, 0, 0
3066, 7256, 7257, 7280, 7279, 0, 0, 0, 0
3067, 7257, 7258, 7281, 7280, 0, 0, 0, 0
3068, 7258, 7259, 7282, 7281, 0, 0, 0, 0
3069, 7259, 7260, 7283, 7282, 0, 0, 0, 0
3070, 7260, 7261, 7284, 7283, 0, 0, 0, 0
3071, 7261, 7262, 7285, 7284, 0, 0, 0, 0
3072, 7262, 7263, 7286, 7285, 0, 0, 0, 0
3073, 7263, 7264, 7287, 7286, 0, 0, 0, 0
3074, 7264, 7265, 7288, 7287, 0, 0, 0, 0
3075, 7265, 7266, 7289, 7288, 0, 0, 0, 0
3076, 7266, 909, 910, 7289, 0, 0, 0, 0
3077, 796, 7267, 865, 34, 0, 0, 0, 0
3078, 7267, 7268, 866, 865, 0, 0, 0, 0
3079, 7268, 7269, 867, 866, 0, 0, 0, 0
3080, 7269, 7270, 868, 867, 0, 0, 0, 0
3081, 7270, 7271, 869, 868, 0, 0, 0, 0
3082, 7271, 7272, 870, 869, 0, 0, 0, 0
3083, 7272, 7273, 871, 870, 0, 0, 0, 0
3084, 7273, 7274, 872, 871, 0, 0, 0, 0
3085, 7274, 7275, 873, 872, 0, 0, 0, 0
3086, 7275, 7276, 874, 873, 0, 0, 0, 0
3087, 7276, 7277, 875, 874, 0, 0, 0, 0
3088, 7277, 7278, 876, 875, 0, 0, 0, 0
3089, 7278, 7279, 877, 876, 0, 0, 0, 0
3090, 7279, 7280, 878, 877, 0, 0, 0, 0
3091, 7280, 7281, 879, 878, 0, 0, 0, 0
3092, 7281, 7282, 880, 879, 0, 0, 0, 0
3093, 7282, 7283, 881, 880, 0, 0, 0, 0
3094, 7283, 7284, 882, 881, 0, 0, 0, 0
3095, 7284, 7285, 883, 882, 0, 0, 0, 0
3096, 7285, 7286, 884, 883, 0, 0, 0, 0
3097, 7286, 7287, 885, 884, 0, 0, 0, 0
3098, 7287, 7288, 886, 885, 0, 0, 0, 0
3099, 7288, 7289, 887, 886, 0, 0, 0, 0
3100, 7289, 910, 38, 887, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface43
36974, 35, 797, 7290, 911, 0, 0, 0, 0
36975, 911, 7290, 7291, 912, 0, 0, 0, 0
36976, 912, 7291, 7292, 913, 0, 0, 0, 0
36977, 913, 7292, 7293, 914, 0, 0, 0, 0
36978, 914, 7293, 7294, 915, 0, 0, 0, 0
36979, 915, 7294, 7295, 916, 0, 0, 0, 0
36980, 916, 7295, 7296, 917, 0, 0, 0, 0
36981, 917, 7296, 7297, 918, 0, 0, 0, 0
36982, 918, 7297, 7298, 919, 0, 0, 0, 0
36983, 919, 7298, 7299, 920, 0, 0, 0, 0
36984, 920, 7299, 7300, 921, 0, 0, 0, 0
36985, 921, 7300, 7301, 922, 0, 0, 0, 0
36986, 922, 7301, 7302, 923, 0, 0, 0, 0
36987, 923, 7302, 7303, 924, 0, 0, 0, 0
36988, 924, 7303, 7304, 925, 0, 0, 0, 0
36989, 925, 7304, 7305, 926, 0, 0, 0, 0
36990, 926, 7305, 7306, 927, 0, 0, 0, 0
36991, 927, 7306, 7307, 928, 0, 0, 0, 0
36992, 928, 7307, 7308, 929, 0, 0, 0, 0
36993, 929, 7308, 7309, 930, 0, 0, 0, 0
36994, 930, 7309, 7310, 931, 0, 0, 0, 0
36995, 931, 7310, 7311, 932, 0, 0, 0, 0
36996, 932, 7311, 7312, 933, 0, 0, 0, 0
36997, 933, 7312, 957, 39, 0, 0, 0, 0
36998, 797, 798, 7313, 7290, 0, 0, 0, 0
36999, 7290, 7313, 7314, 7291, 0, 0, 0, 0
37000, 7291, 7314, 7315, 7292, 0, 0, 0, 0
37001, 7292, 7315, 7316, 7293, 0, 0, 0, 0
37002, 7293, 7316, 7317, 7294, 0, 0, 0, 0
37003, 7294, 7317, 7318, 7295, 0, 0, 0, 0
37004, 7295, 7318, 7319, 7296, 0, 0, 0, 0
37005, 7296, 7319, 7320, 7297, 0, 0, 0, 0
37006, 7297, 7320, 7321, 7298, 0, 0, 0, 0
37007, 7298, 7321, 7322, 7299, 0, 0, 0, 0
37008, 7299, 7322, 7323, 7300, 0, 0, 0, 0
37009, 7300, 7323, 7324, 7301, 0, 0, 0, 0
37010, 7301, 7324, 7325, 7302, 0, 0, 0, 0
37011, 7302, 7325, 7326, 7303, 0, 0, 0, 0
37012, 7303, 7326, 7327, 7304, 0, 0, 0, 0
37013, 7304, 7327, 7328, 7305, 0, 0, 0, 0
37014, 7305, 7328, 7329, 7306, 0, 0, 0, 0
37015, 7306, 7329, 7330, 7307, 0, 0, 0, 0
37016, 7307, 7330, 7331, 7308, 0, 0, 0, 0
37017, 7308, 7331, 7332, 7309, 0, 0, 0, 0
37018, 7309, 7332, 7333, 7310, 0, 0, 0, 0
37019, 7310, 7333, 7334, 7311, 0, 0, 0, 0
37020, 7311, 7334, 7335, 7312, 0, 0, 0, 0
37021, 7312, 7335, 958, 957, 0, 0, 0, 0
37022, 798, 799, 7336, 7313, 0, 0, 0, 0
37023, 7313, 7336, 7337, 7314, 0, 0, 0, 0
37024, 7314, 7337, 7338, 7315, 0, 0, 0, 0
37025, 7315, 7338, 7339, 7316, 0, 0, 0, 0
37026, 7316, 7339, 7340, 7317, 0, 0, 0, 0
37027, 7317, 7340, 7341, 7318, 0, 0, 0, 0
37028, 7318, 7341, 7342, 7319, 0, 0, 0, 0
37029, 7319, 7342, 7343, 7320, 0, 0, 0, 0
37030, 7320, 7343, 7344, 7321, 0, 0, 0, 0
37031, 7321, 7344, 7345, 7322, 0, 0, 0, 0
37032, 7322, 7345, 7346, 7323, 0, 0, 0, 0
37033, 7323, 7346, 7347, 7324, 0, 0, 0, 0
37034, 7324, 7347, 7348, 7325, 0, 0, 0, 0
37035, 7325, 7348, 7349, 7326, 0, 0, 0, 0
37036, 7326, 7349, 7350, 7327, 0, 0, 0, 0
37037, 7327, 7350, 7351, 7328, 0, 0, 0, 0
37038, 7328, 7351, 7352, 7329, 0, 0, 0, 0
37039, 7329, 7352, 7353, 7330, 0, 0, 0, 0
37040, 7330, 7353, 7354, 7331, 0, 0, 0, 0
37041, 7331, 7354, 7355, 7332, 0, 0, 0, 0
37042, 7332, 7355, 7356, 7333, 0, 0, 0, 0
37043, 7333, 7356, 7357, 7334, 0, 0, 0, 0
37044, 7334, 7357, 7358, 7335, 0, 0, 0, 0
37045, 7335, 7358, 959, 958, 0, 0, 0, 0
37046, 799, 800, 7359, 7336, 0, 0, 0, 0
37047, 7336, 7359, 7360, 7337, 0, 0, 0, 0
37048, 7337, 7360, 7361, 7338, 0, 0, 0, 0
37049, 7338, 7361, 7362, 7339, 0, 0, 0, 0
37050, 7339, 7362, 7363, 7340, 0, 0, 0, 0
37051, 7340, 7363, 7364, 7341, 0, 0, 0, 0
37052, 7341, 7364, 7365, 7342, 0, 0, 0, 0
37053, 7342, 7365, 7366, 7343, 0, 0, 0, 0
37054, 7343, 7366, 7367, 7344, 0, 0, 0, 0
37055, 7344, 7367, 7368, 7345, 0, 0, 0, 0
37056, 7345, 7368, 7369, 7346, 0, 0, 0, 0
37057, 7346, 7369, 7370, 7347, 0, 0, 0, 0
37058, 7347, 7370, 7371, 7348, 0, 0, 0, 0
37059, 7348, 7371, 7372, 7349, 0, 0, 0, 0
37060, 7349, 7372, 7373, 7350, 0, 0, 0, 0
37061, 7350, 7373, 7374, 7351, 0, 0, 0, 0
37062, 7351, 7374, 7375, 7352, 0, 0, 0, 0
37063, 7352, 7375, 7376, 7353, 0, 0, 0, 0
37064, 7353, 7376, 7377, 7354, 0, 0, 0, 0
37065, 7354, 7377, 7378, 7355, 0, 0, 0, 0
37066, 7355, 7378, 7379, 7356, 0, 0, 0, 0
37067, 7356, 7379, 7380, 7357, 0, 0, 0, 0
37068, 7357, 7380, 7381, 7358, 0, 0, 0, 0
37069, 7358, 7381, 960, 959, 0, 0, 0, 0
37070, 800, 801, 7382, 7359, 0, 0, 0, 0
37071, 7359, 7382, 7383, 7360, 0, 0, 0, 0
37072, 7360, 7383, 7384, 7361, 0, 0, 0, 0
37073, 7361, 7384, 7385, 7362, 0, 0, 0, 0
37074, 7362, 7385, 7386, 7363, 0, 0, 0, 0
37075, 7363, 7386, 7387, 7364, 0, 0, 0, 0
37076, 7364, 7387, 7388, 7365, 0, 0, 0, 0
37077, 7365, 7388, 7389, 7366, 0, 0, 0, 0
37078, 7366, 7389, 7390, 7367, 0, 0, 0, 0
37079, 7367, 7390, 7391, 7368, 0, 0, 0, 0
37080, 7368, 7391, 7392, 7369, 0, 0, 0, 0
37081, 7369, 7392, 7393, 7370, 0, 0, 0, 0
37082, 7370, 7393, 7394, 7371, 0, 0, 0, 0
37083, 7371, 7394, 7395, 7372, 0, 0, 0, 0
37084, 7372, 7395, 7396, 7373, 0, 0, 0, 0
37085, 7373, 7396, 7397, 7374, 0, 0, 0, 0
37086, 7374, 7397, 7398, 7375, 0, 0, 0, 0
37087, 7375, 7398, 7399, 7376, 0, 0, 0, 0
37088, 7376, 7399, 7400, 7377, 0, 0, 0, 0
37089, 7377, 7400, 7401, 7378, 0, 0, 0, 0
37090, 7378, 7401, 7402, 7379, 0, 0, 0, 0
37091, 7379, 7402, 7403, 7380, 0, 0, 0, 0
37092, 7380, 7403, 7404, 7381, 0, 0, 0, 0
37093, 7381, 7404, 961, 960, 0, 0, 0, 0
37094, 801, 802, 7405, 7382, 0, 0, 0, 0
37095, 7382, 7405, 7406, 7383, 0, 0, 0, 0
37096, 7383, 7406, 7407, 7384, 0, 0, 0, 0
37097, 7384, 7407, 7408, 7385, 0, 0, 0, 0
37098, 7385, 7408, 7409, 7386, 0, 0, 0, 0
37099, 7386, 7409, 7410, 7387, 0, 0, 0, 0
37100, 7387, 7410, 7411, 7388, 0, 0, 0, 0
37101, 7388, 7411, 7412, 7389, 0, 0, 0, 0
37102, 7389, 7412, 7413, 7390, 0, 0, 0, 0
37103, 7390, 7413, 7414, 7391, 0, 0, 0, 0
37104, 7391, 7414, 7415, 7392, 0, 0, 0, 0
37105, 7392, 7415, 7416, 7393, 0, 0, 0, 0
37106, 7393, 7416, 7417, 7394, 0, 0, 0, 0
37107, 7394, 7417, 7418, 7395, 0, 0, 0, 0
37108, 7395, 7418, 7419, 7396, 0, 0, 0, 0
37109, 7396, 7419, 7420, 7397, 0, 0, 0, 0
37110, 7397, 7420, 7421, 7398, 0, 0, 0, 0
37111, 7398, 7421, 7422, 7399, 0, 0, 0, 0
37112, 7399, 7422, 7423, 7400, 0, 0, 0, 0
37113, 7400, 7423, 7424, 7401, 0, 0, 0, 0
37114, 7401, 7424, 7425, 7402, 0, 0, 0, 0
37115, 7402, 7425, 7426, 7403, 0, 0, 0, 0
37116, 7403, 7426, 7427, 7404, 0, 0, 0, 0
37117, 7404, 7427, 962, 961, 0, 0, 0, 0
37118, 802, 803, 7428, 7405, 0, 0, 0, 0
37119, 7405, 7428, 7429, 7406, 0, 0, 0, 0
37120, 7406, 7429, 7430, 7407, 0, 0, 0, 0
37121, 7407, 7430, 7431, 7408, 0, 0, 0, 0
37122, 7408, 7431, 7432, 7409, 0, 0, 0, 0
37123, 7409, 7432, 7433, 7410, 0, 0, 0, 0
37124, 7410, 7433, 7434, 7411, 0, 0, 0, 0
37125, 7411, 7434, 7435, 7412, 0, 0, 0, 0
37126, 7412, 7435, 7436, 7413, 0, 0, 0, 0
37127, 7413, 7436, 7437, 7414, 0, 0, 0, 0
37128, 7414, 7437, 7438, 7415, 0, 0, 0, 0
37129, 7415, 7438, 7439, 7416, 0, 0, 0, 0
37130, 7416, 7439, 7440, 7417, 0, 0, 0, 0
37131, 7417, 7440, 7441, 7418, 0, 0, 0, 0
37132, 7418, 7441, 7442, 7419, 0, 0, 0, 0
37133, 7419, 7442, 7443, 7420, 0, 0, 0, 0
37134, 7420, 7443, 7444, 7421, 0, 0, 0, 0
37135, 7421, 7444, 7445, 7422, 0, 0, 0, 0
37136, 7422, 7445, 7446, 7423, 0, 0, 0, 0
37137, 7423, 7446, 7447, 7424, 0, 0, 0, 0
37138, 7424, 7447, 7448, 7425, 0, 0, 0, 0
37139, 7425, 7448, 7449, 7426, 0, 0, 0, 0
37140, 7426, 7449, 7450, 7427, 0, 0, 0, 0
37141, 7427, 7450, 963, 962, 0, 0, 0, 0
37142, 803, 804, 7451, 7428, 0, 0, 0, 0
37143, 7428, 7451, 7452, 7429, 0, 0, 0, 0
37144, 7429, 7452, 7453, 7430, 0, 0, 0, 0
37145, 7430, 7453, 7454, 7431, 0, 0, 0, 0
37146, 7431, 7454, 7455, 7432, 0, 0, 0, 0
37147, 7432, 7455, 7456, 7433, 0, 0, 0, 0
37148, 7433, 7456, 7457, 7434, 0, 0, 0, 0
37149, 7434, 7457, 7458, 7435, 0, 0, 0, 0
37150, 7435, 7458, 7459, 7436, 0, 0, 0, 0
37151, 7436, 7459, 7460, 7437, 0, 0, 0, 0
37152, 7437, 7460, 7461, 7438, 0, 0, 0, 0
37153, 7438, 7461, 7462, 7439, 0, 0, 0, 0
37154, 7439, 7462, 7463, 7440, 0, 0, 0, 0
37155, 7440, 7463, 7464, 7441, 0, 0, 0, 0
37156, 7441, 7464, 7465, 7442, 0, 0, 0, 0
37157, 7442, 7465, 7466, 7443, 0, 0, 0, 0
37158, 7443, 7466, 7467, 7444, 0, 0, 0, 0
37159, 7444, 7467, 7468, 7445, 0, 0, 0, 0
37160, 7445, 7468, 7469, 7446, 0, 0, 0, 0
37161, 7446, 7469, 7470, 7447, 0, 0, 0, 0
37162, 7447, 7470, 7471, 7448, 0, 0, 0, 0
37163, 7448, 7471, 7472, 7449, 0, 0, 0, 0
37164, 7449, 7472, 7473, 7450, 0, 0, 0, 0
37165, 7450, 7473, 964, 963, 0, 0, 0, 0
37166, 804, 805, 7474, 7451, 0, 0, 0, 0
37167, 7451, 7474, 7475, 7452, 0, 0, 0, 0
37168, 7452, 7475, 7476, 7453, 0, 0, 0, 0
37169, 7453, 7476, 7477, 7454, 0, 0, 0, 0
37170, 7454, 7477, 7478, 7455, 0, 0, 0, 0
37171, 7455, 7478, 7479, 7456, 0, 0, 0, 0
37172, 7456, 7479, 7480, 7457, 0, 0, 0, 0
37173, 7457, 7480, 7481, 7458, 0, 0, 0, 0
37174, 7458, 7481, 7482, 7459, 0, 0, 0, 0
37175, 7459, 7482, 7483, 7460, 0, 0, 0, 0
37176, 7460, 7483, 7484, 7461, 0, 0, 0, 0
37177, 7461, 7484, 7485, 7462, 0, 0, 0, 0
37178, 7462, 7485, 7486, 7463, 0, 0, 0, 0
37179, 7463, 7486, 7487, 7464, 0, 0, 0, 0
37180, 7464, 7487, 7488, 7465, 0, 0, 0, 0
37181, 7465, 7488, 7489, 7466, 0, 0, 0, 0
37182, 7466, 7489, 7490, 7467, 0, 0, 0, 0
37183, 7467, 7490, 7491, 7468, 0, 0, 0, 0
37184, 7468, 7491, 7492, 7469, 0, 0, 0, 0
37185, 7469, 7492, 7493, 7470, 0, 0, 0, 0
37186, 7470, 7493, 7494, 7471, 0, 0, 0, 0
37187, 7471, 7494, 7495, 7472, 0, 0, 0, 0
37188, 7472, 7495, 7496, 7473, 0, 0, 0, 0
37189, 7473, 7496, 965, 964, 0, 0, 0, 0
37190, 805, 806, 7497, 7474, 0, 0, 0, 0
37191, 7474, 7497, 7498, 7475, 0, 0, 0, 0
37192, 7475, 7498, 7499, 7476, 0, 0, 0, 0
37193, 7476, 7499, 7500, 7477, 0, 0, 0, 0
37194, 7477, 7500, 7501, 7478, 0, 0, 0, 0
37195, 7478, 7501, 7502, 7479, 0, 0, 0, 0
37196, 7479, 7502, 7503, 7480, 0, 0, 0, 0
37197, 7480, 7503, 7504, 7481, 0, 0, 0, 0
37198, 7481, 7504, 7505, 7482, 0, 0, 0, 0
37199, 7482, 7505, 7506, 7483, 0, 0, 0, 0
37200, 7483, 7506, 7507, 7484, 0, 0, 0, 0
37201, 7484, 7507, 7508, 7485, 0, 0, 0, 0
37202, 7485, 7508, 7509, 7486, 0, 0, 0, 0
37203, 7486, 7509, 7510, 7487, 0, 0, 0, 0
37204, 7487, 7510, 7511, 7488, 0, 0, 0, 0
37205, 7488, 7511, 7512, 7489, 0, 0, 0, 0
37206, 7489, 7512, 7513, 7490, 0, 0, 0, 0
37207, 7490, 7513, 7514, 7491, 0, 0, 0, 0
37208, 7491, 7514, 7515, 7492, 0, 0, 0, 0
37209, 7492, 7515, 7516, 7493, 0, 0, 0, 0
37210, 7493, 7516, 7517, 7494, 0, 0, 0, 0
37211, 7494, 7517, 7518, 7495, 0, 0, 0, 0
37212, 7495, 7518, 7519, 7496, 0, 0, 0, 0
37213, 7496, 7519, 966, 965, 0, 0, 0, 0
37214, 806, 807, 7520, 7497, 0, 0, 0, 0
37215, 7497, 7520, 7521, 7498, 0, 0, 0, 0
37216, 7498, 7521, 7522, 7499, 0, 0, 0, 0
37217, 7499, 7522, 7523, 7500, 0, 0, 0, 0
37218, 7500, 7523, 7524, 7501, 0, 0, 0, 0
37219, 7501, 7524, 7525, 7502, 0, 0, 0, 0
37220, 7502, 7525, 7526, 7503, 0, 0, 0, 0
37221, 7503, 7526, 7527, 7504, 0, 0, 0, 0
37222, 7504, 7527, 7528, 7505, 0, 0, 0, 0
37223, 7505, 7528, 7529, 7506, 0, 0, 0, 0
37224, 7506, 7529, 7530, 7507, 0, 0, 0, 0
37225, 7507, 7530, 7531, 7508, 0, 0, 0, 0
37226, 7508, 7531, 7532, 7509, 0, 0, 0, 0
37227, 7509, 7532, 7533, 7510, 0, 0, 0, 0
37228, 7510, 7533, 7534, 7511, 0, 0, 0, 0
37229, 7511, 7534, 7535, 7512, 0, 0, 0, 0
37230, 7512, 7535, 7536, 7513, 0, 0, 0, 0
37231, 7513, 7536, 7537, 7514, 0, 0, 0, 0
37232, 7514, 7537, 7538, 7515, 0, 0, 0, 0
37233, 7515, 7538, 7539, 7516, 0, 0, 0, 0
37234, 7516, 7539, 7540, 7517, 0, 0, 0, 0
37235, 7517, 7540, 7541, 7518, 0, 0, 0, 0
37236, 7518, 7541, 7542, 7519, 0, 0, 0, 0
37237, 7519, 7542, 967, 966, 0, 0, 0, 0
37238, 807, 808, 7543, 7520, 0, 0, 0, 0
37239, 7520, 7543, 7544, 7521, 0, 0, 0, 0
37240, 7521, 7544, 7545, 7522, 0, 0, 0, 0
37241, 7522, 7545, 7546, 7523, 0, 0, 0, 0
37242, 7523, 7546, 7547, 7524, 0, 0, 0, 0
37243, 7524, 7547, 7548, 7525, 0, 0, 0, 0
37244, 7525, 7548, 7549, 7526, 0, 0, 0, 0
37245, 7526, 7549, 7550, 7527, 0, 0, 0, 0
37246, 7527, 7550, 7551, 7528, 0, 0, 0, 0
37247, 7528, 7551, 7552, 7529, 0, 0, 0, 0
37248, 7529, 7552, 7553, 7530, 0, 0, 0, 0
37249, 7530, 7553, 7554, 7531, 0, 0, 0, 0
37250, 7531, 7554, 7555, 7532, 0, 0, 0, 0
37251, 7532, 7555, 7556, 7533, 0, 0, 0, 0
37252, 7533, 7556, 7557, 7534, 0, 0, 0, 0
37253, 7534, 7557, 7558, 7535, 0, 0, 0, 0
37254, 7535, 7558, 7559, 7536, 0, 0, 0, 0
37255, 7536, 7559, 7560, 7537, 0, 0, 0, 0
37256, 7537, 7560, 7561, 7538, 0, 0, 0, 0
37257, 7538, 7561, 7562, 7539, 0, 0, 0, 0
37258, 7539, 7562, 7563, 7540, 0, 0, 0, 0
37259, 7540, 7563, 7564, 7541, 0, 0, 0, 0
37260, 7541, 7564, 7565, 7542, 0, 0, 0, 0
37261, 7542, 7565, 968, 967, 0, 0, 0, 0
37262, 808, 809, 7566, 7543, 0, 0, 0, 0
37263, 7543, 7566, 7567, 7544, 0, 0, 0, 0
37264, 7544, 7567, 7568, 7545, 0, 0, 0, 0
37265, 7545, 7568, 7569, 7546, 0, 0, 0, 0
37266, 7546, 7569, 7570, 7547, 0, 0, 0, 0
37267, 7547, 7570, 7571, 7548, 0, 0, 0, 0
37268, 7548, 7571, 7572, 7549, 0, 0, 0, 0
37269, 7549, 7572, 7573, 7550, 0, 0, 0, 0
37270, 7550, 7573, 7574, 7551, 0, 0, 0, 0
37271, 7551, 7574, 7575, 7552, 0, 0, 0, 0
37272, 7552, 7575, 7576, 7553, 0, 0, 0, 0
37273, 7553, 7576, 7577, 7554, 0, 0, 0, 0
37274, 7554, 7577, 7578, 7555, 0, 0, 0, 0
37275, 7555, 7578, 7579, 7556, 0, 0, 0, 0
37276, 7556, 7579, 7580, 7557, 0, 0, 0, 0
37277, 7557, 7580, 7581, 7558, 0, 0, 0, 0
37278, 7558, 7581, 7582, 7559, 0, 0, 0, 0
37279, 7559, 7582, 7583, 7560, 0, 0, 0, 0
37280, 7560, 7583, 7584, 7561, 0, 0, 0, 0
37281, 7561, 7584, 7585, 7562, 0, 0, 0, 0
37282, 7562, 7585, 7586, 7563, 0, 0, 0, 0
37283, 7563, 7586, 7587, 7564, 0, 0, 0, 0
37284, 7564, 7587, 7588, 7565, 0, 0, 0, 0
37285, 7565, 7588, 969, 968, 0, 0, 0, 0
37286, 809, 810, 7589, 7566, 0, 0, 0, 0
37287, 7566, 7589, 7590, 7567, 0, 0, 0, 0
37288, 7567, 7590, 7591, 7568, 0, 0, 0, 0
37289, 7568, 7591, 7592, 7569, 0, 0, 0, 0
37290, 7569, 7592, 7593, 7570, 0, 0, 0, 0
37291, 7570, 7593, 7594, 7571, 0, 0, 0, 0
37292, 7571, 7594, 7595, 7572, 0, 0, 0, 0
37293, 7572, 7595, 7596, 7573, 0, 0, 0, 0
37294, 7573, 7596, 7597, 7574, 0, 0, 0, 0
37295, 7574, 7597, 7598, 7575, 0, 0, 0, 0
37296, 7575, 7598, 7599, 7576, 0, 0, 0, 0
37297, 7576, 7599, 7600, 7577, 0, 0, 0, 0
37298, 7577, 7600, 7601, 7578, 0, 0, 0, 0
37299, 7578, 7601, 7602, 7579, 0, 0, 0, 0
37300, 7579, 7602, 7603, 7580, 0, 0, 0, 0
37301, 7580, 7603, 7604, 7581, 0, 0, 0, 0
37302, 7581, 7604, 7605, 7582, 0, 0, 0, 0
37303, 7582, 7605, 7606, 7583, 0, 0, 0, 0
37304, 7583, 7606, 7607, 7584, 0, 0, 0, 0
37305, 7584, 7607, 7608, 7585, 0, 0, 0, 0
37306, 7585, 7608, 7609, 7586, 0, 0, 0, 0
37307, 7586, 7609, 7610, 7587, 0, 0, 0, 0
37308, 7587, 7610, 7611, 7588, 0, 0, 0, 0
37309, 7588, 7611, 970, 969, 0, 0, 0, 0
37310, 810, 811, 7612, 7589, 0, 0, 0, 0
37311, 7589, 7612, 7613, 7590, 0, 0, 0, 0
37312, 7590, 7613, 7614, 7591, 0, 0, 0, 0
37313, 7591, 7614, 7615, 7592, 0, 0, 0, 0
37314, 7592, 7615, 7616, 7593, 0, 0, 0, 0
37315, 7593, 7616, 7617, 7594, 0, 0, 0, 0
37316, 7594, 7617, 7618, 7595, 0, 0, 0, 0
37317, 7595, 7618, 7619, 7596, 0, 0, 0, 0
37318, 7596, 7619, 7620, 7597, 0, 0, 0, 0
37319, 7597, 7620, 7621, 7598, 0, 0, 0, 0
37320, 7598, 7621, 7622, 7599, 0, 0, 0, 0
37321, 7599, 7622, 7623, 7600, 0, 0, 0, 0
37322, 7600, 7623, 7624, 7601, 0, 0, 0, 0
37323, 7601, 7624, 7625, 7602, 0, 0, 0, 0
37324, 7602, 7625, 7626, 7603, 0, 0, 0, 0
37325, 7603, 7626, 7627, 7604, 0, 0, 0, 0
37326, 7604, 7627, 7628, 7605, 0, 0, 0, 0
37327, 7605, 7628, 7629, 7606, 0, 0, 0, 0
37328, 7606, 7629, 7630, 7607, 0, 0, 0, 0
37329, 7607, 7630, 7631, 7608, 0, 0, 0, 0
37330, 7608, 7631, 7632, 7609, 0, 0, 0, 0
37331, 7609, 7632, 7633, 7610, 0, 0, 0, 0
37332, 7610, 7633, 7634, 7611, 0, 0, 0, 0
37333, 7611, 7634, 971, 970, 0, 0, 0, 0
37334, 811, 812, 7635, 7612, 0, 0, 0, 0
37335, 7612, 7635, 7636, 7613, 0, 0, 0, 0
37336, 7613, 7636, 7637, 7614, 0, 0, 0, 0
37337, 7614, 7637, 7638, 7615, 0, 0, 0, 0
37338, 7615, 7638, 7639, 7616, 0, 0, 0, 0
37339, 7616, 7639, 7640, 7617, 0, 0, 0, 0
37340, 7617, 7640, 7641, 7618, 0, 0, 0, 0
37341, 7618, 7641, 7642, 7619, 0, 0, 0, 0
37342, 7619, 7642, 7643, 7620, 0, 0, 0, 0
37343, 7620, 7643, 7644, 7621, 0, 0, 0, 0
37344, 7621, 7644, 7645, 7622, 0, 0, 0, 0
37345, 7622, 7645, 7646, 7623, 0, 0, 0, 0
37346, 7623, 7646, 7647, 7624, 0, 0, 0, 0
37347, 7624, 7647, 7648, 7625, 0, 0, 0, 0
37348, 7625, 7648, 7649, 7626, 0, 0, 0, 0
37349, 7626, 7649, 7650, 7627, 0, 0, 0, 0
37350, 7627, 7650, 7651, 7628, 0, 0, 0, 0
37351, 7628, 7651, 7652, 7629, 0, 0, 0, 0
37352, 7629, 7652, 7653, 7630, 0, 0, 0, 0
37353, 7630, 7653, 7654, 7631, 0, 0, 0, 0
37354, 7631, 7654, 7655, 7632, 0, 0, 0, 0
37355, 7632, 7655, 7656, 7633, 0, 0, 0, 0
37356, 7633, 7656, 7657, 7634, 0, 0, 0, 0
37357, 7634, 7657, 972, 971, 0, 0, 0, 0
37358, 812, 813, 7658, 7635, 0, 0, 0, 0
37359, 7635, 7658, 7659, 7636, 0, 0, 0, 0
37360, 7636, 7659, 7660, 7637, 0, 0, 0, 0
37361, 7637, 7660, 7661, 7638, 0, 0, 0, 0
37362, 7638, 7661, 7662, 7639, 0, 0, 0, 0
37363, 7639, 7662, 7663, 7640, 0, 0, 0, 0
37364, 7640, 7663, 7664, 7641, 0, 0, 0, 0
37365, 7641, 7664, 7665, 7642, 0, 0, 0, 0
37366, 7642, 7665, 7666, 7643, 0, 0, 0, 0
37367, 7643, 7666, 7667, 7644, 0, 0, 0, 0
37368, 7644, 7667, 7668, 7645, 0, 0, 0, 0
37369, 7645, 7668, 7669, 7646, 0, 0, 0, 0
37370, 7646, 7669, 7670, 7647, 0, 0, 0, 0
37371, 7647, 7670, 7671, 7648, 0, 0, 0, 0
37372, 7648, 7671, 7672, 7649, 0, 0, 0, 0
37373, 7649, 7672, 7673, 7650, 0, 0, 0, 0
37374, 7650, 7673, 7674, 7651, 0, 0, 0, 0
37375, 7651, 7674, 7675, 7652, 0, 0, 0, 0
37376, 7652, 7675, 7676, 7653, 0, 0, 0, 0
37377, 7653, 7676, 7677, 7654, 0, 0, 0, 0
37378, 7654, 7677, 7678, 7655, 0, 0, 0, 0
37379, 7655, 7678, 7679, 7656, 0, 0, 0, 0
37380, 7656, 7679, 7680, 7657, 0, 0, 0, 0
37381, 7657, 7680, 973, 972, 0, 0, 0, 0
37382, 813, 814, 7681, 7658, 0, 0, 0, 0
37383, 7658, 7681, 7682, 7659, 0, 0, 0, 0
37384, 7659, 7682, 7683, 7660, 0, 0, 0, 0
37385, 7660, 7683, 7684, 7661, 0, 0, 0, 0
37386, 7661, 7684, 7685, 7662, 0, 0, 0, 0
37387, 7662, 7685, 7686, 7663, 0, 0, 0, 0
37388, 7663, 7686, 7687, 7664, 0, 0, 0, 0
37389, 7664, 7687, 7688, 7665, 0, 0, 0, 0
37390, 7665, 7688, 7689, 7666, 0, 0, 0, 0
37391, 7666, 7689, 7690, 7667, 0, 0, 0, 0
37392, 7667, 7690, 7691, 7668, 0, 0, 0, 0
37393, 7668, 7691, 7692, 7669, 0, 0, 0, 0
37394, 7669, 7692, 7693, 7670, 0, 0, 0, 0
37395, 7670, 7693, 7694, 7671, 0, 0, 0, 0
37396, 7671, 7694, 7695, 7672, 0, 0, 0, 0
37397, 7672, 7695, 7696, 7673, 0, 0, 0, 0
37398, 7673, 7696, 7697, 7674, 0, 0, 0, 0
37399, 7674, 7697, 7698, 7675, 0, 0, 0, 0
37400, 7675, 7698, 7699, 7676, 0, 0, 0, 0
37401, 7676, 7699, 7700, 7677, 0, 0, 0, 0
37402, 7677, 7700, 7701, 7678, 0, 0, 0, 0
37403, 7678, 7701, 7702, 7679, 0, 0, 0, 0
37404, 7679, 7702, 7703, 7680, 0, 0, 0, 0
37405, 7680, 7703, 974, 973, 0, 0, 0, 0
37406, 814, 815, 7704, 7681, 0, 0, 0, 0
37407, 7681, 7704, 7705, 7682, 0, 0, 0, 0
37408, 7682, 7705, 7706, 7683, 0, 0, 0, 0
37409, 7683, 7706, 7707, 7684, 0, 0, 0, 0
37410, 7684, 7707, 7708, 7685, 0, 0, 0, 0
37411, 7685, 7708, 7709, 7686, 0, 0, 0, 0
37412, 7686, 7709, 7710, 7687, 0, 0, 0, 0
37413, 7687, 7710, 7711, 7688, 0, 0, 0, 0
37414, 7688, 7711, 7712, 7689, 0, 0, 0, 0
37415, 7689, 7712, 7713, 7690, 0, 0, 0, 0
37416, 7690, 7713, 7714, 7691, 0, 0, 0, 0
37417, 7691, 7714, 7715, 7692, 0, 0, 0, 0
37418, 7692, 7715, 7716, 7693, 0, 0, 0, 0
37419, 7693, 7716, 7717, 7694, 0, 0, 0, 0
37420, 7694, 7717, 7718, 7695, 0, 0, 0, 0
37421, 7695, 7718, 7719, 7696, 0, 0, 0, 0
37422, 7696, 7719, 7720, 7697, 0, 0, 0, 0
37423, 7697, 7720, 7721, 7698, 0, 0, 0, 0
37424, 7698, 7721, 7722, 7699, 0, 0, 0, 0
37425, 7699, 7722, 7723, 7700, 0, 0, 0, 0
37426, 7700, 7723, 7724, 7701, 0, 0, 0, 0
37427, 7701, 7724, 7725, 7702, 0, 0, 0, 0
37428, 7702, 7725, 7726, 7703, 0, 0, 0, 0
37429, 7703, 7726, 975, 974, 0, 0, 0, 0
37430, 815, 816, 7727, 7704, 0, 0, 0, 0
37431, 7704, 7727, 7728, 7705, 0, 0, 0, 0
37432, 7705, 7728, 7729, 7706, 0, 0, 0, 0
37433, 7706, 7729, 7730, 7707, 0, 0, 0, 0
37434, 7707, 7730, 7731, 7708, 0, 0, 0, 0
37435, 7708, 7731, 7732, 7709, 0, 0, 0, 0
37436, 7709, 7732, 7733, 7710, 0, 0, 0, 0
37437, 7710, 7733, 7734, 7711, 0, 0, 0, 0
37438, 7711, 7734, 7735, 7712, 0, 0, 0, 0
37439, 7712, 7735, 7736, 7713, 0, 0, 0, 0
37440, 7713, 7736, 7737, 7714, 0, 0, 0, 0
37441, 7714, 7737, 7738, 7715, 0, 0, 0, 0
37442, 7715, 7738, 7739, 7716, 0, 0, 0, 0
37443, 7716, 7739, 7740, 7717, 0, 0, 0, 0
37444, 7717, 7740, 7741, 7718, 0, 0, 0, 0
37445, 7718, 7741, 7742, 7719, 0, 0, 0, 0
37446, 7719, 7742, 7743, 7720, 0, 0, 0, 0
37447, 7720, 7743, 7744, 7721, 0, 0, 0, 0
37448, 7721, 7744, 7745, 7722, 0, 0, 0, 0
37449, 7722, 7745, 7746, 7723, 0, 0, 0, 0
37450, 7723, 7746, 7747, 7724, 0, 0, 0, 0
37451, 7724, 7747, 7748, 7725, 0, 0, 0, 0
37452, 7725, 7748, 7749, 7726, 0, 0, 0, 0
37453, 7726, 7749, 976, 975, 0, 0, 0, 0
37454, 816, 817, 7750, 7727, 0, 0, 0, 0
37455, 7727, 7750, 7751, 7728, 0, 0, 0, 0
37456, 7728, 7751, 7752, 7729, 0, 0, 0, 0
37457, 7729, 7752, 7753, 7730, 0, 0, 0, 0
37458, 7730, 7753, 7754, 7731, 0, 0, 0, 0
37459, 7731, 7754, 7755, 7732, 0, 0, 0, 0
37460, 7732, 7755, 7756, 7733, 0, 0, 0, 0
37461, 7733, 7756, 7757, 7734, 0, 0, 0, 0
37462, 7734, 7757, 7758, 7735, 0, 0, 0, 0
37463, 7735, 7758, 7759, 7736, 0, 0, 0, 0
37464, 7736, 7759, 7760, 7737, 0, 0, 0, 0
37465, 7737, 7760, 7761, 7738, 0, 0, 0, 0
37466, 7738, 7761, 7762, 7739, 0, 0, 0, 0
37467, 7739, 7762, 7763, 7740, 0, 0, 0, 0
37468, 7740, 7763, 7764, 7741, 0, 0, 0, 0
37469, 7741, 7764, 7765, 7742, 0, 0, 0, 0
37470, 7742, 7765, 7766, 7743, 0, 0, 0, 0
37471, 7743, 7766, 7767, 7744, 0, 0, 0, 0
37472, 7744, 7767, 7768, 7745, 0, 0, 0, 0
37473, 7745, 7768, 7769, 7746, 0, 0, 0, 0
37474, 7746, 7769, 7770, 7747, 0, 0, 0, 0
37475, 7747, 7770, 7771, 7748, 0, 0, 0, 0
37476, 7748, 7771, 7772, 7749, 0, 0, 0, 0
37477, 7749, 7772, 977, 976, 0, 0, 0, 0
37478, 817, 818, 7773, 7750, 0, 0, 0, 0
37479, 7750, 7773, 7774, 7751, 0, 0, 0, 0
37480, 7751, 7774, 7775, 7752, 0, 0, 0, 0
37481, 7752, 7775, 7776, 7753, 0, 0, 0, 0
37482, 7753, 7776, 7777, 7754, 0, 0, 0, 0
37483, 7754, 7777, 7778, 7755, 0, 0, 0, 0
37484, 7755, 7778, 7779, 7756, 0, 0, 0, 0
37485, 7756, 7779, 7780, 7757, 0, 0, 0, 0
37486, 7757, 7780, 7781, 7758, 0, 0, 0, 0
37487, 7758, 7781, 7782, 7759, 0, 0, 0, 0
37488, 7759, 7782, 7783, 7760, 0, 0, 0, 0
37489, 7760, 7783, 7784, 7761, 0, 0, 0, 0
37490, 7761, 7784, 7785, 7762, 0, 0, 0, 0
37491, 7762, 7785, 7786, 7763, 0, 0, 0, 0
37492, 7763, 7786, 7787, 7764, 0, 0, 0, 0
37493, 7764, 7787, 7788, 7765, 0, 0, 0, 0
37494, 7765, 7788, 7789, 7766, 0, 0, 0, 0
37495, 7766, 7789, 7790, 7767, 0, 0, 0, 0
37496, 7767, 7790, 7791, 7768, 0, 0, 0, 0
37497, 7768, 7791, 7792, 7769, 0, 0, 0, 0
37498, 7769, 7792, 7793, 7770, 0, 0, 0, 0
37499, 7770, 7793, 7794, 7771, 0, 0, 0, 0
37500, 7771, 7794, 7795, 7772, 0, 0, 0, 0
37501, 7772, 7795, 978, 977, 0, 0, 0, 0
37502, 818, 819, 7796, 7773, 0, 0, 0, 0
37503, 7773, 7796, 7797, 7774, 0, 0, 0, 0
37504, 7774, 7797, 7798, 7775, 0, 0, 0, 0
37505, 7775, 7798, 7799, 7776, 0, 0, 0, 0
37506, 7776, 7799, 7800, 7777, 0, 0, 0, 0
37507, 7777, 7800, 7801, 7778, 0, 0, 0, 0
37508, 7778, 7801, 7802, 7779, 0, 0, 0, 0
37509, 7779, 7802, 7803, 7780, 0, 0, 0, 0
37510, 7780, 7803, 7804, 7781, 0, 0, 0, 0
37511, 7781, 7804, 7805, 7782, 0, 0, 0, 0
37512, 7782, 7805, 7806, 7783, 0, 0, 0, 0
37513, 7783, 7806, 7807, 7784, 0, 0, 0, 0
37514, 7784, 7807, 7808, 7785, 0, 0, 0, 0
37515, 7785, 7808, 7809, 7786, 0, 0, 0, 0
37516, 7786, 7809, 7810, 7787, 0, 0, 0, 0
37517, 7787, 7810, 7811, 7788, 0, 0, 0, 0
37518, 7788, 7811, 7812, 7789, 0, 0, 0, 0
37519, 7789, 7812, 7813, 7790, 0, 0, 0, 0
37520, 7790, 7813, 7814, 7791, 0, 0, 0, 0
37521, 7791, 7814, 7815, 7792, 0, 0, 0, 0
37522, 7792, 7815, 7816, 7793, 0, 0, 0, 0
37523, 7793, 7816, 7817, 7794, 0, 0, 0, 0
37524, 7794, 7817, 7818, 7795, 0, 0, 0, 0
37525, 7795, 7818, 979, 978, 0, 0, 0, 0
37526, 819, 36, 934, 7796, 0, 0, 0, 0
37527, 7796, 934, 935, 7797, 0, 0, 0, 0
37528, 7797, 935, 936, 7798, 0, 0, 0, 0
37529, 7798, 936, 937, 7799, 0, 0, 0, 0
37530, 7799, 937, 938, 7800, 0, 0, 0, 0
37531, 7800, 938, 939, 7801, 0, 0, 0, 0
37532, 7801, 939, 940, 7802, 0, 0, 0, 0
37533, 7802, 940, 941, 7803, 0, 0, 0, 0
37534, 7803, 941, 942, 7804, 0, 0, 0, 0
37535, 7804, 942, 943, 7805, 0, 0, 0, 0
37536, 7805, 943, 944, 7806, 0, 0, 0, 0
37537, 7806, 944, 945, 7807, 0, 0, 0, 0
37538, 7807, 945, 946, 7808, 0, 0, 0, 0
37539, 7808, 946, 947, 7809, 0, 0, 0, 0
37540, 7809, 947, 948, 7810, 0, 0, 0, 0
37541, 7810, 948, 949, 7811, 0, 0, 0, 0
37542, 7811, 949, 950, 7812, 0, 0, 0, 0
37543, 7812, 950, 951, 7813, 0, 0, 0, 0
37544, 7813, 951, 952, 7814, 0, 0, 0, 0
37545, 7814, 952, 953, 7815, 0, 0, 0, 0
37546, 7815, 953, 954, 7816, 0, 0, 0, 0
37547, 7816, 954, 955, 7817, 0, 0, 0, 0
37548, 7817, 955, 956, 7818, 0, 0, 0, 0
37549, 7818, 956, 40, 979, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface44
37550, 35, 911, 7819, 820, 0, 0, 0, 0
37551, 911, 912, 7820, 7819, 0, 0, 0, 0
37552, 912, 913, 7821, 7820, 0, 0, 0, 0
37553, 913, 914, 7822, 7821, 0, 0, 0, 0
37554, 914, 915, 7823, 7822, 0, 0, 0, 0
37555, 915, 916, 7824, 7823, 0, 0, 0, 0
37556, 916, 917, 7825, 7824, 0, 0, 0, 0
37557, 917, 918, 7826, 7825, 0, 0, 0, 0
37558, 918, 919, 7827, 7826, 0, 0, 0, 0
37559, 919, 920, 7828, 7827, 0, 0, 0, 0
37560, 920, 921, 7829, 7828, 0, 0, 0, 0
37561, 921, 922, 7830, 7829, 0, 0, 0, 0
37562, 922, 923, 7831, 7830, 0, 0, 0, 0
37563, 923, 924, 7832, 7831, 0, 0, 0, 0
37564, 924, 925, 7833, 7832, 0, 0, 0, 0
37565, 925, 926, 7834, 7833, 0, 0, 0, 0
37566, 926, 927, 7835, 7834, 0, 0, 0, 0
37567, 927, 928, 7836, 7835, 0, 0, 0, 0
37568, 928, 929, 7837, 7836, 0, 0, 0, 0
37569, 929, 930, 7838, 7837, 0, 0, 0, 0
37570, 930, 931, 7839, 7838, 0, 0, 0, 0
37571, 931, 932, 7840, 7839, 0, 0, 0, 0
37572, 932, 933, 7841, 7840, 0, 0, 0, 0
37573, 933, 39, 980, 7841, 0, 0, 0, 0
37574, 820, 7819, 7842, 821, 0, 0, 0, 0
37575, 7819, 7820, 7843, 7842, 0, 0, 0, 0
37576, 7820, 7821, 7844, 7843, 0, 0, 0, 0
37577, 7821, 7822, 7845, 7844, 0, 0, 0, 0
37578, 7822, 7823, 7846, 7845, 0, 0, 0, 0
37579, 7823, 7824, 7847, 7846, 0, 0, 0, 0
37580, 7824, 7825, 7848, 7847, 0, 0, 0, 0
37581, 7825, 7826, 7849, 7848, 0, 0, 0, 0
37582, 7826, 7827, 7850, 7849, 0, 0, 0, 0
37583, 7827, 7828, 7851, 7850, 0, 0, 0, 0
37584, 7828, 7829, 7852, 7851, 0, 0, 0, 0
37585, 7829, 7830, 7853, 7852, 0, 0, 0, 0
37586, 7830, 7831, 7854, 7853, 0, 0, 0, 0
37587, 7831, 7832, 7855, 7854, 0, 0, 0, 0
37588, 7832, 7833, 7856, 7855, 0, 0, 0, 0
37589, 7833, 7834, 7857, 7856, 0, 0, 0, 0
37590, 7834, 7835, 7858, 7857, 0, 0, 0, 0
37591, 7835, 7836, 7859, 7858, 0, 0, 0, 0
37592, 7836, 7837, 7860, 7859, 0, 0, 0, 0
37593, 7837, 7838, 7861, 7860, 0, 0, 0, 0
37594, 7838, 7839, 7862, 7861, 0, 0, 0, 0
37595, 7839, 7840, 7863, 7862, 0, 0, 0, 0
37596, 7840, 7841, 7864, 7863, 0, 0, 0, 0
37597, 7841, 980, 981, 7864, 0, 0, 0, 0
37598, 821, 7842, 7865, 822, 0, 0, 0, 0
37599, 7842, 7843, 7866, 7865, 0, 0, 0, 0
37600, 7843, 7844, 7867, 7866, 0, 0, 0, 0
37601, 7844, 7845, 7868, 7867, 0, 0, 0, 0
37602, 7845, 7846, 7869, 7868, 0, 0, 0, 0
37603, 7846, 7847, 7870, 7869, 0, 0, 0, 0
37604, 7847, 7848, 7871, 7870, 0, 0, 0, 0
37605, 7848, 7849, 7872, 7871, 0, 0, 0, 0
37606, 7849, 7850, 7873, 7872, 0, 0, 0, 0
37607, 7850, 7851, 7874, 7873, 0, 0, 0, 0
37608, 7851, 7852, 7875, 7874, 0, 0, 0, 0
37609, 7852, 7853, 7876, 7875, 0, 0, 0, 0
37610, 7853, 7854, 7877, 7876, 0, 0, 0, 0
37611, 7854, 7855, 7878, 7877, 0, 0, 0, 0
37612, 7855, 7856, 7879, 7878, 0, 0, 0, 0
37613, 7856, 7857, 7880, 7879, 0, 0, 0, 0
37614, 7857, 7858, 7881, 7880, 0, 0, 0, 0
37615, 7858, 7859, 7882, 7881, 0, 0, 0, 0
37616, 7859, 7860, 7883, 7882, 0, 0, 0, 0
37617, 7860, 7861, 7884, 7883, 0, 0, 0, 0
37618, 7861, 7862, 7885, 7884, 0, 0, 0, 0
37619, 7862, 7863, 7886, 7885, 0, 0, 0, 0
37620, 7863, 7864, 7887, 7886, 0, 0, 0, 0
37621, 7864, 981, 982, 7887, 0, 0, 0, 0
37622, 822, 7865, 7888, 823, 0, 0, 0, 0
37623, 7865, 7866, 7889, 7888, 0, 0, 0, 0
37624, 7866, 7867, 7890, 7889, 0, 0, 0, 0
37625, 7867, 7868, 7891, 7890, 0, 0, 0, 0
37626, 7868, 7869, 7892, 7891, 0, 0, 0, 0
37627, 7869, 7870, 7893, 7892, 0, 0, 0, 0
37628, 7870, 7871, 7894, 7893, 0, 0, 0, 0
37629, 7871, 7872, 7895, 7894, 0, 0, 0, 0
37630, 7872, 7873, 7896, 7895, 0, 0, 0, 0
37631, 7873, 7874, 7897, 7896, 0, 0, 0, 0
37632, 7874, 7875, 7898, 7897, 0, 0, 0, 0
37633, 7875, 7876, 7899, 7898, 0, 0, 0, 0
37634, 7876, 7877, 7900, 7899, 0, 0, 0, 0
37635, 7877, 7878, 7901, 7900, 0, 0, 0, 0
37636, 7878, 7879, 7902, 7901, 0, 0, 0, 0
37637, 7879, 7880, 7903, 7902, 0, 0, 0, 0
37638, 7880, 7881, 7904, 7903, 0, 0, 0, 0
37639, 7881, 7882, 7905, 7904, 0, 0, 0, 0
37640, 7882, 7883, 7906, 7905, 0, 0, 0, 0
37641, 7883, 7884, 7907, 7906, 0, 0, 0, 0
37642, 7884, 7885, 7908, 7907, 0, 0, 0, 0
37643, 7885, 7886, 7909, 7908, 0, 0, 0, 0
37644, 7886, 7887, 7910, 7909, 0, 0, 0, 0
37645, 7887, 982, 983, 7910, 0, 0, 0, 0
37646, 823, 7888, 7911, 824, 0, 0, 0, 0
37647, 7888, 7889, 7912, 7911, 0, 0, 0, 0
37648, 7889, 7890, 7913, 7912, 0, 0, 0, 0
37649, 7890, 7891, 7914, 7913, 0, 0, 0, 0
37650, 7891, 7892, 7915, 7914, 0, 0, 0, 0
37651, 7892, 7893, 7916, 7915, 0, 0, 0, 0
37652, 7893, 7894, 7917, 7916, 0, 0, 0, 0
37653, 7894, 7895, 7918, 7917, 0, 0, 0, 0
37654, 7895, 7896, 7919, 7918, 0, 0, 0, 0
37655, 7896, 7897, 7920, 7919, 0, 0, 0, 0
37656, 7897, 7898, 7921, 7920, 0, 0, 0, 0
37657, 7898, 7899, 7922, 7921, 0, 0, 0, 0
37658, 7899, 7900, 7923, 7922, 0, 0, 0, 0
37659, 7900, 7901, 7924, 7923, 0, 0, 0, 0
37660, 7901, 7902, 7925, 7924, 0, 0, 0, 0
37661, 7902, 7903, 7926, 7925, 0, 0, 0, 0
37662, 7903, 7904, 7927, 7926, 0, 0, 0, 0
37663, 7904, 7905, 7928, 7927, 0, 0, 0, 0
37664, 7905, 7906, 7929, 7928, 0, 0, 0, 0
37665, 7906, 7907, 7930, 7929, 0, 0, 0, 0
37666, 7907, 7908, 7931, 7930, 0, 0, 0, 0
37667, 7908, 7909, 7932, 7931, 0, 0, 0, 0
37668, 7909, 7910, 7933, 7932, 0, 0, 0, 0
37669, 7910, 983, 984, 7933, 0, 0, 0, 0
37670, 824, 7911, 7934, 825, 0, 0, 0, 0
37671, 7911, 7912, 7935, 7934, 0, 0, 0, 0
37672, 7912, 7913, 7936, 7935, 0, 0, 0, 0
37673, 7913, 7914, 7937, 7936, 0, 0, 0, 0
37674, 7914, 7915, 7938, 7937, 0, 0, 0, 0
37675, 7915, 7916, 7939, 7938, 0, 0, 0, 0
37676, 7916, 7917, 7940, 7939, 0, 0, 0, 0
37677, 7917, 7918, 7941, 7940, 0, 0, 0, 0
37678, 7918, 7919, 7942, 7941, 0, 0, 0, 0
37679, 7919, 7920, 7943, 7942, 0, 0, 0, 0
37680, 7920, 7921, 7944, 7943, 0, 0, 0, 0
37681, 7921, 7922, 7945, 7944, 0, 0, 0, 0
37682, 7922, 7923, 7946, 7945, 0, 0, 0, 0
37683, 7923, 7924, 7947, 7946, 0, 0, 0, 0
37684, 7924, 7925, 7948, 7947, 0, 0, 0, 0
37685, 7925, 7926, 7949, 7948, 0, 0, 0, 0
37686, 7926, 7927, 7950, 7949, 0, 0, 0, 0
37687, 7927, 7928, 7951, 7950, 0, 0, 0, 0
37688, 7928, 7929, 7952, 7951, 0, 0, 0, 0
37689, 7929, 7930, 7953, 7952, 0, 0, 0, 0
37690, 7930, 7931, 7954, 7953, 0, 0, 0, 0
37691, 7931, 7932, 7955, 7954, 0, 0, 0, 0
37692, 7932, 7933, 7956, 7955, 0, 0, 0, 0
37693, 7933, 984, 985, 7956, 0, 0, 0, 0
37694, 825, 7934, 7957, 826, 0, 0, 0, 0
37695, 7934, 7935, 7958, 7957, 0, 0, 0, 0
37696, 7935, 7936, 7959, 7958, 0, 0, 0, 0
37697, 7936, 7937, 7960, 7959, 0, 0, 0, 0
37698, 7937, 7938, 7961, 7960, 0, 0, 0, 0
37699, 7938, 7939, 7962, 7961, 0, 0, 0, 0
37700, 7939, 7940, 7963, 7962, 0, 0, 0, 0
37701, 7940, 7941, 7964, 7963, 0, 0, 0, 0
37702, 7941, 7942, 7965, 7964, 0, 0, 0, 0
37703, 7942, 7943, 7966, 7965, 0, 0, 0, 0
37704, 7943, 7944, 7967, 7966, 0, 0, 0, 0
37705, 7944, 7945, 7968, 7967, 0, 0, 0, 0
37706, 7945, 7946, 7969, 7968, 0, 0, 0, 0
37707, 7946, 7947, 7970, 7969, 0, 0, 0, 0
37708, 7947, 7948, 7971, 7970, 0, 0, 0, 0
37709, 7948, 7949, 7972, 7971, 0, 0, 0, 0
37710, 7949, 7950, 7973, 7972, 0, 0, 0, 0
37711, 7950, 7951, 7974, 7973, 0, 0, 0, 0
37712, 7951, 7952, 7975, 7974, 0, 0, 0, 0
37713, 7952, 7953, 7976, 7975, 0, 0, 0, 0
37714, 7953, 7954, 7977, 7976, 0, 0, 0, 0
37715, 7954, 7955, 7978, 7977, 0, 0, 0, 0
37716, 7955, 7956, 7979, 7978, 0, 0, 0, 0
37717, 7956, 985, 986, 7979, 0, 0, 0, 0
37718, 826, 7957, 7980, 827, 0, 0, 0, 0
37719, 7957, 7958, 7981, 7980, 0, 0, 0, 0
37720, 7958, 7959, 7982, 7981, 0, 0, 0, 0
37721, 7959, 7960, 7983, 7982, 0, 0, 0, 0
37722, 7960, 7961, 7984, 7983, 0, 0, 0, 0
37723, 7961, 7962, 7985, 7984, 0, 0, 0, 0
37724, 7962, 7963, 7986, 7985, 0, 0, 0, 0
37725, 7963, 7964, 7987, 7986, 0, 0, 0, 0
37726, 7964, 7965, 7988, 7987, 0, 0, 0, 0
37727, 7965, 7966, 7989, 7988, 0, 0, 0, 0
37728, 7966, 7967, 7990, 7989, 0, 0, 0, 0
37729, 7967, 7968, 7991, 7990, 0, 0, 0, 0
37730, 7968, 7969, 7992, 7991, 0, 0, 0, 0
37731, 7969, 7970, 7993, 7992, 0, 0, 0, 0
37732, 7970, 7971, 7994, 7993, 0, 0, 0, 0
37733, 7971, 7972, 7995, 7994, 0, 0, 0, 0
37734, 7972, 7973, 7996, 7995, 0, 0, 0, 0
37735, 7973, 7974, 7997, 7996, 0, 0, 0, 0
37736, 7974, 7975, 7998, 7997, 0, 0, 0, 0
37737, 7975, 7976, 7999, 7998, 0, 0, 0, 0
37738, 7976, 7977, 8000, 7999, 0, 0, 0, 0
37739, 7977, 7978, 8001, 8000, 0, 0, 0, 0
37740, 7978, 7979, 8002, 8001, 0, 0, 0, 0
37741, 7979, 986, 987, 8002, 0, 0, 0, 0
37742, 827, 7980, 8003, 828, 0, 0, 0, 0
37743, 7980, 7981, 8004, 8003, 0, 0, 0, 0
37744, 7981, 7982, 8005, 8004, 0, 0, 0, 0
37745, 7982, 7983, 8006, 8005, 0, 0, 0, 0
37746, 7983, 7984, 8007, 8006, 0, 0, 0, 0
37747, 7984, 7985, 8008, 8007, 0, 0, 0, 0
37748, 7985, 7986, 8009, 8008, 0, 0, 0, 0
37749, 7986, 7987, 8010, 8009, 0, 0, 0, 0
37750, 7987, 7988, 8011, 8010, 0, 0, 0, 0
37751, 7988, 7989, 8012, 8011, 0, 0, 0, 0
37752, 7989, 7990, 8013, 8012, 0, 0, 0, 0
37753, 7990, 7991, 8014, 8013, 0, 0, 0, 0
37754, 7991, 7992, 8015, 8014, 0, 0, 0, 0
37755, 7992, 7993, 8016, 8015, 0, 0, 0, 0
37756, 7993, 7994, 8017, 8016, 0, 0, 0, 0
37757, 7994, 7995, 8018, 8017, 0, 0, 0, 0
37758, 7995, 7996, 8019, 8018, 0, 0, 0, 0
37759, 7996, 7997, 8020, 8019, 0, 0, 0, 0
37760, 7997, 7998, 8021, 8020, 0, 0, 0, 0
37761, 7998, 7999, 8022, 8021, 0, 0, 0, 0
37762, 7999, 8000, 8023, 8022, 0, 0, 0, 0
37763, 8000, 8001, 8024, 8023, 0, 0, 0, 0
37764, 8001, 8002, 8025, 8024, 0, 0, 0, 0
37765, 8002, 987, 988, 8025, 0, 0, 0, 0
37766, 828, 8003, 8026, 829, 0, 0, 0, 0
37767, 8003, 8004, 8027, 8026, 0, 0, 0, 0
37768, 8004, 8005, 8028, 8027, 0, 0, 0, 0
37769, 8005, 8006, 8029, 8028, 0, 0, 0, 0
37770, 8006, 8007, 8030, 8029, 0, 0, 0, 0
37771, 8007, 8008, 8031, 8030, 0, 0, 0, 0
37772, 8008, 8009, 8032, 8031, 0, 0, 0, 0
37773, 8009, 8010, 8033, 8032, 0, 0, 0, 0
37774, 8010, 8011, 8034, 8033, 0, 0, 0, 0
37775, 8011, 8012, 8035, 8034, 0, 0, 0, 0
37776, 8012, 8013, 8036, 8035, 0, 0, 0, 0
37777, 8013, 8014, 8037, 8036, 0, 0, 0, 0
37778, 8014, 8015, 8038, 8037, 0, 0, 0, 0
37779, 8015, 8016, 8039, 8038, 0, 0, 0, 0
37780, 8016, 8017, 8040, 8039, 0, 0, 0, 0
37781, 8017, 8018, 8041, 8040, 0, 0, 0, 0
37782, 8018, 8019, 8042, 8041, 0, 0, 0, 0
37783, 8019, 8020, 8043, 8042, 0, 0, 0, 0
37784, 8020, 8021, 8044, 8043, 0, 0, 0, 0
37785, 8021, 8022, 8045, 8044, 0, 0, 0, 0
37786, 8022, 8023, 8046, 8045, 0, 0, 0, 0
37787, 8023, 8024, 8047, 8046, 0, 0, 0, 0
37788, 8024, 8025, 8048, 8047, 0, 0, 0, 0
37789, 8025, 988, 989, 8048, 0, 0, 0, 0
37790, 829, 8026, 8049, 830, 0, 0, 0, 0
37791, 8026, 8027, 8050, 8049, 0, 0, 0, 0
37792, 8027, 8028, 8051, 8050, 0, 0, 0, 0
37793, 8028, 8029, 8052, 8051, 0, 0, 0, 0
37794, 8029, 8030, 8053, 8052, 0, 0, 0, 0
37795, 8030, 8031, 8054, 8053, 0, 0, 0, 0
37796, 8031, 8032, 8055, 8054, 0, 0, 0, 0
37797, 8032, 8033, 8056, 8055, 0, 0, 0, 0
37798, 8033, 8034, 8057, 8056, 0, 0, 0, 0
37799, 8034, 8035, 8058, 8057, 0, 0, 0, 0
37800, 8035, 8036, 8059, 8058, 0, 0, 0, 0
37801, 8036, 8037, 8060, 8059, 0, 0, 0, 0
37802, 8037, 8038, 8061, 8060, 0, 0, 0, 0
37803, 8038, 8039, 8062, 8061, 0, 0, 0, 0
37804, 8039, 8040, 8063, 8062, 0, 0, 0, 0
37805, 8040, 8041, 8064, 8063, 0, 0, 0, 0
37806, 8041, 8042, 8065, 8064, 0, 0, 0, 0
37807, 8042, 8043, 8066, 8065, 0, 0, 0, 0
37808, 8043, 8044, 8067, 8066, 0, 0, 0, 0
37809, 8044, 8045, 8068, 8067, 0, 0, 0, 0
37810, 8045, 8046, 8069, 8068, 0, 0, 0, 0
37811, 8046, 8047, 8070, 8069, 0, 0, 0, 0
37812, 8047, 8048, 8071, 8070, 0, 0, 0, 0
37813, 8048, 989, 990, 8071, 0, 0, 0, 0
37814, 830, 8049, 842, 33, 0, 0, 0, 0
37815, 8049, 8050, 843, 842, 0, 0, 0, 0
37816, 8050, 8051, 844, 843, 0, 0, 0, 0
37817, 8051, 8052, 845, 844, 0, 0, 0, 0
37818, 8052, 8053, 846, 845, 0, 0, 0, 0
37819, 8053, 8054, 847, 846, 0, 0, 0, 0
37820, 8054, 8055, 848, 847, 0, 0, 0, 0
37821, 8055, 8056, 849, 848, 0, 0, 0, 0
37822, 8056, 8057, 850, 849, 0, 0, 0, 0
37823, 8057, 8058, 851, 850, 0, 0, 0, 0
37824, 8058, 8059, 852, 851, 0, 0, 0, 0
37825, 8059, 8060, 853, 852, 0, 0, 0, 0
37826, 8060, 8061, 854, 853, 0, 0, 0, 0
37827, 8061, 8062, 855, 854, 0, 0, 0, 0
37828, 8062, 8063, 856, 855, 0, 0, 0, 0
37829, 8063, 8064, 857, 856, 0, 0, 0, 0
37830, 8064, 8065, 858, 857, 0, 0, 0, 0
37831, 8065, 8066, 859, 858, 0, 0, 0, 0
37832, 8066, 8067, 860, 859, 0, 0, 0, 0
37833, 8067, 8068, 861, 860, 0, 0, 0, 0
37834, 8068, 8069, 862, 861, 0, 0, 0, 0
37835, 8069, 8070, 863, 862, 0, 0, 0, 0
37836, 8070, 8071, 864, 863, 0, 0, 0, 0
37837, 8071, 990, 37, 864, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface45
37838, 36, 831, 8072, 934, 0, 0, 0, 0
37839, 934, 8072, 8073, 935, 0, 0, 0, 0
37840, 935, 8073, 8074, 936, 0, 0, 0, 0
37841, 936, 8074, 8075, 937, 0, 0, 0, 0
37842, 937, 8075, 8076, 938, 0, 0, 0, 0
37843, 938, 8076, 8077, 939, 0, 0, 0, 0
37844, 939, 8077, 8078, 940, 0, 0, 0, 0
37845, 940, 8078, 8079, 941, 0, 0, 0, 0
37846, 941, 8079, 8080, 942, 0, 0, 0, 0
37847, 942, 8080, 8081, 943, 0, 0, 0, 0
37848, 943, 8081, 8082, 944, 0, 0, 0, 0
37849, 944, 8082, 8083, 945, 0, 0, 0, 0
37850, 945, 8083, 8084, 946, 0, 0, 0, 0
37851, 946, 8084, 8085, 947, 0, 0, 0, 0
37852, 947, 8085, 8086, 948, 0, 0, 0, 0
37853, 948, 8086, 8087, 949, 0, 0, 0, 0
37854, 949, 8087, 8088, 950, 0, 0, 0, 0
37855, 950, 8088, 8089, 951, 0, 0, 0, 0
37856, 951, 8089, 8090, 952, 0, 0, 0, 0
37857, 952, 8090, 8091, 953, 0, 0, 0, 0
37858, 953, 8091, 8092, 954, 0, 0, 0, 0
37859, 954, 8092, 8093, 955, 0, 0, 0, 0
37860, 955, 8093, 8094, 956, 0, 0, 0, 0
37861, 956, 8094, 991, 40, 0, 0, 0, 0
37862, 831, 832, 8095, 8072, 0, 0, 0, 0
37863, 8072, 8095, 8096, 8073, 0, 0, 0, 0
37864, 8073, 8096, 8097, 8074, 0, 0, 0, 0
37865, 8074, 8097, 8098, 8075, 0, 0, 0, 0
37866, 8075, 8098, 8099, 8076, 0, 0, 0, 0
37867, 8076, 8099, 8100, 8077, 0, 0, 0, 0
37868, 8077, 8100, 8101, 8078, 0, 0, 0, 0
37869, 8078, 8101, 8102, 8079, 0, 0, 0, 0
37870, 8079, 8102, 8103, 8080, 0, 0, 0, 0
37871, 8080, 8103, 8104, 8081, 0, 0, 0, 0
37872, 8081, 8104, 8105, 8082, 0, 0, 0, 0
37873, 8082, 8105, 8106, 8083, 0, 0, 0, 0
37874, 8083, 8106, 8107, 8084, 0, 0, 0, 0
37875, 8084, 8107, 8108, 8085, 0, 0, 0, 0
37876, 8085, 8108, 8109, 8086, 0, 0, 0, 0
37877, 8086, 8109, 8110, 8087, 0, 0, 0, 0
37878, 8087, 8110, 8111, 8088, 0, 0, 0, 0
37879, 8088, 8111, 8112, 8089, 0, 0, 0, 0
37880, 8089, 8112, 8113, 8090, 0, 0, 0, 0
37881, 8090, 8113, 8114, 8091, 0, 0, 0, 0
37882, 8091, 8114, 8115, 8092, 0, 0, 0, 0
37883, 8092, 8115, 8116, 8093, 0, 0, 0, 0
37884, 8093, 8116, 8117, 8094, 0, 0, 0, 0
37885, 8094, 8117, 992, 991, 0, 0, 0, 0
37886, 832, 833, 8118, 8095, 0, 0, 0, 0
37887, 8095, 8118, 8119, 8096, 0, 0, 0, 0
37888, 8096, 8119, 8120, 8097, 0, 0, 0, 0
37889, 8097, 8120, 8121, 8098, 0, 0, 0, 0
37890, 8098, 8121, 8122, 8099, 0, 0, 0, 0
37891, 8099, 8122, 8123, 8100, 0, 0, 0, 0
37892, 8100, 8123, 8124, 8101, 0, 0, 0, 0
37893, 8101, 8124, 8125, 8102, 0, 0, 0, 0
37894, 8102, 8125, 8126, 8103, 0, 0, 0, 0
37895, 8103, 8126, 8127, 8104, 0, 0, 0, 0
37896, 8104, 8127, 8128, 8105, 0, 0, 0, 0
37897, 8105, 8128, 8129, 8106, 0, 0, 0, 0
37898, 8106, 8129, 8130, 8107, 0, 0, 0, 0
37899, 8107, 8130, 8131, 8108, 0, 0, 0, 0
37900, 8108, 8131, 8132, 8109, 0, 0, 0, 0
37901, 8109, 8132, 8133, 8110, 0, 0, 0, 0
37902, 8110, 8133, 8134, 8111, 0, 0, 0, 0
37903, 8111, 8134, 8135, 8112, 0, 0, 0, 0
37904, 8112, 8135, 8136, 8113, 0, 0, 0, 0
37905, 8113, 8136, 8137, 8114, 0, 0, 0, 0
37906, 8114, 8137, 8138, 8115, 0, 0, 0, 0
37907, 8115, 8138, 8139, 8116, 0, 0, 0, 0
37908, 8116, 8139, 8140, 8117, 0, 0, 0, 0
37909, 8117, 8140, 993, 992, 0, 0, 0, 0
37910, 833, 834, 8141, 8118, 0, 0, 0, 0
37911, 8118, 8141, 8142, 8119, 0, 0, 0, 0
37912, 8119, 8142, 8143, 8120, 0, 0, 0, 0
37913, 8120, 8143, 8144, 8121, 0, 0, 0, 0
37914, 8121, 8144, 8145, 8122, 0, 0, 0, 0
37915, 8122, 8145, 8146, 8123, 0, 0, 0, 0
37916, 8123, 8146, 8147, 8124, 0, 0, 0, 0
37917, 8124, 8147, 8148, 8125, 0, 0, 0, 0
37918, 8125, 8148, 8149, 8126, 0, 0, 0, 0
37919, 8126, 8149, 8150, 8127, 0, 0, 0, 0
37920, 8127, 8150, 8151, 8128, 0, 0, 0, 0
37921, 8128, 8151, 8152, 8129, 0, 0, 0, 0
37922, 8129, 8152, 8153, 8130, 0, 0, 0, 0
37923, 8130, 8153, 8154, 8131, 0, 0, 0, 0
37924, 8131, 8154, 8155, 8132, 0, 0, 0, 0
37925, 8132, 8155, 8156, 8133, 0, 0, 0, 0
37926, 8133, 8156, 8157, 8134, 0, 0, 0, 0
37927, 8134, 8157, 8158, 8135, 0, 0, 0, 0
37928, 8135, 8158, 8159, 8136, 0, 0, 0, 0
37929, 8136, 8159, 8160, 8137, 0, 0, 0, 0
37930, 8137, 8160, 8161, 8138, 0, 0, 0, 0
37931, 8138, 8161, 8162, 8139, 0, 0, 0, 0
37932, 8139, 8162, 8163, 8140, 0, 0, 0, 0
37933, 8140, 8163, 994, 993, 0, 0, 0, 0
37934, 834, 835, 8164, 8141, 0, 0, 0, 0
37935, 8141, 8164, 8165, 8142, 0, 0, 0, 0
37936, 8142, 8165, 8166, 8143, 0, 0, 0, 0
37937, 8143, 8166, 8167, 8144, 0, 0, 0, 0
37938, 8144, 8167, 8168, 8145, 0, 0, 0, 0
37939, 8145, 8168, 8169, 8146, 0, 0, 0, 0
37940, 8146, 8169, 8170, 8147, 0, 0, 0, 0
37941, 8147, 8170, 8171, 8148, 0, 0, 0, 0
37942, 8148, 8171, 8172, 8149, 0, 0, 0, 0
37943, 8149, 8172, 8173, 8150, 0, 0, 0, 0
37944, 8150, 8173, 8174, 8151, 0, 0, 0, 0
37945, 8151, 8174, 8175, 8152, 0, 0, 0, 0
37946, 8152, 8175, 8176, 8153, 0, 0, 0, 0
37947, 8153, 8176, 8177, 8154, 0, 0, 0, 0
37948, 8154, 8177, 8178, 8155, 0, 0, 0, 0
37949, 8155, 8178, 8179, 8156, 0, 0, 0, 0
37950, 8156, 8179, 8180, 8157, 0, 0, 0, 0
37951, 8157, 8180, 8181, 8158, 0, 0, 0, 0
37952, 8158, 8181, 8182, 8159, 0, 0, 0, 0
37953, 8159, 8182, 8183, 8160, 0, 0, 0, 0
37954, 8160, 8183, 8184, 8161, 0, 0, 0, 0
37955, 8161, 8184, 8185, 8162, 0, 0, 0, 0
37956, 8162, 8185, 8186, 8163, 0, 0, 0, 0
37957, 8163, 8186, 995, 994, 0, 0, 0, 0
37958, 835, 836, 8187, 8164, 0, 0, 0, 0
37959, 8164, 8187, 8188, 8165, 0, 0, 0, 0
37960, 8165, 8188, 8189, 8166, 0, 0, 0, 0
37961, 8166, 8189, 8190, 8167, 0, 0, 0, 0
37962, 8167, 8190, 8191, 8168, 0, 0, 0, 0
37963, 8168, 8191, 8192, 8169, 0, 0, 0, 0
37964, 8169, 8192, 8193, 8170, 0, 0, 0, 0
37965, 8170, 8193, 8194, 8171, 0, 0, 0, 0
37966, 8171, 8194, 8195, 8172, 0, 0, 0, 0
37967, 8172, 8195, 8196, 8173, 0, 0, 0, 0
37968, 8173, 8196, 8197, 8174, 0, 0, 0, 0
37969, 8174, 8197, 8198, 8175, 0, 0, 0, 0
37970, 8175, 8198, 8199, 8176, 0, 0, 0, 0
37971, 8176, 8199, 8200, 8177, 0, 0, 0, 0
37972, 8177, 8200, 8201, 8178, 0, 0, 0, 0
37973, 8178, 8201, 8202, 8179, 0, 0, 0, 0
37974, 8179, 8202, 8203, 8180, 0, 0, 0, 0
37975, 8180, 8203, 8204, 8181, 0, 0, 0, 0
37976, 8181, 8204, 8205, 8182, 0, 0, 0, 0
37977, 8182, 8205, 8206, 8183, 0, 0, 0, 0
37978, 8183, 8206, 8207, 8184, 0, 0, 0, 0
37979, 8184, 8207, 8208, 8185, 0, 0, 0, 0
37980, 8185, 8208, 8209, 8186, 0, 0, 0, 0
37981, 8186, 8209, 996, 995, 0, 0, 0, 0
37982, 836, 837, 8210, 8187, 0, 0, 0, 0
37983, 8187, 8210, 8211, 8188, 0, 0, 0, 0
37984, 8188, 8211, 8212, 8189, 0, 0, 0, 0
37985, 8189, 8212, 8213, 8190, 0, 0, 0, 0
37986, 8190, 8213, 8214, 8191, 0, 0, 0, 0
37987, 8191, 8214, 8215, 8192, 0, 0, 0, 0
37988, 8192, 8215, 8216, 8193, 0, 0, 0, 0
37989, 8193, 8216, 8217, 8194, 0, 0, 0, 0
37990, 8194, 8217, 8218, 8195, 0, 0, 0, 0
37991, 8195, 8218, 8219, 8196, 0, 0, 0, 0
37992, 8196, 8219, 8220, 8197, 0, 0, 0, 0
37993, 8197, 8220, 8221, 8198, 0, 0, 0, 0
37994, 8198, 8221, 8222, 8199, 0, 0, 0, 0
37995, 8199, 8222, 8223, 8200, 0, 0, 0, 0
37996, 8200, 8223, 8224, 8201, 0, 0, 0, 0
37997, 8201, 8224, 8225, 8202, 0, 0, 0, 0
37998, 8202, 8225, 8226, 8203, 0, 0, 0, 0
37999, 8203, 8226, 8227, 8204, 0, 0, 0, 0
38000, 8204, 8227, 8228, 8205, 0, 0, 0, 0
38001, 8205, 8228, 8229, 8206, 0, 0, 0, 0
38002, 8206, 8229, 8230, 8207, 0, 0, 0, 0
38003, 8207, 8230, 8231, 8208, 0, 0, 0, 0
38004, 8208, 8231, 8232, 8209, 0, 0, 0, 0
38005, 8209, 8232, 997, 996, 0, 0, 0, 0
38006, 837, 838, 8233, 8210, 0, 0, 0, 0
38007, 8210, 8233, 8234, 8211, 0, 0, 0, 0
38008, 8211, 8234, 8235, 8212, 0, 0, 0, 0
38009, 8212, 8235, 8236, 8213, 0, 0, 0, 0
38010, 8213, 8236, 8237, 8214, 0, 0, 0, 0
38011, 8214, 8237, 8238, 8215, 0, 0, 0, 0
38012, 8215, 8238, 8239, 8216, 0, 0, 0, 0
38013, 8216, 8239, 8240, 8217, 0, 0, 0, 0
38014, 8217, 8240, 8241, 8218, 0, 0, 0, 0
38015, 8218, 8241, 8242, 8219, 0, 0, 0, 0
38016, 8219, 8242, 8243, 8220, 0, 0, 0, 0
38017, 8220, 8243, 8244, 8221, 0, 0, 0, 0
38018, 8221, 8244, 8245, 8222, 0, 0, 0, 0
38019, 8222, 8245, 8246, 8223, 0, 0, 0, 0
38020, 8223, 8246, 8247, 8224, 0, 0, 0, 0
38021, 8224, 8247, 8248, 8225, 0, 0, 0, 0
38022, 8225, 8248, 8249, 8226, 0, 0, 0, 0
38023, 8226, 8249, 8250, 8227, 0, 0, 0, 0
38024, 8227, 8250, 8251, 8228, 0, 0, 0, 0
38025, 8228, 8251, 8252, 8229, 0, 0, 0, 0
38026, 8229, 8252, 8253, 8230, 0, 0, 0, 0
38027, 8230, 8253, 8254, 8231, 0, 0, 0, 0
38028, 8231, 8254, 8255, 8232, 0, 0, 0, 0
38029, 8232, 8255, 998, 997, 0, 0, 0, 0
38030, 838, 839, 8256, 8233, 0, 0, 0, 0
38031, 8233, 8256, 8257, 8234, 0, 0, 0, 0
38032, 8234, 8257, 8258, 8235, 0, 0, 0, 0
38033, 8235, 8258, 8259, 8236, 0, 0, 0, 0
38034, 8236, 8259, 8260, 8237, 0, 0, 0, 0
38035, 8237, 8260, 8261, 8238, 0, 0, 0, 0
38036, 8238, 8261, 8262, 8239, 0, 0, 0, 0
38037, 8239, 8262, 8263, 8240, 0, 0, 0, 0
38038, 8240, 8263, 8264, 8241, 0, 0, 0, 0
38039, 8241, 8264, 8265, 8242, 0, 0, 0, 0
38040, 8242, 8265, 8266, 8243, 0, 0, 0, 0
38041, 8243, 8266, 8267, 8244, 0, 0, 0, 0
38042, 8244, 8267, 8268, 8245, 0, 0, 0, 0
38043, 8245, 8268, 8269, 8246, 0, 0, 0, 0
38044, 8246, 8269, 8270, 8247, 0, 0, 0, 0
38045, 8247, 8270, 8271, 8248, 0, 0, 0, 0
38046, 8248, 8271, 8272, 8249, 0, 0, 0, 0
38047, 8249, 8272, 8273, 8250, 0, 0, 0, 0
38048, 8250, 8273, 8274, 8251, 0, 0, 0, 0
38049, 8251, 8274, 8275, 8252, 0, 0, 0, 0
38050, 8252, 8275, 8276, 8253, 0, 0, 0, 0
38051, 8253, 8276, 8277, 8254, 0, 0, 0, 0
38052, 8254, 8277, 8278, 8255, 0, 0, 0, 0
38053, 8255, 8278, 999, 998, 0, 0, 0, 0
38054, 839, 840, 8279, 8256, 0, 0, 0, 0
38055, 8256, 8279, 8280, 8257, 0, 0, 0, 0
38056, 8257, 8280, 8281, 8258, 0, 0, 0, 0
38057, 8258, 8281, 8282, 8259, 0, 0, 0, 0
38058, 8259, 8282, 8283, 8260, 0, 0, 0, 0
38059, 8260, 8283, 8284, 8261, 0, 0, 0, 0
38060, 8261, 8284, 8285, 8262, 0, 0, 0, 0
38061, 8262, 8285, 8286, 8263, 0, 0, 0, 0
38062, 8263, 8286, 8287, 8264, 0, 0, 0, 0
38063, 8264, 8287, 8288, 8265, 0, 0, 0, 0
38064, 8265, 8288, 8289, 8266, 0, 0, 0, 0
38065, 8266, 8289, 8290, 8267, 0, 0, 0, 0
38066, 8267, 8290, 8291, 8268, 0, 0, 0, 0
38067, 8268, 8291, 8292, 8269, 0, 0, 0, 0
38068, 8269, 8292, 8293, 8270, 0, 0, 0, 0
38069, 8270, 8293, 8294, 8271, 0, 0, 0, 0
38070, 8271, 8294, 8295, 8272, 0, 0, 0, 0
38071, 8272, 8295, 8296, 8273, 0, 0, 0, 0
38072, 8273, 8296, 8297, 8274, 0, 0, 0, 0
38073, 8274, 8297, 8298, 8275, 0, 0, 0, 0
38074, 8275, 8298, 8299, 8276, 0, 0, 0, 0
38075, 8276, 8299, 8300, 8277, 0, 0, 0, 0
38076, 8277, 8300, 8301, 8278, 0, 0, 0, 0
38077, 8278, 8301, 1000, 999, 0, 0, 0, 0
38078, 840, 841, 8302, 8279, 0, 0, 0, 0
38079, 8279, 8302, 8303, 8280, 0, 0, 0, 0
38080, 8280, 8303, 8304, 8281, 0, 0, 0, 0
38081, 8281, 8304, 8305, 8282, 0, 0, 0, 0
38082, 8282, 8305, 8306, 8283, 0, 0, 0, 0
38083, 8283, 8306, 8307, 8284, 0, 0, 0, 0
38084, 8284, 8307, 8308, 8285, 0, 0, 0, 0
38085, 8285, 8308, 8309, 8286, 0, 0, 0, 0
38086, 8286, 8309, 8310, 8287, 0, 0, 0, 0
38087, 8287, 8310, 8311, 8288, 0, 0, 0, 0
38088, 8288, 8311, 8312, 8289, 0, 0, 0, 0
38089, 8289, 8312, 8313, 8290, 0, 0, 0, 0
38090, 8290, 8313, 8314, 8291, 0, 0, 0, 0
38091, 8291, 8314, 8315, 8292, 0, 0, 0, 0
38092, 8292, 8315, 8316, 8293, 0, 0, 0, 0
38093, 8293, 8316, 8317, 8294, 0, 0, 0, 0
38094, 8294, 8317, 8318, 8295, 0, 0, 0, 0
38095, 8295, 8318, 8319, 8296, 0, 0, 0, 0
38096, 8296, 8319, 8320, 8297, 0, 0, 0, 0
38097, 8297, 8320, 8321, 8298, 0, 0, 0, 0
38098, 8298, 8321, 8322, 8299, 0, 0, 0, 0
38099, 8299, 8322, 8323, 8300, 0, 0, 0, 0
38100, 8300, 8323, 8324, 8301, 0, 0, 0, 0
38101, 8301, 8324, 1001, 1000, 0, 0, 0, 0
38102, 841, 34, 865, 8302, 0, 0, 0, 0
38103, 8302, 865, 866, 8303, 0, 0, 0, 0
38104, 8303, 866, 867, 8304, 0, 0, 0, 0
38105, 8304, 867, 868, 8305, 0, 0, 0, 0
38106, 8305, 868, 869, 8306, 0, 0, 0, 0
38107, 8306, 869, 870, 8307, 0, 0, 0, 0
38108, 8307, 870, 871, 8308, 0, 0, 0, 0
38109, 8308, 871, 872, 8309, 0, 0, 0, 0
38110, 8309, 872, 873, 8310, 0, 0, 0, 0
38111, 8310, 873, 874, 8311, 0, 0, 0, 0
38112, 8311, 874, 875, 8312, 0, 0, 0, 0
38113, 8312, 875, 876, 8313, 0, 0, 0, 0
38114, 8313, 876, 877, 8314, 0, 0, 0, 0
38115, 8314, 877, 878, 8315, 0, 0, 0, 0
38116, 8315, 878, 879, 8316, 0, 0, 0, 0
38117, 8316, 879, 880, 8317, 0, 0, 0, 0
38118, 8317, 880, 881, 8318, 0, 0, 0, 0
38119, 8318, 881, 882, 8319, 0, 0, 0, 0
38120, 8319, 882, 883, 8320, 0, 0, 0, 0
38121, 8320, 883, 884, 8321, 0, 0, 0, 0
38122, 8321, 884, 885, 8322, 0, 0, 0, 0
38123, 8322, 885, 886, 8323, 0, 0, 0, 0
38124, 8323, 886, 887, 8324, 0, 0, 0, 0
38125, 8324, 887, 38, 1001, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface46
38126, 39, 957, 8325, 980, 0, 0, 0, 0
38127, 957, 958, 8326, 8325, 0, 0, 0, 0
38128, 958, 959, 8327, 8326, 0, 0, 0, 0
38129, 959, 960, 8328, 8327, 0, 0, 0, 0
38130, 960, 961, 8329, 8328, 0, 0, 0, 0
38131, 961, 962, 8330, 8329, 0, 0, 0, 0
38132, 962, 963, 8331, 8330, 0, 0, 0, 0
38133, 963, 964, 8332, 8331, 0, 0, 0, 0
38134, 964, 965, 8333, 8332, 0, 0, 0, 0
38135, 965, 966, 8334, 8333, 0, 0, 0, 0
38136, 966, 967, 8335, 8334, 0, 0, 0, 0
38137, 967, 968, 8336, 8335, 0, 0, 0, 0
38138, 968, 969, 8337, 8336, 0, 0, 0, 0
38139, 969, 970, 8338, 8337, 0, 0, 0, 0
38140, 970, 971, 8339, 8338, 0, 0, 0, 0
38141, 971, 972, 8340, 8339, 0, 0, 0, 0
38142, 972, 973, 8341, 8340, 0, 0, 0, 0
38143, 973, 974, 8342, 8341, 0, 0, 0, 0
38144, 974, 975, 8343, 8342, 0, 0, 0, 0
38145, 975, 976, 8344, 8343, 0, 0, 0, 0
38146, 976, 977, 8345, 8344, 0, 0, 0, 0
38147, 977, 978, 8346, 8345, 0, 0, 0, 0
38148, 978, 979, 8347, 8346, 0, 0, 0, 0
38149, 979, 40, 991, 8347, 0, 0, 0, 0
38150, 980, 8325, 8348, 981, 0, 0, 0, 0
38151, 8325, 8326, 8349, 8348, 0, 0, 0, 0
38152, 8326, 8327, 8350, 8349, 0, 0, 0, 0
38153, 8327, 8328, 8351, 8350, 0, 0, 0, 0
38154, 8328, 8329, 8352, 8351, 0, 0, 0, 0
38155, 8329, 8330, 8353, 8352, 0, 0, 0, 0
38156, 8330, 8331, 8354, 8353, 0, 0, 0, 0
38157, 8331, 8332, 8355, 8354, 0, 0, 0, 0
38158, 8332, 8333, 8356, 8355, 0, 0, 0, 0
38159, 8333, 8334, 8357, 8356, 0, 0, 0, 0
38160, 8334, 8335, 8358, 8357, 0, 0, 0, 0
38161, 8335, 8336, 8359, 8358, 0, 0, 0, 0
38162, 8336, 8337, 8360, 8359, 0, 0, 0, 0
38163, 8337, 8338, 8361, 8360, 0, 0, 0, 0
38164, 8338, 8339, 8362, 8361, 0, 0, 0, 0
38165, 8339, 8340, 8363, 8362, 0, 0, 0, 0
38166, 8340, 8341, 8364, 8363, 0, 0, 0, 0
38167, 8341, 8342, 8365, 8364, 0, 0, 0, 0
38168, 8342, 8343, 8366, 8365, 0, 0, 0, 0
38169, 8343, 8344, 8367, 8366, 0, 0, 0, 0
38170, 8344, 8345, 8368, 8367, 0, 0, 0, 0
38171, 8345, 8346, 8369, 8368, 0, 0, 0, 0
38172, 8346, 8347, 8370, 8369, 0, 0, 0, 0
38173, 8347, 991, 992, 8370, 0, 0, 0, 0
38174, 981, 8348, 8371, 982, 0, 0, 0, 0
38175, 8348, 8349, 8372, 8371, 0, 0, 0, 0
38176, 8349, 8350, 8373, 8372, 0, 0, 0, 0
38177, 8350, 8351, 8374, 8373, 0, 0, 0, 0
38178, 8351, 8352, 8375, 8374, 0, 0, 0, 0
38179, 8352, 8353, 8376, 8375, 0, 0, 0, 0
38180, 8353, 8354, 8377, 8376, 0, 0, 0, 0
38181, 8354, 8355, 8378, 8377, 0, 0, 0, 0
38182, 8355, 8356, 8379, 8378, 0, 0, 0, 0
38183, 8356, 8357, 8380, 8379, 0, 0, 0, 0
38184, 8357, 8358, 8381, 8380, 0, 0, 0, 0
38185, 8358, 8359, 8382, 8381, 0, 0, 0, 0
38186, 8359, 8360, 8383, 8382, 0, 0, 0, 0
38187, 8360, 8361, 8384, 8383, 0, 0, 0, 0
38188, 8361, 8362, 8385, 8384, 0, 0, 0, 0
38189, 8362, 8363, 8386, 8385, 0, 0, 0, 0
38190, 8363, 8364, 8387, 8386, 0, 0, 0, 0
38191, 8364, 8365, 8388, 8387, 0, 0, 0, 0
38192, 8365, 8366, 8389, 8388, 0, 0, 0, 0
38193, 8366, 8367, 8390, 8389, 0, 0, 0, 0
38194, 8367, 8368, 8391, 8390, 0, 0, 0, 0
38195, 8368, 8369, 8392, 8391, 0, 0, 0, 0
38196, 8369, 8370, 8393, 8392, 0, 0, 0, 0
38197, 8370, 992, 993, 8393, 0, 0, 0, 0
38198, 982, 8371, 8394, 983, 0, 0, 0, 0
38199, 8371, 8372, 8395, 8394, 0, 0, 0, 0
38200, 8372, 8373, 8396, 8395, 0, 0, 0, 0
38201, 8373, 8374, 8397, 8396, 0, 0, 0, 0
38202, 8374, 8375, 8398, 8397, 0, 0, 0, 0
38203, 8375, 8376, 8399, 8398, 0, 0, 0, 0
38204, 8376, 8377, 8400, 8399, 0, 0, 0, 0
38205, 8377, 8378, 8401, 8400, 0, 0, 0, 0
38206, 8378, 8379, 8402, 8401, 0, 0, 0, 0
38207, 8379, 8380, 8403, 8402, 0, 0, 0, 0
38208, 8380, 8381, 8404, 8403, 0, 0, 0, 0
38209, 8381, 8382, 8405, 8404, 0, 0, 0, 0
38210, 8382, 8383, 8406, 8405, 0, 0, 0, 0
38211, 8383, 8384, 8407, 8406, 0, 0, 0, 0
38212, 8384, 8385, 8408, 8407, 0, 0, 0, 0
38213, 8385, 8386, 8409, 8408, 0, 0, 0, 0
38214, 8386, 8387, 8410, 8409, 0, 0, 0, 0
38215, 8387, 8388, 8411, 8410, 0, 0, 0, 0
38216, 8388, 8389, 8412, 8411, 0, 0, 0, 0
38217, 8389, 8390, 8413, 8412, 0, 0, 0, 0
38218, 8390, 8391, 8414, 8413, 0, 0, 0, 0
38219, 8391, 8392, 8415, 8414, 0, 0, 0, 0
38220, 8392, 8393, 8416, 8415, 0, 0, 0, 0
38221, 8393, 993, 994, 8416, 0, 0, 0, 0
38222, 983, 8394, 8417, 984, 0, 0, 0, 0
