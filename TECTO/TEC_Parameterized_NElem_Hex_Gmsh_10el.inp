43995, 43981, 44284, 44297, 43994
28012, 42439, 42531, 42535, 42443, 42440, 42532, 42536, 42444, 44286, 44298, 44299, 43995, 44289, 44301, 44302, 
43998, 43984, 44287, 44300, 43997
28013, 42440, 42532, 42536, 42444, 42441, 42533, 42537, 42445, 44289, 44301, 44302, 43998, 44292, 44304, 44305, 
44001, 43987, 44290, 44303, 44000
28014, 42441, 42533, 42537, 42445, 42442, 42534, 42538, 42446, 44292, 44304, 44305, 44001, 44295, 44307, 44308, 
44004, 43990, 44293, 44306, 44003
28015, 42442, 42534, 42538, 42446, 17103, 17126, 17127, 17104, 44295, 44307, 44308, 44004, 0, 0, 0, 
0, 43993, 44296, 44309, 44006
28016, 6292, 6315, 6316, 6293, 42443, 42535, 42539, 42447, 0, 0, 0, 0, 44299, 44311, 44312, 
44008, 43994, 44297, 44310, 44007
28017, 42443, 42535, 42539, 42447, 42444, 42536, 42540, 42448, 44299, 44311, 44312, 44008, 44302, 44314, 44315, 
44011, 43997, 44300, 44313, 44010
28018, 42444, 42536, 42540, 42448, 42445, 42537, 42541, 42449, 44302, 44314, 44315, 44011, 44305, 44317, 44318, 
44014, 44000, 44303, 44316, 44013
28019, 42445, 42537, 42541, 42449, 42446, 42538, 42542, 42450, 44305, 44317, 44318, 44014, 44308, 44320, 44321, 
44017, 44003, 44306, 44319, 44016
28020, 42446, 42538, 42542, 42450, 17104, 17127, 17128, 17105, 44308, 44320, 44321, 44017, 0, 0, 0, 
0, 44006, 44309, 44322, 44019
28021, 6293, 6316, 6317, 6294, 42447, 42539, 42543, 42451, 0, 0, 0, 0, 44312, 44324, 44325, 
44021, 44007, 44310, 44323, 44020
28022, 42447, 42539, 42543, 42451, 42448, 42540, 42544, 42452, 44312, 44324, 44325, 44021, 44315, 44327, 44328, 
44024, 44010, 44313, 44326, 44023
28023, 42448, 42540, 42544, 42452, 42449, 42541, 42545, 42453, 44315, 44327, 44328, 44024, 44318, 44330, 44331, 
44027, 44013, 44316, 44329, 44026
28024, 42449, 42541, 42545, 42453, 42450, 42542, 42546, 42454, 44318, 44330, 44331, 44027, 44321, 44333, 44334, 
44030, 44016, 44319, 44332, 44029
28025, 42450, 42542, 42546, 42454, 17105, 17128, 17129, 17106, 44321, 44333, 44334, 44030, 0, 0, 0, 
0, 44019, 44322, 44335, 44032
28026, 6294, 6317, 6318, 6295, 42451, 42543, 42547, 42455, 0, 0, 0, 0, 44325, 44337, 44338, 
44034, 44020, 44323, 44336, 44033
28027, 42451, 42543, 42547, 42455, 42452, 42544, 42548, 42456, 44325, 44337, 44338, 44034, 44328, 44340, 44341, 
44037, 44023, 44326, 44339, 44036
28028, 42452, 42544, 42548, 42456, 42453, 42545, 42549, 42457, 44328, 44340, 44341, 44037, 44331, 44343, 44344, 
44040, 44026, 44329, 44342, 44039
28029, 42453, 42545, 42549, 42457, 42454, 42546, 42550, 42458, 44331, 44343, 44344, 44040, 44334, 44346, 44347, 
44043, 44029, 44332, 44345, 44042
28030, 42454, 42546, 42550, 42458, 17106, 17129, 17130, 17107, 44334, 44346, 44347, 44043, 0, 0, 0, 
0, 44032, 44335, 44348, 44045
28031, 6295, 6318, 6319, 6296, 42455, 42547, 42551, 42459, 0, 0, 0, 0, 44338, 44350, 44351, 
44047, 44033, 44336, 44349, 44046
28032, 42455, 42547, 42551, 42459, 42456, 42548, 42552, 42460, 44338, 44350, 44351, 44047, 44341, 44353, 44354, 
44050, 44036, 44339, 44352, 44049
28033, 42456, 42548, 42552, 42460, 42457, 42549, 42553, 42461, 44341, 44353, 44354, 44050, 44344, 44356, 44357, 
44053, 44039, 44342, 44355, 44052
28034, 42457, 42549, 42553, 42461, 42458, 42550, 42554, 42462, 44344, 44356, 44357, 44053, 44347, 44359, 44360, 
44056, 44042, 44345, 44358, 44055
28035, 42458, 42550, 42554, 42462, 17107, 17130, 17131, 17108, 44347, 44359, 44360, 44056, 0, 0, 0, 
0, 44045, 44348, 44361, 44058
28036, 6296, 6319, 6320, 6297, 42459, 42551, 42555, 42463, 0, 0, 0, 0, 44351, 44363, 44364, 
44060, 44046, 44349, 44362, 44059
28037, 42459, 42551, 42555, 42463, 42460, 42552, 42556, 42464, 44351, 44363, 44364, 44060, 44354, 44366, 44367, 
44063, 44049, 44352, 44365, 44062
28038, 42460, 42552, 42556, 42464, 42461, 42553, 42557, 42465, 44354, 44366, 44367, 44063, 44357, 44369, 44370, 
44066, 44052, 44355, 44368, 44065
28039, 42461, 42553, 42557, 42465, 42462, 42554, 42558, 42466, 44357, 44369, 44370, 44066, 44360, 44372, 44373, 
44069, 44055, 44358, 44371, 44068
28040, 42462, 42554, 42558, 42466, 17108, 17131, 17132, 17109, 44360, 44372, 44373, 44069, 0, 0, 0, 
0, 44058, 44361, 44374, 44071
28041, 6297, 6320, 6321, 6298, 42463, 42555, 42559, 42467, 0, 0, 0, 0, 44364, 44376, 44377, 
44073, 44059, 44362, 44375, 44072
28042, 42463, 42555, 42559, 42467, 42464, 42556, 42560, 42468, 44364, 44376, 44377, 44073, 44367, 44379, 44380, 
44076, 44062, 44365, 44378, 44075
28043, 42464, 42556, 42560, 42468, 42465, 42557, 42561, 42469, 44367, 44379, 44380, 44076, 44370, 44382, 44383, 
44079, 44065, 44368, 44381, 44078
28044, 42465, 42557, 42561, 42469, 42466, 42558, 42562, 42470, 44370, 44382, 44383, 44079, 44373, 44385, 44386, 
44082, 44068, 44371, 44384, 44081
28045, 42466, 42558, 42562, 42470, 17109, 17132, 17133, 17110, 44373, 44385, 44386, 44082, 0, 0, 0, 
0, 44071, 44374, 44387, 44084
28046, 6298, 6321, 6322, 6299, 42467, 42559, 42563, 42471, 0, 0, 0, 0, 44377, 44389, 44390, 
44086, 44072, 44375, 44388, 44085
28047, 42467, 42559, 42563, 42471, 42468, 42560, 42564, 42472, 44377, 44389, 44390, 44086, 44380, 44392, 44393, 
44089, 44075, 44378, 44391, 44088
28048, 42468, 42560, 42564, 42472, 42469, 42561, 42565, 42473, 44380, 44392, 44393, 44089, 44383, 44395, 44396, 
44092, 44078, 44381, 44394, 44091
28049, 42469, 42561, 42565, 42473, 42470, 42562, 42566, 42474, 44383, 44395, 44396, 44092, 44386, 44398, 44399, 
44095, 44081, 44384, 44397, 44094
28050, 42470, 42562, 42566, 42474, 17110, 17133, 17134, 17111, 44386, 44398, 44399, 44095, 0, 0, 0, 
0, 44084, 44387, 44400, 44097
28051, 6299, 6322, 6323, 6300, 42471, 42563, 42567, 42475, 0, 0, 0, 0, 44390, 44402, 44403, 
44099, 44085, 44388, 44401, 44098
28052, 42471, 42563, 42567, 42475, 42472, 42564, 42568, 42476, 44390, 44402, 44403, 44099, 44393, 44405, 44406, 
44102, 44088, 44391, 44404, 44101
28053, 42472, 42564, 42568, 42476, 42473, 42565, 42569, 42477, 44393, 44405, 44406, 44102, 44396, 44408, 44409, 
44105, 44091, 44394, 44407, 44104
28054, 42473, 42565, 42569, 42477, 42474, 42566, 42570, 42478, 44396, 44408, 44409, 44105, 44399, 44411, 44412, 
44108, 44094, 44397, 44410, 44107
28055, 42474, 42566, 42570, 42478, 17111, 17134, 17135, 17112, 44399, 44411, 44412, 44108, 0, 0, 0, 
0, 44097, 44400, 44413, 44110
28056, 6300, 6323, 6324, 6301, 42475, 42567, 42571, 42479, 0, 0, 0, 0, 44403, 44415, 44416, 
44112, 44098, 44401, 44414, 44111
28057, 42475, 42567, 42571, 42479, 42476, 42568, 42572, 42480, 44403, 44415, 44416, 44112, 44406, 44418, 44419, 
44115, 44101, 44404, 44417, 44114
28058, 42476, 42568, 42572, 42480, 42477, 42569, 42573, 42481, 44406, 44418, 44419, 44115, 44409, 44421, 44422, 
44118, 44104, 44407, 44420, 44117
28059, 42477, 42569, 42573, 42481, 42478, 42570, 42574, 42482, 44409, 44421, 44422, 44118, 44412, 44424, 44425, 
44121, 44107, 44410, 44423, 44120
28060, 42478, 42570, 42574, 42482, 17112, 17135, 17136, 17113, 44412, 44424, 44425, 44121, 0, 0, 0, 
0, 44110, 44413, 44426, 44123
28061, 6301, 6324, 766, 765, 42479, 42571, 16910, 16906, 0, 0, 0, 0, 44416, 44427, 16969, 
44124, 44111, 44414, 16970, 16961
28062, 42479, 42571, 16910, 16906, 42480, 42572, 16911, 16907, 44416, 44427, 16969, 44124, 44419, 44428, 16971, 
44125, 44114, 44417, 16972, 16963
28063, 42480, 42572, 16911, 16907, 42481, 42573, 16912, 16908, 44419, 44428, 16971, 44125, 44422, 44429, 16973, 
44126, 44117, 44420, 16974, 16965
28064, 42481, 42573, 16912, 16908, 42482, 42574, 16913, 16909, 44422, 44429, 16973, 44126, 44425, 44430, 16975, 
44127, 44120, 44423, 16976, 16967
28065, 42482, 42574, 16913, 16909, 17113, 17136, 2164, 2163, 44425, 44430, 16975, 44127, 0, 0, 0, 
0, 44123, 44426, 16977, 16968
28066, 648, 649, 6325, 6302, 16324, 16328, 42575, 42483, 0, 0, 0, 0, 16392, 44432, 44433, 
44129, 16384, 16393, 44431, 44128
28067, 16324, 16328, 42575, 42483, 16325, 16329, 42576, 42484, 16392, 44432, 44433, 44129, 16394, 44435, 44436, 
44132, 16386, 16395, 44434, 44131
28068, 16325, 16329, 42576, 42484, 16326, 16330, 42577, 42485, 16394, 44435, 44436, 44132, 16396, 44438, 44439, 
44135, 16388, 16397, 44437, 44134
28069, 16326, 16330, 42577, 42485, 16327, 16331, 42578, 42486, 16396, 44438, 44439, 44135, 16398, 44441, 44442, 
44138, 16390, 16399, 44440, 44137
28070, 16327, 16331, 42578, 42486, 2094, 2095, 17137, 17114, 16398, 44441, 44442, 44138, 0, 0, 0, 
0, 16391, 16400, 44443, 44140
28071, 6302, 6325, 6326, 6303, 42483, 42575, 42579, 42487, 0, 0, 0, 0, 44433, 44445, 44446, 
44142, 44128, 44431, 44444, 44141
28072, 42483, 42575, 42579, 42487, 42484, 42576, 42580, 42488, 44433, 44445, 44446, 44142, 44436, 44448, 44449, 
44145, 44131, 44434, 44447, 44144
28073, 42484, 42576, 42580, 42488, 42485, 42577, 42581, 42489, 44436, 44448, 44449, 44145, 44439, 44451, 44452, 
44148, 44134, 44437, 44450, 44147
28074, 42485, 42577, 42581, 42489, 42486, 42578, 42582, 42490, 44439, 44451, 44452, 44148, 44442, 44454, 44455, 
44151, 44137, 44440, 44453, 44150
28075, 42486, 42578, 42582, 42490, 17114, 17137, 17138, 17115, 44442, 44454, 44455, 44151, 0, 0, 0, 
0, 44140, 44443, 44456, 44153
28076, 6303, 6326, 6327, 6304, 42487, 42579, 42583, 42491, 0, 0, 0, 0, 44446, 44458, 44459, 
44155, 44141, 44444, 44457, 44154
28077, 42487, 42579, 42583, 42491, 42488, 42580, 42584, 42492, 44446, 44458, 44459, 44155, 44449, 44461, 44462, 
44158, 44144, 44447, 44460, 44157
28078, 42488, 42580, 42584, 42492, 42489, 42581, 42585, 42493, 44449, 44461, 44462, 44158, 44452, 44464, 44465, 
44161, 44147, 44450, 44463, 44160
28079, 42489, 42581, 42585, 42493, 42490, 42582, 42586, 42494, 44452, 44464, 44465, 44161, 44455, 44467, 44468, 
44164, 44150, 44453, 44466, 44163
28080, 42490, 42582, 42586, 42494, 17115, 17138, 17139, 17116, 44455, 44467, 44468, 44164, 0, 0, 0, 
0, 44153, 44456, 44469, 44166
28081, 6304, 6327, 6328, 6305, 42491, 42583, 42587, 42495, 0, 0, 0, 0, 44459, 44471, 44472, 
44168, 44154, 44457, 44470, 44167
28082, 42491, 42583, 42587, 42495, 42492, 42584, 42588, 42496, 44459, 44471, 44472, 44168, 44462, 44474, 44475, 
44171, 44157, 44460, 44473, 44170
28083, 42492, 42584, 42588, 42496, 42493, 42585, 42589, 42497, 44462, 44474, 44475, 44171, 44465, 44477, 44478, 
44174, 44160, 44463, 44476, 44173
28084, 42493, 42585, 42589, 42497, 42494, 42586, 42590, 42498, 44465, 44477, 44478, 44174, 44468, 44480, 44481, 
44177, 44163, 44466, 44479, 44176
28085, 42494, 42586, 42590, 42498, 17116, 17139, 17140, 17117, 44468, 44480, 44481, 44177, 0, 0, 0, 
0, 44166, 44469, 44482, 44179
28086, 6305, 6328, 6329, 6306, 42495, 42587, 42591, 42499, 0, 0, 0, 0, 44472, 44484, 44485, 
44181, 44167, 44470, 44483, 44180
28087, 42495, 42587, 42591, 42499, 42496, 42588, 42592, 42500, 44472, 44484, 44485, 44181, 44475, 44487, 44488, 
44184, 44170, 44473, 44486, 44183
28088, 42496, 42588, 42592, 42500, 42497, 42589, 42593, 42501, 44475, 44487, 44488, 44184, 44478, 44490, 44491, 
44187, 44173, 44476, 44489, 44186
28089, 42497, 42589, 42593, 42501, 42498, 42590, 42594, 42502, 44478, 44490, 44491, 44187, 44481, 44493, 44494, 
44190, 44176, 44479, 44492, 44189
28090, 42498, 42590, 42594, 42502, 17117, 17140, 17141, 17118, 44481, 44493, 44494, 44190, 0, 0, 0, 
0, 44179, 44482, 44495, 44192
28091, 6306, 6329, 6330, 6307, 42499, 42591, 42595, 42503, 0, 0, 0, 0, 44485, 44497, 44498, 
44194, 44180, 44483, 44496, 44193
28092, 42499, 42591, 42595, 42503, 42500, 42592, 42596, 42504, 44485, 44497, 44498, 44194, 44488, 44500, 44501, 
44197, 44183, 44486, 44499, 44196
28093, 42500, 42592, 42596, 42504, 42501, 42593, 42597, 42505, 44488, 44500, 44501, 44197, 44491, 44503, 44504, 
44200, 44186, 44489, 44502, 44199
28094, 42501, 42593, 42597, 42505, 42502, 42594, 42598, 42506, 44491, 44503, 44504, 44200, 44494, 44506, 44507, 
44203, 44189, 44492, 44505, 44202
28095, 42502, 42594, 42598, 42506, 17118, 17141, 17142, 17119, 44494, 44506, 44507, 44203, 0, 0, 0, 
0, 44192, 44495, 44508, 44205
28096, 6307, 6330, 6331, 6308, 42503, 42595, 42599, 42507, 0, 0, 0, 0, 44498, 44510, 44511, 
44207, 44193, 44496, 44509, 44206
28097, 42503, 42595, 42599, 42507, 42504, 42596, 42600, 42508, 44498, 44510, 44511, 44207, 44501, 44513, 44514, 
44210, 44196, 44499, 44512, 44209
28098, 42504, 42596, 42600, 42508, 42505, 42597, 42601, 42509, 44501, 44513, 44514, 44210, 44504, 44516, 44517, 
44213, 44199, 44502, 44515, 44212
28099, 42505, 42597, 42601, 42509, 42506, 42598, 42602, 42510, 44504, 44516, 44517, 44213, 44507, 44519, 44520, 
44216, 44202, 44505, 44518, 44215
28100, 42506, 42598, 42602, 42510, 17119, 17142, 17143, 17120, 44507, 44519, 44520, 44216, 0, 0, 0, 
0, 44205, 44508, 44521, 44218
28101, 6308, 6331, 6332, 6309, 42507, 42599, 42603, 42511, 0, 0, 0, 0, 44511, 44523, 44524, 
44220, 44206, 44509, 44522, 44219
28102, 42507, 42599, 42603, 42511, 42508, 42600, 42604, 42512, 44511, 44523, 44524, 44220, 44514, 44526, 44527, 
44223, 44209, 44512, 44525, 44222
28103, 42508, 42600, 42604, 42512, 42509, 42601, 42605, 42513, 44514, 44526, 44527, 44223, 44517, 44529, 44530, 
44226, 44212, 44515, 44528, 44225
28104, 42509, 42601, 42605, 42513, 42510, 42602, 42606, 42514, 44517, 44529, 44530, 44226, 44520, 44532, 44533, 
44229, 44215, 44518, 44531, 44228
28105, 42510, 42602, 42606, 42514, 17120, 17143, 17144, 17121, 44520, 44532, 44533, 44229, 0, 0, 0, 
0, 44218, 44521, 44534, 44231
28106, 6309, 6332, 6333, 6310, 42511, 42603, 42607, 42515, 0, 0, 0, 0, 44524, 44536, 44537, 
44233, 44219, 44522, 44535, 44232
28107, 42511, 42603, 42607, 42515, 42512, 42604, 42608, 42516, 44524, 44536, 44537, 44233, 44527, 44539, 44540, 
44236, 44222, 44525, 44538, 44235
28108, 42512, 42604, 42608, 42516, 42513, 42605, 42609, 42517, 44527, 44539, 44540, 44236, 44530, 44542, 44543, 
44239, 44225, 44528, 44541, 44238
28109, 42513, 42605, 42609, 42517, 42514, 42606, 42610, 42518, 44530, 44542, 44543, 44239, 44533, 44545, 44546, 
44242, 44228, 44531, 44544, 44241
28110, 42514, 42606, 42610, 42518, 17121, 17144, 17145, 17122, 44533, 44545, 44546, 44242, 0, 0, 0, 
0, 44231, 44534, 44547, 44244
28111, 6310, 6333, 6334, 6311, 42515, 42607, 42611, 42519, 0, 0, 0, 0, 44537, 44549, 44550, 
44246, 44232, 44535, 44548, 44245
28112, 42515, 42607, 42611, 42519, 42516, 42608, 42612, 42520, 44537, 44549, 44550, 44246, 44540, 44552, 44553, 
44249, 44235, 44538, 44551, 44248
28113, 42516, 42608, 42612, 42520, 42517, 42609, 42613, 42521, 44540, 44552, 44553, 44249, 44543, 44555, 44556, 
44252, 44238, 44541, 44554, 44251
28114, 42517, 42609, 42613, 42521, 42518, 42610, 42614, 42522, 44543, 44555, 44556, 44252, 44546, 44558, 44559, 
44255, 44241, 44544, 44557, 44254
28115, 42518, 42610, 42614, 42522, 17122, 17145, 17146, 17123, 44546, 44558, 44559, 44255, 0, 0, 0, 
0, 44244, 44547, 44560, 44257
28116, 6311, 6334, 6335, 6312, 42519, 42611, 42615, 42523, 0, 0, 0, 0, 44550, 44562, 44563, 
44259, 44245, 44548, 44561, 44258
28117, 42519, 42611, 42615, 42523, 42520, 42612, 42616, 42524, 44550, 44562, 44563, 44259, 44553, 44565, 44566, 
44262, 44248, 44551, 44564, 44261
28118, 42520, 42612, 42616, 42524, 42521, 42613, 42617, 42525, 44553, 44565, 44566, 44262, 44556, 44568, 44569, 
44265, 44251, 44554, 44567, 44264
28119, 42521, 42613, 42617, 42525, 42522, 42614, 42618, 42526, 44556, 44568, 44569, 44265, 44559, 44571, 44572, 
44268, 44254, 44557, 44570, 44267
28120, 42522, 42614, 42618, 42526, 17123, 17146, 17147, 17124, 44559, 44571, 44572, 44268, 0, 0, 0, 
0, 44257, 44560, 44573, 44270
28121, 6312, 6335, 6336, 6313, 42523, 42615, 42619, 42527, 0, 0, 0, 0, 44563, 44575, 44576, 
44272, 44258, 44561, 44574, 44271
28122, 42523, 42615, 42619, 42527, 42524, 42616, 42620, 42528, 44563, 44575, 44576, 44272, 44566, 44578, 44579, 
44275, 44261, 44564, 44577, 44274
28123, 42524, 42616, 42620, 42528, 42525, 42617, 42621, 42529, 44566, 44578, 44579, 44275, 44569, 44581, 44582, 
44278, 44264, 44567, 44580, 44277
28124, 42525, 42617, 42621, 42529, 42526, 42618, 42622, 42530, 44569, 44581, 44582, 44278, 44572, 44584, 44585, 
44281, 44267, 44570, 44583, 44280
28125, 42526, 42618, 42622, 42530, 17124, 17147, 17148, 17125, 44572, 44584, 44585, 44281, 0, 0, 0, 
0, 44270, 44573, 44586, 44283
28126, 6313, 6336, 6337, 6314, 42527, 42619, 42623, 42531, 0, 0, 0, 0, 44576, 44588, 44589, 
44285, 44271, 44574, 44587, 44284
28127, 42527, 42619, 42623, 42531, 42528, 42620, 42624, 42532, 44576, 44588, 44589, 44285, 44579, 44591, 44592, 
44288, 44274, 44577, 44590, 44287
28128, 42528, 42620, 42624, 42532, 42529, 42621, 42625, 42533, 44579, 44591, 44592, 44288, 44582, 44594, 44595, 
44291, 44277, 44580, 44593, 44290
28129, 42529, 42621, 42625, 42533, 42530, 42622, 42626, 42534, 44582, 44594, 44595, 44291, 44585, 44597, 44598, 
44294, 44280, 44583, 44596, 44293
28130, 42530, 42622, 42626, 42534, 17125, 17148, 17149, 17126, 44585, 44597, 44598, 44294, 0, 0, 0, 
0, 44283, 44586, 44599, 44296
28131, 6314, 6337, 6338, 6315, 42531, 42623, 42627, 42535, 0, 0, 0, 0, 44589, 44601, 44602, 
44298, 44284, 44587, 44600, 44297
28132, 42531, 42623, 42627, 42535, 42532, 42624, 42628, 42536, 44589, 44601, 44602, 44298, 44592, 44604, 44605, 
44301, 44287, 44590, 44603, 44300
28133, 42532, 42624, 42628, 42536, 42533, 42625, 42629, 42537, 44592, 44604, 44605, 44301, 44595, 44607, 44608, 
44304, 44290, 44593, 44606, 44303
28134, 42533, 42625, 42629, 42537, 42534, 42626, 42630, 42538, 44595, 44607, 44608, 44304, 44598, 44610, 44611, 
44307, 44293, 44596, 44609, 44306
28135, 42534, 42626, 42630, 42538, 17126, 17149, 17150, 17127, 44598, 44610, 44611, 44307, 0, 0, 0, 
0, 44296, 44599, 44612, 44309
28136, 6315, 6338, 6339, 6316, 42535, 42627, 42631, 42539, 0, 0, 0, 0, 44602, 44614, 44615, 
44311, 44297, 44600, 44613, 44310
28137, 42535, 42627, 42631, 42539, 42536, 42628, 42632, 42540, 44602, 44614, 44615, 44311, 44605, 44617, 44618, 
44314, 44300, 44603, 44616, 44313
28138, 42536, 42628, 42632, 42540, 42537, 42629, 42633, 42541, 44605, 44617, 44618, 44314, 44608, 44620, 44621, 
44317, 44303, 44606, 44619, 44316
28139, 42537, 42629, 42633, 42541, 42538, 42630, 42634, 42542, 44608, 44620, 44621, 44317, 44611, 44623, 44624, 
44320, 44306, 44609, 44622, 44319
28140, 42538, 42630, 42634, 42542, 17127, 17150, 17151, 17128, 44611, 44623, 44624, 44320, 0, 0, 0, 
0, 44309, 44612, 44625, 44322
28141, 6316, 6339, 6340, 6317, 42539, 42631, 42635, 42543, 0, 0, 0, 0, 44615, 44627, 44628, 
44324, 44310, 44613, 44626, 44323
28142, 42539, 42631, 42635, 42543, 42540, 42632, 42636, 42544, 44615, 44627, 44628, 44324, 44618, 44630, 44631, 
44327, 44313, 44616, 44629, 44326
28143, 42540, 42632, 42636, 42544, 42541, 42633, 42637, 42545, 44618, 44630, 44631, 44327, 44621, 44633, 44634, 
44330, 44316, 44619, 44632, 44329
28144, 42541, 42633, 42637, 42545, 42542, 42634, 42638, 42546, 44621, 44633, 44634, 44330, 44624, 44636, 44637, 
44333, 44319, 44622, 44635, 44332
28145, 42542, 42634, 42638, 42546, 17128, 17151, 17152, 17129, 44624, 44636, 44637, 44333, 0, 0, 0, 
0, 44322, 44625, 44638, 44335
28146, 6317, 6340, 6341, 6318, 42543, 42635, 42639, 42547, 0, 0, 0, 0, 44628, 44640, 44641, 
44337, 44323, 44626, 44639, 44336
28147, 42543, 42635, 42639, 42547, 42544, 42636, 42640, 42548, 44628, 44640, 44641, 44337, 44631, 44643, 44644, 
44340, 44326, 44629, 44642, 44339
28148, 42544, 42636, 42640, 42548, 42545, 42637, 42641, 42549, 44631, 44643, 44644, 44340, 44634, 44646, 44647, 
44343, 44329, 44632, 44645, 44342
28149, 42545, 42637, 42641, 42549, 42546, 42638, 42642, 42550, 44634, 44646, 44647, 44343, 44637, 44649, 44650, 
44346, 44332, 44635, 44648, 44345
28150, 42546, 42638, 42642, 42550, 17129, 17152, 17153, 17130, 44637, 44649, 44650, 44346, 0, 0, 0, 
0, 44335, 44638, 44651, 44348
28151, 6318, 6341, 6342, 6319, 42547, 42639, 42643, 42551, 0, 0, 0, 0, 44641, 44653, 44654, 
44350, 44336, 44639, 44652, 44349
28152, 42547, 42639, 42643, 42551, 42548, 42640, 42644, 42552, 44641, 44653, 44654, 44350, 44644, 44656, 44657, 
44353, 44339, 44642, 44655, 44352
28153, 42548, 42640, 42644, 42552, 42549, 42641, 42645, 42553, 44644, 44656, 44657, 44353, 44647, 44659, 44660, 
44356, 44342, 44645, 44658, 44355
28154, 42549, 42641, 42645, 42553, 42550, 42642, 42646, 42554, 44647, 44659, 44660, 44356, 44650, 44662, 44663, 
44359, 44345, 44648, 44661, 44358
28155, 42550, 42642, 42646, 42554, 17130, 17153, 17154, 17131, 44650, 44662, 44663, 44359, 0, 0, 0, 
0, 44348, 44651, 44664, 44361
28156, 6319, 6342, 6343, 6320, 42551, 42643, 42647, 42555, 0, 0, 0, 0, 44654, 44666, 44667, 
44363, 44349, 44652, 44665, 44362
28157, 42551, 42643, 42647, 42555, 42552, 42644, 42648, 42556, 44654, 44666, 44667, 44363, 44657, 44669, 44670, 
44366, 44352, 44655, 44668, 44365
28158, 42552, 42644, 42648, 42556, 42553, 42645, 42649, 42557, 44657, 44669, 44670, 44366, 44660, 44672, 44673, 
44369, 44355, 44658, 44671, 44368
28159, 42553, 42645, 42649, 42557, 42554, 42646, 42650, 42558, 44660, 44672, 44673, 44369, 44663, 44675, 44676, 
44372, 44358, 44661, 44674, 44371
28160, 42554, 42646, 42650, 42558, 17131, 17154, 17155, 17132, 44663, 44675, 44676, 44372, 0, 0, 0, 
0, 44361, 44664, 44677, 44374
28161, 6320, 6343, 6344, 6321, 42555, 42647, 42651, 42559, 0, 0, 0, 0, 44667, 44679, 44680, 
44376, 44362, 44665, 44678, 44375
28162, 42555, 42647, 42651, 42559, 42556, 42648, 42652, 42560, 44667, 44679, 44680, 44376, 44670, 44682, 44683, 
44379, 44365, 44668, 44681, 44378
28163, 42556, 42648, 42652, 42560, 42557, 42649, 42653, 42561, 44670, 44682, 44683, 44379, 44673, 44685, 44686, 
44382, 44368, 44671, 44684, 44381
28164, 42557, 42649, 42653, 42561, 42558, 42650, 42654, 42562, 44673, 44685, 44686, 44382, 44676, 44688, 44689, 
44385, 44371, 44674, 44687, 44384
28165, 42558, 42650, 42654, 42562, 17132, 17155, 17156, 17133, 44676, 44688, 44689, 44385, 0, 0, 0, 
0, 44374, 44677, 44690, 44387
28166, 6321, 6344, 6345, 6322, 42559, 42651, 42655, 42563, 0, 0, 0, 0, 44680, 44692, 44693, 
44389, 44375, 44678, 44691, 44388
28167, 42559, 42651, 42655, 42563, 42560, 42652, 42656, 42564, 44680, 44692, 44693, 44389, 44683, 44695, 44696, 
44392, 44378, 44681, 44694, 44391
28168, 42560, 42652, 42656, 42564, 42561, 42653, 42657, 42565, 44683, 44695, 44696, 44392, 44686, 44698, 44699, 
44395, 44381, 44684, 44697, 44394
28169, 42561, 42653, 42657, 42565, 42562, 42654, 42658, 42566, 44686, 44698, 44699, 44395, 44689, 44701, 44702, 
44398, 44384, 44687, 44700, 44397
28170, 42562, 42654, 42658, 42566, 17133, 17156, 17157, 17134, 44689, 44701, 44702, 44398, 0, 0, 0, 
0, 44387, 44690, 44703, 44400
28171, 6322, 6345, 6346, 6323, 42563, 42655, 42659, 42567, 0, 0, 0, 0, 44693, 44705, 44706, 
44402, 44388, 44691, 44704, 44401
28172, 42563, 42655, 42659, 42567, 42564, 42656, 42660, 42568, 44693, 44705, 44706, 44402, 44696, 44708, 44709, 
44405, 44391, 44694, 44707, 44404
28173, 42564, 42656, 42660, 42568, 42565, 42657, 42661, 42569, 44696, 44708, 44709, 44405, 44699, 44711, 44712, 
44408, 44394, 44697, 44710, 44407
28174, 42565, 42657, 42661, 42569, 42566, 42658, 42662, 42570, 44699, 44711, 44712, 44408, 44702, 44714, 44715, 
44411, 44397, 44700, 44713, 44410
28175, 42566, 42658, 42662, 42570, 17134, 17157, 17158, 17135, 44702, 44714, 44715, 44411, 0, 0, 0, 
0, 44400, 44703, 44716, 44413
28176, 6323, 6346, 6347, 6324, 42567, 42659, 42663, 42571, 0, 0, 0, 0, 44706, 44718, 44719, 
44415, 44401, 44704, 44717, 44414
28177, 42567, 42659, 42663, 42571, 42568, 42660, 42664, 42572, 44706, 44718, 44719, 44415, 44709, 44721, 44722, 
44418, 44404, 44707, 44720, 44417
28178, 42568, 42660, 42664, 42572, 42569, 42661, 42665, 42573, 44709, 44721, 44722, 44418, 44712, 44724, 44725, 
44421, 44407, 44710, 44723, 44420
28179, 42569, 42661, 42665, 42573, 42570, 42662, 42666, 42574, 44712, 44724, 44725, 44421, 44715, 44727, 44728, 
44424, 44410, 44713, 44726, 44423
28180, 42570, 42662, 42666, 42574, 17135, 17158, 17159, 17136, 44715, 44727, 44728, 44424, 0, 0, 0, 
0, 44413, 44716, 44729, 44426
28181, 6324, 6347, 767, 766, 42571, 42663, 16914, 16910, 0, 0, 0, 0, 44719, 44730, 16978, 
44427, 44414, 44717, 16979, 16970
28182, 42571, 42663, 16914, 16910, 42572, 42664, 16915, 16911, 44719, 44730, 16978, 44427, 44722, 44731, 16980, 
44428, 44417, 44720, 16981, 16972
28183, 42572, 42664, 16915, 16911, 42573, 42665, 16916, 16912, 44722, 44731, 16980, 44428, 44725, 44732, 16982, 
44429, 44420, 44723, 16983, 16974
28184, 42573, 42665, 16916, 16912, 42574, 42666, 16917, 16913, 44725, 44732, 16982, 44429, 44728, 44733, 16984, 
44430, 44423, 44726, 16985, 16976
28185, 42574, 42666, 16917, 16913, 17136, 17159, 2165, 2164, 44728, 44733, 16984, 44430, 0, 0, 0, 
0, 44426, 44729, 16986, 16977
28186, 649, 650, 6348, 6325, 16328, 16332, 42667, 42575, 0, 0, 0, 0, 16401, 44735, 44736, 
44432, 16393, 16402, 44734, 44431
28187, 16328, 16332, 42667, 42575, 16329, 16333, 42668, 42576, 16401, 44735, 44736, 44432, 16403, 44738, 44739, 
44435, 16395, 16404, 44737, 44434
28188, 16329, 16333, 42668, 42576, 16330, 16334, 42669, 42577, 16403, 44738, 44739, 44435, 16405, 44741, 44742, 
44438, 16397, 16406, 44740, 44437
28189, 16330, 16334, 42669, 42577, 16331, 16335, 42670, 42578, 16405, 44741, 44742, 44438, 16407, 44744, 44745, 
44441, 16399, 16408, 44743, 44440
28190, 16331, 16335, 42670, 42578, 2095, 2096, 17160, 17137, 16407, 44744, 44745, 44441, 0, 0, 0, 
0, 16400, 16409, 44746, 44443
28191, 6325, 6348, 6349, 6326, 42575, 42667, 42671, 42579, 0, 0, 0, 0, 44736, 44748, 44749, 
44445, 44431, 44734, 44747, 44444
28192, 42575, 42667, 42671, 42579, 42576, 42668, 42672, 42580, 44736, 44748, 44749, 44445, 44739, 44751, 44752, 
44448, 44434, 44737, 44750, 44447
28193, 42576, 42668, 42672, 42580, 42577, 42669, 42673, 42581, 44739, 44751, 44752, 44448, 44742, 44754, 44755, 
44451, 44437, 44740, 44753, 44450
28194, 42577, 42669, 42673, 42581, 42578, 42670, 42674, 42582, 44742, 44754, 44755, 44451, 44745, 44757, 44758, 
44454, 44440, 44743, 44756, 44453
28195, 42578, 42670, 42674, 42582, 17137, 17160, 17161, 17138, 44745, 44757, 44758, 44454, 0, 0, 0, 
0, 44443, 44746, 44759, 44456
28196, 6326, 6349, 6350, 6327, 42579, 42671, 42675, 42583, 0, 0, 0, 0, 44749, 44761, 44762, 
44458, 44444, 44747, 44760, 44457
28197, 42579, 42671, 42675, 42583, 42580, 42672, 42676, 42584, 44749, 44761, 44762, 44458, 44752, 44764, 44765, 
44461, 44447, 44750, 44763, 44460
28198, 42580, 42672, 42676, 42584, 42581, 42673, 42677, 42585, 44752, 44764, 44765, 44461, 44755, 44767, 44768, 
44464, 44450, 44753, 44766, 44463
28199, 42581, 42673, 42677, 42585, 42582, 42674, 42678, 42586, 44755, 44767, 44768, 44464, 44758, 44770, 44771, 
44467, 44453, 44756, 44769, 44466
28200, 42582, 42674, 42678, 42586, 17138, 17161, 17162, 17139, 44758, 44770, 44771, 44467, 0, 0, 0, 
0, 44456, 44759, 44772, 44469
28201, 6327, 6350, 6351, 6328, 42583, 42675, 42679, 42587, 0, 0, 0, 0, 44762, 44774, 44775, 
44471, 44457, 44760, 44773, 44470
28202, 42583, 42675, 42679, 42587, 42584, 42676, 42680, 42588, 44762, 44774, 44775, 44471, 44765, 44777, 44778, 
44474, 44460, 44763, 44776, 44473
28203, 42584, 42676, 42680, 42588, 42585, 42677, 42681, 42589, 44765, 44777, 44778, 44474, 44768, 44780, 44781, 
44477, 44463, 44766, 44779, 44476
28204, 42585, 42677, 42681, 42589, 42586, 42678, 42682, 42590, 44768, 44780, 44781, 44477, 44771, 44783, 44784, 
44480, 44466, 44769, 44782, 44479
28205, 42586, 42678, 42682, 42590, 17139, 17162, 17163, 17140, 44771, 44783, 44784, 44480, 0, 0, 0, 
0, 44469, 44772, 44785, 44482
28206, 6328, 6351, 6352, 6329, 42587, 42679, 42683, 42591, 0, 0, 0, 0, 44775, 44787, 44788, 
44484, 44470, 44773, 44786, 44483
28207, 42587, 42679, 42683, 42591, 42588, 42680, 42684, 42592, 44775, 44787, 44788, 44484, 44778, 44790, 44791, 
44487, 44473, 44776, 44789, 44486
28208, 42588, 42680, 42684, 42592, 42589, 42681, 42685, 42593, 44778, 44790, 44791, 44487, 44781, 44793, 44794, 
44490, 44476, 44779, 44792, 44489
28209, 42589, 42681, 42685, 42593, 42590, 42682, 42686, 42594, 44781, 44793, 44794, 44490, 44784, 44796, 44797, 
44493, 44479, 44782, 44795, 44492
28210, 42590, 42682, 42686, 42594, 17140, 17163, 17164, 17141, 44784, 44796, 44797, 44493, 0, 0, 0, 
0, 44482, 44785, 44798, 44495
28211, 6329, 6352, 6353, 6330, 42591, 42683, 42687, 42595, 0, 0, 0, 0, 44788, 44800, 44801, 
44497, 44483, 44786, 44799, 44496
28212, 42591, 42683, 42687, 42595, 42592, 42684, 42688, 42596, 44788, 44800, 44801, 44497, 44791, 44803, 44804, 
44500, 44486, 44789, 44802, 44499
28213, 42592, 42684, 42688, 42596, 42593, 42685, 42689, 42597, 44791, 44803, 44804, 44500, 44794, 44806, 44807, 
44503, 44489, 44792, 44805, 44502
28214, 42593, 42685, 42689, 42597, 42594, 42686, 42690, 42598, 44794, 44806, 44807, 44503, 44797, 44809, 44810, 
44506, 44492, 44795, 44808, 44505
28215, 42594, 42686, 42690, 42598, 17141, 17164, 17165, 17142, 44797, 44809, 44810, 44506, 0, 0, 0, 
0, 44495, 44798, 44811, 44508
28216, 6330, 6353, 6354, 6331, 42595, 42687, 42691, 42599, 0, 0, 0, 0, 44801, 44813, 44814, 
44510, 44496, 44799, 44812, 44509
28217, 42595, 42687, 42691, 42599, 42596, 42688, 42692, 42600, 44801, 44813, 44814, 44510, 44804, 44816, 44817, 
44513, 44499, 44802, 44815, 44512
28218, 42596, 42688, 42692, 42600, 42597, 42689, 42693, 42601, 44804, 44816, 44817, 44513, 44807, 44819, 44820, 
44516, 44502, 44805, 44818, 44515
28219, 42597, 42689, 42693, 42601, 42598, 42690, 42694, 42602, 44807, 44819, 44820, 44516, 44810, 44822, 44823, 
44519, 44505, 44808, 44821, 44518
28220, 42598, 42690, 42694, 42602, 17142, 17165, 17166, 17143, 44810, 44822, 44823, 44519, 0, 0, 0, 
0, 44508, 44811, 44824, 44521
28221, 6331, 6354, 6355, 6332, 42599, 42691, 42695, 42603, 0, 0, 0, 0, 44814, 44826, 44827, 
44523, 44509, 44812, 44825, 44522
28222, 42599, 42691, 42695, 42603, 42600, 42692, 42696, 42604, 44814, 44826, 44827, 44523, 44817, 44829, 44830, 
44526, 44512, 44815, 44828, 44525
28223, 42600, 42692, 42696, 42604, 42601, 42693, 42697, 42605, 44817, 44829, 44830, 44526, 44820, 44832, 44833, 
44529, 44515, 44818, 44831, 44528
28224, 42601, 42693, 42697, 42605, 42602, 42694, 42698, 42606, 44820, 44832, 44833, 44529, 44823, 44835, 44836, 
44532, 44518, 44821, 44834, 44531
28225, 42602, 42694, 42698, 42606, 17143, 17166, 17167, 17144, 44823, 44835, 44836, 44532, 0, 0, 0, 
0, 44521, 44824, 44837, 44534
28226, 6332, 6355, 6356, 6333, 42603, 42695, 42699, 42607, 0, 0, 0, 0, 44827, 44839, 44840, 
44536, 44522, 44825, 44838, 44535
28227, 42603, 42695, 42699, 42607, 42604, 42696, 42700, 42608, 44827, 44839, 44840, 44536, 44830, 44842, 44843, 
44539, 44525, 44828, 44841, 44538
28228, 42604, 42696, 42700, 42608, 42605, 42697, 42701, 42609, 44830, 44842, 44843, 44539, 44833, 44845, 44846, 
44542, 44528, 44831, 44844, 44541
28229, 42605, 42697, 42701, 42609, 42606, 42698, 42702, 42610, 44833, 44845, 44846, 44542, 44836, 44848, 44849, 
44545, 44531, 44834, 44847, 44544
28230, 42606, 42698, 42702, 42610, 17144, 17167, 17168, 17145, 44836, 44848, 44849, 44545, 0, 0, 0, 
0, 44534, 44837, 44850, 44547
28231, 6333, 6356, 6357, 6334, 42607, 42699, 42703, 42611, 0, 0, 0, 0, 44840, 44852, 44853, 
44549, 44535, 44838, 44851, 44548
28232, 42607, 42699, 42703, 42611, 42608, 42700, 42704, 42612, 44840, 44852, 44853, 44549, 44843, 44855, 44856, 
44552, 44538, 44841, 44854, 44551
28233, 42608, 42700, 42704, 42612, 42609, 42701, 42705, 42613, 44843, 44855, 44856, 44552, 44846, 44858, 44859, 
44555, 44541, 44844, 44857, 44554
28234, 42609, 42701, 42705, 42613, 42610, 42702, 42706, 42614, 44846, 44858, 44859, 44555, 44849, 44861, 44862, 
44558, 44544, 44847, 44860, 44557
28235, 42610, 42702, 42706, 42614, 17145, 17168, 17169, 17146, 44849, 44861, 44862, 44558, 0, 0, 0, 
0, 44547, 44850, 44863, 44560
28236, 6334, 6357, 6358, 6335, 42611, 42703, 42707, 42615, 0, 0, 0, 0, 44853, 44865, 44866, 
44562, 44548, 44851, 44864, 44561
28237, 42611, 42703, 42707, 42615, 42612, 42704, 42708, 42616, 44853, 44865, 44866, 44562, 44856, 44868, 44869, 
44565, 44551, 44854, 44867, 44564
28238, 42612, 42704, 42708, 42616, 42613, 42705, 42709, 42617, 44856, 44868, 44869, 44565, 44859, 44871, 44872, 
44568, 44554, 44857, 44870, 44567
28239, 42613, 42705, 42709, 42617, 42614, 42706, 42710, 42618, 44859, 44871, 44872, 44568, 44862, 44874, 44875, 
44571, 44557, 44860, 44873, 44570
28240, 42614, 42706, 42710, 42618, 17146, 17169, 17170, 17147, 44862, 44874, 44875, 44571, 0, 0, 0, 
0, 44560, 44863, 44876, 44573
28241, 6335, 6358, 6359, 6336, 42615, 42707, 42711, 42619, 0, 0, 0, 0, 44866, 44878, 44879, 
44575, 44561, 44864, 44877, 44574
28242, 42615, 42707, 42711, 42619, 42616, 42708, 42712, 42620, 44866, 44878, 44879, 44575, 44869, 44881, 44882, 
44578, 44564, 44867, 44880, 44577
28243, 42616, 42708, 42712, 42620, 42617, 42709, 42713, 42621, 44869, 44881, 44882, 44578, 44872, 44884, 44885, 
44581, 44567, 44870, 44883, 44580
28244, 42617, 42709, 42713, 42621, 42618, 42710, 42714, 42622, 44872, 44884, 44885, 44581, 44875, 44887, 44888, 
44584, 44570, 44873, 44886, 44583
28245, 42618, 42710, 42714, 42622, 17147, 17170, 17171, 17148, 44875, 44887, 44888, 44584, 0, 0, 0, 
0, 44573, 44876, 44889, 44586
28246, 6336, 6359, 6360, 6337, 42619, 42711, 42715, 42623, 0, 0, 0, 0, 44879, 44891, 44892, 
44588, 44574, 44877, 44890, 44587
28247, 42619, 42711, 42715, 42623, 42620, 42712, 42716, 42624, 44879, 44891, 44892, 44588, 44882, 44894, 44895, 
44591, 44577, 44880, 44893, 44590
28248, 42620, 42712, 42716, 42624, 42621, 42713, 42717, 42625, 44882, 44894, 44895, 44591, 44885, 44897, 44898, 
44594, 44580, 44883, 44896, 44593
28249, 42621, 42713, 42717, 42625, 42622, 42714, 42718, 42626, 44885, 44897, 44898, 44594, 44888, 44900, 44901, 
44597, 44583, 44886, 44899, 44596
28250, 42622, 42714, 42718, 42626, 17148, 17171, 17172, 17149, 44888, 44900, 44901, 44597, 0, 0, 0, 
0, 44586, 44889, 44902, 44599
28251, 6337, 6360, 6361, 6338, 42623, 42715, 42719, 42627, 0, 0, 0, 0, 44892, 44904, 44905, 
44601, 44587, 44890, 44903, 44600
28252, 42623, 42715, 42719, 42627, 42624, 42716, 42720, 42628, 44892, 44904, 44905, 44601, 44895, 44907, 44908, 
44604, 44590, 44893, 44906, 44603
28253, 42624, 42716, 42720, 42628, 42625, 42717, 42721, 42629, 44895, 44907, 44908, 44604, 44898, 44910, 44911, 
44607, 44593, 44896, 44909, 44606
28254, 42625, 42717, 42721, 42629, 42626, 42718, 42722, 42630, 44898, 44910, 44911, 44607, 44901, 44913, 44914, 
44610, 44596, 44899, 44912, 44609
28255, 42626, 42718, 42722, 42630, 17149, 17172, 17173, 17150, 44901, 44913, 44914, 44610, 0, 0, 0, 
0, 44599, 44902, 44915, 44612
28256, 6338, 6361, 6362, 6339, 42627, 42719, 42723, 42631, 0, 0, 0, 0, 44905, 44917, 44918, 
44614, 44600, 44903, 44916, 44613
28257, 42627, 42719, 42723, 42631, 42628, 42720, 42724, 42632, 44905, 44917, 44918, 44614, 44908, 44920, 44921, 
44617, 44603, 44906, 44919, 44616
28258, 42628, 42720, 42724, 42632, 42629, 42721, 42725, 42633, 44908, 44920, 44921, 44617, 44911, 44923, 44924, 
44620, 44606, 44909, 44922, 44619
28259, 42629, 42721, 42725, 42633, 42630, 42722, 42726, 42634, 44911, 44923, 44924, 44620, 44914, 44926, 44927, 
44623, 44609, 44912, 44925, 44622
28260, 42630, 42722, 42726, 42634, 17150, 17173, 17174, 17151, 44914, 44926, 44927, 44623, 0, 0, 0, 
0, 44612, 44915, 44928, 44625
28261, 6339, 6362, 6363, 6340, 42631, 42723, 42727, 42635, 0, 0, 0, 0, 44918, 44930, 44931, 
44627, 44613, 44916, 44929, 44626
28262, 42631, 42723, 42727, 42635, 42632, 42724, 42728, 42636, 44918, 44930, 44931, 44627, 44921, 44933, 44934, 
44630, 44616, 44919, 44932, 44629
28263, 42632, 42724, 42728, 42636, 42633, 42725, 42729, 42637, 44921, 44933, 44934, 44630, 44924, 44936, 44937, 
44633, 44619, 44922, 44935, 44632
28264, 42633, 42725, 42729, 42637, 42634, 42726, 42730, 42638, 44924, 44936, 44937, 44633, 44927, 44939, 44940, 
44636, 44622, 44925, 44938, 44635
28265, 42634, 42726, 42730, 42638, 17151, 17174, 17175, 17152, 44927, 44939, 44940, 44636, 0, 0, 0, 
0, 44625, 44928, 44941, 44638
28266, 6340, 6363, 6364, 6341, 42635, 42727, 42731, 42639, 0, 0, 0, 0, 44931, 44943, 44944, 
44640, 44626, 44929, 44942, 44639
28267, 42635, 42727, 42731, 42639, 42636, 42728, 42732, 42640, 44931, 44943, 44944, 44640, 44934, 44946, 44947, 
44643, 44629, 44932, 44945, 44642
28268, 42636, 42728, 42732, 42640, 42637, 42729, 42733, 42641, 44934, 44946, 44947, 44643, 44937, 44949, 44950, 
44646, 44632, 44935, 44948, 44645
28269, 42637, 42729, 42733, 42641, 42638, 42730, 42734, 42642, 44937, 44949, 44950, 44646, 44940, 44952, 44953, 
44649, 44635, 44938, 44951, 44648
28270, 42638, 42730, 42734, 42642, 17152, 17175, 17176, 17153, 44940, 44952, 44953, 44649, 0, 0, 0, 
0, 44638, 44941, 44954, 44651
28271, 6341, 6364, 6365, 6342, 42639, 42731, 42735, 42643, 0, 0, 0, 0, 44944, 44956, 44957, 
44653, 44639, 44942, 44955, 44652
28272, 42639, 42731, 42735, 42643, 42640, 42732, 42736, 42644, 44944, 44956, 44957, 44653, 44947, 44959, 44960, 
44656, 44642, 44945, 44958, 44655
28273, 42640, 42732, 42736, 42644, 42641, 42733, 42737, 42645, 44947, 44959, 44960, 44656, 44950, 44962, 44963, 
44659, 44645, 44948, 44961, 44658
28274, 42641, 42733, 42737, 42645, 42642, 42734, 42738, 42646, 44950, 44962, 44963, 44659, 44953, 44965, 44966, 
44662, 44648, 44951, 44964, 44661
28275, 42642, 42734, 42738, 42646, 17153, 17176, 17177, 17154, 44953, 44965, 44966, 44662, 0, 0, 0, 
0, 44651, 44954, 44967, 44664
28276, 6342, 6365, 6366, 6343, 42643, 42735, 42739, 42647, 0, 0, 0, 0, 44957, 44969, 44970, 
44666, 44652, 44955, 44968, 44665
28277, 42643, 42735, 42739, 42647, 42644, 42736, 42740, 42648, 44957, 44969, 44970, 44666, 44960, 44972, 44973, 
44669, 44655, 44958, 44971, 44668
28278, 42644, 42736, 42740, 42648, 42645, 42737, 42741, 42649, 44960, 44972, 44973, 44669, 44963, 44975, 44976, 
44672, 44658, 44961, 44974, 44671
28279, 42645, 42737, 42741, 42649, 42646, 42738, 42742, 42650, 44963, 44975, 44976, 44672, 44966, 44978, 44979, 
44675, 44661, 44964, 44977, 44674
28280, 42646, 42738, 42742, 42650, 17154, 17177, 17178, 17155, 44966, 44978, 44979, 44675, 0, 0, 0, 
0, 44664, 44967, 44980, 44677
28281, 6343, 6366, 6367, 6344, 42647, 42739, 42743, 42651, 0, 0, 0, 0, 44970, 44982, 44983, 
44679, 44665, 44968, 44981, 44678
28282, 42647, 42739, 42743, 42651, 42648, 42740, 42744, 42652, 44970, 44982, 44983, 44679, 44973, 44985, 44986, 
44682, 44668, 44971, 44984, 44681
28283, 42648, 42740, 42744, 42652, 42649, 42741, 42745, 42653, 44973, 44985, 44986, 44682, 44976, 44988, 44989, 
44685, 44671, 44974, 44987, 44684
28284, 42649, 42741, 42745, 42653, 42650, 42742, 42746, 42654, 44976, 44988, 44989, 44685, 44979, 44991, 44992, 
44688, 44674, 44977, 44990, 44687
28285, 42650, 42742, 42746, 42654, 17155, 17178, 17179, 17156, 44979, 44991, 44992, 44688, 0, 0, 0, 
0, 44677, 44980, 44993, 44690
28286, 6344, 6367, 6368, 6345, 42651, 42743, 42747, 42655, 0, 0, 0, 0, 44983, 44995, 44996, 
44692, 44678, 44981, 44994, 44691
28287, 42651, 42743, 42747, 42655, 42652, 42744, 42748, 42656, 44983, 44995, 44996, 44692, 44986, 44998, 44999, 
44695, 44681, 44984, 44997, 44694
28288, 42652, 42744, 42748, 42656, 42653, 42745, 42749, 42657, 44986, 44998, 44999, 44695, 44989, 45001, 45002, 
44698, 44684, 44987, 45000, 44697
28289, 42653, 42745, 42749, 42657, 42654, 42746, 42750, 42658, 44989, 45001, 45002, 44698, 44992, 45004, 45005, 
44701, 44687, 44990, 45003, 44700
28290, 42654, 42746, 42750, 42658, 17156, 17179, 17180, 17157, 44992, 45004, 45005, 44701, 0, 0, 0, 
0, 44690, 44993, 45006, 44703
28291, 6345, 6368, 6369, 6346, 42655, 42747, 42751, 42659, 0, 0, 0, 0, 44996, 45008, 45009, 
44705, 44691, 44994, 45007, 44704
28292, 42655, 42747, 42751, 42659, 42656, 42748, 42752, 42660, 44996, 45008, 45009, 44705, 44999, 45011, 45012, 
44708, 44694, 44997, 45010, 44707
28293, 42656, 42748, 42752, 42660, 42657, 42749, 42753, 42661, 44999, 45011, 45012, 44708, 45002, 45014, 45015, 
44711, 44697, 45000, 45013, 44710
28294, 42657, 42749, 42753, 42661, 42658, 42750, 42754, 42662, 45002, 45014, 45015, 44711, 45005, 45017, 45018, 
44714, 44700, 45003, 45016, 44713
28295, 42658, 42750, 42754, 42662, 17157, 17180, 17181, 17158, 45005, 45017, 45018, 44714, 0, 0, 0, 
0, 44703, 45006, 45019, 44716
28296, 6346, 6369, 6370, 6347, 42659, 42751, 42755, 42663, 0, 0, 0, 0, 45009, 45021, 45022, 
44718, 44704, 45007, 45020, 44717
28297, 42659, 42751, 42755, 42663, 42660, 42752, 42756, 42664, 45009, 45021, 45022, 44718, 45012, 45024, 45025, 
44721, 44707, 45010, 45023, 44720
28298, 42660, 42752, 42756, 42664, 42661, 42753, 42757, 42665, 45012, 45024, 45025, 44721, 45015, 45027, 45028, 
44724, 44710, 45013, 45026, 44723
28299, 42661, 42753, 42757, 42665, 42662, 42754, 42758, 42666, 45015, 45027, 45028, 44724, 45018, 45030, 45031, 
44727, 44713, 45016, 45029, 44726
28300, 42662, 42754, 42758, 42666, 17158, 17181, 17182, 17159, 45018, 45030, 45031, 44727, 0, 0, 0, 
0, 44716, 45019, 45032, 44729
28301, 6347, 6370, 768, 767, 42663, 42755, 16918, 16914, 0, 0, 0, 0, 45022, 45033, 16987, 
44730, 44717, 45020, 16988, 16979
28302, 42663, 42755, 16918, 16914, 42664, 42756, 16919, 16915, 45022, 45033, 16987, 44730, 45025, 45034, 16989, 
44731, 44720, 45023, 16990, 16981
28303, 42664, 42756, 16919, 16915, 42665, 42757, 16920, 16916, 45025, 45034, 16989, 44731, 45028, 45035, 16991, 
44732, 44723, 45026, 16992, 16983
28304, 42665, 42757, 16920, 16916, 42666, 42758, 16921, 16917, 45028, 45035, 16991, 44732, 45031, 45036, 16993, 
44733, 44726, 45029, 16994, 16985
28305, 42666, 42758, 16921, 16917, 17159, 17182, 2166, 2165, 45031, 45036, 16993, 44733, 0, 0, 0, 
0, 44729, 45032, 16995, 16986
28306, 650, 651, 6371, 6348, 16332, 16336, 42759, 42667, 0, 0, 0, 0, 16410, 45038, 45039, 
44735, 16402, 16411, 45037, 44734
28307, 16332, 16336, 42759, 42667, 16333, 16337, 42760, 42668, 16410, 45038, 45039, 44735, 16412, 45041, 45042, 
44738, 16404, 16413, 45040, 44737
28308, 16333, 16337, 42760, 42668, 16334, 16338, 42761, 42669, 16412, 45041, 45042, 44738, 16414, 45044, 45045, 
44741, 16406, 16415, 45043, 44740
28309, 16334, 16338, 42761, 42669, 16335, 16339, 42762, 42670, 16414, 45044, 45045, 44741, 16416, 45047, 45048, 
44744, 16408, 16417, 45046, 44743
28310, 16335, 16339, 42762, 42670, 2096, 2097, 17183, 17160, 16416, 45047, 45048, 44744, 0, 0, 0, 
0, 16409, 16418, 45049, 44746
28311, 6348, 6371, 6372, 6349, 42667, 42759, 42763, 42671, 0, 0, 0, 0, 45039, 45051, 45052, 
44748, 44734, 45037, 45050, 44747
28312, 42667, 42759, 42763, 42671, 42668, 42760, 42764, 42672, 45039, 45051, 45052, 44748, 45042, 45054, 45055, 
44751, 44737, 45040, 45053, 44750
28313, 42668, 42760, 42764, 42672, 42669, 42761, 42765, 42673, 45042, 45054, 45055, 44751, 45045, 45057, 45058, 
44754, 44740, 45043, 45056, 44753
28314, 42669, 42761, 42765, 42673, 42670, 42762, 42766, 42674, 45045, 45057, 45058, 44754, 45048, 45060, 45061, 
44757, 44743, 45046, 45059, 44756
28315, 42670, 42762, 42766, 42674, 17160, 17183, 17184, 17161, 45048, 45060, 45061, 44757, 0, 0, 0, 
0, 44746, 45049, 45062, 44759
28316, 6349, 6372, 6373, 6350, 42671, 42763, 42767, 42675, 0, 0, 0, 0, 45052, 45064, 45065, 
44761, 44747, 45050, 45063, 44760
28317, 42671, 42763, 42767, 42675, 42672, 42764, 42768, 42676, 45052, 45064, 45065, 44761, 45055, 45067, 45068, 
44764, 44750, 45053, 45066, 44763
28318, 42672, 42764, 42768, 42676, 42673, 42765, 42769, 42677, 45055, 45067, 45068, 44764, 45058, 45070, 45071, 
44767, 44753, 45056, 45069, 44766
28319, 42673, 42765, 42769, 42677, 42674, 42766, 42770, 42678, 45058, 45070, 45071, 44767, 45061, 45073, 45074, 
44770, 44756, 45059, 45072, 44769
28320, 42674, 42766, 42770, 42678, 17161, 17184, 17185, 17162, 45061, 45073, 45074, 44770, 0, 0, 0, 
0, 44759, 45062, 45075, 44772
28321, 6350, 6373, 6374, 6351, 42675, 42767, 42771, 42679, 0, 0, 0, 0, 45065, 45077, 45078, 
44774, 44760, 45063, 45076, 44773
28322, 42675, 42767, 42771, 42679, 42676, 42768, 42772, 42680, 45065, 45077, 45078, 44774, 45068, 45080, 45081, 
44777, 44763, 45066, 45079, 44776
28323, 42676, 42768, 42772, 42680, 42677, 42769, 42773, 42681, 45068, 45080, 45081, 44777, 45071, 45083, 45084, 
44780, 44766, 45069, 45082, 44779
28324, 42677, 42769, 42773, 42681, 42678, 42770, 42774, 42682, 45071, 45083, 45084, 44780, 45074, 45086, 45087, 
44783, 44769, 45072, 45085, 44782
28325, 42678, 42770, 42774, 42682, 17162, 17185, 17186, 17163, 45074, 45086, 45087, 44783, 0, 0, 0, 
0, 44772, 45075, 45088, 44785
28326, 6351, 6374, 6375, 6352, 42679, 42771, 42775, 42683, 0, 0, 0, 0, 45078, 45090, 45091, 
44787, 44773, 45076, 45089, 44786
28327, 42679, 42771, 42775, 42683, 42680, 42772, 42776, 42684, 45078, 45090, 45091, 44787, 45081, 45093, 45094, 
44790, 44776, 45079, 45092, 44789
28328, 42680, 42772, 42776, 42684, 42681, 42773, 42777, 42685, 45081, 45093, 45094, 44790, 45084, 45096, 45097, 
44793, 44779, 45082, 45095, 44792
28329, 42681, 42773, 42777, 42685, 42682, 42774, 42778, 42686, 45084, 45096, 45097, 44793, 45087, 45099, 45100, 
44796, 44782, 45085, 45098, 44795
28330, 42682, 42774, 42778, 42686, 17163, 17186, 17187, 17164, 45087, 45099, 45100, 44796, 0, 0, 0, 
0, 44785, 45088, 45101, 44798
28331, 6352, 6375, 6376, 6353, 42683, 42775, 42779, 42687, 0, 0, 0, 0, 45091, 45103, 45104, 
44800, 44786, 45089, 45102, 44799
28332, 42683, 42775, 42779, 42687, 42684, 42776, 42780, 42688, 45091, 45103, 45104, 44800, 45094, 45106, 45107, 
44803, 44789, 45092, 45105, 44802
28333, 42684, 42776, 42780, 42688, 42685, 42777, 42781, 42689, 45094, 45106, 45107, 44803, 45097, 45109, 45110, 
44806, 44792, 45095, 45108, 44805
28334, 42685, 42777, 42781, 42689, 42686, 42778, 42782, 42690, 45097, 45109, 45110, 44806, 45100, 45112, 45113, 
44809, 44795, 45098, 45111, 44808
28335, 42686, 42778, 42782, 42690, 17164, 17187, 17188, 17165, 45100, 45112, 45113, 44809, 0, 0, 0, 
0, 44798, 45101, 45114, 44811
28336, 6353, 6376, 6377, 6354, 42687, 42779, 42783, 42691, 0, 0, 0, 0, 45104, 45116, 45117, 
44813, 44799, 45102, 45115, 44812
28337, 42687, 42779, 42783, 42691, 42688, 42780, 42784, 42692, 45104, 45116, 45117, 44813, 45107, 45119, 45120, 
44816, 44802, 45105, 45118, 44815
28338, 42688, 42780, 42784, 42692, 42689, 42781, 42785, 42693, 45107, 45119, 45120, 44816, 45110, 45122, 45123, 
44819, 44805, 45108, 45121, 44818
28339, 42689, 42781, 42785, 42693, 42690, 42782, 42786, 42694, 45110, 45122, 45123, 44819, 45113, 45125, 45126, 
44822, 44808, 45111, 45124, 44821
28340, 42690, 42782, 42786, 42694, 17165, 17188, 17189, 17166, 45113, 45125, 45126, 44822, 0, 0, 0, 
0, 44811, 45114, 45127, 44824
28341, 6354, 6377, 6378, 6355, 42691, 42783, 42787, 42695, 0, 0, 0, 0, 45117, 45129, 45130, 
44826, 44812, 45115, 45128, 44825
28342, 42691, 42783, 42787, 42695, 42692, 42784, 42788, 42696, 45117, 45129, 45130, 44826, 45120, 45132, 45133, 
44829, 44815, 45118, 45131, 44828
28343, 42692, 42784, 42788, 42696, 42693, 42785, 42789, 42697, 45120, 45132, 45133, 44829, 45123, 45135, 45136, 
44832, 44818, 45121, 45134, 44831
28344, 42693, 42785, 42789, 42697, 42694, 42786, 42790, 42698, 45123, 45135, 45136, 44832, 45126, 45138, 45139, 
44835, 44821, 45124, 45137, 44834
28345, 42694, 42786, 42790, 42698, 17166, 17189, 17190, 17167, 45126, 45138, 45139, 44835, 0, 0, 0, 
0, 44824, 45127, 45140, 44837
28346, 6355, 6378, 6379, 6356, 42695, 42787, 42791, 42699, 0, 0, 0, 0, 45130, 45142, 45143, 
44839, 44825, 45128, 45141, 44838
28347, 42695, 42787, 42791, 42699, 42696, 42788, 42792, 42700, 45130, 45142, 45143, 44839, 45133, 45145, 45146, 
44842, 44828, 45131, 45144, 44841
28348, 42696, 42788, 42792, 42700, 42697, 42789, 42793, 42701, 45133, 45145, 45146, 44842, 45136, 45148, 45149, 
44845, 44831, 45134, 45147, 44844
28349, 42697, 42789, 42793, 42701, 42698, 42790, 42794, 42702, 45136, 45148, 45149, 44845, 45139, 45151, 45152, 
44848, 44834, 45137, 45150, 44847
28350, 42698, 42790, 42794, 42702, 17167, 17190, 17191, 17168, 45139, 45151, 45152, 44848, 0, 0, 0, 
0, 44837, 45140, 45153, 44850
28351, 6356, 6379, 6380, 6357, 42699, 42791, 42795, 42703, 0, 0, 0, 0, 45143, 45155, 45156, 
44852, 44838, 45141, 45154, 44851
28352, 42699, 42791, 42795, 42703, 42700, 42792, 42796, 42704, 45143, 45155, 45156, 44852, 45146, 45158, 45159, 
44855, 44841, 45144, 45157, 44854
28353, 42700, 42792, 42796, 42704, 42701, 42793, 42797, 42705, 45146, 45158, 45159, 44855, 45149, 45161, 45162, 
44858, 44844, 45147, 45160, 44857
28354, 42701, 42793, 42797, 42705, 42702, 42794, 42798, 42706, 45149, 45161, 45162, 44858, 45152, 45164, 45165, 
44861, 44847, 45150, 45163, 44860
28355, 42702, 42794, 42798, 42706, 17168, 17191, 17192, 17169, 45152, 45164, 45165, 44861, 0, 0, 0, 
0, 44850, 45153, 45166, 44863
28356, 6357, 6380, 6381, 6358, 42703, 42795, 42799, 42707, 0, 0, 0, 0, 45156, 45168, 45169, 
44865, 44851, 45154, 45167, 44864
28357, 42703, 42795, 42799, 42707, 42704, 42796, 42800, 42708, 45156, 45168, 45169, 44865, 45159, 45171, 45172, 
44868, 44854, 45157, 45170, 44867
28358, 42704, 42796, 42800, 42708, 42705, 42797, 42801, 42709, 45159, 45171, 45172, 44868, 45162, 45174, 45175, 
44871, 44857, 45160, 45173, 44870
28359, 42705, 42797, 42801, 42709, 42706, 42798, 42802, 42710, 45162, 45174, 45175, 44871, 45165, 45177, 45178, 
44874, 44860, 45163, 45176, 44873
28360, 42706, 42798, 42802, 42710, 17169, 17192, 17193, 17170, 45165, 45177, 45178, 44874, 0, 0, 0, 
0, 44863, 45166, 45179, 44876
28361, 6358, 6381, 6382, 6359, 42707, 42799, 42803, 42711, 0, 0, 0, 0, 45169, 45181, 45182, 
44878, 44864, 45167, 45180, 44877
28362, 42707, 42799, 42803, 42711, 42708, 42800, 42804, 42712, 45169, 45181, 45182, 44878, 45172, 45184, 45185, 
44881, 44867, 45170, 45183, 44880
28363, 42708, 42800, 42804, 42712, 42709, 42801, 42805, 42713, 45172, 45184, 45185, 44881, 45175, 45187, 45188, 
44884, 44870, 45173, 45186, 44883
28364, 42709, 42801, 42805, 42713, 42710, 42802, 42806, 42714, 45175, 45187, 45188, 44884, 45178, 45190, 45191, 
44887, 44873, 45176, 45189, 44886
28365, 42710, 42802, 42806, 42714, 17170, 17193, 17194, 17171, 45178, 45190, 45191, 44887, 0, 0, 0, 
0, 44876, 45179, 45192, 44889
28366, 6359, 6382, 6383, 6360, 42711, 42803, 42807, 42715, 0, 0, 0, 0, 45182, 45194, 45195, 
44891, 44877, 45180, 45193, 44890
28367, 42711, 42803, 42807, 42715, 42712, 42804, 42808, 42716, 45182, 45194, 45195, 44891, 45185, 45197, 45198, 
44894, 44880, 45183, 45196, 44893
28368, 42712, 42804, 42808, 42716, 42713, 42805, 42809, 42717, 45185, 45197, 45198, 44894, 45188, 45200, 45201, 
44897, 44883, 45186, 45199, 44896
28369, 42713, 42805, 42809, 42717, 42714, 42806, 42810, 42718, 45188, 45200, 45201, 44897, 45191, 45203, 45204, 
44900, 44886, 45189, 45202, 44899
28370, 42714, 42806, 42810, 42718, 17171, 17194, 17195, 17172, 45191, 45203, 45204, 44900, 0, 0, 0, 
0, 44889, 45192, 45205, 44902
28371, 6360, 6383, 6384, 6361, 42715, 42807, 42811, 42719, 0, 0, 0, 0, 45195, 45207, 45208, 
44904, 44890, 45193, 45206, 44903
28372, 42715, 42807, 42811, 42719, 42716, 42808, 42812, 42720, 45195, 45207, 45208, 44904, 45198, 45210, 45211, 
44907, 44893, 45196, 45209, 44906
28373, 42716, 42808, 42812, 42720, 42717, 42809, 42813, 42721, 45198, 45210, 45211, 44907, 45201, 45213, 45214, 
44910, 44896, 45199, 45212, 44909
28374, 42717, 42809, 42813, 42721, 42718, 42810, 42814, 42722, 45201, 45213, 45214, 44910, 45204, 45216, 45217, 
44913, 44899, 45202, 45215, 44912
28375, 42718, 42810, 42814, 42722, 17172, 17195, 17196, 17173, 45204, 45216, 45217, 44913, 0, 0, 0, 
0, 44902, 45205, 45218, 44915
28376, 6361, 6384, 6385, 6362, 42719, 42811, 42815, 42723, 0, 0, 0, 0, 45208, 45220, 45221, 
44917, 44903, 45206, 45219, 44916
28377, 42719, 42811, 42815, 42723, 42720, 42812, 42816, 42724, 45208, 45220, 45221, 44917, 45211, 45223, 45224, 
44920, 44906, 45209, 45222, 44919
28378, 42720, 42812, 42816, 42724, 42721, 42813, 42817, 42725, 45211, 45223, 45224, 44920, 45214, 45226, 45227, 
44923, 44909, 45212, 45225, 44922
28379, 42721, 42813, 42817, 42725, 42722, 42814, 42818, 42726, 45214, 45226, 45227, 44923, 45217, 45229, 45230, 
44926, 44912, 45215, 45228, 44925
28380, 42722, 42814, 42818, 42726, 17173, 17196, 17197, 17174, 45217, 45229, 45230, 44926, 0, 0, 0, 
0, 44915, 45218, 45231, 44928
28381, 6362, 6385, 6386, 6363, 42723, 42815, 42819, 42727, 0, 0, 0, 0, 45221, 45233, 45234, 
44930, 44916, 45219, 45232, 44929
28382, 42723, 42815, 42819, 42727, 42724, 42816, 42820, 42728, 45221, 45233, 45234, 44930, 45224, 45236, 45237, 
44933, 44919, 45222, 45235, 44932
28383, 42724, 42816, 42820, 42728, 42725, 42817, 42821, 42729, 45224, 45236, 45237, 44933, 45227, 45239, 45240, 
44936, 44922, 45225, 45238, 44935
28384, 42725, 42817, 42821, 42729, 42726, 42818, 42822, 42730, 45227, 45239, 45240, 44936, 45230, 45242, 45243, 
44939, 44925, 45228, 45241, 44938
28385, 42726, 42818, 42822, 42730, 17174, 17197, 17198, 17175, 45230, 45242, 45243, 44939, 0, 0, 0, 
0, 44928, 45231, 45244, 44941
28386, 6363, 6386, 6387, 6364, 42727, 42819, 42823, 42731, 0, 0, 0, 0, 45234, 45246, 45247, 
44943, 44929, 45232, 45245, 44942
28387, 42727, 42819, 42823, 42731, 42728, 42820, 42824, 42732, 45234, 45246, 45247, 44943, 45237, 45249, 45250, 
44946, 44932, 45235, 45248, 44945
28388, 42728, 42820, 42824, 42732, 42729, 42821, 42825, 42733, 45237, 45249, 45250, 44946, 45240, 45252, 45253, 
44949, 44935, 45238, 45251, 44948
28389, 42729, 42821, 42825, 42733, 42730, 42822, 42826, 42734, 45240, 45252, 45253, 44949, 45243, 45255, 45256, 
44952, 44938, 45241, 45254, 44951
28390, 42730, 42822, 42826, 42734, 17175, 17198, 17199, 17176, 45243, 45255, 45256, 44952, 0, 0, 0, 
0, 44941, 45244, 45257, 44954
28391, 6364, 6387, 6388, 6365, 42731, 42823, 42827, 42735, 0, 0, 0, 0, 45247, 45259, 45260, 
44956, 44942, 45245, 45258, 44955
28392, 42731, 42823, 42827, 42735, 42732, 42824, 42828, 42736, 45247, 45259, 45260, 44956, 45250, 45262, 45263, 
44959, 44945, 45248, 45261, 44958
28393, 42732, 42824, 42828, 42736, 42733, 42825, 42829, 42737, 45250, 45262, 45263, 44959, 45253, 45265, 45266, 
44962, 44948, 45251, 45264, 44961
28394, 42733, 42825, 42829, 42737, 42734, 42826, 42830, 42738, 45253, 45265, 45266, 44962, 45256, 45268, 45269, 
44965, 44951, 45254, 45267, 44964
28395, 42734, 42826, 42830, 42738, 17176, 17199, 17200, 17177, 45256, 45268, 45269, 44965, 0, 0, 0, 
0, 44954, 45257, 45270, 44967
28396, 6365, 6388, 6389, 6366, 42735, 42827, 42831, 42739, 0, 0, 0, 0, 45260, 45272, 45273, 
44969, 44955, 45258, 45271, 44968
28397, 42735, 42827, 42831, 42739, 42736, 42828, 42832, 42740, 45260, 45272, 45273, 44969, 45263, 45275, 45276, 
44972, 44958, 45261, 45274, 44971
28398, 42736, 42828, 42832, 42740, 42737, 42829, 42833, 42741, 45263, 45275, 45276, 44972, 45266, 45278, 45279, 
44975, 44961, 45264, 45277, 44974
28399, 42737, 42829, 42833, 42741, 42738, 42830, 42834, 42742, 45266, 45278, 45279, 44975, 45269, 45281, 45282, 
44978, 44964, 45267, 45280, 44977
28400, 42738, 42830, 42834, 42742, 17177, 17200, 17201, 17178, 45269, 45281, 45282, 44978, 0, 0, 0, 
0, 44967, 45270, 45283, 44980
28401, 6366, 6389, 6390, 6367, 42739, 42831, 42835, 42743, 0, 0, 0, 0, 45273, 45285, 45286, 
44982, 44968, 45271, 45284, 44981
28402, 42739, 42831, 42835, 42743, 42740, 42832, 42836, 42744, 45273, 45285, 45286, 44982, 45276, 45288, 45289, 
44985, 44971, 45274, 45287, 44984
28403, 42740, 42832, 42836, 42744, 42741, 42833, 42837, 42745, 45276, 45288, 45289, 44985, 45279, 45291, 45292, 
44988, 44974, 45277, 45290, 44987
28404, 42741, 42833, 42837, 42745, 42742, 42834, 42838, 42746, 45279, 45291, 45292, 44988, 45282, 45294, 45295, 
44991, 44977, 45280, 45293, 44990
28405, 42742, 42834, 42838, 42746, 17178, 17201, 17202, 17179, 45282, 45294, 45295, 44991, 0, 0, 0, 
0, 44980, 45283, 45296, 44993
28406, 6367, 6390, 6391, 6368, 42743, 42835, 42839, 42747, 0, 0, 0, 0, 45286, 45298, 45299, 
44995, 44981, 45284, 45297, 44994
28407, 42743, 42835, 42839, 42747, 42744, 42836, 42840, 42748, 45286, 45298, 45299, 44995, 45289, 45301, 45302, 
44998, 44984, 45287, 45300, 44997
28408, 42744, 42836, 42840, 42748, 42745, 42837, 42841, 42749, 45289, 45301, 45302, 44998, 45292, 45304, 45305, 
45001, 44987, 45290, 45303, 45000
28409, 42745, 42837, 42841, 42749, 42746, 42838, 42842, 42750, 45292, 45304, 45305, 45001, 45295, 45307, 45308, 
45004, 44990, 45293, 45306, 45003
28410, 42746, 42838, 42842, 42750, 17179, 17202, 17203, 17180, 45295, 45307, 45308, 45004, 0, 0, 0, 
0, 44993, 45296, 45309, 45006
28411, 6368, 6391, 6392, 6369, 42747, 42839, 42843, 42751, 0, 0, 0, 0, 45299, 45311, 45312, 
45008, 44994, 45297, 45310, 45007
28412, 42747, 42839, 42843, 42751, 42748, 42840, 42844, 42752, 45299, 45311, 45312, 45008, 45302, 45314, 45315, 
45011, 44997, 45300, 45313, 45010
28413, 42748, 42840, 42844, 42752, 42749, 42841, 42845, 42753, 45302, 45314, 45315, 45011, 45305, 45317, 45318, 
45014, 45000, 45303, 45316, 45013
28414, 42749, 42841, 42845, 42753, 42750, 42842, 42846, 42754, 45305, 45317, 45318, 45014, 45308, 45320, 45321, 
45017, 45003, 45306, 45319, 45016
28415, 42750, 42842, 42846, 42754, 17180, 17203, 17204, 17181, 45308, 45320, 45321, 45017, 0, 0, 0, 
0, 45006, 45309, 45322, 45019
28416, 6369, 6392, 6393, 6370, 42751, 42843, 42847, 42755, 0, 0, 0, 0, 45312, 45324, 45325, 
45021, 45007, 45310, 45323, 45020
28417, 42751, 42843, 42847, 42755, 42752, 42844, 42848, 42756, 45312, 45324, 45325, 45021, 45315, 45327, 45328, 
45024, 45010, 45313, 45326, 45023
28418, 42752, 42844, 42848, 42756, 42753, 42845, 42849, 42757, 45315, 45327, 45328, 45024, 45318, 45330, 45331, 
45027, 45013, 45316, 45329, 45026
28419, 42753, 42845, 42849, 42757, 42754, 42846, 42850, 42758, 45318, 45330, 45331, 45027, 45321, 45333, 45334, 
45030, 45016, 45319, 45332, 45029
28420, 42754, 42846, 42850, 42758, 17181, 17204, 17205, 17182, 45321, 45333, 45334, 45030, 0, 0, 0, 
0, 45019, 45322, 45335, 45032
28421, 6370, 6393, 769, 768, 42755, 42847, 16922, 16918, 0, 0, 0, 0, 45325, 45336, 16996, 
45033, 45020, 45323, 16997, 16988
28422, 42755, 42847, 16922, 16918, 42756, 42848, 16923, 16919, 45325, 45336, 16996, 45033, 45328, 45337, 16998, 
45034, 45023, 45326, 16999, 16990
28423, 42756, 42848, 16923, 16919, 42757, 42849, 16924, 16920, 45328, 45337, 16998, 45034, 45331, 45338, 17000, 
45035, 45026, 45329, 17001, 16992
28424, 42757, 42849, 16924, 16920, 42758, 42850, 16925, 16921, 45331, 45338, 17000, 45035, 45334, 45339, 17002, 
45036, 45029, 45332, 17003, 16994
28425, 42758, 42850, 16925, 16921, 17182, 17205, 2167, 2166, 45334, 45339, 17002, 45036, 0, 0, 0, 
0, 45032, 45335, 17004, 16995
28426, 651, 652, 6394, 6371, 16336, 16340, 42851, 42759, 0, 0, 0, 0, 16419, 45341, 45342, 
45038, 16411, 16420, 45340, 45037
28427, 16336, 16340, 42851, 42759, 16337, 16341, 42852, 42760, 16419, 45341, 45342, 45038, 16421, 45344, 45345, 
45041, 16413, 16422, 45343, 45040
28428, 16337, 16341, 42852, 42760, 16338, 16342, 42853, 42761, 16421, 45344, 45345, 45041, 16423, 45347, 45348, 
45044, 16415, 16424, 45346, 45043
28429, 16338, 16342, 42853, 42761, 16339, 16343, 42854, 42762, 16423, 45347, 45348, 45044, 16425, 45350, 45351, 
45047, 16417, 16426, 45349, 45046
28430, 16339, 16343, 42854, 42762, 2097, 2098, 17206, 17183, 16425, 45350, 45351, 45047, 0, 0, 0, 
0, 16418, 16427, 45352, 45049
28431, 6371, 6394, 6395, 6372, 42759, 42851, 42855, 42763, 0, 0, 0, 0, 45342, 45354, 45355, 
45051, 45037, 45340, 45353, 45050
28432, 42759, 42851, 42855, 42763, 42760, 42852, 42856, 42764, 45342, 45354, 45355, 45051, 45345, 45357, 45358, 
45054, 45040, 45343, 45356, 45053
28433, 42760, 42852, 42856, 42764, 42761, 42853, 42857, 42765, 45345, 45357, 45358, 45054, 45348, 45360, 45361, 
45057, 45043, 45346, 45359, 45056
28434, 42761, 42853, 42857, 42765, 42762, 42854, 42858, 42766, 45348, 45360, 45361, 45057, 45351, 45363, 45364, 
45060, 45046, 45349, 45362, 45059
28435, 42762, 42854, 42858, 42766, 17183, 17206, 17207, 17184, 45351, 45363, 45364, 45060, 0, 0, 0, 
0, 45049, 45352, 45365, 45062
28436, 6372, 6395, 6396, 6373, 42763, 42855, 42859, 42767, 0, 0, 0, 0, 45355, 45367, 45368, 
45064, 45050, 45353, 45366, 45063
28437, 42763, 42855, 42859, 42767, 42764, 42856, 42860, 42768, 45355, 45367, 45368, 45064, 45358, 45370, 45371, 
45067, 45053, 45356, 45369, 45066
28438, 42764, 42856, 42860, 42768, 42765, 42857, 42861, 42769, 45358, 45370, 45371, 45067, 45361, 45373, 45374, 
45070, 45056, 45359, 45372, 45069
28439, 42765, 42857, 42861, 42769, 42766, 42858, 42862, 42770, 45361, 45373, 45374, 45070, 45364, 45376, 45377, 
45073, 45059, 45362, 45375, 45072
28440, 42766, 42858, 42862, 42770, 17184, 17207, 17208, 17185, 45364, 45376, 45377, 45073, 0, 0, 0, 
0, 45062, 45365, 45378, 45075
28441, 6373, 6396, 6397, 6374, 42767, 42859, 42863, 42771, 0, 0, 0, 0, 45368, 45380, 45381, 
45077, 45063, 45366, 45379, 45076
28442, 42767, 42859, 42863, 42771, 42768, 42860, 42864, 42772, 45368, 45380, 45381, 45077, 45371, 45383, 45384, 
45080, 45066, 45369, 45382, 45079
28443, 42768, 42860, 42864, 42772, 42769, 42861, 42865, 42773, 45371, 45383, 45384, 45080, 45374, 45386, 45387, 
45083, 45069, 45372, 45385, 45082
28444, 42769, 42861, 42865, 42773, 42770, 42862, 42866, 42774, 45374, 45386, 45387, 45083, 45377, 45389, 45390, 
45086, 45072, 45375, 45388, 45085
28445, 42770, 42862, 42866, 42774, 17185, 17208, 17209, 17186, 45377, 45389, 45390, 45086, 0, 0, 0, 
0, 45075, 45378, 45391, 45088
28446, 6374, 6397, 6398, 6375, 42771, 42863, 42867, 42775, 0, 0, 0, 0, 45381, 45393, 45394, 
45090, 45076, 45379, 45392, 45089
28447, 42771, 42863, 42867, 42775, 42772, 42864, 42868, 42776, 45381, 45393, 45394, 45090, 45384, 45396, 45397, 
45093, 45079, 45382, 45395, 45092
28448, 42772, 42864, 42868, 42776, 42773, 42865, 42869, 42777, 45384, 45396, 45397, 45093, 45387, 45399, 45400, 
45096, 45082, 45385, 45398, 45095
28449, 42773, 42865, 42869, 42777, 42774, 42866, 42870, 42778, 45387, 45399, 45400, 45096, 45390, 45402, 45403, 
45099, 45085, 45388, 45401, 45098
28450, 42774, 42866, 42870, 42778, 17186, 17209, 17210, 17187, 45390, 45402, 45403, 45099, 0, 0, 0, 
0, 45088, 45391, 45404, 45101
28451, 6375, 6398, 6399, 6376, 42775, 42867, 42871, 42779, 0, 0, 0, 0, 45394, 45406, 45407, 
45103, 45089, 45392, 45405, 45102
28452, 42775, 42867, 42871, 42779, 42776, 42868, 42872, 42780, 45394, 45406, 45407, 45103, 45397, 45409, 45410, 
45106, 45092, 45395, 45408, 45105
28453, 42776, 42868, 42872, 42780, 42777, 42869, 42873, 42781, 45397, 45409, 45410, 45106, 45400, 45412, 45413, 
45109, 45095, 45398, 45411, 45108
28454, 42777, 42869, 42873, 42781, 42778, 42870, 42874, 42782, 45400, 45412, 45413, 45109, 45403, 45415, 45416, 
45112, 45098, 45401, 45414, 45111
28455, 42778, 42870, 42874, 42782, 17187, 17210, 17211, 17188, 45403, 45415, 45416, 45112, 0, 0, 0, 
0, 45101, 45404, 45417, 45114
28456, 6376, 6399, 6400, 6377, 42779, 42871, 42875, 42783, 0, 0, 0, 0, 45407, 45419, 45420, 
45116, 45102, 45405, 45418, 45115
28457, 42779, 42871, 42875, 42783, 42780, 42872, 42876, 42784, 45407, 45419, 45420, 45116, 45410, 45422, 45423, 
45119, 45105, 45408, 45421, 45118
28458, 42780, 42872, 42876, 42784, 42781, 42873, 42877, 42785, 45410, 45422, 45423, 45119, 45413, 45425, 45426, 
45122, 45108, 45411, 45424, 45121
28459, 42781, 42873, 42877, 42785, 42782, 42874, 42878, 42786, 45413, 45425, 45426, 45122, 45416, 45428, 45429, 
45125, 45111, 45414, 45427, 45124
28460, 42782, 42874, 42878, 42786, 17188, 17211, 17212, 17189, 45416, 45428, 45429, 45125, 0, 0, 0, 
0, 45114, 45417, 45430, 45127
28461, 6377, 6400, 6401, 6378, 42783, 42875, 42879, 42787, 0, 0, 0, 0, 45420, 45432, 45433, 
45129, 45115, 45418, 45431, 45128
28462, 42783, 42875, 42879, 42787, 42784, 42876, 42880, 42788, 45420, 45432, 45433, 45129, 45423, 45435, 45436, 
45132, 45118, 45421, 45434, 45131
28463, 42784, 42876, 42880, 42788, 42785, 42877, 42881, 42789, 45423, 45435, 45436, 45132, 45426, 45438, 45439, 
45135, 45121, 45424, 45437, 45134
28464, 42785, 42877, 42881, 42789, 42786, 42878, 42882, 42790, 45426, 45438, 45439, 45135, 45429, 45441, 45442, 
45138, 45124, 45427, 45440, 45137
28465, 42786, 42878, 42882, 42790, 17189, 17212, 17213, 17190, 45429, 45441, 45442, 45138, 0, 0, 0, 
0, 45127, 45430, 45443, 45140
28466, 6378, 6401, 6402, 6379, 42787, 42879, 42883, 42791, 0, 0, 0, 0, 45433, 45445, 45446, 
45142, 45128, 45431, 45444, 45141
28467, 42787, 42879, 42883, 42791, 42788, 42880, 42884, 42792, 45433, 45445, 45446, 45142, 45436, 45448, 45449, 
45145, 45131, 45434, 45447, 45144
28468, 42788, 42880, 42884, 42792, 42789, 42881, 42885, 42793, 45436, 45448, 45449, 45145, 45439, 45451, 45452, 
45148, 45134, 45437, 45450, 45147
28469, 42789, 42881, 42885, 42793, 42790, 42882, 42886, 42794, 45439, 45451, 45452, 45148, 45442, 45454, 45455, 
45151, 45137, 45440, 45453, 45150
28470, 42790, 42882, 42886, 42794, 17190, 17213, 17214, 17191, 45442, 45454, 45455, 45151, 0, 0, 0, 
0, 45140, 45443, 45456, 45153
28471, 6379, 6402, 6403, 6380, 42791, 42883, 42887, 42795, 0, 0, 0, 0, 45446, 45458, 45459, 
45155, 45141, 45444, 45457, 45154
28472, 42791, 42883, 42887, 42795, 42792, 42884, 42888, 42796, 45446, 45458, 45459, 45155, 45449, 45461, 45462, 
45158, 45144, 45447, 45460, 45157
28473, 42792, 42884, 42888, 42796, 42793, 42885, 42889, 42797, 45449, 45461, 45462, 45158, 45452, 45464, 45465, 
45161, 45147, 45450, 45463, 45160
28474, 42793, 42885, 42889, 42797, 42794, 42886, 42890, 42798, 45452, 45464, 45465, 45161, 45455, 45467, 45468, 
45164, 45150, 45453, 45466, 45163
28475, 42794, 42886, 42890, 42798, 17191, 17214, 17215, 17192, 45455, 45467, 45468, 45164, 0, 0, 0, 
0, 45153, 45456, 45469, 45166
28476, 6380, 6403, 6404, 6381, 42795, 42887, 42891, 42799, 0, 0, 0, 0, 45459, 45471, 45472, 
45168, 45154, 45457, 45470, 45167
28477, 42795, 42887, 42891, 42799, 42796, 42888, 42892, 42800, 45459, 45471, 45472, 45168, 45462, 45474, 45475, 
45171, 45157, 45460, 45473, 45170
28478, 42796, 42888, 42892, 42800, 42797, 42889, 42893, 42801, 45462, 45474, 45475, 45171, 45465, 45477, 45478, 
45174, 45160, 45463, 45476, 45173
28479, 42797, 42889, 42893, 42801, 42798, 42890, 42894, 42802, 45465, 45477, 45478, 45174, 45468, 45480, 45481, 
45177, 45163, 45466, 45479, 45176
28480, 42798, 42890, 42894, 42802, 17192, 17215, 17216, 17193, 45468, 45480, 45481, 45177, 0, 0, 0, 
0, 45166, 45469, 45482, 45179
28481, 6381, 6404, 6405, 6382, 42799, 42891, 42895, 42803, 0, 0, 0, 0, 45472, 45484, 45485, 
45181, 45167, 45470, 45483, 45180
28482, 42799, 42891, 42895, 42803, 42800, 42892, 42896, 42804, 45472, 45484, 45485, 45181, 45475, 45487, 45488, 
45184, 45170, 45473, 45486, 45183
28483, 42800, 42892, 42896, 42804, 42801, 42893, 42897, 42805, 45475, 45487, 45488, 45184, 45478, 45490, 45491, 
45187, 45173, 45476, 45489, 45186
28484, 42801, 42893, 42897, 42805, 42802, 42894, 42898, 42806, 45478, 45490, 45491, 45187, 45481, 45493, 45494, 
45190, 45176, 45479, 45492, 45189
28485, 42802, 42894, 42898, 42806, 17193, 17216, 17217, 17194, 45481, 45493, 45494, 45190, 0, 0, 0, 
0, 45179, 45482, 45495, 45192
28486, 6382, 6405, 6406, 6383, 42803, 42895, 42899, 42807, 0, 0, 0, 0, 45485, 45497, 45498, 
45194, 45180, 45483, 45496, 45193
28487, 42803, 42895, 42899, 42807, 42804, 42896, 42900, 42808, 45485, 45497, 45498, 45194, 45488, 45500, 45501, 
45197, 45183, 45486, 45499, 45196
28488, 42804, 42896, 42900, 42808, 42805, 42897, 42901, 42809, 45488, 45500, 45501, 45197, 45491, 45503, 45504, 
45200, 45186, 45489, 45502, 45199
28489, 42805, 42897, 42901, 42809, 42806, 42898, 42902, 42810, 45491, 45503, 45504, 45200, 45494, 45506, 45507, 
45203, 45189, 45492, 45505, 45202
28490, 42806, 42898, 42902, 42810, 17194, 17217, 17218, 17195, 45494, 45506, 45507, 45203, 0, 0, 0, 
0, 45192, 45495, 45508, 45205
28491, 6383, 6406, 6407, 6384, 42807, 42899, 42903, 42811, 0, 0, 0, 0, 45498, 45510, 45511, 
45207, 45193, 45496, 45509, 45206
28492, 42807, 42899, 42903, 42811, 42808, 42900, 42904, 42812, 45498, 45510, 45511, 45207, 45501, 45513, 45514, 
45210, 45196, 45499, 45512, 45209
28493, 42808, 42900, 42904, 42812, 42809, 42901, 42905, 42813, 45501, 45513, 45514, 45210, 45504, 45516, 45517, 
45213, 45199, 45502, 45515, 45212
28494, 42809, 42901, 42905, 42813, 42810, 42902, 42906, 42814, 45504, 45516, 45517, 45213, 45507, 45519, 45520, 
45216, 45202, 45505, 45518, 45215
28495, 42810, 42902, 42906, 42814, 17195, 17218, 17219, 17196, 45507, 45519, 45520, 45216, 0, 0, 0, 
0, 45205, 45508, 45521, 45218
28496, 6384, 6407, 6408, 6385, 42811, 42903, 42907, 42815, 0, 0, 0, 0, 45511, 45523, 45524, 
45220, 45206, 45509, 45522, 45219
28497, 42811, 42903, 42907, 42815, 42812, 42904, 42908, 42816, 45511, 45523, 45524, 45220, 45514, 45526, 45527, 
45223, 45209, 45512, 45525, 45222
28498, 42812, 42904, 42908, 42816, 42813, 42905, 42909, 42817, 45514, 45526, 45527, 45223, 45517, 45529, 45530, 
45226, 45212, 45515, 45528, 45225
28499, 42813, 42905, 42909, 42817, 42814, 42906, 42910, 42818, 45517, 45529, 45530, 45226, 45520, 45532, 45533, 
45229, 45215, 45518, 45531, 45228
28500, 42814, 42906, 42910, 42818, 17196, 17219, 17220, 17197, 45520, 45532, 45533, 45229, 0, 0, 0, 
0, 45218, 45521, 45534, 45231
28501, 6385, 6408, 6409, 6386, 42815, 42907, 42911, 42819, 0, 0, 0, 0, 45524, 45536, 45537, 
45233, 45219, 45522, 45535, 45232
28502, 42815, 42907, 42911, 42819, 42816, 42908, 42912, 42820, 45524, 45536, 45537, 45233, 45527, 45539, 45540, 
45236, 45222, 45525, 45538, 45235
28503, 42816, 42908, 42912, 42820, 42817, 42909, 42913, 42821, 45527, 45539, 45540, 45236, 45530, 45542, 45543, 
45239, 45225, 45528, 45541, 45238
28504, 42817, 42909, 42913, 42821, 42818, 42910, 42914, 42822, 45530, 45542, 45543, 45239, 45533, 45545, 45546, 
45242, 45228, 45531, 45544, 45241
28505, 42818, 42910, 42914, 42822, 17197, 17220, 17221, 17198, 45533, 45545, 45546, 45242, 0, 0, 0, 
0, 45231, 45534, 45547, 45244
28506, 6386, 6409, 6410, 6387, 42819, 42911, 42915, 42823, 0, 0, 0, 0, 45537, 45549, 45550, 
45246, 45232, 45535, 45548, 45245
28507, 42819, 42911, 42915, 42823, 42820, 42912, 42916, 42824, 45537, 45549, 45550, 45246, 45540, 45552, 45553, 
45249, 45235, 45538, 45551, 45248
28508, 42820, 42912, 42916, 42824, 42821, 42913, 42917, 42825, 45540, 45552, 45553, 45249, 45543, 45555, 45556, 
45252, 45238, 45541, 45554, 45251
28509, 42821, 42913, 42917, 42825, 42822, 42914, 42918, 42826, 45543, 45555, 45556, 45252, 45546, 45558, 45559, 
45255, 45241, 45544, 45557, 45254
28510, 42822, 42914, 42918, 42826, 17198, 17221, 17222, 17199, 45546, 45558, 45559, 45255, 0, 0, 0, 
0, 45244, 45547, 45560, 45257
28511, 6387, 6410, 6411, 6388, 42823, 42915, 42919, 42827, 0, 0, 0, 0, 45550, 45562, 45563, 
45259, 45245, 45548, 45561, 45258
28512, 42823, 42915, 42919, 42827, 42824, 42916, 42920, 42828, 45550, 45562, 45563, 45259, 45553, 45565, 45566, 
45262, 45248, 45551, 45564, 45261
28513, 42824, 42916, 42920, 42828, 42825, 42917, 42921, 42829, 45553, 45565, 45566, 45262, 45556, 45568, 45569, 
45265, 45251, 45554, 45567, 45264
28514, 42825, 42917, 42921, 42829, 42826, 42918, 42922, 42830, 45556, 45568, 45569, 45265, 45559, 45571, 45572, 
45268, 45254, 45557, 45570, 45267
28515, 42826, 42918, 42922, 42830, 17199, 17222, 17223, 17200, 45559, 45571, 45572, 45268, 0, 0, 0, 
0, 45257, 45560, 45573, 45270
28516, 6388, 6411, 6412, 6389, 42827, 42919, 42923, 42831, 0, 0, 0, 0, 45563, 45575, 45576, 
45272, 45258, 45561, 45574, 45271
28517, 42827, 42919, 42923, 42831, 42828, 42920, 42924, 42832, 45563, 45575, 45576, 45272, 45566, 45578, 45579, 
45275, 45261, 45564, 45577, 45274
28518, 42828, 42920, 42924, 42832, 42829, 42921, 42925, 42833, 45566, 45578, 45579, 45275, 45569, 45581, 45582, 
45278, 45264, 45567, 45580, 45277
28519, 42829, 42921, 42925, 42833, 42830, 42922, 42926, 42834, 45569, 45581, 45582, 45278, 45572, 45584, 45585, 
45281, 45267, 45570, 45583, 45280
28520, 42830, 42922, 42926, 42834, 17200, 17223, 17224, 17201, 45572, 45584, 45585, 45281, 0, 0, 0, 
0, 45270, 45573, 45586, 45283
28521, 6389, 6412, 6413, 6390, 42831, 42923, 42927, 42835, 0, 0, 0, 0, 45576, 45588, 45589, 
45285, 45271, 45574, 45587, 45284
28522, 42831, 42923, 42927, 42835, 42832, 42924, 42928, 42836, 45576, 45588, 45589, 45285, 45579, 45591, 45592, 
45288, 45274, 45577, 45590, 45287
28523, 42832, 42924, 42928, 42836, 42833, 42925, 42929, 42837, 45579, 45591, 45592, 45288, 45582, 45594, 45595, 
45291, 45277, 45580, 45593, 45290
28524, 42833, 42925, 42929, 42837, 42834, 42926, 42930, 42838, 45582, 45594, 45595, 45291, 45585, 45597, 45598, 
45294, 45280, 45583, 45596, 45293
28525, 42834, 42926, 42930, 42838, 17201, 17224, 17225, 17202, 45585, 45597, 45598, 45294, 0, 0, 0, 
0, 45283, 45586, 45599, 45296
28526, 6390, 6413, 6414, 6391, 42835, 42927, 42931, 42839, 0, 0, 0, 0, 45589, 45601, 45602, 
45298, 45284, 45587, 45600, 45297
28527, 42835, 42927, 42931, 42839, 42836, 42928, 42932, 42840, 45589, 45601, 45602, 45298, 45592, 45604, 45605, 
45301, 45287, 45590, 45603, 45300
28528, 42836, 42928, 42932, 42840, 42837, 42929, 42933, 42841, 45592, 45604, 45605, 45301, 45595, 45607, 45608, 
45304, 45290, 45593, 45606, 45303
28529, 42837, 42929, 42933, 42841, 42838, 42930, 42934, 42842, 45595, 45607, 45608, 45304, 45598, 45610, 45611, 
45307, 45293, 45596, 45609, 45306
28530, 42838, 42930, 42934, 42842, 17202, 17225, 17226, 17203, 45598, 45610, 45611, 45307, 0, 0, 0, 
0, 45296, 45599, 45612, 45309
28531, 6391, 6414, 6415, 6392, 42839, 42931, 42935, 42843, 0, 0, 0, 0, 45602, 45614, 45615, 
45311, 45297, 45600, 45613, 45310
28532, 42839, 42931, 42935, 42843, 42840, 42932, 42936, 42844, 45602, 45614, 45615, 45311, 45605, 45617, 45618, 
45314, 45300, 45603, 45616, 45313
28533, 42840, 42932, 42936, 42844, 42841, 42933, 42937, 42845, 45605, 45617, 45618, 45314, 45608, 45620, 45621, 
45317, 45303, 45606, 45619, 45316
28534, 42841, 42933, 42937, 42845, 42842, 42934, 42938, 42846, 45608, 45620, 45621, 45317, 45611, 45623, 45624, 
45320, 45306, 45609, 45622, 45319
28535, 42842, 42934, 42938, 42846, 17203, 17226, 17227, 17204, 45611, 45623, 45624, 45320, 0, 0, 0, 
0, 45309, 45612, 45625, 45322
28536, 6392, 6415, 6416, 6393, 42843, 42935, 42939, 42847, 0, 0, 0, 0, 45615, 45627, 45628, 
45324, 45310, 45613, 45626, 45323
28537, 42843, 42935, 42939, 42847, 42844, 42936, 42940, 42848, 45615, 45627, 45628, 45324, 45618, 45630, 45631, 
45327, 45313, 45616, 45629, 45326
28538, 42844, 42936, 42940, 42848, 42845, 42937, 42941, 42849, 45618, 45630, 45631, 45327, 45621, 45633, 45634, 
45330, 45316, 45619, 45632, 45329
28539, 42845, 42937, 42941, 42849, 42846, 42938, 42942, 42850, 45621, 45633, 45634, 45330, 45624, 45636, 45637, 
45333, 45319, 45622, 45635, 45332
28540, 42846, 42938, 42942, 42850, 17204, 17227, 17228, 17205, 45624, 45636, 45637, 45333, 0, 0, 0, 
0, 45322, 45625, 45638, 45335
28541, 6393, 6416, 770, 769, 42847, 42939, 16926, 16922, 0, 0, 0, 0, 45628, 45639, 17005, 
45336, 45323, 45626, 17006, 16997
28542, 42847, 42939, 16926, 16922, 42848, 42940, 16927, 16923, 45628, 45639, 17005, 45336, 45631, 45640, 17007, 
45337, 45326, 45629, 17008, 16999
28543, 42848, 42940, 16927, 16923, 42849, 42941, 16928, 16924, 45631, 45640, 17007, 45337, 45634, 45641, 17009, 
45338, 45329, 45632, 17010, 17001
28544, 42849, 42941, 16928, 16924, 42850, 42942, 16929, 16925, 45634, 45641, 17009, 45338, 45637, 45642, 17011, 
45339, 45332, 45635, 17012, 17003
28545, 42850, 42942, 16929, 16925, 17205, 17228, 2168, 2167, 45637, 45642, 17011, 45339, 0, 0, 0, 
0, 45335, 45638, 17013, 17004
28546, 652, 653, 6417, 6394, 16340, 16344, 42943, 42851, 0, 0, 0, 0, 16428, 45644, 45645, 
45341, 16420, 16429, 45643, 45340
28547, 16340, 16344, 42943, 42851, 16341, 16345, 42944, 42852, 16428, 45644, 45645, 45341, 16430, 45647, 45648, 
45344, 16422, 16431, 45646, 45343
28548, 16341, 16345, 42944, 42852, 16342, 16346, 42945, 42853, 16430, 45647, 45648, 45344, 16432, 45650, 45651, 
45347, 16424, 16433, 45649, 45346
28549, 16342, 16346, 42945, 42853, 16343, 16347, 42946, 42854, 16432, 45650, 45651, 45347, 16434, 45653, 45654, 
45350, 16426, 16435, 45652, 45349
28550, 16343, 16347, 42946, 42854, 2098, 2099, 17229, 17206, 16434, 45653, 45654, 45350, 0, 0, 0, 
0, 16427, 16436, 45655, 45352
28551, 6394, 6417, 6418, 6395, 42851, 42943, 42947, 42855, 0, 0, 0, 0, 45645, 45657, 45658, 
45354, 45340, 45643, 45656, 45353
28552, 42851, 42943, 42947, 42855, 42852, 42944, 42948, 42856, 45645, 45657, 45658, 45354, 45648, 45660, 45661, 
45357, 45343, 45646, 45659, 45356
28553, 42852, 42944, 42948, 42856, 42853, 42945, 42949, 42857, 45648, 45660, 45661, 45357, 45651, 45663, 45664, 
45360, 45346, 45649, 45662, 45359
28554, 42853, 42945, 42949, 42857, 42854, 42946, 42950, 42858, 45651, 45663, 45664, 45360, 45654, 45666, 45667, 
45363, 45349, 45652, 45665, 45362
28555, 42854, 42946, 42950, 42858, 17206, 17229, 17230, 17207, 45654, 45666, 45667, 45363, 0, 0, 0, 
0, 45352, 45655, 45668, 45365
28556, 6395, 6418, 6419, 6396, 42855, 42947, 42951, 42859, 0, 0, 0, 0, 45658, 45670, 45671, 
45367, 45353, 45656, 45669, 45366
28557, 42855, 42947, 42951, 42859, 42856, 42948, 42952, 42860, 45658, 45670, 45671, 45367, 45661, 45673, 45674, 
45370, 45356, 45659, 45672, 45369
28558, 42856, 42948, 42952, 42860, 42857, 42949, 42953, 42861, 45661, 45673, 45674, 45370, 45664, 45676, 45677, 
45373, 45359, 45662, 45675, 45372
28559, 42857, 42949, 42953, 42861, 42858, 42950, 42954, 42862, 45664, 45676, 45677, 45373, 45667, 45679, 45680, 
45376, 45362, 45665, 45678, 45375
28560, 42858, 42950, 42954, 42862, 17207, 17230, 17231, 17208, 45667, 45679, 45680, 45376, 0, 0, 0, 
0, 45365, 45668, 45681, 45378
28561, 6396, 6419, 6420, 6397, 42859, 42951, 42955, 42863, 0, 0, 0, 0, 45671, 45683, 45684, 
45380, 45366, 45669, 45682, 45379
28562, 42859, 42951, 42955, 42863, 42860, 42952, 42956, 42864, 45671, 45683, 45684, 45380, 45674, 45686, 45687, 
45383, 45369, 45672, 45685, 45382
28563, 42860, 42952, 42956, 42864, 42861, 42953, 42957, 42865, 45674, 45686, 45687, 45383, 45677, 45689, 45690, 
45386, 45372, 45675, 45688, 45385
28564, 42861, 42953, 42957, 42865, 42862, 42954, 42958, 42866, 45677, 45689, 45690, 45386, 45680, 45692, 45693, 
45389, 45375, 45678, 45691, 45388
28565, 42862, 42954, 42958, 42866, 17208, 17231, 17232, 17209, 45680, 45692, 45693, 45389, 0, 0, 0, 
0, 45378, 45681, 45694, 45391
28566, 6397, 6420, 6421, 6398, 42863, 42955, 42959, 42867, 0, 0, 0, 0, 45684, 45696, 45697, 
45393, 45379, 45682, 45695, 45392
28567, 42863, 42955, 42959, 42867, 42864, 42956, 42960, 42868, 45684, 45696, 45697, 45393, 45687, 45699, 45700, 
45396, 45382, 45685, 45698, 45395
28568, 42864, 42956, 42960, 42868, 42865, 42957, 42961, 42869, 45687, 45699, 45700, 45396, 45690, 45702, 45703, 
45399, 45385, 45688, 45701, 45398
28569, 42865, 42957, 42961, 42869, 42866, 42958, 42962, 42870, 45690, 45702, 45703, 45399, 45693, 45705, 45706, 
45402, 45388, 45691, 45704, 45401
28570, 42866, 42958, 42962, 42870, 17209, 17232, 17233, 17210, 45693, 45705, 45706, 45402, 0, 0, 0, 
0, 45391, 45694, 45707, 45404
28571, 6398, 6421, 6422, 6399, 42867, 42959, 42963, 42871, 0, 0, 0, 0, 45697, 45709, 45710, 
45406, 45392, 45695, 45708, 45405
28572, 42867, 42959, 42963, 42871, 42868, 42960, 42964, 42872, 45697, 45709, 45710, 45406, 45700, 45712, 45713, 
45409, 45395, 45698, 45711, 45408
28573, 42868, 42960, 42964, 42872, 42869, 42961, 42965, 42873, 45700, 45712, 45713, 45409, 45703, 45715, 45716, 
45412, 45398, 45701, 45714, 45411
28574, 42869, 42961, 42965, 42873, 42870, 42962, 42966, 42874, 45703, 45715, 45716, 45412, 45706, 45718, 45719, 
45415, 45401, 45704, 45717, 45414
28575, 42870, 42962, 42966, 42874, 17210, 17233, 17234, 17211, 45706, 45718, 45719, 45415, 0, 0, 0, 
0, 45404, 45707, 45720, 45417
28576, 6399, 6422, 6423, 6400, 42871, 42963, 42967, 42875, 0, 0, 0, 0, 45710, 45722, 45723, 
45419, 45405, 45708, 45721, 45418
28577, 42871, 42963, 42967, 42875, 42872, 42964, 42968, 42876, 45710, 45722, 45723, 45419, 45713, 45725, 45726, 
45422, 45408, 45711, 45724, 45421
28578, 42872, 42964, 42968, 42876, 42873, 42965, 42969, 42877, 45713, 45725, 45726, 45422, 45716, 45728, 45729, 
45425, 45411, 45714, 45727, 45424
28579, 42873, 42965, 42969, 42877, 42874, 42966, 42970, 42878, 45716, 45728, 45729, 45425, 45719, 45731, 45732, 
45428, 45414, 45717, 45730, 45427
28580, 42874, 42966, 42970, 42878, 17211, 17234, 17235, 17212, 45719, 45731, 45732, 45428, 0, 0, 0, 
0, 45417, 45720, 45733, 45430
28581, 6400, 6423, 6424, 6401, 42875, 42967, 42971, 42879, 0, 0, 0, 0, 45723, 45735, 45736, 
45432, 45418, 45721, 45734, 45431
28582, 42875, 42967, 42971, 42879, 42876, 42968, 42972, 42880, 45723, 45735, 45736, 45432, 45726, 45738, 45739, 
45435, 45421, 45724, 45737, 45434
28583, 42876, 42968, 42972, 42880, 42877, 42969, 42973, 42881, 45726, 45738, 45739, 45435, 45729, 45741, 45742, 
45438, 45424, 45727, 45740, 45437
28584, 42877, 42969, 42973, 42881, 42878, 42970, 42974, 42882, 45729, 45741, 45742, 45438, 45732, 45744, 45745, 
45441, 45427, 45730, 45743, 45440
28585, 42878, 42970, 42974, 42882, 17212, 17235, 17236, 17213, 45732, 45744, 45745, 45441, 0, 0, 0, 
0, 45430, 45733, 45746, 45443
28586, 6401, 6424, 6425, 6402, 42879, 42971, 42975, 42883, 0, 0, 0, 0, 45736, 45748, 45749, 
45445, 45431, 45734, 45747, 45444
28587, 42879, 42971, 42975, 42883, 42880, 42972, 42976, 42884, 45736, 45748, 45749, 45445, 45739, 45751, 45752, 
45448, 45434, 45737, 45750, 45447
28588, 42880, 42972, 42976, 42884, 42881, 42973, 42977, 42885, 45739, 45751, 45752, 45448, 45742, 45754, 45755, 
45451, 45437, 45740, 45753, 45450
28589, 42881, 42973, 42977, 42885, 42882, 42974, 42978, 42886, 45742, 45754, 45755, 45451, 45745, 45757, 45758, 
45454, 45440, 45743, 45756, 45453
28590, 42882, 42974, 42978, 42886, 17213, 17236, 17237, 17214, 45745, 45757, 45758, 45454, 0, 0, 0, 
0, 45443, 45746, 45759, 45456
28591, 6402, 6425, 6426, 6403, 42883, 42975, 42979, 42887, 0, 0, 0, 0, 45749, 45761, 45762, 
45458, 45444, 45747, 45760, 45457
28592, 42883, 42975, 42979, 42887, 42884, 42976, 42980, 42888, 45749, 45761, 45762, 45458, 45752, 45764, 45765, 
45461, 45447, 45750, 45763, 45460
28593, 42884, 42976, 42980, 42888, 42885, 42977, 42981, 42889, 45752, 45764, 45765, 45461, 45755, 45767, 45768, 
45464, 45450, 45753, 45766, 45463
28594, 42885, 42977, 42981, 42889, 42886, 42978, 42982, 42890, 45755, 45767, 45768, 45464, 45758, 45770, 45771, 
45467, 45453, 45756, 45769, 45466
28595, 42886, 42978, 42982, 42890, 17214, 17237, 17238, 17215, 45758, 45770, 45771, 45467, 0, 0, 0, 
0, 45456, 45759, 45772, 45469
28596, 6403, 6426, 6427, 6404, 42887, 42979, 42983, 42891, 0, 0, 0, 0, 45762, 45774, 45775, 
45471, 45457, 45760, 45773, 45470
28597, 42887, 42979, 42983, 42891, 42888, 42980, 42984, 42892, 45762, 45774, 45775, 45471, 45765, 45777, 45778, 
45474, 45460, 45763, 45776, 45473
28598, 42888, 42980, 42984, 42892, 42889, 42981, 42985, 42893, 45765, 45777, 45778, 45474, 45768, 45780, 45781, 
45477, 45463, 45766, 45779, 45476
28599, 42889, 42981, 42985, 42893, 42890, 42982, 42986, 42894, 45768, 45780, 45781, 45477, 45771, 45783, 45784, 
45480, 45466, 45769, 45782, 45479
28600, 42890, 42982, 42986, 42894, 17215, 17238, 17239, 17216, 45771, 45783, 45784, 45480, 0, 0, 0, 
0, 45469, 45772, 45785, 45482
28601, 6404, 6427, 6428, 6405, 42891, 42983, 42987, 42895, 0, 0, 0, 0, 45775, 45787, 45788, 
45484, 45470, 45773, 45786, 45483
28602, 42891, 42983, 42987, 42895, 42892, 42984, 42988, 42896, 45775, 45787, 45788, 45484, 45778, 45790, 45791, 
45487, 45473, 45776, 45789, 45486
28603, 42892, 42984, 42988, 42896, 42893, 42985, 42989, 42897, 45778, 45790, 45791, 45487, 45781, 45793, 45794, 
45490, 45476, 45779, 45792, 45489
28604, 42893, 42985, 42989, 42897, 42894, 42986, 42990, 42898, 45781, 45793, 45794, 45490, 45784, 45796, 45797, 
45493, 45479, 45782, 45795, 45492
28605, 42894, 42986, 42990, 42898, 17216, 17239, 17240, 17217, 45784, 45796, 45797, 45493, 0, 0, 0, 
0, 45482, 45785, 45798, 45495
28606, 6405, 6428, 6429, 6406, 42895, 42987, 42991, 42899, 0, 0, 0, 0, 45788, 45800, 45801, 
45497, 45483, 45786, 45799, 45496
28607, 42895, 42987, 42991, 42899, 42896, 42988, 42992, 42900, 45788, 45800, 45801, 45497, 45791, 45803, 45804, 
45500, 45486, 45789, 45802, 45499
28608, 42896, 42988, 42992, 42900, 42897, 42989, 42993, 42901, 45791, 45803, 45804, 45500, 45794, 45806, 45807, 
45503, 45489, 45792, 45805, 45502
28609, 42897, 42989, 42993, 42901, 42898, 42990, 42994, 42902, 45794, 45806, 45807, 45503, 45797, 45809, 45810, 
45506, 45492, 45795, 45808, 45505
28610, 42898, 42990, 42994, 42902, 17217, 17240, 17241, 17218, 45797, 45809, 45810, 45506, 0, 0, 0, 
0, 45495, 45798, 45811, 45508
28611, 6406, 6429, 6430, 6407, 42899, 42991, 42995, 42903, 0, 0, 0, 0, 45801, 45813, 45814, 
45510, 45496, 45799, 45812, 45509
28612, 42899, 42991, 42995, 42903, 42900, 42992, 42996, 42904, 45801, 45813, 45814, 45510, 45804, 45816, 45817, 
45513, 45499, 45802, 45815, 45512
28613, 42900, 42992, 42996, 42904, 42901, 42993, 42997, 42905, 45804, 45816, 45817, 45513, 45807, 45819, 45820, 
45516, 45502, 45805, 45818, 45515
28614, 42901, 42993, 42997, 42905, 42902, 42994, 42998, 42906, 45807, 45819, 45820, 45516, 45810, 45822, 45823, 
45519, 45505, 45808, 45821, 45518
28615, 42902, 42994, 42998, 42906, 17218, 17241, 17242, 17219, 45810, 45822, 45823, 45519, 0, 0, 0, 
0, 45508, 45811, 45824, 45521
28616, 6407, 6430, 6431, 6408, 42903, 42995, 42999, 42907, 0, 0, 0, 0, 45814, 45826, 45827, 
45523, 45509, 45812, 45825, 45522
28617, 42903, 42995, 42999, 42907, 42904, 42996, 43000, 42908, 45814, 45826, 45827, 45523, 45817, 45829, 45830, 
45526, 45512, 45815, 45828, 45525
28618, 42904, 42996, 43000, 42908, 42905, 42997, 43001, 42909, 45817, 45829, 45830, 45526, 45820, 45832, 45833, 
45529, 45515, 45818, 45831, 45528
28619, 42905, 42997, 43001, 42909, 42906, 42998, 43002, 42910, 45820, 45832, 45833, 45529, 45823, 45835, 45836, 
45532, 45518, 45821, 45834, 45531
28620, 42906, 42998, 43002, 42910, 17219, 17242, 17243, 17220, 45823, 45835, 45836, 45532, 0, 0, 0, 
0, 45521, 45824, 45837, 45534
28621, 6408, 6431, 6432, 6409, 42907, 42999, 43003, 42911, 0, 0, 0, 0, 45827, 45839, 45840, 
45536, 45522, 45825, 45838, 45535
28622, 42907, 42999, 43003, 42911, 42908, 43000, 43004, 42912, 45827, 45839, 45840, 45536, 45830, 45842, 45843, 
45539, 45525, 45828, 45841, 45538
28623, 42908, 43000, 43004, 42912, 42909, 43001, 43005, 42913, 45830, 45842, 45843, 45539, 45833, 45845, 45846, 
45542, 45528, 45831, 45844, 45541
28624, 42909, 43001, 43005, 42913, 42910, 43002, 43006, 42914, 45833, 45845, 45846, 45542, 45836, 45848, 45849, 
45545, 45531, 45834, 45847, 45544
28625, 42910, 43002, 43006, 42914, 17220, 17243, 17244, 17221, 45836, 45848, 45849, 45545, 0, 0, 0, 
0, 45534, 45837, 45850, 45547
28626, 6409, 6432, 6433, 6410, 42911, 43003, 43007, 42915, 0, 0, 0, 0, 45840, 45852, 45853, 
45549, 45535, 45838, 45851, 45548
28627, 42911, 43003, 43007, 42915, 42912, 43004, 43008, 42916, 45840, 45852, 45853, 45549, 45843, 45855, 45856, 
45552, 45538, 45841, 45854, 45551
28628, 42912, 43004, 43008, 42916, 42913, 43005, 43009, 42917, 45843, 45855, 45856, 45552, 45846, 45858, 45859, 
45555, 45541, 45844, 45857, 45554
28629, 42913, 43005, 43009, 42917, 42914, 43006, 43010, 42918, 45846, 45858, 45859, 45555, 45849, 45861, 45862, 
45558, 45544, 45847, 45860, 45557
28630, 42914, 43006, 43010, 42918, 17221, 17244, 17245, 17222, 45849, 45861, 45862, 45558, 0, 0, 0, 
0, 45547, 45850, 45863, 45560
28631, 6410, 6433, 6434, 6411, 42915, 43007, 43011, 42919, 0, 0, 0, 0, 45853, 45865, 45866, 
45562, 45548, 45851, 45864, 45561
28632, 42915, 43007, 43011, 42919, 42916, 43008, 43012, 42920, 45853, 45865, 45866, 45562, 45856, 45868, 45869, 
45565, 45551, 45854, 45867, 45564
28633, 42916, 43008, 43012, 42920, 42917, 43009, 43013, 42921, 45856, 45868, 45869, 45565, 45859, 45871, 45872, 
45568, 45554, 45857, 45870, 45567
28634, 42917, 43009, 43013, 42921, 42918, 43010, 43014, 42922, 45859, 45871, 45872, 45568, 45862, 45874, 45875, 
45571, 45557, 45860, 45873, 45570
28635, 42918, 43010, 43014, 42922, 17222, 17245, 17246, 17223, 45862, 45874, 45875, 45571, 0, 0, 0, 
0, 45560, 45863, 45876, 45573
28636, 6411, 6434, 6435, 6412, 42919, 43011, 43015, 42923, 0, 0, 0, 0, 45866, 45878, 45879, 
45575, 45561, 45864, 45877, 45574
28637, 42919, 43011, 43015, 42923, 42920, 43012, 43016, 42924, 45866, 45878, 45879, 45575, 45869, 45881, 45882, 
45578, 45564, 45867, 45880, 45577
28638, 42920, 43012, 43016, 42924, 42921, 43013, 43017, 42925, 45869, 45881, 45882, 45578, 45872, 45884, 45885, 
45581, 45567, 45870, 45883, 45580
28639, 42921, 43013, 43017, 42925, 42922, 43014, 43018, 42926, 45872, 45884, 45885, 45581, 45875, 45887, 45888, 
45584, 45570, 45873, 45886, 45583
28640, 42922, 43014, 43018, 42926, 17223, 17246, 17247, 17224, 45875, 45887, 45888, 45584, 0, 0, 0, 
0, 45573, 45876, 45889, 45586
28641, 6412, 6435, 6436, 6413, 42923, 43015, 43019, 42927, 0, 0, 0, 0, 45879, 45891, 45892, 
45588, 45574, 45877, 45890, 45587
28642, 42923, 43015, 43019, 42927, 42924, 43016, 43020, 42928, 45879, 45891, 45892, 45588, 45882, 45894, 45895, 
45591, 45577, 45880, 45893, 45590
28643, 42924, 43016, 43020, 42928, 42925, 43017, 43021, 42929, 45882, 45894, 45895, 45591, 45885, 45897, 45898, 
45594, 45580, 45883, 45896, 45593
28644, 42925, 43017, 43021, 42929, 42926, 43018, 43022, 42930, 45885, 45897, 45898, 45594, 45888, 45900, 45901, 
45597, 45583, 45886, 45899, 45596
28645, 42926, 43018, 43022, 42930, 17224, 17247, 17248, 17225, 45888, 45900, 45901, 45597, 0, 0, 0, 
0, 45586, 45889, 45902, 45599
28646, 6413, 6436, 6437, 6414, 42927, 43019, 43023, 42931, 0, 0, 0, 0, 45892, 45904, 45905, 
45601, 45587, 45890, 45903, 45600
28647, 42927, 43019, 43023, 42931, 42928, 43020, 43024, 42932, 45892, 45904, 45905, 45601, 45895, 45907, 45908, 
45604, 45590, 45893, 45906, 45603
28648, 42928, 43020, 43024, 42932, 42929, 43021, 43025, 42933, 45895, 45907, 45908, 45604, 45898, 45910, 45911, 
45607, 45593, 45896, 45909, 45606
28649, 42929, 43021, 43025, 42933, 42930, 43022, 43026, 42934, 45898, 45910, 45911, 45607, 45901, 45913, 45914, 
45610, 45596, 45899, 45912, 45609
28650, 42930, 43022, 43026, 42934, 17225, 17248, 17249, 17226, 45901, 45913, 45914, 45610, 0, 0, 0, 
0, 45599, 45902, 45915, 45612
28651, 6414, 6437, 6438, 6415, 42931, 43023, 43027, 42935, 0, 0, 0, 0, 45905, 45917, 45918, 
45614, 45600, 45903, 45916, 45613
28652, 42931, 43023, 43027, 42935, 42932, 43024, 43028, 42936, 45905, 45917, 45918, 45614, 45908, 45920, 45921, 
45617, 45603, 45906, 45919, 45616
28653, 42932, 43024, 43028, 42936, 42933, 43025, 43029, 42937, 45908, 45920, 45921, 45617, 45911, 45923, 45924, 
45620, 45606, 45909, 45922, 45619
28654, 42933, 43025, 43029, 42937, 42934, 43026, 43030, 42938, 45911, 45923, 45924, 45620, 45914, 45926, 45927, 
45623, 45609, 45912, 45925, 45622
28655, 42934, 43026, 43030, 42938, 17226, 17249, 17250, 17227, 45914, 45926, 45927, 45623, 0, 0, 0, 
0, 45612, 45915, 45928, 45625
28656, 6415, 6438, 6439, 6416, 42935, 43027, 43031, 42939, 0, 0, 0, 0, 45918, 45930, 45931, 
45627, 45613, 45916, 45929, 45626
28657, 42935, 43027, 43031, 42939, 42936, 43028, 43032, 42940, 45918, 45930, 45931, 45627, 45921, 45933, 45934, 
45630, 45616, 45919, 45932, 45629
28658, 42936, 43028, 43032, 42940, 42937, 43029, 43033, 42941, 45921, 45933, 45934, 45630, 45924, 45936, 45937, 
45633, 45619, 45922, 45935, 45632
28659, 42937, 43029, 43033, 42941, 42938, 43030, 43034, 42942, 45924, 45936, 45937, 45633, 45927, 45939, 45940, 
45636, 45622, 45925, 45938, 45635
28660, 42938, 43030, 43034, 42942, 17227, 17250, 17251, 17228, 45927, 45939, 45940, 45636, 0, 0, 0, 
0, 45625, 45928, 45941, 45638
28661, 6416, 6439, 771, 770, 42939, 43031, 16930, 16926, 0, 0, 0, 0, 45931, 45942, 17014, 
45639, 45626, 45929, 17015, 17006
28662, 42939, 43031, 16930, 16926, 42940, 43032, 16931, 16927, 45931, 45942, 17014, 45639, 45934, 45943, 17016, 
45640, 45629, 45932, 17017, 17008
28663, 42940, 43032, 16931, 16927, 42941, 43033, 16932, 16928, 45934, 45943, 17016, 45640, 45937, 45944, 17018, 
45641, 45632, 45935, 17019, 17010
28664, 42941, 43033, 16932, 16928, 42942, 43034, 16933, 16929, 45937, 45944, 17018, 45641, 45940, 45945, 17020, 
45642, 45635, 45938, 17021, 17012
28665, 42942, 43034, 16933, 16929, 17228, 17251, 2169, 2168, 45940, 45945, 17020, 45642, 0, 0, 0, 
0, 45638, 45941, 17022, 17013
28666, 653, 654, 6440, 6417, 16344, 16348, 43035, 42943, 0, 0, 0, 0, 16437, 45947, 45948, 
45644, 16429, 16438, 45946, 45643
28667, 16344, 16348, 43035, 42943, 16345, 16349, 43036, 42944, 16437, 45947, 45948, 45644, 16439, 45950, 45951, 
45647, 16431, 16440, 45949, 45646
28668, 16345, 16349, 43036, 42944, 16346, 16350, 43037, 42945, 16439, 45950, 45951, 45647, 16441, 45953, 45954, 
45650, 16433, 16442, 45952, 45649
28669, 16346, 16350, 43037, 42945, 16347, 16351, 43038, 42946, 16441, 45953, 45954, 45650, 16443, 45956, 45957, 
45653, 16435, 16444, 45955, 45652
28670, 16347, 16351, 43038, 42946, 2099, 2100, 17252, 17229, 16443, 45956, 45957, 45653, 0, 0, 0, 
0, 16436, 16445, 45958, 45655
28671, 6417, 6440, 6441, 6418, 42943, 43035, 43039, 42947, 0, 0, 0, 0, 45948, 45960, 45961, 
45657, 45643, 45946, 45959, 45656
28672, 42943, 43035, 43039, 42947, 42944, 43036, 43040, 42948, 45948, 45960, 45961, 45657, 45951, 45963, 45964, 
45660, 45646, 45949, 45962, 45659
28673, 42944, 43036, 43040, 42948, 42945, 43037, 43041, 42949, 45951, 45963, 45964, 45660, 45954, 45966, 45967, 
45663, 45649, 45952, 45965, 45662
28674, 42945, 43037, 43041, 42949, 42946, 43038, 43042, 42950, 45954, 45966, 45967, 45663, 45957, 45969, 45970, 
45666, 45652, 45955, 45968, 45665
28675, 42946, 43038, 43042, 42950, 17229, 17252, 17253, 17230, 45957, 45969, 45970, 45666, 0, 0, 0, 
0, 45655, 45958, 45971, 45668
28676, 6418, 6441, 6442, 6419, 42947, 43039, 43043, 42951, 0, 0, 0, 0, 45961, 45973, 45974, 
45670, 45656, 45959, 45972, 45669
28677, 42947, 43039, 43043, 42951, 42948, 43040, 43044, 42952, 45961, 45973, 45974, 45670, 45964, 45976, 45977, 
45673, 45659, 45962, 45975, 45672
28678, 42948, 43040, 43044, 42952, 42949, 43041, 43045, 42953, 45964, 45976, 45977, 45673, 45967, 45979, 45980, 
45676, 45662, 45965, 45978, 45675
28679, 42949, 43041, 43045, 42953, 42950, 43042, 43046, 42954, 45967, 45979, 45980, 45676, 45970, 45982, 45983, 
45679, 45665, 45968, 45981, 45678
28680, 42950, 43042, 43046, 42954, 17230, 17253, 17254, 17231, 45970, 45982, 45983, 45679, 0, 0, 0, 
0, 45668, 45971, 45984, 45681
28681, 6419, 6442, 6443, 6420, 42951, 43043, 43047, 42955, 0, 0, 0, 0, 45974, 45986, 45987, 
45683, 45669, 45972, 45985, 45682
28682, 42951, 43043, 43047, 42955, 42952, 43044, 43048, 42956, 45974, 45986, 45987, 45683, 45977, 45989, 45990, 
45686, 45672, 45975, 45988, 45685
28683, 42952, 43044, 43048, 42956, 42953, 43045, 43049, 42957, 45977, 45989, 45990, 45686, 45980, 45992, 45993, 
45689, 45675, 45978, 45991, 45688
28684, 42953, 43045, 43049, 42957, 42954, 43046, 43050, 42958, 45980, 45992, 45993, 45689, 45983, 45995, 45996, 
45692, 45678, 45981, 45994, 45691
28685, 42954, 43046, 43050, 42958, 17231, 17254, 17255, 17232, 45983, 45995, 45996, 45692, 0, 0, 0, 
0, 45681, 45984, 45997, 45694
28686, 6420, 6443, 6444, 6421, 42955, 43047, 43051, 42959, 0, 0, 0, 0, 45987, 45999, 46000, 
45696, 45682, 45985, 45998, 45695
28687, 42955, 43047, 43051, 42959, 42956, 43048, 43052, 42960, 45987, 45999, 46000, 45696, 45990, 46002, 46003, 
45699, 45685, 45988, 46001, 45698
28688, 42956, 43048, 43052, 42960, 42957, 43049, 43053, 42961, 45990, 46002, 46003, 45699, 45993, 46005, 46006, 
45702, 45688, 45991, 46004, 45701
28689, 42957, 43049, 43053, 42961, 42958, 43050, 43054, 42962, 45993, 46005, 46006, 45702, 45996, 46008, 46009, 
45705, 45691, 45994, 46007, 45704
28690, 42958, 43050, 43054, 42962, 17232, 17255, 17256, 17233, 45996, 46008, 46009, 45705, 0, 0, 0, 
0, 45694, 45997, 46010, 45707
28691, 6421, 6444, 6445, 6422, 42959, 43051, 43055, 42963, 0, 0, 0, 0, 46000, 46012, 46013, 
45709, 45695, 45998, 46011, 45708
28692, 42959, 43051, 43055, 42963, 42960, 43052, 43056, 42964, 46000, 46012, 46013, 45709, 46003, 46015, 46016, 
45712, 45698, 46001, 46014, 45711
28693, 42960, 43052, 43056, 42964, 42961, 43053, 43057, 42965, 46003, 46015, 46016, 45712, 46006, 46018, 46019, 
45715, 45701, 46004, 46017, 45714
28694, 42961, 43053, 43057, 42965, 42962, 43054, 43058, 42966, 46006, 46018, 46019, 45715, 46009, 46021, 46022, 
45718, 45704, 46007, 46020, 45717
28695, 42962, 43054, 43058, 42966, 17233, 17256, 17257, 17234, 46009, 46021, 46022, 45718, 0, 0, 0, 
0, 45707, 46010, 46023, 45720
28696, 6422, 6445, 6446, 6423, 42963, 43055, 43059, 42967, 0, 0, 0, 0, 46013, 46025, 46026, 
45722, 45708, 46011, 46024, 45721
28697, 42963, 43055, 43059, 42967, 42964, 43056, 43060, 42968, 46013, 46025, 46026, 45722, 46016, 46028, 46029, 
45725, 45711, 46014, 46027, 45724
28698, 42964, 43056, 43060, 42968, 42965, 43057, 43061, 42969, 46016, 46028, 46029, 45725, 46019, 46031, 46032, 
45728, 45714, 46017, 46030, 45727
28699, 42965, 43057, 43061, 42969, 42966, 43058, 43062, 42970, 46019, 46031, 46032, 45728, 46022, 46034, 46035, 
45731, 45717, 46020, 46033, 45730
28700, 42966, 43058, 43062, 42970, 17234, 17257, 17258, 17235, 46022, 46034, 46035, 45731, 0, 0, 0, 
0, 45720, 46023, 46036, 45733
28701, 6423, 6446, 6447, 6424, 42967, 43059, 43063, 42971, 0, 0, 0, 0, 46026, 46038, 46039, 
45735, 45721, 46024, 46037, 45734
28702, 42967, 43059, 43063, 42971, 42968, 43060, 43064, 42972, 46026, 46038, 46039, 45735, 46029, 46041, 46042, 
45738, 45724, 46027, 46040, 45737
28703, 42968, 43060, 43064, 42972, 42969, 43061, 43065, 42973, 46029, 46041, 46042, 45738, 46032, 46044, 46045, 
45741, 45727, 46030, 46043, 45740
28704, 42969, 43061, 43065, 42973, 42970, 43062, 43066, 42974, 46032, 46044, 46045, 45741, 46035, 46047, 46048, 
45744, 45730, 46033, 46046, 45743
28705, 42970, 43062, 43066, 42974, 17235, 17258, 17259, 17236, 46035, 46047, 46048, 45744, 0, 0, 0, 
0, 45733, 46036, 46049, 45746
28706, 6424, 6447, 6448, 6425, 42971, 43063, 43067, 42975, 0, 0, 0, 0, 46039, 46051, 46052, 
45748, 45734, 46037, 46050, 45747
28707, 42971, 43063, 43067, 42975, 42972, 43064, 43068, 42976, 46039, 46051, 46052, 45748, 46042, 46054, 46055, 
45751, 45737, 46040, 46053, 45750
28708, 42972, 43064, 43068, 42976, 42973, 43065, 43069, 42977, 46042, 46054, 46055, 45751, 46045, 46057, 46058, 
45754, 45740, 46043, 46056, 45753
28709, 42973, 43065, 43069, 42977, 42974, 43066, 43070, 42978, 46045, 46057, 46058, 45754, 46048, 46060, 46061, 
45757, 45743, 46046, 46059, 45756
28710, 42974, 43066, 43070, 42978, 17236, 17259, 17260, 17237, 46048, 46060, 46061, 45757, 0, 0, 0, 
0, 45746, 46049, 46062, 45759
28711, 6425, 6448, 6449, 6426, 42975, 43067, 43071, 42979, 0, 0, 0, 0, 46052, 46064, 46065, 
45761, 45747, 46050, 46063, 45760
28712, 42975, 43067, 43071, 42979, 42976, 43068, 43072, 42980, 46052, 46064, 46065, 45761, 46055, 46067, 46068, 
45764, 45750, 46053, 46066, 45763
28713, 42976, 43068, 43072, 42980, 42977, 43069, 43073, 42981, 46055, 46067, 46068, 45764, 46058, 46070, 46071, 
45767, 45753, 46056, 46069, 45766
28714, 42977, 43069, 43073, 42981, 42978, 43070, 43074, 42982, 46058, 46070, 46071, 45767, 46061, 46073, 46074, 
45770, 45756, 46059, 46072, 45769
28715, 42978, 43070, 43074, 42982, 17237, 17260, 17261, 17238, 46061, 46073, 46074, 45770, 0, 0, 0, 
0, 45759, 46062, 46075, 45772
28716, 6426, 6449, 6450, 6427, 42979, 43071, 43075, 42983, 0, 0, 0, 0, 46065, 46077, 46078, 
45774, 45760, 46063, 46076, 45773
28717, 42979, 43071, 43075, 42983, 42980, 43072, 43076, 42984, 46065, 46077, 46078, 45774, 46068, 46080, 46081, 
45777, 45763, 46066, 46079, 45776
28718, 42980, 43072, 43076, 42984, 42981, 43073, 43077, 42985, 46068, 46080, 46081, 45777, 46071, 46083, 46084, 
45780, 45766, 46069, 46082, 45779
28719, 42981, 43073, 43077, 42985, 42982, 43074, 43078, 42986, 46071, 46083, 46084, 45780, 46074, 46086, 46087, 
45783, 45769, 46072, 46085, 45782
28720, 42982, 43074, 43078, 42986, 17238, 17261, 17262, 17239, 46074, 46086, 46087, 45783, 0, 0, 0, 
0, 45772, 46075, 46088, 45785
28721, 6427, 6450, 6451, 6428, 42983, 43075, 43079, 42987, 0, 0, 0, 0, 46078, 46090, 46091, 
45787, 45773, 46076, 46089, 45786
28722, 42983, 43075, 43079, 42987, 42984, 43076, 43080, 42988, 46078, 46090, 46091, 45787, 46081, 46093, 46094, 
45790, 45776, 46079, 46092, 45789
28723, 42984, 43076, 43080, 42988, 42985, 43077, 43081, 42989, 46081, 46093, 46094, 45790, 46084, 46096, 46097, 
45793, 45779, 46082, 46095, 45792
28724, 42985, 43077, 43081, 42989, 42986, 43078, 43082, 42990, 46084, 46096, 46097, 45793, 46087, 46099, 46100, 
45796, 45782, 46085, 46098, 45795
28725, 42986, 43078, 43082, 42990, 17239, 17262, 17263, 17240, 46087, 46099, 46100, 45796, 0, 0, 0, 
0, 45785, 46088, 46101, 45798
28726, 6428, 6451, 6452, 6429, 42987, 43079, 43083, 42991, 0, 0, 0, 0, 46091, 46103, 46104, 
45800, 45786, 46089, 46102, 45799
