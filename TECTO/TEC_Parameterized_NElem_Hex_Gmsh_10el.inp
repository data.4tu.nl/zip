7211, 20312, 20335, 20588, 20565, 20313, 20336, 20589, 20566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7212, 20313, 20336, 20589, 20566, 20314, 20337, 20590, 20567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7213, 20314, 20337, 20590, 20567, 20315, 20338, 20591, 20568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7214, 20315, 20338, 20591, 20568, 20316, 20339, 20592, 20569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7215, 20316, 20339, 20592, 20569, 20317, 20340, 20593, 20570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7216, 20317, 20340, 20593, 20570, 20318, 20341, 20594, 20571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7217, 20318, 20341, 20594, 20571, 20319, 20342, 20595, 20572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7218, 20319, 20342, 20595, 20572, 20320, 20343, 20596, 20573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7219, 20320, 20343, 20596, 20573, 20321, 20344, 20597, 20574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7220, 20321, 20344, 20597, 20574, 20322, 20345, 20598, 20575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7221, 20322, 20345, 20598, 20575, 20323, 20346, 20599, 20576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7222, 20323, 20346, 20599, 20576, 20324, 20347, 20600, 20577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7223, 20324, 20347, 20600, 20577, 20325, 20348, 20601, 20578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7224, 20325, 20348, 20601, 20578, 20326, 20349, 20602, 20579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7225, 20326, 20349, 20602, 20579, 20327, 20350, 20603, 20580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7226, 20327, 20350, 20603, 20580, 20328, 20351, 20604, 20581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7227, 20328, 20351, 20604, 20581, 20329, 20352, 20605, 20582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7228, 20329, 20352, 20605, 20582, 20330, 20353, 20606, 20583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7229, 20330, 20353, 20606, 20583, 20331, 20354, 20607, 20584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7230, 20331, 20354, 20607, 20584, 20332, 20355, 20608, 20585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7231, 20332, 20355, 20608, 20585, 20333, 20356, 20609, 20586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7232, 20333, 20356, 20609, 20586, 20334, 20357, 20610, 20587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7233, 20334, 20357, 20610, 20587, 4881, 4882, 4893, 4892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7234, 3065, 3066, 3077, 3076, 20335, 20358, 20611, 20588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7235, 20335, 20358, 20611, 20588, 20336, 20359, 20612, 20589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7236, 20336, 20359, 20612, 20589, 20337, 20360, 20613, 20590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7237, 20337, 20360, 20613, 20590, 20338, 20361, 20614, 20591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7238, 20338, 20361, 20614, 20591, 20339, 20362, 20615, 20592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7239, 20339, 20362, 20615, 20592, 20340, 20363, 20616, 20593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7240, 20340, 20363, 20616, 20593, 20341, 20364, 20617, 20594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7241, 20341, 20364, 20617, 20594, 20342, 20365, 20618, 20595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7242, 20342, 20365, 20618, 20595, 20343, 20366, 20619, 20596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7243, 20343, 20366, 20619, 20596, 20344, 20367, 20620, 20597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7244, 20344, 20367, 20620, 20597, 20345, 20368, 20621, 20598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7245, 20345, 20368, 20621, 20598, 20346, 20369, 20622, 20599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7246, 20346, 20369, 20622, 20599, 20347, 20370, 20623, 20600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7247, 20347, 20370, 20623, 20600, 20348, 20371, 20624, 20601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7248, 20348, 20371, 20624, 20601, 20349, 20372, 20625, 20602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7249, 20349, 20372, 20625, 20602, 20350, 20373, 20626, 20603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7250, 20350, 20373, 20626, 20603, 20351, 20374, 20627, 20604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7251, 20351, 20374, 20627, 20604, 20352, 20375, 20628, 20605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7252, 20352, 20375, 20628, 20605, 20353, 20376, 20629, 20606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7253, 20353, 20376, 20629, 20606, 20354, 20377, 20630, 20607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7254, 20354, 20377, 20630, 20607, 20355, 20378, 20631, 20608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7255, 20355, 20378, 20631, 20608, 20356, 20379, 20632, 20609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7256, 20356, 20379, 20632, 20609, 20357, 20380, 20633, 20610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7257, 20357, 20380, 20633, 20610, 4882, 4883, 4894, 4893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7258, 3066, 3067, 3078, 3077, 20358, 20381, 20634, 20611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7259, 20358, 20381, 20634, 20611, 20359, 20382, 20635, 20612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7260, 20359, 20382, 20635, 20612, 20360, 20383, 20636, 20613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7261, 20360, 20383, 20636, 20613, 20361, 20384, 20637, 20614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7262, 20361, 20384, 20637, 20614, 20362, 20385, 20638, 20615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7263, 20362, 20385, 20638, 20615, 20363, 20386, 20639, 20616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7264, 20363, 20386, 20639, 20616, 20364, 20387, 20640, 20617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7265, 20364, 20387, 20640, 20617, 20365, 20388, 20641, 20618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7266, 20365, 20388, 20641, 20618, 20366, 20389, 20642, 20619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7267, 20366, 20389, 20642, 20619, 20367, 20390, 20643, 20620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7268, 20367, 20390, 20643, 20620, 20368, 20391, 20644, 20621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7269, 20368, 20391, 20644, 20621, 20369, 20392, 20645, 20622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7270, 20369, 20392, 20645, 20622, 20370, 20393, 20646, 20623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7271, 20370, 20393, 20646, 20623, 20371, 20394, 20647, 20624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7272, 20371, 20394, 20647, 20624, 20372, 20395, 20648, 20625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7273, 20372, 20395, 20648, 20625, 20373, 20396, 20649, 20626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7274, 20373, 20396, 20649, 20626, 20374, 20397, 20650, 20627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7275, 20374, 20397, 20650, 20627, 20375, 20398, 20651, 20628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7276, 20375, 20398, 20651, 20628, 20376, 20399, 20652, 20629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7277, 20376, 20399, 20652, 20629, 20377, 20400, 20653, 20630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7278, 20377, 20400, 20653, 20630, 20378, 20401, 20654, 20631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7279, 20378, 20401, 20654, 20631, 20379, 20402, 20655, 20632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7280, 20379, 20402, 20655, 20632, 20380, 20403, 20656, 20633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7281, 20380, 20403, 20656, 20633, 4883, 4884, 4895, 4894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7282, 3067, 3068, 3079, 3078, 20381, 20404, 20657, 20634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7283, 20381, 20404, 20657, 20634, 20382, 20405, 20658, 20635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7284, 20382, 20405, 20658, 20635, 20383, 20406, 20659, 20636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7285, 20383, 20406, 20659, 20636, 20384, 20407, 20660, 20637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7286, 20384, 20407, 20660, 20637, 20385, 20408, 20661, 20638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7287, 20385, 20408, 20661, 20638, 20386, 20409, 20662, 20639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7288, 20386, 20409, 20662, 20639, 20387, 20410, 20663, 20640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7289, 20387, 20410, 20663, 20640, 20388, 20411, 20664, 20641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7290, 20388, 20411, 20664, 20641, 20389, 20412, 20665, 20642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7291, 20389, 20412, 20665, 20642, 20390, 20413, 20666, 20643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7292, 20390, 20413, 20666, 20643, 20391, 20414, 20667, 20644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7293, 20391, 20414, 20667, 20644, 20392, 20415, 20668, 20645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7294, 20392, 20415, 20668, 20645, 20393, 20416, 20669, 20646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7295, 20393, 20416, 20669, 20646, 20394, 20417, 20670, 20647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7296, 20394, 20417, 20670, 20647, 20395, 20418, 20671, 20648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7297, 20395, 20418, 20671, 20648, 20396, 20419, 20672, 20649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7298, 20396, 20419, 20672, 20649, 20397, 20420, 20673, 20650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7299, 20397, 20420, 20673, 20650, 20398, 20421, 20674, 20651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7300, 20398, 20421, 20674, 20651, 20399, 20422, 20675, 20652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7301, 20399, 20422, 20675, 20652, 20400, 20423, 20676, 20653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7302, 20400, 20423, 20676, 20653, 20401, 20424, 20677, 20654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7303, 20401, 20424, 20677, 20654, 20402, 20425, 20678, 20655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7304, 20402, 20425, 20678, 20655, 20403, 20426, 20679, 20656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7305, 20403, 20426, 20679, 20656, 4884, 4885, 4896, 4895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7306, 3068, 3069, 3080, 3079, 20404, 20427, 20680, 20657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7307, 20404, 20427, 20680, 20657, 20405, 20428, 20681, 20658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7308, 20405, 20428, 20681, 20658, 20406, 20429, 20682, 20659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7309, 20406, 20429, 20682, 20659, 20407, 20430, 20683, 20660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7310, 20407, 20430, 20683, 20660, 20408, 20431, 20684, 20661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7311, 20408, 20431, 20684, 20661, 20409, 20432, 20685, 20662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7312, 20409, 20432, 20685, 20662, 20410, 20433, 20686, 20663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7313, 20410, 20433, 20686, 20663, 20411, 20434, 20687, 20664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7314, 20411, 20434, 20687, 20664, 20412, 20435, 20688, 20665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7315, 20412, 20435, 20688, 20665, 20413, 20436, 20689, 20666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7316, 20413, 20436, 20689, 20666, 20414, 20437, 20690, 20667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7317, 20414, 20437, 20690, 20667, 20415, 20438, 20691, 20668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7318, 20415, 20438, 20691, 20668, 20416, 20439, 20692, 20669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7319, 20416, 20439, 20692, 20669, 20417, 20440, 20693, 20670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7320, 20417, 20440, 20693, 20670, 20418, 20441, 20694, 20671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7321, 20418, 20441, 20694, 20671, 20419, 20442, 20695, 20672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7322, 20419, 20442, 20695, 20672, 20420, 20443, 20696, 20673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7323, 20420, 20443, 20696, 20673, 20421, 20444, 20697, 20674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7324, 20421, 20444, 20697, 20674, 20422, 20445, 20698, 20675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7325, 20422, 20445, 20698, 20675, 20423, 20446, 20699, 20676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7326, 20423, 20446, 20699, 20676, 20424, 20447, 20700, 20677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7327, 20424, 20447, 20700, 20677, 20425, 20448, 20701, 20678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7328, 20425, 20448, 20701, 20678, 20426, 20449, 20702, 20679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7329, 20426, 20449, 20702, 20679, 4885, 4886, 4897, 4896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7330, 3069, 3070, 3081, 3080, 20427, 20450, 20703, 20680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7331, 20427, 20450, 20703, 20680, 20428, 20451, 20704, 20681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7332, 20428, 20451, 20704, 20681, 20429, 20452, 20705, 20682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7333, 20429, 20452, 20705, 20682, 20430, 20453, 20706, 20683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7334, 20430, 20453, 20706, 20683, 20431, 20454, 20707, 20684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7335, 20431, 20454, 20707, 20684, 20432, 20455, 20708, 20685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7336, 20432, 20455, 20708, 20685, 20433, 20456, 20709, 20686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7337, 20433, 20456, 20709, 20686, 20434, 20457, 20710, 20687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7338, 20434, 20457, 20710, 20687, 20435, 20458, 20711, 20688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7339, 20435, 20458, 20711, 20688, 20436, 20459, 20712, 20689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7340, 20436, 20459, 20712, 20689, 20437, 20460, 20713, 20690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7341, 20437, 20460, 20713, 20690, 20438, 20461, 20714, 20691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7342, 20438, 20461, 20714, 20691, 20439, 20462, 20715, 20692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7343, 20439, 20462, 20715, 20692, 20440, 20463, 20716, 20693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7344, 20440, 20463, 20716, 20693, 20441, 20464, 20717, 20694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7345, 20441, 20464, 20717, 20694, 20442, 20465, 20718, 20695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7346, 20442, 20465, 20718, 20695, 20443, 20466, 20719, 20696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7347, 20443, 20466, 20719, 20696, 20444, 20467, 20720, 20697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7348, 20444, 20467, 20720, 20697, 20445, 20468, 20721, 20698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7349, 20445, 20468, 20721, 20698, 20446, 20469, 20722, 20699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7350, 20446, 20469, 20722, 20699, 20447, 20470, 20723, 20700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7351, 20447, 20470, 20723, 20700, 20448, 20471, 20724, 20701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7352, 20448, 20471, 20724, 20701, 20449, 20472, 20725, 20702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7353, 20449, 20472, 20725, 20702, 4886, 4887, 4898, 4897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7354, 3070, 3071, 3082, 3081, 20450, 20473, 20726, 20703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7355, 20450, 20473, 20726, 20703, 20451, 20474, 20727, 20704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7356, 20451, 20474, 20727, 20704, 20452, 20475, 20728, 20705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7357, 20452, 20475, 20728, 20705, 20453, 20476, 20729, 20706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7358, 20453, 20476, 20729, 20706, 20454, 20477, 20730, 20707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7359, 20454, 20477, 20730, 20707, 20455, 20478, 20731, 20708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7360, 20455, 20478, 20731, 20708, 20456, 20479, 20732, 20709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7361, 20456, 20479, 20732, 20709, 20457, 20480, 20733, 20710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7362, 20457, 20480, 20733, 20710, 20458, 20481, 20734, 20711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7363, 20458, 20481, 20734, 20711, 20459, 20482, 20735, 20712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7364, 20459, 20482, 20735, 20712, 20460, 20483, 20736, 20713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7365, 20460, 20483, 20736, 20713, 20461, 20484, 20737, 20714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7366, 20461, 20484, 20737, 20714, 20462, 20485, 20738, 20715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7367, 20462, 20485, 20738, 20715, 20463, 20486, 20739, 20716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7368, 20463, 20486, 20739, 20716, 20464, 20487, 20740, 20717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7369, 20464, 20487, 20740, 20717, 20465, 20488, 20741, 20718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7370, 20465, 20488, 20741, 20718, 20466, 20489, 20742, 20719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7371, 20466, 20489, 20742, 20719, 20467, 20490, 20743, 20720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7372, 20467, 20490, 20743, 20720, 20468, 20491, 20744, 20721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7373, 20468, 20491, 20744, 20721, 20469, 20492, 20745, 20722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7374, 20469, 20492, 20745, 20722, 20470, 20493, 20746, 20723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7375, 20470, 20493, 20746, 20723, 20471, 20494, 20747, 20724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7376, 20471, 20494, 20747, 20724, 20472, 20495, 20748, 20725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7377, 20472, 20495, 20748, 20725, 4887, 4888, 4899, 4898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7378, 3071, 277, 278, 3082, 20473, 4108, 4131, 20726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7379, 20473, 4108, 4131, 20726, 20474, 4109, 4132, 20727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7380, 20474, 4109, 4132, 20727, 20475, 4110, 4133, 20728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7381, 20475, 4110, 4133, 20728, 20476, 4111, 4134, 20729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7382, 20476, 4111, 4134, 20729, 20477, 4112, 4135, 20730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7383, 20477, 4112, 4135, 20730, 20478, 4113, 4136, 20731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7384, 20478, 4113, 4136, 20731, 20479, 4114, 4137, 20732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7385, 20479, 4114, 4137, 20732, 20480, 4115, 4138, 20733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7386, 20480, 4115, 4138, 20733, 20481, 4116, 4139, 20734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7387, 20481, 4116, 4139, 20734, 20482, 4117, 4140, 20735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7388, 20482, 4117, 4140, 20735, 20483, 4118, 4141, 20736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7389, 20483, 4118, 4141, 20736, 20484, 4119, 4142, 20737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7390, 20484, 4119, 4142, 20737, 20485, 4120, 4143, 20738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7391, 20485, 4120, 4143, 20738, 20486, 4121, 4144, 20739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7392, 20486, 4121, 4144, 20739, 20487, 4122, 4145, 20740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7393, 20487, 4122, 4145, 20740, 20488, 4123, 4146, 20741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7394, 20488, 4123, 4146, 20741, 20489, 4124, 4147, 20742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7395, 20489, 4124, 4147, 20742, 20490, 4125, 4148, 20743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7396, 20490, 4125, 4148, 20743, 20491, 4126, 4149, 20744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7397, 20491, 4126, 4149, 20744, 20492, 4127, 4150, 20745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7398, 20492, 4127, 4150, 20745, 20493, 4128, 4151, 20746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7399, 20493, 4128, 4151, 20746, 20494, 4129, 4152, 20747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7400, 20494, 4129, 4152, 20747, 20495, 4130, 4153, 20748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7401, 20495, 4130, 4153, 20748, 4888, 437, 438, 4899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7402, 244, 3072, 3083, 245, 3349, 20496, 20749, 3372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7403, 3349, 20496, 20749, 3372, 3350, 20497, 20750, 3373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7404, 3350, 20497, 20750, 3373, 3351, 20498, 20751, 3374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7405, 3351, 20498, 20751, 3374, 3352, 20499, 20752, 3375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7406, 3352, 20499, 20752, 3375, 3353, 20500, 20753, 3376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7407, 3353, 20500, 20753, 3376, 3354, 20501, 20754, 3377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7408, 3354, 20501, 20754, 3377, 3355, 20502, 20755, 3378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7409, 3355, 20502, 20755, 3378, 3356, 20503, 20756, 3379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7410, 3356, 20503, 20756, 3379, 3357, 20504, 20757, 3380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7411, 3357, 20504, 20757, 3380, 3358, 20505, 20758, 3381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7412, 3358, 20505, 20758, 3381, 3359, 20506, 20759, 3382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7413, 3359, 20506, 20759, 3382, 3360, 20507, 20760, 3383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7414, 3360, 20507, 20760, 3383, 3361, 20508, 20761, 3384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7415, 3361, 20508, 20761, 3384, 3362, 20509, 20762, 3385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7416, 3362, 20509, 20762, 3385, 3363, 20510, 20763, 3386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7417, 3363, 20510, 20763, 3386, 3364, 20511, 20764, 3387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7418, 3364, 20511, 20764, 3387, 3365, 20512, 20765, 3388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7419, 3365, 20512, 20765, 3388, 3366, 20513, 20766, 3389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7420, 3366, 20513, 20766, 3389, 3367, 20514, 20767, 3390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7421, 3367, 20514, 20767, 3390, 3368, 20515, 20768, 3391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7422, 3368, 20515, 20768, 3391, 3369, 20516, 20769, 3392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7423, 3369, 20516, 20769, 3392, 3370, 20517, 20770, 3393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7424, 3370, 20517, 20770, 3393, 3371, 20518, 20771, 3394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7425, 3371, 20518, 20771, 3394, 358, 4889, 4900, 359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7426, 3072, 3073, 3084, 3083, 20496, 20519, 20772, 20749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7427, 20496, 20519, 20772, 20749, 20497, 20520, 20773, 20750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7428, 20497, 20520, 20773, 20750, 20498, 20521, 20774, 20751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7429, 20498, 20521, 20774, 20751, 20499, 20522, 20775, 20752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7430, 20499, 20522, 20775, 20752, 20500, 20523, 20776, 20753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7431, 20500, 20523, 20776, 20753, 20501, 20524, 20777, 20754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7432, 20501, 20524, 20777, 20754, 20502, 20525, 20778, 20755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7433, 20502, 20525, 20778, 20755, 20503, 20526, 20779, 20756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7434, 20503, 20526, 20779, 20756, 20504, 20527, 20780, 20757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7435, 20504, 20527, 20780, 20757, 20505, 20528, 20781, 20758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7436, 20505, 20528, 20781, 20758, 20506, 20529, 20782, 20759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7437, 20506, 20529, 20782, 20759, 20507, 20530, 20783, 20760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7438, 20507, 20530, 20783, 20760, 20508, 20531, 20784, 20761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7439, 20508, 20531, 20784, 20761, 20509, 20532, 20785, 20762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7440, 20509, 20532, 20785, 20762, 20510, 20533, 20786, 20763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7441, 20510, 20533, 20786, 20763, 20511, 20534, 20787, 20764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7442, 20511, 20534, 20787, 20764, 20512, 20535, 20788, 20765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7443, 20512, 20535, 20788, 20765, 20513, 20536, 20789, 20766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7444, 20513, 20536, 20789, 20766, 20514, 20537, 20790, 20767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7445, 20514, 20537, 20790, 20767, 20515, 20538, 20791, 20768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7446, 20515, 20538, 20791, 20768, 20516, 20539, 20792, 20769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7447, 20516, 20539, 20792, 20769, 20517, 20540, 20793, 20770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7448, 20517, 20540, 20793, 20770, 20518, 20541, 20794, 20771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7449, 20518, 20541, 20794, 20771, 4889, 4890, 4901, 4900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7450, 3073, 3074, 3085, 3084, 20519, 20542, 20795, 20772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7451, 20519, 20542, 20795, 20772, 20520, 20543, 20796, 20773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7452, 20520, 20543, 20796, 20773, 20521, 20544, 20797, 20774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7453, 20521, 20544, 20797, 20774, 20522, 20545, 20798, 20775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7454, 20522, 20545, 20798, 20775, 20523, 20546, 20799, 20776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7455, 20523, 20546, 20799, 20776, 20524, 20547, 20800, 20777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7456, 20524, 20547, 20800, 20777, 20525, 20548, 20801, 20778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7457, 20525, 20548, 20801, 20778, 20526, 20549, 20802, 20779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7458, 20526, 20549, 20802, 20779, 20527, 20550, 20803, 20780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7459, 20527, 20550, 20803, 20780, 20528, 20551, 20804, 20781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7460, 20528, 20551, 20804, 20781, 20529, 20552, 20805, 20782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7461, 20529, 20552, 20805, 20782, 20530, 20553, 20806, 20783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7462, 20530, 20553, 20806, 20783, 20531, 20554, 20807, 20784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7463, 20531, 20554, 20807, 20784, 20532, 20555, 20808, 20785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7464, 20532, 20555, 20808, 20785, 20533, 20556, 20809, 20786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7465, 20533, 20556, 20809, 20786, 20534, 20557, 20810, 20787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7466, 20534, 20557, 20810, 20787, 20535, 20558, 20811, 20788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7467, 20535, 20558, 20811, 20788, 20536, 20559, 20812, 20789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7468, 20536, 20559, 20812, 20789, 20537, 20560, 20813, 20790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7469, 20537, 20560, 20813, 20790, 20538, 20561, 20814, 20791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7470, 20538, 20561, 20814, 20791, 20539, 20562, 20815, 20792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7471, 20539, 20562, 20815, 20792, 20540, 20563, 20816, 20793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7472, 20540, 20563, 20816, 20793, 20541, 20564, 20817, 20794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7473, 20541, 20564, 20817, 20794, 4890, 4891, 4902, 4901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7474, 3074, 3075, 3086, 3085, 20542, 20565, 20818, 20795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7475, 20542, 20565, 20818, 20795, 20543, 20566, 20819, 20796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7476, 20543, 20566, 20819, 20796, 20544, 20567, 20820, 20797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7477, 20544, 20567, 20820, 20797, 20545, 20568, 20821, 20798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7478, 20545, 20568, 20821, 20798, 20546, 20569, 20822, 20799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7479, 20546, 20569, 20822, 20799, 20547, 20570, 20823, 20800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7480, 20547, 20570, 20823, 20800, 20548, 20571, 20824, 20801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7481, 20548, 20571, 20824, 20801, 20549, 20572, 20825, 20802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7482, 20549, 20572, 20825, 20802, 20550, 20573, 20826, 20803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7483, 20550, 20573, 20826, 20803, 20551, 20574, 20827, 20804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7484, 20551, 20574, 20827, 20804, 20552, 20575, 20828, 20805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7485, 20552, 20575, 20828, 20805, 20553, 20576, 20829, 20806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7486, 20553, 20576, 20829, 20806, 20554, 20577, 20830, 20807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7487, 20554, 20577, 20830, 20807, 20555, 20578, 20831, 20808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7488, 20555, 20578, 20831, 20808, 20556, 20579, 20832, 20809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7489, 20556, 20579, 20832, 20809, 20557, 20580, 20833, 20810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7490, 20557, 20580, 20833, 20810, 20558, 20581, 20834, 20811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7491, 20558, 20581, 20834, 20811, 20559, 20582, 20835, 20812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7492, 20559, 20582, 20835, 20812, 20560, 20583, 20836, 20813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7493, 20560, 20583, 20836, 20813, 20561, 20584, 20837, 20814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7494, 20561, 20584, 20837, 20814, 20562, 20585, 20838, 20815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7495, 20562, 20585, 20838, 20815, 20563, 20586, 20839, 20816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7496, 20563, 20586, 20839, 20816, 20564, 20587, 20840, 20817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7497, 20564, 20587, 20840, 20817, 4891, 4892, 4903, 4902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7498, 3075, 3076, 3087, 3086, 20565, 20588, 20841, 20818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7499, 20565, 20588, 20841, 20818, 20566, 20589, 20842, 20819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7500, 20566, 20589, 20842, 20819, 20567, 20590, 20843, 20820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7501, 20567, 20590, 20843, 20820, 20568, 20591, 20844, 20821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7502, 20568, 20591, 20844, 20821, 20569, 20592, 20845, 20822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7503, 20569, 20592, 20845, 20822, 20570, 20593, 20846, 20823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7504, 20570, 20593, 20846, 20823, 20571, 20594, 20847, 20824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7505, 20571, 20594, 20847, 20824, 20572, 20595, 20848, 20825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7506, 20572, 20595, 20848, 20825, 20573, 20596, 20849, 20826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7507, 20573, 20596, 20849, 20826, 20574, 20597, 20850, 20827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7508, 20574, 20597, 20850, 20827, 20575, 20598, 20851, 20828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7509, 20575, 20598, 20851, 20828, 20576, 20599, 20852, 20829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7510, 20576, 20599, 20852, 20829, 20577, 20600, 20853, 20830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7511, 20577, 20600, 20853, 20830, 20578, 20601, 20854, 20831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7512, 20578, 20601, 20854, 20831, 20579, 20602, 20855, 20832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7513, 20579, 20602, 20855, 20832, 20580, 20603, 20856, 20833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7514, 20580, 20603, 20856, 20833, 20581, 20604, 20857, 20834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7515, 20581, 20604, 20857, 20834, 20582, 20605, 20858, 20835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7516, 20582, 20605, 20858, 20835, 20583, 20606, 20859, 20836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7517, 20583, 20606, 20859, 20836, 20584, 20607, 20860, 20837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7518, 20584, 20607, 20860, 20837, 20585, 20608, 20861, 20838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7519, 20585, 20608, 20861, 20838, 20586, 20609, 20862, 20839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7520, 20586, 20609, 20862, 20839, 20587, 20610, 20863, 20840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7521, 20587, 20610, 20863, 20840, 4892, 4893, 4904, 4903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7522, 3076, 3077, 3088, 3087, 20588, 20611, 20864, 20841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7523, 20588, 20611, 20864, 20841, 20589, 20612, 20865, 20842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7524, 20589, 20612, 20865, 20842, 20590, 20613, 20866, 20843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7525, 20590, 20613, 20866, 20843, 20591, 20614, 20867, 20844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7526, 20591, 20614, 20867, 20844, 20592, 20615, 20868, 20845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7527, 20592, 20615, 20868, 20845, 20593, 20616, 20869, 20846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7528, 20593, 20616, 20869, 20846, 20594, 20617, 20870, 20847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7529, 20594, 20617, 20870, 20847, 20595, 20618, 20871, 20848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7530, 20595, 20618, 20871, 20848, 20596, 20619, 20872, 20849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7531, 20596, 20619, 20872, 20849, 20597, 20620, 20873, 20850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7532, 20597, 20620, 20873, 20850, 20598, 20621, 20874, 20851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7533, 20598, 20621, 20874, 20851, 20599, 20622, 20875, 20852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7534, 20599, 20622, 20875, 20852, 20600, 20623, 20876, 20853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7535, 20600, 20623, 20876, 20853, 20601, 20624, 20877, 20854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7536, 20601, 20624, 20877, 20854, 20602, 20625, 20878, 20855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7537, 20602, 20625, 20878, 20855, 20603, 20626, 20879, 20856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7538, 20603, 20626, 20879, 20856, 20604, 20627, 20880, 20857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7539, 20604, 20627, 20880, 20857, 20605, 20628, 20881, 20858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7540, 20605, 20628, 20881, 20858, 20606, 20629, 20882, 20859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7541, 20606, 20629, 20882, 20859, 20607, 20630, 20883, 20860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7542, 20607, 20630, 20883, 20860, 20608, 20631, 20884, 20861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7543, 20608, 20631, 20884, 20861, 20609, 20632, 20885, 20862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7544, 20609, 20632, 20885, 20862, 20610, 20633, 20886, 20863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7545, 20610, 20633, 20886, 20863, 4893, 4894, 4905, 4904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7546, 3077, 3078, 3089, 3088, 20611, 20634, 20887, 20864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7547, 20611, 20634, 20887, 20864, 20612, 20635, 20888, 20865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7548, 20612, 20635, 20888, 20865, 20613, 20636, 20889, 20866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7549, 20613, 20636, 20889, 20866, 20614, 20637, 20890, 20867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7550, 20614, 20637, 20890, 20867, 20615, 20638, 20891, 20868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7551, 20615, 20638, 20891, 20868, 20616, 20639, 20892, 20869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7552, 20616, 20639, 20892, 20869, 20617, 20640, 20893, 20870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7553, 20617, 20640, 20893, 20870, 20618, 20641, 20894, 20871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7554, 20618, 20641, 20894, 20871, 20619, 20642, 20895, 20872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7555, 20619, 20642, 20895, 20872, 20620, 20643, 20896, 20873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7556, 20620, 20643, 20896, 20873, 20621, 20644, 20897, 20874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7557, 20621, 20644, 20897, 20874, 20622, 20645, 20898, 20875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7558, 20622, 20645, 20898, 20875, 20623, 20646, 20899, 20876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7559, 20623, 20646, 20899, 20876, 20624, 20647, 20900, 20877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7560, 20624, 20647, 20900, 20877, 20625, 20648, 20901, 20878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7561, 20625, 20648, 20901, 20878, 20626, 20649, 20902, 20879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7562, 20626, 20649, 20902, 20879, 20627, 20650, 20903, 20880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7563, 20627, 20650, 20903, 20880, 20628, 20651, 20904, 20881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7564, 20628, 20651, 20904, 20881, 20629, 20652, 20905, 20882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7565, 20629, 20652, 20905, 20882, 20630, 20653, 20906, 20883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7566, 20630, 20653, 20906, 20883, 20631, 20654, 20907, 20884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7567, 20631, 20654, 20907, 20884, 20632, 20655, 20908, 20885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7568, 20632, 20655, 20908, 20885, 20633, 20656, 20909, 20886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7569, 20633, 20656, 20909, 20886, 4894, 4895, 4906, 4905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7570, 3078, 3079, 3090, 3089, 20634, 20657, 20910, 20887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7571, 20634, 20657, 20910, 20887, 20635, 20658, 20911, 20888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7572, 20635, 20658, 20911, 20888, 20636, 20659, 20912, 20889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7573, 20636, 20659, 20912, 20889, 20637, 20660, 20913, 20890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7574, 20637, 20660, 20913, 20890, 20638, 20661, 20914, 20891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7575, 20638, 20661, 20914, 20891, 20639, 20662, 20915, 20892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7576, 20639, 20662, 20915, 20892, 20640, 20663, 20916, 20893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7577, 20640, 20663, 20916, 20893, 20641, 20664, 20917, 20894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7578, 20641, 20664, 20917, 20894, 20642, 20665, 20918, 20895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7579, 20642, 20665, 20918, 20895, 20643, 20666, 20919, 20896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7580, 20643, 20666, 20919, 20896, 20644, 20667, 20920, 20897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7581, 20644, 20667, 20920, 20897, 20645, 20668, 20921, 20898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7582, 20645, 20668, 20921, 20898, 20646, 20669, 20922, 20899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7583, 20646, 20669, 20922, 20899, 20647, 20670, 20923, 20900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7584, 20647, 20670, 20923, 20900, 20648, 20671, 20924, 20901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7585, 20648, 20671, 20924, 20901, 20649, 20672, 20925, 20902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7586, 20649, 20672, 20925, 20902, 20650, 20673, 20926, 20903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7587, 20650, 20673, 20926, 20903, 20651, 20674, 20927, 20904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7588, 20651, 20674, 20927, 20904, 20652, 20675, 20928, 20905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7589, 20652, 20675, 20928, 20905, 20653, 20676, 20929, 20906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7590, 20653, 20676, 20929, 20906, 20654, 20677, 20930, 20907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7591, 20654, 20677, 20930, 20907, 20655, 20678, 20931, 20908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7592, 20655, 20678, 20931, 20908, 20656, 20679, 20932, 20909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7593, 20656, 20679, 20932, 20909, 4895, 4896, 4907, 4906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7594, 3079, 3080, 3091, 3090, 20657, 20680, 20933, 20910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7595, 20657, 20680, 20933, 20910, 20658, 20681, 20934, 20911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7596, 20658, 20681, 20934, 20911, 20659, 20682, 20935, 20912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7597, 20659, 20682, 20935, 20912, 20660, 20683, 20936, 20913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7598, 20660, 20683, 20936, 20913, 20661, 20684, 20937, 20914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7599, 20661, 20684, 20937, 20914, 20662, 20685, 20938, 20915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7600, 20662, 20685, 20938, 20915, 20663, 20686, 20939, 20916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7601, 20663, 20686, 20939, 20916, 20664, 20687, 20940, 20917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7602, 20664, 20687, 20940, 20917, 20665, 20688, 20941, 20918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7603, 20665, 20688, 20941, 20918, 20666, 20689, 20942, 20919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7604, 20666, 20689, 20942, 20919, 20667, 20690, 20943, 20920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7605, 20667, 20690, 20943, 20920, 20668, 20691, 20944, 20921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7606, 20668, 20691, 20944, 20921, 20669, 20692, 20945, 20922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7607, 20669, 20692, 20945, 20922, 20670, 20693, 20946, 20923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7608, 20670, 20693, 20946, 20923, 20671, 20694, 20947, 20924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7609, 20671, 20694, 20947, 20924, 20672, 20695, 20948, 20925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7610, 20672, 20695, 20948, 20925, 20673, 20696, 20949, 20926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7611, 20673, 20696, 20949, 20926, 20674, 20697, 20950, 20927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7612, 20674, 20697, 20950, 20927, 20675, 20698, 20951, 20928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7613, 20675, 20698, 20951, 20928, 20676, 20699, 20952, 20929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7614, 20676, 20699, 20952, 20929, 20677, 20700, 20953, 20930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7615, 20677, 20700, 20953, 20930, 20678, 20701, 20954, 20931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7616, 20678, 20701, 20954, 20931, 20679, 20702, 20955, 20932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7617, 20679, 20702, 20955, 20932, 4896, 4897, 4908, 4907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7618, 3080, 3081, 3092, 3091, 20680, 20703, 20956, 20933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7619, 20680, 20703, 20956, 20933, 20681, 20704, 20957, 20934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7620, 20681, 20704, 20957, 20934, 20682, 20705, 20958, 20935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7621, 20682, 20705, 20958, 20935, 20683, 20706, 20959, 20936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7622, 20683, 20706, 20959, 20936, 20684, 20707, 20960, 20937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7623, 20684, 20707, 20960, 20937, 20685, 20708, 20961, 20938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7624, 20685, 20708, 20961, 20938, 20686, 20709, 20962, 20939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7625, 20686, 20709, 20962, 20939, 20687, 20710, 20963, 20940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7626, 20687, 20710, 20963, 20940, 20688, 20711, 20964, 20941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7627, 20688, 20711, 20964, 20941, 20689, 20712, 20965, 20942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7628, 20689, 20712, 20965, 20942, 20690, 20713, 20966, 20943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7629, 20690, 20713, 20966, 20943, 20691, 20714, 20967, 20944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7630, 20691, 20714, 20967, 20944, 20692, 20715, 20968, 20945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7631, 20692, 20715, 20968, 20945, 20693, 20716, 20969, 20946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7632, 20693, 20716, 20969, 20946, 20694, 20717, 20970, 20947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7633, 20694, 20717, 20970, 20947, 20695, 20718, 20971, 20948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7634, 20695, 20718, 20971, 20948, 20696, 20719, 20972, 20949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7635, 20696, 20719, 20972, 20949, 20697, 20720, 20973, 20950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7636, 20697, 20720, 20973, 20950, 20698, 20721, 20974, 20951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7637, 20698, 20721, 20974, 20951, 20699, 20722, 20975, 20952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7638, 20699, 20722, 20975, 20952, 20700, 20723, 20976, 20953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7639, 20700, 20723, 20976, 20953, 20701, 20724, 20977, 20954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7640, 20701, 20724, 20977, 20954, 20702, 20725, 20978, 20955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7641, 20702, 20725, 20978, 20955, 4897, 4898, 4909, 4908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7642, 3081, 3082, 3093, 3092, 20703, 20726, 20979, 20956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7643, 20703, 20726, 20979, 20956, 20704, 20727, 20980, 20957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7644, 20704, 20727, 20980, 20957, 20705, 20728, 20981, 20958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7645, 20705, 20728, 20981, 20958, 20706, 20729, 20982, 20959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7646, 20706, 20729, 20982, 20959, 20707, 20730, 20983, 20960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7647, 20707, 20730, 20983, 20960, 20708, 20731, 20984, 20961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7648, 20708, 20731, 20984, 20961, 20709, 20732, 20985, 20962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7649, 20709, 20732, 20985, 20962, 20710, 20733, 20986, 20963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7650, 20710, 20733, 20986, 20963, 20711, 20734, 20987, 20964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7651, 20711, 20734, 20987, 20964, 20712, 20735, 20988, 20965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7652, 20712, 20735, 20988, 20965, 20713, 20736, 20989, 20966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7653, 20713, 20736, 20989, 20966, 20714, 20737, 20990, 20967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7654, 20714, 20737, 20990, 20967, 20715, 20738, 20991, 20968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7655, 20715, 20738, 20991, 20968, 20716, 20739, 20992, 20969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7656, 20716, 20739, 20992, 20969, 20717, 20740, 20993, 20970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7657, 20717, 20740, 20993, 20970, 20718, 20741, 20994, 20971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7658, 20718, 20741, 20994, 20971, 20719, 20742, 20995, 20972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7659, 20719, 20742, 20995, 20972, 20720, 20743, 20996, 20973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7660, 20720, 20743, 20996, 20973, 20721, 20744, 20997, 20974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7661, 20721, 20744, 20997, 20974, 20722, 20745, 20998, 20975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7662, 20722, 20745, 20998, 20975, 20723, 20746, 20999, 20976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7663, 20723, 20746, 20999, 20976, 20724, 20747, 21000, 20977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7664, 20724, 20747, 21000, 20977, 20725, 20748, 21001, 20978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7665, 20725, 20748, 21001, 20978, 4898, 4899, 4910, 4909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7666, 3082, 278, 279, 3093, 20726, 4131, 4154, 20979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7667, 20726, 4131, 4154, 20979, 20727, 4132, 4155, 20980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7668, 20727, 4132, 4155, 20980, 20728, 4133, 4156, 20981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7669, 20728, 4133, 4156, 20981, 20729, 4134, 4157, 20982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7670, 20729, 4134, 4157, 20982, 20730, 4135, 4158, 20983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7671, 20730, 4135, 4158, 20983, 20731, 4136, 4159, 20984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7672, 20731, 4136, 4159, 20984, 20732, 4137, 4160, 20985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7673, 20732, 4137, 4160, 20985, 20733, 4138, 4161, 20986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7674, 20733, 4138, 4161, 20986, 20734, 4139, 4162, 20987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7675, 20734, 4139, 4162, 20987, 20735, 4140, 4163, 20988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7676, 20735, 4140, 4163, 20988, 20736, 4141, 4164, 20989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7677, 20736, 4141, 4164, 20989, 20737, 4142, 4165, 20990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7678, 20737, 4142, 4165, 20990, 20738, 4143, 4166, 20991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7679, 20738, 4143, 4166, 20991, 20739, 4144, 4167, 20992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7680, 20739, 4144, 4167, 20992, 20740, 4145, 4168, 20993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7681, 20740, 4145, 4168, 20993, 20741, 4146, 4169, 20994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7682, 20741, 4146, 4169, 20994, 20742, 4147, 4170, 20995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7683, 20742, 4147, 4170, 20995, 20743, 4148, 4171, 20996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7684, 20743, 4148, 4171, 20996, 20744, 4149, 4172, 20997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7685, 20744, 4149, 4172, 20997, 20745, 4150, 4173, 20998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7686, 20745, 4150, 4173, 20998, 20746, 4151, 4174, 20999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7687, 20746, 4151, 4174, 20999, 20747, 4152, 4175, 21000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7688, 20747, 4152, 4175, 21000, 20748, 4153, 4176, 21001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7689, 20748, 4153, 4176, 21001, 4899, 438, 439, 4910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7690, 245, 3083, 3094, 246, 3372, 20749, 21002, 3395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7691, 3372, 20749, 21002, 3395, 3373, 20750, 21003, 3396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7692, 3373, 20750, 21003, 3396, 3374, 20751, 21004, 3397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7693, 3374, 20751, 21004, 3397, 3375, 20752, 21005, 3398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7694, 3375, 20752, 21005, 3398, 3376, 20753, 21006, 3399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7695, 3376, 20753, 21006, 3399, 3377, 20754, 21007, 3400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7696, 3377, 20754, 21007, 3400, 3378, 20755, 21008, 3401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7697, 3378, 20755, 21008, 3401, 3379, 20756, 21009, 3402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7698, 3379, 20756, 21009, 3402, 3380, 20757, 21010, 3403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7699, 3380, 20757, 21010, 3403, 3381, 20758, 21011, 3404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7700, 3381, 20758, 21011, 3404, 3382, 20759, 21012, 3405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7701, 3382, 20759, 21012, 3405, 3383, 20760, 21013, 3406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7702, 3383, 20760, 21013, 3406, 3384, 20761, 21014, 3407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7703, 3384, 20761, 21014, 3407, 3385, 20762, 21015, 3408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7704, 3385, 20762, 21015, 3408, 3386, 20763, 21016, 3409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7705, 3386, 20763, 21016, 3409, 3387, 20764, 21017, 3410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7706, 3387, 20764, 21017, 3410, 3388, 20765, 21018, 3411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7707, 3388, 20765, 21018, 3411, 3389, 20766, 21019, 3412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7708, 3389, 20766, 21019, 3412, 3390, 20767, 21020, 3413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7709, 3390, 20767, 21020, 3413, 3391, 20768, 21021, 3414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7710, 3391, 20768, 21021, 3414, 3392, 20769, 21022, 3415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7711, 3392, 20769, 21022, 3415, 3393, 20770, 21023, 3416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7712, 3393, 20770, 21023, 3416, 3394, 20771, 21024, 3417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7713, 3394, 20771, 21024, 3417, 359, 4900, 4911, 360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7714, 3083, 3084, 3095, 3094, 20749, 20772, 21025, 21002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7715, 20749, 20772, 21025, 21002, 20750, 20773, 21026, 21003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7716, 20750, 20773, 21026, 21003, 20751, 20774, 21027, 21004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7717, 20751, 20774, 21027, 21004, 20752, 20775, 21028, 21005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7718, 20752, 20775, 21028, 21005, 20753, 20776, 21029, 21006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7719, 20753, 20776, 21029, 21006, 20754, 20777, 21030, 21007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7720, 20754, 20777, 21030, 21007, 20755, 20778, 21031, 21008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7721, 20755, 20778, 21031, 21008, 20756, 20779, 21032, 21009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7722, 20756, 20779, 21032, 21009, 20757, 20780, 21033, 21010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7723, 20757, 20780, 21033, 21010, 20758, 20781, 21034, 21011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7724, 20758, 20781, 21034, 21011, 20759, 20782, 21035, 21012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7725, 20759, 20782, 21035, 21012, 20760, 20783, 21036, 21013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7726, 20760, 20783, 21036, 21013, 20761, 20784, 21037, 21014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7727, 20761, 20784, 21037, 21014, 20762, 20785, 21038, 21015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7728, 20762, 20785, 21038, 21015, 20763, 20786, 21039, 21016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7729, 20763, 20786, 21039, 21016, 20764, 20787, 21040, 21017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7730, 20764, 20787, 21040, 21017, 20765, 20788, 21041, 21018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7731, 20765, 20788, 21041, 21018, 20766, 20789, 21042, 21019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7732, 20766, 20789, 21042, 21019, 20767, 20790, 21043, 21020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7733, 20767, 20790, 21043, 21020, 20768, 20791, 21044, 21021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7734, 20768, 20791, 21044, 21021, 20769, 20792, 21045, 21022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7735, 20769, 20792, 21045, 21022, 20770, 20793, 21046, 21023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7736, 20770, 20793, 21046, 21023, 20771, 20794, 21047, 21024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7737, 20771, 20794, 21047, 21024, 4900, 4901, 4912, 4911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7738, 3084, 3085, 3096, 3095, 20772, 20795, 21048, 21025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7739, 20772, 20795, 21048, 21025, 20773, 20796, 21049, 21026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7740, 20773, 20796, 21049, 21026, 20774, 20797, 21050, 21027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7741, 20774, 20797, 21050, 21027, 20775, 20798, 21051, 21028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7742, 20775, 20798, 21051, 21028, 20776, 20799, 21052, 21029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7743, 20776, 20799, 21052, 21029, 20777, 20800, 21053, 21030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7744, 20777, 20800, 21053, 21030, 20778, 20801, 21054, 21031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7745, 20778, 20801, 21054, 21031, 20779, 20802, 21055, 21032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7746, 20779, 20802, 21055, 21032, 20780, 20803, 21056, 21033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7747, 20780, 20803, 21056, 21033, 20781, 20804, 21057, 21034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7748, 20781, 20804, 21057, 21034, 20782, 20805, 21058, 21035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7749, 20782, 20805, 21058, 21035, 20783, 20806, 21059, 21036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7750, 20783, 20806, 21059, 21036, 20784, 20807, 21060, 21037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7751, 20784, 20807, 21060, 21037, 20785, 20808, 21061, 21038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7752, 20785, 20808, 21061, 21038, 20786, 20809, 21062, 21039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7753, 20786, 20809, 21062, 21039, 20787, 20810, 21063, 21040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7754, 20787, 20810, 21063, 21040, 20788, 20811, 21064, 21041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7755, 20788, 20811, 21064, 21041, 20789, 20812, 21065, 21042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7756, 20789, 20812, 21065, 21042, 20790, 20813, 21066, 21043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7757, 20790, 20813, 21066, 21043, 20791, 20814, 21067, 21044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7758, 20791, 20814, 21067, 21044, 20792, 20815, 21068, 21045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7759, 20792, 20815, 21068, 21045, 20793, 20816, 21069, 21046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7760, 20793, 20816, 21069, 21046, 20794, 20817, 21070, 21047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7761, 20794, 20817, 21070, 21047, 4901, 4902, 4913, 4912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7762, 3085, 3086, 3097, 3096, 20795, 20818, 21071, 21048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7763, 20795, 20818, 21071, 21048, 20796, 20819, 21072, 21049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7764, 20796, 20819, 21072, 21049, 20797, 20820, 21073, 21050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7765, 20797, 20820, 21073, 21050, 20798, 20821, 21074, 21051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7766, 20798, 20821, 21074, 21051, 20799, 20822, 21075, 21052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7767, 20799, 20822, 21075, 21052, 20800, 20823, 21076, 21053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7768, 20800, 20823, 21076, 21053, 20801, 20824, 21077, 21054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7769, 20801, 20824, 21077, 21054, 20802, 20825, 21078, 21055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7770, 20802, 20825, 21078, 21055, 20803, 20826, 21079, 21056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7771, 20803, 20826, 21079, 21056, 20804, 20827, 21080, 21057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7772, 20804, 20827, 21080, 21057, 20805, 20828, 21081, 21058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7773, 20805, 20828, 21081, 21058, 20806, 20829, 21082, 21059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7774, 20806, 20829, 21082, 21059, 20807, 20830, 21083, 21060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7775, 20807, 20830, 21083, 21060, 20808, 20831, 21084, 21061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7776, 20808, 20831, 21084, 21061, 20809, 20832, 21085, 21062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7777, 20809, 20832, 21085, 21062, 20810, 20833, 21086, 21063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7778, 20810, 20833, 21086, 21063, 20811, 20834, 21087, 21064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7779, 20811, 20834, 21087, 21064, 20812, 20835, 21088, 21065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7780, 20812, 20835, 21088, 21065, 20813, 20836, 21089, 21066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7781, 20813, 20836, 21089, 21066, 20814, 20837, 21090, 21067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7782, 20814, 20837, 21090, 21067, 20815, 20838, 21091, 21068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7783, 20815, 20838, 21091, 21068, 20816, 20839, 21092, 21069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7784, 20816, 20839, 21092, 21069, 20817, 20840, 21093, 21070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7785, 20817, 20840, 21093, 21070, 4902, 4903, 4914, 4913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7786, 3086, 3087, 3098, 3097, 20818, 20841, 21094, 21071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7787, 20818, 20841, 21094, 21071, 20819, 20842, 21095, 21072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7788, 20819, 20842, 21095, 21072, 20820, 20843, 21096, 21073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7789, 20820, 20843, 21096, 21073, 20821, 20844, 21097, 21074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7790, 20821, 20844, 21097, 21074, 20822, 20845, 21098, 21075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7791, 20822, 20845, 21098, 21075, 20823, 20846, 21099, 21076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7792, 20823, 20846, 21099, 21076, 20824, 20847, 21100, 21077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7793, 20824, 20847, 21100, 21077, 20825, 20848, 21101, 21078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7794, 20825, 20848, 21101, 21078, 20826, 20849, 21102, 21079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7795, 20826, 20849, 21102, 21079, 20827, 20850, 21103, 21080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7796, 20827, 20850, 21103, 21080, 20828, 20851, 21104, 21081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7797, 20828, 20851, 21104, 21081, 20829, 20852, 21105, 21082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7798, 20829, 20852, 21105, 21082, 20830, 20853, 21106, 21083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7799, 20830, 20853, 21106, 21083, 20831, 20854, 21107, 21084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7800, 20831, 20854, 21107, 21084, 20832, 20855, 21108, 21085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7801, 20832, 20855, 21108, 21085, 20833, 20856, 21109, 21086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7802, 20833, 20856, 21109, 21086, 20834, 20857, 21110, 21087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7803, 20834, 20857, 21110, 21087, 20835, 20858, 21111, 21088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7804, 20835, 20858, 21111, 21088, 20836, 20859, 21112, 21089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7805, 20836, 20859, 21112, 21089, 20837, 20860, 21113, 21090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7806, 20837, 20860, 21113, 21090, 20838, 20861, 21114, 21091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7807, 20838, 20861, 21114, 21091, 20839, 20862, 21115, 21092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7808, 20839, 20862, 21115, 21092, 20840, 20863, 21116, 21093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7809, 20840, 20863, 21116, 21093, 4903, 4904, 4915, 4914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7810, 3087, 3088, 3099, 3098, 20841, 20864, 21117, 21094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7811, 20841, 20864, 21117, 21094, 20842, 20865, 21118, 21095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7812, 20842, 20865, 21118, 21095, 20843, 20866, 21119, 21096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7813, 20843, 20866, 21119, 21096, 20844, 20867, 21120, 21097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7814, 20844, 20867, 21120, 21097, 20845, 20868, 21121, 21098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7815, 20845, 20868, 21121, 21098, 20846, 20869, 21122, 21099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7816, 20846, 20869, 21122, 21099, 20847, 20870, 21123, 21100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7817, 20847, 20870, 21123, 21100, 20848, 20871, 21124, 21101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7818, 20848, 20871, 21124, 21101, 20849, 20872, 21125, 21102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7819, 20849, 20872, 21125, 21102, 20850, 20873, 21126, 21103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7820, 20850, 20873, 21126, 21103, 20851, 20874, 21127, 21104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7821, 20851, 20874, 21127, 21104, 20852, 20875, 21128, 21105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7822, 20852, 20875, 21128, 21105, 20853, 20876, 21129, 21106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7823, 20853, 20876, 21129, 21106, 20854, 20877, 21130, 21107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7824, 20854, 20877, 21130, 21107, 20855, 20878, 21131, 21108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7825, 20855, 20878, 21131, 21108, 20856, 20879, 21132, 21109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7826, 20856, 20879, 21132, 21109, 20857, 20880, 21133, 21110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7827, 20857, 20880, 21133, 21110, 20858, 20881, 21134, 21111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7828, 20858, 20881, 21134, 21111, 20859, 20882, 21135, 21112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7829, 20859, 20882, 21135, 21112, 20860, 20883, 21136, 21113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7830, 20860, 20883, 21136, 21113, 20861, 20884, 21137, 21114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7831, 20861, 20884, 21137, 21114, 20862, 20885, 21138, 21115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7832, 20862, 20885, 21138, 21115, 20863, 20886, 21139, 21116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7833, 20863, 20886, 21139, 21116, 4904, 4905, 4916, 4915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7834, 3088, 3089, 3100, 3099, 20864, 20887, 21140, 21117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7835, 20864, 20887, 21140, 21117, 20865, 20888, 21141, 21118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7836, 20865, 20888, 21141, 21118, 20866, 20889, 21142, 21119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7837, 20866, 20889, 21142, 21119, 20867, 20890, 21143, 21120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7838, 20867, 20890, 21143, 21120, 20868, 20891, 21144, 21121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7839, 20868, 20891, 21144, 21121, 20869, 20892, 21145, 21122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7840, 20869, 20892, 21145, 21122, 20870, 20893, 21146, 21123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7841, 20870, 20893, 21146, 21123, 20871, 20894, 21147, 21124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7842, 20871, 20894, 21147, 21124, 20872, 20895, 21148, 21125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7843, 20872, 20895, 21148, 21125, 20873, 20896, 21149, 21126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7844, 20873, 20896, 21149, 21126, 20874, 20897, 21150, 21127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7845, 20874, 20897, 21150, 21127, 20875, 20898, 21151, 21128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7846, 20875, 20898, 21151, 21128, 20876, 20899, 21152, 21129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7847, 20876, 20899, 21152, 21129, 20877, 20900, 21153, 21130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7848, 20877, 20900, 21153, 21130, 20878, 20901, 21154, 21131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7849, 20878, 20901, 21154, 21131, 20879, 20902, 21155, 21132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7850, 20879, 20902, 21155, 21132, 20880, 20903, 21156, 21133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7851, 20880, 20903, 21156, 21133, 20881, 20904, 21157, 21134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7852, 20881, 20904, 21157, 21134, 20882, 20905, 21158, 21135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7853, 20882, 20905, 21158, 21135, 20883, 20906, 21159, 21136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7854, 20883, 20906, 21159, 21136, 20884, 20907, 21160, 21137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7855, 20884, 20907, 21160, 21137, 20885, 20908, 21161, 21138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7856, 20885, 20908, 21161, 21138, 20886, 20909, 21162, 21139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7857, 20886, 20909, 21162, 21139, 4905, 4906, 4917, 4916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7858, 3089, 3090, 3101, 3100, 20887, 20910, 21163, 21140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7859, 20887, 20910, 21163, 21140, 20888, 20911, 21164, 21141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7860, 20888, 20911, 21164, 21141, 20889, 20912, 21165, 21142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7861, 20889, 20912, 21165, 21142, 20890, 20913, 21166, 21143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7862, 20890, 20913, 21166, 21143, 20891, 20914, 21167, 21144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7863, 20891, 20914, 21167, 21144, 20892, 20915, 21168, 21145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7864, 20892, 20915, 21168, 21145, 20893, 20916, 21169, 21146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7865, 20893, 20916, 21169, 21146, 20894, 20917, 21170, 21147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7866, 20894, 20917, 21170, 21147, 20895, 20918, 21171, 21148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7867, 20895, 20918, 21171, 21148, 20896, 20919, 21172, 21149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7868, 20896, 20919, 21172, 21149, 20897, 20920, 21173, 21150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7869, 20897, 20920, 21173, 21150, 20898, 20921, 21174, 21151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7870, 20898, 20921, 21174, 21151, 20899, 20922, 21175, 21152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7871, 20899, 20922, 21175, 21152, 20900, 20923, 21176, 21153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7872, 20900, 20923, 21176, 21153, 20901, 20924, 21177, 21154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7873, 20901, 20924, 21177, 21154, 20902, 20925, 21178, 21155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7874, 20902, 20925, 21178, 21155, 20903, 20926, 21179, 21156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7875, 20903, 20926, 21179, 21156, 20904, 20927, 21180, 21157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7876, 20904, 20927, 21180, 21157, 20905, 20928, 21181, 21158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7877, 20905, 20928, 21181, 21158, 20906, 20929, 21182, 21159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7878, 20906, 20929, 21182, 21159, 20907, 20930, 21183, 21160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7879, 20907, 20930, 21183, 21160, 20908, 20931, 21184, 21161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7880, 20908, 20931, 21184, 21161, 20909, 20932, 21185, 21162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7881, 20909, 20932, 21185, 21162, 4906, 4907, 4918, 4917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7882, 3090, 3091, 3102, 3101, 20910, 20933, 21186, 21163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7883, 20910, 20933, 21186, 21163, 20911, 20934, 21187, 21164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7884, 20911, 20934, 21187, 21164, 20912, 20935, 21188, 21165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7885, 20912, 20935, 21188, 21165, 20913, 20936, 21189, 21166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7886, 20913, 20936, 21189, 21166, 20914, 20937, 21190, 21167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7887, 20914, 20937, 21190, 21167, 20915, 20938, 21191, 21168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7888, 20915, 20938, 21191, 21168, 20916, 20939, 21192, 21169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7889, 20916, 20939, 21192, 21169, 20917, 20940, 21193, 21170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7890, 20917, 20940, 21193, 21170, 20918, 20941, 21194, 21171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7891, 20918, 20941, 21194, 21171, 20919, 20942, 21195, 21172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7892, 20919, 20942, 21195, 21172, 20920, 20943, 21196, 21173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7893, 20920, 20943, 21196, 21173, 20921, 20944, 21197, 21174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7894, 20921, 20944, 21197, 21174, 20922, 20945, 21198, 21175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7895, 20922, 20945, 21198, 21175, 20923, 20946, 21199, 21176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7896, 20923, 20946, 21199, 21176, 20924, 20947, 21200, 21177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7897, 20924, 20947, 21200, 21177, 20925, 20948, 21201, 21178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7898, 20925, 20948, 21201, 21178, 20926, 20949, 21202, 21179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7899, 20926, 20949, 21202, 21179, 20927, 20950, 21203, 21180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7900, 20927, 20950, 21203, 21180, 20928, 20951, 21204, 21181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7901, 20928, 20951, 21204, 21181, 20929, 20952, 21205, 21182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7902, 20929, 20952, 21205, 21182, 20930, 20953, 21206, 21183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7903, 20930, 20953, 21206, 21183, 20931, 20954, 21207, 21184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7904, 20931, 20954, 21207, 21184, 20932, 20955, 21208, 21185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7905, 20932, 20955, 21208, 21185, 4907, 4908, 4919, 4918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7906, 3091, 3092, 3103, 3102, 20933, 20956, 21209, 21186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7907, 20933, 20956, 21209, 21186, 20934, 20957, 21210, 21187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7908, 20934, 20957, 21210, 21187, 20935, 20958, 21211, 21188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7909, 20935, 20958, 21211, 21188, 20936, 20959, 21212, 21189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7910, 20936, 20959, 21212, 21189, 20937, 20960, 21213, 21190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7911, 20937, 20960, 21213, 21190, 20938, 20961, 21214, 21191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7912, 20938, 20961, 21214, 21191, 20939, 20962, 21215, 21192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7913, 20939, 20962, 21215, 21192, 20940, 20963, 21216, 21193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7914, 20940, 20963, 21216, 21193, 20941, 20964, 21217, 21194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7915, 20941, 20964, 21217, 21194, 20942, 20965, 21218, 21195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7916, 20942, 20965, 21218, 21195, 20943, 20966, 21219, 21196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7917, 20943, 20966, 21219, 21196, 20944, 20967, 21220, 21197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7918, 20944, 20967, 21220, 21197, 20945, 20968, 21221, 21198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7919, 20945, 20968, 21221, 21198, 20946, 20969, 21222, 21199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7920, 20946, 20969, 21222, 21199, 20947, 20970, 21223, 21200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7921, 20947, 20970, 21223, 21200, 20948, 20971, 21224, 21201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7922, 20948, 20971, 21224, 21201, 20949, 20972, 21225, 21202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7923, 20949, 20972, 21225, 21202, 20950, 20973, 21226, 21203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7924, 20950, 20973, 21226, 21203, 20951, 20974, 21227, 21204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7925, 20951, 20974, 21227, 21204, 20952, 20975, 21228, 21205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7926, 20952, 20975, 21228, 21205, 20953, 20976, 21229, 21206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7927, 20953, 20976, 21229, 21206, 20954, 20977, 21230, 21207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7928, 20954, 20977, 21230, 21207, 20955, 20978, 21231, 21208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7929, 20955, 20978, 21231, 21208, 4908, 4909, 4920, 4919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7930, 3092, 3093, 3104, 3103, 20956, 20979, 21232, 21209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7931, 20956, 20979, 21232, 21209, 20957, 20980, 21233, 21210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7932, 20957, 20980, 21233, 21210, 20958, 20981, 21234, 21211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7933, 20958, 20981, 21234, 21211, 20959, 20982, 21235, 21212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7934, 20959, 20982, 21235, 21212, 20960, 20983, 21236, 21213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7935, 20960, 20983, 21236, 21213, 20961, 20984, 21237, 21214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7936, 20961, 20984, 21237, 21214, 20962, 20985, 21238, 21215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7937, 20962, 20985, 21238, 21215, 20963, 20986, 21239, 21216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7938, 20963, 20986, 21239, 21216, 20964, 20987, 21240, 21217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7939, 20964, 20987, 21240, 21217, 20965, 20988, 21241, 21218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7940, 20965, 20988, 21241, 21218, 20966, 20989, 21242, 21219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7941, 20966, 20989, 21242, 21219, 20967, 20990, 21243, 21220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7942, 20967, 20990, 21243, 21220, 20968, 20991, 21244, 21221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7943, 20968, 20991, 21244, 21221, 20969, 20992, 21245, 21222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7944, 20969, 20992, 21245, 21222, 20970, 20993, 21246, 21223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7945, 20970, 20993, 21246, 21223, 20971, 20994, 21247, 21224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7946, 20971, 20994, 21247, 21224, 20972, 20995, 21248, 21225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7947, 20972, 20995, 21248, 21225, 20973, 20996, 21249, 21226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7948, 20973, 20996, 21249, 21226, 20974, 20997, 21250, 21227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7949, 20974, 20997, 21250, 21227, 20975, 20998, 21251, 21228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7950, 20975, 20998, 21251, 21228, 20976, 20999, 21252, 21229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7951, 20976, 20999, 21252, 21229, 20977, 21000, 21253, 21230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7952, 20977, 21000, 21253, 21230, 20978, 21001, 21254, 21231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7953, 20978, 21001, 21254, 21231, 4909, 4910, 4921, 4920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7954, 3093, 279, 280, 3104, 20979, 4154, 4177, 21232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7955, 20979, 4154, 4177, 21232, 20980, 4155, 4178, 21233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7956, 20980, 4155, 4178, 21233, 20981, 4156, 4179, 21234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7957, 20981, 4156, 4179, 21234, 20982, 4157, 4180, 21235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7958, 20982, 4157, 4180, 21235, 20983, 4158, 4181, 21236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7959, 20983, 4158, 4181, 21236, 20984, 4159, 4182, 21237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7960, 20984, 4159, 4182, 21237, 20985, 4160, 4183, 21238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7961, 20985, 4160, 4183, 21238, 20986, 4161, 4184, 21239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7962, 20986, 4161, 4184, 21239, 20987, 4162, 4185, 21240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7963, 20987, 4162, 4185, 21240, 20988, 4163, 4186, 21241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7964, 20988, 4163, 4186, 21241, 20989, 4164, 4187, 21242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7965, 20989, 4164, 4187, 21242, 20990, 4165, 4188, 21243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7966, 20990, 4165, 4188, 21243, 20991, 4166, 4189, 21244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7967, 20991, 4166, 4189, 21244, 20992, 4167, 4190, 21245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7968, 20992, 4167, 4190, 21245, 20993, 4168, 4191, 21246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7969, 20993, 4168, 4191, 21246, 20994, 4169, 4192, 21247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7970, 20994, 4169, 4192, 21247, 20995, 4170, 4193, 21248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7971, 20995, 4170, 4193, 21248, 20996, 4171, 4194, 21249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7972, 20996, 4171, 4194, 21249, 20997, 4172, 4195, 21250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7973, 20997, 4172, 4195, 21250, 20998, 4173, 4196, 21251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7974, 20998, 4173, 4196, 21251, 20999, 4174, 4197, 21252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7975, 20999, 4174, 4197, 21252, 21000, 4175, 4198, 21253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7976, 21000, 4175, 4198, 21253, 21001, 4176, 4199, 21254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7977, 21001, 4176, 4199, 21254, 4910, 439, 440, 4921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7978, 246, 3094, 3105, 247, 3395, 21002, 21255, 3418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7979, 3395, 21002, 21255, 3418, 3396, 21003, 21256, 3419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7980, 3396, 21003, 21256, 3419, 3397, 21004, 21257, 3420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7981, 3397, 21004, 21257, 3420, 3398, 21005, 21258, 3421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7982, 3398, 21005, 21258, 3421, 3399, 21006, 21259, 3422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7983, 3399, 21006, 21259, 3422, 3400, 21007, 21260, 3423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7984, 3400, 21007, 21260, 3423, 3401, 21008, 21261, 3424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7985, 3401, 21008, 21261, 3424, 3402, 21009, 21262, 3425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7986, 3402, 21009, 21262, 3425, 3403, 21010, 21263, 3426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7987, 3403, 21010, 21263, 3426, 3404, 21011, 21264, 3427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7988, 3404, 21011, 21264, 3427, 3405, 21012, 21265, 3428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7989, 3405, 21012, 21265, 3428, 3406, 21013, 21266, 3429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7990, 3406, 21013, 21266, 3429, 3407, 21014, 21267, 3430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7991, 3407, 21014, 21267, 3430, 3408, 21015, 21268, 3431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7992, 3408, 21015, 21268, 3431, 3409, 21016, 21269, 3432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7993, 3409, 21016, 21269, 3432, 3410, 21017, 21270, 3433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7994, 3410, 21017, 21270, 3433, 3411, 21018, 21271, 3434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7995, 3411, 21018, 21271, 3434, 3412, 21019, 21272, 3435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7996, 3412, 21019, 21272, 3435, 3413, 21020, 21273, 3436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7997, 3413, 21020, 21273, 3436, 3414, 21021, 21274, 3437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7998, 3414, 21021, 21274, 3437, 3415, 21022, 21275, 3438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7999, 3415, 21022, 21275, 3438, 3416, 21023, 21276, 3439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8000, 3416, 21023, 21276, 3439, 3417, 21024, 21277, 3440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8001, 3417, 21024, 21277, 3440, 360, 4911, 4922, 361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8002, 3094, 3095, 3106, 3105, 21002, 21025, 21278, 21255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8003, 21002, 21025, 21278, 21255, 21003, 21026, 21279, 21256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8004, 21003, 21026, 21279, 21256, 21004, 21027, 21280, 21257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8005, 21004, 21027, 21280, 21257, 21005, 21028, 21281, 21258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8006, 21005, 21028, 21281, 21258, 21006, 21029, 21282, 21259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8007, 21006, 21029, 21282, 21259, 21007, 21030, 21283, 21260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8008, 21007, 21030, 21283, 21260, 21008, 21031, 21284, 21261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8009, 21008, 21031, 21284, 21261, 21009, 21032, 21285, 21262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8010, 21009, 21032, 21285, 21262, 21010, 21033, 21286, 21263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8011, 21010, 21033, 21286, 21263, 21011, 21034, 21287, 21264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8012, 21011, 21034, 21287, 21264, 21012, 21035, 21288, 21265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8013, 21012, 21035, 21288, 21265, 21013, 21036, 21289, 21266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8014, 21013, 21036, 21289, 21266, 21014, 21037, 21290, 21267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8015, 21014, 21037, 21290, 21267, 21015, 21038, 21291, 21268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8016, 21015, 21038, 21291, 21268, 21016, 21039, 21292, 21269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8017, 21016, 21039, 21292, 21269, 21017, 21040, 21293, 21270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8018, 21017, 21040, 21293, 21270, 21018, 21041, 21294, 21271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8019, 21018, 21041, 21294, 21271, 21019, 21042, 21295, 21272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8020, 21019, 21042, 21295, 21272, 21020, 21043, 21296, 21273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8021, 21020, 21043, 21296, 21273, 21021, 21044, 21297, 21274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8022, 21021, 21044, 21297, 21274, 21022, 21045, 21298, 21275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8023, 21022, 21045, 21298, 21275, 21023, 21046, 21299, 21276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8024, 21023, 21046, 21299, 21276, 21024, 21047, 21300, 21277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8025, 21024, 21047, 21300, 21277, 4911, 4912, 4923, 4922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8026, 3095, 3096, 3107, 3106, 21025, 21048, 21301, 21278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8027, 21025, 21048, 21301, 21278, 21026, 21049, 21302, 21279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8028, 21026, 21049, 21302, 21279, 21027, 21050, 21303, 21280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8029, 21027, 21050, 21303, 21280, 21028, 21051, 21304, 21281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8030, 21028, 21051, 21304, 21281, 21029, 21052, 21305, 21282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8031, 21029, 21052, 21305, 21282, 21030, 21053, 21306, 21283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8032, 21030, 21053, 21306, 21283, 21031, 21054, 21307, 21284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8033, 21031, 21054, 21307, 21284, 21032, 21055, 21308, 21285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8034, 21032, 21055, 21308, 21285, 21033, 21056, 21309, 21286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8035, 21033, 21056, 21309, 21286, 21034, 21057, 21310, 21287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8036, 21034, 21057, 21310, 21287, 21035, 21058, 21311, 21288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8037, 21035, 21058, 21311, 21288, 21036, 21059, 21312, 21289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8038, 21036, 21059, 21312, 21289, 21037, 21060, 21313, 21290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8039, 21037, 21060, 21313, 21290, 21038, 21061, 21314, 21291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8040, 21038, 21061, 21314, 21291, 21039, 21062, 21315, 21292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8041, 21039, 21062, 21315, 21292, 21040, 21063, 21316, 21293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8042, 21040, 21063, 21316, 21293, 21041, 21064, 21317, 21294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8043, 21041, 21064, 21317, 21294, 21042, 21065, 21318, 21295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8044, 21042, 21065, 21318, 21295, 21043, 21066, 21319, 21296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8045, 21043, 21066, 21319, 21296, 21044, 21067, 21320, 21297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8046, 21044, 21067, 21320, 21297, 21045, 21068, 21321, 21298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8047, 21045, 21068, 21321, 21298, 21046, 21069, 21322, 21299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8048, 21046, 21069, 21322, 21299, 21047, 21070, 21323, 21300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8049, 21047, 21070, 21323, 21300, 4912, 4913, 4924, 4923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8050, 3096, 3097, 3108, 3107, 21048, 21071, 21324, 21301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8051, 21048, 21071, 21324, 21301, 21049, 21072, 21325, 21302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8052, 21049, 21072, 21325, 21302, 21050, 21073, 21326, 21303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8053, 21050, 21073, 21326, 21303, 21051, 21074, 21327, 21304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8054, 21051, 21074, 21327, 21304, 21052, 21075, 21328, 21305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8055, 21052, 21075, 21328, 21305, 21053, 21076, 21329, 21306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8056, 21053, 21076, 21329, 21306, 21054, 21077, 21330, 21307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8057, 21054, 21077, 21330, 21307, 21055, 21078, 21331, 21308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8058, 21055, 21078, 21331, 21308, 21056, 21079, 21332, 21309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8059, 21056, 21079, 21332, 21309, 21057, 21080, 21333, 21310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8060, 21057, 21080, 21333, 21310, 21058, 21081, 21334, 21311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8061, 21058, 21081, 21334, 21311, 21059, 21082, 21335, 21312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8062, 21059, 21082, 21335, 21312, 21060, 21083, 21336, 21313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8063, 21060, 21083, 21336, 21313, 21061, 21084, 21337, 21314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8064, 21061, 21084, 21337, 21314, 21062, 21085, 21338, 21315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8065, 21062, 21085, 21338, 21315, 21063, 21086, 21339, 21316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8066, 21063, 21086, 21339, 21316, 21064, 21087, 21340, 21317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8067, 21064, 21087, 21340, 21317, 21065, 21088, 21341, 21318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8068, 21065, 21088, 21341, 21318, 21066, 21089, 21342, 21319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8069, 21066, 21089, 21342, 21319, 21067, 21090, 21343, 21320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8070, 21067, 21090, 21343, 21320, 21068, 21091, 21344, 21321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8071, 21068, 21091, 21344, 21321, 21069, 21092, 21345, 21322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8072, 21069, 21092, 21345, 21322, 21070, 21093, 21346, 21323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8073, 21070, 21093, 21346, 21323, 4913, 4914, 4925, 4924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8074, 3097, 3098, 3109, 3108, 21071, 21094, 21347, 21324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8075, 21071, 21094, 21347, 21324, 21072, 21095, 21348, 21325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8076, 21072, 21095, 21348, 21325, 21073, 21096, 21349, 21326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8077, 21073, 21096, 21349, 21326, 21074, 21097, 21350, 21327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8078, 21074, 21097, 21350, 21327, 21075, 21098, 21351, 21328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8079, 21075, 21098, 21351, 21328, 21076, 21099, 21352, 21329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8080, 21076, 21099, 21352, 21329, 21077, 21100, 21353, 21330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8081, 21077, 21100, 21353, 21330, 21078, 21101, 21354, 21331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8082, 21078, 21101, 21354, 21331, 21079, 21102, 21355, 21332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8083, 21079, 21102, 21355, 21332, 21080, 21103, 21356, 21333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8084, 21080, 21103, 21356, 21333, 21081, 21104, 21357, 21334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8085, 21081, 21104, 21357, 21334, 21082, 21105, 21358, 21335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8086, 21082, 21105, 21358, 21335, 21083, 21106, 21359, 21336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8087, 21083, 21106, 21359, 21336, 21084, 21107, 21360, 21337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8088, 21084, 21107, 21360, 21337, 21085, 21108, 21361, 21338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8089, 21085, 21108, 21361, 21338, 21086, 21109, 21362, 21339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8090, 21086, 21109, 21362, 21339, 21087, 21110, 21363, 21340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8091, 21087, 21110, 21363, 21340, 21088, 21111, 21364, 21341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8092, 21088, 21111, 21364, 21341, 21089, 21112, 21365, 21342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8093, 21089, 21112, 21365, 21342, 21090, 21113, 21366, 21343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8094, 21090, 21113, 21366, 21343, 21091, 21114, 21367, 21344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8095, 21091, 21114, 21367, 21344, 21092, 21115, 21368, 21345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8096, 21092, 21115, 21368, 21345, 21093, 21116, 21369, 21346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8097, 21093, 21116, 21369, 21346, 4914, 4915, 4926, 4925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8098, 3098, 3099, 3110, 3109, 21094, 21117, 21370, 21347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8099, 21094, 21117, 21370, 21347, 21095, 21118, 21371, 21348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8100, 21095, 21118, 21371, 21348, 21096, 21119, 21372, 21349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8101, 21096, 21119, 21372, 21349, 21097, 21120, 21373, 21350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8102, 21097, 21120, 21373, 21350, 21098, 21121, 21374, 21351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8103, 21098, 21121, 21374, 21351, 21099, 21122, 21375, 21352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8104, 21099, 21122, 21375, 21352, 21100, 21123, 21376, 21353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8105, 21100, 21123, 21376, 21353, 21101, 21124, 21377, 21354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8106, 21101, 21124, 21377, 21354, 21102, 21125, 21378, 21355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8107, 21102, 21125, 21378, 21355, 21103, 21126, 21379, 21356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8108, 21103, 21126, 21379, 21356, 21104, 21127, 21380, 21357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8109, 21104, 21127, 21380, 21357, 21105, 21128, 21381, 21358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8110, 21105, 21128, 21381, 21358, 21106, 21129, 21382, 21359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8111, 21106, 21129, 21382, 21359, 21107, 21130, 21383, 21360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8112, 21107, 21130, 21383, 21360, 21108, 21131, 21384, 21361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8113, 21108, 21131, 21384, 21361, 21109, 21132, 21385, 21362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8114, 21109, 21132, 21385, 21362, 21110, 21133, 21386, 21363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8115, 21110, 21133, 21386, 21363, 21111, 21134, 21387, 21364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8116, 21111, 21134, 21387, 21364, 21112, 21135, 21388, 21365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8117, 21112, 21135, 21388, 21365, 21113, 21136, 21389, 21366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8118, 21113, 21136, 21389, 21366, 21114, 21137, 21390, 21367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8119, 21114, 21137, 21390, 21367, 21115, 21138, 21391, 21368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8120, 21115, 21138, 21391, 21368, 21116, 21139, 21392, 21369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8121, 21116, 21139, 21392, 21369, 4915, 4916, 4927, 4926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8122, 3099, 3100, 3111, 3110, 21117, 21140, 21393, 21370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8123, 21117, 21140, 21393, 21370, 21118, 21141, 21394, 21371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8124, 21118, 21141, 21394, 21371, 21119, 21142, 21395, 21372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8125, 21119, 21142, 21395, 21372, 21120, 21143, 21396, 21373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8126, 21120, 21143, 21396, 21373, 21121, 21144, 21397, 21374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8127, 21121, 21144, 21397, 21374, 21122, 21145, 21398, 21375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8128, 21122, 21145, 21398, 21375, 21123, 21146, 21399, 21376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8129, 21123, 21146, 21399, 21376, 21124, 21147, 21400, 21377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8130, 21124, 21147, 21400, 21377, 21125, 21148, 21401, 21378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8131, 21125, 21148, 21401, 21378, 21126, 21149, 21402, 21379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8132, 21126, 21149, 21402, 21379, 21127, 21150, 21403, 21380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8133, 21127, 21150, 21403, 21380, 21128, 21151, 21404, 21381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8134, 21128, 21151, 21404, 21381, 21129, 21152, 21405, 21382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8135, 21129, 21152, 21405, 21382, 21130, 21153, 21406, 21383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8136, 21130, 21153, 21406, 21383, 21131, 21154, 21407, 21384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8137, 21131, 21154, 21407, 21384, 21132, 21155, 21408, 21385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8138, 21132, 21155, 21408, 21385, 21133, 21156, 21409, 21386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8139, 21133, 21156, 21409, 21386, 21134, 21157, 21410, 21387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8140, 21134, 21157, 21410, 21387, 21135, 21158, 21411, 21388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8141, 21135, 21158, 21411, 21388, 21136, 21159, 21412, 21389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8142, 21136, 21159, 21412, 21389, 21137, 21160, 21413, 21390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8143, 21137, 21160, 21413, 21390, 21138, 21161, 21414, 21391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8144, 21138, 21161, 21414, 21391, 21139, 21162, 21415, 21392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8145, 21139, 21162, 21415, 21392, 4916, 4917, 4928, 4927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8146, 3100, 3101, 3112, 3111, 21140, 21163, 21416, 21393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8147, 21140, 21163, 21416, 21393, 21141, 21164, 21417, 21394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8148, 21141, 21164, 21417, 21394, 21142, 21165, 21418, 21395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8149, 21142, 21165, 21418, 21395, 21143, 21166, 21419, 21396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8150, 21143, 21166, 21419, 21396, 21144, 21167, 21420, 21397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8151, 21144, 21167, 21420, 21397, 21145, 21168, 21421, 21398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8152, 21145, 21168, 21421, 21398, 21146, 21169, 21422, 21399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8153, 21146, 21169, 21422, 21399, 21147, 21170, 21423, 21400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8154, 21147, 21170, 21423, 21400, 21148, 21171, 21424, 21401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8155, 21148, 21171, 21424, 21401, 21149, 21172, 21425, 21402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8156, 21149, 21172, 21425, 21402, 21150, 21173, 21426, 21403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8157, 21150, 21173, 21426, 21403, 21151, 21174, 21427, 21404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8158, 21151, 21174, 21427, 21404, 21152, 21175, 21428, 21405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8159, 21152, 21175, 21428, 21405, 21153, 21176, 21429, 21406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8160, 21153, 21176, 21429, 21406, 21154, 21177, 21430, 21407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8161, 21154, 21177, 21430, 21407, 21155, 21178, 21431, 21408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8162, 21155, 21178, 21431, 21408, 21156, 21179, 21432, 21409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8163, 21156, 21179, 21432, 21409, 21157, 21180, 21433, 21410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8164, 21157, 21180, 21433, 21410, 21158, 21181, 21434, 21411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8165, 21158, 21181, 21434, 21411, 21159, 21182, 21435, 21412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8166, 21159, 21182, 21435, 21412, 21160, 21183, 21436, 21413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8167, 21160, 21183, 21436, 21413, 21161, 21184, 21437, 21414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8168, 21161, 21184, 21437, 21414, 21162, 21185, 21438, 21415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8169, 21162, 21185, 21438, 21415, 4917, 4918, 4929, 4928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8170, 3101, 3102, 3113, 3112, 21163, 21186, 21439, 21416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8171, 21163, 21186, 21439, 21416, 21164, 21187, 21440, 21417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8172, 21164, 21187, 21440, 21417, 21165, 21188, 21441, 21418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8173, 21165, 21188, 21441, 21418, 21166, 21189, 21442, 21419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8174, 21166, 21189, 21442, 21419, 21167, 21190, 21443, 21420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8175, 21167, 21190, 21443, 21420, 21168, 21191, 21444, 21421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8176, 21168, 21191, 21444, 21421, 21169, 21192, 21445, 21422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8177, 21169, 21192, 21445, 21422, 21170, 21193, 21446, 21423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8178, 21170, 21193, 21446, 21423, 21171, 21194, 21447, 21424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8179, 21171, 21194, 21447, 21424, 21172, 21195, 21448, 21425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8180, 21172, 21195, 21448, 21425, 21173, 21196, 21449, 21426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8181, 21173, 21196, 21449, 21426, 21174, 21197, 21450, 21427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8182, 21174, 21197, 21450, 21427, 21175, 21198, 21451, 21428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8183, 21175, 21198, 21451, 21428, 21176, 21199, 21452, 21429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8184, 21176, 21199, 21452, 21429, 21177, 21200, 21453, 21430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8185, 21177, 21200, 21453, 21430, 21178, 21201, 21454, 21431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8186, 21178, 21201, 21454, 21431, 21179, 21202, 21455, 21432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8187, 21179, 21202, 21455, 21432, 21180, 21203, 21456, 21433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8188, 21180, 21203, 21456, 21433, 21181, 21204, 21457, 21434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8189, 21181, 21204, 21457, 21434, 21182, 21205, 21458, 21435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8190, 21182, 21205, 21458, 21435, 21183, 21206, 21459, 21436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8191, 21183, 21206, 21459, 21436, 21184, 21207, 21460, 21437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8192, 21184, 21207, 21460, 21437, 21185, 21208, 21461, 21438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8193, 21185, 21208, 21461, 21438, 4918, 4919, 4930, 4929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8194, 3102, 3103, 3114, 3113, 21186, 21209, 21462, 21439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8195, 21186, 21209, 21462, 21439, 21187, 21210, 21463, 21440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8196, 21187, 21210, 21463, 21440, 21188, 21211, 21464, 21441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8197, 21188, 21211, 21464, 21441, 21189, 21212, 21465, 21442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8198, 21189, 21212, 21465, 21442, 21190, 21213, 21466, 21443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8199, 21190, 21213, 21466, 21443, 21191, 21214, 21467, 21444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8200, 21191, 21214, 21467, 21444, 21192, 21215, 21468, 21445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8201, 21192, 21215, 21468, 21445, 21193, 21216, 21469, 21446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8202, 21193, 21216, 21469, 21446, 21194, 21217, 21470, 21447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8203, 21194, 21217, 21470, 21447, 21195, 21218, 21471, 21448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8204, 21195, 21218, 21471, 21448, 21196, 21219, 21472, 21449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8205, 21196, 21219, 21472, 21449, 21197, 21220, 21473, 21450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8206, 21197, 21220, 21473, 21450, 21198, 21221, 21474, 21451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8207, 21198, 21221, 21474, 21451, 21199, 21222, 21475, 21452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8208, 21199, 21222, 21475, 21452, 21200, 21223, 21476, 21453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8209, 21200, 21223, 21476, 21453, 21201, 21224, 21477, 21454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8210, 21201, 21224, 21477, 21454, 21202, 21225, 21478, 21455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8211, 21202, 21225, 21478, 21455, 21203, 21226, 21479, 21456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8212, 21203, 21226, 21479, 21456, 21204, 21227, 21480, 21457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8213, 21204, 21227, 21480, 21457, 21205, 21228, 21481, 21458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8214, 21205, 21228, 21481, 21458, 21206, 21229, 21482, 21459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8215, 21206, 21229, 21482, 21459, 21207, 21230, 21483, 21460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8216, 21207, 21230, 21483, 21460, 21208, 21231, 21484, 21461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8217, 21208, 21231, 21484, 21461, 4919, 4920, 4931, 4930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8218, 3103, 3104, 3115, 3114, 21209, 21232, 21485, 21462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8219, 21209, 21232, 21485, 21462, 21210, 21233, 21486, 21463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8220, 21210, 21233, 21486, 21463, 21211, 21234, 21487, 21464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8221, 21211, 21234, 21487, 21464, 21212, 21235, 21488, 21465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8222, 21212, 21235, 21488, 21465, 21213, 21236, 21489, 21466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8223, 21213, 21236, 21489, 21466, 21214, 21237, 21490, 21467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8224, 21214, 21237, 21490, 21467, 21215, 21238, 21491, 21468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8225, 21215, 21238, 21491, 21468, 21216, 21239, 21492, 21469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8226, 21216, 21239, 21492, 21469, 21217, 21240, 21493, 21470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8227, 21217, 21240, 21493, 21470, 21218, 21241, 21494, 21471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8228, 21218, 21241, 21494, 21471, 21219, 21242, 21495, 21472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8229, 21219, 21242, 21495, 21472, 21220, 21243, 21496, 21473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8230, 21220, 21243, 21496, 21473, 21221, 21244, 21497, 21474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8231, 21221, 21244, 21497, 21474, 21222, 21245, 21498, 21475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8232, 21222, 21245, 21498, 21475, 21223, 21246, 21499, 21476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8233, 21223, 21246, 21499, 21476, 21224, 21247, 21500, 21477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8234, 21224, 21247, 21500, 21477, 21225, 21248, 21501, 21478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8235, 21225, 21248, 21501, 21478, 21226, 21249, 21502, 21479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8236, 21226, 21249, 21502, 21479, 21227, 21250, 21503, 21480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8237, 21227, 21250, 21503, 21480, 21228, 21251, 21504, 21481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8238, 21228, 21251, 21504, 21481, 21229, 21252, 21505, 21482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
8239, 21229, 21252, 21505, 21482, 21230, 21253, 21506, 21483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
