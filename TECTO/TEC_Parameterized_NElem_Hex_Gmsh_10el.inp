3343, 0.083333333333333, 1.05, 0
3344, 0.083333333333333, 1.1, 0
3345, 0.083333333333333, 1.15, 0
3346, 0.083333333333333, 1.2, 0
3347, 0.083333333333333, 1.25, 0
3348, 0.083333333333333, 1.3, 0
3349, 0.125, 0.2, 0
3350, 0.125, 0.25, 0
3351, 0.125, 0.3, 0
3352, 0.125, 0.35, 0
3353, 0.125, 0.4, 0
3354, 0.125, 0.45, 0
3355, 0.125, 0.5, 0
3356, 0.125, 0.55, 0
3357, 0.125, 0.6, 0
3358, 0.125, 0.65, 0
3359, 0.125, 0.7, 0
3360, 0.125, 0.75, 0
3361, 0.125, 0.8, 0
3362, 0.125, 0.85, 0
3363, 0.125, 0.9, 0
3364, 0.125, 0.95, 0
3365, 0.125, 1, 0
3366, 0.125, 1.05, 0
3367, 0.125, 1.1, 0
3368, 0.125, 1.15, 0
3369, 0.125, 1.2, 0
3370, 0.125, 1.25, 0
3371, 0.125, 1.3, 0
3372, 0.16666666666667, 0.2, 0
3373, 0.16666666666667, 0.25, 0
3374, 0.16666666666667, 0.3, 0
3375, 0.16666666666667, 0.35, 0
3376, 0.16666666666667, 0.4, 0
3377, 0.16666666666667, 0.45, 0
3378, 0.16666666666667, 0.5, 0
3379, 0.16666666666667, 0.55, 0
3380, 0.16666666666667, 0.6, 0
3381, 0.16666666666667, 0.65, 0
3382, 0.16666666666667, 0.7, 0
3383, 0.16666666666667, 0.75, 0
3384, 0.16666666666667, 0.8, 0
3385, 0.16666666666667, 0.85, 0
3386, 0.16666666666667, 0.9, 0
3387, 0.16666666666667, 0.95, 0
3388, 0.16666666666667, 1, 0
3389, 0.16666666666667, 1.05, 0
3390, 0.16666666666667, 1.1, 0
3391, 0.16666666666667, 1.15, 0
3392, 0.16666666666667, 1.2, 0
3393, 0.16666666666667, 1.25, 0
3394, 0.16666666666667, 1.3, 0
3395, 0.20833333333333, 0.2, 0
3396, 0.20833333333333, 0.25, 0
3397, 0.20833333333333, 0.3, 0
3398, 0.20833333333333, 0.35, 0
3399, 0.20833333333333, 0.4, 0
3400, 0.20833333333333, 0.45, 0
3401, 0.20833333333333, 0.5, 0
3402, 0.20833333333333, 0.55, 0
3403, 0.20833333333333, 0.6, 0
3404, 0.20833333333333, 0.65, 0
3405, 0.20833333333333, 0.7, 0
3406, 0.20833333333333, 0.75, 0
3407, 0.20833333333333, 0.8, 0
3408, 0.20833333333333, 0.85, 0
3409, 0.20833333333333, 0.9, 0
3410, 0.20833333333333, 0.95, 0
3411, 0.20833333333333, 1, 0
3412, 0.20833333333333, 1.05, 0
3413, 0.20833333333333, 1.1, 0
3414, 0.20833333333333, 1.15, 0
3415, 0.20833333333333, 1.2, 0
3416, 0.20833333333333, 1.25, 0
3417, 0.20833333333333, 1.3, 0
3418, 0.25, 0.2, 0
3419, 0.25, 0.25, 0
3420, 0.25, 0.3, 0
3421, 0.25, 0.35, 0
3422, 0.25, 0.4, 0
3423, 0.25, 0.45, 0
3424, 0.25, 0.5, 0
3425, 0.25, 0.55, 0
3426, 0.25, 0.6, 0
3427, 0.25, 0.65, 0
3428, 0.25, 0.7, 0
3429, 0.25, 0.75, 0
3430, 0.25, 0.8, 0
3431, 0.25, 0.85, 0
3432, 0.25, 0.9, 0
3433, 0.25, 0.95, 0
3434, 0.25, 1, 0
3435, 0.25, 1.05, 0
3436, 0.25, 1.1, 0
3437, 0.25, 1.15, 0
3438, 0.25, 1.2, 0
3439, 0.25, 1.25, 0
3440, 0.25, 1.3, 0
3441, 0.29166666666667, 0.2, 0
3442, 0.29166666666667, 0.25, 0
3443, 0.29166666666667, 0.3, 0
3444, 0.29166666666667, 0.35, 0
3445, 0.29166666666667, 0.4, 0
3446, 0.29166666666667, 0.45, 0
3447, 0.29166666666667, 0.5, 0
3448, 0.29166666666667, 0.55, 0
3449, 0.29166666666667, 0.6, 0
3450, 0.29166666666667, 0.65, 0
3451, 0.29166666666667, 0.7, 0
3452, 0.29166666666667, 0.75, 0
3453, 0.29166666666667, 0.8, 0
3454, 0.29166666666667, 0.85, 0
3455, 0.29166666666667, 0.9, 0
3456, 0.29166666666667, 0.95, 0
3457, 0.29166666666667, 1, 0
3458, 0.29166666666667, 1.05, 0
3459, 0.29166666666667, 1.1, 0
3460, 0.29166666666667, 1.15, 0
3461, 0.29166666666667, 1.2, 0
3462, 0.29166666666667, 1.25, 0
3463, 0.29166666666667, 1.3, 0
3464, 0.33333333333333, 0.2, 0
3465, 0.33333333333333, 0.25, 0
3466, 0.33333333333333, 0.3, 0
3467, 0.33333333333333, 0.35, 0
3468, 0.33333333333333, 0.4, 0
3469, 0.33333333333333, 0.45, 0
3470, 0.33333333333333, 0.5, 0
3471, 0.33333333333333, 0.55, 0
3472, 0.33333333333333, 0.6, 0
3473, 0.33333333333333, 0.65, 0
3474, 0.33333333333333, 0.7, 0
3475, 0.33333333333333, 0.75, 0
3476, 0.33333333333333, 0.8, 0
3477, 0.33333333333333, 0.85, 0
3478, 0.33333333333333, 0.9, 0
3479, 0.33333333333333, 0.95, 0
3480, 0.33333333333333, 1, 0
3481, 0.33333333333333, 1.05, 0
3482, 0.33333333333333, 1.1, 0
3483, 0.33333333333333, 1.15, 0
3484, 0.33333333333333, 1.2, 0
3485, 0.33333333333333, 1.25, 0
3486, 0.33333333333333, 1.3, 0
3487, 0.375, 0.2, 0
3488, 0.375, 0.25, 0
3489, 0.375, 0.3, 0
3490, 0.375, 0.35, 0
3491, 0.375, 0.4, 0
3492, 0.375, 0.45, 0
3493, 0.375, 0.5, 0
3494, 0.375, 0.55, 0
3495, 0.375, 0.6, 0
3496, 0.375, 0.65, 0
3497, 0.375, 0.7, 0
3498, 0.375, 0.75, 0
3499, 0.375, 0.8, 0
3500, 0.375, 0.85, 0
3501, 0.375, 0.9, 0
3502, 0.375, 0.95, 0
3503, 0.375, 1, 0
3504, 0.375, 1.05, 0
3505, 0.375, 1.1, 0
3506, 0.375, 1.15, 0
3507, 0.375, 1.2, 0
3508, 0.375, 1.25, 0
3509, 0.375, 1.3, 0
3510, 0.41666666666667, 0.2, 0
3511, 0.41666666666667, 0.25, 0
3512, 0.41666666666667, 0.3, 0
3513, 0.41666666666667, 0.35, 0
3514, 0.41666666666667, 0.4, 0
3515, 0.41666666666667, 0.45, 0
3516, 0.41666666666667, 0.5, 0
3517, 0.41666666666667, 0.55, 0
3518, 0.41666666666667, 0.6, 0
3519, 0.41666666666667, 0.65, 0
3520, 0.41666666666667, 0.7, 0
3521, 0.41666666666667, 0.75, 0
3522, 0.41666666666667, 0.8, 0
3523, 0.41666666666667, 0.85, 0
3524, 0.41666666666667, 0.9, 0
3525, 0.41666666666667, 0.95, 0
3526, 0.41666666666667, 1, 0
3527, 0.41666666666667, 1.05, 0
3528, 0.41666666666667, 1.1, 0
3529, 0.41666666666667, 1.15, 0
3530, 0.41666666666667, 1.2, 0
3531, 0.41666666666667, 1.25, 0
3532, 0.41666666666667, 1.3, 0
3533, 0.45833333333333, 0.2, 0
3534, 0.45833333333333, 0.25, 0
3535, 0.45833333333333, 0.3, 0
3536, 0.45833333333333, 0.35, 0
3537, 0.45833333333333, 0.4, 0
3538, 0.45833333333333, 0.45, 0
3539, 0.45833333333333, 0.5, 0
3540, 0.45833333333333, 0.55, 0
3541, 0.45833333333333, 0.6, 0
3542, 0.45833333333333, 0.65, 0
3543, 0.45833333333333, 0.7, 0
3544, 0.45833333333333, 0.75, 0
3545, 0.45833333333333, 0.8, 0
3546, 0.45833333333333, 0.85, 0
3547, 0.45833333333333, 0.9, 0
3548, 0.45833333333333, 0.95, 0
3549, 0.45833333333333, 1, 0
3550, 0.45833333333333, 1.05, 0
3551, 0.45833333333333, 1.1, 0
3552, 0.45833333333333, 1.15, 0
3553, 0.45833333333333, 1.2, 0
3554, 0.45833333333333, 1.25, 0
3555, 0.45833333333333, 1.3, 0
3556, 0.5, 0.2, 0
3557, 0.5, 0.25, 0
3558, 0.5, 0.3, 0
3559, 0.5, 0.35, 0
3560, 0.5, 0.4, 0
3561, 0.5, 0.45, 0
3562, 0.5, 0.5, 0
3563, 0.5, 0.55, 0
3564, 0.5, 0.6, 0
3565, 0.5, 0.65, 0
3566, 0.5, 0.7, 0
3567, 0.5, 0.75, 0
3568, 0.5, 0.8, 0
3569, 0.5, 0.85, 0
3570, 0.5, 0.9, 0
3571, 0.5, 0.95, 0
3572, 0.5, 1, 0
3573, 0.5, 1.05, 0
3574, 0.5, 1.1, 0
3575, 0.5, 1.15, 0
3576, 0.5, 1.2, 0
3577, 0.5, 1.25, 0
3578, 0.5, 1.3, 0
3579, 0.54166666666667, 0.2, 0
3580, 0.54166666666667, 0.25, 0
3581, 0.54166666666667, 0.3, 0
3582, 0.54166666666667, 0.35, 0
3583, 0.54166666666667, 0.4, 0
3584, 0.54166666666667, 0.45, 0
3585, 0.54166666666667, 0.5, 0
3586, 0.54166666666667, 0.55, 0
3587, 0.54166666666667, 0.6, 0
3588, 0.54166666666667, 0.65, 0
3589, 0.54166666666667, 0.7, 0
3590, 0.54166666666667, 0.75, 0
3591, 0.54166666666667, 0.8, 0
3592, 0.54166666666667, 0.85, 0
3593, 0.54166666666667, 0.9, 0
3594, 0.54166666666667, 0.95, 0
3595, 0.54166666666667, 1, 0
3596, 0.54166666666667, 1.05, 0
3597, 0.54166666666667, 1.1, 0
3598, 0.54166666666667, 1.15, 0
3599, 0.54166666666667, 1.2, 0
3600, 0.54166666666667, 1.25, 0
3601, 0.54166666666667, 1.3, 0
3602, 0.58333333333333, 0.2, 0
3603, 0.58333333333333, 0.25, 0
3604, 0.58333333333333, 0.3, 0
3605, 0.58333333333333, 0.35, 0
3606, 0.58333333333333, 0.4, 0
3607, 0.58333333333333, 0.45, 0
3608, 0.58333333333333, 0.5, 0
3609, 0.58333333333333, 0.55, 0
3610, 0.58333333333333, 0.6, 0
3611, 0.58333333333333, 0.65, 0
3612, 0.58333333333333, 0.7, 0
3613, 0.58333333333333, 0.75, 0
3614, 0.58333333333333, 0.8, 0
3615, 0.58333333333333, 0.85, 0
3616, 0.58333333333333, 0.9, 0
3617, 0.58333333333333, 0.95, 0
3618, 0.58333333333333, 1, 0
3619, 0.58333333333333, 1.05, 0
3620, 0.58333333333333, 1.1, 0
3621, 0.58333333333333, 1.15, 0
3622, 0.58333333333333, 1.2, 0
3623, 0.58333333333333, 1.25, 0
3624, 0.58333333333333, 1.3, 0
3625, 0.625, 0.2, 0
3626, 0.625, 0.25, 0
3627, 0.625, 0.3, 0
3628, 0.625, 0.35, 0
3629, 0.625, 0.4, 0
3630, 0.625, 0.45, 0
3631, 0.625, 0.5, 0
3632, 0.625, 0.55, 0
3633, 0.625, 0.6, 0
3634, 0.625, 0.65, 0
3635, 0.625, 0.7, 0
3636, 0.625, 0.75, 0
3637, 0.625, 0.8, 0
3638, 0.625, 0.85, 0
3639, 0.625, 0.9, 0
3640, 0.625, 0.95, 0
3641, 0.625, 1, 0
3642, 0.625, 1.05, 0
3643, 0.625, 1.1, 0
3644, 0.625, 1.15, 0
3645, 0.625, 1.2, 0
3646, 0.625, 1.25, 0
3647, 0.625, 1.3, 0
3648, 0.66666666666667, 0.2, 0
3649, 0.66666666666667, 0.25, 0
3650, 0.66666666666667, 0.3, 0
3651, 0.66666666666667, 0.35, 0
3652, 0.66666666666667, 0.4, 0
3653, 0.66666666666667, 0.45, 0
3654, 0.66666666666667, 0.5, 0
3655, 0.66666666666667, 0.55, 0
3656, 0.66666666666667, 0.6, 0
3657, 0.66666666666667, 0.65, 0
3658, 0.66666666666667, 0.7, 0
3659, 0.66666666666667, 0.75, 0
3660, 0.66666666666667, 0.8, 0
3661, 0.66666666666667, 0.85, 0
3662, 0.66666666666667, 0.9, 0
3663, 0.66666666666667, 0.95, 0
3664, 0.66666666666667, 1, 0
3665, 0.66666666666667, 1.05, 0
3666, 0.66666666666667, 1.1, 0
3667, 0.66666666666667, 1.15, 0
3668, 0.66666666666667, 1.2, 0
3669, 0.66666666666667, 1.25, 0
3670, 0.66666666666667, 1.3, 0
3671, 0.70833333333333, 0.2, 0
3672, 0.70833333333333, 0.25, 0
3673, 0.70833333333333, 0.3, 0
3674, 0.70833333333333, 0.35, 0
3675, 0.70833333333333, 0.4, 0
3676, 0.70833333333333, 0.45, 0
3677, 0.70833333333333, 0.5, 0
3678, 0.70833333333333, 0.55, 0
3679, 0.70833333333333, 0.6, 0
3680, 0.70833333333333, 0.65, 0
3681, 0.70833333333333, 0.7, 0
3682, 0.70833333333333, 0.75, 0
3683, 0.70833333333333, 0.8, 0
3684, 0.70833333333333, 0.85, 0
3685, 0.70833333333333, 0.9, 0
3686, 0.70833333333333, 0.95, 0
3687, 0.70833333333333, 1, 0
3688, 0.70833333333333, 1.05, 0
3689, 0.70833333333333, 1.1, 0
3690, 0.70833333333333, 1.15, 0
3691, 0.70833333333333, 1.2, 0
3692, 0.70833333333333, 1.25, 0
3693, 0.70833333333333, 1.3, 0
3694, 0.75, 0.2, 0
3695, 0.75, 0.25, 0
3696, 0.75, 0.3, 0
3697, 0.75, 0.35, 0
3698, 0.75, 0.4, 0
3699, 0.75, 0.45, 0
3700, 0.75, 0.5, 0
3701, 0.75, 0.55, 0
3702, 0.75, 0.6, 0
3703, 0.75, 0.65, 0
3704, 0.75, 0.7, 0
3705, 0.75, 0.75, 0
3706, 0.75, 0.8, 0
3707, 0.75, 0.85, 0
3708, 0.75, 0.9, 0
3709, 0.75, 0.95, 0
3710, 0.75, 1, 0
3711, 0.75, 1.05, 0
3712, 0.75, 1.1, 0
3713, 0.75, 1.15, 0
3714, 0.75, 1.2, 0
3715, 0.75, 1.25, 0
3716, 0.75, 1.3, 0
3717, 0.79166666666667, 0.2, 0
3718, 0.79166666666667, 0.25, 0
3719, 0.79166666666667, 0.3, 0
3720, 0.79166666666667, 0.35, 0
3721, 0.79166666666667, 0.4, 0
3722, 0.79166666666667, 0.45, 0
3723, 0.79166666666667, 0.5, 0
3724, 0.79166666666667, 0.55, 0
3725, 0.79166666666667, 0.6, 0
3726, 0.79166666666667, 0.65, 0
3727, 0.79166666666667, 0.7, 0
3728, 0.79166666666667, 0.75, 0
3729, 0.79166666666667, 0.8, 0
3730, 0.79166666666667, 0.85, 0
3731, 0.79166666666667, 0.9, 0
3732, 0.79166666666667, 0.95, 0
3733, 0.79166666666667, 1, 0
3734, 0.79166666666667, 1.05, 0
3735, 0.79166666666667, 1.1, 0
3736, 0.79166666666667, 1.15, 0
3737, 0.79166666666667, 1.2, 0
3738, 0.79166666666667, 1.25, 0
3739, 0.79166666666667, 1.3, 0
3740, 0.83333333333333, 0.2, 0
3741, 0.83333333333333, 0.25, 0
3742, 0.83333333333333, 0.3, 0
3743, 0.83333333333333, 0.35, 0
3744, 0.83333333333333, 0.4, 0
3745, 0.83333333333333, 0.45, 0
3746, 0.83333333333333, 0.5, 0
3747, 0.83333333333333, 0.55, 0
3748, 0.83333333333333, 0.6, 0
3749, 0.83333333333333, 0.65, 0
3750, 0.83333333333333, 0.7, 0
3751, 0.83333333333333, 0.75, 0
3752, 0.83333333333333, 0.8, 0
3753, 0.83333333333333, 0.85, 0
3754, 0.83333333333333, 0.9, 0
3755, 0.83333333333333, 0.95, 0
3756, 0.83333333333333, 1, 0
3757, 0.83333333333333, 1.05, 0
3758, 0.83333333333333, 1.1, 0
3759, 0.83333333333333, 1.15, 0
3760, 0.83333333333333, 1.2, 0
3761, 0.83333333333333, 1.25, 0
3762, 0.83333333333333, 1.3, 0
3763, 0.875, 0.2, 0
3764, 0.875, 0.25, 0
3765, 0.875, 0.3, 0
3766, 0.875, 0.35, 0
3767, 0.875, 0.4, 0
3768, 0.875, 0.45, 0
3769, 0.875, 0.5, 0
3770, 0.875, 0.55, 0
3771, 0.875, 0.6, 0
3772, 0.875, 0.65, 0
3773, 0.875, 0.7, 0
3774, 0.875, 0.75, 0
3775, 0.875, 0.8, 0
3776, 0.875, 0.85, 0
3777, 0.875, 0.9, 0
3778, 0.875, 0.95, 0
3779, 0.875, 1, 0
3780, 0.875, 1.05, 0
3781, 0.875, 1.1, 0
3782, 0.875, 1.15, 0
3783, 0.875, 1.2, 0
3784, 0.875, 1.25, 0
3785, 0.875, 1.3, 0
3786, 0.91666666666667, 0.2, 0
3787, 0.91666666666667, 0.25, 0
3788, 0.91666666666667, 0.3, 0
3789, 0.91666666666667, 0.35, 0
3790, 0.91666666666667, 0.4, 0
3791, 0.91666666666667, 0.45, 0
3792, 0.91666666666667, 0.5, 0
3793, 0.91666666666667, 0.55, 0
3794, 0.91666666666667, 0.6, 0
3795, 0.91666666666667, 0.65, 0
3796, 0.91666666666667, 0.7, 0
3797, 0.91666666666667, 0.75, 0
3798, 0.91666666666667, 0.8, 0
3799, 0.91666666666667, 0.85, 0
3800, 0.91666666666667, 0.9, 0
3801, 0.91666666666667, 0.95, 0
3802, 0.91666666666667, 1, 0
3803, 0.91666666666667, 1.05, 0
3804, 0.91666666666667, 1.1, 0
3805, 0.91666666666667, 1.15, 0
3806, 0.91666666666667, 1.2, 0
3807, 0.91666666666667, 1.25, 0
3808, 0.91666666666667, 1.3, 0
3809, 0.95833333333333, 0.2, 0
3810, 0.95833333333333, 0.25, 0
3811, 0.95833333333333, 0.3, 0
3812, 0.95833333333333, 0.35, 0
3813, 0.95833333333333, 0.4, 0
3814, 0.95833333333333, 0.45, 0
3815, 0.95833333333333, 0.5, 0
3816, 0.95833333333333, 0.55, 0
3817, 0.95833333333333, 0.6, 0
3818, 0.95833333333333, 0.65, 0
3819, 0.95833333333333, 0.7, 0
3820, 0.95833333333333, 0.75, 0
3821, 0.95833333333333, 0.8, 0
3822, 0.95833333333333, 0.85, 0
3823, 0.95833333333333, 0.9, 0
3824, 0.95833333333333, 0.95, 0
3825, 0.95833333333333, 1, 0
3826, 0.95833333333333, 1.05, 0
3827, 0.95833333333333, 1.1, 0
3828, 0.95833333333333, 1.15, 0
3829, 0.95833333333333, 1.2, 0
3830, 0.95833333333333, 1.25, 0
3831, 0.95833333333333, 1.3, 0
3832, 1, 0.2, 0.041666666666667
3833, 1, 0.25, 0.041666666666667
3834, 1, 0.3, 0.041666666666667
3835, 1, 0.35, 0.041666666666667
3836, 1, 0.4, 0.041666666666667
3837, 1, 0.45, 0.041666666666667
3838, 1, 0.5, 0.041666666666667
3839, 1, 0.55, 0.041666666666667
3840, 1, 0.6, 0.041666666666667
3841, 1, 0.65, 0.041666666666667
3842, 1, 0.7, 0.041666666666667
3843, 1, 0.75, 0.041666666666667
3844, 1, 0.8, 0.041666666666667
3845, 1, 0.85, 0.041666666666667
3846, 1, 0.9, 0.041666666666667
3847, 1, 0.95, 0.041666666666667
3848, 1, 1, 0.041666666666667
3849, 1, 1.05, 0.041666666666667
3850, 1, 1.1, 0.041666666666667
3851, 1, 1.15, 0.041666666666667
3852, 1, 1.2, 0.041666666666667
3853, 1, 1.25, 0.041666666666667
3854, 1, 1.3, 0.041666666666667
3855, 1, 0.2, 0.083333333333333
3856, 1, 0.25, 0.083333333333333
3857, 1, 0.3, 0.083333333333333
3858, 1, 0.35, 0.083333333333333
3859, 1, 0.4, 0.083333333333333
3860, 1, 0.45, 0.083333333333333
3861, 1, 0.5, 0.083333333333333
3862, 1, 0.55, 0.083333333333333
3863, 1, 0.6, 0.083333333333333
3864, 1, 0.65, 0.083333333333333
3865, 1, 0.7, 0.083333333333333
3866, 1, 0.75, 0.083333333333333
3867, 1, 0.8, 0.083333333333333
3868, 1, 0.85, 0.083333333333333
3869, 1, 0.9, 0.083333333333333
3870, 1, 0.95, 0.083333333333333
3871, 1, 1, 0.083333333333333
3872, 1, 1.05, 0.083333333333333
3873, 1, 1.1, 0.083333333333333
3874, 1, 1.15, 0.083333333333333
3875, 1, 1.2, 0.083333333333333
3876, 1, 1.25, 0.083333333333333
3877, 1, 1.3, 0.083333333333333
3878, 1, 0.2, 0.125
3879, 1, 0.25, 0.125
3880, 1, 0.3, 0.125
3881, 1, 0.35, 0.125
3882, 1, 0.4, 0.125
3883, 1, 0.45, 0.125
3884, 1, 0.5, 0.125
3885, 1, 0.55, 0.125
3886, 1, 0.6, 0.125
3887, 1, 0.65, 0.125
3888, 1, 0.7, 0.125
3889, 1, 0.75, 0.125
3890, 1, 0.8, 0.125
3891, 1, 0.85, 0.125
3892, 1, 0.9, 0.125
3893, 1, 0.95, 0.125
3894, 1, 1, 0.125
3895, 1, 1.05, 0.125
3896, 1, 1.1, 0.125
3897, 1, 1.15, 0.125
3898, 1, 1.2, 0.125
3899, 1, 1.25, 0.125
3900, 1, 1.3, 0.125
3901, 1, 0.2, 0.16666666666667
3902, 1, 0.25, 0.16666666666667
3903, 1, 0.3, 0.16666666666667
3904, 1, 0.35, 0.16666666666667
3905, 1, 0.4, 0.16666666666667
3906, 1, 0.45, 0.16666666666667
3907, 1, 0.5, 0.16666666666667
3908, 1, 0.55, 0.16666666666667
3909, 1, 0.6, 0.16666666666667
3910, 1, 0.65, 0.16666666666667
3911, 1, 0.7, 0.16666666666667
3912, 1, 0.75, 0.16666666666667
3913, 1, 0.8, 0.16666666666667
3914, 1, 0.85, 0.16666666666667
3915, 1, 0.9, 0.16666666666667
3916, 1, 0.95, 0.16666666666667
3917, 1, 1, 0.16666666666667
3918, 1, 1.05, 0.16666666666667
3919, 1, 1.1, 0.16666666666667
3920, 1, 1.15, 0.16666666666667
3921, 1, 1.2, 0.16666666666667
3922, 1, 1.25, 0.16666666666667
3923, 1, 1.3, 0.16666666666667
3924, 1, 0.2, 0.20833333333333
3925, 1, 0.25, 0.20833333333333
3926, 1, 0.3, 0.20833333333333
3927, 1, 0.35, 0.20833333333333
3928, 1, 0.4, 0.20833333333333
3929, 1, 0.45, 0.20833333333333
3930, 1, 0.5, 0.20833333333333
3931, 1, 0.55, 0.20833333333333
3932, 1, 0.6, 0.20833333333333
3933, 1, 0.65, 0.20833333333333
3934, 1, 0.7, 0.20833333333333
3935, 1, 0.75, 0.20833333333333
3936, 1, 0.8, 0.20833333333333
3937, 1, 0.85, 0.20833333333333
3938, 1, 0.9, 0.20833333333333
3939, 1, 0.95, 0.20833333333333
3940, 1, 1, 0.20833333333333
3941, 1, 1.05, 0.20833333333333
3942, 1, 1.1, 0.20833333333333
3943, 1, 1.15, 0.20833333333333
3944, 1, 1.2, 0.20833333333333
3945, 1, 1.25, 0.20833333333333
3946, 1, 1.3, 0.20833333333333
3947, 1, 0.2, 0.25
3948, 1, 0.25, 0.25
3949, 1, 0.3, 0.25
3950, 1, 0.35, 0.25
3951, 1, 0.4, 0.25
3952, 1, 0.45, 0.25
3953, 1, 0.5, 0.25
3954, 1, 0.55, 0.25
3955, 1, 0.6, 0.25
3956, 1, 0.65, 0.25
3957, 1, 0.7, 0.25
3958, 1, 0.75, 0.25
3959, 1, 0.8, 0.25
3960, 1, 0.85, 0.25
3961, 1, 0.9, 0.25
3962, 1, 0.95, 0.25
3963, 1, 1, 0.25
3964, 1, 1.05, 0.25
3965, 1, 1.1, 0.25
3966, 1, 1.15, 0.25
3967, 1, 1.2, 0.25
3968, 1, 1.25, 0.25
3969, 1, 1.3, 0.25
3970, 1, 0.2, 0.29166666666667
3971, 1, 0.25, 0.29166666666667
3972, 1, 0.3, 0.29166666666667
3973, 1, 0.35, 0.29166666666667
3974, 1, 0.4, 0.29166666666667
3975, 1, 0.45, 0.29166666666667
3976, 1, 0.5, 0.29166666666667
3977, 1, 0.55, 0.29166666666667
3978, 1, 0.6, 0.29166666666667
3979, 1, 0.65, 0.29166666666667
3980, 1, 0.7, 0.29166666666667
3981, 1, 0.75, 0.29166666666667
3982, 1, 0.8, 0.29166666666667
3983, 1, 0.85, 0.29166666666667
3984, 1, 0.9, 0.29166666666667
3985, 1, 0.95, 0.29166666666667
3986, 1, 1, 0.29166666666667
3987, 1, 1.05, 0.29166666666667
3988, 1, 1.1, 0.29166666666667
3989, 1, 1.15, 0.29166666666667
3990, 1, 1.2, 0.29166666666667
3991, 1, 1.25, 0.29166666666667
3992, 1, 1.3, 0.29166666666667
3993, 1, 0.2, 0.33333333333333
3994, 1, 0.25, 0.33333333333333
3995, 1, 0.3, 0.33333333333333
3996, 1, 0.35, 0.33333333333333
3997, 1, 0.4, 0.33333333333333
3998, 1, 0.45, 0.33333333333333
3999, 1, 0.5, 0.33333333333333
4000, 1, 0.55, 0.33333333333333
4001, 1, 0.6, 0.33333333333333
4002, 1, 0.65, 0.33333333333333
4003, 1, 0.7, 0.33333333333333
4004, 1, 0.75, 0.33333333333333
4005, 1, 0.8, 0.33333333333333
4006, 1, 0.85, 0.33333333333333
4007, 1, 0.9, 0.33333333333333
4008, 1, 0.95, 0.33333333333333
4009, 1, 1, 0.33333333333333
4010, 1, 1.05, 0.33333333333333
4011, 1, 1.1, 0.33333333333333
4012, 1, 1.15, 0.33333333333333
4013, 1, 1.2, 0.33333333333333
4014, 1, 1.25, 0.33333333333333
4015, 1, 1.3, 0.33333333333333
4016, 1, 0.2, 0.375
4017, 1, 0.25, 0.375
4018, 1, 0.3, 0.375
4019, 1, 0.35, 0.375
4020, 1, 0.4, 0.375
4021, 1, 0.45, 0.375
4022, 1, 0.5, 0.375
4023, 1, 0.55, 0.375
4024, 1, 0.6, 0.375
4025, 1, 0.65, 0.375
4026, 1, 0.7, 0.375
4027, 1, 0.75, 0.375
4028, 1, 0.8, 0.375
4029, 1, 0.85, 0.375
4030, 1, 0.9, 0.375
4031, 1, 0.95, 0.375
4032, 1, 1, 0.375
4033, 1, 1.05, 0.375
4034, 1, 1.1, 0.375
4035, 1, 1.15, 0.375
4036, 1, 1.2, 0.375
4037, 1, 1.25, 0.375
4038, 1, 1.3, 0.375
4039, 1, 0.2, 0.41666666666667
4040, 1, 0.25, 0.41666666666667
4041, 1, 0.3, 0.41666666666667
4042, 1, 0.35, 0.41666666666667
4043, 1, 0.4, 0.41666666666667
4044, 1, 0.45, 0.41666666666667
4045, 1, 0.5, 0.41666666666667
4046, 1, 0.55, 0.41666666666667
4047, 1, 0.6, 0.41666666666667
4048, 1, 0.65, 0.41666666666667
4049, 1, 0.7, 0.41666666666667
4050, 1, 0.75, 0.41666666666667
4051, 1, 0.8, 0.41666666666667
4052, 1, 0.85, 0.41666666666667
4053, 1, 0.9, 0.41666666666667
4054, 1, 0.95, 0.41666666666667
4055, 1, 1, 0.41666666666667
4056, 1, 1.05, 0.41666666666667
4057, 1, 1.1, 0.41666666666667
4058, 1, 1.15, 0.41666666666667
4059, 1, 1.2, 0.41666666666667
4060, 1, 1.25, 0.41666666666667
4061, 1, 1.3, 0.41666666666667
4062, 1, 0.2, 0.45833333333333
4063, 1, 0.25, 0.45833333333333
4064, 1, 0.3, 0.45833333333333
4065, 1, 0.35, 0.45833333333333
4066, 1, 0.4, 0.45833333333333
4067, 1, 0.45, 0.45833333333333
4068, 1, 0.5, 0.45833333333333
4069, 1, 0.55, 0.45833333333333
4070, 1, 0.6, 0.45833333333333
4071, 1, 0.65, 0.45833333333333
4072, 1, 0.7, 0.45833333333333
4073, 1, 0.75, 0.45833333333333
4074, 1, 0.8, 0.45833333333333
4075, 1, 0.85, 0.45833333333333
4076, 1, 0.9, 0.45833333333333
4077, 1, 0.95, 0.45833333333333
4078, 1, 1, 0.45833333333333
4079, 1, 1.05, 0.45833333333333
4080, 1, 1.1, 0.45833333333333
4081, 1, 1.15, 0.45833333333333
4082, 1, 1.2, 0.45833333333333
4083, 1, 1.25, 0.45833333333333
4084, 1, 1.3, 0.45833333333333
4085, 0.041666666666667, 0.2, 0.5
4086, 0.041666666666667, 0.25, 0.5
4087, 0.041666666666667, 0.3, 0.5
4088, 0.041666666666667, 0.35, 0.5
4089, 0.041666666666667, 0.4, 0.5
4090, 0.041666666666667, 0.45, 0.5
4091, 0.041666666666667, 0.5, 0.5
4092, 0.041666666666667, 0.55, 0.5
4093, 0.041666666666667, 0.6, 0.5
4094, 0.041666666666667, 0.65, 0.5
4095, 0.041666666666667, 0.7, 0.5
4096, 0.041666666666667, 0.75, 0.5
4097, 0.041666666666667, 0.8, 0.5
4098, 0.041666666666667, 0.85, 0.5
4099, 0.041666666666667, 0.9, 0.5
4100, 0.041666666666667, 0.95, 0.5
4101, 0.041666666666667, 1, 0.5
4102, 0.041666666666667, 1.05, 0.5
4103, 0.041666666666667, 1.1, 0.5
4104, 0.041666666666667, 1.15, 0.5
4105, 0.041666666666667, 1.2, 0.5
4106, 0.041666666666667, 1.25, 0.5
4107, 0.041666666666667, 1.3, 0.5
4108, 0.083333333333333, 0.2, 0.5
4109, 0.083333333333333, 0.25, 0.5
4110, 0.083333333333333, 0.3, 0.5
4111, 0.083333333333333, 0.35, 0.5
4112, 0.083333333333333, 0.4, 0.5
4113, 0.083333333333333, 0.45, 0.5
4114, 0.083333333333333, 0.5, 0.5
4115, 0.083333333333333, 0.55, 0.5
4116, 0.083333333333333, 0.6, 0.5
4117, 0.083333333333333, 0.65, 0.5
4118, 0.083333333333333, 0.7, 0.5
4119, 0.083333333333333, 0.75, 0.5
4120, 0.083333333333333, 0.8, 0.5
4121, 0.083333333333333, 0.85, 0.5
4122, 0.083333333333333, 0.9, 0.5
4123, 0.083333333333333, 0.95, 0.5
4124, 0.083333333333333, 1, 0.5
4125, 0.083333333333333, 1.05, 0.5
4126, 0.083333333333333, 1.1, 0.5
4127, 0.083333333333333, 1.15, 0.5
4128, 0.083333333333333, 1.2, 0.5
4129, 0.083333333333333, 1.25, 0.5
4130, 0.083333333333333, 1.3, 0.5
4131, 0.125, 0.2, 0.5
4132, 0.125, 0.25, 0.5
4133, 0.125, 0.3, 0.5
4134, 0.125, 0.35, 0.5
4135, 0.125, 0.4, 0.5
4136, 0.125, 0.45, 0.5
4137, 0.125, 0.5, 0.5
4138, 0.125, 0.55, 0.5
4139, 0.125, 0.6, 0.5
4140, 0.125, 0.65, 0.5
4141, 0.125, 0.7, 0.5
4142, 0.125, 0.75, 0.5
4143, 0.125, 0.8, 0.5
4144, 0.125, 0.85, 0.5
4145, 0.125, 0.9, 0.5
4146, 0.125, 0.95, 0.5
4147, 0.125, 1, 0.5
4148, 0.125, 1.05, 0.5
4149, 0.125, 1.1, 0.5
4150, 0.125, 1.15, 0.5
4151, 0.125, 1.2, 0.5
4152, 0.125, 1.25, 0.5
4153, 0.125, 1.3, 0.5
4154, 0.16666666666667, 0.2, 0.5
4155, 0.16666666666667, 0.25, 0.5
4156, 0.16666666666667, 0.3, 0.5
4157, 0.16666666666667, 0.35, 0.5
4158, 0.16666666666667, 0.4, 0.5
4159, 0.16666666666667, 0.45, 0.5
4160, 0.16666666666667, 0.5, 0.5
4161, 0.16666666666667, 0.55, 0.5
4162, 0.16666666666667, 0.6, 0.5
4163, 0.16666666666667, 0.65, 0.5
4164, 0.16666666666667, 0.7, 0.5
4165, 0.16666666666667, 0.75, 0.5
4166, 0.16666666666667, 0.8, 0.5
4167, 0.16666666666667, 0.85, 0.5
4168, 0.16666666666667, 0.9, 0.5
4169, 0.16666666666667, 0.95, 0.5
4170, 0.16666666666667, 1, 0.5
4171, 0.16666666666667, 1.05, 0.5
4172, 0.16666666666667, 1.1, 0.5
4173, 0.16666666666667, 1.15, 0.5
4174, 0.16666666666667, 1.2, 0.5
4175, 0.16666666666667, 1.25, 0.5
4176, 0.16666666666667, 1.3, 0.5
4177, 0.20833333333333, 0.2, 0.5
4178, 0.20833333333333, 0.25, 0.5
4179, 0.20833333333333, 0.3, 0.5
4180, 0.20833333333333, 0.35, 0.5
4181, 0.20833333333333, 0.4, 0.5
4182, 0.20833333333333, 0.45, 0.5
4183, 0.20833333333333, 0.5, 0.5
4184, 0.20833333333333, 0.55, 0.5
4185, 0.20833333333333, 0.6, 0.5
4186, 0.20833333333333, 0.65, 0.5
4187, 0.20833333333333, 0.7, 0.5
4188, 0.20833333333333, 0.75, 0.5
4189, 0.20833333333333, 0.8, 0.5
4190, 0.20833333333333, 0.85, 0.5
4191, 0.20833333333333, 0.9, 0.5
4192, 0.20833333333333, 0.95, 0.5
4193, 0.20833333333333, 1, 0.5
4194, 0.20833333333333, 1.05, 0.5
4195, 0.20833333333333, 1.1, 0.5
4196, 0.20833333333333, 1.15, 0.5
4197, 0.20833333333333, 1.2, 0.5
4198, 0.20833333333333, 1.25, 0.5
4199, 0.20833333333333, 1.3, 0.5
4200, 0.25, 0.2, 0.5
4201, 0.25, 0.25, 0.5
4202, 0.25, 0.3, 0.5
4203, 0.25, 0.35, 0.5
4204, 0.25, 0.4, 0.5
4205, 0.25, 0.45, 0.5
4206, 0.25, 0.5, 0.5
4207, 0.25, 0.55, 0.5
4208, 0.25, 0.6, 0.5
4209, 0.25, 0.65, 0.5
4210, 0.25, 0.7, 0.5
4211, 0.25, 0.75, 0.5
4212, 0.25, 0.8, 0.5
4213, 0.25, 0.85, 0.5
4214, 0.25, 0.9, 0.5
4215, 0.25, 0.95, 0.5
4216, 0.25, 1, 0.5
4217, 0.25, 1.05, 0.5
4218, 0.25, 1.1, 0.5
4219, 0.25, 1.15, 0.5
4220, 0.25, 1.2, 0.5
4221, 0.25, 1.25, 0.5
4222, 0.25, 1.3, 0.5
4223, 0.29166666666667, 0.2, 0.5
4224, 0.29166666666667, 0.25, 0.5
4225, 0.29166666666667, 0.3, 0.5
4226, 0.29166666666667, 0.35, 0.5
4227, 0.29166666666667, 0.4, 0.5
4228, 0.29166666666667, 0.45, 0.5
4229, 0.29166666666667, 0.5, 0.5
4230, 0.29166666666667, 0.55, 0.5
4231, 0.29166666666667, 0.6, 0.5
4232, 0.29166666666667, 0.65, 0.5
4233, 0.29166666666667, 0.7, 0.5
4234, 0.29166666666667, 0.75, 0.5
4235, 0.29166666666667, 0.8, 0.5
4236, 0.29166666666667, 0.85, 0.5
4237, 0.29166666666667, 0.9, 0.5
4238, 0.29166666666667, 0.95, 0.5
4239, 0.29166666666667, 1, 0.5
4240, 0.29166666666667, 1.05, 0.5
4241, 0.29166666666667, 1.1, 0.5
4242, 0.29166666666667, 1.15, 0.5
4243, 0.29166666666667, 1.2, 0.5
4244, 0.29166666666667, 1.25, 0.5
4245, 0.29166666666667, 1.3, 0.5
4246, 0.33333333333333, 0.2, 0.5
4247, 0.33333333333333, 0.25, 0.5
4248, 0.33333333333333, 0.3, 0.5
4249, 0.33333333333333, 0.35, 0.5
4250, 0.33333333333333, 0.4, 0.5
4251, 0.33333333333333, 0.45, 0.5
4252, 0.33333333333333, 0.5, 0.5
4253, 0.33333333333333, 0.55, 0.5
4254, 0.33333333333333, 0.6, 0.5
4255, 0.33333333333333, 0.65, 0.5
4256, 0.33333333333333, 0.7, 0.5
4257, 0.33333333333333, 0.75, 0.5
4258, 0.33333333333333, 0.8, 0.5
4259, 0.33333333333333, 0.85, 0.5
4260, 0.33333333333333, 0.9, 0.5
4261, 0.33333333333333, 0.95, 0.5
4262, 0.33333333333333, 1, 0.5
4263, 0.33333333333333, 1.05, 0.5
4264, 0.33333333333333, 1.1, 0.5
4265, 0.33333333333333, 1.15, 0.5
4266, 0.33333333333333, 1.2, 0.5
4267, 0.33333333333333, 1.25, 0.5
4268, 0.33333333333333, 1.3, 0.5
4269, 0.375, 0.2, 0.5
4270, 0.375, 0.25, 0.5
4271, 0.375, 0.3, 0.5
4272, 0.375, 0.35, 0.5
4273, 0.375, 0.4, 0.5
4274, 0.375, 0.45, 0.5
4275, 0.375, 0.5, 0.5
4276, 0.375, 0.55, 0.5
4277, 0.375, 0.6, 0.5
4278, 0.375, 0.65, 0.5
4279, 0.375, 0.7, 0.5
4280, 0.375, 0.75, 0.5
4281, 0.375, 0.8, 0.5
4282, 0.375, 0.85, 0.5
4283, 0.375, 0.9, 0.5
4284, 0.375, 0.95, 0.5
4285, 0.375, 1, 0.5
4286, 0.375, 1.05, 0.5
4287, 0.375, 1.1, 0.5
4288, 0.375, 1.15, 0.5
4289, 0.375, 1.2, 0.5
4290, 0.375, 1.25, 0.5
4291, 0.375, 1.3, 0.5
4292, 0.41666666666667, 0.2, 0.5
4293, 0.41666666666667, 0.25, 0.5
4294, 0.41666666666667, 0.3, 0.5
4295, 0.41666666666667, 0.35, 0.5
4296, 0.41666666666667, 0.4, 0.5
4297, 0.41666666666667, 0.45, 0.5
4298, 0.41666666666667, 0.5, 0.5
4299, 0.41666666666667, 0.55, 0.5
4300, 0.41666666666667, 0.6, 0.5
4301, 0.41666666666667, 0.65, 0.5
4302, 0.41666666666667, 0.7, 0.5
4303, 0.41666666666667, 0.75, 0.5
4304, 0.41666666666667, 0.8, 0.5
4305, 0.41666666666667, 0.85, 0.5
4306, 0.41666666666667, 0.9, 0.5
4307, 0.41666666666667, 0.95, 0.5
4308, 0.41666666666667, 1, 0.5
4309, 0.41666666666667, 1.05, 0.5
4310, 0.41666666666667, 1.1, 0.5
4311, 0.41666666666667, 1.15, 0.5
4312, 0.41666666666667, 1.2, 0.5
4313, 0.41666666666667, 1.25, 0.5
4314, 0.41666666666667, 1.3, 0.5
4315, 0.45833333333333, 0.2, 0.5
4316, 0.45833333333333, 0.25, 0.5
4317, 0.45833333333333, 0.3, 0.5
4318, 0.45833333333333, 0.35, 0.5
4319, 0.45833333333333, 0.4, 0.5
4320, 0.45833333333333, 0.45, 0.5
4321, 0.45833333333333, 0.5, 0.5
4322, 0.45833333333333, 0.55, 0.5
4323, 0.45833333333333, 0.6, 0.5
4324, 0.45833333333333, 0.65, 0.5
4325, 0.45833333333333, 0.7, 0.5
4326, 0.45833333333333, 0.75, 0.5
4327, 0.45833333333333, 0.8, 0.5
4328, 0.45833333333333, 0.85, 0.5
4329, 0.45833333333333, 0.9, 0.5
4330, 0.45833333333333, 0.95, 0.5
4331, 0.45833333333333, 1, 0.5
4332, 0.45833333333333, 1.05, 0.5
4333, 0.45833333333333, 1.1, 0.5
4334, 0.45833333333333, 1.15, 0.5
4335, 0.45833333333333, 1.2, 0.5
4336, 0.45833333333333, 1.25, 0.5
4337, 0.45833333333333, 1.3, 0.5
4338, 0.5, 0.2, 0.5
4339, 0.5, 0.25, 0.5
4340, 0.5, 0.3, 0.5
4341, 0.5, 0.35, 0.5
4342, 0.5, 0.4, 0.5
4343, 0.5, 0.45, 0.5
4344, 0.5, 0.5, 0.5
4345, 0.5, 0.55, 0.5
4346, 0.5, 0.6, 0.5
4347, 0.5, 0.65, 0.5
4348, 0.5, 0.7, 0.5
4349, 0.5, 0.75, 0.5
4350, 0.5, 0.8, 0.5
4351, 0.5, 0.85, 0.5
4352, 0.5, 0.9, 0.5
4353, 0.5, 0.95, 0.5
4354, 0.5, 1, 0.5
4355, 0.5, 1.05, 0.5
4356, 0.5, 1.1, 0.5
4357, 0.5, 1.15, 0.5
4358, 0.5, 1.2, 0.5
4359, 0.5, 1.25, 0.5
4360, 0.5, 1.3, 0.5
4361, 0.54166666666667, 0.2, 0.5
4362, 0.54166666666667, 0.25, 0.5
4363, 0.54166666666667, 0.3, 0.5
4364, 0.54166666666667, 0.35, 0.5
4365, 0.54166666666667, 0.4, 0.5
4366, 0.54166666666667, 0.45, 0.5
4367, 0.54166666666667, 0.5, 0.5
4368, 0.54166666666667, 0.55, 0.5
4369, 0.54166666666667, 0.6, 0.5
4370, 0.54166666666667, 0.65, 0.5
4371, 0.54166666666667, 0.7, 0.5
4372, 0.54166666666667, 0.75, 0.5
4373, 0.54166666666667, 0.8, 0.5
4374, 0.54166666666667, 0.85, 0.5
4375, 0.54166666666667, 0.9, 0.5
4376, 0.54166666666667, 0.95, 0.5
4377, 0.54166666666667, 1, 0.5
4378, 0.54166666666667, 1.05, 0.5
4379, 0.54166666666667, 1.1, 0.5
4380, 0.54166666666667, 1.15, 0.5
4381, 0.54166666666667, 1.2, 0.5
4382, 0.54166666666667, 1.25, 0.5
4383, 0.54166666666667, 1.3, 0.5
4384, 0.58333333333333, 0.2, 0.5
4385, 0.58333333333333, 0.25, 0.5
4386, 0.58333333333333, 0.3, 0.5
4387, 0.58333333333333, 0.35, 0.5
4388, 0.58333333333333, 0.4, 0.5
4389, 0.58333333333333, 0.45, 0.5
4390, 0.58333333333333, 0.5, 0.5
4391, 0.58333333333333, 0.55, 0.5
4392, 0.58333333333333, 0.6, 0.5
4393, 0.58333333333333, 0.65, 0.5
4394, 0.58333333333333, 0.7, 0.5
4395, 0.58333333333333, 0.75, 0.5
4396, 0.58333333333333, 0.8, 0.5
4397, 0.58333333333333, 0.85, 0.5
4398, 0.58333333333333, 0.9, 0.5
4399, 0.58333333333333, 0.95, 0.5
4400, 0.58333333333333, 1, 0.5
4401, 0.58333333333333, 1.05, 0.5
4402, 0.58333333333333, 1.1, 0.5
4403, 0.58333333333333, 1.15, 0.5
4404, 0.58333333333333, 1.2, 0.5
4405, 0.58333333333333, 1.25, 0.5
4406, 0.58333333333333, 1.3, 0.5
4407, 0.625, 0.2, 0.5
4408, 0.625, 0.25, 0.5
4409, 0.625, 0.3, 0.5
4410, 0.625, 0.35, 0.5
4411, 0.625, 0.4, 0.5
4412, 0.625, 0.45, 0.5
4413, 0.625, 0.5, 0.5
4414, 0.625, 0.55, 0.5
4415, 0.625, 0.6, 0.5
4416, 0.625, 0.65, 0.5
4417, 0.625, 0.7, 0.5
4418, 0.625, 0.75, 0.5
4419, 0.625, 0.8, 0.5
4420, 0.625, 0.85, 0.5
4421, 0.625, 0.9, 0.5
4422, 0.625, 0.95, 0.5
4423, 0.625, 1, 0.5
4424, 0.625, 1.05, 0.5
4425, 0.625, 1.1, 0.5
4426, 0.625, 1.15, 0.5
4427, 0.625, 1.2, 0.5
4428, 0.625, 1.25, 0.5
4429, 0.625, 1.3, 0.5
4430, 0.66666666666667, 0.2, 0.5
4431, 0.66666666666667, 0.25, 0.5
4432, 0.66666666666667, 0.3, 0.5
4433, 0.66666666666667, 0.35, 0.5
4434, 0.66666666666667, 0.4, 0.5
4435, 0.66666666666667, 0.45, 0.5
4436, 0.66666666666667, 0.5, 0.5
4437, 0.66666666666667, 0.55, 0.5
4438, 0.66666666666667, 0.6, 0.5
4439, 0.66666666666667, 0.65, 0.5
4440, 0.66666666666667, 0.7, 0.5
4441, 0.66666666666667, 0.75, 0.5
4442, 0.66666666666667, 0.8, 0.5
4443, 0.66666666666667, 0.85, 0.5
4444, 0.66666666666667, 0.9, 0.5
4445, 0.66666666666667, 0.95, 0.5
4446, 0.66666666666667, 1, 0.5
4447, 0.66666666666667, 1.05, 0.5
4448, 0.66666666666667, 1.1, 0.5
4449, 0.66666666666667, 1.15, 0.5
4450, 0.66666666666667, 1.2, 0.5
4451, 0.66666666666667, 1.25, 0.5
4452, 0.66666666666667, 1.3, 0.5
4453, 0.70833333333333, 0.2, 0.5
4454, 0.70833333333333, 0.25, 0.5
4455, 0.70833333333333, 0.3, 0.5
4456, 0.70833333333333, 0.35, 0.5
4457, 0.70833333333333, 0.4, 0.5
4458, 0.70833333333333, 0.45, 0.5
4459, 0.70833333333333, 0.5, 0.5
4460, 0.70833333333333, 0.55, 0.5
4461, 0.70833333333333, 0.6, 0.5
4462, 0.70833333333333, 0.65, 0.5
4463, 0.70833333333333, 0.7, 0.5
4464, 0.70833333333333, 0.75, 0.5
4465, 0.70833333333333, 0.8, 0.5
4466, 0.70833333333333, 0.85, 0.5
4467, 0.70833333333333, 0.9, 0.5
4468, 0.70833333333333, 0.95, 0.5
4469, 0.70833333333333, 1, 0.5
4470, 0.70833333333333, 1.05, 0.5
4471, 0.70833333333333, 1.1, 0.5
4472, 0.70833333333333, 1.15, 0.5
4473, 0.70833333333333, 1.2, 0.5
4474, 0.70833333333333, 1.25, 0.5
4475, 0.70833333333333, 1.3, 0.5
4476, 0.75, 0.2, 0.5
4477, 0.75, 0.25, 0.5
4478, 0.75, 0.3, 0.5
4479, 0.75, 0.35, 0.5
4480, 0.75, 0.4, 0.5
4481, 0.75, 0.45, 0.5
4482, 0.75, 0.5, 0.5
4483, 0.75, 0.55, 0.5
4484, 0.75, 0.6, 0.5
4485, 0.75, 0.65, 0.5
4486, 0.75, 0.7, 0.5
4487, 0.75, 0.75, 0.5
4488, 0.75, 0.8, 0.5
4489, 0.75, 0.85, 0.5
4490, 0.75, 0.9, 0.5
4491, 0.75, 0.95, 0.5
4492, 0.75, 1, 0.5
4493, 0.75, 1.05, 0.5
4494, 0.75, 1.1, 0.5
4495, 0.75, 1.15, 0.5
4496, 0.75, 1.2, 0.5
4497, 0.75, 1.25, 0.5
4498, 0.75, 1.3, 0.5
4499, 0.79166666666667, 0.2, 0.5
4500, 0.79166666666667, 0.25, 0.5
4501, 0.79166666666667, 0.3, 0.5
4502, 0.79166666666667, 0.35, 0.5
4503, 0.79166666666667, 0.4, 0.5
4504, 0.79166666666667, 0.45, 0.5
4505, 0.79166666666667, 0.5, 0.5
4506, 0.79166666666667, 0.55, 0.5
4507, 0.79166666666667, 0.6, 0.5
4508, 0.79166666666667, 0.65, 0.5
4509, 0.79166666666667, 0.7, 0.5
4510, 0.79166666666667, 0.75, 0.5
4511, 0.79166666666667, 0.8, 0.5
4512, 0.79166666666667, 0.85, 0.5
4513, 0.79166666666667, 0.9, 0.5
4514, 0.79166666666667, 0.95, 0.5
4515, 0.79166666666667, 1, 0.5
4516, 0.79166666666667, 1.05, 0.5
4517, 0.79166666666667, 1.1, 0.5
4518, 0.79166666666667, 1.15, 0.5
4519, 0.79166666666667, 1.2, 0.5
4520, 0.79166666666667, 1.25, 0.5
4521, 0.79166666666667, 1.3, 0.5
4522, 0.83333333333333, 0.2, 0.5
4523, 0.83333333333333, 0.25, 0.5
4524, 0.83333333333333, 0.3, 0.5
4525, 0.83333333333333, 0.35, 0.5
4526, 0.83333333333333, 0.4, 0.5
4527, 0.83333333333333, 0.45, 0.5
4528, 0.83333333333333, 0.5, 0.5
4529, 0.83333333333333, 0.55, 0.5
4530, 0.83333333333333, 0.6, 0.5
4531, 0.83333333333333, 0.65, 0.5
4532, 0.83333333333333, 0.7, 0.5
4533, 0.83333333333333, 0.75, 0.5
4534, 0.83333333333333, 0.8, 0.5
4535, 0.83333333333333, 0.85, 0.5
4536, 0.83333333333333, 0.9, 0.5
4537, 0.83333333333333, 0.95, 0.5
4538, 0.83333333333333, 1, 0.5
4539, 0.83333333333333, 1.05, 0.5
4540, 0.83333333333333, 1.1, 0.5
4541, 0.83333333333333, 1.15, 0.5
4542, 0.83333333333333, 1.2, 0.5
4543, 0.83333333333333, 1.25, 0.5
4544, 0.83333333333333, 1.3, 0.5
4545, 0.875, 0.2, 0.5
4546, 0.875, 0.25, 0.5
4547, 0.875, 0.3, 0.5
4548, 0.875, 0.35, 0.5
4549, 0.875, 0.4, 0.5
4550, 0.875, 0.45, 0.5
4551, 0.875, 0.5, 0.5
4552, 0.875, 0.55, 0.5
4553, 0.875, 0.6, 0.5
4554, 0.875, 0.65, 0.5
4555, 0.875, 0.7, 0.5
4556, 0.875, 0.75, 0.5
4557, 0.875, 0.8, 0.5
4558, 0.875, 0.85, 0.5
4559, 0.875, 0.9, 0.5
4560, 0.875, 0.95, 0.5
4561, 0.875, 1, 0.5
4562, 0.875, 1.05, 0.5
4563, 0.875, 1.1, 0.5
4564, 0.875, 1.15, 0.5
4565, 0.875, 1.2, 0.5
4566, 0.875, 1.25, 0.5
4567, 0.875, 1.3, 0.5
4568, 0.91666666666667, 0.2, 0.5
4569, 0.91666666666667, 0.25, 0.5
4570, 0.91666666666667, 0.3, 0.5
4571, 0.91666666666667, 0.35, 0.5
4572, 0.91666666666667, 0.4, 0.5
4573, 0.91666666666667, 0.45, 0.5
4574, 0.91666666666667, 0.5, 0.5
4575, 0.91666666666667, 0.55, 0.5
4576, 0.91666666666667, 0.6, 0.5
4577, 0.91666666666667, 0.65, 0.5
4578, 0.91666666666667, 0.7, 0.5
4579, 0.91666666666667, 0.75, 0.5
4580, 0.91666666666667, 0.8, 0.5
4581, 0.91666666666667, 0.85, 0.5
4582, 0.91666666666667, 0.9, 0.5
4583, 0.91666666666667, 0.95, 0.5
4584, 0.91666666666667, 1, 0.5
4585, 0.91666666666667, 1.05, 0.5
4586, 0.91666666666667, 1.1, 0.5
4587, 0.91666666666667, 1.15, 0.5
4588, 0.91666666666667, 1.2, 0.5
4589, 0.91666666666667, 1.25, 0.5
4590, 0.91666666666667, 1.3, 0.5
4591, 0.95833333333333, 0.2, 0.5
4592, 0.95833333333333, 0.25, 0.5
4593, 0.95833333333333, 0.3, 0.5
4594, 0.95833333333333, 0.35, 0.5
4595, 0.95833333333333, 0.4, 0.5
4596, 0.95833333333333, 0.45, 0.5
4597, 0.95833333333333, 0.5, 0.5
4598, 0.95833333333333, 0.55, 0.5
4599, 0.95833333333333, 0.6, 0.5
4600, 0.95833333333333, 0.65, 0.5
4601, 0.95833333333333, 0.7, 0.5
4602, 0.95833333333333, 0.75, 0.5
4603, 0.95833333333333, 0.8, 0.5
4604, 0.95833333333333, 0.85, 0.5
4605, 0.95833333333333, 0.9, 0.5
4606, 0.95833333333333, 0.95, 0.5
4607, 0.95833333333333, 1, 0.5
4608, 0.95833333333333, 1.05, 0.5
4609, 0.95833333333333, 1.1, 0.5
4610, 0.95833333333333, 1.15, 0.5
4611, 0.95833333333333, 1.2, 0.5
4612, 0.95833333333333, 1.25, 0.5
4613, 0.95833333333333, 1.3, 0.5
4614, 0, 0.2, 0.041666666666667
4615, 0, 0.25, 0.041666666666667
4616, 0, 0.3, 0.041666666666667
4617, 0, 0.35, 0.041666666666667
4618, 0, 0.4, 0.041666666666667
4619, 0, 0.45, 0.041666666666667
4620, 0, 0.5, 0.041666666666667
4621, 0, 0.55, 0.041666666666667
4622, 0, 0.6, 0.041666666666667
4623, 0, 0.65, 0.041666666666667
4624, 0, 0.7, 0.041666666666667
4625, 0, 0.75, 0.041666666666667
4626, 0, 0.8, 0.041666666666667
4627, 0, 0.85, 0.041666666666667
4628, 0, 0.9, 0.041666666666667
4629, 0, 0.95, 0.041666666666667
4630, 0, 1, 0.041666666666667
4631, 0, 1.05, 0.041666666666667
4632, 0, 1.1, 0.041666666666667
4633, 0, 1.15, 0.041666666666667
4634, 0, 1.2, 0.041666666666667
4635, 0, 1.25, 0.041666666666667
4636, 0, 1.3, 0.041666666666667
4637, 0, 0.2, 0.083333333333333
4638, 0, 0.25, 0.083333333333333
4639, 0, 0.3, 0.083333333333333
4640, 0, 0.35, 0.083333333333333
4641, 0, 0.4, 0.083333333333333
4642, 0, 0.45, 0.083333333333333
4643, 0, 0.5, 0.083333333333333
4644, 0, 0.55, 0.083333333333333
4645, 0, 0.6, 0.083333333333333
4646, 0, 0.65, 0.083333333333333
4647, 0, 0.7, 0.083333333333333
4648, 0, 0.75, 0.083333333333333
4649, 0, 0.8, 0.083333333333333
4650, 0, 0.85, 0.083333333333333
4651, 0, 0.9, 0.083333333333333
4652, 0, 0.95, 0.083333333333333
4653, 0, 1, 0.083333333333333
4654, 0, 1.05, 0.083333333333333
4655, 0, 1.1, 0.083333333333333
4656, 0, 1.15, 0.083333333333333
4657, 0, 1.2, 0.083333333333333
4658, 0, 1.25, 0.083333333333333
4659, 0, 1.3, 0.083333333333333
4660, 0, 0.2, 0.125
4661, 0, 0.25, 0.125
4662, 0, 0.3, 0.125
4663, 0, 0.35, 0.125
4664, 0, 0.4, 0.125
4665, 0, 0.45, 0.125
4666, 0, 0.5, 0.125
4667, 0, 0.55, 0.125
4668, 0, 0.6, 0.125
4669, 0, 0.65, 0.125
4670, 0, 0.7, 0.125
4671, 0, 0.75, 0.125
4672, 0, 0.8, 0.125
4673, 0, 0.85, 0.125
4674, 0, 0.9, 0.125
4675, 0, 0.95, 0.125
4676, 0, 1, 0.125
4677, 0, 1.05, 0.125
4678, 0, 1.1, 0.125
4679, 0, 1.15, 0.125
4680, 0, 1.2, 0.125
4681, 0, 1.25, 0.125
4682, 0, 1.3, 0.125
4683, 0, 0.2, 0.16666666666667
4684, 0, 0.25, 0.16666666666667
4685, 0, 0.3, 0.16666666666667
4686, 0, 0.35, 0.16666666666667
4687, 0, 0.4, 0.16666666666667
4688, 0, 0.45, 0.16666666666667
4689, 0, 0.5, 0.16666666666667
4690, 0, 0.55, 0.16666666666667
4691, 0, 0.6, 0.16666666666667
4692, 0, 0.65, 0.16666666666667
4693, 0, 0.7, 0.16666666666667
4694, 0, 0.75, 0.16666666666667
4695, 0, 0.8, 0.16666666666667
4696, 0, 0.85, 0.16666666666667
4697, 0, 0.9, 0.16666666666667
4698, 0, 0.95, 0.16666666666667
4699, 0, 1, 0.16666666666667
4700, 0, 1.05, 0.16666666666667
4701, 0, 1.1, 0.16666666666667
4702, 0, 1.15, 0.16666666666667
4703, 0, 1.2, 0.16666666666667
4704, 0, 1.25, 0.16666666666667
4705, 0, 1.3, 0.16666666666667
4706, 0, 0.2, 0.20833333333333
4707, 0, 0.25, 0.20833333333333
4708, 0, 0.3, 0.20833333333333
4709, 0, 0.35, 0.20833333333333
4710, 0, 0.4, 0.20833333333333
4711, 0, 0.45, 0.20833333333333
4712, 0, 0.5, 0.20833333333333
4713, 0, 0.55, 0.20833333333333
4714, 0, 0.6, 0.20833333333333
4715, 0, 0.65, 0.20833333333333
4716, 0, 0.7, 0.20833333333333
4717, 0, 0.75, 0.20833333333333
4718, 0, 0.8, 0.20833333333333
4719, 0, 0.85, 0.20833333333333
4720, 0, 0.9, 0.20833333333333
4721, 0, 0.95, 0.20833333333333
4722, 0, 1, 0.20833333333333
4723, 0, 1.05, 0.20833333333333
4724, 0, 1.1, 0.20833333333333
4725, 0, 1.15, 0.20833333333333
4726, 0, 1.2, 0.20833333333333
4727, 0, 1.25, 0.20833333333333
4728, 0, 1.3, 0.20833333333333
4729, 0, 0.2, 0.25
4730, 0, 0.25, 0.25
4731, 0, 0.3, 0.25
4732, 0, 0.35, 0.25
4733, 0, 0.4, 0.25
4734, 0, 0.45, 0.25
4735, 0, 0.5, 0.25
4736, 0, 0.55, 0.25
4737, 0, 0.6, 0.25
4738, 0, 0.65, 0.25
4739, 0, 0.7, 0.25
4740, 0, 0.75, 0.25
4741, 0, 0.8, 0.25
4742, 0, 0.85, 0.25
4743, 0, 0.9, 0.25
4744, 0, 0.95, 0.25
4745, 0, 1, 0.25
4746, 0, 1.05, 0.25
4747, 0, 1.1, 0.25
4748, 0, 1.15, 0.25
4749, 0, 1.2, 0.25
4750, 0, 1.25, 0.25
4751, 0, 1.3, 0.25
4752, 0, 0.2, 0.29166666666667
4753, 0, 0.25, 0.29166666666667
4754, 0, 0.3, 0.29166666666667
4755, 0, 0.35, 0.29166666666667
4756, 0, 0.4, 0.29166666666667
4757, 0, 0.45, 0.29166666666667
4758, 0, 0.5, 0.29166666666667
4759, 0, 0.55, 0.29166666666667
4760, 0, 0.6, 0.29166666666667
4761, 0, 0.65, 0.29166666666667
4762, 0, 0.7, 0.29166666666667
4763, 0, 0.75, 0.29166666666667
4764, 0, 0.8, 0.29166666666667
4765, 0, 0.85, 0.29166666666667
4766, 0, 0.9, 0.29166666666667
4767, 0, 0.95, 0.29166666666667
4768, 0, 1, 0.29166666666667
4769, 0, 1.05, 0.29166666666667
4770, 0, 1.1, 0.29166666666667
4771, 0, 1.15, 0.29166666666667
4772, 0, 1.2, 0.29166666666667
4773, 0, 1.25, 0.29166666666667
4774, 0, 1.3, 0.29166666666667
4775, 0, 0.2, 0.33333333333333
4776, 0, 0.25, 0.33333333333333
4777, 0, 0.3, 0.33333333333333
4778, 0, 0.35, 0.33333333333333
4779, 0, 0.4, 0.33333333333333
4780, 0, 0.45, 0.33333333333333
4781, 0, 0.5, 0.33333333333333
4782, 0, 0.55, 0.33333333333333
4783, 0, 0.6, 0.33333333333333
4784, 0, 0.65, 0.33333333333333
4785, 0, 0.7, 0.33333333333333
4786, 0, 0.75, 0.33333333333333
4787, 0, 0.8, 0.33333333333333
4788, 0, 0.85, 0.33333333333333
4789, 0, 0.9, 0.33333333333333
4790, 0, 0.95, 0.33333333333333
4791, 0, 1, 0.33333333333333
4792, 0, 1.05, 0.33333333333333
4793, 0, 1.1, 0.33333333333333
4794, 0, 1.15, 0.33333333333333
4795, 0, 1.2, 0.33333333333333
4796, 0, 1.25, 0.33333333333333
4797, 0, 1.3, 0.33333333333333
4798, 0, 0.2, 0.375
4799, 0, 0.25, 0.375
4800, 0, 0.3, 0.375
4801, 0, 0.35, 0.375
4802, 0, 0.4, 0.375
4803, 0, 0.45, 0.375
4804, 0, 0.5, 0.375
4805, 0, 0.55, 0.375
4806, 0, 0.6, 0.375
4807, 0, 0.65, 0.375
4808, 0, 0.7, 0.375
4809, 0, 0.75, 0.375
4810, 0, 0.8, 0.375
4811, 0, 0.85, 0.375
4812, 0, 0.9, 0.375
4813, 0, 0.95, 0.375
4814, 0, 1, 0.375
4815, 0, 1.05, 0.375
4816, 0, 1.1, 0.375
4817, 0, 1.15, 0.375
4818, 0, 1.2, 0.375
4819, 0, 1.25, 0.375
4820, 0, 1.3, 0.375
4821, 0, 0.2, 0.41666666666667
4822, 0, 0.25, 0.41666666666667
4823, 0, 0.3, 0.41666666666667
4824, 0, 0.35, 0.41666666666667
4825, 0, 0.4, 0.41666666666667
4826, 0, 0.45, 0.41666666666667
4827, 0, 0.5, 0.41666666666667
4828, 0, 0.55, 0.41666666666667
4829, 0, 0.6, 0.41666666666667
4830, 0, 0.65, 0.41666666666667
4831, 0, 0.7, 0.41666666666667
4832, 0, 0.75, 0.41666666666667
4833, 0, 0.8, 0.41666666666667
4834, 0, 0.85, 0.41666666666667
4835, 0, 0.9, 0.41666666666667
4836, 0, 0.95, 0.41666666666667
4837, 0, 1, 0.41666666666667
4838, 0, 1.05, 0.41666666666667
4839, 0, 1.1, 0.41666666666667
4840, 0, 1.15, 0.41666666666667
4841, 0, 1.2, 0.41666666666667
4842, 0, 1.25, 0.41666666666667
4843, 0, 1.3, 0.41666666666667
4844, 0, 0.2, 0.45833333333333
4845, 0, 0.25, 0.45833333333333
4846, 0, 0.3, 0.45833333333333
4847, 0, 0.35, 0.45833333333333
4848, 0, 0.4, 0.45833333333333
4849, 0, 0.45, 0.45833333333333
4850, 0, 0.5, 0.45833333333333
4851, 0, 0.55, 0.45833333333333
4852, 0, 0.6, 0.45833333333333
4853, 0, 0.65, 0.45833333333333
4854, 0, 0.7, 0.45833333333333
4855, 0, 0.75, 0.45833333333333
4856, 0, 0.8, 0.45833333333333
4857, 0, 0.85, 0.45833333333333
4858, 0, 0.9, 0.45833333333333
4859, 0, 0.95, 0.45833333333333
4860, 0, 1, 0.45833333333333
4861, 0, 1.05, 0.45833333333333
4862, 0, 1.1, 0.45833333333333
4863, 0, 1.15, 0.45833333333333
4864, 0, 1.2, 0.45833333333333
4865, 0, 1.25, 0.45833333333333
4866, 0, 1.3, 0.45833333333333
4867, 0.041666666666667, 1.35, 0.041666666666667
4868, 0.041666666666667, 1.35, 0.083333333333333
4869, 0.041666666666667, 1.35, 0.125
4870, 0.041666666666667, 1.35, 0.16666666666667
4871, 0.041666666666667, 1.35, 0.20833333333333
4872, 0.041666666666667, 1.35, 0.25
4873, 0.041666666666667, 1.35, 0.29166666666667
4874, 0.041666666666667, 1.35, 0.33333333333333
4875, 0.041666666666667, 1.35, 0.375
4876, 0.041666666666667, 1.35, 0.41666666666667
4877, 0.041666666666667, 1.35, 0.45833333333333
4878, 0.083333333333333, 1.35, 0.041666666666667
4879, 0.083333333333333, 1.35, 0.083333333333333
4880, 0.083333333333333, 1.35, 0.125
4881, 0.083333333333333, 1.35, 0.16666666666667
4882, 0.083333333333333, 1.35, 0.20833333333333
4883, 0.083333333333333, 1.35, 0.25
4884, 0.083333333333333, 1.35, 0.29166666666667
4885, 0.083333333333333, 1.35, 0.33333333333333
4886, 0.083333333333333, 1.35, 0.375
4887, 0.083333333333333, 1.35, 0.41666666666667
4888, 0.083333333333333, 1.35, 0.45833333333333
4889, 0.125, 1.35, 0.041666666666667
4890, 0.125, 1.35, 0.083333333333333
4891, 0.125, 1.35, 0.125
4892, 0.125, 1.35, 0.16666666666667
4893, 0.125, 1.35, 0.20833333333333
4894, 0.125, 1.35, 0.25
4895, 0.125, 1.35, 0.29166666666667
4896, 0.125, 1.35, 0.33333333333333
4897, 0.125, 1.35, 0.375
4898, 0.125, 1.35, 0.41666666666667
4899, 0.125, 1.35, 0.45833333333333
4900, 0.16666666666667, 1.35, 0.041666666666667
4901, 0.16666666666667, 1.35, 0.083333333333333
4902, 0.16666666666667, 1.35, 0.125
4903, 0.16666666666667, 1.35, 0.16666666666667
4904, 0.16666666666667, 1.35, 0.20833333333333
4905, 0.16666666666667, 1.35, 0.25
4906, 0.16666666666667, 1.35, 0.29166666666667
4907, 0.16666666666667, 1.35, 0.33333333333333
4908, 0.16666666666667, 1.35, 0.375
4909, 0.16666666666667, 1.35, 0.41666666666667
4910, 0.16666666666667, 1.35, 0.45833333333333
4911, 0.20833333333333, 1.35, 0.041666666666667
4912, 0.20833333333333, 1.35, 0.083333333333333
4913, 0.20833333333333, 1.35, 0.125
4914, 0.20833333333333, 1.35, 0.16666666666667
4915, 0.20833333333333, 1.35, 0.20833333333333
4916, 0.20833333333333, 1.35, 0.25
4917, 0.20833333333333, 1.35, 0.29166666666667
4918, 0.20833333333333, 1.35, 0.33333333333333
4919, 0.20833333333333, 1.35, 0.375
4920, 0.20833333333333, 1.35, 0.41666666666667
4921, 0.20833333333333, 1.35, 0.45833333333333
4922, 0.25, 1.35, 0.041666666666667
4923, 0.25, 1.35, 0.083333333333333
4924, 0.25, 1.35, 0.125
4925, 0.25, 1.35, 0.16666666666667
4926, 0.25, 1.35, 0.20833333333333
4927, 0.25, 1.35, 0.25
4928, 0.25, 1.35, 0.29166666666667
4929, 0.25, 1.35, 0.33333333333333
4930, 0.25, 1.35, 0.375
4931, 0.25, 1.35, 0.41666666666667
4932, 0.25, 1.35, 0.45833333333333
4933, 0.29166666666667, 1.35, 0.041666666666667
4934, 0.29166666666667, 1.35, 0.083333333333333
4935, 0.29166666666667, 1.35, 0.125
4936, 0.29166666666667, 1.35, 0.16666666666667
4937, 0.29166666666667, 1.35, 0.20833333333333
4938, 0.29166666666667, 1.35, 0.25
4939, 0.29166666666667, 1.35, 0.29166666666667
4940, 0.29166666666667, 1.35, 0.33333333333333
4941, 0.29166666666667, 1.35, 0.375
4942, 0.29166666666667, 1.35, 0.41666666666667
4943, 0.29166666666667, 1.35, 0.45833333333333
4944, 0.33333333333333, 1.35, 0.041666666666667
4945, 0.33333333333333, 1.35, 0.083333333333333
4946, 0.33333333333333, 1.35, 0.125
4947, 0.33333333333333, 1.35, 0.16666666666667
4948, 0.33333333333333, 1.35, 0.20833333333333
4949, 0.33333333333333, 1.35, 0.25
4950, 0.33333333333333, 1.35, 0.29166666666667
4951, 0.33333333333333, 1.35, 0.33333333333333
4952, 0.33333333333333, 1.35, 0.375
4953, 0.33333333333333, 1.35, 0.41666666666667
4954, 0.33333333333333, 1.35, 0.45833333333333
4955, 0.375, 1.35, 0.041666666666667
4956, 0.375, 1.35, 0.083333333333333
4957, 0.375, 1.35, 0.125
4958, 0.375, 1.35, 0.16666666666667
4959, 0.375, 1.35, 0.20833333333333
4960, 0.375, 1.35, 0.25
4961, 0.375, 1.35, 0.29166666666667
4962, 0.375, 1.35, 0.33333333333333
4963, 0.375, 1.35, 0.375
4964, 0.375, 1.35, 0.41666666666667
4965, 0.375, 1.35, 0.45833333333333
4966, 0.41666666666667, 1.35, 0.041666666666667
4967, 0.41666666666667, 1.35, 0.083333333333333
4968, 0.41666666666667, 1.35, 0.125
4969, 0.41666666666667, 1.35, 0.16666666666667
4970, 0.41666666666667, 1.35, 0.20833333333333
4971, 0.41666666666667, 1.35, 0.25
4972, 0.41666666666667, 1.35, 0.29166666666667
4973, 0.41666666666667, 1.35, 0.33333333333333
4974, 0.41666666666667, 1.35, 0.375
4975, 0.41666666666667, 1.35, 0.41666666666667
4976, 0.41666666666667, 1.35, 0.45833333333333
4977, 0.45833333333333, 1.35, 0.041666666666667
4978, 0.45833333333333, 1.35, 0.083333333333333
4979, 0.45833333333333, 1.35, 0.125
4980, 0.45833333333333, 1.35, 0.16666666666667
4981, 0.45833333333333, 1.35, 0.20833333333333
4982, 0.45833333333333, 1.35, 0.25
4983, 0.45833333333333, 1.35, 0.29166666666667
4984, 0.45833333333333, 1.35, 0.33333333333333
4985, 0.45833333333333, 1.35, 0.375
4986, 0.45833333333333, 1.35, 0.41666666666667
4987, 0.45833333333333, 1.35, 0.45833333333333
4988, 0.5, 1.35, 0.041666666666667
4989, 0.5, 1.35, 0.083333333333333
4990, 0.5, 1.35, 0.125
4991, 0.5, 1.35, 0.16666666666667
4992, 0.5, 1.35, 0.20833333333333
4993, 0.5, 1.35, 0.25
4994, 0.5, 1.35, 0.29166666666667
4995, 0.5, 1.35, 0.33333333333333
4996, 0.5, 1.35, 0.375
4997, 0.5, 1.35, 0.41666666666667
4998, 0.5, 1.35, 0.45833333333333
4999, 0.54166666666667, 1.35, 0.041666666666667
5000, 0.54166666666667, 1.35, 0.083333333333333
5001, 0.54166666666667, 1.35, 0.125
5002, 0.54166666666667, 1.35, 0.16666666666667
5003, 0.54166666666667, 1.35, 0.20833333333333
5004, 0.54166666666667, 1.35, 0.25
5005, 0.54166666666667, 1.35, 0.29166666666667
5006, 0.54166666666667, 1.35, 0.33333333333333
5007, 0.54166666666667, 1.35, 0.375
5008, 0.54166666666667, 1.35, 0.41666666666667
5009, 0.54166666666667, 1.35, 0.45833333333333
5010, 0.58333333333333, 1.35, 0.041666666666667
5011, 0.58333333333333, 1.35, 0.083333333333333
5012, 0.58333333333333, 1.35, 0.125
5013, 0.58333333333333, 1.35, 0.16666666666667
5014, 0.58333333333333, 1.35, 0.20833333333333
5015, 0.58333333333333, 1.35, 0.25
5016, 0.58333333333333, 1.35, 0.29166666666667
5017, 0.58333333333333, 1.35, 0.33333333333333
5018, 0.58333333333333, 1.35, 0.375
5019, 0.58333333333333, 1.35, 0.41666666666667
5020, 0.58333333333333, 1.35, 0.45833333333333
5021, 0.625, 1.35, 0.041666666666667
5022, 0.625, 1.35, 0.083333333333333
5023, 0.625, 1.35, 0.125
5024, 0.625, 1.35, 0.16666666666667
5025, 0.625, 1.35, 0.20833333333333
5026, 0.625, 1.35, 0.25
5027, 0.625, 1.35, 0.29166666666667
5028, 0.625, 1.35, 0.33333333333333
5029, 0.625, 1.35, 0.375
5030, 0.625, 1.35, 0.41666666666667
5031, 0.625, 1.35, 0.45833333333333
5032, 0.66666666666667, 1.35, 0.041666666666667
5033, 0.66666666666667, 1.35, 0.083333333333333
5034, 0.66666666666667, 1.35, 0.125
5035, 0.66666666666667, 1.35, 0.16666666666667
5036, 0.66666666666667, 1.35, 0.20833333333333
5037, 0.66666666666667, 1.35, 0.25
5038, 0.66666666666667, 1.35, 0.29166666666667
5039, 0.66666666666667, 1.35, 0.33333333333333
5040, 0.66666666666667, 1.35, 0.375
5041, 0.66666666666667, 1.35, 0.41666666666667
5042, 0.66666666666667, 1.35, 0.45833333333333
5043, 0.70833333333333, 1.35, 0.041666666666667
5044, 0.70833333333333, 1.35, 0.083333333333333
5045, 0.70833333333333, 1.35, 0.125
5046, 0.70833333333333, 1.35, 0.16666666666667
5047, 0.70833333333333, 1.35, 0.20833333333333
5048, 0.70833333333333, 1.35, 0.25
5049, 0.70833333333333, 1.35, 0.29166666666667
5050, 0.70833333333333, 1.35, 0.33333333333333
5051, 0.70833333333333, 1.35, 0.375
5052, 0.70833333333333, 1.35, 0.41666666666667
5053, 0.70833333333333, 1.35, 0.45833333333333
5054, 0.75, 1.35, 0.041666666666667
5055, 0.75, 1.35, 0.083333333333333
5056, 0.75, 1.35, 0.125
5057, 0.75, 1.35, 0.16666666666667
5058, 0.75, 1.35, 0.20833333333333
5059, 0.75, 1.35, 0.25
5060, 0.75, 1.35, 0.29166666666667
5061, 0.75, 1.35, 0.33333333333333
5062, 0.75, 1.35, 0.375
5063, 0.75, 1.35, 0.41666666666667
5064, 0.75, 1.35, 0.45833333333333
5065, 0.79166666666667, 1.35, 0.041666666666667
5066, 0.79166666666667, 1.35, 0.083333333333333
5067, 0.79166666666667, 1.35, 0.125
5068, 0.79166666666667, 1.35, 0.16666666666667
5069, 0.79166666666667, 1.35, 0.20833333333333
5070, 0.79166666666667, 1.35, 0.25
5071, 0.79166666666667, 1.35, 0.29166666666667
5072, 0.79166666666667, 1.35, 0.33333333333333
5073, 0.79166666666667, 1.35, 0.375
5074, 0.79166666666667, 1.35, 0.41666666666667
5075, 0.79166666666667, 1.35, 0.45833333333333
5076, 0.83333333333333, 1.35, 0.041666666666667
5077, 0.83333333333333, 1.35, 0.083333333333333
5078, 0.83333333333333, 1.35, 0.125
5079, 0.83333333333333, 1.35, 0.16666666666667
5080, 0.83333333333333, 1.35, 0.20833333333333
5081, 0.83333333333333, 1.35, 0.25
5082, 0.83333333333333, 1.35, 0.29166666666667
5083, 0.83333333333333, 1.35, 0.33333333333333
5084, 0.83333333333333, 1.35, 0.375
5085, 0.83333333333333, 1.35, 0.41666666666667
5086, 0.83333333333333, 1.35, 0.45833333333333
5087, 0.875, 1.35, 0.041666666666667
5088, 0.875, 1.35, 0.083333333333333
5089, 0.875, 1.35, 0.125
5090, 0.875, 1.35, 0.16666666666667
5091, 0.875, 1.35, 0.20833333333333
5092, 0.875, 1.35, 0.25
5093, 0.875, 1.35, 0.29166666666667
5094, 0.875, 1.35, 0.33333333333333
5095, 0.875, 1.35, 0.375
5096, 0.875, 1.35, 0.41666666666667
5097, 0.875, 1.35, 0.45833333333333
5098, 0.91666666666667, 1.35, 0.041666666666667
5099, 0.91666666666667, 1.35, 0.083333333333333
5100, 0.91666666666667, 1.35, 0.125
5101, 0.91666666666667, 1.35, 0.16666666666667
5102, 0.91666666666667, 1.35, 0.20833333333333
5103, 0.91666666666667, 1.35, 0.25
5104, 0.91666666666667, 1.35, 0.29166666666667
5105, 0.91666666666667, 1.35, 0.33333333333333
5106, 0.91666666666667, 1.35, 0.375
5107, 0.91666666666667, 1.35, 0.41666666666667
5108, 0.91666666666667, 1.35, 0.45833333333333
5109, 0.95833333333333, 1.35, 0.041666666666667
5110, 0.95833333333333, 1.35, 0.083333333333333
5111, 0.95833333333333, 1.35, 0.125
5112, 0.95833333333333, 1.35, 0.16666666666667
5113, 0.95833333333333, 1.35, 0.20833333333333
5114, 0.95833333333333, 1.35, 0.25
5115, 0.95833333333333, 1.35, 0.29166666666667
5116, 0.95833333333333, 1.35, 0.33333333333333
5117, 0.95833333333333, 1.35, 0.375
5118, 0.95833333333333, 1.35, 0.41666666666667
5119, 0.95833333333333, 1.35, 0.45833333333333
5120, 0.041666666666667, 1.4, 0.041666666666667
5121, 0.041666666666667, 1.4, 0.083333333333333
5122, 0.041666666666667, 1.4, 0.125
5123, 0.041666666666667, 1.4, 0.16666666666667
5124, 0.041666666666667, 1.4, 0.20833333333333
5125, 0.041666666666667, 1.4, 0.25
5126, 0.041666666666667, 1.4, 0.29166666666667
5127, 0.041666666666667, 1.4, 0.33333333333333
5128, 0.041666666666667, 1.4, 0.375
5129, 0.041666666666667, 1.4, 0.41666666666667
5130, 0.041666666666667, 1.4, 0.45833333333333
5131, 0.083333333333333, 1.4, 0.041666666666667
5132, 0.083333333333333, 1.4, 0.083333333333333
5133, 0.083333333333333, 1.4, 0.125
5134, 0.083333333333333, 1.4, 0.16666666666667
5135, 0.083333333333333, 1.4, 0.20833333333333
5136, 0.083333333333333, 1.4, 0.25
5137, 0.083333333333333, 1.4, 0.29166666666667
5138, 0.083333333333333, 1.4, 0.33333333333333
5139, 0.083333333333333, 1.4, 0.375
5140, 0.083333333333333, 1.4, 0.41666666666667
5141, 0.083333333333333, 1.4, 0.45833333333333
5142, 0.125, 1.4, 0.041666666666667
5143, 0.125, 1.4, 0.083333333333333
5144, 0.125, 1.4, 0.125
5145, 0.125, 1.4, 0.16666666666667
5146, 0.125, 1.4, 0.20833333333333
5147, 0.125, 1.4, 0.25
5148, 0.125, 1.4, 0.29166666666667
5149, 0.125, 1.4, 0.33333333333333
5150, 0.125, 1.4, 0.375
5151, 0.125, 1.4, 0.41666666666667
5152, 0.125, 1.4, 0.45833333333333
5153, 0.16666666666667, 1.4, 0.041666666666667
5154, 0.16666666666667, 1.4, 0.083333333333333
5155, 0.16666666666667, 1.4, 0.125
5156, 0.16666666666667, 1.4, 0.16666666666667
5157, 0.16666666666667, 1.4, 0.20833333333333
5158, 0.16666666666667, 1.4, 0.25
5159, 0.16666666666667, 1.4, 0.29166666666667
5160, 0.16666666666667, 1.4, 0.33333333333333
5161, 0.16666666666667, 1.4, 0.375
5162, 0.16666666666667, 1.4, 0.41666666666667
5163, 0.16666666666667, 1.4, 0.45833333333333
5164, 0.20833333333333, 1.4, 0.041666666666667
5165, 0.20833333333333, 1.4, 0.083333333333333
5166, 0.20833333333333, 1.4, 0.125
5167, 0.20833333333333, 1.4, 0.16666666666667
5168, 0.20833333333333, 1.4, 0.20833333333333
5169, 0.20833333333333, 1.4, 0.25
5170, 0.20833333333333, 1.4, 0.29166666666667
5171, 0.20833333333333, 1.4, 0.33333333333333
5172, 0.20833333333333, 1.4, 0.375
5173, 0.20833333333333, 1.4, 0.41666666666667
5174, 0.20833333333333, 1.4, 0.45833333333333
5175, 0.25, 1.4, 0.041666666666667
5176, 0.25, 1.4, 0.083333333333333
5177, 0.25, 1.4, 0.125
5178, 0.25, 1.4, 0.16666666666667
5179, 0.25, 1.4, 0.20833333333333
5180, 0.25, 1.4, 0.25
5181, 0.25, 1.4, 0.29166666666667
5182, 0.25, 1.4, 0.33333333333333
5183, 0.25, 1.4, 0.375
5184, 0.25, 1.4, 0.41666666666667
5185, 0.25, 1.4, 0.45833333333333
5186, 0.29166666666667, 1.4, 0.041666666666667
5187, 0.29166666666667, 1.4, 0.083333333333333
5188, 0.29166666666667, 1.4, 0.125
5189, 0.29166666666667, 1.4, 0.16666666666667
5190, 0.29166666666667, 1.4, 0.20833333333333
5191, 0.29166666666667, 1.4, 0.25
5192, 0.29166666666667, 1.4, 0.29166666666667
5193, 0.29166666666667, 1.4, 0.33333333333333
5194, 0.29166666666667, 1.4, 0.375
5195, 0.29166666666667, 1.4, 0.41666666666667
5196, 0.29166666666667, 1.4, 0.45833333333333
5197, 0.33333333333333, 1.4, 0.041666666666667
5198, 0.33333333333333, 1.4, 0.083333333333333
5199, 0.33333333333333, 1.4, 0.125
5200, 0.33333333333333, 1.4, 0.16666666666667
5201, 0.33333333333333, 1.4, 0.20833333333333
5202, 0.33333333333333, 1.4, 0.25
5203, 0.33333333333333, 1.4, 0.29166666666667
5204, 0.33333333333333, 1.4, 0.33333333333333
5205, 0.33333333333333, 1.4, 0.375
5206, 0.33333333333333, 1.4, 0.41666666666667
5207, 0.33333333333333, 1.4, 0.45833333333333
5208, 0.375, 1.4, 0.041666666666667
5209, 0.375, 1.4, 0.083333333333333
5210, 0.375, 1.4, 0.125
5211, 0.375, 1.4, 0.16666666666667
5212, 0.375, 1.4, 0.20833333333333
5213, 0.375, 1.4, 0.25
5214, 0.375, 1.4, 0.29166666666667
5215, 0.375, 1.4, 0.33333333333333
5216, 0.375, 1.4, 0.375
5217, 0.375, 1.4, 0.41666666666667
5218, 0.375, 1.4, 0.45833333333333
5219, 0.41666666666667, 1.4, 0.041666666666667
5220, 0.41666666666667, 1.4, 0.083333333333333
5221, 0.41666666666667, 1.4, 0.125
5222, 0.41666666666667, 1.4, 0.16666666666667
5223, 0.41666666666667, 1.4, 0.20833333333333
5224, 0.41666666666667, 1.4, 0.25
5225, 0.41666666666667, 1.4, 0.29166666666667
5226, 0.41666666666667, 1.4, 0.33333333333333
5227, 0.41666666666667, 1.4, 0.375
5228, 0.41666666666667, 1.4, 0.41666666666667
5229, 0.41666666666667, 1.4, 0.45833333333333
5230, 0.45833333333333, 1.4, 0.041666666666667
5231, 0.45833333333333, 1.4, 0.083333333333333
5232, 0.45833333333333, 1.4, 0.125
5233, 0.45833333333333, 1.4, 0.16666666666667
5234, 0.45833333333333, 1.4, 0.20833333333333
5235, 0.45833333333333, 1.4, 0.25
5236, 0.45833333333333, 1.4, 0.29166666666667
5237, 0.45833333333333, 1.4, 0.33333333333333
5238, 0.45833333333333, 1.4, 0.375
5239, 0.45833333333333, 1.4, 0.41666666666667
5240, 0.45833333333333, 1.4, 0.45833333333333
5241, 0.5, 1.4, 0.041666666666667
5242, 0.5, 1.4, 0.083333333333333
5243, 0.5, 1.4, 0.125
5244, 0.5, 1.4, 0.16666666666667
5245, 0.5, 1.4, 0.20833333333333
5246, 0.5, 1.4, 0.25
5247, 0.5, 1.4, 0.29166666666667
5248, 0.5, 1.4, 0.33333333333333
5249, 0.5, 1.4, 0.375
5250, 0.5, 1.4, 0.41666666666667
5251, 0.5, 1.4, 0.45833333333333
5252, 0.54166666666667, 1.4, 0.041666666666667
5253, 0.54166666666667, 1.4, 0.083333333333333
5254, 0.54166666666667, 1.4, 0.125
5255, 0.54166666666667, 1.4, 0.16666666666667
5256, 0.54166666666667, 1.4, 0.20833333333333
5257, 0.54166666666667, 1.4, 0.25
5258, 0.54166666666667, 1.4, 0.29166666666667
5259, 0.54166666666667, 1.4, 0.33333333333333
5260, 0.54166666666667, 1.4, 0.375
5261, 0.54166666666667, 1.4, 0.41666666666667
5262, 0.54166666666667, 1.4, 0.45833333333333
5263, 0.58333333333333, 1.4, 0.041666666666667
5264, 0.58333333333333, 1.4, 0.083333333333333
5265, 0.58333333333333, 1.4, 0.125
5266, 0.58333333333333, 1.4, 0.16666666666667
5267, 0.58333333333333, 1.4, 0.20833333333333
5268, 0.58333333333333, 1.4, 0.25
5269, 0.58333333333333, 1.4, 0.29166666666667
5270, 0.58333333333333, 1.4, 0.33333333333333
5271, 0.58333333333333, 1.4, 0.375
5272, 0.58333333333333, 1.4, 0.41666666666667
5273, 0.58333333333333, 1.4, 0.45833333333333
5274, 0.625, 1.4, 0.041666666666667
5275, 0.625, 1.4, 0.083333333333333
5276, 0.625, 1.4, 0.125
5277, 0.625, 1.4, 0.16666666666667
5278, 0.625, 1.4, 0.20833333333333
5279, 0.625, 1.4, 0.25
5280, 0.625, 1.4, 0.29166666666667
5281, 0.625, 1.4, 0.33333333333333
5282, 0.625, 1.4, 0.375
5283, 0.625, 1.4, 0.41666666666667
5284, 0.625, 1.4, 0.45833333333333
5285, 0.66666666666667, 1.4, 0.041666666666667
5286, 0.66666666666667, 1.4, 0.083333333333333
5287, 0.66666666666667, 1.4, 0.125
5288, 0.66666666666667, 1.4, 0.16666666666667
5289, 0.66666666666667, 1.4, 0.20833333333333
5290, 0.66666666666667, 1.4, 0.25
5291, 0.66666666666667, 1.4, 0.29166666666667
5292, 0.66666666666667, 1.4, 0.33333333333333
5293, 0.66666666666667, 1.4, 0.375
5294, 0.66666666666667, 1.4, 0.41666666666667
5295, 0.66666666666667, 1.4, 0.45833333333333
5296, 0.70833333333333, 1.4, 0.041666666666667
5297, 0.70833333333333, 1.4, 0.083333333333333
5298, 0.70833333333333, 1.4, 0.125
5299, 0.70833333333333, 1.4, 0.16666666666667
5300, 0.70833333333333, 1.4, 0.20833333333333
5301, 0.70833333333333, 1.4, 0.25
5302, 0.70833333333333, 1.4, 0.29166666666667
5303, 0.70833333333333, 1.4, 0.33333333333333
5304, 0.70833333333333, 1.4, 0.375
5305, 0.70833333333333, 1.4, 0.41666666666667
5306, 0.70833333333333, 1.4, 0.45833333333333
5307, 0.75, 1.4, 0.041666666666667
5308, 0.75, 1.4, 0.083333333333333
5309, 0.75, 1.4, 0.125
5310, 0.75, 1.4, 0.16666666666667
5311, 0.75, 1.4, 0.20833333333333
5312, 0.75, 1.4, 0.25
5313, 0.75, 1.4, 0.29166666666667
5314, 0.75, 1.4, 0.33333333333333
5315, 0.75, 1.4, 0.375
5316, 0.75, 1.4, 0.41666666666667
5317, 0.75, 1.4, 0.45833333333333
5318, 0.79166666666667, 1.4, 0.041666666666667
5319, 0.79166666666667, 1.4, 0.083333333333333
5320, 0.79166666666667, 1.4, 0.125
5321, 0.79166666666667, 1.4, 0.16666666666667
5322, 0.79166666666667, 1.4, 0.20833333333333
5323, 0.79166666666667, 1.4, 0.25
5324, 0.79166666666667, 1.4, 0.29166666666667
5325, 0.79166666666667, 1.4, 0.33333333333333
5326, 0.79166666666667, 1.4, 0.375
5327, 0.79166666666667, 1.4, 0.41666666666667
5328, 0.79166666666667, 1.4, 0.45833333333333
5329, 0.83333333333333, 1.4, 0.041666666666667
5330, 0.83333333333333, 1.4, 0.083333333333333
5331, 0.83333333333333, 1.4, 0.125
5332, 0.83333333333333, 1.4, 0.16666666666667
5333, 0.83333333333333, 1.4, 0.20833333333333
5334, 0.83333333333333, 1.4, 0.25
5335, 0.83333333333333, 1.4, 0.29166666666667
5336, 0.83333333333333, 1.4, 0.33333333333333
5337, 0.83333333333333, 1.4, 0.375
5338, 0.83333333333333, 1.4, 0.41666666666667
5339, 0.83333333333333, 1.4, 0.45833333333333
5340, 0.875, 1.4, 0.041666666666667
5341, 0.875, 1.4, 0.083333333333333
5342, 0.875, 1.4, 0.125
5343, 0.875, 1.4, 0.16666666666667
5344, 0.875, 1.4, 0.20833333333333
5345, 0.875, 1.4, 0.25
5346, 0.875, 1.4, 0.29166666666667
5347, 0.875, 1.4, 0.33333333333333
5348, 0.875, 1.4, 0.375
5349, 0.875, 1.4, 0.41666666666667
5350, 0.875, 1.4, 0.45833333333333
5351, 0.91666666666667, 1.4, 0.041666666666667
5352, 0.91666666666667, 1.4, 0.083333333333333
5353, 0.91666666666667, 1.4, 0.125
5354, 0.91666666666667, 1.4, 0.16666666666667
5355, 0.91666666666667, 1.4, 0.20833333333333
5356, 0.91666666666667, 1.4, 0.25
5357, 0.91666666666667, 1.4, 0.29166666666667
5358, 0.91666666666667, 1.4, 0.33333333333333
5359, 0.91666666666667, 1.4, 0.375
5360, 0.91666666666667, 1.4, 0.41666666666667
5361, 0.91666666666667, 1.4, 0.45833333333333
5362, 0.95833333333333, 1.4, 0.041666666666667
5363, 0.95833333333333, 1.4, 0.083333333333333
5364, 0.95833333333333, 1.4, 0.125
5365, 0.95833333333333, 1.4, 0.16666666666667
5366, 0.95833333333333, 1.4, 0.20833333333333
5367, 0.95833333333333, 1.4, 0.25
5368, 0.95833333333333, 1.4, 0.29166666666667
5369, 0.95833333333333, 1.4, 0.33333333333333
5370, 0.95833333333333, 1.4, 0.375
5371, 0.95833333333333, 1.4, 0.41666666666667
5372, 0.95833333333333, 1.4, 0.45833333333333
5373, 0.041666666666667, 1.4333333333333, 0
5374, 0.041666666666667, 1.4666666666667, 0
5375, 0.083333333333333, 1.4333333333333, 0
5376, 0.083333333333333, 1.4666666666667, 0
5377, 0.125, 1.4333333333333, 0
5378, 0.125, 1.4666666666667, 0
5379, 0.16666666666667, 1.4333333333333, 0
5380, 0.16666666666667, 1.4666666666667, 0
5381, 0.20833333333333, 1.4333333333333, 0
5382, 0.20833333333333, 1.4666666666667, 0
5383, 0.25, 1.4333333333333, 0
5384, 0.25, 1.4666666666667, 0
5385, 0.29166666666667, 1.4333333333333, 0
5386, 0.29166666666667, 1.4666666666667, 0
5387, 0.33333333333333, 1.4333333333333, 0
5388, 0.33333333333333, 1.4666666666667, 0
5389, 0.375, 1.4333333333333, 0
5390, 0.375, 1.4666666666667, 0
5391, 0.41666666666667, 1.4333333333333, 0
5392, 0.41666666666667, 1.4666666666667, 0
5393, 0.45833333333333, 1.4333333333333, 0
5394, 0.45833333333333, 1.4666666666667, 0
5395, 0.5, 1.4333333333333, 0
5396, 0.5, 1.4666666666667, 0
5397, 0.54166666666667, 1.4333333333333, 0
5398, 0.54166666666667, 1.4666666666667, 0
5399, 0.58333333333333, 1.4333333333333, 0
5400, 0.58333333333333, 1.4666666666667, 0
5401, 0.625, 1.4333333333333, 0
5402, 0.625, 1.4666666666667, 0
5403, 0.66666666666667, 1.4333333333333, 0
5404, 0.66666666666667, 1.4666666666667, 0
5405, 0.70833333333333, 1.4333333333333, 0
5406, 0.70833333333333, 1.4666666666667, 0
5407, 0.75, 1.4333333333333, 0
5408, 0.75, 1.4666666666667, 0
5409, 0.79166666666667, 1.4333333333333, 0
5410, 0.79166666666667, 1.4666666666667, 0
5411, 0.83333333333333, 1.4333333333333, 0
5412, 0.83333333333333, 1.4666666666667, 0
5413, 0.875, 1.4333333333333, 0
5414, 0.875, 1.4666666666667, 0
5415, 0.91666666666667, 1.4333333333333, 0
5416, 0.91666666666667, 1.4666666666667, 0
5417, 0.95833333333333, 1.4333333333333, 0
5418, 0.95833333333333, 1.4666666666667, 0
5419, 1, 1.4333333333333, 0.041666666666667
5420, 1, 1.4666666666667, 0.041666666666667
5421, 1, 1.4333333333333, 0.083333333333333
5422, 1, 1.4666666666667, 0.083333333333333
5423, 1, 1.4333333333333, 0.125
5424, 1, 1.4666666666667, 0.125
5425, 1, 1.4333333333333, 0.16666666666667
5426, 1, 1.4666666666667, 0.16666666666667
5427, 1, 1.4333333333333, 0.20833333333333
5428, 1, 1.4666666666667, 0.20833333333333
5429, 1, 1.4333333333333, 0.25
5430, 1, 1.4666666666667, 0.25
5431, 1, 1.4333333333333, 0.29166666666667
5432, 1, 1.4666666666667, 0.29166666666667
5433, 1, 1.4333333333333, 0.33333333333333
5434, 1, 1.4666666666667, 0.33333333333333
5435, 1, 1.4333333333333, 0.375
5436, 1, 1.4666666666667, 0.375
5437, 1, 1.4333333333333, 0.41666666666667
5438, 1, 1.4666666666667, 0.41666666666667
5439, 1, 1.4333333333333, 0.45833333333333
5440, 1, 1.4666666666667, 0.45833333333333
5441, 0.041666666666667, 1.4333333333333, 0.5
5442, 0.041666666666667, 1.4666666666667, 0.5
5443, 0.083333333333333, 1.4333333333333, 0.5
5444, 0.083333333333333, 1.4666666666667, 0.5
5445, 0.125, 1.4333333333333, 0.5
5446, 0.125, 1.4666666666667, 0.5
5447, 0.16666666666667, 1.4333333333333, 0.5
5448, 0.16666666666667, 1.4666666666667, 0.5
5449, 0.20833333333333, 1.4333333333333, 0.5
5450, 0.20833333333333, 1.4666666666667, 0.5
5451, 0.25, 1.4333333333333, 0.5
5452, 0.25, 1.4666666666667, 0.5
5453, 0.29166666666667, 1.4333333333333, 0.5
5454, 0.29166666666667, 1.4666666666667, 0.5
5455, 0.33333333333333, 1.4333333333333, 0.5
5456, 0.33333333333333, 1.4666666666667, 0.5
5457, 0.375, 1.4333333333333, 0.5
5458, 0.375, 1.4666666666667, 0.5
5459, 0.41666666666667, 1.4333333333333, 0.5
5460, 0.41666666666667, 1.4666666666667, 0.5
5461, 0.45833333333333, 1.4333333333333, 0.5
5462, 0.45833333333333, 1.4666666666667, 0.5
5463, 0.5, 1.4333333333333, 0.5
5464, 0.5, 1.4666666666667, 0.5
5465, 0.54166666666667, 1.4333333333333, 0.5
5466, 0.54166666666667, 1.4666666666667, 0.5
5467, 0.58333333333333, 1.4333333333333, 0.5
5468, 0.58333333333333, 1.4666666666667, 0.5
5469, 0.625, 1.4333333333333, 0.5
5470, 0.625, 1.4666666666667, 0.5
5471, 0.66666666666667, 1.4333333333333, 0.5
5472, 0.66666666666667, 1.4666666666667, 0.5
5473, 0.70833333333333, 1.4333333333333, 0.5
5474, 0.70833333333333, 1.4666666666667, 0.5
5475, 0.75, 1.4333333333333, 0.5
5476, 0.75, 1.4666666666667, 0.5
5477, 0.79166666666667, 1.4333333333333, 0.5
5478, 0.79166666666667, 1.4666666666667, 0.5
5479, 0.83333333333333, 1.4333333333333, 0.5
5480, 0.83333333333333, 1.4666666666667, 0.5
5481, 0.875, 1.4333333333333, 0.5
5482, 0.875, 1.4666666666667, 0.5
5483, 0.91666666666667, 1.4333333333333, 0.5
5484, 0.91666666666667, 1.4666666666667, 0.5
5485, 0.95833333333333, 1.4333333333333, 0.5
5486, 0.95833333333333, 1.4666666666667, 0.5
5487, 0, 1.4333333333333, 0.041666666666667
5488, 0, 1.4666666666667, 0.041666666666667
5489, 0, 1.4333333333333, 0.083333333333333
5490, 0, 1.4666666666667, 0.083333333333333
5491, 0, 1.4333333333333, 0.125
5492, 0, 1.4666666666667, 0.125
5493, 0, 1.4333333333333, 0.16666666666667
5494, 0, 1.4666666666667, 0.16666666666667
5495, 0, 1.4333333333333, 0.20833333333333
5496, 0, 1.4666666666667, 0.20833333333333
5497, 0, 1.4333333333333, 0.25
5498, 0, 1.4666666666667, 0.25
5499, 0, 1.4333333333333, 0.29166666666667
5500, 0, 1.4666666666667, 0.29166666666667
5501, 0, 1.4333333333333, 0.33333333333333
5502, 0, 1.4666666666667, 0.33333333333333
5503, 0, 1.4333333333333, 0.375
5504, 0, 1.4666666666667, 0.375
5505, 0, 1.4333333333333, 0.41666666666667
5506, 0, 1.4666666666667, 0.41666666666667
5507, 0, 1.4333333333333, 0.45833333333333
5508, 0, 1.4666666666667, 0.45833333333333
5509, 0.041666666666667, 1.5, 0.041666666666667
5510, 0.041666666666667, 1.5, 0.083333333333333
5511, 0.041666666666667, 1.5, 0.125
5512, 0.041666666666667, 1.5, 0.16666666666667
5513, 0.041666666666667, 1.5, 0.20833333333333
5514, 0.041666666666667, 1.5, 0.25
5515, 0.041666666666667, 1.5, 0.29166666666667
5516, 0.041666666666667, 1.5, 0.33333333333333
5517, 0.041666666666667, 1.5, 0.375
5518, 0.041666666666667, 1.5, 0.41666666666667
5519, 0.041666666666667, 1.5, 0.45833333333333
5520, 0.083333333333333, 1.5, 0.041666666666667
5521, 0.083333333333333, 1.5, 0.083333333333333
5522, 0.083333333333333, 1.5, 0.125
5523, 0.083333333333333, 1.5, 0.16666666666667
5524, 0.083333333333333, 1.5, 0.20833333333333
5525, 0.083333333333333, 1.5, 0.25
5526, 0.083333333333333, 1.5, 0.29166666666667
5527, 0.083333333333333, 1.5, 0.33333333333333
5528, 0.083333333333333, 1.5, 0.375
5529, 0.083333333333333, 1.5, 0.41666666666667
5530, 0.083333333333333, 1.5, 0.45833333333333
5531, 0.125, 1.5, 0.041666666666667
5532, 0.125, 1.5, 0.083333333333333
5533, 0.125, 1.5, 0.125
5534, 0.125, 1.5, 0.16666666666667
5535, 0.125, 1.5, 0.20833333333333
5536, 0.125, 1.5, 0.25
5537, 0.125, 1.5, 0.29166666666667
5538, 0.125, 1.5, 0.33333333333333
5539, 0.125, 1.5, 0.375
5540, 0.125, 1.5, 0.41666666666667
5541, 0.125, 1.5, 0.45833333333333
5542, 0.16666666666667, 1.5, 0.041666666666667
5543, 0.16666666666667, 1.5, 0.083333333333333
5544, 0.16666666666667, 1.5, 0.125
5545, 0.16666666666667, 1.5, 0.16666666666667
5546, 0.16666666666667, 1.5, 0.20833333333333
5547, 0.16666666666667, 1.5, 0.25
5548, 0.16666666666667, 1.5, 0.29166666666667
5549, 0.16666666666667, 1.5, 0.33333333333333
5550, 0.16666666666667, 1.5, 0.375
5551, 0.16666666666667, 1.5, 0.41666666666667
5552, 0.16666666666667, 1.5, 0.45833333333333
5553, 0.20833333333333, 1.5, 0.041666666666667
5554, 0.20833333333333, 1.5, 0.083333333333333
5555, 0.20833333333333, 1.5, 0.125
5556, 0.20833333333333, 1.5, 0.16666666666667
5557, 0.20833333333333, 1.5, 0.20833333333333
5558, 0.20833333333333, 1.5, 0.25
5559, 0.20833333333333, 1.5, 0.29166666666667
5560, 0.20833333333333, 1.5, 0.33333333333333
5561, 0.20833333333333, 1.5, 0.375
5562, 0.20833333333333, 1.5, 0.41666666666667
5563, 0.20833333333333, 1.5, 0.45833333333333
5564, 0.25, 1.5, 0.041666666666667
5565, 0.25, 1.5, 0.083333333333333
5566, 0.25, 1.5, 0.125
5567, 0.25, 1.5, 0.16666666666667
5568, 0.25, 1.5, 0.20833333333333
5569, 0.25, 1.5, 0.25
5570, 0.25, 1.5, 0.29166666666667
5571, 0.25, 1.5, 0.33333333333333
5572, 0.25, 1.5, 0.375
5573, 0.25, 1.5, 0.41666666666667
5574, 0.25, 1.5, 0.45833333333333
5575, 0.29166666666667, 1.5, 0.041666666666667
5576, 0.29166666666667, 1.5, 0.083333333333333
5577, 0.29166666666667, 1.5, 0.125
5578, 0.29166666666667, 1.5, 0.16666666666667
5579, 0.29166666666667, 1.5, 0.20833333333333
5580, 0.29166666666667, 1.5, 0.25
5581, 0.29166666666667, 1.5, 0.29166666666667
5582, 0.29166666666667, 1.5, 0.33333333333333
5583, 0.29166666666667, 1.5, 0.375
5584, 0.29166666666667, 1.5, 0.41666666666667
5585, 0.29166666666667, 1.5, 0.45833333333333
5586, 0.33333333333333, 1.5, 0.041666666666667
5587, 0.33333333333333, 1.5, 0.083333333333333
5588, 0.33333333333333, 1.5, 0.125
5589, 0.33333333333333, 1.5, 0.16666666666667
5590, 0.33333333333333, 1.5, 0.20833333333333
5591, 0.33333333333333, 1.5, 0.25
5592, 0.33333333333333, 1.5, 0.29166666666667
5593, 0.33333333333333, 1.5, 0.33333333333333
5594, 0.33333333333333, 1.5, 0.375
5595, 0.33333333333333, 1.5, 0.41666666666667
5596, 0.33333333333333, 1.5, 0.45833333333333
5597, 0.375, 1.5, 0.041666666666667
5598, 0.375, 1.5, 0.083333333333333
5599, 0.375, 1.5, 0.125
5600, 0.375, 1.5, 0.16666666666667
5601, 0.375, 1.5, 0.20833333333333
5602, 0.375, 1.5, 0.25
5603, 0.375, 1.5, 0.29166666666667
5604, 0.375, 1.5, 0.33333333333333
5605, 0.375, 1.5, 0.375
5606, 0.375, 1.5, 0.41666666666667
5607, 0.375, 1.5, 0.45833333333333
5608, 0.41666666666667, 1.5, 0.041666666666667
5609, 0.41666666666667, 1.5, 0.083333333333333
5610, 0.41666666666667, 1.5, 0.125
5611, 0.41666666666667, 1.5, 0.16666666666667
5612, 0.41666666666667, 1.5, 0.20833333333333
5613, 0.41666666666667, 1.5, 0.25
5614, 0.41666666666667, 1.5, 0.29166666666667
5615, 0.41666666666667, 1.5, 0.33333333333333
5616, 0.41666666666667, 1.5, 0.375
5617, 0.41666666666667, 1.5, 0.41666666666667
5618, 0.41666666666667, 1.5, 0.45833333333333
5619, 0.45833333333333, 1.5, 0.041666666666667
5620, 0.45833333333333, 1.5, 0.083333333333333
5621, 0.45833333333333, 1.5, 0.125
5622, 0.45833333333333, 1.5, 0.16666666666667
5623, 0.45833333333333, 1.5, 0.20833333333333
5624, 0.45833333333333, 1.5, 0.25
5625, 0.45833333333333, 1.5, 0.29166666666667
5626, 0.45833333333333, 1.5, 0.33333333333333
5627, 0.45833333333333, 1.5, 0.375
5628, 0.45833333333333, 1.5, 0.41666666666667
5629, 0.45833333333333, 1.5, 0.45833333333333
5630, 0.5, 1.5, 0.041666666666667
5631, 0.5, 1.5, 0.083333333333333
5632, 0.5, 1.5, 0.125
5633, 0.5, 1.5, 0.16666666666667
5634, 0.5, 1.5, 0.20833333333333
5635, 0.5, 1.5, 0.25
5636, 0.5, 1.5, 0.29166666666667
5637, 0.5, 1.5, 0.33333333333333
5638, 0.5, 1.5, 0.375
5639, 0.5, 1.5, 0.41666666666667
5640, 0.5, 1.5, 0.45833333333333
5641, 0.54166666666667, 1.5, 0.041666666666667
5642, 0.54166666666667, 1.5, 0.083333333333333
5643, 0.54166666666667, 1.5, 0.125
5644, 0.54166666666667, 1.5, 0.16666666666667
5645, 0.54166666666667, 1.5, 0.20833333333333
5646, 0.54166666666667, 1.5, 0.25
5647, 0.54166666666667, 1.5, 0.29166666666667
5648, 0.54166666666667, 1.5, 0.33333333333333
5649, 0.54166666666667, 1.5, 0.375
5650, 0.54166666666667, 1.5, 0.41666666666667
5651, 0.54166666666667, 1.5, 0.45833333333333
5652, 0.58333333333333, 1.5, 0.041666666666667
5653, 0.58333333333333, 1.5, 0.083333333333333
5654, 0.58333333333333, 1.5, 0.125
5655, 0.58333333333333, 1.5, 0.16666666666667
5656, 0.58333333333333, 1.5, 0.20833333333333
5657, 0.58333333333333, 1.5, 0.25
5658, 0.58333333333333, 1.5, 0.29166666666667
5659, 0.58333333333333, 1.5, 0.33333333333333
5660, 0.58333333333333, 1.5, 0.375
5661, 0.58333333333333, 1.5, 0.41666666666667
5662, 0.58333333333333, 1.5, 0.45833333333333
5663, 0.625, 1.5, 0.041666666666667
5664, 0.625, 1.5, 0.083333333333333
5665, 0.625, 1.5, 0.125
5666, 0.625, 1.5, 0.16666666666667
5667, 0.625, 1.5, 0.20833333333333
5668, 0.625, 1.5, 0.25
5669, 0.625, 1.5, 0.29166666666667
5670, 0.625, 1.5, 0.33333333333333
5671, 0.625, 1.5, 0.375
5672, 0.625, 1.5, 0.41666666666667
5673, 0.625, 1.5, 0.45833333333333
5674, 0.66666666666667, 1.5, 0.041666666666667
5675, 0.66666666666667, 1.5, 0.083333333333333
5676, 0.66666666666667, 1.5, 0.125
5677, 0.66666666666667, 1.5, 0.16666666666667
5678, 0.66666666666667, 1.5, 0.20833333333333
5679, 0.66666666666667, 1.5, 0.25
5680, 0.66666666666667, 1.5, 0.29166666666667
5681, 0.66666666666667, 1.5, 0.33333333333333
5682, 0.66666666666667, 1.5, 0.375
5683, 0.66666666666667, 1.5, 0.41666666666667
5684, 0.66666666666667, 1.5, 0.45833333333333
5685, 0.70833333333333, 1.5, 0.041666666666667
5686, 0.70833333333333, 1.5, 0.083333333333333
5687, 0.70833333333333, 1.5, 0.125
5688, 0.70833333333333, 1.5, 0.16666666666667
5689, 0.70833333333333, 1.5, 0.20833333333333
5690, 0.70833333333333, 1.5, 0.25
5691, 0.70833333333333, 1.5, 0.29166666666667
5692, 0.70833333333333, 1.5, 0.33333333333333
5693, 0.70833333333333, 1.5, 0.375
5694, 0.70833333333333, 1.5, 0.41666666666667
5695, 0.70833333333333, 1.5, 0.45833333333333
5696, 0.75, 1.5, 0.041666666666667
5697, 0.75, 1.5, 0.083333333333333
5698, 0.75, 1.5, 0.125
5699, 0.75, 1.5, 0.16666666666667
5700, 0.75, 1.5, 0.20833333333333
5701, 0.75, 1.5, 0.25
5702, 0.75, 1.5, 0.29166666666667
5703, 0.75, 1.5, 0.33333333333333
5704, 0.75, 1.5, 0.375
5705, 0.75, 1.5, 0.41666666666667
5706, 0.75, 1.5, 0.45833333333333
5707, 0.79166666666667, 1.5, 0.041666666666667
5708, 0.79166666666667, 1.5, 0.083333333333333
5709, 0.79166666666667, 1.5, 0.125
5710, 0.79166666666667, 1.5, 0.16666666666667
5711, 0.79166666666667, 1.5, 0.20833333333333
5712, 0.79166666666667, 1.5, 0.25
5713, 0.79166666666667, 1.5, 0.29166666666667
5714, 0.79166666666667, 1.5, 0.33333333333333
5715, 0.79166666666667, 1.5, 0.375
5716, 0.79166666666667, 1.5, 0.41666666666667
5717, 0.79166666666667, 1.5, 0.45833333333333
5718, 0.83333333333333, 1.5, 0.041666666666667
5719, 0.83333333333333, 1.5, 0.083333333333333
5720, 0.83333333333333, 1.5, 0.125
5721, 0.83333333333333, 1.5, 0.16666666666667
5722, 0.83333333333333, 1.5, 0.20833333333333
5723, 0.83333333333333, 1.5, 0.25
5724, 0.83333333333333, 1.5, 0.29166666666667
5725, 0.83333333333333, 1.5, 0.33333333333333
5726, 0.83333333333333, 1.5, 0.375
5727, 0.83333333333333, 1.5, 0.41666666666667
5728, 0.83333333333333, 1.5, 0.45833333333333
5729, 0.875, 1.5, 0.041666666666667
5730, 0.875, 1.5, 0.083333333333333
5731, 0.875, 1.5, 0.125
5732, 0.875, 1.5, 0.16666666666667
5733, 0.875, 1.5, 0.20833333333333
5734, 0.875, 1.5, 0.25
5735, 0.875, 1.5, 0.29166666666667
5736, 0.875, 1.5, 0.33333333333333
5737, 0.875, 1.5, 0.375
5738, 0.875, 1.5, 0.41666666666667
5739, 0.875, 1.5, 0.45833333333333
5740, 0.91666666666667, 1.5, 0.041666666666667
5741, 0.91666666666667, 1.5, 0.083333333333333
5742, 0.91666666666667, 1.5, 0.125
5743, 0.91666666666667, 1.5, 0.16666666666667
5744, 0.91666666666667, 1.5, 0.20833333333333
5745, 0.91666666666667, 1.5, 0.25
5746, 0.91666666666667, 1.5, 0.29166666666667
5747, 0.91666666666667, 1.5, 0.33333333333333
5748, 0.91666666666667, 1.5, 0.375
5749, 0.91666666666667, 1.5, 0.41666666666667
5750, 0.91666666666667, 1.5, 0.45833333333333
5751, 0.95833333333333, 1.5, 0.041666666666667
5752, 0.95833333333333, 1.5, 0.083333333333333
5753, 0.95833333333333, 1.5, 0.125
5754, 0.95833333333333, 1.5, 0.16666666666667
5755, 0.95833333333333, 1.5, 0.20833333333333
5756, 0.95833333333333, 1.5, 0.25
5757, 0.95833333333333, 1.5, 0.29166666666667
5758, 0.95833333333333, 1.5, 0.33333333333333
5759, 0.95833333333333, 1.5, 0.375
5760, 0.95833333333333, 1.5, 0.41666666666667
5761, 0.95833333333333, 1.5, 0.45833333333333
5762, 1.04, 1.4333333333333, 0.5
5763, 1.08, 1.4333333333333, 0.5
5764, 1.12, 1.4333333333333, 0.5
5765, 1.16, 1.4333333333333, 0.5
5766, 1.04, 1.4666666666667, 0.5
5767, 1.08, 1.4666666666667, 0.5
5768, 1.12, 1.4666666666667, 0.5
5769, 1.16, 1.4666666666667, 0.5
5770, 1.04, 1.4333333333333, 0
5771, 1.08, 1.4333333333333, 0
5772, 1.12, 1.4333333333333, 0
5773, 1.16, 1.4333333333333, 0
5774, 1.04, 1.4666666666667, 0
5775, 1.08, 1.4666666666667, 0
5776, 1.12, 1.4666666666667, 0
5777, 1.16, 1.4666666666667, 0
5778, 1.04, 1.4, 0.041666666666667
5779, 1.08, 1.4, 0.041666666666667
5780, 1.12, 1.4, 0.041666666666667
5781, 1.16, 1.4, 0.041666666666667
5782, 1.04, 1.4, 0.083333333333333
5783, 1.08, 1.4, 0.083333333333333
5784, 1.12, 1.4, 0.083333333333333
5785, 1.16, 1.4, 0.083333333333333
5786, 1.04, 1.4, 0.125
5787, 1.08, 1.4, 0.125
5788, 1.12, 1.4, 0.125
5789, 1.16, 1.4, 0.125
5790, 1.04, 1.4, 0.16666666666667
5791, 1.08, 1.4, 0.16666666666667
5792, 1.12, 1.4, 0.16666666666667
5793, 1.16, 1.4, 0.16666666666667
5794, 1.04, 1.4, 0.20833333333333
5795, 1.08, 1.4, 0.20833333333333
5796, 1.12, 1.4, 0.20833333333333
5797, 1.16, 1.4, 0.20833333333333
5798, 1.04, 1.4, 0.25
5799, 1.08, 1.4, 0.25
5800, 1.12, 1.4, 0.25
5801, 1.16, 1.4, 0.25
5802, 1.04, 1.4, 0.29166666666667
5803, 1.08, 1.4, 0.29166666666667
5804, 1.12, 1.4, 0.29166666666667
5805, 1.16, 1.4, 0.29166666666667
5806, 1.04, 1.4, 0.33333333333333
5807, 1.08, 1.4, 0.33333333333333
5808, 1.12, 1.4, 0.33333333333333
5809, 1.16, 1.4, 0.33333333333333
5810, 1.04, 1.4, 0.375
5811, 1.08, 1.4, 0.375
5812, 1.12, 1.4, 0.375
5813, 1.16, 1.4, 0.375
5814, 1.04, 1.4, 0.41666666666667
5815, 1.08, 1.4, 0.41666666666667
5816, 1.12, 1.4, 0.41666666666667
5817, 1.16, 1.4, 0.41666666666667
5818, 1.04, 1.4, 0.45833333333333
5819, 1.08, 1.4, 0.45833333333333
5820, 1.12, 1.4, 0.45833333333333
5821, 1.16, 1.4, 0.45833333333333
5822, 1.04, 1.5, 0.041666666666667
5823, 1.08, 1.5, 0.041666666666667
5824, 1.12, 1.5, 0.041666666666667
5825, 1.16, 1.5, 0.041666666666667
5826, 1.04, 1.5, 0.083333333333333
5827, 1.08, 1.5, 0.083333333333333
5828, 1.12, 1.5, 0.083333333333333
5829, 1.16, 1.5, 0.083333333333333
5830, 1.04, 1.5, 0.125
5831, 1.08, 1.5, 0.125
5832, 1.12, 1.5, 0.125
5833, 1.16, 1.5, 0.125
5834, 1.04, 1.5, 0.16666666666667
5835, 1.08, 1.5, 0.16666666666667
5836, 1.12, 1.5, 0.16666666666667
5837, 1.16, 1.5, 0.16666666666667
5838, 1.04, 1.5, 0.20833333333333
5839, 1.08, 1.5, 0.20833333333333
5840, 1.12, 1.5, 0.20833333333333
5841, 1.16, 1.5, 0.20833333333333
5842, 1.04, 1.5, 0.25
5843, 1.08, 1.5, 0.25
5844, 1.12, 1.5, 0.25
5845, 1.16, 1.5, 0.25
5846, 1.04, 1.5, 0.29166666666667
5847, 1.08, 1.5, 0.29166666666667
5848, 1.12, 1.5, 0.29166666666667
5849, 1.16, 1.5, 0.29166666666667
5850, 1.04, 1.5, 0.33333333333333
5851, 1.08, 1.5, 0.33333333333333
5852, 1.12, 1.5, 0.33333333333333
5853, 1.16, 1.5, 0.33333333333333
5854, 1.04, 1.5, 0.375
5855, 1.08, 1.5, 0.375
5856, 1.12, 1.5, 0.375
5857, 1.16, 1.5, 0.375
5858, 1.04, 1.5, 0.41666666666667
5859, 1.08, 1.5, 0.41666666666667
5860, 1.12, 1.5, 0.41666666666667
5861, 1.16, 1.5, 0.41666666666667
5862, 1.04, 1.5, 0.45833333333333
5863, 1.08, 1.5, 0.45833333333333
5864, 1.12, 1.5, 0.45833333333333
5865, 1.16, 1.5, 0.45833333333333
5866, 1.2, 1.4333333333333, 0.041666666666667
5867, 1.2, 1.4666666666667, 0.041666666666667
5868, 1.2, 1.4333333333333, 0.083333333333333
5869, 1.2, 1.4666666666667, 0.083333333333333
5870, 1.2, 1.4333333333333, 0.125
5871, 1.2, 1.4666666666667, 0.125
5872, 1.2, 1.4333333333333, 0.16666666666667
5873, 1.2, 1.4666666666667, 0.16666666666667
5874, 1.2, 1.4333333333333, 0.20833333333333
5875, 1.2, 1.4666666666667, 0.20833333333333
5876, 1.2, 1.4333333333333, 0.25
5877, 1.2, 1.4666666666667, 0.25
5878, 1.2, 1.4333333333333, 0.29166666666667
5879, 1.2, 1.4666666666667, 0.29166666666667
5880, 1.2, 1.4333333333333, 0.33333333333333
5881, 1.2, 1.4666666666667, 0.33333333333333
5882, 1.2, 1.4333333333333, 0.375
5883, 1.2, 1.4666666666667, 0.375
5884, 1.2, 1.4333333333333, 0.41666666666667
5885, 1.2, 1.4666666666667, 0.41666666666667
5886, 1.2, 1.4333333333333, 0.45833333333333
5887, 1.2, 1.4666666666667, 0.45833333333333
5888, 1.2416666666667, 1.4333333333333, 0.5
5889, 1.2833333333333, 1.4333333333333, 0.5
5890, 1.325, 1.4333333333333, 0.5
5891, 1.3666666666667, 1.4333333333333, 0.5
5892, 1.4083333333333, 1.4333333333333, 0.5
5893, 1.45, 1.4333333333333, 0.5
5894, 1.4916666666667, 1.4333333333333, 0.5
5895, 1.5333333333333, 1.4333333333333, 0.5
5896, 1.575, 1.4333333333333, 0.5
5897, 1.6166666666667, 1.4333333333333, 0.5
5898, 1.6583333333333, 1.4333333333333, 0.5
5899, 1.7, 1.4333333333333, 0.5
5900, 1.7416666666667, 1.4333333333333, 0.5
5901, 1.7833333333333, 1.4333333333333, 0.5
5902, 1.825, 1.4333333333333, 0.5
5903, 1.8666666666667, 1.4333333333333, 0.5
5904, 1.9083333333333, 1.4333333333333, 0.5
5905, 1.95, 1.4333333333333, 0.5
5906, 1.9916666666667, 1.4333333333333, 0.5
5907, 2.0333333333333, 1.4333333333333, 0.5
5908, 2.075, 1.4333333333333, 0.5
5909, 2.1166666666667, 1.4333333333333, 0.5
5910, 2.1583333333333, 1.4333333333333, 0.5
5911, 1.2416666666667, 1.4666666666667, 0.5
5912, 1.2833333333333, 1.4666666666667, 0.5
5913, 1.325, 1.4666666666667, 0.5
5914, 1.3666666666667, 1.4666666666667, 0.5
5915, 1.4083333333333, 1.4666666666667, 0.5
5916, 1.45, 1.4666666666667, 0.5
5917, 1.4916666666667, 1.4666666666667, 0.5
5918, 1.5333333333333, 1.4666666666667, 0.5
5919, 1.575, 1.4666666666667, 0.5
5920, 1.6166666666667, 1.4666666666667, 0.5
5921, 1.6583333333333, 1.4666666666667, 0.5
5922, 1.7, 1.4666666666667, 0.5
5923, 1.7416666666667, 1.4666666666667, 0.5
5924, 1.7833333333333, 1.4666666666667, 0.5
5925, 1.825, 1.4666666666667, 0.5
5926, 1.8666666666667, 1.4666666666667, 0.5
5927, 1.9083333333333, 1.4666666666667, 0.5
5928, 1.95, 1.4666666666667, 0.5
5929, 1.9916666666667, 1.4666666666667, 0.5
5930, 2.0333333333333, 1.4666666666667, 0.5
5931, 2.075, 1.4666666666667, 0.5
5932, 2.1166666666667, 1.4666666666667, 0.5
5933, 2.1583333333333, 1.4666666666667, 0.5
5934, 1.2416666666667, 1.4333333333333, 0
5935, 1.2833333333333, 1.4333333333333, 0
5936, 1.325, 1.4333333333333, 0
5937, 1.3666666666667, 1.4333333333333, 0
5938, 1.4083333333333, 1.4333333333333, 0
5939, 1.45, 1.4333333333333, 0
5940, 1.4916666666667, 1.4333333333333, 0
5941, 1.5333333333333, 1.4333333333333, 0
5942, 1.575, 1.4333333333333, 0
5943, 1.6166666666667, 1.4333333333333, 0
5944, 1.6583333333333, 1.4333333333333, 0
5945, 1.7, 1.4333333333333, 0
5946, 1.7416666666667, 1.4333333333333, 0
5947, 1.7833333333333, 1.4333333333333, 0
5948, 1.825, 1.4333333333333, 0
5949, 1.8666666666667, 1.4333333333333, 0
5950, 1.9083333333333, 1.4333333333333, 0
5951, 1.95, 1.4333333333333, 0
5952, 1.9916666666667, 1.4333333333333, 0
5953, 2.0333333333333, 1.4333333333333, 0
5954, 2.075, 1.4333333333333, 0
5955, 2.1166666666667, 1.4333333333333, 0
5956, 2.1583333333333, 1.4333333333333, 0
5957, 1.2416666666667, 1.4666666666667, 0
5958, 1.2833333333333, 1.4666666666667, 0
5959, 1.325, 1.4666666666667, 0
5960, 1.3666666666667, 1.4666666666667, 0
5961, 1.4083333333333, 1.4666666666667, 0
5962, 1.45, 1.4666666666667, 0
5963, 1.4916666666667, 1.4666666666667, 0
5964, 1.5333333333333, 1.4666666666667, 0
5965, 1.575, 1.4666666666667, 0
5966, 1.6166666666667, 1.4666666666667, 0
5967, 1.6583333333333, 1.4666666666667, 0
5968, 1.7, 1.4666666666667, 0
5969, 1.7416666666667, 1.4666666666667, 0
5970, 1.7833333333333, 1.4666666666667, 0
5971, 1.825, 1.4666666666667, 0
5972, 1.8666666666667, 1.4666666666667, 0
5973, 1.9083333333333, 1.4666666666667, 0
5974, 1.95, 1.4666666666667, 0
5975, 1.9916666666667, 1.4666666666667, 0
5976, 2.0333333333333, 1.4666666666667, 0
5977, 2.075, 1.4666666666667, 0
5978, 2.1166666666667, 1.4666666666667, 0
5979, 2.1583333333333, 1.4666666666667, 0
5980, 1.2416666666667, 1.4, 0.041666666666667
5981, 1.2833333333333, 1.4, 0.041666666666667
5982, 1.325, 1.4, 0.041666666666667
5983, 1.3666666666667, 1.4, 0.041666666666667
5984, 1.4083333333333, 1.4, 0.041666666666667
5985, 1.45, 1.4, 0.041666666666667
5986, 1.4916666666667, 1.4, 0.041666666666667
5987, 1.5333333333333, 1.4, 0.041666666666667
5988, 1.575, 1.4, 0.041666666666667
5989, 1.6166666666667, 1.4, 0.041666666666667
5990, 1.6583333333333, 1.4, 0.041666666666667
5991, 1.7, 1.4, 0.041666666666667
5992, 1.7416666666667, 1.4, 0.041666666666667
5993, 1.7833333333333, 1.4, 0.041666666666667
5994, 1.825, 1.4, 0.041666666666667
5995, 1.8666666666667, 1.4, 0.041666666666667
5996, 1.9083333333333, 1.4, 0.041666666666667
5997, 1.95, 1.4, 0.041666666666667
5998, 1.9916666666667, 1.4, 0.041666666666667
5999, 2.0333333333333, 1.4, 0.041666666666667
6000, 2.075, 1.4, 0.041666666666667
6001, 2.1166666666667, 1.4, 0.041666666666667
6002, 2.1583333333333, 1.4, 0.041666666666667
6003, 1.2416666666667, 1.4, 0.083333333333333
6004, 1.2833333333333, 1.4, 0.083333333333333
6005, 1.325, 1.4, 0.083333333333333
6006, 1.3666666666667, 1.4, 0.083333333333333
6007, 1.4083333333333, 1.4, 0.083333333333333
6008, 1.45, 1.4, 0.083333333333333
6009, 1.4916666666667, 1.4, 0.083333333333333
6010, 1.5333333333333, 1.4, 0.083333333333333
6011, 1.575, 1.4, 0.083333333333333
6012, 1.6166666666667, 1.4, 0.083333333333333
6013, 1.6583333333333, 1.4, 0.083333333333333
6014, 1.7, 1.4, 0.083333333333333
6015, 1.7416666666667, 1.4, 0.083333333333333
6016, 1.7833333333333, 1.4, 0.083333333333333
6017, 1.825, 1.4, 0.083333333333333
6018, 1.8666666666667, 1.4, 0.083333333333333
6019, 1.9083333333333, 1.4, 0.083333333333333
6020, 1.95, 1.4, 0.083333333333333
6021, 1.9916666666667, 1.4, 0.083333333333333
6022, 2.0333333333333, 1.4, 0.083333333333333
6023, 2.075, 1.4, 0.083333333333333
6024, 2.1166666666667, 1.4, 0.083333333333333
6025, 2.1583333333333, 1.4, 0.083333333333333
6026, 1.2416666666667, 1.4, 0.125
6027, 1.2833333333333, 1.4, 0.125
6028, 1.325, 1.4, 0.125
6029, 1.3666666666667, 1.4, 0.125
6030, 1.4083333333333, 1.4, 0.125
6031, 1.45, 1.4, 0.125
6032, 1.4916666666667, 1.4, 0.125
6033, 1.5333333333333, 1.4, 0.125
6034, 1.575, 1.4, 0.125
6035, 1.6166666666667, 1.4, 0.125
6036, 1.6583333333333, 1.4, 0.125
6037, 1.7, 1.4, 0.125
6038, 1.7416666666667, 1.4, 0.125
6039, 1.7833333333333, 1.4, 0.125
6040, 1.825, 1.4, 0.125
6041, 1.8666666666667, 1.4, 0.125
6042, 1.9083333333333, 1.4, 0.125
6043, 1.95, 1.4, 0.125
6044, 1.9916666666667, 1.4, 0.125
6045, 2.0333333333333, 1.4, 0.125
6046, 2.075, 1.4, 0.125
6047, 2.1166666666667, 1.4, 0.125
6048, 2.1583333333333, 1.4, 0.125
6049, 1.2416666666667, 1.4, 0.16666666666667
6050, 1.2833333333333, 1.4, 0.16666666666667
6051, 1.325, 1.4, 0.16666666666667
6052, 1.3666666666667, 1.4, 0.16666666666667
6053, 1.4083333333333, 1.4, 0.16666666666667
6054, 1.45, 1.4, 0.16666666666667
6055, 1.4916666666667, 1.4, 0.16666666666667
6056, 1.5333333333333, 1.4, 0.16666666666667
6057, 1.575, 1.4, 0.16666666666667
6058, 1.6166666666667, 1.4, 0.16666666666667
6059, 1.6583333333333, 1.4, 0.16666666666667
6060, 1.7, 1.4, 0.16666666666667
6061, 1.7416666666667, 1.4, 0.16666666666667
6062, 1.7833333333333, 1.4, 0.16666666666667
6063, 1.825, 1.4, 0.16666666666667
6064, 1.8666666666667, 1.4, 0.16666666666667
6065, 1.9083333333333, 1.4, 0.16666666666667
6066, 1.95, 1.4, 0.16666666666667
6067, 1.9916666666667, 1.4, 0.16666666666667
6068, 2.0333333333333, 1.4, 0.16666666666667
6069, 2.075, 1.4, 0.16666666666667
6070, 2.1166666666667, 1.4, 0.16666666666667
6071, 2.1583333333333, 1.4, 0.16666666666667
6072, 1.2416666666667, 1.4, 0.20833333333333
6073, 1.2833333333333, 1.4, 0.20833333333333
6074, 1.325, 1.4, 0.20833333333333
6075, 1.3666666666667, 1.4, 0.20833333333333
6076, 1.4083333333333, 1.4, 0.20833333333333
6077, 1.45, 1.4, 0.20833333333333
6078, 1.4916666666667, 1.4, 0.20833333333333
6079, 1.5333333333333, 1.4, 0.20833333333333
6080, 1.575, 1.4, 0.20833333333333
6081, 1.6166666666667, 1.4, 0.20833333333333
6082, 1.6583333333333, 1.4, 0.20833333333333
6083, 1.7, 1.4, 0.20833333333333
6084, 1.7416666666667, 1.4, 0.20833333333333
6085, 1.7833333333333, 1.4, 0.20833333333333
6086, 1.825, 1.4, 0.20833333333333
6087, 1.8666666666667, 1.4, 0.20833333333333
6088, 1.9083333333333, 1.4, 0.20833333333333
6089, 1.95, 1.4, 0.20833333333333
6090, 1.9916666666667, 1.4, 0.20833333333333
6091, 2.0333333333333, 1.4, 0.20833333333333
6092, 2.075, 1.4, 0.20833333333333
6093, 2.1166666666667, 1.4, 0.20833333333333
6094, 2.1583333333333, 1.4, 0.20833333333333
6095, 1.2416666666667, 1.4, 0.25
6096, 1.2833333333333, 1.4, 0.25
6097, 1.325, 1.4, 0.25
6098, 1.3666666666667, 1.4, 0.25
6099, 1.4083333333333, 1.4, 0.25
6100, 1.45, 1.4, 0.25
6101, 1.4916666666667, 1.4, 0.25
6102, 1.5333333333333, 1.4, 0.25
6103, 1.575, 1.4, 0.25
6104, 1.6166666666667, 1.4, 0.25
6105, 1.6583333333333, 1.4, 0.25
6106, 1.7, 1.4, 0.25
6107, 1.7416666666667, 1.4, 0.25
6108, 1.7833333333333, 1.4, 0.25
6109, 1.825, 1.4, 0.25
6110, 1.8666666666667, 1.4, 0.25
6111, 1.9083333333333, 1.4, 0.25
6112, 1.95, 1.4, 0.25
6113, 1.9916666666667, 1.4, 0.25
6114, 2.0333333333333, 1.4, 0.25
6115, 2.075, 1.4, 0.25
6116, 2.1166666666667, 1.4, 0.25
6117, 2.1583333333333, 1.4, 0.25
6118, 1.2416666666667, 1.4, 0.29166666666667
6119, 1.2833333333333, 1.4, 0.29166666666667
6120, 1.325, 1.4, 0.29166666666667
6121, 1.3666666666667, 1.4, 0.29166666666667
6122, 1.4083333333333, 1.4, 0.29166666666667
6123, 1.45, 1.4, 0.29166666666667
6124, 1.4916666666667, 1.4, 0.29166666666667
6125, 1.5333333333333, 1.4, 0.29166666666667
6126, 1.575, 1.4, 0.29166666666667
6127, 1.6166666666667, 1.4, 0.29166666666667
6128, 1.6583333333333, 1.4, 0.29166666666667
6129, 1.7, 1.4, 0.29166666666667
6130, 1.7416666666667, 1.4, 0.29166666666667
6131, 1.7833333333333, 1.4, 0.29166666666667
6132, 1.825, 1.4, 0.29166666666667
6133, 1.8666666666667, 1.4, 0.29166666666667
6134, 1.9083333333333, 1.4, 0.29166666666667
6135, 1.95, 1.4, 0.29166666666667
6136, 1.9916666666667, 1.4, 0.29166666666667
6137, 2.0333333333333, 1.4, 0.29166666666667
6138, 2.075, 1.4, 0.29166666666667
6139, 2.1166666666667, 1.4, 0.29166666666667
6140, 2.1583333333333, 1.4, 0.29166666666667
6141, 1.2416666666667, 1.4, 0.33333333333333
6142, 1.2833333333333, 1.4, 0.33333333333333
6143, 1.325, 1.4, 0.33333333333333
6144, 1.3666666666667, 1.4, 0.33333333333333
6145, 1.4083333333333, 1.4, 0.33333333333333
6146, 1.45, 1.4, 0.33333333333333
6147, 1.4916666666667, 1.4, 0.33333333333333
6148, 1.5333333333333, 1.4, 0.33333333333333
6149, 1.575, 1.4, 0.33333333333333
6150, 1.6166666666667, 1.4, 0.33333333333333
6151, 1.6583333333333, 1.4, 0.33333333333333
6152, 1.7, 1.4, 0.33333333333333
6153, 1.7416666666667, 1.4, 0.33333333333333
6154, 1.7833333333333, 1.4, 0.33333333333333
6155, 1.825, 1.4, 0.33333333333333
6156, 1.8666666666667, 1.4, 0.33333333333333
6157, 1.9083333333333, 1.4, 0.33333333333333
6158, 1.95, 1.4, 0.33333333333333
6159, 1.9916666666667, 1.4, 0.33333333333333
6160, 2.0333333333333, 1.4, 0.33333333333333
6161, 2.075, 1.4, 0.33333333333333
6162, 2.1166666666667, 1.4, 0.33333333333333
6163, 2.1583333333333, 1.4, 0.33333333333333
6164, 1.2416666666667, 1.4, 0.375
6165, 1.2833333333333, 1.4, 0.375
6166, 1.325, 1.4, 0.375
6167, 1.3666666666667, 1.4, 0.375
6168, 1.4083333333333, 1.4, 0.375
6169, 1.45, 1.4, 0.375
6170, 1.4916666666667, 1.4, 0.375
6171, 1.5333333333333, 1.4, 0.375
6172, 1.575, 1.4, 0.375
6173, 1.6166666666667, 1.4, 0.375
6174, 1.6583333333333, 1.4, 0.375
6175, 1.7, 1.4, 0.375
6176, 1.7416666666667, 1.4, 0.375
6177, 1.7833333333333, 1.4, 0.375
6178, 1.825, 1.4, 0.375
6179, 1.8666666666667, 1.4, 0.375
6180, 1.9083333333333, 1.4, 0.375
6181, 1.95, 1.4, 0.375
6182, 1.9916666666667, 1.4, 0.375
6183, 2.0333333333333, 1.4, 0.375
6184, 2.075, 1.4, 0.375
6185, 2.1166666666667, 1.4, 0.375
6186, 2.1583333333333, 1.4, 0.375
6187, 1.2416666666667, 1.4, 0.41666666666667
6188, 1.2833333333333, 1.4, 0.41666666666667
6189, 1.325, 1.4, 0.41666666666667
6190, 1.3666666666667, 1.4, 0.41666666666667
6191, 1.4083333333333, 1.4, 0.41666666666667
6192, 1.45, 1.4, 0.41666666666667
6193, 1.4916666666667, 1.4, 0.41666666666667
6194, 1.5333333333333, 1.4, 0.41666666666667
6195, 1.575, 1.4, 0.41666666666667
6196, 1.6166666666667, 1.4, 0.41666666666667
6197, 1.6583333333333, 1.4, 0.41666666666667
6198, 1.7, 1.4, 0.41666666666667
6199, 1.7416666666667, 1.4, 0.41666666666667
6200, 1.7833333333333, 1.4, 0.41666666666667
6201, 1.825, 1.4, 0.41666666666667
6202, 1.8666666666667, 1.4, 0.41666666666667
6203, 1.9083333333333, 1.4, 0.41666666666667
6204, 1.95, 1.4, 0.41666666666667
6205, 1.9916666666667, 1.4, 0.41666666666667
6206, 2.0333333333333, 1.4, 0.41666666666667
6207, 2.075, 1.4, 0.41666666666667
6208, 2.1166666666667, 1.4, 0.41666666666667
6209, 2.1583333333333, 1.4, 0.41666666666667
6210, 1.2416666666667, 1.4, 0.45833333333333
6211, 1.2833333333333, 1.4, 0.45833333333333
6212, 1.325, 1.4, 0.45833333333333
6213, 1.3666666666667, 1.4, 0.45833333333333
6214, 1.4083333333333, 1.4, 0.45833333333333
6215, 1.45, 1.4, 0.45833333333333
6216, 1.4916666666667, 1.4, 0.45833333333333
6217, 1.5333333333333, 1.4, 0.45833333333333
6218, 1.575, 1.4, 0.45833333333333
6219, 1.6166666666667, 1.4, 0.45833333333333
6220, 1.6583333333333, 1.4, 0.45833333333333
6221, 1.7, 1.4, 0.45833333333333
6222, 1.7416666666667, 1.4, 0.45833333333333
6223, 1.7833333333333, 1.4, 0.45833333333333
6224, 1.825, 1.4, 0.45833333333333
6225, 1.8666666666667, 1.4, 0.45833333333333
6226, 1.9083333333333, 1.4, 0.45833333333333
6227, 1.95, 1.4, 0.45833333333333
6228, 1.9916666666667, 1.4, 0.45833333333333
6229, 2.0333333333333, 1.4, 0.45833333333333
6230, 2.075, 1.4, 0.45833333333333
6231, 2.1166666666667, 1.4, 0.45833333333333
6232, 2.1583333333333, 1.4, 0.45833333333333
6233, 1.2416666666667, 1.5, 0.041666666666667
6234, 1.2833333333333, 1.5, 0.041666666666667
6235, 1.325, 1.5, 0.041666666666667
6236, 1.3666666666667, 1.5, 0.041666666666667
6237, 1.4083333333333, 1.5, 0.041666666666667
6238, 1.45, 1.5, 0.041666666666667
6239, 1.4916666666667, 1.5, 0.041666666666667
6240, 1.5333333333333, 1.5, 0.041666666666667
6241, 1.575, 1.5, 0.041666666666667
6242, 1.6166666666667, 1.5, 0.041666666666667
6243, 1.6583333333333, 1.5, 0.041666666666667
6244, 1.7, 1.5, 0.041666666666667
6245, 1.7416666666667, 1.5, 0.041666666666667
6246, 1.7833333333333, 1.5, 0.041666666666667
6247, 1.825, 1.5, 0.041666666666667
6248, 1.8666666666667, 1.5, 0.041666666666667
6249, 1.9083333333333, 1.5, 0.041666666666667
6250, 1.95, 1.5, 0.041666666666667
6251, 1.9916666666667, 1.5, 0.041666666666667
6252, 2.0333333333333, 1.5, 0.041666666666667
6253, 2.075, 1.5, 0.041666666666667
6254, 2.1166666666667, 1.5, 0.041666666666667
6255, 2.1583333333333, 1.5, 0.041666666666667
6256, 1.2416666666667, 1.5, 0.083333333333333
6257, 1.2833333333333, 1.5, 0.083333333333333
6258, 1.325, 1.5, 0.083333333333333
6259, 1.3666666666667, 1.5, 0.083333333333333
6260, 1.4083333333333, 1.5, 0.083333333333333
6261, 1.45, 1.5, 0.083333333333333
6262, 1.4916666666667, 1.5, 0.083333333333333
6263, 1.5333333333333, 1.5, 0.083333333333333
6264, 1.575, 1.5, 0.083333333333333
6265, 1.6166666666667, 1.5, 0.083333333333333
6266, 1.6583333333333, 1.5, 0.083333333333333
6267, 1.7, 1.5, 0.083333333333333
6268, 1.7416666666667, 1.5, 0.083333333333333
6269, 1.7833333333333, 1.5, 0.083333333333333
6270, 1.825, 1.5, 0.083333333333333
6271, 1.8666666666667, 1.5, 0.083333333333333
6272, 1.9083333333333, 1.5, 0.083333333333333
6273, 1.95, 1.5, 0.083333333333333
6274, 1.9916666666667, 1.5, 0.083333333333333
6275, 2.0333333333333, 1.5, 0.083333333333333
6276, 2.075, 1.5, 0.083333333333333
6277, 2.1166666666667, 1.5, 0.083333333333333
6278, 2.1583333333333, 1.5, 0.083333333333333
6279, 1.2416666666667, 1.5, 0.125
6280, 1.2833333333333, 1.5, 0.125
6281, 1.325, 1.5, 0.125
6282, 1.3666666666667, 1.5, 0.125
6283, 1.4083333333333, 1.5, 0.125
6284, 1.45, 1.5, 0.125
6285, 1.4916666666667, 1.5, 0.125
6286, 1.5333333333333, 1.5, 0.125
6287, 1.575, 1.5, 0.125
6288, 1.6166666666667, 1.5, 0.125
6289, 1.6583333333333, 1.5, 0.125
6290, 1.7, 1.5, 0.125
6291, 1.7416666666667, 1.5, 0.125
6292, 1.7833333333333, 1.5, 0.125
6293, 1.825, 1.5, 0.125
6294, 1.8666666666667, 1.5, 0.125
6295, 1.9083333333333, 1.5, 0.125
6296, 1.95, 1.5, 0.125
6297, 1.9916666666667, 1.5, 0.125
6298, 2.0333333333333, 1.5, 0.125
6299, 2.075, 1.5, 0.125
6300, 2.1166666666667, 1.5, 0.125
6301, 2.1583333333333, 1.5, 0.125
6302, 1.2416666666667, 1.5, 0.16666666666667
