49445, 0.54166666666667, -0.18, 0.083333333333333
49446, 0.54166666666667, -0.02, 0.125
49447, 0.54166666666667, -0.04, 0.10416666666667
49448, 0.52083333333333, -0.04, 0.125
49449, 0.54166666666667, -0.06, 0.125
49450, 0.54166666666667, -0.08, 0.10416666666667
49451, 0.52083333333333, -0.08, 0.125
49452, 0.54166666666667, -0.1, 0.125
49453, 0.54166666666667, -0.12, 0.10416666666667
49454, 0.52083333333333, -0.12, 0.125
49455, 0.54166666666667, -0.14, 0.125
49456, 0.54166666666667, -0.16, 0.10416666666667
49457, 0.52083333333333, -0.16, 0.125
49458, 0.54166666666667, -0.18, 0.125
49459, 0.54166666666667, -0.02, 0.16666666666667
49460, 0.54166666666667, -0.04, 0.14583333333333
49461, 0.52083333333333, -0.04, 0.16666666666667
49462, 0.54166666666667, -0.06, 0.16666666666667
49463, 0.54166666666667, -0.08, 0.14583333333333
49464, 0.52083333333333, -0.08, 0.16666666666667
49465, 0.54166666666667, -0.1, 0.16666666666667
49466, 0.54166666666667, -0.12, 0.14583333333333
49467, 0.52083333333333, -0.12, 0.16666666666667
49468, 0.54166666666667, -0.14, 0.16666666666667
49469, 0.54166666666667, -0.16, 0.14583333333333
49470, 0.52083333333333, -0.16, 0.16666666666667
49471, 0.54166666666667, -0.18, 0.16666666666667
49472, 0.54166666666667, -0.02, 0.20833333333333
49473, 0.54166666666667, -0.04, 0.1875
49474, 0.52083333333333, -0.04, 0.20833333333333
49475, 0.54166666666667, -0.06, 0.20833333333333
49476, 0.54166666666667, -0.08, 0.1875
49477, 0.52083333333333, -0.08, 0.20833333333333
49478, 0.54166666666667, -0.1, 0.20833333333333
49479, 0.54166666666667, -0.12, 0.1875
49480, 0.52083333333333, -0.12, 0.20833333333333
49481, 0.54166666666667, -0.14, 0.20833333333333
49482, 0.54166666666667, -0.16, 0.1875
49483, 0.52083333333333, -0.16, 0.20833333333333
49484, 0.54166666666667, -0.18, 0.20833333333333
49485, 0.54166666666667, -0.02, 0.25
49486, 0.54166666666667, -0.04, 0.22916666666667
49487, 0.52083333333333, -0.04, 0.25
49488, 0.54166666666667, -0.06, 0.25
49489, 0.54166666666667, -0.08, 0.22916666666667
49490, 0.52083333333333, -0.08, 0.25
49491, 0.54166666666667, -0.1, 0.25
49492, 0.54166666666667, -0.12, 0.22916666666667
49493, 0.52083333333333, -0.12, 0.25
49494, 0.54166666666667, -0.14, 0.25
49495, 0.54166666666667, -0.16, 0.22916666666667
49496, 0.52083333333333, -0.16, 0.25
49497, 0.54166666666667, -0.18, 0.25
49498, 0.54166666666667, -0.02, 0.29166666666667
49499, 0.54166666666667, -0.04, 0.27083333333333
49500, 0.52083333333333, -0.04, 0.29166666666667
49501, 0.54166666666667, -0.06, 0.29166666666667
49502, 0.54166666666667, -0.08, 0.27083333333333
49503, 0.52083333333333, -0.08, 0.29166666666667
49504, 0.54166666666667, -0.1, 0.29166666666667
49505, 0.54166666666667, -0.12, 0.27083333333333
49506, 0.52083333333333, -0.12, 0.29166666666667
49507, 0.54166666666667, -0.14, 0.29166666666667
49508, 0.54166666666667, -0.16, 0.27083333333333
49509, 0.52083333333333, -0.16, 0.29166666666667
49510, 0.54166666666667, -0.18, 0.29166666666667
49511, 0.54166666666667, -0.02, 0.33333333333333
49512, 0.54166666666667, -0.04, 0.3125
49513, 0.52083333333333, -0.04, 0.33333333333333
49514, 0.54166666666667, -0.06, 0.33333333333333
49515, 0.54166666666667, -0.08, 0.3125
49516, 0.52083333333333, -0.08, 0.33333333333333
49517, 0.54166666666667, -0.1, 0.33333333333333
49518, 0.54166666666667, -0.12, 0.3125
49519, 0.52083333333333, -0.12, 0.33333333333333
49520, 0.54166666666667, -0.14, 0.33333333333333
49521, 0.54166666666667, -0.16, 0.3125
49522, 0.52083333333333, -0.16, 0.33333333333333
49523, 0.54166666666667, -0.18, 0.33333333333333
49524, 0.54166666666667, -0.02, 0.375
49525, 0.54166666666667, -0.04, 0.35416666666667
49526, 0.52083333333333, -0.04, 0.375
49527, 0.54166666666667, -0.06, 0.375
49528, 0.54166666666667, -0.08, 0.35416666666667
49529, 0.52083333333333, -0.08, 0.375
49530, 0.54166666666667, -0.1, 0.375
49531, 0.54166666666667, -0.12, 0.35416666666667
49532, 0.52083333333333, -0.12, 0.375
49533, 0.54166666666667, -0.14, 0.375
49534, 0.54166666666667, -0.16, 0.35416666666667
49535, 0.52083333333333, -0.16, 0.375
49536, 0.54166666666667, -0.18, 0.375
49537, 0.54166666666667, -0.02, 0.41666666666667
49538, 0.54166666666667, -0.04, 0.39583333333333
49539, 0.52083333333333, -0.04, 0.41666666666667
49540, 0.54166666666667, -0.06, 0.41666666666667
49541, 0.54166666666667, -0.08, 0.39583333333333
49542, 0.52083333333333, -0.08, 0.41666666666667
49543, 0.54166666666667, -0.1, 0.41666666666667
49544, 0.54166666666667, -0.12, 0.39583333333333
49545, 0.52083333333333, -0.12, 0.41666666666667
49546, 0.54166666666667, -0.14, 0.41666666666667
49547, 0.54166666666667, -0.16, 0.39583333333333
49548, 0.52083333333333, -0.16, 0.41666666666667
49549, 0.54166666666667, -0.18, 0.41666666666667
49550, 0.54166666666667, -0.02, 0.45833333333333
49551, 0.54166666666667, -0.04, 0.4375
49552, 0.52083333333333, -0.04, 0.45833333333333
49553, 0.54166666666667, -0.06, 0.45833333333333
49554, 0.54166666666667, -0.08, 0.4375
49555, 0.52083333333333, -0.08, 0.45833333333333
49556, 0.54166666666667, -0.1, 0.45833333333333
49557, 0.54166666666667, -0.12, 0.4375
49558, 0.52083333333333, -0.12, 0.45833333333333
49559, 0.54166666666667, -0.14, 0.45833333333333
49560, 0.54166666666667, -0.16, 0.4375
49561, 0.52083333333333, -0.16, 0.45833333333333
49562, 0.54166666666667, -0.18, 0.45833333333333
49563, 0.54166666666667, -0.04, 0.47916666666667
49564, 0.54166666666667, -0.08, 0.47916666666667
49565, 0.54166666666667, -0.12, 0.47916666666667
49566, 0.54166666666667, -0.16, 0.47916666666667
49567, 0.58333333333333, -0.02, 0.041666666666667
49568, 0.58333333333333, -0.04, 0.020833333333333
49569, 0.5625, -0.04, 0.041666666666667
49570, 0.58333333333333, -0.06, 0.041666666666667
49571, 0.58333333333333, -0.08, 0.020833333333333
49572, 0.5625, -0.08, 0.041666666666667
49573, 0.58333333333333, -0.1, 0.041666666666667
49574, 0.58333333333333, -0.12, 0.020833333333333
49575, 0.5625, -0.12, 0.041666666666667
49576, 0.58333333333333, -0.14, 0.041666666666667
49577, 0.58333333333333, -0.16, 0.020833333333333
49578, 0.5625, -0.16, 0.041666666666667
49579, 0.58333333333333, -0.18, 0.041666666666667
49580, 0.58333333333333, -0.02, 0.083333333333333
49581, 0.58333333333333, -0.04, 0.0625
49582, 0.5625, -0.04, 0.083333333333333
49583, 0.58333333333333, -0.06, 0.083333333333333
49584, 0.58333333333333, -0.08, 0.0625
49585, 0.5625, -0.08, 0.083333333333333
49586, 0.58333333333333, -0.1, 0.083333333333333
49587, 0.58333333333333, -0.12, 0.0625
49588, 0.5625, -0.12, 0.083333333333333
49589, 0.58333333333333, -0.14, 0.083333333333333
49590, 0.58333333333333, -0.16, 0.0625
49591, 0.5625, -0.16, 0.083333333333333
49592, 0.58333333333333, -0.18, 0.083333333333333
49593, 0.58333333333333, -0.02, 0.125
49594, 0.58333333333333, -0.04, 0.10416666666667
49595, 0.5625, -0.04, 0.125
49596, 0.58333333333333, -0.06, 0.125
49597, 0.58333333333333, -0.08, 0.10416666666667
49598, 0.5625, -0.08, 0.125
49599, 0.58333333333333, -0.1, 0.125
49600, 0.58333333333333, -0.12, 0.10416666666667
49601, 0.5625, -0.12, 0.125
49602, 0.58333333333333, -0.14, 0.125
49603, 0.58333333333333, -0.16, 0.10416666666667
49604, 0.5625, -0.16, 0.125
49605, 0.58333333333333, -0.18, 0.125
49606, 0.58333333333333, -0.02, 0.16666666666667
49607, 0.58333333333333, -0.04, 0.14583333333333
49608, 0.5625, -0.04, 0.16666666666667
49609, 0.58333333333333, -0.06, 0.16666666666667
49610, 0.58333333333333, -0.08, 0.14583333333333
49611, 0.5625, -0.08, 0.16666666666667
49612, 0.58333333333333, -0.1, 0.16666666666667
49613, 0.58333333333333, -0.12, 0.14583333333333
49614, 0.5625, -0.12, 0.16666666666667
49615, 0.58333333333333, -0.14, 0.16666666666667
49616, 0.58333333333333, -0.16, 0.14583333333333
49617, 0.5625, -0.16, 0.16666666666667
49618, 0.58333333333333, -0.18, 0.16666666666667
49619, 0.58333333333333, -0.02, 0.20833333333333
49620, 0.58333333333333, -0.04, 0.1875
49621, 0.5625, -0.04, 0.20833333333333
49622, 0.58333333333333, -0.06, 0.20833333333333
49623, 0.58333333333333, -0.08, 0.1875
49624, 0.5625, -0.08, 0.20833333333333
49625, 0.58333333333333, -0.1, 0.20833333333333
49626, 0.58333333333333, -0.12, 0.1875
49627, 0.5625, -0.12, 0.20833333333333
49628, 0.58333333333333, -0.14, 0.20833333333333
49629, 0.58333333333333, -0.16, 0.1875
49630, 0.5625, -0.16, 0.20833333333333
49631, 0.58333333333333, -0.18, 0.20833333333333
49632, 0.58333333333333, -0.02, 0.25
49633, 0.58333333333333, -0.04, 0.22916666666667
49634, 0.5625, -0.04, 0.25
49635, 0.58333333333333, -0.06, 0.25
49636, 0.58333333333333, -0.08, 0.22916666666667
49637, 0.5625, -0.08, 0.25
49638, 0.58333333333333, -0.1, 0.25
49639, 0.58333333333333, -0.12, 0.22916666666667
49640, 0.5625, -0.12, 0.25
49641, 0.58333333333333, -0.14, 0.25
49642, 0.58333333333333, -0.16, 0.22916666666667
49643, 0.5625, -0.16, 0.25
49644, 0.58333333333333, -0.18, 0.25
49645, 0.58333333333333, -0.02, 0.29166666666667
49646, 0.58333333333333, -0.04, 0.27083333333333
49647, 0.5625, -0.04, 0.29166666666667
49648, 0.58333333333333, -0.06, 0.29166666666667
49649, 0.58333333333333, -0.08, 0.27083333333333
49650, 0.5625, -0.08, 0.29166666666667
49651, 0.58333333333333, -0.1, 0.29166666666667
49652, 0.58333333333333, -0.12, 0.27083333333333
49653, 0.5625, -0.12, 0.29166666666667
49654, 0.58333333333333, -0.14, 0.29166666666667
49655, 0.58333333333333, -0.16, 0.27083333333333
49656, 0.5625, -0.16, 0.29166666666667
49657, 0.58333333333333, -0.18, 0.29166666666667
49658, 0.58333333333333, -0.02, 0.33333333333333
49659, 0.58333333333333, -0.04, 0.3125
49660, 0.5625, -0.04, 0.33333333333333
49661, 0.58333333333333, -0.06, 0.33333333333333
49662, 0.58333333333333, -0.08, 0.3125
49663, 0.5625, -0.08, 0.33333333333333
49664, 0.58333333333333, -0.1, 0.33333333333333
49665, 0.58333333333333, -0.12, 0.3125
49666, 0.5625, -0.12, 0.33333333333333
49667, 0.58333333333333, -0.14, 0.33333333333333
49668, 0.58333333333333, -0.16, 0.3125
49669, 0.5625, -0.16, 0.33333333333333
49670, 0.58333333333333, -0.18, 0.33333333333333
49671, 0.58333333333333, -0.02, 0.375
49672, 0.58333333333333, -0.04, 0.35416666666667
49673, 0.5625, -0.04, 0.375
49674, 0.58333333333333, -0.06, 0.375
49675, 0.58333333333333, -0.08, 0.35416666666667
49676, 0.5625, -0.08, 0.375
49677, 0.58333333333333, -0.1, 0.375
49678, 0.58333333333333, -0.12, 0.35416666666667
49679, 0.5625, -0.12, 0.375
49680, 0.58333333333333, -0.14, 0.375
49681, 0.58333333333333, -0.16, 0.35416666666667
49682, 0.5625, -0.16, 0.375
49683, 0.58333333333333, -0.18, 0.375
49684, 0.58333333333333, -0.02, 0.41666666666667
49685, 0.58333333333333, -0.04, 0.39583333333333
49686, 0.5625, -0.04, 0.41666666666667
49687, 0.58333333333333, -0.06, 0.41666666666667
49688, 0.58333333333333, -0.08, 0.39583333333333
49689, 0.5625, -0.08, 0.41666666666667
49690, 0.58333333333333, -0.1, 0.41666666666667
49691, 0.58333333333333, -0.12, 0.39583333333333
49692, 0.5625, -0.12, 0.41666666666667
49693, 0.58333333333333, -0.14, 0.41666666666667
49694, 0.58333333333333, -0.16, 0.39583333333333
49695, 0.5625, -0.16, 0.41666666666667
49696, 0.58333333333333, -0.18, 0.41666666666667
49697, 0.58333333333333, -0.02, 0.45833333333333
49698, 0.58333333333333, -0.04, 0.4375
49699, 0.5625, -0.04, 0.45833333333333
49700, 0.58333333333333, -0.06, 0.45833333333333
49701, 0.58333333333333, -0.08, 0.4375
49702, 0.5625, -0.08, 0.45833333333333
49703, 0.58333333333333, -0.1, 0.45833333333333
49704, 0.58333333333333, -0.12, 0.4375
49705, 0.5625, -0.12, 0.45833333333333
49706, 0.58333333333333, -0.14, 0.45833333333333
49707, 0.58333333333333, -0.16, 0.4375
49708, 0.5625, -0.16, 0.45833333333333
49709, 0.58333333333333, -0.18, 0.45833333333333
49710, 0.58333333333333, -0.04, 0.47916666666667
49711, 0.58333333333333, -0.08, 0.47916666666667
49712, 0.58333333333333, -0.12, 0.47916666666667
49713, 0.58333333333333, -0.16, 0.47916666666667
49714, 0.625, -0.02, 0.041666666666667
49715, 0.625, -0.04, 0.020833333333333
49716, 0.60416666666667, -0.04, 0.041666666666667
49717, 0.625, -0.06, 0.041666666666667
49718, 0.625, -0.08, 0.020833333333333
49719, 0.60416666666667, -0.08, 0.041666666666667
49720, 0.625, -0.1, 0.041666666666667
49721, 0.625, -0.12, 0.020833333333333
49722, 0.60416666666667, -0.12, 0.041666666666667
49723, 0.625, -0.14, 0.041666666666667
49724, 0.625, -0.16, 0.020833333333333
49725, 0.60416666666667, -0.16, 0.041666666666667
49726, 0.625, -0.18, 0.041666666666667
49727, 0.625, -0.02, 0.083333333333333
49728, 0.625, -0.04, 0.0625
49729, 0.60416666666667, -0.04, 0.083333333333333
49730, 0.625, -0.06, 0.083333333333333
49731, 0.625, -0.08, 0.0625
49732, 0.60416666666667, -0.08, 0.083333333333333
49733, 0.625, -0.1, 0.083333333333333
49734, 0.625, -0.12, 0.0625
49735, 0.60416666666667, -0.12, 0.083333333333333
49736, 0.625, -0.14, 0.083333333333333
49737, 0.625, -0.16, 0.0625
49738, 0.60416666666667, -0.16, 0.083333333333333
49739, 0.625, -0.18, 0.083333333333333
49740, 0.625, -0.02, 0.125
49741, 0.625, -0.04, 0.10416666666667
49742, 0.60416666666667, -0.04, 0.125
49743, 0.625, -0.06, 0.125
49744, 0.625, -0.08, 0.10416666666667
49745, 0.60416666666667, -0.08, 0.125
49746, 0.625, -0.1, 0.125
49747, 0.625, -0.12, 0.10416666666667
49748, 0.60416666666667, -0.12, 0.125
49749, 0.625, -0.14, 0.125
49750, 0.625, -0.16, 0.10416666666667
49751, 0.60416666666667, -0.16, 0.125
49752, 0.625, -0.18, 0.125
49753, 0.625, -0.02, 0.16666666666667
49754, 0.625, -0.04, 0.14583333333333
49755, 0.60416666666667, -0.04, 0.16666666666667
49756, 0.625, -0.06, 0.16666666666667
49757, 0.625, -0.08, 0.14583333333333
49758, 0.60416666666667, -0.08, 0.16666666666667
49759, 0.625, -0.1, 0.16666666666667
49760, 0.625, -0.12, 0.14583333333333
49761, 0.60416666666667, -0.12, 0.16666666666667
49762, 0.625, -0.14, 0.16666666666667
49763, 0.625, -0.16, 0.14583333333333
49764, 0.60416666666667, -0.16, 0.16666666666667
49765, 0.625, -0.18, 0.16666666666667
49766, 0.625, -0.02, 0.20833333333333
49767, 0.625, -0.04, 0.1875
49768, 0.60416666666667, -0.04, 0.20833333333333
49769, 0.625, -0.06, 0.20833333333333
49770, 0.625, -0.08, 0.1875
49771, 0.60416666666667, -0.08, 0.20833333333333
49772, 0.625, -0.1, 0.20833333333333
49773, 0.625, -0.12, 0.1875
49774, 0.60416666666667, -0.12, 0.20833333333333
49775, 0.625, -0.14, 0.20833333333333
49776, 0.625, -0.16, 0.1875
49777, 0.60416666666667, -0.16, 0.20833333333333
49778, 0.625, -0.18, 0.20833333333333
49779, 0.625, -0.02, 0.25
49780, 0.625, -0.04, 0.22916666666667
49781, 0.60416666666667, -0.04, 0.25
49782, 0.625, -0.06, 0.25
49783, 0.625, -0.08, 0.22916666666667
49784, 0.60416666666667, -0.08, 0.25
49785, 0.625, -0.1, 0.25
49786, 0.625, -0.12, 0.22916666666667
49787, 0.60416666666667, -0.12, 0.25
49788, 0.625, -0.14, 0.25
49789, 0.625, -0.16, 0.22916666666667
49790, 0.60416666666667, -0.16, 0.25
49791, 0.625, -0.18, 0.25
49792, 0.625, -0.02, 0.29166666666667
49793, 0.625, -0.04, 0.27083333333333
49794, 0.60416666666667, -0.04, 0.29166666666667
49795, 0.625, -0.06, 0.29166666666667
49796, 0.625, -0.08, 0.27083333333333
49797, 0.60416666666667, -0.08, 0.29166666666667
49798, 0.625, -0.1, 0.29166666666667
49799, 0.625, -0.12, 0.27083333333333
49800, 0.60416666666667, -0.12, 0.29166666666667
49801, 0.625, -0.14, 0.29166666666667
49802, 0.625, -0.16, 0.27083333333333
49803, 0.60416666666667, -0.16, 0.29166666666667
49804, 0.625, -0.18, 0.29166666666667
49805, 0.625, -0.02, 0.33333333333333
49806, 0.625, -0.04, 0.3125
49807, 0.60416666666667, -0.04, 0.33333333333333
49808, 0.625, -0.06, 0.33333333333333
49809, 0.625, -0.08, 0.3125
49810, 0.60416666666667, -0.08, 0.33333333333333
49811, 0.625, -0.1, 0.33333333333333
49812, 0.625, -0.12, 0.3125
49813, 0.60416666666667, -0.12, 0.33333333333333
49814, 0.625, -0.14, 0.33333333333333
49815, 0.625, -0.16, 0.3125
49816, 0.60416666666667, -0.16, 0.33333333333333
49817, 0.625, -0.18, 0.33333333333333
49818, 0.625, -0.02, 0.375
49819, 0.625, -0.04, 0.35416666666667
49820, 0.60416666666667, -0.04, 0.375
49821, 0.625, -0.06, 0.375
49822, 0.625, -0.08, 0.35416666666667
49823, 0.60416666666667, -0.08, 0.375
49824, 0.625, -0.1, 0.375
49825, 0.625, -0.12, 0.35416666666667
49826, 0.60416666666667, -0.12, 0.375
49827, 0.625, -0.14, 0.375
49828, 0.625, -0.16, 0.35416666666667
49829, 0.60416666666667, -0.16, 0.375
49830, 0.625, -0.18, 0.375
49831, 0.625, -0.02, 0.41666666666667
49832, 0.625, -0.04, 0.39583333333333
49833, 0.60416666666667, -0.04, 0.41666666666667
49834, 0.625, -0.06, 0.41666666666667
49835, 0.625, -0.08, 0.39583333333333
49836, 0.60416666666667, -0.08, 0.41666666666667
49837, 0.625, -0.1, 0.41666666666667
49838, 0.625, -0.12, 0.39583333333333
49839, 0.60416666666667, -0.12, 0.41666666666667
49840, 0.625, -0.14, 0.41666666666667
49841, 0.625, -0.16, 0.39583333333333
49842, 0.60416666666667, -0.16, 0.41666666666667
49843, 0.625, -0.18, 0.41666666666667
49844, 0.625, -0.02, 0.45833333333333
49845, 0.625, -0.04, 0.4375
49846, 0.60416666666667, -0.04, 0.45833333333333
49847, 0.625, -0.06, 0.45833333333333
49848, 0.625, -0.08, 0.4375
49849, 0.60416666666667, -0.08, 0.45833333333333
49850, 0.625, -0.1, 0.45833333333333
49851, 0.625, -0.12, 0.4375
49852, 0.60416666666667, -0.12, 0.45833333333333
49853, 0.625, -0.14, 0.45833333333333
49854, 0.625, -0.16, 0.4375
49855, 0.60416666666667, -0.16, 0.45833333333333
49856, 0.625, -0.18, 0.45833333333333
49857, 0.625, -0.04, 0.47916666666667
49858, 0.625, -0.08, 0.47916666666667
49859, 0.625, -0.12, 0.47916666666667
49860, 0.625, -0.16, 0.47916666666667
49861, 0.66666666666667, -0.02, 0.041666666666667
49862, 0.66666666666667, -0.04, 0.020833333333333
49863, 0.64583333333333, -0.04, 0.041666666666667
49864, 0.66666666666667, -0.06, 0.041666666666667
49865, 0.66666666666667, -0.08, 0.020833333333333
49866, 0.64583333333333, -0.08, 0.041666666666667
49867, 0.66666666666667, -0.1, 0.041666666666667
49868, 0.66666666666667, -0.12, 0.020833333333333
49869, 0.64583333333333, -0.12, 0.041666666666667
49870, 0.66666666666667, -0.14, 0.041666666666667
49871, 0.66666666666667, -0.16, 0.020833333333333
49872, 0.64583333333333, -0.16, 0.041666666666667
49873, 0.66666666666667, -0.18, 0.041666666666667
49874, 0.66666666666667, -0.02, 0.083333333333333
49875, 0.66666666666667, -0.04, 0.0625
49876, 0.64583333333333, -0.04, 0.083333333333333
49877, 0.66666666666667, -0.06, 0.083333333333333
49878, 0.66666666666667, -0.08, 0.0625
49879, 0.64583333333333, -0.08, 0.083333333333333
49880, 0.66666666666667, -0.1, 0.083333333333333
49881, 0.66666666666667, -0.12, 0.0625
49882, 0.64583333333333, -0.12, 0.083333333333333
49883, 0.66666666666667, -0.14, 0.083333333333333
49884, 0.66666666666667, -0.16, 0.0625
49885, 0.64583333333333, -0.16, 0.083333333333333
49886, 0.66666666666667, -0.18, 0.083333333333333
49887, 0.66666666666667, -0.02, 0.125
49888, 0.66666666666667, -0.04, 0.10416666666667
49889, 0.64583333333333, -0.04, 0.125
49890, 0.66666666666667, -0.06, 0.125
49891, 0.66666666666667, -0.08, 0.10416666666667
49892, 0.64583333333333, -0.08, 0.125
49893, 0.66666666666667, -0.1, 0.125
49894, 0.66666666666667, -0.12, 0.10416666666667
49895, 0.64583333333333, -0.12, 0.125
49896, 0.66666666666667, -0.14, 0.125
49897, 0.66666666666667, -0.16, 0.10416666666667
49898, 0.64583333333333, -0.16, 0.125
49899, 0.66666666666667, -0.18, 0.125
49900, 0.66666666666667, -0.02, 0.16666666666667
49901, 0.66666666666667, -0.04, 0.14583333333333
49902, 0.64583333333333, -0.04, 0.16666666666667
49903, 0.66666666666667, -0.06, 0.16666666666667
49904, 0.66666666666667, -0.08, 0.14583333333333
49905, 0.64583333333333, -0.08, 0.16666666666667
49906, 0.66666666666667, -0.1, 0.16666666666667
49907, 0.66666666666667, -0.12, 0.14583333333333
49908, 0.64583333333333, -0.12, 0.16666666666667
49909, 0.66666666666667, -0.14, 0.16666666666667
49910, 0.66666666666667, -0.16, 0.14583333333333
49911, 0.64583333333333, -0.16, 0.16666666666667
49912, 0.66666666666667, -0.18, 0.16666666666667
49913, 0.66666666666667, -0.02, 0.20833333333333
49914, 0.66666666666667, -0.04, 0.1875
49915, 0.64583333333333, -0.04, 0.20833333333333
49916, 0.66666666666667, -0.06, 0.20833333333333
49917, 0.66666666666667, -0.08, 0.1875
49918, 0.64583333333333, -0.08, 0.20833333333333
49919, 0.66666666666667, -0.1, 0.20833333333333
49920, 0.66666666666667, -0.12, 0.1875
49921, 0.64583333333333, -0.12, 0.20833333333333
49922, 0.66666666666667, -0.14, 0.20833333333333
49923, 0.66666666666667, -0.16, 0.1875
49924, 0.64583333333333, -0.16, 0.20833333333333
49925, 0.66666666666667, -0.18, 0.20833333333333
49926, 0.66666666666667, -0.02, 0.25
49927, 0.66666666666667, -0.04, 0.22916666666667
49928, 0.64583333333333, -0.04, 0.25
49929, 0.66666666666667, -0.06, 0.25
49930, 0.66666666666667, -0.08, 0.22916666666667
49931, 0.64583333333333, -0.08, 0.25
49932, 0.66666666666667, -0.1, 0.25
49933, 0.66666666666667, -0.12, 0.22916666666667
49934, 0.64583333333333, -0.12, 0.25
49935, 0.66666666666667, -0.14, 0.25
49936, 0.66666666666667, -0.16, 0.22916666666667
49937, 0.64583333333333, -0.16, 0.25
49938, 0.66666666666667, -0.18, 0.25
49939, 0.66666666666667, -0.02, 0.29166666666667
49940, 0.66666666666667, -0.04, 0.27083333333333
49941, 0.64583333333333, -0.04, 0.29166666666667
49942, 0.66666666666667, -0.06, 0.29166666666667
49943, 0.66666666666667, -0.08, 0.27083333333333
49944, 0.64583333333333, -0.08, 0.29166666666667
49945, 0.66666666666667, -0.1, 0.29166666666667
49946, 0.66666666666667, -0.12, 0.27083333333333
49947, 0.64583333333333, -0.12, 0.29166666666667
49948, 0.66666666666667, -0.14, 0.29166666666667
49949, 0.66666666666667, -0.16, 0.27083333333333
49950, 0.64583333333333, -0.16, 0.29166666666667
49951, 0.66666666666667, -0.18, 0.29166666666667
49952, 0.66666666666667, -0.02, 0.33333333333333
49953, 0.66666666666667, -0.04, 0.3125
49954, 0.64583333333333, -0.04, 0.33333333333333
49955, 0.66666666666667, -0.06, 0.33333333333333
49956, 0.66666666666667, -0.08, 0.3125
49957, 0.64583333333333, -0.08, 0.33333333333333
49958, 0.66666666666667, -0.1, 0.33333333333333
49959, 0.66666666666667, -0.12, 0.3125
49960, 0.64583333333333, -0.12, 0.33333333333333
49961, 0.66666666666667, -0.14, 0.33333333333333
49962, 0.66666666666667, -0.16, 0.3125
49963, 0.64583333333333, -0.16, 0.33333333333333
49964, 0.66666666666667, -0.18, 0.33333333333333
49965, 0.66666666666667, -0.02, 0.375
49966, 0.66666666666667, -0.04, 0.35416666666667
49967, 0.64583333333333, -0.04, 0.375
49968, 0.66666666666667, -0.06, 0.375
49969, 0.66666666666667, -0.08, 0.35416666666667
49970, 0.64583333333333, -0.08, 0.375
49971, 0.66666666666667, -0.1, 0.375
49972, 0.66666666666667, -0.12, 0.35416666666667
49973, 0.64583333333333, -0.12, 0.375
49974, 0.66666666666667, -0.14, 0.375
49975, 0.66666666666667, -0.16, 0.35416666666667
49976, 0.64583333333333, -0.16, 0.375
49977, 0.66666666666667, -0.18, 0.375
49978, 0.66666666666667, -0.02, 0.41666666666667
49979, 0.66666666666667, -0.04, 0.39583333333333
49980, 0.64583333333333, -0.04, 0.41666666666667
49981, 0.66666666666667, -0.06, 0.41666666666667
49982, 0.66666666666667, -0.08, 0.39583333333333
49983, 0.64583333333333, -0.08, 0.41666666666667
49984, 0.66666666666667, -0.1, 0.41666666666667
49985, 0.66666666666667, -0.12, 0.39583333333333
49986, 0.64583333333333, -0.12, 0.41666666666667
49987, 0.66666666666667, -0.14, 0.41666666666667
49988, 0.66666666666667, -0.16, 0.39583333333333
49989, 0.64583333333333, -0.16, 0.41666666666667
49990, 0.66666666666667, -0.18, 0.41666666666667
49991, 0.66666666666667, -0.02, 0.45833333333333
49992, 0.66666666666667, -0.04, 0.4375
49993, 0.64583333333333, -0.04, 0.45833333333333
49994, 0.66666666666667, -0.06, 0.45833333333333
49995, 0.66666666666667, -0.08, 0.4375
49996, 0.64583333333333, -0.08, 0.45833333333333
49997, 0.66666666666667, -0.1, 0.45833333333333
49998, 0.66666666666667, -0.12, 0.4375
49999, 0.64583333333333, -0.12, 0.45833333333333
50000, 0.66666666666667, -0.14, 0.45833333333333
50001, 0.66666666666667, -0.16, 0.4375
50002, 0.64583333333333, -0.16, 0.45833333333333
50003, 0.66666666666667, -0.18, 0.45833333333333
50004, 0.66666666666667, -0.04, 0.47916666666667
50005, 0.66666666666667, -0.08, 0.47916666666667
50006, 0.66666666666667, -0.12, 0.47916666666667
50007, 0.66666666666667, -0.16, 0.47916666666667
50008, 0.70833333333333, -0.02, 0.041666666666667
50009, 0.70833333333333, -0.04, 0.020833333333333
50010, 0.6875, -0.04, 0.041666666666667
50011, 0.70833333333333, -0.06, 0.041666666666667
50012, 0.70833333333333, -0.08, 0.020833333333333
50013, 0.6875, -0.08, 0.041666666666667
50014, 0.70833333333333, -0.1, 0.041666666666667
50015, 0.70833333333333, -0.12, 0.020833333333333
50016, 0.6875, -0.12, 0.041666666666667
50017, 0.70833333333333, -0.14, 0.041666666666667
50018, 0.70833333333333, -0.16, 0.020833333333333
50019, 0.6875, -0.16, 0.041666666666667
50020, 0.70833333333333, -0.18, 0.041666666666667
50021, 0.70833333333333, -0.02, 0.083333333333333
50022, 0.70833333333333, -0.04, 0.0625
50023, 0.6875, -0.04, 0.083333333333333
50024, 0.70833333333333, -0.06, 0.083333333333333
50025, 0.70833333333333, -0.08, 0.0625
50026, 0.6875, -0.08, 0.083333333333333
50027, 0.70833333333333, -0.1, 0.083333333333333
50028, 0.70833333333333, -0.12, 0.0625
50029, 0.6875, -0.12, 0.083333333333333
50030, 0.70833333333333, -0.14, 0.083333333333333
50031, 0.70833333333333, -0.16, 0.0625
50032, 0.6875, -0.16, 0.083333333333333
50033, 0.70833333333333, -0.18, 0.083333333333333
50034, 0.70833333333333, -0.02, 0.125
50035, 0.70833333333333, -0.04, 0.10416666666667
50036, 0.6875, -0.04, 0.125
50037, 0.70833333333333, -0.06, 0.125
50038, 0.70833333333333, -0.08, 0.10416666666667
50039, 0.6875, -0.08, 0.125
50040, 0.70833333333333, -0.1, 0.125
50041, 0.70833333333333, -0.12, 0.10416666666667
50042, 0.6875, -0.12, 0.125
50043, 0.70833333333333, -0.14, 0.125
50044, 0.70833333333333, -0.16, 0.10416666666667
50045, 0.6875, -0.16, 0.125
50046, 0.70833333333333, -0.18, 0.125
50047, 0.70833333333333, -0.02, 0.16666666666667
50048, 0.70833333333333, -0.04, 0.14583333333333
50049, 0.6875, -0.04, 0.16666666666667
50050, 0.70833333333333, -0.06, 0.16666666666667
50051, 0.70833333333333, -0.08, 0.14583333333333
50052, 0.6875, -0.08, 0.16666666666667
50053, 0.70833333333333, -0.1, 0.16666666666667
50054, 0.70833333333333, -0.12, 0.14583333333333
50055, 0.6875, -0.12, 0.16666666666667
50056, 0.70833333333333, -0.14, 0.16666666666667
50057, 0.70833333333333, -0.16, 0.14583333333333
50058, 0.6875, -0.16, 0.16666666666667
50059, 0.70833333333333, -0.18, 0.16666666666667
50060, 0.70833333333333, -0.02, 0.20833333333333
50061, 0.70833333333333, -0.04, 0.1875
50062, 0.6875, -0.04, 0.20833333333333
50063, 0.70833333333333, -0.06, 0.20833333333333
50064, 0.70833333333333, -0.08, 0.1875
50065, 0.6875, -0.08, 0.20833333333333
50066, 0.70833333333333, -0.1, 0.20833333333333
50067, 0.70833333333333, -0.12, 0.1875
50068, 0.6875, -0.12, 0.20833333333333
50069, 0.70833333333333, -0.14, 0.20833333333333
50070, 0.70833333333333, -0.16, 0.1875
50071, 0.6875, -0.16, 0.20833333333333
50072, 0.70833333333333, -0.18, 0.20833333333333
50073, 0.70833333333333, -0.02, 0.25
50074, 0.70833333333333, -0.04, 0.22916666666667
50075, 0.6875, -0.04, 0.25
50076, 0.70833333333333, -0.06, 0.25
50077, 0.70833333333333, -0.08, 0.22916666666667
50078, 0.6875, -0.08, 0.25
50079, 0.70833333333333, -0.1, 0.25
50080, 0.70833333333333, -0.12, 0.22916666666667
50081, 0.6875, -0.12, 0.25
50082, 0.70833333333333, -0.14, 0.25
50083, 0.70833333333333, -0.16, 0.22916666666667
50084, 0.6875, -0.16, 0.25
50085, 0.70833333333333, -0.18, 0.25
50086, 0.70833333333333, -0.02, 0.29166666666667
50087, 0.70833333333333, -0.04, 0.27083333333333
50088, 0.6875, -0.04, 0.29166666666667
50089, 0.70833333333333, -0.06, 0.29166666666667
50090, 0.70833333333333, -0.08, 0.27083333333333
50091, 0.6875, -0.08, 0.29166666666667
50092, 0.70833333333333, -0.1, 0.29166666666667
50093, 0.70833333333333, -0.12, 0.27083333333333
50094, 0.6875, -0.12, 0.29166666666667
50095, 0.70833333333333, -0.14, 0.29166666666667
50096, 0.70833333333333, -0.16, 0.27083333333333
50097, 0.6875, -0.16, 0.29166666666667
50098, 0.70833333333333, -0.18, 0.29166666666667
50099, 0.70833333333333, -0.02, 0.33333333333333
50100, 0.70833333333333, -0.04, 0.3125
50101, 0.6875, -0.04, 0.33333333333333
50102, 0.70833333333333, -0.06, 0.33333333333333
50103, 0.70833333333333, -0.08, 0.3125
50104, 0.6875, -0.08, 0.33333333333333
50105, 0.70833333333333, -0.1, 0.33333333333333
50106, 0.70833333333333, -0.12, 0.3125
50107, 0.6875, -0.12, 0.33333333333333
50108, 0.70833333333333, -0.14, 0.33333333333333
50109, 0.70833333333333, -0.16, 0.3125
50110, 0.6875, -0.16, 0.33333333333333
50111, 0.70833333333333, -0.18, 0.33333333333333
50112, 0.70833333333333, -0.02, 0.375
50113, 0.70833333333333, -0.04, 0.35416666666667
50114, 0.6875, -0.04, 0.375
50115, 0.70833333333333, -0.06, 0.375
50116, 0.70833333333333, -0.08, 0.35416666666667
50117, 0.6875, -0.08, 0.375
50118, 0.70833333333333, -0.1, 0.375
50119, 0.70833333333333, -0.12, 0.35416666666667
50120, 0.6875, -0.12, 0.375
50121, 0.70833333333333, -0.14, 0.375
50122, 0.70833333333333, -0.16, 0.35416666666667
50123, 0.6875, -0.16, 0.375
50124, 0.70833333333333, -0.18, 0.375
50125, 0.70833333333333, -0.02, 0.41666666666667
50126, 0.70833333333333, -0.04, 0.39583333333333
50127, 0.6875, -0.04, 0.41666666666667
50128, 0.70833333333333, -0.06, 0.41666666666667
50129, 0.70833333333333, -0.08, 0.39583333333333
50130, 0.6875, -0.08, 0.41666666666667
50131, 0.70833333333333, -0.1, 0.41666666666667
50132, 0.70833333333333, -0.12, 0.39583333333333
50133, 0.6875, -0.12, 0.41666666666667
50134, 0.70833333333333, -0.14, 0.41666666666667
50135, 0.70833333333333, -0.16, 0.39583333333333
50136, 0.6875, -0.16, 0.41666666666667
50137, 0.70833333333333, -0.18, 0.41666666666667
50138, 0.70833333333333, -0.02, 0.45833333333333
50139, 0.70833333333333, -0.04, 0.4375
50140, 0.6875, -0.04, 0.45833333333333
50141, 0.70833333333333, -0.06, 0.45833333333333
50142, 0.70833333333333, -0.08, 0.4375
50143, 0.6875, -0.08, 0.45833333333333
50144, 0.70833333333333, -0.1, 0.45833333333333
50145, 0.70833333333333, -0.12, 0.4375
50146, 0.6875, -0.12, 0.45833333333333
50147, 0.70833333333333, -0.14, 0.45833333333333
50148, 0.70833333333333, -0.16, 0.4375
50149, 0.6875, -0.16, 0.45833333333333
50150, 0.70833333333333, -0.18, 0.45833333333333
50151, 0.70833333333333, -0.04, 0.47916666666667
50152, 0.70833333333333, -0.08, 0.47916666666667
50153, 0.70833333333333, -0.12, 0.47916666666667
50154, 0.70833333333333, -0.16, 0.47916666666667
50155, 0.75, -0.02, 0.041666666666667
50156, 0.75, -0.04, 0.020833333333333
50157, 0.72916666666667, -0.04, 0.041666666666667
50158, 0.75, -0.06, 0.041666666666667
50159, 0.75, -0.08, 0.020833333333333
50160, 0.72916666666667, -0.08, 0.041666666666667
50161, 0.75, -0.1, 0.041666666666667
50162, 0.75, -0.12, 0.020833333333333
50163, 0.72916666666667, -0.12, 0.041666666666667
50164, 0.75, -0.14, 0.041666666666667
50165, 0.75, -0.16, 0.020833333333333
50166, 0.72916666666667, -0.16, 0.041666666666667
50167, 0.75, -0.18, 0.041666666666667
50168, 0.75, -0.02, 0.083333333333333
50169, 0.75, -0.04, 0.0625
50170, 0.72916666666667, -0.04, 0.083333333333333
50171, 0.75, -0.06, 0.083333333333333
50172, 0.75, -0.08, 0.0625
50173, 0.72916666666667, -0.08, 0.083333333333333
50174, 0.75, -0.1, 0.083333333333333
50175, 0.75, -0.12, 0.0625
50176, 0.72916666666667, -0.12, 0.083333333333333
50177, 0.75, -0.14, 0.083333333333333
50178, 0.75, -0.16, 0.0625
50179, 0.72916666666667, -0.16, 0.083333333333333
50180, 0.75, -0.18, 0.083333333333333
50181, 0.75, -0.02, 0.125
50182, 0.75, -0.04, 0.10416666666667
50183, 0.72916666666667, -0.04, 0.125
50184, 0.75, -0.06, 0.125
50185, 0.75, -0.08, 0.10416666666667
50186, 0.72916666666667, -0.08, 0.125
50187, 0.75, -0.1, 0.125
50188, 0.75, -0.12, 0.10416666666667
50189, 0.72916666666667, -0.12, 0.125
50190, 0.75, -0.14, 0.125
50191, 0.75, -0.16, 0.10416666666667
50192, 0.72916666666667, -0.16, 0.125
50193, 0.75, -0.18, 0.125
50194, 0.75, -0.02, 0.16666666666667
50195, 0.75, -0.04, 0.14583333333333
50196, 0.72916666666667, -0.04, 0.16666666666667
50197, 0.75, -0.06, 0.16666666666667
50198, 0.75, -0.08, 0.14583333333333
50199, 0.72916666666667, -0.08, 0.16666666666667
50200, 0.75, -0.1, 0.16666666666667
50201, 0.75, -0.12, 0.14583333333333
50202, 0.72916666666667, -0.12, 0.16666666666667
50203, 0.75, -0.14, 0.16666666666667
50204, 0.75, -0.16, 0.14583333333333
50205, 0.72916666666667, -0.16, 0.16666666666667
50206, 0.75, -0.18, 0.16666666666667
50207, 0.75, -0.02, 0.20833333333333
50208, 0.75, -0.04, 0.1875
50209, 0.72916666666667, -0.04, 0.20833333333333
50210, 0.75, -0.06, 0.20833333333333
50211, 0.75, -0.08, 0.1875
50212, 0.72916666666667, -0.08, 0.20833333333333
50213, 0.75, -0.1, 0.20833333333333
50214, 0.75, -0.12, 0.1875
50215, 0.72916666666667, -0.12, 0.20833333333333
50216, 0.75, -0.14, 0.20833333333333
50217, 0.75, -0.16, 0.1875
50218, 0.72916666666667, -0.16, 0.20833333333333
50219, 0.75, -0.18, 0.20833333333333
50220, 0.75, -0.02, 0.25
50221, 0.75, -0.04, 0.22916666666667
50222, 0.72916666666667, -0.04, 0.25
50223, 0.75, -0.06, 0.25
50224, 0.75, -0.08, 0.22916666666667
50225, 0.72916666666667, -0.08, 0.25
50226, 0.75, -0.1, 0.25
50227, 0.75, -0.12, 0.22916666666667
50228, 0.72916666666667, -0.12, 0.25
50229, 0.75, -0.14, 0.25
50230, 0.75, -0.16, 0.22916666666667
50231, 0.72916666666667, -0.16, 0.25
50232, 0.75, -0.18, 0.25
50233, 0.75, -0.02, 0.29166666666667
50234, 0.75, -0.04, 0.27083333333333
50235, 0.72916666666667, -0.04, 0.29166666666667
50236, 0.75, -0.06, 0.29166666666667
50237, 0.75, -0.08, 0.27083333333333
50238, 0.72916666666667, -0.08, 0.29166666666667
50239, 0.75, -0.1, 0.29166666666667
50240, 0.75, -0.12, 0.27083333333333
50241, 0.72916666666667, -0.12, 0.29166666666667
50242, 0.75, -0.14, 0.29166666666667
50243, 0.75, -0.16, 0.27083333333333
50244, 0.72916666666667, -0.16, 0.29166666666667
50245, 0.75, -0.18, 0.29166666666667
50246, 0.75, -0.02, 0.33333333333333
50247, 0.75, -0.04, 0.3125
50248, 0.72916666666667, -0.04, 0.33333333333333
50249, 0.75, -0.06, 0.33333333333333
50250, 0.75, -0.08, 0.3125
50251, 0.72916666666667, -0.08, 0.33333333333333
50252, 0.75, -0.1, 0.33333333333333
50253, 0.75, -0.12, 0.3125
50254, 0.72916666666667, -0.12, 0.33333333333333
50255, 0.75, -0.14, 0.33333333333333
50256, 0.75, -0.16, 0.3125
50257, 0.72916666666667, -0.16, 0.33333333333333
50258, 0.75, -0.18, 0.33333333333333
50259, 0.75, -0.02, 0.375
50260, 0.75, -0.04, 0.35416666666667
50261, 0.72916666666667, -0.04, 0.375
50262, 0.75, -0.06, 0.375
50263, 0.75, -0.08, 0.35416666666667
50264, 0.72916666666667, -0.08, 0.375
50265, 0.75, -0.1, 0.375
50266, 0.75, -0.12, 0.35416666666667
50267, 0.72916666666667, -0.12, 0.375
50268, 0.75, -0.14, 0.375
50269, 0.75, -0.16, 0.35416666666667
50270, 0.72916666666667, -0.16, 0.375
50271, 0.75, -0.18, 0.375
50272, 0.75, -0.02, 0.41666666666667
50273, 0.75, -0.04, 0.39583333333333
50274, 0.72916666666667, -0.04, 0.41666666666667
50275, 0.75, -0.06, 0.41666666666667
50276, 0.75, -0.08, 0.39583333333333
50277, 0.72916666666667, -0.08, 0.41666666666667
50278, 0.75, -0.1, 0.41666666666667
50279, 0.75, -0.12, 0.39583333333333
50280, 0.72916666666667, -0.12, 0.41666666666667
50281, 0.75, -0.14, 0.41666666666667
50282, 0.75, -0.16, 0.39583333333333
50283, 0.72916666666667, -0.16, 0.41666666666667
50284, 0.75, -0.18, 0.41666666666667
50285, 0.75, -0.02, 0.45833333333333
50286, 0.75, -0.04, 0.4375
50287, 0.72916666666667, -0.04, 0.45833333333333
50288, 0.75, -0.06, 0.45833333333333
50289, 0.75, -0.08, 0.4375
50290, 0.72916666666667, -0.08, 0.45833333333333
50291, 0.75, -0.1, 0.45833333333333
50292, 0.75, -0.12, 0.4375
50293, 0.72916666666667, -0.12, 0.45833333333333
50294, 0.75, -0.14, 0.45833333333333
50295, 0.75, -0.16, 0.4375
50296, 0.72916666666667, -0.16, 0.45833333333333
50297, 0.75, -0.18, 0.45833333333333
50298, 0.75, -0.04, 0.47916666666667
50299, 0.75, -0.08, 0.47916666666667
50300, 0.75, -0.12, 0.47916666666667
50301, 0.75, -0.16, 0.47916666666667
50302, 0.79166666666667, -0.02, 0.041666666666667
50303, 0.79166666666667, -0.04, 0.020833333333333
50304, 0.77083333333333, -0.04, 0.041666666666667
50305, 0.79166666666667, -0.06, 0.041666666666667
50306, 0.79166666666667, -0.08, 0.020833333333333
50307, 0.77083333333333, -0.08, 0.041666666666667
50308, 0.79166666666667, -0.1, 0.041666666666667
50309, 0.79166666666667, -0.12, 0.020833333333333
50310, 0.77083333333333, -0.12, 0.041666666666667
50311, 0.79166666666667, -0.14, 0.041666666666667
50312, 0.79166666666667, -0.16, 0.020833333333333
50313, 0.77083333333333, -0.16, 0.041666666666667
50314, 0.79166666666667, -0.18, 0.041666666666667
50315, 0.79166666666667, -0.02, 0.083333333333333
50316, 0.79166666666667, -0.04, 0.0625
50317, 0.77083333333333, -0.04, 0.083333333333333
50318, 0.79166666666667, -0.06, 0.083333333333333
50319, 0.79166666666667, -0.08, 0.0625
50320, 0.77083333333333, -0.08, 0.083333333333333
50321, 0.79166666666667, -0.1, 0.083333333333333
50322, 0.79166666666667, -0.12, 0.0625
50323, 0.77083333333333, -0.12, 0.083333333333333
50324, 0.79166666666667, -0.14, 0.083333333333333
50325, 0.79166666666667, -0.16, 0.0625
50326, 0.77083333333333, -0.16, 0.083333333333333
50327, 0.79166666666667, -0.18, 0.083333333333333
50328, 0.79166666666667, -0.02, 0.125
50329, 0.79166666666667, -0.04, 0.10416666666667
50330, 0.77083333333333, -0.04, 0.125
50331, 0.79166666666667, -0.06, 0.125
50332, 0.79166666666667, -0.08, 0.10416666666667
50333, 0.77083333333333, -0.08, 0.125
50334, 0.79166666666667, -0.1, 0.125
50335, 0.79166666666667, -0.12, 0.10416666666667
50336, 0.77083333333333, -0.12, 0.125
50337, 0.79166666666667, -0.14, 0.125
50338, 0.79166666666667, -0.16, 0.10416666666667
50339, 0.77083333333333, -0.16, 0.125
50340, 0.79166666666667, -0.18, 0.125
50341, 0.79166666666667, -0.02, 0.16666666666667
50342, 0.79166666666667, -0.04, 0.14583333333333
50343, 0.77083333333333, -0.04, 0.16666666666667
50344, 0.79166666666667, -0.06, 0.16666666666667
50345, 0.79166666666667, -0.08, 0.14583333333333
50346, 0.77083333333333, -0.08, 0.16666666666667
50347, 0.79166666666667, -0.1, 0.16666666666667
50348, 0.79166666666667, -0.12, 0.14583333333333
50349, 0.77083333333333, -0.12, 0.16666666666667
50350, 0.79166666666667, -0.14, 0.16666666666667
50351, 0.79166666666667, -0.16, 0.14583333333333
50352, 0.77083333333333, -0.16, 0.16666666666667
50353, 0.79166666666667, -0.18, 0.16666666666667
50354, 0.79166666666667, -0.02, 0.20833333333333
50355, 0.79166666666667, -0.04, 0.1875
50356, 0.77083333333333, -0.04, 0.20833333333333
50357, 0.79166666666667, -0.06, 0.20833333333333
50358, 0.79166666666667, -0.08, 0.1875
50359, 0.77083333333333, -0.08, 0.20833333333333
50360, 0.79166666666667, -0.1, 0.20833333333333
50361, 0.79166666666667, -0.12, 0.1875
50362, 0.77083333333333, -0.12, 0.20833333333333
50363, 0.79166666666667, -0.14, 0.20833333333333
50364, 0.79166666666667, -0.16, 0.1875
50365, 0.77083333333333, -0.16, 0.20833333333333
50366, 0.79166666666667, -0.18, 0.20833333333333
50367, 0.79166666666667, -0.02, 0.25
50368, 0.79166666666667, -0.04, 0.22916666666667
50369, 0.77083333333333, -0.04, 0.25
50370, 0.79166666666667, -0.06, 0.25
50371, 0.79166666666667, -0.08, 0.22916666666667
50372, 0.77083333333333, -0.08, 0.25
50373, 0.79166666666667, -0.1, 0.25
50374, 0.79166666666667, -0.12, 0.22916666666667
50375, 0.77083333333333, -0.12, 0.25
50376, 0.79166666666667, -0.14, 0.25
50377, 0.79166666666667, -0.16, 0.22916666666667
50378, 0.77083333333333, -0.16, 0.25
50379, 0.79166666666667, -0.18, 0.25
50380, 0.79166666666667, -0.02, 0.29166666666667
50381, 0.79166666666667, -0.04, 0.27083333333333
50382, 0.77083333333333, -0.04, 0.29166666666667
50383, 0.79166666666667, -0.06, 0.29166666666667
50384, 0.79166666666667, -0.08, 0.27083333333333
50385, 0.77083333333333, -0.08, 0.29166666666667
50386, 0.79166666666667, -0.1, 0.29166666666667
50387, 0.79166666666667, -0.12, 0.27083333333333
50388, 0.77083333333333, -0.12, 0.29166666666667
50389, 0.79166666666667, -0.14, 0.29166666666667
50390, 0.79166666666667, -0.16, 0.27083333333333
50391, 0.77083333333333, -0.16, 0.29166666666667
50392, 0.79166666666667, -0.18, 0.29166666666667
50393, 0.79166666666667, -0.02, 0.33333333333333
50394, 0.79166666666667, -0.04, 0.3125
50395, 0.77083333333333, -0.04, 0.33333333333333
50396, 0.79166666666667, -0.06, 0.33333333333333
50397, 0.79166666666667, -0.08, 0.3125
50398, 0.77083333333333, -0.08, 0.33333333333333
50399, 0.79166666666667, -0.1, 0.33333333333333
50400, 0.79166666666667, -0.12, 0.3125
50401, 0.77083333333333, -0.12, 0.33333333333333
50402, 0.79166666666667, -0.14, 0.33333333333333
50403, 0.79166666666667, -0.16, 0.3125
50404, 0.77083333333333, -0.16, 0.33333333333333
50405, 0.79166666666667, -0.18, 0.33333333333333
50406, 0.79166666666667, -0.02, 0.375
50407, 0.79166666666667, -0.04, 0.35416666666667
50408, 0.77083333333333, -0.04, 0.375
50409, 0.79166666666667, -0.06, 0.375
50410, 0.79166666666667, -0.08, 0.35416666666667
50411, 0.77083333333333, -0.08, 0.375
50412, 0.79166666666667, -0.1, 0.375
50413, 0.79166666666667, -0.12, 0.35416666666667
50414, 0.77083333333333, -0.12, 0.375
50415, 0.79166666666667, -0.14, 0.375
50416, 0.79166666666667, -0.16, 0.35416666666667
50417, 0.77083333333333, -0.16, 0.375
50418, 0.79166666666667, -0.18, 0.375
50419, 0.79166666666667, -0.02, 0.41666666666667
50420, 0.79166666666667, -0.04, 0.39583333333333
50421, 0.77083333333333, -0.04, 0.41666666666667
50422, 0.79166666666667, -0.06, 0.41666666666667
50423, 0.79166666666667, -0.08, 0.39583333333333
50424, 0.77083333333333, -0.08, 0.41666666666667
50425, 0.79166666666667, -0.1, 0.41666666666667
50426, 0.79166666666667, -0.12, 0.39583333333333
50427, 0.77083333333333, -0.12, 0.41666666666667
50428, 0.79166666666667, -0.14, 0.41666666666667
50429, 0.79166666666667, -0.16, 0.39583333333333
50430, 0.77083333333333, -0.16, 0.41666666666667
50431, 0.79166666666667, -0.18, 0.41666666666667
50432, 0.79166666666667, -0.02, 0.45833333333333
50433, 0.79166666666667, -0.04, 0.4375
50434, 0.77083333333333, -0.04, 0.45833333333333
50435, 0.79166666666667, -0.06, 0.45833333333333
50436, 0.79166666666667, -0.08, 0.4375
50437, 0.77083333333333, -0.08, 0.45833333333333
50438, 0.79166666666667, -0.1, 0.45833333333333
50439, 0.79166666666667, -0.12, 0.4375
50440, 0.77083333333333, -0.12, 0.45833333333333
50441, 0.79166666666667, -0.14, 0.45833333333333
50442, 0.79166666666667, -0.16, 0.4375
50443, 0.77083333333333, -0.16, 0.45833333333333
50444, 0.79166666666667, -0.18, 0.45833333333333
50445, 0.79166666666667, -0.04, 0.47916666666667
50446, 0.79166666666667, -0.08, 0.47916666666667
50447, 0.79166666666667, -0.12, 0.47916666666667
50448, 0.79166666666667, -0.16, 0.47916666666667
50449, 0.83333333333333, -0.02, 0.041666666666667
50450, 0.83333333333333, -0.04, 0.020833333333333
50451, 0.8125, -0.04, 0.041666666666667
50452, 0.83333333333333, -0.06, 0.041666666666667
50453, 0.83333333333333, -0.08, 0.020833333333333
50454, 0.8125, -0.08, 0.041666666666667
50455, 0.83333333333333, -0.1, 0.041666666666667
50456, 0.83333333333333, -0.12, 0.020833333333333
50457, 0.8125, -0.12, 0.041666666666667
50458, 0.83333333333333, -0.14, 0.041666666666667
50459, 0.83333333333333, -0.16, 0.020833333333333
50460, 0.8125, -0.16, 0.041666666666667
50461, 0.83333333333333, -0.18, 0.041666666666667
50462, 0.83333333333333, -0.02, 0.083333333333333
50463, 0.83333333333333, -0.04, 0.0625
50464, 0.8125, -0.04, 0.083333333333333
50465, 0.83333333333333, -0.06, 0.083333333333333
50466, 0.83333333333333, -0.08, 0.0625
50467, 0.8125, -0.08, 0.083333333333333
50468, 0.83333333333333, -0.1, 0.083333333333333
50469, 0.83333333333333, -0.12, 0.0625
50470, 0.8125, -0.12, 0.083333333333333
50471, 0.83333333333333, -0.14, 0.083333333333333
50472, 0.83333333333333, -0.16, 0.0625
50473, 0.8125, -0.16, 0.083333333333333
50474, 0.83333333333333, -0.18, 0.083333333333333
50475, 0.83333333333333, -0.02, 0.125
50476, 0.83333333333333, -0.04, 0.10416666666667
50477, 0.8125, -0.04, 0.125
50478, 0.83333333333333, -0.06, 0.125
50479, 0.83333333333333, -0.08, 0.10416666666667
50480, 0.8125, -0.08, 0.125
50481, 0.83333333333333, -0.1, 0.125
50482, 0.83333333333333, -0.12, 0.10416666666667
50483, 0.8125, -0.12, 0.125
50484, 0.83333333333333, -0.14, 0.125
50485, 0.83333333333333, -0.16, 0.10416666666667
50486, 0.8125, -0.16, 0.125
50487, 0.83333333333333, -0.18, 0.125
50488, 0.83333333333333, -0.02, 0.16666666666667
50489, 0.83333333333333, -0.04, 0.14583333333333
50490, 0.8125, -0.04, 0.16666666666667
50491, 0.83333333333333, -0.06, 0.16666666666667
50492, 0.83333333333333, -0.08, 0.14583333333333
50493, 0.8125, -0.08, 0.16666666666667
50494, 0.83333333333333, -0.1, 0.16666666666667
50495, 0.83333333333333, -0.12, 0.14583333333333
50496, 0.8125, -0.12, 0.16666666666667
50497, 0.83333333333333, -0.14, 0.16666666666667
50498, 0.83333333333333, -0.16, 0.14583333333333
50499, 0.8125, -0.16, 0.16666666666667
50500, 0.83333333333333, -0.18, 0.16666666666667
50501, 0.83333333333333, -0.02, 0.20833333333333
50502, 0.83333333333333, -0.04, 0.1875
50503, 0.8125, -0.04, 0.20833333333333
50504, 0.83333333333333, -0.06, 0.20833333333333
50505, 0.83333333333333, -0.08, 0.1875
50506, 0.8125, -0.08, 0.20833333333333
50507, 0.83333333333333, -0.1, 0.20833333333333
50508, 0.83333333333333, -0.12, 0.1875
50509, 0.8125, -0.12, 0.20833333333333
50510, 0.83333333333333, -0.14, 0.20833333333333
50511, 0.83333333333333, -0.16, 0.1875
50512, 0.8125, -0.16, 0.20833333333333
50513, 0.83333333333333, -0.18, 0.20833333333333
50514, 0.83333333333333, -0.02, 0.25
50515, 0.83333333333333, -0.04, 0.22916666666667
50516, 0.8125, -0.04, 0.25
50517, 0.83333333333333, -0.06, 0.25
50518, 0.83333333333333, -0.08, 0.22916666666667
50519, 0.8125, -0.08, 0.25
50520, 0.83333333333333, -0.1, 0.25
50521, 0.83333333333333, -0.12, 0.22916666666667
50522, 0.8125, -0.12, 0.25
50523, 0.83333333333333, -0.14, 0.25
50524, 0.83333333333333, -0.16, 0.22916666666667
50525, 0.8125, -0.16, 0.25
50526, 0.83333333333333, -0.18, 0.25
50527, 0.83333333333333, -0.02, 0.29166666666667
50528, 0.83333333333333, -0.04, 0.27083333333333
50529, 0.8125, -0.04, 0.29166666666667
50530, 0.83333333333333, -0.06, 0.29166666666667
50531, 0.83333333333333, -0.08, 0.27083333333333
50532, 0.8125, -0.08, 0.29166666666667
50533, 0.83333333333333, -0.1, 0.29166666666667
50534, 0.83333333333333, -0.12, 0.27083333333333
50535, 0.8125, -0.12, 0.29166666666667
50536, 0.83333333333333, -0.14, 0.29166666666667
50537, 0.83333333333333, -0.16, 0.27083333333333
50538, 0.8125, -0.16, 0.29166666666667
50539, 0.83333333333333, -0.18, 0.29166666666667
50540, 0.83333333333333, -0.02, 0.33333333333333
50541, 0.83333333333333, -0.04, 0.3125
50542, 0.8125, -0.04, 0.33333333333333
50543, 0.83333333333333, -0.06, 0.33333333333333
50544, 0.83333333333333, -0.08, 0.3125
50545, 0.8125, -0.08, 0.33333333333333
50546, 0.83333333333333, -0.1, 0.33333333333333
50547, 0.83333333333333, -0.12, 0.3125
50548, 0.8125, -0.12, 0.33333333333333
50549, 0.83333333333333, -0.14, 0.33333333333333
50550, 0.83333333333333, -0.16, 0.3125
50551, 0.8125, -0.16, 0.33333333333333
50552, 0.83333333333333, -0.18, 0.33333333333333
50553, 0.83333333333333, -0.02, 0.375
50554, 0.83333333333333, -0.04, 0.35416666666667
50555, 0.8125, -0.04, 0.375
50556, 0.83333333333333, -0.06, 0.375
50557, 0.83333333333333, -0.08, 0.35416666666667
50558, 0.8125, -0.08, 0.375
50559, 0.83333333333333, -0.1, 0.375
50560, 0.83333333333333, -0.12, 0.35416666666667
50561, 0.8125, -0.12, 0.375
50562, 0.83333333333333, -0.14, 0.375
50563, 0.83333333333333, -0.16, 0.35416666666667
50564, 0.8125, -0.16, 0.375
50565, 0.83333333333333, -0.18, 0.375
50566, 0.83333333333333, -0.02, 0.41666666666667
50567, 0.83333333333333, -0.04, 0.39583333333333
50568, 0.8125, -0.04, 0.41666666666667
50569, 0.83333333333333, -0.06, 0.41666666666667
50570, 0.83333333333333, -0.08, 0.39583333333333
50571, 0.8125, -0.08, 0.41666666666667
50572, 0.83333333333333, -0.1, 0.41666666666667
50573, 0.83333333333333, -0.12, 0.39583333333333
50574, 0.8125, -0.12, 0.41666666666667
50575, 0.83333333333333, -0.14, 0.41666666666667
50576, 0.83333333333333, -0.16, 0.39583333333333
50577, 0.8125, -0.16, 0.41666666666667
50578, 0.83333333333333, -0.18, 0.41666666666667
50579, 0.83333333333333, -0.02, 0.45833333333333
50580, 0.83333333333333, -0.04, 0.4375
50581, 0.8125, -0.04, 0.45833333333333
50582, 0.83333333333333, -0.06, 0.45833333333333
50583, 0.83333333333333, -0.08, 0.4375
50584, 0.8125, -0.08, 0.45833333333333
50585, 0.83333333333333, -0.1, 0.45833333333333
50586, 0.83333333333333, -0.12, 0.4375
50587, 0.8125, -0.12, 0.45833333333333
50588, 0.83333333333333, -0.14, 0.45833333333333
50589, 0.83333333333333, -0.16, 0.4375
50590, 0.8125, -0.16, 0.45833333333333
50591, 0.83333333333333, -0.18, 0.45833333333333
50592, 0.83333333333333, -0.04, 0.47916666666667
50593, 0.83333333333333, -0.08, 0.47916666666667
50594, 0.83333333333333, -0.12, 0.47916666666667
50595, 0.83333333333333, -0.16, 0.47916666666667
50596, 0.875, -0.02, 0.041666666666667
50597, 0.875, -0.04, 0.020833333333333
50598, 0.85416666666667, -0.04, 0.041666666666667
50599, 0.875, -0.06, 0.041666666666667
50600, 0.875, -0.08, 0.020833333333333
50601, 0.85416666666667, -0.08, 0.041666666666667
50602, 0.875, -0.1, 0.041666666666667
50603, 0.875, -0.12, 0.020833333333333
50604, 0.85416666666667, -0.12, 0.041666666666667
50605, 0.875, -0.14, 0.041666666666667
50606, 0.875, -0.16, 0.020833333333333
50607, 0.85416666666667, -0.16, 0.041666666666667
50608, 0.875, -0.18, 0.041666666666667
50609, 0.875, -0.02, 0.083333333333333
50610, 0.875, -0.04, 0.0625
50611, 0.85416666666667, -0.04, 0.083333333333333
50612, 0.875, -0.06, 0.083333333333333
50613, 0.875, -0.08, 0.0625
50614, 0.85416666666667, -0.08, 0.083333333333333
50615, 0.875, -0.1, 0.083333333333333
50616, 0.875, -0.12, 0.0625
50617, 0.85416666666667, -0.12, 0.083333333333333
50618, 0.875, -0.14, 0.083333333333333
50619, 0.875, -0.16, 0.0625
50620, 0.85416666666667, -0.16, 0.083333333333333
50621, 0.875, -0.18, 0.083333333333333
50622, 0.875, -0.02, 0.125
50623, 0.875, -0.04, 0.10416666666667
50624, 0.85416666666667, -0.04, 0.125
50625, 0.875, -0.06, 0.125
50626, 0.875, -0.08, 0.10416666666667
50627, 0.85416666666667, -0.08, 0.125
50628, 0.875, -0.1, 0.125
50629, 0.875, -0.12, 0.10416666666667
50630, 0.85416666666667, -0.12, 0.125
50631, 0.875, -0.14, 0.125
50632, 0.875, -0.16, 0.10416666666667
50633, 0.85416666666667, -0.16, 0.125
50634, 0.875, -0.18, 0.125
50635, 0.875, -0.02, 0.16666666666667
50636, 0.875, -0.04, 0.14583333333333
50637, 0.85416666666667, -0.04, 0.16666666666667
50638, 0.875, -0.06, 0.16666666666667
50639, 0.875, -0.08, 0.14583333333333
50640, 0.85416666666667, -0.08, 0.16666666666667
50641, 0.875, -0.1, 0.16666666666667
50642, 0.875, -0.12, 0.14583333333333
50643, 0.85416666666667, -0.12, 0.16666666666667
50644, 0.875, -0.14, 0.16666666666667
50645, 0.875, -0.16, 0.14583333333333
50646, 0.85416666666667, -0.16, 0.16666666666667
50647, 0.875, -0.18, 0.16666666666667
50648, 0.875, -0.02, 0.20833333333333
50649, 0.875, -0.04, 0.1875
50650, 0.85416666666667, -0.04, 0.20833333333333
50651, 0.875, -0.06, 0.20833333333333
50652, 0.875, -0.08, 0.1875
50653, 0.85416666666667, -0.08, 0.20833333333333
50654, 0.875, -0.1, 0.20833333333333
50655, 0.875, -0.12, 0.1875
50656, 0.85416666666667, -0.12, 0.20833333333333
50657, 0.875, -0.14, 0.20833333333333
50658, 0.875, -0.16, 0.1875
50659, 0.85416666666667, -0.16, 0.20833333333333
50660, 0.875, -0.18, 0.20833333333333
50661, 0.875, -0.02, 0.25
50662, 0.875, -0.04, 0.22916666666667
50663, 0.85416666666667, -0.04, 0.25
50664, 0.875, -0.06, 0.25
50665, 0.875, -0.08, 0.22916666666667
50666, 0.85416666666667, -0.08, 0.25
50667, 0.875, -0.1, 0.25
50668, 0.875, -0.12, 0.22916666666667
50669, 0.85416666666667, -0.12, 0.25
50670, 0.875, -0.14, 0.25
50671, 0.875, -0.16, 0.22916666666667
50672, 0.85416666666667, -0.16, 0.25
50673, 0.875, -0.18, 0.25
50674, 0.875, -0.02, 0.29166666666667
50675, 0.875, -0.04, 0.27083333333333
50676, 0.85416666666667, -0.04, 0.29166666666667
50677, 0.875, -0.06, 0.29166666666667
50678, 0.875, -0.08, 0.27083333333333
50679, 0.85416666666667, -0.08, 0.29166666666667
50680, 0.875, -0.1, 0.29166666666667
50681, 0.875, -0.12, 0.27083333333333
50682, 0.85416666666667, -0.12, 0.29166666666667
50683, 0.875, -0.14, 0.29166666666667
50684, 0.875, -0.16, 0.27083333333333
50685, 0.85416666666667, -0.16, 0.29166666666667
50686, 0.875, -0.18, 0.29166666666667
50687, 0.875, -0.02, 0.33333333333333
50688, 0.875, -0.04, 0.3125
50689, 0.85416666666667, -0.04, 0.33333333333333
50690, 0.875, -0.06, 0.33333333333333
50691, 0.875, -0.08, 0.3125
50692, 0.85416666666667, -0.08, 0.33333333333333
50693, 0.875, -0.1, 0.33333333333333
50694, 0.875, -0.12, 0.3125
50695, 0.85416666666667, -0.12, 0.33333333333333
50696, 0.875, -0.14, 0.33333333333333
50697, 0.875, -0.16, 0.3125
50698, 0.85416666666667, -0.16, 0.33333333333333
50699, 0.875, -0.18, 0.33333333333333
50700, 0.875, -0.02, 0.375
50701, 0.875, -0.04, 0.35416666666667
50702, 0.85416666666667, -0.04, 0.375
50703, 0.875, -0.06, 0.375
50704, 0.875, -0.08, 0.35416666666667
50705, 0.85416666666667, -0.08, 0.375
50706, 0.875, -0.1, 0.375
50707, 0.875, -0.12, 0.35416666666667
50708, 0.85416666666667, -0.12, 0.375
50709, 0.875, -0.14, 0.375
50710, 0.875, -0.16, 0.35416666666667
50711, 0.85416666666667, -0.16, 0.375
50712, 0.875, -0.18, 0.375
50713, 0.875, -0.02, 0.41666666666667
50714, 0.875, -0.04, 0.39583333333333
50715, 0.85416666666667, -0.04, 0.41666666666667
50716, 0.875, -0.06, 0.41666666666667
50717, 0.875, -0.08, 0.39583333333333
50718, 0.85416666666667, -0.08, 0.41666666666667
50719, 0.875, -0.1, 0.41666666666667
50720, 0.875, -0.12, 0.39583333333333
50721, 0.85416666666667, -0.12, 0.41666666666667
50722, 0.875, -0.14, 0.41666666666667
50723, 0.875, -0.16, 0.39583333333333
50724, 0.85416666666667, -0.16, 0.41666666666667
50725, 0.875, -0.18, 0.41666666666667
50726, 0.875, -0.02, 0.45833333333333
50727, 0.875, -0.04, 0.4375
50728, 0.85416666666667, -0.04, 0.45833333333333
50729, 0.875, -0.06, 0.45833333333333
50730, 0.875, -0.08, 0.4375
50731, 0.85416666666667, -0.08, 0.45833333333333
50732, 0.875, -0.1, 0.45833333333333
50733, 0.875, -0.12, 0.4375
50734, 0.85416666666667, -0.12, 0.45833333333333
50735, 0.875, -0.14, 0.45833333333333
50736, 0.875, -0.16, 0.4375
50737, 0.85416666666667, -0.16, 0.45833333333333
50738, 0.875, -0.18, 0.45833333333333
50739, 0.875, -0.04, 0.47916666666667
50740, 0.875, -0.08, 0.47916666666667
50741, 0.875, -0.12, 0.47916666666667
50742, 0.875, -0.16, 0.47916666666667
50743, 0.91666666666667, -0.02, 0.041666666666667
50744, 0.91666666666667, -0.04, 0.020833333333333
50745, 0.89583333333333, -0.04, 0.041666666666667
50746, 0.91666666666667, -0.06, 0.041666666666667
50747, 0.91666666666667, -0.08, 0.020833333333333
50748, 0.89583333333333, -0.08, 0.041666666666667
50749, 0.91666666666667, -0.1, 0.041666666666667
50750, 0.91666666666667, -0.12, 0.020833333333333
50751, 0.89583333333333, -0.12, 0.041666666666667
50752, 0.91666666666667, -0.14, 0.041666666666667
50753, 0.91666666666667, -0.16, 0.020833333333333
50754, 0.89583333333333, -0.16, 0.041666666666667
50755, 0.91666666666667, -0.18, 0.041666666666667
50756, 0.91666666666667, -0.02, 0.083333333333333
50757, 0.91666666666667, -0.04, 0.0625
50758, 0.89583333333333, -0.04, 0.083333333333333
50759, 0.91666666666667, -0.06, 0.083333333333333
50760, 0.91666666666667, -0.08, 0.0625
50761, 0.89583333333333, -0.08, 0.083333333333333
50762, 0.91666666666667, -0.1, 0.083333333333333
50763, 0.91666666666667, -0.12, 0.0625
50764, 0.89583333333333, -0.12, 0.083333333333333
50765, 0.91666666666667, -0.14, 0.083333333333333
50766, 0.91666666666667, -0.16, 0.0625
50767, 0.89583333333333, -0.16, 0.083333333333333
50768, 0.91666666666667, -0.18, 0.083333333333333
50769, 0.91666666666667, -0.02, 0.125
50770, 0.91666666666667, -0.04, 0.10416666666667
50771, 0.89583333333333, -0.04, 0.125
50772, 0.91666666666667, -0.06, 0.125
50773, 0.91666666666667, -0.08, 0.10416666666667
50774, 0.89583333333333, -0.08, 0.125
50775, 0.91666666666667, -0.1, 0.125
50776, 0.91666666666667, -0.12, 0.10416666666667
50777, 0.89583333333333, -0.12, 0.125
50778, 0.91666666666667, -0.14, 0.125
50779, 0.91666666666667, -0.16, 0.10416666666667
50780, 0.89583333333333, -0.16, 0.125
50781, 0.91666666666667, -0.18, 0.125
50782, 0.91666666666667, -0.02, 0.16666666666667
50783, 0.91666666666667, -0.04, 0.14583333333333
50784, 0.89583333333333, -0.04, 0.16666666666667
50785, 0.91666666666667, -0.06, 0.16666666666667
50786, 0.91666666666667, -0.08, 0.14583333333333
50787, 0.89583333333333, -0.08, 0.16666666666667
50788, 0.91666666666667, -0.1, 0.16666666666667
50789, 0.91666666666667, -0.12, 0.14583333333333
50790, 0.89583333333333, -0.12, 0.16666666666667
50791, 0.91666666666667, -0.14, 0.16666666666667
50792, 0.91666666666667, -0.16, 0.14583333333333
50793, 0.89583333333333, -0.16, 0.16666666666667
50794, 0.91666666666667, -0.18, 0.16666666666667
50795, 0.91666666666667, -0.02, 0.20833333333333
50796, 0.91666666666667, -0.04, 0.1875
50797, 0.89583333333333, -0.04, 0.20833333333333
50798, 0.91666666666667, -0.06, 0.20833333333333
50799, 0.91666666666667, -0.08, 0.1875
50800, 0.89583333333333, -0.08, 0.20833333333333
50801, 0.91666666666667, -0.1, 0.20833333333333
50802, 0.91666666666667, -0.12, 0.1875
50803, 0.89583333333333, -0.12, 0.20833333333333
50804, 0.91666666666667, -0.14, 0.20833333333333
50805, 0.91666666666667, -0.16, 0.1875
50806, 0.89583333333333, -0.16, 0.20833333333333
50807, 0.91666666666667, -0.18, 0.20833333333333
50808, 0.91666666666667, -0.02, 0.25
50809, 0.91666666666667, -0.04, 0.22916666666667
50810, 0.89583333333333, -0.04, 0.25
50811, 0.91666666666667, -0.06, 0.25
50812, 0.91666666666667, -0.08, 0.22916666666667
50813, 0.89583333333333, -0.08, 0.25
50814, 0.91666666666667, -0.1, 0.25
50815, 0.91666666666667, -0.12, 0.22916666666667
50816, 0.89583333333333, -0.12, 0.25
50817, 0.91666666666667, -0.14, 0.25
50818, 0.91666666666667, -0.16, 0.22916666666667
50819, 0.89583333333333, -0.16, 0.25
50820, 0.91666666666667, -0.18, 0.25
50821, 0.91666666666667, -0.02, 0.29166666666667
50822, 0.91666666666667, -0.04, 0.27083333333333
50823, 0.89583333333333, -0.04, 0.29166666666667
50824, 0.91666666666667, -0.06, 0.29166666666667
50825, 0.91666666666667, -0.08, 0.27083333333333
50826, 0.89583333333333, -0.08, 0.29166666666667
50827, 0.91666666666667, -0.1, 0.29166666666667
50828, 0.91666666666667, -0.12, 0.27083333333333
50829, 0.89583333333333, -0.12, 0.29166666666667
50830, 0.91666666666667, -0.14, 0.29166666666667
50831, 0.91666666666667, -0.16, 0.27083333333333
50832, 0.89583333333333, -0.16, 0.29166666666667
50833, 0.91666666666667, -0.18, 0.29166666666667
50834, 0.91666666666667, -0.02, 0.33333333333333
50835, 0.91666666666667, -0.04, 0.3125
50836, 0.89583333333333, -0.04, 0.33333333333333
50837, 0.91666666666667, -0.06, 0.33333333333333
50838, 0.91666666666667, -0.08, 0.3125
50839, 0.89583333333333, -0.08, 0.33333333333333
50840, 0.91666666666667, -0.1, 0.33333333333333
50841, 0.91666666666667, -0.12, 0.3125
50842, 0.89583333333333, -0.12, 0.33333333333333
50843, 0.91666666666667, -0.14, 0.33333333333333
50844, 0.91666666666667, -0.16, 0.3125
50845, 0.89583333333333, -0.16, 0.33333333333333
50846, 0.91666666666667, -0.18, 0.33333333333333
50847, 0.91666666666667, -0.02, 0.375
50848, 0.91666666666667, -0.04, 0.35416666666667
50849, 0.89583333333333, -0.04, 0.375
50850, 0.91666666666667, -0.06, 0.375
50851, 0.91666666666667, -0.08, 0.35416666666667
50852, 0.89583333333333, -0.08, 0.375
50853, 0.91666666666667, -0.1, 0.375
50854, 0.91666666666667, -0.12, 0.35416666666667
50855, 0.89583333333333, -0.12, 0.375
50856, 0.91666666666667, -0.14, 0.375
50857, 0.91666666666667, -0.16, 0.35416666666667
50858, 0.89583333333333, -0.16, 0.375
50859, 0.91666666666667, -0.18, 0.375
50860, 0.91666666666667, -0.02, 0.41666666666667
50861, 0.91666666666667, -0.04, 0.39583333333333
50862, 0.89583333333333, -0.04, 0.41666666666667
50863, 0.91666666666667, -0.06, 0.41666666666667
50864, 0.91666666666667, -0.08, 0.39583333333333
50865, 0.89583333333333, -0.08, 0.41666666666667
50866, 0.91666666666667, -0.1, 0.41666666666667
50867, 0.91666666666667, -0.12, 0.39583333333333
50868, 0.89583333333333, -0.12, 0.41666666666667
50869, 0.91666666666667, -0.14, 0.41666666666667
50870, 0.91666666666667, -0.16, 0.39583333333333
50871, 0.89583333333333, -0.16, 0.41666666666667
50872, 0.91666666666667, -0.18, 0.41666666666667
50873, 0.91666666666667, -0.02, 0.45833333333333
50874, 0.91666666666667, -0.04, 0.4375
50875, 0.89583333333333, -0.04, 0.45833333333333
50876, 0.91666666666667, -0.06, 0.45833333333333
50877, 0.91666666666667, -0.08, 0.4375
50878, 0.89583333333333, -0.08, 0.45833333333333
50879, 0.91666666666667, -0.1, 0.45833333333333
50880, 0.91666666666667, -0.12, 0.4375
50881, 0.89583333333333, -0.12, 0.45833333333333
50882, 0.91666666666667, -0.14, 0.45833333333333
50883, 0.91666666666667, -0.16, 0.4375
50884, 0.89583333333333, -0.16, 0.45833333333333
50885, 0.91666666666667, -0.18, 0.45833333333333
50886, 0.91666666666667, -0.04, 0.47916666666667
50887, 0.91666666666667, -0.08, 0.47916666666667
50888, 0.91666666666667, -0.12, 0.47916666666667
50889, 0.91666666666667, -0.16, 0.47916666666667
50890, 0.95833333333333, -0.02, 0.041666666666667
50891, 0.95833333333333, -0.04, 0.020833333333333
50892, 0.9375, -0.04, 0.041666666666667
50893, 0.95833333333333, -0.06, 0.041666666666667
50894, 0.95833333333333, -0.08, 0.020833333333333
50895, 0.9375, -0.08, 0.041666666666667
50896, 0.95833333333333, -0.1, 0.041666666666667
50897, 0.95833333333333, -0.12, 0.020833333333333
50898, 0.9375, -0.12, 0.041666666666667
50899, 0.95833333333333, -0.14, 0.041666666666667
50900, 0.95833333333333, -0.16, 0.020833333333333
50901, 0.9375, -0.16, 0.041666666666667
50902, 0.95833333333333, -0.18, 0.041666666666667
50903, 0.95833333333333, -0.02, 0.083333333333333
50904, 0.95833333333333, -0.04, 0.0625
50905, 0.9375, -0.04, 0.083333333333333
50906, 0.95833333333333, -0.06, 0.083333333333333
50907, 0.95833333333333, -0.08, 0.0625
50908, 0.9375, -0.08, 0.083333333333333
50909, 0.95833333333333, -0.1, 0.083333333333333
50910, 0.95833333333333, -0.12, 0.0625
50911, 0.9375, -0.12, 0.083333333333333
50912, 0.95833333333333, -0.14, 0.083333333333333
50913, 0.95833333333333, -0.16, 0.0625
50914, 0.9375, -0.16, 0.083333333333333
50915, 0.95833333333333, -0.18, 0.083333333333333
50916, 0.95833333333333, -0.02, 0.125
50917, 0.95833333333333, -0.04, 0.10416666666667
50918, 0.9375, -0.04, 0.125
50919, 0.95833333333333, -0.06, 0.125
50920, 0.95833333333333, -0.08, 0.10416666666667
50921, 0.9375, -0.08, 0.125
50922, 0.95833333333333, -0.1, 0.125
50923, 0.95833333333333, -0.12, 0.10416666666667
50924, 0.9375, -0.12, 0.125
50925, 0.95833333333333, -0.14, 0.125
50926, 0.95833333333333, -0.16, 0.10416666666667
50927, 0.9375, -0.16, 0.125
50928, 0.95833333333333, -0.18, 0.125
50929, 0.95833333333333, -0.02, 0.16666666666667
50930, 0.95833333333333, -0.04, 0.14583333333333
50931, 0.9375, -0.04, 0.16666666666667
50932, 0.95833333333333, -0.06, 0.16666666666667
50933, 0.95833333333333, -0.08, 0.14583333333333
50934, 0.9375, -0.08, 0.16666666666667
50935, 0.95833333333333, -0.1, 0.16666666666667
50936, 0.95833333333333, -0.12, 0.14583333333333
50937, 0.9375, -0.12, 0.16666666666667
50938, 0.95833333333333, -0.14, 0.16666666666667
50939, 0.95833333333333, -0.16, 0.14583333333333
50940, 0.9375, -0.16, 0.16666666666667
50941, 0.95833333333333, -0.18, 0.16666666666667
50942, 0.95833333333333, -0.02, 0.20833333333333
50943, 0.95833333333333, -0.04, 0.1875
50944, 0.9375, -0.04, 0.20833333333333
50945, 0.95833333333333, -0.06, 0.20833333333333
50946, 0.95833333333333, -0.08, 0.1875
50947, 0.9375, -0.08, 0.20833333333333
50948, 0.95833333333333, -0.1, 0.20833333333333
50949, 0.95833333333333, -0.12, 0.1875
50950, 0.9375, -0.12, 0.20833333333333
50951, 0.95833333333333, -0.14, 0.20833333333333
50952, 0.95833333333333, -0.16, 0.1875
50953, 0.9375, -0.16, 0.20833333333333
50954, 0.95833333333333, -0.18, 0.20833333333333
50955, 0.95833333333333, -0.02, 0.25
50956, 0.95833333333333, -0.04, 0.22916666666667
50957, 0.9375, -0.04, 0.25
50958, 0.95833333333333, -0.06, 0.25
50959, 0.95833333333333, -0.08, 0.22916666666667
50960, 0.9375, -0.08, 0.25
50961, 0.95833333333333, -0.1, 0.25
50962, 0.95833333333333, -0.12, 0.22916666666667
50963, 0.9375, -0.12, 0.25
50964, 0.95833333333333, -0.14, 0.25
50965, 0.95833333333333, -0.16, 0.22916666666667
50966, 0.9375, -0.16, 0.25
50967, 0.95833333333333, -0.18, 0.25
50968, 0.95833333333333, -0.02, 0.29166666666667
50969, 0.95833333333333, -0.04, 0.27083333333333
50970, 0.9375, -0.04, 0.29166666666667
50971, 0.95833333333333, -0.06, 0.29166666666667
50972, 0.95833333333333, -0.08, 0.27083333333333
50973, 0.9375, -0.08, 0.29166666666667
50974, 0.95833333333333, -0.1, 0.29166666666667
50975, 0.95833333333333, -0.12, 0.27083333333333
50976, 0.9375, -0.12, 0.29166666666667
50977, 0.95833333333333, -0.14, 0.29166666666667
50978, 0.95833333333333, -0.16, 0.27083333333333
50979, 0.9375, -0.16, 0.29166666666667
50980, 0.95833333333333, -0.18, 0.29166666666667
50981, 0.95833333333333, -0.02, 0.33333333333333
50982, 0.95833333333333, -0.04, 0.3125
50983, 0.9375, -0.04, 0.33333333333333
50984, 0.95833333333333, -0.06, 0.33333333333333
50985, 0.95833333333333, -0.08, 0.3125
50986, 0.9375, -0.08, 0.33333333333333
50987, 0.95833333333333, -0.1, 0.33333333333333
50988, 0.95833333333333, -0.12, 0.3125
50989, 0.9375, -0.12, 0.33333333333333
50990, 0.95833333333333, -0.14, 0.33333333333333
50991, 0.95833333333333, -0.16, 0.3125
50992, 0.9375, -0.16, 0.33333333333333
50993, 0.95833333333333, -0.18, 0.33333333333333
50994, 0.95833333333333, -0.02, 0.375
50995, 0.95833333333333, -0.04, 0.35416666666667
50996, 0.9375, -0.04, 0.375
50997, 0.95833333333333, -0.06, 0.375
50998, 0.95833333333333, -0.08, 0.35416666666667
50999, 0.9375, -0.08, 0.375
51000, 0.95833333333333, -0.1, 0.375
51001, 0.95833333333333, -0.12, 0.35416666666667
51002, 0.9375, -0.12, 0.375
51003, 0.95833333333333, -0.14, 0.375
51004, 0.95833333333333, -0.16, 0.35416666666667
51005, 0.9375, -0.16, 0.375
51006, 0.95833333333333, -0.18, 0.375
51007, 0.95833333333333, -0.02, 0.41666666666667
51008, 0.95833333333333, -0.04, 0.39583333333333
51009, 0.9375, -0.04, 0.41666666666667
51010, 0.95833333333333, -0.06, 0.41666666666667
51011, 0.95833333333333, -0.08, 0.39583333333333
51012, 0.9375, -0.08, 0.41666666666667
51013, 0.95833333333333, -0.1, 0.41666666666667
51014, 0.95833333333333, -0.12, 0.39583333333333
51015, 0.9375, -0.12, 0.41666666666667
51016, 0.95833333333333, -0.14, 0.41666666666667
51017, 0.95833333333333, -0.16, 0.39583333333333
51018, 0.9375, -0.16, 0.41666666666667
51019, 0.95833333333333, -0.18, 0.41666666666667
51020, 0.95833333333333, -0.02, 0.45833333333333
51021, 0.95833333333333, -0.04, 0.4375
51022, 0.9375, -0.04, 0.45833333333333
51023, 0.95833333333333, -0.06, 0.45833333333333
51024, 0.95833333333333, -0.08, 0.4375
51025, 0.9375, -0.08, 0.45833333333333
51026, 0.95833333333333, -0.1, 0.45833333333333
51027, 0.95833333333333, -0.12, 0.4375
51028, 0.9375, -0.12, 0.45833333333333
51029, 0.95833333333333, -0.14, 0.45833333333333
51030, 0.95833333333333, -0.16, 0.4375
51031, 0.9375, -0.16, 0.45833333333333
51032, 0.95833333333333, -0.18, 0.45833333333333
51033, 0.95833333333333, -0.04, 0.47916666666667
51034, 0.95833333333333, -0.08, 0.47916666666667
51035, 0.95833333333333, -0.12, 0.47916666666667
51036, 0.95833333333333, -0.16, 0.47916666666667
51037, 0.97916666666667, -0.04, 0.041666666666667
51038, 0.97916666666667, -0.08, 0.041666666666667
51039, 0.97916666666667, -0.12, 0.041666666666667
51040, 0.97916666666667, -0.16, 0.041666666666667
51041, 0.97916666666667, -0.04, 0.083333333333333
51042, 0.97916666666667, -0.08, 0.083333333333333
51043, 0.97916666666667, -0.12, 0.083333333333333
51044, 0.97916666666667, -0.16, 0.083333333333333
51045, 0.97916666666667, -0.04, 0.125
51046, 0.97916666666667, -0.08, 0.125
51047, 0.97916666666667, -0.12, 0.125
51048, 0.97916666666667, -0.16, 0.125
51049, 0.97916666666667, -0.04, 0.16666666666667
51050, 0.97916666666667, -0.08, 0.16666666666667
51051, 0.97916666666667, -0.12, 0.16666666666667
51052, 0.97916666666667, -0.16, 0.16666666666667
51053, 0.97916666666667, -0.04, 0.20833333333333
51054, 0.97916666666667, -0.08, 0.20833333333333
51055, 0.97916666666667, -0.12, 0.20833333333333
51056, 0.97916666666667, -0.16, 0.20833333333333
51057, 0.97916666666667, -0.04, 0.25
51058, 0.97916666666667, -0.08, 0.25
51059, 0.97916666666667, -0.12, 0.25
51060, 0.97916666666667, -0.16, 0.25
51061, 0.97916666666667, -0.04, 0.29166666666667
51062, 0.97916666666667, -0.08, 0.29166666666667
51063, 0.97916666666667, -0.12, 0.29166666666667
51064, 0.97916666666667, -0.16, 0.29166666666667
51065, 0.97916666666667, -0.04, 0.33333333333333
51066, 0.97916666666667, -0.08, 0.33333333333333
51067, 0.97916666666667, -0.12, 0.33333333333333
51068, 0.97916666666667, -0.16, 0.33333333333333
51069, 0.97916666666667, -0.04, 0.375
51070, 0.97916666666667, -0.08, 0.375
51071, 0.97916666666667, -0.12, 0.375
51072, 0.97916666666667, -0.16, 0.375
51073, 0.97916666666667, -0.04, 0.41666666666667
51074, 0.97916666666667, -0.08, 0.41666666666667
51075, 0.97916666666667, -0.12, 0.41666666666667
51076, 0.97916666666667, -0.16, 0.41666666666667
51077, 0.97916666666667, -0.04, 0.45833333333333
51078, 0.97916666666667, -0.08, 0.45833333333333
51079, 0.97916666666667, -0.12, 0.45833333333333
51080, 0.97916666666667, -0.16, 0.45833333333333
51081, -0.05, -0.04, 0.041666666666667
51082, -0.05, -0.08, 0.041666666666667
51083, -0.05, -0.12, 0.041666666666667
51084, -0.05, -0.16, 0.041666666666667
51085, -0.05, -0.04, 0.083333333333333
51086, -0.05, -0.08, 0.083333333333333
51087, -0.05, -0.12, 0.083333333333333
51088, -0.05, -0.16, 0.083333333333333
51089, -0.05, -0.04, 0.125
51090, -0.05, -0.08, 0.125
51091, -0.05, -0.12, 0.125
51092, -0.05, -0.16, 0.125
51093, -0.05, -0.04, 0.16666666666667
51094, -0.05, -0.08, 0.16666666666667
51095, -0.05, -0.12, 0.16666666666667
51096, -0.05, -0.16, 0.16666666666667
51097, -0.05, -0.04, 0.20833333333333
51098, -0.05, -0.08, 0.20833333333333
51099, -0.05, -0.12, 0.20833333333333
51100, -0.05, -0.16, 0.20833333333333
51101, -0.05, -0.04, 0.25
51102, -0.05, -0.08, 0.25
51103, -0.05, -0.12, 0.25
51104, -0.05, -0.16, 0.25
51105, -0.05, -0.04, 0.29166666666667
51106, -0.05, -0.08, 0.29166666666667
51107, -0.05, -0.12, 0.29166666666667
51108, -0.05, -0.16, 0.29166666666667
51109, -0.05, -0.04, 0.33333333333333
51110, -0.05, -0.08, 0.33333333333333
51111, -0.05, -0.12, 0.33333333333333
51112, -0.05, -0.16, 0.33333333333333
51113, -0.05, -0.04, 0.375
51114, -0.05, -0.08, 0.375
51115, -0.05, -0.12, 0.375
51116, -0.05, -0.16, 0.375
51117, -0.05, -0.04, 0.41666666666667
51118, -0.05, -0.08, 0.41666666666667
51119, -0.05, -0.12, 0.41666666666667
51120, -0.05, -0.16, 0.41666666666667
51121, -0.05, -0.04, 0.45833333333333
51122, -0.05, -0.08, 0.45833333333333
51123, -0.05, -0.12, 0.45833333333333
51124, -0.05, -0.16, 0.45833333333333
51125, 1.2416666666667, -0.04, 0.041666666666667
51126, 1.2416666666667, -0.08, 0.041666666666667
51127, 1.2416666666667, -0.12, 0.041666666666667
51128, 1.2416666666667, -0.16, 0.041666666666667
51129, 1.2833333333333, -0.04, 0.041666666666667
51130, 1.2833333333333, -0.08, 0.041666666666667
51131, 1.2833333333333, -0.12, 0.041666666666667
51132, 1.2833333333333, -0.16, 0.041666666666667
51133, 1.325, -0.04, 0.041666666666667
51134, 1.325, -0.08, 0.041666666666667
51135, 1.325, -0.12, 0.041666666666667
51136, 1.325, -0.16, 0.041666666666667
51137, 1.3666666666667, -0.04, 0.041666666666667
51138, 1.3666666666667, -0.08, 0.041666666666667
51139, 1.3666666666667, -0.12, 0.041666666666667
51140, 1.3666666666667, -0.16, 0.041666666666667
51141, 1.4083333333333, -0.04, 0.041666666666667
51142, 1.4083333333333, -0.08, 0.041666666666667
51143, 1.4083333333333, -0.12, 0.041666666666667
51144, 1.4083333333333, -0.16, 0.041666666666667
51145, 1.45, -0.04, 0.041666666666667
51146, 1.45, -0.08, 0.041666666666667
51147, 1.45, -0.12, 0.041666666666667
51148, 1.45, -0.16, 0.041666666666667
51149, 1.4916666666667, -0.04, 0.041666666666667
51150, 1.4916666666667, -0.08, 0.041666666666667
51151, 1.4916666666667, -0.12, 0.041666666666667
51152, 1.4916666666667, -0.16, 0.041666666666667
51153, 1.5333333333333, -0.04, 0.041666666666667
51154, 1.5333333333333, -0.08, 0.041666666666667
51155, 1.5333333333333, -0.12, 0.041666666666667
51156, 1.5333333333333, -0.16, 0.041666666666667
51157, 1.575, -0.04, 0.041666666666667
51158, 1.575, -0.08, 0.041666666666667
51159, 1.575, -0.12, 0.041666666666667
51160, 1.575, -0.16, 0.041666666666667
51161, 1.6166666666667, -0.04, 0.041666666666667
51162, 1.6166666666667, -0.08, 0.041666666666667
51163, 1.6166666666667, -0.12, 0.041666666666667
51164, 1.6166666666667, -0.16, 0.041666666666667
51165, 1.6583333333333, -0.04, 0.041666666666667
51166, 1.6583333333333, -0.08, 0.041666666666667
51167, 1.6583333333333, -0.12, 0.041666666666667
51168, 1.6583333333333, -0.16, 0.041666666666667
51169, 1.7, -0.04, 0.041666666666667
51170, 1.7, -0.08, 0.041666666666667
51171, 1.7, -0.12, 0.041666666666667
51172, 1.7, -0.16, 0.041666666666667
51173, 1.7416666666667, -0.04, 0.041666666666667
51174, 1.7416666666667, -0.08, 0.041666666666667
51175, 1.7416666666667, -0.12, 0.041666666666667
51176, 1.7416666666667, -0.16, 0.041666666666667
51177, 1.7833333333333, -0.04, 0.041666666666667
51178, 1.7833333333333, -0.08, 0.041666666666667
51179, 1.7833333333333, -0.12, 0.041666666666667
51180, 1.7833333333333, -0.16, 0.041666666666667
51181, 1.825, -0.04, 0.041666666666667
51182, 1.825, -0.08, 0.041666666666667
51183, 1.825, -0.12, 0.041666666666667
51184, 1.825, -0.16, 0.041666666666667
51185, 1.8666666666667, -0.04, 0.041666666666667
51186, 1.8666666666667, -0.08, 0.041666666666667
51187, 1.8666666666667, -0.12, 0.041666666666667
51188, 1.8666666666667, -0.16, 0.041666666666667
51189, 1.9083333333333, -0.04, 0.041666666666667
51190, 1.9083333333333, -0.08, 0.041666666666667
51191, 1.9083333333333, -0.12, 0.041666666666667
51192, 1.9083333333333, -0.16, 0.041666666666667
51193, 1.95, -0.04, 0.041666666666667
51194, 1.95, -0.08, 0.041666666666667
51195, 1.95, -0.12, 0.041666666666667
51196, 1.95, -0.16, 0.041666666666667
51197, 1.9916666666667, -0.04, 0.041666666666667
51198, 1.9916666666667, -0.08, 0.041666666666667
51199, 1.9916666666667, -0.12, 0.041666666666667
51200, 1.9916666666667, -0.16, 0.041666666666667
51201, 2.0333333333333, -0.04, 0.041666666666667
51202, 2.0333333333333, -0.08, 0.041666666666667
51203, 2.0333333333333, -0.12, 0.041666666666667
51204, 2.0333333333333, -0.16, 0.041666666666667
51205, 2.075, -0.04, 0.041666666666667
51206, 2.075, -0.08, 0.041666666666667
51207, 2.075, -0.12, 0.041666666666667
51208, 2.075, -0.16, 0.041666666666667
51209, 2.1166666666667, -0.04, 0.041666666666667
51210, 2.1166666666667, -0.08, 0.041666666666667
51211, 2.1166666666667, -0.12, 0.041666666666667
51212, 2.1166666666667, -0.16, 0.041666666666667
51213, 2.1583333333333, -0.04, 0.041666666666667
51214, 2.1583333333333, -0.08, 0.041666666666667
51215, 2.1583333333333, -0.12, 0.041666666666667
51216, 2.1583333333333, -0.16, 0.041666666666667
51217, 1.2416666666667, -0.04, 0.083333333333333
51218, 1.2416666666667, -0.08, 0.083333333333333
51219, 1.2416666666667, -0.12, 0.083333333333333
51220, 1.2416666666667, -0.16, 0.083333333333333
51221, 1.2833333333333, -0.04, 0.083333333333333
51222, 1.2833333333333, -0.08, 0.083333333333333
51223, 1.2833333333333, -0.12, 0.083333333333333
51224, 1.2833333333333, -0.16, 0.083333333333333
51225, 1.325, -0.04, 0.083333333333333
51226, 1.325, -0.08, 0.083333333333333
51227, 1.325, -0.12, 0.083333333333333
51228, 1.325, -0.16, 0.083333333333333
51229, 1.3666666666667, -0.04, 0.083333333333333
51230, 1.3666666666667, -0.08, 0.083333333333333
51231, 1.3666666666667, -0.12, 0.083333333333333
51232, 1.3666666666667, -0.16, 0.083333333333333
51233, 1.4083333333333, -0.04, 0.083333333333333
51234, 1.4083333333333, -0.08, 0.083333333333333
51235, 1.4083333333333, -0.12, 0.083333333333333
51236, 1.4083333333333, -0.16, 0.083333333333333
51237, 1.45, -0.04, 0.083333333333333
51238, 1.45, -0.08, 0.083333333333333
51239, 1.45, -0.12, 0.083333333333333
51240, 1.45, -0.16, 0.083333333333333
51241, 1.4916666666667, -0.04, 0.083333333333333
51242, 1.4916666666667, -0.08, 0.083333333333333
51243, 1.4916666666667, -0.12, 0.083333333333333
51244, 1.4916666666667, -0.16, 0.083333333333333
51245, 1.5333333333333, -0.04, 0.083333333333333
51246, 1.5333333333333, -0.08, 0.083333333333333
51247, 1.5333333333333, -0.12, 0.083333333333333
51248, 1.5333333333333, -0.16, 0.083333333333333
51249, 1.575, -0.04, 0.083333333333333
51250, 1.575, -0.08, 0.083333333333333
51251, 1.575, -0.12, 0.083333333333333
51252, 1.575, -0.16, 0.083333333333333
51253, 1.6166666666667, -0.04, 0.083333333333333
51254, 1.6166666666667, -0.08, 0.083333333333333
51255, 1.6166666666667, -0.12, 0.083333333333333
51256, 1.6166666666667, -0.16, 0.083333333333333
51257, 1.6583333333333, -0.04, 0.083333333333333
51258, 1.6583333333333, -0.08, 0.083333333333333
51259, 1.6583333333333, -0.12, 0.083333333333333
51260, 1.6583333333333, -0.16, 0.083333333333333
51261, 1.7, -0.04, 0.083333333333333
51262, 1.7, -0.08, 0.083333333333333
51263, 1.7, -0.12, 0.083333333333333
51264, 1.7, -0.16, 0.083333333333333
51265, 1.7416666666667, -0.04, 0.083333333333333
51266, 1.7416666666667, -0.08, 0.083333333333333
51267, 1.7416666666667, -0.12, 0.083333333333333
51268, 1.7416666666667, -0.16, 0.083333333333333
51269, 1.7833333333333, -0.04, 0.083333333333333
51270, 1.7833333333333, -0.08, 0.083333333333333
51271, 1.7833333333333, -0.12, 0.083333333333333
51272, 1.7833333333333, -0.16, 0.083333333333333
51273, 1.825, -0.04, 0.083333333333333
51274, 1.825, -0.08, 0.083333333333333
51275, 1.825, -0.12, 0.083333333333333
51276, 1.825, -0.16, 0.083333333333333
51277, 1.8666666666667, -0.04, 0.083333333333333
51278, 1.8666666666667, -0.08, 0.083333333333333
51279, 1.8666666666667, -0.12, 0.083333333333333
51280, 1.8666666666667, -0.16, 0.083333333333333
51281, 1.9083333333333, -0.04, 0.083333333333333
51282, 1.9083333333333, -0.08, 0.083333333333333
51283, 1.9083333333333, -0.12, 0.083333333333333
51284, 1.9083333333333, -0.16, 0.083333333333333
51285, 1.95, -0.04, 0.083333333333333
51286, 1.95, -0.08, 0.083333333333333
51287, 1.95, -0.12, 0.083333333333333
51288, 1.95, -0.16, 0.083333333333333
51289, 1.9916666666667, -0.04, 0.083333333333333
51290, 1.9916666666667, -0.08, 0.083333333333333
51291, 1.9916666666667, -0.12, 0.083333333333333
51292, 1.9916666666667, -0.16, 0.083333333333333
51293, 2.0333333333333, -0.04, 0.083333333333333
51294, 2.0333333333333, -0.08, 0.083333333333333
51295, 2.0333333333333, -0.12, 0.083333333333333
51296, 2.0333333333333, -0.16, 0.083333333333333
51297, 2.075, -0.04, 0.083333333333333
51298, 2.075, -0.08, 0.083333333333333
51299, 2.075, -0.12, 0.083333333333333
51300, 2.075, -0.16, 0.083333333333333
51301, 2.1166666666667, -0.04, 0.083333333333333
51302, 2.1166666666667, -0.08, 0.083333333333333
51303, 2.1166666666667, -0.12, 0.083333333333333
51304, 2.1166666666667, -0.16, 0.083333333333333
51305, 2.1583333333333, -0.04, 0.083333333333333
51306, 2.1583333333333, -0.08, 0.083333333333333
51307, 2.1583333333333, -0.12, 0.083333333333333
51308, 2.1583333333333, -0.16, 0.083333333333333
51309, 1.2416666666667, -0.04, 0.125
51310, 1.2416666666667, -0.08, 0.125
51311, 1.2416666666667, -0.12, 0.125
51312, 1.2416666666667, -0.16, 0.125
51313, 1.2833333333333, -0.04, 0.125
51314, 1.2833333333333, -0.08, 0.125
51315, 1.2833333333333, -0.12, 0.125
51316, 1.2833333333333, -0.16, 0.125
51317, 1.325, -0.04, 0.125
51318, 1.325, -0.08, 0.125
51319, 1.325, -0.12, 0.125
51320, 1.325, -0.16, 0.125
51321, 1.3666666666667, -0.04, 0.125
51322, 1.3666666666667, -0.08, 0.125
51323, 1.3666666666667, -0.12, 0.125
51324, 1.3666666666667, -0.16, 0.125
51325, 1.4083333333333, -0.04, 0.125
51326, 1.4083333333333, -0.08, 0.125
51327, 1.4083333333333, -0.12, 0.125
51328, 1.4083333333333, -0.16, 0.125
51329, 1.45, -0.04, 0.125
51330, 1.45, -0.08, 0.125
51331, 1.45, -0.12, 0.125
51332, 1.45, -0.16, 0.125
51333, 1.4916666666667, -0.04, 0.125
51334, 1.4916666666667, -0.08, 0.125
51335, 1.4916666666667, -0.12, 0.125
51336, 1.4916666666667, -0.16, 0.125
51337, 1.5333333333333, -0.04, 0.125
51338, 1.5333333333333, -0.08, 0.125
51339, 1.5333333333333, -0.12, 0.125
51340, 1.5333333333333, -0.16, 0.125
51341, 1.575, -0.04, 0.125
51342, 1.575, -0.08, 0.125
51343, 1.575, -0.12, 0.125
51344, 1.575, -0.16, 0.125
51345, 1.6166666666667, -0.04, 0.125
51346, 1.6166666666667, -0.08, 0.125
51347, 1.6166666666667, -0.12, 0.125
51348, 1.6166666666667, -0.16, 0.125
51349, 1.6583333333333, -0.04, 0.125
51350, 1.6583333333333, -0.08, 0.125
51351, 1.6583333333333, -0.12, 0.125
51352, 1.6583333333333, -0.16, 0.125
51353, 1.7, -0.04, 0.125
51354, 1.7, -0.08, 0.125
51355, 1.7, -0.12, 0.125
51356, 1.7, -0.16, 0.125
51357, 1.7416666666667, -0.04, 0.125
51358, 1.7416666666667, -0.08, 0.125
51359, 1.7416666666667, -0.12, 0.125
51360, 1.7416666666667, -0.16, 0.125
51361, 1.7833333333333, -0.04, 0.125
51362, 1.7833333333333, -0.08, 0.125
51363, 1.7833333333333, -0.12, 0.125
51364, 1.7833333333333, -0.16, 0.125
51365, 1.825, -0.04, 0.125
51366, 1.825, -0.08, 0.125
51367, 1.825, -0.12, 0.125
51368, 1.825, -0.16, 0.125
51369, 1.8666666666667, -0.04, 0.125
51370, 1.8666666666667, -0.08, 0.125
51371, 1.8666666666667, -0.12, 0.125
51372, 1.8666666666667, -0.16, 0.125
51373, 1.9083333333333, -0.04, 0.125
51374, 1.9083333333333, -0.08, 0.125
51375, 1.9083333333333, -0.12, 0.125
51376, 1.9083333333333, -0.16, 0.125
51377, 1.95, -0.04, 0.125
51378, 1.95, -0.08, 0.125
51379, 1.95, -0.12, 0.125
51380, 1.95, -0.16, 0.125
51381, 1.9916666666667, -0.04, 0.125
51382, 1.9916666666667, -0.08, 0.125
51383, 1.9916666666667, -0.12, 0.125
51384, 1.9916666666667, -0.16, 0.125
51385, 2.0333333333333, -0.04, 0.125
51386, 2.0333333333333, -0.08, 0.125
51387, 2.0333333333333, -0.12, 0.125
51388, 2.0333333333333, -0.16, 0.125
51389, 2.075, -0.04, 0.125
51390, 2.075, -0.08, 0.125
51391, 2.075, -0.12, 0.125
51392, 2.075, -0.16, 0.125
51393, 2.1166666666667, -0.04, 0.125
51394, 2.1166666666667, -0.08, 0.125
51395, 2.1166666666667, -0.12, 0.125
51396, 2.1166666666667, -0.16, 0.125
51397, 2.1583333333333, -0.04, 0.125
51398, 2.1583333333333, -0.08, 0.125
51399, 2.1583333333333, -0.12, 0.125
51400, 2.1583333333333, -0.16, 0.125
51401, 1.2416666666667, -0.04, 0.16666666666667
51402, 1.2416666666667, -0.08, 0.16666666666667
51403, 1.2416666666667, -0.12, 0.16666666666667
51404, 1.2416666666667, -0.16, 0.16666666666667
51405, 1.2833333333333, -0.04, 0.16666666666667
51406, 1.2833333333333, -0.08, 0.16666666666667
51407, 1.2833333333333, -0.12, 0.16666666666667
51408, 1.2833333333333, -0.16, 0.16666666666667
51409, 1.325, -0.04, 0.16666666666667
51410, 1.325, -0.08, 0.16666666666667
51411, 1.325, -0.12, 0.16666666666667
51412, 1.325, -0.16, 0.16666666666667
51413, 1.3666666666667, -0.04, 0.16666666666667
51414, 1.3666666666667, -0.08, 0.16666666666667
51415, 1.3666666666667, -0.12, 0.16666666666667
51416, 1.3666666666667, -0.16, 0.16666666666667
51417, 1.4083333333333, -0.04, 0.16666666666667
51418, 1.4083333333333, -0.08, 0.16666666666667
51419, 1.4083333333333, -0.12, 0.16666666666667
51420, 1.4083333333333, -0.16, 0.16666666666667
51421, 1.45, -0.04, 0.16666666666667
51422, 1.45, -0.08, 0.16666666666667
51423, 1.45, -0.12, 0.16666666666667
51424, 1.45, -0.16, 0.16666666666667
51425, 1.4916666666667, -0.04, 0.16666666666667
51426, 1.4916666666667, -0.08, 0.16666666666667
51427, 1.4916666666667, -0.12, 0.16666666666667
51428, 1.4916666666667, -0.16, 0.16666666666667
51429, 1.5333333333333, -0.04, 0.16666666666667
51430, 1.5333333333333, -0.08, 0.16666666666667
51431, 1.5333333333333, -0.12, 0.16666666666667
51432, 1.5333333333333, -0.16, 0.16666666666667
51433, 1.575, -0.04, 0.16666666666667
51434, 1.575, -0.08, 0.16666666666667
51435, 1.575, -0.12, 0.16666666666667
51436, 1.575, -0.16, 0.16666666666667
51437, 1.6166666666667, -0.04, 0.16666666666667
51438, 1.6166666666667, -0.08, 0.16666666666667
51439, 1.6166666666667, -0.12, 0.16666666666667
51440, 1.6166666666667, -0.16, 0.16666666666667
51441, 1.6583333333333, -0.04, 0.16666666666667
51442, 1.6583333333333, -0.08, 0.16666666666667
51443, 1.6583333333333, -0.12, 0.16666666666667
51444, 1.6583333333333, -0.16, 0.16666666666667
51445, 1.7, -0.04, 0.16666666666667
51446, 1.7, -0.08, 0.16666666666667
51447, 1.7, -0.12, 0.16666666666667
51448, 1.7, -0.16, 0.16666666666667
51449, 1.7416666666667, -0.04, 0.16666666666667
51450, 1.7416666666667, -0.08, 0.16666666666667
51451, 1.7416666666667, -0.12, 0.16666666666667
51452, 1.7416666666667, -0.16, 0.16666666666667
51453, 1.7833333333333, -0.04, 0.16666666666667
51454, 1.7833333333333, -0.08, 0.16666666666667
51455, 1.7833333333333, -0.12, 0.16666666666667
51456, 1.7833333333333, -0.16, 0.16666666666667
51457, 1.825, -0.04, 0.16666666666667
51458, 1.825, -0.08, 0.16666666666667
51459, 1.825, -0.12, 0.16666666666667
51460, 1.825, -0.16, 0.16666666666667
51461, 1.8666666666667, -0.04, 0.16666666666667
51462, 1.8666666666667, -0.08, 0.16666666666667
51463, 1.8666666666667, -0.12, 0.16666666666667
51464, 1.8666666666667, -0.16, 0.16666666666667
51465, 1.9083333333333, -0.04, 0.16666666666667
51466, 1.9083333333333, -0.08, 0.16666666666667
51467, 1.9083333333333, -0.12, 0.16666666666667
51468, 1.9083333333333, -0.16, 0.16666666666667
51469, 1.95, -0.04, 0.16666666666667
51470, 1.95, -0.08, 0.16666666666667
51471, 1.95, -0.12, 0.16666666666667
51472, 1.95, -0.16, 0.16666666666667
51473, 1.9916666666667, -0.04, 0.16666666666667
51474, 1.9916666666667, -0.08, 0.16666666666667
51475, 1.9916666666667, -0.12, 0.16666666666667
51476, 1.9916666666667, -0.16, 0.16666666666667
51477, 2.0333333333333, -0.04, 0.16666666666667
51478, 2.0333333333333, -0.08, 0.16666666666667
51479, 2.0333333333333, -0.12, 0.16666666666667
51480, 2.0333333333333, -0.16, 0.16666666666667
51481, 2.075, -0.04, 0.16666666666667
51482, 2.075, -0.08, 0.16666666666667
51483, 2.075, -0.12, 0.16666666666667
51484, 2.075, -0.16, 0.16666666666667
51485, 2.1166666666667, -0.04, 0.16666666666667
51486, 2.1166666666667, -0.08, 0.16666666666667
51487, 2.1166666666667, -0.12, 0.16666666666667
51488, 2.1166666666667, -0.16, 0.16666666666667
51489, 2.1583333333333, -0.04, 0.16666666666667
51490, 2.1583333333333, -0.08, 0.16666666666667
51491, 2.1583333333333, -0.12, 0.16666666666667
51492, 2.1583333333333, -0.16, 0.16666666666667
51493, 1.2416666666667, -0.04, 0.20833333333333
51494, 1.2416666666667, -0.08, 0.20833333333333
51495, 1.2416666666667, -0.12, 0.20833333333333
51496, 1.2416666666667, -0.16, 0.20833333333333
51497, 1.2833333333333, -0.04, 0.20833333333333
51498, 1.2833333333333, -0.08, 0.20833333333333
51499, 1.2833333333333, -0.12, 0.20833333333333
51500, 1.2833333333333, -0.16, 0.20833333333333
51501, 1.325, -0.04, 0.20833333333333
51502, 1.325, -0.08, 0.20833333333333
51503, 1.325, -0.12, 0.20833333333333
51504, 1.325, -0.16, 0.20833333333333
51505, 1.3666666666667, -0.04, 0.20833333333333
51506, 1.3666666666667, -0.08, 0.20833333333333
51507, 1.3666666666667, -0.12, 0.20833333333333
51508, 1.3666666666667, -0.16, 0.20833333333333
51509, 1.4083333333333, -0.04, 0.20833333333333
51510, 1.4083333333333, -0.08, 0.20833333333333
51511, 1.4083333333333, -0.12, 0.20833333333333
51512, 1.4083333333333, -0.16, 0.20833333333333
51513, 1.45, -0.04, 0.20833333333333
51514, 1.45, -0.08, 0.20833333333333
51515, 1.45, -0.12, 0.20833333333333
51516, 1.45, -0.16, 0.20833333333333
51517, 1.4916666666667, -0.04, 0.20833333333333
51518, 1.4916666666667, -0.08, 0.20833333333333
51519, 1.4916666666667, -0.12, 0.20833333333333
51520, 1.4916666666667, -0.16, 0.20833333333333
51521, 1.5333333333333, -0.04, 0.20833333333333
51522, 1.5333333333333, -0.08, 0.20833333333333
51523, 1.5333333333333, -0.12, 0.20833333333333
51524, 1.5333333333333, -0.16, 0.20833333333333
51525, 1.575, -0.04, 0.20833333333333
51526, 1.575, -0.08, 0.20833333333333
51527, 1.575, -0.12, 0.20833333333333
51528, 1.575, -0.16, 0.20833333333333
51529, 1.6166666666667, -0.04, 0.20833333333333
51530, 1.6166666666667, -0.08, 0.20833333333333
51531, 1.6166666666667, -0.12, 0.20833333333333
51532, 1.6166666666667, -0.16, 0.20833333333333
51533, 1.6583333333333, -0.04, 0.20833333333333
51534, 1.6583333333333, -0.08, 0.20833333333333
51535, 1.6583333333333, -0.12, 0.20833333333333
51536, 1.6583333333333, -0.16, 0.20833333333333
51537, 1.7, -0.04, 0.20833333333333
51538, 1.7, -0.08, 0.20833333333333
51539, 1.7, -0.12, 0.20833333333333
51540, 1.7, -0.16, 0.20833333333333
51541, 1.7416666666667, -0.04, 0.20833333333333
51542, 1.7416666666667, -0.08, 0.20833333333333
51543, 1.7416666666667, -0.12, 0.20833333333333
51544, 1.7416666666667, -0.16, 0.20833333333333
51545, 1.7833333333333, -0.04, 0.20833333333333
51546, 1.7833333333333, -0.08, 0.20833333333333
51547, 1.7833333333333, -0.12, 0.20833333333333
51548, 1.7833333333333, -0.16, 0.20833333333333
51549, 1.825, -0.04, 0.20833333333333
51550, 1.825, -0.08, 0.20833333333333
51551, 1.825, -0.12, 0.20833333333333
51552, 1.825, -0.16, 0.20833333333333
51553, 1.8666666666667, -0.04, 0.20833333333333
51554, 1.8666666666667, -0.08, 0.20833333333333
51555, 1.8666666666667, -0.12, 0.20833333333333
51556, 1.8666666666667, -0.16, 0.20833333333333
51557, 1.9083333333333, -0.04, 0.20833333333333
51558, 1.9083333333333, -0.08, 0.20833333333333
51559, 1.9083333333333, -0.12, 0.20833333333333
51560, 1.9083333333333, -0.16, 0.20833333333333
51561, 1.95, -0.04, 0.20833333333333
51562, 1.95, -0.08, 0.20833333333333
51563, 1.95, -0.12, 0.20833333333333
51564, 1.95, -0.16, 0.20833333333333
51565, 1.9916666666667, -0.04, 0.20833333333333
51566, 1.9916666666667, -0.08, 0.20833333333333
51567, 1.9916666666667, -0.12, 0.20833333333333
51568, 1.9916666666667, -0.16, 0.20833333333333
51569, 2.0333333333333, -0.04, 0.20833333333333
51570, 2.0333333333333, -0.08, 0.20833333333333
51571, 2.0333333333333, -0.12, 0.20833333333333
51572, 2.0333333333333, -0.16, 0.20833333333333
51573, 2.075, -0.04, 0.20833333333333
51574, 2.075, -0.08, 0.20833333333333
51575, 2.075, -0.12, 0.20833333333333
51576, 2.075, -0.16, 0.20833333333333
51577, 2.1166666666667, -0.04, 0.20833333333333
51578, 2.1166666666667, -0.08, 0.20833333333333
51579, 2.1166666666667, -0.12, 0.20833333333333
51580, 2.1166666666667, -0.16, 0.20833333333333
51581, 2.1583333333333, -0.04, 0.20833333333333
51582, 2.1583333333333, -0.08, 0.20833333333333
51583, 2.1583333333333, -0.12, 0.20833333333333
51584, 2.1583333333333, -0.16, 0.20833333333333
51585, 1.2416666666667, -0.04, 0.25
51586, 1.2416666666667, -0.08, 0.25
51587, 1.2416666666667, -0.12, 0.25
51588, 1.2416666666667, -0.16, 0.25
51589, 1.2833333333333, -0.04, 0.25
51590, 1.2833333333333, -0.08, 0.25
51591, 1.2833333333333, -0.12, 0.25
51592, 1.2833333333333, -0.16, 0.25
51593, 1.325, -0.04, 0.25
51594, 1.325, -0.08, 0.25
51595, 1.325, -0.12, 0.25
51596, 1.325, -0.16, 0.25
51597, 1.3666666666667, -0.04, 0.25
51598, 1.3666666666667, -0.08, 0.25
51599, 1.3666666666667, -0.12, 0.25
51600, 1.3666666666667, -0.16, 0.25
51601, 1.4083333333333, -0.04, 0.25
51602, 1.4083333333333, -0.08, 0.25
51603, 1.4083333333333, -0.12, 0.25
51604, 1.4083333333333, -0.16, 0.25
51605, 1.45, -0.04, 0.25
51606, 1.45, -0.08, 0.25
51607, 1.45, -0.12, 0.25
51608, 1.45, -0.16, 0.25
51609, 1.4916666666667, -0.04, 0.25
51610, 1.4916666666667, -0.08, 0.25
51611, 1.4916666666667, -0.12, 0.25
51612, 1.4916666666667, -0.16, 0.25
51613, 1.5333333333333, -0.04, 0.25
51614, 1.5333333333333, -0.08, 0.25
51615, 1.5333333333333, -0.12, 0.25
51616, 1.5333333333333, -0.16, 0.25
51617, 1.575, -0.04, 0.25
51618, 1.575, -0.08, 0.25
51619, 1.575, -0.12, 0.25
51620, 1.575, -0.16, 0.25
51621, 1.6166666666667, -0.04, 0.25
51622, 1.6166666666667, -0.08, 0.25
51623, 1.6166666666667, -0.12, 0.25
51624, 1.6166666666667, -0.16, 0.25
51625, 1.6583333333333, -0.04, 0.25
51626, 1.6583333333333, -0.08, 0.25
51627, 1.6583333333333, -0.12, 0.25
51628, 1.6583333333333, -0.16, 0.25
51629, 1.7, -0.04, 0.25
51630, 1.7, -0.08, 0.25
51631, 1.7, -0.12, 0.25
51632, 1.7, -0.16, 0.25
51633, 1.7416666666667, -0.04, 0.25
51634, 1.7416666666667, -0.08, 0.25
51635, 1.7416666666667, -0.12, 0.25
51636, 1.7416666666667, -0.16, 0.25
51637, 1.7833333333333, -0.04, 0.25
51638, 1.7833333333333, -0.08, 0.25
51639, 1.7833333333333, -0.12, 0.25
51640, 1.7833333333333, -0.16, 0.25
51641, 1.825, -0.04, 0.25
51642, 1.825, -0.08, 0.25
51643, 1.825, -0.12, 0.25
51644, 1.825, -0.16, 0.25
51645, 1.8666666666667, -0.04, 0.25
51646, 1.8666666666667, -0.08, 0.25
51647, 1.8666666666667, -0.12, 0.25
51648, 1.8666666666667, -0.16, 0.25
51649, 1.9083333333333, -0.04, 0.25
51650, 1.9083333333333, -0.08, 0.25
51651, 1.9083333333333, -0.12, 0.25
51652, 1.9083333333333, -0.16, 0.25
51653, 1.95, -0.04, 0.25
51654, 1.95, -0.08, 0.25
51655, 1.95, -0.12, 0.25
51656, 1.95, -0.16, 0.25
51657, 1.9916666666667, -0.04, 0.25
51658, 1.9916666666667, -0.08, 0.25
51659, 1.9916666666667, -0.12, 0.25
51660, 1.9916666666667, -0.16, 0.25
51661, 2.0333333333333, -0.04, 0.25
51662, 2.0333333333333, -0.08, 0.25
51663, 2.0333333333333, -0.12, 0.25
51664, 2.0333333333333, -0.16, 0.25
51665, 2.075, -0.04, 0.25
51666, 2.075, -0.08, 0.25
51667, 2.075, -0.12, 0.25
51668, 2.075, -0.16, 0.25
51669, 2.1166666666667, -0.04, 0.25
51670, 2.1166666666667, -0.08, 0.25
51671, 2.1166666666667, -0.12, 0.25
51672, 2.1166666666667, -0.16, 0.25
51673, 2.1583333333333, -0.04, 0.25
51674, 2.1583333333333, -0.08, 0.25
51675, 2.1583333333333, -0.12, 0.25
51676, 2.1583333333333, -0.16, 0.25
51677, 1.2416666666667, -0.04, 0.29166666666667
51678, 1.2416666666667, -0.08, 0.29166666666667
51679, 1.2416666666667, -0.12, 0.29166666666667
51680, 1.2416666666667, -0.16, 0.29166666666667
51681, 1.2833333333333, -0.04, 0.29166666666667
51682, 1.2833333333333, -0.08, 0.29166666666667
51683, 1.2833333333333, -0.12, 0.29166666666667
51684, 1.2833333333333, -0.16, 0.29166666666667
51685, 1.325, -0.04, 0.29166666666667
51686, 1.325, -0.08, 0.29166666666667
51687, 1.325, -0.12, 0.29166666666667
51688, 1.325, -0.16, 0.29166666666667
51689, 1.3666666666667, -0.04, 0.29166666666667
51690, 1.3666666666667, -0.08, 0.29166666666667
51691, 1.3666666666667, -0.12, 0.29166666666667
51692, 1.3666666666667, -0.16, 0.29166666666667
51693, 1.4083333333333, -0.04, 0.29166666666667
51694, 1.4083333333333, -0.08, 0.29166666666667
51695, 1.4083333333333, -0.12, 0.29166666666667
51696, 1.4083333333333, -0.16, 0.29166666666667
51697, 1.45, -0.04, 0.29166666666667
51698, 1.45, -0.08, 0.29166666666667
51699, 1.45, -0.12, 0.29166666666667
51700, 1.45, -0.16, 0.29166666666667
51701, 1.4916666666667, -0.04, 0.29166666666667
51702, 1.4916666666667, -0.08, 0.29166666666667
51703, 1.4916666666667, -0.12, 0.29166666666667
51704, 1.4916666666667, -0.16, 0.29166666666667
51705, 1.5333333333333, -0.04, 0.29166666666667
51706, 1.5333333333333, -0.08, 0.29166666666667
51707, 1.5333333333333, -0.12, 0.29166666666667
51708, 1.5333333333333, -0.16, 0.29166666666667
51709, 1.575, -0.04, 0.29166666666667
51710, 1.575, -0.08, 0.29166666666667
51711, 1.575, -0.12, 0.29166666666667
51712, 1.575, -0.16, 0.29166666666667
51713, 1.6166666666667, -0.04, 0.29166666666667
51714, 1.6166666666667, -0.08, 0.29166666666667
51715, 1.6166666666667, -0.12, 0.29166666666667
51716, 1.6166666666667, -0.16, 0.29166666666667
51717, 1.6583333333333, -0.04, 0.29166666666667
51718, 1.6583333333333, -0.08, 0.29166666666667
51719, 1.6583333333333, -0.12, 0.29166666666667
51720, 1.6583333333333, -0.16, 0.29166666666667
51721, 1.7, -0.04, 0.29166666666667
51722, 1.7, -0.08, 0.29166666666667
51723, 1.7, -0.12, 0.29166666666667
51724, 1.7, -0.16, 0.29166666666667
51725, 1.7416666666667, -0.04, 0.29166666666667
51726, 1.7416666666667, -0.08, 0.29166666666667
51727, 1.7416666666667, -0.12, 0.29166666666667
51728, 1.7416666666667, -0.16, 0.29166666666667
51729, 1.7833333333333, -0.04, 0.29166666666667
51730, 1.7833333333333, -0.08, 0.29166666666667
51731, 1.7833333333333, -0.12, 0.29166666666667
51732, 1.7833333333333, -0.16, 0.29166666666667
51733, 1.825, -0.04, 0.29166666666667
51734, 1.825, -0.08, 0.29166666666667
51735, 1.825, -0.12, 0.29166666666667
51736, 1.825, -0.16, 0.29166666666667
51737, 1.8666666666667, -0.04, 0.29166666666667
51738, 1.8666666666667, -0.08, 0.29166666666667
51739, 1.8666666666667, -0.12, 0.29166666666667
51740, 1.8666666666667, -0.16, 0.29166666666667
51741, 1.9083333333333, -0.04, 0.29166666666667
51742, 1.9083333333333, -0.08, 0.29166666666667
51743, 1.9083333333333, -0.12, 0.29166666666667
51744, 1.9083333333333, -0.16, 0.29166666666667
51745, 1.95, -0.04, 0.29166666666667
51746, 1.95, -0.08, 0.29166666666667
51747, 1.95, -0.12, 0.29166666666667
51748, 1.95, -0.16, 0.29166666666667
51749, 1.9916666666667, -0.04, 0.29166666666667
51750, 1.9916666666667, -0.08, 0.29166666666667
51751, 1.9916666666667, -0.12, 0.29166666666667
51752, 1.9916666666667, -0.16, 0.29166666666667
51753, 2.0333333333333, -0.04, 0.29166666666667
51754, 2.0333333333333, -0.08, 0.29166666666667
51755, 2.0333333333333, -0.12, 0.29166666666667
51756, 2.0333333333333, -0.16, 0.29166666666667
51757, 2.075, -0.04, 0.29166666666667
51758, 2.075, -0.08, 0.29166666666667
51759, 2.075, -0.12, 0.29166666666667
51760, 2.075, -0.16, 0.29166666666667
51761, 2.1166666666667, -0.04, 0.29166666666667
51762, 2.1166666666667, -0.08, 0.29166666666667
51763, 2.1166666666667, -0.12, 0.29166666666667
51764, 2.1166666666667, -0.16, 0.29166666666667
51765, 2.1583333333333, -0.04, 0.29166666666667
51766, 2.1583333333333, -0.08, 0.29166666666667
51767, 2.1583333333333, -0.12, 0.29166666666667
51768, 2.1583333333333, -0.16, 0.29166666666667
51769, 1.2416666666667, -0.04, 0.33333333333333
51770, 1.2416666666667, -0.08, 0.33333333333333
51771, 1.2416666666667, -0.12, 0.33333333333333
51772, 1.2416666666667, -0.16, 0.33333333333333
51773, 1.2833333333333, -0.04, 0.33333333333333
51774, 1.2833333333333, -0.08, 0.33333333333333
51775, 1.2833333333333, -0.12, 0.33333333333333
51776, 1.2833333333333, -0.16, 0.33333333333333
51777, 1.325, -0.04, 0.33333333333333
51778, 1.325, -0.08, 0.33333333333333
51779, 1.325, -0.12, 0.33333333333333
51780, 1.325, -0.16, 0.33333333333333
51781, 1.3666666666667, -0.04, 0.33333333333333
51782, 1.3666666666667, -0.08, 0.33333333333333
51783, 1.3666666666667, -0.12, 0.33333333333333
51784, 1.3666666666667, -0.16, 0.33333333333333
51785, 1.4083333333333, -0.04, 0.33333333333333
51786, 1.4083333333333, -0.08, 0.33333333333333
51787, 1.4083333333333, -0.12, 0.33333333333333
51788, 1.4083333333333, -0.16, 0.33333333333333
51789, 1.45, -0.04, 0.33333333333333
51790, 1.45, -0.08, 0.33333333333333
51791, 1.45, -0.12, 0.33333333333333
51792, 1.45, -0.16, 0.33333333333333
51793, 1.4916666666667, -0.04, 0.33333333333333
51794, 1.4916666666667, -0.08, 0.33333333333333
51795, 1.4916666666667, -0.12, 0.33333333333333
51796, 1.4916666666667, -0.16, 0.33333333333333
51797, 1.5333333333333, -0.04, 0.33333333333333
51798, 1.5333333333333, -0.08, 0.33333333333333
51799, 1.5333333333333, -0.12, 0.33333333333333
51800, 1.5333333333333, -0.16, 0.33333333333333
51801, 1.575, -0.04, 0.33333333333333
51802, 1.575, -0.08, 0.33333333333333
51803, 1.575, -0.12, 0.33333333333333
51804, 1.575, -0.16, 0.33333333333333
51805, 1.6166666666667, -0.04, 0.33333333333333
51806, 1.6166666666667, -0.08, 0.33333333333333
51807, 1.6166666666667, -0.12, 0.33333333333333
