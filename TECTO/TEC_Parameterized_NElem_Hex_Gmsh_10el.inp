33842, 2142, 0, 2143
33843, 2143, 0, 2144
33844, 2144, 0, 2145
33845, 2145, 0, 2146
33846, 2146, 0, 2147
33847, 2147, 0, 2148
33848, 2148, 0, 2149
33849, 2149, 0, 2150
33850, 2150, 0, 2151
33851, 2151, 0, 2152
33852, 2152, 0, 2153
33853, 2153, 0, 2154
33854, 2154, 0, 2155
33855, 2155, 0, 2156
33856, 2156, 0, 2157
33857, 2157, 0, 2158
33858, 2158, 0, 2159
33859, 2159, 0, 2160
33860, 2160, 0, 84
*ELEMENT, type=T3D3, ELSET=Line184
33861, 84, 0, 2161
33862, 2161, 0, 2162
33863, 2162, 0, 2163
33864, 2163, 0, 2164
33865, 2164, 0, 2165
33866, 2165, 0, 2166
33867, 2166, 0, 2167
33868, 2167, 0, 2168
33869, 2168, 0, 2169
33870, 2169, 0, 2170
33871, 2170, 0, 2171
33872, 2171, 0, 83
*ELEMENT, type=T3D3, ELSET=Line185
33873, 6, 2176, 2172
33874, 2172, 2177, 2173
33875, 2173, 2178, 2174
33876, 2174, 2179, 2175
33877, 2175, 2180, 85
*ELEMENT, type=T3D3, ELSET=Line186
33878, 2, 2185, 2181
33879, 2181, 2186, 2182
33880, 2182, 2187, 2183
33881, 2183, 2188, 2184
33882, 2184, 2189, 86
*ELEMENT, type=T3D3, ELSET=Line187
33883, 86, 0, 2190
33884, 2190, 0, 2191
33885, 2191, 0, 2192
33886, 2192, 0, 2193
33887, 2193, 0, 2194
33888, 2194, 0, 2195
33889, 2195, 0, 2196
33890, 2196, 0, 2197
33891, 2197, 0, 2198
33892, 2198, 0, 2199
33893, 2199, 0, 2200
33894, 2200, 0, 2201
33895, 2201, 0, 2202
33896, 2202, 0, 2203
33897, 2203, 0, 2204
33898, 2204, 0, 2205
33899, 2205, 0, 2206
33900, 2206, 0, 2207
33901, 2207, 0, 2208
33902, 2208, 0, 2209
33903, 2209, 0, 2210
33904, 2210, 0, 2211
33905, 2211, 0, 2212
33906, 2212, 0, 85
*ELEMENT, type=T3D3, ELSET=Line188
33907, 5, 0, 2213
33908, 2213, 0, 2214
33909, 2214, 0, 2215
33910, 2215, 0, 2216
33911, 2216, 0, 87
*ELEMENT, type=T3D3, ELSET=Line189
33912, 85, 0, 2217
33913, 2217, 0, 2218
33914, 2218, 0, 2219
33915, 2219, 0, 2220
33916, 2220, 0, 2221
33917, 2221, 0, 2222
33918, 2222, 0, 2223
33919, 2223, 0, 2224
33920, 2224, 0, 2225
33921, 2225, 0, 2226
33922, 2226, 0, 2227
33923, 2227, 0, 87
*ELEMENT, type=T3D3, ELSET=Line190
33924, 1, 0, 2228
33925, 2228, 0, 2229
33926, 2229, 0, 2230
33927, 2230, 0, 2231
33928, 2231, 0, 88
*ELEMENT, type=T3D3, ELSET=Line191
60, 88, 0, 2232
61, 2232, 0, 2233
62, 2233, 0, 2234
63, 2234, 0, 2235
64, 2235, 0, 2236
65, 2236, 0, 2237
66, 2237, 0, 2238
67, 2238, 0, 2239
68, 2239, 0, 2240
69, 2240, 0, 2241
70, 2241, 0, 2242
71, 2242, 0, 2243
72, 2243, 0, 2244
73, 2244, 0, 2245
74, 2245, 0, 2246
75, 2246, 0, 2247
76, 2247, 0, 2248
77, 2248, 0, 2249
78, 2249, 0, 2250
79, 2250, 0, 2251
80, 2251, 0, 2252
81, 2252, 0, 2253
82, 2253, 0, 2254
83, 2254, 0, 87
*ELEMENT, type=T3D3, ELSET=Line192
33929, 86, 0, 2255
33930, 2255, 0, 2256
33931, 2256, 0, 2257
33932, 2257, 0, 2258
33933, 2258, 0, 2259
33934, 2259, 0, 2260
33935, 2260, 0, 2261
33936, 2261, 0, 2262
33937, 2262, 0, 2263
33938, 2263, 0, 2264
33939, 2264, 0, 2265
33940, 2265, 0, 88
*ELEMENT, type=T3D3, ELSET=Line193
33941, 53, 0, 2266
33942, 2266, 0, 2267
33943, 2267, 0, 2268
33944, 2268, 0, 2269
33945, 2269, 0, 89
*ELEMENT, type=T3D3, ELSET=Line194
84, 88, 0, 89
*ELEMENT, type=T3D3, ELSET=Line195
33946, 54, 2274, 2270
33947, 2270, 2275, 2271
33948, 2271, 2276, 2272
33949, 2272, 2277, 2273
33950, 2273, 2278, 90
*ELEMENT, type=T3D3, ELSET=Line196
33951, 86, 0, 90
*ELEMENT, type=T3D3, ELSET=Line197
33952, 90, 0, 2279
33953, 2279, 0, 2280
33954, 2280, 0, 2281
33955, 2281, 0, 2282
33956, 2282, 0, 2283
33957, 2283, 0, 2284
33958, 2284, 0, 2285
33959, 2285, 0, 2286
33960, 2286, 0, 2287
33961, 2287, 0, 2288
33962, 2288, 0, 2289
33963, 2289, 0, 89
*ELEMENT, type=T3D3, ELSET=Line198
33964, 45, 0, 2290
33965, 2290, 0, 2291
33966, 2291, 0, 2292
33967, 2292, 0, 2293
33968, 2293, 0, 91
*ELEMENT, type=T3D3, ELSET=Line199
33969, 46, 0, 2294
33970, 2294, 0, 2295
33971, 2295, 0, 2296
33972, 2296, 0, 2297
33973, 2297, 0, 92
*ELEMENT, type=T3D3, ELSET=Line200
85, 91, 0, 2298
86, 2298, 0, 2299
87, 2299, 0, 2300
88, 2300, 0, 2301
89, 2301, 0, 2302
90, 2302, 0, 2303
91, 2303, 0, 2304
92, 2304, 0, 2305
93, 2305, 0, 2306
94, 2306, 0, 2307
95, 2307, 0, 2308
96, 2308, 0, 2309
97, 2309, 0, 2310
98, 2310, 0, 2311
99, 2311, 0, 2312
100, 2312, 0, 2313
101, 2313, 0, 2314
102, 2314, 0, 2315
103, 2315, 0, 2316
104, 2316, 0, 2317
105, 2317, 0, 2318
106, 2318, 0, 2319
107, 2319, 0, 2320
108, 2320, 0, 92
*ELEMENT, type=T3D3, ELSET=Line201
33974, 47, 2325, 2321
33975, 2321, 2326, 2322
33976, 2322, 2327, 2323
33977, 2323, 2328, 2324
33978, 2324, 2329, 93
*ELEMENT, type=T3D3, ELSET=Line202
33979, 48, 2334, 2330
33980, 2330, 2335, 2331
33981, 2331, 2336, 2332
33982, 2332, 2337, 2333
33983, 2333, 2338, 94
*ELEMENT, type=T3D3, ELSET=Line203
33984, 93, 0, 2339
33985, 2339, 0, 2340
33986, 2340, 0, 2341
33987, 2341, 0, 2342
33988, 2342, 0, 2343
33989, 2343, 0, 2344
33990, 2344, 0, 2345
33991, 2345, 0, 2346
33992, 2346, 0, 2347
33993, 2347, 0, 2348
33994, 2348, 0, 2349
33995, 2349, 0, 2350
33996, 2350, 0, 2351
33997, 2351, 0, 2352
33998, 2352, 0, 2353
33999, 2353, 0, 2354
34000, 2354, 0, 2355
34001, 2355, 0, 2356
34002, 2356, 0, 2357
34003, 2357, 0, 2358
34004, 2358, 0, 2359
34005, 2359, 0, 2360
34006, 2360, 0, 2361
34007, 2361, 0, 94
*ELEMENT, type=T3D3, ELSET=Line204
34008, 93, 0, 2362
34009, 2362, 0, 2363
34010, 2363, 0, 2364
34011, 2364, 0, 2365
34012, 2365, 0, 2366
34013, 2366, 0, 2367
34014, 2367, 0, 2368
34015, 2368, 0, 2369
34016, 2369, 0, 2370
34017, 2370, 0, 2371
34018, 2371, 0, 2372
34019, 2372, 0, 91
*ELEMENT, type=T3D3, ELSET=Line205
34020, 94, 0, 2373
34021, 2373, 0, 2374
34022, 2374, 0, 2375
34023, 2375, 0, 2376
34024, 2376, 0, 2377
34025, 2377, 0, 2378
34026, 2378, 0, 2379
34027, 2379, 0, 2380
34028, 2380, 0, 2381
34029, 2381, 0, 2382
34030, 2382, 0, 2383
34031, 2383, 0, 92
*ELEMENT, type=T3D3, ELSET=Line206
34032, 50, 0, 2384
34033, 2384, 0, 2385
34034, 2385, 0, 2386
34035, 2386, 0, 2387
34036, 2387, 0, 95
*ELEMENT, type=T3D3, ELSET=Line207
109, 92, 0, 95
*ELEMENT, type=T3D3, ELSET=Line208
34037, 52, 2392, 2388
34038, 2388, 2393, 2389
34039, 2389, 2394, 2390
34040, 2390, 2395, 2391
34041, 2391, 2396, 96
*ELEMENT, type=T3D3, ELSET=Line209
34042, 94, 0, 96
*ELEMENT, type=T3D3, ELSET=Line210
34043, 96, 0, 2397
34044, 2397, 0, 2398
34045, 2398, 0, 2399
34046, 2399, 0, 2400
34047, 2400, 0, 2401
34048, 2401, 0, 2402
34049, 2402, 0, 2403
34050, 2403, 0, 2404
34051, 2404, 0, 2405
34052, 2405, 0, 2406
34053, 2406, 0, 2407
34054, 2407, 0, 95
*ELEMENT, type=CPS8, ELSET=Surface1
34055, 2, 98, 2408, 122, 97, 0, 0, 0
34056, 122, 2408, 2409, 123, 0, 0, 0, 0
34057, 123, 2409, 111, 4, 0, 0, 0, 0
34058, 98, 99, 2410, 2408, 0, 0, 0, 0
34059, 2408, 2410, 2411, 2409, 0, 0, 0, 0
34060, 2409, 2411, 112, 111, 0, 0, 0, 0
34061, 99, 100, 2412, 2410, 0, 0, 0, 0
34062, 2410, 2412, 2413, 2411, 0, 0, 0, 0
34063, 2411, 2413, 113, 112, 0, 0, 0, 0
34064, 100, 101, 2414, 2412, 0, 0, 0, 0
34065, 2412, 2414, 2415, 2413, 0, 0, 0, 0
34066, 2413, 2415, 114, 113, 0, 0, 0, 0
34067, 101, 102, 2416, 2414, 0, 0, 0, 0
34068, 2414, 2416, 2417, 2415, 0, 0, 0, 0
34069, 2415, 2417, 115, 114, 0, 0, 0, 0
34070, 102, 103, 2418, 2416, 0, 0, 0, 0
34071, 2416, 2418, 2419, 2417, 0, 0, 0, 0
34072, 2417, 2419, 116, 115, 0, 0, 0, 0
34073, 103, 104, 2420, 2418, 0, 0, 0, 0
34074, 2418, 2420, 2421, 2419, 0, 0, 0, 0
34075, 2419, 2421, 117, 116, 0, 0, 0, 0
34076, 104, 105, 2422, 2420, 0, 0, 0, 0
34077, 2420, 2422, 2423, 2421, 0, 0, 0, 0
34078, 2421, 2423, 118, 117, 0, 0, 0, 0
34079, 105, 106, 2424, 2422, 0, 0, 0, 0
34080, 2422, 2424, 2425, 2423, 0, 0, 0, 0
34081, 2423, 2425, 119, 118, 0, 0, 0, 0
34082, 106, 107, 2426, 2424, 0, 0, 0, 0
34083, 2424, 2426, 2427, 2425, 0, 0, 0, 0
34084, 2425, 2427, 120, 119, 0, 0, 0, 0
34085, 107, 108, 2428, 2426, 0, 0, 0, 0
34086, 2426, 2428, 2429, 2427, 0, 0, 0, 0
34087, 2427, 2429, 121, 120, 0, 0, 0, 0
34088, 108, 1, 109, 2428, 0, 0, 0, 0
34089, 2428, 109, 110, 2429, 0, 0, 0, 0
34090, 2429, 110, 3, 121, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface2
34091, 6, 148, 2430, 124, 0, 0, 0, 0
34092, 148, 149, 2431, 2430, 0, 0, 0, 0
34093, 149, 8, 137, 2431, 0, 0, 0, 0
34094, 124, 2430, 2432, 125, 0, 0, 0, 0
34095, 2430, 2431, 2433, 2432, 0, 0, 0, 0
34096, 2431, 137, 138, 2433, 0, 0, 0, 0
34097, 125, 2432, 2434, 126, 0, 0, 0, 0
34098, 2432, 2433, 2435, 2434, 0, 0, 0, 0
34099, 2433, 138, 139, 2435, 0, 0, 0, 0
34100, 126, 2434, 2436, 127, 0, 0, 0, 0
34101, 2434, 2435, 2437, 2436, 0, 0, 0, 0
34102, 2435, 139, 140, 2437, 0, 0, 0, 0
34103, 127, 2436, 2438, 128, 0, 0, 0, 0
34104, 2436, 2437, 2439, 2438, 0, 0, 0, 0
34105, 2437, 140, 141, 2439, 0, 0, 0, 0
34106, 128, 2438, 2440, 129, 0, 0, 0, 0
34107, 2438, 2439, 2441, 2440, 0, 0, 0, 0
34108, 2439, 141, 142, 2441, 0, 0, 0, 0
34109, 129, 2440, 2442, 130, 0, 0, 0, 0
34110, 2440, 2441, 2443, 2442, 0, 0, 0, 0
34111, 2441, 142, 143, 2443, 0, 0, 0, 0
34112, 130, 2442, 2444, 131, 0, 0, 0, 0
34113, 2442, 2443, 2445, 2444, 0, 0, 0, 0
34114, 2443, 143, 144, 2445, 0, 0, 0, 0
34115, 131, 2444, 2446, 132, 0, 0, 0, 0
34116, 2444, 2445, 2447, 2446, 0, 0, 0, 0
34117, 2445, 144, 145, 2447, 0, 0, 0, 0
34118, 132, 2446, 2448, 133, 0, 0, 0, 0
34119, 2446, 2447, 2449, 2448, 0, 0, 0, 0
34120, 2447, 145, 146, 2449, 0, 0, 0, 0
34121, 133, 2448, 2450, 134, 0, 0, 0, 0
34122, 2448, 2449, 2451, 2450, 0, 0, 0, 0
34123, 2449, 146, 147, 2451, 0, 0, 0, 0
34124, 134, 2450, 135, 5, 0, 0, 0, 0
34125, 2450, 2451, 136, 135, 0, 0, 0, 0
34126, 2451, 147, 7, 136, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface3
110, 2, 150, 2452, 98, 0, 0, 0, 97
111, 98, 2452, 2453, 99, 0, 0, 0, 0
112, 99, 2453, 2454, 100, 0, 0, 0, 0
113, 100, 2454, 2455, 101, 0, 0, 0, 0
114, 101, 2455, 2456, 102, 0, 0, 0, 0
115, 102, 2456, 2457, 103, 0, 0, 0, 0
116, 103, 2457, 2458, 104, 0, 0, 0, 0
117, 104, 2458, 2459, 105, 0, 0, 0, 0
118, 105, 2459, 2460, 106, 0, 0, 0, 0
119, 106, 2460, 2461, 107, 0, 0, 0, 0
120, 107, 2461, 2462, 108, 0, 0, 0, 0
121, 108, 2462, 173, 1, 0, 0, 0, 0
122, 150, 151, 2463, 2452, 0, 0, 0, 0
123, 2452, 2463, 2464, 2453, 0, 0, 0, 0
124, 2453, 2464, 2465, 2454, 0, 0, 0, 0
125, 2454, 2465, 2466, 2455, 0, 0, 0, 0
126, 2455, 2466, 2467, 2456, 0, 0, 0, 0
127, 2456, 2467, 2468, 2457, 0, 0, 0, 0
128, 2457, 2468, 2469, 2458, 0, 0, 0, 0
129, 2458, 2469, 2470, 2459, 0, 0, 0, 0
130, 2459, 2470, 2471, 2460, 0, 0, 0, 0
131, 2460, 2471, 2472, 2461, 0, 0, 0, 0
132, 2461, 2472, 2473, 2462, 0, 0, 0, 0
133, 2462, 2473, 174, 173, 0, 0, 0, 0
134, 151, 152, 2474, 2463, 0, 0, 0, 0
135, 2463, 2474, 2475, 2464, 0, 0, 0, 0
136, 2464, 2475, 2476, 2465, 0, 0, 0, 0
137, 2465, 2476, 2477, 2466, 0, 0, 0, 0
138, 2466, 2477, 2478, 2467, 0, 0, 0, 0
139, 2467, 2478, 2479, 2468, 0, 0, 0, 0
140, 2468, 2479, 2480, 2469, 0, 0, 0, 0
141, 2469, 2480, 2481, 2470, 0, 0, 0, 0
142, 2470, 2481, 2482, 2471, 0, 0, 0, 0
143, 2471, 2482, 2483, 2472, 0, 0, 0, 0
144, 2472, 2483, 2484, 2473, 0, 0, 0, 0
145, 2473, 2484, 175, 174, 0, 0, 0, 0
146, 152, 153, 2485, 2474, 0, 0, 0, 0
147, 2474, 2485, 2486, 2475, 0, 0, 0, 0
148, 2475, 2486, 2487, 2476, 0, 0, 0, 0
149, 2476, 2487, 2488, 2477, 0, 0, 0, 0
150, 2477, 2488, 2489, 2478, 0, 0, 0, 0
151, 2478, 2489, 2490, 2479, 0, 0, 0, 0
152, 2479, 2490, 2491, 2480, 0, 0, 0, 0
153, 2480, 2491, 2492, 2481, 0, 0, 0, 0
154, 2481, 2492, 2493, 2482, 0, 0, 0, 0
155, 2482, 2493, 2494, 2483, 0, 0, 0, 0
156, 2483, 2494, 2495, 2484, 0, 0, 0, 0
157, 2484, 2495, 176, 175, 0, 0, 0, 0
158, 153, 154, 2496, 2485, 0, 0, 0, 0
159, 2485, 2496, 2497, 2486, 0, 0, 0, 0
160, 2486, 2497, 2498, 2487, 0, 0, 0, 0
161, 2487, 2498, 2499, 2488, 0, 0, 0, 0
162, 2488, 2499, 2500, 2489, 0, 0, 0, 0
163, 2489, 2500, 2501, 2490, 0, 0, 0, 0
164, 2490, 2501, 2502, 2491, 0, 0, 0, 0
165, 2491, 2502, 2503, 2492, 0, 0, 0, 0
166, 2492, 2503, 2504, 2493, 0, 0, 0, 0
167, 2493, 2504, 2505, 2494, 0, 0, 0, 0
168, 2494, 2505, 2506, 2495, 0, 0, 0, 0
169, 2495, 2506, 177, 176, 0, 0, 0, 0
170, 154, 155, 2507, 2496, 0, 0, 0, 0
171, 2496, 2507, 2508, 2497, 0, 0, 0, 0
172, 2497, 2508, 2509, 2498, 0, 0, 0, 0
173, 2498, 2509, 2510, 2499, 0, 0, 0, 0
174, 2499, 2510, 2511, 2500, 0, 0, 0, 0
175, 2500, 2511, 2512, 2501, 0, 0, 0, 0
176, 2501, 2512, 2513, 2502, 0, 0, 0, 0
177, 2502, 2513, 2514, 2503, 0, 0, 0, 0
178, 2503, 2514, 2515, 2504, 0, 0, 0, 0
179, 2504, 2515, 2516, 2505, 0, 0, 0, 0
180, 2505, 2516, 2517, 2506, 0, 0, 0, 0
181, 2506, 2517, 178, 177, 0, 0, 0, 0
182, 155, 156, 2518, 2507, 0, 0, 0, 0
183, 2507, 2518, 2519, 2508, 0, 0, 0, 0
184, 2508, 2519, 2520, 2509, 0, 0, 0, 0
185, 2509, 2520, 2521, 2510, 0, 0, 0, 0
186, 2510, 2521, 2522, 2511, 0, 0, 0, 0
187, 2511, 2522, 2523, 2512, 0, 0, 0, 0
188, 2512, 2523, 2524, 2513, 0, 0, 0, 0
189, 2513, 2524, 2525, 2514, 0, 0, 0, 0
190, 2514, 2525, 2526, 2515, 0, 0, 0, 0
191, 2515, 2526, 2527, 2516, 0, 0, 0, 0
192, 2516, 2527, 2528, 2517, 0, 0, 0, 0
193, 2517, 2528, 179, 178, 0, 0, 0, 0
194, 156, 157, 2529, 2518, 0, 0, 0, 0
195, 2518, 2529, 2530, 2519, 0, 0, 0, 0
196, 2519, 2530, 2531, 2520, 0, 0, 0, 0
197, 2520, 2531, 2532, 2521, 0, 0, 0, 0
198, 2521, 2532, 2533, 2522, 0, 0, 0, 0
199, 2522, 2533, 2534, 2523, 0, 0, 0, 0
200, 2523, 2534, 2535, 2524, 0, 0, 0, 0
201, 2524, 2535, 2536, 2525, 0, 0, 0, 0
202, 2525, 2536, 2537, 2526, 0, 0, 0, 0
203, 2526, 2537, 2538, 2527, 0, 0, 0, 0
204, 2527, 2538, 2539, 2528, 0, 0, 0, 0
205, 2528, 2539, 180, 179, 0, 0, 0, 0
206, 157, 158, 2540, 2529, 0, 0, 0, 0
207, 2529, 2540, 2541, 2530, 0, 0, 0, 0
208, 2530, 2541, 2542, 2531, 0, 0, 0, 0
209, 2531, 2542, 2543, 2532, 0, 0, 0, 0
210, 2532, 2543, 2544, 2533, 0, 0, 0, 0
211, 2533, 2544, 2545, 2534, 0, 0, 0, 0
212, 2534, 2545, 2546, 2535, 0, 0, 0, 0
213, 2535, 2546, 2547, 2536, 0, 0, 0, 0
214, 2536, 2547, 2548, 2537, 0, 0, 0, 0
215, 2537, 2548, 2549, 2538, 0, 0, 0, 0
216, 2538, 2549, 2550, 2539, 0, 0, 0, 0
217, 2539, 2550, 181, 180, 0, 0, 0, 0
218, 158, 159, 2551, 2540, 0, 0, 0, 0
219, 2540, 2551, 2552, 2541, 0, 0, 0, 0
220, 2541, 2552, 2553, 2542, 0, 0, 0, 0
221, 2542, 2553, 2554, 2543, 0, 0, 0, 0
222, 2543, 2554, 2555, 2544, 0, 0, 0, 0
223, 2544, 2555, 2556, 2545, 0, 0, 0, 0
224, 2545, 2556, 2557, 2546, 0, 0, 0, 0
225, 2546, 2557, 2558, 2547, 0, 0, 0, 0
226, 2547, 2558, 2559, 2548, 0, 0, 0, 0
227, 2548, 2559, 2560, 2549, 0, 0, 0, 0
228, 2549, 2560, 2561, 2550, 0, 0, 0, 0
229, 2550, 2561, 182, 181, 0, 0, 0, 0
230, 159, 160, 2562, 2551, 0, 0, 0, 0
231, 2551, 2562, 2563, 2552, 0, 0, 0, 0
232, 2552, 2563, 2564, 2553, 0, 0, 0, 0
233, 2553, 2564, 2565, 2554, 0, 0, 0, 0
234, 2554, 2565, 2566, 2555, 0, 0, 0, 0
235, 2555, 2566, 2567, 2556, 0, 0, 0, 0
236, 2556, 2567, 2568, 2557, 0, 0, 0, 0
237, 2557, 2568, 2569, 2558, 0, 0, 0, 0
238, 2558, 2569, 2570, 2559, 0, 0, 0, 0
239, 2559, 2570, 2571, 2560, 0, 0, 0, 0
240, 2560, 2571, 2572, 2561, 0, 0, 0, 0
241, 2561, 2572, 183, 182, 0, 0, 0, 0
242, 160, 161, 2573, 2562, 0, 0, 0, 0
243, 2562, 2573, 2574, 2563, 0, 0, 0, 0
244, 2563, 2574, 2575, 2564, 0, 0, 0, 0
245, 2564, 2575, 2576, 2565, 0, 0, 0, 0
246, 2565, 2576, 2577, 2566, 0, 0, 0, 0
247, 2566, 2577, 2578, 2567, 0, 0, 0, 0
248, 2567, 2578, 2579, 2568, 0, 0, 0, 0
249, 2568, 2579, 2580, 2569, 0, 0, 0, 0
250, 2569, 2580, 2581, 2570, 0, 0, 0, 0
251, 2570, 2581, 2582, 2571, 0, 0, 0, 0
252, 2571, 2582, 2583, 2572, 0, 0, 0, 0
253, 2572, 2583, 184, 183, 0, 0, 0, 0
254, 161, 162, 2584, 2573, 0, 0, 0, 0
255, 2573, 2584, 2585, 2574, 0, 0, 0, 0
256, 2574, 2585, 2586, 2575, 0, 0, 0, 0
257, 2575, 2586, 2587, 2576, 0, 0, 0, 0
258, 2576, 2587, 2588, 2577, 0, 0, 0, 0
259, 2577, 2588, 2589, 2578, 0, 0, 0, 0
260, 2578, 2589, 2590, 2579, 0, 0, 0, 0
261, 2579, 2590, 2591, 2580, 0, 0, 0, 0
262, 2580, 2591, 2592, 2581, 0, 0, 0, 0
263, 2581, 2592, 2593, 2582, 0, 0, 0, 0
264, 2582, 2593, 2594, 2583, 0, 0, 0, 0
265, 2583, 2594, 185, 184, 0, 0, 0, 0
266, 162, 163, 2595, 2584, 0, 0, 0, 0
267, 2584, 2595, 2596, 2585, 0, 0, 0, 0
268, 2585, 2596, 2597, 2586, 0, 0, 0, 0
269, 2586, 2597, 2598, 2587, 0, 0, 0, 0
270, 2587, 2598, 2599, 2588, 0, 0, 0, 0
271, 2588, 2599, 2600, 2589, 0, 0, 0, 0
272, 2589, 2600, 2601, 2590, 0, 0, 0, 0
273, 2590, 2601, 2602, 2591, 0, 0, 0, 0
274, 2591, 2602, 2603, 2592, 0, 0, 0, 0
275, 2592, 2603, 2604, 2593, 0, 0, 0, 0
276, 2593, 2604, 2605, 2594, 0, 0, 0, 0
277, 2594, 2605, 186, 185, 0, 0, 0, 0
278, 163, 164, 2606, 2595, 0, 0, 0, 0
279, 2595, 2606, 2607, 2596, 0, 0, 0, 0
280, 2596, 2607, 2608, 2597, 0, 0, 0, 0
281, 2597, 2608, 2609, 2598, 0, 0, 0, 0
282, 2598, 2609, 2610, 2599, 0, 0, 0, 0
283, 2599, 2610, 2611, 2600, 0, 0, 0, 0
284, 2600, 2611, 2612, 2601, 0, 0, 0, 0
285, 2601, 2612, 2613, 2602, 0, 0, 0, 0
286, 2602, 2613, 2614, 2603, 0, 0, 0, 0
287, 2603, 2614, 2615, 2604, 0, 0, 0, 0
288, 2604, 2615, 2616, 2605, 0, 0, 0, 0
289, 2605, 2616, 187, 186, 0, 0, 0, 0
290, 164, 165, 2617, 2606, 0, 0, 0, 0
291, 2606, 2617, 2618, 2607, 0, 0, 0, 0
292, 2607, 2618, 2619, 2608, 0, 0, 0, 0
293, 2608, 2619, 2620, 2609, 0, 0, 0, 0
294, 2609, 2620, 2621, 2610, 0, 0, 0, 0
295, 2610, 2621, 2622, 2611, 0, 0, 0, 0
296, 2611, 2622, 2623, 2612, 0, 0, 0, 0
297, 2612, 2623, 2624, 2613, 0, 0, 0, 0
298, 2613, 2624, 2625, 2614, 0, 0, 0, 0
299, 2614, 2625, 2626, 2615, 0, 0, 0, 0
300, 2615, 2626, 2627, 2616, 0, 0, 0, 0
301, 2616, 2627, 188, 187, 0, 0, 0, 0
302, 165, 166, 2628, 2617, 0, 0, 0, 0
303, 2617, 2628, 2629, 2618, 0, 0, 0, 0
304, 2618, 2629, 2630, 2619, 0, 0, 0, 0
305, 2619, 2630, 2631, 2620, 0, 0, 0, 0
306, 2620, 2631, 2632, 2621, 0, 0, 0, 0
307, 2621, 2632, 2633, 2622, 0, 0, 0, 0
308, 2622, 2633, 2634, 2623, 0, 0, 0, 0
309, 2623, 2634, 2635, 2624, 0, 0, 0, 0
310, 2624, 2635, 2636, 2625, 0, 0, 0, 0
311, 2625, 2636, 2637, 2626, 0, 0, 0, 0
312, 2626, 2637, 2638, 2627, 0, 0, 0, 0
313, 2627, 2638, 189, 188, 0, 0, 0, 0
314, 166, 167, 2639, 2628, 0, 0, 0, 0
315, 2628, 2639, 2640, 2629, 0, 0, 0, 0
316, 2629, 2640, 2641, 2630, 0, 0, 0, 0
317, 2630, 2641, 2642, 2631, 0, 0, 0, 0
318, 2631, 2642, 2643, 2632, 0, 0, 0, 0
319, 2632, 2643, 2644, 2633, 0, 0, 0, 0
320, 2633, 2644, 2645, 2634, 0, 0, 0, 0
321, 2634, 2645, 2646, 2635, 0, 0, 0, 0
322, 2635, 2646, 2647, 2636, 0, 0, 0, 0
323, 2636, 2647, 2648, 2637, 0, 0, 0, 0
324, 2637, 2648, 2649, 2638, 0, 0, 0, 0
325, 2638, 2649, 190, 189, 0, 0, 0, 0
326, 167, 168, 2650, 2639, 0, 0, 0, 0
327, 2639, 2650, 2651, 2640, 0, 0, 0, 0
328, 2640, 2651, 2652, 2641, 0, 0, 0, 0
329, 2641, 2652, 2653, 2642, 0, 0, 0, 0
330, 2642, 2653, 2654, 2643, 0, 0, 0, 0
331, 2643, 2654, 2655, 2644, 0, 0, 0, 0
332, 2644, 2655, 2656, 2645, 0, 0, 0, 0
333, 2645, 2656, 2657, 2646, 0, 0, 0, 0
334, 2646, 2657, 2658, 2647, 0, 0, 0, 0
335, 2647, 2658, 2659, 2648, 0, 0, 0, 0
336, 2648, 2659, 2660, 2649, 0, 0, 0, 0
337, 2649, 2660, 191, 190, 0, 0, 0, 0
338, 168, 169, 2661, 2650, 0, 0, 0, 0
339, 2650, 2661, 2662, 2651, 0, 0, 0, 0
340, 2651, 2662, 2663, 2652, 0, 0, 0, 0
341, 2652, 2663, 2664, 2653, 0, 0, 0, 0
342, 2653, 2664, 2665, 2654, 0, 0, 0, 0
343, 2654, 2665, 2666, 2655, 0, 0, 0, 0
344, 2655, 2666, 2667, 2656, 0, 0, 0, 0
345, 2656, 2667, 2668, 2657, 0, 0, 0, 0
346, 2657, 2668, 2669, 2658, 0, 0, 0, 0
347, 2658, 2669, 2670, 2659, 0, 0, 0, 0
348, 2659, 2670, 2671, 2660, 0, 0, 0, 0
349, 2660, 2671, 192, 191, 0, 0, 0, 0
350, 169, 170, 2672, 2661, 0, 0, 0, 0
351, 2661, 2672, 2673, 2662, 0, 0, 0, 0
352, 2662, 2673, 2674, 2663, 0, 0, 0, 0
353, 2663, 2674, 2675, 2664, 0, 0, 0, 0
354, 2664, 2675, 2676, 2665, 0, 0, 0, 0
355, 2665, 2676, 2677, 2666, 0, 0, 0, 0
356, 2666, 2677, 2678, 2667, 0, 0, 0, 0
357, 2667, 2678, 2679, 2668, 0, 0, 0, 0
358, 2668, 2679, 2680, 2669, 0, 0, 0, 0
359, 2669, 2680, 2681, 2670, 0, 0, 0, 0
360, 2670, 2681, 2682, 2671, 0, 0, 0, 0
361, 2671, 2682, 193, 192, 0, 0, 0, 0
362, 170, 171, 2683, 2672, 0, 0, 0, 0
363, 2672, 2683, 2684, 2673, 0, 0, 0, 0
364, 2673, 2684, 2685, 2674, 0, 0, 0, 0
365, 2674, 2685, 2686, 2675, 0, 0, 0, 0
366, 2675, 2686, 2687, 2676, 0, 0, 0, 0
367, 2676, 2687, 2688, 2677, 0, 0, 0, 0
368, 2677, 2688, 2689, 2678, 0, 0, 0, 0
369, 2678, 2689, 2690, 2679, 0, 0, 0, 0
370, 2679, 2690, 2691, 2680, 0, 0, 0, 0
371, 2680, 2691, 2692, 2681, 0, 0, 0, 0
372, 2681, 2692, 2693, 2682, 0, 0, 0, 0
373, 2682, 2693, 194, 193, 0, 0, 0, 0
374, 171, 172, 2694, 2683, 0, 0, 0, 0
375, 2683, 2694, 2695, 2684, 0, 0, 0, 0
376, 2684, 2695, 2696, 2685, 0, 0, 0, 0
377, 2685, 2696, 2697, 2686, 0, 0, 0, 0
378, 2686, 2697, 2698, 2687, 0, 0, 0, 0
379, 2687, 2698, 2699, 2688, 0, 0, 0, 0
380, 2688, 2699, 2700, 2689, 0, 0, 0, 0
381, 2689, 2700, 2701, 2690, 0, 0, 0, 0
382, 2690, 2701, 2702, 2691, 0, 0, 0, 0
383, 2691, 2702, 2703, 2692, 0, 0, 0, 0
384, 2692, 2703, 2704, 2693, 0, 0, 0, 0
385, 2693, 2704, 195, 194, 0, 0, 0, 0
386, 172, 6, 124, 2694, 0, 0, 0, 0
387, 2694, 124, 125, 2695, 0, 0, 0, 0
388, 2695, 125, 126, 2696, 0, 0, 0, 0
389, 2696, 126, 127, 2697, 0, 0, 0, 0
390, 2697, 127, 128, 2698, 0, 0, 0, 0
391, 2698, 128, 129, 2699, 0, 0, 0, 0
392, 2699, 129, 130, 2700, 0, 0, 0, 0
393, 2700, 130, 131, 2701, 0, 0, 0, 0
394, 2701, 131, 132, 2702, 0, 0, 0, 0
395, 2702, 132, 133, 2703, 0, 0, 0, 0
396, 2703, 133, 134, 2704, 0, 0, 0, 0
397, 2704, 134, 5, 195, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface4
34127, 4, 111, 2705, 196, 0, 0, 0, 0
34128, 111, 112, 2706, 2705, 0, 0, 0, 0
34129, 112, 113, 2707, 2706, 0, 0, 0, 0
34130, 113, 114, 2708, 2707, 0, 0, 0, 0
34131, 114, 115, 2709, 2708, 0, 0, 0, 0
34132, 115, 116, 2710, 2709, 0, 0, 0, 0
34133, 116, 117, 2711, 2710, 0, 0, 0, 0
34134, 117, 118, 2712, 2711, 0, 0, 0, 0
34135, 118, 119, 2713, 2712, 0, 0, 0, 0
34136, 119, 120, 2714, 2713, 0, 0, 0, 0
34137, 120, 121, 2715, 2714, 0, 0, 0, 0
34138, 121, 3, 219, 2715, 0, 0, 0, 0
34139, 196, 2705, 2716, 197, 0, 0, 0, 0
34140, 2705, 2706, 2717, 2716, 0, 0, 0, 0
34141, 2706, 2707, 2718, 2717, 0, 0, 0, 0
34142, 2707, 2708, 2719, 2718, 0, 0, 0, 0
34143, 2708, 2709, 2720, 2719, 0, 0, 0, 0
34144, 2709, 2710, 2721, 2720, 0, 0, 0, 0
34145, 2710, 2711, 2722, 2721, 0, 0, 0, 0
34146, 2711, 2712, 2723, 2722, 0, 0, 0, 0
34147, 2712, 2713, 2724, 2723, 0, 0, 0, 0
34148, 2713, 2714, 2725, 2724, 0, 0, 0, 0
34149, 2714, 2715, 2726, 2725, 0, 0, 0, 0
34150, 2715, 219, 220, 2726, 0, 0, 0, 0
34151, 197, 2716, 2727, 198, 0, 0, 0, 0
34152, 2716, 2717, 2728, 2727, 0, 0, 0, 0
34153, 2717, 2718, 2729, 2728, 0, 0, 0, 0
34154, 2718, 2719, 2730, 2729, 0, 0, 0, 0
34155, 2719, 2720, 2731, 2730, 0, 0, 0, 0
34156, 2720, 2721, 2732, 2731, 0, 0, 0, 0
34157, 2721, 2722, 2733, 2732, 0, 0, 0, 0
34158, 2722, 2723, 2734, 2733, 0, 0, 0, 0
34159, 2723, 2724, 2735, 2734, 0, 0, 0, 0
34160, 2724, 2725, 2736, 2735, 0, 0, 0, 0
34161, 2725, 2726, 2737, 2736, 0, 0, 0, 0
34162, 2726, 220, 221, 2737, 0, 0, 0, 0
34163, 198, 2727, 2738, 199, 0, 0, 0, 0
34164, 2727, 2728, 2739, 2738, 0, 0, 0, 0
34165, 2728, 2729, 2740, 2739, 0, 0, 0, 0
34166, 2729, 2730, 2741, 2740, 0, 0, 0, 0
34167, 2730, 2731, 2742, 2741, 0, 0, 0, 0
34168, 2731, 2732, 2743, 2742, 0, 0, 0, 0
34169, 2732, 2733, 2744, 2743, 0, 0, 0, 0
34170, 2733, 2734, 2745, 2744, 0, 0, 0, 0
34171, 2734, 2735, 2746, 2745, 0, 0, 0, 0
34172, 2735, 2736, 2747, 2746, 0, 0, 0, 0
34173, 2736, 2737, 2748, 2747, 0, 0, 0, 0
34174, 2737, 221, 222, 2748, 0, 0, 0, 0
34175, 199, 2738, 2749, 200, 0, 0, 0, 0
34176, 2738, 2739, 2750, 2749, 0, 0, 0, 0
34177, 2739, 2740, 2751, 2750, 0, 0, 0, 0
34178, 2740, 2741, 2752, 2751, 0, 0, 0, 0
34179, 2741, 2742, 2753, 2752, 0, 0, 0, 0
34180, 2742, 2743, 2754, 2753, 0, 0, 0, 0
34181, 2743, 2744, 2755, 2754, 0, 0, 0, 0
34182, 2744, 2745, 2756, 2755, 0, 0, 0, 0
34183, 2745, 2746, 2757, 2756, 0, 0, 0, 0
34184, 2746, 2747, 2758, 2757, 0, 0, 0, 0
34185, 2747, 2748, 2759, 2758, 0, 0, 0, 0
34186, 2748, 222, 223, 2759, 0, 0, 0, 0
34187, 200, 2749, 2760, 201, 0, 0, 0, 0
34188, 2749, 2750, 2761, 2760, 0, 0, 0, 0
34189, 2750, 2751, 2762, 2761, 0, 0, 0, 0
34190, 2751, 2752, 2763, 2762, 0, 0, 0, 0
34191, 2752, 2753, 2764, 2763, 0, 0, 0, 0
34192, 2753, 2754, 2765, 2764, 0, 0, 0, 0
34193, 2754, 2755, 2766, 2765, 0, 0, 0, 0
34194, 2755, 2756, 2767, 2766, 0, 0, 0, 0
34195, 2756, 2757, 2768, 2767, 0, 0, 0, 0
34196, 2757, 2758, 2769, 2768, 0, 0, 0, 0
34197, 2758, 2759, 2770, 2769, 0, 0, 0, 0
34198, 2759, 223, 224, 2770, 0, 0, 0, 0
34199, 201, 2760, 2771, 202, 0, 0, 0, 0
34200, 2760, 2761, 2772, 2771, 0, 0, 0, 0
34201, 2761, 2762, 2773, 2772, 0, 0, 0, 0
34202, 2762, 2763, 2774, 2773, 0, 0, 0, 0
34203, 2763, 2764, 2775, 2774, 0, 0, 0, 0
34204, 2764, 2765, 2776, 2775, 0, 0, 0, 0
34205, 2765, 2766, 2777, 2776, 0, 0, 0, 0
34206, 2766, 2767, 2778, 2777, 0, 0, 0, 0
34207, 2767, 2768, 2779, 2778, 0, 0, 0, 0
34208, 2768, 2769, 2780, 2779, 0, 0, 0, 0
34209, 2769, 2770, 2781, 2780, 0, 0, 0, 0
34210, 2770, 224, 225, 2781, 0, 0, 0, 0
34211, 202, 2771, 2782, 203, 0, 0, 0, 0
34212, 2771, 2772, 2783, 2782, 0, 0, 0, 0
34213, 2772, 2773, 2784, 2783, 0, 0, 0, 0
34214, 2773, 2774, 2785, 2784, 0, 0, 0, 0
34215, 2774, 2775, 2786, 2785, 0, 0, 0, 0
34216, 2775, 2776, 2787, 2786, 0, 0, 0, 0
34217, 2776, 2777, 2788, 2787, 0, 0, 0, 0
34218, 2777, 2778, 2789, 2788, 0, 0, 0, 0
34219, 2778, 2779, 2790, 2789, 0, 0, 0, 0
34220, 2779, 2780, 2791, 2790, 0, 0, 0, 0
34221, 2780, 2781, 2792, 2791, 0, 0, 0, 0
34222, 2781, 225, 226, 2792, 0, 0, 0, 0
34223, 203, 2782, 2793, 204, 0, 0, 0, 0
34224, 2782, 2783, 2794, 2793, 0, 0, 0, 0
34225, 2783, 2784, 2795, 2794, 0, 0, 0, 0
34226, 2784, 2785, 2796, 2795, 0, 0, 0, 0
34227, 2785, 2786, 2797, 2796, 0, 0, 0, 0
34228, 2786, 2787, 2798, 2797, 0, 0, 0, 0
34229, 2787, 2788, 2799, 2798, 0, 0, 0, 0
34230, 2788, 2789, 2800, 2799, 0, 0, 0, 0
34231, 2789, 2790, 2801, 2800, 0, 0, 0, 0
34232, 2790, 2791, 2802, 2801, 0, 0, 0, 0
34233, 2791, 2792, 2803, 2802, 0, 0, 0, 0
34234, 2792, 226, 227, 2803, 0, 0, 0, 0
34235, 204, 2793, 2804, 205, 0, 0, 0, 0
34236, 2793, 2794, 2805, 2804, 0, 0, 0, 0
34237, 2794, 2795, 2806, 2805, 0, 0, 0, 0
34238, 2795, 2796, 2807, 2806, 0, 0, 0, 0
34239, 2796, 2797, 2808, 2807, 0, 0, 0, 0
34240, 2797, 2798, 2809, 2808, 0, 0, 0, 0
34241, 2798, 2799, 2810, 2809, 0, 0, 0, 0
34242, 2799, 2800, 2811, 2810, 0, 0, 0, 0
34243, 2800, 2801, 2812, 2811, 0, 0, 0, 0
34244, 2801, 2802, 2813, 2812, 0, 0, 0, 0
34245, 2802, 2803, 2814, 2813, 0, 0, 0, 0
34246, 2803, 227, 228, 2814, 0, 0, 0, 0
34247, 205, 2804, 2815, 206, 0, 0, 0, 0
34248, 2804, 2805, 2816, 2815, 0, 0, 0, 0
34249, 2805, 2806, 2817, 2816, 0, 0, 0, 0
34250, 2806, 2807, 2818, 2817, 0, 0, 0, 0
34251, 2807, 2808, 2819, 2818, 0, 0, 0, 0
34252, 2808, 2809, 2820, 2819, 0, 0, 0, 0
34253, 2809, 2810, 2821, 2820, 0, 0, 0, 0
34254, 2810, 2811, 2822, 2821, 0, 0, 0, 0
34255, 2811, 2812, 2823, 2822, 0, 0, 0, 0
34256, 2812, 2813, 2824, 2823, 0, 0, 0, 0
34257, 2813, 2814, 2825, 2824, 0, 0, 0, 0
34258, 2814, 228, 229, 2825, 0, 0, 0, 0
34259, 206, 2815, 2826, 207, 0, 0, 0, 0
34260, 2815, 2816, 2827, 2826, 0, 0, 0, 0
34261, 2816, 2817, 2828, 2827, 0, 0, 0, 0
34262, 2817, 2818, 2829, 2828, 0, 0, 0, 0
34263, 2818, 2819, 2830, 2829, 0, 0, 0, 0
34264, 2819, 2820, 2831, 2830, 0, 0, 0, 0
34265, 2820, 2821, 2832, 2831, 0, 0, 0, 0
34266, 2821, 2822, 2833, 2832, 0, 0, 0, 0
34267, 2822, 2823, 2834, 2833, 0, 0, 0, 0
34268, 2823, 2824, 2835, 2834, 0, 0, 0, 0
34269, 2824, 2825, 2836, 2835, 0, 0, 0, 0
34270, 2825, 229, 230, 2836, 0, 0, 0, 0
34271, 207, 2826, 2837, 208, 0, 0, 0, 0
34272, 2826, 2827, 2838, 2837, 0, 0, 0, 0
34273, 2827, 2828, 2839, 2838, 0, 0, 0, 0
34274, 2828, 2829, 2840, 2839, 0, 0, 0, 0
34275, 2829, 2830, 2841, 2840, 0, 0, 0, 0
34276, 2830, 2831, 2842, 2841, 0, 0, 0, 0
34277, 2831, 2832, 2843, 2842, 0, 0, 0, 0
34278, 2832, 2833, 2844, 2843, 0, 0, 0, 0
34279, 2833, 2834, 2845, 2844, 0, 0, 0, 0
34280, 2834, 2835, 2846, 2845, 0, 0, 0, 0
34281, 2835, 2836, 2847, 2846, 0, 0, 0, 0
34282, 2836, 230, 231, 2847, 0, 0, 0, 0
34283, 208, 2837, 2848, 209, 0, 0, 0, 0
34284, 2837, 2838, 2849, 2848, 0, 0, 0, 0
34285, 2838, 2839, 2850, 2849, 0, 0, 0, 0
34286, 2839, 2840, 2851, 2850, 0, 0, 0, 0
34287, 2840, 2841, 2852, 2851, 0, 0, 0, 0
34288, 2841, 2842, 2853, 2852, 0, 0, 0, 0
34289, 2842, 2843, 2854, 2853, 0, 0, 0, 0
34290, 2843, 2844, 2855, 2854, 0, 0, 0, 0
34291, 2844, 2845, 2856, 2855, 0, 0, 0, 0
34292, 2845, 2846, 2857, 2856, 0, 0, 0, 0
34293, 2846, 2847, 2858, 2857, 0, 0, 0, 0
34294, 2847, 231, 232, 2858, 0, 0, 0, 0
34295, 209, 2848, 2859, 210, 0, 0, 0, 0
34296, 2848, 2849, 2860, 2859, 0, 0, 0, 0
34297, 2849, 2850, 2861, 2860, 0, 0, 0, 0
34298, 2850, 2851, 2862, 2861, 0, 0, 0, 0
34299, 2851, 2852, 2863, 2862, 0, 0, 0, 0
34300, 2852, 2853, 2864, 2863, 0, 0, 0, 0
34301, 2853, 2854, 2865, 2864, 0, 0, 0, 0
34302, 2854, 2855, 2866, 2865, 0, 0, 0, 0
34303, 2855, 2856, 2867, 2866, 0, 0, 0, 0
34304, 2856, 2857, 2868, 2867, 0, 0, 0, 0
34305, 2857, 2858, 2869, 2868, 0, 0, 0, 0
34306, 2858, 232, 233, 2869, 0, 0, 0, 0
34307, 210, 2859, 2870, 211, 0, 0, 0, 0
34308, 2859, 2860, 2871, 2870, 0, 0, 0, 0
34309, 2860, 2861, 2872, 2871, 0, 0, 0, 0
34310, 2861, 2862, 2873, 2872, 0, 0, 0, 0
34311, 2862, 2863, 2874, 2873, 0, 0, 0, 0
34312, 2863, 2864, 2875, 2874, 0, 0, 0, 0
34313, 2864, 2865, 2876, 2875, 0, 0, 0, 0
34314, 2865, 2866, 2877, 2876, 0, 0, 0, 0
34315, 2866, 2867, 2878, 2877, 0, 0, 0, 0
34316, 2867, 2868, 2879, 2878, 0, 0, 0, 0
34317, 2868, 2869, 2880, 2879, 0, 0, 0, 0
34318, 2869, 233, 234, 2880, 0, 0, 0, 0
34319, 211, 2870, 2881, 212, 0, 0, 0, 0
34320, 2870, 2871, 2882, 2881, 0, 0, 0, 0
34321, 2871, 2872, 2883, 2882, 0, 0, 0, 0
34322, 2872, 2873, 2884, 2883, 0, 0, 0, 0
34323, 2873, 2874, 2885, 2884, 0, 0, 0, 0
34324, 2874, 2875, 2886, 2885, 0, 0, 0, 0
34325, 2875, 2876, 2887, 2886, 0, 0, 0, 0
34326, 2876, 2877, 2888, 2887, 0, 0, 0, 0
34327, 2877, 2878, 2889, 2888, 0, 0, 0, 0
34328, 2878, 2879, 2890, 2889, 0, 0, 0, 0
34329, 2879, 2880, 2891, 2890, 0, 0, 0, 0
34330, 2880, 234, 235, 2891, 0, 0, 0, 0
34331, 212, 2881, 2892, 213, 0, 0, 0, 0
34332, 2881, 2882, 2893, 2892, 0, 0, 0, 0
34333, 2882, 2883, 2894, 2893, 0, 0, 0, 0
34334, 2883, 2884, 2895, 2894, 0, 0, 0, 0
34335, 2884, 2885, 2896, 2895, 0, 0, 0, 0
34336, 2885, 2886, 2897, 2896, 0, 0, 0, 0
34337, 2886, 2887, 2898, 2897, 0, 0, 0, 0
34338, 2887, 2888, 2899, 2898, 0, 0, 0, 0
34339, 2888, 2889, 2900, 2899, 0, 0, 0, 0
34340, 2889, 2890, 2901, 2900, 0, 0, 0, 0
34341, 2890, 2891, 2902, 2901, 0, 0, 0, 0
34342, 2891, 235, 236, 2902, 0, 0, 0, 0
34343, 213, 2892, 2903, 214, 0, 0, 0, 0
34344, 2892, 2893, 2904, 2903, 0, 0, 0, 0
34345, 2893, 2894, 2905, 2904, 0, 0, 0, 0
34346, 2894, 2895, 2906, 2905, 0, 0, 0, 0
34347, 2895, 2896, 2907, 2906, 0, 0, 0, 0
34348, 2896, 2897, 2908, 2907, 0, 0, 0, 0
34349, 2897, 2898, 2909, 2908, 0, 0, 0, 0
34350, 2898, 2899, 2910, 2909, 0, 0, 0, 0
34351, 2899, 2900, 2911, 2910, 0, 0, 0, 0
34352, 2900, 2901, 2912, 2911, 0, 0, 0, 0
34353, 2901, 2902, 2913, 2912, 0, 0, 0, 0
34354, 2902, 236, 237, 2913, 0, 0, 0, 0
34355, 214, 2903, 2914, 215, 0, 0, 0, 0
34356, 2903, 2904, 2915, 2914, 0, 0, 0, 0
34357, 2904, 2905, 2916, 2915, 0, 0, 0, 0
34358, 2905, 2906, 2917, 2916, 0, 0, 0, 0
34359, 2906, 2907, 2918, 2917, 0, 0, 0, 0
34360, 2907, 2908, 2919, 2918, 0, 0, 0, 0
34361, 2908, 2909, 2920, 2919, 0, 0, 0, 0
34362, 2909, 2910, 2921, 2920, 0, 0, 0, 0
34363, 2910, 2911, 2922, 2921, 0, 0, 0, 0
34364, 2911, 2912, 2923, 2922, 0, 0, 0, 0
34365, 2912, 2913, 2924, 2923, 0, 0, 0, 0
34366, 2913, 237, 238, 2924, 0, 0, 0, 0
34367, 215, 2914, 2925, 216, 0, 0, 0, 0
34368, 2914, 2915, 2926, 2925, 0, 0, 0, 0
34369, 2915, 2916, 2927, 2926, 0, 0, 0, 0
34370, 2916, 2917, 2928, 2927, 0, 0, 0, 0
34371, 2917, 2918, 2929, 2928, 0, 0, 0, 0
34372, 2918, 2919, 2930, 2929, 0, 0, 0, 0
34373, 2919, 2920, 2931, 2930, 0, 0, 0, 0
34374, 2920, 2921, 2932, 2931, 0, 0, 0, 0
34375, 2921, 2922, 2933, 2932, 0, 0, 0, 0
34376, 2922, 2923, 2934, 2933, 0, 0, 0, 0
34377, 2923, 2924, 2935, 2934, 0, 0, 0, 0
34378, 2924, 238, 239, 2935, 0, 0, 0, 0
34379, 216, 2925, 2936, 217, 0, 0, 0, 0
34380, 2925, 2926, 2937, 2936, 0, 0, 0, 0
34381, 2926, 2927, 2938, 2937, 0, 0, 0, 0
34382, 2927, 2928, 2939, 2938, 0, 0, 0, 0
34383, 2928, 2929, 2940, 2939, 0, 0, 0, 0
34384, 2929, 2930, 2941, 2940, 0, 0, 0, 0
34385, 2930, 2931, 2942, 2941, 0, 0, 0, 0
34386, 2931, 2932, 2943, 2942, 0, 0, 0, 0
34387, 2932, 2933, 2944, 2943, 0, 0, 0, 0
34388, 2933, 2934, 2945, 2944, 0, 0, 0, 0
34389, 2934, 2935, 2946, 2945, 0, 0, 0, 0
34390, 2935, 239, 240, 2946, 0, 0, 0, 0
34391, 217, 2936, 2947, 218, 0, 0, 0, 0
34392, 2936, 2937, 2948, 2947, 0, 0, 0, 0
34393, 2937, 2938, 2949, 2948, 0, 0, 0, 0
34394, 2938, 2939, 2950, 2949, 0, 0, 0, 0
34395, 2939, 2940, 2951, 2950, 0, 0, 0, 0
34396, 2940, 2941, 2952, 2951, 0, 0, 0, 0
34397, 2941, 2942, 2953, 2952, 0, 0, 0, 0
34398, 2942, 2943, 2954, 2953, 0, 0, 0, 0
34399, 2943, 2944, 2955, 2954, 0, 0, 0, 0
34400, 2944, 2945, 2956, 2955, 0, 0, 0, 0
34401, 2945, 2946, 2957, 2956, 0, 0, 0, 0
34402, 2946, 240, 241, 2957, 0, 0, 0, 0
34403, 218, 2947, 137, 8, 0, 0, 0, 0
34404, 2947, 2948, 138, 137, 0, 0, 0, 0
34405, 2948, 2949, 139, 138, 0, 0, 0, 0
34406, 2949, 2950, 140, 139, 0, 0, 0, 0
34407, 2950, 2951, 141, 140, 0, 0, 0, 0
34408, 2951, 2952, 142, 141, 0, 0, 0, 0
34409, 2952, 2953, 143, 142, 0, 0, 0, 0
34410, 2953, 2954, 144, 143, 0, 0, 0, 0
34411, 2954, 2955, 145, 144, 0, 0, 0, 0
34412, 2955, 2956, 146, 145, 0, 0, 0, 0
34413, 2956, 2957, 147, 146, 0, 0, 0, 0
34414, 2957, 241, 7, 147, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface5
34415, 2, 122, 2958, 150, 0, 0, 0, 0
34416, 150, 2958, 2959, 151, 0, 0, 0, 0
34417, 151, 2959, 2960, 152, 0, 0, 0, 0
34418, 152, 2960, 2961, 153, 0, 0, 0, 0
34419, 153, 2961, 2962, 154, 0, 0, 0, 0
34420, 154, 2962, 2963, 155, 0, 0, 0, 0
34421, 155, 2963, 2964, 156, 0, 0, 0, 0
34422, 156, 2964, 2965, 157, 0, 0, 0, 0
34423, 157, 2965, 2966, 158, 0, 0, 0, 0
34424, 158, 2966, 2967, 159, 0, 0, 0, 0
34425, 159, 2967, 2968, 160, 0, 0, 0, 0
34426, 160, 2968, 2969, 161, 0, 0, 0, 0
34427, 161, 2969, 2970, 162, 0, 0, 0, 0
34428, 162, 2970, 2971, 163, 0, 0, 0, 0
34429, 163, 2971, 2972, 164, 0, 0, 0, 0
34430, 164, 2972, 2973, 165, 0, 0, 0, 0
34431, 165, 2973, 2974, 166, 0, 0, 0, 0
34432, 166, 2974, 2975, 167, 0, 0, 0, 0
34433, 167, 2975, 2976, 168, 0, 0, 0, 0
34434, 168, 2976, 2977, 169, 0, 0, 0, 0
34435, 169, 2977, 2978, 170, 0, 0, 0, 0
34436, 170, 2978, 2979, 171, 0, 0, 0, 0
34437, 171, 2979, 2980, 172, 0, 0, 0, 0
34438, 172, 2980, 148, 6, 0, 0, 0, 0
34439, 122, 123, 2981, 2958, 0, 0, 0, 0
34440, 2958, 2981, 2982, 2959, 0, 0, 0, 0
34441, 2959, 2982, 2983, 2960, 0, 0, 0, 0
34442, 2960, 2983, 2984, 2961, 0, 0, 0, 0
34443, 2961, 2984, 2985, 2962, 0, 0, 0, 0
34444, 2962, 2985, 2986, 2963, 0, 0, 0, 0
34445, 2963, 2986, 2987, 2964, 0, 0, 0, 0
34446, 2964, 2987, 2988, 2965, 0, 0, 0, 0
34447, 2965, 2988, 2989, 2966, 0, 0, 0, 0
34448, 2966, 2989, 2990, 2967, 0, 0, 0, 0
34449, 2967, 2990, 2991, 2968, 0, 0, 0, 0
34450, 2968, 2991, 2992, 2969, 0, 0, 0, 0
34451, 2969, 2992, 2993, 2970, 0, 0, 0, 0
34452, 2970, 2993, 2994, 2971, 0, 0, 0, 0
34453, 2971, 2994, 2995, 2972, 0, 0, 0, 0
34454, 2972, 2995, 2996, 2973, 0, 0, 0, 0
34455, 2973, 2996, 2997, 2974, 0, 0, 0, 0
34456, 2974, 2997, 2998, 2975, 0, 0, 0, 0
34457, 2975, 2998, 2999, 2976, 0, 0, 0, 0
34458, 2976, 2999, 3000, 2977, 0, 0, 0, 0
34459, 2977, 3000, 3001, 2978, 0, 0, 0, 0
34460, 2978, 3001, 3002, 2979, 0, 0, 0, 0
34461, 2979, 3002, 3003, 2980, 0, 0, 0, 0
34462, 2980, 3003, 149, 148, 0, 0, 0, 0
34463, 123, 4, 196, 2981, 0, 0, 0, 0
34464, 2981, 196, 197, 2982, 0, 0, 0, 0
34465, 2982, 197, 198, 2983, 0, 0, 0, 0
34466, 2983, 198, 199, 2984, 0, 0, 0, 0
34467, 2984, 199, 200, 2985, 0, 0, 0, 0
34468, 2985, 200, 201, 2986, 0, 0, 0, 0
34469, 2986, 201, 202, 2987, 0, 0, 0, 0
34470, 2987, 202, 203, 2988, 0, 0, 0, 0
34471, 2988, 203, 204, 2989, 0, 0, 0, 0
34472, 2989, 204, 205, 2990, 0, 0, 0, 0
34473, 2990, 205, 206, 2991, 0, 0, 0, 0
34474, 2991, 206, 207, 2992, 0, 0, 0, 0
34475, 2992, 207, 208, 2993, 0, 0, 0, 0
34476, 2993, 208, 209, 2994, 0, 0, 0, 0
34477, 2994, 209, 210, 2995, 0, 0, 0, 0
34478, 2995, 210, 211, 2996, 0, 0, 0, 0
34479, 2996, 211, 212, 2997, 0, 0, 0, 0
34480, 2997, 212, 213, 2998, 0, 0, 0, 0
34481, 2998, 213, 214, 2999, 0, 0, 0, 0
34482, 2999, 214, 215, 3000, 0, 0, 0, 0
34483, 3000, 215, 216, 3001, 0, 0, 0, 0
34484, 3001, 216, 217, 3002, 0, 0, 0, 0
34485, 3002, 217, 218, 3003, 0, 0, 0, 0
34486, 3003, 218, 8, 149, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface6
398, 1, 173, 3004, 109, 0, 0, 0, 0
399, 173, 174, 3005, 3004, 0, 0, 0, 0
400, 174, 175, 3006, 3005, 0, 0, 0, 0
401, 175, 176, 3007, 3006, 0, 0, 0, 0
402, 176, 177, 3008, 3007, 0, 0, 0, 0
403, 177, 178, 3009, 3008, 0, 0, 0, 0
404, 178, 179, 3010, 3009, 0, 0, 0, 0
405, 179, 180, 3011, 3010, 0, 0, 0, 0
406, 180, 181, 3012, 3011, 0, 0, 0, 0
407, 181, 182, 3013, 3012, 0, 0, 0, 0
408, 182, 183, 3014, 3013, 0, 0, 0, 0
409, 183, 184, 3015, 3014, 0, 0, 0, 0
410, 184, 185, 3016, 3015, 0, 0, 0, 0
411, 185, 186, 3017, 3016, 0, 0, 0, 0
412, 186, 187, 3018, 3017, 0, 0, 0, 0
413, 187, 188, 3019, 3018, 0, 0, 0, 0
414, 188, 189, 3020, 3019, 0, 0, 0, 0
415, 189, 190, 3021, 3020, 0, 0, 0, 0
416, 190, 191, 3022, 3021, 0, 0, 0, 0
417, 191, 192, 3023, 3022, 0, 0, 0, 0
418, 192, 193, 3024, 3023, 0, 0, 0, 0
419, 193, 194, 3025, 3024, 0, 0, 0, 0
420, 194, 195, 3026, 3025, 0, 0, 0, 0
421, 195, 5, 135, 3026, 0, 0, 0, 0
422, 109, 3004, 3027, 110, 0, 0, 0, 0
423, 3004, 3005, 3028, 3027, 0, 0, 0, 0
424, 3005, 3006, 3029, 3028, 0, 0, 0, 0
425, 3006, 3007, 3030, 3029, 0, 0, 0, 0
426, 3007, 3008, 3031, 3030, 0, 0, 0, 0
427, 3008, 3009, 3032, 3031, 0, 0, 0, 0
428, 3009, 3010, 3033, 3032, 0, 0, 0, 0
429, 3010, 3011, 3034, 3033, 0, 0, 0, 0
430, 3011, 3012, 3035, 3034, 0, 0, 0, 0
431, 3012, 3013, 3036, 3035, 0, 0, 0, 0
432, 3013, 3014, 3037, 3036, 0, 0, 0, 0
433, 3014, 3015, 3038, 3037, 0, 0, 0, 0
434, 3015, 3016, 3039, 3038, 0, 0, 0, 0
435, 3016, 3017, 3040, 3039, 0, 0, 0, 0
436, 3017, 3018, 3041, 3040, 0, 0, 0, 0
437, 3018, 3019, 3042, 3041, 0, 0, 0, 0
438, 3019, 3020, 3043, 3042, 0, 0, 0, 0
439, 3020, 3021, 3044, 3043, 0, 0, 0, 0
440, 3021, 3022, 3045, 3044, 0, 0, 0, 0
441, 3022, 3023, 3046, 3045, 0, 0, 0, 0
442, 3023, 3024, 3047, 3046, 0, 0, 0, 0
443, 3024, 3025, 3048, 3047, 0, 0, 0, 0
444, 3025, 3026, 3049, 3048, 0, 0, 0, 0
445, 3026, 135, 136, 3049, 0, 0, 0, 0
446, 110, 3027, 219, 3, 0, 0, 0, 0
447, 3027, 3028, 220, 219, 0, 0, 0, 0
448, 3028, 3029, 221, 220, 0, 0, 0, 0
449, 3029, 3030, 222, 221, 0, 0, 0, 0
450, 3030, 3031, 223, 222, 0, 0, 0, 0
451, 3031, 3032, 224, 223, 0, 0, 0, 0
452, 3032, 3033, 225, 224, 0, 0, 0, 0
453, 3033, 3034, 226, 225, 0, 0, 0, 0
454, 3034, 3035, 227, 226, 0, 0, 0, 0
455, 3035, 3036, 228, 227, 0, 0, 0, 0
456, 3036, 3037, 229, 228, 0, 0, 0, 0
457, 3037, 3038, 230, 229, 0, 0, 0, 0
458, 3038, 3039, 231, 230, 0, 0, 0, 0
459, 3039, 3040, 232, 231, 0, 0, 0, 0
460, 3040, 3041, 233, 232, 0, 0, 0, 0
461, 3041, 3042, 234, 233, 0, 0, 0, 0
462, 3042, 3043, 235, 234, 0, 0, 0, 0
463, 3043, 3044, 236, 235, 0, 0, 0, 0
464, 3044, 3045, 237, 236, 0, 0, 0, 0
465, 3045, 3046, 238, 237, 0, 0, 0, 0
466, 3046, 3047, 239, 238, 0, 0, 0, 0
467, 3047, 3048, 240, 239, 0, 0, 0, 0
468, 3048, 3049, 241, 240, 0, 0, 0, 0
469, 3049, 136, 7, 241, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface7
34487, 4, 10, 242, 196, 0, 0, 0, 0
34488, 196, 242, 243, 197, 0, 0, 0, 0
34489, 197, 243, 244, 198, 0, 0, 0, 0
34490, 198, 244, 245, 199, 0, 0, 0, 0
34491, 199, 245, 246, 200, 0, 0, 0, 0
34492, 200, 246, 247, 201, 0, 0, 0, 0
34493, 201, 247, 248, 202, 0, 0, 0, 0
34494, 202, 248, 249, 203, 0, 0, 0, 0
34495, 203, 249, 250, 204, 0, 0, 0, 0
34496, 204, 250, 251, 205, 0, 0, 0, 0
34497, 205, 251, 252, 206, 0, 0, 0, 0
34498, 206, 252, 253, 207, 0, 0, 0, 0
34499, 207, 253, 254, 208, 0, 0, 0, 0
34500, 208, 254, 255, 209, 0, 0, 0, 0
34501, 209, 255, 256, 210, 0, 0, 0, 0
34502, 210, 256, 257, 211, 0, 0, 0, 0
34503, 211, 257, 258, 212, 0, 0, 0, 0
34504, 212, 258, 259, 213, 0, 0, 0, 0
34505, 213, 259, 260, 214, 0, 0, 0, 0
34506, 214, 260, 261, 215, 0, 0, 0, 0
34507, 215, 261, 262, 216, 0, 0, 0, 0
34508, 216, 262, 263, 217, 0, 0, 0, 0
34509, 217, 263, 264, 218, 0, 0, 0, 0
34510, 218, 264, 9, 8, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface8
34511, 8, 9, 265, 137, 0, 0, 0, 0
34512, 137, 265, 266, 138, 0, 0, 0, 0
34513, 138, 266, 267, 139, 0, 0, 0, 0
34514, 139, 267, 268, 140, 0, 0, 0, 0
34515, 140, 268, 269, 141, 0, 0, 0, 0
34516, 141, 269, 270, 142, 0, 0, 0, 0
34517, 142, 270, 271, 143, 0, 0, 0, 0
34518, 143, 271, 272, 144, 0, 0, 0, 0
34519, 144, 272, 273, 145, 0, 0, 0, 0
34520, 145, 273, 274, 146, 0, 0, 0, 0
34521, 146, 274, 275, 147, 0, 0, 0, 0
34522, 147, 275, 11, 7, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface9
470, 3, 219, 276, 12, 0, 0, 0, 0
471, 219, 220, 277, 276, 0, 0, 0, 0
472, 220, 221, 278, 277, 0, 0, 0, 0
473, 221, 222, 279, 278, 0, 0, 0, 0
474, 222, 223, 280, 279, 0, 0, 0, 0
475, 223, 224, 281, 280, 0, 0, 0, 0
476, 224, 225, 282, 281, 0, 0, 0, 0
477, 225, 226, 283, 282, 0, 0, 0, 0
478, 226, 227, 284, 283, 0, 0, 0, 0
479, 227, 228, 285, 284, 0, 0, 0, 0
480, 228, 229, 286, 285, 0, 0, 0, 0
481, 229, 230, 287, 286, 0, 0, 0, 0
482, 230, 231, 288, 287, 0, 0, 0, 0
483, 231, 232, 289, 288, 0, 0, 0, 0
484, 232, 233, 290, 289, 0, 0, 0, 0
485, 233, 234, 291, 290, 0, 0, 0, 0
486, 234, 235, 292, 291, 0, 0, 0, 0
487, 235, 236, 293, 292, 0, 0, 0, 0
488, 236, 237, 294, 293, 0, 0, 0, 0
489, 237, 238, 295, 294, 0, 0, 0, 0
490, 238, 239, 296, 295, 0, 0, 0, 0
491, 239, 240, 297, 296, 0, 0, 0, 0
492, 240, 241, 298, 297, 0, 0, 0, 0
493, 241, 7, 11, 298, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface10
34523, 4, 111, 299, 10, 0, 0, 0, 0
34524, 111, 112, 300, 299, 0, 0, 0, 0
34525, 112, 113, 301, 300, 0, 0, 0, 0
34526, 113, 114, 302, 301, 0, 0, 0, 0
34527, 114, 115, 303, 302, 0, 0, 0, 0
34528, 115, 116, 304, 303, 0, 0, 0, 0
34529, 116, 117, 305, 304, 0, 0, 0, 0
34530, 117, 118, 306, 305, 0, 0, 0, 0
34531, 118, 119, 307, 306, 0, 0, 0, 0
34532, 119, 120, 308, 307, 0, 0, 0, 0
34533, 120, 121, 309, 308, 0, 0, 0, 0
34534, 121, 3, 12, 309, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface11
34535, 10, 299, 3050, 242, 0, 0, 0, 0
34536, 299, 300, 3051, 3050, 0, 0, 0, 0
34537, 300, 301, 3052, 3051, 0, 0, 0, 0
34538, 301, 302, 3053, 3052, 0, 0, 0, 0
34539, 302, 303, 3054, 3053, 0, 0, 0, 0
34540, 303, 304, 3055, 3054, 0, 0, 0, 0
34541, 304, 305, 3056, 3055, 0, 0, 0, 0
34542, 305, 306, 3057, 3056, 0, 0, 0, 0
34543, 306, 307, 3058, 3057, 0, 0, 0, 0
34544, 307, 308, 3059, 3058, 0, 0, 0, 0
34545, 308, 309, 3060, 3059, 0, 0, 0, 0
34546, 309, 12, 276, 3060, 0, 0, 0, 0
34547, 242, 3050, 3061, 243, 0, 0, 0, 0
34548, 3050, 3051, 3062, 3061, 0, 0, 0, 0
34549, 3051, 3052, 3063, 3062, 0, 0, 0, 0
34550, 3052, 3053, 3064, 3063, 0, 0, 0, 0
34551, 3053, 3054, 3065, 3064, 0, 0, 0, 0
34552, 3054, 3055, 3066, 3065, 0, 0, 0, 0
34553, 3055, 3056, 3067, 3066, 0, 0, 0, 0
34554, 3056, 3057, 3068, 3067, 0, 0, 0, 0
34555, 3057, 3058, 3069, 3068, 0, 0, 0, 0
34556, 3058, 3059, 3070, 3069, 0, 0, 0, 0
34557, 3059, 3060, 3071, 3070, 0, 0, 0, 0
34558, 3060, 276, 277, 3071, 0, 0, 0, 0
34559, 243, 3061, 3072, 244, 0, 0, 0, 0
34560, 3061, 3062, 3073, 3072, 0, 0, 0, 0
34561, 3062, 3063, 3074, 3073, 0, 0, 0, 0
34562, 3063, 3064, 3075, 3074, 0, 0, 0, 0
34563, 3064, 3065, 3076, 3075, 0, 0, 0, 0
34564, 3065, 3066, 3077, 3076, 0, 0, 0, 0
34565, 3066, 3067, 3078, 3077, 0, 0, 0, 0
34566, 3067, 3068, 3079, 3078, 0, 0, 0, 0
34567, 3068, 3069, 3080, 3079, 0, 0, 0, 0
34568, 3069, 3070, 3081, 3080, 0, 0, 0, 0
34569, 3070, 3071, 3082, 3081, 0, 0, 0, 0
34570, 3071, 277, 278, 3082, 0, 0, 0, 0
34571, 244, 3072, 3083, 245, 0, 0, 0, 0
34572, 3072, 3073, 3084, 3083, 0, 0, 0, 0
34573, 3073, 3074, 3085, 3084, 0, 0, 0, 0
34574, 3074, 3075, 3086, 3085, 0, 0, 0, 0
34575, 3075, 3076, 3087, 3086, 0, 0, 0, 0
34576, 3076, 3077, 3088, 3087, 0, 0, 0, 0
34577, 3077, 3078, 3089, 3088, 0, 0, 0, 0
34578, 3078, 3079, 3090, 3089, 0, 0, 0, 0
34579, 3079, 3080, 3091, 3090, 0, 0, 0, 0
34580, 3080, 3081, 3092, 3091, 0, 0, 0, 0
34581, 3081, 3082, 3093, 3092, 0, 0, 0, 0
34582, 3082, 278, 279, 3093, 0, 0, 0, 0
34583, 245, 3083, 3094, 246, 0, 0, 0, 0
34584, 3083, 3084, 3095, 3094, 0, 0, 0, 0
34585, 3084, 3085, 3096, 3095, 0, 0, 0, 0
34586, 3085, 3086, 3097, 3096, 0, 0, 0, 0
34587, 3086, 3087, 3098, 3097, 0, 0, 0, 0
34588, 3087, 3088, 3099, 3098, 0, 0, 0, 0
34589, 3088, 3089, 3100, 3099, 0, 0, 0, 0
34590, 3089, 3090, 3101, 3100, 0, 0, 0, 0
34591, 3090, 3091, 3102, 3101, 0, 0, 0, 0
34592, 3091, 3092, 3103, 3102, 0, 0, 0, 0
34593, 3092, 3093, 3104, 3103, 0, 0, 0, 0
34594, 3093, 279, 280, 3104, 0, 0, 0, 0
34595, 246, 3094, 3105, 247, 0, 0, 0, 0
34596, 3094, 3095, 3106, 3105, 0, 0, 0, 0
34597, 3095, 3096, 3107, 3106, 0, 0, 0, 0
34598, 3096, 3097, 3108, 3107, 0, 0, 0, 0
34599, 3097, 3098, 3109, 3108, 0, 0, 0, 0
34600, 3098, 3099, 3110, 3109, 0, 0, 0, 0
34601, 3099, 3100, 3111, 3110, 0, 0, 0, 0
34602, 3100, 3101, 3112, 3111, 0, 0, 0, 0
34603, 3101, 3102, 3113, 3112, 0, 0, 0, 0
34604, 3102, 3103, 3114, 3113, 0, 0, 0, 0
34605, 3103, 3104, 3115, 3114, 0, 0, 0, 0
34606, 3104, 280, 281, 3115, 0, 0, 0, 0
34607, 247, 3105, 3116, 248, 0, 0, 0, 0
34608, 3105, 3106, 3117, 3116, 0, 0, 0, 0
34609, 3106, 3107, 3118, 3117, 0, 0, 0, 0
34610, 3107, 3108, 3119, 3118, 0, 0, 0, 0
34611, 3108, 3109, 3120, 3119, 0, 0, 0, 0
34612, 3109, 3110, 3121, 3120, 0, 0, 0, 0
34613, 3110, 3111, 3122, 3121, 0, 0, 0, 0
34614, 3111, 3112, 3123, 3122, 0, 0, 0, 0
34615, 3112, 3113, 3124, 3123, 0, 0, 0, 0
34616, 3113, 3114, 3125, 3124, 0, 0, 0, 0
34617, 3114, 3115, 3126, 3125, 0, 0, 0, 0
34618, 3115, 281, 282, 3126, 0, 0, 0, 0
34619, 248, 3116, 3127, 249, 0, 0, 0, 0
34620, 3116, 3117, 3128, 3127, 0, 0, 0, 0
34621, 3117, 3118, 3129, 3128, 0, 0, 0, 0
34622, 3118, 3119, 3130, 3129, 0, 0, 0, 0
34623, 3119, 3120, 3131, 3130, 0, 0, 0, 0
34624, 3120, 3121, 3132, 3131, 0, 0, 0, 0
34625, 3121, 3122, 3133, 3132, 0, 0, 0, 0
34626, 3122, 3123, 3134, 3133, 0, 0, 0, 0
34627, 3123, 3124, 3135, 3134, 0, 0, 0, 0
34628, 3124, 3125, 3136, 3135, 0, 0, 0, 0
34629, 3125, 3126, 3137, 3136, 0, 0, 0, 0
34630, 3126, 282, 283, 3137, 0, 0, 0, 0
34631, 249, 3127, 3138, 250, 0, 0, 0, 0
34632, 3127, 3128, 3139, 3138, 0, 0, 0, 0
34633, 3128, 3129, 3140, 3139, 0, 0, 0, 0
34634, 3129, 3130, 3141, 3140, 0, 0, 0, 0
34635, 3130, 3131, 3142, 3141, 0, 0, 0, 0
34636, 3131, 3132, 3143, 3142, 0, 0, 0, 0
34637, 3132, 3133, 3144, 3143, 0, 0, 0, 0
34638, 3133, 3134, 3145, 3144, 0, 0, 0, 0
34639, 3134, 3135, 3146, 3145, 0, 0, 0, 0
34640, 3135, 3136, 3147, 3146, 0, 0, 0, 0
34641, 3136, 3137, 3148, 3147, 0, 0, 0, 0
34642, 3137, 283, 284, 3148, 0, 0, 0, 0
34643, 250, 3138, 3149, 251, 0, 0, 0, 0
34644, 3138, 3139, 3150, 3149, 0, 0, 0, 0
34645, 3139, 3140, 3151, 3150, 0, 0, 0, 0
34646, 3140, 3141, 3152, 3151, 0, 0, 0, 0
34647, 3141, 3142, 3153, 3152, 0, 0, 0, 0
34648, 3142, 3143, 3154, 3153, 0, 0, 0, 0
34649, 3143, 3144, 3155, 3154, 0, 0, 0, 0
34650, 3144, 3145, 3156, 3155, 0, 0, 0, 0
34651, 3145, 3146, 3157, 3156, 0, 0, 0, 0
34652, 3146, 3147, 3158, 3157, 0, 0, 0, 0
34653, 3147, 3148, 3159, 3158, 0, 0, 0, 0
34654, 3148, 284, 285, 3159, 0, 0, 0, 0
34655, 251, 3149, 3160, 252, 0, 0, 0, 0
34656, 3149, 3150, 3161, 3160, 0, 0, 0, 0
34657, 3150, 3151, 3162, 3161, 0, 0, 0, 0
34658, 3151, 3152, 3163, 3162, 0, 0, 0, 0
34659, 3152, 3153, 3164, 3163, 0, 0, 0, 0
34660, 3153, 3154, 3165, 3164, 0, 0, 0, 0
34661, 3154, 3155, 3166, 3165, 0, 0, 0, 0
34662, 3155, 3156, 3167, 3166, 0, 0, 0, 0
34663, 3156, 3157, 3168, 3167, 0, 0, 0, 0
34664, 3157, 3158, 3169, 3168, 0, 0, 0, 0
34665, 3158, 3159, 3170, 3169, 0, 0, 0, 0
34666, 3159, 285, 286, 3170, 0, 0, 0, 0
34667, 252, 3160, 3171, 253, 0, 0, 0, 0
34668, 3160, 3161, 3172, 3171, 0, 0, 0, 0
34669, 3161, 3162, 3173, 3172, 0, 0, 0, 0
34670, 3162, 3163, 3174, 3173, 0, 0, 0, 0
34671, 3163, 3164, 3175, 3174, 0, 0, 0, 0
34672, 3164, 3165, 3176, 3175, 0, 0, 0, 0
34673, 3165, 3166, 3177, 3176, 0, 0, 0, 0
34674, 3166, 3167, 3178, 3177, 0, 0, 0, 0
34675, 3167, 3168, 3179, 3178, 0, 0, 0, 0
34676, 3168, 3169, 3180, 3179, 0, 0, 0, 0
34677, 3169, 3170, 3181, 3180, 0, 0, 0, 0
34678, 3170, 286, 287, 3181, 0, 0, 0, 0
34679, 253, 3171, 3182, 254, 0, 0, 0, 0
34680, 3171, 3172, 3183, 3182, 0, 0, 0, 0
34681, 3172, 3173, 3184, 3183, 0, 0, 0, 0
34682, 3173, 3174, 3185, 3184, 0, 0, 0, 0
34683, 3174, 3175, 3186, 3185, 0, 0, 0, 0
34684, 3175, 3176, 3187, 3186, 0, 0, 0, 0
34685, 3176, 3177, 3188, 3187, 0, 0, 0, 0
34686, 3177, 3178, 3189, 3188, 0, 0, 0, 0
34687, 3178, 3179, 3190, 3189, 0, 0, 0, 0
34688, 3179, 3180, 3191, 3190, 0, 0, 0, 0
34689, 3180, 3181, 3192, 3191, 0, 0, 0, 0
34690, 3181, 287, 288, 3192, 0, 0, 0, 0
34691, 254, 3182, 3193, 255, 0, 0, 0, 0
34692, 3182, 3183, 3194, 3193, 0, 0, 0, 0
34693, 3183, 3184, 3195, 3194, 0, 0, 0, 0
34694, 3184, 3185, 3196, 3195, 0, 0, 0, 0
34695, 3185, 3186, 3197, 3196, 0, 0, 0, 0
34696, 3186, 3187, 3198, 3197, 0, 0, 0, 0
34697, 3187, 3188, 3199, 3198, 0, 0, 0, 0
34698, 3188, 3189, 3200, 3199, 0, 0, 0, 0
34699, 3189, 3190, 3201, 3200, 0, 0, 0, 0
34700, 3190, 3191, 3202, 3201, 0, 0, 0, 0
34701, 3191, 3192, 3203, 3202, 0, 0, 0, 0
34702, 3192, 288, 289, 3203, 0, 0, 0, 0
34703, 255, 3193, 3204, 256, 0, 0, 0, 0
34704, 3193, 3194, 3205, 3204, 0, 0, 0, 0
34705, 3194, 3195, 3206, 3205, 0, 0, 0, 0
34706, 3195, 3196, 3207, 3206, 0, 0, 0, 0
34707, 3196, 3197, 3208, 3207, 0, 0, 0, 0
34708, 3197, 3198, 3209, 3208, 0, 0, 0, 0
34709, 3198, 3199, 3210, 3209, 0, 0, 0, 0
34710, 3199, 3200, 3211, 3210, 0, 0, 0, 0
34711, 3200, 3201, 3212, 3211, 0, 0, 0, 0
34712, 3201, 3202, 3213, 3212, 0, 0, 0, 0
34713, 3202, 3203, 3214, 3213, 0, 0, 0, 0
34714, 3203, 289, 290, 3214, 0, 0, 0, 0
34715, 256, 3204, 3215, 257, 0, 0, 0, 0
34716, 3204, 3205, 3216, 3215, 0, 0, 0, 0
34717, 3205, 3206, 3217, 3216, 0, 0, 0, 0
34718, 3206, 3207, 3218, 3217, 0, 0, 0, 0
34719, 3207, 3208, 3219, 3218, 0, 0, 0, 0
34720, 3208, 3209, 3220, 3219, 0, 0, 0, 0
34721, 3209, 3210, 3221, 3220, 0, 0, 0, 0
34722, 3210, 3211, 3222, 3221, 0, 0, 0, 0
34723, 3211, 3212, 3223, 3222, 0, 0, 0, 0
34724, 3212, 3213, 3224, 3223, 0, 0, 0, 0
34725, 3213, 3214, 3225, 3224, 0, 0, 0, 0
34726, 3214, 290, 291, 3225, 0, 0, 0, 0
34727, 257, 3215, 3226, 258, 0, 0, 0, 0
34728, 3215, 3216, 3227, 3226, 0, 0, 0, 0
34729, 3216, 3217, 3228, 3227, 0, 0, 0, 0
34730, 3217, 3218, 3229, 3228, 0, 0, 0, 0
34731, 3218, 3219, 3230, 3229, 0, 0, 0, 0
34732, 3219, 3220, 3231, 3230, 0, 0, 0, 0
34733, 3220, 3221, 3232, 3231, 0, 0, 0, 0
34734, 3221, 3222, 3233, 3232, 0, 0, 0, 0
34735, 3222, 3223, 3234, 3233, 0, 0, 0, 0
34736, 3223, 3224, 3235, 3234, 0, 0, 0, 0
34737, 3224, 3225, 3236, 3235, 0, 0, 0, 0
34738, 3225, 291, 292, 3236, 0, 0, 0, 0
34739, 258, 3226, 3237, 259, 0, 0, 0, 0
34740, 3226, 3227, 3238, 3237, 0, 0, 0, 0
34741, 3227, 3228, 3239, 3238, 0, 0, 0, 0
34742, 3228, 3229, 3240, 3239, 0, 0, 0, 0
34743, 3229, 3230, 3241, 3240, 0, 0, 0, 0
34744, 3230, 3231, 3242, 3241, 0, 0, 0, 0
34745, 3231, 3232, 3243, 3242, 0, 0, 0, 0
34746, 3232, 3233, 3244, 3243, 0, 0, 0, 0
34747, 3233, 3234, 3245, 3244, 0, 0, 0, 0
34748, 3234, 3235, 3246, 3245, 0, 0, 0, 0
34749, 3235, 3236, 3247, 3246, 0, 0, 0, 0
34750, 3236, 292, 293, 3247, 0, 0, 0, 0
34751, 259, 3237, 3248, 260, 0, 0, 0, 0
34752, 3237, 3238, 3249, 3248, 0, 0, 0, 0
34753, 3238, 3239, 3250, 3249, 0, 0, 0, 0
34754, 3239, 3240, 3251, 3250, 0, 0, 0, 0
34755, 3240, 3241, 3252, 3251, 0, 0, 0, 0
34756, 3241, 3242, 3253, 3252, 0, 0, 0, 0
34757, 3242, 3243, 3254, 3253, 0, 0, 0, 0
34758, 3243, 3244, 3255, 3254, 0, 0, 0, 0
34759, 3244, 3245, 3256, 3255, 0, 0, 0, 0
34760, 3245, 3246, 3257, 3256, 0, 0, 0, 0
34761, 3246, 3247, 3258, 3257, 0, 0, 0, 0
34762, 3247, 293, 294, 3258, 0, 0, 0, 0
34763, 260, 3248, 3259, 261, 0, 0, 0, 0
34764, 3248, 3249, 3260, 3259, 0, 0, 0, 0
34765, 3249, 3250, 3261, 3260, 0, 0, 0, 0
34766, 3250, 3251, 3262, 3261, 0, 0, 0, 0
34767, 3251, 3252, 3263, 3262, 0, 0, 0, 0
34768, 3252, 3253, 3264, 3263, 0, 0, 0, 0
34769, 3253, 3254, 3265, 3264, 0, 0, 0, 0
34770, 3254, 3255, 3266, 3265, 0, 0, 0, 0
34771, 3255, 3256, 3267, 3266, 0, 0, 0, 0
34772, 3256, 3257, 3268, 3267, 0, 0, 0, 0
34773, 3257, 3258, 3269, 3268, 0, 0, 0, 0
34774, 3258, 294, 295, 3269, 0, 0, 0, 0
34775, 261, 3259, 3270, 262, 0, 0, 0, 0
34776, 3259, 3260, 3271, 3270, 0, 0, 0, 0
34777, 3260, 3261, 3272, 3271, 0, 0, 0, 0
34778, 3261, 3262, 3273, 3272, 0, 0, 0, 0
34779, 3262, 3263, 3274, 3273, 0, 0, 0, 0
34780, 3263, 3264, 3275, 3274, 0, 0, 0, 0
34781, 3264, 3265, 3276, 3275, 0, 0, 0, 0
34782, 3265, 3266, 3277, 3276, 0, 0, 0, 0
34783, 3266, 3267, 3278, 3277, 0, 0, 0, 0
34784, 3267, 3268, 3279, 3278, 0, 0, 0, 0
34785, 3268, 3269, 3280, 3279, 0, 0, 0, 0
34786, 3269, 295, 296, 3280, 0, 0, 0, 0
34787, 262, 3270, 3281, 263, 0, 0, 0, 0
34788, 3270, 3271, 3282, 3281, 0, 0, 0, 0
34789, 3271, 3272, 3283, 3282, 0, 0, 0, 0
34790, 3272, 3273, 3284, 3283, 0, 0, 0, 0
34791, 3273, 3274, 3285, 3284, 0, 0, 0, 0
34792, 3274, 3275, 3286, 3285, 0, 0, 0, 0
34793, 3275, 3276, 3287, 3286, 0, 0, 0, 0
34794, 3276, 3277, 3288, 3287, 0, 0, 0, 0
34795, 3277, 3278, 3289, 3288, 0, 0, 0, 0
34796, 3278, 3279, 3290, 3289, 0, 0, 0, 0
34797, 3279, 3280, 3291, 3290, 0, 0, 0, 0
34798, 3280, 296, 297, 3291, 0, 0, 0, 0
34799, 263, 3281, 3292, 264, 0, 0, 0, 0
34800, 3281, 3282, 3293, 3292, 0, 0, 0, 0
34801, 3282, 3283, 3294, 3293, 0, 0, 0, 0
34802, 3283, 3284, 3295, 3294, 0, 0, 0, 0
34803, 3284, 3285, 3296, 3295, 0, 0, 0, 0
34804, 3285, 3286, 3297, 3296, 0, 0, 0, 0
34805, 3286, 3287, 3298, 3297, 0, 0, 0, 0
34806, 3287, 3288, 3299, 3298, 0, 0, 0, 0
34807, 3288, 3289, 3300, 3299, 0, 0, 0, 0
34808, 3289, 3290, 3301, 3300, 0, 0, 0, 0
34809, 3290, 3291, 3302, 3301, 0, 0, 0, 0
34810, 3291, 297, 298, 3302, 0, 0, 0, 0
34811, 264, 3292, 265, 9, 0, 0, 0, 0
34812, 3292, 3293, 266, 265, 0, 0, 0, 0
34813, 3293, 3294, 267, 266, 0, 0, 0, 0
34814, 3294, 3295, 268, 267, 0, 0, 0, 0
34815, 3295, 3296, 269, 268, 0, 0, 0, 0
34816, 3296, 3297, 270, 269, 0, 0, 0, 0
34817, 3297, 3298, 271, 270, 0, 0, 0, 0
34818, 3298, 3299, 272, 271, 0, 0, 0, 0
34819, 3299, 3300, 273, 272, 0, 0, 0, 0
34820, 3300, 3301, 274, 273, 0, 0, 0, 0
34821, 3301, 3302, 275, 274, 0, 0, 0, 0
34822, 3302, 298, 11, 275, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface12
34823, 10, 333, 3303, 242, 0, 0, 0, 0
34824, 333, 334, 3304, 3303, 0, 0, 0, 0
34825, 334, 335, 3305, 3304, 0, 0, 0, 0
34826, 335, 336, 3306, 3305, 0, 0, 0, 0
34827, 336, 337, 3307, 3306, 0, 0, 0, 0
34828, 337, 338, 3308, 3307, 0, 0, 0, 0
34829, 338, 339, 3309, 3308, 0, 0, 0, 0
34830, 339, 340, 3310, 3309, 0, 0, 0, 0
34831, 340, 341, 3311, 3310, 0, 0, 0, 0
34832, 341, 342, 3312, 3311, 0, 0, 0, 0
34833, 342, 343, 3313, 3312, 0, 0, 0, 0
34834, 343, 344, 3314, 3313, 0, 0, 0, 0
34835, 344, 345, 3315, 3314, 0, 0, 0, 0
34836, 345, 346, 3316, 3315, 0, 0, 0, 0
34837, 346, 347, 3317, 3316, 0, 0, 0, 0
34838, 347, 348, 3318, 3317, 0, 0, 0, 0
34839, 348, 349, 3319, 3318, 0, 0, 0, 0
34840, 349, 350, 3320, 3319, 0, 0, 0, 0
34841, 350, 351, 3321, 3320, 0, 0, 0, 0
34842, 351, 352, 3322, 3321, 0, 0, 0, 0
34843, 352, 353, 3323, 3322, 0, 0, 0, 0
34844, 353, 354, 3324, 3323, 0, 0, 0, 0
34845, 354, 355, 3325, 3324, 0, 0, 0, 0
34846, 355, 14, 356, 3325, 0, 0, 0, 0
34847, 242, 3303, 3326, 243, 0, 0, 0, 0
34848, 3303, 3304, 3327, 3326, 0, 0, 0, 0
34849, 3304, 3305, 3328, 3327, 0, 0, 0, 0
34850, 3305, 3306, 3329, 3328, 0, 0, 0, 0
34851, 3306, 3307, 3330, 3329, 0, 0, 0, 0
34852, 3307, 3308, 3331, 3330, 0, 0, 0, 0
34853, 3308, 3309, 3332, 3331, 0, 0, 0, 0
34854, 3309, 3310, 3333, 3332, 0, 0, 0, 0
34855, 3310, 3311, 3334, 3333, 0, 0, 0, 0
34856, 3311, 3312, 3335, 3334, 0, 0, 0, 0
34857, 3312, 3313, 3336, 3335, 0, 0, 0, 0
34858, 3313, 3314, 3337, 3336, 0, 0, 0, 0
34859, 3314, 3315, 3338, 3337, 0, 0, 0, 0
34860, 3315, 3316, 3339, 3338, 0, 0, 0, 0
34861, 3316, 3317, 3340, 3339, 0, 0, 0, 0
34862, 3317, 3318, 3341, 3340, 0, 0, 0, 0
34863, 3318, 3319, 3342, 3341, 0, 0, 0, 0
34864, 3319, 3320, 3343, 3342, 0, 0, 0, 0
34865, 3320, 3321, 3344, 3343, 0, 0, 0, 0
34866, 3321, 3322, 3345, 3344, 0, 0, 0, 0
34867, 3322, 3323, 3346, 3345, 0, 0, 0, 0
34868, 3323, 3324, 3347, 3346, 0, 0, 0, 0
34869, 3324, 3325, 3348, 3347, 0, 0, 0, 0
34870, 3325, 356, 357, 3348, 0, 0, 0, 0
34871, 243, 3326, 3349, 244, 0, 0, 0, 0
34872, 3326, 3327, 3350, 3349, 0, 0, 0, 0
34873, 3327, 3328, 3351, 3350, 0, 0, 0, 0
34874, 3328, 3329, 3352, 3351, 0, 0, 0, 0
34875, 3329, 3330, 3353, 3352, 0, 0, 0, 0
34876, 3330, 3331, 3354, 3353, 0, 0, 0, 0
34877, 3331, 3332, 3355, 3354, 0, 0, 0, 0
34878, 3332, 3333, 3356, 3355, 0, 0, 0, 0
34879, 3333, 3334, 3357, 3356, 0, 0, 0, 0
34880, 3334, 3335, 3358, 3357, 0, 0, 0, 0
34881, 3335, 3336, 3359, 3358, 0, 0, 0, 0
34882, 3336, 3337, 3360, 3359, 0, 0, 0, 0
34883, 3337, 3338, 3361, 3360, 0, 0, 0, 0
34884, 3338, 3339, 3362, 3361, 0, 0, 0, 0
34885, 3339, 3340, 3363, 3362, 0, 0, 0, 0
34886, 3340, 3341, 3364, 3363, 0, 0, 0, 0
34887, 3341, 3342, 3365, 3364, 0, 0, 0, 0
34888, 3342, 3343, 3366, 3365, 0, 0, 0, 0
34889, 3343, 3344, 3367, 3366, 0, 0, 0, 0
34890, 3344, 3345, 3368, 3367, 0, 0, 0, 0
34891, 3345, 3346, 3369, 3368, 0, 0, 0, 0
34892, 3346, 3347, 3370, 3369, 0, 0, 0, 0
34893, 3347, 3348, 3371, 3370, 0, 0, 0, 0
34894, 3348, 357, 358, 3371, 0, 0, 0, 0
34895, 244, 3349, 3372, 245, 0, 0, 0, 0
34896, 3349, 3350, 3373, 3372, 0, 0, 0, 0
34897, 3350, 3351, 3374, 3373, 0, 0, 0, 0
34898, 3351, 3352, 3375, 3374, 0, 0, 0, 0
34899, 3352, 3353, 3376, 3375, 0, 0, 0, 0
34900, 3353, 3354, 3377, 3376, 0, 0, 0, 0
34901, 3354, 3355, 3378, 3377, 0, 0, 0, 0
34902, 3355, 3356, 3379, 3378, 0, 0, 0, 0
34903, 3356, 3357, 3380, 3379, 0, 0, 0, 0
34904, 3357, 3358, 3381, 3380, 0, 0, 0, 0
34905, 3358, 3359, 3382, 3381, 0, 0, 0, 0
34906, 3359, 3360, 3383, 3382, 0, 0, 0, 0
34907, 3360, 3361, 3384, 3383, 0, 0, 0, 0
34908, 3361, 3362, 3385, 3384, 0, 0, 0, 0
34909, 3362, 3363, 3386, 3385, 0, 0, 0, 0
34910, 3363, 3364, 3387, 3386, 0, 0, 0, 0
34911, 3364, 3365, 3388, 3387, 0, 0, 0, 0
34912, 3365, 3366, 3389, 3388, 0, 0, 0, 0
34913, 3366, 3367, 3390, 3389, 0, 0, 0, 0
34914, 3367, 3368, 3391, 3390, 0, 0, 0, 0
34915, 3368, 3369, 3392, 3391, 0, 0, 0, 0
34916, 3369, 3370, 3393, 3392, 0, 0, 0, 0
34917, 3370, 3371, 3394, 3393, 0, 0, 0, 0
34918, 3371, 358, 359, 3394, 0, 0, 0, 0
34919, 245, 3372, 3395, 246, 0, 0, 0, 0
34920, 3372, 3373, 3396, 3395, 0, 0, 0, 0
34921, 3373, 3374, 3397, 3396, 0, 0, 0, 0
34922, 3374, 3375, 3398, 3397, 0, 0, 0, 0
34923, 3375, 3376, 3399, 3398, 0, 0, 0, 0
34924, 3376, 3377, 3400, 3399, 0, 0, 0, 0
34925, 3377, 3378, 3401, 3400, 0, 0, 0, 0
34926, 3378, 3379, 3402, 3401, 0, 0, 0, 0
34927, 3379, 3380, 3403, 3402, 0, 0, 0, 0
34928, 3380, 3381, 3404, 3403, 0, 0, 0, 0
34929, 3381, 3382, 3405, 3404, 0, 0, 0, 0
34930, 3382, 3383, 3406, 3405, 0, 0, 0, 0
34931, 3383, 3384, 3407, 3406, 0, 0, 0, 0
34932, 3384, 3385, 3408, 3407, 0, 0, 0, 0
34933, 3385, 3386, 3409, 3408, 0, 0, 0, 0
34934, 3386, 3387, 3410, 3409, 0, 0, 0, 0
34935, 3387, 3388, 3411, 3410, 0, 0, 0, 0
34936, 3388, 3389, 3412, 3411, 0, 0, 0, 0
34937, 3389, 3390, 3413, 3412, 0, 0, 0, 0
34938, 3390, 3391, 3414, 3413, 0, 0, 0, 0
34939, 3391, 3392, 3415, 3414, 0, 0, 0, 0
34940, 3392, 3393, 3416, 3415, 0, 0, 0, 0
34941, 3393, 3394, 3417, 3416, 0, 0, 0, 0
34942, 3394, 359, 360, 3417, 0, 0, 0, 0
34943, 246, 3395, 3418, 247, 0, 0, 0, 0
34944, 3395, 3396, 3419, 3418, 0, 0, 0, 0
34945, 3396, 3397, 3420, 3419, 0, 0, 0, 0
34946, 3397, 3398, 3421, 3420, 0, 0, 0, 0
34947, 3398, 3399, 3422, 3421, 0, 0, 0, 0
34948, 3399, 3400, 3423, 3422, 0, 0, 0, 0
34949, 3400, 3401, 3424, 3423, 0, 0, 0, 0
34950, 3401, 3402, 3425, 3424, 0, 0, 0, 0
34951, 3402, 3403, 3426, 3425, 0, 0, 0, 0
34952, 3403, 3404, 3427, 3426, 0, 0, 0, 0
34953, 3404, 3405, 3428, 3427, 0, 0, 0, 0
34954, 3405, 3406, 3429, 3428, 0, 0, 0, 0
34955, 3406, 3407, 3430, 3429, 0, 0, 0, 0
34956, 3407, 3408, 3431, 3430, 0, 0, 0, 0
34957, 3408, 3409, 3432, 3431, 0, 0, 0, 0
34958, 3409, 3410, 3433, 3432, 0, 0, 0, 0
34959, 3410, 3411, 3434, 3433, 0, 0, 0, 0
34960, 3411, 3412, 3435, 3434, 0, 0, 0, 0
34961, 3412, 3413, 3436, 3435, 0, 0, 0, 0
34962, 3413, 3414, 3437, 3436, 0, 0, 0, 0
34963, 3414, 3415, 3438, 3437, 0, 0, 0, 0
34964, 3415, 3416, 3439, 3438, 0, 0, 0, 0
34965, 3416, 3417, 3440, 3439, 0, 0, 0, 0
34966, 3417, 360, 361, 3440, 0, 0, 0, 0
34967, 247, 3418, 3441, 248, 0, 0, 0, 0
34968, 3418, 3419, 3442, 3441, 0, 0, 0, 0
34969, 3419, 3420, 3443, 3442, 0, 0, 0, 0
34970, 3420, 3421, 3444, 3443, 0, 0, 0, 0
34971, 3421, 3422, 3445, 3444, 0, 0, 0, 0
34972, 3422, 3423, 3446, 3445, 0, 0, 0, 0
34973, 3423, 3424, 3447, 3446, 0, 0, 0, 0
34974, 3424, 3425, 3448, 3447, 0, 0, 0, 0
34975, 3425, 3426, 3449, 3448, 0, 0, 0, 0
34976, 3426, 3427, 3450, 3449, 0, 0, 0, 0
34977, 3427, 3428, 3451, 3450, 0, 0, 0, 0
34978, 3428, 3429, 3452, 3451, 0, 0, 0, 0
34979, 3429, 3430, 3453, 3452, 0, 0, 0, 0
34980, 3430, 3431, 3454, 3453, 0, 0, 0, 0
34981, 3431, 3432, 3455, 3454, 0, 0, 0, 0
34982, 3432, 3433, 3456, 3455, 0, 0, 0, 0
34983, 3433, 3434, 3457, 3456, 0, 0, 0, 0
34984, 3434, 3435, 3458, 3457, 0, 0, 0, 0
34985, 3435, 3436, 3459, 3458, 0, 0, 0, 0
34986, 3436, 3437, 3460, 3459, 0, 0, 0, 0
34987, 3437, 3438, 3461, 3460, 0, 0, 0, 0
34988, 3438, 3439, 3462, 3461, 0, 0, 0, 0
34989, 3439, 3440, 3463, 3462, 0, 0, 0, 0
34990, 3440, 361, 362, 3463, 0, 0, 0, 0
34991, 248, 3441, 3464, 249, 0, 0, 0, 0
34992, 3441, 3442, 3465, 3464, 0, 0, 0, 0
34993, 3442, 3443, 3466, 3465, 0, 0, 0, 0
34994, 3443, 3444, 3467, 3466, 0, 0, 0, 0
34995, 3444, 3445, 3468, 3467, 0, 0, 0, 0
34996, 3445, 3446, 3469, 3468, 0, 0, 0, 0
34997, 3446, 3447, 3470, 3469, 0, 0, 0, 0
34998, 3447, 3448, 3471, 3470, 0, 0, 0, 0
34999, 3448, 3449, 3472, 3471, 0, 0, 0, 0
35000, 3449, 3450, 3473, 3472, 0, 0, 0, 0
35001, 3450, 3451, 3474, 3473, 0, 0, 0, 0
35002, 3451, 3452, 3475, 3474, 0, 0, 0, 0
35003, 3452, 3453, 3476, 3475, 0, 0, 0, 0
35004, 3453, 3454, 3477, 3476, 0, 0, 0, 0
35005, 3454, 3455, 3478, 3477, 0, 0, 0, 0
35006, 3455, 3456, 3479, 3478, 0, 0, 0, 0
35007, 3456, 3457, 3480, 3479, 0, 0, 0, 0
35008, 3457, 3458, 3481, 3480, 0, 0, 0, 0
35009, 3458, 3459, 3482, 3481, 0, 0, 0, 0
35010, 3459, 3460, 3483, 3482, 0, 0, 0, 0
35011, 3460, 3461, 3484, 3483, 0, 0, 0, 0
35012, 3461, 3462, 3485, 3484, 0, 0, 0, 0
35013, 3462, 3463, 3486, 3485, 0, 0, 0, 0
35014, 3463, 362, 363, 3486, 0, 0, 0, 0
35015, 249, 3464, 3487, 250, 0, 0, 0, 0
35016, 3464, 3465, 3488, 3487, 0, 0, 0, 0
35017, 3465, 3466, 3489, 3488, 0, 0, 0, 0
35018, 3466, 3467, 3490, 3489, 0, 0, 0, 0
35019, 3467, 3468, 3491, 3490, 0, 0, 0, 0
35020, 3468, 3469, 3492, 3491, 0, 0, 0, 0
35021, 3469, 3470, 3493, 3492, 0, 0, 0, 0
35022, 3470, 3471, 3494, 3493, 0, 0, 0, 0
35023, 3471, 3472, 3495, 3494, 0, 0, 0, 0
35024, 3472, 3473, 3496, 3495, 0, 0, 0, 0
35025, 3473, 3474, 3497, 3496, 0, 0, 0, 0
35026, 3474, 3475, 3498, 3497, 0, 0, 0, 0
35027, 3475, 3476, 3499, 3498, 0, 0, 0, 0
35028, 3476, 3477, 3500, 3499, 0, 0, 0, 0
35029, 3477, 3478, 3501, 3500, 0, 0, 0, 0
35030, 3478, 3479, 3502, 3501, 0, 0, 0, 0
35031, 3479, 3480, 3503, 3502, 0, 0, 0, 0
35032, 3480, 3481, 3504, 3503, 0, 0, 0, 0
35033, 3481, 3482, 3505, 3504, 0, 0, 0, 0
35034, 3482, 3483, 3506, 3505, 0, 0, 0, 0
35035, 3483, 3484, 3507, 3506, 0, 0, 0, 0
35036, 3484, 3485, 3508, 3507, 0, 0, 0, 0
35037, 3485, 3486, 3509, 3508, 0, 0, 0, 0
35038, 3486, 363, 364, 3509, 0, 0, 0, 0
35039, 250, 3487, 3510, 251, 0, 0, 0, 0
35040, 3487, 3488, 3511, 3510, 0, 0, 0, 0
35041, 3488, 3489, 3512, 3511, 0, 0, 0, 0
35042, 3489, 3490, 3513, 3512, 0, 0, 0, 0
35043, 3490, 3491, 3514, 3513, 0, 0, 0, 0
35044, 3491, 3492, 3515, 3514, 0, 0, 0, 0
35045, 3492, 3493, 3516, 3515, 0, 0, 0, 0
35046, 3493, 3494, 3517, 3516, 0, 0, 0, 0
35047, 3494, 3495, 3518, 3517, 0, 0, 0, 0
35048, 3495, 3496, 3519, 3518, 0, 0, 0, 0
35049, 3496, 3497, 3520, 3519, 0, 0, 0, 0
35050, 3497, 3498, 3521, 3520, 0, 0, 0, 0
35051, 3498, 3499, 3522, 3521, 0, 0, 0, 0
35052, 3499, 3500, 3523, 3522, 0, 0, 0, 0
35053, 3500, 3501, 3524, 3523, 0, 0, 0, 0
35054, 3501, 3502, 3525, 3524, 0, 0, 0, 0
35055, 3502, 3503, 3526, 3525, 0, 0, 0, 0
35056, 3503, 3504, 3527, 3526, 0, 0, 0, 0
35057, 3504, 3505, 3528, 3527, 0, 0, 0, 0
35058, 3505, 3506, 3529, 3528, 0, 0, 0, 0
35059, 3506, 3507, 3530, 3529, 0, 0, 0, 0
35060, 3507, 3508, 3531, 3530, 0, 0, 0, 0
35061, 3508, 3509, 3532, 3531, 0, 0, 0, 0
35062, 3509, 364, 365, 3532, 0, 0, 0, 0
35063, 251, 3510, 3533, 252, 0, 0, 0, 0
35064, 3510, 3511, 3534, 3533, 0, 0, 0, 0
35065, 3511, 3512, 3535, 3534, 0, 0, 0, 0
35066, 3512, 3513, 3536, 3535, 0, 0, 0, 0
35067, 3513, 3514, 3537, 3536, 0, 0, 0, 0
35068, 3514, 3515, 3538, 3537, 0, 0, 0, 0
35069, 3515, 3516, 3539, 3538, 0, 0, 0, 0
35070, 3516, 3517, 3540, 3539, 0, 0, 0, 0
35071, 3517, 3518, 3541, 3540, 0, 0, 0, 0
35072, 3518, 3519, 3542, 3541, 0, 0, 0, 0
35073, 3519, 3520, 3543, 3542, 0, 0, 0, 0
35074, 3520, 3521, 3544, 3543, 0, 0, 0, 0
35075, 3521, 3522, 3545, 3544, 0, 0, 0, 0
35076, 3522, 3523, 3546, 3545, 0, 0, 0, 0
35077, 3523, 3524, 3547, 3546, 0, 0, 0, 0
35078, 3524, 3525, 3548, 3547, 0, 0, 0, 0
35079, 3525, 3526, 3549, 3548, 0, 0, 0, 0
35080, 3526, 3527, 3550, 3549, 0, 0, 0, 0
35081, 3527, 3528, 3551, 3550, 0, 0, 0, 0
35082, 3528, 3529, 3552, 3551, 0, 0, 0, 0
35083, 3529, 3530, 3553, 3552, 0, 0, 0, 0
35084, 3530, 3531, 3554, 3553, 0, 0, 0, 0
35085, 3531, 3532, 3555, 3554, 0, 0, 0, 0
35086, 3532, 365, 366, 3555, 0, 0, 0, 0
35087, 252, 3533, 3556, 253, 0, 0, 0, 0
35088, 3533, 3534, 3557, 3556, 0, 0, 0, 0
35089, 3534, 3535, 3558, 3557, 0, 0, 0, 0
35090, 3535, 3536, 3559, 3558, 0, 0, 0, 0
35091, 3536, 3537, 3560, 3559, 0, 0, 0, 0
35092, 3537, 3538, 3561, 3560, 0, 0, 0, 0
35093, 3538, 3539, 3562, 3561, 0, 0, 0, 0
35094, 3539, 3540, 3563, 3562, 0, 0, 0, 0
35095, 3540, 3541, 3564, 3563, 0, 0, 0, 0
35096, 3541, 3542, 3565, 3564, 0, 0, 0, 0
35097, 3542, 3543, 3566, 3565, 0, 0, 0, 0
35098, 3543, 3544, 3567, 3566, 0, 0, 0, 0
35099, 3544, 3545, 3568, 3567, 0, 0, 0, 0
35100, 3545, 3546, 3569, 3568, 0, 0, 0, 0
35101, 3546, 3547, 3570, 3569, 0, 0, 0, 0
35102, 3547, 3548, 3571, 3570, 0, 0, 0, 0
35103, 3548, 3549, 3572, 3571, 0, 0, 0, 0
35104, 3549, 3550, 3573, 3572, 0, 0, 0, 0
35105, 3550, 3551, 3574, 3573, 0, 0, 0, 0
35106, 3551, 3552, 3575, 3574, 0, 0, 0, 0
35107, 3552, 3553, 3576, 3575, 0, 0, 0, 0
35108, 3553, 3554, 3577, 3576, 0, 0, 0, 0
35109, 3554, 3555, 3578, 3577, 0, 0, 0, 0
35110, 3555, 366, 367, 3578, 0, 0, 0, 0
35111, 253, 3556, 3579, 254, 0, 0, 0, 0
35112, 3556, 3557, 3580, 3579, 0, 0, 0, 0
35113, 3557, 3558, 3581, 3580, 0, 0, 0, 0
35114, 3558, 3559, 3582, 3581, 0, 0, 0, 0
35115, 3559, 3560, 3583, 3582, 0, 0, 0, 0
35116, 3560, 3561, 3584, 3583, 0, 0, 0, 0
35117, 3561, 3562, 3585, 3584, 0, 0, 0, 0
35118, 3562, 3563, 3586, 3585, 0, 0, 0, 0
35119, 3563, 3564, 3587, 3586, 0, 0, 0, 0
35120, 3564, 3565, 3588, 3587, 0, 0, 0, 0
35121, 3565, 3566, 3589, 3588, 0, 0, 0, 0
35122, 3566, 3567, 3590, 3589, 0, 0, 0, 0
35123, 3567, 3568, 3591, 3590, 0, 0, 0, 0
35124, 3568, 3569, 3592, 3591, 0, 0, 0, 0
35125, 3569, 3570, 3593, 3592, 0, 0, 0, 0
35126, 3570, 3571, 3594, 3593, 0, 0, 0, 0
35127, 3571, 3572, 3595, 3594, 0, 0, 0, 0
35128, 3572, 3573, 3596, 3595, 0, 0, 0, 0
35129, 3573, 3574, 3597, 3596, 0, 0, 0, 0
35130, 3574, 3575, 3598, 3597, 0, 0, 0, 0
35131, 3575, 3576, 3599, 3598, 0, 0, 0, 0
35132, 3576, 3577, 3600, 3599, 0, 0, 0, 0
35133, 3577, 3578, 3601, 3600, 0, 0, 0, 0
35134, 3578, 367, 368, 3601, 0, 0, 0, 0
35135, 254, 3579, 3602, 255, 0, 0, 0, 0
35136, 3579, 3580, 3603, 3602, 0, 0, 0, 0
35137, 3580, 3581, 3604, 3603, 0, 0, 0, 0
35138, 3581, 3582, 3605, 3604, 0, 0, 0, 0
35139, 3582, 3583, 3606, 3605, 0, 0, 0, 0
35140, 3583, 3584, 3607, 3606, 0, 0, 0, 0
35141, 3584, 3585, 3608, 3607, 0, 0, 0, 0
35142, 3585, 3586, 3609, 3608, 0, 0, 0, 0
35143, 3586, 3587, 3610, 3609, 0, 0, 0, 0
35144, 3587, 3588, 3611, 3610, 0, 0, 0, 0
35145, 3588, 3589, 3612, 3611, 0, 0, 0, 0
35146, 3589, 3590, 3613, 3612, 0, 0, 0, 0
35147, 3590, 3591, 3614, 3613, 0, 0, 0, 0
35148, 3591, 3592, 3615, 3614, 0, 0, 0, 0
35149, 3592, 3593, 3616, 3615, 0, 0, 0, 0
35150, 3593, 3594, 3617, 3616, 0, 0, 0, 0
35151, 3594, 3595, 3618, 3617, 0, 0, 0, 0
35152, 3595, 3596, 3619, 3618, 0, 0, 0, 0
35153, 3596, 3597, 3620, 3619, 0, 0, 0, 0
35154, 3597, 3598, 3621, 3620, 0, 0, 0, 0
35155, 3598, 3599, 3622, 3621, 0, 0, 0, 0
35156, 3599, 3600, 3623, 3622, 0, 0, 0, 0
35157, 3600, 3601, 3624, 3623, 0, 0, 0, 0
35158, 3601, 368, 369, 3624, 0, 0, 0, 0
35159, 255, 3602, 3625, 256, 0, 0, 0, 0
35160, 3602, 3603, 3626, 3625, 0, 0, 0, 0
35161, 3603, 3604, 3627, 3626, 0, 0, 0, 0
35162, 3604, 3605, 3628, 3627, 0, 0, 0, 0
35163, 3605, 3606, 3629, 3628, 0, 0, 0, 0
35164, 3606, 3607, 3630, 3629, 0, 0, 0, 0
35165, 3607, 3608, 3631, 3630, 0, 0, 0, 0
35166, 3608, 3609, 3632, 3631, 0, 0, 0, 0
35167, 3609, 3610, 3633, 3632, 0, 0, 0, 0
35168, 3610, 3611, 3634, 3633, 0, 0, 0, 0
35169, 3611, 3612, 3635, 3634, 0, 0, 0, 0
35170, 3612, 3613, 3636, 3635, 0, 0, 0, 0
35171, 3613, 3614, 3637, 3636, 0, 0, 0, 0
35172, 3614, 3615, 3638, 3637, 0, 0, 0, 0
35173, 3615, 3616, 3639, 3638, 0, 0, 0, 0
35174, 3616, 3617, 3640, 3639, 0, 0, 0, 0
35175, 3617, 3618, 3641, 3640, 0, 0, 0, 0
35176, 3618, 3619, 3642, 3641, 0, 0, 0, 0
35177, 3619, 3620, 3643, 3642, 0, 0, 0, 0
35178, 3620, 3621, 3644, 3643, 0, 0, 0, 0
35179, 3621, 3622, 3645, 3644, 0, 0, 0, 0
35180, 3622, 3623, 3646, 3645, 0, 0, 0, 0
35181, 3623, 3624, 3647, 3646, 0, 0, 0, 0
35182, 3624, 369, 370, 3647, 0, 0, 0, 0
35183, 256, 3625, 3648, 257, 0, 0, 0, 0
35184, 3625, 3626, 3649, 3648, 0, 0, 0, 0
35185, 3626, 3627, 3650, 3649, 0, 0, 0, 0
35186, 3627, 3628, 3651, 3650, 0, 0, 0, 0
35187, 3628, 3629, 3652, 3651, 0, 0, 0, 0
35188, 3629, 3630, 3653, 3652, 0, 0, 0, 0
35189, 3630, 3631, 3654, 3653, 0, 0, 0, 0
35190, 3631, 3632, 3655, 3654, 0, 0, 0, 0
35191, 3632, 3633, 3656, 3655, 0, 0, 0, 0
35192, 3633, 3634, 3657, 3656, 0, 0, 0, 0
35193, 3634, 3635, 3658, 3657, 0, 0, 0, 0
35194, 3635, 3636, 3659, 3658, 0, 0, 0, 0
35195, 3636, 3637, 3660, 3659, 0, 0, 0, 0
35196, 3637, 3638, 3661, 3660, 0, 0, 0, 0
35197, 3638, 3639, 3662, 3661, 0, 0, 0, 0
35198, 3639, 3640, 3663, 3662, 0, 0, 0, 0
35199, 3640, 3641, 3664, 3663, 0, 0, 0, 0
35200, 3641, 3642, 3665, 3664, 0, 0, 0, 0
35201, 3642, 3643, 3666, 3665, 0, 0, 0, 0
35202, 3643, 3644, 3667, 3666, 0, 0, 0, 0
35203, 3644, 3645, 3668, 3667, 0, 0, 0, 0
35204, 3645, 3646, 3669, 3668, 0, 0, 0, 0
35205, 3646, 3647, 3670, 3669, 0, 0, 0, 0
35206, 3647, 370, 371, 3670, 0, 0, 0, 0
35207, 257, 3648, 3671, 258, 0, 0, 0, 0
35208, 3648, 3649, 3672, 3671, 0, 0, 0, 0
35209, 3649, 3650, 3673, 3672, 0, 0, 0, 0
35210, 3650, 3651, 3674, 3673, 0, 0, 0, 0
35211, 3651, 3652, 3675, 3674, 0, 0, 0, 0
35212, 3652, 3653, 3676, 3675, 0, 0, 0, 0
35213, 3653, 3654, 3677, 3676, 0, 0, 0, 0
35214, 3654, 3655, 3678, 3677, 0, 0, 0, 0
35215, 3655, 3656, 3679, 3678, 0, 0, 0, 0
35216, 3656, 3657, 3680, 3679, 0, 0, 0, 0
35217, 3657, 3658, 3681, 3680, 0, 0, 0, 0
35218, 3658, 3659, 3682, 3681, 0, 0, 0, 0
35219, 3659, 3660, 3683, 3682, 0, 0, 0, 0
35220, 3660, 3661, 3684, 3683, 0, 0, 0, 0
35221, 3661, 3662, 3685, 3684, 0, 0, 0, 0
35222, 3662, 3663, 3686, 3685, 0, 0, 0, 0
35223, 3663, 3664, 3687, 3686, 0, 0, 0, 0
35224, 3664, 3665, 3688, 3687, 0, 0, 0, 0
35225, 3665, 3666, 3689, 3688, 0, 0, 0, 0
35226, 3666, 3667, 3690, 3689, 0, 0, 0, 0
35227, 3667, 3668, 3691, 3690, 0, 0, 0, 0
35228, 3668, 3669, 3692, 3691, 0, 0, 0, 0
35229, 3669, 3670, 3693, 3692, 0, 0, 0, 0
35230, 3670, 371, 372, 3693, 0, 0, 0, 0
35231, 258, 3671, 3694, 259, 0, 0, 0, 0
35232, 3671, 3672, 3695, 3694, 0, 0, 0, 0
35233, 3672, 3673, 3696, 3695, 0, 0, 0, 0
35234, 3673, 3674, 3697, 3696, 0, 0, 0, 0
35235, 3674, 3675, 3698, 3697, 0, 0, 0, 0
35236, 3675, 3676, 3699, 3698, 0, 0, 0, 0
35237, 3676, 3677, 3700, 3699, 0, 0, 0, 0
35238, 3677, 3678, 3701, 3700, 0, 0, 0, 0
35239, 3678, 3679, 3702, 3701, 0, 0, 0, 0
35240, 3679, 3680, 3703, 3702, 0, 0, 0, 0
35241, 3680, 3681, 3704, 3703, 0, 0, 0, 0
35242, 3681, 3682, 3705, 3704, 0, 0, 0, 0
35243, 3682, 3683, 3706, 3705, 0, 0, 0, 0
35244, 3683, 3684, 3707, 3706, 0, 0, 0, 0
35245, 3684, 3685, 3708, 3707, 0, 0, 0, 0
35246, 3685, 3686, 3709, 3708, 0, 0, 0, 0
35247, 3686, 3687, 3710, 3709, 0, 0, 0, 0
35248, 3687, 3688, 3711, 3710, 0, 0, 0, 0
35249, 3688, 3689, 3712, 3711, 0, 0, 0, 0
35250, 3689, 3690, 3713, 3712, 0, 0, 0, 0
35251, 3690, 3691, 3714, 3713, 0, 0, 0, 0
35252, 3691, 3692, 3715, 3714, 0, 0, 0, 0
35253, 3692, 3693, 3716, 3715, 0, 0, 0, 0
35254, 3693, 372, 373, 3716, 0, 0, 0, 0
35255, 259, 3694, 3717, 260, 0, 0, 0, 0
35256, 3694, 3695, 3718, 3717, 0, 0, 0, 0
35257, 3695, 3696, 3719, 3718, 0, 0, 0, 0
35258, 3696, 3697, 3720, 3719, 0, 0, 0, 0
35259, 3697, 3698, 3721, 3720, 0, 0, 0, 0
35260, 3698, 3699, 3722, 3721, 0, 0, 0, 0
35261, 3699, 3700, 3723, 3722, 0, 0, 0, 0
35262, 3700, 3701, 3724, 3723, 0, 0, 0, 0
35263, 3701, 3702, 3725, 3724, 0, 0, 0, 0
35264, 3702, 3703, 3726, 3725, 0, 0, 0, 0
35265, 3703, 3704, 3727, 3726, 0, 0, 0, 0
35266, 3704, 3705, 3728, 3727, 0, 0, 0, 0
35267, 3705, 3706, 3729, 3728, 0, 0, 0, 0
35268, 3706, 3707, 3730, 3729, 0, 0, 0, 0
35269, 3707, 3708, 3731, 3730, 0, 0, 0, 0
35270, 3708, 3709, 3732, 3731, 0, 0, 0, 0
35271, 3709, 3710, 3733, 3732, 0, 0, 0, 0
35272, 3710, 3711, 3734, 3733, 0, 0, 0, 0
35273, 3711, 3712, 3735, 3734, 0, 0, 0, 0
35274, 3712, 3713, 3736, 3735, 0, 0, 0, 0
35275, 3713, 3714, 3737, 3736, 0, 0, 0, 0
35276, 3714, 3715, 3738, 3737, 0, 0, 0, 0
35277, 3715, 3716, 3739, 3738, 0, 0, 0, 0
35278, 3716, 373, 374, 3739, 0, 0, 0, 0
35279, 260, 3717, 3740, 261, 0, 0, 0, 0
35280, 3717, 3718, 3741, 3740, 0, 0, 0, 0
35281, 3718, 3719, 3742, 3741, 0, 0, 0, 0
35282, 3719, 3720, 3743, 3742, 0, 0, 0, 0
35283, 3720, 3721, 3744, 3743, 0, 0, 0, 0
35284, 3721, 3722, 3745, 3744, 0, 0, 0, 0
35285, 3722, 3723, 3746, 3745, 0, 0, 0, 0
35286, 3723, 3724, 3747, 3746, 0, 0, 0, 0
35287, 3724, 3725, 3748, 3747, 0, 0, 0, 0
35288, 3725, 3726, 3749, 3748, 0, 0, 0, 0
35289, 3726, 3727, 3750, 3749, 0, 0, 0, 0
35290, 3727, 3728, 3751, 3750, 0, 0, 0, 0
35291, 3728, 3729, 3752, 3751, 0, 0, 0, 0
35292, 3729, 3730, 3753, 3752, 0, 0, 0, 0
35293, 3730, 3731, 3754, 3753, 0, 0, 0, 0
35294, 3731, 3732, 3755, 3754, 0, 0, 0, 0
35295, 3732, 3733, 3756, 3755, 0, 0, 0, 0
35296, 3733, 3734, 3757, 3756, 0, 0, 0, 0
35297, 3734, 3735, 3758, 3757, 0, 0, 0, 0
35298, 3735, 3736, 3759, 3758, 0, 0, 0, 0
35299, 3736, 3737, 3760, 3759, 0, 0, 0, 0
35300, 3737, 3738, 3761, 3760, 0, 0, 0, 0
35301, 3738, 3739, 3762, 3761, 0, 0, 0, 0
35302, 3739, 374, 375, 3762, 0, 0, 0, 0
35303, 261, 3740, 3763, 262, 0, 0, 0, 0
35304, 3740, 3741, 3764, 3763, 0, 0, 0, 0
35305, 3741, 3742, 3765, 3764, 0, 0, 0, 0
35306, 3742, 3743, 3766, 3765, 0, 0, 0, 0
35307, 3743, 3744, 3767, 3766, 0, 0, 0, 0
35308, 3744, 3745, 3768, 3767, 0, 0, 0, 0
35309, 3745, 3746, 3769, 3768, 0, 0, 0, 0
35310, 3746, 3747, 3770, 3769, 0, 0, 0, 0
35311, 3747, 3748, 3771, 3770, 0, 0, 0, 0
35312, 3748, 3749, 3772, 3771, 0, 0, 0, 0
35313, 3749, 3750, 3773, 3772, 0, 0, 0, 0
35314, 3750, 3751, 3774, 3773, 0, 0, 0, 0
35315, 3751, 3752, 3775, 3774, 0, 0, 0, 0
35316, 3752, 3753, 3776, 3775, 0, 0, 0, 0
35317, 3753, 3754, 3777, 3776, 0, 0, 0, 0
35318, 3754, 3755, 3778, 3777, 0, 0, 0, 0
35319, 3755, 3756, 3779, 3778, 0, 0, 0, 0
35320, 3756, 3757, 3780, 3779, 0, 0, 0, 0
35321, 3757, 3758, 3781, 3780, 0, 0, 0, 0
35322, 3758, 3759, 3782, 3781, 0, 0, 0, 0
35323, 3759, 3760, 3783, 3782, 0, 0, 0, 0
35324, 3760, 3761, 3784, 3783, 0, 0, 0, 0
35325, 3761, 3762, 3785, 3784, 0, 0, 0, 0
35326, 3762, 375, 376, 3785, 0, 0, 0, 0
35327, 262, 3763, 3786, 263, 0, 0, 0, 0
35328, 3763, 3764, 3787, 3786, 0, 0, 0, 0
35329, 3764, 3765, 3788, 3787, 0, 0, 0, 0
35330, 3765, 3766, 3789, 3788, 0, 0, 0, 0
35331, 3766, 3767, 3790, 3789, 0, 0, 0, 0
35332, 3767, 3768, 3791, 3790, 0, 0, 0, 0
35333, 3768, 3769, 3792, 3791, 0, 0, 0, 0
35334, 3769, 3770, 3793, 3792, 0, 0, 0, 0
35335, 3770, 3771, 3794, 3793, 0, 0, 0, 0
35336, 3771, 3772, 3795, 3794, 0, 0, 0, 0
35337, 3772, 3773, 3796, 3795, 0, 0, 0, 0
35338, 3773, 3774, 3797, 3796, 0, 0, 0, 0
35339, 3774, 3775, 3798, 3797, 0, 0, 0, 0
35340, 3775, 3776, 3799, 3798, 0, 0, 0, 0
35341, 3776, 3777, 3800, 3799, 0, 0, 0, 0
35342, 3777, 3778, 3801, 3800, 0, 0, 0, 0
35343, 3778, 3779, 3802, 3801, 0, 0, 0, 0
35344, 3779, 3780, 3803, 3802, 0, 0, 0, 0
35345, 3780, 3781, 3804, 3803, 0, 0, 0, 0
35346, 3781, 3782, 3805, 3804, 0, 0, 0, 0
35347, 3782, 3783, 3806, 3805, 0, 0, 0, 0
35348, 3783, 3784, 3807, 3806, 0, 0, 0, 0
35349, 3784, 3785, 3808, 3807, 0, 0, 0, 0
35350, 3785, 376, 377, 3808, 0, 0, 0, 0
35351, 263, 3786, 3809, 264, 0, 0, 0, 0
35352, 3786, 3787, 3810, 3809, 0, 0, 0, 0
35353, 3787, 3788, 3811, 3810, 0, 0, 0, 0
35354, 3788, 3789, 3812, 3811, 0, 0, 0, 0
35355, 3789, 3790, 3813, 3812, 0, 0, 0, 0
35356, 3790, 3791, 3814, 3813, 0, 0, 0, 0
35357, 3791, 3792, 3815, 3814, 0, 0, 0, 0
35358, 3792, 3793, 3816, 3815, 0, 0, 0, 0
35359, 3793, 3794, 3817, 3816, 0, 0, 0, 0
35360, 3794, 3795, 3818, 3817, 0, 0, 0, 0
35361, 3795, 3796, 3819, 3818, 0, 0, 0, 0
35362, 3796, 3797, 3820, 3819, 0, 0, 0, 0
35363, 3797, 3798, 3821, 3820, 0, 0, 0, 0
35364, 3798, 3799, 3822, 3821, 0, 0, 0, 0
35365, 3799, 3800, 3823, 3822, 0, 0, 0, 0
35366, 3800, 3801, 3824, 3823, 0, 0, 0, 0
35367, 3801, 3802, 3825, 3824, 0, 0, 0, 0
35368, 3802, 3803, 3826, 3825, 0, 0, 0, 0
35369, 3803, 3804, 3827, 3826, 0, 0, 0, 0
35370, 3804, 3805, 3828, 3827, 0, 0, 0, 0
35371, 3805, 3806, 3829, 3828, 0, 0, 0, 0
35372, 3806, 3807, 3830, 3829, 0, 0, 0, 0
35373, 3807, 3808, 3831, 3830, 0, 0, 0, 0
35374, 3808, 377, 378, 3831, 0, 0, 0, 0
35375, 264, 3809, 310, 9, 0, 0, 0, 0
35376, 3809, 3810, 311, 310, 0, 0, 0, 0
35377, 3810, 3811, 312, 311, 0, 0, 0, 0
35378, 3811, 3812, 313, 312, 0, 0, 0, 0
35379, 3812, 3813, 314, 313, 0, 0, 0, 0
35380, 3813, 3814, 315, 314, 0, 0, 0, 0
35381, 3814, 3815, 316, 315, 0, 0, 0, 0
35382, 3815, 3816, 317, 316, 0, 0, 0, 0
35383, 3816, 3817, 318, 317, 0, 0, 0, 0
35384, 3817, 3818, 319, 318, 0, 0, 0, 0
35385, 3818, 3819, 320, 319, 0, 0, 0, 0
35386, 3819, 3820, 321, 320, 0, 0, 0, 0
35387, 3820, 3821, 322, 321, 0, 0, 0, 0
35388, 3821, 3822, 323, 322, 0, 0, 0, 0
35389, 3822, 3823, 324, 323, 0, 0, 0, 0
35390, 3823, 3824, 325, 324, 0, 0, 0, 0
35391, 3824, 3825, 326, 325, 0, 0, 0, 0
35392, 3825, 3826, 327, 326, 0, 0, 0, 0
35393, 3826, 3827, 328, 327, 0, 0, 0, 0
35394, 3827, 3828, 329, 328, 0, 0, 0, 0
35395, 3828, 3829, 330, 329, 0, 0, 0, 0
35396, 3829, 3830, 331, 330, 0, 0, 0, 0
35397, 3830, 3831, 332, 331, 0, 0, 0, 0
35398, 3831, 378, 13, 332, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface13
35399, 9, 310, 3832, 265, 0, 0, 0, 0
35400, 310, 311, 3833, 3832, 0, 0, 0, 0
35401, 311, 312, 3834, 3833, 0, 0, 0, 0
35402, 312, 313, 3835, 3834, 0, 0, 0, 0
35403, 313, 314, 3836, 3835, 0, 0, 0, 0
35404, 314, 315, 3837, 3836, 0, 0, 0, 0
35405, 315, 316, 3838, 3837, 0, 0, 0, 0
35406, 316, 317, 3839, 3838, 0, 0, 0, 0
35407, 317, 318, 3840, 3839, 0, 0, 0, 0
35408, 318, 319, 3841, 3840, 0, 0, 0, 0
35409, 319, 320, 3842, 3841, 0, 0, 0, 0
35410, 320, 321, 3843, 3842, 0, 0, 0, 0
35411, 321, 322, 3844, 3843, 0, 0, 0, 0
35412, 322, 323, 3845, 3844, 0, 0, 0, 0
35413, 323, 324, 3846, 3845, 0, 0, 0, 0
35414, 324, 325, 3847, 3846, 0, 0, 0, 0
35415, 325, 326, 3848, 3847, 0, 0, 0, 0
35416, 326, 327, 3849, 3848, 0, 0, 0, 0
35417, 327, 328, 3850, 3849, 0, 0, 0, 0
35418, 328, 329, 3851, 3850, 0, 0, 0, 0
35419, 329, 330, 3852, 3851, 0, 0, 0, 0
35420, 330, 331, 3853, 3852, 0, 0, 0, 0
35421, 331, 332, 3854, 3853, 0, 0, 0, 0
35422, 332, 13, 402, 3854, 0, 0, 0, 0
35423, 265, 3832, 3855, 266, 0, 0, 0, 0
35424, 3832, 3833, 3856, 3855, 0, 0, 0, 0
35425, 3833, 3834, 3857, 3856, 0, 0, 0, 0
35426, 3834, 3835, 3858, 3857, 0, 0, 0, 0
35427, 3835, 3836, 3859, 3858, 0, 0, 0, 0
35428, 3836, 3837, 3860, 3859, 0, 0, 0, 0
35429, 3837, 3838, 3861, 3860, 0, 0, 0, 0
35430, 3838, 3839, 3862, 3861, 0, 0, 0, 0
35431, 3839, 3840, 3863, 3862, 0, 0, 0, 0
35432, 3840, 3841, 3864, 3863, 0, 0, 0, 0
35433, 3841, 3842, 3865, 3864, 0, 0, 0, 0
35434, 3842, 3843, 3866, 3865, 0, 0, 0, 0
35435, 3843, 3844, 3867, 3866, 0, 0, 0, 0
35436, 3844, 3845, 3868, 3867, 0, 0, 0, 0
35437, 3845, 3846, 3869, 3868, 0, 0, 0, 0
35438, 3846, 3847, 3870, 3869, 0, 0, 0, 0
35439, 3847, 3848, 3871, 3870, 0, 0, 0, 0
35440, 3848, 3849, 3872, 3871, 0, 0, 0, 0
35441, 3849, 3850, 3873, 3872, 0, 0, 0, 0
35442, 3850, 3851, 3874, 3873, 0, 0, 0, 0
35443, 3851, 3852, 3875, 3874, 0, 0, 0, 0
35444, 3852, 3853, 3876, 3875, 0, 0, 0, 0
35445, 3853, 3854, 3877, 3876, 0, 0, 0, 0
35446, 3854, 402, 403, 3877, 0, 0, 0, 0
35447, 266, 3855, 3878, 267, 0, 0, 0, 0
35448, 3855, 3856, 3879, 3878, 0, 0, 0, 0
35449, 3856, 3857, 3880, 3879, 0, 0, 0, 0
35450, 3857, 3858, 3881, 3880, 0, 0, 0, 0
35451, 3858, 3859, 3882, 3881, 0, 0, 0, 0
35452, 3859, 3860, 3883, 3882, 0, 0, 0, 0
35453, 3860, 3861, 3884, 3883, 0, 0, 0, 0
35454, 3861, 3862, 3885, 3884, 0, 0, 0, 0
35455, 3862, 3863, 3886, 3885, 0, 0, 0, 0
35456, 3863, 3864, 3887, 3886, 0, 0, 0, 0
35457, 3864, 3865, 3888, 3887, 0, 0, 0, 0
35458, 3865, 3866, 3889, 3888, 0, 0, 0, 0
35459, 3866, 3867, 3890, 3889, 0, 0, 0, 0
35460, 3867, 3868, 3891, 3890, 0, 0, 0, 0
35461, 3868, 3869, 3892, 3891, 0, 0, 0, 0
35462, 3869, 3870, 3893, 3892, 0, 0, 0, 0
35463, 3870, 3871, 3894, 3893, 0, 0, 0, 0
35464, 3871, 3872, 3895, 3894, 0, 0, 0, 0
35465, 3872, 3873, 3896, 3895, 0, 0, 0, 0
35466, 3873, 3874, 3897, 3896, 0, 0, 0, 0
35467, 3874, 3875, 3898, 3897, 0, 0, 0, 0
35468, 3875, 3876, 3899, 3898, 0, 0, 0, 0
35469, 3876, 3877, 3900, 3899, 0, 0, 0, 0
35470, 3877, 403, 404, 3900, 0, 0, 0, 0
35471, 267, 3878, 3901, 268, 0, 0, 0, 0
35472, 3878, 3879, 3902, 3901, 0, 0, 0, 0
35473, 3879, 3880, 3903, 3902, 0, 0, 0, 0
35474, 3880, 3881, 3904, 3903, 0, 0, 0, 0
35475, 3881, 3882, 3905, 3904, 0, 0, 0, 0
35476, 3882, 3883, 3906, 3905, 0, 0, 0, 0
35477, 3883, 3884, 3907, 3906, 0, 0, 0, 0
35478, 3884, 3885, 3908, 3907, 0, 0, 0, 0
35479, 3885, 3886, 3909, 3908, 0, 0, 0, 0
35480, 3886, 3887, 3910, 3909, 0, 0, 0, 0
35481, 3887, 3888, 3911, 3910, 0, 0, 0, 0
35482, 3888, 3889, 3912, 3911, 0, 0, 0, 0
35483, 3889, 3890, 3913, 3912, 0, 0, 0, 0
35484, 3890, 3891, 3914, 3913, 0, 0, 0, 0
35485, 3891, 3892, 3915, 3914, 0, 0, 0, 0
35486, 3892, 3893, 3916, 3915, 0, 0, 0, 0
35487, 3893, 3894, 3917, 3916, 0, 0, 0, 0
35488, 3894, 3895, 3918, 3917, 0, 0, 0, 0
35489, 3895, 3896, 3919, 3918, 0, 0, 0, 0
35490, 3896, 3897, 3920, 3919, 0, 0, 0, 0
35491, 3897, 3898, 3921, 3920, 0, 0, 0, 0
35492, 3898, 3899, 3922, 3921, 0, 0, 0, 0
35493, 3899, 3900, 3923, 3922, 0, 0, 0, 0
35494, 3900, 404, 405, 3923, 0, 0, 0, 0
35495, 268, 3901, 3924, 269, 0, 0, 0, 0
35496, 3901, 3902, 3925, 3924, 0, 0, 0, 0
35497, 3902, 3903, 3926, 3925, 0, 0, 0, 0
35498, 3903, 3904, 3927, 3926, 0, 0, 0, 0
35499, 3904, 3905, 3928, 3927, 0, 0, 0, 0
35500, 3905, 3906, 3929, 3928, 0, 0, 0, 0
35501, 3906, 3907, 3930, 3929, 0, 0, 0, 0
35502, 3907, 3908, 3931, 3930, 0, 0, 0, 0
35503, 3908, 3909, 3932, 3931, 0, 0, 0, 0
35504, 3909, 3910, 3933, 3932, 0, 0, 0, 0
35505, 3910, 3911, 3934, 3933, 0, 0, 0, 0
35506, 3911, 3912, 3935, 3934, 0, 0, 0, 0
35507, 3912, 3913, 3936, 3935, 0, 0, 0, 0
35508, 3913, 3914, 3937, 3936, 0, 0, 0, 0
35509, 3914, 3915, 3938, 3937, 0, 0, 0, 0
35510, 3915, 3916, 3939, 3938, 0, 0, 0, 0
35511, 3916, 3917, 3940, 3939, 0, 0, 0, 0
35512, 3917, 3918, 3941, 3940, 0, 0, 0, 0
35513, 3918, 3919, 3942, 3941, 0, 0, 0, 0
35514, 3919, 3920, 3943, 3942, 0, 0, 0, 0
35515, 3920, 3921, 3944, 3943, 0, 0, 0, 0
35516, 3921, 3922, 3945, 3944, 0, 0, 0, 0
35517, 3922, 3923, 3946, 3945, 0, 0, 0, 0
35518, 3923, 405, 406, 3946, 0, 0, 0, 0
35519, 269, 3924, 3947, 270, 0, 0, 0, 0
35520, 3924, 3925, 3948, 3947, 0, 0, 0, 0
35521, 3925, 3926, 3949, 3948, 0, 0, 0, 0
35522, 3926, 3927, 3950, 3949, 0, 0, 0, 0
35523, 3927, 3928, 3951, 3950, 0, 0, 0, 0
35524, 3928, 3929, 3952, 3951, 0, 0, 0, 0
35525, 3929, 3930, 3953, 3952, 0, 0, 0, 0
35526, 3930, 3931, 3954, 3953, 0, 0, 0, 0
35527, 3931, 3932, 3955, 3954, 0, 0, 0, 0
35528, 3932, 3933, 3956, 3955, 0, 0, 0, 0
35529, 3933, 3934, 3957, 3956, 0, 0, 0, 0
35530, 3934, 3935, 3958, 3957, 0, 0, 0, 0
35531, 3935, 3936, 3959, 3958, 0, 0, 0, 0
35532, 3936, 3937, 3960, 3959, 0, 0, 0, 0
35533, 3937, 3938, 3961, 3960, 0, 0, 0, 0
35534, 3938, 3939, 3962, 3961, 0, 0, 0, 0
35535, 3939, 3940, 3963, 3962, 0, 0, 0, 0
35536, 3940, 3941, 3964, 3963, 0, 0, 0, 0
35537, 3941, 3942, 3965, 3964, 0, 0, 0, 0
35538, 3942, 3943, 3966, 3965, 0, 0, 0, 0
35539, 3943, 3944, 3967, 3966, 0, 0, 0, 0
35540, 3944, 3945, 3968, 3967, 0, 0, 0, 0
35541, 3945, 3946, 3969, 3968, 0, 0, 0, 0
35542, 3946, 406, 407, 3969, 0, 0, 0, 0
35543, 270, 3947, 3970, 271, 0, 0, 0, 0
35544, 3947, 3948, 3971, 3970, 0, 0, 0, 0
35545, 3948, 3949, 3972, 3971, 0, 0, 0, 0
35546, 3949, 3950, 3973, 3972, 0, 0, 0, 0
35547, 3950, 3951, 3974, 3973, 0, 0, 0, 0
35548, 3951, 3952, 3975, 3974, 0, 0, 0, 0
35549, 3952, 3953, 3976, 3975, 0, 0, 0, 0
35550, 3953, 3954, 3977, 3976, 0, 0, 0, 0
35551, 3954, 3955, 3978, 3977, 0, 0, 0, 0
35552, 3955, 3956, 3979, 3978, 0, 0, 0, 0
35553, 3956, 3957, 3980, 3979, 0, 0, 0, 0
35554, 3957, 3958, 3981, 3980, 0, 0, 0, 0
35555, 3958, 3959, 3982, 3981, 0, 0, 0, 0
35556, 3959, 3960, 3983, 3982, 0, 0, 0, 0
35557, 3960, 3961, 3984, 3983, 0, 0, 0, 0
35558, 3961, 3962, 3985, 3984, 0, 0, 0, 0
35559, 3962, 3963, 3986, 3985, 0, 0, 0, 0
35560, 3963, 3964, 3987, 3986, 0, 0, 0, 0
35561, 3964, 3965, 3988, 3987, 0, 0, 0, 0
35562, 3965, 3966, 3989, 3988, 0, 0, 0, 0
35563, 3966, 3967, 3990, 3989, 0, 0, 0, 0
35564, 3967, 3968, 3991, 3990, 0, 0, 0, 0
35565, 3968, 3969, 3992, 3991, 0, 0, 0, 0
35566, 3969, 407, 408, 3992, 0, 0, 0, 0
35567, 271, 3970, 3993, 272, 0, 0, 0, 0
35568, 3970, 3971, 3994, 3993, 0, 0, 0, 0
35569, 3971, 3972, 3995, 3994, 0, 0, 0, 0
35570, 3972, 3973, 3996, 3995, 0, 0, 0, 0
35571, 3973, 3974, 3997, 3996, 0, 0, 0, 0
35572, 3974, 3975, 3998, 3997, 0, 0, 0, 0
35573, 3975, 3976, 3999, 3998, 0, 0, 0, 0
35574, 3976, 3977, 4000, 3999, 0, 0, 0, 0
35575, 3977, 3978, 4001, 4000, 0, 0, 0, 0
35576, 3978, 3979, 4002, 4001, 0, 0, 0, 0
35577, 3979, 3980, 4003, 4002, 0, 0, 0, 0
35578, 3980, 3981, 4004, 4003, 0, 0, 0, 0
35579, 3981, 3982, 4005, 4004, 0, 0, 0, 0
35580, 3982, 3983, 4006, 4005, 0, 0, 0, 0
35581, 3983, 3984, 4007, 4006, 0, 0, 0, 0
35582, 3984, 3985, 4008, 4007, 0, 0, 0, 0
35583, 3985, 3986, 4009, 4008, 0, 0, 0, 0
35584, 3986, 3987, 4010, 4009, 0, 0, 0, 0
35585, 3987, 3988, 4011, 4010, 0, 0, 0, 0
35586, 3988, 3989, 4012, 4011, 0, 0, 0, 0
35587, 3989, 3990, 4013, 4012, 0, 0, 0, 0
35588, 3990, 3991, 4014, 4013, 0, 0, 0, 0
35589, 3991, 3992, 4015, 4014, 0, 0, 0, 0
35590, 3992, 408, 409, 4015, 0, 0, 0, 0
35591, 272, 3993, 4016, 273, 0, 0, 0, 0
35592, 3993, 3994, 4017, 4016, 0, 0, 0, 0
35593, 3994, 3995, 4018, 4017, 0, 0, 0, 0
35594, 3995, 3996, 4019, 4018, 0, 0, 0, 0
35595, 3996, 3997, 4020, 4019, 0, 0, 0, 0
35596, 3997, 3998, 4021, 4020, 0, 0, 0, 0
35597, 3998, 3999, 4022, 4021, 0, 0, 0, 0
35598, 3999, 4000, 4023, 4022, 0, 0, 0, 0
35599, 4000, 4001, 4024, 4023, 0, 0, 0, 0
35600, 4001, 4002, 4025, 4024, 0, 0, 0, 0
35601, 4002, 4003, 4026, 4025, 0, 0, 0, 0
35602, 4003, 4004, 4027, 4026, 0, 0, 0, 0
35603, 4004, 4005, 4028, 4027, 0, 0, 0, 0
35604, 4005, 4006, 4029, 4028, 0, 0, 0, 0
35605, 4006, 4007, 4030, 4029, 0, 0, 0, 0
35606, 4007, 4008, 4031, 4030, 0, 0, 0, 0
35607, 4008, 4009, 4032, 4031, 0, 0, 0, 0
35608, 4009, 4010, 4033, 4032, 0, 0, 0, 0
35609, 4010, 4011, 4034, 4033, 0, 0, 0, 0
35610, 4011, 4012, 4035, 4034, 0, 0, 0, 0
35611, 4012, 4013, 4036, 4035, 0, 0, 0, 0
35612, 4013, 4014, 4037, 4036, 0, 0, 0, 0
35613, 4014, 4015, 4038, 4037, 0, 0, 0, 0
35614, 4015, 409, 410, 4038, 0, 0, 0, 0
35615, 273, 4016, 4039, 274, 0, 0, 0, 0
35616, 4016, 4017, 4040, 4039, 0, 0, 0, 0
35617, 4017, 4018, 4041, 4040, 0, 0, 0, 0
35618, 4018, 4019, 4042, 4041, 0, 0, 0, 0
35619, 4019, 4020, 4043, 4042, 0, 0, 0, 0
35620, 4020, 4021, 4044, 4043, 0, 0, 0, 0
35621, 4021, 4022, 4045, 4044, 0, 0, 0, 0
35622, 4022, 4023, 4046, 4045, 0, 0, 0, 0
35623, 4023, 4024, 4047, 4046, 0, 0, 0, 0
35624, 4024, 4025, 4048, 4047, 0, 0, 0, 0
35625, 4025, 4026, 4049, 4048, 0, 0, 0, 0
35626, 4026, 4027, 4050, 4049, 0, 0, 0, 0
35627, 4027, 4028, 4051, 4050, 0, 0, 0, 0
35628, 4028, 4029, 4052, 4051, 0, 0, 0, 0
35629, 4029, 4030, 4053, 4052, 0, 0, 0, 0
35630, 4030, 4031, 4054, 4053, 0, 0, 0, 0
35631, 4031, 4032, 4055, 4054, 0, 0, 0, 0
35632, 4032, 4033, 4056, 4055, 0, 0, 0, 0
35633, 4033, 4034, 4057, 4056, 0, 0, 0, 0
35634, 4034, 4035, 4058, 4057, 0, 0, 0, 0
35635, 4035, 4036, 4059, 4058, 0, 0, 0, 0
35636, 4036, 4037, 4060, 4059, 0, 0, 0, 0
35637, 4037, 4038, 4061, 4060, 0, 0, 0, 0
35638, 4038, 410, 411, 4061, 0, 0, 0, 0
35639, 274, 4039, 4062, 275, 0, 0, 0, 0
35640, 4039, 4040, 4063, 4062, 0, 0, 0, 0
35641, 4040, 4041, 4064, 4063, 0, 0, 0, 0
35642, 4041, 4042, 4065, 4064, 0, 0, 0, 0
35643, 4042, 4043, 4066, 4065, 0, 0, 0, 0
35644, 4043, 4044, 4067, 4066, 0, 0, 0, 0
35645, 4044, 4045, 4068, 4067, 0, 0, 0, 0
35646, 4045, 4046, 4069, 4068, 0, 0, 0, 0
35647, 4046, 4047, 4070, 4069, 0, 0, 0, 0
35648, 4047, 4048, 4071, 4070, 0, 0, 0, 0
35649, 4048, 4049, 4072, 4071, 0, 0, 0, 0
35650, 4049, 4050, 4073, 4072, 0, 0, 0, 0
35651, 4050, 4051, 4074, 4073, 0, 0, 0, 0
35652, 4051, 4052, 4075, 4074, 0, 0, 0, 0
35653, 4052, 4053, 4076, 4075, 0, 0, 0, 0
35654, 4053, 4054, 4077, 4076, 0, 0, 0, 0
35655, 4054, 4055, 4078, 4077, 0, 0, 0, 0
35656, 4055, 4056, 4079, 4078, 0, 0, 0, 0
35657, 4056, 4057, 4080, 4079, 0, 0, 0, 0
35658, 4057, 4058, 4081, 4080, 0, 0, 0, 0
35659, 4058, 4059, 4082, 4081, 0, 0, 0, 0
35660, 4059, 4060, 4083, 4082, 0, 0, 0, 0
35661, 4060, 4061, 4084, 4083, 0, 0, 0, 0
35662, 4061, 411, 412, 4084, 0, 0, 0, 0
35663, 275, 4062, 379, 11, 0, 0, 0, 0
35664, 4062, 4063, 380, 379, 0, 0, 0, 0
35665, 4063, 4064, 381, 380, 0, 0, 0, 0
35666, 4064, 4065, 382, 381, 0, 0, 0, 0
35667, 4065, 4066, 383, 382, 0, 0, 0, 0
35668, 4066, 4067, 384, 383, 0, 0, 0, 0
35669, 4067, 4068, 385, 384, 0, 0, 0, 0
35670, 4068, 4069, 386, 385, 0, 0, 0, 0
35671, 4069, 4070, 387, 386, 0, 0, 0, 0
35672, 4070, 4071, 388, 387, 0, 0, 0, 0
35673, 4071, 4072, 389, 388, 0, 0, 0, 0
35674, 4072, 4073, 390, 389, 0, 0, 0, 0
35675, 4073, 4074, 391, 390, 0, 0, 0, 0
35676, 4074, 4075, 392, 391, 0, 0, 0, 0
35677, 4075, 4076, 393, 392, 0, 0, 0, 0
35678, 4076, 4077, 394, 393, 0, 0, 0, 0
35679, 4077, 4078, 395, 394, 0, 0, 0, 0
35680, 4078, 4079, 396, 395, 0, 0, 0, 0
35681, 4079, 4080, 397, 396, 0, 0, 0, 0
35682, 4080, 4081, 398, 397, 0, 0, 0, 0
35683, 4081, 4082, 399, 398, 0, 0, 0, 0
35684, 4082, 4083, 400, 399, 0, 0, 0, 0
35685, 4083, 4084, 401, 400, 0, 0, 0, 0
35686, 4084, 412, 15, 401, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface14
494, 12, 276, 4085, 413, 0, 0, 0, 0
495, 413, 4085, 4086, 414, 0, 0, 0, 0
496, 414, 4086, 4087, 415, 0, 0, 0, 0
497, 415, 4087, 4088, 416, 0, 0, 0, 0
498, 416, 4088, 4089, 417, 0, 0, 0, 0
499, 417, 4089, 4090, 418, 0, 0, 0, 0
500, 418, 4090, 4091, 419, 0, 0, 0, 0
501, 419, 4091, 4092, 420, 0, 0, 0, 0
502, 420, 4092, 4093, 421, 0, 0, 0, 0
503, 421, 4093, 4094, 422, 0, 0, 0, 0
504, 422, 4094, 4095, 423, 0, 0, 0, 0
505, 423, 4095, 4096, 424, 0, 0, 0, 0
506, 424, 4096, 4097, 425, 0, 0, 0, 0
507, 425, 4097, 4098, 426, 0, 0, 0, 0
508, 426, 4098, 4099, 427, 0, 0, 0, 0
509, 427, 4099, 4100, 428, 0, 0, 0, 0
510, 428, 4100, 4101, 429, 0, 0, 0, 0
511, 429, 4101, 4102, 430, 0, 0, 0, 0
512, 430, 4102, 4103, 431, 0, 0, 0, 0
513, 431, 4103, 4104, 432, 0, 0, 0, 0
514, 432, 4104, 4105, 433, 0, 0, 0, 0
515, 433, 4105, 4106, 434, 0, 0, 0, 0
516, 434, 4106, 4107, 435, 0, 0, 0, 0
517, 435, 4107, 436, 16, 0, 0, 0, 0
518, 276, 277, 4108, 4085, 0, 0, 0, 0
519, 4085, 4108, 4109, 4086, 0, 0, 0, 0
520, 4086, 4109, 4110, 4087, 0, 0, 0, 0
521, 4087, 4110, 4111, 4088, 0, 0, 0, 0
522, 4088, 4111, 4112, 4089, 0, 0, 0, 0
523, 4089, 4112, 4113, 4090, 0, 0, 0, 0
524, 4090, 4113, 4114, 4091, 0, 0, 0, 0
525, 4091, 4114, 4115, 4092, 0, 0, 0, 0
526, 4092, 4115, 4116, 4093, 0, 0, 0, 0
527, 4093, 4116, 4117, 4094, 0, 0, 0, 0
528, 4094, 4117, 4118, 4095, 0, 0, 0, 0
529, 4095, 4118, 4119, 4096, 0, 0, 0, 0
530, 4096, 4119, 4120, 4097, 0, 0, 0, 0
531, 4097, 4120, 4121, 4098, 0, 0, 0, 0
532, 4098, 4121, 4122, 4099, 0, 0, 0, 0
533, 4099, 4122, 4123, 4100, 0, 0, 0, 0
534, 4100, 4123, 4124, 4101, 0, 0, 0, 0
535, 4101, 4124, 4125, 4102, 0, 0, 0, 0
536, 4102, 4125, 4126, 4103, 0, 0, 0, 0
537, 4103, 4126, 4127, 4104, 0, 0, 0, 0
538, 4104, 4127, 4128, 4105, 0, 0, 0, 0
539, 4105, 4128, 4129, 4106, 0, 0, 0, 0
540, 4106, 4129, 4130, 4107, 0, 0, 0, 0
541, 4107, 4130, 437, 436, 0, 0, 0, 0
542, 277, 278, 4131, 4108, 0, 0, 0, 0
543, 4108, 4131, 4132, 4109, 0, 0, 0, 0
544, 4109, 4132, 4133, 4110, 0, 0, 0, 0
545, 4110, 4133, 4134, 4111, 0, 0, 0, 0
546, 4111, 4134, 4135, 4112, 0, 0, 0, 0
547, 4112, 4135, 4136, 4113, 0, 0, 0, 0
548, 4113, 4136, 4137, 4114, 0, 0, 0, 0
549, 4114, 4137, 4138, 4115, 0, 0, 0, 0
550, 4115, 4138, 4139, 4116, 0, 0, 0, 0
551, 4116, 4139, 4140, 4117, 0, 0, 0, 0
552, 4117, 4140, 4141, 4118, 0, 0, 0, 0
553, 4118, 4141, 4142, 4119, 0, 0, 0, 0
554, 4119, 4142, 4143, 4120, 0, 0, 0, 0
555, 4120, 4143, 4144, 4121, 0, 0, 0, 0
556, 4121, 4144, 4145, 4122, 0, 0, 0, 0
557, 4122, 4145, 4146, 4123, 0, 0, 0, 0
558, 4123, 4146, 4147, 4124, 0, 0, 0, 0
559, 4124, 4147, 4148, 4125, 0, 0, 0, 0
560, 4125, 4148, 4149, 4126, 0, 0, 0, 0
561, 4126, 4149, 4150, 4127, 0, 0, 0, 0
562, 4127, 4150, 4151, 4128, 0, 0, 0, 0
563, 4128, 4151, 4152, 4129, 0, 0, 0, 0
564, 4129, 4152, 4153, 4130, 0, 0, 0, 0
565, 4130, 4153, 438, 437, 0, 0, 0, 0
566, 278, 279, 4154, 4131, 0, 0, 0, 0
567, 4131, 4154, 4155, 4132, 0, 0, 0, 0
568, 4132, 4155, 4156, 4133, 0, 0, 0, 0
569, 4133, 4156, 4157, 4134, 0, 0, 0, 0
570, 4134, 4157, 4158, 4135, 0, 0, 0, 0
571, 4135, 4158, 4159, 4136, 0, 0, 0, 0
572, 4136, 4159, 4160, 4137, 0, 0, 0, 0
573, 4137, 4160, 4161, 4138, 0, 0, 0, 0
574, 4138, 4161, 4162, 4139, 0, 0, 0, 0
575, 4139, 4162, 4163, 4140, 0, 0, 0, 0
576, 4140, 4163, 4164, 4141, 0, 0, 0, 0
577, 4141, 4164, 4165, 4142, 0, 0, 0, 0
578, 4142, 4165, 4166, 4143, 0, 0, 0, 0
579, 4143, 4166, 4167, 4144, 0, 0, 0, 0
580, 4144, 4167, 4168, 4145, 0, 0, 0, 0
581, 4145, 4168, 4169, 4146, 0, 0, 0, 0
582, 4146, 4169, 4170, 4147, 0, 0, 0, 0
583, 4147, 4170, 4171, 4148, 0, 0, 0, 0
584, 4148, 4171, 4172, 4149, 0, 0, 0, 0
585, 4149, 4172, 4173, 4150, 0, 0, 0, 0
586, 4150, 4173, 4174, 4151, 0, 0, 0, 0
587, 4151, 4174, 4175, 4152, 0, 0, 0, 0
588, 4152, 4175, 4176, 4153, 0, 0, 0, 0
589, 4153, 4176, 439, 438, 0, 0, 0, 0
590, 279, 280, 4177, 4154, 0, 0, 0, 0
591, 4154, 4177, 4178, 4155, 0, 0, 0, 0
592, 4155, 4178, 4179, 4156, 0, 0, 0, 0
593, 4156, 4179, 4180, 4157, 0, 0, 0, 0
594, 4157, 4180, 4181, 4158, 0, 0, 0, 0
595, 4158, 4181, 4182, 4159, 0, 0, 0, 0
596, 4159, 4182, 4183, 4160, 0, 0, 0, 0
597, 4160, 4183, 4184, 4161, 0, 0, 0, 0
598, 4161, 4184, 4185, 4162, 0, 0, 0, 0
599, 4162, 4185, 4186, 4163, 0, 0, 0, 0
600, 4163, 4186, 4187, 4164, 0, 0, 0, 0
601, 4164, 4187, 4188, 4165, 0, 0, 0, 0
602, 4165, 4188, 4189, 4166, 0, 0, 0, 0
603, 4166, 4189, 4190, 4167, 0, 0, 0, 0
604, 4167, 4190, 4191, 4168, 0, 0, 0, 0
605, 4168, 4191, 4192, 4169, 0, 0, 0, 0
606, 4169, 4192, 4193, 4170, 0, 0, 0, 0
607, 4170, 4193, 4194, 4171, 0, 0, 0, 0
608, 4171, 4194, 4195, 4172, 0, 0, 0, 0
609, 4172, 4195, 4196, 4173, 0, 0, 0, 0
610, 4173, 4196, 4197, 4174, 0, 0, 0, 0
611, 4174, 4197, 4198, 4175, 0, 0, 0, 0
612, 4175, 4198, 4199, 4176, 0, 0, 0, 0
613, 4176, 4199, 440, 439, 0, 0, 0, 0
614, 280, 281, 4200, 4177, 0, 0, 0, 0
615, 4177, 4200, 4201, 4178, 0, 0, 0, 0
616, 4178, 4201, 4202, 4179, 0, 0, 0, 0
617, 4179, 4202, 4203, 4180, 0, 0, 0, 0
618, 4180, 4203, 4204, 4181, 0, 0, 0, 0
619, 4181, 4204, 4205, 4182, 0, 0, 0, 0
620, 4182, 4205, 4206, 4183, 0, 0, 0, 0
621, 4183, 4206, 4207, 4184, 0, 0, 0, 0
622, 4184, 4207, 4208, 4185, 0, 0, 0, 0
623, 4185, 4208, 4209, 4186, 0, 0, 0, 0
624, 4186, 4209, 4210, 4187, 0, 0, 0, 0
625, 4187, 4210, 4211, 4188, 0, 0, 0, 0
626, 4188, 4211, 4212, 4189, 0, 0, 0, 0
627, 4189, 4212, 4213, 4190, 0, 0, 0, 0
628, 4190, 4213, 4214, 4191, 0, 0, 0, 0
629, 4191, 4214, 4215, 4192, 0, 0, 0, 0
630, 4192, 4215, 4216, 4193, 0, 0, 0, 0
631, 4193, 4216, 4217, 4194, 0, 0, 0, 0
632, 4194, 4217, 4218, 4195, 0, 0, 0, 0
633, 4195, 4218, 4219, 4196, 0, 0, 0, 0
634, 4196, 4219, 4220, 4197, 0, 0, 0, 0
635, 4197, 4220, 4221, 4198, 0, 0, 0, 0
636, 4198, 4221, 4222, 4199, 0, 0, 0, 0
637, 4199, 4222, 441, 440, 0, 0, 0, 0
638, 281, 282, 4223, 4200, 0, 0, 0, 0
639, 4200, 4223, 4224, 4201, 0, 0, 0, 0
640, 4201, 4224, 4225, 4202, 0, 0, 0, 0
641, 4202, 4225, 4226, 4203, 0, 0, 0, 0
642, 4203, 4226, 4227, 4204, 0, 0, 0, 0
643, 4204, 4227, 4228, 4205, 0, 0, 0, 0
644, 4205, 4228, 4229, 4206, 0, 0, 0, 0
645, 4206, 4229, 4230, 4207, 0, 0, 0, 0
646, 4207, 4230, 4231, 4208, 0, 0, 0, 0
647, 4208, 4231, 4232, 4209, 0, 0, 0, 0
648, 4209, 4232, 4233, 4210, 0, 0, 0, 0
649, 4210, 4233, 4234, 4211, 0, 0, 0, 0
650, 4211, 4234, 4235, 4212, 0, 0, 0, 0
651, 4212, 4235, 4236, 4213, 0, 0, 0, 0
652, 4213, 4236, 4237, 4214, 0, 0, 0, 0
653, 4214, 4237, 4238, 4215, 0, 0, 0, 0
654, 4215, 4238, 4239, 4216, 0, 0, 0, 0
655, 4216, 4239, 4240, 4217, 0, 0, 0, 0
656, 4217, 4240, 4241, 4218, 0, 0, 0, 0
657, 4218, 4241, 4242, 4219, 0, 0, 0, 0
658, 4219, 4242, 4243, 4220, 0, 0, 0, 0
659, 4220, 4243, 4244, 4221, 0, 0, 0, 0
660, 4221, 4244, 4245, 4222, 0, 0, 0, 0
661, 4222, 4245, 442, 441, 0, 0, 0, 0
662, 282, 283, 4246, 4223, 0, 0, 0, 0
663, 4223, 4246, 4247, 4224, 0, 0, 0, 0
664, 4224, 4247, 4248, 4225, 0, 0, 0, 0
665, 4225, 4248, 4249, 4226, 0, 0, 0, 0
666, 4226, 4249, 4250, 4227, 0, 0, 0, 0
667, 4227, 4250, 4251, 4228, 0, 0, 0, 0
668, 4228, 4251, 4252, 4229, 0, 0, 0, 0
669, 4229, 4252, 4253, 4230, 0, 0, 0, 0
670, 4230, 4253, 4254, 4231, 0, 0, 0, 0
671, 4231, 4254, 4255, 4232, 0, 0, 0, 0
672, 4232, 4255, 4256, 4233, 0, 0, 0, 0
673, 4233, 4256, 4257, 4234, 0, 0, 0, 0
674, 4234, 4257, 4258, 4235, 0, 0, 0, 0
675, 4235, 4258, 4259, 4236, 0, 0, 0, 0
676, 4236, 4259, 4260, 4237, 0, 0, 0, 0
677, 4237, 4260, 4261, 4238, 0, 0, 0, 0
678, 4238, 4261, 4262, 4239, 0, 0, 0, 0
679, 4239, 4262, 4263, 4240, 0, 0, 0, 0
680, 4240, 4263, 4264, 4241, 0, 0, 0, 0
681, 4241, 4264, 4265, 4242, 0, 0, 0, 0
682, 4242, 4265, 4266, 4243, 0, 0, 0, 0
683, 4243, 4266, 4267, 4244, 0, 0, 0, 0
684, 4244, 4267, 4268, 4245, 0, 0, 0, 0
685, 4245, 4268, 443, 442, 0, 0, 0, 0
686, 283, 284, 4269, 4246, 0, 0, 0, 0
687, 4246, 4269, 4270, 4247, 0, 0, 0, 0
688, 4247, 4270, 4271, 4248, 0, 0, 0, 0
689, 4248, 4271, 4272, 4249, 0, 0, 0, 0
690, 4249, 4272, 4273, 4250, 0, 0, 0, 0
691, 4250, 4273, 4274, 4251, 0, 0, 0, 0
692, 4251, 4274, 4275, 4252, 0, 0, 0, 0
693, 4252, 4275, 4276, 4253, 0, 0, 0, 0
694, 4253, 4276, 4277, 4254, 0, 0, 0, 0
695, 4254, 4277, 4278, 4255, 0, 0, 0, 0
696, 4255, 4278, 4279, 4256, 0, 0, 0, 0
697, 4256, 4279, 4280, 4257, 0, 0, 0, 0
698, 4257, 4280, 4281, 4258, 0, 0, 0, 0
699, 4258, 4281, 4282, 4259, 0, 0, 0, 0
700, 4259, 4282, 4283, 4260, 0, 0, 0, 0
701, 4260, 4283, 4284, 4261, 0, 0, 0, 0
702, 4261, 4284, 4285, 4262, 0, 0, 0, 0
703, 4262, 4285, 4286, 4263, 0, 0, 0, 0
704, 4263, 4286, 4287, 4264, 0, 0, 0, 0
705, 4264, 4287, 4288, 4265, 0, 0, 0, 0
706, 4265, 4288, 4289, 4266, 0, 0, 0, 0
707, 4266, 4289, 4290, 4267, 0, 0, 0, 0
708, 4267, 4290, 4291, 4268, 0, 0, 0, 0
709, 4268, 4291, 444, 443, 0, 0, 0, 0
710, 284, 285, 4292, 4269, 0, 0, 0, 0
711, 4269, 4292, 4293, 4270, 0, 0, 0, 0
712, 4270, 4293, 4294, 4271, 0, 0, 0, 0
713, 4271, 4294, 4295, 4272, 0, 0, 0, 0
714, 4272, 4295, 4296, 4273, 0, 0, 0, 0
715, 4273, 4296, 4297, 4274, 0, 0, 0, 0
716, 4274, 4297, 4298, 4275, 0, 0, 0, 0
717, 4275, 4298, 4299, 4276, 0, 0, 0, 0
718, 4276, 4299, 4300, 4277, 0, 0, 0, 0
719, 4277, 4300, 4301, 4278, 0, 0, 0, 0
720, 4278, 4301, 4302, 4279, 0, 0, 0, 0
721, 4279, 4302, 4303, 4280, 0, 0, 0, 0
722, 4280, 4303, 4304, 4281, 0, 0, 0, 0
723, 4281, 4304, 4305, 4282, 0, 0, 0, 0
724, 4282, 4305, 4306, 4283, 0, 0, 0, 0
725, 4283, 4306, 4307, 4284, 0, 0, 0, 0
726, 4284, 4307, 4308, 4285, 0, 0, 0, 0
727, 4285, 4308, 4309, 4286, 0, 0, 0, 0
728, 4286, 4309, 4310, 4287, 0, 0, 0, 0
729, 4287, 4310, 4311, 4288, 0, 0, 0, 0
730, 4288, 4311, 4312, 4289, 0, 0, 0, 0
731, 4289, 4312, 4313, 4290, 0, 0, 0, 0
732, 4290, 4313, 4314, 4291, 0, 0, 0, 0
733, 4291, 4314, 445, 444, 0, 0, 0, 0
734, 285, 286, 4315, 4292, 0, 0, 0, 0
735, 4292, 4315, 4316, 4293, 0, 0, 0, 0
736, 4293, 4316, 4317, 4294, 0, 0, 0, 0
737, 4294, 4317, 4318, 4295, 0, 0, 0, 0
738, 4295, 4318, 4319, 4296, 0, 0, 0, 0
739, 4296, 4319, 4320, 4297, 0, 0, 0, 0
740, 4297, 4320, 4321, 4298, 0, 0, 0, 0
741, 4298, 4321, 4322, 4299, 0, 0, 0, 0
742, 4299, 4322, 4323, 4300, 0, 0, 0, 0
743, 4300, 4323, 4324, 4301, 0, 0, 0, 0
744, 4301, 4324, 4325, 4302, 0, 0, 0, 0
745, 4302, 4325, 4326, 4303, 0, 0, 0, 0
746, 4303, 4326, 4327, 4304, 0, 0, 0, 0
747, 4304, 4327, 4328, 4305, 0, 0, 0, 0
748, 4305, 4328, 4329, 4306, 0, 0, 0, 0
749, 4306, 4329, 4330, 4307, 0, 0, 0, 0
750, 4307, 4330, 4331, 4308, 0, 0, 0, 0
751, 4308, 4331, 4332, 4309, 0, 0, 0, 0
752, 4309, 4332, 4333, 4310, 0, 0, 0, 0
753, 4310, 4333, 4334, 4311, 0, 0, 0, 0
754, 4311, 4334, 4335, 4312, 0, 0, 0, 0
755, 4312, 4335, 4336, 4313, 0, 0, 0, 0
756, 4313, 4336, 4337, 4314, 0, 0, 0, 0
757, 4314, 4337, 446, 445, 0, 0, 0, 0
758, 286, 287, 4338, 4315, 0, 0, 0, 0
759, 4315, 4338, 4339, 4316, 0, 0, 0, 0
760, 4316, 4339, 4340, 4317, 0, 0, 0, 0
761, 4317, 4340, 4341, 4318, 0, 0, 0, 0
762, 4318, 4341, 4342, 4319, 0, 0, 0, 0
763, 4319, 4342, 4343, 4320, 0, 0, 0, 0
