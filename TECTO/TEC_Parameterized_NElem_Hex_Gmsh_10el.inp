27664, 1.6166666666667, 0.35, 0.083333333333333
27665, 1.6166666666667, 0.3, 0.083333333333333
27666, 1.6166666666667, 0.25, 0.083333333333333
27667, 1.6166666666667, 0.2, 0.083333333333333
27668, 1.6583333333333, 1.3, 0.083333333333333
27669, 1.6583333333333, 1.25, 0.083333333333333
27670, 1.6583333333333, 1.2, 0.083333333333333
27671, 1.6583333333333, 1.15, 0.083333333333333
27672, 1.6583333333333, 1.1, 0.083333333333333
27673, 1.6583333333333, 1.05, 0.083333333333333
27674, 1.6583333333333, 1, 0.083333333333333
27675, 1.6583333333333, 0.95, 0.083333333333333
27676, 1.6583333333333, 0.9, 0.083333333333333
27677, 1.6583333333333, 0.85, 0.083333333333333
27678, 1.6583333333333, 0.8, 0.083333333333333
27679, 1.6583333333333, 0.75, 0.083333333333333
27680, 1.6583333333333, 0.7, 0.083333333333333
27681, 1.6583333333333, 0.65, 0.083333333333333
27682, 1.6583333333333, 0.6, 0.083333333333333
27683, 1.6583333333333, 0.55, 0.083333333333333
27684, 1.6583333333333, 0.5, 0.083333333333333
27685, 1.6583333333333, 0.45, 0.083333333333333
27686, 1.6583333333333, 0.4, 0.083333333333333
27687, 1.6583333333333, 0.35, 0.083333333333333
27688, 1.6583333333333, 0.3, 0.083333333333333
27689, 1.6583333333333, 0.25, 0.083333333333333
27690, 1.6583333333333, 0.2, 0.083333333333333
27691, 1.7, 1.3, 0.083333333333333
27692, 1.7, 1.25, 0.083333333333333
27693, 1.7, 1.2, 0.083333333333333
27694, 1.7, 1.15, 0.083333333333333
27695, 1.7, 1.1, 0.083333333333333
27696, 1.7, 1.05, 0.083333333333333
27697, 1.7, 1, 0.083333333333333
27698, 1.7, 0.95, 0.083333333333333
27699, 1.7, 0.9, 0.083333333333333
27700, 1.7, 0.85, 0.083333333333333
27701, 1.7, 0.8, 0.083333333333333
27702, 1.7, 0.75, 0.083333333333333
27703, 1.7, 0.7, 0.083333333333333
27704, 1.7, 0.65, 0.083333333333333
27705, 1.7, 0.6, 0.083333333333333
27706, 1.7, 0.55, 0.083333333333333
27707, 1.7, 0.5, 0.083333333333333
27708, 1.7, 0.45, 0.083333333333333
27709, 1.7, 0.4, 0.083333333333333
27710, 1.7, 0.35, 0.083333333333333
27711, 1.7, 0.3, 0.083333333333333
27712, 1.7, 0.25, 0.083333333333333
27713, 1.7, 0.2, 0.083333333333333
27714, 1.7416666666667, 1.3, 0.083333333333333
27715, 1.7416666666667, 1.25, 0.083333333333333
27716, 1.7416666666667, 1.2, 0.083333333333333
27717, 1.7416666666667, 1.15, 0.083333333333333
27718, 1.7416666666667, 1.1, 0.083333333333333
27719, 1.7416666666667, 1.05, 0.083333333333333
27720, 1.7416666666667, 1, 0.083333333333333
27721, 1.7416666666667, 0.95, 0.083333333333333
27722, 1.7416666666667, 0.9, 0.083333333333333
27723, 1.7416666666667, 0.85, 0.083333333333333
27724, 1.7416666666667, 0.8, 0.083333333333333
27725, 1.7416666666667, 0.75, 0.083333333333333
27726, 1.7416666666667, 0.7, 0.083333333333333
27727, 1.7416666666667, 0.65, 0.083333333333333
27728, 1.7416666666667, 0.6, 0.083333333333333
27729, 1.7416666666667, 0.55, 0.083333333333333
27730, 1.7416666666667, 0.5, 0.083333333333333
27731, 1.7416666666667, 0.45, 0.083333333333333
27732, 1.7416666666667, 0.4, 0.083333333333333
27733, 1.7416666666667, 0.35, 0.083333333333333
27734, 1.7416666666667, 0.3, 0.083333333333333
27735, 1.7416666666667, 0.25, 0.083333333333333
27736, 1.7416666666667, 0.2, 0.083333333333333
27737, 1.7833333333333, 1.3, 0.083333333333333
27738, 1.7833333333333, 1.25, 0.083333333333333
27739, 1.7833333333333, 1.2, 0.083333333333333
27740, 1.7833333333333, 1.15, 0.083333333333333
27741, 1.7833333333333, 1.1, 0.083333333333333
27742, 1.7833333333333, 1.05, 0.083333333333333
27743, 1.7833333333333, 1, 0.083333333333333
27744, 1.7833333333333, 0.95, 0.083333333333333
27745, 1.7833333333333, 0.9, 0.083333333333333
27746, 1.7833333333333, 0.85, 0.083333333333333
27747, 1.7833333333333, 0.8, 0.083333333333333
27748, 1.7833333333333, 0.75, 0.083333333333333
27749, 1.7833333333333, 0.7, 0.083333333333333
27750, 1.7833333333333, 0.65, 0.083333333333333
27751, 1.7833333333333, 0.6, 0.083333333333333
27752, 1.7833333333333, 0.55, 0.083333333333333
27753, 1.7833333333333, 0.5, 0.083333333333333
27754, 1.7833333333333, 0.45, 0.083333333333333
27755, 1.7833333333333, 0.4, 0.083333333333333
27756, 1.7833333333333, 0.35, 0.083333333333333
27757, 1.7833333333333, 0.3, 0.083333333333333
27758, 1.7833333333333, 0.25, 0.083333333333333
27759, 1.7833333333333, 0.2, 0.083333333333333
27760, 1.825, 1.3, 0.083333333333333
27761, 1.825, 1.25, 0.083333333333333
27762, 1.825, 1.2, 0.083333333333333
27763, 1.825, 1.15, 0.083333333333333
27764, 1.825, 1.1, 0.083333333333333
27765, 1.825, 1.05, 0.083333333333333
27766, 1.825, 1, 0.083333333333333
27767, 1.825, 0.95, 0.083333333333333
27768, 1.825, 0.9, 0.083333333333333
27769, 1.825, 0.85, 0.083333333333333
27770, 1.825, 0.8, 0.083333333333333
27771, 1.825, 0.75, 0.083333333333333
27772, 1.825, 0.7, 0.083333333333333
27773, 1.825, 0.65, 0.083333333333333
27774, 1.825, 0.6, 0.083333333333333
27775, 1.825, 0.55, 0.083333333333333
27776, 1.825, 0.5, 0.083333333333333
27777, 1.825, 0.45, 0.083333333333333
27778, 1.825, 0.4, 0.083333333333333
27779, 1.825, 0.35, 0.083333333333333
27780, 1.825, 0.3, 0.083333333333333
27781, 1.825, 0.25, 0.083333333333333
27782, 1.825, 0.2, 0.083333333333333
27783, 1.8666666666667, 1.3, 0.083333333333333
27784, 1.8666666666667, 1.25, 0.083333333333333
27785, 1.8666666666667, 1.2, 0.083333333333333
27786, 1.8666666666667, 1.15, 0.083333333333333
27787, 1.8666666666667, 1.1, 0.083333333333333
27788, 1.8666666666667, 1.05, 0.083333333333333
27789, 1.8666666666667, 1, 0.083333333333333
27790, 1.8666666666667, 0.95, 0.083333333333333
27791, 1.8666666666667, 0.9, 0.083333333333333
27792, 1.8666666666667, 0.85, 0.083333333333333
27793, 1.8666666666667, 0.8, 0.083333333333333
27794, 1.8666666666667, 0.75, 0.083333333333333
27795, 1.8666666666667, 0.7, 0.083333333333333
27796, 1.8666666666667, 0.65, 0.083333333333333
27797, 1.8666666666667, 0.6, 0.083333333333333
27798, 1.8666666666667, 0.55, 0.083333333333333
27799, 1.8666666666667, 0.5, 0.083333333333333
27800, 1.8666666666667, 0.45, 0.083333333333333
27801, 1.8666666666667, 0.4, 0.083333333333333
27802, 1.8666666666667, 0.35, 0.083333333333333
27803, 1.8666666666667, 0.3, 0.083333333333333
27804, 1.8666666666667, 0.25, 0.083333333333333
27805, 1.8666666666667, 0.2, 0.083333333333333
27806, 1.9083333333333, 1.3, 0.083333333333333
27807, 1.9083333333333, 1.25, 0.083333333333333
27808, 1.9083333333333, 1.2, 0.083333333333333
27809, 1.9083333333333, 1.15, 0.083333333333333
27810, 1.9083333333333, 1.1, 0.083333333333333
27811, 1.9083333333333, 1.05, 0.083333333333333
27812, 1.9083333333333, 1, 0.083333333333333
27813, 1.9083333333333, 0.95, 0.083333333333333
27814, 1.9083333333333, 0.9, 0.083333333333333
27815, 1.9083333333333, 0.85, 0.083333333333333
27816, 1.9083333333333, 0.8, 0.083333333333333
27817, 1.9083333333333, 0.75, 0.083333333333333
27818, 1.9083333333333, 0.7, 0.083333333333333
27819, 1.9083333333333, 0.65, 0.083333333333333
27820, 1.9083333333333, 0.6, 0.083333333333333
27821, 1.9083333333333, 0.55, 0.083333333333333
27822, 1.9083333333333, 0.5, 0.083333333333333
27823, 1.9083333333333, 0.45, 0.083333333333333
27824, 1.9083333333333, 0.4, 0.083333333333333
27825, 1.9083333333333, 0.35, 0.083333333333333
27826, 1.9083333333333, 0.3, 0.083333333333333
27827, 1.9083333333333, 0.25, 0.083333333333333
27828, 1.9083333333333, 0.2, 0.083333333333333
27829, 1.95, 1.3, 0.083333333333333
27830, 1.95, 1.25, 0.083333333333333
27831, 1.95, 1.2, 0.083333333333333
27832, 1.95, 1.15, 0.083333333333333
27833, 1.95, 1.1, 0.083333333333333
27834, 1.95, 1.05, 0.083333333333333
27835, 1.95, 1, 0.083333333333333
27836, 1.95, 0.95, 0.083333333333333
27837, 1.95, 0.9, 0.083333333333333
27838, 1.95, 0.85, 0.083333333333333
27839, 1.95, 0.8, 0.083333333333333
27840, 1.95, 0.75, 0.083333333333333
27841, 1.95, 0.7, 0.083333333333333
27842, 1.95, 0.65, 0.083333333333333
27843, 1.95, 0.6, 0.083333333333333
27844, 1.95, 0.55, 0.083333333333333
27845, 1.95, 0.5, 0.083333333333333
27846, 1.95, 0.45, 0.083333333333333
27847, 1.95, 0.4, 0.083333333333333
27848, 1.95, 0.35, 0.083333333333333
27849, 1.95, 0.3, 0.083333333333333
27850, 1.95, 0.25, 0.083333333333333
27851, 1.95, 0.2, 0.083333333333333
27852, 1.9916666666667, 1.3, 0.083333333333333
27853, 1.9916666666667, 1.25, 0.083333333333333
27854, 1.9916666666667, 1.2, 0.083333333333333
27855, 1.9916666666667, 1.15, 0.083333333333333
27856, 1.9916666666667, 1.1, 0.083333333333333
27857, 1.9916666666667, 1.05, 0.083333333333333
27858, 1.9916666666667, 1, 0.083333333333333
27859, 1.9916666666667, 0.95, 0.083333333333333
27860, 1.9916666666667, 0.9, 0.083333333333333
27861, 1.9916666666667, 0.85, 0.083333333333333
27862, 1.9916666666667, 0.8, 0.083333333333333
27863, 1.9916666666667, 0.75, 0.083333333333333
27864, 1.9916666666667, 0.7, 0.083333333333333
27865, 1.9916666666667, 0.65, 0.083333333333333
27866, 1.9916666666667, 0.6, 0.083333333333333
27867, 1.9916666666667, 0.55, 0.083333333333333
27868, 1.9916666666667, 0.5, 0.083333333333333
27869, 1.9916666666667, 0.45, 0.083333333333333
27870, 1.9916666666667, 0.4, 0.083333333333333
27871, 1.9916666666667, 0.35, 0.083333333333333
27872, 1.9916666666667, 0.3, 0.083333333333333
27873, 1.9916666666667, 0.25, 0.083333333333333
27874, 1.9916666666667, 0.2, 0.083333333333333
27875, 2.0333333333333, 1.3, 0.083333333333333
27876, 2.0333333333333, 1.25, 0.083333333333333
27877, 2.0333333333333, 1.2, 0.083333333333333
27878, 2.0333333333333, 1.15, 0.083333333333333
27879, 2.0333333333333, 1.1, 0.083333333333333
27880, 2.0333333333333, 1.05, 0.083333333333333
27881, 2.0333333333333, 1, 0.083333333333333
27882, 2.0333333333333, 0.95, 0.083333333333333
27883, 2.0333333333333, 0.9, 0.083333333333333
27884, 2.0333333333333, 0.85, 0.083333333333333
27885, 2.0333333333333, 0.8, 0.083333333333333
27886, 2.0333333333333, 0.75, 0.083333333333333
27887, 2.0333333333333, 0.7, 0.083333333333333
27888, 2.0333333333333, 0.65, 0.083333333333333
27889, 2.0333333333333, 0.6, 0.083333333333333
27890, 2.0333333333333, 0.55, 0.083333333333333
27891, 2.0333333333333, 0.5, 0.083333333333333
27892, 2.0333333333333, 0.45, 0.083333333333333
27893, 2.0333333333333, 0.4, 0.083333333333333
27894, 2.0333333333333, 0.35, 0.083333333333333
27895, 2.0333333333333, 0.3, 0.083333333333333
27896, 2.0333333333333, 0.25, 0.083333333333333
27897, 2.0333333333333, 0.2, 0.083333333333333
27898, 2.075, 1.3, 0.083333333333333
27899, 2.075, 1.25, 0.083333333333333
27900, 2.075, 1.2, 0.083333333333333
27901, 2.075, 1.15, 0.083333333333333
27902, 2.075, 1.1, 0.083333333333333
27903, 2.075, 1.05, 0.083333333333333
27904, 2.075, 1, 0.083333333333333
27905, 2.075, 0.95, 0.083333333333333
27906, 2.075, 0.9, 0.083333333333333
27907, 2.075, 0.85, 0.083333333333333
27908, 2.075, 0.8, 0.083333333333333
27909, 2.075, 0.75, 0.083333333333333
27910, 2.075, 0.7, 0.083333333333333
27911, 2.075, 0.65, 0.083333333333333
27912, 2.075, 0.6, 0.083333333333333
27913, 2.075, 0.55, 0.083333333333333
27914, 2.075, 0.5, 0.083333333333333
27915, 2.075, 0.45, 0.083333333333333
27916, 2.075, 0.4, 0.083333333333333
27917, 2.075, 0.35, 0.083333333333333
27918, 2.075, 0.3, 0.083333333333333
27919, 2.075, 0.25, 0.083333333333333
27920, 2.075, 0.2, 0.083333333333333
27921, 2.1166666666667, 1.3, 0.083333333333333
27922, 2.1166666666667, 1.25, 0.083333333333333
27923, 2.1166666666667, 1.2, 0.083333333333333
27924, 2.1166666666667, 1.15, 0.083333333333333
27925, 2.1166666666667, 1.1, 0.083333333333333
27926, 2.1166666666667, 1.05, 0.083333333333333
27927, 2.1166666666667, 1, 0.083333333333333
27928, 2.1166666666667, 0.95, 0.083333333333333
27929, 2.1166666666667, 0.9, 0.083333333333333
27930, 2.1166666666667, 0.85, 0.083333333333333
27931, 2.1166666666667, 0.8, 0.083333333333333
27932, 2.1166666666667, 0.75, 0.083333333333333
27933, 2.1166666666667, 0.7, 0.083333333333333
27934, 2.1166666666667, 0.65, 0.083333333333333
27935, 2.1166666666667, 0.6, 0.083333333333333
27936, 2.1166666666667, 0.55, 0.083333333333333
27937, 2.1166666666667, 0.5, 0.083333333333333
27938, 2.1166666666667, 0.45, 0.083333333333333
27939, 2.1166666666667, 0.4, 0.083333333333333
27940, 2.1166666666667, 0.35, 0.083333333333333
27941, 2.1166666666667, 0.3, 0.083333333333333
27942, 2.1166666666667, 0.25, 0.083333333333333
27943, 2.1166666666667, 0.2, 0.083333333333333
27944, 2.1583333333333, 1.3, 0.083333333333333
27945, 2.1583333333333, 1.25, 0.083333333333333
27946, 2.1583333333333, 1.2, 0.083333333333333
27947, 2.1583333333333, 1.15, 0.083333333333333
27948, 2.1583333333333, 1.1, 0.083333333333333
27949, 2.1583333333333, 1.05, 0.083333333333333
27950, 2.1583333333333, 1, 0.083333333333333
27951, 2.1583333333333, 0.95, 0.083333333333333
27952, 2.1583333333333, 0.9, 0.083333333333333
27953, 2.1583333333333, 0.85, 0.083333333333333
27954, 2.1583333333333, 0.8, 0.083333333333333
27955, 2.1583333333333, 0.75, 0.083333333333333
27956, 2.1583333333333, 0.7, 0.083333333333333
27957, 2.1583333333333, 0.65, 0.083333333333333
27958, 2.1583333333333, 0.6, 0.083333333333333
27959, 2.1583333333333, 0.55, 0.083333333333333
27960, 2.1583333333333, 0.5, 0.083333333333333
27961, 2.1583333333333, 0.45, 0.083333333333333
27962, 2.1583333333333, 0.4, 0.083333333333333
27963, 2.1583333333333, 0.35, 0.083333333333333
27964, 2.1583333333333, 0.3, 0.083333333333333
27965, 2.1583333333333, 0.25, 0.083333333333333
27966, 2.1583333333333, 0.2, 0.083333333333333
27967, 1.2416666666667, 1.3, 0.125
27968, 1.2416666666667, 1.25, 0.125
27969, 1.2416666666667, 1.2, 0.125
27970, 1.2416666666667, 1.15, 0.125
27971, 1.2416666666667, 1.1, 0.125
27972, 1.2416666666667, 1.05, 0.125
27973, 1.2416666666667, 1, 0.125
27974, 1.2416666666667, 0.95, 0.125
27975, 1.2416666666667, 0.9, 0.125
27976, 1.2416666666667, 0.85, 0.125
27977, 1.2416666666667, 0.8, 0.125
27978, 1.2416666666667, 0.75, 0.125
27979, 1.2416666666667, 0.7, 0.125
27980, 1.2416666666667, 0.65, 0.125
27981, 1.2416666666667, 0.6, 0.125
27982, 1.2416666666667, 0.55, 0.125
27983, 1.2416666666667, 0.5, 0.125
27984, 1.2416666666667, 0.45, 0.125
27985, 1.2416666666667, 0.4, 0.125
27986, 1.2416666666667, 0.35, 0.125
27987, 1.2416666666667, 0.3, 0.125
27988, 1.2416666666667, 0.25, 0.125
27989, 1.2416666666667, 0.2, 0.125
27990, 1.2833333333333, 1.3, 0.125
27991, 1.2833333333333, 1.25, 0.125
27992, 1.2833333333333, 1.2, 0.125
27993, 1.2833333333333, 1.15, 0.125
27994, 1.2833333333333, 1.1, 0.125
27995, 1.2833333333333, 1.05, 0.125
27996, 1.2833333333333, 1, 0.125
27997, 1.2833333333333, 0.95, 0.125
27998, 1.2833333333333, 0.9, 0.125
27999, 1.2833333333333, 0.85, 0.125
28000, 1.2833333333333, 0.8, 0.125
28001, 1.2833333333333, 0.75, 0.125
28002, 1.2833333333333, 0.7, 0.125
28003, 1.2833333333333, 0.65, 0.125
28004, 1.2833333333333, 0.6, 0.125
28005, 1.2833333333333, 0.55, 0.125
28006, 1.2833333333333, 0.5, 0.125
28007, 1.2833333333333, 0.45, 0.125
28008, 1.2833333333333, 0.4, 0.125
28009, 1.2833333333333, 0.35, 0.125
28010, 1.2833333333333, 0.3, 0.125
28011, 1.2833333333333, 0.25, 0.125
28012, 1.2833333333333, 0.2, 0.125
28013, 1.325, 1.3, 0.125
28014, 1.325, 1.25, 0.125
28015, 1.325, 1.2, 0.125
28016, 1.325, 1.15, 0.125
28017, 1.325, 1.1, 0.125
28018, 1.325, 1.05, 0.125
28019, 1.325, 1, 0.125
28020, 1.325, 0.95, 0.125
28021, 1.325, 0.9, 0.125
28022, 1.325, 0.85, 0.125
28023, 1.325, 0.8, 0.125
28024, 1.325, 0.75, 0.125
28025, 1.325, 0.7, 0.125
28026, 1.325, 0.65, 0.125
28027, 1.325, 0.6, 0.125
28028, 1.325, 0.55, 0.125
28029, 1.325, 0.5, 0.125
28030, 1.325, 0.45, 0.125
28031, 1.325, 0.4, 0.125
28032, 1.325, 0.35, 0.125
28033, 1.325, 0.3, 0.125
28034, 1.325, 0.25, 0.125
28035, 1.325, 0.2, 0.125
28036, 1.3666666666667, 1.3, 0.125
28037, 1.3666666666667, 1.25, 0.125
28038, 1.3666666666667, 1.2, 0.125
28039, 1.3666666666667, 1.15, 0.125
28040, 1.3666666666667, 1.1, 0.125
28041, 1.3666666666667, 1.05, 0.125
28042, 1.3666666666667, 1, 0.125
28043, 1.3666666666667, 0.95, 0.125
28044, 1.3666666666667, 0.9, 0.125
28045, 1.3666666666667, 0.85, 0.125
28046, 1.3666666666667, 0.8, 0.125
28047, 1.3666666666667, 0.75, 0.125
28048, 1.3666666666667, 0.7, 0.125
28049, 1.3666666666667, 0.65, 0.125
28050, 1.3666666666667, 0.6, 0.125
28051, 1.3666666666667, 0.55, 0.125
28052, 1.3666666666667, 0.5, 0.125
28053, 1.3666666666667, 0.45, 0.125
28054, 1.3666666666667, 0.4, 0.125
28055, 1.3666666666667, 0.35, 0.125
28056, 1.3666666666667, 0.3, 0.125
28057, 1.3666666666667, 0.25, 0.125
28058, 1.3666666666667, 0.2, 0.125
28059, 1.4083333333333, 1.3, 0.125
28060, 1.4083333333333, 1.25, 0.125
28061, 1.4083333333333, 1.2, 0.125
28062, 1.4083333333333, 1.15, 0.125
28063, 1.4083333333333, 1.1, 0.125
28064, 1.4083333333333, 1.05, 0.125
28065, 1.4083333333333, 1, 0.125
28066, 1.4083333333333, 0.95, 0.125
28067, 1.4083333333333, 0.9, 0.125
28068, 1.4083333333333, 0.85, 0.125
28069, 1.4083333333333, 0.8, 0.125
28070, 1.4083333333333, 0.75, 0.125
28071, 1.4083333333333, 0.7, 0.125
28072, 1.4083333333333, 0.65, 0.125
28073, 1.4083333333333, 0.6, 0.125
28074, 1.4083333333333, 0.55, 0.125
28075, 1.4083333333333, 0.5, 0.125
28076, 1.4083333333333, 0.45, 0.125
28077, 1.4083333333333, 0.4, 0.125
28078, 1.4083333333333, 0.35, 0.125
28079, 1.4083333333333, 0.3, 0.125
28080, 1.4083333333333, 0.25, 0.125
28081, 1.4083333333333, 0.2, 0.125
28082, 1.45, 1.3, 0.125
28083, 1.45, 1.25, 0.125
28084, 1.45, 1.2, 0.125
28085, 1.45, 1.15, 0.125
28086, 1.45, 1.1, 0.125
28087, 1.45, 1.05, 0.125
28088, 1.45, 1, 0.125
28089, 1.45, 0.95, 0.125
28090, 1.45, 0.9, 0.125
28091, 1.45, 0.85, 0.125
28092, 1.45, 0.8, 0.125
28093, 1.45, 0.75, 0.125
28094, 1.45, 0.7, 0.125
28095, 1.45, 0.65, 0.125
28096, 1.45, 0.6, 0.125
28097, 1.45, 0.55, 0.125
28098, 1.45, 0.5, 0.125
28099, 1.45, 0.45, 0.125
28100, 1.45, 0.4, 0.125
28101, 1.45, 0.35, 0.125
28102, 1.45, 0.3, 0.125
28103, 1.45, 0.25, 0.125
28104, 1.45, 0.2, 0.125
28105, 1.4916666666667, 1.3, 0.125
28106, 1.4916666666667, 1.25, 0.125
28107, 1.4916666666667, 1.2, 0.125
28108, 1.4916666666667, 1.15, 0.125
28109, 1.4916666666667, 1.1, 0.125
28110, 1.4916666666667, 1.05, 0.125
28111, 1.4916666666667, 1, 0.125
28112, 1.4916666666667, 0.95, 0.125
28113, 1.4916666666667, 0.9, 0.125
28114, 1.4916666666667, 0.85, 0.125
28115, 1.4916666666667, 0.8, 0.125
28116, 1.4916666666667, 0.75, 0.125
28117, 1.4916666666667, 0.7, 0.125
28118, 1.4916666666667, 0.65, 0.125
28119, 1.4916666666667, 0.6, 0.125
28120, 1.4916666666667, 0.55, 0.125
28121, 1.4916666666667, 0.5, 0.125
28122, 1.4916666666667, 0.45, 0.125
28123, 1.4916666666667, 0.4, 0.125
28124, 1.4916666666667, 0.35, 0.125
28125, 1.4916666666667, 0.3, 0.125
28126, 1.4916666666667, 0.25, 0.125
28127, 1.4916666666667, 0.2, 0.125
28128, 1.5333333333333, 1.3, 0.125
28129, 1.5333333333333, 1.25, 0.125
28130, 1.5333333333333, 1.2, 0.125
28131, 1.5333333333333, 1.15, 0.125
28132, 1.5333333333333, 1.1, 0.125
28133, 1.5333333333333, 1.05, 0.125
28134, 1.5333333333333, 1, 0.125
28135, 1.5333333333333, 0.95, 0.125
28136, 1.5333333333333, 0.9, 0.125
28137, 1.5333333333333, 0.85, 0.125
28138, 1.5333333333333, 0.8, 0.125
28139, 1.5333333333333, 0.75, 0.125
28140, 1.5333333333333, 0.7, 0.125
28141, 1.5333333333333, 0.65, 0.125
28142, 1.5333333333333, 0.6, 0.125
28143, 1.5333333333333, 0.55, 0.125
28144, 1.5333333333333, 0.5, 0.125
28145, 1.5333333333333, 0.45, 0.125
28146, 1.5333333333333, 0.4, 0.125
28147, 1.5333333333333, 0.35, 0.125
28148, 1.5333333333333, 0.3, 0.125
28149, 1.5333333333333, 0.25, 0.125
28150, 1.5333333333333, 0.2, 0.125
28151, 1.575, 1.3, 0.125
28152, 1.575, 1.25, 0.125
28153, 1.575, 1.2, 0.125
28154, 1.575, 1.15, 0.125
28155, 1.575, 1.1, 0.125
28156, 1.575, 1.05, 0.125
28157, 1.575, 1, 0.125
28158, 1.575, 0.95, 0.125
28159, 1.575, 0.9, 0.125
28160, 1.575, 0.85, 0.125
28161, 1.575, 0.8, 0.125
28162, 1.575, 0.75, 0.125
28163, 1.575, 0.7, 0.125
28164, 1.575, 0.65, 0.125
28165, 1.575, 0.6, 0.125
28166, 1.575, 0.55, 0.125
28167, 1.575, 0.5, 0.125
28168, 1.575, 0.45, 0.125
28169, 1.575, 0.4, 0.125
28170, 1.575, 0.35, 0.125
28171, 1.575, 0.3, 0.125
28172, 1.575, 0.25, 0.125
28173, 1.575, 0.2, 0.125
28174, 1.6166666666667, 1.3, 0.125
28175, 1.6166666666667, 1.25, 0.125
28176, 1.6166666666667, 1.2, 0.125
28177, 1.6166666666667, 1.15, 0.125
28178, 1.6166666666667, 1.1, 0.125
28179, 1.6166666666667, 1.05, 0.125
28180, 1.6166666666667, 1, 0.125
28181, 1.6166666666667, 0.95, 0.125
28182, 1.6166666666667, 0.9, 0.125
28183, 1.6166666666667, 0.85, 0.125
28184, 1.6166666666667, 0.8, 0.125
28185, 1.6166666666667, 0.75, 0.125
28186, 1.6166666666667, 0.7, 0.125
28187, 1.6166666666667, 0.65, 0.125
28188, 1.6166666666667, 0.6, 0.125
28189, 1.6166666666667, 0.55, 0.125
28190, 1.6166666666667, 0.5, 0.125
28191, 1.6166666666667, 0.45, 0.125
28192, 1.6166666666667, 0.4, 0.125
28193, 1.6166666666667, 0.35, 0.125
28194, 1.6166666666667, 0.3, 0.125
28195, 1.6166666666667, 0.25, 0.125
28196, 1.6166666666667, 0.2, 0.125
28197, 1.6583333333333, 1.3, 0.125
28198, 1.6583333333333, 1.25, 0.125
28199, 1.6583333333333, 1.2, 0.125
28200, 1.6583333333333, 1.15, 0.125
28201, 1.6583333333333, 1.1, 0.125
28202, 1.6583333333333, 1.05, 0.125
28203, 1.6583333333333, 1, 0.125
28204, 1.6583333333333, 0.95, 0.125
28205, 1.6583333333333, 0.9, 0.125
28206, 1.6583333333333, 0.85, 0.125
28207, 1.6583333333333, 0.8, 0.125
28208, 1.6583333333333, 0.75, 0.125
28209, 1.6583333333333, 0.7, 0.125
28210, 1.6583333333333, 0.65, 0.125
28211, 1.6583333333333, 0.6, 0.125
28212, 1.6583333333333, 0.55, 0.125
28213, 1.6583333333333, 0.5, 0.125
28214, 1.6583333333333, 0.45, 0.125
28215, 1.6583333333333, 0.4, 0.125
28216, 1.6583333333333, 0.35, 0.125
28217, 1.6583333333333, 0.3, 0.125
28218, 1.6583333333333, 0.25, 0.125
28219, 1.6583333333333, 0.2, 0.125
28220, 1.7, 1.3, 0.125
28221, 1.7, 1.25, 0.125
28222, 1.7, 1.2, 0.125
28223, 1.7, 1.15, 0.125
28224, 1.7, 1.1, 0.125
28225, 1.7, 1.05, 0.125
28226, 1.7, 1, 0.125
28227, 1.7, 0.95, 0.125
28228, 1.7, 0.9, 0.125
28229, 1.7, 0.85, 0.125
28230, 1.7, 0.8, 0.125
28231, 1.7, 0.75, 0.125
28232, 1.7, 0.7, 0.125
28233, 1.7, 0.65, 0.125
28234, 1.7, 0.6, 0.125
28235, 1.7, 0.55, 0.125
28236, 1.7, 0.5, 0.125
28237, 1.7, 0.45, 0.125
28238, 1.7, 0.4, 0.125
28239, 1.7, 0.35, 0.125
28240, 1.7, 0.3, 0.125
28241, 1.7, 0.25, 0.125
28242, 1.7, 0.2, 0.125
28243, 1.7416666666667, 1.3, 0.125
28244, 1.7416666666667, 1.25, 0.125
28245, 1.7416666666667, 1.2, 0.125
28246, 1.7416666666667, 1.15, 0.125
28247, 1.7416666666667, 1.1, 0.125
28248, 1.7416666666667, 1.05, 0.125
28249, 1.7416666666667, 1, 0.125
28250, 1.7416666666667, 0.95, 0.125
28251, 1.7416666666667, 0.9, 0.125
28252, 1.7416666666667, 0.85, 0.125
28253, 1.7416666666667, 0.8, 0.125
28254, 1.7416666666667, 0.75, 0.125
28255, 1.7416666666667, 0.7, 0.125
28256, 1.7416666666667, 0.65, 0.125
28257, 1.7416666666667, 0.6, 0.125
28258, 1.7416666666667, 0.55, 0.125
28259, 1.7416666666667, 0.5, 0.125
28260, 1.7416666666667, 0.45, 0.125
28261, 1.7416666666667, 0.4, 0.125
28262, 1.7416666666667, 0.35, 0.125
28263, 1.7416666666667, 0.3, 0.125
28264, 1.7416666666667, 0.25, 0.125
28265, 1.7416666666667, 0.2, 0.125
28266, 1.7833333333333, 1.3, 0.125
28267, 1.7833333333333, 1.25, 0.125
28268, 1.7833333333333, 1.2, 0.125
28269, 1.7833333333333, 1.15, 0.125
28270, 1.7833333333333, 1.1, 0.125
28271, 1.7833333333333, 1.05, 0.125
28272, 1.7833333333333, 1, 0.125
28273, 1.7833333333333, 0.95, 0.125
28274, 1.7833333333333, 0.9, 0.125
28275, 1.7833333333333, 0.85, 0.125
28276, 1.7833333333333, 0.8, 0.125
28277, 1.7833333333333, 0.75, 0.125
28278, 1.7833333333333, 0.7, 0.125
28279, 1.7833333333333, 0.65, 0.125
28280, 1.7833333333333, 0.6, 0.125
28281, 1.7833333333333, 0.55, 0.125
28282, 1.7833333333333, 0.5, 0.125
28283, 1.7833333333333, 0.45, 0.125
28284, 1.7833333333333, 0.4, 0.125
28285, 1.7833333333333, 0.35, 0.125
28286, 1.7833333333333, 0.3, 0.125
28287, 1.7833333333333, 0.25, 0.125
28288, 1.7833333333333, 0.2, 0.125
28289, 1.825, 1.3, 0.125
28290, 1.825, 1.25, 0.125
28291, 1.825, 1.2, 0.125
28292, 1.825, 1.15, 0.125
28293, 1.825, 1.1, 0.125
28294, 1.825, 1.05, 0.125
28295, 1.825, 1, 0.125
28296, 1.825, 0.95, 0.125
28297, 1.825, 0.9, 0.125
28298, 1.825, 0.85, 0.125
28299, 1.825, 0.8, 0.125
28300, 1.825, 0.75, 0.125
28301, 1.825, 0.7, 0.125
28302, 1.825, 0.65, 0.125
28303, 1.825, 0.6, 0.125
28304, 1.825, 0.55, 0.125
28305, 1.825, 0.5, 0.125
28306, 1.825, 0.45, 0.125
28307, 1.825, 0.4, 0.125
28308, 1.825, 0.35, 0.125
28309, 1.825, 0.3, 0.125
28310, 1.825, 0.25, 0.125
28311, 1.825, 0.2, 0.125
28312, 1.8666666666667, 1.3, 0.125
28313, 1.8666666666667, 1.25, 0.125
28314, 1.8666666666667, 1.2, 0.125
28315, 1.8666666666667, 1.15, 0.125
28316, 1.8666666666667, 1.1, 0.125
28317, 1.8666666666667, 1.05, 0.125
28318, 1.8666666666667, 1, 0.125
28319, 1.8666666666667, 0.95, 0.125
28320, 1.8666666666667, 0.9, 0.125
28321, 1.8666666666667, 0.85, 0.125
28322, 1.8666666666667, 0.8, 0.125
28323, 1.8666666666667, 0.75, 0.125
28324, 1.8666666666667, 0.7, 0.125
28325, 1.8666666666667, 0.65, 0.125
28326, 1.8666666666667, 0.6, 0.125
28327, 1.8666666666667, 0.55, 0.125
28328, 1.8666666666667, 0.5, 0.125
28329, 1.8666666666667, 0.45, 0.125
28330, 1.8666666666667, 0.4, 0.125
28331, 1.8666666666667, 0.35, 0.125
28332, 1.8666666666667, 0.3, 0.125
28333, 1.8666666666667, 0.25, 0.125
28334, 1.8666666666667, 0.2, 0.125
28335, 1.9083333333333, 1.3, 0.125
28336, 1.9083333333333, 1.25, 0.125
28337, 1.9083333333333, 1.2, 0.125
28338, 1.9083333333333, 1.15, 0.125
28339, 1.9083333333333, 1.1, 0.125
28340, 1.9083333333333, 1.05, 0.125
28341, 1.9083333333333, 1, 0.125
28342, 1.9083333333333, 0.95, 0.125
28343, 1.9083333333333, 0.9, 0.125
28344, 1.9083333333333, 0.85, 0.125
28345, 1.9083333333333, 0.8, 0.125
28346, 1.9083333333333, 0.75, 0.125
28347, 1.9083333333333, 0.7, 0.125
28348, 1.9083333333333, 0.65, 0.125
28349, 1.9083333333333, 0.6, 0.125
28350, 1.9083333333333, 0.55, 0.125
28351, 1.9083333333333, 0.5, 0.125
28352, 1.9083333333333, 0.45, 0.125
28353, 1.9083333333333, 0.4, 0.125
28354, 1.9083333333333, 0.35, 0.125
28355, 1.9083333333333, 0.3, 0.125
28356, 1.9083333333333, 0.25, 0.125
28357, 1.9083333333333, 0.2, 0.125
28358, 1.95, 1.3, 0.125
28359, 1.95, 1.25, 0.125
28360, 1.95, 1.2, 0.125
28361, 1.95, 1.15, 0.125
28362, 1.95, 1.1, 0.125
28363, 1.95, 1.05, 0.125
28364, 1.95, 1, 0.125
28365, 1.95, 0.95, 0.125
28366, 1.95, 0.9, 0.125
28367, 1.95, 0.85, 0.125
28368, 1.95, 0.8, 0.125
28369, 1.95, 0.75, 0.125
28370, 1.95, 0.7, 0.125
28371, 1.95, 0.65, 0.125
28372, 1.95, 0.6, 0.125
28373, 1.95, 0.55, 0.125
28374, 1.95, 0.5, 0.125
28375, 1.95, 0.45, 0.125
28376, 1.95, 0.4, 0.125
28377, 1.95, 0.35, 0.125
28378, 1.95, 0.3, 0.125
28379, 1.95, 0.25, 0.125
28380, 1.95, 0.2, 0.125
28381, 1.9916666666667, 1.3, 0.125
28382, 1.9916666666667, 1.25, 0.125
28383, 1.9916666666667, 1.2, 0.125
28384, 1.9916666666667, 1.15, 0.125
28385, 1.9916666666667, 1.1, 0.125
28386, 1.9916666666667, 1.05, 0.125
28387, 1.9916666666667, 1, 0.125
28388, 1.9916666666667, 0.95, 0.125
28389, 1.9916666666667, 0.9, 0.125
28390, 1.9916666666667, 0.85, 0.125
28391, 1.9916666666667, 0.8, 0.125
28392, 1.9916666666667, 0.75, 0.125
28393, 1.9916666666667, 0.7, 0.125
28394, 1.9916666666667, 0.65, 0.125
28395, 1.9916666666667, 0.6, 0.125
28396, 1.9916666666667, 0.55, 0.125
28397, 1.9916666666667, 0.5, 0.125
28398, 1.9916666666667, 0.45, 0.125
28399, 1.9916666666667, 0.4, 0.125
28400, 1.9916666666667, 0.35, 0.125
28401, 1.9916666666667, 0.3, 0.125
28402, 1.9916666666667, 0.25, 0.125
28403, 1.9916666666667, 0.2, 0.125
28404, 2.0333333333333, 1.3, 0.125
28405, 2.0333333333333, 1.25, 0.125
28406, 2.0333333333333, 1.2, 0.125
28407, 2.0333333333333, 1.15, 0.125
28408, 2.0333333333333, 1.1, 0.125
28409, 2.0333333333333, 1.05, 0.125
28410, 2.0333333333333, 1, 0.125
28411, 2.0333333333333, 0.95, 0.125
28412, 2.0333333333333, 0.9, 0.125
28413, 2.0333333333333, 0.85, 0.125
28414, 2.0333333333333, 0.8, 0.125
28415, 2.0333333333333, 0.75, 0.125
28416, 2.0333333333333, 0.7, 0.125
28417, 2.0333333333333, 0.65, 0.125
28418, 2.0333333333333, 0.6, 0.125
28419, 2.0333333333333, 0.55, 0.125
28420, 2.0333333333333, 0.5, 0.125
28421, 2.0333333333333, 0.45, 0.125
28422, 2.0333333333333, 0.4, 0.125
28423, 2.0333333333333, 0.35, 0.125
28424, 2.0333333333333, 0.3, 0.125
28425, 2.0333333333333, 0.25, 0.125
28426, 2.0333333333333, 0.2, 0.125
28427, 2.075, 1.3, 0.125
28428, 2.075, 1.25, 0.125
28429, 2.075, 1.2, 0.125
28430, 2.075, 1.15, 0.125
28431, 2.075, 1.1, 0.125
28432, 2.075, 1.05, 0.125
28433, 2.075, 1, 0.125
28434, 2.075, 0.95, 0.125
28435, 2.075, 0.9, 0.125
28436, 2.075, 0.85, 0.125
28437, 2.075, 0.8, 0.125
28438, 2.075, 0.75, 0.125
28439, 2.075, 0.7, 0.125
28440, 2.075, 0.65, 0.125
28441, 2.075, 0.6, 0.125
28442, 2.075, 0.55, 0.125
28443, 2.075, 0.5, 0.125
28444, 2.075, 0.45, 0.125
28445, 2.075, 0.4, 0.125
28446, 2.075, 0.35, 0.125
28447, 2.075, 0.3, 0.125
28448, 2.075, 0.25, 0.125
28449, 2.075, 0.2, 0.125
28450, 2.1166666666667, 1.3, 0.125
28451, 2.1166666666667, 1.25, 0.125
28452, 2.1166666666667, 1.2, 0.125
28453, 2.1166666666667, 1.15, 0.125
28454, 2.1166666666667, 1.1, 0.125
28455, 2.1166666666667, 1.05, 0.125
28456, 2.1166666666667, 1, 0.125
28457, 2.1166666666667, 0.95, 0.125
28458, 2.1166666666667, 0.9, 0.125
28459, 2.1166666666667, 0.85, 0.125
28460, 2.1166666666667, 0.8, 0.125
28461, 2.1166666666667, 0.75, 0.125
28462, 2.1166666666667, 0.7, 0.125
28463, 2.1166666666667, 0.65, 0.125
28464, 2.1166666666667, 0.6, 0.125
28465, 2.1166666666667, 0.55, 0.125
28466, 2.1166666666667, 0.5, 0.125
28467, 2.1166666666667, 0.45, 0.125
28468, 2.1166666666667, 0.4, 0.125
28469, 2.1166666666667, 0.35, 0.125
28470, 2.1166666666667, 0.3, 0.125
28471, 2.1166666666667, 0.25, 0.125
28472, 2.1166666666667, 0.2, 0.125
28473, 2.1583333333333, 1.3, 0.125
28474, 2.1583333333333, 1.25, 0.125
28475, 2.1583333333333, 1.2, 0.125
28476, 2.1583333333333, 1.15, 0.125
28477, 2.1583333333333, 1.1, 0.125
28478, 2.1583333333333, 1.05, 0.125
28479, 2.1583333333333, 1, 0.125
28480, 2.1583333333333, 0.95, 0.125
28481, 2.1583333333333, 0.9, 0.125
28482, 2.1583333333333, 0.85, 0.125
28483, 2.1583333333333, 0.8, 0.125
28484, 2.1583333333333, 0.75, 0.125
28485, 2.1583333333333, 0.7, 0.125
28486, 2.1583333333333, 0.65, 0.125
28487, 2.1583333333333, 0.6, 0.125
28488, 2.1583333333333, 0.55, 0.125
28489, 2.1583333333333, 0.5, 0.125
28490, 2.1583333333333, 0.45, 0.125
28491, 2.1583333333333, 0.4, 0.125
28492, 2.1583333333333, 0.35, 0.125
28493, 2.1583333333333, 0.3, 0.125
28494, 2.1583333333333, 0.25, 0.125
28495, 2.1583333333333, 0.2, 0.125
28496, 1.2416666666667, 1.3, 0.16666666666667
28497, 1.2416666666667, 1.25, 0.16666666666667
28498, 1.2416666666667, 1.2, 0.16666666666667
28499, 1.2416666666667, 1.15, 0.16666666666667
28500, 1.2416666666667, 1.1, 0.16666666666667
28501, 1.2416666666667, 1.05, 0.16666666666667
28502, 1.2416666666667, 1, 0.16666666666667
28503, 1.2416666666667, 0.95, 0.16666666666667
28504, 1.2416666666667, 0.9, 0.16666666666667
28505, 1.2416666666667, 0.85, 0.16666666666667
28506, 1.2416666666667, 0.8, 0.16666666666667
28507, 1.2416666666667, 0.75, 0.16666666666667
28508, 1.2416666666667, 0.7, 0.16666666666667
28509, 1.2416666666667, 0.65, 0.16666666666667
28510, 1.2416666666667, 0.6, 0.16666666666667
28511, 1.2416666666667, 0.55, 0.16666666666667
28512, 1.2416666666667, 0.5, 0.16666666666667
28513, 1.2416666666667, 0.45, 0.16666666666667
28514, 1.2416666666667, 0.4, 0.16666666666667
28515, 1.2416666666667, 0.35, 0.16666666666667
28516, 1.2416666666667, 0.3, 0.16666666666667
28517, 1.2416666666667, 0.25, 0.16666666666667
28518, 1.2416666666667, 0.2, 0.16666666666667
28519, 1.2833333333333, 1.3, 0.16666666666667
28520, 1.2833333333333, 1.25, 0.16666666666667
28521, 1.2833333333333, 1.2, 0.16666666666667
28522, 1.2833333333333, 1.15, 0.16666666666667
28523, 1.2833333333333, 1.1, 0.16666666666667
28524, 1.2833333333333, 1.05, 0.16666666666667
28525, 1.2833333333333, 1, 0.16666666666667
28526, 1.2833333333333, 0.95, 0.16666666666667
28527, 1.2833333333333, 0.9, 0.16666666666667
28528, 1.2833333333333, 0.85, 0.16666666666667
28529, 1.2833333333333, 0.8, 0.16666666666667
28530, 1.2833333333333, 0.75, 0.16666666666667
28531, 1.2833333333333, 0.7, 0.16666666666667
28532, 1.2833333333333, 0.65, 0.16666666666667
28533, 1.2833333333333, 0.6, 0.16666666666667
28534, 1.2833333333333, 0.55, 0.16666666666667
28535, 1.2833333333333, 0.5, 0.16666666666667
28536, 1.2833333333333, 0.45, 0.16666666666667
28537, 1.2833333333333, 0.4, 0.16666666666667
28538, 1.2833333333333, 0.35, 0.16666666666667
28539, 1.2833333333333, 0.3, 0.16666666666667
28540, 1.2833333333333, 0.25, 0.16666666666667
28541, 1.2833333333333, 0.2, 0.16666666666667
28542, 1.325, 1.3, 0.16666666666667
28543, 1.325, 1.25, 0.16666666666667
28544, 1.325, 1.2, 0.16666666666667
28545, 1.325, 1.15, 0.16666666666667
28546, 1.325, 1.1, 0.16666666666667
28547, 1.325, 1.05, 0.16666666666667
28548, 1.325, 1, 0.16666666666667
28549, 1.325, 0.95, 0.16666666666667
28550, 1.325, 0.9, 0.16666666666667
28551, 1.325, 0.85, 0.16666666666667
28552, 1.325, 0.8, 0.16666666666667
28553, 1.325, 0.75, 0.16666666666667
28554, 1.325, 0.7, 0.16666666666667
28555, 1.325, 0.65, 0.16666666666667
28556, 1.325, 0.6, 0.16666666666667
28557, 1.325, 0.55, 0.16666666666667
28558, 1.325, 0.5, 0.16666666666667
28559, 1.325, 0.45, 0.16666666666667
28560, 1.325, 0.4, 0.16666666666667
28561, 1.325, 0.35, 0.16666666666667
28562, 1.325, 0.3, 0.16666666666667
28563, 1.325, 0.25, 0.16666666666667
28564, 1.325, 0.2, 0.16666666666667
28565, 1.3666666666667, 1.3, 0.16666666666667
28566, 1.3666666666667, 1.25, 0.16666666666667
28567, 1.3666666666667, 1.2, 0.16666666666667
28568, 1.3666666666667, 1.15, 0.16666666666667
28569, 1.3666666666667, 1.1, 0.16666666666667
28570, 1.3666666666667, 1.05, 0.16666666666667
28571, 1.3666666666667, 1, 0.16666666666667
28572, 1.3666666666667, 0.95, 0.16666666666667
28573, 1.3666666666667, 0.9, 0.16666666666667
28574, 1.3666666666667, 0.85, 0.16666666666667
28575, 1.3666666666667, 0.8, 0.16666666666667
28576, 1.3666666666667, 0.75, 0.16666666666667
28577, 1.3666666666667, 0.7, 0.16666666666667
28578, 1.3666666666667, 0.65, 0.16666666666667
28579, 1.3666666666667, 0.6, 0.16666666666667
28580, 1.3666666666667, 0.55, 0.16666666666667
28581, 1.3666666666667, 0.5, 0.16666666666667
28582, 1.3666666666667, 0.45, 0.16666666666667
28583, 1.3666666666667, 0.4, 0.16666666666667
28584, 1.3666666666667, 0.35, 0.16666666666667
28585, 1.3666666666667, 0.3, 0.16666666666667
28586, 1.3666666666667, 0.25, 0.16666666666667
28587, 1.3666666666667, 0.2, 0.16666666666667
28588, 1.4083333333333, 1.3, 0.16666666666667
28589, 1.4083333333333, 1.25, 0.16666666666667
28590, 1.4083333333333, 1.2, 0.16666666666667
28591, 1.4083333333333, 1.15, 0.16666666666667
28592, 1.4083333333333, 1.1, 0.16666666666667
28593, 1.4083333333333, 1.05, 0.16666666666667
28594, 1.4083333333333, 1, 0.16666666666667
28595, 1.4083333333333, 0.95, 0.16666666666667
28596, 1.4083333333333, 0.9, 0.16666666666667
28597, 1.4083333333333, 0.85, 0.16666666666667
28598, 1.4083333333333, 0.8, 0.16666666666667
28599, 1.4083333333333, 0.75, 0.16666666666667
28600, 1.4083333333333, 0.7, 0.16666666666667
28601, 1.4083333333333, 0.65, 0.16666666666667
28602, 1.4083333333333, 0.6, 0.16666666666667
28603, 1.4083333333333, 0.55, 0.16666666666667
28604, 1.4083333333333, 0.5, 0.16666666666667
28605, 1.4083333333333, 0.45, 0.16666666666667
28606, 1.4083333333333, 0.4, 0.16666666666667
28607, 1.4083333333333, 0.35, 0.16666666666667
28608, 1.4083333333333, 0.3, 0.16666666666667
28609, 1.4083333333333, 0.25, 0.16666666666667
28610, 1.4083333333333, 0.2, 0.16666666666667
28611, 1.45, 1.3, 0.16666666666667
28612, 1.45, 1.25, 0.16666666666667
28613, 1.45, 1.2, 0.16666666666667
28614, 1.45, 1.15, 0.16666666666667
28615, 1.45, 1.1, 0.16666666666667
28616, 1.45, 1.05, 0.16666666666667
28617, 1.45, 1, 0.16666666666667
28618, 1.45, 0.95, 0.16666666666667
28619, 1.45, 0.9, 0.16666666666667
28620, 1.45, 0.85, 0.16666666666667
28621, 1.45, 0.8, 0.16666666666667
28622, 1.45, 0.75, 0.16666666666667
28623, 1.45, 0.7, 0.16666666666667
28624, 1.45, 0.65, 0.16666666666667
28625, 1.45, 0.6, 0.16666666666667
28626, 1.45, 0.55, 0.16666666666667
28627, 1.45, 0.5, 0.16666666666667
28628, 1.45, 0.45, 0.16666666666667
28629, 1.45, 0.4, 0.16666666666667
28630, 1.45, 0.35, 0.16666666666667
28631, 1.45, 0.3, 0.16666666666667
28632, 1.45, 0.25, 0.16666666666667
28633, 1.45, 0.2, 0.16666666666667
28634, 1.4916666666667, 1.3, 0.16666666666667
28635, 1.4916666666667, 1.25, 0.16666666666667
28636, 1.4916666666667, 1.2, 0.16666666666667
28637, 1.4916666666667, 1.15, 0.16666666666667
28638, 1.4916666666667, 1.1, 0.16666666666667
28639, 1.4916666666667, 1.05, 0.16666666666667
28640, 1.4916666666667, 1, 0.16666666666667
28641, 1.4916666666667, 0.95, 0.16666666666667
28642, 1.4916666666667, 0.9, 0.16666666666667
28643, 1.4916666666667, 0.85, 0.16666666666667
28644, 1.4916666666667, 0.8, 0.16666666666667
28645, 1.4916666666667, 0.75, 0.16666666666667
28646, 1.4916666666667, 0.7, 0.16666666666667
28647, 1.4916666666667, 0.65, 0.16666666666667
28648, 1.4916666666667, 0.6, 0.16666666666667
28649, 1.4916666666667, 0.55, 0.16666666666667
28650, 1.4916666666667, 0.5, 0.16666666666667
28651, 1.4916666666667, 0.45, 0.16666666666667
28652, 1.4916666666667, 0.4, 0.16666666666667
28653, 1.4916666666667, 0.35, 0.16666666666667
28654, 1.4916666666667, 0.3, 0.16666666666667
28655, 1.4916666666667, 0.25, 0.16666666666667
28656, 1.4916666666667, 0.2, 0.16666666666667
28657, 1.5333333333333, 1.3, 0.16666666666667
28658, 1.5333333333333, 1.25, 0.16666666666667
28659, 1.5333333333333, 1.2, 0.16666666666667
28660, 1.5333333333333, 1.15, 0.16666666666667
28661, 1.5333333333333, 1.1, 0.16666666666667
28662, 1.5333333333333, 1.05, 0.16666666666667
28663, 1.5333333333333, 1, 0.16666666666667
28664, 1.5333333333333, 0.95, 0.16666666666667
28665, 1.5333333333333, 0.9, 0.16666666666667
28666, 1.5333333333333, 0.85, 0.16666666666667
28667, 1.5333333333333, 0.8, 0.16666666666667
28668, 1.5333333333333, 0.75, 0.16666666666667
28669, 1.5333333333333, 0.7, 0.16666666666667
28670, 1.5333333333333, 0.65, 0.16666666666667
28671, 1.5333333333333, 0.6, 0.16666666666667
28672, 1.5333333333333, 0.55, 0.16666666666667
28673, 1.5333333333333, 0.5, 0.16666666666667
28674, 1.5333333333333, 0.45, 0.16666666666667
28675, 1.5333333333333, 0.4, 0.16666666666667
28676, 1.5333333333333, 0.35, 0.16666666666667
28677, 1.5333333333333, 0.3, 0.16666666666667
28678, 1.5333333333333, 0.25, 0.16666666666667
28679, 1.5333333333333, 0.2, 0.16666666666667
28680, 1.575, 1.3, 0.16666666666667
28681, 1.575, 1.25, 0.16666666666667
28682, 1.575, 1.2, 0.16666666666667
28683, 1.575, 1.15, 0.16666666666667
28684, 1.575, 1.1, 0.16666666666667
28685, 1.575, 1.05, 0.16666666666667
28686, 1.575, 1, 0.16666666666667
28687, 1.575, 0.95, 0.16666666666667
28688, 1.575, 0.9, 0.16666666666667
28689, 1.575, 0.85, 0.16666666666667
28690, 1.575, 0.8, 0.16666666666667
28691, 1.575, 0.75, 0.16666666666667
28692, 1.575, 0.7, 0.16666666666667
28693, 1.575, 0.65, 0.16666666666667
28694, 1.575, 0.6, 0.16666666666667
28695, 1.575, 0.55, 0.16666666666667
28696, 1.575, 0.5, 0.16666666666667
28697, 1.575, 0.45, 0.16666666666667
28698, 1.575, 0.4, 0.16666666666667
28699, 1.575, 0.35, 0.16666666666667
28700, 1.575, 0.3, 0.16666666666667
28701, 1.575, 0.25, 0.16666666666667
28702, 1.575, 0.2, 0.16666666666667
28703, 1.6166666666667, 1.3, 0.16666666666667
28704, 1.6166666666667, 1.25, 0.16666666666667
28705, 1.6166666666667, 1.2, 0.16666666666667
28706, 1.6166666666667, 1.15, 0.16666666666667
28707, 1.6166666666667, 1.1, 0.16666666666667
28708, 1.6166666666667, 1.05, 0.16666666666667
28709, 1.6166666666667, 1, 0.16666666666667
28710, 1.6166666666667, 0.95, 0.16666666666667
28711, 1.6166666666667, 0.9, 0.16666666666667
28712, 1.6166666666667, 0.85, 0.16666666666667
28713, 1.6166666666667, 0.8, 0.16666666666667
28714, 1.6166666666667, 0.75, 0.16666666666667
28715, 1.6166666666667, 0.7, 0.16666666666667
28716, 1.6166666666667, 0.65, 0.16666666666667
28717, 1.6166666666667, 0.6, 0.16666666666667
28718, 1.6166666666667, 0.55, 0.16666666666667
28719, 1.6166666666667, 0.5, 0.16666666666667
28720, 1.6166666666667, 0.45, 0.16666666666667
28721, 1.6166666666667, 0.4, 0.16666666666667
28722, 1.6166666666667, 0.35, 0.16666666666667
28723, 1.6166666666667, 0.3, 0.16666666666667
28724, 1.6166666666667, 0.25, 0.16666666666667
28725, 1.6166666666667, 0.2, 0.16666666666667
28726, 1.6583333333333, 1.3, 0.16666666666667
28727, 1.6583333333333, 1.25, 0.16666666666667
28728, 1.6583333333333, 1.2, 0.16666666666667
28729, 1.6583333333333, 1.15, 0.16666666666667
28730, 1.6583333333333, 1.1, 0.16666666666667
28731, 1.6583333333333, 1.05, 0.16666666666667
28732, 1.6583333333333, 1, 0.16666666666667
28733, 1.6583333333333, 0.95, 0.16666666666667
28734, 1.6583333333333, 0.9, 0.16666666666667
28735, 1.6583333333333, 0.85, 0.16666666666667
28736, 1.6583333333333, 0.8, 0.16666666666667
28737, 1.6583333333333, 0.75, 0.16666666666667
28738, 1.6583333333333, 0.7, 0.16666666666667
28739, 1.6583333333333, 0.65, 0.16666666666667
28740, 1.6583333333333, 0.6, 0.16666666666667
28741, 1.6583333333333, 0.55, 0.16666666666667
28742, 1.6583333333333, 0.5, 0.16666666666667
28743, 1.6583333333333, 0.45, 0.16666666666667
28744, 1.6583333333333, 0.4, 0.16666666666667
28745, 1.6583333333333, 0.35, 0.16666666666667
28746, 1.6583333333333, 0.3, 0.16666666666667
28747, 1.6583333333333, 0.25, 0.16666666666667
28748, 1.6583333333333, 0.2, 0.16666666666667
28749, 1.7, 1.3, 0.16666666666667
28750, 1.7, 1.25, 0.16666666666667
28751, 1.7, 1.2, 0.16666666666667
28752, 1.7, 1.15, 0.16666666666667
28753, 1.7, 1.1, 0.16666666666667
28754, 1.7, 1.05, 0.16666666666667
28755, 1.7, 1, 0.16666666666667
28756, 1.7, 0.95, 0.16666666666667
28757, 1.7, 0.9, 0.16666666666667
28758, 1.7, 0.85, 0.16666666666667
28759, 1.7, 0.8, 0.16666666666667
28760, 1.7, 0.75, 0.16666666666667
28761, 1.7, 0.7, 0.16666666666667
28762, 1.7, 0.65, 0.16666666666667
28763, 1.7, 0.6, 0.16666666666667
28764, 1.7, 0.55, 0.16666666666667
28765, 1.7, 0.5, 0.16666666666667
28766, 1.7, 0.45, 0.16666666666667
28767, 1.7, 0.4, 0.16666666666667
28768, 1.7, 0.35, 0.16666666666667
28769, 1.7, 0.3, 0.16666666666667
28770, 1.7, 0.25, 0.16666666666667
28771, 1.7, 0.2, 0.16666666666667
28772, 1.7416666666667, 1.3, 0.16666666666667
28773, 1.7416666666667, 1.25, 0.16666666666667
28774, 1.7416666666667, 1.2, 0.16666666666667
28775, 1.7416666666667, 1.15, 0.16666666666667
28776, 1.7416666666667, 1.1, 0.16666666666667
28777, 1.7416666666667, 1.05, 0.16666666666667
28778, 1.7416666666667, 1, 0.16666666666667
28779, 1.7416666666667, 0.95, 0.16666666666667
28780, 1.7416666666667, 0.9, 0.16666666666667
28781, 1.7416666666667, 0.85, 0.16666666666667
28782, 1.7416666666667, 0.8, 0.16666666666667
28783, 1.7416666666667, 0.75, 0.16666666666667
28784, 1.7416666666667, 0.7, 0.16666666666667
28785, 1.7416666666667, 0.65, 0.16666666666667
28786, 1.7416666666667, 0.6, 0.16666666666667
28787, 1.7416666666667, 0.55, 0.16666666666667
28788, 1.7416666666667, 0.5, 0.16666666666667
28789, 1.7416666666667, 0.45, 0.16666666666667
28790, 1.7416666666667, 0.4, 0.16666666666667
28791, 1.7416666666667, 0.35, 0.16666666666667
28792, 1.7416666666667, 0.3, 0.16666666666667
28793, 1.7416666666667, 0.25, 0.16666666666667
28794, 1.7416666666667, 0.2, 0.16666666666667
28795, 1.7833333333333, 1.3, 0.16666666666667
28796, 1.7833333333333, 1.25, 0.16666666666667
28797, 1.7833333333333, 1.2, 0.16666666666667
28798, 1.7833333333333, 1.15, 0.16666666666667
28799, 1.7833333333333, 1.1, 0.16666666666667
28800, 1.7833333333333, 1.05, 0.16666666666667
28801, 1.7833333333333, 1, 0.16666666666667
28802, 1.7833333333333, 0.95, 0.16666666666667
28803, 1.7833333333333, 0.9, 0.16666666666667
28804, 1.7833333333333, 0.85, 0.16666666666667
28805, 1.7833333333333, 0.8, 0.16666666666667
28806, 1.7833333333333, 0.75, 0.16666666666667
28807, 1.7833333333333, 0.7, 0.16666666666667
28808, 1.7833333333333, 0.65, 0.16666666666667
28809, 1.7833333333333, 0.6, 0.16666666666667
28810, 1.7833333333333, 0.55, 0.16666666666667
28811, 1.7833333333333, 0.5, 0.16666666666667
28812, 1.7833333333333, 0.45, 0.16666666666667
28813, 1.7833333333333, 0.4, 0.16666666666667
28814, 1.7833333333333, 0.35, 0.16666666666667
28815, 1.7833333333333, 0.3, 0.16666666666667
28816, 1.7833333333333, 0.25, 0.16666666666667
28817, 1.7833333333333, 0.2, 0.16666666666667
28818, 1.825, 1.3, 0.16666666666667
28819, 1.825, 1.25, 0.16666666666667
28820, 1.825, 1.2, 0.16666666666667
28821, 1.825, 1.15, 0.16666666666667
28822, 1.825, 1.1, 0.16666666666667
28823, 1.825, 1.05, 0.16666666666667
28824, 1.825, 1, 0.16666666666667
28825, 1.825, 0.95, 0.16666666666667
28826, 1.825, 0.9, 0.16666666666667
28827, 1.825, 0.85, 0.16666666666667
28828, 1.825, 0.8, 0.16666666666667
28829, 1.825, 0.75, 0.16666666666667
28830, 1.825, 0.7, 0.16666666666667
28831, 1.825, 0.65, 0.16666666666667
28832, 1.825, 0.6, 0.16666666666667
28833, 1.825, 0.55, 0.16666666666667
28834, 1.825, 0.5, 0.16666666666667
28835, 1.825, 0.45, 0.16666666666667
28836, 1.825, 0.4, 0.16666666666667
28837, 1.825, 0.35, 0.16666666666667
28838, 1.825, 0.3, 0.16666666666667
28839, 1.825, 0.25, 0.16666666666667
28840, 1.825, 0.2, 0.16666666666667
28841, 1.8666666666667, 1.3, 0.16666666666667
28842, 1.8666666666667, 1.25, 0.16666666666667
28843, 1.8666666666667, 1.2, 0.16666666666667
28844, 1.8666666666667, 1.15, 0.16666666666667
28845, 1.8666666666667, 1.1, 0.16666666666667
28846, 1.8666666666667, 1.05, 0.16666666666667
28847, 1.8666666666667, 1, 0.16666666666667
28848, 1.8666666666667, 0.95, 0.16666666666667
28849, 1.8666666666667, 0.9, 0.16666666666667
28850, 1.8666666666667, 0.85, 0.16666666666667
28851, 1.8666666666667, 0.8, 0.16666666666667
28852, 1.8666666666667, 0.75, 0.16666666666667
28853, 1.8666666666667, 0.7, 0.16666666666667
28854, 1.8666666666667, 0.65, 0.16666666666667
28855, 1.8666666666667, 0.6, 0.16666666666667
28856, 1.8666666666667, 0.55, 0.16666666666667
28857, 1.8666666666667, 0.5, 0.16666666666667
28858, 1.8666666666667, 0.45, 0.16666666666667
28859, 1.8666666666667, 0.4, 0.16666666666667
28860, 1.8666666666667, 0.35, 0.16666666666667
28861, 1.8666666666667, 0.3, 0.16666666666667
28862, 1.8666666666667, 0.25, 0.16666666666667
28863, 1.8666666666667, 0.2, 0.16666666666667
28864, 1.9083333333333, 1.3, 0.16666666666667
28865, 1.9083333333333, 1.25, 0.16666666666667
28866, 1.9083333333333, 1.2, 0.16666666666667
28867, 1.9083333333333, 1.15, 0.16666666666667
28868, 1.9083333333333, 1.1, 0.16666666666667
28869, 1.9083333333333, 1.05, 0.16666666666667
28870, 1.9083333333333, 1, 0.16666666666667
28871, 1.9083333333333, 0.95, 0.16666666666667
28872, 1.9083333333333, 0.9, 0.16666666666667
28873, 1.9083333333333, 0.85, 0.16666666666667
28874, 1.9083333333333, 0.8, 0.16666666666667
28875, 1.9083333333333, 0.75, 0.16666666666667
28876, 1.9083333333333, 0.7, 0.16666666666667
28877, 1.9083333333333, 0.65, 0.16666666666667
28878, 1.9083333333333, 0.6, 0.16666666666667
28879, 1.9083333333333, 0.55, 0.16666666666667
28880, 1.9083333333333, 0.5, 0.16666666666667
28881, 1.9083333333333, 0.45, 0.16666666666667
28882, 1.9083333333333, 0.4, 0.16666666666667
28883, 1.9083333333333, 0.35, 0.16666666666667
28884, 1.9083333333333, 0.3, 0.16666666666667
28885, 1.9083333333333, 0.25, 0.16666666666667
28886, 1.9083333333333, 0.2, 0.16666666666667
28887, 1.95, 1.3, 0.16666666666667
28888, 1.95, 1.25, 0.16666666666667
28889, 1.95, 1.2, 0.16666666666667
28890, 1.95, 1.15, 0.16666666666667
28891, 1.95, 1.1, 0.16666666666667
28892, 1.95, 1.05, 0.16666666666667
28893, 1.95, 1, 0.16666666666667
28894, 1.95, 0.95, 0.16666666666667
28895, 1.95, 0.9, 0.16666666666667
28896, 1.95, 0.85, 0.16666666666667
28897, 1.95, 0.8, 0.16666666666667
28898, 1.95, 0.75, 0.16666666666667
28899, 1.95, 0.7, 0.16666666666667
28900, 1.95, 0.65, 0.16666666666667
28901, 1.95, 0.6, 0.16666666666667
28902, 1.95, 0.55, 0.16666666666667
28903, 1.95, 0.5, 0.16666666666667
28904, 1.95, 0.45, 0.16666666666667
28905, 1.95, 0.4, 0.16666666666667
28906, 1.95, 0.35, 0.16666666666667
28907, 1.95, 0.3, 0.16666666666667
28908, 1.95, 0.25, 0.16666666666667
28909, 1.95, 0.2, 0.16666666666667
28910, 1.9916666666667, 1.3, 0.16666666666667
28911, 1.9916666666667, 1.25, 0.16666666666667
28912, 1.9916666666667, 1.2, 0.16666666666667
28913, 1.9916666666667, 1.15, 0.16666666666667
28914, 1.9916666666667, 1.1, 0.16666666666667
28915, 1.9916666666667, 1.05, 0.16666666666667
28916, 1.9916666666667, 1, 0.16666666666667
28917, 1.9916666666667, 0.95, 0.16666666666667
28918, 1.9916666666667, 0.9, 0.16666666666667
28919, 1.9916666666667, 0.85, 0.16666666666667
28920, 1.9916666666667, 0.8, 0.16666666666667
28921, 1.9916666666667, 0.75, 0.16666666666667
28922, 1.9916666666667, 0.7, 0.16666666666667
28923, 1.9916666666667, 0.65, 0.16666666666667
28924, 1.9916666666667, 0.6, 0.16666666666667
28925, 1.9916666666667, 0.55, 0.16666666666667
28926, 1.9916666666667, 0.5, 0.16666666666667
28927, 1.9916666666667, 0.45, 0.16666666666667
28928, 1.9916666666667, 0.4, 0.16666666666667
28929, 1.9916666666667, 0.35, 0.16666666666667
28930, 1.9916666666667, 0.3, 0.16666666666667
28931, 1.9916666666667, 0.25, 0.16666666666667
28932, 1.9916666666667, 0.2, 0.16666666666667
28933, 2.0333333333333, 1.3, 0.16666666666667
28934, 2.0333333333333, 1.25, 0.16666666666667
28935, 2.0333333333333, 1.2, 0.16666666666667
28936, 2.0333333333333, 1.15, 0.16666666666667
28937, 2.0333333333333, 1.1, 0.16666666666667
28938, 2.0333333333333, 1.05, 0.16666666666667
28939, 2.0333333333333, 1, 0.16666666666667
28940, 2.0333333333333, 0.95, 0.16666666666667
28941, 2.0333333333333, 0.9, 0.16666666666667
28942, 2.0333333333333, 0.85, 0.16666666666667
28943, 2.0333333333333, 0.8, 0.16666666666667
28944, 2.0333333333333, 0.75, 0.16666666666667
28945, 2.0333333333333, 0.7, 0.16666666666667
28946, 2.0333333333333, 0.65, 0.16666666666667
28947, 2.0333333333333, 0.6, 0.16666666666667
28948, 2.0333333333333, 0.55, 0.16666666666667
28949, 2.0333333333333, 0.5, 0.16666666666667
28950, 2.0333333333333, 0.45, 0.16666666666667
28951, 2.0333333333333, 0.4, 0.16666666666667
28952, 2.0333333333333, 0.35, 0.16666666666667
28953, 2.0333333333333, 0.3, 0.16666666666667
28954, 2.0333333333333, 0.25, 0.16666666666667
28955, 2.0333333333333, 0.2, 0.16666666666667
28956, 2.075, 1.3, 0.16666666666667
28957, 2.075, 1.25, 0.16666666666667
28958, 2.075, 1.2, 0.16666666666667
28959, 2.075, 1.15, 0.16666666666667
28960, 2.075, 1.1, 0.16666666666667
28961, 2.075, 1.05, 0.16666666666667
28962, 2.075, 1, 0.16666666666667
28963, 2.075, 0.95, 0.16666666666667
28964, 2.075, 0.9, 0.16666666666667
28965, 2.075, 0.85, 0.16666666666667
28966, 2.075, 0.8, 0.16666666666667
28967, 2.075, 0.75, 0.16666666666667
28968, 2.075, 0.7, 0.16666666666667
28969, 2.075, 0.65, 0.16666666666667
28970, 2.075, 0.6, 0.16666666666667
28971, 2.075, 0.55, 0.16666666666667
28972, 2.075, 0.5, 0.16666666666667
28973, 2.075, 0.45, 0.16666666666667
28974, 2.075, 0.4, 0.16666666666667
28975, 2.075, 0.35, 0.16666666666667
28976, 2.075, 0.3, 0.16666666666667
28977, 2.075, 0.25, 0.16666666666667
28978, 2.075, 0.2, 0.16666666666667
28979, 2.1166666666667, 1.3, 0.16666666666667
28980, 2.1166666666667, 1.25, 0.16666666666667
28981, 2.1166666666667, 1.2, 0.16666666666667
28982, 2.1166666666667, 1.15, 0.16666666666667
28983, 2.1166666666667, 1.1, 0.16666666666667
28984, 2.1166666666667, 1.05, 0.16666666666667
28985, 2.1166666666667, 1, 0.16666666666667
28986, 2.1166666666667, 0.95, 0.16666666666667
28987, 2.1166666666667, 0.9, 0.16666666666667
28988, 2.1166666666667, 0.85, 0.16666666666667
28989, 2.1166666666667, 0.8, 0.16666666666667
28990, 2.1166666666667, 0.75, 0.16666666666667
28991, 2.1166666666667, 0.7, 0.16666666666667
28992, 2.1166666666667, 0.65, 0.16666666666667
28993, 2.1166666666667, 0.6, 0.16666666666667
28994, 2.1166666666667, 0.55, 0.16666666666667
28995, 2.1166666666667, 0.5, 0.16666666666667
28996, 2.1166666666667, 0.45, 0.16666666666667
28997, 2.1166666666667, 0.4, 0.16666666666667
28998, 2.1166666666667, 0.35, 0.16666666666667
28999, 2.1166666666667, 0.3, 0.16666666666667
29000, 2.1166666666667, 0.25, 0.16666666666667
29001, 2.1166666666667, 0.2, 0.16666666666667
29002, 2.1583333333333, 1.3, 0.16666666666667
29003, 2.1583333333333, 1.25, 0.16666666666667
29004, 2.1583333333333, 1.2, 0.16666666666667
29005, 2.1583333333333, 1.15, 0.16666666666667
29006, 2.1583333333333, 1.1, 0.16666666666667
29007, 2.1583333333333, 1.05, 0.16666666666667
29008, 2.1583333333333, 1, 0.16666666666667
29009, 2.1583333333333, 0.95, 0.16666666666667
29010, 2.1583333333333, 0.9, 0.16666666666667
29011, 2.1583333333333, 0.85, 0.16666666666667
29012, 2.1583333333333, 0.8, 0.16666666666667
29013, 2.1583333333333, 0.75, 0.16666666666667
29014, 2.1583333333333, 0.7, 0.16666666666667
29015, 2.1583333333333, 0.65, 0.16666666666667
29016, 2.1583333333333, 0.6, 0.16666666666667
29017, 2.1583333333333, 0.55, 0.16666666666667
29018, 2.1583333333333, 0.5, 0.16666666666667
29019, 2.1583333333333, 0.45, 0.16666666666667
29020, 2.1583333333333, 0.4, 0.16666666666667
29021, 2.1583333333333, 0.35, 0.16666666666667
29022, 2.1583333333333, 0.3, 0.16666666666667
29023, 2.1583333333333, 0.25, 0.16666666666667
29024, 2.1583333333333, 0.2, 0.16666666666667
29025, 1.2416666666667, 1.3, 0.20833333333333
29026, 1.2416666666667, 1.25, 0.20833333333333
29027, 1.2416666666667, 1.2, 0.20833333333333
29028, 1.2416666666667, 1.15, 0.20833333333333
29029, 1.2416666666667, 1.1, 0.20833333333333
29030, 1.2416666666667, 1.05, 0.20833333333333
29031, 1.2416666666667, 1, 0.20833333333333
29032, 1.2416666666667, 0.95, 0.20833333333333
29033, 1.2416666666667, 0.9, 0.20833333333333
29034, 1.2416666666667, 0.85, 0.20833333333333
29035, 1.2416666666667, 0.8, 0.20833333333333
29036, 1.2416666666667, 0.75, 0.20833333333333
29037, 1.2416666666667, 0.7, 0.20833333333333
29038, 1.2416666666667, 0.65, 0.20833333333333
29039, 1.2416666666667, 0.6, 0.20833333333333
29040, 1.2416666666667, 0.55, 0.20833333333333
29041, 1.2416666666667, 0.5, 0.20833333333333
29042, 1.2416666666667, 0.45, 0.20833333333333
29043, 1.2416666666667, 0.4, 0.20833333333333
29044, 1.2416666666667, 0.35, 0.20833333333333
29045, 1.2416666666667, 0.3, 0.20833333333333
29046, 1.2416666666667, 0.25, 0.20833333333333
29047, 1.2416666666667, 0.2, 0.20833333333333
29048, 1.2833333333333, 1.3, 0.20833333333333
29049, 1.2833333333333, 1.25, 0.20833333333333
29050, 1.2833333333333, 1.2, 0.20833333333333
29051, 1.2833333333333, 1.15, 0.20833333333333
29052, 1.2833333333333, 1.1, 0.20833333333333
29053, 1.2833333333333, 1.05, 0.20833333333333
29054, 1.2833333333333, 1, 0.20833333333333
29055, 1.2833333333333, 0.95, 0.20833333333333
29056, 1.2833333333333, 0.9, 0.20833333333333
29057, 1.2833333333333, 0.85, 0.20833333333333
29058, 1.2833333333333, 0.8, 0.20833333333333
29059, 1.2833333333333, 0.75, 0.20833333333333
29060, 1.2833333333333, 0.7, 0.20833333333333
29061, 1.2833333333333, 0.65, 0.20833333333333
29062, 1.2833333333333, 0.6, 0.20833333333333
29063, 1.2833333333333, 0.55, 0.20833333333333
29064, 1.2833333333333, 0.5, 0.20833333333333
29065, 1.2833333333333, 0.45, 0.20833333333333
29066, 1.2833333333333, 0.4, 0.20833333333333
29067, 1.2833333333333, 0.35, 0.20833333333333
29068, 1.2833333333333, 0.3, 0.20833333333333
29069, 1.2833333333333, 0.25, 0.20833333333333
29070, 1.2833333333333, 0.2, 0.20833333333333
29071, 1.325, 1.3, 0.20833333333333
29072, 1.325, 1.25, 0.20833333333333
29073, 1.325, 1.2, 0.20833333333333
29074, 1.325, 1.15, 0.20833333333333
29075, 1.325, 1.1, 0.20833333333333
29076, 1.325, 1.05, 0.20833333333333
29077, 1.325, 1, 0.20833333333333
29078, 1.325, 0.95, 0.20833333333333
29079, 1.325, 0.9, 0.20833333333333
29080, 1.325, 0.85, 0.20833333333333
29081, 1.325, 0.8, 0.20833333333333
29082, 1.325, 0.75, 0.20833333333333
29083, 1.325, 0.7, 0.20833333333333
29084, 1.325, 0.65, 0.20833333333333
29085, 1.325, 0.6, 0.20833333333333
29086, 1.325, 0.55, 0.20833333333333
29087, 1.325, 0.5, 0.20833333333333
29088, 1.325, 0.45, 0.20833333333333
29089, 1.325, 0.4, 0.20833333333333
29090, 1.325, 0.35, 0.20833333333333
29091, 1.325, 0.3, 0.20833333333333
29092, 1.325, 0.25, 0.20833333333333
29093, 1.325, 0.2, 0.20833333333333
29094, 1.3666666666667, 1.3, 0.20833333333333
29095, 1.3666666666667, 1.25, 0.20833333333333
29096, 1.3666666666667, 1.2, 0.20833333333333
29097, 1.3666666666667, 1.15, 0.20833333333333
29098, 1.3666666666667, 1.1, 0.20833333333333
29099, 1.3666666666667, 1.05, 0.20833333333333
29100, 1.3666666666667, 1, 0.20833333333333
29101, 1.3666666666667, 0.95, 0.20833333333333
29102, 1.3666666666667, 0.9, 0.20833333333333
29103, 1.3666666666667, 0.85, 0.20833333333333
29104, 1.3666666666667, 0.8, 0.20833333333333
29105, 1.3666666666667, 0.75, 0.20833333333333
29106, 1.3666666666667, 0.7, 0.20833333333333
29107, 1.3666666666667, 0.65, 0.20833333333333
29108, 1.3666666666667, 0.6, 0.20833333333333
29109, 1.3666666666667, 0.55, 0.20833333333333
29110, 1.3666666666667, 0.5, 0.20833333333333
29111, 1.3666666666667, 0.45, 0.20833333333333
29112, 1.3666666666667, 0.4, 0.20833333333333
29113, 1.3666666666667, 0.35, 0.20833333333333
29114, 1.3666666666667, 0.3, 0.20833333333333
29115, 1.3666666666667, 0.25, 0.20833333333333
29116, 1.3666666666667, 0.2, 0.20833333333333
29117, 1.4083333333333, 1.3, 0.20833333333333
29118, 1.4083333333333, 1.25, 0.20833333333333
29119, 1.4083333333333, 1.2, 0.20833333333333
29120, 1.4083333333333, 1.15, 0.20833333333333
29121, 1.4083333333333, 1.1, 0.20833333333333
29122, 1.4083333333333, 1.05, 0.20833333333333
29123, 1.4083333333333, 1, 0.20833333333333
29124, 1.4083333333333, 0.95, 0.20833333333333
29125, 1.4083333333333, 0.9, 0.20833333333333
29126, 1.4083333333333, 0.85, 0.20833333333333
29127, 1.4083333333333, 0.8, 0.20833333333333
29128, 1.4083333333333, 0.75, 0.20833333333333
29129, 1.4083333333333, 0.7, 0.20833333333333
29130, 1.4083333333333, 0.65, 0.20833333333333
29131, 1.4083333333333, 0.6, 0.20833333333333
29132, 1.4083333333333, 0.55, 0.20833333333333
29133, 1.4083333333333, 0.5, 0.20833333333333
29134, 1.4083333333333, 0.45, 0.20833333333333
29135, 1.4083333333333, 0.4, 0.20833333333333
29136, 1.4083333333333, 0.35, 0.20833333333333
29137, 1.4083333333333, 0.3, 0.20833333333333
29138, 1.4083333333333, 0.25, 0.20833333333333
29139, 1.4083333333333, 0.2, 0.20833333333333
29140, 1.45, 1.3, 0.20833333333333
29141, 1.45, 1.25, 0.20833333333333
29142, 1.45, 1.2, 0.20833333333333
29143, 1.45, 1.15, 0.20833333333333
29144, 1.45, 1.1, 0.20833333333333
29145, 1.45, 1.05, 0.20833333333333
29146, 1.45, 1, 0.20833333333333
29147, 1.45, 0.95, 0.20833333333333
29148, 1.45, 0.9, 0.20833333333333
29149, 1.45, 0.85, 0.20833333333333
29150, 1.45, 0.8, 0.20833333333333
29151, 1.45, 0.75, 0.20833333333333
29152, 1.45, 0.7, 0.20833333333333
29153, 1.45, 0.65, 0.20833333333333
29154, 1.45, 0.6, 0.20833333333333
29155, 1.45, 0.55, 0.20833333333333
29156, 1.45, 0.5, 0.20833333333333
29157, 1.45, 0.45, 0.20833333333333
29158, 1.45, 0.4, 0.20833333333333
29159, 1.45, 0.35, 0.20833333333333
29160, 1.45, 0.3, 0.20833333333333
29161, 1.45, 0.25, 0.20833333333333
29162, 1.45, 0.2, 0.20833333333333
29163, 1.4916666666667, 1.3, 0.20833333333333
29164, 1.4916666666667, 1.25, 0.20833333333333
29165, 1.4916666666667, 1.2, 0.20833333333333
29166, 1.4916666666667, 1.15, 0.20833333333333
29167, 1.4916666666667, 1.1, 0.20833333333333
29168, 1.4916666666667, 1.05, 0.20833333333333
29169, 1.4916666666667, 1, 0.20833333333333
29170, 1.4916666666667, 0.95, 0.20833333333333
29171, 1.4916666666667, 0.9, 0.20833333333333
29172, 1.4916666666667, 0.85, 0.20833333333333
29173, 1.4916666666667, 0.8, 0.20833333333333
29174, 1.4916666666667, 0.75, 0.20833333333333
29175, 1.4916666666667, 0.7, 0.20833333333333
29176, 1.4916666666667, 0.65, 0.20833333333333
29177, 1.4916666666667, 0.6, 0.20833333333333
29178, 1.4916666666667, 0.55, 0.20833333333333
29179, 1.4916666666667, 0.5, 0.20833333333333
29180, 1.4916666666667, 0.45, 0.20833333333333
29181, 1.4916666666667, 0.4, 0.20833333333333
29182, 1.4916666666667, 0.35, 0.20833333333333
29183, 1.4916666666667, 0.3, 0.20833333333333
29184, 1.4916666666667, 0.25, 0.20833333333333
29185, 1.4916666666667, 0.2, 0.20833333333333
29186, 1.5333333333333, 1.3, 0.20833333333333
29187, 1.5333333333333, 1.25, 0.20833333333333
29188, 1.5333333333333, 1.2, 0.20833333333333
29189, 1.5333333333333, 1.15, 0.20833333333333
29190, 1.5333333333333, 1.1, 0.20833333333333
29191, 1.5333333333333, 1.05, 0.20833333333333
29192, 1.5333333333333, 1, 0.20833333333333
29193, 1.5333333333333, 0.95, 0.20833333333333
29194, 1.5333333333333, 0.9, 0.20833333333333
29195, 1.5333333333333, 0.85, 0.20833333333333
29196, 1.5333333333333, 0.8, 0.20833333333333
29197, 1.5333333333333, 0.75, 0.20833333333333
29198, 1.5333333333333, 0.7, 0.20833333333333
29199, 1.5333333333333, 0.65, 0.20833333333333
29200, 1.5333333333333, 0.6, 0.20833333333333
29201, 1.5333333333333, 0.55, 0.20833333333333
29202, 1.5333333333333, 0.5, 0.20833333333333
29203, 1.5333333333333, 0.45, 0.20833333333333
29204, 1.5333333333333, 0.4, 0.20833333333333
29205, 1.5333333333333, 0.35, 0.20833333333333
29206, 1.5333333333333, 0.3, 0.20833333333333
29207, 1.5333333333333, 0.25, 0.20833333333333
29208, 1.5333333333333, 0.2, 0.20833333333333
29209, 1.575, 1.3, 0.20833333333333
29210, 1.575, 1.25, 0.20833333333333
29211, 1.575, 1.2, 0.20833333333333
29212, 1.575, 1.15, 0.20833333333333
29213, 1.575, 1.1, 0.20833333333333
29214, 1.575, 1.05, 0.20833333333333
29215, 1.575, 1, 0.20833333333333
29216, 1.575, 0.95, 0.20833333333333
29217, 1.575, 0.9, 0.20833333333333
29218, 1.575, 0.85, 0.20833333333333
29219, 1.575, 0.8, 0.20833333333333
29220, 1.575, 0.75, 0.20833333333333
29221, 1.575, 0.7, 0.20833333333333
29222, 1.575, 0.65, 0.20833333333333
29223, 1.575, 0.6, 0.20833333333333
29224, 1.575, 0.55, 0.20833333333333
29225, 1.575, 0.5, 0.20833333333333
29226, 1.575, 0.45, 0.20833333333333
29227, 1.575, 0.4, 0.20833333333333
29228, 1.575, 0.35, 0.20833333333333
29229, 1.575, 0.3, 0.20833333333333
29230, 1.575, 0.25, 0.20833333333333
29231, 1.575, 0.2, 0.20833333333333
29232, 1.6166666666667, 1.3, 0.20833333333333
29233, 1.6166666666667, 1.25, 0.20833333333333
29234, 1.6166666666667, 1.2, 0.20833333333333
29235, 1.6166666666667, 1.15, 0.20833333333333
29236, 1.6166666666667, 1.1, 0.20833333333333
29237, 1.6166666666667, 1.05, 0.20833333333333
29238, 1.6166666666667, 1, 0.20833333333333
29239, 1.6166666666667, 0.95, 0.20833333333333
29240, 1.6166666666667, 0.9, 0.20833333333333
29241, 1.6166666666667, 0.85, 0.20833333333333
29242, 1.6166666666667, 0.8, 0.20833333333333
29243, 1.6166666666667, 0.75, 0.20833333333333
29244, 1.6166666666667, 0.7, 0.20833333333333
29245, 1.6166666666667, 0.65, 0.20833333333333
29246, 1.6166666666667, 0.6, 0.20833333333333
29247, 1.6166666666667, 0.55, 0.20833333333333
29248, 1.6166666666667, 0.5, 0.20833333333333
29249, 1.6166666666667, 0.45, 0.20833333333333
29250, 1.6166666666667, 0.4, 0.20833333333333
29251, 1.6166666666667, 0.35, 0.20833333333333
29252, 1.6166666666667, 0.3, 0.20833333333333
29253, 1.6166666666667, 0.25, 0.20833333333333
29254, 1.6166666666667, 0.2, 0.20833333333333
29255, 1.6583333333333, 1.3, 0.20833333333333
29256, 1.6583333333333, 1.25, 0.20833333333333
29257, 1.6583333333333, 1.2, 0.20833333333333
29258, 1.6583333333333, 1.15, 0.20833333333333
29259, 1.6583333333333, 1.1, 0.20833333333333
29260, 1.6583333333333, 1.05, 0.20833333333333
29261, 1.6583333333333, 1, 0.20833333333333
29262, 1.6583333333333, 0.95, 0.20833333333333
29263, 1.6583333333333, 0.9, 0.20833333333333
29264, 1.6583333333333, 0.85, 0.20833333333333
29265, 1.6583333333333, 0.8, 0.20833333333333
29266, 1.6583333333333, 0.75, 0.20833333333333
29267, 1.6583333333333, 0.7, 0.20833333333333
29268, 1.6583333333333, 0.65, 0.20833333333333
29269, 1.6583333333333, 0.6, 0.20833333333333
29270, 1.6583333333333, 0.55, 0.20833333333333
29271, 1.6583333333333, 0.5, 0.20833333333333
29272, 1.6583333333333, 0.45, 0.20833333333333
29273, 1.6583333333333, 0.4, 0.20833333333333
29274, 1.6583333333333, 0.35, 0.20833333333333
29275, 1.6583333333333, 0.3, 0.20833333333333
29276, 1.6583333333333, 0.25, 0.20833333333333
29277, 1.6583333333333, 0.2, 0.20833333333333
29278, 1.7, 1.3, 0.20833333333333
29279, 1.7, 1.25, 0.20833333333333
29280, 1.7, 1.2, 0.20833333333333
29281, 1.7, 1.15, 0.20833333333333
29282, 1.7, 1.1, 0.20833333333333
29283, 1.7, 1.05, 0.20833333333333
29284, 1.7, 1, 0.20833333333333
29285, 1.7, 0.95, 0.20833333333333
29286, 1.7, 0.9, 0.20833333333333
29287, 1.7, 0.85, 0.20833333333333
29288, 1.7, 0.8, 0.20833333333333
29289, 1.7, 0.75, 0.20833333333333
29290, 1.7, 0.7, 0.20833333333333
29291, 1.7, 0.65, 0.20833333333333
29292, 1.7, 0.6, 0.20833333333333
29293, 1.7, 0.55, 0.20833333333333
29294, 1.7, 0.5, 0.20833333333333
29295, 1.7, 0.45, 0.20833333333333
29296, 1.7, 0.4, 0.20833333333333
29297, 1.7, 0.35, 0.20833333333333
29298, 1.7, 0.3, 0.20833333333333
29299, 1.7, 0.25, 0.20833333333333
29300, 1.7, 0.2, 0.20833333333333
29301, 1.7416666666667, 1.3, 0.20833333333333
29302, 1.7416666666667, 1.25, 0.20833333333333
29303, 1.7416666666667, 1.2, 0.20833333333333
29304, 1.7416666666667, 1.15, 0.20833333333333
29305, 1.7416666666667, 1.1, 0.20833333333333
29306, 1.7416666666667, 1.05, 0.20833333333333
29307, 1.7416666666667, 1, 0.20833333333333
29308, 1.7416666666667, 0.95, 0.20833333333333
29309, 1.7416666666667, 0.9, 0.20833333333333
29310, 1.7416666666667, 0.85, 0.20833333333333
29311, 1.7416666666667, 0.8, 0.20833333333333
29312, 1.7416666666667, 0.75, 0.20833333333333
29313, 1.7416666666667, 0.7, 0.20833333333333
29314, 1.7416666666667, 0.65, 0.20833333333333
29315, 1.7416666666667, 0.6, 0.20833333333333
29316, 1.7416666666667, 0.55, 0.20833333333333
29317, 1.7416666666667, 0.5, 0.20833333333333
29318, 1.7416666666667, 0.45, 0.20833333333333
29319, 1.7416666666667, 0.4, 0.20833333333333
29320, 1.7416666666667, 0.35, 0.20833333333333
29321, 1.7416666666667, 0.3, 0.20833333333333
29322, 1.7416666666667, 0.25, 0.20833333333333
29323, 1.7416666666667, 0.2, 0.20833333333333
29324, 1.7833333333333, 1.3, 0.20833333333333
29325, 1.7833333333333, 1.25, 0.20833333333333
29326, 1.7833333333333, 1.2, 0.20833333333333
29327, 1.7833333333333, 1.15, 0.20833333333333
29328, 1.7833333333333, 1.1, 0.20833333333333
29329, 1.7833333333333, 1.05, 0.20833333333333
29330, 1.7833333333333, 1, 0.20833333333333
29331, 1.7833333333333, 0.95, 0.20833333333333
29332, 1.7833333333333, 0.9, 0.20833333333333
29333, 1.7833333333333, 0.85, 0.20833333333333
29334, 1.7833333333333, 0.8, 0.20833333333333
29335, 1.7833333333333, 0.75, 0.20833333333333
29336, 1.7833333333333, 0.7, 0.20833333333333
29337, 1.7833333333333, 0.65, 0.20833333333333
29338, 1.7833333333333, 0.6, 0.20833333333333
29339, 1.7833333333333, 0.55, 0.20833333333333
29340, 1.7833333333333, 0.5, 0.20833333333333
29341, 1.7833333333333, 0.45, 0.20833333333333
29342, 1.7833333333333, 0.4, 0.20833333333333
29343, 1.7833333333333, 0.35, 0.20833333333333
29344, 1.7833333333333, 0.3, 0.20833333333333
29345, 1.7833333333333, 0.25, 0.20833333333333
29346, 1.7833333333333, 0.2, 0.20833333333333
29347, 1.825, 1.3, 0.20833333333333
29348, 1.825, 1.25, 0.20833333333333
29349, 1.825, 1.2, 0.20833333333333
29350, 1.825, 1.15, 0.20833333333333
29351, 1.825, 1.1, 0.20833333333333
29352, 1.825, 1.05, 0.20833333333333
29353, 1.825, 1, 0.20833333333333
29354, 1.825, 0.95, 0.20833333333333
29355, 1.825, 0.9, 0.20833333333333
29356, 1.825, 0.85, 0.20833333333333
29357, 1.825, 0.8, 0.20833333333333
29358, 1.825, 0.75, 0.20833333333333
29359, 1.825, 0.7, 0.20833333333333
29360, 1.825, 0.65, 0.20833333333333
29361, 1.825, 0.6, 0.20833333333333
29362, 1.825, 0.55, 0.20833333333333
29363, 1.825, 0.5, 0.20833333333333
29364, 1.825, 0.45, 0.20833333333333
29365, 1.825, 0.4, 0.20833333333333
29366, 1.825, 0.35, 0.20833333333333
29367, 1.825, 0.3, 0.20833333333333
29368, 1.825, 0.25, 0.20833333333333
29369, 1.825, 0.2, 0.20833333333333
29370, 1.8666666666667, 1.3, 0.20833333333333
29371, 1.8666666666667, 1.25, 0.20833333333333
29372, 1.8666666666667, 1.2, 0.20833333333333
29373, 1.8666666666667, 1.15, 0.20833333333333
29374, 1.8666666666667, 1.1, 0.20833333333333
29375, 1.8666666666667, 1.05, 0.20833333333333
29376, 1.8666666666667, 1, 0.20833333333333
29377, 1.8666666666667, 0.95, 0.20833333333333
29378, 1.8666666666667, 0.9, 0.20833333333333
29379, 1.8666666666667, 0.85, 0.20833333333333
29380, 1.8666666666667, 0.8, 0.20833333333333
29381, 1.8666666666667, 0.75, 0.20833333333333
29382, 1.8666666666667, 0.7, 0.20833333333333
29383, 1.8666666666667, 0.65, 0.20833333333333
29384, 1.8666666666667, 0.6, 0.20833333333333
29385, 1.8666666666667, 0.55, 0.20833333333333
29386, 1.8666666666667, 0.5, 0.20833333333333
29387, 1.8666666666667, 0.45, 0.20833333333333
29388, 1.8666666666667, 0.4, 0.20833333333333
29389, 1.8666666666667, 0.35, 0.20833333333333
29390, 1.8666666666667, 0.3, 0.20833333333333
29391, 1.8666666666667, 0.25, 0.20833333333333
29392, 1.8666666666667, 0.2, 0.20833333333333
29393, 1.9083333333333, 1.3, 0.20833333333333
29394, 1.9083333333333, 1.25, 0.20833333333333
29395, 1.9083333333333, 1.2, 0.20833333333333
29396, 1.9083333333333, 1.15, 0.20833333333333
29397, 1.9083333333333, 1.1, 0.20833333333333
29398, 1.9083333333333, 1.05, 0.20833333333333
29399, 1.9083333333333, 1, 0.20833333333333
29400, 1.9083333333333, 0.95, 0.20833333333333
29401, 1.9083333333333, 0.9, 0.20833333333333
29402, 1.9083333333333, 0.85, 0.20833333333333
29403, 1.9083333333333, 0.8, 0.20833333333333
29404, 1.9083333333333, 0.75, 0.20833333333333
29405, 1.9083333333333, 0.7, 0.20833333333333
29406, 1.9083333333333, 0.65, 0.20833333333333
29407, 1.9083333333333, 0.6, 0.20833333333333
29408, 1.9083333333333, 0.55, 0.20833333333333
29409, 1.9083333333333, 0.5, 0.20833333333333
29410, 1.9083333333333, 0.45, 0.20833333333333
29411, 1.9083333333333, 0.4, 0.20833333333333
29412, 1.9083333333333, 0.35, 0.20833333333333
29413, 1.9083333333333, 0.3, 0.20833333333333
29414, 1.9083333333333, 0.25, 0.20833333333333
29415, 1.9083333333333, 0.2, 0.20833333333333
29416, 1.95, 1.3, 0.20833333333333
29417, 1.95, 1.25, 0.20833333333333
29418, 1.95, 1.2, 0.20833333333333
29419, 1.95, 1.15, 0.20833333333333
29420, 1.95, 1.1, 0.20833333333333
29421, 1.95, 1.05, 0.20833333333333
29422, 1.95, 1, 0.20833333333333
29423, 1.95, 0.95, 0.20833333333333
29424, 1.95, 0.9, 0.20833333333333
29425, 1.95, 0.85, 0.20833333333333
29426, 1.95, 0.8, 0.20833333333333
29427, 1.95, 0.75, 0.20833333333333
29428, 1.95, 0.7, 0.20833333333333
29429, 1.95, 0.65, 0.20833333333333
29430, 1.95, 0.6, 0.20833333333333
29431, 1.95, 0.55, 0.20833333333333
29432, 1.95, 0.5, 0.20833333333333
29433, 1.95, 0.45, 0.20833333333333
29434, 1.95, 0.4, 0.20833333333333
29435, 1.95, 0.35, 0.20833333333333
29436, 1.95, 0.3, 0.20833333333333
29437, 1.95, 0.25, 0.20833333333333
29438, 1.95, 0.2, 0.20833333333333
29439, 1.9916666666667, 1.3, 0.20833333333333
29440, 1.9916666666667, 1.25, 0.20833333333333
29441, 1.9916666666667, 1.2, 0.20833333333333
29442, 1.9916666666667, 1.15, 0.20833333333333
29443, 1.9916666666667, 1.1, 0.20833333333333
29444, 1.9916666666667, 1.05, 0.20833333333333
29445, 1.9916666666667, 1, 0.20833333333333
29446, 1.9916666666667, 0.95, 0.20833333333333
29447, 1.9916666666667, 0.9, 0.20833333333333
29448, 1.9916666666667, 0.85, 0.20833333333333
29449, 1.9916666666667, 0.8, 0.20833333333333
29450, 1.9916666666667, 0.75, 0.20833333333333
29451, 1.9916666666667, 0.7, 0.20833333333333
29452, 1.9916666666667, 0.65, 0.20833333333333
29453, 1.9916666666667, 0.6, 0.20833333333333
29454, 1.9916666666667, 0.55, 0.20833333333333
29455, 1.9916666666667, 0.5, 0.20833333333333
29456, 1.9916666666667, 0.45, 0.20833333333333
29457, 1.9916666666667, 0.4, 0.20833333333333
29458, 1.9916666666667, 0.35, 0.20833333333333
29459, 1.9916666666667, 0.3, 0.20833333333333
29460, 1.9916666666667, 0.25, 0.20833333333333
29461, 1.9916666666667, 0.2, 0.20833333333333
29462, 2.0333333333333, 1.3, 0.20833333333333
29463, 2.0333333333333, 1.25, 0.20833333333333
29464, 2.0333333333333, 1.2, 0.20833333333333
29465, 2.0333333333333, 1.15, 0.20833333333333
29466, 2.0333333333333, 1.1, 0.20833333333333
29467, 2.0333333333333, 1.05, 0.20833333333333
29468, 2.0333333333333, 1, 0.20833333333333
29469, 2.0333333333333, 0.95, 0.20833333333333
29470, 2.0333333333333, 0.9, 0.20833333333333
29471, 2.0333333333333, 0.85, 0.20833333333333
29472, 2.0333333333333, 0.8, 0.20833333333333
29473, 2.0333333333333, 0.75, 0.20833333333333
29474, 2.0333333333333, 0.7, 0.20833333333333
29475, 2.0333333333333, 0.65, 0.20833333333333
29476, 2.0333333333333, 0.6, 0.20833333333333
29477, 2.0333333333333, 0.55, 0.20833333333333
29478, 2.0333333333333, 0.5, 0.20833333333333
29479, 2.0333333333333, 0.45, 0.20833333333333
29480, 2.0333333333333, 0.4, 0.20833333333333
29481, 2.0333333333333, 0.35, 0.20833333333333
29482, 2.0333333333333, 0.3, 0.20833333333333
29483, 2.0333333333333, 0.25, 0.20833333333333
29484, 2.0333333333333, 0.2, 0.20833333333333
29485, 2.075, 1.3, 0.20833333333333
29486, 2.075, 1.25, 0.20833333333333
29487, 2.075, 1.2, 0.20833333333333
29488, 2.075, 1.15, 0.20833333333333
29489, 2.075, 1.1, 0.20833333333333
29490, 2.075, 1.05, 0.20833333333333
29491, 2.075, 1, 0.20833333333333
29492, 2.075, 0.95, 0.20833333333333
29493, 2.075, 0.9, 0.20833333333333
29494, 2.075, 0.85, 0.20833333333333
29495, 2.075, 0.8, 0.20833333333333
29496, 2.075, 0.75, 0.20833333333333
29497, 2.075, 0.7, 0.20833333333333
29498, 2.075, 0.65, 0.20833333333333
29499, 2.075, 0.6, 0.20833333333333
29500, 2.075, 0.55, 0.20833333333333
29501, 2.075, 0.5, 0.20833333333333
29502, 2.075, 0.45, 0.20833333333333
29503, 2.075, 0.4, 0.20833333333333
29504, 2.075, 0.35, 0.20833333333333
29505, 2.075, 0.3, 0.20833333333333
29506, 2.075, 0.25, 0.20833333333333
29507, 2.075, 0.2, 0.20833333333333
29508, 2.1166666666667, 1.3, 0.20833333333333
29509, 2.1166666666667, 1.25, 0.20833333333333
29510, 2.1166666666667, 1.2, 0.20833333333333
29511, 2.1166666666667, 1.15, 0.20833333333333
29512, 2.1166666666667, 1.1, 0.20833333333333
29513, 2.1166666666667, 1.05, 0.20833333333333
29514, 2.1166666666667, 1, 0.20833333333333
29515, 2.1166666666667, 0.95, 0.20833333333333
29516, 2.1166666666667, 0.9, 0.20833333333333
29517, 2.1166666666667, 0.85, 0.20833333333333
29518, 2.1166666666667, 0.8, 0.20833333333333
29519, 2.1166666666667, 0.75, 0.20833333333333
29520, 2.1166666666667, 0.7, 0.20833333333333
29521, 2.1166666666667, 0.65, 0.20833333333333
29522, 2.1166666666667, 0.6, 0.20833333333333
29523, 2.1166666666667, 0.55, 0.20833333333333
29524, 2.1166666666667, 0.5, 0.20833333333333
29525, 2.1166666666667, 0.45, 0.20833333333333
29526, 2.1166666666667, 0.4, 0.20833333333333
29527, 2.1166666666667, 0.35, 0.20833333333333
29528, 2.1166666666667, 0.3, 0.20833333333333
29529, 2.1166666666667, 0.25, 0.20833333333333
29530, 2.1166666666667, 0.2, 0.20833333333333
29531, 2.1583333333333, 1.3, 0.20833333333333
29532, 2.1583333333333, 1.25, 0.20833333333333
29533, 2.1583333333333, 1.2, 0.20833333333333
29534, 2.1583333333333, 1.15, 0.20833333333333
29535, 2.1583333333333, 1.1, 0.20833333333333
29536, 2.1583333333333, 1.05, 0.20833333333333
29537, 2.1583333333333, 1, 0.20833333333333
29538, 2.1583333333333, 0.95, 0.20833333333333
29539, 2.1583333333333, 0.9, 0.20833333333333
29540, 2.1583333333333, 0.85, 0.20833333333333
29541, 2.1583333333333, 0.8, 0.20833333333333
29542, 2.1583333333333, 0.75, 0.20833333333333
29543, 2.1583333333333, 0.7, 0.20833333333333
29544, 2.1583333333333, 0.65, 0.20833333333333
29545, 2.1583333333333, 0.6, 0.20833333333333
29546, 2.1583333333333, 0.55, 0.20833333333333
29547, 2.1583333333333, 0.5, 0.20833333333333
29548, 2.1583333333333, 0.45, 0.20833333333333
29549, 2.1583333333333, 0.4, 0.20833333333333
29550, 2.1583333333333, 0.35, 0.20833333333333
29551, 2.1583333333333, 0.3, 0.20833333333333
29552, 2.1583333333333, 0.25, 0.20833333333333
29553, 2.1583333333333, 0.2, 0.20833333333333
29554, 1.2416666666667, 1.3, 0.25
29555, 1.2416666666667, 1.25, 0.25
29556, 1.2416666666667, 1.2, 0.25
29557, 1.2416666666667, 1.15, 0.25
29558, 1.2416666666667, 1.1, 0.25
29559, 1.2416666666667, 1.05, 0.25
29560, 1.2416666666667, 1, 0.25
29561, 1.2416666666667, 0.95, 0.25
29562, 1.2416666666667, 0.9, 0.25
29563, 1.2416666666667, 0.85, 0.25
29564, 1.2416666666667, 0.8, 0.25
29565, 1.2416666666667, 0.75, 0.25
29566, 1.2416666666667, 0.7, 0.25
29567, 1.2416666666667, 0.65, 0.25
29568, 1.2416666666667, 0.6, 0.25
29569, 1.2416666666667, 0.55, 0.25
29570, 1.2416666666667, 0.5, 0.25
29571, 1.2416666666667, 0.45, 0.25
29572, 1.2416666666667, 0.4, 0.25
29573, 1.2416666666667, 0.35, 0.25
29574, 1.2416666666667, 0.3, 0.25
29575, 1.2416666666667, 0.25, 0.25
29576, 1.2416666666667, 0.2, 0.25
29577, 1.2833333333333, 1.3, 0.25
29578, 1.2833333333333, 1.25, 0.25
29579, 1.2833333333333, 1.2, 0.25
29580, 1.2833333333333, 1.15, 0.25
29581, 1.2833333333333, 1.1, 0.25
29582, 1.2833333333333, 1.05, 0.25
29583, 1.2833333333333, 1, 0.25
29584, 1.2833333333333, 0.95, 0.25
29585, 1.2833333333333, 0.9, 0.25
29586, 1.2833333333333, 0.85, 0.25
29587, 1.2833333333333, 0.8, 0.25
29588, 1.2833333333333, 0.75, 0.25
29589, 1.2833333333333, 0.7, 0.25
29590, 1.2833333333333, 0.65, 0.25
29591, 1.2833333333333, 0.6, 0.25
29592, 1.2833333333333, 0.55, 0.25
29593, 1.2833333333333, 0.5, 0.25
29594, 1.2833333333333, 0.45, 0.25
29595, 1.2833333333333, 0.4, 0.25
29596, 1.2833333333333, 0.35, 0.25
29597, 1.2833333333333, 0.3, 0.25
29598, 1.2833333333333, 0.25, 0.25
29599, 1.2833333333333, 0.2, 0.25
29600, 1.325, 1.3, 0.25
29601, 1.325, 1.25, 0.25
29602, 1.325, 1.2, 0.25
29603, 1.325, 1.15, 0.25
29604, 1.325, 1.1, 0.25
29605, 1.325, 1.05, 0.25
29606, 1.325, 1, 0.25
29607, 1.325, 0.95, 0.25
29608, 1.325, 0.9, 0.25
29609, 1.325, 0.85, 0.25
29610, 1.325, 0.8, 0.25
29611, 1.325, 0.75, 0.25
29612, 1.325, 0.7, 0.25
29613, 1.325, 0.65, 0.25
29614, 1.325, 0.6, 0.25
29615, 1.325, 0.55, 0.25
29616, 1.325, 0.5, 0.25
29617, 1.325, 0.45, 0.25
29618, 1.325, 0.4, 0.25
29619, 1.325, 0.35, 0.25
29620, 1.325, 0.3, 0.25
29621, 1.325, 0.25, 0.25
29622, 1.325, 0.2, 0.25
29623, 1.3666666666667, 1.3, 0.25
29624, 1.3666666666667, 1.25, 0.25
29625, 1.3666666666667, 1.2, 0.25
29626, 1.3666666666667, 1.15, 0.25
29627, 1.3666666666667, 1.1, 0.25
29628, 1.3666666666667, 1.05, 0.25
29629, 1.3666666666667, 1, 0.25
29630, 1.3666666666667, 0.95, 0.25
29631, 1.3666666666667, 0.9, 0.25
29632, 1.3666666666667, 0.85, 0.25
29633, 1.3666666666667, 0.8, 0.25
29634, 1.3666666666667, 0.75, 0.25
29635, 1.3666666666667, 0.7, 0.25
29636, 1.3666666666667, 0.65, 0.25
29637, 1.3666666666667, 0.6, 0.25
29638, 1.3666666666667, 0.55, 0.25
29639, 1.3666666666667, 0.5, 0.25
29640, 1.3666666666667, 0.45, 0.25
29641, 1.3666666666667, 0.4, 0.25
29642, 1.3666666666667, 0.35, 0.25
29643, 1.3666666666667, 0.3, 0.25
29644, 1.3666666666667, 0.25, 0.25
29645, 1.3666666666667, 0.2, 0.25
29646, 1.4083333333333, 1.3, 0.25
29647, 1.4083333333333, 1.25, 0.25
29648, 1.4083333333333, 1.2, 0.25
29649, 1.4083333333333, 1.15, 0.25
29650, 1.4083333333333, 1.1, 0.25
29651, 1.4083333333333, 1.05, 0.25
29652, 1.4083333333333, 1, 0.25
29653, 1.4083333333333, 0.95, 0.25
29654, 1.4083333333333, 0.9, 0.25
29655, 1.4083333333333, 0.85, 0.25
29656, 1.4083333333333, 0.8, 0.25
29657, 1.4083333333333, 0.75, 0.25
29658, 1.4083333333333, 0.7, 0.25
29659, 1.4083333333333, 0.65, 0.25
29660, 1.4083333333333, 0.6, 0.25
29661, 1.4083333333333, 0.55, 0.25
29662, 1.4083333333333, 0.5, 0.25
29663, 1.4083333333333, 0.45, 0.25
29664, 1.4083333333333, 0.4, 0.25
29665, 1.4083333333333, 0.35, 0.25
29666, 1.4083333333333, 0.3, 0.25
29667, 1.4083333333333, 0.25, 0.25
29668, 1.4083333333333, 0.2, 0.25
29669, 1.45, 1.3, 0.25
29670, 1.45, 1.25, 0.25
29671, 1.45, 1.2, 0.25
29672, 1.45, 1.15, 0.25
29673, 1.45, 1.1, 0.25
29674, 1.45, 1.05, 0.25
29675, 1.45, 1, 0.25
29676, 1.45, 0.95, 0.25
29677, 1.45, 0.9, 0.25
29678, 1.45, 0.85, 0.25
29679, 1.45, 0.8, 0.25
29680, 1.45, 0.75, 0.25
29681, 1.45, 0.7, 0.25
29682, 1.45, 0.65, 0.25
29683, 1.45, 0.6, 0.25
29684, 1.45, 0.55, 0.25
29685, 1.45, 0.5, 0.25
29686, 1.45, 0.45, 0.25
29687, 1.45, 0.4, 0.25
29688, 1.45, 0.35, 0.25
29689, 1.45, 0.3, 0.25
29690, 1.45, 0.25, 0.25
29691, 1.45, 0.2, 0.25
29692, 1.4916666666667, 1.3, 0.25
29693, 1.4916666666667, 1.25, 0.25
29694, 1.4916666666667, 1.2, 0.25
29695, 1.4916666666667, 1.15, 0.25
29696, 1.4916666666667, 1.1, 0.25
29697, 1.4916666666667, 1.05, 0.25
29698, 1.4916666666667, 1, 0.25
29699, 1.4916666666667, 0.95, 0.25
29700, 1.4916666666667, 0.9, 0.25
29701, 1.4916666666667, 0.85, 0.25
29702, 1.4916666666667, 0.8, 0.25
29703, 1.4916666666667, 0.75, 0.25
29704, 1.4916666666667, 0.7, 0.25
29705, 1.4916666666667, 0.65, 0.25
29706, 1.4916666666667, 0.6, 0.25
29707, 1.4916666666667, 0.55, 0.25
29708, 1.4916666666667, 0.5, 0.25
29709, 1.4916666666667, 0.45, 0.25
29710, 1.4916666666667, 0.4, 0.25
29711, 1.4916666666667, 0.35, 0.25
29712, 1.4916666666667, 0.3, 0.25
29713, 1.4916666666667, 0.25, 0.25
29714, 1.4916666666667, 0.2, 0.25
29715, 1.5333333333333, 1.3, 0.25
29716, 1.5333333333333, 1.25, 0.25
29717, 1.5333333333333, 1.2, 0.25
29718, 1.5333333333333, 1.15, 0.25
29719, 1.5333333333333, 1.1, 0.25
29720, 1.5333333333333, 1.05, 0.25
29721, 1.5333333333333, 1, 0.25
29722, 1.5333333333333, 0.95, 0.25
29723, 1.5333333333333, 0.9, 0.25
29724, 1.5333333333333, 0.85, 0.25
29725, 1.5333333333333, 0.8, 0.25
29726, 1.5333333333333, 0.75, 0.25
29727, 1.5333333333333, 0.7, 0.25
29728, 1.5333333333333, 0.65, 0.25
29729, 1.5333333333333, 0.6, 0.25
29730, 1.5333333333333, 0.55, 0.25
29731, 1.5333333333333, 0.5, 0.25
29732, 1.5333333333333, 0.45, 0.25
29733, 1.5333333333333, 0.4, 0.25
29734, 1.5333333333333, 0.35, 0.25
29735, 1.5333333333333, 0.3, 0.25
29736, 1.5333333333333, 0.25, 0.25
29737, 1.5333333333333, 0.2, 0.25
29738, 1.575, 1.3, 0.25
29739, 1.575, 1.25, 0.25
29740, 1.575, 1.2, 0.25
29741, 1.575, 1.15, 0.25
29742, 1.575, 1.1, 0.25
29743, 1.575, 1.05, 0.25
29744, 1.575, 1, 0.25
29745, 1.575, 0.95, 0.25
29746, 1.575, 0.9, 0.25
29747, 1.575, 0.85, 0.25
29748, 1.575, 0.8, 0.25
29749, 1.575, 0.75, 0.25
29750, 1.575, 0.7, 0.25
29751, 1.575, 0.65, 0.25
29752, 1.575, 0.6, 0.25
29753, 1.575, 0.55, 0.25
29754, 1.575, 0.5, 0.25
29755, 1.575, 0.45, 0.25
29756, 1.575, 0.4, 0.25
29757, 1.575, 0.35, 0.25
29758, 1.575, 0.3, 0.25
29759, 1.575, 0.25, 0.25
29760, 1.575, 0.2, 0.25
29761, 1.6166666666667, 1.3, 0.25
29762, 1.6166666666667, 1.25, 0.25
29763, 1.6166666666667, 1.2, 0.25
29764, 1.6166666666667, 1.15, 0.25
29765, 1.6166666666667, 1.1, 0.25
29766, 1.6166666666667, 1.05, 0.25
29767, 1.6166666666667, 1, 0.25
29768, 1.6166666666667, 0.95, 0.25
29769, 1.6166666666667, 0.9, 0.25
29770, 1.6166666666667, 0.85, 0.25
29771, 1.6166666666667, 0.8, 0.25
29772, 1.6166666666667, 0.75, 0.25
29773, 1.6166666666667, 0.7, 0.25
29774, 1.6166666666667, 0.65, 0.25
29775, 1.6166666666667, 0.6, 0.25
29776, 1.6166666666667, 0.55, 0.25
29777, 1.6166666666667, 0.5, 0.25
29778, 1.6166666666667, 0.45, 0.25
29779, 1.6166666666667, 0.4, 0.25
29780, 1.6166666666667, 0.35, 0.25
29781, 1.6166666666667, 0.3, 0.25
29782, 1.6166666666667, 0.25, 0.25
29783, 1.6166666666667, 0.2, 0.25
29784, 1.6583333333333, 1.3, 0.25
29785, 1.6583333333333, 1.25, 0.25
29786, 1.6583333333333, 1.2, 0.25
29787, 1.6583333333333, 1.15, 0.25
29788, 1.6583333333333, 1.1, 0.25
29789, 1.6583333333333, 1.05, 0.25
29790, 1.6583333333333, 1, 0.25
29791, 1.6583333333333, 0.95, 0.25
29792, 1.6583333333333, 0.9, 0.25
29793, 1.6583333333333, 0.85, 0.25
29794, 1.6583333333333, 0.8, 0.25
29795, 1.6583333333333, 0.75, 0.25
29796, 1.6583333333333, 0.7, 0.25
29797, 1.6583333333333, 0.65, 0.25
29798, 1.6583333333333, 0.6, 0.25
29799, 1.6583333333333, 0.55, 0.25
29800, 1.6583333333333, 0.5, 0.25
29801, 1.6583333333333, 0.45, 0.25
29802, 1.6583333333333, 0.4, 0.25
29803, 1.6583333333333, 0.35, 0.25
29804, 1.6583333333333, 0.3, 0.25
29805, 1.6583333333333, 0.25, 0.25
29806, 1.6583333333333, 0.2, 0.25
29807, 1.7, 1.3, 0.25
29808, 1.7, 1.25, 0.25
29809, 1.7, 1.2, 0.25
29810, 1.7, 1.15, 0.25
29811, 1.7, 1.1, 0.25
29812, 1.7, 1.05, 0.25
29813, 1.7, 1, 0.25
29814, 1.7, 0.95, 0.25
29815, 1.7, 0.9, 0.25
29816, 1.7, 0.85, 0.25
29817, 1.7, 0.8, 0.25
29818, 1.7, 0.75, 0.25
29819, 1.7, 0.7, 0.25
29820, 1.7, 0.65, 0.25
29821, 1.7, 0.6, 0.25
29822, 1.7, 0.55, 0.25
29823, 1.7, 0.5, 0.25
29824, 1.7, 0.45, 0.25
29825, 1.7, 0.4, 0.25
29826, 1.7, 0.35, 0.25
29827, 1.7, 0.3, 0.25
29828, 1.7, 0.25, 0.25
29829, 1.7, 0.2, 0.25
29830, 1.7416666666667, 1.3, 0.25
29831, 1.7416666666667, 1.25, 0.25
29832, 1.7416666666667, 1.2, 0.25
29833, 1.7416666666667, 1.15, 0.25
29834, 1.7416666666667, 1.1, 0.25
29835, 1.7416666666667, 1.05, 0.25
29836, 1.7416666666667, 1, 0.25
29837, 1.7416666666667, 0.95, 0.25
29838, 1.7416666666667, 0.9, 0.25
29839, 1.7416666666667, 0.85, 0.25
29840, 1.7416666666667, 0.8, 0.25
29841, 1.7416666666667, 0.75, 0.25
29842, 1.7416666666667, 0.7, 0.25
29843, 1.7416666666667, 0.65, 0.25
29844, 1.7416666666667, 0.6, 0.25
29845, 1.7416666666667, 0.55, 0.25
29846, 1.7416666666667, 0.5, 0.25
29847, 1.7416666666667, 0.45, 0.25
29848, 1.7416666666667, 0.4, 0.25
29849, 1.7416666666667, 0.35, 0.25
29850, 1.7416666666667, 0.3, 0.25
29851, 1.7416666666667, 0.25, 0.25
29852, 1.7416666666667, 0.2, 0.25
29853, 1.7833333333333, 1.3, 0.25
29854, 1.7833333333333, 1.25, 0.25
29855, 1.7833333333333, 1.2, 0.25
29856, 1.7833333333333, 1.15, 0.25
29857, 1.7833333333333, 1.1, 0.25
29858, 1.7833333333333, 1.05, 0.25
29859, 1.7833333333333, 1, 0.25
29860, 1.7833333333333, 0.95, 0.25
29861, 1.7833333333333, 0.9, 0.25
29862, 1.7833333333333, 0.85, 0.25
29863, 1.7833333333333, 0.8, 0.25
29864, 1.7833333333333, 0.75, 0.25
29865, 1.7833333333333, 0.7, 0.25
29866, 1.7833333333333, 0.65, 0.25
29867, 1.7833333333333, 0.6, 0.25
29868, 1.7833333333333, 0.55, 0.25
29869, 1.7833333333333, 0.5, 0.25
29870, 1.7833333333333, 0.45, 0.25
29871, 1.7833333333333, 0.4, 0.25
29872, 1.7833333333333, 0.35, 0.25
29873, 1.7833333333333, 0.3, 0.25
29874, 1.7833333333333, 0.25, 0.25
29875, 1.7833333333333, 0.2, 0.25
29876, 1.825, 1.3, 0.25
29877, 1.825, 1.25, 0.25
29878, 1.825, 1.2, 0.25
29879, 1.825, 1.15, 0.25
29880, 1.825, 1.1, 0.25
29881, 1.825, 1.05, 0.25
29882, 1.825, 1, 0.25
29883, 1.825, 0.95, 0.25
29884, 1.825, 0.9, 0.25
29885, 1.825, 0.85, 0.25
29886, 1.825, 0.8, 0.25
29887, 1.825, 0.75, 0.25
29888, 1.825, 0.7, 0.25
29889, 1.825, 0.65, 0.25
29890, 1.825, 0.6, 0.25
29891, 1.825, 0.55, 0.25
29892, 1.825, 0.5, 0.25
29893, 1.825, 0.45, 0.25
29894, 1.825, 0.4, 0.25
29895, 1.825, 0.35, 0.25
29896, 1.825, 0.3, 0.25
29897, 1.825, 0.25, 0.25
29898, 1.825, 0.2, 0.25
29899, 1.8666666666667, 1.3, 0.25
29900, 1.8666666666667, 1.25, 0.25
29901, 1.8666666666667, 1.2, 0.25
29902, 1.8666666666667, 1.15, 0.25
29903, 1.8666666666667, 1.1, 0.25
29904, 1.8666666666667, 1.05, 0.25
29905, 1.8666666666667, 1, 0.25
29906, 1.8666666666667, 0.95, 0.25
29907, 1.8666666666667, 0.9, 0.25
29908, 1.8666666666667, 0.85, 0.25
29909, 1.8666666666667, 0.8, 0.25
29910, 1.8666666666667, 0.75, 0.25
29911, 1.8666666666667, 0.7, 0.25
29912, 1.8666666666667, 0.65, 0.25
29913, 1.8666666666667, 0.6, 0.25
29914, 1.8666666666667, 0.55, 0.25
29915, 1.8666666666667, 0.5, 0.25
29916, 1.8666666666667, 0.45, 0.25
29917, 1.8666666666667, 0.4, 0.25
29918, 1.8666666666667, 0.35, 0.25
29919, 1.8666666666667, 0.3, 0.25
29920, 1.8666666666667, 0.25, 0.25
29921, 1.8666666666667, 0.2, 0.25
29922, 1.9083333333333, 1.3, 0.25
29923, 1.9083333333333, 1.25, 0.25
29924, 1.9083333333333, 1.2, 0.25
29925, 1.9083333333333, 1.15, 0.25
29926, 1.9083333333333, 1.1, 0.25
29927, 1.9083333333333, 1.05, 0.25
29928, 1.9083333333333, 1, 0.25
29929, 1.9083333333333, 0.95, 0.25
29930, 1.9083333333333, 0.9, 0.25
29931, 1.9083333333333, 0.85, 0.25
29932, 1.9083333333333, 0.8, 0.25
29933, 1.9083333333333, 0.75, 0.25
29934, 1.9083333333333, 0.7, 0.25
29935, 1.9083333333333, 0.65, 0.25
29936, 1.9083333333333, 0.6, 0.25
29937, 1.9083333333333, 0.55, 0.25
29938, 1.9083333333333, 0.5, 0.25
29939, 1.9083333333333, 0.45, 0.25
29940, 1.9083333333333, 0.4, 0.25
29941, 1.9083333333333, 0.35, 0.25
29942, 1.9083333333333, 0.3, 0.25
29943, 1.9083333333333, 0.25, 0.25
29944, 1.9083333333333, 0.2, 0.25
29945, 1.95, 1.3, 0.25
29946, 1.95, 1.25, 0.25
29947, 1.95, 1.2, 0.25
29948, 1.95, 1.15, 0.25
29949, 1.95, 1.1, 0.25
29950, 1.95, 1.05, 0.25
29951, 1.95, 1, 0.25
29952, 1.95, 0.95, 0.25
29953, 1.95, 0.9, 0.25
29954, 1.95, 0.85, 0.25
29955, 1.95, 0.8, 0.25
29956, 1.95, 0.75, 0.25
29957, 1.95, 0.7, 0.25
29958, 1.95, 0.65, 0.25
29959, 1.95, 0.6, 0.25
29960, 1.95, 0.55, 0.25
29961, 1.95, 0.5, 0.25
29962, 1.95, 0.45, 0.25
29963, 1.95, 0.4, 0.25
29964, 1.95, 0.35, 0.25
29965, 1.95, 0.3, 0.25
29966, 1.95, 0.25, 0.25
29967, 1.95, 0.2, 0.25
29968, 1.9916666666667, 1.3, 0.25
29969, 1.9916666666667, 1.25, 0.25
29970, 1.9916666666667, 1.2, 0.25
29971, 1.9916666666667, 1.15, 0.25
29972, 1.9916666666667, 1.1, 0.25
29973, 1.9916666666667, 1.05, 0.25
29974, 1.9916666666667, 1, 0.25
29975, 1.9916666666667, 0.95, 0.25
29976, 1.9916666666667, 0.9, 0.25
29977, 1.9916666666667, 0.85, 0.25
29978, 1.9916666666667, 0.8, 0.25
29979, 1.9916666666667, 0.75, 0.25
29980, 1.9916666666667, 0.7, 0.25
29981, 1.9916666666667, 0.65, 0.25
29982, 1.9916666666667, 0.6, 0.25
29983, 1.9916666666667, 0.55, 0.25
29984, 1.9916666666667, 0.5, 0.25
29985, 1.9916666666667, 0.45, 0.25
29986, 1.9916666666667, 0.4, 0.25
29987, 1.9916666666667, 0.35, 0.25
29988, 1.9916666666667, 0.3, 0.25
29989, 1.9916666666667, 0.25, 0.25
29990, 1.9916666666667, 0.2, 0.25
29991, 2.0333333333333, 1.3, 0.25
29992, 2.0333333333333, 1.25, 0.25
29993, 2.0333333333333, 1.2, 0.25
29994, 2.0333333333333, 1.15, 0.25
29995, 2.0333333333333, 1.1, 0.25
29996, 2.0333333333333, 1.05, 0.25
29997, 2.0333333333333, 1, 0.25
29998, 2.0333333333333, 0.95, 0.25
29999, 2.0333333333333, 0.9, 0.25
30000, 2.0333333333333, 0.85, 0.25
30001, 2.0333333333333, 0.8, 0.25
30002, 2.0333333333333, 0.75, 0.25
30003, 2.0333333333333, 0.7, 0.25
30004, 2.0333333333333, 0.65, 0.25
30005, 2.0333333333333, 0.6, 0.25
30006, 2.0333333333333, 0.55, 0.25
30007, 2.0333333333333, 0.5, 0.25
30008, 2.0333333333333, 0.45, 0.25
30009, 2.0333333333333, 0.4, 0.25
30010, 2.0333333333333, 0.35, 0.25
30011, 2.0333333333333, 0.3, 0.25
30012, 2.0333333333333, 0.25, 0.25
30013, 2.0333333333333, 0.2, 0.25
30014, 2.075, 1.3, 0.25
30015, 2.075, 1.25, 0.25
30016, 2.075, 1.2, 0.25
30017, 2.075, 1.15, 0.25
30018, 2.075, 1.1, 0.25
30019, 2.075, 1.05, 0.25
30020, 2.075, 1, 0.25
30021, 2.075, 0.95, 0.25
30022, 2.075, 0.9, 0.25
30023, 2.075, 0.85, 0.25
30024, 2.075, 0.8, 0.25
30025, 2.075, 0.75, 0.25
30026, 2.075, 0.7, 0.25
30027, 2.075, 0.65, 0.25
30028, 2.075, 0.6, 0.25
30029, 2.075, 0.55, 0.25
30030, 2.075, 0.5, 0.25
30031, 2.075, 0.45, 0.25
30032, 2.075, 0.4, 0.25
30033, 2.075, 0.35, 0.25
30034, 2.075, 0.3, 0.25
30035, 2.075, 0.25, 0.25
30036, 2.075, 0.2, 0.25
30037, 2.1166666666667, 1.3, 0.25
30038, 2.1166666666667, 1.25, 0.25
30039, 2.1166666666667, 1.2, 0.25
30040, 2.1166666666667, 1.15, 0.25
30041, 2.1166666666667, 1.1, 0.25
30042, 2.1166666666667, 1.05, 0.25
30043, 2.1166666666667, 1, 0.25
30044, 2.1166666666667, 0.95, 0.25
30045, 2.1166666666667, 0.9, 0.25
30046, 2.1166666666667, 0.85, 0.25
30047, 2.1166666666667, 0.8, 0.25
30048, 2.1166666666667, 0.75, 0.25
30049, 2.1166666666667, 0.7, 0.25
30050, 2.1166666666667, 0.65, 0.25
30051, 2.1166666666667, 0.6, 0.25
30052, 2.1166666666667, 0.55, 0.25
30053, 2.1166666666667, 0.5, 0.25
30054, 2.1166666666667, 0.45, 0.25
30055, 2.1166666666667, 0.4, 0.25
30056, 2.1166666666667, 0.35, 0.25
30057, 2.1166666666667, 0.3, 0.25
30058, 2.1166666666667, 0.25, 0.25
30059, 2.1166666666667, 0.2, 0.25
30060, 2.1583333333333, 1.3, 0.25
30061, 2.1583333333333, 1.25, 0.25
30062, 2.1583333333333, 1.2, 0.25
30063, 2.1583333333333, 1.15, 0.25
30064, 2.1583333333333, 1.1, 0.25
30065, 2.1583333333333, 1.05, 0.25
30066, 2.1583333333333, 1, 0.25
30067, 2.1583333333333, 0.95, 0.25
30068, 2.1583333333333, 0.9, 0.25
30069, 2.1583333333333, 0.85, 0.25
30070, 2.1583333333333, 0.8, 0.25
30071, 2.1583333333333, 0.75, 0.25
30072, 2.1583333333333, 0.7, 0.25
30073, 2.1583333333333, 0.65, 0.25
30074, 2.1583333333333, 0.6, 0.25
30075, 2.1583333333333, 0.55, 0.25
30076, 2.1583333333333, 0.5, 0.25
30077, 2.1583333333333, 0.45, 0.25
30078, 2.1583333333333, 0.4, 0.25
30079, 2.1583333333333, 0.35, 0.25
30080, 2.1583333333333, 0.3, 0.25
30081, 2.1583333333333, 0.25, 0.25
30082, 2.1583333333333, 0.2, 0.25
30083, 1.2416666666667, 1.3, 0.29166666666667
30084, 1.2416666666667, 1.25, 0.29166666666667
30085, 1.2416666666667, 1.2, 0.29166666666667
30086, 1.2416666666667, 1.15, 0.29166666666667
30087, 1.2416666666667, 1.1, 0.29166666666667
30088, 1.2416666666667, 1.05, 0.29166666666667
30089, 1.2416666666667, 1, 0.29166666666667
30090, 1.2416666666667, 0.95, 0.29166666666667
30091, 1.2416666666667, 0.9, 0.29166666666667
30092, 1.2416666666667, 0.85, 0.29166666666667
30093, 1.2416666666667, 0.8, 0.29166666666667
30094, 1.2416666666667, 0.75, 0.29166666666667
30095, 1.2416666666667, 0.7, 0.29166666666667
30096, 1.2416666666667, 0.65, 0.29166666666667
30097, 1.2416666666667, 0.6, 0.29166666666667
30098, 1.2416666666667, 0.55, 0.29166666666667
30099, 1.2416666666667, 0.5, 0.29166666666667
30100, 1.2416666666667, 0.45, 0.29166666666667
30101, 1.2416666666667, 0.4, 0.29166666666667
30102, 1.2416666666667, 0.35, 0.29166666666667
30103, 1.2416666666667, 0.3, 0.29166666666667
30104, 1.2416666666667, 0.25, 0.29166666666667
30105, 1.2416666666667, 0.2, 0.29166666666667
30106, 1.2833333333333, 1.3, 0.29166666666667
30107, 1.2833333333333, 1.25, 0.29166666666667
30108, 1.2833333333333, 1.2, 0.29166666666667
30109, 1.2833333333333, 1.15, 0.29166666666667
30110, 1.2833333333333, 1.1, 0.29166666666667
30111, 1.2833333333333, 1.05, 0.29166666666667
30112, 1.2833333333333, 1, 0.29166666666667
30113, 1.2833333333333, 0.95, 0.29166666666667
30114, 1.2833333333333, 0.9, 0.29166666666667
30115, 1.2833333333333, 0.85, 0.29166666666667
30116, 1.2833333333333, 0.8, 0.29166666666667
30117, 1.2833333333333, 0.75, 0.29166666666667
30118, 1.2833333333333, 0.7, 0.29166666666667
30119, 1.2833333333333, 0.65, 0.29166666666667
30120, 1.2833333333333, 0.6, 0.29166666666667
30121, 1.2833333333333, 0.55, 0.29166666666667
30122, 1.2833333333333, 0.5, 0.29166666666667
30123, 1.2833333333333, 0.45, 0.29166666666667
30124, 1.2833333333333, 0.4, 0.29166666666667
30125, 1.2833333333333, 0.35, 0.29166666666667
30126, 1.2833333333333, 0.3, 0.29166666666667
30127, 1.2833333333333, 0.25, 0.29166666666667
30128, 1.2833333333333, 0.2, 0.29166666666667
30129, 1.325, 1.3, 0.29166666666667
30130, 1.325, 1.25, 0.29166666666667
30131, 1.325, 1.2, 0.29166666666667
30132, 1.325, 1.15, 0.29166666666667
30133, 1.325, 1.1, 0.29166666666667
30134, 1.325, 1.05, 0.29166666666667
30135, 1.325, 1, 0.29166666666667
30136, 1.325, 0.95, 0.29166666666667
30137, 1.325, 0.9, 0.29166666666667
30138, 1.325, 0.85, 0.29166666666667
30139, 1.325, 0.8, 0.29166666666667
30140, 1.325, 0.75, 0.29166666666667
30141, 1.325, 0.7, 0.29166666666667
30142, 1.325, 0.65, 0.29166666666667
30143, 1.325, 0.6, 0.29166666666667
30144, 1.325, 0.55, 0.29166666666667
30145, 1.325, 0.5, 0.29166666666667
30146, 1.325, 0.45, 0.29166666666667
30147, 1.325, 0.4, 0.29166666666667
30148, 1.325, 0.35, 0.29166666666667
30149, 1.325, 0.3, 0.29166666666667
30150, 1.325, 0.25, 0.29166666666667
30151, 1.325, 0.2, 0.29166666666667
30152, 1.3666666666667, 1.3, 0.29166666666667
30153, 1.3666666666667, 1.25, 0.29166666666667
30154, 1.3666666666667, 1.2, 0.29166666666667
30155, 1.3666666666667, 1.15, 0.29166666666667
30156, 1.3666666666667, 1.1, 0.29166666666667
30157, 1.3666666666667, 1.05, 0.29166666666667
30158, 1.3666666666667, 1, 0.29166666666667
30159, 1.3666666666667, 0.95, 0.29166666666667
30160, 1.3666666666667, 0.9, 0.29166666666667
30161, 1.3666666666667, 0.85, 0.29166666666667
30162, 1.3666666666667, 0.8, 0.29166666666667
30163, 1.3666666666667, 0.75, 0.29166666666667
30164, 1.3666666666667, 0.7, 0.29166666666667
30165, 1.3666666666667, 0.65, 0.29166666666667
30166, 1.3666666666667, 0.6, 0.29166666666667
30167, 1.3666666666667, 0.55, 0.29166666666667
30168, 1.3666666666667, 0.5, 0.29166666666667
30169, 1.3666666666667, 0.45, 0.29166666666667
30170, 1.3666666666667, 0.4, 0.29166666666667
30171, 1.3666666666667, 0.35, 0.29166666666667
30172, 1.3666666666667, 0.3, 0.29166666666667
30173, 1.3666666666667, 0.25, 0.29166666666667
30174, 1.3666666666667, 0.2, 0.29166666666667
30175, 1.4083333333333, 1.3, 0.29166666666667
30176, 1.4083333333333, 1.25, 0.29166666666667
30177, 1.4083333333333, 1.2, 0.29166666666667
30178, 1.4083333333333, 1.15, 0.29166666666667
30179, 1.4083333333333, 1.1, 0.29166666666667
30180, 1.4083333333333, 1.05, 0.29166666666667
30181, 1.4083333333333, 1, 0.29166666666667
30182, 1.4083333333333, 0.95, 0.29166666666667
30183, 1.4083333333333, 0.9, 0.29166666666667
30184, 1.4083333333333, 0.85, 0.29166666666667
30185, 1.4083333333333, 0.8, 0.29166666666667
30186, 1.4083333333333, 0.75, 0.29166666666667
30187, 1.4083333333333, 0.7, 0.29166666666667
30188, 1.4083333333333, 0.65, 0.29166666666667
30189, 1.4083333333333, 0.6, 0.29166666666667
30190, 1.4083333333333, 0.55, 0.29166666666667
30191, 1.4083333333333, 0.5, 0.29166666666667
30192, 1.4083333333333, 0.45, 0.29166666666667
30193, 1.4083333333333, 0.4, 0.29166666666667
30194, 1.4083333333333, 0.35, 0.29166666666667
30195, 1.4083333333333, 0.3, 0.29166666666667
30196, 1.4083333333333, 0.25, 0.29166666666667
30197, 1.4083333333333, 0.2, 0.29166666666667
30198, 1.45, 1.3, 0.29166666666667
30199, 1.45, 1.25, 0.29166666666667
30200, 1.45, 1.2, 0.29166666666667
30201, 1.45, 1.15, 0.29166666666667
30202, 1.45, 1.1, 0.29166666666667
30203, 1.45, 1.05, 0.29166666666667
30204, 1.45, 1, 0.29166666666667
30205, 1.45, 0.95, 0.29166666666667
30206, 1.45, 0.9, 0.29166666666667
30207, 1.45, 0.85, 0.29166666666667
30208, 1.45, 0.8, 0.29166666666667
30209, 1.45, 0.75, 0.29166666666667
30210, 1.45, 0.7, 0.29166666666667
30211, 1.45, 0.65, 0.29166666666667
30212, 1.45, 0.6, 0.29166666666667
30213, 1.45, 0.55, 0.29166666666667
30214, 1.45, 0.5, 0.29166666666667
30215, 1.45, 0.45, 0.29166666666667
30216, 1.45, 0.4, 0.29166666666667
30217, 1.45, 0.35, 0.29166666666667
30218, 1.45, 0.3, 0.29166666666667
30219, 1.45, 0.25, 0.29166666666667
30220, 1.45, 0.2, 0.29166666666667
30221, 1.4916666666667, 1.3, 0.29166666666667
30222, 1.4916666666667, 1.25, 0.29166666666667
30223, 1.4916666666667, 1.2, 0.29166666666667
30224, 1.4916666666667, 1.15, 0.29166666666667
30225, 1.4916666666667, 1.1, 0.29166666666667
30226, 1.4916666666667, 1.05, 0.29166666666667
30227, 1.4916666666667, 1, 0.29166666666667
30228, 1.4916666666667, 0.95, 0.29166666666667
30229, 1.4916666666667, 0.9, 0.29166666666667
30230, 1.4916666666667, 0.85, 0.29166666666667
30231, 1.4916666666667, 0.8, 0.29166666666667
30232, 1.4916666666667, 0.75, 0.29166666666667
30233, 1.4916666666667, 0.7, 0.29166666666667
30234, 1.4916666666667, 0.65, 0.29166666666667
30235, 1.4916666666667, 0.6, 0.29166666666667
30236, 1.4916666666667, 0.55, 0.29166666666667
30237, 1.4916666666667, 0.5, 0.29166666666667
30238, 1.4916666666667, 0.45, 0.29166666666667
30239, 1.4916666666667, 0.4, 0.29166666666667
30240, 1.4916666666667, 0.35, 0.29166666666667
30241, 1.4916666666667, 0.3, 0.29166666666667
30242, 1.4916666666667, 0.25, 0.29166666666667
30243, 1.4916666666667, 0.2, 0.29166666666667
30244, 1.5333333333333, 1.3, 0.29166666666667
30245, 1.5333333333333, 1.25, 0.29166666666667
30246, 1.5333333333333, 1.2, 0.29166666666667
30247, 1.5333333333333, 1.15, 0.29166666666667
30248, 1.5333333333333, 1.1, 0.29166666666667
30249, 1.5333333333333, 1.05, 0.29166666666667
30250, 1.5333333333333, 1, 0.29166666666667
30251, 1.5333333333333, 0.95, 0.29166666666667
30252, 1.5333333333333, 0.9, 0.29166666666667
