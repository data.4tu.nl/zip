30902, 51317, 51321, 51413, 51409, 51318, 51322, 51414, 51410, 52784, 53086, 53087, 53073, 52787, 53089, 53090, 
53076, 52772, 52785, 53088, 53075
30903, 51318, 51322, 51414, 51410, 51319, 51323, 51415, 51411, 52787, 53089, 53090, 53076, 52790, 53092, 53093, 
53079, 52775, 52788, 53091, 53078
30904, 51319, 51323, 51415, 51411, 51320, 51324, 51416, 51412, 52790, 53092, 53093, 53079, 52793, 53095, 53096, 
53082, 52778, 52791, 53094, 53081
30905, 51320, 51324, 51416, 51412, 19128, 19129, 19152, 19151, 52793, 53095, 53096, 53082, 0, 0, 0, 
0, 52781, 52794, 53097, 53084
30906, 9832, 9833, 9856, 9855, 51321, 51325, 51417, 51413, 0, 0, 0, 0, 52797, 53099, 53100, 
53086, 52782, 52795, 53098, 53085
30907, 51321, 51325, 51417, 51413, 51322, 51326, 51418, 51414, 52797, 53099, 53100, 53086, 52800, 53102, 53103, 
53089, 52785, 52798, 53101, 53088
30908, 51322, 51326, 51418, 51414, 51323, 51327, 51419, 51415, 52800, 53102, 53103, 53089, 52803, 53105, 53106, 
53092, 52788, 52801, 53104, 53091
30909, 51323, 51327, 51419, 51415, 51324, 51328, 51420, 51416, 52803, 53105, 53106, 53092, 52806, 53108, 53109, 
53095, 52791, 52804, 53107, 53094
30910, 51324, 51328, 51420, 51416, 19129, 19130, 19153, 19152, 52806, 53108, 53109, 53095, 0, 0, 0, 
0, 52794, 52807, 53110, 53097
30911, 9833, 9834, 9857, 9856, 51325, 51329, 51421, 51417, 0, 0, 0, 0, 52810, 53112, 53113, 
53099, 52795, 52808, 53111, 53098
30912, 51325, 51329, 51421, 51417, 51326, 51330, 51422, 51418, 52810, 53112, 53113, 53099, 52813, 53115, 53116, 
53102, 52798, 52811, 53114, 53101
30913, 51326, 51330, 51422, 51418, 51327, 51331, 51423, 51419, 52813, 53115, 53116, 53102, 52816, 53118, 53119, 
53105, 52801, 52814, 53117, 53104
30914, 51327, 51331, 51423, 51419, 51328, 51332, 51424, 51420, 52816, 53118, 53119, 53105, 52819, 53121, 53122, 
53108, 52804, 52817, 53120, 53107
30915, 51328, 51332, 51424, 51420, 19130, 19131, 19154, 19153, 52819, 53121, 53122, 53108, 0, 0, 0, 
0, 52807, 52820, 53123, 53110
30916, 9834, 9835, 9858, 9857, 51329, 51333, 51425, 51421, 0, 0, 0, 0, 52823, 53125, 53126, 
53112, 52808, 52821, 53124, 53111
30917, 51329, 51333, 51425, 51421, 51330, 51334, 51426, 51422, 52823, 53125, 53126, 53112, 52826, 53128, 53129, 
53115, 52811, 52824, 53127, 53114
30918, 51330, 51334, 51426, 51422, 51331, 51335, 51427, 51423, 52826, 53128, 53129, 53115, 52829, 53131, 53132, 
53118, 52814, 52827, 53130, 53117
30919, 51331, 51335, 51427, 51423, 51332, 51336, 51428, 51424, 52829, 53131, 53132, 53118, 52832, 53134, 53135, 
53121, 52817, 52830, 53133, 53120
30920, 51332, 51336, 51428, 51424, 19131, 19132, 19155, 19154, 52832, 53134, 53135, 53121, 0, 0, 0, 
0, 52820, 52833, 53136, 53123
30921, 9835, 9836, 9859, 9858, 51333, 51337, 51429, 51425, 0, 0, 0, 0, 52836, 53138, 53139, 
53125, 52821, 52834, 53137, 53124
30922, 51333, 51337, 51429, 51425, 51334, 51338, 51430, 51426, 52836, 53138, 53139, 53125, 52839, 53141, 53142, 
53128, 52824, 52837, 53140, 53127
30923, 51334, 51338, 51430, 51426, 51335, 51339, 51431, 51427, 52839, 53141, 53142, 53128, 52842, 53144, 53145, 
53131, 52827, 52840, 53143, 53130
30924, 51335, 51339, 51431, 51427, 51336, 51340, 51432, 51428, 52842, 53144, 53145, 53131, 52845, 53147, 53148, 
53134, 52830, 52843, 53146, 53133
30925, 51336, 51340, 51432, 51428, 19132, 19133, 19156, 19155, 52845, 53147, 53148, 53134, 0, 0, 0, 
0, 52833, 52846, 53149, 53136
30926, 9836, 9837, 9860, 9859, 51337, 51341, 51433, 51429, 0, 0, 0, 0, 52849, 53151, 53152, 
53138, 52834, 52847, 53150, 53137
30927, 51337, 51341, 51433, 51429, 51338, 51342, 51434, 51430, 52849, 53151, 53152, 53138, 52852, 53154, 53155, 
53141, 52837, 52850, 53153, 53140
30928, 51338, 51342, 51434, 51430, 51339, 51343, 51435, 51431, 52852, 53154, 53155, 53141, 52855, 53157, 53158, 
53144, 52840, 52853, 53156, 53143
30929, 51339, 51343, 51435, 51431, 51340, 51344, 51436, 51432, 52855, 53157, 53158, 53144, 52858, 53160, 53161, 
53147, 52843, 52856, 53159, 53146
30930, 51340, 51344, 51436, 51432, 19133, 19134, 19157, 19156, 52858, 53160, 53161, 53147, 0, 0, 0, 
0, 52846, 52859, 53162, 53149
30931, 9837, 9838, 9861, 9860, 51341, 51345, 51437, 51433, 0, 0, 0, 0, 52862, 53164, 53165, 
53151, 52847, 52860, 53163, 53150
30932, 51341, 51345, 51437, 51433, 51342, 51346, 51438, 51434, 52862, 53164, 53165, 53151, 52865, 53167, 53168, 
53154, 52850, 52863, 53166, 53153
30933, 51342, 51346, 51438, 51434, 51343, 51347, 51439, 51435, 52865, 53167, 53168, 53154, 52868, 53170, 53171, 
53157, 52853, 52866, 53169, 53156
30934, 51343, 51347, 51439, 51435, 51344, 51348, 51440, 51436, 52868, 53170, 53171, 53157, 52871, 53173, 53174, 
53160, 52856, 52869, 53172, 53159
30935, 51344, 51348, 51440, 51436, 19134, 19135, 19158, 19157, 52871, 53173, 53174, 53160, 0, 0, 0, 
0, 52859, 52872, 53175, 53162
30936, 9838, 9839, 9862, 9861, 51345, 51349, 51441, 51437, 0, 0, 0, 0, 52875, 53177, 53178, 
53164, 52860, 52873, 53176, 53163
30937, 51345, 51349, 51441, 51437, 51346, 51350, 51442, 51438, 52875, 53177, 53178, 53164, 52878, 53180, 53181, 
53167, 52863, 52876, 53179, 53166
30938, 51346, 51350, 51442, 51438, 51347, 51351, 51443, 51439, 52878, 53180, 53181, 53167, 52881, 53183, 53184, 
53170, 52866, 52879, 53182, 53169
30939, 51347, 51351, 51443, 51439, 51348, 51352, 51444, 51440, 52881, 53183, 53184, 53170, 52884, 53186, 53187, 
53173, 52869, 52882, 53185, 53172
30940, 51348, 51352, 51444, 51440, 19135, 19136, 19159, 19158, 52884, 53186, 53187, 53173, 0, 0, 0, 
0, 52872, 52885, 53188, 53175
30941, 9839, 9840, 9863, 9862, 51349, 51353, 51445, 51441, 0, 0, 0, 0, 52888, 53190, 53191, 
53177, 52873, 52886, 53189, 53176
30942, 51349, 51353, 51445, 51441, 51350, 51354, 51446, 51442, 52888, 53190, 53191, 53177, 52891, 53193, 53194, 
53180, 52876, 52889, 53192, 53179
30943, 51350, 51354, 51446, 51442, 51351, 51355, 51447, 51443, 52891, 53193, 53194, 53180, 52894, 53196, 53197, 
53183, 52879, 52892, 53195, 53182
30944, 51351, 51355, 51447, 51443, 51352, 51356, 51448, 51444, 52894, 53196, 53197, 53183, 52897, 53199, 53200, 
53186, 52882, 52895, 53198, 53185
30945, 51352, 51356, 51448, 51444, 19136, 19137, 19160, 19159, 52897, 53199, 53200, 53186, 0, 0, 0, 
0, 52885, 52898, 53201, 53188
30946, 9840, 9841, 9864, 9863, 51353, 51357, 51449, 51445, 0, 0, 0, 0, 52901, 53203, 53204, 
53190, 52886, 52899, 53202, 53189
30947, 51353, 51357, 51449, 51445, 51354, 51358, 51450, 51446, 52901, 53203, 53204, 53190, 52904, 53206, 53207, 
53193, 52889, 52902, 53205, 53192
30948, 51354, 51358, 51450, 51446, 51355, 51359, 51451, 51447, 52904, 53206, 53207, 53193, 52907, 53209, 53210, 
53196, 52892, 52905, 53208, 53195
30949, 51355, 51359, 51451, 51447, 51356, 51360, 51452, 51448, 52907, 53209, 53210, 53196, 52910, 53212, 53213, 
53199, 52895, 52908, 53211, 53198
30950, 51356, 51360, 51452, 51448, 19137, 19138, 19161, 19160, 52910, 53212, 53213, 53199, 0, 0, 0, 
0, 52898, 52911, 53214, 53201
30951, 9841, 9842, 9865, 9864, 51357, 51361, 51453, 51449, 0, 0, 0, 0, 52914, 53216, 53217, 
53203, 52899, 52912, 53215, 53202
30952, 51357, 51361, 51453, 51449, 51358, 51362, 51454, 51450, 52914, 53216, 53217, 53203, 52917, 53219, 53220, 
53206, 52902, 52915, 53218, 53205
30953, 51358, 51362, 51454, 51450, 51359, 51363, 51455, 51451, 52917, 53219, 53220, 53206, 52920, 53222, 53223, 
53209, 52905, 52918, 53221, 53208
30954, 51359, 51363, 51455, 51451, 51360, 51364, 51456, 51452, 52920, 53222, 53223, 53209, 52923, 53225, 53226, 
53212, 52908, 52921, 53224, 53211
30955, 51360, 51364, 51456, 51452, 19138, 19139, 19162, 19161, 52923, 53225, 53226, 53212, 0, 0, 0, 
0, 52911, 52924, 53227, 53214
30956, 9842, 9843, 9866, 9865, 51361, 51365, 51457, 51453, 0, 0, 0, 0, 52927, 53229, 53230, 
53216, 52912, 52925, 53228, 53215
30957, 51361, 51365, 51457, 51453, 51362, 51366, 51458, 51454, 52927, 53229, 53230, 53216, 52930, 53232, 53233, 
53219, 52915, 52928, 53231, 53218
30958, 51362, 51366, 51458, 51454, 51363, 51367, 51459, 51455, 52930, 53232, 53233, 53219, 52933, 53235, 53236, 
53222, 52918, 52931, 53234, 53221
30959, 51363, 51367, 51459, 51455, 51364, 51368, 51460, 51456, 52933, 53235, 53236, 53222, 52936, 53238, 53239, 
53225, 52921, 52934, 53237, 53224
30960, 51364, 51368, 51460, 51456, 19139, 19140, 19163, 19162, 52936, 53238, 53239, 53225, 0, 0, 0, 
0, 52924, 52937, 53240, 53227
30961, 9843, 9844, 9867, 9866, 51365, 51369, 51461, 51457, 0, 0, 0, 0, 52940, 53242, 53243, 
53229, 52925, 52938, 53241, 53228
30962, 51365, 51369, 51461, 51457, 51366, 51370, 51462, 51458, 52940, 53242, 53243, 53229, 52943, 53245, 53246, 
53232, 52928, 52941, 53244, 53231
30963, 51366, 51370, 51462, 51458, 51367, 51371, 51463, 51459, 52943, 53245, 53246, 53232, 52946, 53248, 53249, 
53235, 52931, 52944, 53247, 53234
30964, 51367, 51371, 51463, 51459, 51368, 51372, 51464, 51460, 52946, 53248, 53249, 53235, 52949, 53251, 53252, 
53238, 52934, 52947, 53250, 53237
30965, 51368, 51372, 51464, 51460, 19140, 19141, 19164, 19163, 52949, 53251, 53252, 53238, 0, 0, 0, 
0, 52937, 52950, 53253, 53240
30966, 9844, 9845, 9868, 9867, 51369, 51373, 51465, 51461, 0, 0, 0, 0, 52953, 53255, 53256, 
53242, 52938, 52951, 53254, 53241
30967, 51369, 51373, 51465, 51461, 51370, 51374, 51466, 51462, 52953, 53255, 53256, 53242, 52956, 53258, 53259, 
53245, 52941, 52954, 53257, 53244
30968, 51370, 51374, 51466, 51462, 51371, 51375, 51467, 51463, 52956, 53258, 53259, 53245, 52959, 53261, 53262, 
53248, 52944, 52957, 53260, 53247
30969, 51371, 51375, 51467, 51463, 51372, 51376, 51468, 51464, 52959, 53261, 53262, 53248, 52962, 53264, 53265, 
53251, 52947, 52960, 53263, 53250
30970, 51372, 51376, 51468, 51464, 19141, 19142, 19165, 19164, 52962, 53264, 53265, 53251, 0, 0, 0, 
0, 52950, 52963, 53266, 53253
30971, 9845, 9846, 9869, 9868, 51373, 51377, 51469, 51465, 0, 0, 0, 0, 52966, 53268, 53269, 
53255, 52951, 52964, 53267, 53254
30972, 51373, 51377, 51469, 51465, 51374, 51378, 51470, 51466, 52966, 53268, 53269, 53255, 52969, 53271, 53272, 
53258, 52954, 52967, 53270, 53257
30973, 51374, 51378, 51470, 51466, 51375, 51379, 51471, 51467, 52969, 53271, 53272, 53258, 52972, 53274, 53275, 
53261, 52957, 52970, 53273, 53260
30974, 51375, 51379, 51471, 51467, 51376, 51380, 51472, 51468, 52972, 53274, 53275, 53261, 52975, 53277, 53278, 
53264, 52960, 52973, 53276, 53263
30975, 51376, 51380, 51472, 51468, 19142, 19143, 19166, 19165, 52975, 53277, 53278, 53264, 0, 0, 0, 
0, 52963, 52976, 53279, 53266
30976, 9846, 9847, 9870, 9869, 51377, 51381, 51473, 51469, 0, 0, 0, 0, 52979, 53281, 53282, 
53268, 52964, 52977, 53280, 53267
30977, 51377, 51381, 51473, 51469, 51378, 51382, 51474, 51470, 52979, 53281, 53282, 53268, 52982, 53284, 53285, 
53271, 52967, 52980, 53283, 53270
30978, 51378, 51382, 51474, 51470, 51379, 51383, 51475, 51471, 52982, 53284, 53285, 53271, 52985, 53287, 53288, 
53274, 52970, 52983, 53286, 53273
30979, 51379, 51383, 51475, 51471, 51380, 51384, 51476, 51472, 52985, 53287, 53288, 53274, 52988, 53290, 53291, 
53277, 52973, 52986, 53289, 53276
30980, 51380, 51384, 51476, 51472, 19143, 19144, 19167, 19166, 52988, 53290, 53291, 53277, 0, 0, 0, 
0, 52976, 52989, 53292, 53279
30981, 9847, 9848, 9871, 9870, 51381, 51385, 51477, 51473, 0, 0, 0, 0, 52992, 53294, 53295, 
53281, 52977, 52990, 53293, 53280
30982, 51381, 51385, 51477, 51473, 51382, 51386, 51478, 51474, 52992, 53294, 53295, 53281, 52995, 53297, 53298, 
53284, 52980, 52993, 53296, 53283
30983, 51382, 51386, 51478, 51474, 51383, 51387, 51479, 51475, 52995, 53297, 53298, 53284, 52998, 53300, 53301, 
53287, 52983, 52996, 53299, 53286
30984, 51383, 51387, 51479, 51475, 51384, 51388, 51480, 51476, 52998, 53300, 53301, 53287, 53001, 53303, 53304, 
53290, 52986, 52999, 53302, 53289
30985, 51384, 51388, 51480, 51476, 19144, 19145, 19168, 19167, 53001, 53303, 53304, 53290, 0, 0, 0, 
0, 52989, 53002, 53305, 53292
30986, 9848, 9849, 9872, 9871, 51385, 51389, 51481, 51477, 0, 0, 0, 0, 53005, 53307, 53308, 
53294, 52990, 53003, 53306, 53293
30987, 51385, 51389, 51481, 51477, 51386, 51390, 51482, 51478, 53005, 53307, 53308, 53294, 53008, 53310, 53311, 
53297, 52993, 53006, 53309, 53296
30988, 51386, 51390, 51482, 51478, 51387, 51391, 51483, 51479, 53008, 53310, 53311, 53297, 53011, 53313, 53314, 
53300, 52996, 53009, 53312, 53299
30989, 51387, 51391, 51483, 51479, 51388, 51392, 51484, 51480, 53011, 53313, 53314, 53300, 53014, 53316, 53317, 
53303, 52999, 53012, 53315, 53302
30990, 51388, 51392, 51484, 51480, 19145, 19146, 19169, 19168, 53014, 53316, 53317, 53303, 0, 0, 0, 
0, 53002, 53015, 53318, 53305
30991, 9849, 9850, 9873, 9872, 51389, 51393, 51485, 51481, 0, 0, 0, 0, 53018, 53320, 53321, 
53307, 53003, 53016, 53319, 53306
30992, 51389, 51393, 51485, 51481, 51390, 51394, 51486, 51482, 53018, 53320, 53321, 53307, 53021, 53323, 53324, 
53310, 53006, 53019, 53322, 53309
30993, 51390, 51394, 51486, 51482, 51391, 51395, 51487, 51483, 53021, 53323, 53324, 53310, 53024, 53326, 53327, 
53313, 53009, 53022, 53325, 53312
30994, 51391, 51395, 51487, 51483, 51392, 51396, 51488, 51484, 53024, 53326, 53327, 53313, 53027, 53329, 53330, 
53316, 53012, 53025, 53328, 53315
30995, 51392, 51396, 51488, 51484, 19146, 19147, 19170, 19169, 53027, 53329, 53330, 53316, 0, 0, 0, 
0, 53015, 53028, 53331, 53318
30996, 9850, 9851, 9874, 9873, 51393, 51397, 51489, 51485, 0, 0, 0, 0, 53031, 53333, 53334, 
53320, 53016, 53029, 53332, 53319
30997, 51393, 51397, 51489, 51485, 51394, 51398, 51490, 51486, 53031, 53333, 53334, 53320, 53034, 53336, 53337, 
53323, 53019, 53032, 53335, 53322
30998, 51394, 51398, 51490, 51486, 51395, 51399, 51491, 51487, 53034, 53336, 53337, 53323, 53037, 53339, 53340, 
53326, 53022, 53035, 53338, 53325
30999, 51395, 51399, 51491, 51487, 51396, 51400, 51492, 51488, 53037, 53339, 53340, 53326, 53040, 53342, 53343, 
53329, 53025, 53038, 53341, 53328
31000, 51396, 51400, 51492, 51488, 19147, 19148, 19171, 19170, 53040, 53342, 53343, 53329, 0, 0, 0, 
0, 53028, 53041, 53344, 53331
31001, 9851, 1193, 1194, 9874, 51397, 18941, 18945, 51489, 0, 0, 0, 0, 53042, 19005, 53345, 
53333, 53029, 18995, 19004, 53332
31002, 51397, 18941, 18945, 51489, 51398, 18942, 18946, 51490, 53042, 19005, 53345, 53333, 53043, 19007, 53346, 
53336, 53032, 18997, 19006, 53335
31003, 51398, 18942, 18946, 51490, 51399, 18943, 18947, 51491, 53043, 19007, 53346, 53336, 53044, 19009, 53347, 
53339, 53035, 18999, 19008, 53338
31004, 51399, 18943, 18947, 51491, 51400, 18944, 18948, 51492, 53044, 19009, 53347, 53339, 53045, 19011, 53348, 
53342, 53038, 19001, 19010, 53341
31005, 51400, 18944, 18948, 51492, 19148, 2375, 2376, 19171, 53045, 19011, 53348, 53342, 0, 0, 0, 
0, 53041, 19003, 19012, 53344
31006, 1183, 9852, 9875, 1184, 18798, 51401, 51493, 18802, 0, 0, 0, 0, 53048, 53350, 53351, 
18866, 18858, 53046, 53349, 18867
31007, 18798, 51401, 51493, 18802, 18799, 51402, 51494, 18803, 53048, 53350, 53351, 18866, 53051, 53353, 53354, 
18868, 18860, 53049, 53352, 18869
31008, 18799, 51402, 51494, 18803, 18800, 51403, 51495, 18804, 53051, 53353, 53354, 18868, 53054, 53356, 53357, 
18870, 18862, 53052, 53355, 18871
31009, 18800, 51403, 51495, 18804, 18801, 51404, 51496, 18805, 53054, 53356, 53357, 18870, 53057, 53359, 53360, 
18872, 18864, 53055, 53358, 18873
31010, 18801, 51404, 51496, 18805, 2365, 19149, 19172, 2366, 53057, 53359, 53360, 18872, 0, 0, 0, 
0, 18865, 53058, 53361, 18874
31011, 9852, 9853, 9876, 9875, 51401, 51405, 51497, 51493, 0, 0, 0, 0, 53061, 53363, 53364, 
53350, 53046, 53059, 53362, 53349
31012, 51401, 51405, 51497, 51493, 51402, 51406, 51498, 51494, 53061, 53363, 53364, 53350, 53064, 53366, 53367, 
53353, 53049, 53062, 53365, 53352
31013, 51402, 51406, 51498, 51494, 51403, 51407, 51499, 51495, 53064, 53366, 53367, 53353, 53067, 53369, 53370, 
53356, 53052, 53065, 53368, 53355
31014, 51403, 51407, 51499, 51495, 51404, 51408, 51500, 51496, 53067, 53369, 53370, 53356, 53070, 53372, 53373, 
53359, 53055, 53068, 53371, 53358
31015, 51404, 51408, 51500, 51496, 19149, 19150, 19173, 19172, 53070, 53372, 53373, 53359, 0, 0, 0, 
0, 53058, 53071, 53374, 53361
31016, 9853, 9854, 9877, 9876, 51405, 51409, 51501, 51497, 0, 0, 0, 0, 53074, 53376, 53377, 
53363, 53059, 53072, 53375, 53362
31017, 51405, 51409, 51501, 51497, 51406, 51410, 51502, 51498, 53074, 53376, 53377, 53363, 53077, 53379, 53380, 
53366, 53062, 53075, 53378, 53365
31018, 51406, 51410, 51502, 51498, 51407, 51411, 51503, 51499, 53077, 53379, 53380, 53366, 53080, 53382, 53383, 
53369, 53065, 53078, 53381, 53368
31019, 51407, 51411, 51503, 51499, 51408, 51412, 51504, 51500, 53080, 53382, 53383, 53369, 53083, 53385, 53386, 
53372, 53068, 53081, 53384, 53371
31020, 51408, 51412, 51504, 51500, 19150, 19151, 19174, 19173, 53083, 53385, 53386, 53372, 0, 0, 0, 
0, 53071, 53084, 53387, 53374
31021, 9854, 9855, 9878, 9877, 51409, 51413, 51505, 51501, 0, 0, 0, 0, 53087, 53389, 53390, 
53376, 53072, 53085, 53388, 53375
31022, 51409, 51413, 51505, 51501, 51410, 51414, 51506, 51502, 53087, 53389, 53390, 53376, 53090, 53392, 53393, 
53379, 53075, 53088, 53391, 53378
31023, 51410, 51414, 51506, 51502, 51411, 51415, 51507, 51503, 53090, 53392, 53393, 53379, 53093, 53395, 53396, 
53382, 53078, 53091, 53394, 53381
31024, 51411, 51415, 51507, 51503, 51412, 51416, 51508, 51504, 53093, 53395, 53396, 53382, 53096, 53398, 53399, 
53385, 53081, 53094, 53397, 53384
31025, 51412, 51416, 51508, 51504, 19151, 19152, 19175, 19174, 53096, 53398, 53399, 53385, 0, 0, 0, 
0, 53084, 53097, 53400, 53387
31026, 9855, 9856, 9879, 9878, 51413, 51417, 51509, 51505, 0, 0, 0, 0, 53100, 53402, 53403, 
53389, 53085, 53098, 53401, 53388
31027, 51413, 51417, 51509, 51505, 51414, 51418, 51510, 51506, 53100, 53402, 53403, 53389, 53103, 53405, 53406, 
53392, 53088, 53101, 53404, 53391
31028, 51414, 51418, 51510, 51506, 51415, 51419, 51511, 51507, 53103, 53405, 53406, 53392, 53106, 53408, 53409, 
53395, 53091, 53104, 53407, 53394
31029, 51415, 51419, 51511, 51507, 51416, 51420, 51512, 51508, 53106, 53408, 53409, 53395, 53109, 53411, 53412, 
53398, 53094, 53107, 53410, 53397
31030, 51416, 51420, 51512, 51508, 19152, 19153, 19176, 19175, 53109, 53411, 53412, 53398, 0, 0, 0, 
0, 53097, 53110, 53413, 53400
31031, 9856, 9857, 9880, 9879, 51417, 51421, 51513, 51509, 0, 0, 0, 0, 53113, 53415, 53416, 
53402, 53098, 53111, 53414, 53401
31032, 51417, 51421, 51513, 51509, 51418, 51422, 51514, 51510, 53113, 53415, 53416, 53402, 53116, 53418, 53419, 
53405, 53101, 53114, 53417, 53404
31033, 51418, 51422, 51514, 51510, 51419, 51423, 51515, 51511, 53116, 53418, 53419, 53405, 53119, 53421, 53422, 
53408, 53104, 53117, 53420, 53407
31034, 51419, 51423, 51515, 51511, 51420, 51424, 51516, 51512, 53119, 53421, 53422, 53408, 53122, 53424, 53425, 
53411, 53107, 53120, 53423, 53410
31035, 51420, 51424, 51516, 51512, 19153, 19154, 19177, 19176, 53122, 53424, 53425, 53411, 0, 0, 0, 
0, 53110, 53123, 53426, 53413
31036, 9857, 9858, 9881, 9880, 51421, 51425, 51517, 51513, 0, 0, 0, 0, 53126, 53428, 53429, 
53415, 53111, 53124, 53427, 53414
31037, 51421, 51425, 51517, 51513, 51422, 51426, 51518, 51514, 53126, 53428, 53429, 53415, 53129, 53431, 53432, 
53418, 53114, 53127, 53430, 53417
31038, 51422, 51426, 51518, 51514, 51423, 51427, 51519, 51515, 53129, 53431, 53432, 53418, 53132, 53434, 53435, 
53421, 53117, 53130, 53433, 53420
31039, 51423, 51427, 51519, 51515, 51424, 51428, 51520, 51516, 53132, 53434, 53435, 53421, 53135, 53437, 53438, 
53424, 53120, 53133, 53436, 53423
31040, 51424, 51428, 51520, 51516, 19154, 19155, 19178, 19177, 53135, 53437, 53438, 53424, 0, 0, 0, 
0, 53123, 53136, 53439, 53426
31041, 9858, 9859, 9882, 9881, 51425, 51429, 51521, 51517, 0, 0, 0, 0, 53139, 53441, 53442, 
53428, 53124, 53137, 53440, 53427
31042, 51425, 51429, 51521, 51517, 51426, 51430, 51522, 51518, 53139, 53441, 53442, 53428, 53142, 53444, 53445, 
53431, 53127, 53140, 53443, 53430
31043, 51426, 51430, 51522, 51518, 51427, 51431, 51523, 51519, 53142, 53444, 53445, 53431, 53145, 53447, 53448, 
53434, 53130, 53143, 53446, 53433
31044, 51427, 51431, 51523, 51519, 51428, 51432, 51524, 51520, 53145, 53447, 53448, 53434, 53148, 53450, 53451, 
53437, 53133, 53146, 53449, 53436
31045, 51428, 51432, 51524, 51520, 19155, 19156, 19179, 19178, 53148, 53450, 53451, 53437, 0, 0, 0, 
0, 53136, 53149, 53452, 53439
31046, 9859, 9860, 9883, 9882, 51429, 51433, 51525, 51521, 0, 0, 0, 0, 53152, 53454, 53455, 
53441, 53137, 53150, 53453, 53440
31047, 51429, 51433, 51525, 51521, 51430, 51434, 51526, 51522, 53152, 53454, 53455, 53441, 53155, 53457, 53458, 
53444, 53140, 53153, 53456, 53443
31048, 51430, 51434, 51526, 51522, 51431, 51435, 51527, 51523, 53155, 53457, 53458, 53444, 53158, 53460, 53461, 
53447, 53143, 53156, 53459, 53446
31049, 51431, 51435, 51527, 51523, 51432, 51436, 51528, 51524, 53158, 53460, 53461, 53447, 53161, 53463, 53464, 
53450, 53146, 53159, 53462, 53449
31050, 51432, 51436, 51528, 51524, 19156, 19157, 19180, 19179, 53161, 53463, 53464, 53450, 0, 0, 0, 
0, 53149, 53162, 53465, 53452
31051, 9860, 9861, 9884, 9883, 51433, 51437, 51529, 51525, 0, 0, 0, 0, 53165, 53467, 53468, 
53454, 53150, 53163, 53466, 53453
31052, 51433, 51437, 51529, 51525, 51434, 51438, 51530, 51526, 53165, 53467, 53468, 53454, 53168, 53470, 53471, 
53457, 53153, 53166, 53469, 53456
31053, 51434, 51438, 51530, 51526, 51435, 51439, 51531, 51527, 53168, 53470, 53471, 53457, 53171, 53473, 53474, 
53460, 53156, 53169, 53472, 53459
31054, 51435, 51439, 51531, 51527, 51436, 51440, 51532, 51528, 53171, 53473, 53474, 53460, 53174, 53476, 53477, 
53463, 53159, 53172, 53475, 53462
31055, 51436, 51440, 51532, 51528, 19157, 19158, 19181, 19180, 53174, 53476, 53477, 53463, 0, 0, 0, 
0, 53162, 53175, 53478, 53465
31056, 9861, 9862, 9885, 9884, 51437, 51441, 51533, 51529, 0, 0, 0, 0, 53178, 53480, 53481, 
53467, 53163, 53176, 53479, 53466
31057, 51437, 51441, 51533, 51529, 51438, 51442, 51534, 51530, 53178, 53480, 53481, 53467, 53181, 53483, 53484, 
53470, 53166, 53179, 53482, 53469
31058, 51438, 51442, 51534, 51530, 51439, 51443, 51535, 51531, 53181, 53483, 53484, 53470, 53184, 53486, 53487, 
53473, 53169, 53182, 53485, 53472
31059, 51439, 51443, 51535, 51531, 51440, 51444, 51536, 51532, 53184, 53486, 53487, 53473, 53187, 53489, 53490, 
53476, 53172, 53185, 53488, 53475
31060, 51440, 51444, 51536, 51532, 19158, 19159, 19182, 19181, 53187, 53489, 53490, 53476, 0, 0, 0, 
0, 53175, 53188, 53491, 53478
31061, 9862, 9863, 9886, 9885, 51441, 51445, 51537, 51533, 0, 0, 0, 0, 53191, 53493, 53494, 
53480, 53176, 53189, 53492, 53479
31062, 51441, 51445, 51537, 51533, 51442, 51446, 51538, 51534, 53191, 53493, 53494, 53480, 53194, 53496, 53497, 
53483, 53179, 53192, 53495, 53482
31063, 51442, 51446, 51538, 51534, 51443, 51447, 51539, 51535, 53194, 53496, 53497, 53483, 53197, 53499, 53500, 
53486, 53182, 53195, 53498, 53485
31064, 51443, 51447, 51539, 51535, 51444, 51448, 51540, 51536, 53197, 53499, 53500, 53486, 53200, 53502, 53503, 
53489, 53185, 53198, 53501, 53488
31065, 51444, 51448, 51540, 51536, 19159, 19160, 19183, 19182, 53200, 53502, 53503, 53489, 0, 0, 0, 
0, 53188, 53201, 53504, 53491
31066, 9863, 9864, 9887, 9886, 51445, 51449, 51541, 51537, 0, 0, 0, 0, 53204, 53506, 53507, 
53493, 53189, 53202, 53505, 53492
31067, 51445, 51449, 51541, 51537, 51446, 51450, 51542, 51538, 53204, 53506, 53507, 53493, 53207, 53509, 53510, 
53496, 53192, 53205, 53508, 53495
31068, 51446, 51450, 51542, 51538, 51447, 51451, 51543, 51539, 53207, 53509, 53510, 53496, 53210, 53512, 53513, 
53499, 53195, 53208, 53511, 53498
31069, 51447, 51451, 51543, 51539, 51448, 51452, 51544, 51540, 53210, 53512, 53513, 53499, 53213, 53515, 53516, 
53502, 53198, 53211, 53514, 53501
31070, 51448, 51452, 51544, 51540, 19160, 19161, 19184, 19183, 53213, 53515, 53516, 53502, 0, 0, 0, 
0, 53201, 53214, 53517, 53504
31071, 9864, 9865, 9888, 9887, 51449, 51453, 51545, 51541, 0, 0, 0, 0, 53217, 53519, 53520, 
53506, 53202, 53215, 53518, 53505
31072, 51449, 51453, 51545, 51541, 51450, 51454, 51546, 51542, 53217, 53519, 53520, 53506, 53220, 53522, 53523, 
53509, 53205, 53218, 53521, 53508
31073, 51450, 51454, 51546, 51542, 51451, 51455, 51547, 51543, 53220, 53522, 53523, 53509, 53223, 53525, 53526, 
53512, 53208, 53221, 53524, 53511
31074, 51451, 51455, 51547, 51543, 51452, 51456, 51548, 51544, 53223, 53525, 53526, 53512, 53226, 53528, 53529, 
53515, 53211, 53224, 53527, 53514
31075, 51452, 51456, 51548, 51544, 19161, 19162, 19185, 19184, 53226, 53528, 53529, 53515, 0, 0, 0, 
0, 53214, 53227, 53530, 53517
31076, 9865, 9866, 9889, 9888, 51453, 51457, 51549, 51545, 0, 0, 0, 0, 53230, 53532, 53533, 
53519, 53215, 53228, 53531, 53518
31077, 51453, 51457, 51549, 51545, 51454, 51458, 51550, 51546, 53230, 53532, 53533, 53519, 53233, 53535, 53536, 
53522, 53218, 53231, 53534, 53521
31078, 51454, 51458, 51550, 51546, 51455, 51459, 51551, 51547, 53233, 53535, 53536, 53522, 53236, 53538, 53539, 
53525, 53221, 53234, 53537, 53524
31079, 51455, 51459, 51551, 51547, 51456, 51460, 51552, 51548, 53236, 53538, 53539, 53525, 53239, 53541, 53542, 
53528, 53224, 53237, 53540, 53527
31080, 51456, 51460, 51552, 51548, 19162, 19163, 19186, 19185, 53239, 53541, 53542, 53528, 0, 0, 0, 
0, 53227, 53240, 53543, 53530
31081, 9866, 9867, 9890, 9889, 51457, 51461, 51553, 51549, 0, 0, 0, 0, 53243, 53545, 53546, 
53532, 53228, 53241, 53544, 53531
31082, 51457, 51461, 51553, 51549, 51458, 51462, 51554, 51550, 53243, 53545, 53546, 53532, 53246, 53548, 53549, 
53535, 53231, 53244, 53547, 53534
31083, 51458, 51462, 51554, 51550, 51459, 51463, 51555, 51551, 53246, 53548, 53549, 53535, 53249, 53551, 53552, 
53538, 53234, 53247, 53550, 53537
31084, 51459, 51463, 51555, 51551, 51460, 51464, 51556, 51552, 53249, 53551, 53552, 53538, 53252, 53554, 53555, 
53541, 53237, 53250, 53553, 53540
31085, 51460, 51464, 51556, 51552, 19163, 19164, 19187, 19186, 53252, 53554, 53555, 53541, 0, 0, 0, 
0, 53240, 53253, 53556, 53543
31086, 9867, 9868, 9891, 9890, 51461, 51465, 51557, 51553, 0, 0, 0, 0, 53256, 53558, 53559, 
53545, 53241, 53254, 53557, 53544
31087, 51461, 51465, 51557, 51553, 51462, 51466, 51558, 51554, 53256, 53558, 53559, 53545, 53259, 53561, 53562, 
53548, 53244, 53257, 53560, 53547
31088, 51462, 51466, 51558, 51554, 51463, 51467, 51559, 51555, 53259, 53561, 53562, 53548, 53262, 53564, 53565, 
53551, 53247, 53260, 53563, 53550
31089, 51463, 51467, 51559, 51555, 51464, 51468, 51560, 51556, 53262, 53564, 53565, 53551, 53265, 53567, 53568, 
53554, 53250, 53263, 53566, 53553
31090, 51464, 51468, 51560, 51556, 19164, 19165, 19188, 19187, 53265, 53567, 53568, 53554, 0, 0, 0, 
0, 53253, 53266, 53569, 53556
31091, 9868, 9869, 9892, 9891, 51465, 51469, 51561, 51557, 0, 0, 0, 0, 53269, 53571, 53572, 
53558, 53254, 53267, 53570, 53557
31092, 51465, 51469, 51561, 51557, 51466, 51470, 51562, 51558, 53269, 53571, 53572, 53558, 53272, 53574, 53575, 
53561, 53257, 53270, 53573, 53560
31093, 51466, 51470, 51562, 51558, 51467, 51471, 51563, 51559, 53272, 53574, 53575, 53561, 53275, 53577, 53578, 
53564, 53260, 53273, 53576, 53563
31094, 51467, 51471, 51563, 51559, 51468, 51472, 51564, 51560, 53275, 53577, 53578, 53564, 53278, 53580, 53581, 
53567, 53263, 53276, 53579, 53566
31095, 51468, 51472, 51564, 51560, 19165, 19166, 19189, 19188, 53278, 53580, 53581, 53567, 0, 0, 0, 
0, 53266, 53279, 53582, 53569
31096, 9869, 9870, 9893, 9892, 51469, 51473, 51565, 51561, 0, 0, 0, 0, 53282, 53584, 53585, 
53571, 53267, 53280, 53583, 53570
31097, 51469, 51473, 51565, 51561, 51470, 51474, 51566, 51562, 53282, 53584, 53585, 53571, 53285, 53587, 53588, 
53574, 53270, 53283, 53586, 53573
31098, 51470, 51474, 51566, 51562, 51471, 51475, 51567, 51563, 53285, 53587, 53588, 53574, 53288, 53590, 53591, 
53577, 53273, 53286, 53589, 53576
31099, 51471, 51475, 51567, 51563, 51472, 51476, 51568, 51564, 53288, 53590, 53591, 53577, 53291, 53593, 53594, 
53580, 53276, 53289, 53592, 53579
31100, 51472, 51476, 51568, 51564, 19166, 19167, 19190, 19189, 53291, 53593, 53594, 53580, 0, 0, 0, 
0, 53279, 53292, 53595, 53582
31101, 9870, 9871, 9894, 9893, 51473, 51477, 51569, 51565, 0, 0, 0, 0, 53295, 53597, 53598, 
53584, 53280, 53293, 53596, 53583
31102, 51473, 51477, 51569, 51565, 51474, 51478, 51570, 51566, 53295, 53597, 53598, 53584, 53298, 53600, 53601, 
53587, 53283, 53296, 53599, 53586
31103, 51474, 51478, 51570, 51566, 51475, 51479, 51571, 51567, 53298, 53600, 53601, 53587, 53301, 53603, 53604, 
53590, 53286, 53299, 53602, 53589
31104, 51475, 51479, 51571, 51567, 51476, 51480, 51572, 51568, 53301, 53603, 53604, 53590, 53304, 53606, 53607, 
53593, 53289, 53302, 53605, 53592
31105, 51476, 51480, 51572, 51568, 19167, 19168, 19191, 19190, 53304, 53606, 53607, 53593, 0, 0, 0, 
0, 53292, 53305, 53608, 53595
31106, 9871, 9872, 9895, 9894, 51477, 51481, 51573, 51569, 0, 0, 0, 0, 53308, 53610, 53611, 
53597, 53293, 53306, 53609, 53596
31107, 51477, 51481, 51573, 51569, 51478, 51482, 51574, 51570, 53308, 53610, 53611, 53597, 53311, 53613, 53614, 
53600, 53296, 53309, 53612, 53599
31108, 51478, 51482, 51574, 51570, 51479, 51483, 51575, 51571, 53311, 53613, 53614, 53600, 53314, 53616, 53617, 
53603, 53299, 53312, 53615, 53602
31109, 51479, 51483, 51575, 51571, 51480, 51484, 51576, 51572, 53314, 53616, 53617, 53603, 53317, 53619, 53620, 
53606, 53302, 53315, 53618, 53605
31110, 51480, 51484, 51576, 51572, 19168, 19169, 19192, 19191, 53317, 53619, 53620, 53606, 0, 0, 0, 
0, 53305, 53318, 53621, 53608
31111, 9872, 9873, 9896, 9895, 51481, 51485, 51577, 51573, 0, 0, 0, 0, 53321, 53623, 53624, 
53610, 53306, 53319, 53622, 53609
31112, 51481, 51485, 51577, 51573, 51482, 51486, 51578, 51574, 53321, 53623, 53624, 53610, 53324, 53626, 53627, 
53613, 53309, 53322, 53625, 53612
31113, 51482, 51486, 51578, 51574, 51483, 51487, 51579, 51575, 53324, 53626, 53627, 53613, 53327, 53629, 53630, 
53616, 53312, 53325, 53628, 53615
31114, 51483, 51487, 51579, 51575, 51484, 51488, 51580, 51576, 53327, 53629, 53630, 53616, 53330, 53632, 53633, 
53619, 53315, 53328, 53631, 53618
31115, 51484, 51488, 51580, 51576, 19169, 19170, 19193, 19192, 53330, 53632, 53633, 53619, 0, 0, 0, 
0, 53318, 53331, 53634, 53621
31116, 9873, 9874, 9897, 9896, 51485, 51489, 51581, 51577, 0, 0, 0, 0, 53334, 53636, 53637, 
53623, 53319, 53332, 53635, 53622
31117, 51485, 51489, 51581, 51577, 51486, 51490, 51582, 51578, 53334, 53636, 53637, 53623, 53337, 53639, 53640, 
53626, 53322, 53335, 53638, 53625
31118, 51486, 51490, 51582, 51578, 51487, 51491, 51583, 51579, 53337, 53639, 53640, 53626, 53340, 53642, 53643, 
53629, 53325, 53338, 53641, 53628
31119, 51487, 51491, 51583, 51579, 51488, 51492, 51584, 51580, 53340, 53642, 53643, 53629, 53343, 53645, 53646, 
53632, 53328, 53341, 53644, 53631
31120, 51488, 51492, 51584, 51580, 19170, 19171, 19194, 19193, 53343, 53645, 53646, 53632, 0, 0, 0, 
0, 53331, 53344, 53647, 53634
31121, 9874, 1194, 1195, 9897, 51489, 18945, 18949, 51581, 0, 0, 0, 0, 53345, 19014, 53648, 
53636, 53332, 19004, 19013, 53635
31122, 51489, 18945, 18949, 51581, 51490, 18946, 18950, 51582, 53345, 19014, 53648, 53636, 53346, 19016, 53649, 
53639, 53335, 19006, 19015, 53638
31123, 51490, 18946, 18950, 51582, 51491, 18947, 18951, 51583, 53346, 19016, 53649, 53639, 53347, 19018, 53650, 
53642, 53338, 19008, 19017, 53641
31124, 51491, 18947, 18951, 51583, 51492, 18948, 18952, 51584, 53347, 19018, 53650, 53642, 53348, 19020, 53651, 
53645, 53341, 19010, 19019, 53644
31125, 51492, 18948, 18952, 51584, 19171, 2376, 2377, 19194, 53348, 19020, 53651, 53645, 0, 0, 0, 
0, 53344, 19012, 19021, 53647
31126, 1184, 9875, 9898, 1185, 18802, 51493, 51585, 18806, 0, 0, 0, 0, 53351, 53653, 53654, 
18875, 18867, 53349, 53652, 18876
31127, 18802, 51493, 51585, 18806, 18803, 51494, 51586, 18807, 53351, 53653, 53654, 18875, 53354, 53656, 53657, 
18877, 18869, 53352, 53655, 18878
31128, 18803, 51494, 51586, 18807, 18804, 51495, 51587, 18808, 53354, 53656, 53657, 18877, 53357, 53659, 53660, 
18879, 18871, 53355, 53658, 18880
31129, 18804, 51495, 51587, 18808, 18805, 51496, 51588, 18809, 53357, 53659, 53660, 18879, 53360, 53662, 53663, 
18881, 18873, 53358, 53661, 18882
31130, 18805, 51496, 51588, 18809, 2366, 19172, 19195, 2367, 53360, 53662, 53663, 18881, 0, 0, 0, 
0, 18874, 53361, 53664, 18883
31131, 9875, 9876, 9899, 9898, 51493, 51497, 51589, 51585, 0, 0, 0, 0, 53364, 53666, 53667, 
53653, 53349, 53362, 53665, 53652
31132, 51493, 51497, 51589, 51585, 51494, 51498, 51590, 51586, 53364, 53666, 53667, 53653, 53367, 53669, 53670, 
53656, 53352, 53365, 53668, 53655
31133, 51494, 51498, 51590, 51586, 51495, 51499, 51591, 51587, 53367, 53669, 53670, 53656, 53370, 53672, 53673, 
53659, 53355, 53368, 53671, 53658
31134, 51495, 51499, 51591, 51587, 51496, 51500, 51592, 51588, 53370, 53672, 53673, 53659, 53373, 53675, 53676, 
53662, 53358, 53371, 53674, 53661
31135, 51496, 51500, 51592, 51588, 19172, 19173, 19196, 19195, 53373, 53675, 53676, 53662, 0, 0, 0, 
0, 53361, 53374, 53677, 53664
31136, 9876, 9877, 9900, 9899, 51497, 51501, 51593, 51589, 0, 0, 0, 0, 53377, 53679, 53680, 
53666, 53362, 53375, 53678, 53665
31137, 51497, 51501, 51593, 51589, 51498, 51502, 51594, 51590, 53377, 53679, 53680, 53666, 53380, 53682, 53683, 
53669, 53365, 53378, 53681, 53668
31138, 51498, 51502, 51594, 51590, 51499, 51503, 51595, 51591, 53380, 53682, 53683, 53669, 53383, 53685, 53686, 
53672, 53368, 53381, 53684, 53671
31139, 51499, 51503, 51595, 51591, 51500, 51504, 51596, 51592, 53383, 53685, 53686, 53672, 53386, 53688, 53689, 
53675, 53371, 53384, 53687, 53674
31140, 51500, 51504, 51596, 51592, 19173, 19174, 19197, 19196, 53386, 53688, 53689, 53675, 0, 0, 0, 
0, 53374, 53387, 53690, 53677
31141, 9877, 9878, 9901, 9900, 51501, 51505, 51597, 51593, 0, 0, 0, 0, 53390, 53692, 53693, 
53679, 53375, 53388, 53691, 53678
31142, 51501, 51505, 51597, 51593, 51502, 51506, 51598, 51594, 53390, 53692, 53693, 53679, 53393, 53695, 53696, 
53682, 53378, 53391, 53694, 53681
31143, 51502, 51506, 51598, 51594, 51503, 51507, 51599, 51595, 53393, 53695, 53696, 53682, 53396, 53698, 53699, 
53685, 53381, 53394, 53697, 53684
31144, 51503, 51507, 51599, 51595, 51504, 51508, 51600, 51596, 53396, 53698, 53699, 53685, 53399, 53701, 53702, 
53688, 53384, 53397, 53700, 53687
31145, 51504, 51508, 51600, 51596, 19174, 19175, 19198, 19197, 53399, 53701, 53702, 53688, 0, 0, 0, 
0, 53387, 53400, 53703, 53690
31146, 9878, 9879, 9902, 9901, 51505, 51509, 51601, 51597, 0, 0, 0, 0, 53403, 53705, 53706, 
53692, 53388, 53401, 53704, 53691
31147, 51505, 51509, 51601, 51597, 51506, 51510, 51602, 51598, 53403, 53705, 53706, 53692, 53406, 53708, 53709, 
53695, 53391, 53404, 53707, 53694
31148, 51506, 51510, 51602, 51598, 51507, 51511, 51603, 51599, 53406, 53708, 53709, 53695, 53409, 53711, 53712, 
53698, 53394, 53407, 53710, 53697
31149, 51507, 51511, 51603, 51599, 51508, 51512, 51604, 51600, 53409, 53711, 53712, 53698, 53412, 53714, 53715, 
53701, 53397, 53410, 53713, 53700
31150, 51508, 51512, 51604, 51600, 19175, 19176, 19199, 19198, 53412, 53714, 53715, 53701, 0, 0, 0, 
0, 53400, 53413, 53716, 53703
31151, 9879, 9880, 9903, 9902, 51509, 51513, 51605, 51601, 0, 0, 0, 0, 53416, 53718, 53719, 
53705, 53401, 53414, 53717, 53704
31152, 51509, 51513, 51605, 51601, 51510, 51514, 51606, 51602, 53416, 53718, 53719, 53705, 53419, 53721, 53722, 
53708, 53404, 53417, 53720, 53707
31153, 51510, 51514, 51606, 51602, 51511, 51515, 51607, 51603, 53419, 53721, 53722, 53708, 53422, 53724, 53725, 
53711, 53407, 53420, 53723, 53710
31154, 51511, 51515, 51607, 51603, 51512, 51516, 51608, 51604, 53422, 53724, 53725, 53711, 53425, 53727, 53728, 
53714, 53410, 53423, 53726, 53713
31155, 51512, 51516, 51608, 51604, 19176, 19177, 19200, 19199, 53425, 53727, 53728, 53714, 0, 0, 0, 
0, 53413, 53426, 53729, 53716
31156, 9880, 9881, 9904, 9903, 51513, 51517, 51609, 51605, 0, 0, 0, 0, 53429, 53731, 53732, 
53718, 53414, 53427, 53730, 53717
31157, 51513, 51517, 51609, 51605, 51514, 51518, 51610, 51606, 53429, 53731, 53732, 53718, 53432, 53734, 53735, 
53721, 53417, 53430, 53733, 53720
31158, 51514, 51518, 51610, 51606, 51515, 51519, 51611, 51607, 53432, 53734, 53735, 53721, 53435, 53737, 53738, 
53724, 53420, 53433, 53736, 53723
31159, 51515, 51519, 51611, 51607, 51516, 51520, 51612, 51608, 53435, 53737, 53738, 53724, 53438, 53740, 53741, 
53727, 53423, 53436, 53739, 53726
31160, 51516, 51520, 51612, 51608, 19177, 19178, 19201, 19200, 53438, 53740, 53741, 53727, 0, 0, 0, 
0, 53426, 53439, 53742, 53729
31161, 9881, 9882, 9905, 9904, 51517, 51521, 51613, 51609, 0, 0, 0, 0, 53442, 53744, 53745, 
53731, 53427, 53440, 53743, 53730
31162, 51517, 51521, 51613, 51609, 51518, 51522, 51614, 51610, 53442, 53744, 53745, 53731, 53445, 53747, 53748, 
53734, 53430, 53443, 53746, 53733
31163, 51518, 51522, 51614, 51610, 51519, 51523, 51615, 51611, 53445, 53747, 53748, 53734, 53448, 53750, 53751, 
53737, 53433, 53446, 53749, 53736
31164, 51519, 51523, 51615, 51611, 51520, 51524, 51616, 51612, 53448, 53750, 53751, 53737, 53451, 53753, 53754, 
53740, 53436, 53449, 53752, 53739
31165, 51520, 51524, 51616, 51612, 19178, 19179, 19202, 19201, 53451, 53753, 53754, 53740, 0, 0, 0, 
0, 53439, 53452, 53755, 53742
31166, 9882, 9883, 9906, 9905, 51521, 51525, 51617, 51613, 0, 0, 0, 0, 53455, 53757, 53758, 
53744, 53440, 53453, 53756, 53743
31167, 51521, 51525, 51617, 51613, 51522, 51526, 51618, 51614, 53455, 53757, 53758, 53744, 53458, 53760, 53761, 
53747, 53443, 53456, 53759, 53746
31168, 51522, 51526, 51618, 51614, 51523, 51527, 51619, 51615, 53458, 53760, 53761, 53747, 53461, 53763, 53764, 
53750, 53446, 53459, 53762, 53749
31169, 51523, 51527, 51619, 51615, 51524, 51528, 51620, 51616, 53461, 53763, 53764, 53750, 53464, 53766, 53767, 
53753, 53449, 53462, 53765, 53752
31170, 51524, 51528, 51620, 51616, 19179, 19180, 19203, 19202, 53464, 53766, 53767, 53753, 0, 0, 0, 
0, 53452, 53465, 53768, 53755
31171, 9883, 9884, 9907, 9906, 51525, 51529, 51621, 51617, 0, 0, 0, 0, 53468, 53770, 53771, 
53757, 53453, 53466, 53769, 53756
31172, 51525, 51529, 51621, 51617, 51526, 51530, 51622, 51618, 53468, 53770, 53771, 53757, 53471, 53773, 53774, 
53760, 53456, 53469, 53772, 53759
31173, 51526, 51530, 51622, 51618, 51527, 51531, 51623, 51619, 53471, 53773, 53774, 53760, 53474, 53776, 53777, 
53763, 53459, 53472, 53775, 53762
31174, 51527, 51531, 51623, 51619, 51528, 51532, 51624, 51620, 53474, 53776, 53777, 53763, 53477, 53779, 53780, 
53766, 53462, 53475, 53778, 53765
31175, 51528, 51532, 51624, 51620, 19180, 19181, 19204, 19203, 53477, 53779, 53780, 53766, 0, 0, 0, 
0, 53465, 53478, 53781, 53768
31176, 9884, 9885, 9908, 9907, 51529, 51533, 51625, 51621, 0, 0, 0, 0, 53481, 53783, 53784, 
53770, 53466, 53479, 53782, 53769
31177, 51529, 51533, 51625, 51621, 51530, 51534, 51626, 51622, 53481, 53783, 53784, 53770, 53484, 53786, 53787, 
53773, 53469, 53482, 53785, 53772
31178, 51530, 51534, 51626, 51622, 51531, 51535, 51627, 51623, 53484, 53786, 53787, 53773, 53487, 53789, 53790, 
53776, 53472, 53485, 53788, 53775
31179, 51531, 51535, 51627, 51623, 51532, 51536, 51628, 51624, 53487, 53789, 53790, 53776, 53490, 53792, 53793, 
53779, 53475, 53488, 53791, 53778
31180, 51532, 51536, 51628, 51624, 19181, 19182, 19205, 19204, 53490, 53792, 53793, 53779, 0, 0, 0, 
0, 53478, 53491, 53794, 53781
31181, 9885, 9886, 9909, 9908, 51533, 51537, 51629, 51625, 0, 0, 0, 0, 53494, 53796, 53797, 
53783, 53479, 53492, 53795, 53782
31182, 51533, 51537, 51629, 51625, 51534, 51538, 51630, 51626, 53494, 53796, 53797, 53783, 53497, 53799, 53800, 
53786, 53482, 53495, 53798, 53785
31183, 51534, 51538, 51630, 51626, 51535, 51539, 51631, 51627, 53497, 53799, 53800, 53786, 53500, 53802, 53803, 
53789, 53485, 53498, 53801, 53788
31184, 51535, 51539, 51631, 51627, 51536, 51540, 51632, 51628, 53500, 53802, 53803, 53789, 53503, 53805, 53806, 
53792, 53488, 53501, 53804, 53791
31185, 51536, 51540, 51632, 51628, 19182, 19183, 19206, 19205, 53503, 53805, 53806, 53792, 0, 0, 0, 
0, 53491, 53504, 53807, 53794
31186, 9886, 9887, 9910, 9909, 51537, 51541, 51633, 51629, 0, 0, 0, 0, 53507, 53809, 53810, 
53796, 53492, 53505, 53808, 53795
31187, 51537, 51541, 51633, 51629, 51538, 51542, 51634, 51630, 53507, 53809, 53810, 53796, 53510, 53812, 53813, 
53799, 53495, 53508, 53811, 53798
31188, 51538, 51542, 51634, 51630, 51539, 51543, 51635, 51631, 53510, 53812, 53813, 53799, 53513, 53815, 53816, 
53802, 53498, 53511, 53814, 53801
31189, 51539, 51543, 51635, 51631, 51540, 51544, 51636, 51632, 53513, 53815, 53816, 53802, 53516, 53818, 53819, 
53805, 53501, 53514, 53817, 53804
31190, 51540, 51544, 51636, 51632, 19183, 19184, 19207, 19206, 53516, 53818, 53819, 53805, 0, 0, 0, 
0, 53504, 53517, 53820, 53807
31191, 9887, 9888, 9911, 9910, 51541, 51545, 51637, 51633, 0, 0, 0, 0, 53520, 53822, 53823, 
53809, 53505, 53518, 53821, 53808
31192, 51541, 51545, 51637, 51633, 51542, 51546, 51638, 51634, 53520, 53822, 53823, 53809, 53523, 53825, 53826, 
53812, 53508, 53521, 53824, 53811
31193, 51542, 51546, 51638, 51634, 51543, 51547, 51639, 51635, 53523, 53825, 53826, 53812, 53526, 53828, 53829, 
53815, 53511, 53524, 53827, 53814
31194, 51543, 51547, 51639, 51635, 51544, 51548, 51640, 51636, 53526, 53828, 53829, 53815, 53529, 53831, 53832, 
53818, 53514, 53527, 53830, 53817
31195, 51544, 51548, 51640, 51636, 19184, 19185, 19208, 19207, 53529, 53831, 53832, 53818, 0, 0, 0, 
0, 53517, 53530, 53833, 53820
31196, 9888, 9889, 9912, 9911, 51545, 51549, 51641, 51637, 0, 0, 0, 0, 53533, 53835, 53836, 
53822, 53518, 53531, 53834, 53821
31197, 51545, 51549, 51641, 51637, 51546, 51550, 51642, 51638, 53533, 53835, 53836, 53822, 53536, 53838, 53839, 
53825, 53521, 53534, 53837, 53824
31198, 51546, 51550, 51642, 51638, 51547, 51551, 51643, 51639, 53536, 53838, 53839, 53825, 53539, 53841, 53842, 
53828, 53524, 53537, 53840, 53827
31199, 51547, 51551, 51643, 51639, 51548, 51552, 51644, 51640, 53539, 53841, 53842, 53828, 53542, 53844, 53845, 
53831, 53527, 53540, 53843, 53830
31200, 51548, 51552, 51644, 51640, 19185, 19186, 19209, 19208, 53542, 53844, 53845, 53831, 0, 0, 0, 
0, 53530, 53543, 53846, 53833
31201, 9889, 9890, 9913, 9912, 51549, 51553, 51645, 51641, 0, 0, 0, 0, 53546, 53848, 53849, 
53835, 53531, 53544, 53847, 53834
31202, 51549, 51553, 51645, 51641, 51550, 51554, 51646, 51642, 53546, 53848, 53849, 53835, 53549, 53851, 53852, 
53838, 53534, 53547, 53850, 53837
31203, 51550, 51554, 51646, 51642, 51551, 51555, 51647, 51643, 53549, 53851, 53852, 53838, 53552, 53854, 53855, 
53841, 53537, 53550, 53853, 53840
31204, 51551, 51555, 51647, 51643, 51552, 51556, 51648, 51644, 53552, 53854, 53855, 53841, 53555, 53857, 53858, 
53844, 53540, 53553, 53856, 53843
31205, 51552, 51556, 51648, 51644, 19186, 19187, 19210, 19209, 53555, 53857, 53858, 53844, 0, 0, 0, 
0, 53543, 53556, 53859, 53846
31206, 9890, 9891, 9914, 9913, 51553, 51557, 51649, 51645, 0, 0, 0, 0, 53559, 53861, 53862, 
53848, 53544, 53557, 53860, 53847
31207, 51553, 51557, 51649, 51645, 51554, 51558, 51650, 51646, 53559, 53861, 53862, 53848, 53562, 53864, 53865, 
53851, 53547, 53560, 53863, 53850
31208, 51554, 51558, 51650, 51646, 51555, 51559, 51651, 51647, 53562, 53864, 53865, 53851, 53565, 53867, 53868, 
53854, 53550, 53563, 53866, 53853
31209, 51555, 51559, 51651, 51647, 51556, 51560, 51652, 51648, 53565, 53867, 53868, 53854, 53568, 53870, 53871, 
53857, 53553, 53566, 53869, 53856
31210, 51556, 51560, 51652, 51648, 19187, 19188, 19211, 19210, 53568, 53870, 53871, 53857, 0, 0, 0, 
0, 53556, 53569, 53872, 53859
31211, 9891, 9892, 9915, 9914, 51557, 51561, 51653, 51649, 0, 0, 0, 0, 53572, 53874, 53875, 
53861, 53557, 53570, 53873, 53860
31212, 51557, 51561, 51653, 51649, 51558, 51562, 51654, 51650, 53572, 53874, 53875, 53861, 53575, 53877, 53878, 
53864, 53560, 53573, 53876, 53863
31213, 51558, 51562, 51654, 51650, 51559, 51563, 51655, 51651, 53575, 53877, 53878, 53864, 53578, 53880, 53881, 
53867, 53563, 53576, 53879, 53866
31214, 51559, 51563, 51655, 51651, 51560, 51564, 51656, 51652, 53578, 53880, 53881, 53867, 53581, 53883, 53884, 
53870, 53566, 53579, 53882, 53869
31215, 51560, 51564, 51656, 51652, 19188, 19189, 19212, 19211, 53581, 53883, 53884, 53870, 0, 0, 0, 
0, 53569, 53582, 53885, 53872
31216, 9892, 9893, 9916, 9915, 51561, 51565, 51657, 51653, 0, 0, 0, 0, 53585, 53887, 53888, 
53874, 53570, 53583, 53886, 53873
31217, 51561, 51565, 51657, 51653, 51562, 51566, 51658, 51654, 53585, 53887, 53888, 53874, 53588, 53890, 53891, 
53877, 53573, 53586, 53889, 53876
31218, 51562, 51566, 51658, 51654, 51563, 51567, 51659, 51655, 53588, 53890, 53891, 53877, 53591, 53893, 53894, 
53880, 53576, 53589, 53892, 53879
31219, 51563, 51567, 51659, 51655, 51564, 51568, 51660, 51656, 53591, 53893, 53894, 53880, 53594, 53896, 53897, 
53883, 53579, 53592, 53895, 53882
31220, 51564, 51568, 51660, 51656, 19189, 19190, 19213, 19212, 53594, 53896, 53897, 53883, 0, 0, 0, 
0, 53582, 53595, 53898, 53885
31221, 9893, 9894, 9917, 9916, 51565, 51569, 51661, 51657, 0, 0, 0, 0, 53598, 53900, 53901, 
53887, 53583, 53596, 53899, 53886
31222, 51565, 51569, 51661, 51657, 51566, 51570, 51662, 51658, 53598, 53900, 53901, 53887, 53601, 53903, 53904, 
53890, 53586, 53599, 53902, 53889
31223, 51566, 51570, 51662, 51658, 51567, 51571, 51663, 51659, 53601, 53903, 53904, 53890, 53604, 53906, 53907, 
53893, 53589, 53602, 53905, 53892
31224, 51567, 51571, 51663, 51659, 51568, 51572, 51664, 51660, 53604, 53906, 53907, 53893, 53607, 53909, 53910, 
53896, 53592, 53605, 53908, 53895
31225, 51568, 51572, 51664, 51660, 19190, 19191, 19214, 19213, 53607, 53909, 53910, 53896, 0, 0, 0, 
0, 53595, 53608, 53911, 53898
31226, 9894, 9895, 9918, 9917, 51569, 51573, 51665, 51661, 0, 0, 0, 0, 53611, 53913, 53914, 
53900, 53596, 53609, 53912, 53899
31227, 51569, 51573, 51665, 51661, 51570, 51574, 51666, 51662, 53611, 53913, 53914, 53900, 53614, 53916, 53917, 
53903, 53599, 53612, 53915, 53902
31228, 51570, 51574, 51666, 51662, 51571, 51575, 51667, 51663, 53614, 53916, 53917, 53903, 53617, 53919, 53920, 
53906, 53602, 53615, 53918, 53905
31229, 51571, 51575, 51667, 51663, 51572, 51576, 51668, 51664, 53617, 53919, 53920, 53906, 53620, 53922, 53923, 
53909, 53605, 53618, 53921, 53908
31230, 51572, 51576, 51668, 51664, 19191, 19192, 19215, 19214, 53620, 53922, 53923, 53909, 0, 0, 0, 
0, 53608, 53621, 53924, 53911
31231, 9895, 9896, 9919, 9918, 51573, 51577, 51669, 51665, 0, 0, 0, 0, 53624, 53926, 53927, 
53913, 53609, 53622, 53925, 53912
31232, 51573, 51577, 51669, 51665, 51574, 51578, 51670, 51666, 53624, 53926, 53927, 53913, 53627, 53929, 53930, 
53916, 53612, 53625, 53928, 53915
31233, 51574, 51578, 51670, 51666, 51575, 51579, 51671, 51667, 53627, 53929, 53930, 53916, 53630, 53932, 53933, 
53919, 53615, 53628, 53931, 53918
31234, 51575, 51579, 51671, 51667, 51576, 51580, 51672, 51668, 53630, 53932, 53933, 53919, 53633, 53935, 53936, 
53922, 53618, 53631, 53934, 53921
31235, 51576, 51580, 51672, 51668, 19192, 19193, 19216, 19215, 53633, 53935, 53936, 53922, 0, 0, 0, 
0, 53621, 53634, 53937, 53924
31236, 9896, 9897, 9920, 9919, 51577, 51581, 51673, 51669, 0, 0, 0, 0, 53637, 53939, 53940, 
53926, 53622, 53635, 53938, 53925
31237, 51577, 51581, 51673, 51669, 51578, 51582, 51674, 51670, 53637, 53939, 53940, 53926, 53640, 53942, 53943, 
53929, 53625, 53638, 53941, 53928
31238, 51578, 51582, 51674, 51670, 51579, 51583, 51675, 51671, 53640, 53942, 53943, 53929, 53643, 53945, 53946, 
53932, 53628, 53641, 53944, 53931
31239, 51579, 51583, 51675, 51671, 51580, 51584, 51676, 51672, 53643, 53945, 53946, 53932, 53646, 53948, 53949, 
53935, 53631, 53644, 53947, 53934
31240, 51580, 51584, 51676, 51672, 19193, 19194, 19217, 19216, 53646, 53948, 53949, 53935, 0, 0, 0, 
0, 53634, 53647, 53950, 53937
31241, 9897, 1195, 1196, 9920, 51581, 18949, 18953, 51673, 0, 0, 0, 0, 53648, 19023, 53951, 
53939, 53635, 19013, 19022, 53938
31242, 51581, 18949, 18953, 51673, 51582, 18950, 18954, 51674, 53648, 19023, 53951, 53939, 53649, 19025, 53952, 
53942, 53638, 19015, 19024, 53941
31243, 51582, 18950, 18954, 51674, 51583, 18951, 18955, 51675, 53649, 19025, 53952, 53942, 53650, 19027, 53953, 
53945, 53641, 19017, 19026, 53944
31244, 51583, 18951, 18955, 51675, 51584, 18952, 18956, 51676, 53650, 19027, 53953, 53945, 53651, 19029, 53954, 
53948, 53644, 19019, 19028, 53947
31245, 51584, 18952, 18956, 51676, 19194, 2377, 2378, 19217, 53651, 19029, 53954, 53948, 0, 0, 0, 
0, 53647, 19021, 19030, 53950
31246, 1185, 9898, 9921, 1186, 18806, 51585, 51677, 18810, 0, 0, 0, 0, 53654, 53956, 53957, 
18884, 18876, 53652, 53955, 18885
31247, 18806, 51585, 51677, 18810, 18807, 51586, 51678, 18811, 53654, 53956, 53957, 18884, 53657, 53959, 53960, 
18886, 18878, 53655, 53958, 18887
31248, 18807, 51586, 51678, 18811, 18808, 51587, 51679, 18812, 53657, 53959, 53960, 18886, 53660, 53962, 53963, 
18888, 18880, 53658, 53961, 18889
31249, 18808, 51587, 51679, 18812, 18809, 51588, 51680, 18813, 53660, 53962, 53963, 18888, 53663, 53965, 53966, 
18890, 18882, 53661, 53964, 18891
31250, 18809, 51588, 51680, 18813, 2367, 19195, 19218, 2368, 53663, 53965, 53966, 18890, 0, 0, 0, 
0, 18883, 53664, 53967, 18892
31251, 9898, 9899, 9922, 9921, 51585, 51589, 51681, 51677, 0, 0, 0, 0, 53667, 53969, 53970, 
53956, 53652, 53665, 53968, 53955
31252, 51585, 51589, 51681, 51677, 51586, 51590, 51682, 51678, 53667, 53969, 53970, 53956, 53670, 53972, 53973, 
53959, 53655, 53668, 53971, 53958
31253, 51586, 51590, 51682, 51678, 51587, 51591, 51683, 51679, 53670, 53972, 53973, 53959, 53673, 53975, 53976, 
53962, 53658, 53671, 53974, 53961
31254, 51587, 51591, 51683, 51679, 51588, 51592, 51684, 51680, 53673, 53975, 53976, 53962, 53676, 53978, 53979, 
53965, 53661, 53674, 53977, 53964
31255, 51588, 51592, 51684, 51680, 19195, 19196, 19219, 19218, 53676, 53978, 53979, 53965, 0, 0, 0, 
0, 53664, 53677, 53980, 53967
31256, 9899, 9900, 9923, 9922, 51589, 51593, 51685, 51681, 0, 0, 0, 0, 53680, 53982, 53983, 
53969, 53665, 53678, 53981, 53968
31257, 51589, 51593, 51685, 51681, 51590, 51594, 51686, 51682, 53680, 53982, 53983, 53969, 53683, 53985, 53986, 
53972, 53668, 53681, 53984, 53971
31258, 51590, 51594, 51686, 51682, 51591, 51595, 51687, 51683, 53683, 53985, 53986, 53972, 53686, 53988, 53989, 
53975, 53671, 53684, 53987, 53974
31259, 51591, 51595, 51687, 51683, 51592, 51596, 51688, 51684, 53686, 53988, 53989, 53975, 53689, 53991, 53992, 
53978, 53674, 53687, 53990, 53977
31260, 51592, 51596, 51688, 51684, 19196, 19197, 19220, 19219, 53689, 53991, 53992, 53978, 0, 0, 0, 
0, 53677, 53690, 53993, 53980
31261, 9900, 9901, 9924, 9923, 51593, 51597, 51689, 51685, 0, 0, 0, 0, 53693, 53995, 53996, 
53982, 53678, 53691, 53994, 53981
31262, 51593, 51597, 51689, 51685, 51594, 51598, 51690, 51686, 53693, 53995, 53996, 53982, 53696, 53998, 53999, 
53985, 53681, 53694, 53997, 53984
31263, 51594, 51598, 51690, 51686, 51595, 51599, 51691, 51687, 53696, 53998, 53999, 53985, 53699, 54001, 54002, 
53988, 53684, 53697, 54000, 53987
31264, 51595, 51599, 51691, 51687, 51596, 51600, 51692, 51688, 53699, 54001, 54002, 53988, 53702, 54004, 54005, 
53991, 53687, 53700, 54003, 53990
31265, 51596, 51600, 51692, 51688, 19197, 19198, 19221, 19220, 53702, 54004, 54005, 53991, 0, 0, 0, 
0, 53690, 53703, 54006, 53993
31266, 9901, 9902, 9925, 9924, 51597, 51601, 51693, 51689, 0, 0, 0, 0, 53706, 54008, 54009, 
53995, 53691, 53704, 54007, 53994
31267, 51597, 51601, 51693, 51689, 51598, 51602, 51694, 51690, 53706, 54008, 54009, 53995, 53709, 54011, 54012, 
53998, 53694, 53707, 54010, 53997
31268, 51598, 51602, 51694, 51690, 51599, 51603, 51695, 51691, 53709, 54011, 54012, 53998, 53712, 54014, 54015, 
54001, 53697, 53710, 54013, 54000
31269, 51599, 51603, 51695, 51691, 51600, 51604, 51696, 51692, 53712, 54014, 54015, 54001, 53715, 54017, 54018, 
54004, 53700, 53713, 54016, 54003
31270, 51600, 51604, 51696, 51692, 19198, 19199, 19222, 19221, 53715, 54017, 54018, 54004, 0, 0, 0, 
0, 53703, 53716, 54019, 54006
31271, 9902, 9903, 9926, 9925, 51601, 51605, 51697, 51693, 0, 0, 0, 0, 53719, 54021, 54022, 
54008, 53704, 53717, 54020, 54007
31272, 51601, 51605, 51697, 51693, 51602, 51606, 51698, 51694, 53719, 54021, 54022, 54008, 53722, 54024, 54025, 
54011, 53707, 53720, 54023, 54010
31273, 51602, 51606, 51698, 51694, 51603, 51607, 51699, 51695, 53722, 54024, 54025, 54011, 53725, 54027, 54028, 
54014, 53710, 53723, 54026, 54013
31274, 51603, 51607, 51699, 51695, 51604, 51608, 51700, 51696, 53725, 54027, 54028, 54014, 53728, 54030, 54031, 
54017, 53713, 53726, 54029, 54016
31275, 51604, 51608, 51700, 51696, 19199, 19200, 19223, 19222, 53728, 54030, 54031, 54017, 0, 0, 0, 
0, 53716, 53729, 54032, 54019
31276, 9903, 9904, 9927, 9926, 51605, 51609, 51701, 51697, 0, 0, 0, 0, 53732, 54034, 54035, 
54021, 53717, 53730, 54033, 54020
31277, 51605, 51609, 51701, 51697, 51606, 51610, 51702, 51698, 53732, 54034, 54035, 54021, 53735, 54037, 54038, 
54024, 53720, 53733, 54036, 54023
31278, 51606, 51610, 51702, 51698, 51607, 51611, 51703, 51699, 53735, 54037, 54038, 54024, 53738, 54040, 54041, 
54027, 53723, 53736, 54039, 54026
31279, 51607, 51611, 51703, 51699, 51608, 51612, 51704, 51700, 53738, 54040, 54041, 54027, 53741, 54043, 54044, 
54030, 53726, 53739, 54042, 54029
31280, 51608, 51612, 51704, 51700, 19200, 19201, 19224, 19223, 53741, 54043, 54044, 54030, 0, 0, 0, 
0, 53729, 53742, 54045, 54032
31281, 9904, 9905, 9928, 9927, 51609, 51613, 51705, 51701, 0, 0, 0, 0, 53745, 54047, 54048, 
54034, 53730, 53743, 54046, 54033
31282, 51609, 51613, 51705, 51701, 51610, 51614, 51706, 51702, 53745, 54047, 54048, 54034, 53748, 54050, 54051, 
54037, 53733, 53746, 54049, 54036
31283, 51610, 51614, 51706, 51702, 51611, 51615, 51707, 51703, 53748, 54050, 54051, 54037, 53751, 54053, 54054, 
54040, 53736, 53749, 54052, 54039
31284, 51611, 51615, 51707, 51703, 51612, 51616, 51708, 51704, 53751, 54053, 54054, 54040, 53754, 54056, 54057, 
54043, 53739, 53752, 54055, 54042
31285, 51612, 51616, 51708, 51704, 19201, 19202, 19225, 19224, 53754, 54056, 54057, 54043, 0, 0, 0, 
0, 53742, 53755, 54058, 54045
31286, 9905, 9906, 9929, 9928, 51613, 51617, 51709, 51705, 0, 0, 0, 0, 53758, 54060, 54061, 
54047, 53743, 53756, 54059, 54046
31287, 51613, 51617, 51709, 51705, 51614, 51618, 51710, 51706, 53758, 54060, 54061, 54047, 53761, 54063, 54064, 
54050, 53746, 53759, 54062, 54049
31288, 51614, 51618, 51710, 51706, 51615, 51619, 51711, 51707, 53761, 54063, 54064, 54050, 53764, 54066, 54067, 
54053, 53749, 53762, 54065, 54052
31289, 51615, 51619, 51711, 51707, 51616, 51620, 51712, 51708, 53764, 54066, 54067, 54053, 53767, 54069, 54070, 
54056, 53752, 53765, 54068, 54055
31290, 51616, 51620, 51712, 51708, 19202, 19203, 19226, 19225, 53767, 54069, 54070, 54056, 0, 0, 0, 
0, 53755, 53768, 54071, 54058
31291, 9906, 9907, 9930, 9929, 51617, 51621, 51713, 51709, 0, 0, 0, 0, 53771, 54073, 54074, 
54060, 53756, 53769, 54072, 54059
31292, 51617, 51621, 51713, 51709, 51618, 51622, 51714, 51710, 53771, 54073, 54074, 54060, 53774, 54076, 54077, 
54063, 53759, 53772, 54075, 54062
31293, 51618, 51622, 51714, 51710, 51619, 51623, 51715, 51711, 53774, 54076, 54077, 54063, 53777, 54079, 54080, 
54066, 53762, 53775, 54078, 54065
31294, 51619, 51623, 51715, 51711, 51620, 51624, 51716, 51712, 53777, 54079, 54080, 54066, 53780, 54082, 54083, 
54069, 53765, 53778, 54081, 54068
31295, 51620, 51624, 51716, 51712, 19203, 19204, 19227, 19226, 53780, 54082, 54083, 54069, 0, 0, 0, 
0, 53768, 53781, 54084, 54071
31296, 9907, 9908, 9931, 9930, 51621, 51625, 51717, 51713, 0, 0, 0, 0, 53784, 54086, 54087, 
54073, 53769, 53782, 54085, 54072
31297, 51621, 51625, 51717, 51713, 51622, 51626, 51718, 51714, 53784, 54086, 54087, 54073, 53787, 54089, 54090, 
54076, 53772, 53785, 54088, 54075
31298, 51622, 51626, 51718, 51714, 51623, 51627, 51719, 51715, 53787, 54089, 54090, 54076, 53790, 54092, 54093, 
54079, 53775, 53788, 54091, 54078
31299, 51623, 51627, 51719, 51715, 51624, 51628, 51720, 51716, 53790, 54092, 54093, 54079, 53793, 54095, 54096, 
54082, 53778, 53791, 54094, 54081
31300, 51624, 51628, 51720, 51716, 19204, 19205, 19228, 19227, 53793, 54095, 54096, 54082, 0, 0, 0, 
0, 53781, 53794, 54097, 54084
31301, 9908, 9909, 9932, 9931, 51625, 51629, 51721, 51717, 0, 0, 0, 0, 53797, 54099, 54100, 
54086, 53782, 53795, 54098, 54085
31302, 51625, 51629, 51721, 51717, 51626, 51630, 51722, 51718, 53797, 54099, 54100, 54086, 53800, 54102, 54103, 
54089, 53785, 53798, 54101, 54088
31303, 51626, 51630, 51722, 51718, 51627, 51631, 51723, 51719, 53800, 54102, 54103, 54089, 53803, 54105, 54106, 
54092, 53788, 53801, 54104, 54091
31304, 51627, 51631, 51723, 51719, 51628, 51632, 51724, 51720, 53803, 54105, 54106, 54092, 53806, 54108, 54109, 
54095, 53791, 53804, 54107, 54094
31305, 51628, 51632, 51724, 51720, 19205, 19206, 19229, 19228, 53806, 54108, 54109, 54095, 0, 0, 0, 
0, 53794, 53807, 54110, 54097
31306, 9909, 9910, 9933, 9932, 51629, 51633, 51725, 51721, 0, 0, 0, 0, 53810, 54112, 54113, 
54099, 53795, 53808, 54111, 54098
31307, 51629, 51633, 51725, 51721, 51630, 51634, 51726, 51722, 53810, 54112, 54113, 54099, 53813, 54115, 54116, 
54102, 53798, 53811, 54114, 54101
31308, 51630, 51634, 51726, 51722, 51631, 51635, 51727, 51723, 53813, 54115, 54116, 54102, 53816, 54118, 54119, 
54105, 53801, 53814, 54117, 54104
31309, 51631, 51635, 51727, 51723, 51632, 51636, 51728, 51724, 53816, 54118, 54119, 54105, 53819, 54121, 54122, 
54108, 53804, 53817, 54120, 54107
31310, 51632, 51636, 51728, 51724, 19206, 19207, 19230, 19229, 53819, 54121, 54122, 54108, 0, 0, 0, 
0, 53807, 53820, 54123, 54110
31311, 9910, 9911, 9934, 9933, 51633, 51637, 51729, 51725, 0, 0, 0, 0, 53823, 54125, 54126, 
54112, 53808, 53821, 54124, 54111
31312, 51633, 51637, 51729, 51725, 51634, 51638, 51730, 51726, 53823, 54125, 54126, 54112, 53826, 54128, 54129, 
54115, 53811, 53824, 54127, 54114
31313, 51634, 51638, 51730, 51726, 51635, 51639, 51731, 51727, 53826, 54128, 54129, 54115, 53829, 54131, 54132, 
54118, 53814, 53827, 54130, 54117
31314, 51635, 51639, 51731, 51727, 51636, 51640, 51732, 51728, 53829, 54131, 54132, 54118, 53832, 54134, 54135, 
54121, 53817, 53830, 54133, 54120
31315, 51636, 51640, 51732, 51728, 19207, 19208, 19231, 19230, 53832, 54134, 54135, 54121, 0, 0, 0, 
0, 53820, 53833, 54136, 54123
31316, 9911, 9912, 9935, 9934, 51637, 51641, 51733, 51729, 0, 0, 0, 0, 53836, 54138, 54139, 
54125, 53821, 53834, 54137, 54124
31317, 51637, 51641, 51733, 51729, 51638, 51642, 51734, 51730, 53836, 54138, 54139, 54125, 53839, 54141, 54142, 
54128, 53824, 53837, 54140, 54127
31318, 51638, 51642, 51734, 51730, 51639, 51643, 51735, 51731, 53839, 54141, 54142, 54128, 53842, 54144, 54145, 
54131, 53827, 53840, 54143, 54130
31319, 51639, 51643, 51735, 51731, 51640, 51644, 51736, 51732, 53842, 54144, 54145, 54131, 53845, 54147, 54148, 
54134, 53830, 53843, 54146, 54133
31320, 51640, 51644, 51736, 51732, 19208, 19209, 19232, 19231, 53845, 54147, 54148, 54134, 0, 0, 0, 
0, 53833, 53846, 54149, 54136
31321, 9912, 9913, 9936, 9935, 51641, 51645, 51737, 51733, 0, 0, 0, 0, 53849, 54151, 54152, 
54138, 53834, 53847, 54150, 54137
31322, 51641, 51645, 51737, 51733, 51642, 51646, 51738, 51734, 53849, 54151, 54152, 54138, 53852, 54154, 54155, 
54141, 53837, 53850, 54153, 54140
31323, 51642, 51646, 51738, 51734, 51643, 51647, 51739, 51735, 53852, 54154, 54155, 54141, 53855, 54157, 54158, 
54144, 53840, 53853, 54156, 54143
31324, 51643, 51647, 51739, 51735, 51644, 51648, 51740, 51736, 53855, 54157, 54158, 54144, 53858, 54160, 54161, 
54147, 53843, 53856, 54159, 54146
31325, 51644, 51648, 51740, 51736, 19209, 19210, 19233, 19232, 53858, 54160, 54161, 54147, 0, 0, 0, 
0, 53846, 53859, 54162, 54149
31326, 9913, 9914, 9937, 9936, 51645, 51649, 51741, 51737, 0, 0, 0, 0, 53862, 54164, 54165, 
54151, 53847, 53860, 54163, 54150
31327, 51645, 51649, 51741, 51737, 51646, 51650, 51742, 51738, 53862, 54164, 54165, 54151, 53865, 54167, 54168, 
54154, 53850, 53863, 54166, 54153
31328, 51646, 51650, 51742, 51738, 51647, 51651, 51743, 51739, 53865, 54167, 54168, 54154, 53868, 54170, 54171, 
54157, 53853, 53866, 54169, 54156
31329, 51647, 51651, 51743, 51739, 51648, 51652, 51744, 51740, 53868, 54170, 54171, 54157, 53871, 54173, 54174, 
54160, 53856, 53869, 54172, 54159
31330, 51648, 51652, 51744, 51740, 19210, 19211, 19234, 19233, 53871, 54173, 54174, 54160, 0, 0, 0, 
0, 53859, 53872, 54175, 54162
31331, 9914, 9915, 9938, 9937, 51649, 51653, 51745, 51741, 0, 0, 0, 0, 53875, 54177, 54178, 
54164, 53860, 53873, 54176, 54163
31332, 51649, 51653, 51745, 51741, 51650, 51654, 51746, 51742, 53875, 54177, 54178, 54164, 53878, 54180, 54181, 
54167, 53863, 53876, 54179, 54166
31333, 51650, 51654, 51746, 51742, 51651, 51655, 51747, 51743, 53878, 54180, 54181, 54167, 53881, 54183, 54184, 
54170, 53866, 53879, 54182, 54169
31334, 51651, 51655, 51747, 51743, 51652, 51656, 51748, 51744, 53881, 54183, 54184, 54170, 53884, 54186, 54187, 
54173, 53869, 53882, 54185, 54172
31335, 51652, 51656, 51748, 51744, 19211, 19212, 19235, 19234, 53884, 54186, 54187, 54173, 0, 0, 0, 
0, 53872, 53885, 54188, 54175
31336, 9915, 9916, 9939, 9938, 51653, 51657, 51749, 51745, 0, 0, 0, 0, 53888, 54190, 54191, 
54177, 53873, 53886, 54189, 54176
31337, 51653, 51657, 51749, 51745, 51654, 51658, 51750, 51746, 53888, 54190, 54191, 54177, 53891, 54193, 54194, 
54180, 53876, 53889, 54192, 54179
31338, 51654, 51658, 51750, 51746, 51655, 51659, 51751, 51747, 53891, 54193, 54194, 54180, 53894, 54196, 54197, 
54183, 53879, 53892, 54195, 54182
31339, 51655, 51659, 51751, 51747, 51656, 51660, 51752, 51748, 53894, 54196, 54197, 54183, 53897, 54199, 54200, 
54186, 53882, 53895, 54198, 54185
31340, 51656, 51660, 51752, 51748, 19212, 19213, 19236, 19235, 53897, 54199, 54200, 54186, 0, 0, 0, 
0, 53885, 53898, 54201, 54188
31341, 9916, 9917, 9940, 9939, 51657, 51661, 51753, 51749, 0, 0, 0, 0, 53901, 54203, 54204, 
54190, 53886, 53899, 54202, 54189
31342, 51657, 51661, 51753, 51749, 51658, 51662, 51754, 51750, 53901, 54203, 54204, 54190, 53904, 54206, 54207, 
54193, 53889, 53902, 54205, 54192
31343, 51658, 51662, 51754, 51750, 51659, 51663, 51755, 51751, 53904, 54206, 54207, 54193, 53907, 54209, 54210, 
54196, 53892, 53905, 54208, 54195
31344, 51659, 51663, 51755, 51751, 51660, 51664, 51756, 51752, 53907, 54209, 54210, 54196, 53910, 54212, 54213, 
54199, 53895, 53908, 54211, 54198
31345, 51660, 51664, 51756, 51752, 19213, 19214, 19237, 19236, 53910, 54212, 54213, 54199, 0, 0, 0, 
0, 53898, 53911, 54214, 54201
31346, 9917, 9918, 9941, 9940, 51661, 51665, 51757, 51753, 0, 0, 0, 0, 53914, 54216, 54217, 
54203, 53899, 53912, 54215, 54202
31347, 51661, 51665, 51757, 51753, 51662, 51666, 51758, 51754, 53914, 54216, 54217, 54203, 53917, 54219, 54220, 
54206, 53902, 53915, 54218, 54205
31348, 51662, 51666, 51758, 51754, 51663, 51667, 51759, 51755, 53917, 54219, 54220, 54206, 53920, 54222, 54223, 
54209, 53905, 53918, 54221, 54208
31349, 51663, 51667, 51759, 51755, 51664, 51668, 51760, 51756, 53920, 54222, 54223, 54209, 53923, 54225, 54226, 
54212, 53908, 53921, 54224, 54211
31350, 51664, 51668, 51760, 51756, 19214, 19215, 19238, 19237, 53923, 54225, 54226, 54212, 0, 0, 0, 
0, 53911, 53924, 54227, 54214
31351, 9918, 9919, 9942, 9941, 51665, 51669, 51761, 51757, 0, 0, 0, 0, 53927, 54229, 54230, 
54216, 53912, 53925, 54228, 54215
31352, 51665, 51669, 51761, 51757, 51666, 51670, 51762, 51758, 53927, 54229, 54230, 54216, 53930, 54232, 54233, 
54219, 53915, 53928, 54231, 54218
31353, 51666, 51670, 51762, 51758, 51667, 51671, 51763, 51759, 53930, 54232, 54233, 54219, 53933, 54235, 54236, 
54222, 53918, 53931, 54234, 54221
31354, 51667, 51671, 51763, 51759, 51668, 51672, 51764, 51760, 53933, 54235, 54236, 54222, 53936, 54238, 54239, 
54225, 53921, 53934, 54237, 54224
31355, 51668, 51672, 51764, 51760, 19215, 19216, 19239, 19238, 53936, 54238, 54239, 54225, 0, 0, 0, 
0, 53924, 53937, 54240, 54227
31356, 9919, 9920, 9943, 9942, 51669, 51673, 51765, 51761, 0, 0, 0, 0, 53940, 54242, 54243, 
54229, 53925, 53938, 54241, 54228
31357, 51669, 51673, 51765, 51761, 51670, 51674, 51766, 51762, 53940, 54242, 54243, 54229, 53943, 54245, 54246, 
54232, 53928, 53941, 54244, 54231
31358, 51670, 51674, 51766, 51762, 51671, 51675, 51767, 51763, 53943, 54245, 54246, 54232, 53946, 54248, 54249, 
54235, 53931, 53944, 54247, 54234
31359, 51671, 51675, 51767, 51763, 51672, 51676, 51768, 51764, 53946, 54248, 54249, 54235, 53949, 54251, 54252, 
54238, 53934, 53947, 54250, 54237
31360, 51672, 51676, 51768, 51764, 19216, 19217, 19240, 19239, 53949, 54251, 54252, 54238, 0, 0, 0, 
0, 53937, 53950, 54253, 54240
31361, 9920, 1196, 1197, 9943, 51673, 18953, 18957, 51765, 0, 0, 0, 0, 53951, 19032, 54254, 
54242, 53938, 19022, 19031, 54241
31362, 51673, 18953, 18957, 51765, 51674, 18954, 18958, 51766, 53951, 19032, 54254, 54242, 53952, 19034, 54255, 
54245, 53941, 19024, 19033, 54244
31363, 51674, 18954, 18958, 51766, 51675, 18955, 18959, 51767, 53952, 19034, 54255, 54245, 53953, 19036, 54256, 
54248, 53944, 19026, 19035, 54247
31364, 51675, 18955, 18959, 51767, 51676, 18956, 18960, 51768, 53953, 19036, 54256, 54248, 53954, 19038, 54257, 
54251, 53947, 19028, 19037, 54250
31365, 51676, 18956, 18960, 51768, 19217, 2378, 2379, 19240, 53954, 19038, 54257, 54251, 0, 0, 0, 
0, 53950, 19030, 19039, 54253
31366, 1186, 9921, 9944, 1187, 18810, 51677, 51769, 18814, 0, 0, 0, 0, 53957, 54259, 54260, 
18893, 18885, 53955, 54258, 18894
31367, 18810, 51677, 51769, 18814, 18811, 51678, 51770, 18815, 53957, 54259, 54260, 18893, 53960, 54262, 54263, 
18895, 18887, 53958, 54261, 18896
31368, 18811, 51678, 51770, 18815, 18812, 51679, 51771, 18816, 53960, 54262, 54263, 18895, 53963, 54265, 54266, 
18897, 18889, 53961, 54264, 18898
31369, 18812, 51679, 51771, 18816, 18813, 51680, 51772, 18817, 53963, 54265, 54266, 18897, 53966, 54268, 54269, 
18899, 18891, 53964, 54267, 18900
31370, 18813, 51680, 51772, 18817, 2368, 19218, 19241, 2369, 53966, 54268, 54269, 18899, 0, 0, 0, 
0, 18892, 53967, 54270, 18901
31371, 9921, 9922, 9945, 9944, 51677, 51681, 51773, 51769, 0, 0, 0, 0, 53970, 54272, 54273, 
54259, 53955, 53968, 54271, 54258
31372, 51677, 51681, 51773, 51769, 51678, 51682, 51774, 51770, 53970, 54272, 54273, 54259, 53973, 54275, 54276, 
54262, 53958, 53971, 54274, 54261
31373, 51678, 51682, 51774, 51770, 51679, 51683, 51775, 51771, 53973, 54275, 54276, 54262, 53976, 54278, 54279, 
54265, 53961, 53974, 54277, 54264
31374, 51679, 51683, 51775, 51771, 51680, 51684, 51776, 51772, 53976, 54278, 54279, 54265, 53979, 54281, 54282, 
54268, 53964, 53977, 54280, 54267
31375, 51680, 51684, 51776, 51772, 19218, 19219, 19242, 19241, 53979, 54281, 54282, 54268, 0, 0, 0, 
0, 53967, 53980, 54283, 54270
31376, 9922, 9923, 9946, 9945, 51681, 51685, 51777, 51773, 0, 0, 0, 0, 53983, 54285, 54286, 
54272, 53968, 53981, 54284, 54271
31377, 51681, 51685, 51777, 51773, 51682, 51686, 51778, 51774, 53983, 54285, 54286, 54272, 53986, 54288, 54289, 
54275, 53971, 53984, 54287, 54274
31378, 51682, 51686, 51778, 51774, 51683, 51687, 51779, 51775, 53986, 54288, 54289, 54275, 53989, 54291, 54292, 
54278, 53974, 53987, 54290, 54277
31379, 51683, 51687, 51779, 51775, 51684, 51688, 51780, 51776, 53989, 54291, 54292, 54278, 53992, 54294, 54295, 
54281, 53977, 53990, 54293, 54280
31380, 51684, 51688, 51780, 51776, 19219, 19220, 19243, 19242, 53992, 54294, 54295, 54281, 0, 0, 0, 
0, 53980, 53993, 54296, 54283
31381, 9923, 9924, 9947, 9946, 51685, 51689, 51781, 51777, 0, 0, 0, 0, 53996, 54298, 54299, 
54285, 53981, 53994, 54297, 54284
31382, 51685, 51689, 51781, 51777, 51686, 51690, 51782, 51778, 53996, 54298, 54299, 54285, 53999, 54301, 54302, 
54288, 53984, 53997, 54300, 54287
31383, 51686, 51690, 51782, 51778, 51687, 51691, 51783, 51779, 53999, 54301, 54302, 54288, 54002, 54304, 54305, 
54291, 53987, 54000, 54303, 54290
31384, 51687, 51691, 51783, 51779, 51688, 51692, 51784, 51780, 54002, 54304, 54305, 54291, 54005, 54307, 54308, 
54294, 53990, 54003, 54306, 54293
31385, 51688, 51692, 51784, 51780, 19220, 19221, 19244, 19243, 54005, 54307, 54308, 54294, 0, 0, 0, 
0, 53993, 54006, 54309, 54296
31386, 9924, 9925, 9948, 9947, 51689, 51693, 51785, 51781, 0, 0, 0, 0, 54009, 54311, 54312, 
54298, 53994, 54007, 54310, 54297
31387, 51689, 51693, 51785, 51781, 51690, 51694, 51786, 51782, 54009, 54311, 54312, 54298, 54012, 54314, 54315, 
54301, 53997, 54010, 54313, 54300
31388, 51690, 51694, 51786, 51782, 51691, 51695, 51787, 51783, 54012, 54314, 54315, 54301, 54015, 54317, 54318, 
54304, 54000, 54013, 54316, 54303
31389, 51691, 51695, 51787, 51783, 51692, 51696, 51788, 51784, 54015, 54317, 54318, 54304, 54018, 54320, 54321, 
54307, 54003, 54016, 54319, 54306
31390, 51692, 51696, 51788, 51784, 19221, 19222, 19245, 19244, 54018, 54320, 54321, 54307, 0, 0, 0, 
0, 54006, 54019, 54322, 54309
31391, 9925, 9926, 9949, 9948, 51693, 51697, 51789, 51785, 0, 0, 0, 0, 54022, 54324, 54325, 
54311, 54007, 54020, 54323, 54310
31392, 51693, 51697, 51789, 51785, 51694, 51698, 51790, 51786, 54022, 54324, 54325, 54311, 54025, 54327, 54328, 
54314, 54010, 54023, 54326, 54313
31393, 51694, 51698, 51790, 51786, 51695, 51699, 51791, 51787, 54025, 54327, 54328, 54314, 54028, 54330, 54331, 
54317, 54013, 54026, 54329, 54316
31394, 51695, 51699, 51791, 51787, 51696, 51700, 51792, 51788, 54028, 54330, 54331, 54317, 54031, 54333, 54334, 
54320, 54016, 54029, 54332, 54319
31395, 51696, 51700, 51792, 51788, 19222, 19223, 19246, 19245, 54031, 54333, 54334, 54320, 0, 0, 0, 
0, 54019, 54032, 54335, 54322
31396, 9926, 9927, 9950, 9949, 51697, 51701, 51793, 51789, 0, 0, 0, 0, 54035, 54337, 54338, 
54324, 54020, 54033, 54336, 54323
31397, 51697, 51701, 51793, 51789, 51698, 51702, 51794, 51790, 54035, 54337, 54338, 54324, 54038, 54340, 54341, 
54327, 54023, 54036, 54339, 54326
31398, 51698, 51702, 51794, 51790, 51699, 51703, 51795, 51791, 54038, 54340, 54341, 54327, 54041, 54343, 54344, 
54330, 54026, 54039, 54342, 54329
31399, 51699, 51703, 51795, 51791, 51700, 51704, 51796, 51792, 54041, 54343, 54344, 54330, 54044, 54346, 54347, 
54333, 54029, 54042, 54345, 54332
31400, 51700, 51704, 51796, 51792, 19223, 19224, 19247, 19246, 54044, 54346, 54347, 54333, 0, 0, 0, 
0, 54032, 54045, 54348, 54335
31401, 9927, 9928, 9951, 9950, 51701, 51705, 51797, 51793, 0, 0, 0, 0, 54048, 54350, 54351, 
54337, 54033, 54046, 54349, 54336
31402, 51701, 51705, 51797, 51793, 51702, 51706, 51798, 51794, 54048, 54350, 54351, 54337, 54051, 54353, 54354, 
54340, 54036, 54049, 54352, 54339
31403, 51702, 51706, 51798, 51794, 51703, 51707, 51799, 51795, 54051, 54353, 54354, 54340, 54054, 54356, 54357, 
54343, 54039, 54052, 54355, 54342
31404, 51703, 51707, 51799, 51795, 51704, 51708, 51800, 51796, 54054, 54356, 54357, 54343, 54057, 54359, 54360, 
54346, 54042, 54055, 54358, 54345
31405, 51704, 51708, 51800, 51796, 19224, 19225, 19248, 19247, 54057, 54359, 54360, 54346, 0, 0, 0, 
0, 54045, 54058, 54361, 54348
31406, 9928, 9929, 9952, 9951, 51705, 51709, 51801, 51797, 0, 0, 0, 0, 54061, 54363, 54364, 
54350, 54046, 54059, 54362, 54349
31407, 51705, 51709, 51801, 51797, 51706, 51710, 51802, 51798, 54061, 54363, 54364, 54350, 54064, 54366, 54367, 
54353, 54049, 54062, 54365, 54352
31408, 51706, 51710, 51802, 51798, 51707, 51711, 51803, 51799, 54064, 54366, 54367, 54353, 54067, 54369, 54370, 
54356, 54052, 54065, 54368, 54355
31409, 51707, 51711, 51803, 51799, 51708, 51712, 51804, 51800, 54067, 54369, 54370, 54356, 54070, 54372, 54373, 
54359, 54055, 54068, 54371, 54358
31410, 51708, 51712, 51804, 51800, 19225, 19226, 19249, 19248, 54070, 54372, 54373, 54359, 0, 0, 0, 
0, 54058, 54071, 54374, 54361
31411, 9929, 9930, 9953, 9952, 51709, 51713, 51805, 51801, 0, 0, 0, 0, 54074, 54376, 54377, 
54363, 54059, 54072, 54375, 54362
31412, 51709, 51713, 51805, 51801, 51710, 51714, 51806, 51802, 54074, 54376, 54377, 54363, 54077, 54379, 54380, 
54366, 54062, 54075, 54378, 54365
31413, 51710, 51714, 51806, 51802, 51711, 51715, 51807, 51803, 54077, 54379, 54380, 54366, 54080, 54382, 54383, 
54369, 54065, 54078, 54381, 54368
31414, 51711, 51715, 51807, 51803, 51712, 51716, 51808, 51804, 54080, 54382, 54383, 54369, 54083, 54385, 54386, 
54372, 54068, 54081, 54384, 54371
31415, 51712, 51716, 51808, 51804, 19226, 19227, 19250, 19249, 54083, 54385, 54386, 54372, 0, 0, 0, 
0, 54071, 54084, 54387, 54374
31416, 9930, 9931, 9954, 9953, 51713, 51717, 51809, 51805, 0, 0, 0, 0, 54087, 54389, 54390, 
54376, 54072, 54085, 54388, 54375
31417, 51713, 51717, 51809, 51805, 51714, 51718, 51810, 51806, 54087, 54389, 54390, 54376, 54090, 54392, 54393, 
54379, 54075, 54088, 54391, 54378
31418, 51714, 51718, 51810, 51806, 51715, 51719, 51811, 51807, 54090, 54392, 54393, 54379, 54093, 54395, 54396, 
54382, 54078, 54091, 54394, 54381
31419, 51715, 51719, 51811, 51807, 51716, 51720, 51812, 51808, 54093, 54395, 54396, 54382, 54096, 54398, 54399, 
54385, 54081, 54094, 54397, 54384
31420, 51716, 51720, 51812, 51808, 19227, 19228, 19251, 19250, 54096, 54398, 54399, 54385, 0, 0, 0, 
0, 54084, 54097, 54400, 54387
31421, 9931, 9932, 9955, 9954, 51717, 51721, 51813, 51809, 0, 0, 0, 0, 54100, 54402, 54403, 
54389, 54085, 54098, 54401, 54388
31422, 51717, 51721, 51813, 51809, 51718, 51722, 51814, 51810, 54100, 54402, 54403, 54389, 54103, 54405, 54406, 
54392, 54088, 54101, 54404, 54391
31423, 51718, 51722, 51814, 51810, 51719, 51723, 51815, 51811, 54103, 54405, 54406, 54392, 54106, 54408, 54409, 
54395, 54091, 54104, 54407, 54394
31424, 51719, 51723, 51815, 51811, 51720, 51724, 51816, 51812, 54106, 54408, 54409, 54395, 54109, 54411, 54412, 
54398, 54094, 54107, 54410, 54397
31425, 51720, 51724, 51816, 51812, 19228, 19229, 19252, 19251, 54109, 54411, 54412, 54398, 0, 0, 0, 
0, 54097, 54110, 54413, 54400
31426, 9932, 9933, 9956, 9955, 51721, 51725, 51817, 51813, 0, 0, 0, 0, 54113, 54415, 54416, 
54402, 54098, 54111, 54414, 54401
31427, 51721, 51725, 51817, 51813, 51722, 51726, 51818, 51814, 54113, 54415, 54416, 54402, 54116, 54418, 54419, 
54405, 54101, 54114, 54417, 54404
31428, 51722, 51726, 51818, 51814, 51723, 51727, 51819, 51815, 54116, 54418, 54419, 54405, 54119, 54421, 54422, 
54408, 54104, 54117, 54420, 54407
31429, 51723, 51727, 51819, 51815, 51724, 51728, 51820, 51816, 54119, 54421, 54422, 54408, 54122, 54424, 54425, 
54411, 54107, 54120, 54423, 54410
31430, 51724, 51728, 51820, 51816, 19229, 19230, 19253, 19252, 54122, 54424, 54425, 54411, 0, 0, 0, 
0, 54110, 54123, 54426, 54413
31431, 9933, 9934, 9957, 9956, 51725, 51729, 51821, 51817, 0, 0, 0, 0, 54126, 54428, 54429, 
54415, 54111, 54124, 54427, 54414
31432, 51725, 51729, 51821, 51817, 51726, 51730, 51822, 51818, 54126, 54428, 54429, 54415, 54129, 54431, 54432, 
54418, 54114, 54127, 54430, 54417
31433, 51726, 51730, 51822, 51818, 51727, 51731, 51823, 51819, 54129, 54431, 54432, 54418, 54132, 54434, 54435, 
54421, 54117, 54130, 54433, 54420
31434, 51727, 51731, 51823, 51819, 51728, 51732, 51824, 51820, 54132, 54434, 54435, 54421, 54135, 54437, 54438, 
54424, 54120, 54133, 54436, 54423
31435, 51728, 51732, 51824, 51820, 19230, 19231, 19254, 19253, 54135, 54437, 54438, 54424, 0, 0, 0, 
0, 54123, 54136, 54439, 54426
31436, 9934, 9935, 9958, 9957, 51729, 51733, 51825, 51821, 0, 0, 0, 0, 54139, 54441, 54442, 
54428, 54124, 54137, 54440, 54427
31437, 51729, 51733, 51825, 51821, 51730, 51734, 51826, 51822, 54139, 54441, 54442, 54428, 54142, 54444, 54445, 
54431, 54127, 54140, 54443, 54430
31438, 51730, 51734, 51826, 51822, 51731, 51735, 51827, 51823, 54142, 54444, 54445, 54431, 54145, 54447, 54448, 
54434, 54130, 54143, 54446, 54433
31439, 51731, 51735, 51827, 51823, 51732, 51736, 51828, 51824, 54145, 54447, 54448, 54434, 54148, 54450, 54451, 
54437, 54133, 54146, 54449, 54436
31440, 51732, 51736, 51828, 51824, 19231, 19232, 19255, 19254, 54148, 54450, 54451, 54437, 0, 0, 0, 
0, 54136, 54149, 54452, 54439
31441, 9935, 9936, 9959, 9958, 51733, 51737, 51829, 51825, 0, 0, 0, 0, 54152, 54454, 54455, 
54441, 54137, 54150, 54453, 54440
31442, 51733, 51737, 51829, 51825, 51734, 51738, 51830, 51826, 54152, 54454, 54455, 54441, 54155, 54457, 54458, 
54444, 54140, 54153, 54456, 54443
31443, 51734, 51738, 51830, 51826, 51735, 51739, 51831, 51827, 54155, 54457, 54458, 54444, 54158, 54460, 54461, 
54447, 54143, 54156, 54459, 54446
31444, 51735, 51739, 51831, 51827, 51736, 51740, 51832, 51828, 54158, 54460, 54461, 54447, 54161, 54463, 54464, 
54450, 54146, 54159, 54462, 54449
31445, 51736, 51740, 51832, 51828, 19232, 19233, 19256, 19255, 54161, 54463, 54464, 54450, 0, 0, 0, 
0, 54149, 54162, 54465, 54452
31446, 9936, 9937, 9960, 9959, 51737, 51741, 51833, 51829, 0, 0, 0, 0, 54165, 54467, 54468, 
54454, 54150, 54163, 54466, 54453
31447, 51737, 51741, 51833, 51829, 51738, 51742, 51834, 51830, 54165, 54467, 54468, 54454, 54168, 54470, 54471, 
54457, 54153, 54166, 54469, 54456
31448, 51738, 51742, 51834, 51830, 51739, 51743, 51835, 51831, 54168, 54470, 54471, 54457, 54171, 54473, 54474, 
54460, 54156, 54169, 54472, 54459
31449, 51739, 51743, 51835, 51831, 51740, 51744, 51836, 51832, 54171, 54473, 54474, 54460, 54174, 54476, 54477, 
54463, 54159, 54172, 54475, 54462
31450, 51740, 51744, 51836, 51832, 19233, 19234, 19257, 19256, 54174, 54476, 54477, 54463, 0, 0, 0, 
0, 54162, 54175, 54478, 54465
31451, 9937, 9938, 9961, 9960, 51741, 51745, 51837, 51833, 0, 0, 0, 0, 54178, 54480, 54481, 
54467, 54163, 54176, 54479, 54466
31452, 51741, 51745, 51837, 51833, 51742, 51746, 51838, 51834, 54178, 54480, 54481, 54467, 54181, 54483, 54484, 
54470, 54166, 54179, 54482, 54469
31453, 51742, 51746, 51838, 51834, 51743, 51747, 51839, 51835, 54181, 54483, 54484, 54470, 54184, 54486, 54487, 
54473, 54169, 54182, 54485, 54472
31454, 51743, 51747, 51839, 51835, 51744, 51748, 51840, 51836, 54184, 54486, 54487, 54473, 54187, 54489, 54490, 
54476, 54172, 54185, 54488, 54475
31455, 51744, 51748, 51840, 51836, 19234, 19235, 19258, 19257, 54187, 54489, 54490, 54476, 0, 0, 0, 
0, 54175, 54188, 54491, 54478
31456, 9938, 9939, 9962, 9961, 51745, 51749, 51841, 51837, 0, 0, 0, 0, 54191, 54493, 54494, 
54480, 54176, 54189, 54492, 54479
31457, 51745, 51749, 51841, 51837, 51746, 51750, 51842, 51838, 54191, 54493, 54494, 54480, 54194, 54496, 54497, 
54483, 54179, 54192, 54495, 54482
31458, 51746, 51750, 51842, 51838, 51747, 51751, 51843, 51839, 54194, 54496, 54497, 54483, 54197, 54499, 54500, 
54486, 54182, 54195, 54498, 54485
31459, 51747, 51751, 51843, 51839, 51748, 51752, 51844, 51840, 54197, 54499, 54500, 54486, 54200, 54502, 54503, 
54489, 54185, 54198, 54501, 54488
31460, 51748, 51752, 51844, 51840, 19235, 19236, 19259, 19258, 54200, 54502, 54503, 54489, 0, 0, 0, 
0, 54188, 54201, 54504, 54491
31461, 9939, 9940, 9963, 9962, 51749, 51753, 51845, 51841, 0, 0, 0, 0, 54204, 54506, 54507, 
54493, 54189, 54202, 54505, 54492
31462, 51749, 51753, 51845, 51841, 51750, 51754, 51846, 51842, 54204, 54506, 54507, 54493, 54207, 54509, 54510, 
54496, 54192, 54205, 54508, 54495
31463, 51750, 51754, 51846, 51842, 51751, 51755, 51847, 51843, 54207, 54509, 54510, 54496, 54210, 54512, 54513, 
54499, 54195, 54208, 54511, 54498
31464, 51751, 51755, 51847, 51843, 51752, 51756, 51848, 51844, 54210, 54512, 54513, 54499, 54213, 54515, 54516, 
54502, 54198, 54211, 54514, 54501
31465, 51752, 51756, 51848, 51844, 19236, 19237, 19260, 19259, 54213, 54515, 54516, 54502, 0, 0, 0, 
0, 54201, 54214, 54517, 54504
31466, 9940, 9941, 9964, 9963, 51753, 51757, 51849, 51845, 0, 0, 0, 0, 54217, 54519, 54520, 
54506, 54202, 54215, 54518, 54505
31467, 51753, 51757, 51849, 51845, 51754, 51758, 51850, 51846, 54217, 54519, 54520, 54506, 54220, 54522, 54523, 
54509, 54205, 54218, 54521, 54508
31468, 51754, 51758, 51850, 51846, 51755, 51759, 51851, 51847, 54220, 54522, 54523, 54509, 54223, 54525, 54526, 
54512, 54208, 54221, 54524, 54511
31469, 51755, 51759, 51851, 51847, 51756, 51760, 51852, 51848, 54223, 54525, 54526, 54512, 54226, 54528, 54529, 
54515, 54211, 54224, 54527, 54514
31470, 51756, 51760, 51852, 51848, 19237, 19238, 19261, 19260, 54226, 54528, 54529, 54515, 0, 0, 0, 
0, 54214, 54227, 54530, 54517
31471, 9941, 9942, 9965, 9964, 51757, 51761, 51853, 51849, 0, 0, 0, 0, 54230, 54532, 54533, 
54519, 54215, 54228, 54531, 54518
31472, 51757, 51761, 51853, 51849, 51758, 51762, 51854, 51850, 54230, 54532, 54533, 54519, 54233, 54535, 54536, 
54522, 54218, 54231, 54534, 54521
31473, 51758, 51762, 51854, 51850, 51759, 51763, 51855, 51851, 54233, 54535, 54536, 54522, 54236, 54538, 54539, 
54525, 54221, 54234, 54537, 54524
31474, 51759, 51763, 51855, 51851, 51760, 51764, 51856, 51852, 54236, 54538, 54539, 54525, 54239, 54541, 54542, 
54528, 54224, 54237, 54540, 54527
31475, 51760, 51764, 51856, 51852, 19238, 19239, 19262, 19261, 54239, 54541, 54542, 54528, 0, 0, 0, 
0, 54227, 54240, 54543, 54530
31476, 9942, 9943, 9966, 9965, 51761, 51765, 51857, 51853, 0, 0, 0, 0, 54243, 54545, 54546, 
54532, 54228, 54241, 54544, 54531
31477, 51761, 51765, 51857, 51853, 51762, 51766, 51858, 51854, 54243, 54545, 54546, 54532, 54246, 54548, 54549, 
54535, 54231, 54244, 54547, 54534
31478, 51762, 51766, 51858, 51854, 51763, 51767, 51859, 51855, 54246, 54548, 54549, 54535, 54249, 54551, 54552, 
54538, 54234, 54247, 54550, 54537
31479, 51763, 51767, 51859, 51855, 51764, 51768, 51860, 51856, 54249, 54551, 54552, 54538, 54252, 54554, 54555, 
54541, 54237, 54250, 54553, 54540
31480, 51764, 51768, 51860, 51856, 19239, 19240, 19263, 19262, 54252, 54554, 54555, 54541, 0, 0, 0, 
0, 54240, 54253, 54556, 54543
31481, 9943, 1197, 1198, 9966, 51765, 18957, 18961, 51857, 0, 0, 0, 0, 54254, 19041, 54557, 
54545, 54241, 19031, 19040, 54544
31482, 51765, 18957, 18961, 51857, 51766, 18958, 18962, 51858, 54254, 19041, 54557, 54545, 54255, 19043, 54558, 
54548, 54244, 19033, 19042, 54547
31483, 51766, 18958, 18962, 51858, 51767, 18959, 18963, 51859, 54255, 19043, 54558, 54548, 54256, 19045, 54559, 
54551, 54247, 19035, 19044, 54550
31484, 51767, 18959, 18963, 51859, 51768, 18960, 18964, 51860, 54256, 19045, 54559, 54551, 54257, 19047, 54560, 
54554, 54250, 19037, 19046, 54553
31485, 51768, 18960, 18964, 51860, 19240, 2379, 2380, 19263, 54257, 19047, 54560, 54554, 0, 0, 0, 
0, 54253, 19039, 19048, 54556
31486, 1187, 9944, 9967, 1188, 18814, 51769, 51861, 18818, 0, 0, 0, 0, 54260, 54562, 54563, 
18902, 18894, 54258, 54561, 18903
31487, 18814, 51769, 51861, 18818, 18815, 51770, 51862, 18819, 54260, 54562, 54563, 18902, 54263, 54565, 54566, 
18904, 18896, 54261, 54564, 18905
31488, 18815, 51770, 51862, 18819, 18816, 51771, 51863, 18820, 54263, 54565, 54566, 18904, 54266, 54568, 54569, 
18906, 18898, 54264, 54567, 18907
31489, 18816, 51771, 51863, 18820, 18817, 51772, 51864, 18821, 54266, 54568, 54569, 18906, 54269, 54571, 54572, 
18908, 18900, 54267, 54570, 18909
31490, 18817, 51772, 51864, 18821, 2369, 19241, 19264, 2370, 54269, 54571, 54572, 18908, 0, 0, 0, 
0, 18901, 54270, 54573, 18910
31491, 9944, 9945, 9968, 9967, 51769, 51773, 51865, 51861, 0, 0, 0, 0, 54273, 54575, 54576, 
54562, 54258, 54271, 54574, 54561
31492, 51769, 51773, 51865, 51861, 51770, 51774, 51866, 51862, 54273, 54575, 54576, 54562, 54276, 54578, 54579, 
54565, 54261, 54274, 54577, 54564
31493, 51770, 51774, 51866, 51862, 51771, 51775, 51867, 51863, 54276, 54578, 54579, 54565, 54279, 54581, 54582, 
54568, 54264, 54277, 54580, 54567
31494, 51771, 51775, 51867, 51863, 51772, 51776, 51868, 51864, 54279, 54581, 54582, 54568, 54282, 54584, 54585, 
54571, 54267, 54280, 54583, 54570
31495, 51772, 51776, 51868, 51864, 19241, 19242, 19265, 19264, 54282, 54584, 54585, 54571, 0, 0, 0, 
0, 54270, 54283, 54586, 54573
31496, 9945, 9946, 9969, 9968, 51773, 51777, 51869, 51865, 0, 0, 0, 0, 54286, 54588, 54589, 
54575, 54271, 54284, 54587, 54574
31497, 51773, 51777, 51869, 51865, 51774, 51778, 51870, 51866, 54286, 54588, 54589, 54575, 54289, 54591, 54592, 
54578, 54274, 54287, 54590, 54577
31498, 51774, 51778, 51870, 51866, 51775, 51779, 51871, 51867, 54289, 54591, 54592, 54578, 54292, 54594, 54595, 
54581, 54277, 54290, 54593, 54580
31499, 51775, 51779, 51871, 51867, 51776, 51780, 51872, 51868, 54292, 54594, 54595, 54581, 54295, 54597, 54598, 
54584, 54280, 54293, 54596, 54583
31500, 51776, 51780, 51872, 51868, 19242, 19243, 19266, 19265, 54295, 54597, 54598, 54584, 0, 0, 0, 
0, 54283, 54296, 54599, 54586
31501, 9946, 9947, 9970, 9969, 51777, 51781, 51873, 51869, 0, 0, 0, 0, 54299, 54601, 54602, 
54588, 54284, 54297, 54600, 54587
31502, 51777, 51781, 51873, 51869, 51778, 51782, 51874, 51870, 54299, 54601, 54602, 54588, 54302, 54604, 54605, 
54591, 54287, 54300, 54603, 54590
31503, 51778, 51782, 51874, 51870, 51779, 51783, 51875, 51871, 54302, 54604, 54605, 54591, 54305, 54607, 54608, 
54594, 54290, 54303, 54606, 54593
31504, 51779, 51783, 51875, 51871, 51780, 51784, 51876, 51872, 54305, 54607, 54608, 54594, 54308, 54610, 54611, 
54597, 54293, 54306, 54609, 54596
31505, 51780, 51784, 51876, 51872, 19243, 19244, 19267, 19266, 54308, 54610, 54611, 54597, 0, 0, 0, 
0, 54296, 54309, 54612, 54599
31506, 9947, 9948, 9971, 9970, 51781, 51785, 51877, 51873, 0, 0, 0, 0, 54312, 54614, 54615, 
54601, 54297, 54310, 54613, 54600
31507, 51781, 51785, 51877, 51873, 51782, 51786, 51878, 51874, 54312, 54614, 54615, 54601, 54315, 54617, 54618, 
54604, 54300, 54313, 54616, 54603
31508, 51782, 51786, 51878, 51874, 51783, 51787, 51879, 51875, 54315, 54617, 54618, 54604, 54318, 54620, 54621, 
54607, 54303, 54316, 54619, 54606
31509, 51783, 51787, 51879, 51875, 51784, 51788, 51880, 51876, 54318, 54620, 54621, 54607, 54321, 54623, 54624, 
54610, 54306, 54319, 54622, 54609
31510, 51784, 51788, 51880, 51876, 19244, 19245, 19268, 19267, 54321, 54623, 54624, 54610, 0, 0, 0, 
0, 54309, 54322, 54625, 54612
31511, 9948, 9949, 9972, 9971, 51785, 51789, 51881, 51877, 0, 0, 0, 0, 54325, 54627, 54628, 
54614, 54310, 54323, 54626, 54613
31512, 51785, 51789, 51881, 51877, 51786, 51790, 51882, 51878, 54325, 54627, 54628, 54614, 54328, 54630, 54631, 
54617, 54313, 54326, 54629, 54616
31513, 51786, 51790, 51882, 51878, 51787, 51791, 51883, 51879, 54328, 54630, 54631, 54617, 54331, 54633, 54634, 
54620, 54316, 54329, 54632, 54619
31514, 51787, 51791, 51883, 51879, 51788, 51792, 51884, 51880, 54331, 54633, 54634, 54620, 54334, 54636, 54637, 
54623, 54319, 54332, 54635, 54622
31515, 51788, 51792, 51884, 51880, 19245, 19246, 19269, 19268, 54334, 54636, 54637, 54623, 0, 0, 0, 
0, 54322, 54335, 54638, 54625
31516, 9949, 9950, 9973, 9972, 51789, 51793, 51885, 51881, 0, 0, 0, 0, 54338, 54640, 54641, 
54627, 54323, 54336, 54639, 54626
31517, 51789, 51793, 51885, 51881, 51790, 51794, 51886, 51882, 54338, 54640, 54641, 54627, 54341, 54643, 54644, 
54630, 54326, 54339, 54642, 54629
31518, 51790, 51794, 51886, 51882, 51791, 51795, 51887, 51883, 54341, 54643, 54644, 54630, 54344, 54646, 54647, 
54633, 54329, 54342, 54645, 54632
31519, 51791, 51795, 51887, 51883, 51792, 51796, 51888, 51884, 54344, 54646, 54647, 54633, 54347, 54649, 54650, 
54636, 54332, 54345, 54648, 54635
31520, 51792, 51796, 51888, 51884, 19246, 19247, 19270, 19269, 54347, 54649, 54650, 54636, 0, 0, 0, 
0, 54335, 54348, 54651, 54638
31521, 9950, 9951, 9974, 9973, 51793, 51797, 51889, 51885, 0, 0, 0, 0, 54351, 54653, 54654, 
54640, 54336, 54349, 54652, 54639
31522, 51793, 51797, 51889, 51885, 51794, 51798, 51890, 51886, 54351, 54653, 54654, 54640, 54354, 54656, 54657, 
54643, 54339, 54352, 54655, 54642
31523, 51794, 51798, 51890, 51886, 51795, 51799, 51891, 51887, 54354, 54656, 54657, 54643, 54357, 54659, 54660, 
54646, 54342, 54355, 54658, 54645
31524, 51795, 51799, 51891, 51887, 51796, 51800, 51892, 51888, 54357, 54659, 54660, 54646, 54360, 54662, 54663, 
54649, 54345, 54358, 54661, 54648
31525, 51796, 51800, 51892, 51888, 19247, 19248, 19271, 19270, 54360, 54662, 54663, 54649, 0, 0, 0, 
0, 54348, 54361, 54664, 54651
31526, 9951, 9952, 9975, 9974, 51797, 51801, 51893, 51889, 0, 0, 0, 0, 54364, 54666, 54667, 
54653, 54349, 54362, 54665, 54652
31527, 51797, 51801, 51893, 51889, 51798, 51802, 51894, 51890, 54364, 54666, 54667, 54653, 54367, 54669, 54670, 
54656, 54352, 54365, 54668, 54655
31528, 51798, 51802, 51894, 51890, 51799, 51803, 51895, 51891, 54367, 54669, 54670, 54656, 54370, 54672, 54673, 
54659, 54355, 54368, 54671, 54658
31529, 51799, 51803, 51895, 51891, 51800, 51804, 51896, 51892, 54370, 54672, 54673, 54659, 54373, 54675, 54676, 
54662, 54358, 54371, 54674, 54661
31530, 51800, 51804, 51896, 51892, 19248, 19249, 19272, 19271, 54373, 54675, 54676, 54662, 0, 0, 0, 
0, 54361, 54374, 54677, 54664
31531, 9952, 9953, 9976, 9975, 51801, 51805, 51897, 51893, 0, 0, 0, 0, 54377, 54679, 54680, 
54666, 54362, 54375, 54678, 54665
31532, 51801, 51805, 51897, 51893, 51802, 51806, 51898, 51894, 54377, 54679, 54680, 54666, 54380, 54682, 54683, 
54669, 54365, 54378, 54681, 54668
31533, 51802, 51806, 51898, 51894, 51803, 51807, 51899, 51895, 54380, 54682, 54683, 54669, 54383, 54685, 54686, 
54672, 54368, 54381, 54684, 54671
31534, 51803, 51807, 51899, 51895, 51804, 51808, 51900, 51896, 54383, 54685, 54686, 54672, 54386, 54688, 54689, 
54675, 54371, 54384, 54687, 54674
31535, 51804, 51808, 51900, 51896, 19249, 19250, 19273, 19272, 54386, 54688, 54689, 54675, 0, 0, 0, 
0, 54374, 54387, 54690, 54677
31536, 9953, 9954, 9977, 9976, 51805, 51809, 51901, 51897, 0, 0, 0, 0, 54390, 54692, 54693, 
54679, 54375, 54388, 54691, 54678
31537, 51805, 51809, 51901, 51897, 51806, 51810, 51902, 51898, 54390, 54692, 54693, 54679, 54393, 54695, 54696, 
54682, 54378, 54391, 54694, 54681
31538, 51806, 51810, 51902, 51898, 51807, 51811, 51903, 51899, 54393, 54695, 54696, 54682, 54396, 54698, 54699, 
54685, 54381, 54394, 54697, 54684
31539, 51807, 51811, 51903, 51899, 51808, 51812, 51904, 51900, 54396, 54698, 54699, 54685, 54399, 54701, 54702, 
54688, 54384, 54397, 54700, 54687
31540, 51808, 51812, 51904, 51900, 19250, 19251, 19274, 19273, 54399, 54701, 54702, 54688, 0, 0, 0, 
0, 54387, 54400, 54703, 54690
31541, 9954, 9955, 9978, 9977, 51809, 51813, 51905, 51901, 0, 0, 0, 0, 54403, 54705, 54706, 
54692, 54388, 54401, 54704, 54691
31542, 51809, 51813, 51905, 51901, 51810, 51814, 51906, 51902, 54403, 54705, 54706, 54692, 54406, 54708, 54709, 
54695, 54391, 54404, 54707, 54694
31543, 51810, 51814, 51906, 51902, 51811, 51815, 51907, 51903, 54406, 54708, 54709, 54695, 54409, 54711, 54712, 
54698, 54394, 54407, 54710, 54697
31544, 51811, 51815, 51907, 51903, 51812, 51816, 51908, 51904, 54409, 54711, 54712, 54698, 54412, 54714, 54715, 
54701, 54397, 54410, 54713, 54700
31545, 51812, 51816, 51908, 51904, 19251, 19252, 19275, 19274, 54412, 54714, 54715, 54701, 0, 0, 0, 
0, 54400, 54413, 54716, 54703
31546, 9955, 9956, 9979, 9978, 51813, 51817, 51909, 51905, 0, 0, 0, 0, 54416, 54718, 54719, 
54705, 54401, 54414, 54717, 54704
31547, 51813, 51817, 51909, 51905, 51814, 51818, 51910, 51906, 54416, 54718, 54719, 54705, 54419, 54721, 54722, 
54708, 54404, 54417, 54720, 54707
31548, 51814, 51818, 51910, 51906, 51815, 51819, 51911, 51907, 54419, 54721, 54722, 54708, 54422, 54724, 54725, 
54711, 54407, 54420, 54723, 54710
31549, 51815, 51819, 51911, 51907, 51816, 51820, 51912, 51908, 54422, 54724, 54725, 54711, 54425, 54727, 54728, 
54714, 54410, 54423, 54726, 54713
31550, 51816, 51820, 51912, 51908, 19252, 19253, 19276, 19275, 54425, 54727, 54728, 54714, 0, 0, 0, 
0, 54413, 54426, 54729, 54716
31551, 9956, 9957, 9980, 9979, 51817, 51821, 51913, 51909, 0, 0, 0, 0, 54429, 54731, 54732, 
54718, 54414, 54427, 54730, 54717
31552, 51817, 51821, 51913, 51909, 51818, 51822, 51914, 51910, 54429, 54731, 54732, 54718, 54432, 54734, 54735, 
54721, 54417, 54430, 54733, 54720
31553, 51818, 51822, 51914, 51910, 51819, 51823, 51915, 51911, 54432, 54734, 54735, 54721, 54435, 54737, 54738, 
54724, 54420, 54433, 54736, 54723
31554, 51819, 51823, 51915, 51911, 51820, 51824, 51916, 51912, 54435, 54737, 54738, 54724, 54438, 54740, 54741, 
54727, 54423, 54436, 54739, 54726
31555, 51820, 51824, 51916, 51912, 19253, 19254, 19277, 19276, 54438, 54740, 54741, 54727, 0, 0, 0, 
0, 54426, 54439, 54742, 54729
31556, 9957, 9958, 9981, 9980, 51821, 51825, 51917, 51913, 0, 0, 0, 0, 54442, 54744, 54745, 
54731, 54427, 54440, 54743, 54730
31557, 51821, 51825, 51917, 51913, 51822, 51826, 51918, 51914, 54442, 54744, 54745, 54731, 54445, 54747, 54748, 
54734, 54430, 54443, 54746, 54733
31558, 51822, 51826, 51918, 51914, 51823, 51827, 51919, 51915, 54445, 54747, 54748, 54734, 54448, 54750, 54751, 
54737, 54433, 54446, 54749, 54736
31559, 51823, 51827, 51919, 51915, 51824, 51828, 51920, 51916, 54448, 54750, 54751, 54737, 54451, 54753, 54754, 
54740, 54436, 54449, 54752, 54739
31560, 51824, 51828, 51920, 51916, 19254, 19255, 19278, 19277, 54451, 54753, 54754, 54740, 0, 0, 0, 
0, 54439, 54452, 54755, 54742
31561, 9958, 9959, 9982, 9981, 51825, 51829, 51921, 51917, 0, 0, 0, 0, 54455, 54757, 54758, 
54744, 54440, 54453, 54756, 54743
31562, 51825, 51829, 51921, 51917, 51826, 51830, 51922, 51918, 54455, 54757, 54758, 54744, 54458, 54760, 54761, 
54747, 54443, 54456, 54759, 54746
31563, 51826, 51830, 51922, 51918, 51827, 51831, 51923, 51919, 54458, 54760, 54761, 54747, 54461, 54763, 54764, 
54750, 54446, 54459, 54762, 54749
31564, 51827, 51831, 51923, 51919, 51828, 51832, 51924, 51920, 54461, 54763, 54764, 54750, 54464, 54766, 54767, 
54753, 54449, 54462, 54765, 54752
31565, 51828, 51832, 51924, 51920, 19255, 19256, 19279, 19278, 54464, 54766, 54767, 54753, 0, 0, 0, 
0, 54452, 54465, 54768, 54755
31566, 9959, 9960, 9983, 9982, 51829, 51833, 51925, 51921, 0, 0, 0, 0, 54468, 54770, 54771, 
54757, 54453, 54466, 54769, 54756
31567, 51829, 51833, 51925, 51921, 51830, 51834, 51926, 51922, 54468, 54770, 54771, 54757, 54471, 54773, 54774, 
54760, 54456, 54469, 54772, 54759
31568, 51830, 51834, 51926, 51922, 51831, 51835, 51927, 51923, 54471, 54773, 54774, 54760, 54474, 54776, 54777, 
54763, 54459, 54472, 54775, 54762
31569, 51831, 51835, 51927, 51923, 51832, 51836, 51928, 51924, 54474, 54776, 54777, 54763, 54477, 54779, 54780, 
54766, 54462, 54475, 54778, 54765
31570, 51832, 51836, 51928, 51924, 19256, 19257, 19280, 19279, 54477, 54779, 54780, 54766, 0, 0, 0, 
0, 54465, 54478, 54781, 54768
31571, 9960, 9961, 9984, 9983, 51833, 51837, 51929, 51925, 0, 0, 0, 0, 54481, 54783, 54784, 
54770, 54466, 54479, 54782, 54769
31572, 51833, 51837, 51929, 51925, 51834, 51838, 51930, 51926, 54481, 54783, 54784, 54770, 54484, 54786, 54787, 
54773, 54469, 54482, 54785, 54772
31573, 51834, 51838, 51930, 51926, 51835, 51839, 51931, 51927, 54484, 54786, 54787, 54773, 54487, 54789, 54790, 
54776, 54472, 54485, 54788, 54775
31574, 51835, 51839, 51931, 51927, 51836, 51840, 51932, 51928, 54487, 54789, 54790, 54776, 54490, 54792, 54793, 
54779, 54475, 54488, 54791, 54778
31575, 51836, 51840, 51932, 51928, 19257, 19258, 19281, 19280, 54490, 54792, 54793, 54779, 0, 0, 0, 
0, 54478, 54491, 54794, 54781
31576, 9961, 9962, 9985, 9984, 51837, 51841, 51933, 51929, 0, 0, 0, 0, 54494, 54796, 54797, 
54783, 54479, 54492, 54795, 54782
31577, 51837, 51841, 51933, 51929, 51838, 51842, 51934, 51930, 54494, 54796, 54797, 54783, 54497, 54799, 54800, 
54786, 54482, 54495, 54798, 54785
31578, 51838, 51842, 51934, 51930, 51839, 51843, 51935, 51931, 54497, 54799, 54800, 54786, 54500, 54802, 54803, 
54789, 54485, 54498, 54801, 54788
31579, 51839, 51843, 51935, 51931, 51840, 51844, 51936, 51932, 54500, 54802, 54803, 54789, 54503, 54805, 54806, 
54792, 54488, 54501, 54804, 54791
31580, 51840, 51844, 51936, 51932, 19258, 19259, 19282, 19281, 54503, 54805, 54806, 54792, 0, 0, 0, 
0, 54491, 54504, 54807, 54794
31581, 9962, 9963, 9986, 9985, 51841, 51845, 51937, 51933, 0, 0, 0, 0, 54507, 54809, 54810, 
54796, 54492, 54505, 54808, 54795
31582, 51841, 51845, 51937, 51933, 51842, 51846, 51938, 51934, 54507, 54809, 54810, 54796, 54510, 54812, 54813, 
54799, 54495, 54508, 54811, 54798
31583, 51842, 51846, 51938, 51934, 51843, 51847, 51939, 51935, 54510, 54812, 54813, 54799, 54513, 54815, 54816, 
54802, 54498, 54511, 54814, 54801
31584, 51843, 51847, 51939, 51935, 51844, 51848, 51940, 51936, 54513, 54815, 54816, 54802, 54516, 54818, 54819, 
54805, 54501, 54514, 54817, 54804
31585, 51844, 51848, 51940, 51936, 19259, 19260, 19283, 19282, 54516, 54818, 54819, 54805, 0, 0, 0, 
0, 54504, 54517, 54820, 54807
31586, 9963, 9964, 9987, 9986, 51845, 51849, 51941, 51937, 0, 0, 0, 0, 54520, 54822, 54823, 
54809, 54505, 54518, 54821, 54808
31587, 51845, 51849, 51941, 51937, 51846, 51850, 51942, 51938, 54520, 54822, 54823, 54809, 54523, 54825, 54826, 
54812, 54508, 54521, 54824, 54811
31588, 51846, 51850, 51942, 51938, 51847, 51851, 51943, 51939, 54523, 54825, 54826, 54812, 54526, 54828, 54829, 
54815, 54511, 54524, 54827, 54814
31589, 51847, 51851, 51943, 51939, 51848, 51852, 51944, 51940, 54526, 54828, 54829, 54815, 54529, 54831, 54832, 
54818, 54514, 54527, 54830, 54817
31590, 51848, 51852, 51944, 51940, 19260, 19261, 19284, 19283, 54529, 54831, 54832, 54818, 0, 0, 0, 
0, 54517, 54530, 54833, 54820
31591, 9964, 9965, 9988, 9987, 51849, 51853, 51945, 51941, 0, 0, 0, 0, 54533, 54835, 54836, 
54822, 54518, 54531, 54834, 54821
31592, 51849, 51853, 51945, 51941, 51850, 51854, 51946, 51942, 54533, 54835, 54836, 54822, 54536, 54838, 54839, 
54825, 54521, 54534, 54837, 54824
31593, 51850, 51854, 51946, 51942, 51851, 51855, 51947, 51943, 54536, 54838, 54839, 54825, 54539, 54841, 54842, 
54828, 54524, 54537, 54840, 54827
31594, 51851, 51855, 51947, 51943, 51852, 51856, 51948, 51944, 54539, 54841, 54842, 54828, 54542, 54844, 54845, 
54831, 54527, 54540, 54843, 54830
31595, 51852, 51856, 51948, 51944, 19261, 19262, 19285, 19284, 54542, 54844, 54845, 54831, 0, 0, 0, 
0, 54530, 54543, 54846, 54833
31596, 9965, 9966, 9989, 9988, 51853, 51857, 51949, 51945, 0, 0, 0, 0, 54546, 54848, 54849, 
54835, 54531, 54544, 54847, 54834
31597, 51853, 51857, 51949, 51945, 51854, 51858, 51950, 51946, 54546, 54848, 54849, 54835, 54549, 54851, 54852, 
54838, 54534, 54547, 54850, 54837
31598, 51854, 51858, 51950, 51946, 51855, 51859, 51951, 51947, 54549, 54851, 54852, 54838, 54552, 54854, 54855, 
54841, 54537, 54550, 54853, 54840
31599, 51855, 51859, 51951, 51947, 51856, 51860, 51952, 51948, 54552, 54854, 54855, 54841, 54555, 54857, 54858, 
54844, 54540, 54553, 54856, 54843
31600, 51856, 51860, 51952, 51948, 19262, 19263, 19286, 19285, 54555, 54857, 54858, 54844, 0, 0, 0, 
0, 54543, 54556, 54859, 54846
31601, 9966, 1198, 1199, 9989, 51857, 18961, 18965, 51949, 0, 0, 0, 0, 54557, 19050, 54860, 
54848, 54544, 19040, 19049, 54847
31602, 51857, 18961, 18965, 51949, 51858, 18962, 18966, 51950, 54557, 19050, 54860, 54848, 54558, 19052, 54861, 
54851, 54547, 19042, 19051, 54850
31603, 51858, 18962, 18966, 51950, 51859, 18963, 18967, 51951, 54558, 19052, 54861, 54851, 54559, 19054, 54862, 
54854, 54550, 19044, 19053, 54853
31604, 51859, 18963, 18967, 51951, 51860, 18964, 18968, 51952, 54559, 19054, 54862, 54854, 54560, 19056, 54863, 
54857, 54553, 19046, 19055, 54856
31605, 51860, 18964, 18968, 51952, 19263, 2380, 2381, 19286, 54560, 19056, 54863, 54857, 0, 0, 0, 
0, 54556, 19048, 19057, 54859
31606, 1188, 9967, 9990, 1189, 18818, 51861, 51953, 18822, 0, 0, 0, 0, 54563, 54865, 54866, 
18911, 18903, 54561, 54864, 18912
31607, 18818, 51861, 51953, 18822, 18819, 51862, 51954, 18823, 54563, 54865, 54866, 18911, 54566, 54868, 54869, 
18913, 18905, 54564, 54867, 18914
31608, 18819, 51862, 51954, 18823, 18820, 51863, 51955, 18824, 54566, 54868, 54869, 18913, 54569, 54871, 54872, 
18915, 18907, 54567, 54870, 18916
31609, 18820, 51863, 51955, 18824, 18821, 51864, 51956, 18825, 54569, 54871, 54872, 18915, 54572, 54874, 54875, 
18917, 18909, 54570, 54873, 18918
31610, 18821, 51864, 51956, 18825, 2370, 19264, 19287, 2371, 54572, 54874, 54875, 18917, 0, 0, 0, 
0, 18910, 54573, 54876, 18919
31611, 9967, 9968, 9991, 9990, 51861, 51865, 51957, 51953, 0, 0, 0, 0, 54576, 54878, 54879, 
54865, 54561, 54574, 54877, 54864
31612, 51861, 51865, 51957, 51953, 51862, 51866, 51958, 51954, 54576, 54878, 54879, 54865, 54579, 54881, 54882, 
54868, 54564, 54577, 54880, 54867
31613, 51862, 51866, 51958, 51954, 51863, 51867, 51959, 51955, 54579, 54881, 54882, 54868, 54582, 54884, 54885, 
54871, 54567, 54580, 54883, 54870
31614, 51863, 51867, 51959, 51955, 51864, 51868, 51960, 51956, 54582, 54884, 54885, 54871, 54585, 54887, 54888, 
54874, 54570, 54583, 54886, 54873
31615, 51864, 51868, 51960, 51956, 19264, 19265, 19288, 19287, 54585, 54887, 54888, 54874, 0, 0, 0, 
0, 54573, 54586, 54889, 54876
31616, 9968, 9969, 9992, 9991, 51865, 51869, 51961, 51957, 0, 0, 0, 0, 54589, 54891, 54892, 
54878, 54574, 54587, 54890, 54877
