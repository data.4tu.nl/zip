25052, 7656, 7679, 7680, 7657, 13939, 13962, 13963, 13940, 0, 0, 0, 0, 14897, 14898, 14899, 
14851, 36293, 36316, 36317, 36294
25053, 7657, 7680, 973, 972, 13940, 13963, 1843, 1842, 0, 0, 0, 0, 14899, 14900, 1866, 
14853, 36294, 36317, 13566, 13565
25054, 813, 814, 7681, 7658, 1796, 1797, 13964, 13941, 0, 0, 0, 0, 1820, 14901, 14902, 
14854, 13543, 13544, 36318, 36295
25055, 7658, 7681, 7682, 7659, 13941, 13964, 13965, 13942, 0, 0, 0, 0, 14902, 14903, 14904, 
14856, 36295, 36318, 36319, 36296
25056, 7659, 7682, 7683, 7660, 13942, 13965, 13966, 13943, 0, 0, 0, 0, 14904, 14905, 14906, 
14858, 36296, 36319, 36320, 36297
25057, 7660, 7683, 7684, 7661, 13943, 13966, 13967, 13944, 0, 0, 0, 0, 14906, 14907, 14908, 
14860, 36297, 36320, 36321, 36298
25058, 7661, 7684, 7685, 7662, 13944, 13967, 13968, 13945, 0, 0, 0, 0, 14908, 14909, 14910, 
14862, 36298, 36321, 36322, 36299
25059, 7662, 7685, 7686, 7663, 13945, 13968, 13969, 13946, 0, 0, 0, 0, 14910, 14911, 14912, 
14864, 36299, 36322, 36323, 36300
25060, 7663, 7686, 7687, 7664, 13946, 13969, 13970, 13947, 0, 0, 0, 0, 14912, 14913, 14914, 
14866, 36300, 36323, 36324, 36301
25061, 7664, 7687, 7688, 7665, 13947, 13970, 13971, 13948, 0, 0, 0, 0, 14914, 14915, 14916, 
14868, 36301, 36324, 36325, 36302
25062, 7665, 7688, 7689, 7666, 13948, 13971, 13972, 13949, 0, 0, 0, 0, 14916, 14917, 14918, 
14870, 36302, 36325, 36326, 36303
25063, 7666, 7689, 7690, 7667, 13949, 13972, 13973, 13950, 0, 0, 0, 0, 14918, 14919, 14920, 
14872, 36303, 36326, 36327, 36304
25064, 7667, 7690, 7691, 7668, 13950, 13973, 13974, 13951, 0, 0, 0, 0, 14920, 14921, 14922, 
14874, 36304, 36327, 36328, 36305
25065, 7668, 7691, 7692, 7669, 13951, 13974, 13975, 13952, 0, 0, 0, 0, 14922, 14923, 14924, 
14876, 36305, 36328, 36329, 36306
25066, 7669, 7692, 7693, 7670, 13952, 13975, 13976, 13953, 0, 0, 0, 0, 14924, 14925, 14926, 
14878, 36306, 36329, 36330, 36307
25067, 7670, 7693, 7694, 7671, 13953, 13976, 13977, 13954, 0, 0, 0, 0, 14926, 14927, 14928, 
14880, 36307, 36330, 36331, 36308
25068, 7671, 7694, 7695, 7672, 13954, 13977, 13978, 13955, 0, 0, 0, 0, 14928, 14929, 14930, 
14882, 36308, 36331, 36332, 36309
25069, 7672, 7695, 7696, 7673, 13955, 13978, 13979, 13956, 0, 0, 0, 0, 14930, 14931, 14932, 
14884, 36309, 36332, 36333, 36310
25070, 7673, 7696, 7697, 7674, 13956, 13979, 13980, 13957, 0, 0, 0, 0, 14932, 14933, 14934, 
14886, 36310, 36333, 36334, 36311
25071, 7674, 7697, 7698, 7675, 13957, 13980, 13981, 13958, 0, 0, 0, 0, 14934, 14935, 14936, 
14888, 36311, 36334, 36335, 36312
25072, 7675, 7698, 7699, 7676, 13958, 13981, 13982, 13959, 0, 0, 0, 0, 14936, 14937, 14938, 
14890, 36312, 36335, 36336, 36313
25073, 7676, 7699, 7700, 7677, 13959, 13982, 13983, 13960, 0, 0, 0, 0, 14938, 14939, 14940, 
14892, 36313, 36336, 36337, 36314
25074, 7677, 7700, 7701, 7678, 13960, 13983, 13984, 13961, 0, 0, 0, 0, 14940, 14941, 14942, 
14894, 36314, 36337, 36338, 36315
25075, 7678, 7701, 7702, 7679, 13961, 13984, 13985, 13962, 0, 0, 0, 0, 14942, 14943, 14944, 
14896, 36315, 36338, 36339, 36316
25076, 7679, 7702, 7703, 7680, 13962, 13985, 13986, 13963, 0, 0, 0, 0, 14944, 14945, 14946, 
14898, 36316, 36339, 36340, 36317
25077, 7680, 7703, 974, 973, 13963, 13986, 1844, 1843, 0, 0, 0, 0, 14946, 14947, 1867, 
14900, 36317, 36340, 13567, 13566
25078, 814, 815, 7704, 7681, 1797, 1798, 13987, 13964, 0, 0, 0, 0, 1821, 14948, 14949, 
14901, 13544, 13545, 36341, 36318
25079, 7681, 7704, 7705, 7682, 13964, 13987, 13988, 13965, 0, 0, 0, 0, 14949, 14950, 14951, 
14903, 36318, 36341, 36342, 36319
25080, 7682, 7705, 7706, 7683, 13965, 13988, 13989, 13966, 0, 0, 0, 0, 14951, 14952, 14953, 
14905, 36319, 36342, 36343, 36320
25081, 7683, 7706, 7707, 7684, 13966, 13989, 13990, 13967, 0, 0, 0, 0, 14953, 14954, 14955, 
14907, 36320, 36343, 36344, 36321
25082, 7684, 7707, 7708, 7685, 13967, 13990, 13991, 13968, 0, 0, 0, 0, 14955, 14956, 14957, 
14909, 36321, 36344, 36345, 36322
25083, 7685, 7708, 7709, 7686, 13968, 13991, 13992, 13969, 0, 0, 0, 0, 14957, 14958, 14959, 
14911, 36322, 36345, 36346, 36323
25084, 7686, 7709, 7710, 7687, 13969, 13992, 13993, 13970, 0, 0, 0, 0, 14959, 14960, 14961, 
14913, 36323, 36346, 36347, 36324
25085, 7687, 7710, 7711, 7688, 13970, 13993, 13994, 13971, 0, 0, 0, 0, 14961, 14962, 14963, 
14915, 36324, 36347, 36348, 36325
25086, 7688, 7711, 7712, 7689, 13971, 13994, 13995, 13972, 0, 0, 0, 0, 14963, 14964, 14965, 
14917, 36325, 36348, 36349, 36326
25087, 7689, 7712, 7713, 7690, 13972, 13995, 13996, 13973, 0, 0, 0, 0, 14965, 14966, 14967, 
14919, 36326, 36349, 36350, 36327
25088, 7690, 7713, 7714, 7691, 13973, 13996, 13997, 13974, 0, 0, 0, 0, 14967, 14968, 14969, 
14921, 36327, 36350, 36351, 36328
25089, 7691, 7714, 7715, 7692, 13974, 13997, 13998, 13975, 0, 0, 0, 0, 14969, 14970, 14971, 
14923, 36328, 36351, 36352, 36329
25090, 7692, 7715, 7716, 7693, 13975, 13998, 13999, 13976, 0, 0, 0, 0, 14971, 14972, 14973, 
14925, 36329, 36352, 36353, 36330
25091, 7693, 7716, 7717, 7694, 13976, 13999, 14000, 13977, 0, 0, 0, 0, 14973, 14974, 14975, 
14927, 36330, 36353, 36354, 36331
25092, 7694, 7717, 7718, 7695, 13977, 14000, 14001, 13978, 0, 0, 0, 0, 14975, 14976, 14977, 
14929, 36331, 36354, 36355, 36332
25093, 7695, 7718, 7719, 7696, 13978, 14001, 14002, 13979, 0, 0, 0, 0, 14977, 14978, 14979, 
14931, 36332, 36355, 36356, 36333
25094, 7696, 7719, 7720, 7697, 13979, 14002, 14003, 13980, 0, 0, 0, 0, 14979, 14980, 14981, 
14933, 36333, 36356, 36357, 36334
25095, 7697, 7720, 7721, 7698, 13980, 14003, 14004, 13981, 0, 0, 0, 0, 14981, 14982, 14983, 
14935, 36334, 36357, 36358, 36335
25096, 7698, 7721, 7722, 7699, 13981, 14004, 14005, 13982, 0, 0, 0, 0, 14983, 14984, 14985, 
14937, 36335, 36358, 36359, 36336
25097, 7699, 7722, 7723, 7700, 13982, 14005, 14006, 13983, 0, 0, 0, 0, 14985, 14986, 14987, 
14939, 36336, 36359, 36360, 36337
25098, 7700, 7723, 7724, 7701, 13983, 14006, 14007, 13984, 0, 0, 0, 0, 14987, 14988, 14989, 
14941, 36337, 36360, 36361, 36338
25099, 7701, 7724, 7725, 7702, 13984, 14007, 14008, 13985, 0, 0, 0, 0, 14989, 14990, 14991, 
14943, 36338, 36361, 36362, 36339
25100, 7702, 7725, 7726, 7703, 13985, 14008, 14009, 13986, 0, 0, 0, 0, 14991, 14992, 14993, 
14945, 36339, 36362, 36363, 36340
25101, 7703, 7726, 975, 974, 13986, 14009, 1845, 1844, 0, 0, 0, 0, 14993, 14994, 1868, 
14947, 36340, 36363, 13568, 13567
25102, 815, 816, 7727, 7704, 1798, 1799, 14010, 13987, 0, 0, 0, 0, 1822, 14995, 14996, 
14948, 13545, 13546, 36364, 36341
25103, 7704, 7727, 7728, 7705, 13987, 14010, 14011, 13988, 0, 0, 0, 0, 14996, 14997, 14998, 
14950, 36341, 36364, 36365, 36342
25104, 7705, 7728, 7729, 7706, 13988, 14011, 14012, 13989, 0, 0, 0, 0, 14998, 14999, 15000, 
14952, 36342, 36365, 36366, 36343
25105, 7706, 7729, 7730, 7707, 13989, 14012, 14013, 13990, 0, 0, 0, 0, 15000, 15001, 15002, 
14954, 36343, 36366, 36367, 36344
25106, 7707, 7730, 7731, 7708, 13990, 14013, 14014, 13991, 0, 0, 0, 0, 15002, 15003, 15004, 
14956, 36344, 36367, 36368, 36345
25107, 7708, 7731, 7732, 7709, 13991, 14014, 14015, 13992, 0, 0, 0, 0, 15004, 15005, 15006, 
14958, 36345, 36368, 36369, 36346
25108, 7709, 7732, 7733, 7710, 13992, 14015, 14016, 13993, 0, 0, 0, 0, 15006, 15007, 15008, 
14960, 36346, 36369, 36370, 36347
25109, 7710, 7733, 7734, 7711, 13993, 14016, 14017, 13994, 0, 0, 0, 0, 15008, 15009, 15010, 
14962, 36347, 36370, 36371, 36348
25110, 7711, 7734, 7735, 7712, 13994, 14017, 14018, 13995, 0, 0, 0, 0, 15010, 15011, 15012, 
14964, 36348, 36371, 36372, 36349
25111, 7712, 7735, 7736, 7713, 13995, 14018, 14019, 13996, 0, 0, 0, 0, 15012, 15013, 15014, 
14966, 36349, 36372, 36373, 36350
25112, 7713, 7736, 7737, 7714, 13996, 14019, 14020, 13997, 0, 0, 0, 0, 15014, 15015, 15016, 
14968, 36350, 36373, 36374, 36351
25113, 7714, 7737, 7738, 7715, 13997, 14020, 14021, 13998, 0, 0, 0, 0, 15016, 15017, 15018, 
14970, 36351, 36374, 36375, 36352
25114, 7715, 7738, 7739, 7716, 13998, 14021, 14022, 13999, 0, 0, 0, 0, 15018, 15019, 15020, 
14972, 36352, 36375, 36376, 36353
25115, 7716, 7739, 7740, 7717, 13999, 14022, 14023, 14000, 0, 0, 0, 0, 15020, 15021, 15022, 
14974, 36353, 36376, 36377, 36354
25116, 7717, 7740, 7741, 7718, 14000, 14023, 14024, 14001, 0, 0, 0, 0, 15022, 15023, 15024, 
14976, 36354, 36377, 36378, 36355
25117, 7718, 7741, 7742, 7719, 14001, 14024, 14025, 14002, 0, 0, 0, 0, 15024, 15025, 15026, 
14978, 36355, 36378, 36379, 36356
25118, 7719, 7742, 7743, 7720, 14002, 14025, 14026, 14003, 0, 0, 0, 0, 15026, 15027, 15028, 
14980, 36356, 36379, 36380, 36357
25119, 7720, 7743, 7744, 7721, 14003, 14026, 14027, 14004, 0, 0, 0, 0, 15028, 15029, 15030, 
14982, 36357, 36380, 36381, 36358
25120, 7721, 7744, 7745, 7722, 14004, 14027, 14028, 14005, 0, 0, 0, 0, 15030, 15031, 15032, 
14984, 36358, 36381, 36382, 36359
25121, 7722, 7745, 7746, 7723, 14005, 14028, 14029, 14006, 0, 0, 0, 0, 15032, 15033, 15034, 
14986, 36359, 36382, 36383, 36360
25122, 7723, 7746, 7747, 7724, 14006, 14029, 14030, 14007, 0, 0, 0, 0, 15034, 15035, 15036, 
14988, 36360, 36383, 36384, 36361
25123, 7724, 7747, 7748, 7725, 14007, 14030, 14031, 14008, 0, 0, 0, 0, 15036, 15037, 15038, 
14990, 36361, 36384, 36385, 36362
25124, 7725, 7748, 7749, 7726, 14008, 14031, 14032, 14009, 0, 0, 0, 0, 15038, 15039, 15040, 
14992, 36362, 36385, 36386, 36363
25125, 7726, 7749, 976, 975, 14009, 14032, 1846, 1845, 0, 0, 0, 0, 15040, 15041, 1869, 
14994, 36363, 36386, 13569, 13568
25126, 816, 817, 7750, 7727, 1799, 1800, 14033, 14010, 0, 0, 0, 0, 1823, 15042, 15043, 
14995, 13546, 13547, 36387, 36364
25127, 7727, 7750, 7751, 7728, 14010, 14033, 14034, 14011, 0, 0, 0, 0, 15043, 15044, 15045, 
14997, 36364, 36387, 36388, 36365
25128, 7728, 7751, 7752, 7729, 14011, 14034, 14035, 14012, 0, 0, 0, 0, 15045, 15046, 15047, 
14999, 36365, 36388, 36389, 36366
25129, 7729, 7752, 7753, 7730, 14012, 14035, 14036, 14013, 0, 0, 0, 0, 15047, 15048, 15049, 
15001, 36366, 36389, 36390, 36367
25130, 7730, 7753, 7754, 7731, 14013, 14036, 14037, 14014, 0, 0, 0, 0, 15049, 15050, 15051, 
15003, 36367, 36390, 36391, 36368
25131, 7731, 7754, 7755, 7732, 14014, 14037, 14038, 14015, 0, 0, 0, 0, 15051, 15052, 15053, 
15005, 36368, 36391, 36392, 36369
25132, 7732, 7755, 7756, 7733, 14015, 14038, 14039, 14016, 0, 0, 0, 0, 15053, 15054, 15055, 
15007, 36369, 36392, 36393, 36370
25133, 7733, 7756, 7757, 7734, 14016, 14039, 14040, 14017, 0, 0, 0, 0, 15055, 15056, 15057, 
15009, 36370, 36393, 36394, 36371
25134, 7734, 7757, 7758, 7735, 14017, 14040, 14041, 14018, 0, 0, 0, 0, 15057, 15058, 15059, 
15011, 36371, 36394, 36395, 36372
25135, 7735, 7758, 7759, 7736, 14018, 14041, 14042, 14019, 0, 0, 0, 0, 15059, 15060, 15061, 
15013, 36372, 36395, 36396, 36373
25136, 7736, 7759, 7760, 7737, 14019, 14042, 14043, 14020, 0, 0, 0, 0, 15061, 15062, 15063, 
15015, 36373, 36396, 36397, 36374
25137, 7737, 7760, 7761, 7738, 14020, 14043, 14044, 14021, 0, 0, 0, 0, 15063, 15064, 15065, 
15017, 36374, 36397, 36398, 36375
25138, 7738, 7761, 7762, 7739, 14021, 14044, 14045, 14022, 0, 0, 0, 0, 15065, 15066, 15067, 
15019, 36375, 36398, 36399, 36376
25139, 7739, 7762, 7763, 7740, 14022, 14045, 14046, 14023, 0, 0, 0, 0, 15067, 15068, 15069, 
15021, 36376, 36399, 36400, 36377
25140, 7740, 7763, 7764, 7741, 14023, 14046, 14047, 14024, 0, 0, 0, 0, 15069, 15070, 15071, 
15023, 36377, 36400, 36401, 36378
25141, 7741, 7764, 7765, 7742, 14024, 14047, 14048, 14025, 0, 0, 0, 0, 15071, 15072, 15073, 
15025, 36378, 36401, 36402, 36379
25142, 7742, 7765, 7766, 7743, 14025, 14048, 14049, 14026, 0, 0, 0, 0, 15073, 15074, 15075, 
15027, 36379, 36402, 36403, 36380
25143, 7743, 7766, 7767, 7744, 14026, 14049, 14050, 14027, 0, 0, 0, 0, 15075, 15076, 15077, 
15029, 36380, 36403, 36404, 36381
25144, 7744, 7767, 7768, 7745, 14027, 14050, 14051, 14028, 0, 0, 0, 0, 15077, 15078, 15079, 
15031, 36381, 36404, 36405, 36382
25145, 7745, 7768, 7769, 7746, 14028, 14051, 14052, 14029, 0, 0, 0, 0, 15079, 15080, 15081, 
15033, 36382, 36405, 36406, 36383
25146, 7746, 7769, 7770, 7747, 14029, 14052, 14053, 14030, 0, 0, 0, 0, 15081, 15082, 15083, 
15035, 36383, 36406, 36407, 36384
25147, 7747, 7770, 7771, 7748, 14030, 14053, 14054, 14031, 0, 0, 0, 0, 15083, 15084, 15085, 
15037, 36384, 36407, 36408, 36385
25148, 7748, 7771, 7772, 7749, 14031, 14054, 14055, 14032, 0, 0, 0, 0, 15085, 15086, 15087, 
15039, 36385, 36408, 36409, 36386
25149, 7749, 7772, 977, 976, 14032, 14055, 1847, 1846, 0, 0, 0, 0, 15087, 15088, 1870, 
15041, 36386, 36409, 13570, 13569
25150, 817, 818, 7773, 7750, 1800, 1801, 14056, 14033, 0, 0, 0, 0, 1824, 15089, 15090, 
15042, 13547, 13548, 36410, 36387
25151, 7750, 7773, 7774, 7751, 14033, 14056, 14057, 14034, 0, 0, 0, 0, 15090, 15091, 15092, 
15044, 36387, 36410, 36411, 36388
25152, 7751, 7774, 7775, 7752, 14034, 14057, 14058, 14035, 0, 0, 0, 0, 15092, 15093, 15094, 
15046, 36388, 36411, 36412, 36389
25153, 7752, 7775, 7776, 7753, 14035, 14058, 14059, 14036, 0, 0, 0, 0, 15094, 15095, 15096, 
15048, 36389, 36412, 36413, 36390
25154, 7753, 7776, 7777, 7754, 14036, 14059, 14060, 14037, 0, 0, 0, 0, 15096, 15097, 15098, 
15050, 36390, 36413, 36414, 36391
25155, 7754, 7777, 7778, 7755, 14037, 14060, 14061, 14038, 0, 0, 0, 0, 15098, 15099, 15100, 
15052, 36391, 36414, 36415, 36392
25156, 7755, 7778, 7779, 7756, 14038, 14061, 14062, 14039, 0, 0, 0, 0, 15100, 15101, 15102, 
15054, 36392, 36415, 36416, 36393
25157, 7756, 7779, 7780, 7757, 14039, 14062, 14063, 14040, 0, 0, 0, 0, 15102, 15103, 15104, 
15056, 36393, 36416, 36417, 36394
25158, 7757, 7780, 7781, 7758, 14040, 14063, 14064, 14041, 0, 0, 0, 0, 15104, 15105, 15106, 
15058, 36394, 36417, 36418, 36395
25159, 7758, 7781, 7782, 7759, 14041, 14064, 14065, 14042, 0, 0, 0, 0, 15106, 15107, 15108, 
15060, 36395, 36418, 36419, 36396
25160, 7759, 7782, 7783, 7760, 14042, 14065, 14066, 14043, 0, 0, 0, 0, 15108, 15109, 15110, 
15062, 36396, 36419, 36420, 36397
25161, 7760, 7783, 7784, 7761, 14043, 14066, 14067, 14044, 0, 0, 0, 0, 15110, 15111, 15112, 
15064, 36397, 36420, 36421, 36398
25162, 7761, 7784, 7785, 7762, 14044, 14067, 14068, 14045, 0, 0, 0, 0, 15112, 15113, 15114, 
15066, 36398, 36421, 36422, 36399
25163, 7762, 7785, 7786, 7763, 14045, 14068, 14069, 14046, 0, 0, 0, 0, 15114, 15115, 15116, 
15068, 36399, 36422, 36423, 36400
25164, 7763, 7786, 7787, 7764, 14046, 14069, 14070, 14047, 0, 0, 0, 0, 15116, 15117, 15118, 
15070, 36400, 36423, 36424, 36401
25165, 7764, 7787, 7788, 7765, 14047, 14070, 14071, 14048, 0, 0, 0, 0, 15118, 15119, 15120, 
15072, 36401, 36424, 36425, 36402
25166, 7765, 7788, 7789, 7766, 14048, 14071, 14072, 14049, 0, 0, 0, 0, 15120, 15121, 15122, 
15074, 36402, 36425, 36426, 36403
25167, 7766, 7789, 7790, 7767, 14049, 14072, 14073, 14050, 0, 0, 0, 0, 15122, 15123, 15124, 
15076, 36403, 36426, 36427, 36404
25168, 7767, 7790, 7791, 7768, 14050, 14073, 14074, 14051, 0, 0, 0, 0, 15124, 15125, 15126, 
15078, 36404, 36427, 36428, 36405
25169, 7768, 7791, 7792, 7769, 14051, 14074, 14075, 14052, 0, 0, 0, 0, 15126, 15127, 15128, 
15080, 36405, 36428, 36429, 36406
25170, 7769, 7792, 7793, 7770, 14052, 14075, 14076, 14053, 0, 0, 0, 0, 15128, 15129, 15130, 
15082, 36406, 36429, 36430, 36407
25171, 7770, 7793, 7794, 7771, 14053, 14076, 14077, 14054, 0, 0, 0, 0, 15130, 15131, 15132, 
15084, 36407, 36430, 36431, 36408
25172, 7771, 7794, 7795, 7772, 14054, 14077, 14078, 14055, 0, 0, 0, 0, 15132, 15133, 15134, 
15086, 36408, 36431, 36432, 36409
25173, 7772, 7795, 978, 977, 14055, 14078, 1848, 1847, 0, 0, 0, 0, 15134, 15135, 1871, 
15088, 36409, 36432, 13571, 13570
25174, 818, 819, 7796, 7773, 1801, 1802, 14079, 14056, 0, 0, 0, 0, 1825, 15136, 15137, 
15089, 13548, 13549, 36433, 36410
25175, 7773, 7796, 7797, 7774, 14056, 14079, 14080, 14057, 0, 0, 0, 0, 15137, 15138, 15139, 
15091, 36410, 36433, 36434, 36411
25176, 7774, 7797, 7798, 7775, 14057, 14080, 14081, 14058, 0, 0, 0, 0, 15139, 15140, 15141, 
15093, 36411, 36434, 36435, 36412
25177, 7775, 7798, 7799, 7776, 14058, 14081, 14082, 14059, 0, 0, 0, 0, 15141, 15142, 15143, 
15095, 36412, 36435, 36436, 36413
25178, 7776, 7799, 7800, 7777, 14059, 14082, 14083, 14060, 0, 0, 0, 0, 15143, 15144, 15145, 
15097, 36413, 36436, 36437, 36414
25179, 7777, 7800, 7801, 7778, 14060, 14083, 14084, 14061, 0, 0, 0, 0, 15145, 15146, 15147, 
15099, 36414, 36437, 36438, 36415
25180, 7778, 7801, 7802, 7779, 14061, 14084, 14085, 14062, 0, 0, 0, 0, 15147, 15148, 15149, 
15101, 36415, 36438, 36439, 36416
25181, 7779, 7802, 7803, 7780, 14062, 14085, 14086, 14063, 0, 0, 0, 0, 15149, 15150, 15151, 
15103, 36416, 36439, 36440, 36417
25182, 7780, 7803, 7804, 7781, 14063, 14086, 14087, 14064, 0, 0, 0, 0, 15151, 15152, 15153, 
15105, 36417, 36440, 36441, 36418
25183, 7781, 7804, 7805, 7782, 14064, 14087, 14088, 14065, 0, 0, 0, 0, 15153, 15154, 15155, 
15107, 36418, 36441, 36442, 36419
25184, 7782, 7805, 7806, 7783, 14065, 14088, 14089, 14066, 0, 0, 0, 0, 15155, 15156, 15157, 
15109, 36419, 36442, 36443, 36420
25185, 7783, 7806, 7807, 7784, 14066, 14089, 14090, 14067, 0, 0, 0, 0, 15157, 15158, 15159, 
15111, 36420, 36443, 36444, 36421
25186, 7784, 7807, 7808, 7785, 14067, 14090, 14091, 14068, 0, 0, 0, 0, 15159, 15160, 15161, 
15113, 36421, 36444, 36445, 36422
25187, 7785, 7808, 7809, 7786, 14068, 14091, 14092, 14069, 0, 0, 0, 0, 15161, 15162, 15163, 
15115, 36422, 36445, 36446, 36423
25188, 7786, 7809, 7810, 7787, 14069, 14092, 14093, 14070, 0, 0, 0, 0, 15163, 15164, 15165, 
15117, 36423, 36446, 36447, 36424
25189, 7787, 7810, 7811, 7788, 14070, 14093, 14094, 14071, 0, 0, 0, 0, 15165, 15166, 15167, 
15119, 36424, 36447, 36448, 36425
25190, 7788, 7811, 7812, 7789, 14071, 14094, 14095, 14072, 0, 0, 0, 0, 15167, 15168, 15169, 
15121, 36425, 36448, 36449, 36426
25191, 7789, 7812, 7813, 7790, 14072, 14095, 14096, 14073, 0, 0, 0, 0, 15169, 15170, 15171, 
15123, 36426, 36449, 36450, 36427
25192, 7790, 7813, 7814, 7791, 14073, 14096, 14097, 14074, 0, 0, 0, 0, 15171, 15172, 15173, 
15125, 36427, 36450, 36451, 36428
25193, 7791, 7814, 7815, 7792, 14074, 14097, 14098, 14075, 0, 0, 0, 0, 15173, 15174, 15175, 
15127, 36428, 36451, 36452, 36429
25194, 7792, 7815, 7816, 7793, 14075, 14098, 14099, 14076, 0, 0, 0, 0, 15175, 15176, 15177, 
15129, 36429, 36452, 36453, 36430
25195, 7793, 7816, 7817, 7794, 14076, 14099, 14100, 14077, 0, 0, 0, 0, 15177, 15178, 15179, 
15131, 36430, 36453, 36454, 36431
25196, 7794, 7817, 7818, 7795, 14077, 14100, 14101, 14078, 0, 0, 0, 0, 15179, 15180, 15181, 
15133, 36431, 36454, 36455, 36432
25197, 7795, 7818, 979, 978, 14078, 14101, 1849, 1848, 0, 0, 0, 0, 15181, 15182, 1872, 
15135, 36432, 36455, 13572, 13571
25198, 819, 36, 934, 7796, 1802, 71, 1733, 14079, 0, 0, 0, 0, 1826, 1756, 15183, 
15136, 13549, 1731, 13504, 36433
25199, 7796, 934, 935, 7797, 14079, 1733, 1734, 14080, 0, 0, 0, 0, 15183, 1757, 15184, 
15138, 36433, 13504, 13505, 36434
25200, 7797, 935, 936, 7798, 14080, 1734, 1735, 14081, 0, 0, 0, 0, 15184, 1758, 15185, 
15140, 36434, 13505, 13506, 36435
25201, 7798, 936, 937, 7799, 14081, 1735, 1736, 14082, 0, 0, 0, 0, 15185, 1759, 15186, 
15142, 36435, 13506, 13507, 36436
25202, 7799, 937, 938, 7800, 14082, 1736, 1737, 14083, 0, 0, 0, 0, 15186, 1760, 15187, 
15144, 36436, 13507, 13508, 36437
25203, 7800, 938, 939, 7801, 14083, 1737, 1738, 14084, 0, 0, 0, 0, 15187, 1761, 15188, 
15146, 36437, 13508, 13509, 36438
25204, 7801, 939, 940, 7802, 14084, 1738, 1739, 14085, 0, 0, 0, 0, 15188, 1762, 15189, 
15148, 36438, 13509, 13510, 36439
25205, 7802, 940, 941, 7803, 14085, 1739, 1740, 14086, 0, 0, 0, 0, 15189, 1763, 15190, 
15150, 36439, 13510, 13511, 36440
25206, 7803, 941, 942, 7804, 14086, 1740, 1741, 14087, 0, 0, 0, 0, 15190, 1764, 15191, 
15152, 36440, 13511, 13512, 36441
25207, 7804, 942, 943, 7805, 14087, 1741, 1742, 14088, 0, 0, 0, 0, 15191, 1765, 15192, 
15154, 36441, 13512, 13513, 36442
25208, 7805, 943, 944, 7806, 14088, 1742, 1743, 14089, 0, 0, 0, 0, 15192, 1766, 15193, 
15156, 36442, 13513, 13514, 36443
25209, 7806, 944, 945, 7807, 14089, 1743, 1744, 14090, 0, 0, 0, 0, 15193, 1767, 15194, 
15158, 36443, 13514, 13515, 36444
25210, 7807, 945, 946, 7808, 14090, 1744, 1745, 14091, 0, 0, 0, 0, 15194, 1768, 15195, 
15160, 36444, 13515, 13516, 36445
25211, 7808, 946, 947, 7809, 14091, 1745, 1746, 14092, 0, 0, 0, 0, 15195, 1769, 15196, 
15162, 36445, 13516, 13517, 36446
25212, 7809, 947, 948, 7810, 14092, 1746, 1747, 14093, 0, 0, 0, 0, 15196, 1770, 15197, 
15164, 36446, 13517, 13518, 36447
25213, 7810, 948, 949, 7811, 14093, 1747, 1748, 14094, 0, 0, 0, 0, 15197, 1771, 15198, 
15166, 36447, 13518, 13519, 36448
25214, 7811, 949, 950, 7812, 14094, 1748, 1749, 14095, 0, 0, 0, 0, 15198, 1772, 15199, 
15168, 36448, 13519, 13520, 36449
25215, 7812, 950, 951, 7813, 14095, 1749, 1750, 14096, 0, 0, 0, 0, 15199, 1773, 15200, 
15170, 36449, 13520, 13521, 36450
25216, 7813, 951, 952, 7814, 14096, 1750, 1751, 14097, 0, 0, 0, 0, 15200, 1774, 15201, 
15172, 36450, 13521, 13522, 36451
25217, 7814, 952, 953, 7815, 14097, 1751, 1752, 14098, 0, 0, 0, 0, 15201, 1775, 15202, 
15174, 36451, 13522, 13523, 36452
25218, 7815, 953, 954, 7816, 14098, 1752, 1753, 14099, 0, 0, 0, 0, 15202, 1776, 15203, 
15176, 36452, 13523, 13524, 36453
25219, 7816, 954, 955, 7817, 14099, 1753, 1754, 14100, 0, 0, 0, 0, 15203, 1777, 15204, 
15178, 36453, 13524, 13525, 36454
25220, 7817, 955, 956, 7818, 14100, 1754, 1755, 14101, 0, 0, 0, 0, 15204, 1778, 15205, 
15180, 36454, 13525, 13526, 36455
25221, 7818, 956, 40, 979, 14101, 1755, 72, 1849, 0, 0, 0, 0, 15205, 1779, 1873, 
15182, 36455, 13526, 1732, 13572
*ELEMENT, type=C3D20, ELSET=Volume16
25222, 9, 310, 3832, 265, 59, 1279, 10125, 1326, 0, 0, 0, 0, 1302, 10378, 10379, 
1337, 1277, 10080, 36456, 10103
25223, 310, 311, 3833, 3832, 1279, 1280, 10126, 10125, 0, 0, 0, 0, 1303, 10380, 10381, 
10378, 10080, 10081, 36457, 36456
25224, 311, 312, 3834, 3833, 1280, 1281, 10127, 10126, 0, 0, 0, 0, 1304, 10382, 10383, 
10380, 10081, 10082, 36458, 36457
25225, 312, 313, 3835, 3834, 1281, 1282, 10128, 10127, 0, 0, 0, 0, 1305, 10384, 10385, 
10382, 10082, 10083, 36459, 36458
25226, 313, 314, 3836, 3835, 1282, 1283, 10129, 10128, 0, 0, 0, 0, 1306, 10386, 10387, 
10384, 10083, 10084, 36460, 36459
25227, 314, 315, 3837, 3836, 1283, 1284, 10130, 10129, 0, 0, 0, 0, 1307, 10388, 10389, 
10386, 10084, 10085, 36461, 36460
25228, 315, 316, 3838, 3837, 1284, 1285, 10131, 10130, 0, 0, 0, 0, 1308, 10390, 10391, 
10388, 10085, 10086, 36462, 36461
25229, 316, 317, 3839, 3838, 1285, 1286, 10132, 10131, 0, 0, 0, 0, 1309, 10392, 10393, 
10390, 10086, 10087, 36463, 36462
25230, 317, 318, 3840, 3839, 1286, 1287, 10133, 10132, 0, 0, 0, 0, 1310, 10394, 10395, 
10392, 10087, 10088, 36464, 36463
25231, 318, 319, 3841, 3840, 1287, 1288, 10134, 10133, 0, 0, 0, 0, 1311, 10396, 10397, 
10394, 10088, 10089, 36465, 36464
25232, 319, 320, 3842, 3841, 1288, 1289, 10135, 10134, 0, 0, 0, 0, 1312, 10398, 10399, 
10396, 10089, 10090, 36466, 36465
25233, 320, 321, 3843, 3842, 1289, 1290, 10136, 10135, 0, 0, 0, 0, 1313, 10400, 10401, 
10398, 10090, 10091, 36467, 36466
25234, 321, 322, 3844, 3843, 1290, 1291, 10137, 10136, 0, 0, 0, 0, 1314, 10402, 10403, 
10400, 10091, 10092, 36468, 36467
25235, 322, 323, 3845, 3844, 1291, 1292, 10138, 10137, 0, 0, 0, 0, 1315, 10404, 10405, 
10402, 10092, 10093, 36469, 36468
25236, 323, 324, 3846, 3845, 1292, 1293, 10139, 10138, 0, 0, 0, 0, 1316, 10406, 10407, 
10404, 10093, 10094, 36470, 36469
25237, 324, 325, 3847, 3846, 1293, 1294, 10140, 10139, 0, 0, 0, 0, 1317, 10408, 10409, 
10406, 10094, 10095, 36471, 36470
25238, 325, 326, 3848, 3847, 1294, 1295, 10141, 10140, 0, 0, 0, 0, 1318, 10410, 10411, 
10408, 10095, 10096, 36472, 36471
25239, 326, 327, 3849, 3848, 1295, 1296, 10142, 10141, 0, 0, 0, 0, 1319, 10412, 10413, 
10410, 10096, 10097, 36473, 36472
25240, 327, 328, 3850, 3849, 1296, 1297, 10143, 10142, 0, 0, 0, 0, 1320, 10414, 10415, 
10412, 10097, 10098, 36474, 36473
25241, 328, 329, 3851, 3850, 1297, 1298, 10144, 10143, 0, 0, 0, 0, 1321, 10416, 10417, 
10414, 10098, 10099, 36475, 36474
25242, 329, 330, 3852, 3851, 1298, 1299, 10145, 10144, 0, 0, 0, 0, 1322, 10418, 10419, 
10416, 10099, 10100, 36476, 36475
25243, 330, 331, 3853, 3852, 1299, 1300, 10146, 10145, 0, 0, 0, 0, 1323, 10420, 10421, 
10418, 10100, 10101, 36477, 36476
25244, 331, 332, 3854, 3853, 1300, 1301, 10147, 10146, 0, 0, 0, 0, 1324, 10422, 10423, 
10420, 10101, 10102, 36478, 36477
25245, 332, 13, 402, 3854, 1301, 60, 1349, 10147, 0, 0, 0, 0, 1325, 1360, 10424, 
10422, 10102, 1278, 10114, 36478
25246, 265, 3832, 3855, 266, 1326, 10125, 10148, 1327, 0, 0, 0, 0, 10379, 10425, 10426, 
1338, 10103, 36456, 36479, 10104
25247, 3832, 3833, 3856, 3855, 10125, 10126, 10149, 10148, 0, 0, 0, 0, 10381, 10427, 10428, 
10425, 36456, 36457, 36480, 36479
25248, 3833, 3834, 3857, 3856, 10126, 10127, 10150, 10149, 0, 0, 0, 0, 10383, 10429, 10430, 
10427, 36457, 36458, 36481, 36480
25249, 3834, 3835, 3858, 3857, 10127, 10128, 10151, 10150, 0, 0, 0, 0, 10385, 10431, 10432, 
10429, 36458, 36459, 36482, 36481
25250, 3835, 3836, 3859, 3858, 10128, 10129, 10152, 10151, 0, 0, 0, 0, 10387, 10433, 10434, 
10431, 36459, 36460, 36483, 36482
25251, 3836, 3837, 3860, 3859, 10129, 10130, 10153, 10152, 0, 0, 0, 0, 10389, 10435, 10436, 
10433, 36460, 36461, 36484, 36483
25252, 3837, 3838, 3861, 3860, 10130, 10131, 10154, 10153, 0, 0, 0, 0, 10391, 10437, 10438, 
10435, 36461, 36462, 36485, 36484
25253, 3838, 3839, 3862, 3861, 10131, 10132, 10155, 10154, 0, 0, 0, 0, 10393, 10439, 10440, 
10437, 36462, 36463, 36486, 36485
25254, 3839, 3840, 3863, 3862, 10132, 10133, 10156, 10155, 0, 0, 0, 0, 10395, 10441, 10442, 
10439, 36463, 36464, 36487, 36486
25255, 3840, 3841, 3864, 3863, 10133, 10134, 10157, 10156, 0, 0, 0, 0, 10397, 10443, 10444, 
10441, 36464, 36465, 36488, 36487
25256, 3841, 3842, 3865, 3864, 10134, 10135, 10158, 10157, 0, 0, 0, 0, 10399, 10445, 10446, 
10443, 36465, 36466, 36489, 36488
25257, 3842, 3843, 3866, 3865, 10135, 10136, 10159, 10158, 0, 0, 0, 0, 10401, 10447, 10448, 
10445, 36466, 36467, 36490, 36489
25258, 3843, 3844, 3867, 3866, 10136, 10137, 10160, 10159, 0, 0, 0, 0, 10403, 10449, 10450, 
10447, 36467, 36468, 36491, 36490
25259, 3844, 3845, 3868, 3867, 10137, 10138, 10161, 10160, 0, 0, 0, 0, 10405, 10451, 10452, 
10449, 36468, 36469, 36492, 36491
25260, 3845, 3846, 3869, 3868, 10138, 10139, 10162, 10161, 0, 0, 0, 0, 10407, 10453, 10454, 
10451, 36469, 36470, 36493, 36492
25261, 3846, 3847, 3870, 3869, 10139, 10140, 10163, 10162, 0, 0, 0, 0, 10409, 10455, 10456, 
10453, 36470, 36471, 36494, 36493
25262, 3847, 3848, 3871, 3870, 10140, 10141, 10164, 10163, 0, 0, 0, 0, 10411, 10457, 10458, 
10455, 36471, 36472, 36495, 36494
25263, 3848, 3849, 3872, 3871, 10141, 10142, 10165, 10164, 0, 0, 0, 0, 10413, 10459, 10460, 
10457, 36472, 36473, 36496, 36495
25264, 3849, 3850, 3873, 3872, 10142, 10143, 10166, 10165, 0, 0, 0, 0, 10415, 10461, 10462, 
10459, 36473, 36474, 36497, 36496
25265, 3850, 3851, 3874, 3873, 10143, 10144, 10167, 10166, 0, 0, 0, 0, 10417, 10463, 10464, 
10461, 36474, 36475, 36498, 36497
25266, 3851, 3852, 3875, 3874, 10144, 10145, 10168, 10167, 0, 0, 0, 0, 10419, 10465, 10466, 
10463, 36475, 36476, 36499, 36498
25267, 3852, 3853, 3876, 3875, 10145, 10146, 10169, 10168, 0, 0, 0, 0, 10421, 10467, 10468, 
10465, 36476, 36477, 36500, 36499
25268, 3853, 3854, 3877, 3876, 10146, 10147, 10170, 10169, 0, 0, 0, 0, 10423, 10469, 10470, 
10467, 36477, 36478, 36501, 36500
25269, 3854, 402, 403, 3877, 10147, 1349, 1350, 10170, 0, 0, 0, 0, 10424, 1361, 10471, 
10469, 36478, 10114, 10115, 36501
25270, 266, 3855, 3878, 267, 1327, 10148, 10171, 1328, 0, 0, 0, 0, 10426, 10472, 10473, 
1339, 10104, 36479, 36502, 10105
25271, 3855, 3856, 3879, 3878, 10148, 10149, 10172, 10171, 0, 0, 0, 0, 10428, 10474, 10475, 
10472, 36479, 36480, 36503, 36502
25272, 3856, 3857, 3880, 3879, 10149, 10150, 10173, 10172, 0, 0, 0, 0, 10430, 10476, 10477, 
10474, 36480, 36481, 36504, 36503
25273, 3857, 3858, 3881, 3880, 10150, 10151, 10174, 10173, 0, 0, 0, 0, 10432, 10478, 10479, 
10476, 36481, 36482, 36505, 36504
25274, 3858, 3859, 3882, 3881, 10151, 10152, 10175, 10174, 0, 0, 0, 0, 10434, 10480, 10481, 
10478, 36482, 36483, 36506, 36505
25275, 3859, 3860, 3883, 3882, 10152, 10153, 10176, 10175, 0, 0, 0, 0, 10436, 10482, 10483, 
10480, 36483, 36484, 36507, 36506
25276, 3860, 3861, 3884, 3883, 10153, 10154, 10177, 10176, 0, 0, 0, 0, 10438, 10484, 10485, 
10482, 36484, 36485, 36508, 36507
25277, 3861, 3862, 3885, 3884, 10154, 10155, 10178, 10177, 0, 0, 0, 0, 10440, 10486, 10487, 
10484, 36485, 36486, 36509, 36508
25278, 3862, 3863, 3886, 3885, 10155, 10156, 10179, 10178, 0, 0, 0, 0, 10442, 10488, 10489, 
10486, 36486, 36487, 36510, 36509
25279, 3863, 3864, 3887, 3886, 10156, 10157, 10180, 10179, 0, 0, 0, 0, 10444, 10490, 10491, 
10488, 36487, 36488, 36511, 36510
25280, 3864, 3865, 3888, 3887, 10157, 10158, 10181, 10180, 0, 0, 0, 0, 10446, 10492, 10493, 
10490, 36488, 36489, 36512, 36511
25281, 3865, 3866, 3889, 3888, 10158, 10159, 10182, 10181, 0, 0, 0, 0, 10448, 10494, 10495, 
10492, 36489, 36490, 36513, 36512
25282, 3866, 3867, 3890, 3889, 10159, 10160, 10183, 10182, 0, 0, 0, 0, 10450, 10496, 10497, 
10494, 36490, 36491, 36514, 36513
25283, 3867, 3868, 3891, 3890, 10160, 10161, 10184, 10183, 0, 0, 0, 0, 10452, 10498, 10499, 
10496, 36491, 36492, 36515, 36514
25284, 3868, 3869, 3892, 3891, 10161, 10162, 10185, 10184, 0, 0, 0, 0, 10454, 10500, 10501, 
10498, 36492, 36493, 36516, 36515
25285, 3869, 3870, 3893, 3892, 10162, 10163, 10186, 10185, 0, 0, 0, 0, 10456, 10502, 10503, 
10500, 36493, 36494, 36517, 36516
25286, 3870, 3871, 3894, 3893, 10163, 10164, 10187, 10186, 0, 0, 0, 0, 10458, 10504, 10505, 
10502, 36494, 36495, 36518, 36517
25287, 3871, 3872, 3895, 3894, 10164, 10165, 10188, 10187, 0, 0, 0, 0, 10460, 10506, 10507, 
10504, 36495, 36496, 36519, 36518
25288, 3872, 3873, 3896, 3895, 10165, 10166, 10189, 10188, 0, 0, 0, 0, 10462, 10508, 10509, 
10506, 36496, 36497, 36520, 36519
25289, 3873, 3874, 3897, 3896, 10166, 10167, 10190, 10189, 0, 0, 0, 0, 10464, 10510, 10511, 
10508, 36497, 36498, 36521, 36520
25290, 3874, 3875, 3898, 3897, 10167, 10168, 10191, 10190, 0, 0, 0, 0, 10466, 10512, 10513, 
10510, 36498, 36499, 36522, 36521
25291, 3875, 3876, 3899, 3898, 10168, 10169, 10192, 10191, 0, 0, 0, 0, 10468, 10514, 10515, 
10512, 36499, 36500, 36523, 36522
25292, 3876, 3877, 3900, 3899, 10169, 10170, 10193, 10192, 0, 0, 0, 0, 10470, 10516, 10517, 
10514, 36500, 36501, 36524, 36523
25293, 3877, 403, 404, 3900, 10170, 1350, 1351, 10193, 0, 0, 0, 0, 10471, 1362, 10518, 
10516, 36501, 10115, 10116, 36524
25294, 267, 3878, 3901, 268, 1328, 10171, 10194, 1329, 0, 0, 0, 0, 10473, 10519, 10520, 
1340, 10105, 36502, 36525, 10106
25295, 3878, 3879, 3902, 3901, 10171, 10172, 10195, 10194, 0, 0, 0, 0, 10475, 10521, 10522, 
10519, 36502, 36503, 36526, 36525
25296, 3879, 3880, 3903, 3902, 10172, 10173, 10196, 10195, 0, 0, 0, 0, 10477, 10523, 10524, 
10521, 36503, 36504, 36527, 36526
25297, 3880, 3881, 3904, 3903, 10173, 10174, 10197, 10196, 0, 0, 0, 0, 10479, 10525, 10526, 
10523, 36504, 36505, 36528, 36527
25298, 3881, 3882, 3905, 3904, 10174, 10175, 10198, 10197, 0, 0, 0, 0, 10481, 10527, 10528, 
10525, 36505, 36506, 36529, 36528
25299, 3882, 3883, 3906, 3905, 10175, 10176, 10199, 10198, 0, 0, 0, 0, 10483, 10529, 10530, 
10527, 36506, 36507, 36530, 36529
25300, 3883, 3884, 3907, 3906, 10176, 10177, 10200, 10199, 0, 0, 0, 0, 10485, 10531, 10532, 
10529, 36507, 36508, 36531, 36530
25301, 3884, 3885, 3908, 3907, 10177, 10178, 10201, 10200, 0, 0, 0, 0, 10487, 10533, 10534, 
10531, 36508, 36509, 36532, 36531
25302, 3885, 3886, 3909, 3908, 10178, 10179, 10202, 10201, 0, 0, 0, 0, 10489, 10535, 10536, 
10533, 36509, 36510, 36533, 36532
25303, 3886, 3887, 3910, 3909, 10179, 10180, 10203, 10202, 0, 0, 0, 0, 10491, 10537, 10538, 
10535, 36510, 36511, 36534, 36533
25304, 3887, 3888, 3911, 3910, 10180, 10181, 10204, 10203, 0, 0, 0, 0, 10493, 10539, 10540, 
10537, 36511, 36512, 36535, 36534
25305, 3888, 3889, 3912, 3911, 10181, 10182, 10205, 10204, 0, 0, 0, 0, 10495, 10541, 10542, 
10539, 36512, 36513, 36536, 36535
25306, 3889, 3890, 3913, 3912, 10182, 10183, 10206, 10205, 0, 0, 0, 0, 10497, 10543, 10544, 
10541, 36513, 36514, 36537, 36536
25307, 3890, 3891, 3914, 3913, 10183, 10184, 10207, 10206, 0, 0, 0, 0, 10499, 10545, 10546, 
10543, 36514, 36515, 36538, 36537
25308, 3891, 3892, 3915, 3914, 10184, 10185, 10208, 10207, 0, 0, 0, 0, 10501, 10547, 10548, 
10545, 36515, 36516, 36539, 36538
25309, 3892, 3893, 3916, 3915, 10185, 10186, 10209, 10208, 0, 0, 0, 0, 10503, 10549, 10550, 
10547, 36516, 36517, 36540, 36539
25310, 3893, 3894, 3917, 3916, 10186, 10187, 10210, 10209, 0, 0, 0, 0, 10505, 10551, 10552, 
10549, 36517, 36518, 36541, 36540
25311, 3894, 3895, 3918, 3917, 10187, 10188, 10211, 10210, 0, 0, 0, 0, 10507, 10553, 10554, 
10551, 36518, 36519, 36542, 36541
25312, 3895, 3896, 3919, 3918, 10188, 10189, 10212, 10211, 0, 0, 0, 0, 10509, 10555, 10556, 
10553, 36519, 36520, 36543, 36542
25313, 3896, 3897, 3920, 3919, 10189, 10190, 10213, 10212, 0, 0, 0, 0, 10511, 10557, 10558, 
10555, 36520, 36521, 36544, 36543
25314, 3897, 3898, 3921, 3920, 10190, 10191, 10214, 10213, 0, 0, 0, 0, 10513, 10559, 10560, 
10557, 36521, 36522, 36545, 36544
25315, 3898, 3899, 3922, 3921, 10191, 10192, 10215, 10214, 0, 0, 0, 0, 10515, 10561, 10562, 
10559, 36522, 36523, 36546, 36545
25316, 3899, 3900, 3923, 3922, 10192, 10193, 10216, 10215, 0, 0, 0, 0, 10517, 10563, 10564, 
10561, 36523, 36524, 36547, 36546
25317, 3900, 404, 405, 3923, 10193, 1351, 1352, 10216, 0, 0, 0, 0, 10518, 1363, 10565, 
10563, 36524, 10116, 10117, 36547
25318, 268, 3901, 3924, 269, 1329, 10194, 10217, 1330, 0, 0, 0, 0, 10520, 10566, 10567, 
1341, 10106, 36525, 36548, 10107
25319, 3901, 3902, 3925, 3924, 10194, 10195, 10218, 10217, 0, 0, 0, 0, 10522, 10568, 10569, 
10566, 36525, 36526, 36549, 36548
25320, 3902, 3903, 3926, 3925, 10195, 10196, 10219, 10218, 0, 0, 0, 0, 10524, 10570, 10571, 
10568, 36526, 36527, 36550, 36549
25321, 3903, 3904, 3927, 3926, 10196, 10197, 10220, 10219, 0, 0, 0, 0, 10526, 10572, 10573, 
10570, 36527, 36528, 36551, 36550
25322, 3904, 3905, 3928, 3927, 10197, 10198, 10221, 10220, 0, 0, 0, 0, 10528, 10574, 10575, 
10572, 36528, 36529, 36552, 36551
25323, 3905, 3906, 3929, 3928, 10198, 10199, 10222, 10221, 0, 0, 0, 0, 10530, 10576, 10577, 
10574, 36529, 36530, 36553, 36552
25324, 3906, 3907, 3930, 3929, 10199, 10200, 10223, 10222, 0, 0, 0, 0, 10532, 10578, 10579, 
10576, 36530, 36531, 36554, 36553
25325, 3907, 3908, 3931, 3930, 10200, 10201, 10224, 10223, 0, 0, 0, 0, 10534, 10580, 10581, 
10578, 36531, 36532, 36555, 36554
25326, 3908, 3909, 3932, 3931, 10201, 10202, 10225, 10224, 0, 0, 0, 0, 10536, 10582, 10583, 
10580, 36532, 36533, 36556, 36555
25327, 3909, 3910, 3933, 3932, 10202, 10203, 10226, 10225, 0, 0, 0, 0, 10538, 10584, 10585, 
10582, 36533, 36534, 36557, 36556
25328, 3910, 3911, 3934, 3933, 10203, 10204, 10227, 10226, 0, 0, 0, 0, 10540, 10586, 10587, 
10584, 36534, 36535, 36558, 36557
25329, 3911, 3912, 3935, 3934, 10204, 10205, 10228, 10227, 0, 0, 0, 0, 10542, 10588, 10589, 
10586, 36535, 36536, 36559, 36558
25330, 3912, 3913, 3936, 3935, 10205, 10206, 10229, 10228, 0, 0, 0, 0, 10544, 10590, 10591, 
10588, 36536, 36537, 36560, 36559
25331, 3913, 3914, 3937, 3936, 10206, 10207, 10230, 10229, 0, 0, 0, 0, 10546, 10592, 10593, 
10590, 36537, 36538, 36561, 36560
25332, 3914, 3915, 3938, 3937, 10207, 10208, 10231, 10230, 0, 0, 0, 0, 10548, 10594, 10595, 
10592, 36538, 36539, 36562, 36561
25333, 3915, 3916, 3939, 3938, 10208, 10209, 10232, 10231, 0, 0, 0, 0, 10550, 10596, 10597, 
10594, 36539, 36540, 36563, 36562
25334, 3916, 3917, 3940, 3939, 10209, 10210, 10233, 10232, 0, 0, 0, 0, 10552, 10598, 10599, 
10596, 36540, 36541, 36564, 36563
25335, 3917, 3918, 3941, 3940, 10210, 10211, 10234, 10233, 0, 0, 0, 0, 10554, 10600, 10601, 
10598, 36541, 36542, 36565, 36564
25336, 3918, 3919, 3942, 3941, 10211, 10212, 10235, 10234, 0, 0, 0, 0, 10556, 10602, 10603, 
10600, 36542, 36543, 36566, 36565
25337, 3919, 3920, 3943, 3942, 10212, 10213, 10236, 10235, 0, 0, 0, 0, 10558, 10604, 10605, 
10602, 36543, 36544, 36567, 36566
25338, 3920, 3921, 3944, 3943, 10213, 10214, 10237, 10236, 0, 0, 0, 0, 10560, 10606, 10607, 
10604, 36544, 36545, 36568, 36567
25339, 3921, 3922, 3945, 3944, 10214, 10215, 10238, 10237, 0, 0, 0, 0, 10562, 10608, 10609, 
10606, 36545, 36546, 36569, 36568
25340, 3922, 3923, 3946, 3945, 10215, 10216, 10239, 10238, 0, 0, 0, 0, 10564, 10610, 10611, 
10608, 36546, 36547, 36570, 36569
25341, 3923, 405, 406, 3946, 10216, 1352, 1353, 10239, 0, 0, 0, 0, 10565, 1364, 10612, 
10610, 36547, 10117, 10118, 36570
25342, 269, 3924, 3947, 270, 1330, 10217, 10240, 1331, 0, 0, 0, 0, 10567, 10613, 10614, 
1342, 10107, 36548, 36571, 10108
25343, 3924, 3925, 3948, 3947, 10217, 10218, 10241, 10240, 0, 0, 0, 0, 10569, 10615, 10616, 
10613, 36548, 36549, 36572, 36571
25344, 3925, 3926, 3949, 3948, 10218, 10219, 10242, 10241, 0, 0, 0, 0, 10571, 10617, 10618, 
10615, 36549, 36550, 36573, 36572
25345, 3926, 3927, 3950, 3949, 10219, 10220, 10243, 10242, 0, 0, 0, 0, 10573, 10619, 10620, 
10617, 36550, 36551, 36574, 36573
25346, 3927, 3928, 3951, 3950, 10220, 10221, 10244, 10243, 0, 0, 0, 0, 10575, 10621, 10622, 
10619, 36551, 36552, 36575, 36574
25347, 3928, 3929, 3952, 3951, 10221, 10222, 10245, 10244, 0, 0, 0, 0, 10577, 10623, 10624, 
10621, 36552, 36553, 36576, 36575
25348, 3929, 3930, 3953, 3952, 10222, 10223, 10246, 10245, 0, 0, 0, 0, 10579, 10625, 10626, 
10623, 36553, 36554, 36577, 36576
25349, 3930, 3931, 3954, 3953, 10223, 10224, 10247, 10246, 0, 0, 0, 0, 10581, 10627, 10628, 
10625, 36554, 36555, 36578, 36577
25350, 3931, 3932, 3955, 3954, 10224, 10225, 10248, 10247, 0, 0, 0, 0, 10583, 10629, 10630, 
10627, 36555, 36556, 36579, 36578
25351, 3932, 3933, 3956, 3955, 10225, 10226, 10249, 10248, 0, 0, 0, 0, 10585, 10631, 10632, 
10629, 36556, 36557, 36580, 36579
25352, 3933, 3934, 3957, 3956, 10226, 10227, 10250, 10249, 0, 0, 0, 0, 10587, 10633, 10634, 
10631, 36557, 36558, 36581, 36580
25353, 3934, 3935, 3958, 3957, 10227, 10228, 10251, 10250, 0, 0, 0, 0, 10589, 10635, 10636, 
10633, 36558, 36559, 36582, 36581
25354, 3935, 3936, 3959, 3958, 10228, 10229, 10252, 10251, 0, 0, 0, 0, 10591, 10637, 10638, 
10635, 36559, 36560, 36583, 36582
25355, 3936, 3937, 3960, 3959, 10229, 10230, 10253, 10252, 0, 0, 0, 0, 10593, 10639, 10640, 
10637, 36560, 36561, 36584, 36583
25356, 3937, 3938, 3961, 3960, 10230, 10231, 10254, 10253, 0, 0, 0, 0, 10595, 10641, 10642, 
10639, 36561, 36562, 36585, 36584
25357, 3938, 3939, 3962, 3961, 10231, 10232, 10255, 10254, 0, 0, 0, 0, 10597, 10643, 10644, 
10641, 36562, 36563, 36586, 36585
25358, 3939, 3940, 3963, 3962, 10232, 10233, 10256, 10255, 0, 0, 0, 0, 10599, 10645, 10646, 
10643, 36563, 36564, 36587, 36586
25359, 3940, 3941, 3964, 3963, 10233, 10234, 10257, 10256, 0, 0, 0, 0, 10601, 10647, 10648, 
10645, 36564, 36565, 36588, 36587
25360, 3941, 3942, 3965, 3964, 10234, 10235, 10258, 10257, 0, 0, 0, 0, 10603, 10649, 10650, 
10647, 36565, 36566, 36589, 36588
25361, 3942, 3943, 3966, 3965, 10235, 10236, 10259, 10258, 0, 0, 0, 0, 10605, 10651, 10652, 
10649, 36566, 36567, 36590, 36589
25362, 3943, 3944, 3967, 3966, 10236, 10237, 10260, 10259, 0, 0, 0, 0, 10607, 10653, 10654, 
10651, 36567, 36568, 36591, 36590
25363, 3944, 3945, 3968, 3967, 10237, 10238, 10261, 10260, 0, 0, 0, 0, 10609, 10655, 10656, 
10653, 36568, 36569, 36592, 36591
25364, 3945, 3946, 3969, 3968, 10238, 10239, 10262, 10261, 0, 0, 0, 0, 10611, 10657, 10658, 
10655, 36569, 36570, 36593, 36592
25365, 3946, 406, 407, 3969, 10239, 1353, 1354, 10262, 0, 0, 0, 0, 10612, 1365, 10659, 
10657, 36570, 10118, 10119, 36593
25366, 270, 3947, 3970, 271, 1331, 10240, 10263, 1332, 0, 0, 0, 0, 10614, 10660, 10661, 
1343, 10108, 36571, 36594, 10109
25367, 3947, 3948, 3971, 3970, 10240, 10241, 10264, 10263, 0, 0, 0, 0, 10616, 10662, 10663, 
10660, 36571, 36572, 36595, 36594
25368, 3948, 3949, 3972, 3971, 10241, 10242, 10265, 10264, 0, 0, 0, 0, 10618, 10664, 10665, 
10662, 36572, 36573, 36596, 36595
25369, 3949, 3950, 3973, 3972, 10242, 10243, 10266, 10265, 0, 0, 0, 0, 10620, 10666, 10667, 
10664, 36573, 36574, 36597, 36596
25370, 3950, 3951, 3974, 3973, 10243, 10244, 10267, 10266, 0, 0, 0, 0, 10622, 10668, 10669, 
10666, 36574, 36575, 36598, 36597
25371, 3951, 3952, 3975, 3974, 10244, 10245, 10268, 10267, 0, 0, 0, 0, 10624, 10670, 10671, 
10668, 36575, 36576, 36599, 36598
25372, 3952, 3953, 3976, 3975, 10245, 10246, 10269, 10268, 0, 0, 0, 0, 10626, 10672, 10673, 
10670, 36576, 36577, 36600, 36599
25373, 3953, 3954, 3977, 3976, 10246, 10247, 10270, 10269, 0, 0, 0, 0, 10628, 10674, 10675, 
10672, 36577, 36578, 36601, 36600
25374, 3954, 3955, 3978, 3977, 10247, 10248, 10271, 10270, 0, 0, 0, 0, 10630, 10676, 10677, 
10674, 36578, 36579, 36602, 36601
25375, 3955, 3956, 3979, 3978, 10248, 10249, 10272, 10271, 0, 0, 0, 0, 10632, 10678, 10679, 
10676, 36579, 36580, 36603, 36602
25376, 3956, 3957, 3980, 3979, 10249, 10250, 10273, 10272, 0, 0, 0, 0, 10634, 10680, 10681, 
10678, 36580, 36581, 36604, 36603
25377, 3957, 3958, 3981, 3980, 10250, 10251, 10274, 10273, 0, 0, 0, 0, 10636, 10682, 10683, 
10680, 36581, 36582, 36605, 36604
25378, 3958, 3959, 3982, 3981, 10251, 10252, 10275, 10274, 0, 0, 0, 0, 10638, 10684, 10685, 
10682, 36582, 36583, 36606, 36605
25379, 3959, 3960, 3983, 3982, 10252, 10253, 10276, 10275, 0, 0, 0, 0, 10640, 10686, 10687, 
10684, 36583, 36584, 36607, 36606
25380, 3960, 3961, 3984, 3983, 10253, 10254, 10277, 10276, 0, 0, 0, 0, 10642, 10688, 10689, 
10686, 36584, 36585, 36608, 36607
25381, 3961, 3962, 3985, 3984, 10254, 10255, 10278, 10277, 0, 0, 0, 0, 10644, 10690, 10691, 
10688, 36585, 36586, 36609, 36608
25382, 3962, 3963, 3986, 3985, 10255, 10256, 10279, 10278, 0, 0, 0, 0, 10646, 10692, 10693, 
10690, 36586, 36587, 36610, 36609
25383, 3963, 3964, 3987, 3986, 10256, 10257, 10280, 10279, 0, 0, 0, 0, 10648, 10694, 10695, 
10692, 36587, 36588, 36611, 36610
25384, 3964, 3965, 3988, 3987, 10257, 10258, 10281, 10280, 0, 0, 0, 0, 10650, 10696, 10697, 
10694, 36588, 36589, 36612, 36611
25385, 3965, 3966, 3989, 3988, 10258, 10259, 10282, 10281, 0, 0, 0, 0, 10652, 10698, 10699, 
10696, 36589, 36590, 36613, 36612
25386, 3966, 3967, 3990, 3989, 10259, 10260, 10283, 10282, 0, 0, 0, 0, 10654, 10700, 10701, 
10698, 36590, 36591, 36614, 36613
25387, 3967, 3968, 3991, 3990, 10260, 10261, 10284, 10283, 0, 0, 0, 0, 10656, 10702, 10703, 
10700, 36591, 36592, 36615, 36614
25388, 3968, 3969, 3992, 3991, 10261, 10262, 10285, 10284, 0, 0, 0, 0, 10658, 10704, 10705, 
10702, 36592, 36593, 36616, 36615
25389, 3969, 407, 408, 3992, 10262, 1354, 1355, 10285, 0, 0, 0, 0, 10659, 1366, 10706, 
10704, 36593, 10119, 10120, 36616
25390, 271, 3970, 3993, 272, 1332, 10263, 10286, 1333, 0, 0, 0, 0, 10661, 10707, 10708, 
1344, 10109, 36594, 36617, 10110
25391, 3970, 3971, 3994, 3993, 10263, 10264, 10287, 10286, 0, 0, 0, 0, 10663, 10709, 10710, 
10707, 36594, 36595, 36618, 36617
25392, 3971, 3972, 3995, 3994, 10264, 10265, 10288, 10287, 0, 0, 0, 0, 10665, 10711, 10712, 
10709, 36595, 36596, 36619, 36618
25393, 3972, 3973, 3996, 3995, 10265, 10266, 10289, 10288, 0, 0, 0, 0, 10667, 10713, 10714, 
10711, 36596, 36597, 36620, 36619
25394, 3973, 3974, 3997, 3996, 10266, 10267, 10290, 10289, 0, 0, 0, 0, 10669, 10715, 10716, 
10713, 36597, 36598, 36621, 36620
25395, 3974, 3975, 3998, 3997, 10267, 10268, 10291, 10290, 0, 0, 0, 0, 10671, 10717, 10718, 
10715, 36598, 36599, 36622, 36621
25396, 3975, 3976, 3999, 3998, 10268, 10269, 10292, 10291, 0, 0, 0, 0, 10673, 10719, 10720, 
10717, 36599, 36600, 36623, 36622
25397, 3976, 3977, 4000, 3999, 10269, 10270, 10293, 10292, 0, 0, 0, 0, 10675, 10721, 10722, 
10719, 36600, 36601, 36624, 36623
25398, 3977, 3978, 4001, 4000, 10270, 10271, 10294, 10293, 0, 0, 0, 0, 10677, 10723, 10724, 
10721, 36601, 36602, 36625, 36624
25399, 3978, 3979, 4002, 4001, 10271, 10272, 10295, 10294, 0, 0, 0, 0, 10679, 10725, 10726, 
10723, 36602, 36603, 36626, 36625
25400, 3979, 3980, 4003, 4002, 10272, 10273, 10296, 10295, 0, 0, 0, 0, 10681, 10727, 10728, 
10725, 36603, 36604, 36627, 36626
25401, 3980, 3981, 4004, 4003, 10273, 10274, 10297, 10296, 0, 0, 0, 0, 10683, 10729, 10730, 
10727, 36604, 36605, 36628, 36627
25402, 3981, 3982, 4005, 4004, 10274, 10275, 10298, 10297, 0, 0, 0, 0, 10685, 10731, 10732, 
10729, 36605, 36606, 36629, 36628
25403, 3982, 3983, 4006, 4005, 10275, 10276, 10299, 10298, 0, 0, 0, 0, 10687, 10733, 10734, 
10731, 36606, 36607, 36630, 36629
25404, 3983, 3984, 4007, 4006, 10276, 10277, 10300, 10299, 0, 0, 0, 0, 10689, 10735, 10736, 
10733, 36607, 36608, 36631, 36630
25405, 3984, 3985, 4008, 4007, 10277, 10278, 10301, 10300, 0, 0, 0, 0, 10691, 10737, 10738, 
10735, 36608, 36609, 36632, 36631
25406, 3985, 3986, 4009, 4008, 10278, 10279, 10302, 10301, 0, 0, 0, 0, 10693, 10739, 10740, 
10737, 36609, 36610, 36633, 36632
25407, 3986, 3987, 4010, 4009, 10279, 10280, 10303, 10302, 0, 0, 0, 0, 10695, 10741, 10742, 
10739, 36610, 36611, 36634, 36633
25408, 3987, 3988, 4011, 4010, 10280, 10281, 10304, 10303, 0, 0, 0, 0, 10697, 10743, 10744, 
10741, 36611, 36612, 36635, 36634
25409, 3988, 3989, 4012, 4011, 10281, 10282, 10305, 10304, 0, 0, 0, 0, 10699, 10745, 10746, 
10743, 36612, 36613, 36636, 36635
25410, 3989, 3990, 4013, 4012, 10282, 10283, 10306, 10305, 0, 0, 0, 0, 10701, 10747, 10748, 
10745, 36613, 36614, 36637, 36636
25411, 3990, 3991, 4014, 4013, 10283, 10284, 10307, 10306, 0, 0, 0, 0, 10703, 10749, 10750, 
10747, 36614, 36615, 36638, 36637
25412, 3991, 3992, 4015, 4014, 10284, 10285, 10308, 10307, 0, 0, 0, 0, 10705, 10751, 10752, 
10749, 36615, 36616, 36639, 36638
25413, 3992, 408, 409, 4015, 10285, 1355, 1356, 10308, 0, 0, 0, 0, 10706, 1367, 10753, 
10751, 36616, 10120, 10121, 36639
25414, 272, 3993, 4016, 273, 1333, 10286, 10309, 1334, 0, 0, 0, 0, 10708, 10754, 10755, 
1345, 10110, 36617, 36640, 10111
25415, 3993, 3994, 4017, 4016, 10286, 10287, 10310, 10309, 0, 0, 0, 0, 10710, 10756, 10757, 
10754, 36617, 36618, 36641, 36640
25416, 3994, 3995, 4018, 4017, 10287, 10288, 10311, 10310, 0, 0, 0, 0, 10712, 10758, 10759, 
10756, 36618, 36619, 36642, 36641
25417, 3995, 3996, 4019, 4018, 10288, 10289, 10312, 10311, 0, 0, 0, 0, 10714, 10760, 10761, 
10758, 36619, 36620, 36643, 36642
25418, 3996, 3997, 4020, 4019, 10289, 10290, 10313, 10312, 0, 0, 0, 0, 10716, 10762, 10763, 
10760, 36620, 36621, 36644, 36643
25419, 3997, 3998, 4021, 4020, 10290, 10291, 10314, 10313, 0, 0, 0, 0, 10718, 10764, 10765, 
10762, 36621, 36622, 36645, 36644
25420, 3998, 3999, 4022, 4021, 10291, 10292, 10315, 10314, 0, 0, 0, 0, 10720, 10766, 10767, 
10764, 36622, 36623, 36646, 36645
25421, 3999, 4000, 4023, 4022, 10292, 10293, 10316, 10315, 0, 0, 0, 0, 10722, 10768, 10769, 
10766, 36623, 36624, 36647, 36646
25422, 4000, 4001, 4024, 4023, 10293, 10294, 10317, 10316, 0, 0, 0, 0, 10724, 10770, 10771, 
10768, 36624, 36625, 36648, 36647
25423, 4001, 4002, 4025, 4024, 10294, 10295, 10318, 10317, 0, 0, 0, 0, 10726, 10772, 10773, 
10770, 36625, 36626, 36649, 36648
25424, 4002, 4003, 4026, 4025, 10295, 10296, 10319, 10318, 0, 0, 0, 0, 10728, 10774, 10775, 
10772, 36626, 36627, 36650, 36649
25425, 4003, 4004, 4027, 4026, 10296, 10297, 10320, 10319, 0, 0, 0, 0, 10730, 10776, 10777, 
10774, 36627, 36628, 36651, 36650
25426, 4004, 4005, 4028, 4027, 10297, 10298, 10321, 10320, 0, 0, 0, 0, 10732, 10778, 10779, 
10776, 36628, 36629, 36652, 36651
25427, 4005, 4006, 4029, 4028, 10298, 10299, 10322, 10321, 0, 0, 0, 0, 10734, 10780, 10781, 
10778, 36629, 36630, 36653, 36652
25428, 4006, 4007, 4030, 4029, 10299, 10300, 10323, 10322, 0, 0, 0, 0, 10736, 10782, 10783, 
10780, 36630, 36631, 36654, 36653
25429, 4007, 4008, 4031, 4030, 10300, 10301, 10324, 10323, 0, 0, 0, 0, 10738, 10784, 10785, 
10782, 36631, 36632, 36655, 36654
25430, 4008, 4009, 4032, 4031, 10301, 10302, 10325, 10324, 0, 0, 0, 0, 10740, 10786, 10787, 
10784, 36632, 36633, 36656, 36655
25431, 4009, 4010, 4033, 4032, 10302, 10303, 10326, 10325, 0, 0, 0, 0, 10742, 10788, 10789, 
10786, 36633, 36634, 36657, 36656
25432, 4010, 4011, 4034, 4033, 10303, 10304, 10327, 10326, 0, 0, 0, 0, 10744, 10790, 10791, 
10788, 36634, 36635, 36658, 36657
25433, 4011, 4012, 4035, 4034, 10304, 10305, 10328, 10327, 0, 0, 0, 0, 10746, 10792, 10793, 
10790, 36635, 36636, 36659, 36658
25434, 4012, 4013, 4036, 4035, 10305, 10306, 10329, 10328, 0, 0, 0, 0, 10748, 10794, 10795, 
10792, 36636, 36637, 36660, 36659
25435, 4013, 4014, 4037, 4036, 10306, 10307, 10330, 10329, 0, 0, 0, 0, 10750, 10796, 10797, 
10794, 36637, 36638, 36661, 36660
25436, 4014, 4015, 4038, 4037, 10307, 10308, 10331, 10330, 0, 0, 0, 0, 10752, 10798, 10799, 
10796, 36638, 36639, 36662, 36661
25437, 4015, 409, 410, 4038, 10308, 1356, 1357, 10331, 0, 0, 0, 0, 10753, 1368, 10800, 
10798, 36639, 10121, 10122, 36662
25438, 273, 4016, 4039, 274, 1334, 10309, 10332, 1335, 0, 0, 0, 0, 10755, 10801, 10802, 
1346, 10111, 36640, 36663, 10112
25439, 4016, 4017, 4040, 4039, 10309, 10310, 10333, 10332, 0, 0, 0, 0, 10757, 10803, 10804, 
10801, 36640, 36641, 36664, 36663
25440, 4017, 4018, 4041, 4040, 10310, 10311, 10334, 10333, 0, 0, 0, 0, 10759, 10805, 10806, 
10803, 36641, 36642, 36665, 36664
25441, 4018, 4019, 4042, 4041, 10311, 10312, 10335, 10334, 0, 0, 0, 0, 10761, 10807, 10808, 
10805, 36642, 36643, 36666, 36665
25442, 4019, 4020, 4043, 4042, 10312, 10313, 10336, 10335, 0, 0, 0, 0, 10763, 10809, 10810, 
10807, 36643, 36644, 36667, 36666
25443, 4020, 4021, 4044, 4043, 10313, 10314, 10337, 10336, 0, 0, 0, 0, 10765, 10811, 10812, 
10809, 36644, 36645, 36668, 36667
25444, 4021, 4022, 4045, 4044, 10314, 10315, 10338, 10337, 0, 0, 0, 0, 10767, 10813, 10814, 
10811, 36645, 36646, 36669, 36668
25445, 4022, 4023, 4046, 4045, 10315, 10316, 10339, 10338, 0, 0, 0, 0, 10769, 10815, 10816, 
10813, 36646, 36647, 36670, 36669
25446, 4023, 4024, 4047, 4046, 10316, 10317, 10340, 10339, 0, 0, 0, 0, 10771, 10817, 10818, 
10815, 36647, 36648, 36671, 36670
25447, 4024, 4025, 4048, 4047, 10317, 10318, 10341, 10340, 0, 0, 0, 0, 10773, 10819, 10820, 
10817, 36648, 36649, 36672, 36671
25448, 4025, 4026, 4049, 4048, 10318, 10319, 10342, 10341, 0, 0, 0, 0, 10775, 10821, 10822, 
10819, 36649, 36650, 36673, 36672
25449, 4026, 4027, 4050, 4049, 10319, 10320, 10343, 10342, 0, 0, 0, 0, 10777, 10823, 10824, 
10821, 36650, 36651, 36674, 36673
25450, 4027, 4028, 4051, 4050, 10320, 10321, 10344, 10343, 0, 0, 0, 0, 10779, 10825, 10826, 
10823, 36651, 36652, 36675, 36674
25451, 4028, 4029, 4052, 4051, 10321, 10322, 10345, 10344, 0, 0, 0, 0, 10781, 10827, 10828, 
10825, 36652, 36653, 36676, 36675
25452, 4029, 4030, 4053, 4052, 10322, 10323, 10346, 10345, 0, 0, 0, 0, 10783, 10829, 10830, 
10827, 36653, 36654, 36677, 36676
25453, 4030, 4031, 4054, 4053, 10323, 10324, 10347, 10346, 0, 0, 0, 0, 10785, 10831, 10832, 
10829, 36654, 36655, 36678, 36677
25454, 4031, 4032, 4055, 4054, 10324, 10325, 10348, 10347, 0, 0, 0, 0, 10787, 10833, 10834, 
10831, 36655, 36656, 36679, 36678
25455, 4032, 4033, 4056, 4055, 10325, 10326, 10349, 10348, 0, 0, 0, 0, 10789, 10835, 10836, 
10833, 36656, 36657, 36680, 36679
25456, 4033, 4034, 4057, 4056, 10326, 10327, 10350, 10349, 0, 0, 0, 0, 10791, 10837, 10838, 
10835, 36657, 36658, 36681, 36680
25457, 4034, 4035, 4058, 4057, 10327, 10328, 10351, 10350, 0, 0, 0, 0, 10793, 10839, 10840, 
10837, 36658, 36659, 36682, 36681
25458, 4035, 4036, 4059, 4058, 10328, 10329, 10352, 10351, 0, 0, 0, 0, 10795, 10841, 10842, 
10839, 36659, 36660, 36683, 36682
25459, 4036, 4037, 4060, 4059, 10329, 10330, 10353, 10352, 0, 0, 0, 0, 10797, 10843, 10844, 
10841, 36660, 36661, 36684, 36683
25460, 4037, 4038, 4061, 4060, 10330, 10331, 10354, 10353, 0, 0, 0, 0, 10799, 10845, 10846, 
10843, 36661, 36662, 36685, 36684
25461, 4038, 410, 411, 4061, 10331, 1357, 1358, 10354, 0, 0, 0, 0, 10800, 1369, 10847, 
10845, 36662, 10122, 10123, 36685
25462, 274, 4039, 4062, 275, 1335, 10332, 10355, 1336, 0, 0, 0, 0, 10802, 10848, 10849, 
1347, 10112, 36663, 36686, 10113
25463, 4039, 4040, 4063, 4062, 10332, 10333, 10356, 10355, 0, 0, 0, 0, 10804, 10850, 10851, 
10848, 36663, 36664, 36687, 36686
25464, 4040, 4041, 4064, 4063, 10333, 10334, 10357, 10356, 0, 0, 0, 0, 10806, 10852, 10853, 
10850, 36664, 36665, 36688, 36687
25465, 4041, 4042, 4065, 4064, 10334, 10335, 10358, 10357, 0, 0, 0, 0, 10808, 10854, 10855, 
10852, 36665, 36666, 36689, 36688
25466, 4042, 4043, 4066, 4065, 10335, 10336, 10359, 10358, 0, 0, 0, 0, 10810, 10856, 10857, 
10854, 36666, 36667, 36690, 36689
25467, 4043, 4044, 4067, 4066, 10336, 10337, 10360, 10359, 0, 0, 0, 0, 10812, 10858, 10859, 
10856, 36667, 36668, 36691, 36690
25468, 4044, 4045, 4068, 4067, 10337, 10338, 10361, 10360, 0, 0, 0, 0, 10814, 10860, 10861, 
10858, 36668, 36669, 36692, 36691
25469, 4045, 4046, 4069, 4068, 10338, 10339, 10362, 10361, 0, 0, 0, 0, 10816, 10862, 10863, 
10860, 36669, 36670, 36693, 36692
25470, 4046, 4047, 4070, 4069, 10339, 10340, 10363, 10362, 0, 0, 0, 0, 10818, 10864, 10865, 
10862, 36670, 36671, 36694, 36693
25471, 4047, 4048, 4071, 4070, 10340, 10341, 10364, 10363, 0, 0, 0, 0, 10820, 10866, 10867, 
10864, 36671, 36672, 36695, 36694
25472, 4048, 4049, 4072, 4071, 10341, 10342, 10365, 10364, 0, 0, 0, 0, 10822, 10868, 10869, 
10866, 36672, 36673, 36696, 36695
25473, 4049, 4050, 4073, 4072, 10342, 10343, 10366, 10365, 0, 0, 0, 0, 10824, 10870, 10871, 
10868, 36673, 36674, 36697, 36696
25474, 4050, 4051, 4074, 4073, 10343, 10344, 10367, 10366, 0, 0, 0, 0, 10826, 10872, 10873, 
10870, 36674, 36675, 36698, 36697
25475, 4051, 4052, 4075, 4074, 10344, 10345, 10368, 10367, 0, 0, 0, 0, 10828, 10874, 10875, 
10872, 36675, 36676, 36699, 36698
25476, 4052, 4053, 4076, 4075, 10345, 10346, 10369, 10368, 0, 0, 0, 0, 10830, 10876, 10877, 
10874, 36676, 36677, 36700, 36699
25477, 4053, 4054, 4077, 4076, 10346, 10347, 10370, 10369, 0, 0, 0, 0, 10832, 10878, 10879, 
10876, 36677, 36678, 36701, 36700
25478, 4054, 4055, 4078, 4077, 10347, 10348, 10371, 10370, 0, 0, 0, 0, 10834, 10880, 10881, 
10878, 36678, 36679, 36702, 36701
25479, 4055, 4056, 4079, 4078, 10348, 10349, 10372, 10371, 0, 0, 0, 0, 10836, 10882, 10883, 
10880, 36679, 36680, 36703, 36702
25480, 4056, 4057, 4080, 4079, 10349, 10350, 10373, 10372, 0, 0, 0, 0, 10838, 10884, 10885, 
10882, 36680, 36681, 36704, 36703
25481, 4057, 4058, 4081, 4080, 10350, 10351, 10374, 10373, 0, 0, 0, 0, 10840, 10886, 10887, 
10884, 36681, 36682, 36705, 36704
25482, 4058, 4059, 4082, 4081, 10351, 10352, 10375, 10374, 0, 0, 0, 0, 10842, 10888, 10889, 
10886, 36682, 36683, 36706, 36705
25483, 4059, 4060, 4083, 4082, 10352, 10353, 10376, 10375, 0, 0, 0, 0, 10844, 10890, 10891, 
10888, 36683, 36684, 36707, 36706
25484, 4060, 4061, 4084, 4083, 10353, 10354, 10377, 10376, 0, 0, 0, 0, 10846, 10892, 10893, 
10890, 36684, 36685, 36708, 36707
25485, 4061, 411, 412, 4084, 10354, 1358, 1359, 10377, 0, 0, 0, 0, 10847, 1370, 10894, 
10892, 36685, 10123, 10124, 36708
25486, 275, 4062, 379, 11, 1336, 10355, 1254, 57, 0, 0, 0, 0, 10849, 10895, 0, 
1348, 10113, 36686, 0, 0
25487, 4062, 4063, 380, 379, 10355, 10356, 1255, 1254, 0, 0, 0, 0, 10851, 10896, 0, 
10895, 36686, 36687, 0, 0
25488, 4063, 4064, 381, 380, 10356, 10357, 1256, 1255, 0, 0, 0, 0, 10853, 10897, 0, 
10896, 36687, 36688, 0, 0
25489, 4064, 4065, 382, 381, 10357, 10358, 1257, 1256, 0, 0, 0, 0, 10855, 10898, 0, 
10897, 36688, 36689, 0, 0
25490, 4065, 4066, 383, 382, 10358, 10359, 1258, 1257, 0, 0, 0, 0, 10857, 10899, 0, 
10898, 36689, 36690, 0, 0
25491, 4066, 4067, 384, 383, 10359, 10360, 1259, 1258, 0, 0, 0, 0, 10859, 10900, 0, 
10899, 36690, 36691, 0, 0
25492, 4067, 4068, 385, 384, 10360, 10361, 1260, 1259, 0, 0, 0, 0, 10861, 10901, 0, 
10900, 36691, 36692, 0, 0
25493, 4068, 4069, 386, 385, 10361, 10362, 1261, 1260, 0, 0, 0, 0, 10863, 10902, 0, 
10901, 36692, 36693, 0, 0
25494, 4069, 4070, 387, 386, 10362, 10363, 1262, 1261, 0, 0, 0, 0, 10865, 10903, 0, 
10902, 36693, 36694, 0, 0
25495, 4070, 4071, 388, 387, 10363, 10364, 1263, 1262, 0, 0, 0, 0, 10867, 10904, 0, 
10903, 36694, 36695, 0, 0
25496, 4071, 4072, 389, 388, 10364, 10365, 1264, 1263, 0, 0, 0, 0, 10869, 10905, 0, 
10904, 36695, 36696, 0, 0
25497, 4072, 4073, 390, 389, 10365, 10366, 1265, 1264, 0, 0, 0, 0, 10871, 10906, 0, 
10905, 36696, 36697, 0, 0
25498, 4073, 4074, 391, 390, 10366, 10367, 1266, 1265, 0, 0, 0, 0, 10873, 10907, 0, 
10906, 36697, 36698, 0, 0
25499, 4074, 4075, 392, 391, 10367, 10368, 1267, 1266, 0, 0, 0, 0, 10875, 10908, 0, 
10907, 36698, 36699, 0, 0
25500, 4075, 4076, 393, 392, 10368, 10369, 1268, 1267, 0, 0, 0, 0, 10877, 10909, 0, 
10908, 36699, 36700, 0, 0
25501, 4076, 4077, 394, 393, 10369, 10370, 1269, 1268, 0, 0, 0, 0, 10879, 10910, 0, 
10909, 36700, 36701, 0, 0
25502, 4077, 4078, 395, 394, 10370, 10371, 1270, 1269, 0, 0, 0, 0, 10881, 10911, 0, 
10910, 36701, 36702, 0, 0
25503, 4078, 4079, 396, 395, 10371, 10372, 1271, 1270, 0, 0, 0, 0, 10883, 10912, 0, 
10911, 36702, 36703, 0, 0
25504, 4079, 4080, 397, 396, 10372, 10373, 1272, 1271, 0, 0, 0, 0, 10885, 10913, 0, 
10912, 36703, 36704, 0, 0
25505, 4080, 4081, 398, 397, 10373, 10374, 1273, 1272, 0, 0, 0, 0, 10887, 10914, 0, 
10913, 36704, 36705, 0, 0
25506, 4081, 4082, 399, 398, 10374, 10375, 1274, 1273, 0, 0, 0, 0, 10889, 10915, 0, 
10914, 36705, 36706, 0, 0
25507, 4082, 4083, 400, 399, 10375, 10376, 1275, 1274, 0, 0, 0, 0, 10891, 10916, 0, 
10915, 36706, 36707, 0, 0
25508, 4083, 4084, 401, 400, 10376, 10377, 1276, 1275, 0, 0, 0, 0, 10893, 10917, 0, 
10916, 36707, 36708, 0, 0
25509, 4084, 412, 15, 401, 10377, 1359, 58, 1276, 0, 0, 0, 0, 10894, 1371, 0, 
10917, 36708, 10124, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume17
25510, 35, 911, 7819, 820, 63, 1397, 10963, 1444, 0, 0, 0, 0, 1420, 11216, 11217, 
1455, 1395, 10918, 36709, 10941
25511, 911, 912, 7820, 7819, 1397, 1398, 10964, 10963, 0, 0, 0, 0, 1421, 11218, 11219, 
11216, 10918, 10919, 36710, 36709
25512, 912, 913, 7821, 7820, 1398, 1399, 10965, 10964, 0, 0, 0, 0, 1422, 11220, 11221, 
11218, 10919, 10920, 36711, 36710
25513, 913, 914, 7822, 7821, 1399, 1400, 10966, 10965, 0, 0, 0, 0, 1423, 11222, 11223, 
11220, 10920, 10921, 36712, 36711
25514, 914, 915, 7823, 7822, 1400, 1401, 10967, 10966, 0, 0, 0, 0, 1424, 11224, 11225, 
11222, 10921, 10922, 36713, 36712
25515, 915, 916, 7824, 7823, 1401, 1402, 10968, 10967, 0, 0, 0, 0, 1425, 11226, 11227, 
11224, 10922, 10923, 36714, 36713
25516, 916, 917, 7825, 7824, 1402, 1403, 10969, 10968, 0, 0, 0, 0, 1426, 11228, 11229, 
11226, 10923, 10924, 36715, 36714
25517, 917, 918, 7826, 7825, 1403, 1404, 10970, 10969, 0, 0, 0, 0, 1427, 11230, 11231, 
11228, 10924, 10925, 36716, 36715
25518, 918, 919, 7827, 7826, 1404, 1405, 10971, 10970, 0, 0, 0, 0, 1428, 11232, 11233, 
11230, 10925, 10926, 36717, 36716
25519, 919, 920, 7828, 7827, 1405, 1406, 10972, 10971, 0, 0, 0, 0, 1429, 11234, 11235, 
11232, 10926, 10927, 36718, 36717
25520, 920, 921, 7829, 7828, 1406, 1407, 10973, 10972, 0, 0, 0, 0, 1430, 11236, 11237, 
11234, 10927, 10928, 36719, 36718
25521, 921, 922, 7830, 7829, 1407, 1408, 10974, 10973, 0, 0, 0, 0, 1431, 11238, 11239, 
11236, 10928, 10929, 36720, 36719
25522, 922, 923, 7831, 7830, 1408, 1409, 10975, 10974, 0, 0, 0, 0, 1432, 11240, 11241, 
11238, 10929, 10930, 36721, 36720
25523, 923, 924, 7832, 7831, 1409, 1410, 10976, 10975, 0, 0, 0, 0, 1433, 11242, 11243, 
11240, 10930, 10931, 36722, 36721
25524, 924, 925, 7833, 7832, 1410, 1411, 10977, 10976, 0, 0, 0, 0, 1434, 11244, 11245, 
11242, 10931, 10932, 36723, 36722
25525, 925, 926, 7834, 7833, 1411, 1412, 10978, 10977, 0, 0, 0, 0, 1435, 11246, 11247, 
11244, 10932, 10933, 36724, 36723
25526, 926, 927, 7835, 7834, 1412, 1413, 10979, 10978, 0, 0, 0, 0, 1436, 11248, 11249, 
11246, 10933, 10934, 36725, 36724
25527, 927, 928, 7836, 7835, 1413, 1414, 10980, 10979, 0, 0, 0, 0, 1437, 11250, 11251, 
11248, 10934, 10935, 36726, 36725
25528, 928, 929, 7837, 7836, 1414, 1415, 10981, 10980, 0, 0, 0, 0, 1438, 11252, 11253, 
11250, 10935, 10936, 36727, 36726
25529, 929, 930, 7838, 7837, 1415, 1416, 10982, 10981, 0, 0, 0, 0, 1439, 11254, 11255, 
11252, 10936, 10937, 36728, 36727
25530, 930, 931, 7839, 7838, 1416, 1417, 10983, 10982, 0, 0, 0, 0, 1440, 11256, 11257, 
11254, 10937, 10938, 36729, 36728
25531, 931, 932, 7840, 7839, 1417, 1418, 10984, 10983, 0, 0, 0, 0, 1441, 11258, 11259, 
11256, 10938, 10939, 36730, 36729
25532, 932, 933, 7841, 7840, 1418, 1419, 10985, 10984, 0, 0, 0, 0, 1442, 11260, 11261, 
11258, 10939, 10940, 36731, 36730
25533, 933, 39, 980, 7841, 1419, 64, 1467, 10985, 0, 0, 0, 0, 1443, 1478, 11262, 
11260, 10940, 1396, 10952, 36731
25534, 820, 7819, 7842, 821, 1444, 10963, 10986, 1445, 0, 0, 0, 0, 11217, 11263, 11264, 
1456, 10941, 36709, 36732, 10942
25535, 7819, 7820, 7843, 7842, 10963, 10964, 10987, 10986, 0, 0, 0, 0, 11219, 11265, 11266, 
11263, 36709, 36710, 36733, 36732
25536, 7820, 7821, 7844, 7843, 10964, 10965, 10988, 10987, 0, 0, 0, 0, 11221, 11267, 11268, 
11265, 36710, 36711, 36734, 36733
25537, 7821, 7822, 7845, 7844, 10965, 10966, 10989, 10988, 0, 0, 0, 0, 11223, 11269, 11270, 
11267, 36711, 36712, 36735, 36734
25538, 7822, 7823, 7846, 7845, 10966, 10967, 10990, 10989, 0, 0, 0, 0, 11225, 11271, 11272, 
11269, 36712, 36713, 36736, 36735
25539, 7823, 7824, 7847, 7846, 10967, 10968, 10991, 10990, 0, 0, 0, 0, 11227, 11273, 11274, 
11271, 36713, 36714, 36737, 36736
25540, 7824, 7825, 7848, 7847, 10968, 10969, 10992, 10991, 0, 0, 0, 0, 11229, 11275, 11276, 
11273, 36714, 36715, 36738, 36737
25541, 7825, 7826, 7849, 7848, 10969, 10970, 10993, 10992, 0, 0, 0, 0, 11231, 11277, 11278, 
11275, 36715, 36716, 36739, 36738
25542, 7826, 7827, 7850, 7849, 10970, 10971, 10994, 10993, 0, 0, 0, 0, 11233, 11279, 11280, 
11277, 36716, 36717, 36740, 36739
25543, 7827, 7828, 7851, 7850, 10971, 10972, 10995, 10994, 0, 0, 0, 0, 11235, 11281, 11282, 
11279, 36717, 36718, 36741, 36740
25544, 7828, 7829, 7852, 7851, 10972, 10973, 10996, 10995, 0, 0, 0, 0, 11237, 11283, 11284, 
11281, 36718, 36719, 36742, 36741
25545, 7829, 7830, 7853, 7852, 10973, 10974, 10997, 10996, 0, 0, 0, 0, 11239, 11285, 11286, 
11283, 36719, 36720, 36743, 36742
25546, 7830, 7831, 7854, 7853, 10974, 10975, 10998, 10997, 0, 0, 0, 0, 11241, 11287, 11288, 
11285, 36720, 36721, 36744, 36743
25547, 7831, 7832, 7855, 7854, 10975, 10976, 10999, 10998, 0, 0, 0, 0, 11243, 11289, 11290, 
11287, 36721, 36722, 36745, 36744
25548, 7832, 7833, 7856, 7855, 10976, 10977, 11000, 10999, 0, 0, 0, 0, 11245, 11291, 11292, 
11289, 36722, 36723, 36746, 36745
25549, 7833, 7834, 7857, 7856, 10977, 10978, 11001, 11000, 0, 0, 0, 0, 11247, 11293, 11294, 
11291, 36723, 36724, 36747, 36746
25550, 7834, 7835, 7858, 7857, 10978, 10979, 11002, 11001, 0, 0, 0, 0, 11249, 11295, 11296, 
11293, 36724, 36725, 36748, 36747
25551, 7835, 7836, 7859, 7858, 10979, 10980, 11003, 11002, 0, 0, 0, 0, 11251, 11297, 11298, 
11295, 36725, 36726, 36749, 36748
25552, 7836, 7837, 7860, 7859, 10980, 10981, 11004, 11003, 0, 0, 0, 0, 11253, 11299, 11300, 
11297, 36726, 36727, 36750, 36749
25553, 7837, 7838, 7861, 7860, 10981, 10982, 11005, 11004, 0, 0, 0, 0, 11255, 11301, 11302, 
11299, 36727, 36728, 36751, 36750
25554, 7838, 7839, 7862, 7861, 10982, 10983, 11006, 11005, 0, 0, 0, 0, 11257, 11303, 11304, 
11301, 36728, 36729, 36752, 36751
25555, 7839, 7840, 7863, 7862, 10983, 10984, 11007, 11006, 0, 0, 0, 0, 11259, 11305, 11306, 
11303, 36729, 36730, 36753, 36752
25556, 7840, 7841, 7864, 7863, 10984, 10985, 11008, 11007, 0, 0, 0, 0, 11261, 11307, 11308, 
11305, 36730, 36731, 36754, 36753
25557, 7841, 980, 981, 7864, 10985, 1467, 1468, 11008, 0, 0, 0, 0, 11262, 1479, 11309, 
11307, 36731, 10952, 10953, 36754
25558, 821, 7842, 7865, 822, 1445, 10986, 11009, 1446, 0, 0, 0, 0, 11264, 11310, 11311, 
1457, 10942, 36732, 36755, 10943
25559, 7842, 7843, 7866, 7865, 10986, 10987, 11010, 11009, 0, 0, 0, 0, 11266, 11312, 11313, 
11310, 36732, 36733, 36756, 36755
25560, 7843, 7844, 7867, 7866, 10987, 10988, 11011, 11010, 0, 0, 0, 0, 11268, 11314, 11315, 
11312, 36733, 36734, 36757, 36756
25561, 7844, 7845, 7868, 7867, 10988, 10989, 11012, 11011, 0, 0, 0, 0, 11270, 11316, 11317, 
11314, 36734, 36735, 36758, 36757
25562, 7845, 7846, 7869, 7868, 10989, 10990, 11013, 11012, 0, 0, 0, 0, 11272, 11318, 11319, 
11316, 36735, 36736, 36759, 36758
25563, 7846, 7847, 7870, 7869, 10990, 10991, 11014, 11013, 0, 0, 0, 0, 11274, 11320, 11321, 
11318, 36736, 36737, 36760, 36759
25564, 7847, 7848, 7871, 7870, 10991, 10992, 11015, 11014, 0, 0, 0, 0, 11276, 11322, 11323, 
11320, 36737, 36738, 36761, 36760
25565, 7848, 7849, 7872, 7871, 10992, 10993, 11016, 11015, 0, 0, 0, 0, 11278, 11324, 11325, 
11322, 36738, 36739, 36762, 36761
25566, 7849, 7850, 7873, 7872, 10993, 10994, 11017, 11016, 0, 0, 0, 0, 11280, 11326, 11327, 
11324, 36739, 36740, 36763, 36762
25567, 7850, 7851, 7874, 7873, 10994, 10995, 11018, 11017, 0, 0, 0, 0, 11282, 11328, 11329, 
11326, 36740, 36741, 36764, 36763
25568, 7851, 7852, 7875, 7874, 10995, 10996, 11019, 11018, 0, 0, 0, 0, 11284, 11330, 11331, 
11328, 36741, 36742, 36765, 36764
25569, 7852, 7853, 7876, 7875, 10996, 10997, 11020, 11019, 0, 0, 0, 0, 11286, 11332, 11333, 
11330, 36742, 36743, 36766, 36765
25570, 7853, 7854, 7877, 7876, 10997, 10998, 11021, 11020, 0, 0, 0, 0, 11288, 11334, 11335, 
11332, 36743, 36744, 36767, 36766
25571, 7854, 7855, 7878, 7877, 10998, 10999, 11022, 11021, 0, 0, 0, 0, 11290, 11336, 11337, 
11334, 36744, 36745, 36768, 36767
25572, 7855, 7856, 7879, 7878, 10999, 11000, 11023, 11022, 0, 0, 0, 0, 11292, 11338, 11339, 
11336, 36745, 36746, 36769, 36768
25573, 7856, 7857, 7880, 7879, 11000, 11001, 11024, 11023, 0, 0, 0, 0, 11294, 11340, 11341, 
11338, 36746, 36747, 36770, 36769
25574, 7857, 7858, 7881, 7880, 11001, 11002, 11025, 11024, 0, 0, 0, 0, 11296, 11342, 11343, 
11340, 36747, 36748, 36771, 36770
25575, 7858, 7859, 7882, 7881, 11002, 11003, 11026, 11025, 0, 0, 0, 0, 11298, 11344, 11345, 
11342, 36748, 36749, 36772, 36771
25576, 7859, 7860, 7883, 7882, 11003, 11004, 11027, 11026, 0, 0, 0, 0, 11300, 11346, 11347, 
11344, 36749, 36750, 36773, 36772
25577, 7860, 7861, 7884, 7883, 11004, 11005, 11028, 11027, 0, 0, 0, 0, 11302, 11348, 11349, 
11346, 36750, 36751, 36774, 36773
25578, 7861, 7862, 7885, 7884, 11005, 11006, 11029, 11028, 0, 0, 0, 0, 11304, 11350, 11351, 
11348, 36751, 36752, 36775, 36774
25579, 7862, 7863, 7886, 7885, 11006, 11007, 11030, 11029, 0, 0, 0, 0, 11306, 11352, 11353, 
11350, 36752, 36753, 36776, 36775
25580, 7863, 7864, 7887, 7886, 11007, 11008, 11031, 11030, 0, 0, 0, 0, 11308, 11354, 11355, 
11352, 36753, 36754, 36777, 36776
25581, 7864, 981, 982, 7887, 11008, 1468, 1469, 11031, 0, 0, 0, 0, 11309, 1480, 11356, 
11354, 36754, 10953, 10954, 36777
25582, 822, 7865, 7888, 823, 1446, 11009, 11032, 1447, 0, 0, 0, 0, 11311, 11357, 11358, 
1458, 10943, 36755, 36778, 10944
25583, 7865, 7866, 7889, 7888, 11009, 11010, 11033, 11032, 0, 0, 0, 0, 11313, 11359, 11360, 
11357, 36755, 36756, 36779, 36778
25584, 7866, 7867, 7890, 7889, 11010, 11011, 11034, 11033, 0, 0, 0, 0, 11315, 11361, 11362, 
11359, 36756, 36757, 36780, 36779
25585, 7867, 7868, 7891, 7890, 11011, 11012, 11035, 11034, 0, 0, 0, 0, 11317, 11363, 11364, 
11361, 36757, 36758, 36781, 36780
25586, 7868, 7869, 7892, 7891, 11012, 11013, 11036, 11035, 0, 0, 0, 0, 11319, 11365, 11366, 
11363, 36758, 36759, 36782, 36781
25587, 7869, 7870, 7893, 7892, 11013, 11014, 11037, 11036, 0, 0, 0, 0, 11321, 11367, 11368, 
11365, 36759, 36760, 36783, 36782
25588, 7870, 7871, 7894, 7893, 11014, 11015, 11038, 11037, 0, 0, 0, 0, 11323, 11369, 11370, 
11367, 36760, 36761, 36784, 36783
25589, 7871, 7872, 7895, 7894, 11015, 11016, 11039, 11038, 0, 0, 0, 0, 11325, 11371, 11372, 
11369, 36761, 36762, 36785, 36784
25590, 7872, 7873, 7896, 7895, 11016, 11017, 11040, 11039, 0, 0, 0, 0, 11327, 11373, 11374, 
11371, 36762, 36763, 36786, 36785
25591, 7873, 7874, 7897, 7896, 11017, 11018, 11041, 11040, 0, 0, 0, 0, 11329, 11375, 11376, 
11373, 36763, 36764, 36787, 36786
25592, 7874, 7875, 7898, 7897, 11018, 11019, 11042, 11041, 0, 0, 0, 0, 11331, 11377, 11378, 
11375, 36764, 36765, 36788, 36787
25593, 7875, 7876, 7899, 7898, 11019, 11020, 11043, 11042, 0, 0, 0, 0, 11333, 11379, 11380, 
11377, 36765, 36766, 36789, 36788
25594, 7876, 7877, 7900, 7899, 11020, 11021, 11044, 11043, 0, 0, 0, 0, 11335, 11381, 11382, 
11379, 36766, 36767, 36790, 36789
25595, 7877, 7878, 7901, 7900, 11021, 11022, 11045, 11044, 0, 0, 0, 0, 11337, 11383, 11384, 
11381, 36767, 36768, 36791, 36790
25596, 7878, 7879, 7902, 7901, 11022, 11023, 11046, 11045, 0, 0, 0, 0, 11339, 11385, 11386, 
11383, 36768, 36769, 36792, 36791
25597, 7879, 7880, 7903, 7902, 11023, 11024, 11047, 11046, 0, 0, 0, 0, 11341, 11387, 11388, 
11385, 36769, 36770, 36793, 36792
25598, 7880, 7881, 7904, 7903, 11024, 11025, 11048, 11047, 0, 0, 0, 0, 11343, 11389, 11390, 
11387, 36770, 36771, 36794, 36793
25599, 7881, 7882, 7905, 7904, 11025, 11026, 11049, 11048, 0, 0, 0, 0, 11345, 11391, 11392, 
11389, 36771, 36772, 36795, 36794
25600, 7882, 7883, 7906, 7905, 11026, 11027, 11050, 11049, 0, 0, 0, 0, 11347, 11393, 11394, 
11391, 36772, 36773, 36796, 36795
25601, 7883, 7884, 7907, 7906, 11027, 11028, 11051, 11050, 0, 0, 0, 0, 11349, 11395, 11396, 
11393, 36773, 36774, 36797, 36796
25602, 7884, 7885, 7908, 7907, 11028, 11029, 11052, 11051, 0, 0, 0, 0, 11351, 11397, 11398, 
11395, 36774, 36775, 36798, 36797
25603, 7885, 7886, 7909, 7908, 11029, 11030, 11053, 11052, 0, 0, 0, 0, 11353, 11399, 11400, 
11397, 36775, 36776, 36799, 36798
25604, 7886, 7887, 7910, 7909, 11030, 11031, 11054, 11053, 0, 0, 0, 0, 11355, 11401, 11402, 
11399, 36776, 36777, 36800, 36799
25605, 7887, 982, 983, 7910, 11031, 1469, 1470, 11054, 0, 0, 0, 0, 11356, 1481, 11403, 
11401, 36777, 10954, 10955, 36800
25606, 823, 7888, 7911, 824, 1447, 11032, 11055, 1448, 0, 0, 0, 0, 11358, 11404, 11405, 
1459, 10944, 36778, 36801, 10945
25607, 7888, 7889, 7912, 7911, 11032, 11033, 11056, 11055, 0, 0, 0, 0, 11360, 11406, 11407, 
11404, 36778, 36779, 36802, 36801
25608, 7889, 7890, 7913, 7912, 11033, 11034, 11057, 11056, 0, 0, 0, 0, 11362, 11408, 11409, 
11406, 36779, 36780, 36803, 36802
25609, 7890, 7891, 7914, 7913, 11034, 11035, 11058, 11057, 0, 0, 0, 0, 11364, 11410, 11411, 
11408, 36780, 36781, 36804, 36803
25610, 7891, 7892, 7915, 7914, 11035, 11036, 11059, 11058, 0, 0, 0, 0, 11366, 11412, 11413, 
11410, 36781, 36782, 36805, 36804
25611, 7892, 7893, 7916, 7915, 11036, 11037, 11060, 11059, 0, 0, 0, 0, 11368, 11414, 11415, 
11412, 36782, 36783, 36806, 36805
25612, 7893, 7894, 7917, 7916, 11037, 11038, 11061, 11060, 0, 0, 0, 0, 11370, 11416, 11417, 
11414, 36783, 36784, 36807, 36806
25613, 7894, 7895, 7918, 7917, 11038, 11039, 11062, 11061, 0, 0, 0, 0, 11372, 11418, 11419, 
11416, 36784, 36785, 36808, 36807
25614, 7895, 7896, 7919, 7918, 11039, 11040, 11063, 11062, 0, 0, 0, 0, 11374, 11420, 11421, 
11418, 36785, 36786, 36809, 36808
25615, 7896, 7897, 7920, 7919, 11040, 11041, 11064, 11063, 0, 0, 0, 0, 11376, 11422, 11423, 
11420, 36786, 36787, 36810, 36809
25616, 7897, 7898, 7921, 7920, 11041, 11042, 11065, 11064, 0, 0, 0, 0, 11378, 11424, 11425, 
11422, 36787, 36788, 36811, 36810
25617, 7898, 7899, 7922, 7921, 11042, 11043, 11066, 11065, 0, 0, 0, 0, 11380, 11426, 11427, 
11424, 36788, 36789, 36812, 36811
25618, 7899, 7900, 7923, 7922, 11043, 11044, 11067, 11066, 0, 0, 0, 0, 11382, 11428, 11429, 
11426, 36789, 36790, 36813, 36812
25619, 7900, 7901, 7924, 7923, 11044, 11045, 11068, 11067, 0, 0, 0, 0, 11384, 11430, 11431, 
11428, 36790, 36791, 36814, 36813
25620, 7901, 7902, 7925, 7924, 11045, 11046, 11069, 11068, 0, 0, 0, 0, 11386, 11432, 11433, 
11430, 36791, 36792, 36815, 36814
25621, 7902, 7903, 7926, 7925, 11046, 11047, 11070, 11069, 0, 0, 0, 0, 11388, 11434, 11435, 
11432, 36792, 36793, 36816, 36815
25622, 7903, 7904, 7927, 7926, 11047, 11048, 11071, 11070, 0, 0, 0, 0, 11390, 11436, 11437, 
11434, 36793, 36794, 36817, 36816
25623, 7904, 7905, 7928, 7927, 11048, 11049, 11072, 11071, 0, 0, 0, 0, 11392, 11438, 11439, 
11436, 36794, 36795, 36818, 36817
25624, 7905, 7906, 7929, 7928, 11049, 11050, 11073, 11072, 0, 0, 0, 0, 11394, 11440, 11441, 
11438, 36795, 36796, 36819, 36818
25625, 7906, 7907, 7930, 7929, 11050, 11051, 11074, 11073, 0, 0, 0, 0, 11396, 11442, 11443, 
11440, 36796, 36797, 36820, 36819
25626, 7907, 7908, 7931, 7930, 11051, 11052, 11075, 11074, 0, 0, 0, 0, 11398, 11444, 11445, 
11442, 36797, 36798, 36821, 36820
25627, 7908, 7909, 7932, 7931, 11052, 11053, 11076, 11075, 0, 0, 0, 0, 11400, 11446, 11447, 
11444, 36798, 36799, 36822, 36821
25628, 7909, 7910, 7933, 7932, 11053, 11054, 11077, 11076, 0, 0, 0, 0, 11402, 11448, 11449, 
11446, 36799, 36800, 36823, 36822
25629, 7910, 983, 984, 7933, 11054, 1470, 1471, 11077, 0, 0, 0, 0, 11403, 1482, 11450, 
11448, 36800, 10955, 10956, 36823
25630, 824, 7911, 7934, 825, 1448, 11055, 11078, 1449, 0, 0, 0, 0, 11405, 11451, 11452, 
1460, 10945, 36801, 36824, 10946
25631, 7911, 7912, 7935, 7934, 11055, 11056, 11079, 11078, 0, 0, 0, 0, 11407, 11453, 11454, 
11451, 36801, 36802, 36825, 36824
25632, 7912, 7913, 7936, 7935, 11056, 11057, 11080, 11079, 0, 0, 0, 0, 11409, 11455, 11456, 
11453, 36802, 36803, 36826, 36825
25633, 7913, 7914, 7937, 7936, 11057, 11058, 11081, 11080, 0, 0, 0, 0, 11411, 11457, 11458, 
11455, 36803, 36804, 36827, 36826
25634, 7914, 7915, 7938, 7937, 11058, 11059, 11082, 11081, 0, 0, 0, 0, 11413, 11459, 11460, 
11457, 36804, 36805, 36828, 36827
25635, 7915, 7916, 7939, 7938, 11059, 11060, 11083, 11082, 0, 0, 0, 0, 11415, 11461, 11462, 
11459, 36805, 36806, 36829, 36828
25636, 7916, 7917, 7940, 7939, 11060, 11061, 11084, 11083, 0, 0, 0, 0, 11417, 11463, 11464, 
11461, 36806, 36807, 36830, 36829
25637, 7917, 7918, 7941, 7940, 11061, 11062, 11085, 11084, 0, 0, 0, 0, 11419, 11465, 11466, 
11463, 36807, 36808, 36831, 36830
25638, 7918, 7919, 7942, 7941, 11062, 11063, 11086, 11085, 0, 0, 0, 0, 11421, 11467, 11468, 
11465, 36808, 36809, 36832, 36831
25639, 7919, 7920, 7943, 7942, 11063, 11064, 11087, 11086, 0, 0, 0, 0, 11423, 11469, 11470, 
11467, 36809, 36810, 36833, 36832
25640, 7920, 7921, 7944, 7943, 11064, 11065, 11088, 11087, 0, 0, 0, 0, 11425, 11471, 11472, 
11469, 36810, 36811, 36834, 36833
25641, 7921, 7922, 7945, 7944, 11065, 11066, 11089, 11088, 0, 0, 0, 0, 11427, 11473, 11474, 
11471, 36811, 36812, 36835, 36834
25642, 7922, 7923, 7946, 7945, 11066, 11067, 11090, 11089, 0, 0, 0, 0, 11429, 11475, 11476, 
11473, 36812, 36813, 36836, 36835
25643, 7923, 7924, 7947, 7946, 11067, 11068, 11091, 11090, 0, 0, 0, 0, 11431, 11477, 11478, 
11475, 36813, 36814, 36837, 36836
25644, 7924, 7925, 7948, 7947, 11068, 11069, 11092, 11091, 0, 0, 0, 0, 11433, 11479, 11480, 
11477, 36814, 36815, 36838, 36837
25645, 7925, 7926, 7949, 7948, 11069, 11070, 11093, 11092, 0, 0, 0, 0, 11435, 11481, 11482, 
11479, 36815, 36816, 36839, 36838
25646, 7926, 7927, 7950, 7949, 11070, 11071, 11094, 11093, 0, 0, 0, 0, 11437, 11483, 11484, 
11481, 36816, 36817, 36840, 36839
25647, 7927, 7928, 7951, 7950, 11071, 11072, 11095, 11094, 0, 0, 0, 0, 11439, 11485, 11486, 
11483, 36817, 36818, 36841, 36840
25648, 7928, 7929, 7952, 7951, 11072, 11073, 11096, 11095, 0, 0, 0, 0, 11441, 11487, 11488, 
11485, 36818, 36819, 36842, 36841
25649, 7929, 7930, 7953, 7952, 11073, 11074, 11097, 11096, 0, 0, 0, 0, 11443, 11489, 11490, 
11487, 36819, 36820, 36843, 36842
25650, 7930, 7931, 7954, 7953, 11074, 11075, 11098, 11097, 0, 0, 0, 0, 11445, 11491, 11492, 
11489, 36820, 36821, 36844, 36843
25651, 7931, 7932, 7955, 7954, 11075, 11076, 11099, 11098, 0, 0, 0, 0, 11447, 11493, 11494, 
11491, 36821, 36822, 36845, 36844
25652, 7932, 7933, 7956, 7955, 11076, 11077, 11100, 11099, 0, 0, 0, 0, 11449, 11495, 11496, 
11493, 36822, 36823, 36846, 36845
25653, 7933, 984, 985, 7956, 11077, 1471, 1472, 11100, 0, 0, 0, 0, 11450, 1483, 11497, 
11495, 36823, 10956, 10957, 36846
25654, 825, 7934, 7957, 826, 1449, 11078, 11101, 1450, 0, 0, 0, 0, 11452, 11498, 11499, 
1461, 10946, 36824, 36847, 10947
25655, 7934, 7935, 7958, 7957, 11078, 11079, 11102, 11101, 0, 0, 0, 0, 11454, 11500, 11501, 
11498, 36824, 36825, 36848, 36847
25656, 7935, 7936, 7959, 7958, 11079, 11080, 11103, 11102, 0, 0, 0, 0, 11456, 11502, 11503, 
11500, 36825, 36826, 36849, 36848
25657, 7936, 7937, 7960, 7959, 11080, 11081, 11104, 11103, 0, 0, 0, 0, 11458, 11504, 11505, 
11502, 36826, 36827, 36850, 36849
25658, 7937, 7938, 7961, 7960, 11081, 11082, 11105, 11104, 0, 0, 0, 0, 11460, 11506, 11507, 
11504, 36827, 36828, 36851, 36850
25659, 7938, 7939, 7962, 7961, 11082, 11083, 11106, 11105, 0, 0, 0, 0, 11462, 11508, 11509, 
11506, 36828, 36829, 36852, 36851
25660, 7939, 7940, 7963, 7962, 11083, 11084, 11107, 11106, 0, 0, 0, 0, 11464, 11510, 11511, 
11508, 36829, 36830, 36853, 36852
25661, 7940, 7941, 7964, 7963, 11084, 11085, 11108, 11107, 0, 0, 0, 0, 11466, 11512, 11513, 
11510, 36830, 36831, 36854, 36853
25662, 7941, 7942, 7965, 7964, 11085, 11086, 11109, 11108, 0, 0, 0, 0, 11468, 11514, 11515, 
11512, 36831, 36832, 36855, 36854
25663, 7942, 7943, 7966, 7965, 11086, 11087, 11110, 11109, 0, 0, 0, 0, 11470, 11516, 11517, 
11514, 36832, 36833, 36856, 36855
25664, 7943, 7944, 7967, 7966, 11087, 11088, 11111, 11110, 0, 0, 0, 0, 11472, 11518, 11519, 
11516, 36833, 36834, 36857, 36856
25665, 7944, 7945, 7968, 7967, 11088, 11089, 11112, 11111, 0, 0, 0, 0, 11474, 11520, 11521, 
11518, 36834, 36835, 36858, 36857
25666, 7945, 7946, 7969, 7968, 11089, 11090, 11113, 11112, 0, 0, 0, 0, 11476, 11522, 11523, 
11520, 36835, 36836, 36859, 36858
25667, 7946, 7947, 7970, 7969, 11090, 11091, 11114, 11113, 0, 0, 0, 0, 11478, 11524, 11525, 
11522, 36836, 36837, 36860, 36859
25668, 7947, 7948, 7971, 7970, 11091, 11092, 11115, 11114, 0, 0, 0, 0, 11480, 11526, 11527, 
11524, 36837, 36838, 36861, 36860
25669, 7948, 7949, 7972, 7971, 11092, 11093, 11116, 11115, 0, 0, 0, 0, 11482, 11528, 11529, 
11526, 36838, 36839, 36862, 36861
25670, 7949, 7950, 7973, 7972, 11093, 11094, 11117, 11116, 0, 0, 0, 0, 11484, 11530, 11531, 
11528, 36839, 36840, 36863, 36862
25671, 7950, 7951, 7974, 7973, 11094, 11095, 11118, 11117, 0, 0, 0, 0, 11486, 11532, 11533, 
11530, 36840, 36841, 36864, 36863
25672, 7951, 7952, 7975, 7974, 11095, 11096, 11119, 11118, 0, 0, 0, 0, 11488, 11534, 11535, 
11532, 36841, 36842, 36865, 36864
25673, 7952, 7953, 7976, 7975, 11096, 11097, 11120, 11119, 0, 0, 0, 0, 11490, 11536, 11537, 
11534, 36842, 36843, 36866, 36865
25674, 7953, 7954, 7977, 7976, 11097, 11098, 11121, 11120, 0, 0, 0, 0, 11492, 11538, 11539, 
11536, 36843, 36844, 36867, 36866
25675, 7954, 7955, 7978, 7977, 11098, 11099, 11122, 11121, 0, 0, 0, 0, 11494, 11540, 11541, 
11538, 36844, 36845, 36868, 36867
25676, 7955, 7956, 7979, 7978, 11099, 11100, 11123, 11122, 0, 0, 0, 0, 11496, 11542, 11543, 
11540, 36845, 36846, 36869, 36868
25677, 7956, 985, 986, 7979, 11100, 1472, 1473, 11123, 0, 0, 0, 0, 11497, 1484, 11544, 
11542, 36846, 10957, 10958, 36869
25678, 826, 7957, 7980, 827, 1450, 11101, 11124, 1451, 0, 0, 0, 0, 11499, 11545, 11546, 
1462, 10947, 36847, 36870, 10948
25679, 7957, 7958, 7981, 7980, 11101, 11102, 11125, 11124, 0, 0, 0, 0, 11501, 11547, 11548, 
11545, 36847, 36848, 36871, 36870
25680, 7958, 7959, 7982, 7981, 11102, 11103, 11126, 11125, 0, 0, 0, 0, 11503, 11549, 11550, 
11547, 36848, 36849, 36872, 36871
25681, 7959, 7960, 7983, 7982, 11103, 11104, 11127, 11126, 0, 0, 0, 0, 11505, 11551, 11552, 
11549, 36849, 36850, 36873, 36872
25682, 7960, 7961, 7984, 7983, 11104, 11105, 11128, 11127, 0, 0, 0, 0, 11507, 11553, 11554, 
11551, 36850, 36851, 36874, 36873
25683, 7961, 7962, 7985, 7984, 11105, 11106, 11129, 11128, 0, 0, 0, 0, 11509, 11555, 11556, 
11553, 36851, 36852, 36875, 36874
25684, 7962, 7963, 7986, 7985, 11106, 11107, 11130, 11129, 0, 0, 0, 0, 11511, 11557, 11558, 
11555, 36852, 36853, 36876, 36875
25685, 7963, 7964, 7987, 7986, 11107, 11108, 11131, 11130, 0, 0, 0, 0, 11513, 11559, 11560, 
11557, 36853, 36854, 36877, 36876
25686, 7964, 7965, 7988, 7987, 11108, 11109, 11132, 11131, 0, 0, 0, 0, 11515, 11561, 11562, 
11559, 36854, 36855, 36878, 36877
25687, 7965, 7966, 7989, 7988, 11109, 11110, 11133, 11132, 0, 0, 0, 0, 11517, 11563, 11564, 
11561, 36855, 36856, 36879, 36878
25688, 7966, 7967, 7990, 7989, 11110, 11111, 11134, 11133, 0, 0, 0, 0, 11519, 11565, 11566, 
11563, 36856, 36857, 36880, 36879
25689, 7967, 7968, 7991, 7990, 11111, 11112, 11135, 11134, 0, 0, 0, 0, 11521, 11567, 11568, 
11565, 36857, 36858, 36881, 36880
25690, 7968, 7969, 7992, 7991, 11112, 11113, 11136, 11135, 0, 0, 0, 0, 11523, 11569, 11570, 
11567, 36858, 36859, 36882, 36881
25691, 7969, 7970, 7993, 7992, 11113, 11114, 11137, 11136, 0, 0, 0, 0, 11525, 11571, 11572, 
11569, 36859, 36860, 36883, 36882
25692, 7970, 7971, 7994, 7993, 11114, 11115, 11138, 11137, 0, 0, 0, 0, 11527, 11573, 11574, 
11571, 36860, 36861, 36884, 36883
25693, 7971, 7972, 7995, 7994, 11115, 11116, 11139, 11138, 0, 0, 0, 0, 11529, 11575, 11576, 
11573, 36861, 36862, 36885, 36884
25694, 7972, 7973, 7996, 7995, 11116, 11117, 11140, 11139, 0, 0, 0, 0, 11531, 11577, 11578, 
11575, 36862, 36863, 36886, 36885
25695, 7973, 7974, 7997, 7996, 11117, 11118, 11141, 11140, 0, 0, 0, 0, 11533, 11579, 11580, 
11577, 36863, 36864, 36887, 36886
25696, 7974, 7975, 7998, 7997, 11118, 11119, 11142, 11141, 0, 0, 0, 0, 11535, 11581, 11582, 
11579, 36864, 36865, 36888, 36887
25697, 7975, 7976, 7999, 7998, 11119, 11120, 11143, 11142, 0, 0, 0, 0, 11537, 11583, 11584, 
11581, 36865, 36866, 36889, 36888
25698, 7976, 7977, 8000, 7999, 11120, 11121, 11144, 11143, 0, 0, 0, 0, 11539, 11585, 11586, 
11583, 36866, 36867, 36890, 36889
25699, 7977, 7978, 8001, 8000, 11121, 11122, 11145, 11144, 0, 0, 0, 0, 11541, 11587, 11588, 
11585, 36867, 36868, 36891, 36890
25700, 7978, 7979, 8002, 8001, 11122, 11123, 11146, 11145, 0, 0, 0, 0, 11543, 11589, 11590, 
11587, 36868, 36869, 36892, 36891
25701, 7979, 986, 987, 8002, 11123, 1473, 1474, 11146, 0, 0, 0, 0, 11544, 1485, 11591, 
11589, 36869, 10958, 10959, 36892
25702, 827, 7980, 8003, 828, 1451, 11124, 11147, 1452, 0, 0, 0, 0, 11546, 11592, 11593, 
1463, 10948, 36870, 36893, 10949
25703, 7980, 7981, 8004, 8003, 11124, 11125, 11148, 11147, 0, 0, 0, 0, 11548, 11594, 11595, 
11592, 36870, 36871, 36894, 36893
25704, 7981, 7982, 8005, 8004, 11125, 11126, 11149, 11148, 0, 0, 0, 0, 11550, 11596, 11597, 
11594, 36871, 36872, 36895, 36894
25705, 7982, 7983, 8006, 8005, 11126, 11127, 11150, 11149, 0, 0, 0, 0, 11552, 11598, 11599, 
11596, 36872, 36873, 36896, 36895
25706, 7983, 7984, 8007, 8006, 11127, 11128, 11151, 11150, 0, 0, 0, 0, 11554, 11600, 11601, 
11598, 36873, 36874, 36897, 36896
25707, 7984, 7985, 8008, 8007, 11128, 11129, 11152, 11151, 0, 0, 0, 0, 11556, 11602, 11603, 
11600, 36874, 36875, 36898, 36897
25708, 7985, 7986, 8009, 8008, 11129, 11130, 11153, 11152, 0, 0, 0, 0, 11558, 11604, 11605, 
11602, 36875, 36876, 36899, 36898
25709, 7986, 7987, 8010, 8009, 11130, 11131, 11154, 11153, 0, 0, 0, 0, 11560, 11606, 11607, 
11604, 36876, 36877, 36900, 36899
25710, 7987, 7988, 8011, 8010, 11131, 11132, 11155, 11154, 0, 0, 0, 0, 11562, 11608, 11609, 
11606, 36877, 36878, 36901, 36900
25711, 7988, 7989, 8012, 8011, 11132, 11133, 11156, 11155, 0, 0, 0, 0, 11564, 11610, 11611, 
11608, 36878, 36879, 36902, 36901
25712, 7989, 7990, 8013, 8012, 11133, 11134, 11157, 11156, 0, 0, 0, 0, 11566, 11612, 11613, 
11610, 36879, 36880, 36903, 36902
25713, 7990, 7991, 8014, 8013, 11134, 11135, 11158, 11157, 0, 0, 0, 0, 11568, 11614, 11615, 
11612, 36880, 36881, 36904, 36903
25714, 7991, 7992, 8015, 8014, 11135, 11136, 11159, 11158, 0, 0, 0, 0, 11570, 11616, 11617, 
11614, 36881, 36882, 36905, 36904
25715, 7992, 7993, 8016, 8015, 11136, 11137, 11160, 11159, 0, 0, 0, 0, 11572, 11618, 11619, 
11616, 36882, 36883, 36906, 36905
25716, 7993, 7994, 8017, 8016, 11137, 11138, 11161, 11160, 0, 0, 0, 0, 11574, 11620, 11621, 
11618, 36883, 36884, 36907, 36906
25717, 7994, 7995, 8018, 8017, 11138, 11139, 11162, 11161, 0, 0, 0, 0, 11576, 11622, 11623, 
11620, 36884, 36885, 36908, 36907
25718, 7995, 7996, 8019, 8018, 11139, 11140, 11163, 11162, 0, 0, 0, 0, 11578, 11624, 11625, 
11622, 36885, 36886, 36909, 36908
25719, 7996, 7997, 8020, 8019, 11140, 11141, 11164, 11163, 0, 0, 0, 0, 11580, 11626, 11627, 
11624, 36886, 36887, 36910, 36909
25720, 7997, 7998, 8021, 8020, 11141, 11142, 11165, 11164, 0, 0, 0, 0, 11582, 11628, 11629, 
11626, 36887, 36888, 36911, 36910
25721, 7998, 7999, 8022, 8021, 11142, 11143, 11166, 11165, 0, 0, 0, 0, 11584, 11630, 11631, 
11628, 36888, 36889, 36912, 36911
25722, 7999, 8000, 8023, 8022, 11143, 11144, 11167, 11166, 0, 0, 0, 0, 11586, 11632, 11633, 
11630, 36889, 36890, 36913, 36912
25723, 8000, 8001, 8024, 8023, 11144, 11145, 11168, 11167, 0, 0, 0, 0, 11588, 11634, 11635, 
11632, 36890, 36891, 36914, 36913
25724, 8001, 8002, 8025, 8024, 11145, 11146, 11169, 11168, 0, 0, 0, 0, 11590, 11636, 11637, 
11634, 36891, 36892, 36915, 36914
25725, 8002, 987, 988, 8025, 11146, 1474, 1475, 11169, 0, 0, 0, 0, 11591, 1486, 11638, 
11636, 36892, 10959, 10960, 36915
25726, 828, 8003, 8026, 829, 1452, 11147, 11170, 1453, 0, 0, 0, 0, 11593, 11639, 11640, 
1464, 10949, 36893, 36916, 10950
25727, 8003, 8004, 8027, 8026, 11147, 11148, 11171, 11170, 0, 0, 0, 0, 11595, 11641, 11642, 
11639, 36893, 36894, 36917, 36916
25728, 8004, 8005, 8028, 8027, 11148, 11149, 11172, 11171, 0, 0, 0, 0, 11597, 11643, 11644, 
11641, 36894, 36895, 36918, 36917
25729, 8005, 8006, 8029, 8028, 11149, 11150, 11173, 11172, 0, 0, 0, 0, 11599, 11645, 11646, 
11643, 36895, 36896, 36919, 36918
25730, 8006, 8007, 8030, 8029, 11150, 11151, 11174, 11173, 0, 0, 0, 0, 11601, 11647, 11648, 
11645, 36896, 36897, 36920, 36919
25731, 8007, 8008, 8031, 8030, 11151, 11152, 11175, 11174, 0, 0, 0, 0, 11603, 11649, 11650, 
11647, 36897, 36898, 36921, 36920
25732, 8008, 8009, 8032, 8031, 11152, 11153, 11176, 11175, 0, 0, 0, 0, 11605, 11651, 11652, 
11649, 36898, 36899, 36922, 36921
25733, 8009, 8010, 8033, 8032, 11153, 11154, 11177, 11176, 0, 0, 0, 0, 11607, 11653, 11654, 
11651, 36899, 36900, 36923, 36922
25734, 8010, 8011, 8034, 8033, 11154, 11155, 11178, 11177, 0, 0, 0, 0, 11609, 11655, 11656, 
11653, 36900, 36901, 36924, 36923
25735, 8011, 8012, 8035, 8034, 11155, 11156, 11179, 11178, 0, 0, 0, 0, 11611, 11657, 11658, 
11655, 36901, 36902, 36925, 36924
25736, 8012, 8013, 8036, 8035, 11156, 11157, 11180, 11179, 0, 0, 0, 0, 11613, 11659, 11660, 
11657, 36902, 36903, 36926, 36925
25737, 8013, 8014, 8037, 8036, 11157, 11158, 11181, 11180, 0, 0, 0, 0, 11615, 11661, 11662, 
11659, 36903, 36904, 36927, 36926
25738, 8014, 8015, 8038, 8037, 11158, 11159, 11182, 11181, 0, 0, 0, 0, 11617, 11663, 11664, 
11661, 36904, 36905, 36928, 36927
25739, 8015, 8016, 8039, 8038, 11159, 11160, 11183, 11182, 0, 0, 0, 0, 11619, 11665, 11666, 
11663, 36905, 36906, 36929, 36928
25740, 8016, 8017, 8040, 8039, 11160, 11161, 11184, 11183, 0, 0, 0, 0, 11621, 11667, 11668, 
11665, 36906, 36907, 36930, 36929
25741, 8017, 8018, 8041, 8040, 11161, 11162, 11185, 11184, 0, 0, 0, 0, 11623, 11669, 11670, 
11667, 36907, 36908, 36931, 36930
25742, 8018, 8019, 8042, 8041, 11162, 11163, 11186, 11185, 0, 0, 0, 0, 11625, 11671, 11672, 
11669, 36908, 36909, 36932, 36931
25743, 8019, 8020, 8043, 8042, 11163, 11164, 11187, 11186, 0, 0, 0, 0, 11627, 11673, 11674, 
11671, 36909, 36910, 36933, 36932
25744, 8020, 8021, 8044, 8043, 11164, 11165, 11188, 11187, 0, 0, 0, 0, 11629, 11675, 11676, 
11673, 36910, 36911, 36934, 36933
25745, 8021, 8022, 8045, 8044, 11165, 11166, 11189, 11188, 0, 0, 0, 0, 11631, 11677, 11678, 
11675, 36911, 36912, 36935, 36934
25746, 8022, 8023, 8046, 8045, 11166, 11167, 11190, 11189, 0, 0, 0, 0, 11633, 11679, 11680, 
11677, 36912, 36913, 36936, 36935
25747, 8023, 8024, 8047, 8046, 11167, 11168, 11191, 11190, 0, 0, 0, 0, 11635, 11681, 11682, 
11679, 36913, 36914, 36937, 36936
25748, 8024, 8025, 8048, 8047, 11168, 11169, 11192, 11191, 0, 0, 0, 0, 11637, 11683, 11684, 
11681, 36914, 36915, 36938, 36937
25749, 8025, 988, 989, 8048, 11169, 1475, 1476, 11192, 0, 0, 0, 0, 11638, 1487, 11685, 
11683, 36915, 10960, 10961, 36938
25750, 829, 8026, 8049, 830, 1453, 11170, 11193, 1454, 0, 0, 0, 0, 11640, 11686, 11687, 
1465, 10950, 36916, 36939, 10951
25751, 8026, 8027, 8050, 8049, 11170, 11171, 11194, 11193, 0, 0, 0, 0, 11642, 11688, 11689, 
11686, 36916, 36917, 36940, 36939
25752, 8027, 8028, 8051, 8050, 11171, 11172, 11195, 11194, 0, 0, 0, 0, 11644, 11690, 11691, 
11688, 36917, 36918, 36941, 36940
25753, 8028, 8029, 8052, 8051, 11172, 11173, 11196, 11195, 0, 0, 0, 0, 11646, 11692, 11693, 
11690, 36918, 36919, 36942, 36941
25754, 8029, 8030, 8053, 8052, 11173, 11174, 11197, 11196, 0, 0, 0, 0, 11648, 11694, 11695, 
11692, 36919, 36920, 36943, 36942
25755, 8030, 8031, 8054, 8053, 11174, 11175, 11198, 11197, 0, 0, 0, 0, 11650, 11696, 11697, 
11694, 36920, 36921, 36944, 36943
25756, 8031, 8032, 8055, 8054, 11175, 11176, 11199, 11198, 0, 0, 0, 0, 11652, 11698, 11699, 
11696, 36921, 36922, 36945, 36944
25757, 8032, 8033, 8056, 8055, 11176, 11177, 11200, 11199, 0, 0, 0, 0, 11654, 11700, 11701, 
11698, 36922, 36923, 36946, 36945
25758, 8033, 8034, 8057, 8056, 11177, 11178, 11201, 11200, 0, 0, 0, 0, 11656, 11702, 11703, 
11700, 36923, 36924, 36947, 36946
25759, 8034, 8035, 8058, 8057, 11178, 11179, 11202, 11201, 0, 0, 0, 0, 11658, 11704, 11705, 
11702, 36924, 36925, 36948, 36947
25760, 8035, 8036, 8059, 8058, 11179, 11180, 11203, 11202, 0, 0, 0, 0, 11660, 11706, 11707, 
11704, 36925, 36926, 36949, 36948
25761, 8036, 8037, 8060, 8059, 11180, 11181, 11204, 11203, 0, 0, 0, 0, 11662, 11708, 11709, 
11706, 36926, 36927, 36950, 36949
25762, 8037, 8038, 8061, 8060, 11181, 11182, 11205, 11204, 0, 0, 0, 0, 11664, 11710, 11711, 
11708, 36927, 36928, 36951, 36950
25763, 8038, 8039, 8062, 8061, 11182, 11183, 11206, 11205, 0, 0, 0, 0, 11666, 11712, 11713, 
11710, 36928, 36929, 36952, 36951
25764, 8039, 8040, 8063, 8062, 11183, 11184, 11207, 11206, 0, 0, 0, 0, 11668, 11714, 11715, 
11712, 36929, 36930, 36953, 36952
25765, 8040, 8041, 8064, 8063, 11184, 11185, 11208, 11207, 0, 0, 0, 0, 11670, 11716, 11717, 
11714, 36930, 36931, 36954, 36953
25766, 8041, 8042, 8065, 8064, 11185, 11186, 11209, 11208, 0, 0, 0, 0, 11672, 11718, 11719, 
11716, 36931, 36932, 36955, 36954
25767, 8042, 8043, 8066, 8065, 11186, 11187, 11210, 11209, 0, 0, 0, 0, 11674, 11720, 11721, 
11718, 36932, 36933, 36956, 36955
25768, 8043, 8044, 8067, 8066, 11187, 11188, 11211, 11210, 0, 0, 0, 0, 11676, 11722, 11723, 
11720, 36933, 36934, 36957, 36956
25769, 8044, 8045, 8068, 8067, 11188, 11189, 11212, 11211, 0, 0, 0, 0, 11678, 11724, 11725, 
11722, 36934, 36935, 36958, 36957
25770, 8045, 8046, 8069, 8068, 11189, 11190, 11213, 11212, 0, 0, 0, 0, 11680, 11726, 11727, 
11724, 36935, 36936, 36959, 36958
25771, 8046, 8047, 8070, 8069, 11190, 11191, 11214, 11213, 0, 0, 0, 0, 11682, 11728, 11729, 
11726, 36936, 36937, 36960, 36959
25772, 8047, 8048, 8071, 8070, 11191, 11192, 11215, 11214, 0, 0, 0, 0, 11684, 11730, 11731, 
11728, 36937, 36938, 36961, 36960
25773, 8048, 989, 990, 8071, 11192, 1476, 1477, 11215, 0, 0, 0, 0, 11685, 1488, 11732, 
11730, 36938, 10961, 10962, 36961
25774, 830, 8049, 842, 33, 1454, 11193, 1372, 61, 0, 0, 0, 0, 11687, 11733, 0, 
1466, 10951, 36939, 0, 0
25775, 8049, 8050, 843, 842, 11193, 11194, 1373, 1372, 0, 0, 0, 0, 11689, 11734, 0, 
11733, 36939, 36940, 0, 0
25776, 8050, 8051, 844, 843, 11194, 11195, 1374, 1373, 0, 0, 0, 0, 11691, 11735, 0, 
11734, 36940, 36941, 0, 0
25777, 8051, 8052, 845, 844, 11195, 11196, 1375, 1374, 0, 0, 0, 0, 11693, 11736, 0, 
11735, 36941, 36942, 0, 0
25778, 8052, 8053, 846, 845, 11196, 11197, 1376, 1375, 0, 0, 0, 0, 11695, 11737, 0, 
11736, 36942, 36943, 0, 0
25779, 8053, 8054, 847, 846, 11197, 11198, 1377, 1376, 0, 0, 0, 0, 11697, 11738, 0, 
11737, 36943, 36944, 0, 0
25780, 8054, 8055, 848, 847, 11198, 11199, 1378, 1377, 0, 0, 0, 0, 11699, 11739, 0, 
11738, 36944, 36945, 0, 0
25781, 8055, 8056, 849, 848, 11199, 11200, 1379, 1378, 0, 0, 0, 0, 11701, 11740, 0, 
11739, 36945, 36946, 0, 0
25782, 8056, 8057, 850, 849, 11200, 11201, 1380, 1379, 0, 0, 0, 0, 11703, 11741, 0, 
11740, 36946, 36947, 0, 0
25783, 8057, 8058, 851, 850, 11201, 11202, 1381, 1380, 0, 0, 0, 0, 11705, 11742, 0, 
11741, 36947, 36948, 0, 0
25784, 8058, 8059, 852, 851, 11202, 11203, 1382, 1381, 0, 0, 0, 0, 11707, 11743, 0, 
11742, 36948, 36949, 0, 0
25785, 8059, 8060, 853, 852, 11203, 11204, 1383, 1382, 0, 0, 0, 0, 11709, 11744, 0, 
11743, 36949, 36950, 0, 0
25786, 8060, 8061, 854, 853, 11204, 11205, 1384, 1383, 0, 0, 0, 0, 11711, 11745, 0, 
11744, 36950, 36951, 0, 0
25787, 8061, 8062, 855, 854, 11205, 11206, 1385, 1384, 0, 0, 0, 0, 11713, 11746, 0, 
11745, 36951, 36952, 0, 0
25788, 8062, 8063, 856, 855, 11206, 11207, 1386, 1385, 0, 0, 0, 0, 11715, 11747, 0, 
11746, 36952, 36953, 0, 0
25789, 8063, 8064, 857, 856, 11207, 11208, 1387, 1386, 0, 0, 0, 0, 11717, 11748, 0, 
11747, 36953, 36954, 0, 0
25790, 8064, 8065, 858, 857, 11208, 11209, 1388, 1387, 0, 0, 0, 0, 11719, 11749, 0, 
11748, 36954, 36955, 0, 0
25791, 8065, 8066, 859, 858, 11209, 11210, 1389, 1388, 0, 0, 0, 0, 11721, 11750, 0, 
11749, 36955, 36956, 0, 0
25792, 8066, 8067, 860, 859, 11210, 11211, 1390, 1389, 0, 0, 0, 0, 11723, 11751, 0, 
11750, 36956, 36957, 0, 0
25793, 8067, 8068, 861, 860, 11211, 11212, 1391, 1390, 0, 0, 0, 0, 11725, 11752, 0, 
11751, 36957, 36958, 0, 0
25794, 8068, 8069, 862, 861, 11212, 11213, 1392, 1391, 0, 0, 0, 0, 11727, 11753, 0, 
11752, 36958, 36959, 0, 0
25795, 8069, 8070, 863, 862, 11213, 11214, 1393, 1392, 0, 0, 0, 0, 11729, 11754, 0, 
11753, 36959, 36960, 0, 0
25796, 8070, 8071, 864, 863, 11214, 11215, 1394, 1393, 0, 0, 0, 0, 11731, 11755, 0, 
11754, 36960, 36961, 0, 0
25797, 8071, 990, 37, 864, 11215, 1477, 62, 1394, 0, 0, 0, 0, 11732, 1489, 0, 
11755, 36961, 10962, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume18
25798, 35, 911, 1397, 63, 69, 1684, 1878, 73, 0, 10918, 1420, 1395, 1707, 15229, 1901, 
1875, 1682, 13481, 15206, 1874
25799, 911, 912, 1398, 1397, 1684, 1685, 1879, 1878, 0, 10919, 1421, 10918, 1708, 15230, 1902, 
15229, 13481, 13482, 15207, 15206
25800, 912, 913, 1399, 1398, 1685, 1686, 1880, 1879, 0, 10920, 1422, 10919, 1709, 15231, 1903, 
15230, 13482, 13483, 15208, 15207
25801, 913, 914, 1400, 1399, 1686, 1687, 1881, 1880, 0, 10921, 1423, 10920, 1710, 15232, 1904, 
15231, 13483, 13484, 15209, 15208
25802, 914, 915, 1401, 1400, 1687, 1688, 1882, 1881, 0, 10922, 1424, 10921, 1711, 15233, 1905, 
15232, 13484, 13485, 15210, 15209
25803, 915, 916, 1402, 1401, 1688, 1689, 1883, 1882, 0, 10923, 1425, 10922, 1712, 15234, 1906, 
15233, 13485, 13486, 15211, 15210
25804, 916, 917, 1403, 1402, 1689, 1690, 1884, 1883, 0, 10924, 1426, 10923, 1713, 15235, 1907, 
15234, 13486, 13487, 15212, 15211
25805, 917, 918, 1404, 1403, 1690, 1691, 1885, 1884, 0, 10925, 1427, 10924, 1714, 15236, 1908, 
15235, 13487, 13488, 15213, 15212
25806, 918, 919, 1405, 1404, 1691, 1692, 1886, 1885, 0, 10926, 1428, 10925, 1715, 15237, 1909, 
15236, 13488, 13489, 15214, 15213
25807, 919, 920, 1406, 1405, 1692, 1693, 1887, 1886, 0, 10927, 1429, 10926, 1716, 15238, 1910, 
15237, 13489, 13490, 15215, 15214
25808, 920, 921, 1407, 1406, 1693, 1694, 1888, 1887, 0, 10928, 1430, 10927, 1717, 15239, 1911, 
15238, 13490, 13491, 15216, 15215
25809, 921, 922, 1408, 1407, 1694, 1695, 1889, 1888, 0, 10929, 1431, 10928, 1718, 15240, 1912, 
15239, 13491, 13492, 15217, 15216
25810, 922, 923, 1409, 1408, 1695, 1696, 1890, 1889, 0, 10930, 1432, 10929, 1719, 15241, 1913, 
15240, 13492, 13493, 15218, 15217
25811, 923, 924, 1410, 1409, 1696, 1697, 1891, 1890, 0, 10931, 1433, 10930, 1720, 15242, 1914, 
15241, 13493, 13494, 15219, 15218
25812, 924, 925, 1411, 1410, 1697, 1698, 1892, 1891, 0, 10932, 1434, 10931, 1721, 15243, 1915, 
15242, 13494, 13495, 15220, 15219
25813, 925, 926, 1412, 1411, 1698, 1699, 1893, 1892, 0, 10933, 1435, 10932, 1722, 15244, 1916, 
15243, 13495, 13496, 15221, 15220
25814, 926, 927, 1413, 1412, 1699, 1700, 1894, 1893, 0, 10934, 1436, 10933, 1723, 15245, 1917, 
15244, 13496, 13497, 15222, 15221
25815, 927, 928, 1414, 1413, 1700, 1701, 1895, 1894, 0, 10935, 1437, 10934, 1724, 15246, 1918, 
15245, 13497, 13498, 15223, 15222
25816, 928, 929, 1415, 1414, 1701, 1702, 1896, 1895, 0, 10936, 1438, 10935, 1725, 15247, 1919, 
15246, 13498, 13499, 15224, 15223
25817, 929, 930, 1416, 1415, 1702, 1703, 1897, 1896, 0, 10937, 1439, 10936, 1726, 15248, 1920, 
15247, 13499, 13500, 15225, 15224
25818, 930, 931, 1417, 1416, 1703, 1704, 1898, 1897, 0, 10938, 1440, 10937, 1727, 15249, 1921, 
15248, 13500, 13501, 15226, 15225
25819, 931, 932, 1418, 1417, 1704, 1705, 1899, 1898, 0, 10939, 1441, 10938, 1728, 15250, 1922, 
15249, 13501, 13502, 15227, 15226
25820, 932, 933, 1419, 1418, 1705, 1706, 1900, 1899, 0, 10940, 1442, 10939, 1729, 15251, 1923, 
15250, 13502, 13503, 15228, 15227
25821, 933, 39, 64, 1419, 1706, 70, 74, 1900, 0, 1396, 1443, 10940, 1730, 1877, 1924, 
15251, 13503, 1683, 1876, 15228
*ELEMENT, type=C3D20, ELSET=Volume19
25822, 9, 310, 1279, 59, 65, 1492, 1929, 75, 0, 10080, 1302, 1277, 1515, 15275, 1952, 
1926, 1490, 11756, 15252, 1925
25823, 310, 311, 1280, 1279, 1492, 1493, 1930, 1929, 0, 10081, 1303, 10080, 1516, 15276, 1953, 
15275, 11756, 11757, 15253, 15252
25824, 311, 312, 1281, 1280, 1493, 1494, 1931, 1930, 0, 10082, 1304, 10081, 1517, 15277, 1954, 
15276, 11757, 11758, 15254, 15253
25825, 312, 313, 1282, 1281, 1494, 1495, 1932, 1931, 0, 10083, 1305, 10082, 1518, 15278, 1955, 
15277, 11758, 11759, 15255, 15254
25826, 313, 314, 1283, 1282, 1495, 1496, 1933, 1932, 0, 10084, 1306, 10083, 1519, 15279, 1956, 
15278, 11759, 11760, 15256, 15255
25827, 314, 315, 1284, 1283, 1496, 1497, 1934, 1933, 0, 10085, 1307, 10084, 1520, 15280, 1957, 
15279, 11760, 11761, 15257, 15256
25828, 315, 316, 1285, 1284, 1497, 1498, 1935, 1934, 0, 10086, 1308, 10085, 1521, 15281, 1958, 
15280, 11761, 11762, 15258, 15257
25829, 316, 317, 1286, 1285, 1498, 1499, 1936, 1935, 0, 10087, 1309, 10086, 1522, 15282, 1959, 
15281, 11762, 11763, 15259, 15258
25830, 317, 318, 1287, 1286, 1499, 1500, 1937, 1936, 0, 10088, 1310, 10087, 1523, 15283, 1960, 
15282, 11763, 11764, 15260, 15259
25831, 318, 319, 1288, 1287, 1500, 1501, 1938, 1937, 0, 10089, 1311, 10088, 1524, 15284, 1961, 
15283, 11764, 11765, 15261, 15260
25832, 319, 320, 1289, 1288, 1501, 1502, 1939, 1938, 0, 10090, 1312, 10089, 1525, 15285, 1962, 
15284, 11765, 11766, 15262, 15261
25833, 320, 321, 1290, 1289, 1502, 1503, 1940, 1939, 0, 10091, 1313, 10090, 1526, 15286, 1963, 
15285, 11766, 11767, 15263, 15262
25834, 321, 322, 1291, 1290, 1503, 1504, 1941, 1940, 0, 10092, 1314, 10091, 1527, 15287, 1964, 
15286, 11767, 11768, 15264, 15263
25835, 322, 323, 1292, 1291, 1504, 1505, 1942, 1941, 0, 10093, 1315, 10092, 1528, 15288, 1965, 
15287, 11768, 11769, 15265, 15264
25836, 323, 324, 1293, 1292, 1505, 1506, 1943, 1942, 0, 10094, 1316, 10093, 1529, 15289, 1966, 
15288, 11769, 11770, 15266, 15265
25837, 324, 325, 1294, 1293, 1506, 1507, 1944, 1943, 0, 10095, 1317, 10094, 1530, 15290, 1967, 
15289, 11770, 11771, 15267, 15266
25838, 325, 326, 1295, 1294, 1507, 1508, 1945, 1944, 0, 10096, 1318, 10095, 1531, 15291, 1968, 
15290, 11771, 11772, 15268, 15267
25839, 326, 327, 1296, 1295, 1508, 1509, 1946, 1945, 0, 10097, 1319, 10096, 1532, 15292, 1969, 
15291, 11772, 11773, 15269, 15268
25840, 327, 328, 1297, 1296, 1509, 1510, 1947, 1946, 0, 10098, 1320, 10097, 1533, 15293, 1970, 
15292, 11773, 11774, 15270, 15269
25841, 328, 329, 1298, 1297, 1510, 1511, 1948, 1947, 0, 10099, 1321, 10098, 1534, 15294, 1971, 
15293, 11774, 11775, 15271, 15270
25842, 329, 330, 1299, 1298, 1511, 1512, 1949, 1948, 0, 10100, 1322, 10099, 1535, 15295, 1972, 
15294, 11775, 11776, 15272, 15271
25843, 330, 331, 1300, 1299, 1512, 1513, 1950, 1949, 0, 10101, 1323, 10100, 1536, 15296, 1973, 
15295, 11776, 11777, 15273, 15272
25844, 331, 332, 1301, 1300, 1513, 1514, 1951, 1950, 0, 10102, 1324, 10101, 1537, 15297, 1974, 
15296, 11777, 11778, 15274, 15273
25845, 332, 13, 60, 1301, 1514, 66, 76, 1951, 0, 1278, 1325, 10102, 1538, 1928, 1975, 
15297, 11778, 1491, 1927, 15274
*ELEMENT, type=C3D20, ELSET=Volume20
25846, 22, 603, 5509, 542, 1985, 15840, 36962, 15298, 0, 0, 0, 0, 15885, 37975, 37976, 
15390, 1989, 15884, 37974, 15391
25847, 1985, 15840, 36962, 15298, 1986, 15841, 36963, 15299, 15885, 37975, 37976, 15390, 15887, 37978, 37979, 
15392, 1990, 15886, 37977, 15393
