9272, 1.6583333333333, 0.1, 0.35416666666667
9273, 1.6375, 0.1, 0.375
9274, 1.7, 0.1, 0.35416666666667
9275, 1.6791666666667, 0.1, 0.375
9276, 1.7416666666667, 0.1, 0.35416666666667
9277, 1.7208333333333, 0.1, 0.375
9278, 1.7833333333333, 0.1, 0.35416666666667
9279, 1.7625, 0.1, 0.375
9280, 1.825, 0.1, 0.35416666666667
9281, 1.8041666666667, 0.1, 0.375
9282, 1.8666666666667, 0.1, 0.35416666666667
9283, 1.8458333333333, 0.1, 0.375
9284, 1.9083333333333, 0.1, 0.35416666666667
9285, 1.8875, 0.1, 0.375
9286, 1.95, 0.1, 0.35416666666667
9287, 1.9291666666667, 0.1, 0.375
9288, 1.9916666666667, 0.1, 0.35416666666667
9289, 1.9708333333333, 0.1, 0.375
9290, 2.0333333333333, 0.1, 0.35416666666667
9291, 2.0125, 0.1, 0.375
9292, 2.075, 0.1, 0.35416666666667
9293, 2.0541666666667, 0.1, 0.375
9294, 2.1166666666667, 0.1, 0.35416666666667
9295, 2.0958333333333, 0.1, 0.375
9296, 2.1583333333333, 0.1, 0.35416666666667
9297, 2.1375, 0.1, 0.375
9298, 2.1791666666667, 0.1, 0.375
9299, 1.2416666666667, 0.1, 0.39583333333333
9300, 1.2208333333333, 0.1, 0.41666666666667
9301, 1.2833333333333, 0.1, 0.39583333333333
9302, 1.2625, 0.1, 0.41666666666667
9303, 1.325, 0.1, 0.39583333333333
9304, 1.3041666666667, 0.1, 0.41666666666667
9305, 1.3666666666667, 0.1, 0.39583333333333
9306, 1.3458333333333, 0.1, 0.41666666666667
9307, 1.4083333333333, 0.1, 0.39583333333333
9308, 1.3875, 0.1, 0.41666666666667
9309, 1.45, 0.1, 0.39583333333333
9310, 1.4291666666667, 0.1, 0.41666666666667
9311, 1.4916666666667, 0.1, 0.39583333333333
9312, 1.4708333333333, 0.1, 0.41666666666667
9313, 1.5333333333333, 0.1, 0.39583333333333
9314, 1.5125, 0.1, 0.41666666666667
9315, 1.575, 0.1, 0.39583333333333
9316, 1.5541666666667, 0.1, 0.41666666666667
9317, 1.6166666666667, 0.1, 0.39583333333333
9318, 1.5958333333333, 0.1, 0.41666666666667
9319, 1.6583333333333, 0.1, 0.39583333333333
9320, 1.6375, 0.1, 0.41666666666667
9321, 1.7, 0.1, 0.39583333333333
9322, 1.6791666666667, 0.1, 0.41666666666667
9323, 1.7416666666667, 0.1, 0.39583333333333
9324, 1.7208333333333, 0.1, 0.41666666666667
9325, 1.7833333333333, 0.1, 0.39583333333333
9326, 1.7625, 0.1, 0.41666666666667
9327, 1.825, 0.1, 0.39583333333333
9328, 1.8041666666667, 0.1, 0.41666666666667
9329, 1.8666666666667, 0.1, 0.39583333333333
9330, 1.8458333333333, 0.1, 0.41666666666667
9331, 1.9083333333333, 0.1, 0.39583333333333
9332, 1.8875, 0.1, 0.41666666666667
9333, 1.95, 0.1, 0.39583333333333
9334, 1.9291666666667, 0.1, 0.41666666666667
9335, 1.9916666666667, 0.1, 0.39583333333333
9336, 1.9708333333333, 0.1, 0.41666666666667
9337, 2.0333333333333, 0.1, 0.39583333333333
9338, 2.0125, 0.1, 0.41666666666667
9339, 2.075, 0.1, 0.39583333333333
9340, 2.0541666666667, 0.1, 0.41666666666667
9341, 2.1166666666667, 0.1, 0.39583333333333
9342, 2.0958333333333, 0.1, 0.41666666666667
9343, 2.1583333333333, 0.1, 0.39583333333333
9344, 2.1375, 0.1, 0.41666666666667
9345, 2.1791666666667, 0.1, 0.41666666666667
9346, 1.2416666666667, 0.1, 0.4375
9347, 1.2208333333333, 0.1, 0.45833333333333
9348, 1.2833333333333, 0.1, 0.4375
9349, 1.2625, 0.1, 0.45833333333333
9350, 1.325, 0.1, 0.4375
9351, 1.3041666666667, 0.1, 0.45833333333333
9352, 1.3666666666667, 0.1, 0.4375
9353, 1.3458333333333, 0.1, 0.45833333333333
9354, 1.4083333333333, 0.1, 0.4375
9355, 1.3875, 0.1, 0.45833333333333
9356, 1.45, 0.1, 0.4375
9357, 1.4291666666667, 0.1, 0.45833333333333
9358, 1.4916666666667, 0.1, 0.4375
9359, 1.4708333333333, 0.1, 0.45833333333333
9360, 1.5333333333333, 0.1, 0.4375
9361, 1.5125, 0.1, 0.45833333333333
9362, 1.575, 0.1, 0.4375
9363, 1.5541666666667, 0.1, 0.45833333333333
9364, 1.6166666666667, 0.1, 0.4375
9365, 1.5958333333333, 0.1, 0.45833333333333
9366, 1.6583333333333, 0.1, 0.4375
9367, 1.6375, 0.1, 0.45833333333333
9368, 1.7, 0.1, 0.4375
9369, 1.6791666666667, 0.1, 0.45833333333333
9370, 1.7416666666667, 0.1, 0.4375
9371, 1.7208333333333, 0.1, 0.45833333333333
9372, 1.7833333333333, 0.1, 0.4375
9373, 1.7625, 0.1, 0.45833333333333
9374, 1.825, 0.1, 0.4375
9375, 1.8041666666667, 0.1, 0.45833333333333
9376, 1.8666666666667, 0.1, 0.4375
9377, 1.8458333333333, 0.1, 0.45833333333333
9378, 1.9083333333333, 0.1, 0.4375
9379, 1.8875, 0.1, 0.45833333333333
9380, 1.95, 0.1, 0.4375
9381, 1.9291666666667, 0.1, 0.45833333333333
9382, 1.9916666666667, 0.1, 0.4375
9383, 1.9708333333333, 0.1, 0.45833333333333
9384, 2.0333333333333, 0.1, 0.4375
9385, 2.0125, 0.1, 0.45833333333333
9386, 2.075, 0.1, 0.4375
9387, 2.0541666666667, 0.1, 0.45833333333333
9388, 2.1166666666667, 0.1, 0.4375
9389, 2.0958333333333, 0.1, 0.45833333333333
9390, 2.1583333333333, 0.1, 0.4375
9391, 2.1375, 0.1, 0.45833333333333
9392, 2.1791666666667, 0.1, 0.45833333333333
9393, 1.2416666666667, 0.1, 0.47916666666667
9394, 1.2833333333333, 0.1, 0.47916666666667
9395, 1.325, 0.1, 0.47916666666667
9396, 1.3666666666667, 0.1, 0.47916666666667
9397, 1.4083333333333, 0.1, 0.47916666666667
9398, 1.45, 0.1, 0.47916666666667
9399, 1.4916666666667, 0.1, 0.47916666666667
9400, 1.5333333333333, 0.1, 0.47916666666667
9401, 1.575, 0.1, 0.47916666666667
9402, 1.6166666666667, 0.1, 0.47916666666667
9403, 1.6583333333333, 0.1, 0.47916666666667
9404, 1.7, 0.1, 0.47916666666667
9405, 1.7416666666667, 0.1, 0.47916666666667
9406, 1.7833333333333, 0.1, 0.47916666666667
9407, 1.825, 0.1, 0.47916666666667
9408, 1.8666666666667, 0.1, 0.47916666666667
9409, 1.9083333333333, 0.1, 0.47916666666667
9410, 1.95, 0.1, 0.47916666666667
9411, 1.9916666666667, 0.1, 0.47916666666667
9412, 2.0333333333333, 0.1, 0.47916666666667
9413, 2.075, 0.1, 0.47916666666667
9414, 2.1166666666667, 0.1, 0.47916666666667
9415, 2.1583333333333, 0.1, 0.47916666666667
9416, 1.2416666666667, 0.066666666666667, 0.5
9417, 1.2416666666667, 0.033333333333333, 0.5
9418, 1.2833333333333, 0.066666666666667, 0.5
9419, 1.2833333333333, 0.033333333333333, 0.5
9420, 1.325, 0.066666666666667, 0.5
9421, 1.325, 0.033333333333333, 0.5
9422, 1.3666666666667, 0.066666666666667, 0.5
9423, 1.3666666666667, 0.033333333333333, 0.5
9424, 1.4083333333333, 0.066666666666667, 0.5
9425, 1.4083333333333, 0.033333333333333, 0.5
9426, 1.45, 0.066666666666667, 0.5
9427, 1.45, 0.033333333333333, 0.5
9428, 1.4916666666667, 0.066666666666667, 0.5
9429, 1.4916666666667, 0.033333333333333, 0.5
9430, 1.5333333333333, 0.066666666666667, 0.5
9431, 1.5333333333333, 0.033333333333333, 0.5
9432, 1.575, 0.066666666666667, 0.5
9433, 1.575, 0.033333333333333, 0.5
9434, 1.6166666666667, 0.066666666666667, 0.5
9435, 1.6166666666667, 0.033333333333333, 0.5
9436, 1.6583333333333, 0.066666666666667, 0.5
9437, 1.6583333333333, 0.033333333333333, 0.5
9438, 1.7, 0.066666666666667, 0.5
9439, 1.7, 0.033333333333333, 0.5
9440, 1.7416666666667, 0.066666666666667, 0.5
9441, 1.7416666666667, 0.033333333333333, 0.5
9442, 1.7833333333333, 0.066666666666667, 0.5
9443, 1.7833333333333, 0.033333333333333, 0.5
9444, 1.825, 0.066666666666667, 0.5
9445, 1.825, 0.033333333333333, 0.5
9446, 1.8666666666667, 0.066666666666667, 0.5
9447, 1.8666666666667, 0.033333333333333, 0.5
9448, 1.9083333333333, 0.066666666666667, 0.5
9449, 1.9083333333333, 0.033333333333333, 0.5
9450, 1.95, 0.066666666666667, 0.5
9451, 1.95, 0.033333333333333, 0.5
9452, 1.9916666666667, 0.066666666666667, 0.5
9453, 1.9916666666667, 0.033333333333333, 0.5
9454, 2.0333333333333, 0.066666666666667, 0.5
9455, 2.0333333333333, 0.033333333333333, 0.5
9456, 2.075, 0.066666666666667, 0.5
9457, 2.075, 0.033333333333333, 0.5
9458, 2.1166666666667, 0.066666666666667, 0.5
9459, 2.1166666666667, 0.033333333333333, 0.5
9460, 2.1583333333333, 0.066666666666667, 0.5
9461, 2.1583333333333, 0.033333333333333, 0.5
9462, 1.2416666666667, 0.066666666666667, 0
9463, 1.2416666666667, 0.033333333333333, 0
9464, 1.2833333333333, 0.066666666666667, 0
9465, 1.2833333333333, 0.033333333333333, 0
9466, 1.325, 0.066666666666667, 0
9467, 1.325, 0.033333333333333, 0
9468, 1.3666666666667, 0.066666666666667, 0
9469, 1.3666666666667, 0.033333333333333, 0
9470, 1.4083333333333, 0.066666666666667, 0
9471, 1.4083333333333, 0.033333333333333, 0
9472, 1.45, 0.066666666666667, 0
9473, 1.45, 0.033333333333333, 0
9474, 1.4916666666667, 0.066666666666667, 0
9475, 1.4916666666667, 0.033333333333333, 0
9476, 1.5333333333333, 0.066666666666667, 0
9477, 1.5333333333333, 0.033333333333333, 0
9478, 1.575, 0.066666666666667, 0
9479, 1.575, 0.033333333333333, 0
9480, 1.6166666666667, 0.066666666666667, 0
9481, 1.6166666666667, 0.033333333333333, 0
9482, 1.6583333333333, 0.066666666666667, 0
9483, 1.6583333333333, 0.033333333333333, 0
9484, 1.7, 0.066666666666667, 0
9485, 1.7, 0.033333333333333, 0
9486, 1.7416666666667, 0.066666666666667, 0
9487, 1.7416666666667, 0.033333333333333, 0
9488, 1.7833333333333, 0.066666666666667, 0
9489, 1.7833333333333, 0.033333333333333, 0
9490, 1.825, 0.066666666666667, 0
9491, 1.825, 0.033333333333333, 0
9492, 1.8666666666667, 0.066666666666667, 0
9493, 1.8666666666667, 0.033333333333333, 0
9494, 1.9083333333333, 0.066666666666667, 0
9495, 1.9083333333333, 0.033333333333333, 0
9496, 1.95, 0.066666666666667, 0
9497, 1.95, 0.033333333333333, 0
9498, 1.9916666666667, 0.066666666666667, 0
9499, 1.9916666666667, 0.033333333333333, 0
9500, 2.0333333333333, 0.066666666666667, 0
9501, 2.0333333333333, 0.033333333333333, 0
9502, 2.075, 0.066666666666667, 0
9503, 2.075, 0.033333333333333, 0
9504, 2.1166666666667, 0.066666666666667, 0
9505, 2.1166666666667, 0.033333333333333, 0
9506, 2.1583333333333, 0.066666666666667, 0
9507, 2.1583333333333, 0.033333333333333, 0
9508, 1.2416666666667, 0.083333333333333, 0
9509, 1.2208333333333, 0.066666666666667, 0
9510, 1.2416666666667, 0.05, 0
9511, 1.2208333333333, 0.033333333333333, 0
9512, 1.2416666666667, 0.016666666666667, 0
9513, 1.2833333333333, 0.083333333333333, 0
9514, 1.2625, 0.066666666666667, 0
9515, 1.2833333333333, 0.05, 0
9516, 1.2625, 0.033333333333333, 0
9517, 1.2833333333333, 0.016666666666667, 0
9518, 1.325, 0.083333333333333, 0
9519, 1.3041666666667, 0.066666666666667, 0
9520, 1.325, 0.05, 0
9521, 1.3041666666667, 0.033333333333333, 0
9522, 1.325, 0.016666666666667, 0
9523, 1.3666666666667, 0.083333333333333, 0
9524, 1.3458333333333, 0.066666666666667, 0
9525, 1.3666666666667, 0.05, 0
9526, 1.3458333333333, 0.033333333333333, 0
9527, 1.3666666666667, 0.016666666666667, 0
9528, 1.4083333333333, 0.083333333333333, 0
9529, 1.3875, 0.066666666666667, 0
9530, 1.4083333333333, 0.05, 0
9531, 1.3875, 0.033333333333333, 0
9532, 1.4083333333333, 0.016666666666667, 0
9533, 1.45, 0.083333333333333, 0
9534, 1.4291666666667, 0.066666666666667, 0
9535, 1.45, 0.05, 0
9536, 1.4291666666667, 0.033333333333333, 0
9537, 1.45, 0.016666666666667, 0
9538, 1.4916666666667, 0.083333333333333, 0
9539, 1.4708333333333, 0.066666666666667, 0
9540, 1.4916666666667, 0.05, 0
9541, 1.4708333333333, 0.033333333333333, 0
9542, 1.4916666666667, 0.016666666666667, 0
9543, 1.5333333333333, 0.083333333333333, 0
9544, 1.5125, 0.066666666666667, 0
9545, 1.5333333333333, 0.05, 0
9546, 1.5125, 0.033333333333333, 0
9547, 1.5333333333333, 0.016666666666667, 0
9548, 1.575, 0.083333333333333, 0
9549, 1.5541666666667, 0.066666666666667, 0
9550, 1.575, 0.05, 0
9551, 1.5541666666667, 0.033333333333333, 0
9552, 1.575, 0.016666666666667, 0
9553, 1.6166666666667, 0.083333333333333, 0
9554, 1.5958333333333, 0.066666666666667, 0
9555, 1.6166666666667, 0.05, 0
9556, 1.5958333333333, 0.033333333333333, 0
9557, 1.6166666666667, 0.016666666666667, 0
9558, 1.6583333333333, 0.083333333333333, 0
9559, 1.6375, 0.066666666666667, 0
9560, 1.6583333333333, 0.05, 0
9561, 1.6375, 0.033333333333333, 0
9562, 1.6583333333333, 0.016666666666667, 0
9563, 1.7, 0.083333333333333, 0
9564, 1.6791666666667, 0.066666666666667, 0
9565, 1.7, 0.05, 0
9566, 1.6791666666667, 0.033333333333333, 0
9567, 1.7, 0.016666666666667, 0
9568, 1.7416666666667, 0.083333333333333, 0
9569, 1.7208333333333, 0.066666666666667, 0
9570, 1.7416666666667, 0.05, 0
9571, 1.7208333333333, 0.033333333333333, 0
9572, 1.7416666666667, 0.016666666666667, 0
9573, 1.7833333333333, 0.083333333333333, 0
9574, 1.7625, 0.066666666666667, 0
9575, 1.7833333333333, 0.05, 0
9576, 1.7625, 0.033333333333333, 0
9577, 1.7833333333333, 0.016666666666667, 0
9578, 1.825, 0.083333333333333, 0
9579, 1.8041666666667, 0.066666666666667, 0
9580, 1.825, 0.05, 0
9581, 1.8041666666667, 0.033333333333333, 0
9582, 1.825, 0.016666666666667, 0
9583, 1.8666666666667, 0.083333333333333, 0
9584, 1.8458333333333, 0.066666666666667, 0
9585, 1.8666666666667, 0.05, 0
9586, 1.8458333333333, 0.033333333333333, 0
9587, 1.8666666666667, 0.016666666666667, 0
9588, 1.9083333333333, 0.083333333333333, 0
9589, 1.8875, 0.066666666666667, 0
9590, 1.9083333333333, 0.05, 0
9591, 1.8875, 0.033333333333333, 0
9592, 1.9083333333333, 0.016666666666667, 0
9593, 1.95, 0.083333333333333, 0
9594, 1.9291666666667, 0.066666666666667, 0
9595, 1.95, 0.05, 0
9596, 1.9291666666667, 0.033333333333333, 0
9597, 1.95, 0.016666666666667, 0
9598, 1.9916666666667, 0.083333333333333, 0
9599, 1.9708333333333, 0.066666666666667, 0
9600, 1.9916666666667, 0.05, 0
9601, 1.9708333333333, 0.033333333333333, 0
9602, 1.9916666666667, 0.016666666666667, 0
9603, 2.0333333333333, 0.083333333333333, 0
9604, 2.0125, 0.066666666666667, 0
9605, 2.0333333333333, 0.05, 0
9606, 2.0125, 0.033333333333333, 0
9607, 2.0333333333333, 0.016666666666667, 0
9608, 2.075, 0.083333333333333, 0
9609, 2.0541666666667, 0.066666666666667, 0
9610, 2.075, 0.05, 0
9611, 2.0541666666667, 0.033333333333333, 0
9612, 2.075, 0.016666666666667, 0
9613, 2.1166666666667, 0.083333333333333, 0
9614, 2.0958333333333, 0.066666666666667, 0
9615, 2.1166666666667, 0.05, 0
9616, 2.0958333333333, 0.033333333333333, 0
9617, 2.1166666666667, 0.016666666666667, 0
9618, 2.1583333333333, 0.083333333333333, 0
9619, 2.1375, 0.066666666666667, 0
9620, 2.1583333333333, 0.05, 0
9621, 2.1375, 0.033333333333333, 0
9622, 2.1583333333333, 0.016666666666667, 0
9623, 2.1791666666667, 0.066666666666667, 0
9624, 2.1791666666667, 0.033333333333333, 0
9625, 1.2, 0.066666666666667, 0.041666666666667
9626, 1.2, 0.033333333333333, 0.041666666666667
9627, 1.2, 0.066666666666667, 0.083333333333333
9628, 1.2, 0.033333333333333, 0.083333333333333
9629, 1.2, 0.066666666666667, 0.125
9630, 1.2, 0.033333333333333, 0.125
9631, 1.2, 0.066666666666667, 0.16666666666667
9632, 1.2, 0.033333333333333, 0.16666666666667
9633, 1.2, 0.066666666666667, 0.20833333333333
9634, 1.2, 0.033333333333333, 0.20833333333333
9635, 1.2, 0.066666666666667, 0.25
9636, 1.2, 0.033333333333333, 0.25
9637, 1.2, 0.066666666666667, 0.29166666666667
9638, 1.2, 0.033333333333333, 0.29166666666667
9639, 1.2, 0.066666666666667, 0.33333333333333
9640, 1.2, 0.033333333333333, 0.33333333333333
9641, 1.2, 0.066666666666667, 0.375
9642, 1.2, 0.033333333333333, 0.375
9643, 1.2, 0.066666666666667, 0.41666666666667
9644, 1.2, 0.033333333333333, 0.41666666666667
9645, 1.2, 0.066666666666667, 0.45833333333333
9646, 1.2, 0.033333333333333, 0.45833333333333
9647, 1.2, 0.066666666666667, 0.020833333333333
9648, 1.2, 0.083333333333333, 0.041666666666667
9649, 1.2, 0.033333333333333, 0.020833333333333
9650, 1.2, 0.05, 0.041666666666667
9651, 1.2, 0.016666666666667, 0.041666666666667
9652, 1.2, 0.066666666666667, 0.0625
9653, 1.2, 0.083333333333333, 0.083333333333333
9654, 1.2, 0.033333333333333, 0.0625
9655, 1.2, 0.05, 0.083333333333333
9656, 1.2, 0.016666666666667, 0.083333333333333
9657, 1.2, 0.066666666666667, 0.10416666666667
9658, 1.2, 0.083333333333333, 0.125
9659, 1.2, 0.033333333333333, 0.10416666666667
9660, 1.2, 0.05, 0.125
9661, 1.2, 0.016666666666667, 0.125
9662, 1.2, 0.066666666666667, 0.14583333333333
9663, 1.2, 0.083333333333333, 0.16666666666667
9664, 1.2, 0.033333333333333, 0.14583333333333
9665, 1.2, 0.05, 0.16666666666667
9666, 1.2, 0.016666666666667, 0.16666666666667
9667, 1.2, 0.066666666666667, 0.1875
9668, 1.2, 0.083333333333333, 0.20833333333333
9669, 1.2, 0.033333333333333, 0.1875
9670, 1.2, 0.05, 0.20833333333333
9671, 1.2, 0.016666666666667, 0.20833333333333
9672, 1.2, 0.066666666666667, 0.22916666666667
9673, 1.2, 0.083333333333333, 0.25
9674, 1.2, 0.033333333333333, 0.22916666666667
9675, 1.2, 0.05, 0.25
9676, 1.2, 0.016666666666667, 0.25
9677, 1.2, 0.066666666666667, 0.27083333333333
9678, 1.2, 0.083333333333333, 0.29166666666667
9679, 1.2, 0.033333333333333, 0.27083333333333
9680, 1.2, 0.05, 0.29166666666667
9681, 1.2, 0.016666666666667, 0.29166666666667
9682, 1.2, 0.066666666666667, 0.3125
9683, 1.2, 0.083333333333333, 0.33333333333333
9684, 1.2, 0.033333333333333, 0.3125
9685, 1.2, 0.05, 0.33333333333333
9686, 1.2, 0.016666666666667, 0.33333333333333
9687, 1.2, 0.066666666666667, 0.35416666666667
9688, 1.2, 0.083333333333333, 0.375
9689, 1.2, 0.033333333333333, 0.35416666666667
9690, 1.2, 0.05, 0.375
9691, 1.2, 0.016666666666667, 0.375
9692, 1.2, 0.066666666666667, 0.39583333333333
9693, 1.2, 0.083333333333333, 0.41666666666667
9694, 1.2, 0.033333333333333, 0.39583333333333
9695, 1.2, 0.05, 0.41666666666667
9696, 1.2, 0.016666666666667, 0.41666666666667
9697, 1.2, 0.066666666666667, 0.4375
9698, 1.2, 0.083333333333333, 0.45833333333333
9699, 1.2, 0.033333333333333, 0.4375
9700, 1.2, 0.05, 0.45833333333333
9701, 1.2, 0.016666666666667, 0.45833333333333
9702, 1.2, 0.066666666666667, 0.47916666666667
9703, 1.2, 0.033333333333333, 0.47916666666667
9704, 2.2, 0.066666666666667, 0.041666666666667
9705, 2.2, 0.033333333333333, 0.041666666666667
9706, 2.2, 0.066666666666667, 0.083333333333333
9707, 2.2, 0.033333333333333, 0.083333333333333
9708, 2.2, 0.066666666666667, 0.125
9709, 2.2, 0.033333333333333, 0.125
9710, 2.2, 0.066666666666667, 0.16666666666667
9711, 2.2, 0.033333333333333, 0.16666666666667
9712, 2.2, 0.066666666666667, 0.20833333333333
9713, 2.2, 0.033333333333333, 0.20833333333333
9714, 2.2, 0.066666666666667, 0.25
9715, 2.2, 0.033333333333333, 0.25
9716, 2.2, 0.066666666666667, 0.29166666666667
9717, 2.2, 0.033333333333333, 0.29166666666667
9718, 2.2, 0.066666666666667, 0.33333333333333
9719, 2.2, 0.033333333333333, 0.33333333333333
9720, 2.2, 0.066666666666667, 0.375
9721, 2.2, 0.033333333333333, 0.375
9722, 2.2, 0.066666666666667, 0.41666666666667
9723, 2.2, 0.033333333333333, 0.41666666666667
9724, 2.2, 0.066666666666667, 0.45833333333333
9725, 2.2, 0.033333333333333, 0.45833333333333
9726, 2.2, 0.083333333333333, 0.041666666666667
9727, 2.2, 0.066666666666667, 0.020833333333333
9728, 2.2, 0.05, 0.041666666666667
9729, 2.2, 0.033333333333333, 0.020833333333333
9730, 2.2, 0.016666666666667, 0.041666666666667
9731, 2.2, 0.083333333333333, 0.083333333333333
9732, 2.2, 0.066666666666667, 0.0625
9733, 2.2, 0.05, 0.083333333333333
9734, 2.2, 0.033333333333333, 0.0625
9735, 2.2, 0.016666666666667, 0.083333333333333
9736, 2.2, 0.083333333333333, 0.125
9737, 2.2, 0.066666666666667, 0.10416666666667
9738, 2.2, 0.05, 0.125
9739, 2.2, 0.033333333333333, 0.10416666666667
9740, 2.2, 0.016666666666667, 0.125
9741, 2.2, 0.083333333333333, 0.16666666666667
9742, 2.2, 0.066666666666667, 0.14583333333333
9743, 2.2, 0.05, 0.16666666666667
9744, 2.2, 0.033333333333333, 0.14583333333333
9745, 2.2, 0.016666666666667, 0.16666666666667
9746, 2.2, 0.083333333333333, 0.20833333333333
9747, 2.2, 0.066666666666667, 0.1875
9748, 2.2, 0.05, 0.20833333333333
9749, 2.2, 0.033333333333333, 0.1875
9750, 2.2, 0.016666666666667, 0.20833333333333
9751, 2.2, 0.083333333333333, 0.25
9752, 2.2, 0.066666666666667, 0.22916666666667
9753, 2.2, 0.05, 0.25
9754, 2.2, 0.033333333333333, 0.22916666666667
9755, 2.2, 0.016666666666667, 0.25
9756, 2.2, 0.083333333333333, 0.29166666666667
9757, 2.2, 0.066666666666667, 0.27083333333333
9758, 2.2, 0.05, 0.29166666666667
9759, 2.2, 0.033333333333333, 0.27083333333333
9760, 2.2, 0.016666666666667, 0.29166666666667
9761, 2.2, 0.083333333333333, 0.33333333333333
9762, 2.2, 0.066666666666667, 0.3125
9763, 2.2, 0.05, 0.33333333333333
9764, 2.2, 0.033333333333333, 0.3125
9765, 2.2, 0.016666666666667, 0.33333333333333
9766, 2.2, 0.083333333333333, 0.375
9767, 2.2, 0.066666666666667, 0.35416666666667
9768, 2.2, 0.05, 0.375
9769, 2.2, 0.033333333333333, 0.35416666666667
9770, 2.2, 0.016666666666667, 0.375
9771, 2.2, 0.083333333333333, 0.41666666666667
9772, 2.2, 0.066666666666667, 0.39583333333333
9773, 2.2, 0.05, 0.41666666666667
9774, 2.2, 0.033333333333333, 0.39583333333333
9775, 2.2, 0.016666666666667, 0.41666666666667
9776, 2.2, 0.083333333333333, 0.45833333333333
9777, 2.2, 0.066666666666667, 0.4375
9778, 2.2, 0.05, 0.45833333333333
9779, 2.2, 0.033333333333333, 0.4375
9780, 2.2, 0.016666666666667, 0.45833333333333
9781, 2.2, 0.066666666666667, 0.47916666666667
9782, 2.2, 0.033333333333333, 0.47916666666667
9783, 1.2416666666667, 1.2490009027033e-16, 0.041666666666667
9784, 1.2833333333333, 1.2490009027033e-16, 0.041666666666667
9785, 1.325, 1.2490009027033e-16, 0.041666666666667
9786, 1.3666666666667, 1.2490009027033e-16, 0.041666666666667
9787, 1.4083333333333, 1.2490009027033e-16, 0.041666666666667
9788, 1.45, 1.2490009027033e-16, 0.041666666666667
9789, 1.4916666666667, 1.2490009027033e-16, 0.041666666666667
9790, 1.5333333333333, 1.2490009027033e-16, 0.041666666666667
9791, 1.575, 1.2490009027033e-16, 0.041666666666667
9792, 1.6166666666667, 1.2490009027033e-16, 0.041666666666667
9793, 1.6583333333333, 1.2490009027033e-16, 0.041666666666667
9794, 1.7, 1.2490009027033e-16, 0.041666666666667
9795, 1.7416666666667, 1.2490009027033e-16, 0.041666666666667
9796, 1.7833333333333, 1.2490009027033e-16, 0.041666666666667
9797, 1.825, 1.2490009027033e-16, 0.041666666666667
9798, 1.8666666666667, 1.2490009027033e-16, 0.041666666666667
9799, 1.9083333333333, 1.2490009027033e-16, 0.041666666666667
9800, 1.95, 1.2490009027033e-16, 0.041666666666667
9801, 1.9916666666667, 1.2490009027033e-16, 0.041666666666667
9802, 2.0333333333333, 1.2490009027033e-16, 0.041666666666667
9803, 2.075, 1.2490009027033e-16, 0.041666666666667
9804, 2.1166666666667, 1.2490009027033e-16, 0.041666666666667
9805, 2.1583333333333, 1.2490009027033e-16, 0.041666666666667
9806, 1.2416666666667, 1.2490009027033e-16, 0.083333333333333
9807, 1.2833333333333, 1.2490009027033e-16, 0.083333333333333
9808, 1.325, 1.2490009027033e-16, 0.083333333333333
9809, 1.3666666666667, 1.2490009027033e-16, 0.083333333333333
9810, 1.4083333333333, 1.2490009027033e-16, 0.083333333333333
9811, 1.45, 1.2490009027033e-16, 0.083333333333333
9812, 1.4916666666667, 1.2490009027033e-16, 0.083333333333333
9813, 1.5333333333333, 1.2490009027033e-16, 0.083333333333333
9814, 1.575, 1.2490009027033e-16, 0.083333333333333
9815, 1.6166666666667, 1.2490009027033e-16, 0.083333333333333
9816, 1.6583333333333, 1.2490009027033e-16, 0.083333333333333
9817, 1.7, 1.2490009027033e-16, 0.083333333333333
9818, 1.7416666666667, 1.2490009027033e-16, 0.083333333333333
9819, 1.7833333333333, 1.2490009027033e-16, 0.083333333333333
9820, 1.825, 1.2490009027033e-16, 0.083333333333333
9821, 1.8666666666667, 1.2490009027033e-16, 0.083333333333333
9822, 1.9083333333333, 1.2490009027033e-16, 0.083333333333333
9823, 1.95, 1.2490009027033e-16, 0.083333333333333
9824, 1.9916666666667, 1.2490009027033e-16, 0.083333333333333
9825, 2.0333333333333, 1.2490009027033e-16, 0.083333333333333
9826, 2.075, 1.2490009027033e-16, 0.083333333333333
9827, 2.1166666666667, 1.2490009027033e-16, 0.083333333333333
9828, 2.1583333333333, 1.2490009027033e-16, 0.083333333333333
9829, 1.2416666666667, 1.2490009027033e-16, 0.125
9830, 1.2833333333333, 1.2490009027033e-16, 0.125
9831, 1.325, 1.2490009027033e-16, 0.125
9832, 1.3666666666667, 1.2490009027033e-16, 0.125
9833, 1.4083333333333, 1.2490009027033e-16, 0.125
9834, 1.45, 1.2490009027033e-16, 0.125
9835, 1.4916666666667, 1.2490009027033e-16, 0.125
9836, 1.5333333333333, 1.2490009027033e-16, 0.125
9837, 1.575, 1.2490009027033e-16, 0.125
9838, 1.6166666666667, 1.2490009027033e-16, 0.125
9839, 1.6583333333333, 1.2490009027033e-16, 0.125
9840, 1.7, 1.2490009027033e-16, 0.125
9841, 1.7416666666667, 1.2490009027033e-16, 0.125
9842, 1.7833333333333, 1.2490009027033e-16, 0.125
9843, 1.825, 1.2490009027033e-16, 0.125
9844, 1.8666666666667, 1.2490009027033e-16, 0.125
9845, 1.9083333333333, 1.2490009027033e-16, 0.125
9846, 1.95, 1.2490009027033e-16, 0.125
9847, 1.9916666666667, 1.2490009027033e-16, 0.125
9848, 2.0333333333333, 1.2490009027033e-16, 0.125
9849, 2.075, 1.2490009027033e-16, 0.125
9850, 2.1166666666667, 1.2490009027033e-16, 0.125
9851, 2.1583333333333, 1.2490009027033e-16, 0.125
9852, 1.2416666666667, 1.2490009027033e-16, 0.16666666666667
9853, 1.2833333333333, 1.2490009027033e-16, 0.16666666666667
9854, 1.325, 1.2490009027033e-16, 0.16666666666667
9855, 1.3666666666667, 1.2490009027033e-16, 0.16666666666667
9856, 1.4083333333333, 1.2490009027033e-16, 0.16666666666667
9857, 1.45, 1.2490009027033e-16, 0.16666666666667
9858, 1.4916666666667, 1.2490009027033e-16, 0.16666666666667
9859, 1.5333333333333, 1.2490009027033e-16, 0.16666666666667
9860, 1.575, 1.2490009027033e-16, 0.16666666666667
9861, 1.6166666666667, 1.2490009027033e-16, 0.16666666666667
9862, 1.6583333333333, 1.2490009027033e-16, 0.16666666666667
9863, 1.7, 1.2490009027033e-16, 0.16666666666667
9864, 1.7416666666667, 1.2490009027033e-16, 0.16666666666667
9865, 1.7833333333333, 1.2490009027033e-16, 0.16666666666667
9866, 1.825, 1.2490009027033e-16, 0.16666666666667
9867, 1.8666666666667, 1.2490009027033e-16, 0.16666666666667
9868, 1.9083333333333, 1.2490009027033e-16, 0.16666666666667
9869, 1.95, 1.2490009027033e-16, 0.16666666666667
9870, 1.9916666666667, 1.2490009027033e-16, 0.16666666666667
9871, 2.0333333333333, 1.2490009027033e-16, 0.16666666666667
9872, 2.075, 1.2490009027033e-16, 0.16666666666667
9873, 2.1166666666667, 1.2490009027033e-16, 0.16666666666667
9874, 2.1583333333333, 1.2490009027033e-16, 0.16666666666667
9875, 1.2416666666667, 1.2490009027033e-16, 0.20833333333333
9876, 1.2833333333333, 1.2490009027033e-16, 0.20833333333333
9877, 1.325, 1.2490009027033e-16, 0.20833333333333
9878, 1.3666666666667, 1.2490009027033e-16, 0.20833333333333
9879, 1.4083333333333, 1.2490009027033e-16, 0.20833333333333
9880, 1.45, 1.2490009027033e-16, 0.20833333333333
9881, 1.4916666666667, 1.2490009027033e-16, 0.20833333333333
9882, 1.5333333333333, 1.2490009027033e-16, 0.20833333333333
9883, 1.575, 1.2490009027033e-16, 0.20833333333333
9884, 1.6166666666667, 1.2490009027033e-16, 0.20833333333333
9885, 1.6583333333333, 1.2490009027033e-16, 0.20833333333333
9886, 1.7, 1.2490009027033e-16, 0.20833333333333
9887, 1.7416666666667, 1.2490009027033e-16, 0.20833333333333
9888, 1.7833333333333, 1.2490009027033e-16, 0.20833333333333
9889, 1.825, 1.2490009027033e-16, 0.20833333333333
9890, 1.8666666666667, 1.2490009027033e-16, 0.20833333333333
9891, 1.9083333333333, 1.2490009027033e-16, 0.20833333333333
9892, 1.95, 1.2490009027033e-16, 0.20833333333333
9893, 1.9916666666667, 1.2490009027033e-16, 0.20833333333333
9894, 2.0333333333333, 1.2490009027033e-16, 0.20833333333333
9895, 2.075, 1.2490009027033e-16, 0.20833333333333
9896, 2.1166666666667, 1.2490009027033e-16, 0.20833333333333
9897, 2.1583333333333, 1.2490009027033e-16, 0.20833333333333
9898, 1.2416666666667, 1.2490009027033e-16, 0.25
9899, 1.2833333333333, 1.2490009027033e-16, 0.25
9900, 1.325, 1.2490009027033e-16, 0.25
9901, 1.3666666666667, 1.2490009027033e-16, 0.25
9902, 1.4083333333333, 1.2490009027033e-16, 0.25
9903, 1.45, 1.2490009027033e-16, 0.25
9904, 1.4916666666667, 1.2490009027033e-16, 0.25
9905, 1.5333333333333, 1.2490009027033e-16, 0.25
9906, 1.575, 1.2490009027033e-16, 0.25
9907, 1.6166666666667, 1.2490009027033e-16, 0.25
9908, 1.6583333333333, 1.2490009027033e-16, 0.25
9909, 1.7, 1.2490009027033e-16, 0.25
9910, 1.7416666666667, 1.2490009027033e-16, 0.25
9911, 1.7833333333333, 1.2490009027033e-16, 0.25
9912, 1.825, 1.2490009027033e-16, 0.25
9913, 1.8666666666667, 1.2490009027033e-16, 0.25
9914, 1.9083333333333, 1.2490009027033e-16, 0.25
9915, 1.95, 1.2490009027033e-16, 0.25
9916, 1.9916666666667, 1.2490009027033e-16, 0.25
9917, 2.0333333333333, 1.2490009027033e-16, 0.25
9918, 2.075, 1.2490009027033e-16, 0.25
9919, 2.1166666666667, 1.2490009027033e-16, 0.25
9920, 2.1583333333333, 1.2490009027033e-16, 0.25
9921, 1.2416666666667, 1.2490009027033e-16, 0.29166666666667
9922, 1.2833333333333, 1.2490009027033e-16, 0.29166666666667
9923, 1.325, 1.2490009027033e-16, 0.29166666666667
9924, 1.3666666666667, 1.2490009027033e-16, 0.29166666666667
9925, 1.4083333333333, 1.2490009027033e-16, 0.29166666666667
9926, 1.45, 1.2490009027033e-16, 0.29166666666667
9927, 1.4916666666667, 1.2490009027033e-16, 0.29166666666667
9928, 1.5333333333333, 1.2490009027033e-16, 0.29166666666667
9929, 1.575, 1.2490009027033e-16, 0.29166666666667
9930, 1.6166666666667, 1.2490009027033e-16, 0.29166666666667
9931, 1.6583333333333, 1.2490009027033e-16, 0.29166666666667
9932, 1.7, 1.2490009027033e-16, 0.29166666666667
9933, 1.7416666666667, 1.2490009027033e-16, 0.29166666666667
9934, 1.7833333333333, 1.2490009027033e-16, 0.29166666666667
9935, 1.825, 1.2490009027033e-16, 0.29166666666667
9936, 1.8666666666667, 1.2490009027033e-16, 0.29166666666667
9937, 1.9083333333333, 1.2490009027033e-16, 0.29166666666667
9938, 1.95, 1.2490009027033e-16, 0.29166666666667
9939, 1.9916666666667, 1.2490009027033e-16, 0.29166666666667
9940, 2.0333333333333, 1.2490009027033e-16, 0.29166666666667
9941, 2.075, 1.2490009027033e-16, 0.29166666666667
9942, 2.1166666666667, 1.2490009027033e-16, 0.29166666666667
9943, 2.1583333333333, 1.2490009027033e-16, 0.29166666666667
9944, 1.2416666666667, 1.2490009027033e-16, 0.33333333333333
9945, 1.2833333333333, 1.2490009027033e-16, 0.33333333333333
9946, 1.325, 1.2490009027033e-16, 0.33333333333333
9947, 1.3666666666667, 1.2490009027033e-16, 0.33333333333333
9948, 1.4083333333333, 1.2490009027033e-16, 0.33333333333333
9949, 1.45, 1.2490009027033e-16, 0.33333333333333
9950, 1.4916666666667, 1.2490009027033e-16, 0.33333333333333
9951, 1.5333333333333, 1.2490009027033e-16, 0.33333333333333
9952, 1.575, 1.2490009027033e-16, 0.33333333333333
9953, 1.6166666666667, 1.2490009027033e-16, 0.33333333333333
9954, 1.6583333333333, 1.2490009027033e-16, 0.33333333333333
9955, 1.7, 1.2490009027033e-16, 0.33333333333333
9956, 1.7416666666667, 1.2490009027033e-16, 0.33333333333333
9957, 1.7833333333333, 1.2490009027033e-16, 0.33333333333333
9958, 1.825, 1.2490009027033e-16, 0.33333333333333
9959, 1.8666666666667, 1.2490009027033e-16, 0.33333333333333
9960, 1.9083333333333, 1.2490009027033e-16, 0.33333333333333
9961, 1.95, 1.2490009027033e-16, 0.33333333333333
9962, 1.9916666666667, 1.2490009027033e-16, 0.33333333333333
9963, 2.0333333333333, 1.2490009027033e-16, 0.33333333333333
9964, 2.075, 1.2490009027033e-16, 0.33333333333333
9965, 2.1166666666667, 1.2490009027033e-16, 0.33333333333333
9966, 2.1583333333333, 1.2490009027033e-16, 0.33333333333333
9967, 1.2416666666667, 1.2490009027033e-16, 0.375
9968, 1.2833333333333, 1.2490009027033e-16, 0.375
9969, 1.325, 1.2490009027033e-16, 0.375
9970, 1.3666666666667, 1.2490009027033e-16, 0.375
9971, 1.4083333333333, 1.2490009027033e-16, 0.375
9972, 1.45, 1.2490009027033e-16, 0.375
9973, 1.4916666666667, 1.2490009027033e-16, 0.375
9974, 1.5333333333333, 1.2490009027033e-16, 0.375
9975, 1.575, 1.2490009027033e-16, 0.375
9976, 1.6166666666667, 1.2490009027033e-16, 0.375
9977, 1.6583333333333, 1.2490009027033e-16, 0.375
9978, 1.7, 1.2490009027033e-16, 0.375
9979, 1.7416666666667, 1.2490009027033e-16, 0.375
9980, 1.7833333333333, 1.2490009027033e-16, 0.375
9981, 1.825, 1.2490009027033e-16, 0.375
9982, 1.8666666666667, 1.2490009027033e-16, 0.375
9983, 1.9083333333333, 1.2490009027033e-16, 0.375
9984, 1.95, 1.2490009027033e-16, 0.375
9985, 1.9916666666667, 1.2490009027033e-16, 0.375
9986, 2.0333333333333, 1.2490009027033e-16, 0.375
9987, 2.075, 1.2490009027033e-16, 0.375
9988, 2.1166666666667, 1.2490009027033e-16, 0.375
9989, 2.1583333333333, 1.2490009027033e-16, 0.375
9990, 1.2416666666667, 1.2490009027033e-16, 0.41666666666667
9991, 1.2833333333333, 1.2490009027033e-16, 0.41666666666667
9992, 1.325, 1.2490009027033e-16, 0.41666666666667
9993, 1.3666666666667, 1.2490009027033e-16, 0.41666666666667
9994, 1.4083333333333, 1.2490009027033e-16, 0.41666666666667
9995, 1.45, 1.2490009027033e-16, 0.41666666666667
9996, 1.4916666666667, 1.2490009027033e-16, 0.41666666666667
9997, 1.5333333333333, 1.2490009027033e-16, 0.41666666666667
9998, 1.575, 1.2490009027033e-16, 0.41666666666667
9999, 1.6166666666667, 1.2490009027033e-16, 0.41666666666667
10000, 1.6583333333333, 1.2490009027033e-16, 0.41666666666667
10001, 1.7, 1.2490009027033e-16, 0.41666666666667
10002, 1.7416666666667, 1.2490009027033e-16, 0.41666666666667
10003, 1.7833333333333, 1.2490009027033e-16, 0.41666666666667
10004, 1.825, 1.2490009027033e-16, 0.41666666666667
10005, 1.8666666666667, 1.2490009027033e-16, 0.41666666666667
10006, 1.9083333333333, 1.2490009027033e-16, 0.41666666666667
10007, 1.95, 1.2490009027033e-16, 0.41666666666667
10008, 1.9916666666667, 1.2490009027033e-16, 0.41666666666667
10009, 2.0333333333333, 1.2490009027033e-16, 0.41666666666667
10010, 2.075, 1.2490009027033e-16, 0.41666666666667
10011, 2.1166666666667, 1.2490009027033e-16, 0.41666666666667
10012, 2.1583333333333, 1.2490009027033e-16, 0.41666666666667
10013, 1.2416666666667, 1.2490009027033e-16, 0.45833333333333
10014, 1.2833333333333, 1.2490009027033e-16, 0.45833333333333
10015, 1.325, 1.2490009027033e-16, 0.45833333333333
10016, 1.3666666666667, 1.2490009027033e-16, 0.45833333333333
10017, 1.4083333333333, 1.2490009027033e-16, 0.45833333333333
10018, 1.45, 1.2490009027033e-16, 0.45833333333333
10019, 1.4916666666667, 1.2490009027033e-16, 0.45833333333333
10020, 1.5333333333333, 1.2490009027033e-16, 0.45833333333333
10021, 1.575, 1.2490009027033e-16, 0.45833333333333
10022, 1.6166666666667, 1.2490009027033e-16, 0.45833333333333
10023, 1.6583333333333, 1.2490009027033e-16, 0.45833333333333
10024, 1.7, 1.2490009027033e-16, 0.45833333333333
10025, 1.7416666666667, 1.2490009027033e-16, 0.45833333333333
10026, 1.7833333333333, 1.2490009027033e-16, 0.45833333333333
10027, 1.825, 1.2490009027033e-16, 0.45833333333333
10028, 1.8666666666667, 1.2490009027033e-16, 0.45833333333333
10029, 1.9083333333333, 1.2490009027033e-16, 0.45833333333333
10030, 1.95, 1.2490009027033e-16, 0.45833333333333
10031, 1.9916666666667, 1.2490009027033e-16, 0.45833333333333
10032, 2.0333333333333, 1.2490009027033e-16, 0.45833333333333
10033, 2.075, 1.2490009027033e-16, 0.45833333333333
10034, 2.1166666666667, 1.2490009027033e-16, 0.45833333333333
10035, 2.1583333333333, 1.2490009027033e-16, 0.45833333333333
55608, 2.25, 0.066666666666667, 0
55609, 2.25, 0.033333333333333, 0
55610, 2.25, 0.1, 0.041666666666667
55611, 2.25, 0.1, 0.083333333333333
55612, 2.25, 0.1, 0.125
55613, 2.25, 0.1, 0.16666666666667
55614, 2.25, 0.1, 0.20833333333333
55615, 2.25, 0.1, 0.25
55616, 2.25, 0.1, 0.29166666666667
55617, 2.25, 0.1, 0.33333333333333
55618, 2.25, 0.1, 0.375
55619, 2.25, 0.1, 0.41666666666667
55620, 2.25, 0.1, 0.45833333333333
10036, 2.3, 0.066666666666667, 0.041666666666667
10037, 2.3, 0.033333333333333, 0.041666666666667
10038, 2.3, 0.066666666666667, 0.083333333333333
10039, 2.3, 0.033333333333333, 0.083333333333333
10040, 2.3, 0.066666666666667, 0.125
10041, 2.3, 0.033333333333333, 0.125
10042, 2.3, 0.066666666666667, 0.16666666666667
10043, 2.3, 0.033333333333333, 0.16666666666667
10044, 2.3, 0.066666666666667, 0.20833333333333
10045, 2.3, 0.033333333333333, 0.20833333333333
10046, 2.3, 0.066666666666667, 0.25
10047, 2.3, 0.033333333333333, 0.25
10048, 2.3, 0.066666666666667, 0.29166666666667
10049, 2.3, 0.033333333333333, 0.29166666666667
10050, 2.3, 0.066666666666667, 0.33333333333333
10051, 2.3, 0.033333333333333, 0.33333333333333
10052, 2.3, 0.066666666666667, 0.375
10053, 2.3, 0.033333333333333, 0.375
10054, 2.3, 0.066666666666667, 0.41666666666667
10055, 2.3, 0.033333333333333, 0.41666666666667
10056, 2.3, 0.066666666666667, 0.45833333333333
10057, 2.3, 0.033333333333333, 0.45833333333333
55621, -0.05, 0.1, 0.041666666666667
55622, -0.05, 0.1, 0.083333333333333
55623, -0.05, 0.1, 0.125
55624, -0.05, 0.1, 0.16666666666667
55625, -0.05, 0.1, 0.20833333333333
55626, -0.05, 0.1, 0.25
55627, -0.05, 0.1, 0.29166666666667
55628, -0.05, 0.1, 0.33333333333333
55629, -0.05, 0.1, 0.375
55630, -0.05, 0.1, 0.41666666666667
55631, -0.05, 0.1, 0.45833333333333
55632, -0.05, 0.033333333333333, 0
55633, -0.05, 0.066666666666667, 0
10058, -0.1, 0.033333333333333, 0.041666666666667
10059, -0.1, 0.066666666666667, 0.041666666666667
10060, -0.1, 0.033333333333333, 0.083333333333333
10061, -0.1, 0.066666666666667, 0.083333333333333
10062, -0.1, 0.033333333333333, 0.125
10063, -0.1, 0.066666666666667, 0.125
10064, -0.1, 0.033333333333333, 0.16666666666667
10065, -0.1, 0.066666666666667, 0.16666666666667
10066, -0.1, 0.033333333333333, 0.20833333333333
10067, -0.1, 0.066666666666667, 0.20833333333333
10068, -0.1, 0.033333333333333, 0.25
10069, -0.1, 0.066666666666667, 0.25
10070, -0.1, 0.033333333333333, 0.29166666666667
10071, -0.1, 0.066666666666667, 0.29166666666667
10072, -0.1, 0.033333333333333, 0.33333333333333
10073, -0.1, 0.066666666666667, 0.33333333333333
10074, -0.1, 0.033333333333333, 0.375
10075, -0.1, 0.066666666666667, 0.375
10076, -0.1, 0.033333333333333, 0.41666666666667
10077, -0.1, 0.066666666666667, 0.41666666666667
10078, -0.1, 0.033333333333333, 0.45833333333333
10079, -0.1, 0.066666666666667, 0.45833333333333
10080, 1.025, 0.2, 0
10081, 1.025, 0.25, 0
10082, 1.025, 0.3, 0
10083, 1.025, 0.35, 0
10084, 1.025, 0.4, 0
10085, 1.025, 0.45, 0
10086, 1.025, 0.5, 0
10087, 1.025, 0.55, 0
10088, 1.025, 0.6, 0
10089, 1.025, 0.65, 0
10090, 1.025, 0.7, 0
10091, 1.025, 0.75, 0
10092, 1.025, 0.8, 0
10093, 1.025, 0.85, 0
10094, 1.025, 0.9, 0
10095, 1.025, 0.95, 0
10096, 1.025, 1, 0
10097, 1.025, 1.05, 0
10098, 1.025, 1.1, 0
10099, 1.025, 1.15, 0
10100, 1.025, 1.2, 0
10101, 1.025, 1.25, 0
10102, 1.025, 1.3, 0
10103, 1.025, 0.15, 0.041666666666667
10104, 1.025, 0.15, 0.083333333333333
10105, 1.025, 0.15, 0.125
10106, 1.025, 0.15, 0.16666666666667
10107, 1.025, 0.15, 0.20833333333333
10108, 1.025, 0.15, 0.25
10109, 1.025, 0.15, 0.29166666666667
10110, 1.025, 0.15, 0.33333333333333
10111, 1.025, 0.15, 0.375
10112, 1.025, 0.15, 0.41666666666667
10113, 1.025, 0.15, 0.45833333333333
10114, 1.025, 1.35, 0.041666666666667
10115, 1.025, 1.35, 0.083333333333333
10116, 1.025, 1.35, 0.125
10117, 1.025, 1.35, 0.16666666666667
10118, 1.025, 1.35, 0.20833333333333
10119, 1.025, 1.35, 0.25
10120, 1.025, 1.35, 0.29166666666667
10121, 1.025, 1.35, 0.33333333333333
10122, 1.025, 1.35, 0.375
10123, 1.025, 1.35, 0.41666666666667
10124, 1.025, 1.35, 0.45833333333333
10125, 1.05, 0.2, 0.041666666666667
10126, 1.05, 0.25, 0.041666666666667
10127, 1.05, 0.3, 0.041666666666667
10128, 1.05, 0.35, 0.041666666666667
10129, 1.05, 0.4, 0.041666666666667
10130, 1.05, 0.45, 0.041666666666667
10131, 1.05, 0.5, 0.041666666666667
10132, 1.05, 0.55, 0.041666666666667
10133, 1.05, 0.6, 0.041666666666667
10134, 1.05, 0.65, 0.041666666666667
10135, 1.05, 0.7, 0.041666666666667
10136, 1.05, 0.75, 0.041666666666667
10137, 1.05, 0.8, 0.041666666666667
10138, 1.05, 0.85, 0.041666666666667
10139, 1.05, 0.9, 0.041666666666667
10140, 1.05, 0.95, 0.041666666666667
10141, 1.05, 1, 0.041666666666667
10142, 1.05, 1.05, 0.041666666666667
10143, 1.05, 1.1, 0.041666666666667
10144, 1.05, 1.15, 0.041666666666667
10145, 1.05, 1.2, 0.041666666666667
10146, 1.05, 1.25, 0.041666666666667
10147, 1.05, 1.3, 0.041666666666667
10148, 1.05, 0.2, 0.083333333333333
10149, 1.05, 0.25, 0.083333333333333
10150, 1.05, 0.3, 0.083333333333333
10151, 1.05, 0.35, 0.083333333333333
10152, 1.05, 0.4, 0.083333333333333
10153, 1.05, 0.45, 0.083333333333333
10154, 1.05, 0.5, 0.083333333333333
10155, 1.05, 0.55, 0.083333333333333
10156, 1.05, 0.6, 0.083333333333333
10157, 1.05, 0.65, 0.083333333333333
10158, 1.05, 0.7, 0.083333333333333
10159, 1.05, 0.75, 0.083333333333333
10160, 1.05, 0.8, 0.083333333333333
10161, 1.05, 0.85, 0.083333333333333
10162, 1.05, 0.9, 0.083333333333333
10163, 1.05, 0.95, 0.083333333333333
10164, 1.05, 1, 0.083333333333333
10165, 1.05, 1.05, 0.083333333333333
10166, 1.05, 1.1, 0.083333333333333
10167, 1.05, 1.15, 0.083333333333333
10168, 1.05, 1.2, 0.083333333333333
10169, 1.05, 1.25, 0.083333333333333
10170, 1.05, 1.3, 0.083333333333333
10171, 1.05, 0.2, 0.125
10172, 1.05, 0.25, 0.125
10173, 1.05, 0.3, 0.125
10174, 1.05, 0.35, 0.125
10175, 1.05, 0.4, 0.125
10176, 1.05, 0.45, 0.125
10177, 1.05, 0.5, 0.125
10178, 1.05, 0.55, 0.125
10179, 1.05, 0.6, 0.125
10180, 1.05, 0.65, 0.125
10181, 1.05, 0.7, 0.125
10182, 1.05, 0.75, 0.125
10183, 1.05, 0.8, 0.125
10184, 1.05, 0.85, 0.125
10185, 1.05, 0.9, 0.125
10186, 1.05, 0.95, 0.125
10187, 1.05, 1, 0.125
10188, 1.05, 1.05, 0.125
10189, 1.05, 1.1, 0.125
10190, 1.05, 1.15, 0.125
10191, 1.05, 1.2, 0.125
10192, 1.05, 1.25, 0.125
10193, 1.05, 1.3, 0.125
10194, 1.05, 0.2, 0.16666666666667
10195, 1.05, 0.25, 0.16666666666667
10196, 1.05, 0.3, 0.16666666666667
10197, 1.05, 0.35, 0.16666666666667
10198, 1.05, 0.4, 0.16666666666667
10199, 1.05, 0.45, 0.16666666666667
10200, 1.05, 0.5, 0.16666666666667
10201, 1.05, 0.55, 0.16666666666667
10202, 1.05, 0.6, 0.16666666666667
10203, 1.05, 0.65, 0.16666666666667
10204, 1.05, 0.7, 0.16666666666667
10205, 1.05, 0.75, 0.16666666666667
10206, 1.05, 0.8, 0.16666666666667
10207, 1.05, 0.85, 0.16666666666667
10208, 1.05, 0.9, 0.16666666666667
10209, 1.05, 0.95, 0.16666666666667
10210, 1.05, 1, 0.16666666666667
10211, 1.05, 1.05, 0.16666666666667
10212, 1.05, 1.1, 0.16666666666667
10213, 1.05, 1.15, 0.16666666666667
10214, 1.05, 1.2, 0.16666666666667
10215, 1.05, 1.25, 0.16666666666667
10216, 1.05, 1.3, 0.16666666666667
10217, 1.05, 0.2, 0.20833333333333
10218, 1.05, 0.25, 0.20833333333333
10219, 1.05, 0.3, 0.20833333333333
10220, 1.05, 0.35, 0.20833333333333
10221, 1.05, 0.4, 0.20833333333333
10222, 1.05, 0.45, 0.20833333333333
10223, 1.05, 0.5, 0.20833333333333
10224, 1.05, 0.55, 0.20833333333333
10225, 1.05, 0.6, 0.20833333333333
10226, 1.05, 0.65, 0.20833333333333
10227, 1.05, 0.7, 0.20833333333333
10228, 1.05, 0.75, 0.20833333333333
10229, 1.05, 0.8, 0.20833333333333
10230, 1.05, 0.85, 0.20833333333333
10231, 1.05, 0.9, 0.20833333333333
10232, 1.05, 0.95, 0.20833333333333
10233, 1.05, 1, 0.20833333333333
10234, 1.05, 1.05, 0.20833333333333
10235, 1.05, 1.1, 0.20833333333333
10236, 1.05, 1.15, 0.20833333333333
10237, 1.05, 1.2, 0.20833333333333
10238, 1.05, 1.25, 0.20833333333333
10239, 1.05, 1.3, 0.20833333333333
10240, 1.05, 0.2, 0.25
10241, 1.05, 0.25, 0.25
10242, 1.05, 0.3, 0.25
10243, 1.05, 0.35, 0.25
10244, 1.05, 0.4, 0.25
10245, 1.05, 0.45, 0.25
10246, 1.05, 0.5, 0.25
10247, 1.05, 0.55, 0.25
10248, 1.05, 0.6, 0.25
10249, 1.05, 0.65, 0.25
10250, 1.05, 0.7, 0.25
10251, 1.05, 0.75, 0.25
10252, 1.05, 0.8, 0.25
10253, 1.05, 0.85, 0.25
10254, 1.05, 0.9, 0.25
10255, 1.05, 0.95, 0.25
10256, 1.05, 1, 0.25
10257, 1.05, 1.05, 0.25
10258, 1.05, 1.1, 0.25
10259, 1.05, 1.15, 0.25
10260, 1.05, 1.2, 0.25
10261, 1.05, 1.25, 0.25
10262, 1.05, 1.3, 0.25
10263, 1.05, 0.2, 0.29166666666667
10264, 1.05, 0.25, 0.29166666666667
10265, 1.05, 0.3, 0.29166666666667
10266, 1.05, 0.35, 0.29166666666667
10267, 1.05, 0.4, 0.29166666666667
10268, 1.05, 0.45, 0.29166666666667
10269, 1.05, 0.5, 0.29166666666667
10270, 1.05, 0.55, 0.29166666666667
10271, 1.05, 0.6, 0.29166666666667
10272, 1.05, 0.65, 0.29166666666667
10273, 1.05, 0.7, 0.29166666666667
10274, 1.05, 0.75, 0.29166666666667
10275, 1.05, 0.8, 0.29166666666667
10276, 1.05, 0.85, 0.29166666666667
10277, 1.05, 0.9, 0.29166666666667
10278, 1.05, 0.95, 0.29166666666667
10279, 1.05, 1, 0.29166666666667
10280, 1.05, 1.05, 0.29166666666667
10281, 1.05, 1.1, 0.29166666666667
10282, 1.05, 1.15, 0.29166666666667
10283, 1.05, 1.2, 0.29166666666667
10284, 1.05, 1.25, 0.29166666666667
10285, 1.05, 1.3, 0.29166666666667
10286, 1.05, 0.2, 0.33333333333333
10287, 1.05, 0.25, 0.33333333333333
10288, 1.05, 0.3, 0.33333333333333
10289, 1.05, 0.35, 0.33333333333333
10290, 1.05, 0.4, 0.33333333333333
10291, 1.05, 0.45, 0.33333333333333
10292, 1.05, 0.5, 0.33333333333333
10293, 1.05, 0.55, 0.33333333333333
10294, 1.05, 0.6, 0.33333333333333
10295, 1.05, 0.65, 0.33333333333333
10296, 1.05, 0.7, 0.33333333333333
10297, 1.05, 0.75, 0.33333333333333
10298, 1.05, 0.8, 0.33333333333333
10299, 1.05, 0.85, 0.33333333333333
10300, 1.05, 0.9, 0.33333333333333
10301, 1.05, 0.95, 0.33333333333333
10302, 1.05, 1, 0.33333333333333
10303, 1.05, 1.05, 0.33333333333333
10304, 1.05, 1.1, 0.33333333333333
10305, 1.05, 1.15, 0.33333333333333
10306, 1.05, 1.2, 0.33333333333333
10307, 1.05, 1.25, 0.33333333333333
10308, 1.05, 1.3, 0.33333333333333
10309, 1.05, 0.2, 0.375
10310, 1.05, 0.25, 0.375
10311, 1.05, 0.3, 0.375
10312, 1.05, 0.35, 0.375
10313, 1.05, 0.4, 0.375
10314, 1.05, 0.45, 0.375
10315, 1.05, 0.5, 0.375
10316, 1.05, 0.55, 0.375
10317, 1.05, 0.6, 0.375
10318, 1.05, 0.65, 0.375
10319, 1.05, 0.7, 0.375
10320, 1.05, 0.75, 0.375
10321, 1.05, 0.8, 0.375
10322, 1.05, 0.85, 0.375
10323, 1.05, 0.9, 0.375
10324, 1.05, 0.95, 0.375
10325, 1.05, 1, 0.375
10326, 1.05, 1.05, 0.375
10327, 1.05, 1.1, 0.375
10328, 1.05, 1.15, 0.375
10329, 1.05, 1.2, 0.375
10330, 1.05, 1.25, 0.375
10331, 1.05, 1.3, 0.375
10332, 1.05, 0.2, 0.41666666666667
10333, 1.05, 0.25, 0.41666666666667
10334, 1.05, 0.3, 0.41666666666667
10335, 1.05, 0.35, 0.41666666666667
10336, 1.05, 0.4, 0.41666666666667
10337, 1.05, 0.45, 0.41666666666667
10338, 1.05, 0.5, 0.41666666666667
10339, 1.05, 0.55, 0.41666666666667
10340, 1.05, 0.6, 0.41666666666667
10341, 1.05, 0.65, 0.41666666666667
10342, 1.05, 0.7, 0.41666666666667
10343, 1.05, 0.75, 0.41666666666667
10344, 1.05, 0.8, 0.41666666666667
10345, 1.05, 0.85, 0.41666666666667
10346, 1.05, 0.9, 0.41666666666667
10347, 1.05, 0.95, 0.41666666666667
10348, 1.05, 1, 0.41666666666667
10349, 1.05, 1.05, 0.41666666666667
10350, 1.05, 1.1, 0.41666666666667
10351, 1.05, 1.15, 0.41666666666667
10352, 1.05, 1.2, 0.41666666666667
10353, 1.05, 1.25, 0.41666666666667
10354, 1.05, 1.3, 0.41666666666667
10355, 1.05, 0.2, 0.45833333333333
10356, 1.05, 0.25, 0.45833333333333
10357, 1.05, 0.3, 0.45833333333333
10358, 1.05, 0.35, 0.45833333333333
10359, 1.05, 0.4, 0.45833333333333
10360, 1.05, 0.45, 0.45833333333333
10361, 1.05, 0.5, 0.45833333333333
10362, 1.05, 0.55, 0.45833333333333
10363, 1.05, 0.6, 0.45833333333333
10364, 1.05, 0.65, 0.45833333333333
10365, 1.05, 0.7, 0.45833333333333
10366, 1.05, 0.75, 0.45833333333333
10367, 1.05, 0.8, 0.45833333333333
10368, 1.05, 0.85, 0.45833333333333
10369, 1.05, 0.9, 0.45833333333333
10370, 1.05, 0.95, 0.45833333333333
10371, 1.05, 1, 0.45833333333333
10372, 1.05, 1.05, 0.45833333333333
10373, 1.05, 1.1, 0.45833333333333
10374, 1.05, 1.15, 0.45833333333333
10375, 1.05, 1.2, 0.45833333333333
10376, 1.05, 1.25, 0.45833333333333
10377, 1.05, 1.3, 0.45833333333333
10378, 1.05, 0.2, 0.020833333333333
10379, 1.05, 0.175, 0.041666666666667
10380, 1.05, 0.25, 0.020833333333333
10381, 1.05, 0.225, 0.041666666666667
10382, 1.05, 0.3, 0.020833333333333
10383, 1.05, 0.275, 0.041666666666667
10384, 1.05, 0.35, 0.020833333333333
10385, 1.05, 0.325, 0.041666666666667
10386, 1.05, 0.4, 0.020833333333333
10387, 1.05, 0.375, 0.041666666666667
10388, 1.05, 0.45, 0.020833333333333
10389, 1.05, 0.425, 0.041666666666667
10390, 1.05, 0.5, 0.020833333333333
10391, 1.05, 0.475, 0.041666666666667
10392, 1.05, 0.55, 0.020833333333333
10393, 1.05, 0.525, 0.041666666666667
10394, 1.05, 0.6, 0.020833333333333
10395, 1.05, 0.575, 0.041666666666667
10396, 1.05, 0.65, 0.020833333333333
10397, 1.05, 0.625, 0.041666666666667
10398, 1.05, 0.7, 0.020833333333333
10399, 1.05, 0.675, 0.041666666666667
10400, 1.05, 0.75, 0.020833333333333
10401, 1.05, 0.725, 0.041666666666667
10402, 1.05, 0.8, 0.020833333333333
10403, 1.05, 0.775, 0.041666666666667
10404, 1.05, 0.85, 0.020833333333333
10405, 1.05, 0.825, 0.041666666666667
10406, 1.05, 0.9, 0.020833333333333
10407, 1.05, 0.875, 0.041666666666667
10408, 1.05, 0.95, 0.020833333333333
10409, 1.05, 0.925, 0.041666666666667
10410, 1.05, 1, 0.020833333333333
10411, 1.05, 0.975, 0.041666666666667
10412, 1.05, 1.05, 0.020833333333333
10413, 1.05, 1.025, 0.041666666666667
10414, 1.05, 1.1, 0.020833333333333
10415, 1.05, 1.075, 0.041666666666667
10416, 1.05, 1.15, 0.020833333333333
10417, 1.05, 1.125, 0.041666666666667
10418, 1.05, 1.2, 0.020833333333333
10419, 1.05, 1.175, 0.041666666666667
10420, 1.05, 1.25, 0.020833333333333
10421, 1.05, 1.225, 0.041666666666667
10422, 1.05, 1.3, 0.020833333333333
10423, 1.05, 1.275, 0.041666666666667
10424, 1.05, 1.325, 0.041666666666667
10425, 1.05, 0.2, 0.0625
10426, 1.05, 0.175, 0.083333333333333
10427, 1.05, 0.25, 0.0625
10428, 1.05, 0.225, 0.083333333333333
10429, 1.05, 0.3, 0.0625
10430, 1.05, 0.275, 0.083333333333333
10431, 1.05, 0.35, 0.0625
10432, 1.05, 0.325, 0.083333333333333
10433, 1.05, 0.4, 0.0625
10434, 1.05, 0.375, 0.083333333333333
10435, 1.05, 0.45, 0.0625
10436, 1.05, 0.425, 0.083333333333333
10437, 1.05, 0.5, 0.0625
10438, 1.05, 0.475, 0.083333333333333
10439, 1.05, 0.55, 0.0625
10440, 1.05, 0.525, 0.083333333333333
10441, 1.05, 0.6, 0.0625
10442, 1.05, 0.575, 0.083333333333333
10443, 1.05, 0.65, 0.0625
10444, 1.05, 0.625, 0.083333333333333
10445, 1.05, 0.7, 0.0625
10446, 1.05, 0.675, 0.083333333333333
10447, 1.05, 0.75, 0.0625
10448, 1.05, 0.725, 0.083333333333333
10449, 1.05, 0.8, 0.0625
10450, 1.05, 0.775, 0.083333333333333
10451, 1.05, 0.85, 0.0625
10452, 1.05, 0.825, 0.083333333333333
10453, 1.05, 0.9, 0.0625
10454, 1.05, 0.875, 0.083333333333333
10455, 1.05, 0.95, 0.0625
10456, 1.05, 0.925, 0.083333333333333
10457, 1.05, 1, 0.0625
10458, 1.05, 0.975, 0.083333333333333
10459, 1.05, 1.05, 0.0625
10460, 1.05, 1.025, 0.083333333333333
10461, 1.05, 1.1, 0.0625
10462, 1.05, 1.075, 0.083333333333333
10463, 1.05, 1.15, 0.0625
10464, 1.05, 1.125, 0.083333333333333
10465, 1.05, 1.2, 0.0625
10466, 1.05, 1.175, 0.083333333333333
10467, 1.05, 1.25, 0.0625
10468, 1.05, 1.225, 0.083333333333333
10469, 1.05, 1.3, 0.0625
10470, 1.05, 1.275, 0.083333333333333
10471, 1.05, 1.325, 0.083333333333333
10472, 1.05, 0.2, 0.10416666666667
10473, 1.05, 0.175, 0.125
10474, 1.05, 0.25, 0.10416666666667
10475, 1.05, 0.225, 0.125
10476, 1.05, 0.3, 0.10416666666667
10477, 1.05, 0.275, 0.125
10478, 1.05, 0.35, 0.10416666666667
10479, 1.05, 0.325, 0.125
10480, 1.05, 0.4, 0.10416666666667
10481, 1.05, 0.375, 0.125
10482, 1.05, 0.45, 0.10416666666667
10483, 1.05, 0.425, 0.125
10484, 1.05, 0.5, 0.10416666666667
10485, 1.05, 0.475, 0.125
10486, 1.05, 0.55, 0.10416666666667
10487, 1.05, 0.525, 0.125
10488, 1.05, 0.6, 0.10416666666667
10489, 1.05, 0.575, 0.125
10490, 1.05, 0.65, 0.10416666666667
10491, 1.05, 0.625, 0.125
10492, 1.05, 0.7, 0.10416666666667
10493, 1.05, 0.675, 0.125
10494, 1.05, 0.75, 0.10416666666667
10495, 1.05, 0.725, 0.125
10496, 1.05, 0.8, 0.10416666666667
10497, 1.05, 0.775, 0.125
10498, 1.05, 0.85, 0.10416666666667
10499, 1.05, 0.825, 0.125
10500, 1.05, 0.9, 0.10416666666667
10501, 1.05, 0.875, 0.125
10502, 1.05, 0.95, 0.10416666666667
10503, 1.05, 0.925, 0.125
10504, 1.05, 1, 0.10416666666667
10505, 1.05, 0.975, 0.125
10506, 1.05, 1.05, 0.10416666666667
10507, 1.05, 1.025, 0.125
10508, 1.05, 1.1, 0.10416666666667
10509, 1.05, 1.075, 0.125
10510, 1.05, 1.15, 0.10416666666667
10511, 1.05, 1.125, 0.125
10512, 1.05, 1.2, 0.10416666666667
10513, 1.05, 1.175, 0.125
10514, 1.05, 1.25, 0.10416666666667
10515, 1.05, 1.225, 0.125
10516, 1.05, 1.3, 0.10416666666667
10517, 1.05, 1.275, 0.125
10518, 1.05, 1.325, 0.125
10519, 1.05, 0.2, 0.14583333333333
10520, 1.05, 0.175, 0.16666666666667
10521, 1.05, 0.25, 0.14583333333333
10522, 1.05, 0.225, 0.16666666666667
10523, 1.05, 0.3, 0.14583333333333
10524, 1.05, 0.275, 0.16666666666667
10525, 1.05, 0.35, 0.14583333333333
10526, 1.05, 0.325, 0.16666666666667
10527, 1.05, 0.4, 0.14583333333333
10528, 1.05, 0.375, 0.16666666666667
10529, 1.05, 0.45, 0.14583333333333
10530, 1.05, 0.425, 0.16666666666667
10531, 1.05, 0.5, 0.14583333333333
10532, 1.05, 0.475, 0.16666666666667
10533, 1.05, 0.55, 0.14583333333333
10534, 1.05, 0.525, 0.16666666666667
10535, 1.05, 0.6, 0.14583333333333
10536, 1.05, 0.575, 0.16666666666667
10537, 1.05, 0.65, 0.14583333333333
10538, 1.05, 0.625, 0.16666666666667
10539, 1.05, 0.7, 0.14583333333333
10540, 1.05, 0.675, 0.16666666666667
10541, 1.05, 0.75, 0.14583333333333
10542, 1.05, 0.725, 0.16666666666667
10543, 1.05, 0.8, 0.14583333333333
10544, 1.05, 0.775, 0.16666666666667
10545, 1.05, 0.85, 0.14583333333333
10546, 1.05, 0.825, 0.16666666666667
10547, 1.05, 0.9, 0.14583333333333
10548, 1.05, 0.875, 0.16666666666667
10549, 1.05, 0.95, 0.14583333333333
10550, 1.05, 0.925, 0.16666666666667
10551, 1.05, 1, 0.14583333333333
10552, 1.05, 0.975, 0.16666666666667
10553, 1.05, 1.05, 0.14583333333333
10554, 1.05, 1.025, 0.16666666666667
10555, 1.05, 1.1, 0.14583333333333
10556, 1.05, 1.075, 0.16666666666667
10557, 1.05, 1.15, 0.14583333333333
10558, 1.05, 1.125, 0.16666666666667
10559, 1.05, 1.2, 0.14583333333333
10560, 1.05, 1.175, 0.16666666666667
10561, 1.05, 1.25, 0.14583333333333
10562, 1.05, 1.225, 0.16666666666667
10563, 1.05, 1.3, 0.14583333333333
10564, 1.05, 1.275, 0.16666666666667
10565, 1.05, 1.325, 0.16666666666667
10566, 1.05, 0.2, 0.1875
10567, 1.05, 0.175, 0.20833333333333
10568, 1.05, 0.25, 0.1875
10569, 1.05, 0.225, 0.20833333333333
10570, 1.05, 0.3, 0.1875
10571, 1.05, 0.275, 0.20833333333333
10572, 1.05, 0.35, 0.1875
10573, 1.05, 0.325, 0.20833333333333
10574, 1.05, 0.4, 0.1875
10575, 1.05, 0.375, 0.20833333333333
10576, 1.05, 0.45, 0.1875
10577, 1.05, 0.425, 0.20833333333333
10578, 1.05, 0.5, 0.1875
10579, 1.05, 0.475, 0.20833333333333
10580, 1.05, 0.55, 0.1875
10581, 1.05, 0.525, 0.20833333333333
10582, 1.05, 0.6, 0.1875
10583, 1.05, 0.575, 0.20833333333333
10584, 1.05, 0.65, 0.1875
10585, 1.05, 0.625, 0.20833333333333
10586, 1.05, 0.7, 0.1875
10587, 1.05, 0.675, 0.20833333333333
10588, 1.05, 0.75, 0.1875
10589, 1.05, 0.725, 0.20833333333333
10590, 1.05, 0.8, 0.1875
10591, 1.05, 0.775, 0.20833333333333
10592, 1.05, 0.85, 0.1875
10593, 1.05, 0.825, 0.20833333333333
10594, 1.05, 0.9, 0.1875
10595, 1.05, 0.875, 0.20833333333333
10596, 1.05, 0.95, 0.1875
10597, 1.05, 0.925, 0.20833333333333
10598, 1.05, 1, 0.1875
10599, 1.05, 0.975, 0.20833333333333
10600, 1.05, 1.05, 0.1875
10601, 1.05, 1.025, 0.20833333333333
10602, 1.05, 1.1, 0.1875
10603, 1.05, 1.075, 0.20833333333333
10604, 1.05, 1.15, 0.1875
10605, 1.05, 1.125, 0.20833333333333
10606, 1.05, 1.2, 0.1875
10607, 1.05, 1.175, 0.20833333333333
10608, 1.05, 1.25, 0.1875
10609, 1.05, 1.225, 0.20833333333333
10610, 1.05, 1.3, 0.1875
10611, 1.05, 1.275, 0.20833333333333
10612, 1.05, 1.325, 0.20833333333333
10613, 1.05, 0.2, 0.22916666666667
10614, 1.05, 0.175, 0.25
10615, 1.05, 0.25, 0.22916666666667
10616, 1.05, 0.225, 0.25
10617, 1.05, 0.3, 0.22916666666667
10618, 1.05, 0.275, 0.25
10619, 1.05, 0.35, 0.22916666666667
10620, 1.05, 0.325, 0.25
10621, 1.05, 0.4, 0.22916666666667
10622, 1.05, 0.375, 0.25
10623, 1.05, 0.45, 0.22916666666667
10624, 1.05, 0.425, 0.25
10625, 1.05, 0.5, 0.22916666666667
10626, 1.05, 0.475, 0.25
10627, 1.05, 0.55, 0.22916666666667
10628, 1.05, 0.525, 0.25
10629, 1.05, 0.6, 0.22916666666667
10630, 1.05, 0.575, 0.25
10631, 1.05, 0.65, 0.22916666666667
10632, 1.05, 0.625, 0.25
10633, 1.05, 0.7, 0.22916666666667
10634, 1.05, 0.675, 0.25
10635, 1.05, 0.75, 0.22916666666667
10636, 1.05, 0.725, 0.25
10637, 1.05, 0.8, 0.22916666666667
10638, 1.05, 0.775, 0.25
10639, 1.05, 0.85, 0.22916666666667
10640, 1.05, 0.825, 0.25
10641, 1.05, 0.9, 0.22916666666667
10642, 1.05, 0.875, 0.25
10643, 1.05, 0.95, 0.22916666666667
10644, 1.05, 0.925, 0.25
10645, 1.05, 1, 0.22916666666667
10646, 1.05, 0.975, 0.25
10647, 1.05, 1.05, 0.22916666666667
10648, 1.05, 1.025, 0.25
10649, 1.05, 1.1, 0.22916666666667
10650, 1.05, 1.075, 0.25
10651, 1.05, 1.15, 0.22916666666667
10652, 1.05, 1.125, 0.25
10653, 1.05, 1.2, 0.22916666666667
10654, 1.05, 1.175, 0.25
10655, 1.05, 1.25, 0.22916666666667
10656, 1.05, 1.225, 0.25
10657, 1.05, 1.3, 0.22916666666667
10658, 1.05, 1.275, 0.25
10659, 1.05, 1.325, 0.25
10660, 1.05, 0.2, 0.27083333333333
10661, 1.05, 0.175, 0.29166666666667
10662, 1.05, 0.25, 0.27083333333333
10663, 1.05, 0.225, 0.29166666666667
10664, 1.05, 0.3, 0.27083333333333
10665, 1.05, 0.275, 0.29166666666667
10666, 1.05, 0.35, 0.27083333333333
10667, 1.05, 0.325, 0.29166666666667
10668, 1.05, 0.4, 0.27083333333333
10669, 1.05, 0.375, 0.29166666666667
10670, 1.05, 0.45, 0.27083333333333
10671, 1.05, 0.425, 0.29166666666667
10672, 1.05, 0.5, 0.27083333333333
10673, 1.05, 0.475, 0.29166666666667
10674, 1.05, 0.55, 0.27083333333333
10675, 1.05, 0.525, 0.29166666666667
10676, 1.05, 0.6, 0.27083333333333
10677, 1.05, 0.575, 0.29166666666667
10678, 1.05, 0.65, 0.27083333333333
10679, 1.05, 0.625, 0.29166666666667
10680, 1.05, 0.7, 0.27083333333333
10681, 1.05, 0.675, 0.29166666666667
10682, 1.05, 0.75, 0.27083333333333
10683, 1.05, 0.725, 0.29166666666667
10684, 1.05, 0.8, 0.27083333333333
10685, 1.05, 0.775, 0.29166666666667
10686, 1.05, 0.85, 0.27083333333333
10687, 1.05, 0.825, 0.29166666666667
10688, 1.05, 0.9, 0.27083333333333
10689, 1.05, 0.875, 0.29166666666667
10690, 1.05, 0.95, 0.27083333333333
10691, 1.05, 0.925, 0.29166666666667
10692, 1.05, 1, 0.27083333333333
10693, 1.05, 0.975, 0.29166666666667
10694, 1.05, 1.05, 0.27083333333333
10695, 1.05, 1.025, 0.29166666666667
10696, 1.05, 1.1, 0.27083333333333
10697, 1.05, 1.075, 0.29166666666667
10698, 1.05, 1.15, 0.27083333333333
10699, 1.05, 1.125, 0.29166666666667
10700, 1.05, 1.2, 0.27083333333333
10701, 1.05, 1.175, 0.29166666666667
10702, 1.05, 1.25, 0.27083333333333
10703, 1.05, 1.225, 0.29166666666667
10704, 1.05, 1.3, 0.27083333333333
10705, 1.05, 1.275, 0.29166666666667
10706, 1.05, 1.325, 0.29166666666667
10707, 1.05, 0.2, 0.3125
10708, 1.05, 0.175, 0.33333333333333
10709, 1.05, 0.25, 0.3125
10710, 1.05, 0.225, 0.33333333333333
10711, 1.05, 0.3, 0.3125
10712, 1.05, 0.275, 0.33333333333333
10713, 1.05, 0.35, 0.3125
10714, 1.05, 0.325, 0.33333333333333
10715, 1.05, 0.4, 0.3125
10716, 1.05, 0.375, 0.33333333333333
10717, 1.05, 0.45, 0.3125
10718, 1.05, 0.425, 0.33333333333333
10719, 1.05, 0.5, 0.3125
10720, 1.05, 0.475, 0.33333333333333
10721, 1.05, 0.55, 0.3125
10722, 1.05, 0.525, 0.33333333333333
10723, 1.05, 0.6, 0.3125
10724, 1.05, 0.575, 0.33333333333333
10725, 1.05, 0.65, 0.3125
10726, 1.05, 0.625, 0.33333333333333
10727, 1.05, 0.7, 0.3125
10728, 1.05, 0.675, 0.33333333333333
10729, 1.05, 0.75, 0.3125
10730, 1.05, 0.725, 0.33333333333333
10731, 1.05, 0.8, 0.3125
10732, 1.05, 0.775, 0.33333333333333
10733, 1.05, 0.85, 0.3125
10734, 1.05, 0.825, 0.33333333333333
10735, 1.05, 0.9, 0.3125
10736, 1.05, 0.875, 0.33333333333333
10737, 1.05, 0.95, 0.3125
10738, 1.05, 0.925, 0.33333333333333
10739, 1.05, 1, 0.3125
10740, 1.05, 0.975, 0.33333333333333
10741, 1.05, 1.05, 0.3125
10742, 1.05, 1.025, 0.33333333333333
10743, 1.05, 1.1, 0.3125
10744, 1.05, 1.075, 0.33333333333333
10745, 1.05, 1.15, 0.3125
10746, 1.05, 1.125, 0.33333333333333
10747, 1.05, 1.2, 0.3125
10748, 1.05, 1.175, 0.33333333333333
10749, 1.05, 1.25, 0.3125
10750, 1.05, 1.225, 0.33333333333333
10751, 1.05, 1.3, 0.3125
10752, 1.05, 1.275, 0.33333333333333
10753, 1.05, 1.325, 0.33333333333333
10754, 1.05, 0.2, 0.35416666666667
10755, 1.05, 0.175, 0.375
10756, 1.05, 0.25, 0.35416666666667
10757, 1.05, 0.225, 0.375
10758, 1.05, 0.3, 0.35416666666667
10759, 1.05, 0.275, 0.375
10760, 1.05, 0.35, 0.35416666666667
10761, 1.05, 0.325, 0.375
10762, 1.05, 0.4, 0.35416666666667
10763, 1.05, 0.375, 0.375
10764, 1.05, 0.45, 0.35416666666667
10765, 1.05, 0.425, 0.375
10766, 1.05, 0.5, 0.35416666666667
10767, 1.05, 0.475, 0.375
10768, 1.05, 0.55, 0.35416666666667
10769, 1.05, 0.525, 0.375
10770, 1.05, 0.6, 0.35416666666667
10771, 1.05, 0.575, 0.375
10772, 1.05, 0.65, 0.35416666666667
10773, 1.05, 0.625, 0.375
10774, 1.05, 0.7, 0.35416666666667
10775, 1.05, 0.675, 0.375
10776, 1.05, 0.75, 0.35416666666667
10777, 1.05, 0.725, 0.375
10778, 1.05, 0.8, 0.35416666666667
10779, 1.05, 0.775, 0.375
10780, 1.05, 0.85, 0.35416666666667
10781, 1.05, 0.825, 0.375
10782, 1.05, 0.9, 0.35416666666667
10783, 1.05, 0.875, 0.375
10784, 1.05, 0.95, 0.35416666666667
10785, 1.05, 0.925, 0.375
10786, 1.05, 1, 0.35416666666667
10787, 1.05, 0.975, 0.375
10788, 1.05, 1.05, 0.35416666666667
10789, 1.05, 1.025, 0.375
10790, 1.05, 1.1, 0.35416666666667
10791, 1.05, 1.075, 0.375
10792, 1.05, 1.15, 0.35416666666667
10793, 1.05, 1.125, 0.375
10794, 1.05, 1.2, 0.35416666666667
10795, 1.05, 1.175, 0.375
10796, 1.05, 1.25, 0.35416666666667
10797, 1.05, 1.225, 0.375
10798, 1.05, 1.3, 0.35416666666667
10799, 1.05, 1.275, 0.375
10800, 1.05, 1.325, 0.375
10801, 1.05, 0.2, 0.39583333333333
10802, 1.05, 0.175, 0.41666666666667
10803, 1.05, 0.25, 0.39583333333333
10804, 1.05, 0.225, 0.41666666666667
10805, 1.05, 0.3, 0.39583333333333
10806, 1.05, 0.275, 0.41666666666667
10807, 1.05, 0.35, 0.39583333333333
10808, 1.05, 0.325, 0.41666666666667
10809, 1.05, 0.4, 0.39583333333333
10810, 1.05, 0.375, 0.41666666666667
10811, 1.05, 0.45, 0.39583333333333
10812, 1.05, 0.425, 0.41666666666667
10813, 1.05, 0.5, 0.39583333333333
10814, 1.05, 0.475, 0.41666666666667
10815, 1.05, 0.55, 0.39583333333333
10816, 1.05, 0.525, 0.41666666666667
10817, 1.05, 0.6, 0.39583333333333
10818, 1.05, 0.575, 0.41666666666667
10819, 1.05, 0.65, 0.39583333333333
10820, 1.05, 0.625, 0.41666666666667
10821, 1.05, 0.7, 0.39583333333333
10822, 1.05, 0.675, 0.41666666666667
10823, 1.05, 0.75, 0.39583333333333
10824, 1.05, 0.725, 0.41666666666667
10825, 1.05, 0.8, 0.39583333333333
10826, 1.05, 0.775, 0.41666666666667
10827, 1.05, 0.85, 0.39583333333333
10828, 1.05, 0.825, 0.41666666666667
10829, 1.05, 0.9, 0.39583333333333
10830, 1.05, 0.875, 0.41666666666667
10831, 1.05, 0.95, 0.39583333333333
10832, 1.05, 0.925, 0.41666666666667
10833, 1.05, 1, 0.39583333333333
10834, 1.05, 0.975, 0.41666666666667
10835, 1.05, 1.05, 0.39583333333333
10836, 1.05, 1.025, 0.41666666666667
10837, 1.05, 1.1, 0.39583333333333
10838, 1.05, 1.075, 0.41666666666667
10839, 1.05, 1.15, 0.39583333333333
10840, 1.05, 1.125, 0.41666666666667
10841, 1.05, 1.2, 0.39583333333333
10842, 1.05, 1.175, 0.41666666666667
10843, 1.05, 1.25, 0.39583333333333
10844, 1.05, 1.225, 0.41666666666667
10845, 1.05, 1.3, 0.39583333333333
10846, 1.05, 1.275, 0.41666666666667
10847, 1.05, 1.325, 0.41666666666667
10848, 1.05, 0.2, 0.4375
10849, 1.05, 0.175, 0.45833333333333
10850, 1.05, 0.25, 0.4375
10851, 1.05, 0.225, 0.45833333333333
10852, 1.05, 0.3, 0.4375
10853, 1.05, 0.275, 0.45833333333333
10854, 1.05, 0.35, 0.4375
10855, 1.05, 0.325, 0.45833333333333
10856, 1.05, 0.4, 0.4375
10857, 1.05, 0.375, 0.45833333333333
10858, 1.05, 0.45, 0.4375
10859, 1.05, 0.425, 0.45833333333333
10860, 1.05, 0.5, 0.4375
10861, 1.05, 0.475, 0.45833333333333
10862, 1.05, 0.55, 0.4375
10863, 1.05, 0.525, 0.45833333333333
10864, 1.05, 0.6, 0.4375
10865, 1.05, 0.575, 0.45833333333333
10866, 1.05, 0.65, 0.4375
10867, 1.05, 0.625, 0.45833333333333
10868, 1.05, 0.7, 0.4375
10869, 1.05, 0.675, 0.45833333333333
10870, 1.05, 0.75, 0.4375
10871, 1.05, 0.725, 0.45833333333333
10872, 1.05, 0.8, 0.4375
10873, 1.05, 0.775, 0.45833333333333
10874, 1.05, 0.85, 0.4375
10875, 1.05, 0.825, 0.45833333333333
10876, 1.05, 0.9, 0.4375
10877, 1.05, 0.875, 0.45833333333333
10878, 1.05, 0.95, 0.4375
10879, 1.05, 0.925, 0.45833333333333
10880, 1.05, 1, 0.4375
10881, 1.05, 0.975, 0.45833333333333
10882, 1.05, 1.05, 0.4375
10883, 1.05, 1.025, 0.45833333333333
10884, 1.05, 1.1, 0.4375
10885, 1.05, 1.075, 0.45833333333333
10886, 1.05, 1.15, 0.4375
10887, 1.05, 1.125, 0.45833333333333
10888, 1.05, 1.2, 0.4375
10889, 1.05, 1.175, 0.45833333333333
10890, 1.05, 1.25, 0.4375
10891, 1.05, 1.225, 0.45833333333333
10892, 1.05, 1.3, 0.4375
10893, 1.05, 1.275, 0.45833333333333
10894, 1.05, 1.325, 0.45833333333333
10895, 1.05, 0.2, 0.47916666666667
10896, 1.05, 0.25, 0.47916666666667
10897, 1.05, 0.3, 0.47916666666667
10898, 1.05, 0.35, 0.47916666666667
10899, 1.05, 0.4, 0.47916666666667
10900, 1.05, 0.45, 0.47916666666667
10901, 1.05, 0.5, 0.47916666666667
10902, 1.05, 0.55, 0.47916666666667
10903, 1.05, 0.6, 0.47916666666667
10904, 1.05, 0.65, 0.47916666666667
10905, 1.05, 0.7, 0.47916666666667
10906, 1.05, 0.75, 0.47916666666667
10907, 1.05, 0.8, 0.47916666666667
10908, 1.05, 0.85, 0.47916666666667
10909, 1.05, 0.9, 0.47916666666667
10910, 1.05, 0.95, 0.47916666666667
10911, 1.05, 1, 0.47916666666667
10912, 1.05, 1.05, 0.47916666666667
10913, 1.05, 1.1, 0.47916666666667
10914, 1.05, 1.15, 0.47916666666667
10915, 1.05, 1.2, 0.47916666666667
10916, 1.05, 1.25, 0.47916666666667
10917, 1.05, 1.3, 0.47916666666667
10918, 1.175, 1.3, 0
10919, 1.175, 1.25, 0
10920, 1.175, 1.2, 0
10921, 1.175, 1.15, 0
10922, 1.175, 1.1, 0
10923, 1.175, 1.05, 0
10924, 1.175, 1, 0
10925, 1.175, 0.95, 0
10926, 1.175, 0.9, 0
10927, 1.175, 0.85, 0
10928, 1.175, 0.8, 0
10929, 1.175, 0.75, 0
10930, 1.175, 0.7, 0
10931, 1.175, 0.65, 0
10932, 1.175, 0.6, 0
10933, 1.175, 0.55, 0
10934, 1.175, 0.5, 0
10935, 1.175, 0.45, 0
10936, 1.175, 0.4, 0
10937, 1.175, 0.35, 0
10938, 1.175, 0.3, 0
10939, 1.175, 0.25, 0
10940, 1.175, 0.2, 0
10941, 1.175, 1.35, 0.041666666666667
10942, 1.175, 1.35, 0.083333333333333
10943, 1.175, 1.35, 0.125
10944, 1.175, 1.35, 0.16666666666667
10945, 1.175, 1.35, 0.20833333333333
10946, 1.175, 1.35, 0.25
10947, 1.175, 1.35, 0.29166666666667
10948, 1.175, 1.35, 0.33333333333333
10949, 1.175, 1.35, 0.375
10950, 1.175, 1.35, 0.41666666666667
10951, 1.175, 1.35, 0.45833333333333
10952, 1.175, 0.15, 0.041666666666667
10953, 1.175, 0.15, 0.083333333333333
10954, 1.175, 0.15, 0.125
10955, 1.175, 0.15, 0.16666666666667
10956, 1.175, 0.15, 0.20833333333333
10957, 1.175, 0.15, 0.25
10958, 1.175, 0.15, 0.29166666666667
10959, 1.175, 0.15, 0.33333333333333
10960, 1.175, 0.15, 0.375
10961, 1.175, 0.15, 0.41666666666667
10962, 1.175, 0.15, 0.45833333333333
10963, 1.15, 1.3, 0.041666666666667
10964, 1.15, 1.25, 0.041666666666667
10965, 1.15, 1.2, 0.041666666666667
10966, 1.15, 1.15, 0.041666666666667
10967, 1.15, 1.1, 0.041666666666667
10968, 1.15, 1.05, 0.041666666666667
10969, 1.15, 1, 0.041666666666667
10970, 1.15, 0.95, 0.041666666666667
10971, 1.15, 0.9, 0.041666666666667
10972, 1.15, 0.85, 0.041666666666667
10973, 1.15, 0.8, 0.041666666666667
10974, 1.15, 0.75, 0.041666666666667
10975, 1.15, 0.7, 0.041666666666667
10976, 1.15, 0.65, 0.041666666666667
10977, 1.15, 0.6, 0.041666666666667
10978, 1.15, 0.55, 0.041666666666667
10979, 1.15, 0.5, 0.041666666666667
10980, 1.15, 0.45, 0.041666666666667
10981, 1.15, 0.4, 0.041666666666667
10982, 1.15, 0.35, 0.041666666666667
10983, 1.15, 0.3, 0.041666666666667
10984, 1.15, 0.25, 0.041666666666667
10985, 1.15, 0.2, 0.041666666666667
10986, 1.15, 1.3, 0.083333333333333
10987, 1.15, 1.25, 0.083333333333333
10988, 1.15, 1.2, 0.083333333333333
10989, 1.15, 1.15, 0.083333333333333
10990, 1.15, 1.1, 0.083333333333333
10991, 1.15, 1.05, 0.083333333333333
10992, 1.15, 1, 0.083333333333333
10993, 1.15, 0.95, 0.083333333333333
10994, 1.15, 0.9, 0.083333333333333
10995, 1.15, 0.85, 0.083333333333333
10996, 1.15, 0.8, 0.083333333333333
10997, 1.15, 0.75, 0.083333333333333
10998, 1.15, 0.7, 0.083333333333333
10999, 1.15, 0.65, 0.083333333333333
11000, 1.15, 0.6, 0.083333333333333
11001, 1.15, 0.55, 0.083333333333333
11002, 1.15, 0.5, 0.083333333333333
11003, 1.15, 0.45, 0.083333333333333
11004, 1.15, 0.4, 0.083333333333333
11005, 1.15, 0.35, 0.083333333333333
11006, 1.15, 0.3, 0.083333333333333
11007, 1.15, 0.25, 0.083333333333333
11008, 1.15, 0.2, 0.083333333333333
11009, 1.15, 1.3, 0.125
11010, 1.15, 1.25, 0.125
11011, 1.15, 1.2, 0.125
11012, 1.15, 1.15, 0.125
11013, 1.15, 1.1, 0.125
11014, 1.15, 1.05, 0.125
11015, 1.15, 1, 0.125
11016, 1.15, 0.95, 0.125
11017, 1.15, 0.9, 0.125
11018, 1.15, 0.85, 0.125
11019, 1.15, 0.8, 0.125
11020, 1.15, 0.75, 0.125
11021, 1.15, 0.7, 0.125
11022, 1.15, 0.65, 0.125
11023, 1.15, 0.6, 0.125
11024, 1.15, 0.55, 0.125
11025, 1.15, 0.5, 0.125
11026, 1.15, 0.45, 0.125
11027, 1.15, 0.4, 0.125
11028, 1.15, 0.35, 0.125
11029, 1.15, 0.3, 0.125
11030, 1.15, 0.25, 0.125
11031, 1.15, 0.2, 0.125
11032, 1.15, 1.3, 0.16666666666667
11033, 1.15, 1.25, 0.16666666666667
11034, 1.15, 1.2, 0.16666666666667
11035, 1.15, 1.15, 0.16666666666667
11036, 1.15, 1.1, 0.16666666666667
11037, 1.15, 1.05, 0.16666666666667
11038, 1.15, 1, 0.16666666666667
11039, 1.15, 0.95, 0.16666666666667
11040, 1.15, 0.9, 0.16666666666667
11041, 1.15, 0.85, 0.16666666666667
11042, 1.15, 0.8, 0.16666666666667
11043, 1.15, 0.75, 0.16666666666667
11044, 1.15, 0.7, 0.16666666666667
11045, 1.15, 0.65, 0.16666666666667
11046, 1.15, 0.6, 0.16666666666667
11047, 1.15, 0.55, 0.16666666666667
11048, 1.15, 0.5, 0.16666666666667
11049, 1.15, 0.45, 0.16666666666667
11050, 1.15, 0.4, 0.16666666666667
11051, 1.15, 0.35, 0.16666666666667
11052, 1.15, 0.3, 0.16666666666667
11053, 1.15, 0.25, 0.16666666666667
11054, 1.15, 0.2, 0.16666666666667
11055, 1.15, 1.3, 0.20833333333333
11056, 1.15, 1.25, 0.20833333333333
11057, 1.15, 1.2, 0.20833333333333
11058, 1.15, 1.15, 0.20833333333333
11059, 1.15, 1.1, 0.20833333333333
11060, 1.15, 1.05, 0.20833333333333
11061, 1.15, 1, 0.20833333333333
11062, 1.15, 0.95, 0.20833333333333
11063, 1.15, 0.9, 0.20833333333333
11064, 1.15, 0.85, 0.20833333333333
11065, 1.15, 0.8, 0.20833333333333
11066, 1.15, 0.75, 0.20833333333333
11067, 1.15, 0.7, 0.20833333333333
11068, 1.15, 0.65, 0.20833333333333
11069, 1.15, 0.6, 0.20833333333333
11070, 1.15, 0.55, 0.20833333333333
11071, 1.15, 0.5, 0.20833333333333
11072, 1.15, 0.45, 0.20833333333333
11073, 1.15, 0.4, 0.20833333333333
11074, 1.15, 0.35, 0.20833333333333
11075, 1.15, 0.3, 0.20833333333333
11076, 1.15, 0.25, 0.20833333333333
11077, 1.15, 0.2, 0.20833333333333
11078, 1.15, 1.3, 0.25
11079, 1.15, 1.25, 0.25
11080, 1.15, 1.2, 0.25
11081, 1.15, 1.15, 0.25
11082, 1.15, 1.1, 0.25
11083, 1.15, 1.05, 0.25
11084, 1.15, 1, 0.25
11085, 1.15, 0.95, 0.25
11086, 1.15, 0.9, 0.25
11087, 1.15, 0.85, 0.25
11088, 1.15, 0.8, 0.25
11089, 1.15, 0.75, 0.25
11090, 1.15, 0.7, 0.25
11091, 1.15, 0.65, 0.25
11092, 1.15, 0.6, 0.25
11093, 1.15, 0.55, 0.25
11094, 1.15, 0.5, 0.25
11095, 1.15, 0.45, 0.25
11096, 1.15, 0.4, 0.25
11097, 1.15, 0.35, 0.25
11098, 1.15, 0.3, 0.25
11099, 1.15, 0.25, 0.25
11100, 1.15, 0.2, 0.25
11101, 1.15, 1.3, 0.29166666666667
11102, 1.15, 1.25, 0.29166666666667
11103, 1.15, 1.2, 0.29166666666667
11104, 1.15, 1.15, 0.29166666666667
11105, 1.15, 1.1, 0.29166666666667
11106, 1.15, 1.05, 0.29166666666667
11107, 1.15, 1, 0.29166666666667
11108, 1.15, 0.95, 0.29166666666667
11109, 1.15, 0.9, 0.29166666666667
11110, 1.15, 0.85, 0.29166666666667
11111, 1.15, 0.8, 0.29166666666667
11112, 1.15, 0.75, 0.29166666666667
11113, 1.15, 0.7, 0.29166666666667
11114, 1.15, 0.65, 0.29166666666667
11115, 1.15, 0.6, 0.29166666666667
11116, 1.15, 0.55, 0.29166666666667
11117, 1.15, 0.5, 0.29166666666667
11118, 1.15, 0.45, 0.29166666666667
11119, 1.15, 0.4, 0.29166666666667
11120, 1.15, 0.35, 0.29166666666667
11121, 1.15, 0.3, 0.29166666666667
11122, 1.15, 0.25, 0.29166666666667
11123, 1.15, 0.2, 0.29166666666667
11124, 1.15, 1.3, 0.33333333333333
11125, 1.15, 1.25, 0.33333333333333
11126, 1.15, 1.2, 0.33333333333333
11127, 1.15, 1.15, 0.33333333333333
11128, 1.15, 1.1, 0.33333333333333
11129, 1.15, 1.05, 0.33333333333333
11130, 1.15, 1, 0.33333333333333
11131, 1.15, 0.95, 0.33333333333333
11132, 1.15, 0.9, 0.33333333333333
11133, 1.15, 0.85, 0.33333333333333
11134, 1.15, 0.8, 0.33333333333333
11135, 1.15, 0.75, 0.33333333333333
11136, 1.15, 0.7, 0.33333333333333
11137, 1.15, 0.65, 0.33333333333333
11138, 1.15, 0.6, 0.33333333333333
11139, 1.15, 0.55, 0.33333333333333
11140, 1.15, 0.5, 0.33333333333333
11141, 1.15, 0.45, 0.33333333333333
11142, 1.15, 0.4, 0.33333333333333
11143, 1.15, 0.35, 0.33333333333333
11144, 1.15, 0.3, 0.33333333333333
11145, 1.15, 0.25, 0.33333333333333
11146, 1.15, 0.2, 0.33333333333333
11147, 1.15, 1.3, 0.375
11148, 1.15, 1.25, 0.375
11149, 1.15, 1.2, 0.375
11150, 1.15, 1.15, 0.375
11151, 1.15, 1.1, 0.375
11152, 1.15, 1.05, 0.375
11153, 1.15, 1, 0.375
11154, 1.15, 0.95, 0.375
11155, 1.15, 0.9, 0.375
11156, 1.15, 0.85, 0.375
11157, 1.15, 0.8, 0.375
11158, 1.15, 0.75, 0.375
11159, 1.15, 0.7, 0.375
11160, 1.15, 0.65, 0.375
11161, 1.15, 0.6, 0.375
11162, 1.15, 0.55, 0.375
11163, 1.15, 0.5, 0.375
11164, 1.15, 0.45, 0.375
11165, 1.15, 0.4, 0.375
11166, 1.15, 0.35, 0.375
11167, 1.15, 0.3, 0.375
11168, 1.15, 0.25, 0.375
11169, 1.15, 0.2, 0.375
11170, 1.15, 1.3, 0.41666666666667
11171, 1.15, 1.25, 0.41666666666667
11172, 1.15, 1.2, 0.41666666666667
11173, 1.15, 1.15, 0.41666666666667
11174, 1.15, 1.1, 0.41666666666667
11175, 1.15, 1.05, 0.41666666666667
11176, 1.15, 1, 0.41666666666667
11177, 1.15, 0.95, 0.41666666666667
11178, 1.15, 0.9, 0.41666666666667
11179, 1.15, 0.85, 0.41666666666667
11180, 1.15, 0.8, 0.41666666666667
11181, 1.15, 0.75, 0.41666666666667
11182, 1.15, 0.7, 0.41666666666667
11183, 1.15, 0.65, 0.41666666666667
11184, 1.15, 0.6, 0.41666666666667
11185, 1.15, 0.55, 0.41666666666667
11186, 1.15, 0.5, 0.41666666666667
11187, 1.15, 0.45, 0.41666666666667
11188, 1.15, 0.4, 0.41666666666667
11189, 1.15, 0.35, 0.41666666666667
11190, 1.15, 0.3, 0.41666666666667
11191, 1.15, 0.25, 0.41666666666667
11192, 1.15, 0.2, 0.41666666666667
11193, 1.15, 1.3, 0.45833333333333
11194, 1.15, 1.25, 0.45833333333333
11195, 1.15, 1.2, 0.45833333333333
11196, 1.15, 1.15, 0.45833333333333
11197, 1.15, 1.1, 0.45833333333333
11198, 1.15, 1.05, 0.45833333333333
11199, 1.15, 1, 0.45833333333333
11200, 1.15, 0.95, 0.45833333333333
11201, 1.15, 0.9, 0.45833333333333
11202, 1.15, 0.85, 0.45833333333333
11203, 1.15, 0.8, 0.45833333333333
11204, 1.15, 0.75, 0.45833333333333
11205, 1.15, 0.7, 0.45833333333333
11206, 1.15, 0.65, 0.45833333333333
11207, 1.15, 0.6, 0.45833333333333
11208, 1.15, 0.55, 0.45833333333333
11209, 1.15, 0.5, 0.45833333333333
11210, 1.15, 0.45, 0.45833333333333
11211, 1.15, 0.4, 0.45833333333333
11212, 1.15, 0.35, 0.45833333333333
11213, 1.15, 0.3, 0.45833333333333
11214, 1.15, 0.25, 0.45833333333333
11215, 1.15, 0.2, 0.45833333333333
11216, 1.15, 1.3, 0.020833333333333
11217, 1.15, 1.325, 0.041666666666667
11218, 1.15, 1.25, 0.020833333333333
11219, 1.15, 1.275, 0.041666666666667
11220, 1.15, 1.2, 0.020833333333333
11221, 1.15, 1.225, 0.041666666666667
11222, 1.15, 1.15, 0.020833333333333
11223, 1.15, 1.175, 0.041666666666667
11224, 1.15, 1.1, 0.020833333333333
11225, 1.15, 1.125, 0.041666666666667
11226, 1.15, 1.05, 0.020833333333333
11227, 1.15, 1.075, 0.041666666666667
11228, 1.15, 1, 0.020833333333333
11229, 1.15, 1.025, 0.041666666666667
11230, 1.15, 0.95, 0.020833333333333
11231, 1.15, 0.975, 0.041666666666667
11232, 1.15, 0.9, 0.020833333333333
11233, 1.15, 0.925, 0.041666666666667
11234, 1.15, 0.85, 0.020833333333333
11235, 1.15, 0.875, 0.041666666666667
11236, 1.15, 0.8, 0.020833333333333
11237, 1.15, 0.825, 0.041666666666667
11238, 1.15, 0.75, 0.020833333333333
11239, 1.15, 0.775, 0.041666666666667
11240, 1.15, 0.7, 0.020833333333333
11241, 1.15, 0.725, 0.041666666666667
11242, 1.15, 0.65, 0.020833333333333
11243, 1.15, 0.675, 0.041666666666667
11244, 1.15, 0.6, 0.020833333333333
11245, 1.15, 0.625, 0.041666666666667
11246, 1.15, 0.55, 0.020833333333333
11247, 1.15, 0.575, 0.041666666666667
11248, 1.15, 0.5, 0.020833333333333
11249, 1.15, 0.525, 0.041666666666667
11250, 1.15, 0.45, 0.020833333333333
11251, 1.15, 0.475, 0.041666666666667
11252, 1.15, 0.4, 0.020833333333333
11253, 1.15, 0.425, 0.041666666666667
11254, 1.15, 0.35, 0.020833333333333
11255, 1.15, 0.375, 0.041666666666667
11256, 1.15, 0.3, 0.020833333333333
11257, 1.15, 0.325, 0.041666666666667
11258, 1.15, 0.25, 0.020833333333333
11259, 1.15, 0.275, 0.041666666666667
11260, 1.15, 0.2, 0.020833333333333
11261, 1.15, 0.225, 0.041666666666667
11262, 1.15, 0.175, 0.041666666666667
11263, 1.15, 1.3, 0.0625
11264, 1.15, 1.325, 0.083333333333333
11265, 1.15, 1.25, 0.0625
11266, 1.15, 1.275, 0.083333333333333
11267, 1.15, 1.2, 0.0625
11268, 1.15, 1.225, 0.083333333333333
11269, 1.15, 1.15, 0.0625
11270, 1.15, 1.175, 0.083333333333333
11271, 1.15, 1.1, 0.0625
11272, 1.15, 1.125, 0.083333333333333
11273, 1.15, 1.05, 0.0625
11274, 1.15, 1.075, 0.083333333333333
11275, 1.15, 1, 0.0625
11276, 1.15, 1.025, 0.083333333333333
11277, 1.15, 0.95, 0.0625
11278, 1.15, 0.975, 0.083333333333333
11279, 1.15, 0.9, 0.0625
11280, 1.15, 0.925, 0.083333333333333
11281, 1.15, 0.85, 0.0625
11282, 1.15, 0.875, 0.083333333333333
11283, 1.15, 0.8, 0.0625
11284, 1.15, 0.825, 0.083333333333333
11285, 1.15, 0.75, 0.0625
11286, 1.15, 0.775, 0.083333333333333
11287, 1.15, 0.7, 0.0625
11288, 1.15, 0.725, 0.083333333333333
11289, 1.15, 0.65, 0.0625
11290, 1.15, 0.675, 0.083333333333333
11291, 1.15, 0.6, 0.0625
11292, 1.15, 0.625, 0.083333333333333
11293, 1.15, 0.55, 0.0625
11294, 1.15, 0.575, 0.083333333333333
11295, 1.15, 0.5, 0.0625
11296, 1.15, 0.525, 0.083333333333333
11297, 1.15, 0.45, 0.0625
11298, 1.15, 0.475, 0.083333333333333
11299, 1.15, 0.4, 0.0625
11300, 1.15, 0.425, 0.083333333333333
11301, 1.15, 0.35, 0.0625
11302, 1.15, 0.375, 0.083333333333333
11303, 1.15, 0.3, 0.0625
11304, 1.15, 0.325, 0.083333333333333
11305, 1.15, 0.25, 0.0625
11306, 1.15, 0.275, 0.083333333333333
11307, 1.15, 0.2, 0.0625
11308, 1.15, 0.225, 0.083333333333333
11309, 1.15, 0.175, 0.083333333333333
11310, 1.15, 1.3, 0.10416666666667
11311, 1.15, 1.325, 0.125
11312, 1.15, 1.25, 0.10416666666667
11313, 1.15, 1.275, 0.125
11314, 1.15, 1.2, 0.10416666666667
11315, 1.15, 1.225, 0.125
11316, 1.15, 1.15, 0.10416666666667
11317, 1.15, 1.175, 0.125
11318, 1.15, 1.1, 0.10416666666667
11319, 1.15, 1.125, 0.125
11320, 1.15, 1.05, 0.10416666666667
11321, 1.15, 1.075, 0.125
11322, 1.15, 1, 0.10416666666667
11323, 1.15, 1.025, 0.125
11324, 1.15, 0.95, 0.10416666666667
11325, 1.15, 0.975, 0.125
11326, 1.15, 0.9, 0.10416666666667
11327, 1.15, 0.925, 0.125
11328, 1.15, 0.85, 0.10416666666667
11329, 1.15, 0.875, 0.125
11330, 1.15, 0.8, 0.10416666666667
11331, 1.15, 0.825, 0.125
11332, 1.15, 0.75, 0.10416666666667
11333, 1.15, 0.775, 0.125
11334, 1.15, 0.7, 0.10416666666667
11335, 1.15, 0.725, 0.125
11336, 1.15, 0.65, 0.10416666666667
11337, 1.15, 0.675, 0.125
11338, 1.15, 0.6, 0.10416666666667
11339, 1.15, 0.625, 0.125
11340, 1.15, 0.55, 0.10416666666667
11341, 1.15, 0.575, 0.125
11342, 1.15, 0.5, 0.10416666666667
11343, 1.15, 0.525, 0.125
11344, 1.15, 0.45, 0.10416666666667
11345, 1.15, 0.475, 0.125
11346, 1.15, 0.4, 0.10416666666667
11347, 1.15, 0.425, 0.125
11348, 1.15, 0.35, 0.10416666666667
11349, 1.15, 0.375, 0.125
11350, 1.15, 0.3, 0.10416666666667
11351, 1.15, 0.325, 0.125
11352, 1.15, 0.25, 0.10416666666667
11353, 1.15, 0.275, 0.125
11354, 1.15, 0.2, 0.10416666666667
11355, 1.15, 0.225, 0.125
11356, 1.15, 0.175, 0.125
11357, 1.15, 1.3, 0.14583333333333
11358, 1.15, 1.325, 0.16666666666667
11359, 1.15, 1.25, 0.14583333333333
11360, 1.15, 1.275, 0.16666666666667
11361, 1.15, 1.2, 0.14583333333333
11362, 1.15, 1.225, 0.16666666666667
11363, 1.15, 1.15, 0.14583333333333
11364, 1.15, 1.175, 0.16666666666667
11365, 1.15, 1.1, 0.14583333333333
11366, 1.15, 1.125, 0.16666666666667
11367, 1.15, 1.05, 0.14583333333333
11368, 1.15, 1.075, 0.16666666666667
11369, 1.15, 1, 0.14583333333333
11370, 1.15, 1.025, 0.16666666666667
11371, 1.15, 0.95, 0.14583333333333
11372, 1.15, 0.975, 0.16666666666667
11373, 1.15, 0.9, 0.14583333333333
11374, 1.15, 0.925, 0.16666666666667
11375, 1.15, 0.85, 0.14583333333333
11376, 1.15, 0.875, 0.16666666666667
11377, 1.15, 0.8, 0.14583333333333
11378, 1.15, 0.825, 0.16666666666667
11379, 1.15, 0.75, 0.14583333333333
11380, 1.15, 0.775, 0.16666666666667
11381, 1.15, 0.7, 0.14583333333333
11382, 1.15, 0.725, 0.16666666666667
11383, 1.15, 0.65, 0.14583333333333
11384, 1.15, 0.675, 0.16666666666667
11385, 1.15, 0.6, 0.14583333333333
11386, 1.15, 0.625, 0.16666666666667
11387, 1.15, 0.55, 0.14583333333333
11388, 1.15, 0.575, 0.16666666666667
11389, 1.15, 0.5, 0.14583333333333
11390, 1.15, 0.525, 0.16666666666667
11391, 1.15, 0.45, 0.14583333333333
11392, 1.15, 0.475, 0.16666666666667
11393, 1.15, 0.4, 0.14583333333333
11394, 1.15, 0.425, 0.16666666666667
11395, 1.15, 0.35, 0.14583333333333
11396, 1.15, 0.375, 0.16666666666667
11397, 1.15, 0.3, 0.14583333333333
11398, 1.15, 0.325, 0.16666666666667
11399, 1.15, 0.25, 0.14583333333333
11400, 1.15, 0.275, 0.16666666666667
11401, 1.15, 0.2, 0.14583333333333
11402, 1.15, 0.225, 0.16666666666667
11403, 1.15, 0.175, 0.16666666666667
11404, 1.15, 1.3, 0.1875
11405, 1.15, 1.325, 0.20833333333333
11406, 1.15, 1.25, 0.1875
11407, 1.15, 1.275, 0.20833333333333
11408, 1.15, 1.2, 0.1875
11409, 1.15, 1.225, 0.20833333333333
11410, 1.15, 1.15, 0.1875
11411, 1.15, 1.175, 0.20833333333333
11412, 1.15, 1.1, 0.1875
11413, 1.15, 1.125, 0.20833333333333
11414, 1.15, 1.05, 0.1875
11415, 1.15, 1.075, 0.20833333333333
11416, 1.15, 1, 0.1875
11417, 1.15, 1.025, 0.20833333333333
11418, 1.15, 0.95, 0.1875
11419, 1.15, 0.975, 0.20833333333333
11420, 1.15, 0.9, 0.1875
11421, 1.15, 0.925, 0.20833333333333
11422, 1.15, 0.85, 0.1875
11423, 1.15, 0.875, 0.20833333333333
11424, 1.15, 0.8, 0.1875
11425, 1.15, 0.825, 0.20833333333333
11426, 1.15, 0.75, 0.1875
11427, 1.15, 0.775, 0.20833333333333
11428, 1.15, 0.7, 0.1875
11429, 1.15, 0.725, 0.20833333333333
11430, 1.15, 0.65, 0.1875
11431, 1.15, 0.675, 0.20833333333333
11432, 1.15, 0.6, 0.1875
11433, 1.15, 0.625, 0.20833333333333
11434, 1.15, 0.55, 0.1875
11435, 1.15, 0.575, 0.20833333333333
11436, 1.15, 0.5, 0.1875
11437, 1.15, 0.525, 0.20833333333333
11438, 1.15, 0.45, 0.1875
11439, 1.15, 0.475, 0.20833333333333
11440, 1.15, 0.4, 0.1875
11441, 1.15, 0.425, 0.20833333333333
11442, 1.15, 0.35, 0.1875
11443, 1.15, 0.375, 0.20833333333333
11444, 1.15, 0.3, 0.1875
11445, 1.15, 0.325, 0.20833333333333
11446, 1.15, 0.25, 0.1875
11447, 1.15, 0.275, 0.20833333333333
11448, 1.15, 0.2, 0.1875
11449, 1.15, 0.225, 0.20833333333333
11450, 1.15, 0.175, 0.20833333333333
11451, 1.15, 1.3, 0.22916666666667
11452, 1.15, 1.325, 0.25
11453, 1.15, 1.25, 0.22916666666667
11454, 1.15, 1.275, 0.25
11455, 1.15, 1.2, 0.22916666666667
11456, 1.15, 1.225, 0.25
11457, 1.15, 1.15, 0.22916666666667
11458, 1.15, 1.175, 0.25
11459, 1.15, 1.1, 0.22916666666667
11460, 1.15, 1.125, 0.25
11461, 1.15, 1.05, 0.22916666666667
11462, 1.15, 1.075, 0.25
11463, 1.15, 1, 0.22916666666667
11464, 1.15, 1.025, 0.25
11465, 1.15, 0.95, 0.22916666666667
11466, 1.15, 0.975, 0.25
11467, 1.15, 0.9, 0.22916666666667
11468, 1.15, 0.925, 0.25
11469, 1.15, 0.85, 0.22916666666667
11470, 1.15, 0.875, 0.25
11471, 1.15, 0.8, 0.22916666666667
11472, 1.15, 0.825, 0.25
11473, 1.15, 0.75, 0.22916666666667
11474, 1.15, 0.775, 0.25
11475, 1.15, 0.7, 0.22916666666667
11476, 1.15, 0.725, 0.25
11477, 1.15, 0.65, 0.22916666666667
11478, 1.15, 0.675, 0.25
11479, 1.15, 0.6, 0.22916666666667
11480, 1.15, 0.625, 0.25
11481, 1.15, 0.55, 0.22916666666667
11482, 1.15, 0.575, 0.25
11483, 1.15, 0.5, 0.22916666666667
11484, 1.15, 0.525, 0.25
11485, 1.15, 0.45, 0.22916666666667
11486, 1.15, 0.475, 0.25
11487, 1.15, 0.4, 0.22916666666667
11488, 1.15, 0.425, 0.25
11489, 1.15, 0.35, 0.22916666666667
11490, 1.15, 0.375, 0.25
11491, 1.15, 0.3, 0.22916666666667
11492, 1.15, 0.325, 0.25
11493, 1.15, 0.25, 0.22916666666667
11494, 1.15, 0.275, 0.25
11495, 1.15, 0.2, 0.22916666666667
11496, 1.15, 0.225, 0.25
11497, 1.15, 0.175, 0.25
11498, 1.15, 1.3, 0.27083333333333
11499, 1.15, 1.325, 0.29166666666667
11500, 1.15, 1.25, 0.27083333333333
11501, 1.15, 1.275, 0.29166666666667
11502, 1.15, 1.2, 0.27083333333333
11503, 1.15, 1.225, 0.29166666666667
11504, 1.15, 1.15, 0.27083333333333
11505, 1.15, 1.175, 0.29166666666667
11506, 1.15, 1.1, 0.27083333333333
11507, 1.15, 1.125, 0.29166666666667
11508, 1.15, 1.05, 0.27083333333333
11509, 1.15, 1.075, 0.29166666666667
11510, 1.15, 1, 0.27083333333333
11511, 1.15, 1.025, 0.29166666666667
11512, 1.15, 0.95, 0.27083333333333
11513, 1.15, 0.975, 0.29166666666667
11514, 1.15, 0.9, 0.27083333333333
11515, 1.15, 0.925, 0.29166666666667
11516, 1.15, 0.85, 0.27083333333333
11517, 1.15, 0.875, 0.29166666666667
11518, 1.15, 0.8, 0.27083333333333
11519, 1.15, 0.825, 0.29166666666667
11520, 1.15, 0.75, 0.27083333333333
11521, 1.15, 0.775, 0.29166666666667
11522, 1.15, 0.7, 0.27083333333333
11523, 1.15, 0.725, 0.29166666666667
11524, 1.15, 0.65, 0.27083333333333
11525, 1.15, 0.675, 0.29166666666667
11526, 1.15, 0.6, 0.27083333333333
11527, 1.15, 0.625, 0.29166666666667
11528, 1.15, 0.55, 0.27083333333333
11529, 1.15, 0.575, 0.29166666666667
11530, 1.15, 0.5, 0.27083333333333
11531, 1.15, 0.525, 0.29166666666667
11532, 1.15, 0.45, 0.27083333333333
11533, 1.15, 0.475, 0.29166666666667
11534, 1.15, 0.4, 0.27083333333333
11535, 1.15, 0.425, 0.29166666666667
11536, 1.15, 0.35, 0.27083333333333
11537, 1.15, 0.375, 0.29166666666667
11538, 1.15, 0.3, 0.27083333333333
11539, 1.15, 0.325, 0.29166666666667
11540, 1.15, 0.25, 0.27083333333333
11541, 1.15, 0.275, 0.29166666666667
11542, 1.15, 0.2, 0.27083333333333
11543, 1.15, 0.225, 0.29166666666667
11544, 1.15, 0.175, 0.29166666666667
11545, 1.15, 1.3, 0.3125
11546, 1.15, 1.325, 0.33333333333333
11547, 1.15, 1.25, 0.3125
11548, 1.15, 1.275, 0.33333333333333
11549, 1.15, 1.2, 0.3125
11550, 1.15, 1.225, 0.33333333333333
11551, 1.15, 1.15, 0.3125
11552, 1.15, 1.175, 0.33333333333333
11553, 1.15, 1.1, 0.3125
11554, 1.15, 1.125, 0.33333333333333
11555, 1.15, 1.05, 0.3125
11556, 1.15, 1.075, 0.33333333333333
11557, 1.15, 1, 0.3125
11558, 1.15, 1.025, 0.33333333333333
11559, 1.15, 0.95, 0.3125
11560, 1.15, 0.975, 0.33333333333333
11561, 1.15, 0.9, 0.3125
11562, 1.15, 0.925, 0.33333333333333
11563, 1.15, 0.85, 0.3125
11564, 1.15, 0.875, 0.33333333333333
11565, 1.15, 0.8, 0.3125
11566, 1.15, 0.825, 0.33333333333333
11567, 1.15, 0.75, 0.3125
11568, 1.15, 0.775, 0.33333333333333
11569, 1.15, 0.7, 0.3125
11570, 1.15, 0.725, 0.33333333333333
11571, 1.15, 0.65, 0.3125
11572, 1.15, 0.675, 0.33333333333333
11573, 1.15, 0.6, 0.3125
11574, 1.15, 0.625, 0.33333333333333
11575, 1.15, 0.55, 0.3125
11576, 1.15, 0.575, 0.33333333333333
11577, 1.15, 0.5, 0.3125
11578, 1.15, 0.525, 0.33333333333333
11579, 1.15, 0.45, 0.3125
11580, 1.15, 0.475, 0.33333333333333
11581, 1.15, 0.4, 0.3125
11582, 1.15, 0.425, 0.33333333333333
11583, 1.15, 0.35, 0.3125
11584, 1.15, 0.375, 0.33333333333333
11585, 1.15, 0.3, 0.3125
11586, 1.15, 0.325, 0.33333333333333
11587, 1.15, 0.25, 0.3125
11588, 1.15, 0.275, 0.33333333333333
11589, 1.15, 0.2, 0.3125
11590, 1.15, 0.225, 0.33333333333333
11591, 1.15, 0.175, 0.33333333333333
11592, 1.15, 1.3, 0.35416666666667
11593, 1.15, 1.325, 0.375
11594, 1.15, 1.25, 0.35416666666667
11595, 1.15, 1.275, 0.375
11596, 1.15, 1.2, 0.35416666666667
11597, 1.15, 1.225, 0.375
11598, 1.15, 1.15, 0.35416666666667
11599, 1.15, 1.175, 0.375
11600, 1.15, 1.1, 0.35416666666667
11601, 1.15, 1.125, 0.375
11602, 1.15, 1.05, 0.35416666666667
11603, 1.15, 1.075, 0.375
11604, 1.15, 1, 0.35416666666667
11605, 1.15, 1.025, 0.375
11606, 1.15, 0.95, 0.35416666666667
11607, 1.15, 0.975, 0.375
11608, 1.15, 0.9, 0.35416666666667
11609, 1.15, 0.925, 0.375
11610, 1.15, 0.85, 0.35416666666667
11611, 1.15, 0.875, 0.375
11612, 1.15, 0.8, 0.35416666666667
11613, 1.15, 0.825, 0.375
11614, 1.15, 0.75, 0.35416666666667
11615, 1.15, 0.775, 0.375
11616, 1.15, 0.7, 0.35416666666667
11617, 1.15, 0.725, 0.375
11618, 1.15, 0.65, 0.35416666666667
11619, 1.15, 0.675, 0.375
11620, 1.15, 0.6, 0.35416666666667
11621, 1.15, 0.625, 0.375
11622, 1.15, 0.55, 0.35416666666667
11623, 1.15, 0.575, 0.375
11624, 1.15, 0.5, 0.35416666666667
11625, 1.15, 0.525, 0.375
11626, 1.15, 0.45, 0.35416666666667
11627, 1.15, 0.475, 0.375
11628, 1.15, 0.4, 0.35416666666667
11629, 1.15, 0.425, 0.375
11630, 1.15, 0.35, 0.35416666666667
11631, 1.15, 0.375, 0.375
11632, 1.15, 0.3, 0.35416666666667
11633, 1.15, 0.325, 0.375
11634, 1.15, 0.25, 0.35416666666667
11635, 1.15, 0.275, 0.375
11636, 1.15, 0.2, 0.35416666666667
11637, 1.15, 0.225, 0.375
11638, 1.15, 0.175, 0.375
11639, 1.15, 1.3, 0.39583333333333
11640, 1.15, 1.325, 0.41666666666667
11641, 1.15, 1.25, 0.39583333333333
11642, 1.15, 1.275, 0.41666666666667
11643, 1.15, 1.2, 0.39583333333333
11644, 1.15, 1.225, 0.41666666666667
11645, 1.15, 1.15, 0.39583333333333
11646, 1.15, 1.175, 0.41666666666667
11647, 1.15, 1.1, 0.39583333333333
11648, 1.15, 1.125, 0.41666666666667
11649, 1.15, 1.05, 0.39583333333333
11650, 1.15, 1.075, 0.41666666666667
11651, 1.15, 1, 0.39583333333333
11652, 1.15, 1.025, 0.41666666666667
11653, 1.15, 0.95, 0.39583333333333
11654, 1.15, 0.975, 0.41666666666667
11655, 1.15, 0.9, 0.39583333333333
11656, 1.15, 0.925, 0.41666666666667
11657, 1.15, 0.85, 0.39583333333333
11658, 1.15, 0.875, 0.41666666666667
11659, 1.15, 0.8, 0.39583333333333
11660, 1.15, 0.825, 0.41666666666667
11661, 1.15, 0.75, 0.39583333333333
11662, 1.15, 0.775, 0.41666666666667
11663, 1.15, 0.7, 0.39583333333333
11664, 1.15, 0.725, 0.41666666666667
11665, 1.15, 0.65, 0.39583333333333
11666, 1.15, 0.675, 0.41666666666667
11667, 1.15, 0.6, 0.39583333333333
11668, 1.15, 0.625, 0.41666666666667
11669, 1.15, 0.55, 0.39583333333333
11670, 1.15, 0.575, 0.41666666666667
11671, 1.15, 0.5, 0.39583333333333
11672, 1.15, 0.525, 0.41666666666667
11673, 1.15, 0.45, 0.39583333333333
11674, 1.15, 0.475, 0.41666666666667
11675, 1.15, 0.4, 0.39583333333333
11676, 1.15, 0.425, 0.41666666666667
11677, 1.15, 0.35, 0.39583333333333
11678, 1.15, 0.375, 0.41666666666667
11679, 1.15, 0.3, 0.39583333333333
11680, 1.15, 0.325, 0.41666666666667
11681, 1.15, 0.25, 0.39583333333333
11682, 1.15, 0.275, 0.41666666666667
11683, 1.15, 0.2, 0.39583333333333
11684, 1.15, 0.225, 0.41666666666667
11685, 1.15, 0.175, 0.41666666666667
11686, 1.15, 1.3, 0.4375
11687, 1.15, 1.325, 0.45833333333333
11688, 1.15, 1.25, 0.4375
11689, 1.15, 1.275, 0.45833333333333
11690, 1.15, 1.2, 0.4375
11691, 1.15, 1.225, 0.45833333333333
11692, 1.15, 1.15, 0.4375
11693, 1.15, 1.175, 0.45833333333333
11694, 1.15, 1.1, 0.4375
11695, 1.15, 1.125, 0.45833333333333
11696, 1.15, 1.05, 0.4375
11697, 1.15, 1.075, 0.45833333333333
11698, 1.15, 1, 0.4375
11699, 1.15, 1.025, 0.45833333333333
11700, 1.15, 0.95, 0.4375
11701, 1.15, 0.975, 0.45833333333333
11702, 1.15, 0.9, 0.4375
11703, 1.15, 0.925, 0.45833333333333
11704, 1.15, 0.85, 0.4375
11705, 1.15, 0.875, 0.45833333333333
11706, 1.15, 0.8, 0.4375
11707, 1.15, 0.825, 0.45833333333333
11708, 1.15, 0.75, 0.4375
11709, 1.15, 0.775, 0.45833333333333
11710, 1.15, 0.7, 0.4375
11711, 1.15, 0.725, 0.45833333333333
11712, 1.15, 0.65, 0.4375
11713, 1.15, 0.675, 0.45833333333333
11714, 1.15, 0.6, 0.4375
11715, 1.15, 0.625, 0.45833333333333
11716, 1.15, 0.55, 0.4375
11717, 1.15, 0.575, 0.45833333333333
11718, 1.15, 0.5, 0.4375
11719, 1.15, 0.525, 0.45833333333333
11720, 1.15, 0.45, 0.4375
11721, 1.15, 0.475, 0.45833333333333
11722, 1.15, 0.4, 0.4375
11723, 1.15, 0.425, 0.45833333333333
11724, 1.15, 0.35, 0.4375
11725, 1.15, 0.375, 0.45833333333333
11726, 1.15, 0.3, 0.4375
11727, 1.15, 0.325, 0.45833333333333
11728, 1.15, 0.25, 0.4375
11729, 1.15, 0.275, 0.45833333333333
11730, 1.15, 0.2, 0.4375
11731, 1.15, 0.225, 0.45833333333333
11732, 1.15, 0.175, 0.45833333333333
11733, 1.15, 1.3, 0.47916666666667
11734, 1.15, 1.25, 0.47916666666667
11735, 1.15, 1.2, 0.47916666666667
11736, 1.15, 1.15, 0.47916666666667
11737, 1.15, 1.1, 0.47916666666667
11738, 1.15, 1.05, 0.47916666666667
11739, 1.15, 1, 0.47916666666667
11740, 1.15, 0.95, 0.47916666666667
11741, 1.15, 0.9, 0.47916666666667
11742, 1.15, 0.85, 0.47916666666667
11743, 1.15, 0.8, 0.47916666666667
11744, 1.15, 0.75, 0.47916666666667
11745, 1.15, 0.7, 0.47916666666667
11746, 1.15, 0.65, 0.47916666666667
11747, 1.15, 0.6, 0.47916666666667
11748, 1.15, 0.55, 0.47916666666667
11749, 1.15, 0.5, 0.47916666666667
11750, 1.15, 0.45, 0.47916666666667
11751, 1.15, 0.4, 0.47916666666667
11752, 1.15, 0.35, 0.47916666666667
11753, 1.15, 0.3, 0.47916666666667
11754, 1.15, 0.25, 0.47916666666667
11755, 1.15, 0.2, 0.47916666666667
11756, 1, 0.2, -0.05
11757, 1, 0.25, -0.05
11758, 1, 0.3, -0.05
11759, 1, 0.35, -0.05
11760, 1, 0.4, -0.05
11761, 1, 0.45, -0.05
11762, 1, 0.5, -0.05
11763, 1, 0.55, -0.05
11764, 1, 0.6, -0.05
11765, 1, 0.65, -0.05
11766, 1, 0.7, -0.05
11767, 1, 0.75, -0.05
11768, 1, 0.8, -0.05
11769, 1, 0.85, -0.05
11770, 1, 0.9, -0.05
11771, 1, 0.95, -0.05
11772, 1, 1, -0.05
11773, 1, 1.05, -0.05
11774, 1, 1.1, -0.05
11775, 1, 1.15, -0.05
11776, 1, 1.2, -0.05
11777, 1, 1.25, -0.05
11778, 1, 1.3, -0.05
11779, 0, 0.2, -0.05
11780, 0, 0.25, -0.05
11781, 0, 0.3, -0.05
11782, 0, 0.35, -0.05
11783, 0, 0.4, -0.05
11784, 0, 0.45, -0.05
11785, 0, 0.5, -0.05
11786, 0, 0.55, -0.05
11787, 0, 0.6, -0.05
11788, 0, 0.65, -0.05
11789, 0, 0.7, -0.05
11790, 0, 0.75, -0.05
11791, 0, 0.8, -0.05
11792, 0, 0.85, -0.05
11793, 0, 0.9, -0.05
11794, 0, 0.95, -0.05
11795, 0, 1, -0.05
11796, 0, 1.05, -0.05
11797, 0, 1.1, -0.05
11798, 0, 1.15, -0.05
11799, 0, 1.2, -0.05
11800, 0, 1.25, -0.05
11801, 0, 1.3, -0.05
11802, 0.041666666666667, 0.15, -0.05
11803, 0.083333333333333, 0.15, -0.05
11804, 0.125, 0.15, -0.05
11805, 0.16666666666667, 0.15, -0.05
11806, 0.20833333333333, 0.15, -0.05
11807, 0.25, 0.15, -0.05
11808, 0.29166666666667, 0.15, -0.05
11809, 0.33333333333333, 0.15, -0.05
11810, 0.375, 0.15, -0.05
11811, 0.41666666666667, 0.15, -0.05
11812, 0.45833333333333, 0.15, -0.05
11813, 0.5, 0.15, -0.05
11814, 0.54166666666667, 0.15, -0.05
11815, 0.58333333333333, 0.15, -0.05
11816, 0.625, 0.15, -0.05
11817, 0.66666666666667, 0.15, -0.05
11818, 0.70833333333333, 0.15, -0.05
11819, 0.75, 0.15, -0.05
11820, 0.79166666666667, 0.15, -0.05
11821, 0.83333333333333, 0.15, -0.05
11822, 0.875, 0.15, -0.05
11823, 0.91666666666667, 0.15, -0.05
11824, 0.95833333333333, 0.15, -0.05
11825, 0.041666666666667, 1.35, -0.05
11826, 0.083333333333333, 1.35, -0.05
11827, 0.125, 1.35, -0.05
11828, 0.16666666666667, 1.35, -0.05
11829, 0.20833333333333, 1.35, -0.05
11830, 0.25, 1.35, -0.05
11831, 0.29166666666667, 1.35, -0.05
11832, 0.33333333333333, 1.35, -0.05
11833, 0.375, 1.35, -0.05
11834, 0.41666666666667, 1.35, -0.05
11835, 0.45833333333333, 1.35, -0.05
11836, 0.5, 1.35, -0.05
11837, 0.54166666666667, 1.35, -0.05
11838, 0.58333333333333, 1.35, -0.05
11839, 0.625, 1.35, -0.05
11840, 0.66666666666667, 1.35, -0.05
11841, 0.70833333333333, 1.35, -0.05
11842, 0.75, 1.35, -0.05
11843, 0.79166666666667, 1.35, -0.05
11844, 0.83333333333333, 1.35, -0.05
11845, 0.875, 1.35, -0.05
11846, 0.91666666666667, 1.35, -0.05
11847, 0.95833333333333, 1.35, -0.05
11848, 0.041666666666667, 0.2, -0.1
11849, 0.041666666666667, 0.25, -0.1
11850, 0.041666666666667, 0.3, -0.1
11851, 0.041666666666667, 0.35, -0.1
11852, 0.041666666666667, 0.4, -0.1
11853, 0.041666666666667, 0.45, -0.1
11854, 0.041666666666667, 0.5, -0.1
11855, 0.041666666666667, 0.55, -0.1
11856, 0.041666666666667, 0.6, -0.1
11857, 0.041666666666667, 0.65, -0.1
11858, 0.041666666666667, 0.7, -0.1
11859, 0.041666666666667, 0.75, -0.1
11860, 0.041666666666667, 0.8, -0.1
11861, 0.041666666666667, 0.85, -0.1
11862, 0.041666666666667, 0.9, -0.1
11863, 0.041666666666667, 0.95, -0.1
11864, 0.041666666666667, 1, -0.1
11865, 0.041666666666667, 1.05, -0.1
11866, 0.041666666666667, 1.1, -0.1
11867, 0.041666666666667, 1.15, -0.1
11868, 0.041666666666667, 1.2, -0.1
11869, 0.041666666666667, 1.25, -0.1
11870, 0.041666666666667, 1.3, -0.1
11871, 0.083333333333333, 0.2, -0.1
11872, 0.083333333333333, 0.25, -0.1
11873, 0.083333333333333, 0.3, -0.1
11874, 0.083333333333333, 0.35, -0.1
11875, 0.083333333333333, 0.4, -0.1
11876, 0.083333333333333, 0.45, -0.1
11877, 0.083333333333333, 0.5, -0.1
11878, 0.083333333333333, 0.55, -0.1
11879, 0.083333333333333, 0.6, -0.1
11880, 0.083333333333333, 0.65, -0.1
11881, 0.083333333333333, 0.7, -0.1
11882, 0.083333333333333, 0.75, -0.1
11883, 0.083333333333333, 0.8, -0.1
11884, 0.083333333333333, 0.85, -0.1
11885, 0.083333333333333, 0.9, -0.1
11886, 0.083333333333333, 0.95, -0.1
11887, 0.083333333333333, 1, -0.1
11888, 0.083333333333333, 1.05, -0.1
11889, 0.083333333333333, 1.1, -0.1
11890, 0.083333333333333, 1.15, -0.1
11891, 0.083333333333333, 1.2, -0.1
11892, 0.083333333333333, 1.25, -0.1
11893, 0.083333333333333, 1.3, -0.1
11894, 0.125, 0.2, -0.1
11895, 0.125, 0.25, -0.1
11896, 0.125, 0.3, -0.1
11897, 0.125, 0.35, -0.1
11898, 0.125, 0.4, -0.1
11899, 0.125, 0.45, -0.1
11900, 0.125, 0.5, -0.1
11901, 0.125, 0.55, -0.1
11902, 0.125, 0.6, -0.1
11903, 0.125, 0.65, -0.1
11904, 0.125, 0.7, -0.1
11905, 0.125, 0.75, -0.1
11906, 0.125, 0.8, -0.1
11907, 0.125, 0.85, -0.1
11908, 0.125, 0.9, -0.1
11909, 0.125, 0.95, -0.1
11910, 0.125, 1, -0.1
11911, 0.125, 1.05, -0.1
11912, 0.125, 1.1, -0.1
11913, 0.125, 1.15, -0.1
11914, 0.125, 1.2, -0.1
11915, 0.125, 1.25, -0.1
11916, 0.125, 1.3, -0.1
11917, 0.16666666666667, 0.2, -0.1
11918, 0.16666666666667, 0.25, -0.1
11919, 0.16666666666667, 0.3, -0.1
11920, 0.16666666666667, 0.35, -0.1
11921, 0.16666666666667, 0.4, -0.1
11922, 0.16666666666667, 0.45, -0.1
11923, 0.16666666666667, 0.5, -0.1
11924, 0.16666666666667, 0.55, -0.1
11925, 0.16666666666667, 0.6, -0.1
11926, 0.16666666666667, 0.65, -0.1
11927, 0.16666666666667, 0.7, -0.1
11928, 0.16666666666667, 0.75, -0.1
11929, 0.16666666666667, 0.8, -0.1
11930, 0.16666666666667, 0.85, -0.1
11931, 0.16666666666667, 0.9, -0.1
11932, 0.16666666666667, 0.95, -0.1
11933, 0.16666666666667, 1, -0.1
11934, 0.16666666666667, 1.05, -0.1
11935, 0.16666666666667, 1.1, -0.1
11936, 0.16666666666667, 1.15, -0.1
11937, 0.16666666666667, 1.2, -0.1
11938, 0.16666666666667, 1.25, -0.1
11939, 0.16666666666667, 1.3, -0.1
11940, 0.20833333333333, 0.2, -0.1
11941, 0.20833333333333, 0.25, -0.1
11942, 0.20833333333333, 0.3, -0.1
11943, 0.20833333333333, 0.35, -0.1
11944, 0.20833333333333, 0.4, -0.1
11945, 0.20833333333333, 0.45, -0.1
11946, 0.20833333333333, 0.5, -0.1
11947, 0.20833333333333, 0.55, -0.1
11948, 0.20833333333333, 0.6, -0.1
11949, 0.20833333333333, 0.65, -0.1
11950, 0.20833333333333, 0.7, -0.1
11951, 0.20833333333333, 0.75, -0.1
11952, 0.20833333333333, 0.8, -0.1
11953, 0.20833333333333, 0.85, -0.1
11954, 0.20833333333333, 0.9, -0.1
11955, 0.20833333333333, 0.95, -0.1
11956, 0.20833333333333, 1, -0.1
11957, 0.20833333333333, 1.05, -0.1
11958, 0.20833333333333, 1.1, -0.1
11959, 0.20833333333333, 1.15, -0.1
11960, 0.20833333333333, 1.2, -0.1
11961, 0.20833333333333, 1.25, -0.1
11962, 0.20833333333333, 1.3, -0.1
11963, 0.25, 0.2, -0.1
11964, 0.25, 0.25, -0.1
11965, 0.25, 0.3, -0.1
11966, 0.25, 0.35, -0.1
11967, 0.25, 0.4, -0.1
11968, 0.25, 0.45, -0.1
11969, 0.25, 0.5, -0.1
11970, 0.25, 0.55, -0.1
11971, 0.25, 0.6, -0.1
11972, 0.25, 0.65, -0.1
11973, 0.25, 0.7, -0.1
11974, 0.25, 0.75, -0.1
11975, 0.25, 0.8, -0.1
11976, 0.25, 0.85, -0.1
11977, 0.25, 0.9, -0.1
11978, 0.25, 0.95, -0.1
11979, 0.25, 1, -0.1
11980, 0.25, 1.05, -0.1
11981, 0.25, 1.1, -0.1
11982, 0.25, 1.15, -0.1
11983, 0.25, 1.2, -0.1
11984, 0.25, 1.25, -0.1
11985, 0.25, 1.3, -0.1
11986, 0.29166666666667, 0.2, -0.1
11987, 0.29166666666667, 0.25, -0.1
11988, 0.29166666666667, 0.3, -0.1
11989, 0.29166666666667, 0.35, -0.1
11990, 0.29166666666667, 0.4, -0.1
11991, 0.29166666666667, 0.45, -0.1
11992, 0.29166666666667, 0.5, -0.1
11993, 0.29166666666667, 0.55, -0.1
11994, 0.29166666666667, 0.6, -0.1
11995, 0.29166666666667, 0.65, -0.1
11996, 0.29166666666667, 0.7, -0.1
11997, 0.29166666666667, 0.75, -0.1
11998, 0.29166666666667, 0.8, -0.1
11999, 0.29166666666667, 0.85, -0.1
12000, 0.29166666666667, 0.9, -0.1
12001, 0.29166666666667, 0.95, -0.1
12002, 0.29166666666667, 1, -0.1
12003, 0.29166666666667, 1.05, -0.1
12004, 0.29166666666667, 1.1, -0.1
12005, 0.29166666666667, 1.15, -0.1
12006, 0.29166666666667, 1.2, -0.1
12007, 0.29166666666667, 1.25, -0.1
12008, 0.29166666666667, 1.3, -0.1
12009, 0.33333333333333, 0.2, -0.1
12010, 0.33333333333333, 0.25, -0.1
12011, 0.33333333333333, 0.3, -0.1
12012, 0.33333333333333, 0.35, -0.1
12013, 0.33333333333333, 0.4, -0.1
