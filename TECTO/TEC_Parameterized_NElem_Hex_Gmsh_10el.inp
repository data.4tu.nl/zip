37227, 0.29166666666667, 1.58, 0.041666666666667
37228, 0.29166666666667, 1.62, 0.041666666666667
37229, 0.29166666666667, 1.66, 0.041666666666667
37230, 0.29166666666667, 1.54, 0.083333333333333
37231, 0.29166666666667, 1.58, 0.083333333333333
37232, 0.29166666666667, 1.62, 0.083333333333333
37233, 0.29166666666667, 1.66, 0.083333333333333
37234, 0.29166666666667, 1.54, 0.125
37235, 0.29166666666667, 1.58, 0.125
37236, 0.29166666666667, 1.62, 0.125
37237, 0.29166666666667, 1.66, 0.125
37238, 0.29166666666667, 1.54, 0.16666666666667
37239, 0.29166666666667, 1.58, 0.16666666666667
37240, 0.29166666666667, 1.62, 0.16666666666667
37241, 0.29166666666667, 1.66, 0.16666666666667
37242, 0.29166666666667, 1.54, 0.20833333333333
37243, 0.29166666666667, 1.58, 0.20833333333333
37244, 0.29166666666667, 1.62, 0.20833333333333
37245, 0.29166666666667, 1.66, 0.20833333333333
37246, 0.29166666666667, 1.54, 0.25
37247, 0.29166666666667, 1.58, 0.25
37248, 0.29166666666667, 1.62, 0.25
37249, 0.29166666666667, 1.66, 0.25
37250, 0.29166666666667, 1.54, 0.29166666666667
37251, 0.29166666666667, 1.58, 0.29166666666667
37252, 0.29166666666667, 1.62, 0.29166666666667
37253, 0.29166666666667, 1.66, 0.29166666666667
37254, 0.29166666666667, 1.54, 0.33333333333333
37255, 0.29166666666667, 1.58, 0.33333333333333
37256, 0.29166666666667, 1.62, 0.33333333333333
37257, 0.29166666666667, 1.66, 0.33333333333333
37258, 0.29166666666667, 1.54, 0.375
37259, 0.29166666666667, 1.58, 0.375
37260, 0.29166666666667, 1.62, 0.375
37261, 0.29166666666667, 1.66, 0.375
37262, 0.29166666666667, 1.54, 0.41666666666667
37263, 0.29166666666667, 1.58, 0.41666666666667
37264, 0.29166666666667, 1.62, 0.41666666666667
37265, 0.29166666666667, 1.66, 0.41666666666667
37266, 0.29166666666667, 1.54, 0.45833333333333
37267, 0.29166666666667, 1.58, 0.45833333333333
37268, 0.29166666666667, 1.62, 0.45833333333333
37269, 0.29166666666667, 1.66, 0.45833333333333
37270, 0.33333333333333, 1.54, 0.041666666666667
37271, 0.33333333333333, 1.58, 0.041666666666667
37272, 0.33333333333333, 1.62, 0.041666666666667
37273, 0.33333333333333, 1.66, 0.041666666666667
37274, 0.33333333333333, 1.54, 0.083333333333333
37275, 0.33333333333333, 1.58, 0.083333333333333
37276, 0.33333333333333, 1.62, 0.083333333333333
37277, 0.33333333333333, 1.66, 0.083333333333333
37278, 0.33333333333333, 1.54, 0.125
37279, 0.33333333333333, 1.58, 0.125
37280, 0.33333333333333, 1.62, 0.125
37281, 0.33333333333333, 1.66, 0.125
37282, 0.33333333333333, 1.54, 0.16666666666667
37283, 0.33333333333333, 1.58, 0.16666666666667
37284, 0.33333333333333, 1.62, 0.16666666666667
37285, 0.33333333333333, 1.66, 0.16666666666667
37286, 0.33333333333333, 1.54, 0.20833333333333
37287, 0.33333333333333, 1.58, 0.20833333333333
37288, 0.33333333333333, 1.62, 0.20833333333333
37289, 0.33333333333333, 1.66, 0.20833333333333
37290, 0.33333333333333, 1.54, 0.25
37291, 0.33333333333333, 1.58, 0.25
37292, 0.33333333333333, 1.62, 0.25
37293, 0.33333333333333, 1.66, 0.25
37294, 0.33333333333333, 1.54, 0.29166666666667
37295, 0.33333333333333, 1.58, 0.29166666666667
37296, 0.33333333333333, 1.62, 0.29166666666667
37297, 0.33333333333333, 1.66, 0.29166666666667
37298, 0.33333333333333, 1.54, 0.33333333333333
37299, 0.33333333333333, 1.58, 0.33333333333333
37300, 0.33333333333333, 1.62, 0.33333333333333
37301, 0.33333333333333, 1.66, 0.33333333333333
37302, 0.33333333333333, 1.54, 0.375
37303, 0.33333333333333, 1.58, 0.375
37304, 0.33333333333333, 1.62, 0.375
37305, 0.33333333333333, 1.66, 0.375
37306, 0.33333333333333, 1.54, 0.41666666666667
37307, 0.33333333333333, 1.58, 0.41666666666667
37308, 0.33333333333333, 1.62, 0.41666666666667
37309, 0.33333333333333, 1.66, 0.41666666666667
37310, 0.33333333333333, 1.54, 0.45833333333333
37311, 0.33333333333333, 1.58, 0.45833333333333
37312, 0.33333333333333, 1.62, 0.45833333333333
37313, 0.33333333333333, 1.66, 0.45833333333333
37314, 0.375, 1.54, 0.041666666666667
37315, 0.375, 1.58, 0.041666666666667
37316, 0.375, 1.62, 0.041666666666667
37317, 0.375, 1.66, 0.041666666666667
37318, 0.375, 1.54, 0.083333333333333
37319, 0.375, 1.58, 0.083333333333333
37320, 0.375, 1.62, 0.083333333333333
37321, 0.375, 1.66, 0.083333333333333
37322, 0.375, 1.54, 0.125
37323, 0.375, 1.58, 0.125
37324, 0.375, 1.62, 0.125
37325, 0.375, 1.66, 0.125
37326, 0.375, 1.54, 0.16666666666667
37327, 0.375, 1.58, 0.16666666666667
37328, 0.375, 1.62, 0.16666666666667
37329, 0.375, 1.66, 0.16666666666667
37330, 0.375, 1.54, 0.20833333333333
37331, 0.375, 1.58, 0.20833333333333
37332, 0.375, 1.62, 0.20833333333333
37333, 0.375, 1.66, 0.20833333333333
37334, 0.375, 1.54, 0.25
37335, 0.375, 1.58, 0.25
37336, 0.375, 1.62, 0.25
37337, 0.375, 1.66, 0.25
37338, 0.375, 1.54, 0.29166666666667
37339, 0.375, 1.58, 0.29166666666667
37340, 0.375, 1.62, 0.29166666666667
37341, 0.375, 1.66, 0.29166666666667
37342, 0.375, 1.54, 0.33333333333333
37343, 0.375, 1.58, 0.33333333333333
37344, 0.375, 1.62, 0.33333333333333
37345, 0.375, 1.66, 0.33333333333333
37346, 0.375, 1.54, 0.375
37347, 0.375, 1.58, 0.375
37348, 0.375, 1.62, 0.375
37349, 0.375, 1.66, 0.375
37350, 0.375, 1.54, 0.41666666666667
37351, 0.375, 1.58, 0.41666666666667
37352, 0.375, 1.62, 0.41666666666667
37353, 0.375, 1.66, 0.41666666666667
37354, 0.375, 1.54, 0.45833333333333
37355, 0.375, 1.58, 0.45833333333333
37356, 0.375, 1.62, 0.45833333333333
37357, 0.375, 1.66, 0.45833333333333
37358, 0.41666666666667, 1.54, 0.041666666666667
37359, 0.41666666666667, 1.58, 0.041666666666667
37360, 0.41666666666667, 1.62, 0.041666666666667
37361, 0.41666666666667, 1.66, 0.041666666666667
37362, 0.41666666666667, 1.54, 0.083333333333333
37363, 0.41666666666667, 1.58, 0.083333333333333
37364, 0.41666666666667, 1.62, 0.083333333333333
37365, 0.41666666666667, 1.66, 0.083333333333333
37366, 0.41666666666667, 1.54, 0.125
37367, 0.41666666666667, 1.58, 0.125
37368, 0.41666666666667, 1.62, 0.125
37369, 0.41666666666667, 1.66, 0.125
37370, 0.41666666666667, 1.54, 0.16666666666667
37371, 0.41666666666667, 1.58, 0.16666666666667
37372, 0.41666666666667, 1.62, 0.16666666666667
37373, 0.41666666666667, 1.66, 0.16666666666667
37374, 0.41666666666667, 1.54, 0.20833333333333
37375, 0.41666666666667, 1.58, 0.20833333333333
37376, 0.41666666666667, 1.62, 0.20833333333333
37377, 0.41666666666667, 1.66, 0.20833333333333
37378, 0.41666666666667, 1.54, 0.25
37379, 0.41666666666667, 1.58, 0.25
37380, 0.41666666666667, 1.62, 0.25
37381, 0.41666666666667, 1.66, 0.25
37382, 0.41666666666667, 1.54, 0.29166666666667
37383, 0.41666666666667, 1.58, 0.29166666666667
37384, 0.41666666666667, 1.62, 0.29166666666667
37385, 0.41666666666667, 1.66, 0.29166666666667
37386, 0.41666666666667, 1.54, 0.33333333333333
37387, 0.41666666666667, 1.58, 0.33333333333333
37388, 0.41666666666667, 1.62, 0.33333333333333
37389, 0.41666666666667, 1.66, 0.33333333333333
37390, 0.41666666666667, 1.54, 0.375
37391, 0.41666666666667, 1.58, 0.375
37392, 0.41666666666667, 1.62, 0.375
37393, 0.41666666666667, 1.66, 0.375
37394, 0.41666666666667, 1.54, 0.41666666666667
37395, 0.41666666666667, 1.58, 0.41666666666667
37396, 0.41666666666667, 1.62, 0.41666666666667
37397, 0.41666666666667, 1.66, 0.41666666666667
37398, 0.41666666666667, 1.54, 0.45833333333333
37399, 0.41666666666667, 1.58, 0.45833333333333
37400, 0.41666666666667, 1.62, 0.45833333333333
37401, 0.41666666666667, 1.66, 0.45833333333333
37402, 0.45833333333333, 1.54, 0.041666666666667
37403, 0.45833333333333, 1.58, 0.041666666666667
37404, 0.45833333333333, 1.62, 0.041666666666667
37405, 0.45833333333333, 1.66, 0.041666666666667
37406, 0.45833333333333, 1.54, 0.083333333333333
37407, 0.45833333333333, 1.58, 0.083333333333333
37408, 0.45833333333333, 1.62, 0.083333333333333
37409, 0.45833333333333, 1.66, 0.083333333333333
37410, 0.45833333333333, 1.54, 0.125
37411, 0.45833333333333, 1.58, 0.125
37412, 0.45833333333333, 1.62, 0.125
37413, 0.45833333333333, 1.66, 0.125
37414, 0.45833333333333, 1.54, 0.16666666666667
37415, 0.45833333333333, 1.58, 0.16666666666667
37416, 0.45833333333333, 1.62, 0.16666666666667
37417, 0.45833333333333, 1.66, 0.16666666666667
37418, 0.45833333333333, 1.54, 0.20833333333333
37419, 0.45833333333333, 1.58, 0.20833333333333
37420, 0.45833333333333, 1.62, 0.20833333333333
37421, 0.45833333333333, 1.66, 0.20833333333333
37422, 0.45833333333333, 1.54, 0.25
37423, 0.45833333333333, 1.58, 0.25
37424, 0.45833333333333, 1.62, 0.25
37425, 0.45833333333333, 1.66, 0.25
37426, 0.45833333333333, 1.54, 0.29166666666667
37427, 0.45833333333333, 1.58, 0.29166666666667
37428, 0.45833333333333, 1.62, 0.29166666666667
37429, 0.45833333333333, 1.66, 0.29166666666667
37430, 0.45833333333333, 1.54, 0.33333333333333
37431, 0.45833333333333, 1.58, 0.33333333333333
37432, 0.45833333333333, 1.62, 0.33333333333333
37433, 0.45833333333333, 1.66, 0.33333333333333
37434, 0.45833333333333, 1.54, 0.375
37435, 0.45833333333333, 1.58, 0.375
37436, 0.45833333333333, 1.62, 0.375
37437, 0.45833333333333, 1.66, 0.375
37438, 0.45833333333333, 1.54, 0.41666666666667
37439, 0.45833333333333, 1.58, 0.41666666666667
37440, 0.45833333333333, 1.62, 0.41666666666667
37441, 0.45833333333333, 1.66, 0.41666666666667
37442, 0.45833333333333, 1.54, 0.45833333333333
37443, 0.45833333333333, 1.58, 0.45833333333333
37444, 0.45833333333333, 1.62, 0.45833333333333
37445, 0.45833333333333, 1.66, 0.45833333333333
37446, 0.5, 1.54, 0.041666666666667
37447, 0.5, 1.58, 0.041666666666667
37448, 0.5, 1.62, 0.041666666666667
37449, 0.5, 1.66, 0.041666666666667
37450, 0.5, 1.54, 0.083333333333333
37451, 0.5, 1.58, 0.083333333333333
37452, 0.5, 1.62, 0.083333333333333
37453, 0.5, 1.66, 0.083333333333333
37454, 0.5, 1.54, 0.125
37455, 0.5, 1.58, 0.125
37456, 0.5, 1.62, 0.125
37457, 0.5, 1.66, 0.125
37458, 0.5, 1.54, 0.16666666666667
37459, 0.5, 1.58, 0.16666666666667
37460, 0.5, 1.62, 0.16666666666667
37461, 0.5, 1.66, 0.16666666666667
37462, 0.5, 1.54, 0.20833333333333
37463, 0.5, 1.58, 0.20833333333333
37464, 0.5, 1.62, 0.20833333333333
37465, 0.5, 1.66, 0.20833333333333
37466, 0.5, 1.54, 0.25
37467, 0.5, 1.58, 0.25
37468, 0.5, 1.62, 0.25
37469, 0.5, 1.66, 0.25
37470, 0.5, 1.54, 0.29166666666667
37471, 0.5, 1.58, 0.29166666666667
37472, 0.5, 1.62, 0.29166666666667
37473, 0.5, 1.66, 0.29166666666667
37474, 0.5, 1.54, 0.33333333333333
37475, 0.5, 1.58, 0.33333333333333
37476, 0.5, 1.62, 0.33333333333333
37477, 0.5, 1.66, 0.33333333333333
37478, 0.5, 1.54, 0.375
37479, 0.5, 1.58, 0.375
37480, 0.5, 1.62, 0.375
37481, 0.5, 1.66, 0.375
37482, 0.5, 1.54, 0.41666666666667
37483, 0.5, 1.58, 0.41666666666667
37484, 0.5, 1.62, 0.41666666666667
37485, 0.5, 1.66, 0.41666666666667
37486, 0.5, 1.54, 0.45833333333333
37487, 0.5, 1.58, 0.45833333333333
37488, 0.5, 1.62, 0.45833333333333
37489, 0.5, 1.66, 0.45833333333333
37490, 0.54166666666667, 1.54, 0.041666666666667
37491, 0.54166666666667, 1.58, 0.041666666666667
37492, 0.54166666666667, 1.62, 0.041666666666667
37493, 0.54166666666667, 1.66, 0.041666666666667
37494, 0.54166666666667, 1.54, 0.083333333333333
37495, 0.54166666666667, 1.58, 0.083333333333333
37496, 0.54166666666667, 1.62, 0.083333333333333
37497, 0.54166666666667, 1.66, 0.083333333333333
37498, 0.54166666666667, 1.54, 0.125
37499, 0.54166666666667, 1.58, 0.125
37500, 0.54166666666667, 1.62, 0.125
37501, 0.54166666666667, 1.66, 0.125
37502, 0.54166666666667, 1.54, 0.16666666666667
37503, 0.54166666666667, 1.58, 0.16666666666667
37504, 0.54166666666667, 1.62, 0.16666666666667
37505, 0.54166666666667, 1.66, 0.16666666666667
37506, 0.54166666666667, 1.54, 0.20833333333333
37507, 0.54166666666667, 1.58, 0.20833333333333
37508, 0.54166666666667, 1.62, 0.20833333333333
37509, 0.54166666666667, 1.66, 0.20833333333333
37510, 0.54166666666667, 1.54, 0.25
37511, 0.54166666666667, 1.58, 0.25
37512, 0.54166666666667, 1.62, 0.25
37513, 0.54166666666667, 1.66, 0.25
37514, 0.54166666666667, 1.54, 0.29166666666667
37515, 0.54166666666667, 1.58, 0.29166666666667
37516, 0.54166666666667, 1.62, 0.29166666666667
37517, 0.54166666666667, 1.66, 0.29166666666667
37518, 0.54166666666667, 1.54, 0.33333333333333
37519, 0.54166666666667, 1.58, 0.33333333333333
37520, 0.54166666666667, 1.62, 0.33333333333333
37521, 0.54166666666667, 1.66, 0.33333333333333
37522, 0.54166666666667, 1.54, 0.375
37523, 0.54166666666667, 1.58, 0.375
37524, 0.54166666666667, 1.62, 0.375
37525, 0.54166666666667, 1.66, 0.375
37526, 0.54166666666667, 1.54, 0.41666666666667
37527, 0.54166666666667, 1.58, 0.41666666666667
37528, 0.54166666666667, 1.62, 0.41666666666667
37529, 0.54166666666667, 1.66, 0.41666666666667
37530, 0.54166666666667, 1.54, 0.45833333333333
37531, 0.54166666666667, 1.58, 0.45833333333333
37532, 0.54166666666667, 1.62, 0.45833333333333
37533, 0.54166666666667, 1.66, 0.45833333333333
37534, 0.58333333333333, 1.54, 0.041666666666667
37535, 0.58333333333333, 1.58, 0.041666666666667
37536, 0.58333333333333, 1.62, 0.041666666666667
37537, 0.58333333333333, 1.66, 0.041666666666667
37538, 0.58333333333333, 1.54, 0.083333333333333
37539, 0.58333333333333, 1.58, 0.083333333333333
37540, 0.58333333333333, 1.62, 0.083333333333333
37541, 0.58333333333333, 1.66, 0.083333333333333
37542, 0.58333333333333, 1.54, 0.125
37543, 0.58333333333333, 1.58, 0.125
37544, 0.58333333333333, 1.62, 0.125
37545, 0.58333333333333, 1.66, 0.125
37546, 0.58333333333333, 1.54, 0.16666666666667
37547, 0.58333333333333, 1.58, 0.16666666666667
37548, 0.58333333333333, 1.62, 0.16666666666667
37549, 0.58333333333333, 1.66, 0.16666666666667
37550, 0.58333333333333, 1.54, 0.20833333333333
37551, 0.58333333333333, 1.58, 0.20833333333333
37552, 0.58333333333333, 1.62, 0.20833333333333
37553, 0.58333333333333, 1.66, 0.20833333333333
37554, 0.58333333333333, 1.54, 0.25
37555, 0.58333333333333, 1.58, 0.25
37556, 0.58333333333333, 1.62, 0.25
37557, 0.58333333333333, 1.66, 0.25
37558, 0.58333333333333, 1.54, 0.29166666666667
37559, 0.58333333333333, 1.58, 0.29166666666667
37560, 0.58333333333333, 1.62, 0.29166666666667
37561, 0.58333333333333, 1.66, 0.29166666666667
37562, 0.58333333333333, 1.54, 0.33333333333333
37563, 0.58333333333333, 1.58, 0.33333333333333
37564, 0.58333333333333, 1.62, 0.33333333333333
37565, 0.58333333333333, 1.66, 0.33333333333333
37566, 0.58333333333333, 1.54, 0.375
37567, 0.58333333333333, 1.58, 0.375
37568, 0.58333333333333, 1.62, 0.375
37569, 0.58333333333333, 1.66, 0.375
37570, 0.58333333333333, 1.54, 0.41666666666667
37571, 0.58333333333333, 1.58, 0.41666666666667
37572, 0.58333333333333, 1.62, 0.41666666666667
37573, 0.58333333333333, 1.66, 0.41666666666667
37574, 0.58333333333333, 1.54, 0.45833333333333
37575, 0.58333333333333, 1.58, 0.45833333333333
37576, 0.58333333333333, 1.62, 0.45833333333333
37577, 0.58333333333333, 1.66, 0.45833333333333
37578, 0.625, 1.54, 0.041666666666667
37579, 0.625, 1.58, 0.041666666666667
37580, 0.625, 1.62, 0.041666666666667
37581, 0.625, 1.66, 0.041666666666667
37582, 0.625, 1.54, 0.083333333333333
37583, 0.625, 1.58, 0.083333333333333
37584, 0.625, 1.62, 0.083333333333333
37585, 0.625, 1.66, 0.083333333333333
37586, 0.625, 1.54, 0.125
37587, 0.625, 1.58, 0.125
37588, 0.625, 1.62, 0.125
37589, 0.625, 1.66, 0.125
37590, 0.625, 1.54, 0.16666666666667
37591, 0.625, 1.58, 0.16666666666667
37592, 0.625, 1.62, 0.16666666666667
37593, 0.625, 1.66, 0.16666666666667
37594, 0.625, 1.54, 0.20833333333333
37595, 0.625, 1.58, 0.20833333333333
37596, 0.625, 1.62, 0.20833333333333
37597, 0.625, 1.66, 0.20833333333333
37598, 0.625, 1.54, 0.25
37599, 0.625, 1.58, 0.25
37600, 0.625, 1.62, 0.25
37601, 0.625, 1.66, 0.25
37602, 0.625, 1.54, 0.29166666666667
37603, 0.625, 1.58, 0.29166666666667
37604, 0.625, 1.62, 0.29166666666667
37605, 0.625, 1.66, 0.29166666666667
37606, 0.625, 1.54, 0.33333333333333
37607, 0.625, 1.58, 0.33333333333333
37608, 0.625, 1.62, 0.33333333333333
37609, 0.625, 1.66, 0.33333333333333
37610, 0.625, 1.54, 0.375
37611, 0.625, 1.58, 0.375
37612, 0.625, 1.62, 0.375
37613, 0.625, 1.66, 0.375
37614, 0.625, 1.54, 0.41666666666667
37615, 0.625, 1.58, 0.41666666666667
37616, 0.625, 1.62, 0.41666666666667
37617, 0.625, 1.66, 0.41666666666667
37618, 0.625, 1.54, 0.45833333333333
37619, 0.625, 1.58, 0.45833333333333
37620, 0.625, 1.62, 0.45833333333333
37621, 0.625, 1.66, 0.45833333333333
37622, 0.66666666666667, 1.54, 0.041666666666667
37623, 0.66666666666667, 1.58, 0.041666666666667
37624, 0.66666666666667, 1.62, 0.041666666666667
37625, 0.66666666666667, 1.66, 0.041666666666667
37626, 0.66666666666667, 1.54, 0.083333333333333
37627, 0.66666666666667, 1.58, 0.083333333333333
37628, 0.66666666666667, 1.62, 0.083333333333333
37629, 0.66666666666667, 1.66, 0.083333333333333
37630, 0.66666666666667, 1.54, 0.125
37631, 0.66666666666667, 1.58, 0.125
37632, 0.66666666666667, 1.62, 0.125
37633, 0.66666666666667, 1.66, 0.125
37634, 0.66666666666667, 1.54, 0.16666666666667
37635, 0.66666666666667, 1.58, 0.16666666666667
37636, 0.66666666666667, 1.62, 0.16666666666667
37637, 0.66666666666667, 1.66, 0.16666666666667
37638, 0.66666666666667, 1.54, 0.20833333333333
37639, 0.66666666666667, 1.58, 0.20833333333333
37640, 0.66666666666667, 1.62, 0.20833333333333
37641, 0.66666666666667, 1.66, 0.20833333333333
37642, 0.66666666666667, 1.54, 0.25
37643, 0.66666666666667, 1.58, 0.25
37644, 0.66666666666667, 1.62, 0.25
37645, 0.66666666666667, 1.66, 0.25
37646, 0.66666666666667, 1.54, 0.29166666666667
37647, 0.66666666666667, 1.58, 0.29166666666667
37648, 0.66666666666667, 1.62, 0.29166666666667
37649, 0.66666666666667, 1.66, 0.29166666666667
37650, 0.66666666666667, 1.54, 0.33333333333333
37651, 0.66666666666667, 1.58, 0.33333333333333
37652, 0.66666666666667, 1.62, 0.33333333333333
37653, 0.66666666666667, 1.66, 0.33333333333333
37654, 0.66666666666667, 1.54, 0.375
37655, 0.66666666666667, 1.58, 0.375
37656, 0.66666666666667, 1.62, 0.375
37657, 0.66666666666667, 1.66, 0.375
37658, 0.66666666666667, 1.54, 0.41666666666667
37659, 0.66666666666667, 1.58, 0.41666666666667
37660, 0.66666666666667, 1.62, 0.41666666666667
37661, 0.66666666666667, 1.66, 0.41666666666667
37662, 0.66666666666667, 1.54, 0.45833333333333
37663, 0.66666666666667, 1.58, 0.45833333333333
37664, 0.66666666666667, 1.62, 0.45833333333333
37665, 0.66666666666667, 1.66, 0.45833333333333
37666, 0.70833333333333, 1.54, 0.041666666666667
37667, 0.70833333333333, 1.58, 0.041666666666667
37668, 0.70833333333333, 1.62, 0.041666666666667
37669, 0.70833333333333, 1.66, 0.041666666666667
37670, 0.70833333333333, 1.54, 0.083333333333333
37671, 0.70833333333333, 1.58, 0.083333333333333
37672, 0.70833333333333, 1.62, 0.083333333333333
37673, 0.70833333333333, 1.66, 0.083333333333333
37674, 0.70833333333333, 1.54, 0.125
37675, 0.70833333333333, 1.58, 0.125
37676, 0.70833333333333, 1.62, 0.125
37677, 0.70833333333333, 1.66, 0.125
37678, 0.70833333333333, 1.54, 0.16666666666667
37679, 0.70833333333333, 1.58, 0.16666666666667
37680, 0.70833333333333, 1.62, 0.16666666666667
37681, 0.70833333333333, 1.66, 0.16666666666667
37682, 0.70833333333333, 1.54, 0.20833333333333
37683, 0.70833333333333, 1.58, 0.20833333333333
37684, 0.70833333333333, 1.62, 0.20833333333333
37685, 0.70833333333333, 1.66, 0.20833333333333
37686, 0.70833333333333, 1.54, 0.25
37687, 0.70833333333333, 1.58, 0.25
37688, 0.70833333333333, 1.62, 0.25
37689, 0.70833333333333, 1.66, 0.25
37690, 0.70833333333333, 1.54, 0.29166666666667
37691, 0.70833333333333, 1.58, 0.29166666666667
37692, 0.70833333333333, 1.62, 0.29166666666667
37693, 0.70833333333333, 1.66, 0.29166666666667
37694, 0.70833333333333, 1.54, 0.33333333333333
37695, 0.70833333333333, 1.58, 0.33333333333333
37696, 0.70833333333333, 1.62, 0.33333333333333
37697, 0.70833333333333, 1.66, 0.33333333333333
37698, 0.70833333333333, 1.54, 0.375
37699, 0.70833333333333, 1.58, 0.375
37700, 0.70833333333333, 1.62, 0.375
37701, 0.70833333333333, 1.66, 0.375
37702, 0.70833333333333, 1.54, 0.41666666666667
37703, 0.70833333333333, 1.58, 0.41666666666667
37704, 0.70833333333333, 1.62, 0.41666666666667
37705, 0.70833333333333, 1.66, 0.41666666666667
37706, 0.70833333333333, 1.54, 0.45833333333333
37707, 0.70833333333333, 1.58, 0.45833333333333
37708, 0.70833333333333, 1.62, 0.45833333333333
37709, 0.70833333333333, 1.66, 0.45833333333333
37710, 0.75, 1.54, 0.041666666666667
37711, 0.75, 1.58, 0.041666666666667
37712, 0.75, 1.62, 0.041666666666667
37713, 0.75, 1.66, 0.041666666666667
37714, 0.75, 1.54, 0.083333333333333
37715, 0.75, 1.58, 0.083333333333333
37716, 0.75, 1.62, 0.083333333333333
37717, 0.75, 1.66, 0.083333333333333
37718, 0.75, 1.54, 0.125
37719, 0.75, 1.58, 0.125
37720, 0.75, 1.62, 0.125
37721, 0.75, 1.66, 0.125
37722, 0.75, 1.54, 0.16666666666667
37723, 0.75, 1.58, 0.16666666666667
37724, 0.75, 1.62, 0.16666666666667
37725, 0.75, 1.66, 0.16666666666667
37726, 0.75, 1.54, 0.20833333333333
37727, 0.75, 1.58, 0.20833333333333
37728, 0.75, 1.62, 0.20833333333333
37729, 0.75, 1.66, 0.20833333333333
37730, 0.75, 1.54, 0.25
37731, 0.75, 1.58, 0.25
37732, 0.75, 1.62, 0.25
37733, 0.75, 1.66, 0.25
37734, 0.75, 1.54, 0.29166666666667
37735, 0.75, 1.58, 0.29166666666667
37736, 0.75, 1.62, 0.29166666666667
37737, 0.75, 1.66, 0.29166666666667
37738, 0.75, 1.54, 0.33333333333333
37739, 0.75, 1.58, 0.33333333333333
37740, 0.75, 1.62, 0.33333333333333
37741, 0.75, 1.66, 0.33333333333333
37742, 0.75, 1.54, 0.375
37743, 0.75, 1.58, 0.375
37744, 0.75, 1.62, 0.375
37745, 0.75, 1.66, 0.375
37746, 0.75, 1.54, 0.41666666666667
37747, 0.75, 1.58, 0.41666666666667
37748, 0.75, 1.62, 0.41666666666667
37749, 0.75, 1.66, 0.41666666666667
37750, 0.75, 1.54, 0.45833333333333
37751, 0.75, 1.58, 0.45833333333333
37752, 0.75, 1.62, 0.45833333333333
37753, 0.75, 1.66, 0.45833333333333
37754, 0.79166666666667, 1.54, 0.041666666666667
37755, 0.79166666666667, 1.58, 0.041666666666667
37756, 0.79166666666667, 1.62, 0.041666666666667
37757, 0.79166666666667, 1.66, 0.041666666666667
37758, 0.79166666666667, 1.54, 0.083333333333333
37759, 0.79166666666667, 1.58, 0.083333333333333
37760, 0.79166666666667, 1.62, 0.083333333333333
37761, 0.79166666666667, 1.66, 0.083333333333333
37762, 0.79166666666667, 1.54, 0.125
37763, 0.79166666666667, 1.58, 0.125
37764, 0.79166666666667, 1.62, 0.125
37765, 0.79166666666667, 1.66, 0.125
37766, 0.79166666666667, 1.54, 0.16666666666667
37767, 0.79166666666667, 1.58, 0.16666666666667
37768, 0.79166666666667, 1.62, 0.16666666666667
37769, 0.79166666666667, 1.66, 0.16666666666667
37770, 0.79166666666667, 1.54, 0.20833333333333
37771, 0.79166666666667, 1.58, 0.20833333333333
37772, 0.79166666666667, 1.62, 0.20833333333333
37773, 0.79166666666667, 1.66, 0.20833333333333
37774, 0.79166666666667, 1.54, 0.25
37775, 0.79166666666667, 1.58, 0.25
37776, 0.79166666666667, 1.62, 0.25
37777, 0.79166666666667, 1.66, 0.25
37778, 0.79166666666667, 1.54, 0.29166666666667
37779, 0.79166666666667, 1.58, 0.29166666666667
37780, 0.79166666666667, 1.62, 0.29166666666667
37781, 0.79166666666667, 1.66, 0.29166666666667
37782, 0.79166666666667, 1.54, 0.33333333333333
37783, 0.79166666666667, 1.58, 0.33333333333333
37784, 0.79166666666667, 1.62, 0.33333333333333
37785, 0.79166666666667, 1.66, 0.33333333333333
37786, 0.79166666666667, 1.54, 0.375
37787, 0.79166666666667, 1.58, 0.375
37788, 0.79166666666667, 1.62, 0.375
37789, 0.79166666666667, 1.66, 0.375
37790, 0.79166666666667, 1.54, 0.41666666666667
37791, 0.79166666666667, 1.58, 0.41666666666667
37792, 0.79166666666667, 1.62, 0.41666666666667
37793, 0.79166666666667, 1.66, 0.41666666666667
37794, 0.79166666666667, 1.54, 0.45833333333333
37795, 0.79166666666667, 1.58, 0.45833333333333
37796, 0.79166666666667, 1.62, 0.45833333333333
37797, 0.79166666666667, 1.66, 0.45833333333333
37798, 0.83333333333333, 1.54, 0.041666666666667
37799, 0.83333333333333, 1.58, 0.041666666666667
37800, 0.83333333333333, 1.62, 0.041666666666667
37801, 0.83333333333333, 1.66, 0.041666666666667
37802, 0.83333333333333, 1.54, 0.083333333333333
37803, 0.83333333333333, 1.58, 0.083333333333333
37804, 0.83333333333333, 1.62, 0.083333333333333
37805, 0.83333333333333, 1.66, 0.083333333333333
37806, 0.83333333333333, 1.54, 0.125
37807, 0.83333333333333, 1.58, 0.125
37808, 0.83333333333333, 1.62, 0.125
37809, 0.83333333333333, 1.66, 0.125
37810, 0.83333333333333, 1.54, 0.16666666666667
37811, 0.83333333333333, 1.58, 0.16666666666667
37812, 0.83333333333333, 1.62, 0.16666666666667
37813, 0.83333333333333, 1.66, 0.16666666666667
37814, 0.83333333333333, 1.54, 0.20833333333333
37815, 0.83333333333333, 1.58, 0.20833333333333
37816, 0.83333333333333, 1.62, 0.20833333333333
37817, 0.83333333333333, 1.66, 0.20833333333333
37818, 0.83333333333333, 1.54, 0.25
37819, 0.83333333333333, 1.58, 0.25
37820, 0.83333333333333, 1.62, 0.25
37821, 0.83333333333333, 1.66, 0.25
37822, 0.83333333333333, 1.54, 0.29166666666667
37823, 0.83333333333333, 1.58, 0.29166666666667
37824, 0.83333333333333, 1.62, 0.29166666666667
37825, 0.83333333333333, 1.66, 0.29166666666667
37826, 0.83333333333333, 1.54, 0.33333333333333
37827, 0.83333333333333, 1.58, 0.33333333333333
37828, 0.83333333333333, 1.62, 0.33333333333333
37829, 0.83333333333333, 1.66, 0.33333333333333
37830, 0.83333333333333, 1.54, 0.375
37831, 0.83333333333333, 1.58, 0.375
37832, 0.83333333333333, 1.62, 0.375
37833, 0.83333333333333, 1.66, 0.375
37834, 0.83333333333333, 1.54, 0.41666666666667
37835, 0.83333333333333, 1.58, 0.41666666666667
37836, 0.83333333333333, 1.62, 0.41666666666667
37837, 0.83333333333333, 1.66, 0.41666666666667
37838, 0.83333333333333, 1.54, 0.45833333333333
37839, 0.83333333333333, 1.58, 0.45833333333333
37840, 0.83333333333333, 1.62, 0.45833333333333
37841, 0.83333333333333, 1.66, 0.45833333333333
37842, 0.875, 1.54, 0.041666666666667
37843, 0.875, 1.58, 0.041666666666667
37844, 0.875, 1.62, 0.041666666666667
37845, 0.875, 1.66, 0.041666666666667
37846, 0.875, 1.54, 0.083333333333333
37847, 0.875, 1.58, 0.083333333333333
37848, 0.875, 1.62, 0.083333333333333
37849, 0.875, 1.66, 0.083333333333333
37850, 0.875, 1.54, 0.125
37851, 0.875, 1.58, 0.125
37852, 0.875, 1.62, 0.125
37853, 0.875, 1.66, 0.125
37854, 0.875, 1.54, 0.16666666666667
37855, 0.875, 1.58, 0.16666666666667
37856, 0.875, 1.62, 0.16666666666667
37857, 0.875, 1.66, 0.16666666666667
37858, 0.875, 1.54, 0.20833333333333
37859, 0.875, 1.58, 0.20833333333333
37860, 0.875, 1.62, 0.20833333333333
37861, 0.875, 1.66, 0.20833333333333
37862, 0.875, 1.54, 0.25
37863, 0.875, 1.58, 0.25
37864, 0.875, 1.62, 0.25
37865, 0.875, 1.66, 0.25
37866, 0.875, 1.54, 0.29166666666667
37867, 0.875, 1.58, 0.29166666666667
37868, 0.875, 1.62, 0.29166666666667
37869, 0.875, 1.66, 0.29166666666667
37870, 0.875, 1.54, 0.33333333333333
37871, 0.875, 1.58, 0.33333333333333
37872, 0.875, 1.62, 0.33333333333333
37873, 0.875, 1.66, 0.33333333333333
37874, 0.875, 1.54, 0.375
37875, 0.875, 1.58, 0.375
37876, 0.875, 1.62, 0.375
37877, 0.875, 1.66, 0.375
37878, 0.875, 1.54, 0.41666666666667
37879, 0.875, 1.58, 0.41666666666667
37880, 0.875, 1.62, 0.41666666666667
37881, 0.875, 1.66, 0.41666666666667
37882, 0.875, 1.54, 0.45833333333333
37883, 0.875, 1.58, 0.45833333333333
37884, 0.875, 1.62, 0.45833333333333
37885, 0.875, 1.66, 0.45833333333333
37886, 0.91666666666667, 1.54, 0.041666666666667
37887, 0.91666666666667, 1.58, 0.041666666666667
37888, 0.91666666666667, 1.62, 0.041666666666667
37889, 0.91666666666667, 1.66, 0.041666666666667
37890, 0.91666666666667, 1.54, 0.083333333333333
37891, 0.91666666666667, 1.58, 0.083333333333333
37892, 0.91666666666667, 1.62, 0.083333333333333
37893, 0.91666666666667, 1.66, 0.083333333333333
37894, 0.91666666666667, 1.54, 0.125
37895, 0.91666666666667, 1.58, 0.125
37896, 0.91666666666667, 1.62, 0.125
37897, 0.91666666666667, 1.66, 0.125
37898, 0.91666666666667, 1.54, 0.16666666666667
37899, 0.91666666666667, 1.58, 0.16666666666667
37900, 0.91666666666667, 1.62, 0.16666666666667
37901, 0.91666666666667, 1.66, 0.16666666666667
37902, 0.91666666666667, 1.54, 0.20833333333333
37903, 0.91666666666667, 1.58, 0.20833333333333
37904, 0.91666666666667, 1.62, 0.20833333333333
37905, 0.91666666666667, 1.66, 0.20833333333333
37906, 0.91666666666667, 1.54, 0.25
37907, 0.91666666666667, 1.58, 0.25
37908, 0.91666666666667, 1.62, 0.25
37909, 0.91666666666667, 1.66, 0.25
37910, 0.91666666666667, 1.54, 0.29166666666667
37911, 0.91666666666667, 1.58, 0.29166666666667
37912, 0.91666666666667, 1.62, 0.29166666666667
37913, 0.91666666666667, 1.66, 0.29166666666667
37914, 0.91666666666667, 1.54, 0.33333333333333
37915, 0.91666666666667, 1.58, 0.33333333333333
37916, 0.91666666666667, 1.62, 0.33333333333333
37917, 0.91666666666667, 1.66, 0.33333333333333
37918, 0.91666666666667, 1.54, 0.375
37919, 0.91666666666667, 1.58, 0.375
37920, 0.91666666666667, 1.62, 0.375
37921, 0.91666666666667, 1.66, 0.375
37922, 0.91666666666667, 1.54, 0.41666666666667
37923, 0.91666666666667, 1.58, 0.41666666666667
37924, 0.91666666666667, 1.62, 0.41666666666667
37925, 0.91666666666667, 1.66, 0.41666666666667
37926, 0.91666666666667, 1.54, 0.45833333333333
37927, 0.91666666666667, 1.58, 0.45833333333333
37928, 0.91666666666667, 1.62, 0.45833333333333
37929, 0.91666666666667, 1.66, 0.45833333333333
37930, 0.95833333333333, 1.54, 0.041666666666667
37931, 0.95833333333333, 1.58, 0.041666666666667
37932, 0.95833333333333, 1.62, 0.041666666666667
37933, 0.95833333333333, 1.66, 0.041666666666667
37934, 0.95833333333333, 1.54, 0.083333333333333
37935, 0.95833333333333, 1.58, 0.083333333333333
37936, 0.95833333333333, 1.62, 0.083333333333333
37937, 0.95833333333333, 1.66, 0.083333333333333
37938, 0.95833333333333, 1.54, 0.125
37939, 0.95833333333333, 1.58, 0.125
37940, 0.95833333333333, 1.62, 0.125
37941, 0.95833333333333, 1.66, 0.125
37942, 0.95833333333333, 1.54, 0.16666666666667
37943, 0.95833333333333, 1.58, 0.16666666666667
37944, 0.95833333333333, 1.62, 0.16666666666667
37945, 0.95833333333333, 1.66, 0.16666666666667
37946, 0.95833333333333, 1.54, 0.20833333333333
37947, 0.95833333333333, 1.58, 0.20833333333333
37948, 0.95833333333333, 1.62, 0.20833333333333
37949, 0.95833333333333, 1.66, 0.20833333333333
37950, 0.95833333333333, 1.54, 0.25
37951, 0.95833333333333, 1.58, 0.25
37952, 0.95833333333333, 1.62, 0.25
37953, 0.95833333333333, 1.66, 0.25
37954, 0.95833333333333, 1.54, 0.29166666666667
37955, 0.95833333333333, 1.58, 0.29166666666667
37956, 0.95833333333333, 1.62, 0.29166666666667
37957, 0.95833333333333, 1.66, 0.29166666666667
37958, 0.95833333333333, 1.54, 0.33333333333333
37959, 0.95833333333333, 1.58, 0.33333333333333
37960, 0.95833333333333, 1.62, 0.33333333333333
37961, 0.95833333333333, 1.66, 0.33333333333333
37962, 0.95833333333333, 1.54, 0.375
37963, 0.95833333333333, 1.58, 0.375
37964, 0.95833333333333, 1.62, 0.375
37965, 0.95833333333333, 1.66, 0.375
37966, 0.95833333333333, 1.54, 0.41666666666667
37967, 0.95833333333333, 1.58, 0.41666666666667
37968, 0.95833333333333, 1.62, 0.41666666666667
37969, 0.95833333333333, 1.66, 0.41666666666667
37970, 0.95833333333333, 1.54, 0.45833333333333
37971, 0.95833333333333, 1.58, 0.45833333333333
37972, 0.95833333333333, 1.62, 0.45833333333333
37973, 0.95833333333333, 1.66, 0.45833333333333
37974, 0.041666666666667, 1.52, 0.041666666666667
37975, 0.020833333333333, 1.54, 0.041666666666667
37976, 0.041666666666667, 1.54, 0.020833333333333
37977, 0.041666666666667, 1.56, 0.041666666666667
37978, 0.020833333333333, 1.58, 0.041666666666667
37979, 0.041666666666667, 1.58, 0.020833333333333
37980, 0.041666666666667, 1.6, 0.041666666666667
37981, 0.020833333333333, 1.62, 0.041666666666667
37982, 0.041666666666667, 1.62, 0.020833333333333
37983, 0.041666666666667, 1.64, 0.041666666666667
37984, 0.020833333333333, 1.66, 0.041666666666667
37985, 0.041666666666667, 1.66, 0.020833333333333
37986, 0.041666666666667, 1.68, 0.041666666666667
37987, 0.041666666666667, 1.52, 0.083333333333333
37988, 0.020833333333333, 1.54, 0.083333333333333
37989, 0.041666666666667, 1.54, 0.0625
37990, 0.041666666666667, 1.56, 0.083333333333333
37991, 0.020833333333333, 1.58, 0.083333333333333
37992, 0.041666666666667, 1.58, 0.0625
37993, 0.041666666666667, 1.6, 0.083333333333333
37994, 0.020833333333333, 1.62, 0.083333333333333
37995, 0.041666666666667, 1.62, 0.0625
37996, 0.041666666666667, 1.64, 0.083333333333333
37997, 0.020833333333333, 1.66, 0.083333333333333
37998, 0.041666666666667, 1.66, 0.0625
37999, 0.041666666666667, 1.68, 0.083333333333333
38000, 0.041666666666667, 1.52, 0.125
38001, 0.020833333333333, 1.54, 0.125
38002, 0.041666666666667, 1.54, 0.10416666666667
38003, 0.041666666666667, 1.56, 0.125
38004, 0.020833333333333, 1.58, 0.125
38005, 0.041666666666667, 1.58, 0.10416666666667
38006, 0.041666666666667, 1.6, 0.125
38007, 0.020833333333333, 1.62, 0.125
38008, 0.041666666666667, 1.62, 0.10416666666667
38009, 0.041666666666667, 1.64, 0.125
38010, 0.020833333333333, 1.66, 0.125
38011, 0.041666666666667, 1.66, 0.10416666666667
38012, 0.041666666666667, 1.68, 0.125
38013, 0.041666666666667, 1.52, 0.16666666666667
38014, 0.020833333333333, 1.54, 0.16666666666667
38015, 0.041666666666667, 1.54, 0.14583333333333
38016, 0.041666666666667, 1.56, 0.16666666666667
38017, 0.020833333333333, 1.58, 0.16666666666667
38018, 0.041666666666667, 1.58, 0.14583333333333
38019, 0.041666666666667, 1.6, 0.16666666666667
38020, 0.020833333333333, 1.62, 0.16666666666667
38021, 0.041666666666667, 1.62, 0.14583333333333
38022, 0.041666666666667, 1.64, 0.16666666666667
38023, 0.020833333333333, 1.66, 0.16666666666667
38024, 0.041666666666667, 1.66, 0.14583333333333
38025, 0.041666666666667, 1.68, 0.16666666666667
38026, 0.041666666666667, 1.52, 0.20833333333333
38027, 0.020833333333333, 1.54, 0.20833333333333
38028, 0.041666666666667, 1.54, 0.1875
38029, 0.041666666666667, 1.56, 0.20833333333333
38030, 0.020833333333333, 1.58, 0.20833333333333
38031, 0.041666666666667, 1.58, 0.1875
38032, 0.041666666666667, 1.6, 0.20833333333333
38033, 0.020833333333333, 1.62, 0.20833333333333
38034, 0.041666666666667, 1.62, 0.1875
38035, 0.041666666666667, 1.64, 0.20833333333333
38036, 0.020833333333333, 1.66, 0.20833333333333
38037, 0.041666666666667, 1.66, 0.1875
38038, 0.041666666666667, 1.68, 0.20833333333333
38039, 0.041666666666667, 1.52, 0.25
38040, 0.020833333333333, 1.54, 0.25
38041, 0.041666666666667, 1.54, 0.22916666666667
38042, 0.041666666666667, 1.56, 0.25
38043, 0.020833333333333, 1.58, 0.25
38044, 0.041666666666667, 1.58, 0.22916666666667
38045, 0.041666666666667, 1.6, 0.25
38046, 0.020833333333333, 1.62, 0.25
38047, 0.041666666666667, 1.62, 0.22916666666667
38048, 0.041666666666667, 1.64, 0.25
38049, 0.020833333333333, 1.66, 0.25
38050, 0.041666666666667, 1.66, 0.22916666666667
38051, 0.041666666666667, 1.68, 0.25
38052, 0.041666666666667, 1.52, 0.29166666666667
38053, 0.020833333333333, 1.54, 0.29166666666667
38054, 0.041666666666667, 1.54, 0.27083333333333
38055, 0.041666666666667, 1.56, 0.29166666666667
38056, 0.020833333333333, 1.58, 0.29166666666667
38057, 0.041666666666667, 1.58, 0.27083333333333
38058, 0.041666666666667, 1.6, 0.29166666666667
38059, 0.020833333333333, 1.62, 0.29166666666667
38060, 0.041666666666667, 1.62, 0.27083333333333
38061, 0.041666666666667, 1.64, 0.29166666666667
38062, 0.020833333333333, 1.66, 0.29166666666667
38063, 0.041666666666667, 1.66, 0.27083333333333
38064, 0.041666666666667, 1.68, 0.29166666666667
38065, 0.041666666666667, 1.52, 0.33333333333333
38066, 0.020833333333333, 1.54, 0.33333333333333
38067, 0.041666666666667, 1.54, 0.3125
38068, 0.041666666666667, 1.56, 0.33333333333333
38069, 0.020833333333333, 1.58, 0.33333333333333
38070, 0.041666666666667, 1.58, 0.3125
38071, 0.041666666666667, 1.6, 0.33333333333333
38072, 0.020833333333333, 1.62, 0.33333333333333
38073, 0.041666666666667, 1.62, 0.3125
38074, 0.041666666666667, 1.64, 0.33333333333333
38075, 0.020833333333333, 1.66, 0.33333333333333
38076, 0.041666666666667, 1.66, 0.3125
38077, 0.041666666666667, 1.68, 0.33333333333333
38078, 0.041666666666667, 1.52, 0.375
38079, 0.020833333333333, 1.54, 0.375
38080, 0.041666666666667, 1.54, 0.35416666666667
38081, 0.041666666666667, 1.56, 0.375
38082, 0.020833333333333, 1.58, 0.375
38083, 0.041666666666667, 1.58, 0.35416666666667
38084, 0.041666666666667, 1.6, 0.375
38085, 0.020833333333333, 1.62, 0.375
38086, 0.041666666666667, 1.62, 0.35416666666667
38087, 0.041666666666667, 1.64, 0.375
38088, 0.020833333333333, 1.66, 0.375
38089, 0.041666666666667, 1.66, 0.35416666666667
38090, 0.041666666666667, 1.68, 0.375
38091, 0.041666666666667, 1.52, 0.41666666666667
38092, 0.020833333333333, 1.54, 0.41666666666667
38093, 0.041666666666667, 1.54, 0.39583333333333
38094, 0.041666666666667, 1.56, 0.41666666666667
38095, 0.020833333333333, 1.58, 0.41666666666667
38096, 0.041666666666667, 1.58, 0.39583333333333
38097, 0.041666666666667, 1.6, 0.41666666666667
38098, 0.020833333333333, 1.62, 0.41666666666667
38099, 0.041666666666667, 1.62, 0.39583333333333
38100, 0.041666666666667, 1.64, 0.41666666666667
38101, 0.020833333333333, 1.66, 0.41666666666667
38102, 0.041666666666667, 1.66, 0.39583333333333
38103, 0.041666666666667, 1.68, 0.41666666666667
38104, 0.041666666666667, 1.52, 0.45833333333333
38105, 0.020833333333333, 1.54, 0.45833333333333
38106, 0.041666666666667, 1.54, 0.4375
38107, 0.041666666666667, 1.56, 0.45833333333333
38108, 0.020833333333333, 1.58, 0.45833333333333
38109, 0.041666666666667, 1.58, 0.4375
38110, 0.041666666666667, 1.6, 0.45833333333333
38111, 0.020833333333333, 1.62, 0.45833333333333
38112, 0.041666666666667, 1.62, 0.4375
38113, 0.041666666666667, 1.64, 0.45833333333333
38114, 0.020833333333333, 1.66, 0.45833333333333
38115, 0.041666666666667, 1.66, 0.4375
38116, 0.041666666666667, 1.68, 0.45833333333333
38117, 0.041666666666667, 1.54, 0.47916666666667
38118, 0.041666666666667, 1.58, 0.47916666666667
38119, 0.041666666666667, 1.62, 0.47916666666667
38120, 0.041666666666667, 1.66, 0.47916666666667
38121, 0.083333333333333, 1.52, 0.041666666666667
38122, 0.0625, 1.54, 0.041666666666667
38123, 0.083333333333333, 1.54, 0.020833333333333
38124, 0.083333333333333, 1.56, 0.041666666666667
38125, 0.0625, 1.58, 0.041666666666667
38126, 0.083333333333333, 1.58, 0.020833333333333
38127, 0.083333333333333, 1.6, 0.041666666666667
38128, 0.0625, 1.62, 0.041666666666667
38129, 0.083333333333333, 1.62, 0.020833333333333
38130, 0.083333333333333, 1.64, 0.041666666666667
38131, 0.0625, 1.66, 0.041666666666667
38132, 0.083333333333333, 1.66, 0.020833333333333
38133, 0.083333333333333, 1.68, 0.041666666666667
38134, 0.083333333333333, 1.52, 0.083333333333333
38135, 0.0625, 1.54, 0.083333333333333
38136, 0.083333333333333, 1.54, 0.0625
38137, 0.083333333333333, 1.56, 0.083333333333333
38138, 0.0625, 1.58, 0.083333333333333
38139, 0.083333333333333, 1.58, 0.0625
38140, 0.083333333333333, 1.6, 0.083333333333333
38141, 0.0625, 1.62, 0.083333333333333
38142, 0.083333333333333, 1.62, 0.0625
38143, 0.083333333333333, 1.64, 0.083333333333333
38144, 0.0625, 1.66, 0.083333333333333
38145, 0.083333333333333, 1.66, 0.0625
38146, 0.083333333333333, 1.68, 0.083333333333333
38147, 0.083333333333333, 1.52, 0.125
38148, 0.0625, 1.54, 0.125
38149, 0.083333333333333, 1.54, 0.10416666666667
38150, 0.083333333333333, 1.56, 0.125
38151, 0.0625, 1.58, 0.125
38152, 0.083333333333333, 1.58, 0.10416666666667
38153, 0.083333333333333, 1.6, 0.125
38154, 0.0625, 1.62, 0.125
38155, 0.083333333333333, 1.62, 0.10416666666667
38156, 0.083333333333333, 1.64, 0.125
38157, 0.0625, 1.66, 0.125
38158, 0.083333333333333, 1.66, 0.10416666666667
38159, 0.083333333333333, 1.68, 0.125
38160, 0.083333333333333, 1.52, 0.16666666666667
38161, 0.0625, 1.54, 0.16666666666667
38162, 0.083333333333333, 1.54, 0.14583333333333
38163, 0.083333333333333, 1.56, 0.16666666666667
38164, 0.0625, 1.58, 0.16666666666667
38165, 0.083333333333333, 1.58, 0.14583333333333
38166, 0.083333333333333, 1.6, 0.16666666666667
38167, 0.0625, 1.62, 0.16666666666667
38168, 0.083333333333333, 1.62, 0.14583333333333
38169, 0.083333333333333, 1.64, 0.16666666666667
38170, 0.0625, 1.66, 0.16666666666667
38171, 0.083333333333333, 1.66, 0.14583333333333
38172, 0.083333333333333, 1.68, 0.16666666666667
38173, 0.083333333333333, 1.52, 0.20833333333333
38174, 0.0625, 1.54, 0.20833333333333
38175, 0.083333333333333, 1.54, 0.1875
38176, 0.083333333333333, 1.56, 0.20833333333333
38177, 0.0625, 1.58, 0.20833333333333
38178, 0.083333333333333, 1.58, 0.1875
38179, 0.083333333333333, 1.6, 0.20833333333333
38180, 0.0625, 1.62, 0.20833333333333
38181, 0.083333333333333, 1.62, 0.1875
38182, 0.083333333333333, 1.64, 0.20833333333333
38183, 0.0625, 1.66, 0.20833333333333
38184, 0.083333333333333, 1.66, 0.1875
38185, 0.083333333333333, 1.68, 0.20833333333333
38186, 0.083333333333333, 1.52, 0.25
38187, 0.0625, 1.54, 0.25
38188, 0.083333333333333, 1.54, 0.22916666666667
38189, 0.083333333333333, 1.56, 0.25
38190, 0.0625, 1.58, 0.25
38191, 0.083333333333333, 1.58, 0.22916666666667
38192, 0.083333333333333, 1.6, 0.25
38193, 0.0625, 1.62, 0.25
38194, 0.083333333333333, 1.62, 0.22916666666667
38195, 0.083333333333333, 1.64, 0.25
38196, 0.0625, 1.66, 0.25
38197, 0.083333333333333, 1.66, 0.22916666666667
38198, 0.083333333333333, 1.68, 0.25
38199, 0.083333333333333, 1.52, 0.29166666666667
38200, 0.0625, 1.54, 0.29166666666667
38201, 0.083333333333333, 1.54, 0.27083333333333
38202, 0.083333333333333, 1.56, 0.29166666666667
38203, 0.0625, 1.58, 0.29166666666667
38204, 0.083333333333333, 1.58, 0.27083333333333
38205, 0.083333333333333, 1.6, 0.29166666666667
38206, 0.0625, 1.62, 0.29166666666667
38207, 0.083333333333333, 1.62, 0.27083333333333
38208, 0.083333333333333, 1.64, 0.29166666666667
38209, 0.0625, 1.66, 0.29166666666667
38210, 0.083333333333333, 1.66, 0.27083333333333
38211, 0.083333333333333, 1.68, 0.29166666666667
38212, 0.083333333333333, 1.52, 0.33333333333333
38213, 0.0625, 1.54, 0.33333333333333
38214, 0.083333333333333, 1.54, 0.3125
38215, 0.083333333333333, 1.56, 0.33333333333333
38216, 0.0625, 1.58, 0.33333333333333
38217, 0.083333333333333, 1.58, 0.3125
38218, 0.083333333333333, 1.6, 0.33333333333333
38219, 0.0625, 1.62, 0.33333333333333
38220, 0.083333333333333, 1.62, 0.3125
38221, 0.083333333333333, 1.64, 0.33333333333333
38222, 0.0625, 1.66, 0.33333333333333
38223, 0.083333333333333, 1.66, 0.3125
38224, 0.083333333333333, 1.68, 0.33333333333333
38225, 0.083333333333333, 1.52, 0.375
38226, 0.0625, 1.54, 0.375
38227, 0.083333333333333, 1.54, 0.35416666666667
38228, 0.083333333333333, 1.56, 0.375
38229, 0.0625, 1.58, 0.375
38230, 0.083333333333333, 1.58, 0.35416666666667
38231, 0.083333333333333, 1.6, 0.375
38232, 0.0625, 1.62, 0.375
38233, 0.083333333333333, 1.62, 0.35416666666667
38234, 0.083333333333333, 1.64, 0.375
38235, 0.0625, 1.66, 0.375
38236, 0.083333333333333, 1.66, 0.35416666666667
38237, 0.083333333333333, 1.68, 0.375
38238, 0.083333333333333, 1.52, 0.41666666666667
38239, 0.0625, 1.54, 0.41666666666667
38240, 0.083333333333333, 1.54, 0.39583333333333
38241, 0.083333333333333, 1.56, 0.41666666666667
38242, 0.0625, 1.58, 0.41666666666667
38243, 0.083333333333333, 1.58, 0.39583333333333
38244, 0.083333333333333, 1.6, 0.41666666666667
38245, 0.0625, 1.62, 0.41666666666667
38246, 0.083333333333333, 1.62, 0.39583333333333
38247, 0.083333333333333, 1.64, 0.41666666666667
38248, 0.0625, 1.66, 0.41666666666667
38249, 0.083333333333333, 1.66, 0.39583333333333
38250, 0.083333333333333, 1.68, 0.41666666666667
38251, 0.083333333333333, 1.52, 0.45833333333333
38252, 0.0625, 1.54, 0.45833333333333
38253, 0.083333333333333, 1.54, 0.4375
38254, 0.083333333333333, 1.56, 0.45833333333333
38255, 0.0625, 1.58, 0.45833333333333
38256, 0.083333333333333, 1.58, 0.4375
38257, 0.083333333333333, 1.6, 0.45833333333333
38258, 0.0625, 1.62, 0.45833333333333
38259, 0.083333333333333, 1.62, 0.4375
38260, 0.083333333333333, 1.64, 0.45833333333333
38261, 0.0625, 1.66, 0.45833333333333
38262, 0.083333333333333, 1.66, 0.4375
38263, 0.083333333333333, 1.68, 0.45833333333333
38264, 0.083333333333333, 1.54, 0.47916666666667
38265, 0.083333333333333, 1.58, 0.47916666666667
38266, 0.083333333333333, 1.62, 0.47916666666667
38267, 0.083333333333333, 1.66, 0.47916666666667
38268, 0.125, 1.52, 0.041666666666667
38269, 0.10416666666667, 1.54, 0.041666666666667
38270, 0.125, 1.54, 0.020833333333333
38271, 0.125, 1.56, 0.041666666666667
38272, 0.10416666666667, 1.58, 0.041666666666667
38273, 0.125, 1.58, 0.020833333333333
38274, 0.125, 1.6, 0.041666666666667
38275, 0.10416666666667, 1.62, 0.041666666666667
38276, 0.125, 1.62, 0.020833333333333
38277, 0.125, 1.64, 0.041666666666667
38278, 0.10416666666667, 1.66, 0.041666666666667
38279, 0.125, 1.66, 0.020833333333333
38280, 0.125, 1.68, 0.041666666666667
38281, 0.125, 1.52, 0.083333333333333
38282, 0.10416666666667, 1.54, 0.083333333333333
38283, 0.125, 1.54, 0.0625
38284, 0.125, 1.56, 0.083333333333333
38285, 0.10416666666667, 1.58, 0.083333333333333
38286, 0.125, 1.58, 0.0625
38287, 0.125, 1.6, 0.083333333333333
38288, 0.10416666666667, 1.62, 0.083333333333333
38289, 0.125, 1.62, 0.0625
38290, 0.125, 1.64, 0.083333333333333
38291, 0.10416666666667, 1.66, 0.083333333333333
38292, 0.125, 1.66, 0.0625
38293, 0.125, 1.68, 0.083333333333333
38294, 0.125, 1.52, 0.125
38295, 0.10416666666667, 1.54, 0.125
38296, 0.125, 1.54, 0.10416666666667
38297, 0.125, 1.56, 0.125
38298, 0.10416666666667, 1.58, 0.125
38299, 0.125, 1.58, 0.10416666666667
38300, 0.125, 1.6, 0.125
38301, 0.10416666666667, 1.62, 0.125
38302, 0.125, 1.62, 0.10416666666667
38303, 0.125, 1.64, 0.125
38304, 0.10416666666667, 1.66, 0.125
38305, 0.125, 1.66, 0.10416666666667
38306, 0.125, 1.68, 0.125
38307, 0.125, 1.52, 0.16666666666667
38308, 0.10416666666667, 1.54, 0.16666666666667
38309, 0.125, 1.54, 0.14583333333333
38310, 0.125, 1.56, 0.16666666666667
38311, 0.10416666666667, 1.58, 0.16666666666667
38312, 0.125, 1.58, 0.14583333333333
38313, 0.125, 1.6, 0.16666666666667
38314, 0.10416666666667, 1.62, 0.16666666666667
38315, 0.125, 1.62, 0.14583333333333
38316, 0.125, 1.64, 0.16666666666667
38317, 0.10416666666667, 1.66, 0.16666666666667
38318, 0.125, 1.66, 0.14583333333333
38319, 0.125, 1.68, 0.16666666666667
38320, 0.125, 1.52, 0.20833333333333
38321, 0.10416666666667, 1.54, 0.20833333333333
38322, 0.125, 1.54, 0.1875
38323, 0.125, 1.56, 0.20833333333333
38324, 0.10416666666667, 1.58, 0.20833333333333
38325, 0.125, 1.58, 0.1875
38326, 0.125, 1.6, 0.20833333333333
38327, 0.10416666666667, 1.62, 0.20833333333333
38328, 0.125, 1.62, 0.1875
38329, 0.125, 1.64, 0.20833333333333
38330, 0.10416666666667, 1.66, 0.20833333333333
38331, 0.125, 1.66, 0.1875
38332, 0.125, 1.68, 0.20833333333333
38333, 0.125, 1.52, 0.25
38334, 0.10416666666667, 1.54, 0.25
38335, 0.125, 1.54, 0.22916666666667
38336, 0.125, 1.56, 0.25
38337, 0.10416666666667, 1.58, 0.25
38338, 0.125, 1.58, 0.22916666666667
38339, 0.125, 1.6, 0.25
38340, 0.10416666666667, 1.62, 0.25
38341, 0.125, 1.62, 0.22916666666667
38342, 0.125, 1.64, 0.25
38343, 0.10416666666667, 1.66, 0.25
38344, 0.125, 1.66, 0.22916666666667
38345, 0.125, 1.68, 0.25
38346, 0.125, 1.52, 0.29166666666667
38347, 0.10416666666667, 1.54, 0.29166666666667
38348, 0.125, 1.54, 0.27083333333333
38349, 0.125, 1.56, 0.29166666666667
38350, 0.10416666666667, 1.58, 0.29166666666667
38351, 0.125, 1.58, 0.27083333333333
38352, 0.125, 1.6, 0.29166666666667
38353, 0.10416666666667, 1.62, 0.29166666666667
38354, 0.125, 1.62, 0.27083333333333
38355, 0.125, 1.64, 0.29166666666667
38356, 0.10416666666667, 1.66, 0.29166666666667
38357, 0.125, 1.66, 0.27083333333333
38358, 0.125, 1.68, 0.29166666666667
38359, 0.125, 1.52, 0.33333333333333
38360, 0.10416666666667, 1.54, 0.33333333333333
38361, 0.125, 1.54, 0.3125
38362, 0.125, 1.56, 0.33333333333333
38363, 0.10416666666667, 1.58, 0.33333333333333
38364, 0.125, 1.58, 0.3125
38365, 0.125, 1.6, 0.33333333333333
38366, 0.10416666666667, 1.62, 0.33333333333333
38367, 0.125, 1.62, 0.3125
38368, 0.125, 1.64, 0.33333333333333
38369, 0.10416666666667, 1.66, 0.33333333333333
38370, 0.125, 1.66, 0.3125
38371, 0.125, 1.68, 0.33333333333333
38372, 0.125, 1.52, 0.375
38373, 0.10416666666667, 1.54, 0.375
38374, 0.125, 1.54, 0.35416666666667
38375, 0.125, 1.56, 0.375
38376, 0.10416666666667, 1.58, 0.375
38377, 0.125, 1.58, 0.35416666666667
38378, 0.125, 1.6, 0.375
38379, 0.10416666666667, 1.62, 0.375
38380, 0.125, 1.62, 0.35416666666667
38381, 0.125, 1.64, 0.375
38382, 0.10416666666667, 1.66, 0.375
38383, 0.125, 1.66, 0.35416666666667
38384, 0.125, 1.68, 0.375
38385, 0.125, 1.52, 0.41666666666667
38386, 0.10416666666667, 1.54, 0.41666666666667
38387, 0.125, 1.54, 0.39583333333333
38388, 0.125, 1.56, 0.41666666666667
38389, 0.10416666666667, 1.58, 0.41666666666667
38390, 0.125, 1.58, 0.39583333333333
38391, 0.125, 1.6, 0.41666666666667
38392, 0.10416666666667, 1.62, 0.41666666666667
38393, 0.125, 1.62, 0.39583333333333
38394, 0.125, 1.64, 0.41666666666667
38395, 0.10416666666667, 1.66, 0.41666666666667
38396, 0.125, 1.66, 0.39583333333333
38397, 0.125, 1.68, 0.41666666666667
38398, 0.125, 1.52, 0.45833333333333
38399, 0.10416666666667, 1.54, 0.45833333333333
38400, 0.125, 1.54, 0.4375
38401, 0.125, 1.56, 0.45833333333333
38402, 0.10416666666667, 1.58, 0.45833333333333
38403, 0.125, 1.58, 0.4375
38404, 0.125, 1.6, 0.45833333333333
38405, 0.10416666666667, 1.62, 0.45833333333333
38406, 0.125, 1.62, 0.4375
38407, 0.125, 1.64, 0.45833333333333
38408, 0.10416666666667, 1.66, 0.45833333333333
38409, 0.125, 1.66, 0.4375
38410, 0.125, 1.68, 0.45833333333333
38411, 0.125, 1.54, 0.47916666666667
38412, 0.125, 1.58, 0.47916666666667
38413, 0.125, 1.62, 0.47916666666667
38414, 0.125, 1.66, 0.47916666666667
38415, 0.16666666666667, 1.52, 0.041666666666667
38416, 0.14583333333333, 1.54, 0.041666666666667
38417, 0.16666666666667, 1.54, 0.020833333333333
38418, 0.16666666666667, 1.56, 0.041666666666667
38419, 0.14583333333333, 1.58, 0.041666666666667
38420, 0.16666666666667, 1.58, 0.020833333333333
38421, 0.16666666666667, 1.6, 0.041666666666667
38422, 0.14583333333333, 1.62, 0.041666666666667
38423, 0.16666666666667, 1.62, 0.020833333333333
38424, 0.16666666666667, 1.64, 0.041666666666667
38425, 0.14583333333333, 1.66, 0.041666666666667
38426, 0.16666666666667, 1.66, 0.020833333333333
38427, 0.16666666666667, 1.68, 0.041666666666667
38428, 0.16666666666667, 1.52, 0.083333333333333
38429, 0.14583333333333, 1.54, 0.083333333333333
38430, 0.16666666666667, 1.54, 0.0625
38431, 0.16666666666667, 1.56, 0.083333333333333
38432, 0.14583333333333, 1.58, 0.083333333333333
38433, 0.16666666666667, 1.58, 0.0625
38434, 0.16666666666667, 1.6, 0.083333333333333
38435, 0.14583333333333, 1.62, 0.083333333333333
38436, 0.16666666666667, 1.62, 0.0625
38437, 0.16666666666667, 1.64, 0.083333333333333
38438, 0.14583333333333, 1.66, 0.083333333333333
38439, 0.16666666666667, 1.66, 0.0625
38440, 0.16666666666667, 1.68, 0.083333333333333
38441, 0.16666666666667, 1.52, 0.125
38442, 0.14583333333333, 1.54, 0.125
38443, 0.16666666666667, 1.54, 0.10416666666667
38444, 0.16666666666667, 1.56, 0.125
38445, 0.14583333333333, 1.58, 0.125
38446, 0.16666666666667, 1.58, 0.10416666666667
38447, 0.16666666666667, 1.6, 0.125
38448, 0.14583333333333, 1.62, 0.125
38449, 0.16666666666667, 1.62, 0.10416666666667
38450, 0.16666666666667, 1.64, 0.125
38451, 0.14583333333333, 1.66, 0.125
38452, 0.16666666666667, 1.66, 0.10416666666667
38453, 0.16666666666667, 1.68, 0.125
38454, 0.16666666666667, 1.52, 0.16666666666667
38455, 0.14583333333333, 1.54, 0.16666666666667
38456, 0.16666666666667, 1.54, 0.14583333333333
38457, 0.16666666666667, 1.56, 0.16666666666667
38458, 0.14583333333333, 1.58, 0.16666666666667
38459, 0.16666666666667, 1.58, 0.14583333333333
38460, 0.16666666666667, 1.6, 0.16666666666667
38461, 0.14583333333333, 1.62, 0.16666666666667
38462, 0.16666666666667, 1.62, 0.14583333333333
38463, 0.16666666666667, 1.64, 0.16666666666667
38464, 0.14583333333333, 1.66, 0.16666666666667
38465, 0.16666666666667, 1.66, 0.14583333333333
38466, 0.16666666666667, 1.68, 0.16666666666667
38467, 0.16666666666667, 1.52, 0.20833333333333
38468, 0.14583333333333, 1.54, 0.20833333333333
38469, 0.16666666666667, 1.54, 0.1875
38470, 0.16666666666667, 1.56, 0.20833333333333
38471, 0.14583333333333, 1.58, 0.20833333333333
38472, 0.16666666666667, 1.58, 0.1875
38473, 0.16666666666667, 1.6, 0.20833333333333
38474, 0.14583333333333, 1.62, 0.20833333333333
38475, 0.16666666666667, 1.62, 0.1875
38476, 0.16666666666667, 1.64, 0.20833333333333
38477, 0.14583333333333, 1.66, 0.20833333333333
38478, 0.16666666666667, 1.66, 0.1875
38479, 0.16666666666667, 1.68, 0.20833333333333
38480, 0.16666666666667, 1.52, 0.25
38481, 0.14583333333333, 1.54, 0.25
38482, 0.16666666666667, 1.54, 0.22916666666667
38483, 0.16666666666667, 1.56, 0.25
38484, 0.14583333333333, 1.58, 0.25
38485, 0.16666666666667, 1.58, 0.22916666666667
38486, 0.16666666666667, 1.6, 0.25
38487, 0.14583333333333, 1.62, 0.25
38488, 0.16666666666667, 1.62, 0.22916666666667
38489, 0.16666666666667, 1.64, 0.25
38490, 0.14583333333333, 1.66, 0.25
38491, 0.16666666666667, 1.66, 0.22916666666667
38492, 0.16666666666667, 1.68, 0.25
38493, 0.16666666666667, 1.52, 0.29166666666667
38494, 0.14583333333333, 1.54, 0.29166666666667
38495, 0.16666666666667, 1.54, 0.27083333333333
38496, 0.16666666666667, 1.56, 0.29166666666667
38497, 0.14583333333333, 1.58, 0.29166666666667
38498, 0.16666666666667, 1.58, 0.27083333333333
38499, 0.16666666666667, 1.6, 0.29166666666667
38500, 0.14583333333333, 1.62, 0.29166666666667
38501, 0.16666666666667, 1.62, 0.27083333333333
38502, 0.16666666666667, 1.64, 0.29166666666667
38503, 0.14583333333333, 1.66, 0.29166666666667
38504, 0.16666666666667, 1.66, 0.27083333333333
38505, 0.16666666666667, 1.68, 0.29166666666667
38506, 0.16666666666667, 1.52, 0.33333333333333
38507, 0.14583333333333, 1.54, 0.33333333333333
38508, 0.16666666666667, 1.54, 0.3125
38509, 0.16666666666667, 1.56, 0.33333333333333
38510, 0.14583333333333, 1.58, 0.33333333333333
38511, 0.16666666666667, 1.58, 0.3125
38512, 0.16666666666667, 1.6, 0.33333333333333
38513, 0.14583333333333, 1.62, 0.33333333333333
38514, 0.16666666666667, 1.62, 0.3125
38515, 0.16666666666667, 1.64, 0.33333333333333
38516, 0.14583333333333, 1.66, 0.33333333333333
38517, 0.16666666666667, 1.66, 0.3125
38518, 0.16666666666667, 1.68, 0.33333333333333
38519, 0.16666666666667, 1.52, 0.375
38520, 0.14583333333333, 1.54, 0.375
38521, 0.16666666666667, 1.54, 0.35416666666667
38522, 0.16666666666667, 1.56, 0.375
38523, 0.14583333333333, 1.58, 0.375
38524, 0.16666666666667, 1.58, 0.35416666666667
38525, 0.16666666666667, 1.6, 0.375
38526, 0.14583333333333, 1.62, 0.375
38527, 0.16666666666667, 1.62, 0.35416666666667
38528, 0.16666666666667, 1.64, 0.375
38529, 0.14583333333333, 1.66, 0.375
38530, 0.16666666666667, 1.66, 0.35416666666667
38531, 0.16666666666667, 1.68, 0.375
38532, 0.16666666666667, 1.52, 0.41666666666667
38533, 0.14583333333333, 1.54, 0.41666666666667
38534, 0.16666666666667, 1.54, 0.39583333333333
38535, 0.16666666666667, 1.56, 0.41666666666667
38536, 0.14583333333333, 1.58, 0.41666666666667
38537, 0.16666666666667, 1.58, 0.39583333333333
38538, 0.16666666666667, 1.6, 0.41666666666667
38539, 0.14583333333333, 1.62, 0.41666666666667
38540, 0.16666666666667, 1.62, 0.39583333333333
38541, 0.16666666666667, 1.64, 0.41666666666667
38542, 0.14583333333333, 1.66, 0.41666666666667
38543, 0.16666666666667, 1.66, 0.39583333333333
38544, 0.16666666666667, 1.68, 0.41666666666667
38545, 0.16666666666667, 1.52, 0.45833333333333
38546, 0.14583333333333, 1.54, 0.45833333333333
38547, 0.16666666666667, 1.54, 0.4375
38548, 0.16666666666667, 1.56, 0.45833333333333
38549, 0.14583333333333, 1.58, 0.45833333333333
38550, 0.16666666666667, 1.58, 0.4375
38551, 0.16666666666667, 1.6, 0.45833333333333
38552, 0.14583333333333, 1.62, 0.45833333333333
38553, 0.16666666666667, 1.62, 0.4375
38554, 0.16666666666667, 1.64, 0.45833333333333
38555, 0.14583333333333, 1.66, 0.45833333333333
38556, 0.16666666666667, 1.66, 0.4375
38557, 0.16666666666667, 1.68, 0.45833333333333
38558, 0.16666666666667, 1.54, 0.47916666666667
38559, 0.16666666666667, 1.58, 0.47916666666667
38560, 0.16666666666667, 1.62, 0.47916666666667
38561, 0.16666666666667, 1.66, 0.47916666666667
38562, 0.20833333333333, 1.52, 0.041666666666667
38563, 0.1875, 1.54, 0.041666666666667
38564, 0.20833333333333, 1.54, 0.020833333333333
38565, 0.20833333333333, 1.56, 0.041666666666667
38566, 0.1875, 1.58, 0.041666666666667
38567, 0.20833333333333, 1.58, 0.020833333333333
38568, 0.20833333333333, 1.6, 0.041666666666667
38569, 0.1875, 1.62, 0.041666666666667
38570, 0.20833333333333, 1.62, 0.020833333333333
38571, 0.20833333333333, 1.64, 0.041666666666667
38572, 0.1875, 1.66, 0.041666666666667
38573, 0.20833333333333, 1.66, 0.020833333333333
38574, 0.20833333333333, 1.68, 0.041666666666667
38575, 0.20833333333333, 1.52, 0.083333333333333
38576, 0.1875, 1.54, 0.083333333333333
38577, 0.20833333333333, 1.54, 0.0625
38578, 0.20833333333333, 1.56, 0.083333333333333
38579, 0.1875, 1.58, 0.083333333333333
38580, 0.20833333333333, 1.58, 0.0625
38581, 0.20833333333333, 1.6, 0.083333333333333
38582, 0.1875, 1.62, 0.083333333333333
38583, 0.20833333333333, 1.62, 0.0625
38584, 0.20833333333333, 1.64, 0.083333333333333
38585, 0.1875, 1.66, 0.083333333333333
38586, 0.20833333333333, 1.66, 0.0625
38587, 0.20833333333333, 1.68, 0.083333333333333
38588, 0.20833333333333, 1.52, 0.125
38589, 0.1875, 1.54, 0.125
38590, 0.20833333333333, 1.54, 0.10416666666667
38591, 0.20833333333333, 1.56, 0.125
38592, 0.1875, 1.58, 0.125
38593, 0.20833333333333, 1.58, 0.10416666666667
38594, 0.20833333333333, 1.6, 0.125
38595, 0.1875, 1.62, 0.125
38596, 0.20833333333333, 1.62, 0.10416666666667
38597, 0.20833333333333, 1.64, 0.125
38598, 0.1875, 1.66, 0.125
38599, 0.20833333333333, 1.66, 0.10416666666667
38600, 0.20833333333333, 1.68, 0.125
38601, 0.20833333333333, 1.52, 0.16666666666667
38602, 0.1875, 1.54, 0.16666666666667
38603, 0.20833333333333, 1.54, 0.14583333333333
38604, 0.20833333333333, 1.56, 0.16666666666667
38605, 0.1875, 1.58, 0.16666666666667
38606, 0.20833333333333, 1.58, 0.14583333333333
38607, 0.20833333333333, 1.6, 0.16666666666667
38608, 0.1875, 1.62, 0.16666666666667
38609, 0.20833333333333, 1.62, 0.14583333333333
38610, 0.20833333333333, 1.64, 0.16666666666667
38611, 0.1875, 1.66, 0.16666666666667
38612, 0.20833333333333, 1.66, 0.14583333333333
38613, 0.20833333333333, 1.68, 0.16666666666667
38614, 0.20833333333333, 1.52, 0.20833333333333
38615, 0.1875, 1.54, 0.20833333333333
38616, 0.20833333333333, 1.54, 0.1875
38617, 0.20833333333333, 1.56, 0.20833333333333
38618, 0.1875, 1.58, 0.20833333333333
38619, 0.20833333333333, 1.58, 0.1875
38620, 0.20833333333333, 1.6, 0.20833333333333
38621, 0.1875, 1.62, 0.20833333333333
38622, 0.20833333333333, 1.62, 0.1875
38623, 0.20833333333333, 1.64, 0.20833333333333
38624, 0.1875, 1.66, 0.20833333333333
38625, 0.20833333333333, 1.66, 0.1875
38626, 0.20833333333333, 1.68, 0.20833333333333
38627, 0.20833333333333, 1.52, 0.25
38628, 0.1875, 1.54, 0.25
38629, 0.20833333333333, 1.54, 0.22916666666667
38630, 0.20833333333333, 1.56, 0.25
38631, 0.1875, 1.58, 0.25
38632, 0.20833333333333, 1.58, 0.22916666666667
38633, 0.20833333333333, 1.6, 0.25
38634, 0.1875, 1.62, 0.25
38635, 0.20833333333333, 1.62, 0.22916666666667
38636, 0.20833333333333, 1.64, 0.25
38637, 0.1875, 1.66, 0.25
38638, 0.20833333333333, 1.66, 0.22916666666667
38639, 0.20833333333333, 1.68, 0.25
38640, 0.20833333333333, 1.52, 0.29166666666667
38641, 0.1875, 1.54, 0.29166666666667
38642, 0.20833333333333, 1.54, 0.27083333333333
38643, 0.20833333333333, 1.56, 0.29166666666667
38644, 0.1875, 1.58, 0.29166666666667
38645, 0.20833333333333, 1.58, 0.27083333333333
38646, 0.20833333333333, 1.6, 0.29166666666667
38647, 0.1875, 1.62, 0.29166666666667
38648, 0.20833333333333, 1.62, 0.27083333333333
38649, 0.20833333333333, 1.64, 0.29166666666667
38650, 0.1875, 1.66, 0.29166666666667
38651, 0.20833333333333, 1.66, 0.27083333333333
38652, 0.20833333333333, 1.68, 0.29166666666667
38653, 0.20833333333333, 1.52, 0.33333333333333
38654, 0.1875, 1.54, 0.33333333333333
38655, 0.20833333333333, 1.54, 0.3125
38656, 0.20833333333333, 1.56, 0.33333333333333
38657, 0.1875, 1.58, 0.33333333333333
38658, 0.20833333333333, 1.58, 0.3125
38659, 0.20833333333333, 1.6, 0.33333333333333
38660, 0.1875, 1.62, 0.33333333333333
38661, 0.20833333333333, 1.62, 0.3125
38662, 0.20833333333333, 1.64, 0.33333333333333
38663, 0.1875, 1.66, 0.33333333333333
38664, 0.20833333333333, 1.66, 0.3125
38665, 0.20833333333333, 1.68, 0.33333333333333
38666, 0.20833333333333, 1.52, 0.375
38667, 0.1875, 1.54, 0.375
38668, 0.20833333333333, 1.54, 0.35416666666667
38669, 0.20833333333333, 1.56, 0.375
38670, 0.1875, 1.58, 0.375
38671, 0.20833333333333, 1.58, 0.35416666666667
38672, 0.20833333333333, 1.6, 0.375
38673, 0.1875, 1.62, 0.375
38674, 0.20833333333333, 1.62, 0.35416666666667
38675, 0.20833333333333, 1.64, 0.375
38676, 0.1875, 1.66, 0.375
38677, 0.20833333333333, 1.66, 0.35416666666667
38678, 0.20833333333333, 1.68, 0.375
38679, 0.20833333333333, 1.52, 0.41666666666667
38680, 0.1875, 1.54, 0.41666666666667
38681, 0.20833333333333, 1.54, 0.39583333333333
38682, 0.20833333333333, 1.56, 0.41666666666667
38683, 0.1875, 1.58, 0.41666666666667
38684, 0.20833333333333, 1.58, 0.39583333333333
38685, 0.20833333333333, 1.6, 0.41666666666667
38686, 0.1875, 1.62, 0.41666666666667
38687, 0.20833333333333, 1.62, 0.39583333333333
38688, 0.20833333333333, 1.64, 0.41666666666667
38689, 0.1875, 1.66, 0.41666666666667
38690, 0.20833333333333, 1.66, 0.39583333333333
38691, 0.20833333333333, 1.68, 0.41666666666667
38692, 0.20833333333333, 1.52, 0.45833333333333
38693, 0.1875, 1.54, 0.45833333333333
38694, 0.20833333333333, 1.54, 0.4375
38695, 0.20833333333333, 1.56, 0.45833333333333
38696, 0.1875, 1.58, 0.45833333333333
38697, 0.20833333333333, 1.58, 0.4375
38698, 0.20833333333333, 1.6, 0.45833333333333
38699, 0.1875, 1.62, 0.45833333333333
38700, 0.20833333333333, 1.62, 0.4375
38701, 0.20833333333333, 1.64, 0.45833333333333
38702, 0.1875, 1.66, 0.45833333333333
38703, 0.20833333333333, 1.66, 0.4375
38704, 0.20833333333333, 1.68, 0.45833333333333
38705, 0.20833333333333, 1.54, 0.47916666666667
38706, 0.20833333333333, 1.58, 0.47916666666667
38707, 0.20833333333333, 1.62, 0.47916666666667
38708, 0.20833333333333, 1.66, 0.47916666666667
38709, 0.25, 1.52, 0.041666666666667
38710, 0.22916666666667, 1.54, 0.041666666666667
38711, 0.25, 1.54, 0.020833333333333
38712, 0.25, 1.56, 0.041666666666667
38713, 0.22916666666667, 1.58, 0.041666666666667
38714, 0.25, 1.58, 0.020833333333333
38715, 0.25, 1.6, 0.041666666666667
38716, 0.22916666666667, 1.62, 0.041666666666667
38717, 0.25, 1.62, 0.020833333333333
38718, 0.25, 1.64, 0.041666666666667
38719, 0.22916666666667, 1.66, 0.041666666666667
38720, 0.25, 1.66, 0.020833333333333
38721, 0.25, 1.68, 0.041666666666667
38722, 0.25, 1.52, 0.083333333333333
38723, 0.22916666666667, 1.54, 0.083333333333333
38724, 0.25, 1.54, 0.0625
38725, 0.25, 1.56, 0.083333333333333
38726, 0.22916666666667, 1.58, 0.083333333333333
38727, 0.25, 1.58, 0.0625
38728, 0.25, 1.6, 0.083333333333333
38729, 0.22916666666667, 1.62, 0.083333333333333
38730, 0.25, 1.62, 0.0625
38731, 0.25, 1.64, 0.083333333333333
38732, 0.22916666666667, 1.66, 0.083333333333333
38733, 0.25, 1.66, 0.0625
38734, 0.25, 1.68, 0.083333333333333
38735, 0.25, 1.52, 0.125
38736, 0.22916666666667, 1.54, 0.125
38737, 0.25, 1.54, 0.10416666666667
38738, 0.25, 1.56, 0.125
38739, 0.22916666666667, 1.58, 0.125
38740, 0.25, 1.58, 0.10416666666667
38741, 0.25, 1.6, 0.125
38742, 0.22916666666667, 1.62, 0.125
38743, 0.25, 1.62, 0.10416666666667
38744, 0.25, 1.64, 0.125
38745, 0.22916666666667, 1.66, 0.125
38746, 0.25, 1.66, 0.10416666666667
38747, 0.25, 1.68, 0.125
38748, 0.25, 1.52, 0.16666666666667
38749, 0.22916666666667, 1.54, 0.16666666666667
38750, 0.25, 1.54, 0.14583333333333
38751, 0.25, 1.56, 0.16666666666667
38752, 0.22916666666667, 1.58, 0.16666666666667
38753, 0.25, 1.58, 0.14583333333333
38754, 0.25, 1.6, 0.16666666666667
38755, 0.22916666666667, 1.62, 0.16666666666667
38756, 0.25, 1.62, 0.14583333333333
38757, 0.25, 1.64, 0.16666666666667
38758, 0.22916666666667, 1.66, 0.16666666666667
38759, 0.25, 1.66, 0.14583333333333
38760, 0.25, 1.68, 0.16666666666667
38761, 0.25, 1.52, 0.20833333333333
38762, 0.22916666666667, 1.54, 0.20833333333333
38763, 0.25, 1.54, 0.1875
38764, 0.25, 1.56, 0.20833333333333
38765, 0.22916666666667, 1.58, 0.20833333333333
38766, 0.25, 1.58, 0.1875
38767, 0.25, 1.6, 0.20833333333333
38768, 0.22916666666667, 1.62, 0.20833333333333
38769, 0.25, 1.62, 0.1875
38770, 0.25, 1.64, 0.20833333333333
38771, 0.22916666666667, 1.66, 0.20833333333333
38772, 0.25, 1.66, 0.1875
38773, 0.25, 1.68, 0.20833333333333
38774, 0.25, 1.52, 0.25
38775, 0.22916666666667, 1.54, 0.25
38776, 0.25, 1.54, 0.22916666666667
38777, 0.25, 1.56, 0.25
38778, 0.22916666666667, 1.58, 0.25
38779, 0.25, 1.58, 0.22916666666667
38780, 0.25, 1.6, 0.25
38781, 0.22916666666667, 1.62, 0.25
38782, 0.25, 1.62, 0.22916666666667
38783, 0.25, 1.64, 0.25
38784, 0.22916666666667, 1.66, 0.25
38785, 0.25, 1.66, 0.22916666666667
38786, 0.25, 1.68, 0.25
38787, 0.25, 1.52, 0.29166666666667
38788, 0.22916666666667, 1.54, 0.29166666666667
38789, 0.25, 1.54, 0.27083333333333
38790, 0.25, 1.56, 0.29166666666667
38791, 0.22916666666667, 1.58, 0.29166666666667
38792, 0.25, 1.58, 0.27083333333333
38793, 0.25, 1.6, 0.29166666666667
38794, 0.22916666666667, 1.62, 0.29166666666667
38795, 0.25, 1.62, 0.27083333333333
38796, 0.25, 1.64, 0.29166666666667
38797, 0.22916666666667, 1.66, 0.29166666666667
38798, 0.25, 1.66, 0.27083333333333
38799, 0.25, 1.68, 0.29166666666667
38800, 0.25, 1.52, 0.33333333333333
38801, 0.22916666666667, 1.54, 0.33333333333333
38802, 0.25, 1.54, 0.3125
38803, 0.25, 1.56, 0.33333333333333
38804, 0.22916666666667, 1.58, 0.33333333333333
38805, 0.25, 1.58, 0.3125
38806, 0.25, 1.6, 0.33333333333333
38807, 0.22916666666667, 1.62, 0.33333333333333
38808, 0.25, 1.62, 0.3125
38809, 0.25, 1.64, 0.33333333333333
38810, 0.22916666666667, 1.66, 0.33333333333333
38811, 0.25, 1.66, 0.3125
38812, 0.25, 1.68, 0.33333333333333
38813, 0.25, 1.52, 0.375
38814, 0.22916666666667, 1.54, 0.375
38815, 0.25, 1.54, 0.35416666666667
38816, 0.25, 1.56, 0.375
38817, 0.22916666666667, 1.58, 0.375
38818, 0.25, 1.58, 0.35416666666667
38819, 0.25, 1.6, 0.375
38820, 0.22916666666667, 1.62, 0.375
38821, 0.25, 1.62, 0.35416666666667
38822, 0.25, 1.64, 0.375
38823, 0.22916666666667, 1.66, 0.375
38824, 0.25, 1.66, 0.35416666666667
38825, 0.25, 1.68, 0.375
38826, 0.25, 1.52, 0.41666666666667
38827, 0.22916666666667, 1.54, 0.41666666666667
38828, 0.25, 1.54, 0.39583333333333
38829, 0.25, 1.56, 0.41666666666667
38830, 0.22916666666667, 1.58, 0.41666666666667
38831, 0.25, 1.58, 0.39583333333333
38832, 0.25, 1.6, 0.41666666666667
38833, 0.22916666666667, 1.62, 0.41666666666667
38834, 0.25, 1.62, 0.39583333333333
38835, 0.25, 1.64, 0.41666666666667
38836, 0.22916666666667, 1.66, 0.41666666666667
38837, 0.25, 1.66, 0.39583333333333
38838, 0.25, 1.68, 0.41666666666667
38839, 0.25, 1.52, 0.45833333333333
38840, 0.22916666666667, 1.54, 0.45833333333333
38841, 0.25, 1.54, 0.4375
38842, 0.25, 1.56, 0.45833333333333
38843, 0.22916666666667, 1.58, 0.45833333333333
38844, 0.25, 1.58, 0.4375
38845, 0.25, 1.6, 0.45833333333333
38846, 0.22916666666667, 1.62, 0.45833333333333
38847, 0.25, 1.62, 0.4375
38848, 0.25, 1.64, 0.45833333333333
38849, 0.22916666666667, 1.66, 0.45833333333333
38850, 0.25, 1.66, 0.4375
38851, 0.25, 1.68, 0.45833333333333
38852, 0.25, 1.54, 0.47916666666667
38853, 0.25, 1.58, 0.47916666666667
38854, 0.25, 1.62, 0.47916666666667
38855, 0.25, 1.66, 0.47916666666667
38856, 0.29166666666667, 1.52, 0.041666666666667
38857, 0.27083333333333, 1.54, 0.041666666666667
38858, 0.29166666666667, 1.54, 0.020833333333333
38859, 0.29166666666667, 1.56, 0.041666666666667
38860, 0.27083333333333, 1.58, 0.041666666666667
38861, 0.29166666666667, 1.58, 0.020833333333333
38862, 0.29166666666667, 1.6, 0.041666666666667
38863, 0.27083333333333, 1.62, 0.041666666666667
38864, 0.29166666666667, 1.62, 0.020833333333333
38865, 0.29166666666667, 1.64, 0.041666666666667
38866, 0.27083333333333, 1.66, 0.041666666666667
38867, 0.29166666666667, 1.66, 0.020833333333333
38868, 0.29166666666667, 1.68, 0.041666666666667
38869, 0.29166666666667, 1.52, 0.083333333333333
38870, 0.27083333333333, 1.54, 0.083333333333333
38871, 0.29166666666667, 1.54, 0.0625
38872, 0.29166666666667, 1.56, 0.083333333333333
38873, 0.27083333333333, 1.58, 0.083333333333333
38874, 0.29166666666667, 1.58, 0.0625
38875, 0.29166666666667, 1.6, 0.083333333333333
38876, 0.27083333333333, 1.62, 0.083333333333333
38877, 0.29166666666667, 1.62, 0.0625
38878, 0.29166666666667, 1.64, 0.083333333333333
38879, 0.27083333333333, 1.66, 0.083333333333333
38880, 0.29166666666667, 1.66, 0.0625
38881, 0.29166666666667, 1.68, 0.083333333333333
38882, 0.29166666666667, 1.52, 0.125
38883, 0.27083333333333, 1.54, 0.125
38884, 0.29166666666667, 1.54, 0.10416666666667
38885, 0.29166666666667, 1.56, 0.125
38886, 0.27083333333333, 1.58, 0.125
38887, 0.29166666666667, 1.58, 0.10416666666667
38888, 0.29166666666667, 1.6, 0.125
38889, 0.27083333333333, 1.62, 0.125
38890, 0.29166666666667, 1.62, 0.10416666666667
38891, 0.29166666666667, 1.64, 0.125
38892, 0.27083333333333, 1.66, 0.125
38893, 0.29166666666667, 1.66, 0.10416666666667
38894, 0.29166666666667, 1.68, 0.125
38895, 0.29166666666667, 1.52, 0.16666666666667
38896, 0.27083333333333, 1.54, 0.16666666666667
38897, 0.29166666666667, 1.54, 0.14583333333333
38898, 0.29166666666667, 1.56, 0.16666666666667
38899, 0.27083333333333, 1.58, 0.16666666666667
38900, 0.29166666666667, 1.58, 0.14583333333333
38901, 0.29166666666667, 1.6, 0.16666666666667
38902, 0.27083333333333, 1.62, 0.16666666666667
38903, 0.29166666666667, 1.62, 0.14583333333333
38904, 0.29166666666667, 1.64, 0.16666666666667
38905, 0.27083333333333, 1.66, 0.16666666666667
38906, 0.29166666666667, 1.66, 0.14583333333333
38907, 0.29166666666667, 1.68, 0.16666666666667
38908, 0.29166666666667, 1.52, 0.20833333333333
38909, 0.27083333333333, 1.54, 0.20833333333333
38910, 0.29166666666667, 1.54, 0.1875
38911, 0.29166666666667, 1.56, 0.20833333333333
38912, 0.27083333333333, 1.58, 0.20833333333333
38913, 0.29166666666667, 1.58, 0.1875
38914, 0.29166666666667, 1.6, 0.20833333333333
38915, 0.27083333333333, 1.62, 0.20833333333333
38916, 0.29166666666667, 1.62, 0.1875
38917, 0.29166666666667, 1.64, 0.20833333333333
38918, 0.27083333333333, 1.66, 0.20833333333333
38919, 0.29166666666667, 1.66, 0.1875
38920, 0.29166666666667, 1.68, 0.20833333333333
38921, 0.29166666666667, 1.52, 0.25
38922, 0.27083333333333, 1.54, 0.25
38923, 0.29166666666667, 1.54, 0.22916666666667
38924, 0.29166666666667, 1.56, 0.25
38925, 0.27083333333333, 1.58, 0.25
38926, 0.29166666666667, 1.58, 0.22916666666667
38927, 0.29166666666667, 1.6, 0.25
38928, 0.27083333333333, 1.62, 0.25
38929, 0.29166666666667, 1.62, 0.22916666666667
38930, 0.29166666666667, 1.64, 0.25
38931, 0.27083333333333, 1.66, 0.25
38932, 0.29166666666667, 1.66, 0.22916666666667
38933, 0.29166666666667, 1.68, 0.25
38934, 0.29166666666667, 1.52, 0.29166666666667
38935, 0.27083333333333, 1.54, 0.29166666666667
38936, 0.29166666666667, 1.54, 0.27083333333333
38937, 0.29166666666667, 1.56, 0.29166666666667
38938, 0.27083333333333, 1.58, 0.29166666666667
38939, 0.29166666666667, 1.58, 0.27083333333333
38940, 0.29166666666667, 1.6, 0.29166666666667
38941, 0.27083333333333, 1.62, 0.29166666666667
38942, 0.29166666666667, 1.62, 0.27083333333333
38943, 0.29166666666667, 1.64, 0.29166666666667
38944, 0.27083333333333, 1.66, 0.29166666666667
38945, 0.29166666666667, 1.66, 0.27083333333333
38946, 0.29166666666667, 1.68, 0.29166666666667
38947, 0.29166666666667, 1.52, 0.33333333333333
38948, 0.27083333333333, 1.54, 0.33333333333333
38949, 0.29166666666667, 1.54, 0.3125
38950, 0.29166666666667, 1.56, 0.33333333333333
38951, 0.27083333333333, 1.58, 0.33333333333333
38952, 0.29166666666667, 1.58, 0.3125
38953, 0.29166666666667, 1.6, 0.33333333333333
38954, 0.27083333333333, 1.62, 0.33333333333333
38955, 0.29166666666667, 1.62, 0.3125
38956, 0.29166666666667, 1.64, 0.33333333333333
38957, 0.27083333333333, 1.66, 0.33333333333333
38958, 0.29166666666667, 1.66, 0.3125
38959, 0.29166666666667, 1.68, 0.33333333333333
38960, 0.29166666666667, 1.52, 0.375
38961, 0.27083333333333, 1.54, 0.375
38962, 0.29166666666667, 1.54, 0.35416666666667
38963, 0.29166666666667, 1.56, 0.375
38964, 0.27083333333333, 1.58, 0.375
38965, 0.29166666666667, 1.58, 0.35416666666667
38966, 0.29166666666667, 1.6, 0.375
38967, 0.27083333333333, 1.62, 0.375
38968, 0.29166666666667, 1.62, 0.35416666666667
38969, 0.29166666666667, 1.64, 0.375
38970, 0.27083333333333, 1.66, 0.375
38971, 0.29166666666667, 1.66, 0.35416666666667
38972, 0.29166666666667, 1.68, 0.375
38973, 0.29166666666667, 1.52, 0.41666666666667
38974, 0.27083333333333, 1.54, 0.41666666666667
38975, 0.29166666666667, 1.54, 0.39583333333333
38976, 0.29166666666667, 1.56, 0.41666666666667
38977, 0.27083333333333, 1.58, 0.41666666666667
38978, 0.29166666666667, 1.58, 0.39583333333333
38979, 0.29166666666667, 1.6, 0.41666666666667
38980, 0.27083333333333, 1.62, 0.41666666666667
38981, 0.29166666666667, 1.62, 0.39583333333333
38982, 0.29166666666667, 1.64, 0.41666666666667
38983, 0.27083333333333, 1.66, 0.41666666666667
38984, 0.29166666666667, 1.66, 0.39583333333333
38985, 0.29166666666667, 1.68, 0.41666666666667
38986, 0.29166666666667, 1.52, 0.45833333333333
38987, 0.27083333333333, 1.54, 0.45833333333333
38988, 0.29166666666667, 1.54, 0.4375
38989, 0.29166666666667, 1.56, 0.45833333333333
38990, 0.27083333333333, 1.58, 0.45833333333333
38991, 0.29166666666667, 1.58, 0.4375
38992, 0.29166666666667, 1.6, 0.45833333333333
38993, 0.27083333333333, 1.62, 0.45833333333333
38994, 0.29166666666667, 1.62, 0.4375
38995, 0.29166666666667, 1.64, 0.45833333333333
38996, 0.27083333333333, 1.66, 0.45833333333333
38997, 0.29166666666667, 1.66, 0.4375
38998, 0.29166666666667, 1.68, 0.45833333333333
38999, 0.29166666666667, 1.54, 0.47916666666667
39000, 0.29166666666667, 1.58, 0.47916666666667
39001, 0.29166666666667, 1.62, 0.47916666666667
39002, 0.29166666666667, 1.66, 0.47916666666667
39003, 0.33333333333333, 1.52, 0.041666666666667
39004, 0.3125, 1.54, 0.041666666666667
39005, 0.33333333333333, 1.54, 0.020833333333333
39006, 0.33333333333333, 1.56, 0.041666666666667
39007, 0.3125, 1.58, 0.041666666666667
39008, 0.33333333333333, 1.58, 0.020833333333333
39009, 0.33333333333333, 1.6, 0.041666666666667
39010, 0.3125, 1.62, 0.041666666666667
39011, 0.33333333333333, 1.62, 0.020833333333333
39012, 0.33333333333333, 1.64, 0.041666666666667
39013, 0.3125, 1.66, 0.041666666666667
39014, 0.33333333333333, 1.66, 0.020833333333333
39015, 0.33333333333333, 1.68, 0.041666666666667
39016, 0.33333333333333, 1.52, 0.083333333333333
39017, 0.3125, 1.54, 0.083333333333333
39018, 0.33333333333333, 1.54, 0.0625
39019, 0.33333333333333, 1.56, 0.083333333333333
39020, 0.3125, 1.58, 0.083333333333333
39021, 0.33333333333333, 1.58, 0.0625
39022, 0.33333333333333, 1.6, 0.083333333333333
39023, 0.3125, 1.62, 0.083333333333333
39024, 0.33333333333333, 1.62, 0.0625
39025, 0.33333333333333, 1.64, 0.083333333333333
39026, 0.3125, 1.66, 0.083333333333333
39027, 0.33333333333333, 1.66, 0.0625
39028, 0.33333333333333, 1.68, 0.083333333333333
39029, 0.33333333333333, 1.52, 0.125
39030, 0.3125, 1.54, 0.125
39031, 0.33333333333333, 1.54, 0.10416666666667
39032, 0.33333333333333, 1.56, 0.125
39033, 0.3125, 1.58, 0.125
39034, 0.33333333333333, 1.58, 0.10416666666667
39035, 0.33333333333333, 1.6, 0.125
39036, 0.3125, 1.62, 0.125
39037, 0.33333333333333, 1.62, 0.10416666666667
39038, 0.33333333333333, 1.64, 0.125
39039, 0.3125, 1.66, 0.125
39040, 0.33333333333333, 1.66, 0.10416666666667
39041, 0.33333333333333, 1.68, 0.125
39042, 0.33333333333333, 1.52, 0.16666666666667
39043, 0.3125, 1.54, 0.16666666666667
39044, 0.33333333333333, 1.54, 0.14583333333333
39045, 0.33333333333333, 1.56, 0.16666666666667
39046, 0.3125, 1.58, 0.16666666666667
39047, 0.33333333333333, 1.58, 0.14583333333333
39048, 0.33333333333333, 1.6, 0.16666666666667
39049, 0.3125, 1.62, 0.16666666666667
39050, 0.33333333333333, 1.62, 0.14583333333333
39051, 0.33333333333333, 1.64, 0.16666666666667
39052, 0.3125, 1.66, 0.16666666666667
39053, 0.33333333333333, 1.66, 0.14583333333333
39054, 0.33333333333333, 1.68, 0.16666666666667
39055, 0.33333333333333, 1.52, 0.20833333333333
39056, 0.3125, 1.54, 0.20833333333333
39057, 0.33333333333333, 1.54, 0.1875
39058, 0.33333333333333, 1.56, 0.20833333333333
39059, 0.3125, 1.58, 0.20833333333333
39060, 0.33333333333333, 1.58, 0.1875
39061, 0.33333333333333, 1.6, 0.20833333333333
39062, 0.3125, 1.62, 0.20833333333333
39063, 0.33333333333333, 1.62, 0.1875
39064, 0.33333333333333, 1.64, 0.20833333333333
39065, 0.3125, 1.66, 0.20833333333333
39066, 0.33333333333333, 1.66, 0.1875
39067, 0.33333333333333, 1.68, 0.20833333333333
39068, 0.33333333333333, 1.52, 0.25
39069, 0.3125, 1.54, 0.25
39070, 0.33333333333333, 1.54, 0.22916666666667
39071, 0.33333333333333, 1.56, 0.25
39072, 0.3125, 1.58, 0.25
39073, 0.33333333333333, 1.58, 0.22916666666667
39074, 0.33333333333333, 1.6, 0.25
39075, 0.3125, 1.62, 0.25
39076, 0.33333333333333, 1.62, 0.22916666666667
39077, 0.33333333333333, 1.64, 0.25
39078, 0.3125, 1.66, 0.25
39079, 0.33333333333333, 1.66, 0.22916666666667
39080, 0.33333333333333, 1.68, 0.25
39081, 0.33333333333333, 1.52, 0.29166666666667
39082, 0.3125, 1.54, 0.29166666666667
39083, 0.33333333333333, 1.54, 0.27083333333333
39084, 0.33333333333333, 1.56, 0.29166666666667
39085, 0.3125, 1.58, 0.29166666666667
39086, 0.33333333333333, 1.58, 0.27083333333333
39087, 0.33333333333333, 1.6, 0.29166666666667
39088, 0.3125, 1.62, 0.29166666666667
39089, 0.33333333333333, 1.62, 0.27083333333333
39090, 0.33333333333333, 1.64, 0.29166666666667
39091, 0.3125, 1.66, 0.29166666666667
39092, 0.33333333333333, 1.66, 0.27083333333333
39093, 0.33333333333333, 1.68, 0.29166666666667
39094, 0.33333333333333, 1.52, 0.33333333333333
39095, 0.3125, 1.54, 0.33333333333333
39096, 0.33333333333333, 1.54, 0.3125
39097, 0.33333333333333, 1.56, 0.33333333333333
39098, 0.3125, 1.58, 0.33333333333333
39099, 0.33333333333333, 1.58, 0.3125
39100, 0.33333333333333, 1.6, 0.33333333333333
39101, 0.3125, 1.62, 0.33333333333333
39102, 0.33333333333333, 1.62, 0.3125
39103, 0.33333333333333, 1.64, 0.33333333333333
39104, 0.3125, 1.66, 0.33333333333333
39105, 0.33333333333333, 1.66, 0.3125
39106, 0.33333333333333, 1.68, 0.33333333333333
39107, 0.33333333333333, 1.52, 0.375
39108, 0.3125, 1.54, 0.375
39109, 0.33333333333333, 1.54, 0.35416666666667
39110, 0.33333333333333, 1.56, 0.375
39111, 0.3125, 1.58, 0.375
39112, 0.33333333333333, 1.58, 0.35416666666667
39113, 0.33333333333333, 1.6, 0.375
39114, 0.3125, 1.62, 0.375
39115, 0.33333333333333, 1.62, 0.35416666666667
39116, 0.33333333333333, 1.64, 0.375
39117, 0.3125, 1.66, 0.375
39118, 0.33333333333333, 1.66, 0.35416666666667
39119, 0.33333333333333, 1.68, 0.375
39120, 0.33333333333333, 1.52, 0.41666666666667
39121, 0.3125, 1.54, 0.41666666666667
39122, 0.33333333333333, 1.54, 0.39583333333333
39123, 0.33333333333333, 1.56, 0.41666666666667
39124, 0.3125, 1.58, 0.41666666666667
39125, 0.33333333333333, 1.58, 0.39583333333333
39126, 0.33333333333333, 1.6, 0.41666666666667
39127, 0.3125, 1.62, 0.41666666666667
39128, 0.33333333333333, 1.62, 0.39583333333333
39129, 0.33333333333333, 1.64, 0.41666666666667
39130, 0.3125, 1.66, 0.41666666666667
39131, 0.33333333333333, 1.66, 0.39583333333333
39132, 0.33333333333333, 1.68, 0.41666666666667
39133, 0.33333333333333, 1.52, 0.45833333333333
39134, 0.3125, 1.54, 0.45833333333333
39135, 0.33333333333333, 1.54, 0.4375
39136, 0.33333333333333, 1.56, 0.45833333333333
39137, 0.3125, 1.58, 0.45833333333333
39138, 0.33333333333333, 1.58, 0.4375
39139, 0.33333333333333, 1.6, 0.45833333333333
39140, 0.3125, 1.62, 0.45833333333333
39141, 0.33333333333333, 1.62, 0.4375
39142, 0.33333333333333, 1.64, 0.45833333333333
39143, 0.3125, 1.66, 0.45833333333333
39144, 0.33333333333333, 1.66, 0.4375
39145, 0.33333333333333, 1.68, 0.45833333333333
39146, 0.33333333333333, 1.54, 0.47916666666667
39147, 0.33333333333333, 1.58, 0.47916666666667
39148, 0.33333333333333, 1.62, 0.47916666666667
39149, 0.33333333333333, 1.66, 0.47916666666667
39150, 0.375, 1.52, 0.041666666666667
39151, 0.35416666666667, 1.54, 0.041666666666667
39152, 0.375, 1.54, 0.020833333333333
39153, 0.375, 1.56, 0.041666666666667
39154, 0.35416666666667, 1.58, 0.041666666666667
39155, 0.375, 1.58, 0.020833333333333
39156, 0.375, 1.6, 0.041666666666667
39157, 0.35416666666667, 1.62, 0.041666666666667
39158, 0.375, 1.62, 0.020833333333333
39159, 0.375, 1.64, 0.041666666666667
39160, 0.35416666666667, 1.66, 0.041666666666667
39161, 0.375, 1.66, 0.020833333333333
39162, 0.375, 1.68, 0.041666666666667
39163, 0.375, 1.52, 0.083333333333333
39164, 0.35416666666667, 1.54, 0.083333333333333
39165, 0.375, 1.54, 0.0625
39166, 0.375, 1.56, 0.083333333333333
39167, 0.35416666666667, 1.58, 0.083333333333333
39168, 0.375, 1.58, 0.0625
39169, 0.375, 1.6, 0.083333333333333
39170, 0.35416666666667, 1.62, 0.083333333333333
39171, 0.375, 1.62, 0.0625
39172, 0.375, 1.64, 0.083333333333333
39173, 0.35416666666667, 1.66, 0.083333333333333
39174, 0.375, 1.66, 0.0625
39175, 0.375, 1.68, 0.083333333333333
39176, 0.375, 1.52, 0.125
39177, 0.35416666666667, 1.54, 0.125
39178, 0.375, 1.54, 0.10416666666667
39179, 0.375, 1.56, 0.125
39180, 0.35416666666667, 1.58, 0.125
39181, 0.375, 1.58, 0.10416666666667
39182, 0.375, 1.6, 0.125
39183, 0.35416666666667, 1.62, 0.125
39184, 0.375, 1.62, 0.10416666666667
39185, 0.375, 1.64, 0.125
39186, 0.35416666666667, 1.66, 0.125
39187, 0.375, 1.66, 0.10416666666667
39188, 0.375, 1.68, 0.125
39189, 0.375, 1.52, 0.16666666666667
39190, 0.35416666666667, 1.54, 0.16666666666667
39191, 0.375, 1.54, 0.14583333333333
39192, 0.375, 1.56, 0.16666666666667
39193, 0.35416666666667, 1.58, 0.16666666666667
39194, 0.375, 1.58, 0.14583333333333
39195, 0.375, 1.6, 0.16666666666667
39196, 0.35416666666667, 1.62, 0.16666666666667
39197, 0.375, 1.62, 0.14583333333333
39198, 0.375, 1.64, 0.16666666666667
39199, 0.35416666666667, 1.66, 0.16666666666667
39200, 0.375, 1.66, 0.14583333333333
39201, 0.375, 1.68, 0.16666666666667
39202, 0.375, 1.52, 0.20833333333333
39203, 0.35416666666667, 1.54, 0.20833333333333
39204, 0.375, 1.54, 0.1875
39205, 0.375, 1.56, 0.20833333333333
39206, 0.35416666666667, 1.58, 0.20833333333333
39207, 0.375, 1.58, 0.1875
39208, 0.375, 1.6, 0.20833333333333
39209, 0.35416666666667, 1.62, 0.20833333333333
39210, 0.375, 1.62, 0.1875
39211, 0.375, 1.64, 0.20833333333333
39212, 0.35416666666667, 1.66, 0.20833333333333
39213, 0.375, 1.66, 0.1875
39214, 0.375, 1.68, 0.20833333333333
39215, 0.375, 1.52, 0.25
39216, 0.35416666666667, 1.54, 0.25
39217, 0.375, 1.54, 0.22916666666667
39218, 0.375, 1.56, 0.25
39219, 0.35416666666667, 1.58, 0.25
39220, 0.375, 1.58, 0.22916666666667
39221, 0.375, 1.6, 0.25
39222, 0.35416666666667, 1.62, 0.25
39223, 0.375, 1.62, 0.22916666666667
39224, 0.375, 1.64, 0.25
39225, 0.35416666666667, 1.66, 0.25
39226, 0.375, 1.66, 0.22916666666667
39227, 0.375, 1.68, 0.25
39228, 0.375, 1.52, 0.29166666666667
39229, 0.35416666666667, 1.54, 0.29166666666667
39230, 0.375, 1.54, 0.27083333333333
39231, 0.375, 1.56, 0.29166666666667
39232, 0.35416666666667, 1.58, 0.29166666666667
39233, 0.375, 1.58, 0.27083333333333
39234, 0.375, 1.6, 0.29166666666667
39235, 0.35416666666667, 1.62, 0.29166666666667
39236, 0.375, 1.62, 0.27083333333333
39237, 0.375, 1.64, 0.29166666666667
39238, 0.35416666666667, 1.66, 0.29166666666667
39239, 0.375, 1.66, 0.27083333333333
39240, 0.375, 1.68, 0.29166666666667
39241, 0.375, 1.52, 0.33333333333333
39242, 0.35416666666667, 1.54, 0.33333333333333
39243, 0.375, 1.54, 0.3125
39244, 0.375, 1.56, 0.33333333333333
39245, 0.35416666666667, 1.58, 0.33333333333333
39246, 0.375, 1.58, 0.3125
39247, 0.375, 1.6, 0.33333333333333
39248, 0.35416666666667, 1.62, 0.33333333333333
39249, 0.375, 1.62, 0.3125
39250, 0.375, 1.64, 0.33333333333333
39251, 0.35416666666667, 1.66, 0.33333333333333
39252, 0.375, 1.66, 0.3125
39253, 0.375, 1.68, 0.33333333333333
39254, 0.375, 1.52, 0.375
39255, 0.35416666666667, 1.54, 0.375
39256, 0.375, 1.54, 0.35416666666667
39257, 0.375, 1.56, 0.375
39258, 0.35416666666667, 1.58, 0.375
39259, 0.375, 1.58, 0.35416666666667
39260, 0.375, 1.6, 0.375
39261, 0.35416666666667, 1.62, 0.375
39262, 0.375, 1.62, 0.35416666666667
39263, 0.375, 1.64, 0.375
39264, 0.35416666666667, 1.66, 0.375
39265, 0.375, 1.66, 0.35416666666667
39266, 0.375, 1.68, 0.375
39267, 0.375, 1.52, 0.41666666666667
39268, 0.35416666666667, 1.54, 0.41666666666667
39269, 0.375, 1.54, 0.39583333333333
39270, 0.375, 1.56, 0.41666666666667
39271, 0.35416666666667, 1.58, 0.41666666666667
39272, 0.375, 1.58, 0.39583333333333
39273, 0.375, 1.6, 0.41666666666667
39274, 0.35416666666667, 1.62, 0.41666666666667
39275, 0.375, 1.62, 0.39583333333333
39276, 0.375, 1.64, 0.41666666666667
39277, 0.35416666666667, 1.66, 0.41666666666667
39278, 0.375, 1.66, 0.39583333333333
39279, 0.375, 1.68, 0.41666666666667
39280, 0.375, 1.52, 0.45833333333333
39281, 0.35416666666667, 1.54, 0.45833333333333
39282, 0.375, 1.54, 0.4375
39283, 0.375, 1.56, 0.45833333333333
39284, 0.35416666666667, 1.58, 0.45833333333333
39285, 0.375, 1.58, 0.4375
39286, 0.375, 1.6, 0.45833333333333
39287, 0.35416666666667, 1.62, 0.45833333333333
39288, 0.375, 1.62, 0.4375
39289, 0.375, 1.64, 0.45833333333333
39290, 0.35416666666667, 1.66, 0.45833333333333
39291, 0.375, 1.66, 0.4375
39292, 0.375, 1.68, 0.45833333333333
39293, 0.375, 1.54, 0.47916666666667
39294, 0.375, 1.58, 0.47916666666667
39295, 0.375, 1.62, 0.47916666666667
39296, 0.375, 1.66, 0.47916666666667
39297, 0.41666666666667, 1.52, 0.041666666666667
39298, 0.39583333333333, 1.54, 0.041666666666667
39299, 0.41666666666667, 1.54, 0.020833333333333
39300, 0.41666666666667, 1.56, 0.041666666666667
39301, 0.39583333333333, 1.58, 0.041666666666667
39302, 0.41666666666667, 1.58, 0.020833333333333
39303, 0.41666666666667, 1.6, 0.041666666666667
39304, 0.39583333333333, 1.62, 0.041666666666667
39305, 0.41666666666667, 1.62, 0.020833333333333
39306, 0.41666666666667, 1.64, 0.041666666666667
39307, 0.39583333333333, 1.66, 0.041666666666667
39308, 0.41666666666667, 1.66, 0.020833333333333
39309, 0.41666666666667, 1.68, 0.041666666666667
39310, 0.41666666666667, 1.52, 0.083333333333333
39311, 0.39583333333333, 1.54, 0.083333333333333
39312, 0.41666666666667, 1.54, 0.0625
39313, 0.41666666666667, 1.56, 0.083333333333333
39314, 0.39583333333333, 1.58, 0.083333333333333
39315, 0.41666666666667, 1.58, 0.0625
39316, 0.41666666666667, 1.6, 0.083333333333333
39317, 0.39583333333333, 1.62, 0.083333333333333
39318, 0.41666666666667, 1.62, 0.0625
39319, 0.41666666666667, 1.64, 0.083333333333333
39320, 0.39583333333333, 1.66, 0.083333333333333
39321, 0.41666666666667, 1.66, 0.0625
39322, 0.41666666666667, 1.68, 0.083333333333333
39323, 0.41666666666667, 1.52, 0.125
39324, 0.39583333333333, 1.54, 0.125
39325, 0.41666666666667, 1.54, 0.10416666666667
39326, 0.41666666666667, 1.56, 0.125
39327, 0.39583333333333, 1.58, 0.125
39328, 0.41666666666667, 1.58, 0.10416666666667
39329, 0.41666666666667, 1.6, 0.125
39330, 0.39583333333333, 1.62, 0.125
39331, 0.41666666666667, 1.62, 0.10416666666667
39332, 0.41666666666667, 1.64, 0.125
39333, 0.39583333333333, 1.66, 0.125
39334, 0.41666666666667, 1.66, 0.10416666666667
39335, 0.41666666666667, 1.68, 0.125
39336, 0.41666666666667, 1.52, 0.16666666666667
39337, 0.39583333333333, 1.54, 0.16666666666667
39338, 0.41666666666667, 1.54, 0.14583333333333
39339, 0.41666666666667, 1.56, 0.16666666666667
39340, 0.39583333333333, 1.58, 0.16666666666667
39341, 0.41666666666667, 1.58, 0.14583333333333
39342, 0.41666666666667, 1.6, 0.16666666666667
39343, 0.39583333333333, 1.62, 0.16666666666667
39344, 0.41666666666667, 1.62, 0.14583333333333
39345, 0.41666666666667, 1.64, 0.16666666666667
39346, 0.39583333333333, 1.66, 0.16666666666667
39347, 0.41666666666667, 1.66, 0.14583333333333
39348, 0.41666666666667, 1.68, 0.16666666666667
39349, 0.41666666666667, 1.52, 0.20833333333333
39350, 0.39583333333333, 1.54, 0.20833333333333
39351, 0.41666666666667, 1.54, 0.1875
39352, 0.41666666666667, 1.56, 0.20833333333333
39353, 0.39583333333333, 1.58, 0.20833333333333
39354, 0.41666666666667, 1.58, 0.1875
39355, 0.41666666666667, 1.6, 0.20833333333333
39356, 0.39583333333333, 1.62, 0.20833333333333
39357, 0.41666666666667, 1.62, 0.1875
39358, 0.41666666666667, 1.64, 0.20833333333333
39359, 0.39583333333333, 1.66, 0.20833333333333
39360, 0.41666666666667, 1.66, 0.1875
39361, 0.41666666666667, 1.68, 0.20833333333333
39362, 0.41666666666667, 1.52, 0.25
39363, 0.39583333333333, 1.54, 0.25
39364, 0.41666666666667, 1.54, 0.22916666666667
39365, 0.41666666666667, 1.56, 0.25
39366, 0.39583333333333, 1.58, 0.25
39367, 0.41666666666667, 1.58, 0.22916666666667
39368, 0.41666666666667, 1.6, 0.25
39369, 0.39583333333333, 1.62, 0.25
39370, 0.41666666666667, 1.62, 0.22916666666667
39371, 0.41666666666667, 1.64, 0.25
39372, 0.39583333333333, 1.66, 0.25
39373, 0.41666666666667, 1.66, 0.22916666666667
39374, 0.41666666666667, 1.68, 0.25
39375, 0.41666666666667, 1.52, 0.29166666666667
39376, 0.39583333333333, 1.54, 0.29166666666667
39377, 0.41666666666667, 1.54, 0.27083333333333
39378, 0.41666666666667, 1.56, 0.29166666666667
39379, 0.39583333333333, 1.58, 0.29166666666667
39380, 0.41666666666667, 1.58, 0.27083333333333
39381, 0.41666666666667, 1.6, 0.29166666666667
39382, 0.39583333333333, 1.62, 0.29166666666667
39383, 0.41666666666667, 1.62, 0.27083333333333
39384, 0.41666666666667, 1.64, 0.29166666666667
39385, 0.39583333333333, 1.66, 0.29166666666667
39386, 0.41666666666667, 1.66, 0.27083333333333
39387, 0.41666666666667, 1.68, 0.29166666666667
39388, 0.41666666666667, 1.52, 0.33333333333333
39389, 0.39583333333333, 1.54, 0.33333333333333
39390, 0.41666666666667, 1.54, 0.3125
39391, 0.41666666666667, 1.56, 0.33333333333333
39392, 0.39583333333333, 1.58, 0.33333333333333
39393, 0.41666666666667, 1.58, 0.3125
39394, 0.41666666666667, 1.6, 0.33333333333333
39395, 0.39583333333333, 1.62, 0.33333333333333
39396, 0.41666666666667, 1.62, 0.3125
39397, 0.41666666666667, 1.64, 0.33333333333333
39398, 0.39583333333333, 1.66, 0.33333333333333
39399, 0.41666666666667, 1.66, 0.3125
39400, 0.41666666666667, 1.68, 0.33333333333333
39401, 0.41666666666667, 1.52, 0.375
39402, 0.39583333333333, 1.54, 0.375
39403, 0.41666666666667, 1.54, 0.35416666666667
39404, 0.41666666666667, 1.56, 0.375
39405, 0.39583333333333, 1.58, 0.375
39406, 0.41666666666667, 1.58, 0.35416666666667
39407, 0.41666666666667, 1.6, 0.375
39408, 0.39583333333333, 1.62, 0.375
39409, 0.41666666666667, 1.62, 0.35416666666667
39410, 0.41666666666667, 1.64, 0.375
39411, 0.39583333333333, 1.66, 0.375
39412, 0.41666666666667, 1.66, 0.35416666666667
39413, 0.41666666666667, 1.68, 0.375
39414, 0.41666666666667, 1.52, 0.41666666666667
39415, 0.39583333333333, 1.54, 0.41666666666667
39416, 0.41666666666667, 1.54, 0.39583333333333
39417, 0.41666666666667, 1.56, 0.41666666666667
39418, 0.39583333333333, 1.58, 0.41666666666667
39419, 0.41666666666667, 1.58, 0.39583333333333
39420, 0.41666666666667, 1.6, 0.41666666666667
39421, 0.39583333333333, 1.62, 0.41666666666667
39422, 0.41666666666667, 1.62, 0.39583333333333
39423, 0.41666666666667, 1.64, 0.41666666666667
39424, 0.39583333333333, 1.66, 0.41666666666667
39425, 0.41666666666667, 1.66, 0.39583333333333
39426, 0.41666666666667, 1.68, 0.41666666666667
39427, 0.41666666666667, 1.52, 0.45833333333333
39428, 0.39583333333333, 1.54, 0.45833333333333
39429, 0.41666666666667, 1.54, 0.4375
39430, 0.41666666666667, 1.56, 0.45833333333333
39431, 0.39583333333333, 1.58, 0.45833333333333
39432, 0.41666666666667, 1.58, 0.4375
39433, 0.41666666666667, 1.6, 0.45833333333333
39434, 0.39583333333333, 1.62, 0.45833333333333
39435, 0.41666666666667, 1.62, 0.4375
39436, 0.41666666666667, 1.64, 0.45833333333333
39437, 0.39583333333333, 1.66, 0.45833333333333
39438, 0.41666666666667, 1.66, 0.4375
39439, 0.41666666666667, 1.68, 0.45833333333333
39440, 0.41666666666667, 1.54, 0.47916666666667
39441, 0.41666666666667, 1.58, 0.47916666666667
39442, 0.41666666666667, 1.62, 0.47916666666667
39443, 0.41666666666667, 1.66, 0.47916666666667
39444, 0.45833333333333, 1.52, 0.041666666666667
39445, 0.4375, 1.54, 0.041666666666667
39446, 0.45833333333333, 1.54, 0.020833333333333
39447, 0.45833333333333, 1.56, 0.041666666666667
39448, 0.4375, 1.58, 0.041666666666667
39449, 0.45833333333333, 1.58, 0.020833333333333
39450, 0.45833333333333, 1.6, 0.041666666666667
39451, 0.4375, 1.62, 0.041666666666667
39452, 0.45833333333333, 1.62, 0.020833333333333
39453, 0.45833333333333, 1.64, 0.041666666666667
39454, 0.4375, 1.66, 0.041666666666667
39455, 0.45833333333333, 1.66, 0.020833333333333
39456, 0.45833333333333, 1.68, 0.041666666666667
39457, 0.45833333333333, 1.52, 0.083333333333333
39458, 0.4375, 1.54, 0.083333333333333
39459, 0.45833333333333, 1.54, 0.0625
39460, 0.45833333333333, 1.56, 0.083333333333333
39461, 0.4375, 1.58, 0.083333333333333
39462, 0.45833333333333, 1.58, 0.0625
39463, 0.45833333333333, 1.6, 0.083333333333333
39464, 0.4375, 1.62, 0.083333333333333
39465, 0.45833333333333, 1.62, 0.0625
39466, 0.45833333333333, 1.64, 0.083333333333333
39467, 0.4375, 1.66, 0.083333333333333
39468, 0.45833333333333, 1.66, 0.0625
39469, 0.45833333333333, 1.68, 0.083333333333333
39470, 0.45833333333333, 1.52, 0.125
39471, 0.4375, 1.54, 0.125
39472, 0.45833333333333, 1.54, 0.10416666666667
39473, 0.45833333333333, 1.56, 0.125
39474, 0.4375, 1.58, 0.125
39475, 0.45833333333333, 1.58, 0.10416666666667
39476, 0.45833333333333, 1.6, 0.125
39477, 0.4375, 1.62, 0.125
39478, 0.45833333333333, 1.62, 0.10416666666667
39479, 0.45833333333333, 1.64, 0.125
39480, 0.4375, 1.66, 0.125
39481, 0.45833333333333, 1.66, 0.10416666666667
39482, 0.45833333333333, 1.68, 0.125
39483, 0.45833333333333, 1.52, 0.16666666666667
39484, 0.4375, 1.54, 0.16666666666667
39485, 0.45833333333333, 1.54, 0.14583333333333
39486, 0.45833333333333, 1.56, 0.16666666666667
39487, 0.4375, 1.58, 0.16666666666667
39488, 0.45833333333333, 1.58, 0.14583333333333
39489, 0.45833333333333, 1.6, 0.16666666666667
39490, 0.4375, 1.62, 0.16666666666667
39491, 0.45833333333333, 1.62, 0.14583333333333
39492, 0.45833333333333, 1.64, 0.16666666666667
39493, 0.4375, 1.66, 0.16666666666667
39494, 0.45833333333333, 1.66, 0.14583333333333
39495, 0.45833333333333, 1.68, 0.16666666666667
39496, 0.45833333333333, 1.52, 0.20833333333333
39497, 0.4375, 1.54, 0.20833333333333
39498, 0.45833333333333, 1.54, 0.1875
39499, 0.45833333333333, 1.56, 0.20833333333333
39500, 0.4375, 1.58, 0.20833333333333
39501, 0.45833333333333, 1.58, 0.1875
39502, 0.45833333333333, 1.6, 0.20833333333333
39503, 0.4375, 1.62, 0.20833333333333
39504, 0.45833333333333, 1.62, 0.1875
39505, 0.45833333333333, 1.64, 0.20833333333333
39506, 0.4375, 1.66, 0.20833333333333
39507, 0.45833333333333, 1.66, 0.1875
39508, 0.45833333333333, 1.68, 0.20833333333333
39509, 0.45833333333333, 1.52, 0.25
39510, 0.4375, 1.54, 0.25
39511, 0.45833333333333, 1.54, 0.22916666666667
39512, 0.45833333333333, 1.56, 0.25
39513, 0.4375, 1.58, 0.25
39514, 0.45833333333333, 1.58, 0.22916666666667
39515, 0.45833333333333, 1.6, 0.25
39516, 0.4375, 1.62, 0.25
39517, 0.45833333333333, 1.62, 0.22916666666667
39518, 0.45833333333333, 1.64, 0.25
39519, 0.4375, 1.66, 0.25
39520, 0.45833333333333, 1.66, 0.22916666666667
39521, 0.45833333333333, 1.68, 0.25
39522, 0.45833333333333, 1.52, 0.29166666666667
39523, 0.4375, 1.54, 0.29166666666667
39524, 0.45833333333333, 1.54, 0.27083333333333
39525, 0.45833333333333, 1.56, 0.29166666666667
39526, 0.4375, 1.58, 0.29166666666667
39527, 0.45833333333333, 1.58, 0.27083333333333
39528, 0.45833333333333, 1.6, 0.29166666666667
39529, 0.4375, 1.62, 0.29166666666667
39530, 0.45833333333333, 1.62, 0.27083333333333
39531, 0.45833333333333, 1.64, 0.29166666666667
39532, 0.4375, 1.66, 0.29166666666667
39533, 0.45833333333333, 1.66, 0.27083333333333
39534, 0.45833333333333, 1.68, 0.29166666666667
39535, 0.45833333333333, 1.52, 0.33333333333333
39536, 0.4375, 1.54, 0.33333333333333
39537, 0.45833333333333, 1.54, 0.3125
39538, 0.45833333333333, 1.56, 0.33333333333333
39539, 0.4375, 1.58, 0.33333333333333
39540, 0.45833333333333, 1.58, 0.3125
39541, 0.45833333333333, 1.6, 0.33333333333333
39542, 0.4375, 1.62, 0.33333333333333
39543, 0.45833333333333, 1.62, 0.3125
39544, 0.45833333333333, 1.64, 0.33333333333333
39545, 0.4375, 1.66, 0.33333333333333
39546, 0.45833333333333, 1.66, 0.3125
39547, 0.45833333333333, 1.68, 0.33333333333333
39548, 0.45833333333333, 1.52, 0.375
39549, 0.4375, 1.54, 0.375
39550, 0.45833333333333, 1.54, 0.35416666666667
39551, 0.45833333333333, 1.56, 0.375
39552, 0.4375, 1.58, 0.375
39553, 0.45833333333333, 1.58, 0.35416666666667
39554, 0.45833333333333, 1.6, 0.375
39555, 0.4375, 1.62, 0.375
39556, 0.45833333333333, 1.62, 0.35416666666667
39557, 0.45833333333333, 1.64, 0.375
39558, 0.4375, 1.66, 0.375
39559, 0.45833333333333, 1.66, 0.35416666666667
39560, 0.45833333333333, 1.68, 0.375
39561, 0.45833333333333, 1.52, 0.41666666666667
39562, 0.4375, 1.54, 0.41666666666667
39563, 0.45833333333333, 1.54, 0.39583333333333
39564, 0.45833333333333, 1.56, 0.41666666666667
39565, 0.4375, 1.58, 0.41666666666667
39566, 0.45833333333333, 1.58, 0.39583333333333
39567, 0.45833333333333, 1.6, 0.41666666666667
39568, 0.4375, 1.62, 0.41666666666667
39569, 0.45833333333333, 1.62, 0.39583333333333
39570, 0.45833333333333, 1.64, 0.41666666666667
39571, 0.4375, 1.66, 0.41666666666667
39572, 0.45833333333333, 1.66, 0.39583333333333
39573, 0.45833333333333, 1.68, 0.41666666666667
39574, 0.45833333333333, 1.52, 0.45833333333333
39575, 0.4375, 1.54, 0.45833333333333
39576, 0.45833333333333, 1.54, 0.4375
39577, 0.45833333333333, 1.56, 0.45833333333333
39578, 0.4375, 1.58, 0.45833333333333
39579, 0.45833333333333, 1.58, 0.4375
39580, 0.45833333333333, 1.6, 0.45833333333333
39581, 0.4375, 1.62, 0.45833333333333
39582, 0.45833333333333, 1.62, 0.4375
39583, 0.45833333333333, 1.64, 0.45833333333333
39584, 0.4375, 1.66, 0.45833333333333
39585, 0.45833333333333, 1.66, 0.4375
39586, 0.45833333333333, 1.68, 0.45833333333333
39587, 0.45833333333333, 1.54, 0.47916666666667
39588, 0.45833333333333, 1.58, 0.47916666666667
39589, 0.45833333333333, 1.62, 0.47916666666667
39590, 0.45833333333333, 1.66, 0.47916666666667
39591, 0.5, 1.52, 0.041666666666667
39592, 0.47916666666667, 1.54, 0.041666666666667
39593, 0.5, 1.54, 0.020833333333333
39594, 0.5, 1.56, 0.041666666666667
39595, 0.47916666666667, 1.58, 0.041666666666667
39596, 0.5, 1.58, 0.020833333333333
39597, 0.5, 1.6, 0.041666666666667
39598, 0.47916666666667, 1.62, 0.041666666666667
39599, 0.5, 1.62, 0.020833333333333
39600, 0.5, 1.64, 0.041666666666667
39601, 0.47916666666667, 1.66, 0.041666666666667
39602, 0.5, 1.66, 0.020833333333333
39603, 0.5, 1.68, 0.041666666666667
39604, 0.5, 1.52, 0.083333333333333
39605, 0.47916666666667, 1.54, 0.083333333333333
39606, 0.5, 1.54, 0.0625
39607, 0.5, 1.56, 0.083333333333333
39608, 0.47916666666667, 1.58, 0.083333333333333
39609, 0.5, 1.58, 0.0625
39610, 0.5, 1.6, 0.083333333333333
39611, 0.47916666666667, 1.62, 0.083333333333333
39612, 0.5, 1.62, 0.0625
39613, 0.5, 1.64, 0.083333333333333
39614, 0.47916666666667, 1.66, 0.083333333333333
39615, 0.5, 1.66, 0.0625
39616, 0.5, 1.68, 0.083333333333333
39617, 0.5, 1.52, 0.125
39618, 0.47916666666667, 1.54, 0.125
39619, 0.5, 1.54, 0.10416666666667
39620, 0.5, 1.56, 0.125
39621, 0.47916666666667, 1.58, 0.125
39622, 0.5, 1.58, 0.10416666666667
39623, 0.5, 1.6, 0.125
39624, 0.47916666666667, 1.62, 0.125
