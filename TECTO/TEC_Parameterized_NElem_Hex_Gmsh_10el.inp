15135, 2.1166666666667, 0.175, -0.1
15136, 2.1583333333333, 1.325, -0.1
15137, 2.1375, 1.3, -0.1
15138, 2.1583333333333, 1.275, -0.1
15139, 2.1375, 1.25, -0.1
15140, 2.1583333333333, 1.225, -0.1
15141, 2.1375, 1.2, -0.1
15142, 2.1583333333333, 1.175, -0.1
15143, 2.1375, 1.15, -0.1
15144, 2.1583333333333, 1.125, -0.1
15145, 2.1375, 1.1, -0.1
15146, 2.1583333333333, 1.075, -0.1
15147, 2.1375, 1.05, -0.1
15148, 2.1583333333333, 1.025, -0.1
15149, 2.1375, 1, -0.1
15150, 2.1583333333333, 0.975, -0.1
15151, 2.1375, 0.95, -0.1
15152, 2.1583333333333, 0.925, -0.1
15153, 2.1375, 0.9, -0.1
15154, 2.1583333333333, 0.875, -0.1
15155, 2.1375, 0.85, -0.1
15156, 2.1583333333333, 0.825, -0.1
15157, 2.1375, 0.8, -0.1
15158, 2.1583333333333, 0.775, -0.1
15159, 2.1375, 0.75, -0.1
15160, 2.1583333333333, 0.725, -0.1
15161, 2.1375, 0.7, -0.1
15162, 2.1583333333333, 0.675, -0.1
15163, 2.1375, 0.65, -0.1
15164, 2.1583333333333, 0.625, -0.1
15165, 2.1375, 0.6, -0.1
15166, 2.1583333333333, 0.575, -0.1
15167, 2.1375, 0.55, -0.1
15168, 2.1583333333333, 0.525, -0.1
15169, 2.1375, 0.5, -0.1
15170, 2.1583333333333, 0.475, -0.1
15171, 2.1375, 0.45, -0.1
15172, 2.1583333333333, 0.425, -0.1
15173, 2.1375, 0.4, -0.1
15174, 2.1583333333333, 0.375, -0.1
15175, 2.1375, 0.35, -0.1
15176, 2.1583333333333, 0.325, -0.1
15177, 2.1375, 0.3, -0.1
15178, 2.1583333333333, 0.275, -0.1
15179, 2.1375, 0.25, -0.1
15180, 2.1583333333333, 0.225, -0.1
15181, 2.1375, 0.2, -0.1
15182, 2.1583333333333, 0.175, -0.1
15183, 2.1791666666667, 1.3, -0.1
15184, 2.1791666666667, 1.25, -0.1
15185, 2.1791666666667, 1.2, -0.1
15186, 2.1791666666667, 1.15, -0.1
15187, 2.1791666666667, 1.1, -0.1
15188, 2.1791666666667, 1.05, -0.1
15189, 2.1791666666667, 1, -0.1
15190, 2.1791666666667, 0.95, -0.1
15191, 2.1791666666667, 0.9, -0.1
15192, 2.1791666666667, 0.85, -0.1
15193, 2.1791666666667, 0.8, -0.1
15194, 2.1791666666667, 0.75, -0.1
15195, 2.1791666666667, 0.7, -0.1
15196, 2.1791666666667, 0.65, -0.1
15197, 2.1791666666667, 0.6, -0.1
15198, 2.1791666666667, 0.55, -0.1
15199, 2.1791666666667, 0.5, -0.1
15200, 2.1791666666667, 0.45, -0.1
15201, 2.1791666666667, 0.4, -0.1
15202, 2.1791666666667, 0.35, -0.1
15203, 2.1791666666667, 0.3, -0.1
15204, 2.1791666666667, 0.25, -0.1
15205, 2.1791666666667, 0.2, -0.1
15206, 1.15, 1.3, -0.05
15207, 1.15, 1.25, -0.05
15208, 1.15, 1.2, -0.05
15209, 1.15, 1.15, -0.05
15210, 1.15, 1.1, -0.05
15211, 1.15, 1.05, -0.05
15212, 1.15, 1, -0.05
15213, 1.15, 0.95, -0.05
15214, 1.15, 0.9, -0.05
15215, 1.15, 0.85, -0.05
15216, 1.15, 0.8, -0.05
15217, 1.15, 0.75, -0.05
15218, 1.15, 0.7, -0.05
15219, 1.15, 0.65, -0.05
15220, 1.15, 0.6, -0.05
15221, 1.15, 0.55, -0.05
15222, 1.15, 0.5, -0.05
15223, 1.15, 0.45, -0.05
15224, 1.15, 0.4, -0.05
15225, 1.15, 0.35, -0.05
15226, 1.15, 0.3, -0.05
15227, 1.15, 0.25, -0.05
15228, 1.15, 0.2, -0.05
15229, 1.175, 1.3, -0.1
15230, 1.175, 1.25, -0.1
15231, 1.175, 1.2, -0.1
15232, 1.175, 1.15, -0.1
15233, 1.175, 1.1, -0.1
15234, 1.175, 1.05, -0.1
15235, 1.175, 1, -0.1
15236, 1.175, 0.95, -0.1
15237, 1.175, 0.9, -0.1
15238, 1.175, 0.85, -0.1
15239, 1.175, 0.8, -0.1
15240, 1.175, 0.75, -0.1
15241, 1.175, 0.7, -0.1
15242, 1.175, 0.65, -0.1
15243, 1.175, 0.6, -0.1
15244, 1.175, 0.55, -0.1
15245, 1.175, 0.5, -0.1
15246, 1.175, 0.45, -0.1
15247, 1.175, 0.4, -0.1
15248, 1.175, 0.35, -0.1
15249, 1.175, 0.3, -0.1
15250, 1.175, 0.25, -0.1
15251, 1.175, 0.2, -0.1
15252, 1.05, 0.2, -0.05
15253, 1.05, 0.25, -0.05
15254, 1.05, 0.3, -0.05
15255, 1.05, 0.35, -0.05
15256, 1.05, 0.4, -0.05
15257, 1.05, 0.45, -0.05
15258, 1.05, 0.5, -0.05
15259, 1.05, 0.55, -0.05
15260, 1.05, 0.6, -0.05
15261, 1.05, 0.65, -0.05
15262, 1.05, 0.7, -0.05
15263, 1.05, 0.75, -0.05
15264, 1.05, 0.8, -0.05
15265, 1.05, 0.85, -0.05
15266, 1.05, 0.9, -0.05
15267, 1.05, 0.95, -0.05
15268, 1.05, 1, -0.05
15269, 1.05, 1.05, -0.05
15270, 1.05, 1.1, -0.05
15271, 1.05, 1.15, -0.05
15272, 1.05, 1.2, -0.05
15273, 1.05, 1.25, -0.05
15274, 1.05, 1.3, -0.05
15275, 1.025, 0.2, -0.1
15276, 1.025, 0.25, -0.1
15277, 1.025, 0.3, -0.1
15278, 1.025, 0.35, -0.1
15279, 1.025, 0.4, -0.1
15280, 1.025, 0.45, -0.1
15281, 1.025, 0.5, -0.1
15282, 1.025, 0.55, -0.1
15283, 1.025, 0.6, -0.1
15284, 1.025, 0.65, -0.1
15285, 1.025, 0.7, -0.1
15286, 1.025, 0.75, -0.1
15287, 1.025, 0.8, -0.1
15288, 1.025, 0.85, -0.1
15289, 1.025, 0.9, -0.1
15290, 1.025, 0.95, -0.1
15291, 1.025, 1, -0.1
15292, 1.025, 1.05, -0.1
15293, 1.025, 1.1, -0.1
15294, 1.025, 1.15, -0.1
15295, 1.025, 1.2, -0.1
15296, 1.025, 1.25, -0.1
15297, 1.025, 1.3, -0.1
15298, 0.041666666666667, 1.54, 0
15299, 0.041666666666667, 1.58, 0
15300, 0.041666666666667, 1.62, 0
15301, 0.041666666666667, 1.66, 0
15302, 0.083333333333333, 1.54, 0
15303, 0.083333333333333, 1.58, 0
15304, 0.083333333333333, 1.62, 0
15305, 0.083333333333333, 1.66, 0
15306, 0.125, 1.54, 0
15307, 0.125, 1.58, 0
15308, 0.125, 1.62, 0
15309, 0.125, 1.66, 0
15310, 0.16666666666667, 1.54, 0
15311, 0.16666666666667, 1.58, 0
15312, 0.16666666666667, 1.62, 0
15313, 0.16666666666667, 1.66, 0
15314, 0.20833333333333, 1.54, 0
15315, 0.20833333333333, 1.58, 0
15316, 0.20833333333333, 1.62, 0
15317, 0.20833333333333, 1.66, 0
15318, 0.25, 1.54, 0
15319, 0.25, 1.58, 0
15320, 0.25, 1.62, 0
15321, 0.25, 1.66, 0
15322, 0.29166666666667, 1.54, 0
15323, 0.29166666666667, 1.58, 0
15324, 0.29166666666667, 1.62, 0
15325, 0.29166666666667, 1.66, 0
15326, 0.33333333333333, 1.54, 0
15327, 0.33333333333333, 1.58, 0
15328, 0.33333333333333, 1.62, 0
15329, 0.33333333333333, 1.66, 0
15330, 0.375, 1.54, 0
15331, 0.375, 1.58, 0
15332, 0.375, 1.62, 0
15333, 0.375, 1.66, 0
15334, 0.41666666666667, 1.54, 0
15335, 0.41666666666667, 1.58, 0
15336, 0.41666666666667, 1.62, 0
15337, 0.41666666666667, 1.66, 0
15338, 0.45833333333333, 1.54, 0
15339, 0.45833333333333, 1.58, 0
15340, 0.45833333333333, 1.62, 0
15341, 0.45833333333333, 1.66, 0
15342, 0.5, 1.54, 0
15343, 0.5, 1.58, 0
15344, 0.5, 1.62, 0
15345, 0.5, 1.66, 0
15346, 0.54166666666667, 1.54, 0
15347, 0.54166666666667, 1.58, 0
15348, 0.54166666666667, 1.62, 0
15349, 0.54166666666667, 1.66, 0
15350, 0.58333333333333, 1.54, 0
15351, 0.58333333333333, 1.58, 0
15352, 0.58333333333333, 1.62, 0
15353, 0.58333333333333, 1.66, 0
15354, 0.625, 1.54, 0
15355, 0.625, 1.58, 0
15356, 0.625, 1.62, 0
15357, 0.625, 1.66, 0
15358, 0.66666666666667, 1.54, 0
15359, 0.66666666666667, 1.58, 0
15360, 0.66666666666667, 1.62, 0
15361, 0.66666666666667, 1.66, 0
15362, 0.70833333333333, 1.54, 0
15363, 0.70833333333333, 1.58, 0
15364, 0.70833333333333, 1.62, 0
15365, 0.70833333333333, 1.66, 0
15366, 0.75, 1.54, 0
15367, 0.75, 1.58, 0
15368, 0.75, 1.62, 0
15369, 0.75, 1.66, 0
15370, 0.79166666666667, 1.54, 0
15371, 0.79166666666667, 1.58, 0
15372, 0.79166666666667, 1.62, 0
15373, 0.79166666666667, 1.66, 0
15374, 0.83333333333333, 1.54, 0
15375, 0.83333333333333, 1.58, 0
15376, 0.83333333333333, 1.62, 0
15377, 0.83333333333333, 1.66, 0
15378, 0.875, 1.54, 0
15379, 0.875, 1.58, 0
15380, 0.875, 1.62, 0
15381, 0.875, 1.66, 0
15382, 0.91666666666667, 1.54, 0
15383, 0.91666666666667, 1.58, 0
15384, 0.91666666666667, 1.62, 0
15385, 0.91666666666667, 1.66, 0
15386, 0.95833333333333, 1.54, 0
15387, 0.95833333333333, 1.58, 0
15388, 0.95833333333333, 1.62, 0
15389, 0.95833333333333, 1.66, 0
15390, 0.020833333333333, 1.54, 0
15391, 0.041666666666667, 1.52, 0
15392, 0.020833333333333, 1.58, 0
15393, 0.041666666666667, 1.56, 0
15394, 0.020833333333333, 1.62, 0
15395, 0.041666666666667, 1.6, 0
15396, 0.020833333333333, 1.66, 0
15397, 0.041666666666667, 1.64, 0
15398, 0.041666666666667, 1.68, 0
15399, 0.0625, 1.54, 0
15400, 0.083333333333333, 1.52, 0
15401, 0.0625, 1.58, 0
15402, 0.083333333333333, 1.56, 0
15403, 0.0625, 1.62, 0
15404, 0.083333333333333, 1.6, 0
15405, 0.0625, 1.66, 0
15406, 0.083333333333333, 1.64, 0
15407, 0.083333333333333, 1.68, 0
15408, 0.10416666666667, 1.54, 0
15409, 0.125, 1.52, 0
15410, 0.10416666666667, 1.58, 0
15411, 0.125, 1.56, 0
15412, 0.10416666666667, 1.62, 0
15413, 0.125, 1.6, 0
15414, 0.10416666666667, 1.66, 0
15415, 0.125, 1.64, 0
15416, 0.125, 1.68, 0
15417, 0.14583333333333, 1.54, 0
15418, 0.16666666666667, 1.52, 0
15419, 0.14583333333333, 1.58, 0
15420, 0.16666666666667, 1.56, 0
15421, 0.14583333333333, 1.62, 0
15422, 0.16666666666667, 1.6, 0
15423, 0.14583333333333, 1.66, 0
15424, 0.16666666666667, 1.64, 0
15425, 0.16666666666667, 1.68, 0
15426, 0.1875, 1.54, 0
15427, 0.20833333333333, 1.52, 0
15428, 0.1875, 1.58, 0
15429, 0.20833333333333, 1.56, 0
15430, 0.1875, 1.62, 0
15431, 0.20833333333333, 1.6, 0
15432, 0.1875, 1.66, 0
15433, 0.20833333333333, 1.64, 0
15434, 0.20833333333333, 1.68, 0
15435, 0.22916666666667, 1.54, 0
15436, 0.25, 1.52, 0
15437, 0.22916666666667, 1.58, 0
15438, 0.25, 1.56, 0
15439, 0.22916666666667, 1.62, 0
15440, 0.25, 1.6, 0
15441, 0.22916666666667, 1.66, 0
15442, 0.25, 1.64, 0
15443, 0.25, 1.68, 0
15444, 0.27083333333333, 1.54, 0
15445, 0.29166666666667, 1.52, 0
15446, 0.27083333333333, 1.58, 0
15447, 0.29166666666667, 1.56, 0
15448, 0.27083333333333, 1.62, 0
15449, 0.29166666666667, 1.6, 0
15450, 0.27083333333333, 1.66, 0
15451, 0.29166666666667, 1.64, 0
15452, 0.29166666666667, 1.68, 0
15453, 0.3125, 1.54, 0
15454, 0.33333333333333, 1.52, 0
15455, 0.3125, 1.58, 0
15456, 0.33333333333333, 1.56, 0
15457, 0.3125, 1.62, 0
15458, 0.33333333333333, 1.6, 0
15459, 0.3125, 1.66, 0
15460, 0.33333333333333, 1.64, 0
15461, 0.33333333333333, 1.68, 0
15462, 0.35416666666667, 1.54, 0
15463, 0.375, 1.52, 0
15464, 0.35416666666667, 1.58, 0
15465, 0.375, 1.56, 0
15466, 0.35416666666667, 1.62, 0
15467, 0.375, 1.6, 0
15468, 0.35416666666667, 1.66, 0
15469, 0.375, 1.64, 0
15470, 0.375, 1.68, 0
15471, 0.39583333333333, 1.54, 0
15472, 0.41666666666667, 1.52, 0
15473, 0.39583333333333, 1.58, 0
15474, 0.41666666666667, 1.56, 0
15475, 0.39583333333333, 1.62, 0
15476, 0.41666666666667, 1.6, 0
15477, 0.39583333333333, 1.66, 0
15478, 0.41666666666667, 1.64, 0
15479, 0.41666666666667, 1.68, 0
15480, 0.4375, 1.54, 0
15481, 0.45833333333333, 1.52, 0
15482, 0.4375, 1.58, 0
15483, 0.45833333333333, 1.56, 0
15484, 0.4375, 1.62, 0
15485, 0.45833333333333, 1.6, 0
15486, 0.4375, 1.66, 0
15487, 0.45833333333333, 1.64, 0
15488, 0.45833333333333, 1.68, 0
15489, 0.47916666666667, 1.54, 0
15490, 0.5, 1.52, 0
15491, 0.47916666666667, 1.58, 0
15492, 0.5, 1.56, 0
15493, 0.47916666666667, 1.62, 0
15494, 0.5, 1.6, 0
15495, 0.47916666666667, 1.66, 0
15496, 0.5, 1.64, 0
15497, 0.5, 1.68, 0
15498, 0.52083333333333, 1.54, 0
15499, 0.54166666666667, 1.52, 0
15500, 0.52083333333333, 1.58, 0
15501, 0.54166666666667, 1.56, 0
15502, 0.52083333333333, 1.62, 0
15503, 0.54166666666667, 1.6, 0
15504, 0.52083333333333, 1.66, 0
15505, 0.54166666666667, 1.64, 0
15506, 0.54166666666667, 1.68, 0
15507, 0.5625, 1.54, 0
15508, 0.58333333333333, 1.52, 0
15509, 0.5625, 1.58, 0
15510, 0.58333333333333, 1.56, 0
15511, 0.5625, 1.62, 0
15512, 0.58333333333333, 1.6, 0
15513, 0.5625, 1.66, 0
15514, 0.58333333333333, 1.64, 0
15515, 0.58333333333333, 1.68, 0
15516, 0.60416666666667, 1.54, 0
15517, 0.625, 1.52, 0
15518, 0.60416666666667, 1.58, 0
15519, 0.625, 1.56, 0
15520, 0.60416666666667, 1.62, 0
15521, 0.625, 1.6, 0
15522, 0.60416666666667, 1.66, 0
15523, 0.625, 1.64, 0
15524, 0.625, 1.68, 0
15525, 0.64583333333333, 1.54, 0
15526, 0.66666666666667, 1.52, 0
15527, 0.64583333333333, 1.58, 0
15528, 0.66666666666667, 1.56, 0
15529, 0.64583333333333, 1.62, 0
15530, 0.66666666666667, 1.6, 0
15531, 0.64583333333333, 1.66, 0
15532, 0.66666666666667, 1.64, 0
15533, 0.66666666666667, 1.68, 0
15534, 0.6875, 1.54, 0
15535, 0.70833333333333, 1.52, 0
15536, 0.6875, 1.58, 0
15537, 0.70833333333333, 1.56, 0
15538, 0.6875, 1.62, 0
15539, 0.70833333333333, 1.6, 0
15540, 0.6875, 1.66, 0
15541, 0.70833333333333, 1.64, 0
15542, 0.70833333333333, 1.68, 0
15543, 0.72916666666667, 1.54, 0
15544, 0.75, 1.52, 0
15545, 0.72916666666667, 1.58, 0
15546, 0.75, 1.56, 0
15547, 0.72916666666667, 1.62, 0
15548, 0.75, 1.6, 0
15549, 0.72916666666667, 1.66, 0
15550, 0.75, 1.64, 0
15551, 0.75, 1.68, 0
15552, 0.77083333333333, 1.54, 0
15553, 0.79166666666667, 1.52, 0
15554, 0.77083333333333, 1.58, 0
15555, 0.79166666666667, 1.56, 0
15556, 0.77083333333333, 1.62, 0
15557, 0.79166666666667, 1.6, 0
15558, 0.77083333333333, 1.66, 0
15559, 0.79166666666667, 1.64, 0
15560, 0.79166666666667, 1.68, 0
15561, 0.8125, 1.54, 0
15562, 0.83333333333333, 1.52, 0
15563, 0.8125, 1.58, 0
15564, 0.83333333333333, 1.56, 0
15565, 0.8125, 1.62, 0
15566, 0.83333333333333, 1.6, 0
15567, 0.8125, 1.66, 0
15568, 0.83333333333333, 1.64, 0
15569, 0.83333333333333, 1.68, 0
15570, 0.85416666666667, 1.54, 0
15571, 0.875, 1.52, 0
15572, 0.85416666666667, 1.58, 0
15573, 0.875, 1.56, 0
15574, 0.85416666666667, 1.62, 0
15575, 0.875, 1.6, 0
15576, 0.85416666666667, 1.66, 0
15577, 0.875, 1.64, 0
15578, 0.875, 1.68, 0
15579, 0.89583333333333, 1.54, 0
15580, 0.91666666666667, 1.52, 0
15581, 0.89583333333333, 1.58, 0
15582, 0.91666666666667, 1.56, 0
15583, 0.89583333333333, 1.62, 0
15584, 0.91666666666667, 1.6, 0
15585, 0.89583333333333, 1.66, 0
15586, 0.91666666666667, 1.64, 0
15587, 0.91666666666667, 1.68, 0
15588, 0.9375, 1.54, 0
15589, 0.95833333333333, 1.52, 0
15590, 0.9375, 1.58, 0
15591, 0.95833333333333, 1.56, 0
15592, 0.9375, 1.62, 0
15593, 0.95833333333333, 1.6, 0
15594, 0.9375, 1.66, 0
15595, 0.95833333333333, 1.64, 0
15596, 0.95833333333333, 1.68, 0
15597, 0.97916666666667, 1.54, 0
15598, 0.97916666666667, 1.58, 0
15599, 0.97916666666667, 1.62, 0
15600, 0.97916666666667, 1.66, 0
15601, 1, 1.54, 0.041666666666667
15602, 1, 1.58, 0.041666666666667
15603, 1, 1.62, 0.041666666666667
15604, 1, 1.66, 0.041666666666667
15605, 1, 1.54, 0.083333333333333
15606, 1, 1.58, 0.083333333333333
15607, 1, 1.62, 0.083333333333333
15608, 1, 1.66, 0.083333333333333
15609, 1, 1.54, 0.125
15610, 1, 1.58, 0.125
15611, 1, 1.62, 0.125
15612, 1, 1.66, 0.125
15613, 1, 1.54, 0.16666666666667
15614, 1, 1.58, 0.16666666666667
15615, 1, 1.62, 0.16666666666667
15616, 1, 1.66, 0.16666666666667
15617, 1, 1.54, 0.20833333333333
15618, 1, 1.58, 0.20833333333333
15619, 1, 1.62, 0.20833333333333
15620, 1, 1.66, 0.20833333333333
15621, 1, 1.54, 0.25
15622, 1, 1.58, 0.25
15623, 1, 1.62, 0.25
15624, 1, 1.66, 0.25
15625, 1, 1.54, 0.29166666666667
15626, 1, 1.58, 0.29166666666667
15627, 1, 1.62, 0.29166666666667
15628, 1, 1.66, 0.29166666666667
15629, 1, 1.54, 0.33333333333333
15630, 1, 1.58, 0.33333333333333
15631, 1, 1.62, 0.33333333333333
15632, 1, 1.66, 0.33333333333333
15633, 1, 1.54, 0.375
15634, 1, 1.58, 0.375
15635, 1, 1.62, 0.375
15636, 1, 1.66, 0.375
15637, 1, 1.54, 0.41666666666667
15638, 1, 1.58, 0.41666666666667
15639, 1, 1.62, 0.41666666666667
15640, 1, 1.66, 0.41666666666667
15641, 1, 1.54, 0.45833333333333
15642, 1, 1.58, 0.45833333333333
15643, 1, 1.62, 0.45833333333333
15644, 1, 1.66, 0.45833333333333
15645, 1, 1.54, 0.020833333333333
15646, 1, 1.52, 0.041666666666667
15647, 1, 1.58, 0.020833333333333
15648, 1, 1.56, 0.041666666666667
15649, 1, 1.62, 0.020833333333333
15650, 1, 1.6, 0.041666666666667
15651, 1, 1.66, 0.020833333333333
15652, 1, 1.64, 0.041666666666667
15653, 1, 1.68, 0.041666666666667
15654, 1, 1.54, 0.0625
15655, 1, 1.52, 0.083333333333333
15656, 1, 1.58, 0.0625
15657, 1, 1.56, 0.083333333333333
15658, 1, 1.62, 0.0625
15659, 1, 1.6, 0.083333333333333
15660, 1, 1.66, 0.0625
15661, 1, 1.64, 0.083333333333333
15662, 1, 1.68, 0.083333333333333
15663, 1, 1.54, 0.10416666666667
15664, 1, 1.52, 0.125
15665, 1, 1.58, 0.10416666666667
15666, 1, 1.56, 0.125
15667, 1, 1.62, 0.10416666666667
15668, 1, 1.6, 0.125
15669, 1, 1.66, 0.10416666666667
15670, 1, 1.64, 0.125
15671, 1, 1.68, 0.125
15672, 1, 1.54, 0.14583333333333
15673, 1, 1.52, 0.16666666666667
15674, 1, 1.58, 0.14583333333333
15675, 1, 1.56, 0.16666666666667
15676, 1, 1.62, 0.14583333333333
15677, 1, 1.6, 0.16666666666667
15678, 1, 1.66, 0.14583333333333
15679, 1, 1.64, 0.16666666666667
15680, 1, 1.68, 0.16666666666667
15681, 1, 1.54, 0.1875
15682, 1, 1.52, 0.20833333333333
15683, 1, 1.58, 0.1875
15684, 1, 1.56, 0.20833333333333
15685, 1, 1.62, 0.1875
15686, 1, 1.6, 0.20833333333333
15687, 1, 1.66, 0.1875
15688, 1, 1.64, 0.20833333333333
15689, 1, 1.68, 0.20833333333333
15690, 1, 1.54, 0.22916666666667
15691, 1, 1.52, 0.25
15692, 1, 1.58, 0.22916666666667
15693, 1, 1.56, 0.25
15694, 1, 1.62, 0.22916666666667
15695, 1, 1.6, 0.25
15696, 1, 1.66, 0.22916666666667
15697, 1, 1.64, 0.25
15698, 1, 1.68, 0.25
15699, 1, 1.54, 0.27083333333333
15700, 1, 1.52, 0.29166666666667
15701, 1, 1.58, 0.27083333333333
15702, 1, 1.56, 0.29166666666667
15703, 1, 1.62, 0.27083333333333
15704, 1, 1.6, 0.29166666666667
15705, 1, 1.66, 0.27083333333333
15706, 1, 1.64, 0.29166666666667
15707, 1, 1.68, 0.29166666666667
15708, 1, 1.54, 0.3125
15709, 1, 1.52, 0.33333333333333
15710, 1, 1.58, 0.3125
15711, 1, 1.56, 0.33333333333333
15712, 1, 1.62, 0.3125
15713, 1, 1.6, 0.33333333333333
15714, 1, 1.66, 0.3125
15715, 1, 1.64, 0.33333333333333
15716, 1, 1.68, 0.33333333333333
15717, 1, 1.54, 0.35416666666667
15718, 1, 1.52, 0.375
15719, 1, 1.58, 0.35416666666667
15720, 1, 1.56, 0.375
15721, 1, 1.62, 0.35416666666667
15722, 1, 1.6, 0.375
15723, 1, 1.66, 0.35416666666667
15724, 1, 1.64, 0.375
15725, 1, 1.68, 0.375
15726, 1, 1.54, 0.39583333333333
15727, 1, 1.52, 0.41666666666667
15728, 1, 1.58, 0.39583333333333
15729, 1, 1.56, 0.41666666666667
15730, 1, 1.62, 0.39583333333333
15731, 1, 1.6, 0.41666666666667
15732, 1, 1.66, 0.39583333333333
15733, 1, 1.64, 0.41666666666667
15734, 1, 1.68, 0.41666666666667
15735, 1, 1.54, 0.4375
15736, 1, 1.52, 0.45833333333333
15737, 1, 1.58, 0.4375
15738, 1, 1.56, 0.45833333333333
15739, 1, 1.62, 0.4375
15740, 1, 1.6, 0.45833333333333
15741, 1, 1.66, 0.4375
15742, 1, 1.64, 0.45833333333333
15743, 1, 1.68, 0.45833333333333
15744, 1, 1.54, 0.47916666666667
15745, 1, 1.58, 0.47916666666667
15746, 1, 1.62, 0.47916666666667
15747, 1, 1.66, 0.47916666666667
15748, 0.041666666666667, 1.54, 0.5
15749, 0.041666666666667, 1.58, 0.5
15750, 0.041666666666667, 1.62, 0.5
15751, 0.041666666666667, 1.66, 0.5
15752, 0.083333333333333, 1.54, 0.5
15753, 0.083333333333333, 1.58, 0.5
15754, 0.083333333333333, 1.62, 0.5
15755, 0.083333333333333, 1.66, 0.5
15756, 0.125, 1.54, 0.5
15757, 0.125, 1.58, 0.5
15758, 0.125, 1.62, 0.5
15759, 0.125, 1.66, 0.5
15760, 0.16666666666667, 1.54, 0.5
15761, 0.16666666666667, 1.58, 0.5
15762, 0.16666666666667, 1.62, 0.5
15763, 0.16666666666667, 1.66, 0.5
15764, 0.20833333333333, 1.54, 0.5
15765, 0.20833333333333, 1.58, 0.5
15766, 0.20833333333333, 1.62, 0.5
15767, 0.20833333333333, 1.66, 0.5
15768, 0.25, 1.54, 0.5
15769, 0.25, 1.58, 0.5
15770, 0.25, 1.62, 0.5
15771, 0.25, 1.66, 0.5
15772, 0.29166666666667, 1.54, 0.5
15773, 0.29166666666667, 1.58, 0.5
15774, 0.29166666666667, 1.62, 0.5
15775, 0.29166666666667, 1.66, 0.5
15776, 0.33333333333333, 1.54, 0.5
15777, 0.33333333333333, 1.58, 0.5
15778, 0.33333333333333, 1.62, 0.5
15779, 0.33333333333333, 1.66, 0.5
15780, 0.375, 1.54, 0.5
15781, 0.375, 1.58, 0.5
15782, 0.375, 1.62, 0.5
15783, 0.375, 1.66, 0.5
15784, 0.41666666666667, 1.54, 0.5
15785, 0.41666666666667, 1.58, 0.5
15786, 0.41666666666667, 1.62, 0.5
15787, 0.41666666666667, 1.66, 0.5
15788, 0.45833333333333, 1.54, 0.5
15789, 0.45833333333333, 1.58, 0.5
15790, 0.45833333333333, 1.62, 0.5
15791, 0.45833333333333, 1.66, 0.5
15792, 0.5, 1.54, 0.5
15793, 0.5, 1.58, 0.5
15794, 0.5, 1.62, 0.5
15795, 0.5, 1.66, 0.5
15796, 0.54166666666667, 1.54, 0.5
15797, 0.54166666666667, 1.58, 0.5
15798, 0.54166666666667, 1.62, 0.5
15799, 0.54166666666667, 1.66, 0.5
15800, 0.58333333333333, 1.54, 0.5
15801, 0.58333333333333, 1.58, 0.5
15802, 0.58333333333333, 1.62, 0.5
15803, 0.58333333333333, 1.66, 0.5
15804, 0.625, 1.54, 0.5
15805, 0.625, 1.58, 0.5
15806, 0.625, 1.62, 0.5
15807, 0.625, 1.66, 0.5
15808, 0.66666666666667, 1.54, 0.5
15809, 0.66666666666667, 1.58, 0.5
15810, 0.66666666666667, 1.62, 0.5
15811, 0.66666666666667, 1.66, 0.5
15812, 0.70833333333333, 1.54, 0.5
15813, 0.70833333333333, 1.58, 0.5
15814, 0.70833333333333, 1.62, 0.5
15815, 0.70833333333333, 1.66, 0.5
15816, 0.75, 1.54, 0.5
15817, 0.75, 1.58, 0.5
15818, 0.75, 1.62, 0.5
15819, 0.75, 1.66, 0.5
15820, 0.79166666666667, 1.54, 0.5
15821, 0.79166666666667, 1.58, 0.5
15822, 0.79166666666667, 1.62, 0.5
15823, 0.79166666666667, 1.66, 0.5
15824, 0.83333333333333, 1.54, 0.5
15825, 0.83333333333333, 1.58, 0.5
15826, 0.83333333333333, 1.62, 0.5
15827, 0.83333333333333, 1.66, 0.5
15828, 0.875, 1.54, 0.5
15829, 0.875, 1.58, 0.5
15830, 0.875, 1.62, 0.5
15831, 0.875, 1.66, 0.5
15832, 0.91666666666667, 1.54, 0.5
15833, 0.91666666666667, 1.58, 0.5
15834, 0.91666666666667, 1.62, 0.5
15835, 0.91666666666667, 1.66, 0.5
15836, 0.95833333333333, 1.54, 0.5
15837, 0.95833333333333, 1.58, 0.5
15838, 0.95833333333333, 1.62, 0.5
15839, 0.95833333333333, 1.66, 0.5
15840, 0, 1.54, 0.041666666666667
15841, 0, 1.58, 0.041666666666667
15842, 0, 1.62, 0.041666666666667
15843, 0, 1.66, 0.041666666666667
15844, 0, 1.54, 0.083333333333333
15845, 0, 1.58, 0.083333333333333
15846, 0, 1.62, 0.083333333333333
15847, 0, 1.66, 0.083333333333333
15848, 0, 1.54, 0.125
15849, 0, 1.58, 0.125
15850, 0, 1.62, 0.125
15851, 0, 1.66, 0.125
15852, 0, 1.54, 0.16666666666667
15853, 0, 1.58, 0.16666666666667
15854, 0, 1.62, 0.16666666666667
15855, 0, 1.66, 0.16666666666667
15856, 0, 1.54, 0.20833333333333
15857, 0, 1.58, 0.20833333333333
15858, 0, 1.62, 0.20833333333333
15859, 0, 1.66, 0.20833333333333
15860, 0, 1.54, 0.25
15861, 0, 1.58, 0.25
15862, 0, 1.62, 0.25
15863, 0, 1.66, 0.25
15864, 0, 1.54, 0.29166666666667
15865, 0, 1.58, 0.29166666666667
15866, 0, 1.62, 0.29166666666667
15867, 0, 1.66, 0.29166666666667
15868, 0, 1.54, 0.33333333333333
15869, 0, 1.58, 0.33333333333333
15870, 0, 1.62, 0.33333333333333
15871, 0, 1.66, 0.33333333333333
15872, 0, 1.54, 0.375
15873, 0, 1.58, 0.375
15874, 0, 1.62, 0.375
15875, 0, 1.66, 0.375
15876, 0, 1.54, 0.41666666666667
15877, 0, 1.58, 0.41666666666667
15878, 0, 1.62, 0.41666666666667
15879, 0, 1.66, 0.41666666666667
15880, 0, 1.54, 0.45833333333333
15881, 0, 1.58, 0.45833333333333
15882, 0, 1.62, 0.45833333333333
15883, 0, 1.66, 0.45833333333333
15884, 0, 1.52, 0.041666666666667
15885, 0, 1.54, 0.020833333333333
15886, 0, 1.56, 0.041666666666667
15887, 0, 1.58, 0.020833333333333
15888, 0, 1.6, 0.041666666666667
15889, 0, 1.62, 0.020833333333333
15890, 0, 1.64, 0.041666666666667
15891, 0, 1.66, 0.020833333333333
15892, 0, 1.68, 0.041666666666667
15893, 0, 1.52, 0.083333333333333
15894, 0, 1.54, 0.0625
15895, 0, 1.56, 0.083333333333333
15896, 0, 1.58, 0.0625
15897, 0, 1.6, 0.083333333333333
15898, 0, 1.62, 0.0625
15899, 0, 1.64, 0.083333333333333
15900, 0, 1.66, 0.0625
15901, 0, 1.68, 0.083333333333333
15902, 0, 1.52, 0.125
15903, 0, 1.54, 0.10416666666667
15904, 0, 1.56, 0.125
15905, 0, 1.58, 0.10416666666667
15906, 0, 1.6, 0.125
15907, 0, 1.62, 0.10416666666667
15908, 0, 1.64, 0.125
15909, 0, 1.66, 0.10416666666667
15910, 0, 1.68, 0.125
15911, 0, 1.52, 0.16666666666667
15912, 0, 1.54, 0.14583333333333
15913, 0, 1.56, 0.16666666666667
15914, 0, 1.58, 0.14583333333333
15915, 0, 1.6, 0.16666666666667
15916, 0, 1.62, 0.14583333333333
15917, 0, 1.64, 0.16666666666667
15918, 0, 1.66, 0.14583333333333
15919, 0, 1.68, 0.16666666666667
15920, 0, 1.52, 0.20833333333333
15921, 0, 1.54, 0.1875
15922, 0, 1.56, 0.20833333333333
15923, 0, 1.58, 0.1875
15924, 0, 1.6, 0.20833333333333
15925, 0, 1.62, 0.1875
15926, 0, 1.64, 0.20833333333333
15927, 0, 1.66, 0.1875
15928, 0, 1.68, 0.20833333333333
15929, 0, 1.52, 0.25
15930, 0, 1.54, 0.22916666666667
15931, 0, 1.56, 0.25
15932, 0, 1.58, 0.22916666666667
15933, 0, 1.6, 0.25
15934, 0, 1.62, 0.22916666666667
15935, 0, 1.64, 0.25
15936, 0, 1.66, 0.22916666666667
15937, 0, 1.68, 0.25
15938, 0, 1.52, 0.29166666666667
15939, 0, 1.54, 0.27083333333333
15940, 0, 1.56, 0.29166666666667
15941, 0, 1.58, 0.27083333333333
15942, 0, 1.6, 0.29166666666667
15943, 0, 1.62, 0.27083333333333
15944, 0, 1.64, 0.29166666666667
15945, 0, 1.66, 0.27083333333333
15946, 0, 1.68, 0.29166666666667
15947, 0, 1.52, 0.33333333333333
15948, 0, 1.54, 0.3125
15949, 0, 1.56, 0.33333333333333
15950, 0, 1.58, 0.3125
15951, 0, 1.6, 0.33333333333333
15952, 0, 1.62, 0.3125
15953, 0, 1.64, 0.33333333333333
15954, 0, 1.66, 0.3125
15955, 0, 1.68, 0.33333333333333
15956, 0, 1.52, 0.375
15957, 0, 1.54, 0.35416666666667
15958, 0, 1.56, 0.375
15959, 0, 1.58, 0.35416666666667
15960, 0, 1.6, 0.375
15961, 0, 1.62, 0.35416666666667
15962, 0, 1.64, 0.375
15963, 0, 1.66, 0.35416666666667
15964, 0, 1.68, 0.375
15965, 0, 1.52, 0.41666666666667
15966, 0, 1.54, 0.39583333333333
15967, 0, 1.56, 0.41666666666667
15968, 0, 1.58, 0.39583333333333
15969, 0, 1.6, 0.41666666666667
15970, 0, 1.62, 0.39583333333333
15971, 0, 1.64, 0.41666666666667
15972, 0, 1.66, 0.39583333333333
15973, 0, 1.68, 0.41666666666667
15974, 0, 1.52, 0.45833333333333
15975, 0, 1.54, 0.4375
15976, 0, 1.56, 0.45833333333333
15977, 0, 1.58, 0.4375
15978, 0, 1.6, 0.45833333333333
15979, 0, 1.62, 0.4375
15980, 0, 1.64, 0.45833333333333
15981, 0, 1.66, 0.4375
15982, 0, 1.68, 0.45833333333333
15983, 0, 1.54, 0.47916666666667
15984, 0, 1.58, 0.47916666666667
15985, 0, 1.62, 0.47916666666667
15986, 0, 1.66, 0.47916666666667
15987, 0.041666666666667, 1.7, 0.041666666666667
15988, 0.041666666666667, 1.7, 0.083333333333333
15989, 0.041666666666667, 1.7, 0.125
15990, 0.041666666666667, 1.7, 0.16666666666667
15991, 0.041666666666667, 1.7, 0.20833333333333
15992, 0.041666666666667, 1.7, 0.25
15993, 0.041666666666667, 1.7, 0.29166666666667
15994, 0.041666666666667, 1.7, 0.33333333333333
15995, 0.041666666666667, 1.7, 0.375
15996, 0.041666666666667, 1.7, 0.41666666666667
15997, 0.041666666666667, 1.7, 0.45833333333333
15998, 0.083333333333333, 1.7, 0.041666666666667
15999, 0.083333333333333, 1.7, 0.083333333333333
16000, 0.083333333333333, 1.7, 0.125
16001, 0.083333333333333, 1.7, 0.16666666666667
16002, 0.083333333333333, 1.7, 0.20833333333333
16003, 0.083333333333333, 1.7, 0.25
16004, 0.083333333333333, 1.7, 0.29166666666667
16005, 0.083333333333333, 1.7, 0.33333333333333
16006, 0.083333333333333, 1.7, 0.375
16007, 0.083333333333333, 1.7, 0.41666666666667
16008, 0.083333333333333, 1.7, 0.45833333333333
16009, 0.125, 1.7, 0.041666666666667
16010, 0.125, 1.7, 0.083333333333333
16011, 0.125, 1.7, 0.125
16012, 0.125, 1.7, 0.16666666666667
16013, 0.125, 1.7, 0.20833333333333
16014, 0.125, 1.7, 0.25
16015, 0.125, 1.7, 0.29166666666667
16016, 0.125, 1.7, 0.33333333333333
16017, 0.125, 1.7, 0.375
16018, 0.125, 1.7, 0.41666666666667
16019, 0.125, 1.7, 0.45833333333333
16020, 0.16666666666667, 1.7, 0.041666666666667
16021, 0.16666666666667, 1.7, 0.083333333333333
16022, 0.16666666666667, 1.7, 0.125
16023, 0.16666666666667, 1.7, 0.16666666666667
16024, 0.16666666666667, 1.7, 0.20833333333333
16025, 0.16666666666667, 1.7, 0.25
16026, 0.16666666666667, 1.7, 0.29166666666667
16027, 0.16666666666667, 1.7, 0.33333333333333
16028, 0.16666666666667, 1.7, 0.375
16029, 0.16666666666667, 1.7, 0.41666666666667
16030, 0.16666666666667, 1.7, 0.45833333333333
16031, 0.20833333333333, 1.7, 0.041666666666667
16032, 0.20833333333333, 1.7, 0.083333333333333
16033, 0.20833333333333, 1.7, 0.125
16034, 0.20833333333333, 1.7, 0.16666666666667
16035, 0.20833333333333, 1.7, 0.20833333333333
16036, 0.20833333333333, 1.7, 0.25
16037, 0.20833333333333, 1.7, 0.29166666666667
16038, 0.20833333333333, 1.7, 0.33333333333333
16039, 0.20833333333333, 1.7, 0.375
16040, 0.20833333333333, 1.7, 0.41666666666667
16041, 0.20833333333333, 1.7, 0.45833333333333
16042, 0.25, 1.7, 0.041666666666667
16043, 0.25, 1.7, 0.083333333333333
16044, 0.25, 1.7, 0.125
16045, 0.25, 1.7, 0.16666666666667
16046, 0.25, 1.7, 0.20833333333333
16047, 0.25, 1.7, 0.25
16048, 0.25, 1.7, 0.29166666666667
16049, 0.25, 1.7, 0.33333333333333
16050, 0.25, 1.7, 0.375
16051, 0.25, 1.7, 0.41666666666667
16052, 0.25, 1.7, 0.45833333333333
16053, 0.29166666666667, 1.7, 0.041666666666667
16054, 0.29166666666667, 1.7, 0.083333333333333
16055, 0.29166666666667, 1.7, 0.125
16056, 0.29166666666667, 1.7, 0.16666666666667
16057, 0.29166666666667, 1.7, 0.20833333333333
16058, 0.29166666666667, 1.7, 0.25
16059, 0.29166666666667, 1.7, 0.29166666666667
16060, 0.29166666666667, 1.7, 0.33333333333333
16061, 0.29166666666667, 1.7, 0.375
16062, 0.29166666666667, 1.7, 0.41666666666667
16063, 0.29166666666667, 1.7, 0.45833333333333
16064, 0.33333333333333, 1.7, 0.041666666666667
16065, 0.33333333333333, 1.7, 0.083333333333333
16066, 0.33333333333333, 1.7, 0.125
16067, 0.33333333333333, 1.7, 0.16666666666667
16068, 0.33333333333333, 1.7, 0.20833333333333
16069, 0.33333333333333, 1.7, 0.25
16070, 0.33333333333333, 1.7, 0.29166666666667
16071, 0.33333333333333, 1.7, 0.33333333333333
16072, 0.33333333333333, 1.7, 0.375
16073, 0.33333333333333, 1.7, 0.41666666666667
16074, 0.33333333333333, 1.7, 0.45833333333333
16075, 0.375, 1.7, 0.041666666666667
16076, 0.375, 1.7, 0.083333333333333
16077, 0.375, 1.7, 0.125
16078, 0.375, 1.7, 0.16666666666667
16079, 0.375, 1.7, 0.20833333333333
16080, 0.375, 1.7, 0.25
16081, 0.375, 1.7, 0.29166666666667
16082, 0.375, 1.7, 0.33333333333333
16083, 0.375, 1.7, 0.375
16084, 0.375, 1.7, 0.41666666666667
16085, 0.375, 1.7, 0.45833333333333
16086, 0.41666666666667, 1.7, 0.041666666666667
16087, 0.41666666666667, 1.7, 0.083333333333333
16088, 0.41666666666667, 1.7, 0.125
16089, 0.41666666666667, 1.7, 0.16666666666667
16090, 0.41666666666667, 1.7, 0.20833333333333
16091, 0.41666666666667, 1.7, 0.25
16092, 0.41666666666667, 1.7, 0.29166666666667
16093, 0.41666666666667, 1.7, 0.33333333333333
16094, 0.41666666666667, 1.7, 0.375
16095, 0.41666666666667, 1.7, 0.41666666666667
16096, 0.41666666666667, 1.7, 0.45833333333333
16097, 0.45833333333333, 1.7, 0.041666666666667
16098, 0.45833333333333, 1.7, 0.083333333333333
16099, 0.45833333333333, 1.7, 0.125
16100, 0.45833333333333, 1.7, 0.16666666666667
16101, 0.45833333333333, 1.7, 0.20833333333333
16102, 0.45833333333333, 1.7, 0.25
16103, 0.45833333333333, 1.7, 0.29166666666667
16104, 0.45833333333333, 1.7, 0.33333333333333
16105, 0.45833333333333, 1.7, 0.375
16106, 0.45833333333333, 1.7, 0.41666666666667
16107, 0.45833333333333, 1.7, 0.45833333333333
16108, 0.5, 1.7, 0.041666666666667
16109, 0.5, 1.7, 0.083333333333333
16110, 0.5, 1.7, 0.125
16111, 0.5, 1.7, 0.16666666666667
16112, 0.5, 1.7, 0.20833333333333
16113, 0.5, 1.7, 0.25
16114, 0.5, 1.7, 0.29166666666667
16115, 0.5, 1.7, 0.33333333333333
16116, 0.5, 1.7, 0.375
16117, 0.5, 1.7, 0.41666666666667
16118, 0.5, 1.7, 0.45833333333333
16119, 0.54166666666667, 1.7, 0.041666666666667
16120, 0.54166666666667, 1.7, 0.083333333333333
16121, 0.54166666666667, 1.7, 0.125
16122, 0.54166666666667, 1.7, 0.16666666666667
16123, 0.54166666666667, 1.7, 0.20833333333333
16124, 0.54166666666667, 1.7, 0.25
16125, 0.54166666666667, 1.7, 0.29166666666667
16126, 0.54166666666667, 1.7, 0.33333333333333
16127, 0.54166666666667, 1.7, 0.375
16128, 0.54166666666667, 1.7, 0.41666666666667
16129, 0.54166666666667, 1.7, 0.45833333333333
16130, 0.58333333333333, 1.7, 0.041666666666667
16131, 0.58333333333333, 1.7, 0.083333333333333
16132, 0.58333333333333, 1.7, 0.125
16133, 0.58333333333333, 1.7, 0.16666666666667
16134, 0.58333333333333, 1.7, 0.20833333333333
16135, 0.58333333333333, 1.7, 0.25
16136, 0.58333333333333, 1.7, 0.29166666666667
16137, 0.58333333333333, 1.7, 0.33333333333333
16138, 0.58333333333333, 1.7, 0.375
16139, 0.58333333333333, 1.7, 0.41666666666667
16140, 0.58333333333333, 1.7, 0.45833333333333
16141, 0.625, 1.7, 0.041666666666667
16142, 0.625, 1.7, 0.083333333333333
16143, 0.625, 1.7, 0.125
16144, 0.625, 1.7, 0.16666666666667
16145, 0.625, 1.7, 0.20833333333333
16146, 0.625, 1.7, 0.25
16147, 0.625, 1.7, 0.29166666666667
16148, 0.625, 1.7, 0.33333333333333
16149, 0.625, 1.7, 0.375
16150, 0.625, 1.7, 0.41666666666667
16151, 0.625, 1.7, 0.45833333333333
16152, 0.66666666666667, 1.7, 0.041666666666667
16153, 0.66666666666667, 1.7, 0.083333333333333
16154, 0.66666666666667, 1.7, 0.125
16155, 0.66666666666667, 1.7, 0.16666666666667
16156, 0.66666666666667, 1.7, 0.20833333333333
16157, 0.66666666666667, 1.7, 0.25
16158, 0.66666666666667, 1.7, 0.29166666666667
16159, 0.66666666666667, 1.7, 0.33333333333333
16160, 0.66666666666667, 1.7, 0.375
16161, 0.66666666666667, 1.7, 0.41666666666667
16162, 0.66666666666667, 1.7, 0.45833333333333
16163, 0.70833333333333, 1.7, 0.041666666666667
16164, 0.70833333333333, 1.7, 0.083333333333333
16165, 0.70833333333333, 1.7, 0.125
16166, 0.70833333333333, 1.7, 0.16666666666667
16167, 0.70833333333333, 1.7, 0.20833333333333
16168, 0.70833333333333, 1.7, 0.25
16169, 0.70833333333333, 1.7, 0.29166666666667
16170, 0.70833333333333, 1.7, 0.33333333333333
16171, 0.70833333333333, 1.7, 0.375
16172, 0.70833333333333, 1.7, 0.41666666666667
16173, 0.70833333333333, 1.7, 0.45833333333333
16174, 0.75, 1.7, 0.041666666666667
16175, 0.75, 1.7, 0.083333333333333
16176, 0.75, 1.7, 0.125
16177, 0.75, 1.7, 0.16666666666667
16178, 0.75, 1.7, 0.20833333333333
16179, 0.75, 1.7, 0.25
16180, 0.75, 1.7, 0.29166666666667
16181, 0.75, 1.7, 0.33333333333333
16182, 0.75, 1.7, 0.375
16183, 0.75, 1.7, 0.41666666666667
16184, 0.75, 1.7, 0.45833333333333
16185, 0.79166666666667, 1.7, 0.041666666666667
16186, 0.79166666666667, 1.7, 0.083333333333333
16187, 0.79166666666667, 1.7, 0.125
16188, 0.79166666666667, 1.7, 0.16666666666667
16189, 0.79166666666667, 1.7, 0.20833333333333
16190, 0.79166666666667, 1.7, 0.25
16191, 0.79166666666667, 1.7, 0.29166666666667
16192, 0.79166666666667, 1.7, 0.33333333333333
16193, 0.79166666666667, 1.7, 0.375
16194, 0.79166666666667, 1.7, 0.41666666666667
16195, 0.79166666666667, 1.7, 0.45833333333333
16196, 0.83333333333333, 1.7, 0.041666666666667
16197, 0.83333333333333, 1.7, 0.083333333333333
16198, 0.83333333333333, 1.7, 0.125
16199, 0.83333333333333, 1.7, 0.16666666666667
16200, 0.83333333333333, 1.7, 0.20833333333333
16201, 0.83333333333333, 1.7, 0.25
16202, 0.83333333333333, 1.7, 0.29166666666667
16203, 0.83333333333333, 1.7, 0.33333333333333
16204, 0.83333333333333, 1.7, 0.375
16205, 0.83333333333333, 1.7, 0.41666666666667
16206, 0.83333333333333, 1.7, 0.45833333333333
16207, 0.875, 1.7, 0.041666666666667
16208, 0.875, 1.7, 0.083333333333333
16209, 0.875, 1.7, 0.125
16210, 0.875, 1.7, 0.16666666666667
16211, 0.875, 1.7, 0.20833333333333
16212, 0.875, 1.7, 0.25
16213, 0.875, 1.7, 0.29166666666667
16214, 0.875, 1.7, 0.33333333333333
16215, 0.875, 1.7, 0.375
16216, 0.875, 1.7, 0.41666666666667
16217, 0.875, 1.7, 0.45833333333333
16218, 0.91666666666667, 1.7, 0.041666666666667
16219, 0.91666666666667, 1.7, 0.083333333333333
16220, 0.91666666666667, 1.7, 0.125
16221, 0.91666666666667, 1.7, 0.16666666666667
16222, 0.91666666666667, 1.7, 0.20833333333333
16223, 0.91666666666667, 1.7, 0.25
16224, 0.91666666666667, 1.7, 0.29166666666667
16225, 0.91666666666667, 1.7, 0.33333333333333
16226, 0.91666666666667, 1.7, 0.375
16227, 0.91666666666667, 1.7, 0.41666666666667
16228, 0.91666666666667, 1.7, 0.45833333333333
16229, 0.95833333333333, 1.7, 0.041666666666667
16230, 0.95833333333333, 1.7, 0.083333333333333
16231, 0.95833333333333, 1.7, 0.125
16232, 0.95833333333333, 1.7, 0.16666666666667
16233, 0.95833333333333, 1.7, 0.20833333333333
16234, 0.95833333333333, 1.7, 0.25
16235, 0.95833333333333, 1.7, 0.29166666666667
16236, 0.95833333333333, 1.7, 0.33333333333333
16237, 0.95833333333333, 1.7, 0.375
16238, 0.95833333333333, 1.7, 0.41666666666667
16239, 0.95833333333333, 1.7, 0.45833333333333
16240, 1.04, 1.54, 0.5
16241, 1.04, 1.58, 0.5
16242, 1.04, 1.62, 0.5
16243, 1.04, 1.66, 0.5
16244, 1.08, 1.54, 0.5
16245, 1.08, 1.58, 0.5
16246, 1.08, 1.62, 0.5
16247, 1.08, 1.66, 0.5
16248, 1.12, 1.54, 0.5
16249, 1.12, 1.58, 0.5
16250, 1.12, 1.62, 0.5
16251, 1.12, 1.66, 0.5
16252, 1.16, 1.54, 0.5
16253, 1.16, 1.58, 0.5
16254, 1.16, 1.62, 0.5
16255, 1.16, 1.66, 0.5
16256, 1.04, 1.54, 0
16257, 1.04, 1.58, 0
16258, 1.04, 1.62, 0
16259, 1.04, 1.66, 0
16260, 1.08, 1.54, 0
16261, 1.08, 1.58, 0
16262, 1.08, 1.62, 0
16263, 1.08, 1.66, 0
16264, 1.12, 1.54, 0
16265, 1.12, 1.58, 0
16266, 1.12, 1.62, 0
16267, 1.12, 1.66, 0
16268, 1.16, 1.54, 0
16269, 1.16, 1.58, 0
16270, 1.16, 1.62, 0
16271, 1.16, 1.66, 0
16272, 1.02, 1.54, 0
16273, 1.04, 1.52, 0
16274, 1.02, 1.58, 0
16275, 1.04, 1.56, 0
16276, 1.02, 1.62, 0
16277, 1.04, 1.6, 0
16278, 1.02, 1.66, 0
16279, 1.04, 1.64, 0
16280, 1.04, 1.68, 0
16281, 1.06, 1.54, 0
16282, 1.08, 1.52, 0
16283, 1.06, 1.58, 0
16284, 1.08, 1.56, 0
16285, 1.06, 1.62, 0
16286, 1.08, 1.6, 0
16287, 1.06, 1.66, 0
16288, 1.08, 1.64, 0
16289, 1.08, 1.68, 0
16290, 1.1, 1.54, 0
16291, 1.12, 1.52, 0
16292, 1.1, 1.58, 0
16293, 1.12, 1.56, 0
16294, 1.1, 1.62, 0
16295, 1.12, 1.6, 0
16296, 1.1, 1.66, 0
16297, 1.12, 1.64, 0
16298, 1.12, 1.68, 0
16299, 1.14, 1.54, 0
16300, 1.16, 1.52, 0
16301, 1.14, 1.58, 0
16302, 1.16, 1.56, 0
16303, 1.14, 1.62, 0
16304, 1.16, 1.6, 0
16305, 1.14, 1.66, 0
16306, 1.16, 1.64, 0
16307, 1.16, 1.68, 0
16308, 1.18, 1.54, 0
16309, 1.18, 1.58, 0
16310, 1.18, 1.62, 0
16311, 1.18, 1.66, 0
16312, 1.2, 1.54, 0.041666666666667
16313, 1.2, 1.58, 0.041666666666667
16314, 1.2, 1.62, 0.041666666666667
16315, 1.2, 1.66, 0.041666666666667
16316, 1.2, 1.54, 0.083333333333333
16317, 1.2, 1.58, 0.083333333333333
16318, 1.2, 1.62, 0.083333333333333
16319, 1.2, 1.66, 0.083333333333333
16320, 1.2, 1.54, 0.125
16321, 1.2, 1.58, 0.125
16322, 1.2, 1.62, 0.125
16323, 1.2, 1.66, 0.125
16324, 1.2, 1.54, 0.16666666666667
16325, 1.2, 1.58, 0.16666666666667
16326, 1.2, 1.62, 0.16666666666667
16327, 1.2, 1.66, 0.16666666666667
16328, 1.2, 1.54, 0.20833333333333
16329, 1.2, 1.58, 0.20833333333333
16330, 1.2, 1.62, 0.20833333333333
16331, 1.2, 1.66, 0.20833333333333
16332, 1.2, 1.54, 0.25
16333, 1.2, 1.58, 0.25
16334, 1.2, 1.62, 0.25
16335, 1.2, 1.66, 0.25
16336, 1.2, 1.54, 0.29166666666667
16337, 1.2, 1.58, 0.29166666666667
16338, 1.2, 1.62, 0.29166666666667
16339, 1.2, 1.66, 0.29166666666667
16340, 1.2, 1.54, 0.33333333333333
16341, 1.2, 1.58, 0.33333333333333
16342, 1.2, 1.62, 0.33333333333333
16343, 1.2, 1.66, 0.33333333333333
16344, 1.2, 1.54, 0.375
16345, 1.2, 1.58, 0.375
16346, 1.2, 1.62, 0.375
16347, 1.2, 1.66, 0.375
16348, 1.2, 1.54, 0.41666666666667
16349, 1.2, 1.58, 0.41666666666667
16350, 1.2, 1.62, 0.41666666666667
16351, 1.2, 1.66, 0.41666666666667
16352, 1.2, 1.54, 0.45833333333333
16353, 1.2, 1.58, 0.45833333333333
16354, 1.2, 1.62, 0.45833333333333
16355, 1.2, 1.66, 0.45833333333333
16356, 1.2, 1.54, 0.020833333333333
16357, 1.2, 1.52, 0.041666666666667
16358, 1.2, 1.58, 0.020833333333333
16359, 1.2, 1.56, 0.041666666666667
16360, 1.2, 1.62, 0.020833333333333
16361, 1.2, 1.6, 0.041666666666667
16362, 1.2, 1.66, 0.020833333333333
16363, 1.2, 1.64, 0.041666666666667
16364, 1.2, 1.68, 0.041666666666667
16365, 1.2, 1.54, 0.0625
16366, 1.2, 1.52, 0.083333333333333
16367, 1.2, 1.58, 0.0625
16368, 1.2, 1.56, 0.083333333333333
16369, 1.2, 1.62, 0.0625
16370, 1.2, 1.6, 0.083333333333333
16371, 1.2, 1.66, 0.0625
16372, 1.2, 1.64, 0.083333333333333
16373, 1.2, 1.68, 0.083333333333333
16374, 1.2, 1.54, 0.10416666666667
16375, 1.2, 1.52, 0.125
16376, 1.2, 1.58, 0.10416666666667
16377, 1.2, 1.56, 0.125
16378, 1.2, 1.62, 0.10416666666667
16379, 1.2, 1.6, 0.125
16380, 1.2, 1.66, 0.10416666666667
16381, 1.2, 1.64, 0.125
16382, 1.2, 1.68, 0.125
16383, 1.2, 1.54, 0.14583333333333
16384, 1.2, 1.52, 0.16666666666667
16385, 1.2, 1.58, 0.14583333333333
16386, 1.2, 1.56, 0.16666666666667
16387, 1.2, 1.62, 0.14583333333333
16388, 1.2, 1.6, 0.16666666666667
16389, 1.2, 1.66, 0.14583333333333
16390, 1.2, 1.64, 0.16666666666667
16391, 1.2, 1.68, 0.16666666666667
16392, 1.2, 1.54, 0.1875
16393, 1.2, 1.52, 0.20833333333333
16394, 1.2, 1.58, 0.1875
16395, 1.2, 1.56, 0.20833333333333
16396, 1.2, 1.62, 0.1875
16397, 1.2, 1.6, 0.20833333333333
16398, 1.2, 1.66, 0.1875
16399, 1.2, 1.64, 0.20833333333333
16400, 1.2, 1.68, 0.20833333333333
16401, 1.2, 1.54, 0.22916666666667
16402, 1.2, 1.52, 0.25
16403, 1.2, 1.58, 0.22916666666667
16404, 1.2, 1.56, 0.25
16405, 1.2, 1.62, 0.22916666666667
16406, 1.2, 1.6, 0.25
16407, 1.2, 1.66, 0.22916666666667
16408, 1.2, 1.64, 0.25
16409, 1.2, 1.68, 0.25
16410, 1.2, 1.54, 0.27083333333333
16411, 1.2, 1.52, 0.29166666666667
16412, 1.2, 1.58, 0.27083333333333
16413, 1.2, 1.56, 0.29166666666667
16414, 1.2, 1.62, 0.27083333333333
16415, 1.2, 1.6, 0.29166666666667
16416, 1.2, 1.66, 0.27083333333333
16417, 1.2, 1.64, 0.29166666666667
16418, 1.2, 1.68, 0.29166666666667
16419, 1.2, 1.54, 0.3125
16420, 1.2, 1.52, 0.33333333333333
16421, 1.2, 1.58, 0.3125
16422, 1.2, 1.56, 0.33333333333333
16423, 1.2, 1.62, 0.3125
16424, 1.2, 1.6, 0.33333333333333
16425, 1.2, 1.66, 0.3125
16426, 1.2, 1.64, 0.33333333333333
16427, 1.2, 1.68, 0.33333333333333
16428, 1.2, 1.54, 0.35416666666667
16429, 1.2, 1.52, 0.375
16430, 1.2, 1.58, 0.35416666666667
16431, 1.2, 1.56, 0.375
16432, 1.2, 1.62, 0.35416666666667
16433, 1.2, 1.6, 0.375
16434, 1.2, 1.66, 0.35416666666667
16435, 1.2, 1.64, 0.375
16436, 1.2, 1.68, 0.375
16437, 1.2, 1.54, 0.39583333333333
16438, 1.2, 1.52, 0.41666666666667
16439, 1.2, 1.58, 0.39583333333333
16440, 1.2, 1.56, 0.41666666666667
16441, 1.2, 1.62, 0.39583333333333
16442, 1.2, 1.6, 0.41666666666667
16443, 1.2, 1.66, 0.39583333333333
16444, 1.2, 1.64, 0.41666666666667
16445, 1.2, 1.68, 0.41666666666667
16446, 1.2, 1.54, 0.4375
16447, 1.2, 1.52, 0.45833333333333
16448, 1.2, 1.58, 0.4375
16449, 1.2, 1.56, 0.45833333333333
16450, 1.2, 1.62, 0.4375
16451, 1.2, 1.6, 0.45833333333333
16452, 1.2, 1.66, 0.4375
16453, 1.2, 1.64, 0.45833333333333
16454, 1.2, 1.68, 0.45833333333333
16455, 1.2, 1.54, 0.47916666666667
16456, 1.2, 1.58, 0.47916666666667
16457, 1.2, 1.62, 0.47916666666667
16458, 1.2, 1.66, 0.47916666666667
16459, 1.04, 1.7, 0.041666666666667
16460, 1.08, 1.7, 0.041666666666667
16461, 1.12, 1.7, 0.041666666666667
16462, 1.16, 1.7, 0.041666666666667
16463, 1.04, 1.7, 0.083333333333333
16464, 1.08, 1.7, 0.083333333333333
16465, 1.12, 1.7, 0.083333333333333
16466, 1.16, 1.7, 0.083333333333333
16467, 1.04, 1.7, 0.125
16468, 1.08, 1.7, 0.125
16469, 1.12, 1.7, 0.125
16470, 1.16, 1.7, 0.125
16471, 1.04, 1.7, 0.16666666666667
16472, 1.08, 1.7, 0.16666666666667
16473, 1.12, 1.7, 0.16666666666667
16474, 1.16, 1.7, 0.16666666666667
16475, 1.04, 1.7, 0.20833333333333
16476, 1.08, 1.7, 0.20833333333333
16477, 1.12, 1.7, 0.20833333333333
16478, 1.16, 1.7, 0.20833333333333
16479, 1.04, 1.7, 0.25
16480, 1.08, 1.7, 0.25
16481, 1.12, 1.7, 0.25
16482, 1.16, 1.7, 0.25
16483, 1.04, 1.7, 0.29166666666667
16484, 1.08, 1.7, 0.29166666666667
16485, 1.12, 1.7, 0.29166666666667
16486, 1.16, 1.7, 0.29166666666667
16487, 1.04, 1.7, 0.33333333333333
16488, 1.08, 1.7, 0.33333333333333
16489, 1.12, 1.7, 0.33333333333333
16490, 1.16, 1.7, 0.33333333333333
16491, 1.04, 1.7, 0.375
16492, 1.08, 1.7, 0.375
16493, 1.12, 1.7, 0.375
16494, 1.16, 1.7, 0.375
16495, 1.04, 1.7, 0.41666666666667
16496, 1.08, 1.7, 0.41666666666667
16497, 1.12, 1.7, 0.41666666666667
16498, 1.16, 1.7, 0.41666666666667
16499, 1.04, 1.7, 0.45833333333333
16500, 1.08, 1.7, 0.45833333333333
16501, 1.12, 1.7, 0.45833333333333
16502, 1.16, 1.7, 0.45833333333333
16503, 1.2416666666667, 1.54, 0.5
16504, 1.2416666666667, 1.58, 0.5
16505, 1.2416666666667, 1.62, 0.5
16506, 1.2416666666667, 1.66, 0.5
16507, 1.2833333333333, 1.54, 0.5
16508, 1.2833333333333, 1.58, 0.5
16509, 1.2833333333333, 1.62, 0.5
16510, 1.2833333333333, 1.66, 0.5
16511, 1.325, 1.54, 0.5
16512, 1.325, 1.58, 0.5
16513, 1.325, 1.62, 0.5
16514, 1.325, 1.66, 0.5
16515, 1.3666666666667, 1.54, 0.5
16516, 1.3666666666667, 1.58, 0.5
16517, 1.3666666666667, 1.62, 0.5
16518, 1.3666666666667, 1.66, 0.5
16519, 1.4083333333333, 1.54, 0.5
16520, 1.4083333333333, 1.58, 0.5
16521, 1.4083333333333, 1.62, 0.5
16522, 1.4083333333333, 1.66, 0.5
16523, 1.45, 1.54, 0.5
16524, 1.45, 1.58, 0.5
16525, 1.45, 1.62, 0.5
16526, 1.45, 1.66, 0.5
16527, 1.4916666666667, 1.54, 0.5
16528, 1.4916666666667, 1.58, 0.5
16529, 1.4916666666667, 1.62, 0.5
16530, 1.4916666666667, 1.66, 0.5
16531, 1.5333333333333, 1.54, 0.5
16532, 1.5333333333333, 1.58, 0.5
16533, 1.5333333333333, 1.62, 0.5
16534, 1.5333333333333, 1.66, 0.5
16535, 1.575, 1.54, 0.5
16536, 1.575, 1.58, 0.5
16537, 1.575, 1.62, 0.5
16538, 1.575, 1.66, 0.5
16539, 1.6166666666667, 1.54, 0.5
16540, 1.6166666666667, 1.58, 0.5
16541, 1.6166666666667, 1.62, 0.5
16542, 1.6166666666667, 1.66, 0.5
16543, 1.6583333333333, 1.54, 0.5
16544, 1.6583333333333, 1.58, 0.5
16545, 1.6583333333333, 1.62, 0.5
16546, 1.6583333333333, 1.66, 0.5
16547, 1.7, 1.54, 0.5
16548, 1.7, 1.58, 0.5
16549, 1.7, 1.62, 0.5
16550, 1.7, 1.66, 0.5
16551, 1.7416666666667, 1.54, 0.5
16552, 1.7416666666667, 1.58, 0.5
16553, 1.7416666666667, 1.62, 0.5
16554, 1.7416666666667, 1.66, 0.5
16555, 1.7833333333333, 1.54, 0.5
16556, 1.7833333333333, 1.58, 0.5
16557, 1.7833333333333, 1.62, 0.5
16558, 1.7833333333333, 1.66, 0.5
16559, 1.825, 1.54, 0.5
16560, 1.825, 1.58, 0.5
16561, 1.825, 1.62, 0.5
16562, 1.825, 1.66, 0.5
16563, 1.8666666666667, 1.54, 0.5
16564, 1.8666666666667, 1.58, 0.5
16565, 1.8666666666667, 1.62, 0.5
16566, 1.8666666666667, 1.66, 0.5
16567, 1.9083333333333, 1.54, 0.5
16568, 1.9083333333333, 1.58, 0.5
16569, 1.9083333333333, 1.62, 0.5
16570, 1.9083333333333, 1.66, 0.5
16571, 1.95, 1.54, 0.5
16572, 1.95, 1.58, 0.5
16573, 1.95, 1.62, 0.5
16574, 1.95, 1.66, 0.5
16575, 1.9916666666667, 1.54, 0.5
16576, 1.9916666666667, 1.58, 0.5
16577, 1.9916666666667, 1.62, 0.5
16578, 1.9916666666667, 1.66, 0.5
16579, 2.0333333333333, 1.54, 0.5
16580, 2.0333333333333, 1.58, 0.5
16581, 2.0333333333333, 1.62, 0.5
16582, 2.0333333333333, 1.66, 0.5
16583, 2.075, 1.54, 0.5
16584, 2.075, 1.58, 0.5
16585, 2.075, 1.62, 0.5
16586, 2.075, 1.66, 0.5
16587, 2.1166666666667, 1.54, 0.5
16588, 2.1166666666667, 1.58, 0.5
16589, 2.1166666666667, 1.62, 0.5
16590, 2.1166666666667, 1.66, 0.5
16591, 2.1583333333333, 1.54, 0.5
16592, 2.1583333333333, 1.58, 0.5
16593, 2.1583333333333, 1.62, 0.5
16594, 2.1583333333333, 1.66, 0.5
16595, 1.2416666666667, 1.54, 0
16596, 1.2416666666667, 1.58, 0
16597, 1.2416666666667, 1.62, 0
16598, 1.2416666666667, 1.66, 0
16599, 1.2833333333333, 1.54, 0
16600, 1.2833333333333, 1.58, 0
16601, 1.2833333333333, 1.62, 0
16602, 1.2833333333333, 1.66, 0
16603, 1.325, 1.54, 0
16604, 1.325, 1.58, 0
16605, 1.325, 1.62, 0
16606, 1.325, 1.66, 0
16607, 1.3666666666667, 1.54, 0
16608, 1.3666666666667, 1.58, 0
16609, 1.3666666666667, 1.62, 0
16610, 1.3666666666667, 1.66, 0
16611, 1.4083333333333, 1.54, 0
16612, 1.4083333333333, 1.58, 0
16613, 1.4083333333333, 1.62, 0
16614, 1.4083333333333, 1.66, 0
16615, 1.45, 1.54, 0
16616, 1.45, 1.58, 0
16617, 1.45, 1.62, 0
16618, 1.45, 1.66, 0
16619, 1.4916666666667, 1.54, 0
16620, 1.4916666666667, 1.58, 0
16621, 1.4916666666667, 1.62, 0
16622, 1.4916666666667, 1.66, 0
16623, 1.5333333333333, 1.54, 0
16624, 1.5333333333333, 1.58, 0
16625, 1.5333333333333, 1.62, 0
16626, 1.5333333333333, 1.66, 0
16627, 1.575, 1.54, 0
16628, 1.575, 1.58, 0
16629, 1.575, 1.62, 0
16630, 1.575, 1.66, 0
16631, 1.6166666666667, 1.54, 0
16632, 1.6166666666667, 1.58, 0
16633, 1.6166666666667, 1.62, 0
16634, 1.6166666666667, 1.66, 0
16635, 1.6583333333333, 1.54, 0
16636, 1.6583333333333, 1.58, 0
16637, 1.6583333333333, 1.62, 0
16638, 1.6583333333333, 1.66, 0
16639, 1.7, 1.54, 0
16640, 1.7, 1.58, 0
16641, 1.7, 1.62, 0
16642, 1.7, 1.66, 0
16643, 1.7416666666667, 1.54, 0
16644, 1.7416666666667, 1.58, 0
16645, 1.7416666666667, 1.62, 0
16646, 1.7416666666667, 1.66, 0
16647, 1.7833333333333, 1.54, 0
16648, 1.7833333333333, 1.58, 0
16649, 1.7833333333333, 1.62, 0
16650, 1.7833333333333, 1.66, 0
16651, 1.825, 1.54, 0
16652, 1.825, 1.58, 0
16653, 1.825, 1.62, 0
16654, 1.825, 1.66, 0
16655, 1.8666666666667, 1.54, 0
16656, 1.8666666666667, 1.58, 0
16657, 1.8666666666667, 1.62, 0
16658, 1.8666666666667, 1.66, 0
16659, 1.9083333333333, 1.54, 0
16660, 1.9083333333333, 1.58, 0
16661, 1.9083333333333, 1.62, 0
16662, 1.9083333333333, 1.66, 0
16663, 1.95, 1.54, 0
16664, 1.95, 1.58, 0
16665, 1.95, 1.62, 0
16666, 1.95, 1.66, 0
16667, 1.9916666666667, 1.54, 0
16668, 1.9916666666667, 1.58, 0
16669, 1.9916666666667, 1.62, 0
16670, 1.9916666666667, 1.66, 0
16671, 2.0333333333333, 1.54, 0
16672, 2.0333333333333, 1.58, 0
16673, 2.0333333333333, 1.62, 0
16674, 2.0333333333333, 1.66, 0
16675, 2.075, 1.54, 0
16676, 2.075, 1.58, 0
16677, 2.075, 1.62, 0
16678, 2.075, 1.66, 0
16679, 2.1166666666667, 1.54, 0
16680, 2.1166666666667, 1.58, 0
16681, 2.1166666666667, 1.62, 0
16682, 2.1166666666667, 1.66, 0
16683, 2.1583333333333, 1.54, 0
16684, 2.1583333333333, 1.58, 0
16685, 2.1583333333333, 1.62, 0
16686, 2.1583333333333, 1.66, 0
16687, 1.2208333333333, 1.54, 0
16688, 1.2416666666667, 1.52, 0
16689, 1.2208333333333, 1.58, 0
16690, 1.2416666666667, 1.56, 0
16691, 1.2208333333333, 1.62, 0
16692, 1.2416666666667, 1.6, 0
16693, 1.2208333333333, 1.66, 0
16694, 1.2416666666667, 1.64, 0
16695, 1.2416666666667, 1.68, 0
16696, 1.2625, 1.54, 0
16697, 1.2833333333333, 1.52, 0
16698, 1.2625, 1.58, 0
16699, 1.2833333333333, 1.56, 0
16700, 1.2625, 1.62, 0
16701, 1.2833333333333, 1.6, 0
16702, 1.2625, 1.66, 0
16703, 1.2833333333333, 1.64, 0
16704, 1.2833333333333, 1.68, 0
16705, 1.3041666666667, 1.54, 0
16706, 1.325, 1.52, 0
16707, 1.3041666666667, 1.58, 0
16708, 1.325, 1.56, 0
16709, 1.3041666666667, 1.62, 0
16710, 1.325, 1.6, 0
16711, 1.3041666666667, 1.66, 0
16712, 1.325, 1.64, 0
16713, 1.325, 1.68, 0
16714, 1.3458333333333, 1.54, 0
16715, 1.3666666666667, 1.52, 0
16716, 1.3458333333333, 1.58, 0
16717, 1.3666666666667, 1.56, 0
16718, 1.3458333333333, 1.62, 0
16719, 1.3666666666667, 1.6, 0
16720, 1.3458333333333, 1.66, 0
16721, 1.3666666666667, 1.64, 0
16722, 1.3666666666667, 1.68, 0
16723, 1.3875, 1.54, 0
16724, 1.4083333333333, 1.52, 0
16725, 1.3875, 1.58, 0
16726, 1.4083333333333, 1.56, 0
16727, 1.3875, 1.62, 0
16728, 1.4083333333333, 1.6, 0
16729, 1.3875, 1.66, 0
16730, 1.4083333333333, 1.64, 0
16731, 1.4083333333333, 1.68, 0
16732, 1.4291666666667, 1.54, 0
16733, 1.45, 1.52, 0
16734, 1.4291666666667, 1.58, 0
16735, 1.45, 1.56, 0
16736, 1.4291666666667, 1.62, 0
16737, 1.45, 1.6, 0
16738, 1.4291666666667, 1.66, 0
16739, 1.45, 1.64, 0
16740, 1.45, 1.68, 0
16741, 1.4708333333333, 1.54, 0
16742, 1.4916666666667, 1.52, 0
16743, 1.4708333333333, 1.58, 0
16744, 1.4916666666667, 1.56, 0
16745, 1.4708333333333, 1.62, 0
16746, 1.4916666666667, 1.6, 0
16747, 1.4708333333333, 1.66, 0
16748, 1.4916666666667, 1.64, 0
16749, 1.4916666666667, 1.68, 0
16750, 1.5125, 1.54, 0
16751, 1.5333333333333, 1.52, 0
16752, 1.5125, 1.58, 0
16753, 1.5333333333333, 1.56, 0
16754, 1.5125, 1.62, 0
16755, 1.5333333333333, 1.6, 0
16756, 1.5125, 1.66, 0
16757, 1.5333333333333, 1.64, 0
16758, 1.5333333333333, 1.68, 0
16759, 1.5541666666667, 1.54, 0
16760, 1.575, 1.52, 0
16761, 1.5541666666667, 1.58, 0
16762, 1.575, 1.56, 0
16763, 1.5541666666667, 1.62, 0
16764, 1.575, 1.6, 0
16765, 1.5541666666667, 1.66, 0
16766, 1.575, 1.64, 0
16767, 1.575, 1.68, 0
16768, 1.5958333333333, 1.54, 0
16769, 1.6166666666667, 1.52, 0
16770, 1.5958333333333, 1.58, 0
16771, 1.6166666666667, 1.56, 0
16772, 1.5958333333333, 1.62, 0
16773, 1.6166666666667, 1.6, 0
16774, 1.5958333333333, 1.66, 0
16775, 1.6166666666667, 1.64, 0
16776, 1.6166666666667, 1.68, 0
16777, 1.6375, 1.54, 0
16778, 1.6583333333333, 1.52, 0
16779, 1.6375, 1.58, 0
16780, 1.6583333333333, 1.56, 0
16781, 1.6375, 1.62, 0
16782, 1.6583333333333, 1.6, 0
16783, 1.6375, 1.66, 0
16784, 1.6583333333333, 1.64, 0
16785, 1.6583333333333, 1.68, 0
16786, 1.6791666666667, 1.54, 0
16787, 1.7, 1.52, 0
16788, 1.6791666666667, 1.58, 0
16789, 1.7, 1.56, 0
16790, 1.6791666666667, 1.62, 0
16791, 1.7, 1.6, 0
16792, 1.6791666666667, 1.66, 0
16793, 1.7, 1.64, 0
16794, 1.7, 1.68, 0
16795, 1.7208333333333, 1.54, 0
16796, 1.7416666666667, 1.52, 0
16797, 1.7208333333333, 1.58, 0
16798, 1.7416666666667, 1.56, 0
16799, 1.7208333333333, 1.62, 0
16800, 1.7416666666667, 1.6, 0
16801, 1.7208333333333, 1.66, 0
16802, 1.7416666666667, 1.64, 0
16803, 1.7416666666667, 1.68, 0
16804, 1.7625, 1.54, 0
16805, 1.7833333333333, 1.52, 0
16806, 1.7625, 1.58, 0
16807, 1.7833333333333, 1.56, 0
16808, 1.7625, 1.62, 0
16809, 1.7833333333333, 1.6, 0
16810, 1.7625, 1.66, 0
16811, 1.7833333333333, 1.64, 0
16812, 1.7833333333333, 1.68, 0
16813, 1.8041666666667, 1.54, 0
16814, 1.825, 1.52, 0
16815, 1.8041666666667, 1.58, 0
16816, 1.825, 1.56, 0
16817, 1.8041666666667, 1.62, 0
16818, 1.825, 1.6, 0
16819, 1.8041666666667, 1.66, 0
16820, 1.825, 1.64, 0
16821, 1.825, 1.68, 0
16822, 1.8458333333333, 1.54, 0
16823, 1.8666666666667, 1.52, 0
16824, 1.8458333333333, 1.58, 0
16825, 1.8666666666667, 1.56, 0
16826, 1.8458333333333, 1.62, 0
16827, 1.8666666666667, 1.6, 0
16828, 1.8458333333333, 1.66, 0
16829, 1.8666666666667, 1.64, 0
16830, 1.8666666666667, 1.68, 0
16831, 1.8875, 1.54, 0
16832, 1.9083333333333, 1.52, 0
16833, 1.8875, 1.58, 0
16834, 1.9083333333333, 1.56, 0
16835, 1.8875, 1.62, 0
16836, 1.9083333333333, 1.6, 0
16837, 1.8875, 1.66, 0
16838, 1.9083333333333, 1.64, 0
16839, 1.9083333333333, 1.68, 0
16840, 1.9291666666667, 1.54, 0
16841, 1.95, 1.52, 0
16842, 1.9291666666667, 1.58, 0
16843, 1.95, 1.56, 0
16844, 1.9291666666667, 1.62, 0
16845, 1.95, 1.6, 0
16846, 1.9291666666667, 1.66, 0
16847, 1.95, 1.64, 0
16848, 1.95, 1.68, 0
16849, 1.9708333333333, 1.54, 0
16850, 1.9916666666667, 1.52, 0
16851, 1.9708333333333, 1.58, 0
16852, 1.9916666666667, 1.56, 0
16853, 1.9708333333333, 1.62, 0
16854, 1.9916666666667, 1.6, 0
16855, 1.9708333333333, 1.66, 0
16856, 1.9916666666667, 1.64, 0
16857, 1.9916666666667, 1.68, 0
16858, 2.0125, 1.54, 0
16859, 2.0333333333333, 1.52, 0
16860, 2.0125, 1.58, 0
16861, 2.0333333333333, 1.56, 0
16862, 2.0125, 1.62, 0
16863, 2.0333333333333, 1.6, 0
16864, 2.0125, 1.66, 0
16865, 2.0333333333333, 1.64, 0
16866, 2.0333333333333, 1.68, 0
16867, 2.0541666666667, 1.54, 0
16868, 2.075, 1.52, 0
16869, 2.0541666666667, 1.58, 0
16870, 2.075, 1.56, 0
16871, 2.0541666666667, 1.62, 0
16872, 2.075, 1.6, 0
16873, 2.0541666666667, 1.66, 0
16874, 2.075, 1.64, 0
16875, 2.075, 1.68, 0
16876, 2.0958333333333, 1.54, 0
16877, 2.1166666666667, 1.52, 0
16878, 2.0958333333333, 1.58, 0
16879, 2.1166666666667, 1.56, 0
16880, 2.0958333333333, 1.62, 0
16881, 2.1166666666667, 1.6, 0
16882, 2.0958333333333, 1.66, 0
16883, 2.1166666666667, 1.64, 0
16884, 2.1166666666667, 1.68, 0
16885, 2.1375, 1.54, 0
16886, 2.1583333333333, 1.52, 0
16887, 2.1375, 1.58, 0
16888, 2.1583333333333, 1.56, 0
16889, 2.1375, 1.62, 0
16890, 2.1583333333333, 1.6, 0
16891, 2.1375, 1.66, 0
16892, 2.1583333333333, 1.64, 0
16893, 2.1583333333333, 1.68, 0
16894, 2.1791666666667, 1.54, 0
16895, 2.1791666666667, 1.58, 0
16896, 2.1791666666667, 1.62, 0
16897, 2.1791666666667, 1.66, 0
16898, 2.2, 1.54, 0.041666666666667
16899, 2.2, 1.58, 0.041666666666667
16900, 2.2, 1.62, 0.041666666666667
16901, 2.2, 1.66, 0.041666666666667
16902, 2.2, 1.54, 0.083333333333333
16903, 2.2, 1.58, 0.083333333333333
16904, 2.2, 1.62, 0.083333333333333
16905, 2.2, 1.66, 0.083333333333333
16906, 2.2, 1.54, 0.125
16907, 2.2, 1.58, 0.125
16908, 2.2, 1.62, 0.125
16909, 2.2, 1.66, 0.125
16910, 2.2, 1.54, 0.16666666666667
16911, 2.2, 1.58, 0.16666666666667
16912, 2.2, 1.62, 0.16666666666667
16913, 2.2, 1.66, 0.16666666666667
16914, 2.2, 1.54, 0.20833333333333
16915, 2.2, 1.58, 0.20833333333333
16916, 2.2, 1.62, 0.20833333333333
16917, 2.2, 1.66, 0.20833333333333
16918, 2.2, 1.54, 0.25
16919, 2.2, 1.58, 0.25
16920, 2.2, 1.62, 0.25
16921, 2.2, 1.66, 0.25
16922, 2.2, 1.54, 0.29166666666667
16923, 2.2, 1.58, 0.29166666666667
16924, 2.2, 1.62, 0.29166666666667
16925, 2.2, 1.66, 0.29166666666667
16926, 2.2, 1.54, 0.33333333333333
16927, 2.2, 1.58, 0.33333333333333
16928, 2.2, 1.62, 0.33333333333333
16929, 2.2, 1.66, 0.33333333333333
16930, 2.2, 1.54, 0.375
16931, 2.2, 1.58, 0.375
16932, 2.2, 1.62, 0.375
16933, 2.2, 1.66, 0.375
16934, 2.2, 1.54, 0.41666666666667
16935, 2.2, 1.58, 0.41666666666667
16936, 2.2, 1.62, 0.41666666666667
16937, 2.2, 1.66, 0.41666666666667
16938, 2.2, 1.54, 0.45833333333333
16939, 2.2, 1.58, 0.45833333333333
16940, 2.2, 1.62, 0.45833333333333
16941, 2.2, 1.66, 0.45833333333333
16942, 2.2, 1.54, 0.020833333333333
16943, 2.2, 1.52, 0.041666666666667
16944, 2.2, 1.58, 0.020833333333333
16945, 2.2, 1.56, 0.041666666666667
16946, 2.2, 1.62, 0.020833333333333
16947, 2.2, 1.6, 0.041666666666667
16948, 2.2, 1.66, 0.020833333333333
16949, 2.2, 1.64, 0.041666666666667
16950, 2.2, 1.68, 0.041666666666667
16951, 2.2, 1.54, 0.0625
16952, 2.2, 1.52, 0.083333333333333
16953, 2.2, 1.58, 0.0625
16954, 2.2, 1.56, 0.083333333333333
16955, 2.2, 1.62, 0.0625
16956, 2.2, 1.6, 0.083333333333333
16957, 2.2, 1.66, 0.0625
16958, 2.2, 1.64, 0.083333333333333
16959, 2.2, 1.68, 0.083333333333333
16960, 2.2, 1.54, 0.10416666666667
16961, 2.2, 1.52, 0.125
16962, 2.2, 1.58, 0.10416666666667
16963, 2.2, 1.56, 0.125
16964, 2.2, 1.62, 0.10416666666667
16965, 2.2, 1.6, 0.125
16966, 2.2, 1.66, 0.10416666666667
16967, 2.2, 1.64, 0.125
16968, 2.2, 1.68, 0.125
16969, 2.2, 1.54, 0.14583333333333
16970, 2.2, 1.52, 0.16666666666667
16971, 2.2, 1.58, 0.14583333333333
16972, 2.2, 1.56, 0.16666666666667
16973, 2.2, 1.62, 0.14583333333333
16974, 2.2, 1.6, 0.16666666666667
16975, 2.2, 1.66, 0.14583333333333
16976, 2.2, 1.64, 0.16666666666667
16977, 2.2, 1.68, 0.16666666666667
16978, 2.2, 1.54, 0.1875
16979, 2.2, 1.52, 0.20833333333333
16980, 2.2, 1.58, 0.1875
16981, 2.2, 1.56, 0.20833333333333
16982, 2.2, 1.62, 0.1875
16983, 2.2, 1.6, 0.20833333333333
16984, 2.2, 1.66, 0.1875
16985, 2.2, 1.64, 0.20833333333333
16986, 2.2, 1.68, 0.20833333333333
16987, 2.2, 1.54, 0.22916666666667
16988, 2.2, 1.52, 0.25
16989, 2.2, 1.58, 0.22916666666667
16990, 2.2, 1.56, 0.25
16991, 2.2, 1.62, 0.22916666666667
16992, 2.2, 1.6, 0.25
16993, 2.2, 1.66, 0.22916666666667
16994, 2.2, 1.64, 0.25
16995, 2.2, 1.68, 0.25
16996, 2.2, 1.54, 0.27083333333333
16997, 2.2, 1.52, 0.29166666666667
16998, 2.2, 1.58, 0.27083333333333
16999, 2.2, 1.56, 0.29166666666667
17000, 2.2, 1.62, 0.27083333333333
17001, 2.2, 1.6, 0.29166666666667
17002, 2.2, 1.66, 0.27083333333333
17003, 2.2, 1.64, 0.29166666666667
17004, 2.2, 1.68, 0.29166666666667
17005, 2.2, 1.54, 0.3125
17006, 2.2, 1.52, 0.33333333333333
17007, 2.2, 1.58, 0.3125
17008, 2.2, 1.56, 0.33333333333333
17009, 2.2, 1.62, 0.3125
17010, 2.2, 1.6, 0.33333333333333
17011, 2.2, 1.66, 0.3125
17012, 2.2, 1.64, 0.33333333333333
17013, 2.2, 1.68, 0.33333333333333
17014, 2.2, 1.54, 0.35416666666667
17015, 2.2, 1.52, 0.375
17016, 2.2, 1.58, 0.35416666666667
17017, 2.2, 1.56, 0.375
17018, 2.2, 1.62, 0.35416666666667
17019, 2.2, 1.6, 0.375
17020, 2.2, 1.66, 0.35416666666667
17021, 2.2, 1.64, 0.375
17022, 2.2, 1.68, 0.375
17023, 2.2, 1.54, 0.39583333333333
17024, 2.2, 1.52, 0.41666666666667
17025, 2.2, 1.58, 0.39583333333333
17026, 2.2, 1.56, 0.41666666666667
17027, 2.2, 1.62, 0.39583333333333
17028, 2.2, 1.6, 0.41666666666667
17029, 2.2, 1.66, 0.39583333333333
17030, 2.2, 1.64, 0.41666666666667
17031, 2.2, 1.68, 0.41666666666667
17032, 2.2, 1.54, 0.4375
17033, 2.2, 1.52, 0.45833333333333
17034, 2.2, 1.58, 0.4375
17035, 2.2, 1.56, 0.45833333333333
17036, 2.2, 1.62, 0.4375
17037, 2.2, 1.6, 0.45833333333333
17038, 2.2, 1.66, 0.4375
17039, 2.2, 1.64, 0.45833333333333
17040, 2.2, 1.68, 0.45833333333333
17041, 2.2, 1.54, 0.47916666666667
17042, 2.2, 1.58, 0.47916666666667
17043, 2.2, 1.62, 0.47916666666667
17044, 2.2, 1.66, 0.47916666666667
17045, 1.2416666666667, 1.7, 0.041666666666667
17046, 1.2833333333333, 1.7, 0.041666666666667
17047, 1.325, 1.7, 0.041666666666667
17048, 1.3666666666667, 1.7, 0.041666666666667
17049, 1.4083333333333, 1.7, 0.041666666666667
17050, 1.45, 1.7, 0.041666666666667
17051, 1.4916666666667, 1.7, 0.041666666666667
17052, 1.5333333333333, 1.7, 0.041666666666667
17053, 1.575, 1.7, 0.041666666666667
17054, 1.6166666666667, 1.7, 0.041666666666667
17055, 1.6583333333333, 1.7, 0.041666666666667
17056, 1.7, 1.7, 0.041666666666667
17057, 1.7416666666667, 1.7, 0.041666666666667
17058, 1.7833333333333, 1.7, 0.041666666666667
17059, 1.825, 1.7, 0.041666666666667
17060, 1.8666666666667, 1.7, 0.041666666666667
17061, 1.9083333333333, 1.7, 0.041666666666667
17062, 1.95, 1.7, 0.041666666666667
17063, 1.9916666666667, 1.7, 0.041666666666667
17064, 2.0333333333333, 1.7, 0.041666666666667
17065, 2.075, 1.7, 0.041666666666667
17066, 2.1166666666667, 1.7, 0.041666666666667
17067, 2.1583333333333, 1.7, 0.041666666666667
17068, 1.2416666666667, 1.7, 0.083333333333333
17069, 1.2833333333333, 1.7, 0.083333333333333
17070, 1.325, 1.7, 0.083333333333333
17071, 1.3666666666667, 1.7, 0.083333333333333
17072, 1.4083333333333, 1.7, 0.083333333333333
17073, 1.45, 1.7, 0.083333333333333
17074, 1.4916666666667, 1.7, 0.083333333333333
17075, 1.5333333333333, 1.7, 0.083333333333333
17076, 1.575, 1.7, 0.083333333333333
17077, 1.6166666666667, 1.7, 0.083333333333333
17078, 1.6583333333333, 1.7, 0.083333333333333
17079, 1.7, 1.7, 0.083333333333333
17080, 1.7416666666667, 1.7, 0.083333333333333
17081, 1.7833333333333, 1.7, 0.083333333333333
17082, 1.825, 1.7, 0.083333333333333
17083, 1.8666666666667, 1.7, 0.083333333333333
17084, 1.9083333333333, 1.7, 0.083333333333333
17085, 1.95, 1.7, 0.083333333333333
17086, 1.9916666666667, 1.7, 0.083333333333333
17087, 2.0333333333333, 1.7, 0.083333333333333
17088, 2.075, 1.7, 0.083333333333333
17089, 2.1166666666667, 1.7, 0.083333333333333
17090, 2.1583333333333, 1.7, 0.083333333333333
17091, 1.2416666666667, 1.7, 0.125
17092, 1.2833333333333, 1.7, 0.125
17093, 1.325, 1.7, 0.125
17094, 1.3666666666667, 1.7, 0.125
17095, 1.4083333333333, 1.7, 0.125
17096, 1.45, 1.7, 0.125
17097, 1.4916666666667, 1.7, 0.125
17098, 1.5333333333333, 1.7, 0.125
17099, 1.575, 1.7, 0.125
17100, 1.6166666666667, 1.7, 0.125
17101, 1.6583333333333, 1.7, 0.125
17102, 1.7, 1.7, 0.125
17103, 1.7416666666667, 1.7, 0.125
17104, 1.7833333333333, 1.7, 0.125
17105, 1.825, 1.7, 0.125
17106, 1.8666666666667, 1.7, 0.125
17107, 1.9083333333333, 1.7, 0.125
17108, 1.95, 1.7, 0.125
17109, 1.9916666666667, 1.7, 0.125
17110, 2.0333333333333, 1.7, 0.125
17111, 2.075, 1.7, 0.125
17112, 2.1166666666667, 1.7, 0.125
17113, 2.1583333333333, 1.7, 0.125
17114, 1.2416666666667, 1.7, 0.16666666666667
17115, 1.2833333333333, 1.7, 0.16666666666667
17116, 1.325, 1.7, 0.16666666666667
17117, 1.3666666666667, 1.7, 0.16666666666667
17118, 1.4083333333333, 1.7, 0.16666666666667
17119, 1.45, 1.7, 0.16666666666667
17120, 1.4916666666667, 1.7, 0.16666666666667
17121, 1.5333333333333, 1.7, 0.16666666666667
17122, 1.575, 1.7, 0.16666666666667
17123, 1.6166666666667, 1.7, 0.16666666666667
17124, 1.6583333333333, 1.7, 0.16666666666667
17125, 1.7, 1.7, 0.16666666666667
17126, 1.7416666666667, 1.7, 0.16666666666667
17127, 1.7833333333333, 1.7, 0.16666666666667
17128, 1.825, 1.7, 0.16666666666667
17129, 1.8666666666667, 1.7, 0.16666666666667
17130, 1.9083333333333, 1.7, 0.16666666666667
17131, 1.95, 1.7, 0.16666666666667
17132, 1.9916666666667, 1.7, 0.16666666666667
17133, 2.0333333333333, 1.7, 0.16666666666667
17134, 2.075, 1.7, 0.16666666666667
17135, 2.1166666666667, 1.7, 0.16666666666667
17136, 2.1583333333333, 1.7, 0.16666666666667
17137, 1.2416666666667, 1.7, 0.20833333333333
17138, 1.2833333333333, 1.7, 0.20833333333333
17139, 1.325, 1.7, 0.20833333333333
17140, 1.3666666666667, 1.7, 0.20833333333333
17141, 1.4083333333333, 1.7, 0.20833333333333
17142, 1.45, 1.7, 0.20833333333333
17143, 1.4916666666667, 1.7, 0.20833333333333
17144, 1.5333333333333, 1.7, 0.20833333333333
17145, 1.575, 1.7, 0.20833333333333
17146, 1.6166666666667, 1.7, 0.20833333333333
17147, 1.6583333333333, 1.7, 0.20833333333333
17148, 1.7, 1.7, 0.20833333333333
17149, 1.7416666666667, 1.7, 0.20833333333333
17150, 1.7833333333333, 1.7, 0.20833333333333
17151, 1.825, 1.7, 0.20833333333333
17152, 1.8666666666667, 1.7, 0.20833333333333
17153, 1.9083333333333, 1.7, 0.20833333333333
17154, 1.95, 1.7, 0.20833333333333
17155, 1.9916666666667, 1.7, 0.20833333333333
17156, 2.0333333333333, 1.7, 0.20833333333333
17157, 2.075, 1.7, 0.20833333333333
17158, 2.1166666666667, 1.7, 0.20833333333333
17159, 2.1583333333333, 1.7, 0.20833333333333
17160, 1.2416666666667, 1.7, 0.25
17161, 1.2833333333333, 1.7, 0.25
17162, 1.325, 1.7, 0.25
17163, 1.3666666666667, 1.7, 0.25
17164, 1.4083333333333, 1.7, 0.25
17165, 1.45, 1.7, 0.25
17166, 1.4916666666667, 1.7, 0.25
17167, 1.5333333333333, 1.7, 0.25
17168, 1.575, 1.7, 0.25
17169, 1.6166666666667, 1.7, 0.25
17170, 1.6583333333333, 1.7, 0.25
17171, 1.7, 1.7, 0.25
17172, 1.7416666666667, 1.7, 0.25
17173, 1.7833333333333, 1.7, 0.25
17174, 1.825, 1.7, 0.25
17175, 1.8666666666667, 1.7, 0.25
17176, 1.9083333333333, 1.7, 0.25
17177, 1.95, 1.7, 0.25
17178, 1.9916666666667, 1.7, 0.25
17179, 2.0333333333333, 1.7, 0.25
17180, 2.075, 1.7, 0.25
17181, 2.1166666666667, 1.7, 0.25
17182, 2.1583333333333, 1.7, 0.25
17183, 1.2416666666667, 1.7, 0.29166666666667
17184, 1.2833333333333, 1.7, 0.29166666666667
17185, 1.325, 1.7, 0.29166666666667
17186, 1.3666666666667, 1.7, 0.29166666666667
17187, 1.4083333333333, 1.7, 0.29166666666667
17188, 1.45, 1.7, 0.29166666666667
17189, 1.4916666666667, 1.7, 0.29166666666667
17190, 1.5333333333333, 1.7, 0.29166666666667
17191, 1.575, 1.7, 0.29166666666667
17192, 1.6166666666667, 1.7, 0.29166666666667
17193, 1.6583333333333, 1.7, 0.29166666666667
17194, 1.7, 1.7, 0.29166666666667
17195, 1.7416666666667, 1.7, 0.29166666666667
17196, 1.7833333333333, 1.7, 0.29166666666667
17197, 1.825, 1.7, 0.29166666666667
17198, 1.8666666666667, 1.7, 0.29166666666667
17199, 1.9083333333333, 1.7, 0.29166666666667
17200, 1.95, 1.7, 0.29166666666667
17201, 1.9916666666667, 1.7, 0.29166666666667
17202, 2.0333333333333, 1.7, 0.29166666666667
17203, 2.075, 1.7, 0.29166666666667
17204, 2.1166666666667, 1.7, 0.29166666666667
17205, 2.1583333333333, 1.7, 0.29166666666667
17206, 1.2416666666667, 1.7, 0.33333333333333
17207, 1.2833333333333, 1.7, 0.33333333333333
17208, 1.325, 1.7, 0.33333333333333
17209, 1.3666666666667, 1.7, 0.33333333333333
17210, 1.4083333333333, 1.7, 0.33333333333333
17211, 1.45, 1.7, 0.33333333333333
17212, 1.4916666666667, 1.7, 0.33333333333333
17213, 1.5333333333333, 1.7, 0.33333333333333
17214, 1.575, 1.7, 0.33333333333333
17215, 1.6166666666667, 1.7, 0.33333333333333
17216, 1.6583333333333, 1.7, 0.33333333333333
17217, 1.7, 1.7, 0.33333333333333
17218, 1.7416666666667, 1.7, 0.33333333333333
17219, 1.7833333333333, 1.7, 0.33333333333333
17220, 1.825, 1.7, 0.33333333333333
17221, 1.8666666666667, 1.7, 0.33333333333333
17222, 1.9083333333333, 1.7, 0.33333333333333
17223, 1.95, 1.7, 0.33333333333333
17224, 1.9916666666667, 1.7, 0.33333333333333
17225, 2.0333333333333, 1.7, 0.33333333333333
17226, 2.075, 1.7, 0.33333333333333
17227, 2.1166666666667, 1.7, 0.33333333333333
17228, 2.1583333333333, 1.7, 0.33333333333333
17229, 1.2416666666667, 1.7, 0.375
17230, 1.2833333333333, 1.7, 0.375
17231, 1.325, 1.7, 0.375
17232, 1.3666666666667, 1.7, 0.375
17233, 1.4083333333333, 1.7, 0.375
17234, 1.45, 1.7, 0.375
17235, 1.4916666666667, 1.7, 0.375
17236, 1.5333333333333, 1.7, 0.375
17237, 1.575, 1.7, 0.375
17238, 1.6166666666667, 1.7, 0.375
17239, 1.6583333333333, 1.7, 0.375
17240, 1.7, 1.7, 0.375
17241, 1.7416666666667, 1.7, 0.375
17242, 1.7833333333333, 1.7, 0.375
17243, 1.825, 1.7, 0.375
17244, 1.8666666666667, 1.7, 0.375
17245, 1.9083333333333, 1.7, 0.375
17246, 1.95, 1.7, 0.375
17247, 1.9916666666667, 1.7, 0.375
17248, 2.0333333333333, 1.7, 0.375
17249, 2.075, 1.7, 0.375
17250, 2.1166666666667, 1.7, 0.375
17251, 2.1583333333333, 1.7, 0.375
17252, 1.2416666666667, 1.7, 0.41666666666667
17253, 1.2833333333333, 1.7, 0.41666666666667
17254, 1.325, 1.7, 0.41666666666667
17255, 1.3666666666667, 1.7, 0.41666666666667
17256, 1.4083333333333, 1.7, 0.41666666666667
17257, 1.45, 1.7, 0.41666666666667
17258, 1.4916666666667, 1.7, 0.41666666666667
17259, 1.5333333333333, 1.7, 0.41666666666667
17260, 1.575, 1.7, 0.41666666666667
17261, 1.6166666666667, 1.7, 0.41666666666667
17262, 1.6583333333333, 1.7, 0.41666666666667
17263, 1.7, 1.7, 0.41666666666667
17264, 1.7416666666667, 1.7, 0.41666666666667
17265, 1.7833333333333, 1.7, 0.41666666666667
17266, 1.825, 1.7, 0.41666666666667
17267, 1.8666666666667, 1.7, 0.41666666666667
17268, 1.9083333333333, 1.7, 0.41666666666667
17269, 1.95, 1.7, 0.41666666666667
17270, 1.9916666666667, 1.7, 0.41666666666667
17271, 2.0333333333333, 1.7, 0.41666666666667
17272, 2.075, 1.7, 0.41666666666667
17273, 2.1166666666667, 1.7, 0.41666666666667
17274, 2.1583333333333, 1.7, 0.41666666666667
17275, 1.2416666666667, 1.7, 0.45833333333333
17276, 1.2833333333333, 1.7, 0.45833333333333
17277, 1.325, 1.7, 0.45833333333333
17278, 1.3666666666667, 1.7, 0.45833333333333
17279, 1.4083333333333, 1.7, 0.45833333333333
17280, 1.45, 1.7, 0.45833333333333
17281, 1.4916666666667, 1.7, 0.45833333333333
17282, 1.5333333333333, 1.7, 0.45833333333333
17283, 1.575, 1.7, 0.45833333333333
17284, 1.6166666666667, 1.7, 0.45833333333333
17285, 1.6583333333333, 1.7, 0.45833333333333
17286, 1.7, 1.7, 0.45833333333333
17287, 1.7416666666667, 1.7, 0.45833333333333
17288, 1.7833333333333, 1.7, 0.45833333333333
17289, 1.825, 1.7, 0.45833333333333
17290, 1.8666666666667, 1.7, 0.45833333333333
17291, 1.9083333333333, 1.7, 0.45833333333333
17292, 1.95, 1.7, 0.45833333333333
17293, 1.9916666666667, 1.7, 0.45833333333333
17294, 2.0333333333333, 1.7, 0.45833333333333
17295, 2.075, 1.7, 0.45833333333333
17296, 2.1166666666667, 1.7, 0.45833333333333
17297, 2.1583333333333, 1.7, 0.45833333333333
17298, 0.041666666666667, -0.04, 0
17299, 0.041666666666667, -0.08, 0
17300, 0.041666666666667, -0.12, 0
17301, 0.041666666666667, -0.16, 0
17302, 0.083333333333333, -0.04, 0
17303, 0.083333333333333, -0.08, 0
17304, 0.083333333333333, -0.12, 0
17305, 0.083333333333333, -0.16, 0
17306, 0.125, -0.04, 0
17307, 0.125, -0.08, 0
17308, 0.125, -0.12, 0
17309, 0.125, -0.16, 0
17310, 0.16666666666667, -0.04, 0
17311, 0.16666666666667, -0.08, 0
17312, 0.16666666666667, -0.12, 0
17313, 0.16666666666667, -0.16, 0
17314, 0.20833333333333, -0.04, 0
17315, 0.20833333333333, -0.08, 0
17316, 0.20833333333333, -0.12, 0
17317, 0.20833333333333, -0.16, 0
17318, 0.25, -0.04, 0
17319, 0.25, -0.08, 0
17320, 0.25, -0.12, 0
17321, 0.25, -0.16, 0
17322, 0.29166666666667, -0.04, 0
17323, 0.29166666666667, -0.08, 0
17324, 0.29166666666667, -0.12, 0
17325, 0.29166666666667, -0.16, 0
17326, 0.33333333333333, -0.04, 0
17327, 0.33333333333333, -0.08, 0
17328, 0.33333333333333, -0.12, 0
17329, 0.33333333333333, -0.16, 0
17330, 0.375, -0.04, 0
17331, 0.375, -0.08, 0
17332, 0.375, -0.12, 0
17333, 0.375, -0.16, 0
17334, 0.41666666666667, -0.04, 0
17335, 0.41666666666667, -0.08, 0
17336, 0.41666666666667, -0.12, 0
17337, 0.41666666666667, -0.16, 0
17338, 0.45833333333333, -0.04, 0
17339, 0.45833333333333, -0.08, 0
17340, 0.45833333333333, -0.12, 0
17341, 0.45833333333333, -0.16, 0
17342, 0.5, -0.04, 0
17343, 0.5, -0.08, 0
17344, 0.5, -0.12, 0
17345, 0.5, -0.16, 0
17346, 0.54166666666667, -0.04, 0
17347, 0.54166666666667, -0.08, 0
17348, 0.54166666666667, -0.12, 0
17349, 0.54166666666667, -0.16, 0
17350, 0.58333333333333, -0.04, 0
17351, 0.58333333333333, -0.08, 0
17352, 0.58333333333333, -0.12, 0
17353, 0.58333333333333, -0.16, 0
17354, 0.625, -0.04, 0
17355, 0.625, -0.08, 0
17356, 0.625, -0.12, 0
17357, 0.625, -0.16, 0
17358, 0.66666666666667, -0.04, 0
17359, 0.66666666666667, -0.08, 0
17360, 0.66666666666667, -0.12, 0
17361, 0.66666666666667, -0.16, 0
17362, 0.70833333333333, -0.04, 0
17363, 0.70833333333333, -0.08, 0
17364, 0.70833333333333, -0.12, 0
17365, 0.70833333333333, -0.16, 0
17366, 0.75, -0.04, 0
17367, 0.75, -0.08, 0
17368, 0.75, -0.12, 0
17369, 0.75, -0.16, 0
17370, 0.79166666666667, -0.04, 0
17371, 0.79166666666667, -0.08, 0
17372, 0.79166666666667, -0.12, 0
17373, 0.79166666666667, -0.16, 0
17374, 0.83333333333333, -0.04, 0
17375, 0.83333333333333, -0.08, 0
17376, 0.83333333333333, -0.12, 0
17377, 0.83333333333333, -0.16, 0
17378, 0.875, -0.04, 0
17379, 0.875, -0.08, 0
17380, 0.875, -0.12, 0
17381, 0.875, -0.16, 0
17382, 0.91666666666667, -0.04, 0
17383, 0.91666666666667, -0.08, 0
17384, 0.91666666666667, -0.12, 0
17385, 0.91666666666667, -0.16, 0
17386, 0.95833333333333, -0.04, 0
17387, 0.95833333333333, -0.08, 0
17388, 0.95833333333333, -0.12, 0
17389, 0.95833333333333, -0.16, 0
17390, 0.041666666666667, -0.02, 0
17391, 0.020833333333333, -0.04, 0
17392, 0.041666666666667, -0.06, 0
17393, 0.020833333333333, -0.08, 0
17394, 0.041666666666667, -0.1, 0
17395, 0.020833333333333, -0.12, 0
17396, 0.041666666666667, -0.14, 0
17397, 0.020833333333333, -0.16, 0
17398, 0.041666666666667, -0.18, 0
17399, 0.083333333333333, -0.02, 0
17400, 0.0625, -0.04, 0
17401, 0.083333333333333, -0.06, 0
17402, 0.0625, -0.08, 0
17403, 0.083333333333333, -0.1, 0
17404, 0.0625, -0.12, 0
17405, 0.083333333333333, -0.14, 0
17406, 0.0625, -0.16, 0
17407, 0.083333333333333, -0.18, 0
17408, 0.125, -0.02, 0
17409, 0.10416666666667, -0.04, 0
17410, 0.125, -0.06, 0
17411, 0.10416666666667, -0.08, 0
17412, 0.125, -0.1, 0
17413, 0.10416666666667, -0.12, 0
17414, 0.125, -0.14, 0
17415, 0.10416666666667, -0.16, 0
17416, 0.125, -0.18, 0
17417, 0.16666666666667, -0.02, 0
17418, 0.14583333333333, -0.04, 0
17419, 0.16666666666667, -0.06, 0
17420, 0.14583333333333, -0.08, 0
17421, 0.16666666666667, -0.1, 0
17422, 0.14583333333333, -0.12, 0
17423, 0.16666666666667, -0.14, 0
17424, 0.14583333333333, -0.16, 0
17425, 0.16666666666667, -0.18, 0
17426, 0.20833333333333, -0.02, 0
17427, 0.1875, -0.04, 0
17428, 0.20833333333333, -0.06, 0
17429, 0.1875, -0.08, 0
17430, 0.20833333333333, -0.1, 0
17431, 0.1875, -0.12, 0
17432, 0.20833333333333, -0.14, 0
17433, 0.1875, -0.16, 0
17434, 0.20833333333333, -0.18, 0
17435, 0.25, -0.02, 0
17436, 0.22916666666667, -0.04, 0
17437, 0.25, -0.06, 0
17438, 0.22916666666667, -0.08, 0
17439, 0.25, -0.1, 0
17440, 0.22916666666667, -0.12, 0
17441, 0.25, -0.14, 0
17442, 0.22916666666667, -0.16, 0
17443, 0.25, -0.18, 0
17444, 0.29166666666667, -0.02, 0
17445, 0.27083333333333, -0.04, 0
17446, 0.29166666666667, -0.06, 0
17447, 0.27083333333333, -0.08, 0
17448, 0.29166666666667, -0.1, 0
17449, 0.27083333333333, -0.12, 0
17450, 0.29166666666667, -0.14, 0
17451, 0.27083333333333, -0.16, 0
17452, 0.29166666666667, -0.18, 0
17453, 0.33333333333333, -0.02, 0
17454, 0.3125, -0.04, 0
17455, 0.33333333333333, -0.06, 0
17456, 0.3125, -0.08, 0
17457, 0.33333333333333, -0.1, 0
17458, 0.3125, -0.12, 0
17459, 0.33333333333333, -0.14, 0
17460, 0.3125, -0.16, 0
17461, 0.33333333333333, -0.18, 0
17462, 0.375, -0.02, 0
17463, 0.35416666666667, -0.04, 0
17464, 0.375, -0.06, 0
17465, 0.35416666666667, -0.08, 0
17466, 0.375, -0.1, 0
17467, 0.35416666666667, -0.12, 0
17468, 0.375, -0.14, 0
17469, 0.35416666666667, -0.16, 0
17470, 0.375, -0.18, 0
17471, 0.41666666666667, -0.02, 0
17472, 0.39583333333333, -0.04, 0
17473, 0.41666666666667, -0.06, 0
17474, 0.39583333333333, -0.08, 0
17475, 0.41666666666667, -0.1, 0
17476, 0.39583333333333, -0.12, 0
17477, 0.41666666666667, -0.14, 0
17478, 0.39583333333333, -0.16, 0
17479, 0.41666666666667, -0.18, 0
17480, 0.45833333333333, -0.02, 0
17481, 0.4375, -0.04, 0
17482, 0.45833333333333, -0.06, 0
17483, 0.4375, -0.08, 0
17484, 0.45833333333333, -0.1, 0
17485, 0.4375, -0.12, 0
17486, 0.45833333333333, -0.14, 0
17487, 0.4375, -0.16, 0
17488, 0.45833333333333, -0.18, 0
17489, 0.5, -0.02, 0
17490, 0.47916666666667, -0.04, 0
17491, 0.5, -0.06, 0
17492, 0.47916666666667, -0.08, 0
17493, 0.5, -0.1, 0
17494, 0.47916666666667, -0.12, 0
17495, 0.5, -0.14, 0
17496, 0.47916666666667, -0.16, 0
17497, 0.5, -0.18, 0
17498, 0.54166666666667, -0.02, 0
17499, 0.52083333333333, -0.04, 0
17500, 0.54166666666667, -0.06, 0
17501, 0.52083333333333, -0.08, 0
17502, 0.54166666666667, -0.1, 0
17503, 0.52083333333333, -0.12, 0
17504, 0.54166666666667, -0.14, 0
17505, 0.52083333333333, -0.16, 0
17506, 0.54166666666667, -0.18, 0
17507, 0.58333333333333, -0.02, 0
17508, 0.5625, -0.04, 0
17509, 0.58333333333333, -0.06, 0
17510, 0.5625, -0.08, 0
17511, 0.58333333333333, -0.1, 0
17512, 0.5625, -0.12, 0
17513, 0.58333333333333, -0.14, 0
17514, 0.5625, -0.16, 0
17515, 0.58333333333333, -0.18, 0
17516, 0.625, -0.02, 0
17517, 0.60416666666667, -0.04, 0
17518, 0.625, -0.06, 0
17519, 0.60416666666667, -0.08, 0
17520, 0.625, -0.1, 0
17521, 0.60416666666667, -0.12, 0
17522, 0.625, -0.14, 0
17523, 0.60416666666667, -0.16, 0
17524, 0.625, -0.18, 0
17525, 0.66666666666667, -0.02, 0
17526, 0.64583333333333, -0.04, 0
17527, 0.66666666666667, -0.06, 0
17528, 0.64583333333333, -0.08, 0
17529, 0.66666666666667, -0.1, 0
17530, 0.64583333333333, -0.12, 0
17531, 0.66666666666667, -0.14, 0
17532, 0.64583333333333, -0.16, 0
17533, 0.66666666666667, -0.18, 0
17534, 0.70833333333333, -0.02, 0
17535, 0.6875, -0.04, 0
17536, 0.70833333333333, -0.06, 0
17537, 0.6875, -0.08, 0
17538, 0.70833333333333, -0.1, 0
17539, 0.6875, -0.12, 0
17540, 0.70833333333333, -0.14, 0
17541, 0.6875, -0.16, 0
17542, 0.70833333333333, -0.18, 0
17543, 0.75, -0.02, 0
17544, 0.72916666666667, -0.04, 0
17545, 0.75, -0.06, 0
17546, 0.72916666666667, -0.08, 0
17547, 0.75, -0.1, 0
17548, 0.72916666666667, -0.12, 0
17549, 0.75, -0.14, 0
17550, 0.72916666666667, -0.16, 0
17551, 0.75, -0.18, 0
17552, 0.79166666666667, -0.02, 0
17553, 0.77083333333333, -0.04, 0
17554, 0.79166666666667, -0.06, 0
17555, 0.77083333333333, -0.08, 0
17556, 0.79166666666667, -0.1, 0
17557, 0.77083333333333, -0.12, 0
17558, 0.79166666666667, -0.14, 0
17559, 0.77083333333333, -0.16, 0
17560, 0.79166666666667, -0.18, 0
17561, 0.83333333333333, -0.02, 0
17562, 0.8125, -0.04, 0
17563, 0.83333333333333, -0.06, 0
17564, 0.8125, -0.08, 0
17565, 0.83333333333333, -0.1, 0
17566, 0.8125, -0.12, 0
17567, 0.83333333333333, -0.14, 0
17568, 0.8125, -0.16, 0
17569, 0.83333333333333, -0.18, 0
17570, 0.875, -0.02, 0
17571, 0.85416666666667, -0.04, 0
17572, 0.875, -0.06, 0
17573, 0.85416666666667, -0.08, 0
17574, 0.875, -0.1, 0
17575, 0.85416666666667, -0.12, 0
17576, 0.875, -0.14, 0
17577, 0.85416666666667, -0.16, 0
17578, 0.875, -0.18, 0
17579, 0.91666666666667, -0.02, 0
17580, 0.89583333333333, -0.04, 0
17581, 0.91666666666667, -0.06, 0
17582, 0.89583333333333, -0.08, 0
17583, 0.91666666666667, -0.1, 0
17584, 0.89583333333333, -0.12, 0
17585, 0.91666666666667, -0.14, 0
17586, 0.89583333333333, -0.16, 0
17587, 0.91666666666667, -0.18, 0
17588, 0.95833333333333, -0.02, 0
17589, 0.9375, -0.04, 0
17590, 0.95833333333333, -0.06, 0
17591, 0.9375, -0.08, 0
17592, 0.95833333333333, -0.1, 0
17593, 0.9375, -0.12, 0
17594, 0.95833333333333, -0.14, 0
17595, 0.9375, -0.16, 0
17596, 0.95833333333333, -0.18, 0
17597, 0.97916666666667, -0.04, 0
17598, 0.97916666666667, -0.08, 0
17599, 0.97916666666667, -0.12, 0
17600, 0.97916666666667, -0.16, 0
17601, 1, -0.04, 0.041666666666667
17602, 1, -0.08, 0.041666666666667
17603, 1, -0.12, 0.041666666666667
17604, 1, -0.16, 0.041666666666667
17605, 1, -0.04, 0.083333333333333
17606, 1, -0.08, 0.083333333333333
17607, 1, -0.12, 0.083333333333333
17608, 1, -0.16, 0.083333333333333
17609, 1, -0.04, 0.125
17610, 1, -0.08, 0.125
17611, 1, -0.12, 0.125
17612, 1, -0.16, 0.125
17613, 1, -0.04, 0.16666666666667
17614, 1, -0.08, 0.16666666666667
17615, 1, -0.12, 0.16666666666667
17616, 1, -0.16, 0.16666666666667
17617, 1, -0.04, 0.20833333333333
17618, 1, -0.08, 0.20833333333333
17619, 1, -0.12, 0.20833333333333
17620, 1, -0.16, 0.20833333333333
17621, 1, -0.04, 0.25
17622, 1, -0.08, 0.25
17623, 1, -0.12, 0.25
17624, 1, -0.16, 0.25
17625, 1, -0.04, 0.29166666666667
17626, 1, -0.08, 0.29166666666667
17627, 1, -0.12, 0.29166666666667
17628, 1, -0.16, 0.29166666666667
17629, 1, -0.04, 0.33333333333333
17630, 1, -0.08, 0.33333333333333
17631, 1, -0.12, 0.33333333333333
17632, 1, -0.16, 0.33333333333333
17633, 1, -0.04, 0.375
17634, 1, -0.08, 0.375
17635, 1, -0.12, 0.375
17636, 1, -0.16, 0.375
17637, 1, -0.04, 0.41666666666667
17638, 1, -0.08, 0.41666666666667
17639, 1, -0.12, 0.41666666666667
17640, 1, -0.16, 0.41666666666667
17641, 1, -0.04, 0.45833333333333
17642, 1, -0.08, 0.45833333333333
17643, 1, -0.12, 0.45833333333333
17644, 1, -0.16, 0.45833333333333
17645, 1, -0.02, 0.041666666666667
17646, 1, -0.04, 0.020833333333333
17647, 1, -0.06, 0.041666666666667
17648, 1, -0.08, 0.020833333333333
17649, 1, -0.1, 0.041666666666667
17650, 1, -0.12, 0.020833333333333
17651, 1, -0.14, 0.041666666666667
17652, 1, -0.16, 0.020833333333333
17653, 1, -0.18, 0.041666666666667
17654, 1, -0.02, 0.083333333333333
17655, 1, -0.04, 0.0625
17656, 1, -0.06, 0.083333333333333
17657, 1, -0.08, 0.0625
17658, 1, -0.1, 0.083333333333333
17659, 1, -0.12, 0.0625
17660, 1, -0.14, 0.083333333333333
17661, 1, -0.16, 0.0625
17662, 1, -0.18, 0.083333333333333
17663, 1, -0.02, 0.125
17664, 1, -0.04, 0.10416666666667
17665, 1, -0.06, 0.125
17666, 1, -0.08, 0.10416666666667
17667, 1, -0.1, 0.125
17668, 1, -0.12, 0.10416666666667
17669, 1, -0.14, 0.125
17670, 1, -0.16, 0.10416666666667
17671, 1, -0.18, 0.125
17672, 1, -0.02, 0.16666666666667
17673, 1, -0.04, 0.14583333333333
17674, 1, -0.06, 0.16666666666667
17675, 1, -0.08, 0.14583333333333
17676, 1, -0.1, 0.16666666666667
17677, 1, -0.12, 0.14583333333333
17678, 1, -0.14, 0.16666666666667
17679, 1, -0.16, 0.14583333333333
17680, 1, -0.18, 0.16666666666667
17681, 1, -0.02, 0.20833333333333
17682, 1, -0.04, 0.1875
17683, 1, -0.06, 0.20833333333333
17684, 1, -0.08, 0.1875
17685, 1, -0.1, 0.20833333333333
17686, 1, -0.12, 0.1875
17687, 1, -0.14, 0.20833333333333
17688, 1, -0.16, 0.1875
17689, 1, -0.18, 0.20833333333333
17690, 1, -0.02, 0.25
17691, 1, -0.04, 0.22916666666667
17692, 1, -0.06, 0.25
17693, 1, -0.08, 0.22916666666667
17694, 1, -0.1, 0.25
17695, 1, -0.12, 0.22916666666667
17696, 1, -0.14, 0.25
17697, 1, -0.16, 0.22916666666667
17698, 1, -0.18, 0.25
17699, 1, -0.02, 0.29166666666667
17700, 1, -0.04, 0.27083333333333
17701, 1, -0.06, 0.29166666666667
17702, 1, -0.08, 0.27083333333333
17703, 1, -0.1, 0.29166666666667
17704, 1, -0.12, 0.27083333333333
17705, 1, -0.14, 0.29166666666667
17706, 1, -0.16, 0.27083333333333
17707, 1, -0.18, 0.29166666666667
17708, 1, -0.02, 0.33333333333333
17709, 1, -0.04, 0.3125
17710, 1, -0.06, 0.33333333333333
17711, 1, -0.08, 0.3125
17712, 1, -0.1, 0.33333333333333
17713, 1, -0.12, 0.3125
17714, 1, -0.14, 0.33333333333333
17715, 1, -0.16, 0.3125
17716, 1, -0.18, 0.33333333333333
17717, 1, -0.02, 0.375
17718, 1, -0.04, 0.35416666666667
17719, 1, -0.06, 0.375
17720, 1, -0.08, 0.35416666666667
17721, 1, -0.1, 0.375
17722, 1, -0.12, 0.35416666666667
17723, 1, -0.14, 0.375
17724, 1, -0.16, 0.35416666666667
17725, 1, -0.18, 0.375
17726, 1, -0.02, 0.41666666666667
17727, 1, -0.04, 0.39583333333333
17728, 1, -0.06, 0.41666666666667
17729, 1, -0.08, 0.39583333333333
17730, 1, -0.1, 0.41666666666667
17731, 1, -0.12, 0.39583333333333
17732, 1, -0.14, 0.41666666666667
17733, 1, -0.16, 0.39583333333333
17734, 1, -0.18, 0.41666666666667
17735, 1, -0.02, 0.45833333333333
17736, 1, -0.04, 0.4375
17737, 1, -0.06, 0.45833333333333
17738, 1, -0.08, 0.4375
17739, 1, -0.1, 0.45833333333333
17740, 1, -0.12, 0.4375
17741, 1, -0.14, 0.45833333333333
17742, 1, -0.16, 0.4375
17743, 1, -0.18, 0.45833333333333
17744, 1, -0.04, 0.47916666666667
17745, 1, -0.08, 0.47916666666667
17746, 1, -0.12, 0.47916666666667
17747, 1, -0.16, 0.47916666666667
17748, 0.041666666666667, -0.04, 0.5
17749, 0.041666666666667, -0.08, 0.5
17750, 0.041666666666667, -0.12, 0.5
17751, 0.041666666666667, -0.16, 0.5
17752, 0.083333333333333, -0.04, 0.5
17753, 0.083333333333333, -0.08, 0.5
17754, 0.083333333333333, -0.12, 0.5
17755, 0.083333333333333, -0.16, 0.5
17756, 0.125, -0.04, 0.5
17757, 0.125, -0.08, 0.5
17758, 0.125, -0.12, 0.5
17759, 0.125, -0.16, 0.5
17760, 0.16666666666667, -0.04, 0.5
17761, 0.16666666666667, -0.08, 0.5
17762, 0.16666666666667, -0.12, 0.5
17763, 0.16666666666667, -0.16, 0.5
17764, 0.20833333333333, -0.04, 0.5
17765, 0.20833333333333, -0.08, 0.5
17766, 0.20833333333333, -0.12, 0.5
17767, 0.20833333333333, -0.16, 0.5
17768, 0.25, -0.04, 0.5
17769, 0.25, -0.08, 0.5
17770, 0.25, -0.12, 0.5
17771, 0.25, -0.16, 0.5
17772, 0.29166666666667, -0.04, 0.5
17773, 0.29166666666667, -0.08, 0.5
17774, 0.29166666666667, -0.12, 0.5
17775, 0.29166666666667, -0.16, 0.5
17776, 0.33333333333333, -0.04, 0.5
17777, 0.33333333333333, -0.08, 0.5
17778, 0.33333333333333, -0.12, 0.5
17779, 0.33333333333333, -0.16, 0.5
17780, 0.375, -0.04, 0.5
17781, 0.375, -0.08, 0.5
17782, 0.375, -0.12, 0.5
17783, 0.375, -0.16, 0.5
17784, 0.41666666666667, -0.04, 0.5
17785, 0.41666666666667, -0.08, 0.5
17786, 0.41666666666667, -0.12, 0.5
17787, 0.41666666666667, -0.16, 0.5
17788, 0.45833333333333, -0.04, 0.5
17789, 0.45833333333333, -0.08, 0.5
17790, 0.45833333333333, -0.12, 0.5
17791, 0.45833333333333, -0.16, 0.5
17792, 0.5, -0.04, 0.5
17793, 0.5, -0.08, 0.5
17794, 0.5, -0.12, 0.5
17795, 0.5, -0.16, 0.5
17796, 0.54166666666667, -0.04, 0.5
17797, 0.54166666666667, -0.08, 0.5
17798, 0.54166666666667, -0.12, 0.5
17799, 0.54166666666667, -0.16, 0.5
17800, 0.58333333333333, -0.04, 0.5
17801, 0.58333333333333, -0.08, 0.5
17802, 0.58333333333333, -0.12, 0.5
17803, 0.58333333333333, -0.16, 0.5
17804, 0.625, -0.04, 0.5
17805, 0.625, -0.08, 0.5
17806, 0.625, -0.12, 0.5
17807, 0.625, -0.16, 0.5
17808, 0.66666666666667, -0.04, 0.5
17809, 0.66666666666667, -0.08, 0.5
17810, 0.66666666666667, -0.12, 0.5
17811, 0.66666666666667, -0.16, 0.5
17812, 0.70833333333333, -0.04, 0.5
17813, 0.70833333333333, -0.08, 0.5
17814, 0.70833333333333, -0.12, 0.5
17815, 0.70833333333333, -0.16, 0.5
17816, 0.75, -0.04, 0.5
17817, 0.75, -0.08, 0.5
17818, 0.75, -0.12, 0.5
17819, 0.75, -0.16, 0.5
17820, 0.79166666666667, -0.04, 0.5
17821, 0.79166666666667, -0.08, 0.5
17822, 0.79166666666667, -0.12, 0.5
17823, 0.79166666666667, -0.16, 0.5
17824, 0.83333333333333, -0.04, 0.5
17825, 0.83333333333333, -0.08, 0.5
17826, 0.83333333333333, -0.12, 0.5
17827, 0.83333333333333, -0.16, 0.5
17828, 0.875, -0.04, 0.5
17829, 0.875, -0.08, 0.5
17830, 0.875, -0.12, 0.5
17831, 0.875, -0.16, 0.5
17832, 0.91666666666667, -0.04, 0.5
17833, 0.91666666666667, -0.08, 0.5
17834, 0.91666666666667, -0.12, 0.5
17835, 0.91666666666667, -0.16, 0.5
17836, 0.95833333333333, -0.04, 0.5
17837, 0.95833333333333, -0.08, 0.5
17838, 0.95833333333333, -0.12, 0.5
17839, 0.95833333333333, -0.16, 0.5
17840, 0, -0.04, 0.041666666666667
17841, 0, -0.08, 0.041666666666667
17842, 0, -0.12, 0.041666666666667
17843, 0, -0.16, 0.041666666666667
17844, 0, -0.04, 0.083333333333333
17845, 0, -0.08, 0.083333333333333
17846, 0, -0.12, 0.083333333333333
17847, 0, -0.16, 0.083333333333333
17848, 0, -0.04, 0.125
17849, 0, -0.08, 0.125
17850, 0, -0.12, 0.125
17851, 0, -0.16, 0.125
17852, 0, -0.04, 0.16666666666667
17853, 0, -0.08, 0.16666666666667
17854, 0, -0.12, 0.16666666666667
17855, 0, -0.16, 0.16666666666667
17856, 0, -0.04, 0.20833333333333
17857, 0, -0.08, 0.20833333333333
17858, 0, -0.12, 0.20833333333333
17859, 0, -0.16, 0.20833333333333
17860, 0, -0.04, 0.25
17861, 0, -0.08, 0.25
17862, 0, -0.12, 0.25
17863, 0, -0.16, 0.25
17864, 0, -0.04, 0.29166666666667
17865, 0, -0.08, 0.29166666666667
17866, 0, -0.12, 0.29166666666667
17867, 0, -0.16, 0.29166666666667
17868, 0, -0.04, 0.33333333333333
17869, 0, -0.08, 0.33333333333333
17870, 0, -0.12, 0.33333333333333
17871, 0, -0.16, 0.33333333333333
17872, 0, -0.04, 0.375
17873, 0, -0.08, 0.375
17874, 0, -0.12, 0.375
17875, 0, -0.16, 0.375
17876, 0, -0.04, 0.41666666666667
17877, 0, -0.08, 0.41666666666667
17878, 0, -0.12, 0.41666666666667
17879, 0, -0.16, 0.41666666666667
17880, 0, -0.04, 0.45833333333333
17881, 0, -0.08, 0.45833333333333
17882, 0, -0.12, 0.45833333333333
17883, 0, -0.16, 0.45833333333333
17884, 0, -0.04, 0.020833333333333
17885, 0, -0.02, 0.041666666666667
17886, 0, -0.08, 0.020833333333333
17887, 0, -0.06, 0.041666666666667
17888, 0, -0.12, 0.020833333333333
17889, 0, -0.1, 0.041666666666667
17890, 0, -0.16, 0.020833333333333
17891, 0, -0.14, 0.041666666666667
17892, 0, -0.18, 0.041666666666667
17893, 0, -0.04, 0.0625
17894, 0, -0.02, 0.083333333333333
17895, 0, -0.08, 0.0625
17896, 0, -0.06, 0.083333333333333
17897, 0, -0.12, 0.0625
17898, 0, -0.1, 0.083333333333333
17899, 0, -0.16, 0.0625
17900, 0, -0.14, 0.083333333333333
17901, 0, -0.18, 0.083333333333333
17902, 0, -0.04, 0.10416666666667
17903, 0, -0.02, 0.125
17904, 0, -0.08, 0.10416666666667
17905, 0, -0.06, 0.125
17906, 0, -0.12, 0.10416666666667
17907, 0, -0.1, 0.125
17908, 0, -0.16, 0.10416666666667
17909, 0, -0.14, 0.125
17910, 0, -0.18, 0.125
17911, 0, -0.04, 0.14583333333333
17912, 0, -0.02, 0.16666666666667
17913, 0, -0.08, 0.14583333333333
17914, 0, -0.06, 0.16666666666667
17915, 0, -0.12, 0.14583333333333
17916, 0, -0.1, 0.16666666666667
17917, 0, -0.16, 0.14583333333333
17918, 0, -0.14, 0.16666666666667
17919, 0, -0.18, 0.16666666666667
17920, 0, -0.04, 0.1875
17921, 0, -0.02, 0.20833333333333
17922, 0, -0.08, 0.1875
17923, 0, -0.06, 0.20833333333333
17924, 0, -0.12, 0.1875
17925, 0, -0.1, 0.20833333333333
17926, 0, -0.16, 0.1875
17927, 0, -0.14, 0.20833333333333
17928, 0, -0.18, 0.20833333333333
17929, 0, -0.04, 0.22916666666667
17930, 0, -0.02, 0.25
17931, 0, -0.08, 0.22916666666667
17932, 0, -0.06, 0.25
17933, 0, -0.12, 0.22916666666667
17934, 0, -0.1, 0.25
17935, 0, -0.16, 0.22916666666667
17936, 0, -0.14, 0.25
17937, 0, -0.18, 0.25
17938, 0, -0.04, 0.27083333333333
17939, 0, -0.02, 0.29166666666667
17940, 0, -0.08, 0.27083333333333
17941, 0, -0.06, 0.29166666666667
17942, 0, -0.12, 0.27083333333333
17943, 0, -0.1, 0.29166666666667
17944, 0, -0.16, 0.27083333333333
17945, 0, -0.14, 0.29166666666667
17946, 0, -0.18, 0.29166666666667
17947, 0, -0.04, 0.3125
17948, 0, -0.02, 0.33333333333333
17949, 0, -0.08, 0.3125
17950, 0, -0.06, 0.33333333333333
17951, 0, -0.12, 0.3125
17952, 0, -0.1, 0.33333333333333
17953, 0, -0.16, 0.3125
17954, 0, -0.14, 0.33333333333333
17955, 0, -0.18, 0.33333333333333
17956, 0, -0.04, 0.35416666666667
17957, 0, -0.02, 0.375
17958, 0, -0.08, 0.35416666666667
17959, 0, -0.06, 0.375
17960, 0, -0.12, 0.35416666666667
17961, 0, -0.1, 0.375
17962, 0, -0.16, 0.35416666666667
17963, 0, -0.14, 0.375
17964, 0, -0.18, 0.375
17965, 0, -0.04, 0.39583333333333
17966, 0, -0.02, 0.41666666666667
17967, 0, -0.08, 0.39583333333333
17968, 0, -0.06, 0.41666666666667
17969, 0, -0.12, 0.39583333333333
17970, 0, -0.1, 0.41666666666667
17971, 0, -0.16, 0.39583333333333
17972, 0, -0.14, 0.41666666666667
17973, 0, -0.18, 0.41666666666667
17974, 0, -0.04, 0.4375
17975, 0, -0.02, 0.45833333333333
17976, 0, -0.08, 0.4375
17977, 0, -0.06, 0.45833333333333
17978, 0, -0.12, 0.4375
17979, 0, -0.1, 0.45833333333333
17980, 0, -0.16, 0.4375
17981, 0, -0.14, 0.45833333333333
17982, 0, -0.18, 0.45833333333333
17983, 0, -0.04, 0.47916666666667
17984, 0, -0.08, 0.47916666666667
17985, 0, -0.12, 0.47916666666667
17986, 0, -0.16, 0.47916666666667
17987, 0.041666666666667, -0.2, 0.041666666666667
17988, 0.041666666666667, -0.2, 0.083333333333333
17989, 0.041666666666667, -0.2, 0.125
17990, 0.041666666666667, -0.2, 0.16666666666667
17991, 0.041666666666667, -0.2, 0.20833333333333
17992, 0.041666666666667, -0.2, 0.25
17993, 0.041666666666667, -0.2, 0.29166666666667
17994, 0.041666666666667, -0.2, 0.33333333333333
17995, 0.041666666666667, -0.2, 0.375
17996, 0.041666666666667, -0.2, 0.41666666666667
17997, 0.041666666666667, -0.2, 0.45833333333333
17998, 0.083333333333333, -0.2, 0.041666666666667
17999, 0.083333333333333, -0.2, 0.083333333333333
18000, 0.083333333333333, -0.2, 0.125
18001, 0.083333333333333, -0.2, 0.16666666666667
18002, 0.083333333333333, -0.2, 0.20833333333333
18003, 0.083333333333333, -0.2, 0.25
18004, 0.083333333333333, -0.2, 0.29166666666667
18005, 0.083333333333333, -0.2, 0.33333333333333
18006, 0.083333333333333, -0.2, 0.375
18007, 0.083333333333333, -0.2, 0.41666666666667
18008, 0.083333333333333, -0.2, 0.45833333333333
18009, 0.125, -0.2, 0.041666666666667
18010, 0.125, -0.2, 0.083333333333333
18011, 0.125, -0.2, 0.125
18012, 0.125, -0.2, 0.16666666666667
18013, 0.125, -0.2, 0.20833333333333
18014, 0.125, -0.2, 0.25
18015, 0.125, -0.2, 0.29166666666667
18016, 0.125, -0.2, 0.33333333333333
18017, 0.125, -0.2, 0.375
18018, 0.125, -0.2, 0.41666666666667
18019, 0.125, -0.2, 0.45833333333333
18020, 0.16666666666667, -0.2, 0.041666666666667
18021, 0.16666666666667, -0.2, 0.083333333333333
18022, 0.16666666666667, -0.2, 0.125
18023, 0.16666666666667, -0.2, 0.16666666666667
18024, 0.16666666666667, -0.2, 0.20833333333333
18025, 0.16666666666667, -0.2, 0.25
18026, 0.16666666666667, -0.2, 0.29166666666667
18027, 0.16666666666667, -0.2, 0.33333333333333
18028, 0.16666666666667, -0.2, 0.375
18029, 0.16666666666667, -0.2, 0.41666666666667
18030, 0.16666666666667, -0.2, 0.45833333333333
18031, 0.20833333333333, -0.2, 0.041666666666667
18032, 0.20833333333333, -0.2, 0.083333333333333
18033, 0.20833333333333, -0.2, 0.125
18034, 0.20833333333333, -0.2, 0.16666666666667
18035, 0.20833333333333, -0.2, 0.20833333333333
18036, 0.20833333333333, -0.2, 0.25
18037, 0.20833333333333, -0.2, 0.29166666666667
18038, 0.20833333333333, -0.2, 0.33333333333333
18039, 0.20833333333333, -0.2, 0.375
18040, 0.20833333333333, -0.2, 0.41666666666667
18041, 0.20833333333333, -0.2, 0.45833333333333
18042, 0.25, -0.2, 0.041666666666667
18043, 0.25, -0.2, 0.083333333333333
18044, 0.25, -0.2, 0.125
18045, 0.25, -0.2, 0.16666666666667
18046, 0.25, -0.2, 0.20833333333333
18047, 0.25, -0.2, 0.25
18048, 0.25, -0.2, 0.29166666666667
18049, 0.25, -0.2, 0.33333333333333
18050, 0.25, -0.2, 0.375
18051, 0.25, -0.2, 0.41666666666667
18052, 0.25, -0.2, 0.45833333333333
18053, 0.29166666666667, -0.2, 0.041666666666667
18054, 0.29166666666667, -0.2, 0.083333333333333
18055, 0.29166666666667, -0.2, 0.125
18056, 0.29166666666667, -0.2, 0.16666666666667
18057, 0.29166666666667, -0.2, 0.20833333333333
18058, 0.29166666666667, -0.2, 0.25
18059, 0.29166666666667, -0.2, 0.29166666666667
18060, 0.29166666666667, -0.2, 0.33333333333333
18061, 0.29166666666667, -0.2, 0.375
18062, 0.29166666666667, -0.2, 0.41666666666667
18063, 0.29166666666667, -0.2, 0.45833333333333
18064, 0.33333333333333, -0.2, 0.041666666666667
18065, 0.33333333333333, -0.2, 0.083333333333333
18066, 0.33333333333333, -0.2, 0.125
18067, 0.33333333333333, -0.2, 0.16666666666667
18068, 0.33333333333333, -0.2, 0.20833333333333
18069, 0.33333333333333, -0.2, 0.25
18070, 0.33333333333333, -0.2, 0.29166666666667
18071, 0.33333333333333, -0.2, 0.33333333333333
18072, 0.33333333333333, -0.2, 0.375
18073, 0.33333333333333, -0.2, 0.41666666666667
18074, 0.33333333333333, -0.2, 0.45833333333333
18075, 0.375, -0.2, 0.041666666666667
18076, 0.375, -0.2, 0.083333333333333
18077, 0.375, -0.2, 0.125
18078, 0.375, -0.2, 0.16666666666667
18079, 0.375, -0.2, 0.20833333333333
18080, 0.375, -0.2, 0.25
18081, 0.375, -0.2, 0.29166666666667
18082, 0.375, -0.2, 0.33333333333333
18083, 0.375, -0.2, 0.375
18084, 0.375, -0.2, 0.41666666666667
18085, 0.375, -0.2, 0.45833333333333
18086, 0.41666666666667, -0.2, 0.041666666666667
18087, 0.41666666666667, -0.2, 0.083333333333333
18088, 0.41666666666667, -0.2, 0.125
18089, 0.41666666666667, -0.2, 0.16666666666667
18090, 0.41666666666667, -0.2, 0.20833333333333
18091, 0.41666666666667, -0.2, 0.25
18092, 0.41666666666667, -0.2, 0.29166666666667
18093, 0.41666666666667, -0.2, 0.33333333333333
18094, 0.41666666666667, -0.2, 0.375
18095, 0.41666666666667, -0.2, 0.41666666666667
18096, 0.41666666666667, -0.2, 0.45833333333333
18097, 0.45833333333333, -0.2, 0.041666666666667
18098, 0.45833333333333, -0.2, 0.083333333333333
18099, 0.45833333333333, -0.2, 0.125
18100, 0.45833333333333, -0.2, 0.16666666666667
18101, 0.45833333333333, -0.2, 0.20833333333333
18102, 0.45833333333333, -0.2, 0.25
18103, 0.45833333333333, -0.2, 0.29166666666667
18104, 0.45833333333333, -0.2, 0.33333333333333
18105, 0.45833333333333, -0.2, 0.375
18106, 0.45833333333333, -0.2, 0.41666666666667
18107, 0.45833333333333, -0.2, 0.45833333333333
18108, 0.5, -0.2, 0.041666666666667
18109, 0.5, -0.2, 0.083333333333333
18110, 0.5, -0.2, 0.125
18111, 0.5, -0.2, 0.16666666666667
18112, 0.5, -0.2, 0.20833333333333
18113, 0.5, -0.2, 0.25
18114, 0.5, -0.2, 0.29166666666667
18115, 0.5, -0.2, 0.33333333333333
18116, 0.5, -0.2, 0.375
18117, 0.5, -0.2, 0.41666666666667
18118, 0.5, -0.2, 0.45833333333333
18119, 0.54166666666667, -0.2, 0.041666666666667
18120, 0.54166666666667, -0.2, 0.083333333333333
18121, 0.54166666666667, -0.2, 0.125
18122, 0.54166666666667, -0.2, 0.16666666666667
18123, 0.54166666666667, -0.2, 0.20833333333333
18124, 0.54166666666667, -0.2, 0.25
18125, 0.54166666666667, -0.2, 0.29166666666667
18126, 0.54166666666667, -0.2, 0.33333333333333
18127, 0.54166666666667, -0.2, 0.375
18128, 0.54166666666667, -0.2, 0.41666666666667
18129, 0.54166666666667, -0.2, 0.45833333333333
18130, 0.58333333333333, -0.2, 0.041666666666667
18131, 0.58333333333333, -0.2, 0.083333333333333
18132, 0.58333333333333, -0.2, 0.125
18133, 0.58333333333333, -0.2, 0.16666666666667
18134, 0.58333333333333, -0.2, 0.20833333333333
18135, 0.58333333333333, -0.2, 0.25
18136, 0.58333333333333, -0.2, 0.29166666666667
18137, 0.58333333333333, -0.2, 0.33333333333333
18138, 0.58333333333333, -0.2, 0.375
18139, 0.58333333333333, -0.2, 0.41666666666667
18140, 0.58333333333333, -0.2, 0.45833333333333
18141, 0.625, -0.2, 0.041666666666667
18142, 0.625, -0.2, 0.083333333333333
18143, 0.625, -0.2, 0.125
18144, 0.625, -0.2, 0.16666666666667
18145, 0.625, -0.2, 0.20833333333333
18146, 0.625, -0.2, 0.25
18147, 0.625, -0.2, 0.29166666666667
18148, 0.625, -0.2, 0.33333333333333
18149, 0.625, -0.2, 0.375
18150, 0.625, -0.2, 0.41666666666667
18151, 0.625, -0.2, 0.45833333333333
18152, 0.66666666666667, -0.2, 0.041666666666667
18153, 0.66666666666667, -0.2, 0.083333333333333
18154, 0.66666666666667, -0.2, 0.125
18155, 0.66666666666667, -0.2, 0.16666666666667
18156, 0.66666666666667, -0.2, 0.20833333333333
18157, 0.66666666666667, -0.2, 0.25
18158, 0.66666666666667, -0.2, 0.29166666666667
18159, 0.66666666666667, -0.2, 0.33333333333333
18160, 0.66666666666667, -0.2, 0.375
18161, 0.66666666666667, -0.2, 0.41666666666667
18162, 0.66666666666667, -0.2, 0.45833333333333
18163, 0.70833333333333, -0.2, 0.041666666666667
18164, 0.70833333333333, -0.2, 0.083333333333333
18165, 0.70833333333333, -0.2, 0.125
18166, 0.70833333333333, -0.2, 0.16666666666667
18167, 0.70833333333333, -0.2, 0.20833333333333
18168, 0.70833333333333, -0.2, 0.25
18169, 0.70833333333333, -0.2, 0.29166666666667
18170, 0.70833333333333, -0.2, 0.33333333333333
18171, 0.70833333333333, -0.2, 0.375
18172, 0.70833333333333, -0.2, 0.41666666666667
18173, 0.70833333333333, -0.2, 0.45833333333333
18174, 0.75, -0.2, 0.041666666666667
18175, 0.75, -0.2, 0.083333333333333
18176, 0.75, -0.2, 0.125
18177, 0.75, -0.2, 0.16666666666667
18178, 0.75, -0.2, 0.20833333333333
18179, 0.75, -0.2, 0.25
18180, 0.75, -0.2, 0.29166666666667
18181, 0.75, -0.2, 0.33333333333333
18182, 0.75, -0.2, 0.375
18183, 0.75, -0.2, 0.41666666666667
18184, 0.75, -0.2, 0.45833333333333
18185, 0.79166666666667, -0.2, 0.041666666666667
18186, 0.79166666666667, -0.2, 0.083333333333333
18187, 0.79166666666667, -0.2, 0.125
18188, 0.79166666666667, -0.2, 0.16666666666667
18189, 0.79166666666667, -0.2, 0.20833333333333
18190, 0.79166666666667, -0.2, 0.25
18191, 0.79166666666667, -0.2, 0.29166666666667
18192, 0.79166666666667, -0.2, 0.33333333333333
18193, 0.79166666666667, -0.2, 0.375
18194, 0.79166666666667, -0.2, 0.41666666666667
18195, 0.79166666666667, -0.2, 0.45833333333333
18196, 0.83333333333333, -0.2, 0.041666666666667
18197, 0.83333333333333, -0.2, 0.083333333333333
18198, 0.83333333333333, -0.2, 0.125
18199, 0.83333333333333, -0.2, 0.16666666666667
18200, 0.83333333333333, -0.2, 0.20833333333333
18201, 0.83333333333333, -0.2, 0.25
18202, 0.83333333333333, -0.2, 0.29166666666667
18203, 0.83333333333333, -0.2, 0.33333333333333
18204, 0.83333333333333, -0.2, 0.375
18205, 0.83333333333333, -0.2, 0.41666666666667
18206, 0.83333333333333, -0.2, 0.45833333333333
18207, 0.875, -0.2, 0.041666666666667
18208, 0.875, -0.2, 0.083333333333333
