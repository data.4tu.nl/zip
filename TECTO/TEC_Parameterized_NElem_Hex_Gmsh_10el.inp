24261, 3463, 362, 363, 3486, 12008, 1641, 1642, 12031, 0, 0, 0, 0, 12705, 1665, 12752, 
12750, 35558, 11831, 11832, 35581
24262, 249, 3464, 3487, 250, 1595, 12009, 12032, 1596, 0, 0, 0, 0, 12707, 12753, 12754, 
1619, 11809, 35559, 35582, 11810
24263, 3464, 3465, 3488, 3487, 12009, 12010, 12033, 12032, 0, 0, 0, 0, 12709, 12755, 12756, 
12753, 35559, 35560, 35583, 35582
24264, 3465, 3466, 3489, 3488, 12010, 12011, 12034, 12033, 0, 0, 0, 0, 12711, 12757, 12758, 
12755, 35560, 35561, 35584, 35583
24265, 3466, 3467, 3490, 3489, 12011, 12012, 12035, 12034, 0, 0, 0, 0, 12713, 12759, 12760, 
12757, 35561, 35562, 35585, 35584
24266, 3467, 3468, 3491, 3490, 12012, 12013, 12036, 12035, 0, 0, 0, 0, 12715, 12761, 12762, 
12759, 35562, 35563, 35586, 35585
24267, 3468, 3469, 3492, 3491, 12013, 12014, 12037, 12036, 0, 0, 0, 0, 12717, 12763, 12764, 
12761, 35563, 35564, 35587, 35586
24268, 3469, 3470, 3493, 3492, 12014, 12015, 12038, 12037, 0, 0, 0, 0, 12719, 12765, 12766, 
12763, 35564, 35565, 35588, 35587
24269, 3470, 3471, 3494, 3493, 12015, 12016, 12039, 12038, 0, 0, 0, 0, 12721, 12767, 12768, 
12765, 35565, 35566, 35589, 35588
24270, 3471, 3472, 3495, 3494, 12016, 12017, 12040, 12039, 0, 0, 0, 0, 12723, 12769, 12770, 
12767, 35566, 35567, 35590, 35589
24271, 3472, 3473, 3496, 3495, 12017, 12018, 12041, 12040, 0, 0, 0, 0, 12725, 12771, 12772, 
12769, 35567, 35568, 35591, 35590
24272, 3473, 3474, 3497, 3496, 12018, 12019, 12042, 12041, 0, 0, 0, 0, 12727, 12773, 12774, 
12771, 35568, 35569, 35592, 35591
24273, 3474, 3475, 3498, 3497, 12019, 12020, 12043, 12042, 0, 0, 0, 0, 12729, 12775, 12776, 
12773, 35569, 35570, 35593, 35592
24274, 3475, 3476, 3499, 3498, 12020, 12021, 12044, 12043, 0, 0, 0, 0, 12731, 12777, 12778, 
12775, 35570, 35571, 35594, 35593
24275, 3476, 3477, 3500, 3499, 12021, 12022, 12045, 12044, 0, 0, 0, 0, 12733, 12779, 12780, 
12777, 35571, 35572, 35595, 35594
24276, 3477, 3478, 3501, 3500, 12022, 12023, 12046, 12045, 0, 0, 0, 0, 12735, 12781, 12782, 
12779, 35572, 35573, 35596, 35595
24277, 3478, 3479, 3502, 3501, 12023, 12024, 12047, 12046, 0, 0, 0, 0, 12737, 12783, 12784, 
12781, 35573, 35574, 35597, 35596
24278, 3479, 3480, 3503, 3502, 12024, 12025, 12048, 12047, 0, 0, 0, 0, 12739, 12785, 12786, 
12783, 35574, 35575, 35598, 35597
24279, 3480, 3481, 3504, 3503, 12025, 12026, 12049, 12048, 0, 0, 0, 0, 12741, 12787, 12788, 
12785, 35575, 35576, 35599, 35598
24280, 3481, 3482, 3505, 3504, 12026, 12027, 12050, 12049, 0, 0, 0, 0, 12743, 12789, 12790, 
12787, 35576, 35577, 35600, 35599
24281, 3482, 3483, 3506, 3505, 12027, 12028, 12051, 12050, 0, 0, 0, 0, 12745, 12791, 12792, 
12789, 35577, 35578, 35601, 35600
24282, 3483, 3484, 3507, 3506, 12028, 12029, 12052, 12051, 0, 0, 0, 0, 12747, 12793, 12794, 
12791, 35578, 35579, 35602, 35601
24283, 3484, 3485, 3508, 3507, 12029, 12030, 12053, 12052, 0, 0, 0, 0, 12749, 12795, 12796, 
12793, 35579, 35580, 35603, 35602
24284, 3485, 3486, 3509, 3508, 12030, 12031, 12054, 12053, 0, 0, 0, 0, 12751, 12797, 12798, 
12795, 35580, 35581, 35604, 35603
24285, 3486, 363, 364, 3509, 12031, 1642, 1643, 12054, 0, 0, 0, 0, 12752, 1666, 12799, 
12797, 35581, 11832, 11833, 35604
24286, 250, 3487, 3510, 251, 1596, 12032, 12055, 1597, 0, 0, 0, 0, 12754, 12800, 12801, 
1620, 11810, 35582, 35605, 11811
24287, 3487, 3488, 3511, 3510, 12032, 12033, 12056, 12055, 0, 0, 0, 0, 12756, 12802, 12803, 
12800, 35582, 35583, 35606, 35605
24288, 3488, 3489, 3512, 3511, 12033, 12034, 12057, 12056, 0, 0, 0, 0, 12758, 12804, 12805, 
12802, 35583, 35584, 35607, 35606
24289, 3489, 3490, 3513, 3512, 12034, 12035, 12058, 12057, 0, 0, 0, 0, 12760, 12806, 12807, 
12804, 35584, 35585, 35608, 35607
24290, 3490, 3491, 3514, 3513, 12035, 12036, 12059, 12058, 0, 0, 0, 0, 12762, 12808, 12809, 
12806, 35585, 35586, 35609, 35608
24291, 3491, 3492, 3515, 3514, 12036, 12037, 12060, 12059, 0, 0, 0, 0, 12764, 12810, 12811, 
12808, 35586, 35587, 35610, 35609
24292, 3492, 3493, 3516, 3515, 12037, 12038, 12061, 12060, 0, 0, 0, 0, 12766, 12812, 12813, 
12810, 35587, 35588, 35611, 35610
24293, 3493, 3494, 3517, 3516, 12038, 12039, 12062, 12061, 0, 0, 0, 0, 12768, 12814, 12815, 
12812, 35588, 35589, 35612, 35611
24294, 3494, 3495, 3518, 3517, 12039, 12040, 12063, 12062, 0, 0, 0, 0, 12770, 12816, 12817, 
12814, 35589, 35590, 35613, 35612
24295, 3495, 3496, 3519, 3518, 12040, 12041, 12064, 12063, 0, 0, 0, 0, 12772, 12818, 12819, 
12816, 35590, 35591, 35614, 35613
24296, 3496, 3497, 3520, 3519, 12041, 12042, 12065, 12064, 0, 0, 0, 0, 12774, 12820, 12821, 
12818, 35591, 35592, 35615, 35614
24297, 3497, 3498, 3521, 3520, 12042, 12043, 12066, 12065, 0, 0, 0, 0, 12776, 12822, 12823, 
12820, 35592, 35593, 35616, 35615
24298, 3498, 3499, 3522, 3521, 12043, 12044, 12067, 12066, 0, 0, 0, 0, 12778, 12824, 12825, 
12822, 35593, 35594, 35617, 35616
24299, 3499, 3500, 3523, 3522, 12044, 12045, 12068, 12067, 0, 0, 0, 0, 12780, 12826, 12827, 
12824, 35594, 35595, 35618, 35617
24300, 3500, 3501, 3524, 3523, 12045, 12046, 12069, 12068, 0, 0, 0, 0, 12782, 12828, 12829, 
12826, 35595, 35596, 35619, 35618
24301, 3501, 3502, 3525, 3524, 12046, 12047, 12070, 12069, 0, 0, 0, 0, 12784, 12830, 12831, 
12828, 35596, 35597, 35620, 35619
24302, 3502, 3503, 3526, 3525, 12047, 12048, 12071, 12070, 0, 0, 0, 0, 12786, 12832, 12833, 
12830, 35597, 35598, 35621, 35620
24303, 3503, 3504, 3527, 3526, 12048, 12049, 12072, 12071, 0, 0, 0, 0, 12788, 12834, 12835, 
12832, 35598, 35599, 35622, 35621
24304, 3504, 3505, 3528, 3527, 12049, 12050, 12073, 12072, 0, 0, 0, 0, 12790, 12836, 12837, 
12834, 35599, 35600, 35623, 35622
24305, 3505, 3506, 3529, 3528, 12050, 12051, 12074, 12073, 0, 0, 0, 0, 12792, 12838, 12839, 
12836, 35600, 35601, 35624, 35623
24306, 3506, 3507, 3530, 3529, 12051, 12052, 12075, 12074, 0, 0, 0, 0, 12794, 12840, 12841, 
12838, 35601, 35602, 35625, 35624
24307, 3507, 3508, 3531, 3530, 12052, 12053, 12076, 12075, 0, 0, 0, 0, 12796, 12842, 12843, 
12840, 35602, 35603, 35626, 35625
24308, 3508, 3509, 3532, 3531, 12053, 12054, 12077, 12076, 0, 0, 0, 0, 12798, 12844, 12845, 
12842, 35603, 35604, 35627, 35626
24309, 3509, 364, 365, 3532, 12054, 1643, 1644, 12077, 0, 0, 0, 0, 12799, 1667, 12846, 
12844, 35604, 11833, 11834, 35627
24310, 251, 3510, 3533, 252, 1597, 12055, 12078, 1598, 0, 0, 0, 0, 12801, 12847, 12848, 
1621, 11811, 35605, 35628, 11812
24311, 3510, 3511, 3534, 3533, 12055, 12056, 12079, 12078, 0, 0, 0, 0, 12803, 12849, 12850, 
12847, 35605, 35606, 35629, 35628
24312, 3511, 3512, 3535, 3534, 12056, 12057, 12080, 12079, 0, 0, 0, 0, 12805, 12851, 12852, 
12849, 35606, 35607, 35630, 35629
24313, 3512, 3513, 3536, 3535, 12057, 12058, 12081, 12080, 0, 0, 0, 0, 12807, 12853, 12854, 
12851, 35607, 35608, 35631, 35630
24314, 3513, 3514, 3537, 3536, 12058, 12059, 12082, 12081, 0, 0, 0, 0, 12809, 12855, 12856, 
12853, 35608, 35609, 35632, 35631
24315, 3514, 3515, 3538, 3537, 12059, 12060, 12083, 12082, 0, 0, 0, 0, 12811, 12857, 12858, 
12855, 35609, 35610, 35633, 35632
24316, 3515, 3516, 3539, 3538, 12060, 12061, 12084, 12083, 0, 0, 0, 0, 12813, 12859, 12860, 
12857, 35610, 35611, 35634, 35633
24317, 3516, 3517, 3540, 3539, 12061, 12062, 12085, 12084, 0, 0, 0, 0, 12815, 12861, 12862, 
12859, 35611, 35612, 35635, 35634
24318, 3517, 3518, 3541, 3540, 12062, 12063, 12086, 12085, 0, 0, 0, 0, 12817, 12863, 12864, 
12861, 35612, 35613, 35636, 35635
24319, 3518, 3519, 3542, 3541, 12063, 12064, 12087, 12086, 0, 0, 0, 0, 12819, 12865, 12866, 
12863, 35613, 35614, 35637, 35636
24320, 3519, 3520, 3543, 3542, 12064, 12065, 12088, 12087, 0, 0, 0, 0, 12821, 12867, 12868, 
12865, 35614, 35615, 35638, 35637
24321, 3520, 3521, 3544, 3543, 12065, 12066, 12089, 12088, 0, 0, 0, 0, 12823, 12869, 12870, 
12867, 35615, 35616, 35639, 35638
24322, 3521, 3522, 3545, 3544, 12066, 12067, 12090, 12089, 0, 0, 0, 0, 12825, 12871, 12872, 
12869, 35616, 35617, 35640, 35639
24323, 3522, 3523, 3546, 3545, 12067, 12068, 12091, 12090, 0, 0, 0, 0, 12827, 12873, 12874, 
12871, 35617, 35618, 35641, 35640
24324, 3523, 3524, 3547, 3546, 12068, 12069, 12092, 12091, 0, 0, 0, 0, 12829, 12875, 12876, 
12873, 35618, 35619, 35642, 35641
24325, 3524, 3525, 3548, 3547, 12069, 12070, 12093, 12092, 0, 0, 0, 0, 12831, 12877, 12878, 
12875, 35619, 35620, 35643, 35642
24326, 3525, 3526, 3549, 3548, 12070, 12071, 12094, 12093, 0, 0, 0, 0, 12833, 12879, 12880, 
12877, 35620, 35621, 35644, 35643
24327, 3526, 3527, 3550, 3549, 12071, 12072, 12095, 12094, 0, 0, 0, 0, 12835, 12881, 12882, 
12879, 35621, 35622, 35645, 35644
24328, 3527, 3528, 3551, 3550, 12072, 12073, 12096, 12095, 0, 0, 0, 0, 12837, 12883, 12884, 
12881, 35622, 35623, 35646, 35645
24329, 3528, 3529, 3552, 3551, 12073, 12074, 12097, 12096, 0, 0, 0, 0, 12839, 12885, 12886, 
12883, 35623, 35624, 35647, 35646
24330, 3529, 3530, 3553, 3552, 12074, 12075, 12098, 12097, 0, 0, 0, 0, 12841, 12887, 12888, 
12885, 35624, 35625, 35648, 35647
24331, 3530, 3531, 3554, 3553, 12075, 12076, 12099, 12098, 0, 0, 0, 0, 12843, 12889, 12890, 
12887, 35625, 35626, 35649, 35648
24332, 3531, 3532, 3555, 3554, 12076, 12077, 12100, 12099, 0, 0, 0, 0, 12845, 12891, 12892, 
12889, 35626, 35627, 35650, 35649
24333, 3532, 365, 366, 3555, 12077, 1644, 1645, 12100, 0, 0, 0, 0, 12846, 1668, 12893, 
12891, 35627, 11834, 11835, 35650
24334, 252, 3533, 3556, 253, 1598, 12078, 12101, 1599, 0, 0, 0, 0, 12848, 12894, 12895, 
1622, 11812, 35628, 35651, 11813
24335, 3533, 3534, 3557, 3556, 12078, 12079, 12102, 12101, 0, 0, 0, 0, 12850, 12896, 12897, 
12894, 35628, 35629, 35652, 35651
24336, 3534, 3535, 3558, 3557, 12079, 12080, 12103, 12102, 0, 0, 0, 0, 12852, 12898, 12899, 
12896, 35629, 35630, 35653, 35652
24337, 3535, 3536, 3559, 3558, 12080, 12081, 12104, 12103, 0, 0, 0, 0, 12854, 12900, 12901, 
12898, 35630, 35631, 35654, 35653
24338, 3536, 3537, 3560, 3559, 12081, 12082, 12105, 12104, 0, 0, 0, 0, 12856, 12902, 12903, 
12900, 35631, 35632, 35655, 35654
24339, 3537, 3538, 3561, 3560, 12082, 12083, 12106, 12105, 0, 0, 0, 0, 12858, 12904, 12905, 
12902, 35632, 35633, 35656, 35655
24340, 3538, 3539, 3562, 3561, 12083, 12084, 12107, 12106, 0, 0, 0, 0, 12860, 12906, 12907, 
12904, 35633, 35634, 35657, 35656
24341, 3539, 3540, 3563, 3562, 12084, 12085, 12108, 12107, 0, 0, 0, 0, 12862, 12908, 12909, 
12906, 35634, 35635, 35658, 35657
24342, 3540, 3541, 3564, 3563, 12085, 12086, 12109, 12108, 0, 0, 0, 0, 12864, 12910, 12911, 
12908, 35635, 35636, 35659, 35658
24343, 3541, 3542, 3565, 3564, 12086, 12087, 12110, 12109, 0, 0, 0, 0, 12866, 12912, 12913, 
12910, 35636, 35637, 35660, 35659
24344, 3542, 3543, 3566, 3565, 12087, 12088, 12111, 12110, 0, 0, 0, 0, 12868, 12914, 12915, 
12912, 35637, 35638, 35661, 35660
24345, 3543, 3544, 3567, 3566, 12088, 12089, 12112, 12111, 0, 0, 0, 0, 12870, 12916, 12917, 
12914, 35638, 35639, 35662, 35661
24346, 3544, 3545, 3568, 3567, 12089, 12090, 12113, 12112, 0, 0, 0, 0, 12872, 12918, 12919, 
12916, 35639, 35640, 35663, 35662
24347, 3545, 3546, 3569, 3568, 12090, 12091, 12114, 12113, 0, 0, 0, 0, 12874, 12920, 12921, 
12918, 35640, 35641, 35664, 35663
24348, 3546, 3547, 3570, 3569, 12091, 12092, 12115, 12114, 0, 0, 0, 0, 12876, 12922, 12923, 
12920, 35641, 35642, 35665, 35664
24349, 3547, 3548, 3571, 3570, 12092, 12093, 12116, 12115, 0, 0, 0, 0, 12878, 12924, 12925, 
12922, 35642, 35643, 35666, 35665
24350, 3548, 3549, 3572, 3571, 12093, 12094, 12117, 12116, 0, 0, 0, 0, 12880, 12926, 12927, 
12924, 35643, 35644, 35667, 35666
24351, 3549, 3550, 3573, 3572, 12094, 12095, 12118, 12117, 0, 0, 0, 0, 12882, 12928, 12929, 
12926, 35644, 35645, 35668, 35667
24352, 3550, 3551, 3574, 3573, 12095, 12096, 12119, 12118, 0, 0, 0, 0, 12884, 12930, 12931, 
12928, 35645, 35646, 35669, 35668
24353, 3551, 3552, 3575, 3574, 12096, 12097, 12120, 12119, 0, 0, 0, 0, 12886, 12932, 12933, 
12930, 35646, 35647, 35670, 35669
24354, 3552, 3553, 3576, 3575, 12097, 12098, 12121, 12120, 0, 0, 0, 0, 12888, 12934, 12935, 
12932, 35647, 35648, 35671, 35670
24355, 3553, 3554, 3577, 3576, 12098, 12099, 12122, 12121, 0, 0, 0, 0, 12890, 12936, 12937, 
12934, 35648, 35649, 35672, 35671
24356, 3554, 3555, 3578, 3577, 12099, 12100, 12123, 12122, 0, 0, 0, 0, 12892, 12938, 12939, 
12936, 35649, 35650, 35673, 35672
24357, 3555, 366, 367, 3578, 12100, 1645, 1646, 12123, 0, 0, 0, 0, 12893, 1669, 12940, 
12938, 35650, 11835, 11836, 35673
24358, 253, 3556, 3579, 254, 1599, 12101, 12124, 1600, 0, 0, 0, 0, 12895, 12941, 12942, 
1623, 11813, 35651, 35674, 11814
24359, 3556, 3557, 3580, 3579, 12101, 12102, 12125, 12124, 0, 0, 0, 0, 12897, 12943, 12944, 
12941, 35651, 35652, 35675, 35674
24360, 3557, 3558, 3581, 3580, 12102, 12103, 12126, 12125, 0, 0, 0, 0, 12899, 12945, 12946, 
12943, 35652, 35653, 35676, 35675
24361, 3558, 3559, 3582, 3581, 12103, 12104, 12127, 12126, 0, 0, 0, 0, 12901, 12947, 12948, 
12945, 35653, 35654, 35677, 35676
24362, 3559, 3560, 3583, 3582, 12104, 12105, 12128, 12127, 0, 0, 0, 0, 12903, 12949, 12950, 
12947, 35654, 35655, 35678, 35677
24363, 3560, 3561, 3584, 3583, 12105, 12106, 12129, 12128, 0, 0, 0, 0, 12905, 12951, 12952, 
12949, 35655, 35656, 35679, 35678
24364, 3561, 3562, 3585, 3584, 12106, 12107, 12130, 12129, 0, 0, 0, 0, 12907, 12953, 12954, 
12951, 35656, 35657, 35680, 35679
24365, 3562, 3563, 3586, 3585, 12107, 12108, 12131, 12130, 0, 0, 0, 0, 12909, 12955, 12956, 
12953, 35657, 35658, 35681, 35680
24366, 3563, 3564, 3587, 3586, 12108, 12109, 12132, 12131, 0, 0, 0, 0, 12911, 12957, 12958, 
12955, 35658, 35659, 35682, 35681
24367, 3564, 3565, 3588, 3587, 12109, 12110, 12133, 12132, 0, 0, 0, 0, 12913, 12959, 12960, 
12957, 35659, 35660, 35683, 35682
24368, 3565, 3566, 3589, 3588, 12110, 12111, 12134, 12133, 0, 0, 0, 0, 12915, 12961, 12962, 
12959, 35660, 35661, 35684, 35683
24369, 3566, 3567, 3590, 3589, 12111, 12112, 12135, 12134, 0, 0, 0, 0, 12917, 12963, 12964, 
12961, 35661, 35662, 35685, 35684
24370, 3567, 3568, 3591, 3590, 12112, 12113, 12136, 12135, 0, 0, 0, 0, 12919, 12965, 12966, 
12963, 35662, 35663, 35686, 35685
24371, 3568, 3569, 3592, 3591, 12113, 12114, 12137, 12136, 0, 0, 0, 0, 12921, 12967, 12968, 
12965, 35663, 35664, 35687, 35686
24372, 3569, 3570, 3593, 3592, 12114, 12115, 12138, 12137, 0, 0, 0, 0, 12923, 12969, 12970, 
12967, 35664, 35665, 35688, 35687
24373, 3570, 3571, 3594, 3593, 12115, 12116, 12139, 12138, 0, 0, 0, 0, 12925, 12971, 12972, 
12969, 35665, 35666, 35689, 35688
24374, 3571, 3572, 3595, 3594, 12116, 12117, 12140, 12139, 0, 0, 0, 0, 12927, 12973, 12974, 
12971, 35666, 35667, 35690, 35689
24375, 3572, 3573, 3596, 3595, 12117, 12118, 12141, 12140, 0, 0, 0, 0, 12929, 12975, 12976, 
12973, 35667, 35668, 35691, 35690
24376, 3573, 3574, 3597, 3596, 12118, 12119, 12142, 12141, 0, 0, 0, 0, 12931, 12977, 12978, 
12975, 35668, 35669, 35692, 35691
24377, 3574, 3575, 3598, 3597, 12119, 12120, 12143, 12142, 0, 0, 0, 0, 12933, 12979, 12980, 
12977, 35669, 35670, 35693, 35692
24378, 3575, 3576, 3599, 3598, 12120, 12121, 12144, 12143, 0, 0, 0, 0, 12935, 12981, 12982, 
12979, 35670, 35671, 35694, 35693
24379, 3576, 3577, 3600, 3599, 12121, 12122, 12145, 12144, 0, 0, 0, 0, 12937, 12983, 12984, 
12981, 35671, 35672, 35695, 35694
24380, 3577, 3578, 3601, 3600, 12122, 12123, 12146, 12145, 0, 0, 0, 0, 12939, 12985, 12986, 
12983, 35672, 35673, 35696, 35695
24381, 3578, 367, 368, 3601, 12123, 1646, 1647, 12146, 0, 0, 0, 0, 12940, 1670, 12987, 
12985, 35673, 11836, 11837, 35696
24382, 254, 3579, 3602, 255, 1600, 12124, 12147, 1601, 0, 0, 0, 0, 12942, 12988, 12989, 
1624, 11814, 35674, 35697, 11815
24383, 3579, 3580, 3603, 3602, 12124, 12125, 12148, 12147, 0, 0, 0, 0, 12944, 12990, 12991, 
12988, 35674, 35675, 35698, 35697
24384, 3580, 3581, 3604, 3603, 12125, 12126, 12149, 12148, 0, 0, 0, 0, 12946, 12992, 12993, 
12990, 35675, 35676, 35699, 35698
24385, 3581, 3582, 3605, 3604, 12126, 12127, 12150, 12149, 0, 0, 0, 0, 12948, 12994, 12995, 
12992, 35676, 35677, 35700, 35699
24386, 3582, 3583, 3606, 3605, 12127, 12128, 12151, 12150, 0, 0, 0, 0, 12950, 12996, 12997, 
12994, 35677, 35678, 35701, 35700
24387, 3583, 3584, 3607, 3606, 12128, 12129, 12152, 12151, 0, 0, 0, 0, 12952, 12998, 12999, 
12996, 35678, 35679, 35702, 35701
24388, 3584, 3585, 3608, 3607, 12129, 12130, 12153, 12152, 0, 0, 0, 0, 12954, 13000, 13001, 
12998, 35679, 35680, 35703, 35702
24389, 3585, 3586, 3609, 3608, 12130, 12131, 12154, 12153, 0, 0, 0, 0, 12956, 13002, 13003, 
13000, 35680, 35681, 35704, 35703
24390, 3586, 3587, 3610, 3609, 12131, 12132, 12155, 12154, 0, 0, 0, 0, 12958, 13004, 13005, 
13002, 35681, 35682, 35705, 35704
24391, 3587, 3588, 3611, 3610, 12132, 12133, 12156, 12155, 0, 0, 0, 0, 12960, 13006, 13007, 
13004, 35682, 35683, 35706, 35705
24392, 3588, 3589, 3612, 3611, 12133, 12134, 12157, 12156, 0, 0, 0, 0, 12962, 13008, 13009, 
13006, 35683, 35684, 35707, 35706
24393, 3589, 3590, 3613, 3612, 12134, 12135, 12158, 12157, 0, 0, 0, 0, 12964, 13010, 13011, 
13008, 35684, 35685, 35708, 35707
24394, 3590, 3591, 3614, 3613, 12135, 12136, 12159, 12158, 0, 0, 0, 0, 12966, 13012, 13013, 
13010, 35685, 35686, 35709, 35708
24395, 3591, 3592, 3615, 3614, 12136, 12137, 12160, 12159, 0, 0, 0, 0, 12968, 13014, 13015, 
13012, 35686, 35687, 35710, 35709
24396, 3592, 3593, 3616, 3615, 12137, 12138, 12161, 12160, 0, 0, 0, 0, 12970, 13016, 13017, 
13014, 35687, 35688, 35711, 35710
24397, 3593, 3594, 3617, 3616, 12138, 12139, 12162, 12161, 0, 0, 0, 0, 12972, 13018, 13019, 
13016, 35688, 35689, 35712, 35711
24398, 3594, 3595, 3618, 3617, 12139, 12140, 12163, 12162, 0, 0, 0, 0, 12974, 13020, 13021, 
13018, 35689, 35690, 35713, 35712
24399, 3595, 3596, 3619, 3618, 12140, 12141, 12164, 12163, 0, 0, 0, 0, 12976, 13022, 13023, 
13020, 35690, 35691, 35714, 35713
24400, 3596, 3597, 3620, 3619, 12141, 12142, 12165, 12164, 0, 0, 0, 0, 12978, 13024, 13025, 
13022, 35691, 35692, 35715, 35714
24401, 3597, 3598, 3621, 3620, 12142, 12143, 12166, 12165, 0, 0, 0, 0, 12980, 13026, 13027, 
13024, 35692, 35693, 35716, 35715
24402, 3598, 3599, 3622, 3621, 12143, 12144, 12167, 12166, 0, 0, 0, 0, 12982, 13028, 13029, 
13026, 35693, 35694, 35717, 35716
24403, 3599, 3600, 3623, 3622, 12144, 12145, 12168, 12167, 0, 0, 0, 0, 12984, 13030, 13031, 
13028, 35694, 35695, 35718, 35717
24404, 3600, 3601, 3624, 3623, 12145, 12146, 12169, 12168, 0, 0, 0, 0, 12986, 13032, 13033, 
13030, 35695, 35696, 35719, 35718
24405, 3601, 368, 369, 3624, 12146, 1647, 1648, 12169, 0, 0, 0, 0, 12987, 1671, 13034, 
13032, 35696, 11837, 11838, 35719
24406, 255, 3602, 3625, 256, 1601, 12147, 12170, 1602, 0, 0, 0, 0, 12989, 13035, 13036, 
1625, 11815, 35697, 35720, 11816
24407, 3602, 3603, 3626, 3625, 12147, 12148, 12171, 12170, 0, 0, 0, 0, 12991, 13037, 13038, 
13035, 35697, 35698, 35721, 35720
24408, 3603, 3604, 3627, 3626, 12148, 12149, 12172, 12171, 0, 0, 0, 0, 12993, 13039, 13040, 
13037, 35698, 35699, 35722, 35721
24409, 3604, 3605, 3628, 3627, 12149, 12150, 12173, 12172, 0, 0, 0, 0, 12995, 13041, 13042, 
13039, 35699, 35700, 35723, 35722
24410, 3605, 3606, 3629, 3628, 12150, 12151, 12174, 12173, 0, 0, 0, 0, 12997, 13043, 13044, 
13041, 35700, 35701, 35724, 35723
24411, 3606, 3607, 3630, 3629, 12151, 12152, 12175, 12174, 0, 0, 0, 0, 12999, 13045, 13046, 
13043, 35701, 35702, 35725, 35724
24412, 3607, 3608, 3631, 3630, 12152, 12153, 12176, 12175, 0, 0, 0, 0, 13001, 13047, 13048, 
13045, 35702, 35703, 35726, 35725
24413, 3608, 3609, 3632, 3631, 12153, 12154, 12177, 12176, 0, 0, 0, 0, 13003, 13049, 13050, 
13047, 35703, 35704, 35727, 35726
24414, 3609, 3610, 3633, 3632, 12154, 12155, 12178, 12177, 0, 0, 0, 0, 13005, 13051, 13052, 
13049, 35704, 35705, 35728, 35727
24415, 3610, 3611, 3634, 3633, 12155, 12156, 12179, 12178, 0, 0, 0, 0, 13007, 13053, 13054, 
13051, 35705, 35706, 35729, 35728
24416, 3611, 3612, 3635, 3634, 12156, 12157, 12180, 12179, 0, 0, 0, 0, 13009, 13055, 13056, 
13053, 35706, 35707, 35730, 35729
24417, 3612, 3613, 3636, 3635, 12157, 12158, 12181, 12180, 0, 0, 0, 0, 13011, 13057, 13058, 
13055, 35707, 35708, 35731, 35730
24418, 3613, 3614, 3637, 3636, 12158, 12159, 12182, 12181, 0, 0, 0, 0, 13013, 13059, 13060, 
13057, 35708, 35709, 35732, 35731
24419, 3614, 3615, 3638, 3637, 12159, 12160, 12183, 12182, 0, 0, 0, 0, 13015, 13061, 13062, 
13059, 35709, 35710, 35733, 35732
24420, 3615, 3616, 3639, 3638, 12160, 12161, 12184, 12183, 0, 0, 0, 0, 13017, 13063, 13064, 
13061, 35710, 35711, 35734, 35733
24421, 3616, 3617, 3640, 3639, 12161, 12162, 12185, 12184, 0, 0, 0, 0, 13019, 13065, 13066, 
13063, 35711, 35712, 35735, 35734
24422, 3617, 3618, 3641, 3640, 12162, 12163, 12186, 12185, 0, 0, 0, 0, 13021, 13067, 13068, 
13065, 35712, 35713, 35736, 35735
24423, 3618, 3619, 3642, 3641, 12163, 12164, 12187, 12186, 0, 0, 0, 0, 13023, 13069, 13070, 
13067, 35713, 35714, 35737, 35736
24424, 3619, 3620, 3643, 3642, 12164, 12165, 12188, 12187, 0, 0, 0, 0, 13025, 13071, 13072, 
13069, 35714, 35715, 35738, 35737
24425, 3620, 3621, 3644, 3643, 12165, 12166, 12189, 12188, 0, 0, 0, 0, 13027, 13073, 13074, 
13071, 35715, 35716, 35739, 35738
24426, 3621, 3622, 3645, 3644, 12166, 12167, 12190, 12189, 0, 0, 0, 0, 13029, 13075, 13076, 
13073, 35716, 35717, 35740, 35739
24427, 3622, 3623, 3646, 3645, 12167, 12168, 12191, 12190, 0, 0, 0, 0, 13031, 13077, 13078, 
13075, 35717, 35718, 35741, 35740
24428, 3623, 3624, 3647, 3646, 12168, 12169, 12192, 12191, 0, 0, 0, 0, 13033, 13079, 13080, 
13077, 35718, 35719, 35742, 35741
24429, 3624, 369, 370, 3647, 12169, 1648, 1649, 12192, 0, 0, 0, 0, 13034, 1672, 13081, 
13079, 35719, 11838, 11839, 35742
24430, 256, 3625, 3648, 257, 1602, 12170, 12193, 1603, 0, 0, 0, 0, 13036, 13082, 13083, 
1626, 11816, 35720, 35743, 11817
24431, 3625, 3626, 3649, 3648, 12170, 12171, 12194, 12193, 0, 0, 0, 0, 13038, 13084, 13085, 
13082, 35720, 35721, 35744, 35743
24432, 3626, 3627, 3650, 3649, 12171, 12172, 12195, 12194, 0, 0, 0, 0, 13040, 13086, 13087, 
13084, 35721, 35722, 35745, 35744
24433, 3627, 3628, 3651, 3650, 12172, 12173, 12196, 12195, 0, 0, 0, 0, 13042, 13088, 13089, 
13086, 35722, 35723, 35746, 35745
24434, 3628, 3629, 3652, 3651, 12173, 12174, 12197, 12196, 0, 0, 0, 0, 13044, 13090, 13091, 
13088, 35723, 35724, 35747, 35746
24435, 3629, 3630, 3653, 3652, 12174, 12175, 12198, 12197, 0, 0, 0, 0, 13046, 13092, 13093, 
13090, 35724, 35725, 35748, 35747
24436, 3630, 3631, 3654, 3653, 12175, 12176, 12199, 12198, 0, 0, 0, 0, 13048, 13094, 13095, 
13092, 35725, 35726, 35749, 35748
24437, 3631, 3632, 3655, 3654, 12176, 12177, 12200, 12199, 0, 0, 0, 0, 13050, 13096, 13097, 
13094, 35726, 35727, 35750, 35749
24438, 3632, 3633, 3656, 3655, 12177, 12178, 12201, 12200, 0, 0, 0, 0, 13052, 13098, 13099, 
13096, 35727, 35728, 35751, 35750
24439, 3633, 3634, 3657, 3656, 12178, 12179, 12202, 12201, 0, 0, 0, 0, 13054, 13100, 13101, 
13098, 35728, 35729, 35752, 35751
24440, 3634, 3635, 3658, 3657, 12179, 12180, 12203, 12202, 0, 0, 0, 0, 13056, 13102, 13103, 
13100, 35729, 35730, 35753, 35752
24441, 3635, 3636, 3659, 3658, 12180, 12181, 12204, 12203, 0, 0, 0, 0, 13058, 13104, 13105, 
13102, 35730, 35731, 35754, 35753
24442, 3636, 3637, 3660, 3659, 12181, 12182, 12205, 12204, 0, 0, 0, 0, 13060, 13106, 13107, 
13104, 35731, 35732, 35755, 35754
24443, 3637, 3638, 3661, 3660, 12182, 12183, 12206, 12205, 0, 0, 0, 0, 13062, 13108, 13109, 
13106, 35732, 35733, 35756, 35755
24444, 3638, 3639, 3662, 3661, 12183, 12184, 12207, 12206, 0, 0, 0, 0, 13064, 13110, 13111, 
13108, 35733, 35734, 35757, 35756
24445, 3639, 3640, 3663, 3662, 12184, 12185, 12208, 12207, 0, 0, 0, 0, 13066, 13112, 13113, 
13110, 35734, 35735, 35758, 35757
24446, 3640, 3641, 3664, 3663, 12185, 12186, 12209, 12208, 0, 0, 0, 0, 13068, 13114, 13115, 
13112, 35735, 35736, 35759, 35758
24447, 3641, 3642, 3665, 3664, 12186, 12187, 12210, 12209, 0, 0, 0, 0, 13070, 13116, 13117, 
13114, 35736, 35737, 35760, 35759
24448, 3642, 3643, 3666, 3665, 12187, 12188, 12211, 12210, 0, 0, 0, 0, 13072, 13118, 13119, 
13116, 35737, 35738, 35761, 35760
24449, 3643, 3644, 3667, 3666, 12188, 12189, 12212, 12211, 0, 0, 0, 0, 13074, 13120, 13121, 
13118, 35738, 35739, 35762, 35761
24450, 3644, 3645, 3668, 3667, 12189, 12190, 12213, 12212, 0, 0, 0, 0, 13076, 13122, 13123, 
13120, 35739, 35740, 35763, 35762
24451, 3645, 3646, 3669, 3668, 12190, 12191, 12214, 12213, 0, 0, 0, 0, 13078, 13124, 13125, 
13122, 35740, 35741, 35764, 35763
24452, 3646, 3647, 3670, 3669, 12191, 12192, 12215, 12214, 0, 0, 0, 0, 13080, 13126, 13127, 
13124, 35741, 35742, 35765, 35764
24453, 3647, 370, 371, 3670, 12192, 1649, 1650, 12215, 0, 0, 0, 0, 13081, 1673, 13128, 
13126, 35742, 11839, 11840, 35765
24454, 257, 3648, 3671, 258, 1603, 12193, 12216, 1604, 0, 0, 0, 0, 13083, 13129, 13130, 
1627, 11817, 35743, 35766, 11818
24455, 3648, 3649, 3672, 3671, 12193, 12194, 12217, 12216, 0, 0, 0, 0, 13085, 13131, 13132, 
13129, 35743, 35744, 35767, 35766
24456, 3649, 3650, 3673, 3672, 12194, 12195, 12218, 12217, 0, 0, 0, 0, 13087, 13133, 13134, 
13131, 35744, 35745, 35768, 35767
24457, 3650, 3651, 3674, 3673, 12195, 12196, 12219, 12218, 0, 0, 0, 0, 13089, 13135, 13136, 
13133, 35745, 35746, 35769, 35768
24458, 3651, 3652, 3675, 3674, 12196, 12197, 12220, 12219, 0, 0, 0, 0, 13091, 13137, 13138, 
13135, 35746, 35747, 35770, 35769
24459, 3652, 3653, 3676, 3675, 12197, 12198, 12221, 12220, 0, 0, 0, 0, 13093, 13139, 13140, 
13137, 35747, 35748, 35771, 35770
24460, 3653, 3654, 3677, 3676, 12198, 12199, 12222, 12221, 0, 0, 0, 0, 13095, 13141, 13142, 
13139, 35748, 35749, 35772, 35771
24461, 3654, 3655, 3678, 3677, 12199, 12200, 12223, 12222, 0, 0, 0, 0, 13097, 13143, 13144, 
13141, 35749, 35750, 35773, 35772
24462, 3655, 3656, 3679, 3678, 12200, 12201, 12224, 12223, 0, 0, 0, 0, 13099, 13145, 13146, 
13143, 35750, 35751, 35774, 35773
24463, 3656, 3657, 3680, 3679, 12201, 12202, 12225, 12224, 0, 0, 0, 0, 13101, 13147, 13148, 
13145, 35751, 35752, 35775, 35774
24464, 3657, 3658, 3681, 3680, 12202, 12203, 12226, 12225, 0, 0, 0, 0, 13103, 13149, 13150, 
13147, 35752, 35753, 35776, 35775
24465, 3658, 3659, 3682, 3681, 12203, 12204, 12227, 12226, 0, 0, 0, 0, 13105, 13151, 13152, 
13149, 35753, 35754, 35777, 35776
24466, 3659, 3660, 3683, 3682, 12204, 12205, 12228, 12227, 0, 0, 0, 0, 13107, 13153, 13154, 
13151, 35754, 35755, 35778, 35777
24467, 3660, 3661, 3684, 3683, 12205, 12206, 12229, 12228, 0, 0, 0, 0, 13109, 13155, 13156, 
13153, 35755, 35756, 35779, 35778
24468, 3661, 3662, 3685, 3684, 12206, 12207, 12230, 12229, 0, 0, 0, 0, 13111, 13157, 13158, 
13155, 35756, 35757, 35780, 35779
24469, 3662, 3663, 3686, 3685, 12207, 12208, 12231, 12230, 0, 0, 0, 0, 13113, 13159, 13160, 
13157, 35757, 35758, 35781, 35780
24470, 3663, 3664, 3687, 3686, 12208, 12209, 12232, 12231, 0, 0, 0, 0, 13115, 13161, 13162, 
13159, 35758, 35759, 35782, 35781
24471, 3664, 3665, 3688, 3687, 12209, 12210, 12233, 12232, 0, 0, 0, 0, 13117, 13163, 13164, 
13161, 35759, 35760, 35783, 35782
24472, 3665, 3666, 3689, 3688, 12210, 12211, 12234, 12233, 0, 0, 0, 0, 13119, 13165, 13166, 
13163, 35760, 35761, 35784, 35783
24473, 3666, 3667, 3690, 3689, 12211, 12212, 12235, 12234, 0, 0, 0, 0, 13121, 13167, 13168, 
13165, 35761, 35762, 35785, 35784
24474, 3667, 3668, 3691, 3690, 12212, 12213, 12236, 12235, 0, 0, 0, 0, 13123, 13169, 13170, 
13167, 35762, 35763, 35786, 35785
24475, 3668, 3669, 3692, 3691, 12213, 12214, 12237, 12236, 0, 0, 0, 0, 13125, 13171, 13172, 
13169, 35763, 35764, 35787, 35786
24476, 3669, 3670, 3693, 3692, 12214, 12215, 12238, 12237, 0, 0, 0, 0, 13127, 13173, 13174, 
13171, 35764, 35765, 35788, 35787
24477, 3670, 371, 372, 3693, 12215, 1650, 1651, 12238, 0, 0, 0, 0, 13128, 1674, 13175, 
13173, 35765, 11840, 11841, 35788
24478, 258, 3671, 3694, 259, 1604, 12216, 12239, 1605, 0, 0, 0, 0, 13130, 13176, 13177, 
1628, 11818, 35766, 35789, 11819
24479, 3671, 3672, 3695, 3694, 12216, 12217, 12240, 12239, 0, 0, 0, 0, 13132, 13178, 13179, 
13176, 35766, 35767, 35790, 35789
24480, 3672, 3673, 3696, 3695, 12217, 12218, 12241, 12240, 0, 0, 0, 0, 13134, 13180, 13181, 
13178, 35767, 35768, 35791, 35790
24481, 3673, 3674, 3697, 3696, 12218, 12219, 12242, 12241, 0, 0, 0, 0, 13136, 13182, 13183, 
13180, 35768, 35769, 35792, 35791
24482, 3674, 3675, 3698, 3697, 12219, 12220, 12243, 12242, 0, 0, 0, 0, 13138, 13184, 13185, 
13182, 35769, 35770, 35793, 35792
24483, 3675, 3676, 3699, 3698, 12220, 12221, 12244, 12243, 0, 0, 0, 0, 13140, 13186, 13187, 
13184, 35770, 35771, 35794, 35793
24484, 3676, 3677, 3700, 3699, 12221, 12222, 12245, 12244, 0, 0, 0, 0, 13142, 13188, 13189, 
13186, 35771, 35772, 35795, 35794
24485, 3677, 3678, 3701, 3700, 12222, 12223, 12246, 12245, 0, 0, 0, 0, 13144, 13190, 13191, 
13188, 35772, 35773, 35796, 35795
24486, 3678, 3679, 3702, 3701, 12223, 12224, 12247, 12246, 0, 0, 0, 0, 13146, 13192, 13193, 
13190, 35773, 35774, 35797, 35796
24487, 3679, 3680, 3703, 3702, 12224, 12225, 12248, 12247, 0, 0, 0, 0, 13148, 13194, 13195, 
13192, 35774, 35775, 35798, 35797
24488, 3680, 3681, 3704, 3703, 12225, 12226, 12249, 12248, 0, 0, 0, 0, 13150, 13196, 13197, 
13194, 35775, 35776, 35799, 35798
24489, 3681, 3682, 3705, 3704, 12226, 12227, 12250, 12249, 0, 0, 0, 0, 13152, 13198, 13199, 
13196, 35776, 35777, 35800, 35799
24490, 3682, 3683, 3706, 3705, 12227, 12228, 12251, 12250, 0, 0, 0, 0, 13154, 13200, 13201, 
13198, 35777, 35778, 35801, 35800
24491, 3683, 3684, 3707, 3706, 12228, 12229, 12252, 12251, 0, 0, 0, 0, 13156, 13202, 13203, 
13200, 35778, 35779, 35802, 35801
24492, 3684, 3685, 3708, 3707, 12229, 12230, 12253, 12252, 0, 0, 0, 0, 13158, 13204, 13205, 
13202, 35779, 35780, 35803, 35802
24493, 3685, 3686, 3709, 3708, 12230, 12231, 12254, 12253, 0, 0, 0, 0, 13160, 13206, 13207, 
13204, 35780, 35781, 35804, 35803
24494, 3686, 3687, 3710, 3709, 12231, 12232, 12255, 12254, 0, 0, 0, 0, 13162, 13208, 13209, 
13206, 35781, 35782, 35805, 35804
24495, 3687, 3688, 3711, 3710, 12232, 12233, 12256, 12255, 0, 0, 0, 0, 13164, 13210, 13211, 
13208, 35782, 35783, 35806, 35805
24496, 3688, 3689, 3712, 3711, 12233, 12234, 12257, 12256, 0, 0, 0, 0, 13166, 13212, 13213, 
13210, 35783, 35784, 35807, 35806
24497, 3689, 3690, 3713, 3712, 12234, 12235, 12258, 12257, 0, 0, 0, 0, 13168, 13214, 13215, 
13212, 35784, 35785, 35808, 35807
24498, 3690, 3691, 3714, 3713, 12235, 12236, 12259, 12258, 0, 0, 0, 0, 13170, 13216, 13217, 
13214, 35785, 35786, 35809, 35808
24499, 3691, 3692, 3715, 3714, 12236, 12237, 12260, 12259, 0, 0, 0, 0, 13172, 13218, 13219, 
13216, 35786, 35787, 35810, 35809
24500, 3692, 3693, 3716, 3715, 12237, 12238, 12261, 12260, 0, 0, 0, 0, 13174, 13220, 13221, 
13218, 35787, 35788, 35811, 35810
24501, 3693, 372, 373, 3716, 12238, 1651, 1652, 12261, 0, 0, 0, 0, 13175, 1675, 13222, 
13220, 35788, 11841, 11842, 35811
24502, 259, 3694, 3717, 260, 1605, 12239, 12262, 1606, 0, 0, 0, 0, 13177, 13223, 13224, 
1629, 11819, 35789, 35812, 11820
24503, 3694, 3695, 3718, 3717, 12239, 12240, 12263, 12262, 0, 0, 0, 0, 13179, 13225, 13226, 
13223, 35789, 35790, 35813, 35812
24504, 3695, 3696, 3719, 3718, 12240, 12241, 12264, 12263, 0, 0, 0, 0, 13181, 13227, 13228, 
13225, 35790, 35791, 35814, 35813
24505, 3696, 3697, 3720, 3719, 12241, 12242, 12265, 12264, 0, 0, 0, 0, 13183, 13229, 13230, 
13227, 35791, 35792, 35815, 35814
24506, 3697, 3698, 3721, 3720, 12242, 12243, 12266, 12265, 0, 0, 0, 0, 13185, 13231, 13232, 
13229, 35792, 35793, 35816, 35815
24507, 3698, 3699, 3722, 3721, 12243, 12244, 12267, 12266, 0, 0, 0, 0, 13187, 13233, 13234, 
13231, 35793, 35794, 35817, 35816
24508, 3699, 3700, 3723, 3722, 12244, 12245, 12268, 12267, 0, 0, 0, 0, 13189, 13235, 13236, 
13233, 35794, 35795, 35818, 35817
24509, 3700, 3701, 3724, 3723, 12245, 12246, 12269, 12268, 0, 0, 0, 0, 13191, 13237, 13238, 
13235, 35795, 35796, 35819, 35818
24510, 3701, 3702, 3725, 3724, 12246, 12247, 12270, 12269, 0, 0, 0, 0, 13193, 13239, 13240, 
13237, 35796, 35797, 35820, 35819
24511, 3702, 3703, 3726, 3725, 12247, 12248, 12271, 12270, 0, 0, 0, 0, 13195, 13241, 13242, 
13239, 35797, 35798, 35821, 35820
24512, 3703, 3704, 3727, 3726, 12248, 12249, 12272, 12271, 0, 0, 0, 0, 13197, 13243, 13244, 
13241, 35798, 35799, 35822, 35821
24513, 3704, 3705, 3728, 3727, 12249, 12250, 12273, 12272, 0, 0, 0, 0, 13199, 13245, 13246, 
13243, 35799, 35800, 35823, 35822
24514, 3705, 3706, 3729, 3728, 12250, 12251, 12274, 12273, 0, 0, 0, 0, 13201, 13247, 13248, 
13245, 35800, 35801, 35824, 35823
24515, 3706, 3707, 3730, 3729, 12251, 12252, 12275, 12274, 0, 0, 0, 0, 13203, 13249, 13250, 
13247, 35801, 35802, 35825, 35824
24516, 3707, 3708, 3731, 3730, 12252, 12253, 12276, 12275, 0, 0, 0, 0, 13205, 13251, 13252, 
13249, 35802, 35803, 35826, 35825
24517, 3708, 3709, 3732, 3731, 12253, 12254, 12277, 12276, 0, 0, 0, 0, 13207, 13253, 13254, 
13251, 35803, 35804, 35827, 35826
24518, 3709, 3710, 3733, 3732, 12254, 12255, 12278, 12277, 0, 0, 0, 0, 13209, 13255, 13256, 
13253, 35804, 35805, 35828, 35827
24519, 3710, 3711, 3734, 3733, 12255, 12256, 12279, 12278, 0, 0, 0, 0, 13211, 13257, 13258, 
13255, 35805, 35806, 35829, 35828
24520, 3711, 3712, 3735, 3734, 12256, 12257, 12280, 12279, 0, 0, 0, 0, 13213, 13259, 13260, 
13257, 35806, 35807, 35830, 35829
24521, 3712, 3713, 3736, 3735, 12257, 12258, 12281, 12280, 0, 0, 0, 0, 13215, 13261, 13262, 
13259, 35807, 35808, 35831, 35830
24522, 3713, 3714, 3737, 3736, 12258, 12259, 12282, 12281, 0, 0, 0, 0, 13217, 13263, 13264, 
13261, 35808, 35809, 35832, 35831
24523, 3714, 3715, 3738, 3737, 12259, 12260, 12283, 12282, 0, 0, 0, 0, 13219, 13265, 13266, 
13263, 35809, 35810, 35833, 35832
24524, 3715, 3716, 3739, 3738, 12260, 12261, 12284, 12283, 0, 0, 0, 0, 13221, 13267, 13268, 
13265, 35810, 35811, 35834, 35833
24525, 3716, 373, 374, 3739, 12261, 1652, 1653, 12284, 0, 0, 0, 0, 13222, 1676, 13269, 
13267, 35811, 11842, 11843, 35834
24526, 260, 3717, 3740, 261, 1606, 12262, 12285, 1607, 0, 0, 0, 0, 13224, 13270, 13271, 
1630, 11820, 35812, 35835, 11821
24527, 3717, 3718, 3741, 3740, 12262, 12263, 12286, 12285, 0, 0, 0, 0, 13226, 13272, 13273, 
13270, 35812, 35813, 35836, 35835
24528, 3718, 3719, 3742, 3741, 12263, 12264, 12287, 12286, 0, 0, 0, 0, 13228, 13274, 13275, 
13272, 35813, 35814, 35837, 35836
24529, 3719, 3720, 3743, 3742, 12264, 12265, 12288, 12287, 0, 0, 0, 0, 13230, 13276, 13277, 
13274, 35814, 35815, 35838, 35837
24530, 3720, 3721, 3744, 3743, 12265, 12266, 12289, 12288, 0, 0, 0, 0, 13232, 13278, 13279, 
13276, 35815, 35816, 35839, 35838
24531, 3721, 3722, 3745, 3744, 12266, 12267, 12290, 12289, 0, 0, 0, 0, 13234, 13280, 13281, 
13278, 35816, 35817, 35840, 35839
24532, 3722, 3723, 3746, 3745, 12267, 12268, 12291, 12290, 0, 0, 0, 0, 13236, 13282, 13283, 
13280, 35817, 35818, 35841, 35840
24533, 3723, 3724, 3747, 3746, 12268, 12269, 12292, 12291, 0, 0, 0, 0, 13238, 13284, 13285, 
13282, 35818, 35819, 35842, 35841
24534, 3724, 3725, 3748, 3747, 12269, 12270, 12293, 12292, 0, 0, 0, 0, 13240, 13286, 13287, 
13284, 35819, 35820, 35843, 35842
24535, 3725, 3726, 3749, 3748, 12270, 12271, 12294, 12293, 0, 0, 0, 0, 13242, 13288, 13289, 
13286, 35820, 35821, 35844, 35843
24536, 3726, 3727, 3750, 3749, 12271, 12272, 12295, 12294, 0, 0, 0, 0, 13244, 13290, 13291, 
13288, 35821, 35822, 35845, 35844
24537, 3727, 3728, 3751, 3750, 12272, 12273, 12296, 12295, 0, 0, 0, 0, 13246, 13292, 13293, 
13290, 35822, 35823, 35846, 35845
24538, 3728, 3729, 3752, 3751, 12273, 12274, 12297, 12296, 0, 0, 0, 0, 13248, 13294, 13295, 
13292, 35823, 35824, 35847, 35846
24539, 3729, 3730, 3753, 3752, 12274, 12275, 12298, 12297, 0, 0, 0, 0, 13250, 13296, 13297, 
13294, 35824, 35825, 35848, 35847
24540, 3730, 3731, 3754, 3753, 12275, 12276, 12299, 12298, 0, 0, 0, 0, 13252, 13298, 13299, 
13296, 35825, 35826, 35849, 35848
24541, 3731, 3732, 3755, 3754, 12276, 12277, 12300, 12299, 0, 0, 0, 0, 13254, 13300, 13301, 
13298, 35826, 35827, 35850, 35849
24542, 3732, 3733, 3756, 3755, 12277, 12278, 12301, 12300, 0, 0, 0, 0, 13256, 13302, 13303, 
13300, 35827, 35828, 35851, 35850
24543, 3733, 3734, 3757, 3756, 12278, 12279, 12302, 12301, 0, 0, 0, 0, 13258, 13304, 13305, 
13302, 35828, 35829, 35852, 35851
24544, 3734, 3735, 3758, 3757, 12279, 12280, 12303, 12302, 0, 0, 0, 0, 13260, 13306, 13307, 
13304, 35829, 35830, 35853, 35852
24545, 3735, 3736, 3759, 3758, 12280, 12281, 12304, 12303, 0, 0, 0, 0, 13262, 13308, 13309, 
13306, 35830, 35831, 35854, 35853
24546, 3736, 3737, 3760, 3759, 12281, 12282, 12305, 12304, 0, 0, 0, 0, 13264, 13310, 13311, 
13308, 35831, 35832, 35855, 35854
24547, 3737, 3738, 3761, 3760, 12282, 12283, 12306, 12305, 0, 0, 0, 0, 13266, 13312, 13313, 
13310, 35832, 35833, 35856, 35855
24548, 3738, 3739, 3762, 3761, 12283, 12284, 12307, 12306, 0, 0, 0, 0, 13268, 13314, 13315, 
13312, 35833, 35834, 35857, 35856
24549, 3739, 374, 375, 3762, 12284, 1653, 1654, 12307, 0, 0, 0, 0, 13269, 1677, 13316, 
13314, 35834, 11843, 11844, 35857
24550, 261, 3740, 3763, 262, 1607, 12285, 12308, 1608, 0, 0, 0, 0, 13271, 13317, 13318, 
1631, 11821, 35835, 35858, 11822
24551, 3740, 3741, 3764, 3763, 12285, 12286, 12309, 12308, 0, 0, 0, 0, 13273, 13319, 13320, 
13317, 35835, 35836, 35859, 35858
24552, 3741, 3742, 3765, 3764, 12286, 12287, 12310, 12309, 0, 0, 0, 0, 13275, 13321, 13322, 
13319, 35836, 35837, 35860, 35859
24553, 3742, 3743, 3766, 3765, 12287, 12288, 12311, 12310, 0, 0, 0, 0, 13277, 13323, 13324, 
13321, 35837, 35838, 35861, 35860
24554, 3743, 3744, 3767, 3766, 12288, 12289, 12312, 12311, 0, 0, 0, 0, 13279, 13325, 13326, 
13323, 35838, 35839, 35862, 35861
24555, 3744, 3745, 3768, 3767, 12289, 12290, 12313, 12312, 0, 0, 0, 0, 13281, 13327, 13328, 
13325, 35839, 35840, 35863, 35862
24556, 3745, 3746, 3769, 3768, 12290, 12291, 12314, 12313, 0, 0, 0, 0, 13283, 13329, 13330, 
13327, 35840, 35841, 35864, 35863
24557, 3746, 3747, 3770, 3769, 12291, 12292, 12315, 12314, 0, 0, 0, 0, 13285, 13331, 13332, 
13329, 35841, 35842, 35865, 35864
24558, 3747, 3748, 3771, 3770, 12292, 12293, 12316, 12315, 0, 0, 0, 0, 13287, 13333, 13334, 
13331, 35842, 35843, 35866, 35865
24559, 3748, 3749, 3772, 3771, 12293, 12294, 12317, 12316, 0, 0, 0, 0, 13289, 13335, 13336, 
13333, 35843, 35844, 35867, 35866
24560, 3749, 3750, 3773, 3772, 12294, 12295, 12318, 12317, 0, 0, 0, 0, 13291, 13337, 13338, 
13335, 35844, 35845, 35868, 35867
24561, 3750, 3751, 3774, 3773, 12295, 12296, 12319, 12318, 0, 0, 0, 0, 13293, 13339, 13340, 
13337, 35845, 35846, 35869, 35868
24562, 3751, 3752, 3775, 3774, 12296, 12297, 12320, 12319, 0, 0, 0, 0, 13295, 13341, 13342, 
13339, 35846, 35847, 35870, 35869
24563, 3752, 3753, 3776, 3775, 12297, 12298, 12321, 12320, 0, 0, 0, 0, 13297, 13343, 13344, 
13341, 35847, 35848, 35871, 35870
24564, 3753, 3754, 3777, 3776, 12298, 12299, 12322, 12321, 0, 0, 0, 0, 13299, 13345, 13346, 
13343, 35848, 35849, 35872, 35871
24565, 3754, 3755, 3778, 3777, 12299, 12300, 12323, 12322, 0, 0, 0, 0, 13301, 13347, 13348, 
13345, 35849, 35850, 35873, 35872
24566, 3755, 3756, 3779, 3778, 12300, 12301, 12324, 12323, 0, 0, 0, 0, 13303, 13349, 13350, 
13347, 35850, 35851, 35874, 35873
24567, 3756, 3757, 3780, 3779, 12301, 12302, 12325, 12324, 0, 0, 0, 0, 13305, 13351, 13352, 
13349, 35851, 35852, 35875, 35874
24568, 3757, 3758, 3781, 3780, 12302, 12303, 12326, 12325, 0, 0, 0, 0, 13307, 13353, 13354, 
13351, 35852, 35853, 35876, 35875
24569, 3758, 3759, 3782, 3781, 12303, 12304, 12327, 12326, 0, 0, 0, 0, 13309, 13355, 13356, 
13353, 35853, 35854, 35877, 35876
24570, 3759, 3760, 3783, 3782, 12304, 12305, 12328, 12327, 0, 0, 0, 0, 13311, 13357, 13358, 
13355, 35854, 35855, 35878, 35877
24571, 3760, 3761, 3784, 3783, 12305, 12306, 12329, 12328, 0, 0, 0, 0, 13313, 13359, 13360, 
13357, 35855, 35856, 35879, 35878
24572, 3761, 3762, 3785, 3784, 12306, 12307, 12330, 12329, 0, 0, 0, 0, 13315, 13361, 13362, 
13359, 35856, 35857, 35880, 35879
24573, 3762, 375, 376, 3785, 12307, 1654, 1655, 12330, 0, 0, 0, 0, 13316, 1678, 13363, 
13361, 35857, 11844, 11845, 35880
24574, 262, 3763, 3786, 263, 1608, 12308, 12331, 1609, 0, 0, 0, 0, 13318, 13364, 13365, 
1632, 11822, 35858, 35881, 11823
24575, 3763, 3764, 3787, 3786, 12308, 12309, 12332, 12331, 0, 0, 0, 0, 13320, 13366, 13367, 
13364, 35858, 35859, 35882, 35881
24576, 3764, 3765, 3788, 3787, 12309, 12310, 12333, 12332, 0, 0, 0, 0, 13322, 13368, 13369, 
13366, 35859, 35860, 35883, 35882
24577, 3765, 3766, 3789, 3788, 12310, 12311, 12334, 12333, 0, 0, 0, 0, 13324, 13370, 13371, 
13368, 35860, 35861, 35884, 35883
24578, 3766, 3767, 3790, 3789, 12311, 12312, 12335, 12334, 0, 0, 0, 0, 13326, 13372, 13373, 
13370, 35861, 35862, 35885, 35884
24579, 3767, 3768, 3791, 3790, 12312, 12313, 12336, 12335, 0, 0, 0, 0, 13328, 13374, 13375, 
13372, 35862, 35863, 35886, 35885
24580, 3768, 3769, 3792, 3791, 12313, 12314, 12337, 12336, 0, 0, 0, 0, 13330, 13376, 13377, 
13374, 35863, 35864, 35887, 35886
24581, 3769, 3770, 3793, 3792, 12314, 12315, 12338, 12337, 0, 0, 0, 0, 13332, 13378, 13379, 
13376, 35864, 35865, 35888, 35887
24582, 3770, 3771, 3794, 3793, 12315, 12316, 12339, 12338, 0, 0, 0, 0, 13334, 13380, 13381, 
13378, 35865, 35866, 35889, 35888
24583, 3771, 3772, 3795, 3794, 12316, 12317, 12340, 12339, 0, 0, 0, 0, 13336, 13382, 13383, 
13380, 35866, 35867, 35890, 35889
24584, 3772, 3773, 3796, 3795, 12317, 12318, 12341, 12340, 0, 0, 0, 0, 13338, 13384, 13385, 
13382, 35867, 35868, 35891, 35890
24585, 3773, 3774, 3797, 3796, 12318, 12319, 12342, 12341, 0, 0, 0, 0, 13340, 13386, 13387, 
13384, 35868, 35869, 35892, 35891
24586, 3774, 3775, 3798, 3797, 12319, 12320, 12343, 12342, 0, 0, 0, 0, 13342, 13388, 13389, 
13386, 35869, 35870, 35893, 35892
24587, 3775, 3776, 3799, 3798, 12320, 12321, 12344, 12343, 0, 0, 0, 0, 13344, 13390, 13391, 
13388, 35870, 35871, 35894, 35893
24588, 3776, 3777, 3800, 3799, 12321, 12322, 12345, 12344, 0, 0, 0, 0, 13346, 13392, 13393, 
13390, 35871, 35872, 35895, 35894
24589, 3777, 3778, 3801, 3800, 12322, 12323, 12346, 12345, 0, 0, 0, 0, 13348, 13394, 13395, 
13392, 35872, 35873, 35896, 35895
24590, 3778, 3779, 3802, 3801, 12323, 12324, 12347, 12346, 0, 0, 0, 0, 13350, 13396, 13397, 
13394, 35873, 35874, 35897, 35896
24591, 3779, 3780, 3803, 3802, 12324, 12325, 12348, 12347, 0, 0, 0, 0, 13352, 13398, 13399, 
13396, 35874, 35875, 35898, 35897
24592, 3780, 3781, 3804, 3803, 12325, 12326, 12349, 12348, 0, 0, 0, 0, 13354, 13400, 13401, 
13398, 35875, 35876, 35899, 35898
24593, 3781, 3782, 3805, 3804, 12326, 12327, 12350, 12349, 0, 0, 0, 0, 13356, 13402, 13403, 
13400, 35876, 35877, 35900, 35899
24594, 3782, 3783, 3806, 3805, 12327, 12328, 12351, 12350, 0, 0, 0, 0, 13358, 13404, 13405, 
13402, 35877, 35878, 35901, 35900
24595, 3783, 3784, 3807, 3806, 12328, 12329, 12352, 12351, 0, 0, 0, 0, 13360, 13406, 13407, 
13404, 35878, 35879, 35902, 35901
24596, 3784, 3785, 3808, 3807, 12329, 12330, 12353, 12352, 0, 0, 0, 0, 13362, 13408, 13409, 
13406, 35879, 35880, 35903, 35902
24597, 3785, 376, 377, 3808, 12330, 1655, 1656, 12353, 0, 0, 0, 0, 13363, 1679, 13410, 
13408, 35880, 11845, 11846, 35903
24598, 263, 3786, 3809, 264, 1609, 12331, 12354, 1610, 0, 0, 0, 0, 13365, 13411, 13412, 
1633, 11823, 35881, 35904, 11824
24599, 3786, 3787, 3810, 3809, 12331, 12332, 12355, 12354, 0, 0, 0, 0, 13367, 13413, 13414, 
13411, 35881, 35882, 35905, 35904
24600, 3787, 3788, 3811, 3810, 12332, 12333, 12356, 12355, 0, 0, 0, 0, 13369, 13415, 13416, 
13413, 35882, 35883, 35906, 35905
24601, 3788, 3789, 3812, 3811, 12333, 12334, 12357, 12356, 0, 0, 0, 0, 13371, 13417, 13418, 
13415, 35883, 35884, 35907, 35906
24602, 3789, 3790, 3813, 3812, 12334, 12335, 12358, 12357, 0, 0, 0, 0, 13373, 13419, 13420, 
13417, 35884, 35885, 35908, 35907
24603, 3790, 3791, 3814, 3813, 12335, 12336, 12359, 12358, 0, 0, 0, 0, 13375, 13421, 13422, 
13419, 35885, 35886, 35909, 35908
24604, 3791, 3792, 3815, 3814, 12336, 12337, 12360, 12359, 0, 0, 0, 0, 13377, 13423, 13424, 
13421, 35886, 35887, 35910, 35909
24605, 3792, 3793, 3816, 3815, 12337, 12338, 12361, 12360, 0, 0, 0, 0, 13379, 13425, 13426, 
13423, 35887, 35888, 35911, 35910
24606, 3793, 3794, 3817, 3816, 12338, 12339, 12362, 12361, 0, 0, 0, 0, 13381, 13427, 13428, 
13425, 35888, 35889, 35912, 35911
24607, 3794, 3795, 3818, 3817, 12339, 12340, 12363, 12362, 0, 0, 0, 0, 13383, 13429, 13430, 
13427, 35889, 35890, 35913, 35912
24608, 3795, 3796, 3819, 3818, 12340, 12341, 12364, 12363, 0, 0, 0, 0, 13385, 13431, 13432, 
13429, 35890, 35891, 35914, 35913
24609, 3796, 3797, 3820, 3819, 12341, 12342, 12365, 12364, 0, 0, 0, 0, 13387, 13433, 13434, 
13431, 35891, 35892, 35915, 35914
24610, 3797, 3798, 3821, 3820, 12342, 12343, 12366, 12365, 0, 0, 0, 0, 13389, 13435, 13436, 
13433, 35892, 35893, 35916, 35915
24611, 3798, 3799, 3822, 3821, 12343, 12344, 12367, 12366, 0, 0, 0, 0, 13391, 13437, 13438, 
13435, 35893, 35894, 35917, 35916
24612, 3799, 3800, 3823, 3822, 12344, 12345, 12368, 12367, 0, 0, 0, 0, 13393, 13439, 13440, 
13437, 35894, 35895, 35918, 35917
24613, 3800, 3801, 3824, 3823, 12345, 12346, 12369, 12368, 0, 0, 0, 0, 13395, 13441, 13442, 
13439, 35895, 35896, 35919, 35918
24614, 3801, 3802, 3825, 3824, 12346, 12347, 12370, 12369, 0, 0, 0, 0, 13397, 13443, 13444, 
13441, 35896, 35897, 35920, 35919
24615, 3802, 3803, 3826, 3825, 12347, 12348, 12371, 12370, 0, 0, 0, 0, 13399, 13445, 13446, 
13443, 35897, 35898, 35921, 35920
24616, 3803, 3804, 3827, 3826, 12348, 12349, 12372, 12371, 0, 0, 0, 0, 13401, 13447, 13448, 
13445, 35898, 35899, 35922, 35921
24617, 3804, 3805, 3828, 3827, 12349, 12350, 12373, 12372, 0, 0, 0, 0, 13403, 13449, 13450, 
13447, 35899, 35900, 35923, 35922
24618, 3805, 3806, 3829, 3828, 12350, 12351, 12374, 12373, 0, 0, 0, 0, 13405, 13451, 13452, 
13449, 35900, 35901, 35924, 35923
24619, 3806, 3807, 3830, 3829, 12351, 12352, 12375, 12374, 0, 0, 0, 0, 13407, 13453, 13454, 
13451, 35901, 35902, 35925, 35924
24620, 3807, 3808, 3831, 3830, 12352, 12353, 12376, 12375, 0, 0, 0, 0, 13409, 13455, 13456, 
13453, 35902, 35903, 35926, 35925
24621, 3808, 377, 378, 3831, 12353, 1656, 1657, 12376, 0, 0, 0, 0, 13410, 1680, 13457, 
13455, 35903, 11846, 11847, 35926
24622, 264, 3809, 310, 9, 1610, 12354, 1492, 65, 0, 0, 0, 0, 13412, 13458, 1515, 
1634, 11824, 35904, 11756, 1490
24623, 3809, 3810, 311, 310, 12354, 12355, 1493, 1492, 0, 0, 0, 0, 13414, 13459, 1516, 
13458, 35904, 35905, 11757, 11756
24624, 3810, 3811, 312, 311, 12355, 12356, 1494, 1493, 0, 0, 0, 0, 13416, 13460, 1517, 
13459, 35905, 35906, 11758, 11757
24625, 3811, 3812, 313, 312, 12356, 12357, 1495, 1494, 0, 0, 0, 0, 13418, 13461, 1518, 
13460, 35906, 35907, 11759, 11758
24626, 3812, 3813, 314, 313, 12357, 12358, 1496, 1495, 0, 0, 0, 0, 13420, 13462, 1519, 
13461, 35907, 35908, 11760, 11759
24627, 3813, 3814, 315, 314, 12358, 12359, 1497, 1496, 0, 0, 0, 0, 13422, 13463, 1520, 
13462, 35908, 35909, 11761, 11760
24628, 3814, 3815, 316, 315, 12359, 12360, 1498, 1497, 0, 0, 0, 0, 13424, 13464, 1521, 
13463, 35909, 35910, 11762, 11761
24629, 3815, 3816, 317, 316, 12360, 12361, 1499, 1498, 0, 0, 0, 0, 13426, 13465, 1522, 
13464, 35910, 35911, 11763, 11762
24630, 3816, 3817, 318, 317, 12361, 12362, 1500, 1499, 0, 0, 0, 0, 13428, 13466, 1523, 
13465, 35911, 35912, 11764, 11763
24631, 3817, 3818, 319, 318, 12362, 12363, 1501, 1500, 0, 0, 0, 0, 13430, 13467, 1524, 
13466, 35912, 35913, 11765, 11764
24632, 3818, 3819, 320, 319, 12363, 12364, 1502, 1501, 0, 0, 0, 0, 13432, 13468, 1525, 
13467, 35913, 35914, 11766, 11765
24633, 3819, 3820, 321, 320, 12364, 12365, 1503, 1502, 0, 0, 0, 0, 13434, 13469, 1526, 
13468, 35914, 35915, 11767, 11766
24634, 3820, 3821, 322, 321, 12365, 12366, 1504, 1503, 0, 0, 0, 0, 13436, 13470, 1527, 
13469, 35915, 35916, 11768, 11767
24635, 3821, 3822, 323, 322, 12366, 12367, 1505, 1504, 0, 0, 0, 0, 13438, 13471, 1528, 
13470, 35916, 35917, 11769, 11768
24636, 3822, 3823, 324, 323, 12367, 12368, 1506, 1505, 0, 0, 0, 0, 13440, 13472, 1529, 
13471, 35917, 35918, 11770, 11769
24637, 3823, 3824, 325, 324, 12368, 12369, 1507, 1506, 0, 0, 0, 0, 13442, 13473, 1530, 
13472, 35918, 35919, 11771, 11770
24638, 3824, 3825, 326, 325, 12369, 12370, 1508, 1507, 0, 0, 0, 0, 13444, 13474, 1531, 
13473, 35919, 35920, 11772, 11771
24639, 3825, 3826, 327, 326, 12370, 12371, 1509, 1508, 0, 0, 0, 0, 13446, 13475, 1532, 
13474, 35920, 35921, 11773, 11772
24640, 3826, 3827, 328, 327, 12371, 12372, 1510, 1509, 0, 0, 0, 0, 13448, 13476, 1533, 
13475, 35921, 35922, 11774, 11773
24641, 3827, 3828, 329, 328, 12372, 12373, 1511, 1510, 0, 0, 0, 0, 13450, 13477, 1534, 
13476, 35922, 35923, 11775, 11774
24642, 3828, 3829, 330, 329, 12373, 12374, 1512, 1511, 0, 0, 0, 0, 13452, 13478, 1535, 
13477, 35923, 35924, 11776, 11775
24643, 3829, 3830, 331, 330, 12374, 12375, 1513, 1512, 0, 0, 0, 0, 13454, 13479, 1536, 
13478, 35924, 35925, 11777, 11776
24644, 3830, 3831, 332, 331, 12375, 12376, 1514, 1513, 0, 0, 0, 0, 13456, 13480, 1537, 
13479, 35925, 35926, 11778, 11777
24645, 3831, 378, 13, 332, 12376, 1657, 66, 1514, 0, 0, 0, 0, 13457, 1681, 1538, 
13480, 35926, 11847, 1491, 11778
*ELEMENT, type=C3D20, ELSET=Volume15
24646, 35, 797, 7290, 911, 69, 1780, 13573, 1684, 0, 0, 0, 0, 1803, 14102, 14103, 
1707, 1682, 13527, 35927, 13481
24647, 911, 7290, 7291, 912, 1684, 13573, 13574, 1685, 0, 0, 0, 0, 14103, 14104, 14105, 
1708, 13481, 35927, 35928, 13482
24648, 912, 7291, 7292, 913, 1685, 13574, 13575, 1686, 0, 0, 0, 0, 14105, 14106, 14107, 
1709, 13482, 35928, 35929, 13483
24649, 913, 7292, 7293, 914, 1686, 13575, 13576, 1687, 0, 0, 0, 0, 14107, 14108, 14109, 
1710, 13483, 35929, 35930, 13484
24650, 914, 7293, 7294, 915, 1687, 13576, 13577, 1688, 0, 0, 0, 0, 14109, 14110, 14111, 
1711, 13484, 35930, 35931, 13485
24651, 915, 7294, 7295, 916, 1688, 13577, 13578, 1689, 0, 0, 0, 0, 14111, 14112, 14113, 
1712, 13485, 35931, 35932, 13486
24652, 916, 7295, 7296, 917, 1689, 13578, 13579, 1690, 0, 0, 0, 0, 14113, 14114, 14115, 
1713, 13486, 35932, 35933, 13487
24653, 917, 7296, 7297, 918, 1690, 13579, 13580, 1691, 0, 0, 0, 0, 14115, 14116, 14117, 
1714, 13487, 35933, 35934, 13488
24654, 918, 7297, 7298, 919, 1691, 13580, 13581, 1692, 0, 0, 0, 0, 14117, 14118, 14119, 
1715, 13488, 35934, 35935, 13489
24655, 919, 7298, 7299, 920, 1692, 13581, 13582, 1693, 0, 0, 0, 0, 14119, 14120, 14121, 
1716, 13489, 35935, 35936, 13490
24656, 920, 7299, 7300, 921, 1693, 13582, 13583, 1694, 0, 0, 0, 0, 14121, 14122, 14123, 
1717, 13490, 35936, 35937, 13491
24657, 921, 7300, 7301, 922, 1694, 13583, 13584, 1695, 0, 0, 0, 0, 14123, 14124, 14125, 
1718, 13491, 35937, 35938, 13492
24658, 922, 7301, 7302, 923, 1695, 13584, 13585, 1696, 0, 0, 0, 0, 14125, 14126, 14127, 
1719, 13492, 35938, 35939, 13493
24659, 923, 7302, 7303, 924, 1696, 13585, 13586, 1697, 0, 0, 0, 0, 14127, 14128, 14129, 
1720, 13493, 35939, 35940, 13494
24660, 924, 7303, 7304, 925, 1697, 13586, 13587, 1698, 0, 0, 0, 0, 14129, 14130, 14131, 
1721, 13494, 35940, 35941, 13495
24661, 925, 7304, 7305, 926, 1698, 13587, 13588, 1699, 0, 0, 0, 0, 14131, 14132, 14133, 
1722, 13495, 35941, 35942, 13496
24662, 926, 7305, 7306, 927, 1699, 13588, 13589, 1700, 0, 0, 0, 0, 14133, 14134, 14135, 
1723, 13496, 35942, 35943, 13497
24663, 927, 7306, 7307, 928, 1700, 13589, 13590, 1701, 0, 0, 0, 0, 14135, 14136, 14137, 
1724, 13497, 35943, 35944, 13498
24664, 928, 7307, 7308, 929, 1701, 13590, 13591, 1702, 0, 0, 0, 0, 14137, 14138, 14139, 
1725, 13498, 35944, 35945, 13499
24665, 929, 7308, 7309, 930, 1702, 13591, 13592, 1703, 0, 0, 0, 0, 14139, 14140, 14141, 
1726, 13499, 35945, 35946, 13500
24666, 930, 7309, 7310, 931, 1703, 13592, 13593, 1704, 0, 0, 0, 0, 14141, 14142, 14143, 
1727, 13500, 35946, 35947, 13501
24667, 931, 7310, 7311, 932, 1704, 13593, 13594, 1705, 0, 0, 0, 0, 14143, 14144, 14145, 
1728, 13501, 35947, 35948, 13502
24668, 932, 7311, 7312, 933, 1705, 13594, 13595, 1706, 0, 0, 0, 0, 14145, 14146, 14147, 
1729, 13502, 35948, 35949, 13503
24669, 933, 7312, 957, 39, 1706, 13595, 1827, 70, 0, 0, 0, 0, 14147, 14148, 1850, 
1730, 13503, 35949, 13550, 1683
24670, 797, 798, 7313, 7290, 1780, 1781, 13596, 13573, 0, 0, 0, 0, 1804, 14149, 14150, 
14102, 13527, 13528, 35950, 35927
24671, 7290, 7313, 7314, 7291, 13573, 13596, 13597, 13574, 0, 0, 0, 0, 14150, 14151, 14152, 
14104, 35927, 35950, 35951, 35928
24672, 7291, 7314, 7315, 7292, 13574, 13597, 13598, 13575, 0, 0, 0, 0, 14152, 14153, 14154, 
14106, 35928, 35951, 35952, 35929
24673, 7292, 7315, 7316, 7293, 13575, 13598, 13599, 13576, 0, 0, 0, 0, 14154, 14155, 14156, 
14108, 35929, 35952, 35953, 35930
24674, 7293, 7316, 7317, 7294, 13576, 13599, 13600, 13577, 0, 0, 0, 0, 14156, 14157, 14158, 
14110, 35930, 35953, 35954, 35931
24675, 7294, 7317, 7318, 7295, 13577, 13600, 13601, 13578, 0, 0, 0, 0, 14158, 14159, 14160, 
14112, 35931, 35954, 35955, 35932
24676, 7295, 7318, 7319, 7296, 13578, 13601, 13602, 13579, 0, 0, 0, 0, 14160, 14161, 14162, 
14114, 35932, 35955, 35956, 35933
24677, 7296, 7319, 7320, 7297, 13579, 13602, 13603, 13580, 0, 0, 0, 0, 14162, 14163, 14164, 
14116, 35933, 35956, 35957, 35934
24678, 7297, 7320, 7321, 7298, 13580, 13603, 13604, 13581, 0, 0, 0, 0, 14164, 14165, 14166, 
14118, 35934, 35957, 35958, 35935
24679, 7298, 7321, 7322, 7299, 13581, 13604, 13605, 13582, 0, 0, 0, 0, 14166, 14167, 14168, 
14120, 35935, 35958, 35959, 35936
24680, 7299, 7322, 7323, 7300, 13582, 13605, 13606, 13583, 0, 0, 0, 0, 14168, 14169, 14170, 
14122, 35936, 35959, 35960, 35937
24681, 7300, 7323, 7324, 7301, 13583, 13606, 13607, 13584, 0, 0, 0, 0, 14170, 14171, 14172, 
14124, 35937, 35960, 35961, 35938
24682, 7301, 7324, 7325, 7302, 13584, 13607, 13608, 13585, 0, 0, 0, 0, 14172, 14173, 14174, 
14126, 35938, 35961, 35962, 35939
24683, 7302, 7325, 7326, 7303, 13585, 13608, 13609, 13586, 0, 0, 0, 0, 14174, 14175, 14176, 
14128, 35939, 35962, 35963, 35940
24684, 7303, 7326, 7327, 7304, 13586, 13609, 13610, 13587, 0, 0, 0, 0, 14176, 14177, 14178, 
14130, 35940, 35963, 35964, 35941
24685, 7304, 7327, 7328, 7305, 13587, 13610, 13611, 13588, 0, 0, 0, 0, 14178, 14179, 14180, 
14132, 35941, 35964, 35965, 35942
24686, 7305, 7328, 7329, 7306, 13588, 13611, 13612, 13589, 0, 0, 0, 0, 14180, 14181, 14182, 
14134, 35942, 35965, 35966, 35943
24687, 7306, 7329, 7330, 7307, 13589, 13612, 13613, 13590, 0, 0, 0, 0, 14182, 14183, 14184, 
14136, 35943, 35966, 35967, 35944
24688, 7307, 7330, 7331, 7308, 13590, 13613, 13614, 13591, 0, 0, 0, 0, 14184, 14185, 14186, 
14138, 35944, 35967, 35968, 35945
24689, 7308, 7331, 7332, 7309, 13591, 13614, 13615, 13592, 0, 0, 0, 0, 14186, 14187, 14188, 
14140, 35945, 35968, 35969, 35946
24690, 7309, 7332, 7333, 7310, 13592, 13615, 13616, 13593, 0, 0, 0, 0, 14188, 14189, 14190, 
14142, 35946, 35969, 35970, 35947
24691, 7310, 7333, 7334, 7311, 13593, 13616, 13617, 13594, 0, 0, 0, 0, 14190, 14191, 14192, 
14144, 35947, 35970, 35971, 35948
24692, 7311, 7334, 7335, 7312, 13594, 13617, 13618, 13595, 0, 0, 0, 0, 14192, 14193, 14194, 
14146, 35948, 35971, 35972, 35949
24693, 7312, 7335, 958, 957, 13595, 13618, 1828, 1827, 0, 0, 0, 0, 14194, 14195, 1851, 
14148, 35949, 35972, 13551, 13550
24694, 798, 799, 7336, 7313, 1781, 1782, 13619, 13596, 0, 0, 0, 0, 1805, 14196, 14197, 
14149, 13528, 13529, 35973, 35950
24695, 7313, 7336, 7337, 7314, 13596, 13619, 13620, 13597, 0, 0, 0, 0, 14197, 14198, 14199, 
14151, 35950, 35973, 35974, 35951
24696, 7314, 7337, 7338, 7315, 13597, 13620, 13621, 13598, 0, 0, 0, 0, 14199, 14200, 14201, 
14153, 35951, 35974, 35975, 35952
24697, 7315, 7338, 7339, 7316, 13598, 13621, 13622, 13599, 0, 0, 0, 0, 14201, 14202, 14203, 
14155, 35952, 35975, 35976, 35953
24698, 7316, 7339, 7340, 7317, 13599, 13622, 13623, 13600, 0, 0, 0, 0, 14203, 14204, 14205, 
14157, 35953, 35976, 35977, 35954
24699, 7317, 7340, 7341, 7318, 13600, 13623, 13624, 13601, 0, 0, 0, 0, 14205, 14206, 14207, 
14159, 35954, 35977, 35978, 35955
24700, 7318, 7341, 7342, 7319, 13601, 13624, 13625, 13602, 0, 0, 0, 0, 14207, 14208, 14209, 
14161, 35955, 35978, 35979, 35956
24701, 7319, 7342, 7343, 7320, 13602, 13625, 13626, 13603, 0, 0, 0, 0, 14209, 14210, 14211, 
14163, 35956, 35979, 35980, 35957
24702, 7320, 7343, 7344, 7321, 13603, 13626, 13627, 13604, 0, 0, 0, 0, 14211, 14212, 14213, 
14165, 35957, 35980, 35981, 35958
24703, 7321, 7344, 7345, 7322, 13604, 13627, 13628, 13605, 0, 0, 0, 0, 14213, 14214, 14215, 
14167, 35958, 35981, 35982, 35959
24704, 7322, 7345, 7346, 7323, 13605, 13628, 13629, 13606, 0, 0, 0, 0, 14215, 14216, 14217, 
14169, 35959, 35982, 35983, 35960
24705, 7323, 7346, 7347, 7324, 13606, 13629, 13630, 13607, 0, 0, 0, 0, 14217, 14218, 14219, 
14171, 35960, 35983, 35984, 35961
24706, 7324, 7347, 7348, 7325, 13607, 13630, 13631, 13608, 0, 0, 0, 0, 14219, 14220, 14221, 
14173, 35961, 35984, 35985, 35962
24707, 7325, 7348, 7349, 7326, 13608, 13631, 13632, 13609, 0, 0, 0, 0, 14221, 14222, 14223, 
14175, 35962, 35985, 35986, 35963
24708, 7326, 7349, 7350, 7327, 13609, 13632, 13633, 13610, 0, 0, 0, 0, 14223, 14224, 14225, 
14177, 35963, 35986, 35987, 35964
24709, 7327, 7350, 7351, 7328, 13610, 13633, 13634, 13611, 0, 0, 0, 0, 14225, 14226, 14227, 
14179, 35964, 35987, 35988, 35965
24710, 7328, 7351, 7352, 7329, 13611, 13634, 13635, 13612, 0, 0, 0, 0, 14227, 14228, 14229, 
14181, 35965, 35988, 35989, 35966
24711, 7329, 7352, 7353, 7330, 13612, 13635, 13636, 13613, 0, 0, 0, 0, 14229, 14230, 14231, 
14183, 35966, 35989, 35990, 35967
24712, 7330, 7353, 7354, 7331, 13613, 13636, 13637, 13614, 0, 0, 0, 0, 14231, 14232, 14233, 
14185, 35967, 35990, 35991, 35968
24713, 7331, 7354, 7355, 7332, 13614, 13637, 13638, 13615, 0, 0, 0, 0, 14233, 14234, 14235, 
14187, 35968, 35991, 35992, 35969
24714, 7332, 7355, 7356, 7333, 13615, 13638, 13639, 13616, 0, 0, 0, 0, 14235, 14236, 14237, 
14189, 35969, 35992, 35993, 35970
24715, 7333, 7356, 7357, 7334, 13616, 13639, 13640, 13617, 0, 0, 0, 0, 14237, 14238, 14239, 
14191, 35970, 35993, 35994, 35971
24716, 7334, 7357, 7358, 7335, 13617, 13640, 13641, 13618, 0, 0, 0, 0, 14239, 14240, 14241, 
14193, 35971, 35994, 35995, 35972
24717, 7335, 7358, 959, 958, 13618, 13641, 1829, 1828, 0, 0, 0, 0, 14241, 14242, 1852, 
14195, 35972, 35995, 13552, 13551
24718, 799, 800, 7359, 7336, 1782, 1783, 13642, 13619, 0, 0, 0, 0, 1806, 14243, 14244, 
14196, 13529, 13530, 35996, 35973
24719, 7336, 7359, 7360, 7337, 13619, 13642, 13643, 13620, 0, 0, 0, 0, 14244, 14245, 14246, 
14198, 35973, 35996, 35997, 35974
24720, 7337, 7360, 7361, 7338, 13620, 13643, 13644, 13621, 0, 0, 0, 0, 14246, 14247, 14248, 
14200, 35974, 35997, 35998, 35975
24721, 7338, 7361, 7362, 7339, 13621, 13644, 13645, 13622, 0, 0, 0, 0, 14248, 14249, 14250, 
14202, 35975, 35998, 35999, 35976
24722, 7339, 7362, 7363, 7340, 13622, 13645, 13646, 13623, 0, 0, 0, 0, 14250, 14251, 14252, 
14204, 35976, 35999, 36000, 35977
24723, 7340, 7363, 7364, 7341, 13623, 13646, 13647, 13624, 0, 0, 0, 0, 14252, 14253, 14254, 
14206, 35977, 36000, 36001, 35978
24724, 7341, 7364, 7365, 7342, 13624, 13647, 13648, 13625, 0, 0, 0, 0, 14254, 14255, 14256, 
14208, 35978, 36001, 36002, 35979
24725, 7342, 7365, 7366, 7343, 13625, 13648, 13649, 13626, 0, 0, 0, 0, 14256, 14257, 14258, 
14210, 35979, 36002, 36003, 35980
24726, 7343, 7366, 7367, 7344, 13626, 13649, 13650, 13627, 0, 0, 0, 0, 14258, 14259, 14260, 
14212, 35980, 36003, 36004, 35981
24727, 7344, 7367, 7368, 7345, 13627, 13650, 13651, 13628, 0, 0, 0, 0, 14260, 14261, 14262, 
14214, 35981, 36004, 36005, 35982
24728, 7345, 7368, 7369, 7346, 13628, 13651, 13652, 13629, 0, 0, 0, 0, 14262, 14263, 14264, 
14216, 35982, 36005, 36006, 35983
24729, 7346, 7369, 7370, 7347, 13629, 13652, 13653, 13630, 0, 0, 0, 0, 14264, 14265, 14266, 
14218, 35983, 36006, 36007, 35984
24730, 7347, 7370, 7371, 7348, 13630, 13653, 13654, 13631, 0, 0, 0, 0, 14266, 14267, 14268, 
14220, 35984, 36007, 36008, 35985
24731, 7348, 7371, 7372, 7349, 13631, 13654, 13655, 13632, 0, 0, 0, 0, 14268, 14269, 14270, 
14222, 35985, 36008, 36009, 35986
24732, 7349, 7372, 7373, 7350, 13632, 13655, 13656, 13633, 0, 0, 0, 0, 14270, 14271, 14272, 
14224, 35986, 36009, 36010, 35987
24733, 7350, 7373, 7374, 7351, 13633, 13656, 13657, 13634, 0, 0, 0, 0, 14272, 14273, 14274, 
14226, 35987, 36010, 36011, 35988
24734, 7351, 7374, 7375, 7352, 13634, 13657, 13658, 13635, 0, 0, 0, 0, 14274, 14275, 14276, 
14228, 35988, 36011, 36012, 35989
24735, 7352, 7375, 7376, 7353, 13635, 13658, 13659, 13636, 0, 0, 0, 0, 14276, 14277, 14278, 
14230, 35989, 36012, 36013, 35990
24736, 7353, 7376, 7377, 7354, 13636, 13659, 13660, 13637, 0, 0, 0, 0, 14278, 14279, 14280, 
14232, 35990, 36013, 36014, 35991
24737, 7354, 7377, 7378, 7355, 13637, 13660, 13661, 13638, 0, 0, 0, 0, 14280, 14281, 14282, 
14234, 35991, 36014, 36015, 35992
24738, 7355, 7378, 7379, 7356, 13638, 13661, 13662, 13639, 0, 0, 0, 0, 14282, 14283, 14284, 
14236, 35992, 36015, 36016, 35993
24739, 7356, 7379, 7380, 7357, 13639, 13662, 13663, 13640, 0, 0, 0, 0, 14284, 14285, 14286, 
14238, 35993, 36016, 36017, 35994
24740, 7357, 7380, 7381, 7358, 13640, 13663, 13664, 13641, 0, 0, 0, 0, 14286, 14287, 14288, 
14240, 35994, 36017, 36018, 35995
24741, 7358, 7381, 960, 959, 13641, 13664, 1830, 1829, 0, 0, 0, 0, 14288, 14289, 1853, 
14242, 35995, 36018, 13553, 13552
24742, 800, 801, 7382, 7359, 1783, 1784, 13665, 13642, 0, 0, 0, 0, 1807, 14290, 14291, 
14243, 13530, 13531, 36019, 35996
24743, 7359, 7382, 7383, 7360, 13642, 13665, 13666, 13643, 0, 0, 0, 0, 14291, 14292, 14293, 
14245, 35996, 36019, 36020, 35997
24744, 7360, 7383, 7384, 7361, 13643, 13666, 13667, 13644, 0, 0, 0, 0, 14293, 14294, 14295, 
14247, 35997, 36020, 36021, 35998
24745, 7361, 7384, 7385, 7362, 13644, 13667, 13668, 13645, 0, 0, 0, 0, 14295, 14296, 14297, 
14249, 35998, 36021, 36022, 35999
24746, 7362, 7385, 7386, 7363, 13645, 13668, 13669, 13646, 0, 0, 0, 0, 14297, 14298, 14299, 
14251, 35999, 36022, 36023, 36000
24747, 7363, 7386, 7387, 7364, 13646, 13669, 13670, 13647, 0, 0, 0, 0, 14299, 14300, 14301, 
14253, 36000, 36023, 36024, 36001
24748, 7364, 7387, 7388, 7365, 13647, 13670, 13671, 13648, 0, 0, 0, 0, 14301, 14302, 14303, 
14255, 36001, 36024, 36025, 36002
24749, 7365, 7388, 7389, 7366, 13648, 13671, 13672, 13649, 0, 0, 0, 0, 14303, 14304, 14305, 
14257, 36002, 36025, 36026, 36003
24750, 7366, 7389, 7390, 7367, 13649, 13672, 13673, 13650, 0, 0, 0, 0, 14305, 14306, 14307, 
14259, 36003, 36026, 36027, 36004
24751, 7367, 7390, 7391, 7368, 13650, 13673, 13674, 13651, 0, 0, 0, 0, 14307, 14308, 14309, 
14261, 36004, 36027, 36028, 36005
24752, 7368, 7391, 7392, 7369, 13651, 13674, 13675, 13652, 0, 0, 0, 0, 14309, 14310, 14311, 
14263, 36005, 36028, 36029, 36006
24753, 7369, 7392, 7393, 7370, 13652, 13675, 13676, 13653, 0, 0, 0, 0, 14311, 14312, 14313, 
14265, 36006, 36029, 36030, 36007
24754, 7370, 7393, 7394, 7371, 13653, 13676, 13677, 13654, 0, 0, 0, 0, 14313, 14314, 14315, 
14267, 36007, 36030, 36031, 36008
24755, 7371, 7394, 7395, 7372, 13654, 13677, 13678, 13655, 0, 0, 0, 0, 14315, 14316, 14317, 
14269, 36008, 36031, 36032, 36009
24756, 7372, 7395, 7396, 7373, 13655, 13678, 13679, 13656, 0, 0, 0, 0, 14317, 14318, 14319, 
14271, 36009, 36032, 36033, 36010
24757, 7373, 7396, 7397, 7374, 13656, 13679, 13680, 13657, 0, 0, 0, 0, 14319, 14320, 14321, 
14273, 36010, 36033, 36034, 36011
24758, 7374, 7397, 7398, 7375, 13657, 13680, 13681, 13658, 0, 0, 0, 0, 14321, 14322, 14323, 
14275, 36011, 36034, 36035, 36012
24759, 7375, 7398, 7399, 7376, 13658, 13681, 13682, 13659, 0, 0, 0, 0, 14323, 14324, 14325, 
14277, 36012, 36035, 36036, 36013
24760, 7376, 7399, 7400, 7377, 13659, 13682, 13683, 13660, 0, 0, 0, 0, 14325, 14326, 14327, 
14279, 36013, 36036, 36037, 36014
24761, 7377, 7400, 7401, 7378, 13660, 13683, 13684, 13661, 0, 0, 0, 0, 14327, 14328, 14329, 
14281, 36014, 36037, 36038, 36015
24762, 7378, 7401, 7402, 7379, 13661, 13684, 13685, 13662, 0, 0, 0, 0, 14329, 14330, 14331, 
14283, 36015, 36038, 36039, 36016
24763, 7379, 7402, 7403, 7380, 13662, 13685, 13686, 13663, 0, 0, 0, 0, 14331, 14332, 14333, 
14285, 36016, 36039, 36040, 36017
24764, 7380, 7403, 7404, 7381, 13663, 13686, 13687, 13664, 0, 0, 0, 0, 14333, 14334, 14335, 
14287, 36017, 36040, 36041, 36018
24765, 7381, 7404, 961, 960, 13664, 13687, 1831, 1830, 0, 0, 0, 0, 14335, 14336, 1854, 
14289, 36018, 36041, 13554, 13553
24766, 801, 802, 7405, 7382, 1784, 1785, 13688, 13665, 0, 0, 0, 0, 1808, 14337, 14338, 
14290, 13531, 13532, 36042, 36019
24767, 7382, 7405, 7406, 7383, 13665, 13688, 13689, 13666, 0, 0, 0, 0, 14338, 14339, 14340, 
14292, 36019, 36042, 36043, 36020
24768, 7383, 7406, 7407, 7384, 13666, 13689, 13690, 13667, 0, 0, 0, 0, 14340, 14341, 14342, 
14294, 36020, 36043, 36044, 36021
24769, 7384, 7407, 7408, 7385, 13667, 13690, 13691, 13668, 0, 0, 0, 0, 14342, 14343, 14344, 
14296, 36021, 36044, 36045, 36022
24770, 7385, 7408, 7409, 7386, 13668, 13691, 13692, 13669, 0, 0, 0, 0, 14344, 14345, 14346, 
14298, 36022, 36045, 36046, 36023
24771, 7386, 7409, 7410, 7387, 13669, 13692, 13693, 13670, 0, 0, 0, 0, 14346, 14347, 14348, 
14300, 36023, 36046, 36047, 36024
24772, 7387, 7410, 7411, 7388, 13670, 13693, 13694, 13671, 0, 0, 0, 0, 14348, 14349, 14350, 
14302, 36024, 36047, 36048, 36025
24773, 7388, 7411, 7412, 7389, 13671, 13694, 13695, 13672, 0, 0, 0, 0, 14350, 14351, 14352, 
14304, 36025, 36048, 36049, 36026
24774, 7389, 7412, 7413, 7390, 13672, 13695, 13696, 13673, 0, 0, 0, 0, 14352, 14353, 14354, 
14306, 36026, 36049, 36050, 36027
24775, 7390, 7413, 7414, 7391, 13673, 13696, 13697, 13674, 0, 0, 0, 0, 14354, 14355, 14356, 
14308, 36027, 36050, 36051, 36028
24776, 7391, 7414, 7415, 7392, 13674, 13697, 13698, 13675, 0, 0, 0, 0, 14356, 14357, 14358, 
14310, 36028, 36051, 36052, 36029
24777, 7392, 7415, 7416, 7393, 13675, 13698, 13699, 13676, 0, 0, 0, 0, 14358, 14359, 14360, 
14312, 36029, 36052, 36053, 36030
24778, 7393, 7416, 7417, 7394, 13676, 13699, 13700, 13677, 0, 0, 0, 0, 14360, 14361, 14362, 
14314, 36030, 36053, 36054, 36031
24779, 7394, 7417, 7418, 7395, 13677, 13700, 13701, 13678, 0, 0, 0, 0, 14362, 14363, 14364, 
14316, 36031, 36054, 36055, 36032
24780, 7395, 7418, 7419, 7396, 13678, 13701, 13702, 13679, 0, 0, 0, 0, 14364, 14365, 14366, 
14318, 36032, 36055, 36056, 36033
24781, 7396, 7419, 7420, 7397, 13679, 13702, 13703, 13680, 0, 0, 0, 0, 14366, 14367, 14368, 
14320, 36033, 36056, 36057, 36034
24782, 7397, 7420, 7421, 7398, 13680, 13703, 13704, 13681, 0, 0, 0, 0, 14368, 14369, 14370, 
14322, 36034, 36057, 36058, 36035
24783, 7398, 7421, 7422, 7399, 13681, 13704, 13705, 13682, 0, 0, 0, 0, 14370, 14371, 14372, 
14324, 36035, 36058, 36059, 36036
24784, 7399, 7422, 7423, 7400, 13682, 13705, 13706, 13683, 0, 0, 0, 0, 14372, 14373, 14374, 
14326, 36036, 36059, 36060, 36037
24785, 7400, 7423, 7424, 7401, 13683, 13706, 13707, 13684, 0, 0, 0, 0, 14374, 14375, 14376, 
14328, 36037, 36060, 36061, 36038
24786, 7401, 7424, 7425, 7402, 13684, 13707, 13708, 13685, 0, 0, 0, 0, 14376, 14377, 14378, 
14330, 36038, 36061, 36062, 36039
24787, 7402, 7425, 7426, 7403, 13685, 13708, 13709, 13686, 0, 0, 0, 0, 14378, 14379, 14380, 
14332, 36039, 36062, 36063, 36040
24788, 7403, 7426, 7427, 7404, 13686, 13709, 13710, 13687, 0, 0, 0, 0, 14380, 14381, 14382, 
14334, 36040, 36063, 36064, 36041
24789, 7404, 7427, 962, 961, 13687, 13710, 1832, 1831, 0, 0, 0, 0, 14382, 14383, 1855, 
14336, 36041, 36064, 13555, 13554
24790, 802, 803, 7428, 7405, 1785, 1786, 13711, 13688, 0, 0, 0, 0, 1809, 14384, 14385, 
14337, 13532, 13533, 36065, 36042
24791, 7405, 7428, 7429, 7406, 13688, 13711, 13712, 13689, 0, 0, 0, 0, 14385, 14386, 14387, 
14339, 36042, 36065, 36066, 36043
24792, 7406, 7429, 7430, 7407, 13689, 13712, 13713, 13690, 0, 0, 0, 0, 14387, 14388, 14389, 
14341, 36043, 36066, 36067, 36044
24793, 7407, 7430, 7431, 7408, 13690, 13713, 13714, 13691, 0, 0, 0, 0, 14389, 14390, 14391, 
14343, 36044, 36067, 36068, 36045
24794, 7408, 7431, 7432, 7409, 13691, 13714, 13715, 13692, 0, 0, 0, 0, 14391, 14392, 14393, 
14345, 36045, 36068, 36069, 36046
24795, 7409, 7432, 7433, 7410, 13692, 13715, 13716, 13693, 0, 0, 0, 0, 14393, 14394, 14395, 
14347, 36046, 36069, 36070, 36047
24796, 7410, 7433, 7434, 7411, 13693, 13716, 13717, 13694, 0, 0, 0, 0, 14395, 14396, 14397, 
14349, 36047, 36070, 36071, 36048
24797, 7411, 7434, 7435, 7412, 13694, 13717, 13718, 13695, 0, 0, 0, 0, 14397, 14398, 14399, 
14351, 36048, 36071, 36072, 36049
24798, 7412, 7435, 7436, 7413, 13695, 13718, 13719, 13696, 0, 0, 0, 0, 14399, 14400, 14401, 
14353, 36049, 36072, 36073, 36050
24799, 7413, 7436, 7437, 7414, 13696, 13719, 13720, 13697, 0, 0, 0, 0, 14401, 14402, 14403, 
14355, 36050, 36073, 36074, 36051
24800, 7414, 7437, 7438, 7415, 13697, 13720, 13721, 13698, 0, 0, 0, 0, 14403, 14404, 14405, 
14357, 36051, 36074, 36075, 36052
24801, 7415, 7438, 7439, 7416, 13698, 13721, 13722, 13699, 0, 0, 0, 0, 14405, 14406, 14407, 
14359, 36052, 36075, 36076, 36053
24802, 7416, 7439, 7440, 7417, 13699, 13722, 13723, 13700, 0, 0, 0, 0, 14407, 14408, 14409, 
14361, 36053, 36076, 36077, 36054
24803, 7417, 7440, 7441, 7418, 13700, 13723, 13724, 13701, 0, 0, 0, 0, 14409, 14410, 14411, 
14363, 36054, 36077, 36078, 36055
24804, 7418, 7441, 7442, 7419, 13701, 13724, 13725, 13702, 0, 0, 0, 0, 14411, 14412, 14413, 
14365, 36055, 36078, 36079, 36056
24805, 7419, 7442, 7443, 7420, 13702, 13725, 13726, 13703, 0, 0, 0, 0, 14413, 14414, 14415, 
14367, 36056, 36079, 36080, 36057
24806, 7420, 7443, 7444, 7421, 13703, 13726, 13727, 13704, 0, 0, 0, 0, 14415, 14416, 14417, 
14369, 36057, 36080, 36081, 36058
24807, 7421, 7444, 7445, 7422, 13704, 13727, 13728, 13705, 0, 0, 0, 0, 14417, 14418, 14419, 
14371, 36058, 36081, 36082, 36059
24808, 7422, 7445, 7446, 7423, 13705, 13728, 13729, 13706, 0, 0, 0, 0, 14419, 14420, 14421, 
14373, 36059, 36082, 36083, 36060
24809, 7423, 7446, 7447, 7424, 13706, 13729, 13730, 13707, 0, 0, 0, 0, 14421, 14422, 14423, 
14375, 36060, 36083, 36084, 36061
24810, 7424, 7447, 7448, 7425, 13707, 13730, 13731, 13708, 0, 0, 0, 0, 14423, 14424, 14425, 
14377, 36061, 36084, 36085, 36062
24811, 7425, 7448, 7449, 7426, 13708, 13731, 13732, 13709, 0, 0, 0, 0, 14425, 14426, 14427, 
14379, 36062, 36085, 36086, 36063
24812, 7426, 7449, 7450, 7427, 13709, 13732, 13733, 13710, 0, 0, 0, 0, 14427, 14428, 14429, 
14381, 36063, 36086, 36087, 36064
24813, 7427, 7450, 963, 962, 13710, 13733, 1833, 1832, 0, 0, 0, 0, 14429, 14430, 1856, 
14383, 36064, 36087, 13556, 13555
24814, 803, 804, 7451, 7428, 1786, 1787, 13734, 13711, 0, 0, 0, 0, 1810, 14431, 14432, 
14384, 13533, 13534, 36088, 36065
24815, 7428, 7451, 7452, 7429, 13711, 13734, 13735, 13712, 0, 0, 0, 0, 14432, 14433, 14434, 
14386, 36065, 36088, 36089, 36066
24816, 7429, 7452, 7453, 7430, 13712, 13735, 13736, 13713, 0, 0, 0, 0, 14434, 14435, 14436, 
14388, 36066, 36089, 36090, 36067
24817, 7430, 7453, 7454, 7431, 13713, 13736, 13737, 13714, 0, 0, 0, 0, 14436, 14437, 14438, 
14390, 36067, 36090, 36091, 36068
24818, 7431, 7454, 7455, 7432, 13714, 13737, 13738, 13715, 0, 0, 0, 0, 14438, 14439, 14440, 
14392, 36068, 36091, 36092, 36069
24819, 7432, 7455, 7456, 7433, 13715, 13738, 13739, 13716, 0, 0, 0, 0, 14440, 14441, 14442, 
14394, 36069, 36092, 36093, 36070
24820, 7433, 7456, 7457, 7434, 13716, 13739, 13740, 13717, 0, 0, 0, 0, 14442, 14443, 14444, 
14396, 36070, 36093, 36094, 36071
24821, 7434, 7457, 7458, 7435, 13717, 13740, 13741, 13718, 0, 0, 0, 0, 14444, 14445, 14446, 
14398, 36071, 36094, 36095, 36072
24822, 7435, 7458, 7459, 7436, 13718, 13741, 13742, 13719, 0, 0, 0, 0, 14446, 14447, 14448, 
14400, 36072, 36095, 36096, 36073
24823, 7436, 7459, 7460, 7437, 13719, 13742, 13743, 13720, 0, 0, 0, 0, 14448, 14449, 14450, 
14402, 36073, 36096, 36097, 36074
24824, 7437, 7460, 7461, 7438, 13720, 13743, 13744, 13721, 0, 0, 0, 0, 14450, 14451, 14452, 
14404, 36074, 36097, 36098, 36075
24825, 7438, 7461, 7462, 7439, 13721, 13744, 13745, 13722, 0, 0, 0, 0, 14452, 14453, 14454, 
14406, 36075, 36098, 36099, 36076
24826, 7439, 7462, 7463, 7440, 13722, 13745, 13746, 13723, 0, 0, 0, 0, 14454, 14455, 14456, 
14408, 36076, 36099, 36100, 36077
24827, 7440, 7463, 7464, 7441, 13723, 13746, 13747, 13724, 0, 0, 0, 0, 14456, 14457, 14458, 
14410, 36077, 36100, 36101, 36078
24828, 7441, 7464, 7465, 7442, 13724, 13747, 13748, 13725, 0, 0, 0, 0, 14458, 14459, 14460, 
14412, 36078, 36101, 36102, 36079
24829, 7442, 7465, 7466, 7443, 13725, 13748, 13749, 13726, 0, 0, 0, 0, 14460, 14461, 14462, 
14414, 36079, 36102, 36103, 36080
24830, 7443, 7466, 7467, 7444, 13726, 13749, 13750, 13727, 0, 0, 0, 0, 14462, 14463, 14464, 
14416, 36080, 36103, 36104, 36081
24831, 7444, 7467, 7468, 7445, 13727, 13750, 13751, 13728, 0, 0, 0, 0, 14464, 14465, 14466, 
14418, 36081, 36104, 36105, 36082
24832, 7445, 7468, 7469, 7446, 13728, 13751, 13752, 13729, 0, 0, 0, 0, 14466, 14467, 14468, 
14420, 36082, 36105, 36106, 36083
24833, 7446, 7469, 7470, 7447, 13729, 13752, 13753, 13730, 0, 0, 0, 0, 14468, 14469, 14470, 
14422, 36083, 36106, 36107, 36084
24834, 7447, 7470, 7471, 7448, 13730, 13753, 13754, 13731, 0, 0, 0, 0, 14470, 14471, 14472, 
14424, 36084, 36107, 36108, 36085
24835, 7448, 7471, 7472, 7449, 13731, 13754, 13755, 13732, 0, 0, 0, 0, 14472, 14473, 14474, 
14426, 36085, 36108, 36109, 36086
24836, 7449, 7472, 7473, 7450, 13732, 13755, 13756, 13733, 0, 0, 0, 0, 14474, 14475, 14476, 
14428, 36086, 36109, 36110, 36087
24837, 7450, 7473, 964, 963, 13733, 13756, 1834, 1833, 0, 0, 0, 0, 14476, 14477, 1857, 
14430, 36087, 36110, 13557, 13556
24838, 804, 805, 7474, 7451, 1787, 1788, 13757, 13734, 0, 0, 0, 0, 1811, 14478, 14479, 
14431, 13534, 13535, 36111, 36088
24839, 7451, 7474, 7475, 7452, 13734, 13757, 13758, 13735, 0, 0, 0, 0, 14479, 14480, 14481, 
14433, 36088, 36111, 36112, 36089
24840, 7452, 7475, 7476, 7453, 13735, 13758, 13759, 13736, 0, 0, 0, 0, 14481, 14482, 14483, 
14435, 36089, 36112, 36113, 36090
24841, 7453, 7476, 7477, 7454, 13736, 13759, 13760, 13737, 0, 0, 0, 0, 14483, 14484, 14485, 
14437, 36090, 36113, 36114, 36091
24842, 7454, 7477, 7478, 7455, 13737, 13760, 13761, 13738, 0, 0, 0, 0, 14485, 14486, 14487, 
14439, 36091, 36114, 36115, 36092
24843, 7455, 7478, 7479, 7456, 13738, 13761, 13762, 13739, 0, 0, 0, 0, 14487, 14488, 14489, 
14441, 36092, 36115, 36116, 36093
24844, 7456, 7479, 7480, 7457, 13739, 13762, 13763, 13740, 0, 0, 0, 0, 14489, 14490, 14491, 
14443, 36093, 36116, 36117, 36094
24845, 7457, 7480, 7481, 7458, 13740, 13763, 13764, 13741, 0, 0, 0, 0, 14491, 14492, 14493, 
14445, 36094, 36117, 36118, 36095
24846, 7458, 7481, 7482, 7459, 13741, 13764, 13765, 13742, 0, 0, 0, 0, 14493, 14494, 14495, 
14447, 36095, 36118, 36119, 36096
24847, 7459, 7482, 7483, 7460, 13742, 13765, 13766, 13743, 0, 0, 0, 0, 14495, 14496, 14497, 
14449, 36096, 36119, 36120, 36097
24848, 7460, 7483, 7484, 7461, 13743, 13766, 13767, 13744, 0, 0, 0, 0, 14497, 14498, 14499, 
14451, 36097, 36120, 36121, 36098
24849, 7461, 7484, 7485, 7462, 13744, 13767, 13768, 13745, 0, 0, 0, 0, 14499, 14500, 14501, 
14453, 36098, 36121, 36122, 36099
24850, 7462, 7485, 7486, 7463, 13745, 13768, 13769, 13746, 0, 0, 0, 0, 14501, 14502, 14503, 
14455, 36099, 36122, 36123, 36100
24851, 7463, 7486, 7487, 7464, 13746, 13769, 13770, 13747, 0, 0, 0, 0, 14503, 14504, 14505, 
14457, 36100, 36123, 36124, 36101
24852, 7464, 7487, 7488, 7465, 13747, 13770, 13771, 13748, 0, 0, 0, 0, 14505, 14506, 14507, 
14459, 36101, 36124, 36125, 36102
24853, 7465, 7488, 7489, 7466, 13748, 13771, 13772, 13749, 0, 0, 0, 0, 14507, 14508, 14509, 
14461, 36102, 36125, 36126, 36103
24854, 7466, 7489, 7490, 7467, 13749, 13772, 13773, 13750, 0, 0, 0, 0, 14509, 14510, 14511, 
14463, 36103, 36126, 36127, 36104
24855, 7467, 7490, 7491, 7468, 13750, 13773, 13774, 13751, 0, 0, 0, 0, 14511, 14512, 14513, 
14465, 36104, 36127, 36128, 36105
24856, 7468, 7491, 7492, 7469, 13751, 13774, 13775, 13752, 0, 0, 0, 0, 14513, 14514, 14515, 
14467, 36105, 36128, 36129, 36106
24857, 7469, 7492, 7493, 7470, 13752, 13775, 13776, 13753, 0, 0, 0, 0, 14515, 14516, 14517, 
14469, 36106, 36129, 36130, 36107
24858, 7470, 7493, 7494, 7471, 13753, 13776, 13777, 13754, 0, 0, 0, 0, 14517, 14518, 14519, 
14471, 36107, 36130, 36131, 36108
24859, 7471, 7494, 7495, 7472, 13754, 13777, 13778, 13755, 0, 0, 0, 0, 14519, 14520, 14521, 
14473, 36108, 36131, 36132, 36109
24860, 7472, 7495, 7496, 7473, 13755, 13778, 13779, 13756, 0, 0, 0, 0, 14521, 14522, 14523, 
14475, 36109, 36132, 36133, 36110
24861, 7473, 7496, 965, 964, 13756, 13779, 1835, 1834, 0, 0, 0, 0, 14523, 14524, 1858, 
14477, 36110, 36133, 13558, 13557
24862, 805, 806, 7497, 7474, 1788, 1789, 13780, 13757, 0, 0, 0, 0, 1812, 14525, 14526, 
14478, 13535, 13536, 36134, 36111
24863, 7474, 7497, 7498, 7475, 13757, 13780, 13781, 13758, 0, 0, 0, 0, 14526, 14527, 14528, 
14480, 36111, 36134, 36135, 36112
24864, 7475, 7498, 7499, 7476, 13758, 13781, 13782, 13759, 0, 0, 0, 0, 14528, 14529, 14530, 
14482, 36112, 36135, 36136, 36113
24865, 7476, 7499, 7500, 7477, 13759, 13782, 13783, 13760, 0, 0, 0, 0, 14530, 14531, 14532, 
14484, 36113, 36136, 36137, 36114
24866, 7477, 7500, 7501, 7478, 13760, 13783, 13784, 13761, 0, 0, 0, 0, 14532, 14533, 14534, 
14486, 36114, 36137, 36138, 36115
24867, 7478, 7501, 7502, 7479, 13761, 13784, 13785, 13762, 0, 0, 0, 0, 14534, 14535, 14536, 
14488, 36115, 36138, 36139, 36116
24868, 7479, 7502, 7503, 7480, 13762, 13785, 13786, 13763, 0, 0, 0, 0, 14536, 14537, 14538, 
14490, 36116, 36139, 36140, 36117
24869, 7480, 7503, 7504, 7481, 13763, 13786, 13787, 13764, 0, 0, 0, 0, 14538, 14539, 14540, 
14492, 36117, 36140, 36141, 36118
24870, 7481, 7504, 7505, 7482, 13764, 13787, 13788, 13765, 0, 0, 0, 0, 14540, 14541, 14542, 
14494, 36118, 36141, 36142, 36119
24871, 7482, 7505, 7506, 7483, 13765, 13788, 13789, 13766, 0, 0, 0, 0, 14542, 14543, 14544, 
14496, 36119, 36142, 36143, 36120
24872, 7483, 7506, 7507, 7484, 13766, 13789, 13790, 13767, 0, 0, 0, 0, 14544, 14545, 14546, 
14498, 36120, 36143, 36144, 36121
24873, 7484, 7507, 7508, 7485, 13767, 13790, 13791, 13768, 0, 0, 0, 0, 14546, 14547, 14548, 
14500, 36121, 36144, 36145, 36122
24874, 7485, 7508, 7509, 7486, 13768, 13791, 13792, 13769, 0, 0, 0, 0, 14548, 14549, 14550, 
14502, 36122, 36145, 36146, 36123
24875, 7486, 7509, 7510, 7487, 13769, 13792, 13793, 13770, 0, 0, 0, 0, 14550, 14551, 14552, 
14504, 36123, 36146, 36147, 36124
24876, 7487, 7510, 7511, 7488, 13770, 13793, 13794, 13771, 0, 0, 0, 0, 14552, 14553, 14554, 
14506, 36124, 36147, 36148, 36125
24877, 7488, 7511, 7512, 7489, 13771, 13794, 13795, 13772, 0, 0, 0, 0, 14554, 14555, 14556, 
14508, 36125, 36148, 36149, 36126
24878, 7489, 7512, 7513, 7490, 13772, 13795, 13796, 13773, 0, 0, 0, 0, 14556, 14557, 14558, 
14510, 36126, 36149, 36150, 36127
24879, 7490, 7513, 7514, 7491, 13773, 13796, 13797, 13774, 0, 0, 0, 0, 14558, 14559, 14560, 
14512, 36127, 36150, 36151, 36128
24880, 7491, 7514, 7515, 7492, 13774, 13797, 13798, 13775, 0, 0, 0, 0, 14560, 14561, 14562, 
14514, 36128, 36151, 36152, 36129
24881, 7492, 7515, 7516, 7493, 13775, 13798, 13799, 13776, 0, 0, 0, 0, 14562, 14563, 14564, 
14516, 36129, 36152, 36153, 36130
24882, 7493, 7516, 7517, 7494, 13776, 13799, 13800, 13777, 0, 0, 0, 0, 14564, 14565, 14566, 
14518, 36130, 36153, 36154, 36131
24883, 7494, 7517, 7518, 7495, 13777, 13800, 13801, 13778, 0, 0, 0, 0, 14566, 14567, 14568, 
14520, 36131, 36154, 36155, 36132
24884, 7495, 7518, 7519, 7496, 13778, 13801, 13802, 13779, 0, 0, 0, 0, 14568, 14569, 14570, 
14522, 36132, 36155, 36156, 36133
24885, 7496, 7519, 966, 965, 13779, 13802, 1836, 1835, 0, 0, 0, 0, 14570, 14571, 1859, 
14524, 36133, 36156, 13559, 13558
24886, 806, 807, 7520, 7497, 1789, 1790, 13803, 13780, 0, 0, 0, 0, 1813, 14572, 14573, 
14525, 13536, 13537, 36157, 36134
24887, 7497, 7520, 7521, 7498, 13780, 13803, 13804, 13781, 0, 0, 0, 0, 14573, 14574, 14575, 
14527, 36134, 36157, 36158, 36135
24888, 7498, 7521, 7522, 7499, 13781, 13804, 13805, 13782, 0, 0, 0, 0, 14575, 14576, 14577, 
14529, 36135, 36158, 36159, 36136
24889, 7499, 7522, 7523, 7500, 13782, 13805, 13806, 13783, 0, 0, 0, 0, 14577, 14578, 14579, 
14531, 36136, 36159, 36160, 36137
24890, 7500, 7523, 7524, 7501, 13783, 13806, 13807, 13784, 0, 0, 0, 0, 14579, 14580, 14581, 
14533, 36137, 36160, 36161, 36138
24891, 7501, 7524, 7525, 7502, 13784, 13807, 13808, 13785, 0, 0, 0, 0, 14581, 14582, 14583, 
14535, 36138, 36161, 36162, 36139
24892, 7502, 7525, 7526, 7503, 13785, 13808, 13809, 13786, 0, 0, 0, 0, 14583, 14584, 14585, 
14537, 36139, 36162, 36163, 36140
24893, 7503, 7526, 7527, 7504, 13786, 13809, 13810, 13787, 0, 0, 0, 0, 14585, 14586, 14587, 
14539, 36140, 36163, 36164, 36141
24894, 7504, 7527, 7528, 7505, 13787, 13810, 13811, 13788, 0, 0, 0, 0, 14587, 14588, 14589, 
14541, 36141, 36164, 36165, 36142
24895, 7505, 7528, 7529, 7506, 13788, 13811, 13812, 13789, 0, 0, 0, 0, 14589, 14590, 14591, 
14543, 36142, 36165, 36166, 36143
24896, 7506, 7529, 7530, 7507, 13789, 13812, 13813, 13790, 0, 0, 0, 0, 14591, 14592, 14593, 
14545, 36143, 36166, 36167, 36144
24897, 7507, 7530, 7531, 7508, 13790, 13813, 13814, 13791, 0, 0, 0, 0, 14593, 14594, 14595, 
14547, 36144, 36167, 36168, 36145
24898, 7508, 7531, 7532, 7509, 13791, 13814, 13815, 13792, 0, 0, 0, 0, 14595, 14596, 14597, 
14549, 36145, 36168, 36169, 36146
24899, 7509, 7532, 7533, 7510, 13792, 13815, 13816, 13793, 0, 0, 0, 0, 14597, 14598, 14599, 
14551, 36146, 36169, 36170, 36147
24900, 7510, 7533, 7534, 7511, 13793, 13816, 13817, 13794, 0, 0, 0, 0, 14599, 14600, 14601, 
14553, 36147, 36170, 36171, 36148
24901, 7511, 7534, 7535, 7512, 13794, 13817, 13818, 13795, 0, 0, 0, 0, 14601, 14602, 14603, 
14555, 36148, 36171, 36172, 36149
24902, 7512, 7535, 7536, 7513, 13795, 13818, 13819, 13796, 0, 0, 0, 0, 14603, 14604, 14605, 
14557, 36149, 36172, 36173, 36150
24903, 7513, 7536, 7537, 7514, 13796, 13819, 13820, 13797, 0, 0, 0, 0, 14605, 14606, 14607, 
14559, 36150, 36173, 36174, 36151
24904, 7514, 7537, 7538, 7515, 13797, 13820, 13821, 13798, 0, 0, 0, 0, 14607, 14608, 14609, 
14561, 36151, 36174, 36175, 36152
24905, 7515, 7538, 7539, 7516, 13798, 13821, 13822, 13799, 0, 0, 0, 0, 14609, 14610, 14611, 
14563, 36152, 36175, 36176, 36153
24906, 7516, 7539, 7540, 7517, 13799, 13822, 13823, 13800, 0, 0, 0, 0, 14611, 14612, 14613, 
14565, 36153, 36176, 36177, 36154
24907, 7517, 7540, 7541, 7518, 13800, 13823, 13824, 13801, 0, 0, 0, 0, 14613, 14614, 14615, 
14567, 36154, 36177, 36178, 36155
24908, 7518, 7541, 7542, 7519, 13801, 13824, 13825, 13802, 0, 0, 0, 0, 14615, 14616, 14617, 
14569, 36155, 36178, 36179, 36156
24909, 7519, 7542, 967, 966, 13802, 13825, 1837, 1836, 0, 0, 0, 0, 14617, 14618, 1860, 
14571, 36156, 36179, 13560, 13559
24910, 807, 808, 7543, 7520, 1790, 1791, 13826, 13803, 0, 0, 0, 0, 1814, 14619, 14620, 
14572, 13537, 13538, 36180, 36157
24911, 7520, 7543, 7544, 7521, 13803, 13826, 13827, 13804, 0, 0, 0, 0, 14620, 14621, 14622, 
14574, 36157, 36180, 36181, 36158
24912, 7521, 7544, 7545, 7522, 13804, 13827, 13828, 13805, 0, 0, 0, 0, 14622, 14623, 14624, 
14576, 36158, 36181, 36182, 36159
24913, 7522, 7545, 7546, 7523, 13805, 13828, 13829, 13806, 0, 0, 0, 0, 14624, 14625, 14626, 
14578, 36159, 36182, 36183, 36160
24914, 7523, 7546, 7547, 7524, 13806, 13829, 13830, 13807, 0, 0, 0, 0, 14626, 14627, 14628, 
14580, 36160, 36183, 36184, 36161
24915, 7524, 7547, 7548, 7525, 13807, 13830, 13831, 13808, 0, 0, 0, 0, 14628, 14629, 14630, 
14582, 36161, 36184, 36185, 36162
24916, 7525, 7548, 7549, 7526, 13808, 13831, 13832, 13809, 0, 0, 0, 0, 14630, 14631, 14632, 
14584, 36162, 36185, 36186, 36163
24917, 7526, 7549, 7550, 7527, 13809, 13832, 13833, 13810, 0, 0, 0, 0, 14632, 14633, 14634, 
14586, 36163, 36186, 36187, 36164
24918, 7527, 7550, 7551, 7528, 13810, 13833, 13834, 13811, 0, 0, 0, 0, 14634, 14635, 14636, 
14588, 36164, 36187, 36188, 36165
24919, 7528, 7551, 7552, 7529, 13811, 13834, 13835, 13812, 0, 0, 0, 0, 14636, 14637, 14638, 
14590, 36165, 36188, 36189, 36166
24920, 7529, 7552, 7553, 7530, 13812, 13835, 13836, 13813, 0, 0, 0, 0, 14638, 14639, 14640, 
14592, 36166, 36189, 36190, 36167
24921, 7530, 7553, 7554, 7531, 13813, 13836, 13837, 13814, 0, 0, 0, 0, 14640, 14641, 14642, 
14594, 36167, 36190, 36191, 36168
24922, 7531, 7554, 7555, 7532, 13814, 13837, 13838, 13815, 0, 0, 0, 0, 14642, 14643, 14644, 
14596, 36168, 36191, 36192, 36169
24923, 7532, 7555, 7556, 7533, 13815, 13838, 13839, 13816, 0, 0, 0, 0, 14644, 14645, 14646, 
14598, 36169, 36192, 36193, 36170
24924, 7533, 7556, 7557, 7534, 13816, 13839, 13840, 13817, 0, 0, 0, 0, 14646, 14647, 14648, 
14600, 36170, 36193, 36194, 36171
24925, 7534, 7557, 7558, 7535, 13817, 13840, 13841, 13818, 0, 0, 0, 0, 14648, 14649, 14650, 
14602, 36171, 36194, 36195, 36172
24926, 7535, 7558, 7559, 7536, 13818, 13841, 13842, 13819, 0, 0, 0, 0, 14650, 14651, 14652, 
14604, 36172, 36195, 36196, 36173
24927, 7536, 7559, 7560, 7537, 13819, 13842, 13843, 13820, 0, 0, 0, 0, 14652, 14653, 14654, 
14606, 36173, 36196, 36197, 36174
24928, 7537, 7560, 7561, 7538, 13820, 13843, 13844, 13821, 0, 0, 0, 0, 14654, 14655, 14656, 
14608, 36174, 36197, 36198, 36175
24929, 7538, 7561, 7562, 7539, 13821, 13844, 13845, 13822, 0, 0, 0, 0, 14656, 14657, 14658, 
14610, 36175, 36198, 36199, 36176
24930, 7539, 7562, 7563, 7540, 13822, 13845, 13846, 13823, 0, 0, 0, 0, 14658, 14659, 14660, 
14612, 36176, 36199, 36200, 36177
24931, 7540, 7563, 7564, 7541, 13823, 13846, 13847, 13824, 0, 0, 0, 0, 14660, 14661, 14662, 
14614, 36177, 36200, 36201, 36178
24932, 7541, 7564, 7565, 7542, 13824, 13847, 13848, 13825, 0, 0, 0, 0, 14662, 14663, 14664, 
14616, 36178, 36201, 36202, 36179
24933, 7542, 7565, 968, 967, 13825, 13848, 1838, 1837, 0, 0, 0, 0, 14664, 14665, 1861, 
14618, 36179, 36202, 13561, 13560
24934, 808, 809, 7566, 7543, 1791, 1792, 13849, 13826, 0, 0, 0, 0, 1815, 14666, 14667, 
14619, 13538, 13539, 36203, 36180
24935, 7543, 7566, 7567, 7544, 13826, 13849, 13850, 13827, 0, 0, 0, 0, 14667, 14668, 14669, 
14621, 36180, 36203, 36204, 36181
24936, 7544, 7567, 7568, 7545, 13827, 13850, 13851, 13828, 0, 0, 0, 0, 14669, 14670, 14671, 
14623, 36181, 36204, 36205, 36182
24937, 7545, 7568, 7569, 7546, 13828, 13851, 13852, 13829, 0, 0, 0, 0, 14671, 14672, 14673, 
14625, 36182, 36205, 36206, 36183
24938, 7546, 7569, 7570, 7547, 13829, 13852, 13853, 13830, 0, 0, 0, 0, 14673, 14674, 14675, 
14627, 36183, 36206, 36207, 36184
24939, 7547, 7570, 7571, 7548, 13830, 13853, 13854, 13831, 0, 0, 0, 0, 14675, 14676, 14677, 
14629, 36184, 36207, 36208, 36185
24940, 7548, 7571, 7572, 7549, 13831, 13854, 13855, 13832, 0, 0, 0, 0, 14677, 14678, 14679, 
14631, 36185, 36208, 36209, 36186
24941, 7549, 7572, 7573, 7550, 13832, 13855, 13856, 13833, 0, 0, 0, 0, 14679, 14680, 14681, 
14633, 36186, 36209, 36210, 36187
24942, 7550, 7573, 7574, 7551, 13833, 13856, 13857, 13834, 0, 0, 0, 0, 14681, 14682, 14683, 
14635, 36187, 36210, 36211, 36188
24943, 7551, 7574, 7575, 7552, 13834, 13857, 13858, 13835, 0, 0, 0, 0, 14683, 14684, 14685, 
14637, 36188, 36211, 36212, 36189
24944, 7552, 7575, 7576, 7553, 13835, 13858, 13859, 13836, 0, 0, 0, 0, 14685, 14686, 14687, 
14639, 36189, 36212, 36213, 36190
24945, 7553, 7576, 7577, 7554, 13836, 13859, 13860, 13837, 0, 0, 0, 0, 14687, 14688, 14689, 
14641, 36190, 36213, 36214, 36191
24946, 7554, 7577, 7578, 7555, 13837, 13860, 13861, 13838, 0, 0, 0, 0, 14689, 14690, 14691, 
14643, 36191, 36214, 36215, 36192
24947, 7555, 7578, 7579, 7556, 13838, 13861, 13862, 13839, 0, 0, 0, 0, 14691, 14692, 14693, 
14645, 36192, 36215, 36216, 36193
24948, 7556, 7579, 7580, 7557, 13839, 13862, 13863, 13840, 0, 0, 0, 0, 14693, 14694, 14695, 
14647, 36193, 36216, 36217, 36194
24949, 7557, 7580, 7581, 7558, 13840, 13863, 13864, 13841, 0, 0, 0, 0, 14695, 14696, 14697, 
14649, 36194, 36217, 36218, 36195
24950, 7558, 7581, 7582, 7559, 13841, 13864, 13865, 13842, 0, 0, 0, 0, 14697, 14698, 14699, 
14651, 36195, 36218, 36219, 36196
24951, 7559, 7582, 7583, 7560, 13842, 13865, 13866, 13843, 0, 0, 0, 0, 14699, 14700, 14701, 
14653, 36196, 36219, 36220, 36197
24952, 7560, 7583, 7584, 7561, 13843, 13866, 13867, 13844, 0, 0, 0, 0, 14701, 14702, 14703, 
14655, 36197, 36220, 36221, 36198
24953, 7561, 7584, 7585, 7562, 13844, 13867, 13868, 13845, 0, 0, 0, 0, 14703, 14704, 14705, 
14657, 36198, 36221, 36222, 36199
24954, 7562, 7585, 7586, 7563, 13845, 13868, 13869, 13846, 0, 0, 0, 0, 14705, 14706, 14707, 
14659, 36199, 36222, 36223, 36200
24955, 7563, 7586, 7587, 7564, 13846, 13869, 13870, 13847, 0, 0, 0, 0, 14707, 14708, 14709, 
14661, 36200, 36223, 36224, 36201
24956, 7564, 7587, 7588, 7565, 13847, 13870, 13871, 13848, 0, 0, 0, 0, 14709, 14710, 14711, 
14663, 36201, 36224, 36225, 36202
24957, 7565, 7588, 969, 968, 13848, 13871, 1839, 1838, 0, 0, 0, 0, 14711, 14712, 1862, 
14665, 36202, 36225, 13562, 13561
24958, 809, 810, 7589, 7566, 1792, 1793, 13872, 13849, 0, 0, 0, 0, 1816, 14713, 14714, 
14666, 13539, 13540, 36226, 36203
24959, 7566, 7589, 7590, 7567, 13849, 13872, 13873, 13850, 0, 0, 0, 0, 14714, 14715, 14716, 
14668, 36203, 36226, 36227, 36204
24960, 7567, 7590, 7591, 7568, 13850, 13873, 13874, 13851, 0, 0, 0, 0, 14716, 14717, 14718, 
14670, 36204, 36227, 36228, 36205
24961, 7568, 7591, 7592, 7569, 13851, 13874, 13875, 13852, 0, 0, 0, 0, 14718, 14719, 14720, 
14672, 36205, 36228, 36229, 36206
24962, 7569, 7592, 7593, 7570, 13852, 13875, 13876, 13853, 0, 0, 0, 0, 14720, 14721, 14722, 
14674, 36206, 36229, 36230, 36207
24963, 7570, 7593, 7594, 7571, 13853, 13876, 13877, 13854, 0, 0, 0, 0, 14722, 14723, 14724, 
14676, 36207, 36230, 36231, 36208
24964, 7571, 7594, 7595, 7572, 13854, 13877, 13878, 13855, 0, 0, 0, 0, 14724, 14725, 14726, 
14678, 36208, 36231, 36232, 36209
24965, 7572, 7595, 7596, 7573, 13855, 13878, 13879, 13856, 0, 0, 0, 0, 14726, 14727, 14728, 
14680, 36209, 36232, 36233, 36210
24966, 7573, 7596, 7597, 7574, 13856, 13879, 13880, 13857, 0, 0, 0, 0, 14728, 14729, 14730, 
14682, 36210, 36233, 36234, 36211
24967, 7574, 7597, 7598, 7575, 13857, 13880, 13881, 13858, 0, 0, 0, 0, 14730, 14731, 14732, 
14684, 36211, 36234, 36235, 36212
24968, 7575, 7598, 7599, 7576, 13858, 13881, 13882, 13859, 0, 0, 0, 0, 14732, 14733, 14734, 
14686, 36212, 36235, 36236, 36213
24969, 7576, 7599, 7600, 7577, 13859, 13882, 13883, 13860, 0, 0, 0, 0, 14734, 14735, 14736, 
14688, 36213, 36236, 36237, 36214
24970, 7577, 7600, 7601, 7578, 13860, 13883, 13884, 13861, 0, 0, 0, 0, 14736, 14737, 14738, 
14690, 36214, 36237, 36238, 36215
24971, 7578, 7601, 7602, 7579, 13861, 13884, 13885, 13862, 0, 0, 0, 0, 14738, 14739, 14740, 
14692, 36215, 36238, 36239, 36216
24972, 7579, 7602, 7603, 7580, 13862, 13885, 13886, 13863, 0, 0, 0, 0, 14740, 14741, 14742, 
14694, 36216, 36239, 36240, 36217
24973, 7580, 7603, 7604, 7581, 13863, 13886, 13887, 13864, 0, 0, 0, 0, 14742, 14743, 14744, 
14696, 36217, 36240, 36241, 36218
24974, 7581, 7604, 7605, 7582, 13864, 13887, 13888, 13865, 0, 0, 0, 0, 14744, 14745, 14746, 
14698, 36218, 36241, 36242, 36219
24975, 7582, 7605, 7606, 7583, 13865, 13888, 13889, 13866, 0, 0, 0, 0, 14746, 14747, 14748, 
14700, 36219, 36242, 36243, 36220
24976, 7583, 7606, 7607, 7584, 13866, 13889, 13890, 13867, 0, 0, 0, 0, 14748, 14749, 14750, 
14702, 36220, 36243, 36244, 36221
24977, 7584, 7607, 7608, 7585, 13867, 13890, 13891, 13868, 0, 0, 0, 0, 14750, 14751, 14752, 
14704, 36221, 36244, 36245, 36222
24978, 7585, 7608, 7609, 7586, 13868, 13891, 13892, 13869, 0, 0, 0, 0, 14752, 14753, 14754, 
14706, 36222, 36245, 36246, 36223
24979, 7586, 7609, 7610, 7587, 13869, 13892, 13893, 13870, 0, 0, 0, 0, 14754, 14755, 14756, 
14708, 36223, 36246, 36247, 36224
24980, 7587, 7610, 7611, 7588, 13870, 13893, 13894, 13871, 0, 0, 0, 0, 14756, 14757, 14758, 
14710, 36224, 36247, 36248, 36225
24981, 7588, 7611, 970, 969, 13871, 13894, 1840, 1839, 0, 0, 0, 0, 14758, 14759, 1863, 
14712, 36225, 36248, 13563, 13562
24982, 810, 811, 7612, 7589, 1793, 1794, 13895, 13872, 0, 0, 0, 0, 1817, 14760, 14761, 
14713, 13540, 13541, 36249, 36226
24983, 7589, 7612, 7613, 7590, 13872, 13895, 13896, 13873, 0, 0, 0, 0, 14761, 14762, 14763, 
14715, 36226, 36249, 36250, 36227
24984, 7590, 7613, 7614, 7591, 13873, 13896, 13897, 13874, 0, 0, 0, 0, 14763, 14764, 14765, 
14717, 36227, 36250, 36251, 36228
24985, 7591, 7614, 7615, 7592, 13874, 13897, 13898, 13875, 0, 0, 0, 0, 14765, 14766, 14767, 
14719, 36228, 36251, 36252, 36229
24986, 7592, 7615, 7616, 7593, 13875, 13898, 13899, 13876, 0, 0, 0, 0, 14767, 14768, 14769, 
14721, 36229, 36252, 36253, 36230
24987, 7593, 7616, 7617, 7594, 13876, 13899, 13900, 13877, 0, 0, 0, 0, 14769, 14770, 14771, 
14723, 36230, 36253, 36254, 36231
24988, 7594, 7617, 7618, 7595, 13877, 13900, 13901, 13878, 0, 0, 0, 0, 14771, 14772, 14773, 
14725, 36231, 36254, 36255, 36232
24989, 7595, 7618, 7619, 7596, 13878, 13901, 13902, 13879, 0, 0, 0, 0, 14773, 14774, 14775, 
14727, 36232, 36255, 36256, 36233
24990, 7596, 7619, 7620, 7597, 13879, 13902, 13903, 13880, 0, 0, 0, 0, 14775, 14776, 14777, 
14729, 36233, 36256, 36257, 36234
24991, 7597, 7620, 7621, 7598, 13880, 13903, 13904, 13881, 0, 0, 0, 0, 14777, 14778, 14779, 
14731, 36234, 36257, 36258, 36235
24992, 7598, 7621, 7622, 7599, 13881, 13904, 13905, 13882, 0, 0, 0, 0, 14779, 14780, 14781, 
14733, 36235, 36258, 36259, 36236
24993, 7599, 7622, 7623, 7600, 13882, 13905, 13906, 13883, 0, 0, 0, 0, 14781, 14782, 14783, 
14735, 36236, 36259, 36260, 36237
24994, 7600, 7623, 7624, 7601, 13883, 13906, 13907, 13884, 0, 0, 0, 0, 14783, 14784, 14785, 
14737, 36237, 36260, 36261, 36238
24995, 7601, 7624, 7625, 7602, 13884, 13907, 13908, 13885, 0, 0, 0, 0, 14785, 14786, 14787, 
14739, 36238, 36261, 36262, 36239
24996, 7602, 7625, 7626, 7603, 13885, 13908, 13909, 13886, 0, 0, 0, 0, 14787, 14788, 14789, 
14741, 36239, 36262, 36263, 36240
24997, 7603, 7626, 7627, 7604, 13886, 13909, 13910, 13887, 0, 0, 0, 0, 14789, 14790, 14791, 
14743, 36240, 36263, 36264, 36241
24998, 7604, 7627, 7628, 7605, 13887, 13910, 13911, 13888, 0, 0, 0, 0, 14791, 14792, 14793, 
14745, 36241, 36264, 36265, 36242
24999, 7605, 7628, 7629, 7606, 13888, 13911, 13912, 13889, 0, 0, 0, 0, 14793, 14794, 14795, 
14747, 36242, 36265, 36266, 36243
25000, 7606, 7629, 7630, 7607, 13889, 13912, 13913, 13890, 0, 0, 0, 0, 14795, 14796, 14797, 
14749, 36243, 36266, 36267, 36244
25001, 7607, 7630, 7631, 7608, 13890, 13913, 13914, 13891, 0, 0, 0, 0, 14797, 14798, 14799, 
14751, 36244, 36267, 36268, 36245
25002, 7608, 7631, 7632, 7609, 13891, 13914, 13915, 13892, 0, 0, 0, 0, 14799, 14800, 14801, 
14753, 36245, 36268, 36269, 36246
25003, 7609, 7632, 7633, 7610, 13892, 13915, 13916, 13893, 0, 0, 0, 0, 14801, 14802, 14803, 
14755, 36246, 36269, 36270, 36247
25004, 7610, 7633, 7634, 7611, 13893, 13916, 13917, 13894, 0, 0, 0, 0, 14803, 14804, 14805, 
14757, 36247, 36270, 36271, 36248
25005, 7611, 7634, 971, 970, 13894, 13917, 1841, 1840, 0, 0, 0, 0, 14805, 14806, 1864, 
14759, 36248, 36271, 13564, 13563
25006, 811, 812, 7635, 7612, 1794, 1795, 13918, 13895, 0, 0, 0, 0, 1818, 14807, 14808, 
14760, 13541, 13542, 36272, 36249
25007, 7612, 7635, 7636, 7613, 13895, 13918, 13919, 13896, 0, 0, 0, 0, 14808, 14809, 14810, 
14762, 36249, 36272, 36273, 36250
25008, 7613, 7636, 7637, 7614, 13896, 13919, 13920, 13897, 0, 0, 0, 0, 14810, 14811, 14812, 
14764, 36250, 36273, 36274, 36251
25009, 7614, 7637, 7638, 7615, 13897, 13920, 13921, 13898, 0, 0, 0, 0, 14812, 14813, 14814, 
14766, 36251, 36274, 36275, 36252
25010, 7615, 7638, 7639, 7616, 13898, 13921, 13922, 13899, 0, 0, 0, 0, 14814, 14815, 14816, 
14768, 36252, 36275, 36276, 36253
25011, 7616, 7639, 7640, 7617, 13899, 13922, 13923, 13900, 0, 0, 0, 0, 14816, 14817, 14818, 
14770, 36253, 36276, 36277, 36254
25012, 7617, 7640, 7641, 7618, 13900, 13923, 13924, 13901, 0, 0, 0, 0, 14818, 14819, 14820, 
14772, 36254, 36277, 36278, 36255
25013, 7618, 7641, 7642, 7619, 13901, 13924, 13925, 13902, 0, 0, 0, 0, 14820, 14821, 14822, 
14774, 36255, 36278, 36279, 36256
25014, 7619, 7642, 7643, 7620, 13902, 13925, 13926, 13903, 0, 0, 0, 0, 14822, 14823, 14824, 
14776, 36256, 36279, 36280, 36257
25015, 7620, 7643, 7644, 7621, 13903, 13926, 13927, 13904, 0, 0, 0, 0, 14824, 14825, 14826, 
14778, 36257, 36280, 36281, 36258
25016, 7621, 7644, 7645, 7622, 13904, 13927, 13928, 13905, 0, 0, 0, 0, 14826, 14827, 14828, 
14780, 36258, 36281, 36282, 36259
25017, 7622, 7645, 7646, 7623, 13905, 13928, 13929, 13906, 0, 0, 0, 0, 14828, 14829, 14830, 
14782, 36259, 36282, 36283, 36260
25018, 7623, 7646, 7647, 7624, 13906, 13929, 13930, 13907, 0, 0, 0, 0, 14830, 14831, 14832, 
14784, 36260, 36283, 36284, 36261
25019, 7624, 7647, 7648, 7625, 13907, 13930, 13931, 13908, 0, 0, 0, 0, 14832, 14833, 14834, 
14786, 36261, 36284, 36285, 36262
25020, 7625, 7648, 7649, 7626, 13908, 13931, 13932, 13909, 0, 0, 0, 0, 14834, 14835, 14836, 
14788, 36262, 36285, 36286, 36263
25021, 7626, 7649, 7650, 7627, 13909, 13932, 13933, 13910, 0, 0, 0, 0, 14836, 14837, 14838, 
14790, 36263, 36286, 36287, 36264
25022, 7627, 7650, 7651, 7628, 13910, 13933, 13934, 13911, 0, 0, 0, 0, 14838, 14839, 14840, 
14792, 36264, 36287, 36288, 36265
25023, 7628, 7651, 7652, 7629, 13911, 13934, 13935, 13912, 0, 0, 0, 0, 14840, 14841, 14842, 
14794, 36265, 36288, 36289, 36266
25024, 7629, 7652, 7653, 7630, 13912, 13935, 13936, 13913, 0, 0, 0, 0, 14842, 14843, 14844, 
14796, 36266, 36289, 36290, 36267
25025, 7630, 7653, 7654, 7631, 13913, 13936, 13937, 13914, 0, 0, 0, 0, 14844, 14845, 14846, 
14798, 36267, 36290, 36291, 36268
25026, 7631, 7654, 7655, 7632, 13914, 13937, 13938, 13915, 0, 0, 0, 0, 14846, 14847, 14848, 
14800, 36268, 36291, 36292, 36269
25027, 7632, 7655, 7656, 7633, 13915, 13938, 13939, 13916, 0, 0, 0, 0, 14848, 14849, 14850, 
14802, 36269, 36292, 36293, 36270
25028, 7633, 7656, 7657, 7634, 13916, 13939, 13940, 13917, 0, 0, 0, 0, 14850, 14851, 14852, 
14804, 36270, 36293, 36294, 36271
25029, 7634, 7657, 972, 971, 13917, 13940, 1842, 1841, 0, 0, 0, 0, 14852, 14853, 1865, 
14806, 36271, 36294, 13565, 13564
25030, 812, 813, 7658, 7635, 1795, 1796, 13941, 13918, 0, 0, 0, 0, 1819, 14854, 14855, 
14807, 13542, 13543, 36295, 36272
25031, 7635, 7658, 7659, 7636, 13918, 13941, 13942, 13919, 0, 0, 0, 0, 14855, 14856, 14857, 
14809, 36272, 36295, 36296, 36273
25032, 7636, 7659, 7660, 7637, 13919, 13942, 13943, 13920, 0, 0, 0, 0, 14857, 14858, 14859, 
14811, 36273, 36296, 36297, 36274
25033, 7637, 7660, 7661, 7638, 13920, 13943, 13944, 13921, 0, 0, 0, 0, 14859, 14860, 14861, 
14813, 36274, 36297, 36298, 36275
25034, 7638, 7661, 7662, 7639, 13921, 13944, 13945, 13922, 0, 0, 0, 0, 14861, 14862, 14863, 
14815, 36275, 36298, 36299, 36276
25035, 7639, 7662, 7663, 7640, 13922, 13945, 13946, 13923, 0, 0, 0, 0, 14863, 14864, 14865, 
14817, 36276, 36299, 36300, 36277
25036, 7640, 7663, 7664, 7641, 13923, 13946, 13947, 13924, 0, 0, 0, 0, 14865, 14866, 14867, 
14819, 36277, 36300, 36301, 36278
25037, 7641, 7664, 7665, 7642, 13924, 13947, 13948, 13925, 0, 0, 0, 0, 14867, 14868, 14869, 
14821, 36278, 36301, 36302, 36279
25038, 7642, 7665, 7666, 7643, 13925, 13948, 13949, 13926, 0, 0, 0, 0, 14869, 14870, 14871, 
14823, 36279, 36302, 36303, 36280
25039, 7643, 7666, 7667, 7644, 13926, 13949, 13950, 13927, 0, 0, 0, 0, 14871, 14872, 14873, 
14825, 36280, 36303, 36304, 36281
25040, 7644, 7667, 7668, 7645, 13927, 13950, 13951, 13928, 0, 0, 0, 0, 14873, 14874, 14875, 
14827, 36281, 36304, 36305, 36282
25041, 7645, 7668, 7669, 7646, 13928, 13951, 13952, 13929, 0, 0, 0, 0, 14875, 14876, 14877, 
14829, 36282, 36305, 36306, 36283
25042, 7646, 7669, 7670, 7647, 13929, 13952, 13953, 13930, 0, 0, 0, 0, 14877, 14878, 14879, 
14831, 36283, 36306, 36307, 36284
25043, 7647, 7670, 7671, 7648, 13930, 13953, 13954, 13931, 0, 0, 0, 0, 14879, 14880, 14881, 
14833, 36284, 36307, 36308, 36285
25044, 7648, 7671, 7672, 7649, 13931, 13954, 13955, 13932, 0, 0, 0, 0, 14881, 14882, 14883, 
14835, 36285, 36308, 36309, 36286
25045, 7649, 7672, 7673, 7650, 13932, 13955, 13956, 13933, 0, 0, 0, 0, 14883, 14884, 14885, 
14837, 36286, 36309, 36310, 36287
25046, 7650, 7673, 7674, 7651, 13933, 13956, 13957, 13934, 0, 0, 0, 0, 14885, 14886, 14887, 
14839, 36287, 36310, 36311, 36288
25047, 7651, 7674, 7675, 7652, 13934, 13957, 13958, 13935, 0, 0, 0, 0, 14887, 14888, 14889, 
14841, 36288, 36311, 36312, 36289
25048, 7652, 7675, 7676, 7653, 13935, 13958, 13959, 13936, 0, 0, 0, 0, 14889, 14890, 14891, 
14843, 36289, 36312, 36313, 36290
25049, 7653, 7676, 7677, 7654, 13936, 13959, 13960, 13937, 0, 0, 0, 0, 14891, 14892, 14893, 
14845, 36290, 36313, 36314, 36291
25050, 7654, 7677, 7678, 7655, 13937, 13960, 13961, 13938, 0, 0, 0, 0, 14893, 14894, 14895, 
14847, 36291, 36314, 36315, 36292
25051, 7655, 7678, 7679, 7656, 13938, 13961, 13962, 13939, 0, 0, 0, 0, 14895, 14896, 14897, 
14849, 36292, 36315, 36316, 36293
