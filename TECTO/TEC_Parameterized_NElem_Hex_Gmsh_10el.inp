*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Hex_Gmsh_10el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.1, 0.5
4, 0, 0.1, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.1, 0.5
8, 1, 0.1, 0
9, 1, 0.15, 0
10, 0, 0.15, 0
11, 1, 0.15, 0.5
12, 0, 0.15, 0.5
13, 1, 1.35, 0
14, 0, 1.35, 0
15, 1, 1.35, 0.5
16, 0, 1.35, 0.5
17, 1, 1.4, 0
18, 0, 1.4, 0
19, 1, 1.4, 0.5
20, 0, 1.4, 0.5
21, 1, 1.5, 0
22, 0, 1.5, 0
23, 1, 1.5, 0.5
24, 0, 1.5, 0.5
25, 1.2, 1.4, 0.5
26, 1.2, 1.5, 0.5
27, 1.2, 1.4, 0
28, 1.2, 1.5, 0
29, 2.2, 1.4, 0.5
30, 2.2, 1.5, 0.5
31, 2.2, 1.4, 0
32, 2.2, 1.5, 0
33, 1.2, 1.35, 0.5
34, 2.2, 1.35, 0.5
35, 1.2, 1.35, 0
36, 2.2, 1.35, 0
37, 1.2, 0.15, 0.5
38, 2.2, 0.15, 0.5
39, 1.2, 0.15, 0
40, 2.2, 0.15, 0
41, 1.2, 0.1, 0.5
42, 2.2, 0.1, 0.5
43, 1.2, 0.1, 0
44, 2.2, 0.1, 0
45, 1.2, -1.2490009027033e-16, 0.5
46, 2.2, -1.2490009027033e-16, 0.5
47, 1.2, -1.2490009027033e-16, 0
48, 2.2, -1.2490009027033e-16, 0
49, 2.3, 0.1, 0.5
50, 2.3, -1.2490009027033e-16, 0.5
51, 2.3, 0.1, 0
52, 2.3, -1.2490009027033e-16, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.1, 0.5
56, -0.1, 0.1, 0
57, 1.05, 0.15, 0.5
58, 1.05, 1.35, 0.5
59, 1.05, 0.15, 0
60, 1.05, 1.35, 0
61, 1.15, 1.35, 0.5
62, 1.15, 0.15, 0.5
63, 1.15, 1.35, 0
64, 1.15, 0.15, 0
65, 1, 0.15, -0.1
66, 1, 1.35, -0.1
67, 0, 0.15, -0.1
68, 0, 1.35, -0.1
69, 1.2, 1.35, -0.1
70, 1.2, 0.15, -0.1
71, 2.2, 1.35, -0.1
72, 2.2, 0.15, -0.1
73, 1.15, 1.35, -0.1
74, 1.15, 0.15, -0.1
75, 1.05, 0.15, -0.1
76, 1.05, 1.35, -0.1
77, 1, 1.7, 0
78, 0, 1.7, 0
79, 1, 1.7, 0.5
80, 0, 1.7, 0.5
81, 1.2, 1.7, 0.5
82, 1.2, 1.7, 0
83, 2.2, 1.7, 0.5
84, 2.2, 1.7, 0
85, 1, -0.2, 0
86, 0, -0.2, 0
87, 1, -0.2, 0.5
88, 0, -0.2, 0.5
89, -0.1, -0.2, 0.5
90, -0.1, -0.2, 0
91, 1.2, -0.2, 0.5
92, 2.2, -0.2, 0.5
93, 1.2, -0.2, 0
94, 2.2, -0.2, 0
95, 2.3, -0.2, 0.5
96, 2.3, -0.2, 0
97, 0, 0, 0.020833333333333
98, 0, 0, 0.041666666666667
99, 0, 0, 0.083333333333333
100, 0, 0, 0.125
101, 0, 0, 0.16666666666667
102, 0, 0, 0.20833333333333
103, 0, 0, 0.25
104, 0, 0, 0.29166666666667
105, 0, 0, 0.33333333333333
106, 0, 0, 0.375
107, 0, 0, 0.41666666666667
108, 0, 0, 0.45833333333333
109, 0, 0.033333333333333, 0.5
110, 0, 0.066666666666667, 0.5
111, 0, 0.1, 0.041666666666667
112, 0, 0.1, 0.083333333333333
113, 0, 0.1, 0.125
114, 0, 0.1, 0.16666666666667
115, 0, 0.1, 0.20833333333333
116, 0, 0.1, 0.25
117, 0, 0.1, 0.29166666666667
118, 0, 0.1, 0.33333333333333
119, 0, 0.1, 0.375
120, 0, 0.1, 0.41666666666667
121, 0, 0.1, 0.45833333333333
122, 0, 0.033333333333333, 0
123, 0, 0.066666666666667, 0
124, 1, 0, 0.041666666666667
125, 1, 0, 0.083333333333333
126, 1, 0, 0.125
127, 1, 0, 0.16666666666667
128, 1, 0, 0.20833333333333
129, 1, 0, 0.25
130, 1, 0, 0.29166666666667
131, 1, 0, 0.33333333333333
132, 1, 0, 0.375
133, 1, 0, 0.41666666666667
134, 1, 0, 0.45833333333333
135, 1, 0.033333333333333, 0.5
136, 1, 0.066666666666667, 0.5
137, 1, 0.1, 0.041666666666667
138, 1, 0.1, 0.083333333333333
139, 1, 0.1, 0.125
140, 1, 0.1, 0.16666666666667
141, 1, 0.1, 0.20833333333333
142, 1, 0.1, 0.25
143, 1, 0.1, 0.29166666666667
144, 1, 0.1, 0.33333333333333
145, 1, 0.1, 0.375
146, 1, 0.1, 0.41666666666667
147, 1, 0.1, 0.45833333333333
148, 1, 0.033333333333333, 0
149, 1, 0.066666666666667, 0
150, 0.041666666666667, 0, 0
151, 0.083333333333333, 0, 0
152, 0.125, 0, 0
153, 0.16666666666667, 0, 0
154, 0.20833333333333, 0, 0
155, 0.25, 0, 0
156, 0.29166666666667, 0, 0
157, 0.33333333333333, 0, 0
158, 0.375, 0, 0
159, 0.41666666666667, 0, 0
160, 0.45833333333333, 0, 0
161, 0.5, 0, 0
162, 0.54166666666667, 0, 0
163, 0.58333333333333, 0, 0
164, 0.625, 0, 0
165, 0.66666666666667, 0, 0
166, 0.70833333333333, 0, 0
167, 0.75, 0, 0
168, 0.79166666666667, 0, 0
169, 0.83333333333333, 0, 0
170, 0.875, 0, 0
171, 0.91666666666667, 0, 0
172, 0.95833333333333, 0, 0
173, 0.041666666666667, 0, 0.5
174, 0.083333333333333, 0, 0.5
175, 0.125, 0, 0.5
176, 0.16666666666667, 0, 0.5
177, 0.20833333333333, 0, 0.5
178, 0.25, 0, 0.5
179, 0.29166666666667, 0, 0.5
180, 0.33333333333333, 0, 0.5
181, 0.375, 0, 0.5
182, 0.41666666666667, 0, 0.5
183, 0.45833333333333, 0, 0.5
184, 0.5, 0, 0.5
185, 0.54166666666667, 0, 0.5
186, 0.58333333333333, 0, 0.5
187, 0.625, 0, 0.5
188, 0.66666666666667, 0, 0.5
189, 0.70833333333333, 0, 0.5
190, 0.75, 0, 0.5
191, 0.79166666666667, 0, 0.5
192, 0.83333333333333, 0, 0.5
193, 0.875, 0, 0.5
194, 0.91666666666667, 0, 0.5
195, 0.95833333333333, 0, 0.5
196, 0.041666666666667, 0.1, 0
197, 0.083333333333333, 0.1, 0
198, 0.125, 0.1, 0
199, 0.16666666666667, 0.1, 0
200, 0.20833333333333, 0.1, 0
201, 0.25, 0.1, 0
202, 0.29166666666667, 0.1, 0
203, 0.33333333333333, 0.1, 0
204, 0.375, 0.1, 0
205, 0.41666666666667, 0.1, 0
206, 0.45833333333333, 0.1, 0
207, 0.5, 0.1, 0
208, 0.54166666666667, 0.1, 0
209, 0.58333333333333, 0.1, 0
210, 0.625, 0.1, 0
211, 0.66666666666667, 0.1, 0
212, 0.70833333333333, 0.1, 0
213, 0.75, 0.1, 0
214, 0.79166666666667, 0.1, 0
215, 0.83333333333333, 0.1, 0
216, 0.875, 0.1, 0
217, 0.91666666666667, 0.1, 0
218, 0.95833333333333, 0.1, 0
219, 0.041666666666667, 0.1, 0.5
220, 0.083333333333333, 0.1, 0.5
221, 0.125, 0.1, 0.5
222, 0.16666666666667, 0.1, 0.5
223, 0.20833333333333, 0.1, 0.5
224, 0.25, 0.1, 0.5
225, 0.29166666666667, 0.1, 0.5
226, 0.33333333333333, 0.1, 0.5
227, 0.375, 0.1, 0.5
228, 0.41666666666667, 0.1, 0.5
229, 0.45833333333333, 0.1, 0.5
230, 0.5, 0.1, 0.5
231, 0.54166666666667, 0.1, 0.5
232, 0.58333333333333, 0.1, 0.5
233, 0.625, 0.1, 0.5
234, 0.66666666666667, 0.1, 0.5
235, 0.70833333333333, 0.1, 0.5
236, 0.75, 0.1, 0.5
237, 0.79166666666667, 0.1, 0.5
238, 0.83333333333333, 0.1, 0.5
239, 0.875, 0.1, 0.5
240, 0.91666666666667, 0.1, 0.5
241, 0.95833333333333, 0.1, 0.5
242, 0.041666666666667, 0.15, 0
243, 0.083333333333333, 0.15, 0
244, 0.125, 0.15, 0
245, 0.16666666666667, 0.15, 0
246, 0.20833333333333, 0.15, 0
247, 0.25, 0.15, 0
248, 0.29166666666667, 0.15, 0
249, 0.33333333333333, 0.15, 0
250, 0.375, 0.15, 0
251, 0.41666666666667, 0.15, 0
252, 0.45833333333333, 0.15, 0
253, 0.5, 0.15, 0
254, 0.54166666666667, 0.15, 0
255, 0.58333333333333, 0.15, 0
256, 0.625, 0.15, 0
257, 0.66666666666667, 0.15, 0
258, 0.70833333333333, 0.15, 0
259, 0.75, 0.15, 0
260, 0.79166666666667, 0.15, 0
261, 0.83333333333333, 0.15, 0
262, 0.875, 0.15, 0
263, 0.91666666666667, 0.15, 0
264, 0.95833333333333, 0.15, 0
265, 1, 0.15, 0.041666666666667
266, 1, 0.15, 0.083333333333333
267, 1, 0.15, 0.125
268, 1, 0.15, 0.16666666666667
269, 1, 0.15, 0.20833333333333
270, 1, 0.15, 0.25
271, 1, 0.15, 0.29166666666667
272, 1, 0.15, 0.33333333333333
273, 1, 0.15, 0.375
274, 1, 0.15, 0.41666666666667
275, 1, 0.15, 0.45833333333333
276, 0.041666666666667, 0.15, 0.5
277, 0.083333333333333, 0.15, 0.5
278, 0.125, 0.15, 0.5
279, 0.16666666666667, 0.15, 0.5
280, 0.20833333333333, 0.15, 0.5
281, 0.25, 0.15, 0.5
282, 0.29166666666667, 0.15, 0.5
283, 0.33333333333333, 0.15, 0.5
284, 0.375, 0.15, 0.5
285, 0.41666666666667, 0.15, 0.5
286, 0.45833333333333, 0.15, 0.5
287, 0.5, 0.15, 0.5
288, 0.54166666666667, 0.15, 0.5
289, 0.58333333333333, 0.15, 0.5
290, 0.625, 0.15, 0.5
291, 0.66666666666667, 0.15, 0.5
292, 0.70833333333333, 0.15, 0.5
293, 0.75, 0.15, 0.5
294, 0.79166666666667, 0.15, 0.5
295, 0.83333333333333, 0.15, 0.5
296, 0.875, 0.15, 0.5
297, 0.91666666666667, 0.15, 0.5
298, 0.95833333333333, 0.15, 0.5
299, 0, 0.15, 0.041666666666667
300, 0, 0.15, 0.083333333333333
301, 0, 0.15, 0.125
302, 0, 0.15, 0.16666666666667
303, 0, 0.15, 0.20833333333333
304, 0, 0.15, 0.25
305, 0, 0.15, 0.29166666666667
306, 0, 0.15, 0.33333333333333
307, 0, 0.15, 0.375
308, 0, 0.15, 0.41666666666667
309, 0, 0.15, 0.45833333333333
310, 1, 0.2, 0
311, 1, 0.25, 0
312, 1, 0.3, 0
313, 1, 0.35, 0
314, 1, 0.4, 0
315, 1, 0.45, 0
316, 1, 0.5, 0
317, 1, 0.55, 0
318, 1, 0.6, 0
319, 1, 0.65, 0
320, 1, 0.7, 0
321, 1, 0.75, 0
322, 1, 0.8, 0
323, 1, 0.85, 0
324, 1, 0.9, 0
325, 1, 0.95, 0
326, 1, 1, 0
327, 1, 1.05, 0
328, 1, 1.1, 0
329, 1, 1.15, 0
330, 1, 1.2, 0
331, 1, 1.25, 0
332, 1, 1.3, 0
333, 0, 0.2, 0
334, 0, 0.25, 0
335, 0, 0.3, 0
336, 0, 0.35, 0
337, 0, 0.4, 0
338, 0, 0.45, 0
339, 0, 0.5, 0
340, 0, 0.55, 0
341, 0, 0.6, 0
342, 0, 0.65, 0
343, 0, 0.7, 0
344, 0, 0.75, 0
345, 0, 0.8, 0
346, 0, 0.85, 0
347, 0, 0.9, 0
348, 0, 0.95, 0
349, 0, 1, 0
350, 0, 1.05, 0
351, 0, 1.1, 0
352, 0, 1.15, 0
353, 0, 1.2, 0
354, 0, 1.25, 0
355, 0, 1.3, 0
356, 0.041666666666667, 1.35, 0
357, 0.083333333333333, 1.35, 0
358, 0.125, 1.35, 0
359, 0.16666666666667, 1.35, 0
360, 0.20833333333333, 1.35, 0
361, 0.25, 1.35, 0
362, 0.29166666666667, 1.35, 0
363, 0.33333333333333, 1.35, 0
364, 0.375, 1.35, 0
365, 0.41666666666667, 1.35, 0
366, 0.45833333333333, 1.35, 0
367, 0.5, 1.35, 0
368, 0.54166666666667, 1.35, 0
369, 0.58333333333333, 1.35, 0
370, 0.625, 1.35, 0
371, 0.66666666666667, 1.35, 0
372, 0.70833333333333, 1.35, 0
373, 0.75, 1.35, 0
374, 0.79166666666667, 1.35, 0
375, 0.83333333333333, 1.35, 0
376, 0.875, 1.35, 0
377, 0.91666666666667, 1.35, 0
378, 0.95833333333333, 1.35, 0
379, 1, 0.2, 0.5
380, 1, 0.25, 0.5
381, 1, 0.3, 0.5
382, 1, 0.35, 0.5
383, 1, 0.4, 0.5
384, 1, 0.45, 0.5
385, 1, 0.5, 0.5
386, 1, 0.55, 0.5
387, 1, 0.6, 0.5
388, 1, 0.65, 0.5
389, 1, 0.7, 0.5
390, 1, 0.75, 0.5
391, 1, 0.8, 0.5
392, 1, 0.85, 0.5
393, 1, 0.9, 0.5
394, 1, 0.95, 0.5
395, 1, 1, 0.5
396, 1, 1.05, 0.5
397, 1, 1.1, 0.5
398, 1, 1.15, 0.5
399, 1, 1.2, 0.5
400, 1, 1.25, 0.5
401, 1, 1.3, 0.5
402, 1, 1.35, 0.041666666666667
403, 1, 1.35, 0.083333333333333
404, 1, 1.35, 0.125
405, 1, 1.35, 0.16666666666667
406, 1, 1.35, 0.20833333333333
407, 1, 1.35, 0.25
408, 1, 1.35, 0.29166666666667
409, 1, 1.35, 0.33333333333333
410, 1, 1.35, 0.375
411, 1, 1.35, 0.41666666666667
412, 1, 1.35, 0.45833333333333
413, 0, 0.2, 0.5
414, 0, 0.25, 0.5
415, 0, 0.3, 0.5
416, 0, 0.35, 0.5
417, 0, 0.4, 0.5
418, 0, 0.45, 0.5
419, 0, 0.5, 0.5
420, 0, 0.55, 0.5
421, 0, 0.6, 0.5
422, 0, 0.65, 0.5
423, 0, 0.7, 0.5
424, 0, 0.75, 0.5
425, 0, 0.8, 0.5
426, 0, 0.85, 0.5
427, 0, 0.9, 0.5
428, 0, 0.95, 0.5
429, 0, 1, 0.5
430, 0, 1.05, 0.5
431, 0, 1.1, 0.5
432, 0, 1.15, 0.5
433, 0, 1.2, 0.5
434, 0, 1.25, 0.5
435, 0, 1.3, 0.5
436, 0.041666666666667, 1.35, 0.5
437, 0.083333333333333, 1.35, 0.5
438, 0.125, 1.35, 0.5
439, 0.16666666666667, 1.35, 0.5
440, 0.20833333333333, 1.35, 0.5
441, 0.25, 1.35, 0.5
442, 0.29166666666667, 1.35, 0.5
443, 0.33333333333333, 1.35, 0.5
444, 0.375, 1.35, 0.5
445, 0.41666666666667, 1.35, 0.5
446, 0.45833333333333, 1.35, 0.5
447, 0.5, 1.35, 0.5
448, 0.54166666666667, 1.35, 0.5
449, 0.58333333333333, 1.35, 0.5
450, 0.625, 1.35, 0.5
451, 0.66666666666667, 1.35, 0.5
452, 0.70833333333333, 1.35, 0.5
453, 0.75, 1.35, 0.5
454, 0.79166666666667, 1.35, 0.5
455, 0.83333333333333, 1.35, 0.5
456, 0.875, 1.35, 0.5
457, 0.91666666666667, 1.35, 0.5
458, 0.95833333333333, 1.35, 0.5
459, 0, 1.35, 0.041666666666667
460, 0, 1.35, 0.083333333333333
461, 0, 1.35, 0.125
462, 0, 1.35, 0.16666666666667
463, 0, 1.35, 0.20833333333333
464, 0, 1.35, 0.25
465, 0, 1.35, 0.29166666666667
466, 0, 1.35, 0.33333333333333
467, 0, 1.35, 0.375
468, 0, 1.35, 0.41666666666667
469, 0, 1.35, 0.45833333333333
470, 0.041666666666667, 1.4, 0
471, 0.083333333333333, 1.4, 0
472, 0.125, 1.4, 0
473, 0.16666666666667, 1.4, 0
474, 0.20833333333333, 1.4, 0
475, 0.25, 1.4, 0
476, 0.29166666666667, 1.4, 0
477, 0.33333333333333, 1.4, 0
478, 0.375, 1.4, 0
479, 0.41666666666667, 1.4, 0
480, 0.45833333333333, 1.4, 0
481, 0.5, 1.4, 0
482, 0.54166666666667, 1.4, 0
483, 0.58333333333333, 1.4, 0
484, 0.625, 1.4, 0
485, 0.66666666666667, 1.4, 0
486, 0.70833333333333, 1.4, 0
487, 0.75, 1.4, 0
488, 0.79166666666667, 1.4, 0
489, 0.83333333333333, 1.4, 0
490, 0.875, 1.4, 0
491, 0.91666666666667, 1.4, 0
492, 0.95833333333333, 1.4, 0
493, 1, 1.4, 0.041666666666667
494, 1, 1.4, 0.083333333333333
495, 1, 1.4, 0.125
496, 1, 1.4, 0.16666666666667
497, 1, 1.4, 0.20833333333333
498, 1, 1.4, 0.25
499, 1, 1.4, 0.29166666666667
500, 1, 1.4, 0.33333333333333
501, 1, 1.4, 0.375
502, 1, 1.4, 0.41666666666667
503, 1, 1.4, 0.45833333333333
504, 0.041666666666667, 1.4, 0.5
505, 0.083333333333333, 1.4, 0.5
506, 0.125, 1.4, 0.5
507, 0.16666666666667, 1.4, 0.5
508, 0.20833333333333, 1.4, 0.5
509, 0.25, 1.4, 0.5
510, 0.29166666666667, 1.4, 0.5
511, 0.33333333333333, 1.4, 0.5
512, 0.375, 1.4, 0.5
513, 0.41666666666667, 1.4, 0.5
514, 0.45833333333333, 1.4, 0.5
515, 0.5, 1.4, 0.5
516, 0.54166666666667, 1.4, 0.5
517, 0.58333333333333, 1.4, 0.5
518, 0.625, 1.4, 0.5
519, 0.66666666666667, 1.4, 0.5
520, 0.70833333333333, 1.4, 0.5
521, 0.75, 1.4, 0.5
522, 0.79166666666667, 1.4, 0.5
523, 0.83333333333333, 1.4, 0.5
524, 0.875, 1.4, 0.5
525, 0.91666666666667, 1.4, 0.5
526, 0.95833333333333, 1.4, 0.5
527, 0, 1.4, 0.041666666666667
528, 0, 1.4, 0.083333333333333
529, 0, 1.4, 0.125
530, 0, 1.4, 0.16666666666667
531, 0, 1.4, 0.20833333333333
532, 0, 1.4, 0.25
533, 0, 1.4, 0.29166666666667
534, 0, 1.4, 0.33333333333333
535, 0, 1.4, 0.375
536, 0, 1.4, 0.41666666666667
537, 0, 1.4, 0.45833333333333
538, 1, 1.4333333333333, 0
539, 1, 1.4666666666667, 0
540, 0, 1.4333333333333, 0
541, 0, 1.4666666666667, 0
542, 0.041666666666667, 1.5, 0
543, 0.083333333333333, 1.5, 0
544, 0.125, 1.5, 0
545, 0.16666666666667, 1.5, 0
546, 0.20833333333333, 1.5, 0
547, 0.25, 1.5, 0
548, 0.29166666666667, 1.5, 0
549, 0.33333333333333, 1.5, 0
550, 0.375, 1.5, 0
551, 0.41666666666667, 1.5, 0
552, 0.45833333333333, 1.5, 0
553, 0.5, 1.5, 0
554, 0.54166666666667, 1.5, 0
555, 0.58333333333333, 1.5, 0
556, 0.625, 1.5, 0
557, 0.66666666666667, 1.5, 0
558, 0.70833333333333, 1.5, 0
559, 0.75, 1.5, 0
560, 0.79166666666667, 1.5, 0
561, 0.83333333333333, 1.5, 0
562, 0.875, 1.5, 0
563, 0.91666666666667, 1.5, 0
564, 0.95833333333333, 1.5, 0
565, 1, 1.4333333333333, 0.5
566, 1, 1.4666666666667, 0.5
567, 1, 1.5, 0.041666666666667
568, 1, 1.5, 0.083333333333333
569, 1, 1.5, 0.125
570, 1, 1.5, 0.16666666666667
571, 1, 1.5, 0.20833333333333
572, 1, 1.5, 0.25
573, 1, 1.5, 0.29166666666667
574, 1, 1.5, 0.33333333333333
575, 1, 1.5, 0.375
576, 1, 1.5, 0.41666666666667
577, 1, 1.5, 0.45833333333333
578, 0, 1.4333333333333, 0.5
579, 0, 1.4666666666667, 0.5
580, 0.041666666666667, 1.5, 0.5
581, 0.083333333333333, 1.5, 0.5
582, 0.125, 1.5, 0.5
583, 0.16666666666667, 1.5, 0.5
584, 0.20833333333333, 1.5, 0.5
585, 0.25, 1.5, 0.5
586, 0.29166666666667, 1.5, 0.5
587, 0.33333333333333, 1.5, 0.5
588, 0.375, 1.5, 0.5
589, 0.41666666666667, 1.5, 0.5
590, 0.45833333333333, 1.5, 0.5
591, 0.5, 1.5, 0.5
592, 0.54166666666667, 1.5, 0.5
593, 0.58333333333333, 1.5, 0.5
594, 0.625, 1.5, 0.5
595, 0.66666666666667, 1.5, 0.5
596, 0.70833333333333, 1.5, 0.5
597, 0.75, 1.5, 0.5
598, 0.79166666666667, 1.5, 0.5
599, 0.83333333333333, 1.5, 0.5
600, 0.875, 1.5, 0.5
601, 0.91666666666667, 1.5, 0.5
602, 0.95833333333333, 1.5, 0.5
603, 0, 1.5, 0.041666666666667
604, 0, 1.5, 0.083333333333333
605, 0, 1.5, 0.125
606, 0, 1.5, 0.16666666666667
607, 0, 1.5, 0.20833333333333
608, 0, 1.5, 0.25
609, 0, 1.5, 0.29166666666667
610, 0, 1.5, 0.33333333333333
611, 0, 1.5, 0.375
612, 0, 1.5, 0.41666666666667
613, 0, 1.5, 0.45833333333333
614, 1.04, 1.4, 0.5
615, 1.08, 1.4, 0.5
616, 1.12, 1.4, 0.5
617, 1.16, 1.4, 0.5
618, 1.04, 1.5, 0.5
619, 1.08, 1.5, 0.5
620, 1.12, 1.5, 0.5
621, 1.16, 1.5, 0.5
622, 1.2, 1.4333333333333, 0.5
623, 1.2, 1.4666666666667, 0.5
624, 1.04, 1.4, 0
625, 1.08, 1.4, 0
626, 1.12, 1.4, 0
627, 1.16, 1.4, 0
628, 1.04, 1.5, 0
629, 1.08, 1.5, 0
630, 1.12, 1.5, 0
631, 1.16, 1.5, 0
632, 1.2, 1.4333333333333, 0
633, 1.2, 1.4666666666667, 0
634, 1.2, 1.4, 0.041666666666667
635, 1.2, 1.4, 0.083333333333333
636, 1.2, 1.4, 0.125
637, 1.2, 1.4, 0.16666666666667
638, 1.2, 1.4, 0.20833333333333
639, 1.2, 1.4, 0.25
640, 1.2, 1.4, 0.29166666666667
641, 1.2, 1.4, 0.33333333333333
642, 1.2, 1.4, 0.375
643, 1.2, 1.4, 0.41666666666667
644, 1.2, 1.4, 0.45833333333333
645, 1.2, 1.5, 0.041666666666667
646, 1.2, 1.5, 0.083333333333333
647, 1.2, 1.5, 0.125
648, 1.2, 1.5, 0.16666666666667
649, 1.2, 1.5, 0.20833333333333
650, 1.2, 1.5, 0.25
651, 1.2, 1.5, 0.29166666666667
652, 1.2, 1.5, 0.33333333333333
653, 1.2, 1.5, 0.375
654, 1.2, 1.5, 0.41666666666667
655, 1.2, 1.5, 0.45833333333333
656, 1.2416666666667, 1.4, 0.5
657, 1.2833333333333, 1.4, 0.5
658, 1.325, 1.4, 0.5
659, 1.3666666666667, 1.4, 0.5
660, 1.4083333333333, 1.4, 0.5
661, 1.45, 1.4, 0.5
662, 1.4916666666667, 1.4, 0.5
663, 1.5333333333333, 1.4, 0.5
664, 1.575, 1.4, 0.5
665, 1.6166666666667, 1.4, 0.5
666, 1.6583333333333, 1.4, 0.5
667, 1.7, 1.4, 0.5
668, 1.7416666666667, 1.4, 0.5
669, 1.7833333333333, 1.4, 0.5
670, 1.825, 1.4, 0.5
671, 1.8666666666667, 1.4, 0.5
672, 1.9083333333333, 1.4, 0.5
673, 1.95, 1.4, 0.5
674, 1.9916666666667, 1.4, 0.5
675, 2.0333333333333, 1.4, 0.5
676, 2.075, 1.4, 0.5
677, 2.1166666666667, 1.4, 0.5
678, 2.1583333333333, 1.4, 0.5
679, 1.2416666666667, 1.5, 0.5
680, 1.2833333333333, 1.5, 0.5
681, 1.325, 1.5, 0.5
682, 1.3666666666667, 1.5, 0.5
683, 1.4083333333333, 1.5, 0.5
684, 1.45, 1.5, 0.5
685, 1.4916666666667, 1.5, 0.5
686, 1.5333333333333, 1.5, 0.5
687, 1.575, 1.5, 0.5
688, 1.6166666666667, 1.5, 0.5
689, 1.6583333333333, 1.5, 0.5
690, 1.7, 1.5, 0.5
691, 1.7416666666667, 1.5, 0.5
692, 1.7833333333333, 1.5, 0.5
693, 1.825, 1.5, 0.5
694, 1.8666666666667, 1.5, 0.5
695, 1.9083333333333, 1.5, 0.5
696, 1.95, 1.5, 0.5
697, 1.9916666666667, 1.5, 0.5
698, 2.0333333333333, 1.5, 0.5
699, 2.075, 1.5, 0.5
700, 2.1166666666667, 1.5, 0.5
701, 2.1583333333333, 1.5, 0.5
702, 2.2, 1.4333333333333, 0.5
703, 2.2, 1.4666666666667, 0.5
704, 1.2416666666667, 1.4, 0
705, 1.2833333333333, 1.4, 0
706, 1.325, 1.4, 0
707, 1.3666666666667, 1.4, 0
708, 1.4083333333333, 1.4, 0
709, 1.45, 1.4, 0
710, 1.4916666666667, 1.4, 0
711, 1.5333333333333, 1.4, 0
712, 1.575, 1.4, 0
713, 1.6166666666667, 1.4, 0
714, 1.6583333333333, 1.4, 0
715, 1.7, 1.4, 0
716, 1.7416666666667, 1.4, 0
717, 1.7833333333333, 1.4, 0
718, 1.825, 1.4, 0
719, 1.8666666666667, 1.4, 0
720, 1.9083333333333, 1.4, 0
721, 1.95, 1.4, 0
722, 1.9916666666667, 1.4, 0
723, 2.0333333333333, 1.4, 0
724, 2.075, 1.4, 0
725, 2.1166666666667, 1.4, 0
726, 2.1583333333333, 1.4, 0
727, 1.2416666666667, 1.5, 0
728, 1.2833333333333, 1.5, 0
729, 1.325, 1.5, 0
730, 1.3666666666667, 1.5, 0
731, 1.4083333333333, 1.5, 0
732, 1.45, 1.5, 0
733, 1.4916666666667, 1.5, 0
734, 1.5333333333333, 1.5, 0
735, 1.575, 1.5, 0
736, 1.6166666666667, 1.5, 0
737, 1.6583333333333, 1.5, 0
738, 1.7, 1.5, 0
739, 1.7416666666667, 1.5, 0
740, 1.7833333333333, 1.5, 0
741, 1.825, 1.5, 0
742, 1.8666666666667, 1.5, 0
743, 1.9083333333333, 1.5, 0
744, 1.95, 1.5, 0
745, 1.9916666666667, 1.5, 0
746, 2.0333333333333, 1.5, 0
747, 2.075, 1.5, 0
748, 2.1166666666667, 1.5, 0
749, 2.1583333333333, 1.5, 0
750, 2.2, 1.4333333333333, 0
751, 2.2, 1.4666666666667, 0
752, 2.2, 1.4, 0.041666666666667
753, 2.2, 1.4, 0.083333333333333
754, 2.2, 1.4, 0.125
755, 2.2, 1.4, 0.16666666666667
756, 2.2, 1.4, 0.20833333333333
757, 2.2, 1.4, 0.25
758, 2.2, 1.4, 0.29166666666667
759, 2.2, 1.4, 0.33333333333333
760, 2.2, 1.4, 0.375
761, 2.2, 1.4, 0.41666666666667
762, 2.2, 1.4, 0.45833333333333
763, 2.2, 1.5, 0.041666666666667
764, 2.2, 1.5, 0.083333333333333
765, 2.2, 1.5, 0.125
766, 2.2, 1.5, 0.16666666666667
767, 2.2, 1.5, 0.20833333333333
768, 2.2, 1.5, 0.25
769, 2.2, 1.5, 0.29166666666667
770, 2.2, 1.5, 0.33333333333333
771, 2.2, 1.5, 0.375
772, 2.2, 1.5, 0.41666666666667
773, 2.2, 1.5, 0.45833333333333
774, 1.2416666666667, 1.35, 0.5
775, 1.2833333333333, 1.35, 0.5
776, 1.325, 1.35, 0.5
777, 1.3666666666667, 1.35, 0.5
778, 1.4083333333333, 1.35, 0.5
779, 1.45, 1.35, 0.5
780, 1.4916666666667, 1.35, 0.5
781, 1.5333333333333, 1.35, 0.5
782, 1.575, 1.35, 0.5
783, 1.6166666666667, 1.35, 0.5
784, 1.6583333333333, 1.35, 0.5
785, 1.7, 1.35, 0.5
786, 1.7416666666667, 1.35, 0.5
787, 1.7833333333333, 1.35, 0.5
788, 1.825, 1.35, 0.5
789, 1.8666666666667, 1.35, 0.5
790, 1.9083333333333, 1.35, 0.5
791, 1.95, 1.35, 0.5
792, 1.9916666666667, 1.35, 0.5
793, 2.0333333333333, 1.35, 0.5
794, 2.075, 1.35, 0.5
795, 2.1166666666667, 1.35, 0.5
796, 2.1583333333333, 1.35, 0.5
797, 1.2416666666667, 1.35, 0
798, 1.2833333333333, 1.35, 0
799, 1.325, 1.35, 0
800, 1.3666666666667, 1.35, 0
801, 1.4083333333333, 1.35, 0
802, 1.45, 1.35, 0
803, 1.4916666666667, 1.35, 0
804, 1.5333333333333, 1.35, 0
805, 1.575, 1.35, 0
806, 1.6166666666667, 1.35, 0
807, 1.6583333333333, 1.35, 0
808, 1.7, 1.35, 0
809, 1.7416666666667, 1.35, 0
810, 1.7833333333333, 1.35, 0
811, 1.825, 1.35, 0
812, 1.8666666666667, 1.35, 0
813, 1.9083333333333, 1.35, 0
814, 1.95, 1.35, 0
815, 1.9916666666667, 1.35, 0
816, 2.0333333333333, 1.35, 0
817, 2.075, 1.35, 0
818, 2.1166666666667, 1.35, 0
819, 2.1583333333333, 1.35, 0
820, 1.2, 1.35, 0.041666666666667
821, 1.2, 1.35, 0.083333333333333
822, 1.2, 1.35, 0.125
823, 1.2, 1.35, 0.16666666666667
824, 1.2, 1.35, 0.20833333333333
825, 1.2, 1.35, 0.25
826, 1.2, 1.35, 0.29166666666667
827, 1.2, 1.35, 0.33333333333333
828, 1.2, 1.35, 0.375
829, 1.2, 1.35, 0.41666666666667
830, 1.2, 1.35, 0.45833333333333
831, 2.2, 1.35, 0.041666666666667
832, 2.2, 1.35, 0.083333333333333
833, 2.2, 1.35, 0.125
834, 2.2, 1.35, 0.16666666666667
835, 2.2, 1.35, 0.20833333333333
836, 2.2, 1.35, 0.25
837, 2.2, 1.35, 0.29166666666667
838, 2.2, 1.35, 0.33333333333333
839, 2.2, 1.35, 0.375
840, 2.2, 1.35, 0.41666666666667
841, 2.2, 1.35, 0.45833333333333
842, 1.2, 1.3, 0.5
843, 1.2, 1.25, 0.5
844, 1.2, 1.2, 0.5
845, 1.2, 1.15, 0.5
846, 1.2, 1.1, 0.5
847, 1.2, 1.05, 0.5
848, 1.2, 1, 0.5
849, 1.2, 0.95, 0.5
850, 1.2, 0.9, 0.5
851, 1.2, 0.85, 0.5
852, 1.2, 0.8, 0.5
853, 1.2, 0.75, 0.5
854, 1.2, 0.7, 0.5
855, 1.2, 0.65, 0.5
856, 1.2, 0.6, 0.5
857, 1.2, 0.55, 0.5
858, 1.2, 0.5, 0.5
859, 1.2, 0.45, 0.5
860, 1.2, 0.4, 0.5
861, 1.2, 0.35, 0.5
862, 1.2, 0.3, 0.5
863, 1.2, 0.25, 0.5
864, 1.2, 0.2, 0.5
865, 2.2, 1.3, 0.5
866, 2.2, 1.25, 0.5
867, 2.2, 1.2, 0.5
868, 2.2, 1.15, 0.5
869, 2.2, 1.1, 0.5
870, 2.2, 1.05, 0.5
871, 2.2, 1, 0.5
872, 2.2, 0.95, 0.5
873, 2.2, 0.9, 0.5
874, 2.2, 0.85, 0.5
875, 2.2, 0.8, 0.5
876, 2.2, 0.75, 0.5
877, 2.2, 0.7, 0.5
878, 2.2, 0.65, 0.5
879, 2.2, 0.6, 0.5
880, 2.2, 0.55, 0.5
881, 2.2, 0.5, 0.5
882, 2.2, 0.45, 0.5
883, 2.2, 0.4, 0.5
884, 2.2, 0.35, 0.5
885, 2.2, 0.3, 0.5
886, 2.2, 0.25, 0.5
887, 2.2, 0.2, 0.5
888, 1.2416666666667, 0.15, 0.5
889, 1.2833333333333, 0.15, 0.5
890, 1.325, 0.15, 0.5
891, 1.3666666666667, 0.15, 0.5
892, 1.4083333333333, 0.15, 0.5
893, 1.45, 0.15, 0.5
894, 1.4916666666667, 0.15, 0.5
895, 1.5333333333333, 0.15, 0.5
896, 1.575, 0.15, 0.5
897, 1.6166666666667, 0.15, 0.5
898, 1.6583333333333, 0.15, 0.5
899, 1.7, 0.15, 0.5
900, 1.7416666666667, 0.15, 0.5
901, 1.7833333333333, 0.15, 0.5
902, 1.825, 0.15, 0.5
903, 1.8666666666667, 0.15, 0.5
904, 1.9083333333333, 0.15, 0.5
905, 1.95, 0.15, 0.5
906, 1.9916666666667, 0.15, 0.5
907, 2.0333333333333, 0.15, 0.5
908, 2.075, 0.15, 0.5
909, 2.1166666666667, 0.15, 0.5
910, 2.1583333333333, 0.15, 0.5
911, 1.2, 1.3, 0
912, 1.2, 1.25, 0
913, 1.2, 1.2, 0
914, 1.2, 1.15, 0
915, 1.2, 1.1, 0
916, 1.2, 1.05, 0
917, 1.2, 1, 0
918, 1.2, 0.95, 0
919, 1.2, 0.9, 0
920, 1.2, 0.85, 0
921, 1.2, 0.8, 0
922, 1.2, 0.75, 0
923, 1.2, 0.7, 0
924, 1.2, 0.65, 0
925, 1.2, 0.6, 0
926, 1.2, 0.55, 0
927, 1.2, 0.5, 0
928, 1.2, 0.45, 0
929, 1.2, 0.4, 0
930, 1.2, 0.35, 0
931, 1.2, 0.3, 0
932, 1.2, 0.25, 0
933, 1.2, 0.2, 0
934, 2.2, 1.3, 0
935, 2.2, 1.25, 0
936, 2.2, 1.2, 0
937, 2.2, 1.15, 0
938, 2.2, 1.1, 0
939, 2.2, 1.05, 0
940, 2.2, 1, 0
941, 2.2, 0.95, 0
942, 2.2, 0.9, 0
943, 2.2, 0.85, 0
944, 2.2, 0.8, 0
945, 2.2, 0.75, 0
946, 2.2, 0.7, 0
947, 2.2, 0.65, 0
948, 2.2, 0.6, 0
949, 2.2, 0.55, 0
950, 2.2, 0.5, 0
951, 2.2, 0.45, 0
952, 2.2, 0.4, 0
953, 2.2, 0.35, 0
954, 2.2, 0.3, 0
955, 2.2, 0.25, 0
956, 2.2, 0.2, 0
957, 1.2416666666667, 0.15, 0
958, 1.2833333333333, 0.15, 0
959, 1.325, 0.15, 0
960, 1.3666666666667, 0.15, 0
961, 1.4083333333333, 0.15, 0
962, 1.45, 0.15, 0
963, 1.4916666666667, 0.15, 0
964, 1.5333333333333, 0.15, 0
965, 1.575, 0.15, 0
966, 1.6166666666667, 0.15, 0
967, 1.6583333333333, 0.15, 0
968, 1.7, 0.15, 0
969, 1.7416666666667, 0.15, 0
970, 1.7833333333333, 0.15, 0
971, 1.825, 0.15, 0
972, 1.8666666666667, 0.15, 0
973, 1.9083333333333, 0.15, 0
974, 1.95, 0.15, 0
975, 1.9916666666667, 0.15, 0
976, 2.0333333333333, 0.15, 0
977, 2.075, 0.15, 0
978, 2.1166666666667, 0.15, 0
979, 2.1583333333333, 0.15, 0
980, 1.2, 0.15, 0.041666666666667
981, 1.2, 0.15, 0.083333333333333
982, 1.2, 0.15, 0.125
983, 1.2, 0.15, 0.16666666666667
984, 1.2, 0.15, 0.20833333333333
985, 1.2, 0.15, 0.25
986, 1.2, 0.15, 0.29166666666667
987, 1.2, 0.15, 0.33333333333333
988, 1.2, 0.15, 0.375
989, 1.2, 0.15, 0.41666666666667
990, 1.2, 0.15, 0.45833333333333
991, 2.2, 0.15, 0.041666666666667
992, 2.2, 0.15, 0.083333333333333
993, 2.2, 0.15, 0.125
994, 2.2, 0.15, 0.16666666666667
995, 2.2, 0.15, 0.20833333333333
996, 2.2, 0.15, 0.25
997, 2.2, 0.15, 0.29166666666667
998, 2.2, 0.15, 0.33333333333333
999, 2.2, 0.15, 0.375
1000, 2.2, 0.15, 0.41666666666667
1001, 2.2, 0.15, 0.45833333333333
1002, 1.2416666666667, 0.1, 0.5
1003, 1.2833333333333, 0.1, 0.5
1004, 1.325, 0.1, 0.5
1005, 1.3666666666667, 0.1, 0.5
1006, 1.4083333333333, 0.1, 0.5
1007, 1.45, 0.1, 0.5
1008, 1.4916666666667, 0.1, 0.5
1009, 1.5333333333333, 0.1, 0.5
1010, 1.575, 0.1, 0.5
1011, 1.6166666666667, 0.1, 0.5
1012, 1.6583333333333, 0.1, 0.5
1013, 1.7, 0.1, 0.5
1014, 1.7416666666667, 0.1, 0.5
1015, 1.7833333333333, 0.1, 0.5
1016, 1.825, 0.1, 0.5
1017, 1.8666666666667, 0.1, 0.5
1018, 1.9083333333333, 0.1, 0.5
1019, 1.95, 0.1, 0.5
1020, 1.9916666666667, 0.1, 0.5
1021, 2.0333333333333, 0.1, 0.5
1022, 2.075, 0.1, 0.5
1023, 2.1166666666667, 0.1, 0.5
1024, 2.1583333333333, 0.1, 0.5
1025, 1.2, 0.125, 0
1026, 2.2, 0.125, 0
1027, 1.2416666666667, 0.1, 0
1028, 1.2833333333333, 0.1, 0
1029, 1.325, 0.1, 0
1030, 1.3666666666667, 0.1, 0
1031, 1.4083333333333, 0.1, 0
1032, 1.45, 0.1, 0
1033, 1.4916666666667, 0.1, 0
1034, 1.5333333333333, 0.1, 0
1035, 1.575, 0.1, 0
1036, 1.6166666666667, 0.1, 0
1037, 1.6583333333333, 0.1, 0
1038, 1.7, 0.1, 0
1039, 1.7416666666667, 0.1, 0
1040, 1.7833333333333, 0.1, 0
1041, 1.825, 0.1, 0
1042, 1.8666666666667, 0.1, 0
1043, 1.9083333333333, 0.1, 0
1044, 1.95, 0.1, 0
1045, 1.9916666666667, 0.1, 0
1046, 2.0333333333333, 0.1, 0
1047, 2.075, 0.1, 0
1048, 2.1166666666667, 0.1, 0
1049, 2.1583333333333, 0.1, 0
1050, 1.2208333333333, 0.1, 0
1051, 1.2625, 0.1, 0
1052, 1.3041666666667, 0.1, 0
1053, 1.3458333333333, 0.1, 0
1054, 1.3875, 0.1, 0
1055, 1.4291666666667, 0.1, 0
1056, 1.4708333333333, 0.1, 0
1057, 1.5125, 0.1, 0
1058, 1.5541666666667, 0.1, 0
1059, 1.5958333333333, 0.1, 0
1060, 1.6375, 0.1, 0
1061, 1.6791666666667, 0.1, 0
1062, 1.7208333333333, 0.1, 0
1063, 1.7625, 0.1, 0
1064, 1.8041666666667, 0.1, 0
1065, 1.8458333333333, 0.1, 0
1066, 1.8875, 0.1, 0
1067, 1.9291666666667, 0.1, 0
1068, 1.9708333333333, 0.1, 0
1069, 2.0125, 0.1, 0
1070, 2.0541666666667, 0.1, 0
1071, 2.0958333333333, 0.1, 0
1072, 2.1375, 0.1, 0
1073, 2.1791666666667, 0.1, 0
1074, 1.2, 0.1, 0.041666666666667
1075, 1.2, 0.1, 0.083333333333333
1076, 1.2, 0.1, 0.125
1077, 1.2, 0.1, 0.16666666666667
1078, 1.2, 0.1, 0.20833333333333
1079, 1.2, 0.1, 0.25
1080, 1.2, 0.1, 0.29166666666667
1081, 1.2, 0.1, 0.33333333333333
1082, 1.2, 0.1, 0.375
1083, 1.2, 0.1, 0.41666666666667
1084, 1.2, 0.1, 0.45833333333333
1085, 1.2, 0.1, 0.020833333333333
1086, 1.2, 0.1, 0.0625
1087, 1.2, 0.1, 0.10416666666667
1088, 1.2, 0.1, 0.14583333333333
1089, 1.2, 0.1, 0.1875
1090, 1.2, 0.1, 0.22916666666667
1091, 1.2, 0.1, 0.27083333333333
1092, 1.2, 0.1, 0.3125
1093, 1.2, 0.1, 0.35416666666667
1094, 1.2, 0.1, 0.39583333333333
1095, 1.2, 0.1, 0.4375
1096, 1.2, 0.1, 0.47916666666667
1097, 2.2, 0.1, 0.041666666666667
1098, 2.2, 0.1, 0.083333333333333
1099, 2.2, 0.1, 0.125
1100, 2.2, 0.1, 0.16666666666667
1101, 2.2, 0.1, 0.20833333333333
1102, 2.2, 0.1, 0.25
1103, 2.2, 0.1, 0.29166666666667
1104, 2.2, 0.1, 0.33333333333333
1105, 2.2, 0.1, 0.375
1106, 2.2, 0.1, 0.41666666666667
1107, 2.2, 0.1, 0.45833333333333
1108, 2.2, 0.1, 0.020833333333333
1109, 2.2, 0.1, 0.0625
1110, 2.2, 0.1, 0.10416666666667
1111, 2.2, 0.1, 0.14583333333333
1112, 2.2, 0.1, 0.1875
1113, 2.2, 0.1, 0.22916666666667
1114, 2.2, 0.1, 0.27083333333333
1115, 2.2, 0.1, 0.3125
1116, 2.2, 0.1, 0.35416666666667
1117, 2.2, 0.1, 0.39583333333333
1118, 2.2, 0.1, 0.4375
1119, 2.2, 0.1, 0.47916666666667
1120, 1.2, 0.066666666666667, 0.5
1121, 1.2, 0.033333333333333, 0.5
1122, 2.2, 0.066666666666667, 0.5
1123, 2.2, 0.033333333333333, 0.5
1124, 1.2416666666667, 1.2490009027033e-16, 0.5
1125, 1.2833333333333, 1.2490009027033e-16, 0.5
1126, 1.325, 1.2490009027033e-16, 0.5
1127, 1.3666666666667, 1.2490009027033e-16, 0.5
1128, 1.4083333333333, 1.2490009027033e-16, 0.5
1129, 1.45, 1.2490009027033e-16, 0.5
1130, 1.4916666666667, 1.2490009027033e-16, 0.5
1131, 1.5333333333333, 1.2490009027033e-16, 0.5
1132, 1.575, 1.2490009027033e-16, 0.5
1133, 1.6166666666667, 1.2490009027033e-16, 0.5
1134, 1.6583333333333, 1.2490009027033e-16, 0.5
1135, 1.7, 1.2490009027033e-16, 0.5
1136, 1.7416666666667, 1.2490009027033e-16, 0.5
1137, 1.7833333333333, 1.2490009027033e-16, 0.5
1138, 1.825, 1.2490009027033e-16, 0.5
1139, 1.8666666666667, 1.2490009027033e-16, 0.5
1140, 1.9083333333333, 1.2490009027033e-16, 0.5
1141, 1.95, 1.2490009027033e-16, 0.5
1142, 1.9916666666667, 1.2490009027033e-16, 0.5
1143, 2.0333333333333, 1.2490009027033e-16, 0.5
1144, 2.075, 1.2490009027033e-16, 0.5
1145, 2.1166666666667, 1.2490009027033e-16, 0.5
1146, 2.1583333333333, 1.2490009027033e-16, 0.5
1147, 1.2, 0.066666666666667, 0
1148, 1.2, 0.033333333333333, 0
1149, 1.2, 0.083333333333333, 0
1150, 1.2, 0.05, 0
1151, 1.2, 0.016666666666667, 0
1152, 2.2, 0.066666666666667, 0
1153, 2.2, 0.033333333333333, 0
1154, 2.2, 0.083333333333333, 0
1155, 2.2, 0.05, 0
1156, 2.2, 0.016666666666667, 0
1157, 1.2416666666667, 1.2490009027033e-16, 0
1158, 1.2833333333333, 1.2490009027033e-16, 0
1159, 1.325, 1.2490009027033e-16, 0
1160, 1.3666666666667, 1.2490009027033e-16, 0
1161, 1.4083333333333, 1.2490009027033e-16, 0
1162, 1.45, 1.2490009027033e-16, 0
1163, 1.4916666666667, 1.2490009027033e-16, 0
1164, 1.5333333333333, 1.2490009027033e-16, 0
1165, 1.575, 1.2490009027033e-16, 0
1166, 1.6166666666667, 1.2490009027033e-16, 0
1167, 1.6583333333333, 1.2490009027033e-16, 0
1168, 1.7, 1.2490009027033e-16, 0
1169, 1.7416666666667, 1.2490009027033e-16, 0
1170, 1.7833333333333, 1.2490009027033e-16, 0
1171, 1.825, 1.2490009027033e-16, 0
1172, 1.8666666666667, 1.2490009027033e-16, 0
1173, 1.9083333333333, 1.2490009027033e-16, 0
1174, 1.95, 1.2490009027033e-16, 0
1175, 1.9916666666667, 1.2490009027033e-16, 0
1176, 2.0333333333333, 1.2490009027033e-16, 0
1177, 2.075, 1.2490009027033e-16, 0
1178, 2.1166666666667, 1.2490009027033e-16, 0
1179, 2.1583333333333, 1.2490009027033e-16, 0
1180, 1.2, 1.2490009027033e-16, 0.041666666666667
1181, 1.2, 1.2490009027033e-16, 0.083333333333333
1182, 1.2, 1.2490009027033e-16, 0.125
1183, 1.2, 1.2490009027033e-16, 0.16666666666667
1184, 1.2, 1.2490009027033e-16, 0.20833333333333
1185, 1.2, 1.2490009027033e-16, 0.25
1186, 1.2, 1.2490009027033e-16, 0.29166666666667
1187, 1.2, 1.2490009027033e-16, 0.33333333333333
1188, 1.2, 1.2490009027033e-16, 0.375
1189, 1.2, 1.2490009027033e-16, 0.41666666666667
1190, 1.2, 1.2490009027033e-16, 0.45833333333333
1191, 2.2, 1.2490009027033e-16, 0.041666666666667
1192, 2.2, 1.2490009027033e-16, 0.083333333333333
1193, 2.2, 1.2490009027033e-16, 0.125
1194, 2.2, 1.2490009027033e-16, 0.16666666666667
1195, 2.2, 1.2490009027033e-16, 0.20833333333333
1196, 2.2, 1.2490009027033e-16, 0.25
1197, 2.2, 1.2490009027033e-16, 0.29166666666667
1198, 2.2, 1.2490009027033e-16, 0.33333333333333
1199, 2.2, 1.2490009027033e-16, 0.375
1200, 2.2, 1.2490009027033e-16, 0.41666666666667
1201, 2.2, 1.2490009027033e-16, 0.45833333333333
1202, 2.3, 0.066666666666667, 0.5
1203, 2.3, 0.033333333333333, 0.5
55606, 2.25, 0.1, 0
1204, 2.3, 0.066666666666667, 0
1205, 2.3, 0.033333333333333, 0
1206, 2.3, 0.1, 0.041666666666667
1207, 2.3, 0.1, 0.083333333333333
1208, 2.3, 0.1, 0.125
1209, 2.3, 0.1, 0.16666666666667
1210, 2.3, 0.1, 0.20833333333333
1211, 2.3, 0.1, 0.25
1212, 2.3, 0.1, 0.29166666666667
1213, 2.3, 0.1, 0.33333333333333
1214, 2.3, 0.1, 0.375
1215, 2.3, 0.1, 0.41666666666667
1216, 2.3, 0.1, 0.45833333333333
1217, 2.3, 1.2490009027033e-16, 0.041666666666667
1218, 2.3, 1.2490009027033e-16, 0.083333333333333
1219, 2.3, 1.2490009027033e-16, 0.125
1220, 2.3, 1.2490009027033e-16, 0.16666666666667
1221, 2.3, 1.2490009027033e-16, 0.20833333333333
1222, 2.3, 1.2490009027033e-16, 0.25
1223, 2.3, 1.2490009027033e-16, 0.29166666666667
1224, 2.3, 1.2490009027033e-16, 0.33333333333333
1225, 2.3, 1.2490009027033e-16, 0.375
1226, 2.3, 1.2490009027033e-16, 0.41666666666667
1227, 2.3, 1.2490009027033e-16, 0.45833333333333
1228, -0.1, 0, 0.041666666666667
1229, -0.1, 0, 0.083333333333333
1230, -0.1, 0, 0.125
1231, -0.1, 0, 0.16666666666667
1232, -0.1, 0, 0.20833333333333
1233, -0.1, 0, 0.25
1234, -0.1, 0, 0.29166666666667
1235, -0.1, 0, 0.33333333333333
1236, -0.1, 0, 0.375
1237, -0.1, 0, 0.41666666666667
1238, -0.1, 0, 0.45833333333333
1239, -0.1, 0.033333333333333, 0.5
1240, -0.1, 0.066666666666667, 0.5
55607, -0.05, 0.1, 0
1241, -0.1, 0.1, 0.041666666666667
1242, -0.1, 0.1, 0.083333333333333
1243, -0.1, 0.1, 0.125
1244, -0.1, 0.1, 0.16666666666667
1245, -0.1, 0.1, 0.20833333333333
1246, -0.1, 0.1, 0.25
1247, -0.1, 0.1, 0.29166666666667
1248, -0.1, 0.1, 0.33333333333333
1249, -0.1, 0.1, 0.375
1250, -0.1, 0.1, 0.41666666666667
1251, -0.1, 0.1, 0.45833333333333
1252, -0.1, 0.033333333333333, 0
1253, -0.1, 0.066666666666667, 0
1254, 1.05, 0.2, 0.5
1255, 1.05, 0.25, 0.5
1256, 1.05, 0.3, 0.5
1257, 1.05, 0.35, 0.5
1258, 1.05, 0.4, 0.5
1259, 1.05, 0.45, 0.5
1260, 1.05, 0.5, 0.5
1261, 1.05, 0.55, 0.5
1262, 1.05, 0.6, 0.5
1263, 1.05, 0.65, 0.5
1264, 1.05, 0.7, 0.5
1265, 1.05, 0.75, 0.5
1266, 1.05, 0.8, 0.5
1267, 1.05, 0.85, 0.5
1268, 1.05, 0.9, 0.5
1269, 1.05, 0.95, 0.5
1270, 1.05, 1, 0.5
1271, 1.05, 1.05, 0.5
1272, 1.05, 1.1, 0.5
1273, 1.05, 1.15, 0.5
1274, 1.05, 1.2, 0.5
1275, 1.05, 1.25, 0.5
1276, 1.05, 1.3, 0.5
1277, 1.025, 0.15, 0
1278, 1.025, 1.35, 0
1279, 1.05, 0.2, 0
1280, 1.05, 0.25, 0
1281, 1.05, 0.3, 0
1282, 1.05, 0.35, 0
1283, 1.05, 0.4, 0
1284, 1.05, 0.45, 0
1285, 1.05, 0.5, 0
1286, 1.05, 0.55, 0
1287, 1.05, 0.6, 0
1288, 1.05, 0.65, 0
1289, 1.05, 0.7, 0
1290, 1.05, 0.75, 0
1291, 1.05, 0.8, 0
1292, 1.05, 0.85, 0
1293, 1.05, 0.9, 0
1294, 1.05, 0.95, 0
1295, 1.05, 1, 0
1296, 1.05, 1.05, 0
1297, 1.05, 1.1, 0
1298, 1.05, 1.15, 0
1299, 1.05, 1.2, 0
1300, 1.05, 1.25, 0
1301, 1.05, 1.3, 0
1302, 1.05, 0.175, 0
1303, 1.05, 0.225, 0
1304, 1.05, 0.275, 0
1305, 1.05, 0.325, 0
1306, 1.05, 0.375, 0
1307, 1.05, 0.425, 0
1308, 1.05, 0.475, 0
1309, 1.05, 0.525, 0
1310, 1.05, 0.575, 0
1311, 1.05, 0.625, 0
1312, 1.05, 0.675, 0
1313, 1.05, 0.725, 0
1314, 1.05, 0.775, 0
1315, 1.05, 0.825, 0
1316, 1.05, 0.875, 0
1317, 1.05, 0.925, 0
1318, 1.05, 0.975, 0
1319, 1.05, 1.025, 0
1320, 1.05, 1.075, 0
1321, 1.05, 1.125, 0
1322, 1.05, 1.175, 0
1323, 1.05, 1.225, 0
1324, 1.05, 1.275, 0
1325, 1.05, 1.325, 0
1326, 1.05, 0.15, 0.041666666666667
1327, 1.05, 0.15, 0.083333333333333
1328, 1.05, 0.15, 0.125
1329, 1.05, 0.15, 0.16666666666667
1330, 1.05, 0.15, 0.20833333333333
1331, 1.05, 0.15, 0.25
1332, 1.05, 0.15, 0.29166666666667
1333, 1.05, 0.15, 0.33333333333333
1334, 1.05, 0.15, 0.375
1335, 1.05, 0.15, 0.41666666666667
1336, 1.05, 0.15, 0.45833333333333
1337, 1.05, 0.15, 0.020833333333333
1338, 1.05, 0.15, 0.0625
1339, 1.05, 0.15, 0.10416666666667
1340, 1.05, 0.15, 0.14583333333333
1341, 1.05, 0.15, 0.1875
1342, 1.05, 0.15, 0.22916666666667
1343, 1.05, 0.15, 0.27083333333333
1344, 1.05, 0.15, 0.3125
1345, 1.05, 0.15, 0.35416666666667
1346, 1.05, 0.15, 0.39583333333333
1347, 1.05, 0.15, 0.4375
1348, 1.05, 0.15, 0.47916666666667
1349, 1.05, 1.35, 0.041666666666667
1350, 1.05, 1.35, 0.083333333333333
1351, 1.05, 1.35, 0.125
1352, 1.05, 1.35, 0.16666666666667
1353, 1.05, 1.35, 0.20833333333333
1354, 1.05, 1.35, 0.25
1355, 1.05, 1.35, 0.29166666666667
1356, 1.05, 1.35, 0.33333333333333
1357, 1.05, 1.35, 0.375
1358, 1.05, 1.35, 0.41666666666667
1359, 1.05, 1.35, 0.45833333333333
1360, 1.05, 1.35, 0.020833333333333
1361, 1.05, 1.35, 0.0625
1362, 1.05, 1.35, 0.10416666666667
1363, 1.05, 1.35, 0.14583333333333
1364, 1.05, 1.35, 0.1875
1365, 1.05, 1.35, 0.22916666666667
1366, 1.05, 1.35, 0.27083333333333
1367, 1.05, 1.35, 0.3125
1368, 1.05, 1.35, 0.35416666666667
1369, 1.05, 1.35, 0.39583333333333
1370, 1.05, 1.35, 0.4375
1371, 1.05, 1.35, 0.47916666666667
1372, 1.15, 1.3, 0.5
1373, 1.15, 1.25, 0.5
1374, 1.15, 1.2, 0.5
1375, 1.15, 1.15, 0.5
1376, 1.15, 1.1, 0.5
1377, 1.15, 1.05, 0.5
1378, 1.15, 1, 0.5
1379, 1.15, 0.95, 0.5
1380, 1.15, 0.9, 0.5
1381, 1.15, 0.85, 0.5
1382, 1.15, 0.8, 0.5
1383, 1.15, 0.75, 0.5
1384, 1.15, 0.7, 0.5
1385, 1.15, 0.65, 0.5
1386, 1.15, 0.6, 0.5
1387, 1.15, 0.55, 0.5
1388, 1.15, 0.5, 0.5
1389, 1.15, 0.45, 0.5
1390, 1.15, 0.4, 0.5
1391, 1.15, 0.35, 0.5
1392, 1.15, 0.3, 0.5
1393, 1.15, 0.25, 0.5
1394, 1.15, 0.2, 0.5
1395, 1.175, 1.35, 0
1396, 1.175, 0.15, 0
1397, 1.15, 1.3, 0
1398, 1.15, 1.25, 0
1399, 1.15, 1.2, 0
1400, 1.15, 1.15, 0
1401, 1.15, 1.1, 0
1402, 1.15, 1.05, 0
1403, 1.15, 1, 0
1404, 1.15, 0.95, 0
1405, 1.15, 0.9, 0
1406, 1.15, 0.85, 0
1407, 1.15, 0.8, 0
1408, 1.15, 0.75, 0
1409, 1.15, 0.7, 0
1410, 1.15, 0.65, 0
1411, 1.15, 0.6, 0
1412, 1.15, 0.55, 0
1413, 1.15, 0.5, 0
1414, 1.15, 0.45, 0
1415, 1.15, 0.4, 0
1416, 1.15, 0.35, 0
1417, 1.15, 0.3, 0
1418, 1.15, 0.25, 0
1419, 1.15, 0.2, 0
1420, 1.15, 1.325, 0
1421, 1.15, 1.275, 0
1422, 1.15, 1.225, 0
1423, 1.15, 1.175, 0
1424, 1.15, 1.125, 0
1425, 1.15, 1.075, 0
1426, 1.15, 1.025, 0
1427, 1.15, 0.975, 0
1428, 1.15, 0.925, 0
1429, 1.15, 0.875, 0
1430, 1.15, 0.825, 0
1431, 1.15, 0.775, 0
1432, 1.15, 0.725, 0
1433, 1.15, 0.675, 0
1434, 1.15, 0.625, 0
1435, 1.15, 0.575, 0
1436, 1.15, 0.525, 0
1437, 1.15, 0.475, 0
1438, 1.15, 0.425, 0
1439, 1.15, 0.375, 0
1440, 1.15, 0.325, 0
1441, 1.15, 0.275, 0
1442, 1.15, 0.225, 0
1443, 1.15, 0.175, 0
1444, 1.15, 1.35, 0.041666666666667
1445, 1.15, 1.35, 0.083333333333333
1446, 1.15, 1.35, 0.125
1447, 1.15, 1.35, 0.16666666666667
1448, 1.15, 1.35, 0.20833333333333
1449, 1.15, 1.35, 0.25
1450, 1.15, 1.35, 0.29166666666667
1451, 1.15, 1.35, 0.33333333333333
1452, 1.15, 1.35, 0.375
1453, 1.15, 1.35, 0.41666666666667
1454, 1.15, 1.35, 0.45833333333333
1455, 1.15, 1.35, 0.020833333333333
1456, 1.15, 1.35, 0.0625
1457, 1.15, 1.35, 0.10416666666667
1458, 1.15, 1.35, 0.14583333333333
1459, 1.15, 1.35, 0.1875
1460, 1.15, 1.35, 0.22916666666667
1461, 1.15, 1.35, 0.27083333333333
1462, 1.15, 1.35, 0.3125
1463, 1.15, 1.35, 0.35416666666667
1464, 1.15, 1.35, 0.39583333333333
1465, 1.15, 1.35, 0.4375
1466, 1.15, 1.35, 0.47916666666667
1467, 1.15, 0.15, 0.041666666666667
1468, 1.15, 0.15, 0.083333333333333
1469, 1.15, 0.15, 0.125
1470, 1.15, 0.15, 0.16666666666667
1471, 1.15, 0.15, 0.20833333333333
1472, 1.15, 0.15, 0.25
1473, 1.15, 0.15, 0.29166666666667
1474, 1.15, 0.15, 0.33333333333333
1475, 1.15, 0.15, 0.375
1476, 1.15, 0.15, 0.41666666666667
1477, 1.15, 0.15, 0.45833333333333
1478, 1.15, 0.15, 0.020833333333333
1479, 1.15, 0.15, 0.0625
1480, 1.15, 0.15, 0.10416666666667
1481, 1.15, 0.15, 0.14583333333333
1482, 1.15, 0.15, 0.1875
1483, 1.15, 0.15, 0.22916666666667
1484, 1.15, 0.15, 0.27083333333333
1485, 1.15, 0.15, 0.3125
1486, 1.15, 0.15, 0.35416666666667
1487, 1.15, 0.15, 0.39583333333333
1488, 1.15, 0.15, 0.4375
1489, 1.15, 0.15, 0.47916666666667
1490, 1, 0.15, -0.05
1491, 1, 1.35, -0.05
1492, 1, 0.2, -0.1
1493, 1, 0.25, -0.1
1494, 1, 0.3, -0.1
1495, 1, 0.35, -0.1
1496, 1, 0.4, -0.1
1497, 1, 0.45, -0.1
1498, 1, 0.5, -0.1
1499, 1, 0.55, -0.1
1500, 1, 0.6, -0.1
1501, 1, 0.65, -0.1
1502, 1, 0.7, -0.1
1503, 1, 0.75, -0.1
1504, 1, 0.8, -0.1
1505, 1, 0.85, -0.1
1506, 1, 0.9, -0.1
1507, 1, 0.95, -0.1
1508, 1, 1, -0.1
1509, 1, 1.05, -0.1
1510, 1, 1.1, -0.1
1511, 1, 1.15, -0.1
1512, 1, 1.2, -0.1
1513, 1, 1.25, -0.1
1514, 1, 1.3, -0.1
1515, 1, 0.175, -0.1
1516, 1, 0.225, -0.1
1517, 1, 0.275, -0.1
1518, 1, 0.325, -0.1
1519, 1, 0.375, -0.1
1520, 1, 0.425, -0.1
1521, 1, 0.475, -0.1
1522, 1, 0.525, -0.1
1523, 1, 0.575, -0.1
1524, 1, 0.625, -0.1
1525, 1, 0.675, -0.1
1526, 1, 0.725, -0.1
1527, 1, 0.775, -0.1
1528, 1, 0.825, -0.1
1529, 1, 0.875, -0.1
1530, 1, 0.925, -0.1
1531, 1, 0.975, -0.1
1532, 1, 1.025, -0.1
1533, 1, 1.075, -0.1
1534, 1, 1.125, -0.1
1535, 1, 1.175, -0.1
1536, 1, 1.225, -0.1
1537, 1, 1.275, -0.1
1538, 1, 1.325, -0.1
1539, 0, 0.15, -0.05
1540, 0, 1.35, -0.05
1541, 0, 0.2, -0.1
1542, 0, 0.25, -0.1
1543, 0, 0.3, -0.1
1544, 0, 0.35, -0.1
1545, 0, 0.4, -0.1
1546, 0, 0.45, -0.1
1547, 0, 0.5, -0.1
1548, 0, 0.55, -0.1
1549, 0, 0.6, -0.1
1550, 0, 0.65, -0.1
1551, 0, 0.7, -0.1
1552, 0, 0.75, -0.1
1553, 0, 0.8, -0.1
1554, 0, 0.85, -0.1
1555, 0, 0.9, -0.1
1556, 0, 0.95, -0.1
1557, 0, 1, -0.1
1558, 0, 1.05, -0.1
1559, 0, 1.1, -0.1
1560, 0, 1.15, -0.1
1561, 0, 1.2, -0.1
1562, 0, 1.25, -0.1
1563, 0, 1.3, -0.1
1564, 0, 0.175, -0.1
1565, 0, 0.225, -0.1
1566, 0, 0.275, -0.1
1567, 0, 0.325, -0.1
1568, 0, 0.375, -0.1
1569, 0, 0.425, -0.1
1570, 0, 0.475, -0.1
1571, 0, 0.525, -0.1
1572, 0, 0.575, -0.1
1573, 0, 0.625, -0.1
1574, 0, 0.675, -0.1
1575, 0, 0.725, -0.1
1576, 0, 0.775, -0.1
1577, 0, 0.825, -0.1
1578, 0, 0.875, -0.1
1579, 0, 0.925, -0.1
1580, 0, 0.975, -0.1
1581, 0, 1.025, -0.1
1582, 0, 1.075, -0.1
1583, 0, 1.125, -0.1
1584, 0, 1.175, -0.1
1585, 0, 1.225, -0.1
1586, 0, 1.275, -0.1
1587, 0, 1.325, -0.1
1588, 0.041666666666667, 0.15, -0.1
1589, 0.083333333333333, 0.15, -0.1
1590, 0.125, 0.15, -0.1
1591, 0.16666666666667, 0.15, -0.1
1592, 0.20833333333333, 0.15, -0.1
1593, 0.25, 0.15, -0.1
1594, 0.29166666666667, 0.15, -0.1
1595, 0.33333333333333, 0.15, -0.1
1596, 0.375, 0.15, -0.1
1597, 0.41666666666667, 0.15, -0.1
1598, 0.45833333333333, 0.15, -0.1
1599, 0.5, 0.15, -0.1
1600, 0.54166666666667, 0.15, -0.1
1601, 0.58333333333333, 0.15, -0.1
1602, 0.625, 0.15, -0.1
1603, 0.66666666666667, 0.15, -0.1
1604, 0.70833333333333, 0.15, -0.1
1605, 0.75, 0.15, -0.1
1606, 0.79166666666667, 0.15, -0.1
1607, 0.83333333333333, 0.15, -0.1
1608, 0.875, 0.15, -0.1
1609, 0.91666666666667, 0.15, -0.1
1610, 0.95833333333333, 0.15, -0.1
1611, 0.020833333333333, 0.15, -0.1
1612, 0.0625, 0.15, -0.1
1613, 0.10416666666667, 0.15, -0.1
1614, 0.14583333333333, 0.15, -0.1
1615, 0.1875, 0.15, -0.1
1616, 0.22916666666667, 0.15, -0.1
1617, 0.27083333333333, 0.15, -0.1
1618, 0.3125, 0.15, -0.1
1619, 0.35416666666667, 0.15, -0.1
1620, 0.39583333333333, 0.15, -0.1
1621, 0.4375, 0.15, -0.1
1622, 0.47916666666667, 0.15, -0.1
1623, 0.52083333333333, 0.15, -0.1
1624, 0.5625, 0.15, -0.1
1625, 0.60416666666667, 0.15, -0.1
1626, 0.64583333333333, 0.15, -0.1
1627, 0.6875, 0.15, -0.1
1628, 0.72916666666667, 0.15, -0.1
1629, 0.77083333333333, 0.15, -0.1
1630, 0.8125, 0.15, -0.1
1631, 0.85416666666667, 0.15, -0.1
1632, 0.89583333333333, 0.15, -0.1
1633, 0.9375, 0.15, -0.1
1634, 0.97916666666667, 0.15, -0.1
1635, 0.041666666666667, 1.35, -0.1
1636, 0.083333333333333, 1.35, -0.1
1637, 0.125, 1.35, -0.1
1638, 0.16666666666667, 1.35, -0.1
1639, 0.20833333333333, 1.35, -0.1
1640, 0.25, 1.35, -0.1
1641, 0.29166666666667, 1.35, -0.1
1642, 0.33333333333333, 1.35, -0.1
1643, 0.375, 1.35, -0.1
1644, 0.41666666666667, 1.35, -0.1
1645, 0.45833333333333, 1.35, -0.1
1646, 0.5, 1.35, -0.1
1647, 0.54166666666667, 1.35, -0.1
1648, 0.58333333333333, 1.35, -0.1
1649, 0.625, 1.35, -0.1
1650, 0.66666666666667, 1.35, -0.1
1651, 0.70833333333333, 1.35, -0.1
1652, 0.75, 1.35, -0.1
1653, 0.79166666666667, 1.35, -0.1
1654, 0.83333333333333, 1.35, -0.1
1655, 0.875, 1.35, -0.1
1656, 0.91666666666667, 1.35, -0.1
1657, 0.95833333333333, 1.35, -0.1
1658, 0.020833333333333, 1.35, -0.1
1659, 0.0625, 1.35, -0.1
1660, 0.10416666666667, 1.35, -0.1
1661, 0.14583333333333, 1.35, -0.1
1662, 0.1875, 1.35, -0.1
1663, 0.22916666666667, 1.35, -0.1
1664, 0.27083333333333, 1.35, -0.1
1665, 0.3125, 1.35, -0.1
1666, 0.35416666666667, 1.35, -0.1
1667, 0.39583333333333, 1.35, -0.1
1668, 0.4375, 1.35, -0.1
1669, 0.47916666666667, 1.35, -0.1
1670, 0.52083333333333, 1.35, -0.1
1671, 0.5625, 1.35, -0.1
1672, 0.60416666666667, 1.35, -0.1
1673, 0.64583333333333, 1.35, -0.1
1674, 0.6875, 1.35, -0.1
1675, 0.72916666666667, 1.35, -0.1
1676, 0.77083333333333, 1.35, -0.1
1677, 0.8125, 1.35, -0.1
1678, 0.85416666666667, 1.35, -0.1
1679, 0.89583333333333, 1.35, -0.1
1680, 0.9375, 1.35, -0.1
1681, 0.97916666666667, 1.35, -0.1
1682, 1.2, 1.35, -0.05
1683, 1.2, 0.15, -0.05
1684, 1.2, 1.3, -0.1
1685, 1.2, 1.25, -0.1
1686, 1.2, 1.2, -0.1
1687, 1.2, 1.15, -0.1
1688, 1.2, 1.1, -0.1
1689, 1.2, 1.05, -0.1
1690, 1.2, 1, -0.1
1691, 1.2, 0.95, -0.1
1692, 1.2, 0.9, -0.1
1693, 1.2, 0.85, -0.1
1694, 1.2, 0.8, -0.1
1695, 1.2, 0.75, -0.1
1696, 1.2, 0.7, -0.1
1697, 1.2, 0.65, -0.1
1698, 1.2, 0.6, -0.1
1699, 1.2, 0.55, -0.1
1700, 1.2, 0.5, -0.1
1701, 1.2, 0.45, -0.1
1702, 1.2, 0.4, -0.1
1703, 1.2, 0.35, -0.1
1704, 1.2, 0.3, -0.1
1705, 1.2, 0.25, -0.1
1706, 1.2, 0.2, -0.1
1707, 1.2, 1.325, -0.1
1708, 1.2, 1.275, -0.1
1709, 1.2, 1.225, -0.1
1710, 1.2, 1.175, -0.1
1711, 1.2, 1.125, -0.1
1712, 1.2, 1.075, -0.1
1713, 1.2, 1.025, -0.1
1714, 1.2, 0.975, -0.1
1715, 1.2, 0.925, -0.1
1716, 1.2, 0.875, -0.1
1717, 1.2, 0.825, -0.1
1718, 1.2, 0.775, -0.1
1719, 1.2, 0.725, -0.1
1720, 1.2, 0.675, -0.1
1721, 1.2, 0.625, -0.1
1722, 1.2, 0.575, -0.1
1723, 1.2, 0.525, -0.1
1724, 1.2, 0.475, -0.1
1725, 1.2, 0.425, -0.1
1726, 1.2, 0.375, -0.1
1727, 1.2, 0.325, -0.1
1728, 1.2, 0.275, -0.1
1729, 1.2, 0.225, -0.1
1730, 1.2, 0.175, -0.1
1731, 2.2, 1.35, -0.05
1732, 2.2, 0.15, -0.05
1733, 2.2, 1.3, -0.1
1734, 2.2, 1.25, -0.1
1735, 2.2, 1.2, -0.1
1736, 2.2, 1.15, -0.1
1737, 2.2, 1.1, -0.1
1738, 2.2, 1.05, -0.1
1739, 2.2, 1, -0.1
1740, 2.2, 0.95, -0.1
1741, 2.2, 0.9, -0.1
1742, 2.2, 0.85, -0.1
1743, 2.2, 0.8, -0.1
1744, 2.2, 0.75, -0.1
1745, 2.2, 0.7, -0.1
1746, 2.2, 0.65, -0.1
1747, 2.2, 0.6, -0.1
1748, 2.2, 0.55, -0.1
1749, 2.2, 0.5, -0.1
1750, 2.2, 0.45, -0.1
1751, 2.2, 0.4, -0.1
1752, 2.2, 0.35, -0.1
1753, 2.2, 0.3, -0.1
1754, 2.2, 0.25, -0.1
1755, 2.2, 0.2, -0.1
1756, 2.2, 1.325, -0.1
1757, 2.2, 1.275, -0.1
1758, 2.2, 1.225, -0.1
1759, 2.2, 1.175, -0.1
1760, 2.2, 1.125, -0.1
1761, 2.2, 1.075, -0.1
1762, 2.2, 1.025, -0.1
1763, 2.2, 0.975, -0.1
1764, 2.2, 0.925, -0.1
1765, 2.2, 0.875, -0.1
1766, 2.2, 0.825, -0.1
1767, 2.2, 0.775, -0.1
1768, 2.2, 0.725, -0.1
1769, 2.2, 0.675, -0.1
1770, 2.2, 0.625, -0.1
1771, 2.2, 0.575, -0.1
1772, 2.2, 0.525, -0.1
1773, 2.2, 0.475, -0.1
1774, 2.2, 0.425, -0.1
1775, 2.2, 0.375, -0.1
1776, 2.2, 0.325, -0.1
1777, 2.2, 0.275, -0.1
1778, 2.2, 0.225, -0.1
1779, 2.2, 0.175, -0.1
1780, 1.2416666666667, 1.35, -0.1
1781, 1.2833333333333, 1.35, -0.1
1782, 1.325, 1.35, -0.1
1783, 1.3666666666667, 1.35, -0.1
1784, 1.4083333333333, 1.35, -0.1
1785, 1.45, 1.35, -0.1
1786, 1.4916666666667, 1.35, -0.1
1787, 1.5333333333333, 1.35, -0.1
1788, 1.575, 1.35, -0.1
1789, 1.6166666666667, 1.35, -0.1
1790, 1.6583333333333, 1.35, -0.1
1791, 1.7, 1.35, -0.1
1792, 1.7416666666667, 1.35, -0.1
1793, 1.7833333333333, 1.35, -0.1
1794, 1.825, 1.35, -0.1
1795, 1.8666666666667, 1.35, -0.1
1796, 1.9083333333333, 1.35, -0.1
1797, 1.95, 1.35, -0.1
1798, 1.9916666666667, 1.35, -0.1
1799, 2.0333333333333, 1.35, -0.1
1800, 2.075, 1.35, -0.1
1801, 2.1166666666667, 1.35, -0.1
1802, 2.1583333333333, 1.35, -0.1
1803, 1.2208333333333, 1.35, -0.1
1804, 1.2625, 1.35, -0.1
1805, 1.3041666666667, 1.35, -0.1
1806, 1.3458333333333, 1.35, -0.1
1807, 1.3875, 1.35, -0.1
1808, 1.4291666666667, 1.35, -0.1
1809, 1.4708333333333, 1.35, -0.1
1810, 1.5125, 1.35, -0.1
1811, 1.5541666666667, 1.35, -0.1
1812, 1.5958333333333, 1.35, -0.1
1813, 1.6375, 1.35, -0.1
1814, 1.6791666666667, 1.35, -0.1
1815, 1.7208333333333, 1.35, -0.1
1816, 1.7625, 1.35, -0.1
1817, 1.8041666666667, 1.35, -0.1
1818, 1.8458333333333, 1.35, -0.1
1819, 1.8875, 1.35, -0.1
1820, 1.9291666666667, 1.35, -0.1
1821, 1.9708333333333, 1.35, -0.1
1822, 2.0125, 1.35, -0.1
1823, 2.0541666666667, 1.35, -0.1
1824, 2.0958333333333, 1.35, -0.1
1825, 2.1375, 1.35, -0.1
1826, 2.1791666666667, 1.35, -0.1
1827, 1.2416666666667, 0.15, -0.1
1828, 1.2833333333333, 0.15, -0.1
1829, 1.325, 0.15, -0.1
1830, 1.3666666666667, 0.15, -0.1
1831, 1.4083333333333, 0.15, -0.1
1832, 1.45, 0.15, -0.1
1833, 1.4916666666667, 0.15, -0.1
1834, 1.5333333333333, 0.15, -0.1
1835, 1.575, 0.15, -0.1
1836, 1.6166666666667, 0.15, -0.1
1837, 1.6583333333333, 0.15, -0.1
1838, 1.7, 0.15, -0.1
1839, 1.7416666666667, 0.15, -0.1
1840, 1.7833333333333, 0.15, -0.1
1841, 1.825, 0.15, -0.1
1842, 1.8666666666667, 0.15, -0.1
1843, 1.9083333333333, 0.15, -0.1
1844, 1.95, 0.15, -0.1
1845, 1.9916666666667, 0.15, -0.1
1846, 2.0333333333333, 0.15, -0.1
1847, 2.075, 0.15, -0.1
1848, 2.1166666666667, 0.15, -0.1
1849, 2.1583333333333, 0.15, -0.1
1850, 1.2208333333333, 0.15, -0.1
1851, 1.2625, 0.15, -0.1
1852, 1.3041666666667, 0.15, -0.1
1853, 1.3458333333333, 0.15, -0.1
1854, 1.3875, 0.15, -0.1
1855, 1.4291666666667, 0.15, -0.1
1856, 1.4708333333333, 0.15, -0.1
1857, 1.5125, 0.15, -0.1
1858, 1.5541666666667, 0.15, -0.1
1859, 1.5958333333333, 0.15, -0.1
1860, 1.6375, 0.15, -0.1
1861, 1.6791666666667, 0.15, -0.1
1862, 1.7208333333333, 0.15, -0.1
1863, 1.7625, 0.15, -0.1
1864, 1.8041666666667, 0.15, -0.1
1865, 1.8458333333333, 0.15, -0.1
1866, 1.8875, 0.15, -0.1
1867, 1.9291666666667, 0.15, -0.1
1868, 1.9708333333333, 0.15, -0.1
1869, 2.0125, 0.15, -0.1
1870, 2.0541666666667, 0.15, -0.1
1871, 2.0958333333333, 0.15, -0.1
1872, 2.1375, 0.15, -0.1
1873, 2.1791666666667, 0.15, -0.1
1874, 1.15, 1.35, -0.05
1875, 1.175, 1.35, -0.1
1876, 1.15, 0.15, -0.05
1877, 1.175, 0.15, -0.1
1878, 1.15, 1.3, -0.1
1879, 1.15, 1.25, -0.1
1880, 1.15, 1.2, -0.1
1881, 1.15, 1.15, -0.1
1882, 1.15, 1.1, -0.1
1883, 1.15, 1.05, -0.1
1884, 1.15, 1, -0.1
1885, 1.15, 0.95, -0.1
1886, 1.15, 0.9, -0.1
1887, 1.15, 0.85, -0.1
1888, 1.15, 0.8, -0.1
1889, 1.15, 0.75, -0.1
1890, 1.15, 0.7, -0.1
1891, 1.15, 0.65, -0.1
1892, 1.15, 0.6, -0.1
1893, 1.15, 0.55, -0.1
1894, 1.15, 0.5, -0.1
1895, 1.15, 0.45, -0.1
1896, 1.15, 0.4, -0.1
1897, 1.15, 0.35, -0.1
1898, 1.15, 0.3, -0.1
1899, 1.15, 0.25, -0.1
1900, 1.15, 0.2, -0.1
1901, 1.15, 1.325, -0.1
1902, 1.15, 1.275, -0.1
1903, 1.15, 1.225, -0.1
1904, 1.15, 1.175, -0.1
1905, 1.15, 1.125, -0.1
1906, 1.15, 1.075, -0.1
1907, 1.15, 1.025, -0.1
1908, 1.15, 0.975, -0.1
1909, 1.15, 0.925, -0.1
1910, 1.15, 0.875, -0.1
1911, 1.15, 0.825, -0.1
1912, 1.15, 0.775, -0.1
1913, 1.15, 0.725, -0.1
1914, 1.15, 0.675, -0.1
1915, 1.15, 0.625, -0.1
1916, 1.15, 0.575, -0.1
1917, 1.15, 0.525, -0.1
1918, 1.15, 0.475, -0.1
1919, 1.15, 0.425, -0.1
1920, 1.15, 0.375, -0.1
1921, 1.15, 0.325, -0.1
1922, 1.15, 0.275, -0.1
1923, 1.15, 0.225, -0.1
1924, 1.15, 0.175, -0.1
1925, 1.05, 0.15, -0.05
1926, 1.025, 0.15, -0.1
1927, 1.05, 1.35, -0.05
1928, 1.025, 1.35, -0.1
1929, 1.05, 0.2, -0.1
1930, 1.05, 0.25, -0.1
1931, 1.05, 0.3, -0.1
1932, 1.05, 0.35, -0.1
1933, 1.05, 0.4, -0.1
1934, 1.05, 0.45, -0.1
1935, 1.05, 0.5, -0.1
1936, 1.05, 0.55, -0.1
1937, 1.05, 0.6, -0.1
1938, 1.05, 0.65, -0.1
1939, 1.05, 0.7, -0.1
1940, 1.05, 0.75, -0.1
1941, 1.05, 0.8, -0.1
1942, 1.05, 0.85, -0.1
1943, 1.05, 0.9, -0.1
1944, 1.05, 0.95, -0.1
1945, 1.05, 1, -0.1
1946, 1.05, 1.05, -0.1
1947, 1.05, 1.1, -0.1
1948, 1.05, 1.15, -0.1
1949, 1.05, 1.2, -0.1
1950, 1.05, 1.25, -0.1
1951, 1.05, 1.3, -0.1
1952, 1.05, 0.175, -0.1
1953, 1.05, 0.225, -0.1
1954, 1.05, 0.275, -0.1
1955, 1.05, 0.325, -0.1
1956, 1.05, 0.375, -0.1
1957, 1.05, 0.425, -0.1
1958, 1.05, 0.475, -0.1
1959, 1.05, 0.525, -0.1
1960, 1.05, 0.575, -0.1
1961, 1.05, 0.625, -0.1
1962, 1.05, 0.675, -0.1
1963, 1.05, 0.725, -0.1
1964, 1.05, 0.775, -0.1
1965, 1.05, 0.825, -0.1
1966, 1.05, 0.875, -0.1
1967, 1.05, 0.925, -0.1
1968, 1.05, 0.975, -0.1
1969, 1.05, 1.025, -0.1
1970, 1.05, 1.075, -0.1
1971, 1.05, 1.125, -0.1
1972, 1.05, 1.175, -0.1
1973, 1.05, 1.225, -0.1
1974, 1.05, 1.275, -0.1
1975, 1.05, 1.325, -0.1
1976, 1, 1.54, 0
1977, 1, 1.58, 0
1978, 1, 1.62, 0
1979, 1, 1.66, 0
1980, 1, 1.52, 0
1981, 1, 1.56, 0
1982, 1, 1.6, 0
1983, 1, 1.64, 0
1984, 1, 1.68, 0
1985, 0, 1.54, 0
1986, 0, 1.58, 0
1987, 0, 1.62, 0
1988, 0, 1.66, 0
1989, 0, 1.52, 0
1990, 0, 1.56, 0
1991, 0, 1.6, 0
1992, 0, 1.64, 0
1993, 0, 1.68, 0
1994, 0.041666666666667, 1.7, 0
1995, 0.083333333333333, 1.7, 0
1996, 0.125, 1.7, 0
1997, 0.16666666666667, 1.7, 0
1998, 0.20833333333333, 1.7, 0
1999, 0.25, 1.7, 0
2000, 0.29166666666667, 1.7, 0
2001, 0.33333333333333, 1.7, 0
2002, 0.375, 1.7, 0
2003, 0.41666666666667, 1.7, 0
2004, 0.45833333333333, 1.7, 0
2005, 0.5, 1.7, 0
2006, 0.54166666666667, 1.7, 0
2007, 0.58333333333333, 1.7, 0
2008, 0.625, 1.7, 0
2009, 0.66666666666667, 1.7, 0
2010, 0.70833333333333, 1.7, 0
2011, 0.75, 1.7, 0
2012, 0.79166666666667, 1.7, 0
2013, 0.83333333333333, 1.7, 0
2014, 0.875, 1.7, 0
2015, 0.91666666666667, 1.7, 0
2016, 0.95833333333333, 1.7, 0
2017, 1, 1.54, 0.5
2018, 1, 1.58, 0.5
2019, 1, 1.62, 0.5
2020, 1, 1.66, 0.5
2021, 1, 1.7, 0.041666666666667
2022, 1, 1.7, 0.083333333333333
2023, 1, 1.7, 0.125
2024, 1, 1.7, 0.16666666666667
2025, 1, 1.7, 0.20833333333333
2026, 1, 1.7, 0.25
2027, 1, 1.7, 0.29166666666667
2028, 1, 1.7, 0.33333333333333
2029, 1, 1.7, 0.375
2030, 1, 1.7, 0.41666666666667
2031, 1, 1.7, 0.45833333333333
2032, 0, 1.54, 0.5
2033, 0, 1.58, 0.5
2034, 0, 1.62, 0.5
2035, 0, 1.66, 0.5
2036, 0.041666666666667, 1.7, 0.5
2037, 0.083333333333333, 1.7, 0.5
2038, 0.125, 1.7, 0.5
2039, 0.16666666666667, 1.7, 0.5
2040, 0.20833333333333, 1.7, 0.5
2041, 0.25, 1.7, 0.5
2042, 0.29166666666667, 1.7, 0.5
2043, 0.33333333333333, 1.7, 0.5
2044, 0.375, 1.7, 0.5
2045, 0.41666666666667, 1.7, 0.5
2046, 0.45833333333333, 1.7, 0.5
2047, 0.5, 1.7, 0.5
2048, 0.54166666666667, 1.7, 0.5
2049, 0.58333333333333, 1.7, 0.5
2050, 0.625, 1.7, 0.5
2051, 0.66666666666667, 1.7, 0.5
2052, 0.70833333333333, 1.7, 0.5
2053, 0.75, 1.7, 0.5
2054, 0.79166666666667, 1.7, 0.5
2055, 0.83333333333333, 1.7, 0.5
2056, 0.875, 1.7, 0.5
2057, 0.91666666666667, 1.7, 0.5
2058, 0.95833333333333, 1.7, 0.5
2059, 0, 1.7, 0.041666666666667
2060, 0, 1.7, 0.083333333333333
2061, 0, 1.7, 0.125
2062, 0, 1.7, 0.16666666666667
2063, 0, 1.7, 0.20833333333333
2064, 0, 1.7, 0.25
2065, 0, 1.7, 0.29166666666667
2066, 0, 1.7, 0.33333333333333
2067, 0, 1.7, 0.375
2068, 0, 1.7, 0.41666666666667
2069, 0, 1.7, 0.45833333333333
2070, 1.2, 1.54, 0.5
2071, 1.2, 1.58, 0.5
2072, 1.2, 1.62, 0.5
2073, 1.2, 1.66, 0.5
2074, 1.04, 1.7, 0.5
2075, 1.08, 1.7, 0.5
2076, 1.12, 1.7, 0.5
2077, 1.16, 1.7, 0.5
2078, 1.2, 1.54, 0
2079, 1.2, 1.58, 0
2080, 1.2, 1.62, 0
2081, 1.2, 1.66, 0
2082, 1.2, 1.52, 0
2083, 1.2, 1.56, 0
2084, 1.2, 1.6, 0
2085, 1.2, 1.64, 0
2086, 1.2, 1.68, 0
2087, 1.04, 1.7, 0
2088, 1.08, 1.7, 0
2089, 1.12, 1.7, 0
2090, 1.16, 1.7, 0
2091, 1.2, 1.7, 0.041666666666667
2092, 1.2, 1.7, 0.083333333333333
2093, 1.2, 1.7, 0.125
2094, 1.2, 1.7, 0.16666666666667
2095, 1.2, 1.7, 0.20833333333333
2096, 1.2, 1.7, 0.25
2097, 1.2, 1.7, 0.29166666666667
2098, 1.2, 1.7, 0.33333333333333
2099, 1.2, 1.7, 0.375
2100, 1.2, 1.7, 0.41666666666667
2101, 1.2, 1.7, 0.45833333333333
2102, 2.2, 1.54, 0.5
2103, 2.2, 1.58, 0.5
2104, 2.2, 1.62, 0.5
2105, 2.2, 1.66, 0.5
2106, 1.2416666666667, 1.7, 0.5
2107, 1.2833333333333, 1.7, 0.5
2108, 1.325, 1.7, 0.5
2109, 1.3666666666667, 1.7, 0.5
2110, 1.4083333333333, 1.7, 0.5
2111, 1.45, 1.7, 0.5
2112, 1.4916666666667, 1.7, 0.5
2113, 1.5333333333333, 1.7, 0.5
2114, 1.575, 1.7, 0.5
2115, 1.6166666666667, 1.7, 0.5
2116, 1.6583333333333, 1.7, 0.5
2117, 1.7, 1.7, 0.5
2118, 1.7416666666667, 1.7, 0.5
2119, 1.7833333333333, 1.7, 0.5
2120, 1.825, 1.7, 0.5
2121, 1.8666666666667, 1.7, 0.5
2122, 1.9083333333333, 1.7, 0.5
2123, 1.95, 1.7, 0.5
2124, 1.9916666666667, 1.7, 0.5
2125, 2.0333333333333, 1.7, 0.5
2126, 2.075, 1.7, 0.5
2127, 2.1166666666667, 1.7, 0.5
2128, 2.1583333333333, 1.7, 0.5
2129, 2.2, 1.54, 0
2130, 2.2, 1.58, 0
2131, 2.2, 1.62, 0
2132, 2.2, 1.66, 0
2133, 2.2, 1.52, 0
2134, 2.2, 1.56, 0
2135, 2.2, 1.6, 0
2136, 2.2, 1.64, 0
2137, 2.2, 1.68, 0
2138, 1.2416666666667, 1.7, 0
2139, 1.2833333333333, 1.7, 0
2140, 1.325, 1.7, 0
2141, 1.3666666666667, 1.7, 0
2142, 1.4083333333333, 1.7, 0
2143, 1.45, 1.7, 0
2144, 1.4916666666667, 1.7, 0
2145, 1.5333333333333, 1.7, 0
2146, 1.575, 1.7, 0
2147, 1.6166666666667, 1.7, 0
2148, 1.6583333333333, 1.7, 0
2149, 1.7, 1.7, 0
2150, 1.7416666666667, 1.7, 0
2151, 1.7833333333333, 1.7, 0
2152, 1.825, 1.7, 0
2153, 1.8666666666667, 1.7, 0
2154, 1.9083333333333, 1.7, 0
2155, 1.95, 1.7, 0
2156, 1.9916666666667, 1.7, 0
2157, 2.0333333333333, 1.7, 0
2158, 2.075, 1.7, 0
2159, 2.1166666666667, 1.7, 0
2160, 2.1583333333333, 1.7, 0
2161, 2.2, 1.7, 0.041666666666667
2162, 2.2, 1.7, 0.083333333333333
2163, 2.2, 1.7, 0.125
2164, 2.2, 1.7, 0.16666666666667
2165, 2.2, 1.7, 0.20833333333333
2166, 2.2, 1.7, 0.25
2167, 2.2, 1.7, 0.29166666666667
2168, 2.2, 1.7, 0.33333333333333
2169, 2.2, 1.7, 0.375
2170, 2.2, 1.7, 0.41666666666667
2171, 2.2, 1.7, 0.45833333333333
2172, 1, -0.04, 0
2173, 1, -0.08, 0
2174, 1, -0.12, 0
2175, 1, -0.16, 0
2176, 1, -0.02, 0
2177, 1, -0.06, 0
2178, 1, -0.1, 0
2179, 1, -0.14, 0
2180, 1, -0.18, 0
2181, 0, -0.04, 0
2182, 0, -0.08, 0
2183, 0, -0.12, 0
2184, 0, -0.16, 0
2185, 0, -0.02, 0
2186, 0, -0.06, 0
2187, 0, -0.1, 0
2188, 0, -0.14, 0
2189, 0, -0.18, 0
2190, 0.041666666666667, -0.2, 0
2191, 0.083333333333333, -0.2, 0
2192, 0.125, -0.2, 0
2193, 0.16666666666667, -0.2, 0
2194, 0.20833333333333, -0.2, 0
2195, 0.25, -0.2, 0
2196, 0.29166666666667, -0.2, 0
2197, 0.33333333333333, -0.2, 0
2198, 0.375, -0.2, 0
2199, 0.41666666666667, -0.2, 0
2200, 0.45833333333333, -0.2, 0
2201, 0.5, -0.2, 0
2202, 0.54166666666667, -0.2, 0
2203, 0.58333333333333, -0.2, 0
2204, 0.625, -0.2, 0
2205, 0.66666666666667, -0.2, 0
2206, 0.70833333333333, -0.2, 0
2207, 0.75, -0.2, 0
2208, 0.79166666666667, -0.2, 0
2209, 0.83333333333333, -0.2, 0
2210, 0.875, -0.2, 0
2211, 0.91666666666667, -0.2, 0
2212, 0.95833333333333, -0.2, 0
2213, 1, -0.04, 0.5
2214, 1, -0.08, 0.5
2215, 1, -0.12, 0.5
2216, 1, -0.16, 0.5
2217, 1, -0.2, 0.041666666666667
2218, 1, -0.2, 0.083333333333333
2219, 1, -0.2, 0.125
2220, 1, -0.2, 0.16666666666667
2221, 1, -0.2, 0.20833333333333
2222, 1, -0.2, 0.25
2223, 1, -0.2, 0.29166666666667
2224, 1, -0.2, 0.33333333333333
2225, 1, -0.2, 0.375
2226, 1, -0.2, 0.41666666666667
2227, 1, -0.2, 0.45833333333333
2228, 0, -0.04, 0.5
2229, 0, -0.08, 0.5
2230, 0, -0.12, 0.5
2231, 0, -0.16, 0.5
2232, 0.041666666666667, -0.2, 0.5
2233, 0.083333333333333, -0.2, 0.5
2234, 0.125, -0.2, 0.5
2235, 0.16666666666667, -0.2, 0.5
2236, 0.20833333333333, -0.2, 0.5
2237, 0.25, -0.2, 0.5
2238, 0.29166666666667, -0.2, 0.5
2239, 0.33333333333333, -0.2, 0.5
2240, 0.375, -0.2, 0.5
2241, 0.41666666666667, -0.2, 0.5
2242, 0.45833333333333, -0.2, 0.5
2243, 0.5, -0.2, 0.5
2244, 0.54166666666667, -0.2, 0.5
2245, 0.58333333333333, -0.2, 0.5
2246, 0.625, -0.2, 0.5
2247, 0.66666666666667, -0.2, 0.5
2248, 0.70833333333333, -0.2, 0.5
2249, 0.75, -0.2, 0.5
2250, 0.79166666666667, -0.2, 0.5
2251, 0.83333333333333, -0.2, 0.5
2252, 0.875, -0.2, 0.5
2253, 0.91666666666667, -0.2, 0.5
2254, 0.95833333333333, -0.2, 0.5
2255, 0, -0.2, 0.041666666666667
2256, 0, -0.2, 0.083333333333333
2257, 0, -0.2, 0.125
2258, 0, -0.2, 0.16666666666667
2259, 0, -0.2, 0.20833333333333
2260, 0, -0.2, 0.25
2261, 0, -0.2, 0.29166666666667
2262, 0, -0.2, 0.33333333333333
2263, 0, -0.2, 0.375
2264, 0, -0.2, 0.41666666666667
2265, 0, -0.2, 0.45833333333333
2266, -0.1, -0.04, 0.5
2267, -0.1, -0.08, 0.5
2268, -0.1, -0.12, 0.5
2269, -0.1, -0.16, 0.5
2270, -0.1, -0.04, 0
2271, -0.1, -0.08, 0
2272, -0.1, -0.12, 0
2273, -0.1, -0.16, 0
2274, -0.1, -0.02, 0
2275, -0.1, -0.06, 0
2276, -0.1, -0.1, 0
2277, -0.1, -0.14, 0
2278, -0.1, -0.18, 0
2279, -0.1, -0.2, 0.041666666666667
2280, -0.1, -0.2, 0.083333333333333
2281, -0.1, -0.2, 0.125
2282, -0.1, -0.2, 0.16666666666667
2283, -0.1, -0.2, 0.20833333333333
2284, -0.1, -0.2, 0.25
2285, -0.1, -0.2, 0.29166666666667
2286, -0.1, -0.2, 0.33333333333333
2287, -0.1, -0.2, 0.375
2288, -0.1, -0.2, 0.41666666666667
2289, -0.1, -0.2, 0.45833333333333
2290, 1.2, -0.04, 0.5
2291, 1.2, -0.08, 0.5
2292, 1.2, -0.12, 0.5
2293, 1.2, -0.16, 0.5
2294, 2.2, -0.04, 0.5
2295, 2.2, -0.08, 0.5
2296, 2.2, -0.12, 0.5
2297, 2.2, -0.16, 0.5
2298, 1.2416666666667, -0.2, 0.5
2299, 1.2833333333333, -0.2, 0.5
2300, 1.325, -0.2, 0.5
2301, 1.3666666666667, -0.2, 0.5
2302, 1.4083333333333, -0.2, 0.5
2303, 1.45, -0.2, 0.5
2304, 1.4916666666667, -0.2, 0.5
2305, 1.5333333333333, -0.2, 0.5
2306, 1.575, -0.2, 0.5
2307, 1.6166666666667, -0.2, 0.5
2308, 1.6583333333333, -0.2, 0.5
2309, 1.7, -0.2, 0.5
2310, 1.7416666666667, -0.2, 0.5
2311, 1.7833333333333, -0.2, 0.5
2312, 1.825, -0.2, 0.5
2313, 1.8666666666667, -0.2, 0.5
2314, 1.9083333333333, -0.2, 0.5
2315, 1.95, -0.2, 0.5
2316, 1.9916666666667, -0.2, 0.5
2317, 2.0333333333333, -0.2, 0.5
2318, 2.075, -0.2, 0.5
2319, 2.1166666666667, -0.2, 0.5
2320, 2.1583333333333, -0.2, 0.5
2321, 1.2, -0.04, 0
2322, 1.2, -0.08, 0
2323, 1.2, -0.12, 0
2324, 1.2, -0.16, 0
2325, 1.2, -0.02, 0
2326, 1.2, -0.06, 0
2327, 1.2, -0.1, 0
2328, 1.2, -0.14, 0
2329, 1.2, -0.18, 0
2330, 2.2, -0.04, 0
2331, 2.2, -0.08, 0
2332, 2.2, -0.12, 0
2333, 2.2, -0.16, 0
2334, 2.2, -0.02, 0
2335, 2.2, -0.06, 0
2336, 2.2, -0.1, 0
2337, 2.2, -0.14, 0
2338, 2.2, -0.18, 0
2339, 1.2416666666667, -0.2, 0
2340, 1.2833333333333, -0.2, 0
2341, 1.325, -0.2, 0
2342, 1.3666666666667, -0.2, 0
2343, 1.4083333333333, -0.2, 0
2344, 1.45, -0.2, 0
2345, 1.4916666666667, -0.2, 0
2346, 1.5333333333333, -0.2, 0
2347, 1.575, -0.2, 0
2348, 1.6166666666667, -0.2, 0
2349, 1.6583333333333, -0.2, 0
2350, 1.7, -0.2, 0
2351, 1.7416666666667, -0.2, 0
2352, 1.7833333333333, -0.2, 0
2353, 1.825, -0.2, 0
2354, 1.8666666666667, -0.2, 0
2355, 1.9083333333333, -0.2, 0
2356, 1.95, -0.2, 0
2357, 1.9916666666667, -0.2, 0
2358, 2.0333333333333, -0.2, 0
2359, 2.075, -0.2, 0
2360, 2.1166666666667, -0.2, 0
2361, 2.1583333333333, -0.2, 0
2362, 1.2, -0.2, 0.041666666666667
2363, 1.2, -0.2, 0.083333333333333
2364, 1.2, -0.2, 0.125
2365, 1.2, -0.2, 0.16666666666667
2366, 1.2, -0.2, 0.20833333333333
2367, 1.2, -0.2, 0.25
2368, 1.2, -0.2, 0.29166666666667
2369, 1.2, -0.2, 0.33333333333333
2370, 1.2, -0.2, 0.375
2371, 1.2, -0.2, 0.41666666666667
2372, 1.2, -0.2, 0.45833333333333
2373, 2.2, -0.2, 0.041666666666667
2374, 2.2, -0.2, 0.083333333333333
2375, 2.2, -0.2, 0.125
2376, 2.2, -0.2, 0.16666666666667
2377, 2.2, -0.2, 0.20833333333333
2378, 2.2, -0.2, 0.25
2379, 2.2, -0.2, 0.29166666666667
2380, 2.2, -0.2, 0.33333333333333
2381, 2.2, -0.2, 0.375
2382, 2.2, -0.2, 0.41666666666667
2383, 2.2, -0.2, 0.45833333333333
2384, 2.3, -0.04, 0.5
2385, 2.3, -0.08, 0.5
2386, 2.3, -0.12, 0.5
2387, 2.3, -0.16, 0.5
2388, 2.3, -0.04, 0
2389, 2.3, -0.08, 0
2390, 2.3, -0.12, 0
2391, 2.3, -0.16, 0
2392, 2.3, -0.02, 0
2393, 2.3, -0.06, 0
2394, 2.3, -0.1, 0
2395, 2.3, -0.14, 0
2396, 2.3, -0.18, 0
2397, 2.3, -0.2, 0.041666666666667
2398, 2.3, -0.2, 0.083333333333333
2399, 2.3, -0.2, 0.125
2400, 2.3, -0.2, 0.16666666666667
2401, 2.3, -0.2, 0.20833333333333
2402, 2.3, -0.2, 0.25
2403, 2.3, -0.2, 0.29166666666667
2404, 2.3, -0.2, 0.33333333333333
2405, 2.3, -0.2, 0.375
2406, 2.3, -0.2, 0.41666666666667
2407, 2.3, -0.2, 0.45833333333333
2408, 0, 0.033333333333333, 0.041666666666667
2409, 0, 0.066666666666667, 0.041666666666667
2410, 0, 0.033333333333333, 0.083333333333333
2411, 0, 0.066666666666667, 0.083333333333333
2412, 0, 0.033333333333333, 0.125
2413, 0, 0.066666666666667, 0.125
2414, 0, 0.033333333333333, 0.16666666666667
2415, 0, 0.066666666666667, 0.16666666666667
2416, 0, 0.033333333333333, 0.20833333333333
2417, 0, 0.066666666666667, 0.20833333333333
2418, 0, 0.033333333333333, 0.25
2419, 0, 0.066666666666667, 0.25
2420, 0, 0.033333333333333, 0.29166666666667
2421, 0, 0.066666666666667, 0.29166666666667
2422, 0, 0.033333333333333, 0.33333333333333
2423, 0, 0.066666666666667, 0.33333333333333
2424, 0, 0.033333333333333, 0.375
2425, 0, 0.066666666666667, 0.375
2426, 0, 0.033333333333333, 0.41666666666667
2427, 0, 0.066666666666667, 0.41666666666667
2428, 0, 0.033333333333333, 0.45833333333333
2429, 0, 0.066666666666667, 0.45833333333333
2430, 1, 0.033333333333333, 0.041666666666667
2431, 1, 0.066666666666667, 0.041666666666667
2432, 1, 0.033333333333333, 0.083333333333333
2433, 1, 0.066666666666667, 0.083333333333333
2434, 1, 0.033333333333333, 0.125
2435, 1, 0.066666666666667, 0.125
2436, 1, 0.033333333333333, 0.16666666666667
2437, 1, 0.066666666666667, 0.16666666666667
2438, 1, 0.033333333333333, 0.20833333333333
2439, 1, 0.066666666666667, 0.20833333333333
2440, 1, 0.033333333333333, 0.25
2441, 1, 0.066666666666667, 0.25
2442, 1, 0.033333333333333, 0.29166666666667
2443, 1, 0.066666666666667, 0.29166666666667
2444, 1, 0.033333333333333, 0.33333333333333
2445, 1, 0.066666666666667, 0.33333333333333
2446, 1, 0.033333333333333, 0.375
2447, 1, 0.066666666666667, 0.375
2448, 1, 0.033333333333333, 0.41666666666667
2449, 1, 0.066666666666667, 0.41666666666667
2450, 1, 0.033333333333333, 0.45833333333333
2451, 1, 0.066666666666667, 0.45833333333333
2452, 0.041666666666667, 0, 0.041666666666667
2453, 0.041666666666667, 0, 0.083333333333333
2454, 0.041666666666667, 0, 0.125
2455, 0.041666666666667, 0, 0.16666666666667
2456, 0.041666666666667, 0, 0.20833333333333
2457, 0.041666666666667, 0, 0.25
2458, 0.041666666666667, 0, 0.29166666666667
2459, 0.041666666666667, 0, 0.33333333333333
2460, 0.041666666666667, 0, 0.375
2461, 0.041666666666667, 0, 0.41666666666667
2462, 0.041666666666667, 0, 0.45833333333333
2463, 0.083333333333333, 0, 0.041666666666667
2464, 0.083333333333333, 0, 0.083333333333333
2465, 0.083333333333333, 0, 0.125
2466, 0.083333333333333, 0, 0.16666666666667
2467, 0.083333333333333, 0, 0.20833333333333
2468, 0.083333333333333, 0, 0.25
2469, 0.083333333333333, 0, 0.29166666666667
2470, 0.083333333333333, 0, 0.33333333333333
2471, 0.083333333333333, 0, 0.375
2472, 0.083333333333333, 0, 0.41666666666667
2473, 0.083333333333333, 0, 0.45833333333333
2474, 0.125, 0, 0.041666666666667
2475, 0.125, 0, 0.083333333333333
2476, 0.125, 0, 0.125
2477, 0.125, 0, 0.16666666666667
2478, 0.125, 0, 0.20833333333333
2479, 0.125, 0, 0.25
2480, 0.125, 0, 0.29166666666667
2481, 0.125, 0, 0.33333333333333
2482, 0.125, 0, 0.375
2483, 0.125, 0, 0.41666666666667
2484, 0.125, 0, 0.45833333333333
2485, 0.16666666666667, 0, 0.041666666666667
2486, 0.16666666666667, 0, 0.083333333333333
2487, 0.16666666666667, 0, 0.125
2488, 0.16666666666667, 0, 0.16666666666667
2489, 0.16666666666667, 0, 0.20833333333333
2490, 0.16666666666667, 0, 0.25
2491, 0.16666666666667, 0, 0.29166666666667
2492, 0.16666666666667, 0, 0.33333333333333
2493, 0.16666666666667, 0, 0.375
2494, 0.16666666666667, 0, 0.41666666666667
2495, 0.16666666666667, 0, 0.45833333333333
2496, 0.20833333333333, 0, 0.041666666666667
2497, 0.20833333333333, 0, 0.083333333333333
2498, 0.20833333333333, 0, 0.125
2499, 0.20833333333333, 0, 0.16666666666667
2500, 0.20833333333333, 0, 0.20833333333333
2501, 0.20833333333333, 0, 0.25
2502, 0.20833333333333, 0, 0.29166666666667
2503, 0.20833333333333, 0, 0.33333333333333
2504, 0.20833333333333, 0, 0.375
2505, 0.20833333333333, 0, 0.41666666666667
2506, 0.20833333333333, 0, 0.45833333333333
2507, 0.25, 0, 0.041666666666667
2508, 0.25, 0, 0.083333333333333
2509, 0.25, 0, 0.125
2510, 0.25, 0, 0.16666666666667
2511, 0.25, 0, 0.20833333333333
2512, 0.25, 0, 0.25
2513, 0.25, 0, 0.29166666666667
2514, 0.25, 0, 0.33333333333333
2515, 0.25, 0, 0.375
2516, 0.25, 0, 0.41666666666667
2517, 0.25, 0, 0.45833333333333
2518, 0.29166666666667, 0, 0.041666666666667
2519, 0.29166666666667, 0, 0.083333333333333
2520, 0.29166666666667, 0, 0.125
2521, 0.29166666666667, 0, 0.16666666666667
2522, 0.29166666666667, 0, 0.20833333333333
2523, 0.29166666666667, 0, 0.25
2524, 0.29166666666667, 0, 0.29166666666667
2525, 0.29166666666667, 0, 0.33333333333333
2526, 0.29166666666667, 0, 0.375
2527, 0.29166666666667, 0, 0.41666666666667
2528, 0.29166666666667, 0, 0.45833333333333
2529, 0.33333333333333, 0, 0.041666666666667
2530, 0.33333333333333, 0, 0.083333333333333
2531, 0.33333333333333, 0, 0.125
2532, 0.33333333333333, 0, 0.16666666666667
2533, 0.33333333333333, 0, 0.20833333333333
2534, 0.33333333333333, 0, 0.25
2535, 0.33333333333333, 0, 0.29166666666667
2536, 0.33333333333333, 0, 0.33333333333333
2537, 0.33333333333333, 0, 0.375
2538, 0.33333333333333, 0, 0.41666666666667
2539, 0.33333333333333, 0, 0.45833333333333
2540, 0.375, 0, 0.041666666666667
2541, 0.375, 0, 0.083333333333333
2542, 0.375, 0, 0.125
2543, 0.375, 0, 0.16666666666667
2544, 0.375, 0, 0.20833333333333
2545, 0.375, 0, 0.25
2546, 0.375, 0, 0.29166666666667
2547, 0.375, 0, 0.33333333333333
2548, 0.375, 0, 0.375
2549, 0.375, 0, 0.41666666666667
2550, 0.375, 0, 0.45833333333333
2551, 0.41666666666667, 0, 0.041666666666667
2552, 0.41666666666667, 0, 0.083333333333333
2553, 0.41666666666667, 0, 0.125
2554, 0.41666666666667, 0, 0.16666666666667
2555, 0.41666666666667, 0, 0.20833333333333
2556, 0.41666666666667, 0, 0.25
2557, 0.41666666666667, 0, 0.29166666666667
2558, 0.41666666666667, 0, 0.33333333333333
2559, 0.41666666666667, 0, 0.375
2560, 0.41666666666667, 0, 0.41666666666667
2561, 0.41666666666667, 0, 0.45833333333333
2562, 0.45833333333333, 0, 0.041666666666667
2563, 0.45833333333333, 0, 0.083333333333333
2564, 0.45833333333333, 0, 0.125
2565, 0.45833333333333, 0, 0.16666666666667
2566, 0.45833333333333, 0, 0.20833333333333
2567, 0.45833333333333, 0, 0.25
2568, 0.45833333333333, 0, 0.29166666666667
2569, 0.45833333333333, 0, 0.33333333333333
2570, 0.45833333333333, 0, 0.375
2571, 0.45833333333333, 0, 0.41666666666667
2572, 0.45833333333333, 0, 0.45833333333333
2573, 0.5, 0, 0.041666666666667
2574, 0.5, 0, 0.083333333333333
2575, 0.5, 0, 0.125
2576, 0.5, 0, 0.16666666666667
2577, 0.5, 0, 0.20833333333333
2578, 0.5, 0, 0.25
2579, 0.5, 0, 0.29166666666667
2580, 0.5, 0, 0.33333333333333
2581, 0.5, 0, 0.375
2582, 0.5, 0, 0.41666666666667
2583, 0.5, 0, 0.45833333333333
2584, 0.54166666666667, 0, 0.041666666666667
2585, 0.54166666666667, 0, 0.083333333333333
2586, 0.54166666666667, 0, 0.125
2587, 0.54166666666667, 0, 0.16666666666667
2588, 0.54166666666667, 0, 0.20833333333333
2589, 0.54166666666667, 0, 0.25
2590, 0.54166666666667, 0, 0.29166666666667
2591, 0.54166666666667, 0, 0.33333333333333
2592, 0.54166666666667, 0, 0.375
2593, 0.54166666666667, 0, 0.41666666666667
2594, 0.54166666666667, 0, 0.45833333333333
2595, 0.58333333333333, 0, 0.041666666666667
2596, 0.58333333333333, 0, 0.083333333333333
2597, 0.58333333333333, 0, 0.125
2598, 0.58333333333333, 0, 0.16666666666667
2599, 0.58333333333333, 0, 0.20833333333333
2600, 0.58333333333333, 0, 0.25
2601, 0.58333333333333, 0, 0.29166666666667
2602, 0.58333333333333, 0, 0.33333333333333
2603, 0.58333333333333, 0, 0.375
2604, 0.58333333333333, 0, 0.41666666666667
2605, 0.58333333333333, 0, 0.45833333333333
2606, 0.625, 0, 0.041666666666667
2607, 0.625, 0, 0.083333333333333
2608, 0.625, 0, 0.125
2609, 0.625, 0, 0.16666666666667
2610, 0.625, 0, 0.20833333333333
2611, 0.625, 0, 0.25
2612, 0.625, 0, 0.29166666666667
2613, 0.625, 0, 0.33333333333333
2614, 0.625, 0, 0.375
2615, 0.625, 0, 0.41666666666667
2616, 0.625, 0, 0.45833333333333
2617, 0.66666666666667, 0, 0.041666666666667
2618, 0.66666666666667, 0, 0.083333333333333
2619, 0.66666666666667, 0, 0.125
2620, 0.66666666666667, 0, 0.16666666666667
2621, 0.66666666666667, 0, 0.20833333333333
2622, 0.66666666666667, 0, 0.25
2623, 0.66666666666667, 0, 0.29166666666667
2624, 0.66666666666667, 0, 0.33333333333333
2625, 0.66666666666667, 0, 0.375
2626, 0.66666666666667, 0, 0.41666666666667
2627, 0.66666666666667, 0, 0.45833333333333
2628, 0.70833333333333, 0, 0.041666666666667
2629, 0.70833333333333, 0, 0.083333333333333
2630, 0.70833333333333, 0, 0.125
2631, 0.70833333333333, 0, 0.16666666666667
2632, 0.70833333333333, 0, 0.20833333333333
2633, 0.70833333333333, 0, 0.25
2634, 0.70833333333333, 0, 0.29166666666667
2635, 0.70833333333333, 0, 0.33333333333333
2636, 0.70833333333333, 0, 0.375
2637, 0.70833333333333, 0, 0.41666666666667
2638, 0.70833333333333, 0, 0.45833333333333
2639, 0.75, 0, 0.041666666666667
2640, 0.75, 0, 0.083333333333333
2641, 0.75, 0, 0.125
2642, 0.75, 0, 0.16666666666667
2643, 0.75, 0, 0.20833333333333
2644, 0.75, 0, 0.25
2645, 0.75, 0, 0.29166666666667
2646, 0.75, 0, 0.33333333333333
2647, 0.75, 0, 0.375
2648, 0.75, 0, 0.41666666666667
2649, 0.75, 0, 0.45833333333333
2650, 0.79166666666667, 0, 0.041666666666667
2651, 0.79166666666667, 0, 0.083333333333333
2652, 0.79166666666667, 0, 0.125
2653, 0.79166666666667, 0, 0.16666666666667
2654, 0.79166666666667, 0, 0.20833333333333
2655, 0.79166666666667, 0, 0.25
2656, 0.79166666666667, 0, 0.29166666666667
2657, 0.79166666666667, 0, 0.33333333333333
2658, 0.79166666666667, 0, 0.375
2659, 0.79166666666667, 0, 0.41666666666667
2660, 0.79166666666667, 0, 0.45833333333333
2661, 0.83333333333333, 0, 0.041666666666667
2662, 0.83333333333333, 0, 0.083333333333333
2663, 0.83333333333333, 0, 0.125
2664, 0.83333333333333, 0, 0.16666666666667
2665, 0.83333333333333, 0, 0.20833333333333
2666, 0.83333333333333, 0, 0.25
2667, 0.83333333333333, 0, 0.29166666666667
2668, 0.83333333333333, 0, 0.33333333333333
2669, 0.83333333333333, 0, 0.375
2670, 0.83333333333333, 0, 0.41666666666667
2671, 0.83333333333333, 0, 0.45833333333333
2672, 0.875, 0, 0.041666666666667
2673, 0.875, 0, 0.083333333333333
2674, 0.875, 0, 0.125
2675, 0.875, 0, 0.16666666666667
2676, 0.875, 0, 0.20833333333333
2677, 0.875, 0, 0.25
2678, 0.875, 0, 0.29166666666667
2679, 0.875, 0, 0.33333333333333
2680, 0.875, 0, 0.375
2681, 0.875, 0, 0.41666666666667
2682, 0.875, 0, 0.45833333333333
2683, 0.91666666666667, 0, 0.041666666666667
2684, 0.91666666666667, 0, 0.083333333333333
2685, 0.91666666666667, 0, 0.125
2686, 0.91666666666667, 0, 0.16666666666667
2687, 0.91666666666667, 0, 0.20833333333333
2688, 0.91666666666667, 0, 0.25
2689, 0.91666666666667, 0, 0.29166666666667
2690, 0.91666666666667, 0, 0.33333333333333
2691, 0.91666666666667, 0, 0.375
2692, 0.91666666666667, 0, 0.41666666666667
2693, 0.91666666666667, 0, 0.45833333333333
2694, 0.95833333333333, 0, 0.041666666666667
2695, 0.95833333333333, 0, 0.083333333333333
2696, 0.95833333333333, 0, 0.125
2697, 0.95833333333333, 0, 0.16666666666667
2698, 0.95833333333333, 0, 0.20833333333333
2699, 0.95833333333333, 0, 0.25
2700, 0.95833333333333, 0, 0.29166666666667
2701, 0.95833333333333, 0, 0.33333333333333
2702, 0.95833333333333, 0, 0.375
2703, 0.95833333333333, 0, 0.41666666666667
2704, 0.95833333333333, 0, 0.45833333333333
2705, 0.041666666666667, 0.1, 0.041666666666667
2706, 0.041666666666667, 0.1, 0.083333333333333
2707, 0.041666666666667, 0.1, 0.125
2708, 0.041666666666667, 0.1, 0.16666666666667
2709, 0.041666666666667, 0.1, 0.20833333333333
2710, 0.041666666666667, 0.1, 0.25
2711, 0.041666666666667, 0.1, 0.29166666666667
2712, 0.041666666666667, 0.1, 0.33333333333333
2713, 0.041666666666667, 0.1, 0.375
2714, 0.041666666666667, 0.1, 0.41666666666667
2715, 0.041666666666667, 0.1, 0.45833333333333
2716, 0.083333333333333, 0.1, 0.041666666666667
2717, 0.083333333333333, 0.1, 0.083333333333333
2718, 0.083333333333333, 0.1, 0.125
2719, 0.083333333333333, 0.1, 0.16666666666667
2720, 0.083333333333333, 0.1, 0.20833333333333
2721, 0.083333333333333, 0.1, 0.25
2722, 0.083333333333333, 0.1, 0.29166666666667
2723, 0.083333333333333, 0.1, 0.33333333333333
2724, 0.083333333333333, 0.1, 0.375
2725, 0.083333333333333, 0.1, 0.41666666666667
2726, 0.083333333333333, 0.1, 0.45833333333333
2727, 0.125, 0.1, 0.041666666666667
2728, 0.125, 0.1, 0.083333333333333
2729, 0.125, 0.1, 0.125
2730, 0.125, 0.1, 0.16666666666667
2731, 0.125, 0.1, 0.20833333333333
2732, 0.125, 0.1, 0.25
2733, 0.125, 0.1, 0.29166666666667
2734, 0.125, 0.1, 0.33333333333333
2735, 0.125, 0.1, 0.375
2736, 0.125, 0.1, 0.41666666666667
2737, 0.125, 0.1, 0.45833333333333
2738, 0.16666666666667, 0.1, 0.041666666666667
2739, 0.16666666666667, 0.1, 0.083333333333333
2740, 0.16666666666667, 0.1, 0.125
2741, 0.16666666666667, 0.1, 0.16666666666667
2742, 0.16666666666667, 0.1, 0.20833333333333
2743, 0.16666666666667, 0.1, 0.25
2744, 0.16666666666667, 0.1, 0.29166666666667
2745, 0.16666666666667, 0.1, 0.33333333333333
2746, 0.16666666666667, 0.1, 0.375
2747, 0.16666666666667, 0.1, 0.41666666666667
2748, 0.16666666666667, 0.1, 0.45833333333333
2749, 0.20833333333333, 0.1, 0.041666666666667
2750, 0.20833333333333, 0.1, 0.083333333333333
2751, 0.20833333333333, 0.1, 0.125
2752, 0.20833333333333, 0.1, 0.16666666666667
2753, 0.20833333333333, 0.1, 0.20833333333333
2754, 0.20833333333333, 0.1, 0.25
2755, 0.20833333333333, 0.1, 0.29166666666667
2756, 0.20833333333333, 0.1, 0.33333333333333
2757, 0.20833333333333, 0.1, 0.375
2758, 0.20833333333333, 0.1, 0.41666666666667
2759, 0.20833333333333, 0.1, 0.45833333333333
2760, 0.25, 0.1, 0.041666666666667
2761, 0.25, 0.1, 0.083333333333333
2762, 0.25, 0.1, 0.125
2763, 0.25, 0.1, 0.16666666666667
2764, 0.25, 0.1, 0.20833333333333
2765, 0.25, 0.1, 0.25
2766, 0.25, 0.1, 0.29166666666667
2767, 0.25, 0.1, 0.33333333333333
2768, 0.25, 0.1, 0.375
2769, 0.25, 0.1, 0.41666666666667
2770, 0.25, 0.1, 0.45833333333333
2771, 0.29166666666667, 0.1, 0.041666666666667
2772, 0.29166666666667, 0.1, 0.083333333333333
2773, 0.29166666666667, 0.1, 0.125
2774, 0.29166666666667, 0.1, 0.16666666666667
2775, 0.29166666666667, 0.1, 0.20833333333333
2776, 0.29166666666667, 0.1, 0.25
2777, 0.29166666666667, 0.1, 0.29166666666667
2778, 0.29166666666667, 0.1, 0.33333333333333
2779, 0.29166666666667, 0.1, 0.375
2780, 0.29166666666667, 0.1, 0.41666666666667
2781, 0.29166666666667, 0.1, 0.45833333333333
2782, 0.33333333333333, 0.1, 0.041666666666667
2783, 0.33333333333333, 0.1, 0.083333333333333
2784, 0.33333333333333, 0.1, 0.125
2785, 0.33333333333333, 0.1, 0.16666666666667
2786, 0.33333333333333, 0.1, 0.20833333333333
2787, 0.33333333333333, 0.1, 0.25
2788, 0.33333333333333, 0.1, 0.29166666666667
2789, 0.33333333333333, 0.1, 0.33333333333333
2790, 0.33333333333333, 0.1, 0.375
2791, 0.33333333333333, 0.1, 0.41666666666667
2792, 0.33333333333333, 0.1, 0.45833333333333
2793, 0.375, 0.1, 0.041666666666667
2794, 0.375, 0.1, 0.083333333333333
2795, 0.375, 0.1, 0.125
2796, 0.375, 0.1, 0.16666666666667
2797, 0.375, 0.1, 0.20833333333333
2798, 0.375, 0.1, 0.25
2799, 0.375, 0.1, 0.29166666666667
2800, 0.375, 0.1, 0.33333333333333
2801, 0.375, 0.1, 0.375
2802, 0.375, 0.1, 0.41666666666667
2803, 0.375, 0.1, 0.45833333333333
2804, 0.41666666666667, 0.1, 0.041666666666667
2805, 0.41666666666667, 0.1, 0.083333333333333
2806, 0.41666666666667, 0.1, 0.125
2807, 0.41666666666667, 0.1, 0.16666666666667
2808, 0.41666666666667, 0.1, 0.20833333333333
2809, 0.41666666666667, 0.1, 0.25
2810, 0.41666666666667, 0.1, 0.29166666666667
2811, 0.41666666666667, 0.1, 0.33333333333333
2812, 0.41666666666667, 0.1, 0.375
2813, 0.41666666666667, 0.1, 0.41666666666667
2814, 0.41666666666667, 0.1, 0.45833333333333
2815, 0.45833333333333, 0.1, 0.041666666666667
2816, 0.45833333333333, 0.1, 0.083333333333333
2817, 0.45833333333333, 0.1, 0.125
2818, 0.45833333333333, 0.1, 0.16666666666667
2819, 0.45833333333333, 0.1, 0.20833333333333
2820, 0.45833333333333, 0.1, 0.25
2821, 0.45833333333333, 0.1, 0.29166666666667
2822, 0.45833333333333, 0.1, 0.33333333333333
2823, 0.45833333333333, 0.1, 0.375
2824, 0.45833333333333, 0.1, 0.41666666666667
2825, 0.45833333333333, 0.1, 0.45833333333333
2826, 0.5, 0.1, 0.041666666666667
2827, 0.5, 0.1, 0.083333333333333
2828, 0.5, 0.1, 0.125
2829, 0.5, 0.1, 0.16666666666667
2830, 0.5, 0.1, 0.20833333333333
2831, 0.5, 0.1, 0.25
2832, 0.5, 0.1, 0.29166666666667
2833, 0.5, 0.1, 0.33333333333333
2834, 0.5, 0.1, 0.375
2835, 0.5, 0.1, 0.41666666666667
2836, 0.5, 0.1, 0.45833333333333
2837, 0.54166666666667, 0.1, 0.041666666666667
2838, 0.54166666666667, 0.1, 0.083333333333333
2839, 0.54166666666667, 0.1, 0.125
2840, 0.54166666666667, 0.1, 0.16666666666667
2841, 0.54166666666667, 0.1, 0.20833333333333
2842, 0.54166666666667, 0.1, 0.25
2843, 0.54166666666667, 0.1, 0.29166666666667
2844, 0.54166666666667, 0.1, 0.33333333333333
2845, 0.54166666666667, 0.1, 0.375
2846, 0.54166666666667, 0.1, 0.41666666666667
2847, 0.54166666666667, 0.1, 0.45833333333333
2848, 0.58333333333333, 0.1, 0.041666666666667
2849, 0.58333333333333, 0.1, 0.083333333333333
2850, 0.58333333333333, 0.1, 0.125
2851, 0.58333333333333, 0.1, 0.16666666666667
2852, 0.58333333333333, 0.1, 0.20833333333333
2853, 0.58333333333333, 0.1, 0.25
2854, 0.58333333333333, 0.1, 0.29166666666667
2855, 0.58333333333333, 0.1, 0.33333333333333
2856, 0.58333333333333, 0.1, 0.375
2857, 0.58333333333333, 0.1, 0.41666666666667
2858, 0.58333333333333, 0.1, 0.45833333333333
2859, 0.625, 0.1, 0.041666666666667
2860, 0.625, 0.1, 0.083333333333333
2861, 0.625, 0.1, 0.125
2862, 0.625, 0.1, 0.16666666666667
2863, 0.625, 0.1, 0.20833333333333
2864, 0.625, 0.1, 0.25
2865, 0.625, 0.1, 0.29166666666667
2866, 0.625, 0.1, 0.33333333333333
2867, 0.625, 0.1, 0.375
2868, 0.625, 0.1, 0.41666666666667
2869, 0.625, 0.1, 0.45833333333333
2870, 0.66666666666667, 0.1, 0.041666666666667
2871, 0.66666666666667, 0.1, 0.083333333333333
2872, 0.66666666666667, 0.1, 0.125
2873, 0.66666666666667, 0.1, 0.16666666666667
2874, 0.66666666666667, 0.1, 0.20833333333333
2875, 0.66666666666667, 0.1, 0.25
2876, 0.66666666666667, 0.1, 0.29166666666667
2877, 0.66666666666667, 0.1, 0.33333333333333
2878, 0.66666666666667, 0.1, 0.375
2879, 0.66666666666667, 0.1, 0.41666666666667
2880, 0.66666666666667, 0.1, 0.45833333333333
2881, 0.70833333333333, 0.1, 0.041666666666667
2882, 0.70833333333333, 0.1, 0.083333333333333
2883, 0.70833333333333, 0.1, 0.125
2884, 0.70833333333333, 0.1, 0.16666666666667
2885, 0.70833333333333, 0.1, 0.20833333333333
2886, 0.70833333333333, 0.1, 0.25
2887, 0.70833333333333, 0.1, 0.29166666666667
2888, 0.70833333333333, 0.1, 0.33333333333333
2889, 0.70833333333333, 0.1, 0.375
2890, 0.70833333333333, 0.1, 0.41666666666667
2891, 0.70833333333333, 0.1, 0.45833333333333
2892, 0.75, 0.1, 0.041666666666667
2893, 0.75, 0.1, 0.083333333333333
2894, 0.75, 0.1, 0.125
2895, 0.75, 0.1, 0.16666666666667
2896, 0.75, 0.1, 0.20833333333333
2897, 0.75, 0.1, 0.25
2898, 0.75, 0.1, 0.29166666666667
2899, 0.75, 0.1, 0.33333333333333
2900, 0.75, 0.1, 0.375
2901, 0.75, 0.1, 0.41666666666667
2902, 0.75, 0.1, 0.45833333333333
2903, 0.79166666666667, 0.1, 0.041666666666667
2904, 0.79166666666667, 0.1, 0.083333333333333
2905, 0.79166666666667, 0.1, 0.125
2906, 0.79166666666667, 0.1, 0.16666666666667
2907, 0.79166666666667, 0.1, 0.20833333333333
2908, 0.79166666666667, 0.1, 0.25
2909, 0.79166666666667, 0.1, 0.29166666666667
2910, 0.79166666666667, 0.1, 0.33333333333333
2911, 0.79166666666667, 0.1, 0.375
2912, 0.79166666666667, 0.1, 0.41666666666667
2913, 0.79166666666667, 0.1, 0.45833333333333
2914, 0.83333333333333, 0.1, 0.041666666666667
2915, 0.83333333333333, 0.1, 0.083333333333333
2916, 0.83333333333333, 0.1, 0.125
2917, 0.83333333333333, 0.1, 0.16666666666667
2918, 0.83333333333333, 0.1, 0.20833333333333
2919, 0.83333333333333, 0.1, 0.25
2920, 0.83333333333333, 0.1, 0.29166666666667
2921, 0.83333333333333, 0.1, 0.33333333333333
2922, 0.83333333333333, 0.1, 0.375
2923, 0.83333333333333, 0.1, 0.41666666666667
2924, 0.83333333333333, 0.1, 0.45833333333333
2925, 0.875, 0.1, 0.041666666666667
2926, 0.875, 0.1, 0.083333333333333
2927, 0.875, 0.1, 0.125
2928, 0.875, 0.1, 0.16666666666667
2929, 0.875, 0.1, 0.20833333333333
2930, 0.875, 0.1, 0.25
2931, 0.875, 0.1, 0.29166666666667
2932, 0.875, 0.1, 0.33333333333333
2933, 0.875, 0.1, 0.375
2934, 0.875, 0.1, 0.41666666666667
2935, 0.875, 0.1, 0.45833333333333
2936, 0.91666666666667, 0.1, 0.041666666666667
2937, 0.91666666666667, 0.1, 0.083333333333333
2938, 0.91666666666667, 0.1, 0.125
2939, 0.91666666666667, 0.1, 0.16666666666667
2940, 0.91666666666667, 0.1, 0.20833333333333
2941, 0.91666666666667, 0.1, 0.25
2942, 0.91666666666667, 0.1, 0.29166666666667
2943, 0.91666666666667, 0.1, 0.33333333333333
2944, 0.91666666666667, 0.1, 0.375
2945, 0.91666666666667, 0.1, 0.41666666666667
2946, 0.91666666666667, 0.1, 0.45833333333333
2947, 0.95833333333333, 0.1, 0.041666666666667
2948, 0.95833333333333, 0.1, 0.083333333333333
2949, 0.95833333333333, 0.1, 0.125
2950, 0.95833333333333, 0.1, 0.16666666666667
2951, 0.95833333333333, 0.1, 0.20833333333333
2952, 0.95833333333333, 0.1, 0.25
2953, 0.95833333333333, 0.1, 0.29166666666667
2954, 0.95833333333333, 0.1, 0.33333333333333
2955, 0.95833333333333, 0.1, 0.375
2956, 0.95833333333333, 0.1, 0.41666666666667
2957, 0.95833333333333, 0.1, 0.45833333333333
2958, 0.041666666666667, 0.033333333333333, 0
2959, 0.083333333333333, 0.033333333333333, 0
2960, 0.125, 0.033333333333333, 0
2961, 0.16666666666667, 0.033333333333333, 0
2962, 0.20833333333333, 0.033333333333333, 0
2963, 0.25, 0.033333333333333, 0
2964, 0.29166666666667, 0.033333333333333, 0
2965, 0.33333333333333, 0.033333333333333, 0
2966, 0.375, 0.033333333333333, 0
2967, 0.41666666666667, 0.033333333333333, 0
2968, 0.45833333333333, 0.033333333333333, 0
2969, 0.5, 0.033333333333333, 0
2970, 0.54166666666667, 0.033333333333333, 0
2971, 0.58333333333333, 0.033333333333333, 0
2972, 0.625, 0.033333333333333, 0
2973, 0.66666666666667, 0.033333333333333, 0
2974, 0.70833333333333, 0.033333333333333, 0
2975, 0.75, 0.033333333333333, 0
2976, 0.79166666666667, 0.033333333333333, 0
2977, 0.83333333333333, 0.033333333333333, 0
2978, 0.875, 0.033333333333333, 0
2979, 0.91666666666667, 0.033333333333333, 0
2980, 0.95833333333333, 0.033333333333333, 0
2981, 0.041666666666667, 0.066666666666667, 0
2982, 0.083333333333333, 0.066666666666667, 0
2983, 0.125, 0.066666666666667, 0
2984, 0.16666666666667, 0.066666666666667, 0
2985, 0.20833333333333, 0.066666666666667, 0
2986, 0.25, 0.066666666666667, 0
2987, 0.29166666666667, 0.066666666666667, 0
2988, 0.33333333333333, 0.066666666666667, 0
2989, 0.375, 0.066666666666667, 0
2990, 0.41666666666667, 0.066666666666667, 0
2991, 0.45833333333333, 0.066666666666667, 0
2992, 0.5, 0.066666666666667, 0
2993, 0.54166666666667, 0.066666666666667, 0
2994, 0.58333333333333, 0.066666666666667, 0
2995, 0.625, 0.066666666666667, 0
2996, 0.66666666666667, 0.066666666666667, 0
2997, 0.70833333333333, 0.066666666666667, 0
2998, 0.75, 0.066666666666667, 0
2999, 0.79166666666667, 0.066666666666667, 0
3000, 0.83333333333333, 0.066666666666667, 0
3001, 0.875, 0.066666666666667, 0
3002, 0.91666666666667, 0.066666666666667, 0
3003, 0.95833333333333, 0.066666666666667, 0
3004, 0.041666666666667, 0.033333333333333, 0.5
3005, 0.083333333333333, 0.033333333333333, 0.5
3006, 0.125, 0.033333333333333, 0.5
3007, 0.16666666666667, 0.033333333333333, 0.5
3008, 0.20833333333333, 0.033333333333333, 0.5
3009, 0.25, 0.033333333333333, 0.5
3010, 0.29166666666667, 0.033333333333333, 0.5
3011, 0.33333333333333, 0.033333333333333, 0.5
3012, 0.375, 0.033333333333333, 0.5
3013, 0.41666666666667, 0.033333333333333, 0.5
3014, 0.45833333333333, 0.033333333333333, 0.5
3015, 0.5, 0.033333333333333, 0.5
3016, 0.54166666666667, 0.033333333333333, 0.5
3017, 0.58333333333333, 0.033333333333333, 0.5
3018, 0.625, 0.033333333333333, 0.5
3019, 0.66666666666667, 0.033333333333333, 0.5
3020, 0.70833333333333, 0.033333333333333, 0.5
3021, 0.75, 0.033333333333333, 0.5
3022, 0.79166666666667, 0.033333333333333, 0.5
3023, 0.83333333333333, 0.033333333333333, 0.5
3024, 0.875, 0.033333333333333, 0.5
3025, 0.91666666666667, 0.033333333333333, 0.5
3026, 0.95833333333333, 0.033333333333333, 0.5
3027, 0.041666666666667, 0.066666666666667, 0.5
3028, 0.083333333333333, 0.066666666666667, 0.5
3029, 0.125, 0.066666666666667, 0.5
3030, 0.16666666666667, 0.066666666666667, 0.5
3031, 0.20833333333333, 0.066666666666667, 0.5
3032, 0.25, 0.066666666666667, 0.5
3033, 0.29166666666667, 0.066666666666667, 0.5
3034, 0.33333333333333, 0.066666666666667, 0.5
3035, 0.375, 0.066666666666667, 0.5
3036, 0.41666666666667, 0.066666666666667, 0.5
3037, 0.45833333333333, 0.066666666666667, 0.5
3038, 0.5, 0.066666666666667, 0.5
3039, 0.54166666666667, 0.066666666666667, 0.5
3040, 0.58333333333333, 0.066666666666667, 0.5
3041, 0.625, 0.066666666666667, 0.5
3042, 0.66666666666667, 0.066666666666667, 0.5
3043, 0.70833333333333, 0.066666666666667, 0.5
3044, 0.75, 0.066666666666667, 0.5
3045, 0.79166666666667, 0.066666666666667, 0.5
3046, 0.83333333333333, 0.066666666666667, 0.5
3047, 0.875, 0.066666666666667, 0.5
3048, 0.91666666666667, 0.066666666666667, 0.5
3049, 0.95833333333333, 0.066666666666667, 0.5
3050, 0.041666666666667, 0.15, 0.041666666666667
3051, 0.041666666666667, 0.15, 0.083333333333333
3052, 0.041666666666667, 0.15, 0.125
3053, 0.041666666666667, 0.15, 0.16666666666667
3054, 0.041666666666667, 0.15, 0.20833333333333
3055, 0.041666666666667, 0.15, 0.25
3056, 0.041666666666667, 0.15, 0.29166666666667
3057, 0.041666666666667, 0.15, 0.33333333333333
3058, 0.041666666666667, 0.15, 0.375
3059, 0.041666666666667, 0.15, 0.41666666666667
3060, 0.041666666666667, 0.15, 0.45833333333333
3061, 0.083333333333333, 0.15, 0.041666666666667
3062, 0.083333333333333, 0.15, 0.083333333333333
3063, 0.083333333333333, 0.15, 0.125
3064, 0.083333333333333, 0.15, 0.16666666666667
3065, 0.083333333333333, 0.15, 0.20833333333333
3066, 0.083333333333333, 0.15, 0.25
3067, 0.083333333333333, 0.15, 0.29166666666667
3068, 0.083333333333333, 0.15, 0.33333333333333
3069, 0.083333333333333, 0.15, 0.375
3070, 0.083333333333333, 0.15, 0.41666666666667
3071, 0.083333333333333, 0.15, 0.45833333333333
3072, 0.125, 0.15, 0.041666666666667
3073, 0.125, 0.15, 0.083333333333333
3074, 0.125, 0.15, 0.125
3075, 0.125, 0.15, 0.16666666666667
3076, 0.125, 0.15, 0.20833333333333
3077, 0.125, 0.15, 0.25
3078, 0.125, 0.15, 0.29166666666667
3079, 0.125, 0.15, 0.33333333333333
3080, 0.125, 0.15, 0.375
3081, 0.125, 0.15, 0.41666666666667
3082, 0.125, 0.15, 0.45833333333333
3083, 0.16666666666667, 0.15, 0.041666666666667
3084, 0.16666666666667, 0.15, 0.083333333333333
3085, 0.16666666666667, 0.15, 0.125
3086, 0.16666666666667, 0.15, 0.16666666666667
3087, 0.16666666666667, 0.15, 0.20833333333333
3088, 0.16666666666667, 0.15, 0.25
3089, 0.16666666666667, 0.15, 0.29166666666667
3090, 0.16666666666667, 0.15, 0.33333333333333
3091, 0.16666666666667, 0.15, 0.375
3092, 0.16666666666667, 0.15, 0.41666666666667
3093, 0.16666666666667, 0.15, 0.45833333333333
3094, 0.20833333333333, 0.15, 0.041666666666667
3095, 0.20833333333333, 0.15, 0.083333333333333
3096, 0.20833333333333, 0.15, 0.125
3097, 0.20833333333333, 0.15, 0.16666666666667
3098, 0.20833333333333, 0.15, 0.20833333333333
3099, 0.20833333333333, 0.15, 0.25
3100, 0.20833333333333, 0.15, 0.29166666666667
3101, 0.20833333333333, 0.15, 0.33333333333333
3102, 0.20833333333333, 0.15, 0.375
3103, 0.20833333333333, 0.15, 0.41666666666667
3104, 0.20833333333333, 0.15, 0.45833333333333
3105, 0.25, 0.15, 0.041666666666667
3106, 0.25, 0.15, 0.083333333333333
3107, 0.25, 0.15, 0.125
3108, 0.25, 0.15, 0.16666666666667
3109, 0.25, 0.15, 0.20833333333333
3110, 0.25, 0.15, 0.25
3111, 0.25, 0.15, 0.29166666666667
3112, 0.25, 0.15, 0.33333333333333
3113, 0.25, 0.15, 0.375
3114, 0.25, 0.15, 0.41666666666667
3115, 0.25, 0.15, 0.45833333333333
3116, 0.29166666666667, 0.15, 0.041666666666667
3117, 0.29166666666667, 0.15, 0.083333333333333
3118, 0.29166666666667, 0.15, 0.125
3119, 0.29166666666667, 0.15, 0.16666666666667
3120, 0.29166666666667, 0.15, 0.20833333333333
3121, 0.29166666666667, 0.15, 0.25
3122, 0.29166666666667, 0.15, 0.29166666666667
3123, 0.29166666666667, 0.15, 0.33333333333333
3124, 0.29166666666667, 0.15, 0.375
3125, 0.29166666666667, 0.15, 0.41666666666667
3126, 0.29166666666667, 0.15, 0.45833333333333
3127, 0.33333333333333, 0.15, 0.041666666666667
3128, 0.33333333333333, 0.15, 0.083333333333333
3129, 0.33333333333333, 0.15, 0.125
3130, 0.33333333333333, 0.15, 0.16666666666667
3131, 0.33333333333333, 0.15, 0.20833333333333
3132, 0.33333333333333, 0.15, 0.25
3133, 0.33333333333333, 0.15, 0.29166666666667
3134, 0.33333333333333, 0.15, 0.33333333333333
3135, 0.33333333333333, 0.15, 0.375
3136, 0.33333333333333, 0.15, 0.41666666666667
3137, 0.33333333333333, 0.15, 0.45833333333333
3138, 0.375, 0.15, 0.041666666666667
3139, 0.375, 0.15, 0.083333333333333
3140, 0.375, 0.15, 0.125
3141, 0.375, 0.15, 0.16666666666667
3142, 0.375, 0.15, 0.20833333333333
3143, 0.375, 0.15, 0.25
3144, 0.375, 0.15, 0.29166666666667
3145, 0.375, 0.15, 0.33333333333333
3146, 0.375, 0.15, 0.375
3147, 0.375, 0.15, 0.41666666666667
3148, 0.375, 0.15, 0.45833333333333
3149, 0.41666666666667, 0.15, 0.041666666666667
3150, 0.41666666666667, 0.15, 0.083333333333333
3151, 0.41666666666667, 0.15, 0.125
3152, 0.41666666666667, 0.15, 0.16666666666667
3153, 0.41666666666667, 0.15, 0.20833333333333
3154, 0.41666666666667, 0.15, 0.25
3155, 0.41666666666667, 0.15, 0.29166666666667
3156, 0.41666666666667, 0.15, 0.33333333333333
3157, 0.41666666666667, 0.15, 0.375
3158, 0.41666666666667, 0.15, 0.41666666666667
3159, 0.41666666666667, 0.15, 0.45833333333333
3160, 0.45833333333333, 0.15, 0.041666666666667
3161, 0.45833333333333, 0.15, 0.083333333333333
3162, 0.45833333333333, 0.15, 0.125
3163, 0.45833333333333, 0.15, 0.16666666666667
3164, 0.45833333333333, 0.15, 0.20833333333333
3165, 0.45833333333333, 0.15, 0.25
3166, 0.45833333333333, 0.15, 0.29166666666667
3167, 0.45833333333333, 0.15, 0.33333333333333
3168, 0.45833333333333, 0.15, 0.375
3169, 0.45833333333333, 0.15, 0.41666666666667
3170, 0.45833333333333, 0.15, 0.45833333333333
3171, 0.5, 0.15, 0.041666666666667
3172, 0.5, 0.15, 0.083333333333333
3173, 0.5, 0.15, 0.125
3174, 0.5, 0.15, 0.16666666666667
3175, 0.5, 0.15, 0.20833333333333
3176, 0.5, 0.15, 0.25
3177, 0.5, 0.15, 0.29166666666667
3178, 0.5, 0.15, 0.33333333333333
3179, 0.5, 0.15, 0.375
3180, 0.5, 0.15, 0.41666666666667
3181, 0.5, 0.15, 0.45833333333333
3182, 0.54166666666667, 0.15, 0.041666666666667
3183, 0.54166666666667, 0.15, 0.083333333333333
3184, 0.54166666666667, 0.15, 0.125
3185, 0.54166666666667, 0.15, 0.16666666666667
3186, 0.54166666666667, 0.15, 0.20833333333333
3187, 0.54166666666667, 0.15, 0.25
3188, 0.54166666666667, 0.15, 0.29166666666667
3189, 0.54166666666667, 0.15, 0.33333333333333
3190, 0.54166666666667, 0.15, 0.375
3191, 0.54166666666667, 0.15, 0.41666666666667
3192, 0.54166666666667, 0.15, 0.45833333333333
3193, 0.58333333333333, 0.15, 0.041666666666667
3194, 0.58333333333333, 0.15, 0.083333333333333
3195, 0.58333333333333, 0.15, 0.125
3196, 0.58333333333333, 0.15, 0.16666666666667
3197, 0.58333333333333, 0.15, 0.20833333333333
3198, 0.58333333333333, 0.15, 0.25
3199, 0.58333333333333, 0.15, 0.29166666666667
3200, 0.58333333333333, 0.15, 0.33333333333333
3201, 0.58333333333333, 0.15, 0.375
3202, 0.58333333333333, 0.15, 0.41666666666667
3203, 0.58333333333333, 0.15, 0.45833333333333
3204, 0.625, 0.15, 0.041666666666667
3205, 0.625, 0.15, 0.083333333333333
3206, 0.625, 0.15, 0.125
3207, 0.625, 0.15, 0.16666666666667
3208, 0.625, 0.15, 0.20833333333333
3209, 0.625, 0.15, 0.25
3210, 0.625, 0.15, 0.29166666666667
3211, 0.625, 0.15, 0.33333333333333
3212, 0.625, 0.15, 0.375
3213, 0.625, 0.15, 0.41666666666667
3214, 0.625, 0.15, 0.45833333333333
3215, 0.66666666666667, 0.15, 0.041666666666667
3216, 0.66666666666667, 0.15, 0.083333333333333
3217, 0.66666666666667, 0.15, 0.125
3218, 0.66666666666667, 0.15, 0.16666666666667
3219, 0.66666666666667, 0.15, 0.20833333333333
3220, 0.66666666666667, 0.15, 0.25
3221, 0.66666666666667, 0.15, 0.29166666666667
3222, 0.66666666666667, 0.15, 0.33333333333333
3223, 0.66666666666667, 0.15, 0.375
3224, 0.66666666666667, 0.15, 0.41666666666667
3225, 0.66666666666667, 0.15, 0.45833333333333
3226, 0.70833333333333, 0.15, 0.041666666666667
3227, 0.70833333333333, 0.15, 0.083333333333333
3228, 0.70833333333333, 0.15, 0.125
3229, 0.70833333333333, 0.15, 0.16666666666667
3230, 0.70833333333333, 0.15, 0.20833333333333
3231, 0.70833333333333, 0.15, 0.25
3232, 0.70833333333333, 0.15, 0.29166666666667
3233, 0.70833333333333, 0.15, 0.33333333333333
3234, 0.70833333333333, 0.15, 0.375
3235, 0.70833333333333, 0.15, 0.41666666666667
3236, 0.70833333333333, 0.15, 0.45833333333333
3237, 0.75, 0.15, 0.041666666666667
3238, 0.75, 0.15, 0.083333333333333
3239, 0.75, 0.15, 0.125
3240, 0.75, 0.15, 0.16666666666667
3241, 0.75, 0.15, 0.20833333333333
3242, 0.75, 0.15, 0.25
3243, 0.75, 0.15, 0.29166666666667
3244, 0.75, 0.15, 0.33333333333333
3245, 0.75, 0.15, 0.375
3246, 0.75, 0.15, 0.41666666666667
3247, 0.75, 0.15, 0.45833333333333
3248, 0.79166666666667, 0.15, 0.041666666666667
3249, 0.79166666666667, 0.15, 0.083333333333333
3250, 0.79166666666667, 0.15, 0.125
3251, 0.79166666666667, 0.15, 0.16666666666667
3252, 0.79166666666667, 0.15, 0.20833333333333
3253, 0.79166666666667, 0.15, 0.25
3254, 0.79166666666667, 0.15, 0.29166666666667
3255, 0.79166666666667, 0.15, 0.33333333333333
3256, 0.79166666666667, 0.15, 0.375
3257, 0.79166666666667, 0.15, 0.41666666666667
3258, 0.79166666666667, 0.15, 0.45833333333333
3259, 0.83333333333333, 0.15, 0.041666666666667
3260, 0.83333333333333, 0.15, 0.083333333333333
3261, 0.83333333333333, 0.15, 0.125
3262, 0.83333333333333, 0.15, 0.16666666666667
3263, 0.83333333333333, 0.15, 0.20833333333333
3264, 0.83333333333333, 0.15, 0.25
3265, 0.83333333333333, 0.15, 0.29166666666667
3266, 0.83333333333333, 0.15, 0.33333333333333
3267, 0.83333333333333, 0.15, 0.375
3268, 0.83333333333333, 0.15, 0.41666666666667
3269, 0.83333333333333, 0.15, 0.45833333333333
3270, 0.875, 0.15, 0.041666666666667
3271, 0.875, 0.15, 0.083333333333333
3272, 0.875, 0.15, 0.125
3273, 0.875, 0.15, 0.16666666666667
3274, 0.875, 0.15, 0.20833333333333
3275, 0.875, 0.15, 0.25
3276, 0.875, 0.15, 0.29166666666667
3277, 0.875, 0.15, 0.33333333333333
3278, 0.875, 0.15, 0.375
3279, 0.875, 0.15, 0.41666666666667
3280, 0.875, 0.15, 0.45833333333333
3281, 0.91666666666667, 0.15, 0.041666666666667
3282, 0.91666666666667, 0.15, 0.083333333333333
3283, 0.91666666666667, 0.15, 0.125
3284, 0.91666666666667, 0.15, 0.16666666666667
3285, 0.91666666666667, 0.15, 0.20833333333333
3286, 0.91666666666667, 0.15, 0.25
3287, 0.91666666666667, 0.15, 0.29166666666667
3288, 0.91666666666667, 0.15, 0.33333333333333
3289, 0.91666666666667, 0.15, 0.375
3290, 0.91666666666667, 0.15, 0.41666666666667
3291, 0.91666666666667, 0.15, 0.45833333333333
3292, 0.95833333333333, 0.15, 0.041666666666667
3293, 0.95833333333333, 0.15, 0.083333333333333
3294, 0.95833333333333, 0.15, 0.125
3295, 0.95833333333333, 0.15, 0.16666666666667
3296, 0.95833333333333, 0.15, 0.20833333333333
3297, 0.95833333333333, 0.15, 0.25
3298, 0.95833333333333, 0.15, 0.29166666666667
3299, 0.95833333333333, 0.15, 0.33333333333333
3300, 0.95833333333333, 0.15, 0.375
3301, 0.95833333333333, 0.15, 0.41666666666667
3302, 0.95833333333333, 0.15, 0.45833333333333
3303, 0.041666666666667, 0.2, 0
3304, 0.041666666666667, 0.25, 0
3305, 0.041666666666667, 0.3, 0
3306, 0.041666666666667, 0.35, 0
3307, 0.041666666666667, 0.4, 0
3308, 0.041666666666667, 0.45, 0
3309, 0.041666666666667, 0.5, 0
3310, 0.041666666666667, 0.55, 0
3311, 0.041666666666667, 0.6, 0
3312, 0.041666666666667, 0.65, 0
3313, 0.041666666666667, 0.7, 0
3314, 0.041666666666667, 0.75, 0
3315, 0.041666666666667, 0.8, 0
3316, 0.041666666666667, 0.85, 0
3317, 0.041666666666667, 0.9, 0
3318, 0.041666666666667, 0.95, 0
3319, 0.041666666666667, 1, 0
3320, 0.041666666666667, 1.05, 0
3321, 0.041666666666667, 1.1, 0
3322, 0.041666666666667, 1.15, 0
3323, 0.041666666666667, 1.2, 0
3324, 0.041666666666667, 1.25, 0
3325, 0.041666666666667, 1.3, 0
3326, 0.083333333333333, 0.2, 0
3327, 0.083333333333333, 0.25, 0
3328, 0.083333333333333, 0.3, 0
3329, 0.083333333333333, 0.35, 0
3330, 0.083333333333333, 0.4, 0
3331, 0.083333333333333, 0.45, 0
3332, 0.083333333333333, 0.5, 0
3333, 0.083333333333333, 0.55, 0
3334, 0.083333333333333, 0.6, 0
3335, 0.083333333333333, 0.65, 0
3336, 0.083333333333333, 0.7, 0
3337, 0.083333333333333, 0.75, 0
3338, 0.083333333333333, 0.8, 0
3339, 0.083333333333333, 0.85, 0
3340, 0.083333333333333, 0.9, 0
3341, 0.083333333333333, 0.95, 0
3342, 0.083333333333333, 1, 0
