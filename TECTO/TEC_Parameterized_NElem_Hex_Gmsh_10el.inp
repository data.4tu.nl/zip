12014, 0.33333333333333, 0.45, -0.1
12015, 0.33333333333333, 0.5, -0.1
12016, 0.33333333333333, 0.55, -0.1
12017, 0.33333333333333, 0.6, -0.1
12018, 0.33333333333333, 0.65, -0.1
12019, 0.33333333333333, 0.7, -0.1
12020, 0.33333333333333, 0.75, -0.1
12021, 0.33333333333333, 0.8, -0.1
12022, 0.33333333333333, 0.85, -0.1
12023, 0.33333333333333, 0.9, -0.1
12024, 0.33333333333333, 0.95, -0.1
12025, 0.33333333333333, 1, -0.1
12026, 0.33333333333333, 1.05, -0.1
12027, 0.33333333333333, 1.1, -0.1
12028, 0.33333333333333, 1.15, -0.1
12029, 0.33333333333333, 1.2, -0.1
12030, 0.33333333333333, 1.25, -0.1
12031, 0.33333333333333, 1.3, -0.1
12032, 0.375, 0.2, -0.1
12033, 0.375, 0.25, -0.1
12034, 0.375, 0.3, -0.1
12035, 0.375, 0.35, -0.1
12036, 0.375, 0.4, -0.1
12037, 0.375, 0.45, -0.1
12038, 0.375, 0.5, -0.1
12039, 0.375, 0.55, -0.1
12040, 0.375, 0.6, -0.1
12041, 0.375, 0.65, -0.1
12042, 0.375, 0.7, -0.1
12043, 0.375, 0.75, -0.1
12044, 0.375, 0.8, -0.1
12045, 0.375, 0.85, -0.1
12046, 0.375, 0.9, -0.1
12047, 0.375, 0.95, -0.1
12048, 0.375, 1, -0.1
12049, 0.375, 1.05, -0.1
12050, 0.375, 1.1, -0.1
12051, 0.375, 1.15, -0.1
12052, 0.375, 1.2, -0.1
12053, 0.375, 1.25, -0.1
12054, 0.375, 1.3, -0.1
12055, 0.41666666666667, 0.2, -0.1
12056, 0.41666666666667, 0.25, -0.1
12057, 0.41666666666667, 0.3, -0.1
12058, 0.41666666666667, 0.35, -0.1
12059, 0.41666666666667, 0.4, -0.1
12060, 0.41666666666667, 0.45, -0.1
12061, 0.41666666666667, 0.5, -0.1
12062, 0.41666666666667, 0.55, -0.1
12063, 0.41666666666667, 0.6, -0.1
12064, 0.41666666666667, 0.65, -0.1
12065, 0.41666666666667, 0.7, -0.1
12066, 0.41666666666667, 0.75, -0.1
12067, 0.41666666666667, 0.8, -0.1
12068, 0.41666666666667, 0.85, -0.1
12069, 0.41666666666667, 0.9, -0.1
12070, 0.41666666666667, 0.95, -0.1
12071, 0.41666666666667, 1, -0.1
12072, 0.41666666666667, 1.05, -0.1
12073, 0.41666666666667, 1.1, -0.1
12074, 0.41666666666667, 1.15, -0.1
12075, 0.41666666666667, 1.2, -0.1
12076, 0.41666666666667, 1.25, -0.1
12077, 0.41666666666667, 1.3, -0.1
12078, 0.45833333333333, 0.2, -0.1
12079, 0.45833333333333, 0.25, -0.1
12080, 0.45833333333333, 0.3, -0.1
12081, 0.45833333333333, 0.35, -0.1
12082, 0.45833333333333, 0.4, -0.1
12083, 0.45833333333333, 0.45, -0.1
12084, 0.45833333333333, 0.5, -0.1
12085, 0.45833333333333, 0.55, -0.1
12086, 0.45833333333333, 0.6, -0.1
12087, 0.45833333333333, 0.65, -0.1
12088, 0.45833333333333, 0.7, -0.1
12089, 0.45833333333333, 0.75, -0.1
12090, 0.45833333333333, 0.8, -0.1
12091, 0.45833333333333, 0.85, -0.1
12092, 0.45833333333333, 0.9, -0.1
12093, 0.45833333333333, 0.95, -0.1
12094, 0.45833333333333, 1, -0.1
12095, 0.45833333333333, 1.05, -0.1
12096, 0.45833333333333, 1.1, -0.1
12097, 0.45833333333333, 1.15, -0.1
12098, 0.45833333333333, 1.2, -0.1
12099, 0.45833333333333, 1.25, -0.1
12100, 0.45833333333333, 1.3, -0.1
12101, 0.5, 0.2, -0.1
12102, 0.5, 0.25, -0.1
12103, 0.5, 0.3, -0.1
12104, 0.5, 0.35, -0.1
12105, 0.5, 0.4, -0.1
12106, 0.5, 0.45, -0.1
12107, 0.5, 0.5, -0.1
12108, 0.5, 0.55, -0.1
12109, 0.5, 0.6, -0.1
12110, 0.5, 0.65, -0.1
12111, 0.5, 0.7, -0.1
12112, 0.5, 0.75, -0.1
12113, 0.5, 0.8, -0.1
12114, 0.5, 0.85, -0.1
12115, 0.5, 0.9, -0.1
12116, 0.5, 0.95, -0.1
12117, 0.5, 1, -0.1
12118, 0.5, 1.05, -0.1
12119, 0.5, 1.1, -0.1
12120, 0.5, 1.15, -0.1
12121, 0.5, 1.2, -0.1
12122, 0.5, 1.25, -0.1
12123, 0.5, 1.3, -0.1
12124, 0.54166666666667, 0.2, -0.1
12125, 0.54166666666667, 0.25, -0.1
12126, 0.54166666666667, 0.3, -0.1
12127, 0.54166666666667, 0.35, -0.1
12128, 0.54166666666667, 0.4, -0.1
12129, 0.54166666666667, 0.45, -0.1
12130, 0.54166666666667, 0.5, -0.1
12131, 0.54166666666667, 0.55, -0.1
12132, 0.54166666666667, 0.6, -0.1
12133, 0.54166666666667, 0.65, -0.1
12134, 0.54166666666667, 0.7, -0.1
12135, 0.54166666666667, 0.75, -0.1
12136, 0.54166666666667, 0.8, -0.1
12137, 0.54166666666667, 0.85, -0.1
12138, 0.54166666666667, 0.9, -0.1
12139, 0.54166666666667, 0.95, -0.1
12140, 0.54166666666667, 1, -0.1
12141, 0.54166666666667, 1.05, -0.1
12142, 0.54166666666667, 1.1, -0.1
12143, 0.54166666666667, 1.15, -0.1
12144, 0.54166666666667, 1.2, -0.1
12145, 0.54166666666667, 1.25, -0.1
12146, 0.54166666666667, 1.3, -0.1
12147, 0.58333333333333, 0.2, -0.1
12148, 0.58333333333333, 0.25, -0.1
12149, 0.58333333333333, 0.3, -0.1
12150, 0.58333333333333, 0.35, -0.1
12151, 0.58333333333333, 0.4, -0.1
12152, 0.58333333333333, 0.45, -0.1
12153, 0.58333333333333, 0.5, -0.1
12154, 0.58333333333333, 0.55, -0.1
12155, 0.58333333333333, 0.6, -0.1
12156, 0.58333333333333, 0.65, -0.1
12157, 0.58333333333333, 0.7, -0.1
12158, 0.58333333333333, 0.75, -0.1
12159, 0.58333333333333, 0.8, -0.1
12160, 0.58333333333333, 0.85, -0.1
12161, 0.58333333333333, 0.9, -0.1
12162, 0.58333333333333, 0.95, -0.1
12163, 0.58333333333333, 1, -0.1
12164, 0.58333333333333, 1.05, -0.1
12165, 0.58333333333333, 1.1, -0.1
12166, 0.58333333333333, 1.15, -0.1
12167, 0.58333333333333, 1.2, -0.1
12168, 0.58333333333333, 1.25, -0.1
12169, 0.58333333333333, 1.3, -0.1
12170, 0.625, 0.2, -0.1
12171, 0.625, 0.25, -0.1
12172, 0.625, 0.3, -0.1
12173, 0.625, 0.35, -0.1
12174, 0.625, 0.4, -0.1
12175, 0.625, 0.45, -0.1
12176, 0.625, 0.5, -0.1
12177, 0.625, 0.55, -0.1
12178, 0.625, 0.6, -0.1
12179, 0.625, 0.65, -0.1
12180, 0.625, 0.7, -0.1
12181, 0.625, 0.75, -0.1
12182, 0.625, 0.8, -0.1
12183, 0.625, 0.85, -0.1
12184, 0.625, 0.9, -0.1
12185, 0.625, 0.95, -0.1
12186, 0.625, 1, -0.1
12187, 0.625, 1.05, -0.1
12188, 0.625, 1.1, -0.1
12189, 0.625, 1.15, -0.1
12190, 0.625, 1.2, -0.1
12191, 0.625, 1.25, -0.1
12192, 0.625, 1.3, -0.1
12193, 0.66666666666667, 0.2, -0.1
12194, 0.66666666666667, 0.25, -0.1
12195, 0.66666666666667, 0.3, -0.1
12196, 0.66666666666667, 0.35, -0.1
12197, 0.66666666666667, 0.4, -0.1
12198, 0.66666666666667, 0.45, -0.1
12199, 0.66666666666667, 0.5, -0.1
12200, 0.66666666666667, 0.55, -0.1
12201, 0.66666666666667, 0.6, -0.1
12202, 0.66666666666667, 0.65, -0.1
12203, 0.66666666666667, 0.7, -0.1
12204, 0.66666666666667, 0.75, -0.1
12205, 0.66666666666667, 0.8, -0.1
12206, 0.66666666666667, 0.85, -0.1
12207, 0.66666666666667, 0.9, -0.1
12208, 0.66666666666667, 0.95, -0.1
12209, 0.66666666666667, 1, -0.1
12210, 0.66666666666667, 1.05, -0.1
12211, 0.66666666666667, 1.1, -0.1
12212, 0.66666666666667, 1.15, -0.1
12213, 0.66666666666667, 1.2, -0.1
12214, 0.66666666666667, 1.25, -0.1
12215, 0.66666666666667, 1.3, -0.1
12216, 0.70833333333333, 0.2, -0.1
12217, 0.70833333333333, 0.25, -0.1
12218, 0.70833333333333, 0.3, -0.1
12219, 0.70833333333333, 0.35, -0.1
12220, 0.70833333333333, 0.4, -0.1
12221, 0.70833333333333, 0.45, -0.1
12222, 0.70833333333333, 0.5, -0.1
12223, 0.70833333333333, 0.55, -0.1
12224, 0.70833333333333, 0.6, -0.1
12225, 0.70833333333333, 0.65, -0.1
12226, 0.70833333333333, 0.7, -0.1
12227, 0.70833333333333, 0.75, -0.1
12228, 0.70833333333333, 0.8, -0.1
12229, 0.70833333333333, 0.85, -0.1
12230, 0.70833333333333, 0.9, -0.1
12231, 0.70833333333333, 0.95, -0.1
12232, 0.70833333333333, 1, -0.1
12233, 0.70833333333333, 1.05, -0.1
12234, 0.70833333333333, 1.1, -0.1
12235, 0.70833333333333, 1.15, -0.1
12236, 0.70833333333333, 1.2, -0.1
12237, 0.70833333333333, 1.25, -0.1
12238, 0.70833333333333, 1.3, -0.1
12239, 0.75, 0.2, -0.1
12240, 0.75, 0.25, -0.1
12241, 0.75, 0.3, -0.1
12242, 0.75, 0.35, -0.1
12243, 0.75, 0.4, -0.1
12244, 0.75, 0.45, -0.1
12245, 0.75, 0.5, -0.1
12246, 0.75, 0.55, -0.1
12247, 0.75, 0.6, -0.1
12248, 0.75, 0.65, -0.1
12249, 0.75, 0.7, -0.1
12250, 0.75, 0.75, -0.1
12251, 0.75, 0.8, -0.1
12252, 0.75, 0.85, -0.1
12253, 0.75, 0.9, -0.1
12254, 0.75, 0.95, -0.1
12255, 0.75, 1, -0.1
12256, 0.75, 1.05, -0.1
12257, 0.75, 1.1, -0.1
12258, 0.75, 1.15, -0.1
12259, 0.75, 1.2, -0.1
12260, 0.75, 1.25, -0.1
12261, 0.75, 1.3, -0.1
12262, 0.79166666666667, 0.2, -0.1
12263, 0.79166666666667, 0.25, -0.1
12264, 0.79166666666667, 0.3, -0.1
12265, 0.79166666666667, 0.35, -0.1
12266, 0.79166666666667, 0.4, -0.1
12267, 0.79166666666667, 0.45, -0.1
12268, 0.79166666666667, 0.5, -0.1
12269, 0.79166666666667, 0.55, -0.1
12270, 0.79166666666667, 0.6, -0.1
12271, 0.79166666666667, 0.65, -0.1
12272, 0.79166666666667, 0.7, -0.1
12273, 0.79166666666667, 0.75, -0.1
12274, 0.79166666666667, 0.8, -0.1
12275, 0.79166666666667, 0.85, -0.1
12276, 0.79166666666667, 0.9, -0.1
12277, 0.79166666666667, 0.95, -0.1
12278, 0.79166666666667, 1, -0.1
12279, 0.79166666666667, 1.05, -0.1
12280, 0.79166666666667, 1.1, -0.1
12281, 0.79166666666667, 1.15, -0.1
12282, 0.79166666666667, 1.2, -0.1
12283, 0.79166666666667, 1.25, -0.1
12284, 0.79166666666667, 1.3, -0.1
12285, 0.83333333333333, 0.2, -0.1
12286, 0.83333333333333, 0.25, -0.1
12287, 0.83333333333333, 0.3, -0.1
12288, 0.83333333333333, 0.35, -0.1
12289, 0.83333333333333, 0.4, -0.1
12290, 0.83333333333333, 0.45, -0.1
12291, 0.83333333333333, 0.5, -0.1
12292, 0.83333333333333, 0.55, -0.1
12293, 0.83333333333333, 0.6, -0.1
12294, 0.83333333333333, 0.65, -0.1
12295, 0.83333333333333, 0.7, -0.1
12296, 0.83333333333333, 0.75, -0.1
12297, 0.83333333333333, 0.8, -0.1
12298, 0.83333333333333, 0.85, -0.1
12299, 0.83333333333333, 0.9, -0.1
12300, 0.83333333333333, 0.95, -0.1
12301, 0.83333333333333, 1, -0.1
12302, 0.83333333333333, 1.05, -0.1
12303, 0.83333333333333, 1.1, -0.1
12304, 0.83333333333333, 1.15, -0.1
12305, 0.83333333333333, 1.2, -0.1
12306, 0.83333333333333, 1.25, -0.1
12307, 0.83333333333333, 1.3, -0.1
12308, 0.875, 0.2, -0.1
12309, 0.875, 0.25, -0.1
12310, 0.875, 0.3, -0.1
12311, 0.875, 0.35, -0.1
12312, 0.875, 0.4, -0.1
12313, 0.875, 0.45, -0.1
12314, 0.875, 0.5, -0.1
12315, 0.875, 0.55, -0.1
12316, 0.875, 0.6, -0.1
12317, 0.875, 0.65, -0.1
12318, 0.875, 0.7, -0.1
12319, 0.875, 0.75, -0.1
12320, 0.875, 0.8, -0.1
12321, 0.875, 0.85, -0.1
12322, 0.875, 0.9, -0.1
12323, 0.875, 0.95, -0.1
12324, 0.875, 1, -0.1
12325, 0.875, 1.05, -0.1
12326, 0.875, 1.1, -0.1
12327, 0.875, 1.15, -0.1
12328, 0.875, 1.2, -0.1
12329, 0.875, 1.25, -0.1
12330, 0.875, 1.3, -0.1
12331, 0.91666666666667, 0.2, -0.1
12332, 0.91666666666667, 0.25, -0.1
12333, 0.91666666666667, 0.3, -0.1
12334, 0.91666666666667, 0.35, -0.1
12335, 0.91666666666667, 0.4, -0.1
12336, 0.91666666666667, 0.45, -0.1
12337, 0.91666666666667, 0.5, -0.1
12338, 0.91666666666667, 0.55, -0.1
12339, 0.91666666666667, 0.6, -0.1
12340, 0.91666666666667, 0.65, -0.1
12341, 0.91666666666667, 0.7, -0.1
12342, 0.91666666666667, 0.75, -0.1
12343, 0.91666666666667, 0.8, -0.1
12344, 0.91666666666667, 0.85, -0.1
12345, 0.91666666666667, 0.9, -0.1
12346, 0.91666666666667, 0.95, -0.1
12347, 0.91666666666667, 1, -0.1
12348, 0.91666666666667, 1.05, -0.1
12349, 0.91666666666667, 1.1, -0.1
12350, 0.91666666666667, 1.15, -0.1
12351, 0.91666666666667, 1.2, -0.1
12352, 0.91666666666667, 1.25, -0.1
12353, 0.91666666666667, 1.3, -0.1
12354, 0.95833333333333, 0.2, -0.1
12355, 0.95833333333333, 0.25, -0.1
12356, 0.95833333333333, 0.3, -0.1
12357, 0.95833333333333, 0.35, -0.1
12358, 0.95833333333333, 0.4, -0.1
12359, 0.95833333333333, 0.45, -0.1
12360, 0.95833333333333, 0.5, -0.1
12361, 0.95833333333333, 0.55, -0.1
12362, 0.95833333333333, 0.6, -0.1
12363, 0.95833333333333, 0.65, -0.1
12364, 0.95833333333333, 0.7, -0.1
12365, 0.95833333333333, 0.75, -0.1
12366, 0.95833333333333, 0.8, -0.1
12367, 0.95833333333333, 0.85, -0.1
12368, 0.95833333333333, 0.9, -0.1
12369, 0.95833333333333, 0.95, -0.1
12370, 0.95833333333333, 1, -0.1
12371, 0.95833333333333, 1.05, -0.1
12372, 0.95833333333333, 1.1, -0.1
12373, 0.95833333333333, 1.15, -0.1
12374, 0.95833333333333, 1.2, -0.1
12375, 0.95833333333333, 1.25, -0.1
12376, 0.95833333333333, 1.3, -0.1
12377, 0.020833333333333, 0.2, -0.1
12378, 0.041666666666667, 0.175, -0.1
12379, 0.020833333333333, 0.25, -0.1
12380, 0.041666666666667, 0.225, -0.1
12381, 0.020833333333333, 0.3, -0.1
12382, 0.041666666666667, 0.275, -0.1
12383, 0.020833333333333, 0.35, -0.1
12384, 0.041666666666667, 0.325, -0.1
12385, 0.020833333333333, 0.4, -0.1
12386, 0.041666666666667, 0.375, -0.1
12387, 0.020833333333333, 0.45, -0.1
12388, 0.041666666666667, 0.425, -0.1
12389, 0.020833333333333, 0.5, -0.1
12390, 0.041666666666667, 0.475, -0.1
12391, 0.020833333333333, 0.55, -0.1
12392, 0.041666666666667, 0.525, -0.1
12393, 0.020833333333333, 0.6, -0.1
12394, 0.041666666666667, 0.575, -0.1
12395, 0.020833333333333, 0.65, -0.1
12396, 0.041666666666667, 0.625, -0.1
12397, 0.020833333333333, 0.7, -0.1
12398, 0.041666666666667, 0.675, -0.1
12399, 0.020833333333333, 0.75, -0.1
12400, 0.041666666666667, 0.725, -0.1
12401, 0.020833333333333, 0.8, -0.1
12402, 0.041666666666667, 0.775, -0.1
12403, 0.020833333333333, 0.85, -0.1
12404, 0.041666666666667, 0.825, -0.1
12405, 0.020833333333333, 0.9, -0.1
12406, 0.041666666666667, 0.875, -0.1
12407, 0.020833333333333, 0.95, -0.1
12408, 0.041666666666667, 0.925, -0.1
12409, 0.020833333333333, 1, -0.1
12410, 0.041666666666667, 0.975, -0.1
12411, 0.020833333333333, 1.05, -0.1
12412, 0.041666666666667, 1.025, -0.1
12413, 0.020833333333333, 1.1, -0.1
12414, 0.041666666666667, 1.075, -0.1
12415, 0.020833333333333, 1.15, -0.1
12416, 0.041666666666667, 1.125, -0.1
12417, 0.020833333333333, 1.2, -0.1
12418, 0.041666666666667, 1.175, -0.1
12419, 0.020833333333333, 1.25, -0.1
12420, 0.041666666666667, 1.225, -0.1
12421, 0.020833333333333, 1.3, -0.1
12422, 0.041666666666667, 1.275, -0.1
12423, 0.041666666666667, 1.325, -0.1
12424, 0.0625, 0.2, -0.1
12425, 0.083333333333333, 0.175, -0.1
12426, 0.0625, 0.25, -0.1
12427, 0.083333333333333, 0.225, -0.1
12428, 0.0625, 0.3, -0.1
12429, 0.083333333333333, 0.275, -0.1
12430, 0.0625, 0.35, -0.1
12431, 0.083333333333333, 0.325, -0.1
12432, 0.0625, 0.4, -0.1
12433, 0.083333333333333, 0.375, -0.1
12434, 0.0625, 0.45, -0.1
12435, 0.083333333333333, 0.425, -0.1
12436, 0.0625, 0.5, -0.1
12437, 0.083333333333333, 0.475, -0.1
12438, 0.0625, 0.55, -0.1
12439, 0.083333333333333, 0.525, -0.1
12440, 0.0625, 0.6, -0.1
12441, 0.083333333333333, 0.575, -0.1
12442, 0.0625, 0.65, -0.1
12443, 0.083333333333333, 0.625, -0.1
12444, 0.0625, 0.7, -0.1
12445, 0.083333333333333, 0.675, -0.1
12446, 0.0625, 0.75, -0.1
12447, 0.083333333333333, 0.725, -0.1
12448, 0.0625, 0.8, -0.1
12449, 0.083333333333333, 0.775, -0.1
12450, 0.0625, 0.85, -0.1
12451, 0.083333333333333, 0.825, -0.1
12452, 0.0625, 0.9, -0.1
12453, 0.083333333333333, 0.875, -0.1
12454, 0.0625, 0.95, -0.1
12455, 0.083333333333333, 0.925, -0.1
12456, 0.0625, 1, -0.1
12457, 0.083333333333333, 0.975, -0.1
12458, 0.0625, 1.05, -0.1
12459, 0.083333333333333, 1.025, -0.1
12460, 0.0625, 1.1, -0.1
12461, 0.083333333333333, 1.075, -0.1
12462, 0.0625, 1.15, -0.1
12463, 0.083333333333333, 1.125, -0.1
12464, 0.0625, 1.2, -0.1
12465, 0.083333333333333, 1.175, -0.1
12466, 0.0625, 1.25, -0.1
12467, 0.083333333333333, 1.225, -0.1
12468, 0.0625, 1.3, -0.1
12469, 0.083333333333333, 1.275, -0.1
12470, 0.083333333333333, 1.325, -0.1
12471, 0.10416666666667, 0.2, -0.1
12472, 0.125, 0.175, -0.1
12473, 0.10416666666667, 0.25, -0.1
12474, 0.125, 0.225, -0.1
12475, 0.10416666666667, 0.3, -0.1
12476, 0.125, 0.275, -0.1
12477, 0.10416666666667, 0.35, -0.1
12478, 0.125, 0.325, -0.1
12479, 0.10416666666667, 0.4, -0.1
12480, 0.125, 0.375, -0.1
12481, 0.10416666666667, 0.45, -0.1
12482, 0.125, 0.425, -0.1
12483, 0.10416666666667, 0.5, -0.1
12484, 0.125, 0.475, -0.1
12485, 0.10416666666667, 0.55, -0.1
12486, 0.125, 0.525, -0.1
12487, 0.10416666666667, 0.6, -0.1
12488, 0.125, 0.575, -0.1
12489, 0.10416666666667, 0.65, -0.1
12490, 0.125, 0.625, -0.1
12491, 0.10416666666667, 0.7, -0.1
12492, 0.125, 0.675, -0.1
12493, 0.10416666666667, 0.75, -0.1
12494, 0.125, 0.725, -0.1
12495, 0.10416666666667, 0.8, -0.1
12496, 0.125, 0.775, -0.1
12497, 0.10416666666667, 0.85, -0.1
12498, 0.125, 0.825, -0.1
12499, 0.10416666666667, 0.9, -0.1
12500, 0.125, 0.875, -0.1
12501, 0.10416666666667, 0.95, -0.1
12502, 0.125, 0.925, -0.1
12503, 0.10416666666667, 1, -0.1
12504, 0.125, 0.975, -0.1
12505, 0.10416666666667, 1.05, -0.1
12506, 0.125, 1.025, -0.1
12507, 0.10416666666667, 1.1, -0.1
12508, 0.125, 1.075, -0.1
12509, 0.10416666666667, 1.15, -0.1
12510, 0.125, 1.125, -0.1
12511, 0.10416666666667, 1.2, -0.1
12512, 0.125, 1.175, -0.1
12513, 0.10416666666667, 1.25, -0.1
12514, 0.125, 1.225, -0.1
12515, 0.10416666666667, 1.3, -0.1
12516, 0.125, 1.275, -0.1
12517, 0.125, 1.325, -0.1
12518, 0.14583333333333, 0.2, -0.1
12519, 0.16666666666667, 0.175, -0.1
12520, 0.14583333333333, 0.25, -0.1
12521, 0.16666666666667, 0.225, -0.1
12522, 0.14583333333333, 0.3, -0.1
12523, 0.16666666666667, 0.275, -0.1
12524, 0.14583333333333, 0.35, -0.1
12525, 0.16666666666667, 0.325, -0.1
12526, 0.14583333333333, 0.4, -0.1
12527, 0.16666666666667, 0.375, -0.1
12528, 0.14583333333333, 0.45, -0.1
12529, 0.16666666666667, 0.425, -0.1
12530, 0.14583333333333, 0.5, -0.1
12531, 0.16666666666667, 0.475, -0.1
12532, 0.14583333333333, 0.55, -0.1
12533, 0.16666666666667, 0.525, -0.1
12534, 0.14583333333333, 0.6, -0.1
12535, 0.16666666666667, 0.575, -0.1
12536, 0.14583333333333, 0.65, -0.1
12537, 0.16666666666667, 0.625, -0.1
12538, 0.14583333333333, 0.7, -0.1
12539, 0.16666666666667, 0.675, -0.1
12540, 0.14583333333333, 0.75, -0.1
12541, 0.16666666666667, 0.725, -0.1
12542, 0.14583333333333, 0.8, -0.1
12543, 0.16666666666667, 0.775, -0.1
12544, 0.14583333333333, 0.85, -0.1
12545, 0.16666666666667, 0.825, -0.1
12546, 0.14583333333333, 0.9, -0.1
12547, 0.16666666666667, 0.875, -0.1
12548, 0.14583333333333, 0.95, -0.1
12549, 0.16666666666667, 0.925, -0.1
12550, 0.14583333333333, 1, -0.1
12551, 0.16666666666667, 0.975, -0.1
12552, 0.14583333333333, 1.05, -0.1
12553, 0.16666666666667, 1.025, -0.1
12554, 0.14583333333333, 1.1, -0.1
12555, 0.16666666666667, 1.075, -0.1
12556, 0.14583333333333, 1.15, -0.1
12557, 0.16666666666667, 1.125, -0.1
12558, 0.14583333333333, 1.2, -0.1
12559, 0.16666666666667, 1.175, -0.1
12560, 0.14583333333333, 1.25, -0.1
12561, 0.16666666666667, 1.225, -0.1
12562, 0.14583333333333, 1.3, -0.1
12563, 0.16666666666667, 1.275, -0.1
12564, 0.16666666666667, 1.325, -0.1
12565, 0.1875, 0.2, -0.1
12566, 0.20833333333333, 0.175, -0.1
12567, 0.1875, 0.25, -0.1
12568, 0.20833333333333, 0.225, -0.1
12569, 0.1875, 0.3, -0.1
12570, 0.20833333333333, 0.275, -0.1
12571, 0.1875, 0.35, -0.1
12572, 0.20833333333333, 0.325, -0.1
12573, 0.1875, 0.4, -0.1
12574, 0.20833333333333, 0.375, -0.1
12575, 0.1875, 0.45, -0.1
12576, 0.20833333333333, 0.425, -0.1
12577, 0.1875, 0.5, -0.1
12578, 0.20833333333333, 0.475, -0.1
12579, 0.1875, 0.55, -0.1
12580, 0.20833333333333, 0.525, -0.1
12581, 0.1875, 0.6, -0.1
12582, 0.20833333333333, 0.575, -0.1
12583, 0.1875, 0.65, -0.1
12584, 0.20833333333333, 0.625, -0.1
12585, 0.1875, 0.7, -0.1
12586, 0.20833333333333, 0.675, -0.1
12587, 0.1875, 0.75, -0.1
12588, 0.20833333333333, 0.725, -0.1
12589, 0.1875, 0.8, -0.1
12590, 0.20833333333333, 0.775, -0.1
12591, 0.1875, 0.85, -0.1
12592, 0.20833333333333, 0.825, -0.1
12593, 0.1875, 0.9, -0.1
12594, 0.20833333333333, 0.875, -0.1
12595, 0.1875, 0.95, -0.1
12596, 0.20833333333333, 0.925, -0.1
12597, 0.1875, 1, -0.1
12598, 0.20833333333333, 0.975, -0.1
12599, 0.1875, 1.05, -0.1
12600, 0.20833333333333, 1.025, -0.1
12601, 0.1875, 1.1, -0.1
12602, 0.20833333333333, 1.075, -0.1
12603, 0.1875, 1.15, -0.1
12604, 0.20833333333333, 1.125, -0.1
12605, 0.1875, 1.2, -0.1
12606, 0.20833333333333, 1.175, -0.1
12607, 0.1875, 1.25, -0.1
12608, 0.20833333333333, 1.225, -0.1
12609, 0.1875, 1.3, -0.1
12610, 0.20833333333333, 1.275, -0.1
12611, 0.20833333333333, 1.325, -0.1
12612, 0.22916666666667, 0.2, -0.1
12613, 0.25, 0.175, -0.1
12614, 0.22916666666667, 0.25, -0.1
12615, 0.25, 0.225, -0.1
12616, 0.22916666666667, 0.3, -0.1
12617, 0.25, 0.275, -0.1
12618, 0.22916666666667, 0.35, -0.1
12619, 0.25, 0.325, -0.1
12620, 0.22916666666667, 0.4, -0.1
12621, 0.25, 0.375, -0.1
12622, 0.22916666666667, 0.45, -0.1
12623, 0.25, 0.425, -0.1
12624, 0.22916666666667, 0.5, -0.1
12625, 0.25, 0.475, -0.1
12626, 0.22916666666667, 0.55, -0.1
12627, 0.25, 0.525, -0.1
12628, 0.22916666666667, 0.6, -0.1
12629, 0.25, 0.575, -0.1
12630, 0.22916666666667, 0.65, -0.1
12631, 0.25, 0.625, -0.1
12632, 0.22916666666667, 0.7, -0.1
12633, 0.25, 0.675, -0.1
12634, 0.22916666666667, 0.75, -0.1
12635, 0.25, 0.725, -0.1
12636, 0.22916666666667, 0.8, -0.1
12637, 0.25, 0.775, -0.1
12638, 0.22916666666667, 0.85, -0.1
12639, 0.25, 0.825, -0.1
12640, 0.22916666666667, 0.9, -0.1
12641, 0.25, 0.875, -0.1
12642, 0.22916666666667, 0.95, -0.1
12643, 0.25, 0.925, -0.1
12644, 0.22916666666667, 1, -0.1
12645, 0.25, 0.975, -0.1
12646, 0.22916666666667, 1.05, -0.1
12647, 0.25, 1.025, -0.1
12648, 0.22916666666667, 1.1, -0.1
12649, 0.25, 1.075, -0.1
12650, 0.22916666666667, 1.15, -0.1
12651, 0.25, 1.125, -0.1
12652, 0.22916666666667, 1.2, -0.1
12653, 0.25, 1.175, -0.1
12654, 0.22916666666667, 1.25, -0.1
12655, 0.25, 1.225, -0.1
12656, 0.22916666666667, 1.3, -0.1
12657, 0.25, 1.275, -0.1
12658, 0.25, 1.325, -0.1
12659, 0.27083333333333, 0.2, -0.1
12660, 0.29166666666667, 0.175, -0.1
12661, 0.27083333333333, 0.25, -0.1
12662, 0.29166666666667, 0.225, -0.1
12663, 0.27083333333333, 0.3, -0.1
12664, 0.29166666666667, 0.275, -0.1
12665, 0.27083333333333, 0.35, -0.1
12666, 0.29166666666667, 0.325, -0.1
12667, 0.27083333333333, 0.4, -0.1
12668, 0.29166666666667, 0.375, -0.1
12669, 0.27083333333333, 0.45, -0.1
12670, 0.29166666666667, 0.425, -0.1
12671, 0.27083333333333, 0.5, -0.1
12672, 0.29166666666667, 0.475, -0.1
12673, 0.27083333333333, 0.55, -0.1
12674, 0.29166666666667, 0.525, -0.1
12675, 0.27083333333333, 0.6, -0.1
12676, 0.29166666666667, 0.575, -0.1
12677, 0.27083333333333, 0.65, -0.1
12678, 0.29166666666667, 0.625, -0.1
12679, 0.27083333333333, 0.7, -0.1
12680, 0.29166666666667, 0.675, -0.1
12681, 0.27083333333333, 0.75, -0.1
12682, 0.29166666666667, 0.725, -0.1
12683, 0.27083333333333, 0.8, -0.1
12684, 0.29166666666667, 0.775, -0.1
12685, 0.27083333333333, 0.85, -0.1
12686, 0.29166666666667, 0.825, -0.1
12687, 0.27083333333333, 0.9, -0.1
12688, 0.29166666666667, 0.875, -0.1
12689, 0.27083333333333, 0.95, -0.1
12690, 0.29166666666667, 0.925, -0.1
12691, 0.27083333333333, 1, -0.1
12692, 0.29166666666667, 0.975, -0.1
12693, 0.27083333333333, 1.05, -0.1
12694, 0.29166666666667, 1.025, -0.1
12695, 0.27083333333333, 1.1, -0.1
12696, 0.29166666666667, 1.075, -0.1
12697, 0.27083333333333, 1.15, -0.1
12698, 0.29166666666667, 1.125, -0.1
12699, 0.27083333333333, 1.2, -0.1
12700, 0.29166666666667, 1.175, -0.1
12701, 0.27083333333333, 1.25, -0.1
12702, 0.29166666666667, 1.225, -0.1
12703, 0.27083333333333, 1.3, -0.1
12704, 0.29166666666667, 1.275, -0.1
12705, 0.29166666666667, 1.325, -0.1
12706, 0.3125, 0.2, -0.1
12707, 0.33333333333333, 0.175, -0.1
12708, 0.3125, 0.25, -0.1
12709, 0.33333333333333, 0.225, -0.1
12710, 0.3125, 0.3, -0.1
12711, 0.33333333333333, 0.275, -0.1
12712, 0.3125, 0.35, -0.1
12713, 0.33333333333333, 0.325, -0.1
12714, 0.3125, 0.4, -0.1
12715, 0.33333333333333, 0.375, -0.1
12716, 0.3125, 0.45, -0.1
12717, 0.33333333333333, 0.425, -0.1
12718, 0.3125, 0.5, -0.1
12719, 0.33333333333333, 0.475, -0.1
12720, 0.3125, 0.55, -0.1
12721, 0.33333333333333, 0.525, -0.1
12722, 0.3125, 0.6, -0.1
12723, 0.33333333333333, 0.575, -0.1
12724, 0.3125, 0.65, -0.1
12725, 0.33333333333333, 0.625, -0.1
12726, 0.3125, 0.7, -0.1
12727, 0.33333333333333, 0.675, -0.1
12728, 0.3125, 0.75, -0.1
12729, 0.33333333333333, 0.725, -0.1
12730, 0.3125, 0.8, -0.1
12731, 0.33333333333333, 0.775, -0.1
12732, 0.3125, 0.85, -0.1
12733, 0.33333333333333, 0.825, -0.1
12734, 0.3125, 0.9, -0.1
12735, 0.33333333333333, 0.875, -0.1
12736, 0.3125, 0.95, -0.1
12737, 0.33333333333333, 0.925, -0.1
12738, 0.3125, 1, -0.1
12739, 0.33333333333333, 0.975, -0.1
12740, 0.3125, 1.05, -0.1
12741, 0.33333333333333, 1.025, -0.1
12742, 0.3125, 1.1, -0.1
12743, 0.33333333333333, 1.075, -0.1
12744, 0.3125, 1.15, -0.1
12745, 0.33333333333333, 1.125, -0.1
12746, 0.3125, 1.2, -0.1
12747, 0.33333333333333, 1.175, -0.1
12748, 0.3125, 1.25, -0.1
12749, 0.33333333333333, 1.225, -0.1
12750, 0.3125, 1.3, -0.1
12751, 0.33333333333333, 1.275, -0.1
12752, 0.33333333333333, 1.325, -0.1
12753, 0.35416666666667, 0.2, -0.1
12754, 0.375, 0.175, -0.1
12755, 0.35416666666667, 0.25, -0.1
12756, 0.375, 0.225, -0.1
12757, 0.35416666666667, 0.3, -0.1
12758, 0.375, 0.275, -0.1
12759, 0.35416666666667, 0.35, -0.1
12760, 0.375, 0.325, -0.1
12761, 0.35416666666667, 0.4, -0.1
12762, 0.375, 0.375, -0.1
12763, 0.35416666666667, 0.45, -0.1
12764, 0.375, 0.425, -0.1
12765, 0.35416666666667, 0.5, -0.1
12766, 0.375, 0.475, -0.1
12767, 0.35416666666667, 0.55, -0.1
12768, 0.375, 0.525, -0.1
12769, 0.35416666666667, 0.6, -0.1
12770, 0.375, 0.575, -0.1
12771, 0.35416666666667, 0.65, -0.1
12772, 0.375, 0.625, -0.1
12773, 0.35416666666667, 0.7, -0.1
12774, 0.375, 0.675, -0.1
12775, 0.35416666666667, 0.75, -0.1
12776, 0.375, 0.725, -0.1
12777, 0.35416666666667, 0.8, -0.1
12778, 0.375, 0.775, -0.1
12779, 0.35416666666667, 0.85, -0.1
12780, 0.375, 0.825, -0.1
12781, 0.35416666666667, 0.9, -0.1
12782, 0.375, 0.875, -0.1
12783, 0.35416666666667, 0.95, -0.1
12784, 0.375, 0.925, -0.1
12785, 0.35416666666667, 1, -0.1
12786, 0.375, 0.975, -0.1
12787, 0.35416666666667, 1.05, -0.1
12788, 0.375, 1.025, -0.1
12789, 0.35416666666667, 1.1, -0.1
12790, 0.375, 1.075, -0.1
12791, 0.35416666666667, 1.15, -0.1
12792, 0.375, 1.125, -0.1
12793, 0.35416666666667, 1.2, -0.1
12794, 0.375, 1.175, -0.1
12795, 0.35416666666667, 1.25, -0.1
12796, 0.375, 1.225, -0.1
12797, 0.35416666666667, 1.3, -0.1
12798, 0.375, 1.275, -0.1
12799, 0.375, 1.325, -0.1
12800, 0.39583333333333, 0.2, -0.1
12801, 0.41666666666667, 0.175, -0.1
12802, 0.39583333333333, 0.25, -0.1
12803, 0.41666666666667, 0.225, -0.1
12804, 0.39583333333333, 0.3, -0.1
12805, 0.41666666666667, 0.275, -0.1
12806, 0.39583333333333, 0.35, -0.1
12807, 0.41666666666667, 0.325, -0.1
12808, 0.39583333333333, 0.4, -0.1
12809, 0.41666666666667, 0.375, -0.1
12810, 0.39583333333333, 0.45, -0.1
12811, 0.41666666666667, 0.425, -0.1
12812, 0.39583333333333, 0.5, -0.1
12813, 0.41666666666667, 0.475, -0.1
12814, 0.39583333333333, 0.55, -0.1
12815, 0.41666666666667, 0.525, -0.1
12816, 0.39583333333333, 0.6, -0.1
12817, 0.41666666666667, 0.575, -0.1
12818, 0.39583333333333, 0.65, -0.1
12819, 0.41666666666667, 0.625, -0.1
12820, 0.39583333333333, 0.7, -0.1
12821, 0.41666666666667, 0.675, -0.1
12822, 0.39583333333333, 0.75, -0.1
12823, 0.41666666666667, 0.725, -0.1
12824, 0.39583333333333, 0.8, -0.1
12825, 0.41666666666667, 0.775, -0.1
12826, 0.39583333333333, 0.85, -0.1
12827, 0.41666666666667, 0.825, -0.1
12828, 0.39583333333333, 0.9, -0.1
12829, 0.41666666666667, 0.875, -0.1
12830, 0.39583333333333, 0.95, -0.1
12831, 0.41666666666667, 0.925, -0.1
12832, 0.39583333333333, 1, -0.1
12833, 0.41666666666667, 0.975, -0.1
12834, 0.39583333333333, 1.05, -0.1
12835, 0.41666666666667, 1.025, -0.1
12836, 0.39583333333333, 1.1, -0.1
12837, 0.41666666666667, 1.075, -0.1
12838, 0.39583333333333, 1.15, -0.1
12839, 0.41666666666667, 1.125, -0.1
12840, 0.39583333333333, 1.2, -0.1
12841, 0.41666666666667, 1.175, -0.1
12842, 0.39583333333333, 1.25, -0.1
12843, 0.41666666666667, 1.225, -0.1
12844, 0.39583333333333, 1.3, -0.1
12845, 0.41666666666667, 1.275, -0.1
12846, 0.41666666666667, 1.325, -0.1
12847, 0.4375, 0.2, -0.1
12848, 0.45833333333333, 0.175, -0.1
12849, 0.4375, 0.25, -0.1
12850, 0.45833333333333, 0.225, -0.1
12851, 0.4375, 0.3, -0.1
12852, 0.45833333333333, 0.275, -0.1
12853, 0.4375, 0.35, -0.1
12854, 0.45833333333333, 0.325, -0.1
12855, 0.4375, 0.4, -0.1
12856, 0.45833333333333, 0.375, -0.1
12857, 0.4375, 0.45, -0.1
12858, 0.45833333333333, 0.425, -0.1
12859, 0.4375, 0.5, -0.1
12860, 0.45833333333333, 0.475, -0.1
12861, 0.4375, 0.55, -0.1
12862, 0.45833333333333, 0.525, -0.1
12863, 0.4375, 0.6, -0.1
12864, 0.45833333333333, 0.575, -0.1
12865, 0.4375, 0.65, -0.1
12866, 0.45833333333333, 0.625, -0.1
12867, 0.4375, 0.7, -0.1
12868, 0.45833333333333, 0.675, -0.1
12869, 0.4375, 0.75, -0.1
12870, 0.45833333333333, 0.725, -0.1
12871, 0.4375, 0.8, -0.1
12872, 0.45833333333333, 0.775, -0.1
12873, 0.4375, 0.85, -0.1
12874, 0.45833333333333, 0.825, -0.1
12875, 0.4375, 0.9, -0.1
12876, 0.45833333333333, 0.875, -0.1
12877, 0.4375, 0.95, -0.1
12878, 0.45833333333333, 0.925, -0.1
12879, 0.4375, 1, -0.1
12880, 0.45833333333333, 0.975, -0.1
12881, 0.4375, 1.05, -0.1
12882, 0.45833333333333, 1.025, -0.1
12883, 0.4375, 1.1, -0.1
12884, 0.45833333333333, 1.075, -0.1
12885, 0.4375, 1.15, -0.1
12886, 0.45833333333333, 1.125, -0.1
12887, 0.4375, 1.2, -0.1
12888, 0.45833333333333, 1.175, -0.1
12889, 0.4375, 1.25, -0.1
12890, 0.45833333333333, 1.225, -0.1
12891, 0.4375, 1.3, -0.1
12892, 0.45833333333333, 1.275, -0.1
12893, 0.45833333333333, 1.325, -0.1
12894, 0.47916666666667, 0.2, -0.1
12895, 0.5, 0.175, -0.1
12896, 0.47916666666667, 0.25, -0.1
12897, 0.5, 0.225, -0.1
12898, 0.47916666666667, 0.3, -0.1
12899, 0.5, 0.275, -0.1
12900, 0.47916666666667, 0.35, -0.1
12901, 0.5, 0.325, -0.1
12902, 0.47916666666667, 0.4, -0.1
12903, 0.5, 0.375, -0.1
12904, 0.47916666666667, 0.45, -0.1
12905, 0.5, 0.425, -0.1
12906, 0.47916666666667, 0.5, -0.1
12907, 0.5, 0.475, -0.1
12908, 0.47916666666667, 0.55, -0.1
12909, 0.5, 0.525, -0.1
12910, 0.47916666666667, 0.6, -0.1
12911, 0.5, 0.575, -0.1
12912, 0.47916666666667, 0.65, -0.1
12913, 0.5, 0.625, -0.1
12914, 0.47916666666667, 0.7, -0.1
12915, 0.5, 0.675, -0.1
12916, 0.47916666666667, 0.75, -0.1
12917, 0.5, 0.725, -0.1
12918, 0.47916666666667, 0.8, -0.1
12919, 0.5, 0.775, -0.1
12920, 0.47916666666667, 0.85, -0.1
12921, 0.5, 0.825, -0.1
12922, 0.47916666666667, 0.9, -0.1
12923, 0.5, 0.875, -0.1
12924, 0.47916666666667, 0.95, -0.1
12925, 0.5, 0.925, -0.1
12926, 0.47916666666667, 1, -0.1
12927, 0.5, 0.975, -0.1
12928, 0.47916666666667, 1.05, -0.1
12929, 0.5, 1.025, -0.1
12930, 0.47916666666667, 1.1, -0.1
12931, 0.5, 1.075, -0.1
12932, 0.47916666666667, 1.15, -0.1
12933, 0.5, 1.125, -0.1
12934, 0.47916666666667, 1.2, -0.1
12935, 0.5, 1.175, -0.1
12936, 0.47916666666667, 1.25, -0.1
12937, 0.5, 1.225, -0.1
12938, 0.47916666666667, 1.3, -0.1
12939, 0.5, 1.275, -0.1
12940, 0.5, 1.325, -0.1
12941, 0.52083333333333, 0.2, -0.1
12942, 0.54166666666667, 0.175, -0.1
12943, 0.52083333333333, 0.25, -0.1
12944, 0.54166666666667, 0.225, -0.1
12945, 0.52083333333333, 0.3, -0.1
12946, 0.54166666666667, 0.275, -0.1
12947, 0.52083333333333, 0.35, -0.1
12948, 0.54166666666667, 0.325, -0.1
12949, 0.52083333333333, 0.4, -0.1
12950, 0.54166666666667, 0.375, -0.1
12951, 0.52083333333333, 0.45, -0.1
12952, 0.54166666666667, 0.425, -0.1
12953, 0.52083333333333, 0.5, -0.1
12954, 0.54166666666667, 0.475, -0.1
12955, 0.52083333333333, 0.55, -0.1
12956, 0.54166666666667, 0.525, -0.1
12957, 0.52083333333333, 0.6, -0.1
12958, 0.54166666666667, 0.575, -0.1
12959, 0.52083333333333, 0.65, -0.1
12960, 0.54166666666667, 0.625, -0.1
12961, 0.52083333333333, 0.7, -0.1
12962, 0.54166666666667, 0.675, -0.1
12963, 0.52083333333333, 0.75, -0.1
12964, 0.54166666666667, 0.725, -0.1
12965, 0.52083333333333, 0.8, -0.1
12966, 0.54166666666667, 0.775, -0.1
12967, 0.52083333333333, 0.85, -0.1
12968, 0.54166666666667, 0.825, -0.1
12969, 0.52083333333333, 0.9, -0.1
12970, 0.54166666666667, 0.875, -0.1
12971, 0.52083333333333, 0.95, -0.1
12972, 0.54166666666667, 0.925, -0.1
12973, 0.52083333333333, 1, -0.1
12974, 0.54166666666667, 0.975, -0.1
12975, 0.52083333333333, 1.05, -0.1
12976, 0.54166666666667, 1.025, -0.1
12977, 0.52083333333333, 1.1, -0.1
12978, 0.54166666666667, 1.075, -0.1
12979, 0.52083333333333, 1.15, -0.1
12980, 0.54166666666667, 1.125, -0.1
12981, 0.52083333333333, 1.2, -0.1
12982, 0.54166666666667, 1.175, -0.1
12983, 0.52083333333333, 1.25, -0.1
12984, 0.54166666666667, 1.225, -0.1
12985, 0.52083333333333, 1.3, -0.1
12986, 0.54166666666667, 1.275, -0.1
12987, 0.54166666666667, 1.325, -0.1
12988, 0.5625, 0.2, -0.1
12989, 0.58333333333333, 0.175, -0.1
12990, 0.5625, 0.25, -0.1
12991, 0.58333333333333, 0.225, -0.1
12992, 0.5625, 0.3, -0.1
12993, 0.58333333333333, 0.275, -0.1
12994, 0.5625, 0.35, -0.1
12995, 0.58333333333333, 0.325, -0.1
12996, 0.5625, 0.4, -0.1
12997, 0.58333333333333, 0.375, -0.1
12998, 0.5625, 0.45, -0.1
12999, 0.58333333333333, 0.425, -0.1
13000, 0.5625, 0.5, -0.1
13001, 0.58333333333333, 0.475, -0.1
13002, 0.5625, 0.55, -0.1
13003, 0.58333333333333, 0.525, -0.1
13004, 0.5625, 0.6, -0.1
13005, 0.58333333333333, 0.575, -0.1
13006, 0.5625, 0.65, -0.1
13007, 0.58333333333333, 0.625, -0.1
13008, 0.5625, 0.7, -0.1
13009, 0.58333333333333, 0.675, -0.1
13010, 0.5625, 0.75, -0.1
13011, 0.58333333333333, 0.725, -0.1
13012, 0.5625, 0.8, -0.1
13013, 0.58333333333333, 0.775, -0.1
13014, 0.5625, 0.85, -0.1
13015, 0.58333333333333, 0.825, -0.1
13016, 0.5625, 0.9, -0.1
13017, 0.58333333333333, 0.875, -0.1
13018, 0.5625, 0.95, -0.1
13019, 0.58333333333333, 0.925, -0.1
13020, 0.5625, 1, -0.1
13021, 0.58333333333333, 0.975, -0.1
13022, 0.5625, 1.05, -0.1
13023, 0.58333333333333, 1.025, -0.1
13024, 0.5625, 1.1, -0.1
13025, 0.58333333333333, 1.075, -0.1
13026, 0.5625, 1.15, -0.1
13027, 0.58333333333333, 1.125, -0.1
13028, 0.5625, 1.2, -0.1
13029, 0.58333333333333, 1.175, -0.1
13030, 0.5625, 1.25, -0.1
13031, 0.58333333333333, 1.225, -0.1
13032, 0.5625, 1.3, -0.1
13033, 0.58333333333333, 1.275, -0.1
13034, 0.58333333333333, 1.325, -0.1
13035, 0.60416666666667, 0.2, -0.1
13036, 0.625, 0.175, -0.1
13037, 0.60416666666667, 0.25, -0.1
13038, 0.625, 0.225, -0.1
13039, 0.60416666666667, 0.3, -0.1
13040, 0.625, 0.275, -0.1
13041, 0.60416666666667, 0.35, -0.1
13042, 0.625, 0.325, -0.1
13043, 0.60416666666667, 0.4, -0.1
13044, 0.625, 0.375, -0.1
13045, 0.60416666666667, 0.45, -0.1
13046, 0.625, 0.425, -0.1
13047, 0.60416666666667, 0.5, -0.1
13048, 0.625, 0.475, -0.1
13049, 0.60416666666667, 0.55, -0.1
13050, 0.625, 0.525, -0.1
13051, 0.60416666666667, 0.6, -0.1
13052, 0.625, 0.575, -0.1
13053, 0.60416666666667, 0.65, -0.1
13054, 0.625, 0.625, -0.1
13055, 0.60416666666667, 0.7, -0.1
13056, 0.625, 0.675, -0.1
13057, 0.60416666666667, 0.75, -0.1
13058, 0.625, 0.725, -0.1
13059, 0.60416666666667, 0.8, -0.1
13060, 0.625, 0.775, -0.1
13061, 0.60416666666667, 0.85, -0.1
13062, 0.625, 0.825, -0.1
13063, 0.60416666666667, 0.9, -0.1
13064, 0.625, 0.875, -0.1
13065, 0.60416666666667, 0.95, -0.1
13066, 0.625, 0.925, -0.1
13067, 0.60416666666667, 1, -0.1
13068, 0.625, 0.975, -0.1
13069, 0.60416666666667, 1.05, -0.1
13070, 0.625, 1.025, -0.1
13071, 0.60416666666667, 1.1, -0.1
13072, 0.625, 1.075, -0.1
13073, 0.60416666666667, 1.15, -0.1
13074, 0.625, 1.125, -0.1
13075, 0.60416666666667, 1.2, -0.1
13076, 0.625, 1.175, -0.1
13077, 0.60416666666667, 1.25, -0.1
13078, 0.625, 1.225, -0.1
13079, 0.60416666666667, 1.3, -0.1
13080, 0.625, 1.275, -0.1
13081, 0.625, 1.325, -0.1
13082, 0.64583333333333, 0.2, -0.1
13083, 0.66666666666667, 0.175, -0.1
13084, 0.64583333333333, 0.25, -0.1
13085, 0.66666666666667, 0.225, -0.1
13086, 0.64583333333333, 0.3, -0.1
13087, 0.66666666666667, 0.275, -0.1
13088, 0.64583333333333, 0.35, -0.1
13089, 0.66666666666667, 0.325, -0.1
13090, 0.64583333333333, 0.4, -0.1
13091, 0.66666666666667, 0.375, -0.1
13092, 0.64583333333333, 0.45, -0.1
13093, 0.66666666666667, 0.425, -0.1
13094, 0.64583333333333, 0.5, -0.1
13095, 0.66666666666667, 0.475, -0.1
13096, 0.64583333333333, 0.55, -0.1
13097, 0.66666666666667, 0.525, -0.1
13098, 0.64583333333333, 0.6, -0.1
13099, 0.66666666666667, 0.575, -0.1
13100, 0.64583333333333, 0.65, -0.1
13101, 0.66666666666667, 0.625, -0.1
13102, 0.64583333333333, 0.7, -0.1
13103, 0.66666666666667, 0.675, -0.1
13104, 0.64583333333333, 0.75, -0.1
13105, 0.66666666666667, 0.725, -0.1
13106, 0.64583333333333, 0.8, -0.1
13107, 0.66666666666667, 0.775, -0.1
13108, 0.64583333333333, 0.85, -0.1
13109, 0.66666666666667, 0.825, -0.1
13110, 0.64583333333333, 0.9, -0.1
13111, 0.66666666666667, 0.875, -0.1
13112, 0.64583333333333, 0.95, -0.1
13113, 0.66666666666667, 0.925, -0.1
13114, 0.64583333333333, 1, -0.1
13115, 0.66666666666667, 0.975, -0.1
13116, 0.64583333333333, 1.05, -0.1
13117, 0.66666666666667, 1.025, -0.1
13118, 0.64583333333333, 1.1, -0.1
13119, 0.66666666666667, 1.075, -0.1
13120, 0.64583333333333, 1.15, -0.1
13121, 0.66666666666667, 1.125, -0.1
13122, 0.64583333333333, 1.2, -0.1
13123, 0.66666666666667, 1.175, -0.1
13124, 0.64583333333333, 1.25, -0.1
13125, 0.66666666666667, 1.225, -0.1
13126, 0.64583333333333, 1.3, -0.1
13127, 0.66666666666667, 1.275, -0.1
13128, 0.66666666666667, 1.325, -0.1
13129, 0.6875, 0.2, -0.1
13130, 0.70833333333333, 0.175, -0.1
13131, 0.6875, 0.25, -0.1
13132, 0.70833333333333, 0.225, -0.1
13133, 0.6875, 0.3, -0.1
13134, 0.70833333333333, 0.275, -0.1
13135, 0.6875, 0.35, -0.1
13136, 0.70833333333333, 0.325, -0.1
13137, 0.6875, 0.4, -0.1
13138, 0.70833333333333, 0.375, -0.1
13139, 0.6875, 0.45, -0.1
13140, 0.70833333333333, 0.425, -0.1
13141, 0.6875, 0.5, -0.1
13142, 0.70833333333333, 0.475, -0.1
13143, 0.6875, 0.55, -0.1
13144, 0.70833333333333, 0.525, -0.1
13145, 0.6875, 0.6, -0.1
13146, 0.70833333333333, 0.575, -0.1
13147, 0.6875, 0.65, -0.1
13148, 0.70833333333333, 0.625, -0.1
13149, 0.6875, 0.7, -0.1
13150, 0.70833333333333, 0.675, -0.1
13151, 0.6875, 0.75, -0.1
13152, 0.70833333333333, 0.725, -0.1
13153, 0.6875, 0.8, -0.1
13154, 0.70833333333333, 0.775, -0.1
13155, 0.6875, 0.85, -0.1
13156, 0.70833333333333, 0.825, -0.1
13157, 0.6875, 0.9, -0.1
13158, 0.70833333333333, 0.875, -0.1
13159, 0.6875, 0.95, -0.1
13160, 0.70833333333333, 0.925, -0.1
13161, 0.6875, 1, -0.1
13162, 0.70833333333333, 0.975, -0.1
13163, 0.6875, 1.05, -0.1
13164, 0.70833333333333, 1.025, -0.1
13165, 0.6875, 1.1, -0.1
13166, 0.70833333333333, 1.075, -0.1
13167, 0.6875, 1.15, -0.1
13168, 0.70833333333333, 1.125, -0.1
13169, 0.6875, 1.2, -0.1
13170, 0.70833333333333, 1.175, -0.1
13171, 0.6875, 1.25, -0.1
13172, 0.70833333333333, 1.225, -0.1
13173, 0.6875, 1.3, -0.1
13174, 0.70833333333333, 1.275, -0.1
13175, 0.70833333333333, 1.325, -0.1
13176, 0.72916666666667, 0.2, -0.1
13177, 0.75, 0.175, -0.1
13178, 0.72916666666667, 0.25, -0.1
13179, 0.75, 0.225, -0.1
13180, 0.72916666666667, 0.3, -0.1
13181, 0.75, 0.275, -0.1
13182, 0.72916666666667, 0.35, -0.1
13183, 0.75, 0.325, -0.1
13184, 0.72916666666667, 0.4, -0.1
13185, 0.75, 0.375, -0.1
13186, 0.72916666666667, 0.45, -0.1
13187, 0.75, 0.425, -0.1
13188, 0.72916666666667, 0.5, -0.1
13189, 0.75, 0.475, -0.1
13190, 0.72916666666667, 0.55, -0.1
13191, 0.75, 0.525, -0.1
13192, 0.72916666666667, 0.6, -0.1
13193, 0.75, 0.575, -0.1
13194, 0.72916666666667, 0.65, -0.1
13195, 0.75, 0.625, -0.1
13196, 0.72916666666667, 0.7, -0.1
13197, 0.75, 0.675, -0.1
13198, 0.72916666666667, 0.75, -0.1
13199, 0.75, 0.725, -0.1
13200, 0.72916666666667, 0.8, -0.1
13201, 0.75, 0.775, -0.1
13202, 0.72916666666667, 0.85, -0.1
13203, 0.75, 0.825, -0.1
13204, 0.72916666666667, 0.9, -0.1
13205, 0.75, 0.875, -0.1
13206, 0.72916666666667, 0.95, -0.1
13207, 0.75, 0.925, -0.1
13208, 0.72916666666667, 1, -0.1
13209, 0.75, 0.975, -0.1
13210, 0.72916666666667, 1.05, -0.1
13211, 0.75, 1.025, -0.1
13212, 0.72916666666667, 1.1, -0.1
13213, 0.75, 1.075, -0.1
13214, 0.72916666666667, 1.15, -0.1
13215, 0.75, 1.125, -0.1
13216, 0.72916666666667, 1.2, -0.1
13217, 0.75, 1.175, -0.1
13218, 0.72916666666667, 1.25, -0.1
13219, 0.75, 1.225, -0.1
13220, 0.72916666666667, 1.3, -0.1
13221, 0.75, 1.275, -0.1
13222, 0.75, 1.325, -0.1
13223, 0.77083333333333, 0.2, -0.1
13224, 0.79166666666667, 0.175, -0.1
13225, 0.77083333333333, 0.25, -0.1
13226, 0.79166666666667, 0.225, -0.1
13227, 0.77083333333333, 0.3, -0.1
13228, 0.79166666666667, 0.275, -0.1
13229, 0.77083333333333, 0.35, -0.1
13230, 0.79166666666667, 0.325, -0.1
13231, 0.77083333333333, 0.4, -0.1
13232, 0.79166666666667, 0.375, -0.1
13233, 0.77083333333333, 0.45, -0.1
13234, 0.79166666666667, 0.425, -0.1
13235, 0.77083333333333, 0.5, -0.1
13236, 0.79166666666667, 0.475, -0.1
13237, 0.77083333333333, 0.55, -0.1
13238, 0.79166666666667, 0.525, -0.1
13239, 0.77083333333333, 0.6, -0.1
13240, 0.79166666666667, 0.575, -0.1
13241, 0.77083333333333, 0.65, -0.1
13242, 0.79166666666667, 0.625, -0.1
13243, 0.77083333333333, 0.7, -0.1
13244, 0.79166666666667, 0.675, -0.1
13245, 0.77083333333333, 0.75, -0.1
13246, 0.79166666666667, 0.725, -0.1
13247, 0.77083333333333, 0.8, -0.1
13248, 0.79166666666667, 0.775, -0.1
13249, 0.77083333333333, 0.85, -0.1
13250, 0.79166666666667, 0.825, -0.1
13251, 0.77083333333333, 0.9, -0.1
13252, 0.79166666666667, 0.875, -0.1
13253, 0.77083333333333, 0.95, -0.1
13254, 0.79166666666667, 0.925, -0.1
13255, 0.77083333333333, 1, -0.1
13256, 0.79166666666667, 0.975, -0.1
13257, 0.77083333333333, 1.05, -0.1
13258, 0.79166666666667, 1.025, -0.1
13259, 0.77083333333333, 1.1, -0.1
13260, 0.79166666666667, 1.075, -0.1
13261, 0.77083333333333, 1.15, -0.1
13262, 0.79166666666667, 1.125, -0.1
13263, 0.77083333333333, 1.2, -0.1
13264, 0.79166666666667, 1.175, -0.1
13265, 0.77083333333333, 1.25, -0.1
13266, 0.79166666666667, 1.225, -0.1
13267, 0.77083333333333, 1.3, -0.1
13268, 0.79166666666667, 1.275, -0.1
13269, 0.79166666666667, 1.325, -0.1
13270, 0.8125, 0.2, -0.1
13271, 0.83333333333333, 0.175, -0.1
13272, 0.8125, 0.25, -0.1
13273, 0.83333333333333, 0.225, -0.1
13274, 0.8125, 0.3, -0.1
13275, 0.83333333333333, 0.275, -0.1
13276, 0.8125, 0.35, -0.1
13277, 0.83333333333333, 0.325, -0.1
13278, 0.8125, 0.4, -0.1
13279, 0.83333333333333, 0.375, -0.1
13280, 0.8125, 0.45, -0.1
13281, 0.83333333333333, 0.425, -0.1
13282, 0.8125, 0.5, -0.1
13283, 0.83333333333333, 0.475, -0.1
13284, 0.8125, 0.55, -0.1
13285, 0.83333333333333, 0.525, -0.1
13286, 0.8125, 0.6, -0.1
13287, 0.83333333333333, 0.575, -0.1
13288, 0.8125, 0.65, -0.1
13289, 0.83333333333333, 0.625, -0.1
13290, 0.8125, 0.7, -0.1
13291, 0.83333333333333, 0.675, -0.1
13292, 0.8125, 0.75, -0.1
13293, 0.83333333333333, 0.725, -0.1
13294, 0.8125, 0.8, -0.1
13295, 0.83333333333333, 0.775, -0.1
13296, 0.8125, 0.85, -0.1
13297, 0.83333333333333, 0.825, -0.1
13298, 0.8125, 0.9, -0.1
13299, 0.83333333333333, 0.875, -0.1
13300, 0.8125, 0.95, -0.1
13301, 0.83333333333333, 0.925, -0.1
13302, 0.8125, 1, -0.1
13303, 0.83333333333333, 0.975, -0.1
13304, 0.8125, 1.05, -0.1
13305, 0.83333333333333, 1.025, -0.1
13306, 0.8125, 1.1, -0.1
13307, 0.83333333333333, 1.075, -0.1
13308, 0.8125, 1.15, -0.1
13309, 0.83333333333333, 1.125, -0.1
13310, 0.8125, 1.2, -0.1
13311, 0.83333333333333, 1.175, -0.1
13312, 0.8125, 1.25, -0.1
13313, 0.83333333333333, 1.225, -0.1
13314, 0.8125, 1.3, -0.1
13315, 0.83333333333333, 1.275, -0.1
13316, 0.83333333333333, 1.325, -0.1
13317, 0.85416666666667, 0.2, -0.1
13318, 0.875, 0.175, -0.1
13319, 0.85416666666667, 0.25, -0.1
13320, 0.875, 0.225, -0.1
13321, 0.85416666666667, 0.3, -0.1
13322, 0.875, 0.275, -0.1
13323, 0.85416666666667, 0.35, -0.1
13324, 0.875, 0.325, -0.1
13325, 0.85416666666667, 0.4, -0.1
13326, 0.875, 0.375, -0.1
13327, 0.85416666666667, 0.45, -0.1
13328, 0.875, 0.425, -0.1
13329, 0.85416666666667, 0.5, -0.1
13330, 0.875, 0.475, -0.1
13331, 0.85416666666667, 0.55, -0.1
13332, 0.875, 0.525, -0.1
13333, 0.85416666666667, 0.6, -0.1
13334, 0.875, 0.575, -0.1
13335, 0.85416666666667, 0.65, -0.1
13336, 0.875, 0.625, -0.1
13337, 0.85416666666667, 0.7, -0.1
13338, 0.875, 0.675, -0.1
13339, 0.85416666666667, 0.75, -0.1
13340, 0.875, 0.725, -0.1
13341, 0.85416666666667, 0.8, -0.1
13342, 0.875, 0.775, -0.1
13343, 0.85416666666667, 0.85, -0.1
13344, 0.875, 0.825, -0.1
13345, 0.85416666666667, 0.9, -0.1
13346, 0.875, 0.875, -0.1
13347, 0.85416666666667, 0.95, -0.1
13348, 0.875, 0.925, -0.1
13349, 0.85416666666667, 1, -0.1
13350, 0.875, 0.975, -0.1
13351, 0.85416666666667, 1.05, -0.1
13352, 0.875, 1.025, -0.1
13353, 0.85416666666667, 1.1, -0.1
13354, 0.875, 1.075, -0.1
13355, 0.85416666666667, 1.15, -0.1
13356, 0.875, 1.125, -0.1
13357, 0.85416666666667, 1.2, -0.1
13358, 0.875, 1.175, -0.1
13359, 0.85416666666667, 1.25, -0.1
13360, 0.875, 1.225, -0.1
13361, 0.85416666666667, 1.3, -0.1
13362, 0.875, 1.275, -0.1
13363, 0.875, 1.325, -0.1
13364, 0.89583333333333, 0.2, -0.1
13365, 0.91666666666667, 0.175, -0.1
13366, 0.89583333333333, 0.25, -0.1
13367, 0.91666666666667, 0.225, -0.1
13368, 0.89583333333333, 0.3, -0.1
13369, 0.91666666666667, 0.275, -0.1
13370, 0.89583333333333, 0.35, -0.1
13371, 0.91666666666667, 0.325, -0.1
13372, 0.89583333333333, 0.4, -0.1
13373, 0.91666666666667, 0.375, -0.1
13374, 0.89583333333333, 0.45, -0.1
13375, 0.91666666666667, 0.425, -0.1
13376, 0.89583333333333, 0.5, -0.1
13377, 0.91666666666667, 0.475, -0.1
13378, 0.89583333333333, 0.55, -0.1
13379, 0.91666666666667, 0.525, -0.1
13380, 0.89583333333333, 0.6, -0.1
13381, 0.91666666666667, 0.575, -0.1
13382, 0.89583333333333, 0.65, -0.1
13383, 0.91666666666667, 0.625, -0.1
13384, 0.89583333333333, 0.7, -0.1
13385, 0.91666666666667, 0.675, -0.1
13386, 0.89583333333333, 0.75, -0.1
13387, 0.91666666666667, 0.725, -0.1
13388, 0.89583333333333, 0.8, -0.1
13389, 0.91666666666667, 0.775, -0.1
13390, 0.89583333333333, 0.85, -0.1
13391, 0.91666666666667, 0.825, -0.1
13392, 0.89583333333333, 0.9, -0.1
13393, 0.91666666666667, 0.875, -0.1
13394, 0.89583333333333, 0.95, -0.1
13395, 0.91666666666667, 0.925, -0.1
13396, 0.89583333333333, 1, -0.1
13397, 0.91666666666667, 0.975, -0.1
13398, 0.89583333333333, 1.05, -0.1
13399, 0.91666666666667, 1.025, -0.1
13400, 0.89583333333333, 1.1, -0.1
13401, 0.91666666666667, 1.075, -0.1
13402, 0.89583333333333, 1.15, -0.1
13403, 0.91666666666667, 1.125, -0.1
13404, 0.89583333333333, 1.2, -0.1
13405, 0.91666666666667, 1.175, -0.1
13406, 0.89583333333333, 1.25, -0.1
13407, 0.91666666666667, 1.225, -0.1
13408, 0.89583333333333, 1.3, -0.1
13409, 0.91666666666667, 1.275, -0.1
13410, 0.91666666666667, 1.325, -0.1
13411, 0.9375, 0.2, -0.1
13412, 0.95833333333333, 0.175, -0.1
13413, 0.9375, 0.25, -0.1
13414, 0.95833333333333, 0.225, -0.1
13415, 0.9375, 0.3, -0.1
13416, 0.95833333333333, 0.275, -0.1
13417, 0.9375, 0.35, -0.1
13418, 0.95833333333333, 0.325, -0.1
13419, 0.9375, 0.4, -0.1
13420, 0.95833333333333, 0.375, -0.1
13421, 0.9375, 0.45, -0.1
13422, 0.95833333333333, 0.425, -0.1
13423, 0.9375, 0.5, -0.1
13424, 0.95833333333333, 0.475, -0.1
13425, 0.9375, 0.55, -0.1
13426, 0.95833333333333, 0.525, -0.1
13427, 0.9375, 0.6, -0.1
13428, 0.95833333333333, 0.575, -0.1
13429, 0.9375, 0.65, -0.1
13430, 0.95833333333333, 0.625, -0.1
13431, 0.9375, 0.7, -0.1
13432, 0.95833333333333, 0.675, -0.1
13433, 0.9375, 0.75, -0.1
13434, 0.95833333333333, 0.725, -0.1
13435, 0.9375, 0.8, -0.1
13436, 0.95833333333333, 0.775, -0.1
13437, 0.9375, 0.85, -0.1
13438, 0.95833333333333, 0.825, -0.1
13439, 0.9375, 0.9, -0.1
13440, 0.95833333333333, 0.875, -0.1
13441, 0.9375, 0.95, -0.1
13442, 0.95833333333333, 0.925, -0.1
13443, 0.9375, 1, -0.1
13444, 0.95833333333333, 0.975, -0.1
13445, 0.9375, 1.05, -0.1
13446, 0.95833333333333, 1.025, -0.1
13447, 0.9375, 1.1, -0.1
13448, 0.95833333333333, 1.075, -0.1
13449, 0.9375, 1.15, -0.1
13450, 0.95833333333333, 1.125, -0.1
13451, 0.9375, 1.2, -0.1
13452, 0.95833333333333, 1.175, -0.1
13453, 0.9375, 1.25, -0.1
13454, 0.95833333333333, 1.225, -0.1
13455, 0.9375, 1.3, -0.1
13456, 0.95833333333333, 1.275, -0.1
13457, 0.95833333333333, 1.325, -0.1
13458, 0.97916666666667, 0.2, -0.1
13459, 0.97916666666667, 0.25, -0.1
13460, 0.97916666666667, 0.3, -0.1
13461, 0.97916666666667, 0.35, -0.1
13462, 0.97916666666667, 0.4, -0.1
13463, 0.97916666666667, 0.45, -0.1
13464, 0.97916666666667, 0.5, -0.1
13465, 0.97916666666667, 0.55, -0.1
13466, 0.97916666666667, 0.6, -0.1
13467, 0.97916666666667, 0.65, -0.1
13468, 0.97916666666667, 0.7, -0.1
13469, 0.97916666666667, 0.75, -0.1
13470, 0.97916666666667, 0.8, -0.1
13471, 0.97916666666667, 0.85, -0.1
13472, 0.97916666666667, 0.9, -0.1
13473, 0.97916666666667, 0.95, -0.1
13474, 0.97916666666667, 1, -0.1
13475, 0.97916666666667, 1.05, -0.1
13476, 0.97916666666667, 1.1, -0.1
13477, 0.97916666666667, 1.15, -0.1
13478, 0.97916666666667, 1.2, -0.1
13479, 0.97916666666667, 1.25, -0.1
13480, 0.97916666666667, 1.3, -0.1
13481, 1.2, 1.3, -0.05
13482, 1.2, 1.25, -0.05
13483, 1.2, 1.2, -0.05
13484, 1.2, 1.15, -0.05
13485, 1.2, 1.1, -0.05
13486, 1.2, 1.05, -0.05
13487, 1.2, 1, -0.05
13488, 1.2, 0.95, -0.05
13489, 1.2, 0.9, -0.05
13490, 1.2, 0.85, -0.05
13491, 1.2, 0.8, -0.05
13492, 1.2, 0.75, -0.05
13493, 1.2, 0.7, -0.05
13494, 1.2, 0.65, -0.05
13495, 1.2, 0.6, -0.05
13496, 1.2, 0.55, -0.05
13497, 1.2, 0.5, -0.05
13498, 1.2, 0.45, -0.05
13499, 1.2, 0.4, -0.05
13500, 1.2, 0.35, -0.05
13501, 1.2, 0.3, -0.05
13502, 1.2, 0.25, -0.05
13503, 1.2, 0.2, -0.05
13504, 2.2, 1.3, -0.05
13505, 2.2, 1.25, -0.05
13506, 2.2, 1.2, -0.05
13507, 2.2, 1.15, -0.05
13508, 2.2, 1.1, -0.05
13509, 2.2, 1.05, -0.05
13510, 2.2, 1, -0.05
13511, 2.2, 0.95, -0.05
13512, 2.2, 0.9, -0.05
13513, 2.2, 0.85, -0.05
13514, 2.2, 0.8, -0.05
13515, 2.2, 0.75, -0.05
13516, 2.2, 0.7, -0.05
13517, 2.2, 0.65, -0.05
13518, 2.2, 0.6, -0.05
13519, 2.2, 0.55, -0.05
13520, 2.2, 0.5, -0.05
13521, 2.2, 0.45, -0.05
13522, 2.2, 0.4, -0.05
13523, 2.2, 0.35, -0.05
13524, 2.2, 0.3, -0.05
13525, 2.2, 0.25, -0.05
13526, 2.2, 0.2, -0.05
13527, 1.2416666666667, 1.35, -0.05
13528, 1.2833333333333, 1.35, -0.05
13529, 1.325, 1.35, -0.05
13530, 1.3666666666667, 1.35, -0.05
13531, 1.4083333333333, 1.35, -0.05
13532, 1.45, 1.35, -0.05
13533, 1.4916666666667, 1.35, -0.05
13534, 1.5333333333333, 1.35, -0.05
13535, 1.575, 1.35, -0.05
13536, 1.6166666666667, 1.35, -0.05
13537, 1.6583333333333, 1.35, -0.05
13538, 1.7, 1.35, -0.05
13539, 1.7416666666667, 1.35, -0.05
13540, 1.7833333333333, 1.35, -0.05
13541, 1.825, 1.35, -0.05
13542, 1.8666666666667, 1.35, -0.05
13543, 1.9083333333333, 1.35, -0.05
13544, 1.95, 1.35, -0.05
13545, 1.9916666666667, 1.35, -0.05
13546, 2.0333333333333, 1.35, -0.05
13547, 2.075, 1.35, -0.05
13548, 2.1166666666667, 1.35, -0.05
13549, 2.1583333333333, 1.35, -0.05
13550, 1.2416666666667, 0.15, -0.05
13551, 1.2833333333333, 0.15, -0.05
13552, 1.325, 0.15, -0.05
13553, 1.3666666666667, 0.15, -0.05
13554, 1.4083333333333, 0.15, -0.05
13555, 1.45, 0.15, -0.05
13556, 1.4916666666667, 0.15, -0.05
13557, 1.5333333333333, 0.15, -0.05
13558, 1.575, 0.15, -0.05
13559, 1.6166666666667, 0.15, -0.05
13560, 1.6583333333333, 0.15, -0.05
13561, 1.7, 0.15, -0.05
13562, 1.7416666666667, 0.15, -0.05
13563, 1.7833333333333, 0.15, -0.05
13564, 1.825, 0.15, -0.05
13565, 1.8666666666667, 0.15, -0.05
13566, 1.9083333333333, 0.15, -0.05
13567, 1.95, 0.15, -0.05
13568, 1.9916666666667, 0.15, -0.05
13569, 2.0333333333333, 0.15, -0.05
13570, 2.075, 0.15, -0.05
13571, 2.1166666666667, 0.15, -0.05
13572, 2.1583333333333, 0.15, -0.05
13573, 1.2416666666667, 1.3, -0.1
13574, 1.2416666666667, 1.25, -0.1
13575, 1.2416666666667, 1.2, -0.1
13576, 1.2416666666667, 1.15, -0.1
13577, 1.2416666666667, 1.1, -0.1
13578, 1.2416666666667, 1.05, -0.1
13579, 1.2416666666667, 1, -0.1
13580, 1.2416666666667, 0.95, -0.1
13581, 1.2416666666667, 0.9, -0.1
13582, 1.2416666666667, 0.85, -0.1
13583, 1.2416666666667, 0.8, -0.1
13584, 1.2416666666667, 0.75, -0.1
13585, 1.2416666666667, 0.7, -0.1
13586, 1.2416666666667, 0.65, -0.1
13587, 1.2416666666667, 0.6, -0.1
13588, 1.2416666666667, 0.55, -0.1
13589, 1.2416666666667, 0.5, -0.1
13590, 1.2416666666667, 0.45, -0.1
13591, 1.2416666666667, 0.4, -0.1
13592, 1.2416666666667, 0.35, -0.1
13593, 1.2416666666667, 0.3, -0.1
13594, 1.2416666666667, 0.25, -0.1
13595, 1.2416666666667, 0.2, -0.1
13596, 1.2833333333333, 1.3, -0.1
13597, 1.2833333333333, 1.25, -0.1
13598, 1.2833333333333, 1.2, -0.1
13599, 1.2833333333333, 1.15, -0.1
13600, 1.2833333333333, 1.1, -0.1
13601, 1.2833333333333, 1.05, -0.1
13602, 1.2833333333333, 1, -0.1
13603, 1.2833333333333, 0.95, -0.1
13604, 1.2833333333333, 0.9, -0.1
13605, 1.2833333333333, 0.85, -0.1
13606, 1.2833333333333, 0.8, -0.1
13607, 1.2833333333333, 0.75, -0.1
13608, 1.2833333333333, 0.7, -0.1
13609, 1.2833333333333, 0.65, -0.1
13610, 1.2833333333333, 0.6, -0.1
13611, 1.2833333333333, 0.55, -0.1
13612, 1.2833333333333, 0.5, -0.1
13613, 1.2833333333333, 0.45, -0.1
13614, 1.2833333333333, 0.4, -0.1
13615, 1.2833333333333, 0.35, -0.1
13616, 1.2833333333333, 0.3, -0.1
13617, 1.2833333333333, 0.25, -0.1
13618, 1.2833333333333, 0.2, -0.1
13619, 1.325, 1.3, -0.1
13620, 1.325, 1.25, -0.1
13621, 1.325, 1.2, -0.1
13622, 1.325, 1.15, -0.1
13623, 1.325, 1.1, -0.1
13624, 1.325, 1.05, -0.1
13625, 1.325, 1, -0.1
13626, 1.325, 0.95, -0.1
13627, 1.325, 0.9, -0.1
13628, 1.325, 0.85, -0.1
13629, 1.325, 0.8, -0.1
13630, 1.325, 0.75, -0.1
13631, 1.325, 0.7, -0.1
13632, 1.325, 0.65, -0.1
13633, 1.325, 0.6, -0.1
13634, 1.325, 0.55, -0.1
13635, 1.325, 0.5, -0.1
13636, 1.325, 0.45, -0.1
13637, 1.325, 0.4, -0.1
13638, 1.325, 0.35, -0.1
13639, 1.325, 0.3, -0.1
13640, 1.325, 0.25, -0.1
13641, 1.325, 0.2, -0.1
13642, 1.3666666666667, 1.3, -0.1
13643, 1.3666666666667, 1.25, -0.1
13644, 1.3666666666667, 1.2, -0.1
13645, 1.3666666666667, 1.15, -0.1
13646, 1.3666666666667, 1.1, -0.1
13647, 1.3666666666667, 1.05, -0.1
13648, 1.3666666666667, 1, -0.1
13649, 1.3666666666667, 0.95, -0.1
13650, 1.3666666666667, 0.9, -0.1
13651, 1.3666666666667, 0.85, -0.1
13652, 1.3666666666667, 0.8, -0.1
13653, 1.3666666666667, 0.75, -0.1
13654, 1.3666666666667, 0.7, -0.1
13655, 1.3666666666667, 0.65, -0.1
13656, 1.3666666666667, 0.6, -0.1
13657, 1.3666666666667, 0.55, -0.1
13658, 1.3666666666667, 0.5, -0.1
13659, 1.3666666666667, 0.45, -0.1
13660, 1.3666666666667, 0.4, -0.1
13661, 1.3666666666667, 0.35, -0.1
13662, 1.3666666666667, 0.3, -0.1
13663, 1.3666666666667, 0.25, -0.1
13664, 1.3666666666667, 0.2, -0.1
13665, 1.4083333333333, 1.3, -0.1
13666, 1.4083333333333, 1.25, -0.1
13667, 1.4083333333333, 1.2, -0.1
13668, 1.4083333333333, 1.15, -0.1
13669, 1.4083333333333, 1.1, -0.1
13670, 1.4083333333333, 1.05, -0.1
13671, 1.4083333333333, 1, -0.1
13672, 1.4083333333333, 0.95, -0.1
13673, 1.4083333333333, 0.9, -0.1
13674, 1.4083333333333, 0.85, -0.1
13675, 1.4083333333333, 0.8, -0.1
13676, 1.4083333333333, 0.75, -0.1
13677, 1.4083333333333, 0.7, -0.1
13678, 1.4083333333333, 0.65, -0.1
13679, 1.4083333333333, 0.6, -0.1
13680, 1.4083333333333, 0.55, -0.1
13681, 1.4083333333333, 0.5, -0.1
13682, 1.4083333333333, 0.45, -0.1
13683, 1.4083333333333, 0.4, -0.1
13684, 1.4083333333333, 0.35, -0.1
13685, 1.4083333333333, 0.3, -0.1
13686, 1.4083333333333, 0.25, -0.1
13687, 1.4083333333333, 0.2, -0.1
13688, 1.45, 1.3, -0.1
13689, 1.45, 1.25, -0.1
13690, 1.45, 1.2, -0.1
13691, 1.45, 1.15, -0.1
13692, 1.45, 1.1, -0.1
13693, 1.45, 1.05, -0.1
13694, 1.45, 1, -0.1
13695, 1.45, 0.95, -0.1
13696, 1.45, 0.9, -0.1
13697, 1.45, 0.85, -0.1
13698, 1.45, 0.8, -0.1
13699, 1.45, 0.75, -0.1
13700, 1.45, 0.7, -0.1
13701, 1.45, 0.65, -0.1
13702, 1.45, 0.6, -0.1
13703, 1.45, 0.55, -0.1
13704, 1.45, 0.5, -0.1
13705, 1.45, 0.45, -0.1
13706, 1.45, 0.4, -0.1
13707, 1.45, 0.35, -0.1
13708, 1.45, 0.3, -0.1
13709, 1.45, 0.25, -0.1
13710, 1.45, 0.2, -0.1
13711, 1.4916666666667, 1.3, -0.1
13712, 1.4916666666667, 1.25, -0.1
13713, 1.4916666666667, 1.2, -0.1
13714, 1.4916666666667, 1.15, -0.1
13715, 1.4916666666667, 1.1, -0.1
13716, 1.4916666666667, 1.05, -0.1
13717, 1.4916666666667, 1, -0.1
13718, 1.4916666666667, 0.95, -0.1
13719, 1.4916666666667, 0.9, -0.1
13720, 1.4916666666667, 0.85, -0.1
13721, 1.4916666666667, 0.8, -0.1
13722, 1.4916666666667, 0.75, -0.1
13723, 1.4916666666667, 0.7, -0.1
13724, 1.4916666666667, 0.65, -0.1
13725, 1.4916666666667, 0.6, -0.1
13726, 1.4916666666667, 0.55, -0.1
13727, 1.4916666666667, 0.5, -0.1
13728, 1.4916666666667, 0.45, -0.1
13729, 1.4916666666667, 0.4, -0.1
13730, 1.4916666666667, 0.35, -0.1
13731, 1.4916666666667, 0.3, -0.1
13732, 1.4916666666667, 0.25, -0.1
13733, 1.4916666666667, 0.2, -0.1
13734, 1.5333333333333, 1.3, -0.1
13735, 1.5333333333333, 1.25, -0.1
13736, 1.5333333333333, 1.2, -0.1
13737, 1.5333333333333, 1.15, -0.1
13738, 1.5333333333333, 1.1, -0.1
13739, 1.5333333333333, 1.05, -0.1
13740, 1.5333333333333, 1, -0.1
13741, 1.5333333333333, 0.95, -0.1
13742, 1.5333333333333, 0.9, -0.1
13743, 1.5333333333333, 0.85, -0.1
13744, 1.5333333333333, 0.8, -0.1
13745, 1.5333333333333, 0.75, -0.1
13746, 1.5333333333333, 0.7, -0.1
13747, 1.5333333333333, 0.65, -0.1
13748, 1.5333333333333, 0.6, -0.1
13749, 1.5333333333333, 0.55, -0.1
13750, 1.5333333333333, 0.5, -0.1
13751, 1.5333333333333, 0.45, -0.1
13752, 1.5333333333333, 0.4, -0.1
13753, 1.5333333333333, 0.35, -0.1
13754, 1.5333333333333, 0.3, -0.1
13755, 1.5333333333333, 0.25, -0.1
13756, 1.5333333333333, 0.2, -0.1
13757, 1.575, 1.3, -0.1
13758, 1.575, 1.25, -0.1
13759, 1.575, 1.2, -0.1
13760, 1.575, 1.15, -0.1
13761, 1.575, 1.1, -0.1
13762, 1.575, 1.05, -0.1
13763, 1.575, 1, -0.1
13764, 1.575, 0.95, -0.1
13765, 1.575, 0.9, -0.1
13766, 1.575, 0.85, -0.1
13767, 1.575, 0.8, -0.1
13768, 1.575, 0.75, -0.1
13769, 1.575, 0.7, -0.1
13770, 1.575, 0.65, -0.1
13771, 1.575, 0.6, -0.1
13772, 1.575, 0.55, -0.1
13773, 1.575, 0.5, -0.1
13774, 1.575, 0.45, -0.1
13775, 1.575, 0.4, -0.1
13776, 1.575, 0.35, -0.1
13777, 1.575, 0.3, -0.1
13778, 1.575, 0.25, -0.1
13779, 1.575, 0.2, -0.1
13780, 1.6166666666667, 1.3, -0.1
13781, 1.6166666666667, 1.25, -0.1
13782, 1.6166666666667, 1.2, -0.1
13783, 1.6166666666667, 1.15, -0.1
13784, 1.6166666666667, 1.1, -0.1
13785, 1.6166666666667, 1.05, -0.1
13786, 1.6166666666667, 1, -0.1
13787, 1.6166666666667, 0.95, -0.1
13788, 1.6166666666667, 0.9, -0.1
13789, 1.6166666666667, 0.85, -0.1
13790, 1.6166666666667, 0.8, -0.1
13791, 1.6166666666667, 0.75, -0.1
13792, 1.6166666666667, 0.7, -0.1
13793, 1.6166666666667, 0.65, -0.1
13794, 1.6166666666667, 0.6, -0.1
13795, 1.6166666666667, 0.55, -0.1
13796, 1.6166666666667, 0.5, -0.1
13797, 1.6166666666667, 0.45, -0.1
13798, 1.6166666666667, 0.4, -0.1
13799, 1.6166666666667, 0.35, -0.1
13800, 1.6166666666667, 0.3, -0.1
13801, 1.6166666666667, 0.25, -0.1
13802, 1.6166666666667, 0.2, -0.1
13803, 1.6583333333333, 1.3, -0.1
13804, 1.6583333333333, 1.25, -0.1
13805, 1.6583333333333, 1.2, -0.1
13806, 1.6583333333333, 1.15, -0.1
13807, 1.6583333333333, 1.1, -0.1
13808, 1.6583333333333, 1.05, -0.1
13809, 1.6583333333333, 1, -0.1
13810, 1.6583333333333, 0.95, -0.1
13811, 1.6583333333333, 0.9, -0.1
13812, 1.6583333333333, 0.85, -0.1
13813, 1.6583333333333, 0.8, -0.1
13814, 1.6583333333333, 0.75, -0.1
13815, 1.6583333333333, 0.7, -0.1
13816, 1.6583333333333, 0.65, -0.1
13817, 1.6583333333333, 0.6, -0.1
13818, 1.6583333333333, 0.55, -0.1
13819, 1.6583333333333, 0.5, -0.1
13820, 1.6583333333333, 0.45, -0.1
13821, 1.6583333333333, 0.4, -0.1
13822, 1.6583333333333, 0.35, -0.1
13823, 1.6583333333333, 0.3, -0.1
13824, 1.6583333333333, 0.25, -0.1
13825, 1.6583333333333, 0.2, -0.1
13826, 1.7, 1.3, -0.1
13827, 1.7, 1.25, -0.1
13828, 1.7, 1.2, -0.1
13829, 1.7, 1.15, -0.1
13830, 1.7, 1.1, -0.1
13831, 1.7, 1.05, -0.1
13832, 1.7, 1, -0.1
13833, 1.7, 0.95, -0.1
13834, 1.7, 0.9, -0.1
13835, 1.7, 0.85, -0.1
13836, 1.7, 0.8, -0.1
13837, 1.7, 0.75, -0.1
13838, 1.7, 0.7, -0.1
13839, 1.7, 0.65, -0.1
13840, 1.7, 0.6, -0.1
13841, 1.7, 0.55, -0.1
13842, 1.7, 0.5, -0.1
13843, 1.7, 0.45, -0.1
13844, 1.7, 0.4, -0.1
13845, 1.7, 0.35, -0.1
13846, 1.7, 0.3, -0.1
13847, 1.7, 0.25, -0.1
13848, 1.7, 0.2, -0.1
13849, 1.7416666666667, 1.3, -0.1
13850, 1.7416666666667, 1.25, -0.1
13851, 1.7416666666667, 1.2, -0.1
13852, 1.7416666666667, 1.15, -0.1
13853, 1.7416666666667, 1.1, -0.1
13854, 1.7416666666667, 1.05, -0.1
13855, 1.7416666666667, 1, -0.1
13856, 1.7416666666667, 0.95, -0.1
13857, 1.7416666666667, 0.9, -0.1
13858, 1.7416666666667, 0.85, -0.1
13859, 1.7416666666667, 0.8, -0.1
13860, 1.7416666666667, 0.75, -0.1
13861, 1.7416666666667, 0.7, -0.1
13862, 1.7416666666667, 0.65, -0.1
13863, 1.7416666666667, 0.6, -0.1
13864, 1.7416666666667, 0.55, -0.1
13865, 1.7416666666667, 0.5, -0.1
13866, 1.7416666666667, 0.45, -0.1
13867, 1.7416666666667, 0.4, -0.1
13868, 1.7416666666667, 0.35, -0.1
13869, 1.7416666666667, 0.3, -0.1
13870, 1.7416666666667, 0.25, -0.1
13871, 1.7416666666667, 0.2, -0.1
13872, 1.7833333333333, 1.3, -0.1
13873, 1.7833333333333, 1.25, -0.1
13874, 1.7833333333333, 1.2, -0.1
13875, 1.7833333333333, 1.15, -0.1
13876, 1.7833333333333, 1.1, -0.1
13877, 1.7833333333333, 1.05, -0.1
13878, 1.7833333333333, 1, -0.1
13879, 1.7833333333333, 0.95, -0.1
13880, 1.7833333333333, 0.9, -0.1
13881, 1.7833333333333, 0.85, -0.1
13882, 1.7833333333333, 0.8, -0.1
13883, 1.7833333333333, 0.75, -0.1
13884, 1.7833333333333, 0.7, -0.1
13885, 1.7833333333333, 0.65, -0.1
13886, 1.7833333333333, 0.6, -0.1
13887, 1.7833333333333, 0.55, -0.1
13888, 1.7833333333333, 0.5, -0.1
13889, 1.7833333333333, 0.45, -0.1
13890, 1.7833333333333, 0.4, -0.1
13891, 1.7833333333333, 0.35, -0.1
13892, 1.7833333333333, 0.3, -0.1
13893, 1.7833333333333, 0.25, -0.1
13894, 1.7833333333333, 0.2, -0.1
13895, 1.825, 1.3, -0.1
13896, 1.825, 1.25, -0.1
13897, 1.825, 1.2, -0.1
13898, 1.825, 1.15, -0.1
13899, 1.825, 1.1, -0.1
13900, 1.825, 1.05, -0.1
13901, 1.825, 1, -0.1
13902, 1.825, 0.95, -0.1
13903, 1.825, 0.9, -0.1
13904, 1.825, 0.85, -0.1
13905, 1.825, 0.8, -0.1
13906, 1.825, 0.75, -0.1
13907, 1.825, 0.7, -0.1
13908, 1.825, 0.65, -0.1
13909, 1.825, 0.6, -0.1
13910, 1.825, 0.55, -0.1
13911, 1.825, 0.5, -0.1
13912, 1.825, 0.45, -0.1
13913, 1.825, 0.4, -0.1
13914, 1.825, 0.35, -0.1
13915, 1.825, 0.3, -0.1
13916, 1.825, 0.25, -0.1
13917, 1.825, 0.2, -0.1
13918, 1.8666666666667, 1.3, -0.1
13919, 1.8666666666667, 1.25, -0.1
13920, 1.8666666666667, 1.2, -0.1
13921, 1.8666666666667, 1.15, -0.1
13922, 1.8666666666667, 1.1, -0.1
13923, 1.8666666666667, 1.05, -0.1
13924, 1.8666666666667, 1, -0.1
13925, 1.8666666666667, 0.95, -0.1
13926, 1.8666666666667, 0.9, -0.1
13927, 1.8666666666667, 0.85, -0.1
13928, 1.8666666666667, 0.8, -0.1
13929, 1.8666666666667, 0.75, -0.1
13930, 1.8666666666667, 0.7, -0.1
13931, 1.8666666666667, 0.65, -0.1
13932, 1.8666666666667, 0.6, -0.1
13933, 1.8666666666667, 0.55, -0.1
13934, 1.8666666666667, 0.5, -0.1
13935, 1.8666666666667, 0.45, -0.1
13936, 1.8666666666667, 0.4, -0.1
13937, 1.8666666666667, 0.35, -0.1
13938, 1.8666666666667, 0.3, -0.1
13939, 1.8666666666667, 0.25, -0.1
13940, 1.8666666666667, 0.2, -0.1
13941, 1.9083333333333, 1.3, -0.1
13942, 1.9083333333333, 1.25, -0.1
13943, 1.9083333333333, 1.2, -0.1
13944, 1.9083333333333, 1.15, -0.1
13945, 1.9083333333333, 1.1, -0.1
13946, 1.9083333333333, 1.05, -0.1
13947, 1.9083333333333, 1, -0.1
13948, 1.9083333333333, 0.95, -0.1
13949, 1.9083333333333, 0.9, -0.1
13950, 1.9083333333333, 0.85, -0.1
13951, 1.9083333333333, 0.8, -0.1
13952, 1.9083333333333, 0.75, -0.1
13953, 1.9083333333333, 0.7, -0.1
13954, 1.9083333333333, 0.65, -0.1
13955, 1.9083333333333, 0.6, -0.1
13956, 1.9083333333333, 0.55, -0.1
13957, 1.9083333333333, 0.5, -0.1
13958, 1.9083333333333, 0.45, -0.1
13959, 1.9083333333333, 0.4, -0.1
13960, 1.9083333333333, 0.35, -0.1
13961, 1.9083333333333, 0.3, -0.1
13962, 1.9083333333333, 0.25, -0.1
13963, 1.9083333333333, 0.2, -0.1
13964, 1.95, 1.3, -0.1
13965, 1.95, 1.25, -0.1
13966, 1.95, 1.2, -0.1
13967, 1.95, 1.15, -0.1
13968, 1.95, 1.1, -0.1
13969, 1.95, 1.05, -0.1
13970, 1.95, 1, -0.1
13971, 1.95, 0.95, -0.1
13972, 1.95, 0.9, -0.1
13973, 1.95, 0.85, -0.1
13974, 1.95, 0.8, -0.1
13975, 1.95, 0.75, -0.1
13976, 1.95, 0.7, -0.1
13977, 1.95, 0.65, -0.1
13978, 1.95, 0.6, -0.1
13979, 1.95, 0.55, -0.1
13980, 1.95, 0.5, -0.1
13981, 1.95, 0.45, -0.1
13982, 1.95, 0.4, -0.1
13983, 1.95, 0.35, -0.1
13984, 1.95, 0.3, -0.1
13985, 1.95, 0.25, -0.1
13986, 1.95, 0.2, -0.1
13987, 1.9916666666667, 1.3, -0.1
13988, 1.9916666666667, 1.25, -0.1
13989, 1.9916666666667, 1.2, -0.1
13990, 1.9916666666667, 1.15, -0.1
13991, 1.9916666666667, 1.1, -0.1
13992, 1.9916666666667, 1.05, -0.1
13993, 1.9916666666667, 1, -0.1
13994, 1.9916666666667, 0.95, -0.1
13995, 1.9916666666667, 0.9, -0.1
13996, 1.9916666666667, 0.85, -0.1
13997, 1.9916666666667, 0.8, -0.1
13998, 1.9916666666667, 0.75, -0.1
13999, 1.9916666666667, 0.7, -0.1
14000, 1.9916666666667, 0.65, -0.1
14001, 1.9916666666667, 0.6, -0.1
14002, 1.9916666666667, 0.55, -0.1
14003, 1.9916666666667, 0.5, -0.1
14004, 1.9916666666667, 0.45, -0.1
14005, 1.9916666666667, 0.4, -0.1
14006, 1.9916666666667, 0.35, -0.1
14007, 1.9916666666667, 0.3, -0.1
14008, 1.9916666666667, 0.25, -0.1
14009, 1.9916666666667, 0.2, -0.1
14010, 2.0333333333333, 1.3, -0.1
14011, 2.0333333333333, 1.25, -0.1
14012, 2.0333333333333, 1.2, -0.1
14013, 2.0333333333333, 1.15, -0.1
14014, 2.0333333333333, 1.1, -0.1
14015, 2.0333333333333, 1.05, -0.1
14016, 2.0333333333333, 1, -0.1
14017, 2.0333333333333, 0.95, -0.1
14018, 2.0333333333333, 0.9, -0.1
14019, 2.0333333333333, 0.85, -0.1
14020, 2.0333333333333, 0.8, -0.1
14021, 2.0333333333333, 0.75, -0.1
14022, 2.0333333333333, 0.7, -0.1
14023, 2.0333333333333, 0.65, -0.1
14024, 2.0333333333333, 0.6, -0.1
14025, 2.0333333333333, 0.55, -0.1
14026, 2.0333333333333, 0.5, -0.1
14027, 2.0333333333333, 0.45, -0.1
14028, 2.0333333333333, 0.4, -0.1
14029, 2.0333333333333, 0.35, -0.1
14030, 2.0333333333333, 0.3, -0.1
14031, 2.0333333333333, 0.25, -0.1
14032, 2.0333333333333, 0.2, -0.1
14033, 2.075, 1.3, -0.1
14034, 2.075, 1.25, -0.1
14035, 2.075, 1.2, -0.1
14036, 2.075, 1.15, -0.1
14037, 2.075, 1.1, -0.1
14038, 2.075, 1.05, -0.1
14039, 2.075, 1, -0.1
14040, 2.075, 0.95, -0.1
14041, 2.075, 0.9, -0.1
14042, 2.075, 0.85, -0.1
14043, 2.075, 0.8, -0.1
14044, 2.075, 0.75, -0.1
14045, 2.075, 0.7, -0.1
14046, 2.075, 0.65, -0.1
14047, 2.075, 0.6, -0.1
14048, 2.075, 0.55, -0.1
14049, 2.075, 0.5, -0.1
14050, 2.075, 0.45, -0.1
14051, 2.075, 0.4, -0.1
14052, 2.075, 0.35, -0.1
14053, 2.075, 0.3, -0.1
14054, 2.075, 0.25, -0.1
14055, 2.075, 0.2, -0.1
14056, 2.1166666666667, 1.3, -0.1
14057, 2.1166666666667, 1.25, -0.1
14058, 2.1166666666667, 1.2, -0.1
14059, 2.1166666666667, 1.15, -0.1
14060, 2.1166666666667, 1.1, -0.1
14061, 2.1166666666667, 1.05, -0.1
14062, 2.1166666666667, 1, -0.1
14063, 2.1166666666667, 0.95, -0.1
14064, 2.1166666666667, 0.9, -0.1
14065, 2.1166666666667, 0.85, -0.1
14066, 2.1166666666667, 0.8, -0.1
14067, 2.1166666666667, 0.75, -0.1
14068, 2.1166666666667, 0.7, -0.1
14069, 2.1166666666667, 0.65, -0.1
14070, 2.1166666666667, 0.6, -0.1
14071, 2.1166666666667, 0.55, -0.1
14072, 2.1166666666667, 0.5, -0.1
14073, 2.1166666666667, 0.45, -0.1
14074, 2.1166666666667, 0.4, -0.1
14075, 2.1166666666667, 0.35, -0.1
14076, 2.1166666666667, 0.3, -0.1
14077, 2.1166666666667, 0.25, -0.1
14078, 2.1166666666667, 0.2, -0.1
14079, 2.1583333333333, 1.3, -0.1
14080, 2.1583333333333, 1.25, -0.1
14081, 2.1583333333333, 1.2, -0.1
14082, 2.1583333333333, 1.15, -0.1
14083, 2.1583333333333, 1.1, -0.1
14084, 2.1583333333333, 1.05, -0.1
14085, 2.1583333333333, 1, -0.1
14086, 2.1583333333333, 0.95, -0.1
14087, 2.1583333333333, 0.9, -0.1
14088, 2.1583333333333, 0.85, -0.1
14089, 2.1583333333333, 0.8, -0.1
14090, 2.1583333333333, 0.75, -0.1
14091, 2.1583333333333, 0.7, -0.1
14092, 2.1583333333333, 0.65, -0.1
14093, 2.1583333333333, 0.6, -0.1
14094, 2.1583333333333, 0.55, -0.1
14095, 2.1583333333333, 0.5, -0.1
14096, 2.1583333333333, 0.45, -0.1
14097, 2.1583333333333, 0.4, -0.1
14098, 2.1583333333333, 0.35, -0.1
14099, 2.1583333333333, 0.3, -0.1
14100, 2.1583333333333, 0.25, -0.1
14101, 2.1583333333333, 0.2, -0.1
14102, 1.2416666666667, 1.325, -0.1
14103, 1.2208333333333, 1.3, -0.1
14104, 1.2416666666667, 1.275, -0.1
14105, 1.2208333333333, 1.25, -0.1
14106, 1.2416666666667, 1.225, -0.1
14107, 1.2208333333333, 1.2, -0.1
14108, 1.2416666666667, 1.175, -0.1
14109, 1.2208333333333, 1.15, -0.1
14110, 1.2416666666667, 1.125, -0.1
14111, 1.2208333333333, 1.1, -0.1
14112, 1.2416666666667, 1.075, -0.1
14113, 1.2208333333333, 1.05, -0.1
14114, 1.2416666666667, 1.025, -0.1
14115, 1.2208333333333, 1, -0.1
14116, 1.2416666666667, 0.975, -0.1
14117, 1.2208333333333, 0.95, -0.1
14118, 1.2416666666667, 0.925, -0.1
14119, 1.2208333333333, 0.9, -0.1
14120, 1.2416666666667, 0.875, -0.1
14121, 1.2208333333333, 0.85, -0.1
14122, 1.2416666666667, 0.825, -0.1
14123, 1.2208333333333, 0.8, -0.1
14124, 1.2416666666667, 0.775, -0.1
14125, 1.2208333333333, 0.75, -0.1
14126, 1.2416666666667, 0.725, -0.1
14127, 1.2208333333333, 0.7, -0.1
14128, 1.2416666666667, 0.675, -0.1
14129, 1.2208333333333, 0.65, -0.1
14130, 1.2416666666667, 0.625, -0.1
14131, 1.2208333333333, 0.6, -0.1
14132, 1.2416666666667, 0.575, -0.1
14133, 1.2208333333333, 0.55, -0.1
14134, 1.2416666666667, 0.525, -0.1
14135, 1.2208333333333, 0.5, -0.1
14136, 1.2416666666667, 0.475, -0.1
14137, 1.2208333333333, 0.45, -0.1
14138, 1.2416666666667, 0.425, -0.1
14139, 1.2208333333333, 0.4, -0.1
14140, 1.2416666666667, 0.375, -0.1
14141, 1.2208333333333, 0.35, -0.1
14142, 1.2416666666667, 0.325, -0.1
14143, 1.2208333333333, 0.3, -0.1
14144, 1.2416666666667, 0.275, -0.1
14145, 1.2208333333333, 0.25, -0.1
14146, 1.2416666666667, 0.225, -0.1
14147, 1.2208333333333, 0.2, -0.1
14148, 1.2416666666667, 0.175, -0.1
14149, 1.2833333333333, 1.325, -0.1
14150, 1.2625, 1.3, -0.1
14151, 1.2833333333333, 1.275, -0.1
14152, 1.2625, 1.25, -0.1
14153, 1.2833333333333, 1.225, -0.1
14154, 1.2625, 1.2, -0.1
14155, 1.2833333333333, 1.175, -0.1
14156, 1.2625, 1.15, -0.1
14157, 1.2833333333333, 1.125, -0.1
14158, 1.2625, 1.1, -0.1
14159, 1.2833333333333, 1.075, -0.1
14160, 1.2625, 1.05, -0.1
14161, 1.2833333333333, 1.025, -0.1
14162, 1.2625, 1, -0.1
14163, 1.2833333333333, 0.975, -0.1
14164, 1.2625, 0.95, -0.1
14165, 1.2833333333333, 0.925, -0.1
14166, 1.2625, 0.9, -0.1
14167, 1.2833333333333, 0.875, -0.1
14168, 1.2625, 0.85, -0.1
14169, 1.2833333333333, 0.825, -0.1
14170, 1.2625, 0.8, -0.1
14171, 1.2833333333333, 0.775, -0.1
14172, 1.2625, 0.75, -0.1
14173, 1.2833333333333, 0.725, -0.1
14174, 1.2625, 0.7, -0.1
14175, 1.2833333333333, 0.675, -0.1
14176, 1.2625, 0.65, -0.1
14177, 1.2833333333333, 0.625, -0.1
14178, 1.2625, 0.6, -0.1
14179, 1.2833333333333, 0.575, -0.1
14180, 1.2625, 0.55, -0.1
14181, 1.2833333333333, 0.525, -0.1
14182, 1.2625, 0.5, -0.1
14183, 1.2833333333333, 0.475, -0.1
14184, 1.2625, 0.45, -0.1
14185, 1.2833333333333, 0.425, -0.1
14186, 1.2625, 0.4, -0.1
14187, 1.2833333333333, 0.375, -0.1
14188, 1.2625, 0.35, -0.1
14189, 1.2833333333333, 0.325, -0.1
14190, 1.2625, 0.3, -0.1
14191, 1.2833333333333, 0.275, -0.1
14192, 1.2625, 0.25, -0.1
14193, 1.2833333333333, 0.225, -0.1
14194, 1.2625, 0.2, -0.1
14195, 1.2833333333333, 0.175, -0.1
14196, 1.325, 1.325, -0.1
14197, 1.3041666666667, 1.3, -0.1
14198, 1.325, 1.275, -0.1
14199, 1.3041666666667, 1.25, -0.1
14200, 1.325, 1.225, -0.1
14201, 1.3041666666667, 1.2, -0.1
14202, 1.325, 1.175, -0.1
14203, 1.3041666666667, 1.15, -0.1
14204, 1.325, 1.125, -0.1
14205, 1.3041666666667, 1.1, -0.1
14206, 1.325, 1.075, -0.1
14207, 1.3041666666667, 1.05, -0.1
14208, 1.325, 1.025, -0.1
14209, 1.3041666666667, 1, -0.1
14210, 1.325, 0.975, -0.1
14211, 1.3041666666667, 0.95, -0.1
14212, 1.325, 0.925, -0.1
14213, 1.3041666666667, 0.9, -0.1
14214, 1.325, 0.875, -0.1
14215, 1.3041666666667, 0.85, -0.1
14216, 1.325, 0.825, -0.1
14217, 1.3041666666667, 0.8, -0.1
14218, 1.325, 0.775, -0.1
14219, 1.3041666666667, 0.75, -0.1
14220, 1.325, 0.725, -0.1
14221, 1.3041666666667, 0.7, -0.1
14222, 1.325, 0.675, -0.1
14223, 1.3041666666667, 0.65, -0.1
14224, 1.325, 0.625, -0.1
14225, 1.3041666666667, 0.6, -0.1
14226, 1.325, 0.575, -0.1
14227, 1.3041666666667, 0.55, -0.1
14228, 1.325, 0.525, -0.1
14229, 1.3041666666667, 0.5, -0.1
14230, 1.325, 0.475, -0.1
14231, 1.3041666666667, 0.45, -0.1
14232, 1.325, 0.425, -0.1
14233, 1.3041666666667, 0.4, -0.1
14234, 1.325, 0.375, -0.1
14235, 1.3041666666667, 0.35, -0.1
14236, 1.325, 0.325, -0.1
14237, 1.3041666666667, 0.3, -0.1
14238, 1.325, 0.275, -0.1
14239, 1.3041666666667, 0.25, -0.1
14240, 1.325, 0.225, -0.1
14241, 1.3041666666667, 0.2, -0.1
14242, 1.325, 0.175, -0.1
14243, 1.3666666666667, 1.325, -0.1
14244, 1.3458333333333, 1.3, -0.1
14245, 1.3666666666667, 1.275, -0.1
14246, 1.3458333333333, 1.25, -0.1
14247, 1.3666666666667, 1.225, -0.1
14248, 1.3458333333333, 1.2, -0.1
14249, 1.3666666666667, 1.175, -0.1
14250, 1.3458333333333, 1.15, -0.1
14251, 1.3666666666667, 1.125, -0.1
14252, 1.3458333333333, 1.1, -0.1
14253, 1.3666666666667, 1.075, -0.1
14254, 1.3458333333333, 1.05, -0.1
14255, 1.3666666666667, 1.025, -0.1
14256, 1.3458333333333, 1, -0.1
14257, 1.3666666666667, 0.975, -0.1
14258, 1.3458333333333, 0.95, -0.1
14259, 1.3666666666667, 0.925, -0.1
14260, 1.3458333333333, 0.9, -0.1
14261, 1.3666666666667, 0.875, -0.1
14262, 1.3458333333333, 0.85, -0.1
14263, 1.3666666666667, 0.825, -0.1
14264, 1.3458333333333, 0.8, -0.1
14265, 1.3666666666667, 0.775, -0.1
14266, 1.3458333333333, 0.75, -0.1
14267, 1.3666666666667, 0.725, -0.1
14268, 1.3458333333333, 0.7, -0.1
14269, 1.3666666666667, 0.675, -0.1
14270, 1.3458333333333, 0.65, -0.1
14271, 1.3666666666667, 0.625, -0.1
14272, 1.3458333333333, 0.6, -0.1
14273, 1.3666666666667, 0.575, -0.1
14274, 1.3458333333333, 0.55, -0.1
14275, 1.3666666666667, 0.525, -0.1
14276, 1.3458333333333, 0.5, -0.1
14277, 1.3666666666667, 0.475, -0.1
14278, 1.3458333333333, 0.45, -0.1
14279, 1.3666666666667, 0.425, -0.1
14280, 1.3458333333333, 0.4, -0.1
14281, 1.3666666666667, 0.375, -0.1
14282, 1.3458333333333, 0.35, -0.1
14283, 1.3666666666667, 0.325, -0.1
14284, 1.3458333333333, 0.3, -0.1
14285, 1.3666666666667, 0.275, -0.1
14286, 1.3458333333333, 0.25, -0.1
14287, 1.3666666666667, 0.225, -0.1
14288, 1.3458333333333, 0.2, -0.1
14289, 1.3666666666667, 0.175, -0.1
14290, 1.4083333333333, 1.325, -0.1
14291, 1.3875, 1.3, -0.1
14292, 1.4083333333333, 1.275, -0.1
14293, 1.3875, 1.25, -0.1
14294, 1.4083333333333, 1.225, -0.1
14295, 1.3875, 1.2, -0.1
14296, 1.4083333333333, 1.175, -0.1
14297, 1.3875, 1.15, -0.1
14298, 1.4083333333333, 1.125, -0.1
14299, 1.3875, 1.1, -0.1
14300, 1.4083333333333, 1.075, -0.1
14301, 1.3875, 1.05, -0.1
14302, 1.4083333333333, 1.025, -0.1
14303, 1.3875, 1, -0.1
14304, 1.4083333333333, 0.975, -0.1
14305, 1.3875, 0.95, -0.1
14306, 1.4083333333333, 0.925, -0.1
14307, 1.3875, 0.9, -0.1
14308, 1.4083333333333, 0.875, -0.1
14309, 1.3875, 0.85, -0.1
14310, 1.4083333333333, 0.825, -0.1
14311, 1.3875, 0.8, -0.1
14312, 1.4083333333333, 0.775, -0.1
14313, 1.3875, 0.75, -0.1
14314, 1.4083333333333, 0.725, -0.1
14315, 1.3875, 0.7, -0.1
14316, 1.4083333333333, 0.675, -0.1
14317, 1.3875, 0.65, -0.1
14318, 1.4083333333333, 0.625, -0.1
14319, 1.3875, 0.6, -0.1
14320, 1.4083333333333, 0.575, -0.1
14321, 1.3875, 0.55, -0.1
14322, 1.4083333333333, 0.525, -0.1
14323, 1.3875, 0.5, -0.1
14324, 1.4083333333333, 0.475, -0.1
14325, 1.3875, 0.45, -0.1
14326, 1.4083333333333, 0.425, -0.1
14327, 1.3875, 0.4, -0.1
14328, 1.4083333333333, 0.375, -0.1
14329, 1.3875, 0.35, -0.1
14330, 1.4083333333333, 0.325, -0.1
14331, 1.3875, 0.3, -0.1
14332, 1.4083333333333, 0.275, -0.1
14333, 1.3875, 0.25, -0.1
14334, 1.4083333333333, 0.225, -0.1
14335, 1.3875, 0.2, -0.1
14336, 1.4083333333333, 0.175, -0.1
14337, 1.45, 1.325, -0.1
14338, 1.4291666666667, 1.3, -0.1
14339, 1.45, 1.275, -0.1
14340, 1.4291666666667, 1.25, -0.1
14341, 1.45, 1.225, -0.1
14342, 1.4291666666667, 1.2, -0.1
14343, 1.45, 1.175, -0.1
14344, 1.4291666666667, 1.15, -0.1
14345, 1.45, 1.125, -0.1
14346, 1.4291666666667, 1.1, -0.1
14347, 1.45, 1.075, -0.1
14348, 1.4291666666667, 1.05, -0.1
14349, 1.45, 1.025, -0.1
14350, 1.4291666666667, 1, -0.1
14351, 1.45, 0.975, -0.1
14352, 1.4291666666667, 0.95, -0.1
14353, 1.45, 0.925, -0.1
14354, 1.4291666666667, 0.9, -0.1
14355, 1.45, 0.875, -0.1
14356, 1.4291666666667, 0.85, -0.1
14357, 1.45, 0.825, -0.1
14358, 1.4291666666667, 0.8, -0.1
14359, 1.45, 0.775, -0.1
14360, 1.4291666666667, 0.75, -0.1
14361, 1.45, 0.725, -0.1
14362, 1.4291666666667, 0.7, -0.1
14363, 1.45, 0.675, -0.1
14364, 1.4291666666667, 0.65, -0.1
14365, 1.45, 0.625, -0.1
14366, 1.4291666666667, 0.6, -0.1
14367, 1.45, 0.575, -0.1
14368, 1.4291666666667, 0.55, -0.1
14369, 1.45, 0.525, -0.1
14370, 1.4291666666667, 0.5, -0.1
14371, 1.45, 0.475, -0.1
14372, 1.4291666666667, 0.45, -0.1
14373, 1.45, 0.425, -0.1
14374, 1.4291666666667, 0.4, -0.1
14375, 1.45, 0.375, -0.1
14376, 1.4291666666667, 0.35, -0.1
14377, 1.45, 0.325, -0.1
14378, 1.4291666666667, 0.3, -0.1
14379, 1.45, 0.275, -0.1
14380, 1.4291666666667, 0.25, -0.1
14381, 1.45, 0.225, -0.1
14382, 1.4291666666667, 0.2, -0.1
14383, 1.45, 0.175, -0.1
14384, 1.4916666666667, 1.325, -0.1
14385, 1.4708333333333, 1.3, -0.1
14386, 1.4916666666667, 1.275, -0.1
14387, 1.4708333333333, 1.25, -0.1
14388, 1.4916666666667, 1.225, -0.1
14389, 1.4708333333333, 1.2, -0.1
14390, 1.4916666666667, 1.175, -0.1
14391, 1.4708333333333, 1.15, -0.1
14392, 1.4916666666667, 1.125, -0.1
14393, 1.4708333333333, 1.1, -0.1
14394, 1.4916666666667, 1.075, -0.1
14395, 1.4708333333333, 1.05, -0.1
14396, 1.4916666666667, 1.025, -0.1
14397, 1.4708333333333, 1, -0.1
14398, 1.4916666666667, 0.975, -0.1
14399, 1.4708333333333, 0.95, -0.1
14400, 1.4916666666667, 0.925, -0.1
14401, 1.4708333333333, 0.9, -0.1
14402, 1.4916666666667, 0.875, -0.1
14403, 1.4708333333333, 0.85, -0.1
14404, 1.4916666666667, 0.825, -0.1
14405, 1.4708333333333, 0.8, -0.1
14406, 1.4916666666667, 0.775, -0.1
14407, 1.4708333333333, 0.75, -0.1
14408, 1.4916666666667, 0.725, -0.1
14409, 1.4708333333333, 0.7, -0.1
14410, 1.4916666666667, 0.675, -0.1
14411, 1.4708333333333, 0.65, -0.1
14412, 1.4916666666667, 0.625, -0.1
14413, 1.4708333333333, 0.6, -0.1
14414, 1.4916666666667, 0.575, -0.1
14415, 1.4708333333333, 0.55, -0.1
14416, 1.4916666666667, 0.525, -0.1
14417, 1.4708333333333, 0.5, -0.1
14418, 1.4916666666667, 0.475, -0.1
14419, 1.4708333333333, 0.45, -0.1
14420, 1.4916666666667, 0.425, -0.1
14421, 1.4708333333333, 0.4, -0.1
14422, 1.4916666666667, 0.375, -0.1
14423, 1.4708333333333, 0.35, -0.1
14424, 1.4916666666667, 0.325, -0.1
14425, 1.4708333333333, 0.3, -0.1
14426, 1.4916666666667, 0.275, -0.1
14427, 1.4708333333333, 0.25, -0.1
14428, 1.4916666666667, 0.225, -0.1
14429, 1.4708333333333, 0.2, -0.1
14430, 1.4916666666667, 0.175, -0.1
14431, 1.5333333333333, 1.325, -0.1
14432, 1.5125, 1.3, -0.1
14433, 1.5333333333333, 1.275, -0.1
14434, 1.5125, 1.25, -0.1
14435, 1.5333333333333, 1.225, -0.1
14436, 1.5125, 1.2, -0.1
14437, 1.5333333333333, 1.175, -0.1
14438, 1.5125, 1.15, -0.1
14439, 1.5333333333333, 1.125, -0.1
14440, 1.5125, 1.1, -0.1
14441, 1.5333333333333, 1.075, -0.1
14442, 1.5125, 1.05, -0.1
14443, 1.5333333333333, 1.025, -0.1
14444, 1.5125, 1, -0.1
14445, 1.5333333333333, 0.975, -0.1
14446, 1.5125, 0.95, -0.1
14447, 1.5333333333333, 0.925, -0.1
14448, 1.5125, 0.9, -0.1
14449, 1.5333333333333, 0.875, -0.1
14450, 1.5125, 0.85, -0.1
14451, 1.5333333333333, 0.825, -0.1
14452, 1.5125, 0.8, -0.1
14453, 1.5333333333333, 0.775, -0.1
14454, 1.5125, 0.75, -0.1
14455, 1.5333333333333, 0.725, -0.1
14456, 1.5125, 0.7, -0.1
14457, 1.5333333333333, 0.675, -0.1
14458, 1.5125, 0.65, -0.1
14459, 1.5333333333333, 0.625, -0.1
14460, 1.5125, 0.6, -0.1
14461, 1.5333333333333, 0.575, -0.1
14462, 1.5125, 0.55, -0.1
14463, 1.5333333333333, 0.525, -0.1
14464, 1.5125, 0.5, -0.1
14465, 1.5333333333333, 0.475, -0.1
14466, 1.5125, 0.45, -0.1
14467, 1.5333333333333, 0.425, -0.1
14468, 1.5125, 0.4, -0.1
14469, 1.5333333333333, 0.375, -0.1
14470, 1.5125, 0.35, -0.1
14471, 1.5333333333333, 0.325, -0.1
14472, 1.5125, 0.3, -0.1
14473, 1.5333333333333, 0.275, -0.1
14474, 1.5125, 0.25, -0.1
14475, 1.5333333333333, 0.225, -0.1
14476, 1.5125, 0.2, -0.1
14477, 1.5333333333333, 0.175, -0.1
14478, 1.575, 1.325, -0.1
14479, 1.5541666666667, 1.3, -0.1
14480, 1.575, 1.275, -0.1
14481, 1.5541666666667, 1.25, -0.1
14482, 1.575, 1.225, -0.1
14483, 1.5541666666667, 1.2, -0.1
14484, 1.575, 1.175, -0.1
14485, 1.5541666666667, 1.15, -0.1
14486, 1.575, 1.125, -0.1
14487, 1.5541666666667, 1.1, -0.1
14488, 1.575, 1.075, -0.1
14489, 1.5541666666667, 1.05, -0.1
14490, 1.575, 1.025, -0.1
14491, 1.5541666666667, 1, -0.1
14492, 1.575, 0.975, -0.1
14493, 1.5541666666667, 0.95, -0.1
14494, 1.575, 0.925, -0.1
14495, 1.5541666666667, 0.9, -0.1
14496, 1.575, 0.875, -0.1
14497, 1.5541666666667, 0.85, -0.1
14498, 1.575, 0.825, -0.1
14499, 1.5541666666667, 0.8, -0.1
14500, 1.575, 0.775, -0.1
14501, 1.5541666666667, 0.75, -0.1
14502, 1.575, 0.725, -0.1
14503, 1.5541666666667, 0.7, -0.1
14504, 1.575, 0.675, -0.1
14505, 1.5541666666667, 0.65, -0.1
14506, 1.575, 0.625, -0.1
14507, 1.5541666666667, 0.6, -0.1
14508, 1.575, 0.575, -0.1
14509, 1.5541666666667, 0.55, -0.1
14510, 1.575, 0.525, -0.1
14511, 1.5541666666667, 0.5, -0.1
14512, 1.575, 0.475, -0.1
14513, 1.5541666666667, 0.45, -0.1
14514, 1.575, 0.425, -0.1
14515, 1.5541666666667, 0.4, -0.1
14516, 1.575, 0.375, -0.1
14517, 1.5541666666667, 0.35, -0.1
14518, 1.575, 0.325, -0.1
14519, 1.5541666666667, 0.3, -0.1
14520, 1.575, 0.275, -0.1
14521, 1.5541666666667, 0.25, -0.1
14522, 1.575, 0.225, -0.1
14523, 1.5541666666667, 0.2, -0.1
14524, 1.575, 0.175, -0.1
14525, 1.6166666666667, 1.325, -0.1
14526, 1.5958333333333, 1.3, -0.1
14527, 1.6166666666667, 1.275, -0.1
14528, 1.5958333333333, 1.25, -0.1
14529, 1.6166666666667, 1.225, -0.1
14530, 1.5958333333333, 1.2, -0.1
14531, 1.6166666666667, 1.175, -0.1
14532, 1.5958333333333, 1.15, -0.1
14533, 1.6166666666667, 1.125, -0.1
14534, 1.5958333333333, 1.1, -0.1
14535, 1.6166666666667, 1.075, -0.1
14536, 1.5958333333333, 1.05, -0.1
14537, 1.6166666666667, 1.025, -0.1
14538, 1.5958333333333, 1, -0.1
14539, 1.6166666666667, 0.975, -0.1
14540, 1.5958333333333, 0.95, -0.1
14541, 1.6166666666667, 0.925, -0.1
14542, 1.5958333333333, 0.9, -0.1
14543, 1.6166666666667, 0.875, -0.1
14544, 1.5958333333333, 0.85, -0.1
14545, 1.6166666666667, 0.825, -0.1
14546, 1.5958333333333, 0.8, -0.1
14547, 1.6166666666667, 0.775, -0.1
14548, 1.5958333333333, 0.75, -0.1
14549, 1.6166666666667, 0.725, -0.1
14550, 1.5958333333333, 0.7, -0.1
14551, 1.6166666666667, 0.675, -0.1
14552, 1.5958333333333, 0.65, -0.1
14553, 1.6166666666667, 0.625, -0.1
14554, 1.5958333333333, 0.6, -0.1
14555, 1.6166666666667, 0.575, -0.1
14556, 1.5958333333333, 0.55, -0.1
14557, 1.6166666666667, 0.525, -0.1
14558, 1.5958333333333, 0.5, -0.1
14559, 1.6166666666667, 0.475, -0.1
14560, 1.5958333333333, 0.45, -0.1
14561, 1.6166666666667, 0.425, -0.1
14562, 1.5958333333333, 0.4, -0.1
14563, 1.6166666666667, 0.375, -0.1
14564, 1.5958333333333, 0.35, -0.1
14565, 1.6166666666667, 0.325, -0.1
14566, 1.5958333333333, 0.3, -0.1
14567, 1.6166666666667, 0.275, -0.1
14568, 1.5958333333333, 0.25, -0.1
14569, 1.6166666666667, 0.225, -0.1
14570, 1.5958333333333, 0.2, -0.1
14571, 1.6166666666667, 0.175, -0.1
14572, 1.6583333333333, 1.325, -0.1
14573, 1.6375, 1.3, -0.1
14574, 1.6583333333333, 1.275, -0.1
14575, 1.6375, 1.25, -0.1
14576, 1.6583333333333, 1.225, -0.1
14577, 1.6375, 1.2, -0.1
14578, 1.6583333333333, 1.175, -0.1
14579, 1.6375, 1.15, -0.1
14580, 1.6583333333333, 1.125, -0.1
14581, 1.6375, 1.1, -0.1
14582, 1.6583333333333, 1.075, -0.1
14583, 1.6375, 1.05, -0.1
14584, 1.6583333333333, 1.025, -0.1
14585, 1.6375, 1, -0.1
14586, 1.6583333333333, 0.975, -0.1
14587, 1.6375, 0.95, -0.1
14588, 1.6583333333333, 0.925, -0.1
14589, 1.6375, 0.9, -0.1
14590, 1.6583333333333, 0.875, -0.1
14591, 1.6375, 0.85, -0.1
14592, 1.6583333333333, 0.825, -0.1
14593, 1.6375, 0.8, -0.1
14594, 1.6583333333333, 0.775, -0.1
14595, 1.6375, 0.75, -0.1
14596, 1.6583333333333, 0.725, -0.1
14597, 1.6375, 0.7, -0.1
14598, 1.6583333333333, 0.675, -0.1
14599, 1.6375, 0.65, -0.1
14600, 1.6583333333333, 0.625, -0.1
14601, 1.6375, 0.6, -0.1
14602, 1.6583333333333, 0.575, -0.1
14603, 1.6375, 0.55, -0.1
14604, 1.6583333333333, 0.525, -0.1
14605, 1.6375, 0.5, -0.1
14606, 1.6583333333333, 0.475, -0.1
14607, 1.6375, 0.45, -0.1
14608, 1.6583333333333, 0.425, -0.1
14609, 1.6375, 0.4, -0.1
14610, 1.6583333333333, 0.375, -0.1
14611, 1.6375, 0.35, -0.1
14612, 1.6583333333333, 0.325, -0.1
14613, 1.6375, 0.3, -0.1
14614, 1.6583333333333, 0.275, -0.1
14615, 1.6375, 0.25, -0.1
14616, 1.6583333333333, 0.225, -0.1
14617, 1.6375, 0.2, -0.1
14618, 1.6583333333333, 0.175, -0.1
14619, 1.7, 1.325, -0.1
14620, 1.6791666666667, 1.3, -0.1
14621, 1.7, 1.275, -0.1
14622, 1.6791666666667, 1.25, -0.1
14623, 1.7, 1.225, -0.1
14624, 1.6791666666667, 1.2, -0.1
14625, 1.7, 1.175, -0.1
14626, 1.6791666666667, 1.15, -0.1
14627, 1.7, 1.125, -0.1
14628, 1.6791666666667, 1.1, -0.1
14629, 1.7, 1.075, -0.1
14630, 1.6791666666667, 1.05, -0.1
14631, 1.7, 1.025, -0.1
14632, 1.6791666666667, 1, -0.1
14633, 1.7, 0.975, -0.1
14634, 1.6791666666667, 0.95, -0.1
14635, 1.7, 0.925, -0.1
14636, 1.6791666666667, 0.9, -0.1
14637, 1.7, 0.875, -0.1
14638, 1.6791666666667, 0.85, -0.1
14639, 1.7, 0.825, -0.1
14640, 1.6791666666667, 0.8, -0.1
14641, 1.7, 0.775, -0.1
14642, 1.6791666666667, 0.75, -0.1
14643, 1.7, 0.725, -0.1
14644, 1.6791666666667, 0.7, -0.1
14645, 1.7, 0.675, -0.1
14646, 1.6791666666667, 0.65, -0.1
14647, 1.7, 0.625, -0.1
14648, 1.6791666666667, 0.6, -0.1
14649, 1.7, 0.575, -0.1
14650, 1.6791666666667, 0.55, -0.1
14651, 1.7, 0.525, -0.1
14652, 1.6791666666667, 0.5, -0.1
14653, 1.7, 0.475, -0.1
14654, 1.6791666666667, 0.45, -0.1
14655, 1.7, 0.425, -0.1
14656, 1.6791666666667, 0.4, -0.1
14657, 1.7, 0.375, -0.1
14658, 1.6791666666667, 0.35, -0.1
14659, 1.7, 0.325, -0.1
14660, 1.6791666666667, 0.3, -0.1
14661, 1.7, 0.275, -0.1
14662, 1.6791666666667, 0.25, -0.1
14663, 1.7, 0.225, -0.1
14664, 1.6791666666667, 0.2, -0.1
14665, 1.7, 0.175, -0.1
14666, 1.7416666666667, 1.325, -0.1
14667, 1.7208333333333, 1.3, -0.1
14668, 1.7416666666667, 1.275, -0.1
14669, 1.7208333333333, 1.25, -0.1
14670, 1.7416666666667, 1.225, -0.1
14671, 1.7208333333333, 1.2, -0.1
14672, 1.7416666666667, 1.175, -0.1
14673, 1.7208333333333, 1.15, -0.1
14674, 1.7416666666667, 1.125, -0.1
14675, 1.7208333333333, 1.1, -0.1
14676, 1.7416666666667, 1.075, -0.1
14677, 1.7208333333333, 1.05, -0.1
14678, 1.7416666666667, 1.025, -0.1
14679, 1.7208333333333, 1, -0.1
14680, 1.7416666666667, 0.975, -0.1
14681, 1.7208333333333, 0.95, -0.1
14682, 1.7416666666667, 0.925, -0.1
14683, 1.7208333333333, 0.9, -0.1
14684, 1.7416666666667, 0.875, -0.1
14685, 1.7208333333333, 0.85, -0.1
14686, 1.7416666666667, 0.825, -0.1
14687, 1.7208333333333, 0.8, -0.1
14688, 1.7416666666667, 0.775, -0.1
14689, 1.7208333333333, 0.75, -0.1
14690, 1.7416666666667, 0.725, -0.1
14691, 1.7208333333333, 0.7, -0.1
14692, 1.7416666666667, 0.675, -0.1
14693, 1.7208333333333, 0.65, -0.1
14694, 1.7416666666667, 0.625, -0.1
14695, 1.7208333333333, 0.6, -0.1
14696, 1.7416666666667, 0.575, -0.1
14697, 1.7208333333333, 0.55, -0.1
14698, 1.7416666666667, 0.525, -0.1
14699, 1.7208333333333, 0.5, -0.1
14700, 1.7416666666667, 0.475, -0.1
14701, 1.7208333333333, 0.45, -0.1
14702, 1.7416666666667, 0.425, -0.1
14703, 1.7208333333333, 0.4, -0.1
14704, 1.7416666666667, 0.375, -0.1
14705, 1.7208333333333, 0.35, -0.1
14706, 1.7416666666667, 0.325, -0.1
14707, 1.7208333333333, 0.3, -0.1
14708, 1.7416666666667, 0.275, -0.1
14709, 1.7208333333333, 0.25, -0.1
14710, 1.7416666666667, 0.225, -0.1
14711, 1.7208333333333, 0.2, -0.1
14712, 1.7416666666667, 0.175, -0.1
14713, 1.7833333333333, 1.325, -0.1
14714, 1.7625, 1.3, -0.1
14715, 1.7833333333333, 1.275, -0.1
14716, 1.7625, 1.25, -0.1
14717, 1.7833333333333, 1.225, -0.1
14718, 1.7625, 1.2, -0.1
14719, 1.7833333333333, 1.175, -0.1
14720, 1.7625, 1.15, -0.1
14721, 1.7833333333333, 1.125, -0.1
14722, 1.7625, 1.1, -0.1
14723, 1.7833333333333, 1.075, -0.1
14724, 1.7625, 1.05, -0.1
14725, 1.7833333333333, 1.025, -0.1
14726, 1.7625, 1, -0.1
14727, 1.7833333333333, 0.975, -0.1
14728, 1.7625, 0.95, -0.1
14729, 1.7833333333333, 0.925, -0.1
14730, 1.7625, 0.9, -0.1
14731, 1.7833333333333, 0.875, -0.1
14732, 1.7625, 0.85, -0.1
14733, 1.7833333333333, 0.825, -0.1
14734, 1.7625, 0.8, -0.1
14735, 1.7833333333333, 0.775, -0.1
14736, 1.7625, 0.75, -0.1
14737, 1.7833333333333, 0.725, -0.1
14738, 1.7625, 0.7, -0.1
14739, 1.7833333333333, 0.675, -0.1
14740, 1.7625, 0.65, -0.1
14741, 1.7833333333333, 0.625, -0.1
14742, 1.7625, 0.6, -0.1
14743, 1.7833333333333, 0.575, -0.1
14744, 1.7625, 0.55, -0.1
14745, 1.7833333333333, 0.525, -0.1
14746, 1.7625, 0.5, -0.1
14747, 1.7833333333333, 0.475, -0.1
14748, 1.7625, 0.45, -0.1
14749, 1.7833333333333, 0.425, -0.1
14750, 1.7625, 0.4, -0.1
14751, 1.7833333333333, 0.375, -0.1
14752, 1.7625, 0.35, -0.1
14753, 1.7833333333333, 0.325, -0.1
14754, 1.7625, 0.3, -0.1
14755, 1.7833333333333, 0.275, -0.1
14756, 1.7625, 0.25, -0.1
14757, 1.7833333333333, 0.225, -0.1
14758, 1.7625, 0.2, -0.1
14759, 1.7833333333333, 0.175, -0.1
14760, 1.825, 1.325, -0.1
14761, 1.8041666666667, 1.3, -0.1
14762, 1.825, 1.275, -0.1
14763, 1.8041666666667, 1.25, -0.1
14764, 1.825, 1.225, -0.1
14765, 1.8041666666667, 1.2, -0.1
14766, 1.825, 1.175, -0.1
14767, 1.8041666666667, 1.15, -0.1
14768, 1.825, 1.125, -0.1
14769, 1.8041666666667, 1.1, -0.1
14770, 1.825, 1.075, -0.1
14771, 1.8041666666667, 1.05, -0.1
14772, 1.825, 1.025, -0.1
14773, 1.8041666666667, 1, -0.1
14774, 1.825, 0.975, -0.1
14775, 1.8041666666667, 0.95, -0.1
14776, 1.825, 0.925, -0.1
14777, 1.8041666666667, 0.9, -0.1
14778, 1.825, 0.875, -0.1
14779, 1.8041666666667, 0.85, -0.1
14780, 1.825, 0.825, -0.1
14781, 1.8041666666667, 0.8, -0.1
14782, 1.825, 0.775, -0.1
14783, 1.8041666666667, 0.75, -0.1
14784, 1.825, 0.725, -0.1
14785, 1.8041666666667, 0.7, -0.1
14786, 1.825, 0.675, -0.1
14787, 1.8041666666667, 0.65, -0.1
14788, 1.825, 0.625, -0.1
14789, 1.8041666666667, 0.6, -0.1
14790, 1.825, 0.575, -0.1
14791, 1.8041666666667, 0.55, -0.1
14792, 1.825, 0.525, -0.1
14793, 1.8041666666667, 0.5, -0.1
14794, 1.825, 0.475, -0.1
14795, 1.8041666666667, 0.45, -0.1
14796, 1.825, 0.425, -0.1
14797, 1.8041666666667, 0.4, -0.1
14798, 1.825, 0.375, -0.1
14799, 1.8041666666667, 0.35, -0.1
14800, 1.825, 0.325, -0.1
14801, 1.8041666666667, 0.3, -0.1
14802, 1.825, 0.275, -0.1
14803, 1.8041666666667, 0.25, -0.1
14804, 1.825, 0.225, -0.1
14805, 1.8041666666667, 0.2, -0.1
14806, 1.825, 0.175, -0.1
14807, 1.8666666666667, 1.325, -0.1
14808, 1.8458333333333, 1.3, -0.1
14809, 1.8666666666667, 1.275, -0.1
14810, 1.8458333333333, 1.25, -0.1
14811, 1.8666666666667, 1.225, -0.1
14812, 1.8458333333333, 1.2, -0.1
14813, 1.8666666666667, 1.175, -0.1
14814, 1.8458333333333, 1.15, -0.1
14815, 1.8666666666667, 1.125, -0.1
14816, 1.8458333333333, 1.1, -0.1
14817, 1.8666666666667, 1.075, -0.1
14818, 1.8458333333333, 1.05, -0.1
14819, 1.8666666666667, 1.025, -0.1
14820, 1.8458333333333, 1, -0.1
14821, 1.8666666666667, 0.975, -0.1
14822, 1.8458333333333, 0.95, -0.1
14823, 1.8666666666667, 0.925, -0.1
14824, 1.8458333333333, 0.9, -0.1
14825, 1.8666666666667, 0.875, -0.1
14826, 1.8458333333333, 0.85, -0.1
14827, 1.8666666666667, 0.825, -0.1
14828, 1.8458333333333, 0.8, -0.1
14829, 1.8666666666667, 0.775, -0.1
14830, 1.8458333333333, 0.75, -0.1
14831, 1.8666666666667, 0.725, -0.1
14832, 1.8458333333333, 0.7, -0.1
14833, 1.8666666666667, 0.675, -0.1
14834, 1.8458333333333, 0.65, -0.1
14835, 1.8666666666667, 0.625, -0.1
14836, 1.8458333333333, 0.6, -0.1
14837, 1.8666666666667, 0.575, -0.1
14838, 1.8458333333333, 0.55, -0.1
14839, 1.8666666666667, 0.525, -0.1
14840, 1.8458333333333, 0.5, -0.1
14841, 1.8666666666667, 0.475, -0.1
14842, 1.8458333333333, 0.45, -0.1
14843, 1.8666666666667, 0.425, -0.1
14844, 1.8458333333333, 0.4, -0.1
14845, 1.8666666666667, 0.375, -0.1
14846, 1.8458333333333, 0.35, -0.1
14847, 1.8666666666667, 0.325, -0.1
14848, 1.8458333333333, 0.3, -0.1
14849, 1.8666666666667, 0.275, -0.1
14850, 1.8458333333333, 0.25, -0.1
14851, 1.8666666666667, 0.225, -0.1
14852, 1.8458333333333, 0.2, -0.1
14853, 1.8666666666667, 0.175, -0.1
14854, 1.9083333333333, 1.325, -0.1
14855, 1.8875, 1.3, -0.1
14856, 1.9083333333333, 1.275, -0.1
14857, 1.8875, 1.25, -0.1
14858, 1.9083333333333, 1.225, -0.1
14859, 1.8875, 1.2, -0.1
14860, 1.9083333333333, 1.175, -0.1
14861, 1.8875, 1.15, -0.1
14862, 1.9083333333333, 1.125, -0.1
14863, 1.8875, 1.1, -0.1
14864, 1.9083333333333, 1.075, -0.1
14865, 1.8875, 1.05, -0.1
14866, 1.9083333333333, 1.025, -0.1
14867, 1.8875, 1, -0.1
14868, 1.9083333333333, 0.975, -0.1
14869, 1.8875, 0.95, -0.1
14870, 1.9083333333333, 0.925, -0.1
14871, 1.8875, 0.9, -0.1
14872, 1.9083333333333, 0.875, -0.1
14873, 1.8875, 0.85, -0.1
14874, 1.9083333333333, 0.825, -0.1
14875, 1.8875, 0.8, -0.1
14876, 1.9083333333333, 0.775, -0.1
14877, 1.8875, 0.75, -0.1
14878, 1.9083333333333, 0.725, -0.1
14879, 1.8875, 0.7, -0.1
14880, 1.9083333333333, 0.675, -0.1
14881, 1.8875, 0.65, -0.1
14882, 1.9083333333333, 0.625, -0.1
14883, 1.8875, 0.6, -0.1
14884, 1.9083333333333, 0.575, -0.1
14885, 1.8875, 0.55, -0.1
14886, 1.9083333333333, 0.525, -0.1
14887, 1.8875, 0.5, -0.1
14888, 1.9083333333333, 0.475, -0.1
14889, 1.8875, 0.45, -0.1
14890, 1.9083333333333, 0.425, -0.1
14891, 1.8875, 0.4, -0.1
14892, 1.9083333333333, 0.375, -0.1
14893, 1.8875, 0.35, -0.1
14894, 1.9083333333333, 0.325, -0.1
14895, 1.8875, 0.3, -0.1
14896, 1.9083333333333, 0.275, -0.1
14897, 1.8875, 0.25, -0.1
14898, 1.9083333333333, 0.225, -0.1
14899, 1.8875, 0.2, -0.1
14900, 1.9083333333333, 0.175, -0.1
14901, 1.95, 1.325, -0.1
14902, 1.9291666666667, 1.3, -0.1
14903, 1.95, 1.275, -0.1
14904, 1.9291666666667, 1.25, -0.1
14905, 1.95, 1.225, -0.1
14906, 1.9291666666667, 1.2, -0.1
14907, 1.95, 1.175, -0.1
14908, 1.9291666666667, 1.15, -0.1
14909, 1.95, 1.125, -0.1
14910, 1.9291666666667, 1.1, -0.1
14911, 1.95, 1.075, -0.1
14912, 1.9291666666667, 1.05, -0.1
14913, 1.95, 1.025, -0.1
14914, 1.9291666666667, 1, -0.1
14915, 1.95, 0.975, -0.1
14916, 1.9291666666667, 0.95, -0.1
14917, 1.95, 0.925, -0.1
14918, 1.9291666666667, 0.9, -0.1
14919, 1.95, 0.875, -0.1
14920, 1.9291666666667, 0.85, -0.1
14921, 1.95, 0.825, -0.1
14922, 1.9291666666667, 0.8, -0.1
14923, 1.95, 0.775, -0.1
14924, 1.9291666666667, 0.75, -0.1
14925, 1.95, 0.725, -0.1
14926, 1.9291666666667, 0.7, -0.1
14927, 1.95, 0.675, -0.1
14928, 1.9291666666667, 0.65, -0.1
14929, 1.95, 0.625, -0.1
14930, 1.9291666666667, 0.6, -0.1
14931, 1.95, 0.575, -0.1
14932, 1.9291666666667, 0.55, -0.1
14933, 1.95, 0.525, -0.1
14934, 1.9291666666667, 0.5, -0.1
14935, 1.95, 0.475, -0.1
14936, 1.9291666666667, 0.45, -0.1
14937, 1.95, 0.425, -0.1
14938, 1.9291666666667, 0.4, -0.1
14939, 1.95, 0.375, -0.1
14940, 1.9291666666667, 0.35, -0.1
14941, 1.95, 0.325, -0.1
14942, 1.9291666666667, 0.3, -0.1
14943, 1.95, 0.275, -0.1
14944, 1.9291666666667, 0.25, -0.1
14945, 1.95, 0.225, -0.1
14946, 1.9291666666667, 0.2, -0.1
14947, 1.95, 0.175, -0.1
14948, 1.9916666666667, 1.325, -0.1
14949, 1.9708333333333, 1.3, -0.1
14950, 1.9916666666667, 1.275, -0.1
14951, 1.9708333333333, 1.25, -0.1
14952, 1.9916666666667, 1.225, -0.1
14953, 1.9708333333333, 1.2, -0.1
14954, 1.9916666666667, 1.175, -0.1
14955, 1.9708333333333, 1.15, -0.1
14956, 1.9916666666667, 1.125, -0.1
14957, 1.9708333333333, 1.1, -0.1
14958, 1.9916666666667, 1.075, -0.1
14959, 1.9708333333333, 1.05, -0.1
14960, 1.9916666666667, 1.025, -0.1
14961, 1.9708333333333, 1, -0.1
14962, 1.9916666666667, 0.975, -0.1
14963, 1.9708333333333, 0.95, -0.1
14964, 1.9916666666667, 0.925, -0.1
14965, 1.9708333333333, 0.9, -0.1
14966, 1.9916666666667, 0.875, -0.1
14967, 1.9708333333333, 0.85, -0.1
14968, 1.9916666666667, 0.825, -0.1
14969, 1.9708333333333, 0.8, -0.1
14970, 1.9916666666667, 0.775, -0.1
14971, 1.9708333333333, 0.75, -0.1
14972, 1.9916666666667, 0.725, -0.1
14973, 1.9708333333333, 0.7, -0.1
14974, 1.9916666666667, 0.675, -0.1
14975, 1.9708333333333, 0.65, -0.1
14976, 1.9916666666667, 0.625, -0.1
14977, 1.9708333333333, 0.6, -0.1
14978, 1.9916666666667, 0.575, -0.1
14979, 1.9708333333333, 0.55, -0.1
14980, 1.9916666666667, 0.525, -0.1
14981, 1.9708333333333, 0.5, -0.1
14982, 1.9916666666667, 0.475, -0.1
14983, 1.9708333333333, 0.45, -0.1
14984, 1.9916666666667, 0.425, -0.1
14985, 1.9708333333333, 0.4, -0.1
14986, 1.9916666666667, 0.375, -0.1
14987, 1.9708333333333, 0.35, -0.1
14988, 1.9916666666667, 0.325, -0.1
14989, 1.9708333333333, 0.3, -0.1
14990, 1.9916666666667, 0.275, -0.1
14991, 1.9708333333333, 0.25, -0.1
14992, 1.9916666666667, 0.225, -0.1
14993, 1.9708333333333, 0.2, -0.1
14994, 1.9916666666667, 0.175, -0.1
14995, 2.0333333333333, 1.325, -0.1
14996, 2.0125, 1.3, -0.1
14997, 2.0333333333333, 1.275, -0.1
14998, 2.0125, 1.25, -0.1
14999, 2.0333333333333, 1.225, -0.1
15000, 2.0125, 1.2, -0.1
15001, 2.0333333333333, 1.175, -0.1
15002, 2.0125, 1.15, -0.1
15003, 2.0333333333333, 1.125, -0.1
15004, 2.0125, 1.1, -0.1
15005, 2.0333333333333, 1.075, -0.1
15006, 2.0125, 1.05, -0.1
15007, 2.0333333333333, 1.025, -0.1
15008, 2.0125, 1, -0.1
15009, 2.0333333333333, 0.975, -0.1
15010, 2.0125, 0.95, -0.1
15011, 2.0333333333333, 0.925, -0.1
15012, 2.0125, 0.9, -0.1
15013, 2.0333333333333, 0.875, -0.1
15014, 2.0125, 0.85, -0.1
15015, 2.0333333333333, 0.825, -0.1
15016, 2.0125, 0.8, -0.1
15017, 2.0333333333333, 0.775, -0.1
15018, 2.0125, 0.75, -0.1
15019, 2.0333333333333, 0.725, -0.1
15020, 2.0125, 0.7, -0.1
15021, 2.0333333333333, 0.675, -0.1
15022, 2.0125, 0.65, -0.1
15023, 2.0333333333333, 0.625, -0.1
15024, 2.0125, 0.6, -0.1
15025, 2.0333333333333, 0.575, -0.1
15026, 2.0125, 0.55, -0.1
15027, 2.0333333333333, 0.525, -0.1
15028, 2.0125, 0.5, -0.1
15029, 2.0333333333333, 0.475, -0.1
15030, 2.0125, 0.45, -0.1
15031, 2.0333333333333, 0.425, -0.1
15032, 2.0125, 0.4, -0.1
15033, 2.0333333333333, 0.375, -0.1
15034, 2.0125, 0.35, -0.1
15035, 2.0333333333333, 0.325, -0.1
15036, 2.0125, 0.3, -0.1
15037, 2.0333333333333, 0.275, -0.1
15038, 2.0125, 0.25, -0.1
15039, 2.0333333333333, 0.225, -0.1
15040, 2.0125, 0.2, -0.1
15041, 2.0333333333333, 0.175, -0.1
15042, 2.075, 1.325, -0.1
15043, 2.0541666666667, 1.3, -0.1
15044, 2.075, 1.275, -0.1
15045, 2.0541666666667, 1.25, -0.1
15046, 2.075, 1.225, -0.1
15047, 2.0541666666667, 1.2, -0.1
15048, 2.075, 1.175, -0.1
15049, 2.0541666666667, 1.15, -0.1
15050, 2.075, 1.125, -0.1
15051, 2.0541666666667, 1.1, -0.1
15052, 2.075, 1.075, -0.1
15053, 2.0541666666667, 1.05, -0.1
15054, 2.075, 1.025, -0.1
15055, 2.0541666666667, 1, -0.1
15056, 2.075, 0.975, -0.1
15057, 2.0541666666667, 0.95, -0.1
15058, 2.075, 0.925, -0.1
15059, 2.0541666666667, 0.9, -0.1
15060, 2.075, 0.875, -0.1
15061, 2.0541666666667, 0.85, -0.1
15062, 2.075, 0.825, -0.1
15063, 2.0541666666667, 0.8, -0.1
15064, 2.075, 0.775, -0.1
15065, 2.0541666666667, 0.75, -0.1
15066, 2.075, 0.725, -0.1
15067, 2.0541666666667, 0.7, -0.1
15068, 2.075, 0.675, -0.1
15069, 2.0541666666667, 0.65, -0.1
15070, 2.075, 0.625, -0.1
15071, 2.0541666666667, 0.6, -0.1
15072, 2.075, 0.575, -0.1
15073, 2.0541666666667, 0.55, -0.1
15074, 2.075, 0.525, -0.1
15075, 2.0541666666667, 0.5, -0.1
15076, 2.075, 0.475, -0.1
15077, 2.0541666666667, 0.45, -0.1
15078, 2.075, 0.425, -0.1
15079, 2.0541666666667, 0.4, -0.1
15080, 2.075, 0.375, -0.1
15081, 2.0541666666667, 0.35, -0.1
15082, 2.075, 0.325, -0.1
15083, 2.0541666666667, 0.3, -0.1
15084, 2.075, 0.275, -0.1
15085, 2.0541666666667, 0.25, -0.1
15086, 2.075, 0.225, -0.1
15087, 2.0541666666667, 0.2, -0.1
15088, 2.075, 0.175, -0.1
15089, 2.1166666666667, 1.325, -0.1
15090, 2.0958333333333, 1.3, -0.1
15091, 2.1166666666667, 1.275, -0.1
15092, 2.0958333333333, 1.25, -0.1
15093, 2.1166666666667, 1.225, -0.1
15094, 2.0958333333333, 1.2, -0.1
15095, 2.1166666666667, 1.175, -0.1
15096, 2.0958333333333, 1.15, -0.1
15097, 2.1166666666667, 1.125, -0.1
15098, 2.0958333333333, 1.1, -0.1
15099, 2.1166666666667, 1.075, -0.1
15100, 2.0958333333333, 1.05, -0.1
15101, 2.1166666666667, 1.025, -0.1
15102, 2.0958333333333, 1, -0.1
15103, 2.1166666666667, 0.975, -0.1
15104, 2.0958333333333, 0.95, -0.1
15105, 2.1166666666667, 0.925, -0.1
15106, 2.0958333333333, 0.9, -0.1
15107, 2.1166666666667, 0.875, -0.1
15108, 2.0958333333333, 0.85, -0.1
15109, 2.1166666666667, 0.825, -0.1
15110, 2.0958333333333, 0.8, -0.1
15111, 2.1166666666667, 0.775, -0.1
15112, 2.0958333333333, 0.75, -0.1
15113, 2.1166666666667, 0.725, -0.1
15114, 2.0958333333333, 0.7, -0.1
15115, 2.1166666666667, 0.675, -0.1
15116, 2.0958333333333, 0.65, -0.1
15117, 2.1166666666667, 0.625, -0.1
15118, 2.0958333333333, 0.6, -0.1
15119, 2.1166666666667, 0.575, -0.1
15120, 2.0958333333333, 0.55, -0.1
15121, 2.1166666666667, 0.525, -0.1
15122, 2.0958333333333, 0.5, -0.1
15123, 2.1166666666667, 0.475, -0.1
15124, 2.0958333333333, 0.45, -0.1
15125, 2.1166666666667, 0.425, -0.1
15126, 2.0958333333333, 0.4, -0.1
15127, 2.1166666666667, 0.375, -0.1
15128, 2.0958333333333, 0.35, -0.1
15129, 2.1166666666667, 0.325, -0.1
15130, 2.0958333333333, 0.3, -0.1
15131, 2.1166666666667, 0.275, -0.1
15132, 2.0958333333333, 0.25, -0.1
15133, 2.1166666666667, 0.225, -0.1
15134, 2.0958333333333, 0.2, -0.1
