28727, 42987, 43079, 43083, 42991, 42988, 43080, 43084, 42992, 46091, 46103, 46104, 45800, 46094, 46106, 46107, 
45803, 45789, 46092, 46105, 45802
28728, 42988, 43080, 43084, 42992, 42989, 43081, 43085, 42993, 46094, 46106, 46107, 45803, 46097, 46109, 46110, 
45806, 45792, 46095, 46108, 45805
28729, 42989, 43081, 43085, 42993, 42990, 43082, 43086, 42994, 46097, 46109, 46110, 45806, 46100, 46112, 46113, 
45809, 45795, 46098, 46111, 45808
28730, 42990, 43082, 43086, 42994, 17240, 17263, 17264, 17241, 46100, 46112, 46113, 45809, 0, 0, 0, 
0, 45798, 46101, 46114, 45811
28731, 6429, 6452, 6453, 6430, 42991, 43083, 43087, 42995, 0, 0, 0, 0, 46104, 46116, 46117, 
45813, 45799, 46102, 46115, 45812
28732, 42991, 43083, 43087, 42995, 42992, 43084, 43088, 42996, 46104, 46116, 46117, 45813, 46107, 46119, 46120, 
45816, 45802, 46105, 46118, 45815
28733, 42992, 43084, 43088, 42996, 42993, 43085, 43089, 42997, 46107, 46119, 46120, 45816, 46110, 46122, 46123, 
45819, 45805, 46108, 46121, 45818
28734, 42993, 43085, 43089, 42997, 42994, 43086, 43090, 42998, 46110, 46122, 46123, 45819, 46113, 46125, 46126, 
45822, 45808, 46111, 46124, 45821
28735, 42994, 43086, 43090, 42998, 17241, 17264, 17265, 17242, 46113, 46125, 46126, 45822, 0, 0, 0, 
0, 45811, 46114, 46127, 45824
28736, 6430, 6453, 6454, 6431, 42995, 43087, 43091, 42999, 0, 0, 0, 0, 46117, 46129, 46130, 
45826, 45812, 46115, 46128, 45825
28737, 42995, 43087, 43091, 42999, 42996, 43088, 43092, 43000, 46117, 46129, 46130, 45826, 46120, 46132, 46133, 
45829, 45815, 46118, 46131, 45828
28738, 42996, 43088, 43092, 43000, 42997, 43089, 43093, 43001, 46120, 46132, 46133, 45829, 46123, 46135, 46136, 
45832, 45818, 46121, 46134, 45831
28739, 42997, 43089, 43093, 43001, 42998, 43090, 43094, 43002, 46123, 46135, 46136, 45832, 46126, 46138, 46139, 
45835, 45821, 46124, 46137, 45834
28740, 42998, 43090, 43094, 43002, 17242, 17265, 17266, 17243, 46126, 46138, 46139, 45835, 0, 0, 0, 
0, 45824, 46127, 46140, 45837
28741, 6431, 6454, 6455, 6432, 42999, 43091, 43095, 43003, 0, 0, 0, 0, 46130, 46142, 46143, 
45839, 45825, 46128, 46141, 45838
28742, 42999, 43091, 43095, 43003, 43000, 43092, 43096, 43004, 46130, 46142, 46143, 45839, 46133, 46145, 46146, 
45842, 45828, 46131, 46144, 45841
28743, 43000, 43092, 43096, 43004, 43001, 43093, 43097, 43005, 46133, 46145, 46146, 45842, 46136, 46148, 46149, 
45845, 45831, 46134, 46147, 45844
28744, 43001, 43093, 43097, 43005, 43002, 43094, 43098, 43006, 46136, 46148, 46149, 45845, 46139, 46151, 46152, 
45848, 45834, 46137, 46150, 45847
28745, 43002, 43094, 43098, 43006, 17243, 17266, 17267, 17244, 46139, 46151, 46152, 45848, 0, 0, 0, 
0, 45837, 46140, 46153, 45850
28746, 6432, 6455, 6456, 6433, 43003, 43095, 43099, 43007, 0, 0, 0, 0, 46143, 46155, 46156, 
45852, 45838, 46141, 46154, 45851
28747, 43003, 43095, 43099, 43007, 43004, 43096, 43100, 43008, 46143, 46155, 46156, 45852, 46146, 46158, 46159, 
45855, 45841, 46144, 46157, 45854
28748, 43004, 43096, 43100, 43008, 43005, 43097, 43101, 43009, 46146, 46158, 46159, 45855, 46149, 46161, 46162, 
45858, 45844, 46147, 46160, 45857
28749, 43005, 43097, 43101, 43009, 43006, 43098, 43102, 43010, 46149, 46161, 46162, 45858, 46152, 46164, 46165, 
45861, 45847, 46150, 46163, 45860
28750, 43006, 43098, 43102, 43010, 17244, 17267, 17268, 17245, 46152, 46164, 46165, 45861, 0, 0, 0, 
0, 45850, 46153, 46166, 45863
28751, 6433, 6456, 6457, 6434, 43007, 43099, 43103, 43011, 0, 0, 0, 0, 46156, 46168, 46169, 
45865, 45851, 46154, 46167, 45864
28752, 43007, 43099, 43103, 43011, 43008, 43100, 43104, 43012, 46156, 46168, 46169, 45865, 46159, 46171, 46172, 
45868, 45854, 46157, 46170, 45867
28753, 43008, 43100, 43104, 43012, 43009, 43101, 43105, 43013, 46159, 46171, 46172, 45868, 46162, 46174, 46175, 
45871, 45857, 46160, 46173, 45870
28754, 43009, 43101, 43105, 43013, 43010, 43102, 43106, 43014, 46162, 46174, 46175, 45871, 46165, 46177, 46178, 
45874, 45860, 46163, 46176, 45873
28755, 43010, 43102, 43106, 43014, 17245, 17268, 17269, 17246, 46165, 46177, 46178, 45874, 0, 0, 0, 
0, 45863, 46166, 46179, 45876
28756, 6434, 6457, 6458, 6435, 43011, 43103, 43107, 43015, 0, 0, 0, 0, 46169, 46181, 46182, 
45878, 45864, 46167, 46180, 45877
28757, 43011, 43103, 43107, 43015, 43012, 43104, 43108, 43016, 46169, 46181, 46182, 45878, 46172, 46184, 46185, 
45881, 45867, 46170, 46183, 45880
28758, 43012, 43104, 43108, 43016, 43013, 43105, 43109, 43017, 46172, 46184, 46185, 45881, 46175, 46187, 46188, 
45884, 45870, 46173, 46186, 45883
28759, 43013, 43105, 43109, 43017, 43014, 43106, 43110, 43018, 46175, 46187, 46188, 45884, 46178, 46190, 46191, 
45887, 45873, 46176, 46189, 45886
28760, 43014, 43106, 43110, 43018, 17246, 17269, 17270, 17247, 46178, 46190, 46191, 45887, 0, 0, 0, 
0, 45876, 46179, 46192, 45889
28761, 6435, 6458, 6459, 6436, 43015, 43107, 43111, 43019, 0, 0, 0, 0, 46182, 46194, 46195, 
45891, 45877, 46180, 46193, 45890
28762, 43015, 43107, 43111, 43019, 43016, 43108, 43112, 43020, 46182, 46194, 46195, 45891, 46185, 46197, 46198, 
45894, 45880, 46183, 46196, 45893
28763, 43016, 43108, 43112, 43020, 43017, 43109, 43113, 43021, 46185, 46197, 46198, 45894, 46188, 46200, 46201, 
45897, 45883, 46186, 46199, 45896
28764, 43017, 43109, 43113, 43021, 43018, 43110, 43114, 43022, 46188, 46200, 46201, 45897, 46191, 46203, 46204, 
45900, 45886, 46189, 46202, 45899
28765, 43018, 43110, 43114, 43022, 17247, 17270, 17271, 17248, 46191, 46203, 46204, 45900, 0, 0, 0, 
0, 45889, 46192, 46205, 45902
28766, 6436, 6459, 6460, 6437, 43019, 43111, 43115, 43023, 0, 0, 0, 0, 46195, 46207, 46208, 
45904, 45890, 46193, 46206, 45903
28767, 43019, 43111, 43115, 43023, 43020, 43112, 43116, 43024, 46195, 46207, 46208, 45904, 46198, 46210, 46211, 
45907, 45893, 46196, 46209, 45906
28768, 43020, 43112, 43116, 43024, 43021, 43113, 43117, 43025, 46198, 46210, 46211, 45907, 46201, 46213, 46214, 
45910, 45896, 46199, 46212, 45909
28769, 43021, 43113, 43117, 43025, 43022, 43114, 43118, 43026, 46201, 46213, 46214, 45910, 46204, 46216, 46217, 
45913, 45899, 46202, 46215, 45912
28770, 43022, 43114, 43118, 43026, 17248, 17271, 17272, 17249, 46204, 46216, 46217, 45913, 0, 0, 0, 
0, 45902, 46205, 46218, 45915
28771, 6437, 6460, 6461, 6438, 43023, 43115, 43119, 43027, 0, 0, 0, 0, 46208, 46220, 46221, 
45917, 45903, 46206, 46219, 45916
28772, 43023, 43115, 43119, 43027, 43024, 43116, 43120, 43028, 46208, 46220, 46221, 45917, 46211, 46223, 46224, 
45920, 45906, 46209, 46222, 45919
28773, 43024, 43116, 43120, 43028, 43025, 43117, 43121, 43029, 46211, 46223, 46224, 45920, 46214, 46226, 46227, 
45923, 45909, 46212, 46225, 45922
28774, 43025, 43117, 43121, 43029, 43026, 43118, 43122, 43030, 46214, 46226, 46227, 45923, 46217, 46229, 46230, 
45926, 45912, 46215, 46228, 45925
28775, 43026, 43118, 43122, 43030, 17249, 17272, 17273, 17250, 46217, 46229, 46230, 45926, 0, 0, 0, 
0, 45915, 46218, 46231, 45928
28776, 6438, 6461, 6462, 6439, 43027, 43119, 43123, 43031, 0, 0, 0, 0, 46221, 46233, 46234, 
45930, 45916, 46219, 46232, 45929
28777, 43027, 43119, 43123, 43031, 43028, 43120, 43124, 43032, 46221, 46233, 46234, 45930, 46224, 46236, 46237, 
45933, 45919, 46222, 46235, 45932
28778, 43028, 43120, 43124, 43032, 43029, 43121, 43125, 43033, 46224, 46236, 46237, 45933, 46227, 46239, 46240, 
45936, 45922, 46225, 46238, 45935
28779, 43029, 43121, 43125, 43033, 43030, 43122, 43126, 43034, 46227, 46239, 46240, 45936, 46230, 46242, 46243, 
45939, 45925, 46228, 46241, 45938
28780, 43030, 43122, 43126, 43034, 17250, 17273, 17274, 17251, 46230, 46242, 46243, 45939, 0, 0, 0, 
0, 45928, 46231, 46244, 45941
28781, 6439, 6462, 772, 771, 43031, 43123, 16934, 16930, 0, 0, 0, 0, 46234, 46245, 17023, 
45942, 45929, 46232, 17024, 17015
28782, 43031, 43123, 16934, 16930, 43032, 43124, 16935, 16931, 46234, 46245, 17023, 45942, 46237, 46246, 17025, 
45943, 45932, 46235, 17026, 17017
28783, 43032, 43124, 16935, 16931, 43033, 43125, 16936, 16932, 46237, 46246, 17025, 45943, 46240, 46247, 17027, 
45944, 45935, 46238, 17028, 17019
28784, 43033, 43125, 16936, 16932, 43034, 43126, 16937, 16933, 46240, 46247, 17027, 45944, 46243, 46248, 17029, 
45945, 45938, 46241, 17030, 17021
28785, 43034, 43126, 16937, 16933, 17251, 17274, 2170, 2169, 46243, 46248, 17029, 45945, 0, 0, 0, 
0, 45941, 46244, 17031, 17022
28786, 654, 655, 6463, 6440, 16348, 16352, 43127, 43035, 0, 0, 0, 0, 16446, 46250, 46251, 
45947, 16438, 16447, 46249, 45946
28787, 16348, 16352, 43127, 43035, 16349, 16353, 43128, 43036, 16446, 46250, 46251, 45947, 16448, 46253, 46254, 
45950, 16440, 16449, 46252, 45949
28788, 16349, 16353, 43128, 43036, 16350, 16354, 43129, 43037, 16448, 46253, 46254, 45950, 16450, 46256, 46257, 
45953, 16442, 16451, 46255, 45952
28789, 16350, 16354, 43129, 43037, 16351, 16355, 43130, 43038, 16450, 46256, 46257, 45953, 16452, 46259, 46260, 
45956, 16444, 16453, 46258, 45955
28790, 16351, 16355, 43130, 43038, 2100, 2101, 17275, 17252, 16452, 46259, 46260, 45956, 0, 0, 0, 
0, 16445, 16454, 46261, 45958
28791, 6440, 6463, 6464, 6441, 43035, 43127, 43131, 43039, 0, 0, 0, 0, 46251, 46263, 46264, 
45960, 45946, 46249, 46262, 45959
28792, 43035, 43127, 43131, 43039, 43036, 43128, 43132, 43040, 46251, 46263, 46264, 45960, 46254, 46266, 46267, 
45963, 45949, 46252, 46265, 45962
28793, 43036, 43128, 43132, 43040, 43037, 43129, 43133, 43041, 46254, 46266, 46267, 45963, 46257, 46269, 46270, 
45966, 45952, 46255, 46268, 45965
28794, 43037, 43129, 43133, 43041, 43038, 43130, 43134, 43042, 46257, 46269, 46270, 45966, 46260, 46272, 46273, 
45969, 45955, 46258, 46271, 45968
28795, 43038, 43130, 43134, 43042, 17252, 17275, 17276, 17253, 46260, 46272, 46273, 45969, 0, 0, 0, 
0, 45958, 46261, 46274, 45971
28796, 6441, 6464, 6465, 6442, 43039, 43131, 43135, 43043, 0, 0, 0, 0, 46264, 46276, 46277, 
45973, 45959, 46262, 46275, 45972
28797, 43039, 43131, 43135, 43043, 43040, 43132, 43136, 43044, 46264, 46276, 46277, 45973, 46267, 46279, 46280, 
45976, 45962, 46265, 46278, 45975
28798, 43040, 43132, 43136, 43044, 43041, 43133, 43137, 43045, 46267, 46279, 46280, 45976, 46270, 46282, 46283, 
45979, 45965, 46268, 46281, 45978
28799, 43041, 43133, 43137, 43045, 43042, 43134, 43138, 43046, 46270, 46282, 46283, 45979, 46273, 46285, 46286, 
45982, 45968, 46271, 46284, 45981
28800, 43042, 43134, 43138, 43046, 17253, 17276, 17277, 17254, 46273, 46285, 46286, 45982, 0, 0, 0, 
0, 45971, 46274, 46287, 45984
28801, 6442, 6465, 6466, 6443, 43043, 43135, 43139, 43047, 0, 0, 0, 0, 46277, 46289, 46290, 
45986, 45972, 46275, 46288, 45985
28802, 43043, 43135, 43139, 43047, 43044, 43136, 43140, 43048, 46277, 46289, 46290, 45986, 46280, 46292, 46293, 
45989, 45975, 46278, 46291, 45988
28803, 43044, 43136, 43140, 43048, 43045, 43137, 43141, 43049, 46280, 46292, 46293, 45989, 46283, 46295, 46296, 
45992, 45978, 46281, 46294, 45991
28804, 43045, 43137, 43141, 43049, 43046, 43138, 43142, 43050, 46283, 46295, 46296, 45992, 46286, 46298, 46299, 
45995, 45981, 46284, 46297, 45994
28805, 43046, 43138, 43142, 43050, 17254, 17277, 17278, 17255, 46286, 46298, 46299, 45995, 0, 0, 0, 
0, 45984, 46287, 46300, 45997
28806, 6443, 6466, 6467, 6444, 43047, 43139, 43143, 43051, 0, 0, 0, 0, 46290, 46302, 46303, 
45999, 45985, 46288, 46301, 45998
28807, 43047, 43139, 43143, 43051, 43048, 43140, 43144, 43052, 46290, 46302, 46303, 45999, 46293, 46305, 46306, 
46002, 45988, 46291, 46304, 46001
28808, 43048, 43140, 43144, 43052, 43049, 43141, 43145, 43053, 46293, 46305, 46306, 46002, 46296, 46308, 46309, 
46005, 45991, 46294, 46307, 46004
28809, 43049, 43141, 43145, 43053, 43050, 43142, 43146, 43054, 46296, 46308, 46309, 46005, 46299, 46311, 46312, 
46008, 45994, 46297, 46310, 46007
28810, 43050, 43142, 43146, 43054, 17255, 17278, 17279, 17256, 46299, 46311, 46312, 46008, 0, 0, 0, 
0, 45997, 46300, 46313, 46010
28811, 6444, 6467, 6468, 6445, 43051, 43143, 43147, 43055, 0, 0, 0, 0, 46303, 46315, 46316, 
46012, 45998, 46301, 46314, 46011
28812, 43051, 43143, 43147, 43055, 43052, 43144, 43148, 43056, 46303, 46315, 46316, 46012, 46306, 46318, 46319, 
46015, 46001, 46304, 46317, 46014
28813, 43052, 43144, 43148, 43056, 43053, 43145, 43149, 43057, 46306, 46318, 46319, 46015, 46309, 46321, 46322, 
46018, 46004, 46307, 46320, 46017
28814, 43053, 43145, 43149, 43057, 43054, 43146, 43150, 43058, 46309, 46321, 46322, 46018, 46312, 46324, 46325, 
46021, 46007, 46310, 46323, 46020
28815, 43054, 43146, 43150, 43058, 17256, 17279, 17280, 17257, 46312, 46324, 46325, 46021, 0, 0, 0, 
0, 46010, 46313, 46326, 46023
28816, 6445, 6468, 6469, 6446, 43055, 43147, 43151, 43059, 0, 0, 0, 0, 46316, 46328, 46329, 
46025, 46011, 46314, 46327, 46024
28817, 43055, 43147, 43151, 43059, 43056, 43148, 43152, 43060, 46316, 46328, 46329, 46025, 46319, 46331, 46332, 
46028, 46014, 46317, 46330, 46027
28818, 43056, 43148, 43152, 43060, 43057, 43149, 43153, 43061, 46319, 46331, 46332, 46028, 46322, 46334, 46335, 
46031, 46017, 46320, 46333, 46030
28819, 43057, 43149, 43153, 43061, 43058, 43150, 43154, 43062, 46322, 46334, 46335, 46031, 46325, 46337, 46338, 
46034, 46020, 46323, 46336, 46033
28820, 43058, 43150, 43154, 43062, 17257, 17280, 17281, 17258, 46325, 46337, 46338, 46034, 0, 0, 0, 
0, 46023, 46326, 46339, 46036
28821, 6446, 6469, 6470, 6447, 43059, 43151, 43155, 43063, 0, 0, 0, 0, 46329, 46341, 46342, 
46038, 46024, 46327, 46340, 46037
28822, 43059, 43151, 43155, 43063, 43060, 43152, 43156, 43064, 46329, 46341, 46342, 46038, 46332, 46344, 46345, 
46041, 46027, 46330, 46343, 46040
28823, 43060, 43152, 43156, 43064, 43061, 43153, 43157, 43065, 46332, 46344, 46345, 46041, 46335, 46347, 46348, 
46044, 46030, 46333, 46346, 46043
28824, 43061, 43153, 43157, 43065, 43062, 43154, 43158, 43066, 46335, 46347, 46348, 46044, 46338, 46350, 46351, 
46047, 46033, 46336, 46349, 46046
28825, 43062, 43154, 43158, 43066, 17258, 17281, 17282, 17259, 46338, 46350, 46351, 46047, 0, 0, 0, 
0, 46036, 46339, 46352, 46049
28826, 6447, 6470, 6471, 6448, 43063, 43155, 43159, 43067, 0, 0, 0, 0, 46342, 46354, 46355, 
46051, 46037, 46340, 46353, 46050
28827, 43063, 43155, 43159, 43067, 43064, 43156, 43160, 43068, 46342, 46354, 46355, 46051, 46345, 46357, 46358, 
46054, 46040, 46343, 46356, 46053
28828, 43064, 43156, 43160, 43068, 43065, 43157, 43161, 43069, 46345, 46357, 46358, 46054, 46348, 46360, 46361, 
46057, 46043, 46346, 46359, 46056
28829, 43065, 43157, 43161, 43069, 43066, 43158, 43162, 43070, 46348, 46360, 46361, 46057, 46351, 46363, 46364, 
46060, 46046, 46349, 46362, 46059
28830, 43066, 43158, 43162, 43070, 17259, 17282, 17283, 17260, 46351, 46363, 46364, 46060, 0, 0, 0, 
0, 46049, 46352, 46365, 46062
28831, 6448, 6471, 6472, 6449, 43067, 43159, 43163, 43071, 0, 0, 0, 0, 46355, 46367, 46368, 
46064, 46050, 46353, 46366, 46063
28832, 43067, 43159, 43163, 43071, 43068, 43160, 43164, 43072, 46355, 46367, 46368, 46064, 46358, 46370, 46371, 
46067, 46053, 46356, 46369, 46066
28833, 43068, 43160, 43164, 43072, 43069, 43161, 43165, 43073, 46358, 46370, 46371, 46067, 46361, 46373, 46374, 
46070, 46056, 46359, 46372, 46069
28834, 43069, 43161, 43165, 43073, 43070, 43162, 43166, 43074, 46361, 46373, 46374, 46070, 46364, 46376, 46377, 
46073, 46059, 46362, 46375, 46072
28835, 43070, 43162, 43166, 43074, 17260, 17283, 17284, 17261, 46364, 46376, 46377, 46073, 0, 0, 0, 
0, 46062, 46365, 46378, 46075
28836, 6449, 6472, 6473, 6450, 43071, 43163, 43167, 43075, 0, 0, 0, 0, 46368, 46380, 46381, 
46077, 46063, 46366, 46379, 46076
28837, 43071, 43163, 43167, 43075, 43072, 43164, 43168, 43076, 46368, 46380, 46381, 46077, 46371, 46383, 46384, 
46080, 46066, 46369, 46382, 46079
28838, 43072, 43164, 43168, 43076, 43073, 43165, 43169, 43077, 46371, 46383, 46384, 46080, 46374, 46386, 46387, 
46083, 46069, 46372, 46385, 46082
28839, 43073, 43165, 43169, 43077, 43074, 43166, 43170, 43078, 46374, 46386, 46387, 46083, 46377, 46389, 46390, 
46086, 46072, 46375, 46388, 46085
28840, 43074, 43166, 43170, 43078, 17261, 17284, 17285, 17262, 46377, 46389, 46390, 46086, 0, 0, 0, 
0, 46075, 46378, 46391, 46088
28841, 6450, 6473, 6474, 6451, 43075, 43167, 43171, 43079, 0, 0, 0, 0, 46381, 46393, 46394, 
46090, 46076, 46379, 46392, 46089
28842, 43075, 43167, 43171, 43079, 43076, 43168, 43172, 43080, 46381, 46393, 46394, 46090, 46384, 46396, 46397, 
46093, 46079, 46382, 46395, 46092
28843, 43076, 43168, 43172, 43080, 43077, 43169, 43173, 43081, 46384, 46396, 46397, 46093, 46387, 46399, 46400, 
46096, 46082, 46385, 46398, 46095
28844, 43077, 43169, 43173, 43081, 43078, 43170, 43174, 43082, 46387, 46399, 46400, 46096, 46390, 46402, 46403, 
46099, 46085, 46388, 46401, 46098
28845, 43078, 43170, 43174, 43082, 17262, 17285, 17286, 17263, 46390, 46402, 46403, 46099, 0, 0, 0, 
0, 46088, 46391, 46404, 46101
28846, 6451, 6474, 6475, 6452, 43079, 43171, 43175, 43083, 0, 0, 0, 0, 46394, 46406, 46407, 
46103, 46089, 46392, 46405, 46102
28847, 43079, 43171, 43175, 43083, 43080, 43172, 43176, 43084, 46394, 46406, 46407, 46103, 46397, 46409, 46410, 
46106, 46092, 46395, 46408, 46105
28848, 43080, 43172, 43176, 43084, 43081, 43173, 43177, 43085, 46397, 46409, 46410, 46106, 46400, 46412, 46413, 
46109, 46095, 46398, 46411, 46108
28849, 43081, 43173, 43177, 43085, 43082, 43174, 43178, 43086, 46400, 46412, 46413, 46109, 46403, 46415, 46416, 
46112, 46098, 46401, 46414, 46111
28850, 43082, 43174, 43178, 43086, 17263, 17286, 17287, 17264, 46403, 46415, 46416, 46112, 0, 0, 0, 
0, 46101, 46404, 46417, 46114
28851, 6452, 6475, 6476, 6453, 43083, 43175, 43179, 43087, 0, 0, 0, 0, 46407, 46419, 46420, 
46116, 46102, 46405, 46418, 46115
28852, 43083, 43175, 43179, 43087, 43084, 43176, 43180, 43088, 46407, 46419, 46420, 46116, 46410, 46422, 46423, 
46119, 46105, 46408, 46421, 46118
28853, 43084, 43176, 43180, 43088, 43085, 43177, 43181, 43089, 46410, 46422, 46423, 46119, 46413, 46425, 46426, 
46122, 46108, 46411, 46424, 46121
28854, 43085, 43177, 43181, 43089, 43086, 43178, 43182, 43090, 46413, 46425, 46426, 46122, 46416, 46428, 46429, 
46125, 46111, 46414, 46427, 46124
28855, 43086, 43178, 43182, 43090, 17264, 17287, 17288, 17265, 46416, 46428, 46429, 46125, 0, 0, 0, 
0, 46114, 46417, 46430, 46127
28856, 6453, 6476, 6477, 6454, 43087, 43179, 43183, 43091, 0, 0, 0, 0, 46420, 46432, 46433, 
46129, 46115, 46418, 46431, 46128
28857, 43087, 43179, 43183, 43091, 43088, 43180, 43184, 43092, 46420, 46432, 46433, 46129, 46423, 46435, 46436, 
46132, 46118, 46421, 46434, 46131
28858, 43088, 43180, 43184, 43092, 43089, 43181, 43185, 43093, 46423, 46435, 46436, 46132, 46426, 46438, 46439, 
46135, 46121, 46424, 46437, 46134
28859, 43089, 43181, 43185, 43093, 43090, 43182, 43186, 43094, 46426, 46438, 46439, 46135, 46429, 46441, 46442, 
46138, 46124, 46427, 46440, 46137
28860, 43090, 43182, 43186, 43094, 17265, 17288, 17289, 17266, 46429, 46441, 46442, 46138, 0, 0, 0, 
0, 46127, 46430, 46443, 46140
28861, 6454, 6477, 6478, 6455, 43091, 43183, 43187, 43095, 0, 0, 0, 0, 46433, 46445, 46446, 
46142, 46128, 46431, 46444, 46141
28862, 43091, 43183, 43187, 43095, 43092, 43184, 43188, 43096, 46433, 46445, 46446, 46142, 46436, 46448, 46449, 
46145, 46131, 46434, 46447, 46144
28863, 43092, 43184, 43188, 43096, 43093, 43185, 43189, 43097, 46436, 46448, 46449, 46145, 46439, 46451, 46452, 
46148, 46134, 46437, 46450, 46147
28864, 43093, 43185, 43189, 43097, 43094, 43186, 43190, 43098, 46439, 46451, 46452, 46148, 46442, 46454, 46455, 
46151, 46137, 46440, 46453, 46150
28865, 43094, 43186, 43190, 43098, 17266, 17289, 17290, 17267, 46442, 46454, 46455, 46151, 0, 0, 0, 
0, 46140, 46443, 46456, 46153
28866, 6455, 6478, 6479, 6456, 43095, 43187, 43191, 43099, 0, 0, 0, 0, 46446, 46458, 46459, 
46155, 46141, 46444, 46457, 46154
28867, 43095, 43187, 43191, 43099, 43096, 43188, 43192, 43100, 46446, 46458, 46459, 46155, 46449, 46461, 46462, 
46158, 46144, 46447, 46460, 46157
28868, 43096, 43188, 43192, 43100, 43097, 43189, 43193, 43101, 46449, 46461, 46462, 46158, 46452, 46464, 46465, 
46161, 46147, 46450, 46463, 46160
28869, 43097, 43189, 43193, 43101, 43098, 43190, 43194, 43102, 46452, 46464, 46465, 46161, 46455, 46467, 46468, 
46164, 46150, 46453, 46466, 46163
28870, 43098, 43190, 43194, 43102, 17267, 17290, 17291, 17268, 46455, 46467, 46468, 46164, 0, 0, 0, 
0, 46153, 46456, 46469, 46166
28871, 6456, 6479, 6480, 6457, 43099, 43191, 43195, 43103, 0, 0, 0, 0, 46459, 46471, 46472, 
46168, 46154, 46457, 46470, 46167
28872, 43099, 43191, 43195, 43103, 43100, 43192, 43196, 43104, 46459, 46471, 46472, 46168, 46462, 46474, 46475, 
46171, 46157, 46460, 46473, 46170
28873, 43100, 43192, 43196, 43104, 43101, 43193, 43197, 43105, 46462, 46474, 46475, 46171, 46465, 46477, 46478, 
46174, 46160, 46463, 46476, 46173
28874, 43101, 43193, 43197, 43105, 43102, 43194, 43198, 43106, 46465, 46477, 46478, 46174, 46468, 46480, 46481, 
46177, 46163, 46466, 46479, 46176
28875, 43102, 43194, 43198, 43106, 17268, 17291, 17292, 17269, 46468, 46480, 46481, 46177, 0, 0, 0, 
0, 46166, 46469, 46482, 46179
28876, 6457, 6480, 6481, 6458, 43103, 43195, 43199, 43107, 0, 0, 0, 0, 46472, 46484, 46485, 
46181, 46167, 46470, 46483, 46180
28877, 43103, 43195, 43199, 43107, 43104, 43196, 43200, 43108, 46472, 46484, 46485, 46181, 46475, 46487, 46488, 
46184, 46170, 46473, 46486, 46183
28878, 43104, 43196, 43200, 43108, 43105, 43197, 43201, 43109, 46475, 46487, 46488, 46184, 46478, 46490, 46491, 
46187, 46173, 46476, 46489, 46186
28879, 43105, 43197, 43201, 43109, 43106, 43198, 43202, 43110, 46478, 46490, 46491, 46187, 46481, 46493, 46494, 
46190, 46176, 46479, 46492, 46189
28880, 43106, 43198, 43202, 43110, 17269, 17292, 17293, 17270, 46481, 46493, 46494, 46190, 0, 0, 0, 
0, 46179, 46482, 46495, 46192
28881, 6458, 6481, 6482, 6459, 43107, 43199, 43203, 43111, 0, 0, 0, 0, 46485, 46497, 46498, 
46194, 46180, 46483, 46496, 46193
28882, 43107, 43199, 43203, 43111, 43108, 43200, 43204, 43112, 46485, 46497, 46498, 46194, 46488, 46500, 46501, 
46197, 46183, 46486, 46499, 46196
28883, 43108, 43200, 43204, 43112, 43109, 43201, 43205, 43113, 46488, 46500, 46501, 46197, 46491, 46503, 46504, 
46200, 46186, 46489, 46502, 46199
28884, 43109, 43201, 43205, 43113, 43110, 43202, 43206, 43114, 46491, 46503, 46504, 46200, 46494, 46506, 46507, 
46203, 46189, 46492, 46505, 46202
28885, 43110, 43202, 43206, 43114, 17270, 17293, 17294, 17271, 46494, 46506, 46507, 46203, 0, 0, 0, 
0, 46192, 46495, 46508, 46205
28886, 6459, 6482, 6483, 6460, 43111, 43203, 43207, 43115, 0, 0, 0, 0, 46498, 46510, 46511, 
46207, 46193, 46496, 46509, 46206
28887, 43111, 43203, 43207, 43115, 43112, 43204, 43208, 43116, 46498, 46510, 46511, 46207, 46501, 46513, 46514, 
46210, 46196, 46499, 46512, 46209
28888, 43112, 43204, 43208, 43116, 43113, 43205, 43209, 43117, 46501, 46513, 46514, 46210, 46504, 46516, 46517, 
46213, 46199, 46502, 46515, 46212
28889, 43113, 43205, 43209, 43117, 43114, 43206, 43210, 43118, 46504, 46516, 46517, 46213, 46507, 46519, 46520, 
46216, 46202, 46505, 46518, 46215
28890, 43114, 43206, 43210, 43118, 17271, 17294, 17295, 17272, 46507, 46519, 46520, 46216, 0, 0, 0, 
0, 46205, 46508, 46521, 46218
28891, 6460, 6483, 6484, 6461, 43115, 43207, 43211, 43119, 0, 0, 0, 0, 46511, 46523, 46524, 
46220, 46206, 46509, 46522, 46219
28892, 43115, 43207, 43211, 43119, 43116, 43208, 43212, 43120, 46511, 46523, 46524, 46220, 46514, 46526, 46527, 
46223, 46209, 46512, 46525, 46222
28893, 43116, 43208, 43212, 43120, 43117, 43209, 43213, 43121, 46514, 46526, 46527, 46223, 46517, 46529, 46530, 
46226, 46212, 46515, 46528, 46225
28894, 43117, 43209, 43213, 43121, 43118, 43210, 43214, 43122, 46517, 46529, 46530, 46226, 46520, 46532, 46533, 
46229, 46215, 46518, 46531, 46228
28895, 43118, 43210, 43214, 43122, 17272, 17295, 17296, 17273, 46520, 46532, 46533, 46229, 0, 0, 0, 
0, 46218, 46521, 46534, 46231
28896, 6461, 6484, 6485, 6462, 43119, 43211, 43215, 43123, 0, 0, 0, 0, 46524, 46536, 46537, 
46233, 46219, 46522, 46535, 46232
28897, 43119, 43211, 43215, 43123, 43120, 43212, 43216, 43124, 46524, 46536, 46537, 46233, 46527, 46539, 46540, 
46236, 46222, 46525, 46538, 46235
28898, 43120, 43212, 43216, 43124, 43121, 43213, 43217, 43125, 46527, 46539, 46540, 46236, 46530, 46542, 46543, 
46239, 46225, 46528, 46541, 46238
28899, 43121, 43213, 43217, 43125, 43122, 43214, 43218, 43126, 46530, 46542, 46543, 46239, 46533, 46545, 46546, 
46242, 46228, 46531, 46544, 46241
28900, 43122, 43214, 43218, 43126, 17273, 17296, 17297, 17274, 46533, 46545, 46546, 46242, 0, 0, 0, 
0, 46231, 46534, 46547, 46244
28901, 6462, 6485, 773, 772, 43123, 43215, 16938, 16934, 0, 0, 0, 0, 46537, 46548, 17032, 
46245, 46232, 46535, 17033, 17024
28902, 43123, 43215, 16938, 16934, 43124, 43216, 16939, 16935, 46537, 46548, 17032, 46245, 46540, 46549, 17034, 
46246, 46235, 46538, 17035, 17026
28903, 43124, 43216, 16939, 16935, 43125, 43217, 16940, 16936, 46540, 46549, 17034, 46246, 46543, 46550, 17036, 
46247, 46238, 46541, 17037, 17028
28904, 43125, 43217, 16940, 16936, 43126, 43218, 16941, 16937, 46543, 46550, 17036, 46247, 46546, 46551, 17038, 
46248, 46241, 46544, 17039, 17030
28905, 43126, 43218, 16941, 16937, 17274, 17297, 2171, 2170, 46546, 46551, 17038, 46248, 0, 0, 0, 
0, 46244, 46547, 17040, 17031
28906, 655, 26, 679, 6463, 16352, 2070, 16503, 43127, 0, 0, 0, 0, 16455, 0, 46552, 
46250, 16447, 0, 0, 46249
28907, 16352, 2070, 16503, 43127, 16353, 2071, 16504, 43128, 16455, 0, 46552, 46250, 16456, 0, 46553, 
46253, 16449, 0, 0, 46252
28908, 16353, 2071, 16504, 43128, 16354, 2072, 16505, 43129, 16456, 0, 46553, 46253, 16457, 0, 46554, 
46256, 16451, 0, 0, 46255
28909, 16354, 2072, 16505, 43129, 16355, 2073, 16506, 43130, 16457, 0, 46554, 46256, 16458, 0, 46555, 
46259, 16453, 0, 0, 46258
28910, 16355, 2073, 16506, 43130, 2101, 81, 2106, 17275, 16458, 0, 46555, 46259, 0, 0, 0, 
0, 16454, 0, 0, 46261
28911, 6463, 679, 680, 6464, 43127, 16503, 16507, 43131, 0, 0, 0, 0, 46552, 0, 46556, 
46263, 46249, 0, 0, 46262
28912, 43127, 16503, 16507, 43131, 43128, 16504, 16508, 43132, 46552, 0, 46556, 46263, 46553, 0, 46557, 
46266, 46252, 0, 0, 46265
28913, 43128, 16504, 16508, 43132, 43129, 16505, 16509, 43133, 46553, 0, 46557, 46266, 46554, 0, 46558, 
46269, 46255, 0, 0, 46268
28914, 43129, 16505, 16509, 43133, 43130, 16506, 16510, 43134, 46554, 0, 46558, 46269, 46555, 0, 46559, 
46272, 46258, 0, 0, 46271
28915, 43130, 16506, 16510, 43134, 17275, 2106, 2107, 17276, 46555, 0, 46559, 46272, 0, 0, 0, 
0, 46261, 0, 0, 46274
28916, 6464, 680, 681, 6465, 43131, 16507, 16511, 43135, 0, 0, 0, 0, 46556, 0, 46560, 
46276, 46262, 0, 0, 46275
28917, 43131, 16507, 16511, 43135, 43132, 16508, 16512, 43136, 46556, 0, 46560, 46276, 46557, 0, 46561, 
46279, 46265, 0, 0, 46278
28918, 43132, 16508, 16512, 43136, 43133, 16509, 16513, 43137, 46557, 0, 46561, 46279, 46558, 0, 46562, 
46282, 46268, 0, 0, 46281
28919, 43133, 16509, 16513, 43137, 43134, 16510, 16514, 43138, 46558, 0, 46562, 46282, 46559, 0, 46563, 
46285, 46271, 0, 0, 46284
28920, 43134, 16510, 16514, 43138, 17276, 2107, 2108, 17277, 46559, 0, 46563, 46285, 0, 0, 0, 
0, 46274, 0, 0, 46287
28921, 6465, 681, 682, 6466, 43135, 16511, 16515, 43139, 0, 0, 0, 0, 46560, 0, 46564, 
46289, 46275, 0, 0, 46288
28922, 43135, 16511, 16515, 43139, 43136, 16512, 16516, 43140, 46560, 0, 46564, 46289, 46561, 0, 46565, 
46292, 46278, 0, 0, 46291
28923, 43136, 16512, 16516, 43140, 43137, 16513, 16517, 43141, 46561, 0, 46565, 46292, 46562, 0, 46566, 
46295, 46281, 0, 0, 46294
28924, 43137, 16513, 16517, 43141, 43138, 16514, 16518, 43142, 46562, 0, 46566, 46295, 46563, 0, 46567, 
46298, 46284, 0, 0, 46297
28925, 43138, 16514, 16518, 43142, 17277, 2108, 2109, 17278, 46563, 0, 46567, 46298, 0, 0, 0, 
0, 46287, 0, 0, 46300
28926, 6466, 682, 683, 6467, 43139, 16515, 16519, 43143, 0, 0, 0, 0, 46564, 0, 46568, 
46302, 46288, 0, 0, 46301
28927, 43139, 16515, 16519, 43143, 43140, 16516, 16520, 43144, 46564, 0, 46568, 46302, 46565, 0, 46569, 
46305, 46291, 0, 0, 46304
28928, 43140, 16516, 16520, 43144, 43141, 16517, 16521, 43145, 46565, 0, 46569, 46305, 46566, 0, 46570, 
46308, 46294, 0, 0, 46307
28929, 43141, 16517, 16521, 43145, 43142, 16518, 16522, 43146, 46566, 0, 46570, 46308, 46567, 0, 46571, 
46311, 46297, 0, 0, 46310
28930, 43142, 16518, 16522, 43146, 17278, 2109, 2110, 17279, 46567, 0, 46571, 46311, 0, 0, 0, 
0, 46300, 0, 0, 46313
28931, 6467, 683, 684, 6468, 43143, 16519, 16523, 43147, 0, 0, 0, 0, 46568, 0, 46572, 
46315, 46301, 0, 0, 46314
28932, 43143, 16519, 16523, 43147, 43144, 16520, 16524, 43148, 46568, 0, 46572, 46315, 46569, 0, 46573, 
46318, 46304, 0, 0, 46317
28933, 43144, 16520, 16524, 43148, 43145, 16521, 16525, 43149, 46569, 0, 46573, 46318, 46570, 0, 46574, 
46321, 46307, 0, 0, 46320
28934, 43145, 16521, 16525, 43149, 43146, 16522, 16526, 43150, 46570, 0, 46574, 46321, 46571, 0, 46575, 
46324, 46310, 0, 0, 46323
28935, 43146, 16522, 16526, 43150, 17279, 2110, 2111, 17280, 46571, 0, 46575, 46324, 0, 0, 0, 
0, 46313, 0, 0, 46326
28936, 6468, 684, 685, 6469, 43147, 16523, 16527, 43151, 0, 0, 0, 0, 46572, 0, 46576, 
46328, 46314, 0, 0, 46327
28937, 43147, 16523, 16527, 43151, 43148, 16524, 16528, 43152, 46572, 0, 46576, 46328, 46573, 0, 46577, 
46331, 46317, 0, 0, 46330
28938, 43148, 16524, 16528, 43152, 43149, 16525, 16529, 43153, 46573, 0, 46577, 46331, 46574, 0, 46578, 
46334, 46320, 0, 0, 46333
28939, 43149, 16525, 16529, 43153, 43150, 16526, 16530, 43154, 46574, 0, 46578, 46334, 46575, 0, 46579, 
46337, 46323, 0, 0, 46336
28940, 43150, 16526, 16530, 43154, 17280, 2111, 2112, 17281, 46575, 0, 46579, 46337, 0, 0, 0, 
0, 46326, 0, 0, 46339
28941, 6469, 685, 686, 6470, 43151, 16527, 16531, 43155, 0, 0, 0, 0, 46576, 0, 46580, 
46341, 46327, 0, 0, 46340
28942, 43151, 16527, 16531, 43155, 43152, 16528, 16532, 43156, 46576, 0, 46580, 46341, 46577, 0, 46581, 
46344, 46330, 0, 0, 46343
28943, 43152, 16528, 16532, 43156, 43153, 16529, 16533, 43157, 46577, 0, 46581, 46344, 46578, 0, 46582, 
46347, 46333, 0, 0, 46346
28944, 43153, 16529, 16533, 43157, 43154, 16530, 16534, 43158, 46578, 0, 46582, 46347, 46579, 0, 46583, 
46350, 46336, 0, 0, 46349
28945, 43154, 16530, 16534, 43158, 17281, 2112, 2113, 17282, 46579, 0, 46583, 46350, 0, 0, 0, 
0, 46339, 0, 0, 46352
28946, 6470, 686, 687, 6471, 43155, 16531, 16535, 43159, 0, 0, 0, 0, 46580, 0, 46584, 
46354, 46340, 0, 0, 46353
28947, 43155, 16531, 16535, 43159, 43156, 16532, 16536, 43160, 46580, 0, 46584, 46354, 46581, 0, 46585, 
46357, 46343, 0, 0, 46356
28948, 43156, 16532, 16536, 43160, 43157, 16533, 16537, 43161, 46581, 0, 46585, 46357, 46582, 0, 46586, 
46360, 46346, 0, 0, 46359
28949, 43157, 16533, 16537, 43161, 43158, 16534, 16538, 43162, 46582, 0, 46586, 46360, 46583, 0, 46587, 
46363, 46349, 0, 0, 46362
28950, 43158, 16534, 16538, 43162, 17282, 2113, 2114, 17283, 46583, 0, 46587, 46363, 0, 0, 0, 
0, 46352, 0, 0, 46365
28951, 6471, 687, 688, 6472, 43159, 16535, 16539, 43163, 0, 0, 0, 0, 46584, 0, 46588, 
46367, 46353, 0, 0, 46366
28952, 43159, 16535, 16539, 43163, 43160, 16536, 16540, 43164, 46584, 0, 46588, 46367, 46585, 0, 46589, 
46370, 46356, 0, 0, 46369
28953, 43160, 16536, 16540, 43164, 43161, 16537, 16541, 43165, 46585, 0, 46589, 46370, 46586, 0, 46590, 
46373, 46359, 0, 0, 46372
28954, 43161, 16537, 16541, 43165, 43162, 16538, 16542, 43166, 46586, 0, 46590, 46373, 46587, 0, 46591, 
46376, 46362, 0, 0, 46375
28955, 43162, 16538, 16542, 43166, 17283, 2114, 2115, 17284, 46587, 0, 46591, 46376, 0, 0, 0, 
0, 46365, 0, 0, 46378
28956, 6472, 688, 689, 6473, 43163, 16539, 16543, 43167, 0, 0, 0, 0, 46588, 0, 46592, 
46380, 46366, 0, 0, 46379
28957, 43163, 16539, 16543, 43167, 43164, 16540, 16544, 43168, 46588, 0, 46592, 46380, 46589, 0, 46593, 
46383, 46369, 0, 0, 46382
28958, 43164, 16540, 16544, 43168, 43165, 16541, 16545, 43169, 46589, 0, 46593, 46383, 46590, 0, 46594, 
46386, 46372, 0, 0, 46385
28959, 43165, 16541, 16545, 43169, 43166, 16542, 16546, 43170, 46590, 0, 46594, 46386, 46591, 0, 46595, 
46389, 46375, 0, 0, 46388
28960, 43166, 16542, 16546, 43170, 17284, 2115, 2116, 17285, 46591, 0, 46595, 46389, 0, 0, 0, 
0, 46378, 0, 0, 46391
28961, 6473, 689, 690, 6474, 43167, 16543, 16547, 43171, 0, 0, 0, 0, 46592, 0, 46596, 
46393, 46379, 0, 0, 46392
28962, 43167, 16543, 16547, 43171, 43168, 16544, 16548, 43172, 46592, 0, 46596, 46393, 46593, 0, 46597, 
46396, 46382, 0, 0, 46395
28963, 43168, 16544, 16548, 43172, 43169, 16545, 16549, 43173, 46593, 0, 46597, 46396, 46594, 0, 46598, 
46399, 46385, 0, 0, 46398
28964, 43169, 16545, 16549, 43173, 43170, 16546, 16550, 43174, 46594, 0, 46598, 46399, 46595, 0, 46599, 
46402, 46388, 0, 0, 46401
28965, 43170, 16546, 16550, 43174, 17285, 2116, 2117, 17286, 46595, 0, 46599, 46402, 0, 0, 0, 
0, 46391, 0, 0, 46404
28966, 6474, 690, 691, 6475, 43171, 16547, 16551, 43175, 0, 0, 0, 0, 46596, 0, 46600, 
46406, 46392, 0, 0, 46405
28967, 43171, 16547, 16551, 43175, 43172, 16548, 16552, 43176, 46596, 0, 46600, 46406, 46597, 0, 46601, 
46409, 46395, 0, 0, 46408
28968, 43172, 16548, 16552, 43176, 43173, 16549, 16553, 43177, 46597, 0, 46601, 46409, 46598, 0, 46602, 
46412, 46398, 0, 0, 46411
28969, 43173, 16549, 16553, 43177, 43174, 16550, 16554, 43178, 46598, 0, 46602, 46412, 46599, 0, 46603, 
46415, 46401, 0, 0, 46414
28970, 43174, 16550, 16554, 43178, 17286, 2117, 2118, 17287, 46599, 0, 46603, 46415, 0, 0, 0, 
0, 46404, 0, 0, 46417
28971, 6475, 691, 692, 6476, 43175, 16551, 16555, 43179, 0, 0, 0, 0, 46600, 0, 46604, 
46419, 46405, 0, 0, 46418
28972, 43175, 16551, 16555, 43179, 43176, 16552, 16556, 43180, 46600, 0, 46604, 46419, 46601, 0, 46605, 
46422, 46408, 0, 0, 46421
28973, 43176, 16552, 16556, 43180, 43177, 16553, 16557, 43181, 46601, 0, 46605, 46422, 46602, 0, 46606, 
46425, 46411, 0, 0, 46424
28974, 43177, 16553, 16557, 43181, 43178, 16554, 16558, 43182, 46602, 0, 46606, 46425, 46603, 0, 46607, 
46428, 46414, 0, 0, 46427
28975, 43178, 16554, 16558, 43182, 17287, 2118, 2119, 17288, 46603, 0, 46607, 46428, 0, 0, 0, 
0, 46417, 0, 0, 46430
28976, 6476, 692, 693, 6477, 43179, 16555, 16559, 43183, 0, 0, 0, 0, 46604, 0, 46608, 
46432, 46418, 0, 0, 46431
28977, 43179, 16555, 16559, 43183, 43180, 16556, 16560, 43184, 46604, 0, 46608, 46432, 46605, 0, 46609, 
46435, 46421, 0, 0, 46434
28978, 43180, 16556, 16560, 43184, 43181, 16557, 16561, 43185, 46605, 0, 46609, 46435, 46606, 0, 46610, 
46438, 46424, 0, 0, 46437
28979, 43181, 16557, 16561, 43185, 43182, 16558, 16562, 43186, 46606, 0, 46610, 46438, 46607, 0, 46611, 
46441, 46427, 0, 0, 46440
28980, 43182, 16558, 16562, 43186, 17288, 2119, 2120, 17289, 46607, 0, 46611, 46441, 0, 0, 0, 
0, 46430, 0, 0, 46443
28981, 6477, 693, 694, 6478, 43183, 16559, 16563, 43187, 0, 0, 0, 0, 46608, 0, 46612, 
46445, 46431, 0, 0, 46444
28982, 43183, 16559, 16563, 43187, 43184, 16560, 16564, 43188, 46608, 0, 46612, 46445, 46609, 0, 46613, 
46448, 46434, 0, 0, 46447
28983, 43184, 16560, 16564, 43188, 43185, 16561, 16565, 43189, 46609, 0, 46613, 46448, 46610, 0, 46614, 
46451, 46437, 0, 0, 46450
28984, 43185, 16561, 16565, 43189, 43186, 16562, 16566, 43190, 46610, 0, 46614, 46451, 46611, 0, 46615, 
46454, 46440, 0, 0, 46453
28985, 43186, 16562, 16566, 43190, 17289, 2120, 2121, 17290, 46611, 0, 46615, 46454, 0, 0, 0, 
0, 46443, 0, 0, 46456
28986, 6478, 694, 695, 6479, 43187, 16563, 16567, 43191, 0, 0, 0, 0, 46612, 0, 46616, 
46458, 46444, 0, 0, 46457
28987, 43187, 16563, 16567, 43191, 43188, 16564, 16568, 43192, 46612, 0, 46616, 46458, 46613, 0, 46617, 
46461, 46447, 0, 0, 46460
28988, 43188, 16564, 16568, 43192, 43189, 16565, 16569, 43193, 46613, 0, 46617, 46461, 46614, 0, 46618, 
46464, 46450, 0, 0, 46463
28989, 43189, 16565, 16569, 43193, 43190, 16566, 16570, 43194, 46614, 0, 46618, 46464, 46615, 0, 46619, 
46467, 46453, 0, 0, 46466
28990, 43190, 16566, 16570, 43194, 17290, 2121, 2122, 17291, 46615, 0, 46619, 46467, 0, 0, 0, 
0, 46456, 0, 0, 46469
28991, 6479, 695, 696, 6480, 43191, 16567, 16571, 43195, 0, 0, 0, 0, 46616, 0, 46620, 
46471, 46457, 0, 0, 46470
28992, 43191, 16567, 16571, 43195, 43192, 16568, 16572, 43196, 46616, 0, 46620, 46471, 46617, 0, 46621, 
46474, 46460, 0, 0, 46473
28993, 43192, 16568, 16572, 43196, 43193, 16569, 16573, 43197, 46617, 0, 46621, 46474, 46618, 0, 46622, 
46477, 46463, 0, 0, 46476
28994, 43193, 16569, 16573, 43197, 43194, 16570, 16574, 43198, 46618, 0, 46622, 46477, 46619, 0, 46623, 
46480, 46466, 0, 0, 46479
28995, 43194, 16570, 16574, 43198, 17291, 2122, 2123, 17292, 46619, 0, 46623, 46480, 0, 0, 0, 
0, 46469, 0, 0, 46482
28996, 6480, 696, 697, 6481, 43195, 16571, 16575, 43199, 0, 0, 0, 0, 46620, 0, 46624, 
46484, 46470, 0, 0, 46483
28997, 43195, 16571, 16575, 43199, 43196, 16572, 16576, 43200, 46620, 0, 46624, 46484, 46621, 0, 46625, 
46487, 46473, 0, 0, 46486
28998, 43196, 16572, 16576, 43200, 43197, 16573, 16577, 43201, 46621, 0, 46625, 46487, 46622, 0, 46626, 
46490, 46476, 0, 0, 46489
28999, 43197, 16573, 16577, 43201, 43198, 16574, 16578, 43202, 46622, 0, 46626, 46490, 46623, 0, 46627, 
46493, 46479, 0, 0, 46492
29000, 43198, 16574, 16578, 43202, 17292, 2123, 2124, 17293, 46623, 0, 46627, 46493, 0, 0, 0, 
0, 46482, 0, 0, 46495
29001, 6481, 697, 698, 6482, 43199, 16575, 16579, 43203, 0, 0, 0, 0, 46624, 0, 46628, 
46497, 46483, 0, 0, 46496
29002, 43199, 16575, 16579, 43203, 43200, 16576, 16580, 43204, 46624, 0, 46628, 46497, 46625, 0, 46629, 
46500, 46486, 0, 0, 46499
29003, 43200, 16576, 16580, 43204, 43201, 16577, 16581, 43205, 46625, 0, 46629, 46500, 46626, 0, 46630, 
46503, 46489, 0, 0, 46502
29004, 43201, 16577, 16581, 43205, 43202, 16578, 16582, 43206, 46626, 0, 46630, 46503, 46627, 0, 46631, 
46506, 46492, 0, 0, 46505
29005, 43202, 16578, 16582, 43206, 17293, 2124, 2125, 17294, 46627, 0, 46631, 46506, 0, 0, 0, 
0, 46495, 0, 0, 46508
29006, 6482, 698, 699, 6483, 43203, 16579, 16583, 43207, 0, 0, 0, 0, 46628, 0, 46632, 
46510, 46496, 0, 0, 46509
29007, 43203, 16579, 16583, 43207, 43204, 16580, 16584, 43208, 46628, 0, 46632, 46510, 46629, 0, 46633, 
46513, 46499, 0, 0, 46512
29008, 43204, 16580, 16584, 43208, 43205, 16581, 16585, 43209, 46629, 0, 46633, 46513, 46630, 0, 46634, 
46516, 46502, 0, 0, 46515
29009, 43205, 16581, 16585, 43209, 43206, 16582, 16586, 43210, 46630, 0, 46634, 46516, 46631, 0, 46635, 
46519, 46505, 0, 0, 46518
29010, 43206, 16582, 16586, 43210, 17294, 2125, 2126, 17295, 46631, 0, 46635, 46519, 0, 0, 0, 
0, 46508, 0, 0, 46521
29011, 6483, 699, 700, 6484, 43207, 16583, 16587, 43211, 0, 0, 0, 0, 46632, 0, 46636, 
46523, 46509, 0, 0, 46522
29012, 43207, 16583, 16587, 43211, 43208, 16584, 16588, 43212, 46632, 0, 46636, 46523, 46633, 0, 46637, 
46526, 46512, 0, 0, 46525
29013, 43208, 16584, 16588, 43212, 43209, 16585, 16589, 43213, 46633, 0, 46637, 46526, 46634, 0, 46638, 
46529, 46515, 0, 0, 46528
29014, 43209, 16585, 16589, 43213, 43210, 16586, 16590, 43214, 46634, 0, 46638, 46529, 46635, 0, 46639, 
46532, 46518, 0, 0, 46531
29015, 43210, 16586, 16590, 43214, 17295, 2126, 2127, 17296, 46635, 0, 46639, 46532, 0, 0, 0, 
0, 46521, 0, 0, 46534
29016, 6484, 700, 701, 6485, 43211, 16587, 16591, 43215, 0, 0, 0, 0, 46636, 0, 46640, 
46536, 46522, 0, 0, 46535
29017, 43211, 16587, 16591, 43215, 43212, 16588, 16592, 43216, 46636, 0, 46640, 46536, 46637, 0, 46641, 
46539, 46525, 0, 0, 46538
29018, 43212, 16588, 16592, 43216, 43213, 16589, 16593, 43217, 46637, 0, 46641, 46539, 46638, 0, 46642, 
46542, 46528, 0, 0, 46541
29019, 43213, 16589, 16593, 43217, 43214, 16590, 16594, 43218, 46638, 0, 46642, 46542, 46639, 0, 46643, 
46545, 46531, 0, 0, 46544
29020, 43214, 16590, 16594, 43218, 17296, 2127, 2128, 17297, 46639, 0, 46643, 46545, 0, 0, 0, 
0, 46534, 0, 0, 46547
29021, 6485, 701, 30, 773, 43215, 16591, 2102, 16938, 0, 0, 0, 0, 46640, 0, 17041, 
46548, 46535, 0, 0, 17033
29022, 43215, 16591, 2102, 16938, 43216, 16592, 2103, 16939, 46640, 0, 17041, 46548, 46641, 0, 17042, 
46549, 46538, 0, 0, 17035
29023, 43216, 16592, 2103, 16939, 43217, 16593, 2104, 16940, 46641, 0, 17042, 46549, 46642, 0, 17043, 
46550, 46541, 0, 0, 17037
29024, 43217, 16593, 2104, 16940, 43218, 16594, 2105, 16941, 46642, 0, 17043, 46550, 46643, 0, 17044, 
46551, 46544, 0, 0, 17039
29025, 43218, 16594, 2105, 16941, 17297, 2128, 83, 2171, 46643, 0, 17044, 46551, 0, 0, 0, 
0, 46547, 0, 0, 17040
*ELEMENT, type=C3D20, ELSET=Volume23
29026, 2, 150, 2452, 98, 2181, 17298, 46644, 17840, 0, 0, 0, 97, 17391, 47657, 47658, 
17884, 2185, 17390, 47656, 17885
29027, 2181, 17298, 46644, 17840, 2182, 17299, 46645, 17841, 17391, 47657, 47658, 17884, 17393, 47660, 47661, 
17886, 2186, 17392, 47659, 17887
29028, 2182, 17299, 46645, 17841, 2183, 17300, 46646, 17842, 17393, 47660, 47661, 17886, 17395, 47663, 47664, 
17888, 2187, 17394, 47662, 17889
29029, 2183, 17300, 46646, 17842, 2184, 17301, 46647, 17843, 17395, 47663, 47664, 17888, 17397, 47666, 47667, 
17890, 2188, 17396, 47665, 17891
29030, 2184, 17301, 46647, 17843, 86, 2190, 17987, 2255, 17397, 47666, 47667, 17890, 0, 0, 0, 
0, 2189, 17398, 47668, 17892
29031, 98, 2452, 2453, 99, 17840, 46644, 46648, 17844, 0, 0, 0, 0, 47658, 47670, 47671, 
17893, 17885, 47656, 47669, 17894
29032, 17840, 46644, 46648, 17844, 17841, 46645, 46649, 17845, 47658, 47670, 47671, 17893, 47661, 47673, 47674, 
17895, 17887, 47659, 47672, 17896
29033, 17841, 46645, 46649, 17845, 17842, 46646, 46650, 17846, 47661, 47673, 47674, 17895, 47664, 47676, 47677, 
17897, 17889, 47662, 47675, 17898
29034, 17842, 46646, 46650, 17846, 17843, 46647, 46651, 17847, 47664, 47676, 47677, 17897, 47667, 47679, 47680, 
17899, 17891, 47665, 47678, 17900
29035, 17843, 46647, 46651, 17847, 2255, 17987, 17988, 2256, 47667, 47679, 47680, 17899, 0, 0, 0, 
0, 17892, 47668, 47681, 17901
29036, 99, 2453, 2454, 100, 17844, 46648, 46652, 17848, 0, 0, 0, 0, 47671, 47683, 47684, 
17902, 17894, 47669, 47682, 17903
29037, 17844, 46648, 46652, 17848, 17845, 46649, 46653, 17849, 47671, 47683, 47684, 17902, 47674, 47686, 47687, 
17904, 17896, 47672, 47685, 17905
29038, 17845, 46649, 46653, 17849, 17846, 46650, 46654, 17850, 47674, 47686, 47687, 17904, 47677, 47689, 47690, 
17906, 17898, 47675, 47688, 17907
29039, 17846, 46650, 46654, 17850, 17847, 46651, 46655, 17851, 47677, 47689, 47690, 17906, 47680, 47692, 47693, 
17908, 17900, 47678, 47691, 17909
29040, 17847, 46651, 46655, 17851, 2256, 17988, 17989, 2257, 47680, 47692, 47693, 17908, 0, 0, 0, 
0, 17901, 47681, 47694, 17910
29041, 100, 2454, 2455, 101, 17848, 46652, 46656, 17852, 0, 0, 0, 0, 47684, 47696, 47697, 
17911, 17903, 47682, 47695, 17912
29042, 17848, 46652, 46656, 17852, 17849, 46653, 46657, 17853, 47684, 47696, 47697, 17911, 47687, 47699, 47700, 
17913, 17905, 47685, 47698, 17914
29043, 17849, 46653, 46657, 17853, 17850, 46654, 46658, 17854, 47687, 47699, 47700, 17913, 47690, 47702, 47703, 
17915, 17907, 47688, 47701, 17916
29044, 17850, 46654, 46658, 17854, 17851, 46655, 46659, 17855, 47690, 47702, 47703, 17915, 47693, 47705, 47706, 
17917, 17909, 47691, 47704, 17918
29045, 17851, 46655, 46659, 17855, 2257, 17989, 17990, 2258, 47693, 47705, 47706, 17917, 0, 0, 0, 
0, 17910, 47694, 47707, 17919
29046, 101, 2455, 2456, 102, 17852, 46656, 46660, 17856, 0, 0, 0, 0, 47697, 47709, 47710, 
17920, 17912, 47695, 47708, 17921
29047, 17852, 46656, 46660, 17856, 17853, 46657, 46661, 17857, 47697, 47709, 47710, 17920, 47700, 47712, 47713, 
17922, 17914, 47698, 47711, 17923
29048, 17853, 46657, 46661, 17857, 17854, 46658, 46662, 17858, 47700, 47712, 47713, 17922, 47703, 47715, 47716, 
17924, 17916, 47701, 47714, 17925
29049, 17854, 46658, 46662, 17858, 17855, 46659, 46663, 17859, 47703, 47715, 47716, 17924, 47706, 47718, 47719, 
17926, 17918, 47704, 47717, 17927
29050, 17855, 46659, 46663, 17859, 2258, 17990, 17991, 2259, 47706, 47718, 47719, 17926, 0, 0, 0, 
0, 17919, 47707, 47720, 17928
29051, 102, 2456, 2457, 103, 17856, 46660, 46664, 17860, 0, 0, 0, 0, 47710, 47722, 47723, 
17929, 17921, 47708, 47721, 17930
29052, 17856, 46660, 46664, 17860, 17857, 46661, 46665, 17861, 47710, 47722, 47723, 17929, 47713, 47725, 47726, 
17931, 17923, 47711, 47724, 17932
29053, 17857, 46661, 46665, 17861, 17858, 46662, 46666, 17862, 47713, 47725, 47726, 17931, 47716, 47728, 47729, 
17933, 17925, 47714, 47727, 17934
29054, 17858, 46662, 46666, 17862, 17859, 46663, 46667, 17863, 47716, 47728, 47729, 17933, 47719, 47731, 47732, 
17935, 17927, 47717, 47730, 17936
29055, 17859, 46663, 46667, 17863, 2259, 17991, 17992, 2260, 47719, 47731, 47732, 17935, 0, 0, 0, 
0, 17928, 47720, 47733, 17937
29056, 103, 2457, 2458, 104, 17860, 46664, 46668, 17864, 0, 0, 0, 0, 47723, 47735, 47736, 
17938, 17930, 47721, 47734, 17939
29057, 17860, 46664, 46668, 17864, 17861, 46665, 46669, 17865, 47723, 47735, 47736, 17938, 47726, 47738, 47739, 
17940, 17932, 47724, 47737, 17941
29058, 17861, 46665, 46669, 17865, 17862, 46666, 46670, 17866, 47726, 47738, 47739, 17940, 47729, 47741, 47742, 
17942, 17934, 47727, 47740, 17943
29059, 17862, 46666, 46670, 17866, 17863, 46667, 46671, 17867, 47729, 47741, 47742, 17942, 47732, 47744, 47745, 
17944, 17936, 47730, 47743, 17945
29060, 17863, 46667, 46671, 17867, 2260, 17992, 17993, 2261, 47732, 47744, 47745, 17944, 0, 0, 0, 
0, 17937, 47733, 47746, 17946
29061, 104, 2458, 2459, 105, 17864, 46668, 46672, 17868, 0, 0, 0, 0, 47736, 47748, 47749, 
17947, 17939, 47734, 47747, 17948
29062, 17864, 46668, 46672, 17868, 17865, 46669, 46673, 17869, 47736, 47748, 47749, 17947, 47739, 47751, 47752, 
17949, 17941, 47737, 47750, 17950
29063, 17865, 46669, 46673, 17869, 17866, 46670, 46674, 17870, 47739, 47751, 47752, 17949, 47742, 47754, 47755, 
17951, 17943, 47740, 47753, 17952
29064, 17866, 46670, 46674, 17870, 17867, 46671, 46675, 17871, 47742, 47754, 47755, 17951, 47745, 47757, 47758, 
17953, 17945, 47743, 47756, 17954
29065, 17867, 46671, 46675, 17871, 2261, 17993, 17994, 2262, 47745, 47757, 47758, 17953, 0, 0, 0, 
0, 17946, 47746, 47759, 17955
29066, 105, 2459, 2460, 106, 17868, 46672, 46676, 17872, 0, 0, 0, 0, 47749, 47761, 47762, 
17956, 17948, 47747, 47760, 17957
29067, 17868, 46672, 46676, 17872, 17869, 46673, 46677, 17873, 47749, 47761, 47762, 17956, 47752, 47764, 47765, 
17958, 17950, 47750, 47763, 17959
29068, 17869, 46673, 46677, 17873, 17870, 46674, 46678, 17874, 47752, 47764, 47765, 17958, 47755, 47767, 47768, 
17960, 17952, 47753, 47766, 17961
29069, 17870, 46674, 46678, 17874, 17871, 46675, 46679, 17875, 47755, 47767, 47768, 17960, 47758, 47770, 47771, 
17962, 17954, 47756, 47769, 17963
29070, 17871, 46675, 46679, 17875, 2262, 17994, 17995, 2263, 47758, 47770, 47771, 17962, 0, 0, 0, 
0, 17955, 47759, 47772, 17964
29071, 106, 2460, 2461, 107, 17872, 46676, 46680, 17876, 0, 0, 0, 0, 47762, 47774, 47775, 
17965, 17957, 47760, 47773, 17966
29072, 17872, 46676, 46680, 17876, 17873, 46677, 46681, 17877, 47762, 47774, 47775, 17965, 47765, 47777, 47778, 
17967, 17959, 47763, 47776, 17968
29073, 17873, 46677, 46681, 17877, 17874, 46678, 46682, 17878, 47765, 47777, 47778, 17967, 47768, 47780, 47781, 
17969, 17961, 47766, 47779, 17970
29074, 17874, 46678, 46682, 17878, 17875, 46679, 46683, 17879, 47768, 47780, 47781, 17969, 47771, 47783, 47784, 
17971, 17963, 47769, 47782, 17972
29075, 17875, 46679, 46683, 17879, 2263, 17995, 17996, 2264, 47771, 47783, 47784, 17971, 0, 0, 0, 
0, 17964, 47772, 47785, 17973
29076, 107, 2461, 2462, 108, 17876, 46680, 46684, 17880, 0, 0, 0, 0, 47775, 47787, 47788, 
17974, 17966, 47773, 47786, 17975
29077, 17876, 46680, 46684, 17880, 17877, 46681, 46685, 17881, 47775, 47787, 47788, 17974, 47778, 47790, 47791, 
17976, 17968, 47776, 47789, 17977
29078, 17877, 46681, 46685, 17881, 17878, 46682, 46686, 17882, 47778, 47790, 47791, 17976, 47781, 47793, 47794, 
17978, 17970, 47779, 47792, 17979
29079, 17878, 46682, 46686, 17882, 17879, 46683, 46687, 17883, 47781, 47793, 47794, 17978, 47784, 47796, 47797, 
17980, 17972, 47782, 47795, 17981
29080, 17879, 46683, 46687, 17883, 2264, 17996, 17997, 2265, 47784, 47796, 47797, 17980, 0, 0, 0, 
0, 17973, 47785, 47798, 17982
29081, 108, 2462, 173, 1, 17880, 46684, 17748, 2228, 0, 0, 0, 0, 47788, 47799, 0, 
17983, 17975, 47786, 0, 0
29082, 17880, 46684, 17748, 2228, 17881, 46685, 17749, 2229, 47788, 47799, 0, 17983, 47791, 47800, 0, 
17984, 17977, 47789, 0, 0
29083, 17881, 46685, 17749, 2229, 17882, 46686, 17750, 2230, 47791, 47800, 0, 17984, 47794, 47801, 0, 
17985, 17979, 47792, 0, 0
29084, 17882, 46686, 17750, 2230, 17883, 46687, 17751, 2231, 47794, 47801, 0, 17985, 47797, 47802, 0, 
17986, 17981, 47795, 0, 0
29085, 17883, 46687, 17751, 2231, 2265, 17997, 2232, 88, 47797, 47802, 0, 17986, 0, 0, 0, 
0, 17982, 47798, 0, 0
29086, 150, 151, 2463, 2452, 17298, 17302, 46688, 46644, 0, 0, 0, 0, 17400, 47804, 47805, 
47657, 17390, 17399, 47803, 47656
29087, 17298, 17302, 46688, 46644, 17299, 17303, 46689, 46645, 17400, 47804, 47805, 47657, 17402, 47807, 47808, 
47660, 17392, 17401, 47806, 47659
29088, 17299, 17303, 46689, 46645, 17300, 17304, 46690, 46646, 17402, 47807, 47808, 47660, 17404, 47810, 47811, 
47663, 17394, 17403, 47809, 47662
29089, 17300, 17304, 46690, 46646, 17301, 17305, 46691, 46647, 17404, 47810, 47811, 47663, 17406, 47813, 47814, 
47666, 17396, 17405, 47812, 47665
29090, 17301, 17305, 46691, 46647, 2190, 2191, 17998, 17987, 17406, 47813, 47814, 47666, 0, 0, 0, 
0, 17398, 17407, 47815, 47668
29091, 2452, 2463, 2464, 2453, 46644, 46688, 46692, 46648, 0, 0, 0, 0, 47805, 47817, 47818, 
47670, 47656, 47803, 47816, 47669
29092, 46644, 46688, 46692, 46648, 46645, 46689, 46693, 46649, 47805, 47817, 47818, 47670, 47808, 47820, 47821, 
47673, 47659, 47806, 47819, 47672
29093, 46645, 46689, 46693, 46649, 46646, 46690, 46694, 46650, 47808, 47820, 47821, 47673, 47811, 47823, 47824, 
47676, 47662, 47809, 47822, 47675
29094, 46646, 46690, 46694, 46650, 46647, 46691, 46695, 46651, 47811, 47823, 47824, 47676, 47814, 47826, 47827, 
47679, 47665, 47812, 47825, 47678
29095, 46647, 46691, 46695, 46651, 17987, 17998, 17999, 17988, 47814, 47826, 47827, 47679, 0, 0, 0, 
0, 47668, 47815, 47828, 47681
29096, 2453, 2464, 2465, 2454, 46648, 46692, 46696, 46652, 0, 0, 0, 0, 47818, 47830, 47831, 
47683, 47669, 47816, 47829, 47682
29097, 46648, 46692, 46696, 46652, 46649, 46693, 46697, 46653, 47818, 47830, 47831, 47683, 47821, 47833, 47834, 
47686, 47672, 47819, 47832, 47685
29098, 46649, 46693, 46697, 46653, 46650, 46694, 46698, 46654, 47821, 47833, 47834, 47686, 47824, 47836, 47837, 
47689, 47675, 47822, 47835, 47688
29099, 46650, 46694, 46698, 46654, 46651, 46695, 46699, 46655, 47824, 47836, 47837, 47689, 47827, 47839, 47840, 
47692, 47678, 47825, 47838, 47691
29100, 46651, 46695, 46699, 46655, 17988, 17999, 18000, 17989, 47827, 47839, 47840, 47692, 0, 0, 0, 
0, 47681, 47828, 47841, 47694
29101, 2454, 2465, 2466, 2455, 46652, 46696, 46700, 46656, 0, 0, 0, 0, 47831, 47843, 47844, 
47696, 47682, 47829, 47842, 47695
29102, 46652, 46696, 46700, 46656, 46653, 46697, 46701, 46657, 47831, 47843, 47844, 47696, 47834, 47846, 47847, 
47699, 47685, 47832, 47845, 47698
29103, 46653, 46697, 46701, 46657, 46654, 46698, 46702, 46658, 47834, 47846, 47847, 47699, 47837, 47849, 47850, 
47702, 47688, 47835, 47848, 47701
29104, 46654, 46698, 46702, 46658, 46655, 46699, 46703, 46659, 47837, 47849, 47850, 47702, 47840, 47852, 47853, 
47705, 47691, 47838, 47851, 47704
29105, 46655, 46699, 46703, 46659, 17989, 18000, 18001, 17990, 47840, 47852, 47853, 47705, 0, 0, 0, 
0, 47694, 47841, 47854, 47707
29106, 2455, 2466, 2467, 2456, 46656, 46700, 46704, 46660, 0, 0, 0, 0, 47844, 47856, 47857, 
47709, 47695, 47842, 47855, 47708
29107, 46656, 46700, 46704, 46660, 46657, 46701, 46705, 46661, 47844, 47856, 47857, 47709, 47847, 47859, 47860, 
47712, 47698, 47845, 47858, 47711
29108, 46657, 46701, 46705, 46661, 46658, 46702, 46706, 46662, 47847, 47859, 47860, 47712, 47850, 47862, 47863, 
47715, 47701, 47848, 47861, 47714
29109, 46658, 46702, 46706, 46662, 46659, 46703, 46707, 46663, 47850, 47862, 47863, 47715, 47853, 47865, 47866, 
47718, 47704, 47851, 47864, 47717
29110, 46659, 46703, 46707, 46663, 17990, 18001, 18002, 17991, 47853, 47865, 47866, 47718, 0, 0, 0, 
0, 47707, 47854, 47867, 47720
29111, 2456, 2467, 2468, 2457, 46660, 46704, 46708, 46664, 0, 0, 0, 0, 47857, 47869, 47870, 
47722, 47708, 47855, 47868, 47721
29112, 46660, 46704, 46708, 46664, 46661, 46705, 46709, 46665, 47857, 47869, 47870, 47722, 47860, 47872, 47873, 
47725, 47711, 47858, 47871, 47724
29113, 46661, 46705, 46709, 46665, 46662, 46706, 46710, 46666, 47860, 47872, 47873, 47725, 47863, 47875, 47876, 
47728, 47714, 47861, 47874, 47727
29114, 46662, 46706, 46710, 46666, 46663, 46707, 46711, 46667, 47863, 47875, 47876, 47728, 47866, 47878, 47879, 
47731, 47717, 47864, 47877, 47730
29115, 46663, 46707, 46711, 46667, 17991, 18002, 18003, 17992, 47866, 47878, 47879, 47731, 0, 0, 0, 
0, 47720, 47867, 47880, 47733
29116, 2457, 2468, 2469, 2458, 46664, 46708, 46712, 46668, 0, 0, 0, 0, 47870, 47882, 47883, 
47735, 47721, 47868, 47881, 47734
29117, 46664, 46708, 46712, 46668, 46665, 46709, 46713, 46669, 47870, 47882, 47883, 47735, 47873, 47885, 47886, 
47738, 47724, 47871, 47884, 47737
29118, 46665, 46709, 46713, 46669, 46666, 46710, 46714, 46670, 47873, 47885, 47886, 47738, 47876, 47888, 47889, 
47741, 47727, 47874, 47887, 47740
29119, 46666, 46710, 46714, 46670, 46667, 46711, 46715, 46671, 47876, 47888, 47889, 47741, 47879, 47891, 47892, 
47744, 47730, 47877, 47890, 47743
29120, 46667, 46711, 46715, 46671, 17992, 18003, 18004, 17993, 47879, 47891, 47892, 47744, 0, 0, 0, 
0, 47733, 47880, 47893, 47746
29121, 2458, 2469, 2470, 2459, 46668, 46712, 46716, 46672, 0, 0, 0, 0, 47883, 47895, 47896, 
47748, 47734, 47881, 47894, 47747
29122, 46668, 46712, 46716, 46672, 46669, 46713, 46717, 46673, 47883, 47895, 47896, 47748, 47886, 47898, 47899, 
47751, 47737, 47884, 47897, 47750
29123, 46669, 46713, 46717, 46673, 46670, 46714, 46718, 46674, 47886, 47898, 47899, 47751, 47889, 47901, 47902, 
47754, 47740, 47887, 47900, 47753
29124, 46670, 46714, 46718, 46674, 46671, 46715, 46719, 46675, 47889, 47901, 47902, 47754, 47892, 47904, 47905, 
47757, 47743, 47890, 47903, 47756
29125, 46671, 46715, 46719, 46675, 17993, 18004, 18005, 17994, 47892, 47904, 47905, 47757, 0, 0, 0, 
0, 47746, 47893, 47906, 47759
29126, 2459, 2470, 2471, 2460, 46672, 46716, 46720, 46676, 0, 0, 0, 0, 47896, 47908, 47909, 
47761, 47747, 47894, 47907, 47760
29127, 46672, 46716, 46720, 46676, 46673, 46717, 46721, 46677, 47896, 47908, 47909, 47761, 47899, 47911, 47912, 
47764, 47750, 47897, 47910, 47763
29128, 46673, 46717, 46721, 46677, 46674, 46718, 46722, 46678, 47899, 47911, 47912, 47764, 47902, 47914, 47915, 
47767, 47753, 47900, 47913, 47766
29129, 46674, 46718, 46722, 46678, 46675, 46719, 46723, 46679, 47902, 47914, 47915, 47767, 47905, 47917, 47918, 
47770, 47756, 47903, 47916, 47769
29130, 46675, 46719, 46723, 46679, 17994, 18005, 18006, 17995, 47905, 47917, 47918, 47770, 0, 0, 0, 
0, 47759, 47906, 47919, 47772
29131, 2460, 2471, 2472, 2461, 46676, 46720, 46724, 46680, 0, 0, 0, 0, 47909, 47921, 47922, 
47774, 47760, 47907, 47920, 47773
29132, 46676, 46720, 46724, 46680, 46677, 46721, 46725, 46681, 47909, 47921, 47922, 47774, 47912, 47924, 47925, 
47777, 47763, 47910, 47923, 47776
29133, 46677, 46721, 46725, 46681, 46678, 46722, 46726, 46682, 47912, 47924, 47925, 47777, 47915, 47927, 47928, 
47780, 47766, 47913, 47926, 47779
29134, 46678, 46722, 46726, 46682, 46679, 46723, 46727, 46683, 47915, 47927, 47928, 47780, 47918, 47930, 47931, 
47783, 47769, 47916, 47929, 47782
29135, 46679, 46723, 46727, 46683, 17995, 18006, 18007, 17996, 47918, 47930, 47931, 47783, 0, 0, 0, 
0, 47772, 47919, 47932, 47785
29136, 2461, 2472, 2473, 2462, 46680, 46724, 46728, 46684, 0, 0, 0, 0, 47922, 47934, 47935, 
47787, 47773, 47920, 47933, 47786
29137, 46680, 46724, 46728, 46684, 46681, 46725, 46729, 46685, 47922, 47934, 47935, 47787, 47925, 47937, 47938, 
47790, 47776, 47923, 47936, 47789
29138, 46681, 46725, 46729, 46685, 46682, 46726, 46730, 46686, 47925, 47937, 47938, 47790, 47928, 47940, 47941, 
47793, 47779, 47926, 47939, 47792
29139, 46682, 46726, 46730, 46686, 46683, 46727, 46731, 46687, 47928, 47940, 47941, 47793, 47931, 47943, 47944, 
47796, 47782, 47929, 47942, 47795
29140, 46683, 46727, 46731, 46687, 17996, 18007, 18008, 17997, 47931, 47943, 47944, 47796, 0, 0, 0, 
0, 47785, 47932, 47945, 47798
29141, 2462, 2473, 174, 173, 46684, 46728, 17752, 17748, 0, 0, 0, 0, 47935, 47946, 0, 
47799, 47786, 47933, 0, 0
29142, 46684, 46728, 17752, 17748, 46685, 46729, 17753, 17749, 47935, 47946, 0, 47799, 47938, 47947, 0, 
47800, 47789, 47936, 0, 0
29143, 46685, 46729, 17753, 17749, 46686, 46730, 17754, 17750, 47938, 47947, 0, 47800, 47941, 47948, 0, 
47801, 47792, 47939, 0, 0
29144, 46686, 46730, 17754, 17750, 46687, 46731, 17755, 17751, 47941, 47948, 0, 47801, 47944, 47949, 0, 
47802, 47795, 47942, 0, 0
29145, 46687, 46731, 17755, 17751, 17997, 18008, 2233, 2232, 47944, 47949, 0, 47802, 0, 0, 0, 
0, 47798, 47945, 0, 0
29146, 151, 152, 2474, 2463, 17302, 17306, 46732, 46688, 0, 0, 0, 0, 17409, 47951, 47952, 
47804, 17399, 17408, 47950, 47803
29147, 17302, 17306, 46732, 46688, 17303, 17307, 46733, 46689, 17409, 47951, 47952, 47804, 17411, 47954, 47955, 
47807, 17401, 17410, 47953, 47806
29148, 17303, 17307, 46733, 46689, 17304, 17308, 46734, 46690, 17411, 47954, 47955, 47807, 17413, 47957, 47958, 
47810, 17403, 17412, 47956, 47809
29149, 17304, 17308, 46734, 46690, 17305, 17309, 46735, 46691, 17413, 47957, 47958, 47810, 17415, 47960, 47961, 
47813, 17405, 17414, 47959, 47812
29150, 17305, 17309, 46735, 46691, 2191, 2192, 18009, 17998, 17415, 47960, 47961, 47813, 0, 0, 0, 
0, 17407, 17416, 47962, 47815
29151, 2463, 2474, 2475, 2464, 46688, 46732, 46736, 46692, 0, 0, 0, 0, 47952, 47964, 47965, 
47817, 47803, 47950, 47963, 47816
29152, 46688, 46732, 46736, 46692, 46689, 46733, 46737, 46693, 47952, 47964, 47965, 47817, 47955, 47967, 47968, 
47820, 47806, 47953, 47966, 47819
29153, 46689, 46733, 46737, 46693, 46690, 46734, 46738, 46694, 47955, 47967, 47968, 47820, 47958, 47970, 47971, 
47823, 47809, 47956, 47969, 47822
29154, 46690, 46734, 46738, 46694, 46691, 46735, 46739, 46695, 47958, 47970, 47971, 47823, 47961, 47973, 47974, 
47826, 47812, 47959, 47972, 47825
29155, 46691, 46735, 46739, 46695, 17998, 18009, 18010, 17999, 47961, 47973, 47974, 47826, 0, 0, 0, 
0, 47815, 47962, 47975, 47828
29156, 2464, 2475, 2476, 2465, 46692, 46736, 46740, 46696, 0, 0, 0, 0, 47965, 47977, 47978, 
47830, 47816, 47963, 47976, 47829
29157, 46692, 46736, 46740, 46696, 46693, 46737, 46741, 46697, 47965, 47977, 47978, 47830, 47968, 47980, 47981, 
47833, 47819, 47966, 47979, 47832
29158, 46693, 46737, 46741, 46697, 46694, 46738, 46742, 46698, 47968, 47980, 47981, 47833, 47971, 47983, 47984, 
47836, 47822, 47969, 47982, 47835
29159, 46694, 46738, 46742, 46698, 46695, 46739, 46743, 46699, 47971, 47983, 47984, 47836, 47974, 47986, 47987, 
47839, 47825, 47972, 47985, 47838
29160, 46695, 46739, 46743, 46699, 17999, 18010, 18011, 18000, 47974, 47986, 47987, 47839, 0, 0, 0, 
0, 47828, 47975, 47988, 47841
29161, 2465, 2476, 2477, 2466, 46696, 46740, 46744, 46700, 0, 0, 0, 0, 47978, 47990, 47991, 
47843, 47829, 47976, 47989, 47842
29162, 46696, 46740, 46744, 46700, 46697, 46741, 46745, 46701, 47978, 47990, 47991, 47843, 47981, 47993, 47994, 
47846, 47832, 47979, 47992, 47845
29163, 46697, 46741, 46745, 46701, 46698, 46742, 46746, 46702, 47981, 47993, 47994, 47846, 47984, 47996, 47997, 
47849, 47835, 47982, 47995, 47848
29164, 46698, 46742, 46746, 46702, 46699, 46743, 46747, 46703, 47984, 47996, 47997, 47849, 47987, 47999, 48000, 
47852, 47838, 47985, 47998, 47851
29165, 46699, 46743, 46747, 46703, 18000, 18011, 18012, 18001, 47987, 47999, 48000, 47852, 0, 0, 0, 
0, 47841, 47988, 48001, 47854
29166, 2466, 2477, 2478, 2467, 46700, 46744, 46748, 46704, 0, 0, 0, 0, 47991, 48003, 48004, 
47856, 47842, 47989, 48002, 47855
29167, 46700, 46744, 46748, 46704, 46701, 46745, 46749, 46705, 47991, 48003, 48004, 47856, 47994, 48006, 48007, 
47859, 47845, 47992, 48005, 47858
29168, 46701, 46745, 46749, 46705, 46702, 46746, 46750, 46706, 47994, 48006, 48007, 47859, 47997, 48009, 48010, 
47862, 47848, 47995, 48008, 47861
29169, 46702, 46746, 46750, 46706, 46703, 46747, 46751, 46707, 47997, 48009, 48010, 47862, 48000, 48012, 48013, 
47865, 47851, 47998, 48011, 47864
29170, 46703, 46747, 46751, 46707, 18001, 18012, 18013, 18002, 48000, 48012, 48013, 47865, 0, 0, 0, 
0, 47854, 48001, 48014, 47867
29171, 2467, 2478, 2479, 2468, 46704, 46748, 46752, 46708, 0, 0, 0, 0, 48004, 48016, 48017, 
47869, 47855, 48002, 48015, 47868
29172, 46704, 46748, 46752, 46708, 46705, 46749, 46753, 46709, 48004, 48016, 48017, 47869, 48007, 48019, 48020, 
47872, 47858, 48005, 48018, 47871
29173, 46705, 46749, 46753, 46709, 46706, 46750, 46754, 46710, 48007, 48019, 48020, 47872, 48010, 48022, 48023, 
47875, 47861, 48008, 48021, 47874
29174, 46706, 46750, 46754, 46710, 46707, 46751, 46755, 46711, 48010, 48022, 48023, 47875, 48013, 48025, 48026, 
47878, 47864, 48011, 48024, 47877
29175, 46707, 46751, 46755, 46711, 18002, 18013, 18014, 18003, 48013, 48025, 48026, 47878, 0, 0, 0, 
0, 47867, 48014, 48027, 47880
29176, 2468, 2479, 2480, 2469, 46708, 46752, 46756, 46712, 0, 0, 0, 0, 48017, 48029, 48030, 
47882, 47868, 48015, 48028, 47881
29177, 46708, 46752, 46756, 46712, 46709, 46753, 46757, 46713, 48017, 48029, 48030, 47882, 48020, 48032, 48033, 
47885, 47871, 48018, 48031, 47884
29178, 46709, 46753, 46757, 46713, 46710, 46754, 46758, 46714, 48020, 48032, 48033, 47885, 48023, 48035, 48036, 
47888, 47874, 48021, 48034, 47887
29179, 46710, 46754, 46758, 46714, 46711, 46755, 46759, 46715, 48023, 48035, 48036, 47888, 48026, 48038, 48039, 
47891, 47877, 48024, 48037, 47890
29180, 46711, 46755, 46759, 46715, 18003, 18014, 18015, 18004, 48026, 48038, 48039, 47891, 0, 0, 0, 
0, 47880, 48027, 48040, 47893
29181, 2469, 2480, 2481, 2470, 46712, 46756, 46760, 46716, 0, 0, 0, 0, 48030, 48042, 48043, 
47895, 47881, 48028, 48041, 47894
29182, 46712, 46756, 46760, 46716, 46713, 46757, 46761, 46717, 48030, 48042, 48043, 47895, 48033, 48045, 48046, 
47898, 47884, 48031, 48044, 47897
29183, 46713, 46757, 46761, 46717, 46714, 46758, 46762, 46718, 48033, 48045, 48046, 47898, 48036, 48048, 48049, 
47901, 47887, 48034, 48047, 47900
29184, 46714, 46758, 46762, 46718, 46715, 46759, 46763, 46719, 48036, 48048, 48049, 47901, 48039, 48051, 48052, 
47904, 47890, 48037, 48050, 47903
29185, 46715, 46759, 46763, 46719, 18004, 18015, 18016, 18005, 48039, 48051, 48052, 47904, 0, 0, 0, 
0, 47893, 48040, 48053, 47906
29186, 2470, 2481, 2482, 2471, 46716, 46760, 46764, 46720, 0, 0, 0, 0, 48043, 48055, 48056, 
47908, 47894, 48041, 48054, 47907
29187, 46716, 46760, 46764, 46720, 46717, 46761, 46765, 46721, 48043, 48055, 48056, 47908, 48046, 48058, 48059, 
47911, 47897, 48044, 48057, 47910
29188, 46717, 46761, 46765, 46721, 46718, 46762, 46766, 46722, 48046, 48058, 48059, 47911, 48049, 48061, 48062, 
47914, 47900, 48047, 48060, 47913
29189, 46718, 46762, 46766, 46722, 46719, 46763, 46767, 46723, 48049, 48061, 48062, 47914, 48052, 48064, 48065, 
47917, 47903, 48050, 48063, 47916
29190, 46719, 46763, 46767, 46723, 18005, 18016, 18017, 18006, 48052, 48064, 48065, 47917, 0, 0, 0, 
0, 47906, 48053, 48066, 47919
29191, 2471, 2482, 2483, 2472, 46720, 46764, 46768, 46724, 0, 0, 0, 0, 48056, 48068, 48069, 
47921, 47907, 48054, 48067, 47920
29192, 46720, 46764, 46768, 46724, 46721, 46765, 46769, 46725, 48056, 48068, 48069, 47921, 48059, 48071, 48072, 
47924, 47910, 48057, 48070, 47923
29193, 46721, 46765, 46769, 46725, 46722, 46766, 46770, 46726, 48059, 48071, 48072, 47924, 48062, 48074, 48075, 
47927, 47913, 48060, 48073, 47926
29194, 46722, 46766, 46770, 46726, 46723, 46767, 46771, 46727, 48062, 48074, 48075, 47927, 48065, 48077, 48078, 
47930, 47916, 48063, 48076, 47929
29195, 46723, 46767, 46771, 46727, 18006, 18017, 18018, 18007, 48065, 48077, 48078, 47930, 0, 0, 0, 
0, 47919, 48066, 48079, 47932
29196, 2472, 2483, 2484, 2473, 46724, 46768, 46772, 46728, 0, 0, 0, 0, 48069, 48081, 48082, 
47934, 47920, 48067, 48080, 47933
29197, 46724, 46768, 46772, 46728, 46725, 46769, 46773, 46729, 48069, 48081, 48082, 47934, 48072, 48084, 48085, 
47937, 47923, 48070, 48083, 47936
29198, 46725, 46769, 46773, 46729, 46726, 46770, 46774, 46730, 48072, 48084, 48085, 47937, 48075, 48087, 48088, 
47940, 47926, 48073, 48086, 47939
29199, 46726, 46770, 46774, 46730, 46727, 46771, 46775, 46731, 48075, 48087, 48088, 47940, 48078, 48090, 48091, 
47943, 47929, 48076, 48089, 47942
29200, 46727, 46771, 46775, 46731, 18007, 18018, 18019, 18008, 48078, 48090, 48091, 47943, 0, 0, 0, 
0, 47932, 48079, 48092, 47945
29201, 2473, 2484, 175, 174, 46728, 46772, 17756, 17752, 0, 0, 0, 0, 48082, 48093, 0, 
47946, 47933, 48080, 0, 0
29202, 46728, 46772, 17756, 17752, 46729, 46773, 17757, 17753, 48082, 48093, 0, 47946, 48085, 48094, 0, 
47947, 47936, 48083, 0, 0
29203, 46729, 46773, 17757, 17753, 46730, 46774, 17758, 17754, 48085, 48094, 0, 47947, 48088, 48095, 0, 
47948, 47939, 48086, 0, 0
29204, 46730, 46774, 17758, 17754, 46731, 46775, 17759, 17755, 48088, 48095, 0, 47948, 48091, 48096, 0, 
47949, 47942, 48089, 0, 0
29205, 46731, 46775, 17759, 17755, 18008, 18019, 2234, 2233, 48091, 48096, 0, 47949, 0, 0, 0, 
0, 47945, 48092, 0, 0
29206, 152, 153, 2485, 2474, 17306, 17310, 46776, 46732, 0, 0, 0, 0, 17418, 48098, 48099, 
47951, 17408, 17417, 48097, 47950
29207, 17306, 17310, 46776, 46732, 17307, 17311, 46777, 46733, 17418, 48098, 48099, 47951, 17420, 48101, 48102, 
47954, 17410, 17419, 48100, 47953
29208, 17307, 17311, 46777, 46733, 17308, 17312, 46778, 46734, 17420, 48101, 48102, 47954, 17422, 48104, 48105, 
47957, 17412, 17421, 48103, 47956
29209, 17308, 17312, 46778, 46734, 17309, 17313, 46779, 46735, 17422, 48104, 48105, 47957, 17424, 48107, 48108, 
47960, 17414, 17423, 48106, 47959
29210, 17309, 17313, 46779, 46735, 2192, 2193, 18020, 18009, 17424, 48107, 48108, 47960, 0, 0, 0, 
0, 17416, 17425, 48109, 47962
29211, 2474, 2485, 2486, 2475, 46732, 46776, 46780, 46736, 0, 0, 0, 0, 48099, 48111, 48112, 
47964, 47950, 48097, 48110, 47963
29212, 46732, 46776, 46780, 46736, 46733, 46777, 46781, 46737, 48099, 48111, 48112, 47964, 48102, 48114, 48115, 
47967, 47953, 48100, 48113, 47966
29213, 46733, 46777, 46781, 46737, 46734, 46778, 46782, 46738, 48102, 48114, 48115, 47967, 48105, 48117, 48118, 
47970, 47956, 48103, 48116, 47969
29214, 46734, 46778, 46782, 46738, 46735, 46779, 46783, 46739, 48105, 48117, 48118, 47970, 48108, 48120, 48121, 
47973, 47959, 48106, 48119, 47972
29215, 46735, 46779, 46783, 46739, 18009, 18020, 18021, 18010, 48108, 48120, 48121, 47973, 0, 0, 0, 
0, 47962, 48109, 48122, 47975
29216, 2475, 2486, 2487, 2476, 46736, 46780, 46784, 46740, 0, 0, 0, 0, 48112, 48124, 48125, 
47977, 47963, 48110, 48123, 47976
29217, 46736, 46780, 46784, 46740, 46737, 46781, 46785, 46741, 48112, 48124, 48125, 47977, 48115, 48127, 48128, 
47980, 47966, 48113, 48126, 47979
29218, 46737, 46781, 46785, 46741, 46738, 46782, 46786, 46742, 48115, 48127, 48128, 47980, 48118, 48130, 48131, 
47983, 47969, 48116, 48129, 47982
29219, 46738, 46782, 46786, 46742, 46739, 46783, 46787, 46743, 48118, 48130, 48131, 47983, 48121, 48133, 48134, 
47986, 47972, 48119, 48132, 47985
29220, 46739, 46783, 46787, 46743, 18010, 18021, 18022, 18011, 48121, 48133, 48134, 47986, 0, 0, 0, 
0, 47975, 48122, 48135, 47988
29221, 2476, 2487, 2488, 2477, 46740, 46784, 46788, 46744, 0, 0, 0, 0, 48125, 48137, 48138, 
47990, 47976, 48123, 48136, 47989
29222, 46740, 46784, 46788, 46744, 46741, 46785, 46789, 46745, 48125, 48137, 48138, 47990, 48128, 48140, 48141, 
47993, 47979, 48126, 48139, 47992
29223, 46741, 46785, 46789, 46745, 46742, 46786, 46790, 46746, 48128, 48140, 48141, 47993, 48131, 48143, 48144, 
47996, 47982, 48129, 48142, 47995
29224, 46742, 46786, 46790, 46746, 46743, 46787, 46791, 46747, 48131, 48143, 48144, 47996, 48134, 48146, 48147, 
47999, 47985, 48132, 48145, 47998
29225, 46743, 46787, 46791, 46747, 18011, 18022, 18023, 18012, 48134, 48146, 48147, 47999, 0, 0, 0, 
0, 47988, 48135, 48148, 48001
29226, 2477, 2488, 2489, 2478, 46744, 46788, 46792, 46748, 0, 0, 0, 0, 48138, 48150, 48151, 
48003, 47989, 48136, 48149, 48002
29227, 46744, 46788, 46792, 46748, 46745, 46789, 46793, 46749, 48138, 48150, 48151, 48003, 48141, 48153, 48154, 
48006, 47992, 48139, 48152, 48005
29228, 46745, 46789, 46793, 46749, 46746, 46790, 46794, 46750, 48141, 48153, 48154, 48006, 48144, 48156, 48157, 
48009, 47995, 48142, 48155, 48008
29229, 46746, 46790, 46794, 46750, 46747, 46791, 46795, 46751, 48144, 48156, 48157, 48009, 48147, 48159, 48160, 
48012, 47998, 48145, 48158, 48011
29230, 46747, 46791, 46795, 46751, 18012, 18023, 18024, 18013, 48147, 48159, 48160, 48012, 0, 0, 0, 
0, 48001, 48148, 48161, 48014
29231, 2478, 2489, 2490, 2479, 46748, 46792, 46796, 46752, 0, 0, 0, 0, 48151, 48163, 48164, 
48016, 48002, 48149, 48162, 48015
29232, 46748, 46792, 46796, 46752, 46749, 46793, 46797, 46753, 48151, 48163, 48164, 48016, 48154, 48166, 48167, 
48019, 48005, 48152, 48165, 48018
29233, 46749, 46793, 46797, 46753, 46750, 46794, 46798, 46754, 48154, 48166, 48167, 48019, 48157, 48169, 48170, 
48022, 48008, 48155, 48168, 48021
29234, 46750, 46794, 46798, 46754, 46751, 46795, 46799, 46755, 48157, 48169, 48170, 48022, 48160, 48172, 48173, 
48025, 48011, 48158, 48171, 48024
29235, 46751, 46795, 46799, 46755, 18013, 18024, 18025, 18014, 48160, 48172, 48173, 48025, 0, 0, 0, 
0, 48014, 48161, 48174, 48027
29236, 2479, 2490, 2491, 2480, 46752, 46796, 46800, 46756, 0, 0, 0, 0, 48164, 48176, 48177, 
48029, 48015, 48162, 48175, 48028
29237, 46752, 46796, 46800, 46756, 46753, 46797, 46801, 46757, 48164, 48176, 48177, 48029, 48167, 48179, 48180, 
48032, 48018, 48165, 48178, 48031
29238, 46753, 46797, 46801, 46757, 46754, 46798, 46802, 46758, 48167, 48179, 48180, 48032, 48170, 48182, 48183, 
48035, 48021, 48168, 48181, 48034
29239, 46754, 46798, 46802, 46758, 46755, 46799, 46803, 46759, 48170, 48182, 48183, 48035, 48173, 48185, 48186, 
48038, 48024, 48171, 48184, 48037
29240, 46755, 46799, 46803, 46759, 18014, 18025, 18026, 18015, 48173, 48185, 48186, 48038, 0, 0, 0, 
0, 48027, 48174, 48187, 48040
29241, 2480, 2491, 2492, 2481, 46756, 46800, 46804, 46760, 0, 0, 0, 0, 48177, 48189, 48190, 
48042, 48028, 48175, 48188, 48041
29242, 46756, 46800, 46804, 46760, 46757, 46801, 46805, 46761, 48177, 48189, 48190, 48042, 48180, 48192, 48193, 
48045, 48031, 48178, 48191, 48044
29243, 46757, 46801, 46805, 46761, 46758, 46802, 46806, 46762, 48180, 48192, 48193, 48045, 48183, 48195, 48196, 
48048, 48034, 48181, 48194, 48047
29244, 46758, 46802, 46806, 46762, 46759, 46803, 46807, 46763, 48183, 48195, 48196, 48048, 48186, 48198, 48199, 
48051, 48037, 48184, 48197, 48050
29245, 46759, 46803, 46807, 46763, 18015, 18026, 18027, 18016, 48186, 48198, 48199, 48051, 0, 0, 0, 
0, 48040, 48187, 48200, 48053
29246, 2481, 2492, 2493, 2482, 46760, 46804, 46808, 46764, 0, 0, 0, 0, 48190, 48202, 48203, 
48055, 48041, 48188, 48201, 48054
29247, 46760, 46804, 46808, 46764, 46761, 46805, 46809, 46765, 48190, 48202, 48203, 48055, 48193, 48205, 48206, 
48058, 48044, 48191, 48204, 48057
29248, 46761, 46805, 46809, 46765, 46762, 46806, 46810, 46766, 48193, 48205, 48206, 48058, 48196, 48208, 48209, 
48061, 48047, 48194, 48207, 48060
29249, 46762, 46806, 46810, 46766, 46763, 46807, 46811, 46767, 48196, 48208, 48209, 48061, 48199, 48211, 48212, 
48064, 48050, 48197, 48210, 48063
29250, 46763, 46807, 46811, 46767, 18016, 18027, 18028, 18017, 48199, 48211, 48212, 48064, 0, 0, 0, 
0, 48053, 48200, 48213, 48066
29251, 2482, 2493, 2494, 2483, 46764, 46808, 46812, 46768, 0, 0, 0, 0, 48203, 48215, 48216, 
48068, 48054, 48201, 48214, 48067
29252, 46764, 46808, 46812, 46768, 46765, 46809, 46813, 46769, 48203, 48215, 48216, 48068, 48206, 48218, 48219, 
48071, 48057, 48204, 48217, 48070
29253, 46765, 46809, 46813, 46769, 46766, 46810, 46814, 46770, 48206, 48218, 48219, 48071, 48209, 48221, 48222, 
48074, 48060, 48207, 48220, 48073
29254, 46766, 46810, 46814, 46770, 46767, 46811, 46815, 46771, 48209, 48221, 48222, 48074, 48212, 48224, 48225, 
48077, 48063, 48210, 48223, 48076
29255, 46767, 46811, 46815, 46771, 18017, 18028, 18029, 18018, 48212, 48224, 48225, 48077, 0, 0, 0, 
0, 48066, 48213, 48226, 48079
29256, 2483, 2494, 2495, 2484, 46768, 46812, 46816, 46772, 0, 0, 0, 0, 48216, 48228, 48229, 
48081, 48067, 48214, 48227, 48080
29257, 46768, 46812, 46816, 46772, 46769, 46813, 46817, 46773, 48216, 48228, 48229, 48081, 48219, 48231, 48232, 
48084, 48070, 48217, 48230, 48083
29258, 46769, 46813, 46817, 46773, 46770, 46814, 46818, 46774, 48219, 48231, 48232, 48084, 48222, 48234, 48235, 
48087, 48073, 48220, 48233, 48086
29259, 46770, 46814, 46818, 46774, 46771, 46815, 46819, 46775, 48222, 48234, 48235, 48087, 48225, 48237, 48238, 
48090, 48076, 48223, 48236, 48089
29260, 46771, 46815, 46819, 46775, 18018, 18029, 18030, 18019, 48225, 48237, 48238, 48090, 0, 0, 0, 
0, 48079, 48226, 48239, 48092
29261, 2484, 2495, 176, 175, 46772, 46816, 17760, 17756, 0, 0, 0, 0, 48229, 48240, 0, 
48093, 48080, 48227, 0, 0
29262, 46772, 46816, 17760, 17756, 46773, 46817, 17761, 17757, 48229, 48240, 0, 48093, 48232, 48241, 0, 
48094, 48083, 48230, 0, 0
29263, 46773, 46817, 17761, 17757, 46774, 46818, 17762, 17758, 48232, 48241, 0, 48094, 48235, 48242, 0, 
48095, 48086, 48233, 0, 0
29264, 46774, 46818, 17762, 17758, 46775, 46819, 17763, 17759, 48235, 48242, 0, 48095, 48238, 48243, 0, 
48096, 48089, 48236, 0, 0
29265, 46775, 46819, 17763, 17759, 18019, 18030, 2235, 2234, 48238, 48243, 0, 48096, 0, 0, 0, 
0, 48092, 48239, 0, 0
29266, 153, 154, 2496, 2485, 17310, 17314, 46820, 46776, 0, 0, 0, 0, 17427, 48245, 48246, 
48098, 17417, 17426, 48244, 48097
29267, 17310, 17314, 46820, 46776, 17311, 17315, 46821, 46777, 17427, 48245, 48246, 48098, 17429, 48248, 48249, 
48101, 17419, 17428, 48247, 48100
29268, 17311, 17315, 46821, 46777, 17312, 17316, 46822, 46778, 17429, 48248, 48249, 48101, 17431, 48251, 48252, 
48104, 17421, 17430, 48250, 48103
29269, 17312, 17316, 46822, 46778, 17313, 17317, 46823, 46779, 17431, 48251, 48252, 48104, 17433, 48254, 48255, 
48107, 17423, 17432, 48253, 48106
29270, 17313, 17317, 46823, 46779, 2193, 2194, 18031, 18020, 17433, 48254, 48255, 48107, 0, 0, 0, 
0, 17425, 17434, 48256, 48109
29271, 2485, 2496, 2497, 2486, 46776, 46820, 46824, 46780, 0, 0, 0, 0, 48246, 48258, 48259, 
48111, 48097, 48244, 48257, 48110
29272, 46776, 46820, 46824, 46780, 46777, 46821, 46825, 46781, 48246, 48258, 48259, 48111, 48249, 48261, 48262, 
48114, 48100, 48247, 48260, 48113
29273, 46777, 46821, 46825, 46781, 46778, 46822, 46826, 46782, 48249, 48261, 48262, 48114, 48252, 48264, 48265, 
48117, 48103, 48250, 48263, 48116
29274, 46778, 46822, 46826, 46782, 46779, 46823, 46827, 46783, 48252, 48264, 48265, 48117, 48255, 48267, 48268, 
48120, 48106, 48253, 48266, 48119
29275, 46779, 46823, 46827, 46783, 18020, 18031, 18032, 18021, 48255, 48267, 48268, 48120, 0, 0, 0, 
0, 48109, 48256, 48269, 48122
29276, 2486, 2497, 2498, 2487, 46780, 46824, 46828, 46784, 0, 0, 0, 0, 48259, 48271, 48272, 
48124, 48110, 48257, 48270, 48123
29277, 46780, 46824, 46828, 46784, 46781, 46825, 46829, 46785, 48259, 48271, 48272, 48124, 48262, 48274, 48275, 
48127, 48113, 48260, 48273, 48126
29278, 46781, 46825, 46829, 46785, 46782, 46826, 46830, 46786, 48262, 48274, 48275, 48127, 48265, 48277, 48278, 
48130, 48116, 48263, 48276, 48129
29279, 46782, 46826, 46830, 46786, 46783, 46827, 46831, 46787, 48265, 48277, 48278, 48130, 48268, 48280, 48281, 
48133, 48119, 48266, 48279, 48132
29280, 46783, 46827, 46831, 46787, 18021, 18032, 18033, 18022, 48268, 48280, 48281, 48133, 0, 0, 0, 
0, 48122, 48269, 48282, 48135
29281, 2487, 2498, 2499, 2488, 46784, 46828, 46832, 46788, 0, 0, 0, 0, 48272, 48284, 48285, 
48137, 48123, 48270, 48283, 48136
29282, 46784, 46828, 46832, 46788, 46785, 46829, 46833, 46789, 48272, 48284, 48285, 48137, 48275, 48287, 48288, 
48140, 48126, 48273, 48286, 48139
29283, 46785, 46829, 46833, 46789, 46786, 46830, 46834, 46790, 48275, 48287, 48288, 48140, 48278, 48290, 48291, 
48143, 48129, 48276, 48289, 48142
29284, 46786, 46830, 46834, 46790, 46787, 46831, 46835, 46791, 48278, 48290, 48291, 48143, 48281, 48293, 48294, 
48146, 48132, 48279, 48292, 48145
29285, 46787, 46831, 46835, 46791, 18022, 18033, 18034, 18023, 48281, 48293, 48294, 48146, 0, 0, 0, 
0, 48135, 48282, 48295, 48148
29286, 2488, 2499, 2500, 2489, 46788, 46832, 46836, 46792, 0, 0, 0, 0, 48285, 48297, 48298, 
48150, 48136, 48283, 48296, 48149
29287, 46788, 46832, 46836, 46792, 46789, 46833, 46837, 46793, 48285, 48297, 48298, 48150, 48288, 48300, 48301, 
48153, 48139, 48286, 48299, 48152
29288, 46789, 46833, 46837, 46793, 46790, 46834, 46838, 46794, 48288, 48300, 48301, 48153, 48291, 48303, 48304, 
48156, 48142, 48289, 48302, 48155
29289, 46790, 46834, 46838, 46794, 46791, 46835, 46839, 46795, 48291, 48303, 48304, 48156, 48294, 48306, 48307, 
48159, 48145, 48292, 48305, 48158
29290, 46791, 46835, 46839, 46795, 18023, 18034, 18035, 18024, 48294, 48306, 48307, 48159, 0, 0, 0, 
0, 48148, 48295, 48308, 48161
29291, 2489, 2500, 2501, 2490, 46792, 46836, 46840, 46796, 0, 0, 0, 0, 48298, 48310, 48311, 
48163, 48149, 48296, 48309, 48162
29292, 46792, 46836, 46840, 46796, 46793, 46837, 46841, 46797, 48298, 48310, 48311, 48163, 48301, 48313, 48314, 
48166, 48152, 48299, 48312, 48165
29293, 46793, 46837, 46841, 46797, 46794, 46838, 46842, 46798, 48301, 48313, 48314, 48166, 48304, 48316, 48317, 
48169, 48155, 48302, 48315, 48168
29294, 46794, 46838, 46842, 46798, 46795, 46839, 46843, 46799, 48304, 48316, 48317, 48169, 48307, 48319, 48320, 
48172, 48158, 48305, 48318, 48171
29295, 46795, 46839, 46843, 46799, 18024, 18035, 18036, 18025, 48307, 48319, 48320, 48172, 0, 0, 0, 
0, 48161, 48308, 48321, 48174
29296, 2490, 2501, 2502, 2491, 46796, 46840, 46844, 46800, 0, 0, 0, 0, 48311, 48323, 48324, 
48176, 48162, 48309, 48322, 48175
29297, 46796, 46840, 46844, 46800, 46797, 46841, 46845, 46801, 48311, 48323, 48324, 48176, 48314, 48326, 48327, 
48179, 48165, 48312, 48325, 48178
29298, 46797, 46841, 46845, 46801, 46798, 46842, 46846, 46802, 48314, 48326, 48327, 48179, 48317, 48329, 48330, 
48182, 48168, 48315, 48328, 48181
29299, 46798, 46842, 46846, 46802, 46799, 46843, 46847, 46803, 48317, 48329, 48330, 48182, 48320, 48332, 48333, 
48185, 48171, 48318, 48331, 48184
29300, 46799, 46843, 46847, 46803, 18025, 18036, 18037, 18026, 48320, 48332, 48333, 48185, 0, 0, 0, 
0, 48174, 48321, 48334, 48187
29301, 2491, 2502, 2503, 2492, 46800, 46844, 46848, 46804, 0, 0, 0, 0, 48324, 48336, 48337, 
48189, 48175, 48322, 48335, 48188
29302, 46800, 46844, 46848, 46804, 46801, 46845, 46849, 46805, 48324, 48336, 48337, 48189, 48327, 48339, 48340, 
48192, 48178, 48325, 48338, 48191
29303, 46801, 46845, 46849, 46805, 46802, 46846, 46850, 46806, 48327, 48339, 48340, 48192, 48330, 48342, 48343, 
48195, 48181, 48328, 48341, 48194
29304, 46802, 46846, 46850, 46806, 46803, 46847, 46851, 46807, 48330, 48342, 48343, 48195, 48333, 48345, 48346, 
48198, 48184, 48331, 48344, 48197
29305, 46803, 46847, 46851, 46807, 18026, 18037, 18038, 18027, 48333, 48345, 48346, 48198, 0, 0, 0, 
0, 48187, 48334, 48347, 48200
29306, 2492, 2503, 2504, 2493, 46804, 46848, 46852, 46808, 0, 0, 0, 0, 48337, 48349, 48350, 
48202, 48188, 48335, 48348, 48201
29307, 46804, 46848, 46852, 46808, 46805, 46849, 46853, 46809, 48337, 48349, 48350, 48202, 48340, 48352, 48353, 
48205, 48191, 48338, 48351, 48204
29308, 46805, 46849, 46853, 46809, 46806, 46850, 46854, 46810, 48340, 48352, 48353, 48205, 48343, 48355, 48356, 
48208, 48194, 48341, 48354, 48207
29309, 46806, 46850, 46854, 46810, 46807, 46851, 46855, 46811, 48343, 48355, 48356, 48208, 48346, 48358, 48359, 
48211, 48197, 48344, 48357, 48210
29310, 46807, 46851, 46855, 46811, 18027, 18038, 18039, 18028, 48346, 48358, 48359, 48211, 0, 0, 0, 
0, 48200, 48347, 48360, 48213
29311, 2493, 2504, 2505, 2494, 46808, 46852, 46856, 46812, 0, 0, 0, 0, 48350, 48362, 48363, 
48215, 48201, 48348, 48361, 48214
29312, 46808, 46852, 46856, 46812, 46809, 46853, 46857, 46813, 48350, 48362, 48363, 48215, 48353, 48365, 48366, 
48218, 48204, 48351, 48364, 48217
29313, 46809, 46853, 46857, 46813, 46810, 46854, 46858, 46814, 48353, 48365, 48366, 48218, 48356, 48368, 48369, 
48221, 48207, 48354, 48367, 48220
29314, 46810, 46854, 46858, 46814, 46811, 46855, 46859, 46815, 48356, 48368, 48369, 48221, 48359, 48371, 48372, 
48224, 48210, 48357, 48370, 48223
29315, 46811, 46855, 46859, 46815, 18028, 18039, 18040, 18029, 48359, 48371, 48372, 48224, 0, 0, 0, 
0, 48213, 48360, 48373, 48226
29316, 2494, 2505, 2506, 2495, 46812, 46856, 46860, 46816, 0, 0, 0, 0, 48363, 48375, 48376, 
48228, 48214, 48361, 48374, 48227
29317, 46812, 46856, 46860, 46816, 46813, 46857, 46861, 46817, 48363, 48375, 48376, 48228, 48366, 48378, 48379, 
48231, 48217, 48364, 48377, 48230
29318, 46813, 46857, 46861, 46817, 46814, 46858, 46862, 46818, 48366, 48378, 48379, 48231, 48369, 48381, 48382, 
48234, 48220, 48367, 48380, 48233
29319, 46814, 46858, 46862, 46818, 46815, 46859, 46863, 46819, 48369, 48381, 48382, 48234, 48372, 48384, 48385, 
48237, 48223, 48370, 48383, 48236
29320, 46815, 46859, 46863, 46819, 18029, 18040, 18041, 18030, 48372, 48384, 48385, 48237, 0, 0, 0, 
0, 48226, 48373, 48386, 48239
29321, 2495, 2506, 177, 176, 46816, 46860, 17764, 17760, 0, 0, 0, 0, 48376, 48387, 0, 
48240, 48227, 48374, 0, 0
29322, 46816, 46860, 17764, 17760, 46817, 46861, 17765, 17761, 48376, 48387, 0, 48240, 48379, 48388, 0, 
48241, 48230, 48377, 0, 0
29323, 46817, 46861, 17765, 17761, 46818, 46862, 17766, 17762, 48379, 48388, 0, 48241, 48382, 48389, 0, 
48242, 48233, 48380, 0, 0
29324, 46818, 46862, 17766, 17762, 46819, 46863, 17767, 17763, 48382, 48389, 0, 48242, 48385, 48390, 0, 
48243, 48236, 48383, 0, 0
29325, 46819, 46863, 17767, 17763, 18030, 18041, 2236, 2235, 48385, 48390, 0, 48243, 0, 0, 0, 
0, 48239, 48386, 0, 0
29326, 154, 155, 2507, 2496, 17314, 17318, 46864, 46820, 0, 0, 0, 0, 17436, 48392, 48393, 
48245, 17426, 17435, 48391, 48244
29327, 17314, 17318, 46864, 46820, 17315, 17319, 46865, 46821, 17436, 48392, 48393, 48245, 17438, 48395, 48396, 
48248, 17428, 17437, 48394, 48247
29328, 17315, 17319, 46865, 46821, 17316, 17320, 46866, 46822, 17438, 48395, 48396, 48248, 17440, 48398, 48399, 
48251, 17430, 17439, 48397, 48250
29329, 17316, 17320, 46866, 46822, 17317, 17321, 46867, 46823, 17440, 48398, 48399, 48251, 17442, 48401, 48402, 
48254, 17432, 17441, 48400, 48253
29330, 17317, 17321, 46867, 46823, 2194, 2195, 18042, 18031, 17442, 48401, 48402, 48254, 0, 0, 0, 
0, 17434, 17443, 48403, 48256
29331, 2496, 2507, 2508, 2497, 46820, 46864, 46868, 46824, 0, 0, 0, 0, 48393, 48405, 48406, 
48258, 48244, 48391, 48404, 48257
29332, 46820, 46864, 46868, 46824, 46821, 46865, 46869, 46825, 48393, 48405, 48406, 48258, 48396, 48408, 48409, 
48261, 48247, 48394, 48407, 48260
29333, 46821, 46865, 46869, 46825, 46822, 46866, 46870, 46826, 48396, 48408, 48409, 48261, 48399, 48411, 48412, 
48264, 48250, 48397, 48410, 48263
29334, 46822, 46866, 46870, 46826, 46823, 46867, 46871, 46827, 48399, 48411, 48412, 48264, 48402, 48414, 48415, 
48267, 48253, 48400, 48413, 48266
29335, 46823, 46867, 46871, 46827, 18031, 18042, 18043, 18032, 48402, 48414, 48415, 48267, 0, 0, 0, 
0, 48256, 48403, 48416, 48269
29336, 2497, 2508, 2509, 2498, 46824, 46868, 46872, 46828, 0, 0, 0, 0, 48406, 48418, 48419, 
48271, 48257, 48404, 48417, 48270
29337, 46824, 46868, 46872, 46828, 46825, 46869, 46873, 46829, 48406, 48418, 48419, 48271, 48409, 48421, 48422, 
48274, 48260, 48407, 48420, 48273
29338, 46825, 46869, 46873, 46829, 46826, 46870, 46874, 46830, 48409, 48421, 48422, 48274, 48412, 48424, 48425, 
48277, 48263, 48410, 48423, 48276
29339, 46826, 46870, 46874, 46830, 46827, 46871, 46875, 46831, 48412, 48424, 48425, 48277, 48415, 48427, 48428, 
48280, 48266, 48413, 48426, 48279
29340, 46827, 46871, 46875, 46831, 18032, 18043, 18044, 18033, 48415, 48427, 48428, 48280, 0, 0, 0, 
0, 48269, 48416, 48429, 48282
29341, 2498, 2509, 2510, 2499, 46828, 46872, 46876, 46832, 0, 0, 0, 0, 48419, 48431, 48432, 
48284, 48270, 48417, 48430, 48283
29342, 46828, 46872, 46876, 46832, 46829, 46873, 46877, 46833, 48419, 48431, 48432, 48284, 48422, 48434, 48435, 
48287, 48273, 48420, 48433, 48286
29343, 46829, 46873, 46877, 46833, 46830, 46874, 46878, 46834, 48422, 48434, 48435, 48287, 48425, 48437, 48438, 
48290, 48276, 48423, 48436, 48289
29344, 46830, 46874, 46878, 46834, 46831, 46875, 46879, 46835, 48425, 48437, 48438, 48290, 48428, 48440, 48441, 
48293, 48279, 48426, 48439, 48292
29345, 46831, 46875, 46879, 46835, 18033, 18044, 18045, 18034, 48428, 48440, 48441, 48293, 0, 0, 0, 
0, 48282, 48429, 48442, 48295
29346, 2499, 2510, 2511, 2500, 46832, 46876, 46880, 46836, 0, 0, 0, 0, 48432, 48444, 48445, 
48297, 48283, 48430, 48443, 48296
29347, 46832, 46876, 46880, 46836, 46833, 46877, 46881, 46837, 48432, 48444, 48445, 48297, 48435, 48447, 48448, 
48300, 48286, 48433, 48446, 48299
29348, 46833, 46877, 46881, 46837, 46834, 46878, 46882, 46838, 48435, 48447, 48448, 48300, 48438, 48450, 48451, 
48303, 48289, 48436, 48449, 48302
29349, 46834, 46878, 46882, 46838, 46835, 46879, 46883, 46839, 48438, 48450, 48451, 48303, 48441, 48453, 48454, 
48306, 48292, 48439, 48452, 48305
29350, 46835, 46879, 46883, 46839, 18034, 18045, 18046, 18035, 48441, 48453, 48454, 48306, 0, 0, 0, 
0, 48295, 48442, 48455, 48308
29351, 2500, 2511, 2512, 2501, 46836, 46880, 46884, 46840, 0, 0, 0, 0, 48445, 48457, 48458, 
48310, 48296, 48443, 48456, 48309
29352, 46836, 46880, 46884, 46840, 46837, 46881, 46885, 46841, 48445, 48457, 48458, 48310, 48448, 48460, 48461, 
48313, 48299, 48446, 48459, 48312
29353, 46837, 46881, 46885, 46841, 46838, 46882, 46886, 46842, 48448, 48460, 48461, 48313, 48451, 48463, 48464, 
48316, 48302, 48449, 48462, 48315
29354, 46838, 46882, 46886, 46842, 46839, 46883, 46887, 46843, 48451, 48463, 48464, 48316, 48454, 48466, 48467, 
48319, 48305, 48452, 48465, 48318
29355, 46839, 46883, 46887, 46843, 18035, 18046, 18047, 18036, 48454, 48466, 48467, 48319, 0, 0, 0, 
0, 48308, 48455, 48468, 48321
29356, 2501, 2512, 2513, 2502, 46840, 46884, 46888, 46844, 0, 0, 0, 0, 48458, 48470, 48471, 
48323, 48309, 48456, 48469, 48322
29357, 46840, 46884, 46888, 46844, 46841, 46885, 46889, 46845, 48458, 48470, 48471, 48323, 48461, 48473, 48474, 
48326, 48312, 48459, 48472, 48325
29358, 46841, 46885, 46889, 46845, 46842, 46886, 46890, 46846, 48461, 48473, 48474, 48326, 48464, 48476, 48477, 
48329, 48315, 48462, 48475, 48328
29359, 46842, 46886, 46890, 46846, 46843, 46887, 46891, 46847, 48464, 48476, 48477, 48329, 48467, 48479, 48480, 
48332, 48318, 48465, 48478, 48331
29360, 46843, 46887, 46891, 46847, 18036, 18047, 18048, 18037, 48467, 48479, 48480, 48332, 0, 0, 0, 
0, 48321, 48468, 48481, 48334
29361, 2502, 2513, 2514, 2503, 46844, 46888, 46892, 46848, 0, 0, 0, 0, 48471, 48483, 48484, 
48336, 48322, 48469, 48482, 48335
29362, 46844, 46888, 46892, 46848, 46845, 46889, 46893, 46849, 48471, 48483, 48484, 48336, 48474, 48486, 48487, 
48339, 48325, 48472, 48485, 48338
29363, 46845, 46889, 46893, 46849, 46846, 46890, 46894, 46850, 48474, 48486, 48487, 48339, 48477, 48489, 48490, 
48342, 48328, 48475, 48488, 48341
29364, 46846, 46890, 46894, 46850, 46847, 46891, 46895, 46851, 48477, 48489, 48490, 48342, 48480, 48492, 48493, 
48345, 48331, 48478, 48491, 48344
29365, 46847, 46891, 46895, 46851, 18037, 18048, 18049, 18038, 48480, 48492, 48493, 48345, 0, 0, 0, 
0, 48334, 48481, 48494, 48347
29366, 2503, 2514, 2515, 2504, 46848, 46892, 46896, 46852, 0, 0, 0, 0, 48484, 48496, 48497, 
48349, 48335, 48482, 48495, 48348
29367, 46848, 46892, 46896, 46852, 46849, 46893, 46897, 46853, 48484, 48496, 48497, 48349, 48487, 48499, 48500, 
48352, 48338, 48485, 48498, 48351
29368, 46849, 46893, 46897, 46853, 46850, 46894, 46898, 46854, 48487, 48499, 48500, 48352, 48490, 48502, 48503, 
48355, 48341, 48488, 48501, 48354
29369, 46850, 46894, 46898, 46854, 46851, 46895, 46899, 46855, 48490, 48502, 48503, 48355, 48493, 48505, 48506, 
48358, 48344, 48491, 48504, 48357
29370, 46851, 46895, 46899, 46855, 18038, 18049, 18050, 18039, 48493, 48505, 48506, 48358, 0, 0, 0, 
0, 48347, 48494, 48507, 48360
29371, 2504, 2515, 2516, 2505, 46852, 46896, 46900, 46856, 0, 0, 0, 0, 48497, 48509, 48510, 
48362, 48348, 48495, 48508, 48361
29372, 46852, 46896, 46900, 46856, 46853, 46897, 46901, 46857, 48497, 48509, 48510, 48362, 48500, 48512, 48513, 
48365, 48351, 48498, 48511, 48364
29373, 46853, 46897, 46901, 46857, 46854, 46898, 46902, 46858, 48500, 48512, 48513, 48365, 48503, 48515, 48516, 
48368, 48354, 48501, 48514, 48367
29374, 46854, 46898, 46902, 46858, 46855, 46899, 46903, 46859, 48503, 48515, 48516, 48368, 48506, 48518, 48519, 
48371, 48357, 48504, 48517, 48370
29375, 46855, 46899, 46903, 46859, 18039, 18050, 18051, 18040, 48506, 48518, 48519, 48371, 0, 0, 0, 
0, 48360, 48507, 48520, 48373
29376, 2505, 2516, 2517, 2506, 46856, 46900, 46904, 46860, 0, 0, 0, 0, 48510, 48522, 48523, 
48375, 48361, 48508, 48521, 48374
29377, 46856, 46900, 46904, 46860, 46857, 46901, 46905, 46861, 48510, 48522, 48523, 48375, 48513, 48525, 48526, 
48378, 48364, 48511, 48524, 48377
29378, 46857, 46901, 46905, 46861, 46858, 46902, 46906, 46862, 48513, 48525, 48526, 48378, 48516, 48528, 48529, 
48381, 48367, 48514, 48527, 48380
29379, 46858, 46902, 46906, 46862, 46859, 46903, 46907, 46863, 48516, 48528, 48529, 48381, 48519, 48531, 48532, 
48384, 48370, 48517, 48530, 48383
29380, 46859, 46903, 46907, 46863, 18040, 18051, 18052, 18041, 48519, 48531, 48532, 48384, 0, 0, 0, 
0, 48373, 48520, 48533, 48386
29381, 2506, 2517, 178, 177, 46860, 46904, 17768, 17764, 0, 0, 0, 0, 48523, 48534, 0, 
48387, 48374, 48521, 0, 0
29382, 46860, 46904, 17768, 17764, 46861, 46905, 17769, 17765, 48523, 48534, 0, 48387, 48526, 48535, 0, 
48388, 48377, 48524, 0, 0
29383, 46861, 46905, 17769, 17765, 46862, 46906, 17770, 17766, 48526, 48535, 0, 48388, 48529, 48536, 0, 
48389, 48380, 48527, 0, 0
29384, 46862, 46906, 17770, 17766, 46863, 46907, 17771, 17767, 48529, 48536, 0, 48389, 48532, 48537, 0, 
48390, 48383, 48530, 0, 0
29385, 46863, 46907, 17771, 17767, 18041, 18052, 2237, 2236, 48532, 48537, 0, 48390, 0, 0, 0, 
0, 48386, 48533, 0, 0
29386, 155, 156, 2518, 2507, 17318, 17322, 46908, 46864, 0, 0, 0, 0, 17445, 48539, 48540, 
48392, 17435, 17444, 48538, 48391
29387, 17318, 17322, 46908, 46864, 17319, 17323, 46909, 46865, 17445, 48539, 48540, 48392, 17447, 48542, 48543, 
48395, 17437, 17446, 48541, 48394
29388, 17319, 17323, 46909, 46865, 17320, 17324, 46910, 46866, 17447, 48542, 48543, 48395, 17449, 48545, 48546, 
48398, 17439, 17448, 48544, 48397
29389, 17320, 17324, 46910, 46866, 17321, 17325, 46911, 46867, 17449, 48545, 48546, 48398, 17451, 48548, 48549, 
48401, 17441, 17450, 48547, 48400
29390, 17321, 17325, 46911, 46867, 2195, 2196, 18053, 18042, 17451, 48548, 48549, 48401, 0, 0, 0, 
0, 17443, 17452, 48550, 48403
29391, 2507, 2518, 2519, 2508, 46864, 46908, 46912, 46868, 0, 0, 0, 0, 48540, 48552, 48553, 
48405, 48391, 48538, 48551, 48404
29392, 46864, 46908, 46912, 46868, 46865, 46909, 46913, 46869, 48540, 48552, 48553, 48405, 48543, 48555, 48556, 
48408, 48394, 48541, 48554, 48407
29393, 46865, 46909, 46913, 46869, 46866, 46910, 46914, 46870, 48543, 48555, 48556, 48408, 48546, 48558, 48559, 
48411, 48397, 48544, 48557, 48410
29394, 46866, 46910, 46914, 46870, 46867, 46911, 46915, 46871, 48546, 48558, 48559, 48411, 48549, 48561, 48562, 
48414, 48400, 48547, 48560, 48413
29395, 46867, 46911, 46915, 46871, 18042, 18053, 18054, 18043, 48549, 48561, 48562, 48414, 0, 0, 0, 
0, 48403, 48550, 48563, 48416
29396, 2508, 2519, 2520, 2509, 46868, 46912, 46916, 46872, 0, 0, 0, 0, 48553, 48565, 48566, 
48418, 48404, 48551, 48564, 48417
29397, 46868, 46912, 46916, 46872, 46869, 46913, 46917, 46873, 48553, 48565, 48566, 48418, 48556, 48568, 48569, 
48421, 48407, 48554, 48567, 48420
29398, 46869, 46913, 46917, 46873, 46870, 46914, 46918, 46874, 48556, 48568, 48569, 48421, 48559, 48571, 48572, 
48424, 48410, 48557, 48570, 48423
29399, 46870, 46914, 46918, 46874, 46871, 46915, 46919, 46875, 48559, 48571, 48572, 48424, 48562, 48574, 48575, 
48427, 48413, 48560, 48573, 48426
29400, 46871, 46915, 46919, 46875, 18043, 18054, 18055, 18044, 48562, 48574, 48575, 48427, 0, 0, 0, 
0, 48416, 48563, 48576, 48429
29401, 2509, 2520, 2521, 2510, 46872, 46916, 46920, 46876, 0, 0, 0, 0, 48566, 48578, 48579, 
48431, 48417, 48564, 48577, 48430
29402, 46872, 46916, 46920, 46876, 46873, 46917, 46921, 46877, 48566, 48578, 48579, 48431, 48569, 48581, 48582, 
48434, 48420, 48567, 48580, 48433
29403, 46873, 46917, 46921, 46877, 46874, 46918, 46922, 46878, 48569, 48581, 48582, 48434, 48572, 48584, 48585, 
48437, 48423, 48570, 48583, 48436
29404, 46874, 46918, 46922, 46878, 46875, 46919, 46923, 46879, 48572, 48584, 48585, 48437, 48575, 48587, 48588, 
48440, 48426, 48573, 48586, 48439
29405, 46875, 46919, 46923, 46879, 18044, 18055, 18056, 18045, 48575, 48587, 48588, 48440, 0, 0, 0, 
0, 48429, 48576, 48589, 48442
29406, 2510, 2521, 2522, 2511, 46876, 46920, 46924, 46880, 0, 0, 0, 0, 48579, 48591, 48592, 
48444, 48430, 48577, 48590, 48443
29407, 46876, 46920, 46924, 46880, 46877, 46921, 46925, 46881, 48579, 48591, 48592, 48444, 48582, 48594, 48595, 
48447, 48433, 48580, 48593, 48446
29408, 46877, 46921, 46925, 46881, 46878, 46922, 46926, 46882, 48582, 48594, 48595, 48447, 48585, 48597, 48598, 
48450, 48436, 48583, 48596, 48449
29409, 46878, 46922, 46926, 46882, 46879, 46923, 46927, 46883, 48585, 48597, 48598, 48450, 48588, 48600, 48601, 
48453, 48439, 48586, 48599, 48452
29410, 46879, 46923, 46927, 46883, 18045, 18056, 18057, 18046, 48588, 48600, 48601, 48453, 0, 0, 0, 
0, 48442, 48589, 48602, 48455
29411, 2511, 2522, 2523, 2512, 46880, 46924, 46928, 46884, 0, 0, 0, 0, 48592, 48604, 48605, 
48457, 48443, 48590, 48603, 48456
29412, 46880, 46924, 46928, 46884, 46881, 46925, 46929, 46885, 48592, 48604, 48605, 48457, 48595, 48607, 48608, 
48460, 48446, 48593, 48606, 48459
29413, 46881, 46925, 46929, 46885, 46882, 46926, 46930, 46886, 48595, 48607, 48608, 48460, 48598, 48610, 48611, 
48463, 48449, 48596, 48609, 48462
29414, 46882, 46926, 46930, 46886, 46883, 46927, 46931, 46887, 48598, 48610, 48611, 48463, 48601, 48613, 48614, 
48466, 48452, 48599, 48612, 48465
29415, 46883, 46927, 46931, 46887, 18046, 18057, 18058, 18047, 48601, 48613, 48614, 48466, 0, 0, 0, 
0, 48455, 48602, 48615, 48468
29416, 2512, 2523, 2524, 2513, 46884, 46928, 46932, 46888, 0, 0, 0, 0, 48605, 48617, 48618, 
48470, 48456, 48603, 48616, 48469
29417, 46884, 46928, 46932, 46888, 46885, 46929, 46933, 46889, 48605, 48617, 48618, 48470, 48608, 48620, 48621, 
48473, 48459, 48606, 48619, 48472
29418, 46885, 46929, 46933, 46889, 46886, 46930, 46934, 46890, 48608, 48620, 48621, 48473, 48611, 48623, 48624, 
48476, 48462, 48609, 48622, 48475
29419, 46886, 46930, 46934, 46890, 46887, 46931, 46935, 46891, 48611, 48623, 48624, 48476, 48614, 48626, 48627, 
48479, 48465, 48612, 48625, 48478
29420, 46887, 46931, 46935, 46891, 18047, 18058, 18059, 18048, 48614, 48626, 48627, 48479, 0, 0, 0, 
0, 48468, 48615, 48628, 48481
29421, 2513, 2524, 2525, 2514, 46888, 46932, 46936, 46892, 0, 0, 0, 0, 48618, 48630, 48631, 
48483, 48469, 48616, 48629, 48482
29422, 46888, 46932, 46936, 46892, 46889, 46933, 46937, 46893, 48618, 48630, 48631, 48483, 48621, 48633, 48634, 
48486, 48472, 48619, 48632, 48485
29423, 46889, 46933, 46937, 46893, 46890, 46934, 46938, 46894, 48621, 48633, 48634, 48486, 48624, 48636, 48637, 
48489, 48475, 48622, 48635, 48488
29424, 46890, 46934, 46938, 46894, 46891, 46935, 46939, 46895, 48624, 48636, 48637, 48489, 48627, 48639, 48640, 
48492, 48478, 48625, 48638, 48491
29425, 46891, 46935, 46939, 46895, 18048, 18059, 18060, 18049, 48627, 48639, 48640, 48492, 0, 0, 0, 
0, 48481, 48628, 48641, 48494
29426, 2514, 2525, 2526, 2515, 46892, 46936, 46940, 46896, 0, 0, 0, 0, 48631, 48643, 48644, 
48496, 48482, 48629, 48642, 48495
29427, 46892, 46936, 46940, 46896, 46893, 46937, 46941, 46897, 48631, 48643, 48644, 48496, 48634, 48646, 48647, 
48499, 48485, 48632, 48645, 48498
29428, 46893, 46937, 46941, 46897, 46894, 46938, 46942, 46898, 48634, 48646, 48647, 48499, 48637, 48649, 48650, 
48502, 48488, 48635, 48648, 48501
29429, 46894, 46938, 46942, 46898, 46895, 46939, 46943, 46899, 48637, 48649, 48650, 48502, 48640, 48652, 48653, 
48505, 48491, 48638, 48651, 48504
29430, 46895, 46939, 46943, 46899, 18049, 18060, 18061, 18050, 48640, 48652, 48653, 48505, 0, 0, 0, 
0, 48494, 48641, 48654, 48507
29431, 2515, 2526, 2527, 2516, 46896, 46940, 46944, 46900, 0, 0, 0, 0, 48644, 48656, 48657, 
48509, 48495, 48642, 48655, 48508
29432, 46896, 46940, 46944, 46900, 46897, 46941, 46945, 46901, 48644, 48656, 48657, 48509, 48647, 48659, 48660, 
48512, 48498, 48645, 48658, 48511
29433, 46897, 46941, 46945, 46901, 46898, 46942, 46946, 46902, 48647, 48659, 48660, 48512, 48650, 48662, 48663, 
48515, 48501, 48648, 48661, 48514
29434, 46898, 46942, 46946, 46902, 46899, 46943, 46947, 46903, 48650, 48662, 48663, 48515, 48653, 48665, 48666, 
48518, 48504, 48651, 48664, 48517
29435, 46899, 46943, 46947, 46903, 18050, 18061, 18062, 18051, 48653, 48665, 48666, 48518, 0, 0, 0, 
0, 48507, 48654, 48667, 48520
29436, 2516, 2527, 2528, 2517, 46900, 46944, 46948, 46904, 0, 0, 0, 0, 48657, 48669, 48670, 
48522, 48508, 48655, 48668, 48521
29437, 46900, 46944, 46948, 46904, 46901, 46945, 46949, 46905, 48657, 48669, 48670, 48522, 48660, 48672, 48673, 
48525, 48511, 48658, 48671, 48524
29438, 46901, 46945, 46949, 46905, 46902, 46946, 46950, 46906, 48660, 48672, 48673, 48525, 48663, 48675, 48676, 
48528, 48514, 48661, 48674, 48527
29439, 46902, 46946, 46950, 46906, 46903, 46947, 46951, 46907, 48663, 48675, 48676, 48528, 48666, 48678, 48679, 
48531, 48517, 48664, 48677, 48530
29440, 46903, 46947, 46951, 46907, 18051, 18062, 18063, 18052, 48666, 48678, 48679, 48531, 0, 0, 0, 
0, 48520, 48667, 48680, 48533
29441, 2517, 2528, 179, 178, 46904, 46948, 17772, 17768, 0, 0, 0, 0, 48670, 48681, 0, 
48534, 48521, 48668, 0, 0
29442, 46904, 46948, 17772, 17768, 46905, 46949, 17773, 17769, 48670, 48681, 0, 48534, 48673, 48682, 0, 
48535, 48524, 48671, 0, 0
29443, 46905, 46949, 17773, 17769, 46906, 46950, 17774, 17770, 48673, 48682, 0, 48535, 48676, 48683, 0, 
48536, 48527, 48674, 0, 0
29444, 46906, 46950, 17774, 17770, 46907, 46951, 17775, 17771, 48676, 48683, 0, 48536, 48679, 48684, 0, 
48537, 48530, 48677, 0, 0
29445, 46907, 46951, 17775, 17771, 18052, 18063, 2238, 2237, 48679, 48684, 0, 48537, 0, 0, 0, 
0, 48533, 48680, 0, 0
29446, 156, 157, 2529, 2518, 17322, 17326, 46952, 46908, 0, 0, 0, 0, 17454, 48686, 48687, 
48539, 17444, 17453, 48685, 48538
29447, 17322, 17326, 46952, 46908, 17323, 17327, 46953, 46909, 17454, 48686, 48687, 48539, 17456, 48689, 48690, 
48542, 17446, 17455, 48688, 48541
29448, 17323, 17327, 46953, 46909, 17324, 17328, 46954, 46910, 17456, 48689, 48690, 48542, 17458, 48692, 48693, 
48545, 17448, 17457, 48691, 48544
29449, 17324, 17328, 46954, 46910, 17325, 17329, 46955, 46911, 17458, 48692, 48693, 48545, 17460, 48695, 48696, 
48548, 17450, 17459, 48694, 48547
29450, 17325, 17329, 46955, 46911, 2196, 2197, 18064, 18053, 17460, 48695, 48696, 48548, 0, 0, 0, 
0, 17452, 17461, 48697, 48550
29451, 2518, 2529, 2530, 2519, 46908, 46952, 46956, 46912, 0, 0, 0, 0, 48687, 48699, 48700, 
48552, 48538, 48685, 48698, 48551
29452, 46908, 46952, 46956, 46912, 46909, 46953, 46957, 46913, 48687, 48699, 48700, 48552, 48690, 48702, 48703, 
48555, 48541, 48688, 48701, 48554
29453, 46909, 46953, 46957, 46913, 46910, 46954, 46958, 46914, 48690, 48702, 48703, 48555, 48693, 48705, 48706, 
48558, 48544, 48691, 48704, 48557
29454, 46910, 46954, 46958, 46914, 46911, 46955, 46959, 46915, 48693, 48705, 48706, 48558, 48696, 48708, 48709, 
48561, 48547, 48694, 48707, 48560
29455, 46911, 46955, 46959, 46915, 18053, 18064, 18065, 18054, 48696, 48708, 48709, 48561, 0, 0, 0, 
0, 48550, 48697, 48710, 48563
29456, 2519, 2530, 2531, 2520, 46912, 46956, 46960, 46916, 0, 0, 0, 0, 48700, 48712, 48713, 
48565, 48551, 48698, 48711, 48564
29457, 46912, 46956, 46960, 46916, 46913, 46957, 46961, 46917, 48700, 48712, 48713, 48565, 48703, 48715, 48716, 
48568, 48554, 48701, 48714, 48567
29458, 46913, 46957, 46961, 46917, 46914, 46958, 46962, 46918, 48703, 48715, 48716, 48568, 48706, 48718, 48719, 
48571, 48557, 48704, 48717, 48570
29459, 46914, 46958, 46962, 46918, 46915, 46959, 46963, 46919, 48706, 48718, 48719, 48571, 48709, 48721, 48722, 
