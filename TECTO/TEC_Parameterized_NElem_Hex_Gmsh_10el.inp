764, 4320, 4343, 4344, 4321, 0, 0, 0, 0
765, 4321, 4344, 4345, 4322, 0, 0, 0, 0
766, 4322, 4345, 4346, 4323, 0, 0, 0, 0
767, 4323, 4346, 4347, 4324, 0, 0, 0, 0
768, 4324, 4347, 4348, 4325, 0, 0, 0, 0
769, 4325, 4348, 4349, 4326, 0, 0, 0, 0
770, 4326, 4349, 4350, 4327, 0, 0, 0, 0
771, 4327, 4350, 4351, 4328, 0, 0, 0, 0
772, 4328, 4351, 4352, 4329, 0, 0, 0, 0
773, 4329, 4352, 4353, 4330, 0, 0, 0, 0
774, 4330, 4353, 4354, 4331, 0, 0, 0, 0
775, 4331, 4354, 4355, 4332, 0, 0, 0, 0
776, 4332, 4355, 4356, 4333, 0, 0, 0, 0
777, 4333, 4356, 4357, 4334, 0, 0, 0, 0
778, 4334, 4357, 4358, 4335, 0, 0, 0, 0
779, 4335, 4358, 4359, 4336, 0, 0, 0, 0
780, 4336, 4359, 4360, 4337, 0, 0, 0, 0
781, 4337, 4360, 447, 446, 0, 0, 0, 0
782, 287, 288, 4361, 4338, 0, 0, 0, 0
783, 4338, 4361, 4362, 4339, 0, 0, 0, 0
784, 4339, 4362, 4363, 4340, 0, 0, 0, 0
785, 4340, 4363, 4364, 4341, 0, 0, 0, 0
786, 4341, 4364, 4365, 4342, 0, 0, 0, 0
787, 4342, 4365, 4366, 4343, 0, 0, 0, 0
788, 4343, 4366, 4367, 4344, 0, 0, 0, 0
789, 4344, 4367, 4368, 4345, 0, 0, 0, 0
790, 4345, 4368, 4369, 4346, 0, 0, 0, 0
791, 4346, 4369, 4370, 4347, 0, 0, 0, 0
792, 4347, 4370, 4371, 4348, 0, 0, 0, 0
793, 4348, 4371, 4372, 4349, 0, 0, 0, 0
794, 4349, 4372, 4373, 4350, 0, 0, 0, 0
795, 4350, 4373, 4374, 4351, 0, 0, 0, 0
796, 4351, 4374, 4375, 4352, 0, 0, 0, 0
797, 4352, 4375, 4376, 4353, 0, 0, 0, 0
798, 4353, 4376, 4377, 4354, 0, 0, 0, 0
799, 4354, 4377, 4378, 4355, 0, 0, 0, 0
800, 4355, 4378, 4379, 4356, 0, 0, 0, 0
801, 4356, 4379, 4380, 4357, 0, 0, 0, 0
802, 4357, 4380, 4381, 4358, 0, 0, 0, 0
803, 4358, 4381, 4382, 4359, 0, 0, 0, 0
804, 4359, 4382, 4383, 4360, 0, 0, 0, 0
805, 4360, 4383, 448, 447, 0, 0, 0, 0
806, 288, 289, 4384, 4361, 0, 0, 0, 0
807, 4361, 4384, 4385, 4362, 0, 0, 0, 0
808, 4362, 4385, 4386, 4363, 0, 0, 0, 0
809, 4363, 4386, 4387, 4364, 0, 0, 0, 0
810, 4364, 4387, 4388, 4365, 0, 0, 0, 0
811, 4365, 4388, 4389, 4366, 0, 0, 0, 0
812, 4366, 4389, 4390, 4367, 0, 0, 0, 0
813, 4367, 4390, 4391, 4368, 0, 0, 0, 0
814, 4368, 4391, 4392, 4369, 0, 0, 0, 0
815, 4369, 4392, 4393, 4370, 0, 0, 0, 0
816, 4370, 4393, 4394, 4371, 0, 0, 0, 0
817, 4371, 4394, 4395, 4372, 0, 0, 0, 0
818, 4372, 4395, 4396, 4373, 0, 0, 0, 0
819, 4373, 4396, 4397, 4374, 0, 0, 0, 0
820, 4374, 4397, 4398, 4375, 0, 0, 0, 0
821, 4375, 4398, 4399, 4376, 0, 0, 0, 0
822, 4376, 4399, 4400, 4377, 0, 0, 0, 0
823, 4377, 4400, 4401, 4378, 0, 0, 0, 0
824, 4378, 4401, 4402, 4379, 0, 0, 0, 0
825, 4379, 4402, 4403, 4380, 0, 0, 0, 0
826, 4380, 4403, 4404, 4381, 0, 0, 0, 0
827, 4381, 4404, 4405, 4382, 0, 0, 0, 0
828, 4382, 4405, 4406, 4383, 0, 0, 0, 0
829, 4383, 4406, 449, 448, 0, 0, 0, 0
830, 289, 290, 4407, 4384, 0, 0, 0, 0
831, 4384, 4407, 4408, 4385, 0, 0, 0, 0
832, 4385, 4408, 4409, 4386, 0, 0, 0, 0
833, 4386, 4409, 4410, 4387, 0, 0, 0, 0
834, 4387, 4410, 4411, 4388, 0, 0, 0, 0
835, 4388, 4411, 4412, 4389, 0, 0, 0, 0
836, 4389, 4412, 4413, 4390, 0, 0, 0, 0
837, 4390, 4413, 4414, 4391, 0, 0, 0, 0
838, 4391, 4414, 4415, 4392, 0, 0, 0, 0
839, 4392, 4415, 4416, 4393, 0, 0, 0, 0
840, 4393, 4416, 4417, 4394, 0, 0, 0, 0
841, 4394, 4417, 4418, 4395, 0, 0, 0, 0
842, 4395, 4418, 4419, 4396, 0, 0, 0, 0
843, 4396, 4419, 4420, 4397, 0, 0, 0, 0
844, 4397, 4420, 4421, 4398, 0, 0, 0, 0
845, 4398, 4421, 4422, 4399, 0, 0, 0, 0
846, 4399, 4422, 4423, 4400, 0, 0, 0, 0
847, 4400, 4423, 4424, 4401, 0, 0, 0, 0
848, 4401, 4424, 4425, 4402, 0, 0, 0, 0
849, 4402, 4425, 4426, 4403, 0, 0, 0, 0
850, 4403, 4426, 4427, 4404, 0, 0, 0, 0
851, 4404, 4427, 4428, 4405, 0, 0, 0, 0
852, 4405, 4428, 4429, 4406, 0, 0, 0, 0
853, 4406, 4429, 450, 449, 0, 0, 0, 0
854, 290, 291, 4430, 4407, 0, 0, 0, 0
855, 4407, 4430, 4431, 4408, 0, 0, 0, 0
856, 4408, 4431, 4432, 4409, 0, 0, 0, 0
857, 4409, 4432, 4433, 4410, 0, 0, 0, 0
858, 4410, 4433, 4434, 4411, 0, 0, 0, 0
859, 4411, 4434, 4435, 4412, 0, 0, 0, 0
860, 4412, 4435, 4436, 4413, 0, 0, 0, 0
861, 4413, 4436, 4437, 4414, 0, 0, 0, 0
862, 4414, 4437, 4438, 4415, 0, 0, 0, 0
863, 4415, 4438, 4439, 4416, 0, 0, 0, 0
864, 4416, 4439, 4440, 4417, 0, 0, 0, 0
865, 4417, 4440, 4441, 4418, 0, 0, 0, 0
866, 4418, 4441, 4442, 4419, 0, 0, 0, 0
867, 4419, 4442, 4443, 4420, 0, 0, 0, 0
868, 4420, 4443, 4444, 4421, 0, 0, 0, 0
869, 4421, 4444, 4445, 4422, 0, 0, 0, 0
870, 4422, 4445, 4446, 4423, 0, 0, 0, 0
871, 4423, 4446, 4447, 4424, 0, 0, 0, 0
872, 4424, 4447, 4448, 4425, 0, 0, 0, 0
873, 4425, 4448, 4449, 4426, 0, 0, 0, 0
874, 4426, 4449, 4450, 4427, 0, 0, 0, 0
875, 4427, 4450, 4451, 4428, 0, 0, 0, 0
876, 4428, 4451, 4452, 4429, 0, 0, 0, 0
877, 4429, 4452, 451, 450, 0, 0, 0, 0
878, 291, 292, 4453, 4430, 0, 0, 0, 0
879, 4430, 4453, 4454, 4431, 0, 0, 0, 0
880, 4431, 4454, 4455, 4432, 0, 0, 0, 0
881, 4432, 4455, 4456, 4433, 0, 0, 0, 0
882, 4433, 4456, 4457, 4434, 0, 0, 0, 0
883, 4434, 4457, 4458, 4435, 0, 0, 0, 0
884, 4435, 4458, 4459, 4436, 0, 0, 0, 0
885, 4436, 4459, 4460, 4437, 0, 0, 0, 0
886, 4437, 4460, 4461, 4438, 0, 0, 0, 0
887, 4438, 4461, 4462, 4439, 0, 0, 0, 0
888, 4439, 4462, 4463, 4440, 0, 0, 0, 0
889, 4440, 4463, 4464, 4441, 0, 0, 0, 0
890, 4441, 4464, 4465, 4442, 0, 0, 0, 0
891, 4442, 4465, 4466, 4443, 0, 0, 0, 0
892, 4443, 4466, 4467, 4444, 0, 0, 0, 0
893, 4444, 4467, 4468, 4445, 0, 0, 0, 0
894, 4445, 4468, 4469, 4446, 0, 0, 0, 0
895, 4446, 4469, 4470, 4447, 0, 0, 0, 0
896, 4447, 4470, 4471, 4448, 0, 0, 0, 0
897, 4448, 4471, 4472, 4449, 0, 0, 0, 0
898, 4449, 4472, 4473, 4450, 0, 0, 0, 0
899, 4450, 4473, 4474, 4451, 0, 0, 0, 0
900, 4451, 4474, 4475, 4452, 0, 0, 0, 0
901, 4452, 4475, 452, 451, 0, 0, 0, 0
902, 292, 293, 4476, 4453, 0, 0, 0, 0
903, 4453, 4476, 4477, 4454, 0, 0, 0, 0
904, 4454, 4477, 4478, 4455, 0, 0, 0, 0
905, 4455, 4478, 4479, 4456, 0, 0, 0, 0
906, 4456, 4479, 4480, 4457, 0, 0, 0, 0
907, 4457, 4480, 4481, 4458, 0, 0, 0, 0
908, 4458, 4481, 4482, 4459, 0, 0, 0, 0
909, 4459, 4482, 4483, 4460, 0, 0, 0, 0
910, 4460, 4483, 4484, 4461, 0, 0, 0, 0
911, 4461, 4484, 4485, 4462, 0, 0, 0, 0
912, 4462, 4485, 4486, 4463, 0, 0, 0, 0
913, 4463, 4486, 4487, 4464, 0, 0, 0, 0
914, 4464, 4487, 4488, 4465, 0, 0, 0, 0
915, 4465, 4488, 4489, 4466, 0, 0, 0, 0
916, 4466, 4489, 4490, 4467, 0, 0, 0, 0
917, 4467, 4490, 4491, 4468, 0, 0, 0, 0
918, 4468, 4491, 4492, 4469, 0, 0, 0, 0
919, 4469, 4492, 4493, 4470, 0, 0, 0, 0
920, 4470, 4493, 4494, 4471, 0, 0, 0, 0
921, 4471, 4494, 4495, 4472, 0, 0, 0, 0
922, 4472, 4495, 4496, 4473, 0, 0, 0, 0
923, 4473, 4496, 4497, 4474, 0, 0, 0, 0
924, 4474, 4497, 4498, 4475, 0, 0, 0, 0
925, 4475, 4498, 453, 452, 0, 0, 0, 0
926, 293, 294, 4499, 4476, 0, 0, 0, 0
927, 4476, 4499, 4500, 4477, 0, 0, 0, 0
928, 4477, 4500, 4501, 4478, 0, 0, 0, 0
929, 4478, 4501, 4502, 4479, 0, 0, 0, 0
930, 4479, 4502, 4503, 4480, 0, 0, 0, 0
931, 4480, 4503, 4504, 4481, 0, 0, 0, 0
932, 4481, 4504, 4505, 4482, 0, 0, 0, 0
933, 4482, 4505, 4506, 4483, 0, 0, 0, 0
934, 4483, 4506, 4507, 4484, 0, 0, 0, 0
935, 4484, 4507, 4508, 4485, 0, 0, 0, 0
936, 4485, 4508, 4509, 4486, 0, 0, 0, 0
937, 4486, 4509, 4510, 4487, 0, 0, 0, 0
938, 4487, 4510, 4511, 4488, 0, 0, 0, 0
939, 4488, 4511, 4512, 4489, 0, 0, 0, 0
940, 4489, 4512, 4513, 4490, 0, 0, 0, 0
941, 4490, 4513, 4514, 4491, 0, 0, 0, 0
942, 4491, 4514, 4515, 4492, 0, 0, 0, 0
943, 4492, 4515, 4516, 4493, 0, 0, 0, 0
944, 4493, 4516, 4517, 4494, 0, 0, 0, 0
945, 4494, 4517, 4518, 4495, 0, 0, 0, 0
946, 4495, 4518, 4519, 4496, 0, 0, 0, 0
947, 4496, 4519, 4520, 4497, 0, 0, 0, 0
948, 4497, 4520, 4521, 4498, 0, 0, 0, 0
949, 4498, 4521, 454, 453, 0, 0, 0, 0
950, 294, 295, 4522, 4499, 0, 0, 0, 0
951, 4499, 4522, 4523, 4500, 0, 0, 0, 0
952, 4500, 4523, 4524, 4501, 0, 0, 0, 0
953, 4501, 4524, 4525, 4502, 0, 0, 0, 0
954, 4502, 4525, 4526, 4503, 0, 0, 0, 0
955, 4503, 4526, 4527, 4504, 0, 0, 0, 0
956, 4504, 4527, 4528, 4505, 0, 0, 0, 0
957, 4505, 4528, 4529, 4506, 0, 0, 0, 0
958, 4506, 4529, 4530, 4507, 0, 0, 0, 0
959, 4507, 4530, 4531, 4508, 0, 0, 0, 0
960, 4508, 4531, 4532, 4509, 0, 0, 0, 0
961, 4509, 4532, 4533, 4510, 0, 0, 0, 0
962, 4510, 4533, 4534, 4511, 0, 0, 0, 0
963, 4511, 4534, 4535, 4512, 0, 0, 0, 0
964, 4512, 4535, 4536, 4513, 0, 0, 0, 0
965, 4513, 4536, 4537, 4514, 0, 0, 0, 0
966, 4514, 4537, 4538, 4515, 0, 0, 0, 0
967, 4515, 4538, 4539, 4516, 0, 0, 0, 0
968, 4516, 4539, 4540, 4517, 0, 0, 0, 0
969, 4517, 4540, 4541, 4518, 0, 0, 0, 0
970, 4518, 4541, 4542, 4519, 0, 0, 0, 0
971, 4519, 4542, 4543, 4520, 0, 0, 0, 0
972, 4520, 4543, 4544, 4521, 0, 0, 0, 0
973, 4521, 4544, 455, 454, 0, 0, 0, 0
974, 295, 296, 4545, 4522, 0, 0, 0, 0
975, 4522, 4545, 4546, 4523, 0, 0, 0, 0
976, 4523, 4546, 4547, 4524, 0, 0, 0, 0
977, 4524, 4547, 4548, 4525, 0, 0, 0, 0
978, 4525, 4548, 4549, 4526, 0, 0, 0, 0
979, 4526, 4549, 4550, 4527, 0, 0, 0, 0
980, 4527, 4550, 4551, 4528, 0, 0, 0, 0
981, 4528, 4551, 4552, 4529, 0, 0, 0, 0
982, 4529, 4552, 4553, 4530, 0, 0, 0, 0
983, 4530, 4553, 4554, 4531, 0, 0, 0, 0
984, 4531, 4554, 4555, 4532, 0, 0, 0, 0
985, 4532, 4555, 4556, 4533, 0, 0, 0, 0
986, 4533, 4556, 4557, 4534, 0, 0, 0, 0
987, 4534, 4557, 4558, 4535, 0, 0, 0, 0
988, 4535, 4558, 4559, 4536, 0, 0, 0, 0
989, 4536, 4559, 4560, 4537, 0, 0, 0, 0
990, 4537, 4560, 4561, 4538, 0, 0, 0, 0
991, 4538, 4561, 4562, 4539, 0, 0, 0, 0
992, 4539, 4562, 4563, 4540, 0, 0, 0, 0
993, 4540, 4563, 4564, 4541, 0, 0, 0, 0
994, 4541, 4564, 4565, 4542, 0, 0, 0, 0
995, 4542, 4565, 4566, 4543, 0, 0, 0, 0
996, 4543, 4566, 4567, 4544, 0, 0, 0, 0
997, 4544, 4567, 456, 455, 0, 0, 0, 0
998, 296, 297, 4568, 4545, 0, 0, 0, 0
999, 4545, 4568, 4569, 4546, 0, 0, 0, 0
1000, 4546, 4569, 4570, 4547, 0, 0, 0, 0
1001, 4547, 4570, 4571, 4548, 0, 0, 0, 0
1002, 4548, 4571, 4572, 4549, 0, 0, 0, 0
1003, 4549, 4572, 4573, 4550, 0, 0, 0, 0
1004, 4550, 4573, 4574, 4551, 0, 0, 0, 0
1005, 4551, 4574, 4575, 4552, 0, 0, 0, 0
1006, 4552, 4575, 4576, 4553, 0, 0, 0, 0
1007, 4553, 4576, 4577, 4554, 0, 0, 0, 0
1008, 4554, 4577, 4578, 4555, 0, 0, 0, 0
1009, 4555, 4578, 4579, 4556, 0, 0, 0, 0
1010, 4556, 4579, 4580, 4557, 0, 0, 0, 0
1011, 4557, 4580, 4581, 4558, 0, 0, 0, 0
1012, 4558, 4581, 4582, 4559, 0, 0, 0, 0
1013, 4559, 4582, 4583, 4560, 0, 0, 0, 0
1014, 4560, 4583, 4584, 4561, 0, 0, 0, 0
1015, 4561, 4584, 4585, 4562, 0, 0, 0, 0
1016, 4562, 4585, 4586, 4563, 0, 0, 0, 0
1017, 4563, 4586, 4587, 4564, 0, 0, 0, 0
1018, 4564, 4587, 4588, 4565, 0, 0, 0, 0
1019, 4565, 4588, 4589, 4566, 0, 0, 0, 0
1020, 4566, 4589, 4590, 4567, 0, 0, 0, 0
1021, 4567, 4590, 457, 456, 0, 0, 0, 0
1022, 297, 298, 4591, 4568, 0, 0, 0, 0
1023, 4568, 4591, 4592, 4569, 0, 0, 0, 0
1024, 4569, 4592, 4593, 4570, 0, 0, 0, 0
1025, 4570, 4593, 4594, 4571, 0, 0, 0, 0
1026, 4571, 4594, 4595, 4572, 0, 0, 0, 0
1027, 4572, 4595, 4596, 4573, 0, 0, 0, 0
1028, 4573, 4596, 4597, 4574, 0, 0, 0, 0
1029, 4574, 4597, 4598, 4575, 0, 0, 0, 0
1030, 4575, 4598, 4599, 4576, 0, 0, 0, 0
1031, 4576, 4599, 4600, 4577, 0, 0, 0, 0
1032, 4577, 4600, 4601, 4578, 0, 0, 0, 0
1033, 4578, 4601, 4602, 4579, 0, 0, 0, 0
1034, 4579, 4602, 4603, 4580, 0, 0, 0, 0
1035, 4580, 4603, 4604, 4581, 0, 0, 0, 0
1036, 4581, 4604, 4605, 4582, 0, 0, 0, 0
1037, 4582, 4605, 4606, 4583, 0, 0, 0, 0
1038, 4583, 4606, 4607, 4584, 0, 0, 0, 0
1039, 4584, 4607, 4608, 4585, 0, 0, 0, 0
1040, 4585, 4608, 4609, 4586, 0, 0, 0, 0
1041, 4586, 4609, 4610, 4587, 0, 0, 0, 0
1042, 4587, 4610, 4611, 4588, 0, 0, 0, 0
1043, 4588, 4611, 4612, 4589, 0, 0, 0, 0
1044, 4589, 4612, 4613, 4590, 0, 0, 0, 0
1045, 4590, 4613, 458, 457, 0, 0, 0, 0
1046, 298, 11, 379, 4591, 0, 0, 0, 0
1047, 4591, 379, 380, 4592, 0, 0, 0, 0
1048, 4592, 380, 381, 4593, 0, 0, 0, 0
1049, 4593, 381, 382, 4594, 0, 0, 0, 0
1050, 4594, 382, 383, 4595, 0, 0, 0, 0
1051, 4595, 383, 384, 4596, 0, 0, 0, 0
1052, 4596, 384, 385, 4597, 0, 0, 0, 0
1053, 4597, 385, 386, 4598, 0, 0, 0, 0
1054, 4598, 386, 387, 4599, 0, 0, 0, 0
1055, 4599, 387, 388, 4600, 0, 0, 0, 0
1056, 4600, 388, 389, 4601, 0, 0, 0, 0
1057, 4601, 389, 390, 4602, 0, 0, 0, 0
1058, 4602, 390, 391, 4603, 0, 0, 0, 0
1059, 4603, 391, 392, 4604, 0, 0, 0, 0
1060, 4604, 392, 393, 4605, 0, 0, 0, 0
1061, 4605, 393, 394, 4606, 0, 0, 0, 0
1062, 4606, 394, 395, 4607, 0, 0, 0, 0
1063, 4607, 395, 396, 4608, 0, 0, 0, 0
1064, 4608, 396, 397, 4609, 0, 0, 0, 0
1065, 4609, 397, 398, 4610, 0, 0, 0, 0
1066, 4610, 398, 399, 4611, 0, 0, 0, 0
1067, 4611, 399, 400, 4612, 0, 0, 0, 0
1068, 4612, 400, 401, 4613, 0, 0, 0, 0
1069, 4613, 401, 15, 458, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface15
35687, 10, 299, 4614, 333, 0, 0, 0, 0
35688, 333, 4614, 4615, 334, 0, 0, 0, 0
35689, 334, 4615, 4616, 335, 0, 0, 0, 0
35690, 335, 4616, 4617, 336, 0, 0, 0, 0
35691, 336, 4617, 4618, 337, 0, 0, 0, 0
35692, 337, 4618, 4619, 338, 0, 0, 0, 0
35693, 338, 4619, 4620, 339, 0, 0, 0, 0
35694, 339, 4620, 4621, 340, 0, 0, 0, 0
35695, 340, 4621, 4622, 341, 0, 0, 0, 0
35696, 341, 4622, 4623, 342, 0, 0, 0, 0
35697, 342, 4623, 4624, 343, 0, 0, 0, 0
35698, 343, 4624, 4625, 344, 0, 0, 0, 0
35699, 344, 4625, 4626, 345, 0, 0, 0, 0
35700, 345, 4626, 4627, 346, 0, 0, 0, 0
35701, 346, 4627, 4628, 347, 0, 0, 0, 0
35702, 347, 4628, 4629, 348, 0, 0, 0, 0
35703, 348, 4629, 4630, 349, 0, 0, 0, 0
35704, 349, 4630, 4631, 350, 0, 0, 0, 0
35705, 350, 4631, 4632, 351, 0, 0, 0, 0
35706, 351, 4632, 4633, 352, 0, 0, 0, 0
35707, 352, 4633, 4634, 353, 0, 0, 0, 0
35708, 353, 4634, 4635, 354, 0, 0, 0, 0
35709, 354, 4635, 4636, 355, 0, 0, 0, 0
35710, 355, 4636, 459, 14, 0, 0, 0, 0
35711, 299, 300, 4637, 4614, 0, 0, 0, 0
35712, 4614, 4637, 4638, 4615, 0, 0, 0, 0
35713, 4615, 4638, 4639, 4616, 0, 0, 0, 0
35714, 4616, 4639, 4640, 4617, 0, 0, 0, 0
35715, 4617, 4640, 4641, 4618, 0, 0, 0, 0
35716, 4618, 4641, 4642, 4619, 0, 0, 0, 0
35717, 4619, 4642, 4643, 4620, 0, 0, 0, 0
35718, 4620, 4643, 4644, 4621, 0, 0, 0, 0
35719, 4621, 4644, 4645, 4622, 0, 0, 0, 0
35720, 4622, 4645, 4646, 4623, 0, 0, 0, 0
35721, 4623, 4646, 4647, 4624, 0, 0, 0, 0
35722, 4624, 4647, 4648, 4625, 0, 0, 0, 0
35723, 4625, 4648, 4649, 4626, 0, 0, 0, 0
35724, 4626, 4649, 4650, 4627, 0, 0, 0, 0
35725, 4627, 4650, 4651, 4628, 0, 0, 0, 0
35726, 4628, 4651, 4652, 4629, 0, 0, 0, 0
35727, 4629, 4652, 4653, 4630, 0, 0, 0, 0
35728, 4630, 4653, 4654, 4631, 0, 0, 0, 0
35729, 4631, 4654, 4655, 4632, 0, 0, 0, 0
35730, 4632, 4655, 4656, 4633, 0, 0, 0, 0
35731, 4633, 4656, 4657, 4634, 0, 0, 0, 0
35732, 4634, 4657, 4658, 4635, 0, 0, 0, 0
35733, 4635, 4658, 4659, 4636, 0, 0, 0, 0
35734, 4636, 4659, 460, 459, 0, 0, 0, 0
35735, 300, 301, 4660, 4637, 0, 0, 0, 0
35736, 4637, 4660, 4661, 4638, 0, 0, 0, 0
35737, 4638, 4661, 4662, 4639, 0, 0, 0, 0
35738, 4639, 4662, 4663, 4640, 0, 0, 0, 0
35739, 4640, 4663, 4664, 4641, 0, 0, 0, 0
35740, 4641, 4664, 4665, 4642, 0, 0, 0, 0
35741, 4642, 4665, 4666, 4643, 0, 0, 0, 0
35742, 4643, 4666, 4667, 4644, 0, 0, 0, 0
35743, 4644, 4667, 4668, 4645, 0, 0, 0, 0
35744, 4645, 4668, 4669, 4646, 0, 0, 0, 0
35745, 4646, 4669, 4670, 4647, 0, 0, 0, 0
35746, 4647, 4670, 4671, 4648, 0, 0, 0, 0
35747, 4648, 4671, 4672, 4649, 0, 0, 0, 0
35748, 4649, 4672, 4673, 4650, 0, 0, 0, 0
35749, 4650, 4673, 4674, 4651, 0, 0, 0, 0
35750, 4651, 4674, 4675, 4652, 0, 0, 0, 0
35751, 4652, 4675, 4676, 4653, 0, 0, 0, 0
35752, 4653, 4676, 4677, 4654, 0, 0, 0, 0
35753, 4654, 4677, 4678, 4655, 0, 0, 0, 0
35754, 4655, 4678, 4679, 4656, 0, 0, 0, 0
35755, 4656, 4679, 4680, 4657, 0, 0, 0, 0
35756, 4657, 4680, 4681, 4658, 0, 0, 0, 0
35757, 4658, 4681, 4682, 4659, 0, 0, 0, 0
35758, 4659, 4682, 461, 460, 0, 0, 0, 0
35759, 301, 302, 4683, 4660, 0, 0, 0, 0
35760, 4660, 4683, 4684, 4661, 0, 0, 0, 0
35761, 4661, 4684, 4685, 4662, 0, 0, 0, 0
35762, 4662, 4685, 4686, 4663, 0, 0, 0, 0
35763, 4663, 4686, 4687, 4664, 0, 0, 0, 0
35764, 4664, 4687, 4688, 4665, 0, 0, 0, 0
35765, 4665, 4688, 4689, 4666, 0, 0, 0, 0
35766, 4666, 4689, 4690, 4667, 0, 0, 0, 0
35767, 4667, 4690, 4691, 4668, 0, 0, 0, 0
35768, 4668, 4691, 4692, 4669, 0, 0, 0, 0
35769, 4669, 4692, 4693, 4670, 0, 0, 0, 0
35770, 4670, 4693, 4694, 4671, 0, 0, 0, 0
35771, 4671, 4694, 4695, 4672, 0, 0, 0, 0
35772, 4672, 4695, 4696, 4673, 0, 0, 0, 0
35773, 4673, 4696, 4697, 4674, 0, 0, 0, 0
35774, 4674, 4697, 4698, 4675, 0, 0, 0, 0
35775, 4675, 4698, 4699, 4676, 0, 0, 0, 0
35776, 4676, 4699, 4700, 4677, 0, 0, 0, 0
35777, 4677, 4700, 4701, 4678, 0, 0, 0, 0
35778, 4678, 4701, 4702, 4679, 0, 0, 0, 0
35779, 4679, 4702, 4703, 4680, 0, 0, 0, 0
35780, 4680, 4703, 4704, 4681, 0, 0, 0, 0
35781, 4681, 4704, 4705, 4682, 0, 0, 0, 0
35782, 4682, 4705, 462, 461, 0, 0, 0, 0
35783, 302, 303, 4706, 4683, 0, 0, 0, 0
35784, 4683, 4706, 4707, 4684, 0, 0, 0, 0
35785, 4684, 4707, 4708, 4685, 0, 0, 0, 0
35786, 4685, 4708, 4709, 4686, 0, 0, 0, 0
35787, 4686, 4709, 4710, 4687, 0, 0, 0, 0
35788, 4687, 4710, 4711, 4688, 0, 0, 0, 0
35789, 4688, 4711, 4712, 4689, 0, 0, 0, 0
35790, 4689, 4712, 4713, 4690, 0, 0, 0, 0
35791, 4690, 4713, 4714, 4691, 0, 0, 0, 0
35792, 4691, 4714, 4715, 4692, 0, 0, 0, 0
35793, 4692, 4715, 4716, 4693, 0, 0, 0, 0
35794, 4693, 4716, 4717, 4694, 0, 0, 0, 0
35795, 4694, 4717, 4718, 4695, 0, 0, 0, 0
35796, 4695, 4718, 4719, 4696, 0, 0, 0, 0
35797, 4696, 4719, 4720, 4697, 0, 0, 0, 0
35798, 4697, 4720, 4721, 4698, 0, 0, 0, 0
35799, 4698, 4721, 4722, 4699, 0, 0, 0, 0
35800, 4699, 4722, 4723, 4700, 0, 0, 0, 0
35801, 4700, 4723, 4724, 4701, 0, 0, 0, 0
35802, 4701, 4724, 4725, 4702, 0, 0, 0, 0
35803, 4702, 4725, 4726, 4703, 0, 0, 0, 0
35804, 4703, 4726, 4727, 4704, 0, 0, 0, 0
35805, 4704, 4727, 4728, 4705, 0, 0, 0, 0
35806, 4705, 4728, 463, 462, 0, 0, 0, 0
35807, 303, 304, 4729, 4706, 0, 0, 0, 0
35808, 4706, 4729, 4730, 4707, 0, 0, 0, 0
35809, 4707, 4730, 4731, 4708, 0, 0, 0, 0
35810, 4708, 4731, 4732, 4709, 0, 0, 0, 0
35811, 4709, 4732, 4733, 4710, 0, 0, 0, 0
35812, 4710, 4733, 4734, 4711, 0, 0, 0, 0
35813, 4711, 4734, 4735, 4712, 0, 0, 0, 0
35814, 4712, 4735, 4736, 4713, 0, 0, 0, 0
35815, 4713, 4736, 4737, 4714, 0, 0, 0, 0
35816, 4714, 4737, 4738, 4715, 0, 0, 0, 0
35817, 4715, 4738, 4739, 4716, 0, 0, 0, 0
35818, 4716, 4739, 4740, 4717, 0, 0, 0, 0
35819, 4717, 4740, 4741, 4718, 0, 0, 0, 0
35820, 4718, 4741, 4742, 4719, 0, 0, 0, 0
35821, 4719, 4742, 4743, 4720, 0, 0, 0, 0
35822, 4720, 4743, 4744, 4721, 0, 0, 0, 0
35823, 4721, 4744, 4745, 4722, 0, 0, 0, 0
35824, 4722, 4745, 4746, 4723, 0, 0, 0, 0
35825, 4723, 4746, 4747, 4724, 0, 0, 0, 0
35826, 4724, 4747, 4748, 4725, 0, 0, 0, 0
35827, 4725, 4748, 4749, 4726, 0, 0, 0, 0
35828, 4726, 4749, 4750, 4727, 0, 0, 0, 0
35829, 4727, 4750, 4751, 4728, 0, 0, 0, 0
35830, 4728, 4751, 464, 463, 0, 0, 0, 0
35831, 304, 305, 4752, 4729, 0, 0, 0, 0
35832, 4729, 4752, 4753, 4730, 0, 0, 0, 0
35833, 4730, 4753, 4754, 4731, 0, 0, 0, 0
35834, 4731, 4754, 4755, 4732, 0, 0, 0, 0
35835, 4732, 4755, 4756, 4733, 0, 0, 0, 0
35836, 4733, 4756, 4757, 4734, 0, 0, 0, 0
35837, 4734, 4757, 4758, 4735, 0, 0, 0, 0
35838, 4735, 4758, 4759, 4736, 0, 0, 0, 0
35839, 4736, 4759, 4760, 4737, 0, 0, 0, 0
35840, 4737, 4760, 4761, 4738, 0, 0, 0, 0
35841, 4738, 4761, 4762, 4739, 0, 0, 0, 0
35842, 4739, 4762, 4763, 4740, 0, 0, 0, 0
35843, 4740, 4763, 4764, 4741, 0, 0, 0, 0
35844, 4741, 4764, 4765, 4742, 0, 0, 0, 0
35845, 4742, 4765, 4766, 4743, 0, 0, 0, 0
35846, 4743, 4766, 4767, 4744, 0, 0, 0, 0
35847, 4744, 4767, 4768, 4745, 0, 0, 0, 0
35848, 4745, 4768, 4769, 4746, 0, 0, 0, 0
35849, 4746, 4769, 4770, 4747, 0, 0, 0, 0
35850, 4747, 4770, 4771, 4748, 0, 0, 0, 0
35851, 4748, 4771, 4772, 4749, 0, 0, 0, 0
35852, 4749, 4772, 4773, 4750, 0, 0, 0, 0
35853, 4750, 4773, 4774, 4751, 0, 0, 0, 0
35854, 4751, 4774, 465, 464, 0, 0, 0, 0
35855, 305, 306, 4775, 4752, 0, 0, 0, 0
35856, 4752, 4775, 4776, 4753, 0, 0, 0, 0
35857, 4753, 4776, 4777, 4754, 0, 0, 0, 0
35858, 4754, 4777, 4778, 4755, 0, 0, 0, 0
35859, 4755, 4778, 4779, 4756, 0, 0, 0, 0
35860, 4756, 4779, 4780, 4757, 0, 0, 0, 0
35861, 4757, 4780, 4781, 4758, 0, 0, 0, 0
35862, 4758, 4781, 4782, 4759, 0, 0, 0, 0
35863, 4759, 4782, 4783, 4760, 0, 0, 0, 0
35864, 4760, 4783, 4784, 4761, 0, 0, 0, 0
35865, 4761, 4784, 4785, 4762, 0, 0, 0, 0
35866, 4762, 4785, 4786, 4763, 0, 0, 0, 0
35867, 4763, 4786, 4787, 4764, 0, 0, 0, 0
35868, 4764, 4787, 4788, 4765, 0, 0, 0, 0
35869, 4765, 4788, 4789, 4766, 0, 0, 0, 0
35870, 4766, 4789, 4790, 4767, 0, 0, 0, 0
35871, 4767, 4790, 4791, 4768, 0, 0, 0, 0
35872, 4768, 4791, 4792, 4769, 0, 0, 0, 0
35873, 4769, 4792, 4793, 4770, 0, 0, 0, 0
35874, 4770, 4793, 4794, 4771, 0, 0, 0, 0
35875, 4771, 4794, 4795, 4772, 0, 0, 0, 0
35876, 4772, 4795, 4796, 4773, 0, 0, 0, 0
35877, 4773, 4796, 4797, 4774, 0, 0, 0, 0
35878, 4774, 4797, 466, 465, 0, 0, 0, 0
35879, 306, 307, 4798, 4775, 0, 0, 0, 0
35880, 4775, 4798, 4799, 4776, 0, 0, 0, 0
35881, 4776, 4799, 4800, 4777, 0, 0, 0, 0
35882, 4777, 4800, 4801, 4778, 0, 0, 0, 0
35883, 4778, 4801, 4802, 4779, 0, 0, 0, 0
35884, 4779, 4802, 4803, 4780, 0, 0, 0, 0
35885, 4780, 4803, 4804, 4781, 0, 0, 0, 0
35886, 4781, 4804, 4805, 4782, 0, 0, 0, 0
35887, 4782, 4805, 4806, 4783, 0, 0, 0, 0
35888, 4783, 4806, 4807, 4784, 0, 0, 0, 0
35889, 4784, 4807, 4808, 4785, 0, 0, 0, 0
35890, 4785, 4808, 4809, 4786, 0, 0, 0, 0
35891, 4786, 4809, 4810, 4787, 0, 0, 0, 0
35892, 4787, 4810, 4811, 4788, 0, 0, 0, 0
35893, 4788, 4811, 4812, 4789, 0, 0, 0, 0
35894, 4789, 4812, 4813, 4790, 0, 0, 0, 0
35895, 4790, 4813, 4814, 4791, 0, 0, 0, 0
35896, 4791, 4814, 4815, 4792, 0, 0, 0, 0
35897, 4792, 4815, 4816, 4793, 0, 0, 0, 0
35898, 4793, 4816, 4817, 4794, 0, 0, 0, 0
35899, 4794, 4817, 4818, 4795, 0, 0, 0, 0
35900, 4795, 4818, 4819, 4796, 0, 0, 0, 0
35901, 4796, 4819, 4820, 4797, 0, 0, 0, 0
35902, 4797, 4820, 467, 466, 0, 0, 0, 0
35903, 307, 308, 4821, 4798, 0, 0, 0, 0
35904, 4798, 4821, 4822, 4799, 0, 0, 0, 0
35905, 4799, 4822, 4823, 4800, 0, 0, 0, 0
35906, 4800, 4823, 4824, 4801, 0, 0, 0, 0
35907, 4801, 4824, 4825, 4802, 0, 0, 0, 0
35908, 4802, 4825, 4826, 4803, 0, 0, 0, 0
35909, 4803, 4826, 4827, 4804, 0, 0, 0, 0
35910, 4804, 4827, 4828, 4805, 0, 0, 0, 0
35911, 4805, 4828, 4829, 4806, 0, 0, 0, 0
35912, 4806, 4829, 4830, 4807, 0, 0, 0, 0
35913, 4807, 4830, 4831, 4808, 0, 0, 0, 0
35914, 4808, 4831, 4832, 4809, 0, 0, 0, 0
35915, 4809, 4832, 4833, 4810, 0, 0, 0, 0
35916, 4810, 4833, 4834, 4811, 0, 0, 0, 0
35917, 4811, 4834, 4835, 4812, 0, 0, 0, 0
35918, 4812, 4835, 4836, 4813, 0, 0, 0, 0
35919, 4813, 4836, 4837, 4814, 0, 0, 0, 0
35920, 4814, 4837, 4838, 4815, 0, 0, 0, 0
35921, 4815, 4838, 4839, 4816, 0, 0, 0, 0
35922, 4816, 4839, 4840, 4817, 0, 0, 0, 0
35923, 4817, 4840, 4841, 4818, 0, 0, 0, 0
35924, 4818, 4841, 4842, 4819, 0, 0, 0, 0
35925, 4819, 4842, 4843, 4820, 0, 0, 0, 0
35926, 4820, 4843, 468, 467, 0, 0, 0, 0
35927, 308, 309, 4844, 4821, 0, 0, 0, 0
35928, 4821, 4844, 4845, 4822, 0, 0, 0, 0
35929, 4822, 4845, 4846, 4823, 0, 0, 0, 0
35930, 4823, 4846, 4847, 4824, 0, 0, 0, 0
35931, 4824, 4847, 4848, 4825, 0, 0, 0, 0
35932, 4825, 4848, 4849, 4826, 0, 0, 0, 0
35933, 4826, 4849, 4850, 4827, 0, 0, 0, 0
35934, 4827, 4850, 4851, 4828, 0, 0, 0, 0
35935, 4828, 4851, 4852, 4829, 0, 0, 0, 0
35936, 4829, 4852, 4853, 4830, 0, 0, 0, 0
35937, 4830, 4853, 4854, 4831, 0, 0, 0, 0
35938, 4831, 4854, 4855, 4832, 0, 0, 0, 0
35939, 4832, 4855, 4856, 4833, 0, 0, 0, 0
35940, 4833, 4856, 4857, 4834, 0, 0, 0, 0
35941, 4834, 4857, 4858, 4835, 0, 0, 0, 0
35942, 4835, 4858, 4859, 4836, 0, 0, 0, 0
35943, 4836, 4859, 4860, 4837, 0, 0, 0, 0
35944, 4837, 4860, 4861, 4838, 0, 0, 0, 0
35945, 4838, 4861, 4862, 4839, 0, 0, 0, 0
35946, 4839, 4862, 4863, 4840, 0, 0, 0, 0
35947, 4840, 4863, 4864, 4841, 0, 0, 0, 0
35948, 4841, 4864, 4865, 4842, 0, 0, 0, 0
35949, 4842, 4865, 4866, 4843, 0, 0, 0, 0
35950, 4843, 4866, 469, 468, 0, 0, 0, 0
35951, 309, 12, 413, 4844, 0, 0, 0, 0
35952, 4844, 413, 414, 4845, 0, 0, 0, 0
35953, 4845, 414, 415, 4846, 0, 0, 0, 0
35954, 4846, 415, 416, 4847, 0, 0, 0, 0
35955, 4847, 416, 417, 4848, 0, 0, 0, 0
35956, 4848, 417, 418, 4849, 0, 0, 0, 0
35957, 4849, 418, 419, 4850, 0, 0, 0, 0
35958, 4850, 419, 420, 4851, 0, 0, 0, 0
35959, 4851, 420, 421, 4852, 0, 0, 0, 0
35960, 4852, 421, 422, 4853, 0, 0, 0, 0
35961, 4853, 422, 423, 4854, 0, 0, 0, 0
35962, 4854, 423, 424, 4855, 0, 0, 0, 0
35963, 4855, 424, 425, 4856, 0, 0, 0, 0
35964, 4856, 425, 426, 4857, 0, 0, 0, 0
35965, 4857, 426, 427, 4858, 0, 0, 0, 0
35966, 4858, 427, 428, 4859, 0, 0, 0, 0
35967, 4859, 428, 429, 4860, 0, 0, 0, 0
35968, 4860, 429, 430, 4861, 0, 0, 0, 0
35969, 4861, 430, 431, 4862, 0, 0, 0, 0
35970, 4862, 431, 432, 4863, 0, 0, 0, 0
35971, 4863, 432, 433, 4864, 0, 0, 0, 0
35972, 4864, 433, 434, 4865, 0, 0, 0, 0
35973, 4865, 434, 435, 4866, 0, 0, 0, 0
35974, 4866, 435, 16, 469, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface16
1070, 14, 459, 4867, 356, 0, 0, 0, 0
1071, 459, 460, 4868, 4867, 0, 0, 0, 0
1072, 460, 461, 4869, 4868, 0, 0, 0, 0
1073, 461, 462, 4870, 4869, 0, 0, 0, 0
1074, 462, 463, 4871, 4870, 0, 0, 0, 0
1075, 463, 464, 4872, 4871, 0, 0, 0, 0
1076, 464, 465, 4873, 4872, 0, 0, 0, 0
1077, 465, 466, 4874, 4873, 0, 0, 0, 0
1078, 466, 467, 4875, 4874, 0, 0, 0, 0
1079, 467, 468, 4876, 4875, 0, 0, 0, 0
1080, 468, 469, 4877, 4876, 0, 0, 0, 0
1081, 469, 16, 436, 4877, 0, 0, 0, 0
1082, 356, 4867, 4878, 357, 0, 0, 0, 0
1083, 4867, 4868, 4879, 4878, 0, 0, 0, 0
1084, 4868, 4869, 4880, 4879, 0, 0, 0, 0
1085, 4869, 4870, 4881, 4880, 0, 0, 0, 0
1086, 4870, 4871, 4882, 4881, 0, 0, 0, 0
1087, 4871, 4872, 4883, 4882, 0, 0, 0, 0
1088, 4872, 4873, 4884, 4883, 0, 0, 0, 0
1089, 4873, 4874, 4885, 4884, 0, 0, 0, 0
1090, 4874, 4875, 4886, 4885, 0, 0, 0, 0
1091, 4875, 4876, 4887, 4886, 0, 0, 0, 0
1092, 4876, 4877, 4888, 4887, 0, 0, 0, 0
1093, 4877, 436, 437, 4888, 0, 0, 0, 0
1094, 357, 4878, 4889, 358, 0, 0, 0, 0
1095, 4878, 4879, 4890, 4889, 0, 0, 0, 0
1096, 4879, 4880, 4891, 4890, 0, 0, 0, 0
1097, 4880, 4881, 4892, 4891, 0, 0, 0, 0
1098, 4881, 4882, 4893, 4892, 0, 0, 0, 0
1099, 4882, 4883, 4894, 4893, 0, 0, 0, 0
1100, 4883, 4884, 4895, 4894, 0, 0, 0, 0
1101, 4884, 4885, 4896, 4895, 0, 0, 0, 0
1102, 4885, 4886, 4897, 4896, 0, 0, 0, 0
1103, 4886, 4887, 4898, 4897, 0, 0, 0, 0
1104, 4887, 4888, 4899, 4898, 0, 0, 0, 0
1105, 4888, 437, 438, 4899, 0, 0, 0, 0
1106, 358, 4889, 4900, 359, 0, 0, 0, 0
1107, 4889, 4890, 4901, 4900, 0, 0, 0, 0
1108, 4890, 4891, 4902, 4901, 0, 0, 0, 0
1109, 4891, 4892, 4903, 4902, 0, 0, 0, 0
1110, 4892, 4893, 4904, 4903, 0, 0, 0, 0
1111, 4893, 4894, 4905, 4904, 0, 0, 0, 0
1112, 4894, 4895, 4906, 4905, 0, 0, 0, 0
1113, 4895, 4896, 4907, 4906, 0, 0, 0, 0
1114, 4896, 4897, 4908, 4907, 0, 0, 0, 0
1115, 4897, 4898, 4909, 4908, 0, 0, 0, 0
1116, 4898, 4899, 4910, 4909, 0, 0, 0, 0
1117, 4899, 438, 439, 4910, 0, 0, 0, 0
1118, 359, 4900, 4911, 360, 0, 0, 0, 0
1119, 4900, 4901, 4912, 4911, 0, 0, 0, 0
1120, 4901, 4902, 4913, 4912, 0, 0, 0, 0
1121, 4902, 4903, 4914, 4913, 0, 0, 0, 0
1122, 4903, 4904, 4915, 4914, 0, 0, 0, 0
1123, 4904, 4905, 4916, 4915, 0, 0, 0, 0
1124, 4905, 4906, 4917, 4916, 0, 0, 0, 0
1125, 4906, 4907, 4918, 4917, 0, 0, 0, 0
1126, 4907, 4908, 4919, 4918, 0, 0, 0, 0
1127, 4908, 4909, 4920, 4919, 0, 0, 0, 0
1128, 4909, 4910, 4921, 4920, 0, 0, 0, 0
1129, 4910, 439, 440, 4921, 0, 0, 0, 0
1130, 360, 4911, 4922, 361, 0, 0, 0, 0
1131, 4911, 4912, 4923, 4922, 0, 0, 0, 0
1132, 4912, 4913, 4924, 4923, 0, 0, 0, 0
1133, 4913, 4914, 4925, 4924, 0, 0, 0, 0
1134, 4914, 4915, 4926, 4925, 0, 0, 0, 0
1135, 4915, 4916, 4927, 4926, 0, 0, 0, 0
1136, 4916, 4917, 4928, 4927, 0, 0, 0, 0
1137, 4917, 4918, 4929, 4928, 0, 0, 0, 0
1138, 4918, 4919, 4930, 4929, 0, 0, 0, 0
1139, 4919, 4920, 4931, 4930, 0, 0, 0, 0
1140, 4920, 4921, 4932, 4931, 0, 0, 0, 0
1141, 4921, 440, 441, 4932, 0, 0, 0, 0
1142, 361, 4922, 4933, 362, 0, 0, 0, 0
1143, 4922, 4923, 4934, 4933, 0, 0, 0, 0
1144, 4923, 4924, 4935, 4934, 0, 0, 0, 0
1145, 4924, 4925, 4936, 4935, 0, 0, 0, 0
1146, 4925, 4926, 4937, 4936, 0, 0, 0, 0
1147, 4926, 4927, 4938, 4937, 0, 0, 0, 0
1148, 4927, 4928, 4939, 4938, 0, 0, 0, 0
1149, 4928, 4929, 4940, 4939, 0, 0, 0, 0
1150, 4929, 4930, 4941, 4940, 0, 0, 0, 0
1151, 4930, 4931, 4942, 4941, 0, 0, 0, 0
1152, 4931, 4932, 4943, 4942, 0, 0, 0, 0
1153, 4932, 441, 442, 4943, 0, 0, 0, 0
1154, 362, 4933, 4944, 363, 0, 0, 0, 0
1155, 4933, 4934, 4945, 4944, 0, 0, 0, 0
1156, 4934, 4935, 4946, 4945, 0, 0, 0, 0
1157, 4935, 4936, 4947, 4946, 0, 0, 0, 0
1158, 4936, 4937, 4948, 4947, 0, 0, 0, 0
1159, 4937, 4938, 4949, 4948, 0, 0, 0, 0
1160, 4938, 4939, 4950, 4949, 0, 0, 0, 0
1161, 4939, 4940, 4951, 4950, 0, 0, 0, 0
1162, 4940, 4941, 4952, 4951, 0, 0, 0, 0
1163, 4941, 4942, 4953, 4952, 0, 0, 0, 0
1164, 4942, 4943, 4954, 4953, 0, 0, 0, 0
1165, 4943, 442, 443, 4954, 0, 0, 0, 0
1166, 363, 4944, 4955, 364, 0, 0, 0, 0
1167, 4944, 4945, 4956, 4955, 0, 0, 0, 0
1168, 4945, 4946, 4957, 4956, 0, 0, 0, 0
1169, 4946, 4947, 4958, 4957, 0, 0, 0, 0
1170, 4947, 4948, 4959, 4958, 0, 0, 0, 0
1171, 4948, 4949, 4960, 4959, 0, 0, 0, 0
1172, 4949, 4950, 4961, 4960, 0, 0, 0, 0
1173, 4950, 4951, 4962, 4961, 0, 0, 0, 0
1174, 4951, 4952, 4963, 4962, 0, 0, 0, 0
1175, 4952, 4953, 4964, 4963, 0, 0, 0, 0
1176, 4953, 4954, 4965, 4964, 0, 0, 0, 0
1177, 4954, 443, 444, 4965, 0, 0, 0, 0
1178, 364, 4955, 4966, 365, 0, 0, 0, 0
1179, 4955, 4956, 4967, 4966, 0, 0, 0, 0
1180, 4956, 4957, 4968, 4967, 0, 0, 0, 0
1181, 4957, 4958, 4969, 4968, 0, 0, 0, 0
1182, 4958, 4959, 4970, 4969, 0, 0, 0, 0
1183, 4959, 4960, 4971, 4970, 0, 0, 0, 0
1184, 4960, 4961, 4972, 4971, 0, 0, 0, 0
1185, 4961, 4962, 4973, 4972, 0, 0, 0, 0
1186, 4962, 4963, 4974, 4973, 0, 0, 0, 0
1187, 4963, 4964, 4975, 4974, 0, 0, 0, 0
1188, 4964, 4965, 4976, 4975, 0, 0, 0, 0
1189, 4965, 444, 445, 4976, 0, 0, 0, 0
1190, 365, 4966, 4977, 366, 0, 0, 0, 0
1191, 4966, 4967, 4978, 4977, 0, 0, 0, 0
1192, 4967, 4968, 4979, 4978, 0, 0, 0, 0
1193, 4968, 4969, 4980, 4979, 0, 0, 0, 0
1194, 4969, 4970, 4981, 4980, 0, 0, 0, 0
1195, 4970, 4971, 4982, 4981, 0, 0, 0, 0
1196, 4971, 4972, 4983, 4982, 0, 0, 0, 0
1197, 4972, 4973, 4984, 4983, 0, 0, 0, 0
1198, 4973, 4974, 4985, 4984, 0, 0, 0, 0
1199, 4974, 4975, 4986, 4985, 0, 0, 0, 0
1200, 4975, 4976, 4987, 4986, 0, 0, 0, 0
1201, 4976, 445, 446, 4987, 0, 0, 0, 0
1202, 366, 4977, 4988, 367, 0, 0, 0, 0
1203, 4977, 4978, 4989, 4988, 0, 0, 0, 0
1204, 4978, 4979, 4990, 4989, 0, 0, 0, 0
1205, 4979, 4980, 4991, 4990, 0, 0, 0, 0
1206, 4980, 4981, 4992, 4991, 0, 0, 0, 0
1207, 4981, 4982, 4993, 4992, 0, 0, 0, 0
1208, 4982, 4983, 4994, 4993, 0, 0, 0, 0
1209, 4983, 4984, 4995, 4994, 0, 0, 0, 0
1210, 4984, 4985, 4996, 4995, 0, 0, 0, 0
1211, 4985, 4986, 4997, 4996, 0, 0, 0, 0
1212, 4986, 4987, 4998, 4997, 0, 0, 0, 0
1213, 4987, 446, 447, 4998, 0, 0, 0, 0
1214, 367, 4988, 4999, 368, 0, 0, 0, 0
1215, 4988, 4989, 5000, 4999, 0, 0, 0, 0
1216, 4989, 4990, 5001, 5000, 0, 0, 0, 0
1217, 4990, 4991, 5002, 5001, 0, 0, 0, 0
1218, 4991, 4992, 5003, 5002, 0, 0, 0, 0
1219, 4992, 4993, 5004, 5003, 0, 0, 0, 0
1220, 4993, 4994, 5005, 5004, 0, 0, 0, 0
1221, 4994, 4995, 5006, 5005, 0, 0, 0, 0
1222, 4995, 4996, 5007, 5006, 0, 0, 0, 0
1223, 4996, 4997, 5008, 5007, 0, 0, 0, 0
1224, 4997, 4998, 5009, 5008, 0, 0, 0, 0
1225, 4998, 447, 448, 5009, 0, 0, 0, 0
1226, 368, 4999, 5010, 369, 0, 0, 0, 0
1227, 4999, 5000, 5011, 5010, 0, 0, 0, 0
1228, 5000, 5001, 5012, 5011, 0, 0, 0, 0
1229, 5001, 5002, 5013, 5012, 0, 0, 0, 0
1230, 5002, 5003, 5014, 5013, 0, 0, 0, 0
1231, 5003, 5004, 5015, 5014, 0, 0, 0, 0
1232, 5004, 5005, 5016, 5015, 0, 0, 0, 0
1233, 5005, 5006, 5017, 5016, 0, 0, 0, 0
1234, 5006, 5007, 5018, 5017, 0, 0, 0, 0
1235, 5007, 5008, 5019, 5018, 0, 0, 0, 0
1236, 5008, 5009, 5020, 5019, 0, 0, 0, 0
1237, 5009, 448, 449, 5020, 0, 0, 0, 0
1238, 369, 5010, 5021, 370, 0, 0, 0, 0
1239, 5010, 5011, 5022, 5021, 0, 0, 0, 0
1240, 5011, 5012, 5023, 5022, 0, 0, 0, 0
1241, 5012, 5013, 5024, 5023, 0, 0, 0, 0
1242, 5013, 5014, 5025, 5024, 0, 0, 0, 0
1243, 5014, 5015, 5026, 5025, 0, 0, 0, 0
1244, 5015, 5016, 5027, 5026, 0, 0, 0, 0
1245, 5016, 5017, 5028, 5027, 0, 0, 0, 0
1246, 5017, 5018, 5029, 5028, 0, 0, 0, 0
1247, 5018, 5019, 5030, 5029, 0, 0, 0, 0
1248, 5019, 5020, 5031, 5030, 0, 0, 0, 0
1249, 5020, 449, 450, 5031, 0, 0, 0, 0
1250, 370, 5021, 5032, 371, 0, 0, 0, 0
1251, 5021, 5022, 5033, 5032, 0, 0, 0, 0
1252, 5022, 5023, 5034, 5033, 0, 0, 0, 0
1253, 5023, 5024, 5035, 5034, 0, 0, 0, 0
1254, 5024, 5025, 5036, 5035, 0, 0, 0, 0
1255, 5025, 5026, 5037, 5036, 0, 0, 0, 0
1256, 5026, 5027, 5038, 5037, 0, 0, 0, 0
1257, 5027, 5028, 5039, 5038, 0, 0, 0, 0
1258, 5028, 5029, 5040, 5039, 0, 0, 0, 0
1259, 5029, 5030, 5041, 5040, 0, 0, 0, 0
1260, 5030, 5031, 5042, 5041, 0, 0, 0, 0
1261, 5031, 450, 451, 5042, 0, 0, 0, 0
1262, 371, 5032, 5043, 372, 0, 0, 0, 0
1263, 5032, 5033, 5044, 5043, 0, 0, 0, 0
1264, 5033, 5034, 5045, 5044, 0, 0, 0, 0
1265, 5034, 5035, 5046, 5045, 0, 0, 0, 0
1266, 5035, 5036, 5047, 5046, 0, 0, 0, 0
1267, 5036, 5037, 5048, 5047, 0, 0, 0, 0
1268, 5037, 5038, 5049, 5048, 0, 0, 0, 0
1269, 5038, 5039, 5050, 5049, 0, 0, 0, 0
1270, 5039, 5040, 5051, 5050, 0, 0, 0, 0
1271, 5040, 5041, 5052, 5051, 0, 0, 0, 0
1272, 5041, 5042, 5053, 5052, 0, 0, 0, 0
1273, 5042, 451, 452, 5053, 0, 0, 0, 0
1274, 372, 5043, 5054, 373, 0, 0, 0, 0
1275, 5043, 5044, 5055, 5054, 0, 0, 0, 0
1276, 5044, 5045, 5056, 5055, 0, 0, 0, 0
1277, 5045, 5046, 5057, 5056, 0, 0, 0, 0
1278, 5046, 5047, 5058, 5057, 0, 0, 0, 0
1279, 5047, 5048, 5059, 5058, 0, 0, 0, 0
1280, 5048, 5049, 5060, 5059, 0, 0, 0, 0
1281, 5049, 5050, 5061, 5060, 0, 0, 0, 0
1282, 5050, 5051, 5062, 5061, 0, 0, 0, 0
1283, 5051, 5052, 5063, 5062, 0, 0, 0, 0
1284, 5052, 5053, 5064, 5063, 0, 0, 0, 0
1285, 5053, 452, 453, 5064, 0, 0, 0, 0
1286, 373, 5054, 5065, 374, 0, 0, 0, 0
1287, 5054, 5055, 5066, 5065, 0, 0, 0, 0
1288, 5055, 5056, 5067, 5066, 0, 0, 0, 0
1289, 5056, 5057, 5068, 5067, 0, 0, 0, 0
1290, 5057, 5058, 5069, 5068, 0, 0, 0, 0
1291, 5058, 5059, 5070, 5069, 0, 0, 0, 0
1292, 5059, 5060, 5071, 5070, 0, 0, 0, 0
1293, 5060, 5061, 5072, 5071, 0, 0, 0, 0
1294, 5061, 5062, 5073, 5072, 0, 0, 0, 0
1295, 5062, 5063, 5074, 5073, 0, 0, 0, 0
1296, 5063, 5064, 5075, 5074, 0, 0, 0, 0
1297, 5064, 453, 454, 5075, 0, 0, 0, 0
1298, 374, 5065, 5076, 375, 0, 0, 0, 0
1299, 5065, 5066, 5077, 5076, 0, 0, 0, 0
1300, 5066, 5067, 5078, 5077, 0, 0, 0, 0
1301, 5067, 5068, 5079, 5078, 0, 0, 0, 0
1302, 5068, 5069, 5080, 5079, 0, 0, 0, 0
1303, 5069, 5070, 5081, 5080, 0, 0, 0, 0
1304, 5070, 5071, 5082, 5081, 0, 0, 0, 0
1305, 5071, 5072, 5083, 5082, 0, 0, 0, 0
1306, 5072, 5073, 5084, 5083, 0, 0, 0, 0
1307, 5073, 5074, 5085, 5084, 0, 0, 0, 0
1308, 5074, 5075, 5086, 5085, 0, 0, 0, 0
1309, 5075, 454, 455, 5086, 0, 0, 0, 0
1310, 375, 5076, 5087, 376, 0, 0, 0, 0
1311, 5076, 5077, 5088, 5087, 0, 0, 0, 0
1312, 5077, 5078, 5089, 5088, 0, 0, 0, 0
1313, 5078, 5079, 5090, 5089, 0, 0, 0, 0
1314, 5079, 5080, 5091, 5090, 0, 0, 0, 0
1315, 5080, 5081, 5092, 5091, 0, 0, 0, 0
1316, 5081, 5082, 5093, 5092, 0, 0, 0, 0
1317, 5082, 5083, 5094, 5093, 0, 0, 0, 0
1318, 5083, 5084, 5095, 5094, 0, 0, 0, 0
1319, 5084, 5085, 5096, 5095, 0, 0, 0, 0
1320, 5085, 5086, 5097, 5096, 0, 0, 0, 0
1321, 5086, 455, 456, 5097, 0, 0, 0, 0
1322, 376, 5087, 5098, 377, 0, 0, 0, 0
1323, 5087, 5088, 5099, 5098, 0, 0, 0, 0
1324, 5088, 5089, 5100, 5099, 0, 0, 0, 0
1325, 5089, 5090, 5101, 5100, 0, 0, 0, 0
1326, 5090, 5091, 5102, 5101, 0, 0, 0, 0
1327, 5091, 5092, 5103, 5102, 0, 0, 0, 0
1328, 5092, 5093, 5104, 5103, 0, 0, 0, 0
1329, 5093, 5094, 5105, 5104, 0, 0, 0, 0
1330, 5094, 5095, 5106, 5105, 0, 0, 0, 0
1331, 5095, 5096, 5107, 5106, 0, 0, 0, 0
1332, 5096, 5097, 5108, 5107, 0, 0, 0, 0
1333, 5097, 456, 457, 5108, 0, 0, 0, 0
1334, 377, 5098, 5109, 378, 0, 0, 0, 0
1335, 5098, 5099, 5110, 5109, 0, 0, 0, 0
1336, 5099, 5100, 5111, 5110, 0, 0, 0, 0
1337, 5100, 5101, 5112, 5111, 0, 0, 0, 0
1338, 5101, 5102, 5113, 5112, 0, 0, 0, 0
1339, 5102, 5103, 5114, 5113, 0, 0, 0, 0
1340, 5103, 5104, 5115, 5114, 0, 0, 0, 0
1341, 5104, 5105, 5116, 5115, 0, 0, 0, 0
1342, 5105, 5106, 5117, 5116, 0, 0, 0, 0
1343, 5106, 5107, 5118, 5117, 0, 0, 0, 0
1344, 5107, 5108, 5119, 5118, 0, 0, 0, 0
1345, 5108, 457, 458, 5119, 0, 0, 0, 0
1346, 378, 5109, 402, 13, 0, 0, 0, 0
1347, 5109, 5110, 403, 402, 0, 0, 0, 0
1348, 5110, 5111, 404, 403, 0, 0, 0, 0
1349, 5111, 5112, 405, 404, 0, 0, 0, 0
1350, 5112, 5113, 406, 405, 0, 0, 0, 0
1351, 5113, 5114, 407, 406, 0, 0, 0, 0
1352, 5114, 5115, 408, 407, 0, 0, 0, 0
1353, 5115, 5116, 409, 408, 0, 0, 0, 0
1354, 5116, 5117, 410, 409, 0, 0, 0, 0
1355, 5117, 5118, 411, 410, 0, 0, 0, 0
1356, 5118, 5119, 412, 411, 0, 0, 0, 0
1357, 5119, 458, 15, 412, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface17
35975, 14, 18, 470, 356, 0, 0, 0, 0
35976, 356, 470, 471, 357, 0, 0, 0, 0
35977, 357, 471, 472, 358, 0, 0, 0, 0
35978, 358, 472, 473, 359, 0, 0, 0, 0
35979, 359, 473, 474, 360, 0, 0, 0, 0
35980, 360, 474, 475, 361, 0, 0, 0, 0
35981, 361, 475, 476, 362, 0, 0, 0, 0
35982, 362, 476, 477, 363, 0, 0, 0, 0
35983, 363, 477, 478, 364, 0, 0, 0, 0
35984, 364, 478, 479, 365, 0, 0, 0, 0
35985, 365, 479, 480, 366, 0, 0, 0, 0
35986, 366, 480, 481, 367, 0, 0, 0, 0
35987, 367, 481, 482, 368, 0, 0, 0, 0
35988, 368, 482, 483, 369, 0, 0, 0, 0
35989, 369, 483, 484, 370, 0, 0, 0, 0
35990, 370, 484, 485, 371, 0, 0, 0, 0
35991, 371, 485, 486, 372, 0, 0, 0, 0
35992, 372, 486, 487, 373, 0, 0, 0, 0
35993, 373, 487, 488, 374, 0, 0, 0, 0
35994, 374, 488, 489, 375, 0, 0, 0, 0
35995, 375, 489, 490, 376, 0, 0, 0, 0
35996, 376, 490, 491, 377, 0, 0, 0, 0
35997, 377, 491, 492, 378, 0, 0, 0, 0
35998, 378, 492, 17, 13, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface18
35999, 13, 17, 493, 402, 0, 0, 0, 0
36000, 402, 493, 494, 403, 0, 0, 0, 0
36001, 403, 494, 495, 404, 0, 0, 0, 0
36002, 404, 495, 496, 405, 0, 0, 0, 0
36003, 405, 496, 497, 406, 0, 0, 0, 0
36004, 406, 497, 498, 407, 0, 0, 0, 0
36005, 407, 498, 499, 408, 0, 0, 0, 0
36006, 408, 499, 500, 409, 0, 0, 0, 0
36007, 409, 500, 501, 410, 0, 0, 0, 0
36008, 410, 501, 502, 411, 0, 0, 0, 0
36009, 411, 502, 503, 412, 0, 0, 0, 0
36010, 412, 503, 19, 15, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface19
1358, 16, 436, 504, 20, 0, 0, 0, 0
1359, 436, 437, 505, 504, 0, 0, 0, 0
1360, 437, 438, 506, 505, 0, 0, 0, 0
1361, 438, 439, 507, 506, 0, 0, 0, 0
1362, 439, 440, 508, 507, 0, 0, 0, 0
1363, 440, 441, 509, 508, 0, 0, 0, 0
1364, 441, 442, 510, 509, 0, 0, 0, 0
1365, 442, 443, 511, 510, 0, 0, 0, 0
1366, 443, 444, 512, 511, 0, 0, 0, 0
1367, 444, 445, 513, 512, 0, 0, 0, 0
1368, 445, 446, 514, 513, 0, 0, 0, 0
1369, 446, 447, 515, 514, 0, 0, 0, 0
1370, 447, 448, 516, 515, 0, 0, 0, 0
1371, 448, 449, 517, 516, 0, 0, 0, 0
1372, 449, 450, 518, 517, 0, 0, 0, 0
1373, 450, 451, 519, 518, 0, 0, 0, 0
1374, 451, 452, 520, 519, 0, 0, 0, 0
1375, 452, 453, 521, 520, 0, 0, 0, 0
1376, 453, 454, 522, 521, 0, 0, 0, 0
1377, 454, 455, 523, 522, 0, 0, 0, 0
1378, 455, 456, 524, 523, 0, 0, 0, 0
1379, 456, 457, 525, 524, 0, 0, 0, 0
1380, 457, 458, 526, 525, 0, 0, 0, 0
1381, 458, 15, 19, 526, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface20
36011, 14, 459, 527, 18, 0, 0, 0, 0
36012, 459, 460, 528, 527, 0, 0, 0, 0
36013, 460, 461, 529, 528, 0, 0, 0, 0
36014, 461, 462, 530, 529, 0, 0, 0, 0
36015, 462, 463, 531, 530, 0, 0, 0, 0
36016, 463, 464, 532, 531, 0, 0, 0, 0
36017, 464, 465, 533, 532, 0, 0, 0, 0
36018, 465, 466, 534, 533, 0, 0, 0, 0
36019, 466, 467, 535, 534, 0, 0, 0, 0
36020, 467, 468, 536, 535, 0, 0, 0, 0
36021, 468, 469, 537, 536, 0, 0, 0, 0
36022, 469, 16, 20, 537, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface21
36023, 18, 527, 5120, 470, 0, 0, 0, 0
36024, 527, 528, 5121, 5120, 0, 0, 0, 0
36025, 528, 529, 5122, 5121, 0, 0, 0, 0
36026, 529, 530, 5123, 5122, 0, 0, 0, 0
36027, 530, 531, 5124, 5123, 0, 0, 0, 0
36028, 531, 532, 5125, 5124, 0, 0, 0, 0
36029, 532, 533, 5126, 5125, 0, 0, 0, 0
36030, 533, 534, 5127, 5126, 0, 0, 0, 0
36031, 534, 535, 5128, 5127, 0, 0, 0, 0
36032, 535, 536, 5129, 5128, 0, 0, 0, 0
36033, 536, 537, 5130, 5129, 0, 0, 0, 0
36034, 537, 20, 504, 5130, 0, 0, 0, 0
36035, 470, 5120, 5131, 471, 0, 0, 0, 0
36036, 5120, 5121, 5132, 5131, 0, 0, 0, 0
36037, 5121, 5122, 5133, 5132, 0, 0, 0, 0
36038, 5122, 5123, 5134, 5133, 0, 0, 0, 0
36039, 5123, 5124, 5135, 5134, 0, 0, 0, 0
36040, 5124, 5125, 5136, 5135, 0, 0, 0, 0
36041, 5125, 5126, 5137, 5136, 0, 0, 0, 0
36042, 5126, 5127, 5138, 5137, 0, 0, 0, 0
36043, 5127, 5128, 5139, 5138, 0, 0, 0, 0
36044, 5128, 5129, 5140, 5139, 0, 0, 0, 0
36045, 5129, 5130, 5141, 5140, 0, 0, 0, 0
36046, 5130, 504, 505, 5141, 0, 0, 0, 0
36047, 471, 5131, 5142, 472, 0, 0, 0, 0
36048, 5131, 5132, 5143, 5142, 0, 0, 0, 0
36049, 5132, 5133, 5144, 5143, 0, 0, 0, 0
36050, 5133, 5134, 5145, 5144, 0, 0, 0, 0
36051, 5134, 5135, 5146, 5145, 0, 0, 0, 0
36052, 5135, 5136, 5147, 5146, 0, 0, 0, 0
36053, 5136, 5137, 5148, 5147, 0, 0, 0, 0
36054, 5137, 5138, 5149, 5148, 0, 0, 0, 0
36055, 5138, 5139, 5150, 5149, 0, 0, 0, 0
36056, 5139, 5140, 5151, 5150, 0, 0, 0, 0
36057, 5140, 5141, 5152, 5151, 0, 0, 0, 0
36058, 5141, 505, 506, 5152, 0, 0, 0, 0
36059, 472, 5142, 5153, 473, 0, 0, 0, 0
36060, 5142, 5143, 5154, 5153, 0, 0, 0, 0
36061, 5143, 5144, 5155, 5154, 0, 0, 0, 0
36062, 5144, 5145, 5156, 5155, 0, 0, 0, 0
36063, 5145, 5146, 5157, 5156, 0, 0, 0, 0
36064, 5146, 5147, 5158, 5157, 0, 0, 0, 0
36065, 5147, 5148, 5159, 5158, 0, 0, 0, 0
36066, 5148, 5149, 5160, 5159, 0, 0, 0, 0
36067, 5149, 5150, 5161, 5160, 0, 0, 0, 0
36068, 5150, 5151, 5162, 5161, 0, 0, 0, 0
36069, 5151, 5152, 5163, 5162, 0, 0, 0, 0
36070, 5152, 506, 507, 5163, 0, 0, 0, 0
36071, 473, 5153, 5164, 474, 0, 0, 0, 0
36072, 5153, 5154, 5165, 5164, 0, 0, 0, 0
36073, 5154, 5155, 5166, 5165, 0, 0, 0, 0
36074, 5155, 5156, 5167, 5166, 0, 0, 0, 0
36075, 5156, 5157, 5168, 5167, 0, 0, 0, 0
36076, 5157, 5158, 5169, 5168, 0, 0, 0, 0
36077, 5158, 5159, 5170, 5169, 0, 0, 0, 0
36078, 5159, 5160, 5171, 5170, 0, 0, 0, 0
36079, 5160, 5161, 5172, 5171, 0, 0, 0, 0
36080, 5161, 5162, 5173, 5172, 0, 0, 0, 0
36081, 5162, 5163, 5174, 5173, 0, 0, 0, 0
36082, 5163, 507, 508, 5174, 0, 0, 0, 0
36083, 474, 5164, 5175, 475, 0, 0, 0, 0
36084, 5164, 5165, 5176, 5175, 0, 0, 0, 0
36085, 5165, 5166, 5177, 5176, 0, 0, 0, 0
36086, 5166, 5167, 5178, 5177, 0, 0, 0, 0
36087, 5167, 5168, 5179, 5178, 0, 0, 0, 0
36088, 5168, 5169, 5180, 5179, 0, 0, 0, 0
36089, 5169, 5170, 5181, 5180, 0, 0, 0, 0
36090, 5170, 5171, 5182, 5181, 0, 0, 0, 0
36091, 5171, 5172, 5183, 5182, 0, 0, 0, 0
36092, 5172, 5173, 5184, 5183, 0, 0, 0, 0
36093, 5173, 5174, 5185, 5184, 0, 0, 0, 0
36094, 5174, 508, 509, 5185, 0, 0, 0, 0
36095, 475, 5175, 5186, 476, 0, 0, 0, 0
36096, 5175, 5176, 5187, 5186, 0, 0, 0, 0
36097, 5176, 5177, 5188, 5187, 0, 0, 0, 0
36098, 5177, 5178, 5189, 5188, 0, 0, 0, 0
36099, 5178, 5179, 5190, 5189, 0, 0, 0, 0
36100, 5179, 5180, 5191, 5190, 0, 0, 0, 0
36101, 5180, 5181, 5192, 5191, 0, 0, 0, 0
36102, 5181, 5182, 5193, 5192, 0, 0, 0, 0
36103, 5182, 5183, 5194, 5193, 0, 0, 0, 0
36104, 5183, 5184, 5195, 5194, 0, 0, 0, 0
36105, 5184, 5185, 5196, 5195, 0, 0, 0, 0
36106, 5185, 509, 510, 5196, 0, 0, 0, 0
36107, 476, 5186, 5197, 477, 0, 0, 0, 0
36108, 5186, 5187, 5198, 5197, 0, 0, 0, 0
36109, 5187, 5188, 5199, 5198, 0, 0, 0, 0
36110, 5188, 5189, 5200, 5199, 0, 0, 0, 0
36111, 5189, 5190, 5201, 5200, 0, 0, 0, 0
36112, 5190, 5191, 5202, 5201, 0, 0, 0, 0
36113, 5191, 5192, 5203, 5202, 0, 0, 0, 0
36114, 5192, 5193, 5204, 5203, 0, 0, 0, 0
36115, 5193, 5194, 5205, 5204, 0, 0, 0, 0
36116, 5194, 5195, 5206, 5205, 0, 0, 0, 0
36117, 5195, 5196, 5207, 5206, 0, 0, 0, 0
36118, 5196, 510, 511, 5207, 0, 0, 0, 0
36119, 477, 5197, 5208, 478, 0, 0, 0, 0
36120, 5197, 5198, 5209, 5208, 0, 0, 0, 0
36121, 5198, 5199, 5210, 5209, 0, 0, 0, 0
36122, 5199, 5200, 5211, 5210, 0, 0, 0, 0
36123, 5200, 5201, 5212, 5211, 0, 0, 0, 0
36124, 5201, 5202, 5213, 5212, 0, 0, 0, 0
36125, 5202, 5203, 5214, 5213, 0, 0, 0, 0
36126, 5203, 5204, 5215, 5214, 0, 0, 0, 0
36127, 5204, 5205, 5216, 5215, 0, 0, 0, 0
36128, 5205, 5206, 5217, 5216, 0, 0, 0, 0
36129, 5206, 5207, 5218, 5217, 0, 0, 0, 0
36130, 5207, 511, 512, 5218, 0, 0, 0, 0
36131, 478, 5208, 5219, 479, 0, 0, 0, 0
36132, 5208, 5209, 5220, 5219, 0, 0, 0, 0
36133, 5209, 5210, 5221, 5220, 0, 0, 0, 0
36134, 5210, 5211, 5222, 5221, 0, 0, 0, 0
36135, 5211, 5212, 5223, 5222, 0, 0, 0, 0
36136, 5212, 5213, 5224, 5223, 0, 0, 0, 0
36137, 5213, 5214, 5225, 5224, 0, 0, 0, 0
36138, 5214, 5215, 5226, 5225, 0, 0, 0, 0
36139, 5215, 5216, 5227, 5226, 0, 0, 0, 0
36140, 5216, 5217, 5228, 5227, 0, 0, 0, 0
36141, 5217, 5218, 5229, 5228, 0, 0, 0, 0
36142, 5218, 512, 513, 5229, 0, 0, 0, 0
36143, 479, 5219, 5230, 480, 0, 0, 0, 0
36144, 5219, 5220, 5231, 5230, 0, 0, 0, 0
36145, 5220, 5221, 5232, 5231, 0, 0, 0, 0
36146, 5221, 5222, 5233, 5232, 0, 0, 0, 0
36147, 5222, 5223, 5234, 5233, 0, 0, 0, 0
36148, 5223, 5224, 5235, 5234, 0, 0, 0, 0
36149, 5224, 5225, 5236, 5235, 0, 0, 0, 0
36150, 5225, 5226, 5237, 5236, 0, 0, 0, 0
36151, 5226, 5227, 5238, 5237, 0, 0, 0, 0
36152, 5227, 5228, 5239, 5238, 0, 0, 0, 0
36153, 5228, 5229, 5240, 5239, 0, 0, 0, 0
36154, 5229, 513, 514, 5240, 0, 0, 0, 0
36155, 480, 5230, 5241, 481, 0, 0, 0, 0
36156, 5230, 5231, 5242, 5241, 0, 0, 0, 0
36157, 5231, 5232, 5243, 5242, 0, 0, 0, 0
36158, 5232, 5233, 5244, 5243, 0, 0, 0, 0
36159, 5233, 5234, 5245, 5244, 0, 0, 0, 0
36160, 5234, 5235, 5246, 5245, 0, 0, 0, 0
36161, 5235, 5236, 5247, 5246, 0, 0, 0, 0
36162, 5236, 5237, 5248, 5247, 0, 0, 0, 0
36163, 5237, 5238, 5249, 5248, 0, 0, 0, 0
36164, 5238, 5239, 5250, 5249, 0, 0, 0, 0
36165, 5239, 5240, 5251, 5250, 0, 0, 0, 0
36166, 5240, 514, 515, 5251, 0, 0, 0, 0
36167, 481, 5241, 5252, 482, 0, 0, 0, 0
36168, 5241, 5242, 5253, 5252, 0, 0, 0, 0
36169, 5242, 5243, 5254, 5253, 0, 0, 0, 0
36170, 5243, 5244, 5255, 5254, 0, 0, 0, 0
36171, 5244, 5245, 5256, 5255, 0, 0, 0, 0
36172, 5245, 5246, 5257, 5256, 0, 0, 0, 0
36173, 5246, 5247, 5258, 5257, 0, 0, 0, 0
36174, 5247, 5248, 5259, 5258, 0, 0, 0, 0
36175, 5248, 5249, 5260, 5259, 0, 0, 0, 0
36176, 5249, 5250, 5261, 5260, 0, 0, 0, 0
36177, 5250, 5251, 5262, 5261, 0, 0, 0, 0
36178, 5251, 515, 516, 5262, 0, 0, 0, 0
36179, 482, 5252, 5263, 483, 0, 0, 0, 0
36180, 5252, 5253, 5264, 5263, 0, 0, 0, 0
36181, 5253, 5254, 5265, 5264, 0, 0, 0, 0
36182, 5254, 5255, 5266, 5265, 0, 0, 0, 0
36183, 5255, 5256, 5267, 5266, 0, 0, 0, 0
36184, 5256, 5257, 5268, 5267, 0, 0, 0, 0
36185, 5257, 5258, 5269, 5268, 0, 0, 0, 0
36186, 5258, 5259, 5270, 5269, 0, 0, 0, 0
36187, 5259, 5260, 5271, 5270, 0, 0, 0, 0
36188, 5260, 5261, 5272, 5271, 0, 0, 0, 0
36189, 5261, 5262, 5273, 5272, 0, 0, 0, 0
36190, 5262, 516, 517, 5273, 0, 0, 0, 0
36191, 483, 5263, 5274, 484, 0, 0, 0, 0
36192, 5263, 5264, 5275, 5274, 0, 0, 0, 0
36193, 5264, 5265, 5276, 5275, 0, 0, 0, 0
36194, 5265, 5266, 5277, 5276, 0, 0, 0, 0
36195, 5266, 5267, 5278, 5277, 0, 0, 0, 0
36196, 5267, 5268, 5279, 5278, 0, 0, 0, 0
36197, 5268, 5269, 5280, 5279, 0, 0, 0, 0
36198, 5269, 5270, 5281, 5280, 0, 0, 0, 0
36199, 5270, 5271, 5282, 5281, 0, 0, 0, 0
36200, 5271, 5272, 5283, 5282, 0, 0, 0, 0
36201, 5272, 5273, 5284, 5283, 0, 0, 0, 0
36202, 5273, 517, 518, 5284, 0, 0, 0, 0
36203, 484, 5274, 5285, 485, 0, 0, 0, 0
36204, 5274, 5275, 5286, 5285, 0, 0, 0, 0
36205, 5275, 5276, 5287, 5286, 0, 0, 0, 0
36206, 5276, 5277, 5288, 5287, 0, 0, 0, 0
36207, 5277, 5278, 5289, 5288, 0, 0, 0, 0
36208, 5278, 5279, 5290, 5289, 0, 0, 0, 0
36209, 5279, 5280, 5291, 5290, 0, 0, 0, 0
36210, 5280, 5281, 5292, 5291, 0, 0, 0, 0
36211, 5281, 5282, 5293, 5292, 0, 0, 0, 0
36212, 5282, 5283, 5294, 5293, 0, 0, 0, 0
36213, 5283, 5284, 5295, 5294, 0, 0, 0, 0
36214, 5284, 518, 519, 5295, 0, 0, 0, 0
36215, 485, 5285, 5296, 486, 0, 0, 0, 0
36216, 5285, 5286, 5297, 5296, 0, 0, 0, 0
36217, 5286, 5287, 5298, 5297, 0, 0, 0, 0
36218, 5287, 5288, 5299, 5298, 0, 0, 0, 0
36219, 5288, 5289, 5300, 5299, 0, 0, 0, 0
36220, 5289, 5290, 5301, 5300, 0, 0, 0, 0
36221, 5290, 5291, 5302, 5301, 0, 0, 0, 0
36222, 5291, 5292, 5303, 5302, 0, 0, 0, 0
36223, 5292, 5293, 5304, 5303, 0, 0, 0, 0
36224, 5293, 5294, 5305, 5304, 0, 0, 0, 0
36225, 5294, 5295, 5306, 5305, 0, 0, 0, 0
36226, 5295, 519, 520, 5306, 0, 0, 0, 0
36227, 486, 5296, 5307, 487, 0, 0, 0, 0
36228, 5296, 5297, 5308, 5307, 0, 0, 0, 0
36229, 5297, 5298, 5309, 5308, 0, 0, 0, 0
36230, 5298, 5299, 5310, 5309, 0, 0, 0, 0
36231, 5299, 5300, 5311, 5310, 0, 0, 0, 0
36232, 5300, 5301, 5312, 5311, 0, 0, 0, 0
36233, 5301, 5302, 5313, 5312, 0, 0, 0, 0
36234, 5302, 5303, 5314, 5313, 0, 0, 0, 0
36235, 5303, 5304, 5315, 5314, 0, 0, 0, 0
36236, 5304, 5305, 5316, 5315, 0, 0, 0, 0
36237, 5305, 5306, 5317, 5316, 0, 0, 0, 0
36238, 5306, 520, 521, 5317, 0, 0, 0, 0
36239, 487, 5307, 5318, 488, 0, 0, 0, 0
36240, 5307, 5308, 5319, 5318, 0, 0, 0, 0
36241, 5308, 5309, 5320, 5319, 0, 0, 0, 0
36242, 5309, 5310, 5321, 5320, 0, 0, 0, 0
36243, 5310, 5311, 5322, 5321, 0, 0, 0, 0
36244, 5311, 5312, 5323, 5322, 0, 0, 0, 0
36245, 5312, 5313, 5324, 5323, 0, 0, 0, 0
36246, 5313, 5314, 5325, 5324, 0, 0, 0, 0
36247, 5314, 5315, 5326, 5325, 0, 0, 0, 0
36248, 5315, 5316, 5327, 5326, 0, 0, 0, 0
36249, 5316, 5317, 5328, 5327, 0, 0, 0, 0
36250, 5317, 521, 522, 5328, 0, 0, 0, 0
36251, 488, 5318, 5329, 489, 0, 0, 0, 0
36252, 5318, 5319, 5330, 5329, 0, 0, 0, 0
36253, 5319, 5320, 5331, 5330, 0, 0, 0, 0
36254, 5320, 5321, 5332, 5331, 0, 0, 0, 0
36255, 5321, 5322, 5333, 5332, 0, 0, 0, 0
36256, 5322, 5323, 5334, 5333, 0, 0, 0, 0
36257, 5323, 5324, 5335, 5334, 0, 0, 0, 0
36258, 5324, 5325, 5336, 5335, 0, 0, 0, 0
36259, 5325, 5326, 5337, 5336, 0, 0, 0, 0
36260, 5326, 5327, 5338, 5337, 0, 0, 0, 0
36261, 5327, 5328, 5339, 5338, 0, 0, 0, 0
36262, 5328, 522, 523, 5339, 0, 0, 0, 0
36263, 489, 5329, 5340, 490, 0, 0, 0, 0
36264, 5329, 5330, 5341, 5340, 0, 0, 0, 0
36265, 5330, 5331, 5342, 5341, 0, 0, 0, 0
36266, 5331, 5332, 5343, 5342, 0, 0, 0, 0
36267, 5332, 5333, 5344, 5343, 0, 0, 0, 0
36268, 5333, 5334, 5345, 5344, 0, 0, 0, 0
36269, 5334, 5335, 5346, 5345, 0, 0, 0, 0
36270, 5335, 5336, 5347, 5346, 0, 0, 0, 0
36271, 5336, 5337, 5348, 5347, 0, 0, 0, 0
36272, 5337, 5338, 5349, 5348, 0, 0, 0, 0
36273, 5338, 5339, 5350, 5349, 0, 0, 0, 0
36274, 5339, 523, 524, 5350, 0, 0, 0, 0
36275, 490, 5340, 5351, 491, 0, 0, 0, 0
36276, 5340, 5341, 5352, 5351, 0, 0, 0, 0
36277, 5341, 5342, 5353, 5352, 0, 0, 0, 0
36278, 5342, 5343, 5354, 5353, 0, 0, 0, 0
36279, 5343, 5344, 5355, 5354, 0, 0, 0, 0
36280, 5344, 5345, 5356, 5355, 0, 0, 0, 0
36281, 5345, 5346, 5357, 5356, 0, 0, 0, 0
36282, 5346, 5347, 5358, 5357, 0, 0, 0, 0
36283, 5347, 5348, 5359, 5358, 0, 0, 0, 0
36284, 5348, 5349, 5360, 5359, 0, 0, 0, 0
36285, 5349, 5350, 5361, 5360, 0, 0, 0, 0
36286, 5350, 524, 525, 5361, 0, 0, 0, 0
36287, 491, 5351, 5362, 492, 0, 0, 0, 0
36288, 5351, 5352, 5363, 5362, 0, 0, 0, 0
36289, 5352, 5353, 5364, 5363, 0, 0, 0, 0
36290, 5353, 5354, 5365, 5364, 0, 0, 0, 0
36291, 5354, 5355, 5366, 5365, 0, 0, 0, 0
36292, 5355, 5356, 5367, 5366, 0, 0, 0, 0
36293, 5356, 5357, 5368, 5367, 0, 0, 0, 0
36294, 5357, 5358, 5369, 5368, 0, 0, 0, 0
36295, 5358, 5359, 5370, 5369, 0, 0, 0, 0
36296, 5359, 5360, 5371, 5370, 0, 0, 0, 0
36297, 5360, 5361, 5372, 5371, 0, 0, 0, 0
36298, 5361, 525, 526, 5372, 0, 0, 0, 0
36299, 492, 5362, 493, 17, 0, 0, 0, 0
36300, 5362, 5363, 494, 493, 0, 0, 0, 0
36301, 5363, 5364, 495, 494, 0, 0, 0, 0
36302, 5364, 5365, 496, 495, 0, 0, 0, 0
36303, 5365, 5366, 497, 496, 0, 0, 0, 0
36304, 5366, 5367, 498, 497, 0, 0, 0, 0
36305, 5367, 5368, 499, 498, 0, 0, 0, 0
36306, 5368, 5369, 500, 499, 0, 0, 0, 0
36307, 5369, 5370, 501, 500, 0, 0, 0, 0
36308, 5370, 5371, 502, 501, 0, 0, 0, 0
36309, 5371, 5372, 503, 502, 0, 0, 0, 0
36310, 5372, 526, 19, 503, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface22
36311, 18, 540, 5373, 470, 0, 0, 0, 0
36312, 540, 541, 5374, 5373, 0, 0, 0, 0
36313, 541, 22, 542, 5374, 0, 0, 0, 0
36314, 470, 5373, 5375, 471, 0, 0, 0, 0
36315, 5373, 5374, 5376, 5375, 0, 0, 0, 0
36316, 5374, 542, 543, 5376, 0, 0, 0, 0
36317, 471, 5375, 5377, 472, 0, 0, 0, 0
36318, 5375, 5376, 5378, 5377, 0, 0, 0, 0
36319, 5376, 543, 544, 5378, 0, 0, 0, 0
36320, 472, 5377, 5379, 473, 0, 0, 0, 0
36321, 5377, 5378, 5380, 5379, 0, 0, 0, 0
36322, 5378, 544, 545, 5380, 0, 0, 0, 0
36323, 473, 5379, 5381, 474, 0, 0, 0, 0
36324, 5379, 5380, 5382, 5381, 0, 0, 0, 0
36325, 5380, 545, 546, 5382, 0, 0, 0, 0
36326, 474, 5381, 5383, 475, 0, 0, 0, 0
36327, 5381, 5382, 5384, 5383, 0, 0, 0, 0
36328, 5382, 546, 547, 5384, 0, 0, 0, 0
36329, 475, 5383, 5385, 476, 0, 0, 0, 0
36330, 5383, 5384, 5386, 5385, 0, 0, 0, 0
36331, 5384, 547, 548, 5386, 0, 0, 0, 0
36332, 476, 5385, 5387, 477, 0, 0, 0, 0
36333, 5385, 5386, 5388, 5387, 0, 0, 0, 0
36334, 5386, 548, 549, 5388, 0, 0, 0, 0
36335, 477, 5387, 5389, 478, 0, 0, 0, 0
36336, 5387, 5388, 5390, 5389, 0, 0, 0, 0
36337, 5388, 549, 550, 5390, 0, 0, 0, 0
36338, 478, 5389, 5391, 479, 0, 0, 0, 0
36339, 5389, 5390, 5392, 5391, 0, 0, 0, 0
36340, 5390, 550, 551, 5392, 0, 0, 0, 0
36341, 479, 5391, 5393, 480, 0, 0, 0, 0
36342, 5391, 5392, 5394, 5393, 0, 0, 0, 0
36343, 5392, 551, 552, 5394, 0, 0, 0, 0
36344, 480, 5393, 5395, 481, 0, 0, 0, 0
36345, 5393, 5394, 5396, 5395, 0, 0, 0, 0
36346, 5394, 552, 553, 5396, 0, 0, 0, 0
36347, 481, 5395, 5397, 482, 0, 0, 0, 0
36348, 5395, 5396, 5398, 5397, 0, 0, 0, 0
36349, 5396, 553, 554, 5398, 0, 0, 0, 0
36350, 482, 5397, 5399, 483, 0, 0, 0, 0
36351, 5397, 5398, 5400, 5399, 0, 0, 0, 0
36352, 5398, 554, 555, 5400, 0, 0, 0, 0
36353, 483, 5399, 5401, 484, 0, 0, 0, 0
36354, 5399, 5400, 5402, 5401, 0, 0, 0, 0
36355, 5400, 555, 556, 5402, 0, 0, 0, 0
36356, 484, 5401, 5403, 485, 0, 0, 0, 0
36357, 5401, 5402, 5404, 5403, 0, 0, 0, 0
36358, 5402, 556, 557, 5404, 0, 0, 0, 0
36359, 485, 5403, 5405, 486, 0, 0, 0, 0
36360, 5403, 5404, 5406, 5405, 0, 0, 0, 0
36361, 5404, 557, 558, 5406, 0, 0, 0, 0
36362, 486, 5405, 5407, 487, 0, 0, 0, 0
36363, 5405, 5406, 5408, 5407, 0, 0, 0, 0
36364, 5406, 558, 559, 5408, 0, 0, 0, 0
36365, 487, 5407, 5409, 488, 0, 0, 0, 0
36366, 5407, 5408, 5410, 5409, 0, 0, 0, 0
36367, 5408, 559, 560, 5410, 0, 0, 0, 0
36368, 488, 5409, 5411, 489, 0, 0, 0, 0
36369, 5409, 5410, 5412, 5411, 0, 0, 0, 0
36370, 5410, 560, 561, 5412, 0, 0, 0, 0
36371, 489, 5411, 5413, 490, 0, 0, 0, 0
36372, 5411, 5412, 5414, 5413, 0, 0, 0, 0
36373, 5412, 561, 562, 5414, 0, 0, 0, 0
36374, 490, 5413, 5415, 491, 0, 0, 0, 0
36375, 5413, 5414, 5416, 5415, 0, 0, 0, 0
36376, 5414, 562, 563, 5416, 0, 0, 0, 0
36377, 491, 5415, 5417, 492, 0, 0, 0, 0
36378, 5415, 5416, 5418, 5417, 0, 0, 0, 0
36379, 5416, 563, 564, 5418, 0, 0, 0, 0
36380, 492, 5417, 538, 17, 0, 0, 0, 0
36381, 5417, 5418, 539, 538, 0, 0, 0, 0
36382, 5418, 564, 21, 539, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface23
36383, 17, 538, 5419, 493, 0, 0, 0, 0
36384, 538, 539, 5420, 5419, 0, 0, 0, 0
36385, 539, 21, 567, 5420, 0, 0, 0, 0
36386, 493, 5419, 5421, 494, 0, 0, 0, 0
36387, 5419, 5420, 5422, 5421, 0, 0, 0, 0
36388, 5420, 567, 568, 5422, 0, 0, 0, 0
36389, 494, 5421, 5423, 495, 0, 0, 0, 0
36390, 5421, 5422, 5424, 5423, 0, 0, 0, 0
36391, 5422, 568, 569, 5424, 0, 0, 0, 0
36392, 495, 5423, 5425, 496, 0, 0, 0, 0
36393, 5423, 5424, 5426, 5425, 0, 0, 0, 0
36394, 5424, 569, 570, 5426, 0, 0, 0, 0
36395, 496, 5425, 5427, 497, 0, 0, 0, 0
36396, 5425, 5426, 5428, 5427, 0, 0, 0, 0
36397, 5426, 570, 571, 5428, 0, 0, 0, 0
36398, 497, 5427, 5429, 498, 0, 0, 0, 0
36399, 5427, 5428, 5430, 5429, 0, 0, 0, 0
36400, 5428, 571, 572, 5430, 0, 0, 0, 0
36401, 498, 5429, 5431, 499, 0, 0, 0, 0
36402, 5429, 5430, 5432, 5431, 0, 0, 0, 0
36403, 5430, 572, 573, 5432, 0, 0, 0, 0
36404, 499, 5431, 5433, 500, 0, 0, 0, 0
36405, 5431, 5432, 5434, 5433, 0, 0, 0, 0
36406, 5432, 573, 574, 5434, 0, 0, 0, 0
36407, 500, 5433, 5435, 501, 0, 0, 0, 0
36408, 5433, 5434, 5436, 5435, 0, 0, 0, 0
36409, 5434, 574, 575, 5436, 0, 0, 0, 0
36410, 501, 5435, 5437, 502, 0, 0, 0, 0
36411, 5435, 5436, 5438, 5437, 0, 0, 0, 0
36412, 5436, 575, 576, 5438, 0, 0, 0, 0
36413, 502, 5437, 5439, 503, 0, 0, 0, 0
36414, 5437, 5438, 5440, 5439, 0, 0, 0, 0
36415, 5438, 576, 577, 5440, 0, 0, 0, 0
36416, 503, 5439, 565, 19, 0, 0, 0, 0
36417, 5439, 5440, 566, 565, 0, 0, 0, 0
36418, 5440, 577, 23, 566, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface24
1382, 20, 504, 5441, 578, 0, 0, 0, 0
1383, 578, 5441, 5442, 579, 0, 0, 0, 0
1384, 579, 5442, 580, 24, 0, 0, 0, 0
1385, 504, 505, 5443, 5441, 0, 0, 0, 0
1386, 5441, 5443, 5444, 5442, 0, 0, 0, 0
1387, 5442, 5444, 581, 580, 0, 0, 0, 0
1388, 505, 506, 5445, 5443, 0, 0, 0, 0
1389, 5443, 5445, 5446, 5444, 0, 0, 0, 0
1390, 5444, 5446, 582, 581, 0, 0, 0, 0
1391, 506, 507, 5447, 5445, 0, 0, 0, 0
1392, 5445, 5447, 5448, 5446, 0, 0, 0, 0
1393, 5446, 5448, 583, 582, 0, 0, 0, 0
1394, 507, 508, 5449, 5447, 0, 0, 0, 0
1395, 5447, 5449, 5450, 5448, 0, 0, 0, 0
1396, 5448, 5450, 584, 583, 0, 0, 0, 0
1397, 508, 509, 5451, 5449, 0, 0, 0, 0
1398, 5449, 5451, 5452, 5450, 0, 0, 0, 0
1399, 5450, 5452, 585, 584, 0, 0, 0, 0
1400, 509, 510, 5453, 5451, 0, 0, 0, 0
1401, 5451, 5453, 5454, 5452, 0, 0, 0, 0
1402, 5452, 5454, 586, 585, 0, 0, 0, 0
1403, 510, 511, 5455, 5453, 0, 0, 0, 0
1404, 5453, 5455, 5456, 5454, 0, 0, 0, 0
1405, 5454, 5456, 587, 586, 0, 0, 0, 0
1406, 511, 512, 5457, 5455, 0, 0, 0, 0
1407, 5455, 5457, 5458, 5456, 0, 0, 0, 0
1408, 5456, 5458, 588, 587, 0, 0, 0, 0
1409, 512, 513, 5459, 5457, 0, 0, 0, 0
1410, 5457, 5459, 5460, 5458, 0, 0, 0, 0
1411, 5458, 5460, 589, 588, 0, 0, 0, 0
1412, 513, 514, 5461, 5459, 0, 0, 0, 0
1413, 5459, 5461, 5462, 5460, 0, 0, 0, 0
1414, 5460, 5462, 590, 589, 0, 0, 0, 0
1415, 514, 515, 5463, 5461, 0, 0, 0, 0
1416, 5461, 5463, 5464, 5462, 0, 0, 0, 0
1417, 5462, 5464, 591, 590, 0, 0, 0, 0
1418, 515, 516, 5465, 5463, 0, 0, 0, 0
1419, 5463, 5465, 5466, 5464, 0, 0, 0, 0
1420, 5464, 5466, 592, 591, 0, 0, 0, 0
1421, 516, 517, 5467, 5465, 0, 0, 0, 0
1422, 5465, 5467, 5468, 5466, 0, 0, 0, 0
1423, 5466, 5468, 593, 592, 0, 0, 0, 0
1424, 517, 518, 5469, 5467, 0, 0, 0, 0
1425, 5467, 5469, 5470, 5468, 0, 0, 0, 0
1426, 5468, 5470, 594, 593, 0, 0, 0, 0
1427, 518, 519, 5471, 5469, 0, 0, 0, 0
1428, 5469, 5471, 5472, 5470, 0, 0, 0, 0
1429, 5470, 5472, 595, 594, 0, 0, 0, 0
1430, 519, 520, 5473, 5471, 0, 0, 0, 0
1431, 5471, 5473, 5474, 5472, 0, 0, 0, 0
1432, 5472, 5474, 596, 595, 0, 0, 0, 0
1433, 520, 521, 5475, 5473, 0, 0, 0, 0
1434, 5473, 5475, 5476, 5474, 0, 0, 0, 0
1435, 5474, 5476, 597, 596, 0, 0, 0, 0
1436, 521, 522, 5477, 5475, 0, 0, 0, 0
1437, 5475, 5477, 5478, 5476, 0, 0, 0, 0
1438, 5476, 5478, 598, 597, 0, 0, 0, 0
1439, 522, 523, 5479, 5477, 0, 0, 0, 0
1440, 5477, 5479, 5480, 5478, 0, 0, 0, 0
1441, 5478, 5480, 599, 598, 0, 0, 0, 0
1442, 523, 524, 5481, 5479, 0, 0, 0, 0
1443, 5479, 5481, 5482, 5480, 0, 0, 0, 0
1444, 5480, 5482, 600, 599, 0, 0, 0, 0
1445, 524, 525, 5483, 5481, 0, 0, 0, 0
1446, 5481, 5483, 5484, 5482, 0, 0, 0, 0
1447, 5482, 5484, 601, 600, 0, 0, 0, 0
1448, 525, 526, 5485, 5483, 0, 0, 0, 0
1449, 5483, 5485, 5486, 5484, 0, 0, 0, 0
1450, 5484, 5486, 602, 601, 0, 0, 0, 0
1451, 526, 19, 565, 5485, 0, 0, 0, 0
1452, 5485, 565, 566, 5486, 0, 0, 0, 0
1453, 5486, 566, 23, 602, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface25
1454, 18, 527, 5487, 540, 0, 0, 0, 0
1455, 540, 5487, 5488, 541, 0, 0, 0, 0
1456, 541, 5488, 603, 22, 0, 0, 0, 0
1457, 527, 528, 5489, 5487, 0, 0, 0, 0
1458, 5487, 5489, 5490, 5488, 0, 0, 0, 0
1459, 5488, 5490, 604, 603, 0, 0, 0, 0
1460, 528, 529, 5491, 5489, 0, 0, 0, 0
1461, 5489, 5491, 5492, 5490, 0, 0, 0, 0
1462, 5490, 5492, 605, 604, 0, 0, 0, 0
1463, 529, 530, 5493, 5491, 0, 0, 0, 0
1464, 5491, 5493, 5494, 5492, 0, 0, 0, 0
1465, 5492, 5494, 606, 605, 0, 0, 0, 0
1466, 530, 531, 5495, 5493, 0, 0, 0, 0
1467, 5493, 5495, 5496, 5494, 0, 0, 0, 0
1468, 5494, 5496, 607, 606, 0, 0, 0, 0
1469, 531, 532, 5497, 5495, 0, 0, 0, 0
1470, 5495, 5497, 5498, 5496, 0, 0, 0, 0
1471, 5496, 5498, 608, 607, 0, 0, 0, 0
1472, 532, 533, 5499, 5497, 0, 0, 0, 0
1473, 5497, 5499, 5500, 5498, 0, 0, 0, 0
1474, 5498, 5500, 609, 608, 0, 0, 0, 0
1475, 533, 534, 5501, 5499, 0, 0, 0, 0
1476, 5499, 5501, 5502, 5500, 0, 0, 0, 0
1477, 5500, 5502, 610, 609, 0, 0, 0, 0
1478, 534, 535, 5503, 5501, 0, 0, 0, 0
1479, 5501, 5503, 5504, 5502, 0, 0, 0, 0
1480, 5502, 5504, 611, 610, 0, 0, 0, 0
1481, 535, 536, 5505, 5503, 0, 0, 0, 0
1482, 5503, 5505, 5506, 5504, 0, 0, 0, 0
1483, 5504, 5506, 612, 611, 0, 0, 0, 0
1484, 536, 537, 5507, 5505, 0, 0, 0, 0
1485, 5505, 5507, 5508, 5506, 0, 0, 0, 0
1486, 5506, 5508, 613, 612, 0, 0, 0, 0
1487, 537, 20, 578, 5507, 0, 0, 0, 0
1488, 5507, 578, 579, 5508, 0, 0, 0, 0
1489, 5508, 579, 24, 613, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface26
1490, 22, 603, 5509, 542, 0, 0, 0, 0
1491, 603, 604, 5510, 5509, 0, 0, 0, 0
1492, 604, 605, 5511, 5510, 0, 0, 0, 0
1493, 605, 606, 5512, 5511, 0, 0, 0, 0
1494, 606, 607, 5513, 5512, 0, 0, 0, 0
1495, 607, 608, 5514, 5513, 0, 0, 0, 0
1496, 608, 609, 5515, 5514, 0, 0, 0, 0
1497, 609, 610, 5516, 5515, 0, 0, 0, 0
1498, 610, 611, 5517, 5516, 0, 0, 0, 0
1499, 611, 612, 5518, 5517, 0, 0, 0, 0
1500, 612, 613, 5519, 5518, 0, 0, 0, 0
1501, 613, 24, 580, 5519, 0, 0, 0, 0
1502, 542, 5509, 5520, 543, 0, 0, 0, 0
1503, 5509, 5510, 5521, 5520, 0, 0, 0, 0
1504, 5510, 5511, 5522, 5521, 0, 0, 0, 0
1505, 5511, 5512, 5523, 5522, 0, 0, 0, 0
1506, 5512, 5513, 5524, 5523, 0, 0, 0, 0
1507, 5513, 5514, 5525, 5524, 0, 0, 0, 0
1508, 5514, 5515, 5526, 5525, 0, 0, 0, 0
1509, 5515, 5516, 5527, 5526, 0, 0, 0, 0
1510, 5516, 5517, 5528, 5527, 0, 0, 0, 0
1511, 5517, 5518, 5529, 5528, 0, 0, 0, 0
1512, 5518, 5519, 5530, 5529, 0, 0, 0, 0
1513, 5519, 580, 581, 5530, 0, 0, 0, 0
1514, 543, 5520, 5531, 544, 0, 0, 0, 0
1515, 5520, 5521, 5532, 5531, 0, 0, 0, 0
1516, 5521, 5522, 5533, 5532, 0, 0, 0, 0
1517, 5522, 5523, 5534, 5533, 0, 0, 0, 0
1518, 5523, 5524, 5535, 5534, 0, 0, 0, 0
1519, 5524, 5525, 5536, 5535, 0, 0, 0, 0
1520, 5525, 5526, 5537, 5536, 0, 0, 0, 0
1521, 5526, 5527, 5538, 5537, 0, 0, 0, 0
1522, 5527, 5528, 5539, 5538, 0, 0, 0, 0
1523, 5528, 5529, 5540, 5539, 0, 0, 0, 0
1524, 5529, 5530, 5541, 5540, 0, 0, 0, 0
1525, 5530, 581, 582, 5541, 0, 0, 0, 0
1526, 544, 5531, 5542, 545, 0, 0, 0, 0
1527, 5531, 5532, 5543, 5542, 0, 0, 0, 0
1528, 5532, 5533, 5544, 5543, 0, 0, 0, 0
1529, 5533, 5534, 5545, 5544, 0, 0, 0, 0
1530, 5534, 5535, 5546, 5545, 0, 0, 0, 0
1531, 5535, 5536, 5547, 5546, 0, 0, 0, 0
1532, 5536, 5537, 5548, 5547, 0, 0, 0, 0
1533, 5537, 5538, 5549, 5548, 0, 0, 0, 0
1534, 5538, 5539, 5550, 5549, 0, 0, 0, 0
1535, 5539, 5540, 5551, 5550, 0, 0, 0, 0
1536, 5540, 5541, 5552, 5551, 0, 0, 0, 0
1537, 5541, 582, 583, 5552, 0, 0, 0, 0
1538, 545, 5542, 5553, 546, 0, 0, 0, 0
1539, 5542, 5543, 5554, 5553, 0, 0, 0, 0
1540, 5543, 5544, 5555, 5554, 0, 0, 0, 0
1541, 5544, 5545, 5556, 5555, 0, 0, 0, 0
1542, 5545, 5546, 5557, 5556, 0, 0, 0, 0
1543, 5546, 5547, 5558, 5557, 0, 0, 0, 0
1544, 5547, 5548, 5559, 5558, 0, 0, 0, 0
1545, 5548, 5549, 5560, 5559, 0, 0, 0, 0
1546, 5549, 5550, 5561, 5560, 0, 0, 0, 0
1547, 5550, 5551, 5562, 5561, 0, 0, 0, 0
1548, 5551, 5552, 5563, 5562, 0, 0, 0, 0
1549, 5552, 583, 584, 5563, 0, 0, 0, 0
1550, 546, 5553, 5564, 547, 0, 0, 0, 0
1551, 5553, 5554, 5565, 5564, 0, 0, 0, 0
1552, 5554, 5555, 5566, 5565, 0, 0, 0, 0
1553, 5555, 5556, 5567, 5566, 0, 0, 0, 0
1554, 5556, 5557, 5568, 5567, 0, 0, 0, 0
1555, 5557, 5558, 5569, 5568, 0, 0, 0, 0
1556, 5558, 5559, 5570, 5569, 0, 0, 0, 0
1557, 5559, 5560, 5571, 5570, 0, 0, 0, 0
1558, 5560, 5561, 5572, 5571, 0, 0, 0, 0
1559, 5561, 5562, 5573, 5572, 0, 0, 0, 0
1560, 5562, 5563, 5574, 5573, 0, 0, 0, 0
1561, 5563, 584, 585, 5574, 0, 0, 0, 0
1562, 547, 5564, 5575, 548, 0, 0, 0, 0
1563, 5564, 5565, 5576, 5575, 0, 0, 0, 0
1564, 5565, 5566, 5577, 5576, 0, 0, 0, 0
1565, 5566, 5567, 5578, 5577, 0, 0, 0, 0
1566, 5567, 5568, 5579, 5578, 0, 0, 0, 0
1567, 5568, 5569, 5580, 5579, 0, 0, 0, 0
1568, 5569, 5570, 5581, 5580, 0, 0, 0, 0
1569, 5570, 5571, 5582, 5581, 0, 0, 0, 0
1570, 5571, 5572, 5583, 5582, 0, 0, 0, 0
1571, 5572, 5573, 5584, 5583, 0, 0, 0, 0
1572, 5573, 5574, 5585, 5584, 0, 0, 0, 0
1573, 5574, 585, 586, 5585, 0, 0, 0, 0
1574, 548, 5575, 5586, 549, 0, 0, 0, 0
1575, 5575, 5576, 5587, 5586, 0, 0, 0, 0
1576, 5576, 5577, 5588, 5587, 0, 0, 0, 0
1577, 5577, 5578, 5589, 5588, 0, 0, 0, 0
1578, 5578, 5579, 5590, 5589, 0, 0, 0, 0
1579, 5579, 5580, 5591, 5590, 0, 0, 0, 0
1580, 5580, 5581, 5592, 5591, 0, 0, 0, 0
1581, 5581, 5582, 5593, 5592, 0, 0, 0, 0
1582, 5582, 5583, 5594, 5593, 0, 0, 0, 0
1583, 5583, 5584, 5595, 5594, 0, 0, 0, 0
1584, 5584, 5585, 5596, 5595, 0, 0, 0, 0
1585, 5585, 586, 587, 5596, 0, 0, 0, 0
1586, 549, 5586, 5597, 550, 0, 0, 0, 0
1587, 5586, 5587, 5598, 5597, 0, 0, 0, 0
1588, 5587, 5588, 5599, 5598, 0, 0, 0, 0
1589, 5588, 5589, 5600, 5599, 0, 0, 0, 0
1590, 5589, 5590, 5601, 5600, 0, 0, 0, 0
1591, 5590, 5591, 5602, 5601, 0, 0, 0, 0
1592, 5591, 5592, 5603, 5602, 0, 0, 0, 0
1593, 5592, 5593, 5604, 5603, 0, 0, 0, 0
1594, 5593, 5594, 5605, 5604, 0, 0, 0, 0
1595, 5594, 5595, 5606, 5605, 0, 0, 0, 0
1596, 5595, 5596, 5607, 5606, 0, 0, 0, 0
1597, 5596, 587, 588, 5607, 0, 0, 0, 0
1598, 550, 5597, 5608, 551, 0, 0, 0, 0
1599, 5597, 5598, 5609, 5608, 0, 0, 0, 0
1600, 5598, 5599, 5610, 5609, 0, 0, 0, 0
1601, 5599, 5600, 5611, 5610, 0, 0, 0, 0
1602, 5600, 5601, 5612, 5611, 0, 0, 0, 0
1603, 5601, 5602, 5613, 5612, 0, 0, 0, 0
1604, 5602, 5603, 5614, 5613, 0, 0, 0, 0
1605, 5603, 5604, 5615, 5614, 0, 0, 0, 0
1606, 5604, 5605, 5616, 5615, 0, 0, 0, 0
1607, 5605, 5606, 5617, 5616, 0, 0, 0, 0
1608, 5606, 5607, 5618, 5617, 0, 0, 0, 0
1609, 5607, 588, 589, 5618, 0, 0, 0, 0
1610, 551, 5608, 5619, 552, 0, 0, 0, 0
1611, 5608, 5609, 5620, 5619, 0, 0, 0, 0
1612, 5609, 5610, 5621, 5620, 0, 0, 0, 0
1613, 5610, 5611, 5622, 5621, 0, 0, 0, 0
1614, 5611, 5612, 5623, 5622, 0, 0, 0, 0
1615, 5612, 5613, 5624, 5623, 0, 0, 0, 0
1616, 5613, 5614, 5625, 5624, 0, 0, 0, 0
1617, 5614, 5615, 5626, 5625, 0, 0, 0, 0
1618, 5615, 5616, 5627, 5626, 0, 0, 0, 0
1619, 5616, 5617, 5628, 5627, 0, 0, 0, 0
1620, 5617, 5618, 5629, 5628, 0, 0, 0, 0
1621, 5618, 589, 590, 5629, 0, 0, 0, 0
1622, 552, 5619, 5630, 553, 0, 0, 0, 0
1623, 5619, 5620, 5631, 5630, 0, 0, 0, 0
1624, 5620, 5621, 5632, 5631, 0, 0, 0, 0
1625, 5621, 5622, 5633, 5632, 0, 0, 0, 0
1626, 5622, 5623, 5634, 5633, 0, 0, 0, 0
1627, 5623, 5624, 5635, 5634, 0, 0, 0, 0
1628, 5624, 5625, 5636, 5635, 0, 0, 0, 0
1629, 5625, 5626, 5637, 5636, 0, 0, 0, 0
1630, 5626, 5627, 5638, 5637, 0, 0, 0, 0
1631, 5627, 5628, 5639, 5638, 0, 0, 0, 0
1632, 5628, 5629, 5640, 5639, 0, 0, 0, 0
1633, 5629, 590, 591, 5640, 0, 0, 0, 0
1634, 553, 5630, 5641, 554, 0, 0, 0, 0
1635, 5630, 5631, 5642, 5641, 0, 0, 0, 0
1636, 5631, 5632, 5643, 5642, 0, 0, 0, 0
1637, 5632, 5633, 5644, 5643, 0, 0, 0, 0
1638, 5633, 5634, 5645, 5644, 0, 0, 0, 0
1639, 5634, 5635, 5646, 5645, 0, 0, 0, 0
1640, 5635, 5636, 5647, 5646, 0, 0, 0, 0
1641, 5636, 5637, 5648, 5647, 0, 0, 0, 0
1642, 5637, 5638, 5649, 5648, 0, 0, 0, 0
1643, 5638, 5639, 5650, 5649, 0, 0, 0, 0
1644, 5639, 5640, 5651, 5650, 0, 0, 0, 0
1645, 5640, 591, 592, 5651, 0, 0, 0, 0
1646, 554, 5641, 5652, 555, 0, 0, 0, 0
1647, 5641, 5642, 5653, 5652, 0, 0, 0, 0
1648, 5642, 5643, 5654, 5653, 0, 0, 0, 0
1649, 5643, 5644, 5655, 5654, 0, 0, 0, 0
1650, 5644, 5645, 5656, 5655, 0, 0, 0, 0
1651, 5645, 5646, 5657, 5656, 0, 0, 0, 0
1652, 5646, 5647, 5658, 5657, 0, 0, 0, 0
1653, 5647, 5648, 5659, 5658, 0, 0, 0, 0
1654, 5648, 5649, 5660, 5659, 0, 0, 0, 0
1655, 5649, 5650, 5661, 5660, 0, 0, 0, 0
1656, 5650, 5651, 5662, 5661, 0, 0, 0, 0
1657, 5651, 592, 593, 5662, 0, 0, 0, 0
1658, 555, 5652, 5663, 556, 0, 0, 0, 0
1659, 5652, 5653, 5664, 5663, 0, 0, 0, 0
1660, 5653, 5654, 5665, 5664, 0, 0, 0, 0
1661, 5654, 5655, 5666, 5665, 0, 0, 0, 0
1662, 5655, 5656, 5667, 5666, 0, 0, 0, 0
1663, 5656, 5657, 5668, 5667, 0, 0, 0, 0
1664, 5657, 5658, 5669, 5668, 0, 0, 0, 0
1665, 5658, 5659, 5670, 5669, 0, 0, 0, 0
1666, 5659, 5660, 5671, 5670, 0, 0, 0, 0
1667, 5660, 5661, 5672, 5671, 0, 0, 0, 0
1668, 5661, 5662, 5673, 5672, 0, 0, 0, 0
1669, 5662, 593, 594, 5673, 0, 0, 0, 0
1670, 556, 5663, 5674, 557, 0, 0, 0, 0
1671, 5663, 5664, 5675, 5674, 0, 0, 0, 0
1672, 5664, 5665, 5676, 5675, 0, 0, 0, 0
1673, 5665, 5666, 5677, 5676, 0, 0, 0, 0
1674, 5666, 5667, 5678, 5677, 0, 0, 0, 0
1675, 5667, 5668, 5679, 5678, 0, 0, 0, 0
1676, 5668, 5669, 5680, 5679, 0, 0, 0, 0
1677, 5669, 5670, 5681, 5680, 0, 0, 0, 0
1678, 5670, 5671, 5682, 5681, 0, 0, 0, 0
1679, 5671, 5672, 5683, 5682, 0, 0, 0, 0
1680, 5672, 5673, 5684, 5683, 0, 0, 0, 0
1681, 5673, 594, 595, 5684, 0, 0, 0, 0
1682, 557, 5674, 5685, 558, 0, 0, 0, 0
1683, 5674, 5675, 5686, 5685, 0, 0, 0, 0
1684, 5675, 5676, 5687, 5686, 0, 0, 0, 0
1685, 5676, 5677, 5688, 5687, 0, 0, 0, 0
1686, 5677, 5678, 5689, 5688, 0, 0, 0, 0
1687, 5678, 5679, 5690, 5689, 0, 0, 0, 0
1688, 5679, 5680, 5691, 5690, 0, 0, 0, 0
1689, 5680, 5681, 5692, 5691, 0, 0, 0, 0
1690, 5681, 5682, 5693, 5692, 0, 0, 0, 0
1691, 5682, 5683, 5694, 5693, 0, 0, 0, 0
1692, 5683, 5684, 5695, 5694, 0, 0, 0, 0
1693, 5684, 595, 596, 5695, 0, 0, 0, 0
1694, 558, 5685, 5696, 559, 0, 0, 0, 0
1695, 5685, 5686, 5697, 5696, 0, 0, 0, 0
1696, 5686, 5687, 5698, 5697, 0, 0, 0, 0
1697, 5687, 5688, 5699, 5698, 0, 0, 0, 0
1698, 5688, 5689, 5700, 5699, 0, 0, 0, 0
1699, 5689, 5690, 5701, 5700, 0, 0, 0, 0
1700, 5690, 5691, 5702, 5701, 0, 0, 0, 0
1701, 5691, 5692, 5703, 5702, 0, 0, 0, 0
1702, 5692, 5693, 5704, 5703, 0, 0, 0, 0
1703, 5693, 5694, 5705, 5704, 0, 0, 0, 0
1704, 5694, 5695, 5706, 5705, 0, 0, 0, 0
1705, 5695, 596, 597, 5706, 0, 0, 0, 0
1706, 559, 5696, 5707, 560, 0, 0, 0, 0
1707, 5696, 5697, 5708, 5707, 0, 0, 0, 0
1708, 5697, 5698, 5709, 5708, 0, 0, 0, 0
1709, 5698, 5699, 5710, 5709, 0, 0, 0, 0
1710, 5699, 5700, 5711, 5710, 0, 0, 0, 0
1711, 5700, 5701, 5712, 5711, 0, 0, 0, 0
1712, 5701, 5702, 5713, 5712, 0, 0, 0, 0
1713, 5702, 5703, 5714, 5713, 0, 0, 0, 0
1714, 5703, 5704, 5715, 5714, 0, 0, 0, 0
1715, 5704, 5705, 5716, 5715, 0, 0, 0, 0
1716, 5705, 5706, 5717, 5716, 0, 0, 0, 0
1717, 5706, 597, 598, 5717, 0, 0, 0, 0
1718, 560, 5707, 5718, 561, 0, 0, 0, 0
1719, 5707, 5708, 5719, 5718, 0, 0, 0, 0
1720, 5708, 5709, 5720, 5719, 0, 0, 0, 0
1721, 5709, 5710, 5721, 5720, 0, 0, 0, 0
1722, 5710, 5711, 5722, 5721, 0, 0, 0, 0
1723, 5711, 5712, 5723, 5722, 0, 0, 0, 0
1724, 5712, 5713, 5724, 5723, 0, 0, 0, 0
1725, 5713, 5714, 5725, 5724, 0, 0, 0, 0
1726, 5714, 5715, 5726, 5725, 0, 0, 0, 0
1727, 5715, 5716, 5727, 5726, 0, 0, 0, 0
1728, 5716, 5717, 5728, 5727, 0, 0, 0, 0
1729, 5717, 598, 599, 5728, 0, 0, 0, 0
1730, 561, 5718, 5729, 562, 0, 0, 0, 0
1731, 5718, 5719, 5730, 5729, 0, 0, 0, 0
1732, 5719, 5720, 5731, 5730, 0, 0, 0, 0
1733, 5720, 5721, 5732, 5731, 0, 0, 0, 0
1734, 5721, 5722, 5733, 5732, 0, 0, 0, 0
1735, 5722, 5723, 5734, 5733, 0, 0, 0, 0
1736, 5723, 5724, 5735, 5734, 0, 0, 0, 0
1737, 5724, 5725, 5736, 5735, 0, 0, 0, 0
1738, 5725, 5726, 5737, 5736, 0, 0, 0, 0
1739, 5726, 5727, 5738, 5737, 0, 0, 0, 0
1740, 5727, 5728, 5739, 5738, 0, 0, 0, 0
1741, 5728, 599, 600, 5739, 0, 0, 0, 0
1742, 562, 5729, 5740, 563, 0, 0, 0, 0
1743, 5729, 5730, 5741, 5740, 0, 0, 0, 0
1744, 5730, 5731, 5742, 5741, 0, 0, 0, 0
1745, 5731, 5732, 5743, 5742, 0, 0, 0, 0
1746, 5732, 5733, 5744, 5743, 0, 0, 0, 0
1747, 5733, 5734, 5745, 5744, 0, 0, 0, 0
1748, 5734, 5735, 5746, 5745, 0, 0, 0, 0
1749, 5735, 5736, 5747, 5746, 0, 0, 0, 0
1750, 5736, 5737, 5748, 5747, 0, 0, 0, 0
1751, 5737, 5738, 5749, 5748, 0, 0, 0, 0
1752, 5738, 5739, 5750, 5749, 0, 0, 0, 0
1753, 5739, 600, 601, 5750, 0, 0, 0, 0
1754, 563, 5740, 5751, 564, 0, 0, 0, 0
1755, 5740, 5741, 5752, 5751, 0, 0, 0, 0
1756, 5741, 5742, 5753, 5752, 0, 0, 0, 0
1757, 5742, 5743, 5754, 5753, 0, 0, 0, 0
1758, 5743, 5744, 5755, 5754, 0, 0, 0, 0
1759, 5744, 5745, 5756, 5755, 0, 0, 0, 0
1760, 5745, 5746, 5757, 5756, 0, 0, 0, 0
1761, 5746, 5747, 5758, 5757, 0, 0, 0, 0
1762, 5747, 5748, 5759, 5758, 0, 0, 0, 0
1763, 5748, 5749, 5760, 5759, 0, 0, 0, 0
1764, 5749, 5750, 5761, 5760, 0, 0, 0, 0
1765, 5750, 601, 602, 5761, 0, 0, 0, 0
1766, 564, 5751, 567, 21, 0, 0, 0, 0
1767, 5751, 5752, 568, 567, 0, 0, 0, 0
1768, 5752, 5753, 569, 568, 0, 0, 0, 0
1769, 5753, 5754, 570, 569, 0, 0, 0, 0
1770, 5754, 5755, 571, 570, 0, 0, 0, 0
1771, 5755, 5756, 572, 571, 0, 0, 0, 0
1772, 5756, 5757, 573, 572, 0, 0, 0, 0
1773, 5757, 5758, 574, 573, 0, 0, 0, 0
1774, 5758, 5759, 575, 574, 0, 0, 0, 0
1775, 5759, 5760, 576, 575, 0, 0, 0, 0
1776, 5760, 5761, 577, 576, 0, 0, 0, 0
1777, 5761, 602, 23, 577, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface27
1778, 19, 614, 5762, 565, 0, 0, 0, 0
1779, 614, 615, 5763, 5762, 0, 0, 0, 0
1780, 615, 616, 5764, 5763, 0, 0, 0, 0
1781, 616, 617, 5765, 5764, 0, 0, 0, 0
1782, 617, 25, 622, 5765, 0, 0, 0, 0
1783, 565, 5762, 5766, 566, 0, 0, 0, 0
1784, 5762, 5763, 5767, 5766, 0, 0, 0, 0
1785, 5763, 5764, 5768, 5767, 0, 0, 0, 0
1786, 5764, 5765, 5769, 5768, 0, 0, 0, 0
1787, 5765, 622, 623, 5769, 0, 0, 0, 0
1788, 566, 5766, 618, 23, 0, 0, 0, 0
1789, 5766, 5767, 619, 618, 0, 0, 0, 0
1790, 5767, 5768, 620, 619, 0, 0, 0, 0
1791, 5768, 5769, 621, 620, 0, 0, 0, 0
1792, 5769, 623, 26, 621, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface28
36419, 17, 538, 5770, 624, 0, 0, 0, 0
36420, 624, 5770, 5771, 625, 0, 0, 0, 0
36421, 625, 5771, 5772, 626, 0, 0, 0, 0
36422, 626, 5772, 5773, 627, 0, 0, 0, 0
36423, 627, 5773, 632, 27, 0, 0, 0, 0
36424, 538, 539, 5774, 5770, 0, 0, 0, 0
36425, 5770, 5774, 5775, 5771, 0, 0, 0, 0
36426, 5771, 5775, 5776, 5772, 0, 0, 0, 0
36427, 5772, 5776, 5777, 5773, 0, 0, 0, 0
36428, 5773, 5777, 633, 632, 0, 0, 0, 0
36429, 539, 21, 628, 5774, 0, 0, 0, 0
36430, 5774, 628, 629, 5775, 0, 0, 0, 0
36431, 5775, 629, 630, 5776, 0, 0, 0, 0
36432, 5776, 630, 631, 5777, 0, 0, 0, 0
36433, 5777, 631, 28, 633, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface29
36434, 17, 624, 5778, 493, 0, 0, 0, 0
36435, 624, 625, 5779, 5778, 0, 0, 0, 0
36436, 625, 626, 5780, 5779, 0, 0, 0, 0
36437, 626, 627, 5781, 5780, 0, 0, 0, 0
36438, 627, 27, 634, 5781, 0, 0, 0, 0
36439, 493, 5778, 5782, 494, 0, 0, 0, 0
36440, 5778, 5779, 5783, 5782, 0, 0, 0, 0
36441, 5779, 5780, 5784, 5783, 0, 0, 0, 0
36442, 5780, 5781, 5785, 5784, 0, 0, 0, 0
36443, 5781, 634, 635, 5785, 0, 0, 0, 0
36444, 494, 5782, 5786, 495, 0, 0, 0, 0
36445, 5782, 5783, 5787, 5786, 0, 0, 0, 0
36446, 5783, 5784, 5788, 5787, 0, 0, 0, 0
36447, 5784, 5785, 5789, 5788, 0, 0, 0, 0
36448, 5785, 635, 636, 5789, 0, 0, 0, 0
36449, 495, 5786, 5790, 496, 0, 0, 0, 0
36450, 5786, 5787, 5791, 5790, 0, 0, 0, 0
36451, 5787, 5788, 5792, 5791, 0, 0, 0, 0
36452, 5788, 5789, 5793, 5792, 0, 0, 0, 0
36453, 5789, 636, 637, 5793, 0, 0, 0, 0
36454, 496, 5790, 5794, 497, 0, 0, 0, 0
36455, 5790, 5791, 5795, 5794, 0, 0, 0, 0
36456, 5791, 5792, 5796, 5795, 0, 0, 0, 0
36457, 5792, 5793, 5797, 5796, 0, 0, 0, 0
36458, 5793, 637, 638, 5797, 0, 0, 0, 0
36459, 497, 5794, 5798, 498, 0, 0, 0, 0
36460, 5794, 5795, 5799, 5798, 0, 0, 0, 0
36461, 5795, 5796, 5800, 5799, 0, 0, 0, 0
36462, 5796, 5797, 5801, 5800, 0, 0, 0, 0
36463, 5797, 638, 639, 5801, 0, 0, 0, 0
36464, 498, 5798, 5802, 499, 0, 0, 0, 0
36465, 5798, 5799, 5803, 5802, 0, 0, 0, 0
36466, 5799, 5800, 5804, 5803, 0, 0, 0, 0
36467, 5800, 5801, 5805, 5804, 0, 0, 0, 0
36468, 5801, 639, 640, 5805, 0, 0, 0, 0
36469, 499, 5802, 5806, 500, 0, 0, 0, 0
36470, 5802, 5803, 5807, 5806, 0, 0, 0, 0
36471, 5803, 5804, 5808, 5807, 0, 0, 0, 0
36472, 5804, 5805, 5809, 5808, 0, 0, 0, 0
36473, 5805, 640, 641, 5809, 0, 0, 0, 0
36474, 500, 5806, 5810, 501, 0, 0, 0, 0
36475, 5806, 5807, 5811, 5810, 0, 0, 0, 0
36476, 5807, 5808, 5812, 5811, 0, 0, 0, 0
36477, 5808, 5809, 5813, 5812, 0, 0, 0, 0
36478, 5809, 641, 642, 5813, 0, 0, 0, 0
36479, 501, 5810, 5814, 502, 0, 0, 0, 0
36480, 5810, 5811, 5815, 5814, 0, 0, 0, 0
36481, 5811, 5812, 5816, 5815, 0, 0, 0, 0
36482, 5812, 5813, 5817, 5816, 0, 0, 0, 0
36483, 5813, 642, 643, 5817, 0, 0, 0, 0
36484, 502, 5814, 5818, 503, 0, 0, 0, 0
36485, 5814, 5815, 5819, 5818, 0, 0, 0, 0
36486, 5815, 5816, 5820, 5819, 0, 0, 0, 0
36487, 5816, 5817, 5821, 5820, 0, 0, 0, 0
36488, 5817, 643, 644, 5821, 0, 0, 0, 0
36489, 503, 5818, 614, 19, 0, 0, 0, 0
36490, 5818, 5819, 615, 614, 0, 0, 0, 0
36491, 5819, 5820, 616, 615, 0, 0, 0, 0
36492, 5820, 5821, 617, 616, 0, 0, 0, 0
36493, 5821, 644, 25, 617, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface30
1793, 21, 567, 5822, 628, 0, 0, 0, 0
1794, 628, 5822, 5823, 629, 0, 0, 0, 0
1795, 629, 5823, 5824, 630, 0, 0, 0, 0
1796, 630, 5824, 5825, 631, 0, 0, 0, 0
1797, 631, 5825, 645, 28, 0, 0, 0, 0
1798, 567, 568, 5826, 5822, 0, 0, 0, 0
1799, 5822, 5826, 5827, 5823, 0, 0, 0, 0
1800, 5823, 5827, 5828, 5824, 0, 0, 0, 0
1801, 5824, 5828, 5829, 5825, 0, 0, 0, 0
1802, 5825, 5829, 646, 645, 0, 0, 0, 0
1803, 568, 569, 5830, 5826, 0, 0, 0, 0
1804, 5826, 5830, 5831, 5827, 0, 0, 0, 0
1805, 5827, 5831, 5832, 5828, 0, 0, 0, 0
1806, 5828, 5832, 5833, 5829, 0, 0, 0, 0
1807, 5829, 5833, 647, 646, 0, 0, 0, 0
1808, 569, 570, 5834, 5830, 0, 0, 0, 0
1809, 5830, 5834, 5835, 5831, 0, 0, 0, 0
1810, 5831, 5835, 5836, 5832, 0, 0, 0, 0
1811, 5832, 5836, 5837, 5833, 0, 0, 0, 0
1812, 5833, 5837, 648, 647, 0, 0, 0, 0
1813, 570, 571, 5838, 5834, 0, 0, 0, 0
1814, 5834, 5838, 5839, 5835, 0, 0, 0, 0
1815, 5835, 5839, 5840, 5836, 0, 0, 0, 0
1816, 5836, 5840, 5841, 5837, 0, 0, 0, 0
1817, 5837, 5841, 649, 648, 0, 0, 0, 0
1818, 571, 572, 5842, 5838, 0, 0, 0, 0
1819, 5838, 5842, 5843, 5839, 0, 0, 0, 0
1820, 5839, 5843, 5844, 5840, 0, 0, 0, 0
1821, 5840, 5844, 5845, 5841, 0, 0, 0, 0
1822, 5841, 5845, 650, 649, 0, 0, 0, 0
1823, 572, 573, 5846, 5842, 0, 0, 0, 0
1824, 5842, 5846, 5847, 5843, 0, 0, 0, 0
1825, 5843, 5847, 5848, 5844, 0, 0, 0, 0
1826, 5844, 5848, 5849, 5845, 0, 0, 0, 0
1827, 5845, 5849, 651, 650, 0, 0, 0, 0
1828, 573, 574, 5850, 5846, 0, 0, 0, 0
1829, 5846, 5850, 5851, 5847, 0, 0, 0, 0
1830, 5847, 5851, 5852, 5848, 0, 0, 0, 0
1831, 5848, 5852, 5853, 5849, 0, 0, 0, 0
1832, 5849, 5853, 652, 651, 0, 0, 0, 0
1833, 574, 575, 5854, 5850, 0, 0, 0, 0
1834, 5850, 5854, 5855, 5851, 0, 0, 0, 0
1835, 5851, 5855, 5856, 5852, 0, 0, 0, 0
1836, 5852, 5856, 5857, 5853, 0, 0, 0, 0
1837, 5853, 5857, 653, 652, 0, 0, 0, 0
1838, 575, 576, 5858, 5854, 0, 0, 0, 0
1839, 5854, 5858, 5859, 5855, 0, 0, 0, 0
1840, 5855, 5859, 5860, 5856, 0, 0, 0, 0
1841, 5856, 5860, 5861, 5857, 0, 0, 0, 0
1842, 5857, 5861, 654, 653, 0, 0, 0, 0
1843, 576, 577, 5862, 5858, 0, 0, 0, 0
1844, 5858, 5862, 5863, 5859, 0, 0, 0, 0
1845, 5859, 5863, 5864, 5860, 0, 0, 0, 0
1846, 5860, 5864, 5865, 5861, 0, 0, 0, 0
1847, 5861, 5865, 655, 654, 0, 0, 0, 0
1848, 577, 23, 618, 5862, 0, 0, 0, 0
1849, 5862, 618, 619, 5863, 0, 0, 0, 0
1850, 5863, 619, 620, 5864, 0, 0, 0, 0
1851, 5864, 620, 621, 5865, 0, 0, 0, 0
1852, 5865, 621, 26, 655, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface31
36494, 27, 632, 5866, 634, 0, 0, 0, 0
36495, 632, 633, 5867, 5866, 0, 0, 0, 0
36496, 633, 28, 645, 5867, 0, 0, 0, 0
36497, 634, 5866, 5868, 635, 0, 0, 0, 0
36498, 5866, 5867, 5869, 5868, 0, 0, 0, 0
36499, 5867, 645, 646, 5869, 0, 0, 0, 0
36500, 635, 5868, 5870, 636, 0, 0, 0, 0
36501, 5868, 5869, 5871, 5870, 0, 0, 0, 0
36502, 5869, 646, 647, 5871, 0, 0, 0, 0
36503, 636, 5870, 5872, 637, 0, 0, 0, 0
36504, 5870, 5871, 5873, 5872, 0, 0, 0, 0
36505, 5871, 647, 648, 5873, 0, 0, 0, 0
36506, 637, 5872, 5874, 638, 0, 0, 0, 0
36507, 5872, 5873, 5875, 5874, 0, 0, 0, 0
36508, 5873, 648, 649, 5875, 0, 0, 0, 0
36509, 638, 5874, 5876, 639, 0, 0, 0, 0
36510, 5874, 5875, 5877, 5876, 0, 0, 0, 0
36511, 5875, 649, 650, 5877, 0, 0, 0, 0
36512, 639, 5876, 5878, 640, 0, 0, 0, 0
36513, 5876, 5877, 5879, 5878, 0, 0, 0, 0
36514, 5877, 650, 651, 5879, 0, 0, 0, 0
36515, 640, 5878, 5880, 641, 0, 0, 0, 0
36516, 5878, 5879, 5881, 5880, 0, 0, 0, 0
36517, 5879, 651, 652, 5881, 0, 0, 0, 0
36518, 641, 5880, 5882, 642, 0, 0, 0, 0
36519, 5880, 5881, 5883, 5882, 0, 0, 0, 0
36520, 5881, 652, 653, 5883, 0, 0, 0, 0
36521, 642, 5882, 5884, 643, 0, 0, 0, 0
36522, 5882, 5883, 5885, 5884, 0, 0, 0, 0
36523, 5883, 653, 654, 5885, 0, 0, 0, 0
36524, 643, 5884, 5886, 644, 0, 0, 0, 0
36525, 5884, 5885, 5887, 5886, 0, 0, 0, 0
36526, 5885, 654, 655, 5887, 0, 0, 0, 0
36527, 644, 5886, 622, 25, 0, 0, 0, 0
36528, 5886, 5887, 623, 622, 0, 0, 0, 0
36529, 5887, 655, 26, 623, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface32
1853, 25, 656, 5888, 622, 0, 0, 0, 0
1854, 656, 657, 5889, 5888, 0, 0, 0, 0
1855, 657, 658, 5890, 5889, 0, 0, 0, 0
1856, 658, 659, 5891, 5890, 0, 0, 0, 0
1857, 659, 660, 5892, 5891, 0, 0, 0, 0
1858, 660, 661, 5893, 5892, 0, 0, 0, 0
1859, 661, 662, 5894, 5893, 0, 0, 0, 0
1860, 662, 663, 5895, 5894, 0, 0, 0, 0
1861, 663, 664, 5896, 5895, 0, 0, 0, 0
1862, 664, 665, 5897, 5896, 0, 0, 0, 0
1863, 665, 666, 5898, 5897, 0, 0, 0, 0
1864, 666, 667, 5899, 5898, 0, 0, 0, 0
1865, 667, 668, 5900, 5899, 0, 0, 0, 0
1866, 668, 669, 5901, 5900, 0, 0, 0, 0
1867, 669, 670, 5902, 5901, 0, 0, 0, 0
1868, 670, 671, 5903, 5902, 0, 0, 0, 0
1869, 671, 672, 5904, 5903, 0, 0, 0, 0
1870, 672, 673, 5905, 5904, 0, 0, 0, 0
1871, 673, 674, 5906, 5905, 0, 0, 0, 0
1872, 674, 675, 5907, 5906, 0, 0, 0, 0
1873, 675, 676, 5908, 5907, 0, 0, 0, 0
1874, 676, 677, 5909, 5908, 0, 0, 0, 0
1875, 677, 678, 5910, 5909, 0, 0, 0, 0
1876, 678, 29, 702, 5910, 0, 0, 0, 0
1877, 622, 5888, 5911, 623, 0, 0, 0, 0
1878, 5888, 5889, 5912, 5911, 0, 0, 0, 0
1879, 5889, 5890, 5913, 5912, 0, 0, 0, 0
1880, 5890, 5891, 5914, 5913, 0, 0, 0, 0
1881, 5891, 5892, 5915, 5914, 0, 0, 0, 0
1882, 5892, 5893, 5916, 5915, 0, 0, 0, 0
1883, 5893, 5894, 5917, 5916, 0, 0, 0, 0
1884, 5894, 5895, 5918, 5917, 0, 0, 0, 0
1885, 5895, 5896, 5919, 5918, 0, 0, 0, 0
1886, 5896, 5897, 5920, 5919, 0, 0, 0, 0
1887, 5897, 5898, 5921, 5920, 0, 0, 0, 0
1888, 5898, 5899, 5922, 5921, 0, 0, 0, 0
1889, 5899, 5900, 5923, 5922, 0, 0, 0, 0
1890, 5900, 5901, 5924, 5923, 0, 0, 0, 0
1891, 5901, 5902, 5925, 5924, 0, 0, 0, 0
1892, 5902, 5903, 5926, 5925, 0, 0, 0, 0
1893, 5903, 5904, 5927, 5926, 0, 0, 0, 0
1894, 5904, 5905, 5928, 5927, 0, 0, 0, 0
1895, 5905, 5906, 5929, 5928, 0, 0, 0, 0
1896, 5906, 5907, 5930, 5929, 0, 0, 0, 0
1897, 5907, 5908, 5931, 5930, 0, 0, 0, 0
1898, 5908, 5909, 5932, 5931, 0, 0, 0, 0
1899, 5909, 5910, 5933, 5932, 0, 0, 0, 0
1900, 5910, 702, 703, 5933, 0, 0, 0, 0
1901, 623, 5911, 679, 26, 0, 0, 0, 0
1902, 5911, 5912, 680, 679, 0, 0, 0, 0
1903, 5912, 5913, 681, 680, 0, 0, 0, 0
1904, 5913, 5914, 682, 681, 0, 0, 0, 0
1905, 5914, 5915, 683, 682, 0, 0, 0, 0
1906, 5915, 5916, 684, 683, 0, 0, 0, 0
1907, 5916, 5917, 685, 684, 0, 0, 0, 0
1908, 5917, 5918, 686, 685, 0, 0, 0, 0
1909, 5918, 5919, 687, 686, 0, 0, 0, 0
1910, 5919, 5920, 688, 687, 0, 0, 0, 0
1911, 5920, 5921, 689, 688, 0, 0, 0, 0
1912, 5921, 5922, 690, 689, 0, 0, 0, 0
1913, 5922, 5923, 691, 690, 0, 0, 0, 0
1914, 5923, 5924, 692, 691, 0, 0, 0, 0
1915, 5924, 5925, 693, 692, 0, 0, 0, 0
1916, 5925, 5926, 694, 693, 0, 0, 0, 0
1917, 5926, 5927, 695, 694, 0, 0, 0, 0
1918, 5927, 5928, 696, 695, 0, 0, 0, 0
1919, 5928, 5929, 697, 696, 0, 0, 0, 0
1920, 5929, 5930, 698, 697, 0, 0, 0, 0
1921, 5930, 5931, 699, 698, 0, 0, 0, 0
1922, 5931, 5932, 700, 699, 0, 0, 0, 0
1923, 5932, 5933, 701, 700, 0, 0, 0, 0
1924, 5933, 703, 30, 701, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface33
36530, 27, 632, 5934, 704, 0, 0, 0, 0
36531, 704, 5934, 5935, 705, 0, 0, 0, 0
36532, 705, 5935, 5936, 706, 0, 0, 0, 0
36533, 706, 5936, 5937, 707, 0, 0, 0, 0
36534, 707, 5937, 5938, 708, 0, 0, 0, 0
36535, 708, 5938, 5939, 709, 0, 0, 0, 0
36536, 709, 5939, 5940, 710, 0, 0, 0, 0
36537, 710, 5940, 5941, 711, 0, 0, 0, 0
36538, 711, 5941, 5942, 712, 0, 0, 0, 0
36539, 712, 5942, 5943, 713, 0, 0, 0, 0
36540, 713, 5943, 5944, 714, 0, 0, 0, 0
36541, 714, 5944, 5945, 715, 0, 0, 0, 0
36542, 715, 5945, 5946, 716, 0, 0, 0, 0
36543, 716, 5946, 5947, 717, 0, 0, 0, 0
36544, 717, 5947, 5948, 718, 0, 0, 0, 0
36545, 718, 5948, 5949, 719, 0, 0, 0, 0
36546, 719, 5949, 5950, 720, 0, 0, 0, 0
36547, 720, 5950, 5951, 721, 0, 0, 0, 0
36548, 721, 5951, 5952, 722, 0, 0, 0, 0
36549, 722, 5952, 5953, 723, 0, 0, 0, 0
36550, 723, 5953, 5954, 724, 0, 0, 0, 0
36551, 724, 5954, 5955, 725, 0, 0, 0, 0
36552, 725, 5955, 5956, 726, 0, 0, 0, 0
36553, 726, 5956, 750, 31, 0, 0, 0, 0
36554, 632, 633, 5957, 5934, 0, 0, 0, 0
36555, 5934, 5957, 5958, 5935, 0, 0, 0, 0
36556, 5935, 5958, 5959, 5936, 0, 0, 0, 0
36557, 5936, 5959, 5960, 5937, 0, 0, 0, 0
36558, 5937, 5960, 5961, 5938, 0, 0, 0, 0
36559, 5938, 5961, 5962, 5939, 0, 0, 0, 0
36560, 5939, 5962, 5963, 5940, 0, 0, 0, 0
36561, 5940, 5963, 5964, 5941, 0, 0, 0, 0
36562, 5941, 5964, 5965, 5942, 0, 0, 0, 0
36563, 5942, 5965, 5966, 5943, 0, 0, 0, 0
36564, 5943, 5966, 5967, 5944, 0, 0, 0, 0
36565, 5944, 5967, 5968, 5945, 0, 0, 0, 0
36566, 5945, 5968, 5969, 5946, 0, 0, 0, 0
36567, 5946, 5969, 5970, 5947, 0, 0, 0, 0
36568, 5947, 5970, 5971, 5948, 0, 0, 0, 0
36569, 5948, 5971, 5972, 5949, 0, 0, 0, 0
36570, 5949, 5972, 5973, 5950, 0, 0, 0, 0
36571, 5950, 5973, 5974, 5951, 0, 0, 0, 0
36572, 5951, 5974, 5975, 5952, 0, 0, 0, 0
36573, 5952, 5975, 5976, 5953, 0, 0, 0, 0
36574, 5953, 5976, 5977, 5954, 0, 0, 0, 0
36575, 5954, 5977, 5978, 5955, 0, 0, 0, 0
36576, 5955, 5978, 5979, 5956, 0, 0, 0, 0
36577, 5956, 5979, 751, 750, 0, 0, 0, 0
36578, 633, 28, 727, 5957, 0, 0, 0, 0
36579, 5957, 727, 728, 5958, 0, 0, 0, 0
36580, 5958, 728, 729, 5959, 0, 0, 0, 0
36581, 5959, 729, 730, 5960, 0, 0, 0, 0
36582, 5960, 730, 731, 5961, 0, 0, 0, 0
36583, 5961, 731, 732, 5962, 0, 0, 0, 0
36584, 5962, 732, 733, 5963, 0, 0, 0, 0
36585, 5963, 733, 734, 5964, 0, 0, 0, 0
36586, 5964, 734, 735, 5965, 0, 0, 0, 0
36587, 5965, 735, 736, 5966, 0, 0, 0, 0
36588, 5966, 736, 737, 5967, 0, 0, 0, 0
36589, 5967, 737, 738, 5968, 0, 0, 0, 0
36590, 5968, 738, 739, 5969, 0, 0, 0, 0
36591, 5969, 739, 740, 5970, 0, 0, 0, 0
36592, 5970, 740, 741, 5971, 0, 0, 0, 0
36593, 5971, 741, 742, 5972, 0, 0, 0, 0
36594, 5972, 742, 743, 5973, 0, 0, 0, 0
36595, 5973, 743, 744, 5974, 0, 0, 0, 0
36596, 5974, 744, 745, 5975, 0, 0, 0, 0
36597, 5975, 745, 746, 5976, 0, 0, 0, 0
36598, 5976, 746, 747, 5977, 0, 0, 0, 0
36599, 5977, 747, 748, 5978, 0, 0, 0, 0
36600, 5978, 748, 749, 5979, 0, 0, 0, 0
36601, 5979, 749, 32, 751, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface34
36602, 27, 704, 5980, 634, 0, 0, 0, 0
36603, 704, 705, 5981, 5980, 0, 0, 0, 0
36604, 705, 706, 5982, 5981, 0, 0, 0, 0
36605, 706, 707, 5983, 5982, 0, 0, 0, 0
36606, 707, 708, 5984, 5983, 0, 0, 0, 0
36607, 708, 709, 5985, 5984, 0, 0, 0, 0
36608, 709, 710, 5986, 5985, 0, 0, 0, 0
36609, 710, 711, 5987, 5986, 0, 0, 0, 0
36610, 711, 712, 5988, 5987, 0, 0, 0, 0
36611, 712, 713, 5989, 5988, 0, 0, 0, 0
36612, 713, 714, 5990, 5989, 0, 0, 0, 0
36613, 714, 715, 5991, 5990, 0, 0, 0, 0
36614, 715, 716, 5992, 5991, 0, 0, 0, 0
36615, 716, 717, 5993, 5992, 0, 0, 0, 0
36616, 717, 718, 5994, 5993, 0, 0, 0, 0
36617, 718, 719, 5995, 5994, 0, 0, 0, 0
36618, 719, 720, 5996, 5995, 0, 0, 0, 0
36619, 720, 721, 5997, 5996, 0, 0, 0, 0
36620, 721, 722, 5998, 5997, 0, 0, 0, 0
36621, 722, 723, 5999, 5998, 0, 0, 0, 0
36622, 723, 724, 6000, 5999, 0, 0, 0, 0
36623, 724, 725, 6001, 6000, 0, 0, 0, 0
36624, 725, 726, 6002, 6001, 0, 0, 0, 0
36625, 726, 31, 752, 6002, 0, 0, 0, 0
36626, 634, 5980, 6003, 635, 0, 0, 0, 0
36627, 5980, 5981, 6004, 6003, 0, 0, 0, 0
36628, 5981, 5982, 6005, 6004, 0, 0, 0, 0
36629, 5982, 5983, 6006, 6005, 0, 0, 0, 0
36630, 5983, 5984, 6007, 6006, 0, 0, 0, 0
36631, 5984, 5985, 6008, 6007, 0, 0, 0, 0
36632, 5985, 5986, 6009, 6008, 0, 0, 0, 0
36633, 5986, 5987, 6010, 6009, 0, 0, 0, 0
36634, 5987, 5988, 6011, 6010, 0, 0, 0, 0
36635, 5988, 5989, 6012, 6011, 0, 0, 0, 0
36636, 5989, 5990, 6013, 6012, 0, 0, 0, 0
36637, 5990, 5991, 6014, 6013, 0, 0, 0, 0
36638, 5991, 5992, 6015, 6014, 0, 0, 0, 0
36639, 5992, 5993, 6016, 6015, 0, 0, 0, 0
36640, 5993, 5994, 6017, 6016, 0, 0, 0, 0
36641, 5994, 5995, 6018, 6017, 0, 0, 0, 0
36642, 5995, 5996, 6019, 6018, 0, 0, 0, 0
36643, 5996, 5997, 6020, 6019, 0, 0, 0, 0
36644, 5997, 5998, 6021, 6020, 0, 0, 0, 0
36645, 5998, 5999, 6022, 6021, 0, 0, 0, 0
36646, 5999, 6000, 6023, 6022, 0, 0, 0, 0
36647, 6000, 6001, 6024, 6023, 0, 0, 0, 0
36648, 6001, 6002, 6025, 6024, 0, 0, 0, 0
36649, 6002, 752, 753, 6025, 0, 0, 0, 0
36650, 635, 6003, 6026, 636, 0, 0, 0, 0
36651, 6003, 6004, 6027, 6026, 0, 0, 0, 0
36652, 6004, 6005, 6028, 6027, 0, 0, 0, 0
36653, 6005, 6006, 6029, 6028, 0, 0, 0, 0
36654, 6006, 6007, 6030, 6029, 0, 0, 0, 0
36655, 6007, 6008, 6031, 6030, 0, 0, 0, 0
36656, 6008, 6009, 6032, 6031, 0, 0, 0, 0
36657, 6009, 6010, 6033, 6032, 0, 0, 0, 0
36658, 6010, 6011, 6034, 6033, 0, 0, 0, 0
36659, 6011, 6012, 6035, 6034, 0, 0, 0, 0
36660, 6012, 6013, 6036, 6035, 0, 0, 0, 0
36661, 6013, 6014, 6037, 6036, 0, 0, 0, 0
36662, 6014, 6015, 6038, 6037, 0, 0, 0, 0
36663, 6015, 6016, 6039, 6038, 0, 0, 0, 0
36664, 6016, 6017, 6040, 6039, 0, 0, 0, 0
36665, 6017, 6018, 6041, 6040, 0, 0, 0, 0
36666, 6018, 6019, 6042, 6041, 0, 0, 0, 0
36667, 6019, 6020, 6043, 6042, 0, 0, 0, 0
36668, 6020, 6021, 6044, 6043, 0, 0, 0, 0
36669, 6021, 6022, 6045, 6044, 0, 0, 0, 0
36670, 6022, 6023, 6046, 6045, 0, 0, 0, 0
36671, 6023, 6024, 6047, 6046, 0, 0, 0, 0
36672, 6024, 6025, 6048, 6047, 0, 0, 0, 0
36673, 6025, 753, 754, 6048, 0, 0, 0, 0
36674, 636, 6026, 6049, 637, 0, 0, 0, 0
36675, 6026, 6027, 6050, 6049, 0, 0, 0, 0
36676, 6027, 6028, 6051, 6050, 0, 0, 0, 0
36677, 6028, 6029, 6052, 6051, 0, 0, 0, 0
36678, 6029, 6030, 6053, 6052, 0, 0, 0, 0
36679, 6030, 6031, 6054, 6053, 0, 0, 0, 0
36680, 6031, 6032, 6055, 6054, 0, 0, 0, 0
36681, 6032, 6033, 6056, 6055, 0, 0, 0, 0
36682, 6033, 6034, 6057, 6056, 0, 0, 0, 0
36683, 6034, 6035, 6058, 6057, 0, 0, 0, 0
36684, 6035, 6036, 6059, 6058, 0, 0, 0, 0
36685, 6036, 6037, 6060, 6059, 0, 0, 0, 0
36686, 6037, 6038, 6061, 6060, 0, 0, 0, 0
36687, 6038, 6039, 6062, 6061, 0, 0, 0, 0
36688, 6039, 6040, 6063, 6062, 0, 0, 0, 0
36689, 6040, 6041, 6064, 6063, 0, 0, 0, 0
36690, 6041, 6042, 6065, 6064, 0, 0, 0, 0
36691, 6042, 6043, 6066, 6065, 0, 0, 0, 0
36692, 6043, 6044, 6067, 6066, 0, 0, 0, 0
36693, 6044, 6045, 6068, 6067, 0, 0, 0, 0
36694, 6045, 6046, 6069, 6068, 0, 0, 0, 0
36695, 6046, 6047, 6070, 6069, 0, 0, 0, 0
36696, 6047, 6048, 6071, 6070, 0, 0, 0, 0
36697, 6048, 754, 755, 6071, 0, 0, 0, 0
36698, 637, 6049, 6072, 638, 0, 0, 0, 0
36699, 6049, 6050, 6073, 6072, 0, 0, 0, 0
36700, 6050, 6051, 6074, 6073, 0, 0, 0, 0
36701, 6051, 6052, 6075, 6074, 0, 0, 0, 0
36702, 6052, 6053, 6076, 6075, 0, 0, 0, 0
36703, 6053, 6054, 6077, 6076, 0, 0, 0, 0
36704, 6054, 6055, 6078, 6077, 0, 0, 0, 0
36705, 6055, 6056, 6079, 6078, 0, 0, 0, 0
36706, 6056, 6057, 6080, 6079, 0, 0, 0, 0
36707, 6057, 6058, 6081, 6080, 0, 0, 0, 0
36708, 6058, 6059, 6082, 6081, 0, 0, 0, 0
36709, 6059, 6060, 6083, 6082, 0, 0, 0, 0
36710, 6060, 6061, 6084, 6083, 0, 0, 0, 0
36711, 6061, 6062, 6085, 6084, 0, 0, 0, 0
36712, 6062, 6063, 6086, 6085, 0, 0, 0, 0
36713, 6063, 6064, 6087, 6086, 0, 0, 0, 0
36714, 6064, 6065, 6088, 6087, 0, 0, 0, 0
36715, 6065, 6066, 6089, 6088, 0, 0, 0, 0
36716, 6066, 6067, 6090, 6089, 0, 0, 0, 0
36717, 6067, 6068, 6091, 6090, 0, 0, 0, 0
36718, 6068, 6069, 6092, 6091, 0, 0, 0, 0
36719, 6069, 6070, 6093, 6092, 0, 0, 0, 0
36720, 6070, 6071, 6094, 6093, 0, 0, 0, 0
36721, 6071, 755, 756, 6094, 0, 0, 0, 0
36722, 638, 6072, 6095, 639, 0, 0, 0, 0
36723, 6072, 6073, 6096, 6095, 0, 0, 0, 0
36724, 6073, 6074, 6097, 6096, 0, 0, 0, 0
36725, 6074, 6075, 6098, 6097, 0, 0, 0, 0
36726, 6075, 6076, 6099, 6098, 0, 0, 0, 0
36727, 6076, 6077, 6100, 6099, 0, 0, 0, 0
36728, 6077, 6078, 6101, 6100, 0, 0, 0, 0
36729, 6078, 6079, 6102, 6101, 0, 0, 0, 0
36730, 6079, 6080, 6103, 6102, 0, 0, 0, 0
36731, 6080, 6081, 6104, 6103, 0, 0, 0, 0
36732, 6081, 6082, 6105, 6104, 0, 0, 0, 0
36733, 6082, 6083, 6106, 6105, 0, 0, 0, 0
36734, 6083, 6084, 6107, 6106, 0, 0, 0, 0
36735, 6084, 6085, 6108, 6107, 0, 0, 0, 0
36736, 6085, 6086, 6109, 6108, 0, 0, 0, 0
36737, 6086, 6087, 6110, 6109, 0, 0, 0, 0
36738, 6087, 6088, 6111, 6110, 0, 0, 0, 0
36739, 6088, 6089, 6112, 6111, 0, 0, 0, 0
36740, 6089, 6090, 6113, 6112, 0, 0, 0, 0
36741, 6090, 6091, 6114, 6113, 0, 0, 0, 0
36742, 6091, 6092, 6115, 6114, 0, 0, 0, 0
36743, 6092, 6093, 6116, 6115, 0, 0, 0, 0
36744, 6093, 6094, 6117, 6116, 0, 0, 0, 0
36745, 6094, 756, 757, 6117, 0, 0, 0, 0
36746, 639, 6095, 6118, 640, 0, 0, 0, 0
36747, 6095, 6096, 6119, 6118, 0, 0, 0, 0
36748, 6096, 6097, 6120, 6119, 0, 0, 0, 0
36749, 6097, 6098, 6121, 6120, 0, 0, 0, 0
36750, 6098, 6099, 6122, 6121, 0, 0, 0, 0
36751, 6099, 6100, 6123, 6122, 0, 0, 0, 0
36752, 6100, 6101, 6124, 6123, 0, 0, 0, 0
36753, 6101, 6102, 6125, 6124, 0, 0, 0, 0
36754, 6102, 6103, 6126, 6125, 0, 0, 0, 0
36755, 6103, 6104, 6127, 6126, 0, 0, 0, 0
36756, 6104, 6105, 6128, 6127, 0, 0, 0, 0
36757, 6105, 6106, 6129, 6128, 0, 0, 0, 0
36758, 6106, 6107, 6130, 6129, 0, 0, 0, 0
36759, 6107, 6108, 6131, 6130, 0, 0, 0, 0
36760, 6108, 6109, 6132, 6131, 0, 0, 0, 0
36761, 6109, 6110, 6133, 6132, 0, 0, 0, 0
36762, 6110, 6111, 6134, 6133, 0, 0, 0, 0
36763, 6111, 6112, 6135, 6134, 0, 0, 0, 0
36764, 6112, 6113, 6136, 6135, 0, 0, 0, 0
36765, 6113, 6114, 6137, 6136, 0, 0, 0, 0
36766, 6114, 6115, 6138, 6137, 0, 0, 0, 0
36767, 6115, 6116, 6139, 6138, 0, 0, 0, 0
36768, 6116, 6117, 6140, 6139, 0, 0, 0, 0
36769, 6117, 757, 758, 6140, 0, 0, 0, 0
36770, 640, 6118, 6141, 641, 0, 0, 0, 0
36771, 6118, 6119, 6142, 6141, 0, 0, 0, 0
36772, 6119, 6120, 6143, 6142, 0, 0, 0, 0
36773, 6120, 6121, 6144, 6143, 0, 0, 0, 0
36774, 6121, 6122, 6145, 6144, 0, 0, 0, 0
36775, 6122, 6123, 6146, 6145, 0, 0, 0, 0
36776, 6123, 6124, 6147, 6146, 0, 0, 0, 0
36777, 6124, 6125, 6148, 6147, 0, 0, 0, 0
36778, 6125, 6126, 6149, 6148, 0, 0, 0, 0
36779, 6126, 6127, 6150, 6149, 0, 0, 0, 0
36780, 6127, 6128, 6151, 6150, 0, 0, 0, 0
36781, 6128, 6129, 6152, 6151, 0, 0, 0, 0
36782, 6129, 6130, 6153, 6152, 0, 0, 0, 0
36783, 6130, 6131, 6154, 6153, 0, 0, 0, 0
36784, 6131, 6132, 6155, 6154, 0, 0, 0, 0
36785, 6132, 6133, 6156, 6155, 0, 0, 0, 0
36786, 6133, 6134, 6157, 6156, 0, 0, 0, 0
36787, 6134, 6135, 6158, 6157, 0, 0, 0, 0
36788, 6135, 6136, 6159, 6158, 0, 0, 0, 0
36789, 6136, 6137, 6160, 6159, 0, 0, 0, 0
36790, 6137, 6138, 6161, 6160, 0, 0, 0, 0
36791, 6138, 6139, 6162, 6161, 0, 0, 0, 0
36792, 6139, 6140, 6163, 6162, 0, 0, 0, 0
36793, 6140, 758, 759, 6163, 0, 0, 0, 0
36794, 641, 6141, 6164, 642, 0, 0, 0, 0
36795, 6141, 6142, 6165, 6164, 0, 0, 0, 0
36796, 6142, 6143, 6166, 6165, 0, 0, 0, 0
36797, 6143, 6144, 6167, 6166, 0, 0, 0, 0
36798, 6144, 6145, 6168, 6167, 0, 0, 0, 0
36799, 6145, 6146, 6169, 6168, 0, 0, 0, 0
36800, 6146, 6147, 6170, 6169, 0, 0, 0, 0
36801, 6147, 6148, 6171, 6170, 0, 0, 0, 0
36802, 6148, 6149, 6172, 6171, 0, 0, 0, 0
36803, 6149, 6150, 6173, 6172, 0, 0, 0, 0
36804, 6150, 6151, 6174, 6173, 0, 0, 0, 0
36805, 6151, 6152, 6175, 6174, 0, 0, 0, 0
36806, 6152, 6153, 6176, 6175, 0, 0, 0, 0
36807, 6153, 6154, 6177, 6176, 0, 0, 0, 0
36808, 6154, 6155, 6178, 6177, 0, 0, 0, 0
36809, 6155, 6156, 6179, 6178, 0, 0, 0, 0
36810, 6156, 6157, 6180, 6179, 0, 0, 0, 0
36811, 6157, 6158, 6181, 6180, 0, 0, 0, 0
36812, 6158, 6159, 6182, 6181, 0, 0, 0, 0
36813, 6159, 6160, 6183, 6182, 0, 0, 0, 0
36814, 6160, 6161, 6184, 6183, 0, 0, 0, 0
36815, 6161, 6162, 6185, 6184, 0, 0, 0, 0
36816, 6162, 6163, 6186, 6185, 0, 0, 0, 0
36817, 6163, 759, 760, 6186, 0, 0, 0, 0
36818, 642, 6164, 6187, 643, 0, 0, 0, 0
36819, 6164, 6165, 6188, 6187, 0, 0, 0, 0
36820, 6165, 6166, 6189, 6188, 0, 0, 0, 0
36821, 6166, 6167, 6190, 6189, 0, 0, 0, 0
36822, 6167, 6168, 6191, 6190, 0, 0, 0, 0
36823, 6168, 6169, 6192, 6191, 0, 0, 0, 0
36824, 6169, 6170, 6193, 6192, 0, 0, 0, 0
36825, 6170, 6171, 6194, 6193, 0, 0, 0, 0
36826, 6171, 6172, 6195, 6194, 0, 0, 0, 0
36827, 6172, 6173, 6196, 6195, 0, 0, 0, 0
36828, 6173, 6174, 6197, 6196, 0, 0, 0, 0
36829, 6174, 6175, 6198, 6197, 0, 0, 0, 0
36830, 6175, 6176, 6199, 6198, 0, 0, 0, 0
36831, 6176, 6177, 6200, 6199, 0, 0, 0, 0
36832, 6177, 6178, 6201, 6200, 0, 0, 0, 0
36833, 6178, 6179, 6202, 6201, 0, 0, 0, 0
36834, 6179, 6180, 6203, 6202, 0, 0, 0, 0
36835, 6180, 6181, 6204, 6203, 0, 0, 0, 0
36836, 6181, 6182, 6205, 6204, 0, 0, 0, 0
36837, 6182, 6183, 6206, 6205, 0, 0, 0, 0
36838, 6183, 6184, 6207, 6206, 0, 0, 0, 0
36839, 6184, 6185, 6208, 6207, 0, 0, 0, 0
36840, 6185, 6186, 6209, 6208, 0, 0, 0, 0
36841, 6186, 760, 761, 6209, 0, 0, 0, 0
36842, 643, 6187, 6210, 644, 0, 0, 0, 0
36843, 6187, 6188, 6211, 6210, 0, 0, 0, 0
36844, 6188, 6189, 6212, 6211, 0, 0, 0, 0
36845, 6189, 6190, 6213, 6212, 0, 0, 0, 0
36846, 6190, 6191, 6214, 6213, 0, 0, 0, 0
36847, 6191, 6192, 6215, 6214, 0, 0, 0, 0
36848, 6192, 6193, 6216, 6215, 0, 0, 0, 0
36849, 6193, 6194, 6217, 6216, 0, 0, 0, 0
36850, 6194, 6195, 6218, 6217, 0, 0, 0, 0
36851, 6195, 6196, 6219, 6218, 0, 0, 0, 0
36852, 6196, 6197, 6220, 6219, 0, 0, 0, 0
36853, 6197, 6198, 6221, 6220, 0, 0, 0, 0
36854, 6198, 6199, 6222, 6221, 0, 0, 0, 0
36855, 6199, 6200, 6223, 6222, 0, 0, 0, 0
36856, 6200, 6201, 6224, 6223, 0, 0, 0, 0
36857, 6201, 6202, 6225, 6224, 0, 0, 0, 0
36858, 6202, 6203, 6226, 6225, 0, 0, 0, 0
36859, 6203, 6204, 6227, 6226, 0, 0, 0, 0
36860, 6204, 6205, 6228, 6227, 0, 0, 0, 0
36861, 6205, 6206, 6229, 6228, 0, 0, 0, 0
36862, 6206, 6207, 6230, 6229, 0, 0, 0, 0
36863, 6207, 6208, 6231, 6230, 0, 0, 0, 0
36864, 6208, 6209, 6232, 6231, 0, 0, 0, 0
36865, 6209, 761, 762, 6232, 0, 0, 0, 0
36866, 644, 6210, 656, 25, 0, 0, 0, 0
36867, 6210, 6211, 657, 656, 0, 0, 0, 0
36868, 6211, 6212, 658, 657, 0, 0, 0, 0
36869, 6212, 6213, 659, 658, 0, 0, 0, 0
36870, 6213, 6214, 660, 659, 0, 0, 0, 0
36871, 6214, 6215, 661, 660, 0, 0, 0, 0
36872, 6215, 6216, 662, 661, 0, 0, 0, 0
36873, 6216, 6217, 663, 662, 0, 0, 0, 0
36874, 6217, 6218, 664, 663, 0, 0, 0, 0
36875, 6218, 6219, 665, 664, 0, 0, 0, 0
36876, 6219, 6220, 666, 665, 0, 0, 0, 0
36877, 6220, 6221, 667, 666, 0, 0, 0, 0
36878, 6221, 6222, 668, 667, 0, 0, 0, 0
36879, 6222, 6223, 669, 668, 0, 0, 0, 0
36880, 6223, 6224, 670, 669, 0, 0, 0, 0
36881, 6224, 6225, 671, 670, 0, 0, 0, 0
36882, 6225, 6226, 672, 671, 0, 0, 0, 0
36883, 6226, 6227, 673, 672, 0, 0, 0, 0
36884, 6227, 6228, 674, 673, 0, 0, 0, 0
36885, 6228, 6229, 675, 674, 0, 0, 0, 0
36886, 6229, 6230, 676, 675, 0, 0, 0, 0
36887, 6230, 6231, 677, 676, 0, 0, 0, 0
36888, 6231, 6232, 678, 677, 0, 0, 0, 0
36889, 6232, 762, 29, 678, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface35
1925, 28, 645, 6233, 727, 0, 0, 0, 0
1926, 727, 6233, 6234, 728, 0, 0, 0, 0
1927, 728, 6234, 6235, 729, 0, 0, 0, 0
1928, 729, 6235, 6236, 730, 0, 0, 0, 0
1929, 730, 6236, 6237, 731, 0, 0, 0, 0
1930, 731, 6237, 6238, 732, 0, 0, 0, 0
1931, 732, 6238, 6239, 733, 0, 0, 0, 0
1932, 733, 6239, 6240, 734, 0, 0, 0, 0
1933, 734, 6240, 6241, 735, 0, 0, 0, 0
1934, 735, 6241, 6242, 736, 0, 0, 0, 0
1935, 736, 6242, 6243, 737, 0, 0, 0, 0
1936, 737, 6243, 6244, 738, 0, 0, 0, 0
1937, 738, 6244, 6245, 739, 0, 0, 0, 0
1938, 739, 6245, 6246, 740, 0, 0, 0, 0
1939, 740, 6246, 6247, 741, 0, 0, 0, 0
1940, 741, 6247, 6248, 742, 0, 0, 0, 0
1941, 742, 6248, 6249, 743, 0, 0, 0, 0
1942, 743, 6249, 6250, 744, 0, 0, 0, 0
1943, 744, 6250, 6251, 745, 0, 0, 0, 0
1944, 745, 6251, 6252, 746, 0, 0, 0, 0
1945, 746, 6252, 6253, 747, 0, 0, 0, 0
1946, 747, 6253, 6254, 748, 0, 0, 0, 0
1947, 748, 6254, 6255, 749, 0, 0, 0, 0
1948, 749, 6255, 763, 32, 0, 0, 0, 0
1949, 645, 646, 6256, 6233, 0, 0, 0, 0
1950, 6233, 6256, 6257, 6234, 0, 0, 0, 0
1951, 6234, 6257, 6258, 6235, 0, 0, 0, 0
1952, 6235, 6258, 6259, 6236, 0, 0, 0, 0
1953, 6236, 6259, 6260, 6237, 0, 0, 0, 0
1954, 6237, 6260, 6261, 6238, 0, 0, 0, 0
1955, 6238, 6261, 6262, 6239, 0, 0, 0, 0
1956, 6239, 6262, 6263, 6240, 0, 0, 0, 0
1957, 6240, 6263, 6264, 6241, 0, 0, 0, 0
1958, 6241, 6264, 6265, 6242, 0, 0, 0, 0
1959, 6242, 6265, 6266, 6243, 0, 0, 0, 0
1960, 6243, 6266, 6267, 6244, 0, 0, 0, 0
1961, 6244, 6267, 6268, 6245, 0, 0, 0, 0
1962, 6245, 6268, 6269, 6246, 0, 0, 0, 0
1963, 6246, 6269, 6270, 6247, 0, 0, 0, 0
1964, 6247, 6270, 6271, 6248, 0, 0, 0, 0
1965, 6248, 6271, 6272, 6249, 0, 0, 0, 0
1966, 6249, 6272, 6273, 6250, 0, 0, 0, 0
1967, 6250, 6273, 6274, 6251, 0, 0, 0, 0
1968, 6251, 6274, 6275, 6252, 0, 0, 0, 0
1969, 6252, 6275, 6276, 6253, 0, 0, 0, 0
1970, 6253, 6276, 6277, 6254, 0, 0, 0, 0
1971, 6254, 6277, 6278, 6255, 0, 0, 0, 0
1972, 6255, 6278, 764, 763, 0, 0, 0, 0
1973, 646, 647, 6279, 6256, 0, 0, 0, 0
1974, 6256, 6279, 6280, 6257, 0, 0, 0, 0
1975, 6257, 6280, 6281, 6258, 0, 0, 0, 0
1976, 6258, 6281, 6282, 6259, 0, 0, 0, 0
1977, 6259, 6282, 6283, 6260, 0, 0, 0, 0
1978, 6260, 6283, 6284, 6261, 0, 0, 0, 0
1979, 6261, 6284, 6285, 6262, 0, 0, 0, 0
1980, 6262, 6285, 6286, 6263, 0, 0, 0, 0
1981, 6263, 6286, 6287, 6264, 0, 0, 0, 0
1982, 6264, 6287, 6288, 6265, 0, 0, 0, 0
1983, 6265, 6288, 6289, 6266, 0, 0, 0, 0
1984, 6266, 6289, 6290, 6267, 0, 0, 0, 0
1985, 6267, 6290, 6291, 6268, 0, 0, 0, 0
1986, 6268, 6291, 6292, 6269, 0, 0, 0, 0
1987, 6269, 6292, 6293, 6270, 0, 0, 0, 0
1988, 6270, 6293, 6294, 6271, 0, 0, 0, 0
1989, 6271, 6294, 6295, 6272, 0, 0, 0, 0
1990, 6272, 6295, 6296, 6273, 0, 0, 0, 0
1991, 6273, 6296, 6297, 6274, 0, 0, 0, 0
1992, 6274, 6297, 6298, 6275, 0, 0, 0, 0
1993, 6275, 6298, 6299, 6276, 0, 0, 0, 0
1994, 6276, 6299, 6300, 6277, 0, 0, 0, 0
1995, 6277, 6300, 6301, 6278, 0, 0, 0, 0
1996, 6278, 6301, 765, 764, 0, 0, 0, 0
1997, 647, 648, 6302, 6279, 0, 0, 0, 0
1998, 6279, 6302, 6303, 6280, 0, 0, 0, 0
1999, 6280, 6303, 6304, 6281, 0, 0, 0, 0
2000, 6281, 6304, 6305, 6282, 0, 0, 0, 0
2001, 6282, 6305, 6306, 6283, 0, 0, 0, 0
2002, 6283, 6306, 6307, 6284, 0, 0, 0, 0
2003, 6284, 6307, 6308, 6285, 0, 0, 0, 0
2004, 6285, 6308, 6309, 6286, 0, 0, 0, 0
2005, 6286, 6309, 6310, 6287, 0, 0, 0, 0
