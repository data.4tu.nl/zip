17567, 27875, 27898, 28427, 28404, 27876, 27899, 28428, 28405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17568, 27876, 27899, 28428, 28405, 27877, 27900, 28429, 28406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17569, 27877, 27900, 28429, 28406, 27878, 27901, 28430, 28407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17570, 27878, 27901, 28430, 28407, 27879, 27902, 28431, 28408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17571, 27879, 27902, 28431, 28408, 27880, 27903, 28432, 28409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17572, 27880, 27903, 28432, 28409, 27881, 27904, 28433, 28410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17573, 27881, 27904, 28433, 28410, 27882, 27905, 28434, 28411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17574, 27882, 27905, 28434, 28411, 27883, 27906, 28435, 28412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17575, 27883, 27906, 28435, 28412, 27884, 27907, 28436, 28413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17576, 27884, 27907, 28436, 28413, 27885, 27908, 28437, 28414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17577, 27885, 27908, 28437, 28414, 27886, 27909, 28438, 28415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17578, 27886, 27909, 28438, 28415, 27887, 27910, 28439, 28416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17579, 27887, 27910, 28439, 28416, 27888, 27911, 28440, 28417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17580, 27888, 27911, 28440, 28417, 27889, 27912, 28441, 28418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17581, 27889, 27912, 28441, 28418, 27890, 27913, 28442, 28419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17582, 27890, 27913, 28442, 28419, 27891, 27914, 28443, 28420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17583, 27891, 27914, 28443, 28420, 27892, 27915, 28444, 28421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17584, 27892, 27915, 28444, 28421, 27893, 27916, 28445, 28422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17585, 27893, 27916, 28445, 28422, 27894, 27917, 28446, 28423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17586, 27894, 27917, 28446, 28423, 27895, 27918, 28447, 28424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17587, 27895, 27918, 28447, 28424, 27896, 27919, 28448, 28425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17588, 27896, 27919, 28448, 28425, 27897, 27920, 28449, 28426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17589, 27897, 27920, 28449, 28426, 8367, 8368, 8391, 8390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17590, 6551, 6552, 6575, 6574, 27898, 27921, 28450, 28427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17591, 27898, 27921, 28450, 28427, 27899, 27922, 28451, 28428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17592, 27899, 27922, 28451, 28428, 27900, 27923, 28452, 28429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17593, 27900, 27923, 28452, 28429, 27901, 27924, 28453, 28430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17594, 27901, 27924, 28453, 28430, 27902, 27925, 28454, 28431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17595, 27902, 27925, 28454, 28431, 27903, 27926, 28455, 28432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17596, 27903, 27926, 28455, 28432, 27904, 27927, 28456, 28433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17597, 27904, 27927, 28456, 28433, 27905, 27928, 28457, 28434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17598, 27905, 27928, 28457, 28434, 27906, 27929, 28458, 28435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17599, 27906, 27929, 28458, 28435, 27907, 27930, 28459, 28436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17600, 27907, 27930, 28459, 28436, 27908, 27931, 28460, 28437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17601, 27908, 27931, 28460, 28437, 27909, 27932, 28461, 28438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17602, 27909, 27932, 28461, 28438, 27910, 27933, 28462, 28439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17603, 27910, 27933, 28462, 28439, 27911, 27934, 28463, 28440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17604, 27911, 27934, 28463, 28440, 27912, 27935, 28464, 28441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17605, 27912, 27935, 28464, 28441, 27913, 27936, 28465, 28442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17606, 27913, 27936, 28465, 28442, 27914, 27937, 28466, 28443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17607, 27914, 27937, 28466, 28443, 27915, 27938, 28467, 28444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17608, 27915, 27938, 28467, 28444, 27916, 27939, 28468, 28445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17609, 27916, 27939, 28468, 28445, 27917, 27940, 28469, 28446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17610, 27917, 27940, 28469, 28446, 27918, 27941, 28470, 28447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17611, 27918, 27941, 28470, 28447, 27919, 27942, 28471, 28448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17612, 27919, 27942, 28471, 28448, 27920, 27943, 28472, 28449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17613, 27920, 27943, 28472, 28449, 8368, 8369, 8392, 8391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17614, 6552, 6553, 6576, 6575, 27921, 27944, 28473, 28450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17615, 27921, 27944, 28473, 28450, 27922, 27945, 28474, 28451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17616, 27922, 27945, 28474, 28451, 27923, 27946, 28475, 28452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17617, 27923, 27946, 28475, 28452, 27924, 27947, 28476, 28453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17618, 27924, 27947, 28476, 28453, 27925, 27948, 28477, 28454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17619, 27925, 27948, 28477, 28454, 27926, 27949, 28478, 28455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17620, 27926, 27949, 28478, 28455, 27927, 27950, 28479, 28456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17621, 27927, 27950, 28479, 28456, 27928, 27951, 28480, 28457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17622, 27928, 27951, 28480, 28457, 27929, 27952, 28481, 28458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17623, 27929, 27952, 28481, 28458, 27930, 27953, 28482, 28459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17624, 27930, 27953, 28482, 28459, 27931, 27954, 28483, 28460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17625, 27931, 27954, 28483, 28460, 27932, 27955, 28484, 28461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17626, 27932, 27955, 28484, 28461, 27933, 27956, 28485, 28462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17627, 27933, 27956, 28485, 28462, 27934, 27957, 28486, 28463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17628, 27934, 27957, 28486, 28463, 27935, 27958, 28487, 28464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17629, 27935, 27958, 28487, 28464, 27936, 27959, 28488, 28465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17630, 27936, 27959, 28488, 28465, 27937, 27960, 28489, 28466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17631, 27937, 27960, 28489, 28466, 27938, 27961, 28490, 28467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17632, 27938, 27961, 28490, 28467, 27939, 27962, 28491, 28468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17633, 27939, 27962, 28491, 28468, 27940, 27963, 28492, 28469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17634, 27940, 27963, 28492, 28469, 27941, 27964, 28493, 28470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17635, 27941, 27964, 28493, 28470, 27942, 27965, 28494, 28471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17636, 27942, 27965, 28494, 28471, 27943, 27966, 28495, 28472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17637, 27943, 27966, 28495, 28472, 8369, 8370, 8393, 8392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17638, 6553, 832, 833, 6576, 27944, 8095, 8118, 28473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17639, 27944, 8095, 8118, 28473, 27945, 8096, 8119, 28474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17640, 27945, 8096, 8119, 28474, 27946, 8097, 8120, 28475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17641, 27946, 8097, 8120, 28475, 27947, 8098, 8121, 28476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17642, 27947, 8098, 8121, 28476, 27948, 8099, 8122, 28477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17643, 27948, 8099, 8122, 28477, 27949, 8100, 8123, 28478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17644, 27949, 8100, 8123, 28478, 27950, 8101, 8124, 28479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17645, 27950, 8101, 8124, 28479, 27951, 8102, 8125, 28480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17646, 27951, 8102, 8125, 28480, 27952, 8103, 8126, 28481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17647, 27952, 8103, 8126, 28481, 27953, 8104, 8127, 28482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17648, 27953, 8104, 8127, 28482, 27954, 8105, 8128, 28483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17649, 27954, 8105, 8128, 28483, 27955, 8106, 8129, 28484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17650, 27955, 8106, 8129, 28484, 27956, 8107, 8130, 28485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17651, 27956, 8107, 8130, 28485, 27957, 8108, 8131, 28486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17652, 27957, 8108, 8131, 28486, 27958, 8109, 8132, 28487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17653, 27958, 8109, 8132, 28487, 27959, 8110, 8133, 28488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17654, 27959, 8110, 8133, 28488, 27960, 8111, 8134, 28489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17655, 27960, 8111, 8134, 28489, 27961, 8112, 8135, 28490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17656, 27961, 8112, 8135, 28490, 27962, 8113, 8136, 28491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17657, 27962, 8113, 8136, 28491, 27963, 8114, 8137, 28492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17658, 27963, 8114, 8137, 28492, 27964, 8115, 8138, 28493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17659, 27964, 8115, 8138, 28493, 27965, 8116, 8139, 28494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17660, 27965, 8116, 8139, 28494, 27966, 8117, 8140, 28495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17661, 27966, 8117, 8140, 28495, 8370, 992, 993, 8393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17662, 822, 6554, 6577, 823, 7865, 27967, 28496, 7888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17663, 7865, 27967, 28496, 7888, 7866, 27968, 28497, 7889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17664, 7866, 27968, 28497, 7889, 7867, 27969, 28498, 7890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17665, 7867, 27969, 28498, 7890, 7868, 27970, 28499, 7891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17666, 7868, 27970, 28499, 7891, 7869, 27971, 28500, 7892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17667, 7869, 27971, 28500, 7892, 7870, 27972, 28501, 7893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17668, 7870, 27972, 28501, 7893, 7871, 27973, 28502, 7894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17669, 7871, 27973, 28502, 7894, 7872, 27974, 28503, 7895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17670, 7872, 27974, 28503, 7895, 7873, 27975, 28504, 7896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17671, 7873, 27975, 28504, 7896, 7874, 27976, 28505, 7897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17672, 7874, 27976, 28505, 7897, 7875, 27977, 28506, 7898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17673, 7875, 27977, 28506, 7898, 7876, 27978, 28507, 7899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17674, 7876, 27978, 28507, 7899, 7877, 27979, 28508, 7900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17675, 7877, 27979, 28508, 7900, 7878, 27980, 28509, 7901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17676, 7878, 27980, 28509, 7901, 7879, 27981, 28510, 7902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17677, 7879, 27981, 28510, 7902, 7880, 27982, 28511, 7903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17678, 7880, 27982, 28511, 7903, 7881, 27983, 28512, 7904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17679, 7881, 27983, 28512, 7904, 7882, 27984, 28513, 7905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17680, 7882, 27984, 28513, 7905, 7883, 27985, 28514, 7906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17681, 7883, 27985, 28514, 7906, 7884, 27986, 28515, 7907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17682, 7884, 27986, 28515, 7907, 7885, 27987, 28516, 7908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17683, 7885, 27987, 28516, 7908, 7886, 27988, 28517, 7909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17684, 7886, 27988, 28517, 7909, 7887, 27989, 28518, 7910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17685, 7887, 27989, 28518, 7910, 982, 8371, 8394, 983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17686, 6554, 6555, 6578, 6577, 27967, 27990, 28519, 28496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17687, 27967, 27990, 28519, 28496, 27968, 27991, 28520, 28497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17688, 27968, 27991, 28520, 28497, 27969, 27992, 28521, 28498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17689, 27969, 27992, 28521, 28498, 27970, 27993, 28522, 28499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17690, 27970, 27993, 28522, 28499, 27971, 27994, 28523, 28500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17691, 27971, 27994, 28523, 28500, 27972, 27995, 28524, 28501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17692, 27972, 27995, 28524, 28501, 27973, 27996, 28525, 28502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17693, 27973, 27996, 28525, 28502, 27974, 27997, 28526, 28503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17694, 27974, 27997, 28526, 28503, 27975, 27998, 28527, 28504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17695, 27975, 27998, 28527, 28504, 27976, 27999, 28528, 28505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17696, 27976, 27999, 28528, 28505, 27977, 28000, 28529, 28506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17697, 27977, 28000, 28529, 28506, 27978, 28001, 28530, 28507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17698, 27978, 28001, 28530, 28507, 27979, 28002, 28531, 28508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17699, 27979, 28002, 28531, 28508, 27980, 28003, 28532, 28509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17700, 27980, 28003, 28532, 28509, 27981, 28004, 28533, 28510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17701, 27981, 28004, 28533, 28510, 27982, 28005, 28534, 28511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17702, 27982, 28005, 28534, 28511, 27983, 28006, 28535, 28512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17703, 27983, 28006, 28535, 28512, 27984, 28007, 28536, 28513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17704, 27984, 28007, 28536, 28513, 27985, 28008, 28537, 28514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17705, 27985, 28008, 28537, 28514, 27986, 28009, 28538, 28515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17706, 27986, 28009, 28538, 28515, 27987, 28010, 28539, 28516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17707, 27987, 28010, 28539, 28516, 27988, 28011, 28540, 28517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17708, 27988, 28011, 28540, 28517, 27989, 28012, 28541, 28518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17709, 27989, 28012, 28541, 28518, 8371, 8372, 8395, 8394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17710, 6555, 6556, 6579, 6578, 27990, 28013, 28542, 28519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17711, 27990, 28013, 28542, 28519, 27991, 28014, 28543, 28520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17712, 27991, 28014, 28543, 28520, 27992, 28015, 28544, 28521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17713, 27992, 28015, 28544, 28521, 27993, 28016, 28545, 28522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17714, 27993, 28016, 28545, 28522, 27994, 28017, 28546, 28523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17715, 27994, 28017, 28546, 28523, 27995, 28018, 28547, 28524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17716, 27995, 28018, 28547, 28524, 27996, 28019, 28548, 28525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17717, 27996, 28019, 28548, 28525, 27997, 28020, 28549, 28526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17718, 27997, 28020, 28549, 28526, 27998, 28021, 28550, 28527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17719, 27998, 28021, 28550, 28527, 27999, 28022, 28551, 28528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17720, 27999, 28022, 28551, 28528, 28000, 28023, 28552, 28529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17721, 28000, 28023, 28552, 28529, 28001, 28024, 28553, 28530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17722, 28001, 28024, 28553, 28530, 28002, 28025, 28554, 28531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17723, 28002, 28025, 28554, 28531, 28003, 28026, 28555, 28532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17724, 28003, 28026, 28555, 28532, 28004, 28027, 28556, 28533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17725, 28004, 28027, 28556, 28533, 28005, 28028, 28557, 28534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17726, 28005, 28028, 28557, 28534, 28006, 28029, 28558, 28535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17727, 28006, 28029, 28558, 28535, 28007, 28030, 28559, 28536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17728, 28007, 28030, 28559, 28536, 28008, 28031, 28560, 28537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17729, 28008, 28031, 28560, 28537, 28009, 28032, 28561, 28538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17730, 28009, 28032, 28561, 28538, 28010, 28033, 28562, 28539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17731, 28010, 28033, 28562, 28539, 28011, 28034, 28563, 28540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17732, 28011, 28034, 28563, 28540, 28012, 28035, 28564, 28541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17733, 28012, 28035, 28564, 28541, 8372, 8373, 8396, 8395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17734, 6556, 6557, 6580, 6579, 28013, 28036, 28565, 28542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17735, 28013, 28036, 28565, 28542, 28014, 28037, 28566, 28543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17736, 28014, 28037, 28566, 28543, 28015, 28038, 28567, 28544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17737, 28015, 28038, 28567, 28544, 28016, 28039, 28568, 28545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17738, 28016, 28039, 28568, 28545, 28017, 28040, 28569, 28546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17739, 28017, 28040, 28569, 28546, 28018, 28041, 28570, 28547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17740, 28018, 28041, 28570, 28547, 28019, 28042, 28571, 28548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17741, 28019, 28042, 28571, 28548, 28020, 28043, 28572, 28549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17742, 28020, 28043, 28572, 28549, 28021, 28044, 28573, 28550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17743, 28021, 28044, 28573, 28550, 28022, 28045, 28574, 28551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17744, 28022, 28045, 28574, 28551, 28023, 28046, 28575, 28552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17745, 28023, 28046, 28575, 28552, 28024, 28047, 28576, 28553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17746, 28024, 28047, 28576, 28553, 28025, 28048, 28577, 28554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17747, 28025, 28048, 28577, 28554, 28026, 28049, 28578, 28555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17748, 28026, 28049, 28578, 28555, 28027, 28050, 28579, 28556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17749, 28027, 28050, 28579, 28556, 28028, 28051, 28580, 28557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17750, 28028, 28051, 28580, 28557, 28029, 28052, 28581, 28558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17751, 28029, 28052, 28581, 28558, 28030, 28053, 28582, 28559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17752, 28030, 28053, 28582, 28559, 28031, 28054, 28583, 28560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17753, 28031, 28054, 28583, 28560, 28032, 28055, 28584, 28561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17754, 28032, 28055, 28584, 28561, 28033, 28056, 28585, 28562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17755, 28033, 28056, 28585, 28562, 28034, 28057, 28586, 28563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17756, 28034, 28057, 28586, 28563, 28035, 28058, 28587, 28564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17757, 28035, 28058, 28587, 28564, 8373, 8374, 8397, 8396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17758, 6557, 6558, 6581, 6580, 28036, 28059, 28588, 28565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17759, 28036, 28059, 28588, 28565, 28037, 28060, 28589, 28566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17760, 28037, 28060, 28589, 28566, 28038, 28061, 28590, 28567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17761, 28038, 28061, 28590, 28567, 28039, 28062, 28591, 28568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17762, 28039, 28062, 28591, 28568, 28040, 28063, 28592, 28569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17763, 28040, 28063, 28592, 28569, 28041, 28064, 28593, 28570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17764, 28041, 28064, 28593, 28570, 28042, 28065, 28594, 28571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17765, 28042, 28065, 28594, 28571, 28043, 28066, 28595, 28572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17766, 28043, 28066, 28595, 28572, 28044, 28067, 28596, 28573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17767, 28044, 28067, 28596, 28573, 28045, 28068, 28597, 28574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17768, 28045, 28068, 28597, 28574, 28046, 28069, 28598, 28575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17769, 28046, 28069, 28598, 28575, 28047, 28070, 28599, 28576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17770, 28047, 28070, 28599, 28576, 28048, 28071, 28600, 28577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17771, 28048, 28071, 28600, 28577, 28049, 28072, 28601, 28578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17772, 28049, 28072, 28601, 28578, 28050, 28073, 28602, 28579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17773, 28050, 28073, 28602, 28579, 28051, 28074, 28603, 28580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17774, 28051, 28074, 28603, 28580, 28052, 28075, 28604, 28581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17775, 28052, 28075, 28604, 28581, 28053, 28076, 28605, 28582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17776, 28053, 28076, 28605, 28582, 28054, 28077, 28606, 28583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17777, 28054, 28077, 28606, 28583, 28055, 28078, 28607, 28584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17778, 28055, 28078, 28607, 28584, 28056, 28079, 28608, 28585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17779, 28056, 28079, 28608, 28585, 28057, 28080, 28609, 28586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17780, 28057, 28080, 28609, 28586, 28058, 28081, 28610, 28587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17781, 28058, 28081, 28610, 28587, 8374, 8375, 8398, 8397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17782, 6558, 6559, 6582, 6581, 28059, 28082, 28611, 28588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17783, 28059, 28082, 28611, 28588, 28060, 28083, 28612, 28589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17784, 28060, 28083, 28612, 28589, 28061, 28084, 28613, 28590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17785, 28061, 28084, 28613, 28590, 28062, 28085, 28614, 28591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17786, 28062, 28085, 28614, 28591, 28063, 28086, 28615, 28592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17787, 28063, 28086, 28615, 28592, 28064, 28087, 28616, 28593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17788, 28064, 28087, 28616, 28593, 28065, 28088, 28617, 28594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17789, 28065, 28088, 28617, 28594, 28066, 28089, 28618, 28595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17790, 28066, 28089, 28618, 28595, 28067, 28090, 28619, 28596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17791, 28067, 28090, 28619, 28596, 28068, 28091, 28620, 28597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17792, 28068, 28091, 28620, 28597, 28069, 28092, 28621, 28598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17793, 28069, 28092, 28621, 28598, 28070, 28093, 28622, 28599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17794, 28070, 28093, 28622, 28599, 28071, 28094, 28623, 28600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17795, 28071, 28094, 28623, 28600, 28072, 28095, 28624, 28601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17796, 28072, 28095, 28624, 28601, 28073, 28096, 28625, 28602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17797, 28073, 28096, 28625, 28602, 28074, 28097, 28626, 28603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17798, 28074, 28097, 28626, 28603, 28075, 28098, 28627, 28604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17799, 28075, 28098, 28627, 28604, 28076, 28099, 28628, 28605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17800, 28076, 28099, 28628, 28605, 28077, 28100, 28629, 28606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17801, 28077, 28100, 28629, 28606, 28078, 28101, 28630, 28607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17802, 28078, 28101, 28630, 28607, 28079, 28102, 28631, 28608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17803, 28079, 28102, 28631, 28608, 28080, 28103, 28632, 28609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17804, 28080, 28103, 28632, 28609, 28081, 28104, 28633, 28610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17805, 28081, 28104, 28633, 28610, 8375, 8376, 8399, 8398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17806, 6559, 6560, 6583, 6582, 28082, 28105, 28634, 28611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17807, 28082, 28105, 28634, 28611, 28083, 28106, 28635, 28612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17808, 28083, 28106, 28635, 28612, 28084, 28107, 28636, 28613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17809, 28084, 28107, 28636, 28613, 28085, 28108, 28637, 28614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17810, 28085, 28108, 28637, 28614, 28086, 28109, 28638, 28615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17811, 28086, 28109, 28638, 28615, 28087, 28110, 28639, 28616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17812, 28087, 28110, 28639, 28616, 28088, 28111, 28640, 28617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17813, 28088, 28111, 28640, 28617, 28089, 28112, 28641, 28618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17814, 28089, 28112, 28641, 28618, 28090, 28113, 28642, 28619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17815, 28090, 28113, 28642, 28619, 28091, 28114, 28643, 28620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17816, 28091, 28114, 28643, 28620, 28092, 28115, 28644, 28621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17817, 28092, 28115, 28644, 28621, 28093, 28116, 28645, 28622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17818, 28093, 28116, 28645, 28622, 28094, 28117, 28646, 28623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17819, 28094, 28117, 28646, 28623, 28095, 28118, 28647, 28624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17820, 28095, 28118, 28647, 28624, 28096, 28119, 28648, 28625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17821, 28096, 28119, 28648, 28625, 28097, 28120, 28649, 28626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17822, 28097, 28120, 28649, 28626, 28098, 28121, 28650, 28627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17823, 28098, 28121, 28650, 28627, 28099, 28122, 28651, 28628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17824, 28099, 28122, 28651, 28628, 28100, 28123, 28652, 28629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17825, 28100, 28123, 28652, 28629, 28101, 28124, 28653, 28630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17826, 28101, 28124, 28653, 28630, 28102, 28125, 28654, 28631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17827, 28102, 28125, 28654, 28631, 28103, 28126, 28655, 28632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17828, 28103, 28126, 28655, 28632, 28104, 28127, 28656, 28633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17829, 28104, 28127, 28656, 28633, 8376, 8377, 8400, 8399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17830, 6560, 6561, 6584, 6583, 28105, 28128, 28657, 28634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17831, 28105, 28128, 28657, 28634, 28106, 28129, 28658, 28635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17832, 28106, 28129, 28658, 28635, 28107, 28130, 28659, 28636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17833, 28107, 28130, 28659, 28636, 28108, 28131, 28660, 28637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17834, 28108, 28131, 28660, 28637, 28109, 28132, 28661, 28638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17835, 28109, 28132, 28661, 28638, 28110, 28133, 28662, 28639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17836, 28110, 28133, 28662, 28639, 28111, 28134, 28663, 28640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17837, 28111, 28134, 28663, 28640, 28112, 28135, 28664, 28641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17838, 28112, 28135, 28664, 28641, 28113, 28136, 28665, 28642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17839, 28113, 28136, 28665, 28642, 28114, 28137, 28666, 28643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17840, 28114, 28137, 28666, 28643, 28115, 28138, 28667, 28644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17841, 28115, 28138, 28667, 28644, 28116, 28139, 28668, 28645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17842, 28116, 28139, 28668, 28645, 28117, 28140, 28669, 28646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17843, 28117, 28140, 28669, 28646, 28118, 28141, 28670, 28647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17844, 28118, 28141, 28670, 28647, 28119, 28142, 28671, 28648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17845, 28119, 28142, 28671, 28648, 28120, 28143, 28672, 28649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17846, 28120, 28143, 28672, 28649, 28121, 28144, 28673, 28650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17847, 28121, 28144, 28673, 28650, 28122, 28145, 28674, 28651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17848, 28122, 28145, 28674, 28651, 28123, 28146, 28675, 28652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17849, 28123, 28146, 28675, 28652, 28124, 28147, 28676, 28653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17850, 28124, 28147, 28676, 28653, 28125, 28148, 28677, 28654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17851, 28125, 28148, 28677, 28654, 28126, 28149, 28678, 28655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17852, 28126, 28149, 28678, 28655, 28127, 28150, 28679, 28656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17853, 28127, 28150, 28679, 28656, 8377, 8378, 8401, 8400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17854, 6561, 6562, 6585, 6584, 28128, 28151, 28680, 28657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17855, 28128, 28151, 28680, 28657, 28129, 28152, 28681, 28658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17856, 28129, 28152, 28681, 28658, 28130, 28153, 28682, 28659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17857, 28130, 28153, 28682, 28659, 28131, 28154, 28683, 28660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17858, 28131, 28154, 28683, 28660, 28132, 28155, 28684, 28661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17859, 28132, 28155, 28684, 28661, 28133, 28156, 28685, 28662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17860, 28133, 28156, 28685, 28662, 28134, 28157, 28686, 28663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17861, 28134, 28157, 28686, 28663, 28135, 28158, 28687, 28664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17862, 28135, 28158, 28687, 28664, 28136, 28159, 28688, 28665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17863, 28136, 28159, 28688, 28665, 28137, 28160, 28689, 28666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17864, 28137, 28160, 28689, 28666, 28138, 28161, 28690, 28667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17865, 28138, 28161, 28690, 28667, 28139, 28162, 28691, 28668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17866, 28139, 28162, 28691, 28668, 28140, 28163, 28692, 28669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17867, 28140, 28163, 28692, 28669, 28141, 28164, 28693, 28670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17868, 28141, 28164, 28693, 28670, 28142, 28165, 28694, 28671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17869, 28142, 28165, 28694, 28671, 28143, 28166, 28695, 28672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17870, 28143, 28166, 28695, 28672, 28144, 28167, 28696, 28673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17871, 28144, 28167, 28696, 28673, 28145, 28168, 28697, 28674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17872, 28145, 28168, 28697, 28674, 28146, 28169, 28698, 28675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17873, 28146, 28169, 28698, 28675, 28147, 28170, 28699, 28676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17874, 28147, 28170, 28699, 28676, 28148, 28171, 28700, 28677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17875, 28148, 28171, 28700, 28677, 28149, 28172, 28701, 28678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17876, 28149, 28172, 28701, 28678, 28150, 28173, 28702, 28679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17877, 28150, 28173, 28702, 28679, 8378, 8379, 8402, 8401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17878, 6562, 6563, 6586, 6585, 28151, 28174, 28703, 28680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17879, 28151, 28174, 28703, 28680, 28152, 28175, 28704, 28681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17880, 28152, 28175, 28704, 28681, 28153, 28176, 28705, 28682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17881, 28153, 28176, 28705, 28682, 28154, 28177, 28706, 28683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17882, 28154, 28177, 28706, 28683, 28155, 28178, 28707, 28684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17883, 28155, 28178, 28707, 28684, 28156, 28179, 28708, 28685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17884, 28156, 28179, 28708, 28685, 28157, 28180, 28709, 28686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17885, 28157, 28180, 28709, 28686, 28158, 28181, 28710, 28687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17886, 28158, 28181, 28710, 28687, 28159, 28182, 28711, 28688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17887, 28159, 28182, 28711, 28688, 28160, 28183, 28712, 28689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17888, 28160, 28183, 28712, 28689, 28161, 28184, 28713, 28690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17889, 28161, 28184, 28713, 28690, 28162, 28185, 28714, 28691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17890, 28162, 28185, 28714, 28691, 28163, 28186, 28715, 28692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17891, 28163, 28186, 28715, 28692, 28164, 28187, 28716, 28693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17892, 28164, 28187, 28716, 28693, 28165, 28188, 28717, 28694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17893, 28165, 28188, 28717, 28694, 28166, 28189, 28718, 28695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17894, 28166, 28189, 28718, 28695, 28167, 28190, 28719, 28696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17895, 28167, 28190, 28719, 28696, 28168, 28191, 28720, 28697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17896, 28168, 28191, 28720, 28697, 28169, 28192, 28721, 28698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17897, 28169, 28192, 28721, 28698, 28170, 28193, 28722, 28699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17898, 28170, 28193, 28722, 28699, 28171, 28194, 28723, 28700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17899, 28171, 28194, 28723, 28700, 28172, 28195, 28724, 28701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17900, 28172, 28195, 28724, 28701, 28173, 28196, 28725, 28702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17901, 28173, 28196, 28725, 28702, 8379, 8380, 8403, 8402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17902, 6563, 6564, 6587, 6586, 28174, 28197, 28726, 28703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17903, 28174, 28197, 28726, 28703, 28175, 28198, 28727, 28704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17904, 28175, 28198, 28727, 28704, 28176, 28199, 28728, 28705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17905, 28176, 28199, 28728, 28705, 28177, 28200, 28729, 28706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17906, 28177, 28200, 28729, 28706, 28178, 28201, 28730, 28707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17907, 28178, 28201, 28730, 28707, 28179, 28202, 28731, 28708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17908, 28179, 28202, 28731, 28708, 28180, 28203, 28732, 28709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17909, 28180, 28203, 28732, 28709, 28181, 28204, 28733, 28710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17910, 28181, 28204, 28733, 28710, 28182, 28205, 28734, 28711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17911, 28182, 28205, 28734, 28711, 28183, 28206, 28735, 28712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17912, 28183, 28206, 28735, 28712, 28184, 28207, 28736, 28713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17913, 28184, 28207, 28736, 28713, 28185, 28208, 28737, 28714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17914, 28185, 28208, 28737, 28714, 28186, 28209, 28738, 28715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17915, 28186, 28209, 28738, 28715, 28187, 28210, 28739, 28716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17916, 28187, 28210, 28739, 28716, 28188, 28211, 28740, 28717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17917, 28188, 28211, 28740, 28717, 28189, 28212, 28741, 28718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17918, 28189, 28212, 28741, 28718, 28190, 28213, 28742, 28719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17919, 28190, 28213, 28742, 28719, 28191, 28214, 28743, 28720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17920, 28191, 28214, 28743, 28720, 28192, 28215, 28744, 28721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17921, 28192, 28215, 28744, 28721, 28193, 28216, 28745, 28722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17922, 28193, 28216, 28745, 28722, 28194, 28217, 28746, 28723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17923, 28194, 28217, 28746, 28723, 28195, 28218, 28747, 28724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17924, 28195, 28218, 28747, 28724, 28196, 28219, 28748, 28725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17925, 28196, 28219, 28748, 28725, 8380, 8381, 8404, 8403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17926, 6564, 6565, 6588, 6587, 28197, 28220, 28749, 28726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17927, 28197, 28220, 28749, 28726, 28198, 28221, 28750, 28727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17928, 28198, 28221, 28750, 28727, 28199, 28222, 28751, 28728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17929, 28199, 28222, 28751, 28728, 28200, 28223, 28752, 28729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17930, 28200, 28223, 28752, 28729, 28201, 28224, 28753, 28730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17931, 28201, 28224, 28753, 28730, 28202, 28225, 28754, 28731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17932, 28202, 28225, 28754, 28731, 28203, 28226, 28755, 28732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17933, 28203, 28226, 28755, 28732, 28204, 28227, 28756, 28733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17934, 28204, 28227, 28756, 28733, 28205, 28228, 28757, 28734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17935, 28205, 28228, 28757, 28734, 28206, 28229, 28758, 28735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17936, 28206, 28229, 28758, 28735, 28207, 28230, 28759, 28736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17937, 28207, 28230, 28759, 28736, 28208, 28231, 28760, 28737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17938, 28208, 28231, 28760, 28737, 28209, 28232, 28761, 28738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17939, 28209, 28232, 28761, 28738, 28210, 28233, 28762, 28739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17940, 28210, 28233, 28762, 28739, 28211, 28234, 28763, 28740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17941, 28211, 28234, 28763, 28740, 28212, 28235, 28764, 28741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17942, 28212, 28235, 28764, 28741, 28213, 28236, 28765, 28742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17943, 28213, 28236, 28765, 28742, 28214, 28237, 28766, 28743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17944, 28214, 28237, 28766, 28743, 28215, 28238, 28767, 28744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17945, 28215, 28238, 28767, 28744, 28216, 28239, 28768, 28745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17946, 28216, 28239, 28768, 28745, 28217, 28240, 28769, 28746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17947, 28217, 28240, 28769, 28746, 28218, 28241, 28770, 28747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17948, 28218, 28241, 28770, 28747, 28219, 28242, 28771, 28748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17949, 28219, 28242, 28771, 28748, 8381, 8382, 8405, 8404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17950, 6565, 6566, 6589, 6588, 28220, 28243, 28772, 28749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17951, 28220, 28243, 28772, 28749, 28221, 28244, 28773, 28750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17952, 28221, 28244, 28773, 28750, 28222, 28245, 28774, 28751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17953, 28222, 28245, 28774, 28751, 28223, 28246, 28775, 28752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17954, 28223, 28246, 28775, 28752, 28224, 28247, 28776, 28753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17955, 28224, 28247, 28776, 28753, 28225, 28248, 28777, 28754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17956, 28225, 28248, 28777, 28754, 28226, 28249, 28778, 28755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17957, 28226, 28249, 28778, 28755, 28227, 28250, 28779, 28756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17958, 28227, 28250, 28779, 28756, 28228, 28251, 28780, 28757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17959, 28228, 28251, 28780, 28757, 28229, 28252, 28781, 28758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17960, 28229, 28252, 28781, 28758, 28230, 28253, 28782, 28759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17961, 28230, 28253, 28782, 28759, 28231, 28254, 28783, 28760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17962, 28231, 28254, 28783, 28760, 28232, 28255, 28784, 28761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17963, 28232, 28255, 28784, 28761, 28233, 28256, 28785, 28762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17964, 28233, 28256, 28785, 28762, 28234, 28257, 28786, 28763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17965, 28234, 28257, 28786, 28763, 28235, 28258, 28787, 28764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17966, 28235, 28258, 28787, 28764, 28236, 28259, 28788, 28765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17967, 28236, 28259, 28788, 28765, 28237, 28260, 28789, 28766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17968, 28237, 28260, 28789, 28766, 28238, 28261, 28790, 28767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17969, 28238, 28261, 28790, 28767, 28239, 28262, 28791, 28768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17970, 28239, 28262, 28791, 28768, 28240, 28263, 28792, 28769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17971, 28240, 28263, 28792, 28769, 28241, 28264, 28793, 28770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17972, 28241, 28264, 28793, 28770, 28242, 28265, 28794, 28771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17973, 28242, 28265, 28794, 28771, 8382, 8383, 8406, 8405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17974, 6566, 6567, 6590, 6589, 28243, 28266, 28795, 28772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17975, 28243, 28266, 28795, 28772, 28244, 28267, 28796, 28773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17976, 28244, 28267, 28796, 28773, 28245, 28268, 28797, 28774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17977, 28245, 28268, 28797, 28774, 28246, 28269, 28798, 28775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17978, 28246, 28269, 28798, 28775, 28247, 28270, 28799, 28776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17979, 28247, 28270, 28799, 28776, 28248, 28271, 28800, 28777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17980, 28248, 28271, 28800, 28777, 28249, 28272, 28801, 28778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17981, 28249, 28272, 28801, 28778, 28250, 28273, 28802, 28779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17982, 28250, 28273, 28802, 28779, 28251, 28274, 28803, 28780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17983, 28251, 28274, 28803, 28780, 28252, 28275, 28804, 28781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17984, 28252, 28275, 28804, 28781, 28253, 28276, 28805, 28782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17985, 28253, 28276, 28805, 28782, 28254, 28277, 28806, 28783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17986, 28254, 28277, 28806, 28783, 28255, 28278, 28807, 28784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17987, 28255, 28278, 28807, 28784, 28256, 28279, 28808, 28785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17988, 28256, 28279, 28808, 28785, 28257, 28280, 28809, 28786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17989, 28257, 28280, 28809, 28786, 28258, 28281, 28810, 28787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17990, 28258, 28281, 28810, 28787, 28259, 28282, 28811, 28788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17991, 28259, 28282, 28811, 28788, 28260, 28283, 28812, 28789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17992, 28260, 28283, 28812, 28789, 28261, 28284, 28813, 28790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17993, 28261, 28284, 28813, 28790, 28262, 28285, 28814, 28791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17994, 28262, 28285, 28814, 28791, 28263, 28286, 28815, 28792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17995, 28263, 28286, 28815, 28792, 28264, 28287, 28816, 28793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17996, 28264, 28287, 28816, 28793, 28265, 28288, 28817, 28794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17997, 28265, 28288, 28817, 28794, 8383, 8384, 8407, 8406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17998, 6567, 6568, 6591, 6590, 28266, 28289, 28818, 28795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
17999, 28266, 28289, 28818, 28795, 28267, 28290, 28819, 28796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18000, 28267, 28290, 28819, 28796, 28268, 28291, 28820, 28797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18001, 28268, 28291, 28820, 28797, 28269, 28292, 28821, 28798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18002, 28269, 28292, 28821, 28798, 28270, 28293, 28822, 28799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18003, 28270, 28293, 28822, 28799, 28271, 28294, 28823, 28800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18004, 28271, 28294, 28823, 28800, 28272, 28295, 28824, 28801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18005, 28272, 28295, 28824, 28801, 28273, 28296, 28825, 28802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18006, 28273, 28296, 28825, 28802, 28274, 28297, 28826, 28803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18007, 28274, 28297, 28826, 28803, 28275, 28298, 28827, 28804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18008, 28275, 28298, 28827, 28804, 28276, 28299, 28828, 28805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18009, 28276, 28299, 28828, 28805, 28277, 28300, 28829, 28806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18010, 28277, 28300, 28829, 28806, 28278, 28301, 28830, 28807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18011, 28278, 28301, 28830, 28807, 28279, 28302, 28831, 28808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18012, 28279, 28302, 28831, 28808, 28280, 28303, 28832, 28809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18013, 28280, 28303, 28832, 28809, 28281, 28304, 28833, 28810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18014, 28281, 28304, 28833, 28810, 28282, 28305, 28834, 28811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18015, 28282, 28305, 28834, 28811, 28283, 28306, 28835, 28812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18016, 28283, 28306, 28835, 28812, 28284, 28307, 28836, 28813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18017, 28284, 28307, 28836, 28813, 28285, 28308, 28837, 28814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18018, 28285, 28308, 28837, 28814, 28286, 28309, 28838, 28815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18019, 28286, 28309, 28838, 28815, 28287, 28310, 28839, 28816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18020, 28287, 28310, 28839, 28816, 28288, 28311, 28840, 28817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18021, 28288, 28311, 28840, 28817, 8384, 8385, 8408, 8407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18022, 6568, 6569, 6592, 6591, 28289, 28312, 28841, 28818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18023, 28289, 28312, 28841, 28818, 28290, 28313, 28842, 28819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18024, 28290, 28313, 28842, 28819, 28291, 28314, 28843, 28820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18025, 28291, 28314, 28843, 28820, 28292, 28315, 28844, 28821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18026, 28292, 28315, 28844, 28821, 28293, 28316, 28845, 28822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18027, 28293, 28316, 28845, 28822, 28294, 28317, 28846, 28823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18028, 28294, 28317, 28846, 28823, 28295, 28318, 28847, 28824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18029, 28295, 28318, 28847, 28824, 28296, 28319, 28848, 28825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18030, 28296, 28319, 28848, 28825, 28297, 28320, 28849, 28826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18031, 28297, 28320, 28849, 28826, 28298, 28321, 28850, 28827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18032, 28298, 28321, 28850, 28827, 28299, 28322, 28851, 28828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18033, 28299, 28322, 28851, 28828, 28300, 28323, 28852, 28829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18034, 28300, 28323, 28852, 28829, 28301, 28324, 28853, 28830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18035, 28301, 28324, 28853, 28830, 28302, 28325, 28854, 28831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18036, 28302, 28325, 28854, 28831, 28303, 28326, 28855, 28832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18037, 28303, 28326, 28855, 28832, 28304, 28327, 28856, 28833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18038, 28304, 28327, 28856, 28833, 28305, 28328, 28857, 28834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18039, 28305, 28328, 28857, 28834, 28306, 28329, 28858, 28835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18040, 28306, 28329, 28858, 28835, 28307, 28330, 28859, 28836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18041, 28307, 28330, 28859, 28836, 28308, 28331, 28860, 28837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18042, 28308, 28331, 28860, 28837, 28309, 28332, 28861, 28838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18043, 28309, 28332, 28861, 28838, 28310, 28333, 28862, 28839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18044, 28310, 28333, 28862, 28839, 28311, 28334, 28863, 28840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18045, 28311, 28334, 28863, 28840, 8385, 8386, 8409, 8408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18046, 6569, 6570, 6593, 6592, 28312, 28335, 28864, 28841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18047, 28312, 28335, 28864, 28841, 28313, 28336, 28865, 28842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18048, 28313, 28336, 28865, 28842, 28314, 28337, 28866, 28843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18049, 28314, 28337, 28866, 28843, 28315, 28338, 28867, 28844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18050, 28315, 28338, 28867, 28844, 28316, 28339, 28868, 28845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18051, 28316, 28339, 28868, 28845, 28317, 28340, 28869, 28846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18052, 28317, 28340, 28869, 28846, 28318, 28341, 28870, 28847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18053, 28318, 28341, 28870, 28847, 28319, 28342, 28871, 28848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18054, 28319, 28342, 28871, 28848, 28320, 28343, 28872, 28849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18055, 28320, 28343, 28872, 28849, 28321, 28344, 28873, 28850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18056, 28321, 28344, 28873, 28850, 28322, 28345, 28874, 28851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18057, 28322, 28345, 28874, 28851, 28323, 28346, 28875, 28852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18058, 28323, 28346, 28875, 28852, 28324, 28347, 28876, 28853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18059, 28324, 28347, 28876, 28853, 28325, 28348, 28877, 28854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18060, 28325, 28348, 28877, 28854, 28326, 28349, 28878, 28855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18061, 28326, 28349, 28878, 28855, 28327, 28350, 28879, 28856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18062, 28327, 28350, 28879, 28856, 28328, 28351, 28880, 28857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18063, 28328, 28351, 28880, 28857, 28329, 28352, 28881, 28858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18064, 28329, 28352, 28881, 28858, 28330, 28353, 28882, 28859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18065, 28330, 28353, 28882, 28859, 28331, 28354, 28883, 28860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18066, 28331, 28354, 28883, 28860, 28332, 28355, 28884, 28861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18067, 28332, 28355, 28884, 28861, 28333, 28356, 28885, 28862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18068, 28333, 28356, 28885, 28862, 28334, 28357, 28886, 28863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18069, 28334, 28357, 28886, 28863, 8386, 8387, 8410, 8409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18070, 6570, 6571, 6594, 6593, 28335, 28358, 28887, 28864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18071, 28335, 28358, 28887, 28864, 28336, 28359, 28888, 28865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18072, 28336, 28359, 28888, 28865, 28337, 28360, 28889, 28866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18073, 28337, 28360, 28889, 28866, 28338, 28361, 28890, 28867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18074, 28338, 28361, 28890, 28867, 28339, 28362, 28891, 28868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18075, 28339, 28362, 28891, 28868, 28340, 28363, 28892, 28869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18076, 28340, 28363, 28892, 28869, 28341, 28364, 28893, 28870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18077, 28341, 28364, 28893, 28870, 28342, 28365, 28894, 28871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18078, 28342, 28365, 28894, 28871, 28343, 28366, 28895, 28872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18079, 28343, 28366, 28895, 28872, 28344, 28367, 28896, 28873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18080, 28344, 28367, 28896, 28873, 28345, 28368, 28897, 28874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18081, 28345, 28368, 28897, 28874, 28346, 28369, 28898, 28875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18082, 28346, 28369, 28898, 28875, 28347, 28370, 28899, 28876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18083, 28347, 28370, 28899, 28876, 28348, 28371, 28900, 28877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18084, 28348, 28371, 28900, 28877, 28349, 28372, 28901, 28878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18085, 28349, 28372, 28901, 28878, 28350, 28373, 28902, 28879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18086, 28350, 28373, 28902, 28879, 28351, 28374, 28903, 28880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18087, 28351, 28374, 28903, 28880, 28352, 28375, 28904, 28881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18088, 28352, 28375, 28904, 28881, 28353, 28376, 28905, 28882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18089, 28353, 28376, 28905, 28882, 28354, 28377, 28906, 28883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18090, 28354, 28377, 28906, 28883, 28355, 28378, 28907, 28884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18091, 28355, 28378, 28907, 28884, 28356, 28379, 28908, 28885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18092, 28356, 28379, 28908, 28885, 28357, 28380, 28909, 28886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18093, 28357, 28380, 28909, 28886, 8387, 8388, 8411, 8410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18094, 6571, 6572, 6595, 6594, 28358, 28381, 28910, 28887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18095, 28358, 28381, 28910, 28887, 28359, 28382, 28911, 28888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18096, 28359, 28382, 28911, 28888, 28360, 28383, 28912, 28889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18097, 28360, 28383, 28912, 28889, 28361, 28384, 28913, 28890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18098, 28361, 28384, 28913, 28890, 28362, 28385, 28914, 28891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18099, 28362, 28385, 28914, 28891, 28363, 28386, 28915, 28892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18100, 28363, 28386, 28915, 28892, 28364, 28387, 28916, 28893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18101, 28364, 28387, 28916, 28893, 28365, 28388, 28917, 28894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18102, 28365, 28388, 28917, 28894, 28366, 28389, 28918, 28895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18103, 28366, 28389, 28918, 28895, 28367, 28390, 28919, 28896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18104, 28367, 28390, 28919, 28896, 28368, 28391, 28920, 28897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18105, 28368, 28391, 28920, 28897, 28369, 28392, 28921, 28898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18106, 28369, 28392, 28921, 28898, 28370, 28393, 28922, 28899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18107, 28370, 28393, 28922, 28899, 28371, 28394, 28923, 28900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18108, 28371, 28394, 28923, 28900, 28372, 28395, 28924, 28901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18109, 28372, 28395, 28924, 28901, 28373, 28396, 28925, 28902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18110, 28373, 28396, 28925, 28902, 28374, 28397, 28926, 28903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18111, 28374, 28397, 28926, 28903, 28375, 28398, 28927, 28904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18112, 28375, 28398, 28927, 28904, 28376, 28399, 28928, 28905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18113, 28376, 28399, 28928, 28905, 28377, 28400, 28929, 28906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18114, 28377, 28400, 28929, 28906, 28378, 28401, 28930, 28907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18115, 28378, 28401, 28930, 28907, 28379, 28402, 28931, 28908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18116, 28379, 28402, 28931, 28908, 28380, 28403, 28932, 28909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18117, 28380, 28403, 28932, 28909, 8388, 8389, 8412, 8411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18118, 6572, 6573, 6596, 6595, 28381, 28404, 28933, 28910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18119, 28381, 28404, 28933, 28910, 28382, 28405, 28934, 28911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18120, 28382, 28405, 28934, 28911, 28383, 28406, 28935, 28912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18121, 28383, 28406, 28935, 28912, 28384, 28407, 28936, 28913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18122, 28384, 28407, 28936, 28913, 28385, 28408, 28937, 28914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18123, 28385, 28408, 28937, 28914, 28386, 28409, 28938, 28915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18124, 28386, 28409, 28938, 28915, 28387, 28410, 28939, 28916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18125, 28387, 28410, 28939, 28916, 28388, 28411, 28940, 28917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18126, 28388, 28411, 28940, 28917, 28389, 28412, 28941, 28918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18127, 28389, 28412, 28941, 28918, 28390, 28413, 28942, 28919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18128, 28390, 28413, 28942, 28919, 28391, 28414, 28943, 28920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18129, 28391, 28414, 28943, 28920, 28392, 28415, 28944, 28921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18130, 28392, 28415, 28944, 28921, 28393, 28416, 28945, 28922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18131, 28393, 28416, 28945, 28922, 28394, 28417, 28946, 28923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18132, 28394, 28417, 28946, 28923, 28395, 28418, 28947, 28924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18133, 28395, 28418, 28947, 28924, 28396, 28419, 28948, 28925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18134, 28396, 28419, 28948, 28925, 28397, 28420, 28949, 28926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18135, 28397, 28420, 28949, 28926, 28398, 28421, 28950, 28927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18136, 28398, 28421, 28950, 28927, 28399, 28422, 28951, 28928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18137, 28399, 28422, 28951, 28928, 28400, 28423, 28952, 28929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18138, 28400, 28423, 28952, 28929, 28401, 28424, 28953, 28930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18139, 28401, 28424, 28953, 28930, 28402, 28425, 28954, 28931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18140, 28402, 28425, 28954, 28931, 28403, 28426, 28955, 28932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18141, 28403, 28426, 28955, 28932, 8389, 8390, 8413, 8412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18142, 6573, 6574, 6597, 6596, 28404, 28427, 28956, 28933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18143, 28404, 28427, 28956, 28933, 28405, 28428, 28957, 28934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18144, 28405, 28428, 28957, 28934, 28406, 28429, 28958, 28935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18145, 28406, 28429, 28958, 28935, 28407, 28430, 28959, 28936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18146, 28407, 28430, 28959, 28936, 28408, 28431, 28960, 28937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18147, 28408, 28431, 28960, 28937, 28409, 28432, 28961, 28938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18148, 28409, 28432, 28961, 28938, 28410, 28433, 28962, 28939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18149, 28410, 28433, 28962, 28939, 28411, 28434, 28963, 28940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18150, 28411, 28434, 28963, 28940, 28412, 28435, 28964, 28941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18151, 28412, 28435, 28964, 28941, 28413, 28436, 28965, 28942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18152, 28413, 28436, 28965, 28942, 28414, 28437, 28966, 28943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18153, 28414, 28437, 28966, 28943, 28415, 28438, 28967, 28944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18154, 28415, 28438, 28967, 28944, 28416, 28439, 28968, 28945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18155, 28416, 28439, 28968, 28945, 28417, 28440, 28969, 28946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18156, 28417, 28440, 28969, 28946, 28418, 28441, 28970, 28947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18157, 28418, 28441, 28970, 28947, 28419, 28442, 28971, 28948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18158, 28419, 28442, 28971, 28948, 28420, 28443, 28972, 28949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18159, 28420, 28443, 28972, 28949, 28421, 28444, 28973, 28950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18160, 28421, 28444, 28973, 28950, 28422, 28445, 28974, 28951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18161, 28422, 28445, 28974, 28951, 28423, 28446, 28975, 28952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18162, 28423, 28446, 28975, 28952, 28424, 28447, 28976, 28953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18163, 28424, 28447, 28976, 28953, 28425, 28448, 28977, 28954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18164, 28425, 28448, 28977, 28954, 28426, 28449, 28978, 28955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18165, 28426, 28449, 28978, 28955, 8390, 8391, 8414, 8413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18166, 6574, 6575, 6598, 6597, 28427, 28450, 28979, 28956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18167, 28427, 28450, 28979, 28956, 28428, 28451, 28980, 28957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18168, 28428, 28451, 28980, 28957, 28429, 28452, 28981, 28958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18169, 28429, 28452, 28981, 28958, 28430, 28453, 28982, 28959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18170, 28430, 28453, 28982, 28959, 28431, 28454, 28983, 28960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18171, 28431, 28454, 28983, 28960, 28432, 28455, 28984, 28961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18172, 28432, 28455, 28984, 28961, 28433, 28456, 28985, 28962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18173, 28433, 28456, 28985, 28962, 28434, 28457, 28986, 28963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18174, 28434, 28457, 28986, 28963, 28435, 28458, 28987, 28964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18175, 28435, 28458, 28987, 28964, 28436, 28459, 28988, 28965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18176, 28436, 28459, 28988, 28965, 28437, 28460, 28989, 28966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18177, 28437, 28460, 28989, 28966, 28438, 28461, 28990, 28967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18178, 28438, 28461, 28990, 28967, 28439, 28462, 28991, 28968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18179, 28439, 28462, 28991, 28968, 28440, 28463, 28992, 28969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18180, 28440, 28463, 28992, 28969, 28441, 28464, 28993, 28970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18181, 28441, 28464, 28993, 28970, 28442, 28465, 28994, 28971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18182, 28442, 28465, 28994, 28971, 28443, 28466, 28995, 28972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18183, 28443, 28466, 28995, 28972, 28444, 28467, 28996, 28973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18184, 28444, 28467, 28996, 28973, 28445, 28468, 28997, 28974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18185, 28445, 28468, 28997, 28974, 28446, 28469, 28998, 28975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18186, 28446, 28469, 28998, 28975, 28447, 28470, 28999, 28976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18187, 28447, 28470, 28999, 28976, 28448, 28471, 29000, 28977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18188, 28448, 28471, 29000, 28977, 28449, 28472, 29001, 28978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18189, 28449, 28472, 29001, 28978, 8391, 8392, 8415, 8414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18190, 6575, 6576, 6599, 6598, 28450, 28473, 29002, 28979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18191, 28450, 28473, 29002, 28979, 28451, 28474, 29003, 28980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18192, 28451, 28474, 29003, 28980, 28452, 28475, 29004, 28981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18193, 28452, 28475, 29004, 28981, 28453, 28476, 29005, 28982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18194, 28453, 28476, 29005, 28982, 28454, 28477, 29006, 28983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18195, 28454, 28477, 29006, 28983, 28455, 28478, 29007, 28984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18196, 28455, 28478, 29007, 28984, 28456, 28479, 29008, 28985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18197, 28456, 28479, 29008, 28985, 28457, 28480, 29009, 28986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18198, 28457, 28480, 29009, 28986, 28458, 28481, 29010, 28987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18199, 28458, 28481, 29010, 28987, 28459, 28482, 29011, 28988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18200, 28459, 28482, 29011, 28988, 28460, 28483, 29012, 28989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18201, 28460, 28483, 29012, 28989, 28461, 28484, 29013, 28990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18202, 28461, 28484, 29013, 28990, 28462, 28485, 29014, 28991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18203, 28462, 28485, 29014, 28991, 28463, 28486, 29015, 28992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18204, 28463, 28486, 29015, 28992, 28464, 28487, 29016, 28993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18205, 28464, 28487, 29016, 28993, 28465, 28488, 29017, 28994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18206, 28465, 28488, 29017, 28994, 28466, 28489, 29018, 28995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18207, 28466, 28489, 29018, 28995, 28467, 28490, 29019, 28996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18208, 28467, 28490, 29019, 28996, 28468, 28491, 29020, 28997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18209, 28468, 28491, 29020, 28997, 28469, 28492, 29021, 28998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18210, 28469, 28492, 29021, 28998, 28470, 28493, 29022, 28999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18211, 28470, 28493, 29022, 28999, 28471, 28494, 29023, 29000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18212, 28471, 28494, 29023, 29000, 28472, 28495, 29024, 29001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18213, 28472, 28495, 29024, 29001, 8392, 8393, 8416, 8415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18214, 6576, 833, 834, 6599, 28473, 8118, 8141, 29002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18215, 28473, 8118, 8141, 29002, 28474, 8119, 8142, 29003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18216, 28474, 8119, 8142, 29003, 28475, 8120, 8143, 29004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18217, 28475, 8120, 8143, 29004, 28476, 8121, 8144, 29005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18218, 28476, 8121, 8144, 29005, 28477, 8122, 8145, 29006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18219, 28477, 8122, 8145, 29006, 28478, 8123, 8146, 29007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18220, 28478, 8123, 8146, 29007, 28479, 8124, 8147, 29008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18221, 28479, 8124, 8147, 29008, 28480, 8125, 8148, 29009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18222, 28480, 8125, 8148, 29009, 28481, 8126, 8149, 29010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18223, 28481, 8126, 8149, 29010, 28482, 8127, 8150, 29011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18224, 28482, 8127, 8150, 29011, 28483, 8128, 8151, 29012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18225, 28483, 8128, 8151, 29012, 28484, 8129, 8152, 29013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18226, 28484, 8129, 8152, 29013, 28485, 8130, 8153, 29014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18227, 28485, 8130, 8153, 29014, 28486, 8131, 8154, 29015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18228, 28486, 8131, 8154, 29015, 28487, 8132, 8155, 29016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18229, 28487, 8132, 8155, 29016, 28488, 8133, 8156, 29017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18230, 28488, 8133, 8156, 29017, 28489, 8134, 8157, 29018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18231, 28489, 8134, 8157, 29018, 28490, 8135, 8158, 29019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18232, 28490, 8135, 8158, 29019, 28491, 8136, 8159, 29020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18233, 28491, 8136, 8159, 29020, 28492, 8137, 8160, 29021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18234, 28492, 8137, 8160, 29021, 28493, 8138, 8161, 29022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18235, 28493, 8138, 8161, 29022, 28494, 8139, 8162, 29023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18236, 28494, 8139, 8162, 29023, 28495, 8140, 8163, 29024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18237, 28495, 8140, 8163, 29024, 8393, 993, 994, 8416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18238, 823, 6577, 6600, 824, 7888, 28496, 29025, 7911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18239, 7888, 28496, 29025, 7911, 7889, 28497, 29026, 7912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18240, 7889, 28497, 29026, 7912, 7890, 28498, 29027, 7913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18241, 7890, 28498, 29027, 7913, 7891, 28499, 29028, 7914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18242, 7891, 28499, 29028, 7914, 7892, 28500, 29029, 7915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18243, 7892, 28500, 29029, 7915, 7893, 28501, 29030, 7916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18244, 7893, 28501, 29030, 7916, 7894, 28502, 29031, 7917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18245, 7894, 28502, 29031, 7917, 7895, 28503, 29032, 7918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18246, 7895, 28503, 29032, 7918, 7896, 28504, 29033, 7919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18247, 7896, 28504, 29033, 7919, 7897, 28505, 29034, 7920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18248, 7897, 28505, 29034, 7920, 7898, 28506, 29035, 7921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18249, 7898, 28506, 29035, 7921, 7899, 28507, 29036, 7922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18250, 7899, 28507, 29036, 7922, 7900, 28508, 29037, 7923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18251, 7900, 28508, 29037, 7923, 7901, 28509, 29038, 7924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18252, 7901, 28509, 29038, 7924, 7902, 28510, 29039, 7925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18253, 7902, 28510, 29039, 7925, 7903, 28511, 29040, 7926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18254, 7903, 28511, 29040, 7926, 7904, 28512, 29041, 7927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18255, 7904, 28512, 29041, 7927, 7905, 28513, 29042, 7928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18256, 7905, 28513, 29042, 7928, 7906, 28514, 29043, 7929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18257, 7906, 28514, 29043, 7929, 7907, 28515, 29044, 7930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18258, 7907, 28515, 29044, 7930, 7908, 28516, 29045, 7931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18259, 7908, 28516, 29045, 7931, 7909, 28517, 29046, 7932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18260, 7909, 28517, 29046, 7932, 7910, 28518, 29047, 7933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18261, 7910, 28518, 29047, 7933, 983, 8394, 8417, 984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18262, 6577, 6578, 6601, 6600, 28496, 28519, 29048, 29025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18263, 28496, 28519, 29048, 29025, 28497, 28520, 29049, 29026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18264, 28497, 28520, 29049, 29026, 28498, 28521, 29050, 29027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18265, 28498, 28521, 29050, 29027, 28499, 28522, 29051, 29028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18266, 28499, 28522, 29051, 29028, 28500, 28523, 29052, 29029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18267, 28500, 28523, 29052, 29029, 28501, 28524, 29053, 29030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18268, 28501, 28524, 29053, 29030, 28502, 28525, 29054, 29031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18269, 28502, 28525, 29054, 29031, 28503, 28526, 29055, 29032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18270, 28503, 28526, 29055, 29032, 28504, 28527, 29056, 29033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18271, 28504, 28527, 29056, 29033, 28505, 28528, 29057, 29034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18272, 28505, 28528, 29057, 29034, 28506, 28529, 29058, 29035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18273, 28506, 28529, 29058, 29035, 28507, 28530, 29059, 29036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18274, 28507, 28530, 29059, 29036, 28508, 28531, 29060, 29037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18275, 28508, 28531, 29060, 29037, 28509, 28532, 29061, 29038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18276, 28509, 28532, 29061, 29038, 28510, 28533, 29062, 29039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18277, 28510, 28533, 29062, 29039, 28511, 28534, 29063, 29040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18278, 28511, 28534, 29063, 29040, 28512, 28535, 29064, 29041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18279, 28512, 28535, 29064, 29041, 28513, 28536, 29065, 29042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18280, 28513, 28536, 29065, 29042, 28514, 28537, 29066, 29043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18281, 28514, 28537, 29066, 29043, 28515, 28538, 29067, 29044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18282, 28515, 28538, 29067, 29044, 28516, 28539, 29068, 29045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18283, 28516, 28539, 29068, 29045, 28517, 28540, 29069, 29046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18284, 28517, 28540, 29069, 29046, 28518, 28541, 29070, 29047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18285, 28518, 28541, 29070, 29047, 8394, 8395, 8418, 8417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18286, 6578, 6579, 6602, 6601, 28519, 28542, 29071, 29048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18287, 28519, 28542, 29071, 29048, 28520, 28543, 29072, 29049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18288, 28520, 28543, 29072, 29049, 28521, 28544, 29073, 29050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18289, 28521, 28544, 29073, 29050, 28522, 28545, 29074, 29051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18290, 28522, 28545, 29074, 29051, 28523, 28546, 29075, 29052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18291, 28523, 28546, 29075, 29052, 28524, 28547, 29076, 29053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18292, 28524, 28547, 29076, 29053, 28525, 28548, 29077, 29054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18293, 28525, 28548, 29077, 29054, 28526, 28549, 29078, 29055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18294, 28526, 28549, 29078, 29055, 28527, 28550, 29079, 29056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18295, 28527, 28550, 29079, 29056, 28528, 28551, 29080, 29057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18296, 28528, 28551, 29080, 29057, 28529, 28552, 29081, 29058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18297, 28529, 28552, 29081, 29058, 28530, 28553, 29082, 29059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18298, 28530, 28553, 29082, 29059, 28531, 28554, 29083, 29060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18299, 28531, 28554, 29083, 29060, 28532, 28555, 29084, 29061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18300, 28532, 28555, 29084, 29061, 28533, 28556, 29085, 29062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18301, 28533, 28556, 29085, 29062, 28534, 28557, 29086, 29063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18302, 28534, 28557, 29086, 29063, 28535, 28558, 29087, 29064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18303, 28535, 28558, 29087, 29064, 28536, 28559, 29088, 29065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18304, 28536, 28559, 29088, 29065, 28537, 28560, 29089, 29066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18305, 28537, 28560, 29089, 29066, 28538, 28561, 29090, 29067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18306, 28538, 28561, 29090, 29067, 28539, 28562, 29091, 29068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18307, 28539, 28562, 29091, 29068, 28540, 28563, 29092, 29069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18308, 28540, 28563, 29092, 29069, 28541, 28564, 29093, 29070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18309, 28541, 28564, 29093, 29070, 8395, 8396, 8419, 8418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18310, 6579, 6580, 6603, 6602, 28542, 28565, 29094, 29071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18311, 28542, 28565, 29094, 29071, 28543, 28566, 29095, 29072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18312, 28543, 28566, 29095, 29072, 28544, 28567, 29096, 29073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18313, 28544, 28567, 29096, 29073, 28545, 28568, 29097, 29074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18314, 28545, 28568, 29097, 29074, 28546, 28569, 29098, 29075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18315, 28546, 28569, 29098, 29075, 28547, 28570, 29099, 29076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18316, 28547, 28570, 29099, 29076, 28548, 28571, 29100, 29077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18317, 28548, 28571, 29100, 29077, 28549, 28572, 29101, 29078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18318, 28549, 28572, 29101, 29078, 28550, 28573, 29102, 29079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18319, 28550, 28573, 29102, 29079, 28551, 28574, 29103, 29080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18320, 28551, 28574, 29103, 29080, 28552, 28575, 29104, 29081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18321, 28552, 28575, 29104, 29081, 28553, 28576, 29105, 29082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18322, 28553, 28576, 29105, 29082, 28554, 28577, 29106, 29083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18323, 28554, 28577, 29106, 29083, 28555, 28578, 29107, 29084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18324, 28555, 28578, 29107, 29084, 28556, 28579, 29108, 29085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18325, 28556, 28579, 29108, 29085, 28557, 28580, 29109, 29086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18326, 28557, 28580, 29109, 29086, 28558, 28581, 29110, 29087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18327, 28558, 28581, 29110, 29087, 28559, 28582, 29111, 29088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18328, 28559, 28582, 29111, 29088, 28560, 28583, 29112, 29089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18329, 28560, 28583, 29112, 29089, 28561, 28584, 29113, 29090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18330, 28561, 28584, 29113, 29090, 28562, 28585, 29114, 29091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18331, 28562, 28585, 29114, 29091, 28563, 28586, 29115, 29092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18332, 28563, 28586, 29115, 29092, 28564, 28587, 29116, 29093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18333, 28564, 28587, 29116, 29093, 8396, 8397, 8420, 8419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18334, 6580, 6581, 6604, 6603, 28565, 28588, 29117, 29094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18335, 28565, 28588, 29117, 29094, 28566, 28589, 29118, 29095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18336, 28566, 28589, 29118, 29095, 28567, 28590, 29119, 29096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18337, 28567, 28590, 29119, 29096, 28568, 28591, 29120, 29097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18338, 28568, 28591, 29120, 29097, 28569, 28592, 29121, 29098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18339, 28569, 28592, 29121, 29098, 28570, 28593, 29122, 29099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18340, 28570, 28593, 29122, 29099, 28571, 28594, 29123, 29100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18341, 28571, 28594, 29123, 29100, 28572, 28595, 29124, 29101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18342, 28572, 28595, 29124, 29101, 28573, 28596, 29125, 29102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18343, 28573, 28596, 29125, 29102, 28574, 28597, 29126, 29103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18344, 28574, 28597, 29126, 29103, 28575, 28598, 29127, 29104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18345, 28575, 28598, 29127, 29104, 28576, 28599, 29128, 29105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18346, 28576, 28599, 29128, 29105, 28577, 28600, 29129, 29106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18347, 28577, 28600, 29129, 29106, 28578, 28601, 29130, 29107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18348, 28578, 28601, 29130, 29107, 28579, 28602, 29131, 29108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18349, 28579, 28602, 29131, 29108, 28580, 28603, 29132, 29109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18350, 28580, 28603, 29132, 29109, 28581, 28604, 29133, 29110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18351, 28581, 28604, 29133, 29110, 28582, 28605, 29134, 29111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18352, 28582, 28605, 29134, 29111, 28583, 28606, 29135, 29112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18353, 28583, 28606, 29135, 29112, 28584, 28607, 29136, 29113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18354, 28584, 28607, 29136, 29113, 28585, 28608, 29137, 29114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18355, 28585, 28608, 29137, 29114, 28586, 28609, 29138, 29115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18356, 28586, 28609, 29138, 29115, 28587, 28610, 29139, 29116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18357, 28587, 28610, 29139, 29116, 8397, 8398, 8421, 8420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18358, 6581, 6582, 6605, 6604, 28588, 28611, 29140, 29117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18359, 28588, 28611, 29140, 29117, 28589, 28612, 29141, 29118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18360, 28589, 28612, 29141, 29118, 28590, 28613, 29142, 29119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18361, 28590, 28613, 29142, 29119, 28591, 28614, 29143, 29120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18362, 28591, 28614, 29143, 29120, 28592, 28615, 29144, 29121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18363, 28592, 28615, 29144, 29121, 28593, 28616, 29145, 29122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18364, 28593, 28616, 29145, 29122, 28594, 28617, 29146, 29123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18365, 28594, 28617, 29146, 29123, 28595, 28618, 29147, 29124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18366, 28595, 28618, 29147, 29124, 28596, 28619, 29148, 29125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18367, 28596, 28619, 29148, 29125, 28597, 28620, 29149, 29126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18368, 28597, 28620, 29149, 29126, 28598, 28621, 29150, 29127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18369, 28598, 28621, 29150, 29127, 28599, 28622, 29151, 29128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18370, 28599, 28622, 29151, 29128, 28600, 28623, 29152, 29129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18371, 28600, 28623, 29152, 29129, 28601, 28624, 29153, 29130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18372, 28601, 28624, 29153, 29130, 28602, 28625, 29154, 29131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18373, 28602, 28625, 29154, 29131, 28603, 28626, 29155, 29132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18374, 28603, 28626, 29155, 29132, 28604, 28627, 29156, 29133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18375, 28604, 28627, 29156, 29133, 28605, 28628, 29157, 29134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18376, 28605, 28628, 29157, 29134, 28606, 28629, 29158, 29135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18377, 28606, 28629, 29158, 29135, 28607, 28630, 29159, 29136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18378, 28607, 28630, 29159, 29136, 28608, 28631, 29160, 29137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18379, 28608, 28631, 29160, 29137, 28609, 28632, 29161, 29138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18380, 28609, 28632, 29161, 29138, 28610, 28633, 29162, 29139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18381, 28610, 28633, 29162, 29139, 8398, 8399, 8422, 8421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18382, 6582, 6583, 6606, 6605, 28611, 28634, 29163, 29140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18383, 28611, 28634, 29163, 29140, 28612, 28635, 29164, 29141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18384, 28612, 28635, 29164, 29141, 28613, 28636, 29165, 29142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18385, 28613, 28636, 29165, 29142, 28614, 28637, 29166, 29143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18386, 28614, 28637, 29166, 29143, 28615, 28638, 29167, 29144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18387, 28615, 28638, 29167, 29144, 28616, 28639, 29168, 29145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18388, 28616, 28639, 29168, 29145, 28617, 28640, 29169, 29146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18389, 28617, 28640, 29169, 29146, 28618, 28641, 29170, 29147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18390, 28618, 28641, 29170, 29147, 28619, 28642, 29171, 29148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18391, 28619, 28642, 29171, 29148, 28620, 28643, 29172, 29149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18392, 28620, 28643, 29172, 29149, 28621, 28644, 29173, 29150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18393, 28621, 28644, 29173, 29150, 28622, 28645, 29174, 29151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18394, 28622, 28645, 29174, 29151, 28623, 28646, 29175, 29152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18395, 28623, 28646, 29175, 29152, 28624, 28647, 29176, 29153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18396, 28624, 28647, 29176, 29153, 28625, 28648, 29177, 29154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18397, 28625, 28648, 29177, 29154, 28626, 28649, 29178, 29155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18398, 28626, 28649, 29178, 29155, 28627, 28650, 29179, 29156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18399, 28627, 28650, 29179, 29156, 28628, 28651, 29180, 29157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18400, 28628, 28651, 29180, 29157, 28629, 28652, 29181, 29158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18401, 28629, 28652, 29181, 29158, 28630, 28653, 29182, 29159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18402, 28630, 28653, 29182, 29159, 28631, 28654, 29183, 29160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18403, 28631, 28654, 29183, 29160, 28632, 28655, 29184, 29161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18404, 28632, 28655, 29184, 29161, 28633, 28656, 29185, 29162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18405, 28633, 28656, 29185, 29162, 8399, 8400, 8423, 8422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18406, 6583, 6584, 6607, 6606, 28634, 28657, 29186, 29163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18407, 28634, 28657, 29186, 29163, 28635, 28658, 29187, 29164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18408, 28635, 28658, 29187, 29164, 28636, 28659, 29188, 29165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18409, 28636, 28659, 29188, 29165, 28637, 28660, 29189, 29166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18410, 28637, 28660, 29189, 29166, 28638, 28661, 29190, 29167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18411, 28638, 28661, 29190, 29167, 28639, 28662, 29191, 29168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18412, 28639, 28662, 29191, 29168, 28640, 28663, 29192, 29169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18413, 28640, 28663, 29192, 29169, 28641, 28664, 29193, 29170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18414, 28641, 28664, 29193, 29170, 28642, 28665, 29194, 29171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18415, 28642, 28665, 29194, 29171, 28643, 28666, 29195, 29172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18416, 28643, 28666, 29195, 29172, 28644, 28667, 29196, 29173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18417, 28644, 28667, 29196, 29173, 28645, 28668, 29197, 29174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18418, 28645, 28668, 29197, 29174, 28646, 28669, 29198, 29175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18419, 28646, 28669, 29198, 29175, 28647, 28670, 29199, 29176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18420, 28647, 28670, 29199, 29176, 28648, 28671, 29200, 29177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18421, 28648, 28671, 29200, 29177, 28649, 28672, 29201, 29178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18422, 28649, 28672, 29201, 29178, 28650, 28673, 29202, 29179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18423, 28650, 28673, 29202, 29179, 28651, 28674, 29203, 29180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18424, 28651, 28674, 29203, 29180, 28652, 28675, 29204, 29181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18425, 28652, 28675, 29204, 29181, 28653, 28676, 29205, 29182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18426, 28653, 28676, 29205, 29182, 28654, 28677, 29206, 29183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18427, 28654, 28677, 29206, 29183, 28655, 28678, 29207, 29184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18428, 28655, 28678, 29207, 29184, 28656, 28679, 29208, 29185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18429, 28656, 28679, 29208, 29185, 8400, 8401, 8424, 8423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18430, 6584, 6585, 6608, 6607, 28657, 28680, 29209, 29186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18431, 28657, 28680, 29209, 29186, 28658, 28681, 29210, 29187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18432, 28658, 28681, 29210, 29187, 28659, 28682, 29211, 29188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18433, 28659, 28682, 29211, 29188, 28660, 28683, 29212, 29189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18434, 28660, 28683, 29212, 29189, 28661, 28684, 29213, 29190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18435, 28661, 28684, 29213, 29190, 28662, 28685, 29214, 29191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18436, 28662, 28685, 29214, 29191, 28663, 28686, 29215, 29192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18437, 28663, 28686, 29215, 29192, 28664, 28687, 29216, 29193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18438, 28664, 28687, 29216, 29193, 28665, 28688, 29217, 29194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18439, 28665, 28688, 29217, 29194, 28666, 28689, 29218, 29195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18440, 28666, 28689, 29218, 29195, 28667, 28690, 29219, 29196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18441, 28667, 28690, 29219, 29196, 28668, 28691, 29220, 29197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18442, 28668, 28691, 29220, 29197, 28669, 28692, 29221, 29198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18443, 28669, 28692, 29221, 29198, 28670, 28693, 29222, 29199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18444, 28670, 28693, 29222, 29199, 28671, 28694, 29223, 29200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18445, 28671, 28694, 29223, 29200, 28672, 28695, 29224, 29201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18446, 28672, 28695, 29224, 29201, 28673, 28696, 29225, 29202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18447, 28673, 28696, 29225, 29202, 28674, 28697, 29226, 29203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18448, 28674, 28697, 29226, 29203, 28675, 28698, 29227, 29204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18449, 28675, 28698, 29227, 29204, 28676, 28699, 29228, 29205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18450, 28676, 28699, 29228, 29205, 28677, 28700, 29229, 29206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18451, 28677, 28700, 29229, 29206, 28678, 28701, 29230, 29207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18452, 28678, 28701, 29230, 29207, 28679, 28702, 29231, 29208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18453, 28679, 28702, 29231, 29208, 8401, 8402, 8425, 8424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18454, 6585, 6586, 6609, 6608, 28680, 28703, 29232, 29209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18455, 28680, 28703, 29232, 29209, 28681, 28704, 29233, 29210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18456, 28681, 28704, 29233, 29210, 28682, 28705, 29234, 29211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18457, 28682, 28705, 29234, 29211, 28683, 28706, 29235, 29212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18458, 28683, 28706, 29235, 29212, 28684, 28707, 29236, 29213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18459, 28684, 28707, 29236, 29213, 28685, 28708, 29237, 29214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18460, 28685, 28708, 29237, 29214, 28686, 28709, 29238, 29215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18461, 28686, 28709, 29238, 29215, 28687, 28710, 29239, 29216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18462, 28687, 28710, 29239, 29216, 28688, 28711, 29240, 29217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18463, 28688, 28711, 29240, 29217, 28689, 28712, 29241, 29218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18464, 28689, 28712, 29241, 29218, 28690, 28713, 29242, 29219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18465, 28690, 28713, 29242, 29219, 28691, 28714, 29243, 29220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18466, 28691, 28714, 29243, 29220, 28692, 28715, 29244, 29221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18467, 28692, 28715, 29244, 29221, 28693, 28716, 29245, 29222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18468, 28693, 28716, 29245, 29222, 28694, 28717, 29246, 29223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18469, 28694, 28717, 29246, 29223, 28695, 28718, 29247, 29224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18470, 28695, 28718, 29247, 29224, 28696, 28719, 29248, 29225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18471, 28696, 28719, 29248, 29225, 28697, 28720, 29249, 29226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18472, 28697, 28720, 29249, 29226, 28698, 28721, 29250, 29227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18473, 28698, 28721, 29250, 29227, 28699, 28722, 29251, 29228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18474, 28699, 28722, 29251, 29228, 28700, 28723, 29252, 29229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18475, 28700, 28723, 29252, 29229, 28701, 28724, 29253, 29230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18476, 28701, 28724, 29253, 29230, 28702, 28725, 29254, 29231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18477, 28702, 28725, 29254, 29231, 8402, 8403, 8426, 8425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18478, 6586, 6587, 6610, 6609, 28703, 28726, 29255, 29232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18479, 28703, 28726, 29255, 29232, 28704, 28727, 29256, 29233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18480, 28704, 28727, 29256, 29233, 28705, 28728, 29257, 29234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18481, 28705, 28728, 29257, 29234, 28706, 28729, 29258, 29235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18482, 28706, 28729, 29258, 29235, 28707, 28730, 29259, 29236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18483, 28707, 28730, 29259, 29236, 28708, 28731, 29260, 29237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18484, 28708, 28731, 29260, 29237, 28709, 28732, 29261, 29238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18485, 28709, 28732, 29261, 29238, 28710, 28733, 29262, 29239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18486, 28710, 28733, 29262, 29239, 28711, 28734, 29263, 29240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18487, 28711, 28734, 29263, 29240, 28712, 28735, 29264, 29241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18488, 28712, 28735, 29264, 29241, 28713, 28736, 29265, 29242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18489, 28713, 28736, 29265, 29242, 28714, 28737, 29266, 29243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18490, 28714, 28737, 29266, 29243, 28715, 28738, 29267, 29244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18491, 28715, 28738, 29267, 29244, 28716, 28739, 29268, 29245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18492, 28716, 28739, 29268, 29245, 28717, 28740, 29269, 29246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18493, 28717, 28740, 29269, 29246, 28718, 28741, 29270, 29247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18494, 28718, 28741, 29270, 29247, 28719, 28742, 29271, 29248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18495, 28719, 28742, 29271, 29248, 28720, 28743, 29272, 29249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18496, 28720, 28743, 29272, 29249, 28721, 28744, 29273, 29250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18497, 28721, 28744, 29273, 29250, 28722, 28745, 29274, 29251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18498, 28722, 28745, 29274, 29251, 28723, 28746, 29275, 29252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18499, 28723, 28746, 29275, 29252, 28724, 28747, 29276, 29253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18500, 28724, 28747, 29276, 29253, 28725, 28748, 29277, 29254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18501, 28725, 28748, 29277, 29254, 8403, 8404, 8427, 8426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18502, 6587, 6588, 6611, 6610, 28726, 28749, 29278, 29255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18503, 28726, 28749, 29278, 29255, 28727, 28750, 29279, 29256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18504, 28727, 28750, 29279, 29256, 28728, 28751, 29280, 29257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18505, 28728, 28751, 29280, 29257, 28729, 28752, 29281, 29258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18506, 28729, 28752, 29281, 29258, 28730, 28753, 29282, 29259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18507, 28730, 28753, 29282, 29259, 28731, 28754, 29283, 29260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18508, 28731, 28754, 29283, 29260, 28732, 28755, 29284, 29261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18509, 28732, 28755, 29284, 29261, 28733, 28756, 29285, 29262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18510, 28733, 28756, 29285, 29262, 28734, 28757, 29286, 29263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18511, 28734, 28757, 29286, 29263, 28735, 28758, 29287, 29264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18512, 28735, 28758, 29287, 29264, 28736, 28759, 29288, 29265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18513, 28736, 28759, 29288, 29265, 28737, 28760, 29289, 29266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18514, 28737, 28760, 29289, 29266, 28738, 28761, 29290, 29267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18515, 28738, 28761, 29290, 29267, 28739, 28762, 29291, 29268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18516, 28739, 28762, 29291, 29268, 28740, 28763, 29292, 29269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18517, 28740, 28763, 29292, 29269, 28741, 28764, 29293, 29270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18518, 28741, 28764, 29293, 29270, 28742, 28765, 29294, 29271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18519, 28742, 28765, 29294, 29271, 28743, 28766, 29295, 29272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18520, 28743, 28766, 29295, 29272, 28744, 28767, 29296, 29273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18521, 28744, 28767, 29296, 29273, 28745, 28768, 29297, 29274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18522, 28745, 28768, 29297, 29274, 28746, 28769, 29298, 29275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18523, 28746, 28769, 29298, 29275, 28747, 28770, 29299, 29276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18524, 28747, 28770, 29299, 29276, 28748, 28771, 29300, 29277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18525, 28748, 28771, 29300, 29277, 8404, 8405, 8428, 8427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18526, 6588, 6589, 6612, 6611, 28749, 28772, 29301, 29278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18527, 28749, 28772, 29301, 29278, 28750, 28773, 29302, 29279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18528, 28750, 28773, 29302, 29279, 28751, 28774, 29303, 29280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18529, 28751, 28774, 29303, 29280, 28752, 28775, 29304, 29281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18530, 28752, 28775, 29304, 29281, 28753, 28776, 29305, 29282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18531, 28753, 28776, 29305, 29282, 28754, 28777, 29306, 29283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18532, 28754, 28777, 29306, 29283, 28755, 28778, 29307, 29284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18533, 28755, 28778, 29307, 29284, 28756, 28779, 29308, 29285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18534, 28756, 28779, 29308, 29285, 28757, 28780, 29309, 29286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18535, 28757, 28780, 29309, 29286, 28758, 28781, 29310, 29287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18536, 28758, 28781, 29310, 29287, 28759, 28782, 29311, 29288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18537, 28759, 28782, 29311, 29288, 28760, 28783, 29312, 29289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18538, 28760, 28783, 29312, 29289, 28761, 28784, 29313, 29290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18539, 28761, 28784, 29313, 29290, 28762, 28785, 29314, 29291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18540, 28762, 28785, 29314, 29291, 28763, 28786, 29315, 29292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18541, 28763, 28786, 29315, 29292, 28764, 28787, 29316, 29293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18542, 28764, 28787, 29316, 29293, 28765, 28788, 29317, 29294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18543, 28765, 28788, 29317, 29294, 28766, 28789, 29318, 29295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18544, 28766, 28789, 29318, 29295, 28767, 28790, 29319, 29296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18545, 28767, 28790, 29319, 29296, 28768, 28791, 29320, 29297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18546, 28768, 28791, 29320, 29297, 28769, 28792, 29321, 29298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18547, 28769, 28792, 29321, 29298, 28770, 28793, 29322, 29299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18548, 28770, 28793, 29322, 29299, 28771, 28794, 29323, 29300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18549, 28771, 28794, 29323, 29300, 8405, 8406, 8429, 8428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18550, 6589, 6590, 6613, 6612, 28772, 28795, 29324, 29301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18551, 28772, 28795, 29324, 29301, 28773, 28796, 29325, 29302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18552, 28773, 28796, 29325, 29302, 28774, 28797, 29326, 29303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18553, 28774, 28797, 29326, 29303, 28775, 28798, 29327, 29304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18554, 28775, 28798, 29327, 29304, 28776, 28799, 29328, 29305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18555, 28776, 28799, 29328, 29305, 28777, 28800, 29329, 29306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18556, 28777, 28800, 29329, 29306, 28778, 28801, 29330, 29307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18557, 28778, 28801, 29330, 29307, 28779, 28802, 29331, 29308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18558, 28779, 28802, 29331, 29308, 28780, 28803, 29332, 29309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18559, 28780, 28803, 29332, 29309, 28781, 28804, 29333, 29310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18560, 28781, 28804, 29333, 29310, 28782, 28805, 29334, 29311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18561, 28782, 28805, 29334, 29311, 28783, 28806, 29335, 29312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18562, 28783, 28806, 29335, 29312, 28784, 28807, 29336, 29313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18563, 28784, 28807, 29336, 29313, 28785, 28808, 29337, 29314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18564, 28785, 28808, 29337, 29314, 28786, 28809, 29338, 29315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18565, 28786, 28809, 29338, 29315, 28787, 28810, 29339, 29316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18566, 28787, 28810, 29339, 29316, 28788, 28811, 29340, 29317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18567, 28788, 28811, 29340, 29317, 28789, 28812, 29341, 29318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18568, 28789, 28812, 29341, 29318, 28790, 28813, 29342, 29319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18569, 28790, 28813, 29342, 29319, 28791, 28814, 29343, 29320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18570, 28791, 28814, 29343, 29320, 28792, 28815, 29344, 29321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18571, 28792, 28815, 29344, 29321, 28793, 28816, 29345, 29322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18572, 28793, 28816, 29345, 29322, 28794, 28817, 29346, 29323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18573, 28794, 28817, 29346, 29323, 8406, 8407, 8430, 8429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18574, 6590, 6591, 6614, 6613, 28795, 28818, 29347, 29324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18575, 28795, 28818, 29347, 29324, 28796, 28819, 29348, 29325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18576, 28796, 28819, 29348, 29325, 28797, 28820, 29349, 29326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18577, 28797, 28820, 29349, 29326, 28798, 28821, 29350, 29327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18578, 28798, 28821, 29350, 29327, 28799, 28822, 29351, 29328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18579, 28799, 28822, 29351, 29328, 28800, 28823, 29352, 29329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18580, 28800, 28823, 29352, 29329, 28801, 28824, 29353, 29330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18581, 28801, 28824, 29353, 29330, 28802, 28825, 29354, 29331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18582, 28802, 28825, 29354, 29331, 28803, 28826, 29355, 29332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18583, 28803, 28826, 29355, 29332, 28804, 28827, 29356, 29333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
