38223, 8394, 8395, 8418, 8417, 0, 0, 0, 0
38224, 8395, 8396, 8419, 8418, 0, 0, 0, 0
38225, 8396, 8397, 8420, 8419, 0, 0, 0, 0
38226, 8397, 8398, 8421, 8420, 0, 0, 0, 0
38227, 8398, 8399, 8422, 8421, 0, 0, 0, 0
38228, 8399, 8400, 8423, 8422, 0, 0, 0, 0
38229, 8400, 8401, 8424, 8423, 0, 0, 0, 0
38230, 8401, 8402, 8425, 8424, 0, 0, 0, 0
38231, 8402, 8403, 8426, 8425, 0, 0, 0, 0
38232, 8403, 8404, 8427, 8426, 0, 0, 0, 0
38233, 8404, 8405, 8428, 8427, 0, 0, 0, 0
38234, 8405, 8406, 8429, 8428, 0, 0, 0, 0
38235, 8406, 8407, 8430, 8429, 0, 0, 0, 0
38236, 8407, 8408, 8431, 8430, 0, 0, 0, 0
38237, 8408, 8409, 8432, 8431, 0, 0, 0, 0
38238, 8409, 8410, 8433, 8432, 0, 0, 0, 0
38239, 8410, 8411, 8434, 8433, 0, 0, 0, 0
38240, 8411, 8412, 8435, 8434, 0, 0, 0, 0
38241, 8412, 8413, 8436, 8435, 0, 0, 0, 0
38242, 8413, 8414, 8437, 8436, 0, 0, 0, 0
38243, 8414, 8415, 8438, 8437, 0, 0, 0, 0
38244, 8415, 8416, 8439, 8438, 0, 0, 0, 0
38245, 8416, 994, 995, 8439, 0, 0, 0, 0
38246, 984, 8417, 8440, 985, 0, 0, 0, 0
38247, 8417, 8418, 8441, 8440, 0, 0, 0, 0
38248, 8418, 8419, 8442, 8441, 0, 0, 0, 0
38249, 8419, 8420, 8443, 8442, 0, 0, 0, 0
38250, 8420, 8421, 8444, 8443, 0, 0, 0, 0
38251, 8421, 8422, 8445, 8444, 0, 0, 0, 0
38252, 8422, 8423, 8446, 8445, 0, 0, 0, 0
38253, 8423, 8424, 8447, 8446, 0, 0, 0, 0
38254, 8424, 8425, 8448, 8447, 0, 0, 0, 0
38255, 8425, 8426, 8449, 8448, 0, 0, 0, 0
38256, 8426, 8427, 8450, 8449, 0, 0, 0, 0
38257, 8427, 8428, 8451, 8450, 0, 0, 0, 0
38258, 8428, 8429, 8452, 8451, 0, 0, 0, 0
38259, 8429, 8430, 8453, 8452, 0, 0, 0, 0
38260, 8430, 8431, 8454, 8453, 0, 0, 0, 0
38261, 8431, 8432, 8455, 8454, 0, 0, 0, 0
38262, 8432, 8433, 8456, 8455, 0, 0, 0, 0
38263, 8433, 8434, 8457, 8456, 0, 0, 0, 0
38264, 8434, 8435, 8458, 8457, 0, 0, 0, 0
38265, 8435, 8436, 8459, 8458, 0, 0, 0, 0
38266, 8436, 8437, 8460, 8459, 0, 0, 0, 0
38267, 8437, 8438, 8461, 8460, 0, 0, 0, 0
38268, 8438, 8439, 8462, 8461, 0, 0, 0, 0
38269, 8439, 995, 996, 8462, 0, 0, 0, 0
38270, 985, 8440, 8463, 986, 0, 0, 0, 0
38271, 8440, 8441, 8464, 8463, 0, 0, 0, 0
38272, 8441, 8442, 8465, 8464, 0, 0, 0, 0
38273, 8442, 8443, 8466, 8465, 0, 0, 0, 0
38274, 8443, 8444, 8467, 8466, 0, 0, 0, 0
38275, 8444, 8445, 8468, 8467, 0, 0, 0, 0
38276, 8445, 8446, 8469, 8468, 0, 0, 0, 0
38277, 8446, 8447, 8470, 8469, 0, 0, 0, 0
38278, 8447, 8448, 8471, 8470, 0, 0, 0, 0
38279, 8448, 8449, 8472, 8471, 0, 0, 0, 0
38280, 8449, 8450, 8473, 8472, 0, 0, 0, 0
38281, 8450, 8451, 8474, 8473, 0, 0, 0, 0
38282, 8451, 8452, 8475, 8474, 0, 0, 0, 0
38283, 8452, 8453, 8476, 8475, 0, 0, 0, 0
38284, 8453, 8454, 8477, 8476, 0, 0, 0, 0
38285, 8454, 8455, 8478, 8477, 0, 0, 0, 0
38286, 8455, 8456, 8479, 8478, 0, 0, 0, 0
38287, 8456, 8457, 8480, 8479, 0, 0, 0, 0
38288, 8457, 8458, 8481, 8480, 0, 0, 0, 0
38289, 8458, 8459, 8482, 8481, 0, 0, 0, 0
38290, 8459, 8460, 8483, 8482, 0, 0, 0, 0
38291, 8460, 8461, 8484, 8483, 0, 0, 0, 0
38292, 8461, 8462, 8485, 8484, 0, 0, 0, 0
38293, 8462, 996, 997, 8485, 0, 0, 0, 0
38294, 986, 8463, 8486, 987, 0, 0, 0, 0
38295, 8463, 8464, 8487, 8486, 0, 0, 0, 0
38296, 8464, 8465, 8488, 8487, 0, 0, 0, 0
38297, 8465, 8466, 8489, 8488, 0, 0, 0, 0
38298, 8466, 8467, 8490, 8489, 0, 0, 0, 0
38299, 8467, 8468, 8491, 8490, 0, 0, 0, 0
38300, 8468, 8469, 8492, 8491, 0, 0, 0, 0
38301, 8469, 8470, 8493, 8492, 0, 0, 0, 0
38302, 8470, 8471, 8494, 8493, 0, 0, 0, 0
38303, 8471, 8472, 8495, 8494, 0, 0, 0, 0
38304, 8472, 8473, 8496, 8495, 0, 0, 0, 0
38305, 8473, 8474, 8497, 8496, 0, 0, 0, 0
38306, 8474, 8475, 8498, 8497, 0, 0, 0, 0
38307, 8475, 8476, 8499, 8498, 0, 0, 0, 0
38308, 8476, 8477, 8500, 8499, 0, 0, 0, 0
38309, 8477, 8478, 8501, 8500, 0, 0, 0, 0
38310, 8478, 8479, 8502, 8501, 0, 0, 0, 0
38311, 8479, 8480, 8503, 8502, 0, 0, 0, 0
38312, 8480, 8481, 8504, 8503, 0, 0, 0, 0
38313, 8481, 8482, 8505, 8504, 0, 0, 0, 0
38314, 8482, 8483, 8506, 8505, 0, 0, 0, 0
38315, 8483, 8484, 8507, 8506, 0, 0, 0, 0
38316, 8484, 8485, 8508, 8507, 0, 0, 0, 0
38317, 8485, 997, 998, 8508, 0, 0, 0, 0
38318, 987, 8486, 8509, 988, 0, 0, 0, 0
38319, 8486, 8487, 8510, 8509, 0, 0, 0, 0
38320, 8487, 8488, 8511, 8510, 0, 0, 0, 0
38321, 8488, 8489, 8512, 8511, 0, 0, 0, 0
38322, 8489, 8490, 8513, 8512, 0, 0, 0, 0
38323, 8490, 8491, 8514, 8513, 0, 0, 0, 0
38324, 8491, 8492, 8515, 8514, 0, 0, 0, 0
38325, 8492, 8493, 8516, 8515, 0, 0, 0, 0
38326, 8493, 8494, 8517, 8516, 0, 0, 0, 0
38327, 8494, 8495, 8518, 8517, 0, 0, 0, 0
38328, 8495, 8496, 8519, 8518, 0, 0, 0, 0
38329, 8496, 8497, 8520, 8519, 0, 0, 0, 0
38330, 8497, 8498, 8521, 8520, 0, 0, 0, 0
38331, 8498, 8499, 8522, 8521, 0, 0, 0, 0
38332, 8499, 8500, 8523, 8522, 0, 0, 0, 0
38333, 8500, 8501, 8524, 8523, 0, 0, 0, 0
38334, 8501, 8502, 8525, 8524, 0, 0, 0, 0
38335, 8502, 8503, 8526, 8525, 0, 0, 0, 0
38336, 8503, 8504, 8527, 8526, 0, 0, 0, 0
38337, 8504, 8505, 8528, 8527, 0, 0, 0, 0
38338, 8505, 8506, 8529, 8528, 0, 0, 0, 0
38339, 8506, 8507, 8530, 8529, 0, 0, 0, 0
38340, 8507, 8508, 8531, 8530, 0, 0, 0, 0
38341, 8508, 998, 999, 8531, 0, 0, 0, 0
38342, 988, 8509, 8532, 989, 0, 0, 0, 0
38343, 8509, 8510, 8533, 8532, 0, 0, 0, 0
38344, 8510, 8511, 8534, 8533, 0, 0, 0, 0
38345, 8511, 8512, 8535, 8534, 0, 0, 0, 0
38346, 8512, 8513, 8536, 8535, 0, 0, 0, 0
38347, 8513, 8514, 8537, 8536, 0, 0, 0, 0
38348, 8514, 8515, 8538, 8537, 0, 0, 0, 0
38349, 8515, 8516, 8539, 8538, 0, 0, 0, 0
38350, 8516, 8517, 8540, 8539, 0, 0, 0, 0
38351, 8517, 8518, 8541, 8540, 0, 0, 0, 0
38352, 8518, 8519, 8542, 8541, 0, 0, 0, 0
38353, 8519, 8520, 8543, 8542, 0, 0, 0, 0
38354, 8520, 8521, 8544, 8543, 0, 0, 0, 0
38355, 8521, 8522, 8545, 8544, 0, 0, 0, 0
38356, 8522, 8523, 8546, 8545, 0, 0, 0, 0
38357, 8523, 8524, 8547, 8546, 0, 0, 0, 0
38358, 8524, 8525, 8548, 8547, 0, 0, 0, 0
38359, 8525, 8526, 8549, 8548, 0, 0, 0, 0
38360, 8526, 8527, 8550, 8549, 0, 0, 0, 0
38361, 8527, 8528, 8551, 8550, 0, 0, 0, 0
38362, 8528, 8529, 8552, 8551, 0, 0, 0, 0
38363, 8529, 8530, 8553, 8552, 0, 0, 0, 0
38364, 8530, 8531, 8554, 8553, 0, 0, 0, 0
38365, 8531, 999, 1000, 8554, 0, 0, 0, 0
38366, 989, 8532, 8555, 990, 0, 0, 0, 0
38367, 8532, 8533, 8556, 8555, 0, 0, 0, 0
38368, 8533, 8534, 8557, 8556, 0, 0, 0, 0
38369, 8534, 8535, 8558, 8557, 0, 0, 0, 0
38370, 8535, 8536, 8559, 8558, 0, 0, 0, 0
38371, 8536, 8537, 8560, 8559, 0, 0, 0, 0
38372, 8537, 8538, 8561, 8560, 0, 0, 0, 0
38373, 8538, 8539, 8562, 8561, 0, 0, 0, 0
38374, 8539, 8540, 8563, 8562, 0, 0, 0, 0
38375, 8540, 8541, 8564, 8563, 0, 0, 0, 0
38376, 8541, 8542, 8565, 8564, 0, 0, 0, 0
38377, 8542, 8543, 8566, 8565, 0, 0, 0, 0
38378, 8543, 8544, 8567, 8566, 0, 0, 0, 0
38379, 8544, 8545, 8568, 8567, 0, 0, 0, 0
38380, 8545, 8546, 8569, 8568, 0, 0, 0, 0
38381, 8546, 8547, 8570, 8569, 0, 0, 0, 0
38382, 8547, 8548, 8571, 8570, 0, 0, 0, 0
38383, 8548, 8549, 8572, 8571, 0, 0, 0, 0
38384, 8549, 8550, 8573, 8572, 0, 0, 0, 0
38385, 8550, 8551, 8574, 8573, 0, 0, 0, 0
38386, 8551, 8552, 8575, 8574, 0, 0, 0, 0
38387, 8552, 8553, 8576, 8575, 0, 0, 0, 0
38388, 8553, 8554, 8577, 8576, 0, 0, 0, 0
38389, 8554, 1000, 1001, 8577, 0, 0, 0, 0
38390, 990, 8555, 888, 37, 0, 0, 0, 0
38391, 8555, 8556, 889, 888, 0, 0, 0, 0
38392, 8556, 8557, 890, 889, 0, 0, 0, 0
38393, 8557, 8558, 891, 890, 0, 0, 0, 0
38394, 8558, 8559, 892, 891, 0, 0, 0, 0
38395, 8559, 8560, 893, 892, 0, 0, 0, 0
38396, 8560, 8561, 894, 893, 0, 0, 0, 0
38397, 8561, 8562, 895, 894, 0, 0, 0, 0
38398, 8562, 8563, 896, 895, 0, 0, 0, 0
38399, 8563, 8564, 897, 896, 0, 0, 0, 0
38400, 8564, 8565, 898, 897, 0, 0, 0, 0
38401, 8565, 8566, 899, 898, 0, 0, 0, 0
38402, 8566, 8567, 900, 899, 0, 0, 0, 0
38403, 8567, 8568, 901, 900, 0, 0, 0, 0
38404, 8568, 8569, 902, 901, 0, 0, 0, 0
38405, 8569, 8570, 903, 902, 0, 0, 0, 0
38406, 8570, 8571, 904, 903, 0, 0, 0, 0
38407, 8571, 8572, 905, 904, 0, 0, 0, 0
38408, 8572, 8573, 906, 905, 0, 0, 0, 0
38409, 8573, 8574, 907, 906, 0, 0, 0, 0
38410, 8574, 8575, 908, 907, 0, 0, 0, 0
38411, 8575, 8576, 909, 908, 0, 0, 0, 0
38412, 8576, 8577, 910, 909, 0, 0, 0, 0
38413, 8577, 1001, 38, 910, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface47
3101, 37, 41, 1002, 888, 0, 0, 0, 0
3102, 888, 1002, 1003, 889, 0, 0, 0, 0
3103, 889, 1003, 1004, 890, 0, 0, 0, 0
3104, 890, 1004, 1005, 891, 0, 0, 0, 0
3105, 891, 1005, 1006, 892, 0, 0, 0, 0
3106, 892, 1006, 1007, 893, 0, 0, 0, 0
3107, 893, 1007, 1008, 894, 0, 0, 0, 0
3108, 894, 1008, 1009, 895, 0, 0, 0, 0
3109, 895, 1009, 1010, 896, 0, 0, 0, 0
3110, 896, 1010, 1011, 897, 0, 0, 0, 0
3111, 897, 1011, 1012, 898, 0, 0, 0, 0
3112, 898, 1012, 1013, 899, 0, 0, 0, 0
3113, 899, 1013, 1014, 900, 0, 0, 0, 0
3114, 900, 1014, 1015, 901, 0, 0, 0, 0
3115, 901, 1015, 1016, 902, 0, 0, 0, 0
3116, 902, 1016, 1017, 903, 0, 0, 0, 0
3117, 903, 1017, 1018, 904, 0, 0, 0, 0
3118, 904, 1018, 1019, 905, 0, 0, 0, 0
3119, 905, 1019, 1020, 906, 0, 0, 0, 0
3120, 906, 1020, 1021, 907, 0, 0, 0, 0
3121, 907, 1021, 1022, 908, 0, 0, 0, 0
3122, 908, 1022, 1023, 909, 0, 0, 0, 0
3123, 909, 1023, 1024, 910, 0, 0, 0, 0
3124, 910, 1024, 42, 38, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface48
38414, 39, 957, 1027, 43, 0, 8578, 1050, 1025
38415, 957, 958, 1028, 1027, 0, 8579, 1051, 8578
38416, 958, 959, 1029, 1028, 0, 8580, 1052, 8579
38417, 959, 960, 1030, 1029, 0, 8581, 1053, 8580
38418, 960, 961, 1031, 1030, 0, 8582, 1054, 8581
38419, 961, 962, 1032, 1031, 0, 8583, 1055, 8582
38420, 962, 963, 1033, 1032, 0, 8584, 1056, 8583
38421, 963, 964, 1034, 1033, 0, 8585, 1057, 8584
38422, 964, 965, 1035, 1034, 0, 8586, 1058, 8585
38423, 965, 966, 1036, 1035, 0, 8587, 1059, 8586
38424, 966, 967, 1037, 1036, 0, 8588, 1060, 8587
38425, 967, 968, 1038, 1037, 0, 8589, 1061, 8588
38426, 968, 969, 1039, 1038, 0, 8590, 1062, 8589
38427, 969, 970, 1040, 1039, 0, 8591, 1063, 8590
38428, 970, 971, 1041, 1040, 0, 8592, 1064, 8591
38429, 971, 972, 1042, 1041, 0, 8593, 1065, 8592
38430, 972, 973, 1043, 1042, 0, 8594, 1066, 8593
38431, 973, 974, 1044, 1043, 0, 8595, 1067, 8594
38432, 974, 975, 1045, 1044, 0, 8596, 1068, 8595
38433, 975, 976, 1046, 1045, 0, 8597, 1069, 8596
38434, 976, 977, 1047, 1046, 0, 8598, 1070, 8597
38435, 977, 978, 1048, 1047, 0, 8599, 1071, 8598
38436, 978, 979, 1049, 1048, 0, 8600, 1072, 8599
38437, 979, 40, 44, 1049, 0, 1026, 1073, 8600
*ELEMENT, type=CPS8, ELSET=Surface49
38438, 39, 43, 1074, 980, 1025, 1085, 8601, 0
38439, 980, 1074, 1075, 981, 8601, 1086, 8602, 0
38440, 981, 1075, 1076, 982, 8602, 1087, 8603, 0
38441, 982, 1076, 1077, 983, 8603, 1088, 8604, 0
38442, 983, 1077, 1078, 984, 8604, 1089, 8605, 0
38443, 984, 1078, 1079, 985, 8605, 1090, 8606, 0
38444, 985, 1079, 1080, 986, 8606, 1091, 8607, 0
38445, 986, 1080, 1081, 987, 8607, 1092, 8608, 0
38446, 987, 1081, 1082, 988, 8608, 1093, 8609, 0
38447, 988, 1082, 1083, 989, 8609, 1094, 8610, 0
38448, 989, 1083, 1084, 990, 8610, 1095, 8611, 0
38449, 990, 1084, 41, 37, 8611, 1096, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface50
38450, 40, 991, 1097, 44, 0, 8612, 1108, 1026
38451, 991, 992, 1098, 1097, 0, 8613, 1109, 8612
38452, 992, 993, 1099, 1098, 0, 8614, 1110, 8613
38453, 993, 994, 1100, 1099, 0, 8615, 1111, 8614
38454, 994, 995, 1101, 1100, 0, 8616, 1112, 8615
38455, 995, 996, 1102, 1101, 0, 8617, 1113, 8616
38456, 996, 997, 1103, 1102, 0, 8618, 1114, 8617
38457, 997, 998, 1104, 1103, 0, 8619, 1115, 8618
38458, 998, 999, 1105, 1104, 0, 8620, 1116, 8619
38459, 999, 1000, 1106, 1105, 0, 8621, 1117, 8620
38460, 1000, 1001, 1107, 1106, 0, 8622, 1118, 8621
38461, 1001, 38, 42, 1107, 0, 0, 1119, 8622
*ELEMENT, type=CPS8, ELSET=Surface51
38462, 43, 1027, 8623, 1074, 1050, 8876, 8877, 1085
38463, 1027, 1028, 8624, 8623, 1051, 8878, 8879, 8876
38464, 1028, 1029, 8625, 8624, 1052, 8880, 8881, 8878
38465, 1029, 1030, 8626, 8625, 1053, 8882, 8883, 8880
38466, 1030, 1031, 8627, 8626, 1054, 8884, 8885, 8882
38467, 1031, 1032, 8628, 8627, 1055, 8886, 8887, 8884
38468, 1032, 1033, 8629, 8628, 1056, 8888, 8889, 8886
38469, 1033, 1034, 8630, 8629, 1057, 8890, 8891, 8888
38470, 1034, 1035, 8631, 8630, 1058, 8892, 8893, 8890
38471, 1035, 1036, 8632, 8631, 1059, 8894, 8895, 8892
38472, 1036, 1037, 8633, 8632, 1060, 8896, 8897, 8894
38473, 1037, 1038, 8634, 8633, 1061, 8898, 8899, 8896
38474, 1038, 1039, 8635, 8634, 1062, 8900, 8901, 8898
38475, 1039, 1040, 8636, 8635, 1063, 8902, 8903, 8900
38476, 1040, 1041, 8637, 8636, 1064, 8904, 8905, 8902
38477, 1041, 1042, 8638, 8637, 1065, 8906, 8907, 8904
38478, 1042, 1043, 8639, 8638, 1066, 8908, 8909, 8906
38479, 1043, 1044, 8640, 8639, 1067, 8910, 8911, 8908
38480, 1044, 1045, 8641, 8640, 1068, 8912, 8913, 8910
38481, 1045, 1046, 8642, 8641, 1069, 8914, 8915, 8912
38482, 1046, 1047, 8643, 8642, 1070, 8916, 8917, 8914
38483, 1047, 1048, 8644, 8643, 1071, 8918, 8919, 8916
38484, 1048, 1049, 8645, 8644, 1072, 8920, 8921, 8918
38485, 1049, 44, 1097, 8645, 1073, 1108, 8922, 8920
38486, 1074, 8623, 8646, 1075, 8877, 8923, 8924, 1086
38487, 8623, 8624, 8647, 8646, 8879, 8925, 8926, 8923
38488, 8624, 8625, 8648, 8647, 8881, 8927, 8928, 8925
38489, 8625, 8626, 8649, 8648, 8883, 8929, 8930, 8927
38490, 8626, 8627, 8650, 8649, 8885, 8931, 8932, 8929
38491, 8627, 8628, 8651, 8650, 8887, 8933, 8934, 8931
38492, 8628, 8629, 8652, 8651, 8889, 8935, 8936, 8933
38493, 8629, 8630, 8653, 8652, 8891, 8937, 8938, 8935
38494, 8630, 8631, 8654, 8653, 8893, 8939, 8940, 8937
38495, 8631, 8632, 8655, 8654, 8895, 8941, 8942, 8939
38496, 8632, 8633, 8656, 8655, 8897, 8943, 8944, 8941
38497, 8633, 8634, 8657, 8656, 8899, 8945, 8946, 8943
38498, 8634, 8635, 8658, 8657, 8901, 8947, 8948, 8945
38499, 8635, 8636, 8659, 8658, 8903, 8949, 8950, 8947
38500, 8636, 8637, 8660, 8659, 8905, 8951, 8952, 8949
38501, 8637, 8638, 8661, 8660, 8907, 8953, 8954, 8951
38502, 8638, 8639, 8662, 8661, 8909, 8955, 8956, 8953
38503, 8639, 8640, 8663, 8662, 8911, 8957, 8958, 8955
38504, 8640, 8641, 8664, 8663, 8913, 8959, 8960, 8957
38505, 8641, 8642, 8665, 8664, 8915, 8961, 8962, 8959
38506, 8642, 8643, 8666, 8665, 8917, 8963, 8964, 8961
38507, 8643, 8644, 8667, 8666, 8919, 8965, 8966, 8963
38508, 8644, 8645, 8668, 8667, 8921, 8967, 8968, 8965
38509, 8645, 1097, 1098, 8668, 8922, 1109, 8969, 8967
38510, 1075, 8646, 8669, 1076, 8924, 8970, 8971, 1087
38511, 8646, 8647, 8670, 8669, 8926, 8972, 8973, 8970
38512, 8647, 8648, 8671, 8670, 8928, 8974, 8975, 8972
38513, 8648, 8649, 8672, 8671, 8930, 8976, 8977, 8974
38514, 8649, 8650, 8673, 8672, 8932, 8978, 8979, 8976
38515, 8650, 8651, 8674, 8673, 8934, 8980, 8981, 8978
38516, 8651, 8652, 8675, 8674, 8936, 8982, 8983, 8980
38517, 8652, 8653, 8676, 8675, 8938, 8984, 8985, 8982
38518, 8653, 8654, 8677, 8676, 8940, 8986, 8987, 8984
38519, 8654, 8655, 8678, 8677, 8942, 8988, 8989, 8986
38520, 8655, 8656, 8679, 8678, 8944, 8990, 8991, 8988
38521, 8656, 8657, 8680, 8679, 8946, 8992, 8993, 8990
38522, 8657, 8658, 8681, 8680, 8948, 8994, 8995, 8992
38523, 8658, 8659, 8682, 8681, 8950, 8996, 8997, 8994
38524, 8659, 8660, 8683, 8682, 8952, 8998, 8999, 8996
38525, 8660, 8661, 8684, 8683, 8954, 9000, 9001, 8998
38526, 8661, 8662, 8685, 8684, 8956, 9002, 9003, 9000
38527, 8662, 8663, 8686, 8685, 8958, 9004, 9005, 9002
38528, 8663, 8664, 8687, 8686, 8960, 9006, 9007, 9004
38529, 8664, 8665, 8688, 8687, 8962, 9008, 9009, 9006
38530, 8665, 8666, 8689, 8688, 8964, 9010, 9011, 9008
38531, 8666, 8667, 8690, 8689, 8966, 9012, 9013, 9010
38532, 8667, 8668, 8691, 8690, 8968, 9014, 9015, 9012
38533, 8668, 1098, 1099, 8691, 8969, 1110, 9016, 9014
38534, 1076, 8669, 8692, 1077, 8971, 9017, 9018, 1088
38535, 8669, 8670, 8693, 8692, 8973, 9019, 9020, 9017
38536, 8670, 8671, 8694, 8693, 8975, 9021, 9022, 9019
38537, 8671, 8672, 8695, 8694, 8977, 9023, 9024, 9021
38538, 8672, 8673, 8696, 8695, 8979, 9025, 9026, 9023
38539, 8673, 8674, 8697, 8696, 8981, 9027, 9028, 9025
38540, 8674, 8675, 8698, 8697, 8983, 9029, 9030, 9027
38541, 8675, 8676, 8699, 8698, 8985, 9031, 9032, 9029
38542, 8676, 8677, 8700, 8699, 8987, 9033, 9034, 9031
38543, 8677, 8678, 8701, 8700, 8989, 9035, 9036, 9033
38544, 8678, 8679, 8702, 8701, 8991, 9037, 9038, 9035
38545, 8679, 8680, 8703, 8702, 8993, 9039, 9040, 9037
38546, 8680, 8681, 8704, 8703, 8995, 9041, 9042, 9039
38547, 8681, 8682, 8705, 8704, 8997, 9043, 9044, 9041
38548, 8682, 8683, 8706, 8705, 8999, 9045, 9046, 9043
38549, 8683, 8684, 8707, 8706, 9001, 9047, 9048, 9045
38550, 8684, 8685, 8708, 8707, 9003, 9049, 9050, 9047
38551, 8685, 8686, 8709, 8708, 9005, 9051, 9052, 9049
38552, 8686, 8687, 8710, 8709, 9007, 9053, 9054, 9051
38553, 8687, 8688, 8711, 8710, 9009, 9055, 9056, 9053
38554, 8688, 8689, 8712, 8711, 9011, 9057, 9058, 9055
38555, 8689, 8690, 8713, 8712, 9013, 9059, 9060, 9057
38556, 8690, 8691, 8714, 8713, 9015, 9061, 9062, 9059
38557, 8691, 1099, 1100, 8714, 9016, 1111, 9063, 9061
38558, 1077, 8692, 8715, 1078, 9018, 9064, 9065, 1089
38559, 8692, 8693, 8716, 8715, 9020, 9066, 9067, 9064
38560, 8693, 8694, 8717, 8716, 9022, 9068, 9069, 9066
38561, 8694, 8695, 8718, 8717, 9024, 9070, 9071, 9068
38562, 8695, 8696, 8719, 8718, 9026, 9072, 9073, 9070
38563, 8696, 8697, 8720, 8719, 9028, 9074, 9075, 9072
38564, 8697, 8698, 8721, 8720, 9030, 9076, 9077, 9074
38565, 8698, 8699, 8722, 8721, 9032, 9078, 9079, 9076
38566, 8699, 8700, 8723, 8722, 9034, 9080, 9081, 9078
38567, 8700, 8701, 8724, 8723, 9036, 9082, 9083, 9080
38568, 8701, 8702, 8725, 8724, 9038, 9084, 9085, 9082
38569, 8702, 8703, 8726, 8725, 9040, 9086, 9087, 9084
38570, 8703, 8704, 8727, 8726, 9042, 9088, 9089, 9086
38571, 8704, 8705, 8728, 8727, 9044, 9090, 9091, 9088
38572, 8705, 8706, 8729, 8728, 9046, 9092, 9093, 9090
38573, 8706, 8707, 8730, 8729, 9048, 9094, 9095, 9092
38574, 8707, 8708, 8731, 8730, 9050, 9096, 9097, 9094
38575, 8708, 8709, 8732, 8731, 9052, 9098, 9099, 9096
38576, 8709, 8710, 8733, 8732, 9054, 9100, 9101, 9098
38577, 8710, 8711, 8734, 8733, 9056, 9102, 9103, 9100
38578, 8711, 8712, 8735, 8734, 9058, 9104, 9105, 9102
38579, 8712, 8713, 8736, 8735, 9060, 9106, 9107, 9104
38580, 8713, 8714, 8737, 8736, 9062, 9108, 9109, 9106
38581, 8714, 1100, 1101, 8737, 9063, 1112, 9110, 9108
38582, 1078, 8715, 8738, 1079, 9065, 9111, 9112, 1090
38583, 8715, 8716, 8739, 8738, 9067, 9113, 9114, 9111
38584, 8716, 8717, 8740, 8739, 9069, 9115, 9116, 9113
38585, 8717, 8718, 8741, 8740, 9071, 9117, 9118, 9115
38586, 8718, 8719, 8742, 8741, 9073, 9119, 9120, 9117
38587, 8719, 8720, 8743, 8742, 9075, 9121, 9122, 9119
38588, 8720, 8721, 8744, 8743, 9077, 9123, 9124, 9121
38589, 8721, 8722, 8745, 8744, 9079, 9125, 9126, 9123
38590, 8722, 8723, 8746, 8745, 9081, 9127, 9128, 9125
38591, 8723, 8724, 8747, 8746, 9083, 9129, 9130, 9127
38592, 8724, 8725, 8748, 8747, 9085, 9131, 9132, 9129
38593, 8725, 8726, 8749, 8748, 9087, 9133, 9134, 9131
38594, 8726, 8727, 8750, 8749, 9089, 9135, 9136, 9133
38595, 8727, 8728, 8751, 8750, 9091, 9137, 9138, 9135
38596, 8728, 8729, 8752, 8751, 9093, 9139, 9140, 9137
38597, 8729, 8730, 8753, 8752, 9095, 9141, 9142, 9139
38598, 8730, 8731, 8754, 8753, 9097, 9143, 9144, 9141
38599, 8731, 8732, 8755, 8754, 9099, 9145, 9146, 9143
38600, 8732, 8733, 8756, 8755, 9101, 9147, 9148, 9145
38601, 8733, 8734, 8757, 8756, 9103, 9149, 9150, 9147
38602, 8734, 8735, 8758, 8757, 9105, 9151, 9152, 9149
38603, 8735, 8736, 8759, 8758, 9107, 9153, 9154, 9151
38604, 8736, 8737, 8760, 8759, 9109, 9155, 9156, 9153
38605, 8737, 1101, 1102, 8760, 9110, 1113, 9157, 9155
38606, 1079, 8738, 8761, 1080, 9112, 9158, 9159, 1091
38607, 8738, 8739, 8762, 8761, 9114, 9160, 9161, 9158
38608, 8739, 8740, 8763, 8762, 9116, 9162, 9163, 9160
38609, 8740, 8741, 8764, 8763, 9118, 9164, 9165, 9162
38610, 8741, 8742, 8765, 8764, 9120, 9166, 9167, 9164
38611, 8742, 8743, 8766, 8765, 9122, 9168, 9169, 9166
38612, 8743, 8744, 8767, 8766, 9124, 9170, 9171, 9168
38613, 8744, 8745, 8768, 8767, 9126, 9172, 9173, 9170
38614, 8745, 8746, 8769, 8768, 9128, 9174, 9175, 9172
38615, 8746, 8747, 8770, 8769, 9130, 9176, 9177, 9174
38616, 8747, 8748, 8771, 8770, 9132, 9178, 9179, 9176
38617, 8748, 8749, 8772, 8771, 9134, 9180, 9181, 9178
38618, 8749, 8750, 8773, 8772, 9136, 9182, 9183, 9180
38619, 8750, 8751, 8774, 8773, 9138, 9184, 9185, 9182
38620, 8751, 8752, 8775, 8774, 9140, 9186, 9187, 9184
38621, 8752, 8753, 8776, 8775, 9142, 9188, 9189, 9186
38622, 8753, 8754, 8777, 8776, 9144, 9190, 9191, 9188
38623, 8754, 8755, 8778, 8777, 9146, 9192, 9193, 9190
38624, 8755, 8756, 8779, 8778, 9148, 9194, 9195, 9192
38625, 8756, 8757, 8780, 8779, 9150, 9196, 9197, 9194
38626, 8757, 8758, 8781, 8780, 9152, 9198, 9199, 9196
38627, 8758, 8759, 8782, 8781, 9154, 9200, 9201, 9198
38628, 8759, 8760, 8783, 8782, 9156, 9202, 9203, 9200
38629, 8760, 1102, 1103, 8783, 9157, 1114, 9204, 9202
38630, 1080, 8761, 8784, 1081, 9159, 9205, 9206, 1092
38631, 8761, 8762, 8785, 8784, 9161, 9207, 9208, 9205
38632, 8762, 8763, 8786, 8785, 9163, 9209, 9210, 9207
38633, 8763, 8764, 8787, 8786, 9165, 9211, 9212, 9209
38634, 8764, 8765, 8788, 8787, 9167, 9213, 9214, 9211
38635, 8765, 8766, 8789, 8788, 9169, 9215, 9216, 9213
38636, 8766, 8767, 8790, 8789, 9171, 9217, 9218, 9215
38637, 8767, 8768, 8791, 8790, 9173, 9219, 9220, 9217
38638, 8768, 8769, 8792, 8791, 9175, 9221, 9222, 9219
38639, 8769, 8770, 8793, 8792, 9177, 9223, 9224, 9221
38640, 8770, 8771, 8794, 8793, 9179, 9225, 9226, 9223
38641, 8771, 8772, 8795, 8794, 9181, 9227, 9228, 9225
38642, 8772, 8773, 8796, 8795, 9183, 9229, 9230, 9227
38643, 8773, 8774, 8797, 8796, 9185, 9231, 9232, 9229
38644, 8774, 8775, 8798, 8797, 9187, 9233, 9234, 9231
38645, 8775, 8776, 8799, 8798, 9189, 9235, 9236, 9233
38646, 8776, 8777, 8800, 8799, 9191, 9237, 9238, 9235
38647, 8777, 8778, 8801, 8800, 9193, 9239, 9240, 9237
38648, 8778, 8779, 8802, 8801, 9195, 9241, 9242, 9239
38649, 8779, 8780, 8803, 8802, 9197, 9243, 9244, 9241
38650, 8780, 8781, 8804, 8803, 9199, 9245, 9246, 9243
38651, 8781, 8782, 8805, 8804, 9201, 9247, 9248, 9245
38652, 8782, 8783, 8806, 8805, 9203, 9249, 9250, 9247
38653, 8783, 1103, 1104, 8806, 9204, 1115, 9251, 9249
38654, 1081, 8784, 8807, 1082, 9206, 9252, 9253, 1093
38655, 8784, 8785, 8808, 8807, 9208, 9254, 9255, 9252
38656, 8785, 8786, 8809, 8808, 9210, 9256, 9257, 9254
38657, 8786, 8787, 8810, 8809, 9212, 9258, 9259, 9256
38658, 8787, 8788, 8811, 8810, 9214, 9260, 9261, 9258
38659, 8788, 8789, 8812, 8811, 9216, 9262, 9263, 9260
38660, 8789, 8790, 8813, 8812, 9218, 9264, 9265, 9262
38661, 8790, 8791, 8814, 8813, 9220, 9266, 9267, 9264
38662, 8791, 8792, 8815, 8814, 9222, 9268, 9269, 9266
38663, 8792, 8793, 8816, 8815, 9224, 9270, 9271, 9268
38664, 8793, 8794, 8817, 8816, 9226, 9272, 9273, 9270
38665, 8794, 8795, 8818, 8817, 9228, 9274, 9275, 9272
38666, 8795, 8796, 8819, 8818, 9230, 9276, 9277, 9274
38667, 8796, 8797, 8820, 8819, 9232, 9278, 9279, 9276
38668, 8797, 8798, 8821, 8820, 9234, 9280, 9281, 9278
38669, 8798, 8799, 8822, 8821, 9236, 9282, 9283, 9280
38670, 8799, 8800, 8823, 8822, 9238, 9284, 9285, 9282
38671, 8800, 8801, 8824, 8823, 9240, 9286, 9287, 9284
38672, 8801, 8802, 8825, 8824, 9242, 9288, 9289, 9286
38673, 8802, 8803, 8826, 8825, 9244, 9290, 9291, 9288
38674, 8803, 8804, 8827, 8826, 9246, 9292, 9293, 9290
38675, 8804, 8805, 8828, 8827, 9248, 9294, 9295, 9292
38676, 8805, 8806, 8829, 8828, 9250, 9296, 9297, 9294
38677, 8806, 1104, 1105, 8829, 9251, 1116, 9298, 9296
38678, 1082, 8807, 8830, 1083, 9253, 9299, 9300, 1094
38679, 8807, 8808, 8831, 8830, 9255, 9301, 9302, 9299
38680, 8808, 8809, 8832, 8831, 9257, 9303, 9304, 9301
38681, 8809, 8810, 8833, 8832, 9259, 9305, 9306, 9303
38682, 8810, 8811, 8834, 8833, 9261, 9307, 9308, 9305
38683, 8811, 8812, 8835, 8834, 9263, 9309, 9310, 9307
38684, 8812, 8813, 8836, 8835, 9265, 9311, 9312, 9309
38685, 8813, 8814, 8837, 8836, 9267, 9313, 9314, 9311
38686, 8814, 8815, 8838, 8837, 9269, 9315, 9316, 9313
38687, 8815, 8816, 8839, 8838, 9271, 9317, 9318, 9315
38688, 8816, 8817, 8840, 8839, 9273, 9319, 9320, 9317
38689, 8817, 8818, 8841, 8840, 9275, 9321, 9322, 9319
38690, 8818, 8819, 8842, 8841, 9277, 9323, 9324, 9321
38691, 8819, 8820, 8843, 8842, 9279, 9325, 9326, 9323
38692, 8820, 8821, 8844, 8843, 9281, 9327, 9328, 9325
38693, 8821, 8822, 8845, 8844, 9283, 9329, 9330, 9327
38694, 8822, 8823, 8846, 8845, 9285, 9331, 9332, 9329
38695, 8823, 8824, 8847, 8846, 9287, 9333, 9334, 9331
38696, 8824, 8825, 8848, 8847, 9289, 9335, 9336, 9333
38697, 8825, 8826, 8849, 8848, 9291, 9337, 9338, 9335
38698, 8826, 8827, 8850, 8849, 9293, 9339, 9340, 9337
38699, 8827, 8828, 8851, 8850, 9295, 9341, 9342, 9339
38700, 8828, 8829, 8852, 8851, 9297, 9343, 9344, 9341
38701, 8829, 1105, 1106, 8852, 9298, 1117, 9345, 9343
38702, 1083, 8830, 8853, 1084, 9300, 9346, 9347, 1095
38703, 8830, 8831, 8854, 8853, 9302, 9348, 9349, 9346
38704, 8831, 8832, 8855, 8854, 9304, 9350, 9351, 9348
38705, 8832, 8833, 8856, 8855, 9306, 9352, 9353, 9350
38706, 8833, 8834, 8857, 8856, 9308, 9354, 9355, 9352
38707, 8834, 8835, 8858, 8857, 9310, 9356, 9357, 9354
38708, 8835, 8836, 8859, 8858, 9312, 9358, 9359, 9356
38709, 8836, 8837, 8860, 8859, 9314, 9360, 9361, 9358
38710, 8837, 8838, 8861, 8860, 9316, 9362, 9363, 9360
38711, 8838, 8839, 8862, 8861, 9318, 9364, 9365, 9362
38712, 8839, 8840, 8863, 8862, 9320, 9366, 9367, 9364
38713, 8840, 8841, 8864, 8863, 9322, 9368, 9369, 9366
38714, 8841, 8842, 8865, 8864, 9324, 9370, 9371, 9368
38715, 8842, 8843, 8866, 8865, 9326, 9372, 9373, 9370
38716, 8843, 8844, 8867, 8866, 9328, 9374, 9375, 9372
38717, 8844, 8845, 8868, 8867, 9330, 9376, 9377, 9374
38718, 8845, 8846, 8869, 8868, 9332, 9378, 9379, 9376
38719, 8846, 8847, 8870, 8869, 9334, 9380, 9381, 9378
38720, 8847, 8848, 8871, 8870, 9336, 9382, 9383, 9380
38721, 8848, 8849, 8872, 8871, 9338, 9384, 9385, 9382
38722, 8849, 8850, 8873, 8872, 9340, 9386, 9387, 9384
38723, 8850, 8851, 8874, 8873, 9342, 9388, 9389, 9386
38724, 8851, 8852, 8875, 8874, 9344, 9390, 9391, 9388
38725, 8852, 1106, 1107, 8875, 9345, 1118, 9392, 9390
38726, 1084, 8853, 1002, 41, 9347, 9393, 0, 1096
38727, 8853, 8854, 1003, 1002, 9349, 9394, 0, 9393
38728, 8854, 8855, 1004, 1003, 9351, 9395, 0, 9394
38729, 8855, 8856, 1005, 1004, 9353, 9396, 0, 9395
38730, 8856, 8857, 1006, 1005, 9355, 9397, 0, 9396
38731, 8857, 8858, 1007, 1006, 9357, 9398, 0, 9397
38732, 8858, 8859, 1008, 1007, 9359, 9399, 0, 9398
38733, 8859, 8860, 1009, 1008, 9361, 9400, 0, 9399
38734, 8860, 8861, 1010, 1009, 9363, 9401, 0, 9400
38735, 8861, 8862, 1011, 1010, 9365, 9402, 0, 9401
38736, 8862, 8863, 1012, 1011, 9367, 9403, 0, 9402
38737, 8863, 8864, 1013, 1012, 9369, 9404, 0, 9403
38738, 8864, 8865, 1014, 1013, 9371, 9405, 0, 9404
38739, 8865, 8866, 1015, 1014, 9373, 9406, 0, 9405
38740, 8866, 8867, 1016, 1015, 9375, 9407, 0, 9406
38741, 8867, 8868, 1017, 1016, 9377, 9408, 0, 9407
38742, 8868, 8869, 1018, 1017, 9379, 9409, 0, 9408
38743, 8869, 8870, 1019, 1018, 9381, 9410, 0, 9409
38744, 8870, 8871, 1020, 1019, 9383, 9411, 0, 9410
38745, 8871, 8872, 1021, 1020, 9385, 9412, 0, 9411
38746, 8872, 8873, 1022, 1021, 9387, 9413, 0, 9412
38747, 8873, 8874, 1023, 1022, 9389, 9414, 0, 9413
38748, 8874, 8875, 1024, 1023, 9391, 9415, 0, 9414
38749, 8875, 1107, 42, 1024, 9392, 1119, 0, 9415
*ELEMENT, type=CPS8, ELSET=Surface52
3125, 41, 1120, 9416, 1002, 0, 0, 0, 0
3126, 1120, 1121, 9417, 9416, 0, 0, 0, 0
3127, 1121, 45, 1124, 9417, 0, 0, 0, 0
3128, 1002, 9416, 9418, 1003, 0, 0, 0, 0
3129, 9416, 9417, 9419, 9418, 0, 0, 0, 0
3130, 9417, 1124, 1125, 9419, 0, 0, 0, 0
3131, 1003, 9418, 9420, 1004, 0, 0, 0, 0
3132, 9418, 9419, 9421, 9420, 0, 0, 0, 0
3133, 9419, 1125, 1126, 9421, 0, 0, 0, 0
3134, 1004, 9420, 9422, 1005, 0, 0, 0, 0
3135, 9420, 9421, 9423, 9422, 0, 0, 0, 0
3136, 9421, 1126, 1127, 9423, 0, 0, 0, 0
3137, 1005, 9422, 9424, 1006, 0, 0, 0, 0
3138, 9422, 9423, 9425, 9424, 0, 0, 0, 0
3139, 9423, 1127, 1128, 9425, 0, 0, 0, 0
3140, 1006, 9424, 9426, 1007, 0, 0, 0, 0
3141, 9424, 9425, 9427, 9426, 0, 0, 0, 0
3142, 9425, 1128, 1129, 9427, 0, 0, 0, 0
3143, 1007, 9426, 9428, 1008, 0, 0, 0, 0
3144, 9426, 9427, 9429, 9428, 0, 0, 0, 0
3145, 9427, 1129, 1130, 9429, 0, 0, 0, 0
3146, 1008, 9428, 9430, 1009, 0, 0, 0, 0
3147, 9428, 9429, 9431, 9430, 0, 0, 0, 0
3148, 9429, 1130, 1131, 9431, 0, 0, 0, 0
3149, 1009, 9430, 9432, 1010, 0, 0, 0, 0
3150, 9430, 9431, 9433, 9432, 0, 0, 0, 0
3151, 9431, 1131, 1132, 9433, 0, 0, 0, 0
3152, 1010, 9432, 9434, 1011, 0, 0, 0, 0
3153, 9432, 9433, 9435, 9434, 0, 0, 0, 0
3154, 9433, 1132, 1133, 9435, 0, 0, 0, 0
3155, 1011, 9434, 9436, 1012, 0, 0, 0, 0
3156, 9434, 9435, 9437, 9436, 0, 0, 0, 0
3157, 9435, 1133, 1134, 9437, 0, 0, 0, 0
3158, 1012, 9436, 9438, 1013, 0, 0, 0, 0
3159, 9436, 9437, 9439, 9438, 0, 0, 0, 0
3160, 9437, 1134, 1135, 9439, 0, 0, 0, 0
3161, 1013, 9438, 9440, 1014, 0, 0, 0, 0
3162, 9438, 9439, 9441, 9440, 0, 0, 0, 0
3163, 9439, 1135, 1136, 9441, 0, 0, 0, 0
3164, 1014, 9440, 9442, 1015, 0, 0, 0, 0
3165, 9440, 9441, 9443, 9442, 0, 0, 0, 0
3166, 9441, 1136, 1137, 9443, 0, 0, 0, 0
3167, 1015, 9442, 9444, 1016, 0, 0, 0, 0
3168, 9442, 9443, 9445, 9444, 0, 0, 0, 0
3169, 9443, 1137, 1138, 9445, 0, 0, 0, 0
3170, 1016, 9444, 9446, 1017, 0, 0, 0, 0
3171, 9444, 9445, 9447, 9446, 0, 0, 0, 0
3172, 9445, 1138, 1139, 9447, 0, 0, 0, 0
3173, 1017, 9446, 9448, 1018, 0, 0, 0, 0
3174, 9446, 9447, 9449, 9448, 0, 0, 0, 0
3175, 9447, 1139, 1140, 9449, 0, 0, 0, 0
3176, 1018, 9448, 9450, 1019, 0, 0, 0, 0
3177, 9448, 9449, 9451, 9450, 0, 0, 0, 0
3178, 9449, 1140, 1141, 9451, 0, 0, 0, 0
3179, 1019, 9450, 9452, 1020, 0, 0, 0, 0
3180, 9450, 9451, 9453, 9452, 0, 0, 0, 0
3181, 9451, 1141, 1142, 9453, 0, 0, 0, 0
3182, 1020, 9452, 9454, 1021, 0, 0, 0, 0
3183, 9452, 9453, 9455, 9454, 0, 0, 0, 0
3184, 9453, 1142, 1143, 9455, 0, 0, 0, 0
3185, 1021, 9454, 9456, 1022, 0, 0, 0, 0
3186, 9454, 9455, 9457, 9456, 0, 0, 0, 0
3187, 9455, 1143, 1144, 9457, 0, 0, 0, 0
3188, 1022, 9456, 9458, 1023, 0, 0, 0, 0
3189, 9456, 9457, 9459, 9458, 0, 0, 0, 0
3190, 9457, 1144, 1145, 9459, 0, 0, 0, 0
3191, 1023, 9458, 9460, 1024, 0, 0, 0, 0
3192, 9458, 9459, 9461, 9460, 0, 0, 0, 0
3193, 9459, 1145, 1146, 9461, 0, 0, 0, 0
3194, 1024, 9460, 1122, 42, 0, 0, 0, 0
3195, 9460, 9461, 1123, 1122, 0, 0, 0, 0
3196, 9461, 1146, 46, 1123, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface53
38750, 43, 1027, 9462, 1147, 1050, 9508, 9509, 1149
38751, 1147, 9462, 9463, 1148, 9509, 9510, 9511, 1150
38752, 1148, 9463, 1157, 47, 9511, 9512, 0, 1151
38753, 1027, 1028, 9464, 9462, 1051, 9513, 9514, 9508
38754, 9462, 9464, 9465, 9463, 9514, 9515, 9516, 9510
38755, 9463, 9465, 1158, 1157, 9516, 9517, 0, 9512
38756, 1028, 1029, 9466, 9464, 1052, 9518, 9519, 9513
38757, 9464, 9466, 9467, 9465, 9519, 9520, 9521, 9515
38758, 9465, 9467, 1159, 1158, 9521, 9522, 0, 9517
38759, 1029, 1030, 9468, 9466, 1053, 9523, 9524, 9518
38760, 9466, 9468, 9469, 9467, 9524, 9525, 9526, 9520
38761, 9467, 9469, 1160, 1159, 9526, 9527, 0, 9522
38762, 1030, 1031, 9470, 9468, 1054, 9528, 9529, 9523
38763, 9468, 9470, 9471, 9469, 9529, 9530, 9531, 9525
38764, 9469, 9471, 1161, 1160, 9531, 9532, 0, 9527
38765, 1031, 1032, 9472, 9470, 1055, 9533, 9534, 9528
38766, 9470, 9472, 9473, 9471, 9534, 9535, 9536, 9530
38767, 9471, 9473, 1162, 1161, 9536, 9537, 0, 9532
38768, 1032, 1033, 9474, 9472, 1056, 9538, 9539, 9533
38769, 9472, 9474, 9475, 9473, 9539, 9540, 9541, 9535
38770, 9473, 9475, 1163, 1162, 9541, 9542, 0, 9537
38771, 1033, 1034, 9476, 9474, 1057, 9543, 9544, 9538
38772, 9474, 9476, 9477, 9475, 9544, 9545, 9546, 9540
38773, 9475, 9477, 1164, 1163, 9546, 9547, 0, 9542
38774, 1034, 1035, 9478, 9476, 1058, 9548, 9549, 9543
38775, 9476, 9478, 9479, 9477, 9549, 9550, 9551, 9545
38776, 9477, 9479, 1165, 1164, 9551, 9552, 0, 9547
38777, 1035, 1036, 9480, 9478, 1059, 9553, 9554, 9548
38778, 9478, 9480, 9481, 9479, 9554, 9555, 9556, 9550
38779, 9479, 9481, 1166, 1165, 9556, 9557, 0, 9552
38780, 1036, 1037, 9482, 9480, 1060, 9558, 9559, 9553
38781, 9480, 9482, 9483, 9481, 9559, 9560, 9561, 9555
38782, 9481, 9483, 1167, 1166, 9561, 9562, 0, 9557
38783, 1037, 1038, 9484, 9482, 1061, 9563, 9564, 9558
38784, 9482, 9484, 9485, 9483, 9564, 9565, 9566, 9560
38785, 9483, 9485, 1168, 1167, 9566, 9567, 0, 9562
38786, 1038, 1039, 9486, 9484, 1062, 9568, 9569, 9563
38787, 9484, 9486, 9487, 9485, 9569, 9570, 9571, 9565
38788, 9485, 9487, 1169, 1168, 9571, 9572, 0, 9567
38789, 1039, 1040, 9488, 9486, 1063, 9573, 9574, 9568
38790, 9486, 9488, 9489, 9487, 9574, 9575, 9576, 9570
38791, 9487, 9489, 1170, 1169, 9576, 9577, 0, 9572
38792, 1040, 1041, 9490, 9488, 1064, 9578, 9579, 9573
38793, 9488, 9490, 9491, 9489, 9579, 9580, 9581, 9575
38794, 9489, 9491, 1171, 1170, 9581, 9582, 0, 9577
38795, 1041, 1042, 9492, 9490, 1065, 9583, 9584, 9578
38796, 9490, 9492, 9493, 9491, 9584, 9585, 9586, 9580
38797, 9491, 9493, 1172, 1171, 9586, 9587, 0, 9582
38798, 1042, 1043, 9494, 9492, 1066, 9588, 9589, 9583
38799, 9492, 9494, 9495, 9493, 9589, 9590, 9591, 9585
38800, 9493, 9495, 1173, 1172, 9591, 9592, 0, 9587
38801, 1043, 1044, 9496, 9494, 1067, 9593, 9594, 9588
38802, 9494, 9496, 9497, 9495, 9594, 9595, 9596, 9590
38803, 9495, 9497, 1174, 1173, 9596, 9597, 0, 9592
38804, 1044, 1045, 9498, 9496, 1068, 9598, 9599, 9593
38805, 9496, 9498, 9499, 9497, 9599, 9600, 9601, 9595
38806, 9497, 9499, 1175, 1174, 9601, 9602, 0, 9597
38807, 1045, 1046, 9500, 9498, 1069, 9603, 9604, 9598
38808, 9498, 9500, 9501, 9499, 9604, 9605, 9606, 9600
38809, 9499, 9501, 1176, 1175, 9606, 9607, 0, 9602
38810, 1046, 1047, 9502, 9500, 1070, 9608, 9609, 9603
38811, 9500, 9502, 9503, 9501, 9609, 9610, 9611, 9605
38812, 9501, 9503, 1177, 1176, 9611, 9612, 0, 9607
38813, 1047, 1048, 9504, 9502, 1071, 9613, 9614, 9608
38814, 9502, 9504, 9505, 9503, 9614, 9615, 9616, 9610
38815, 9503, 9505, 1178, 1177, 9616, 9617, 0, 9612
38816, 1048, 1049, 9506, 9504, 1072, 9618, 9619, 9613
38817, 9504, 9506, 9507, 9505, 9619, 9620, 9621, 9615
38818, 9505, 9507, 1179, 1178, 9621, 9622, 0, 9617
38819, 1049, 44, 1152, 9506, 1073, 1154, 9623, 9618
38820, 9506, 1152, 1153, 9507, 9623, 1155, 9624, 9620
38821, 9507, 1153, 48, 1179, 9624, 1156, 0, 9622
*ELEMENT, type=CPS8, ELSET=Surface54
38822, 43, 1147, 9625, 1074, 1149, 9647, 9648, 1085
38823, 1147, 1148, 9626, 9625, 1150, 9649, 9650, 9647
38824, 1148, 47, 1180, 9626, 1151, 0, 9651, 9649
38825, 1074, 9625, 9627, 1075, 9648, 9652, 9653, 1086
38826, 9625, 9626, 9628, 9627, 9650, 9654, 9655, 9652
38827, 9626, 1180, 1181, 9628, 9651, 0, 9656, 9654
38828, 1075, 9627, 9629, 1076, 9653, 9657, 9658, 1087
38829, 9627, 9628, 9630, 9629, 9655, 9659, 9660, 9657
38830, 9628, 1181, 1182, 9630, 9656, 0, 9661, 9659
38831, 1076, 9629, 9631, 1077, 9658, 9662, 9663, 1088
38832, 9629, 9630, 9632, 9631, 9660, 9664, 9665, 9662
38833, 9630, 1182, 1183, 9632, 9661, 0, 9666, 9664
38834, 1077, 9631, 9633, 1078, 9663, 9667, 9668, 1089
38835, 9631, 9632, 9634, 9633, 9665, 9669, 9670, 9667
38836, 9632, 1183, 1184, 9634, 9666, 0, 9671, 9669
38837, 1078, 9633, 9635, 1079, 9668, 9672, 9673, 1090
38838, 9633, 9634, 9636, 9635, 9670, 9674, 9675, 9672
38839, 9634, 1184, 1185, 9636, 9671, 0, 9676, 9674
38840, 1079, 9635, 9637, 1080, 9673, 9677, 9678, 1091
38841, 9635, 9636, 9638, 9637, 9675, 9679, 9680, 9677
38842, 9636, 1185, 1186, 9638, 9676, 0, 9681, 9679
38843, 1080, 9637, 9639, 1081, 9678, 9682, 9683, 1092
38844, 9637, 9638, 9640, 9639, 9680, 9684, 9685, 9682
38845, 9638, 1186, 1187, 9640, 9681, 0, 9686, 9684
38846, 1081, 9639, 9641, 1082, 9683, 9687, 9688, 1093
38847, 9639, 9640, 9642, 9641, 9685, 9689, 9690, 9687
38848, 9640, 1187, 1188, 9642, 9686, 0, 9691, 9689
38849, 1082, 9641, 9643, 1083, 9688, 9692, 9693, 1094
38850, 9641, 9642, 9644, 9643, 9690, 9694, 9695, 9692
38851, 9642, 1188, 1189, 9644, 9691, 0, 9696, 9694
38852, 1083, 9643, 9645, 1084, 9693, 9697, 9698, 1095
38853, 9643, 9644, 9646, 9645, 9695, 9699, 9700, 9697
38854, 9644, 1189, 1190, 9646, 9696, 0, 9701, 9699
38855, 1084, 9645, 1120, 41, 9698, 9702, 0, 1096
38856, 9645, 9646, 1121, 1120, 9700, 9703, 0, 9702
38857, 9646, 1190, 45, 1121, 9701, 0, 0, 9703
*ELEMENT, type=CPS8, ELSET=Surface55
38858, 44, 1097, 9704, 1152, 1108, 9726, 9727, 1154
38859, 1152, 9704, 9705, 1153, 9727, 9728, 9729, 1155
38860, 1153, 9705, 1191, 48, 9729, 9730, 0, 1156
38861, 1097, 1098, 9706, 9704, 1109, 9731, 9732, 9726
38862, 9704, 9706, 9707, 9705, 9732, 9733, 9734, 9728
38863, 9705, 9707, 1192, 1191, 9734, 9735, 0, 9730
38864, 1098, 1099, 9708, 9706, 1110, 9736, 9737, 9731
38865, 9706, 9708, 9709, 9707, 9737, 9738, 9739, 9733
38866, 9707, 9709, 1193, 1192, 9739, 9740, 0, 9735
38867, 1099, 1100, 9710, 9708, 1111, 9741, 9742, 9736
38868, 9708, 9710, 9711, 9709, 9742, 9743, 9744, 9738
38869, 9709, 9711, 1194, 1193, 9744, 9745, 0, 9740
38870, 1100, 1101, 9712, 9710, 1112, 9746, 9747, 9741
38871, 9710, 9712, 9713, 9711, 9747, 9748, 9749, 9743
38872, 9711, 9713, 1195, 1194, 9749, 9750, 0, 9745
38873, 1101, 1102, 9714, 9712, 1113, 9751, 9752, 9746
38874, 9712, 9714, 9715, 9713, 9752, 9753, 9754, 9748
38875, 9713, 9715, 1196, 1195, 9754, 9755, 0, 9750
38876, 1102, 1103, 9716, 9714, 1114, 9756, 9757, 9751
38877, 9714, 9716, 9717, 9715, 9757, 9758, 9759, 9753
38878, 9715, 9717, 1197, 1196, 9759, 9760, 0, 9755
38879, 1103, 1104, 9718, 9716, 1115, 9761, 9762, 9756
38880, 9716, 9718, 9719, 9717, 9762, 9763, 9764, 9758
38881, 9717, 9719, 1198, 1197, 9764, 9765, 0, 9760
38882, 1104, 1105, 9720, 9718, 1116, 9766, 9767, 9761
38883, 9718, 9720, 9721, 9719, 9767, 9768, 9769, 9763
38884, 9719, 9721, 1199, 1198, 9769, 9770, 0, 9765
38885, 1105, 1106, 9722, 9720, 1117, 9771, 9772, 9766
38886, 9720, 9722, 9723, 9721, 9772, 9773, 9774, 9768
38887, 9721, 9723, 1200, 1199, 9774, 9775, 0, 9770
38888, 1106, 1107, 9724, 9722, 1118, 9776, 9777, 9771
38889, 9722, 9724, 9725, 9723, 9777, 9778, 9779, 9773
38890, 9723, 9725, 1201, 1200, 9779, 9780, 0, 9775
38891, 1107, 42, 1122, 9724, 1119, 0, 9781, 9776
38892, 9724, 1122, 1123, 9725, 9781, 0, 9782, 9778
38893, 9725, 1123, 46, 1201, 9782, 0, 0, 9780
*ELEMENT, type=CPS8, ELSET=Surface56
3197, 47, 1157, 9783, 1180, 0, 0, 0, 0
3198, 1157, 1158, 9784, 9783, 0, 0, 0, 0
3199, 1158, 1159, 9785, 9784, 0, 0, 0, 0
3200, 1159, 1160, 9786, 9785, 0, 0, 0, 0
3201, 1160, 1161, 9787, 9786, 0, 0, 0, 0
3202, 1161, 1162, 9788, 9787, 0, 0, 0, 0
3203, 1162, 1163, 9789, 9788, 0, 0, 0, 0
3204, 1163, 1164, 9790, 9789, 0, 0, 0, 0
3205, 1164, 1165, 9791, 9790, 0, 0, 0, 0
3206, 1165, 1166, 9792, 9791, 0, 0, 0, 0
3207, 1166, 1167, 9793, 9792, 0, 0, 0, 0
3208, 1167, 1168, 9794, 9793, 0, 0, 0, 0
3209, 1168, 1169, 9795, 9794, 0, 0, 0, 0
3210, 1169, 1170, 9796, 9795, 0, 0, 0, 0
3211, 1170, 1171, 9797, 9796, 0, 0, 0, 0
3212, 1171, 1172, 9798, 9797, 0, 0, 0, 0
3213, 1172, 1173, 9799, 9798, 0, 0, 0, 0
3214, 1173, 1174, 9800, 9799, 0, 0, 0, 0
3215, 1174, 1175, 9801, 9800, 0, 0, 0, 0
3216, 1175, 1176, 9802, 9801, 0, 0, 0, 0
3217, 1176, 1177, 9803, 9802, 0, 0, 0, 0
3218, 1177, 1178, 9804, 9803, 0, 0, 0, 0
3219, 1178, 1179, 9805, 9804, 0, 0, 0, 0
3220, 1179, 48, 1191, 9805, 0, 0, 0, 0
3221, 1180, 9783, 9806, 1181, 0, 0, 0, 0
3222, 9783, 9784, 9807, 9806, 0, 0, 0, 0
3223, 9784, 9785, 9808, 9807, 0, 0, 0, 0
3224, 9785, 9786, 9809, 9808, 0, 0, 0, 0
3225, 9786, 9787, 9810, 9809, 0, 0, 0, 0
3226, 9787, 9788, 9811, 9810, 0, 0, 0, 0
3227, 9788, 9789, 9812, 9811, 0, 0, 0, 0
3228, 9789, 9790, 9813, 9812, 0, 0, 0, 0
3229, 9790, 9791, 9814, 9813, 0, 0, 0, 0
3230, 9791, 9792, 9815, 9814, 0, 0, 0, 0
3231, 9792, 9793, 9816, 9815, 0, 0, 0, 0
3232, 9793, 9794, 9817, 9816, 0, 0, 0, 0
3233, 9794, 9795, 9818, 9817, 0, 0, 0, 0
3234, 9795, 9796, 9819, 9818, 0, 0, 0, 0
3235, 9796, 9797, 9820, 9819, 0, 0, 0, 0
3236, 9797, 9798, 9821, 9820, 0, 0, 0, 0
3237, 9798, 9799, 9822, 9821, 0, 0, 0, 0
3238, 9799, 9800, 9823, 9822, 0, 0, 0, 0
3239, 9800, 9801, 9824, 9823, 0, 0, 0, 0
3240, 9801, 9802, 9825, 9824, 0, 0, 0, 0
3241, 9802, 9803, 9826, 9825, 0, 0, 0, 0
3242, 9803, 9804, 9827, 9826, 0, 0, 0, 0
3243, 9804, 9805, 9828, 9827, 0, 0, 0, 0
3244, 9805, 1191, 1192, 9828, 0, 0, 0, 0
3245, 1181, 9806, 9829, 1182, 0, 0, 0, 0
3246, 9806, 9807, 9830, 9829, 0, 0, 0, 0
3247, 9807, 9808, 9831, 9830, 0, 0, 0, 0
3248, 9808, 9809, 9832, 9831, 0, 0, 0, 0
3249, 9809, 9810, 9833, 9832, 0, 0, 0, 0
3250, 9810, 9811, 9834, 9833, 0, 0, 0, 0
3251, 9811, 9812, 9835, 9834, 0, 0, 0, 0
3252, 9812, 9813, 9836, 9835, 0, 0, 0, 0
3253, 9813, 9814, 9837, 9836, 0, 0, 0, 0
3254, 9814, 9815, 9838, 9837, 0, 0, 0, 0
3255, 9815, 9816, 9839, 9838, 0, 0, 0, 0
3256, 9816, 9817, 9840, 9839, 0, 0, 0, 0
3257, 9817, 9818, 9841, 9840, 0, 0, 0, 0
3258, 9818, 9819, 9842, 9841, 0, 0, 0, 0
3259, 9819, 9820, 9843, 9842, 0, 0, 0, 0
3260, 9820, 9821, 9844, 9843, 0, 0, 0, 0
3261, 9821, 9822, 9845, 9844, 0, 0, 0, 0
3262, 9822, 9823, 9846, 9845, 0, 0, 0, 0
3263, 9823, 9824, 9847, 9846, 0, 0, 0, 0
3264, 9824, 9825, 9848, 9847, 0, 0, 0, 0
3265, 9825, 9826, 9849, 9848, 0, 0, 0, 0
3266, 9826, 9827, 9850, 9849, 0, 0, 0, 0
3267, 9827, 9828, 9851, 9850, 0, 0, 0, 0
3268, 9828, 1192, 1193, 9851, 0, 0, 0, 0
3269, 1182, 9829, 9852, 1183, 0, 0, 0, 0
3270, 9829, 9830, 9853, 9852, 0, 0, 0, 0
3271, 9830, 9831, 9854, 9853, 0, 0, 0, 0
3272, 9831, 9832, 9855, 9854, 0, 0, 0, 0
3273, 9832, 9833, 9856, 9855, 0, 0, 0, 0
3274, 9833, 9834, 9857, 9856, 0, 0, 0, 0
3275, 9834, 9835, 9858, 9857, 0, 0, 0, 0
3276, 9835, 9836, 9859, 9858, 0, 0, 0, 0
3277, 9836, 9837, 9860, 9859, 0, 0, 0, 0
3278, 9837, 9838, 9861, 9860, 0, 0, 0, 0
3279, 9838, 9839, 9862, 9861, 0, 0, 0, 0
3280, 9839, 9840, 9863, 9862, 0, 0, 0, 0
3281, 9840, 9841, 9864, 9863, 0, 0, 0, 0
3282, 9841, 9842, 9865, 9864, 0, 0, 0, 0
3283, 9842, 9843, 9866, 9865, 0, 0, 0, 0
3284, 9843, 9844, 9867, 9866, 0, 0, 0, 0
3285, 9844, 9845, 9868, 9867, 0, 0, 0, 0
3286, 9845, 9846, 9869, 9868, 0, 0, 0, 0
3287, 9846, 9847, 9870, 9869, 0, 0, 0, 0
3288, 9847, 9848, 9871, 9870, 0, 0, 0, 0
3289, 9848, 9849, 9872, 9871, 0, 0, 0, 0
3290, 9849, 9850, 9873, 9872, 0, 0, 0, 0
3291, 9850, 9851, 9874, 9873, 0, 0, 0, 0
3292, 9851, 1193, 1194, 9874, 0, 0, 0, 0
3293, 1183, 9852, 9875, 1184, 0, 0, 0, 0
3294, 9852, 9853, 9876, 9875, 0, 0, 0, 0
3295, 9853, 9854, 9877, 9876, 0, 0, 0, 0
3296, 9854, 9855, 9878, 9877, 0, 0, 0, 0
3297, 9855, 9856, 9879, 9878, 0, 0, 0, 0
3298, 9856, 9857, 9880, 9879, 0, 0, 0, 0
3299, 9857, 9858, 9881, 9880, 0, 0, 0, 0
3300, 9858, 9859, 9882, 9881, 0, 0, 0, 0
3301, 9859, 9860, 9883, 9882, 0, 0, 0, 0
3302, 9860, 9861, 9884, 9883, 0, 0, 0, 0
3303, 9861, 9862, 9885, 9884, 0, 0, 0, 0
3304, 9862, 9863, 9886, 9885, 0, 0, 0, 0
3305, 9863, 9864, 9887, 9886, 0, 0, 0, 0
3306, 9864, 9865, 9888, 9887, 0, 0, 0, 0
3307, 9865, 9866, 9889, 9888, 0, 0, 0, 0
3308, 9866, 9867, 9890, 9889, 0, 0, 0, 0
3309, 9867, 9868, 9891, 9890, 0, 0, 0, 0
3310, 9868, 9869, 9892, 9891, 0, 0, 0, 0
3311, 9869, 9870, 9893, 9892, 0, 0, 0, 0
3312, 9870, 9871, 9894, 9893, 0, 0, 0, 0
3313, 9871, 9872, 9895, 9894, 0, 0, 0, 0
3314, 9872, 9873, 9896, 9895, 0, 0, 0, 0
3315, 9873, 9874, 9897, 9896, 0, 0, 0, 0
3316, 9874, 1194, 1195, 9897, 0, 0, 0, 0
3317, 1184, 9875, 9898, 1185, 0, 0, 0, 0
3318, 9875, 9876, 9899, 9898, 0, 0, 0, 0
3319, 9876, 9877, 9900, 9899, 0, 0, 0, 0
3320, 9877, 9878, 9901, 9900, 0, 0, 0, 0
3321, 9878, 9879, 9902, 9901, 0, 0, 0, 0
3322, 9879, 9880, 9903, 9902, 0, 0, 0, 0
3323, 9880, 9881, 9904, 9903, 0, 0, 0, 0
3324, 9881, 9882, 9905, 9904, 0, 0, 0, 0
3325, 9882, 9883, 9906, 9905, 0, 0, 0, 0
3326, 9883, 9884, 9907, 9906, 0, 0, 0, 0
3327, 9884, 9885, 9908, 9907, 0, 0, 0, 0
3328, 9885, 9886, 9909, 9908, 0, 0, 0, 0
3329, 9886, 9887, 9910, 9909, 0, 0, 0, 0
3330, 9887, 9888, 9911, 9910, 0, 0, 0, 0
3331, 9888, 9889, 9912, 9911, 0, 0, 0, 0
3332, 9889, 9890, 9913, 9912, 0, 0, 0, 0
3333, 9890, 9891, 9914, 9913, 0, 0, 0, 0
3334, 9891, 9892, 9915, 9914, 0, 0, 0, 0
3335, 9892, 9893, 9916, 9915, 0, 0, 0, 0
3336, 9893, 9894, 9917, 9916, 0, 0, 0, 0
3337, 9894, 9895, 9918, 9917, 0, 0, 0, 0
3338, 9895, 9896, 9919, 9918, 0, 0, 0, 0
3339, 9896, 9897, 9920, 9919, 0, 0, 0, 0
3340, 9897, 1195, 1196, 9920, 0, 0, 0, 0
3341, 1185, 9898, 9921, 1186, 0, 0, 0, 0
3342, 9898, 9899, 9922, 9921, 0, 0, 0, 0
3343, 9899, 9900, 9923, 9922, 0, 0, 0, 0
3344, 9900, 9901, 9924, 9923, 0, 0, 0, 0
3345, 9901, 9902, 9925, 9924, 0, 0, 0, 0
3346, 9902, 9903, 9926, 9925, 0, 0, 0, 0
3347, 9903, 9904, 9927, 9926, 0, 0, 0, 0
3348, 9904, 9905, 9928, 9927, 0, 0, 0, 0
3349, 9905, 9906, 9929, 9928, 0, 0, 0, 0
3350, 9906, 9907, 9930, 9929, 0, 0, 0, 0
3351, 9907, 9908, 9931, 9930, 0, 0, 0, 0
3352, 9908, 9909, 9932, 9931, 0, 0, 0, 0
3353, 9909, 9910, 9933, 9932, 0, 0, 0, 0
3354, 9910, 9911, 9934, 9933, 0, 0, 0, 0
3355, 9911, 9912, 9935, 9934, 0, 0, 0, 0
3356, 9912, 9913, 9936, 9935, 0, 0, 0, 0
3357, 9913, 9914, 9937, 9936, 0, 0, 0, 0
3358, 9914, 9915, 9938, 9937, 0, 0, 0, 0
3359, 9915, 9916, 9939, 9938, 0, 0, 0, 0
3360, 9916, 9917, 9940, 9939, 0, 0, 0, 0
3361, 9917, 9918, 9941, 9940, 0, 0, 0, 0
3362, 9918, 9919, 9942, 9941, 0, 0, 0, 0
3363, 9919, 9920, 9943, 9942, 0, 0, 0, 0
3364, 9920, 1196, 1197, 9943, 0, 0, 0, 0
3365, 1186, 9921, 9944, 1187, 0, 0, 0, 0
3366, 9921, 9922, 9945, 9944, 0, 0, 0, 0
3367, 9922, 9923, 9946, 9945, 0, 0, 0, 0
3368, 9923, 9924, 9947, 9946, 0, 0, 0, 0
3369, 9924, 9925, 9948, 9947, 0, 0, 0, 0
3370, 9925, 9926, 9949, 9948, 0, 0, 0, 0
3371, 9926, 9927, 9950, 9949, 0, 0, 0, 0
3372, 9927, 9928, 9951, 9950, 0, 0, 0, 0
3373, 9928, 9929, 9952, 9951, 0, 0, 0, 0
3374, 9929, 9930, 9953, 9952, 0, 0, 0, 0
3375, 9930, 9931, 9954, 9953, 0, 0, 0, 0
3376, 9931, 9932, 9955, 9954, 0, 0, 0, 0
3377, 9932, 9933, 9956, 9955, 0, 0, 0, 0
3378, 9933, 9934, 9957, 9956, 0, 0, 0, 0
3379, 9934, 9935, 9958, 9957, 0, 0, 0, 0
3380, 9935, 9936, 9959, 9958, 0, 0, 0, 0
3381, 9936, 9937, 9960, 9959, 0, 0, 0, 0
3382, 9937, 9938, 9961, 9960, 0, 0, 0, 0
3383, 9938, 9939, 9962, 9961, 0, 0, 0, 0
3384, 9939, 9940, 9963, 9962, 0, 0, 0, 0
3385, 9940, 9941, 9964, 9963, 0, 0, 0, 0
3386, 9941, 9942, 9965, 9964, 0, 0, 0, 0
3387, 9942, 9943, 9966, 9965, 0, 0, 0, 0
3388, 9943, 1197, 1198, 9966, 0, 0, 0, 0
3389, 1187, 9944, 9967, 1188, 0, 0, 0, 0
3390, 9944, 9945, 9968, 9967, 0, 0, 0, 0
3391, 9945, 9946, 9969, 9968, 0, 0, 0, 0
3392, 9946, 9947, 9970, 9969, 0, 0, 0, 0
3393, 9947, 9948, 9971, 9970, 0, 0, 0, 0
3394, 9948, 9949, 9972, 9971, 0, 0, 0, 0
3395, 9949, 9950, 9973, 9972, 0, 0, 0, 0
3396, 9950, 9951, 9974, 9973, 0, 0, 0, 0
3397, 9951, 9952, 9975, 9974, 0, 0, 0, 0
3398, 9952, 9953, 9976, 9975, 0, 0, 0, 0
3399, 9953, 9954, 9977, 9976, 0, 0, 0, 0
3400, 9954, 9955, 9978, 9977, 0, 0, 0, 0
3401, 9955, 9956, 9979, 9978, 0, 0, 0, 0
3402, 9956, 9957, 9980, 9979, 0, 0, 0, 0
3403, 9957, 9958, 9981, 9980, 0, 0, 0, 0
3404, 9958, 9959, 9982, 9981, 0, 0, 0, 0
3405, 9959, 9960, 9983, 9982, 0, 0, 0, 0
3406, 9960, 9961, 9984, 9983, 0, 0, 0, 0
3407, 9961, 9962, 9985, 9984, 0, 0, 0, 0
3408, 9962, 9963, 9986, 9985, 0, 0, 0, 0
3409, 9963, 9964, 9987, 9986, 0, 0, 0, 0
3410, 9964, 9965, 9988, 9987, 0, 0, 0, 0
3411, 9965, 9966, 9989, 9988, 0, 0, 0, 0
3412, 9966, 1198, 1199, 9989, 0, 0, 0, 0
3413, 1188, 9967, 9990, 1189, 0, 0, 0, 0
3414, 9967, 9968, 9991, 9990, 0, 0, 0, 0
3415, 9968, 9969, 9992, 9991, 0, 0, 0, 0
3416, 9969, 9970, 9993, 9992, 0, 0, 0, 0
3417, 9970, 9971, 9994, 9993, 0, 0, 0, 0
3418, 9971, 9972, 9995, 9994, 0, 0, 0, 0
3419, 9972, 9973, 9996, 9995, 0, 0, 0, 0
3420, 9973, 9974, 9997, 9996, 0, 0, 0, 0
3421, 9974, 9975, 9998, 9997, 0, 0, 0, 0
3422, 9975, 9976, 9999, 9998, 0, 0, 0, 0
3423, 9976, 9977, 10000, 9999, 0, 0, 0, 0
3424, 9977, 9978, 10001, 10000, 0, 0, 0, 0
3425, 9978, 9979, 10002, 10001, 0, 0, 0, 0
3426, 9979, 9980, 10003, 10002, 0, 0, 0, 0
3427, 9980, 9981, 10004, 10003, 0, 0, 0, 0
3428, 9981, 9982, 10005, 10004, 0, 0, 0, 0
3429, 9982, 9983, 10006, 10005, 0, 0, 0, 0
3430, 9983, 9984, 10007, 10006, 0, 0, 0, 0
3431, 9984, 9985, 10008, 10007, 0, 0, 0, 0
3432, 9985, 9986, 10009, 10008, 0, 0, 0, 0
3433, 9986, 9987, 10010, 10009, 0, 0, 0, 0
3434, 9987, 9988, 10011, 10010, 0, 0, 0, 0
3435, 9988, 9989, 10012, 10011, 0, 0, 0, 0
3436, 9989, 1199, 1200, 10012, 0, 0, 0, 0
3437, 1189, 9990, 10013, 1190, 0, 0, 0, 0
3438, 9990, 9991, 10014, 10013, 0, 0, 0, 0
3439, 9991, 9992, 10015, 10014, 0, 0, 0, 0
3440, 9992, 9993, 10016, 10015, 0, 0, 0, 0
3441, 9993, 9994, 10017, 10016, 0, 0, 0, 0
3442, 9994, 9995, 10018, 10017, 0, 0, 0, 0
3443, 9995, 9996, 10019, 10018, 0, 0, 0, 0
3444, 9996, 9997, 10020, 10019, 0, 0, 0, 0
3445, 9997, 9998, 10021, 10020, 0, 0, 0, 0
3446, 9998, 9999, 10022, 10021, 0, 0, 0, 0
3447, 9999, 10000, 10023, 10022, 0, 0, 0, 0
3448, 10000, 10001, 10024, 10023, 0, 0, 0, 0
3449, 10001, 10002, 10025, 10024, 0, 0, 0, 0
3450, 10002, 10003, 10026, 10025, 0, 0, 0, 0
3451, 10003, 10004, 10027, 10026, 0, 0, 0, 0
3452, 10004, 10005, 10028, 10027, 0, 0, 0, 0
3453, 10005, 10006, 10029, 10028, 0, 0, 0, 0
3454, 10006, 10007, 10030, 10029, 0, 0, 0, 0
3455, 10007, 10008, 10031, 10030, 0, 0, 0, 0
3456, 10008, 10009, 10032, 10031, 0, 0, 0, 0
3457, 10009, 10010, 10033, 10032, 0, 0, 0, 0
3458, 10010, 10011, 10034, 10033, 0, 0, 0, 0
3459, 10011, 10012, 10035, 10034, 0, 0, 0, 0
3460, 10012, 1200, 1201, 10035, 0, 0, 0, 0
3461, 1190, 10013, 1124, 45, 0, 0, 0, 0
3462, 10013, 10014, 1125, 1124, 0, 0, 0, 0
3463, 10014, 10015, 1126, 1125, 0, 0, 0, 0
3464, 10015, 10016, 1127, 1126, 0, 0, 0, 0
3465, 10016, 10017, 1128, 1127, 0, 0, 0, 0
3466, 10017, 10018, 1129, 1128, 0, 0, 0, 0
3467, 10018, 10019, 1130, 1129, 0, 0, 0, 0
3468, 10019, 10020, 1131, 1130, 0, 0, 0, 0
3469, 10020, 10021, 1132, 1131, 0, 0, 0, 0
3470, 10021, 10022, 1133, 1132, 0, 0, 0, 0
3471, 10022, 10023, 1134, 1133, 0, 0, 0, 0
3472, 10023, 10024, 1135, 1134, 0, 0, 0, 0
3473, 10024, 10025, 1136, 1135, 0, 0, 0, 0
3474, 10025, 10026, 1137, 1136, 0, 0, 0, 0
3475, 10026, 10027, 1138, 1137, 0, 0, 0, 0
3476, 10027, 10028, 1139, 1138, 0, 0, 0, 0
3477, 10028, 10029, 1140, 1139, 0, 0, 0, 0
3478, 10029, 10030, 1141, 1140, 0, 0, 0, 0
3479, 10030, 10031, 1142, 1141, 0, 0, 0, 0
3480, 10031, 10032, 1143, 1142, 0, 0, 0, 0
3481, 10032, 10033, 1144, 1143, 0, 0, 0, 0
3482, 10033, 10034, 1145, 1144, 0, 0, 0, 0
3483, 10034, 10035, 1146, 1145, 0, 0, 0, 0
3484, 10035, 1201, 46, 1146, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface57
3485, 42, 1122, 1202, 49, 0, 0, 0, 0
3486, 1122, 1123, 1203, 1202, 0, 0, 0, 0
3487, 1123, 46, 50, 1203, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface58
38894, 44, 51, 1204, 1152, 55606, 0, 55608, 1154
38895, 1152, 1204, 1205, 1153, 55608, 0, 55609, 1155
38896, 1153, 1205, 52, 48, 55609, 0, 0, 1156
*ELEMENT, type=CPS8, ELSET=Surface59
38897, 44, 1097, 1206, 51, 1108, 55610, 0, 55606
38898, 1097, 1098, 1207, 1206, 1109, 55611, 0, 55610
38899, 1098, 1099, 1208, 1207, 1110, 55612, 0, 55611
38900, 1099, 1100, 1209, 1208, 1111, 55613, 0, 55612
38901, 1100, 1101, 1210, 1209, 1112, 55614, 0, 55613
38902, 1101, 1102, 1211, 1210, 1113, 55615, 0, 55614
38903, 1102, 1103, 1212, 1211, 1114, 55616, 0, 55615
38904, 1103, 1104, 1213, 1212, 1115, 55617, 0, 55616
38905, 1104, 1105, 1214, 1213, 1116, 55618, 0, 55617
38906, 1105, 1106, 1215, 1214, 1117, 55619, 0, 55618
38907, 1106, 1107, 1216, 1215, 1118, 55620, 0, 55619
38908, 1107, 42, 49, 1216, 1119, 0, 0, 55620
*ELEMENT, type=CPS8, ELSET=Surface60
3488, 48, 52, 1217, 1191, 0, 0, 0, 0
3489, 1191, 1217, 1218, 1192, 0, 0, 0, 0
3490, 1192, 1218, 1219, 1193, 0, 0, 0, 0
3491, 1193, 1219, 1220, 1194, 0, 0, 0, 0
3492, 1194, 1220, 1221, 1195, 0, 0, 0, 0
3493, 1195, 1221, 1222, 1196, 0, 0, 0, 0
3494, 1196, 1222, 1223, 1197, 0, 0, 0, 0
3495, 1197, 1223, 1224, 1198, 0, 0, 0, 0
3496, 1198, 1224, 1225, 1199, 0, 0, 0, 0
3497, 1199, 1225, 1226, 1200, 0, 0, 0, 0
3498, 1200, 1226, 1227, 1201, 0, 0, 0, 0
3499, 1201, 1227, 50, 46, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface61
3500, 51, 1206, 10036, 1204, 0, 0, 0, 0
3501, 1204, 10036, 10037, 1205, 0, 0, 0, 0
3502, 1205, 10037, 1217, 52, 0, 0, 0, 0
3503, 1206, 1207, 10038, 10036, 0, 0, 0, 0
3504, 10036, 10038, 10039, 10037, 0, 0, 0, 0
3505, 10037, 10039, 1218, 1217, 0, 0, 0, 0
3506, 1207, 1208, 10040, 10038, 0, 0, 0, 0
3507, 10038, 10040, 10041, 10039, 0, 0, 0, 0
3508, 10039, 10041, 1219, 1218, 0, 0, 0, 0
3509, 1208, 1209, 10042, 10040, 0, 0, 0, 0
3510, 10040, 10042, 10043, 10041, 0, 0, 0, 0
3511, 10041, 10043, 1220, 1219, 0, 0, 0, 0
3512, 1209, 1210, 10044, 10042, 0, 0, 0, 0
3513, 10042, 10044, 10045, 10043, 0, 0, 0, 0
3514, 10043, 10045, 1221, 1220, 0, 0, 0, 0
3515, 1210, 1211, 10046, 10044, 0, 0, 0, 0
3516, 10044, 10046, 10047, 10045, 0, 0, 0, 0
3517, 10045, 10047, 1222, 1221, 0, 0, 0, 0
3518, 1211, 1212, 10048, 10046, 0, 0, 0, 0
3519, 10046, 10048, 10049, 10047, 0, 0, 0, 0
3520, 10047, 10049, 1223, 1222, 0, 0, 0, 0
3521, 1212, 1213, 10050, 10048, 0, 0, 0, 0
3522, 10048, 10050, 10051, 10049, 0, 0, 0, 0
3523, 10049, 10051, 1224, 1223, 0, 0, 0, 0
3524, 1213, 1214, 10052, 10050, 0, 0, 0, 0
3525, 10050, 10052, 10053, 10051, 0, 0, 0, 0
3526, 10051, 10053, 1225, 1224, 0, 0, 0, 0
3527, 1214, 1215, 10054, 10052, 0, 0, 0, 0
3528, 10052, 10054, 10055, 10053, 0, 0, 0, 0
3529, 10053, 10055, 1226, 1225, 0, 0, 0, 0
3530, 1215, 1216, 10056, 10054, 0, 0, 0, 0
3531, 10054, 10056, 10057, 10055, 0, 0, 0, 0
3532, 10055, 10057, 1227, 1226, 0, 0, 0, 0
3533, 1216, 49, 1202, 10056, 0, 0, 0, 0
3534, 10056, 1202, 1203, 10057, 0, 0, 0, 0
3535, 10057, 1203, 50, 1227, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface62
3536, 2, 98, 1228, 54, 97, 0, 0, 0
3537, 98, 99, 1229, 1228, 0, 0, 0, 0
3538, 99, 100, 1230, 1229, 0, 0, 0, 0
3539, 100, 101, 1231, 1230, 0, 0, 0, 0
3540, 101, 102, 1232, 1231, 0, 0, 0, 0
3541, 102, 103, 1233, 1232, 0, 0, 0, 0
3542, 103, 104, 1234, 1233, 0, 0, 0, 0
3543, 104, 105, 1235, 1234, 0, 0, 0, 0
3544, 105, 106, 1236, 1235, 0, 0, 0, 0
3545, 106, 107, 1237, 1236, 0, 0, 0, 0
3546, 107, 108, 1238, 1237, 0, 0, 0, 0
3547, 108, 1, 53, 1238, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface63
3548, 1, 109, 1239, 53, 0, 0, 0, 0
3549, 109, 110, 1240, 1239, 0, 0, 0, 0
3550, 110, 3, 55, 1240, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface64
38909, 4, 56, 1241, 111, 55607, 0, 55621, 0
38910, 111, 1241, 1242, 112, 55621, 0, 55622, 0
38911, 112, 1242, 1243, 113, 55622, 0, 55623, 0
38912, 113, 1243, 1244, 114, 55623, 0, 55624, 0
38913, 114, 1244, 1245, 115, 55624, 0, 55625, 0
38914, 115, 1245, 1246, 116, 55625, 0, 55626, 0
38915, 116, 1246, 1247, 117, 55626, 0, 55627, 0
38916, 117, 1247, 1248, 118, 55627, 0, 55628, 0
38917, 118, 1248, 1249, 119, 55628, 0, 55629, 0
38918, 119, 1249, 1250, 120, 55629, 0, 55630, 0
38919, 120, 1250, 1251, 121, 55630, 0, 55631, 0
38920, 121, 1251, 55, 3, 55631, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface65
38921, 2, 54, 1252, 122, 0, 0, 55632, 0
38922, 122, 1252, 1253, 123, 55632, 0, 55633, 0
38923, 123, 1253, 56, 4, 55633, 0, 55607, 0
*ELEMENT, type=CPS8, ELSET=Surface66
3551, 54, 1228, 10058, 1252, 0, 0, 0, 0
3552, 1252, 10058, 10059, 1253, 0, 0, 0, 0
3553, 1253, 10059, 1241, 56, 0, 0, 0, 0
3554, 1228, 1229, 10060, 10058, 0, 0, 0, 0
3555, 10058, 10060, 10061, 10059, 0, 0, 0, 0
3556, 10059, 10061, 1242, 1241, 0, 0, 0, 0
3557, 1229, 1230, 10062, 10060, 0, 0, 0, 0
3558, 10060, 10062, 10063, 10061, 0, 0, 0, 0
3559, 10061, 10063, 1243, 1242, 0, 0, 0, 0
3560, 1230, 1231, 10064, 10062, 0, 0, 0, 0
3561, 10062, 10064, 10065, 10063, 0, 0, 0, 0
3562, 10063, 10065, 1244, 1243, 0, 0, 0, 0
3563, 1231, 1232, 10066, 10064, 0, 0, 0, 0
3564, 10064, 10066, 10067, 10065, 0, 0, 0, 0
3565, 10065, 10067, 1245, 1244, 0, 0, 0, 0
3566, 1232, 1233, 10068, 10066, 0, 0, 0, 0
3567, 10066, 10068, 10069, 10067, 0, 0, 0, 0
3568, 10067, 10069, 1246, 1245, 0, 0, 0, 0
3569, 1233, 1234, 10070, 10068, 0, 0, 0, 0
3570, 10068, 10070, 10071, 10069, 0, 0, 0, 0
3571, 10069, 10071, 1247, 1246, 0, 0, 0, 0
3572, 1234, 1235, 10072, 10070, 0, 0, 0, 0
3573, 10070, 10072, 10073, 10071, 0, 0, 0, 0
3574, 10071, 10073, 1248, 1247, 0, 0, 0, 0
3575, 1235, 1236, 10074, 10072, 0, 0, 0, 0
3576, 10072, 10074, 10075, 10073, 0, 0, 0, 0
3577, 10073, 10075, 1249, 1248, 0, 0, 0, 0
3578, 1236, 1237, 10076, 10074, 0, 0, 0, 0
3579, 10074, 10076, 10077, 10075, 0, 0, 0, 0
3580, 10075, 10077, 1250, 1249, 0, 0, 0, 0
3581, 1237, 1238, 10078, 10076, 0, 0, 0, 0
3582, 10076, 10078, 10079, 10077, 0, 0, 0, 0
3583, 10077, 10079, 1251, 1250, 0, 0, 0, 0
3584, 1238, 53, 1239, 10078, 0, 0, 0, 0
3585, 10078, 1239, 1240, 10079, 0, 0, 0, 0
3586, 10079, 1240, 55, 1251, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface77
3587, 11, 57, 1254, 379, 0, 0, 0, 0
3588, 379, 1254, 1255, 380, 0, 0, 0, 0
3589, 380, 1255, 1256, 381, 0, 0, 0, 0
3590, 381, 1256, 1257, 382, 0, 0, 0, 0
3591, 382, 1257, 1258, 383, 0, 0, 0, 0
3592, 383, 1258, 1259, 384, 0, 0, 0, 0
3593, 384, 1259, 1260, 385, 0, 0, 0, 0
3594, 385, 1260, 1261, 386, 0, 0, 0, 0
3595, 386, 1261, 1262, 387, 0, 0, 0, 0
3596, 387, 1262, 1263, 388, 0, 0, 0, 0
3597, 388, 1263, 1264, 389, 0, 0, 0, 0
3598, 389, 1264, 1265, 390, 0, 0, 0, 0
3599, 390, 1265, 1266, 391, 0, 0, 0, 0
3600, 391, 1266, 1267, 392, 0, 0, 0, 0
3601, 392, 1267, 1268, 393, 0, 0, 0, 0
3602, 393, 1268, 1269, 394, 0, 0, 0, 0
3603, 394, 1269, 1270, 395, 0, 0, 0, 0
3604, 395, 1270, 1271, 396, 0, 0, 0, 0
3605, 396, 1271, 1272, 397, 0, 0, 0, 0
3606, 397, 1272, 1273, 398, 0, 0, 0, 0
3607, 398, 1273, 1274, 399, 0, 0, 0, 0
3608, 399, 1274, 1275, 400, 0, 0, 0, 0
3609, 400, 1275, 1276, 401, 0, 0, 0, 0
3610, 401, 1276, 58, 15, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface78
38924, 9, 310, 1279, 59, 0, 10080, 1302, 1277
38925, 310, 311, 1280, 1279, 0, 10081, 1303, 10080
38926, 311, 312, 1281, 1280, 0, 10082, 1304, 10081
38927, 312, 313, 1282, 1281, 0, 10083, 1305, 10082
38928, 313, 314, 1283, 1282, 0, 10084, 1306, 10083
38929, 314, 315, 1284, 1283, 0, 10085, 1307, 10084
38930, 315, 316, 1285, 1284, 0, 10086, 1308, 10085
38931, 316, 317, 1286, 1285, 0, 10087, 1309, 10086
38932, 317, 318, 1287, 1286, 0, 10088, 1310, 10087
38933, 318, 319, 1288, 1287, 0, 10089, 1311, 10088
38934, 319, 320, 1289, 1288, 0, 10090, 1312, 10089
38935, 320, 321, 1290, 1289, 0, 10091, 1313, 10090
38936, 321, 322, 1291, 1290, 0, 10092, 1314, 10091
38937, 322, 323, 1292, 1291, 0, 10093, 1315, 10092
38938, 323, 324, 1293, 1292, 0, 10094, 1316, 10093
38939, 324, 325, 1294, 1293, 0, 10095, 1317, 10094
38940, 325, 326, 1295, 1294, 0, 10096, 1318, 10095
38941, 326, 327, 1296, 1295, 0, 10097, 1319, 10096
38942, 327, 328, 1297, 1296, 0, 10098, 1320, 10097
38943, 328, 329, 1298, 1297, 0, 10099, 1321, 10098
38944, 329, 330, 1299, 1298, 0, 10100, 1322, 10099
38945, 330, 331, 1300, 1299, 0, 10101, 1323, 10100
38946, 331, 332, 1301, 1300, 0, 10102, 1324, 10101
38947, 332, 13, 60, 1301, 0, 1278, 1325, 10102
*ELEMENT, type=CPS8, ELSET=Surface79
38948, 9, 59, 1326, 265, 1277, 1337, 10103, 0
38949, 265, 1326, 1327, 266, 10103, 1338, 10104, 0
38950, 266, 1327, 1328, 267, 10104, 1339, 10105, 0
38951, 267, 1328, 1329, 268, 10105, 1340, 10106, 0
38952, 268, 1329, 1330, 269, 10106, 1341, 10107, 0
38953, 269, 1330, 1331, 270, 10107, 1342, 10108, 0
38954, 270, 1331, 1332, 271, 10108, 1343, 10109, 0
38955, 271, 1332, 1333, 272, 10109, 1344, 10110, 0
38956, 272, 1333, 1334, 273, 10110, 1345, 10111, 0
38957, 273, 1334, 1335, 274, 10111, 1346, 10112, 0
38958, 274, 1335, 1336, 275, 10112, 1347, 10113, 0
38959, 275, 1336, 57, 11, 10113, 1348, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface80
38960, 13, 402, 1349, 60, 0, 10114, 1360, 1278
38961, 402, 403, 1350, 1349, 0, 10115, 1361, 10114
38962, 403, 404, 1351, 1350, 0, 10116, 1362, 10115
38963, 404, 405, 1352, 1351, 0, 10117, 1363, 10116
38964, 405, 406, 1353, 1352, 0, 10118, 1364, 10117
38965, 406, 407, 1354, 1353, 0, 10119, 1365, 10118
38966, 407, 408, 1355, 1354, 0, 10120, 1366, 10119
38967, 408, 409, 1356, 1355, 0, 10121, 1367, 10120
38968, 409, 410, 1357, 1356, 0, 10122, 1368, 10121
38969, 410, 411, 1358, 1357, 0, 10123, 1369, 10122
38970, 411, 412, 1359, 1358, 0, 10124, 1370, 10123
38971, 412, 15, 58, 1359, 0, 0, 1371, 10124
*ELEMENT, type=CPS8, ELSET=Surface81
38972, 59, 1279, 10125, 1326, 1302, 10378, 10379, 1337
38973, 1279, 1280, 10126, 10125, 1303, 10380, 10381, 10378
38974, 1280, 1281, 10127, 10126, 1304, 10382, 10383, 10380
38975, 1281, 1282, 10128, 10127, 1305, 10384, 10385, 10382
38976, 1282, 1283, 10129, 10128, 1306, 10386, 10387, 10384
38977, 1283, 1284, 10130, 10129, 1307, 10388, 10389, 10386
38978, 1284, 1285, 10131, 10130, 1308, 10390, 10391, 10388
38979, 1285, 1286, 10132, 10131, 1309, 10392, 10393, 10390
38980, 1286, 1287, 10133, 10132, 1310, 10394, 10395, 10392
38981, 1287, 1288, 10134, 10133, 1311, 10396, 10397, 10394
38982, 1288, 1289, 10135, 10134, 1312, 10398, 10399, 10396
38983, 1289, 1290, 10136, 10135, 1313, 10400, 10401, 10398
38984, 1290, 1291, 10137, 10136, 1314, 10402, 10403, 10400
38985, 1291, 1292, 10138, 10137, 1315, 10404, 10405, 10402
38986, 1292, 1293, 10139, 10138, 1316, 10406, 10407, 10404
38987, 1293, 1294, 10140, 10139, 1317, 10408, 10409, 10406
38988, 1294, 1295, 10141, 10140, 1318, 10410, 10411, 10408
38989, 1295, 1296, 10142, 10141, 1319, 10412, 10413, 10410
38990, 1296, 1297, 10143, 10142, 1320, 10414, 10415, 10412
38991, 1297, 1298, 10144, 10143, 1321, 10416, 10417, 10414
38992, 1298, 1299, 10145, 10144, 1322, 10418, 10419, 10416
38993, 1299, 1300, 10146, 10145, 1323, 10420, 10421, 10418
38994, 1300, 1301, 10147, 10146, 1324, 10422, 10423, 10420
38995, 1301, 60, 1349, 10147, 1325, 1360, 10424, 10422
38996, 1326, 10125, 10148, 1327, 10379, 10425, 10426, 1338
38997, 10125, 10126, 10149, 10148, 10381, 10427, 10428, 10425
38998, 10126, 10127, 10150, 10149, 10383, 10429, 10430, 10427
38999, 10127, 10128, 10151, 10150, 10385, 10431, 10432, 10429
39000, 10128, 10129, 10152, 10151, 10387, 10433, 10434, 10431
39001, 10129, 10130, 10153, 10152, 10389, 10435, 10436, 10433
39002, 10130, 10131, 10154, 10153, 10391, 10437, 10438, 10435
39003, 10131, 10132, 10155, 10154, 10393, 10439, 10440, 10437
39004, 10132, 10133, 10156, 10155, 10395, 10441, 10442, 10439
39005, 10133, 10134, 10157, 10156, 10397, 10443, 10444, 10441
39006, 10134, 10135, 10158, 10157, 10399, 10445, 10446, 10443
39007, 10135, 10136, 10159, 10158, 10401, 10447, 10448, 10445
39008, 10136, 10137, 10160, 10159, 10403, 10449, 10450, 10447
39009, 10137, 10138, 10161, 10160, 10405, 10451, 10452, 10449
39010, 10138, 10139, 10162, 10161, 10407, 10453, 10454, 10451
39011, 10139, 10140, 10163, 10162, 10409, 10455, 10456, 10453
39012, 10140, 10141, 10164, 10163, 10411, 10457, 10458, 10455
39013, 10141, 10142, 10165, 10164, 10413, 10459, 10460, 10457
39014, 10142, 10143, 10166, 10165, 10415, 10461, 10462, 10459
39015, 10143, 10144, 10167, 10166, 10417, 10463, 10464, 10461
39016, 10144, 10145, 10168, 10167, 10419, 10465, 10466, 10463
39017, 10145, 10146, 10169, 10168, 10421, 10467, 10468, 10465
39018, 10146, 10147, 10170, 10169, 10423, 10469, 10470, 10467
39019, 10147, 1349, 1350, 10170, 10424, 1361, 10471, 10469
39020, 1327, 10148, 10171, 1328, 10426, 10472, 10473, 1339
39021, 10148, 10149, 10172, 10171, 10428, 10474, 10475, 10472
39022, 10149, 10150, 10173, 10172, 10430, 10476, 10477, 10474
39023, 10150, 10151, 10174, 10173, 10432, 10478, 10479, 10476
39024, 10151, 10152, 10175, 10174, 10434, 10480, 10481, 10478
39025, 10152, 10153, 10176, 10175, 10436, 10482, 10483, 10480
39026, 10153, 10154, 10177, 10176, 10438, 10484, 10485, 10482
39027, 10154, 10155, 10178, 10177, 10440, 10486, 10487, 10484
39028, 10155, 10156, 10179, 10178, 10442, 10488, 10489, 10486
39029, 10156, 10157, 10180, 10179, 10444, 10490, 10491, 10488
39030, 10157, 10158, 10181, 10180, 10446, 10492, 10493, 10490
39031, 10158, 10159, 10182, 10181, 10448, 10494, 10495, 10492
39032, 10159, 10160, 10183, 10182, 10450, 10496, 10497, 10494
39033, 10160, 10161, 10184, 10183, 10452, 10498, 10499, 10496
39034, 10161, 10162, 10185, 10184, 10454, 10500, 10501, 10498
39035, 10162, 10163, 10186, 10185, 10456, 10502, 10503, 10500
39036, 10163, 10164, 10187, 10186, 10458, 10504, 10505, 10502
39037, 10164, 10165, 10188, 10187, 10460, 10506, 10507, 10504
39038, 10165, 10166, 10189, 10188, 10462, 10508, 10509, 10506
39039, 10166, 10167, 10190, 10189, 10464, 10510, 10511, 10508
39040, 10167, 10168, 10191, 10190, 10466, 10512, 10513, 10510
39041, 10168, 10169, 10192, 10191, 10468, 10514, 10515, 10512
39042, 10169, 10170, 10193, 10192, 10470, 10516, 10517, 10514
39043, 10170, 1350, 1351, 10193, 10471, 1362, 10518, 10516
39044, 1328, 10171, 10194, 1329, 10473, 10519, 10520, 1340
39045, 10171, 10172, 10195, 10194, 10475, 10521, 10522, 10519
39046, 10172, 10173, 10196, 10195, 10477, 10523, 10524, 10521
39047, 10173, 10174, 10197, 10196, 10479, 10525, 10526, 10523
39048, 10174, 10175, 10198, 10197, 10481, 10527, 10528, 10525
39049, 10175, 10176, 10199, 10198, 10483, 10529, 10530, 10527
39050, 10176, 10177, 10200, 10199, 10485, 10531, 10532, 10529
39051, 10177, 10178, 10201, 10200, 10487, 10533, 10534, 10531
39052, 10178, 10179, 10202, 10201, 10489, 10535, 10536, 10533
39053, 10179, 10180, 10203, 10202, 10491, 10537, 10538, 10535
39054, 10180, 10181, 10204, 10203, 10493, 10539, 10540, 10537
39055, 10181, 10182, 10205, 10204, 10495, 10541, 10542, 10539
39056, 10182, 10183, 10206, 10205, 10497, 10543, 10544, 10541
39057, 10183, 10184, 10207, 10206, 10499, 10545, 10546, 10543
39058, 10184, 10185, 10208, 10207, 10501, 10547, 10548, 10545
39059, 10185, 10186, 10209, 10208, 10503, 10549, 10550, 10547
39060, 10186, 10187, 10210, 10209, 10505, 10551, 10552, 10549
39061, 10187, 10188, 10211, 10210, 10507, 10553, 10554, 10551
39062, 10188, 10189, 10212, 10211, 10509, 10555, 10556, 10553
39063, 10189, 10190, 10213, 10212, 10511, 10557, 10558, 10555
39064, 10190, 10191, 10214, 10213, 10513, 10559, 10560, 10557
39065, 10191, 10192, 10215, 10214, 10515, 10561, 10562, 10559
39066, 10192, 10193, 10216, 10215, 10517, 10563, 10564, 10561
39067, 10193, 1351, 1352, 10216, 10518, 1363, 10565, 10563
39068, 1329, 10194, 10217, 1330, 10520, 10566, 10567, 1341
39069, 10194, 10195, 10218, 10217, 10522, 10568, 10569, 10566
39070, 10195, 10196, 10219, 10218, 10524, 10570, 10571, 10568
39071, 10196, 10197, 10220, 10219, 10526, 10572, 10573, 10570
39072, 10197, 10198, 10221, 10220, 10528, 10574, 10575, 10572
39073, 10198, 10199, 10222, 10221, 10530, 10576, 10577, 10574
39074, 10199, 10200, 10223, 10222, 10532, 10578, 10579, 10576
39075, 10200, 10201, 10224, 10223, 10534, 10580, 10581, 10578
39076, 10201, 10202, 10225, 10224, 10536, 10582, 10583, 10580
39077, 10202, 10203, 10226, 10225, 10538, 10584, 10585, 10582
39078, 10203, 10204, 10227, 10226, 10540, 10586, 10587, 10584
39079, 10204, 10205, 10228, 10227, 10542, 10588, 10589, 10586
39080, 10205, 10206, 10229, 10228, 10544, 10590, 10591, 10588
39081, 10206, 10207, 10230, 10229, 10546, 10592, 10593, 10590
39082, 10207, 10208, 10231, 10230, 10548, 10594, 10595, 10592
39083, 10208, 10209, 10232, 10231, 10550, 10596, 10597, 10594
39084, 10209, 10210, 10233, 10232, 10552, 10598, 10599, 10596
39085, 10210, 10211, 10234, 10233, 10554, 10600, 10601, 10598
39086, 10211, 10212, 10235, 10234, 10556, 10602, 10603, 10600
39087, 10212, 10213, 10236, 10235, 10558, 10604, 10605, 10602
39088, 10213, 10214, 10237, 10236, 10560, 10606, 10607, 10604
39089, 10214, 10215, 10238, 10237, 10562, 10608, 10609, 10606
39090, 10215, 10216, 10239, 10238, 10564, 10610, 10611, 10608
39091, 10216, 1352, 1353, 10239, 10565, 1364, 10612, 10610
39092, 1330, 10217, 10240, 1331, 10567, 10613, 10614, 1342
39093, 10217, 10218, 10241, 10240, 10569, 10615, 10616, 10613
39094, 10218, 10219, 10242, 10241, 10571, 10617, 10618, 10615
39095, 10219, 10220, 10243, 10242, 10573, 10619, 10620, 10617
39096, 10220, 10221, 10244, 10243, 10575, 10621, 10622, 10619
39097, 10221, 10222, 10245, 10244, 10577, 10623, 10624, 10621
39098, 10222, 10223, 10246, 10245, 10579, 10625, 10626, 10623
39099, 10223, 10224, 10247, 10246, 10581, 10627, 10628, 10625
39100, 10224, 10225, 10248, 10247, 10583, 10629, 10630, 10627
39101, 10225, 10226, 10249, 10248, 10585, 10631, 10632, 10629
39102, 10226, 10227, 10250, 10249, 10587, 10633, 10634, 10631
39103, 10227, 10228, 10251, 10250, 10589, 10635, 10636, 10633
39104, 10228, 10229, 10252, 10251, 10591, 10637, 10638, 10635
39105, 10229, 10230, 10253, 10252, 10593, 10639, 10640, 10637
39106, 10230, 10231, 10254, 10253, 10595, 10641, 10642, 10639
39107, 10231, 10232, 10255, 10254, 10597, 10643, 10644, 10641
39108, 10232, 10233, 10256, 10255, 10599, 10645, 10646, 10643
39109, 10233, 10234, 10257, 10256, 10601, 10647, 10648, 10645
39110, 10234, 10235, 10258, 10257, 10603, 10649, 10650, 10647
39111, 10235, 10236, 10259, 10258, 10605, 10651, 10652, 10649
39112, 10236, 10237, 10260, 10259, 10607, 10653, 10654, 10651
39113, 10237, 10238, 10261, 10260, 10609, 10655, 10656, 10653
39114, 10238, 10239, 10262, 10261, 10611, 10657, 10658, 10655
39115, 10239, 1353, 1354, 10262, 10612, 1365, 10659, 10657
39116, 1331, 10240, 10263, 1332, 10614, 10660, 10661, 1343
39117, 10240, 10241, 10264, 10263, 10616, 10662, 10663, 10660
39118, 10241, 10242, 10265, 10264, 10618, 10664, 10665, 10662
39119, 10242, 10243, 10266, 10265, 10620, 10666, 10667, 10664
39120, 10243, 10244, 10267, 10266, 10622, 10668, 10669, 10666
39121, 10244, 10245, 10268, 10267, 10624, 10670, 10671, 10668
39122, 10245, 10246, 10269, 10268, 10626, 10672, 10673, 10670
39123, 10246, 10247, 10270, 10269, 10628, 10674, 10675, 10672
39124, 10247, 10248, 10271, 10270, 10630, 10676, 10677, 10674
39125, 10248, 10249, 10272, 10271, 10632, 10678, 10679, 10676
39126, 10249, 10250, 10273, 10272, 10634, 10680, 10681, 10678
39127, 10250, 10251, 10274, 10273, 10636, 10682, 10683, 10680
39128, 10251, 10252, 10275, 10274, 10638, 10684, 10685, 10682
39129, 10252, 10253, 10276, 10275, 10640, 10686, 10687, 10684
39130, 10253, 10254, 10277, 10276, 10642, 10688, 10689, 10686
39131, 10254, 10255, 10278, 10277, 10644, 10690, 10691, 10688
39132, 10255, 10256, 10279, 10278, 10646, 10692, 10693, 10690
39133, 10256, 10257, 10280, 10279, 10648, 10694, 10695, 10692
39134, 10257, 10258, 10281, 10280, 10650, 10696, 10697, 10694
39135, 10258, 10259, 10282, 10281, 10652, 10698, 10699, 10696
39136, 10259, 10260, 10283, 10282, 10654, 10700, 10701, 10698
39137, 10260, 10261, 10284, 10283, 10656, 10702, 10703, 10700
39138, 10261, 10262, 10285, 10284, 10658, 10704, 10705, 10702
39139, 10262, 1354, 1355, 10285, 10659, 1366, 10706, 10704
39140, 1332, 10263, 10286, 1333, 10661, 10707, 10708, 1344
39141, 10263, 10264, 10287, 10286, 10663, 10709, 10710, 10707
39142, 10264, 10265, 10288, 10287, 10665, 10711, 10712, 10709
39143, 10265, 10266, 10289, 10288, 10667, 10713, 10714, 10711
39144, 10266, 10267, 10290, 10289, 10669, 10715, 10716, 10713
39145, 10267, 10268, 10291, 10290, 10671, 10717, 10718, 10715
39146, 10268, 10269, 10292, 10291, 10673, 10719, 10720, 10717
39147, 10269, 10270, 10293, 10292, 10675, 10721, 10722, 10719
39148, 10270, 10271, 10294, 10293, 10677, 10723, 10724, 10721
39149, 10271, 10272, 10295, 10294, 10679, 10725, 10726, 10723
39150, 10272, 10273, 10296, 10295, 10681, 10727, 10728, 10725
39151, 10273, 10274, 10297, 10296, 10683, 10729, 10730, 10727
39152, 10274, 10275, 10298, 10297, 10685, 10731, 10732, 10729
39153, 10275, 10276, 10299, 10298, 10687, 10733, 10734, 10731
39154, 10276, 10277, 10300, 10299, 10689, 10735, 10736, 10733
39155, 10277, 10278, 10301, 10300, 10691, 10737, 10738, 10735
39156, 10278, 10279, 10302, 10301, 10693, 10739, 10740, 10737
39157, 10279, 10280, 10303, 10302, 10695, 10741, 10742, 10739
39158, 10280, 10281, 10304, 10303, 10697, 10743, 10744, 10741
39159, 10281, 10282, 10305, 10304, 10699, 10745, 10746, 10743
39160, 10282, 10283, 10306, 10305, 10701, 10747, 10748, 10745
39161, 10283, 10284, 10307, 10306, 10703, 10749, 10750, 10747
39162, 10284, 10285, 10308, 10307, 10705, 10751, 10752, 10749
39163, 10285, 1355, 1356, 10308, 10706, 1367, 10753, 10751
39164, 1333, 10286, 10309, 1334, 10708, 10754, 10755, 1345
39165, 10286, 10287, 10310, 10309, 10710, 10756, 10757, 10754
39166, 10287, 10288, 10311, 10310, 10712, 10758, 10759, 10756
39167, 10288, 10289, 10312, 10311, 10714, 10760, 10761, 10758
39168, 10289, 10290, 10313, 10312, 10716, 10762, 10763, 10760
39169, 10290, 10291, 10314, 10313, 10718, 10764, 10765, 10762
39170, 10291, 10292, 10315, 10314, 10720, 10766, 10767, 10764
39171, 10292, 10293, 10316, 10315, 10722, 10768, 10769, 10766
39172, 10293, 10294, 10317, 10316, 10724, 10770, 10771, 10768
39173, 10294, 10295, 10318, 10317, 10726, 10772, 10773, 10770
39174, 10295, 10296, 10319, 10318, 10728, 10774, 10775, 10772
39175, 10296, 10297, 10320, 10319, 10730, 10776, 10777, 10774
39176, 10297, 10298, 10321, 10320, 10732, 10778, 10779, 10776
39177, 10298, 10299, 10322, 10321, 10734, 10780, 10781, 10778
39178, 10299, 10300, 10323, 10322, 10736, 10782, 10783, 10780
39179, 10300, 10301, 10324, 10323, 10738, 10784, 10785, 10782
39180, 10301, 10302, 10325, 10324, 10740, 10786, 10787, 10784
39181, 10302, 10303, 10326, 10325, 10742, 10788, 10789, 10786
39182, 10303, 10304, 10327, 10326, 10744, 10790, 10791, 10788
39183, 10304, 10305, 10328, 10327, 10746, 10792, 10793, 10790
39184, 10305, 10306, 10329, 10328, 10748, 10794, 10795, 10792
39185, 10306, 10307, 10330, 10329, 10750, 10796, 10797, 10794
39186, 10307, 10308, 10331, 10330, 10752, 10798, 10799, 10796
39187, 10308, 1356, 1357, 10331, 10753, 1368, 10800, 10798
39188, 1334, 10309, 10332, 1335, 10755, 10801, 10802, 1346
39189, 10309, 10310, 10333, 10332, 10757, 10803, 10804, 10801
39190, 10310, 10311, 10334, 10333, 10759, 10805, 10806, 10803
39191, 10311, 10312, 10335, 10334, 10761, 10807, 10808, 10805
39192, 10312, 10313, 10336, 10335, 10763, 10809, 10810, 10807
39193, 10313, 10314, 10337, 10336, 10765, 10811, 10812, 10809
39194, 10314, 10315, 10338, 10337, 10767, 10813, 10814, 10811
39195, 10315, 10316, 10339, 10338, 10769, 10815, 10816, 10813
39196, 10316, 10317, 10340, 10339, 10771, 10817, 10818, 10815
39197, 10317, 10318, 10341, 10340, 10773, 10819, 10820, 10817
39198, 10318, 10319, 10342, 10341, 10775, 10821, 10822, 10819
39199, 10319, 10320, 10343, 10342, 10777, 10823, 10824, 10821
39200, 10320, 10321, 10344, 10343, 10779, 10825, 10826, 10823
39201, 10321, 10322, 10345, 10344, 10781, 10827, 10828, 10825
39202, 10322, 10323, 10346, 10345, 10783, 10829, 10830, 10827
39203, 10323, 10324, 10347, 10346, 10785, 10831, 10832, 10829
39204, 10324, 10325, 10348, 10347, 10787, 10833, 10834, 10831
39205, 10325, 10326, 10349, 10348, 10789, 10835, 10836, 10833
39206, 10326, 10327, 10350, 10349, 10791, 10837, 10838, 10835
39207, 10327, 10328, 10351, 10350, 10793, 10839, 10840, 10837
39208, 10328, 10329, 10352, 10351, 10795, 10841, 10842, 10839
39209, 10329, 10330, 10353, 10352, 10797, 10843, 10844, 10841
39210, 10330, 10331, 10354, 10353, 10799, 10845, 10846, 10843
39211, 10331, 1357, 1358, 10354, 10800, 1369, 10847, 10845
39212, 1335, 10332, 10355, 1336, 10802, 10848, 10849, 1347
39213, 10332, 10333, 10356, 10355, 10804, 10850, 10851, 10848
39214, 10333, 10334, 10357, 10356, 10806, 10852, 10853, 10850
39215, 10334, 10335, 10358, 10357, 10808, 10854, 10855, 10852
39216, 10335, 10336, 10359, 10358, 10810, 10856, 10857, 10854
39217, 10336, 10337, 10360, 10359, 10812, 10858, 10859, 10856
39218, 10337, 10338, 10361, 10360, 10814, 10860, 10861, 10858
39219, 10338, 10339, 10362, 10361, 10816, 10862, 10863, 10860
39220, 10339, 10340, 10363, 10362, 10818, 10864, 10865, 10862
39221, 10340, 10341, 10364, 10363, 10820, 10866, 10867, 10864
39222, 10341, 10342, 10365, 10364, 10822, 10868, 10869, 10866
39223, 10342, 10343, 10366, 10365, 10824, 10870, 10871, 10868
39224, 10343, 10344, 10367, 10366, 10826, 10872, 10873, 10870
39225, 10344, 10345, 10368, 10367, 10828, 10874, 10875, 10872
39226, 10345, 10346, 10369, 10368, 10830, 10876, 10877, 10874
39227, 10346, 10347, 10370, 10369, 10832, 10878, 10879, 10876
39228, 10347, 10348, 10371, 10370, 10834, 10880, 10881, 10878
39229, 10348, 10349, 10372, 10371, 10836, 10882, 10883, 10880
39230, 10349, 10350, 10373, 10372, 10838, 10884, 10885, 10882
39231, 10350, 10351, 10374, 10373, 10840, 10886, 10887, 10884
39232, 10351, 10352, 10375, 10374, 10842, 10888, 10889, 10886
39233, 10352, 10353, 10376, 10375, 10844, 10890, 10891, 10888
39234, 10353, 10354, 10377, 10376, 10846, 10892, 10893, 10890
39235, 10354, 1358, 1359, 10377, 10847, 1370, 10894, 10892
39236, 1336, 10355, 1254, 57, 10849, 10895, 0, 1348
39237, 10355, 10356, 1255, 1254, 10851, 10896, 0, 10895
39238, 10356, 10357, 1256, 1255, 10853, 10897, 0, 10896
39239, 10357, 10358, 1257, 1256, 10855, 10898, 0, 10897
39240, 10358, 10359, 1258, 1257, 10857, 10899, 0, 10898
39241, 10359, 10360, 1259, 1258, 10859, 10900, 0, 10899
39242, 10360, 10361, 1260, 1259, 10861, 10901, 0, 10900
39243, 10361, 10362, 1261, 1260, 10863, 10902, 0, 10901
39244, 10362, 10363, 1262, 1261, 10865, 10903, 0, 10902
39245, 10363, 10364, 1263, 1262, 10867, 10904, 0, 10903
39246, 10364, 10365, 1264, 1263, 10869, 10905, 0, 10904
39247, 10365, 10366, 1265, 1264, 10871, 10906, 0, 10905
39248, 10366, 10367, 1266, 1265, 10873, 10907, 0, 10906
39249, 10367, 10368, 1267, 1266, 10875, 10908, 0, 10907
39250, 10368, 10369, 1268, 1267, 10877, 10909, 0, 10908
39251, 10369, 10370, 1269, 1268, 10879, 10910, 0, 10909
39252, 10370, 10371, 1270, 1269, 10881, 10911, 0, 10910
39253, 10371, 10372, 1271, 1270, 10883, 10912, 0, 10911
39254, 10372, 10373, 1272, 1271, 10885, 10913, 0, 10912
39255, 10373, 10374, 1273, 1272, 10887, 10914, 0, 10913
39256, 10374, 10375, 1274, 1273, 10889, 10915, 0, 10914
39257, 10375, 10376, 1275, 1274, 10891, 10916, 0, 10915
39258, 10376, 10377, 1276, 1275, 10893, 10917, 0, 10916
39259, 10377, 1359, 58, 1276, 10894, 1371, 0, 10917
*ELEMENT, type=CPS8, ELSET=Surface82
3611, 33, 61, 1372, 842, 0, 0, 0, 0
3612, 842, 1372, 1373, 843, 0, 0, 0, 0
3613, 843, 1373, 1374, 844, 0, 0, 0, 0
3614, 844, 1374, 1375, 845, 0, 0, 0, 0
3615, 845, 1375, 1376, 846, 0, 0, 0, 0
3616, 846, 1376, 1377, 847, 0, 0, 0, 0
3617, 847, 1377, 1378, 848, 0, 0, 0, 0
3618, 848, 1378, 1379, 849, 0, 0, 0, 0
3619, 849, 1379, 1380, 850, 0, 0, 0, 0
3620, 850, 1380, 1381, 851, 0, 0, 0, 0
3621, 851, 1381, 1382, 852, 0, 0, 0, 0
3622, 852, 1382, 1383, 853, 0, 0, 0, 0
3623, 853, 1383, 1384, 854, 0, 0, 0, 0
3624, 854, 1384, 1385, 855, 0, 0, 0, 0
3625, 855, 1385, 1386, 856, 0, 0, 0, 0
3626, 856, 1386, 1387, 857, 0, 0, 0, 0
3627, 857, 1387, 1388, 858, 0, 0, 0, 0
3628, 858, 1388, 1389, 859, 0, 0, 0, 0
3629, 859, 1389, 1390, 860, 0, 0, 0, 0
3630, 860, 1390, 1391, 861, 0, 0, 0, 0
3631, 861, 1391, 1392, 862, 0, 0, 0, 0
3632, 862, 1392, 1393, 863, 0, 0, 0, 0
3633, 863, 1393, 1394, 864, 0, 0, 0, 0
3634, 864, 1394, 62, 37, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface83
39260, 35, 911, 1397, 63, 0, 10918, 1420, 1395
39261, 911, 912, 1398, 1397, 0, 10919, 1421, 10918
39262, 912, 913, 1399, 1398, 0, 10920, 1422, 10919
39263, 913, 914, 1400, 1399, 0, 10921, 1423, 10920
39264, 914, 915, 1401, 1400, 0, 10922, 1424, 10921
39265, 915, 916, 1402, 1401, 0, 10923, 1425, 10922
39266, 916, 917, 1403, 1402, 0, 10924, 1426, 10923
39267, 917, 918, 1404, 1403, 0, 10925, 1427, 10924
39268, 918, 919, 1405, 1404, 0, 10926, 1428, 10925
39269, 919, 920, 1406, 1405, 0, 10927, 1429, 10926
39270, 920, 921, 1407, 1406, 0, 10928, 1430, 10927
39271, 921, 922, 1408, 1407, 0, 10929, 1431, 10928
39272, 922, 923, 1409, 1408, 0, 10930, 1432, 10929
39273, 923, 924, 1410, 1409, 0, 10931, 1433, 10930
39274, 924, 925, 1411, 1410, 0, 10932, 1434, 10931
39275, 925, 926, 1412, 1411, 0, 10933, 1435, 10932
39276, 926, 927, 1413, 1412, 0, 10934, 1436, 10933
39277, 927, 928, 1414, 1413, 0, 10935, 1437, 10934
39278, 928, 929, 1415, 1414, 0, 10936, 1438, 10935
39279, 929, 930, 1416, 1415, 0, 10937, 1439, 10936
39280, 930, 931, 1417, 1416, 0, 10938, 1440, 10937
39281, 931, 932, 1418, 1417, 0, 10939, 1441, 10938
39282, 932, 933, 1419, 1418, 0, 10940, 1442, 10939
39283, 933, 39, 64, 1419, 0, 1396, 1443, 10940
*ELEMENT, type=CPS8, ELSET=Surface84
39284, 35, 63, 1444, 820, 1395, 1455, 10941, 0
39285, 820, 1444, 1445, 821, 10941, 1456, 10942, 0
39286, 821, 1445, 1446, 822, 10942, 1457, 10943, 0
39287, 822, 1446, 1447, 823, 10943, 1458, 10944, 0
39288, 823, 1447, 1448, 824, 10944, 1459, 10945, 0
39289, 824, 1448, 1449, 825, 10945, 1460, 10946, 0
39290, 825, 1449, 1450, 826, 10946, 1461, 10947, 0
39291, 826, 1450, 1451, 827, 10947, 1462, 10948, 0
39292, 827, 1451, 1452, 828, 10948, 1463, 10949, 0
39293, 828, 1452, 1453, 829, 10949, 1464, 10950, 0
39294, 829, 1453, 1454, 830, 10950, 1465, 10951, 0
39295, 830, 1454, 61, 33, 10951, 1466, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface85
39296, 39, 980, 1467, 64, 0, 10952, 1478, 1396
39297, 980, 981, 1468, 1467, 0, 10953, 1479, 10952
39298, 981, 982, 1469, 1468, 0, 10954, 1480, 10953
39299, 982, 983, 1470, 1469, 0, 10955, 1481, 10954
39300, 983, 984, 1471, 1470, 0, 10956, 1482, 10955
39301, 984, 985, 1472, 1471, 0, 10957, 1483, 10956
39302, 985, 986, 1473, 1472, 0, 10958, 1484, 10957
39303, 986, 987, 1474, 1473, 0, 10959, 1485, 10958
39304, 987, 988, 1475, 1474, 0, 10960, 1486, 10959
39305, 988, 989, 1476, 1475, 0, 10961, 1487, 10960
39306, 989, 990, 1477, 1476, 0, 10962, 1488, 10961
39307, 990, 37, 62, 1477, 0, 0, 1489, 10962
*ELEMENT, type=CPS8, ELSET=Surface86
39308, 63, 1397, 10963, 1444, 1420, 11216, 11217, 1455
39309, 1397, 1398, 10964, 10963, 1421, 11218, 11219, 11216
39310, 1398, 1399, 10965, 10964, 1422, 11220, 11221, 11218
39311, 1399, 1400, 10966, 10965, 1423, 11222, 11223, 11220
39312, 1400, 1401, 10967, 10966, 1424, 11224, 11225, 11222
39313, 1401, 1402, 10968, 10967, 1425, 11226, 11227, 11224
39314, 1402, 1403, 10969, 10968, 1426, 11228, 11229, 11226
39315, 1403, 1404, 10970, 10969, 1427, 11230, 11231, 11228
39316, 1404, 1405, 10971, 10970, 1428, 11232, 11233, 11230
39317, 1405, 1406, 10972, 10971, 1429, 11234, 11235, 11232
39318, 1406, 1407, 10973, 10972, 1430, 11236, 11237, 11234
39319, 1407, 1408, 10974, 10973, 1431, 11238, 11239, 11236
39320, 1408, 1409, 10975, 10974, 1432, 11240, 11241, 11238
39321, 1409, 1410, 10976, 10975, 1433, 11242, 11243, 11240
39322, 1410, 1411, 10977, 10976, 1434, 11244, 11245, 11242
39323, 1411, 1412, 10978, 10977, 1435, 11246, 11247, 11244
39324, 1412, 1413, 10979, 10978, 1436, 11248, 11249, 11246
39325, 1413, 1414, 10980, 10979, 1437, 11250, 11251, 11248
39326, 1414, 1415, 10981, 10980, 1438, 11252, 11253, 11250
39327, 1415, 1416, 10982, 10981, 1439, 11254, 11255, 11252
39328, 1416, 1417, 10983, 10982, 1440, 11256, 11257, 11254
39329, 1417, 1418, 10984, 10983, 1441, 11258, 11259, 11256
39330, 1418, 1419, 10985, 10984, 1442, 11260, 11261, 11258
39331, 1419, 64, 1467, 10985, 1443, 1478, 11262, 11260
39332, 1444, 10963, 10986, 1445, 11217, 11263, 11264, 1456
39333, 10963, 10964, 10987, 10986, 11219, 11265, 11266, 11263
39334, 10964, 10965, 10988, 10987, 11221, 11267, 11268, 11265
39335, 10965, 10966, 10989, 10988, 11223, 11269, 11270, 11267
39336, 10966, 10967, 10990, 10989, 11225, 11271, 11272, 11269
39337, 10967, 10968, 10991, 10990, 11227, 11273, 11274, 11271
39338, 10968, 10969, 10992, 10991, 11229, 11275, 11276, 11273
39339, 10969, 10970, 10993, 10992, 11231, 11277, 11278, 11275
39340, 10970, 10971, 10994, 10993, 11233, 11279, 11280, 11277
39341, 10971, 10972, 10995, 10994, 11235, 11281, 11282, 11279
39342, 10972, 10973, 10996, 10995, 11237, 11283, 11284, 11281
39343, 10973, 10974, 10997, 10996, 11239, 11285, 11286, 11283
39344, 10974, 10975, 10998, 10997, 11241, 11287, 11288, 11285
39345, 10975, 10976, 10999, 10998, 11243, 11289, 11290, 11287
39346, 10976, 10977, 11000, 10999, 11245, 11291, 11292, 11289
39347, 10977, 10978, 11001, 11000, 11247, 11293, 11294, 11291
39348, 10978, 10979, 11002, 11001, 11249, 11295, 11296, 11293
39349, 10979, 10980, 11003, 11002, 11251, 11297, 11298, 11295
39350, 10980, 10981, 11004, 11003, 11253, 11299, 11300, 11297
39351, 10981, 10982, 11005, 11004, 11255, 11301, 11302, 11299
39352, 10982, 10983, 11006, 11005, 11257, 11303, 11304, 11301
39353, 10983, 10984, 11007, 11006, 11259, 11305, 11306, 11303
39354, 10984, 10985, 11008, 11007, 11261, 11307, 11308, 11305
39355, 10985, 1467, 1468, 11008, 11262, 1479, 11309, 11307
39356, 1445, 10986, 11009, 1446, 11264, 11310, 11311, 1457
39357, 10986, 10987, 11010, 11009, 11266, 11312, 11313, 11310
39358, 10987, 10988, 11011, 11010, 11268, 11314, 11315, 11312
39359, 10988, 10989, 11012, 11011, 11270, 11316, 11317, 11314
39360, 10989, 10990, 11013, 11012, 11272, 11318, 11319, 11316
39361, 10990, 10991, 11014, 11013, 11274, 11320, 11321, 11318
39362, 10991, 10992, 11015, 11014, 11276, 11322, 11323, 11320
39363, 10992, 10993, 11016, 11015, 11278, 11324, 11325, 11322
39364, 10993, 10994, 11017, 11016, 11280, 11326, 11327, 11324
39365, 10994, 10995, 11018, 11017, 11282, 11328, 11329, 11326
39366, 10995, 10996, 11019, 11018, 11284, 11330, 11331, 11328
39367, 10996, 10997, 11020, 11019, 11286, 11332, 11333, 11330
39368, 10997, 10998, 11021, 11020, 11288, 11334, 11335, 11332
39369, 10998, 10999, 11022, 11021, 11290, 11336, 11337, 11334
39370, 10999, 11000, 11023, 11022, 11292, 11338, 11339, 11336
39371, 11000, 11001, 11024, 11023, 11294, 11340, 11341, 11338
39372, 11001, 11002, 11025, 11024, 11296, 11342, 11343, 11340
39373, 11002, 11003, 11026, 11025, 11298, 11344, 11345, 11342
39374, 11003, 11004, 11027, 11026, 11300, 11346, 11347, 11344
39375, 11004, 11005, 11028, 11027, 11302, 11348, 11349, 11346
39376, 11005, 11006, 11029, 11028, 11304, 11350, 11351, 11348
39377, 11006, 11007, 11030, 11029, 11306, 11352, 11353, 11350
39378, 11007, 11008, 11031, 11030, 11308, 11354, 11355, 11352
39379, 11008, 1468, 1469, 11031, 11309, 1480, 11356, 11354
39380, 1446, 11009, 11032, 1447, 11311, 11357, 11358, 1458
39381, 11009, 11010, 11033, 11032, 11313, 11359, 11360, 11357
39382, 11010, 11011, 11034, 11033, 11315, 11361, 11362, 11359
39383, 11011, 11012, 11035, 11034, 11317, 11363, 11364, 11361
39384, 11012, 11013, 11036, 11035, 11319, 11365, 11366, 11363
39385, 11013, 11014, 11037, 11036, 11321, 11367, 11368, 11365
39386, 11014, 11015, 11038, 11037, 11323, 11369, 11370, 11367
39387, 11015, 11016, 11039, 11038, 11325, 11371, 11372, 11369
39388, 11016, 11017, 11040, 11039, 11327, 11373, 11374, 11371
39389, 11017, 11018, 11041, 11040, 11329, 11375, 11376, 11373
39390, 11018, 11019, 11042, 11041, 11331, 11377, 11378, 11375
39391, 11019, 11020, 11043, 11042, 11333, 11379, 11380, 11377
39392, 11020, 11021, 11044, 11043, 11335, 11381, 11382, 11379
39393, 11021, 11022, 11045, 11044, 11337, 11383, 11384, 11381
39394, 11022, 11023, 11046, 11045, 11339, 11385, 11386, 11383
39395, 11023, 11024, 11047, 11046, 11341, 11387, 11388, 11385
39396, 11024, 11025, 11048, 11047, 11343, 11389, 11390, 11387
39397, 11025, 11026, 11049, 11048, 11345, 11391, 11392, 11389
39398, 11026, 11027, 11050, 11049, 11347, 11393, 11394, 11391
39399, 11027, 11028, 11051, 11050, 11349, 11395, 11396, 11393
39400, 11028, 11029, 11052, 11051, 11351, 11397, 11398, 11395
39401, 11029, 11030, 11053, 11052, 11353, 11399, 11400, 11397
39402, 11030, 11031, 11054, 11053, 11355, 11401, 11402, 11399
39403, 11031, 1469, 1470, 11054, 11356, 1481, 11403, 11401
39404, 1447, 11032, 11055, 1448, 11358, 11404, 11405, 1459
39405, 11032, 11033, 11056, 11055, 11360, 11406, 11407, 11404
39406, 11033, 11034, 11057, 11056, 11362, 11408, 11409, 11406
39407, 11034, 11035, 11058, 11057, 11364, 11410, 11411, 11408
39408, 11035, 11036, 11059, 11058, 11366, 11412, 11413, 11410
39409, 11036, 11037, 11060, 11059, 11368, 11414, 11415, 11412
39410, 11037, 11038, 11061, 11060, 11370, 11416, 11417, 11414
39411, 11038, 11039, 11062, 11061, 11372, 11418, 11419, 11416
39412, 11039, 11040, 11063, 11062, 11374, 11420, 11421, 11418
39413, 11040, 11041, 11064, 11063, 11376, 11422, 11423, 11420
39414, 11041, 11042, 11065, 11064, 11378, 11424, 11425, 11422
39415, 11042, 11043, 11066, 11065, 11380, 11426, 11427, 11424
39416, 11043, 11044, 11067, 11066, 11382, 11428, 11429, 11426
39417, 11044, 11045, 11068, 11067, 11384, 11430, 11431, 11428
39418, 11045, 11046, 11069, 11068, 11386, 11432, 11433, 11430
39419, 11046, 11047, 11070, 11069, 11388, 11434, 11435, 11432
39420, 11047, 11048, 11071, 11070, 11390, 11436, 11437, 11434
39421, 11048, 11049, 11072, 11071, 11392, 11438, 11439, 11436
39422, 11049, 11050, 11073, 11072, 11394, 11440, 11441, 11438
39423, 11050, 11051, 11074, 11073, 11396, 11442, 11443, 11440
39424, 11051, 11052, 11075, 11074, 11398, 11444, 11445, 11442
39425, 11052, 11053, 11076, 11075, 11400, 11446, 11447, 11444
39426, 11053, 11054, 11077, 11076, 11402, 11448, 11449, 11446
39427, 11054, 1470, 1471, 11077, 11403, 1482, 11450, 11448
39428, 1448, 11055, 11078, 1449, 11405, 11451, 11452, 1460
39429, 11055, 11056, 11079, 11078, 11407, 11453, 11454, 11451
39430, 11056, 11057, 11080, 11079, 11409, 11455, 11456, 11453
39431, 11057, 11058, 11081, 11080, 11411, 11457, 11458, 11455
39432, 11058, 11059, 11082, 11081, 11413, 11459, 11460, 11457
39433, 11059, 11060, 11083, 11082, 11415, 11461, 11462, 11459
39434, 11060, 11061, 11084, 11083, 11417, 11463, 11464, 11461
39435, 11061, 11062, 11085, 11084, 11419, 11465, 11466, 11463
39436, 11062, 11063, 11086, 11085, 11421, 11467, 11468, 11465
39437, 11063, 11064, 11087, 11086, 11423, 11469, 11470, 11467
39438, 11064, 11065, 11088, 11087, 11425, 11471, 11472, 11469
39439, 11065, 11066, 11089, 11088, 11427, 11473, 11474, 11471
39440, 11066, 11067, 11090, 11089, 11429, 11475, 11476, 11473
39441, 11067, 11068, 11091, 11090, 11431, 11477, 11478, 11475
39442, 11068, 11069, 11092, 11091, 11433, 11479, 11480, 11477
39443, 11069, 11070, 11093, 11092, 11435, 11481, 11482, 11479
39444, 11070, 11071, 11094, 11093, 11437, 11483, 11484, 11481
39445, 11071, 11072, 11095, 11094, 11439, 11485, 11486, 11483
39446, 11072, 11073, 11096, 11095, 11441, 11487, 11488, 11485
39447, 11073, 11074, 11097, 11096, 11443, 11489, 11490, 11487
39448, 11074, 11075, 11098, 11097, 11445, 11491, 11492, 11489
39449, 11075, 11076, 11099, 11098, 11447, 11493, 11494, 11491
39450, 11076, 11077, 11100, 11099, 11449, 11495, 11496, 11493
39451, 11077, 1471, 1472, 11100, 11450, 1483, 11497, 11495
39452, 1449, 11078, 11101, 1450, 11452, 11498, 11499, 1461
39453, 11078, 11079, 11102, 11101, 11454, 11500, 11501, 11498
39454, 11079, 11080, 11103, 11102, 11456, 11502, 11503, 11500
39455, 11080, 11081, 11104, 11103, 11458, 11504, 11505, 11502
39456, 11081, 11082, 11105, 11104, 11460, 11506, 11507, 11504
39457, 11082, 11083, 11106, 11105, 11462, 11508, 11509, 11506
39458, 11083, 11084, 11107, 11106, 11464, 11510, 11511, 11508
39459, 11084, 11085, 11108, 11107, 11466, 11512, 11513, 11510
39460, 11085, 11086, 11109, 11108, 11468, 11514, 11515, 11512
39461, 11086, 11087, 11110, 11109, 11470, 11516, 11517, 11514
39462, 11087, 11088, 11111, 11110, 11472, 11518, 11519, 11516
39463, 11088, 11089, 11112, 11111, 11474, 11520, 11521, 11518
39464, 11089, 11090, 11113, 11112, 11476, 11522, 11523, 11520
39465, 11090, 11091, 11114, 11113, 11478, 11524, 11525, 11522
39466, 11091, 11092, 11115, 11114, 11480, 11526, 11527, 11524
39467, 11092, 11093, 11116, 11115, 11482, 11528, 11529, 11526
39468, 11093, 11094, 11117, 11116, 11484, 11530, 11531, 11528
39469, 11094, 11095, 11118, 11117, 11486, 11532, 11533, 11530
39470, 11095, 11096, 11119, 11118, 11488, 11534, 11535, 11532
39471, 11096, 11097, 11120, 11119, 11490, 11536, 11537, 11534
39472, 11097, 11098, 11121, 11120, 11492, 11538, 11539, 11536
39473, 11098, 11099, 11122, 11121, 11494, 11540, 11541, 11538
39474, 11099, 11100, 11123, 11122, 11496, 11542, 11543, 11540
39475, 11100, 1472, 1473, 11123, 11497, 1484, 11544, 11542
39476, 1450, 11101, 11124, 1451, 11499, 11545, 11546, 1462
39477, 11101, 11102, 11125, 11124, 11501, 11547, 11548, 11545
39478, 11102, 11103, 11126, 11125, 11503, 11549, 11550, 11547
39479, 11103, 11104, 11127, 11126, 11505, 11551, 11552, 11549
39480, 11104, 11105, 11128, 11127, 11507, 11553, 11554, 11551
39481, 11105, 11106, 11129, 11128, 11509, 11555, 11556, 11553
39482, 11106, 11107, 11130, 11129, 11511, 11557, 11558, 11555
39483, 11107, 11108, 11131, 11130, 11513, 11559, 11560, 11557
39484, 11108, 11109, 11132, 11131, 11515, 11561, 11562, 11559
39485, 11109, 11110, 11133, 11132, 11517, 11563, 11564, 11561
39486, 11110, 11111, 11134, 11133, 11519, 11565, 11566, 11563
39487, 11111, 11112, 11135, 11134, 11521, 11567, 11568, 11565
39488, 11112, 11113, 11136, 11135, 11523, 11569, 11570, 11567
39489, 11113, 11114, 11137, 11136, 11525, 11571, 11572, 11569
39490, 11114, 11115, 11138, 11137, 11527, 11573, 11574, 11571
39491, 11115, 11116, 11139, 11138, 11529, 11575, 11576, 11573
39492, 11116, 11117, 11140, 11139, 11531, 11577, 11578, 11575
39493, 11117, 11118, 11141, 11140, 11533, 11579, 11580, 11577
39494, 11118, 11119, 11142, 11141, 11535, 11581, 11582, 11579
39495, 11119, 11120, 11143, 11142, 11537, 11583, 11584, 11581
39496, 11120, 11121, 11144, 11143, 11539, 11585, 11586, 11583
39497, 11121, 11122, 11145, 11144, 11541, 11587, 11588, 11585
39498, 11122, 11123, 11146, 11145, 11543, 11589, 11590, 11587
39499, 11123, 1473, 1474, 11146, 11544, 1485, 11591, 11589
39500, 1451, 11124, 11147, 1452, 11546, 11592, 11593, 1463
39501, 11124, 11125, 11148, 11147, 11548, 11594, 11595, 11592
39502, 11125, 11126, 11149, 11148, 11550, 11596, 11597, 11594
39503, 11126, 11127, 11150, 11149, 11552, 11598, 11599, 11596
39504, 11127, 11128, 11151, 11150, 11554, 11600, 11601, 11598
39505, 11128, 11129, 11152, 11151, 11556, 11602, 11603, 11600
39506, 11129, 11130, 11153, 11152, 11558, 11604, 11605, 11602
39507, 11130, 11131, 11154, 11153, 11560, 11606, 11607, 11604
39508, 11131, 11132, 11155, 11154, 11562, 11608, 11609, 11606
39509, 11132, 11133, 11156, 11155, 11564, 11610, 11611, 11608
39510, 11133, 11134, 11157, 11156, 11566, 11612, 11613, 11610
39511, 11134, 11135, 11158, 11157, 11568, 11614, 11615, 11612
39512, 11135, 11136, 11159, 11158, 11570, 11616, 11617, 11614
39513, 11136, 11137, 11160, 11159, 11572, 11618, 11619, 11616
39514, 11137, 11138, 11161, 11160, 11574, 11620, 11621, 11618
39515, 11138, 11139, 11162, 11161, 11576, 11622, 11623, 11620
39516, 11139, 11140, 11163, 11162, 11578, 11624, 11625, 11622
39517, 11140, 11141, 11164, 11163, 11580, 11626, 11627, 11624
39518, 11141, 11142, 11165, 11164, 11582, 11628, 11629, 11626
39519, 11142, 11143, 11166, 11165, 11584, 11630, 11631, 11628
39520, 11143, 11144, 11167, 11166, 11586, 11632, 11633, 11630
39521, 11144, 11145, 11168, 11167, 11588, 11634, 11635, 11632
39522, 11145, 11146, 11169, 11168, 11590, 11636, 11637, 11634
39523, 11146, 1474, 1475, 11169, 11591, 1486, 11638, 11636
39524, 1452, 11147, 11170, 1453, 11593, 11639, 11640, 1464
39525, 11147, 11148, 11171, 11170, 11595, 11641, 11642, 11639
39526, 11148, 11149, 11172, 11171, 11597, 11643, 11644, 11641
39527, 11149, 11150, 11173, 11172, 11599, 11645, 11646, 11643
39528, 11150, 11151, 11174, 11173, 11601, 11647, 11648, 11645
39529, 11151, 11152, 11175, 11174, 11603, 11649, 11650, 11647
39530, 11152, 11153, 11176, 11175, 11605, 11651, 11652, 11649
39531, 11153, 11154, 11177, 11176, 11607, 11653, 11654, 11651
39532, 11154, 11155, 11178, 11177, 11609, 11655, 11656, 11653
39533, 11155, 11156, 11179, 11178, 11611, 11657, 11658, 11655
39534, 11156, 11157, 11180, 11179, 11613, 11659, 11660, 11657
39535, 11157, 11158, 11181, 11180, 11615, 11661, 11662, 11659
39536, 11158, 11159, 11182, 11181, 11617, 11663, 11664, 11661
39537, 11159, 11160, 11183, 11182, 11619, 11665, 11666, 11663
39538, 11160, 11161, 11184, 11183, 11621, 11667, 11668, 11665
39539, 11161, 11162, 11185, 11184, 11623, 11669, 11670, 11667
39540, 11162, 11163, 11186, 11185, 11625, 11671, 11672, 11669
39541, 11163, 11164, 11187, 11186, 11627, 11673, 11674, 11671
39542, 11164, 11165, 11188, 11187, 11629, 11675, 11676, 11673
39543, 11165, 11166, 11189, 11188, 11631, 11677, 11678, 11675
39544, 11166, 11167, 11190, 11189, 11633, 11679, 11680, 11677
39545, 11167, 11168, 11191, 11190, 11635, 11681, 11682, 11679
39546, 11168, 11169, 11192, 11191, 11637, 11683, 11684, 11681
39547, 11169, 1475, 1476, 11192, 11638, 1487, 11685, 11683
39548, 1453, 11170, 11193, 1454, 11640, 11686, 11687, 1465
39549, 11170, 11171, 11194, 11193, 11642, 11688, 11689, 11686
39550, 11171, 11172, 11195, 11194, 11644, 11690, 11691, 11688
39551, 11172, 11173, 11196, 11195, 11646, 11692, 11693, 11690
39552, 11173, 11174, 11197, 11196, 11648, 11694, 11695, 11692
39553, 11174, 11175, 11198, 11197, 11650, 11696, 11697, 11694
39554, 11175, 11176, 11199, 11198, 11652, 11698, 11699, 11696
39555, 11176, 11177, 11200, 11199, 11654, 11700, 11701, 11698
39556, 11177, 11178, 11201, 11200, 11656, 11702, 11703, 11700
39557, 11178, 11179, 11202, 11201, 11658, 11704, 11705, 11702
39558, 11179, 11180, 11203, 11202, 11660, 11706, 11707, 11704
39559, 11180, 11181, 11204, 11203, 11662, 11708, 11709, 11706
39560, 11181, 11182, 11205, 11204, 11664, 11710, 11711, 11708
39561, 11182, 11183, 11206, 11205, 11666, 11712, 11713, 11710
39562, 11183, 11184, 11207, 11206, 11668, 11714, 11715, 11712
39563, 11184, 11185, 11208, 11207, 11670, 11716, 11717, 11714
39564, 11185, 11186, 11209, 11208, 11672, 11718, 11719, 11716
39565, 11186, 11187, 11210, 11209, 11674, 11720, 11721, 11718
39566, 11187, 11188, 11211, 11210, 11676, 11722, 11723, 11720
39567, 11188, 11189, 11212, 11211, 11678, 11724, 11725, 11722
39568, 11189, 11190, 11213, 11212, 11680, 11726, 11727, 11724
39569, 11190, 11191, 11214, 11213, 11682, 11728, 11729, 11726
39570, 11191, 11192, 11215, 11214, 11684, 11730, 11731, 11728
39571, 11192, 1476, 1477, 11215, 11685, 1488, 11732, 11730
39572, 1454, 11193, 1372, 61, 11687, 11733, 0, 1466
39573, 11193, 11194, 1373, 1372, 11689, 11734, 0, 11733
39574, 11194, 11195, 1374, 1373, 11691, 11735, 0, 11734
39575, 11195, 11196, 1375, 1374, 11693, 11736, 0, 11735
39576, 11196, 11197, 1376, 1375, 11695, 11737, 0, 11736
39577, 11197, 11198, 1377, 1376, 11697, 11738, 0, 11737
39578, 11198, 11199, 1378, 1377, 11699, 11739, 0, 11738
39579, 11199, 11200, 1379, 1378, 11701, 11740, 0, 11739
39580, 11200, 11201, 1380, 1379, 11703, 11741, 0, 11740
39581, 11201, 11202, 1381, 1380, 11705, 11742, 0, 11741
39582, 11202, 11203, 1382, 1381, 11707, 11743, 0, 11742
39583, 11203, 11204, 1383, 1382, 11709, 11744, 0, 11743
39584, 11204, 11205, 1384, 1383, 11711, 11745, 0, 11744
39585, 11205, 11206, 1385, 1384, 11713, 11746, 0, 11745
39586, 11206, 11207, 1386, 1385, 11715, 11747, 0, 11746
39587, 11207, 11208, 1387, 1386, 11717, 11748, 0, 11747
39588, 11208, 11209, 1388, 1387, 11719, 11749, 0, 11748
39589, 11209, 11210, 1389, 1388, 11721, 11750, 0, 11749
39590, 11210, 11211, 1390, 1389, 11723, 11751, 0, 11750
39591, 11211, 11212, 1391, 1390, 11725, 11752, 0, 11751
39592, 11212, 11213, 1392, 1391, 11727, 11753, 0, 11752
39593, 11213, 11214, 1393, 1392, 11729, 11754, 0, 11753
39594, 11214, 11215, 1394, 1393, 11731, 11755, 0, 11754
39595, 11215, 1477, 62, 1394, 11732, 1489, 0, 11755
*ELEMENT, type=CPS8, ELSET=Surface87
39596, 9, 65, 1492, 310, 1490, 1515, 11756, 0
39597, 310, 1492, 1493, 311, 11756, 1516, 11757, 0
39598, 311, 1493, 1494, 312, 11757, 1517, 11758, 0
39599, 312, 1494, 1495, 313, 11758, 1518, 11759, 0
39600, 313, 1495, 1496, 314, 11759, 1519, 11760, 0
39601, 314, 1496, 1497, 315, 11760, 1520, 11761, 0
39602, 315, 1497, 1498, 316, 11761, 1521, 11762, 0
39603, 316, 1498, 1499, 317, 11762, 1522, 11763, 0
39604, 317, 1499, 1500, 318, 11763, 1523, 11764, 0
39605, 318, 1500, 1501, 319, 11764, 1524, 11765, 0
39606, 319, 1501, 1502, 320, 11765, 1525, 11766, 0
39607, 320, 1502, 1503, 321, 11766, 1526, 11767, 0
39608, 321, 1503, 1504, 322, 11767, 1527, 11768, 0
39609, 322, 1504, 1505, 323, 11768, 1528, 11769, 0
39610, 323, 1505, 1506, 324, 11769, 1529, 11770, 0
39611, 324, 1506, 1507, 325, 11770, 1530, 11771, 0
39612, 325, 1507, 1508, 326, 11771, 1531, 11772, 0
39613, 326, 1508, 1509, 327, 11772, 1532, 11773, 0
39614, 327, 1509, 1510, 328, 11773, 1533, 11774, 0
39615, 328, 1510, 1511, 329, 11774, 1534, 11775, 0
39616, 329, 1511, 1512, 330, 11775, 1535, 11776, 0
39617, 330, 1512, 1513, 331, 11776, 1536, 11777, 0
39618, 331, 1513, 1514, 332, 11777, 1537, 11778, 0
39619, 332, 1514, 66, 13, 11778, 1538, 1491, 0
*ELEMENT, type=CPS8, ELSET=Surface88
39620, 10, 333, 1541, 67, 0, 11779, 1564, 1539
39621, 333, 334, 1542, 1541, 0, 11780, 1565, 11779
39622, 334, 335, 1543, 1542, 0, 11781, 1566, 11780
39623, 335, 336, 1544, 1543, 0, 11782, 1567, 11781
39624, 336, 337, 1545, 1544, 0, 11783, 1568, 11782
39625, 337, 338, 1546, 1545, 0, 11784, 1569, 11783
39626, 338, 339, 1547, 1546, 0, 11785, 1570, 11784
39627, 339, 340, 1548, 1547, 0, 11786, 1571, 11785
39628, 340, 341, 1549, 1548, 0, 11787, 1572, 11786
39629, 341, 342, 1550, 1549, 0, 11788, 1573, 11787
39630, 342, 343, 1551, 1550, 0, 11789, 1574, 11788
39631, 343, 344, 1552, 1551, 0, 11790, 1575, 11789
39632, 344, 345, 1553, 1552, 0, 11791, 1576, 11790
39633, 345, 346, 1554, 1553, 0, 11792, 1577, 11791
39634, 346, 347, 1555, 1554, 0, 11793, 1578, 11792
39635, 347, 348, 1556, 1555, 0, 11794, 1579, 11793
39636, 348, 349, 1557, 1556, 0, 11795, 1580, 11794
