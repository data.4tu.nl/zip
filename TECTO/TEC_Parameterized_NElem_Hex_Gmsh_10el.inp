34660, 1.4083333333333, 0.033333333333333, 0.3125
34661, 1.3875, 0.033333333333333, 0.33333333333333
34662, 1.4083333333333, 0.016666666666667, 0.33333333333333
34663, 1.45, 0.083333333333333, 0.33333333333333
34664, 1.45, 0.066666666666667, 0.3125
34665, 1.4291666666667, 0.066666666666667, 0.33333333333333
34666, 1.45, 0.05, 0.33333333333333
34667, 1.45, 0.033333333333333, 0.3125
34668, 1.4291666666667, 0.033333333333333, 0.33333333333333
34669, 1.45, 0.016666666666667, 0.33333333333333
34670, 1.4916666666667, 0.083333333333333, 0.33333333333333
34671, 1.4916666666667, 0.066666666666667, 0.3125
34672, 1.4708333333333, 0.066666666666667, 0.33333333333333
34673, 1.4916666666667, 0.05, 0.33333333333333
34674, 1.4916666666667, 0.033333333333333, 0.3125
34675, 1.4708333333333, 0.033333333333333, 0.33333333333333
34676, 1.4916666666667, 0.016666666666667, 0.33333333333333
34677, 1.5333333333333, 0.083333333333333, 0.33333333333333
34678, 1.5333333333333, 0.066666666666667, 0.3125
34679, 1.5125, 0.066666666666667, 0.33333333333333
34680, 1.5333333333333, 0.05, 0.33333333333333
34681, 1.5333333333333, 0.033333333333333, 0.3125
34682, 1.5125, 0.033333333333333, 0.33333333333333
34683, 1.5333333333333, 0.016666666666667, 0.33333333333333
34684, 1.575, 0.083333333333333, 0.33333333333333
34685, 1.575, 0.066666666666667, 0.3125
34686, 1.5541666666667, 0.066666666666667, 0.33333333333333
34687, 1.575, 0.05, 0.33333333333333
34688, 1.575, 0.033333333333333, 0.3125
34689, 1.5541666666667, 0.033333333333333, 0.33333333333333
34690, 1.575, 0.016666666666667, 0.33333333333333
34691, 1.6166666666667, 0.083333333333333, 0.33333333333333
34692, 1.6166666666667, 0.066666666666667, 0.3125
34693, 1.5958333333333, 0.066666666666667, 0.33333333333333
34694, 1.6166666666667, 0.05, 0.33333333333333
34695, 1.6166666666667, 0.033333333333333, 0.3125
34696, 1.5958333333333, 0.033333333333333, 0.33333333333333
34697, 1.6166666666667, 0.016666666666667, 0.33333333333333
34698, 1.6583333333333, 0.083333333333333, 0.33333333333333
34699, 1.6583333333333, 0.066666666666667, 0.3125
34700, 1.6375, 0.066666666666667, 0.33333333333333
34701, 1.6583333333333, 0.05, 0.33333333333333
34702, 1.6583333333333, 0.033333333333333, 0.3125
34703, 1.6375, 0.033333333333333, 0.33333333333333
34704, 1.6583333333333, 0.016666666666667, 0.33333333333333
34705, 1.7, 0.083333333333333, 0.33333333333333
34706, 1.7, 0.066666666666667, 0.3125
34707, 1.6791666666667, 0.066666666666667, 0.33333333333333
34708, 1.7, 0.05, 0.33333333333333
34709, 1.7, 0.033333333333333, 0.3125
34710, 1.6791666666667, 0.033333333333333, 0.33333333333333
34711, 1.7, 0.016666666666667, 0.33333333333333
34712, 1.7416666666667, 0.083333333333333, 0.33333333333333
34713, 1.7416666666667, 0.066666666666667, 0.3125
34714, 1.7208333333333, 0.066666666666667, 0.33333333333333
34715, 1.7416666666667, 0.05, 0.33333333333333
34716, 1.7416666666667, 0.033333333333333, 0.3125
34717, 1.7208333333333, 0.033333333333333, 0.33333333333333
34718, 1.7416666666667, 0.016666666666667, 0.33333333333333
34719, 1.7833333333333, 0.083333333333333, 0.33333333333333
34720, 1.7833333333333, 0.066666666666667, 0.3125
34721, 1.7625, 0.066666666666667, 0.33333333333333
34722, 1.7833333333333, 0.05, 0.33333333333333
34723, 1.7833333333333, 0.033333333333333, 0.3125
34724, 1.7625, 0.033333333333333, 0.33333333333333
34725, 1.7833333333333, 0.016666666666667, 0.33333333333333
34726, 1.825, 0.083333333333333, 0.33333333333333
34727, 1.825, 0.066666666666667, 0.3125
34728, 1.8041666666667, 0.066666666666667, 0.33333333333333
34729, 1.825, 0.05, 0.33333333333333
34730, 1.825, 0.033333333333333, 0.3125
34731, 1.8041666666667, 0.033333333333333, 0.33333333333333
34732, 1.825, 0.016666666666667, 0.33333333333333
34733, 1.8666666666667, 0.083333333333333, 0.33333333333333
34734, 1.8666666666667, 0.066666666666667, 0.3125
34735, 1.8458333333333, 0.066666666666667, 0.33333333333333
34736, 1.8666666666667, 0.05, 0.33333333333333
34737, 1.8666666666667, 0.033333333333333, 0.3125
34738, 1.8458333333333, 0.033333333333333, 0.33333333333333
34739, 1.8666666666667, 0.016666666666667, 0.33333333333333
34740, 1.9083333333333, 0.083333333333333, 0.33333333333333
34741, 1.9083333333333, 0.066666666666667, 0.3125
34742, 1.8875, 0.066666666666667, 0.33333333333333
34743, 1.9083333333333, 0.05, 0.33333333333333
34744, 1.9083333333333, 0.033333333333333, 0.3125
34745, 1.8875, 0.033333333333333, 0.33333333333333
34746, 1.9083333333333, 0.016666666666667, 0.33333333333333
34747, 1.95, 0.083333333333333, 0.33333333333333
34748, 1.95, 0.066666666666667, 0.3125
34749, 1.9291666666667, 0.066666666666667, 0.33333333333333
34750, 1.95, 0.05, 0.33333333333333
34751, 1.95, 0.033333333333333, 0.3125
34752, 1.9291666666667, 0.033333333333333, 0.33333333333333
34753, 1.95, 0.016666666666667, 0.33333333333333
34754, 1.9916666666667, 0.083333333333333, 0.33333333333333
34755, 1.9916666666667, 0.066666666666667, 0.3125
34756, 1.9708333333333, 0.066666666666667, 0.33333333333333
34757, 1.9916666666667, 0.05, 0.33333333333333
34758, 1.9916666666667, 0.033333333333333, 0.3125
34759, 1.9708333333333, 0.033333333333333, 0.33333333333333
34760, 1.9916666666667, 0.016666666666667, 0.33333333333333
34761, 2.0333333333333, 0.083333333333333, 0.33333333333333
34762, 2.0333333333333, 0.066666666666667, 0.3125
34763, 2.0125, 0.066666666666667, 0.33333333333333
34764, 2.0333333333333, 0.05, 0.33333333333333
34765, 2.0333333333333, 0.033333333333333, 0.3125
34766, 2.0125, 0.033333333333333, 0.33333333333333
34767, 2.0333333333333, 0.016666666666667, 0.33333333333333
34768, 2.075, 0.083333333333333, 0.33333333333333
34769, 2.075, 0.066666666666667, 0.3125
34770, 2.0541666666667, 0.066666666666667, 0.33333333333333
34771, 2.075, 0.05, 0.33333333333333
34772, 2.075, 0.033333333333333, 0.3125
34773, 2.0541666666667, 0.033333333333333, 0.33333333333333
34774, 2.075, 0.016666666666667, 0.33333333333333
34775, 2.1166666666667, 0.083333333333333, 0.33333333333333
34776, 2.1166666666667, 0.066666666666667, 0.3125
34777, 2.0958333333333, 0.066666666666667, 0.33333333333333
34778, 2.1166666666667, 0.05, 0.33333333333333
34779, 2.1166666666667, 0.033333333333333, 0.3125
34780, 2.0958333333333, 0.033333333333333, 0.33333333333333
34781, 2.1166666666667, 0.016666666666667, 0.33333333333333
34782, 2.1583333333333, 0.083333333333333, 0.33333333333333
34783, 2.1583333333333, 0.066666666666667, 0.3125
34784, 2.1375, 0.066666666666667, 0.33333333333333
34785, 2.1583333333333, 0.05, 0.33333333333333
34786, 2.1583333333333, 0.033333333333333, 0.3125
34787, 2.1375, 0.033333333333333, 0.33333333333333
34788, 2.1583333333333, 0.016666666666667, 0.33333333333333
34789, 2.1791666666667, 0.066666666666667, 0.33333333333333
34790, 2.1791666666667, 0.033333333333333, 0.33333333333333
34791, 1.2416666666667, 0.083333333333333, 0.375
34792, 1.2416666666667, 0.066666666666667, 0.35416666666667
34793, 1.2208333333333, 0.066666666666667, 0.375
34794, 1.2416666666667, 0.05, 0.375
34795, 1.2416666666667, 0.033333333333333, 0.35416666666667
34796, 1.2208333333333, 0.033333333333333, 0.375
34797, 1.2416666666667, 0.016666666666667, 0.375
34798, 1.2833333333333, 0.083333333333333, 0.375
34799, 1.2833333333333, 0.066666666666667, 0.35416666666667
34800, 1.2625, 0.066666666666667, 0.375
34801, 1.2833333333333, 0.05, 0.375
34802, 1.2833333333333, 0.033333333333333, 0.35416666666667
34803, 1.2625, 0.033333333333333, 0.375
34804, 1.2833333333333, 0.016666666666667, 0.375
34805, 1.325, 0.083333333333333, 0.375
34806, 1.325, 0.066666666666667, 0.35416666666667
34807, 1.3041666666667, 0.066666666666667, 0.375
34808, 1.325, 0.05, 0.375
34809, 1.325, 0.033333333333333, 0.35416666666667
34810, 1.3041666666667, 0.033333333333333, 0.375
34811, 1.325, 0.016666666666667, 0.375
34812, 1.3666666666667, 0.083333333333333, 0.375
34813, 1.3666666666667, 0.066666666666667, 0.35416666666667
34814, 1.3458333333333, 0.066666666666667, 0.375
34815, 1.3666666666667, 0.05, 0.375
34816, 1.3666666666667, 0.033333333333333, 0.35416666666667
34817, 1.3458333333333, 0.033333333333333, 0.375
34818, 1.3666666666667, 0.016666666666667, 0.375
34819, 1.4083333333333, 0.083333333333333, 0.375
34820, 1.4083333333333, 0.066666666666667, 0.35416666666667
34821, 1.3875, 0.066666666666667, 0.375
34822, 1.4083333333333, 0.05, 0.375
34823, 1.4083333333333, 0.033333333333333, 0.35416666666667
34824, 1.3875, 0.033333333333333, 0.375
34825, 1.4083333333333, 0.016666666666667, 0.375
34826, 1.45, 0.083333333333333, 0.375
34827, 1.45, 0.066666666666667, 0.35416666666667
34828, 1.4291666666667, 0.066666666666667, 0.375
34829, 1.45, 0.05, 0.375
34830, 1.45, 0.033333333333333, 0.35416666666667
34831, 1.4291666666667, 0.033333333333333, 0.375
34832, 1.45, 0.016666666666667, 0.375
34833, 1.4916666666667, 0.083333333333333, 0.375
34834, 1.4916666666667, 0.066666666666667, 0.35416666666667
34835, 1.4708333333333, 0.066666666666667, 0.375
34836, 1.4916666666667, 0.05, 0.375
34837, 1.4916666666667, 0.033333333333333, 0.35416666666667
34838, 1.4708333333333, 0.033333333333333, 0.375
34839, 1.4916666666667, 0.016666666666667, 0.375
34840, 1.5333333333333, 0.083333333333333, 0.375
34841, 1.5333333333333, 0.066666666666667, 0.35416666666667
34842, 1.5125, 0.066666666666667, 0.375
34843, 1.5333333333333, 0.05, 0.375
34844, 1.5333333333333, 0.033333333333333, 0.35416666666667
34845, 1.5125, 0.033333333333333, 0.375
34846, 1.5333333333333, 0.016666666666667, 0.375
34847, 1.575, 0.083333333333333, 0.375
34848, 1.575, 0.066666666666667, 0.35416666666667
34849, 1.5541666666667, 0.066666666666667, 0.375
34850, 1.575, 0.05, 0.375
34851, 1.575, 0.033333333333333, 0.35416666666667
34852, 1.5541666666667, 0.033333333333333, 0.375
34853, 1.575, 0.016666666666667, 0.375
34854, 1.6166666666667, 0.083333333333333, 0.375
34855, 1.6166666666667, 0.066666666666667, 0.35416666666667
34856, 1.5958333333333, 0.066666666666667, 0.375
34857, 1.6166666666667, 0.05, 0.375
34858, 1.6166666666667, 0.033333333333333, 0.35416666666667
34859, 1.5958333333333, 0.033333333333333, 0.375
34860, 1.6166666666667, 0.016666666666667, 0.375
34861, 1.6583333333333, 0.083333333333333, 0.375
34862, 1.6583333333333, 0.066666666666667, 0.35416666666667
34863, 1.6375, 0.066666666666667, 0.375
34864, 1.6583333333333, 0.05, 0.375
34865, 1.6583333333333, 0.033333333333333, 0.35416666666667
34866, 1.6375, 0.033333333333333, 0.375
34867, 1.6583333333333, 0.016666666666667, 0.375
34868, 1.7, 0.083333333333333, 0.375
34869, 1.7, 0.066666666666667, 0.35416666666667
34870, 1.6791666666667, 0.066666666666667, 0.375
34871, 1.7, 0.05, 0.375
34872, 1.7, 0.033333333333333, 0.35416666666667
34873, 1.6791666666667, 0.033333333333333, 0.375
34874, 1.7, 0.016666666666667, 0.375
34875, 1.7416666666667, 0.083333333333333, 0.375
34876, 1.7416666666667, 0.066666666666667, 0.35416666666667
34877, 1.7208333333333, 0.066666666666667, 0.375
34878, 1.7416666666667, 0.05, 0.375
34879, 1.7416666666667, 0.033333333333333, 0.35416666666667
34880, 1.7208333333333, 0.033333333333333, 0.375
34881, 1.7416666666667, 0.016666666666667, 0.375
34882, 1.7833333333333, 0.083333333333333, 0.375
34883, 1.7833333333333, 0.066666666666667, 0.35416666666667
34884, 1.7625, 0.066666666666667, 0.375
34885, 1.7833333333333, 0.05, 0.375
34886, 1.7833333333333, 0.033333333333333, 0.35416666666667
34887, 1.7625, 0.033333333333333, 0.375
34888, 1.7833333333333, 0.016666666666667, 0.375
34889, 1.825, 0.083333333333333, 0.375
34890, 1.825, 0.066666666666667, 0.35416666666667
34891, 1.8041666666667, 0.066666666666667, 0.375
34892, 1.825, 0.05, 0.375
34893, 1.825, 0.033333333333333, 0.35416666666667
34894, 1.8041666666667, 0.033333333333333, 0.375
34895, 1.825, 0.016666666666667, 0.375
34896, 1.8666666666667, 0.083333333333333, 0.375
34897, 1.8666666666667, 0.066666666666667, 0.35416666666667
34898, 1.8458333333333, 0.066666666666667, 0.375
34899, 1.8666666666667, 0.05, 0.375
34900, 1.8666666666667, 0.033333333333333, 0.35416666666667
34901, 1.8458333333333, 0.033333333333333, 0.375
34902, 1.8666666666667, 0.016666666666667, 0.375
34903, 1.9083333333333, 0.083333333333333, 0.375
34904, 1.9083333333333, 0.066666666666667, 0.35416666666667
34905, 1.8875, 0.066666666666667, 0.375
34906, 1.9083333333333, 0.05, 0.375
34907, 1.9083333333333, 0.033333333333333, 0.35416666666667
34908, 1.8875, 0.033333333333333, 0.375
34909, 1.9083333333333, 0.016666666666667, 0.375
34910, 1.95, 0.083333333333333, 0.375
34911, 1.95, 0.066666666666667, 0.35416666666667
34912, 1.9291666666667, 0.066666666666667, 0.375
34913, 1.95, 0.05, 0.375
34914, 1.95, 0.033333333333333, 0.35416666666667
34915, 1.9291666666667, 0.033333333333333, 0.375
34916, 1.95, 0.016666666666667, 0.375
34917, 1.9916666666667, 0.083333333333333, 0.375
34918, 1.9916666666667, 0.066666666666667, 0.35416666666667
34919, 1.9708333333333, 0.066666666666667, 0.375
34920, 1.9916666666667, 0.05, 0.375
34921, 1.9916666666667, 0.033333333333333, 0.35416666666667
34922, 1.9708333333333, 0.033333333333333, 0.375
34923, 1.9916666666667, 0.016666666666667, 0.375
34924, 2.0333333333333, 0.083333333333333, 0.375
34925, 2.0333333333333, 0.066666666666667, 0.35416666666667
34926, 2.0125, 0.066666666666667, 0.375
34927, 2.0333333333333, 0.05, 0.375
34928, 2.0333333333333, 0.033333333333333, 0.35416666666667
34929, 2.0125, 0.033333333333333, 0.375
34930, 2.0333333333333, 0.016666666666667, 0.375
34931, 2.075, 0.083333333333333, 0.375
34932, 2.075, 0.066666666666667, 0.35416666666667
34933, 2.0541666666667, 0.066666666666667, 0.375
34934, 2.075, 0.05, 0.375
34935, 2.075, 0.033333333333333, 0.35416666666667
34936, 2.0541666666667, 0.033333333333333, 0.375
34937, 2.075, 0.016666666666667, 0.375
34938, 2.1166666666667, 0.083333333333333, 0.375
34939, 2.1166666666667, 0.066666666666667, 0.35416666666667
34940, 2.0958333333333, 0.066666666666667, 0.375
34941, 2.1166666666667, 0.05, 0.375
34942, 2.1166666666667, 0.033333333333333, 0.35416666666667
34943, 2.0958333333333, 0.033333333333333, 0.375
34944, 2.1166666666667, 0.016666666666667, 0.375
34945, 2.1583333333333, 0.083333333333333, 0.375
34946, 2.1583333333333, 0.066666666666667, 0.35416666666667
34947, 2.1375, 0.066666666666667, 0.375
34948, 2.1583333333333, 0.05, 0.375
34949, 2.1583333333333, 0.033333333333333, 0.35416666666667
34950, 2.1375, 0.033333333333333, 0.375
34951, 2.1583333333333, 0.016666666666667, 0.375
34952, 2.1791666666667, 0.066666666666667, 0.375
34953, 2.1791666666667, 0.033333333333333, 0.375
34954, 1.2416666666667, 0.083333333333333, 0.41666666666667
34955, 1.2416666666667, 0.066666666666667, 0.39583333333333
34956, 1.2208333333333, 0.066666666666667, 0.41666666666667
34957, 1.2416666666667, 0.05, 0.41666666666667
34958, 1.2416666666667, 0.033333333333333, 0.39583333333333
34959, 1.2208333333333, 0.033333333333333, 0.41666666666667
34960, 1.2416666666667, 0.016666666666667, 0.41666666666667
34961, 1.2833333333333, 0.083333333333333, 0.41666666666667
34962, 1.2833333333333, 0.066666666666667, 0.39583333333333
34963, 1.2625, 0.066666666666667, 0.41666666666667
34964, 1.2833333333333, 0.05, 0.41666666666667
34965, 1.2833333333333, 0.033333333333333, 0.39583333333333
34966, 1.2625, 0.033333333333333, 0.41666666666667
34967, 1.2833333333333, 0.016666666666667, 0.41666666666667
34968, 1.325, 0.083333333333333, 0.41666666666667
34969, 1.325, 0.066666666666667, 0.39583333333333
34970, 1.3041666666667, 0.066666666666667, 0.41666666666667
34971, 1.325, 0.05, 0.41666666666667
34972, 1.325, 0.033333333333333, 0.39583333333333
34973, 1.3041666666667, 0.033333333333333, 0.41666666666667
34974, 1.325, 0.016666666666667, 0.41666666666667
34975, 1.3666666666667, 0.083333333333333, 0.41666666666667
34976, 1.3666666666667, 0.066666666666667, 0.39583333333333
34977, 1.3458333333333, 0.066666666666667, 0.41666666666667
34978, 1.3666666666667, 0.05, 0.41666666666667
34979, 1.3666666666667, 0.033333333333333, 0.39583333333333
34980, 1.3458333333333, 0.033333333333333, 0.41666666666667
34981, 1.3666666666667, 0.016666666666667, 0.41666666666667
34982, 1.4083333333333, 0.083333333333333, 0.41666666666667
34983, 1.4083333333333, 0.066666666666667, 0.39583333333333
34984, 1.3875, 0.066666666666667, 0.41666666666667
34985, 1.4083333333333, 0.05, 0.41666666666667
34986, 1.4083333333333, 0.033333333333333, 0.39583333333333
34987, 1.3875, 0.033333333333333, 0.41666666666667
34988, 1.4083333333333, 0.016666666666667, 0.41666666666667
34989, 1.45, 0.083333333333333, 0.41666666666667
34990, 1.45, 0.066666666666667, 0.39583333333333
34991, 1.4291666666667, 0.066666666666667, 0.41666666666667
34992, 1.45, 0.05, 0.41666666666667
34993, 1.45, 0.033333333333333, 0.39583333333333
34994, 1.4291666666667, 0.033333333333333, 0.41666666666667
34995, 1.45, 0.016666666666667, 0.41666666666667
34996, 1.4916666666667, 0.083333333333333, 0.41666666666667
34997, 1.4916666666667, 0.066666666666667, 0.39583333333333
34998, 1.4708333333333, 0.066666666666667, 0.41666666666667
34999, 1.4916666666667, 0.05, 0.41666666666667
35000, 1.4916666666667, 0.033333333333333, 0.39583333333333
35001, 1.4708333333333, 0.033333333333333, 0.41666666666667
35002, 1.4916666666667, 0.016666666666667, 0.41666666666667
35003, 1.5333333333333, 0.083333333333333, 0.41666666666667
35004, 1.5333333333333, 0.066666666666667, 0.39583333333333
35005, 1.5125, 0.066666666666667, 0.41666666666667
35006, 1.5333333333333, 0.05, 0.41666666666667
35007, 1.5333333333333, 0.033333333333333, 0.39583333333333
35008, 1.5125, 0.033333333333333, 0.41666666666667
35009, 1.5333333333333, 0.016666666666667, 0.41666666666667
35010, 1.575, 0.083333333333333, 0.41666666666667
35011, 1.575, 0.066666666666667, 0.39583333333333
35012, 1.5541666666667, 0.066666666666667, 0.41666666666667
35013, 1.575, 0.05, 0.41666666666667
35014, 1.575, 0.033333333333333, 0.39583333333333
35015, 1.5541666666667, 0.033333333333333, 0.41666666666667
35016, 1.575, 0.016666666666667, 0.41666666666667
35017, 1.6166666666667, 0.083333333333333, 0.41666666666667
35018, 1.6166666666667, 0.066666666666667, 0.39583333333333
35019, 1.5958333333333, 0.066666666666667, 0.41666666666667
35020, 1.6166666666667, 0.05, 0.41666666666667
35021, 1.6166666666667, 0.033333333333333, 0.39583333333333
35022, 1.5958333333333, 0.033333333333333, 0.41666666666667
35023, 1.6166666666667, 0.016666666666667, 0.41666666666667
35024, 1.6583333333333, 0.083333333333333, 0.41666666666667
35025, 1.6583333333333, 0.066666666666667, 0.39583333333333
35026, 1.6375, 0.066666666666667, 0.41666666666667
35027, 1.6583333333333, 0.05, 0.41666666666667
35028, 1.6583333333333, 0.033333333333333, 0.39583333333333
35029, 1.6375, 0.033333333333333, 0.41666666666667
35030, 1.6583333333333, 0.016666666666667, 0.41666666666667
35031, 1.7, 0.083333333333333, 0.41666666666667
35032, 1.7, 0.066666666666667, 0.39583333333333
35033, 1.6791666666667, 0.066666666666667, 0.41666666666667
35034, 1.7, 0.05, 0.41666666666667
35035, 1.7, 0.033333333333333, 0.39583333333333
35036, 1.6791666666667, 0.033333333333333, 0.41666666666667
35037, 1.7, 0.016666666666667, 0.41666666666667
35038, 1.7416666666667, 0.083333333333333, 0.41666666666667
35039, 1.7416666666667, 0.066666666666667, 0.39583333333333
35040, 1.7208333333333, 0.066666666666667, 0.41666666666667
35041, 1.7416666666667, 0.05, 0.41666666666667
35042, 1.7416666666667, 0.033333333333333, 0.39583333333333
35043, 1.7208333333333, 0.033333333333333, 0.41666666666667
35044, 1.7416666666667, 0.016666666666667, 0.41666666666667
35045, 1.7833333333333, 0.083333333333333, 0.41666666666667
35046, 1.7833333333333, 0.066666666666667, 0.39583333333333
35047, 1.7625, 0.066666666666667, 0.41666666666667
35048, 1.7833333333333, 0.05, 0.41666666666667
35049, 1.7833333333333, 0.033333333333333, 0.39583333333333
35050, 1.7625, 0.033333333333333, 0.41666666666667
35051, 1.7833333333333, 0.016666666666667, 0.41666666666667
35052, 1.825, 0.083333333333333, 0.41666666666667
35053, 1.825, 0.066666666666667, 0.39583333333333
35054, 1.8041666666667, 0.066666666666667, 0.41666666666667
35055, 1.825, 0.05, 0.41666666666667
35056, 1.825, 0.033333333333333, 0.39583333333333
35057, 1.8041666666667, 0.033333333333333, 0.41666666666667
35058, 1.825, 0.016666666666667, 0.41666666666667
35059, 1.8666666666667, 0.083333333333333, 0.41666666666667
35060, 1.8666666666667, 0.066666666666667, 0.39583333333333
35061, 1.8458333333333, 0.066666666666667, 0.41666666666667
35062, 1.8666666666667, 0.05, 0.41666666666667
35063, 1.8666666666667, 0.033333333333333, 0.39583333333333
35064, 1.8458333333333, 0.033333333333333, 0.41666666666667
35065, 1.8666666666667, 0.016666666666667, 0.41666666666667
35066, 1.9083333333333, 0.083333333333333, 0.41666666666667
35067, 1.9083333333333, 0.066666666666667, 0.39583333333333
35068, 1.8875, 0.066666666666667, 0.41666666666667
35069, 1.9083333333333, 0.05, 0.41666666666667
35070, 1.9083333333333, 0.033333333333333, 0.39583333333333
35071, 1.8875, 0.033333333333333, 0.41666666666667
35072, 1.9083333333333, 0.016666666666667, 0.41666666666667
35073, 1.95, 0.083333333333333, 0.41666666666667
35074, 1.95, 0.066666666666667, 0.39583333333333
35075, 1.9291666666667, 0.066666666666667, 0.41666666666667
35076, 1.95, 0.05, 0.41666666666667
35077, 1.95, 0.033333333333333, 0.39583333333333
35078, 1.9291666666667, 0.033333333333333, 0.41666666666667
35079, 1.95, 0.016666666666667, 0.41666666666667
35080, 1.9916666666667, 0.083333333333333, 0.41666666666667
35081, 1.9916666666667, 0.066666666666667, 0.39583333333333
35082, 1.9708333333333, 0.066666666666667, 0.41666666666667
35083, 1.9916666666667, 0.05, 0.41666666666667
35084, 1.9916666666667, 0.033333333333333, 0.39583333333333
35085, 1.9708333333333, 0.033333333333333, 0.41666666666667
35086, 1.9916666666667, 0.016666666666667, 0.41666666666667
35087, 2.0333333333333, 0.083333333333333, 0.41666666666667
35088, 2.0333333333333, 0.066666666666667, 0.39583333333333
35089, 2.0125, 0.066666666666667, 0.41666666666667
35090, 2.0333333333333, 0.05, 0.41666666666667
35091, 2.0333333333333, 0.033333333333333, 0.39583333333333
35092, 2.0125, 0.033333333333333, 0.41666666666667
35093, 2.0333333333333, 0.016666666666667, 0.41666666666667
35094, 2.075, 0.083333333333333, 0.41666666666667
35095, 2.075, 0.066666666666667, 0.39583333333333
35096, 2.0541666666667, 0.066666666666667, 0.41666666666667
35097, 2.075, 0.05, 0.41666666666667
35098, 2.075, 0.033333333333333, 0.39583333333333
35099, 2.0541666666667, 0.033333333333333, 0.41666666666667
35100, 2.075, 0.016666666666667, 0.41666666666667
35101, 2.1166666666667, 0.083333333333333, 0.41666666666667
35102, 2.1166666666667, 0.066666666666667, 0.39583333333333
35103, 2.0958333333333, 0.066666666666667, 0.41666666666667
35104, 2.1166666666667, 0.05, 0.41666666666667
35105, 2.1166666666667, 0.033333333333333, 0.39583333333333
35106, 2.0958333333333, 0.033333333333333, 0.41666666666667
35107, 2.1166666666667, 0.016666666666667, 0.41666666666667
35108, 2.1583333333333, 0.083333333333333, 0.41666666666667
35109, 2.1583333333333, 0.066666666666667, 0.39583333333333
35110, 2.1375, 0.066666666666667, 0.41666666666667
35111, 2.1583333333333, 0.05, 0.41666666666667
35112, 2.1583333333333, 0.033333333333333, 0.39583333333333
35113, 2.1375, 0.033333333333333, 0.41666666666667
35114, 2.1583333333333, 0.016666666666667, 0.41666666666667
35115, 2.1791666666667, 0.066666666666667, 0.41666666666667
35116, 2.1791666666667, 0.033333333333333, 0.41666666666667
35117, 1.2416666666667, 0.083333333333333, 0.45833333333333
35118, 1.2416666666667, 0.066666666666667, 0.4375
35119, 1.2208333333333, 0.066666666666667, 0.45833333333333
35120, 1.2416666666667, 0.05, 0.45833333333333
35121, 1.2416666666667, 0.033333333333333, 0.4375
35122, 1.2208333333333, 0.033333333333333, 0.45833333333333
35123, 1.2416666666667, 0.016666666666667, 0.45833333333333
35124, 1.2833333333333, 0.083333333333333, 0.45833333333333
35125, 1.2833333333333, 0.066666666666667, 0.4375
35126, 1.2625, 0.066666666666667, 0.45833333333333
35127, 1.2833333333333, 0.05, 0.45833333333333
35128, 1.2833333333333, 0.033333333333333, 0.4375
35129, 1.2625, 0.033333333333333, 0.45833333333333
35130, 1.2833333333333, 0.016666666666667, 0.45833333333333
35131, 1.325, 0.083333333333333, 0.45833333333333
35132, 1.325, 0.066666666666667, 0.4375
35133, 1.3041666666667, 0.066666666666667, 0.45833333333333
35134, 1.325, 0.05, 0.45833333333333
35135, 1.325, 0.033333333333333, 0.4375
35136, 1.3041666666667, 0.033333333333333, 0.45833333333333
35137, 1.325, 0.016666666666667, 0.45833333333333
35138, 1.3666666666667, 0.083333333333333, 0.45833333333333
35139, 1.3666666666667, 0.066666666666667, 0.4375
35140, 1.3458333333333, 0.066666666666667, 0.45833333333333
35141, 1.3666666666667, 0.05, 0.45833333333333
35142, 1.3666666666667, 0.033333333333333, 0.4375
35143, 1.3458333333333, 0.033333333333333, 0.45833333333333
35144, 1.3666666666667, 0.016666666666667, 0.45833333333333
35145, 1.4083333333333, 0.083333333333333, 0.45833333333333
35146, 1.4083333333333, 0.066666666666667, 0.4375
35147, 1.3875, 0.066666666666667, 0.45833333333333
35148, 1.4083333333333, 0.05, 0.45833333333333
35149, 1.4083333333333, 0.033333333333333, 0.4375
35150, 1.3875, 0.033333333333333, 0.45833333333333
35151, 1.4083333333333, 0.016666666666667, 0.45833333333333
35152, 1.45, 0.083333333333333, 0.45833333333333
35153, 1.45, 0.066666666666667, 0.4375
35154, 1.4291666666667, 0.066666666666667, 0.45833333333333
35155, 1.45, 0.05, 0.45833333333333
35156, 1.45, 0.033333333333333, 0.4375
35157, 1.4291666666667, 0.033333333333333, 0.45833333333333
35158, 1.45, 0.016666666666667, 0.45833333333333
35159, 1.4916666666667, 0.083333333333333, 0.45833333333333
35160, 1.4916666666667, 0.066666666666667, 0.4375
35161, 1.4708333333333, 0.066666666666667, 0.45833333333333
35162, 1.4916666666667, 0.05, 0.45833333333333
35163, 1.4916666666667, 0.033333333333333, 0.4375
35164, 1.4708333333333, 0.033333333333333, 0.45833333333333
35165, 1.4916666666667, 0.016666666666667, 0.45833333333333
35166, 1.5333333333333, 0.083333333333333, 0.45833333333333
35167, 1.5333333333333, 0.066666666666667, 0.4375
35168, 1.5125, 0.066666666666667, 0.45833333333333
35169, 1.5333333333333, 0.05, 0.45833333333333
35170, 1.5333333333333, 0.033333333333333, 0.4375
35171, 1.5125, 0.033333333333333, 0.45833333333333
35172, 1.5333333333333, 0.016666666666667, 0.45833333333333
35173, 1.575, 0.083333333333333, 0.45833333333333
35174, 1.575, 0.066666666666667, 0.4375
35175, 1.5541666666667, 0.066666666666667, 0.45833333333333
35176, 1.575, 0.05, 0.45833333333333
35177, 1.575, 0.033333333333333, 0.4375
35178, 1.5541666666667, 0.033333333333333, 0.45833333333333
35179, 1.575, 0.016666666666667, 0.45833333333333
35180, 1.6166666666667, 0.083333333333333, 0.45833333333333
35181, 1.6166666666667, 0.066666666666667, 0.4375
35182, 1.5958333333333, 0.066666666666667, 0.45833333333333
35183, 1.6166666666667, 0.05, 0.45833333333333
35184, 1.6166666666667, 0.033333333333333, 0.4375
35185, 1.5958333333333, 0.033333333333333, 0.45833333333333
35186, 1.6166666666667, 0.016666666666667, 0.45833333333333
35187, 1.6583333333333, 0.083333333333333, 0.45833333333333
35188, 1.6583333333333, 0.066666666666667, 0.4375
35189, 1.6375, 0.066666666666667, 0.45833333333333
35190, 1.6583333333333, 0.05, 0.45833333333333
35191, 1.6583333333333, 0.033333333333333, 0.4375
35192, 1.6375, 0.033333333333333, 0.45833333333333
35193, 1.6583333333333, 0.016666666666667, 0.45833333333333
35194, 1.7, 0.083333333333333, 0.45833333333333
35195, 1.7, 0.066666666666667, 0.4375
35196, 1.6791666666667, 0.066666666666667, 0.45833333333333
35197, 1.7, 0.05, 0.45833333333333
35198, 1.7, 0.033333333333333, 0.4375
35199, 1.6791666666667, 0.033333333333333, 0.45833333333333
35200, 1.7, 0.016666666666667, 0.45833333333333
35201, 1.7416666666667, 0.083333333333333, 0.45833333333333
35202, 1.7416666666667, 0.066666666666667, 0.4375
35203, 1.7208333333333, 0.066666666666667, 0.45833333333333
35204, 1.7416666666667, 0.05, 0.45833333333333
35205, 1.7416666666667, 0.033333333333333, 0.4375
35206, 1.7208333333333, 0.033333333333333, 0.45833333333333
35207, 1.7416666666667, 0.016666666666667, 0.45833333333333
35208, 1.7833333333333, 0.083333333333333, 0.45833333333333
35209, 1.7833333333333, 0.066666666666667, 0.4375
35210, 1.7625, 0.066666666666667, 0.45833333333333
35211, 1.7833333333333, 0.05, 0.45833333333333
35212, 1.7833333333333, 0.033333333333333, 0.4375
35213, 1.7625, 0.033333333333333, 0.45833333333333
35214, 1.7833333333333, 0.016666666666667, 0.45833333333333
35215, 1.825, 0.083333333333333, 0.45833333333333
35216, 1.825, 0.066666666666667, 0.4375
35217, 1.8041666666667, 0.066666666666667, 0.45833333333333
35218, 1.825, 0.05, 0.45833333333333
35219, 1.825, 0.033333333333333, 0.4375
35220, 1.8041666666667, 0.033333333333333, 0.45833333333333
35221, 1.825, 0.016666666666667, 0.45833333333333
35222, 1.8666666666667, 0.083333333333333, 0.45833333333333
35223, 1.8666666666667, 0.066666666666667, 0.4375
35224, 1.8458333333333, 0.066666666666667, 0.45833333333333
35225, 1.8666666666667, 0.05, 0.45833333333333
35226, 1.8666666666667, 0.033333333333333, 0.4375
35227, 1.8458333333333, 0.033333333333333, 0.45833333333333
35228, 1.8666666666667, 0.016666666666667, 0.45833333333333
35229, 1.9083333333333, 0.083333333333333, 0.45833333333333
35230, 1.9083333333333, 0.066666666666667, 0.4375
35231, 1.8875, 0.066666666666667, 0.45833333333333
35232, 1.9083333333333, 0.05, 0.45833333333333
35233, 1.9083333333333, 0.033333333333333, 0.4375
35234, 1.8875, 0.033333333333333, 0.45833333333333
35235, 1.9083333333333, 0.016666666666667, 0.45833333333333
35236, 1.95, 0.083333333333333, 0.45833333333333
35237, 1.95, 0.066666666666667, 0.4375
35238, 1.9291666666667, 0.066666666666667, 0.45833333333333
35239, 1.95, 0.05, 0.45833333333333
35240, 1.95, 0.033333333333333, 0.4375
35241, 1.9291666666667, 0.033333333333333, 0.45833333333333
35242, 1.95, 0.016666666666667, 0.45833333333333
35243, 1.9916666666667, 0.083333333333333, 0.45833333333333
35244, 1.9916666666667, 0.066666666666667, 0.4375
35245, 1.9708333333333, 0.066666666666667, 0.45833333333333
35246, 1.9916666666667, 0.05, 0.45833333333333
35247, 1.9916666666667, 0.033333333333333, 0.4375
35248, 1.9708333333333, 0.033333333333333, 0.45833333333333
35249, 1.9916666666667, 0.016666666666667, 0.45833333333333
35250, 2.0333333333333, 0.083333333333333, 0.45833333333333
35251, 2.0333333333333, 0.066666666666667, 0.4375
35252, 2.0125, 0.066666666666667, 0.45833333333333
35253, 2.0333333333333, 0.05, 0.45833333333333
35254, 2.0333333333333, 0.033333333333333, 0.4375
35255, 2.0125, 0.033333333333333, 0.45833333333333
35256, 2.0333333333333, 0.016666666666667, 0.45833333333333
35257, 2.075, 0.083333333333333, 0.45833333333333
35258, 2.075, 0.066666666666667, 0.4375
35259, 2.0541666666667, 0.066666666666667, 0.45833333333333
35260, 2.075, 0.05, 0.45833333333333
35261, 2.075, 0.033333333333333, 0.4375
35262, 2.0541666666667, 0.033333333333333, 0.45833333333333
35263, 2.075, 0.016666666666667, 0.45833333333333
35264, 2.1166666666667, 0.083333333333333, 0.45833333333333
35265, 2.1166666666667, 0.066666666666667, 0.4375
35266, 2.0958333333333, 0.066666666666667, 0.45833333333333
35267, 2.1166666666667, 0.05, 0.45833333333333
35268, 2.1166666666667, 0.033333333333333, 0.4375
35269, 2.0958333333333, 0.033333333333333, 0.45833333333333
35270, 2.1166666666667, 0.016666666666667, 0.45833333333333
35271, 2.1583333333333, 0.083333333333333, 0.45833333333333
35272, 2.1583333333333, 0.066666666666667, 0.4375
35273, 2.1375, 0.066666666666667, 0.45833333333333
35274, 2.1583333333333, 0.05, 0.45833333333333
35275, 2.1583333333333, 0.033333333333333, 0.4375
35276, 2.1375, 0.033333333333333, 0.45833333333333
35277, 2.1583333333333, 0.016666666666667, 0.45833333333333
35278, 2.1791666666667, 0.066666666666667, 0.45833333333333
35279, 2.1791666666667, 0.033333333333333, 0.45833333333333
35280, 1.2416666666667, 0.066666666666667, 0.47916666666667
35281, 1.2416666666667, 0.033333333333333, 0.47916666666667
35282, 1.2833333333333, 0.066666666666667, 0.47916666666667
35283, 1.2833333333333, 0.033333333333333, 0.47916666666667
35284, 1.325, 0.066666666666667, 0.47916666666667
35285, 1.325, 0.033333333333333, 0.47916666666667
35286, 1.3666666666667, 0.066666666666667, 0.47916666666667
35287, 1.3666666666667, 0.033333333333333, 0.47916666666667
35288, 1.4083333333333, 0.066666666666667, 0.47916666666667
35289, 1.4083333333333, 0.033333333333333, 0.47916666666667
35290, 1.45, 0.066666666666667, 0.47916666666667
35291, 1.45, 0.033333333333333, 0.47916666666667
35292, 1.4916666666667, 0.066666666666667, 0.47916666666667
35293, 1.4916666666667, 0.033333333333333, 0.47916666666667
35294, 1.5333333333333, 0.066666666666667, 0.47916666666667
35295, 1.5333333333333, 0.033333333333333, 0.47916666666667
35296, 1.575, 0.066666666666667, 0.47916666666667
35297, 1.575, 0.033333333333333, 0.47916666666667
35298, 1.6166666666667, 0.066666666666667, 0.47916666666667
35299, 1.6166666666667, 0.033333333333333, 0.47916666666667
35300, 1.6583333333333, 0.066666666666667, 0.47916666666667
35301, 1.6583333333333, 0.033333333333333, 0.47916666666667
35302, 1.7, 0.066666666666667, 0.47916666666667
35303, 1.7, 0.033333333333333, 0.47916666666667
35304, 1.7416666666667, 0.066666666666667, 0.47916666666667
35305, 1.7416666666667, 0.033333333333333, 0.47916666666667
35306, 1.7833333333333, 0.066666666666667, 0.47916666666667
35307, 1.7833333333333, 0.033333333333333, 0.47916666666667
35308, 1.825, 0.066666666666667, 0.47916666666667
35309, 1.825, 0.033333333333333, 0.47916666666667
35310, 1.8666666666667, 0.066666666666667, 0.47916666666667
35311, 1.8666666666667, 0.033333333333333, 0.47916666666667
35312, 1.9083333333333, 0.066666666666667, 0.47916666666667
35313, 1.9083333333333, 0.033333333333333, 0.47916666666667
35314, 1.95, 0.066666666666667, 0.47916666666667
35315, 1.95, 0.033333333333333, 0.47916666666667
35316, 1.9916666666667, 0.066666666666667, 0.47916666666667
35317, 1.9916666666667, 0.033333333333333, 0.47916666666667
35318, 2.0333333333333, 0.066666666666667, 0.47916666666667
35319, 2.0333333333333, 0.033333333333333, 0.47916666666667
35320, 2.075, 0.066666666666667, 0.47916666666667
35321, 2.075, 0.033333333333333, 0.47916666666667
35322, 2.1166666666667, 0.066666666666667, 0.47916666666667
35323, 2.1166666666667, 0.033333333333333, 0.47916666666667
35324, 2.1583333333333, 0.066666666666667, 0.47916666666667
35325, 2.1583333333333, 0.033333333333333, 0.47916666666667
35326, 2.25, 0.1, 0
35327, 2.25, 0.1, 0.041666666666667
35328, 2.25, 0.066666666666667, 0.041666666666667
35329, 2.25, 0.066666666666667, 0
35330, 2.25, 0.033333333333333, 0.041666666666667
35331, 2.25, 0.033333333333333, 0
35332, 2.25, 0.1, 0.083333333333333
35333, 2.25, 0.066666666666667, 0.083333333333333
35334, 2.25, 0.033333333333333, 0.083333333333333
35335, 2.25, 0.1, 0.125
35336, 2.25, 0.066666666666667, 0.125
35337, 2.25, 0.033333333333333, 0.125
35338, 2.25, 0.1, 0.16666666666667
35339, 2.25, 0.066666666666667, 0.16666666666667
35340, 2.25, 0.033333333333333, 0.16666666666667
35341, 2.25, 0.1, 0.20833333333333
35342, 2.25, 0.066666666666667, 0.20833333333333
35343, 2.25, 0.033333333333333, 0.20833333333333
35344, 2.25, 0.1, 0.25
35345, 2.25, 0.066666666666667, 0.25
35346, 2.25, 0.033333333333333, 0.25
35347, 2.25, 0.1, 0.29166666666667
35348, 2.25, 0.066666666666667, 0.29166666666667
35349, 2.25, 0.033333333333333, 0.29166666666667
35350, 2.25, 0.1, 0.33333333333333
35351, 2.25, 0.066666666666667, 0.33333333333333
35352, 2.25, 0.033333333333333, 0.33333333333333
35353, 2.25, 0.1, 0.375
35354, 2.25, 0.066666666666667, 0.375
35355, 2.25, 0.033333333333333, 0.375
35356, 2.25, 0.1, 0.41666666666667
35357, 2.25, 0.066666666666667, 0.41666666666667
35358, 2.25, 0.033333333333333, 0.41666666666667
35359, 2.25, 0.1, 0.45833333333333
35360, 2.25, 0.066666666666667, 0.45833333333333
35361, 2.25, 0.033333333333333, 0.45833333333333
35362, -0.05, 0.033333333333333, 0.041666666666667
35363, -0.05, 0.033333333333333, 0
35364, -0.05, 0.066666666666667, 0.041666666666667
35365, -0.05, 0.066666666666667, 0
35366, -0.05, 0.1, 0.041666666666667
35367, -0.05, 0.1, 0
35368, -0.05, 0.033333333333333, 0.083333333333333
35369, -0.05, 0.066666666666667, 0.083333333333333
35370, -0.05, 0.1, 0.083333333333333
35371, -0.05, 0.033333333333333, 0.125
35372, -0.05, 0.066666666666667, 0.125
35373, -0.05, 0.1, 0.125
35374, -0.05, 0.033333333333333, 0.16666666666667
35375, -0.05, 0.066666666666667, 0.16666666666667
35376, -0.05, 0.1, 0.16666666666667
35377, -0.05, 0.033333333333333, 0.20833333333333
35378, -0.05, 0.066666666666667, 0.20833333333333
35379, -0.05, 0.1, 0.20833333333333
35380, -0.05, 0.033333333333333, 0.25
35381, -0.05, 0.066666666666667, 0.25
35382, -0.05, 0.1, 0.25
35383, -0.05, 0.033333333333333, 0.29166666666667
35384, -0.05, 0.066666666666667, 0.29166666666667
35385, -0.05, 0.1, 0.29166666666667
35386, -0.05, 0.033333333333333, 0.33333333333333
35387, -0.05, 0.066666666666667, 0.33333333333333
35388, -0.05, 0.1, 0.33333333333333
35389, -0.05, 0.033333333333333, 0.375
35390, -0.05, 0.066666666666667, 0.375
35391, -0.05, 0.1, 0.375
35392, -0.05, 0.033333333333333, 0.41666666666667
35393, -0.05, 0.066666666666667, 0.41666666666667
35394, -0.05, 0.1, 0.41666666666667
35395, -0.05, 0.033333333333333, 0.45833333333333
35396, -0.05, 0.066666666666667, 0.45833333333333
35397, -0.05, 0.1, 0.45833333333333
35398, 0.041666666666667, 0.2, -0.05
35399, 0.041666666666667, 0.25, -0.05
35400, 0.041666666666667, 0.3, -0.05
35401, 0.041666666666667, 0.35, -0.05
35402, 0.041666666666667, 0.4, -0.05
35403, 0.041666666666667, 0.45, -0.05
35404, 0.041666666666667, 0.5, -0.05
35405, 0.041666666666667, 0.55, -0.05
35406, 0.041666666666667, 0.6, -0.05
35407, 0.041666666666667, 0.65, -0.05
35408, 0.041666666666667, 0.7, -0.05
35409, 0.041666666666667, 0.75, -0.05
35410, 0.041666666666667, 0.8, -0.05
35411, 0.041666666666667, 0.85, -0.05
35412, 0.041666666666667, 0.9, -0.05
35413, 0.041666666666667, 0.95, -0.05
35414, 0.041666666666667, 1, -0.05
35415, 0.041666666666667, 1.05, -0.05
35416, 0.041666666666667, 1.1, -0.05
35417, 0.041666666666667, 1.15, -0.05
35418, 0.041666666666667, 1.2, -0.05
35419, 0.041666666666667, 1.25, -0.05
35420, 0.041666666666667, 1.3, -0.05
35421, 0.083333333333333, 0.2, -0.05
35422, 0.083333333333333, 0.25, -0.05
35423, 0.083333333333333, 0.3, -0.05
35424, 0.083333333333333, 0.35, -0.05
35425, 0.083333333333333, 0.4, -0.05
35426, 0.083333333333333, 0.45, -0.05
35427, 0.083333333333333, 0.5, -0.05
35428, 0.083333333333333, 0.55, -0.05
35429, 0.083333333333333, 0.6, -0.05
35430, 0.083333333333333, 0.65, -0.05
35431, 0.083333333333333, 0.7, -0.05
35432, 0.083333333333333, 0.75, -0.05
35433, 0.083333333333333, 0.8, -0.05
35434, 0.083333333333333, 0.85, -0.05
35435, 0.083333333333333, 0.9, -0.05
35436, 0.083333333333333, 0.95, -0.05
35437, 0.083333333333333, 1, -0.05
35438, 0.083333333333333, 1.05, -0.05
35439, 0.083333333333333, 1.1, -0.05
35440, 0.083333333333333, 1.15, -0.05
35441, 0.083333333333333, 1.2, -0.05
35442, 0.083333333333333, 1.25, -0.05
35443, 0.083333333333333, 1.3, -0.05
35444, 0.125, 0.2, -0.05
35445, 0.125, 0.25, -0.05
35446, 0.125, 0.3, -0.05
35447, 0.125, 0.35, -0.05
35448, 0.125, 0.4, -0.05
35449, 0.125, 0.45, -0.05
35450, 0.125, 0.5, -0.05
35451, 0.125, 0.55, -0.05
35452, 0.125, 0.6, -0.05
35453, 0.125, 0.65, -0.05
35454, 0.125, 0.7, -0.05
35455, 0.125, 0.75, -0.05
35456, 0.125, 0.8, -0.05
35457, 0.125, 0.85, -0.05
35458, 0.125, 0.9, -0.05
35459, 0.125, 0.95, -0.05
35460, 0.125, 1, -0.05
35461, 0.125, 1.05, -0.05
35462, 0.125, 1.1, -0.05
35463, 0.125, 1.15, -0.05
35464, 0.125, 1.2, -0.05
35465, 0.125, 1.25, -0.05
35466, 0.125, 1.3, -0.05
35467, 0.16666666666667, 0.2, -0.05
35468, 0.16666666666667, 0.25, -0.05
35469, 0.16666666666667, 0.3, -0.05
35470, 0.16666666666667, 0.35, -0.05
35471, 0.16666666666667, 0.4, -0.05
35472, 0.16666666666667, 0.45, -0.05
35473, 0.16666666666667, 0.5, -0.05
35474, 0.16666666666667, 0.55, -0.05
35475, 0.16666666666667, 0.6, -0.05
35476, 0.16666666666667, 0.65, -0.05
35477, 0.16666666666667, 0.7, -0.05
35478, 0.16666666666667, 0.75, -0.05
35479, 0.16666666666667, 0.8, -0.05
35480, 0.16666666666667, 0.85, -0.05
35481, 0.16666666666667, 0.9, -0.05
35482, 0.16666666666667, 0.95, -0.05
35483, 0.16666666666667, 1, -0.05
35484, 0.16666666666667, 1.05, -0.05
35485, 0.16666666666667, 1.1, -0.05
35486, 0.16666666666667, 1.15, -0.05
35487, 0.16666666666667, 1.2, -0.05
35488, 0.16666666666667, 1.25, -0.05
35489, 0.16666666666667, 1.3, -0.05
35490, 0.20833333333333, 0.2, -0.05
35491, 0.20833333333333, 0.25, -0.05
35492, 0.20833333333333, 0.3, -0.05
35493, 0.20833333333333, 0.35, -0.05
35494, 0.20833333333333, 0.4, -0.05
35495, 0.20833333333333, 0.45, -0.05
35496, 0.20833333333333, 0.5, -0.05
35497, 0.20833333333333, 0.55, -0.05
35498, 0.20833333333333, 0.6, -0.05
35499, 0.20833333333333, 0.65, -0.05
35500, 0.20833333333333, 0.7, -0.05
35501, 0.20833333333333, 0.75, -0.05
35502, 0.20833333333333, 0.8, -0.05
35503, 0.20833333333333, 0.85, -0.05
35504, 0.20833333333333, 0.9, -0.05
35505, 0.20833333333333, 0.95, -0.05
35506, 0.20833333333333, 1, -0.05
35507, 0.20833333333333, 1.05, -0.05
35508, 0.20833333333333, 1.1, -0.05
35509, 0.20833333333333, 1.15, -0.05
35510, 0.20833333333333, 1.2, -0.05
35511, 0.20833333333333, 1.25, -0.05
35512, 0.20833333333333, 1.3, -0.05
35513, 0.25, 0.2, -0.05
35514, 0.25, 0.25, -0.05
35515, 0.25, 0.3, -0.05
35516, 0.25, 0.35, -0.05
35517, 0.25, 0.4, -0.05
35518, 0.25, 0.45, -0.05
35519, 0.25, 0.5, -0.05
35520, 0.25, 0.55, -0.05
35521, 0.25, 0.6, -0.05
35522, 0.25, 0.65, -0.05
35523, 0.25, 0.7, -0.05
35524, 0.25, 0.75, -0.05
35525, 0.25, 0.8, -0.05
35526, 0.25, 0.85, -0.05
35527, 0.25, 0.9, -0.05
35528, 0.25, 0.95, -0.05
35529, 0.25, 1, -0.05
35530, 0.25, 1.05, -0.05
35531, 0.25, 1.1, -0.05
35532, 0.25, 1.15, -0.05
35533, 0.25, 1.2, -0.05
35534, 0.25, 1.25, -0.05
35535, 0.25, 1.3, -0.05
35536, 0.29166666666667, 0.2, -0.05
35537, 0.29166666666667, 0.25, -0.05
35538, 0.29166666666667, 0.3, -0.05
35539, 0.29166666666667, 0.35, -0.05
35540, 0.29166666666667, 0.4, -0.05
35541, 0.29166666666667, 0.45, -0.05
35542, 0.29166666666667, 0.5, -0.05
35543, 0.29166666666667, 0.55, -0.05
35544, 0.29166666666667, 0.6, -0.05
35545, 0.29166666666667, 0.65, -0.05
35546, 0.29166666666667, 0.7, -0.05
35547, 0.29166666666667, 0.75, -0.05
35548, 0.29166666666667, 0.8, -0.05
35549, 0.29166666666667, 0.85, -0.05
35550, 0.29166666666667, 0.9, -0.05
35551, 0.29166666666667, 0.95, -0.05
35552, 0.29166666666667, 1, -0.05
35553, 0.29166666666667, 1.05, -0.05
35554, 0.29166666666667, 1.1, -0.05
35555, 0.29166666666667, 1.15, -0.05
35556, 0.29166666666667, 1.2, -0.05
35557, 0.29166666666667, 1.25, -0.05
35558, 0.29166666666667, 1.3, -0.05
35559, 0.33333333333333, 0.2, -0.05
35560, 0.33333333333333, 0.25, -0.05
35561, 0.33333333333333, 0.3, -0.05
35562, 0.33333333333333, 0.35, -0.05
35563, 0.33333333333333, 0.4, -0.05
35564, 0.33333333333333, 0.45, -0.05
35565, 0.33333333333333, 0.5, -0.05
35566, 0.33333333333333, 0.55, -0.05
35567, 0.33333333333333, 0.6, -0.05
35568, 0.33333333333333, 0.65, -0.05
35569, 0.33333333333333, 0.7, -0.05
35570, 0.33333333333333, 0.75, -0.05
35571, 0.33333333333333, 0.8, -0.05
35572, 0.33333333333333, 0.85, -0.05
35573, 0.33333333333333, 0.9, -0.05
35574, 0.33333333333333, 0.95, -0.05
35575, 0.33333333333333, 1, -0.05
35576, 0.33333333333333, 1.05, -0.05
35577, 0.33333333333333, 1.1, -0.05
35578, 0.33333333333333, 1.15, -0.05
35579, 0.33333333333333, 1.2, -0.05
35580, 0.33333333333333, 1.25, -0.05
35581, 0.33333333333333, 1.3, -0.05
35582, 0.375, 0.2, -0.05
35583, 0.375, 0.25, -0.05
35584, 0.375, 0.3, -0.05
35585, 0.375, 0.35, -0.05
35586, 0.375, 0.4, -0.05
35587, 0.375, 0.45, -0.05
35588, 0.375, 0.5, -0.05
35589, 0.375, 0.55, -0.05
35590, 0.375, 0.6, -0.05
35591, 0.375, 0.65, -0.05
35592, 0.375, 0.7, -0.05
35593, 0.375, 0.75, -0.05
35594, 0.375, 0.8, -0.05
35595, 0.375, 0.85, -0.05
35596, 0.375, 0.9, -0.05
35597, 0.375, 0.95, -0.05
35598, 0.375, 1, -0.05
35599, 0.375, 1.05, -0.05
35600, 0.375, 1.1, -0.05
35601, 0.375, 1.15, -0.05
35602, 0.375, 1.2, -0.05
35603, 0.375, 1.25, -0.05
35604, 0.375, 1.3, -0.05
35605, 0.41666666666667, 0.2, -0.05
35606, 0.41666666666667, 0.25, -0.05
35607, 0.41666666666667, 0.3, -0.05
35608, 0.41666666666667, 0.35, -0.05
35609, 0.41666666666667, 0.4, -0.05
35610, 0.41666666666667, 0.45, -0.05
35611, 0.41666666666667, 0.5, -0.05
35612, 0.41666666666667, 0.55, -0.05
35613, 0.41666666666667, 0.6, -0.05
35614, 0.41666666666667, 0.65, -0.05
35615, 0.41666666666667, 0.7, -0.05
35616, 0.41666666666667, 0.75, -0.05
35617, 0.41666666666667, 0.8, -0.05
35618, 0.41666666666667, 0.85, -0.05
35619, 0.41666666666667, 0.9, -0.05
35620, 0.41666666666667, 0.95, -0.05
35621, 0.41666666666667, 1, -0.05
35622, 0.41666666666667, 1.05, -0.05
35623, 0.41666666666667, 1.1, -0.05
35624, 0.41666666666667, 1.15, -0.05
35625, 0.41666666666667, 1.2, -0.05
35626, 0.41666666666667, 1.25, -0.05
35627, 0.41666666666667, 1.3, -0.05
35628, 0.45833333333333, 0.2, -0.05
35629, 0.45833333333333, 0.25, -0.05
35630, 0.45833333333333, 0.3, -0.05
35631, 0.45833333333333, 0.35, -0.05
35632, 0.45833333333333, 0.4, -0.05
35633, 0.45833333333333, 0.45, -0.05
35634, 0.45833333333333, 0.5, -0.05
35635, 0.45833333333333, 0.55, -0.05
35636, 0.45833333333333, 0.6, -0.05
35637, 0.45833333333333, 0.65, -0.05
35638, 0.45833333333333, 0.7, -0.05
35639, 0.45833333333333, 0.75, -0.05
35640, 0.45833333333333, 0.8, -0.05
35641, 0.45833333333333, 0.85, -0.05
35642, 0.45833333333333, 0.9, -0.05
35643, 0.45833333333333, 0.95, -0.05
35644, 0.45833333333333, 1, -0.05
35645, 0.45833333333333, 1.05, -0.05
35646, 0.45833333333333, 1.1, -0.05
35647, 0.45833333333333, 1.15, -0.05
35648, 0.45833333333333, 1.2, -0.05
35649, 0.45833333333333, 1.25, -0.05
35650, 0.45833333333333, 1.3, -0.05
35651, 0.5, 0.2, -0.05
35652, 0.5, 0.25, -0.05
35653, 0.5, 0.3, -0.05
35654, 0.5, 0.35, -0.05
35655, 0.5, 0.4, -0.05
35656, 0.5, 0.45, -0.05
35657, 0.5, 0.5, -0.05
35658, 0.5, 0.55, -0.05
35659, 0.5, 0.6, -0.05
35660, 0.5, 0.65, -0.05
35661, 0.5, 0.7, -0.05
35662, 0.5, 0.75, -0.05
35663, 0.5, 0.8, -0.05
35664, 0.5, 0.85, -0.05
35665, 0.5, 0.9, -0.05
35666, 0.5, 0.95, -0.05
35667, 0.5, 1, -0.05
35668, 0.5, 1.05, -0.05
35669, 0.5, 1.1, -0.05
35670, 0.5, 1.15, -0.05
35671, 0.5, 1.2, -0.05
35672, 0.5, 1.25, -0.05
35673, 0.5, 1.3, -0.05
35674, 0.54166666666667, 0.2, -0.05
35675, 0.54166666666667, 0.25, -0.05
35676, 0.54166666666667, 0.3, -0.05
35677, 0.54166666666667, 0.35, -0.05
35678, 0.54166666666667, 0.4, -0.05
35679, 0.54166666666667, 0.45, -0.05
35680, 0.54166666666667, 0.5, -0.05
35681, 0.54166666666667, 0.55, -0.05
35682, 0.54166666666667, 0.6, -0.05
35683, 0.54166666666667, 0.65, -0.05
35684, 0.54166666666667, 0.7, -0.05
35685, 0.54166666666667, 0.75, -0.05
35686, 0.54166666666667, 0.8, -0.05
35687, 0.54166666666667, 0.85, -0.05
35688, 0.54166666666667, 0.9, -0.05
35689, 0.54166666666667, 0.95, -0.05
35690, 0.54166666666667, 1, -0.05
35691, 0.54166666666667, 1.05, -0.05
35692, 0.54166666666667, 1.1, -0.05
35693, 0.54166666666667, 1.15, -0.05
35694, 0.54166666666667, 1.2, -0.05
35695, 0.54166666666667, 1.25, -0.05
35696, 0.54166666666667, 1.3, -0.05
35697, 0.58333333333333, 0.2, -0.05
35698, 0.58333333333333, 0.25, -0.05
35699, 0.58333333333333, 0.3, -0.05
35700, 0.58333333333333, 0.35, -0.05
35701, 0.58333333333333, 0.4, -0.05
35702, 0.58333333333333, 0.45, -0.05
35703, 0.58333333333333, 0.5, -0.05
35704, 0.58333333333333, 0.55, -0.05
35705, 0.58333333333333, 0.6, -0.05
35706, 0.58333333333333, 0.65, -0.05
35707, 0.58333333333333, 0.7, -0.05
35708, 0.58333333333333, 0.75, -0.05
35709, 0.58333333333333, 0.8, -0.05
35710, 0.58333333333333, 0.85, -0.05
35711, 0.58333333333333, 0.9, -0.05
35712, 0.58333333333333, 0.95, -0.05
35713, 0.58333333333333, 1, -0.05
35714, 0.58333333333333, 1.05, -0.05
35715, 0.58333333333333, 1.1, -0.05
35716, 0.58333333333333, 1.15, -0.05
35717, 0.58333333333333, 1.2, -0.05
35718, 0.58333333333333, 1.25, -0.05
35719, 0.58333333333333, 1.3, -0.05
35720, 0.625, 0.2, -0.05
35721, 0.625, 0.25, -0.05
35722, 0.625, 0.3, -0.05
35723, 0.625, 0.35, -0.05
35724, 0.625, 0.4, -0.05
35725, 0.625, 0.45, -0.05
35726, 0.625, 0.5, -0.05
35727, 0.625, 0.55, -0.05
35728, 0.625, 0.6, -0.05
35729, 0.625, 0.65, -0.05
35730, 0.625, 0.7, -0.05
35731, 0.625, 0.75, -0.05
35732, 0.625, 0.8, -0.05
35733, 0.625, 0.85, -0.05
35734, 0.625, 0.9, -0.05
35735, 0.625, 0.95, -0.05
35736, 0.625, 1, -0.05
35737, 0.625, 1.05, -0.05
35738, 0.625, 1.1, -0.05
35739, 0.625, 1.15, -0.05
35740, 0.625, 1.2, -0.05
35741, 0.625, 1.25, -0.05
35742, 0.625, 1.3, -0.05
35743, 0.66666666666667, 0.2, -0.05
35744, 0.66666666666667, 0.25, -0.05
35745, 0.66666666666667, 0.3, -0.05
35746, 0.66666666666667, 0.35, -0.05
35747, 0.66666666666667, 0.4, -0.05
35748, 0.66666666666667, 0.45, -0.05
35749, 0.66666666666667, 0.5, -0.05
35750, 0.66666666666667, 0.55, -0.05
35751, 0.66666666666667, 0.6, -0.05
35752, 0.66666666666667, 0.65, -0.05
35753, 0.66666666666667, 0.7, -0.05
35754, 0.66666666666667, 0.75, -0.05
35755, 0.66666666666667, 0.8, -0.05
35756, 0.66666666666667, 0.85, -0.05
35757, 0.66666666666667, 0.9, -0.05
35758, 0.66666666666667, 0.95, -0.05
35759, 0.66666666666667, 1, -0.05
35760, 0.66666666666667, 1.05, -0.05
35761, 0.66666666666667, 1.1, -0.05
35762, 0.66666666666667, 1.15, -0.05
35763, 0.66666666666667, 1.2, -0.05
35764, 0.66666666666667, 1.25, -0.05
35765, 0.66666666666667, 1.3, -0.05
35766, 0.70833333333333, 0.2, -0.05
35767, 0.70833333333333, 0.25, -0.05
35768, 0.70833333333333, 0.3, -0.05
35769, 0.70833333333333, 0.35, -0.05
35770, 0.70833333333333, 0.4, -0.05
35771, 0.70833333333333, 0.45, -0.05
35772, 0.70833333333333, 0.5, -0.05
35773, 0.70833333333333, 0.55, -0.05
35774, 0.70833333333333, 0.6, -0.05
35775, 0.70833333333333, 0.65, -0.05
35776, 0.70833333333333, 0.7, -0.05
35777, 0.70833333333333, 0.75, -0.05
35778, 0.70833333333333, 0.8, -0.05
35779, 0.70833333333333, 0.85, -0.05
35780, 0.70833333333333, 0.9, -0.05
35781, 0.70833333333333, 0.95, -0.05
35782, 0.70833333333333, 1, -0.05
35783, 0.70833333333333, 1.05, -0.05
35784, 0.70833333333333, 1.1, -0.05
35785, 0.70833333333333, 1.15, -0.05
35786, 0.70833333333333, 1.2, -0.05
35787, 0.70833333333333, 1.25, -0.05
35788, 0.70833333333333, 1.3, -0.05
35789, 0.75, 0.2, -0.05
35790, 0.75, 0.25, -0.05
35791, 0.75, 0.3, -0.05
35792, 0.75, 0.35, -0.05
35793, 0.75, 0.4, -0.05
35794, 0.75, 0.45, -0.05
35795, 0.75, 0.5, -0.05
35796, 0.75, 0.55, -0.05
35797, 0.75, 0.6, -0.05
35798, 0.75, 0.65, -0.05
35799, 0.75, 0.7, -0.05
35800, 0.75, 0.75, -0.05
35801, 0.75, 0.8, -0.05
35802, 0.75, 0.85, -0.05
35803, 0.75, 0.9, -0.05
35804, 0.75, 0.95, -0.05
35805, 0.75, 1, -0.05
35806, 0.75, 1.05, -0.05
35807, 0.75, 1.1, -0.05
35808, 0.75, 1.15, -0.05
35809, 0.75, 1.2, -0.05
35810, 0.75, 1.25, -0.05
35811, 0.75, 1.3, -0.05
35812, 0.79166666666667, 0.2, -0.05
35813, 0.79166666666667, 0.25, -0.05
35814, 0.79166666666667, 0.3, -0.05
35815, 0.79166666666667, 0.35, -0.05
35816, 0.79166666666667, 0.4, -0.05
35817, 0.79166666666667, 0.45, -0.05
35818, 0.79166666666667, 0.5, -0.05
35819, 0.79166666666667, 0.55, -0.05
35820, 0.79166666666667, 0.6, -0.05
35821, 0.79166666666667, 0.65, -0.05
35822, 0.79166666666667, 0.7, -0.05
35823, 0.79166666666667, 0.75, -0.05
35824, 0.79166666666667, 0.8, -0.05
35825, 0.79166666666667, 0.85, -0.05
35826, 0.79166666666667, 0.9, -0.05
35827, 0.79166666666667, 0.95, -0.05
35828, 0.79166666666667, 1, -0.05
35829, 0.79166666666667, 1.05, -0.05
35830, 0.79166666666667, 1.1, -0.05
35831, 0.79166666666667, 1.15, -0.05
35832, 0.79166666666667, 1.2, -0.05
35833, 0.79166666666667, 1.25, -0.05
35834, 0.79166666666667, 1.3, -0.05
35835, 0.83333333333333, 0.2, -0.05
35836, 0.83333333333333, 0.25, -0.05
35837, 0.83333333333333, 0.3, -0.05
35838, 0.83333333333333, 0.35, -0.05
35839, 0.83333333333333, 0.4, -0.05
35840, 0.83333333333333, 0.45, -0.05
35841, 0.83333333333333, 0.5, -0.05
35842, 0.83333333333333, 0.55, -0.05
35843, 0.83333333333333, 0.6, -0.05
35844, 0.83333333333333, 0.65, -0.05
35845, 0.83333333333333, 0.7, -0.05
35846, 0.83333333333333, 0.75, -0.05
35847, 0.83333333333333, 0.8, -0.05
35848, 0.83333333333333, 0.85, -0.05
35849, 0.83333333333333, 0.9, -0.05
35850, 0.83333333333333, 0.95, -0.05
35851, 0.83333333333333, 1, -0.05
35852, 0.83333333333333, 1.05, -0.05
35853, 0.83333333333333, 1.1, -0.05
35854, 0.83333333333333, 1.15, -0.05
35855, 0.83333333333333, 1.2, -0.05
35856, 0.83333333333333, 1.25, -0.05
35857, 0.83333333333333, 1.3, -0.05
35858, 0.875, 0.2, -0.05
35859, 0.875, 0.25, -0.05
35860, 0.875, 0.3, -0.05
35861, 0.875, 0.35, -0.05
35862, 0.875, 0.4, -0.05
35863, 0.875, 0.45, -0.05
35864, 0.875, 0.5, -0.05
35865, 0.875, 0.55, -0.05
35866, 0.875, 0.6, -0.05
35867, 0.875, 0.65, -0.05
35868, 0.875, 0.7, -0.05
35869, 0.875, 0.75, -0.05
35870, 0.875, 0.8, -0.05
35871, 0.875, 0.85, -0.05
35872, 0.875, 0.9, -0.05
35873, 0.875, 0.95, -0.05
35874, 0.875, 1, -0.05
35875, 0.875, 1.05, -0.05
35876, 0.875, 1.1, -0.05
35877, 0.875, 1.15, -0.05
35878, 0.875, 1.2, -0.05
35879, 0.875, 1.25, -0.05
35880, 0.875, 1.3, -0.05
35881, 0.91666666666667, 0.2, -0.05
35882, 0.91666666666667, 0.25, -0.05
35883, 0.91666666666667, 0.3, -0.05
35884, 0.91666666666667, 0.35, -0.05
35885, 0.91666666666667, 0.4, -0.05
35886, 0.91666666666667, 0.45, -0.05
35887, 0.91666666666667, 0.5, -0.05
35888, 0.91666666666667, 0.55, -0.05
35889, 0.91666666666667, 0.6, -0.05
35890, 0.91666666666667, 0.65, -0.05
35891, 0.91666666666667, 0.7, -0.05
35892, 0.91666666666667, 0.75, -0.05
35893, 0.91666666666667, 0.8, -0.05
35894, 0.91666666666667, 0.85, -0.05
35895, 0.91666666666667, 0.9, -0.05
35896, 0.91666666666667, 0.95, -0.05
35897, 0.91666666666667, 1, -0.05
35898, 0.91666666666667, 1.05, -0.05
35899, 0.91666666666667, 1.1, -0.05
35900, 0.91666666666667, 1.15, -0.05
35901, 0.91666666666667, 1.2, -0.05
35902, 0.91666666666667, 1.25, -0.05
35903, 0.91666666666667, 1.3, -0.05
35904, 0.95833333333333, 0.2, -0.05
35905, 0.95833333333333, 0.25, -0.05
35906, 0.95833333333333, 0.3, -0.05
35907, 0.95833333333333, 0.35, -0.05
35908, 0.95833333333333, 0.4, -0.05
35909, 0.95833333333333, 0.45, -0.05
35910, 0.95833333333333, 0.5, -0.05
35911, 0.95833333333333, 0.55, -0.05
35912, 0.95833333333333, 0.6, -0.05
35913, 0.95833333333333, 0.65, -0.05
35914, 0.95833333333333, 0.7, -0.05
35915, 0.95833333333333, 0.75, -0.05
35916, 0.95833333333333, 0.8, -0.05
35917, 0.95833333333333, 0.85, -0.05
35918, 0.95833333333333, 0.9, -0.05
35919, 0.95833333333333, 0.95, -0.05
35920, 0.95833333333333, 1, -0.05
35921, 0.95833333333333, 1.05, -0.05
35922, 0.95833333333333, 1.1, -0.05
35923, 0.95833333333333, 1.15, -0.05
35924, 0.95833333333333, 1.2, -0.05
35925, 0.95833333333333, 1.25, -0.05
35926, 0.95833333333333, 1.3, -0.05
35927, 1.2416666666667, 1.3, -0.05
35928, 1.2416666666667, 1.25, -0.05
35929, 1.2416666666667, 1.2, -0.05
35930, 1.2416666666667, 1.15, -0.05
35931, 1.2416666666667, 1.1, -0.05
35932, 1.2416666666667, 1.05, -0.05
35933, 1.2416666666667, 1, -0.05
35934, 1.2416666666667, 0.95, -0.05
35935, 1.2416666666667, 0.9, -0.05
35936, 1.2416666666667, 0.85, -0.05
35937, 1.2416666666667, 0.8, -0.05
35938, 1.2416666666667, 0.75, -0.05
35939, 1.2416666666667, 0.7, -0.05
35940, 1.2416666666667, 0.65, -0.05
35941, 1.2416666666667, 0.6, -0.05
35942, 1.2416666666667, 0.55, -0.05
35943, 1.2416666666667, 0.5, -0.05
35944, 1.2416666666667, 0.45, -0.05
35945, 1.2416666666667, 0.4, -0.05
35946, 1.2416666666667, 0.35, -0.05
35947, 1.2416666666667, 0.3, -0.05
35948, 1.2416666666667, 0.25, -0.05
35949, 1.2416666666667, 0.2, -0.05
35950, 1.2833333333333, 1.3, -0.05
35951, 1.2833333333333, 1.25, -0.05
35952, 1.2833333333333, 1.2, -0.05
35953, 1.2833333333333, 1.15, -0.05
35954, 1.2833333333333, 1.1, -0.05
35955, 1.2833333333333, 1.05, -0.05
35956, 1.2833333333333, 1, -0.05
35957, 1.2833333333333, 0.95, -0.05
35958, 1.2833333333333, 0.9, -0.05
35959, 1.2833333333333, 0.85, -0.05
35960, 1.2833333333333, 0.8, -0.05
35961, 1.2833333333333, 0.75, -0.05
35962, 1.2833333333333, 0.7, -0.05
35963, 1.2833333333333, 0.65, -0.05
35964, 1.2833333333333, 0.6, -0.05
35965, 1.2833333333333, 0.55, -0.05
35966, 1.2833333333333, 0.5, -0.05
35967, 1.2833333333333, 0.45, -0.05
35968, 1.2833333333333, 0.4, -0.05
35969, 1.2833333333333, 0.35, -0.05
35970, 1.2833333333333, 0.3, -0.05
35971, 1.2833333333333, 0.25, -0.05
35972, 1.2833333333333, 0.2, -0.05
35973, 1.325, 1.3, -0.05
35974, 1.325, 1.25, -0.05
35975, 1.325, 1.2, -0.05
35976, 1.325, 1.15, -0.05
35977, 1.325, 1.1, -0.05
35978, 1.325, 1.05, -0.05
35979, 1.325, 1, -0.05
35980, 1.325, 0.95, -0.05
35981, 1.325, 0.9, -0.05
35982, 1.325, 0.85, -0.05
35983, 1.325, 0.8, -0.05
35984, 1.325, 0.75, -0.05
35985, 1.325, 0.7, -0.05
35986, 1.325, 0.65, -0.05
35987, 1.325, 0.6, -0.05
35988, 1.325, 0.55, -0.05
35989, 1.325, 0.5, -0.05
35990, 1.325, 0.45, -0.05
35991, 1.325, 0.4, -0.05
35992, 1.325, 0.35, -0.05
35993, 1.325, 0.3, -0.05
35994, 1.325, 0.25, -0.05
35995, 1.325, 0.2, -0.05
35996, 1.3666666666667, 1.3, -0.05
35997, 1.3666666666667, 1.25, -0.05
35998, 1.3666666666667, 1.2, -0.05
35999, 1.3666666666667, 1.15, -0.05
36000, 1.3666666666667, 1.1, -0.05
36001, 1.3666666666667, 1.05, -0.05
36002, 1.3666666666667, 1, -0.05
36003, 1.3666666666667, 0.95, -0.05
36004, 1.3666666666667, 0.9, -0.05
36005, 1.3666666666667, 0.85, -0.05
36006, 1.3666666666667, 0.8, -0.05
36007, 1.3666666666667, 0.75, -0.05
36008, 1.3666666666667, 0.7, -0.05
36009, 1.3666666666667, 0.65, -0.05
36010, 1.3666666666667, 0.6, -0.05
36011, 1.3666666666667, 0.55, -0.05
36012, 1.3666666666667, 0.5, -0.05
36013, 1.3666666666667, 0.45, -0.05
36014, 1.3666666666667, 0.4, -0.05
36015, 1.3666666666667, 0.35, -0.05
36016, 1.3666666666667, 0.3, -0.05
36017, 1.3666666666667, 0.25, -0.05
36018, 1.3666666666667, 0.2, -0.05
36019, 1.4083333333333, 1.3, -0.05
36020, 1.4083333333333, 1.25, -0.05
36021, 1.4083333333333, 1.2, -0.05
36022, 1.4083333333333, 1.15, -0.05
36023, 1.4083333333333, 1.1, -0.05
36024, 1.4083333333333, 1.05, -0.05
36025, 1.4083333333333, 1, -0.05
36026, 1.4083333333333, 0.95, -0.05
36027, 1.4083333333333, 0.9, -0.05
36028, 1.4083333333333, 0.85, -0.05
36029, 1.4083333333333, 0.8, -0.05
36030, 1.4083333333333, 0.75, -0.05
36031, 1.4083333333333, 0.7, -0.05
36032, 1.4083333333333, 0.65, -0.05
36033, 1.4083333333333, 0.6, -0.05
36034, 1.4083333333333, 0.55, -0.05
36035, 1.4083333333333, 0.5, -0.05
36036, 1.4083333333333, 0.45, -0.05
36037, 1.4083333333333, 0.4, -0.05
36038, 1.4083333333333, 0.35, -0.05
36039, 1.4083333333333, 0.3, -0.05
36040, 1.4083333333333, 0.25, -0.05
36041, 1.4083333333333, 0.2, -0.05
36042, 1.45, 1.3, -0.05
36043, 1.45, 1.25, -0.05
36044, 1.45, 1.2, -0.05
36045, 1.45, 1.15, -0.05
36046, 1.45, 1.1, -0.05
36047, 1.45, 1.05, -0.05
36048, 1.45, 1, -0.05
36049, 1.45, 0.95, -0.05
36050, 1.45, 0.9, -0.05
36051, 1.45, 0.85, -0.05
36052, 1.45, 0.8, -0.05
36053, 1.45, 0.75, -0.05
36054, 1.45, 0.7, -0.05
36055, 1.45, 0.65, -0.05
36056, 1.45, 0.6, -0.05
36057, 1.45, 0.55, -0.05
36058, 1.45, 0.5, -0.05
36059, 1.45, 0.45, -0.05
36060, 1.45, 0.4, -0.05
36061, 1.45, 0.35, -0.05
36062, 1.45, 0.3, -0.05
36063, 1.45, 0.25, -0.05
36064, 1.45, 0.2, -0.05
36065, 1.4916666666667, 1.3, -0.05
36066, 1.4916666666667, 1.25, -0.05
36067, 1.4916666666667, 1.2, -0.05
36068, 1.4916666666667, 1.15, -0.05
36069, 1.4916666666667, 1.1, -0.05
36070, 1.4916666666667, 1.05, -0.05
36071, 1.4916666666667, 1, -0.05
36072, 1.4916666666667, 0.95, -0.05
36073, 1.4916666666667, 0.9, -0.05
36074, 1.4916666666667, 0.85, -0.05
36075, 1.4916666666667, 0.8, -0.05
36076, 1.4916666666667, 0.75, -0.05
36077, 1.4916666666667, 0.7, -0.05
36078, 1.4916666666667, 0.65, -0.05
36079, 1.4916666666667, 0.6, -0.05
36080, 1.4916666666667, 0.55, -0.05
36081, 1.4916666666667, 0.5, -0.05
36082, 1.4916666666667, 0.45, -0.05
36083, 1.4916666666667, 0.4, -0.05
36084, 1.4916666666667, 0.35, -0.05
36085, 1.4916666666667, 0.3, -0.05
36086, 1.4916666666667, 0.25, -0.05
36087, 1.4916666666667, 0.2, -0.05
36088, 1.5333333333333, 1.3, -0.05
36089, 1.5333333333333, 1.25, -0.05
36090, 1.5333333333333, 1.2, -0.05
36091, 1.5333333333333, 1.15, -0.05
36092, 1.5333333333333, 1.1, -0.05
36093, 1.5333333333333, 1.05, -0.05
36094, 1.5333333333333, 1, -0.05
36095, 1.5333333333333, 0.95, -0.05
36096, 1.5333333333333, 0.9, -0.05
36097, 1.5333333333333, 0.85, -0.05
36098, 1.5333333333333, 0.8, -0.05
36099, 1.5333333333333, 0.75, -0.05
36100, 1.5333333333333, 0.7, -0.05
36101, 1.5333333333333, 0.65, -0.05
36102, 1.5333333333333, 0.6, -0.05
36103, 1.5333333333333, 0.55, -0.05
36104, 1.5333333333333, 0.5, -0.05
36105, 1.5333333333333, 0.45, -0.05
36106, 1.5333333333333, 0.4, -0.05
36107, 1.5333333333333, 0.35, -0.05
36108, 1.5333333333333, 0.3, -0.05
36109, 1.5333333333333, 0.25, -0.05
36110, 1.5333333333333, 0.2, -0.05
36111, 1.575, 1.3, -0.05
36112, 1.575, 1.25, -0.05
36113, 1.575, 1.2, -0.05
36114, 1.575, 1.15, -0.05
36115, 1.575, 1.1, -0.05
36116, 1.575, 1.05, -0.05
36117, 1.575, 1, -0.05
36118, 1.575, 0.95, -0.05
36119, 1.575, 0.9, -0.05
36120, 1.575, 0.85, -0.05
36121, 1.575, 0.8, -0.05
36122, 1.575, 0.75, -0.05
36123, 1.575, 0.7, -0.05
36124, 1.575, 0.65, -0.05
36125, 1.575, 0.6, -0.05
36126, 1.575, 0.55, -0.05
36127, 1.575, 0.5, -0.05
36128, 1.575, 0.45, -0.05
36129, 1.575, 0.4, -0.05
36130, 1.575, 0.35, -0.05
36131, 1.575, 0.3, -0.05
36132, 1.575, 0.25, -0.05
36133, 1.575, 0.2, -0.05
36134, 1.6166666666667, 1.3, -0.05
36135, 1.6166666666667, 1.25, -0.05
36136, 1.6166666666667, 1.2, -0.05
36137, 1.6166666666667, 1.15, -0.05
36138, 1.6166666666667, 1.1, -0.05
36139, 1.6166666666667, 1.05, -0.05
36140, 1.6166666666667, 1, -0.05
36141, 1.6166666666667, 0.95, -0.05
36142, 1.6166666666667, 0.9, -0.05
36143, 1.6166666666667, 0.85, -0.05
36144, 1.6166666666667, 0.8, -0.05
36145, 1.6166666666667, 0.75, -0.05
36146, 1.6166666666667, 0.7, -0.05
36147, 1.6166666666667, 0.65, -0.05
36148, 1.6166666666667, 0.6, -0.05
36149, 1.6166666666667, 0.55, -0.05
36150, 1.6166666666667, 0.5, -0.05
36151, 1.6166666666667, 0.45, -0.05
36152, 1.6166666666667, 0.4, -0.05
36153, 1.6166666666667, 0.35, -0.05
36154, 1.6166666666667, 0.3, -0.05
36155, 1.6166666666667, 0.25, -0.05
36156, 1.6166666666667, 0.2, -0.05
36157, 1.6583333333333, 1.3, -0.05
36158, 1.6583333333333, 1.25, -0.05
36159, 1.6583333333333, 1.2, -0.05
36160, 1.6583333333333, 1.15, -0.05
36161, 1.6583333333333, 1.1, -0.05
36162, 1.6583333333333, 1.05, -0.05
36163, 1.6583333333333, 1, -0.05
36164, 1.6583333333333, 0.95, -0.05
36165, 1.6583333333333, 0.9, -0.05
36166, 1.6583333333333, 0.85, -0.05
36167, 1.6583333333333, 0.8, -0.05
36168, 1.6583333333333, 0.75, -0.05
36169, 1.6583333333333, 0.7, -0.05
36170, 1.6583333333333, 0.65, -0.05
36171, 1.6583333333333, 0.6, -0.05
36172, 1.6583333333333, 0.55, -0.05
36173, 1.6583333333333, 0.5, -0.05
36174, 1.6583333333333, 0.45, -0.05
36175, 1.6583333333333, 0.4, -0.05
36176, 1.6583333333333, 0.35, -0.05
36177, 1.6583333333333, 0.3, -0.05
36178, 1.6583333333333, 0.25, -0.05
36179, 1.6583333333333, 0.2, -0.05
36180, 1.7, 1.3, -0.05
36181, 1.7, 1.25, -0.05
36182, 1.7, 1.2, -0.05
36183, 1.7, 1.15, -0.05
36184, 1.7, 1.1, -0.05
36185, 1.7, 1.05, -0.05
36186, 1.7, 1, -0.05
36187, 1.7, 0.95, -0.05
36188, 1.7, 0.9, -0.05
36189, 1.7, 0.85, -0.05
36190, 1.7, 0.8, -0.05
36191, 1.7, 0.75, -0.05
36192, 1.7, 0.7, -0.05
36193, 1.7, 0.65, -0.05
36194, 1.7, 0.6, -0.05
36195, 1.7, 0.55, -0.05
36196, 1.7, 0.5, -0.05
36197, 1.7, 0.45, -0.05
36198, 1.7, 0.4, -0.05
36199, 1.7, 0.35, -0.05
36200, 1.7, 0.3, -0.05
36201, 1.7, 0.25, -0.05
36202, 1.7, 0.2, -0.05
36203, 1.7416666666667, 1.3, -0.05
36204, 1.7416666666667, 1.25, -0.05
36205, 1.7416666666667, 1.2, -0.05
36206, 1.7416666666667, 1.15, -0.05
36207, 1.7416666666667, 1.1, -0.05
36208, 1.7416666666667, 1.05, -0.05
36209, 1.7416666666667, 1, -0.05
36210, 1.7416666666667, 0.95, -0.05
36211, 1.7416666666667, 0.9, -0.05
36212, 1.7416666666667, 0.85, -0.05
36213, 1.7416666666667, 0.8, -0.05
36214, 1.7416666666667, 0.75, -0.05
36215, 1.7416666666667, 0.7, -0.05
36216, 1.7416666666667, 0.65, -0.05
36217, 1.7416666666667, 0.6, -0.05
36218, 1.7416666666667, 0.55, -0.05
36219, 1.7416666666667, 0.5, -0.05
36220, 1.7416666666667, 0.45, -0.05
36221, 1.7416666666667, 0.4, -0.05
36222, 1.7416666666667, 0.35, -0.05
36223, 1.7416666666667, 0.3, -0.05
36224, 1.7416666666667, 0.25, -0.05
36225, 1.7416666666667, 0.2, -0.05
36226, 1.7833333333333, 1.3, -0.05
36227, 1.7833333333333, 1.25, -0.05
36228, 1.7833333333333, 1.2, -0.05
36229, 1.7833333333333, 1.15, -0.05
36230, 1.7833333333333, 1.1, -0.05
36231, 1.7833333333333, 1.05, -0.05
36232, 1.7833333333333, 1, -0.05
36233, 1.7833333333333, 0.95, -0.05
36234, 1.7833333333333, 0.9, -0.05
36235, 1.7833333333333, 0.85, -0.05
36236, 1.7833333333333, 0.8, -0.05
36237, 1.7833333333333, 0.75, -0.05
36238, 1.7833333333333, 0.7, -0.05
36239, 1.7833333333333, 0.65, -0.05
36240, 1.7833333333333, 0.6, -0.05
36241, 1.7833333333333, 0.55, -0.05
36242, 1.7833333333333, 0.5, -0.05
36243, 1.7833333333333, 0.45, -0.05
36244, 1.7833333333333, 0.4, -0.05
36245, 1.7833333333333, 0.35, -0.05
36246, 1.7833333333333, 0.3, -0.05
36247, 1.7833333333333, 0.25, -0.05
36248, 1.7833333333333, 0.2, -0.05
36249, 1.825, 1.3, -0.05
36250, 1.825, 1.25, -0.05
36251, 1.825, 1.2, -0.05
36252, 1.825, 1.15, -0.05
36253, 1.825, 1.1, -0.05
36254, 1.825, 1.05, -0.05
36255, 1.825, 1, -0.05
36256, 1.825, 0.95, -0.05
36257, 1.825, 0.9, -0.05
36258, 1.825, 0.85, -0.05
36259, 1.825, 0.8, -0.05
36260, 1.825, 0.75, -0.05
36261, 1.825, 0.7, -0.05
36262, 1.825, 0.65, -0.05
36263, 1.825, 0.6, -0.05
36264, 1.825, 0.55, -0.05
36265, 1.825, 0.5, -0.05
36266, 1.825, 0.45, -0.05
36267, 1.825, 0.4, -0.05
36268, 1.825, 0.35, -0.05
36269, 1.825, 0.3, -0.05
36270, 1.825, 0.25, -0.05
36271, 1.825, 0.2, -0.05
36272, 1.8666666666667, 1.3, -0.05
36273, 1.8666666666667, 1.25, -0.05
36274, 1.8666666666667, 1.2, -0.05
36275, 1.8666666666667, 1.15, -0.05
36276, 1.8666666666667, 1.1, -0.05
36277, 1.8666666666667, 1.05, -0.05
36278, 1.8666666666667, 1, -0.05
36279, 1.8666666666667, 0.95, -0.05
36280, 1.8666666666667, 0.9, -0.05
36281, 1.8666666666667, 0.85, -0.05
36282, 1.8666666666667, 0.8, -0.05
36283, 1.8666666666667, 0.75, -0.05
36284, 1.8666666666667, 0.7, -0.05
36285, 1.8666666666667, 0.65, -0.05
36286, 1.8666666666667, 0.6, -0.05
36287, 1.8666666666667, 0.55, -0.05
36288, 1.8666666666667, 0.5, -0.05
36289, 1.8666666666667, 0.45, -0.05
36290, 1.8666666666667, 0.4, -0.05
36291, 1.8666666666667, 0.35, -0.05
36292, 1.8666666666667, 0.3, -0.05
36293, 1.8666666666667, 0.25, -0.05
36294, 1.8666666666667, 0.2, -0.05
36295, 1.9083333333333, 1.3, -0.05
36296, 1.9083333333333, 1.25, -0.05
36297, 1.9083333333333, 1.2, -0.05
36298, 1.9083333333333, 1.15, -0.05
36299, 1.9083333333333, 1.1, -0.05
36300, 1.9083333333333, 1.05, -0.05
36301, 1.9083333333333, 1, -0.05
36302, 1.9083333333333, 0.95, -0.05
36303, 1.9083333333333, 0.9, -0.05
36304, 1.9083333333333, 0.85, -0.05
36305, 1.9083333333333, 0.8, -0.05
36306, 1.9083333333333, 0.75, -0.05
36307, 1.9083333333333, 0.7, -0.05
36308, 1.9083333333333, 0.65, -0.05
36309, 1.9083333333333, 0.6, -0.05
36310, 1.9083333333333, 0.55, -0.05
36311, 1.9083333333333, 0.5, -0.05
36312, 1.9083333333333, 0.45, -0.05
36313, 1.9083333333333, 0.4, -0.05
36314, 1.9083333333333, 0.35, -0.05
36315, 1.9083333333333, 0.3, -0.05
36316, 1.9083333333333, 0.25, -0.05
36317, 1.9083333333333, 0.2, -0.05
36318, 1.95, 1.3, -0.05
36319, 1.95, 1.25, -0.05
36320, 1.95, 1.2, -0.05
36321, 1.95, 1.15, -0.05
36322, 1.95, 1.1, -0.05
36323, 1.95, 1.05, -0.05
36324, 1.95, 1, -0.05
36325, 1.95, 0.95, -0.05
36326, 1.95, 0.9, -0.05
36327, 1.95, 0.85, -0.05
36328, 1.95, 0.8, -0.05
36329, 1.95, 0.75, -0.05
36330, 1.95, 0.7, -0.05
36331, 1.95, 0.65, -0.05
36332, 1.95, 0.6, -0.05
36333, 1.95, 0.55, -0.05
36334, 1.95, 0.5, -0.05
36335, 1.95, 0.45, -0.05
36336, 1.95, 0.4, -0.05
36337, 1.95, 0.35, -0.05
36338, 1.95, 0.3, -0.05
36339, 1.95, 0.25, -0.05
36340, 1.95, 0.2, -0.05
36341, 1.9916666666667, 1.3, -0.05
36342, 1.9916666666667, 1.25, -0.05
36343, 1.9916666666667, 1.2, -0.05
36344, 1.9916666666667, 1.15, -0.05
36345, 1.9916666666667, 1.1, -0.05
36346, 1.9916666666667, 1.05, -0.05
36347, 1.9916666666667, 1, -0.05
36348, 1.9916666666667, 0.95, -0.05
36349, 1.9916666666667, 0.9, -0.05
36350, 1.9916666666667, 0.85, -0.05
36351, 1.9916666666667, 0.8, -0.05
36352, 1.9916666666667, 0.75, -0.05
36353, 1.9916666666667, 0.7, -0.05
36354, 1.9916666666667, 0.65, -0.05
36355, 1.9916666666667, 0.6, -0.05
36356, 1.9916666666667, 0.55, -0.05
36357, 1.9916666666667, 0.5, -0.05
36358, 1.9916666666667, 0.45, -0.05
36359, 1.9916666666667, 0.4, -0.05
36360, 1.9916666666667, 0.35, -0.05
36361, 1.9916666666667, 0.3, -0.05
36362, 1.9916666666667, 0.25, -0.05
36363, 1.9916666666667, 0.2, -0.05
36364, 2.0333333333333, 1.3, -0.05
36365, 2.0333333333333, 1.25, -0.05
36366, 2.0333333333333, 1.2, -0.05
36367, 2.0333333333333, 1.15, -0.05
36368, 2.0333333333333, 1.1, -0.05
36369, 2.0333333333333, 1.05, -0.05
36370, 2.0333333333333, 1, -0.05
36371, 2.0333333333333, 0.95, -0.05
36372, 2.0333333333333, 0.9, -0.05
36373, 2.0333333333333, 0.85, -0.05
36374, 2.0333333333333, 0.8, -0.05
36375, 2.0333333333333, 0.75, -0.05
36376, 2.0333333333333, 0.7, -0.05
36377, 2.0333333333333, 0.65, -0.05
36378, 2.0333333333333, 0.6, -0.05
36379, 2.0333333333333, 0.55, -0.05
36380, 2.0333333333333, 0.5, -0.05
36381, 2.0333333333333, 0.45, -0.05
36382, 2.0333333333333, 0.4, -0.05
36383, 2.0333333333333, 0.35, -0.05
36384, 2.0333333333333, 0.3, -0.05
36385, 2.0333333333333, 0.25, -0.05
36386, 2.0333333333333, 0.2, -0.05
36387, 2.075, 1.3, -0.05
36388, 2.075, 1.25, -0.05
36389, 2.075, 1.2, -0.05
36390, 2.075, 1.15, -0.05
36391, 2.075, 1.1, -0.05
36392, 2.075, 1.05, -0.05
36393, 2.075, 1, -0.05
36394, 2.075, 0.95, -0.05
36395, 2.075, 0.9, -0.05
36396, 2.075, 0.85, -0.05
36397, 2.075, 0.8, -0.05
36398, 2.075, 0.75, -0.05
36399, 2.075, 0.7, -0.05
36400, 2.075, 0.65, -0.05
36401, 2.075, 0.6, -0.05
36402, 2.075, 0.55, -0.05
36403, 2.075, 0.5, -0.05
36404, 2.075, 0.45, -0.05
36405, 2.075, 0.4, -0.05
36406, 2.075, 0.35, -0.05
36407, 2.075, 0.3, -0.05
36408, 2.075, 0.25, -0.05
36409, 2.075, 0.2, -0.05
36410, 2.1166666666667, 1.3, -0.05
36411, 2.1166666666667, 1.25, -0.05
36412, 2.1166666666667, 1.2, -0.05
36413, 2.1166666666667, 1.15, -0.05
36414, 2.1166666666667, 1.1, -0.05
36415, 2.1166666666667, 1.05, -0.05
36416, 2.1166666666667, 1, -0.05
36417, 2.1166666666667, 0.95, -0.05
36418, 2.1166666666667, 0.9, -0.05
36419, 2.1166666666667, 0.85, -0.05
36420, 2.1166666666667, 0.8, -0.05
36421, 2.1166666666667, 0.75, -0.05
36422, 2.1166666666667, 0.7, -0.05
36423, 2.1166666666667, 0.65, -0.05
36424, 2.1166666666667, 0.6, -0.05
36425, 2.1166666666667, 0.55, -0.05
36426, 2.1166666666667, 0.5, -0.05
36427, 2.1166666666667, 0.45, -0.05
36428, 2.1166666666667, 0.4, -0.05
36429, 2.1166666666667, 0.35, -0.05
36430, 2.1166666666667, 0.3, -0.05
36431, 2.1166666666667, 0.25, -0.05
36432, 2.1166666666667, 0.2, -0.05
36433, 2.1583333333333, 1.3, -0.05
36434, 2.1583333333333, 1.25, -0.05
36435, 2.1583333333333, 1.2, -0.05
36436, 2.1583333333333, 1.15, -0.05
36437, 2.1583333333333, 1.1, -0.05
36438, 2.1583333333333, 1.05, -0.05
36439, 2.1583333333333, 1, -0.05
36440, 2.1583333333333, 0.95, -0.05
36441, 2.1583333333333, 0.9, -0.05
36442, 2.1583333333333, 0.85, -0.05
36443, 2.1583333333333, 0.8, -0.05
36444, 2.1583333333333, 0.75, -0.05
36445, 2.1583333333333, 0.7, -0.05
36446, 2.1583333333333, 0.65, -0.05
36447, 2.1583333333333, 0.6, -0.05
36448, 2.1583333333333, 0.55, -0.05
36449, 2.1583333333333, 0.5, -0.05
36450, 2.1583333333333, 0.45, -0.05
36451, 2.1583333333333, 0.4, -0.05
36452, 2.1583333333333, 0.35, -0.05
36453, 2.1583333333333, 0.3, -0.05
36454, 2.1583333333333, 0.25, -0.05
36455, 2.1583333333333, 0.2, -0.05
36456, 1.025, 0.2, 0.041666666666667
36457, 1.025, 0.25, 0.041666666666667
36458, 1.025, 0.3, 0.041666666666667
36459, 1.025, 0.35, 0.041666666666667
36460, 1.025, 0.4, 0.041666666666667
36461, 1.025, 0.45, 0.041666666666667
36462, 1.025, 0.5, 0.041666666666667
36463, 1.025, 0.55, 0.041666666666667
36464, 1.025, 0.6, 0.041666666666667
36465, 1.025, 0.65, 0.041666666666667
36466, 1.025, 0.7, 0.041666666666667
36467, 1.025, 0.75, 0.041666666666667
36468, 1.025, 0.8, 0.041666666666667
36469, 1.025, 0.85, 0.041666666666667
36470, 1.025, 0.9, 0.041666666666667
36471, 1.025, 0.95, 0.041666666666667
36472, 1.025, 1, 0.041666666666667
36473, 1.025, 1.05, 0.041666666666667
36474, 1.025, 1.1, 0.041666666666667
36475, 1.025, 1.15, 0.041666666666667
36476, 1.025, 1.2, 0.041666666666667
36477, 1.025, 1.25, 0.041666666666667
36478, 1.025, 1.3, 0.041666666666667
36479, 1.025, 0.2, 0.083333333333333
36480, 1.025, 0.25, 0.083333333333333
36481, 1.025, 0.3, 0.083333333333333
36482, 1.025, 0.35, 0.083333333333333
36483, 1.025, 0.4, 0.083333333333333
36484, 1.025, 0.45, 0.083333333333333
36485, 1.025, 0.5, 0.083333333333333
36486, 1.025, 0.55, 0.083333333333333
36487, 1.025, 0.6, 0.083333333333333
36488, 1.025, 0.65, 0.083333333333333
36489, 1.025, 0.7, 0.083333333333333
36490, 1.025, 0.75, 0.083333333333333
36491, 1.025, 0.8, 0.083333333333333
36492, 1.025, 0.85, 0.083333333333333
36493, 1.025, 0.9, 0.083333333333333
36494, 1.025, 0.95, 0.083333333333333
36495, 1.025, 1, 0.083333333333333
36496, 1.025, 1.05, 0.083333333333333
36497, 1.025, 1.1, 0.083333333333333
36498, 1.025, 1.15, 0.083333333333333
36499, 1.025, 1.2, 0.083333333333333
36500, 1.025, 1.25, 0.083333333333333
36501, 1.025, 1.3, 0.083333333333333
36502, 1.025, 0.2, 0.125
36503, 1.025, 0.25, 0.125
36504, 1.025, 0.3, 0.125
36505, 1.025, 0.35, 0.125
36506, 1.025, 0.4, 0.125
36507, 1.025, 0.45, 0.125
36508, 1.025, 0.5, 0.125
36509, 1.025, 0.55, 0.125
36510, 1.025, 0.6, 0.125
36511, 1.025, 0.65, 0.125
36512, 1.025, 0.7, 0.125
36513, 1.025, 0.75, 0.125
36514, 1.025, 0.8, 0.125
36515, 1.025, 0.85, 0.125
36516, 1.025, 0.9, 0.125
36517, 1.025, 0.95, 0.125
36518, 1.025, 1, 0.125
36519, 1.025, 1.05, 0.125
36520, 1.025, 1.1, 0.125
36521, 1.025, 1.15, 0.125
36522, 1.025, 1.2, 0.125
36523, 1.025, 1.25, 0.125
36524, 1.025, 1.3, 0.125
36525, 1.025, 0.2, 0.16666666666667
36526, 1.025, 0.25, 0.16666666666667
36527, 1.025, 0.3, 0.16666666666667
36528, 1.025, 0.35, 0.16666666666667
36529, 1.025, 0.4, 0.16666666666667
36530, 1.025, 0.45, 0.16666666666667
36531, 1.025, 0.5, 0.16666666666667
36532, 1.025, 0.55, 0.16666666666667
36533, 1.025, 0.6, 0.16666666666667
36534, 1.025, 0.65, 0.16666666666667
36535, 1.025, 0.7, 0.16666666666667
36536, 1.025, 0.75, 0.16666666666667
36537, 1.025, 0.8, 0.16666666666667
36538, 1.025, 0.85, 0.16666666666667
36539, 1.025, 0.9, 0.16666666666667
36540, 1.025, 0.95, 0.16666666666667
36541, 1.025, 1, 0.16666666666667
36542, 1.025, 1.05, 0.16666666666667
36543, 1.025, 1.1, 0.16666666666667
36544, 1.025, 1.15, 0.16666666666667
36545, 1.025, 1.2, 0.16666666666667
36546, 1.025, 1.25, 0.16666666666667
36547, 1.025, 1.3, 0.16666666666667
36548, 1.025, 0.2, 0.20833333333333
36549, 1.025, 0.25, 0.20833333333333
36550, 1.025, 0.3, 0.20833333333333
36551, 1.025, 0.35, 0.20833333333333
36552, 1.025, 0.4, 0.20833333333333
36553, 1.025, 0.45, 0.20833333333333
36554, 1.025, 0.5, 0.20833333333333
36555, 1.025, 0.55, 0.20833333333333
36556, 1.025, 0.6, 0.20833333333333
36557, 1.025, 0.65, 0.20833333333333
36558, 1.025, 0.7, 0.20833333333333
36559, 1.025, 0.75, 0.20833333333333
36560, 1.025, 0.8, 0.20833333333333
36561, 1.025, 0.85, 0.20833333333333
36562, 1.025, 0.9, 0.20833333333333
36563, 1.025, 0.95, 0.20833333333333
36564, 1.025, 1, 0.20833333333333
36565, 1.025, 1.05, 0.20833333333333
36566, 1.025, 1.1, 0.20833333333333
36567, 1.025, 1.15, 0.20833333333333
36568, 1.025, 1.2, 0.20833333333333
36569, 1.025, 1.25, 0.20833333333333
36570, 1.025, 1.3, 0.20833333333333
36571, 1.025, 0.2, 0.25
36572, 1.025, 0.25, 0.25
36573, 1.025, 0.3, 0.25
36574, 1.025, 0.35, 0.25
36575, 1.025, 0.4, 0.25
36576, 1.025, 0.45, 0.25
36577, 1.025, 0.5, 0.25
36578, 1.025, 0.55, 0.25
36579, 1.025, 0.6, 0.25
36580, 1.025, 0.65, 0.25
36581, 1.025, 0.7, 0.25
36582, 1.025, 0.75, 0.25
36583, 1.025, 0.8, 0.25
36584, 1.025, 0.85, 0.25
36585, 1.025, 0.9, 0.25
36586, 1.025, 0.95, 0.25
36587, 1.025, 1, 0.25
36588, 1.025, 1.05, 0.25
36589, 1.025, 1.1, 0.25
36590, 1.025, 1.15, 0.25
36591, 1.025, 1.2, 0.25
36592, 1.025, 1.25, 0.25
36593, 1.025, 1.3, 0.25
36594, 1.025, 0.2, 0.29166666666667
36595, 1.025, 0.25, 0.29166666666667
36596, 1.025, 0.3, 0.29166666666667
36597, 1.025, 0.35, 0.29166666666667
36598, 1.025, 0.4, 0.29166666666667
36599, 1.025, 0.45, 0.29166666666667
36600, 1.025, 0.5, 0.29166666666667
36601, 1.025, 0.55, 0.29166666666667
36602, 1.025, 0.6, 0.29166666666667
36603, 1.025, 0.65, 0.29166666666667
36604, 1.025, 0.7, 0.29166666666667
36605, 1.025, 0.75, 0.29166666666667
36606, 1.025, 0.8, 0.29166666666667
36607, 1.025, 0.85, 0.29166666666667
36608, 1.025, 0.9, 0.29166666666667
36609, 1.025, 0.95, 0.29166666666667
36610, 1.025, 1, 0.29166666666667
36611, 1.025, 1.05, 0.29166666666667
36612, 1.025, 1.1, 0.29166666666667
36613, 1.025, 1.15, 0.29166666666667
36614, 1.025, 1.2, 0.29166666666667
36615, 1.025, 1.25, 0.29166666666667
36616, 1.025, 1.3, 0.29166666666667
36617, 1.025, 0.2, 0.33333333333333
36618, 1.025, 0.25, 0.33333333333333
36619, 1.025, 0.3, 0.33333333333333
36620, 1.025, 0.35, 0.33333333333333
36621, 1.025, 0.4, 0.33333333333333
36622, 1.025, 0.45, 0.33333333333333
36623, 1.025, 0.5, 0.33333333333333
36624, 1.025, 0.55, 0.33333333333333
36625, 1.025, 0.6, 0.33333333333333
36626, 1.025, 0.65, 0.33333333333333
36627, 1.025, 0.7, 0.33333333333333
36628, 1.025, 0.75, 0.33333333333333
36629, 1.025, 0.8, 0.33333333333333
36630, 1.025, 0.85, 0.33333333333333
36631, 1.025, 0.9, 0.33333333333333
36632, 1.025, 0.95, 0.33333333333333
36633, 1.025, 1, 0.33333333333333
36634, 1.025, 1.05, 0.33333333333333
36635, 1.025, 1.1, 0.33333333333333
36636, 1.025, 1.15, 0.33333333333333
36637, 1.025, 1.2, 0.33333333333333
36638, 1.025, 1.25, 0.33333333333333
36639, 1.025, 1.3, 0.33333333333333
36640, 1.025, 0.2, 0.375
36641, 1.025, 0.25, 0.375
36642, 1.025, 0.3, 0.375
36643, 1.025, 0.35, 0.375
36644, 1.025, 0.4, 0.375
36645, 1.025, 0.45, 0.375
36646, 1.025, 0.5, 0.375
36647, 1.025, 0.55, 0.375
36648, 1.025, 0.6, 0.375
36649, 1.025, 0.65, 0.375
36650, 1.025, 0.7, 0.375
36651, 1.025, 0.75, 0.375
36652, 1.025, 0.8, 0.375
36653, 1.025, 0.85, 0.375
36654, 1.025, 0.9, 0.375
36655, 1.025, 0.95, 0.375
36656, 1.025, 1, 0.375
36657, 1.025, 1.05, 0.375
36658, 1.025, 1.1, 0.375
36659, 1.025, 1.15, 0.375
36660, 1.025, 1.2, 0.375
36661, 1.025, 1.25, 0.375
36662, 1.025, 1.3, 0.375
36663, 1.025, 0.2, 0.41666666666667
36664, 1.025, 0.25, 0.41666666666667
36665, 1.025, 0.3, 0.41666666666667
36666, 1.025, 0.35, 0.41666666666667
36667, 1.025, 0.4, 0.41666666666667
36668, 1.025, 0.45, 0.41666666666667
36669, 1.025, 0.5, 0.41666666666667
36670, 1.025, 0.55, 0.41666666666667
36671, 1.025, 0.6, 0.41666666666667
36672, 1.025, 0.65, 0.41666666666667
36673, 1.025, 0.7, 0.41666666666667
36674, 1.025, 0.75, 0.41666666666667
36675, 1.025, 0.8, 0.41666666666667
36676, 1.025, 0.85, 0.41666666666667
36677, 1.025, 0.9, 0.41666666666667
36678, 1.025, 0.95, 0.41666666666667
36679, 1.025, 1, 0.41666666666667
36680, 1.025, 1.05, 0.41666666666667
36681, 1.025, 1.1, 0.41666666666667
36682, 1.025, 1.15, 0.41666666666667
36683, 1.025, 1.2, 0.41666666666667
36684, 1.025, 1.25, 0.41666666666667
36685, 1.025, 1.3, 0.41666666666667
36686, 1.025, 0.2, 0.45833333333333
36687, 1.025, 0.25, 0.45833333333333
36688, 1.025, 0.3, 0.45833333333333
36689, 1.025, 0.35, 0.45833333333333
36690, 1.025, 0.4, 0.45833333333333
36691, 1.025, 0.45, 0.45833333333333
36692, 1.025, 0.5, 0.45833333333333
36693, 1.025, 0.55, 0.45833333333333
36694, 1.025, 0.6, 0.45833333333333
36695, 1.025, 0.65, 0.45833333333333
36696, 1.025, 0.7, 0.45833333333333
36697, 1.025, 0.75, 0.45833333333333
36698, 1.025, 0.8, 0.45833333333333
36699, 1.025, 0.85, 0.45833333333333
36700, 1.025, 0.9, 0.45833333333333
36701, 1.025, 0.95, 0.45833333333333
36702, 1.025, 1, 0.45833333333333
36703, 1.025, 1.05, 0.45833333333333
36704, 1.025, 1.1, 0.45833333333333
36705, 1.025, 1.15, 0.45833333333333
36706, 1.025, 1.2, 0.45833333333333
36707, 1.025, 1.25, 0.45833333333333
36708, 1.025, 1.3, 0.45833333333333
36709, 1.175, 1.3, 0.041666666666667
36710, 1.175, 1.25, 0.041666666666667
36711, 1.175, 1.2, 0.041666666666667
36712, 1.175, 1.15, 0.041666666666667
36713, 1.175, 1.1, 0.041666666666667
36714, 1.175, 1.05, 0.041666666666667
36715, 1.175, 1, 0.041666666666667
36716, 1.175, 0.95, 0.041666666666667
36717, 1.175, 0.9, 0.041666666666667
36718, 1.175, 0.85, 0.041666666666667
36719, 1.175, 0.8, 0.041666666666667
36720, 1.175, 0.75, 0.041666666666667
36721, 1.175, 0.7, 0.041666666666667
36722, 1.175, 0.65, 0.041666666666667
36723, 1.175, 0.6, 0.041666666666667
36724, 1.175, 0.55, 0.041666666666667
36725, 1.175, 0.5, 0.041666666666667
36726, 1.175, 0.45, 0.041666666666667
36727, 1.175, 0.4, 0.041666666666667
36728, 1.175, 0.35, 0.041666666666667
36729, 1.175, 0.3, 0.041666666666667
36730, 1.175, 0.25, 0.041666666666667
36731, 1.175, 0.2, 0.041666666666667
36732, 1.175, 1.3, 0.083333333333333
36733, 1.175, 1.25, 0.083333333333333
36734, 1.175, 1.2, 0.083333333333333
36735, 1.175, 1.15, 0.083333333333333
36736, 1.175, 1.1, 0.083333333333333
36737, 1.175, 1.05, 0.083333333333333
36738, 1.175, 1, 0.083333333333333
36739, 1.175, 0.95, 0.083333333333333
36740, 1.175, 0.9, 0.083333333333333
36741, 1.175, 0.85, 0.083333333333333
36742, 1.175, 0.8, 0.083333333333333
36743, 1.175, 0.75, 0.083333333333333
36744, 1.175, 0.7, 0.083333333333333
36745, 1.175, 0.65, 0.083333333333333
36746, 1.175, 0.6, 0.083333333333333
36747, 1.175, 0.55, 0.083333333333333
36748, 1.175, 0.5, 0.083333333333333
36749, 1.175, 0.45, 0.083333333333333
36750, 1.175, 0.4, 0.083333333333333
36751, 1.175, 0.35, 0.083333333333333
36752, 1.175, 0.3, 0.083333333333333
36753, 1.175, 0.25, 0.083333333333333
36754, 1.175, 0.2, 0.083333333333333
36755, 1.175, 1.3, 0.125
36756, 1.175, 1.25, 0.125
36757, 1.175, 1.2, 0.125
36758, 1.175, 1.15, 0.125
36759, 1.175, 1.1, 0.125
36760, 1.175, 1.05, 0.125
36761, 1.175, 1, 0.125
36762, 1.175, 0.95, 0.125
36763, 1.175, 0.9, 0.125
36764, 1.175, 0.85, 0.125
36765, 1.175, 0.8, 0.125
36766, 1.175, 0.75, 0.125
36767, 1.175, 0.7, 0.125
36768, 1.175, 0.65, 0.125
36769, 1.175, 0.6, 0.125
36770, 1.175, 0.55, 0.125
36771, 1.175, 0.5, 0.125
36772, 1.175, 0.45, 0.125
36773, 1.175, 0.4, 0.125
36774, 1.175, 0.35, 0.125
36775, 1.175, 0.3, 0.125
36776, 1.175, 0.25, 0.125
36777, 1.175, 0.2, 0.125
36778, 1.175, 1.3, 0.16666666666667
36779, 1.175, 1.25, 0.16666666666667
36780, 1.175, 1.2, 0.16666666666667
36781, 1.175, 1.15, 0.16666666666667
36782, 1.175, 1.1, 0.16666666666667
36783, 1.175, 1.05, 0.16666666666667
36784, 1.175, 1, 0.16666666666667
36785, 1.175, 0.95, 0.16666666666667
36786, 1.175, 0.9, 0.16666666666667
36787, 1.175, 0.85, 0.16666666666667
36788, 1.175, 0.8, 0.16666666666667
36789, 1.175, 0.75, 0.16666666666667
36790, 1.175, 0.7, 0.16666666666667
36791, 1.175, 0.65, 0.16666666666667
36792, 1.175, 0.6, 0.16666666666667
36793, 1.175, 0.55, 0.16666666666667
36794, 1.175, 0.5, 0.16666666666667
36795, 1.175, 0.45, 0.16666666666667
36796, 1.175, 0.4, 0.16666666666667
36797, 1.175, 0.35, 0.16666666666667
36798, 1.175, 0.3, 0.16666666666667
36799, 1.175, 0.25, 0.16666666666667
36800, 1.175, 0.2, 0.16666666666667
36801, 1.175, 1.3, 0.20833333333333
36802, 1.175, 1.25, 0.20833333333333
36803, 1.175, 1.2, 0.20833333333333
36804, 1.175, 1.15, 0.20833333333333
36805, 1.175, 1.1, 0.20833333333333
36806, 1.175, 1.05, 0.20833333333333
36807, 1.175, 1, 0.20833333333333
36808, 1.175, 0.95, 0.20833333333333
36809, 1.175, 0.9, 0.20833333333333
36810, 1.175, 0.85, 0.20833333333333
36811, 1.175, 0.8, 0.20833333333333
36812, 1.175, 0.75, 0.20833333333333
36813, 1.175, 0.7, 0.20833333333333
36814, 1.175, 0.65, 0.20833333333333
36815, 1.175, 0.6, 0.20833333333333
36816, 1.175, 0.55, 0.20833333333333
36817, 1.175, 0.5, 0.20833333333333
36818, 1.175, 0.45, 0.20833333333333
36819, 1.175, 0.4, 0.20833333333333
36820, 1.175, 0.35, 0.20833333333333
36821, 1.175, 0.3, 0.20833333333333
36822, 1.175, 0.25, 0.20833333333333
36823, 1.175, 0.2, 0.20833333333333
36824, 1.175, 1.3, 0.25
36825, 1.175, 1.25, 0.25
36826, 1.175, 1.2, 0.25
36827, 1.175, 1.15, 0.25
36828, 1.175, 1.1, 0.25
36829, 1.175, 1.05, 0.25
36830, 1.175, 1, 0.25
36831, 1.175, 0.95, 0.25
36832, 1.175, 0.9, 0.25
36833, 1.175, 0.85, 0.25
36834, 1.175, 0.8, 0.25
36835, 1.175, 0.75, 0.25
36836, 1.175, 0.7, 0.25
36837, 1.175, 0.65, 0.25
36838, 1.175, 0.6, 0.25
36839, 1.175, 0.55, 0.25
36840, 1.175, 0.5, 0.25
36841, 1.175, 0.45, 0.25
36842, 1.175, 0.4, 0.25
36843, 1.175, 0.35, 0.25
36844, 1.175, 0.3, 0.25
36845, 1.175, 0.25, 0.25
36846, 1.175, 0.2, 0.25
36847, 1.175, 1.3, 0.29166666666667
36848, 1.175, 1.25, 0.29166666666667
36849, 1.175, 1.2, 0.29166666666667
36850, 1.175, 1.15, 0.29166666666667
36851, 1.175, 1.1, 0.29166666666667
36852, 1.175, 1.05, 0.29166666666667
36853, 1.175, 1, 0.29166666666667
36854, 1.175, 0.95, 0.29166666666667
36855, 1.175, 0.9, 0.29166666666667
36856, 1.175, 0.85, 0.29166666666667
36857, 1.175, 0.8, 0.29166666666667
36858, 1.175, 0.75, 0.29166666666667
36859, 1.175, 0.7, 0.29166666666667
36860, 1.175, 0.65, 0.29166666666667
36861, 1.175, 0.6, 0.29166666666667
36862, 1.175, 0.55, 0.29166666666667
36863, 1.175, 0.5, 0.29166666666667
36864, 1.175, 0.45, 0.29166666666667
36865, 1.175, 0.4, 0.29166666666667
36866, 1.175, 0.35, 0.29166666666667
36867, 1.175, 0.3, 0.29166666666667
36868, 1.175, 0.25, 0.29166666666667
36869, 1.175, 0.2, 0.29166666666667
36870, 1.175, 1.3, 0.33333333333333
36871, 1.175, 1.25, 0.33333333333333
36872, 1.175, 1.2, 0.33333333333333
36873, 1.175, 1.15, 0.33333333333333
36874, 1.175, 1.1, 0.33333333333333
36875, 1.175, 1.05, 0.33333333333333
36876, 1.175, 1, 0.33333333333333
36877, 1.175, 0.95, 0.33333333333333
36878, 1.175, 0.9, 0.33333333333333
36879, 1.175, 0.85, 0.33333333333333
36880, 1.175, 0.8, 0.33333333333333
36881, 1.175, 0.75, 0.33333333333333
36882, 1.175, 0.7, 0.33333333333333
36883, 1.175, 0.65, 0.33333333333333
36884, 1.175, 0.6, 0.33333333333333
36885, 1.175, 0.55, 0.33333333333333
36886, 1.175, 0.5, 0.33333333333333
36887, 1.175, 0.45, 0.33333333333333
36888, 1.175, 0.4, 0.33333333333333
36889, 1.175, 0.35, 0.33333333333333
36890, 1.175, 0.3, 0.33333333333333
36891, 1.175, 0.25, 0.33333333333333
36892, 1.175, 0.2, 0.33333333333333
36893, 1.175, 1.3, 0.375
36894, 1.175, 1.25, 0.375
36895, 1.175, 1.2, 0.375
36896, 1.175, 1.15, 0.375
36897, 1.175, 1.1, 0.375
36898, 1.175, 1.05, 0.375
36899, 1.175, 1, 0.375
36900, 1.175, 0.95, 0.375
36901, 1.175, 0.9, 0.375
36902, 1.175, 0.85, 0.375
36903, 1.175, 0.8, 0.375
36904, 1.175, 0.75, 0.375
36905, 1.175, 0.7, 0.375
36906, 1.175, 0.65, 0.375
36907, 1.175, 0.6, 0.375
36908, 1.175, 0.55, 0.375
36909, 1.175, 0.5, 0.375
36910, 1.175, 0.45, 0.375
36911, 1.175, 0.4, 0.375
36912, 1.175, 0.35, 0.375
36913, 1.175, 0.3, 0.375
36914, 1.175, 0.25, 0.375
36915, 1.175, 0.2, 0.375
36916, 1.175, 1.3, 0.41666666666667
36917, 1.175, 1.25, 0.41666666666667
36918, 1.175, 1.2, 0.41666666666667
36919, 1.175, 1.15, 0.41666666666667
36920, 1.175, 1.1, 0.41666666666667
36921, 1.175, 1.05, 0.41666666666667
36922, 1.175, 1, 0.41666666666667
36923, 1.175, 0.95, 0.41666666666667
36924, 1.175, 0.9, 0.41666666666667
36925, 1.175, 0.85, 0.41666666666667
36926, 1.175, 0.8, 0.41666666666667
36927, 1.175, 0.75, 0.41666666666667
36928, 1.175, 0.7, 0.41666666666667
36929, 1.175, 0.65, 0.41666666666667
36930, 1.175, 0.6, 0.41666666666667
36931, 1.175, 0.55, 0.41666666666667
36932, 1.175, 0.5, 0.41666666666667
36933, 1.175, 0.45, 0.41666666666667
36934, 1.175, 0.4, 0.41666666666667
36935, 1.175, 0.35, 0.41666666666667
36936, 1.175, 0.3, 0.41666666666667
36937, 1.175, 0.25, 0.41666666666667
36938, 1.175, 0.2, 0.41666666666667
36939, 1.175, 1.3, 0.45833333333333
36940, 1.175, 1.25, 0.45833333333333
36941, 1.175, 1.2, 0.45833333333333
36942, 1.175, 1.15, 0.45833333333333
36943, 1.175, 1.1, 0.45833333333333
36944, 1.175, 1.05, 0.45833333333333
36945, 1.175, 1, 0.45833333333333
36946, 1.175, 0.95, 0.45833333333333
36947, 1.175, 0.9, 0.45833333333333
36948, 1.175, 0.85, 0.45833333333333
36949, 1.175, 0.8, 0.45833333333333
36950, 1.175, 0.75, 0.45833333333333
36951, 1.175, 0.7, 0.45833333333333
36952, 1.175, 0.65, 0.45833333333333
36953, 1.175, 0.6, 0.45833333333333
36954, 1.175, 0.55, 0.45833333333333
36955, 1.175, 0.5, 0.45833333333333
36956, 1.175, 0.45, 0.45833333333333
36957, 1.175, 0.4, 0.45833333333333
36958, 1.175, 0.35, 0.45833333333333
36959, 1.175, 0.3, 0.45833333333333
36960, 1.175, 0.25, 0.45833333333333
36961, 1.175, 0.2, 0.45833333333333
36962, 0.041666666666667, 1.54, 0.041666666666667
36963, 0.041666666666667, 1.58, 0.041666666666667
36964, 0.041666666666667, 1.62, 0.041666666666667
36965, 0.041666666666667, 1.66, 0.041666666666667
36966, 0.041666666666667, 1.54, 0.083333333333333
36967, 0.041666666666667, 1.58, 0.083333333333333
36968, 0.041666666666667, 1.62, 0.083333333333333
36969, 0.041666666666667, 1.66, 0.083333333333333
36970, 0.041666666666667, 1.54, 0.125
36971, 0.041666666666667, 1.58, 0.125
36972, 0.041666666666667, 1.62, 0.125
36973, 0.041666666666667, 1.66, 0.125
36974, 0.041666666666667, 1.54, 0.16666666666667
36975, 0.041666666666667, 1.58, 0.16666666666667
36976, 0.041666666666667, 1.62, 0.16666666666667
36977, 0.041666666666667, 1.66, 0.16666666666667
36978, 0.041666666666667, 1.54, 0.20833333333333
36979, 0.041666666666667, 1.58, 0.20833333333333
36980, 0.041666666666667, 1.62, 0.20833333333333
36981, 0.041666666666667, 1.66, 0.20833333333333
36982, 0.041666666666667, 1.54, 0.25
36983, 0.041666666666667, 1.58, 0.25
36984, 0.041666666666667, 1.62, 0.25
36985, 0.041666666666667, 1.66, 0.25
36986, 0.041666666666667, 1.54, 0.29166666666667
36987, 0.041666666666667, 1.58, 0.29166666666667
36988, 0.041666666666667, 1.62, 0.29166666666667
36989, 0.041666666666667, 1.66, 0.29166666666667
36990, 0.041666666666667, 1.54, 0.33333333333333
36991, 0.041666666666667, 1.58, 0.33333333333333
36992, 0.041666666666667, 1.62, 0.33333333333333
36993, 0.041666666666667, 1.66, 0.33333333333333
36994, 0.041666666666667, 1.54, 0.375
36995, 0.041666666666667, 1.58, 0.375
36996, 0.041666666666667, 1.62, 0.375
36997, 0.041666666666667, 1.66, 0.375
36998, 0.041666666666667, 1.54, 0.41666666666667
36999, 0.041666666666667, 1.58, 0.41666666666667
37000, 0.041666666666667, 1.62, 0.41666666666667
37001, 0.041666666666667, 1.66, 0.41666666666667
37002, 0.041666666666667, 1.54, 0.45833333333333
37003, 0.041666666666667, 1.58, 0.45833333333333
37004, 0.041666666666667, 1.62, 0.45833333333333
37005, 0.041666666666667, 1.66, 0.45833333333333
37006, 0.083333333333333, 1.54, 0.041666666666667
37007, 0.083333333333333, 1.58, 0.041666666666667
37008, 0.083333333333333, 1.62, 0.041666666666667
37009, 0.083333333333333, 1.66, 0.041666666666667
37010, 0.083333333333333, 1.54, 0.083333333333333
37011, 0.083333333333333, 1.58, 0.083333333333333
37012, 0.083333333333333, 1.62, 0.083333333333333
37013, 0.083333333333333, 1.66, 0.083333333333333
37014, 0.083333333333333, 1.54, 0.125
37015, 0.083333333333333, 1.58, 0.125
37016, 0.083333333333333, 1.62, 0.125
37017, 0.083333333333333, 1.66, 0.125
37018, 0.083333333333333, 1.54, 0.16666666666667
37019, 0.083333333333333, 1.58, 0.16666666666667
37020, 0.083333333333333, 1.62, 0.16666666666667
37021, 0.083333333333333, 1.66, 0.16666666666667
37022, 0.083333333333333, 1.54, 0.20833333333333
37023, 0.083333333333333, 1.58, 0.20833333333333
37024, 0.083333333333333, 1.62, 0.20833333333333
37025, 0.083333333333333, 1.66, 0.20833333333333
37026, 0.083333333333333, 1.54, 0.25
37027, 0.083333333333333, 1.58, 0.25
37028, 0.083333333333333, 1.62, 0.25
37029, 0.083333333333333, 1.66, 0.25
37030, 0.083333333333333, 1.54, 0.29166666666667
37031, 0.083333333333333, 1.58, 0.29166666666667
37032, 0.083333333333333, 1.62, 0.29166666666667
37033, 0.083333333333333, 1.66, 0.29166666666667
37034, 0.083333333333333, 1.54, 0.33333333333333
37035, 0.083333333333333, 1.58, 0.33333333333333
37036, 0.083333333333333, 1.62, 0.33333333333333
37037, 0.083333333333333, 1.66, 0.33333333333333
37038, 0.083333333333333, 1.54, 0.375
37039, 0.083333333333333, 1.58, 0.375
37040, 0.083333333333333, 1.62, 0.375
37041, 0.083333333333333, 1.66, 0.375
37042, 0.083333333333333, 1.54, 0.41666666666667
37043, 0.083333333333333, 1.58, 0.41666666666667
37044, 0.083333333333333, 1.62, 0.41666666666667
37045, 0.083333333333333, 1.66, 0.41666666666667
37046, 0.083333333333333, 1.54, 0.45833333333333
37047, 0.083333333333333, 1.58, 0.45833333333333
37048, 0.083333333333333, 1.62, 0.45833333333333
37049, 0.083333333333333, 1.66, 0.45833333333333
37050, 0.125, 1.54, 0.041666666666667
37051, 0.125, 1.58, 0.041666666666667
37052, 0.125, 1.62, 0.041666666666667
37053, 0.125, 1.66, 0.041666666666667
37054, 0.125, 1.54, 0.083333333333333
37055, 0.125, 1.58, 0.083333333333333
37056, 0.125, 1.62, 0.083333333333333
37057, 0.125, 1.66, 0.083333333333333
37058, 0.125, 1.54, 0.125
37059, 0.125, 1.58, 0.125
37060, 0.125, 1.62, 0.125
37061, 0.125, 1.66, 0.125
37062, 0.125, 1.54, 0.16666666666667
37063, 0.125, 1.58, 0.16666666666667
37064, 0.125, 1.62, 0.16666666666667
37065, 0.125, 1.66, 0.16666666666667
37066, 0.125, 1.54, 0.20833333333333
37067, 0.125, 1.58, 0.20833333333333
37068, 0.125, 1.62, 0.20833333333333
37069, 0.125, 1.66, 0.20833333333333
37070, 0.125, 1.54, 0.25
37071, 0.125, 1.58, 0.25
37072, 0.125, 1.62, 0.25
37073, 0.125, 1.66, 0.25
37074, 0.125, 1.54, 0.29166666666667
37075, 0.125, 1.58, 0.29166666666667
37076, 0.125, 1.62, 0.29166666666667
37077, 0.125, 1.66, 0.29166666666667
37078, 0.125, 1.54, 0.33333333333333
37079, 0.125, 1.58, 0.33333333333333
37080, 0.125, 1.62, 0.33333333333333
37081, 0.125, 1.66, 0.33333333333333
37082, 0.125, 1.54, 0.375
37083, 0.125, 1.58, 0.375
37084, 0.125, 1.62, 0.375
37085, 0.125, 1.66, 0.375
37086, 0.125, 1.54, 0.41666666666667
37087, 0.125, 1.58, 0.41666666666667
37088, 0.125, 1.62, 0.41666666666667
37089, 0.125, 1.66, 0.41666666666667
37090, 0.125, 1.54, 0.45833333333333
37091, 0.125, 1.58, 0.45833333333333
37092, 0.125, 1.62, 0.45833333333333
37093, 0.125, 1.66, 0.45833333333333
37094, 0.16666666666667, 1.54, 0.041666666666667
37095, 0.16666666666667, 1.58, 0.041666666666667
37096, 0.16666666666667, 1.62, 0.041666666666667
37097, 0.16666666666667, 1.66, 0.041666666666667
37098, 0.16666666666667, 1.54, 0.083333333333333
37099, 0.16666666666667, 1.58, 0.083333333333333
37100, 0.16666666666667, 1.62, 0.083333333333333
37101, 0.16666666666667, 1.66, 0.083333333333333
37102, 0.16666666666667, 1.54, 0.125
37103, 0.16666666666667, 1.58, 0.125
37104, 0.16666666666667, 1.62, 0.125
37105, 0.16666666666667, 1.66, 0.125
37106, 0.16666666666667, 1.54, 0.16666666666667
37107, 0.16666666666667, 1.58, 0.16666666666667
37108, 0.16666666666667, 1.62, 0.16666666666667
37109, 0.16666666666667, 1.66, 0.16666666666667
37110, 0.16666666666667, 1.54, 0.20833333333333
37111, 0.16666666666667, 1.58, 0.20833333333333
37112, 0.16666666666667, 1.62, 0.20833333333333
37113, 0.16666666666667, 1.66, 0.20833333333333
37114, 0.16666666666667, 1.54, 0.25
37115, 0.16666666666667, 1.58, 0.25
37116, 0.16666666666667, 1.62, 0.25
37117, 0.16666666666667, 1.66, 0.25
37118, 0.16666666666667, 1.54, 0.29166666666667
37119, 0.16666666666667, 1.58, 0.29166666666667
37120, 0.16666666666667, 1.62, 0.29166666666667
37121, 0.16666666666667, 1.66, 0.29166666666667
37122, 0.16666666666667, 1.54, 0.33333333333333
37123, 0.16666666666667, 1.58, 0.33333333333333
37124, 0.16666666666667, 1.62, 0.33333333333333
37125, 0.16666666666667, 1.66, 0.33333333333333
37126, 0.16666666666667, 1.54, 0.375
37127, 0.16666666666667, 1.58, 0.375
37128, 0.16666666666667, 1.62, 0.375
37129, 0.16666666666667, 1.66, 0.375
37130, 0.16666666666667, 1.54, 0.41666666666667
37131, 0.16666666666667, 1.58, 0.41666666666667
37132, 0.16666666666667, 1.62, 0.41666666666667
37133, 0.16666666666667, 1.66, 0.41666666666667
37134, 0.16666666666667, 1.54, 0.45833333333333
37135, 0.16666666666667, 1.58, 0.45833333333333
37136, 0.16666666666667, 1.62, 0.45833333333333
37137, 0.16666666666667, 1.66, 0.45833333333333
37138, 0.20833333333333, 1.54, 0.041666666666667
37139, 0.20833333333333, 1.58, 0.041666666666667
37140, 0.20833333333333, 1.62, 0.041666666666667
37141, 0.20833333333333, 1.66, 0.041666666666667
37142, 0.20833333333333, 1.54, 0.083333333333333
37143, 0.20833333333333, 1.58, 0.083333333333333
37144, 0.20833333333333, 1.62, 0.083333333333333
37145, 0.20833333333333, 1.66, 0.083333333333333
37146, 0.20833333333333, 1.54, 0.125
37147, 0.20833333333333, 1.58, 0.125
37148, 0.20833333333333, 1.62, 0.125
37149, 0.20833333333333, 1.66, 0.125
37150, 0.20833333333333, 1.54, 0.16666666666667
37151, 0.20833333333333, 1.58, 0.16666666666667
37152, 0.20833333333333, 1.62, 0.16666666666667
37153, 0.20833333333333, 1.66, 0.16666666666667
37154, 0.20833333333333, 1.54, 0.20833333333333
37155, 0.20833333333333, 1.58, 0.20833333333333
37156, 0.20833333333333, 1.62, 0.20833333333333
37157, 0.20833333333333, 1.66, 0.20833333333333
37158, 0.20833333333333, 1.54, 0.25
37159, 0.20833333333333, 1.58, 0.25
37160, 0.20833333333333, 1.62, 0.25
37161, 0.20833333333333, 1.66, 0.25
37162, 0.20833333333333, 1.54, 0.29166666666667
37163, 0.20833333333333, 1.58, 0.29166666666667
37164, 0.20833333333333, 1.62, 0.29166666666667
37165, 0.20833333333333, 1.66, 0.29166666666667
37166, 0.20833333333333, 1.54, 0.33333333333333
37167, 0.20833333333333, 1.58, 0.33333333333333
37168, 0.20833333333333, 1.62, 0.33333333333333
37169, 0.20833333333333, 1.66, 0.33333333333333
37170, 0.20833333333333, 1.54, 0.375
37171, 0.20833333333333, 1.58, 0.375
37172, 0.20833333333333, 1.62, 0.375
37173, 0.20833333333333, 1.66, 0.375
37174, 0.20833333333333, 1.54, 0.41666666666667
37175, 0.20833333333333, 1.58, 0.41666666666667
37176, 0.20833333333333, 1.62, 0.41666666666667
37177, 0.20833333333333, 1.66, 0.41666666666667
37178, 0.20833333333333, 1.54, 0.45833333333333
37179, 0.20833333333333, 1.58, 0.45833333333333
37180, 0.20833333333333, 1.62, 0.45833333333333
37181, 0.20833333333333, 1.66, 0.45833333333333
37182, 0.25, 1.54, 0.041666666666667
37183, 0.25, 1.58, 0.041666666666667
37184, 0.25, 1.62, 0.041666666666667
37185, 0.25, 1.66, 0.041666666666667
37186, 0.25, 1.54, 0.083333333333333
37187, 0.25, 1.58, 0.083333333333333
37188, 0.25, 1.62, 0.083333333333333
37189, 0.25, 1.66, 0.083333333333333
37190, 0.25, 1.54, 0.125
37191, 0.25, 1.58, 0.125
37192, 0.25, 1.62, 0.125
37193, 0.25, 1.66, 0.125
37194, 0.25, 1.54, 0.16666666666667
37195, 0.25, 1.58, 0.16666666666667
37196, 0.25, 1.62, 0.16666666666667
37197, 0.25, 1.66, 0.16666666666667
37198, 0.25, 1.54, 0.20833333333333
37199, 0.25, 1.58, 0.20833333333333
37200, 0.25, 1.62, 0.20833333333333
37201, 0.25, 1.66, 0.20833333333333
37202, 0.25, 1.54, 0.25
37203, 0.25, 1.58, 0.25
37204, 0.25, 1.62, 0.25
37205, 0.25, 1.66, 0.25
37206, 0.25, 1.54, 0.29166666666667
37207, 0.25, 1.58, 0.29166666666667
37208, 0.25, 1.62, 0.29166666666667
37209, 0.25, 1.66, 0.29166666666667
37210, 0.25, 1.54, 0.33333333333333
37211, 0.25, 1.58, 0.33333333333333
37212, 0.25, 1.62, 0.33333333333333
37213, 0.25, 1.66, 0.33333333333333
37214, 0.25, 1.54, 0.375
37215, 0.25, 1.58, 0.375
37216, 0.25, 1.62, 0.375
37217, 0.25, 1.66, 0.375
37218, 0.25, 1.54, 0.41666666666667
37219, 0.25, 1.58, 0.41666666666667
37220, 0.25, 1.62, 0.41666666666667
37221, 0.25, 1.66, 0.41666666666667
37222, 0.25, 1.54, 0.45833333333333
37223, 0.25, 1.58, 0.45833333333333
37224, 0.25, 1.62, 0.45833333333333
37225, 0.25, 1.66, 0.45833333333333
37226, 0.29166666666667, 1.54, 0.041666666666667
