6140, 19976, 19953, 19907, 19930, 19977, 19954, 19908, 19931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6141, 19977, 19954, 19908, 19931, 19978, 19955, 19909, 19932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6142, 19978, 19955, 19909, 19932, 19979, 19956, 19910, 19933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6143, 19979, 19956, 19910, 19933, 19980, 19957, 19911, 19934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6144, 19980, 19957, 19911, 19934, 19981, 19958, 19912, 19935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6145, 19981, 19958, 19912, 19935, 19982, 19959, 19913, 19936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6146, 19982, 19959, 19913, 19936, 19983, 19960, 19914, 19937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6147, 19983, 19960, 19914, 19937, 19984, 19961, 19915, 19938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6148, 19984, 19961, 19915, 19938, 19985, 19962, 19916, 19939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6149, 19985, 19962, 19916, 19939, 19986, 19963, 19917, 19940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6150, 19986, 19963, 19917, 19940, 19987, 19964, 19918, 19941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6151, 19987, 19964, 19918, 19941, 19988, 19965, 19919, 19942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6152, 19988, 19965, 19919, 19942, 19989, 19966, 19920, 19943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6153, 19989, 19966, 19920, 19943, 2451, 2450, 2448, 2449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6154, 121, 2429, 2427, 120, 2715, 19967, 19921, 2714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6155, 2715, 19967, 19921, 2714, 2726, 19968, 19922, 2725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6156, 2726, 19968, 19922, 2725, 2737, 19969, 19923, 2736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6157, 2737, 19969, 19923, 2736, 2748, 19970, 19924, 2747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6158, 2748, 19970, 19924, 2747, 2759, 19971, 19925, 2758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6159, 2759, 19971, 19925, 2758, 2770, 19972, 19926, 2769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6160, 2770, 19972, 19926, 2769, 2781, 19973, 19927, 2780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6161, 2781, 19973, 19927, 2780, 2792, 19974, 19928, 2791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6162, 2792, 19974, 19928, 2791, 2803, 19975, 19929, 2802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6163, 2803, 19975, 19929, 2802, 2814, 19976, 19930, 2813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6164, 2814, 19976, 19930, 2813, 2825, 19977, 19931, 2824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6165, 2825, 19977, 19931, 2824, 2836, 19978, 19932, 2835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6166, 2836, 19978, 19932, 2835, 2847, 19979, 19933, 2846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6167, 2847, 19979, 19933, 2846, 2858, 19980, 19934, 2857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6168, 2858, 19980, 19934, 2857, 2869, 19981, 19935, 2868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6169, 2869, 19981, 19935, 2868, 2880, 19982, 19936, 2879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6170, 2880, 19982, 19936, 2879, 2891, 19983, 19937, 2890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6171, 2891, 19983, 19937, 2890, 2902, 19984, 19938, 2901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6172, 2902, 19984, 19938, 2901, 2913, 19985, 19939, 2912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6173, 2913, 19985, 19939, 2912, 2924, 19986, 19940, 2923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6174, 2924, 19986, 19940, 2923, 2935, 19987, 19941, 2934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6175, 2935, 19987, 19941, 2934, 2946, 19988, 19942, 2945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6176, 2946, 19988, 19942, 2945, 2957, 19989, 19943, 2956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6177, 2957, 19989, 19943, 2956, 147, 2451, 2449, 146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6178, 109, 1, 108, 2428, 3004, 173, 2462, 19944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6179, 3004, 173, 2462, 19944, 3005, 174, 2473, 19945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6180, 3005, 174, 2473, 19945, 3006, 175, 2484, 19946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6181, 3006, 175, 2484, 19946, 3007, 176, 2495, 19947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6182, 3007, 176, 2495, 19947, 3008, 177, 2506, 19948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6183, 3008, 177, 2506, 19948, 3009, 178, 2517, 19949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6184, 3009, 178, 2517, 19949, 3010, 179, 2528, 19950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6185, 3010, 179, 2528, 19950, 3011, 180, 2539, 19951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6186, 3011, 180, 2539, 19951, 3012, 181, 2550, 19952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6187, 3012, 181, 2550, 19952, 3013, 182, 2561, 19953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6188, 3013, 182, 2561, 19953, 3014, 183, 2572, 19954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6189, 3014, 183, 2572, 19954, 3015, 184, 2583, 19955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6190, 3015, 184, 2583, 19955, 3016, 185, 2594, 19956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6191, 3016, 185, 2594, 19956, 3017, 186, 2605, 19957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6192, 3017, 186, 2605, 19957, 3018, 187, 2616, 19958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6193, 3018, 187, 2616, 19958, 3019, 188, 2627, 19959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6194, 3019, 188, 2627, 19959, 3020, 189, 2638, 19960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6195, 3020, 189, 2638, 19960, 3021, 190, 2649, 19961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6196, 3021, 190, 2649, 19961, 3022, 191, 2660, 19962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6197, 3022, 191, 2660, 19962, 3023, 192, 2671, 19963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6198, 3023, 192, 2671, 19963, 3024, 193, 2682, 19964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6199, 3024, 193, 2682, 19964, 3025, 194, 2693, 19965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6200, 3025, 194, 2693, 19965, 3026, 195, 2704, 19966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6201, 3026, 195, 2704, 19966, 135, 5, 134, 2450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6202, 110, 109, 2428, 2429, 3027, 3004, 19944, 19967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6203, 3027, 3004, 19944, 19967, 3028, 3005, 19945, 19968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6204, 3028, 3005, 19945, 19968, 3029, 3006, 19946, 19969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6205, 3029, 3006, 19946, 19969, 3030, 3007, 19947, 19970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6206, 3030, 3007, 19947, 19970, 3031, 3008, 19948, 19971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6207, 3031, 3008, 19948, 19971, 3032, 3009, 19949, 19972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6208, 3032, 3009, 19949, 19972, 3033, 3010, 19950, 19973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6209, 3033, 3010, 19950, 19973, 3034, 3011, 19951, 19974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6210, 3034, 3011, 19951, 19974, 3035, 3012, 19952, 19975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6211, 3035, 3012, 19952, 19975, 3036, 3013, 19953, 19976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6212, 3036, 3013, 19953, 19976, 3037, 3014, 19954, 19977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6213, 3037, 3014, 19954, 19977, 3038, 3015, 19955, 19978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6214, 3038, 3015, 19955, 19978, 3039, 3016, 19956, 19979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6215, 3039, 3016, 19956, 19979, 3040, 3017, 19957, 19980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6216, 3040, 3017, 19957, 19980, 3041, 3018, 19958, 19981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6217, 3041, 3018, 19958, 19981, 3042, 3019, 19959, 19982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6218, 3042, 3019, 19959, 19982, 3043, 3020, 19960, 19983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6219, 3043, 3020, 19960, 19983, 3044, 3021, 19961, 19984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6220, 3044, 3021, 19961, 19984, 3045, 3022, 19962, 19985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6221, 3045, 3022, 19962, 19985, 3046, 3023, 19963, 19986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6222, 3046, 3023, 19963, 19986, 3047, 3024, 19964, 19987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6223, 3047, 3024, 19964, 19987, 3048, 3025, 19965, 19988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6224, 3048, 3025, 19965, 19988, 3049, 3026, 19966, 19989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6225, 3049, 3026, 19966, 19989, 136, 135, 2450, 2451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6226, 3, 110, 2429, 121, 219, 3027, 19967, 2715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6227, 219, 3027, 19967, 2715, 220, 3028, 19968, 2726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6228, 220, 3028, 19968, 2726, 221, 3029, 19969, 2737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6229, 221, 3029, 19969, 2737, 222, 3030, 19970, 2748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6230, 222, 3030, 19970, 2748, 223, 3031, 19971, 2759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6231, 223, 3031, 19971, 2759, 224, 3032, 19972, 2770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6232, 224, 3032, 19972, 2770, 225, 3033, 19973, 2781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6233, 225, 3033, 19973, 2781, 226, 3034, 19974, 2792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6234, 226, 3034, 19974, 2792, 227, 3035, 19975, 2803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6235, 227, 3035, 19975, 2803, 228, 3036, 19976, 2814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6236, 228, 3036, 19976, 2814, 229, 3037, 19977, 2825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6237, 229, 3037, 19977, 2825, 230, 3038, 19978, 2836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6238, 230, 3038, 19978, 2836, 231, 3039, 19979, 2847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6239, 231, 3039, 19979, 2847, 232, 3040, 19980, 2858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6240, 232, 3040, 19980, 2858, 233, 3041, 19981, 2869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6241, 233, 3041, 19981, 2869, 234, 3042, 19982, 2880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6242, 234, 3042, 19982, 2880, 235, 3043, 19983, 2891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6243, 235, 3043, 19983, 2891, 236, 3044, 19984, 2902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6244, 236, 3044, 19984, 2902, 237, 3045, 19985, 2913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6245, 237, 3045, 19985, 2913, 238, 3046, 19986, 2924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6246, 238, 3046, 19986, 2924, 239, 3047, 19987, 2935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6247, 239, 3047, 19987, 2935, 240, 3048, 19988, 2946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6248, 240, 3048, 19988, 2946, 241, 3049, 19989, 2957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6249, 241, 3049, 19989, 2957, 7, 136, 2451, 147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume2
6250, 4, 111, 2705, 196, 10, 299, 3050, 242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6251, 111, 112, 2706, 2705, 299, 300, 3051, 3050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6252, 112, 113, 2707, 2706, 300, 301, 3052, 3051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6253, 113, 114, 2708, 2707, 301, 302, 3053, 3052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6254, 114, 115, 2709, 2708, 302, 303, 3054, 3053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6255, 115, 116, 2710, 2709, 303, 304, 3055, 3054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6256, 116, 117, 2711, 2710, 304, 305, 3056, 3055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6257, 117, 118, 2712, 2711, 305, 306, 3057, 3056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6258, 118, 119, 2713, 2712, 306, 307, 3058, 3057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6259, 119, 120, 2714, 2713, 307, 308, 3059, 3058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6260, 120, 121, 2715, 2714, 308, 309, 3060, 3059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6261, 121, 3, 219, 2715, 309, 12, 276, 3060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6262, 196, 2705, 2716, 197, 242, 3050, 3061, 243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6263, 2705, 2706, 2717, 2716, 3050, 3051, 3062, 3061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6264, 2706, 2707, 2718, 2717, 3051, 3052, 3063, 3062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6265, 2707, 2708, 2719, 2718, 3052, 3053, 3064, 3063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6266, 2708, 2709, 2720, 2719, 3053, 3054, 3065, 3064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6267, 2709, 2710, 2721, 2720, 3054, 3055, 3066, 3065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6268, 2710, 2711, 2722, 2721, 3055, 3056, 3067, 3066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6269, 2711, 2712, 2723, 2722, 3056, 3057, 3068, 3067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6270, 2712, 2713, 2724, 2723, 3057, 3058, 3069, 3068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6271, 2713, 2714, 2725, 2724, 3058, 3059, 3070, 3069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6272, 2714, 2715, 2726, 2725, 3059, 3060, 3071, 3070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6273, 2715, 219, 220, 2726, 3060, 276, 277, 3071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6274, 197, 2716, 2727, 198, 243, 3061, 3072, 244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6275, 2716, 2717, 2728, 2727, 3061, 3062, 3073, 3072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6276, 2717, 2718, 2729, 2728, 3062, 3063, 3074, 3073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6277, 2718, 2719, 2730, 2729, 3063, 3064, 3075, 3074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6278, 2719, 2720, 2731, 2730, 3064, 3065, 3076, 3075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6279, 2720, 2721, 2732, 2731, 3065, 3066, 3077, 3076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6280, 2721, 2722, 2733, 2732, 3066, 3067, 3078, 3077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6281, 2722, 2723, 2734, 2733, 3067, 3068, 3079, 3078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6282, 2723, 2724, 2735, 2734, 3068, 3069, 3080, 3079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6283, 2724, 2725, 2736, 2735, 3069, 3070, 3081, 3080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6284, 2725, 2726, 2737, 2736, 3070, 3071, 3082, 3081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6285, 2726, 220, 221, 2737, 3071, 277, 278, 3082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6286, 198, 2727, 2738, 199, 244, 3072, 3083, 245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6287, 2727, 2728, 2739, 2738, 3072, 3073, 3084, 3083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6288, 2728, 2729, 2740, 2739, 3073, 3074, 3085, 3084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6289, 2729, 2730, 2741, 2740, 3074, 3075, 3086, 3085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6290, 2730, 2731, 2742, 2741, 3075, 3076, 3087, 3086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6291, 2731, 2732, 2743, 2742, 3076, 3077, 3088, 3087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6292, 2732, 2733, 2744, 2743, 3077, 3078, 3089, 3088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6293, 2733, 2734, 2745, 2744, 3078, 3079, 3090, 3089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6294, 2734, 2735, 2746, 2745, 3079, 3080, 3091, 3090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6295, 2735, 2736, 2747, 2746, 3080, 3081, 3092, 3091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6296, 2736, 2737, 2748, 2747, 3081, 3082, 3093, 3092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6297, 2737, 221, 222, 2748, 3082, 278, 279, 3093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6298, 199, 2738, 2749, 200, 245, 3083, 3094, 246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6299, 2738, 2739, 2750, 2749, 3083, 3084, 3095, 3094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6300, 2739, 2740, 2751, 2750, 3084, 3085, 3096, 3095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6301, 2740, 2741, 2752, 2751, 3085, 3086, 3097, 3096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6302, 2741, 2742, 2753, 2752, 3086, 3087, 3098, 3097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6303, 2742, 2743, 2754, 2753, 3087, 3088, 3099, 3098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6304, 2743, 2744, 2755, 2754, 3088, 3089, 3100, 3099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6305, 2744, 2745, 2756, 2755, 3089, 3090, 3101, 3100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6306, 2745, 2746, 2757, 2756, 3090, 3091, 3102, 3101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6307, 2746, 2747, 2758, 2757, 3091, 3092, 3103, 3102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6308, 2747, 2748, 2759, 2758, 3092, 3093, 3104, 3103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6309, 2748, 222, 223, 2759, 3093, 279, 280, 3104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6310, 200, 2749, 2760, 201, 246, 3094, 3105, 247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6311, 2749, 2750, 2761, 2760, 3094, 3095, 3106, 3105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6312, 2750, 2751, 2762, 2761, 3095, 3096, 3107, 3106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6313, 2751, 2752, 2763, 2762, 3096, 3097, 3108, 3107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6314, 2752, 2753, 2764, 2763, 3097, 3098, 3109, 3108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6315, 2753, 2754, 2765, 2764, 3098, 3099, 3110, 3109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6316, 2754, 2755, 2766, 2765, 3099, 3100, 3111, 3110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6317, 2755, 2756, 2767, 2766, 3100, 3101, 3112, 3111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6318, 2756, 2757, 2768, 2767, 3101, 3102, 3113, 3112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6319, 2757, 2758, 2769, 2768, 3102, 3103, 3114, 3113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6320, 2758, 2759, 2770, 2769, 3103, 3104, 3115, 3114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6321, 2759, 223, 224, 2770, 3104, 280, 281, 3115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6322, 201, 2760, 2771, 202, 247, 3105, 3116, 248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6323, 2760, 2761, 2772, 2771, 3105, 3106, 3117, 3116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6324, 2761, 2762, 2773, 2772, 3106, 3107, 3118, 3117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6325, 2762, 2763, 2774, 2773, 3107, 3108, 3119, 3118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6326, 2763, 2764, 2775, 2774, 3108, 3109, 3120, 3119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6327, 2764, 2765, 2776, 2775, 3109, 3110, 3121, 3120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6328, 2765, 2766, 2777, 2776, 3110, 3111, 3122, 3121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6329, 2766, 2767, 2778, 2777, 3111, 3112, 3123, 3122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6330, 2767, 2768, 2779, 2778, 3112, 3113, 3124, 3123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6331, 2768, 2769, 2780, 2779, 3113, 3114, 3125, 3124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6332, 2769, 2770, 2781, 2780, 3114, 3115, 3126, 3125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6333, 2770, 224, 225, 2781, 3115, 281, 282, 3126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6334, 202, 2771, 2782, 203, 248, 3116, 3127, 249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6335, 2771, 2772, 2783, 2782, 3116, 3117, 3128, 3127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6336, 2772, 2773, 2784, 2783, 3117, 3118, 3129, 3128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6337, 2773, 2774, 2785, 2784, 3118, 3119, 3130, 3129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6338, 2774, 2775, 2786, 2785, 3119, 3120, 3131, 3130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6339, 2775, 2776, 2787, 2786, 3120, 3121, 3132, 3131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6340, 2776, 2777, 2788, 2787, 3121, 3122, 3133, 3132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6341, 2777, 2778, 2789, 2788, 3122, 3123, 3134, 3133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6342, 2778, 2779, 2790, 2789, 3123, 3124, 3135, 3134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6343, 2779, 2780, 2791, 2790, 3124, 3125, 3136, 3135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6344, 2780, 2781, 2792, 2791, 3125, 3126, 3137, 3136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6345, 2781, 225, 226, 2792, 3126, 282, 283, 3137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6346, 203, 2782, 2793, 204, 249, 3127, 3138, 250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6347, 2782, 2783, 2794, 2793, 3127, 3128, 3139, 3138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6348, 2783, 2784, 2795, 2794, 3128, 3129, 3140, 3139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6349, 2784, 2785, 2796, 2795, 3129, 3130, 3141, 3140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6350, 2785, 2786, 2797, 2796, 3130, 3131, 3142, 3141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6351, 2786, 2787, 2798, 2797, 3131, 3132, 3143, 3142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6352, 2787, 2788, 2799, 2798, 3132, 3133, 3144, 3143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6353, 2788, 2789, 2800, 2799, 3133, 3134, 3145, 3144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6354, 2789, 2790, 2801, 2800, 3134, 3135, 3146, 3145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6355, 2790, 2791, 2802, 2801, 3135, 3136, 3147, 3146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6356, 2791, 2792, 2803, 2802, 3136, 3137, 3148, 3147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6357, 2792, 226, 227, 2803, 3137, 283, 284, 3148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6358, 204, 2793, 2804, 205, 250, 3138, 3149, 251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6359, 2793, 2794, 2805, 2804, 3138, 3139, 3150, 3149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6360, 2794, 2795, 2806, 2805, 3139, 3140, 3151, 3150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6361, 2795, 2796, 2807, 2806, 3140, 3141, 3152, 3151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6362, 2796, 2797, 2808, 2807, 3141, 3142, 3153, 3152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6363, 2797, 2798, 2809, 2808, 3142, 3143, 3154, 3153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6364, 2798, 2799, 2810, 2809, 3143, 3144, 3155, 3154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6365, 2799, 2800, 2811, 2810, 3144, 3145, 3156, 3155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6366, 2800, 2801, 2812, 2811, 3145, 3146, 3157, 3156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6367, 2801, 2802, 2813, 2812, 3146, 3147, 3158, 3157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6368, 2802, 2803, 2814, 2813, 3147, 3148, 3159, 3158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6369, 2803, 227, 228, 2814, 3148, 284, 285, 3159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6370, 205, 2804, 2815, 206, 251, 3149, 3160, 252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6371, 2804, 2805, 2816, 2815, 3149, 3150, 3161, 3160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6372, 2805, 2806, 2817, 2816, 3150, 3151, 3162, 3161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6373, 2806, 2807, 2818, 2817, 3151, 3152, 3163, 3162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6374, 2807, 2808, 2819, 2818, 3152, 3153, 3164, 3163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6375, 2808, 2809, 2820, 2819, 3153, 3154, 3165, 3164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6376, 2809, 2810, 2821, 2820, 3154, 3155, 3166, 3165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6377, 2810, 2811, 2822, 2821, 3155, 3156, 3167, 3166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6378, 2811, 2812, 2823, 2822, 3156, 3157, 3168, 3167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6379, 2812, 2813, 2824, 2823, 3157, 3158, 3169, 3168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6380, 2813, 2814, 2825, 2824, 3158, 3159, 3170, 3169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6381, 2814, 228, 229, 2825, 3159, 285, 286, 3170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6382, 206, 2815, 2826, 207, 252, 3160, 3171, 253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6383, 2815, 2816, 2827, 2826, 3160, 3161, 3172, 3171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6384, 2816, 2817, 2828, 2827, 3161, 3162, 3173, 3172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6385, 2817, 2818, 2829, 2828, 3162, 3163, 3174, 3173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6386, 2818, 2819, 2830, 2829, 3163, 3164, 3175, 3174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6387, 2819, 2820, 2831, 2830, 3164, 3165, 3176, 3175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6388, 2820, 2821, 2832, 2831, 3165, 3166, 3177, 3176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6389, 2821, 2822, 2833, 2832, 3166, 3167, 3178, 3177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6390, 2822, 2823, 2834, 2833, 3167, 3168, 3179, 3178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6391, 2823, 2824, 2835, 2834, 3168, 3169, 3180, 3179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6392, 2824, 2825, 2836, 2835, 3169, 3170, 3181, 3180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6393, 2825, 229, 230, 2836, 3170, 286, 287, 3181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6394, 207, 2826, 2837, 208, 253, 3171, 3182, 254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6395, 2826, 2827, 2838, 2837, 3171, 3172, 3183, 3182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6396, 2827, 2828, 2839, 2838, 3172, 3173, 3184, 3183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6397, 2828, 2829, 2840, 2839, 3173, 3174, 3185, 3184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6398, 2829, 2830, 2841, 2840, 3174, 3175, 3186, 3185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6399, 2830, 2831, 2842, 2841, 3175, 3176, 3187, 3186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6400, 2831, 2832, 2843, 2842, 3176, 3177, 3188, 3187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6401, 2832, 2833, 2844, 2843, 3177, 3178, 3189, 3188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6402, 2833, 2834, 2845, 2844, 3178, 3179, 3190, 3189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6403, 2834, 2835, 2846, 2845, 3179, 3180, 3191, 3190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6404, 2835, 2836, 2847, 2846, 3180, 3181, 3192, 3191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6405, 2836, 230, 231, 2847, 3181, 287, 288, 3192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6406, 208, 2837, 2848, 209, 254, 3182, 3193, 255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6407, 2837, 2838, 2849, 2848, 3182, 3183, 3194, 3193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6408, 2838, 2839, 2850, 2849, 3183, 3184, 3195, 3194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6409, 2839, 2840, 2851, 2850, 3184, 3185, 3196, 3195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6410, 2840, 2841, 2852, 2851, 3185, 3186, 3197, 3196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6411, 2841, 2842, 2853, 2852, 3186, 3187, 3198, 3197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6412, 2842, 2843, 2854, 2853, 3187, 3188, 3199, 3198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6413, 2843, 2844, 2855, 2854, 3188, 3189, 3200, 3199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6414, 2844, 2845, 2856, 2855, 3189, 3190, 3201, 3200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6415, 2845, 2846, 2857, 2856, 3190, 3191, 3202, 3201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6416, 2846, 2847, 2858, 2857, 3191, 3192, 3203, 3202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6417, 2847, 231, 232, 2858, 3192, 288, 289, 3203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6418, 209, 2848, 2859, 210, 255, 3193, 3204, 256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6419, 2848, 2849, 2860, 2859, 3193, 3194, 3205, 3204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6420, 2849, 2850, 2861, 2860, 3194, 3195, 3206, 3205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6421, 2850, 2851, 2862, 2861, 3195, 3196, 3207, 3206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6422, 2851, 2852, 2863, 2862, 3196, 3197, 3208, 3207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6423, 2852, 2853, 2864, 2863, 3197, 3198, 3209, 3208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6424, 2853, 2854, 2865, 2864, 3198, 3199, 3210, 3209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6425, 2854, 2855, 2866, 2865, 3199, 3200, 3211, 3210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6426, 2855, 2856, 2867, 2866, 3200, 3201, 3212, 3211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6427, 2856, 2857, 2868, 2867, 3201, 3202, 3213, 3212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6428, 2857, 2858, 2869, 2868, 3202, 3203, 3214, 3213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6429, 2858, 232, 233, 2869, 3203, 289, 290, 3214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6430, 210, 2859, 2870, 211, 256, 3204, 3215, 257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6431, 2859, 2860, 2871, 2870, 3204, 3205, 3216, 3215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6432, 2860, 2861, 2872, 2871, 3205, 3206, 3217, 3216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6433, 2861, 2862, 2873, 2872, 3206, 3207, 3218, 3217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6434, 2862, 2863, 2874, 2873, 3207, 3208, 3219, 3218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6435, 2863, 2864, 2875, 2874, 3208, 3209, 3220, 3219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6436, 2864, 2865, 2876, 2875, 3209, 3210, 3221, 3220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6437, 2865, 2866, 2877, 2876, 3210, 3211, 3222, 3221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6438, 2866, 2867, 2878, 2877, 3211, 3212, 3223, 3222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6439, 2867, 2868, 2879, 2878, 3212, 3213, 3224, 3223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6440, 2868, 2869, 2880, 2879, 3213, 3214, 3225, 3224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6441, 2869, 233, 234, 2880, 3214, 290, 291, 3225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6442, 211, 2870, 2881, 212, 257, 3215, 3226, 258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6443, 2870, 2871, 2882, 2881, 3215, 3216, 3227, 3226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6444, 2871, 2872, 2883, 2882, 3216, 3217, 3228, 3227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6445, 2872, 2873, 2884, 2883, 3217, 3218, 3229, 3228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6446, 2873, 2874, 2885, 2884, 3218, 3219, 3230, 3229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6447, 2874, 2875, 2886, 2885, 3219, 3220, 3231, 3230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6448, 2875, 2876, 2887, 2886, 3220, 3221, 3232, 3231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6449, 2876, 2877, 2888, 2887, 3221, 3222, 3233, 3232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6450, 2877, 2878, 2889, 2888, 3222, 3223, 3234, 3233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6451, 2878, 2879, 2890, 2889, 3223, 3224, 3235, 3234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6452, 2879, 2880, 2891, 2890, 3224, 3225, 3236, 3235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6453, 2880, 234, 235, 2891, 3225, 291, 292, 3236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6454, 212, 2881, 2892, 213, 258, 3226, 3237, 259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6455, 2881, 2882, 2893, 2892, 3226, 3227, 3238, 3237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6456, 2882, 2883, 2894, 2893, 3227, 3228, 3239, 3238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6457, 2883, 2884, 2895, 2894, 3228, 3229, 3240, 3239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6458, 2884, 2885, 2896, 2895, 3229, 3230, 3241, 3240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6459, 2885, 2886, 2897, 2896, 3230, 3231, 3242, 3241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6460, 2886, 2887, 2898, 2897, 3231, 3232, 3243, 3242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6461, 2887, 2888, 2899, 2898, 3232, 3233, 3244, 3243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6462, 2888, 2889, 2900, 2899, 3233, 3234, 3245, 3244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6463, 2889, 2890, 2901, 2900, 3234, 3235, 3246, 3245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6464, 2890, 2891, 2902, 2901, 3235, 3236, 3247, 3246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6465, 2891, 235, 236, 2902, 3236, 292, 293, 3247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6466, 213, 2892, 2903, 214, 259, 3237, 3248, 260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6467, 2892, 2893, 2904, 2903, 3237, 3238, 3249, 3248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6468, 2893, 2894, 2905, 2904, 3238, 3239, 3250, 3249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6469, 2894, 2895, 2906, 2905, 3239, 3240, 3251, 3250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6470, 2895, 2896, 2907, 2906, 3240, 3241, 3252, 3251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6471, 2896, 2897, 2908, 2907, 3241, 3242, 3253, 3252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6472, 2897, 2898, 2909, 2908, 3242, 3243, 3254, 3253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6473, 2898, 2899, 2910, 2909, 3243, 3244, 3255, 3254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6474, 2899, 2900, 2911, 2910, 3244, 3245, 3256, 3255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6475, 2900, 2901, 2912, 2911, 3245, 3246, 3257, 3256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6476, 2901, 2902, 2913, 2912, 3246, 3247, 3258, 3257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6477, 2902, 236, 237, 2913, 3247, 293, 294, 3258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6478, 214, 2903, 2914, 215, 260, 3248, 3259, 261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6479, 2903, 2904, 2915, 2914, 3248, 3249, 3260, 3259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6480, 2904, 2905, 2916, 2915, 3249, 3250, 3261, 3260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6481, 2905, 2906, 2917, 2916, 3250, 3251, 3262, 3261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6482, 2906, 2907, 2918, 2917, 3251, 3252, 3263, 3262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6483, 2907, 2908, 2919, 2918, 3252, 3253, 3264, 3263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6484, 2908, 2909, 2920, 2919, 3253, 3254, 3265, 3264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6485, 2909, 2910, 2921, 2920, 3254, 3255, 3266, 3265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6486, 2910, 2911, 2922, 2921, 3255, 3256, 3267, 3266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6487, 2911, 2912, 2923, 2922, 3256, 3257, 3268, 3267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6488, 2912, 2913, 2924, 2923, 3257, 3258, 3269, 3268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6489, 2913, 237, 238, 2924, 3258, 294, 295, 3269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6490, 215, 2914, 2925, 216, 261, 3259, 3270, 262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6491, 2914, 2915, 2926, 2925, 3259, 3260, 3271, 3270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6492, 2915, 2916, 2927, 2926, 3260, 3261, 3272, 3271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6493, 2916, 2917, 2928, 2927, 3261, 3262, 3273, 3272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6494, 2917, 2918, 2929, 2928, 3262, 3263, 3274, 3273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6495, 2918, 2919, 2930, 2929, 3263, 3264, 3275, 3274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6496, 2919, 2920, 2931, 2930, 3264, 3265, 3276, 3275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6497, 2920, 2921, 2932, 2931, 3265, 3266, 3277, 3276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6498, 2921, 2922, 2933, 2932, 3266, 3267, 3278, 3277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6499, 2922, 2923, 2934, 2933, 3267, 3268, 3279, 3278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6500, 2923, 2924, 2935, 2934, 3268, 3269, 3280, 3279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6501, 2924, 238, 239, 2935, 3269, 295, 296, 3280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6502, 216, 2925, 2936, 217, 262, 3270, 3281, 263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6503, 2925, 2926, 2937, 2936, 3270, 3271, 3282, 3281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6504, 2926, 2927, 2938, 2937, 3271, 3272, 3283, 3282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6505, 2927, 2928, 2939, 2938, 3272, 3273, 3284, 3283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6506, 2928, 2929, 2940, 2939, 3273, 3274, 3285, 3284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6507, 2929, 2930, 2941, 2940, 3274, 3275, 3286, 3285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6508, 2930, 2931, 2942, 2941, 3275, 3276, 3287, 3286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6509, 2931, 2932, 2943, 2942, 3276, 3277, 3288, 3287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6510, 2932, 2933, 2944, 2943, 3277, 3278, 3289, 3288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6511, 2933, 2934, 2945, 2944, 3278, 3279, 3290, 3289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6512, 2934, 2935, 2946, 2945, 3279, 3280, 3291, 3290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6513, 2935, 239, 240, 2946, 3280, 296, 297, 3291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6514, 217, 2936, 2947, 218, 263, 3281, 3292, 264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6515, 2936, 2937, 2948, 2947, 3281, 3282, 3293, 3292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6516, 2937, 2938, 2949, 2948, 3282, 3283, 3294, 3293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6517, 2938, 2939, 2950, 2949, 3283, 3284, 3295, 3294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6518, 2939, 2940, 2951, 2950, 3284, 3285, 3296, 3295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6519, 2940, 2941, 2952, 2951, 3285, 3286, 3297, 3296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6520, 2941, 2942, 2953, 2952, 3286, 3287, 3298, 3297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6521, 2942, 2943, 2954, 2953, 3287, 3288, 3299, 3298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6522, 2943, 2944, 2955, 2954, 3288, 3289, 3300, 3299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6523, 2944, 2945, 2956, 2955, 3289, 3290, 3301, 3300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6524, 2945, 2946, 2957, 2956, 3290, 3291, 3302, 3301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6525, 2946, 240, 241, 2957, 3291, 297, 298, 3302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6526, 218, 2947, 137, 8, 264, 3292, 265, 9, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6527, 2947, 2948, 138, 137, 3292, 3293, 266, 265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6528, 2948, 2949, 139, 138, 3293, 3294, 267, 266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6529, 2949, 2950, 140, 139, 3294, 3295, 268, 267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6530, 2950, 2951, 141, 140, 3295, 3296, 269, 268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6531, 2951, 2952, 142, 141, 3296, 3297, 270, 269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6532, 2952, 2953, 143, 142, 3297, 3298, 271, 270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6533, 2953, 2954, 144, 143, 3298, 3299, 272, 271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6534, 2954, 2955, 145, 144, 3299, 3300, 273, 272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6535, 2955, 2956, 146, 145, 3300, 3301, 274, 273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6536, 2956, 2957, 147, 146, 3301, 3302, 275, 274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6537, 2957, 241, 7, 147, 3302, 298, 11, 275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume3
6538, 10, 299, 3050, 242, 333, 4614, 19990, 3303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6539, 333, 4614, 19990, 3303, 334, 4615, 19991, 3304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6540, 334, 4615, 19991, 3304, 335, 4616, 19992, 3305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6541, 335, 4616, 19992, 3305, 336, 4617, 19993, 3306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6542, 336, 4617, 19993, 3306, 337, 4618, 19994, 3307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6543, 337, 4618, 19994, 3307, 338, 4619, 19995, 3308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6544, 338, 4619, 19995, 3308, 339, 4620, 19996, 3309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6545, 339, 4620, 19996, 3309, 340, 4621, 19997, 3310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6546, 340, 4621, 19997, 3310, 341, 4622, 19998, 3311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6547, 341, 4622, 19998, 3311, 342, 4623, 19999, 3312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6548, 342, 4623, 19999, 3312, 343, 4624, 20000, 3313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6549, 343, 4624, 20000, 3313, 344, 4625, 20001, 3314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6550, 344, 4625, 20001, 3314, 345, 4626, 20002, 3315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6551, 345, 4626, 20002, 3315, 346, 4627, 20003, 3316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6552, 346, 4627, 20003, 3316, 347, 4628, 20004, 3317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6553, 347, 4628, 20004, 3317, 348, 4629, 20005, 3318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6554, 348, 4629, 20005, 3318, 349, 4630, 20006, 3319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6555, 349, 4630, 20006, 3319, 350, 4631, 20007, 3320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6556, 350, 4631, 20007, 3320, 351, 4632, 20008, 3321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6557, 351, 4632, 20008, 3321, 352, 4633, 20009, 3322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6558, 352, 4633, 20009, 3322, 353, 4634, 20010, 3323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6559, 353, 4634, 20010, 3323, 354, 4635, 20011, 3324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6560, 354, 4635, 20011, 3324, 355, 4636, 20012, 3325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6561, 355, 4636, 20012, 3325, 14, 459, 4867, 356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6562, 299, 300, 3051, 3050, 4614, 4637, 20013, 19990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6563, 4614, 4637, 20013, 19990, 4615, 4638, 20014, 19991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6564, 4615, 4638, 20014, 19991, 4616, 4639, 20015, 19992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6565, 4616, 4639, 20015, 19992, 4617, 4640, 20016, 19993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6566, 4617, 4640, 20016, 19993, 4618, 4641, 20017, 19994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6567, 4618, 4641, 20017, 19994, 4619, 4642, 20018, 19995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6568, 4619, 4642, 20018, 19995, 4620, 4643, 20019, 19996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6569, 4620, 4643, 20019, 19996, 4621, 4644, 20020, 19997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6570, 4621, 4644, 20020, 19997, 4622, 4645, 20021, 19998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6571, 4622, 4645, 20021, 19998, 4623, 4646, 20022, 19999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6572, 4623, 4646, 20022, 19999, 4624, 4647, 20023, 20000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6573, 4624, 4647, 20023, 20000, 4625, 4648, 20024, 20001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6574, 4625, 4648, 20024, 20001, 4626, 4649, 20025, 20002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6575, 4626, 4649, 20025, 20002, 4627, 4650, 20026, 20003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6576, 4627, 4650, 20026, 20003, 4628, 4651, 20027, 20004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6577, 4628, 4651, 20027, 20004, 4629, 4652, 20028, 20005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6578, 4629, 4652, 20028, 20005, 4630, 4653, 20029, 20006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6579, 4630, 4653, 20029, 20006, 4631, 4654, 20030, 20007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6580, 4631, 4654, 20030, 20007, 4632, 4655, 20031, 20008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6581, 4632, 4655, 20031, 20008, 4633, 4656, 20032, 20009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6582, 4633, 4656, 20032, 20009, 4634, 4657, 20033, 20010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6583, 4634, 4657, 20033, 20010, 4635, 4658, 20034, 20011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6584, 4635, 4658, 20034, 20011, 4636, 4659, 20035, 20012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6585, 4636, 4659, 20035, 20012, 459, 460, 4868, 4867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6586, 300, 301, 3052, 3051, 4637, 4660, 20036, 20013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6587, 4637, 4660, 20036, 20013, 4638, 4661, 20037, 20014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6588, 4638, 4661, 20037, 20014, 4639, 4662, 20038, 20015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6589, 4639, 4662, 20038, 20015, 4640, 4663, 20039, 20016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6590, 4640, 4663, 20039, 20016, 4641, 4664, 20040, 20017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6591, 4641, 4664, 20040, 20017, 4642, 4665, 20041, 20018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6592, 4642, 4665, 20041, 20018, 4643, 4666, 20042, 20019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6593, 4643, 4666, 20042, 20019, 4644, 4667, 20043, 20020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6594, 4644, 4667, 20043, 20020, 4645, 4668, 20044, 20021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6595, 4645, 4668, 20044, 20021, 4646, 4669, 20045, 20022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6596, 4646, 4669, 20045, 20022, 4647, 4670, 20046, 20023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6597, 4647, 4670, 20046, 20023, 4648, 4671, 20047, 20024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6598, 4648, 4671, 20047, 20024, 4649, 4672, 20048, 20025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6599, 4649, 4672, 20048, 20025, 4650, 4673, 20049, 20026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6600, 4650, 4673, 20049, 20026, 4651, 4674, 20050, 20027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6601, 4651, 4674, 20050, 20027, 4652, 4675, 20051, 20028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6602, 4652, 4675, 20051, 20028, 4653, 4676, 20052, 20029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6603, 4653, 4676, 20052, 20029, 4654, 4677, 20053, 20030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6604, 4654, 4677, 20053, 20030, 4655, 4678, 20054, 20031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6605, 4655, 4678, 20054, 20031, 4656, 4679, 20055, 20032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6606, 4656, 4679, 20055, 20032, 4657, 4680, 20056, 20033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6607, 4657, 4680, 20056, 20033, 4658, 4681, 20057, 20034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6608, 4658, 4681, 20057, 20034, 4659, 4682, 20058, 20035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6609, 4659, 4682, 20058, 20035, 460, 461, 4869, 4868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6610, 301, 302, 3053, 3052, 4660, 4683, 20059, 20036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6611, 4660, 4683, 20059, 20036, 4661, 4684, 20060, 20037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6612, 4661, 4684, 20060, 20037, 4662, 4685, 20061, 20038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6613, 4662, 4685, 20061, 20038, 4663, 4686, 20062, 20039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6614, 4663, 4686, 20062, 20039, 4664, 4687, 20063, 20040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6615, 4664, 4687, 20063, 20040, 4665, 4688, 20064, 20041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6616, 4665, 4688, 20064, 20041, 4666, 4689, 20065, 20042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6617, 4666, 4689, 20065, 20042, 4667, 4690, 20066, 20043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6618, 4667, 4690, 20066, 20043, 4668, 4691, 20067, 20044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6619, 4668, 4691, 20067, 20044, 4669, 4692, 20068, 20045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6620, 4669, 4692, 20068, 20045, 4670, 4693, 20069, 20046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6621, 4670, 4693, 20069, 20046, 4671, 4694, 20070, 20047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6622, 4671, 4694, 20070, 20047, 4672, 4695, 20071, 20048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6623, 4672, 4695, 20071, 20048, 4673, 4696, 20072, 20049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6624, 4673, 4696, 20072, 20049, 4674, 4697, 20073, 20050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6625, 4674, 4697, 20073, 20050, 4675, 4698, 20074, 20051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6626, 4675, 4698, 20074, 20051, 4676, 4699, 20075, 20052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6627, 4676, 4699, 20075, 20052, 4677, 4700, 20076, 20053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6628, 4677, 4700, 20076, 20053, 4678, 4701, 20077, 20054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6629, 4678, 4701, 20077, 20054, 4679, 4702, 20078, 20055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6630, 4679, 4702, 20078, 20055, 4680, 4703, 20079, 20056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6631, 4680, 4703, 20079, 20056, 4681, 4704, 20080, 20057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6632, 4681, 4704, 20080, 20057, 4682, 4705, 20081, 20058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6633, 4682, 4705, 20081, 20058, 461, 462, 4870, 4869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6634, 302, 303, 3054, 3053, 4683, 4706, 20082, 20059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6635, 4683, 4706, 20082, 20059, 4684, 4707, 20083, 20060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6636, 4684, 4707, 20083, 20060, 4685, 4708, 20084, 20061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6637, 4685, 4708, 20084, 20061, 4686, 4709, 20085, 20062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6638, 4686, 4709, 20085, 20062, 4687, 4710, 20086, 20063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6639, 4687, 4710, 20086, 20063, 4688, 4711, 20087, 20064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6640, 4688, 4711, 20087, 20064, 4689, 4712, 20088, 20065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6641, 4689, 4712, 20088, 20065, 4690, 4713, 20089, 20066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6642, 4690, 4713, 20089, 20066, 4691, 4714, 20090, 20067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6643, 4691, 4714, 20090, 20067, 4692, 4715, 20091, 20068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6644, 4692, 4715, 20091, 20068, 4693, 4716, 20092, 20069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6645, 4693, 4716, 20092, 20069, 4694, 4717, 20093, 20070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6646, 4694, 4717, 20093, 20070, 4695, 4718, 20094, 20071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6647, 4695, 4718, 20094, 20071, 4696, 4719, 20095, 20072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6648, 4696, 4719, 20095, 20072, 4697, 4720, 20096, 20073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6649, 4697, 4720, 20096, 20073, 4698, 4721, 20097, 20074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6650, 4698, 4721, 20097, 20074, 4699, 4722, 20098, 20075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6651, 4699, 4722, 20098, 20075, 4700, 4723, 20099, 20076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6652, 4700, 4723, 20099, 20076, 4701, 4724, 20100, 20077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6653, 4701, 4724, 20100, 20077, 4702, 4725, 20101, 20078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6654, 4702, 4725, 20101, 20078, 4703, 4726, 20102, 20079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6655, 4703, 4726, 20102, 20079, 4704, 4727, 20103, 20080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6656, 4704, 4727, 20103, 20080, 4705, 4728, 20104, 20081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6657, 4705, 4728, 20104, 20081, 462, 463, 4871, 4870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6658, 303, 304, 3055, 3054, 4706, 4729, 20105, 20082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6659, 4706, 4729, 20105, 20082, 4707, 4730, 20106, 20083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6660, 4707, 4730, 20106, 20083, 4708, 4731, 20107, 20084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6661, 4708, 4731, 20107, 20084, 4709, 4732, 20108, 20085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6662, 4709, 4732, 20108, 20085, 4710, 4733, 20109, 20086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6663, 4710, 4733, 20109, 20086, 4711, 4734, 20110, 20087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6664, 4711, 4734, 20110, 20087, 4712, 4735, 20111, 20088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6665, 4712, 4735, 20111, 20088, 4713, 4736, 20112, 20089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6666, 4713, 4736, 20112, 20089, 4714, 4737, 20113, 20090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6667, 4714, 4737, 20113, 20090, 4715, 4738, 20114, 20091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6668, 4715, 4738, 20114, 20091, 4716, 4739, 20115, 20092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6669, 4716, 4739, 20115, 20092, 4717, 4740, 20116, 20093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6670, 4717, 4740, 20116, 20093, 4718, 4741, 20117, 20094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6671, 4718, 4741, 20117, 20094, 4719, 4742, 20118, 20095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6672, 4719, 4742, 20118, 20095, 4720, 4743, 20119, 20096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6673, 4720, 4743, 20119, 20096, 4721, 4744, 20120, 20097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6674, 4721, 4744, 20120, 20097, 4722, 4745, 20121, 20098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6675, 4722, 4745, 20121, 20098, 4723, 4746, 20122, 20099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6676, 4723, 4746, 20122, 20099, 4724, 4747, 20123, 20100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6677, 4724, 4747, 20123, 20100, 4725, 4748, 20124, 20101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6678, 4725, 4748, 20124, 20101, 4726, 4749, 20125, 20102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6679, 4726, 4749, 20125, 20102, 4727, 4750, 20126, 20103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6680, 4727, 4750, 20126, 20103, 4728, 4751, 20127, 20104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6681, 4728, 4751, 20127, 20104, 463, 464, 4872, 4871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6682, 304, 305, 3056, 3055, 4729, 4752, 20128, 20105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6683, 4729, 4752, 20128, 20105, 4730, 4753, 20129, 20106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6684, 4730, 4753, 20129, 20106, 4731, 4754, 20130, 20107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6685, 4731, 4754, 20130, 20107, 4732, 4755, 20131, 20108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6686, 4732, 4755, 20131, 20108, 4733, 4756, 20132, 20109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6687, 4733, 4756, 20132, 20109, 4734, 4757, 20133, 20110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6688, 4734, 4757, 20133, 20110, 4735, 4758, 20134, 20111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6689, 4735, 4758, 20134, 20111, 4736, 4759, 20135, 20112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6690, 4736, 4759, 20135, 20112, 4737, 4760, 20136, 20113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6691, 4737, 4760, 20136, 20113, 4738, 4761, 20137, 20114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6692, 4738, 4761, 20137, 20114, 4739, 4762, 20138, 20115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6693, 4739, 4762, 20138, 20115, 4740, 4763, 20139, 20116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6694, 4740, 4763, 20139, 20116, 4741, 4764, 20140, 20117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6695, 4741, 4764, 20140, 20117, 4742, 4765, 20141, 20118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6696, 4742, 4765, 20141, 20118, 4743, 4766, 20142, 20119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6697, 4743, 4766, 20142, 20119, 4744, 4767, 20143, 20120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6698, 4744, 4767, 20143, 20120, 4745, 4768, 20144, 20121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6699, 4745, 4768, 20144, 20121, 4746, 4769, 20145, 20122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6700, 4746, 4769, 20145, 20122, 4747, 4770, 20146, 20123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6701, 4747, 4770, 20146, 20123, 4748, 4771, 20147, 20124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6702, 4748, 4771, 20147, 20124, 4749, 4772, 20148, 20125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6703, 4749, 4772, 20148, 20125, 4750, 4773, 20149, 20126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6704, 4750, 4773, 20149, 20126, 4751, 4774, 20150, 20127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6705, 4751, 4774, 20150, 20127, 464, 465, 4873, 4872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6706, 305, 306, 3057, 3056, 4752, 4775, 20151, 20128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6707, 4752, 4775, 20151, 20128, 4753, 4776, 20152, 20129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6708, 4753, 4776, 20152, 20129, 4754, 4777, 20153, 20130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6709, 4754, 4777, 20153, 20130, 4755, 4778, 20154, 20131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6710, 4755, 4778, 20154, 20131, 4756, 4779, 20155, 20132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6711, 4756, 4779, 20155, 20132, 4757, 4780, 20156, 20133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6712, 4757, 4780, 20156, 20133, 4758, 4781, 20157, 20134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6713, 4758, 4781, 20157, 20134, 4759, 4782, 20158, 20135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6714, 4759, 4782, 20158, 20135, 4760, 4783, 20159, 20136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6715, 4760, 4783, 20159, 20136, 4761, 4784, 20160, 20137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6716, 4761, 4784, 20160, 20137, 4762, 4785, 20161, 20138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6717, 4762, 4785, 20161, 20138, 4763, 4786, 20162, 20139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6718, 4763, 4786, 20162, 20139, 4764, 4787, 20163, 20140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6719, 4764, 4787, 20163, 20140, 4765, 4788, 20164, 20141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6720, 4765, 4788, 20164, 20141, 4766, 4789, 20165, 20142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6721, 4766, 4789, 20165, 20142, 4767, 4790, 20166, 20143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6722, 4767, 4790, 20166, 20143, 4768, 4791, 20167, 20144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6723, 4768, 4791, 20167, 20144, 4769, 4792, 20168, 20145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6724, 4769, 4792, 20168, 20145, 4770, 4793, 20169, 20146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6725, 4770, 4793, 20169, 20146, 4771, 4794, 20170, 20147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6726, 4771, 4794, 20170, 20147, 4772, 4795, 20171, 20148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6727, 4772, 4795, 20171, 20148, 4773, 4796, 20172, 20149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6728, 4773, 4796, 20172, 20149, 4774, 4797, 20173, 20150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6729, 4774, 4797, 20173, 20150, 465, 466, 4874, 4873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6730, 306, 307, 3058, 3057, 4775, 4798, 20174, 20151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6731, 4775, 4798, 20174, 20151, 4776, 4799, 20175, 20152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6732, 4776, 4799, 20175, 20152, 4777, 4800, 20176, 20153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6733, 4777, 4800, 20176, 20153, 4778, 4801, 20177, 20154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6734, 4778, 4801, 20177, 20154, 4779, 4802, 20178, 20155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6735, 4779, 4802, 20178, 20155, 4780, 4803, 20179, 20156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6736, 4780, 4803, 20179, 20156, 4781, 4804, 20180, 20157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6737, 4781, 4804, 20180, 20157, 4782, 4805, 20181, 20158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6738, 4782, 4805, 20181, 20158, 4783, 4806, 20182, 20159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6739, 4783, 4806, 20182, 20159, 4784, 4807, 20183, 20160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6740, 4784, 4807, 20183, 20160, 4785, 4808, 20184, 20161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6741, 4785, 4808, 20184, 20161, 4786, 4809, 20185, 20162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6742, 4786, 4809, 20185, 20162, 4787, 4810, 20186, 20163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6743, 4787, 4810, 20186, 20163, 4788, 4811, 20187, 20164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6744, 4788, 4811, 20187, 20164, 4789, 4812, 20188, 20165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6745, 4789, 4812, 20188, 20165, 4790, 4813, 20189, 20166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6746, 4790, 4813, 20189, 20166, 4791, 4814, 20190, 20167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6747, 4791, 4814, 20190, 20167, 4792, 4815, 20191, 20168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6748, 4792, 4815, 20191, 20168, 4793, 4816, 20192, 20169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6749, 4793, 4816, 20192, 20169, 4794, 4817, 20193, 20170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6750, 4794, 4817, 20193, 20170, 4795, 4818, 20194, 20171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6751, 4795, 4818, 20194, 20171, 4796, 4819, 20195, 20172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6752, 4796, 4819, 20195, 20172, 4797, 4820, 20196, 20173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6753, 4797, 4820, 20196, 20173, 466, 467, 4875, 4874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6754, 307, 308, 3059, 3058, 4798, 4821, 20197, 20174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6755, 4798, 4821, 20197, 20174, 4799, 4822, 20198, 20175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6756, 4799, 4822, 20198, 20175, 4800, 4823, 20199, 20176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6757, 4800, 4823, 20199, 20176, 4801, 4824, 20200, 20177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6758, 4801, 4824, 20200, 20177, 4802, 4825, 20201, 20178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6759, 4802, 4825, 20201, 20178, 4803, 4826, 20202, 20179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6760, 4803, 4826, 20202, 20179, 4804, 4827, 20203, 20180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6761, 4804, 4827, 20203, 20180, 4805, 4828, 20204, 20181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6762, 4805, 4828, 20204, 20181, 4806, 4829, 20205, 20182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6763, 4806, 4829, 20205, 20182, 4807, 4830, 20206, 20183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6764, 4807, 4830, 20206, 20183, 4808, 4831, 20207, 20184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6765, 4808, 4831, 20207, 20184, 4809, 4832, 20208, 20185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6766, 4809, 4832, 20208, 20185, 4810, 4833, 20209, 20186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6767, 4810, 4833, 20209, 20186, 4811, 4834, 20210, 20187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6768, 4811, 4834, 20210, 20187, 4812, 4835, 20211, 20188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6769, 4812, 4835, 20211, 20188, 4813, 4836, 20212, 20189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6770, 4813, 4836, 20212, 20189, 4814, 4837, 20213, 20190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6771, 4814, 4837, 20213, 20190, 4815, 4838, 20214, 20191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6772, 4815, 4838, 20214, 20191, 4816, 4839, 20215, 20192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6773, 4816, 4839, 20215, 20192, 4817, 4840, 20216, 20193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6774, 4817, 4840, 20216, 20193, 4818, 4841, 20217, 20194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6775, 4818, 4841, 20217, 20194, 4819, 4842, 20218, 20195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6776, 4819, 4842, 20218, 20195, 4820, 4843, 20219, 20196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6777, 4820, 4843, 20219, 20196, 467, 468, 4876, 4875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6778, 308, 309, 3060, 3059, 4821, 4844, 20220, 20197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6779, 4821, 4844, 20220, 20197, 4822, 4845, 20221, 20198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6780, 4822, 4845, 20221, 20198, 4823, 4846, 20222, 20199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6781, 4823, 4846, 20222, 20199, 4824, 4847, 20223, 20200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6782, 4824, 4847, 20223, 20200, 4825, 4848, 20224, 20201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6783, 4825, 4848, 20224, 20201, 4826, 4849, 20225, 20202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6784, 4826, 4849, 20225, 20202, 4827, 4850, 20226, 20203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6785, 4827, 4850, 20226, 20203, 4828, 4851, 20227, 20204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6786, 4828, 4851, 20227, 20204, 4829, 4852, 20228, 20205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6787, 4829, 4852, 20228, 20205, 4830, 4853, 20229, 20206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6788, 4830, 4853, 20229, 20206, 4831, 4854, 20230, 20207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6789, 4831, 4854, 20230, 20207, 4832, 4855, 20231, 20208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6790, 4832, 4855, 20231, 20208, 4833, 4856, 20232, 20209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6791, 4833, 4856, 20232, 20209, 4834, 4857, 20233, 20210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6792, 4834, 4857, 20233, 20210, 4835, 4858, 20234, 20211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6793, 4835, 4858, 20234, 20211, 4836, 4859, 20235, 20212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6794, 4836, 4859, 20235, 20212, 4837, 4860, 20236, 20213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6795, 4837, 4860, 20236, 20213, 4838, 4861, 20237, 20214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6796, 4838, 4861, 20237, 20214, 4839, 4862, 20238, 20215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6797, 4839, 4862, 20238, 20215, 4840, 4863, 20239, 20216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6798, 4840, 4863, 20239, 20216, 4841, 4864, 20240, 20217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6799, 4841, 4864, 20240, 20217, 4842, 4865, 20241, 20218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6800, 4842, 4865, 20241, 20218, 4843, 4866, 20242, 20219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6801, 4843, 4866, 20242, 20219, 468, 469, 4877, 4876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6802, 309, 12, 276, 3060, 4844, 413, 4085, 20220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6803, 4844, 413, 4085, 20220, 4845, 414, 4086, 20221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6804, 4845, 414, 4086, 20221, 4846, 415, 4087, 20222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6805, 4846, 415, 4087, 20222, 4847, 416, 4088, 20223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6806, 4847, 416, 4088, 20223, 4848, 417, 4089, 20224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6807, 4848, 417, 4089, 20224, 4849, 418, 4090, 20225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6808, 4849, 418, 4090, 20225, 4850, 419, 4091, 20226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6809, 4850, 419, 4091, 20226, 4851, 420, 4092, 20227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6810, 4851, 420, 4092, 20227, 4852, 421, 4093, 20228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6811, 4852, 421, 4093, 20228, 4853, 422, 4094, 20229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6812, 4853, 422, 4094, 20229, 4854, 423, 4095, 20230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6813, 4854, 423, 4095, 20230, 4855, 424, 4096, 20231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6814, 4855, 424, 4096, 20231, 4856, 425, 4097, 20232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6815, 4856, 425, 4097, 20232, 4857, 426, 4098, 20233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6816, 4857, 426, 4098, 20233, 4858, 427, 4099, 20234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6817, 4858, 427, 4099, 20234, 4859, 428, 4100, 20235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6818, 4859, 428, 4100, 20235, 4860, 429, 4101, 20236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6819, 4860, 429, 4101, 20236, 4861, 430, 4102, 20237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6820, 4861, 430, 4102, 20237, 4862, 431, 4103, 20238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6821, 4862, 431, 4103, 20238, 4863, 432, 4104, 20239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6822, 4863, 432, 4104, 20239, 4864, 433, 4105, 20240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6823, 4864, 433, 4105, 20240, 4865, 434, 4106, 20241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6824, 4865, 434, 4106, 20241, 4866, 435, 4107, 20242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6825, 4866, 435, 4107, 20242, 469, 16, 436, 4877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6826, 242, 3050, 3061, 243, 3303, 19990, 20243, 3326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6827, 3303, 19990, 20243, 3326, 3304, 19991, 20244, 3327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6828, 3304, 19991, 20244, 3327, 3305, 19992, 20245, 3328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6829, 3305, 19992, 20245, 3328, 3306, 19993, 20246, 3329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6830, 3306, 19993, 20246, 3329, 3307, 19994, 20247, 3330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6831, 3307, 19994, 20247, 3330, 3308, 19995, 20248, 3331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6832, 3308, 19995, 20248, 3331, 3309, 19996, 20249, 3332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6833, 3309, 19996, 20249, 3332, 3310, 19997, 20250, 3333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6834, 3310, 19997, 20250, 3333, 3311, 19998, 20251, 3334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6835, 3311, 19998, 20251, 3334, 3312, 19999, 20252, 3335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6836, 3312, 19999, 20252, 3335, 3313, 20000, 20253, 3336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6837, 3313, 20000, 20253, 3336, 3314, 20001, 20254, 3337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6838, 3314, 20001, 20254, 3337, 3315, 20002, 20255, 3338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6839, 3315, 20002, 20255, 3338, 3316, 20003, 20256, 3339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6840, 3316, 20003, 20256, 3339, 3317, 20004, 20257, 3340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6841, 3317, 20004, 20257, 3340, 3318, 20005, 20258, 3341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6842, 3318, 20005, 20258, 3341, 3319, 20006, 20259, 3342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6843, 3319, 20006, 20259, 3342, 3320, 20007, 20260, 3343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6844, 3320, 20007, 20260, 3343, 3321, 20008, 20261, 3344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6845, 3321, 20008, 20261, 3344, 3322, 20009, 20262, 3345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6846, 3322, 20009, 20262, 3345, 3323, 20010, 20263, 3346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6847, 3323, 20010, 20263, 3346, 3324, 20011, 20264, 3347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6848, 3324, 20011, 20264, 3347, 3325, 20012, 20265, 3348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6849, 3325, 20012, 20265, 3348, 356, 4867, 4878, 357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6850, 3050, 3051, 3062, 3061, 19990, 20013, 20266, 20243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6851, 19990, 20013, 20266, 20243, 19991, 20014, 20267, 20244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6852, 19991, 20014, 20267, 20244, 19992, 20015, 20268, 20245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6853, 19992, 20015, 20268, 20245, 19993, 20016, 20269, 20246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6854, 19993, 20016, 20269, 20246, 19994, 20017, 20270, 20247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6855, 19994, 20017, 20270, 20247, 19995, 20018, 20271, 20248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6856, 19995, 20018, 20271, 20248, 19996, 20019, 20272, 20249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6857, 19996, 20019, 20272, 20249, 19997, 20020, 20273, 20250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6858, 19997, 20020, 20273, 20250, 19998, 20021, 20274, 20251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6859, 19998, 20021, 20274, 20251, 19999, 20022, 20275, 20252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6860, 19999, 20022, 20275, 20252, 20000, 20023, 20276, 20253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6861, 20000, 20023, 20276, 20253, 20001, 20024, 20277, 20254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6862, 20001, 20024, 20277, 20254, 20002, 20025, 20278, 20255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6863, 20002, 20025, 20278, 20255, 20003, 20026, 20279, 20256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6864, 20003, 20026, 20279, 20256, 20004, 20027, 20280, 20257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6865, 20004, 20027, 20280, 20257, 20005, 20028, 20281, 20258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6866, 20005, 20028, 20281, 20258, 20006, 20029, 20282, 20259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6867, 20006, 20029, 20282, 20259, 20007, 20030, 20283, 20260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6868, 20007, 20030, 20283, 20260, 20008, 20031, 20284, 20261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6869, 20008, 20031, 20284, 20261, 20009, 20032, 20285, 20262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6870, 20009, 20032, 20285, 20262, 20010, 20033, 20286, 20263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6871, 20010, 20033, 20286, 20263, 20011, 20034, 20287, 20264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6872, 20011, 20034, 20287, 20264, 20012, 20035, 20288, 20265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6873, 20012, 20035, 20288, 20265, 4867, 4868, 4879, 4878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6874, 3051, 3052, 3063, 3062, 20013, 20036, 20289, 20266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6875, 20013, 20036, 20289, 20266, 20014, 20037, 20290, 20267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6876, 20014, 20037, 20290, 20267, 20015, 20038, 20291, 20268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6877, 20015, 20038, 20291, 20268, 20016, 20039, 20292, 20269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6878, 20016, 20039, 20292, 20269, 20017, 20040, 20293, 20270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6879, 20017, 20040, 20293, 20270, 20018, 20041, 20294, 20271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6880, 20018, 20041, 20294, 20271, 20019, 20042, 20295, 20272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6881, 20019, 20042, 20295, 20272, 20020, 20043, 20296, 20273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6882, 20020, 20043, 20296, 20273, 20021, 20044, 20297, 20274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6883, 20021, 20044, 20297, 20274, 20022, 20045, 20298, 20275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6884, 20022, 20045, 20298, 20275, 20023, 20046, 20299, 20276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6885, 20023, 20046, 20299, 20276, 20024, 20047, 20300, 20277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6886, 20024, 20047, 20300, 20277, 20025, 20048, 20301, 20278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6887, 20025, 20048, 20301, 20278, 20026, 20049, 20302, 20279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6888, 20026, 20049, 20302, 20279, 20027, 20050, 20303, 20280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6889, 20027, 20050, 20303, 20280, 20028, 20051, 20304, 20281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6890, 20028, 20051, 20304, 20281, 20029, 20052, 20305, 20282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6891, 20029, 20052, 20305, 20282, 20030, 20053, 20306, 20283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6892, 20030, 20053, 20306, 20283, 20031, 20054, 20307, 20284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6893, 20031, 20054, 20307, 20284, 20032, 20055, 20308, 20285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6894, 20032, 20055, 20308, 20285, 20033, 20056, 20309, 20286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6895, 20033, 20056, 20309, 20286, 20034, 20057, 20310, 20287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6896, 20034, 20057, 20310, 20287, 20035, 20058, 20311, 20288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6897, 20035, 20058, 20311, 20288, 4868, 4869, 4880, 4879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6898, 3052, 3053, 3064, 3063, 20036, 20059, 20312, 20289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6899, 20036, 20059, 20312, 20289, 20037, 20060, 20313, 20290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6900, 20037, 20060, 20313, 20290, 20038, 20061, 20314, 20291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6901, 20038, 20061, 20314, 20291, 20039, 20062, 20315, 20292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6902, 20039, 20062, 20315, 20292, 20040, 20063, 20316, 20293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6903, 20040, 20063, 20316, 20293, 20041, 20064, 20317, 20294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6904, 20041, 20064, 20317, 20294, 20042, 20065, 20318, 20295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6905, 20042, 20065, 20318, 20295, 20043, 20066, 20319, 20296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6906, 20043, 20066, 20319, 20296, 20044, 20067, 20320, 20297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6907, 20044, 20067, 20320, 20297, 20045, 20068, 20321, 20298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6908, 20045, 20068, 20321, 20298, 20046, 20069, 20322, 20299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6909, 20046, 20069, 20322, 20299, 20047, 20070, 20323, 20300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6910, 20047, 20070, 20323, 20300, 20048, 20071, 20324, 20301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6911, 20048, 20071, 20324, 20301, 20049, 20072, 20325, 20302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6912, 20049, 20072, 20325, 20302, 20050, 20073, 20326, 20303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6913, 20050, 20073, 20326, 20303, 20051, 20074, 20327, 20304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6914, 20051, 20074, 20327, 20304, 20052, 20075, 20328, 20305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6915, 20052, 20075, 20328, 20305, 20053, 20076, 20329, 20306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6916, 20053, 20076, 20329, 20306, 20054, 20077, 20330, 20307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6917, 20054, 20077, 20330, 20307, 20055, 20078, 20331, 20308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6918, 20055, 20078, 20331, 20308, 20056, 20079, 20332, 20309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6919, 20056, 20079, 20332, 20309, 20057, 20080, 20333, 20310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6920, 20057, 20080, 20333, 20310, 20058, 20081, 20334, 20311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6921, 20058, 20081, 20334, 20311, 4869, 4870, 4881, 4880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6922, 3053, 3054, 3065, 3064, 20059, 20082, 20335, 20312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6923, 20059, 20082, 20335, 20312, 20060, 20083, 20336, 20313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6924, 20060, 20083, 20336, 20313, 20061, 20084, 20337, 20314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6925, 20061, 20084, 20337, 20314, 20062, 20085, 20338, 20315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6926, 20062, 20085, 20338, 20315, 20063, 20086, 20339, 20316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6927, 20063, 20086, 20339, 20316, 20064, 20087, 20340, 20317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6928, 20064, 20087, 20340, 20317, 20065, 20088, 20341, 20318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6929, 20065, 20088, 20341, 20318, 20066, 20089, 20342, 20319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6930, 20066, 20089, 20342, 20319, 20067, 20090, 20343, 20320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6931, 20067, 20090, 20343, 20320, 20068, 20091, 20344, 20321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6932, 20068, 20091, 20344, 20321, 20069, 20092, 20345, 20322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6933, 20069, 20092, 20345, 20322, 20070, 20093, 20346, 20323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6934, 20070, 20093, 20346, 20323, 20071, 20094, 20347, 20324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6935, 20071, 20094, 20347, 20324, 20072, 20095, 20348, 20325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6936, 20072, 20095, 20348, 20325, 20073, 20096, 20349, 20326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6937, 20073, 20096, 20349, 20326, 20074, 20097, 20350, 20327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6938, 20074, 20097, 20350, 20327, 20075, 20098, 20351, 20328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6939, 20075, 20098, 20351, 20328, 20076, 20099, 20352, 20329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6940, 20076, 20099, 20352, 20329, 20077, 20100, 20353, 20330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6941, 20077, 20100, 20353, 20330, 20078, 20101, 20354, 20331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6942, 20078, 20101, 20354, 20331, 20079, 20102, 20355, 20332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6943, 20079, 20102, 20355, 20332, 20080, 20103, 20356, 20333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6944, 20080, 20103, 20356, 20333, 20081, 20104, 20357, 20334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6945, 20081, 20104, 20357, 20334, 4870, 4871, 4882, 4881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6946, 3054, 3055, 3066, 3065, 20082, 20105, 20358, 20335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6947, 20082, 20105, 20358, 20335, 20083, 20106, 20359, 20336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6948, 20083, 20106, 20359, 20336, 20084, 20107, 20360, 20337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6949, 20084, 20107, 20360, 20337, 20085, 20108, 20361, 20338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6950, 20085, 20108, 20361, 20338, 20086, 20109, 20362, 20339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6951, 20086, 20109, 20362, 20339, 20087, 20110, 20363, 20340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6952, 20087, 20110, 20363, 20340, 20088, 20111, 20364, 20341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6953, 20088, 20111, 20364, 20341, 20089, 20112, 20365, 20342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6954, 20089, 20112, 20365, 20342, 20090, 20113, 20366, 20343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6955, 20090, 20113, 20366, 20343, 20091, 20114, 20367, 20344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6956, 20091, 20114, 20367, 20344, 20092, 20115, 20368, 20345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6957, 20092, 20115, 20368, 20345, 20093, 20116, 20369, 20346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6958, 20093, 20116, 20369, 20346, 20094, 20117, 20370, 20347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6959, 20094, 20117, 20370, 20347, 20095, 20118, 20371, 20348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6960, 20095, 20118, 20371, 20348, 20096, 20119, 20372, 20349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6961, 20096, 20119, 20372, 20349, 20097, 20120, 20373, 20350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6962, 20097, 20120, 20373, 20350, 20098, 20121, 20374, 20351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6963, 20098, 20121, 20374, 20351, 20099, 20122, 20375, 20352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6964, 20099, 20122, 20375, 20352, 20100, 20123, 20376, 20353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6965, 20100, 20123, 20376, 20353, 20101, 20124, 20377, 20354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6966, 20101, 20124, 20377, 20354, 20102, 20125, 20378, 20355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6967, 20102, 20125, 20378, 20355, 20103, 20126, 20379, 20356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6968, 20103, 20126, 20379, 20356, 20104, 20127, 20380, 20357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6969, 20104, 20127, 20380, 20357, 4871, 4872, 4883, 4882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6970, 3055, 3056, 3067, 3066, 20105, 20128, 20381, 20358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6971, 20105, 20128, 20381, 20358, 20106, 20129, 20382, 20359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6972, 20106, 20129, 20382, 20359, 20107, 20130, 20383, 20360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6973, 20107, 20130, 20383, 20360, 20108, 20131, 20384, 20361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6974, 20108, 20131, 20384, 20361, 20109, 20132, 20385, 20362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6975, 20109, 20132, 20385, 20362, 20110, 20133, 20386, 20363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6976, 20110, 20133, 20386, 20363, 20111, 20134, 20387, 20364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6977, 20111, 20134, 20387, 20364, 20112, 20135, 20388, 20365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6978, 20112, 20135, 20388, 20365, 20113, 20136, 20389, 20366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6979, 20113, 20136, 20389, 20366, 20114, 20137, 20390, 20367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6980, 20114, 20137, 20390, 20367, 20115, 20138, 20391, 20368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6981, 20115, 20138, 20391, 20368, 20116, 20139, 20392, 20369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6982, 20116, 20139, 20392, 20369, 20117, 20140, 20393, 20370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6983, 20117, 20140, 20393, 20370, 20118, 20141, 20394, 20371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6984, 20118, 20141, 20394, 20371, 20119, 20142, 20395, 20372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6985, 20119, 20142, 20395, 20372, 20120, 20143, 20396, 20373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6986, 20120, 20143, 20396, 20373, 20121, 20144, 20397, 20374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6987, 20121, 20144, 20397, 20374, 20122, 20145, 20398, 20375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6988, 20122, 20145, 20398, 20375, 20123, 20146, 20399, 20376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6989, 20123, 20146, 20399, 20376, 20124, 20147, 20400, 20377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6990, 20124, 20147, 20400, 20377, 20125, 20148, 20401, 20378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6991, 20125, 20148, 20401, 20378, 20126, 20149, 20402, 20379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6992, 20126, 20149, 20402, 20379, 20127, 20150, 20403, 20380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6993, 20127, 20150, 20403, 20380, 4872, 4873, 4884, 4883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6994, 3056, 3057, 3068, 3067, 20128, 20151, 20404, 20381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6995, 20128, 20151, 20404, 20381, 20129, 20152, 20405, 20382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6996, 20129, 20152, 20405, 20382, 20130, 20153, 20406, 20383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6997, 20130, 20153, 20406, 20383, 20131, 20154, 20407, 20384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6998, 20131, 20154, 20407, 20384, 20132, 20155, 20408, 20385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
6999, 20132, 20155, 20408, 20385, 20133, 20156, 20409, 20386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7000, 20133, 20156, 20409, 20386, 20134, 20157, 20410, 20387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7001, 20134, 20157, 20410, 20387, 20135, 20158, 20411, 20388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7002, 20135, 20158, 20411, 20388, 20136, 20159, 20412, 20389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7003, 20136, 20159, 20412, 20389, 20137, 20160, 20413, 20390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7004, 20137, 20160, 20413, 20390, 20138, 20161, 20414, 20391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7005, 20138, 20161, 20414, 20391, 20139, 20162, 20415, 20392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7006, 20139, 20162, 20415, 20392, 20140, 20163, 20416, 20393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7007, 20140, 20163, 20416, 20393, 20141, 20164, 20417, 20394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7008, 20141, 20164, 20417, 20394, 20142, 20165, 20418, 20395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7009, 20142, 20165, 20418, 20395, 20143, 20166, 20419, 20396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7010, 20143, 20166, 20419, 20396, 20144, 20167, 20420, 20397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7011, 20144, 20167, 20420, 20397, 20145, 20168, 20421, 20398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7012, 20145, 20168, 20421, 20398, 20146, 20169, 20422, 20399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7013, 20146, 20169, 20422, 20399, 20147, 20170, 20423, 20400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7014, 20147, 20170, 20423, 20400, 20148, 20171, 20424, 20401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7015, 20148, 20171, 20424, 20401, 20149, 20172, 20425, 20402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7016, 20149, 20172, 20425, 20402, 20150, 20173, 20426, 20403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7017, 20150, 20173, 20426, 20403, 4873, 4874, 4885, 4884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7018, 3057, 3058, 3069, 3068, 20151, 20174, 20427, 20404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7019, 20151, 20174, 20427, 20404, 20152, 20175, 20428, 20405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7020, 20152, 20175, 20428, 20405, 20153, 20176, 20429, 20406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7021, 20153, 20176, 20429, 20406, 20154, 20177, 20430, 20407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7022, 20154, 20177, 20430, 20407, 20155, 20178, 20431, 20408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7023, 20155, 20178, 20431, 20408, 20156, 20179, 20432, 20409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7024, 20156, 20179, 20432, 20409, 20157, 20180, 20433, 20410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7025, 20157, 20180, 20433, 20410, 20158, 20181, 20434, 20411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7026, 20158, 20181, 20434, 20411, 20159, 20182, 20435, 20412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7027, 20159, 20182, 20435, 20412, 20160, 20183, 20436, 20413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7028, 20160, 20183, 20436, 20413, 20161, 20184, 20437, 20414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7029, 20161, 20184, 20437, 20414, 20162, 20185, 20438, 20415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7030, 20162, 20185, 20438, 20415, 20163, 20186, 20439, 20416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7031, 20163, 20186, 20439, 20416, 20164, 20187, 20440, 20417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7032, 20164, 20187, 20440, 20417, 20165, 20188, 20441, 20418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7033, 20165, 20188, 20441, 20418, 20166, 20189, 20442, 20419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7034, 20166, 20189, 20442, 20419, 20167, 20190, 20443, 20420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7035, 20167, 20190, 20443, 20420, 20168, 20191, 20444, 20421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7036, 20168, 20191, 20444, 20421, 20169, 20192, 20445, 20422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7037, 20169, 20192, 20445, 20422, 20170, 20193, 20446, 20423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7038, 20170, 20193, 20446, 20423, 20171, 20194, 20447, 20424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7039, 20171, 20194, 20447, 20424, 20172, 20195, 20448, 20425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7040, 20172, 20195, 20448, 20425, 20173, 20196, 20449, 20426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7041, 20173, 20196, 20449, 20426, 4874, 4875, 4886, 4885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7042, 3058, 3059, 3070, 3069, 20174, 20197, 20450, 20427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7043, 20174, 20197, 20450, 20427, 20175, 20198, 20451, 20428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7044, 20175, 20198, 20451, 20428, 20176, 20199, 20452, 20429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7045, 20176, 20199, 20452, 20429, 20177, 20200, 20453, 20430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7046, 20177, 20200, 20453, 20430, 20178, 20201, 20454, 20431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7047, 20178, 20201, 20454, 20431, 20179, 20202, 20455, 20432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7048, 20179, 20202, 20455, 20432, 20180, 20203, 20456, 20433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7049, 20180, 20203, 20456, 20433, 20181, 20204, 20457, 20434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7050, 20181, 20204, 20457, 20434, 20182, 20205, 20458, 20435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7051, 20182, 20205, 20458, 20435, 20183, 20206, 20459, 20436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7052, 20183, 20206, 20459, 20436, 20184, 20207, 20460, 20437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7053, 20184, 20207, 20460, 20437, 20185, 20208, 20461, 20438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7054, 20185, 20208, 20461, 20438, 20186, 20209, 20462, 20439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7055, 20186, 20209, 20462, 20439, 20187, 20210, 20463, 20440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7056, 20187, 20210, 20463, 20440, 20188, 20211, 20464, 20441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7057, 20188, 20211, 20464, 20441, 20189, 20212, 20465, 20442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7058, 20189, 20212, 20465, 20442, 20190, 20213, 20466, 20443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7059, 20190, 20213, 20466, 20443, 20191, 20214, 20467, 20444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7060, 20191, 20214, 20467, 20444, 20192, 20215, 20468, 20445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7061, 20192, 20215, 20468, 20445, 20193, 20216, 20469, 20446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7062, 20193, 20216, 20469, 20446, 20194, 20217, 20470, 20447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7063, 20194, 20217, 20470, 20447, 20195, 20218, 20471, 20448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7064, 20195, 20218, 20471, 20448, 20196, 20219, 20472, 20449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7065, 20196, 20219, 20472, 20449, 4875, 4876, 4887, 4886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7066, 3059, 3060, 3071, 3070, 20197, 20220, 20473, 20450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7067, 20197, 20220, 20473, 20450, 20198, 20221, 20474, 20451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7068, 20198, 20221, 20474, 20451, 20199, 20222, 20475, 20452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7069, 20199, 20222, 20475, 20452, 20200, 20223, 20476, 20453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7070, 20200, 20223, 20476, 20453, 20201, 20224, 20477, 20454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7071, 20201, 20224, 20477, 20454, 20202, 20225, 20478, 20455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7072, 20202, 20225, 20478, 20455, 20203, 20226, 20479, 20456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7073, 20203, 20226, 20479, 20456, 20204, 20227, 20480, 20457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7074, 20204, 20227, 20480, 20457, 20205, 20228, 20481, 20458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7075, 20205, 20228, 20481, 20458, 20206, 20229, 20482, 20459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7076, 20206, 20229, 20482, 20459, 20207, 20230, 20483, 20460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7077, 20207, 20230, 20483, 20460, 20208, 20231, 20484, 20461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7078, 20208, 20231, 20484, 20461, 20209, 20232, 20485, 20462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7079, 20209, 20232, 20485, 20462, 20210, 20233, 20486, 20463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7080, 20210, 20233, 20486, 20463, 20211, 20234, 20487, 20464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7081, 20211, 20234, 20487, 20464, 20212, 20235, 20488, 20465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7082, 20212, 20235, 20488, 20465, 20213, 20236, 20489, 20466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7083, 20213, 20236, 20489, 20466, 20214, 20237, 20490, 20467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7084, 20214, 20237, 20490, 20467, 20215, 20238, 20491, 20468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7085, 20215, 20238, 20491, 20468, 20216, 20239, 20492, 20469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7086, 20216, 20239, 20492, 20469, 20217, 20240, 20493, 20470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7087, 20217, 20240, 20493, 20470, 20218, 20241, 20494, 20471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7088, 20218, 20241, 20494, 20471, 20219, 20242, 20495, 20472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7089, 20219, 20242, 20495, 20472, 4876, 4877, 4888, 4887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7090, 3060, 276, 277, 3071, 20220, 4085, 4108, 20473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7091, 20220, 4085, 4108, 20473, 20221, 4086, 4109, 20474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7092, 20221, 4086, 4109, 20474, 20222, 4087, 4110, 20475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7093, 20222, 4087, 4110, 20475, 20223, 4088, 4111, 20476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7094, 20223, 4088, 4111, 20476, 20224, 4089, 4112, 20477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7095, 20224, 4089, 4112, 20477, 20225, 4090, 4113, 20478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7096, 20225, 4090, 4113, 20478, 20226, 4091, 4114, 20479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7097, 20226, 4091, 4114, 20479, 20227, 4092, 4115, 20480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7098, 20227, 4092, 4115, 20480, 20228, 4093, 4116, 20481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7099, 20228, 4093, 4116, 20481, 20229, 4094, 4117, 20482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7100, 20229, 4094, 4117, 20482, 20230, 4095, 4118, 20483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7101, 20230, 4095, 4118, 20483, 20231, 4096, 4119, 20484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7102, 20231, 4096, 4119, 20484, 20232, 4097, 4120, 20485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7103, 20232, 4097, 4120, 20485, 20233, 4098, 4121, 20486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7104, 20233, 4098, 4121, 20486, 20234, 4099, 4122, 20487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7105, 20234, 4099, 4122, 20487, 20235, 4100, 4123, 20488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7106, 20235, 4100, 4123, 20488, 20236, 4101, 4124, 20489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7107, 20236, 4101, 4124, 20489, 20237, 4102, 4125, 20490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7108, 20237, 4102, 4125, 20490, 20238, 4103, 4126, 20491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7109, 20238, 4103, 4126, 20491, 20239, 4104, 4127, 20492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7110, 20239, 4104, 4127, 20492, 20240, 4105, 4128, 20493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7111, 20240, 4105, 4128, 20493, 20241, 4106, 4129, 20494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7112, 20241, 4106, 4129, 20494, 20242, 4107, 4130, 20495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7113, 20242, 4107, 4130, 20495, 4877, 436, 437, 4888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7114, 243, 3061, 3072, 244, 3326, 20243, 20496, 3349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7115, 3326, 20243, 20496, 3349, 3327, 20244, 20497, 3350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7116, 3327, 20244, 20497, 3350, 3328, 20245, 20498, 3351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7117, 3328, 20245, 20498, 3351, 3329, 20246, 20499, 3352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7118, 3329, 20246, 20499, 3352, 3330, 20247, 20500, 3353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7119, 3330, 20247, 20500, 3353, 3331, 20248, 20501, 3354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7120, 3331, 20248, 20501, 3354, 3332, 20249, 20502, 3355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7121, 3332, 20249, 20502, 3355, 3333, 20250, 20503, 3356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7122, 3333, 20250, 20503, 3356, 3334, 20251, 20504, 3357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7123, 3334, 20251, 20504, 3357, 3335, 20252, 20505, 3358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7124, 3335, 20252, 20505, 3358, 3336, 20253, 20506, 3359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7125, 3336, 20253, 20506, 3359, 3337, 20254, 20507, 3360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7126, 3337, 20254, 20507, 3360, 3338, 20255, 20508, 3361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7127, 3338, 20255, 20508, 3361, 3339, 20256, 20509, 3362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7128, 3339, 20256, 20509, 3362, 3340, 20257, 20510, 3363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7129, 3340, 20257, 20510, 3363, 3341, 20258, 20511, 3364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7130, 3341, 20258, 20511, 3364, 3342, 20259, 20512, 3365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7131, 3342, 20259, 20512, 3365, 3343, 20260, 20513, 3366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7132, 3343, 20260, 20513, 3366, 3344, 20261, 20514, 3367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7133, 3344, 20261, 20514, 3367, 3345, 20262, 20515, 3368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7134, 3345, 20262, 20515, 3368, 3346, 20263, 20516, 3369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7135, 3346, 20263, 20516, 3369, 3347, 20264, 20517, 3370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7136, 3347, 20264, 20517, 3370, 3348, 20265, 20518, 3371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7137, 3348, 20265, 20518, 3371, 357, 4878, 4889, 358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7138, 3061, 3062, 3073, 3072, 20243, 20266, 20519, 20496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7139, 20243, 20266, 20519, 20496, 20244, 20267, 20520, 20497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7140, 20244, 20267, 20520, 20497, 20245, 20268, 20521, 20498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7141, 20245, 20268, 20521, 20498, 20246, 20269, 20522, 20499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7142, 20246, 20269, 20522, 20499, 20247, 20270, 20523, 20500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7143, 20247, 20270, 20523, 20500, 20248, 20271, 20524, 20501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7144, 20248, 20271, 20524, 20501, 20249, 20272, 20525, 20502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7145, 20249, 20272, 20525, 20502, 20250, 20273, 20526, 20503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7146, 20250, 20273, 20526, 20503, 20251, 20274, 20527, 20504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7147, 20251, 20274, 20527, 20504, 20252, 20275, 20528, 20505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7148, 20252, 20275, 20528, 20505, 20253, 20276, 20529, 20506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7149, 20253, 20276, 20529, 20506, 20254, 20277, 20530, 20507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7150, 20254, 20277, 20530, 20507, 20255, 20278, 20531, 20508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7151, 20255, 20278, 20531, 20508, 20256, 20279, 20532, 20509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7152, 20256, 20279, 20532, 20509, 20257, 20280, 20533, 20510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7153, 20257, 20280, 20533, 20510, 20258, 20281, 20534, 20511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7154, 20258, 20281, 20534, 20511, 20259, 20282, 20535, 20512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7155, 20259, 20282, 20535, 20512, 20260, 20283, 20536, 20513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7156, 20260, 20283, 20536, 20513, 20261, 20284, 20537, 20514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7157, 20261, 20284, 20537, 20514, 20262, 20285, 20538, 20515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7158, 20262, 20285, 20538, 20515, 20263, 20286, 20539, 20516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7159, 20263, 20286, 20539, 20516, 20264, 20287, 20540, 20517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7160, 20264, 20287, 20540, 20517, 20265, 20288, 20541, 20518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7161, 20265, 20288, 20541, 20518, 4878, 4879, 4890, 4889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7162, 3062, 3063, 3074, 3073, 20266, 20289, 20542, 20519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7163, 20266, 20289, 20542, 20519, 20267, 20290, 20543, 20520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7164, 20267, 20290, 20543, 20520, 20268, 20291, 20544, 20521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7165, 20268, 20291, 20544, 20521, 20269, 20292, 20545, 20522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7166, 20269, 20292, 20545, 20522, 20270, 20293, 20546, 20523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7167, 20270, 20293, 20546, 20523, 20271, 20294, 20547, 20524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7168, 20271, 20294, 20547, 20524, 20272, 20295, 20548, 20525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7169, 20272, 20295, 20548, 20525, 20273, 20296, 20549, 20526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7170, 20273, 20296, 20549, 20526, 20274, 20297, 20550, 20527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7171, 20274, 20297, 20550, 20527, 20275, 20298, 20551, 20528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7172, 20275, 20298, 20551, 20528, 20276, 20299, 20552, 20529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7173, 20276, 20299, 20552, 20529, 20277, 20300, 20553, 20530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7174, 20277, 20300, 20553, 20530, 20278, 20301, 20554, 20531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7175, 20278, 20301, 20554, 20531, 20279, 20302, 20555, 20532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7176, 20279, 20302, 20555, 20532, 20280, 20303, 20556, 20533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7177, 20280, 20303, 20556, 20533, 20281, 20304, 20557, 20534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7178, 20281, 20304, 20557, 20534, 20282, 20305, 20558, 20535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7179, 20282, 20305, 20558, 20535, 20283, 20306, 20559, 20536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7180, 20283, 20306, 20559, 20536, 20284, 20307, 20560, 20537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7181, 20284, 20307, 20560, 20537, 20285, 20308, 20561, 20538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7182, 20285, 20308, 20561, 20538, 20286, 20309, 20562, 20539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7183, 20286, 20309, 20562, 20539, 20287, 20310, 20563, 20540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7184, 20287, 20310, 20563, 20540, 20288, 20311, 20564, 20541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7185, 20288, 20311, 20564, 20541, 4879, 4880, 4891, 4890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7186, 3063, 3064, 3075, 3074, 20289, 20312, 20565, 20542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7187, 20289, 20312, 20565, 20542, 20290, 20313, 20566, 20543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7188, 20290, 20313, 20566, 20543, 20291, 20314, 20567, 20544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7189, 20291, 20314, 20567, 20544, 20292, 20315, 20568, 20545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7190, 20292, 20315, 20568, 20545, 20293, 20316, 20569, 20546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7191, 20293, 20316, 20569, 20546, 20294, 20317, 20570, 20547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7192, 20294, 20317, 20570, 20547, 20295, 20318, 20571, 20548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7193, 20295, 20318, 20571, 20548, 20296, 20319, 20572, 20549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7194, 20296, 20319, 20572, 20549, 20297, 20320, 20573, 20550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7195, 20297, 20320, 20573, 20550, 20298, 20321, 20574, 20551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7196, 20298, 20321, 20574, 20551, 20299, 20322, 20575, 20552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7197, 20299, 20322, 20575, 20552, 20300, 20323, 20576, 20553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7198, 20300, 20323, 20576, 20553, 20301, 20324, 20577, 20554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7199, 20301, 20324, 20577, 20554, 20302, 20325, 20578, 20555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7200, 20302, 20325, 20578, 20555, 20303, 20326, 20579, 20556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7201, 20303, 20326, 20579, 20556, 20304, 20327, 20580, 20557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7202, 20304, 20327, 20580, 20557, 20305, 20328, 20581, 20558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7203, 20305, 20328, 20581, 20558, 20306, 20329, 20582, 20559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7204, 20306, 20329, 20582, 20559, 20307, 20330, 20583, 20560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7205, 20307, 20330, 20583, 20560, 20308, 20331, 20584, 20561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7206, 20308, 20331, 20584, 20561, 20309, 20332, 20585, 20562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7207, 20309, 20332, 20585, 20562, 20310, 20333, 20586, 20563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7208, 20310, 20333, 20586, 20563, 20311, 20334, 20587, 20564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7209, 20311, 20334, 20587, 20564, 4880, 4881, 4892, 4891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
7210, 3064, 3065, 3076, 3075, 20312, 20335, 20588, 20565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
