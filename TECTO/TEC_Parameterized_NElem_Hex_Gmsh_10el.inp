42208, 1.2416666666667, 1.58, 0.041666666666667
42209, 1.2416666666667, 1.62, 0.041666666666667
42210, 1.2416666666667, 1.66, 0.041666666666667
42211, 1.2833333333333, 1.54, 0.041666666666667
42212, 1.2833333333333, 1.58, 0.041666666666667
42213, 1.2833333333333, 1.62, 0.041666666666667
42214, 1.2833333333333, 1.66, 0.041666666666667
42215, 1.325, 1.54, 0.041666666666667
42216, 1.325, 1.58, 0.041666666666667
42217, 1.325, 1.62, 0.041666666666667
42218, 1.325, 1.66, 0.041666666666667
42219, 1.3666666666667, 1.54, 0.041666666666667
42220, 1.3666666666667, 1.58, 0.041666666666667
42221, 1.3666666666667, 1.62, 0.041666666666667
42222, 1.3666666666667, 1.66, 0.041666666666667
42223, 1.4083333333333, 1.54, 0.041666666666667
42224, 1.4083333333333, 1.58, 0.041666666666667
42225, 1.4083333333333, 1.62, 0.041666666666667
42226, 1.4083333333333, 1.66, 0.041666666666667
42227, 1.45, 1.54, 0.041666666666667
42228, 1.45, 1.58, 0.041666666666667
42229, 1.45, 1.62, 0.041666666666667
42230, 1.45, 1.66, 0.041666666666667
42231, 1.4916666666667, 1.54, 0.041666666666667
42232, 1.4916666666667, 1.58, 0.041666666666667
42233, 1.4916666666667, 1.62, 0.041666666666667
42234, 1.4916666666667, 1.66, 0.041666666666667
42235, 1.5333333333333, 1.54, 0.041666666666667
42236, 1.5333333333333, 1.58, 0.041666666666667
42237, 1.5333333333333, 1.62, 0.041666666666667
42238, 1.5333333333333, 1.66, 0.041666666666667
42239, 1.575, 1.54, 0.041666666666667
42240, 1.575, 1.58, 0.041666666666667
42241, 1.575, 1.62, 0.041666666666667
42242, 1.575, 1.66, 0.041666666666667
42243, 1.6166666666667, 1.54, 0.041666666666667
42244, 1.6166666666667, 1.58, 0.041666666666667
42245, 1.6166666666667, 1.62, 0.041666666666667
42246, 1.6166666666667, 1.66, 0.041666666666667
42247, 1.6583333333333, 1.54, 0.041666666666667
42248, 1.6583333333333, 1.58, 0.041666666666667
42249, 1.6583333333333, 1.62, 0.041666666666667
42250, 1.6583333333333, 1.66, 0.041666666666667
42251, 1.7, 1.54, 0.041666666666667
42252, 1.7, 1.58, 0.041666666666667
42253, 1.7, 1.62, 0.041666666666667
42254, 1.7, 1.66, 0.041666666666667
42255, 1.7416666666667, 1.54, 0.041666666666667
42256, 1.7416666666667, 1.58, 0.041666666666667
42257, 1.7416666666667, 1.62, 0.041666666666667
42258, 1.7416666666667, 1.66, 0.041666666666667
42259, 1.7833333333333, 1.54, 0.041666666666667
42260, 1.7833333333333, 1.58, 0.041666666666667
42261, 1.7833333333333, 1.62, 0.041666666666667
42262, 1.7833333333333, 1.66, 0.041666666666667
42263, 1.825, 1.54, 0.041666666666667
42264, 1.825, 1.58, 0.041666666666667
42265, 1.825, 1.62, 0.041666666666667
42266, 1.825, 1.66, 0.041666666666667
42267, 1.8666666666667, 1.54, 0.041666666666667
42268, 1.8666666666667, 1.58, 0.041666666666667
42269, 1.8666666666667, 1.62, 0.041666666666667
42270, 1.8666666666667, 1.66, 0.041666666666667
42271, 1.9083333333333, 1.54, 0.041666666666667
42272, 1.9083333333333, 1.58, 0.041666666666667
42273, 1.9083333333333, 1.62, 0.041666666666667
42274, 1.9083333333333, 1.66, 0.041666666666667
42275, 1.95, 1.54, 0.041666666666667
42276, 1.95, 1.58, 0.041666666666667
42277, 1.95, 1.62, 0.041666666666667
42278, 1.95, 1.66, 0.041666666666667
42279, 1.9916666666667, 1.54, 0.041666666666667
42280, 1.9916666666667, 1.58, 0.041666666666667
42281, 1.9916666666667, 1.62, 0.041666666666667
42282, 1.9916666666667, 1.66, 0.041666666666667
42283, 2.0333333333333, 1.54, 0.041666666666667
42284, 2.0333333333333, 1.58, 0.041666666666667
42285, 2.0333333333333, 1.62, 0.041666666666667
42286, 2.0333333333333, 1.66, 0.041666666666667
42287, 2.075, 1.54, 0.041666666666667
42288, 2.075, 1.58, 0.041666666666667
42289, 2.075, 1.62, 0.041666666666667
42290, 2.075, 1.66, 0.041666666666667
42291, 2.1166666666667, 1.54, 0.041666666666667
42292, 2.1166666666667, 1.58, 0.041666666666667
42293, 2.1166666666667, 1.62, 0.041666666666667
42294, 2.1166666666667, 1.66, 0.041666666666667
42295, 2.1583333333333, 1.54, 0.041666666666667
42296, 2.1583333333333, 1.58, 0.041666666666667
42297, 2.1583333333333, 1.62, 0.041666666666667
42298, 2.1583333333333, 1.66, 0.041666666666667
42299, 1.2416666666667, 1.54, 0.083333333333333
42300, 1.2416666666667, 1.58, 0.083333333333333
42301, 1.2416666666667, 1.62, 0.083333333333333
42302, 1.2416666666667, 1.66, 0.083333333333333
42303, 1.2833333333333, 1.54, 0.083333333333333
42304, 1.2833333333333, 1.58, 0.083333333333333
42305, 1.2833333333333, 1.62, 0.083333333333333
42306, 1.2833333333333, 1.66, 0.083333333333333
42307, 1.325, 1.54, 0.083333333333333
42308, 1.325, 1.58, 0.083333333333333
42309, 1.325, 1.62, 0.083333333333333
42310, 1.325, 1.66, 0.083333333333333
42311, 1.3666666666667, 1.54, 0.083333333333333
42312, 1.3666666666667, 1.58, 0.083333333333333
42313, 1.3666666666667, 1.62, 0.083333333333333
42314, 1.3666666666667, 1.66, 0.083333333333333
42315, 1.4083333333333, 1.54, 0.083333333333333
42316, 1.4083333333333, 1.58, 0.083333333333333
42317, 1.4083333333333, 1.62, 0.083333333333333
42318, 1.4083333333333, 1.66, 0.083333333333333
42319, 1.45, 1.54, 0.083333333333333
42320, 1.45, 1.58, 0.083333333333333
42321, 1.45, 1.62, 0.083333333333333
42322, 1.45, 1.66, 0.083333333333333
42323, 1.4916666666667, 1.54, 0.083333333333333
42324, 1.4916666666667, 1.58, 0.083333333333333
42325, 1.4916666666667, 1.62, 0.083333333333333
42326, 1.4916666666667, 1.66, 0.083333333333333
42327, 1.5333333333333, 1.54, 0.083333333333333
42328, 1.5333333333333, 1.58, 0.083333333333333
42329, 1.5333333333333, 1.62, 0.083333333333333
42330, 1.5333333333333, 1.66, 0.083333333333333
42331, 1.575, 1.54, 0.083333333333333
42332, 1.575, 1.58, 0.083333333333333
42333, 1.575, 1.62, 0.083333333333333
42334, 1.575, 1.66, 0.083333333333333
42335, 1.6166666666667, 1.54, 0.083333333333333
42336, 1.6166666666667, 1.58, 0.083333333333333
42337, 1.6166666666667, 1.62, 0.083333333333333
42338, 1.6166666666667, 1.66, 0.083333333333333
42339, 1.6583333333333, 1.54, 0.083333333333333
42340, 1.6583333333333, 1.58, 0.083333333333333
42341, 1.6583333333333, 1.62, 0.083333333333333
42342, 1.6583333333333, 1.66, 0.083333333333333
42343, 1.7, 1.54, 0.083333333333333
42344, 1.7, 1.58, 0.083333333333333
42345, 1.7, 1.62, 0.083333333333333
42346, 1.7, 1.66, 0.083333333333333
42347, 1.7416666666667, 1.54, 0.083333333333333
42348, 1.7416666666667, 1.58, 0.083333333333333
42349, 1.7416666666667, 1.62, 0.083333333333333
42350, 1.7416666666667, 1.66, 0.083333333333333
42351, 1.7833333333333, 1.54, 0.083333333333333
42352, 1.7833333333333, 1.58, 0.083333333333333
42353, 1.7833333333333, 1.62, 0.083333333333333
42354, 1.7833333333333, 1.66, 0.083333333333333
42355, 1.825, 1.54, 0.083333333333333
42356, 1.825, 1.58, 0.083333333333333
42357, 1.825, 1.62, 0.083333333333333
42358, 1.825, 1.66, 0.083333333333333
42359, 1.8666666666667, 1.54, 0.083333333333333
42360, 1.8666666666667, 1.58, 0.083333333333333
42361, 1.8666666666667, 1.62, 0.083333333333333
42362, 1.8666666666667, 1.66, 0.083333333333333
42363, 1.9083333333333, 1.54, 0.083333333333333
42364, 1.9083333333333, 1.58, 0.083333333333333
42365, 1.9083333333333, 1.62, 0.083333333333333
42366, 1.9083333333333, 1.66, 0.083333333333333
42367, 1.95, 1.54, 0.083333333333333
42368, 1.95, 1.58, 0.083333333333333
42369, 1.95, 1.62, 0.083333333333333
42370, 1.95, 1.66, 0.083333333333333
42371, 1.9916666666667, 1.54, 0.083333333333333
42372, 1.9916666666667, 1.58, 0.083333333333333
42373, 1.9916666666667, 1.62, 0.083333333333333
42374, 1.9916666666667, 1.66, 0.083333333333333
42375, 2.0333333333333, 1.54, 0.083333333333333
42376, 2.0333333333333, 1.58, 0.083333333333333
42377, 2.0333333333333, 1.62, 0.083333333333333
42378, 2.0333333333333, 1.66, 0.083333333333333
42379, 2.075, 1.54, 0.083333333333333
42380, 2.075, 1.58, 0.083333333333333
42381, 2.075, 1.62, 0.083333333333333
42382, 2.075, 1.66, 0.083333333333333
42383, 2.1166666666667, 1.54, 0.083333333333333
42384, 2.1166666666667, 1.58, 0.083333333333333
42385, 2.1166666666667, 1.62, 0.083333333333333
42386, 2.1166666666667, 1.66, 0.083333333333333
42387, 2.1583333333333, 1.54, 0.083333333333333
42388, 2.1583333333333, 1.58, 0.083333333333333
42389, 2.1583333333333, 1.62, 0.083333333333333
42390, 2.1583333333333, 1.66, 0.083333333333333
42391, 1.2416666666667, 1.54, 0.125
42392, 1.2416666666667, 1.58, 0.125
42393, 1.2416666666667, 1.62, 0.125
42394, 1.2416666666667, 1.66, 0.125
42395, 1.2833333333333, 1.54, 0.125
42396, 1.2833333333333, 1.58, 0.125
42397, 1.2833333333333, 1.62, 0.125
42398, 1.2833333333333, 1.66, 0.125
42399, 1.325, 1.54, 0.125
42400, 1.325, 1.58, 0.125
42401, 1.325, 1.62, 0.125
42402, 1.325, 1.66, 0.125
42403, 1.3666666666667, 1.54, 0.125
42404, 1.3666666666667, 1.58, 0.125
42405, 1.3666666666667, 1.62, 0.125
42406, 1.3666666666667, 1.66, 0.125
42407, 1.4083333333333, 1.54, 0.125
42408, 1.4083333333333, 1.58, 0.125
42409, 1.4083333333333, 1.62, 0.125
42410, 1.4083333333333, 1.66, 0.125
42411, 1.45, 1.54, 0.125
42412, 1.45, 1.58, 0.125
42413, 1.45, 1.62, 0.125
42414, 1.45, 1.66, 0.125
42415, 1.4916666666667, 1.54, 0.125
42416, 1.4916666666667, 1.58, 0.125
42417, 1.4916666666667, 1.62, 0.125
42418, 1.4916666666667, 1.66, 0.125
42419, 1.5333333333333, 1.54, 0.125
42420, 1.5333333333333, 1.58, 0.125
42421, 1.5333333333333, 1.62, 0.125
42422, 1.5333333333333, 1.66, 0.125
42423, 1.575, 1.54, 0.125
42424, 1.575, 1.58, 0.125
42425, 1.575, 1.62, 0.125
42426, 1.575, 1.66, 0.125
42427, 1.6166666666667, 1.54, 0.125
42428, 1.6166666666667, 1.58, 0.125
42429, 1.6166666666667, 1.62, 0.125
42430, 1.6166666666667, 1.66, 0.125
42431, 1.6583333333333, 1.54, 0.125
42432, 1.6583333333333, 1.58, 0.125
42433, 1.6583333333333, 1.62, 0.125
42434, 1.6583333333333, 1.66, 0.125
42435, 1.7, 1.54, 0.125
42436, 1.7, 1.58, 0.125
42437, 1.7, 1.62, 0.125
42438, 1.7, 1.66, 0.125
42439, 1.7416666666667, 1.54, 0.125
42440, 1.7416666666667, 1.58, 0.125
42441, 1.7416666666667, 1.62, 0.125
42442, 1.7416666666667, 1.66, 0.125
42443, 1.7833333333333, 1.54, 0.125
42444, 1.7833333333333, 1.58, 0.125
42445, 1.7833333333333, 1.62, 0.125
42446, 1.7833333333333, 1.66, 0.125
42447, 1.825, 1.54, 0.125
42448, 1.825, 1.58, 0.125
42449, 1.825, 1.62, 0.125
42450, 1.825, 1.66, 0.125
42451, 1.8666666666667, 1.54, 0.125
42452, 1.8666666666667, 1.58, 0.125
42453, 1.8666666666667, 1.62, 0.125
42454, 1.8666666666667, 1.66, 0.125
42455, 1.9083333333333, 1.54, 0.125
42456, 1.9083333333333, 1.58, 0.125
42457, 1.9083333333333, 1.62, 0.125
42458, 1.9083333333333, 1.66, 0.125
42459, 1.95, 1.54, 0.125
42460, 1.95, 1.58, 0.125
42461, 1.95, 1.62, 0.125
42462, 1.95, 1.66, 0.125
42463, 1.9916666666667, 1.54, 0.125
42464, 1.9916666666667, 1.58, 0.125
42465, 1.9916666666667, 1.62, 0.125
42466, 1.9916666666667, 1.66, 0.125
42467, 2.0333333333333, 1.54, 0.125
42468, 2.0333333333333, 1.58, 0.125
42469, 2.0333333333333, 1.62, 0.125
42470, 2.0333333333333, 1.66, 0.125
42471, 2.075, 1.54, 0.125
42472, 2.075, 1.58, 0.125
42473, 2.075, 1.62, 0.125
42474, 2.075, 1.66, 0.125
42475, 2.1166666666667, 1.54, 0.125
42476, 2.1166666666667, 1.58, 0.125
42477, 2.1166666666667, 1.62, 0.125
42478, 2.1166666666667, 1.66, 0.125
42479, 2.1583333333333, 1.54, 0.125
42480, 2.1583333333333, 1.58, 0.125
42481, 2.1583333333333, 1.62, 0.125
42482, 2.1583333333333, 1.66, 0.125
42483, 1.2416666666667, 1.54, 0.16666666666667
42484, 1.2416666666667, 1.58, 0.16666666666667
42485, 1.2416666666667, 1.62, 0.16666666666667
42486, 1.2416666666667, 1.66, 0.16666666666667
42487, 1.2833333333333, 1.54, 0.16666666666667
42488, 1.2833333333333, 1.58, 0.16666666666667
42489, 1.2833333333333, 1.62, 0.16666666666667
42490, 1.2833333333333, 1.66, 0.16666666666667
42491, 1.325, 1.54, 0.16666666666667
42492, 1.325, 1.58, 0.16666666666667
42493, 1.325, 1.62, 0.16666666666667
42494, 1.325, 1.66, 0.16666666666667
42495, 1.3666666666667, 1.54, 0.16666666666667
42496, 1.3666666666667, 1.58, 0.16666666666667
42497, 1.3666666666667, 1.62, 0.16666666666667
42498, 1.3666666666667, 1.66, 0.16666666666667
42499, 1.4083333333333, 1.54, 0.16666666666667
42500, 1.4083333333333, 1.58, 0.16666666666667
42501, 1.4083333333333, 1.62, 0.16666666666667
42502, 1.4083333333333, 1.66, 0.16666666666667
42503, 1.45, 1.54, 0.16666666666667
42504, 1.45, 1.58, 0.16666666666667
42505, 1.45, 1.62, 0.16666666666667
42506, 1.45, 1.66, 0.16666666666667
42507, 1.4916666666667, 1.54, 0.16666666666667
42508, 1.4916666666667, 1.58, 0.16666666666667
42509, 1.4916666666667, 1.62, 0.16666666666667
42510, 1.4916666666667, 1.66, 0.16666666666667
42511, 1.5333333333333, 1.54, 0.16666666666667
42512, 1.5333333333333, 1.58, 0.16666666666667
42513, 1.5333333333333, 1.62, 0.16666666666667
42514, 1.5333333333333, 1.66, 0.16666666666667
42515, 1.575, 1.54, 0.16666666666667
42516, 1.575, 1.58, 0.16666666666667
42517, 1.575, 1.62, 0.16666666666667
42518, 1.575, 1.66, 0.16666666666667
42519, 1.6166666666667, 1.54, 0.16666666666667
42520, 1.6166666666667, 1.58, 0.16666666666667
42521, 1.6166666666667, 1.62, 0.16666666666667
42522, 1.6166666666667, 1.66, 0.16666666666667
42523, 1.6583333333333, 1.54, 0.16666666666667
42524, 1.6583333333333, 1.58, 0.16666666666667
42525, 1.6583333333333, 1.62, 0.16666666666667
42526, 1.6583333333333, 1.66, 0.16666666666667
42527, 1.7, 1.54, 0.16666666666667
42528, 1.7, 1.58, 0.16666666666667
42529, 1.7, 1.62, 0.16666666666667
42530, 1.7, 1.66, 0.16666666666667
42531, 1.7416666666667, 1.54, 0.16666666666667
42532, 1.7416666666667, 1.58, 0.16666666666667
42533, 1.7416666666667, 1.62, 0.16666666666667
42534, 1.7416666666667, 1.66, 0.16666666666667
42535, 1.7833333333333, 1.54, 0.16666666666667
42536, 1.7833333333333, 1.58, 0.16666666666667
42537, 1.7833333333333, 1.62, 0.16666666666667
42538, 1.7833333333333, 1.66, 0.16666666666667
42539, 1.825, 1.54, 0.16666666666667
42540, 1.825, 1.58, 0.16666666666667
42541, 1.825, 1.62, 0.16666666666667
42542, 1.825, 1.66, 0.16666666666667
42543, 1.8666666666667, 1.54, 0.16666666666667
42544, 1.8666666666667, 1.58, 0.16666666666667
42545, 1.8666666666667, 1.62, 0.16666666666667
42546, 1.8666666666667, 1.66, 0.16666666666667
42547, 1.9083333333333, 1.54, 0.16666666666667
42548, 1.9083333333333, 1.58, 0.16666666666667
42549, 1.9083333333333, 1.62, 0.16666666666667
42550, 1.9083333333333, 1.66, 0.16666666666667
42551, 1.95, 1.54, 0.16666666666667
42552, 1.95, 1.58, 0.16666666666667
42553, 1.95, 1.62, 0.16666666666667
42554, 1.95, 1.66, 0.16666666666667
42555, 1.9916666666667, 1.54, 0.16666666666667
42556, 1.9916666666667, 1.58, 0.16666666666667
42557, 1.9916666666667, 1.62, 0.16666666666667
42558, 1.9916666666667, 1.66, 0.16666666666667
42559, 2.0333333333333, 1.54, 0.16666666666667
42560, 2.0333333333333, 1.58, 0.16666666666667
42561, 2.0333333333333, 1.62, 0.16666666666667
42562, 2.0333333333333, 1.66, 0.16666666666667
42563, 2.075, 1.54, 0.16666666666667
42564, 2.075, 1.58, 0.16666666666667
42565, 2.075, 1.62, 0.16666666666667
42566, 2.075, 1.66, 0.16666666666667
42567, 2.1166666666667, 1.54, 0.16666666666667
42568, 2.1166666666667, 1.58, 0.16666666666667
42569, 2.1166666666667, 1.62, 0.16666666666667
42570, 2.1166666666667, 1.66, 0.16666666666667
42571, 2.1583333333333, 1.54, 0.16666666666667
42572, 2.1583333333333, 1.58, 0.16666666666667
42573, 2.1583333333333, 1.62, 0.16666666666667
42574, 2.1583333333333, 1.66, 0.16666666666667
42575, 1.2416666666667, 1.54, 0.20833333333333
42576, 1.2416666666667, 1.58, 0.20833333333333
42577, 1.2416666666667, 1.62, 0.20833333333333
42578, 1.2416666666667, 1.66, 0.20833333333333
42579, 1.2833333333333, 1.54, 0.20833333333333
42580, 1.2833333333333, 1.58, 0.20833333333333
42581, 1.2833333333333, 1.62, 0.20833333333333
42582, 1.2833333333333, 1.66, 0.20833333333333
42583, 1.325, 1.54, 0.20833333333333
42584, 1.325, 1.58, 0.20833333333333
42585, 1.325, 1.62, 0.20833333333333
42586, 1.325, 1.66, 0.20833333333333
42587, 1.3666666666667, 1.54, 0.20833333333333
42588, 1.3666666666667, 1.58, 0.20833333333333
42589, 1.3666666666667, 1.62, 0.20833333333333
42590, 1.3666666666667, 1.66, 0.20833333333333
42591, 1.4083333333333, 1.54, 0.20833333333333
42592, 1.4083333333333, 1.58, 0.20833333333333
42593, 1.4083333333333, 1.62, 0.20833333333333
42594, 1.4083333333333, 1.66, 0.20833333333333
42595, 1.45, 1.54, 0.20833333333333
42596, 1.45, 1.58, 0.20833333333333
42597, 1.45, 1.62, 0.20833333333333
42598, 1.45, 1.66, 0.20833333333333
42599, 1.4916666666667, 1.54, 0.20833333333333
42600, 1.4916666666667, 1.58, 0.20833333333333
42601, 1.4916666666667, 1.62, 0.20833333333333
42602, 1.4916666666667, 1.66, 0.20833333333333
42603, 1.5333333333333, 1.54, 0.20833333333333
42604, 1.5333333333333, 1.58, 0.20833333333333
42605, 1.5333333333333, 1.62, 0.20833333333333
42606, 1.5333333333333, 1.66, 0.20833333333333
42607, 1.575, 1.54, 0.20833333333333
42608, 1.575, 1.58, 0.20833333333333
42609, 1.575, 1.62, 0.20833333333333
42610, 1.575, 1.66, 0.20833333333333
42611, 1.6166666666667, 1.54, 0.20833333333333
42612, 1.6166666666667, 1.58, 0.20833333333333
42613, 1.6166666666667, 1.62, 0.20833333333333
42614, 1.6166666666667, 1.66, 0.20833333333333
42615, 1.6583333333333, 1.54, 0.20833333333333
42616, 1.6583333333333, 1.58, 0.20833333333333
42617, 1.6583333333333, 1.62, 0.20833333333333
42618, 1.6583333333333, 1.66, 0.20833333333333
42619, 1.7, 1.54, 0.20833333333333
42620, 1.7, 1.58, 0.20833333333333
42621, 1.7, 1.62, 0.20833333333333
42622, 1.7, 1.66, 0.20833333333333
42623, 1.7416666666667, 1.54, 0.20833333333333
42624, 1.7416666666667, 1.58, 0.20833333333333
42625, 1.7416666666667, 1.62, 0.20833333333333
42626, 1.7416666666667, 1.66, 0.20833333333333
42627, 1.7833333333333, 1.54, 0.20833333333333
42628, 1.7833333333333, 1.58, 0.20833333333333
42629, 1.7833333333333, 1.62, 0.20833333333333
42630, 1.7833333333333, 1.66, 0.20833333333333
42631, 1.825, 1.54, 0.20833333333333
42632, 1.825, 1.58, 0.20833333333333
42633, 1.825, 1.62, 0.20833333333333
42634, 1.825, 1.66, 0.20833333333333
42635, 1.8666666666667, 1.54, 0.20833333333333
42636, 1.8666666666667, 1.58, 0.20833333333333
42637, 1.8666666666667, 1.62, 0.20833333333333
42638, 1.8666666666667, 1.66, 0.20833333333333
42639, 1.9083333333333, 1.54, 0.20833333333333
42640, 1.9083333333333, 1.58, 0.20833333333333
42641, 1.9083333333333, 1.62, 0.20833333333333
42642, 1.9083333333333, 1.66, 0.20833333333333
42643, 1.95, 1.54, 0.20833333333333
42644, 1.95, 1.58, 0.20833333333333
42645, 1.95, 1.62, 0.20833333333333
42646, 1.95, 1.66, 0.20833333333333
42647, 1.9916666666667, 1.54, 0.20833333333333
42648, 1.9916666666667, 1.58, 0.20833333333333
42649, 1.9916666666667, 1.62, 0.20833333333333
42650, 1.9916666666667, 1.66, 0.20833333333333
42651, 2.0333333333333, 1.54, 0.20833333333333
42652, 2.0333333333333, 1.58, 0.20833333333333
42653, 2.0333333333333, 1.62, 0.20833333333333
42654, 2.0333333333333, 1.66, 0.20833333333333
42655, 2.075, 1.54, 0.20833333333333
42656, 2.075, 1.58, 0.20833333333333
42657, 2.075, 1.62, 0.20833333333333
42658, 2.075, 1.66, 0.20833333333333
42659, 2.1166666666667, 1.54, 0.20833333333333
42660, 2.1166666666667, 1.58, 0.20833333333333
42661, 2.1166666666667, 1.62, 0.20833333333333
42662, 2.1166666666667, 1.66, 0.20833333333333
42663, 2.1583333333333, 1.54, 0.20833333333333
42664, 2.1583333333333, 1.58, 0.20833333333333
42665, 2.1583333333333, 1.62, 0.20833333333333
42666, 2.1583333333333, 1.66, 0.20833333333333
42667, 1.2416666666667, 1.54, 0.25
42668, 1.2416666666667, 1.58, 0.25
42669, 1.2416666666667, 1.62, 0.25
42670, 1.2416666666667, 1.66, 0.25
42671, 1.2833333333333, 1.54, 0.25
42672, 1.2833333333333, 1.58, 0.25
42673, 1.2833333333333, 1.62, 0.25
42674, 1.2833333333333, 1.66, 0.25
42675, 1.325, 1.54, 0.25
42676, 1.325, 1.58, 0.25
42677, 1.325, 1.62, 0.25
42678, 1.325, 1.66, 0.25
42679, 1.3666666666667, 1.54, 0.25
42680, 1.3666666666667, 1.58, 0.25
42681, 1.3666666666667, 1.62, 0.25
42682, 1.3666666666667, 1.66, 0.25
42683, 1.4083333333333, 1.54, 0.25
42684, 1.4083333333333, 1.58, 0.25
42685, 1.4083333333333, 1.62, 0.25
42686, 1.4083333333333, 1.66, 0.25
42687, 1.45, 1.54, 0.25
42688, 1.45, 1.58, 0.25
42689, 1.45, 1.62, 0.25
42690, 1.45, 1.66, 0.25
42691, 1.4916666666667, 1.54, 0.25
42692, 1.4916666666667, 1.58, 0.25
42693, 1.4916666666667, 1.62, 0.25
42694, 1.4916666666667, 1.66, 0.25
42695, 1.5333333333333, 1.54, 0.25
42696, 1.5333333333333, 1.58, 0.25
42697, 1.5333333333333, 1.62, 0.25
42698, 1.5333333333333, 1.66, 0.25
42699, 1.575, 1.54, 0.25
42700, 1.575, 1.58, 0.25
42701, 1.575, 1.62, 0.25
42702, 1.575, 1.66, 0.25
42703, 1.6166666666667, 1.54, 0.25
42704, 1.6166666666667, 1.58, 0.25
42705, 1.6166666666667, 1.62, 0.25
42706, 1.6166666666667, 1.66, 0.25
42707, 1.6583333333333, 1.54, 0.25
42708, 1.6583333333333, 1.58, 0.25
42709, 1.6583333333333, 1.62, 0.25
42710, 1.6583333333333, 1.66, 0.25
42711, 1.7, 1.54, 0.25
42712, 1.7, 1.58, 0.25
42713, 1.7, 1.62, 0.25
42714, 1.7, 1.66, 0.25
42715, 1.7416666666667, 1.54, 0.25
42716, 1.7416666666667, 1.58, 0.25
42717, 1.7416666666667, 1.62, 0.25
42718, 1.7416666666667, 1.66, 0.25
42719, 1.7833333333333, 1.54, 0.25
42720, 1.7833333333333, 1.58, 0.25
42721, 1.7833333333333, 1.62, 0.25
42722, 1.7833333333333, 1.66, 0.25
42723, 1.825, 1.54, 0.25
42724, 1.825, 1.58, 0.25
42725, 1.825, 1.62, 0.25
42726, 1.825, 1.66, 0.25
42727, 1.8666666666667, 1.54, 0.25
42728, 1.8666666666667, 1.58, 0.25
42729, 1.8666666666667, 1.62, 0.25
42730, 1.8666666666667, 1.66, 0.25
42731, 1.9083333333333, 1.54, 0.25
42732, 1.9083333333333, 1.58, 0.25
42733, 1.9083333333333, 1.62, 0.25
42734, 1.9083333333333, 1.66, 0.25
42735, 1.95, 1.54, 0.25
42736, 1.95, 1.58, 0.25
42737, 1.95, 1.62, 0.25
42738, 1.95, 1.66, 0.25
42739, 1.9916666666667, 1.54, 0.25
42740, 1.9916666666667, 1.58, 0.25
42741, 1.9916666666667, 1.62, 0.25
42742, 1.9916666666667, 1.66, 0.25
42743, 2.0333333333333, 1.54, 0.25
42744, 2.0333333333333, 1.58, 0.25
42745, 2.0333333333333, 1.62, 0.25
42746, 2.0333333333333, 1.66, 0.25
42747, 2.075, 1.54, 0.25
42748, 2.075, 1.58, 0.25
42749, 2.075, 1.62, 0.25
42750, 2.075, 1.66, 0.25
42751, 2.1166666666667, 1.54, 0.25
42752, 2.1166666666667, 1.58, 0.25
42753, 2.1166666666667, 1.62, 0.25
42754, 2.1166666666667, 1.66, 0.25
42755, 2.1583333333333, 1.54, 0.25
42756, 2.1583333333333, 1.58, 0.25
42757, 2.1583333333333, 1.62, 0.25
42758, 2.1583333333333, 1.66, 0.25
42759, 1.2416666666667, 1.54, 0.29166666666667
42760, 1.2416666666667, 1.58, 0.29166666666667
42761, 1.2416666666667, 1.62, 0.29166666666667
42762, 1.2416666666667, 1.66, 0.29166666666667
42763, 1.2833333333333, 1.54, 0.29166666666667
42764, 1.2833333333333, 1.58, 0.29166666666667
42765, 1.2833333333333, 1.62, 0.29166666666667
42766, 1.2833333333333, 1.66, 0.29166666666667
42767, 1.325, 1.54, 0.29166666666667
42768, 1.325, 1.58, 0.29166666666667
42769, 1.325, 1.62, 0.29166666666667
42770, 1.325, 1.66, 0.29166666666667
42771, 1.3666666666667, 1.54, 0.29166666666667
42772, 1.3666666666667, 1.58, 0.29166666666667
42773, 1.3666666666667, 1.62, 0.29166666666667
42774, 1.3666666666667, 1.66, 0.29166666666667
42775, 1.4083333333333, 1.54, 0.29166666666667
42776, 1.4083333333333, 1.58, 0.29166666666667
42777, 1.4083333333333, 1.62, 0.29166666666667
42778, 1.4083333333333, 1.66, 0.29166666666667
42779, 1.45, 1.54, 0.29166666666667
42780, 1.45, 1.58, 0.29166666666667
42781, 1.45, 1.62, 0.29166666666667
42782, 1.45, 1.66, 0.29166666666667
42783, 1.4916666666667, 1.54, 0.29166666666667
42784, 1.4916666666667, 1.58, 0.29166666666667
42785, 1.4916666666667, 1.62, 0.29166666666667
42786, 1.4916666666667, 1.66, 0.29166666666667
42787, 1.5333333333333, 1.54, 0.29166666666667
42788, 1.5333333333333, 1.58, 0.29166666666667
42789, 1.5333333333333, 1.62, 0.29166666666667
42790, 1.5333333333333, 1.66, 0.29166666666667
42791, 1.575, 1.54, 0.29166666666667
42792, 1.575, 1.58, 0.29166666666667
42793, 1.575, 1.62, 0.29166666666667
42794, 1.575, 1.66, 0.29166666666667
42795, 1.6166666666667, 1.54, 0.29166666666667
42796, 1.6166666666667, 1.58, 0.29166666666667
42797, 1.6166666666667, 1.62, 0.29166666666667
42798, 1.6166666666667, 1.66, 0.29166666666667
42799, 1.6583333333333, 1.54, 0.29166666666667
42800, 1.6583333333333, 1.58, 0.29166666666667
42801, 1.6583333333333, 1.62, 0.29166666666667
42802, 1.6583333333333, 1.66, 0.29166666666667
42803, 1.7, 1.54, 0.29166666666667
42804, 1.7, 1.58, 0.29166666666667
42805, 1.7, 1.62, 0.29166666666667
42806, 1.7, 1.66, 0.29166666666667
42807, 1.7416666666667, 1.54, 0.29166666666667
42808, 1.7416666666667, 1.58, 0.29166666666667
42809, 1.7416666666667, 1.62, 0.29166666666667
42810, 1.7416666666667, 1.66, 0.29166666666667
42811, 1.7833333333333, 1.54, 0.29166666666667
42812, 1.7833333333333, 1.58, 0.29166666666667
42813, 1.7833333333333, 1.62, 0.29166666666667
42814, 1.7833333333333, 1.66, 0.29166666666667
42815, 1.825, 1.54, 0.29166666666667
42816, 1.825, 1.58, 0.29166666666667
42817, 1.825, 1.62, 0.29166666666667
42818, 1.825, 1.66, 0.29166666666667
42819, 1.8666666666667, 1.54, 0.29166666666667
42820, 1.8666666666667, 1.58, 0.29166666666667
42821, 1.8666666666667, 1.62, 0.29166666666667
42822, 1.8666666666667, 1.66, 0.29166666666667
42823, 1.9083333333333, 1.54, 0.29166666666667
42824, 1.9083333333333, 1.58, 0.29166666666667
42825, 1.9083333333333, 1.62, 0.29166666666667
42826, 1.9083333333333, 1.66, 0.29166666666667
42827, 1.95, 1.54, 0.29166666666667
42828, 1.95, 1.58, 0.29166666666667
42829, 1.95, 1.62, 0.29166666666667
42830, 1.95, 1.66, 0.29166666666667
42831, 1.9916666666667, 1.54, 0.29166666666667
42832, 1.9916666666667, 1.58, 0.29166666666667
42833, 1.9916666666667, 1.62, 0.29166666666667
42834, 1.9916666666667, 1.66, 0.29166666666667
42835, 2.0333333333333, 1.54, 0.29166666666667
42836, 2.0333333333333, 1.58, 0.29166666666667
42837, 2.0333333333333, 1.62, 0.29166666666667
42838, 2.0333333333333, 1.66, 0.29166666666667
42839, 2.075, 1.54, 0.29166666666667
42840, 2.075, 1.58, 0.29166666666667
42841, 2.075, 1.62, 0.29166666666667
42842, 2.075, 1.66, 0.29166666666667
42843, 2.1166666666667, 1.54, 0.29166666666667
42844, 2.1166666666667, 1.58, 0.29166666666667
42845, 2.1166666666667, 1.62, 0.29166666666667
42846, 2.1166666666667, 1.66, 0.29166666666667
42847, 2.1583333333333, 1.54, 0.29166666666667
42848, 2.1583333333333, 1.58, 0.29166666666667
42849, 2.1583333333333, 1.62, 0.29166666666667
42850, 2.1583333333333, 1.66, 0.29166666666667
42851, 1.2416666666667, 1.54, 0.33333333333333
42852, 1.2416666666667, 1.58, 0.33333333333333
42853, 1.2416666666667, 1.62, 0.33333333333333
42854, 1.2416666666667, 1.66, 0.33333333333333
42855, 1.2833333333333, 1.54, 0.33333333333333
42856, 1.2833333333333, 1.58, 0.33333333333333
42857, 1.2833333333333, 1.62, 0.33333333333333
42858, 1.2833333333333, 1.66, 0.33333333333333
42859, 1.325, 1.54, 0.33333333333333
42860, 1.325, 1.58, 0.33333333333333
42861, 1.325, 1.62, 0.33333333333333
42862, 1.325, 1.66, 0.33333333333333
42863, 1.3666666666667, 1.54, 0.33333333333333
42864, 1.3666666666667, 1.58, 0.33333333333333
42865, 1.3666666666667, 1.62, 0.33333333333333
42866, 1.3666666666667, 1.66, 0.33333333333333
42867, 1.4083333333333, 1.54, 0.33333333333333
42868, 1.4083333333333, 1.58, 0.33333333333333
42869, 1.4083333333333, 1.62, 0.33333333333333
42870, 1.4083333333333, 1.66, 0.33333333333333
42871, 1.45, 1.54, 0.33333333333333
42872, 1.45, 1.58, 0.33333333333333
42873, 1.45, 1.62, 0.33333333333333
42874, 1.45, 1.66, 0.33333333333333
42875, 1.4916666666667, 1.54, 0.33333333333333
42876, 1.4916666666667, 1.58, 0.33333333333333
42877, 1.4916666666667, 1.62, 0.33333333333333
42878, 1.4916666666667, 1.66, 0.33333333333333
42879, 1.5333333333333, 1.54, 0.33333333333333
42880, 1.5333333333333, 1.58, 0.33333333333333
42881, 1.5333333333333, 1.62, 0.33333333333333
42882, 1.5333333333333, 1.66, 0.33333333333333
42883, 1.575, 1.54, 0.33333333333333
42884, 1.575, 1.58, 0.33333333333333
42885, 1.575, 1.62, 0.33333333333333
42886, 1.575, 1.66, 0.33333333333333
42887, 1.6166666666667, 1.54, 0.33333333333333
42888, 1.6166666666667, 1.58, 0.33333333333333
42889, 1.6166666666667, 1.62, 0.33333333333333
42890, 1.6166666666667, 1.66, 0.33333333333333
42891, 1.6583333333333, 1.54, 0.33333333333333
42892, 1.6583333333333, 1.58, 0.33333333333333
42893, 1.6583333333333, 1.62, 0.33333333333333
42894, 1.6583333333333, 1.66, 0.33333333333333
42895, 1.7, 1.54, 0.33333333333333
42896, 1.7, 1.58, 0.33333333333333
42897, 1.7, 1.62, 0.33333333333333
42898, 1.7, 1.66, 0.33333333333333
42899, 1.7416666666667, 1.54, 0.33333333333333
42900, 1.7416666666667, 1.58, 0.33333333333333
42901, 1.7416666666667, 1.62, 0.33333333333333
42902, 1.7416666666667, 1.66, 0.33333333333333
42903, 1.7833333333333, 1.54, 0.33333333333333
42904, 1.7833333333333, 1.58, 0.33333333333333
42905, 1.7833333333333, 1.62, 0.33333333333333
42906, 1.7833333333333, 1.66, 0.33333333333333
42907, 1.825, 1.54, 0.33333333333333
42908, 1.825, 1.58, 0.33333333333333
42909, 1.825, 1.62, 0.33333333333333
42910, 1.825, 1.66, 0.33333333333333
42911, 1.8666666666667, 1.54, 0.33333333333333
42912, 1.8666666666667, 1.58, 0.33333333333333
42913, 1.8666666666667, 1.62, 0.33333333333333
42914, 1.8666666666667, 1.66, 0.33333333333333
42915, 1.9083333333333, 1.54, 0.33333333333333
42916, 1.9083333333333, 1.58, 0.33333333333333
42917, 1.9083333333333, 1.62, 0.33333333333333
42918, 1.9083333333333, 1.66, 0.33333333333333
42919, 1.95, 1.54, 0.33333333333333
42920, 1.95, 1.58, 0.33333333333333
42921, 1.95, 1.62, 0.33333333333333
42922, 1.95, 1.66, 0.33333333333333
42923, 1.9916666666667, 1.54, 0.33333333333333
42924, 1.9916666666667, 1.58, 0.33333333333333
42925, 1.9916666666667, 1.62, 0.33333333333333
42926, 1.9916666666667, 1.66, 0.33333333333333
42927, 2.0333333333333, 1.54, 0.33333333333333
42928, 2.0333333333333, 1.58, 0.33333333333333
42929, 2.0333333333333, 1.62, 0.33333333333333
42930, 2.0333333333333, 1.66, 0.33333333333333
42931, 2.075, 1.54, 0.33333333333333
42932, 2.075, 1.58, 0.33333333333333
42933, 2.075, 1.62, 0.33333333333333
42934, 2.075, 1.66, 0.33333333333333
42935, 2.1166666666667, 1.54, 0.33333333333333
42936, 2.1166666666667, 1.58, 0.33333333333333
42937, 2.1166666666667, 1.62, 0.33333333333333
42938, 2.1166666666667, 1.66, 0.33333333333333
42939, 2.1583333333333, 1.54, 0.33333333333333
42940, 2.1583333333333, 1.58, 0.33333333333333
42941, 2.1583333333333, 1.62, 0.33333333333333
42942, 2.1583333333333, 1.66, 0.33333333333333
42943, 1.2416666666667, 1.54, 0.375
42944, 1.2416666666667, 1.58, 0.375
42945, 1.2416666666667, 1.62, 0.375
42946, 1.2416666666667, 1.66, 0.375
42947, 1.2833333333333, 1.54, 0.375
42948, 1.2833333333333, 1.58, 0.375
42949, 1.2833333333333, 1.62, 0.375
42950, 1.2833333333333, 1.66, 0.375
42951, 1.325, 1.54, 0.375
42952, 1.325, 1.58, 0.375
42953, 1.325, 1.62, 0.375
42954, 1.325, 1.66, 0.375
42955, 1.3666666666667, 1.54, 0.375
42956, 1.3666666666667, 1.58, 0.375
42957, 1.3666666666667, 1.62, 0.375
42958, 1.3666666666667, 1.66, 0.375
42959, 1.4083333333333, 1.54, 0.375
42960, 1.4083333333333, 1.58, 0.375
42961, 1.4083333333333, 1.62, 0.375
42962, 1.4083333333333, 1.66, 0.375
42963, 1.45, 1.54, 0.375
42964, 1.45, 1.58, 0.375
42965, 1.45, 1.62, 0.375
42966, 1.45, 1.66, 0.375
42967, 1.4916666666667, 1.54, 0.375
42968, 1.4916666666667, 1.58, 0.375
42969, 1.4916666666667, 1.62, 0.375
42970, 1.4916666666667, 1.66, 0.375
42971, 1.5333333333333, 1.54, 0.375
42972, 1.5333333333333, 1.58, 0.375
42973, 1.5333333333333, 1.62, 0.375
42974, 1.5333333333333, 1.66, 0.375
42975, 1.575, 1.54, 0.375
42976, 1.575, 1.58, 0.375
42977, 1.575, 1.62, 0.375
42978, 1.575, 1.66, 0.375
42979, 1.6166666666667, 1.54, 0.375
42980, 1.6166666666667, 1.58, 0.375
42981, 1.6166666666667, 1.62, 0.375
42982, 1.6166666666667, 1.66, 0.375
42983, 1.6583333333333, 1.54, 0.375
42984, 1.6583333333333, 1.58, 0.375
42985, 1.6583333333333, 1.62, 0.375
42986, 1.6583333333333, 1.66, 0.375
42987, 1.7, 1.54, 0.375
42988, 1.7, 1.58, 0.375
42989, 1.7, 1.62, 0.375
42990, 1.7, 1.66, 0.375
42991, 1.7416666666667, 1.54, 0.375
42992, 1.7416666666667, 1.58, 0.375
42993, 1.7416666666667, 1.62, 0.375
42994, 1.7416666666667, 1.66, 0.375
42995, 1.7833333333333, 1.54, 0.375
42996, 1.7833333333333, 1.58, 0.375
42997, 1.7833333333333, 1.62, 0.375
42998, 1.7833333333333, 1.66, 0.375
42999, 1.825, 1.54, 0.375
43000, 1.825, 1.58, 0.375
43001, 1.825, 1.62, 0.375
43002, 1.825, 1.66, 0.375
43003, 1.8666666666667, 1.54, 0.375
43004, 1.8666666666667, 1.58, 0.375
43005, 1.8666666666667, 1.62, 0.375
43006, 1.8666666666667, 1.66, 0.375
43007, 1.9083333333333, 1.54, 0.375
43008, 1.9083333333333, 1.58, 0.375
43009, 1.9083333333333, 1.62, 0.375
43010, 1.9083333333333, 1.66, 0.375
43011, 1.95, 1.54, 0.375
43012, 1.95, 1.58, 0.375
43013, 1.95, 1.62, 0.375
43014, 1.95, 1.66, 0.375
43015, 1.9916666666667, 1.54, 0.375
43016, 1.9916666666667, 1.58, 0.375
43017, 1.9916666666667, 1.62, 0.375
43018, 1.9916666666667, 1.66, 0.375
43019, 2.0333333333333, 1.54, 0.375
43020, 2.0333333333333, 1.58, 0.375
43021, 2.0333333333333, 1.62, 0.375
43022, 2.0333333333333, 1.66, 0.375
43023, 2.075, 1.54, 0.375
43024, 2.075, 1.58, 0.375
43025, 2.075, 1.62, 0.375
43026, 2.075, 1.66, 0.375
43027, 2.1166666666667, 1.54, 0.375
43028, 2.1166666666667, 1.58, 0.375
43029, 2.1166666666667, 1.62, 0.375
43030, 2.1166666666667, 1.66, 0.375
43031, 2.1583333333333, 1.54, 0.375
43032, 2.1583333333333, 1.58, 0.375
43033, 2.1583333333333, 1.62, 0.375
43034, 2.1583333333333, 1.66, 0.375
43035, 1.2416666666667, 1.54, 0.41666666666667
43036, 1.2416666666667, 1.58, 0.41666666666667
43037, 1.2416666666667, 1.62, 0.41666666666667
43038, 1.2416666666667, 1.66, 0.41666666666667
43039, 1.2833333333333, 1.54, 0.41666666666667
43040, 1.2833333333333, 1.58, 0.41666666666667
43041, 1.2833333333333, 1.62, 0.41666666666667
43042, 1.2833333333333, 1.66, 0.41666666666667
43043, 1.325, 1.54, 0.41666666666667
43044, 1.325, 1.58, 0.41666666666667
43045, 1.325, 1.62, 0.41666666666667
43046, 1.325, 1.66, 0.41666666666667
43047, 1.3666666666667, 1.54, 0.41666666666667
43048, 1.3666666666667, 1.58, 0.41666666666667
43049, 1.3666666666667, 1.62, 0.41666666666667
43050, 1.3666666666667, 1.66, 0.41666666666667
43051, 1.4083333333333, 1.54, 0.41666666666667
43052, 1.4083333333333, 1.58, 0.41666666666667
43053, 1.4083333333333, 1.62, 0.41666666666667
43054, 1.4083333333333, 1.66, 0.41666666666667
43055, 1.45, 1.54, 0.41666666666667
43056, 1.45, 1.58, 0.41666666666667
43057, 1.45, 1.62, 0.41666666666667
43058, 1.45, 1.66, 0.41666666666667
43059, 1.4916666666667, 1.54, 0.41666666666667
43060, 1.4916666666667, 1.58, 0.41666666666667
43061, 1.4916666666667, 1.62, 0.41666666666667
43062, 1.4916666666667, 1.66, 0.41666666666667
43063, 1.5333333333333, 1.54, 0.41666666666667
43064, 1.5333333333333, 1.58, 0.41666666666667
43065, 1.5333333333333, 1.62, 0.41666666666667
43066, 1.5333333333333, 1.66, 0.41666666666667
43067, 1.575, 1.54, 0.41666666666667
43068, 1.575, 1.58, 0.41666666666667
43069, 1.575, 1.62, 0.41666666666667
43070, 1.575, 1.66, 0.41666666666667
43071, 1.6166666666667, 1.54, 0.41666666666667
43072, 1.6166666666667, 1.58, 0.41666666666667
43073, 1.6166666666667, 1.62, 0.41666666666667
43074, 1.6166666666667, 1.66, 0.41666666666667
43075, 1.6583333333333, 1.54, 0.41666666666667
43076, 1.6583333333333, 1.58, 0.41666666666667
43077, 1.6583333333333, 1.62, 0.41666666666667
43078, 1.6583333333333, 1.66, 0.41666666666667
43079, 1.7, 1.54, 0.41666666666667
43080, 1.7, 1.58, 0.41666666666667
43081, 1.7, 1.62, 0.41666666666667
43082, 1.7, 1.66, 0.41666666666667
43083, 1.7416666666667, 1.54, 0.41666666666667
43084, 1.7416666666667, 1.58, 0.41666666666667
43085, 1.7416666666667, 1.62, 0.41666666666667
43086, 1.7416666666667, 1.66, 0.41666666666667
43087, 1.7833333333333, 1.54, 0.41666666666667
43088, 1.7833333333333, 1.58, 0.41666666666667
43089, 1.7833333333333, 1.62, 0.41666666666667
43090, 1.7833333333333, 1.66, 0.41666666666667
43091, 1.825, 1.54, 0.41666666666667
43092, 1.825, 1.58, 0.41666666666667
43093, 1.825, 1.62, 0.41666666666667
43094, 1.825, 1.66, 0.41666666666667
43095, 1.8666666666667, 1.54, 0.41666666666667
43096, 1.8666666666667, 1.58, 0.41666666666667
43097, 1.8666666666667, 1.62, 0.41666666666667
43098, 1.8666666666667, 1.66, 0.41666666666667
43099, 1.9083333333333, 1.54, 0.41666666666667
43100, 1.9083333333333, 1.58, 0.41666666666667
43101, 1.9083333333333, 1.62, 0.41666666666667
43102, 1.9083333333333, 1.66, 0.41666666666667
43103, 1.95, 1.54, 0.41666666666667
43104, 1.95, 1.58, 0.41666666666667
43105, 1.95, 1.62, 0.41666666666667
43106, 1.95, 1.66, 0.41666666666667
43107, 1.9916666666667, 1.54, 0.41666666666667
43108, 1.9916666666667, 1.58, 0.41666666666667
43109, 1.9916666666667, 1.62, 0.41666666666667
43110, 1.9916666666667, 1.66, 0.41666666666667
43111, 2.0333333333333, 1.54, 0.41666666666667
43112, 2.0333333333333, 1.58, 0.41666666666667
43113, 2.0333333333333, 1.62, 0.41666666666667
43114, 2.0333333333333, 1.66, 0.41666666666667
43115, 2.075, 1.54, 0.41666666666667
43116, 2.075, 1.58, 0.41666666666667
43117, 2.075, 1.62, 0.41666666666667
43118, 2.075, 1.66, 0.41666666666667
43119, 2.1166666666667, 1.54, 0.41666666666667
43120, 2.1166666666667, 1.58, 0.41666666666667
43121, 2.1166666666667, 1.62, 0.41666666666667
43122, 2.1166666666667, 1.66, 0.41666666666667
43123, 2.1583333333333, 1.54, 0.41666666666667
43124, 2.1583333333333, 1.58, 0.41666666666667
43125, 2.1583333333333, 1.62, 0.41666666666667
43126, 2.1583333333333, 1.66, 0.41666666666667
43127, 1.2416666666667, 1.54, 0.45833333333333
43128, 1.2416666666667, 1.58, 0.45833333333333
43129, 1.2416666666667, 1.62, 0.45833333333333
43130, 1.2416666666667, 1.66, 0.45833333333333
43131, 1.2833333333333, 1.54, 0.45833333333333
43132, 1.2833333333333, 1.58, 0.45833333333333
43133, 1.2833333333333, 1.62, 0.45833333333333
43134, 1.2833333333333, 1.66, 0.45833333333333
43135, 1.325, 1.54, 0.45833333333333
43136, 1.325, 1.58, 0.45833333333333
43137, 1.325, 1.62, 0.45833333333333
43138, 1.325, 1.66, 0.45833333333333
43139, 1.3666666666667, 1.54, 0.45833333333333
43140, 1.3666666666667, 1.58, 0.45833333333333
43141, 1.3666666666667, 1.62, 0.45833333333333
43142, 1.3666666666667, 1.66, 0.45833333333333
43143, 1.4083333333333, 1.54, 0.45833333333333
43144, 1.4083333333333, 1.58, 0.45833333333333
43145, 1.4083333333333, 1.62, 0.45833333333333
43146, 1.4083333333333, 1.66, 0.45833333333333
43147, 1.45, 1.54, 0.45833333333333
43148, 1.45, 1.58, 0.45833333333333
43149, 1.45, 1.62, 0.45833333333333
43150, 1.45, 1.66, 0.45833333333333
43151, 1.4916666666667, 1.54, 0.45833333333333
43152, 1.4916666666667, 1.58, 0.45833333333333
43153, 1.4916666666667, 1.62, 0.45833333333333
43154, 1.4916666666667, 1.66, 0.45833333333333
43155, 1.5333333333333, 1.54, 0.45833333333333
43156, 1.5333333333333, 1.58, 0.45833333333333
43157, 1.5333333333333, 1.62, 0.45833333333333
43158, 1.5333333333333, 1.66, 0.45833333333333
43159, 1.575, 1.54, 0.45833333333333
43160, 1.575, 1.58, 0.45833333333333
43161, 1.575, 1.62, 0.45833333333333
43162, 1.575, 1.66, 0.45833333333333
43163, 1.6166666666667, 1.54, 0.45833333333333
43164, 1.6166666666667, 1.58, 0.45833333333333
43165, 1.6166666666667, 1.62, 0.45833333333333
43166, 1.6166666666667, 1.66, 0.45833333333333
43167, 1.6583333333333, 1.54, 0.45833333333333
43168, 1.6583333333333, 1.58, 0.45833333333333
43169, 1.6583333333333, 1.62, 0.45833333333333
43170, 1.6583333333333, 1.66, 0.45833333333333
43171, 1.7, 1.54, 0.45833333333333
43172, 1.7, 1.58, 0.45833333333333
43173, 1.7, 1.62, 0.45833333333333
43174, 1.7, 1.66, 0.45833333333333
43175, 1.7416666666667, 1.54, 0.45833333333333
43176, 1.7416666666667, 1.58, 0.45833333333333
43177, 1.7416666666667, 1.62, 0.45833333333333
43178, 1.7416666666667, 1.66, 0.45833333333333
43179, 1.7833333333333, 1.54, 0.45833333333333
43180, 1.7833333333333, 1.58, 0.45833333333333
43181, 1.7833333333333, 1.62, 0.45833333333333
43182, 1.7833333333333, 1.66, 0.45833333333333
43183, 1.825, 1.54, 0.45833333333333
43184, 1.825, 1.58, 0.45833333333333
43185, 1.825, 1.62, 0.45833333333333
43186, 1.825, 1.66, 0.45833333333333
43187, 1.8666666666667, 1.54, 0.45833333333333
43188, 1.8666666666667, 1.58, 0.45833333333333
43189, 1.8666666666667, 1.62, 0.45833333333333
43190, 1.8666666666667, 1.66, 0.45833333333333
43191, 1.9083333333333, 1.54, 0.45833333333333
43192, 1.9083333333333, 1.58, 0.45833333333333
43193, 1.9083333333333, 1.62, 0.45833333333333
43194, 1.9083333333333, 1.66, 0.45833333333333
43195, 1.95, 1.54, 0.45833333333333
43196, 1.95, 1.58, 0.45833333333333
43197, 1.95, 1.62, 0.45833333333333
43198, 1.95, 1.66, 0.45833333333333
43199, 1.9916666666667, 1.54, 0.45833333333333
43200, 1.9916666666667, 1.58, 0.45833333333333
43201, 1.9916666666667, 1.62, 0.45833333333333
43202, 1.9916666666667, 1.66, 0.45833333333333
43203, 2.0333333333333, 1.54, 0.45833333333333
43204, 2.0333333333333, 1.58, 0.45833333333333
43205, 2.0333333333333, 1.62, 0.45833333333333
43206, 2.0333333333333, 1.66, 0.45833333333333
43207, 2.075, 1.54, 0.45833333333333
43208, 2.075, 1.58, 0.45833333333333
43209, 2.075, 1.62, 0.45833333333333
43210, 2.075, 1.66, 0.45833333333333
43211, 2.1166666666667, 1.54, 0.45833333333333
43212, 2.1166666666667, 1.58, 0.45833333333333
43213, 2.1166666666667, 1.62, 0.45833333333333
43214, 2.1166666666667, 1.66, 0.45833333333333
43215, 2.1583333333333, 1.54, 0.45833333333333
43216, 2.1583333333333, 1.58, 0.45833333333333
43217, 2.1583333333333, 1.62, 0.45833333333333
43218, 2.1583333333333, 1.66, 0.45833333333333
43219, 1.2416666666667, 1.52, 0.041666666666667
43220, 1.2208333333333, 1.54, 0.041666666666667
43221, 1.2416666666667, 1.54, 0.020833333333333
43222, 1.2416666666667, 1.56, 0.041666666666667
43223, 1.2208333333333, 1.58, 0.041666666666667
43224, 1.2416666666667, 1.58, 0.020833333333333
43225, 1.2416666666667, 1.6, 0.041666666666667
43226, 1.2208333333333, 1.62, 0.041666666666667
43227, 1.2416666666667, 1.62, 0.020833333333333
43228, 1.2416666666667, 1.64, 0.041666666666667
43229, 1.2208333333333, 1.66, 0.041666666666667
43230, 1.2416666666667, 1.66, 0.020833333333333
43231, 1.2416666666667, 1.68, 0.041666666666667
43232, 1.2833333333333, 1.52, 0.041666666666667
43233, 1.2625, 1.54, 0.041666666666667
43234, 1.2833333333333, 1.54, 0.020833333333333
43235, 1.2833333333333, 1.56, 0.041666666666667
43236, 1.2625, 1.58, 0.041666666666667
43237, 1.2833333333333, 1.58, 0.020833333333333
43238, 1.2833333333333, 1.6, 0.041666666666667
43239, 1.2625, 1.62, 0.041666666666667
43240, 1.2833333333333, 1.62, 0.020833333333333
43241, 1.2833333333333, 1.64, 0.041666666666667
43242, 1.2625, 1.66, 0.041666666666667
43243, 1.2833333333333, 1.66, 0.020833333333333
43244, 1.2833333333333, 1.68, 0.041666666666667
43245, 1.325, 1.52, 0.041666666666667
43246, 1.3041666666667, 1.54, 0.041666666666667
43247, 1.325, 1.54, 0.020833333333333
43248, 1.325, 1.56, 0.041666666666667
43249, 1.3041666666667, 1.58, 0.041666666666667
43250, 1.325, 1.58, 0.020833333333333
43251, 1.325, 1.6, 0.041666666666667
43252, 1.3041666666667, 1.62, 0.041666666666667
43253, 1.325, 1.62, 0.020833333333333
43254, 1.325, 1.64, 0.041666666666667
43255, 1.3041666666667, 1.66, 0.041666666666667
43256, 1.325, 1.66, 0.020833333333333
43257, 1.325, 1.68, 0.041666666666667
43258, 1.3666666666667, 1.52, 0.041666666666667
43259, 1.3458333333333, 1.54, 0.041666666666667
43260, 1.3666666666667, 1.54, 0.020833333333333
43261, 1.3666666666667, 1.56, 0.041666666666667
43262, 1.3458333333333, 1.58, 0.041666666666667
43263, 1.3666666666667, 1.58, 0.020833333333333
43264, 1.3666666666667, 1.6, 0.041666666666667
43265, 1.3458333333333, 1.62, 0.041666666666667
43266, 1.3666666666667, 1.62, 0.020833333333333
43267, 1.3666666666667, 1.64, 0.041666666666667
43268, 1.3458333333333, 1.66, 0.041666666666667
43269, 1.3666666666667, 1.66, 0.020833333333333
43270, 1.3666666666667, 1.68, 0.041666666666667
43271, 1.4083333333333, 1.52, 0.041666666666667
43272, 1.3875, 1.54, 0.041666666666667
43273, 1.4083333333333, 1.54, 0.020833333333333
43274, 1.4083333333333, 1.56, 0.041666666666667
43275, 1.3875, 1.58, 0.041666666666667
43276, 1.4083333333333, 1.58, 0.020833333333333
43277, 1.4083333333333, 1.6, 0.041666666666667
43278, 1.3875, 1.62, 0.041666666666667
43279, 1.4083333333333, 1.62, 0.020833333333333
43280, 1.4083333333333, 1.64, 0.041666666666667
43281, 1.3875, 1.66, 0.041666666666667
43282, 1.4083333333333, 1.66, 0.020833333333333
43283, 1.4083333333333, 1.68, 0.041666666666667
43284, 1.45, 1.52, 0.041666666666667
43285, 1.4291666666667, 1.54, 0.041666666666667
43286, 1.45, 1.54, 0.020833333333333
43287, 1.45, 1.56, 0.041666666666667
43288, 1.4291666666667, 1.58, 0.041666666666667
43289, 1.45, 1.58, 0.020833333333333
43290, 1.45, 1.6, 0.041666666666667
43291, 1.4291666666667, 1.62, 0.041666666666667
43292, 1.45, 1.62, 0.020833333333333
43293, 1.45, 1.64, 0.041666666666667
43294, 1.4291666666667, 1.66, 0.041666666666667
43295, 1.45, 1.66, 0.020833333333333
43296, 1.45, 1.68, 0.041666666666667
43297, 1.4916666666667, 1.52, 0.041666666666667
43298, 1.4708333333333, 1.54, 0.041666666666667
43299, 1.4916666666667, 1.54, 0.020833333333333
43300, 1.4916666666667, 1.56, 0.041666666666667
43301, 1.4708333333333, 1.58, 0.041666666666667
43302, 1.4916666666667, 1.58, 0.020833333333333
43303, 1.4916666666667, 1.6, 0.041666666666667
43304, 1.4708333333333, 1.62, 0.041666666666667
43305, 1.4916666666667, 1.62, 0.020833333333333
43306, 1.4916666666667, 1.64, 0.041666666666667
43307, 1.4708333333333, 1.66, 0.041666666666667
43308, 1.4916666666667, 1.66, 0.020833333333333
43309, 1.4916666666667, 1.68, 0.041666666666667
43310, 1.5333333333333, 1.52, 0.041666666666667
43311, 1.5125, 1.54, 0.041666666666667
43312, 1.5333333333333, 1.54, 0.020833333333333
43313, 1.5333333333333, 1.56, 0.041666666666667
43314, 1.5125, 1.58, 0.041666666666667
43315, 1.5333333333333, 1.58, 0.020833333333333
43316, 1.5333333333333, 1.6, 0.041666666666667
43317, 1.5125, 1.62, 0.041666666666667
43318, 1.5333333333333, 1.62, 0.020833333333333
43319, 1.5333333333333, 1.64, 0.041666666666667
43320, 1.5125, 1.66, 0.041666666666667
43321, 1.5333333333333, 1.66, 0.020833333333333
43322, 1.5333333333333, 1.68, 0.041666666666667
43323, 1.575, 1.52, 0.041666666666667
43324, 1.5541666666667, 1.54, 0.041666666666667
43325, 1.575, 1.54, 0.020833333333333
43326, 1.575, 1.56, 0.041666666666667
43327, 1.5541666666667, 1.58, 0.041666666666667
43328, 1.575, 1.58, 0.020833333333333
43329, 1.575, 1.6, 0.041666666666667
43330, 1.5541666666667, 1.62, 0.041666666666667
43331, 1.575, 1.62, 0.020833333333333
43332, 1.575, 1.64, 0.041666666666667
43333, 1.5541666666667, 1.66, 0.041666666666667
43334, 1.575, 1.66, 0.020833333333333
43335, 1.575, 1.68, 0.041666666666667
43336, 1.6166666666667, 1.52, 0.041666666666667
43337, 1.5958333333333, 1.54, 0.041666666666667
43338, 1.6166666666667, 1.54, 0.020833333333333
43339, 1.6166666666667, 1.56, 0.041666666666667
43340, 1.5958333333333, 1.58, 0.041666666666667
43341, 1.6166666666667, 1.58, 0.020833333333333
43342, 1.6166666666667, 1.6, 0.041666666666667
43343, 1.5958333333333, 1.62, 0.041666666666667
43344, 1.6166666666667, 1.62, 0.020833333333333
43345, 1.6166666666667, 1.64, 0.041666666666667
43346, 1.5958333333333, 1.66, 0.041666666666667
43347, 1.6166666666667, 1.66, 0.020833333333333
43348, 1.6166666666667, 1.68, 0.041666666666667
43349, 1.6583333333333, 1.52, 0.041666666666667
43350, 1.6375, 1.54, 0.041666666666667
43351, 1.6583333333333, 1.54, 0.020833333333333
43352, 1.6583333333333, 1.56, 0.041666666666667
43353, 1.6375, 1.58, 0.041666666666667
43354, 1.6583333333333, 1.58, 0.020833333333333
43355, 1.6583333333333, 1.6, 0.041666666666667
43356, 1.6375, 1.62, 0.041666666666667
43357, 1.6583333333333, 1.62, 0.020833333333333
43358, 1.6583333333333, 1.64, 0.041666666666667
43359, 1.6375, 1.66, 0.041666666666667
43360, 1.6583333333333, 1.66, 0.020833333333333
43361, 1.6583333333333, 1.68, 0.041666666666667
43362, 1.7, 1.52, 0.041666666666667
43363, 1.6791666666667, 1.54, 0.041666666666667
43364, 1.7, 1.54, 0.020833333333333
43365, 1.7, 1.56, 0.041666666666667
43366, 1.6791666666667, 1.58, 0.041666666666667
43367, 1.7, 1.58, 0.020833333333333
43368, 1.7, 1.6, 0.041666666666667
43369, 1.6791666666667, 1.62, 0.041666666666667
43370, 1.7, 1.62, 0.020833333333333
43371, 1.7, 1.64, 0.041666666666667
43372, 1.6791666666667, 1.66, 0.041666666666667
43373, 1.7, 1.66, 0.020833333333333
43374, 1.7, 1.68, 0.041666666666667
43375, 1.7416666666667, 1.52, 0.041666666666667
43376, 1.7208333333333, 1.54, 0.041666666666667
43377, 1.7416666666667, 1.54, 0.020833333333333
43378, 1.7416666666667, 1.56, 0.041666666666667
43379, 1.7208333333333, 1.58, 0.041666666666667
43380, 1.7416666666667, 1.58, 0.020833333333333
43381, 1.7416666666667, 1.6, 0.041666666666667
43382, 1.7208333333333, 1.62, 0.041666666666667
43383, 1.7416666666667, 1.62, 0.020833333333333
43384, 1.7416666666667, 1.64, 0.041666666666667
43385, 1.7208333333333, 1.66, 0.041666666666667
43386, 1.7416666666667, 1.66, 0.020833333333333
43387, 1.7416666666667, 1.68, 0.041666666666667
43388, 1.7833333333333, 1.52, 0.041666666666667
43389, 1.7625, 1.54, 0.041666666666667
43390, 1.7833333333333, 1.54, 0.020833333333333
43391, 1.7833333333333, 1.56, 0.041666666666667
43392, 1.7625, 1.58, 0.041666666666667
43393, 1.7833333333333, 1.58, 0.020833333333333
43394, 1.7833333333333, 1.6, 0.041666666666667
43395, 1.7625, 1.62, 0.041666666666667
43396, 1.7833333333333, 1.62, 0.020833333333333
43397, 1.7833333333333, 1.64, 0.041666666666667
43398, 1.7625, 1.66, 0.041666666666667
43399, 1.7833333333333, 1.66, 0.020833333333333
43400, 1.7833333333333, 1.68, 0.041666666666667
43401, 1.825, 1.52, 0.041666666666667
43402, 1.8041666666667, 1.54, 0.041666666666667
43403, 1.825, 1.54, 0.020833333333333
43404, 1.825, 1.56, 0.041666666666667
43405, 1.8041666666667, 1.58, 0.041666666666667
43406, 1.825, 1.58, 0.020833333333333
43407, 1.825, 1.6, 0.041666666666667
43408, 1.8041666666667, 1.62, 0.041666666666667
43409, 1.825, 1.62, 0.020833333333333
43410, 1.825, 1.64, 0.041666666666667
43411, 1.8041666666667, 1.66, 0.041666666666667
43412, 1.825, 1.66, 0.020833333333333
43413, 1.825, 1.68, 0.041666666666667
43414, 1.8666666666667, 1.52, 0.041666666666667
43415, 1.8458333333333, 1.54, 0.041666666666667
43416, 1.8666666666667, 1.54, 0.020833333333333
43417, 1.8666666666667, 1.56, 0.041666666666667
43418, 1.8458333333333, 1.58, 0.041666666666667
43419, 1.8666666666667, 1.58, 0.020833333333333
43420, 1.8666666666667, 1.6, 0.041666666666667
43421, 1.8458333333333, 1.62, 0.041666666666667
43422, 1.8666666666667, 1.62, 0.020833333333333
43423, 1.8666666666667, 1.64, 0.041666666666667
43424, 1.8458333333333, 1.66, 0.041666666666667
43425, 1.8666666666667, 1.66, 0.020833333333333
43426, 1.8666666666667, 1.68, 0.041666666666667
43427, 1.9083333333333, 1.52, 0.041666666666667
43428, 1.8875, 1.54, 0.041666666666667
43429, 1.9083333333333, 1.54, 0.020833333333333
43430, 1.9083333333333, 1.56, 0.041666666666667
43431, 1.8875, 1.58, 0.041666666666667
43432, 1.9083333333333, 1.58, 0.020833333333333
43433, 1.9083333333333, 1.6, 0.041666666666667
43434, 1.8875, 1.62, 0.041666666666667
43435, 1.9083333333333, 1.62, 0.020833333333333
43436, 1.9083333333333, 1.64, 0.041666666666667
43437, 1.8875, 1.66, 0.041666666666667
43438, 1.9083333333333, 1.66, 0.020833333333333
43439, 1.9083333333333, 1.68, 0.041666666666667
43440, 1.95, 1.52, 0.041666666666667
43441, 1.9291666666667, 1.54, 0.041666666666667
43442, 1.95, 1.54, 0.020833333333333
43443, 1.95, 1.56, 0.041666666666667
43444, 1.9291666666667, 1.58, 0.041666666666667
43445, 1.95, 1.58, 0.020833333333333
43446, 1.95, 1.6, 0.041666666666667
43447, 1.9291666666667, 1.62, 0.041666666666667
43448, 1.95, 1.62, 0.020833333333333
43449, 1.95, 1.64, 0.041666666666667
43450, 1.9291666666667, 1.66, 0.041666666666667
43451, 1.95, 1.66, 0.020833333333333
43452, 1.95, 1.68, 0.041666666666667
43453, 1.9916666666667, 1.52, 0.041666666666667
43454, 1.9708333333333, 1.54, 0.041666666666667
43455, 1.9916666666667, 1.54, 0.020833333333333
43456, 1.9916666666667, 1.56, 0.041666666666667
43457, 1.9708333333333, 1.58, 0.041666666666667
43458, 1.9916666666667, 1.58, 0.020833333333333
43459, 1.9916666666667, 1.6, 0.041666666666667
43460, 1.9708333333333, 1.62, 0.041666666666667
43461, 1.9916666666667, 1.62, 0.020833333333333
43462, 1.9916666666667, 1.64, 0.041666666666667
43463, 1.9708333333333, 1.66, 0.041666666666667
43464, 1.9916666666667, 1.66, 0.020833333333333
43465, 1.9916666666667, 1.68, 0.041666666666667
43466, 2.0333333333333, 1.52, 0.041666666666667
43467, 2.0125, 1.54, 0.041666666666667
43468, 2.0333333333333, 1.54, 0.020833333333333
43469, 2.0333333333333, 1.56, 0.041666666666667
43470, 2.0125, 1.58, 0.041666666666667
43471, 2.0333333333333, 1.58, 0.020833333333333
43472, 2.0333333333333, 1.6, 0.041666666666667
43473, 2.0125, 1.62, 0.041666666666667
43474, 2.0333333333333, 1.62, 0.020833333333333
43475, 2.0333333333333, 1.64, 0.041666666666667
43476, 2.0125, 1.66, 0.041666666666667
43477, 2.0333333333333, 1.66, 0.020833333333333
43478, 2.0333333333333, 1.68, 0.041666666666667
43479, 2.075, 1.52, 0.041666666666667
43480, 2.0541666666667, 1.54, 0.041666666666667
43481, 2.075, 1.54, 0.020833333333333
43482, 2.075, 1.56, 0.041666666666667
43483, 2.0541666666667, 1.58, 0.041666666666667
43484, 2.075, 1.58, 0.020833333333333
43485, 2.075, 1.6, 0.041666666666667
43486, 2.0541666666667, 1.62, 0.041666666666667
43487, 2.075, 1.62, 0.020833333333333
43488, 2.075, 1.64, 0.041666666666667
43489, 2.0541666666667, 1.66, 0.041666666666667
43490, 2.075, 1.66, 0.020833333333333
43491, 2.075, 1.68, 0.041666666666667
43492, 2.1166666666667, 1.52, 0.041666666666667
43493, 2.0958333333333, 1.54, 0.041666666666667
43494, 2.1166666666667, 1.54, 0.020833333333333
43495, 2.1166666666667, 1.56, 0.041666666666667
43496, 2.0958333333333, 1.58, 0.041666666666667
43497, 2.1166666666667, 1.58, 0.020833333333333
43498, 2.1166666666667, 1.6, 0.041666666666667
43499, 2.0958333333333, 1.62, 0.041666666666667
43500, 2.1166666666667, 1.62, 0.020833333333333
43501, 2.1166666666667, 1.64, 0.041666666666667
43502, 2.0958333333333, 1.66, 0.041666666666667
43503, 2.1166666666667, 1.66, 0.020833333333333
43504, 2.1166666666667, 1.68, 0.041666666666667
43505, 2.1583333333333, 1.52, 0.041666666666667
43506, 2.1375, 1.54, 0.041666666666667
43507, 2.1583333333333, 1.54, 0.020833333333333
43508, 2.1583333333333, 1.56, 0.041666666666667
43509, 2.1375, 1.58, 0.041666666666667
43510, 2.1583333333333, 1.58, 0.020833333333333
43511, 2.1583333333333, 1.6, 0.041666666666667
43512, 2.1375, 1.62, 0.041666666666667
43513, 2.1583333333333, 1.62, 0.020833333333333
43514, 2.1583333333333, 1.64, 0.041666666666667
43515, 2.1375, 1.66, 0.041666666666667
43516, 2.1583333333333, 1.66, 0.020833333333333
43517, 2.1583333333333, 1.68, 0.041666666666667
43518, 2.1791666666667, 1.54, 0.041666666666667
43519, 2.1791666666667, 1.58, 0.041666666666667
43520, 2.1791666666667, 1.62, 0.041666666666667
43521, 2.1791666666667, 1.66, 0.041666666666667
43522, 1.2416666666667, 1.52, 0.083333333333333
43523, 1.2208333333333, 1.54, 0.083333333333333
43524, 1.2416666666667, 1.54, 0.0625
43525, 1.2416666666667, 1.56, 0.083333333333333
43526, 1.2208333333333, 1.58, 0.083333333333333
43527, 1.2416666666667, 1.58, 0.0625
43528, 1.2416666666667, 1.6, 0.083333333333333
43529, 1.2208333333333, 1.62, 0.083333333333333
43530, 1.2416666666667, 1.62, 0.0625
43531, 1.2416666666667, 1.64, 0.083333333333333
43532, 1.2208333333333, 1.66, 0.083333333333333
43533, 1.2416666666667, 1.66, 0.0625
43534, 1.2416666666667, 1.68, 0.083333333333333
43535, 1.2833333333333, 1.52, 0.083333333333333
43536, 1.2625, 1.54, 0.083333333333333
43537, 1.2833333333333, 1.54, 0.0625
43538, 1.2833333333333, 1.56, 0.083333333333333
43539, 1.2625, 1.58, 0.083333333333333
43540, 1.2833333333333, 1.58, 0.0625
43541, 1.2833333333333, 1.6, 0.083333333333333
43542, 1.2625, 1.62, 0.083333333333333
43543, 1.2833333333333, 1.62, 0.0625
43544, 1.2833333333333, 1.64, 0.083333333333333
43545, 1.2625, 1.66, 0.083333333333333
43546, 1.2833333333333, 1.66, 0.0625
43547, 1.2833333333333, 1.68, 0.083333333333333
43548, 1.325, 1.52, 0.083333333333333
43549, 1.3041666666667, 1.54, 0.083333333333333
43550, 1.325, 1.54, 0.0625
43551, 1.325, 1.56, 0.083333333333333
43552, 1.3041666666667, 1.58, 0.083333333333333
43553, 1.325, 1.58, 0.0625
43554, 1.325, 1.6, 0.083333333333333
43555, 1.3041666666667, 1.62, 0.083333333333333
43556, 1.325, 1.62, 0.0625
43557, 1.325, 1.64, 0.083333333333333
43558, 1.3041666666667, 1.66, 0.083333333333333
43559, 1.325, 1.66, 0.0625
43560, 1.325, 1.68, 0.083333333333333
43561, 1.3666666666667, 1.52, 0.083333333333333
43562, 1.3458333333333, 1.54, 0.083333333333333
43563, 1.3666666666667, 1.54, 0.0625
43564, 1.3666666666667, 1.56, 0.083333333333333
43565, 1.3458333333333, 1.58, 0.083333333333333
43566, 1.3666666666667, 1.58, 0.0625
43567, 1.3666666666667, 1.6, 0.083333333333333
43568, 1.3458333333333, 1.62, 0.083333333333333
43569, 1.3666666666667, 1.62, 0.0625
43570, 1.3666666666667, 1.64, 0.083333333333333
43571, 1.3458333333333, 1.66, 0.083333333333333
43572, 1.3666666666667, 1.66, 0.0625
43573, 1.3666666666667, 1.68, 0.083333333333333
43574, 1.4083333333333, 1.52, 0.083333333333333
43575, 1.3875, 1.54, 0.083333333333333
43576, 1.4083333333333, 1.54, 0.0625
43577, 1.4083333333333, 1.56, 0.083333333333333
43578, 1.3875, 1.58, 0.083333333333333
43579, 1.4083333333333, 1.58, 0.0625
43580, 1.4083333333333, 1.6, 0.083333333333333
43581, 1.3875, 1.62, 0.083333333333333
43582, 1.4083333333333, 1.62, 0.0625
43583, 1.4083333333333, 1.64, 0.083333333333333
43584, 1.3875, 1.66, 0.083333333333333
43585, 1.4083333333333, 1.66, 0.0625
43586, 1.4083333333333, 1.68, 0.083333333333333
43587, 1.45, 1.52, 0.083333333333333
43588, 1.4291666666667, 1.54, 0.083333333333333
43589, 1.45, 1.54, 0.0625
43590, 1.45, 1.56, 0.083333333333333
43591, 1.4291666666667, 1.58, 0.083333333333333
43592, 1.45, 1.58, 0.0625
43593, 1.45, 1.6, 0.083333333333333
43594, 1.4291666666667, 1.62, 0.083333333333333
43595, 1.45, 1.62, 0.0625
43596, 1.45, 1.64, 0.083333333333333
43597, 1.4291666666667, 1.66, 0.083333333333333
43598, 1.45, 1.66, 0.0625
43599, 1.45, 1.68, 0.083333333333333
43600, 1.4916666666667, 1.52, 0.083333333333333
43601, 1.4708333333333, 1.54, 0.083333333333333
43602, 1.4916666666667, 1.54, 0.0625
43603, 1.4916666666667, 1.56, 0.083333333333333
43604, 1.4708333333333, 1.58, 0.083333333333333
43605, 1.4916666666667, 1.58, 0.0625
43606, 1.4916666666667, 1.6, 0.083333333333333
43607, 1.4708333333333, 1.62, 0.083333333333333
43608, 1.4916666666667, 1.62, 0.0625
43609, 1.4916666666667, 1.64, 0.083333333333333
43610, 1.4708333333333, 1.66, 0.083333333333333
43611, 1.4916666666667, 1.66, 0.0625
43612, 1.4916666666667, 1.68, 0.083333333333333
43613, 1.5333333333333, 1.52, 0.083333333333333
43614, 1.5125, 1.54, 0.083333333333333
43615, 1.5333333333333, 1.54, 0.0625
43616, 1.5333333333333, 1.56, 0.083333333333333
43617, 1.5125, 1.58, 0.083333333333333
43618, 1.5333333333333, 1.58, 0.0625
43619, 1.5333333333333, 1.6, 0.083333333333333
43620, 1.5125, 1.62, 0.083333333333333
43621, 1.5333333333333, 1.62, 0.0625
43622, 1.5333333333333, 1.64, 0.083333333333333
43623, 1.5125, 1.66, 0.083333333333333
43624, 1.5333333333333, 1.66, 0.0625
43625, 1.5333333333333, 1.68, 0.083333333333333
43626, 1.575, 1.52, 0.083333333333333
43627, 1.5541666666667, 1.54, 0.083333333333333
43628, 1.575, 1.54, 0.0625
43629, 1.575, 1.56, 0.083333333333333
43630, 1.5541666666667, 1.58, 0.083333333333333
43631, 1.575, 1.58, 0.0625
43632, 1.575, 1.6, 0.083333333333333
43633, 1.5541666666667, 1.62, 0.083333333333333
43634, 1.575, 1.62, 0.0625
43635, 1.575, 1.64, 0.083333333333333
43636, 1.5541666666667, 1.66, 0.083333333333333
43637, 1.575, 1.66, 0.0625
43638, 1.575, 1.68, 0.083333333333333
43639, 1.6166666666667, 1.52, 0.083333333333333
43640, 1.5958333333333, 1.54, 0.083333333333333
43641, 1.6166666666667, 1.54, 0.0625
43642, 1.6166666666667, 1.56, 0.083333333333333
43643, 1.5958333333333, 1.58, 0.083333333333333
43644, 1.6166666666667, 1.58, 0.0625
43645, 1.6166666666667, 1.6, 0.083333333333333
43646, 1.5958333333333, 1.62, 0.083333333333333
43647, 1.6166666666667, 1.62, 0.0625
43648, 1.6166666666667, 1.64, 0.083333333333333
43649, 1.5958333333333, 1.66, 0.083333333333333
43650, 1.6166666666667, 1.66, 0.0625
43651, 1.6166666666667, 1.68, 0.083333333333333
43652, 1.6583333333333, 1.52, 0.083333333333333
43653, 1.6375, 1.54, 0.083333333333333
43654, 1.6583333333333, 1.54, 0.0625
43655, 1.6583333333333, 1.56, 0.083333333333333
43656, 1.6375, 1.58, 0.083333333333333
43657, 1.6583333333333, 1.58, 0.0625
43658, 1.6583333333333, 1.6, 0.083333333333333
43659, 1.6375, 1.62, 0.083333333333333
43660, 1.6583333333333, 1.62, 0.0625
43661, 1.6583333333333, 1.64, 0.083333333333333
43662, 1.6375, 1.66, 0.083333333333333
43663, 1.6583333333333, 1.66, 0.0625
43664, 1.6583333333333, 1.68, 0.083333333333333
43665, 1.7, 1.52, 0.083333333333333
43666, 1.6791666666667, 1.54, 0.083333333333333
43667, 1.7, 1.54, 0.0625
43668, 1.7, 1.56, 0.083333333333333
43669, 1.6791666666667, 1.58, 0.083333333333333
43670, 1.7, 1.58, 0.0625
43671, 1.7, 1.6, 0.083333333333333
43672, 1.6791666666667, 1.62, 0.083333333333333
43673, 1.7, 1.62, 0.0625
43674, 1.7, 1.64, 0.083333333333333
43675, 1.6791666666667, 1.66, 0.083333333333333
43676, 1.7, 1.66, 0.0625
43677, 1.7, 1.68, 0.083333333333333
43678, 1.7416666666667, 1.52, 0.083333333333333
43679, 1.7208333333333, 1.54, 0.083333333333333
43680, 1.7416666666667, 1.54, 0.0625
43681, 1.7416666666667, 1.56, 0.083333333333333
43682, 1.7208333333333, 1.58, 0.083333333333333
43683, 1.7416666666667, 1.58, 0.0625
43684, 1.7416666666667, 1.6, 0.083333333333333
43685, 1.7208333333333, 1.62, 0.083333333333333
43686, 1.7416666666667, 1.62, 0.0625
43687, 1.7416666666667, 1.64, 0.083333333333333
43688, 1.7208333333333, 1.66, 0.083333333333333
43689, 1.7416666666667, 1.66, 0.0625
43690, 1.7416666666667, 1.68, 0.083333333333333
43691, 1.7833333333333, 1.52, 0.083333333333333
43692, 1.7625, 1.54, 0.083333333333333
43693, 1.7833333333333, 1.54, 0.0625
43694, 1.7833333333333, 1.56, 0.083333333333333
43695, 1.7625, 1.58, 0.083333333333333
43696, 1.7833333333333, 1.58, 0.0625
43697, 1.7833333333333, 1.6, 0.083333333333333
43698, 1.7625, 1.62, 0.083333333333333
43699, 1.7833333333333, 1.62, 0.0625
43700, 1.7833333333333, 1.64, 0.083333333333333
43701, 1.7625, 1.66, 0.083333333333333
43702, 1.7833333333333, 1.66, 0.0625
43703, 1.7833333333333, 1.68, 0.083333333333333
43704, 1.825, 1.52, 0.083333333333333
43705, 1.8041666666667, 1.54, 0.083333333333333
43706, 1.825, 1.54, 0.0625
43707, 1.825, 1.56, 0.083333333333333
43708, 1.8041666666667, 1.58, 0.083333333333333
43709, 1.825, 1.58, 0.0625
43710, 1.825, 1.6, 0.083333333333333
43711, 1.8041666666667, 1.62, 0.083333333333333
43712, 1.825, 1.62, 0.0625
43713, 1.825, 1.64, 0.083333333333333
43714, 1.8041666666667, 1.66, 0.083333333333333
43715, 1.825, 1.66, 0.0625
43716, 1.825, 1.68, 0.083333333333333
43717, 1.8666666666667, 1.52, 0.083333333333333
43718, 1.8458333333333, 1.54, 0.083333333333333
43719, 1.8666666666667, 1.54, 0.0625
43720, 1.8666666666667, 1.56, 0.083333333333333
43721, 1.8458333333333, 1.58, 0.083333333333333
43722, 1.8666666666667, 1.58, 0.0625
43723, 1.8666666666667, 1.6, 0.083333333333333
43724, 1.8458333333333, 1.62, 0.083333333333333
43725, 1.8666666666667, 1.62, 0.0625
43726, 1.8666666666667, 1.64, 0.083333333333333
43727, 1.8458333333333, 1.66, 0.083333333333333
43728, 1.8666666666667, 1.66, 0.0625
43729, 1.8666666666667, 1.68, 0.083333333333333
43730, 1.9083333333333, 1.52, 0.083333333333333
43731, 1.8875, 1.54, 0.083333333333333
43732, 1.9083333333333, 1.54, 0.0625
43733, 1.9083333333333, 1.56, 0.083333333333333
43734, 1.8875, 1.58, 0.083333333333333
43735, 1.9083333333333, 1.58, 0.0625
43736, 1.9083333333333, 1.6, 0.083333333333333
43737, 1.8875, 1.62, 0.083333333333333
43738, 1.9083333333333, 1.62, 0.0625
43739, 1.9083333333333, 1.64, 0.083333333333333
43740, 1.8875, 1.66, 0.083333333333333
43741, 1.9083333333333, 1.66, 0.0625
43742, 1.9083333333333, 1.68, 0.083333333333333
43743, 1.95, 1.52, 0.083333333333333
43744, 1.9291666666667, 1.54, 0.083333333333333
43745, 1.95, 1.54, 0.0625
43746, 1.95, 1.56, 0.083333333333333
43747, 1.9291666666667, 1.58, 0.083333333333333
43748, 1.95, 1.58, 0.0625
43749, 1.95, 1.6, 0.083333333333333
43750, 1.9291666666667, 1.62, 0.083333333333333
43751, 1.95, 1.62, 0.0625
43752, 1.95, 1.64, 0.083333333333333
43753, 1.9291666666667, 1.66, 0.083333333333333
43754, 1.95, 1.66, 0.0625
43755, 1.95, 1.68, 0.083333333333333
43756, 1.9916666666667, 1.52, 0.083333333333333
43757, 1.9708333333333, 1.54, 0.083333333333333
43758, 1.9916666666667, 1.54, 0.0625
43759, 1.9916666666667, 1.56, 0.083333333333333
43760, 1.9708333333333, 1.58, 0.083333333333333
43761, 1.9916666666667, 1.58, 0.0625
43762, 1.9916666666667, 1.6, 0.083333333333333
43763, 1.9708333333333, 1.62, 0.083333333333333
43764, 1.9916666666667, 1.62, 0.0625
43765, 1.9916666666667, 1.64, 0.083333333333333
43766, 1.9708333333333, 1.66, 0.083333333333333
43767, 1.9916666666667, 1.66, 0.0625
43768, 1.9916666666667, 1.68, 0.083333333333333
43769, 2.0333333333333, 1.52, 0.083333333333333
43770, 2.0125, 1.54, 0.083333333333333
43771, 2.0333333333333, 1.54, 0.0625
43772, 2.0333333333333, 1.56, 0.083333333333333
43773, 2.0125, 1.58, 0.083333333333333
43774, 2.0333333333333, 1.58, 0.0625
43775, 2.0333333333333, 1.6, 0.083333333333333
43776, 2.0125, 1.62, 0.083333333333333
43777, 2.0333333333333, 1.62, 0.0625
43778, 2.0333333333333, 1.64, 0.083333333333333
43779, 2.0125, 1.66, 0.083333333333333
43780, 2.0333333333333, 1.66, 0.0625
43781, 2.0333333333333, 1.68, 0.083333333333333
43782, 2.075, 1.52, 0.083333333333333
43783, 2.0541666666667, 1.54, 0.083333333333333
43784, 2.075, 1.54, 0.0625
43785, 2.075, 1.56, 0.083333333333333
43786, 2.0541666666667, 1.58, 0.083333333333333
43787, 2.075, 1.58, 0.0625
43788, 2.075, 1.6, 0.083333333333333
43789, 2.0541666666667, 1.62, 0.083333333333333
43790, 2.075, 1.62, 0.0625
43791, 2.075, 1.64, 0.083333333333333
43792, 2.0541666666667, 1.66, 0.083333333333333
43793, 2.075, 1.66, 0.0625
43794, 2.075, 1.68, 0.083333333333333
43795, 2.1166666666667, 1.52, 0.083333333333333
43796, 2.0958333333333, 1.54, 0.083333333333333
43797, 2.1166666666667, 1.54, 0.0625
43798, 2.1166666666667, 1.56, 0.083333333333333
43799, 2.0958333333333, 1.58, 0.083333333333333
43800, 2.1166666666667, 1.58, 0.0625
43801, 2.1166666666667, 1.6, 0.083333333333333
43802, 2.0958333333333, 1.62, 0.083333333333333
43803, 2.1166666666667, 1.62, 0.0625
43804, 2.1166666666667, 1.64, 0.083333333333333
43805, 2.0958333333333, 1.66, 0.083333333333333
43806, 2.1166666666667, 1.66, 0.0625
43807, 2.1166666666667, 1.68, 0.083333333333333
43808, 2.1583333333333, 1.52, 0.083333333333333
43809, 2.1375, 1.54, 0.083333333333333
43810, 2.1583333333333, 1.54, 0.0625
43811, 2.1583333333333, 1.56, 0.083333333333333
43812, 2.1375, 1.58, 0.083333333333333
43813, 2.1583333333333, 1.58, 0.0625
43814, 2.1583333333333, 1.6, 0.083333333333333
43815, 2.1375, 1.62, 0.083333333333333
43816, 2.1583333333333, 1.62, 0.0625
43817, 2.1583333333333, 1.64, 0.083333333333333
43818, 2.1375, 1.66, 0.083333333333333
43819, 2.1583333333333, 1.66, 0.0625
43820, 2.1583333333333, 1.68, 0.083333333333333
43821, 2.1791666666667, 1.54, 0.083333333333333
43822, 2.1791666666667, 1.58, 0.083333333333333
43823, 2.1791666666667, 1.62, 0.083333333333333
43824, 2.1791666666667, 1.66, 0.083333333333333
43825, 1.2416666666667, 1.52, 0.125
43826, 1.2208333333333, 1.54, 0.125
43827, 1.2416666666667, 1.54, 0.10416666666667
43828, 1.2416666666667, 1.56, 0.125
43829, 1.2208333333333, 1.58, 0.125
43830, 1.2416666666667, 1.58, 0.10416666666667
43831, 1.2416666666667, 1.6, 0.125
43832, 1.2208333333333, 1.62, 0.125
43833, 1.2416666666667, 1.62, 0.10416666666667
43834, 1.2416666666667, 1.64, 0.125
43835, 1.2208333333333, 1.66, 0.125
43836, 1.2416666666667, 1.66, 0.10416666666667
43837, 1.2416666666667, 1.68, 0.125
43838, 1.2833333333333, 1.52, 0.125
43839, 1.2625, 1.54, 0.125
43840, 1.2833333333333, 1.54, 0.10416666666667
43841, 1.2833333333333, 1.56, 0.125
43842, 1.2625, 1.58, 0.125
43843, 1.2833333333333, 1.58, 0.10416666666667
43844, 1.2833333333333, 1.6, 0.125
43845, 1.2625, 1.62, 0.125
43846, 1.2833333333333, 1.62, 0.10416666666667
43847, 1.2833333333333, 1.64, 0.125
43848, 1.2625, 1.66, 0.125
43849, 1.2833333333333, 1.66, 0.10416666666667
43850, 1.2833333333333, 1.68, 0.125
43851, 1.325, 1.52, 0.125
43852, 1.3041666666667, 1.54, 0.125
43853, 1.325, 1.54, 0.10416666666667
43854, 1.325, 1.56, 0.125
43855, 1.3041666666667, 1.58, 0.125
43856, 1.325, 1.58, 0.10416666666667
43857, 1.325, 1.6, 0.125
43858, 1.3041666666667, 1.62, 0.125
43859, 1.325, 1.62, 0.10416666666667
43860, 1.325, 1.64, 0.125
43861, 1.3041666666667, 1.66, 0.125
43862, 1.325, 1.66, 0.10416666666667
43863, 1.325, 1.68, 0.125
43864, 1.3666666666667, 1.52, 0.125
43865, 1.3458333333333, 1.54, 0.125
43866, 1.3666666666667, 1.54, 0.10416666666667
43867, 1.3666666666667, 1.56, 0.125
43868, 1.3458333333333, 1.58, 0.125
43869, 1.3666666666667, 1.58, 0.10416666666667
43870, 1.3666666666667, 1.6, 0.125
43871, 1.3458333333333, 1.62, 0.125
43872, 1.3666666666667, 1.62, 0.10416666666667
43873, 1.3666666666667, 1.64, 0.125
43874, 1.3458333333333, 1.66, 0.125
43875, 1.3666666666667, 1.66, 0.10416666666667
43876, 1.3666666666667, 1.68, 0.125
43877, 1.4083333333333, 1.52, 0.125
43878, 1.3875, 1.54, 0.125
43879, 1.4083333333333, 1.54, 0.10416666666667
43880, 1.4083333333333, 1.56, 0.125
43881, 1.3875, 1.58, 0.125
43882, 1.4083333333333, 1.58, 0.10416666666667
43883, 1.4083333333333, 1.6, 0.125
43884, 1.3875, 1.62, 0.125
43885, 1.4083333333333, 1.62, 0.10416666666667
43886, 1.4083333333333, 1.64, 0.125
43887, 1.3875, 1.66, 0.125
43888, 1.4083333333333, 1.66, 0.10416666666667
43889, 1.4083333333333, 1.68, 0.125
43890, 1.45, 1.52, 0.125
43891, 1.4291666666667, 1.54, 0.125
43892, 1.45, 1.54, 0.10416666666667
43893, 1.45, 1.56, 0.125
43894, 1.4291666666667, 1.58, 0.125
43895, 1.45, 1.58, 0.10416666666667
43896, 1.45, 1.6, 0.125
43897, 1.4291666666667, 1.62, 0.125
43898, 1.45, 1.62, 0.10416666666667
43899, 1.45, 1.64, 0.125
43900, 1.4291666666667, 1.66, 0.125
43901, 1.45, 1.66, 0.10416666666667
43902, 1.45, 1.68, 0.125
43903, 1.4916666666667, 1.52, 0.125
43904, 1.4708333333333, 1.54, 0.125
43905, 1.4916666666667, 1.54, 0.10416666666667
43906, 1.4916666666667, 1.56, 0.125
43907, 1.4708333333333, 1.58, 0.125
43908, 1.4916666666667, 1.58, 0.10416666666667
43909, 1.4916666666667, 1.6, 0.125
43910, 1.4708333333333, 1.62, 0.125
43911, 1.4916666666667, 1.62, 0.10416666666667
43912, 1.4916666666667, 1.64, 0.125
43913, 1.4708333333333, 1.66, 0.125
43914, 1.4916666666667, 1.66, 0.10416666666667
43915, 1.4916666666667, 1.68, 0.125
43916, 1.5333333333333, 1.52, 0.125
43917, 1.5125, 1.54, 0.125
43918, 1.5333333333333, 1.54, 0.10416666666667
43919, 1.5333333333333, 1.56, 0.125
43920, 1.5125, 1.58, 0.125
43921, 1.5333333333333, 1.58, 0.10416666666667
43922, 1.5333333333333, 1.6, 0.125
43923, 1.5125, 1.62, 0.125
43924, 1.5333333333333, 1.62, 0.10416666666667
43925, 1.5333333333333, 1.64, 0.125
43926, 1.5125, 1.66, 0.125
43927, 1.5333333333333, 1.66, 0.10416666666667
43928, 1.5333333333333, 1.68, 0.125
43929, 1.575, 1.52, 0.125
43930, 1.5541666666667, 1.54, 0.125
43931, 1.575, 1.54, 0.10416666666667
43932, 1.575, 1.56, 0.125
43933, 1.5541666666667, 1.58, 0.125
43934, 1.575, 1.58, 0.10416666666667
43935, 1.575, 1.6, 0.125
43936, 1.5541666666667, 1.62, 0.125
43937, 1.575, 1.62, 0.10416666666667
43938, 1.575, 1.64, 0.125
43939, 1.5541666666667, 1.66, 0.125
43940, 1.575, 1.66, 0.10416666666667
43941, 1.575, 1.68, 0.125
43942, 1.6166666666667, 1.52, 0.125
43943, 1.5958333333333, 1.54, 0.125
43944, 1.6166666666667, 1.54, 0.10416666666667
43945, 1.6166666666667, 1.56, 0.125
43946, 1.5958333333333, 1.58, 0.125
43947, 1.6166666666667, 1.58, 0.10416666666667
43948, 1.6166666666667, 1.6, 0.125
43949, 1.5958333333333, 1.62, 0.125
43950, 1.6166666666667, 1.62, 0.10416666666667
43951, 1.6166666666667, 1.64, 0.125
43952, 1.5958333333333, 1.66, 0.125
43953, 1.6166666666667, 1.66, 0.10416666666667
43954, 1.6166666666667, 1.68, 0.125
43955, 1.6583333333333, 1.52, 0.125
43956, 1.6375, 1.54, 0.125
43957, 1.6583333333333, 1.54, 0.10416666666667
43958, 1.6583333333333, 1.56, 0.125
43959, 1.6375, 1.58, 0.125
43960, 1.6583333333333, 1.58, 0.10416666666667
43961, 1.6583333333333, 1.6, 0.125
43962, 1.6375, 1.62, 0.125
43963, 1.6583333333333, 1.62, 0.10416666666667
43964, 1.6583333333333, 1.64, 0.125
43965, 1.6375, 1.66, 0.125
43966, 1.6583333333333, 1.66, 0.10416666666667
43967, 1.6583333333333, 1.68, 0.125
43968, 1.7, 1.52, 0.125
43969, 1.6791666666667, 1.54, 0.125
43970, 1.7, 1.54, 0.10416666666667
43971, 1.7, 1.56, 0.125
43972, 1.6791666666667, 1.58, 0.125
43973, 1.7, 1.58, 0.10416666666667
43974, 1.7, 1.6, 0.125
43975, 1.6791666666667, 1.62, 0.125
43976, 1.7, 1.62, 0.10416666666667
43977, 1.7, 1.64, 0.125
43978, 1.6791666666667, 1.66, 0.125
43979, 1.7, 1.66, 0.10416666666667
43980, 1.7, 1.68, 0.125
43981, 1.7416666666667, 1.52, 0.125
43982, 1.7208333333333, 1.54, 0.125
43983, 1.7416666666667, 1.54, 0.10416666666667
43984, 1.7416666666667, 1.56, 0.125
43985, 1.7208333333333, 1.58, 0.125
43986, 1.7416666666667, 1.58, 0.10416666666667
43987, 1.7416666666667, 1.6, 0.125
43988, 1.7208333333333, 1.62, 0.125
43989, 1.7416666666667, 1.62, 0.10416666666667
43990, 1.7416666666667, 1.64, 0.125
43991, 1.7208333333333, 1.66, 0.125
43992, 1.7416666666667, 1.66, 0.10416666666667
43993, 1.7416666666667, 1.68, 0.125
43994, 1.7833333333333, 1.52, 0.125
43995, 1.7625, 1.54, 0.125
43996, 1.7833333333333, 1.54, 0.10416666666667
43997, 1.7833333333333, 1.56, 0.125
43998, 1.7625, 1.58, 0.125
43999, 1.7833333333333, 1.58, 0.10416666666667
44000, 1.7833333333333, 1.6, 0.125
44001, 1.7625, 1.62, 0.125
44002, 1.7833333333333, 1.62, 0.10416666666667
44003, 1.7833333333333, 1.64, 0.125
44004, 1.7625, 1.66, 0.125
44005, 1.7833333333333, 1.66, 0.10416666666667
44006, 1.7833333333333, 1.68, 0.125
44007, 1.825, 1.52, 0.125
44008, 1.8041666666667, 1.54, 0.125
44009, 1.825, 1.54, 0.10416666666667
44010, 1.825, 1.56, 0.125
44011, 1.8041666666667, 1.58, 0.125
44012, 1.825, 1.58, 0.10416666666667
44013, 1.825, 1.6, 0.125
44014, 1.8041666666667, 1.62, 0.125
44015, 1.825, 1.62, 0.10416666666667
44016, 1.825, 1.64, 0.125
44017, 1.8041666666667, 1.66, 0.125
44018, 1.825, 1.66, 0.10416666666667
44019, 1.825, 1.68, 0.125
44020, 1.8666666666667, 1.52, 0.125
44021, 1.8458333333333, 1.54, 0.125
44022, 1.8666666666667, 1.54, 0.10416666666667
44023, 1.8666666666667, 1.56, 0.125
44024, 1.8458333333333, 1.58, 0.125
44025, 1.8666666666667, 1.58, 0.10416666666667
44026, 1.8666666666667, 1.6, 0.125
44027, 1.8458333333333, 1.62, 0.125
44028, 1.8666666666667, 1.62, 0.10416666666667
44029, 1.8666666666667, 1.64, 0.125
44030, 1.8458333333333, 1.66, 0.125
44031, 1.8666666666667, 1.66, 0.10416666666667
44032, 1.8666666666667, 1.68, 0.125
44033, 1.9083333333333, 1.52, 0.125
44034, 1.8875, 1.54, 0.125
44035, 1.9083333333333, 1.54, 0.10416666666667
44036, 1.9083333333333, 1.56, 0.125
44037, 1.8875, 1.58, 0.125
44038, 1.9083333333333, 1.58, 0.10416666666667
44039, 1.9083333333333, 1.6, 0.125
44040, 1.8875, 1.62, 0.125
44041, 1.9083333333333, 1.62, 0.10416666666667
44042, 1.9083333333333, 1.64, 0.125
44043, 1.8875, 1.66, 0.125
44044, 1.9083333333333, 1.66, 0.10416666666667
44045, 1.9083333333333, 1.68, 0.125
44046, 1.95, 1.52, 0.125
44047, 1.9291666666667, 1.54, 0.125
44048, 1.95, 1.54, 0.10416666666667
44049, 1.95, 1.56, 0.125
44050, 1.9291666666667, 1.58, 0.125
44051, 1.95, 1.58, 0.10416666666667
44052, 1.95, 1.6, 0.125
44053, 1.9291666666667, 1.62, 0.125
44054, 1.95, 1.62, 0.10416666666667
44055, 1.95, 1.64, 0.125
44056, 1.9291666666667, 1.66, 0.125
44057, 1.95, 1.66, 0.10416666666667
44058, 1.95, 1.68, 0.125
44059, 1.9916666666667, 1.52, 0.125
44060, 1.9708333333333, 1.54, 0.125
44061, 1.9916666666667, 1.54, 0.10416666666667
44062, 1.9916666666667, 1.56, 0.125
44063, 1.9708333333333, 1.58, 0.125
44064, 1.9916666666667, 1.58, 0.10416666666667
44065, 1.9916666666667, 1.6, 0.125
44066, 1.9708333333333, 1.62, 0.125
44067, 1.9916666666667, 1.62, 0.10416666666667
44068, 1.9916666666667, 1.64, 0.125
44069, 1.9708333333333, 1.66, 0.125
44070, 1.9916666666667, 1.66, 0.10416666666667
44071, 1.9916666666667, 1.68, 0.125
44072, 2.0333333333333, 1.52, 0.125
44073, 2.0125, 1.54, 0.125
44074, 2.0333333333333, 1.54, 0.10416666666667
44075, 2.0333333333333, 1.56, 0.125
44076, 2.0125, 1.58, 0.125
44077, 2.0333333333333, 1.58, 0.10416666666667
44078, 2.0333333333333, 1.6, 0.125
44079, 2.0125, 1.62, 0.125
44080, 2.0333333333333, 1.62, 0.10416666666667
44081, 2.0333333333333, 1.64, 0.125
44082, 2.0125, 1.66, 0.125
44083, 2.0333333333333, 1.66, 0.10416666666667
44084, 2.0333333333333, 1.68, 0.125
44085, 2.075, 1.52, 0.125
44086, 2.0541666666667, 1.54, 0.125
44087, 2.075, 1.54, 0.10416666666667
44088, 2.075, 1.56, 0.125
44089, 2.0541666666667, 1.58, 0.125
44090, 2.075, 1.58, 0.10416666666667
44091, 2.075, 1.6, 0.125
44092, 2.0541666666667, 1.62, 0.125
44093, 2.075, 1.62, 0.10416666666667
44094, 2.075, 1.64, 0.125
44095, 2.0541666666667, 1.66, 0.125
44096, 2.075, 1.66, 0.10416666666667
44097, 2.075, 1.68, 0.125
44098, 2.1166666666667, 1.52, 0.125
44099, 2.0958333333333, 1.54, 0.125
44100, 2.1166666666667, 1.54, 0.10416666666667
44101, 2.1166666666667, 1.56, 0.125
44102, 2.0958333333333, 1.58, 0.125
44103, 2.1166666666667, 1.58, 0.10416666666667
44104, 2.1166666666667, 1.6, 0.125
44105, 2.0958333333333, 1.62, 0.125
44106, 2.1166666666667, 1.62, 0.10416666666667
44107, 2.1166666666667, 1.64, 0.125
44108, 2.0958333333333, 1.66, 0.125
44109, 2.1166666666667, 1.66, 0.10416666666667
44110, 2.1166666666667, 1.68, 0.125
44111, 2.1583333333333, 1.52, 0.125
44112, 2.1375, 1.54, 0.125
44113, 2.1583333333333, 1.54, 0.10416666666667
44114, 2.1583333333333, 1.56, 0.125
44115, 2.1375, 1.58, 0.125
44116, 2.1583333333333, 1.58, 0.10416666666667
44117, 2.1583333333333, 1.6, 0.125
44118, 2.1375, 1.62, 0.125
44119, 2.1583333333333, 1.62, 0.10416666666667
44120, 2.1583333333333, 1.64, 0.125
44121, 2.1375, 1.66, 0.125
44122, 2.1583333333333, 1.66, 0.10416666666667
44123, 2.1583333333333, 1.68, 0.125
44124, 2.1791666666667, 1.54, 0.125
44125, 2.1791666666667, 1.58, 0.125
44126, 2.1791666666667, 1.62, 0.125
44127, 2.1791666666667, 1.66, 0.125
44128, 1.2416666666667, 1.52, 0.16666666666667
44129, 1.2208333333333, 1.54, 0.16666666666667
44130, 1.2416666666667, 1.54, 0.14583333333333
44131, 1.2416666666667, 1.56, 0.16666666666667
44132, 1.2208333333333, 1.58, 0.16666666666667
44133, 1.2416666666667, 1.58, 0.14583333333333
44134, 1.2416666666667, 1.6, 0.16666666666667
44135, 1.2208333333333, 1.62, 0.16666666666667
44136, 1.2416666666667, 1.62, 0.14583333333333
44137, 1.2416666666667, 1.64, 0.16666666666667
44138, 1.2208333333333, 1.66, 0.16666666666667
44139, 1.2416666666667, 1.66, 0.14583333333333
44140, 1.2416666666667, 1.68, 0.16666666666667
44141, 1.2833333333333, 1.52, 0.16666666666667
44142, 1.2625, 1.54, 0.16666666666667
44143, 1.2833333333333, 1.54, 0.14583333333333
44144, 1.2833333333333, 1.56, 0.16666666666667
44145, 1.2625, 1.58, 0.16666666666667
44146, 1.2833333333333, 1.58, 0.14583333333333
44147, 1.2833333333333, 1.6, 0.16666666666667
44148, 1.2625, 1.62, 0.16666666666667
44149, 1.2833333333333, 1.62, 0.14583333333333
44150, 1.2833333333333, 1.64, 0.16666666666667
44151, 1.2625, 1.66, 0.16666666666667
44152, 1.2833333333333, 1.66, 0.14583333333333
44153, 1.2833333333333, 1.68, 0.16666666666667
44154, 1.325, 1.52, 0.16666666666667
44155, 1.3041666666667, 1.54, 0.16666666666667
44156, 1.325, 1.54, 0.14583333333333
44157, 1.325, 1.56, 0.16666666666667
44158, 1.3041666666667, 1.58, 0.16666666666667
44159, 1.325, 1.58, 0.14583333333333
44160, 1.325, 1.6, 0.16666666666667
44161, 1.3041666666667, 1.62, 0.16666666666667
44162, 1.325, 1.62, 0.14583333333333
44163, 1.325, 1.64, 0.16666666666667
44164, 1.3041666666667, 1.66, 0.16666666666667
44165, 1.325, 1.66, 0.14583333333333
44166, 1.325, 1.68, 0.16666666666667
44167, 1.3666666666667, 1.52, 0.16666666666667
44168, 1.3458333333333, 1.54, 0.16666666666667
44169, 1.3666666666667, 1.54, 0.14583333333333
44170, 1.3666666666667, 1.56, 0.16666666666667
44171, 1.3458333333333, 1.58, 0.16666666666667
44172, 1.3666666666667, 1.58, 0.14583333333333
44173, 1.3666666666667, 1.6, 0.16666666666667
44174, 1.3458333333333, 1.62, 0.16666666666667
44175, 1.3666666666667, 1.62, 0.14583333333333
44176, 1.3666666666667, 1.64, 0.16666666666667
44177, 1.3458333333333, 1.66, 0.16666666666667
44178, 1.3666666666667, 1.66, 0.14583333333333
44179, 1.3666666666667, 1.68, 0.16666666666667
44180, 1.4083333333333, 1.52, 0.16666666666667
44181, 1.3875, 1.54, 0.16666666666667
44182, 1.4083333333333, 1.54, 0.14583333333333
44183, 1.4083333333333, 1.56, 0.16666666666667
44184, 1.3875, 1.58, 0.16666666666667
44185, 1.4083333333333, 1.58, 0.14583333333333
44186, 1.4083333333333, 1.6, 0.16666666666667
44187, 1.3875, 1.62, 0.16666666666667
44188, 1.4083333333333, 1.62, 0.14583333333333
44189, 1.4083333333333, 1.64, 0.16666666666667
44190, 1.3875, 1.66, 0.16666666666667
44191, 1.4083333333333, 1.66, 0.14583333333333
44192, 1.4083333333333, 1.68, 0.16666666666667
44193, 1.45, 1.52, 0.16666666666667
44194, 1.4291666666667, 1.54, 0.16666666666667
44195, 1.45, 1.54, 0.14583333333333
44196, 1.45, 1.56, 0.16666666666667
44197, 1.4291666666667, 1.58, 0.16666666666667
44198, 1.45, 1.58, 0.14583333333333
44199, 1.45, 1.6, 0.16666666666667
44200, 1.4291666666667, 1.62, 0.16666666666667
44201, 1.45, 1.62, 0.14583333333333
44202, 1.45, 1.64, 0.16666666666667
44203, 1.4291666666667, 1.66, 0.16666666666667
44204, 1.45, 1.66, 0.14583333333333
44205, 1.45, 1.68, 0.16666666666667
44206, 1.4916666666667, 1.52, 0.16666666666667
44207, 1.4708333333333, 1.54, 0.16666666666667
44208, 1.4916666666667, 1.54, 0.14583333333333
44209, 1.4916666666667, 1.56, 0.16666666666667
44210, 1.4708333333333, 1.58, 0.16666666666667
44211, 1.4916666666667, 1.58, 0.14583333333333
44212, 1.4916666666667, 1.6, 0.16666666666667
44213, 1.4708333333333, 1.62, 0.16666666666667
44214, 1.4916666666667, 1.62, 0.14583333333333
44215, 1.4916666666667, 1.64, 0.16666666666667
44216, 1.4708333333333, 1.66, 0.16666666666667
44217, 1.4916666666667, 1.66, 0.14583333333333
44218, 1.4916666666667, 1.68, 0.16666666666667
44219, 1.5333333333333, 1.52, 0.16666666666667
44220, 1.5125, 1.54, 0.16666666666667
44221, 1.5333333333333, 1.54, 0.14583333333333
44222, 1.5333333333333, 1.56, 0.16666666666667
44223, 1.5125, 1.58, 0.16666666666667
44224, 1.5333333333333, 1.58, 0.14583333333333
44225, 1.5333333333333, 1.6, 0.16666666666667
44226, 1.5125, 1.62, 0.16666666666667
44227, 1.5333333333333, 1.62, 0.14583333333333
44228, 1.5333333333333, 1.64, 0.16666666666667
44229, 1.5125, 1.66, 0.16666666666667
44230, 1.5333333333333, 1.66, 0.14583333333333
44231, 1.5333333333333, 1.68, 0.16666666666667
44232, 1.575, 1.52, 0.16666666666667
44233, 1.5541666666667, 1.54, 0.16666666666667
44234, 1.575, 1.54, 0.14583333333333
44235, 1.575, 1.56, 0.16666666666667
44236, 1.5541666666667, 1.58, 0.16666666666667
44237, 1.575, 1.58, 0.14583333333333
44238, 1.575, 1.6, 0.16666666666667
44239, 1.5541666666667, 1.62, 0.16666666666667
44240, 1.575, 1.62, 0.14583333333333
44241, 1.575, 1.64, 0.16666666666667
44242, 1.5541666666667, 1.66, 0.16666666666667
44243, 1.575, 1.66, 0.14583333333333
44244, 1.575, 1.68, 0.16666666666667
44245, 1.6166666666667, 1.52, 0.16666666666667
44246, 1.5958333333333, 1.54, 0.16666666666667
44247, 1.6166666666667, 1.54, 0.14583333333333
44248, 1.6166666666667, 1.56, 0.16666666666667
44249, 1.5958333333333, 1.58, 0.16666666666667
44250, 1.6166666666667, 1.58, 0.14583333333333
44251, 1.6166666666667, 1.6, 0.16666666666667
44252, 1.5958333333333, 1.62, 0.16666666666667
44253, 1.6166666666667, 1.62, 0.14583333333333
44254, 1.6166666666667, 1.64, 0.16666666666667
44255, 1.5958333333333, 1.66, 0.16666666666667
44256, 1.6166666666667, 1.66, 0.14583333333333
44257, 1.6166666666667, 1.68, 0.16666666666667
44258, 1.6583333333333, 1.52, 0.16666666666667
44259, 1.6375, 1.54, 0.16666666666667
44260, 1.6583333333333, 1.54, 0.14583333333333
44261, 1.6583333333333, 1.56, 0.16666666666667
44262, 1.6375, 1.58, 0.16666666666667
44263, 1.6583333333333, 1.58, 0.14583333333333
44264, 1.6583333333333, 1.6, 0.16666666666667
44265, 1.6375, 1.62, 0.16666666666667
44266, 1.6583333333333, 1.62, 0.14583333333333
44267, 1.6583333333333, 1.64, 0.16666666666667
44268, 1.6375, 1.66, 0.16666666666667
44269, 1.6583333333333, 1.66, 0.14583333333333
44270, 1.6583333333333, 1.68, 0.16666666666667
44271, 1.7, 1.52, 0.16666666666667
44272, 1.6791666666667, 1.54, 0.16666666666667
44273, 1.7, 1.54, 0.14583333333333
44274, 1.7, 1.56, 0.16666666666667
44275, 1.6791666666667, 1.58, 0.16666666666667
44276, 1.7, 1.58, 0.14583333333333
44277, 1.7, 1.6, 0.16666666666667
44278, 1.6791666666667, 1.62, 0.16666666666667
44279, 1.7, 1.62, 0.14583333333333
44280, 1.7, 1.64, 0.16666666666667
44281, 1.6791666666667, 1.66, 0.16666666666667
44282, 1.7, 1.66, 0.14583333333333
44283, 1.7, 1.68, 0.16666666666667
44284, 1.7416666666667, 1.52, 0.16666666666667
44285, 1.7208333333333, 1.54, 0.16666666666667
44286, 1.7416666666667, 1.54, 0.14583333333333
44287, 1.7416666666667, 1.56, 0.16666666666667
44288, 1.7208333333333, 1.58, 0.16666666666667
44289, 1.7416666666667, 1.58, 0.14583333333333
44290, 1.7416666666667, 1.6, 0.16666666666667
44291, 1.7208333333333, 1.62, 0.16666666666667
44292, 1.7416666666667, 1.62, 0.14583333333333
44293, 1.7416666666667, 1.64, 0.16666666666667
44294, 1.7208333333333, 1.66, 0.16666666666667
44295, 1.7416666666667, 1.66, 0.14583333333333
44296, 1.7416666666667, 1.68, 0.16666666666667
44297, 1.7833333333333, 1.52, 0.16666666666667
44298, 1.7625, 1.54, 0.16666666666667
44299, 1.7833333333333, 1.54, 0.14583333333333
44300, 1.7833333333333, 1.56, 0.16666666666667
44301, 1.7625, 1.58, 0.16666666666667
44302, 1.7833333333333, 1.58, 0.14583333333333
44303, 1.7833333333333, 1.6, 0.16666666666667
44304, 1.7625, 1.62, 0.16666666666667
44305, 1.7833333333333, 1.62, 0.14583333333333
44306, 1.7833333333333, 1.64, 0.16666666666667
44307, 1.7625, 1.66, 0.16666666666667
44308, 1.7833333333333, 1.66, 0.14583333333333
44309, 1.7833333333333, 1.68, 0.16666666666667
44310, 1.825, 1.52, 0.16666666666667
44311, 1.8041666666667, 1.54, 0.16666666666667
44312, 1.825, 1.54, 0.14583333333333
44313, 1.825, 1.56, 0.16666666666667
44314, 1.8041666666667, 1.58, 0.16666666666667
44315, 1.825, 1.58, 0.14583333333333
44316, 1.825, 1.6, 0.16666666666667
44317, 1.8041666666667, 1.62, 0.16666666666667
44318, 1.825, 1.62, 0.14583333333333
44319, 1.825, 1.64, 0.16666666666667
44320, 1.8041666666667, 1.66, 0.16666666666667
44321, 1.825, 1.66, 0.14583333333333
44322, 1.825, 1.68, 0.16666666666667
44323, 1.8666666666667, 1.52, 0.16666666666667
44324, 1.8458333333333, 1.54, 0.16666666666667
44325, 1.8666666666667, 1.54, 0.14583333333333
44326, 1.8666666666667, 1.56, 0.16666666666667
44327, 1.8458333333333, 1.58, 0.16666666666667
44328, 1.8666666666667, 1.58, 0.14583333333333
44329, 1.8666666666667, 1.6, 0.16666666666667
44330, 1.8458333333333, 1.62, 0.16666666666667
44331, 1.8666666666667, 1.62, 0.14583333333333
44332, 1.8666666666667, 1.64, 0.16666666666667
44333, 1.8458333333333, 1.66, 0.16666666666667
44334, 1.8666666666667, 1.66, 0.14583333333333
44335, 1.8666666666667, 1.68, 0.16666666666667
44336, 1.9083333333333, 1.52, 0.16666666666667
44337, 1.8875, 1.54, 0.16666666666667
44338, 1.9083333333333, 1.54, 0.14583333333333
44339, 1.9083333333333, 1.56, 0.16666666666667
44340, 1.8875, 1.58, 0.16666666666667
44341, 1.9083333333333, 1.58, 0.14583333333333
44342, 1.9083333333333, 1.6, 0.16666666666667
44343, 1.8875, 1.62, 0.16666666666667
44344, 1.9083333333333, 1.62, 0.14583333333333
44345, 1.9083333333333, 1.64, 0.16666666666667
44346, 1.8875, 1.66, 0.16666666666667
44347, 1.9083333333333, 1.66, 0.14583333333333
44348, 1.9083333333333, 1.68, 0.16666666666667
44349, 1.95, 1.52, 0.16666666666667
44350, 1.9291666666667, 1.54, 0.16666666666667
44351, 1.95, 1.54, 0.14583333333333
44352, 1.95, 1.56, 0.16666666666667
44353, 1.9291666666667, 1.58, 0.16666666666667
44354, 1.95, 1.58, 0.14583333333333
44355, 1.95, 1.6, 0.16666666666667
44356, 1.9291666666667, 1.62, 0.16666666666667
44357, 1.95, 1.62, 0.14583333333333
44358, 1.95, 1.64, 0.16666666666667
44359, 1.9291666666667, 1.66, 0.16666666666667
44360, 1.95, 1.66, 0.14583333333333
44361, 1.95, 1.68, 0.16666666666667
44362, 1.9916666666667, 1.52, 0.16666666666667
44363, 1.9708333333333, 1.54, 0.16666666666667
44364, 1.9916666666667, 1.54, 0.14583333333333
44365, 1.9916666666667, 1.56, 0.16666666666667
44366, 1.9708333333333, 1.58, 0.16666666666667
44367, 1.9916666666667, 1.58, 0.14583333333333
44368, 1.9916666666667, 1.6, 0.16666666666667
44369, 1.9708333333333, 1.62, 0.16666666666667
44370, 1.9916666666667, 1.62, 0.14583333333333
44371, 1.9916666666667, 1.64, 0.16666666666667
44372, 1.9708333333333, 1.66, 0.16666666666667
44373, 1.9916666666667, 1.66, 0.14583333333333
44374, 1.9916666666667, 1.68, 0.16666666666667
44375, 2.0333333333333, 1.52, 0.16666666666667
44376, 2.0125, 1.54, 0.16666666666667
44377, 2.0333333333333, 1.54, 0.14583333333333
44378, 2.0333333333333, 1.56, 0.16666666666667
44379, 2.0125, 1.58, 0.16666666666667
44380, 2.0333333333333, 1.58, 0.14583333333333
44381, 2.0333333333333, 1.6, 0.16666666666667
44382, 2.0125, 1.62, 0.16666666666667
44383, 2.0333333333333, 1.62, 0.14583333333333
44384, 2.0333333333333, 1.64, 0.16666666666667
44385, 2.0125, 1.66, 0.16666666666667
44386, 2.0333333333333, 1.66, 0.14583333333333
44387, 2.0333333333333, 1.68, 0.16666666666667
44388, 2.075, 1.52, 0.16666666666667
44389, 2.0541666666667, 1.54, 0.16666666666667
44390, 2.075, 1.54, 0.14583333333333
44391, 2.075, 1.56, 0.16666666666667
44392, 2.0541666666667, 1.58, 0.16666666666667
44393, 2.075, 1.58, 0.14583333333333
44394, 2.075, 1.6, 0.16666666666667
44395, 2.0541666666667, 1.62, 0.16666666666667
44396, 2.075, 1.62, 0.14583333333333
44397, 2.075, 1.64, 0.16666666666667
44398, 2.0541666666667, 1.66, 0.16666666666667
44399, 2.075, 1.66, 0.14583333333333
44400, 2.075, 1.68, 0.16666666666667
44401, 2.1166666666667, 1.52, 0.16666666666667
44402, 2.0958333333333, 1.54, 0.16666666666667
44403, 2.1166666666667, 1.54, 0.14583333333333
44404, 2.1166666666667, 1.56, 0.16666666666667
44405, 2.0958333333333, 1.58, 0.16666666666667
44406, 2.1166666666667, 1.58, 0.14583333333333
44407, 2.1166666666667, 1.6, 0.16666666666667
44408, 2.0958333333333, 1.62, 0.16666666666667
44409, 2.1166666666667, 1.62, 0.14583333333333
44410, 2.1166666666667, 1.64, 0.16666666666667
44411, 2.0958333333333, 1.66, 0.16666666666667
44412, 2.1166666666667, 1.66, 0.14583333333333
44413, 2.1166666666667, 1.68, 0.16666666666667
44414, 2.1583333333333, 1.52, 0.16666666666667
44415, 2.1375, 1.54, 0.16666666666667
44416, 2.1583333333333, 1.54, 0.14583333333333
44417, 2.1583333333333, 1.56, 0.16666666666667
44418, 2.1375, 1.58, 0.16666666666667
44419, 2.1583333333333, 1.58, 0.14583333333333
44420, 2.1583333333333, 1.6, 0.16666666666667
44421, 2.1375, 1.62, 0.16666666666667
44422, 2.1583333333333, 1.62, 0.14583333333333
44423, 2.1583333333333, 1.64, 0.16666666666667
44424, 2.1375, 1.66, 0.16666666666667
44425, 2.1583333333333, 1.66, 0.14583333333333
44426, 2.1583333333333, 1.68, 0.16666666666667
44427, 2.1791666666667, 1.54, 0.16666666666667
44428, 2.1791666666667, 1.58, 0.16666666666667
44429, 2.1791666666667, 1.62, 0.16666666666667
44430, 2.1791666666667, 1.66, 0.16666666666667
44431, 1.2416666666667, 1.52, 0.20833333333333
44432, 1.2208333333333, 1.54, 0.20833333333333
44433, 1.2416666666667, 1.54, 0.1875
44434, 1.2416666666667, 1.56, 0.20833333333333
44435, 1.2208333333333, 1.58, 0.20833333333333
44436, 1.2416666666667, 1.58, 0.1875
44437, 1.2416666666667, 1.6, 0.20833333333333
44438, 1.2208333333333, 1.62, 0.20833333333333
44439, 1.2416666666667, 1.62, 0.1875
44440, 1.2416666666667, 1.64, 0.20833333333333
44441, 1.2208333333333, 1.66, 0.20833333333333
44442, 1.2416666666667, 1.66, 0.1875
44443, 1.2416666666667, 1.68, 0.20833333333333
44444, 1.2833333333333, 1.52, 0.20833333333333
44445, 1.2625, 1.54, 0.20833333333333
44446, 1.2833333333333, 1.54, 0.1875
44447, 1.2833333333333, 1.56, 0.20833333333333
44448, 1.2625, 1.58, 0.20833333333333
44449, 1.2833333333333, 1.58, 0.1875
44450, 1.2833333333333, 1.6, 0.20833333333333
44451, 1.2625, 1.62, 0.20833333333333
44452, 1.2833333333333, 1.62, 0.1875
44453, 1.2833333333333, 1.64, 0.20833333333333
44454, 1.2625, 1.66, 0.20833333333333
44455, 1.2833333333333, 1.66, 0.1875
44456, 1.2833333333333, 1.68, 0.20833333333333
44457, 1.325, 1.52, 0.20833333333333
44458, 1.3041666666667, 1.54, 0.20833333333333
44459, 1.325, 1.54, 0.1875
44460, 1.325, 1.56, 0.20833333333333
44461, 1.3041666666667, 1.58, 0.20833333333333
44462, 1.325, 1.58, 0.1875
44463, 1.325, 1.6, 0.20833333333333
44464, 1.3041666666667, 1.62, 0.20833333333333
44465, 1.325, 1.62, 0.1875
44466, 1.325, 1.64, 0.20833333333333
44467, 1.3041666666667, 1.66, 0.20833333333333
44468, 1.325, 1.66, 0.1875
44469, 1.325, 1.68, 0.20833333333333
44470, 1.3666666666667, 1.52, 0.20833333333333
44471, 1.3458333333333, 1.54, 0.20833333333333
44472, 1.3666666666667, 1.54, 0.1875
44473, 1.3666666666667, 1.56, 0.20833333333333
44474, 1.3458333333333, 1.58, 0.20833333333333
44475, 1.3666666666667, 1.58, 0.1875
44476, 1.3666666666667, 1.6, 0.20833333333333
44477, 1.3458333333333, 1.62, 0.20833333333333
44478, 1.3666666666667, 1.62, 0.1875
44479, 1.3666666666667, 1.64, 0.20833333333333
44480, 1.3458333333333, 1.66, 0.20833333333333
44481, 1.3666666666667, 1.66, 0.1875
44482, 1.3666666666667, 1.68, 0.20833333333333
44483, 1.4083333333333, 1.52, 0.20833333333333
44484, 1.3875, 1.54, 0.20833333333333
44485, 1.4083333333333, 1.54, 0.1875
44486, 1.4083333333333, 1.56, 0.20833333333333
44487, 1.3875, 1.58, 0.20833333333333
44488, 1.4083333333333, 1.58, 0.1875
44489, 1.4083333333333, 1.6, 0.20833333333333
44490, 1.3875, 1.62, 0.20833333333333
44491, 1.4083333333333, 1.62, 0.1875
44492, 1.4083333333333, 1.64, 0.20833333333333
44493, 1.3875, 1.66, 0.20833333333333
44494, 1.4083333333333, 1.66, 0.1875
44495, 1.4083333333333, 1.68, 0.20833333333333
44496, 1.45, 1.52, 0.20833333333333
44497, 1.4291666666667, 1.54, 0.20833333333333
44498, 1.45, 1.54, 0.1875
44499, 1.45, 1.56, 0.20833333333333
44500, 1.4291666666667, 1.58, 0.20833333333333
44501, 1.45, 1.58, 0.1875
44502, 1.45, 1.6, 0.20833333333333
44503, 1.4291666666667, 1.62, 0.20833333333333
44504, 1.45, 1.62, 0.1875
44505, 1.45, 1.64, 0.20833333333333
44506, 1.4291666666667, 1.66, 0.20833333333333
44507, 1.45, 1.66, 0.1875
44508, 1.45, 1.68, 0.20833333333333
44509, 1.4916666666667, 1.52, 0.20833333333333
44510, 1.4708333333333, 1.54, 0.20833333333333
44511, 1.4916666666667, 1.54, 0.1875
44512, 1.4916666666667, 1.56, 0.20833333333333
44513, 1.4708333333333, 1.58, 0.20833333333333
44514, 1.4916666666667, 1.58, 0.1875
44515, 1.4916666666667, 1.6, 0.20833333333333
44516, 1.4708333333333, 1.62, 0.20833333333333
44517, 1.4916666666667, 1.62, 0.1875
44518, 1.4916666666667, 1.64, 0.20833333333333
44519, 1.4708333333333, 1.66, 0.20833333333333
44520, 1.4916666666667, 1.66, 0.1875
44521, 1.4916666666667, 1.68, 0.20833333333333
44522, 1.5333333333333, 1.52, 0.20833333333333
44523, 1.5125, 1.54, 0.20833333333333
44524, 1.5333333333333, 1.54, 0.1875
44525, 1.5333333333333, 1.56, 0.20833333333333
44526, 1.5125, 1.58, 0.20833333333333
44527, 1.5333333333333, 1.58, 0.1875
44528, 1.5333333333333, 1.6, 0.20833333333333
44529, 1.5125, 1.62, 0.20833333333333
44530, 1.5333333333333, 1.62, 0.1875
44531, 1.5333333333333, 1.64, 0.20833333333333
44532, 1.5125, 1.66, 0.20833333333333
44533, 1.5333333333333, 1.66, 0.1875
44534, 1.5333333333333, 1.68, 0.20833333333333
44535, 1.575, 1.52, 0.20833333333333
44536, 1.5541666666667, 1.54, 0.20833333333333
44537, 1.575, 1.54, 0.1875
44538, 1.575, 1.56, 0.20833333333333
44539, 1.5541666666667, 1.58, 0.20833333333333
44540, 1.575, 1.58, 0.1875
44541, 1.575, 1.6, 0.20833333333333
44542, 1.5541666666667, 1.62, 0.20833333333333
44543, 1.575, 1.62, 0.1875
44544, 1.575, 1.64, 0.20833333333333
44545, 1.5541666666667, 1.66, 0.20833333333333
44546, 1.575, 1.66, 0.1875
44547, 1.575, 1.68, 0.20833333333333
44548, 1.6166666666667, 1.52, 0.20833333333333
44549, 1.5958333333333, 1.54, 0.20833333333333
44550, 1.6166666666667, 1.54, 0.1875
44551, 1.6166666666667, 1.56, 0.20833333333333
44552, 1.5958333333333, 1.58, 0.20833333333333
44553, 1.6166666666667, 1.58, 0.1875
44554, 1.6166666666667, 1.6, 0.20833333333333
44555, 1.5958333333333, 1.62, 0.20833333333333
44556, 1.6166666666667, 1.62, 0.1875
44557, 1.6166666666667, 1.64, 0.20833333333333
44558, 1.5958333333333, 1.66, 0.20833333333333
44559, 1.6166666666667, 1.66, 0.1875
44560, 1.6166666666667, 1.68, 0.20833333333333
44561, 1.6583333333333, 1.52, 0.20833333333333
44562, 1.6375, 1.54, 0.20833333333333
44563, 1.6583333333333, 1.54, 0.1875
44564, 1.6583333333333, 1.56, 0.20833333333333
44565, 1.6375, 1.58, 0.20833333333333
44566, 1.6583333333333, 1.58, 0.1875
44567, 1.6583333333333, 1.6, 0.20833333333333
44568, 1.6375, 1.62, 0.20833333333333
44569, 1.6583333333333, 1.62, 0.1875
44570, 1.6583333333333, 1.64, 0.20833333333333
44571, 1.6375, 1.66, 0.20833333333333
44572, 1.6583333333333, 1.66, 0.1875
44573, 1.6583333333333, 1.68, 0.20833333333333
44574, 1.7, 1.52, 0.20833333333333
44575, 1.6791666666667, 1.54, 0.20833333333333
44576, 1.7, 1.54, 0.1875
44577, 1.7, 1.56, 0.20833333333333
44578, 1.6791666666667, 1.58, 0.20833333333333
44579, 1.7, 1.58, 0.1875
44580, 1.7, 1.6, 0.20833333333333
44581, 1.6791666666667, 1.62, 0.20833333333333
44582, 1.7, 1.62, 0.1875
44583, 1.7, 1.64, 0.20833333333333
44584, 1.6791666666667, 1.66, 0.20833333333333
44585, 1.7, 1.66, 0.1875
44586, 1.7, 1.68, 0.20833333333333
44587, 1.7416666666667, 1.52, 0.20833333333333
44588, 1.7208333333333, 1.54, 0.20833333333333
44589, 1.7416666666667, 1.54, 0.1875
44590, 1.7416666666667, 1.56, 0.20833333333333
44591, 1.7208333333333, 1.58, 0.20833333333333
44592, 1.7416666666667, 1.58, 0.1875
44593, 1.7416666666667, 1.6, 0.20833333333333
44594, 1.7208333333333, 1.62, 0.20833333333333
44595, 1.7416666666667, 1.62, 0.1875
44596, 1.7416666666667, 1.64, 0.20833333333333
44597, 1.7208333333333, 1.66, 0.20833333333333
44598, 1.7416666666667, 1.66, 0.1875
44599, 1.7416666666667, 1.68, 0.20833333333333
44600, 1.7833333333333, 1.52, 0.20833333333333
44601, 1.7625, 1.54, 0.20833333333333
44602, 1.7833333333333, 1.54, 0.1875
44603, 1.7833333333333, 1.56, 0.20833333333333
44604, 1.7625, 1.58, 0.20833333333333
44605, 1.7833333333333, 1.58, 0.1875
44606, 1.7833333333333, 1.6, 0.20833333333333
44607, 1.7625, 1.62, 0.20833333333333
44608, 1.7833333333333, 1.62, 0.1875
44609, 1.7833333333333, 1.64, 0.20833333333333
44610, 1.7625, 1.66, 0.20833333333333
44611, 1.7833333333333, 1.66, 0.1875
44612, 1.7833333333333, 1.68, 0.20833333333333
44613, 1.825, 1.52, 0.20833333333333
44614, 1.8041666666667, 1.54, 0.20833333333333
44615, 1.825, 1.54, 0.1875
44616, 1.825, 1.56, 0.20833333333333
44617, 1.8041666666667, 1.58, 0.20833333333333
44618, 1.825, 1.58, 0.1875
44619, 1.825, 1.6, 0.20833333333333
44620, 1.8041666666667, 1.62, 0.20833333333333
44621, 1.825, 1.62, 0.1875
44622, 1.825, 1.64, 0.20833333333333
44623, 1.8041666666667, 1.66, 0.20833333333333
44624, 1.825, 1.66, 0.1875
44625, 1.825, 1.68, 0.20833333333333
44626, 1.8666666666667, 1.52, 0.20833333333333
44627, 1.8458333333333, 1.54, 0.20833333333333
44628, 1.8666666666667, 1.54, 0.1875
44629, 1.8666666666667, 1.56, 0.20833333333333
44630, 1.8458333333333, 1.58, 0.20833333333333
44631, 1.8666666666667, 1.58, 0.1875
44632, 1.8666666666667, 1.6, 0.20833333333333
44633, 1.8458333333333, 1.62, 0.20833333333333
44634, 1.8666666666667, 1.62, 0.1875
44635, 1.8666666666667, 1.64, 0.20833333333333
