19601, 29733, 29756, 30285, 30262, 29734, 29757, 30286, 30263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19602, 29734, 29757, 30286, 30263, 29735, 29758, 30287, 30264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19603, 29735, 29758, 30287, 30264, 29736, 29759, 30288, 30265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19604, 29736, 29759, 30288, 30265, 29737, 29760, 30289, 30266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19605, 29737, 29760, 30289, 30266, 8447, 8448, 8471, 8470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19606, 6631, 6632, 6655, 6654, 29738, 29761, 30290, 30267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19607, 29738, 29761, 30290, 30267, 29739, 29762, 30291, 30268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19608, 29739, 29762, 30291, 30268, 29740, 29763, 30292, 30269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19609, 29740, 29763, 30292, 30269, 29741, 29764, 30293, 30270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19610, 29741, 29764, 30293, 30270, 29742, 29765, 30294, 30271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19611, 29742, 29765, 30294, 30271, 29743, 29766, 30295, 30272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19612, 29743, 29766, 30295, 30272, 29744, 29767, 30296, 30273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19613, 29744, 29767, 30296, 30273, 29745, 29768, 30297, 30274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19614, 29745, 29768, 30297, 30274, 29746, 29769, 30298, 30275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19615, 29746, 29769, 30298, 30275, 29747, 29770, 30299, 30276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19616, 29747, 29770, 30299, 30276, 29748, 29771, 30300, 30277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19617, 29748, 29771, 30300, 30277, 29749, 29772, 30301, 30278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19618, 29749, 29772, 30301, 30278, 29750, 29773, 30302, 30279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19619, 29750, 29773, 30302, 30279, 29751, 29774, 30303, 30280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19620, 29751, 29774, 30303, 30280, 29752, 29775, 30304, 30281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19621, 29752, 29775, 30304, 30281, 29753, 29776, 30305, 30282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19622, 29753, 29776, 30305, 30282, 29754, 29777, 30306, 30283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19623, 29754, 29777, 30306, 30283, 29755, 29778, 30307, 30284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19624, 29755, 29778, 30307, 30284, 29756, 29779, 30308, 30285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19625, 29756, 29779, 30308, 30285, 29757, 29780, 30309, 30286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19626, 29757, 29780, 30309, 30286, 29758, 29781, 30310, 30287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19627, 29758, 29781, 30310, 30287, 29759, 29782, 30311, 30288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19628, 29759, 29782, 30311, 30288, 29760, 29783, 30312, 30289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19629, 29760, 29783, 30312, 30289, 8448, 8449, 8472, 8471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19630, 6632, 6633, 6656, 6655, 29761, 29784, 30313, 30290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19631, 29761, 29784, 30313, 30290, 29762, 29785, 30314, 30291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19632, 29762, 29785, 30314, 30291, 29763, 29786, 30315, 30292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19633, 29763, 29786, 30315, 30292, 29764, 29787, 30316, 30293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19634, 29764, 29787, 30316, 30293, 29765, 29788, 30317, 30294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19635, 29765, 29788, 30317, 30294, 29766, 29789, 30318, 30295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19636, 29766, 29789, 30318, 30295, 29767, 29790, 30319, 30296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19637, 29767, 29790, 30319, 30296, 29768, 29791, 30320, 30297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19638, 29768, 29791, 30320, 30297, 29769, 29792, 30321, 30298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19639, 29769, 29792, 30321, 30298, 29770, 29793, 30322, 30299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19640, 29770, 29793, 30322, 30299, 29771, 29794, 30323, 30300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19641, 29771, 29794, 30323, 30300, 29772, 29795, 30324, 30301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19642, 29772, 29795, 30324, 30301, 29773, 29796, 30325, 30302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19643, 29773, 29796, 30325, 30302, 29774, 29797, 30326, 30303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19644, 29774, 29797, 30326, 30303, 29775, 29798, 30327, 30304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19645, 29775, 29798, 30327, 30304, 29776, 29799, 30328, 30305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19646, 29776, 29799, 30328, 30305, 29777, 29800, 30329, 30306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19647, 29777, 29800, 30329, 30306, 29778, 29801, 30330, 30307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19648, 29778, 29801, 30330, 30307, 29779, 29802, 30331, 30308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19649, 29779, 29802, 30331, 30308, 29780, 29803, 30332, 30309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19650, 29780, 29803, 30332, 30309, 29781, 29804, 30333, 30310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19651, 29781, 29804, 30333, 30310, 29782, 29805, 30334, 30311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19652, 29782, 29805, 30334, 30311, 29783, 29806, 30335, 30312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19653, 29783, 29806, 30335, 30312, 8449, 8450, 8473, 8472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19654, 6633, 6634, 6657, 6656, 29784, 29807, 30336, 30313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19655, 29784, 29807, 30336, 30313, 29785, 29808, 30337, 30314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19656, 29785, 29808, 30337, 30314, 29786, 29809, 30338, 30315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19657, 29786, 29809, 30338, 30315, 29787, 29810, 30339, 30316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19658, 29787, 29810, 30339, 30316, 29788, 29811, 30340, 30317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19659, 29788, 29811, 30340, 30317, 29789, 29812, 30341, 30318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19660, 29789, 29812, 30341, 30318, 29790, 29813, 30342, 30319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19661, 29790, 29813, 30342, 30319, 29791, 29814, 30343, 30320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19662, 29791, 29814, 30343, 30320, 29792, 29815, 30344, 30321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19663, 29792, 29815, 30344, 30321, 29793, 29816, 30345, 30322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19664, 29793, 29816, 30345, 30322, 29794, 29817, 30346, 30323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19665, 29794, 29817, 30346, 30323, 29795, 29818, 30347, 30324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19666, 29795, 29818, 30347, 30324, 29796, 29819, 30348, 30325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19667, 29796, 29819, 30348, 30325, 29797, 29820, 30349, 30326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19668, 29797, 29820, 30349, 30326, 29798, 29821, 30350, 30327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19669, 29798, 29821, 30350, 30327, 29799, 29822, 30351, 30328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19670, 29799, 29822, 30351, 30328, 29800, 29823, 30352, 30329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19671, 29800, 29823, 30352, 30329, 29801, 29824, 30353, 30330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19672, 29801, 29824, 30353, 30330, 29802, 29825, 30354, 30331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19673, 29802, 29825, 30354, 30331, 29803, 29826, 30355, 30332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19674, 29803, 29826, 30355, 30332, 29804, 29827, 30356, 30333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19675, 29804, 29827, 30356, 30333, 29805, 29828, 30357, 30334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19676, 29805, 29828, 30357, 30334, 29806, 29829, 30358, 30335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19677, 29806, 29829, 30358, 30335, 8450, 8451, 8474, 8473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19678, 6634, 6635, 6658, 6657, 29807, 29830, 30359, 30336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19679, 29807, 29830, 30359, 30336, 29808, 29831, 30360, 30337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19680, 29808, 29831, 30360, 30337, 29809, 29832, 30361, 30338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19681, 29809, 29832, 30361, 30338, 29810, 29833, 30362, 30339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19682, 29810, 29833, 30362, 30339, 29811, 29834, 30363, 30340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19683, 29811, 29834, 30363, 30340, 29812, 29835, 30364, 30341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19684, 29812, 29835, 30364, 30341, 29813, 29836, 30365, 30342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19685, 29813, 29836, 30365, 30342, 29814, 29837, 30366, 30343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19686, 29814, 29837, 30366, 30343, 29815, 29838, 30367, 30344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19687, 29815, 29838, 30367, 30344, 29816, 29839, 30368, 30345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19688, 29816, 29839, 30368, 30345, 29817, 29840, 30369, 30346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19689, 29817, 29840, 30369, 30346, 29818, 29841, 30370, 30347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19690, 29818, 29841, 30370, 30347, 29819, 29842, 30371, 30348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19691, 29819, 29842, 30371, 30348, 29820, 29843, 30372, 30349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19692, 29820, 29843, 30372, 30349, 29821, 29844, 30373, 30350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19693, 29821, 29844, 30373, 30350, 29822, 29845, 30374, 30351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19694, 29822, 29845, 30374, 30351, 29823, 29846, 30375, 30352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19695, 29823, 29846, 30375, 30352, 29824, 29847, 30376, 30353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19696, 29824, 29847, 30376, 30353, 29825, 29848, 30377, 30354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19697, 29825, 29848, 30377, 30354, 29826, 29849, 30378, 30355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19698, 29826, 29849, 30378, 30355, 29827, 29850, 30379, 30356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19699, 29827, 29850, 30379, 30356, 29828, 29851, 30380, 30357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19700, 29828, 29851, 30380, 30357, 29829, 29852, 30381, 30358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19701, 29829, 29852, 30381, 30358, 8451, 8452, 8475, 8474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19702, 6635, 6636, 6659, 6658, 29830, 29853, 30382, 30359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19703, 29830, 29853, 30382, 30359, 29831, 29854, 30383, 30360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19704, 29831, 29854, 30383, 30360, 29832, 29855, 30384, 30361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19705, 29832, 29855, 30384, 30361, 29833, 29856, 30385, 30362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19706, 29833, 29856, 30385, 30362, 29834, 29857, 30386, 30363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19707, 29834, 29857, 30386, 30363, 29835, 29858, 30387, 30364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19708, 29835, 29858, 30387, 30364, 29836, 29859, 30388, 30365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19709, 29836, 29859, 30388, 30365, 29837, 29860, 30389, 30366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19710, 29837, 29860, 30389, 30366, 29838, 29861, 30390, 30367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19711, 29838, 29861, 30390, 30367, 29839, 29862, 30391, 30368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19712, 29839, 29862, 30391, 30368, 29840, 29863, 30392, 30369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19713, 29840, 29863, 30392, 30369, 29841, 29864, 30393, 30370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19714, 29841, 29864, 30393, 30370, 29842, 29865, 30394, 30371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19715, 29842, 29865, 30394, 30371, 29843, 29866, 30395, 30372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19716, 29843, 29866, 30395, 30372, 29844, 29867, 30396, 30373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19717, 29844, 29867, 30396, 30373, 29845, 29868, 30397, 30374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19718, 29845, 29868, 30397, 30374, 29846, 29869, 30398, 30375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19719, 29846, 29869, 30398, 30375, 29847, 29870, 30399, 30376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19720, 29847, 29870, 30399, 30376, 29848, 29871, 30400, 30377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19721, 29848, 29871, 30400, 30377, 29849, 29872, 30401, 30378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19722, 29849, 29872, 30401, 30378, 29850, 29873, 30402, 30379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19723, 29850, 29873, 30402, 30379, 29851, 29874, 30403, 30380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19724, 29851, 29874, 30403, 30380, 29852, 29875, 30404, 30381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19725, 29852, 29875, 30404, 30381, 8452, 8453, 8476, 8475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19726, 6636, 6637, 6660, 6659, 29853, 29876, 30405, 30382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19727, 29853, 29876, 30405, 30382, 29854, 29877, 30406, 30383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19728, 29854, 29877, 30406, 30383, 29855, 29878, 30407, 30384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19729, 29855, 29878, 30407, 30384, 29856, 29879, 30408, 30385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19730, 29856, 29879, 30408, 30385, 29857, 29880, 30409, 30386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19731, 29857, 29880, 30409, 30386, 29858, 29881, 30410, 30387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19732, 29858, 29881, 30410, 30387, 29859, 29882, 30411, 30388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19733, 29859, 29882, 30411, 30388, 29860, 29883, 30412, 30389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19734, 29860, 29883, 30412, 30389, 29861, 29884, 30413, 30390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19735, 29861, 29884, 30413, 30390, 29862, 29885, 30414, 30391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19736, 29862, 29885, 30414, 30391, 29863, 29886, 30415, 30392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19737, 29863, 29886, 30415, 30392, 29864, 29887, 30416, 30393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19738, 29864, 29887, 30416, 30393, 29865, 29888, 30417, 30394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19739, 29865, 29888, 30417, 30394, 29866, 29889, 30418, 30395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19740, 29866, 29889, 30418, 30395, 29867, 29890, 30419, 30396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19741, 29867, 29890, 30419, 30396, 29868, 29891, 30420, 30397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19742, 29868, 29891, 30420, 30397, 29869, 29892, 30421, 30398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19743, 29869, 29892, 30421, 30398, 29870, 29893, 30422, 30399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19744, 29870, 29893, 30422, 30399, 29871, 29894, 30423, 30400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19745, 29871, 29894, 30423, 30400, 29872, 29895, 30424, 30401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19746, 29872, 29895, 30424, 30401, 29873, 29896, 30425, 30402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19747, 29873, 29896, 30425, 30402, 29874, 29897, 30426, 30403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19748, 29874, 29897, 30426, 30403, 29875, 29898, 30427, 30404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19749, 29875, 29898, 30427, 30404, 8453, 8454, 8477, 8476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19750, 6637, 6638, 6661, 6660, 29876, 29899, 30428, 30405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19751, 29876, 29899, 30428, 30405, 29877, 29900, 30429, 30406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19752, 29877, 29900, 30429, 30406, 29878, 29901, 30430, 30407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19753, 29878, 29901, 30430, 30407, 29879, 29902, 30431, 30408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19754, 29879, 29902, 30431, 30408, 29880, 29903, 30432, 30409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19755, 29880, 29903, 30432, 30409, 29881, 29904, 30433, 30410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19756, 29881, 29904, 30433, 30410, 29882, 29905, 30434, 30411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19757, 29882, 29905, 30434, 30411, 29883, 29906, 30435, 30412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19758, 29883, 29906, 30435, 30412, 29884, 29907, 30436, 30413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19759, 29884, 29907, 30436, 30413, 29885, 29908, 30437, 30414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19760, 29885, 29908, 30437, 30414, 29886, 29909, 30438, 30415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19761, 29886, 29909, 30438, 30415, 29887, 29910, 30439, 30416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19762, 29887, 29910, 30439, 30416, 29888, 29911, 30440, 30417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19763, 29888, 29911, 30440, 30417, 29889, 29912, 30441, 30418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19764, 29889, 29912, 30441, 30418, 29890, 29913, 30442, 30419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19765, 29890, 29913, 30442, 30419, 29891, 29914, 30443, 30420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19766, 29891, 29914, 30443, 30420, 29892, 29915, 30444, 30421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19767, 29892, 29915, 30444, 30421, 29893, 29916, 30445, 30422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19768, 29893, 29916, 30445, 30422, 29894, 29917, 30446, 30423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19769, 29894, 29917, 30446, 30423, 29895, 29918, 30447, 30424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19770, 29895, 29918, 30447, 30424, 29896, 29919, 30448, 30425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19771, 29896, 29919, 30448, 30425, 29897, 29920, 30449, 30426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19772, 29897, 29920, 30449, 30426, 29898, 29921, 30450, 30427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19773, 29898, 29921, 30450, 30427, 8454, 8455, 8478, 8477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19774, 6638, 6639, 6662, 6661, 29899, 29922, 30451, 30428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19775, 29899, 29922, 30451, 30428, 29900, 29923, 30452, 30429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19776, 29900, 29923, 30452, 30429, 29901, 29924, 30453, 30430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19777, 29901, 29924, 30453, 30430, 29902, 29925, 30454, 30431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19778, 29902, 29925, 30454, 30431, 29903, 29926, 30455, 30432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19779, 29903, 29926, 30455, 30432, 29904, 29927, 30456, 30433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19780, 29904, 29927, 30456, 30433, 29905, 29928, 30457, 30434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19781, 29905, 29928, 30457, 30434, 29906, 29929, 30458, 30435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19782, 29906, 29929, 30458, 30435, 29907, 29930, 30459, 30436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19783, 29907, 29930, 30459, 30436, 29908, 29931, 30460, 30437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19784, 29908, 29931, 30460, 30437, 29909, 29932, 30461, 30438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19785, 29909, 29932, 30461, 30438, 29910, 29933, 30462, 30439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19786, 29910, 29933, 30462, 30439, 29911, 29934, 30463, 30440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19787, 29911, 29934, 30463, 30440, 29912, 29935, 30464, 30441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19788, 29912, 29935, 30464, 30441, 29913, 29936, 30465, 30442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19789, 29913, 29936, 30465, 30442, 29914, 29937, 30466, 30443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19790, 29914, 29937, 30466, 30443, 29915, 29938, 30467, 30444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19791, 29915, 29938, 30467, 30444, 29916, 29939, 30468, 30445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19792, 29916, 29939, 30468, 30445, 29917, 29940, 30469, 30446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19793, 29917, 29940, 30469, 30446, 29918, 29941, 30470, 30447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19794, 29918, 29941, 30470, 30447, 29919, 29942, 30471, 30448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19795, 29919, 29942, 30471, 30448, 29920, 29943, 30472, 30449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19796, 29920, 29943, 30472, 30449, 29921, 29944, 30473, 30450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19797, 29921, 29944, 30473, 30450, 8455, 8456, 8479, 8478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19798, 6639, 6640, 6663, 6662, 29922, 29945, 30474, 30451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19799, 29922, 29945, 30474, 30451, 29923, 29946, 30475, 30452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19800, 29923, 29946, 30475, 30452, 29924, 29947, 30476, 30453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19801, 29924, 29947, 30476, 30453, 29925, 29948, 30477, 30454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19802, 29925, 29948, 30477, 30454, 29926, 29949, 30478, 30455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19803, 29926, 29949, 30478, 30455, 29927, 29950, 30479, 30456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19804, 29927, 29950, 30479, 30456, 29928, 29951, 30480, 30457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19805, 29928, 29951, 30480, 30457, 29929, 29952, 30481, 30458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19806, 29929, 29952, 30481, 30458, 29930, 29953, 30482, 30459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19807, 29930, 29953, 30482, 30459, 29931, 29954, 30483, 30460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19808, 29931, 29954, 30483, 30460, 29932, 29955, 30484, 30461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19809, 29932, 29955, 30484, 30461, 29933, 29956, 30485, 30462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19810, 29933, 29956, 30485, 30462, 29934, 29957, 30486, 30463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19811, 29934, 29957, 30486, 30463, 29935, 29958, 30487, 30464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19812, 29935, 29958, 30487, 30464, 29936, 29959, 30488, 30465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19813, 29936, 29959, 30488, 30465, 29937, 29960, 30489, 30466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19814, 29937, 29960, 30489, 30466, 29938, 29961, 30490, 30467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19815, 29938, 29961, 30490, 30467, 29939, 29962, 30491, 30468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19816, 29939, 29962, 30491, 30468, 29940, 29963, 30492, 30469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19817, 29940, 29963, 30492, 30469, 29941, 29964, 30493, 30470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19818, 29941, 29964, 30493, 30470, 29942, 29965, 30494, 30471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19819, 29942, 29965, 30494, 30471, 29943, 29966, 30495, 30472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19820, 29943, 29966, 30495, 30472, 29944, 29967, 30496, 30473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19821, 29944, 29967, 30496, 30473, 8456, 8457, 8480, 8479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19822, 6640, 6641, 6664, 6663, 29945, 29968, 30497, 30474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19823, 29945, 29968, 30497, 30474, 29946, 29969, 30498, 30475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19824, 29946, 29969, 30498, 30475, 29947, 29970, 30499, 30476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19825, 29947, 29970, 30499, 30476, 29948, 29971, 30500, 30477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19826, 29948, 29971, 30500, 30477, 29949, 29972, 30501, 30478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19827, 29949, 29972, 30501, 30478, 29950, 29973, 30502, 30479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19828, 29950, 29973, 30502, 30479, 29951, 29974, 30503, 30480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19829, 29951, 29974, 30503, 30480, 29952, 29975, 30504, 30481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19830, 29952, 29975, 30504, 30481, 29953, 29976, 30505, 30482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19831, 29953, 29976, 30505, 30482, 29954, 29977, 30506, 30483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19832, 29954, 29977, 30506, 30483, 29955, 29978, 30507, 30484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19833, 29955, 29978, 30507, 30484, 29956, 29979, 30508, 30485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19834, 29956, 29979, 30508, 30485, 29957, 29980, 30509, 30486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19835, 29957, 29980, 30509, 30486, 29958, 29981, 30510, 30487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19836, 29958, 29981, 30510, 30487, 29959, 29982, 30511, 30488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19837, 29959, 29982, 30511, 30488, 29960, 29983, 30512, 30489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19838, 29960, 29983, 30512, 30489, 29961, 29984, 30513, 30490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19839, 29961, 29984, 30513, 30490, 29962, 29985, 30514, 30491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19840, 29962, 29985, 30514, 30491, 29963, 29986, 30515, 30492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19841, 29963, 29986, 30515, 30492, 29964, 29987, 30516, 30493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19842, 29964, 29987, 30516, 30493, 29965, 29988, 30517, 30494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19843, 29965, 29988, 30517, 30494, 29966, 29989, 30518, 30495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19844, 29966, 29989, 30518, 30495, 29967, 29990, 30519, 30496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19845, 29967, 29990, 30519, 30496, 8457, 8458, 8481, 8480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19846, 6641, 6642, 6665, 6664, 29968, 29991, 30520, 30497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19847, 29968, 29991, 30520, 30497, 29969, 29992, 30521, 30498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19848, 29969, 29992, 30521, 30498, 29970, 29993, 30522, 30499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19849, 29970, 29993, 30522, 30499, 29971, 29994, 30523, 30500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19850, 29971, 29994, 30523, 30500, 29972, 29995, 30524, 30501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19851, 29972, 29995, 30524, 30501, 29973, 29996, 30525, 30502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19852, 29973, 29996, 30525, 30502, 29974, 29997, 30526, 30503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19853, 29974, 29997, 30526, 30503, 29975, 29998, 30527, 30504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19854, 29975, 29998, 30527, 30504, 29976, 29999, 30528, 30505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19855, 29976, 29999, 30528, 30505, 29977, 30000, 30529, 30506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19856, 29977, 30000, 30529, 30506, 29978, 30001, 30530, 30507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19857, 29978, 30001, 30530, 30507, 29979, 30002, 30531, 30508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19858, 29979, 30002, 30531, 30508, 29980, 30003, 30532, 30509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19859, 29980, 30003, 30532, 30509, 29981, 30004, 30533, 30510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19860, 29981, 30004, 30533, 30510, 29982, 30005, 30534, 30511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19861, 29982, 30005, 30534, 30511, 29983, 30006, 30535, 30512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19862, 29983, 30006, 30535, 30512, 29984, 30007, 30536, 30513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19863, 29984, 30007, 30536, 30513, 29985, 30008, 30537, 30514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19864, 29985, 30008, 30537, 30514, 29986, 30009, 30538, 30515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19865, 29986, 30009, 30538, 30515, 29987, 30010, 30539, 30516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19866, 29987, 30010, 30539, 30516, 29988, 30011, 30540, 30517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19867, 29988, 30011, 30540, 30517, 29989, 30012, 30541, 30518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19868, 29989, 30012, 30541, 30518, 29990, 30013, 30542, 30519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19869, 29990, 30013, 30542, 30519, 8458, 8459, 8482, 8481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19870, 6642, 6643, 6666, 6665, 29991, 30014, 30543, 30520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19871, 29991, 30014, 30543, 30520, 29992, 30015, 30544, 30521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19872, 29992, 30015, 30544, 30521, 29993, 30016, 30545, 30522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19873, 29993, 30016, 30545, 30522, 29994, 30017, 30546, 30523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19874, 29994, 30017, 30546, 30523, 29995, 30018, 30547, 30524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19875, 29995, 30018, 30547, 30524, 29996, 30019, 30548, 30525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19876, 29996, 30019, 30548, 30525, 29997, 30020, 30549, 30526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19877, 29997, 30020, 30549, 30526, 29998, 30021, 30550, 30527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19878, 29998, 30021, 30550, 30527, 29999, 30022, 30551, 30528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19879, 29999, 30022, 30551, 30528, 30000, 30023, 30552, 30529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19880, 30000, 30023, 30552, 30529, 30001, 30024, 30553, 30530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19881, 30001, 30024, 30553, 30530, 30002, 30025, 30554, 30531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19882, 30002, 30025, 30554, 30531, 30003, 30026, 30555, 30532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19883, 30003, 30026, 30555, 30532, 30004, 30027, 30556, 30533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19884, 30004, 30027, 30556, 30533, 30005, 30028, 30557, 30534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19885, 30005, 30028, 30557, 30534, 30006, 30029, 30558, 30535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19886, 30006, 30029, 30558, 30535, 30007, 30030, 30559, 30536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19887, 30007, 30030, 30559, 30536, 30008, 30031, 30560, 30537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19888, 30008, 30031, 30560, 30537, 30009, 30032, 30561, 30538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19889, 30009, 30032, 30561, 30538, 30010, 30033, 30562, 30539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19890, 30010, 30033, 30562, 30539, 30011, 30034, 30563, 30540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19891, 30011, 30034, 30563, 30540, 30012, 30035, 30564, 30541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19892, 30012, 30035, 30564, 30541, 30013, 30036, 30565, 30542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19893, 30013, 30036, 30565, 30542, 8459, 8460, 8483, 8482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19894, 6643, 6644, 6667, 6666, 30014, 30037, 30566, 30543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19895, 30014, 30037, 30566, 30543, 30015, 30038, 30567, 30544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19896, 30015, 30038, 30567, 30544, 30016, 30039, 30568, 30545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19897, 30016, 30039, 30568, 30545, 30017, 30040, 30569, 30546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19898, 30017, 30040, 30569, 30546, 30018, 30041, 30570, 30547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19899, 30018, 30041, 30570, 30547, 30019, 30042, 30571, 30548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19900, 30019, 30042, 30571, 30548, 30020, 30043, 30572, 30549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19901, 30020, 30043, 30572, 30549, 30021, 30044, 30573, 30550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19902, 30021, 30044, 30573, 30550, 30022, 30045, 30574, 30551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19903, 30022, 30045, 30574, 30551, 30023, 30046, 30575, 30552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19904, 30023, 30046, 30575, 30552, 30024, 30047, 30576, 30553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19905, 30024, 30047, 30576, 30553, 30025, 30048, 30577, 30554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19906, 30025, 30048, 30577, 30554, 30026, 30049, 30578, 30555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19907, 30026, 30049, 30578, 30555, 30027, 30050, 30579, 30556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19908, 30027, 30050, 30579, 30556, 30028, 30051, 30580, 30557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19909, 30028, 30051, 30580, 30557, 30029, 30052, 30581, 30558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19910, 30029, 30052, 30581, 30558, 30030, 30053, 30582, 30559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19911, 30030, 30053, 30582, 30559, 30031, 30054, 30583, 30560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19912, 30031, 30054, 30583, 30560, 30032, 30055, 30584, 30561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19913, 30032, 30055, 30584, 30561, 30033, 30056, 30585, 30562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19914, 30033, 30056, 30585, 30562, 30034, 30057, 30586, 30563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19915, 30034, 30057, 30586, 30563, 30035, 30058, 30587, 30564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19916, 30035, 30058, 30587, 30564, 30036, 30059, 30588, 30565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19917, 30036, 30059, 30588, 30565, 8460, 8461, 8484, 8483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19918, 6644, 6645, 6668, 6667, 30037, 30060, 30589, 30566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19919, 30037, 30060, 30589, 30566, 30038, 30061, 30590, 30567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19920, 30038, 30061, 30590, 30567, 30039, 30062, 30591, 30568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19921, 30039, 30062, 30591, 30568, 30040, 30063, 30592, 30569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19922, 30040, 30063, 30592, 30569, 30041, 30064, 30593, 30570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19923, 30041, 30064, 30593, 30570, 30042, 30065, 30594, 30571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19924, 30042, 30065, 30594, 30571, 30043, 30066, 30595, 30572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19925, 30043, 30066, 30595, 30572, 30044, 30067, 30596, 30573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19926, 30044, 30067, 30596, 30573, 30045, 30068, 30597, 30574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19927, 30045, 30068, 30597, 30574, 30046, 30069, 30598, 30575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19928, 30046, 30069, 30598, 30575, 30047, 30070, 30599, 30576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19929, 30047, 30070, 30599, 30576, 30048, 30071, 30600, 30577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19930, 30048, 30071, 30600, 30577, 30049, 30072, 30601, 30578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19931, 30049, 30072, 30601, 30578, 30050, 30073, 30602, 30579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19932, 30050, 30073, 30602, 30579, 30051, 30074, 30603, 30580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19933, 30051, 30074, 30603, 30580, 30052, 30075, 30604, 30581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19934, 30052, 30075, 30604, 30581, 30053, 30076, 30605, 30582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19935, 30053, 30076, 30605, 30582, 30054, 30077, 30606, 30583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19936, 30054, 30077, 30606, 30583, 30055, 30078, 30607, 30584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19937, 30055, 30078, 30607, 30584, 30056, 30079, 30608, 30585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19938, 30056, 30079, 30608, 30585, 30057, 30080, 30609, 30586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19939, 30057, 30080, 30609, 30586, 30058, 30081, 30610, 30587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19940, 30058, 30081, 30610, 30587, 30059, 30082, 30611, 30588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19941, 30059, 30082, 30611, 30588, 8461, 8462, 8485, 8484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19942, 6645, 836, 837, 6668, 30060, 8187, 8210, 30589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19943, 30060, 8187, 8210, 30589, 30061, 8188, 8211, 30590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19944, 30061, 8188, 8211, 30590, 30062, 8189, 8212, 30591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19945, 30062, 8189, 8212, 30591, 30063, 8190, 8213, 30592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19946, 30063, 8190, 8213, 30592, 30064, 8191, 8214, 30593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19947, 30064, 8191, 8214, 30593, 30065, 8192, 8215, 30594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19948, 30065, 8192, 8215, 30594, 30066, 8193, 8216, 30595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19949, 30066, 8193, 8216, 30595, 30067, 8194, 8217, 30596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19950, 30067, 8194, 8217, 30596, 30068, 8195, 8218, 30597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19951, 30068, 8195, 8218, 30597, 30069, 8196, 8219, 30598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19952, 30069, 8196, 8219, 30598, 30070, 8197, 8220, 30599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19953, 30070, 8197, 8220, 30599, 30071, 8198, 8221, 30600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19954, 30071, 8198, 8221, 30600, 30072, 8199, 8222, 30601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19955, 30072, 8199, 8222, 30601, 30073, 8200, 8223, 30602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19956, 30073, 8200, 8223, 30602, 30074, 8201, 8224, 30603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19957, 30074, 8201, 8224, 30603, 30075, 8202, 8225, 30604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19958, 30075, 8202, 8225, 30604, 30076, 8203, 8226, 30605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19959, 30076, 8203, 8226, 30605, 30077, 8204, 8227, 30606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19960, 30077, 8204, 8227, 30606, 30078, 8205, 8228, 30607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19961, 30078, 8205, 8228, 30607, 30079, 8206, 8229, 30608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19962, 30079, 8206, 8229, 30608, 30080, 8207, 8230, 30609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19963, 30080, 8207, 8230, 30609, 30081, 8208, 8231, 30610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19964, 30081, 8208, 8231, 30610, 30082, 8209, 8232, 30611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19965, 30082, 8209, 8232, 30611, 8462, 996, 997, 8485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19966, 826, 6646, 6669, 827, 7957, 30083, 30612, 7980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19967, 7957, 30083, 30612, 7980, 7958, 30084, 30613, 7981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19968, 7958, 30084, 30613, 7981, 7959, 30085, 30614, 7982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19969, 7959, 30085, 30614, 7982, 7960, 30086, 30615, 7983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19970, 7960, 30086, 30615, 7983, 7961, 30087, 30616, 7984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19971, 7961, 30087, 30616, 7984, 7962, 30088, 30617, 7985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19972, 7962, 30088, 30617, 7985, 7963, 30089, 30618, 7986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19973, 7963, 30089, 30618, 7986, 7964, 30090, 30619, 7987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19974, 7964, 30090, 30619, 7987, 7965, 30091, 30620, 7988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19975, 7965, 30091, 30620, 7988, 7966, 30092, 30621, 7989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19976, 7966, 30092, 30621, 7989, 7967, 30093, 30622, 7990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19977, 7967, 30093, 30622, 7990, 7968, 30094, 30623, 7991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19978, 7968, 30094, 30623, 7991, 7969, 30095, 30624, 7992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19979, 7969, 30095, 30624, 7992, 7970, 30096, 30625, 7993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19980, 7970, 30096, 30625, 7993, 7971, 30097, 30626, 7994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19981, 7971, 30097, 30626, 7994, 7972, 30098, 30627, 7995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19982, 7972, 30098, 30627, 7995, 7973, 30099, 30628, 7996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19983, 7973, 30099, 30628, 7996, 7974, 30100, 30629, 7997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19984, 7974, 30100, 30629, 7997, 7975, 30101, 30630, 7998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19985, 7975, 30101, 30630, 7998, 7976, 30102, 30631, 7999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19986, 7976, 30102, 30631, 7999, 7977, 30103, 30632, 8000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19987, 7977, 30103, 30632, 8000, 7978, 30104, 30633, 8001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19988, 7978, 30104, 30633, 8001, 7979, 30105, 30634, 8002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19989, 7979, 30105, 30634, 8002, 986, 8463, 8486, 987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19990, 6646, 6647, 6670, 6669, 30083, 30106, 30635, 30612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19991, 30083, 30106, 30635, 30612, 30084, 30107, 30636, 30613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19992, 30084, 30107, 30636, 30613, 30085, 30108, 30637, 30614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19993, 30085, 30108, 30637, 30614, 30086, 30109, 30638, 30615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19994, 30086, 30109, 30638, 30615, 30087, 30110, 30639, 30616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19995, 30087, 30110, 30639, 30616, 30088, 30111, 30640, 30617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19996, 30088, 30111, 30640, 30617, 30089, 30112, 30641, 30618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19997, 30089, 30112, 30641, 30618, 30090, 30113, 30642, 30619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19998, 30090, 30113, 30642, 30619, 30091, 30114, 30643, 30620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19999, 30091, 30114, 30643, 30620, 30092, 30115, 30644, 30621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20000, 30092, 30115, 30644, 30621, 30093, 30116, 30645, 30622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20001, 30093, 30116, 30645, 30622, 30094, 30117, 30646, 30623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20002, 30094, 30117, 30646, 30623, 30095, 30118, 30647, 30624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20003, 30095, 30118, 30647, 30624, 30096, 30119, 30648, 30625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20004, 30096, 30119, 30648, 30625, 30097, 30120, 30649, 30626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20005, 30097, 30120, 30649, 30626, 30098, 30121, 30650, 30627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20006, 30098, 30121, 30650, 30627, 30099, 30122, 30651, 30628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20007, 30099, 30122, 30651, 30628, 30100, 30123, 30652, 30629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20008, 30100, 30123, 30652, 30629, 30101, 30124, 30653, 30630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20009, 30101, 30124, 30653, 30630, 30102, 30125, 30654, 30631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20010, 30102, 30125, 30654, 30631, 30103, 30126, 30655, 30632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20011, 30103, 30126, 30655, 30632, 30104, 30127, 30656, 30633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20012, 30104, 30127, 30656, 30633, 30105, 30128, 30657, 30634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20013, 30105, 30128, 30657, 30634, 8463, 8464, 8487, 8486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20014, 6647, 6648, 6671, 6670, 30106, 30129, 30658, 30635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20015, 30106, 30129, 30658, 30635, 30107, 30130, 30659, 30636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20016, 30107, 30130, 30659, 30636, 30108, 30131, 30660, 30637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20017, 30108, 30131, 30660, 30637, 30109, 30132, 30661, 30638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20018, 30109, 30132, 30661, 30638, 30110, 30133, 30662, 30639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20019, 30110, 30133, 30662, 30639, 30111, 30134, 30663, 30640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20020, 30111, 30134, 30663, 30640, 30112, 30135, 30664, 30641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20021, 30112, 30135, 30664, 30641, 30113, 30136, 30665, 30642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20022, 30113, 30136, 30665, 30642, 30114, 30137, 30666, 30643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20023, 30114, 30137, 30666, 30643, 30115, 30138, 30667, 30644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20024, 30115, 30138, 30667, 30644, 30116, 30139, 30668, 30645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20025, 30116, 30139, 30668, 30645, 30117, 30140, 30669, 30646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20026, 30117, 30140, 30669, 30646, 30118, 30141, 30670, 30647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20027, 30118, 30141, 30670, 30647, 30119, 30142, 30671, 30648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20028, 30119, 30142, 30671, 30648, 30120, 30143, 30672, 30649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20029, 30120, 30143, 30672, 30649, 30121, 30144, 30673, 30650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20030, 30121, 30144, 30673, 30650, 30122, 30145, 30674, 30651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20031, 30122, 30145, 30674, 30651, 30123, 30146, 30675, 30652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20032, 30123, 30146, 30675, 30652, 30124, 30147, 30676, 30653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20033, 30124, 30147, 30676, 30653, 30125, 30148, 30677, 30654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20034, 30125, 30148, 30677, 30654, 30126, 30149, 30678, 30655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20035, 30126, 30149, 30678, 30655, 30127, 30150, 30679, 30656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20036, 30127, 30150, 30679, 30656, 30128, 30151, 30680, 30657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20037, 30128, 30151, 30680, 30657, 8464, 8465, 8488, 8487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20038, 6648, 6649, 6672, 6671, 30129, 30152, 30681, 30658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20039, 30129, 30152, 30681, 30658, 30130, 30153, 30682, 30659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20040, 30130, 30153, 30682, 30659, 30131, 30154, 30683, 30660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20041, 30131, 30154, 30683, 30660, 30132, 30155, 30684, 30661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20042, 30132, 30155, 30684, 30661, 30133, 30156, 30685, 30662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20043, 30133, 30156, 30685, 30662, 30134, 30157, 30686, 30663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20044, 30134, 30157, 30686, 30663, 30135, 30158, 30687, 30664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20045, 30135, 30158, 30687, 30664, 30136, 30159, 30688, 30665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20046, 30136, 30159, 30688, 30665, 30137, 30160, 30689, 30666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20047, 30137, 30160, 30689, 30666, 30138, 30161, 30690, 30667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20048, 30138, 30161, 30690, 30667, 30139, 30162, 30691, 30668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20049, 30139, 30162, 30691, 30668, 30140, 30163, 30692, 30669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20050, 30140, 30163, 30692, 30669, 30141, 30164, 30693, 30670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20051, 30141, 30164, 30693, 30670, 30142, 30165, 30694, 30671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20052, 30142, 30165, 30694, 30671, 30143, 30166, 30695, 30672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20053, 30143, 30166, 30695, 30672, 30144, 30167, 30696, 30673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20054, 30144, 30167, 30696, 30673, 30145, 30168, 30697, 30674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20055, 30145, 30168, 30697, 30674, 30146, 30169, 30698, 30675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20056, 30146, 30169, 30698, 30675, 30147, 30170, 30699, 30676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20057, 30147, 30170, 30699, 30676, 30148, 30171, 30700, 30677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20058, 30148, 30171, 30700, 30677, 30149, 30172, 30701, 30678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20059, 30149, 30172, 30701, 30678, 30150, 30173, 30702, 30679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20060, 30150, 30173, 30702, 30679, 30151, 30174, 30703, 30680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20061, 30151, 30174, 30703, 30680, 8465, 8466, 8489, 8488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20062, 6649, 6650, 6673, 6672, 30152, 30175, 30704, 30681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20063, 30152, 30175, 30704, 30681, 30153, 30176, 30705, 30682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20064, 30153, 30176, 30705, 30682, 30154, 30177, 30706, 30683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20065, 30154, 30177, 30706, 30683, 30155, 30178, 30707, 30684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20066, 30155, 30178, 30707, 30684, 30156, 30179, 30708, 30685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20067, 30156, 30179, 30708, 30685, 30157, 30180, 30709, 30686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20068, 30157, 30180, 30709, 30686, 30158, 30181, 30710, 30687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20069, 30158, 30181, 30710, 30687, 30159, 30182, 30711, 30688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20070, 30159, 30182, 30711, 30688, 30160, 30183, 30712, 30689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20071, 30160, 30183, 30712, 30689, 30161, 30184, 30713, 30690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20072, 30161, 30184, 30713, 30690, 30162, 30185, 30714, 30691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20073, 30162, 30185, 30714, 30691, 30163, 30186, 30715, 30692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20074, 30163, 30186, 30715, 30692, 30164, 30187, 30716, 30693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20075, 30164, 30187, 30716, 30693, 30165, 30188, 30717, 30694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20076, 30165, 30188, 30717, 30694, 30166, 30189, 30718, 30695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20077, 30166, 30189, 30718, 30695, 30167, 30190, 30719, 30696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20078, 30167, 30190, 30719, 30696, 30168, 30191, 30720, 30697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20079, 30168, 30191, 30720, 30697, 30169, 30192, 30721, 30698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20080, 30169, 30192, 30721, 30698, 30170, 30193, 30722, 30699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20081, 30170, 30193, 30722, 30699, 30171, 30194, 30723, 30700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20082, 30171, 30194, 30723, 30700, 30172, 30195, 30724, 30701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20083, 30172, 30195, 30724, 30701, 30173, 30196, 30725, 30702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20084, 30173, 30196, 30725, 30702, 30174, 30197, 30726, 30703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20085, 30174, 30197, 30726, 30703, 8466, 8467, 8490, 8489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20086, 6650, 6651, 6674, 6673, 30175, 30198, 30727, 30704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20087, 30175, 30198, 30727, 30704, 30176, 30199, 30728, 30705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20088, 30176, 30199, 30728, 30705, 30177, 30200, 30729, 30706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20089, 30177, 30200, 30729, 30706, 30178, 30201, 30730, 30707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20090, 30178, 30201, 30730, 30707, 30179, 30202, 30731, 30708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20091, 30179, 30202, 30731, 30708, 30180, 30203, 30732, 30709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20092, 30180, 30203, 30732, 30709, 30181, 30204, 30733, 30710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20093, 30181, 30204, 30733, 30710, 30182, 30205, 30734, 30711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20094, 30182, 30205, 30734, 30711, 30183, 30206, 30735, 30712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20095, 30183, 30206, 30735, 30712, 30184, 30207, 30736, 30713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20096, 30184, 30207, 30736, 30713, 30185, 30208, 30737, 30714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20097, 30185, 30208, 30737, 30714, 30186, 30209, 30738, 30715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20098, 30186, 30209, 30738, 30715, 30187, 30210, 30739, 30716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20099, 30187, 30210, 30739, 30716, 30188, 30211, 30740, 30717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20100, 30188, 30211, 30740, 30717, 30189, 30212, 30741, 30718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20101, 30189, 30212, 30741, 30718, 30190, 30213, 30742, 30719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20102, 30190, 30213, 30742, 30719, 30191, 30214, 30743, 30720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20103, 30191, 30214, 30743, 30720, 30192, 30215, 30744, 30721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20104, 30192, 30215, 30744, 30721, 30193, 30216, 30745, 30722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20105, 30193, 30216, 30745, 30722, 30194, 30217, 30746, 30723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20106, 30194, 30217, 30746, 30723, 30195, 30218, 30747, 30724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20107, 30195, 30218, 30747, 30724, 30196, 30219, 30748, 30725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20108, 30196, 30219, 30748, 30725, 30197, 30220, 30749, 30726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20109, 30197, 30220, 30749, 30726, 8467, 8468, 8491, 8490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20110, 6651, 6652, 6675, 6674, 30198, 30221, 30750, 30727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20111, 30198, 30221, 30750, 30727, 30199, 30222, 30751, 30728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20112, 30199, 30222, 30751, 30728, 30200, 30223, 30752, 30729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20113, 30200, 30223, 30752, 30729, 30201, 30224, 30753, 30730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20114, 30201, 30224, 30753, 30730, 30202, 30225, 30754, 30731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20115, 30202, 30225, 30754, 30731, 30203, 30226, 30755, 30732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20116, 30203, 30226, 30755, 30732, 30204, 30227, 30756, 30733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20117, 30204, 30227, 30756, 30733, 30205, 30228, 30757, 30734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20118, 30205, 30228, 30757, 30734, 30206, 30229, 30758, 30735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20119, 30206, 30229, 30758, 30735, 30207, 30230, 30759, 30736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20120, 30207, 30230, 30759, 30736, 30208, 30231, 30760, 30737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20121, 30208, 30231, 30760, 30737, 30209, 30232, 30761, 30738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20122, 30209, 30232, 30761, 30738, 30210, 30233, 30762, 30739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20123, 30210, 30233, 30762, 30739, 30211, 30234, 30763, 30740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20124, 30211, 30234, 30763, 30740, 30212, 30235, 30764, 30741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20125, 30212, 30235, 30764, 30741, 30213, 30236, 30765, 30742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20126, 30213, 30236, 30765, 30742, 30214, 30237, 30766, 30743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20127, 30214, 30237, 30766, 30743, 30215, 30238, 30767, 30744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20128, 30215, 30238, 30767, 30744, 30216, 30239, 30768, 30745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20129, 30216, 30239, 30768, 30745, 30217, 30240, 30769, 30746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20130, 30217, 30240, 30769, 30746, 30218, 30241, 30770, 30747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20131, 30218, 30241, 30770, 30747, 30219, 30242, 30771, 30748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20132, 30219, 30242, 30771, 30748, 30220, 30243, 30772, 30749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20133, 30220, 30243, 30772, 30749, 8468, 8469, 8492, 8491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20134, 6652, 6653, 6676, 6675, 30221, 30244, 30773, 30750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20135, 30221, 30244, 30773, 30750, 30222, 30245, 30774, 30751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20136, 30222, 30245, 30774, 30751, 30223, 30246, 30775, 30752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20137, 30223, 30246, 30775, 30752, 30224, 30247, 30776, 30753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20138, 30224, 30247, 30776, 30753, 30225, 30248, 30777, 30754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20139, 30225, 30248, 30777, 30754, 30226, 30249, 30778, 30755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20140, 30226, 30249, 30778, 30755, 30227, 30250, 30779, 30756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20141, 30227, 30250, 30779, 30756, 30228, 30251, 30780, 30757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20142, 30228, 30251, 30780, 30757, 30229, 30252, 30781, 30758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20143, 30229, 30252, 30781, 30758, 30230, 30253, 30782, 30759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20144, 30230, 30253, 30782, 30759, 30231, 30254, 30783, 30760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20145, 30231, 30254, 30783, 30760, 30232, 30255, 30784, 30761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20146, 30232, 30255, 30784, 30761, 30233, 30256, 30785, 30762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20147, 30233, 30256, 30785, 30762, 30234, 30257, 30786, 30763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20148, 30234, 30257, 30786, 30763, 30235, 30258, 30787, 30764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20149, 30235, 30258, 30787, 30764, 30236, 30259, 30788, 30765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20150, 30236, 30259, 30788, 30765, 30237, 30260, 30789, 30766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20151, 30237, 30260, 30789, 30766, 30238, 30261, 30790, 30767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20152, 30238, 30261, 30790, 30767, 30239, 30262, 30791, 30768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20153, 30239, 30262, 30791, 30768, 30240, 30263, 30792, 30769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20154, 30240, 30263, 30792, 30769, 30241, 30264, 30793, 30770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20155, 30241, 30264, 30793, 30770, 30242, 30265, 30794, 30771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20156, 30242, 30265, 30794, 30771, 30243, 30266, 30795, 30772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20157, 30243, 30266, 30795, 30772, 8469, 8470, 8493, 8492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20158, 6653, 6654, 6677, 6676, 30244, 30267, 30796, 30773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20159, 30244, 30267, 30796, 30773, 30245, 30268, 30797, 30774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20160, 30245, 30268, 30797, 30774, 30246, 30269, 30798, 30775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20161, 30246, 30269, 30798, 30775, 30247, 30270, 30799, 30776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20162, 30247, 30270, 30799, 30776, 30248, 30271, 30800, 30777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20163, 30248, 30271, 30800, 30777, 30249, 30272, 30801, 30778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20164, 30249, 30272, 30801, 30778, 30250, 30273, 30802, 30779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20165, 30250, 30273, 30802, 30779, 30251, 30274, 30803, 30780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20166, 30251, 30274, 30803, 30780, 30252, 30275, 30804, 30781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20167, 30252, 30275, 30804, 30781, 30253, 30276, 30805, 30782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20168, 30253, 30276, 30805, 30782, 30254, 30277, 30806, 30783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20169, 30254, 30277, 30806, 30783, 30255, 30278, 30807, 30784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20170, 30255, 30278, 30807, 30784, 30256, 30279, 30808, 30785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20171, 30256, 30279, 30808, 30785, 30257, 30280, 30809, 30786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20172, 30257, 30280, 30809, 30786, 30258, 30281, 30810, 30787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20173, 30258, 30281, 30810, 30787, 30259, 30282, 30811, 30788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20174, 30259, 30282, 30811, 30788, 30260, 30283, 30812, 30789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20175, 30260, 30283, 30812, 30789, 30261, 30284, 30813, 30790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20176, 30261, 30284, 30813, 30790, 30262, 30285, 30814, 30791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20177, 30262, 30285, 30814, 30791, 30263, 30286, 30815, 30792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20178, 30263, 30286, 30815, 30792, 30264, 30287, 30816, 30793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20179, 30264, 30287, 30816, 30793, 30265, 30288, 30817, 30794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20180, 30265, 30288, 30817, 30794, 30266, 30289, 30818, 30795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20181, 30266, 30289, 30818, 30795, 8470, 8471, 8494, 8493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20182, 6654, 6655, 6678, 6677, 30267, 30290, 30819, 30796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20183, 30267, 30290, 30819, 30796, 30268, 30291, 30820, 30797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20184, 30268, 30291, 30820, 30797, 30269, 30292, 30821, 30798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20185, 30269, 30292, 30821, 30798, 30270, 30293, 30822, 30799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20186, 30270, 30293, 30822, 30799, 30271, 30294, 30823, 30800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20187, 30271, 30294, 30823, 30800, 30272, 30295, 30824, 30801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20188, 30272, 30295, 30824, 30801, 30273, 30296, 30825, 30802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20189, 30273, 30296, 30825, 30802, 30274, 30297, 30826, 30803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20190, 30274, 30297, 30826, 30803, 30275, 30298, 30827, 30804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20191, 30275, 30298, 30827, 30804, 30276, 30299, 30828, 30805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20192, 30276, 30299, 30828, 30805, 30277, 30300, 30829, 30806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20193, 30277, 30300, 30829, 30806, 30278, 30301, 30830, 30807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20194, 30278, 30301, 30830, 30807, 30279, 30302, 30831, 30808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20195, 30279, 30302, 30831, 30808, 30280, 30303, 30832, 30809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20196, 30280, 30303, 30832, 30809, 30281, 30304, 30833, 30810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20197, 30281, 30304, 30833, 30810, 30282, 30305, 30834, 30811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20198, 30282, 30305, 30834, 30811, 30283, 30306, 30835, 30812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20199, 30283, 30306, 30835, 30812, 30284, 30307, 30836, 30813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20200, 30284, 30307, 30836, 30813, 30285, 30308, 30837, 30814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20201, 30285, 30308, 30837, 30814, 30286, 30309, 30838, 30815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20202, 30286, 30309, 30838, 30815, 30287, 30310, 30839, 30816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20203, 30287, 30310, 30839, 30816, 30288, 30311, 30840, 30817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20204, 30288, 30311, 30840, 30817, 30289, 30312, 30841, 30818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20205, 30289, 30312, 30841, 30818, 8471, 8472, 8495, 8494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20206, 6655, 6656, 6679, 6678, 30290, 30313, 30842, 30819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20207, 30290, 30313, 30842, 30819, 30291, 30314, 30843, 30820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20208, 30291, 30314, 30843, 30820, 30292, 30315, 30844, 30821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20209, 30292, 30315, 30844, 30821, 30293, 30316, 30845, 30822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20210, 30293, 30316, 30845, 30822, 30294, 30317, 30846, 30823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20211, 30294, 30317, 30846, 30823, 30295, 30318, 30847, 30824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20212, 30295, 30318, 30847, 30824, 30296, 30319, 30848, 30825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20213, 30296, 30319, 30848, 30825, 30297, 30320, 30849, 30826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20214, 30297, 30320, 30849, 30826, 30298, 30321, 30850, 30827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20215, 30298, 30321, 30850, 30827, 30299, 30322, 30851, 30828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20216, 30299, 30322, 30851, 30828, 30300, 30323, 30852, 30829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20217, 30300, 30323, 30852, 30829, 30301, 30324, 30853, 30830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20218, 30301, 30324, 30853, 30830, 30302, 30325, 30854, 30831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20219, 30302, 30325, 30854, 30831, 30303, 30326, 30855, 30832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20220, 30303, 30326, 30855, 30832, 30304, 30327, 30856, 30833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20221, 30304, 30327, 30856, 30833, 30305, 30328, 30857, 30834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20222, 30305, 30328, 30857, 30834, 30306, 30329, 30858, 30835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20223, 30306, 30329, 30858, 30835, 30307, 30330, 30859, 30836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20224, 30307, 30330, 30859, 30836, 30308, 30331, 30860, 30837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20225, 30308, 30331, 30860, 30837, 30309, 30332, 30861, 30838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20226, 30309, 30332, 30861, 30838, 30310, 30333, 30862, 30839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20227, 30310, 30333, 30862, 30839, 30311, 30334, 30863, 30840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20228, 30311, 30334, 30863, 30840, 30312, 30335, 30864, 30841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20229, 30312, 30335, 30864, 30841, 8472, 8473, 8496, 8495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20230, 6656, 6657, 6680, 6679, 30313, 30336, 30865, 30842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20231, 30313, 30336, 30865, 30842, 30314, 30337, 30866, 30843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20232, 30314, 30337, 30866, 30843, 30315, 30338, 30867, 30844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20233, 30315, 30338, 30867, 30844, 30316, 30339, 30868, 30845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20234, 30316, 30339, 30868, 30845, 30317, 30340, 30869, 30846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20235, 30317, 30340, 30869, 30846, 30318, 30341, 30870, 30847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20236, 30318, 30341, 30870, 30847, 30319, 30342, 30871, 30848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20237, 30319, 30342, 30871, 30848, 30320, 30343, 30872, 30849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20238, 30320, 30343, 30872, 30849, 30321, 30344, 30873, 30850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20239, 30321, 30344, 30873, 30850, 30322, 30345, 30874, 30851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20240, 30322, 30345, 30874, 30851, 30323, 30346, 30875, 30852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20241, 30323, 30346, 30875, 30852, 30324, 30347, 30876, 30853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20242, 30324, 30347, 30876, 30853, 30325, 30348, 30877, 30854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20243, 30325, 30348, 30877, 30854, 30326, 30349, 30878, 30855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20244, 30326, 30349, 30878, 30855, 30327, 30350, 30879, 30856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20245, 30327, 30350, 30879, 30856, 30328, 30351, 30880, 30857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20246, 30328, 30351, 30880, 30857, 30329, 30352, 30881, 30858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20247, 30329, 30352, 30881, 30858, 30330, 30353, 30882, 30859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20248, 30330, 30353, 30882, 30859, 30331, 30354, 30883, 30860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20249, 30331, 30354, 30883, 30860, 30332, 30355, 30884, 30861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20250, 30332, 30355, 30884, 30861, 30333, 30356, 30885, 30862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20251, 30333, 30356, 30885, 30862, 30334, 30357, 30886, 30863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20252, 30334, 30357, 30886, 30863, 30335, 30358, 30887, 30864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20253, 30335, 30358, 30887, 30864, 8473, 8474, 8497, 8496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20254, 6657, 6658, 6681, 6680, 30336, 30359, 30888, 30865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20255, 30336, 30359, 30888, 30865, 30337, 30360, 30889, 30866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20256, 30337, 30360, 30889, 30866, 30338, 30361, 30890, 30867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20257, 30338, 30361, 30890, 30867, 30339, 30362, 30891, 30868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20258, 30339, 30362, 30891, 30868, 30340, 30363, 30892, 30869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20259, 30340, 30363, 30892, 30869, 30341, 30364, 30893, 30870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20260, 30341, 30364, 30893, 30870, 30342, 30365, 30894, 30871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20261, 30342, 30365, 30894, 30871, 30343, 30366, 30895, 30872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20262, 30343, 30366, 30895, 30872, 30344, 30367, 30896, 30873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20263, 30344, 30367, 30896, 30873, 30345, 30368, 30897, 30874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20264, 30345, 30368, 30897, 30874, 30346, 30369, 30898, 30875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20265, 30346, 30369, 30898, 30875, 30347, 30370, 30899, 30876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20266, 30347, 30370, 30899, 30876, 30348, 30371, 30900, 30877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20267, 30348, 30371, 30900, 30877, 30349, 30372, 30901, 30878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20268, 30349, 30372, 30901, 30878, 30350, 30373, 30902, 30879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20269, 30350, 30373, 30902, 30879, 30351, 30374, 30903, 30880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20270, 30351, 30374, 30903, 30880, 30352, 30375, 30904, 30881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20271, 30352, 30375, 30904, 30881, 30353, 30376, 30905, 30882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20272, 30353, 30376, 30905, 30882, 30354, 30377, 30906, 30883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20273, 30354, 30377, 30906, 30883, 30355, 30378, 30907, 30884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20274, 30355, 30378, 30907, 30884, 30356, 30379, 30908, 30885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20275, 30356, 30379, 30908, 30885, 30357, 30380, 30909, 30886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20276, 30357, 30380, 30909, 30886, 30358, 30381, 30910, 30887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20277, 30358, 30381, 30910, 30887, 8474, 8475, 8498, 8497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20278, 6658, 6659, 6682, 6681, 30359, 30382, 30911, 30888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20279, 30359, 30382, 30911, 30888, 30360, 30383, 30912, 30889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20280, 30360, 30383, 30912, 30889, 30361, 30384, 30913, 30890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20281, 30361, 30384, 30913, 30890, 30362, 30385, 30914, 30891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20282, 30362, 30385, 30914, 30891, 30363, 30386, 30915, 30892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20283, 30363, 30386, 30915, 30892, 30364, 30387, 30916, 30893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20284, 30364, 30387, 30916, 30893, 30365, 30388, 30917, 30894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20285, 30365, 30388, 30917, 30894, 30366, 30389, 30918, 30895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20286, 30366, 30389, 30918, 30895, 30367, 30390, 30919, 30896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20287, 30367, 30390, 30919, 30896, 30368, 30391, 30920, 30897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20288, 30368, 30391, 30920, 30897, 30369, 30392, 30921, 30898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20289, 30369, 30392, 30921, 30898, 30370, 30393, 30922, 30899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20290, 30370, 30393, 30922, 30899, 30371, 30394, 30923, 30900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20291, 30371, 30394, 30923, 30900, 30372, 30395, 30924, 30901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20292, 30372, 30395, 30924, 30901, 30373, 30396, 30925, 30902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20293, 30373, 30396, 30925, 30902, 30374, 30397, 30926, 30903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20294, 30374, 30397, 30926, 30903, 30375, 30398, 30927, 30904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20295, 30375, 30398, 30927, 30904, 30376, 30399, 30928, 30905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20296, 30376, 30399, 30928, 30905, 30377, 30400, 30929, 30906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20297, 30377, 30400, 30929, 30906, 30378, 30401, 30930, 30907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20298, 30378, 30401, 30930, 30907, 30379, 30402, 30931, 30908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20299, 30379, 30402, 30931, 30908, 30380, 30403, 30932, 30909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20300, 30380, 30403, 30932, 30909, 30381, 30404, 30933, 30910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20301, 30381, 30404, 30933, 30910, 8475, 8476, 8499, 8498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20302, 6659, 6660, 6683, 6682, 30382, 30405, 30934, 30911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20303, 30382, 30405, 30934, 30911, 30383, 30406, 30935, 30912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20304, 30383, 30406, 30935, 30912, 30384, 30407, 30936, 30913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20305, 30384, 30407, 30936, 30913, 30385, 30408, 30937, 30914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20306, 30385, 30408, 30937, 30914, 30386, 30409, 30938, 30915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20307, 30386, 30409, 30938, 30915, 30387, 30410, 30939, 30916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20308, 30387, 30410, 30939, 30916, 30388, 30411, 30940, 30917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20309, 30388, 30411, 30940, 30917, 30389, 30412, 30941, 30918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20310, 30389, 30412, 30941, 30918, 30390, 30413, 30942, 30919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20311, 30390, 30413, 30942, 30919, 30391, 30414, 30943, 30920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20312, 30391, 30414, 30943, 30920, 30392, 30415, 30944, 30921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20313, 30392, 30415, 30944, 30921, 30393, 30416, 30945, 30922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20314, 30393, 30416, 30945, 30922, 30394, 30417, 30946, 30923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20315, 30394, 30417, 30946, 30923, 30395, 30418, 30947, 30924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20316, 30395, 30418, 30947, 30924, 30396, 30419, 30948, 30925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20317, 30396, 30419, 30948, 30925, 30397, 30420, 30949, 30926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20318, 30397, 30420, 30949, 30926, 30398, 30421, 30950, 30927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20319, 30398, 30421, 30950, 30927, 30399, 30422, 30951, 30928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20320, 30399, 30422, 30951, 30928, 30400, 30423, 30952, 30929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20321, 30400, 30423, 30952, 30929, 30401, 30424, 30953, 30930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20322, 30401, 30424, 30953, 30930, 30402, 30425, 30954, 30931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20323, 30402, 30425, 30954, 30931, 30403, 30426, 30955, 30932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20324, 30403, 30426, 30955, 30932, 30404, 30427, 30956, 30933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20325, 30404, 30427, 30956, 30933, 8476, 8477, 8500, 8499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20326, 6660, 6661, 6684, 6683, 30405, 30428, 30957, 30934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20327, 30405, 30428, 30957, 30934, 30406, 30429, 30958, 30935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20328, 30406, 30429, 30958, 30935, 30407, 30430, 30959, 30936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20329, 30407, 30430, 30959, 30936, 30408, 30431, 30960, 30937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20330, 30408, 30431, 30960, 30937, 30409, 30432, 30961, 30938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20331, 30409, 30432, 30961, 30938, 30410, 30433, 30962, 30939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20332, 30410, 30433, 30962, 30939, 30411, 30434, 30963, 30940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20333, 30411, 30434, 30963, 30940, 30412, 30435, 30964, 30941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20334, 30412, 30435, 30964, 30941, 30413, 30436, 30965, 30942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20335, 30413, 30436, 30965, 30942, 30414, 30437, 30966, 30943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20336, 30414, 30437, 30966, 30943, 30415, 30438, 30967, 30944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20337, 30415, 30438, 30967, 30944, 30416, 30439, 30968, 30945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20338, 30416, 30439, 30968, 30945, 30417, 30440, 30969, 30946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20339, 30417, 30440, 30969, 30946, 30418, 30441, 30970, 30947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20340, 30418, 30441, 30970, 30947, 30419, 30442, 30971, 30948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20341, 30419, 30442, 30971, 30948, 30420, 30443, 30972, 30949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20342, 30420, 30443, 30972, 30949, 30421, 30444, 30973, 30950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20343, 30421, 30444, 30973, 30950, 30422, 30445, 30974, 30951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20344, 30422, 30445, 30974, 30951, 30423, 30446, 30975, 30952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20345, 30423, 30446, 30975, 30952, 30424, 30447, 30976, 30953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20346, 30424, 30447, 30976, 30953, 30425, 30448, 30977, 30954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20347, 30425, 30448, 30977, 30954, 30426, 30449, 30978, 30955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20348, 30426, 30449, 30978, 30955, 30427, 30450, 30979, 30956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20349, 30427, 30450, 30979, 30956, 8477, 8478, 8501, 8500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20350, 6661, 6662, 6685, 6684, 30428, 30451, 30980, 30957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20351, 30428, 30451, 30980, 30957, 30429, 30452, 30981, 30958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20352, 30429, 30452, 30981, 30958, 30430, 30453, 30982, 30959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20353, 30430, 30453, 30982, 30959, 30431, 30454, 30983, 30960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20354, 30431, 30454, 30983, 30960, 30432, 30455, 30984, 30961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20355, 30432, 30455, 30984, 30961, 30433, 30456, 30985, 30962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20356, 30433, 30456, 30985, 30962, 30434, 30457, 30986, 30963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20357, 30434, 30457, 30986, 30963, 30435, 30458, 30987, 30964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20358, 30435, 30458, 30987, 30964, 30436, 30459, 30988, 30965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20359, 30436, 30459, 30988, 30965, 30437, 30460, 30989, 30966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20360, 30437, 30460, 30989, 30966, 30438, 30461, 30990, 30967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20361, 30438, 30461, 30990, 30967, 30439, 30462, 30991, 30968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20362, 30439, 30462, 30991, 30968, 30440, 30463, 30992, 30969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20363, 30440, 30463, 30992, 30969, 30441, 30464, 30993, 30970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20364, 30441, 30464, 30993, 30970, 30442, 30465, 30994, 30971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20365, 30442, 30465, 30994, 30971, 30443, 30466, 30995, 30972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20366, 30443, 30466, 30995, 30972, 30444, 30467, 30996, 30973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20367, 30444, 30467, 30996, 30973, 30445, 30468, 30997, 30974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20368, 30445, 30468, 30997, 30974, 30446, 30469, 30998, 30975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20369, 30446, 30469, 30998, 30975, 30447, 30470, 30999, 30976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20370, 30447, 30470, 30999, 30976, 30448, 30471, 31000, 30977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20371, 30448, 30471, 31000, 30977, 30449, 30472, 31001, 30978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20372, 30449, 30472, 31001, 30978, 30450, 30473, 31002, 30979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20373, 30450, 30473, 31002, 30979, 8478, 8479, 8502, 8501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20374, 6662, 6663, 6686, 6685, 30451, 30474, 31003, 30980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20375, 30451, 30474, 31003, 30980, 30452, 30475, 31004, 30981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20376, 30452, 30475, 31004, 30981, 30453, 30476, 31005, 30982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20377, 30453, 30476, 31005, 30982, 30454, 30477, 31006, 30983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20378, 30454, 30477, 31006, 30983, 30455, 30478, 31007, 30984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20379, 30455, 30478, 31007, 30984, 30456, 30479, 31008, 30985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20380, 30456, 30479, 31008, 30985, 30457, 30480, 31009, 30986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20381, 30457, 30480, 31009, 30986, 30458, 30481, 31010, 30987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20382, 30458, 30481, 31010, 30987, 30459, 30482, 31011, 30988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20383, 30459, 30482, 31011, 30988, 30460, 30483, 31012, 30989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20384, 30460, 30483, 31012, 30989, 30461, 30484, 31013, 30990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20385, 30461, 30484, 31013, 30990, 30462, 30485, 31014, 30991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20386, 30462, 30485, 31014, 30991, 30463, 30486, 31015, 30992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20387, 30463, 30486, 31015, 30992, 30464, 30487, 31016, 30993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20388, 30464, 30487, 31016, 30993, 30465, 30488, 31017, 30994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20389, 30465, 30488, 31017, 30994, 30466, 30489, 31018, 30995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20390, 30466, 30489, 31018, 30995, 30467, 30490, 31019, 30996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20391, 30467, 30490, 31019, 30996, 30468, 30491, 31020, 30997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20392, 30468, 30491, 31020, 30997, 30469, 30492, 31021, 30998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20393, 30469, 30492, 31021, 30998, 30470, 30493, 31022, 30999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20394, 30470, 30493, 31022, 30999, 30471, 30494, 31023, 31000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20395, 30471, 30494, 31023, 31000, 30472, 30495, 31024, 31001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20396, 30472, 30495, 31024, 31001, 30473, 30496, 31025, 31002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20397, 30473, 30496, 31025, 31002, 8479, 8480, 8503, 8502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20398, 6663, 6664, 6687, 6686, 30474, 30497, 31026, 31003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20399, 30474, 30497, 31026, 31003, 30475, 30498, 31027, 31004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20400, 30475, 30498, 31027, 31004, 30476, 30499, 31028, 31005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20401, 30476, 30499, 31028, 31005, 30477, 30500, 31029, 31006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20402, 30477, 30500, 31029, 31006, 30478, 30501, 31030, 31007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20403, 30478, 30501, 31030, 31007, 30479, 30502, 31031, 31008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20404, 30479, 30502, 31031, 31008, 30480, 30503, 31032, 31009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20405, 30480, 30503, 31032, 31009, 30481, 30504, 31033, 31010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20406, 30481, 30504, 31033, 31010, 30482, 30505, 31034, 31011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20407, 30482, 30505, 31034, 31011, 30483, 30506, 31035, 31012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20408, 30483, 30506, 31035, 31012, 30484, 30507, 31036, 31013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20409, 30484, 30507, 31036, 31013, 30485, 30508, 31037, 31014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20410, 30485, 30508, 31037, 31014, 30486, 30509, 31038, 31015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20411, 30486, 30509, 31038, 31015, 30487, 30510, 31039, 31016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20412, 30487, 30510, 31039, 31016, 30488, 30511, 31040, 31017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20413, 30488, 30511, 31040, 31017, 30489, 30512, 31041, 31018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20414, 30489, 30512, 31041, 31018, 30490, 30513, 31042, 31019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20415, 30490, 30513, 31042, 31019, 30491, 30514, 31043, 31020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20416, 30491, 30514, 31043, 31020, 30492, 30515, 31044, 31021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20417, 30492, 30515, 31044, 31021, 30493, 30516, 31045, 31022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20418, 30493, 30516, 31045, 31022, 30494, 30517, 31046, 31023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20419, 30494, 30517, 31046, 31023, 30495, 30518, 31047, 31024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20420, 30495, 30518, 31047, 31024, 30496, 30519, 31048, 31025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20421, 30496, 30519, 31048, 31025, 8480, 8481, 8504, 8503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20422, 6664, 6665, 6688, 6687, 30497, 30520, 31049, 31026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20423, 30497, 30520, 31049, 31026, 30498, 30521, 31050, 31027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20424, 30498, 30521, 31050, 31027, 30499, 30522, 31051, 31028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20425, 30499, 30522, 31051, 31028, 30500, 30523, 31052, 31029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20426, 30500, 30523, 31052, 31029, 30501, 30524, 31053, 31030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20427, 30501, 30524, 31053, 31030, 30502, 30525, 31054, 31031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20428, 30502, 30525, 31054, 31031, 30503, 30526, 31055, 31032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20429, 30503, 30526, 31055, 31032, 30504, 30527, 31056, 31033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20430, 30504, 30527, 31056, 31033, 30505, 30528, 31057, 31034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20431, 30505, 30528, 31057, 31034, 30506, 30529, 31058, 31035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20432, 30506, 30529, 31058, 31035, 30507, 30530, 31059, 31036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20433, 30507, 30530, 31059, 31036, 30508, 30531, 31060, 31037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20434, 30508, 30531, 31060, 31037, 30509, 30532, 31061, 31038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20435, 30509, 30532, 31061, 31038, 30510, 30533, 31062, 31039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20436, 30510, 30533, 31062, 31039, 30511, 30534, 31063, 31040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20437, 30511, 30534, 31063, 31040, 30512, 30535, 31064, 31041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20438, 30512, 30535, 31064, 31041, 30513, 30536, 31065, 31042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20439, 30513, 30536, 31065, 31042, 30514, 30537, 31066, 31043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20440, 30514, 30537, 31066, 31043, 30515, 30538, 31067, 31044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20441, 30515, 30538, 31067, 31044, 30516, 30539, 31068, 31045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20442, 30516, 30539, 31068, 31045, 30517, 30540, 31069, 31046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20443, 30517, 30540, 31069, 31046, 30518, 30541, 31070, 31047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20444, 30518, 30541, 31070, 31047, 30519, 30542, 31071, 31048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20445, 30519, 30542, 31071, 31048, 8481, 8482, 8505, 8504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20446, 6665, 6666, 6689, 6688, 30520, 30543, 31072, 31049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20447, 30520, 30543, 31072, 31049, 30521, 30544, 31073, 31050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20448, 30521, 30544, 31073, 31050, 30522, 30545, 31074, 31051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20449, 30522, 30545, 31074, 31051, 30523, 30546, 31075, 31052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20450, 30523, 30546, 31075, 31052, 30524, 30547, 31076, 31053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20451, 30524, 30547, 31076, 31053, 30525, 30548, 31077, 31054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20452, 30525, 30548, 31077, 31054, 30526, 30549, 31078, 31055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20453, 30526, 30549, 31078, 31055, 30527, 30550, 31079, 31056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20454, 30527, 30550, 31079, 31056, 30528, 30551, 31080, 31057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20455, 30528, 30551, 31080, 31057, 30529, 30552, 31081, 31058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20456, 30529, 30552, 31081, 31058, 30530, 30553, 31082, 31059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20457, 30530, 30553, 31082, 31059, 30531, 30554, 31083, 31060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20458, 30531, 30554, 31083, 31060, 30532, 30555, 31084, 31061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20459, 30532, 30555, 31084, 31061, 30533, 30556, 31085, 31062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20460, 30533, 30556, 31085, 31062, 30534, 30557, 31086, 31063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20461, 30534, 30557, 31086, 31063, 30535, 30558, 31087, 31064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20462, 30535, 30558, 31087, 31064, 30536, 30559, 31088, 31065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20463, 30536, 30559, 31088, 31065, 30537, 30560, 31089, 31066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20464, 30537, 30560, 31089, 31066, 30538, 30561, 31090, 31067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20465, 30538, 30561, 31090, 31067, 30539, 30562, 31091, 31068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20466, 30539, 30562, 31091, 31068, 30540, 30563, 31092, 31069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20467, 30540, 30563, 31092, 31069, 30541, 30564, 31093, 31070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20468, 30541, 30564, 31093, 31070, 30542, 30565, 31094, 31071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20469, 30542, 30565, 31094, 31071, 8482, 8483, 8506, 8505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20470, 6666, 6667, 6690, 6689, 30543, 30566, 31095, 31072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20471, 30543, 30566, 31095, 31072, 30544, 30567, 31096, 31073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20472, 30544, 30567, 31096, 31073, 30545, 30568, 31097, 31074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20473, 30545, 30568, 31097, 31074, 30546, 30569, 31098, 31075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20474, 30546, 30569, 31098, 31075, 30547, 30570, 31099, 31076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20475, 30547, 30570, 31099, 31076, 30548, 30571, 31100, 31077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20476, 30548, 30571, 31100, 31077, 30549, 30572, 31101, 31078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20477, 30549, 30572, 31101, 31078, 30550, 30573, 31102, 31079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20478, 30550, 30573, 31102, 31079, 30551, 30574, 31103, 31080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20479, 30551, 30574, 31103, 31080, 30552, 30575, 31104, 31081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20480, 30552, 30575, 31104, 31081, 30553, 30576, 31105, 31082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20481, 30553, 30576, 31105, 31082, 30554, 30577, 31106, 31083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20482, 30554, 30577, 31106, 31083, 30555, 30578, 31107, 31084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20483, 30555, 30578, 31107, 31084, 30556, 30579, 31108, 31085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20484, 30556, 30579, 31108, 31085, 30557, 30580, 31109, 31086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20485, 30557, 30580, 31109, 31086, 30558, 30581, 31110, 31087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20486, 30558, 30581, 31110, 31087, 30559, 30582, 31111, 31088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20487, 30559, 30582, 31111, 31088, 30560, 30583, 31112, 31089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20488, 30560, 30583, 31112, 31089, 30561, 30584, 31113, 31090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20489, 30561, 30584, 31113, 31090, 30562, 30585, 31114, 31091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20490, 30562, 30585, 31114, 31091, 30563, 30586, 31115, 31092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20491, 30563, 30586, 31115, 31092, 30564, 30587, 31116, 31093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20492, 30564, 30587, 31116, 31093, 30565, 30588, 31117, 31094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20493, 30565, 30588, 31117, 31094, 8483, 8484, 8507, 8506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20494, 6667, 6668, 6691, 6690, 30566, 30589, 31118, 31095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20495, 30566, 30589, 31118, 31095, 30567, 30590, 31119, 31096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20496, 30567, 30590, 31119, 31096, 30568, 30591, 31120, 31097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20497, 30568, 30591, 31120, 31097, 30569, 30592, 31121, 31098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20498, 30569, 30592, 31121, 31098, 30570, 30593, 31122, 31099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20499, 30570, 30593, 31122, 31099, 30571, 30594, 31123, 31100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20500, 30571, 30594, 31123, 31100, 30572, 30595, 31124, 31101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20501, 30572, 30595, 31124, 31101, 30573, 30596, 31125, 31102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20502, 30573, 30596, 31125, 31102, 30574, 30597, 31126, 31103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20503, 30574, 30597, 31126, 31103, 30575, 30598, 31127, 31104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20504, 30575, 30598, 31127, 31104, 30576, 30599, 31128, 31105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20505, 30576, 30599, 31128, 31105, 30577, 30600, 31129, 31106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20506, 30577, 30600, 31129, 31106, 30578, 30601, 31130, 31107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20507, 30578, 30601, 31130, 31107, 30579, 30602, 31131, 31108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20508, 30579, 30602, 31131, 31108, 30580, 30603, 31132, 31109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20509, 30580, 30603, 31132, 31109, 30581, 30604, 31133, 31110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20510, 30581, 30604, 31133, 31110, 30582, 30605, 31134, 31111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20511, 30582, 30605, 31134, 31111, 30583, 30606, 31135, 31112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20512, 30583, 30606, 31135, 31112, 30584, 30607, 31136, 31113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20513, 30584, 30607, 31136, 31113, 30585, 30608, 31137, 31114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20514, 30585, 30608, 31137, 31114, 30586, 30609, 31138, 31115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20515, 30586, 30609, 31138, 31115, 30587, 30610, 31139, 31116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20516, 30587, 30610, 31139, 31116, 30588, 30611, 31140, 31117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20517, 30588, 30611, 31140, 31117, 8484, 8485, 8508, 8507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20518, 6668, 837, 838, 6691, 30589, 8210, 8233, 31118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20519, 30589, 8210, 8233, 31118, 30590, 8211, 8234, 31119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20520, 30590, 8211, 8234, 31119, 30591, 8212, 8235, 31120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20521, 30591, 8212, 8235, 31120, 30592, 8213, 8236, 31121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20522, 30592, 8213, 8236, 31121, 30593, 8214, 8237, 31122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20523, 30593, 8214, 8237, 31122, 30594, 8215, 8238, 31123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20524, 30594, 8215, 8238, 31123, 30595, 8216, 8239, 31124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20525, 30595, 8216, 8239, 31124, 30596, 8217, 8240, 31125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20526, 30596, 8217, 8240, 31125, 30597, 8218, 8241, 31126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20527, 30597, 8218, 8241, 31126, 30598, 8219, 8242, 31127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20528, 30598, 8219, 8242, 31127, 30599, 8220, 8243, 31128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20529, 30599, 8220, 8243, 31128, 30600, 8221, 8244, 31129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20530, 30600, 8221, 8244, 31129, 30601, 8222, 8245, 31130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20531, 30601, 8222, 8245, 31130, 30602, 8223, 8246, 31131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20532, 30602, 8223, 8246, 31131, 30603, 8224, 8247, 31132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20533, 30603, 8224, 8247, 31132, 30604, 8225, 8248, 31133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20534, 30604, 8225, 8248, 31133, 30605, 8226, 8249, 31134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20535, 30605, 8226, 8249, 31134, 30606, 8227, 8250, 31135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20536, 30606, 8227, 8250, 31135, 30607, 8228, 8251, 31136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20537, 30607, 8228, 8251, 31136, 30608, 8229, 8252, 31137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20538, 30608, 8229, 8252, 31137, 30609, 8230, 8253, 31138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20539, 30609, 8230, 8253, 31138, 30610, 8231, 8254, 31139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20540, 30610, 8231, 8254, 31139, 30611, 8232, 8255, 31140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20541, 30611, 8232, 8255, 31140, 8485, 997, 998, 8508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20542, 827, 6669, 6692, 828, 7980, 30612, 31141, 8003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20543, 7980, 30612, 31141, 8003, 7981, 30613, 31142, 8004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20544, 7981, 30613, 31142, 8004, 7982, 30614, 31143, 8005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20545, 7982, 30614, 31143, 8005, 7983, 30615, 31144, 8006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20546, 7983, 30615, 31144, 8006, 7984, 30616, 31145, 8007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20547, 7984, 30616, 31145, 8007, 7985, 30617, 31146, 8008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20548, 7985, 30617, 31146, 8008, 7986, 30618, 31147, 8009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20549, 7986, 30618, 31147, 8009, 7987, 30619, 31148, 8010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20550, 7987, 30619, 31148, 8010, 7988, 30620, 31149, 8011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20551, 7988, 30620, 31149, 8011, 7989, 30621, 31150, 8012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20552, 7989, 30621, 31150, 8012, 7990, 30622, 31151, 8013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20553, 7990, 30622, 31151, 8013, 7991, 30623, 31152, 8014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20554, 7991, 30623, 31152, 8014, 7992, 30624, 31153, 8015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20555, 7992, 30624, 31153, 8015, 7993, 30625, 31154, 8016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20556, 7993, 30625, 31154, 8016, 7994, 30626, 31155, 8017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20557, 7994, 30626, 31155, 8017, 7995, 30627, 31156, 8018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20558, 7995, 30627, 31156, 8018, 7996, 30628, 31157, 8019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20559, 7996, 30628, 31157, 8019, 7997, 30629, 31158, 8020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20560, 7997, 30629, 31158, 8020, 7998, 30630, 31159, 8021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20561, 7998, 30630, 31159, 8021, 7999, 30631, 31160, 8022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20562, 7999, 30631, 31160, 8022, 8000, 30632, 31161, 8023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20563, 8000, 30632, 31161, 8023, 8001, 30633, 31162, 8024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20564, 8001, 30633, 31162, 8024, 8002, 30634, 31163, 8025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20565, 8002, 30634, 31163, 8025, 987, 8486, 8509, 988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20566, 6669, 6670, 6693, 6692, 30612, 30635, 31164, 31141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20567, 30612, 30635, 31164, 31141, 30613, 30636, 31165, 31142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20568, 30613, 30636, 31165, 31142, 30614, 30637, 31166, 31143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20569, 30614, 30637, 31166, 31143, 30615, 30638, 31167, 31144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20570, 30615, 30638, 31167, 31144, 30616, 30639, 31168, 31145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20571, 30616, 30639, 31168, 31145, 30617, 30640, 31169, 31146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20572, 30617, 30640, 31169, 31146, 30618, 30641, 31170, 31147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20573, 30618, 30641, 31170, 31147, 30619, 30642, 31171, 31148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20574, 30619, 30642, 31171, 31148, 30620, 30643, 31172, 31149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20575, 30620, 30643, 31172, 31149, 30621, 30644, 31173, 31150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20576, 30621, 30644, 31173, 31150, 30622, 30645, 31174, 31151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20577, 30622, 30645, 31174, 31151, 30623, 30646, 31175, 31152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20578, 30623, 30646, 31175, 31152, 30624, 30647, 31176, 31153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20579, 30624, 30647, 31176, 31153, 30625, 30648, 31177, 31154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20580, 30625, 30648, 31177, 31154, 30626, 30649, 31178, 31155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20581, 30626, 30649, 31178, 31155, 30627, 30650, 31179, 31156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20582, 30627, 30650, 31179, 31156, 30628, 30651, 31180, 31157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20583, 30628, 30651, 31180, 31157, 30629, 30652, 31181, 31158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20584, 30629, 30652, 31181, 31158, 30630, 30653, 31182, 31159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20585, 30630, 30653, 31182, 31159, 30631, 30654, 31183, 31160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20586, 30631, 30654, 31183, 31160, 30632, 30655, 31184, 31161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20587, 30632, 30655, 31184, 31161, 30633, 30656, 31185, 31162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20588, 30633, 30656, 31185, 31162, 30634, 30657, 31186, 31163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20589, 30634, 30657, 31186, 31163, 8486, 8487, 8510, 8509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20590, 6670, 6671, 6694, 6693, 30635, 30658, 31187, 31164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20591, 30635, 30658, 31187, 31164, 30636, 30659, 31188, 31165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20592, 30636, 30659, 31188, 31165, 30637, 30660, 31189, 31166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20593, 30637, 30660, 31189, 31166, 30638, 30661, 31190, 31167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20594, 30638, 30661, 31190, 31167, 30639, 30662, 31191, 31168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20595, 30639, 30662, 31191, 31168, 30640, 30663, 31192, 31169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20596, 30640, 30663, 31192, 31169, 30641, 30664, 31193, 31170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20597, 30641, 30664, 31193, 31170, 30642, 30665, 31194, 31171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20598, 30642, 30665, 31194, 31171, 30643, 30666, 31195, 31172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20599, 30643, 30666, 31195, 31172, 30644, 30667, 31196, 31173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20600, 30644, 30667, 31196, 31173, 30645, 30668, 31197, 31174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20601, 30645, 30668, 31197, 31174, 30646, 30669, 31198, 31175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20602, 30646, 30669, 31198, 31175, 30647, 30670, 31199, 31176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20603, 30647, 30670, 31199, 31176, 30648, 30671, 31200, 31177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20604, 30648, 30671, 31200, 31177, 30649, 30672, 31201, 31178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20605, 30649, 30672, 31201, 31178, 30650, 30673, 31202, 31179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20606, 30650, 30673, 31202, 31179, 30651, 30674, 31203, 31180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20607, 30651, 30674, 31203, 31180, 30652, 30675, 31204, 31181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20608, 30652, 30675, 31204, 31181, 30653, 30676, 31205, 31182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20609, 30653, 30676, 31205, 31182, 30654, 30677, 31206, 31183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20610, 30654, 30677, 31206, 31183, 30655, 30678, 31207, 31184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20611, 30655, 30678, 31207, 31184, 30656, 30679, 31208, 31185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20612, 30656, 30679, 31208, 31185, 30657, 30680, 31209, 31186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20613, 30657, 30680, 31209, 31186, 8487, 8488, 8511, 8510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20614, 6671, 6672, 6695, 6694, 30658, 30681, 31210, 31187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20615, 30658, 30681, 31210, 31187, 30659, 30682, 31211, 31188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20616, 30659, 30682, 31211, 31188, 30660, 30683, 31212, 31189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
20617, 30660, 30683, 31212, 31189, 30661, 30684, 31213, 31190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
