15480, 26795, 6418, 6441, 26841, 26796, 6419, 6442, 26842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15481, 26796, 6419, 6442, 26842, 26797, 6420, 6443, 26843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15482, 26797, 6420, 6443, 26843, 26798, 6421, 6444, 26844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15483, 26798, 6421, 6444, 26844, 26799, 6422, 6445, 26845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15484, 26799, 6422, 6445, 26845, 26800, 6423, 6446, 26846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15485, 26800, 6423, 6446, 26846, 26801, 6424, 6447, 26847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15486, 26801, 6424, 6447, 26847, 26802, 6425, 6448, 26848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15487, 26802, 6425, 6448, 26848, 26803, 6426, 6449, 26849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15488, 26803, 6426, 6449, 26849, 26804, 6427, 6450, 26850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15489, 26804, 6427, 6450, 26850, 26805, 6428, 6451, 26851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15490, 26805, 6428, 6451, 26851, 26806, 6429, 6452, 26852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15491, 26806, 6429, 6452, 26852, 26807, 6430, 6453, 26853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15492, 26807, 6430, 6453, 26853, 26808, 6431, 6454, 26854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15493, 26808, 6431, 6454, 26854, 26809, 6432, 6455, 26855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15494, 26809, 6432, 6455, 26855, 26810, 6433, 6456, 26856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15495, 26810, 6433, 6456, 26856, 26811, 6434, 6457, 26857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15496, 26811, 6434, 6457, 26857, 26812, 6435, 6458, 26858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15497, 26812, 6435, 6458, 26858, 26813, 6436, 6459, 26859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15498, 26813, 6436, 6459, 26859, 26814, 6437, 6460, 26860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15499, 26814, 6437, 6460, 26860, 26815, 6438, 6461, 26861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15500, 26815, 6438, 6461, 26861, 26816, 6439, 6462, 26862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15501, 26816, 6439, 6462, 26862, 6503, 771, 772, 6505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15502, 643, 5884, 5886, 644, 6187, 26817, 26863, 6210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15503, 6187, 26817, 26863, 6210, 6188, 26818, 26864, 6211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15504, 6188, 26818, 26864, 6211, 6189, 26819, 26865, 6212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15505, 6189, 26819, 26865, 6212, 6190, 26820, 26866, 6213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15506, 6190, 26820, 26866, 6213, 6191, 26821, 26867, 6214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15507, 6191, 26821, 26867, 6214, 6192, 26822, 26868, 6215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15508, 6192, 26822, 26868, 6215, 6193, 26823, 26869, 6216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15509, 6193, 26823, 26869, 6216, 6194, 26824, 26870, 6217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15510, 6194, 26824, 26870, 6217, 6195, 26825, 26871, 6218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15511, 6195, 26825, 26871, 6218, 6196, 26826, 26872, 6219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15512, 6196, 26826, 26872, 6219, 6197, 26827, 26873, 6220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15513, 6197, 26827, 26873, 6220, 6198, 26828, 26874, 6221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15514, 6198, 26828, 26874, 6221, 6199, 26829, 26875, 6222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15515, 6199, 26829, 26875, 6222, 6200, 26830, 26876, 6223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15516, 6200, 26830, 26876, 6223, 6201, 26831, 26877, 6224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15517, 6201, 26831, 26877, 6224, 6202, 26832, 26878, 6225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15518, 6202, 26832, 26878, 6225, 6203, 26833, 26879, 6226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15519, 6203, 26833, 26879, 6226, 6204, 26834, 26880, 6227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15520, 6204, 26834, 26880, 6227, 6205, 26835, 26881, 6228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15521, 6205, 26835, 26881, 6228, 6206, 26836, 26882, 6229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15522, 6206, 26836, 26882, 6229, 6207, 26837, 26883, 6230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15523, 6207, 26837, 26883, 6230, 6208, 26838, 26884, 6231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15524, 6208, 26838, 26884, 6231, 6209, 26839, 26885, 6232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15525, 6209, 26839, 26885, 6232, 761, 6504, 6506, 762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15526, 5884, 5885, 5887, 5886, 26817, 26840, 26886, 26863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15527, 26817, 26840, 26886, 26863, 26818, 26841, 26887, 26864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15528, 26818, 26841, 26887, 26864, 26819, 26842, 26888, 26865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15529, 26819, 26842, 26888, 26865, 26820, 26843, 26889, 26866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15530, 26820, 26843, 26889, 26866, 26821, 26844, 26890, 26867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15531, 26821, 26844, 26890, 26867, 26822, 26845, 26891, 26868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15532, 26822, 26845, 26891, 26868, 26823, 26846, 26892, 26869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15533, 26823, 26846, 26892, 26869, 26824, 26847, 26893, 26870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15534, 26824, 26847, 26893, 26870, 26825, 26848, 26894, 26871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15535, 26825, 26848, 26894, 26871, 26826, 26849, 26895, 26872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15536, 26826, 26849, 26895, 26872, 26827, 26850, 26896, 26873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15537, 26827, 26850, 26896, 26873, 26828, 26851, 26897, 26874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15538, 26828, 26851, 26897, 26874, 26829, 26852, 26898, 26875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15539, 26829, 26852, 26898, 26875, 26830, 26853, 26899, 26876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15540, 26830, 26853, 26899, 26876, 26831, 26854, 26900, 26877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15541, 26831, 26854, 26900, 26877, 26832, 26855, 26901, 26878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15542, 26832, 26855, 26901, 26878, 26833, 26856, 26902, 26879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15543, 26833, 26856, 26902, 26879, 26834, 26857, 26903, 26880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15544, 26834, 26857, 26903, 26880, 26835, 26858, 26904, 26881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15545, 26835, 26858, 26904, 26881, 26836, 26859, 26905, 26882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15546, 26836, 26859, 26905, 26882, 26837, 26860, 26906, 26883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15547, 26837, 26860, 26906, 26883, 26838, 26861, 26907, 26884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15548, 26838, 26861, 26907, 26884, 26839, 26862, 26908, 26885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15549, 26839, 26862, 26908, 26885, 6504, 6505, 6507, 6506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15550, 5885, 654, 655, 5887, 26840, 6440, 6463, 26886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15551, 26840, 6440, 6463, 26886, 26841, 6441, 6464, 26887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15552, 26841, 6441, 6464, 26887, 26842, 6442, 6465, 26888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15553, 26842, 6442, 6465, 26888, 26843, 6443, 6466, 26889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15554, 26843, 6443, 6466, 26889, 26844, 6444, 6467, 26890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15555, 26844, 6444, 6467, 26890, 26845, 6445, 6468, 26891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15556, 26845, 6445, 6468, 26891, 26846, 6446, 6469, 26892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15557, 26846, 6446, 6469, 26892, 26847, 6447, 6470, 26893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15558, 26847, 6447, 6470, 26893, 26848, 6448, 6471, 26894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15559, 26848, 6448, 6471, 26894, 26849, 6449, 6472, 26895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15560, 26849, 6449, 6472, 26895, 26850, 6450, 6473, 26896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15561, 26850, 6450, 6473, 26896, 26851, 6451, 6474, 26897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15562, 26851, 6451, 6474, 26897, 26852, 6452, 6475, 26898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15563, 26852, 6452, 6475, 26898, 26853, 6453, 6476, 26899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15564, 26853, 6453, 6476, 26899, 26854, 6454, 6477, 26900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15565, 26854, 6454, 6477, 26900, 26855, 6455, 6478, 26901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15566, 26855, 6455, 6478, 26901, 26856, 6456, 6479, 26902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15567, 26856, 6456, 6479, 26902, 26857, 6457, 6480, 26903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15568, 26857, 6457, 6480, 26903, 26858, 6458, 6481, 26904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15569, 26858, 6458, 6481, 26904, 26859, 6459, 6482, 26905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15570, 26859, 6459, 6482, 26905, 26860, 6460, 6483, 26906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15571, 26860, 6460, 6483, 26906, 26861, 6461, 6484, 26907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15572, 26861, 6461, 6484, 26907, 26862, 6462, 6485, 26908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15573, 26862, 6462, 6485, 26908, 6505, 772, 773, 6507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15574, 644, 5886, 622, 25, 6210, 26863, 5888, 656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15575, 6210, 26863, 5888, 656, 6211, 26864, 5889, 657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15576, 6211, 26864, 5889, 657, 6212, 26865, 5890, 658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15577, 6212, 26865, 5890, 658, 6213, 26866, 5891, 659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15578, 6213, 26866, 5891, 659, 6214, 26867, 5892, 660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15579, 6214, 26867, 5892, 660, 6215, 26868, 5893, 661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15580, 6215, 26868, 5893, 661, 6216, 26869, 5894, 662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15581, 6216, 26869, 5894, 662, 6217, 26870, 5895, 663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15582, 6217, 26870, 5895, 663, 6218, 26871, 5896, 664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15583, 6218, 26871, 5896, 664, 6219, 26872, 5897, 665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15584, 6219, 26872, 5897, 665, 6220, 26873, 5898, 666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15585, 6220, 26873, 5898, 666, 6221, 26874, 5899, 667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15586, 6221, 26874, 5899, 667, 6222, 26875, 5900, 668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15587, 6222, 26875, 5900, 668, 6223, 26876, 5901, 669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15588, 6223, 26876, 5901, 669, 6224, 26877, 5902, 670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15589, 6224, 26877, 5902, 670, 6225, 26878, 5903, 671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15590, 6225, 26878, 5903, 671, 6226, 26879, 5904, 672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15591, 6226, 26879, 5904, 672, 6227, 26880, 5905, 673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15592, 6227, 26880, 5905, 673, 6228, 26881, 5906, 674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15593, 6228, 26881, 5906, 674, 6229, 26882, 5907, 675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15594, 6229, 26882, 5907, 675, 6230, 26883, 5908, 676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15595, 6230, 26883, 5908, 676, 6231, 26884, 5909, 677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15596, 6231, 26884, 5909, 677, 6232, 26885, 5910, 678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15597, 6232, 26885, 5910, 678, 762, 6506, 702, 29, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15598, 5886, 5887, 623, 622, 26863, 26886, 5911, 5888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15599, 26863, 26886, 5911, 5888, 26864, 26887, 5912, 5889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15600, 26864, 26887, 5912, 5889, 26865, 26888, 5913, 5890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15601, 26865, 26888, 5913, 5890, 26866, 26889, 5914, 5891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15602, 26866, 26889, 5914, 5891, 26867, 26890, 5915, 5892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15603, 26867, 26890, 5915, 5892, 26868, 26891, 5916, 5893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15604, 26868, 26891, 5916, 5893, 26869, 26892, 5917, 5894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15605, 26869, 26892, 5917, 5894, 26870, 26893, 5918, 5895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15606, 26870, 26893, 5918, 5895, 26871, 26894, 5919, 5896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15607, 26871, 26894, 5919, 5896, 26872, 26895, 5920, 5897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15608, 26872, 26895, 5920, 5897, 26873, 26896, 5921, 5898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15609, 26873, 26896, 5921, 5898, 26874, 26897, 5922, 5899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15610, 26874, 26897, 5922, 5899, 26875, 26898, 5923, 5900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15611, 26875, 26898, 5923, 5900, 26876, 26899, 5924, 5901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15612, 26876, 26899, 5924, 5901, 26877, 26900, 5925, 5902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15613, 26877, 26900, 5925, 5902, 26878, 26901, 5926, 5903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15614, 26878, 26901, 5926, 5903, 26879, 26902, 5927, 5904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15615, 26879, 26902, 5927, 5904, 26880, 26903, 5928, 5905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15616, 26880, 26903, 5928, 5905, 26881, 26904, 5929, 5906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15617, 26881, 26904, 5929, 5906, 26882, 26905, 5930, 5907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15618, 26882, 26905, 5930, 5907, 26883, 26906, 5931, 5908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15619, 26883, 26906, 5931, 5908, 26884, 26907, 5932, 5909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15620, 26884, 26907, 5932, 5909, 26885, 26908, 5933, 5910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15621, 26885, 26908, 5933, 5910, 6506, 6507, 703, 702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15622, 5887, 655, 26, 623, 26886, 6463, 679, 5911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15623, 26886, 6463, 679, 5911, 26887, 6464, 680, 5912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15624, 26887, 6464, 680, 5912, 26888, 6465, 681, 5913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15625, 26888, 6465, 681, 5913, 26889, 6466, 682, 5914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15626, 26889, 6466, 682, 5914, 26890, 6467, 683, 5915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15627, 26890, 6467, 683, 5915, 26891, 6468, 684, 5916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15628, 26891, 6468, 684, 5916, 26892, 6469, 685, 5917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15629, 26892, 6469, 685, 5917, 26893, 6470, 686, 5918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15630, 26893, 6470, 686, 5918, 26894, 6471, 687, 5919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15631, 26894, 6471, 687, 5919, 26895, 6472, 688, 5920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15632, 26895, 6472, 688, 5920, 26896, 6473, 689, 5921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15633, 26896, 6473, 689, 5921, 26897, 6474, 690, 5922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15634, 26897, 6474, 690, 5922, 26898, 6475, 691, 5923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15635, 26898, 6475, 691, 5923, 26899, 6476, 692, 5924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15636, 26899, 6476, 692, 5924, 26900, 6477, 693, 5925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15637, 26900, 6477, 693, 5925, 26901, 6478, 694, 5926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15638, 26901, 6478, 694, 5926, 26902, 6479, 695, 5927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15639, 26902, 6479, 695, 5927, 26903, 6480, 696, 5928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15640, 26903, 6480, 696, 5928, 26904, 6481, 697, 5929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15641, 26904, 6481, 697, 5929, 26905, 6482, 698, 5930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15642, 26905, 6482, 698, 5930, 26906, 6483, 699, 5931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15643, 26906, 6483, 699, 5931, 26907, 6484, 700, 5932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15644, 26907, 6484, 700, 5932, 26908, 6485, 701, 5933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15645, 26908, 6485, 701, 5933, 6507, 773, 30, 703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume8
15646, 27, 704, 5980, 634, 35, 797, 6508, 820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15647, 704, 705, 5981, 5980, 797, 798, 6509, 6508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15648, 705, 706, 5982, 5981, 798, 799, 6510, 6509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15649, 706, 707, 5983, 5982, 799, 800, 6511, 6510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15650, 707, 708, 5984, 5983, 800, 801, 6512, 6511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15651, 708, 709, 5985, 5984, 801, 802, 6513, 6512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15652, 709, 710, 5986, 5985, 802, 803, 6514, 6513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15653, 710, 711, 5987, 5986, 803, 804, 6515, 6514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15654, 711, 712, 5988, 5987, 804, 805, 6516, 6515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15655, 712, 713, 5989, 5988, 805, 806, 6517, 6516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15656, 713, 714, 5990, 5989, 806, 807, 6518, 6517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15657, 714, 715, 5991, 5990, 807, 808, 6519, 6518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15658, 715, 716, 5992, 5991, 808, 809, 6520, 6519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15659, 716, 717, 5993, 5992, 809, 810, 6521, 6520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15660, 717, 718, 5994, 5993, 810, 811, 6522, 6521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15661, 718, 719, 5995, 5994, 811, 812, 6523, 6522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15662, 719, 720, 5996, 5995, 812, 813, 6524, 6523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15663, 720, 721, 5997, 5996, 813, 814, 6525, 6524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15664, 721, 722, 5998, 5997, 814, 815, 6526, 6525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15665, 722, 723, 5999, 5998, 815, 816, 6527, 6526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15666, 723, 724, 6000, 5999, 816, 817, 6528, 6527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15667, 724, 725, 6001, 6000, 817, 818, 6529, 6528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15668, 725, 726, 6002, 6001, 818, 819, 6530, 6529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15669, 726, 31, 752, 6002, 819, 36, 831, 6530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15670, 634, 5980, 6003, 635, 820, 6508, 6531, 821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15671, 5980, 5981, 6004, 6003, 6508, 6509, 6532, 6531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15672, 5981, 5982, 6005, 6004, 6509, 6510, 6533, 6532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15673, 5982, 5983, 6006, 6005, 6510, 6511, 6534, 6533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15674, 5983, 5984, 6007, 6006, 6511, 6512, 6535, 6534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15675, 5984, 5985, 6008, 6007, 6512, 6513, 6536, 6535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15676, 5985, 5986, 6009, 6008, 6513, 6514, 6537, 6536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15677, 5986, 5987, 6010, 6009, 6514, 6515, 6538, 6537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15678, 5987, 5988, 6011, 6010, 6515, 6516, 6539, 6538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15679, 5988, 5989, 6012, 6011, 6516, 6517, 6540, 6539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15680, 5989, 5990, 6013, 6012, 6517, 6518, 6541, 6540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15681, 5990, 5991, 6014, 6013, 6518, 6519, 6542, 6541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15682, 5991, 5992, 6015, 6014, 6519, 6520, 6543, 6542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15683, 5992, 5993, 6016, 6015, 6520, 6521, 6544, 6543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15684, 5993, 5994, 6017, 6016, 6521, 6522, 6545, 6544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15685, 5994, 5995, 6018, 6017, 6522, 6523, 6546, 6545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15686, 5995, 5996, 6019, 6018, 6523, 6524, 6547, 6546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15687, 5996, 5997, 6020, 6019, 6524, 6525, 6548, 6547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15688, 5997, 5998, 6021, 6020, 6525, 6526, 6549, 6548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15689, 5998, 5999, 6022, 6021, 6526, 6527, 6550, 6549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15690, 5999, 6000, 6023, 6022, 6527, 6528, 6551, 6550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15691, 6000, 6001, 6024, 6023, 6528, 6529, 6552, 6551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15692, 6001, 6002, 6025, 6024, 6529, 6530, 6553, 6552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15693, 6002, 752, 753, 6025, 6530, 831, 832, 6553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15694, 635, 6003, 6026, 636, 821, 6531, 6554, 822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15695, 6003, 6004, 6027, 6026, 6531, 6532, 6555, 6554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15696, 6004, 6005, 6028, 6027, 6532, 6533, 6556, 6555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15697, 6005, 6006, 6029, 6028, 6533, 6534, 6557, 6556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15698, 6006, 6007, 6030, 6029, 6534, 6535, 6558, 6557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15699, 6007, 6008, 6031, 6030, 6535, 6536, 6559, 6558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15700, 6008, 6009, 6032, 6031, 6536, 6537, 6560, 6559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15701, 6009, 6010, 6033, 6032, 6537, 6538, 6561, 6560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15702, 6010, 6011, 6034, 6033, 6538, 6539, 6562, 6561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15703, 6011, 6012, 6035, 6034, 6539, 6540, 6563, 6562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15704, 6012, 6013, 6036, 6035, 6540, 6541, 6564, 6563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15705, 6013, 6014, 6037, 6036, 6541, 6542, 6565, 6564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15706, 6014, 6015, 6038, 6037, 6542, 6543, 6566, 6565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15707, 6015, 6016, 6039, 6038, 6543, 6544, 6567, 6566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15708, 6016, 6017, 6040, 6039, 6544, 6545, 6568, 6567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15709, 6017, 6018, 6041, 6040, 6545, 6546, 6569, 6568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15710, 6018, 6019, 6042, 6041, 6546, 6547, 6570, 6569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15711, 6019, 6020, 6043, 6042, 6547, 6548, 6571, 6570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15712, 6020, 6021, 6044, 6043, 6548, 6549, 6572, 6571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15713, 6021, 6022, 6045, 6044, 6549, 6550, 6573, 6572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15714, 6022, 6023, 6046, 6045, 6550, 6551, 6574, 6573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15715, 6023, 6024, 6047, 6046, 6551, 6552, 6575, 6574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15716, 6024, 6025, 6048, 6047, 6552, 6553, 6576, 6575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15717, 6025, 753, 754, 6048, 6553, 832, 833, 6576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15718, 636, 6026, 6049, 637, 822, 6554, 6577, 823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15719, 6026, 6027, 6050, 6049, 6554, 6555, 6578, 6577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15720, 6027, 6028, 6051, 6050, 6555, 6556, 6579, 6578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15721, 6028, 6029, 6052, 6051, 6556, 6557, 6580, 6579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15722, 6029, 6030, 6053, 6052, 6557, 6558, 6581, 6580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15723, 6030, 6031, 6054, 6053, 6558, 6559, 6582, 6581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15724, 6031, 6032, 6055, 6054, 6559, 6560, 6583, 6582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15725, 6032, 6033, 6056, 6055, 6560, 6561, 6584, 6583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15726, 6033, 6034, 6057, 6056, 6561, 6562, 6585, 6584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15727, 6034, 6035, 6058, 6057, 6562, 6563, 6586, 6585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15728, 6035, 6036, 6059, 6058, 6563, 6564, 6587, 6586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15729, 6036, 6037, 6060, 6059, 6564, 6565, 6588, 6587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15730, 6037, 6038, 6061, 6060, 6565, 6566, 6589, 6588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15731, 6038, 6039, 6062, 6061, 6566, 6567, 6590, 6589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15732, 6039, 6040, 6063, 6062, 6567, 6568, 6591, 6590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15733, 6040, 6041, 6064, 6063, 6568, 6569, 6592, 6591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15734, 6041, 6042, 6065, 6064, 6569, 6570, 6593, 6592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15735, 6042, 6043, 6066, 6065, 6570, 6571, 6594, 6593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15736, 6043, 6044, 6067, 6066, 6571, 6572, 6595, 6594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15737, 6044, 6045, 6068, 6067, 6572, 6573, 6596, 6595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15738, 6045, 6046, 6069, 6068, 6573, 6574, 6597, 6596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15739, 6046, 6047, 6070, 6069, 6574, 6575, 6598, 6597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15740, 6047, 6048, 6071, 6070, 6575, 6576, 6599, 6598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15741, 6048, 754, 755, 6071, 6576, 833, 834, 6599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15742, 637, 6049, 6072, 638, 823, 6577, 6600, 824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15743, 6049, 6050, 6073, 6072, 6577, 6578, 6601, 6600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15744, 6050, 6051, 6074, 6073, 6578, 6579, 6602, 6601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15745, 6051, 6052, 6075, 6074, 6579, 6580, 6603, 6602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15746, 6052, 6053, 6076, 6075, 6580, 6581, 6604, 6603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15747, 6053, 6054, 6077, 6076, 6581, 6582, 6605, 6604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15748, 6054, 6055, 6078, 6077, 6582, 6583, 6606, 6605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15749, 6055, 6056, 6079, 6078, 6583, 6584, 6607, 6606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15750, 6056, 6057, 6080, 6079, 6584, 6585, 6608, 6607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15751, 6057, 6058, 6081, 6080, 6585, 6586, 6609, 6608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15752, 6058, 6059, 6082, 6081, 6586, 6587, 6610, 6609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15753, 6059, 6060, 6083, 6082, 6587, 6588, 6611, 6610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15754, 6060, 6061, 6084, 6083, 6588, 6589, 6612, 6611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15755, 6061, 6062, 6085, 6084, 6589, 6590, 6613, 6612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15756, 6062, 6063, 6086, 6085, 6590, 6591, 6614, 6613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15757, 6063, 6064, 6087, 6086, 6591, 6592, 6615, 6614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15758, 6064, 6065, 6088, 6087, 6592, 6593, 6616, 6615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15759, 6065, 6066, 6089, 6088, 6593, 6594, 6617, 6616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15760, 6066, 6067, 6090, 6089, 6594, 6595, 6618, 6617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15761, 6067, 6068, 6091, 6090, 6595, 6596, 6619, 6618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15762, 6068, 6069, 6092, 6091, 6596, 6597, 6620, 6619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15763, 6069, 6070, 6093, 6092, 6597, 6598, 6621, 6620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15764, 6070, 6071, 6094, 6093, 6598, 6599, 6622, 6621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15765, 6071, 755, 756, 6094, 6599, 834, 835, 6622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15766, 638, 6072, 6095, 639, 824, 6600, 6623, 825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15767, 6072, 6073, 6096, 6095, 6600, 6601, 6624, 6623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15768, 6073, 6074, 6097, 6096, 6601, 6602, 6625, 6624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15769, 6074, 6075, 6098, 6097, 6602, 6603, 6626, 6625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15770, 6075, 6076, 6099, 6098, 6603, 6604, 6627, 6626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15771, 6076, 6077, 6100, 6099, 6604, 6605, 6628, 6627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15772, 6077, 6078, 6101, 6100, 6605, 6606, 6629, 6628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15773, 6078, 6079, 6102, 6101, 6606, 6607, 6630, 6629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15774, 6079, 6080, 6103, 6102, 6607, 6608, 6631, 6630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15775, 6080, 6081, 6104, 6103, 6608, 6609, 6632, 6631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15776, 6081, 6082, 6105, 6104, 6609, 6610, 6633, 6632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15777, 6082, 6083, 6106, 6105, 6610, 6611, 6634, 6633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15778, 6083, 6084, 6107, 6106, 6611, 6612, 6635, 6634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15779, 6084, 6085, 6108, 6107, 6612, 6613, 6636, 6635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15780, 6085, 6086, 6109, 6108, 6613, 6614, 6637, 6636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15781, 6086, 6087, 6110, 6109, 6614, 6615, 6638, 6637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15782, 6087, 6088, 6111, 6110, 6615, 6616, 6639, 6638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15783, 6088, 6089, 6112, 6111, 6616, 6617, 6640, 6639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15784, 6089, 6090, 6113, 6112, 6617, 6618, 6641, 6640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15785, 6090, 6091, 6114, 6113, 6618, 6619, 6642, 6641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15786, 6091, 6092, 6115, 6114, 6619, 6620, 6643, 6642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15787, 6092, 6093, 6116, 6115, 6620, 6621, 6644, 6643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15788, 6093, 6094, 6117, 6116, 6621, 6622, 6645, 6644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15789, 6094, 756, 757, 6117, 6622, 835, 836, 6645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15790, 639, 6095, 6118, 640, 825, 6623, 6646, 826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15791, 6095, 6096, 6119, 6118, 6623, 6624, 6647, 6646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15792, 6096, 6097, 6120, 6119, 6624, 6625, 6648, 6647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15793, 6097, 6098, 6121, 6120, 6625, 6626, 6649, 6648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15794, 6098, 6099, 6122, 6121, 6626, 6627, 6650, 6649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15795, 6099, 6100, 6123, 6122, 6627, 6628, 6651, 6650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15796, 6100, 6101, 6124, 6123, 6628, 6629, 6652, 6651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15797, 6101, 6102, 6125, 6124, 6629, 6630, 6653, 6652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15798, 6102, 6103, 6126, 6125, 6630, 6631, 6654, 6653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15799, 6103, 6104, 6127, 6126, 6631, 6632, 6655, 6654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15800, 6104, 6105, 6128, 6127, 6632, 6633, 6656, 6655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15801, 6105, 6106, 6129, 6128, 6633, 6634, 6657, 6656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15802, 6106, 6107, 6130, 6129, 6634, 6635, 6658, 6657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15803, 6107, 6108, 6131, 6130, 6635, 6636, 6659, 6658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15804, 6108, 6109, 6132, 6131, 6636, 6637, 6660, 6659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15805, 6109, 6110, 6133, 6132, 6637, 6638, 6661, 6660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15806, 6110, 6111, 6134, 6133, 6638, 6639, 6662, 6661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15807, 6111, 6112, 6135, 6134, 6639, 6640, 6663, 6662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15808, 6112, 6113, 6136, 6135, 6640, 6641, 6664, 6663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15809, 6113, 6114, 6137, 6136, 6641, 6642, 6665, 6664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15810, 6114, 6115, 6138, 6137, 6642, 6643, 6666, 6665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15811, 6115, 6116, 6139, 6138, 6643, 6644, 6667, 6666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15812, 6116, 6117, 6140, 6139, 6644, 6645, 6668, 6667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15813, 6117, 757, 758, 6140, 6645, 836, 837, 6668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15814, 640, 6118, 6141, 641, 826, 6646, 6669, 827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15815, 6118, 6119, 6142, 6141, 6646, 6647, 6670, 6669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15816, 6119, 6120, 6143, 6142, 6647, 6648, 6671, 6670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15817, 6120, 6121, 6144, 6143, 6648, 6649, 6672, 6671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15818, 6121, 6122, 6145, 6144, 6649, 6650, 6673, 6672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15819, 6122, 6123, 6146, 6145, 6650, 6651, 6674, 6673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15820, 6123, 6124, 6147, 6146, 6651, 6652, 6675, 6674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15821, 6124, 6125, 6148, 6147, 6652, 6653, 6676, 6675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15822, 6125, 6126, 6149, 6148, 6653, 6654, 6677, 6676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15823, 6126, 6127, 6150, 6149, 6654, 6655, 6678, 6677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15824, 6127, 6128, 6151, 6150, 6655, 6656, 6679, 6678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15825, 6128, 6129, 6152, 6151, 6656, 6657, 6680, 6679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15826, 6129, 6130, 6153, 6152, 6657, 6658, 6681, 6680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15827, 6130, 6131, 6154, 6153, 6658, 6659, 6682, 6681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15828, 6131, 6132, 6155, 6154, 6659, 6660, 6683, 6682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15829, 6132, 6133, 6156, 6155, 6660, 6661, 6684, 6683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15830, 6133, 6134, 6157, 6156, 6661, 6662, 6685, 6684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15831, 6134, 6135, 6158, 6157, 6662, 6663, 6686, 6685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15832, 6135, 6136, 6159, 6158, 6663, 6664, 6687, 6686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15833, 6136, 6137, 6160, 6159, 6664, 6665, 6688, 6687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15834, 6137, 6138, 6161, 6160, 6665, 6666, 6689, 6688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15835, 6138, 6139, 6162, 6161, 6666, 6667, 6690, 6689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15836, 6139, 6140, 6163, 6162, 6667, 6668, 6691, 6690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15837, 6140, 758, 759, 6163, 6668, 837, 838, 6691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15838, 641, 6141, 6164, 642, 827, 6669, 6692, 828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15839, 6141, 6142, 6165, 6164, 6669, 6670, 6693, 6692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15840, 6142, 6143, 6166, 6165, 6670, 6671, 6694, 6693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15841, 6143, 6144, 6167, 6166, 6671, 6672, 6695, 6694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15842, 6144, 6145, 6168, 6167, 6672, 6673, 6696, 6695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15843, 6145, 6146, 6169, 6168, 6673, 6674, 6697, 6696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15844, 6146, 6147, 6170, 6169, 6674, 6675, 6698, 6697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15845, 6147, 6148, 6171, 6170, 6675, 6676, 6699, 6698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15846, 6148, 6149, 6172, 6171, 6676, 6677, 6700, 6699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15847, 6149, 6150, 6173, 6172, 6677, 6678, 6701, 6700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15848, 6150, 6151, 6174, 6173, 6678, 6679, 6702, 6701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15849, 6151, 6152, 6175, 6174, 6679, 6680, 6703, 6702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15850, 6152, 6153, 6176, 6175, 6680, 6681, 6704, 6703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15851, 6153, 6154, 6177, 6176, 6681, 6682, 6705, 6704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15852, 6154, 6155, 6178, 6177, 6682, 6683, 6706, 6705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15853, 6155, 6156, 6179, 6178, 6683, 6684, 6707, 6706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15854, 6156, 6157, 6180, 6179, 6684, 6685, 6708, 6707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15855, 6157, 6158, 6181, 6180, 6685, 6686, 6709, 6708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15856, 6158, 6159, 6182, 6181, 6686, 6687, 6710, 6709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15857, 6159, 6160, 6183, 6182, 6687, 6688, 6711, 6710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15858, 6160, 6161, 6184, 6183, 6688, 6689, 6712, 6711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15859, 6161, 6162, 6185, 6184, 6689, 6690, 6713, 6712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15860, 6162, 6163, 6186, 6185, 6690, 6691, 6714, 6713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15861, 6163, 759, 760, 6186, 6691, 838, 839, 6714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15862, 642, 6164, 6187, 643, 828, 6692, 6715, 829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15863, 6164, 6165, 6188, 6187, 6692, 6693, 6716, 6715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15864, 6165, 6166, 6189, 6188, 6693, 6694, 6717, 6716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15865, 6166, 6167, 6190, 6189, 6694, 6695, 6718, 6717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15866, 6167, 6168, 6191, 6190, 6695, 6696, 6719, 6718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15867, 6168, 6169, 6192, 6191, 6696, 6697, 6720, 6719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15868, 6169, 6170, 6193, 6192, 6697, 6698, 6721, 6720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15869, 6170, 6171, 6194, 6193, 6698, 6699, 6722, 6721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15870, 6171, 6172, 6195, 6194, 6699, 6700, 6723, 6722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15871, 6172, 6173, 6196, 6195, 6700, 6701, 6724, 6723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15872, 6173, 6174, 6197, 6196, 6701, 6702, 6725, 6724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15873, 6174, 6175, 6198, 6197, 6702, 6703, 6726, 6725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15874, 6175, 6176, 6199, 6198, 6703, 6704, 6727, 6726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15875, 6176, 6177, 6200, 6199, 6704, 6705, 6728, 6727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15876, 6177, 6178, 6201, 6200, 6705, 6706, 6729, 6728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15877, 6178, 6179, 6202, 6201, 6706, 6707, 6730, 6729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15878, 6179, 6180, 6203, 6202, 6707, 6708, 6731, 6730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15879, 6180, 6181, 6204, 6203, 6708, 6709, 6732, 6731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15880, 6181, 6182, 6205, 6204, 6709, 6710, 6733, 6732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15881, 6182, 6183, 6206, 6205, 6710, 6711, 6734, 6733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15882, 6183, 6184, 6207, 6206, 6711, 6712, 6735, 6734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15883, 6184, 6185, 6208, 6207, 6712, 6713, 6736, 6735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15884, 6185, 6186, 6209, 6208, 6713, 6714, 6737, 6736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15885, 6186, 760, 761, 6209, 6714, 839, 840, 6737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15886, 643, 6187, 6210, 644, 829, 6715, 6738, 830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15887, 6187, 6188, 6211, 6210, 6715, 6716, 6739, 6738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15888, 6188, 6189, 6212, 6211, 6716, 6717, 6740, 6739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15889, 6189, 6190, 6213, 6212, 6717, 6718, 6741, 6740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15890, 6190, 6191, 6214, 6213, 6718, 6719, 6742, 6741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15891, 6191, 6192, 6215, 6214, 6719, 6720, 6743, 6742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15892, 6192, 6193, 6216, 6215, 6720, 6721, 6744, 6743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15893, 6193, 6194, 6217, 6216, 6721, 6722, 6745, 6744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15894, 6194, 6195, 6218, 6217, 6722, 6723, 6746, 6745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15895, 6195, 6196, 6219, 6218, 6723, 6724, 6747, 6746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15896, 6196, 6197, 6220, 6219, 6724, 6725, 6748, 6747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15897, 6197, 6198, 6221, 6220, 6725, 6726, 6749, 6748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15898, 6198, 6199, 6222, 6221, 6726, 6727, 6750, 6749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15899, 6199, 6200, 6223, 6222, 6727, 6728, 6751, 6750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15900, 6200, 6201, 6224, 6223, 6728, 6729, 6752, 6751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15901, 6201, 6202, 6225, 6224, 6729, 6730, 6753, 6752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15902, 6202, 6203, 6226, 6225, 6730, 6731, 6754, 6753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15903, 6203, 6204, 6227, 6226, 6731, 6732, 6755, 6754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15904, 6204, 6205, 6228, 6227, 6732, 6733, 6756, 6755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15905, 6205, 6206, 6229, 6228, 6733, 6734, 6757, 6756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15906, 6206, 6207, 6230, 6229, 6734, 6735, 6758, 6757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15907, 6207, 6208, 6231, 6230, 6735, 6736, 6759, 6758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15908, 6208, 6209, 6232, 6231, 6736, 6737, 6760, 6759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15909, 6209, 761, 762, 6232, 6737, 840, 841, 6760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15910, 644, 6210, 656, 25, 830, 6738, 774, 33, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15911, 6210, 6211, 657, 656, 6738, 6739, 775, 774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15912, 6211, 6212, 658, 657, 6739, 6740, 776, 775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15913, 6212, 6213, 659, 658, 6740, 6741, 777, 776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15914, 6213, 6214, 660, 659, 6741, 6742, 778, 777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15915, 6214, 6215, 661, 660, 6742, 6743, 779, 778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15916, 6215, 6216, 662, 661, 6743, 6744, 780, 779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15917, 6216, 6217, 663, 662, 6744, 6745, 781, 780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15918, 6217, 6218, 664, 663, 6745, 6746, 782, 781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15919, 6218, 6219, 665, 664, 6746, 6747, 783, 782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15920, 6219, 6220, 666, 665, 6747, 6748, 784, 783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15921, 6220, 6221, 667, 666, 6748, 6749, 785, 784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15922, 6221, 6222, 668, 667, 6749, 6750, 786, 785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15923, 6222, 6223, 669, 668, 6750, 6751, 787, 786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15924, 6223, 6224, 670, 669, 6751, 6752, 788, 787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15925, 6224, 6225, 671, 670, 6752, 6753, 789, 788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15926, 6225, 6226, 672, 671, 6753, 6754, 790, 789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15927, 6226, 6227, 673, 672, 6754, 6755, 791, 790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15928, 6227, 6228, 674, 673, 6755, 6756, 792, 791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15929, 6228, 6229, 675, 674, 6756, 6757, 793, 792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15930, 6229, 6230, 676, 675, 6757, 6758, 794, 793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15931, 6230, 6231, 677, 676, 6758, 6759, 795, 794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15932, 6231, 6232, 678, 677, 6759, 6760, 796, 795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15933, 6232, 762, 29, 678, 6760, 841, 34, 796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume9
15934, 35, 797, 6508, 820, 911, 7290, 26909, 7819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15935, 911, 7290, 26909, 7819, 912, 7291, 26910, 7820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15936, 912, 7291, 26910, 7820, 913, 7292, 26911, 7821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15937, 913, 7292, 26911, 7821, 914, 7293, 26912, 7822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15938, 914, 7293, 26912, 7822, 915, 7294, 26913, 7823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15939, 915, 7294, 26913, 7823, 916, 7295, 26914, 7824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15940, 916, 7295, 26914, 7824, 917, 7296, 26915, 7825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15941, 917, 7296, 26915, 7825, 918, 7297, 26916, 7826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15942, 918, 7297, 26916, 7826, 919, 7298, 26917, 7827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15943, 919, 7298, 26917, 7827, 920, 7299, 26918, 7828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15944, 920, 7299, 26918, 7828, 921, 7300, 26919, 7829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15945, 921, 7300, 26919, 7829, 922, 7301, 26920, 7830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15946, 922, 7301, 26920, 7830, 923, 7302, 26921, 7831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15947, 923, 7302, 26921, 7831, 924, 7303, 26922, 7832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15948, 924, 7303, 26922, 7832, 925, 7304, 26923, 7833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15949, 925, 7304, 26923, 7833, 926, 7305, 26924, 7834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15950, 926, 7305, 26924, 7834, 927, 7306, 26925, 7835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15951, 927, 7306, 26925, 7835, 928, 7307, 26926, 7836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15952, 928, 7307, 26926, 7836, 929, 7308, 26927, 7837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15953, 929, 7308, 26927, 7837, 930, 7309, 26928, 7838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15954, 930, 7309, 26928, 7838, 931, 7310, 26929, 7839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15955, 931, 7310, 26929, 7839, 932, 7311, 26930, 7840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15956, 932, 7311, 26930, 7840, 933, 7312, 26931, 7841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15957, 933, 7312, 26931, 7841, 39, 957, 8325, 980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15958, 797, 798, 6509, 6508, 7290, 7313, 26932, 26909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15959, 7290, 7313, 26932, 26909, 7291, 7314, 26933, 26910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15960, 7291, 7314, 26933, 26910, 7292, 7315, 26934, 26911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15961, 7292, 7315, 26934, 26911, 7293, 7316, 26935, 26912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15962, 7293, 7316, 26935, 26912, 7294, 7317, 26936, 26913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15963, 7294, 7317, 26936, 26913, 7295, 7318, 26937, 26914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15964, 7295, 7318, 26937, 26914, 7296, 7319, 26938, 26915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15965, 7296, 7319, 26938, 26915, 7297, 7320, 26939, 26916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15966, 7297, 7320, 26939, 26916, 7298, 7321, 26940, 26917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15967, 7298, 7321, 26940, 26917, 7299, 7322, 26941, 26918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15968, 7299, 7322, 26941, 26918, 7300, 7323, 26942, 26919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15969, 7300, 7323, 26942, 26919, 7301, 7324, 26943, 26920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15970, 7301, 7324, 26943, 26920, 7302, 7325, 26944, 26921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15971, 7302, 7325, 26944, 26921, 7303, 7326, 26945, 26922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15972, 7303, 7326, 26945, 26922, 7304, 7327, 26946, 26923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15973, 7304, 7327, 26946, 26923, 7305, 7328, 26947, 26924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15974, 7305, 7328, 26947, 26924, 7306, 7329, 26948, 26925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15975, 7306, 7329, 26948, 26925, 7307, 7330, 26949, 26926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15976, 7307, 7330, 26949, 26926, 7308, 7331, 26950, 26927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15977, 7308, 7331, 26950, 26927, 7309, 7332, 26951, 26928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15978, 7309, 7332, 26951, 26928, 7310, 7333, 26952, 26929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15979, 7310, 7333, 26952, 26929, 7311, 7334, 26953, 26930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15980, 7311, 7334, 26953, 26930, 7312, 7335, 26954, 26931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15981, 7312, 7335, 26954, 26931, 957, 958, 8326, 8325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15982, 798, 799, 6510, 6509, 7313, 7336, 26955, 26932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15983, 7313, 7336, 26955, 26932, 7314, 7337, 26956, 26933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15984, 7314, 7337, 26956, 26933, 7315, 7338, 26957, 26934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15985, 7315, 7338, 26957, 26934, 7316, 7339, 26958, 26935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15986, 7316, 7339, 26958, 26935, 7317, 7340, 26959, 26936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15987, 7317, 7340, 26959, 26936, 7318, 7341, 26960, 26937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15988, 7318, 7341, 26960, 26937, 7319, 7342, 26961, 26938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15989, 7319, 7342, 26961, 26938, 7320, 7343, 26962, 26939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15990, 7320, 7343, 26962, 26939, 7321, 7344, 26963, 26940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15991, 7321, 7344, 26963, 26940, 7322, 7345, 26964, 26941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15992, 7322, 7345, 26964, 26941, 7323, 7346, 26965, 26942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15993, 7323, 7346, 26965, 26942, 7324, 7347, 26966, 26943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15994, 7324, 7347, 26966, 26943, 7325, 7348, 26967, 26944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15995, 7325, 7348, 26967, 26944, 7326, 7349, 26968, 26945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15996, 7326, 7349, 26968, 26945, 7327, 7350, 26969, 26946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15997, 7327, 7350, 26969, 26946, 7328, 7351, 26970, 26947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15998, 7328, 7351, 26970, 26947, 7329, 7352, 26971, 26948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15999, 7329, 7352, 26971, 26948, 7330, 7353, 26972, 26949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16000, 7330, 7353, 26972, 26949, 7331, 7354, 26973, 26950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16001, 7331, 7354, 26973, 26950, 7332, 7355, 26974, 26951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16002, 7332, 7355, 26974, 26951, 7333, 7356, 26975, 26952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16003, 7333, 7356, 26975, 26952, 7334, 7357, 26976, 26953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16004, 7334, 7357, 26976, 26953, 7335, 7358, 26977, 26954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16005, 7335, 7358, 26977, 26954, 958, 959, 8327, 8326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16006, 799, 800, 6511, 6510, 7336, 7359, 26978, 26955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16007, 7336, 7359, 26978, 26955, 7337, 7360, 26979, 26956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16008, 7337, 7360, 26979, 26956, 7338, 7361, 26980, 26957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16009, 7338, 7361, 26980, 26957, 7339, 7362, 26981, 26958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16010, 7339, 7362, 26981, 26958, 7340, 7363, 26982, 26959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16011, 7340, 7363, 26982, 26959, 7341, 7364, 26983, 26960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16012, 7341, 7364, 26983, 26960, 7342, 7365, 26984, 26961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16013, 7342, 7365, 26984, 26961, 7343, 7366, 26985, 26962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16014, 7343, 7366, 26985, 26962, 7344, 7367, 26986, 26963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16015, 7344, 7367, 26986, 26963, 7345, 7368, 26987, 26964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16016, 7345, 7368, 26987, 26964, 7346, 7369, 26988, 26965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16017, 7346, 7369, 26988, 26965, 7347, 7370, 26989, 26966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16018, 7347, 7370, 26989, 26966, 7348, 7371, 26990, 26967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16019, 7348, 7371, 26990, 26967, 7349, 7372, 26991, 26968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16020, 7349, 7372, 26991, 26968, 7350, 7373, 26992, 26969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16021, 7350, 7373, 26992, 26969, 7351, 7374, 26993, 26970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16022, 7351, 7374, 26993, 26970, 7352, 7375, 26994, 26971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16023, 7352, 7375, 26994, 26971, 7353, 7376, 26995, 26972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16024, 7353, 7376, 26995, 26972, 7354, 7377, 26996, 26973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16025, 7354, 7377, 26996, 26973, 7355, 7378, 26997, 26974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16026, 7355, 7378, 26997, 26974, 7356, 7379, 26998, 26975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16027, 7356, 7379, 26998, 26975, 7357, 7380, 26999, 26976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16028, 7357, 7380, 26999, 26976, 7358, 7381, 27000, 26977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16029, 7358, 7381, 27000, 26977, 959, 960, 8328, 8327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16030, 800, 801, 6512, 6511, 7359, 7382, 27001, 26978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16031, 7359, 7382, 27001, 26978, 7360, 7383, 27002, 26979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16032, 7360, 7383, 27002, 26979, 7361, 7384, 27003, 26980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16033, 7361, 7384, 27003, 26980, 7362, 7385, 27004, 26981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16034, 7362, 7385, 27004, 26981, 7363, 7386, 27005, 26982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16035, 7363, 7386, 27005, 26982, 7364, 7387, 27006, 26983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16036, 7364, 7387, 27006, 26983, 7365, 7388, 27007, 26984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16037, 7365, 7388, 27007, 26984, 7366, 7389, 27008, 26985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16038, 7366, 7389, 27008, 26985, 7367, 7390, 27009, 26986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16039, 7367, 7390, 27009, 26986, 7368, 7391, 27010, 26987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16040, 7368, 7391, 27010, 26987, 7369, 7392, 27011, 26988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16041, 7369, 7392, 27011, 26988, 7370, 7393, 27012, 26989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16042, 7370, 7393, 27012, 26989, 7371, 7394, 27013, 26990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16043, 7371, 7394, 27013, 26990, 7372, 7395, 27014, 26991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16044, 7372, 7395, 27014, 26991, 7373, 7396, 27015, 26992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16045, 7373, 7396, 27015, 26992, 7374, 7397, 27016, 26993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16046, 7374, 7397, 27016, 26993, 7375, 7398, 27017, 26994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16047, 7375, 7398, 27017, 26994, 7376, 7399, 27018, 26995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16048, 7376, 7399, 27018, 26995, 7377, 7400, 27019, 26996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16049, 7377, 7400, 27019, 26996, 7378, 7401, 27020, 26997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16050, 7378, 7401, 27020, 26997, 7379, 7402, 27021, 26998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16051, 7379, 7402, 27021, 26998, 7380, 7403, 27022, 26999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16052, 7380, 7403, 27022, 26999, 7381, 7404, 27023, 27000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16053, 7381, 7404, 27023, 27000, 960, 961, 8329, 8328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16054, 801, 802, 6513, 6512, 7382, 7405, 27024, 27001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16055, 7382, 7405, 27024, 27001, 7383, 7406, 27025, 27002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16056, 7383, 7406, 27025, 27002, 7384, 7407, 27026, 27003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16057, 7384, 7407, 27026, 27003, 7385, 7408, 27027, 27004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16058, 7385, 7408, 27027, 27004, 7386, 7409, 27028, 27005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16059, 7386, 7409, 27028, 27005, 7387, 7410, 27029, 27006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16060, 7387, 7410, 27029, 27006, 7388, 7411, 27030, 27007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16061, 7388, 7411, 27030, 27007, 7389, 7412, 27031, 27008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16062, 7389, 7412, 27031, 27008, 7390, 7413, 27032, 27009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16063, 7390, 7413, 27032, 27009, 7391, 7414, 27033, 27010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16064, 7391, 7414, 27033, 27010, 7392, 7415, 27034, 27011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16065, 7392, 7415, 27034, 27011, 7393, 7416, 27035, 27012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16066, 7393, 7416, 27035, 27012, 7394, 7417, 27036, 27013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16067, 7394, 7417, 27036, 27013, 7395, 7418, 27037, 27014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16068, 7395, 7418, 27037, 27014, 7396, 7419, 27038, 27015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16069, 7396, 7419, 27038, 27015, 7397, 7420, 27039, 27016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16070, 7397, 7420, 27039, 27016, 7398, 7421, 27040, 27017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16071, 7398, 7421, 27040, 27017, 7399, 7422, 27041, 27018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16072, 7399, 7422, 27041, 27018, 7400, 7423, 27042, 27019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16073, 7400, 7423, 27042, 27019, 7401, 7424, 27043, 27020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16074, 7401, 7424, 27043, 27020, 7402, 7425, 27044, 27021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16075, 7402, 7425, 27044, 27021, 7403, 7426, 27045, 27022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16076, 7403, 7426, 27045, 27022, 7404, 7427, 27046, 27023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16077, 7404, 7427, 27046, 27023, 961, 962, 8330, 8329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16078, 802, 803, 6514, 6513, 7405, 7428, 27047, 27024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16079, 7405, 7428, 27047, 27024, 7406, 7429, 27048, 27025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16080, 7406, 7429, 27048, 27025, 7407, 7430, 27049, 27026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16081, 7407, 7430, 27049, 27026, 7408, 7431, 27050, 27027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16082, 7408, 7431, 27050, 27027, 7409, 7432, 27051, 27028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16083, 7409, 7432, 27051, 27028, 7410, 7433, 27052, 27029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16084, 7410, 7433, 27052, 27029, 7411, 7434, 27053, 27030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16085, 7411, 7434, 27053, 27030, 7412, 7435, 27054, 27031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16086, 7412, 7435, 27054, 27031, 7413, 7436, 27055, 27032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16087, 7413, 7436, 27055, 27032, 7414, 7437, 27056, 27033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16088, 7414, 7437, 27056, 27033, 7415, 7438, 27057, 27034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16089, 7415, 7438, 27057, 27034, 7416, 7439, 27058, 27035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16090, 7416, 7439, 27058, 27035, 7417, 7440, 27059, 27036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16091, 7417, 7440, 27059, 27036, 7418, 7441, 27060, 27037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16092, 7418, 7441, 27060, 27037, 7419, 7442, 27061, 27038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16093, 7419, 7442, 27061, 27038, 7420, 7443, 27062, 27039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16094, 7420, 7443, 27062, 27039, 7421, 7444, 27063, 27040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16095, 7421, 7444, 27063, 27040, 7422, 7445, 27064, 27041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16096, 7422, 7445, 27064, 27041, 7423, 7446, 27065, 27042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16097, 7423, 7446, 27065, 27042, 7424, 7447, 27066, 27043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16098, 7424, 7447, 27066, 27043, 7425, 7448, 27067, 27044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16099, 7425, 7448, 27067, 27044, 7426, 7449, 27068, 27045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16100, 7426, 7449, 27068, 27045, 7427, 7450, 27069, 27046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16101, 7427, 7450, 27069, 27046, 962, 963, 8331, 8330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16102, 803, 804, 6515, 6514, 7428, 7451, 27070, 27047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16103, 7428, 7451, 27070, 27047, 7429, 7452, 27071, 27048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16104, 7429, 7452, 27071, 27048, 7430, 7453, 27072, 27049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16105, 7430, 7453, 27072, 27049, 7431, 7454, 27073, 27050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16106, 7431, 7454, 27073, 27050, 7432, 7455, 27074, 27051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16107, 7432, 7455, 27074, 27051, 7433, 7456, 27075, 27052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16108, 7433, 7456, 27075, 27052, 7434, 7457, 27076, 27053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16109, 7434, 7457, 27076, 27053, 7435, 7458, 27077, 27054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16110, 7435, 7458, 27077, 27054, 7436, 7459, 27078, 27055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16111, 7436, 7459, 27078, 27055, 7437, 7460, 27079, 27056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16112, 7437, 7460, 27079, 27056, 7438, 7461, 27080, 27057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16113, 7438, 7461, 27080, 27057, 7439, 7462, 27081, 27058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16114, 7439, 7462, 27081, 27058, 7440, 7463, 27082, 27059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16115, 7440, 7463, 27082, 27059, 7441, 7464, 27083, 27060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16116, 7441, 7464, 27083, 27060, 7442, 7465, 27084, 27061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16117, 7442, 7465, 27084, 27061, 7443, 7466, 27085, 27062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16118, 7443, 7466, 27085, 27062, 7444, 7467, 27086, 27063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16119, 7444, 7467, 27086, 27063, 7445, 7468, 27087, 27064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16120, 7445, 7468, 27087, 27064, 7446, 7469, 27088, 27065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16121, 7446, 7469, 27088, 27065, 7447, 7470, 27089, 27066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16122, 7447, 7470, 27089, 27066, 7448, 7471, 27090, 27067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16123, 7448, 7471, 27090, 27067, 7449, 7472, 27091, 27068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16124, 7449, 7472, 27091, 27068, 7450, 7473, 27092, 27069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16125, 7450, 7473, 27092, 27069, 963, 964, 8332, 8331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16126, 804, 805, 6516, 6515, 7451, 7474, 27093, 27070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16127, 7451, 7474, 27093, 27070, 7452, 7475, 27094, 27071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16128, 7452, 7475, 27094, 27071, 7453, 7476, 27095, 27072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16129, 7453, 7476, 27095, 27072, 7454, 7477, 27096, 27073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16130, 7454, 7477, 27096, 27073, 7455, 7478, 27097, 27074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16131, 7455, 7478, 27097, 27074, 7456, 7479, 27098, 27075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16132, 7456, 7479, 27098, 27075, 7457, 7480, 27099, 27076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16133, 7457, 7480, 27099, 27076, 7458, 7481, 27100, 27077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16134, 7458, 7481, 27100, 27077, 7459, 7482, 27101, 27078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16135, 7459, 7482, 27101, 27078, 7460, 7483, 27102, 27079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16136, 7460, 7483, 27102, 27079, 7461, 7484, 27103, 27080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16137, 7461, 7484, 27103, 27080, 7462, 7485, 27104, 27081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16138, 7462, 7485, 27104, 27081, 7463, 7486, 27105, 27082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16139, 7463, 7486, 27105, 27082, 7464, 7487, 27106, 27083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16140, 7464, 7487, 27106, 27083, 7465, 7488, 27107, 27084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16141, 7465, 7488, 27107, 27084, 7466, 7489, 27108, 27085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16142, 7466, 7489, 27108, 27085, 7467, 7490, 27109, 27086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16143, 7467, 7490, 27109, 27086, 7468, 7491, 27110, 27087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16144, 7468, 7491, 27110, 27087, 7469, 7492, 27111, 27088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16145, 7469, 7492, 27111, 27088, 7470, 7493, 27112, 27089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16146, 7470, 7493, 27112, 27089, 7471, 7494, 27113, 27090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16147, 7471, 7494, 27113, 27090, 7472, 7495, 27114, 27091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16148, 7472, 7495, 27114, 27091, 7473, 7496, 27115, 27092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16149, 7473, 7496, 27115, 27092, 964, 965, 8333, 8332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16150, 805, 806, 6517, 6516, 7474, 7497, 27116, 27093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16151, 7474, 7497, 27116, 27093, 7475, 7498, 27117, 27094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16152, 7475, 7498, 27117, 27094, 7476, 7499, 27118, 27095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16153, 7476, 7499, 27118, 27095, 7477, 7500, 27119, 27096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16154, 7477, 7500, 27119, 27096, 7478, 7501, 27120, 27097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16155, 7478, 7501, 27120, 27097, 7479, 7502, 27121, 27098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16156, 7479, 7502, 27121, 27098, 7480, 7503, 27122, 27099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16157, 7480, 7503, 27122, 27099, 7481, 7504, 27123, 27100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16158, 7481, 7504, 27123, 27100, 7482, 7505, 27124, 27101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16159, 7482, 7505, 27124, 27101, 7483, 7506, 27125, 27102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16160, 7483, 7506, 27125, 27102, 7484, 7507, 27126, 27103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16161, 7484, 7507, 27126, 27103, 7485, 7508, 27127, 27104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16162, 7485, 7508, 27127, 27104, 7486, 7509, 27128, 27105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16163, 7486, 7509, 27128, 27105, 7487, 7510, 27129, 27106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16164, 7487, 7510, 27129, 27106, 7488, 7511, 27130, 27107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16165, 7488, 7511, 27130, 27107, 7489, 7512, 27131, 27108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16166, 7489, 7512, 27131, 27108, 7490, 7513, 27132, 27109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16167, 7490, 7513, 27132, 27109, 7491, 7514, 27133, 27110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16168, 7491, 7514, 27133, 27110, 7492, 7515, 27134, 27111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16169, 7492, 7515, 27134, 27111, 7493, 7516, 27135, 27112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16170, 7493, 7516, 27135, 27112, 7494, 7517, 27136, 27113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16171, 7494, 7517, 27136, 27113, 7495, 7518, 27137, 27114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16172, 7495, 7518, 27137, 27114, 7496, 7519, 27138, 27115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16173, 7496, 7519, 27138, 27115, 965, 966, 8334, 8333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16174, 806, 807, 6518, 6517, 7497, 7520, 27139, 27116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16175, 7497, 7520, 27139, 27116, 7498, 7521, 27140, 27117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16176, 7498, 7521, 27140, 27117, 7499, 7522, 27141, 27118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16177, 7499, 7522, 27141, 27118, 7500, 7523, 27142, 27119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16178, 7500, 7523, 27142, 27119, 7501, 7524, 27143, 27120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16179, 7501, 7524, 27143, 27120, 7502, 7525, 27144, 27121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16180, 7502, 7525, 27144, 27121, 7503, 7526, 27145, 27122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16181, 7503, 7526, 27145, 27122, 7504, 7527, 27146, 27123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16182, 7504, 7527, 27146, 27123, 7505, 7528, 27147, 27124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16183, 7505, 7528, 27147, 27124, 7506, 7529, 27148, 27125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16184, 7506, 7529, 27148, 27125, 7507, 7530, 27149, 27126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16185, 7507, 7530, 27149, 27126, 7508, 7531, 27150, 27127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16186, 7508, 7531, 27150, 27127, 7509, 7532, 27151, 27128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16187, 7509, 7532, 27151, 27128, 7510, 7533, 27152, 27129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16188, 7510, 7533, 27152, 27129, 7511, 7534, 27153, 27130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16189, 7511, 7534, 27153, 27130, 7512, 7535, 27154, 27131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16190, 7512, 7535, 27154, 27131, 7513, 7536, 27155, 27132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16191, 7513, 7536, 27155, 27132, 7514, 7537, 27156, 27133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16192, 7514, 7537, 27156, 27133, 7515, 7538, 27157, 27134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16193, 7515, 7538, 27157, 27134, 7516, 7539, 27158, 27135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16194, 7516, 7539, 27158, 27135, 7517, 7540, 27159, 27136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16195, 7517, 7540, 27159, 27136, 7518, 7541, 27160, 27137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16196, 7518, 7541, 27160, 27137, 7519, 7542, 27161, 27138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16197, 7519, 7542, 27161, 27138, 966, 967, 8335, 8334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16198, 807, 808, 6519, 6518, 7520, 7543, 27162, 27139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16199, 7520, 7543, 27162, 27139, 7521, 7544, 27163, 27140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16200, 7521, 7544, 27163, 27140, 7522, 7545, 27164, 27141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16201, 7522, 7545, 27164, 27141, 7523, 7546, 27165, 27142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16202, 7523, 7546, 27165, 27142, 7524, 7547, 27166, 27143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16203, 7524, 7547, 27166, 27143, 7525, 7548, 27167, 27144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16204, 7525, 7548, 27167, 27144, 7526, 7549, 27168, 27145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16205, 7526, 7549, 27168, 27145, 7527, 7550, 27169, 27146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16206, 7527, 7550, 27169, 27146, 7528, 7551, 27170, 27147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16207, 7528, 7551, 27170, 27147, 7529, 7552, 27171, 27148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16208, 7529, 7552, 27171, 27148, 7530, 7553, 27172, 27149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16209, 7530, 7553, 27172, 27149, 7531, 7554, 27173, 27150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16210, 7531, 7554, 27173, 27150, 7532, 7555, 27174, 27151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16211, 7532, 7555, 27174, 27151, 7533, 7556, 27175, 27152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16212, 7533, 7556, 27175, 27152, 7534, 7557, 27176, 27153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16213, 7534, 7557, 27176, 27153, 7535, 7558, 27177, 27154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16214, 7535, 7558, 27177, 27154, 7536, 7559, 27178, 27155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16215, 7536, 7559, 27178, 27155, 7537, 7560, 27179, 27156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16216, 7537, 7560, 27179, 27156, 7538, 7561, 27180, 27157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16217, 7538, 7561, 27180, 27157, 7539, 7562, 27181, 27158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16218, 7539, 7562, 27181, 27158, 7540, 7563, 27182, 27159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16219, 7540, 7563, 27182, 27159, 7541, 7564, 27183, 27160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16220, 7541, 7564, 27183, 27160, 7542, 7565, 27184, 27161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16221, 7542, 7565, 27184, 27161, 967, 968, 8336, 8335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16222, 808, 809, 6520, 6519, 7543, 7566, 27185, 27162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16223, 7543, 7566, 27185, 27162, 7544, 7567, 27186, 27163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16224, 7544, 7567, 27186, 27163, 7545, 7568, 27187, 27164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16225, 7545, 7568, 27187, 27164, 7546, 7569, 27188, 27165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16226, 7546, 7569, 27188, 27165, 7547, 7570, 27189, 27166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16227, 7547, 7570, 27189, 27166, 7548, 7571, 27190, 27167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16228, 7548, 7571, 27190, 27167, 7549, 7572, 27191, 27168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16229, 7549, 7572, 27191, 27168, 7550, 7573, 27192, 27169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16230, 7550, 7573, 27192, 27169, 7551, 7574, 27193, 27170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16231, 7551, 7574, 27193, 27170, 7552, 7575, 27194, 27171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16232, 7552, 7575, 27194, 27171, 7553, 7576, 27195, 27172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16233, 7553, 7576, 27195, 27172, 7554, 7577, 27196, 27173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16234, 7554, 7577, 27196, 27173, 7555, 7578, 27197, 27174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16235, 7555, 7578, 27197, 27174, 7556, 7579, 27198, 27175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16236, 7556, 7579, 27198, 27175, 7557, 7580, 27199, 27176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16237, 7557, 7580, 27199, 27176, 7558, 7581, 27200, 27177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16238, 7558, 7581, 27200, 27177, 7559, 7582, 27201, 27178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16239, 7559, 7582, 27201, 27178, 7560, 7583, 27202, 27179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16240, 7560, 7583, 27202, 27179, 7561, 7584, 27203, 27180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16241, 7561, 7584, 27203, 27180, 7562, 7585, 27204, 27181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16242, 7562, 7585, 27204, 27181, 7563, 7586, 27205, 27182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16243, 7563, 7586, 27205, 27182, 7564, 7587, 27206, 27183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16244, 7564, 7587, 27206, 27183, 7565, 7588, 27207, 27184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16245, 7565, 7588, 27207, 27184, 968, 969, 8337, 8336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16246, 809, 810, 6521, 6520, 7566, 7589, 27208, 27185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16247, 7566, 7589, 27208, 27185, 7567, 7590, 27209, 27186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16248, 7567, 7590, 27209, 27186, 7568, 7591, 27210, 27187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16249, 7568, 7591, 27210, 27187, 7569, 7592, 27211, 27188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16250, 7569, 7592, 27211, 27188, 7570, 7593, 27212, 27189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16251, 7570, 7593, 27212, 27189, 7571, 7594, 27213, 27190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16252, 7571, 7594, 27213, 27190, 7572, 7595, 27214, 27191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16253, 7572, 7595, 27214, 27191, 7573, 7596, 27215, 27192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16254, 7573, 7596, 27215, 27192, 7574, 7597, 27216, 27193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16255, 7574, 7597, 27216, 27193, 7575, 7598, 27217, 27194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16256, 7575, 7598, 27217, 27194, 7576, 7599, 27218, 27195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16257, 7576, 7599, 27218, 27195, 7577, 7600, 27219, 27196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16258, 7577, 7600, 27219, 27196, 7578, 7601, 27220, 27197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16259, 7578, 7601, 27220, 27197, 7579, 7602, 27221, 27198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16260, 7579, 7602, 27221, 27198, 7580, 7603, 27222, 27199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16261, 7580, 7603, 27222, 27199, 7581, 7604, 27223, 27200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16262, 7581, 7604, 27223, 27200, 7582, 7605, 27224, 27201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16263, 7582, 7605, 27224, 27201, 7583, 7606, 27225, 27202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16264, 7583, 7606, 27225, 27202, 7584, 7607, 27226, 27203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16265, 7584, 7607, 27226, 27203, 7585, 7608, 27227, 27204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16266, 7585, 7608, 27227, 27204, 7586, 7609, 27228, 27205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16267, 7586, 7609, 27228, 27205, 7587, 7610, 27229, 27206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16268, 7587, 7610, 27229, 27206, 7588, 7611, 27230, 27207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16269, 7588, 7611, 27230, 27207, 969, 970, 8338, 8337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16270, 810, 811, 6522, 6521, 7589, 7612, 27231, 27208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16271, 7589, 7612, 27231, 27208, 7590, 7613, 27232, 27209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16272, 7590, 7613, 27232, 27209, 7591, 7614, 27233, 27210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16273, 7591, 7614, 27233, 27210, 7592, 7615, 27234, 27211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16274, 7592, 7615, 27234, 27211, 7593, 7616, 27235, 27212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16275, 7593, 7616, 27235, 27212, 7594, 7617, 27236, 27213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16276, 7594, 7617, 27236, 27213, 7595, 7618, 27237, 27214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16277, 7595, 7618, 27237, 27214, 7596, 7619, 27238, 27215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16278, 7596, 7619, 27238, 27215, 7597, 7620, 27239, 27216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16279, 7597, 7620, 27239, 27216, 7598, 7621, 27240, 27217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16280, 7598, 7621, 27240, 27217, 7599, 7622, 27241, 27218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16281, 7599, 7622, 27241, 27218, 7600, 7623, 27242, 27219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16282, 7600, 7623, 27242, 27219, 7601, 7624, 27243, 27220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16283, 7601, 7624, 27243, 27220, 7602, 7625, 27244, 27221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16284, 7602, 7625, 27244, 27221, 7603, 7626, 27245, 27222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16285, 7603, 7626, 27245, 27222, 7604, 7627, 27246, 27223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16286, 7604, 7627, 27246, 27223, 7605, 7628, 27247, 27224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16287, 7605, 7628, 27247, 27224, 7606, 7629, 27248, 27225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16288, 7606, 7629, 27248, 27225, 7607, 7630, 27249, 27226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16289, 7607, 7630, 27249, 27226, 7608, 7631, 27250, 27227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16290, 7608, 7631, 27250, 27227, 7609, 7632, 27251, 27228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16291, 7609, 7632, 27251, 27228, 7610, 7633, 27252, 27229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16292, 7610, 7633, 27252, 27229, 7611, 7634, 27253, 27230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16293, 7611, 7634, 27253, 27230, 970, 971, 8339, 8338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16294, 811, 812, 6523, 6522, 7612, 7635, 27254, 27231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16295, 7612, 7635, 27254, 27231, 7613, 7636, 27255, 27232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16296, 7613, 7636, 27255, 27232, 7614, 7637, 27256, 27233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16297, 7614, 7637, 27256, 27233, 7615, 7638, 27257, 27234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16298, 7615, 7638, 27257, 27234, 7616, 7639, 27258, 27235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16299, 7616, 7639, 27258, 27235, 7617, 7640, 27259, 27236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16300, 7617, 7640, 27259, 27236, 7618, 7641, 27260, 27237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16301, 7618, 7641, 27260, 27237, 7619, 7642, 27261, 27238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16302, 7619, 7642, 27261, 27238, 7620, 7643, 27262, 27239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16303, 7620, 7643, 27262, 27239, 7621, 7644, 27263, 27240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16304, 7621, 7644, 27263, 27240, 7622, 7645, 27264, 27241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16305, 7622, 7645, 27264, 27241, 7623, 7646, 27265, 27242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16306, 7623, 7646, 27265, 27242, 7624, 7647, 27266, 27243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16307, 7624, 7647, 27266, 27243, 7625, 7648, 27267, 27244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16308, 7625, 7648, 27267, 27244, 7626, 7649, 27268, 27245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16309, 7626, 7649, 27268, 27245, 7627, 7650, 27269, 27246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16310, 7627, 7650, 27269, 27246, 7628, 7651, 27270, 27247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16311, 7628, 7651, 27270, 27247, 7629, 7652, 27271, 27248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16312, 7629, 7652, 27271, 27248, 7630, 7653, 27272, 27249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16313, 7630, 7653, 27272, 27249, 7631, 7654, 27273, 27250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16314, 7631, 7654, 27273, 27250, 7632, 7655, 27274, 27251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16315, 7632, 7655, 27274, 27251, 7633, 7656, 27275, 27252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16316, 7633, 7656, 27275, 27252, 7634, 7657, 27276, 27253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16317, 7634, 7657, 27276, 27253, 971, 972, 8340, 8339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16318, 812, 813, 6524, 6523, 7635, 7658, 27277, 27254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16319, 7635, 7658, 27277, 27254, 7636, 7659, 27278, 27255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16320, 7636, 7659, 27278, 27255, 7637, 7660, 27279, 27256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16321, 7637, 7660, 27279, 27256, 7638, 7661, 27280, 27257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16322, 7638, 7661, 27280, 27257, 7639, 7662, 27281, 27258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16323, 7639, 7662, 27281, 27258, 7640, 7663, 27282, 27259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16324, 7640, 7663, 27282, 27259, 7641, 7664, 27283, 27260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16325, 7641, 7664, 27283, 27260, 7642, 7665, 27284, 27261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16326, 7642, 7665, 27284, 27261, 7643, 7666, 27285, 27262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16327, 7643, 7666, 27285, 27262, 7644, 7667, 27286, 27263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16328, 7644, 7667, 27286, 27263, 7645, 7668, 27287, 27264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16329, 7645, 7668, 27287, 27264, 7646, 7669, 27288, 27265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16330, 7646, 7669, 27288, 27265, 7647, 7670, 27289, 27266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16331, 7647, 7670, 27289, 27266, 7648, 7671, 27290, 27267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16332, 7648, 7671, 27290, 27267, 7649, 7672, 27291, 27268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16333, 7649, 7672, 27291, 27268, 7650, 7673, 27292, 27269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16334, 7650, 7673, 27292, 27269, 7651, 7674, 27293, 27270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16335, 7651, 7674, 27293, 27270, 7652, 7675, 27294, 27271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16336, 7652, 7675, 27294, 27271, 7653, 7676, 27295, 27272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16337, 7653, 7676, 27295, 27272, 7654, 7677, 27296, 27273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16338, 7654, 7677, 27296, 27273, 7655, 7678, 27297, 27274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16339, 7655, 7678, 27297, 27274, 7656, 7679, 27298, 27275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16340, 7656, 7679, 27298, 27275, 7657, 7680, 27299, 27276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16341, 7657, 7680, 27299, 27276, 972, 973, 8341, 8340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16342, 813, 814, 6525, 6524, 7658, 7681, 27300, 27277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16343, 7658, 7681, 27300, 27277, 7659, 7682, 27301, 27278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16344, 7659, 7682, 27301, 27278, 7660, 7683, 27302, 27279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16345, 7660, 7683, 27302, 27279, 7661, 7684, 27303, 27280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16346, 7661, 7684, 27303, 27280, 7662, 7685, 27304, 27281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16347, 7662, 7685, 27304, 27281, 7663, 7686, 27305, 27282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16348, 7663, 7686, 27305, 27282, 7664, 7687, 27306, 27283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16349, 7664, 7687, 27306, 27283, 7665, 7688, 27307, 27284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16350, 7665, 7688, 27307, 27284, 7666, 7689, 27308, 27285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16351, 7666, 7689, 27308, 27285, 7667, 7690, 27309, 27286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16352, 7667, 7690, 27309, 27286, 7668, 7691, 27310, 27287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16353, 7668, 7691, 27310, 27287, 7669, 7692, 27311, 27288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16354, 7669, 7692, 27311, 27288, 7670, 7693, 27312, 27289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16355, 7670, 7693, 27312, 27289, 7671, 7694, 27313, 27290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16356, 7671, 7694, 27313, 27290, 7672, 7695, 27314, 27291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16357, 7672, 7695, 27314, 27291, 7673, 7696, 27315, 27292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16358, 7673, 7696, 27315, 27292, 7674, 7697, 27316, 27293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16359, 7674, 7697, 27316, 27293, 7675, 7698, 27317, 27294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16360, 7675, 7698, 27317, 27294, 7676, 7699, 27318, 27295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16361, 7676, 7699, 27318, 27295, 7677, 7700, 27319, 27296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16362, 7677, 7700, 27319, 27296, 7678, 7701, 27320, 27297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16363, 7678, 7701, 27320, 27297, 7679, 7702, 27321, 27298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16364, 7679, 7702, 27321, 27298, 7680, 7703, 27322, 27299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16365, 7680, 7703, 27322, 27299, 973, 974, 8342, 8341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16366, 814, 815, 6526, 6525, 7681, 7704, 27323, 27300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16367, 7681, 7704, 27323, 27300, 7682, 7705, 27324, 27301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16368, 7682, 7705, 27324, 27301, 7683, 7706, 27325, 27302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16369, 7683, 7706, 27325, 27302, 7684, 7707, 27326, 27303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16370, 7684, 7707, 27326, 27303, 7685, 7708, 27327, 27304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16371, 7685, 7708, 27327, 27304, 7686, 7709, 27328, 27305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16372, 7686, 7709, 27328, 27305, 7687, 7710, 27329, 27306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16373, 7687, 7710, 27329, 27306, 7688, 7711, 27330, 27307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16374, 7688, 7711, 27330, 27307, 7689, 7712, 27331, 27308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16375, 7689, 7712, 27331, 27308, 7690, 7713, 27332, 27309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16376, 7690, 7713, 27332, 27309, 7691, 7714, 27333, 27310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16377, 7691, 7714, 27333, 27310, 7692, 7715, 27334, 27311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16378, 7692, 7715, 27334, 27311, 7693, 7716, 27335, 27312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16379, 7693, 7716, 27335, 27312, 7694, 7717, 27336, 27313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16380, 7694, 7717, 27336, 27313, 7695, 7718, 27337, 27314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16381, 7695, 7718, 27337, 27314, 7696, 7719, 27338, 27315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16382, 7696, 7719, 27338, 27315, 7697, 7720, 27339, 27316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16383, 7697, 7720, 27339, 27316, 7698, 7721, 27340, 27317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16384, 7698, 7721, 27340, 27317, 7699, 7722, 27341, 27318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16385, 7699, 7722, 27341, 27318, 7700, 7723, 27342, 27319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16386, 7700, 7723, 27342, 27319, 7701, 7724, 27343, 27320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16387, 7701, 7724, 27343, 27320, 7702, 7725, 27344, 27321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16388, 7702, 7725, 27344, 27321, 7703, 7726, 27345, 27322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16389, 7703, 7726, 27345, 27322, 974, 975, 8343, 8342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16390, 815, 816, 6527, 6526, 7704, 7727, 27346, 27323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16391, 7704, 7727, 27346, 27323, 7705, 7728, 27347, 27324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16392, 7705, 7728, 27347, 27324, 7706, 7729, 27348, 27325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16393, 7706, 7729, 27348, 27325, 7707, 7730, 27349, 27326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16394, 7707, 7730, 27349, 27326, 7708, 7731, 27350, 27327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16395, 7708, 7731, 27350, 27327, 7709, 7732, 27351, 27328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16396, 7709, 7732, 27351, 27328, 7710, 7733, 27352, 27329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16397, 7710, 7733, 27352, 27329, 7711, 7734, 27353, 27330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16398, 7711, 7734, 27353, 27330, 7712, 7735, 27354, 27331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16399, 7712, 7735, 27354, 27331, 7713, 7736, 27355, 27332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16400, 7713, 7736, 27355, 27332, 7714, 7737, 27356, 27333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16401, 7714, 7737, 27356, 27333, 7715, 7738, 27357, 27334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16402, 7715, 7738, 27357, 27334, 7716, 7739, 27358, 27335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16403, 7716, 7739, 27358, 27335, 7717, 7740, 27359, 27336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16404, 7717, 7740, 27359, 27336, 7718, 7741, 27360, 27337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16405, 7718, 7741, 27360, 27337, 7719, 7742, 27361, 27338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16406, 7719, 7742, 27361, 27338, 7720, 7743, 27362, 27339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16407, 7720, 7743, 27362, 27339, 7721, 7744, 27363, 27340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16408, 7721, 7744, 27363, 27340, 7722, 7745, 27364, 27341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16409, 7722, 7745, 27364, 27341, 7723, 7746, 27365, 27342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16410, 7723, 7746, 27365, 27342, 7724, 7747, 27366, 27343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16411, 7724, 7747, 27366, 27343, 7725, 7748, 27367, 27344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16412, 7725, 7748, 27367, 27344, 7726, 7749, 27368, 27345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16413, 7726, 7749, 27368, 27345, 975, 976, 8344, 8343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16414, 816, 817, 6528, 6527, 7727, 7750, 27369, 27346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16415, 7727, 7750, 27369, 27346, 7728, 7751, 27370, 27347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16416, 7728, 7751, 27370, 27347, 7729, 7752, 27371, 27348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16417, 7729, 7752, 27371, 27348, 7730, 7753, 27372, 27349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16418, 7730, 7753, 27372, 27349, 7731, 7754, 27373, 27350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16419, 7731, 7754, 27373, 27350, 7732, 7755, 27374, 27351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16420, 7732, 7755, 27374, 27351, 7733, 7756, 27375, 27352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16421, 7733, 7756, 27375, 27352, 7734, 7757, 27376, 27353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16422, 7734, 7757, 27376, 27353, 7735, 7758, 27377, 27354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16423, 7735, 7758, 27377, 27354, 7736, 7759, 27378, 27355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16424, 7736, 7759, 27378, 27355, 7737, 7760, 27379, 27356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16425, 7737, 7760, 27379, 27356, 7738, 7761, 27380, 27357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16426, 7738, 7761, 27380, 27357, 7739, 7762, 27381, 27358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16427, 7739, 7762, 27381, 27358, 7740, 7763, 27382, 27359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16428, 7740, 7763, 27382, 27359, 7741, 7764, 27383, 27360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16429, 7741, 7764, 27383, 27360, 7742, 7765, 27384, 27361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16430, 7742, 7765, 27384, 27361, 7743, 7766, 27385, 27362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16431, 7743, 7766, 27385, 27362, 7744, 7767, 27386, 27363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16432, 7744, 7767, 27386, 27363, 7745, 7768, 27387, 27364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16433, 7745, 7768, 27387, 27364, 7746, 7769, 27388, 27365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16434, 7746, 7769, 27388, 27365, 7747, 7770, 27389, 27366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16435, 7747, 7770, 27389, 27366, 7748, 7771, 27390, 27367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16436, 7748, 7771, 27390, 27367, 7749, 7772, 27391, 27368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16437, 7749, 7772, 27391, 27368, 976, 977, 8345, 8344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16438, 817, 818, 6529, 6528, 7750, 7773, 27392, 27369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16439, 7750, 7773, 27392, 27369, 7751, 7774, 27393, 27370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16440, 7751, 7774, 27393, 27370, 7752, 7775, 27394, 27371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16441, 7752, 7775, 27394, 27371, 7753, 7776, 27395, 27372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16442, 7753, 7776, 27395, 27372, 7754, 7777, 27396, 27373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16443, 7754, 7777, 27396, 27373, 7755, 7778, 27397, 27374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16444, 7755, 7778, 27397, 27374, 7756, 7779, 27398, 27375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16445, 7756, 7779, 27398, 27375, 7757, 7780, 27399, 27376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16446, 7757, 7780, 27399, 27376, 7758, 7781, 27400, 27377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16447, 7758, 7781, 27400, 27377, 7759, 7782, 27401, 27378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16448, 7759, 7782, 27401, 27378, 7760, 7783, 27402, 27379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16449, 7760, 7783, 27402, 27379, 7761, 7784, 27403, 27380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16450, 7761, 7784, 27403, 27380, 7762, 7785, 27404, 27381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16451, 7762, 7785, 27404, 27381, 7763, 7786, 27405, 27382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16452, 7763, 7786, 27405, 27382, 7764, 7787, 27406, 27383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16453, 7764, 7787, 27406, 27383, 7765, 7788, 27407, 27384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16454, 7765, 7788, 27407, 27384, 7766, 7789, 27408, 27385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16455, 7766, 7789, 27408, 27385, 7767, 7790, 27409, 27386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16456, 7767, 7790, 27409, 27386, 7768, 7791, 27410, 27387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16457, 7768, 7791, 27410, 27387, 7769, 7792, 27411, 27388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16458, 7769, 7792, 27411, 27388, 7770, 7793, 27412, 27389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16459, 7770, 7793, 27412, 27389, 7771, 7794, 27413, 27390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16460, 7771, 7794, 27413, 27390, 7772, 7795, 27414, 27391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16461, 7772, 7795, 27414, 27391, 977, 978, 8346, 8345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16462, 818, 819, 6530, 6529, 7773, 7796, 27415, 27392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16463, 7773, 7796, 27415, 27392, 7774, 7797, 27416, 27393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16464, 7774, 7797, 27416, 27393, 7775, 7798, 27417, 27394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16465, 7775, 7798, 27417, 27394, 7776, 7799, 27418, 27395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16466, 7776, 7799, 27418, 27395, 7777, 7800, 27419, 27396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16467, 7777, 7800, 27419, 27396, 7778, 7801, 27420, 27397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16468, 7778, 7801, 27420, 27397, 7779, 7802, 27421, 27398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16469, 7779, 7802, 27421, 27398, 7780, 7803, 27422, 27399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16470, 7780, 7803, 27422, 27399, 7781, 7804, 27423, 27400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16471, 7781, 7804, 27423, 27400, 7782, 7805, 27424, 27401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16472, 7782, 7805, 27424, 27401, 7783, 7806, 27425, 27402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16473, 7783, 7806, 27425, 27402, 7784, 7807, 27426, 27403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16474, 7784, 7807, 27426, 27403, 7785, 7808, 27427, 27404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16475, 7785, 7808, 27427, 27404, 7786, 7809, 27428, 27405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16476, 7786, 7809, 27428, 27405, 7787, 7810, 27429, 27406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16477, 7787, 7810, 27429, 27406, 7788, 7811, 27430, 27407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16478, 7788, 7811, 27430, 27407, 7789, 7812, 27431, 27408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16479, 7789, 7812, 27431, 27408, 7790, 7813, 27432, 27409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16480, 7790, 7813, 27432, 27409, 7791, 7814, 27433, 27410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16481, 7791, 7814, 27433, 27410, 7792, 7815, 27434, 27411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16482, 7792, 7815, 27434, 27411, 7793, 7816, 27435, 27412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16483, 7793, 7816, 27435, 27412, 7794, 7817, 27436, 27413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16484, 7794, 7817, 27436, 27413, 7795, 7818, 27437, 27414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16485, 7795, 7818, 27437, 27414, 978, 979, 8347, 8346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16486, 819, 36, 831, 6530, 7796, 934, 8072, 27415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16487, 7796, 934, 8072, 27415, 7797, 935, 8073, 27416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16488, 7797, 935, 8073, 27416, 7798, 936, 8074, 27417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16489, 7798, 936, 8074, 27417, 7799, 937, 8075, 27418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16490, 7799, 937, 8075, 27418, 7800, 938, 8076, 27419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16491, 7800, 938, 8076, 27419, 7801, 939, 8077, 27420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16492, 7801, 939, 8077, 27420, 7802, 940, 8078, 27421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16493, 7802, 940, 8078, 27421, 7803, 941, 8079, 27422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16494, 7803, 941, 8079, 27422, 7804, 942, 8080, 27423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16495, 7804, 942, 8080, 27423, 7805, 943, 8081, 27424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16496, 7805, 943, 8081, 27424, 7806, 944, 8082, 27425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16497, 7806, 944, 8082, 27425, 7807, 945, 8083, 27426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16498, 7807, 945, 8083, 27426, 7808, 946, 8084, 27427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16499, 7808, 946, 8084, 27427, 7809, 947, 8085, 27428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16500, 7809, 947, 8085, 27428, 7810, 948, 8086, 27429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16501, 7810, 948, 8086, 27429, 7811, 949, 8087, 27430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16502, 7811, 949, 8087, 27430, 7812, 950, 8088, 27431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16503, 7812, 950, 8088, 27431, 7813, 951, 8089, 27432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16504, 7813, 951, 8089, 27432, 7814, 952, 8090, 27433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16505, 7814, 952, 8090, 27433, 7815, 953, 8091, 27434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16506, 7815, 953, 8091, 27434, 7816, 954, 8092, 27435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16507, 7816, 954, 8092, 27435, 7817, 955, 8093, 27436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16508, 7817, 955, 8093, 27436, 7818, 956, 8094, 27437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16509, 7818, 956, 8094, 27437, 979, 40, 991, 8347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16510, 820, 6508, 6531, 821, 7819, 26909, 27438, 7842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16511, 7819, 26909, 27438, 7842, 7820, 26910, 27439, 7843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16512, 7820, 26910, 27439, 7843, 7821, 26911, 27440, 7844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16513, 7821, 26911, 27440, 7844, 7822, 26912, 27441, 7845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16514, 7822, 26912, 27441, 7845, 7823, 26913, 27442, 7846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16515, 7823, 26913, 27442, 7846, 7824, 26914, 27443, 7847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16516, 7824, 26914, 27443, 7847, 7825, 26915, 27444, 7848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16517, 7825, 26915, 27444, 7848, 7826, 26916, 27445, 7849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16518, 7826, 26916, 27445, 7849, 7827, 26917, 27446, 7850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16519, 7827, 26917, 27446, 7850, 7828, 26918, 27447, 7851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16520, 7828, 26918, 27447, 7851, 7829, 26919, 27448, 7852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16521, 7829, 26919, 27448, 7852, 7830, 26920, 27449, 7853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16522, 7830, 26920, 27449, 7853, 7831, 26921, 27450, 7854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16523, 7831, 26921, 27450, 7854, 7832, 26922, 27451, 7855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16524, 7832, 26922, 27451, 7855, 7833, 26923, 27452, 7856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16525, 7833, 26923, 27452, 7856, 7834, 26924, 27453, 7857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16526, 7834, 26924, 27453, 7857, 7835, 26925, 27454, 7858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16527, 7835, 26925, 27454, 7858, 7836, 26926, 27455, 7859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16528, 7836, 26926, 27455, 7859, 7837, 26927, 27456, 7860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16529, 7837, 26927, 27456, 7860, 7838, 26928, 27457, 7861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16530, 7838, 26928, 27457, 7861, 7839, 26929, 27458, 7862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16531, 7839, 26929, 27458, 7862, 7840, 26930, 27459, 7863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16532, 7840, 26930, 27459, 7863, 7841, 26931, 27460, 7864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16533, 7841, 26931, 27460, 7864, 980, 8325, 8348, 981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16534, 6508, 6509, 6532, 6531, 26909, 26932, 27461, 27438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16535, 26909, 26932, 27461, 27438, 26910, 26933, 27462, 27439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16536, 26910, 26933, 27462, 27439, 26911, 26934, 27463, 27440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16537, 26911, 26934, 27463, 27440, 26912, 26935, 27464, 27441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16538, 26912, 26935, 27464, 27441, 26913, 26936, 27465, 27442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16539, 26913, 26936, 27465, 27442, 26914, 26937, 27466, 27443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16540, 26914, 26937, 27466, 27443, 26915, 26938, 27467, 27444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16541, 26915, 26938, 27467, 27444, 26916, 26939, 27468, 27445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16542, 26916, 26939, 27468, 27445, 26917, 26940, 27469, 27446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16543, 26917, 26940, 27469, 27446, 26918, 26941, 27470, 27447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16544, 26918, 26941, 27470, 27447, 26919, 26942, 27471, 27448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16545, 26919, 26942, 27471, 27448, 26920, 26943, 27472, 27449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16546, 26920, 26943, 27472, 27449, 26921, 26944, 27473, 27450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16547, 26921, 26944, 27473, 27450, 26922, 26945, 27474, 27451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16548, 26922, 26945, 27474, 27451, 26923, 26946, 27475, 27452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16549, 26923, 26946, 27475, 27452, 26924, 26947, 27476, 27453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16550, 26924, 26947, 27476, 27453, 26925, 26948, 27477, 27454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
16551, 26925, 26948, 27477, 27454, 26926, 26949, 27478, 27455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
