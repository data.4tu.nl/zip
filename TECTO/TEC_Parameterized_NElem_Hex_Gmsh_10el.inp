20676, 0.125, 1.15, 0.33333333333333
20677, 0.125, 1.2, 0.33333333333333
20678, 0.125, 1.25, 0.33333333333333
20679, 0.125, 1.3, 0.33333333333333
20680, 0.125, 0.2, 0.375
20681, 0.125, 0.25, 0.375
20682, 0.125, 0.3, 0.375
20683, 0.125, 0.35, 0.375
20684, 0.125, 0.4, 0.375
20685, 0.125, 0.45, 0.375
20686, 0.125, 0.5, 0.375
20687, 0.125, 0.55, 0.375
20688, 0.125, 0.6, 0.375
20689, 0.125, 0.65, 0.375
20690, 0.125, 0.7, 0.375
20691, 0.125, 0.75, 0.375
20692, 0.125, 0.8, 0.375
20693, 0.125, 0.85, 0.375
20694, 0.125, 0.9, 0.375
20695, 0.125, 0.95, 0.375
20696, 0.125, 1, 0.375
20697, 0.125, 1.05, 0.375
20698, 0.125, 1.1, 0.375
20699, 0.125, 1.15, 0.375
20700, 0.125, 1.2, 0.375
20701, 0.125, 1.25, 0.375
20702, 0.125, 1.3, 0.375
20703, 0.125, 0.2, 0.41666666666667
20704, 0.125, 0.25, 0.41666666666667
20705, 0.125, 0.3, 0.41666666666667
20706, 0.125, 0.35, 0.41666666666667
20707, 0.125, 0.4, 0.41666666666667
20708, 0.125, 0.45, 0.41666666666667
20709, 0.125, 0.5, 0.41666666666667
20710, 0.125, 0.55, 0.41666666666667
20711, 0.125, 0.6, 0.41666666666667
20712, 0.125, 0.65, 0.41666666666667
20713, 0.125, 0.7, 0.41666666666667
20714, 0.125, 0.75, 0.41666666666667
20715, 0.125, 0.8, 0.41666666666667
20716, 0.125, 0.85, 0.41666666666667
20717, 0.125, 0.9, 0.41666666666667
20718, 0.125, 0.95, 0.41666666666667
20719, 0.125, 1, 0.41666666666667
20720, 0.125, 1.05, 0.41666666666667
20721, 0.125, 1.1, 0.41666666666667
20722, 0.125, 1.15, 0.41666666666667
20723, 0.125, 1.2, 0.41666666666667
20724, 0.125, 1.25, 0.41666666666667
20725, 0.125, 1.3, 0.41666666666667
20726, 0.125, 0.2, 0.45833333333333
20727, 0.125, 0.25, 0.45833333333333
20728, 0.125, 0.3, 0.45833333333333
20729, 0.125, 0.35, 0.45833333333333
20730, 0.125, 0.4, 0.45833333333333
20731, 0.125, 0.45, 0.45833333333333
20732, 0.125, 0.5, 0.45833333333333
20733, 0.125, 0.55, 0.45833333333333
20734, 0.125, 0.6, 0.45833333333333
20735, 0.125, 0.65, 0.45833333333333
20736, 0.125, 0.7, 0.45833333333333
20737, 0.125, 0.75, 0.45833333333333
20738, 0.125, 0.8, 0.45833333333333
20739, 0.125, 0.85, 0.45833333333333
20740, 0.125, 0.9, 0.45833333333333
20741, 0.125, 0.95, 0.45833333333333
20742, 0.125, 1, 0.45833333333333
20743, 0.125, 1.05, 0.45833333333333
20744, 0.125, 1.1, 0.45833333333333
20745, 0.125, 1.15, 0.45833333333333
20746, 0.125, 1.2, 0.45833333333333
20747, 0.125, 1.25, 0.45833333333333
20748, 0.125, 1.3, 0.45833333333333
20749, 0.16666666666667, 0.2, 0.041666666666667
20750, 0.16666666666667, 0.25, 0.041666666666667
20751, 0.16666666666667, 0.3, 0.041666666666667
20752, 0.16666666666667, 0.35, 0.041666666666667
20753, 0.16666666666667, 0.4, 0.041666666666667
20754, 0.16666666666667, 0.45, 0.041666666666667
20755, 0.16666666666667, 0.5, 0.041666666666667
20756, 0.16666666666667, 0.55, 0.041666666666667
20757, 0.16666666666667, 0.6, 0.041666666666667
20758, 0.16666666666667, 0.65, 0.041666666666667
20759, 0.16666666666667, 0.7, 0.041666666666667
20760, 0.16666666666667, 0.75, 0.041666666666667
20761, 0.16666666666667, 0.8, 0.041666666666667
20762, 0.16666666666667, 0.85, 0.041666666666667
20763, 0.16666666666667, 0.9, 0.041666666666667
20764, 0.16666666666667, 0.95, 0.041666666666667
20765, 0.16666666666667, 1, 0.041666666666667
20766, 0.16666666666667, 1.05, 0.041666666666667
20767, 0.16666666666667, 1.1, 0.041666666666667
20768, 0.16666666666667, 1.15, 0.041666666666667
20769, 0.16666666666667, 1.2, 0.041666666666667
20770, 0.16666666666667, 1.25, 0.041666666666667
20771, 0.16666666666667, 1.3, 0.041666666666667
20772, 0.16666666666667, 0.2, 0.083333333333333
20773, 0.16666666666667, 0.25, 0.083333333333333
20774, 0.16666666666667, 0.3, 0.083333333333333
20775, 0.16666666666667, 0.35, 0.083333333333333
20776, 0.16666666666667, 0.4, 0.083333333333333
20777, 0.16666666666667, 0.45, 0.083333333333333
20778, 0.16666666666667, 0.5, 0.083333333333333
20779, 0.16666666666667, 0.55, 0.083333333333333
20780, 0.16666666666667, 0.6, 0.083333333333333
20781, 0.16666666666667, 0.65, 0.083333333333333
20782, 0.16666666666667, 0.7, 0.083333333333333
20783, 0.16666666666667, 0.75, 0.083333333333333
20784, 0.16666666666667, 0.8, 0.083333333333333
20785, 0.16666666666667, 0.85, 0.083333333333333
20786, 0.16666666666667, 0.9, 0.083333333333333
20787, 0.16666666666667, 0.95, 0.083333333333333
20788, 0.16666666666667, 1, 0.083333333333333
20789, 0.16666666666667, 1.05, 0.083333333333333
20790, 0.16666666666667, 1.1, 0.083333333333333
20791, 0.16666666666667, 1.15, 0.083333333333333
20792, 0.16666666666667, 1.2, 0.083333333333333
20793, 0.16666666666667, 1.25, 0.083333333333333
20794, 0.16666666666667, 1.3, 0.083333333333333
20795, 0.16666666666667, 0.2, 0.125
20796, 0.16666666666667, 0.25, 0.125
20797, 0.16666666666667, 0.3, 0.125
20798, 0.16666666666667, 0.35, 0.125
20799, 0.16666666666667, 0.4, 0.125
20800, 0.16666666666667, 0.45, 0.125
20801, 0.16666666666667, 0.5, 0.125
20802, 0.16666666666667, 0.55, 0.125
20803, 0.16666666666667, 0.6, 0.125
20804, 0.16666666666667, 0.65, 0.125
20805, 0.16666666666667, 0.7, 0.125
20806, 0.16666666666667, 0.75, 0.125
20807, 0.16666666666667, 0.8, 0.125
20808, 0.16666666666667, 0.85, 0.125
20809, 0.16666666666667, 0.9, 0.125
20810, 0.16666666666667, 0.95, 0.125
20811, 0.16666666666667, 1, 0.125
20812, 0.16666666666667, 1.05, 0.125
20813, 0.16666666666667, 1.1, 0.125
20814, 0.16666666666667, 1.15, 0.125
20815, 0.16666666666667, 1.2, 0.125
20816, 0.16666666666667, 1.25, 0.125
20817, 0.16666666666667, 1.3, 0.125
20818, 0.16666666666667, 0.2, 0.16666666666667
20819, 0.16666666666667, 0.25, 0.16666666666667
20820, 0.16666666666667, 0.3, 0.16666666666667
20821, 0.16666666666667, 0.35, 0.16666666666667
20822, 0.16666666666667, 0.4, 0.16666666666667
20823, 0.16666666666667, 0.45, 0.16666666666667
20824, 0.16666666666667, 0.5, 0.16666666666667
20825, 0.16666666666667, 0.55, 0.16666666666667
20826, 0.16666666666667, 0.6, 0.16666666666667
20827, 0.16666666666667, 0.65, 0.16666666666667
20828, 0.16666666666667, 0.7, 0.16666666666667
20829, 0.16666666666667, 0.75, 0.16666666666667
20830, 0.16666666666667, 0.8, 0.16666666666667
20831, 0.16666666666667, 0.85, 0.16666666666667
20832, 0.16666666666667, 0.9, 0.16666666666667
20833, 0.16666666666667, 0.95, 0.16666666666667
20834, 0.16666666666667, 1, 0.16666666666667
20835, 0.16666666666667, 1.05, 0.16666666666667
20836, 0.16666666666667, 1.1, 0.16666666666667
20837, 0.16666666666667, 1.15, 0.16666666666667
20838, 0.16666666666667, 1.2, 0.16666666666667
20839, 0.16666666666667, 1.25, 0.16666666666667
20840, 0.16666666666667, 1.3, 0.16666666666667
20841, 0.16666666666667, 0.2, 0.20833333333333
20842, 0.16666666666667, 0.25, 0.20833333333333
20843, 0.16666666666667, 0.3, 0.20833333333333
20844, 0.16666666666667, 0.35, 0.20833333333333
20845, 0.16666666666667, 0.4, 0.20833333333333
20846, 0.16666666666667, 0.45, 0.20833333333333
20847, 0.16666666666667, 0.5, 0.20833333333333
20848, 0.16666666666667, 0.55, 0.20833333333333
20849, 0.16666666666667, 0.6, 0.20833333333333
20850, 0.16666666666667, 0.65, 0.20833333333333
20851, 0.16666666666667, 0.7, 0.20833333333333
20852, 0.16666666666667, 0.75, 0.20833333333333
20853, 0.16666666666667, 0.8, 0.20833333333333
20854, 0.16666666666667, 0.85, 0.20833333333333
20855, 0.16666666666667, 0.9, 0.20833333333333
20856, 0.16666666666667, 0.95, 0.20833333333333
20857, 0.16666666666667, 1, 0.20833333333333
20858, 0.16666666666667, 1.05, 0.20833333333333
20859, 0.16666666666667, 1.1, 0.20833333333333
20860, 0.16666666666667, 1.15, 0.20833333333333
20861, 0.16666666666667, 1.2, 0.20833333333333
20862, 0.16666666666667, 1.25, 0.20833333333333
20863, 0.16666666666667, 1.3, 0.20833333333333
20864, 0.16666666666667, 0.2, 0.25
20865, 0.16666666666667, 0.25, 0.25
20866, 0.16666666666667, 0.3, 0.25
20867, 0.16666666666667, 0.35, 0.25
20868, 0.16666666666667, 0.4, 0.25
20869, 0.16666666666667, 0.45, 0.25
20870, 0.16666666666667, 0.5, 0.25
20871, 0.16666666666667, 0.55, 0.25
20872, 0.16666666666667, 0.6, 0.25
20873, 0.16666666666667, 0.65, 0.25
20874, 0.16666666666667, 0.7, 0.25
20875, 0.16666666666667, 0.75, 0.25
20876, 0.16666666666667, 0.8, 0.25
20877, 0.16666666666667, 0.85, 0.25
20878, 0.16666666666667, 0.9, 0.25
20879, 0.16666666666667, 0.95, 0.25
20880, 0.16666666666667, 1, 0.25
20881, 0.16666666666667, 1.05, 0.25
20882, 0.16666666666667, 1.1, 0.25
20883, 0.16666666666667, 1.15, 0.25
20884, 0.16666666666667, 1.2, 0.25
20885, 0.16666666666667, 1.25, 0.25
20886, 0.16666666666667, 1.3, 0.25
20887, 0.16666666666667, 0.2, 0.29166666666667
20888, 0.16666666666667, 0.25, 0.29166666666667
20889, 0.16666666666667, 0.3, 0.29166666666667
20890, 0.16666666666667, 0.35, 0.29166666666667
20891, 0.16666666666667, 0.4, 0.29166666666667
20892, 0.16666666666667, 0.45, 0.29166666666667
20893, 0.16666666666667, 0.5, 0.29166666666667
20894, 0.16666666666667, 0.55, 0.29166666666667
20895, 0.16666666666667, 0.6, 0.29166666666667
20896, 0.16666666666667, 0.65, 0.29166666666667
20897, 0.16666666666667, 0.7, 0.29166666666667
20898, 0.16666666666667, 0.75, 0.29166666666667
20899, 0.16666666666667, 0.8, 0.29166666666667
20900, 0.16666666666667, 0.85, 0.29166666666667
20901, 0.16666666666667, 0.9, 0.29166666666667
20902, 0.16666666666667, 0.95, 0.29166666666667
20903, 0.16666666666667, 1, 0.29166666666667
20904, 0.16666666666667, 1.05, 0.29166666666667
20905, 0.16666666666667, 1.1, 0.29166666666667
20906, 0.16666666666667, 1.15, 0.29166666666667
20907, 0.16666666666667, 1.2, 0.29166666666667
20908, 0.16666666666667, 1.25, 0.29166666666667
20909, 0.16666666666667, 1.3, 0.29166666666667
20910, 0.16666666666667, 0.2, 0.33333333333333
20911, 0.16666666666667, 0.25, 0.33333333333333
20912, 0.16666666666667, 0.3, 0.33333333333333
20913, 0.16666666666667, 0.35, 0.33333333333333
20914, 0.16666666666667, 0.4, 0.33333333333333
20915, 0.16666666666667, 0.45, 0.33333333333333
20916, 0.16666666666667, 0.5, 0.33333333333333
20917, 0.16666666666667, 0.55, 0.33333333333333
20918, 0.16666666666667, 0.6, 0.33333333333333
20919, 0.16666666666667, 0.65, 0.33333333333333
20920, 0.16666666666667, 0.7, 0.33333333333333
20921, 0.16666666666667, 0.75, 0.33333333333333
20922, 0.16666666666667, 0.8, 0.33333333333333
20923, 0.16666666666667, 0.85, 0.33333333333333
20924, 0.16666666666667, 0.9, 0.33333333333333
20925, 0.16666666666667, 0.95, 0.33333333333333
20926, 0.16666666666667, 1, 0.33333333333333
20927, 0.16666666666667, 1.05, 0.33333333333333
20928, 0.16666666666667, 1.1, 0.33333333333333
20929, 0.16666666666667, 1.15, 0.33333333333333
20930, 0.16666666666667, 1.2, 0.33333333333333
20931, 0.16666666666667, 1.25, 0.33333333333333
20932, 0.16666666666667, 1.3, 0.33333333333333
20933, 0.16666666666667, 0.2, 0.375
20934, 0.16666666666667, 0.25, 0.375
20935, 0.16666666666667, 0.3, 0.375
20936, 0.16666666666667, 0.35, 0.375
20937, 0.16666666666667, 0.4, 0.375
20938, 0.16666666666667, 0.45, 0.375
20939, 0.16666666666667, 0.5, 0.375
20940, 0.16666666666667, 0.55, 0.375
20941, 0.16666666666667, 0.6, 0.375
20942, 0.16666666666667, 0.65, 0.375
20943, 0.16666666666667, 0.7, 0.375
20944, 0.16666666666667, 0.75, 0.375
20945, 0.16666666666667, 0.8, 0.375
20946, 0.16666666666667, 0.85, 0.375
20947, 0.16666666666667, 0.9, 0.375
20948, 0.16666666666667, 0.95, 0.375
20949, 0.16666666666667, 1, 0.375
20950, 0.16666666666667, 1.05, 0.375
20951, 0.16666666666667, 1.1, 0.375
20952, 0.16666666666667, 1.15, 0.375
20953, 0.16666666666667, 1.2, 0.375
20954, 0.16666666666667, 1.25, 0.375
20955, 0.16666666666667, 1.3, 0.375
20956, 0.16666666666667, 0.2, 0.41666666666667
20957, 0.16666666666667, 0.25, 0.41666666666667
20958, 0.16666666666667, 0.3, 0.41666666666667
20959, 0.16666666666667, 0.35, 0.41666666666667
20960, 0.16666666666667, 0.4, 0.41666666666667
20961, 0.16666666666667, 0.45, 0.41666666666667
20962, 0.16666666666667, 0.5, 0.41666666666667
20963, 0.16666666666667, 0.55, 0.41666666666667
20964, 0.16666666666667, 0.6, 0.41666666666667
20965, 0.16666666666667, 0.65, 0.41666666666667
20966, 0.16666666666667, 0.7, 0.41666666666667
20967, 0.16666666666667, 0.75, 0.41666666666667
20968, 0.16666666666667, 0.8, 0.41666666666667
20969, 0.16666666666667, 0.85, 0.41666666666667
20970, 0.16666666666667, 0.9, 0.41666666666667
20971, 0.16666666666667, 0.95, 0.41666666666667
20972, 0.16666666666667, 1, 0.41666666666667
20973, 0.16666666666667, 1.05, 0.41666666666667
20974, 0.16666666666667, 1.1, 0.41666666666667
20975, 0.16666666666667, 1.15, 0.41666666666667
20976, 0.16666666666667, 1.2, 0.41666666666667
20977, 0.16666666666667, 1.25, 0.41666666666667
20978, 0.16666666666667, 1.3, 0.41666666666667
20979, 0.16666666666667, 0.2, 0.45833333333333
20980, 0.16666666666667, 0.25, 0.45833333333333
20981, 0.16666666666667, 0.3, 0.45833333333333
20982, 0.16666666666667, 0.35, 0.45833333333333
20983, 0.16666666666667, 0.4, 0.45833333333333
20984, 0.16666666666667, 0.45, 0.45833333333333
20985, 0.16666666666667, 0.5, 0.45833333333333
20986, 0.16666666666667, 0.55, 0.45833333333333
20987, 0.16666666666667, 0.6, 0.45833333333333
20988, 0.16666666666667, 0.65, 0.45833333333333
20989, 0.16666666666667, 0.7, 0.45833333333333
20990, 0.16666666666667, 0.75, 0.45833333333333
20991, 0.16666666666667, 0.8, 0.45833333333333
20992, 0.16666666666667, 0.85, 0.45833333333333
20993, 0.16666666666667, 0.9, 0.45833333333333
20994, 0.16666666666667, 0.95, 0.45833333333333
20995, 0.16666666666667, 1, 0.45833333333333
20996, 0.16666666666667, 1.05, 0.45833333333333
20997, 0.16666666666667, 1.1, 0.45833333333333
20998, 0.16666666666667, 1.15, 0.45833333333333
20999, 0.16666666666667, 1.2, 0.45833333333333
21000, 0.16666666666667, 1.25, 0.45833333333333
21001, 0.16666666666667, 1.3, 0.45833333333333
21002, 0.20833333333333, 0.2, 0.041666666666667
21003, 0.20833333333333, 0.25, 0.041666666666667
21004, 0.20833333333333, 0.3, 0.041666666666667
21005, 0.20833333333333, 0.35, 0.041666666666667
21006, 0.20833333333333, 0.4, 0.041666666666667
21007, 0.20833333333333, 0.45, 0.041666666666667
21008, 0.20833333333333, 0.5, 0.041666666666667
21009, 0.20833333333333, 0.55, 0.041666666666667
21010, 0.20833333333333, 0.6, 0.041666666666667
21011, 0.20833333333333, 0.65, 0.041666666666667
21012, 0.20833333333333, 0.7, 0.041666666666667
21013, 0.20833333333333, 0.75, 0.041666666666667
21014, 0.20833333333333, 0.8, 0.041666666666667
21015, 0.20833333333333, 0.85, 0.041666666666667
21016, 0.20833333333333, 0.9, 0.041666666666667
21017, 0.20833333333333, 0.95, 0.041666666666667
21018, 0.20833333333333, 1, 0.041666666666667
21019, 0.20833333333333, 1.05, 0.041666666666667
21020, 0.20833333333333, 1.1, 0.041666666666667
21021, 0.20833333333333, 1.15, 0.041666666666667
21022, 0.20833333333333, 1.2, 0.041666666666667
21023, 0.20833333333333, 1.25, 0.041666666666667
21024, 0.20833333333333, 1.3, 0.041666666666667
21025, 0.20833333333333, 0.2, 0.083333333333333
21026, 0.20833333333333, 0.25, 0.083333333333333
21027, 0.20833333333333, 0.3, 0.083333333333333
21028, 0.20833333333333, 0.35, 0.083333333333333
21029, 0.20833333333333, 0.4, 0.083333333333333
21030, 0.20833333333333, 0.45, 0.083333333333333
21031, 0.20833333333333, 0.5, 0.083333333333333
21032, 0.20833333333333, 0.55, 0.083333333333333
21033, 0.20833333333333, 0.6, 0.083333333333333
21034, 0.20833333333333, 0.65, 0.083333333333333
21035, 0.20833333333333, 0.7, 0.083333333333333
21036, 0.20833333333333, 0.75, 0.083333333333333
21037, 0.20833333333333, 0.8, 0.083333333333333
21038, 0.20833333333333, 0.85, 0.083333333333333
21039, 0.20833333333333, 0.9, 0.083333333333333
21040, 0.20833333333333, 0.95, 0.083333333333333
21041, 0.20833333333333, 1, 0.083333333333333
21042, 0.20833333333333, 1.05, 0.083333333333333
21043, 0.20833333333333, 1.1, 0.083333333333333
21044, 0.20833333333333, 1.15, 0.083333333333333
21045, 0.20833333333333, 1.2, 0.083333333333333
21046, 0.20833333333333, 1.25, 0.083333333333333
21047, 0.20833333333333, 1.3, 0.083333333333333
21048, 0.20833333333333, 0.2, 0.125
21049, 0.20833333333333, 0.25, 0.125
21050, 0.20833333333333, 0.3, 0.125
21051, 0.20833333333333, 0.35, 0.125
21052, 0.20833333333333, 0.4, 0.125
21053, 0.20833333333333, 0.45, 0.125
21054, 0.20833333333333, 0.5, 0.125
21055, 0.20833333333333, 0.55, 0.125
21056, 0.20833333333333, 0.6, 0.125
21057, 0.20833333333333, 0.65, 0.125
21058, 0.20833333333333, 0.7, 0.125
21059, 0.20833333333333, 0.75, 0.125
21060, 0.20833333333333, 0.8, 0.125
21061, 0.20833333333333, 0.85, 0.125
21062, 0.20833333333333, 0.9, 0.125
21063, 0.20833333333333, 0.95, 0.125
21064, 0.20833333333333, 1, 0.125
21065, 0.20833333333333, 1.05, 0.125
21066, 0.20833333333333, 1.1, 0.125
21067, 0.20833333333333, 1.15, 0.125
21068, 0.20833333333333, 1.2, 0.125
21069, 0.20833333333333, 1.25, 0.125
21070, 0.20833333333333, 1.3, 0.125
21071, 0.20833333333333, 0.2, 0.16666666666667
21072, 0.20833333333333, 0.25, 0.16666666666667
21073, 0.20833333333333, 0.3, 0.16666666666667
21074, 0.20833333333333, 0.35, 0.16666666666667
21075, 0.20833333333333, 0.4, 0.16666666666667
21076, 0.20833333333333, 0.45, 0.16666666666667
21077, 0.20833333333333, 0.5, 0.16666666666667
21078, 0.20833333333333, 0.55, 0.16666666666667
21079, 0.20833333333333, 0.6, 0.16666666666667
21080, 0.20833333333333, 0.65, 0.16666666666667
21081, 0.20833333333333, 0.7, 0.16666666666667
21082, 0.20833333333333, 0.75, 0.16666666666667
21083, 0.20833333333333, 0.8, 0.16666666666667
21084, 0.20833333333333, 0.85, 0.16666666666667
21085, 0.20833333333333, 0.9, 0.16666666666667
21086, 0.20833333333333, 0.95, 0.16666666666667
21087, 0.20833333333333, 1, 0.16666666666667
21088, 0.20833333333333, 1.05, 0.16666666666667
21089, 0.20833333333333, 1.1, 0.16666666666667
21090, 0.20833333333333, 1.15, 0.16666666666667
21091, 0.20833333333333, 1.2, 0.16666666666667
21092, 0.20833333333333, 1.25, 0.16666666666667
21093, 0.20833333333333, 1.3, 0.16666666666667
21094, 0.20833333333333, 0.2, 0.20833333333333
21095, 0.20833333333333, 0.25, 0.20833333333333
21096, 0.20833333333333, 0.3, 0.20833333333333
21097, 0.20833333333333, 0.35, 0.20833333333333
21098, 0.20833333333333, 0.4, 0.20833333333333
21099, 0.20833333333333, 0.45, 0.20833333333333
21100, 0.20833333333333, 0.5, 0.20833333333333
21101, 0.20833333333333, 0.55, 0.20833333333333
21102, 0.20833333333333, 0.6, 0.20833333333333
21103, 0.20833333333333, 0.65, 0.20833333333333
21104, 0.20833333333333, 0.7, 0.20833333333333
21105, 0.20833333333333, 0.75, 0.20833333333333
21106, 0.20833333333333, 0.8, 0.20833333333333
21107, 0.20833333333333, 0.85, 0.20833333333333
21108, 0.20833333333333, 0.9, 0.20833333333333
21109, 0.20833333333333, 0.95, 0.20833333333333
21110, 0.20833333333333, 1, 0.20833333333333
21111, 0.20833333333333, 1.05, 0.20833333333333
21112, 0.20833333333333, 1.1, 0.20833333333333
21113, 0.20833333333333, 1.15, 0.20833333333333
21114, 0.20833333333333, 1.2, 0.20833333333333
21115, 0.20833333333333, 1.25, 0.20833333333333
21116, 0.20833333333333, 1.3, 0.20833333333333
21117, 0.20833333333333, 0.2, 0.25
21118, 0.20833333333333, 0.25, 0.25
21119, 0.20833333333333, 0.3, 0.25
21120, 0.20833333333333, 0.35, 0.25
21121, 0.20833333333333, 0.4, 0.25
21122, 0.20833333333333, 0.45, 0.25
21123, 0.20833333333333, 0.5, 0.25
21124, 0.20833333333333, 0.55, 0.25
21125, 0.20833333333333, 0.6, 0.25
21126, 0.20833333333333, 0.65, 0.25
21127, 0.20833333333333, 0.7, 0.25
21128, 0.20833333333333, 0.75, 0.25
21129, 0.20833333333333, 0.8, 0.25
21130, 0.20833333333333, 0.85, 0.25
21131, 0.20833333333333, 0.9, 0.25
21132, 0.20833333333333, 0.95, 0.25
21133, 0.20833333333333, 1, 0.25
21134, 0.20833333333333, 1.05, 0.25
21135, 0.20833333333333, 1.1, 0.25
21136, 0.20833333333333, 1.15, 0.25
21137, 0.20833333333333, 1.2, 0.25
21138, 0.20833333333333, 1.25, 0.25
21139, 0.20833333333333, 1.3, 0.25
21140, 0.20833333333333, 0.2, 0.29166666666667
21141, 0.20833333333333, 0.25, 0.29166666666667
21142, 0.20833333333333, 0.3, 0.29166666666667
21143, 0.20833333333333, 0.35, 0.29166666666667
21144, 0.20833333333333, 0.4, 0.29166666666667
21145, 0.20833333333333, 0.45, 0.29166666666667
21146, 0.20833333333333, 0.5, 0.29166666666667
21147, 0.20833333333333, 0.55, 0.29166666666667
21148, 0.20833333333333, 0.6, 0.29166666666667
21149, 0.20833333333333, 0.65, 0.29166666666667
21150, 0.20833333333333, 0.7, 0.29166666666667
21151, 0.20833333333333, 0.75, 0.29166666666667
21152, 0.20833333333333, 0.8, 0.29166666666667
21153, 0.20833333333333, 0.85, 0.29166666666667
21154, 0.20833333333333, 0.9, 0.29166666666667
21155, 0.20833333333333, 0.95, 0.29166666666667
21156, 0.20833333333333, 1, 0.29166666666667
21157, 0.20833333333333, 1.05, 0.29166666666667
21158, 0.20833333333333, 1.1, 0.29166666666667
21159, 0.20833333333333, 1.15, 0.29166666666667
21160, 0.20833333333333, 1.2, 0.29166666666667
21161, 0.20833333333333, 1.25, 0.29166666666667
21162, 0.20833333333333, 1.3, 0.29166666666667
21163, 0.20833333333333, 0.2, 0.33333333333333
21164, 0.20833333333333, 0.25, 0.33333333333333
21165, 0.20833333333333, 0.3, 0.33333333333333
21166, 0.20833333333333, 0.35, 0.33333333333333
21167, 0.20833333333333, 0.4, 0.33333333333333
21168, 0.20833333333333, 0.45, 0.33333333333333
21169, 0.20833333333333, 0.5, 0.33333333333333
21170, 0.20833333333333, 0.55, 0.33333333333333
21171, 0.20833333333333, 0.6, 0.33333333333333
21172, 0.20833333333333, 0.65, 0.33333333333333
21173, 0.20833333333333, 0.7, 0.33333333333333
21174, 0.20833333333333, 0.75, 0.33333333333333
21175, 0.20833333333333, 0.8, 0.33333333333333
21176, 0.20833333333333, 0.85, 0.33333333333333
21177, 0.20833333333333, 0.9, 0.33333333333333
21178, 0.20833333333333, 0.95, 0.33333333333333
21179, 0.20833333333333, 1, 0.33333333333333
21180, 0.20833333333333, 1.05, 0.33333333333333
21181, 0.20833333333333, 1.1, 0.33333333333333
21182, 0.20833333333333, 1.15, 0.33333333333333
21183, 0.20833333333333, 1.2, 0.33333333333333
21184, 0.20833333333333, 1.25, 0.33333333333333
21185, 0.20833333333333, 1.3, 0.33333333333333
21186, 0.20833333333333, 0.2, 0.375
21187, 0.20833333333333, 0.25, 0.375
21188, 0.20833333333333, 0.3, 0.375
21189, 0.20833333333333, 0.35, 0.375
21190, 0.20833333333333, 0.4, 0.375
21191, 0.20833333333333, 0.45, 0.375
21192, 0.20833333333333, 0.5, 0.375
21193, 0.20833333333333, 0.55, 0.375
21194, 0.20833333333333, 0.6, 0.375
21195, 0.20833333333333, 0.65, 0.375
21196, 0.20833333333333, 0.7, 0.375
21197, 0.20833333333333, 0.75, 0.375
21198, 0.20833333333333, 0.8, 0.375
21199, 0.20833333333333, 0.85, 0.375
21200, 0.20833333333333, 0.9, 0.375
21201, 0.20833333333333, 0.95, 0.375
21202, 0.20833333333333, 1, 0.375
21203, 0.20833333333333, 1.05, 0.375
21204, 0.20833333333333, 1.1, 0.375
21205, 0.20833333333333, 1.15, 0.375
21206, 0.20833333333333, 1.2, 0.375
21207, 0.20833333333333, 1.25, 0.375
21208, 0.20833333333333, 1.3, 0.375
21209, 0.20833333333333, 0.2, 0.41666666666667
21210, 0.20833333333333, 0.25, 0.41666666666667
21211, 0.20833333333333, 0.3, 0.41666666666667
21212, 0.20833333333333, 0.35, 0.41666666666667
21213, 0.20833333333333, 0.4, 0.41666666666667
21214, 0.20833333333333, 0.45, 0.41666666666667
21215, 0.20833333333333, 0.5, 0.41666666666667
21216, 0.20833333333333, 0.55, 0.41666666666667
21217, 0.20833333333333, 0.6, 0.41666666666667
21218, 0.20833333333333, 0.65, 0.41666666666667
21219, 0.20833333333333, 0.7, 0.41666666666667
21220, 0.20833333333333, 0.75, 0.41666666666667
21221, 0.20833333333333, 0.8, 0.41666666666667
21222, 0.20833333333333, 0.85, 0.41666666666667
21223, 0.20833333333333, 0.9, 0.41666666666667
21224, 0.20833333333333, 0.95, 0.41666666666667
21225, 0.20833333333333, 1, 0.41666666666667
21226, 0.20833333333333, 1.05, 0.41666666666667
21227, 0.20833333333333, 1.1, 0.41666666666667
21228, 0.20833333333333, 1.15, 0.41666666666667
21229, 0.20833333333333, 1.2, 0.41666666666667
21230, 0.20833333333333, 1.25, 0.41666666666667
21231, 0.20833333333333, 1.3, 0.41666666666667
21232, 0.20833333333333, 0.2, 0.45833333333333
21233, 0.20833333333333, 0.25, 0.45833333333333
21234, 0.20833333333333, 0.3, 0.45833333333333
21235, 0.20833333333333, 0.35, 0.45833333333333
21236, 0.20833333333333, 0.4, 0.45833333333333
21237, 0.20833333333333, 0.45, 0.45833333333333
21238, 0.20833333333333, 0.5, 0.45833333333333
21239, 0.20833333333333, 0.55, 0.45833333333333
21240, 0.20833333333333, 0.6, 0.45833333333333
21241, 0.20833333333333, 0.65, 0.45833333333333
21242, 0.20833333333333, 0.7, 0.45833333333333
21243, 0.20833333333333, 0.75, 0.45833333333333
21244, 0.20833333333333, 0.8, 0.45833333333333
21245, 0.20833333333333, 0.85, 0.45833333333333
21246, 0.20833333333333, 0.9, 0.45833333333333
21247, 0.20833333333333, 0.95, 0.45833333333333
21248, 0.20833333333333, 1, 0.45833333333333
21249, 0.20833333333333, 1.05, 0.45833333333333
21250, 0.20833333333333, 1.1, 0.45833333333333
21251, 0.20833333333333, 1.15, 0.45833333333333
21252, 0.20833333333333, 1.2, 0.45833333333333
21253, 0.20833333333333, 1.25, 0.45833333333333
21254, 0.20833333333333, 1.3, 0.45833333333333
21255, 0.25, 0.2, 0.041666666666667
21256, 0.25, 0.25, 0.041666666666667
21257, 0.25, 0.3, 0.041666666666667
21258, 0.25, 0.35, 0.041666666666667
21259, 0.25, 0.4, 0.041666666666667
21260, 0.25, 0.45, 0.041666666666667
21261, 0.25, 0.5, 0.041666666666667
21262, 0.25, 0.55, 0.041666666666667
21263, 0.25, 0.6, 0.041666666666667
21264, 0.25, 0.65, 0.041666666666667
21265, 0.25, 0.7, 0.041666666666667
21266, 0.25, 0.75, 0.041666666666667
21267, 0.25, 0.8, 0.041666666666667
21268, 0.25, 0.85, 0.041666666666667
21269, 0.25, 0.9, 0.041666666666667
21270, 0.25, 0.95, 0.041666666666667
21271, 0.25, 1, 0.041666666666667
21272, 0.25, 1.05, 0.041666666666667
21273, 0.25, 1.1, 0.041666666666667
21274, 0.25, 1.15, 0.041666666666667
21275, 0.25, 1.2, 0.041666666666667
21276, 0.25, 1.25, 0.041666666666667
21277, 0.25, 1.3, 0.041666666666667
21278, 0.25, 0.2, 0.083333333333333
21279, 0.25, 0.25, 0.083333333333333
21280, 0.25, 0.3, 0.083333333333333
21281, 0.25, 0.35, 0.083333333333333
21282, 0.25, 0.4, 0.083333333333333
21283, 0.25, 0.45, 0.083333333333333
21284, 0.25, 0.5, 0.083333333333333
21285, 0.25, 0.55, 0.083333333333333
21286, 0.25, 0.6, 0.083333333333333
21287, 0.25, 0.65, 0.083333333333333
21288, 0.25, 0.7, 0.083333333333333
21289, 0.25, 0.75, 0.083333333333333
21290, 0.25, 0.8, 0.083333333333333
21291, 0.25, 0.85, 0.083333333333333
21292, 0.25, 0.9, 0.083333333333333
21293, 0.25, 0.95, 0.083333333333333
21294, 0.25, 1, 0.083333333333333
21295, 0.25, 1.05, 0.083333333333333
21296, 0.25, 1.1, 0.083333333333333
21297, 0.25, 1.15, 0.083333333333333
21298, 0.25, 1.2, 0.083333333333333
21299, 0.25, 1.25, 0.083333333333333
21300, 0.25, 1.3, 0.083333333333333
21301, 0.25, 0.2, 0.125
21302, 0.25, 0.25, 0.125
21303, 0.25, 0.3, 0.125
21304, 0.25, 0.35, 0.125
21305, 0.25, 0.4, 0.125
21306, 0.25, 0.45, 0.125
21307, 0.25, 0.5, 0.125
21308, 0.25, 0.55, 0.125
21309, 0.25, 0.6, 0.125
21310, 0.25, 0.65, 0.125
21311, 0.25, 0.7, 0.125
21312, 0.25, 0.75, 0.125
21313, 0.25, 0.8, 0.125
21314, 0.25, 0.85, 0.125
21315, 0.25, 0.9, 0.125
21316, 0.25, 0.95, 0.125
21317, 0.25, 1, 0.125
21318, 0.25, 1.05, 0.125
21319, 0.25, 1.1, 0.125
21320, 0.25, 1.15, 0.125
21321, 0.25, 1.2, 0.125
21322, 0.25, 1.25, 0.125
21323, 0.25, 1.3, 0.125
21324, 0.25, 0.2, 0.16666666666667
21325, 0.25, 0.25, 0.16666666666667
21326, 0.25, 0.3, 0.16666666666667
21327, 0.25, 0.35, 0.16666666666667
21328, 0.25, 0.4, 0.16666666666667
21329, 0.25, 0.45, 0.16666666666667
21330, 0.25, 0.5, 0.16666666666667
21331, 0.25, 0.55, 0.16666666666667
21332, 0.25, 0.6, 0.16666666666667
21333, 0.25, 0.65, 0.16666666666667
21334, 0.25, 0.7, 0.16666666666667
21335, 0.25, 0.75, 0.16666666666667
21336, 0.25, 0.8, 0.16666666666667
21337, 0.25, 0.85, 0.16666666666667
21338, 0.25, 0.9, 0.16666666666667
21339, 0.25, 0.95, 0.16666666666667
21340, 0.25, 1, 0.16666666666667
21341, 0.25, 1.05, 0.16666666666667
21342, 0.25, 1.1, 0.16666666666667
21343, 0.25, 1.15, 0.16666666666667
21344, 0.25, 1.2, 0.16666666666667
21345, 0.25, 1.25, 0.16666666666667
21346, 0.25, 1.3, 0.16666666666667
21347, 0.25, 0.2, 0.20833333333333
21348, 0.25, 0.25, 0.20833333333333
21349, 0.25, 0.3, 0.20833333333333
21350, 0.25, 0.35, 0.20833333333333
21351, 0.25, 0.4, 0.20833333333333
21352, 0.25, 0.45, 0.20833333333333
21353, 0.25, 0.5, 0.20833333333333
21354, 0.25, 0.55, 0.20833333333333
21355, 0.25, 0.6, 0.20833333333333
21356, 0.25, 0.65, 0.20833333333333
21357, 0.25, 0.7, 0.20833333333333
21358, 0.25, 0.75, 0.20833333333333
21359, 0.25, 0.8, 0.20833333333333
21360, 0.25, 0.85, 0.20833333333333
21361, 0.25, 0.9, 0.20833333333333
21362, 0.25, 0.95, 0.20833333333333
21363, 0.25, 1, 0.20833333333333
21364, 0.25, 1.05, 0.20833333333333
21365, 0.25, 1.1, 0.20833333333333
21366, 0.25, 1.15, 0.20833333333333
21367, 0.25, 1.2, 0.20833333333333
21368, 0.25, 1.25, 0.20833333333333
21369, 0.25, 1.3, 0.20833333333333
21370, 0.25, 0.2, 0.25
21371, 0.25, 0.25, 0.25
21372, 0.25, 0.3, 0.25
21373, 0.25, 0.35, 0.25
21374, 0.25, 0.4, 0.25
21375, 0.25, 0.45, 0.25
21376, 0.25, 0.5, 0.25
21377, 0.25, 0.55, 0.25
21378, 0.25, 0.6, 0.25
21379, 0.25, 0.65, 0.25
21380, 0.25, 0.7, 0.25
21381, 0.25, 0.75, 0.25
21382, 0.25, 0.8, 0.25
21383, 0.25, 0.85, 0.25
21384, 0.25, 0.9, 0.25
21385, 0.25, 0.95, 0.25
21386, 0.25, 1, 0.25
21387, 0.25, 1.05, 0.25
21388, 0.25, 1.1, 0.25
21389, 0.25, 1.15, 0.25
21390, 0.25, 1.2, 0.25
21391, 0.25, 1.25, 0.25
21392, 0.25, 1.3, 0.25
21393, 0.25, 0.2, 0.29166666666667
21394, 0.25, 0.25, 0.29166666666667
21395, 0.25, 0.3, 0.29166666666667
21396, 0.25, 0.35, 0.29166666666667
21397, 0.25, 0.4, 0.29166666666667
21398, 0.25, 0.45, 0.29166666666667
21399, 0.25, 0.5, 0.29166666666667
21400, 0.25, 0.55, 0.29166666666667
21401, 0.25, 0.6, 0.29166666666667
21402, 0.25, 0.65, 0.29166666666667
21403, 0.25, 0.7, 0.29166666666667
21404, 0.25, 0.75, 0.29166666666667
21405, 0.25, 0.8, 0.29166666666667
21406, 0.25, 0.85, 0.29166666666667
21407, 0.25, 0.9, 0.29166666666667
21408, 0.25, 0.95, 0.29166666666667
21409, 0.25, 1, 0.29166666666667
21410, 0.25, 1.05, 0.29166666666667
21411, 0.25, 1.1, 0.29166666666667
21412, 0.25, 1.15, 0.29166666666667
21413, 0.25, 1.2, 0.29166666666667
21414, 0.25, 1.25, 0.29166666666667
21415, 0.25, 1.3, 0.29166666666667
21416, 0.25, 0.2, 0.33333333333333
21417, 0.25, 0.25, 0.33333333333333
21418, 0.25, 0.3, 0.33333333333333
21419, 0.25, 0.35, 0.33333333333333
21420, 0.25, 0.4, 0.33333333333333
21421, 0.25, 0.45, 0.33333333333333
21422, 0.25, 0.5, 0.33333333333333
21423, 0.25, 0.55, 0.33333333333333
21424, 0.25, 0.6, 0.33333333333333
21425, 0.25, 0.65, 0.33333333333333
21426, 0.25, 0.7, 0.33333333333333
21427, 0.25, 0.75, 0.33333333333333
21428, 0.25, 0.8, 0.33333333333333
21429, 0.25, 0.85, 0.33333333333333
21430, 0.25, 0.9, 0.33333333333333
21431, 0.25, 0.95, 0.33333333333333
21432, 0.25, 1, 0.33333333333333
21433, 0.25, 1.05, 0.33333333333333
21434, 0.25, 1.1, 0.33333333333333
21435, 0.25, 1.15, 0.33333333333333
21436, 0.25, 1.2, 0.33333333333333
21437, 0.25, 1.25, 0.33333333333333
21438, 0.25, 1.3, 0.33333333333333
21439, 0.25, 0.2, 0.375
21440, 0.25, 0.25, 0.375
21441, 0.25, 0.3, 0.375
21442, 0.25, 0.35, 0.375
21443, 0.25, 0.4, 0.375
21444, 0.25, 0.45, 0.375
21445, 0.25, 0.5, 0.375
21446, 0.25, 0.55, 0.375
21447, 0.25, 0.6, 0.375
21448, 0.25, 0.65, 0.375
21449, 0.25, 0.7, 0.375
21450, 0.25, 0.75, 0.375
21451, 0.25, 0.8, 0.375
21452, 0.25, 0.85, 0.375
21453, 0.25, 0.9, 0.375
21454, 0.25, 0.95, 0.375
21455, 0.25, 1, 0.375
21456, 0.25, 1.05, 0.375
21457, 0.25, 1.1, 0.375
21458, 0.25, 1.15, 0.375
21459, 0.25, 1.2, 0.375
21460, 0.25, 1.25, 0.375
21461, 0.25, 1.3, 0.375
21462, 0.25, 0.2, 0.41666666666667
21463, 0.25, 0.25, 0.41666666666667
21464, 0.25, 0.3, 0.41666666666667
21465, 0.25, 0.35, 0.41666666666667
21466, 0.25, 0.4, 0.41666666666667
21467, 0.25, 0.45, 0.41666666666667
21468, 0.25, 0.5, 0.41666666666667
21469, 0.25, 0.55, 0.41666666666667
21470, 0.25, 0.6, 0.41666666666667
21471, 0.25, 0.65, 0.41666666666667
21472, 0.25, 0.7, 0.41666666666667
21473, 0.25, 0.75, 0.41666666666667
21474, 0.25, 0.8, 0.41666666666667
21475, 0.25, 0.85, 0.41666666666667
21476, 0.25, 0.9, 0.41666666666667
21477, 0.25, 0.95, 0.41666666666667
21478, 0.25, 1, 0.41666666666667
21479, 0.25, 1.05, 0.41666666666667
21480, 0.25, 1.1, 0.41666666666667
21481, 0.25, 1.15, 0.41666666666667
21482, 0.25, 1.2, 0.41666666666667
21483, 0.25, 1.25, 0.41666666666667
21484, 0.25, 1.3, 0.41666666666667
21485, 0.25, 0.2, 0.45833333333333
21486, 0.25, 0.25, 0.45833333333333
21487, 0.25, 0.3, 0.45833333333333
21488, 0.25, 0.35, 0.45833333333333
21489, 0.25, 0.4, 0.45833333333333
21490, 0.25, 0.45, 0.45833333333333
21491, 0.25, 0.5, 0.45833333333333
21492, 0.25, 0.55, 0.45833333333333
21493, 0.25, 0.6, 0.45833333333333
21494, 0.25, 0.65, 0.45833333333333
21495, 0.25, 0.7, 0.45833333333333
21496, 0.25, 0.75, 0.45833333333333
21497, 0.25, 0.8, 0.45833333333333
21498, 0.25, 0.85, 0.45833333333333
21499, 0.25, 0.9, 0.45833333333333
21500, 0.25, 0.95, 0.45833333333333
21501, 0.25, 1, 0.45833333333333
21502, 0.25, 1.05, 0.45833333333333
21503, 0.25, 1.1, 0.45833333333333
21504, 0.25, 1.15, 0.45833333333333
21505, 0.25, 1.2, 0.45833333333333
21506, 0.25, 1.25, 0.45833333333333
21507, 0.25, 1.3, 0.45833333333333
21508, 0.29166666666667, 0.2, 0.041666666666667
21509, 0.29166666666667, 0.25, 0.041666666666667
21510, 0.29166666666667, 0.3, 0.041666666666667
21511, 0.29166666666667, 0.35, 0.041666666666667
21512, 0.29166666666667, 0.4, 0.041666666666667
21513, 0.29166666666667, 0.45, 0.041666666666667
21514, 0.29166666666667, 0.5, 0.041666666666667
21515, 0.29166666666667, 0.55, 0.041666666666667
21516, 0.29166666666667, 0.6, 0.041666666666667
21517, 0.29166666666667, 0.65, 0.041666666666667
21518, 0.29166666666667, 0.7, 0.041666666666667
21519, 0.29166666666667, 0.75, 0.041666666666667
21520, 0.29166666666667, 0.8, 0.041666666666667
21521, 0.29166666666667, 0.85, 0.041666666666667
21522, 0.29166666666667, 0.9, 0.041666666666667
21523, 0.29166666666667, 0.95, 0.041666666666667
21524, 0.29166666666667, 1, 0.041666666666667
21525, 0.29166666666667, 1.05, 0.041666666666667
21526, 0.29166666666667, 1.1, 0.041666666666667
21527, 0.29166666666667, 1.15, 0.041666666666667
21528, 0.29166666666667, 1.2, 0.041666666666667
21529, 0.29166666666667, 1.25, 0.041666666666667
21530, 0.29166666666667, 1.3, 0.041666666666667
21531, 0.29166666666667, 0.2, 0.083333333333333
21532, 0.29166666666667, 0.25, 0.083333333333333
21533, 0.29166666666667, 0.3, 0.083333333333333
21534, 0.29166666666667, 0.35, 0.083333333333333
21535, 0.29166666666667, 0.4, 0.083333333333333
21536, 0.29166666666667, 0.45, 0.083333333333333
21537, 0.29166666666667, 0.5, 0.083333333333333
21538, 0.29166666666667, 0.55, 0.083333333333333
21539, 0.29166666666667, 0.6, 0.083333333333333
21540, 0.29166666666667, 0.65, 0.083333333333333
21541, 0.29166666666667, 0.7, 0.083333333333333
21542, 0.29166666666667, 0.75, 0.083333333333333
21543, 0.29166666666667, 0.8, 0.083333333333333
21544, 0.29166666666667, 0.85, 0.083333333333333
21545, 0.29166666666667, 0.9, 0.083333333333333
21546, 0.29166666666667, 0.95, 0.083333333333333
21547, 0.29166666666667, 1, 0.083333333333333
21548, 0.29166666666667, 1.05, 0.083333333333333
21549, 0.29166666666667, 1.1, 0.083333333333333
21550, 0.29166666666667, 1.15, 0.083333333333333
21551, 0.29166666666667, 1.2, 0.083333333333333
21552, 0.29166666666667, 1.25, 0.083333333333333
21553, 0.29166666666667, 1.3, 0.083333333333333
21554, 0.29166666666667, 0.2, 0.125
21555, 0.29166666666667, 0.25, 0.125
21556, 0.29166666666667, 0.3, 0.125
21557, 0.29166666666667, 0.35, 0.125
21558, 0.29166666666667, 0.4, 0.125
21559, 0.29166666666667, 0.45, 0.125
21560, 0.29166666666667, 0.5, 0.125
21561, 0.29166666666667, 0.55, 0.125
21562, 0.29166666666667, 0.6, 0.125
21563, 0.29166666666667, 0.65, 0.125
21564, 0.29166666666667, 0.7, 0.125
21565, 0.29166666666667, 0.75, 0.125
21566, 0.29166666666667, 0.8, 0.125
21567, 0.29166666666667, 0.85, 0.125
21568, 0.29166666666667, 0.9, 0.125
21569, 0.29166666666667, 0.95, 0.125
21570, 0.29166666666667, 1, 0.125
21571, 0.29166666666667, 1.05, 0.125
21572, 0.29166666666667, 1.1, 0.125
21573, 0.29166666666667, 1.15, 0.125
21574, 0.29166666666667, 1.2, 0.125
21575, 0.29166666666667, 1.25, 0.125
21576, 0.29166666666667, 1.3, 0.125
21577, 0.29166666666667, 0.2, 0.16666666666667
21578, 0.29166666666667, 0.25, 0.16666666666667
21579, 0.29166666666667, 0.3, 0.16666666666667
21580, 0.29166666666667, 0.35, 0.16666666666667
21581, 0.29166666666667, 0.4, 0.16666666666667
21582, 0.29166666666667, 0.45, 0.16666666666667
21583, 0.29166666666667, 0.5, 0.16666666666667
21584, 0.29166666666667, 0.55, 0.16666666666667
21585, 0.29166666666667, 0.6, 0.16666666666667
21586, 0.29166666666667, 0.65, 0.16666666666667
21587, 0.29166666666667, 0.7, 0.16666666666667
21588, 0.29166666666667, 0.75, 0.16666666666667
21589, 0.29166666666667, 0.8, 0.16666666666667
21590, 0.29166666666667, 0.85, 0.16666666666667
21591, 0.29166666666667, 0.9, 0.16666666666667
21592, 0.29166666666667, 0.95, 0.16666666666667
21593, 0.29166666666667, 1, 0.16666666666667
21594, 0.29166666666667, 1.05, 0.16666666666667
21595, 0.29166666666667, 1.1, 0.16666666666667
21596, 0.29166666666667, 1.15, 0.16666666666667
21597, 0.29166666666667, 1.2, 0.16666666666667
21598, 0.29166666666667, 1.25, 0.16666666666667
21599, 0.29166666666667, 1.3, 0.16666666666667
21600, 0.29166666666667, 0.2, 0.20833333333333
21601, 0.29166666666667, 0.25, 0.20833333333333
21602, 0.29166666666667, 0.3, 0.20833333333333
21603, 0.29166666666667, 0.35, 0.20833333333333
21604, 0.29166666666667, 0.4, 0.20833333333333
21605, 0.29166666666667, 0.45, 0.20833333333333
21606, 0.29166666666667, 0.5, 0.20833333333333
21607, 0.29166666666667, 0.55, 0.20833333333333
21608, 0.29166666666667, 0.6, 0.20833333333333
21609, 0.29166666666667, 0.65, 0.20833333333333
21610, 0.29166666666667, 0.7, 0.20833333333333
21611, 0.29166666666667, 0.75, 0.20833333333333
21612, 0.29166666666667, 0.8, 0.20833333333333
21613, 0.29166666666667, 0.85, 0.20833333333333
21614, 0.29166666666667, 0.9, 0.20833333333333
21615, 0.29166666666667, 0.95, 0.20833333333333
21616, 0.29166666666667, 1, 0.20833333333333
21617, 0.29166666666667, 1.05, 0.20833333333333
21618, 0.29166666666667, 1.1, 0.20833333333333
21619, 0.29166666666667, 1.15, 0.20833333333333
21620, 0.29166666666667, 1.2, 0.20833333333333
21621, 0.29166666666667, 1.25, 0.20833333333333
21622, 0.29166666666667, 1.3, 0.20833333333333
21623, 0.29166666666667, 0.2, 0.25
21624, 0.29166666666667, 0.25, 0.25
21625, 0.29166666666667, 0.3, 0.25
21626, 0.29166666666667, 0.35, 0.25
21627, 0.29166666666667, 0.4, 0.25
21628, 0.29166666666667, 0.45, 0.25
21629, 0.29166666666667, 0.5, 0.25
21630, 0.29166666666667, 0.55, 0.25
21631, 0.29166666666667, 0.6, 0.25
21632, 0.29166666666667, 0.65, 0.25
21633, 0.29166666666667, 0.7, 0.25
21634, 0.29166666666667, 0.75, 0.25
21635, 0.29166666666667, 0.8, 0.25
21636, 0.29166666666667, 0.85, 0.25
21637, 0.29166666666667, 0.9, 0.25
21638, 0.29166666666667, 0.95, 0.25
21639, 0.29166666666667, 1, 0.25
21640, 0.29166666666667, 1.05, 0.25
21641, 0.29166666666667, 1.1, 0.25
21642, 0.29166666666667, 1.15, 0.25
21643, 0.29166666666667, 1.2, 0.25
21644, 0.29166666666667, 1.25, 0.25
21645, 0.29166666666667, 1.3, 0.25
21646, 0.29166666666667, 0.2, 0.29166666666667
21647, 0.29166666666667, 0.25, 0.29166666666667
21648, 0.29166666666667, 0.3, 0.29166666666667
21649, 0.29166666666667, 0.35, 0.29166666666667
21650, 0.29166666666667, 0.4, 0.29166666666667
21651, 0.29166666666667, 0.45, 0.29166666666667
21652, 0.29166666666667, 0.5, 0.29166666666667
21653, 0.29166666666667, 0.55, 0.29166666666667
21654, 0.29166666666667, 0.6, 0.29166666666667
21655, 0.29166666666667, 0.65, 0.29166666666667
21656, 0.29166666666667, 0.7, 0.29166666666667
21657, 0.29166666666667, 0.75, 0.29166666666667
21658, 0.29166666666667, 0.8, 0.29166666666667
21659, 0.29166666666667, 0.85, 0.29166666666667
21660, 0.29166666666667, 0.9, 0.29166666666667
21661, 0.29166666666667, 0.95, 0.29166666666667
21662, 0.29166666666667, 1, 0.29166666666667
21663, 0.29166666666667, 1.05, 0.29166666666667
21664, 0.29166666666667, 1.1, 0.29166666666667
21665, 0.29166666666667, 1.15, 0.29166666666667
21666, 0.29166666666667, 1.2, 0.29166666666667
21667, 0.29166666666667, 1.25, 0.29166666666667
21668, 0.29166666666667, 1.3, 0.29166666666667
21669, 0.29166666666667, 0.2, 0.33333333333333
21670, 0.29166666666667, 0.25, 0.33333333333333
21671, 0.29166666666667, 0.3, 0.33333333333333
21672, 0.29166666666667, 0.35, 0.33333333333333
21673, 0.29166666666667, 0.4, 0.33333333333333
21674, 0.29166666666667, 0.45, 0.33333333333333
21675, 0.29166666666667, 0.5, 0.33333333333333
21676, 0.29166666666667, 0.55, 0.33333333333333
21677, 0.29166666666667, 0.6, 0.33333333333333
21678, 0.29166666666667, 0.65, 0.33333333333333
21679, 0.29166666666667, 0.7, 0.33333333333333
21680, 0.29166666666667, 0.75, 0.33333333333333
21681, 0.29166666666667, 0.8, 0.33333333333333
21682, 0.29166666666667, 0.85, 0.33333333333333
21683, 0.29166666666667, 0.9, 0.33333333333333
21684, 0.29166666666667, 0.95, 0.33333333333333
21685, 0.29166666666667, 1, 0.33333333333333
21686, 0.29166666666667, 1.05, 0.33333333333333
21687, 0.29166666666667, 1.1, 0.33333333333333
21688, 0.29166666666667, 1.15, 0.33333333333333
21689, 0.29166666666667, 1.2, 0.33333333333333
21690, 0.29166666666667, 1.25, 0.33333333333333
21691, 0.29166666666667, 1.3, 0.33333333333333
21692, 0.29166666666667, 0.2, 0.375
21693, 0.29166666666667, 0.25, 0.375
21694, 0.29166666666667, 0.3, 0.375
21695, 0.29166666666667, 0.35, 0.375
21696, 0.29166666666667, 0.4, 0.375
21697, 0.29166666666667, 0.45, 0.375
21698, 0.29166666666667, 0.5, 0.375
21699, 0.29166666666667, 0.55, 0.375
21700, 0.29166666666667, 0.6, 0.375
21701, 0.29166666666667, 0.65, 0.375
21702, 0.29166666666667, 0.7, 0.375
21703, 0.29166666666667, 0.75, 0.375
21704, 0.29166666666667, 0.8, 0.375
21705, 0.29166666666667, 0.85, 0.375
21706, 0.29166666666667, 0.9, 0.375
21707, 0.29166666666667, 0.95, 0.375
21708, 0.29166666666667, 1, 0.375
21709, 0.29166666666667, 1.05, 0.375
21710, 0.29166666666667, 1.1, 0.375
21711, 0.29166666666667, 1.15, 0.375
21712, 0.29166666666667, 1.2, 0.375
21713, 0.29166666666667, 1.25, 0.375
21714, 0.29166666666667, 1.3, 0.375
21715, 0.29166666666667, 0.2, 0.41666666666667
21716, 0.29166666666667, 0.25, 0.41666666666667
21717, 0.29166666666667, 0.3, 0.41666666666667
21718, 0.29166666666667, 0.35, 0.41666666666667
21719, 0.29166666666667, 0.4, 0.41666666666667
21720, 0.29166666666667, 0.45, 0.41666666666667
21721, 0.29166666666667, 0.5, 0.41666666666667
21722, 0.29166666666667, 0.55, 0.41666666666667
21723, 0.29166666666667, 0.6, 0.41666666666667
21724, 0.29166666666667, 0.65, 0.41666666666667
21725, 0.29166666666667, 0.7, 0.41666666666667
21726, 0.29166666666667, 0.75, 0.41666666666667
21727, 0.29166666666667, 0.8, 0.41666666666667
21728, 0.29166666666667, 0.85, 0.41666666666667
21729, 0.29166666666667, 0.9, 0.41666666666667
21730, 0.29166666666667, 0.95, 0.41666666666667
21731, 0.29166666666667, 1, 0.41666666666667
21732, 0.29166666666667, 1.05, 0.41666666666667
21733, 0.29166666666667, 1.1, 0.41666666666667
21734, 0.29166666666667, 1.15, 0.41666666666667
21735, 0.29166666666667, 1.2, 0.41666666666667
21736, 0.29166666666667, 1.25, 0.41666666666667
21737, 0.29166666666667, 1.3, 0.41666666666667
21738, 0.29166666666667, 0.2, 0.45833333333333
21739, 0.29166666666667, 0.25, 0.45833333333333
21740, 0.29166666666667, 0.3, 0.45833333333333
21741, 0.29166666666667, 0.35, 0.45833333333333
21742, 0.29166666666667, 0.4, 0.45833333333333
21743, 0.29166666666667, 0.45, 0.45833333333333
21744, 0.29166666666667, 0.5, 0.45833333333333
21745, 0.29166666666667, 0.55, 0.45833333333333
21746, 0.29166666666667, 0.6, 0.45833333333333
21747, 0.29166666666667, 0.65, 0.45833333333333
21748, 0.29166666666667, 0.7, 0.45833333333333
21749, 0.29166666666667, 0.75, 0.45833333333333
21750, 0.29166666666667, 0.8, 0.45833333333333
21751, 0.29166666666667, 0.85, 0.45833333333333
21752, 0.29166666666667, 0.9, 0.45833333333333
21753, 0.29166666666667, 0.95, 0.45833333333333
21754, 0.29166666666667, 1, 0.45833333333333
21755, 0.29166666666667, 1.05, 0.45833333333333
21756, 0.29166666666667, 1.1, 0.45833333333333
21757, 0.29166666666667, 1.15, 0.45833333333333
21758, 0.29166666666667, 1.2, 0.45833333333333
21759, 0.29166666666667, 1.25, 0.45833333333333
21760, 0.29166666666667, 1.3, 0.45833333333333
21761, 0.33333333333333, 0.2, 0.041666666666667
21762, 0.33333333333333, 0.25, 0.041666666666667
21763, 0.33333333333333, 0.3, 0.041666666666667
21764, 0.33333333333333, 0.35, 0.041666666666667
21765, 0.33333333333333, 0.4, 0.041666666666667
21766, 0.33333333333333, 0.45, 0.041666666666667
21767, 0.33333333333333, 0.5, 0.041666666666667
21768, 0.33333333333333, 0.55, 0.041666666666667
21769, 0.33333333333333, 0.6, 0.041666666666667
21770, 0.33333333333333, 0.65, 0.041666666666667
21771, 0.33333333333333, 0.7, 0.041666666666667
21772, 0.33333333333333, 0.75, 0.041666666666667
21773, 0.33333333333333, 0.8, 0.041666666666667
21774, 0.33333333333333, 0.85, 0.041666666666667
21775, 0.33333333333333, 0.9, 0.041666666666667
21776, 0.33333333333333, 0.95, 0.041666666666667
21777, 0.33333333333333, 1, 0.041666666666667
21778, 0.33333333333333, 1.05, 0.041666666666667
21779, 0.33333333333333, 1.1, 0.041666666666667
21780, 0.33333333333333, 1.15, 0.041666666666667
21781, 0.33333333333333, 1.2, 0.041666666666667
21782, 0.33333333333333, 1.25, 0.041666666666667
21783, 0.33333333333333, 1.3, 0.041666666666667
21784, 0.33333333333333, 0.2, 0.083333333333333
21785, 0.33333333333333, 0.25, 0.083333333333333
21786, 0.33333333333333, 0.3, 0.083333333333333
21787, 0.33333333333333, 0.35, 0.083333333333333
21788, 0.33333333333333, 0.4, 0.083333333333333
21789, 0.33333333333333, 0.45, 0.083333333333333
21790, 0.33333333333333, 0.5, 0.083333333333333
21791, 0.33333333333333, 0.55, 0.083333333333333
21792, 0.33333333333333, 0.6, 0.083333333333333
21793, 0.33333333333333, 0.65, 0.083333333333333
21794, 0.33333333333333, 0.7, 0.083333333333333
21795, 0.33333333333333, 0.75, 0.083333333333333
21796, 0.33333333333333, 0.8, 0.083333333333333
21797, 0.33333333333333, 0.85, 0.083333333333333
21798, 0.33333333333333, 0.9, 0.083333333333333
21799, 0.33333333333333, 0.95, 0.083333333333333
21800, 0.33333333333333, 1, 0.083333333333333
21801, 0.33333333333333, 1.05, 0.083333333333333
21802, 0.33333333333333, 1.1, 0.083333333333333
21803, 0.33333333333333, 1.15, 0.083333333333333
21804, 0.33333333333333, 1.2, 0.083333333333333
21805, 0.33333333333333, 1.25, 0.083333333333333
21806, 0.33333333333333, 1.3, 0.083333333333333
21807, 0.33333333333333, 0.2, 0.125
21808, 0.33333333333333, 0.25, 0.125
21809, 0.33333333333333, 0.3, 0.125
21810, 0.33333333333333, 0.35, 0.125
21811, 0.33333333333333, 0.4, 0.125
21812, 0.33333333333333, 0.45, 0.125
21813, 0.33333333333333, 0.5, 0.125
21814, 0.33333333333333, 0.55, 0.125
21815, 0.33333333333333, 0.6, 0.125
21816, 0.33333333333333, 0.65, 0.125
21817, 0.33333333333333, 0.7, 0.125
21818, 0.33333333333333, 0.75, 0.125
21819, 0.33333333333333, 0.8, 0.125
21820, 0.33333333333333, 0.85, 0.125
21821, 0.33333333333333, 0.9, 0.125
21822, 0.33333333333333, 0.95, 0.125
21823, 0.33333333333333, 1, 0.125
21824, 0.33333333333333, 1.05, 0.125
21825, 0.33333333333333, 1.1, 0.125
21826, 0.33333333333333, 1.15, 0.125
21827, 0.33333333333333, 1.2, 0.125
21828, 0.33333333333333, 1.25, 0.125
21829, 0.33333333333333, 1.3, 0.125
21830, 0.33333333333333, 0.2, 0.16666666666667
21831, 0.33333333333333, 0.25, 0.16666666666667
21832, 0.33333333333333, 0.3, 0.16666666666667
21833, 0.33333333333333, 0.35, 0.16666666666667
21834, 0.33333333333333, 0.4, 0.16666666666667
21835, 0.33333333333333, 0.45, 0.16666666666667
21836, 0.33333333333333, 0.5, 0.16666666666667
21837, 0.33333333333333, 0.55, 0.16666666666667
21838, 0.33333333333333, 0.6, 0.16666666666667
21839, 0.33333333333333, 0.65, 0.16666666666667
21840, 0.33333333333333, 0.7, 0.16666666666667
21841, 0.33333333333333, 0.75, 0.16666666666667
21842, 0.33333333333333, 0.8, 0.16666666666667
21843, 0.33333333333333, 0.85, 0.16666666666667
21844, 0.33333333333333, 0.9, 0.16666666666667
21845, 0.33333333333333, 0.95, 0.16666666666667
21846, 0.33333333333333, 1, 0.16666666666667
21847, 0.33333333333333, 1.05, 0.16666666666667
21848, 0.33333333333333, 1.1, 0.16666666666667
21849, 0.33333333333333, 1.15, 0.16666666666667
21850, 0.33333333333333, 1.2, 0.16666666666667
21851, 0.33333333333333, 1.25, 0.16666666666667
21852, 0.33333333333333, 1.3, 0.16666666666667
21853, 0.33333333333333, 0.2, 0.20833333333333
21854, 0.33333333333333, 0.25, 0.20833333333333
21855, 0.33333333333333, 0.3, 0.20833333333333
21856, 0.33333333333333, 0.35, 0.20833333333333
21857, 0.33333333333333, 0.4, 0.20833333333333
21858, 0.33333333333333, 0.45, 0.20833333333333
21859, 0.33333333333333, 0.5, 0.20833333333333
21860, 0.33333333333333, 0.55, 0.20833333333333
21861, 0.33333333333333, 0.6, 0.20833333333333
21862, 0.33333333333333, 0.65, 0.20833333333333
21863, 0.33333333333333, 0.7, 0.20833333333333
21864, 0.33333333333333, 0.75, 0.20833333333333
21865, 0.33333333333333, 0.8, 0.20833333333333
21866, 0.33333333333333, 0.85, 0.20833333333333
21867, 0.33333333333333, 0.9, 0.20833333333333
21868, 0.33333333333333, 0.95, 0.20833333333333
21869, 0.33333333333333, 1, 0.20833333333333
21870, 0.33333333333333, 1.05, 0.20833333333333
21871, 0.33333333333333, 1.1, 0.20833333333333
21872, 0.33333333333333, 1.15, 0.20833333333333
21873, 0.33333333333333, 1.2, 0.20833333333333
21874, 0.33333333333333, 1.25, 0.20833333333333
21875, 0.33333333333333, 1.3, 0.20833333333333
21876, 0.33333333333333, 0.2, 0.25
21877, 0.33333333333333, 0.25, 0.25
21878, 0.33333333333333, 0.3, 0.25
21879, 0.33333333333333, 0.35, 0.25
21880, 0.33333333333333, 0.4, 0.25
21881, 0.33333333333333, 0.45, 0.25
21882, 0.33333333333333, 0.5, 0.25
21883, 0.33333333333333, 0.55, 0.25
21884, 0.33333333333333, 0.6, 0.25
21885, 0.33333333333333, 0.65, 0.25
21886, 0.33333333333333, 0.7, 0.25
21887, 0.33333333333333, 0.75, 0.25
21888, 0.33333333333333, 0.8, 0.25
21889, 0.33333333333333, 0.85, 0.25
21890, 0.33333333333333, 0.9, 0.25
21891, 0.33333333333333, 0.95, 0.25
21892, 0.33333333333333, 1, 0.25
21893, 0.33333333333333, 1.05, 0.25
21894, 0.33333333333333, 1.1, 0.25
21895, 0.33333333333333, 1.15, 0.25
21896, 0.33333333333333, 1.2, 0.25
21897, 0.33333333333333, 1.25, 0.25
21898, 0.33333333333333, 1.3, 0.25
21899, 0.33333333333333, 0.2, 0.29166666666667
21900, 0.33333333333333, 0.25, 0.29166666666667
21901, 0.33333333333333, 0.3, 0.29166666666667
21902, 0.33333333333333, 0.35, 0.29166666666667
21903, 0.33333333333333, 0.4, 0.29166666666667
21904, 0.33333333333333, 0.45, 0.29166666666667
21905, 0.33333333333333, 0.5, 0.29166666666667
21906, 0.33333333333333, 0.55, 0.29166666666667
21907, 0.33333333333333, 0.6, 0.29166666666667
21908, 0.33333333333333, 0.65, 0.29166666666667
21909, 0.33333333333333, 0.7, 0.29166666666667
21910, 0.33333333333333, 0.75, 0.29166666666667
21911, 0.33333333333333, 0.8, 0.29166666666667
21912, 0.33333333333333, 0.85, 0.29166666666667
21913, 0.33333333333333, 0.9, 0.29166666666667
21914, 0.33333333333333, 0.95, 0.29166666666667
21915, 0.33333333333333, 1, 0.29166666666667
21916, 0.33333333333333, 1.05, 0.29166666666667
21917, 0.33333333333333, 1.1, 0.29166666666667
21918, 0.33333333333333, 1.15, 0.29166666666667
21919, 0.33333333333333, 1.2, 0.29166666666667
21920, 0.33333333333333, 1.25, 0.29166666666667
21921, 0.33333333333333, 1.3, 0.29166666666667
21922, 0.33333333333333, 0.2, 0.33333333333333
21923, 0.33333333333333, 0.25, 0.33333333333333
21924, 0.33333333333333, 0.3, 0.33333333333333
21925, 0.33333333333333, 0.35, 0.33333333333333
21926, 0.33333333333333, 0.4, 0.33333333333333
21927, 0.33333333333333, 0.45, 0.33333333333333
21928, 0.33333333333333, 0.5, 0.33333333333333
21929, 0.33333333333333, 0.55, 0.33333333333333
21930, 0.33333333333333, 0.6, 0.33333333333333
21931, 0.33333333333333, 0.65, 0.33333333333333
21932, 0.33333333333333, 0.7, 0.33333333333333
21933, 0.33333333333333, 0.75, 0.33333333333333
21934, 0.33333333333333, 0.8, 0.33333333333333
21935, 0.33333333333333, 0.85, 0.33333333333333
21936, 0.33333333333333, 0.9, 0.33333333333333
21937, 0.33333333333333, 0.95, 0.33333333333333
21938, 0.33333333333333, 1, 0.33333333333333
21939, 0.33333333333333, 1.05, 0.33333333333333
21940, 0.33333333333333, 1.1, 0.33333333333333
21941, 0.33333333333333, 1.15, 0.33333333333333
21942, 0.33333333333333, 1.2, 0.33333333333333
21943, 0.33333333333333, 1.25, 0.33333333333333
21944, 0.33333333333333, 1.3, 0.33333333333333
21945, 0.33333333333333, 0.2, 0.375
21946, 0.33333333333333, 0.25, 0.375
21947, 0.33333333333333, 0.3, 0.375
21948, 0.33333333333333, 0.35, 0.375
21949, 0.33333333333333, 0.4, 0.375
21950, 0.33333333333333, 0.45, 0.375
21951, 0.33333333333333, 0.5, 0.375
21952, 0.33333333333333, 0.55, 0.375
21953, 0.33333333333333, 0.6, 0.375
21954, 0.33333333333333, 0.65, 0.375
21955, 0.33333333333333, 0.7, 0.375
21956, 0.33333333333333, 0.75, 0.375
21957, 0.33333333333333, 0.8, 0.375
21958, 0.33333333333333, 0.85, 0.375
21959, 0.33333333333333, 0.9, 0.375
21960, 0.33333333333333, 0.95, 0.375
21961, 0.33333333333333, 1, 0.375
21962, 0.33333333333333, 1.05, 0.375
21963, 0.33333333333333, 1.1, 0.375
21964, 0.33333333333333, 1.15, 0.375
21965, 0.33333333333333, 1.2, 0.375
21966, 0.33333333333333, 1.25, 0.375
21967, 0.33333333333333, 1.3, 0.375
21968, 0.33333333333333, 0.2, 0.41666666666667
21969, 0.33333333333333, 0.25, 0.41666666666667
21970, 0.33333333333333, 0.3, 0.41666666666667
21971, 0.33333333333333, 0.35, 0.41666666666667
21972, 0.33333333333333, 0.4, 0.41666666666667
21973, 0.33333333333333, 0.45, 0.41666666666667
21974, 0.33333333333333, 0.5, 0.41666666666667
21975, 0.33333333333333, 0.55, 0.41666666666667
21976, 0.33333333333333, 0.6, 0.41666666666667
21977, 0.33333333333333, 0.65, 0.41666666666667
21978, 0.33333333333333, 0.7, 0.41666666666667
21979, 0.33333333333333, 0.75, 0.41666666666667
21980, 0.33333333333333, 0.8, 0.41666666666667
21981, 0.33333333333333, 0.85, 0.41666666666667
21982, 0.33333333333333, 0.9, 0.41666666666667
21983, 0.33333333333333, 0.95, 0.41666666666667
21984, 0.33333333333333, 1, 0.41666666666667
21985, 0.33333333333333, 1.05, 0.41666666666667
21986, 0.33333333333333, 1.1, 0.41666666666667
21987, 0.33333333333333, 1.15, 0.41666666666667
21988, 0.33333333333333, 1.2, 0.41666666666667
21989, 0.33333333333333, 1.25, 0.41666666666667
21990, 0.33333333333333, 1.3, 0.41666666666667
21991, 0.33333333333333, 0.2, 0.45833333333333
21992, 0.33333333333333, 0.25, 0.45833333333333
21993, 0.33333333333333, 0.3, 0.45833333333333
21994, 0.33333333333333, 0.35, 0.45833333333333
21995, 0.33333333333333, 0.4, 0.45833333333333
21996, 0.33333333333333, 0.45, 0.45833333333333
21997, 0.33333333333333, 0.5, 0.45833333333333
21998, 0.33333333333333, 0.55, 0.45833333333333
21999, 0.33333333333333, 0.6, 0.45833333333333
22000, 0.33333333333333, 0.65, 0.45833333333333
22001, 0.33333333333333, 0.7, 0.45833333333333
22002, 0.33333333333333, 0.75, 0.45833333333333
22003, 0.33333333333333, 0.8, 0.45833333333333
22004, 0.33333333333333, 0.85, 0.45833333333333
22005, 0.33333333333333, 0.9, 0.45833333333333
22006, 0.33333333333333, 0.95, 0.45833333333333
22007, 0.33333333333333, 1, 0.45833333333333
22008, 0.33333333333333, 1.05, 0.45833333333333
22009, 0.33333333333333, 1.1, 0.45833333333333
22010, 0.33333333333333, 1.15, 0.45833333333333
22011, 0.33333333333333, 1.2, 0.45833333333333
22012, 0.33333333333333, 1.25, 0.45833333333333
22013, 0.33333333333333, 1.3, 0.45833333333333
22014, 0.375, 0.2, 0.041666666666667
22015, 0.375, 0.25, 0.041666666666667
22016, 0.375, 0.3, 0.041666666666667
22017, 0.375, 0.35, 0.041666666666667
22018, 0.375, 0.4, 0.041666666666667
22019, 0.375, 0.45, 0.041666666666667
22020, 0.375, 0.5, 0.041666666666667
22021, 0.375, 0.55, 0.041666666666667
22022, 0.375, 0.6, 0.041666666666667
22023, 0.375, 0.65, 0.041666666666667
22024, 0.375, 0.7, 0.041666666666667
22025, 0.375, 0.75, 0.041666666666667
22026, 0.375, 0.8, 0.041666666666667
22027, 0.375, 0.85, 0.041666666666667
22028, 0.375, 0.9, 0.041666666666667
22029, 0.375, 0.95, 0.041666666666667
22030, 0.375, 1, 0.041666666666667
22031, 0.375, 1.05, 0.041666666666667
22032, 0.375, 1.1, 0.041666666666667
22033, 0.375, 1.15, 0.041666666666667
22034, 0.375, 1.2, 0.041666666666667
22035, 0.375, 1.25, 0.041666666666667
22036, 0.375, 1.3, 0.041666666666667
22037, 0.375, 0.2, 0.083333333333333
22038, 0.375, 0.25, 0.083333333333333
22039, 0.375, 0.3, 0.083333333333333
22040, 0.375, 0.35, 0.083333333333333
22041, 0.375, 0.4, 0.083333333333333
22042, 0.375, 0.45, 0.083333333333333
22043, 0.375, 0.5, 0.083333333333333
22044, 0.375, 0.55, 0.083333333333333
22045, 0.375, 0.6, 0.083333333333333
22046, 0.375, 0.65, 0.083333333333333
22047, 0.375, 0.7, 0.083333333333333
22048, 0.375, 0.75, 0.083333333333333
22049, 0.375, 0.8, 0.083333333333333
22050, 0.375, 0.85, 0.083333333333333
22051, 0.375, 0.9, 0.083333333333333
22052, 0.375, 0.95, 0.083333333333333
22053, 0.375, 1, 0.083333333333333
22054, 0.375, 1.05, 0.083333333333333
22055, 0.375, 1.1, 0.083333333333333
22056, 0.375, 1.15, 0.083333333333333
22057, 0.375, 1.2, 0.083333333333333
22058, 0.375, 1.25, 0.083333333333333
22059, 0.375, 1.3, 0.083333333333333
22060, 0.375, 0.2, 0.125
22061, 0.375, 0.25, 0.125
22062, 0.375, 0.3, 0.125
22063, 0.375, 0.35, 0.125
22064, 0.375, 0.4, 0.125
22065, 0.375, 0.45, 0.125
22066, 0.375, 0.5, 0.125
22067, 0.375, 0.55, 0.125
22068, 0.375, 0.6, 0.125
22069, 0.375, 0.65, 0.125
22070, 0.375, 0.7, 0.125
22071, 0.375, 0.75, 0.125
22072, 0.375, 0.8, 0.125
22073, 0.375, 0.85, 0.125
22074, 0.375, 0.9, 0.125
22075, 0.375, 0.95, 0.125
22076, 0.375, 1, 0.125
22077, 0.375, 1.05, 0.125
22078, 0.375, 1.1, 0.125
22079, 0.375, 1.15, 0.125
22080, 0.375, 1.2, 0.125
22081, 0.375, 1.25, 0.125
22082, 0.375, 1.3, 0.125
22083, 0.375, 0.2, 0.16666666666667
22084, 0.375, 0.25, 0.16666666666667
22085, 0.375, 0.3, 0.16666666666667
22086, 0.375, 0.35, 0.16666666666667
22087, 0.375, 0.4, 0.16666666666667
22088, 0.375, 0.45, 0.16666666666667
22089, 0.375, 0.5, 0.16666666666667
22090, 0.375, 0.55, 0.16666666666667
22091, 0.375, 0.6, 0.16666666666667
22092, 0.375, 0.65, 0.16666666666667
22093, 0.375, 0.7, 0.16666666666667
22094, 0.375, 0.75, 0.16666666666667
22095, 0.375, 0.8, 0.16666666666667
22096, 0.375, 0.85, 0.16666666666667
22097, 0.375, 0.9, 0.16666666666667
22098, 0.375, 0.95, 0.16666666666667
22099, 0.375, 1, 0.16666666666667
22100, 0.375, 1.05, 0.16666666666667
22101, 0.375, 1.1, 0.16666666666667
22102, 0.375, 1.15, 0.16666666666667
22103, 0.375, 1.2, 0.16666666666667
22104, 0.375, 1.25, 0.16666666666667
22105, 0.375, 1.3, 0.16666666666667
22106, 0.375, 0.2, 0.20833333333333
22107, 0.375, 0.25, 0.20833333333333
22108, 0.375, 0.3, 0.20833333333333
22109, 0.375, 0.35, 0.20833333333333
22110, 0.375, 0.4, 0.20833333333333
22111, 0.375, 0.45, 0.20833333333333
22112, 0.375, 0.5, 0.20833333333333
22113, 0.375, 0.55, 0.20833333333333
22114, 0.375, 0.6, 0.20833333333333
22115, 0.375, 0.65, 0.20833333333333
22116, 0.375, 0.7, 0.20833333333333
22117, 0.375, 0.75, 0.20833333333333
22118, 0.375, 0.8, 0.20833333333333
22119, 0.375, 0.85, 0.20833333333333
22120, 0.375, 0.9, 0.20833333333333
22121, 0.375, 0.95, 0.20833333333333
22122, 0.375, 1, 0.20833333333333
22123, 0.375, 1.05, 0.20833333333333
22124, 0.375, 1.1, 0.20833333333333
22125, 0.375, 1.15, 0.20833333333333
22126, 0.375, 1.2, 0.20833333333333
22127, 0.375, 1.25, 0.20833333333333
22128, 0.375, 1.3, 0.20833333333333
22129, 0.375, 0.2, 0.25
22130, 0.375, 0.25, 0.25
22131, 0.375, 0.3, 0.25
22132, 0.375, 0.35, 0.25
22133, 0.375, 0.4, 0.25
22134, 0.375, 0.45, 0.25
22135, 0.375, 0.5, 0.25
22136, 0.375, 0.55, 0.25
22137, 0.375, 0.6, 0.25
22138, 0.375, 0.65, 0.25
22139, 0.375, 0.7, 0.25
22140, 0.375, 0.75, 0.25
22141, 0.375, 0.8, 0.25
22142, 0.375, 0.85, 0.25
22143, 0.375, 0.9, 0.25
22144, 0.375, 0.95, 0.25
22145, 0.375, 1, 0.25
22146, 0.375, 1.05, 0.25
22147, 0.375, 1.1, 0.25
22148, 0.375, 1.15, 0.25
22149, 0.375, 1.2, 0.25
22150, 0.375, 1.25, 0.25
22151, 0.375, 1.3, 0.25
22152, 0.375, 0.2, 0.29166666666667
22153, 0.375, 0.25, 0.29166666666667
22154, 0.375, 0.3, 0.29166666666667
22155, 0.375, 0.35, 0.29166666666667
22156, 0.375, 0.4, 0.29166666666667
22157, 0.375, 0.45, 0.29166666666667
22158, 0.375, 0.5, 0.29166666666667
22159, 0.375, 0.55, 0.29166666666667
22160, 0.375, 0.6, 0.29166666666667
22161, 0.375, 0.65, 0.29166666666667
22162, 0.375, 0.7, 0.29166666666667
22163, 0.375, 0.75, 0.29166666666667
22164, 0.375, 0.8, 0.29166666666667
22165, 0.375, 0.85, 0.29166666666667
22166, 0.375, 0.9, 0.29166666666667
22167, 0.375, 0.95, 0.29166666666667
22168, 0.375, 1, 0.29166666666667
22169, 0.375, 1.05, 0.29166666666667
22170, 0.375, 1.1, 0.29166666666667
22171, 0.375, 1.15, 0.29166666666667
22172, 0.375, 1.2, 0.29166666666667
22173, 0.375, 1.25, 0.29166666666667
22174, 0.375, 1.3, 0.29166666666667
22175, 0.375, 0.2, 0.33333333333333
22176, 0.375, 0.25, 0.33333333333333
22177, 0.375, 0.3, 0.33333333333333
22178, 0.375, 0.35, 0.33333333333333
22179, 0.375, 0.4, 0.33333333333333
22180, 0.375, 0.45, 0.33333333333333
22181, 0.375, 0.5, 0.33333333333333
22182, 0.375, 0.55, 0.33333333333333
22183, 0.375, 0.6, 0.33333333333333
22184, 0.375, 0.65, 0.33333333333333
22185, 0.375, 0.7, 0.33333333333333
22186, 0.375, 0.75, 0.33333333333333
22187, 0.375, 0.8, 0.33333333333333
22188, 0.375, 0.85, 0.33333333333333
22189, 0.375, 0.9, 0.33333333333333
22190, 0.375, 0.95, 0.33333333333333
22191, 0.375, 1, 0.33333333333333
22192, 0.375, 1.05, 0.33333333333333
22193, 0.375, 1.1, 0.33333333333333
22194, 0.375, 1.15, 0.33333333333333
22195, 0.375, 1.2, 0.33333333333333
22196, 0.375, 1.25, 0.33333333333333
22197, 0.375, 1.3, 0.33333333333333
22198, 0.375, 0.2, 0.375
22199, 0.375, 0.25, 0.375
22200, 0.375, 0.3, 0.375
22201, 0.375, 0.35, 0.375
22202, 0.375, 0.4, 0.375
22203, 0.375, 0.45, 0.375
22204, 0.375, 0.5, 0.375
22205, 0.375, 0.55, 0.375
22206, 0.375, 0.6, 0.375
22207, 0.375, 0.65, 0.375
22208, 0.375, 0.7, 0.375
22209, 0.375, 0.75, 0.375
22210, 0.375, 0.8, 0.375
22211, 0.375, 0.85, 0.375
22212, 0.375, 0.9, 0.375
22213, 0.375, 0.95, 0.375
22214, 0.375, 1, 0.375
22215, 0.375, 1.05, 0.375
22216, 0.375, 1.1, 0.375
22217, 0.375, 1.15, 0.375
22218, 0.375, 1.2, 0.375
22219, 0.375, 1.25, 0.375
22220, 0.375, 1.3, 0.375
22221, 0.375, 0.2, 0.41666666666667
22222, 0.375, 0.25, 0.41666666666667
22223, 0.375, 0.3, 0.41666666666667
22224, 0.375, 0.35, 0.41666666666667
22225, 0.375, 0.4, 0.41666666666667
22226, 0.375, 0.45, 0.41666666666667
22227, 0.375, 0.5, 0.41666666666667
22228, 0.375, 0.55, 0.41666666666667
22229, 0.375, 0.6, 0.41666666666667
22230, 0.375, 0.65, 0.41666666666667
22231, 0.375, 0.7, 0.41666666666667
22232, 0.375, 0.75, 0.41666666666667
22233, 0.375, 0.8, 0.41666666666667
22234, 0.375, 0.85, 0.41666666666667
22235, 0.375, 0.9, 0.41666666666667
22236, 0.375, 0.95, 0.41666666666667
22237, 0.375, 1, 0.41666666666667
22238, 0.375, 1.05, 0.41666666666667
22239, 0.375, 1.1, 0.41666666666667
22240, 0.375, 1.15, 0.41666666666667
22241, 0.375, 1.2, 0.41666666666667
22242, 0.375, 1.25, 0.41666666666667
22243, 0.375, 1.3, 0.41666666666667
22244, 0.375, 0.2, 0.45833333333333
22245, 0.375, 0.25, 0.45833333333333
22246, 0.375, 0.3, 0.45833333333333
22247, 0.375, 0.35, 0.45833333333333
22248, 0.375, 0.4, 0.45833333333333
22249, 0.375, 0.45, 0.45833333333333
22250, 0.375, 0.5, 0.45833333333333
22251, 0.375, 0.55, 0.45833333333333
22252, 0.375, 0.6, 0.45833333333333
22253, 0.375, 0.65, 0.45833333333333
22254, 0.375, 0.7, 0.45833333333333
22255, 0.375, 0.75, 0.45833333333333
22256, 0.375, 0.8, 0.45833333333333
22257, 0.375, 0.85, 0.45833333333333
22258, 0.375, 0.9, 0.45833333333333
22259, 0.375, 0.95, 0.45833333333333
22260, 0.375, 1, 0.45833333333333
22261, 0.375, 1.05, 0.45833333333333
22262, 0.375, 1.1, 0.45833333333333
22263, 0.375, 1.15, 0.45833333333333
22264, 0.375, 1.2, 0.45833333333333
22265, 0.375, 1.25, 0.45833333333333
22266, 0.375, 1.3, 0.45833333333333
22267, 0.41666666666667, 0.2, 0.041666666666667
22268, 0.41666666666667, 0.25, 0.041666666666667
22269, 0.41666666666667, 0.3, 0.041666666666667
22270, 0.41666666666667, 0.35, 0.041666666666667
22271, 0.41666666666667, 0.4, 0.041666666666667
22272, 0.41666666666667, 0.45, 0.041666666666667
22273, 0.41666666666667, 0.5, 0.041666666666667
22274, 0.41666666666667, 0.55, 0.041666666666667
22275, 0.41666666666667, 0.6, 0.041666666666667
22276, 0.41666666666667, 0.65, 0.041666666666667
22277, 0.41666666666667, 0.7, 0.041666666666667
22278, 0.41666666666667, 0.75, 0.041666666666667
22279, 0.41666666666667, 0.8, 0.041666666666667
22280, 0.41666666666667, 0.85, 0.041666666666667
22281, 0.41666666666667, 0.9, 0.041666666666667
22282, 0.41666666666667, 0.95, 0.041666666666667
22283, 0.41666666666667, 1, 0.041666666666667
22284, 0.41666666666667, 1.05, 0.041666666666667
22285, 0.41666666666667, 1.1, 0.041666666666667
22286, 0.41666666666667, 1.15, 0.041666666666667
22287, 0.41666666666667, 1.2, 0.041666666666667
22288, 0.41666666666667, 1.25, 0.041666666666667
22289, 0.41666666666667, 1.3, 0.041666666666667
22290, 0.41666666666667, 0.2, 0.083333333333333
22291, 0.41666666666667, 0.25, 0.083333333333333
22292, 0.41666666666667, 0.3, 0.083333333333333
22293, 0.41666666666667, 0.35, 0.083333333333333
22294, 0.41666666666667, 0.4, 0.083333333333333
22295, 0.41666666666667, 0.45, 0.083333333333333
22296, 0.41666666666667, 0.5, 0.083333333333333
22297, 0.41666666666667, 0.55, 0.083333333333333
22298, 0.41666666666667, 0.6, 0.083333333333333
22299, 0.41666666666667, 0.65, 0.083333333333333
22300, 0.41666666666667, 0.7, 0.083333333333333
22301, 0.41666666666667, 0.75, 0.083333333333333
22302, 0.41666666666667, 0.8, 0.083333333333333
22303, 0.41666666666667, 0.85, 0.083333333333333
22304, 0.41666666666667, 0.9, 0.083333333333333
22305, 0.41666666666667, 0.95, 0.083333333333333
22306, 0.41666666666667, 1, 0.083333333333333
22307, 0.41666666666667, 1.05, 0.083333333333333
22308, 0.41666666666667, 1.1, 0.083333333333333
22309, 0.41666666666667, 1.15, 0.083333333333333
22310, 0.41666666666667, 1.2, 0.083333333333333
22311, 0.41666666666667, 1.25, 0.083333333333333
22312, 0.41666666666667, 1.3, 0.083333333333333
22313, 0.41666666666667, 0.2, 0.125
22314, 0.41666666666667, 0.25, 0.125
22315, 0.41666666666667, 0.3, 0.125
22316, 0.41666666666667, 0.35, 0.125
22317, 0.41666666666667, 0.4, 0.125
22318, 0.41666666666667, 0.45, 0.125
22319, 0.41666666666667, 0.5, 0.125
22320, 0.41666666666667, 0.55, 0.125
22321, 0.41666666666667, 0.6, 0.125
22322, 0.41666666666667, 0.65, 0.125
22323, 0.41666666666667, 0.7, 0.125
22324, 0.41666666666667, 0.75, 0.125
22325, 0.41666666666667, 0.8, 0.125
22326, 0.41666666666667, 0.85, 0.125
22327, 0.41666666666667, 0.9, 0.125
22328, 0.41666666666667, 0.95, 0.125
22329, 0.41666666666667, 1, 0.125
22330, 0.41666666666667, 1.05, 0.125
22331, 0.41666666666667, 1.1, 0.125
22332, 0.41666666666667, 1.15, 0.125
22333, 0.41666666666667, 1.2, 0.125
22334, 0.41666666666667, 1.25, 0.125
22335, 0.41666666666667, 1.3, 0.125
22336, 0.41666666666667, 0.2, 0.16666666666667
22337, 0.41666666666667, 0.25, 0.16666666666667
22338, 0.41666666666667, 0.3, 0.16666666666667
22339, 0.41666666666667, 0.35, 0.16666666666667
22340, 0.41666666666667, 0.4, 0.16666666666667
22341, 0.41666666666667, 0.45, 0.16666666666667
22342, 0.41666666666667, 0.5, 0.16666666666667
22343, 0.41666666666667, 0.55, 0.16666666666667
22344, 0.41666666666667, 0.6, 0.16666666666667
22345, 0.41666666666667, 0.65, 0.16666666666667
22346, 0.41666666666667, 0.7, 0.16666666666667
22347, 0.41666666666667, 0.75, 0.16666666666667
22348, 0.41666666666667, 0.8, 0.16666666666667
22349, 0.41666666666667, 0.85, 0.16666666666667
22350, 0.41666666666667, 0.9, 0.16666666666667
22351, 0.41666666666667, 0.95, 0.16666666666667
22352, 0.41666666666667, 1, 0.16666666666667
22353, 0.41666666666667, 1.05, 0.16666666666667
22354, 0.41666666666667, 1.1, 0.16666666666667
22355, 0.41666666666667, 1.15, 0.16666666666667
22356, 0.41666666666667, 1.2, 0.16666666666667
22357, 0.41666666666667, 1.25, 0.16666666666667
22358, 0.41666666666667, 1.3, 0.16666666666667
22359, 0.41666666666667, 0.2, 0.20833333333333
22360, 0.41666666666667, 0.25, 0.20833333333333
22361, 0.41666666666667, 0.3, 0.20833333333333
22362, 0.41666666666667, 0.35, 0.20833333333333
22363, 0.41666666666667, 0.4, 0.20833333333333
22364, 0.41666666666667, 0.45, 0.20833333333333
22365, 0.41666666666667, 0.5, 0.20833333333333
22366, 0.41666666666667, 0.55, 0.20833333333333
22367, 0.41666666666667, 0.6, 0.20833333333333
22368, 0.41666666666667, 0.65, 0.20833333333333
22369, 0.41666666666667, 0.7, 0.20833333333333
22370, 0.41666666666667, 0.75, 0.20833333333333
22371, 0.41666666666667, 0.8, 0.20833333333333
22372, 0.41666666666667, 0.85, 0.20833333333333
22373, 0.41666666666667, 0.9, 0.20833333333333
22374, 0.41666666666667, 0.95, 0.20833333333333
22375, 0.41666666666667, 1, 0.20833333333333
22376, 0.41666666666667, 1.05, 0.20833333333333
22377, 0.41666666666667, 1.1, 0.20833333333333
22378, 0.41666666666667, 1.15, 0.20833333333333
22379, 0.41666666666667, 1.2, 0.20833333333333
22380, 0.41666666666667, 1.25, 0.20833333333333
22381, 0.41666666666667, 1.3, 0.20833333333333
22382, 0.41666666666667, 0.2, 0.25
22383, 0.41666666666667, 0.25, 0.25
22384, 0.41666666666667, 0.3, 0.25
22385, 0.41666666666667, 0.35, 0.25
22386, 0.41666666666667, 0.4, 0.25
22387, 0.41666666666667, 0.45, 0.25
22388, 0.41666666666667, 0.5, 0.25
22389, 0.41666666666667, 0.55, 0.25
22390, 0.41666666666667, 0.6, 0.25
22391, 0.41666666666667, 0.65, 0.25
22392, 0.41666666666667, 0.7, 0.25
22393, 0.41666666666667, 0.75, 0.25
22394, 0.41666666666667, 0.8, 0.25
22395, 0.41666666666667, 0.85, 0.25
22396, 0.41666666666667, 0.9, 0.25
22397, 0.41666666666667, 0.95, 0.25
22398, 0.41666666666667, 1, 0.25
22399, 0.41666666666667, 1.05, 0.25
22400, 0.41666666666667, 1.1, 0.25
22401, 0.41666666666667, 1.15, 0.25
22402, 0.41666666666667, 1.2, 0.25
22403, 0.41666666666667, 1.25, 0.25
22404, 0.41666666666667, 1.3, 0.25
22405, 0.41666666666667, 0.2, 0.29166666666667
22406, 0.41666666666667, 0.25, 0.29166666666667
22407, 0.41666666666667, 0.3, 0.29166666666667
22408, 0.41666666666667, 0.35, 0.29166666666667
22409, 0.41666666666667, 0.4, 0.29166666666667
22410, 0.41666666666667, 0.45, 0.29166666666667
22411, 0.41666666666667, 0.5, 0.29166666666667
22412, 0.41666666666667, 0.55, 0.29166666666667
22413, 0.41666666666667, 0.6, 0.29166666666667
22414, 0.41666666666667, 0.65, 0.29166666666667
22415, 0.41666666666667, 0.7, 0.29166666666667
22416, 0.41666666666667, 0.75, 0.29166666666667
22417, 0.41666666666667, 0.8, 0.29166666666667
22418, 0.41666666666667, 0.85, 0.29166666666667
22419, 0.41666666666667, 0.9, 0.29166666666667
22420, 0.41666666666667, 0.95, 0.29166666666667
22421, 0.41666666666667, 1, 0.29166666666667
22422, 0.41666666666667, 1.05, 0.29166666666667
22423, 0.41666666666667, 1.1, 0.29166666666667
22424, 0.41666666666667, 1.15, 0.29166666666667
22425, 0.41666666666667, 1.2, 0.29166666666667
22426, 0.41666666666667, 1.25, 0.29166666666667
22427, 0.41666666666667, 1.3, 0.29166666666667
22428, 0.41666666666667, 0.2, 0.33333333333333
22429, 0.41666666666667, 0.25, 0.33333333333333
22430, 0.41666666666667, 0.3, 0.33333333333333
22431, 0.41666666666667, 0.35, 0.33333333333333
22432, 0.41666666666667, 0.4, 0.33333333333333
22433, 0.41666666666667, 0.45, 0.33333333333333
22434, 0.41666666666667, 0.5, 0.33333333333333
22435, 0.41666666666667, 0.55, 0.33333333333333
22436, 0.41666666666667, 0.6, 0.33333333333333
22437, 0.41666666666667, 0.65, 0.33333333333333
22438, 0.41666666666667, 0.7, 0.33333333333333
22439, 0.41666666666667, 0.75, 0.33333333333333
22440, 0.41666666666667, 0.8, 0.33333333333333
22441, 0.41666666666667, 0.85, 0.33333333333333
22442, 0.41666666666667, 0.9, 0.33333333333333
22443, 0.41666666666667, 0.95, 0.33333333333333
22444, 0.41666666666667, 1, 0.33333333333333
22445, 0.41666666666667, 1.05, 0.33333333333333
22446, 0.41666666666667, 1.1, 0.33333333333333
22447, 0.41666666666667, 1.15, 0.33333333333333
22448, 0.41666666666667, 1.2, 0.33333333333333
22449, 0.41666666666667, 1.25, 0.33333333333333
22450, 0.41666666666667, 1.3, 0.33333333333333
22451, 0.41666666666667, 0.2, 0.375
22452, 0.41666666666667, 0.25, 0.375
22453, 0.41666666666667, 0.3, 0.375
22454, 0.41666666666667, 0.35, 0.375
22455, 0.41666666666667, 0.4, 0.375
22456, 0.41666666666667, 0.45, 0.375
22457, 0.41666666666667, 0.5, 0.375
22458, 0.41666666666667, 0.55, 0.375
22459, 0.41666666666667, 0.6, 0.375
22460, 0.41666666666667, 0.65, 0.375
22461, 0.41666666666667, 0.7, 0.375
22462, 0.41666666666667, 0.75, 0.375
22463, 0.41666666666667, 0.8, 0.375
22464, 0.41666666666667, 0.85, 0.375
22465, 0.41666666666667, 0.9, 0.375
22466, 0.41666666666667, 0.95, 0.375
22467, 0.41666666666667, 1, 0.375
22468, 0.41666666666667, 1.05, 0.375
22469, 0.41666666666667, 1.1, 0.375
22470, 0.41666666666667, 1.15, 0.375
22471, 0.41666666666667, 1.2, 0.375
22472, 0.41666666666667, 1.25, 0.375
22473, 0.41666666666667, 1.3, 0.375
22474, 0.41666666666667, 0.2, 0.41666666666667
22475, 0.41666666666667, 0.25, 0.41666666666667
22476, 0.41666666666667, 0.3, 0.41666666666667
22477, 0.41666666666667, 0.35, 0.41666666666667
22478, 0.41666666666667, 0.4, 0.41666666666667
22479, 0.41666666666667, 0.45, 0.41666666666667
22480, 0.41666666666667, 0.5, 0.41666666666667
22481, 0.41666666666667, 0.55, 0.41666666666667
22482, 0.41666666666667, 0.6, 0.41666666666667
22483, 0.41666666666667, 0.65, 0.41666666666667
22484, 0.41666666666667, 0.7, 0.41666666666667
22485, 0.41666666666667, 0.75, 0.41666666666667
22486, 0.41666666666667, 0.8, 0.41666666666667
22487, 0.41666666666667, 0.85, 0.41666666666667
22488, 0.41666666666667, 0.9, 0.41666666666667
22489, 0.41666666666667, 0.95, 0.41666666666667
22490, 0.41666666666667, 1, 0.41666666666667
22491, 0.41666666666667, 1.05, 0.41666666666667
22492, 0.41666666666667, 1.1, 0.41666666666667
22493, 0.41666666666667, 1.15, 0.41666666666667
22494, 0.41666666666667, 1.2, 0.41666666666667
22495, 0.41666666666667, 1.25, 0.41666666666667
22496, 0.41666666666667, 1.3, 0.41666666666667
22497, 0.41666666666667, 0.2, 0.45833333333333
22498, 0.41666666666667, 0.25, 0.45833333333333
22499, 0.41666666666667, 0.3, 0.45833333333333
22500, 0.41666666666667, 0.35, 0.45833333333333
22501, 0.41666666666667, 0.4, 0.45833333333333
22502, 0.41666666666667, 0.45, 0.45833333333333
22503, 0.41666666666667, 0.5, 0.45833333333333
22504, 0.41666666666667, 0.55, 0.45833333333333
22505, 0.41666666666667, 0.6, 0.45833333333333
22506, 0.41666666666667, 0.65, 0.45833333333333
22507, 0.41666666666667, 0.7, 0.45833333333333
22508, 0.41666666666667, 0.75, 0.45833333333333
22509, 0.41666666666667, 0.8, 0.45833333333333
22510, 0.41666666666667, 0.85, 0.45833333333333
22511, 0.41666666666667, 0.9, 0.45833333333333
22512, 0.41666666666667, 0.95, 0.45833333333333
22513, 0.41666666666667, 1, 0.45833333333333
22514, 0.41666666666667, 1.05, 0.45833333333333
22515, 0.41666666666667, 1.1, 0.45833333333333
22516, 0.41666666666667, 1.15, 0.45833333333333
22517, 0.41666666666667, 1.2, 0.45833333333333
22518, 0.41666666666667, 1.25, 0.45833333333333
22519, 0.41666666666667, 1.3, 0.45833333333333
22520, 0.45833333333333, 0.2, 0.041666666666667
22521, 0.45833333333333, 0.25, 0.041666666666667
22522, 0.45833333333333, 0.3, 0.041666666666667
22523, 0.45833333333333, 0.35, 0.041666666666667
22524, 0.45833333333333, 0.4, 0.041666666666667
22525, 0.45833333333333, 0.45, 0.041666666666667
22526, 0.45833333333333, 0.5, 0.041666666666667
22527, 0.45833333333333, 0.55, 0.041666666666667
22528, 0.45833333333333, 0.6, 0.041666666666667
22529, 0.45833333333333, 0.65, 0.041666666666667
22530, 0.45833333333333, 0.7, 0.041666666666667
22531, 0.45833333333333, 0.75, 0.041666666666667
22532, 0.45833333333333, 0.8, 0.041666666666667
22533, 0.45833333333333, 0.85, 0.041666666666667
22534, 0.45833333333333, 0.9, 0.041666666666667
22535, 0.45833333333333, 0.95, 0.041666666666667
22536, 0.45833333333333, 1, 0.041666666666667
22537, 0.45833333333333, 1.05, 0.041666666666667
22538, 0.45833333333333, 1.1, 0.041666666666667
22539, 0.45833333333333, 1.15, 0.041666666666667
22540, 0.45833333333333, 1.2, 0.041666666666667
22541, 0.45833333333333, 1.25, 0.041666666666667
22542, 0.45833333333333, 1.3, 0.041666666666667
22543, 0.45833333333333, 0.2, 0.083333333333333
22544, 0.45833333333333, 0.25, 0.083333333333333
22545, 0.45833333333333, 0.3, 0.083333333333333
22546, 0.45833333333333, 0.35, 0.083333333333333
22547, 0.45833333333333, 0.4, 0.083333333333333
22548, 0.45833333333333, 0.45, 0.083333333333333
22549, 0.45833333333333, 0.5, 0.083333333333333
22550, 0.45833333333333, 0.55, 0.083333333333333
22551, 0.45833333333333, 0.6, 0.083333333333333
22552, 0.45833333333333, 0.65, 0.083333333333333
22553, 0.45833333333333, 0.7, 0.083333333333333
22554, 0.45833333333333, 0.75, 0.083333333333333
22555, 0.45833333333333, 0.8, 0.083333333333333
22556, 0.45833333333333, 0.85, 0.083333333333333
22557, 0.45833333333333, 0.9, 0.083333333333333
22558, 0.45833333333333, 0.95, 0.083333333333333
22559, 0.45833333333333, 1, 0.083333333333333
22560, 0.45833333333333, 1.05, 0.083333333333333
22561, 0.45833333333333, 1.1, 0.083333333333333
22562, 0.45833333333333, 1.15, 0.083333333333333
22563, 0.45833333333333, 1.2, 0.083333333333333
22564, 0.45833333333333, 1.25, 0.083333333333333
22565, 0.45833333333333, 1.3, 0.083333333333333
22566, 0.45833333333333, 0.2, 0.125
22567, 0.45833333333333, 0.25, 0.125
22568, 0.45833333333333, 0.3, 0.125
22569, 0.45833333333333, 0.35, 0.125
22570, 0.45833333333333, 0.4, 0.125
22571, 0.45833333333333, 0.45, 0.125
22572, 0.45833333333333, 0.5, 0.125
22573, 0.45833333333333, 0.55, 0.125
22574, 0.45833333333333, 0.6, 0.125
22575, 0.45833333333333, 0.65, 0.125
22576, 0.45833333333333, 0.7, 0.125
22577, 0.45833333333333, 0.75, 0.125
22578, 0.45833333333333, 0.8, 0.125
22579, 0.45833333333333, 0.85, 0.125
22580, 0.45833333333333, 0.9, 0.125
22581, 0.45833333333333, 0.95, 0.125
22582, 0.45833333333333, 1, 0.125
22583, 0.45833333333333, 1.05, 0.125
22584, 0.45833333333333, 1.1, 0.125
22585, 0.45833333333333, 1.15, 0.125
22586, 0.45833333333333, 1.2, 0.125
22587, 0.45833333333333, 1.25, 0.125
22588, 0.45833333333333, 1.3, 0.125
22589, 0.45833333333333, 0.2, 0.16666666666667
22590, 0.45833333333333, 0.25, 0.16666666666667
22591, 0.45833333333333, 0.3, 0.16666666666667
22592, 0.45833333333333, 0.35, 0.16666666666667
22593, 0.45833333333333, 0.4, 0.16666666666667
22594, 0.45833333333333, 0.45, 0.16666666666667
22595, 0.45833333333333, 0.5, 0.16666666666667
22596, 0.45833333333333, 0.55, 0.16666666666667
22597, 0.45833333333333, 0.6, 0.16666666666667
22598, 0.45833333333333, 0.65, 0.16666666666667
22599, 0.45833333333333, 0.7, 0.16666666666667
22600, 0.45833333333333, 0.75, 0.16666666666667
22601, 0.45833333333333, 0.8, 0.16666666666667
22602, 0.45833333333333, 0.85, 0.16666666666667
22603, 0.45833333333333, 0.9, 0.16666666666667
22604, 0.45833333333333, 0.95, 0.16666666666667
22605, 0.45833333333333, 1, 0.16666666666667
22606, 0.45833333333333, 1.05, 0.16666666666667
22607, 0.45833333333333, 1.1, 0.16666666666667
22608, 0.45833333333333, 1.15, 0.16666666666667
22609, 0.45833333333333, 1.2, 0.16666666666667
22610, 0.45833333333333, 1.25, 0.16666666666667
22611, 0.45833333333333, 1.3, 0.16666666666667
22612, 0.45833333333333, 0.2, 0.20833333333333
22613, 0.45833333333333, 0.25, 0.20833333333333
22614, 0.45833333333333, 0.3, 0.20833333333333
22615, 0.45833333333333, 0.35, 0.20833333333333
22616, 0.45833333333333, 0.4, 0.20833333333333
22617, 0.45833333333333, 0.45, 0.20833333333333
22618, 0.45833333333333, 0.5, 0.20833333333333
22619, 0.45833333333333, 0.55, 0.20833333333333
22620, 0.45833333333333, 0.6, 0.20833333333333
22621, 0.45833333333333, 0.65, 0.20833333333333
22622, 0.45833333333333, 0.7, 0.20833333333333
22623, 0.45833333333333, 0.75, 0.20833333333333
22624, 0.45833333333333, 0.8, 0.20833333333333
22625, 0.45833333333333, 0.85, 0.20833333333333
22626, 0.45833333333333, 0.9, 0.20833333333333
22627, 0.45833333333333, 0.95, 0.20833333333333
22628, 0.45833333333333, 1, 0.20833333333333
22629, 0.45833333333333, 1.05, 0.20833333333333
22630, 0.45833333333333, 1.1, 0.20833333333333
22631, 0.45833333333333, 1.15, 0.20833333333333
22632, 0.45833333333333, 1.2, 0.20833333333333
22633, 0.45833333333333, 1.25, 0.20833333333333
22634, 0.45833333333333, 1.3, 0.20833333333333
22635, 0.45833333333333, 0.2, 0.25
22636, 0.45833333333333, 0.25, 0.25
22637, 0.45833333333333, 0.3, 0.25
22638, 0.45833333333333, 0.35, 0.25
22639, 0.45833333333333, 0.4, 0.25
22640, 0.45833333333333, 0.45, 0.25
22641, 0.45833333333333, 0.5, 0.25
22642, 0.45833333333333, 0.55, 0.25
22643, 0.45833333333333, 0.6, 0.25
22644, 0.45833333333333, 0.65, 0.25
22645, 0.45833333333333, 0.7, 0.25
22646, 0.45833333333333, 0.75, 0.25
22647, 0.45833333333333, 0.8, 0.25
22648, 0.45833333333333, 0.85, 0.25
22649, 0.45833333333333, 0.9, 0.25
22650, 0.45833333333333, 0.95, 0.25
22651, 0.45833333333333, 1, 0.25
22652, 0.45833333333333, 1.05, 0.25
22653, 0.45833333333333, 1.1, 0.25
22654, 0.45833333333333, 1.15, 0.25
22655, 0.45833333333333, 1.2, 0.25
22656, 0.45833333333333, 1.25, 0.25
22657, 0.45833333333333, 1.3, 0.25
22658, 0.45833333333333, 0.2, 0.29166666666667
22659, 0.45833333333333, 0.25, 0.29166666666667
22660, 0.45833333333333, 0.3, 0.29166666666667
22661, 0.45833333333333, 0.35, 0.29166666666667
22662, 0.45833333333333, 0.4, 0.29166666666667
22663, 0.45833333333333, 0.45, 0.29166666666667
22664, 0.45833333333333, 0.5, 0.29166666666667
22665, 0.45833333333333, 0.55, 0.29166666666667
22666, 0.45833333333333, 0.6, 0.29166666666667
22667, 0.45833333333333, 0.65, 0.29166666666667
22668, 0.45833333333333, 0.7, 0.29166666666667
22669, 0.45833333333333, 0.75, 0.29166666666667
22670, 0.45833333333333, 0.8, 0.29166666666667
22671, 0.45833333333333, 0.85, 0.29166666666667
22672, 0.45833333333333, 0.9, 0.29166666666667
22673, 0.45833333333333, 0.95, 0.29166666666667
22674, 0.45833333333333, 1, 0.29166666666667
22675, 0.45833333333333, 1.05, 0.29166666666667
22676, 0.45833333333333, 1.1, 0.29166666666667
22677, 0.45833333333333, 1.15, 0.29166666666667
22678, 0.45833333333333, 1.2, 0.29166666666667
22679, 0.45833333333333, 1.25, 0.29166666666667
22680, 0.45833333333333, 1.3, 0.29166666666667
22681, 0.45833333333333, 0.2, 0.33333333333333
22682, 0.45833333333333, 0.25, 0.33333333333333
22683, 0.45833333333333, 0.3, 0.33333333333333
22684, 0.45833333333333, 0.35, 0.33333333333333
22685, 0.45833333333333, 0.4, 0.33333333333333
22686, 0.45833333333333, 0.45, 0.33333333333333
22687, 0.45833333333333, 0.5, 0.33333333333333
22688, 0.45833333333333, 0.55, 0.33333333333333
22689, 0.45833333333333, 0.6, 0.33333333333333
22690, 0.45833333333333, 0.65, 0.33333333333333
22691, 0.45833333333333, 0.7, 0.33333333333333
22692, 0.45833333333333, 0.75, 0.33333333333333
22693, 0.45833333333333, 0.8, 0.33333333333333
22694, 0.45833333333333, 0.85, 0.33333333333333
22695, 0.45833333333333, 0.9, 0.33333333333333
22696, 0.45833333333333, 0.95, 0.33333333333333
22697, 0.45833333333333, 1, 0.33333333333333
22698, 0.45833333333333, 1.05, 0.33333333333333
22699, 0.45833333333333, 1.1, 0.33333333333333
22700, 0.45833333333333, 1.15, 0.33333333333333
22701, 0.45833333333333, 1.2, 0.33333333333333
22702, 0.45833333333333, 1.25, 0.33333333333333
22703, 0.45833333333333, 1.3, 0.33333333333333
22704, 0.45833333333333, 0.2, 0.375
22705, 0.45833333333333, 0.25, 0.375
22706, 0.45833333333333, 0.3, 0.375
22707, 0.45833333333333, 0.35, 0.375
22708, 0.45833333333333, 0.4, 0.375
22709, 0.45833333333333, 0.45, 0.375
22710, 0.45833333333333, 0.5, 0.375
22711, 0.45833333333333, 0.55, 0.375
22712, 0.45833333333333, 0.6, 0.375
22713, 0.45833333333333, 0.65, 0.375
22714, 0.45833333333333, 0.7, 0.375
22715, 0.45833333333333, 0.75, 0.375
22716, 0.45833333333333, 0.8, 0.375
22717, 0.45833333333333, 0.85, 0.375
22718, 0.45833333333333, 0.9, 0.375
22719, 0.45833333333333, 0.95, 0.375
22720, 0.45833333333333, 1, 0.375
22721, 0.45833333333333, 1.05, 0.375
22722, 0.45833333333333, 1.1, 0.375
22723, 0.45833333333333, 1.15, 0.375
22724, 0.45833333333333, 1.2, 0.375
22725, 0.45833333333333, 1.25, 0.375
22726, 0.45833333333333, 1.3, 0.375
22727, 0.45833333333333, 0.2, 0.41666666666667
22728, 0.45833333333333, 0.25, 0.41666666666667
22729, 0.45833333333333, 0.3, 0.41666666666667
22730, 0.45833333333333, 0.35, 0.41666666666667
22731, 0.45833333333333, 0.4, 0.41666666666667
22732, 0.45833333333333, 0.45, 0.41666666666667
22733, 0.45833333333333, 0.5, 0.41666666666667
22734, 0.45833333333333, 0.55, 0.41666666666667
22735, 0.45833333333333, 0.6, 0.41666666666667
22736, 0.45833333333333, 0.65, 0.41666666666667
22737, 0.45833333333333, 0.7, 0.41666666666667
22738, 0.45833333333333, 0.75, 0.41666666666667
22739, 0.45833333333333, 0.8, 0.41666666666667
22740, 0.45833333333333, 0.85, 0.41666666666667
22741, 0.45833333333333, 0.9, 0.41666666666667
22742, 0.45833333333333, 0.95, 0.41666666666667
22743, 0.45833333333333, 1, 0.41666666666667
22744, 0.45833333333333, 1.05, 0.41666666666667
22745, 0.45833333333333, 1.1, 0.41666666666667
22746, 0.45833333333333, 1.15, 0.41666666666667
22747, 0.45833333333333, 1.2, 0.41666666666667
22748, 0.45833333333333, 1.25, 0.41666666666667
22749, 0.45833333333333, 1.3, 0.41666666666667
22750, 0.45833333333333, 0.2, 0.45833333333333
22751, 0.45833333333333, 0.25, 0.45833333333333
22752, 0.45833333333333, 0.3, 0.45833333333333
22753, 0.45833333333333, 0.35, 0.45833333333333
22754, 0.45833333333333, 0.4, 0.45833333333333
22755, 0.45833333333333, 0.45, 0.45833333333333
22756, 0.45833333333333, 0.5, 0.45833333333333
22757, 0.45833333333333, 0.55, 0.45833333333333
22758, 0.45833333333333, 0.6, 0.45833333333333
22759, 0.45833333333333, 0.65, 0.45833333333333
22760, 0.45833333333333, 0.7, 0.45833333333333
22761, 0.45833333333333, 0.75, 0.45833333333333
22762, 0.45833333333333, 0.8, 0.45833333333333
22763, 0.45833333333333, 0.85, 0.45833333333333
22764, 0.45833333333333, 0.9, 0.45833333333333
22765, 0.45833333333333, 0.95, 0.45833333333333
22766, 0.45833333333333, 1, 0.45833333333333
22767, 0.45833333333333, 1.05, 0.45833333333333
22768, 0.45833333333333, 1.1, 0.45833333333333
22769, 0.45833333333333, 1.15, 0.45833333333333
22770, 0.45833333333333, 1.2, 0.45833333333333
22771, 0.45833333333333, 1.25, 0.45833333333333
22772, 0.45833333333333, 1.3, 0.45833333333333
22773, 0.5, 0.2, 0.041666666666667
22774, 0.5, 0.25, 0.041666666666667
22775, 0.5, 0.3, 0.041666666666667
22776, 0.5, 0.35, 0.041666666666667
22777, 0.5, 0.4, 0.041666666666667
22778, 0.5, 0.45, 0.041666666666667
22779, 0.5, 0.5, 0.041666666666667
22780, 0.5, 0.55, 0.041666666666667
22781, 0.5, 0.6, 0.041666666666667
22782, 0.5, 0.65, 0.041666666666667
22783, 0.5, 0.7, 0.041666666666667
22784, 0.5, 0.75, 0.041666666666667
22785, 0.5, 0.8, 0.041666666666667
22786, 0.5, 0.85, 0.041666666666667
22787, 0.5, 0.9, 0.041666666666667
22788, 0.5, 0.95, 0.041666666666667
22789, 0.5, 1, 0.041666666666667
22790, 0.5, 1.05, 0.041666666666667
22791, 0.5, 1.1, 0.041666666666667
22792, 0.5, 1.15, 0.041666666666667
22793, 0.5, 1.2, 0.041666666666667
22794, 0.5, 1.25, 0.041666666666667
22795, 0.5, 1.3, 0.041666666666667
22796, 0.5, 0.2, 0.083333333333333
22797, 0.5, 0.25, 0.083333333333333
22798, 0.5, 0.3, 0.083333333333333
22799, 0.5, 0.35, 0.083333333333333
22800, 0.5, 0.4, 0.083333333333333
22801, 0.5, 0.45, 0.083333333333333
22802, 0.5, 0.5, 0.083333333333333
22803, 0.5, 0.55, 0.083333333333333
22804, 0.5, 0.6, 0.083333333333333
22805, 0.5, 0.65, 0.083333333333333
22806, 0.5, 0.7, 0.083333333333333
22807, 0.5, 0.75, 0.083333333333333
22808, 0.5, 0.8, 0.083333333333333
22809, 0.5, 0.85, 0.083333333333333
22810, 0.5, 0.9, 0.083333333333333
22811, 0.5, 0.95, 0.083333333333333
22812, 0.5, 1, 0.083333333333333
22813, 0.5, 1.05, 0.083333333333333
22814, 0.5, 1.1, 0.083333333333333
22815, 0.5, 1.15, 0.083333333333333
22816, 0.5, 1.2, 0.083333333333333
22817, 0.5, 1.25, 0.083333333333333
22818, 0.5, 1.3, 0.083333333333333
22819, 0.5, 0.2, 0.125
22820, 0.5, 0.25, 0.125
22821, 0.5, 0.3, 0.125
22822, 0.5, 0.35, 0.125
22823, 0.5, 0.4, 0.125
22824, 0.5, 0.45, 0.125
22825, 0.5, 0.5, 0.125
22826, 0.5, 0.55, 0.125
22827, 0.5, 0.6, 0.125
22828, 0.5, 0.65, 0.125
22829, 0.5, 0.7, 0.125
22830, 0.5, 0.75, 0.125
22831, 0.5, 0.8, 0.125
22832, 0.5, 0.85, 0.125
22833, 0.5, 0.9, 0.125
22834, 0.5, 0.95, 0.125
22835, 0.5, 1, 0.125
22836, 0.5, 1.05, 0.125
22837, 0.5, 1.1, 0.125
22838, 0.5, 1.15, 0.125
22839, 0.5, 1.2, 0.125
22840, 0.5, 1.25, 0.125
22841, 0.5, 1.3, 0.125
22842, 0.5, 0.2, 0.16666666666667
22843, 0.5, 0.25, 0.16666666666667
22844, 0.5, 0.3, 0.16666666666667
22845, 0.5, 0.35, 0.16666666666667
22846, 0.5, 0.4, 0.16666666666667
22847, 0.5, 0.45, 0.16666666666667
22848, 0.5, 0.5, 0.16666666666667
22849, 0.5, 0.55, 0.16666666666667
22850, 0.5, 0.6, 0.16666666666667
22851, 0.5, 0.65, 0.16666666666667
22852, 0.5, 0.7, 0.16666666666667
22853, 0.5, 0.75, 0.16666666666667
22854, 0.5, 0.8, 0.16666666666667
22855, 0.5, 0.85, 0.16666666666667
22856, 0.5, 0.9, 0.16666666666667
22857, 0.5, 0.95, 0.16666666666667
22858, 0.5, 1, 0.16666666666667
22859, 0.5, 1.05, 0.16666666666667
22860, 0.5, 1.1, 0.16666666666667
22861, 0.5, 1.15, 0.16666666666667
22862, 0.5, 1.2, 0.16666666666667
22863, 0.5, 1.25, 0.16666666666667
22864, 0.5, 1.3, 0.16666666666667
22865, 0.5, 0.2, 0.20833333333333
22866, 0.5, 0.25, 0.20833333333333
22867, 0.5, 0.3, 0.20833333333333
22868, 0.5, 0.35, 0.20833333333333
22869, 0.5, 0.4, 0.20833333333333
22870, 0.5, 0.45, 0.20833333333333
22871, 0.5, 0.5, 0.20833333333333
22872, 0.5, 0.55, 0.20833333333333
22873, 0.5, 0.6, 0.20833333333333
22874, 0.5, 0.65, 0.20833333333333
22875, 0.5, 0.7, 0.20833333333333
22876, 0.5, 0.75, 0.20833333333333
22877, 0.5, 0.8, 0.20833333333333
22878, 0.5, 0.85, 0.20833333333333
22879, 0.5, 0.9, 0.20833333333333
22880, 0.5, 0.95, 0.20833333333333
22881, 0.5, 1, 0.20833333333333
22882, 0.5, 1.05, 0.20833333333333
22883, 0.5, 1.1, 0.20833333333333
22884, 0.5, 1.15, 0.20833333333333
22885, 0.5, 1.2, 0.20833333333333
22886, 0.5, 1.25, 0.20833333333333
22887, 0.5, 1.3, 0.20833333333333
22888, 0.5, 0.2, 0.25
22889, 0.5, 0.25, 0.25
22890, 0.5, 0.3, 0.25
22891, 0.5, 0.35, 0.25
22892, 0.5, 0.4, 0.25
22893, 0.5, 0.45, 0.25
22894, 0.5, 0.5, 0.25
22895, 0.5, 0.55, 0.25
22896, 0.5, 0.6, 0.25
22897, 0.5, 0.65, 0.25
22898, 0.5, 0.7, 0.25
22899, 0.5, 0.75, 0.25
22900, 0.5, 0.8, 0.25
22901, 0.5, 0.85, 0.25
22902, 0.5, 0.9, 0.25
22903, 0.5, 0.95, 0.25
22904, 0.5, 1, 0.25
22905, 0.5, 1.05, 0.25
22906, 0.5, 1.1, 0.25
22907, 0.5, 1.15, 0.25
22908, 0.5, 1.2, 0.25
22909, 0.5, 1.25, 0.25
22910, 0.5, 1.3, 0.25
22911, 0.5, 0.2, 0.29166666666667
22912, 0.5, 0.25, 0.29166666666667
22913, 0.5, 0.3, 0.29166666666667
22914, 0.5, 0.35, 0.29166666666667
22915, 0.5, 0.4, 0.29166666666667
22916, 0.5, 0.45, 0.29166666666667
22917, 0.5, 0.5, 0.29166666666667
22918, 0.5, 0.55, 0.29166666666667
22919, 0.5, 0.6, 0.29166666666667
22920, 0.5, 0.65, 0.29166666666667
22921, 0.5, 0.7, 0.29166666666667
22922, 0.5, 0.75, 0.29166666666667
22923, 0.5, 0.8, 0.29166666666667
22924, 0.5, 0.85, 0.29166666666667
22925, 0.5, 0.9, 0.29166666666667
22926, 0.5, 0.95, 0.29166666666667
22927, 0.5, 1, 0.29166666666667
22928, 0.5, 1.05, 0.29166666666667
22929, 0.5, 1.1, 0.29166666666667
22930, 0.5, 1.15, 0.29166666666667
22931, 0.5, 1.2, 0.29166666666667
22932, 0.5, 1.25, 0.29166666666667
22933, 0.5, 1.3, 0.29166666666667
22934, 0.5, 0.2, 0.33333333333333
22935, 0.5, 0.25, 0.33333333333333
22936, 0.5, 0.3, 0.33333333333333
22937, 0.5, 0.35, 0.33333333333333
22938, 0.5, 0.4, 0.33333333333333
22939, 0.5, 0.45, 0.33333333333333
22940, 0.5, 0.5, 0.33333333333333
22941, 0.5, 0.55, 0.33333333333333
22942, 0.5, 0.6, 0.33333333333333
22943, 0.5, 0.65, 0.33333333333333
22944, 0.5, 0.7, 0.33333333333333
22945, 0.5, 0.75, 0.33333333333333
22946, 0.5, 0.8, 0.33333333333333
22947, 0.5, 0.85, 0.33333333333333
22948, 0.5, 0.9, 0.33333333333333
22949, 0.5, 0.95, 0.33333333333333
22950, 0.5, 1, 0.33333333333333
22951, 0.5, 1.05, 0.33333333333333
22952, 0.5, 1.1, 0.33333333333333
22953, 0.5, 1.15, 0.33333333333333
22954, 0.5, 1.2, 0.33333333333333
22955, 0.5, 1.25, 0.33333333333333
22956, 0.5, 1.3, 0.33333333333333
22957, 0.5, 0.2, 0.375
22958, 0.5, 0.25, 0.375
22959, 0.5, 0.3, 0.375
22960, 0.5, 0.35, 0.375
22961, 0.5, 0.4, 0.375
22962, 0.5, 0.45, 0.375
22963, 0.5, 0.5, 0.375
22964, 0.5, 0.55, 0.375
22965, 0.5, 0.6, 0.375
22966, 0.5, 0.65, 0.375
22967, 0.5, 0.7, 0.375
22968, 0.5, 0.75, 0.375
22969, 0.5, 0.8, 0.375
22970, 0.5, 0.85, 0.375
22971, 0.5, 0.9, 0.375
22972, 0.5, 0.95, 0.375
22973, 0.5, 1, 0.375
22974, 0.5, 1.05, 0.375
22975, 0.5, 1.1, 0.375
22976, 0.5, 1.15, 0.375
22977, 0.5, 1.2, 0.375
22978, 0.5, 1.25, 0.375
22979, 0.5, 1.3, 0.375
22980, 0.5, 0.2, 0.41666666666667
22981, 0.5, 0.25, 0.41666666666667
22982, 0.5, 0.3, 0.41666666666667
22983, 0.5, 0.35, 0.41666666666667
22984, 0.5, 0.4, 0.41666666666667
22985, 0.5, 0.45, 0.41666666666667
22986, 0.5, 0.5, 0.41666666666667
22987, 0.5, 0.55, 0.41666666666667
22988, 0.5, 0.6, 0.41666666666667
22989, 0.5, 0.65, 0.41666666666667
22990, 0.5, 0.7, 0.41666666666667
22991, 0.5, 0.75, 0.41666666666667
22992, 0.5, 0.8, 0.41666666666667
22993, 0.5, 0.85, 0.41666666666667
22994, 0.5, 0.9, 0.41666666666667
22995, 0.5, 0.95, 0.41666666666667
22996, 0.5, 1, 0.41666666666667
22997, 0.5, 1.05, 0.41666666666667
22998, 0.5, 1.1, 0.41666666666667
22999, 0.5, 1.15, 0.41666666666667
23000, 0.5, 1.2, 0.41666666666667
23001, 0.5, 1.25, 0.41666666666667
23002, 0.5, 1.3, 0.41666666666667
23003, 0.5, 0.2, 0.45833333333333
23004, 0.5, 0.25, 0.45833333333333
23005, 0.5, 0.3, 0.45833333333333
23006, 0.5, 0.35, 0.45833333333333
23007, 0.5, 0.4, 0.45833333333333
23008, 0.5, 0.45, 0.45833333333333
23009, 0.5, 0.5, 0.45833333333333
23010, 0.5, 0.55, 0.45833333333333
23011, 0.5, 0.6, 0.45833333333333
23012, 0.5, 0.65, 0.45833333333333
23013, 0.5, 0.7, 0.45833333333333
23014, 0.5, 0.75, 0.45833333333333
23015, 0.5, 0.8, 0.45833333333333
23016, 0.5, 0.85, 0.45833333333333
23017, 0.5, 0.9, 0.45833333333333
23018, 0.5, 0.95, 0.45833333333333
23019, 0.5, 1, 0.45833333333333
23020, 0.5, 1.05, 0.45833333333333
23021, 0.5, 1.1, 0.45833333333333
23022, 0.5, 1.15, 0.45833333333333
23023, 0.5, 1.2, 0.45833333333333
23024, 0.5, 1.25, 0.45833333333333
23025, 0.5, 1.3, 0.45833333333333
23026, 0.54166666666667, 0.2, 0.041666666666667
23027, 0.54166666666667, 0.25, 0.041666666666667
23028, 0.54166666666667, 0.3, 0.041666666666667
23029, 0.54166666666667, 0.35, 0.041666666666667
23030, 0.54166666666667, 0.4, 0.041666666666667
23031, 0.54166666666667, 0.45, 0.041666666666667
23032, 0.54166666666667, 0.5, 0.041666666666667
23033, 0.54166666666667, 0.55, 0.041666666666667
23034, 0.54166666666667, 0.6, 0.041666666666667
23035, 0.54166666666667, 0.65, 0.041666666666667
23036, 0.54166666666667, 0.7, 0.041666666666667
23037, 0.54166666666667, 0.75, 0.041666666666667
23038, 0.54166666666667, 0.8, 0.041666666666667
23039, 0.54166666666667, 0.85, 0.041666666666667
23040, 0.54166666666667, 0.9, 0.041666666666667
23041, 0.54166666666667, 0.95, 0.041666666666667
23042, 0.54166666666667, 1, 0.041666666666667
23043, 0.54166666666667, 1.05, 0.041666666666667
23044, 0.54166666666667, 1.1, 0.041666666666667
23045, 0.54166666666667, 1.15, 0.041666666666667
23046, 0.54166666666667, 1.2, 0.041666666666667
23047, 0.54166666666667, 1.25, 0.041666666666667
23048, 0.54166666666667, 1.3, 0.041666666666667
23049, 0.54166666666667, 0.2, 0.083333333333333
23050, 0.54166666666667, 0.25, 0.083333333333333
23051, 0.54166666666667, 0.3, 0.083333333333333
23052, 0.54166666666667, 0.35, 0.083333333333333
23053, 0.54166666666667, 0.4, 0.083333333333333
23054, 0.54166666666667, 0.45, 0.083333333333333
23055, 0.54166666666667, 0.5, 0.083333333333333
23056, 0.54166666666667, 0.55, 0.083333333333333
23057, 0.54166666666667, 0.6, 0.083333333333333
23058, 0.54166666666667, 0.65, 0.083333333333333
23059, 0.54166666666667, 0.7, 0.083333333333333
23060, 0.54166666666667, 0.75, 0.083333333333333
23061, 0.54166666666667, 0.8, 0.083333333333333
23062, 0.54166666666667, 0.85, 0.083333333333333
23063, 0.54166666666667, 0.9, 0.083333333333333
23064, 0.54166666666667, 0.95, 0.083333333333333
23065, 0.54166666666667, 1, 0.083333333333333
23066, 0.54166666666667, 1.05, 0.083333333333333
23067, 0.54166666666667, 1.1, 0.083333333333333
23068, 0.54166666666667, 1.15, 0.083333333333333
23069, 0.54166666666667, 1.2, 0.083333333333333
23070, 0.54166666666667, 1.25, 0.083333333333333
23071, 0.54166666666667, 1.3, 0.083333333333333
23072, 0.54166666666667, 0.2, 0.125
23073, 0.54166666666667, 0.25, 0.125
23074, 0.54166666666667, 0.3, 0.125
23075, 0.54166666666667, 0.35, 0.125
23076, 0.54166666666667, 0.4, 0.125
23077, 0.54166666666667, 0.45, 0.125
23078, 0.54166666666667, 0.5, 0.125
23079, 0.54166666666667, 0.55, 0.125
23080, 0.54166666666667, 0.6, 0.125
23081, 0.54166666666667, 0.65, 0.125
23082, 0.54166666666667, 0.7, 0.125
23083, 0.54166666666667, 0.75, 0.125
23084, 0.54166666666667, 0.8, 0.125
23085, 0.54166666666667, 0.85, 0.125
23086, 0.54166666666667, 0.9, 0.125
23087, 0.54166666666667, 0.95, 0.125
23088, 0.54166666666667, 1, 0.125
23089, 0.54166666666667, 1.05, 0.125
23090, 0.54166666666667, 1.1, 0.125
23091, 0.54166666666667, 1.15, 0.125
23092, 0.54166666666667, 1.2, 0.125
23093, 0.54166666666667, 1.25, 0.125
23094, 0.54166666666667, 1.3, 0.125
23095, 0.54166666666667, 0.2, 0.16666666666667
23096, 0.54166666666667, 0.25, 0.16666666666667
23097, 0.54166666666667, 0.3, 0.16666666666667
23098, 0.54166666666667, 0.35, 0.16666666666667
23099, 0.54166666666667, 0.4, 0.16666666666667
23100, 0.54166666666667, 0.45, 0.16666666666667
23101, 0.54166666666667, 0.5, 0.16666666666667
23102, 0.54166666666667, 0.55, 0.16666666666667
23103, 0.54166666666667, 0.6, 0.16666666666667
23104, 0.54166666666667, 0.65, 0.16666666666667
23105, 0.54166666666667, 0.7, 0.16666666666667
23106, 0.54166666666667, 0.75, 0.16666666666667
23107, 0.54166666666667, 0.8, 0.16666666666667
23108, 0.54166666666667, 0.85, 0.16666666666667
23109, 0.54166666666667, 0.9, 0.16666666666667
23110, 0.54166666666667, 0.95, 0.16666666666667
23111, 0.54166666666667, 1, 0.16666666666667
23112, 0.54166666666667, 1.05, 0.16666666666667
23113, 0.54166666666667, 1.1, 0.16666666666667
23114, 0.54166666666667, 1.15, 0.16666666666667
23115, 0.54166666666667, 1.2, 0.16666666666667
23116, 0.54166666666667, 1.25, 0.16666666666667
23117, 0.54166666666667, 1.3, 0.16666666666667
23118, 0.54166666666667, 0.2, 0.20833333333333
23119, 0.54166666666667, 0.25, 0.20833333333333
23120, 0.54166666666667, 0.3, 0.20833333333333
23121, 0.54166666666667, 0.35, 0.20833333333333
23122, 0.54166666666667, 0.4, 0.20833333333333
23123, 0.54166666666667, 0.45, 0.20833333333333
23124, 0.54166666666667, 0.5, 0.20833333333333
23125, 0.54166666666667, 0.55, 0.20833333333333
23126, 0.54166666666667, 0.6, 0.20833333333333
23127, 0.54166666666667, 0.65, 0.20833333333333
23128, 0.54166666666667, 0.7, 0.20833333333333
23129, 0.54166666666667, 0.75, 0.20833333333333
23130, 0.54166666666667, 0.8, 0.20833333333333
23131, 0.54166666666667, 0.85, 0.20833333333333
23132, 0.54166666666667, 0.9, 0.20833333333333
23133, 0.54166666666667, 0.95, 0.20833333333333
23134, 0.54166666666667, 1, 0.20833333333333
23135, 0.54166666666667, 1.05, 0.20833333333333
23136, 0.54166666666667, 1.1, 0.20833333333333
23137, 0.54166666666667, 1.15, 0.20833333333333
23138, 0.54166666666667, 1.2, 0.20833333333333
23139, 0.54166666666667, 1.25, 0.20833333333333
23140, 0.54166666666667, 1.3, 0.20833333333333
23141, 0.54166666666667, 0.2, 0.25
23142, 0.54166666666667, 0.25, 0.25
23143, 0.54166666666667, 0.3, 0.25
23144, 0.54166666666667, 0.35, 0.25
