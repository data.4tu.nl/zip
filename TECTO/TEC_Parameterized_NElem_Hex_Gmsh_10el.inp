32707, 2.1583333333333, 1.2, 0.45833333333333
32708, 2.1583333333333, 1.15, 0.45833333333333
32709, 2.1583333333333, 1.1, 0.45833333333333
32710, 2.1583333333333, 1.05, 0.45833333333333
32711, 2.1583333333333, 1, 0.45833333333333
32712, 2.1583333333333, 0.95, 0.45833333333333
32713, 2.1583333333333, 0.9, 0.45833333333333
32714, 2.1583333333333, 0.85, 0.45833333333333
32715, 2.1583333333333, 0.8, 0.45833333333333
32716, 2.1583333333333, 0.75, 0.45833333333333
32717, 2.1583333333333, 0.7, 0.45833333333333
32718, 2.1583333333333, 0.65, 0.45833333333333
32719, 2.1583333333333, 0.6, 0.45833333333333
32720, 2.1583333333333, 0.55, 0.45833333333333
32721, 2.1583333333333, 0.5, 0.45833333333333
32722, 2.1583333333333, 0.45, 0.45833333333333
32723, 2.1583333333333, 0.4, 0.45833333333333
32724, 2.1583333333333, 0.35, 0.45833333333333
32725, 2.1583333333333, 0.3, 0.45833333333333
32726, 2.1583333333333, 0.25, 0.45833333333333
32727, 2.1583333333333, 0.2, 0.45833333333333
32728, 1.2416666666667, 0.125, 0.041666666666667
32729, 1.2833333333333, 0.125, 0.041666666666667
32730, 1.325, 0.125, 0.041666666666667
32731, 1.3666666666667, 0.125, 0.041666666666667
32732, 1.4083333333333, 0.125, 0.041666666666667
32733, 1.45, 0.125, 0.041666666666667
32734, 1.4916666666667, 0.125, 0.041666666666667
32735, 1.5333333333333, 0.125, 0.041666666666667
32736, 1.575, 0.125, 0.041666666666667
32737, 1.6166666666667, 0.125, 0.041666666666667
32738, 1.6583333333333, 0.125, 0.041666666666667
32739, 1.7, 0.125, 0.041666666666667
32740, 1.7416666666667, 0.125, 0.041666666666667
32741, 1.7833333333333, 0.125, 0.041666666666667
32742, 1.825, 0.125, 0.041666666666667
32743, 1.8666666666667, 0.125, 0.041666666666667
32744, 1.9083333333333, 0.125, 0.041666666666667
32745, 1.95, 0.125, 0.041666666666667
32746, 1.9916666666667, 0.125, 0.041666666666667
32747, 2.0333333333333, 0.125, 0.041666666666667
32748, 2.075, 0.125, 0.041666666666667
32749, 2.1166666666667, 0.125, 0.041666666666667
32750, 2.1583333333333, 0.125, 0.041666666666667
32751, 1.2416666666667, 0.125, 0.083333333333333
32752, 1.2833333333333, 0.125, 0.083333333333333
32753, 1.325, 0.125, 0.083333333333333
32754, 1.3666666666667, 0.125, 0.083333333333333
32755, 1.4083333333333, 0.125, 0.083333333333333
32756, 1.45, 0.125, 0.083333333333333
32757, 1.4916666666667, 0.125, 0.083333333333333
32758, 1.5333333333333, 0.125, 0.083333333333333
32759, 1.575, 0.125, 0.083333333333333
32760, 1.6166666666667, 0.125, 0.083333333333333
32761, 1.6583333333333, 0.125, 0.083333333333333
32762, 1.7, 0.125, 0.083333333333333
32763, 1.7416666666667, 0.125, 0.083333333333333
32764, 1.7833333333333, 0.125, 0.083333333333333
32765, 1.825, 0.125, 0.083333333333333
32766, 1.8666666666667, 0.125, 0.083333333333333
32767, 1.9083333333333, 0.125, 0.083333333333333
32768, 1.95, 0.125, 0.083333333333333
32769, 1.9916666666667, 0.125, 0.083333333333333
32770, 2.0333333333333, 0.125, 0.083333333333333
32771, 2.075, 0.125, 0.083333333333333
32772, 2.1166666666667, 0.125, 0.083333333333333
32773, 2.1583333333333, 0.125, 0.083333333333333
32774, 1.2416666666667, 0.125, 0.125
32775, 1.2833333333333, 0.125, 0.125
32776, 1.325, 0.125, 0.125
32777, 1.3666666666667, 0.125, 0.125
32778, 1.4083333333333, 0.125, 0.125
32779, 1.45, 0.125, 0.125
32780, 1.4916666666667, 0.125, 0.125
32781, 1.5333333333333, 0.125, 0.125
32782, 1.575, 0.125, 0.125
32783, 1.6166666666667, 0.125, 0.125
32784, 1.6583333333333, 0.125, 0.125
32785, 1.7, 0.125, 0.125
32786, 1.7416666666667, 0.125, 0.125
32787, 1.7833333333333, 0.125, 0.125
32788, 1.825, 0.125, 0.125
32789, 1.8666666666667, 0.125, 0.125
32790, 1.9083333333333, 0.125, 0.125
32791, 1.95, 0.125, 0.125
32792, 1.9916666666667, 0.125, 0.125
32793, 2.0333333333333, 0.125, 0.125
32794, 2.075, 0.125, 0.125
32795, 2.1166666666667, 0.125, 0.125
32796, 2.1583333333333, 0.125, 0.125
32797, 1.2416666666667, 0.125, 0.16666666666667
32798, 1.2833333333333, 0.125, 0.16666666666667
32799, 1.325, 0.125, 0.16666666666667
32800, 1.3666666666667, 0.125, 0.16666666666667
32801, 1.4083333333333, 0.125, 0.16666666666667
32802, 1.45, 0.125, 0.16666666666667
32803, 1.4916666666667, 0.125, 0.16666666666667
32804, 1.5333333333333, 0.125, 0.16666666666667
32805, 1.575, 0.125, 0.16666666666667
32806, 1.6166666666667, 0.125, 0.16666666666667
32807, 1.6583333333333, 0.125, 0.16666666666667
32808, 1.7, 0.125, 0.16666666666667
32809, 1.7416666666667, 0.125, 0.16666666666667
32810, 1.7833333333333, 0.125, 0.16666666666667
32811, 1.825, 0.125, 0.16666666666667
32812, 1.8666666666667, 0.125, 0.16666666666667
32813, 1.9083333333333, 0.125, 0.16666666666667
32814, 1.95, 0.125, 0.16666666666667
32815, 1.9916666666667, 0.125, 0.16666666666667
32816, 2.0333333333333, 0.125, 0.16666666666667
32817, 2.075, 0.125, 0.16666666666667
32818, 2.1166666666667, 0.125, 0.16666666666667
32819, 2.1583333333333, 0.125, 0.16666666666667
32820, 1.2416666666667, 0.125, 0.20833333333333
32821, 1.2833333333333, 0.125, 0.20833333333333
32822, 1.325, 0.125, 0.20833333333333
32823, 1.3666666666667, 0.125, 0.20833333333333
32824, 1.4083333333333, 0.125, 0.20833333333333
32825, 1.45, 0.125, 0.20833333333333
32826, 1.4916666666667, 0.125, 0.20833333333333
32827, 1.5333333333333, 0.125, 0.20833333333333
32828, 1.575, 0.125, 0.20833333333333
32829, 1.6166666666667, 0.125, 0.20833333333333
32830, 1.6583333333333, 0.125, 0.20833333333333
32831, 1.7, 0.125, 0.20833333333333
32832, 1.7416666666667, 0.125, 0.20833333333333
32833, 1.7833333333333, 0.125, 0.20833333333333
32834, 1.825, 0.125, 0.20833333333333
32835, 1.8666666666667, 0.125, 0.20833333333333
32836, 1.9083333333333, 0.125, 0.20833333333333
32837, 1.95, 0.125, 0.20833333333333
32838, 1.9916666666667, 0.125, 0.20833333333333
32839, 2.0333333333333, 0.125, 0.20833333333333
32840, 2.075, 0.125, 0.20833333333333
32841, 2.1166666666667, 0.125, 0.20833333333333
32842, 2.1583333333333, 0.125, 0.20833333333333
32843, 1.2416666666667, 0.125, 0.25
32844, 1.2833333333333, 0.125, 0.25
32845, 1.325, 0.125, 0.25
32846, 1.3666666666667, 0.125, 0.25
32847, 1.4083333333333, 0.125, 0.25
32848, 1.45, 0.125, 0.25
32849, 1.4916666666667, 0.125, 0.25
32850, 1.5333333333333, 0.125, 0.25
32851, 1.575, 0.125, 0.25
32852, 1.6166666666667, 0.125, 0.25
32853, 1.6583333333333, 0.125, 0.25
32854, 1.7, 0.125, 0.25
32855, 1.7416666666667, 0.125, 0.25
32856, 1.7833333333333, 0.125, 0.25
32857, 1.825, 0.125, 0.25
32858, 1.8666666666667, 0.125, 0.25
32859, 1.9083333333333, 0.125, 0.25
32860, 1.95, 0.125, 0.25
32861, 1.9916666666667, 0.125, 0.25
32862, 2.0333333333333, 0.125, 0.25
32863, 2.075, 0.125, 0.25
32864, 2.1166666666667, 0.125, 0.25
32865, 2.1583333333333, 0.125, 0.25
32866, 1.2416666666667, 0.125, 0.29166666666667
32867, 1.2833333333333, 0.125, 0.29166666666667
32868, 1.325, 0.125, 0.29166666666667
32869, 1.3666666666667, 0.125, 0.29166666666667
32870, 1.4083333333333, 0.125, 0.29166666666667
32871, 1.45, 0.125, 0.29166666666667
32872, 1.4916666666667, 0.125, 0.29166666666667
32873, 1.5333333333333, 0.125, 0.29166666666667
32874, 1.575, 0.125, 0.29166666666667
32875, 1.6166666666667, 0.125, 0.29166666666667
32876, 1.6583333333333, 0.125, 0.29166666666667
32877, 1.7, 0.125, 0.29166666666667
32878, 1.7416666666667, 0.125, 0.29166666666667
32879, 1.7833333333333, 0.125, 0.29166666666667
32880, 1.825, 0.125, 0.29166666666667
32881, 1.8666666666667, 0.125, 0.29166666666667
32882, 1.9083333333333, 0.125, 0.29166666666667
32883, 1.95, 0.125, 0.29166666666667
32884, 1.9916666666667, 0.125, 0.29166666666667
32885, 2.0333333333333, 0.125, 0.29166666666667
32886, 2.075, 0.125, 0.29166666666667
32887, 2.1166666666667, 0.125, 0.29166666666667
32888, 2.1583333333333, 0.125, 0.29166666666667
32889, 1.2416666666667, 0.125, 0.33333333333333
32890, 1.2833333333333, 0.125, 0.33333333333333
32891, 1.325, 0.125, 0.33333333333333
32892, 1.3666666666667, 0.125, 0.33333333333333
32893, 1.4083333333333, 0.125, 0.33333333333333
32894, 1.45, 0.125, 0.33333333333333
32895, 1.4916666666667, 0.125, 0.33333333333333
32896, 1.5333333333333, 0.125, 0.33333333333333
32897, 1.575, 0.125, 0.33333333333333
32898, 1.6166666666667, 0.125, 0.33333333333333
32899, 1.6583333333333, 0.125, 0.33333333333333
32900, 1.7, 0.125, 0.33333333333333
32901, 1.7416666666667, 0.125, 0.33333333333333
32902, 1.7833333333333, 0.125, 0.33333333333333
32903, 1.825, 0.125, 0.33333333333333
32904, 1.8666666666667, 0.125, 0.33333333333333
32905, 1.9083333333333, 0.125, 0.33333333333333
32906, 1.95, 0.125, 0.33333333333333
32907, 1.9916666666667, 0.125, 0.33333333333333
32908, 2.0333333333333, 0.125, 0.33333333333333
32909, 2.075, 0.125, 0.33333333333333
32910, 2.1166666666667, 0.125, 0.33333333333333
32911, 2.1583333333333, 0.125, 0.33333333333333
32912, 1.2416666666667, 0.125, 0.375
32913, 1.2833333333333, 0.125, 0.375
32914, 1.325, 0.125, 0.375
32915, 1.3666666666667, 0.125, 0.375
32916, 1.4083333333333, 0.125, 0.375
32917, 1.45, 0.125, 0.375
32918, 1.4916666666667, 0.125, 0.375
32919, 1.5333333333333, 0.125, 0.375
32920, 1.575, 0.125, 0.375
32921, 1.6166666666667, 0.125, 0.375
32922, 1.6583333333333, 0.125, 0.375
32923, 1.7, 0.125, 0.375
32924, 1.7416666666667, 0.125, 0.375
32925, 1.7833333333333, 0.125, 0.375
32926, 1.825, 0.125, 0.375
32927, 1.8666666666667, 0.125, 0.375
32928, 1.9083333333333, 0.125, 0.375
32929, 1.95, 0.125, 0.375
32930, 1.9916666666667, 0.125, 0.375
32931, 2.0333333333333, 0.125, 0.375
32932, 2.075, 0.125, 0.375
32933, 2.1166666666667, 0.125, 0.375
32934, 2.1583333333333, 0.125, 0.375
32935, 1.2416666666667, 0.125, 0.41666666666667
32936, 1.2833333333333, 0.125, 0.41666666666667
32937, 1.325, 0.125, 0.41666666666667
32938, 1.3666666666667, 0.125, 0.41666666666667
32939, 1.4083333333333, 0.125, 0.41666666666667
32940, 1.45, 0.125, 0.41666666666667
32941, 1.4916666666667, 0.125, 0.41666666666667
32942, 1.5333333333333, 0.125, 0.41666666666667
32943, 1.575, 0.125, 0.41666666666667
32944, 1.6166666666667, 0.125, 0.41666666666667
32945, 1.6583333333333, 0.125, 0.41666666666667
32946, 1.7, 0.125, 0.41666666666667
32947, 1.7416666666667, 0.125, 0.41666666666667
32948, 1.7833333333333, 0.125, 0.41666666666667
32949, 1.825, 0.125, 0.41666666666667
32950, 1.8666666666667, 0.125, 0.41666666666667
32951, 1.9083333333333, 0.125, 0.41666666666667
32952, 1.95, 0.125, 0.41666666666667
32953, 1.9916666666667, 0.125, 0.41666666666667
32954, 2.0333333333333, 0.125, 0.41666666666667
32955, 2.075, 0.125, 0.41666666666667
32956, 2.1166666666667, 0.125, 0.41666666666667
32957, 2.1583333333333, 0.125, 0.41666666666667
32958, 1.2416666666667, 0.125, 0.45833333333333
32959, 1.2833333333333, 0.125, 0.45833333333333
32960, 1.325, 0.125, 0.45833333333333
32961, 1.3666666666667, 0.125, 0.45833333333333
32962, 1.4083333333333, 0.125, 0.45833333333333
32963, 1.45, 0.125, 0.45833333333333
32964, 1.4916666666667, 0.125, 0.45833333333333
32965, 1.5333333333333, 0.125, 0.45833333333333
32966, 1.575, 0.125, 0.45833333333333
32967, 1.6166666666667, 0.125, 0.45833333333333
32968, 1.6583333333333, 0.125, 0.45833333333333
32969, 1.7, 0.125, 0.45833333333333
32970, 1.7416666666667, 0.125, 0.45833333333333
32971, 1.7833333333333, 0.125, 0.45833333333333
32972, 1.825, 0.125, 0.45833333333333
32973, 1.8666666666667, 0.125, 0.45833333333333
32974, 1.9083333333333, 0.125, 0.45833333333333
32975, 1.95, 0.125, 0.45833333333333
32976, 1.9916666666667, 0.125, 0.45833333333333
32977, 2.0333333333333, 0.125, 0.45833333333333
32978, 2.075, 0.125, 0.45833333333333
32979, 2.1166666666667, 0.125, 0.45833333333333
32980, 2.1583333333333, 0.125, 0.45833333333333
32981, 1.2416666666667, 0.066666666666667, 0.041666666666667
32982, 1.2416666666667, 0.033333333333333, 0.041666666666667
32983, 1.2833333333333, 0.066666666666667, 0.041666666666667
32984, 1.2833333333333, 0.033333333333333, 0.041666666666667
32985, 1.325, 0.066666666666667, 0.041666666666667
32986, 1.325, 0.033333333333333, 0.041666666666667
32987, 1.3666666666667, 0.066666666666667, 0.041666666666667
32988, 1.3666666666667, 0.033333333333333, 0.041666666666667
32989, 1.4083333333333, 0.066666666666667, 0.041666666666667
32990, 1.4083333333333, 0.033333333333333, 0.041666666666667
32991, 1.45, 0.066666666666667, 0.041666666666667
32992, 1.45, 0.033333333333333, 0.041666666666667
32993, 1.4916666666667, 0.066666666666667, 0.041666666666667
32994, 1.4916666666667, 0.033333333333333, 0.041666666666667
32995, 1.5333333333333, 0.066666666666667, 0.041666666666667
32996, 1.5333333333333, 0.033333333333333, 0.041666666666667
32997, 1.575, 0.066666666666667, 0.041666666666667
32998, 1.575, 0.033333333333333, 0.041666666666667
32999, 1.6166666666667, 0.066666666666667, 0.041666666666667
33000, 1.6166666666667, 0.033333333333333, 0.041666666666667
33001, 1.6583333333333, 0.066666666666667, 0.041666666666667
33002, 1.6583333333333, 0.033333333333333, 0.041666666666667
33003, 1.7, 0.066666666666667, 0.041666666666667
33004, 1.7, 0.033333333333333, 0.041666666666667
33005, 1.7416666666667, 0.066666666666667, 0.041666666666667
33006, 1.7416666666667, 0.033333333333333, 0.041666666666667
33007, 1.7833333333333, 0.066666666666667, 0.041666666666667
33008, 1.7833333333333, 0.033333333333333, 0.041666666666667
33009, 1.825, 0.066666666666667, 0.041666666666667
33010, 1.825, 0.033333333333333, 0.041666666666667
33011, 1.8666666666667, 0.066666666666667, 0.041666666666667
33012, 1.8666666666667, 0.033333333333333, 0.041666666666667
33013, 1.9083333333333, 0.066666666666667, 0.041666666666667
33014, 1.9083333333333, 0.033333333333333, 0.041666666666667
33015, 1.95, 0.066666666666667, 0.041666666666667
33016, 1.95, 0.033333333333333, 0.041666666666667
33017, 1.9916666666667, 0.066666666666667, 0.041666666666667
33018, 1.9916666666667, 0.033333333333333, 0.041666666666667
33019, 2.0333333333333, 0.066666666666667, 0.041666666666667
33020, 2.0333333333333, 0.033333333333333, 0.041666666666667
33021, 2.075, 0.066666666666667, 0.041666666666667
33022, 2.075, 0.033333333333333, 0.041666666666667
33023, 2.1166666666667, 0.066666666666667, 0.041666666666667
33024, 2.1166666666667, 0.033333333333333, 0.041666666666667
33025, 2.1583333333333, 0.066666666666667, 0.041666666666667
33026, 2.1583333333333, 0.033333333333333, 0.041666666666667
33027, 1.2416666666667, 0.066666666666667, 0.083333333333333
33028, 1.2416666666667, 0.033333333333333, 0.083333333333333
33029, 1.2833333333333, 0.066666666666667, 0.083333333333333
33030, 1.2833333333333, 0.033333333333333, 0.083333333333333
33031, 1.325, 0.066666666666667, 0.083333333333333
33032, 1.325, 0.033333333333333, 0.083333333333333
33033, 1.3666666666667, 0.066666666666667, 0.083333333333333
33034, 1.3666666666667, 0.033333333333333, 0.083333333333333
33035, 1.4083333333333, 0.066666666666667, 0.083333333333333
33036, 1.4083333333333, 0.033333333333333, 0.083333333333333
33037, 1.45, 0.066666666666667, 0.083333333333333
33038, 1.45, 0.033333333333333, 0.083333333333333
33039, 1.4916666666667, 0.066666666666667, 0.083333333333333
33040, 1.4916666666667, 0.033333333333333, 0.083333333333333
33041, 1.5333333333333, 0.066666666666667, 0.083333333333333
33042, 1.5333333333333, 0.033333333333333, 0.083333333333333
33043, 1.575, 0.066666666666667, 0.083333333333333
33044, 1.575, 0.033333333333333, 0.083333333333333
33045, 1.6166666666667, 0.066666666666667, 0.083333333333333
33046, 1.6166666666667, 0.033333333333333, 0.083333333333333
33047, 1.6583333333333, 0.066666666666667, 0.083333333333333
33048, 1.6583333333333, 0.033333333333333, 0.083333333333333
33049, 1.7, 0.066666666666667, 0.083333333333333
33050, 1.7, 0.033333333333333, 0.083333333333333
33051, 1.7416666666667, 0.066666666666667, 0.083333333333333
33052, 1.7416666666667, 0.033333333333333, 0.083333333333333
33053, 1.7833333333333, 0.066666666666667, 0.083333333333333
33054, 1.7833333333333, 0.033333333333333, 0.083333333333333
33055, 1.825, 0.066666666666667, 0.083333333333333
33056, 1.825, 0.033333333333333, 0.083333333333333
33057, 1.8666666666667, 0.066666666666667, 0.083333333333333
33058, 1.8666666666667, 0.033333333333333, 0.083333333333333
33059, 1.9083333333333, 0.066666666666667, 0.083333333333333
33060, 1.9083333333333, 0.033333333333333, 0.083333333333333
33061, 1.95, 0.066666666666667, 0.083333333333333
33062, 1.95, 0.033333333333333, 0.083333333333333
33063, 1.9916666666667, 0.066666666666667, 0.083333333333333
33064, 1.9916666666667, 0.033333333333333, 0.083333333333333
33065, 2.0333333333333, 0.066666666666667, 0.083333333333333
33066, 2.0333333333333, 0.033333333333333, 0.083333333333333
33067, 2.075, 0.066666666666667, 0.083333333333333
33068, 2.075, 0.033333333333333, 0.083333333333333
33069, 2.1166666666667, 0.066666666666667, 0.083333333333333
33070, 2.1166666666667, 0.033333333333333, 0.083333333333333
33071, 2.1583333333333, 0.066666666666667, 0.083333333333333
33072, 2.1583333333333, 0.033333333333333, 0.083333333333333
33073, 1.2416666666667, 0.066666666666667, 0.125
33074, 1.2416666666667, 0.033333333333333, 0.125
33075, 1.2833333333333, 0.066666666666667, 0.125
33076, 1.2833333333333, 0.033333333333333, 0.125
33077, 1.325, 0.066666666666667, 0.125
33078, 1.325, 0.033333333333333, 0.125
33079, 1.3666666666667, 0.066666666666667, 0.125
33080, 1.3666666666667, 0.033333333333333, 0.125
33081, 1.4083333333333, 0.066666666666667, 0.125
33082, 1.4083333333333, 0.033333333333333, 0.125
33083, 1.45, 0.066666666666667, 0.125
33084, 1.45, 0.033333333333333, 0.125
33085, 1.4916666666667, 0.066666666666667, 0.125
33086, 1.4916666666667, 0.033333333333333, 0.125
33087, 1.5333333333333, 0.066666666666667, 0.125
33088, 1.5333333333333, 0.033333333333333, 0.125
33089, 1.575, 0.066666666666667, 0.125
33090, 1.575, 0.033333333333333, 0.125
33091, 1.6166666666667, 0.066666666666667, 0.125
33092, 1.6166666666667, 0.033333333333333, 0.125
33093, 1.6583333333333, 0.066666666666667, 0.125
33094, 1.6583333333333, 0.033333333333333, 0.125
33095, 1.7, 0.066666666666667, 0.125
33096, 1.7, 0.033333333333333, 0.125
33097, 1.7416666666667, 0.066666666666667, 0.125
33098, 1.7416666666667, 0.033333333333333, 0.125
33099, 1.7833333333333, 0.066666666666667, 0.125
33100, 1.7833333333333, 0.033333333333333, 0.125
33101, 1.825, 0.066666666666667, 0.125
33102, 1.825, 0.033333333333333, 0.125
33103, 1.8666666666667, 0.066666666666667, 0.125
33104, 1.8666666666667, 0.033333333333333, 0.125
33105, 1.9083333333333, 0.066666666666667, 0.125
33106, 1.9083333333333, 0.033333333333333, 0.125
33107, 1.95, 0.066666666666667, 0.125
33108, 1.95, 0.033333333333333, 0.125
33109, 1.9916666666667, 0.066666666666667, 0.125
33110, 1.9916666666667, 0.033333333333333, 0.125
33111, 2.0333333333333, 0.066666666666667, 0.125
33112, 2.0333333333333, 0.033333333333333, 0.125
33113, 2.075, 0.066666666666667, 0.125
33114, 2.075, 0.033333333333333, 0.125
33115, 2.1166666666667, 0.066666666666667, 0.125
33116, 2.1166666666667, 0.033333333333333, 0.125
33117, 2.1583333333333, 0.066666666666667, 0.125
33118, 2.1583333333333, 0.033333333333333, 0.125
33119, 1.2416666666667, 0.066666666666667, 0.16666666666667
33120, 1.2416666666667, 0.033333333333333, 0.16666666666667
33121, 1.2833333333333, 0.066666666666667, 0.16666666666667
33122, 1.2833333333333, 0.033333333333333, 0.16666666666667
33123, 1.325, 0.066666666666667, 0.16666666666667
33124, 1.325, 0.033333333333333, 0.16666666666667
33125, 1.3666666666667, 0.066666666666667, 0.16666666666667
33126, 1.3666666666667, 0.033333333333333, 0.16666666666667
33127, 1.4083333333333, 0.066666666666667, 0.16666666666667
33128, 1.4083333333333, 0.033333333333333, 0.16666666666667
33129, 1.45, 0.066666666666667, 0.16666666666667
33130, 1.45, 0.033333333333333, 0.16666666666667
33131, 1.4916666666667, 0.066666666666667, 0.16666666666667
33132, 1.4916666666667, 0.033333333333333, 0.16666666666667
33133, 1.5333333333333, 0.066666666666667, 0.16666666666667
33134, 1.5333333333333, 0.033333333333333, 0.16666666666667
33135, 1.575, 0.066666666666667, 0.16666666666667
33136, 1.575, 0.033333333333333, 0.16666666666667
33137, 1.6166666666667, 0.066666666666667, 0.16666666666667
33138, 1.6166666666667, 0.033333333333333, 0.16666666666667
33139, 1.6583333333333, 0.066666666666667, 0.16666666666667
33140, 1.6583333333333, 0.033333333333333, 0.16666666666667
33141, 1.7, 0.066666666666667, 0.16666666666667
33142, 1.7, 0.033333333333333, 0.16666666666667
33143, 1.7416666666667, 0.066666666666667, 0.16666666666667
33144, 1.7416666666667, 0.033333333333333, 0.16666666666667
33145, 1.7833333333333, 0.066666666666667, 0.16666666666667
33146, 1.7833333333333, 0.033333333333333, 0.16666666666667
33147, 1.825, 0.066666666666667, 0.16666666666667
33148, 1.825, 0.033333333333333, 0.16666666666667
33149, 1.8666666666667, 0.066666666666667, 0.16666666666667
33150, 1.8666666666667, 0.033333333333333, 0.16666666666667
33151, 1.9083333333333, 0.066666666666667, 0.16666666666667
33152, 1.9083333333333, 0.033333333333333, 0.16666666666667
33153, 1.95, 0.066666666666667, 0.16666666666667
33154, 1.95, 0.033333333333333, 0.16666666666667
33155, 1.9916666666667, 0.066666666666667, 0.16666666666667
33156, 1.9916666666667, 0.033333333333333, 0.16666666666667
33157, 2.0333333333333, 0.066666666666667, 0.16666666666667
33158, 2.0333333333333, 0.033333333333333, 0.16666666666667
33159, 2.075, 0.066666666666667, 0.16666666666667
33160, 2.075, 0.033333333333333, 0.16666666666667
33161, 2.1166666666667, 0.066666666666667, 0.16666666666667
33162, 2.1166666666667, 0.033333333333333, 0.16666666666667
33163, 2.1583333333333, 0.066666666666667, 0.16666666666667
33164, 2.1583333333333, 0.033333333333333, 0.16666666666667
33165, 1.2416666666667, 0.066666666666667, 0.20833333333333
33166, 1.2416666666667, 0.033333333333333, 0.20833333333333
33167, 1.2833333333333, 0.066666666666667, 0.20833333333333
33168, 1.2833333333333, 0.033333333333333, 0.20833333333333
33169, 1.325, 0.066666666666667, 0.20833333333333
33170, 1.325, 0.033333333333333, 0.20833333333333
33171, 1.3666666666667, 0.066666666666667, 0.20833333333333
33172, 1.3666666666667, 0.033333333333333, 0.20833333333333
33173, 1.4083333333333, 0.066666666666667, 0.20833333333333
33174, 1.4083333333333, 0.033333333333333, 0.20833333333333
33175, 1.45, 0.066666666666667, 0.20833333333333
33176, 1.45, 0.033333333333333, 0.20833333333333
33177, 1.4916666666667, 0.066666666666667, 0.20833333333333
33178, 1.4916666666667, 0.033333333333333, 0.20833333333333
33179, 1.5333333333333, 0.066666666666667, 0.20833333333333
33180, 1.5333333333333, 0.033333333333333, 0.20833333333333
33181, 1.575, 0.066666666666667, 0.20833333333333
33182, 1.575, 0.033333333333333, 0.20833333333333
33183, 1.6166666666667, 0.066666666666667, 0.20833333333333
33184, 1.6166666666667, 0.033333333333333, 0.20833333333333
33185, 1.6583333333333, 0.066666666666667, 0.20833333333333
33186, 1.6583333333333, 0.033333333333333, 0.20833333333333
33187, 1.7, 0.066666666666667, 0.20833333333333
33188, 1.7, 0.033333333333333, 0.20833333333333
33189, 1.7416666666667, 0.066666666666667, 0.20833333333333
33190, 1.7416666666667, 0.033333333333333, 0.20833333333333
33191, 1.7833333333333, 0.066666666666667, 0.20833333333333
33192, 1.7833333333333, 0.033333333333333, 0.20833333333333
33193, 1.825, 0.066666666666667, 0.20833333333333
33194, 1.825, 0.033333333333333, 0.20833333333333
33195, 1.8666666666667, 0.066666666666667, 0.20833333333333
33196, 1.8666666666667, 0.033333333333333, 0.20833333333333
33197, 1.9083333333333, 0.066666666666667, 0.20833333333333
33198, 1.9083333333333, 0.033333333333333, 0.20833333333333
33199, 1.95, 0.066666666666667, 0.20833333333333
33200, 1.95, 0.033333333333333, 0.20833333333333
33201, 1.9916666666667, 0.066666666666667, 0.20833333333333
33202, 1.9916666666667, 0.033333333333333, 0.20833333333333
33203, 2.0333333333333, 0.066666666666667, 0.20833333333333
33204, 2.0333333333333, 0.033333333333333, 0.20833333333333
33205, 2.075, 0.066666666666667, 0.20833333333333
33206, 2.075, 0.033333333333333, 0.20833333333333
33207, 2.1166666666667, 0.066666666666667, 0.20833333333333
33208, 2.1166666666667, 0.033333333333333, 0.20833333333333
33209, 2.1583333333333, 0.066666666666667, 0.20833333333333
33210, 2.1583333333333, 0.033333333333333, 0.20833333333333
33211, 1.2416666666667, 0.066666666666667, 0.25
33212, 1.2416666666667, 0.033333333333333, 0.25
33213, 1.2833333333333, 0.066666666666667, 0.25
33214, 1.2833333333333, 0.033333333333333, 0.25
33215, 1.325, 0.066666666666667, 0.25
33216, 1.325, 0.033333333333333, 0.25
33217, 1.3666666666667, 0.066666666666667, 0.25
33218, 1.3666666666667, 0.033333333333333, 0.25
33219, 1.4083333333333, 0.066666666666667, 0.25
33220, 1.4083333333333, 0.033333333333333, 0.25
33221, 1.45, 0.066666666666667, 0.25
33222, 1.45, 0.033333333333333, 0.25
33223, 1.4916666666667, 0.066666666666667, 0.25
33224, 1.4916666666667, 0.033333333333333, 0.25
33225, 1.5333333333333, 0.066666666666667, 0.25
33226, 1.5333333333333, 0.033333333333333, 0.25
33227, 1.575, 0.066666666666667, 0.25
33228, 1.575, 0.033333333333333, 0.25
33229, 1.6166666666667, 0.066666666666667, 0.25
33230, 1.6166666666667, 0.033333333333333, 0.25
33231, 1.6583333333333, 0.066666666666667, 0.25
33232, 1.6583333333333, 0.033333333333333, 0.25
33233, 1.7, 0.066666666666667, 0.25
33234, 1.7, 0.033333333333333, 0.25
33235, 1.7416666666667, 0.066666666666667, 0.25
33236, 1.7416666666667, 0.033333333333333, 0.25
33237, 1.7833333333333, 0.066666666666667, 0.25
33238, 1.7833333333333, 0.033333333333333, 0.25
33239, 1.825, 0.066666666666667, 0.25
33240, 1.825, 0.033333333333333, 0.25
33241, 1.8666666666667, 0.066666666666667, 0.25
33242, 1.8666666666667, 0.033333333333333, 0.25
33243, 1.9083333333333, 0.066666666666667, 0.25
33244, 1.9083333333333, 0.033333333333333, 0.25
33245, 1.95, 0.066666666666667, 0.25
33246, 1.95, 0.033333333333333, 0.25
33247, 1.9916666666667, 0.066666666666667, 0.25
33248, 1.9916666666667, 0.033333333333333, 0.25
33249, 2.0333333333333, 0.066666666666667, 0.25
33250, 2.0333333333333, 0.033333333333333, 0.25
33251, 2.075, 0.066666666666667, 0.25
33252, 2.075, 0.033333333333333, 0.25
33253, 2.1166666666667, 0.066666666666667, 0.25
33254, 2.1166666666667, 0.033333333333333, 0.25
33255, 2.1583333333333, 0.066666666666667, 0.25
33256, 2.1583333333333, 0.033333333333333, 0.25
33257, 1.2416666666667, 0.066666666666667, 0.29166666666667
33258, 1.2416666666667, 0.033333333333333, 0.29166666666667
33259, 1.2833333333333, 0.066666666666667, 0.29166666666667
33260, 1.2833333333333, 0.033333333333333, 0.29166666666667
33261, 1.325, 0.066666666666667, 0.29166666666667
33262, 1.325, 0.033333333333333, 0.29166666666667
33263, 1.3666666666667, 0.066666666666667, 0.29166666666667
33264, 1.3666666666667, 0.033333333333333, 0.29166666666667
33265, 1.4083333333333, 0.066666666666667, 0.29166666666667
33266, 1.4083333333333, 0.033333333333333, 0.29166666666667
33267, 1.45, 0.066666666666667, 0.29166666666667
33268, 1.45, 0.033333333333333, 0.29166666666667
33269, 1.4916666666667, 0.066666666666667, 0.29166666666667
33270, 1.4916666666667, 0.033333333333333, 0.29166666666667
33271, 1.5333333333333, 0.066666666666667, 0.29166666666667
33272, 1.5333333333333, 0.033333333333333, 0.29166666666667
33273, 1.575, 0.066666666666667, 0.29166666666667
33274, 1.575, 0.033333333333333, 0.29166666666667
33275, 1.6166666666667, 0.066666666666667, 0.29166666666667
33276, 1.6166666666667, 0.033333333333333, 0.29166666666667
33277, 1.6583333333333, 0.066666666666667, 0.29166666666667
33278, 1.6583333333333, 0.033333333333333, 0.29166666666667
33279, 1.7, 0.066666666666667, 0.29166666666667
33280, 1.7, 0.033333333333333, 0.29166666666667
33281, 1.7416666666667, 0.066666666666667, 0.29166666666667
33282, 1.7416666666667, 0.033333333333333, 0.29166666666667
33283, 1.7833333333333, 0.066666666666667, 0.29166666666667
33284, 1.7833333333333, 0.033333333333333, 0.29166666666667
33285, 1.825, 0.066666666666667, 0.29166666666667
33286, 1.825, 0.033333333333333, 0.29166666666667
33287, 1.8666666666667, 0.066666666666667, 0.29166666666667
33288, 1.8666666666667, 0.033333333333333, 0.29166666666667
33289, 1.9083333333333, 0.066666666666667, 0.29166666666667
33290, 1.9083333333333, 0.033333333333333, 0.29166666666667
33291, 1.95, 0.066666666666667, 0.29166666666667
33292, 1.95, 0.033333333333333, 0.29166666666667
33293, 1.9916666666667, 0.066666666666667, 0.29166666666667
33294, 1.9916666666667, 0.033333333333333, 0.29166666666667
33295, 2.0333333333333, 0.066666666666667, 0.29166666666667
33296, 2.0333333333333, 0.033333333333333, 0.29166666666667
33297, 2.075, 0.066666666666667, 0.29166666666667
33298, 2.075, 0.033333333333333, 0.29166666666667
33299, 2.1166666666667, 0.066666666666667, 0.29166666666667
33300, 2.1166666666667, 0.033333333333333, 0.29166666666667
33301, 2.1583333333333, 0.066666666666667, 0.29166666666667
33302, 2.1583333333333, 0.033333333333333, 0.29166666666667
33303, 1.2416666666667, 0.066666666666667, 0.33333333333333
33304, 1.2416666666667, 0.033333333333333, 0.33333333333333
33305, 1.2833333333333, 0.066666666666667, 0.33333333333333
33306, 1.2833333333333, 0.033333333333333, 0.33333333333333
33307, 1.325, 0.066666666666667, 0.33333333333333
33308, 1.325, 0.033333333333333, 0.33333333333333
33309, 1.3666666666667, 0.066666666666667, 0.33333333333333
33310, 1.3666666666667, 0.033333333333333, 0.33333333333333
33311, 1.4083333333333, 0.066666666666667, 0.33333333333333
33312, 1.4083333333333, 0.033333333333333, 0.33333333333333
33313, 1.45, 0.066666666666667, 0.33333333333333
33314, 1.45, 0.033333333333333, 0.33333333333333
33315, 1.4916666666667, 0.066666666666667, 0.33333333333333
33316, 1.4916666666667, 0.033333333333333, 0.33333333333333
33317, 1.5333333333333, 0.066666666666667, 0.33333333333333
33318, 1.5333333333333, 0.033333333333333, 0.33333333333333
33319, 1.575, 0.066666666666667, 0.33333333333333
33320, 1.575, 0.033333333333333, 0.33333333333333
33321, 1.6166666666667, 0.066666666666667, 0.33333333333333
33322, 1.6166666666667, 0.033333333333333, 0.33333333333333
33323, 1.6583333333333, 0.066666666666667, 0.33333333333333
33324, 1.6583333333333, 0.033333333333333, 0.33333333333333
33325, 1.7, 0.066666666666667, 0.33333333333333
33326, 1.7, 0.033333333333333, 0.33333333333333
33327, 1.7416666666667, 0.066666666666667, 0.33333333333333
33328, 1.7416666666667, 0.033333333333333, 0.33333333333333
33329, 1.7833333333333, 0.066666666666667, 0.33333333333333
33330, 1.7833333333333, 0.033333333333333, 0.33333333333333
33331, 1.825, 0.066666666666667, 0.33333333333333
33332, 1.825, 0.033333333333333, 0.33333333333333
33333, 1.8666666666667, 0.066666666666667, 0.33333333333333
33334, 1.8666666666667, 0.033333333333333, 0.33333333333333
33335, 1.9083333333333, 0.066666666666667, 0.33333333333333
33336, 1.9083333333333, 0.033333333333333, 0.33333333333333
33337, 1.95, 0.066666666666667, 0.33333333333333
33338, 1.95, 0.033333333333333, 0.33333333333333
33339, 1.9916666666667, 0.066666666666667, 0.33333333333333
33340, 1.9916666666667, 0.033333333333333, 0.33333333333333
33341, 2.0333333333333, 0.066666666666667, 0.33333333333333
33342, 2.0333333333333, 0.033333333333333, 0.33333333333333
33343, 2.075, 0.066666666666667, 0.33333333333333
33344, 2.075, 0.033333333333333, 0.33333333333333
33345, 2.1166666666667, 0.066666666666667, 0.33333333333333
33346, 2.1166666666667, 0.033333333333333, 0.33333333333333
33347, 2.1583333333333, 0.066666666666667, 0.33333333333333
33348, 2.1583333333333, 0.033333333333333, 0.33333333333333
33349, 1.2416666666667, 0.066666666666667, 0.375
33350, 1.2416666666667, 0.033333333333333, 0.375
33351, 1.2833333333333, 0.066666666666667, 0.375
33352, 1.2833333333333, 0.033333333333333, 0.375
33353, 1.325, 0.066666666666667, 0.375
33354, 1.325, 0.033333333333333, 0.375
33355, 1.3666666666667, 0.066666666666667, 0.375
33356, 1.3666666666667, 0.033333333333333, 0.375
33357, 1.4083333333333, 0.066666666666667, 0.375
33358, 1.4083333333333, 0.033333333333333, 0.375
33359, 1.45, 0.066666666666667, 0.375
33360, 1.45, 0.033333333333333, 0.375
33361, 1.4916666666667, 0.066666666666667, 0.375
33362, 1.4916666666667, 0.033333333333333, 0.375
33363, 1.5333333333333, 0.066666666666667, 0.375
33364, 1.5333333333333, 0.033333333333333, 0.375
33365, 1.575, 0.066666666666667, 0.375
33366, 1.575, 0.033333333333333, 0.375
33367, 1.6166666666667, 0.066666666666667, 0.375
33368, 1.6166666666667, 0.033333333333333, 0.375
33369, 1.6583333333333, 0.066666666666667, 0.375
33370, 1.6583333333333, 0.033333333333333, 0.375
33371, 1.7, 0.066666666666667, 0.375
33372, 1.7, 0.033333333333333, 0.375
33373, 1.7416666666667, 0.066666666666667, 0.375
33374, 1.7416666666667, 0.033333333333333, 0.375
33375, 1.7833333333333, 0.066666666666667, 0.375
33376, 1.7833333333333, 0.033333333333333, 0.375
33377, 1.825, 0.066666666666667, 0.375
33378, 1.825, 0.033333333333333, 0.375
33379, 1.8666666666667, 0.066666666666667, 0.375
33380, 1.8666666666667, 0.033333333333333, 0.375
33381, 1.9083333333333, 0.066666666666667, 0.375
33382, 1.9083333333333, 0.033333333333333, 0.375
33383, 1.95, 0.066666666666667, 0.375
33384, 1.95, 0.033333333333333, 0.375
33385, 1.9916666666667, 0.066666666666667, 0.375
33386, 1.9916666666667, 0.033333333333333, 0.375
33387, 2.0333333333333, 0.066666666666667, 0.375
33388, 2.0333333333333, 0.033333333333333, 0.375
33389, 2.075, 0.066666666666667, 0.375
33390, 2.075, 0.033333333333333, 0.375
33391, 2.1166666666667, 0.066666666666667, 0.375
33392, 2.1166666666667, 0.033333333333333, 0.375
33393, 2.1583333333333, 0.066666666666667, 0.375
33394, 2.1583333333333, 0.033333333333333, 0.375
33395, 1.2416666666667, 0.066666666666667, 0.41666666666667
33396, 1.2416666666667, 0.033333333333333, 0.41666666666667
33397, 1.2833333333333, 0.066666666666667, 0.41666666666667
33398, 1.2833333333333, 0.033333333333333, 0.41666666666667
33399, 1.325, 0.066666666666667, 0.41666666666667
33400, 1.325, 0.033333333333333, 0.41666666666667
33401, 1.3666666666667, 0.066666666666667, 0.41666666666667
33402, 1.3666666666667, 0.033333333333333, 0.41666666666667
33403, 1.4083333333333, 0.066666666666667, 0.41666666666667
33404, 1.4083333333333, 0.033333333333333, 0.41666666666667
33405, 1.45, 0.066666666666667, 0.41666666666667
33406, 1.45, 0.033333333333333, 0.41666666666667
33407, 1.4916666666667, 0.066666666666667, 0.41666666666667
33408, 1.4916666666667, 0.033333333333333, 0.41666666666667
33409, 1.5333333333333, 0.066666666666667, 0.41666666666667
33410, 1.5333333333333, 0.033333333333333, 0.41666666666667
33411, 1.575, 0.066666666666667, 0.41666666666667
33412, 1.575, 0.033333333333333, 0.41666666666667
33413, 1.6166666666667, 0.066666666666667, 0.41666666666667
33414, 1.6166666666667, 0.033333333333333, 0.41666666666667
33415, 1.6583333333333, 0.066666666666667, 0.41666666666667
33416, 1.6583333333333, 0.033333333333333, 0.41666666666667
33417, 1.7, 0.066666666666667, 0.41666666666667
33418, 1.7, 0.033333333333333, 0.41666666666667
33419, 1.7416666666667, 0.066666666666667, 0.41666666666667
33420, 1.7416666666667, 0.033333333333333, 0.41666666666667
33421, 1.7833333333333, 0.066666666666667, 0.41666666666667
33422, 1.7833333333333, 0.033333333333333, 0.41666666666667
33423, 1.825, 0.066666666666667, 0.41666666666667
33424, 1.825, 0.033333333333333, 0.41666666666667
33425, 1.8666666666667, 0.066666666666667, 0.41666666666667
33426, 1.8666666666667, 0.033333333333333, 0.41666666666667
33427, 1.9083333333333, 0.066666666666667, 0.41666666666667
33428, 1.9083333333333, 0.033333333333333, 0.41666666666667
33429, 1.95, 0.066666666666667, 0.41666666666667
33430, 1.95, 0.033333333333333, 0.41666666666667
33431, 1.9916666666667, 0.066666666666667, 0.41666666666667
33432, 1.9916666666667, 0.033333333333333, 0.41666666666667
33433, 2.0333333333333, 0.066666666666667, 0.41666666666667
33434, 2.0333333333333, 0.033333333333333, 0.41666666666667
33435, 2.075, 0.066666666666667, 0.41666666666667
33436, 2.075, 0.033333333333333, 0.41666666666667
33437, 2.1166666666667, 0.066666666666667, 0.41666666666667
33438, 2.1166666666667, 0.033333333333333, 0.41666666666667
33439, 2.1583333333333, 0.066666666666667, 0.41666666666667
33440, 2.1583333333333, 0.033333333333333, 0.41666666666667
33441, 1.2416666666667, 0.066666666666667, 0.45833333333333
33442, 1.2416666666667, 0.033333333333333, 0.45833333333333
33443, 1.2833333333333, 0.066666666666667, 0.45833333333333
33444, 1.2833333333333, 0.033333333333333, 0.45833333333333
33445, 1.325, 0.066666666666667, 0.45833333333333
33446, 1.325, 0.033333333333333, 0.45833333333333
33447, 1.3666666666667, 0.066666666666667, 0.45833333333333
33448, 1.3666666666667, 0.033333333333333, 0.45833333333333
33449, 1.4083333333333, 0.066666666666667, 0.45833333333333
33450, 1.4083333333333, 0.033333333333333, 0.45833333333333
33451, 1.45, 0.066666666666667, 0.45833333333333
33452, 1.45, 0.033333333333333, 0.45833333333333
33453, 1.4916666666667, 0.066666666666667, 0.45833333333333
33454, 1.4916666666667, 0.033333333333333, 0.45833333333333
33455, 1.5333333333333, 0.066666666666667, 0.45833333333333
33456, 1.5333333333333, 0.033333333333333, 0.45833333333333
33457, 1.575, 0.066666666666667, 0.45833333333333
33458, 1.575, 0.033333333333333, 0.45833333333333
33459, 1.6166666666667, 0.066666666666667, 0.45833333333333
33460, 1.6166666666667, 0.033333333333333, 0.45833333333333
33461, 1.6583333333333, 0.066666666666667, 0.45833333333333
33462, 1.6583333333333, 0.033333333333333, 0.45833333333333
33463, 1.7, 0.066666666666667, 0.45833333333333
33464, 1.7, 0.033333333333333, 0.45833333333333
33465, 1.7416666666667, 0.066666666666667, 0.45833333333333
33466, 1.7416666666667, 0.033333333333333, 0.45833333333333
33467, 1.7833333333333, 0.066666666666667, 0.45833333333333
33468, 1.7833333333333, 0.033333333333333, 0.45833333333333
33469, 1.825, 0.066666666666667, 0.45833333333333
33470, 1.825, 0.033333333333333, 0.45833333333333
33471, 1.8666666666667, 0.066666666666667, 0.45833333333333
33472, 1.8666666666667, 0.033333333333333, 0.45833333333333
33473, 1.9083333333333, 0.066666666666667, 0.45833333333333
33474, 1.9083333333333, 0.033333333333333, 0.45833333333333
33475, 1.95, 0.066666666666667, 0.45833333333333
33476, 1.95, 0.033333333333333, 0.45833333333333
33477, 1.9916666666667, 0.066666666666667, 0.45833333333333
33478, 1.9916666666667, 0.033333333333333, 0.45833333333333
33479, 2.0333333333333, 0.066666666666667, 0.45833333333333
33480, 2.0333333333333, 0.033333333333333, 0.45833333333333
33481, 2.075, 0.066666666666667, 0.45833333333333
33482, 2.075, 0.033333333333333, 0.45833333333333
33483, 2.1166666666667, 0.066666666666667, 0.45833333333333
33484, 2.1166666666667, 0.033333333333333, 0.45833333333333
33485, 2.1583333333333, 0.066666666666667, 0.45833333333333
33486, 2.1583333333333, 0.033333333333333, 0.45833333333333
33487, 1.2416666666667, 0.083333333333333, 0.041666666666667
33488, 1.2416666666667, 0.066666666666667, 0.020833333333333
33489, 1.2208333333333, 0.066666666666667, 0.041666666666667
33490, 1.2416666666667, 0.05, 0.041666666666667
33491, 1.2416666666667, 0.033333333333333, 0.020833333333333
33492, 1.2208333333333, 0.033333333333333, 0.041666666666667
33493, 1.2416666666667, 0.016666666666667, 0.041666666666667
33494, 1.2833333333333, 0.083333333333333, 0.041666666666667
33495, 1.2833333333333, 0.066666666666667, 0.020833333333333
33496, 1.2625, 0.066666666666667, 0.041666666666667
33497, 1.2833333333333, 0.05, 0.041666666666667
33498, 1.2833333333333, 0.033333333333333, 0.020833333333333
33499, 1.2625, 0.033333333333333, 0.041666666666667
33500, 1.2833333333333, 0.016666666666667, 0.041666666666667
33501, 1.325, 0.083333333333333, 0.041666666666667
33502, 1.325, 0.066666666666667, 0.020833333333333
33503, 1.3041666666667, 0.066666666666667, 0.041666666666667
33504, 1.325, 0.05, 0.041666666666667
33505, 1.325, 0.033333333333333, 0.020833333333333
33506, 1.3041666666667, 0.033333333333333, 0.041666666666667
33507, 1.325, 0.016666666666667, 0.041666666666667
33508, 1.3666666666667, 0.083333333333333, 0.041666666666667
33509, 1.3666666666667, 0.066666666666667, 0.020833333333333
33510, 1.3458333333333, 0.066666666666667, 0.041666666666667
33511, 1.3666666666667, 0.05, 0.041666666666667
33512, 1.3666666666667, 0.033333333333333, 0.020833333333333
33513, 1.3458333333333, 0.033333333333333, 0.041666666666667
33514, 1.3666666666667, 0.016666666666667, 0.041666666666667
33515, 1.4083333333333, 0.083333333333333, 0.041666666666667
33516, 1.4083333333333, 0.066666666666667, 0.020833333333333
33517, 1.3875, 0.066666666666667, 0.041666666666667
33518, 1.4083333333333, 0.05, 0.041666666666667
33519, 1.4083333333333, 0.033333333333333, 0.020833333333333
33520, 1.3875, 0.033333333333333, 0.041666666666667
33521, 1.4083333333333, 0.016666666666667, 0.041666666666667
33522, 1.45, 0.083333333333333, 0.041666666666667
33523, 1.45, 0.066666666666667, 0.020833333333333
33524, 1.4291666666667, 0.066666666666667, 0.041666666666667
33525, 1.45, 0.05, 0.041666666666667
33526, 1.45, 0.033333333333333, 0.020833333333333
33527, 1.4291666666667, 0.033333333333333, 0.041666666666667
33528, 1.45, 0.016666666666667, 0.041666666666667
33529, 1.4916666666667, 0.083333333333333, 0.041666666666667
33530, 1.4916666666667, 0.066666666666667, 0.020833333333333
33531, 1.4708333333333, 0.066666666666667, 0.041666666666667
33532, 1.4916666666667, 0.05, 0.041666666666667
33533, 1.4916666666667, 0.033333333333333, 0.020833333333333
33534, 1.4708333333333, 0.033333333333333, 0.041666666666667
33535, 1.4916666666667, 0.016666666666667, 0.041666666666667
33536, 1.5333333333333, 0.083333333333333, 0.041666666666667
33537, 1.5333333333333, 0.066666666666667, 0.020833333333333
33538, 1.5125, 0.066666666666667, 0.041666666666667
33539, 1.5333333333333, 0.05, 0.041666666666667
33540, 1.5333333333333, 0.033333333333333, 0.020833333333333
33541, 1.5125, 0.033333333333333, 0.041666666666667
33542, 1.5333333333333, 0.016666666666667, 0.041666666666667
33543, 1.575, 0.083333333333333, 0.041666666666667
33544, 1.575, 0.066666666666667, 0.020833333333333
33545, 1.5541666666667, 0.066666666666667, 0.041666666666667
33546, 1.575, 0.05, 0.041666666666667
33547, 1.575, 0.033333333333333, 0.020833333333333
33548, 1.5541666666667, 0.033333333333333, 0.041666666666667
33549, 1.575, 0.016666666666667, 0.041666666666667
33550, 1.6166666666667, 0.083333333333333, 0.041666666666667
33551, 1.6166666666667, 0.066666666666667, 0.020833333333333
33552, 1.5958333333333, 0.066666666666667, 0.041666666666667
33553, 1.6166666666667, 0.05, 0.041666666666667
33554, 1.6166666666667, 0.033333333333333, 0.020833333333333
33555, 1.5958333333333, 0.033333333333333, 0.041666666666667
33556, 1.6166666666667, 0.016666666666667, 0.041666666666667
33557, 1.6583333333333, 0.083333333333333, 0.041666666666667
33558, 1.6583333333333, 0.066666666666667, 0.020833333333333
33559, 1.6375, 0.066666666666667, 0.041666666666667
33560, 1.6583333333333, 0.05, 0.041666666666667
33561, 1.6583333333333, 0.033333333333333, 0.020833333333333
33562, 1.6375, 0.033333333333333, 0.041666666666667
33563, 1.6583333333333, 0.016666666666667, 0.041666666666667
33564, 1.7, 0.083333333333333, 0.041666666666667
33565, 1.7, 0.066666666666667, 0.020833333333333
33566, 1.6791666666667, 0.066666666666667, 0.041666666666667
33567, 1.7, 0.05, 0.041666666666667
33568, 1.7, 0.033333333333333, 0.020833333333333
33569, 1.6791666666667, 0.033333333333333, 0.041666666666667
33570, 1.7, 0.016666666666667, 0.041666666666667
33571, 1.7416666666667, 0.083333333333333, 0.041666666666667
33572, 1.7416666666667, 0.066666666666667, 0.020833333333333
33573, 1.7208333333333, 0.066666666666667, 0.041666666666667
33574, 1.7416666666667, 0.05, 0.041666666666667
33575, 1.7416666666667, 0.033333333333333, 0.020833333333333
33576, 1.7208333333333, 0.033333333333333, 0.041666666666667
33577, 1.7416666666667, 0.016666666666667, 0.041666666666667
33578, 1.7833333333333, 0.083333333333333, 0.041666666666667
33579, 1.7833333333333, 0.066666666666667, 0.020833333333333
33580, 1.7625, 0.066666666666667, 0.041666666666667
33581, 1.7833333333333, 0.05, 0.041666666666667
33582, 1.7833333333333, 0.033333333333333, 0.020833333333333
33583, 1.7625, 0.033333333333333, 0.041666666666667
33584, 1.7833333333333, 0.016666666666667, 0.041666666666667
33585, 1.825, 0.083333333333333, 0.041666666666667
33586, 1.825, 0.066666666666667, 0.020833333333333
33587, 1.8041666666667, 0.066666666666667, 0.041666666666667
33588, 1.825, 0.05, 0.041666666666667
33589, 1.825, 0.033333333333333, 0.020833333333333
33590, 1.8041666666667, 0.033333333333333, 0.041666666666667
33591, 1.825, 0.016666666666667, 0.041666666666667
33592, 1.8666666666667, 0.083333333333333, 0.041666666666667
33593, 1.8666666666667, 0.066666666666667, 0.020833333333333
33594, 1.8458333333333, 0.066666666666667, 0.041666666666667
33595, 1.8666666666667, 0.05, 0.041666666666667
33596, 1.8666666666667, 0.033333333333333, 0.020833333333333
33597, 1.8458333333333, 0.033333333333333, 0.041666666666667
33598, 1.8666666666667, 0.016666666666667, 0.041666666666667
33599, 1.9083333333333, 0.083333333333333, 0.041666666666667
33600, 1.9083333333333, 0.066666666666667, 0.020833333333333
33601, 1.8875, 0.066666666666667, 0.041666666666667
33602, 1.9083333333333, 0.05, 0.041666666666667
33603, 1.9083333333333, 0.033333333333333, 0.020833333333333
33604, 1.8875, 0.033333333333333, 0.041666666666667
33605, 1.9083333333333, 0.016666666666667, 0.041666666666667
33606, 1.95, 0.083333333333333, 0.041666666666667
33607, 1.95, 0.066666666666667, 0.020833333333333
33608, 1.9291666666667, 0.066666666666667, 0.041666666666667
33609, 1.95, 0.05, 0.041666666666667
33610, 1.95, 0.033333333333333, 0.020833333333333
33611, 1.9291666666667, 0.033333333333333, 0.041666666666667
33612, 1.95, 0.016666666666667, 0.041666666666667
33613, 1.9916666666667, 0.083333333333333, 0.041666666666667
33614, 1.9916666666667, 0.066666666666667, 0.020833333333333
33615, 1.9708333333333, 0.066666666666667, 0.041666666666667
33616, 1.9916666666667, 0.05, 0.041666666666667
33617, 1.9916666666667, 0.033333333333333, 0.020833333333333
33618, 1.9708333333333, 0.033333333333333, 0.041666666666667
33619, 1.9916666666667, 0.016666666666667, 0.041666666666667
33620, 2.0333333333333, 0.083333333333333, 0.041666666666667
33621, 2.0333333333333, 0.066666666666667, 0.020833333333333
33622, 2.0125, 0.066666666666667, 0.041666666666667
33623, 2.0333333333333, 0.05, 0.041666666666667
33624, 2.0333333333333, 0.033333333333333, 0.020833333333333
33625, 2.0125, 0.033333333333333, 0.041666666666667
33626, 2.0333333333333, 0.016666666666667, 0.041666666666667
33627, 2.075, 0.083333333333333, 0.041666666666667
33628, 2.075, 0.066666666666667, 0.020833333333333
33629, 2.0541666666667, 0.066666666666667, 0.041666666666667
33630, 2.075, 0.05, 0.041666666666667
33631, 2.075, 0.033333333333333, 0.020833333333333
33632, 2.0541666666667, 0.033333333333333, 0.041666666666667
33633, 2.075, 0.016666666666667, 0.041666666666667
33634, 2.1166666666667, 0.083333333333333, 0.041666666666667
33635, 2.1166666666667, 0.066666666666667, 0.020833333333333
33636, 2.0958333333333, 0.066666666666667, 0.041666666666667
33637, 2.1166666666667, 0.05, 0.041666666666667
33638, 2.1166666666667, 0.033333333333333, 0.020833333333333
33639, 2.0958333333333, 0.033333333333333, 0.041666666666667
33640, 2.1166666666667, 0.016666666666667, 0.041666666666667
33641, 2.1583333333333, 0.083333333333333, 0.041666666666667
33642, 2.1583333333333, 0.066666666666667, 0.020833333333333
33643, 2.1375, 0.066666666666667, 0.041666666666667
33644, 2.1583333333333, 0.05, 0.041666666666667
33645, 2.1583333333333, 0.033333333333333, 0.020833333333333
33646, 2.1375, 0.033333333333333, 0.041666666666667
33647, 2.1583333333333, 0.016666666666667, 0.041666666666667
33648, 2.1791666666667, 0.066666666666667, 0.041666666666667
33649, 2.1791666666667, 0.033333333333333, 0.041666666666667
33650, 1.2416666666667, 0.083333333333333, 0.083333333333333
33651, 1.2416666666667, 0.066666666666667, 0.0625
33652, 1.2208333333333, 0.066666666666667, 0.083333333333333
33653, 1.2416666666667, 0.05, 0.083333333333333
33654, 1.2416666666667, 0.033333333333333, 0.0625
33655, 1.2208333333333, 0.033333333333333, 0.083333333333333
33656, 1.2416666666667, 0.016666666666667, 0.083333333333333
33657, 1.2833333333333, 0.083333333333333, 0.083333333333333
33658, 1.2833333333333, 0.066666666666667, 0.0625
33659, 1.2625, 0.066666666666667, 0.083333333333333
33660, 1.2833333333333, 0.05, 0.083333333333333
33661, 1.2833333333333, 0.033333333333333, 0.0625
33662, 1.2625, 0.033333333333333, 0.083333333333333
33663, 1.2833333333333, 0.016666666666667, 0.083333333333333
33664, 1.325, 0.083333333333333, 0.083333333333333
33665, 1.325, 0.066666666666667, 0.0625
33666, 1.3041666666667, 0.066666666666667, 0.083333333333333
33667, 1.325, 0.05, 0.083333333333333
33668, 1.325, 0.033333333333333, 0.0625
33669, 1.3041666666667, 0.033333333333333, 0.083333333333333
33670, 1.325, 0.016666666666667, 0.083333333333333
33671, 1.3666666666667, 0.083333333333333, 0.083333333333333
33672, 1.3666666666667, 0.066666666666667, 0.0625
33673, 1.3458333333333, 0.066666666666667, 0.083333333333333
33674, 1.3666666666667, 0.05, 0.083333333333333
33675, 1.3666666666667, 0.033333333333333, 0.0625
33676, 1.3458333333333, 0.033333333333333, 0.083333333333333
33677, 1.3666666666667, 0.016666666666667, 0.083333333333333
33678, 1.4083333333333, 0.083333333333333, 0.083333333333333
33679, 1.4083333333333, 0.066666666666667, 0.0625
33680, 1.3875, 0.066666666666667, 0.083333333333333
33681, 1.4083333333333, 0.05, 0.083333333333333
33682, 1.4083333333333, 0.033333333333333, 0.0625
33683, 1.3875, 0.033333333333333, 0.083333333333333
33684, 1.4083333333333, 0.016666666666667, 0.083333333333333
33685, 1.45, 0.083333333333333, 0.083333333333333
33686, 1.45, 0.066666666666667, 0.0625
33687, 1.4291666666667, 0.066666666666667, 0.083333333333333
33688, 1.45, 0.05, 0.083333333333333
33689, 1.45, 0.033333333333333, 0.0625
33690, 1.4291666666667, 0.033333333333333, 0.083333333333333
33691, 1.45, 0.016666666666667, 0.083333333333333
33692, 1.4916666666667, 0.083333333333333, 0.083333333333333
33693, 1.4916666666667, 0.066666666666667, 0.0625
33694, 1.4708333333333, 0.066666666666667, 0.083333333333333
33695, 1.4916666666667, 0.05, 0.083333333333333
33696, 1.4916666666667, 0.033333333333333, 0.0625
33697, 1.4708333333333, 0.033333333333333, 0.083333333333333
33698, 1.4916666666667, 0.016666666666667, 0.083333333333333
33699, 1.5333333333333, 0.083333333333333, 0.083333333333333
33700, 1.5333333333333, 0.066666666666667, 0.0625
33701, 1.5125, 0.066666666666667, 0.083333333333333
33702, 1.5333333333333, 0.05, 0.083333333333333
33703, 1.5333333333333, 0.033333333333333, 0.0625
33704, 1.5125, 0.033333333333333, 0.083333333333333
33705, 1.5333333333333, 0.016666666666667, 0.083333333333333
33706, 1.575, 0.083333333333333, 0.083333333333333
33707, 1.575, 0.066666666666667, 0.0625
33708, 1.5541666666667, 0.066666666666667, 0.083333333333333
33709, 1.575, 0.05, 0.083333333333333
33710, 1.575, 0.033333333333333, 0.0625
33711, 1.5541666666667, 0.033333333333333, 0.083333333333333
33712, 1.575, 0.016666666666667, 0.083333333333333
33713, 1.6166666666667, 0.083333333333333, 0.083333333333333
33714, 1.6166666666667, 0.066666666666667, 0.0625
33715, 1.5958333333333, 0.066666666666667, 0.083333333333333
33716, 1.6166666666667, 0.05, 0.083333333333333
33717, 1.6166666666667, 0.033333333333333, 0.0625
33718, 1.5958333333333, 0.033333333333333, 0.083333333333333
33719, 1.6166666666667, 0.016666666666667, 0.083333333333333
33720, 1.6583333333333, 0.083333333333333, 0.083333333333333
33721, 1.6583333333333, 0.066666666666667, 0.0625
33722, 1.6375, 0.066666666666667, 0.083333333333333
33723, 1.6583333333333, 0.05, 0.083333333333333
33724, 1.6583333333333, 0.033333333333333, 0.0625
33725, 1.6375, 0.033333333333333, 0.083333333333333
33726, 1.6583333333333, 0.016666666666667, 0.083333333333333
33727, 1.7, 0.083333333333333, 0.083333333333333
33728, 1.7, 0.066666666666667, 0.0625
33729, 1.6791666666667, 0.066666666666667, 0.083333333333333
33730, 1.7, 0.05, 0.083333333333333
33731, 1.7, 0.033333333333333, 0.0625
33732, 1.6791666666667, 0.033333333333333, 0.083333333333333
33733, 1.7, 0.016666666666667, 0.083333333333333
33734, 1.7416666666667, 0.083333333333333, 0.083333333333333
33735, 1.7416666666667, 0.066666666666667, 0.0625
33736, 1.7208333333333, 0.066666666666667, 0.083333333333333
33737, 1.7416666666667, 0.05, 0.083333333333333
33738, 1.7416666666667, 0.033333333333333, 0.0625
33739, 1.7208333333333, 0.033333333333333, 0.083333333333333
33740, 1.7416666666667, 0.016666666666667, 0.083333333333333
33741, 1.7833333333333, 0.083333333333333, 0.083333333333333
33742, 1.7833333333333, 0.066666666666667, 0.0625
33743, 1.7625, 0.066666666666667, 0.083333333333333
33744, 1.7833333333333, 0.05, 0.083333333333333
33745, 1.7833333333333, 0.033333333333333, 0.0625
33746, 1.7625, 0.033333333333333, 0.083333333333333
33747, 1.7833333333333, 0.016666666666667, 0.083333333333333
33748, 1.825, 0.083333333333333, 0.083333333333333
33749, 1.825, 0.066666666666667, 0.0625
33750, 1.8041666666667, 0.066666666666667, 0.083333333333333
33751, 1.825, 0.05, 0.083333333333333
33752, 1.825, 0.033333333333333, 0.0625
33753, 1.8041666666667, 0.033333333333333, 0.083333333333333
33754, 1.825, 0.016666666666667, 0.083333333333333
33755, 1.8666666666667, 0.083333333333333, 0.083333333333333
33756, 1.8666666666667, 0.066666666666667, 0.0625
33757, 1.8458333333333, 0.066666666666667, 0.083333333333333
33758, 1.8666666666667, 0.05, 0.083333333333333
33759, 1.8666666666667, 0.033333333333333, 0.0625
33760, 1.8458333333333, 0.033333333333333, 0.083333333333333
33761, 1.8666666666667, 0.016666666666667, 0.083333333333333
33762, 1.9083333333333, 0.083333333333333, 0.083333333333333
33763, 1.9083333333333, 0.066666666666667, 0.0625
33764, 1.8875, 0.066666666666667, 0.083333333333333
33765, 1.9083333333333, 0.05, 0.083333333333333
33766, 1.9083333333333, 0.033333333333333, 0.0625
33767, 1.8875, 0.033333333333333, 0.083333333333333
33768, 1.9083333333333, 0.016666666666667, 0.083333333333333
33769, 1.95, 0.083333333333333, 0.083333333333333
33770, 1.95, 0.066666666666667, 0.0625
33771, 1.9291666666667, 0.066666666666667, 0.083333333333333
33772, 1.95, 0.05, 0.083333333333333
33773, 1.95, 0.033333333333333, 0.0625
33774, 1.9291666666667, 0.033333333333333, 0.083333333333333
33775, 1.95, 0.016666666666667, 0.083333333333333
33776, 1.9916666666667, 0.083333333333333, 0.083333333333333
33777, 1.9916666666667, 0.066666666666667, 0.0625
33778, 1.9708333333333, 0.066666666666667, 0.083333333333333
33779, 1.9916666666667, 0.05, 0.083333333333333
33780, 1.9916666666667, 0.033333333333333, 0.0625
33781, 1.9708333333333, 0.033333333333333, 0.083333333333333
33782, 1.9916666666667, 0.016666666666667, 0.083333333333333
33783, 2.0333333333333, 0.083333333333333, 0.083333333333333
33784, 2.0333333333333, 0.066666666666667, 0.0625
33785, 2.0125, 0.066666666666667, 0.083333333333333
33786, 2.0333333333333, 0.05, 0.083333333333333
33787, 2.0333333333333, 0.033333333333333, 0.0625
33788, 2.0125, 0.033333333333333, 0.083333333333333
33789, 2.0333333333333, 0.016666666666667, 0.083333333333333
33790, 2.075, 0.083333333333333, 0.083333333333333
33791, 2.075, 0.066666666666667, 0.0625
33792, 2.0541666666667, 0.066666666666667, 0.083333333333333
33793, 2.075, 0.05, 0.083333333333333
33794, 2.075, 0.033333333333333, 0.0625
33795, 2.0541666666667, 0.033333333333333, 0.083333333333333
33796, 2.075, 0.016666666666667, 0.083333333333333
33797, 2.1166666666667, 0.083333333333333, 0.083333333333333
33798, 2.1166666666667, 0.066666666666667, 0.0625
33799, 2.0958333333333, 0.066666666666667, 0.083333333333333
33800, 2.1166666666667, 0.05, 0.083333333333333
33801, 2.1166666666667, 0.033333333333333, 0.0625
33802, 2.0958333333333, 0.033333333333333, 0.083333333333333
33803, 2.1166666666667, 0.016666666666667, 0.083333333333333
33804, 2.1583333333333, 0.083333333333333, 0.083333333333333
33805, 2.1583333333333, 0.066666666666667, 0.0625
33806, 2.1375, 0.066666666666667, 0.083333333333333
33807, 2.1583333333333, 0.05, 0.083333333333333
33808, 2.1583333333333, 0.033333333333333, 0.0625
33809, 2.1375, 0.033333333333333, 0.083333333333333
33810, 2.1583333333333, 0.016666666666667, 0.083333333333333
33811, 2.1791666666667, 0.066666666666667, 0.083333333333333
33812, 2.1791666666667, 0.033333333333333, 0.083333333333333
33813, 1.2416666666667, 0.083333333333333, 0.125
33814, 1.2416666666667, 0.066666666666667, 0.10416666666667
33815, 1.2208333333333, 0.066666666666667, 0.125
33816, 1.2416666666667, 0.05, 0.125
33817, 1.2416666666667, 0.033333333333333, 0.10416666666667
33818, 1.2208333333333, 0.033333333333333, 0.125
33819, 1.2416666666667, 0.016666666666667, 0.125
33820, 1.2833333333333, 0.083333333333333, 0.125
33821, 1.2833333333333, 0.066666666666667, 0.10416666666667
33822, 1.2625, 0.066666666666667, 0.125
33823, 1.2833333333333, 0.05, 0.125
33824, 1.2833333333333, 0.033333333333333, 0.10416666666667
33825, 1.2625, 0.033333333333333, 0.125
33826, 1.2833333333333, 0.016666666666667, 0.125
33827, 1.325, 0.083333333333333, 0.125
33828, 1.325, 0.066666666666667, 0.10416666666667
33829, 1.3041666666667, 0.066666666666667, 0.125
33830, 1.325, 0.05, 0.125
33831, 1.325, 0.033333333333333, 0.10416666666667
33832, 1.3041666666667, 0.033333333333333, 0.125
33833, 1.325, 0.016666666666667, 0.125
33834, 1.3666666666667, 0.083333333333333, 0.125
33835, 1.3666666666667, 0.066666666666667, 0.10416666666667
33836, 1.3458333333333, 0.066666666666667, 0.125
33837, 1.3666666666667, 0.05, 0.125
33838, 1.3666666666667, 0.033333333333333, 0.10416666666667
33839, 1.3458333333333, 0.033333333333333, 0.125
33840, 1.3666666666667, 0.016666666666667, 0.125
33841, 1.4083333333333, 0.083333333333333, 0.125
33842, 1.4083333333333, 0.066666666666667, 0.10416666666667
33843, 1.3875, 0.066666666666667, 0.125
33844, 1.4083333333333, 0.05, 0.125
33845, 1.4083333333333, 0.033333333333333, 0.10416666666667
33846, 1.3875, 0.033333333333333, 0.125
33847, 1.4083333333333, 0.016666666666667, 0.125
33848, 1.45, 0.083333333333333, 0.125
33849, 1.45, 0.066666666666667, 0.10416666666667
33850, 1.4291666666667, 0.066666666666667, 0.125
33851, 1.45, 0.05, 0.125
33852, 1.45, 0.033333333333333, 0.10416666666667
33853, 1.4291666666667, 0.033333333333333, 0.125
33854, 1.45, 0.016666666666667, 0.125
33855, 1.4916666666667, 0.083333333333333, 0.125
33856, 1.4916666666667, 0.066666666666667, 0.10416666666667
33857, 1.4708333333333, 0.066666666666667, 0.125
33858, 1.4916666666667, 0.05, 0.125
33859, 1.4916666666667, 0.033333333333333, 0.10416666666667
33860, 1.4708333333333, 0.033333333333333, 0.125
33861, 1.4916666666667, 0.016666666666667, 0.125
33862, 1.5333333333333, 0.083333333333333, 0.125
33863, 1.5333333333333, 0.066666666666667, 0.10416666666667
33864, 1.5125, 0.066666666666667, 0.125
33865, 1.5333333333333, 0.05, 0.125
33866, 1.5333333333333, 0.033333333333333, 0.10416666666667
33867, 1.5125, 0.033333333333333, 0.125
33868, 1.5333333333333, 0.016666666666667, 0.125
33869, 1.575, 0.083333333333333, 0.125
33870, 1.575, 0.066666666666667, 0.10416666666667
33871, 1.5541666666667, 0.066666666666667, 0.125
33872, 1.575, 0.05, 0.125
33873, 1.575, 0.033333333333333, 0.10416666666667
33874, 1.5541666666667, 0.033333333333333, 0.125
33875, 1.575, 0.016666666666667, 0.125
33876, 1.6166666666667, 0.083333333333333, 0.125
33877, 1.6166666666667, 0.066666666666667, 0.10416666666667
33878, 1.5958333333333, 0.066666666666667, 0.125
33879, 1.6166666666667, 0.05, 0.125
33880, 1.6166666666667, 0.033333333333333, 0.10416666666667
33881, 1.5958333333333, 0.033333333333333, 0.125
33882, 1.6166666666667, 0.016666666666667, 0.125
33883, 1.6583333333333, 0.083333333333333, 0.125
33884, 1.6583333333333, 0.066666666666667, 0.10416666666667
33885, 1.6375, 0.066666666666667, 0.125
33886, 1.6583333333333, 0.05, 0.125
33887, 1.6583333333333, 0.033333333333333, 0.10416666666667
33888, 1.6375, 0.033333333333333, 0.125
33889, 1.6583333333333, 0.016666666666667, 0.125
33890, 1.7, 0.083333333333333, 0.125
33891, 1.7, 0.066666666666667, 0.10416666666667
33892, 1.6791666666667, 0.066666666666667, 0.125
33893, 1.7, 0.05, 0.125
33894, 1.7, 0.033333333333333, 0.10416666666667
33895, 1.6791666666667, 0.033333333333333, 0.125
33896, 1.7, 0.016666666666667, 0.125
33897, 1.7416666666667, 0.083333333333333, 0.125
33898, 1.7416666666667, 0.066666666666667, 0.10416666666667
33899, 1.7208333333333, 0.066666666666667, 0.125
33900, 1.7416666666667, 0.05, 0.125
33901, 1.7416666666667, 0.033333333333333, 0.10416666666667
33902, 1.7208333333333, 0.033333333333333, 0.125
33903, 1.7416666666667, 0.016666666666667, 0.125
33904, 1.7833333333333, 0.083333333333333, 0.125
33905, 1.7833333333333, 0.066666666666667, 0.10416666666667
33906, 1.7625, 0.066666666666667, 0.125
33907, 1.7833333333333, 0.05, 0.125
33908, 1.7833333333333, 0.033333333333333, 0.10416666666667
33909, 1.7625, 0.033333333333333, 0.125
33910, 1.7833333333333, 0.016666666666667, 0.125
33911, 1.825, 0.083333333333333, 0.125
33912, 1.825, 0.066666666666667, 0.10416666666667
33913, 1.8041666666667, 0.066666666666667, 0.125
33914, 1.825, 0.05, 0.125
33915, 1.825, 0.033333333333333, 0.10416666666667
33916, 1.8041666666667, 0.033333333333333, 0.125
33917, 1.825, 0.016666666666667, 0.125
33918, 1.8666666666667, 0.083333333333333, 0.125
33919, 1.8666666666667, 0.066666666666667, 0.10416666666667
33920, 1.8458333333333, 0.066666666666667, 0.125
33921, 1.8666666666667, 0.05, 0.125
33922, 1.8666666666667, 0.033333333333333, 0.10416666666667
33923, 1.8458333333333, 0.033333333333333, 0.125
33924, 1.8666666666667, 0.016666666666667, 0.125
33925, 1.9083333333333, 0.083333333333333, 0.125
33926, 1.9083333333333, 0.066666666666667, 0.10416666666667
33927, 1.8875, 0.066666666666667, 0.125
33928, 1.9083333333333, 0.05, 0.125
33929, 1.9083333333333, 0.033333333333333, 0.10416666666667
33930, 1.8875, 0.033333333333333, 0.125
33931, 1.9083333333333, 0.016666666666667, 0.125
33932, 1.95, 0.083333333333333, 0.125
33933, 1.95, 0.066666666666667, 0.10416666666667
33934, 1.9291666666667, 0.066666666666667, 0.125
33935, 1.95, 0.05, 0.125
33936, 1.95, 0.033333333333333, 0.10416666666667
33937, 1.9291666666667, 0.033333333333333, 0.125
33938, 1.95, 0.016666666666667, 0.125
33939, 1.9916666666667, 0.083333333333333, 0.125
33940, 1.9916666666667, 0.066666666666667, 0.10416666666667
33941, 1.9708333333333, 0.066666666666667, 0.125
33942, 1.9916666666667, 0.05, 0.125
33943, 1.9916666666667, 0.033333333333333, 0.10416666666667
33944, 1.9708333333333, 0.033333333333333, 0.125
33945, 1.9916666666667, 0.016666666666667, 0.125
33946, 2.0333333333333, 0.083333333333333, 0.125
33947, 2.0333333333333, 0.066666666666667, 0.10416666666667
33948, 2.0125, 0.066666666666667, 0.125
33949, 2.0333333333333, 0.05, 0.125
33950, 2.0333333333333, 0.033333333333333, 0.10416666666667
33951, 2.0125, 0.033333333333333, 0.125
33952, 2.0333333333333, 0.016666666666667, 0.125
33953, 2.075, 0.083333333333333, 0.125
33954, 2.075, 0.066666666666667, 0.10416666666667
33955, 2.0541666666667, 0.066666666666667, 0.125
33956, 2.075, 0.05, 0.125
33957, 2.075, 0.033333333333333, 0.10416666666667
33958, 2.0541666666667, 0.033333333333333, 0.125
33959, 2.075, 0.016666666666667, 0.125
33960, 2.1166666666667, 0.083333333333333, 0.125
33961, 2.1166666666667, 0.066666666666667, 0.10416666666667
33962, 2.0958333333333, 0.066666666666667, 0.125
33963, 2.1166666666667, 0.05, 0.125
33964, 2.1166666666667, 0.033333333333333, 0.10416666666667
33965, 2.0958333333333, 0.033333333333333, 0.125
33966, 2.1166666666667, 0.016666666666667, 0.125
33967, 2.1583333333333, 0.083333333333333, 0.125
33968, 2.1583333333333, 0.066666666666667, 0.10416666666667
33969, 2.1375, 0.066666666666667, 0.125
33970, 2.1583333333333, 0.05, 0.125
33971, 2.1583333333333, 0.033333333333333, 0.10416666666667
33972, 2.1375, 0.033333333333333, 0.125
33973, 2.1583333333333, 0.016666666666667, 0.125
33974, 2.1791666666667, 0.066666666666667, 0.125
33975, 2.1791666666667, 0.033333333333333, 0.125
33976, 1.2416666666667, 0.083333333333333, 0.16666666666667
33977, 1.2416666666667, 0.066666666666667, 0.14583333333333
33978, 1.2208333333333, 0.066666666666667, 0.16666666666667
33979, 1.2416666666667, 0.05, 0.16666666666667
33980, 1.2416666666667, 0.033333333333333, 0.14583333333333
33981, 1.2208333333333, 0.033333333333333, 0.16666666666667
33982, 1.2416666666667, 0.016666666666667, 0.16666666666667
33983, 1.2833333333333, 0.083333333333333, 0.16666666666667
33984, 1.2833333333333, 0.066666666666667, 0.14583333333333
33985, 1.2625, 0.066666666666667, 0.16666666666667
33986, 1.2833333333333, 0.05, 0.16666666666667
33987, 1.2833333333333, 0.033333333333333, 0.14583333333333
33988, 1.2625, 0.033333333333333, 0.16666666666667
33989, 1.2833333333333, 0.016666666666667, 0.16666666666667
33990, 1.325, 0.083333333333333, 0.16666666666667
33991, 1.325, 0.066666666666667, 0.14583333333333
33992, 1.3041666666667, 0.066666666666667, 0.16666666666667
33993, 1.325, 0.05, 0.16666666666667
33994, 1.325, 0.033333333333333, 0.14583333333333
33995, 1.3041666666667, 0.033333333333333, 0.16666666666667
33996, 1.325, 0.016666666666667, 0.16666666666667
33997, 1.3666666666667, 0.083333333333333, 0.16666666666667
33998, 1.3666666666667, 0.066666666666667, 0.14583333333333
33999, 1.3458333333333, 0.066666666666667, 0.16666666666667
34000, 1.3666666666667, 0.05, 0.16666666666667
34001, 1.3666666666667, 0.033333333333333, 0.14583333333333
34002, 1.3458333333333, 0.033333333333333, 0.16666666666667
34003, 1.3666666666667, 0.016666666666667, 0.16666666666667
34004, 1.4083333333333, 0.083333333333333, 0.16666666666667
34005, 1.4083333333333, 0.066666666666667, 0.14583333333333
34006, 1.3875, 0.066666666666667, 0.16666666666667
34007, 1.4083333333333, 0.05, 0.16666666666667
34008, 1.4083333333333, 0.033333333333333, 0.14583333333333
34009, 1.3875, 0.033333333333333, 0.16666666666667
34010, 1.4083333333333, 0.016666666666667, 0.16666666666667
34011, 1.45, 0.083333333333333, 0.16666666666667
34012, 1.45, 0.066666666666667, 0.14583333333333
34013, 1.4291666666667, 0.066666666666667, 0.16666666666667
34014, 1.45, 0.05, 0.16666666666667
34015, 1.45, 0.033333333333333, 0.14583333333333
34016, 1.4291666666667, 0.033333333333333, 0.16666666666667
34017, 1.45, 0.016666666666667, 0.16666666666667
34018, 1.4916666666667, 0.083333333333333, 0.16666666666667
34019, 1.4916666666667, 0.066666666666667, 0.14583333333333
34020, 1.4708333333333, 0.066666666666667, 0.16666666666667
34021, 1.4916666666667, 0.05, 0.16666666666667
34022, 1.4916666666667, 0.033333333333333, 0.14583333333333
34023, 1.4708333333333, 0.033333333333333, 0.16666666666667
34024, 1.4916666666667, 0.016666666666667, 0.16666666666667
34025, 1.5333333333333, 0.083333333333333, 0.16666666666667
34026, 1.5333333333333, 0.066666666666667, 0.14583333333333
34027, 1.5125, 0.066666666666667, 0.16666666666667
34028, 1.5333333333333, 0.05, 0.16666666666667
34029, 1.5333333333333, 0.033333333333333, 0.14583333333333
34030, 1.5125, 0.033333333333333, 0.16666666666667
34031, 1.5333333333333, 0.016666666666667, 0.16666666666667
34032, 1.575, 0.083333333333333, 0.16666666666667
34033, 1.575, 0.066666666666667, 0.14583333333333
34034, 1.5541666666667, 0.066666666666667, 0.16666666666667
34035, 1.575, 0.05, 0.16666666666667
34036, 1.575, 0.033333333333333, 0.14583333333333
34037, 1.5541666666667, 0.033333333333333, 0.16666666666667
34038, 1.575, 0.016666666666667, 0.16666666666667
34039, 1.6166666666667, 0.083333333333333, 0.16666666666667
34040, 1.6166666666667, 0.066666666666667, 0.14583333333333
34041, 1.5958333333333, 0.066666666666667, 0.16666666666667
34042, 1.6166666666667, 0.05, 0.16666666666667
34043, 1.6166666666667, 0.033333333333333, 0.14583333333333
34044, 1.5958333333333, 0.033333333333333, 0.16666666666667
34045, 1.6166666666667, 0.016666666666667, 0.16666666666667
34046, 1.6583333333333, 0.083333333333333, 0.16666666666667
34047, 1.6583333333333, 0.066666666666667, 0.14583333333333
34048, 1.6375, 0.066666666666667, 0.16666666666667
34049, 1.6583333333333, 0.05, 0.16666666666667
34050, 1.6583333333333, 0.033333333333333, 0.14583333333333
34051, 1.6375, 0.033333333333333, 0.16666666666667
34052, 1.6583333333333, 0.016666666666667, 0.16666666666667
34053, 1.7, 0.083333333333333, 0.16666666666667
34054, 1.7, 0.066666666666667, 0.14583333333333
34055, 1.6791666666667, 0.066666666666667, 0.16666666666667
34056, 1.7, 0.05, 0.16666666666667
34057, 1.7, 0.033333333333333, 0.14583333333333
34058, 1.6791666666667, 0.033333333333333, 0.16666666666667
34059, 1.7, 0.016666666666667, 0.16666666666667
34060, 1.7416666666667, 0.083333333333333, 0.16666666666667
34061, 1.7416666666667, 0.066666666666667, 0.14583333333333
34062, 1.7208333333333, 0.066666666666667, 0.16666666666667
34063, 1.7416666666667, 0.05, 0.16666666666667
34064, 1.7416666666667, 0.033333333333333, 0.14583333333333
34065, 1.7208333333333, 0.033333333333333, 0.16666666666667
34066, 1.7416666666667, 0.016666666666667, 0.16666666666667
34067, 1.7833333333333, 0.083333333333333, 0.16666666666667
34068, 1.7833333333333, 0.066666666666667, 0.14583333333333
34069, 1.7625, 0.066666666666667, 0.16666666666667
34070, 1.7833333333333, 0.05, 0.16666666666667
34071, 1.7833333333333, 0.033333333333333, 0.14583333333333
34072, 1.7625, 0.033333333333333, 0.16666666666667
34073, 1.7833333333333, 0.016666666666667, 0.16666666666667
34074, 1.825, 0.083333333333333, 0.16666666666667
34075, 1.825, 0.066666666666667, 0.14583333333333
34076, 1.8041666666667, 0.066666666666667, 0.16666666666667
34077, 1.825, 0.05, 0.16666666666667
34078, 1.825, 0.033333333333333, 0.14583333333333
34079, 1.8041666666667, 0.033333333333333, 0.16666666666667
34080, 1.825, 0.016666666666667, 0.16666666666667
34081, 1.8666666666667, 0.083333333333333, 0.16666666666667
34082, 1.8666666666667, 0.066666666666667, 0.14583333333333
34083, 1.8458333333333, 0.066666666666667, 0.16666666666667
34084, 1.8666666666667, 0.05, 0.16666666666667
34085, 1.8666666666667, 0.033333333333333, 0.14583333333333
34086, 1.8458333333333, 0.033333333333333, 0.16666666666667
34087, 1.8666666666667, 0.016666666666667, 0.16666666666667
34088, 1.9083333333333, 0.083333333333333, 0.16666666666667
34089, 1.9083333333333, 0.066666666666667, 0.14583333333333
34090, 1.8875, 0.066666666666667, 0.16666666666667
34091, 1.9083333333333, 0.05, 0.16666666666667
34092, 1.9083333333333, 0.033333333333333, 0.14583333333333
34093, 1.8875, 0.033333333333333, 0.16666666666667
34094, 1.9083333333333, 0.016666666666667, 0.16666666666667
34095, 1.95, 0.083333333333333, 0.16666666666667
34096, 1.95, 0.066666666666667, 0.14583333333333
34097, 1.9291666666667, 0.066666666666667, 0.16666666666667
34098, 1.95, 0.05, 0.16666666666667
34099, 1.95, 0.033333333333333, 0.14583333333333
34100, 1.9291666666667, 0.033333333333333, 0.16666666666667
34101, 1.95, 0.016666666666667, 0.16666666666667
34102, 1.9916666666667, 0.083333333333333, 0.16666666666667
34103, 1.9916666666667, 0.066666666666667, 0.14583333333333
34104, 1.9708333333333, 0.066666666666667, 0.16666666666667
34105, 1.9916666666667, 0.05, 0.16666666666667
34106, 1.9916666666667, 0.033333333333333, 0.14583333333333
34107, 1.9708333333333, 0.033333333333333, 0.16666666666667
34108, 1.9916666666667, 0.016666666666667, 0.16666666666667
34109, 2.0333333333333, 0.083333333333333, 0.16666666666667
34110, 2.0333333333333, 0.066666666666667, 0.14583333333333
34111, 2.0125, 0.066666666666667, 0.16666666666667
34112, 2.0333333333333, 0.05, 0.16666666666667
34113, 2.0333333333333, 0.033333333333333, 0.14583333333333
34114, 2.0125, 0.033333333333333, 0.16666666666667
34115, 2.0333333333333, 0.016666666666667, 0.16666666666667
34116, 2.075, 0.083333333333333, 0.16666666666667
34117, 2.075, 0.066666666666667, 0.14583333333333
34118, 2.0541666666667, 0.066666666666667, 0.16666666666667
34119, 2.075, 0.05, 0.16666666666667
34120, 2.075, 0.033333333333333, 0.14583333333333
34121, 2.0541666666667, 0.033333333333333, 0.16666666666667
34122, 2.075, 0.016666666666667, 0.16666666666667
34123, 2.1166666666667, 0.083333333333333, 0.16666666666667
34124, 2.1166666666667, 0.066666666666667, 0.14583333333333
34125, 2.0958333333333, 0.066666666666667, 0.16666666666667
34126, 2.1166666666667, 0.05, 0.16666666666667
34127, 2.1166666666667, 0.033333333333333, 0.14583333333333
34128, 2.0958333333333, 0.033333333333333, 0.16666666666667
34129, 2.1166666666667, 0.016666666666667, 0.16666666666667
34130, 2.1583333333333, 0.083333333333333, 0.16666666666667
34131, 2.1583333333333, 0.066666666666667, 0.14583333333333
34132, 2.1375, 0.066666666666667, 0.16666666666667
34133, 2.1583333333333, 0.05, 0.16666666666667
34134, 2.1583333333333, 0.033333333333333, 0.14583333333333
34135, 2.1375, 0.033333333333333, 0.16666666666667
34136, 2.1583333333333, 0.016666666666667, 0.16666666666667
34137, 2.1791666666667, 0.066666666666667, 0.16666666666667
34138, 2.1791666666667, 0.033333333333333, 0.16666666666667
34139, 1.2416666666667, 0.083333333333333, 0.20833333333333
34140, 1.2416666666667, 0.066666666666667, 0.1875
34141, 1.2208333333333, 0.066666666666667, 0.20833333333333
34142, 1.2416666666667, 0.05, 0.20833333333333
34143, 1.2416666666667, 0.033333333333333, 0.1875
34144, 1.2208333333333, 0.033333333333333, 0.20833333333333
34145, 1.2416666666667, 0.016666666666667, 0.20833333333333
34146, 1.2833333333333, 0.083333333333333, 0.20833333333333
34147, 1.2833333333333, 0.066666666666667, 0.1875
34148, 1.2625, 0.066666666666667, 0.20833333333333
34149, 1.2833333333333, 0.05, 0.20833333333333
34150, 1.2833333333333, 0.033333333333333, 0.1875
34151, 1.2625, 0.033333333333333, 0.20833333333333
34152, 1.2833333333333, 0.016666666666667, 0.20833333333333
34153, 1.325, 0.083333333333333, 0.20833333333333
34154, 1.325, 0.066666666666667, 0.1875
34155, 1.3041666666667, 0.066666666666667, 0.20833333333333
34156, 1.325, 0.05, 0.20833333333333
34157, 1.325, 0.033333333333333, 0.1875
34158, 1.3041666666667, 0.033333333333333, 0.20833333333333
34159, 1.325, 0.016666666666667, 0.20833333333333
34160, 1.3666666666667, 0.083333333333333, 0.20833333333333
34161, 1.3666666666667, 0.066666666666667, 0.1875
34162, 1.3458333333333, 0.066666666666667, 0.20833333333333
34163, 1.3666666666667, 0.05, 0.20833333333333
34164, 1.3666666666667, 0.033333333333333, 0.1875
34165, 1.3458333333333, 0.033333333333333, 0.20833333333333
34166, 1.3666666666667, 0.016666666666667, 0.20833333333333
34167, 1.4083333333333, 0.083333333333333, 0.20833333333333
34168, 1.4083333333333, 0.066666666666667, 0.1875
34169, 1.3875, 0.066666666666667, 0.20833333333333
34170, 1.4083333333333, 0.05, 0.20833333333333
34171, 1.4083333333333, 0.033333333333333, 0.1875
34172, 1.3875, 0.033333333333333, 0.20833333333333
34173, 1.4083333333333, 0.016666666666667, 0.20833333333333
34174, 1.45, 0.083333333333333, 0.20833333333333
34175, 1.45, 0.066666666666667, 0.1875
34176, 1.4291666666667, 0.066666666666667, 0.20833333333333
34177, 1.45, 0.05, 0.20833333333333
34178, 1.45, 0.033333333333333, 0.1875
34179, 1.4291666666667, 0.033333333333333, 0.20833333333333
34180, 1.45, 0.016666666666667, 0.20833333333333
34181, 1.4916666666667, 0.083333333333333, 0.20833333333333
34182, 1.4916666666667, 0.066666666666667, 0.1875
34183, 1.4708333333333, 0.066666666666667, 0.20833333333333
34184, 1.4916666666667, 0.05, 0.20833333333333
34185, 1.4916666666667, 0.033333333333333, 0.1875
34186, 1.4708333333333, 0.033333333333333, 0.20833333333333
34187, 1.4916666666667, 0.016666666666667, 0.20833333333333
34188, 1.5333333333333, 0.083333333333333, 0.20833333333333
34189, 1.5333333333333, 0.066666666666667, 0.1875
34190, 1.5125, 0.066666666666667, 0.20833333333333
34191, 1.5333333333333, 0.05, 0.20833333333333
34192, 1.5333333333333, 0.033333333333333, 0.1875
34193, 1.5125, 0.033333333333333, 0.20833333333333
34194, 1.5333333333333, 0.016666666666667, 0.20833333333333
34195, 1.575, 0.083333333333333, 0.20833333333333
34196, 1.575, 0.066666666666667, 0.1875
34197, 1.5541666666667, 0.066666666666667, 0.20833333333333
34198, 1.575, 0.05, 0.20833333333333
34199, 1.575, 0.033333333333333, 0.1875
34200, 1.5541666666667, 0.033333333333333, 0.20833333333333
34201, 1.575, 0.016666666666667, 0.20833333333333
34202, 1.6166666666667, 0.083333333333333, 0.20833333333333
34203, 1.6166666666667, 0.066666666666667, 0.1875
34204, 1.5958333333333, 0.066666666666667, 0.20833333333333
34205, 1.6166666666667, 0.05, 0.20833333333333
34206, 1.6166666666667, 0.033333333333333, 0.1875
34207, 1.5958333333333, 0.033333333333333, 0.20833333333333
34208, 1.6166666666667, 0.016666666666667, 0.20833333333333
34209, 1.6583333333333, 0.083333333333333, 0.20833333333333
34210, 1.6583333333333, 0.066666666666667, 0.1875
34211, 1.6375, 0.066666666666667, 0.20833333333333
34212, 1.6583333333333, 0.05, 0.20833333333333
34213, 1.6583333333333, 0.033333333333333, 0.1875
34214, 1.6375, 0.033333333333333, 0.20833333333333
34215, 1.6583333333333, 0.016666666666667, 0.20833333333333
34216, 1.7, 0.083333333333333, 0.20833333333333
34217, 1.7, 0.066666666666667, 0.1875
34218, 1.6791666666667, 0.066666666666667, 0.20833333333333
34219, 1.7, 0.05, 0.20833333333333
34220, 1.7, 0.033333333333333, 0.1875
34221, 1.6791666666667, 0.033333333333333, 0.20833333333333
34222, 1.7, 0.016666666666667, 0.20833333333333
34223, 1.7416666666667, 0.083333333333333, 0.20833333333333
34224, 1.7416666666667, 0.066666666666667, 0.1875
34225, 1.7208333333333, 0.066666666666667, 0.20833333333333
34226, 1.7416666666667, 0.05, 0.20833333333333
34227, 1.7416666666667, 0.033333333333333, 0.1875
34228, 1.7208333333333, 0.033333333333333, 0.20833333333333
34229, 1.7416666666667, 0.016666666666667, 0.20833333333333
34230, 1.7833333333333, 0.083333333333333, 0.20833333333333
34231, 1.7833333333333, 0.066666666666667, 0.1875
34232, 1.7625, 0.066666666666667, 0.20833333333333
34233, 1.7833333333333, 0.05, 0.20833333333333
34234, 1.7833333333333, 0.033333333333333, 0.1875
34235, 1.7625, 0.033333333333333, 0.20833333333333
34236, 1.7833333333333, 0.016666666666667, 0.20833333333333
34237, 1.825, 0.083333333333333, 0.20833333333333
34238, 1.825, 0.066666666666667, 0.1875
34239, 1.8041666666667, 0.066666666666667, 0.20833333333333
34240, 1.825, 0.05, 0.20833333333333
34241, 1.825, 0.033333333333333, 0.1875
34242, 1.8041666666667, 0.033333333333333, 0.20833333333333
34243, 1.825, 0.016666666666667, 0.20833333333333
34244, 1.8666666666667, 0.083333333333333, 0.20833333333333
34245, 1.8666666666667, 0.066666666666667, 0.1875
34246, 1.8458333333333, 0.066666666666667, 0.20833333333333
34247, 1.8666666666667, 0.05, 0.20833333333333
34248, 1.8666666666667, 0.033333333333333, 0.1875
34249, 1.8458333333333, 0.033333333333333, 0.20833333333333
34250, 1.8666666666667, 0.016666666666667, 0.20833333333333
34251, 1.9083333333333, 0.083333333333333, 0.20833333333333
34252, 1.9083333333333, 0.066666666666667, 0.1875
34253, 1.8875, 0.066666666666667, 0.20833333333333
34254, 1.9083333333333, 0.05, 0.20833333333333
34255, 1.9083333333333, 0.033333333333333, 0.1875
34256, 1.8875, 0.033333333333333, 0.20833333333333
34257, 1.9083333333333, 0.016666666666667, 0.20833333333333
34258, 1.95, 0.083333333333333, 0.20833333333333
34259, 1.95, 0.066666666666667, 0.1875
34260, 1.9291666666667, 0.066666666666667, 0.20833333333333
34261, 1.95, 0.05, 0.20833333333333
34262, 1.95, 0.033333333333333, 0.1875
34263, 1.9291666666667, 0.033333333333333, 0.20833333333333
34264, 1.95, 0.016666666666667, 0.20833333333333
34265, 1.9916666666667, 0.083333333333333, 0.20833333333333
34266, 1.9916666666667, 0.066666666666667, 0.1875
34267, 1.9708333333333, 0.066666666666667, 0.20833333333333
34268, 1.9916666666667, 0.05, 0.20833333333333
34269, 1.9916666666667, 0.033333333333333, 0.1875
34270, 1.9708333333333, 0.033333333333333, 0.20833333333333
34271, 1.9916666666667, 0.016666666666667, 0.20833333333333
34272, 2.0333333333333, 0.083333333333333, 0.20833333333333
34273, 2.0333333333333, 0.066666666666667, 0.1875
34274, 2.0125, 0.066666666666667, 0.20833333333333
34275, 2.0333333333333, 0.05, 0.20833333333333
34276, 2.0333333333333, 0.033333333333333, 0.1875
34277, 2.0125, 0.033333333333333, 0.20833333333333
34278, 2.0333333333333, 0.016666666666667, 0.20833333333333
34279, 2.075, 0.083333333333333, 0.20833333333333
34280, 2.075, 0.066666666666667, 0.1875
34281, 2.0541666666667, 0.066666666666667, 0.20833333333333
34282, 2.075, 0.05, 0.20833333333333
34283, 2.075, 0.033333333333333, 0.1875
34284, 2.0541666666667, 0.033333333333333, 0.20833333333333
34285, 2.075, 0.016666666666667, 0.20833333333333
34286, 2.1166666666667, 0.083333333333333, 0.20833333333333
34287, 2.1166666666667, 0.066666666666667, 0.1875
34288, 2.0958333333333, 0.066666666666667, 0.20833333333333
34289, 2.1166666666667, 0.05, 0.20833333333333
34290, 2.1166666666667, 0.033333333333333, 0.1875
34291, 2.0958333333333, 0.033333333333333, 0.20833333333333
34292, 2.1166666666667, 0.016666666666667, 0.20833333333333
34293, 2.1583333333333, 0.083333333333333, 0.20833333333333
34294, 2.1583333333333, 0.066666666666667, 0.1875
34295, 2.1375, 0.066666666666667, 0.20833333333333
34296, 2.1583333333333, 0.05, 0.20833333333333
34297, 2.1583333333333, 0.033333333333333, 0.1875
34298, 2.1375, 0.033333333333333, 0.20833333333333
34299, 2.1583333333333, 0.016666666666667, 0.20833333333333
34300, 2.1791666666667, 0.066666666666667, 0.20833333333333
34301, 2.1791666666667, 0.033333333333333, 0.20833333333333
34302, 1.2416666666667, 0.083333333333333, 0.25
34303, 1.2416666666667, 0.066666666666667, 0.22916666666667
34304, 1.2208333333333, 0.066666666666667, 0.25
34305, 1.2416666666667, 0.05, 0.25
34306, 1.2416666666667, 0.033333333333333, 0.22916666666667
34307, 1.2208333333333, 0.033333333333333, 0.25
34308, 1.2416666666667, 0.016666666666667, 0.25
34309, 1.2833333333333, 0.083333333333333, 0.25
34310, 1.2833333333333, 0.066666666666667, 0.22916666666667
34311, 1.2625, 0.066666666666667, 0.25
34312, 1.2833333333333, 0.05, 0.25
34313, 1.2833333333333, 0.033333333333333, 0.22916666666667
34314, 1.2625, 0.033333333333333, 0.25
34315, 1.2833333333333, 0.016666666666667, 0.25
34316, 1.325, 0.083333333333333, 0.25
34317, 1.325, 0.066666666666667, 0.22916666666667
34318, 1.3041666666667, 0.066666666666667, 0.25
34319, 1.325, 0.05, 0.25
34320, 1.325, 0.033333333333333, 0.22916666666667
34321, 1.3041666666667, 0.033333333333333, 0.25
34322, 1.325, 0.016666666666667, 0.25
34323, 1.3666666666667, 0.083333333333333, 0.25
34324, 1.3666666666667, 0.066666666666667, 0.22916666666667
34325, 1.3458333333333, 0.066666666666667, 0.25
34326, 1.3666666666667, 0.05, 0.25
34327, 1.3666666666667, 0.033333333333333, 0.22916666666667
34328, 1.3458333333333, 0.033333333333333, 0.25
34329, 1.3666666666667, 0.016666666666667, 0.25
34330, 1.4083333333333, 0.083333333333333, 0.25
34331, 1.4083333333333, 0.066666666666667, 0.22916666666667
34332, 1.3875, 0.066666666666667, 0.25
34333, 1.4083333333333, 0.05, 0.25
34334, 1.4083333333333, 0.033333333333333, 0.22916666666667
34335, 1.3875, 0.033333333333333, 0.25
34336, 1.4083333333333, 0.016666666666667, 0.25
34337, 1.45, 0.083333333333333, 0.25
34338, 1.45, 0.066666666666667, 0.22916666666667
34339, 1.4291666666667, 0.066666666666667, 0.25
34340, 1.45, 0.05, 0.25
34341, 1.45, 0.033333333333333, 0.22916666666667
34342, 1.4291666666667, 0.033333333333333, 0.25
34343, 1.45, 0.016666666666667, 0.25
34344, 1.4916666666667, 0.083333333333333, 0.25
34345, 1.4916666666667, 0.066666666666667, 0.22916666666667
34346, 1.4708333333333, 0.066666666666667, 0.25
34347, 1.4916666666667, 0.05, 0.25
34348, 1.4916666666667, 0.033333333333333, 0.22916666666667
34349, 1.4708333333333, 0.033333333333333, 0.25
34350, 1.4916666666667, 0.016666666666667, 0.25
34351, 1.5333333333333, 0.083333333333333, 0.25
34352, 1.5333333333333, 0.066666666666667, 0.22916666666667
34353, 1.5125, 0.066666666666667, 0.25
34354, 1.5333333333333, 0.05, 0.25
34355, 1.5333333333333, 0.033333333333333, 0.22916666666667
34356, 1.5125, 0.033333333333333, 0.25
34357, 1.5333333333333, 0.016666666666667, 0.25
34358, 1.575, 0.083333333333333, 0.25
34359, 1.575, 0.066666666666667, 0.22916666666667
34360, 1.5541666666667, 0.066666666666667, 0.25
34361, 1.575, 0.05, 0.25
34362, 1.575, 0.033333333333333, 0.22916666666667
34363, 1.5541666666667, 0.033333333333333, 0.25
34364, 1.575, 0.016666666666667, 0.25
34365, 1.6166666666667, 0.083333333333333, 0.25
34366, 1.6166666666667, 0.066666666666667, 0.22916666666667
34367, 1.5958333333333, 0.066666666666667, 0.25
34368, 1.6166666666667, 0.05, 0.25
34369, 1.6166666666667, 0.033333333333333, 0.22916666666667
34370, 1.5958333333333, 0.033333333333333, 0.25
34371, 1.6166666666667, 0.016666666666667, 0.25
34372, 1.6583333333333, 0.083333333333333, 0.25
34373, 1.6583333333333, 0.066666666666667, 0.22916666666667
34374, 1.6375, 0.066666666666667, 0.25
34375, 1.6583333333333, 0.05, 0.25
34376, 1.6583333333333, 0.033333333333333, 0.22916666666667
34377, 1.6375, 0.033333333333333, 0.25
34378, 1.6583333333333, 0.016666666666667, 0.25
34379, 1.7, 0.083333333333333, 0.25
34380, 1.7, 0.066666666666667, 0.22916666666667
34381, 1.6791666666667, 0.066666666666667, 0.25
34382, 1.7, 0.05, 0.25
34383, 1.7, 0.033333333333333, 0.22916666666667
34384, 1.6791666666667, 0.033333333333333, 0.25
34385, 1.7, 0.016666666666667, 0.25
34386, 1.7416666666667, 0.083333333333333, 0.25
34387, 1.7416666666667, 0.066666666666667, 0.22916666666667
34388, 1.7208333333333, 0.066666666666667, 0.25
34389, 1.7416666666667, 0.05, 0.25
34390, 1.7416666666667, 0.033333333333333, 0.22916666666667
34391, 1.7208333333333, 0.033333333333333, 0.25
34392, 1.7416666666667, 0.016666666666667, 0.25
34393, 1.7833333333333, 0.083333333333333, 0.25
34394, 1.7833333333333, 0.066666666666667, 0.22916666666667
34395, 1.7625, 0.066666666666667, 0.25
34396, 1.7833333333333, 0.05, 0.25
34397, 1.7833333333333, 0.033333333333333, 0.22916666666667
34398, 1.7625, 0.033333333333333, 0.25
34399, 1.7833333333333, 0.016666666666667, 0.25
34400, 1.825, 0.083333333333333, 0.25
34401, 1.825, 0.066666666666667, 0.22916666666667
34402, 1.8041666666667, 0.066666666666667, 0.25
34403, 1.825, 0.05, 0.25
34404, 1.825, 0.033333333333333, 0.22916666666667
34405, 1.8041666666667, 0.033333333333333, 0.25
34406, 1.825, 0.016666666666667, 0.25
34407, 1.8666666666667, 0.083333333333333, 0.25
34408, 1.8666666666667, 0.066666666666667, 0.22916666666667
34409, 1.8458333333333, 0.066666666666667, 0.25
34410, 1.8666666666667, 0.05, 0.25
34411, 1.8666666666667, 0.033333333333333, 0.22916666666667
34412, 1.8458333333333, 0.033333333333333, 0.25
34413, 1.8666666666667, 0.016666666666667, 0.25
34414, 1.9083333333333, 0.083333333333333, 0.25
34415, 1.9083333333333, 0.066666666666667, 0.22916666666667
34416, 1.8875, 0.066666666666667, 0.25
34417, 1.9083333333333, 0.05, 0.25
34418, 1.9083333333333, 0.033333333333333, 0.22916666666667
34419, 1.8875, 0.033333333333333, 0.25
34420, 1.9083333333333, 0.016666666666667, 0.25
34421, 1.95, 0.083333333333333, 0.25
34422, 1.95, 0.066666666666667, 0.22916666666667
34423, 1.9291666666667, 0.066666666666667, 0.25
34424, 1.95, 0.05, 0.25
34425, 1.95, 0.033333333333333, 0.22916666666667
34426, 1.9291666666667, 0.033333333333333, 0.25
34427, 1.95, 0.016666666666667, 0.25
34428, 1.9916666666667, 0.083333333333333, 0.25
34429, 1.9916666666667, 0.066666666666667, 0.22916666666667
34430, 1.9708333333333, 0.066666666666667, 0.25
34431, 1.9916666666667, 0.05, 0.25
34432, 1.9916666666667, 0.033333333333333, 0.22916666666667
34433, 1.9708333333333, 0.033333333333333, 0.25
34434, 1.9916666666667, 0.016666666666667, 0.25
34435, 2.0333333333333, 0.083333333333333, 0.25
34436, 2.0333333333333, 0.066666666666667, 0.22916666666667
34437, 2.0125, 0.066666666666667, 0.25
34438, 2.0333333333333, 0.05, 0.25
34439, 2.0333333333333, 0.033333333333333, 0.22916666666667
34440, 2.0125, 0.033333333333333, 0.25
34441, 2.0333333333333, 0.016666666666667, 0.25
34442, 2.075, 0.083333333333333, 0.25
34443, 2.075, 0.066666666666667, 0.22916666666667
34444, 2.0541666666667, 0.066666666666667, 0.25
34445, 2.075, 0.05, 0.25
34446, 2.075, 0.033333333333333, 0.22916666666667
34447, 2.0541666666667, 0.033333333333333, 0.25
34448, 2.075, 0.016666666666667, 0.25
34449, 2.1166666666667, 0.083333333333333, 0.25
34450, 2.1166666666667, 0.066666666666667, 0.22916666666667
34451, 2.0958333333333, 0.066666666666667, 0.25
34452, 2.1166666666667, 0.05, 0.25
34453, 2.1166666666667, 0.033333333333333, 0.22916666666667
34454, 2.0958333333333, 0.033333333333333, 0.25
34455, 2.1166666666667, 0.016666666666667, 0.25
34456, 2.1583333333333, 0.083333333333333, 0.25
34457, 2.1583333333333, 0.066666666666667, 0.22916666666667
34458, 2.1375, 0.066666666666667, 0.25
34459, 2.1583333333333, 0.05, 0.25
34460, 2.1583333333333, 0.033333333333333, 0.22916666666667
34461, 2.1375, 0.033333333333333, 0.25
34462, 2.1583333333333, 0.016666666666667, 0.25
34463, 2.1791666666667, 0.066666666666667, 0.25
34464, 2.1791666666667, 0.033333333333333, 0.25
34465, 1.2416666666667, 0.083333333333333, 0.29166666666667
34466, 1.2416666666667, 0.066666666666667, 0.27083333333333
34467, 1.2208333333333, 0.066666666666667, 0.29166666666667
34468, 1.2416666666667, 0.05, 0.29166666666667
34469, 1.2416666666667, 0.033333333333333, 0.27083333333333
34470, 1.2208333333333, 0.033333333333333, 0.29166666666667
34471, 1.2416666666667, 0.016666666666667, 0.29166666666667
34472, 1.2833333333333, 0.083333333333333, 0.29166666666667
34473, 1.2833333333333, 0.066666666666667, 0.27083333333333
34474, 1.2625, 0.066666666666667, 0.29166666666667
34475, 1.2833333333333, 0.05, 0.29166666666667
34476, 1.2833333333333, 0.033333333333333, 0.27083333333333
34477, 1.2625, 0.033333333333333, 0.29166666666667
34478, 1.2833333333333, 0.016666666666667, 0.29166666666667
34479, 1.325, 0.083333333333333, 0.29166666666667
34480, 1.325, 0.066666666666667, 0.27083333333333
34481, 1.3041666666667, 0.066666666666667, 0.29166666666667
34482, 1.325, 0.05, 0.29166666666667
34483, 1.325, 0.033333333333333, 0.27083333333333
34484, 1.3041666666667, 0.033333333333333, 0.29166666666667
34485, 1.325, 0.016666666666667, 0.29166666666667
34486, 1.3666666666667, 0.083333333333333, 0.29166666666667
34487, 1.3666666666667, 0.066666666666667, 0.27083333333333
34488, 1.3458333333333, 0.066666666666667, 0.29166666666667
34489, 1.3666666666667, 0.05, 0.29166666666667
34490, 1.3666666666667, 0.033333333333333, 0.27083333333333
34491, 1.3458333333333, 0.033333333333333, 0.29166666666667
34492, 1.3666666666667, 0.016666666666667, 0.29166666666667
34493, 1.4083333333333, 0.083333333333333, 0.29166666666667
34494, 1.4083333333333, 0.066666666666667, 0.27083333333333
34495, 1.3875, 0.066666666666667, 0.29166666666667
34496, 1.4083333333333, 0.05, 0.29166666666667
34497, 1.4083333333333, 0.033333333333333, 0.27083333333333
34498, 1.3875, 0.033333333333333, 0.29166666666667
34499, 1.4083333333333, 0.016666666666667, 0.29166666666667
34500, 1.45, 0.083333333333333, 0.29166666666667
34501, 1.45, 0.066666666666667, 0.27083333333333
34502, 1.4291666666667, 0.066666666666667, 0.29166666666667
34503, 1.45, 0.05, 0.29166666666667
34504, 1.45, 0.033333333333333, 0.27083333333333
34505, 1.4291666666667, 0.033333333333333, 0.29166666666667
34506, 1.45, 0.016666666666667, 0.29166666666667
34507, 1.4916666666667, 0.083333333333333, 0.29166666666667
34508, 1.4916666666667, 0.066666666666667, 0.27083333333333
34509, 1.4708333333333, 0.066666666666667, 0.29166666666667
34510, 1.4916666666667, 0.05, 0.29166666666667
34511, 1.4916666666667, 0.033333333333333, 0.27083333333333
34512, 1.4708333333333, 0.033333333333333, 0.29166666666667
34513, 1.4916666666667, 0.016666666666667, 0.29166666666667
34514, 1.5333333333333, 0.083333333333333, 0.29166666666667
34515, 1.5333333333333, 0.066666666666667, 0.27083333333333
34516, 1.5125, 0.066666666666667, 0.29166666666667
34517, 1.5333333333333, 0.05, 0.29166666666667
34518, 1.5333333333333, 0.033333333333333, 0.27083333333333
34519, 1.5125, 0.033333333333333, 0.29166666666667
34520, 1.5333333333333, 0.016666666666667, 0.29166666666667
34521, 1.575, 0.083333333333333, 0.29166666666667
34522, 1.575, 0.066666666666667, 0.27083333333333
34523, 1.5541666666667, 0.066666666666667, 0.29166666666667
34524, 1.575, 0.05, 0.29166666666667
34525, 1.575, 0.033333333333333, 0.27083333333333
34526, 1.5541666666667, 0.033333333333333, 0.29166666666667
34527, 1.575, 0.016666666666667, 0.29166666666667
34528, 1.6166666666667, 0.083333333333333, 0.29166666666667
34529, 1.6166666666667, 0.066666666666667, 0.27083333333333
34530, 1.5958333333333, 0.066666666666667, 0.29166666666667
34531, 1.6166666666667, 0.05, 0.29166666666667
34532, 1.6166666666667, 0.033333333333333, 0.27083333333333
34533, 1.5958333333333, 0.033333333333333, 0.29166666666667
34534, 1.6166666666667, 0.016666666666667, 0.29166666666667
34535, 1.6583333333333, 0.083333333333333, 0.29166666666667
34536, 1.6583333333333, 0.066666666666667, 0.27083333333333
34537, 1.6375, 0.066666666666667, 0.29166666666667
34538, 1.6583333333333, 0.05, 0.29166666666667
34539, 1.6583333333333, 0.033333333333333, 0.27083333333333
34540, 1.6375, 0.033333333333333, 0.29166666666667
34541, 1.6583333333333, 0.016666666666667, 0.29166666666667
34542, 1.7, 0.083333333333333, 0.29166666666667
34543, 1.7, 0.066666666666667, 0.27083333333333
34544, 1.6791666666667, 0.066666666666667, 0.29166666666667
34545, 1.7, 0.05, 0.29166666666667
34546, 1.7, 0.033333333333333, 0.27083333333333
34547, 1.6791666666667, 0.033333333333333, 0.29166666666667
34548, 1.7, 0.016666666666667, 0.29166666666667
34549, 1.7416666666667, 0.083333333333333, 0.29166666666667
34550, 1.7416666666667, 0.066666666666667, 0.27083333333333
34551, 1.7208333333333, 0.066666666666667, 0.29166666666667
34552, 1.7416666666667, 0.05, 0.29166666666667
34553, 1.7416666666667, 0.033333333333333, 0.27083333333333
34554, 1.7208333333333, 0.033333333333333, 0.29166666666667
34555, 1.7416666666667, 0.016666666666667, 0.29166666666667
34556, 1.7833333333333, 0.083333333333333, 0.29166666666667
34557, 1.7833333333333, 0.066666666666667, 0.27083333333333
34558, 1.7625, 0.066666666666667, 0.29166666666667
34559, 1.7833333333333, 0.05, 0.29166666666667
34560, 1.7833333333333, 0.033333333333333, 0.27083333333333
34561, 1.7625, 0.033333333333333, 0.29166666666667
34562, 1.7833333333333, 0.016666666666667, 0.29166666666667
34563, 1.825, 0.083333333333333, 0.29166666666667
34564, 1.825, 0.066666666666667, 0.27083333333333
34565, 1.8041666666667, 0.066666666666667, 0.29166666666667
34566, 1.825, 0.05, 0.29166666666667
34567, 1.825, 0.033333333333333, 0.27083333333333
34568, 1.8041666666667, 0.033333333333333, 0.29166666666667
34569, 1.825, 0.016666666666667, 0.29166666666667
34570, 1.8666666666667, 0.083333333333333, 0.29166666666667
34571, 1.8666666666667, 0.066666666666667, 0.27083333333333
34572, 1.8458333333333, 0.066666666666667, 0.29166666666667
34573, 1.8666666666667, 0.05, 0.29166666666667
34574, 1.8666666666667, 0.033333333333333, 0.27083333333333
34575, 1.8458333333333, 0.033333333333333, 0.29166666666667
34576, 1.8666666666667, 0.016666666666667, 0.29166666666667
34577, 1.9083333333333, 0.083333333333333, 0.29166666666667
34578, 1.9083333333333, 0.066666666666667, 0.27083333333333
34579, 1.8875, 0.066666666666667, 0.29166666666667
34580, 1.9083333333333, 0.05, 0.29166666666667
34581, 1.9083333333333, 0.033333333333333, 0.27083333333333
34582, 1.8875, 0.033333333333333, 0.29166666666667
34583, 1.9083333333333, 0.016666666666667, 0.29166666666667
34584, 1.95, 0.083333333333333, 0.29166666666667
34585, 1.95, 0.066666666666667, 0.27083333333333
34586, 1.9291666666667, 0.066666666666667, 0.29166666666667
34587, 1.95, 0.05, 0.29166666666667
34588, 1.95, 0.033333333333333, 0.27083333333333
34589, 1.9291666666667, 0.033333333333333, 0.29166666666667
34590, 1.95, 0.016666666666667, 0.29166666666667
34591, 1.9916666666667, 0.083333333333333, 0.29166666666667
34592, 1.9916666666667, 0.066666666666667, 0.27083333333333
34593, 1.9708333333333, 0.066666666666667, 0.29166666666667
34594, 1.9916666666667, 0.05, 0.29166666666667
34595, 1.9916666666667, 0.033333333333333, 0.27083333333333
34596, 1.9708333333333, 0.033333333333333, 0.29166666666667
34597, 1.9916666666667, 0.016666666666667, 0.29166666666667
34598, 2.0333333333333, 0.083333333333333, 0.29166666666667
34599, 2.0333333333333, 0.066666666666667, 0.27083333333333
34600, 2.0125, 0.066666666666667, 0.29166666666667
34601, 2.0333333333333, 0.05, 0.29166666666667
34602, 2.0333333333333, 0.033333333333333, 0.27083333333333
34603, 2.0125, 0.033333333333333, 0.29166666666667
34604, 2.0333333333333, 0.016666666666667, 0.29166666666667
34605, 2.075, 0.083333333333333, 0.29166666666667
34606, 2.075, 0.066666666666667, 0.27083333333333
34607, 2.0541666666667, 0.066666666666667, 0.29166666666667
34608, 2.075, 0.05, 0.29166666666667
34609, 2.075, 0.033333333333333, 0.27083333333333
34610, 2.0541666666667, 0.033333333333333, 0.29166666666667
34611, 2.075, 0.016666666666667, 0.29166666666667
34612, 2.1166666666667, 0.083333333333333, 0.29166666666667
34613, 2.1166666666667, 0.066666666666667, 0.27083333333333
34614, 2.0958333333333, 0.066666666666667, 0.29166666666667
34615, 2.1166666666667, 0.05, 0.29166666666667
34616, 2.1166666666667, 0.033333333333333, 0.27083333333333
34617, 2.0958333333333, 0.033333333333333, 0.29166666666667
34618, 2.1166666666667, 0.016666666666667, 0.29166666666667
34619, 2.1583333333333, 0.083333333333333, 0.29166666666667
34620, 2.1583333333333, 0.066666666666667, 0.27083333333333
34621, 2.1375, 0.066666666666667, 0.29166666666667
34622, 2.1583333333333, 0.05, 0.29166666666667
34623, 2.1583333333333, 0.033333333333333, 0.27083333333333
34624, 2.1375, 0.033333333333333, 0.29166666666667
34625, 2.1583333333333, 0.016666666666667, 0.29166666666667
34626, 2.1791666666667, 0.066666666666667, 0.29166666666667
34627, 2.1791666666667, 0.033333333333333, 0.29166666666667
34628, 1.2416666666667, 0.083333333333333, 0.33333333333333
34629, 1.2416666666667, 0.066666666666667, 0.3125
34630, 1.2208333333333, 0.066666666666667, 0.33333333333333
34631, 1.2416666666667, 0.05, 0.33333333333333
34632, 1.2416666666667, 0.033333333333333, 0.3125
34633, 1.2208333333333, 0.033333333333333, 0.33333333333333
34634, 1.2416666666667, 0.016666666666667, 0.33333333333333
34635, 1.2833333333333, 0.083333333333333, 0.33333333333333
34636, 1.2833333333333, 0.066666666666667, 0.3125
34637, 1.2625, 0.066666666666667, 0.33333333333333
34638, 1.2833333333333, 0.05, 0.33333333333333
34639, 1.2833333333333, 0.033333333333333, 0.3125
34640, 1.2625, 0.033333333333333, 0.33333333333333
34641, 1.2833333333333, 0.016666666666667, 0.33333333333333
34642, 1.325, 0.083333333333333, 0.33333333333333
34643, 1.325, 0.066666666666667, 0.3125
34644, 1.3041666666667, 0.066666666666667, 0.33333333333333
34645, 1.325, 0.05, 0.33333333333333
34646, 1.325, 0.033333333333333, 0.3125
34647, 1.3041666666667, 0.033333333333333, 0.33333333333333
34648, 1.325, 0.016666666666667, 0.33333333333333
34649, 1.3666666666667, 0.083333333333333, 0.33333333333333
34650, 1.3666666666667, 0.066666666666667, 0.3125
34651, 1.3458333333333, 0.066666666666667, 0.33333333333333
34652, 1.3666666666667, 0.05, 0.33333333333333
34653, 1.3666666666667, 0.033333333333333, 0.3125
34654, 1.3458333333333, 0.033333333333333, 0.33333333333333
34655, 1.3666666666667, 0.016666666666667, 0.33333333333333
34656, 1.4083333333333, 0.083333333333333, 0.33333333333333
34657, 1.4083333333333, 0.066666666666667, 0.3125
34658, 1.3875, 0.066666666666667, 0.33333333333333
34659, 1.4083333333333, 0.05, 0.33333333333333
