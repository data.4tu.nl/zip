25848, 1986, 15841, 36963, 15299, 1987, 15842, 36964, 15300, 15887, 37978, 37979, 15392, 15889, 37981, 37982, 
15394, 1991, 15888, 37980, 15395
25849, 1987, 15842, 36964, 15300, 1988, 15843, 36965, 15301, 15889, 37981, 37982, 15394, 15891, 37984, 37985, 
15396, 1992, 15890, 37983, 15397
25850, 1988, 15843, 36965, 15301, 78, 2059, 15987, 1994, 15891, 37984, 37985, 15396, 0, 0, 0, 
0, 1993, 15892, 37986, 15398
25851, 603, 604, 5510, 5509, 15840, 15844, 36966, 36962, 0, 0, 0, 0, 15894, 37988, 37989, 
37975, 15884, 15893, 37987, 37974
25852, 15840, 15844, 36966, 36962, 15841, 15845, 36967, 36963, 15894, 37988, 37989, 37975, 15896, 37991, 37992, 
37978, 15886, 15895, 37990, 37977
25853, 15841, 15845, 36967, 36963, 15842, 15846, 36968, 36964, 15896, 37991, 37992, 37978, 15898, 37994, 37995, 
37981, 15888, 15897, 37993, 37980
25854, 15842, 15846, 36968, 36964, 15843, 15847, 36969, 36965, 15898, 37994, 37995, 37981, 15900, 37997, 37998, 
37984, 15890, 15899, 37996, 37983
25855, 15843, 15847, 36969, 36965, 2059, 2060, 15988, 15987, 15900, 37997, 37998, 37984, 0, 0, 0, 
0, 15892, 15901, 37999, 37986
25856, 604, 605, 5511, 5510, 15844, 15848, 36970, 36966, 0, 0, 0, 0, 15903, 38001, 38002, 
37988, 15893, 15902, 38000, 37987
25857, 15844, 15848, 36970, 36966, 15845, 15849, 36971, 36967, 15903, 38001, 38002, 37988, 15905, 38004, 38005, 
37991, 15895, 15904, 38003, 37990
25858, 15845, 15849, 36971, 36967, 15846, 15850, 36972, 36968, 15905, 38004, 38005, 37991, 15907, 38007, 38008, 
37994, 15897, 15906, 38006, 37993
25859, 15846, 15850, 36972, 36968, 15847, 15851, 36973, 36969, 15907, 38007, 38008, 37994, 15909, 38010, 38011, 
37997, 15899, 15908, 38009, 37996
25860, 15847, 15851, 36973, 36969, 2060, 2061, 15989, 15988, 15909, 38010, 38011, 37997, 0, 0, 0, 
0, 15901, 15910, 38012, 37999
25861, 605, 606, 5512, 5511, 15848, 15852, 36974, 36970, 0, 0, 0, 0, 15912, 38014, 38015, 
38001, 15902, 15911, 38013, 38000
25862, 15848, 15852, 36974, 36970, 15849, 15853, 36975, 36971, 15912, 38014, 38015, 38001, 15914, 38017, 38018, 
38004, 15904, 15913, 38016, 38003
25863, 15849, 15853, 36975, 36971, 15850, 15854, 36976, 36972, 15914, 38017, 38018, 38004, 15916, 38020, 38021, 
38007, 15906, 15915, 38019, 38006
25864, 15850, 15854, 36976, 36972, 15851, 15855, 36977, 36973, 15916, 38020, 38021, 38007, 15918, 38023, 38024, 
38010, 15908, 15917, 38022, 38009
25865, 15851, 15855, 36977, 36973, 2061, 2062, 15990, 15989, 15918, 38023, 38024, 38010, 0, 0, 0, 
0, 15910, 15919, 38025, 38012
25866, 606, 607, 5513, 5512, 15852, 15856, 36978, 36974, 0, 0, 0, 0, 15921, 38027, 38028, 
38014, 15911, 15920, 38026, 38013
25867, 15852, 15856, 36978, 36974, 15853, 15857, 36979, 36975, 15921, 38027, 38028, 38014, 15923, 38030, 38031, 
38017, 15913, 15922, 38029, 38016
25868, 15853, 15857, 36979, 36975, 15854, 15858, 36980, 36976, 15923, 38030, 38031, 38017, 15925, 38033, 38034, 
38020, 15915, 15924, 38032, 38019
25869, 15854, 15858, 36980, 36976, 15855, 15859, 36981, 36977, 15925, 38033, 38034, 38020, 15927, 38036, 38037, 
38023, 15917, 15926, 38035, 38022
25870, 15855, 15859, 36981, 36977, 2062, 2063, 15991, 15990, 15927, 38036, 38037, 38023, 0, 0, 0, 
0, 15919, 15928, 38038, 38025
25871, 607, 608, 5514, 5513, 15856, 15860, 36982, 36978, 0, 0, 0, 0, 15930, 38040, 38041, 
38027, 15920, 15929, 38039, 38026
25872, 15856, 15860, 36982, 36978, 15857, 15861, 36983, 36979, 15930, 38040, 38041, 38027, 15932, 38043, 38044, 
38030, 15922, 15931, 38042, 38029
25873, 15857, 15861, 36983, 36979, 15858, 15862, 36984, 36980, 15932, 38043, 38044, 38030, 15934, 38046, 38047, 
38033, 15924, 15933, 38045, 38032
25874, 15858, 15862, 36984, 36980, 15859, 15863, 36985, 36981, 15934, 38046, 38047, 38033, 15936, 38049, 38050, 
38036, 15926, 15935, 38048, 38035
25875, 15859, 15863, 36985, 36981, 2063, 2064, 15992, 15991, 15936, 38049, 38050, 38036, 0, 0, 0, 
0, 15928, 15937, 38051, 38038
25876, 608, 609, 5515, 5514, 15860, 15864, 36986, 36982, 0, 0, 0, 0, 15939, 38053, 38054, 
38040, 15929, 15938, 38052, 38039
25877, 15860, 15864, 36986, 36982, 15861, 15865, 36987, 36983, 15939, 38053, 38054, 38040, 15941, 38056, 38057, 
38043, 15931, 15940, 38055, 38042
25878, 15861, 15865, 36987, 36983, 15862, 15866, 36988, 36984, 15941, 38056, 38057, 38043, 15943, 38059, 38060, 
38046, 15933, 15942, 38058, 38045
25879, 15862, 15866, 36988, 36984, 15863, 15867, 36989, 36985, 15943, 38059, 38060, 38046, 15945, 38062, 38063, 
38049, 15935, 15944, 38061, 38048
25880, 15863, 15867, 36989, 36985, 2064, 2065, 15993, 15992, 15945, 38062, 38063, 38049, 0, 0, 0, 
0, 15937, 15946, 38064, 38051
25881, 609, 610, 5516, 5515, 15864, 15868, 36990, 36986, 0, 0, 0, 0, 15948, 38066, 38067, 
38053, 15938, 15947, 38065, 38052
25882, 15864, 15868, 36990, 36986, 15865, 15869, 36991, 36987, 15948, 38066, 38067, 38053, 15950, 38069, 38070, 
38056, 15940, 15949, 38068, 38055
25883, 15865, 15869, 36991, 36987, 15866, 15870, 36992, 36988, 15950, 38069, 38070, 38056, 15952, 38072, 38073, 
38059, 15942, 15951, 38071, 38058
25884, 15866, 15870, 36992, 36988, 15867, 15871, 36993, 36989, 15952, 38072, 38073, 38059, 15954, 38075, 38076, 
38062, 15944, 15953, 38074, 38061
25885, 15867, 15871, 36993, 36989, 2065, 2066, 15994, 15993, 15954, 38075, 38076, 38062, 0, 0, 0, 
0, 15946, 15955, 38077, 38064
25886, 610, 611, 5517, 5516, 15868, 15872, 36994, 36990, 0, 0, 0, 0, 15957, 38079, 38080, 
38066, 15947, 15956, 38078, 38065
25887, 15868, 15872, 36994, 36990, 15869, 15873, 36995, 36991, 15957, 38079, 38080, 38066, 15959, 38082, 38083, 
38069, 15949, 15958, 38081, 38068
25888, 15869, 15873, 36995, 36991, 15870, 15874, 36996, 36992, 15959, 38082, 38083, 38069, 15961, 38085, 38086, 
38072, 15951, 15960, 38084, 38071
25889, 15870, 15874, 36996, 36992, 15871, 15875, 36997, 36993, 15961, 38085, 38086, 38072, 15963, 38088, 38089, 
38075, 15953, 15962, 38087, 38074
25890, 15871, 15875, 36997, 36993, 2066, 2067, 15995, 15994, 15963, 38088, 38089, 38075, 0, 0, 0, 
0, 15955, 15964, 38090, 38077
25891, 611, 612, 5518, 5517, 15872, 15876, 36998, 36994, 0, 0, 0, 0, 15966, 38092, 38093, 
38079, 15956, 15965, 38091, 38078
25892, 15872, 15876, 36998, 36994, 15873, 15877, 36999, 36995, 15966, 38092, 38093, 38079, 15968, 38095, 38096, 
38082, 15958, 15967, 38094, 38081
25893, 15873, 15877, 36999, 36995, 15874, 15878, 37000, 36996, 15968, 38095, 38096, 38082, 15970, 38098, 38099, 
38085, 15960, 15969, 38097, 38084
25894, 15874, 15878, 37000, 36996, 15875, 15879, 37001, 36997, 15970, 38098, 38099, 38085, 15972, 38101, 38102, 
38088, 15962, 15971, 38100, 38087
25895, 15875, 15879, 37001, 36997, 2067, 2068, 15996, 15995, 15972, 38101, 38102, 38088, 0, 0, 0, 
0, 15964, 15973, 38103, 38090
25896, 612, 613, 5519, 5518, 15876, 15880, 37002, 36998, 0, 0, 0, 0, 15975, 38105, 38106, 
38092, 15965, 15974, 38104, 38091
25897, 15876, 15880, 37002, 36998, 15877, 15881, 37003, 36999, 15975, 38105, 38106, 38092, 15977, 38108, 38109, 
38095, 15967, 15976, 38107, 38094
25898, 15877, 15881, 37003, 36999, 15878, 15882, 37004, 37000, 15977, 38108, 38109, 38095, 15979, 38111, 38112, 
38098, 15969, 15978, 38110, 38097
25899, 15878, 15882, 37004, 37000, 15879, 15883, 37005, 37001, 15979, 38111, 38112, 38098, 15981, 38114, 38115, 
38101, 15971, 15980, 38113, 38100
25900, 15879, 15883, 37005, 37001, 2068, 2069, 15997, 15996, 15981, 38114, 38115, 38101, 0, 0, 0, 
0, 15973, 15982, 38116, 38103
25901, 613, 24, 580, 5519, 15880, 2032, 15748, 37002, 0, 0, 0, 0, 15983, 0, 38117, 
38105, 15974, 0, 0, 38104
25902, 15880, 2032, 15748, 37002, 15881, 2033, 15749, 37003, 15983, 0, 38117, 38105, 15984, 0, 38118, 
38108, 15976, 0, 0, 38107
25903, 15881, 2033, 15749, 37003, 15882, 2034, 15750, 37004, 15984, 0, 38118, 38108, 15985, 0, 38119, 
38111, 15978, 0, 0, 38110
25904, 15882, 2034, 15750, 37004, 15883, 2035, 15751, 37005, 15985, 0, 38119, 38111, 15986, 0, 38120, 
38114, 15980, 0, 0, 38113
25905, 15883, 2035, 15751, 37005, 2069, 80, 2036, 15997, 15986, 0, 38120, 38114, 0, 0, 0, 
0, 15982, 0, 0, 38116
25906, 542, 5509, 5520, 543, 15298, 36962, 37006, 15302, 0, 0, 0, 0, 37976, 38122, 38123, 
15399, 15391, 37974, 38121, 15400
25907, 15298, 36962, 37006, 15302, 15299, 36963, 37007, 15303, 37976, 38122, 38123, 15399, 37979, 38125, 38126, 
15401, 15393, 37977, 38124, 15402
25908, 15299, 36963, 37007, 15303, 15300, 36964, 37008, 15304, 37979, 38125, 38126, 15401, 37982, 38128, 38129, 
15403, 15395, 37980, 38127, 15404
25909, 15300, 36964, 37008, 15304, 15301, 36965, 37009, 15305, 37982, 38128, 38129, 15403, 37985, 38131, 38132, 
15405, 15397, 37983, 38130, 15406
25910, 15301, 36965, 37009, 15305, 1994, 15987, 15998, 1995, 37985, 38131, 38132, 15405, 0, 0, 0, 
0, 15398, 37986, 38133, 15407
25911, 5509, 5510, 5521, 5520, 36962, 36966, 37010, 37006, 0, 0, 0, 0, 37989, 38135, 38136, 
38122, 37974, 37987, 38134, 38121
25912, 36962, 36966, 37010, 37006, 36963, 36967, 37011, 37007, 37989, 38135, 38136, 38122, 37992, 38138, 38139, 
38125, 37977, 37990, 38137, 38124
25913, 36963, 36967, 37011, 37007, 36964, 36968, 37012, 37008, 37992, 38138, 38139, 38125, 37995, 38141, 38142, 
38128, 37980, 37993, 38140, 38127
25914, 36964, 36968, 37012, 37008, 36965, 36969, 37013, 37009, 37995, 38141, 38142, 38128, 37998, 38144, 38145, 
38131, 37983, 37996, 38143, 38130
25915, 36965, 36969, 37013, 37009, 15987, 15988, 15999, 15998, 37998, 38144, 38145, 38131, 0, 0, 0, 
0, 37986, 37999, 38146, 38133
25916, 5510, 5511, 5522, 5521, 36966, 36970, 37014, 37010, 0, 0, 0, 0, 38002, 38148, 38149, 
38135, 37987, 38000, 38147, 38134
25917, 36966, 36970, 37014, 37010, 36967, 36971, 37015, 37011, 38002, 38148, 38149, 38135, 38005, 38151, 38152, 
38138, 37990, 38003, 38150, 38137
25918, 36967, 36971, 37015, 37011, 36968, 36972, 37016, 37012, 38005, 38151, 38152, 38138, 38008, 38154, 38155, 
38141, 37993, 38006, 38153, 38140
25919, 36968, 36972, 37016, 37012, 36969, 36973, 37017, 37013, 38008, 38154, 38155, 38141, 38011, 38157, 38158, 
38144, 37996, 38009, 38156, 38143
25920, 36969, 36973, 37017, 37013, 15988, 15989, 16000, 15999, 38011, 38157, 38158, 38144, 0, 0, 0, 
0, 37999, 38012, 38159, 38146
25921, 5511, 5512, 5523, 5522, 36970, 36974, 37018, 37014, 0, 0, 0, 0, 38015, 38161, 38162, 
38148, 38000, 38013, 38160, 38147
25922, 36970, 36974, 37018, 37014, 36971, 36975, 37019, 37015, 38015, 38161, 38162, 38148, 38018, 38164, 38165, 
38151, 38003, 38016, 38163, 38150
25923, 36971, 36975, 37019, 37015, 36972, 36976, 37020, 37016, 38018, 38164, 38165, 38151, 38021, 38167, 38168, 
38154, 38006, 38019, 38166, 38153
25924, 36972, 36976, 37020, 37016, 36973, 36977, 37021, 37017, 38021, 38167, 38168, 38154, 38024, 38170, 38171, 
38157, 38009, 38022, 38169, 38156
25925, 36973, 36977, 37021, 37017, 15989, 15990, 16001, 16000, 38024, 38170, 38171, 38157, 0, 0, 0, 
0, 38012, 38025, 38172, 38159
25926, 5512, 5513, 5524, 5523, 36974, 36978, 37022, 37018, 0, 0, 0, 0, 38028, 38174, 38175, 
38161, 38013, 38026, 38173, 38160
25927, 36974, 36978, 37022, 37018, 36975, 36979, 37023, 37019, 38028, 38174, 38175, 38161, 38031, 38177, 38178, 
38164, 38016, 38029, 38176, 38163
25928, 36975, 36979, 37023, 37019, 36976, 36980, 37024, 37020, 38031, 38177, 38178, 38164, 38034, 38180, 38181, 
38167, 38019, 38032, 38179, 38166
25929, 36976, 36980, 37024, 37020, 36977, 36981, 37025, 37021, 38034, 38180, 38181, 38167, 38037, 38183, 38184, 
38170, 38022, 38035, 38182, 38169
25930, 36977, 36981, 37025, 37021, 15990, 15991, 16002, 16001, 38037, 38183, 38184, 38170, 0, 0, 0, 
0, 38025, 38038, 38185, 38172
25931, 5513, 5514, 5525, 5524, 36978, 36982, 37026, 37022, 0, 0, 0, 0, 38041, 38187, 38188, 
38174, 38026, 38039, 38186, 38173
25932, 36978, 36982, 37026, 37022, 36979, 36983, 37027, 37023, 38041, 38187, 38188, 38174, 38044, 38190, 38191, 
38177, 38029, 38042, 38189, 38176
25933, 36979, 36983, 37027, 37023, 36980, 36984, 37028, 37024, 38044, 38190, 38191, 38177, 38047, 38193, 38194, 
38180, 38032, 38045, 38192, 38179
25934, 36980, 36984, 37028, 37024, 36981, 36985, 37029, 37025, 38047, 38193, 38194, 38180, 38050, 38196, 38197, 
38183, 38035, 38048, 38195, 38182
25935, 36981, 36985, 37029, 37025, 15991, 15992, 16003, 16002, 38050, 38196, 38197, 38183, 0, 0, 0, 
0, 38038, 38051, 38198, 38185
25936, 5514, 5515, 5526, 5525, 36982, 36986, 37030, 37026, 0, 0, 0, 0, 38054, 38200, 38201, 
38187, 38039, 38052, 38199, 38186
25937, 36982, 36986, 37030, 37026, 36983, 36987, 37031, 37027, 38054, 38200, 38201, 38187, 38057, 38203, 38204, 
38190, 38042, 38055, 38202, 38189
25938, 36983, 36987, 37031, 37027, 36984, 36988, 37032, 37028, 38057, 38203, 38204, 38190, 38060, 38206, 38207, 
38193, 38045, 38058, 38205, 38192
25939, 36984, 36988, 37032, 37028, 36985, 36989, 37033, 37029, 38060, 38206, 38207, 38193, 38063, 38209, 38210, 
38196, 38048, 38061, 38208, 38195
25940, 36985, 36989, 37033, 37029, 15992, 15993, 16004, 16003, 38063, 38209, 38210, 38196, 0, 0, 0, 
0, 38051, 38064, 38211, 38198
25941, 5515, 5516, 5527, 5526, 36986, 36990, 37034, 37030, 0, 0, 0, 0, 38067, 38213, 38214, 
38200, 38052, 38065, 38212, 38199
25942, 36986, 36990, 37034, 37030, 36987, 36991, 37035, 37031, 38067, 38213, 38214, 38200, 38070, 38216, 38217, 
38203, 38055, 38068, 38215, 38202
25943, 36987, 36991, 37035, 37031, 36988, 36992, 37036, 37032, 38070, 38216, 38217, 38203, 38073, 38219, 38220, 
38206, 38058, 38071, 38218, 38205
25944, 36988, 36992, 37036, 37032, 36989, 36993, 37037, 37033, 38073, 38219, 38220, 38206, 38076, 38222, 38223, 
38209, 38061, 38074, 38221, 38208
25945, 36989, 36993, 37037, 37033, 15993, 15994, 16005, 16004, 38076, 38222, 38223, 38209, 0, 0, 0, 
0, 38064, 38077, 38224, 38211
25946, 5516, 5517, 5528, 5527, 36990, 36994, 37038, 37034, 0, 0, 0, 0, 38080, 38226, 38227, 
38213, 38065, 38078, 38225, 38212
25947, 36990, 36994, 37038, 37034, 36991, 36995, 37039, 37035, 38080, 38226, 38227, 38213, 38083, 38229, 38230, 
38216, 38068, 38081, 38228, 38215
25948, 36991, 36995, 37039, 37035, 36992, 36996, 37040, 37036, 38083, 38229, 38230, 38216, 38086, 38232, 38233, 
38219, 38071, 38084, 38231, 38218
25949, 36992, 36996, 37040, 37036, 36993, 36997, 37041, 37037, 38086, 38232, 38233, 38219, 38089, 38235, 38236, 
38222, 38074, 38087, 38234, 38221
25950, 36993, 36997, 37041, 37037, 15994, 15995, 16006, 16005, 38089, 38235, 38236, 38222, 0, 0, 0, 
0, 38077, 38090, 38237, 38224
25951, 5517, 5518, 5529, 5528, 36994, 36998, 37042, 37038, 0, 0, 0, 0, 38093, 38239, 38240, 
38226, 38078, 38091, 38238, 38225
25952, 36994, 36998, 37042, 37038, 36995, 36999, 37043, 37039, 38093, 38239, 38240, 38226, 38096, 38242, 38243, 
38229, 38081, 38094, 38241, 38228
25953, 36995, 36999, 37043, 37039, 36996, 37000, 37044, 37040, 38096, 38242, 38243, 38229, 38099, 38245, 38246, 
38232, 38084, 38097, 38244, 38231
25954, 36996, 37000, 37044, 37040, 36997, 37001, 37045, 37041, 38099, 38245, 38246, 38232, 38102, 38248, 38249, 
38235, 38087, 38100, 38247, 38234
25955, 36997, 37001, 37045, 37041, 15995, 15996, 16007, 16006, 38102, 38248, 38249, 38235, 0, 0, 0, 
0, 38090, 38103, 38250, 38237
25956, 5518, 5519, 5530, 5529, 36998, 37002, 37046, 37042, 0, 0, 0, 0, 38106, 38252, 38253, 
38239, 38091, 38104, 38251, 38238
25957, 36998, 37002, 37046, 37042, 36999, 37003, 37047, 37043, 38106, 38252, 38253, 38239, 38109, 38255, 38256, 
38242, 38094, 38107, 38254, 38241
25958, 36999, 37003, 37047, 37043, 37000, 37004, 37048, 37044, 38109, 38255, 38256, 38242, 38112, 38258, 38259, 
38245, 38097, 38110, 38257, 38244
25959, 37000, 37004, 37048, 37044, 37001, 37005, 37049, 37045, 38112, 38258, 38259, 38245, 38115, 38261, 38262, 
38248, 38100, 38113, 38260, 38247
25960, 37001, 37005, 37049, 37045, 15996, 15997, 16008, 16007, 38115, 38261, 38262, 38248, 0, 0, 0, 
0, 38103, 38116, 38263, 38250
25961, 5519, 580, 581, 5530, 37002, 15748, 15752, 37046, 0, 0, 0, 0, 38117, 0, 38264, 
38252, 38104, 0, 0, 38251
25962, 37002, 15748, 15752, 37046, 37003, 15749, 15753, 37047, 38117, 0, 38264, 38252, 38118, 0, 38265, 
38255, 38107, 0, 0, 38254
25963, 37003, 15749, 15753, 37047, 37004, 15750, 15754, 37048, 38118, 0, 38265, 38255, 38119, 0, 38266, 
38258, 38110, 0, 0, 38257
25964, 37004, 15750, 15754, 37048, 37005, 15751, 15755, 37049, 38119, 0, 38266, 38258, 38120, 0, 38267, 
38261, 38113, 0, 0, 38260
25965, 37005, 15751, 15755, 37049, 15997, 2036, 2037, 16008, 38120, 0, 38267, 38261, 0, 0, 0, 
0, 38116, 0, 0, 38263
25966, 543, 5520, 5531, 544, 15302, 37006, 37050, 15306, 0, 0, 0, 0, 38123, 38269, 38270, 
15408, 15400, 38121, 38268, 15409
25967, 15302, 37006, 37050, 15306, 15303, 37007, 37051, 15307, 38123, 38269, 38270, 15408, 38126, 38272, 38273, 
15410, 15402, 38124, 38271, 15411
25968, 15303, 37007, 37051, 15307, 15304, 37008, 37052, 15308, 38126, 38272, 38273, 15410, 38129, 38275, 38276, 
15412, 15404, 38127, 38274, 15413
25969, 15304, 37008, 37052, 15308, 15305, 37009, 37053, 15309, 38129, 38275, 38276, 15412, 38132, 38278, 38279, 
15414, 15406, 38130, 38277, 15415
25970, 15305, 37009, 37053, 15309, 1995, 15998, 16009, 1996, 38132, 38278, 38279, 15414, 0, 0, 0, 
0, 15407, 38133, 38280, 15416
25971, 5520, 5521, 5532, 5531, 37006, 37010, 37054, 37050, 0, 0, 0, 0, 38136, 38282, 38283, 
38269, 38121, 38134, 38281, 38268
25972, 37006, 37010, 37054, 37050, 37007, 37011, 37055, 37051, 38136, 38282, 38283, 38269, 38139, 38285, 38286, 
38272, 38124, 38137, 38284, 38271
25973, 37007, 37011, 37055, 37051, 37008, 37012, 37056, 37052, 38139, 38285, 38286, 38272, 38142, 38288, 38289, 
38275, 38127, 38140, 38287, 38274
25974, 37008, 37012, 37056, 37052, 37009, 37013, 37057, 37053, 38142, 38288, 38289, 38275, 38145, 38291, 38292, 
38278, 38130, 38143, 38290, 38277
25975, 37009, 37013, 37057, 37053, 15998, 15999, 16010, 16009, 38145, 38291, 38292, 38278, 0, 0, 0, 
0, 38133, 38146, 38293, 38280
25976, 5521, 5522, 5533, 5532, 37010, 37014, 37058, 37054, 0, 0, 0, 0, 38149, 38295, 38296, 
38282, 38134, 38147, 38294, 38281
25977, 37010, 37014, 37058, 37054, 37011, 37015, 37059, 37055, 38149, 38295, 38296, 38282, 38152, 38298, 38299, 
38285, 38137, 38150, 38297, 38284
25978, 37011, 37015, 37059, 37055, 37012, 37016, 37060, 37056, 38152, 38298, 38299, 38285, 38155, 38301, 38302, 
38288, 38140, 38153, 38300, 38287
25979, 37012, 37016, 37060, 37056, 37013, 37017, 37061, 37057, 38155, 38301, 38302, 38288, 38158, 38304, 38305, 
38291, 38143, 38156, 38303, 38290
25980, 37013, 37017, 37061, 37057, 15999, 16000, 16011, 16010, 38158, 38304, 38305, 38291, 0, 0, 0, 
0, 38146, 38159, 38306, 38293
25981, 5522, 5523, 5534, 5533, 37014, 37018, 37062, 37058, 0, 0, 0, 0, 38162, 38308, 38309, 
38295, 38147, 38160, 38307, 38294
25982, 37014, 37018, 37062, 37058, 37015, 37019, 37063, 37059, 38162, 38308, 38309, 38295, 38165, 38311, 38312, 
38298, 38150, 38163, 38310, 38297
25983, 37015, 37019, 37063, 37059, 37016, 37020, 37064, 37060, 38165, 38311, 38312, 38298, 38168, 38314, 38315, 
38301, 38153, 38166, 38313, 38300
25984, 37016, 37020, 37064, 37060, 37017, 37021, 37065, 37061, 38168, 38314, 38315, 38301, 38171, 38317, 38318, 
38304, 38156, 38169, 38316, 38303
25985, 37017, 37021, 37065, 37061, 16000, 16001, 16012, 16011, 38171, 38317, 38318, 38304, 0, 0, 0, 
0, 38159, 38172, 38319, 38306
25986, 5523, 5524, 5535, 5534, 37018, 37022, 37066, 37062, 0, 0, 0, 0, 38175, 38321, 38322, 
38308, 38160, 38173, 38320, 38307
25987, 37018, 37022, 37066, 37062, 37019, 37023, 37067, 37063, 38175, 38321, 38322, 38308, 38178, 38324, 38325, 
38311, 38163, 38176, 38323, 38310
25988, 37019, 37023, 37067, 37063, 37020, 37024, 37068, 37064, 38178, 38324, 38325, 38311, 38181, 38327, 38328, 
38314, 38166, 38179, 38326, 38313
25989, 37020, 37024, 37068, 37064, 37021, 37025, 37069, 37065, 38181, 38327, 38328, 38314, 38184, 38330, 38331, 
38317, 38169, 38182, 38329, 38316
25990, 37021, 37025, 37069, 37065, 16001, 16002, 16013, 16012, 38184, 38330, 38331, 38317, 0, 0, 0, 
0, 38172, 38185, 38332, 38319
25991, 5524, 5525, 5536, 5535, 37022, 37026, 37070, 37066, 0, 0, 0, 0, 38188, 38334, 38335, 
38321, 38173, 38186, 38333, 38320
25992, 37022, 37026, 37070, 37066, 37023, 37027, 37071, 37067, 38188, 38334, 38335, 38321, 38191, 38337, 38338, 
38324, 38176, 38189, 38336, 38323
25993, 37023, 37027, 37071, 37067, 37024, 37028, 37072, 37068, 38191, 38337, 38338, 38324, 38194, 38340, 38341, 
38327, 38179, 38192, 38339, 38326
25994, 37024, 37028, 37072, 37068, 37025, 37029, 37073, 37069, 38194, 38340, 38341, 38327, 38197, 38343, 38344, 
38330, 38182, 38195, 38342, 38329
25995, 37025, 37029, 37073, 37069, 16002, 16003, 16014, 16013, 38197, 38343, 38344, 38330, 0, 0, 0, 
0, 38185, 38198, 38345, 38332
25996, 5525, 5526, 5537, 5536, 37026, 37030, 37074, 37070, 0, 0, 0, 0, 38201, 38347, 38348, 
38334, 38186, 38199, 38346, 38333
25997, 37026, 37030, 37074, 37070, 37027, 37031, 37075, 37071, 38201, 38347, 38348, 38334, 38204, 38350, 38351, 
38337, 38189, 38202, 38349, 38336
25998, 37027, 37031, 37075, 37071, 37028, 37032, 37076, 37072, 38204, 38350, 38351, 38337, 38207, 38353, 38354, 
38340, 38192, 38205, 38352, 38339
25999, 37028, 37032, 37076, 37072, 37029, 37033, 37077, 37073, 38207, 38353, 38354, 38340, 38210, 38356, 38357, 
38343, 38195, 38208, 38355, 38342
26000, 37029, 37033, 37077, 37073, 16003, 16004, 16015, 16014, 38210, 38356, 38357, 38343, 0, 0, 0, 
0, 38198, 38211, 38358, 38345
26001, 5526, 5527, 5538, 5537, 37030, 37034, 37078, 37074, 0, 0, 0, 0, 38214, 38360, 38361, 
38347, 38199, 38212, 38359, 38346
26002, 37030, 37034, 37078, 37074, 37031, 37035, 37079, 37075, 38214, 38360, 38361, 38347, 38217, 38363, 38364, 
38350, 38202, 38215, 38362, 38349
26003, 37031, 37035, 37079, 37075, 37032, 37036, 37080, 37076, 38217, 38363, 38364, 38350, 38220, 38366, 38367, 
38353, 38205, 38218, 38365, 38352
26004, 37032, 37036, 37080, 37076, 37033, 37037, 37081, 37077, 38220, 38366, 38367, 38353, 38223, 38369, 38370, 
38356, 38208, 38221, 38368, 38355
26005, 37033, 37037, 37081, 37077, 16004, 16005, 16016, 16015, 38223, 38369, 38370, 38356, 0, 0, 0, 
0, 38211, 38224, 38371, 38358
26006, 5527, 5528, 5539, 5538, 37034, 37038, 37082, 37078, 0, 0, 0, 0, 38227, 38373, 38374, 
38360, 38212, 38225, 38372, 38359
26007, 37034, 37038, 37082, 37078, 37035, 37039, 37083, 37079, 38227, 38373, 38374, 38360, 38230, 38376, 38377, 
38363, 38215, 38228, 38375, 38362
26008, 37035, 37039, 37083, 37079, 37036, 37040, 37084, 37080, 38230, 38376, 38377, 38363, 38233, 38379, 38380, 
38366, 38218, 38231, 38378, 38365
26009, 37036, 37040, 37084, 37080, 37037, 37041, 37085, 37081, 38233, 38379, 38380, 38366, 38236, 38382, 38383, 
38369, 38221, 38234, 38381, 38368
26010, 37037, 37041, 37085, 37081, 16005, 16006, 16017, 16016, 38236, 38382, 38383, 38369, 0, 0, 0, 
0, 38224, 38237, 38384, 38371
26011, 5528, 5529, 5540, 5539, 37038, 37042, 37086, 37082, 0, 0, 0, 0, 38240, 38386, 38387, 
38373, 38225, 38238, 38385, 38372
26012, 37038, 37042, 37086, 37082, 37039, 37043, 37087, 37083, 38240, 38386, 38387, 38373, 38243, 38389, 38390, 
38376, 38228, 38241, 38388, 38375
26013, 37039, 37043, 37087, 37083, 37040, 37044, 37088, 37084, 38243, 38389, 38390, 38376, 38246, 38392, 38393, 
38379, 38231, 38244, 38391, 38378
26014, 37040, 37044, 37088, 37084, 37041, 37045, 37089, 37085, 38246, 38392, 38393, 38379, 38249, 38395, 38396, 
38382, 38234, 38247, 38394, 38381
26015, 37041, 37045, 37089, 37085, 16006, 16007, 16018, 16017, 38249, 38395, 38396, 38382, 0, 0, 0, 
0, 38237, 38250, 38397, 38384
26016, 5529, 5530, 5541, 5540, 37042, 37046, 37090, 37086, 0, 0, 0, 0, 38253, 38399, 38400, 
38386, 38238, 38251, 38398, 38385
26017, 37042, 37046, 37090, 37086, 37043, 37047, 37091, 37087, 38253, 38399, 38400, 38386, 38256, 38402, 38403, 
38389, 38241, 38254, 38401, 38388
26018, 37043, 37047, 37091, 37087, 37044, 37048, 37092, 37088, 38256, 38402, 38403, 38389, 38259, 38405, 38406, 
38392, 38244, 38257, 38404, 38391
26019, 37044, 37048, 37092, 37088, 37045, 37049, 37093, 37089, 38259, 38405, 38406, 38392, 38262, 38408, 38409, 
38395, 38247, 38260, 38407, 38394
26020, 37045, 37049, 37093, 37089, 16007, 16008, 16019, 16018, 38262, 38408, 38409, 38395, 0, 0, 0, 
0, 38250, 38263, 38410, 38397
26021, 5530, 581, 582, 5541, 37046, 15752, 15756, 37090, 0, 0, 0, 0, 38264, 0, 38411, 
38399, 38251, 0, 0, 38398
26022, 37046, 15752, 15756, 37090, 37047, 15753, 15757, 37091, 38264, 0, 38411, 38399, 38265, 0, 38412, 
38402, 38254, 0, 0, 38401
26023, 37047, 15753, 15757, 37091, 37048, 15754, 15758, 37092, 38265, 0, 38412, 38402, 38266, 0, 38413, 
38405, 38257, 0, 0, 38404
26024, 37048, 15754, 15758, 37092, 37049, 15755, 15759, 37093, 38266, 0, 38413, 38405, 38267, 0, 38414, 
38408, 38260, 0, 0, 38407
26025, 37049, 15755, 15759, 37093, 16008, 2037, 2038, 16019, 38267, 0, 38414, 38408, 0, 0, 0, 
0, 38263, 0, 0, 38410
26026, 544, 5531, 5542, 545, 15306, 37050, 37094, 15310, 0, 0, 0, 0, 38270, 38416, 38417, 
15417, 15409, 38268, 38415, 15418
26027, 15306, 37050, 37094, 15310, 15307, 37051, 37095, 15311, 38270, 38416, 38417, 15417, 38273, 38419, 38420, 
15419, 15411, 38271, 38418, 15420
26028, 15307, 37051, 37095, 15311, 15308, 37052, 37096, 15312, 38273, 38419, 38420, 15419, 38276, 38422, 38423, 
15421, 15413, 38274, 38421, 15422
26029, 15308, 37052, 37096, 15312, 15309, 37053, 37097, 15313, 38276, 38422, 38423, 15421, 38279, 38425, 38426, 
15423, 15415, 38277, 38424, 15424
26030, 15309, 37053, 37097, 15313, 1996, 16009, 16020, 1997, 38279, 38425, 38426, 15423, 0, 0, 0, 
0, 15416, 38280, 38427, 15425
26031, 5531, 5532, 5543, 5542, 37050, 37054, 37098, 37094, 0, 0, 0, 0, 38283, 38429, 38430, 
38416, 38268, 38281, 38428, 38415
26032, 37050, 37054, 37098, 37094, 37051, 37055, 37099, 37095, 38283, 38429, 38430, 38416, 38286, 38432, 38433, 
38419, 38271, 38284, 38431, 38418
26033, 37051, 37055, 37099, 37095, 37052, 37056, 37100, 37096, 38286, 38432, 38433, 38419, 38289, 38435, 38436, 
38422, 38274, 38287, 38434, 38421
26034, 37052, 37056, 37100, 37096, 37053, 37057, 37101, 37097, 38289, 38435, 38436, 38422, 38292, 38438, 38439, 
38425, 38277, 38290, 38437, 38424
26035, 37053, 37057, 37101, 37097, 16009, 16010, 16021, 16020, 38292, 38438, 38439, 38425, 0, 0, 0, 
0, 38280, 38293, 38440, 38427
26036, 5532, 5533, 5544, 5543, 37054, 37058, 37102, 37098, 0, 0, 0, 0, 38296, 38442, 38443, 
38429, 38281, 38294, 38441, 38428
26037, 37054, 37058, 37102, 37098, 37055, 37059, 37103, 37099, 38296, 38442, 38443, 38429, 38299, 38445, 38446, 
38432, 38284, 38297, 38444, 38431
26038, 37055, 37059, 37103, 37099, 37056, 37060, 37104, 37100, 38299, 38445, 38446, 38432, 38302, 38448, 38449, 
38435, 38287, 38300, 38447, 38434
26039, 37056, 37060, 37104, 37100, 37057, 37061, 37105, 37101, 38302, 38448, 38449, 38435, 38305, 38451, 38452, 
38438, 38290, 38303, 38450, 38437
26040, 37057, 37061, 37105, 37101, 16010, 16011, 16022, 16021, 38305, 38451, 38452, 38438, 0, 0, 0, 
0, 38293, 38306, 38453, 38440
26041, 5533, 5534, 5545, 5544, 37058, 37062, 37106, 37102, 0, 0, 0, 0, 38309, 38455, 38456, 
38442, 38294, 38307, 38454, 38441
26042, 37058, 37062, 37106, 37102, 37059, 37063, 37107, 37103, 38309, 38455, 38456, 38442, 38312, 38458, 38459, 
38445, 38297, 38310, 38457, 38444
26043, 37059, 37063, 37107, 37103, 37060, 37064, 37108, 37104, 38312, 38458, 38459, 38445, 38315, 38461, 38462, 
38448, 38300, 38313, 38460, 38447
26044, 37060, 37064, 37108, 37104, 37061, 37065, 37109, 37105, 38315, 38461, 38462, 38448, 38318, 38464, 38465, 
38451, 38303, 38316, 38463, 38450
26045, 37061, 37065, 37109, 37105, 16011, 16012, 16023, 16022, 38318, 38464, 38465, 38451, 0, 0, 0, 
0, 38306, 38319, 38466, 38453
26046, 5534, 5535, 5546, 5545, 37062, 37066, 37110, 37106, 0, 0, 0, 0, 38322, 38468, 38469, 
38455, 38307, 38320, 38467, 38454
26047, 37062, 37066, 37110, 37106, 37063, 37067, 37111, 37107, 38322, 38468, 38469, 38455, 38325, 38471, 38472, 
38458, 38310, 38323, 38470, 38457
26048, 37063, 37067, 37111, 37107, 37064, 37068, 37112, 37108, 38325, 38471, 38472, 38458, 38328, 38474, 38475, 
38461, 38313, 38326, 38473, 38460
26049, 37064, 37068, 37112, 37108, 37065, 37069, 37113, 37109, 38328, 38474, 38475, 38461, 38331, 38477, 38478, 
38464, 38316, 38329, 38476, 38463
26050, 37065, 37069, 37113, 37109, 16012, 16013, 16024, 16023, 38331, 38477, 38478, 38464, 0, 0, 0, 
0, 38319, 38332, 38479, 38466
26051, 5535, 5536, 5547, 5546, 37066, 37070, 37114, 37110, 0, 0, 0, 0, 38335, 38481, 38482, 
38468, 38320, 38333, 38480, 38467
26052, 37066, 37070, 37114, 37110, 37067, 37071, 37115, 37111, 38335, 38481, 38482, 38468, 38338, 38484, 38485, 
38471, 38323, 38336, 38483, 38470
26053, 37067, 37071, 37115, 37111, 37068, 37072, 37116, 37112, 38338, 38484, 38485, 38471, 38341, 38487, 38488, 
38474, 38326, 38339, 38486, 38473
26054, 37068, 37072, 37116, 37112, 37069, 37073, 37117, 37113, 38341, 38487, 38488, 38474, 38344, 38490, 38491, 
38477, 38329, 38342, 38489, 38476
26055, 37069, 37073, 37117, 37113, 16013, 16014, 16025, 16024, 38344, 38490, 38491, 38477, 0, 0, 0, 
0, 38332, 38345, 38492, 38479
26056, 5536, 5537, 5548, 5547, 37070, 37074, 37118, 37114, 0, 0, 0, 0, 38348, 38494, 38495, 
38481, 38333, 38346, 38493, 38480
26057, 37070, 37074, 37118, 37114, 37071, 37075, 37119, 37115, 38348, 38494, 38495, 38481, 38351, 38497, 38498, 
38484, 38336, 38349, 38496, 38483
26058, 37071, 37075, 37119, 37115, 37072, 37076, 37120, 37116, 38351, 38497, 38498, 38484, 38354, 38500, 38501, 
38487, 38339, 38352, 38499, 38486
26059, 37072, 37076, 37120, 37116, 37073, 37077, 37121, 37117, 38354, 38500, 38501, 38487, 38357, 38503, 38504, 
38490, 38342, 38355, 38502, 38489
26060, 37073, 37077, 37121, 37117, 16014, 16015, 16026, 16025, 38357, 38503, 38504, 38490, 0, 0, 0, 
0, 38345, 38358, 38505, 38492
26061, 5537, 5538, 5549, 5548, 37074, 37078, 37122, 37118, 0, 0, 0, 0, 38361, 38507, 38508, 
38494, 38346, 38359, 38506, 38493
26062, 37074, 37078, 37122, 37118, 37075, 37079, 37123, 37119, 38361, 38507, 38508, 38494, 38364, 38510, 38511, 
38497, 38349, 38362, 38509, 38496
26063, 37075, 37079, 37123, 37119, 37076, 37080, 37124, 37120, 38364, 38510, 38511, 38497, 38367, 38513, 38514, 
38500, 38352, 38365, 38512, 38499
26064, 37076, 37080, 37124, 37120, 37077, 37081, 37125, 37121, 38367, 38513, 38514, 38500, 38370, 38516, 38517, 
38503, 38355, 38368, 38515, 38502
26065, 37077, 37081, 37125, 37121, 16015, 16016, 16027, 16026, 38370, 38516, 38517, 38503, 0, 0, 0, 
0, 38358, 38371, 38518, 38505
26066, 5538, 5539, 5550, 5549, 37078, 37082, 37126, 37122, 0, 0, 0, 0, 38374, 38520, 38521, 
38507, 38359, 38372, 38519, 38506
26067, 37078, 37082, 37126, 37122, 37079, 37083, 37127, 37123, 38374, 38520, 38521, 38507, 38377, 38523, 38524, 
38510, 38362, 38375, 38522, 38509
26068, 37079, 37083, 37127, 37123, 37080, 37084, 37128, 37124, 38377, 38523, 38524, 38510, 38380, 38526, 38527, 
38513, 38365, 38378, 38525, 38512
26069, 37080, 37084, 37128, 37124, 37081, 37085, 37129, 37125, 38380, 38526, 38527, 38513, 38383, 38529, 38530, 
38516, 38368, 38381, 38528, 38515
26070, 37081, 37085, 37129, 37125, 16016, 16017, 16028, 16027, 38383, 38529, 38530, 38516, 0, 0, 0, 
0, 38371, 38384, 38531, 38518
26071, 5539, 5540, 5551, 5550, 37082, 37086, 37130, 37126, 0, 0, 0, 0, 38387, 38533, 38534, 
38520, 38372, 38385, 38532, 38519
26072, 37082, 37086, 37130, 37126, 37083, 37087, 37131, 37127, 38387, 38533, 38534, 38520, 38390, 38536, 38537, 
38523, 38375, 38388, 38535, 38522
26073, 37083, 37087, 37131, 37127, 37084, 37088, 37132, 37128, 38390, 38536, 38537, 38523, 38393, 38539, 38540, 
38526, 38378, 38391, 38538, 38525
26074, 37084, 37088, 37132, 37128, 37085, 37089, 37133, 37129, 38393, 38539, 38540, 38526, 38396, 38542, 38543, 
38529, 38381, 38394, 38541, 38528
26075, 37085, 37089, 37133, 37129, 16017, 16018, 16029, 16028, 38396, 38542, 38543, 38529, 0, 0, 0, 
0, 38384, 38397, 38544, 38531
26076, 5540, 5541, 5552, 5551, 37086, 37090, 37134, 37130, 0, 0, 0, 0, 38400, 38546, 38547, 
38533, 38385, 38398, 38545, 38532
26077, 37086, 37090, 37134, 37130, 37087, 37091, 37135, 37131, 38400, 38546, 38547, 38533, 38403, 38549, 38550, 
38536, 38388, 38401, 38548, 38535
26078, 37087, 37091, 37135, 37131, 37088, 37092, 37136, 37132, 38403, 38549, 38550, 38536, 38406, 38552, 38553, 
38539, 38391, 38404, 38551, 38538
26079, 37088, 37092, 37136, 37132, 37089, 37093, 37137, 37133, 38406, 38552, 38553, 38539, 38409, 38555, 38556, 
38542, 38394, 38407, 38554, 38541
26080, 37089, 37093, 37137, 37133, 16018, 16019, 16030, 16029, 38409, 38555, 38556, 38542, 0, 0, 0, 
0, 38397, 38410, 38557, 38544
26081, 5541, 582, 583, 5552, 37090, 15756, 15760, 37134, 0, 0, 0, 0, 38411, 0, 38558, 
38546, 38398, 0, 0, 38545
26082, 37090, 15756, 15760, 37134, 37091, 15757, 15761, 37135, 38411, 0, 38558, 38546, 38412, 0, 38559, 
38549, 38401, 0, 0, 38548
26083, 37091, 15757, 15761, 37135, 37092, 15758, 15762, 37136, 38412, 0, 38559, 38549, 38413, 0, 38560, 
38552, 38404, 0, 0, 38551
26084, 37092, 15758, 15762, 37136, 37093, 15759, 15763, 37137, 38413, 0, 38560, 38552, 38414, 0, 38561, 
38555, 38407, 0, 0, 38554
26085, 37093, 15759, 15763, 37137, 16019, 2038, 2039, 16030, 38414, 0, 38561, 38555, 0, 0, 0, 
0, 38410, 0, 0, 38557
26086, 545, 5542, 5553, 546, 15310, 37094, 37138, 15314, 0, 0, 0, 0, 38417, 38563, 38564, 
15426, 15418, 38415, 38562, 15427
26087, 15310, 37094, 37138, 15314, 15311, 37095, 37139, 15315, 38417, 38563, 38564, 15426, 38420, 38566, 38567, 
15428, 15420, 38418, 38565, 15429
26088, 15311, 37095, 37139, 15315, 15312, 37096, 37140, 15316, 38420, 38566, 38567, 15428, 38423, 38569, 38570, 
15430, 15422, 38421, 38568, 15431
26089, 15312, 37096, 37140, 15316, 15313, 37097, 37141, 15317, 38423, 38569, 38570, 15430, 38426, 38572, 38573, 
15432, 15424, 38424, 38571, 15433
26090, 15313, 37097, 37141, 15317, 1997, 16020, 16031, 1998, 38426, 38572, 38573, 15432, 0, 0, 0, 
0, 15425, 38427, 38574, 15434
26091, 5542, 5543, 5554, 5553, 37094, 37098, 37142, 37138, 0, 0, 0, 0, 38430, 38576, 38577, 
38563, 38415, 38428, 38575, 38562
26092, 37094, 37098, 37142, 37138, 37095, 37099, 37143, 37139, 38430, 38576, 38577, 38563, 38433, 38579, 38580, 
38566, 38418, 38431, 38578, 38565
26093, 37095, 37099, 37143, 37139, 37096, 37100, 37144, 37140, 38433, 38579, 38580, 38566, 38436, 38582, 38583, 
38569, 38421, 38434, 38581, 38568
26094, 37096, 37100, 37144, 37140, 37097, 37101, 37145, 37141, 38436, 38582, 38583, 38569, 38439, 38585, 38586, 
38572, 38424, 38437, 38584, 38571
26095, 37097, 37101, 37145, 37141, 16020, 16021, 16032, 16031, 38439, 38585, 38586, 38572, 0, 0, 0, 
0, 38427, 38440, 38587, 38574
26096, 5543, 5544, 5555, 5554, 37098, 37102, 37146, 37142, 0, 0, 0, 0, 38443, 38589, 38590, 
38576, 38428, 38441, 38588, 38575
26097, 37098, 37102, 37146, 37142, 37099, 37103, 37147, 37143, 38443, 38589, 38590, 38576, 38446, 38592, 38593, 
38579, 38431, 38444, 38591, 38578
26098, 37099, 37103, 37147, 37143, 37100, 37104, 37148, 37144, 38446, 38592, 38593, 38579, 38449, 38595, 38596, 
38582, 38434, 38447, 38594, 38581
26099, 37100, 37104, 37148, 37144, 37101, 37105, 37149, 37145, 38449, 38595, 38596, 38582, 38452, 38598, 38599, 
38585, 38437, 38450, 38597, 38584
26100, 37101, 37105, 37149, 37145, 16021, 16022, 16033, 16032, 38452, 38598, 38599, 38585, 0, 0, 0, 
0, 38440, 38453, 38600, 38587
26101, 5544, 5545, 5556, 5555, 37102, 37106, 37150, 37146, 0, 0, 0, 0, 38456, 38602, 38603, 
38589, 38441, 38454, 38601, 38588
26102, 37102, 37106, 37150, 37146, 37103, 37107, 37151, 37147, 38456, 38602, 38603, 38589, 38459, 38605, 38606, 
38592, 38444, 38457, 38604, 38591
26103, 37103, 37107, 37151, 37147, 37104, 37108, 37152, 37148, 38459, 38605, 38606, 38592, 38462, 38608, 38609, 
38595, 38447, 38460, 38607, 38594
26104, 37104, 37108, 37152, 37148, 37105, 37109, 37153, 37149, 38462, 38608, 38609, 38595, 38465, 38611, 38612, 
38598, 38450, 38463, 38610, 38597
26105, 37105, 37109, 37153, 37149, 16022, 16023, 16034, 16033, 38465, 38611, 38612, 38598, 0, 0, 0, 
0, 38453, 38466, 38613, 38600
26106, 5545, 5546, 5557, 5556, 37106, 37110, 37154, 37150, 0, 0, 0, 0, 38469, 38615, 38616, 
38602, 38454, 38467, 38614, 38601
26107, 37106, 37110, 37154, 37150, 37107, 37111, 37155, 37151, 38469, 38615, 38616, 38602, 38472, 38618, 38619, 
38605, 38457, 38470, 38617, 38604
26108, 37107, 37111, 37155, 37151, 37108, 37112, 37156, 37152, 38472, 38618, 38619, 38605, 38475, 38621, 38622, 
38608, 38460, 38473, 38620, 38607
26109, 37108, 37112, 37156, 37152, 37109, 37113, 37157, 37153, 38475, 38621, 38622, 38608, 38478, 38624, 38625, 
38611, 38463, 38476, 38623, 38610
26110, 37109, 37113, 37157, 37153, 16023, 16024, 16035, 16034, 38478, 38624, 38625, 38611, 0, 0, 0, 
0, 38466, 38479, 38626, 38613
26111, 5546, 5547, 5558, 5557, 37110, 37114, 37158, 37154, 0, 0, 0, 0, 38482, 38628, 38629, 
38615, 38467, 38480, 38627, 38614
26112, 37110, 37114, 37158, 37154, 37111, 37115, 37159, 37155, 38482, 38628, 38629, 38615, 38485, 38631, 38632, 
38618, 38470, 38483, 38630, 38617
26113, 37111, 37115, 37159, 37155, 37112, 37116, 37160, 37156, 38485, 38631, 38632, 38618, 38488, 38634, 38635, 
38621, 38473, 38486, 38633, 38620
26114, 37112, 37116, 37160, 37156, 37113, 37117, 37161, 37157, 38488, 38634, 38635, 38621, 38491, 38637, 38638, 
38624, 38476, 38489, 38636, 38623
26115, 37113, 37117, 37161, 37157, 16024, 16025, 16036, 16035, 38491, 38637, 38638, 38624, 0, 0, 0, 
0, 38479, 38492, 38639, 38626
26116, 5547, 5548, 5559, 5558, 37114, 37118, 37162, 37158, 0, 0, 0, 0, 38495, 38641, 38642, 
38628, 38480, 38493, 38640, 38627
26117, 37114, 37118, 37162, 37158, 37115, 37119, 37163, 37159, 38495, 38641, 38642, 38628, 38498, 38644, 38645, 
38631, 38483, 38496, 38643, 38630
26118, 37115, 37119, 37163, 37159, 37116, 37120, 37164, 37160, 38498, 38644, 38645, 38631, 38501, 38647, 38648, 
38634, 38486, 38499, 38646, 38633
26119, 37116, 37120, 37164, 37160, 37117, 37121, 37165, 37161, 38501, 38647, 38648, 38634, 38504, 38650, 38651, 
38637, 38489, 38502, 38649, 38636
26120, 37117, 37121, 37165, 37161, 16025, 16026, 16037, 16036, 38504, 38650, 38651, 38637, 0, 0, 0, 
0, 38492, 38505, 38652, 38639
26121, 5548, 5549, 5560, 5559, 37118, 37122, 37166, 37162, 0, 0, 0, 0, 38508, 38654, 38655, 
38641, 38493, 38506, 38653, 38640
26122, 37118, 37122, 37166, 37162, 37119, 37123, 37167, 37163, 38508, 38654, 38655, 38641, 38511, 38657, 38658, 
38644, 38496, 38509, 38656, 38643
26123, 37119, 37123, 37167, 37163, 37120, 37124, 37168, 37164, 38511, 38657, 38658, 38644, 38514, 38660, 38661, 
38647, 38499, 38512, 38659, 38646
26124, 37120, 37124, 37168, 37164, 37121, 37125, 37169, 37165, 38514, 38660, 38661, 38647, 38517, 38663, 38664, 
38650, 38502, 38515, 38662, 38649
26125, 37121, 37125, 37169, 37165, 16026, 16027, 16038, 16037, 38517, 38663, 38664, 38650, 0, 0, 0, 
0, 38505, 38518, 38665, 38652
26126, 5549, 5550, 5561, 5560, 37122, 37126, 37170, 37166, 0, 0, 0, 0, 38521, 38667, 38668, 
38654, 38506, 38519, 38666, 38653
26127, 37122, 37126, 37170, 37166, 37123, 37127, 37171, 37167, 38521, 38667, 38668, 38654, 38524, 38670, 38671, 
38657, 38509, 38522, 38669, 38656
26128, 37123, 37127, 37171, 37167, 37124, 37128, 37172, 37168, 38524, 38670, 38671, 38657, 38527, 38673, 38674, 
38660, 38512, 38525, 38672, 38659
26129, 37124, 37128, 37172, 37168, 37125, 37129, 37173, 37169, 38527, 38673, 38674, 38660, 38530, 38676, 38677, 
38663, 38515, 38528, 38675, 38662
26130, 37125, 37129, 37173, 37169, 16027, 16028, 16039, 16038, 38530, 38676, 38677, 38663, 0, 0, 0, 
0, 38518, 38531, 38678, 38665
26131, 5550, 5551, 5562, 5561, 37126, 37130, 37174, 37170, 0, 0, 0, 0, 38534, 38680, 38681, 
38667, 38519, 38532, 38679, 38666
26132, 37126, 37130, 37174, 37170, 37127, 37131, 37175, 37171, 38534, 38680, 38681, 38667, 38537, 38683, 38684, 
38670, 38522, 38535, 38682, 38669
26133, 37127, 37131, 37175, 37171, 37128, 37132, 37176, 37172, 38537, 38683, 38684, 38670, 38540, 38686, 38687, 
38673, 38525, 38538, 38685, 38672
26134, 37128, 37132, 37176, 37172, 37129, 37133, 37177, 37173, 38540, 38686, 38687, 38673, 38543, 38689, 38690, 
38676, 38528, 38541, 38688, 38675
26135, 37129, 37133, 37177, 37173, 16028, 16029, 16040, 16039, 38543, 38689, 38690, 38676, 0, 0, 0, 
0, 38531, 38544, 38691, 38678
26136, 5551, 5552, 5563, 5562, 37130, 37134, 37178, 37174, 0, 0, 0, 0, 38547, 38693, 38694, 
38680, 38532, 38545, 38692, 38679
26137, 37130, 37134, 37178, 37174, 37131, 37135, 37179, 37175, 38547, 38693, 38694, 38680, 38550, 38696, 38697, 
38683, 38535, 38548, 38695, 38682
26138, 37131, 37135, 37179, 37175, 37132, 37136, 37180, 37176, 38550, 38696, 38697, 38683, 38553, 38699, 38700, 
38686, 38538, 38551, 38698, 38685
26139, 37132, 37136, 37180, 37176, 37133, 37137, 37181, 37177, 38553, 38699, 38700, 38686, 38556, 38702, 38703, 
38689, 38541, 38554, 38701, 38688
26140, 37133, 37137, 37181, 37177, 16029, 16030, 16041, 16040, 38556, 38702, 38703, 38689, 0, 0, 0, 
0, 38544, 38557, 38704, 38691
26141, 5552, 583, 584, 5563, 37134, 15760, 15764, 37178, 0, 0, 0, 0, 38558, 0, 38705, 
38693, 38545, 0, 0, 38692
26142, 37134, 15760, 15764, 37178, 37135, 15761, 15765, 37179, 38558, 0, 38705, 38693, 38559, 0, 38706, 
38696, 38548, 0, 0, 38695
26143, 37135, 15761, 15765, 37179, 37136, 15762, 15766, 37180, 38559, 0, 38706, 38696, 38560, 0, 38707, 
38699, 38551, 0, 0, 38698
26144, 37136, 15762, 15766, 37180, 37137, 15763, 15767, 37181, 38560, 0, 38707, 38699, 38561, 0, 38708, 
38702, 38554, 0, 0, 38701
26145, 37137, 15763, 15767, 37181, 16030, 2039, 2040, 16041, 38561, 0, 38708, 38702, 0, 0, 0, 
0, 38557, 0, 0, 38704
26146, 546, 5553, 5564, 547, 15314, 37138, 37182, 15318, 0, 0, 0, 0, 38564, 38710, 38711, 
15435, 15427, 38562, 38709, 15436
26147, 15314, 37138, 37182, 15318, 15315, 37139, 37183, 15319, 38564, 38710, 38711, 15435, 38567, 38713, 38714, 
15437, 15429, 38565, 38712, 15438
26148, 15315, 37139, 37183, 15319, 15316, 37140, 37184, 15320, 38567, 38713, 38714, 15437, 38570, 38716, 38717, 
15439, 15431, 38568, 38715, 15440
26149, 15316, 37140, 37184, 15320, 15317, 37141, 37185, 15321, 38570, 38716, 38717, 15439, 38573, 38719, 38720, 
15441, 15433, 38571, 38718, 15442
26150, 15317, 37141, 37185, 15321, 1998, 16031, 16042, 1999, 38573, 38719, 38720, 15441, 0, 0, 0, 
0, 15434, 38574, 38721, 15443
26151, 5553, 5554, 5565, 5564, 37138, 37142, 37186, 37182, 0, 0, 0, 0, 38577, 38723, 38724, 
38710, 38562, 38575, 38722, 38709
26152, 37138, 37142, 37186, 37182, 37139, 37143, 37187, 37183, 38577, 38723, 38724, 38710, 38580, 38726, 38727, 
38713, 38565, 38578, 38725, 38712
26153, 37139, 37143, 37187, 37183, 37140, 37144, 37188, 37184, 38580, 38726, 38727, 38713, 38583, 38729, 38730, 
38716, 38568, 38581, 38728, 38715
26154, 37140, 37144, 37188, 37184, 37141, 37145, 37189, 37185, 38583, 38729, 38730, 38716, 38586, 38732, 38733, 
38719, 38571, 38584, 38731, 38718
26155, 37141, 37145, 37189, 37185, 16031, 16032, 16043, 16042, 38586, 38732, 38733, 38719, 0, 0, 0, 
0, 38574, 38587, 38734, 38721
26156, 5554, 5555, 5566, 5565, 37142, 37146, 37190, 37186, 0, 0, 0, 0, 38590, 38736, 38737, 
38723, 38575, 38588, 38735, 38722
26157, 37142, 37146, 37190, 37186, 37143, 37147, 37191, 37187, 38590, 38736, 38737, 38723, 38593, 38739, 38740, 
38726, 38578, 38591, 38738, 38725
26158, 37143, 37147, 37191, 37187, 37144, 37148, 37192, 37188, 38593, 38739, 38740, 38726, 38596, 38742, 38743, 
38729, 38581, 38594, 38741, 38728
26159, 37144, 37148, 37192, 37188, 37145, 37149, 37193, 37189, 38596, 38742, 38743, 38729, 38599, 38745, 38746, 
38732, 38584, 38597, 38744, 38731
26160, 37145, 37149, 37193, 37189, 16032, 16033, 16044, 16043, 38599, 38745, 38746, 38732, 0, 0, 0, 
0, 38587, 38600, 38747, 38734
26161, 5555, 5556, 5567, 5566, 37146, 37150, 37194, 37190, 0, 0, 0, 0, 38603, 38749, 38750, 
38736, 38588, 38601, 38748, 38735
26162, 37146, 37150, 37194, 37190, 37147, 37151, 37195, 37191, 38603, 38749, 38750, 38736, 38606, 38752, 38753, 
38739, 38591, 38604, 38751, 38738
26163, 37147, 37151, 37195, 37191, 37148, 37152, 37196, 37192, 38606, 38752, 38753, 38739, 38609, 38755, 38756, 
38742, 38594, 38607, 38754, 38741
26164, 37148, 37152, 37196, 37192, 37149, 37153, 37197, 37193, 38609, 38755, 38756, 38742, 38612, 38758, 38759, 
38745, 38597, 38610, 38757, 38744
26165, 37149, 37153, 37197, 37193, 16033, 16034, 16045, 16044, 38612, 38758, 38759, 38745, 0, 0, 0, 
0, 38600, 38613, 38760, 38747
26166, 5556, 5557, 5568, 5567, 37150, 37154, 37198, 37194, 0, 0, 0, 0, 38616, 38762, 38763, 
38749, 38601, 38614, 38761, 38748
26167, 37150, 37154, 37198, 37194, 37151, 37155, 37199, 37195, 38616, 38762, 38763, 38749, 38619, 38765, 38766, 
38752, 38604, 38617, 38764, 38751
26168, 37151, 37155, 37199, 37195, 37152, 37156, 37200, 37196, 38619, 38765, 38766, 38752, 38622, 38768, 38769, 
38755, 38607, 38620, 38767, 38754
26169, 37152, 37156, 37200, 37196, 37153, 37157, 37201, 37197, 38622, 38768, 38769, 38755, 38625, 38771, 38772, 
38758, 38610, 38623, 38770, 38757
26170, 37153, 37157, 37201, 37197, 16034, 16035, 16046, 16045, 38625, 38771, 38772, 38758, 0, 0, 0, 
0, 38613, 38626, 38773, 38760
26171, 5557, 5558, 5569, 5568, 37154, 37158, 37202, 37198, 0, 0, 0, 0, 38629, 38775, 38776, 
38762, 38614, 38627, 38774, 38761
26172, 37154, 37158, 37202, 37198, 37155, 37159, 37203, 37199, 38629, 38775, 38776, 38762, 38632, 38778, 38779, 
38765, 38617, 38630, 38777, 38764
26173, 37155, 37159, 37203, 37199, 37156, 37160, 37204, 37200, 38632, 38778, 38779, 38765, 38635, 38781, 38782, 
38768, 38620, 38633, 38780, 38767
26174, 37156, 37160, 37204, 37200, 37157, 37161, 37205, 37201, 38635, 38781, 38782, 38768, 38638, 38784, 38785, 
38771, 38623, 38636, 38783, 38770
26175, 37157, 37161, 37205, 37201, 16035, 16036, 16047, 16046, 38638, 38784, 38785, 38771, 0, 0, 0, 
0, 38626, 38639, 38786, 38773
26176, 5558, 5559, 5570, 5569, 37158, 37162, 37206, 37202, 0, 0, 0, 0, 38642, 38788, 38789, 
38775, 38627, 38640, 38787, 38774
26177, 37158, 37162, 37206, 37202, 37159, 37163, 37207, 37203, 38642, 38788, 38789, 38775, 38645, 38791, 38792, 
38778, 38630, 38643, 38790, 38777
26178, 37159, 37163, 37207, 37203, 37160, 37164, 37208, 37204, 38645, 38791, 38792, 38778, 38648, 38794, 38795, 
38781, 38633, 38646, 38793, 38780
26179, 37160, 37164, 37208, 37204, 37161, 37165, 37209, 37205, 38648, 38794, 38795, 38781, 38651, 38797, 38798, 
38784, 38636, 38649, 38796, 38783
26180, 37161, 37165, 37209, 37205, 16036, 16037, 16048, 16047, 38651, 38797, 38798, 38784, 0, 0, 0, 
0, 38639, 38652, 38799, 38786
26181, 5559, 5560, 5571, 5570, 37162, 37166, 37210, 37206, 0, 0, 0, 0, 38655, 38801, 38802, 
38788, 38640, 38653, 38800, 38787
26182, 37162, 37166, 37210, 37206, 37163, 37167, 37211, 37207, 38655, 38801, 38802, 38788, 38658, 38804, 38805, 
38791, 38643, 38656, 38803, 38790
26183, 37163, 37167, 37211, 37207, 37164, 37168, 37212, 37208, 38658, 38804, 38805, 38791, 38661, 38807, 38808, 
38794, 38646, 38659, 38806, 38793
26184, 37164, 37168, 37212, 37208, 37165, 37169, 37213, 37209, 38661, 38807, 38808, 38794, 38664, 38810, 38811, 
38797, 38649, 38662, 38809, 38796
26185, 37165, 37169, 37213, 37209, 16037, 16038, 16049, 16048, 38664, 38810, 38811, 38797, 0, 0, 0, 
0, 38652, 38665, 38812, 38799
26186, 5560, 5561, 5572, 5571, 37166, 37170, 37214, 37210, 0, 0, 0, 0, 38668, 38814, 38815, 
38801, 38653, 38666, 38813, 38800
26187, 37166, 37170, 37214, 37210, 37167, 37171, 37215, 37211, 38668, 38814, 38815, 38801, 38671, 38817, 38818, 
38804, 38656, 38669, 38816, 38803
26188, 37167, 37171, 37215, 37211, 37168, 37172, 37216, 37212, 38671, 38817, 38818, 38804, 38674, 38820, 38821, 
38807, 38659, 38672, 38819, 38806
26189, 37168, 37172, 37216, 37212, 37169, 37173, 37217, 37213, 38674, 38820, 38821, 38807, 38677, 38823, 38824, 
38810, 38662, 38675, 38822, 38809
26190, 37169, 37173, 37217, 37213, 16038, 16039, 16050, 16049, 38677, 38823, 38824, 38810, 0, 0, 0, 
0, 38665, 38678, 38825, 38812
26191, 5561, 5562, 5573, 5572, 37170, 37174, 37218, 37214, 0, 0, 0, 0, 38681, 38827, 38828, 
38814, 38666, 38679, 38826, 38813
26192, 37170, 37174, 37218, 37214, 37171, 37175, 37219, 37215, 38681, 38827, 38828, 38814, 38684, 38830, 38831, 
38817, 38669, 38682, 38829, 38816
26193, 37171, 37175, 37219, 37215, 37172, 37176, 37220, 37216, 38684, 38830, 38831, 38817, 38687, 38833, 38834, 
38820, 38672, 38685, 38832, 38819
26194, 37172, 37176, 37220, 37216, 37173, 37177, 37221, 37217, 38687, 38833, 38834, 38820, 38690, 38836, 38837, 
38823, 38675, 38688, 38835, 38822
26195, 37173, 37177, 37221, 37217, 16039, 16040, 16051, 16050, 38690, 38836, 38837, 38823, 0, 0, 0, 
0, 38678, 38691, 38838, 38825
26196, 5562, 5563, 5574, 5573, 37174, 37178, 37222, 37218, 0, 0, 0, 0, 38694, 38840, 38841, 
38827, 38679, 38692, 38839, 38826
26197, 37174, 37178, 37222, 37218, 37175, 37179, 37223, 37219, 38694, 38840, 38841, 38827, 38697, 38843, 38844, 
38830, 38682, 38695, 38842, 38829
26198, 37175, 37179, 37223, 37219, 37176, 37180, 37224, 37220, 38697, 38843, 38844, 38830, 38700, 38846, 38847, 
38833, 38685, 38698, 38845, 38832
26199, 37176, 37180, 37224, 37220, 37177, 37181, 37225, 37221, 38700, 38846, 38847, 38833, 38703, 38849, 38850, 
38836, 38688, 38701, 38848, 38835
26200, 37177, 37181, 37225, 37221, 16040, 16041, 16052, 16051, 38703, 38849, 38850, 38836, 0, 0, 0, 
0, 38691, 38704, 38851, 38838
26201, 5563, 584, 585, 5574, 37178, 15764, 15768, 37222, 0, 0, 0, 0, 38705, 0, 38852, 
38840, 38692, 0, 0, 38839
26202, 37178, 15764, 15768, 37222, 37179, 15765, 15769, 37223, 38705, 0, 38852, 38840, 38706, 0, 38853, 
38843, 38695, 0, 0, 38842
26203, 37179, 15765, 15769, 37223, 37180, 15766, 15770, 37224, 38706, 0, 38853, 38843, 38707, 0, 38854, 
38846, 38698, 0, 0, 38845
26204, 37180, 15766, 15770, 37224, 37181, 15767, 15771, 37225, 38707, 0, 38854, 38846, 38708, 0, 38855, 
38849, 38701, 0, 0, 38848
26205, 37181, 15767, 15771, 37225, 16041, 2040, 2041, 16052, 38708, 0, 38855, 38849, 0, 0, 0, 
0, 38704, 0, 0, 38851
26206, 547, 5564, 5575, 548, 15318, 37182, 37226, 15322, 0, 0, 0, 0, 38711, 38857, 38858, 
15444, 15436, 38709, 38856, 15445
26207, 15318, 37182, 37226, 15322, 15319, 37183, 37227, 15323, 38711, 38857, 38858, 15444, 38714, 38860, 38861, 
15446, 15438, 38712, 38859, 15447
26208, 15319, 37183, 37227, 15323, 15320, 37184, 37228, 15324, 38714, 38860, 38861, 15446, 38717, 38863, 38864, 
15448, 15440, 38715, 38862, 15449
26209, 15320, 37184, 37228, 15324, 15321, 37185, 37229, 15325, 38717, 38863, 38864, 15448, 38720, 38866, 38867, 
15450, 15442, 38718, 38865, 15451
26210, 15321, 37185, 37229, 15325, 1999, 16042, 16053, 2000, 38720, 38866, 38867, 15450, 0, 0, 0, 
0, 15443, 38721, 38868, 15452
26211, 5564, 5565, 5576, 5575, 37182, 37186, 37230, 37226, 0, 0, 0, 0, 38724, 38870, 38871, 
38857, 38709, 38722, 38869, 38856
26212, 37182, 37186, 37230, 37226, 37183, 37187, 37231, 37227, 38724, 38870, 38871, 38857, 38727, 38873, 38874, 
38860, 38712, 38725, 38872, 38859
26213, 37183, 37187, 37231, 37227, 37184, 37188, 37232, 37228, 38727, 38873, 38874, 38860, 38730, 38876, 38877, 
38863, 38715, 38728, 38875, 38862
26214, 37184, 37188, 37232, 37228, 37185, 37189, 37233, 37229, 38730, 38876, 38877, 38863, 38733, 38879, 38880, 
38866, 38718, 38731, 38878, 38865
26215, 37185, 37189, 37233, 37229, 16042, 16043, 16054, 16053, 38733, 38879, 38880, 38866, 0, 0, 0, 
0, 38721, 38734, 38881, 38868
26216, 5565, 5566, 5577, 5576, 37186, 37190, 37234, 37230, 0, 0, 0, 0, 38737, 38883, 38884, 
38870, 38722, 38735, 38882, 38869
26217, 37186, 37190, 37234, 37230, 37187, 37191, 37235, 37231, 38737, 38883, 38884, 38870, 38740, 38886, 38887, 
38873, 38725, 38738, 38885, 38872
26218, 37187, 37191, 37235, 37231, 37188, 37192, 37236, 37232, 38740, 38886, 38887, 38873, 38743, 38889, 38890, 
38876, 38728, 38741, 38888, 38875
26219, 37188, 37192, 37236, 37232, 37189, 37193, 37237, 37233, 38743, 38889, 38890, 38876, 38746, 38892, 38893, 
38879, 38731, 38744, 38891, 38878
26220, 37189, 37193, 37237, 37233, 16043, 16044, 16055, 16054, 38746, 38892, 38893, 38879, 0, 0, 0, 
0, 38734, 38747, 38894, 38881
26221, 5566, 5567, 5578, 5577, 37190, 37194, 37238, 37234, 0, 0, 0, 0, 38750, 38896, 38897, 
38883, 38735, 38748, 38895, 38882
26222, 37190, 37194, 37238, 37234, 37191, 37195, 37239, 37235, 38750, 38896, 38897, 38883, 38753, 38899, 38900, 
38886, 38738, 38751, 38898, 38885
26223, 37191, 37195, 37239, 37235, 37192, 37196, 37240, 37236, 38753, 38899, 38900, 38886, 38756, 38902, 38903, 
38889, 38741, 38754, 38901, 38888
26224, 37192, 37196, 37240, 37236, 37193, 37197, 37241, 37237, 38756, 38902, 38903, 38889, 38759, 38905, 38906, 
38892, 38744, 38757, 38904, 38891
26225, 37193, 37197, 37241, 37237, 16044, 16045, 16056, 16055, 38759, 38905, 38906, 38892, 0, 0, 0, 
0, 38747, 38760, 38907, 38894
26226, 5567, 5568, 5579, 5578, 37194, 37198, 37242, 37238, 0, 0, 0, 0, 38763, 38909, 38910, 
38896, 38748, 38761, 38908, 38895
26227, 37194, 37198, 37242, 37238, 37195, 37199, 37243, 37239, 38763, 38909, 38910, 38896, 38766, 38912, 38913, 
38899, 38751, 38764, 38911, 38898
26228, 37195, 37199, 37243, 37239, 37196, 37200, 37244, 37240, 38766, 38912, 38913, 38899, 38769, 38915, 38916, 
38902, 38754, 38767, 38914, 38901
26229, 37196, 37200, 37244, 37240, 37197, 37201, 37245, 37241, 38769, 38915, 38916, 38902, 38772, 38918, 38919, 
38905, 38757, 38770, 38917, 38904
26230, 37197, 37201, 37245, 37241, 16045, 16046, 16057, 16056, 38772, 38918, 38919, 38905, 0, 0, 0, 
0, 38760, 38773, 38920, 38907
26231, 5568, 5569, 5580, 5579, 37198, 37202, 37246, 37242, 0, 0, 0, 0, 38776, 38922, 38923, 
38909, 38761, 38774, 38921, 38908
26232, 37198, 37202, 37246, 37242, 37199, 37203, 37247, 37243, 38776, 38922, 38923, 38909, 38779, 38925, 38926, 
38912, 38764, 38777, 38924, 38911
26233, 37199, 37203, 37247, 37243, 37200, 37204, 37248, 37244, 38779, 38925, 38926, 38912, 38782, 38928, 38929, 
38915, 38767, 38780, 38927, 38914
26234, 37200, 37204, 37248, 37244, 37201, 37205, 37249, 37245, 38782, 38928, 38929, 38915, 38785, 38931, 38932, 
38918, 38770, 38783, 38930, 38917
26235, 37201, 37205, 37249, 37245, 16046, 16047, 16058, 16057, 38785, 38931, 38932, 38918, 0, 0, 0, 
0, 38773, 38786, 38933, 38920
26236, 5569, 5570, 5581, 5580, 37202, 37206, 37250, 37246, 0, 0, 0, 0, 38789, 38935, 38936, 
38922, 38774, 38787, 38934, 38921
26237, 37202, 37206, 37250, 37246, 37203, 37207, 37251, 37247, 38789, 38935, 38936, 38922, 38792, 38938, 38939, 
38925, 38777, 38790, 38937, 38924
26238, 37203, 37207, 37251, 37247, 37204, 37208, 37252, 37248, 38792, 38938, 38939, 38925, 38795, 38941, 38942, 
38928, 38780, 38793, 38940, 38927
26239, 37204, 37208, 37252, 37248, 37205, 37209, 37253, 37249, 38795, 38941, 38942, 38928, 38798, 38944, 38945, 
38931, 38783, 38796, 38943, 38930
26240, 37205, 37209, 37253, 37249, 16047, 16048, 16059, 16058, 38798, 38944, 38945, 38931, 0, 0, 0, 
0, 38786, 38799, 38946, 38933
26241, 5570, 5571, 5582, 5581, 37206, 37210, 37254, 37250, 0, 0, 0, 0, 38802, 38948, 38949, 
38935, 38787, 38800, 38947, 38934
26242, 37206, 37210, 37254, 37250, 37207, 37211, 37255, 37251, 38802, 38948, 38949, 38935, 38805, 38951, 38952, 
38938, 38790, 38803, 38950, 38937
26243, 37207, 37211, 37255, 37251, 37208, 37212, 37256, 37252, 38805, 38951, 38952, 38938, 38808, 38954, 38955, 
38941, 38793, 38806, 38953, 38940
26244, 37208, 37212, 37256, 37252, 37209, 37213, 37257, 37253, 38808, 38954, 38955, 38941, 38811, 38957, 38958, 
38944, 38796, 38809, 38956, 38943
26245, 37209, 37213, 37257, 37253, 16048, 16049, 16060, 16059, 38811, 38957, 38958, 38944, 0, 0, 0, 
0, 38799, 38812, 38959, 38946
26246, 5571, 5572, 5583, 5582, 37210, 37214, 37258, 37254, 0, 0, 0, 0, 38815, 38961, 38962, 
38948, 38800, 38813, 38960, 38947
26247, 37210, 37214, 37258, 37254, 37211, 37215, 37259, 37255, 38815, 38961, 38962, 38948, 38818, 38964, 38965, 
38951, 38803, 38816, 38963, 38950
26248, 37211, 37215, 37259, 37255, 37212, 37216, 37260, 37256, 38818, 38964, 38965, 38951, 38821, 38967, 38968, 
38954, 38806, 38819, 38966, 38953
26249, 37212, 37216, 37260, 37256, 37213, 37217, 37261, 37257, 38821, 38967, 38968, 38954, 38824, 38970, 38971, 
38957, 38809, 38822, 38969, 38956
26250, 37213, 37217, 37261, 37257, 16049, 16050, 16061, 16060, 38824, 38970, 38971, 38957, 0, 0, 0, 
0, 38812, 38825, 38972, 38959
26251, 5572, 5573, 5584, 5583, 37214, 37218, 37262, 37258, 0, 0, 0, 0, 38828, 38974, 38975, 
38961, 38813, 38826, 38973, 38960
26252, 37214, 37218, 37262, 37258, 37215, 37219, 37263, 37259, 38828, 38974, 38975, 38961, 38831, 38977, 38978, 
38964, 38816, 38829, 38976, 38963
26253, 37215, 37219, 37263, 37259, 37216, 37220, 37264, 37260, 38831, 38977, 38978, 38964, 38834, 38980, 38981, 
38967, 38819, 38832, 38979, 38966
26254, 37216, 37220, 37264, 37260, 37217, 37221, 37265, 37261, 38834, 38980, 38981, 38967, 38837, 38983, 38984, 
38970, 38822, 38835, 38982, 38969
26255, 37217, 37221, 37265, 37261, 16050, 16051, 16062, 16061, 38837, 38983, 38984, 38970, 0, 0, 0, 
0, 38825, 38838, 38985, 38972
26256, 5573, 5574, 5585, 5584, 37218, 37222, 37266, 37262, 0, 0, 0, 0, 38841, 38987, 38988, 
38974, 38826, 38839, 38986, 38973
26257, 37218, 37222, 37266, 37262, 37219, 37223, 37267, 37263, 38841, 38987, 38988, 38974, 38844, 38990, 38991, 
38977, 38829, 38842, 38989, 38976
26258, 37219, 37223, 37267, 37263, 37220, 37224, 37268, 37264, 38844, 38990, 38991, 38977, 38847, 38993, 38994, 
38980, 38832, 38845, 38992, 38979
26259, 37220, 37224, 37268, 37264, 37221, 37225, 37269, 37265, 38847, 38993, 38994, 38980, 38850, 38996, 38997, 
38983, 38835, 38848, 38995, 38982
26260, 37221, 37225, 37269, 37265, 16051, 16052, 16063, 16062, 38850, 38996, 38997, 38983, 0, 0, 0, 
0, 38838, 38851, 38998, 38985
26261, 5574, 585, 586, 5585, 37222, 15768, 15772, 37266, 0, 0, 0, 0, 38852, 0, 38999, 
38987, 38839, 0, 0, 38986
26262, 37222, 15768, 15772, 37266, 37223, 15769, 15773, 37267, 38852, 0, 38999, 38987, 38853, 0, 39000, 
38990, 38842, 0, 0, 38989
26263, 37223, 15769, 15773, 37267, 37224, 15770, 15774, 37268, 38853, 0, 39000, 38990, 38854, 0, 39001, 
38993, 38845, 0, 0, 38992
26264, 37224, 15770, 15774, 37268, 37225, 15771, 15775, 37269, 38854, 0, 39001, 38993, 38855, 0, 39002, 
38996, 38848, 0, 0, 38995
26265, 37225, 15771, 15775, 37269, 16052, 2041, 2042, 16063, 38855, 0, 39002, 38996, 0, 0, 0, 
0, 38851, 0, 0, 38998
26266, 548, 5575, 5586, 549, 15322, 37226, 37270, 15326, 0, 0, 0, 0, 38858, 39004, 39005, 
15453, 15445, 38856, 39003, 15454
26267, 15322, 37226, 37270, 15326, 15323, 37227, 37271, 15327, 38858, 39004, 39005, 15453, 38861, 39007, 39008, 
15455, 15447, 38859, 39006, 15456
26268, 15323, 37227, 37271, 15327, 15324, 37228, 37272, 15328, 38861, 39007, 39008, 15455, 38864, 39010, 39011, 
15457, 15449, 38862, 39009, 15458
26269, 15324, 37228, 37272, 15328, 15325, 37229, 37273, 15329, 38864, 39010, 39011, 15457, 38867, 39013, 39014, 
15459, 15451, 38865, 39012, 15460
26270, 15325, 37229, 37273, 15329, 2000, 16053, 16064, 2001, 38867, 39013, 39014, 15459, 0, 0, 0, 
0, 15452, 38868, 39015, 15461
26271, 5575, 5576, 5587, 5586, 37226, 37230, 37274, 37270, 0, 0, 0, 0, 38871, 39017, 39018, 
39004, 38856, 38869, 39016, 39003
26272, 37226, 37230, 37274, 37270, 37227, 37231, 37275, 37271, 38871, 39017, 39018, 39004, 38874, 39020, 39021, 
39007, 38859, 38872, 39019, 39006
26273, 37227, 37231, 37275, 37271, 37228, 37232, 37276, 37272, 38874, 39020, 39021, 39007, 38877, 39023, 39024, 
39010, 38862, 38875, 39022, 39009
26274, 37228, 37232, 37276, 37272, 37229, 37233, 37277, 37273, 38877, 39023, 39024, 39010, 38880, 39026, 39027, 
39013, 38865, 38878, 39025, 39012
26275, 37229, 37233, 37277, 37273, 16053, 16054, 16065, 16064, 38880, 39026, 39027, 39013, 0, 0, 0, 
0, 38868, 38881, 39028, 39015
26276, 5576, 5577, 5588, 5587, 37230, 37234, 37278, 37274, 0, 0, 0, 0, 38884, 39030, 39031, 
39017, 38869, 38882, 39029, 39016
26277, 37230, 37234, 37278, 37274, 37231, 37235, 37279, 37275, 38884, 39030, 39031, 39017, 38887, 39033, 39034, 
39020, 38872, 38885, 39032, 39019
26278, 37231, 37235, 37279, 37275, 37232, 37236, 37280, 37276, 38887, 39033, 39034, 39020, 38890, 39036, 39037, 
39023, 38875, 38888, 39035, 39022
26279, 37232, 37236, 37280, 37276, 37233, 37237, 37281, 37277, 38890, 39036, 39037, 39023, 38893, 39039, 39040, 
39026, 38878, 38891, 39038, 39025
26280, 37233, 37237, 37281, 37277, 16054, 16055, 16066, 16065, 38893, 39039, 39040, 39026, 0, 0, 0, 
0, 38881, 38894, 39041, 39028
26281, 5577, 5578, 5589, 5588, 37234, 37238, 37282, 37278, 0, 0, 0, 0, 38897, 39043, 39044, 
39030, 38882, 38895, 39042, 39029
26282, 37234, 37238, 37282, 37278, 37235, 37239, 37283, 37279, 38897, 39043, 39044, 39030, 38900, 39046, 39047, 
39033, 38885, 38898, 39045, 39032
26283, 37235, 37239, 37283, 37279, 37236, 37240, 37284, 37280, 38900, 39046, 39047, 39033, 38903, 39049, 39050, 
39036, 38888, 38901, 39048, 39035
26284, 37236, 37240, 37284, 37280, 37237, 37241, 37285, 37281, 38903, 39049, 39050, 39036, 38906, 39052, 39053, 
39039, 38891, 38904, 39051, 39038
26285, 37237, 37241, 37285, 37281, 16055, 16056, 16067, 16066, 38906, 39052, 39053, 39039, 0, 0, 0, 
0, 38894, 38907, 39054, 39041
26286, 5578, 5579, 5590, 5589, 37238, 37242, 37286, 37282, 0, 0, 0, 0, 38910, 39056, 39057, 
39043, 38895, 38908, 39055, 39042
26287, 37238, 37242, 37286, 37282, 37239, 37243, 37287, 37283, 38910, 39056, 39057, 39043, 38913, 39059, 39060, 
39046, 38898, 38911, 39058, 39045
26288, 37239, 37243, 37287, 37283, 37240, 37244, 37288, 37284, 38913, 39059, 39060, 39046, 38916, 39062, 39063, 
39049, 38901, 38914, 39061, 39048
26289, 37240, 37244, 37288, 37284, 37241, 37245, 37289, 37285, 38916, 39062, 39063, 39049, 38919, 39065, 39066, 
39052, 38904, 38917, 39064, 39051
26290, 37241, 37245, 37289, 37285, 16056, 16057, 16068, 16067, 38919, 39065, 39066, 39052, 0, 0, 0, 
0, 38907, 38920, 39067, 39054
26291, 5579, 5580, 5591, 5590, 37242, 37246, 37290, 37286, 0, 0, 0, 0, 38923, 39069, 39070, 
39056, 38908, 38921, 39068, 39055
26292, 37242, 37246, 37290, 37286, 37243, 37247, 37291, 37287, 38923, 39069, 39070, 39056, 38926, 39072, 39073, 
39059, 38911, 38924, 39071, 39058
26293, 37243, 37247, 37291, 37287, 37244, 37248, 37292, 37288, 38926, 39072, 39073, 39059, 38929, 39075, 39076, 
39062, 38914, 38927, 39074, 39061
26294, 37244, 37248, 37292, 37288, 37245, 37249, 37293, 37289, 38929, 39075, 39076, 39062, 38932, 39078, 39079, 
39065, 38917, 38930, 39077, 39064
26295, 37245, 37249, 37293, 37289, 16057, 16058, 16069, 16068, 38932, 39078, 39079, 39065, 0, 0, 0, 
0, 38920, 38933, 39080, 39067
26296, 5580, 5581, 5592, 5591, 37246, 37250, 37294, 37290, 0, 0, 0, 0, 38936, 39082, 39083, 
39069, 38921, 38934, 39081, 39068
26297, 37246, 37250, 37294, 37290, 37247, 37251, 37295, 37291, 38936, 39082, 39083, 39069, 38939, 39085, 39086, 
39072, 38924, 38937, 39084, 39071
26298, 37247, 37251, 37295, 37291, 37248, 37252, 37296, 37292, 38939, 39085, 39086, 39072, 38942, 39088, 39089, 
39075, 38927, 38940, 39087, 39074
26299, 37248, 37252, 37296, 37292, 37249, 37253, 37297, 37293, 38942, 39088, 39089, 39075, 38945, 39091, 39092, 
39078, 38930, 38943, 39090, 39077
26300, 37249, 37253, 37297, 37293, 16058, 16059, 16070, 16069, 38945, 39091, 39092, 39078, 0, 0, 0, 
0, 38933, 38946, 39093, 39080
26301, 5581, 5582, 5593, 5592, 37250, 37254, 37298, 37294, 0, 0, 0, 0, 38949, 39095, 39096, 
39082, 38934, 38947, 39094, 39081
26302, 37250, 37254, 37298, 37294, 37251, 37255, 37299, 37295, 38949, 39095, 39096, 39082, 38952, 39098, 39099, 
39085, 38937, 38950, 39097, 39084
26303, 37251, 37255, 37299, 37295, 37252, 37256, 37300, 37296, 38952, 39098, 39099, 39085, 38955, 39101, 39102, 
39088, 38940, 38953, 39100, 39087
26304, 37252, 37256, 37300, 37296, 37253, 37257, 37301, 37297, 38955, 39101, 39102, 39088, 38958, 39104, 39105, 
39091, 38943, 38956, 39103, 39090
26305, 37253, 37257, 37301, 37297, 16059, 16060, 16071, 16070, 38958, 39104, 39105, 39091, 0, 0, 0, 
0, 38946, 38959, 39106, 39093
26306, 5582, 5583, 5594, 5593, 37254, 37258, 37302, 37298, 0, 0, 0, 0, 38962, 39108, 39109, 
39095, 38947, 38960, 39107, 39094
26307, 37254, 37258, 37302, 37298, 37255, 37259, 37303, 37299, 38962, 39108, 39109, 39095, 38965, 39111, 39112, 
39098, 38950, 38963, 39110, 39097
26308, 37255, 37259, 37303, 37299, 37256, 37260, 37304, 37300, 38965, 39111, 39112, 39098, 38968, 39114, 39115, 
39101, 38953, 38966, 39113, 39100
26309, 37256, 37260, 37304, 37300, 37257, 37261, 37305, 37301, 38968, 39114, 39115, 39101, 38971, 39117, 39118, 
39104, 38956, 38969, 39116, 39103
26310, 37257, 37261, 37305, 37301, 16060, 16061, 16072, 16071, 38971, 39117, 39118, 39104, 0, 0, 0, 
0, 38959, 38972, 39119, 39106
26311, 5583, 5584, 5595, 5594, 37258, 37262, 37306, 37302, 0, 0, 0, 0, 38975, 39121, 39122, 
39108, 38960, 38973, 39120, 39107
26312, 37258, 37262, 37306, 37302, 37259, 37263, 37307, 37303, 38975, 39121, 39122, 39108, 38978, 39124, 39125, 
39111, 38963, 38976, 39123, 39110
26313, 37259, 37263, 37307, 37303, 37260, 37264, 37308, 37304, 38978, 39124, 39125, 39111, 38981, 39127, 39128, 
39114, 38966, 38979, 39126, 39113
26314, 37260, 37264, 37308, 37304, 37261, 37265, 37309, 37305, 38981, 39127, 39128, 39114, 38984, 39130, 39131, 
39117, 38969, 38982, 39129, 39116
26315, 37261, 37265, 37309, 37305, 16061, 16062, 16073, 16072, 38984, 39130, 39131, 39117, 0, 0, 0, 
0, 38972, 38985, 39132, 39119
26316, 5584, 5585, 5596, 5595, 37262, 37266, 37310, 37306, 0, 0, 0, 0, 38988, 39134, 39135, 
39121, 38973, 38986, 39133, 39120
26317, 37262, 37266, 37310, 37306, 37263, 37267, 37311, 37307, 38988, 39134, 39135, 39121, 38991, 39137, 39138, 
39124, 38976, 38989, 39136, 39123
26318, 37263, 37267, 37311, 37307, 37264, 37268, 37312, 37308, 38991, 39137, 39138, 39124, 38994, 39140, 39141, 
39127, 38979, 38992, 39139, 39126
26319, 37264, 37268, 37312, 37308, 37265, 37269, 37313, 37309, 38994, 39140, 39141, 39127, 38997, 39143, 39144, 
39130, 38982, 38995, 39142, 39129
26320, 37265, 37269, 37313, 37309, 16062, 16063, 16074, 16073, 38997, 39143, 39144, 39130, 0, 0, 0, 
0, 38985, 38998, 39145, 39132
26321, 5585, 586, 587, 5596, 37266, 15772, 15776, 37310, 0, 0, 0, 0, 38999, 0, 39146, 
39134, 38986, 0, 0, 39133
26322, 37266, 15772, 15776, 37310, 37267, 15773, 15777, 37311, 38999, 0, 39146, 39134, 39000, 0, 39147, 
39137, 38989, 0, 0, 39136
26323, 37267, 15773, 15777, 37311, 37268, 15774, 15778, 37312, 39000, 0, 39147, 39137, 39001, 0, 39148, 
39140, 38992, 0, 0, 39139
26324, 37268, 15774, 15778, 37312, 37269, 15775, 15779, 37313, 39001, 0, 39148, 39140, 39002, 0, 39149, 
39143, 38995, 0, 0, 39142
26325, 37269, 15775, 15779, 37313, 16063, 2042, 2043, 16074, 39002, 0, 39149, 39143, 0, 0, 0, 
0, 38998, 0, 0, 39145
26326, 549, 5586, 5597, 550, 15326, 37270, 37314, 15330, 0, 0, 0, 0, 39005, 39151, 39152, 
15462, 15454, 39003, 39150, 15463
26327, 15326, 37270, 37314, 15330, 15327, 37271, 37315, 15331, 39005, 39151, 39152, 15462, 39008, 39154, 39155, 
15464, 15456, 39006, 39153, 15465
26328, 15327, 37271, 37315, 15331, 15328, 37272, 37316, 15332, 39008, 39154, 39155, 15464, 39011, 39157, 39158, 
15466, 15458, 39009, 39156, 15467
26329, 15328, 37272, 37316, 15332, 15329, 37273, 37317, 15333, 39011, 39157, 39158, 15466, 39014, 39160, 39161, 
15468, 15460, 39012, 39159, 15469
26330, 15329, 37273, 37317, 15333, 2001, 16064, 16075, 2002, 39014, 39160, 39161, 15468, 0, 0, 0, 
0, 15461, 39015, 39162, 15470
26331, 5586, 5587, 5598, 5597, 37270, 37274, 37318, 37314, 0, 0, 0, 0, 39018, 39164, 39165, 
39151, 39003, 39016, 39163, 39150
26332, 37270, 37274, 37318, 37314, 37271, 37275, 37319, 37315, 39018, 39164, 39165, 39151, 39021, 39167, 39168, 
39154, 39006, 39019, 39166, 39153
26333, 37271, 37275, 37319, 37315, 37272, 37276, 37320, 37316, 39021, 39167, 39168, 39154, 39024, 39170, 39171, 
39157, 39009, 39022, 39169, 39156
26334, 37272, 37276, 37320, 37316, 37273, 37277, 37321, 37317, 39024, 39170, 39171, 39157, 39027, 39173, 39174, 
39160, 39012, 39025, 39172, 39159
26335, 37273, 37277, 37321, 37317, 16064, 16065, 16076, 16075, 39027, 39173, 39174, 39160, 0, 0, 0, 
0, 39015, 39028, 39175, 39162
26336, 5587, 5588, 5599, 5598, 37274, 37278, 37322, 37318, 0, 0, 0, 0, 39031, 39177, 39178, 
39164, 39016, 39029, 39176, 39163
26337, 37274, 37278, 37322, 37318, 37275, 37279, 37323, 37319, 39031, 39177, 39178, 39164, 39034, 39180, 39181, 
39167, 39019, 39032, 39179, 39166
26338, 37275, 37279, 37323, 37319, 37276, 37280, 37324, 37320, 39034, 39180, 39181, 39167, 39037, 39183, 39184, 
39170, 39022, 39035, 39182, 39169
26339, 37276, 37280, 37324, 37320, 37277, 37281, 37325, 37321, 39037, 39183, 39184, 39170, 39040, 39186, 39187, 
39173, 39025, 39038, 39185, 39172
26340, 37277, 37281, 37325, 37321, 16065, 16066, 16077, 16076, 39040, 39186, 39187, 39173, 0, 0, 0, 
0, 39028, 39041, 39188, 39175
26341, 5588, 5589, 5600, 5599, 37278, 37282, 37326, 37322, 0, 0, 0, 0, 39044, 39190, 39191, 
39177, 39029, 39042, 39189, 39176
26342, 37278, 37282, 37326, 37322, 37279, 37283, 37327, 37323, 39044, 39190, 39191, 39177, 39047, 39193, 39194, 
39180, 39032, 39045, 39192, 39179
26343, 37279, 37283, 37327, 37323, 37280, 37284, 37328, 37324, 39047, 39193, 39194, 39180, 39050, 39196, 39197, 
39183, 39035, 39048, 39195, 39182
26344, 37280, 37284, 37328, 37324, 37281, 37285, 37329, 37325, 39050, 39196, 39197, 39183, 39053, 39199, 39200, 
39186, 39038, 39051, 39198, 39185
26345, 37281, 37285, 37329, 37325, 16066, 16067, 16078, 16077, 39053, 39199, 39200, 39186, 0, 0, 0, 
0, 39041, 39054, 39201, 39188
26346, 5589, 5590, 5601, 5600, 37282, 37286, 37330, 37326, 0, 0, 0, 0, 39057, 39203, 39204, 
39190, 39042, 39055, 39202, 39189
26347, 37282, 37286, 37330, 37326, 37283, 37287, 37331, 37327, 39057, 39203, 39204, 39190, 39060, 39206, 39207, 
39193, 39045, 39058, 39205, 39192
26348, 37283, 37287, 37331, 37327, 37284, 37288, 37332, 37328, 39060, 39206, 39207, 39193, 39063, 39209, 39210, 
39196, 39048, 39061, 39208, 39195
26349, 37284, 37288, 37332, 37328, 37285, 37289, 37333, 37329, 39063, 39209, 39210, 39196, 39066, 39212, 39213, 
39199, 39051, 39064, 39211, 39198
26350, 37285, 37289, 37333, 37329, 16067, 16068, 16079, 16078, 39066, 39212, 39213, 39199, 0, 0, 0, 
0, 39054, 39067, 39214, 39201
26351, 5590, 5591, 5602, 5601, 37286, 37290, 37334, 37330, 0, 0, 0, 0, 39070, 39216, 39217, 
39203, 39055, 39068, 39215, 39202
26352, 37286, 37290, 37334, 37330, 37287, 37291, 37335, 37331, 39070, 39216, 39217, 39203, 39073, 39219, 39220, 
39206, 39058, 39071, 39218, 39205
26353, 37287, 37291, 37335, 37331, 37288, 37292, 37336, 37332, 39073, 39219, 39220, 39206, 39076, 39222, 39223, 
39209, 39061, 39074, 39221, 39208
26354, 37288, 37292, 37336, 37332, 37289, 37293, 37337, 37333, 39076, 39222, 39223, 39209, 39079, 39225, 39226, 
39212, 39064, 39077, 39224, 39211
26355, 37289, 37293, 37337, 37333, 16068, 16069, 16080, 16079, 39079, 39225, 39226, 39212, 0, 0, 0, 
0, 39067, 39080, 39227, 39214
26356, 5591, 5592, 5603, 5602, 37290, 37294, 37338, 37334, 0, 0, 0, 0, 39083, 39229, 39230, 
39216, 39068, 39081, 39228, 39215
26357, 37290, 37294, 37338, 37334, 37291, 37295, 37339, 37335, 39083, 39229, 39230, 39216, 39086, 39232, 39233, 
39219, 39071, 39084, 39231, 39218
26358, 37291, 37295, 37339, 37335, 37292, 37296, 37340, 37336, 39086, 39232, 39233, 39219, 39089, 39235, 39236, 
39222, 39074, 39087, 39234, 39221
26359, 37292, 37296, 37340, 37336, 37293, 37297, 37341, 37337, 39089, 39235, 39236, 39222, 39092, 39238, 39239, 
39225, 39077, 39090, 39237, 39224
26360, 37293, 37297, 37341, 37337, 16069, 16070, 16081, 16080, 39092, 39238, 39239, 39225, 0, 0, 0, 
0, 39080, 39093, 39240, 39227
26361, 5592, 5593, 5604, 5603, 37294, 37298, 37342, 37338, 0, 0, 0, 0, 39096, 39242, 39243, 
39229, 39081, 39094, 39241, 39228
26362, 37294, 37298, 37342, 37338, 37295, 37299, 37343, 37339, 39096, 39242, 39243, 39229, 39099, 39245, 39246, 
39232, 39084, 39097, 39244, 39231
26363, 37295, 37299, 37343, 37339, 37296, 37300, 37344, 37340, 39099, 39245, 39246, 39232, 39102, 39248, 39249, 
39235, 39087, 39100, 39247, 39234
26364, 37296, 37300, 37344, 37340, 37297, 37301, 37345, 37341, 39102, 39248, 39249, 39235, 39105, 39251, 39252, 
39238, 39090, 39103, 39250, 39237
26365, 37297, 37301, 37345, 37341, 16070, 16071, 16082, 16081, 39105, 39251, 39252, 39238, 0, 0, 0, 
0, 39093, 39106, 39253, 39240
26366, 5593, 5594, 5605, 5604, 37298, 37302, 37346, 37342, 0, 0, 0, 0, 39109, 39255, 39256, 
39242, 39094, 39107, 39254, 39241
26367, 37298, 37302, 37346, 37342, 37299, 37303, 37347, 37343, 39109, 39255, 39256, 39242, 39112, 39258, 39259, 
39245, 39097, 39110, 39257, 39244
26368, 37299, 37303, 37347, 37343, 37300, 37304, 37348, 37344, 39112, 39258, 39259, 39245, 39115, 39261, 39262, 
39248, 39100, 39113, 39260, 39247
26369, 37300, 37304, 37348, 37344, 37301, 37305, 37349, 37345, 39115, 39261, 39262, 39248, 39118, 39264, 39265, 
39251, 39103, 39116, 39263, 39250
26370, 37301, 37305, 37349, 37345, 16071, 16072, 16083, 16082, 39118, 39264, 39265, 39251, 0, 0, 0, 
0, 39106, 39119, 39266, 39253
26371, 5594, 5595, 5606, 5605, 37302, 37306, 37350, 37346, 0, 0, 0, 0, 39122, 39268, 39269, 
39255, 39107, 39120, 39267, 39254
26372, 37302, 37306, 37350, 37346, 37303, 37307, 37351, 37347, 39122, 39268, 39269, 39255, 39125, 39271, 39272, 
39258, 39110, 39123, 39270, 39257
26373, 37303, 37307, 37351, 37347, 37304, 37308, 37352, 37348, 39125, 39271, 39272, 39258, 39128, 39274, 39275, 
39261, 39113, 39126, 39273, 39260
26374, 37304, 37308, 37352, 37348, 37305, 37309, 37353, 37349, 39128, 39274, 39275, 39261, 39131, 39277, 39278, 
39264, 39116, 39129, 39276, 39263
26375, 37305, 37309, 37353, 37349, 16072, 16073, 16084, 16083, 39131, 39277, 39278, 39264, 0, 0, 0, 
0, 39119, 39132, 39279, 39266
26376, 5595, 5596, 5607, 5606, 37306, 37310, 37354, 37350, 0, 0, 0, 0, 39135, 39281, 39282, 
39268, 39120, 39133, 39280, 39267
26377, 37306, 37310, 37354, 37350, 37307, 37311, 37355, 37351, 39135, 39281, 39282, 39268, 39138, 39284, 39285, 
39271, 39123, 39136, 39283, 39270
26378, 37307, 37311, 37355, 37351, 37308, 37312, 37356, 37352, 39138, 39284, 39285, 39271, 39141, 39287, 39288, 
39274, 39126, 39139, 39286, 39273
26379, 37308, 37312, 37356, 37352, 37309, 37313, 37357, 37353, 39141, 39287, 39288, 39274, 39144, 39290, 39291, 
39277, 39129, 39142, 39289, 39276
26380, 37309, 37313, 37357, 37353, 16073, 16074, 16085, 16084, 39144, 39290, 39291, 39277, 0, 0, 0, 
0, 39132, 39145, 39292, 39279
26381, 5596, 587, 588, 5607, 37310, 15776, 15780, 37354, 0, 0, 0, 0, 39146, 0, 39293, 
39281, 39133, 0, 0, 39280
26382, 37310, 15776, 15780, 37354, 37311, 15777, 15781, 37355, 39146, 0, 39293, 39281, 39147, 0, 39294, 
39284, 39136, 0, 0, 39283
26383, 37311, 15777, 15781, 37355, 37312, 15778, 15782, 37356, 39147, 0, 39294, 39284, 39148, 0, 39295, 
39287, 39139, 0, 0, 39286
26384, 37312, 15778, 15782, 37356, 37313, 15779, 15783, 37357, 39148, 0, 39295, 39287, 39149, 0, 39296, 
39290, 39142, 0, 0, 39289
26385, 37313, 15779, 15783, 37357, 16074, 2043, 2044, 16085, 39149, 0, 39296, 39290, 0, 0, 0, 
0, 39145, 0, 0, 39292
26386, 550, 5597, 5608, 551, 15330, 37314, 37358, 15334, 0, 0, 0, 0, 39152, 39298, 39299, 
15471, 15463, 39150, 39297, 15472
26387, 15330, 37314, 37358, 15334, 15331, 37315, 37359, 15335, 39152, 39298, 39299, 15471, 39155, 39301, 39302, 
15473, 15465, 39153, 39300, 15474
26388, 15331, 37315, 37359, 15335, 15332, 37316, 37360, 15336, 39155, 39301, 39302, 15473, 39158, 39304, 39305, 
15475, 15467, 39156, 39303, 15476
26389, 15332, 37316, 37360, 15336, 15333, 37317, 37361, 15337, 39158, 39304, 39305, 15475, 39161, 39307, 39308, 
15477, 15469, 39159, 39306, 15478
26390, 15333, 37317, 37361, 15337, 2002, 16075, 16086, 2003, 39161, 39307, 39308, 15477, 0, 0, 0, 
0, 15470, 39162, 39309, 15479
26391, 5597, 5598, 5609, 5608, 37314, 37318, 37362, 37358, 0, 0, 0, 0, 39165, 39311, 39312, 
39298, 39150, 39163, 39310, 39297
26392, 37314, 37318, 37362, 37358, 37315, 37319, 37363, 37359, 39165, 39311, 39312, 39298, 39168, 39314, 39315, 
39301, 39153, 39166, 39313, 39300
26393, 37315, 37319, 37363, 37359, 37316, 37320, 37364, 37360, 39168, 39314, 39315, 39301, 39171, 39317, 39318, 
39304, 39156, 39169, 39316, 39303
26394, 37316, 37320, 37364, 37360, 37317, 37321, 37365, 37361, 39171, 39317, 39318, 39304, 39174, 39320, 39321, 
39307, 39159, 39172, 39319, 39306
26395, 37317, 37321, 37365, 37361, 16075, 16076, 16087, 16086, 39174, 39320, 39321, 39307, 0, 0, 0, 
0, 39162, 39175, 39322, 39309
26396, 5598, 5599, 5610, 5609, 37318, 37322, 37366, 37362, 0, 0, 0, 0, 39178, 39324, 39325, 
39311, 39163, 39176, 39323, 39310
26397, 37318, 37322, 37366, 37362, 37319, 37323, 37367, 37363, 39178, 39324, 39325, 39311, 39181, 39327, 39328, 
39314, 39166, 39179, 39326, 39313
26398, 37319, 37323, 37367, 37363, 37320, 37324, 37368, 37364, 39181, 39327, 39328, 39314, 39184, 39330, 39331, 
39317, 39169, 39182, 39329, 39316
26399, 37320, 37324, 37368, 37364, 37321, 37325, 37369, 37365, 39184, 39330, 39331, 39317, 39187, 39333, 39334, 
39320, 39172, 39185, 39332, 39319
26400, 37321, 37325, 37369, 37365, 16076, 16077, 16088, 16087, 39187, 39333, 39334, 39320, 0, 0, 0, 
0, 39175, 39188, 39335, 39322
26401, 5599, 5600, 5611, 5610, 37322, 37326, 37370, 37366, 0, 0, 0, 0, 39191, 39337, 39338, 
39324, 39176, 39189, 39336, 39323
26402, 37322, 37326, 37370, 37366, 37323, 37327, 37371, 37367, 39191, 39337, 39338, 39324, 39194, 39340, 39341, 
39327, 39179, 39192, 39339, 39326
26403, 37323, 37327, 37371, 37367, 37324, 37328, 37372, 37368, 39194, 39340, 39341, 39327, 39197, 39343, 39344, 
39330, 39182, 39195, 39342, 39329
26404, 37324, 37328, 37372, 37368, 37325, 37329, 37373, 37369, 39197, 39343, 39344, 39330, 39200, 39346, 39347, 
39333, 39185, 39198, 39345, 39332
26405, 37325, 37329, 37373, 37369, 16077, 16078, 16089, 16088, 39200, 39346, 39347, 39333, 0, 0, 0, 
0, 39188, 39201, 39348, 39335
26406, 5600, 5601, 5612, 5611, 37326, 37330, 37374, 37370, 0, 0, 0, 0, 39204, 39350, 39351, 
39337, 39189, 39202, 39349, 39336
26407, 37326, 37330, 37374, 37370, 37327, 37331, 37375, 37371, 39204, 39350, 39351, 39337, 39207, 39353, 39354, 
39340, 39192, 39205, 39352, 39339
26408, 37327, 37331, 37375, 37371, 37328, 37332, 37376, 37372, 39207, 39353, 39354, 39340, 39210, 39356, 39357, 
39343, 39195, 39208, 39355, 39342
26409, 37328, 37332, 37376, 37372, 37329, 37333, 37377, 37373, 39210, 39356, 39357, 39343, 39213, 39359, 39360, 
39346, 39198, 39211, 39358, 39345
26410, 37329, 37333, 37377, 37373, 16078, 16079, 16090, 16089, 39213, 39359, 39360, 39346, 0, 0, 0, 
0, 39201, 39214, 39361, 39348
26411, 5601, 5602, 5613, 5612, 37330, 37334, 37378, 37374, 0, 0, 0, 0, 39217, 39363, 39364, 
39350, 39202, 39215, 39362, 39349
26412, 37330, 37334, 37378, 37374, 37331, 37335, 37379, 37375, 39217, 39363, 39364, 39350, 39220, 39366, 39367, 
39353, 39205, 39218, 39365, 39352
26413, 37331, 37335, 37379, 37375, 37332, 37336, 37380, 37376, 39220, 39366, 39367, 39353, 39223, 39369, 39370, 
39356, 39208, 39221, 39368, 39355
26414, 37332, 37336, 37380, 37376, 37333, 37337, 37381, 37377, 39223, 39369, 39370, 39356, 39226, 39372, 39373, 
39359, 39211, 39224, 39371, 39358
26415, 37333, 37337, 37381, 37377, 16079, 16080, 16091, 16090, 39226, 39372, 39373, 39359, 0, 0, 0, 
0, 39214, 39227, 39374, 39361
26416, 5602, 5603, 5614, 5613, 37334, 37338, 37382, 37378, 0, 0, 0, 0, 39230, 39376, 39377, 
39363, 39215, 39228, 39375, 39362
26417, 37334, 37338, 37382, 37378, 37335, 37339, 37383, 37379, 39230, 39376, 39377, 39363, 39233, 39379, 39380, 
39366, 39218, 39231, 39378, 39365
26418, 37335, 37339, 37383, 37379, 37336, 37340, 37384, 37380, 39233, 39379, 39380, 39366, 39236, 39382, 39383, 
39369, 39221, 39234, 39381, 39368
26419, 37336, 37340, 37384, 37380, 37337, 37341, 37385, 37381, 39236, 39382, 39383, 39369, 39239, 39385, 39386, 
39372, 39224, 39237, 39384, 39371
26420, 37337, 37341, 37385, 37381, 16080, 16081, 16092, 16091, 39239, 39385, 39386, 39372, 0, 0, 0, 
0, 39227, 39240, 39387, 39374
26421, 5603, 5604, 5615, 5614, 37338, 37342, 37386, 37382, 0, 0, 0, 0, 39243, 39389, 39390, 
39376, 39228, 39241, 39388, 39375
26422, 37338, 37342, 37386, 37382, 37339, 37343, 37387, 37383, 39243, 39389, 39390, 39376, 39246, 39392, 39393, 
39379, 39231, 39244, 39391, 39378
26423, 37339, 37343, 37387, 37383, 37340, 37344, 37388, 37384, 39246, 39392, 39393, 39379, 39249, 39395, 39396, 
39382, 39234, 39247, 39394, 39381
26424, 37340, 37344, 37388, 37384, 37341, 37345, 37389, 37385, 39249, 39395, 39396, 39382, 39252, 39398, 39399, 
39385, 39237, 39250, 39397, 39384
26425, 37341, 37345, 37389, 37385, 16081, 16082, 16093, 16092, 39252, 39398, 39399, 39385, 0, 0, 0, 
0, 39240, 39253, 39400, 39387
26426, 5604, 5605, 5616, 5615, 37342, 37346, 37390, 37386, 0, 0, 0, 0, 39256, 39402, 39403, 
39389, 39241, 39254, 39401, 39388
26427, 37342, 37346, 37390, 37386, 37343, 37347, 37391, 37387, 39256, 39402, 39403, 39389, 39259, 39405, 39406, 
39392, 39244, 39257, 39404, 39391
26428, 37343, 37347, 37391, 37387, 37344, 37348, 37392, 37388, 39259, 39405, 39406, 39392, 39262, 39408, 39409, 
39395, 39247, 39260, 39407, 39394
26429, 37344, 37348, 37392, 37388, 37345, 37349, 37393, 37389, 39262, 39408, 39409, 39395, 39265, 39411, 39412, 
39398, 39250, 39263, 39410, 39397
26430, 37345, 37349, 37393, 37389, 16082, 16083, 16094, 16093, 39265, 39411, 39412, 39398, 0, 0, 0, 
0, 39253, 39266, 39413, 39400
26431, 5605, 5606, 5617, 5616, 37346, 37350, 37394, 37390, 0, 0, 0, 0, 39269, 39415, 39416, 
39402, 39254, 39267, 39414, 39401
26432, 37346, 37350, 37394, 37390, 37347, 37351, 37395, 37391, 39269, 39415, 39416, 39402, 39272, 39418, 39419, 
39405, 39257, 39270, 39417, 39404
26433, 37347, 37351, 37395, 37391, 37348, 37352, 37396, 37392, 39272, 39418, 39419, 39405, 39275, 39421, 39422, 
39408, 39260, 39273, 39420, 39407
26434, 37348, 37352, 37396, 37392, 37349, 37353, 37397, 37393, 39275, 39421, 39422, 39408, 39278, 39424, 39425, 
39411, 39263, 39276, 39423, 39410
26435, 37349, 37353, 37397, 37393, 16083, 16084, 16095, 16094, 39278, 39424, 39425, 39411, 0, 0, 0, 
0, 39266, 39279, 39426, 39413
26436, 5606, 5607, 5618, 5617, 37350, 37354, 37398, 37394, 0, 0, 0, 0, 39282, 39428, 39429, 
39415, 39267, 39280, 39427, 39414
26437, 37350, 37354, 37398, 37394, 37351, 37355, 37399, 37395, 39282, 39428, 39429, 39415, 39285, 39431, 39432, 
39418, 39270, 39283, 39430, 39417
26438, 37351, 37355, 37399, 37395, 37352, 37356, 37400, 37396, 39285, 39431, 39432, 39418, 39288, 39434, 39435, 
39421, 39273, 39286, 39433, 39420
26439, 37352, 37356, 37400, 37396, 37353, 37357, 37401, 37397, 39288, 39434, 39435, 39421, 39291, 39437, 39438, 
39424, 39276, 39289, 39436, 39423
26440, 37353, 37357, 37401, 37397, 16084, 16085, 16096, 16095, 39291, 39437, 39438, 39424, 0, 0, 0, 
0, 39279, 39292, 39439, 39426
26441, 5607, 588, 589, 5618, 37354, 15780, 15784, 37398, 0, 0, 0, 0, 39293, 0, 39440, 
39428, 39280, 0, 0, 39427
26442, 37354, 15780, 15784, 37398, 37355, 15781, 15785, 37399, 39293, 0, 39440, 39428, 39294, 0, 39441, 
39431, 39283, 0, 0, 39430
26443, 37355, 15781, 15785, 37399, 37356, 15782, 15786, 37400, 39294, 0, 39441, 39431, 39295, 0, 39442, 
39434, 39286, 0, 0, 39433
26444, 37356, 15782, 15786, 37400, 37357, 15783, 15787, 37401, 39295, 0, 39442, 39434, 39296, 0, 39443, 
39437, 39289, 0, 0, 39436
26445, 37357, 15783, 15787, 37401, 16085, 2044, 2045, 16096, 39296, 0, 39443, 39437, 0, 0, 0, 
0, 39292, 0, 0, 39439
26446, 551, 5608, 5619, 552, 15334, 37358, 37402, 15338, 0, 0, 0, 0, 39299, 39445, 39446, 
15480, 15472, 39297, 39444, 15481
26447, 15334, 37358, 37402, 15338, 15335, 37359, 37403, 15339, 39299, 39445, 39446, 15480, 39302, 39448, 39449, 
15482, 15474, 39300, 39447, 15483
26448, 15335, 37359, 37403, 15339, 15336, 37360, 37404, 15340, 39302, 39448, 39449, 15482, 39305, 39451, 39452, 
15484, 15476, 39303, 39450, 15485
26449, 15336, 37360, 37404, 15340, 15337, 37361, 37405, 15341, 39305, 39451, 39452, 15484, 39308, 39454, 39455, 
15486, 15478, 39306, 39453, 15487
26450, 15337, 37361, 37405, 15341, 2003, 16086, 16097, 2004, 39308, 39454, 39455, 15486, 0, 0, 0, 
0, 15479, 39309, 39456, 15488
26451, 5608, 5609, 5620, 5619, 37358, 37362, 37406, 37402, 0, 0, 0, 0, 39312, 39458, 39459, 
39445, 39297, 39310, 39457, 39444
26452, 37358, 37362, 37406, 37402, 37359, 37363, 37407, 37403, 39312, 39458, 39459, 39445, 39315, 39461, 39462, 
39448, 39300, 39313, 39460, 39447
26453, 37359, 37363, 37407, 37403, 37360, 37364, 37408, 37404, 39315, 39461, 39462, 39448, 39318, 39464, 39465, 
39451, 39303, 39316, 39463, 39450
26454, 37360, 37364, 37408, 37404, 37361, 37365, 37409, 37405, 39318, 39464, 39465, 39451, 39321, 39467, 39468, 
39454, 39306, 39319, 39466, 39453
26455, 37361, 37365, 37409, 37405, 16086, 16087, 16098, 16097, 39321, 39467, 39468, 39454, 0, 0, 0, 
0, 39309, 39322, 39469, 39456
26456, 5609, 5610, 5621, 5620, 37362, 37366, 37410, 37406, 0, 0, 0, 0, 39325, 39471, 39472, 
39458, 39310, 39323, 39470, 39457
26457, 37362, 37366, 37410, 37406, 37363, 37367, 37411, 37407, 39325, 39471, 39472, 39458, 39328, 39474, 39475, 
39461, 39313, 39326, 39473, 39460
26458, 37363, 37367, 37411, 37407, 37364, 37368, 37412, 37408, 39328, 39474, 39475, 39461, 39331, 39477, 39478, 
39464, 39316, 39329, 39476, 39463
26459, 37364, 37368, 37412, 37408, 37365, 37369, 37413, 37409, 39331, 39477, 39478, 39464, 39334, 39480, 39481, 
39467, 39319, 39332, 39479, 39466
26460, 37365, 37369, 37413, 37409, 16087, 16088, 16099, 16098, 39334, 39480, 39481, 39467, 0, 0, 0, 
0, 39322, 39335, 39482, 39469
26461, 5610, 5611, 5622, 5621, 37366, 37370, 37414, 37410, 0, 0, 0, 0, 39338, 39484, 39485, 
39471, 39323, 39336, 39483, 39470
26462, 37366, 37370, 37414, 37410, 37367, 37371, 37415, 37411, 39338, 39484, 39485, 39471, 39341, 39487, 39488, 
39474, 39326, 39339, 39486, 39473
26463, 37367, 37371, 37415, 37411, 37368, 37372, 37416, 37412, 39341, 39487, 39488, 39474, 39344, 39490, 39491, 
39477, 39329, 39342, 39489, 39476
26464, 37368, 37372, 37416, 37412, 37369, 37373, 37417, 37413, 39344, 39490, 39491, 39477, 39347, 39493, 39494, 
39480, 39332, 39345, 39492, 39479
26465, 37369, 37373, 37417, 37413, 16088, 16089, 16100, 16099, 39347, 39493, 39494, 39480, 0, 0, 0, 
0, 39335, 39348, 39495, 39482
26466, 5611, 5612, 5623, 5622, 37370, 37374, 37418, 37414, 0, 0, 0, 0, 39351, 39497, 39498, 
39484, 39336, 39349, 39496, 39483
26467, 37370, 37374, 37418, 37414, 37371, 37375, 37419, 37415, 39351, 39497, 39498, 39484, 39354, 39500, 39501, 
39487, 39339, 39352, 39499, 39486
26468, 37371, 37375, 37419, 37415, 37372, 37376, 37420, 37416, 39354, 39500, 39501, 39487, 39357, 39503, 39504, 
39490, 39342, 39355, 39502, 39489
26469, 37372, 37376, 37420, 37416, 37373, 37377, 37421, 37417, 39357, 39503, 39504, 39490, 39360, 39506, 39507, 
39493, 39345, 39358, 39505, 39492
26470, 37373, 37377, 37421, 37417, 16089, 16090, 16101, 16100, 39360, 39506, 39507, 39493, 0, 0, 0, 
0, 39348, 39361, 39508, 39495
26471, 5612, 5613, 5624, 5623, 37374, 37378, 37422, 37418, 0, 0, 0, 0, 39364, 39510, 39511, 
39497, 39349, 39362, 39509, 39496
26472, 37374, 37378, 37422, 37418, 37375, 37379, 37423, 37419, 39364, 39510, 39511, 39497, 39367, 39513, 39514, 
39500, 39352, 39365, 39512, 39499
26473, 37375, 37379, 37423, 37419, 37376, 37380, 37424, 37420, 39367, 39513, 39514, 39500, 39370, 39516, 39517, 
39503, 39355, 39368, 39515, 39502
26474, 37376, 37380, 37424, 37420, 37377, 37381, 37425, 37421, 39370, 39516, 39517, 39503, 39373, 39519, 39520, 
39506, 39358, 39371, 39518, 39505
26475, 37377, 37381, 37425, 37421, 16090, 16091, 16102, 16101, 39373, 39519, 39520, 39506, 0, 0, 0, 
0, 39361, 39374, 39521, 39508
26476, 5613, 5614, 5625, 5624, 37378, 37382, 37426, 37422, 0, 0, 0, 0, 39377, 39523, 39524, 
39510, 39362, 39375, 39522, 39509
26477, 37378, 37382, 37426, 37422, 37379, 37383, 37427, 37423, 39377, 39523, 39524, 39510, 39380, 39526, 39527, 
39513, 39365, 39378, 39525, 39512
26478, 37379, 37383, 37427, 37423, 37380, 37384, 37428, 37424, 39380, 39526, 39527, 39513, 39383, 39529, 39530, 
39516, 39368, 39381, 39528, 39515
26479, 37380, 37384, 37428, 37424, 37381, 37385, 37429, 37425, 39383, 39529, 39530, 39516, 39386, 39532, 39533, 
39519, 39371, 39384, 39531, 39518
26480, 37381, 37385, 37429, 37425, 16091, 16092, 16103, 16102, 39386, 39532, 39533, 39519, 0, 0, 0, 
0, 39374, 39387, 39534, 39521
26481, 5614, 5615, 5626, 5625, 37382, 37386, 37430, 37426, 0, 0, 0, 0, 39390, 39536, 39537, 
39523, 39375, 39388, 39535, 39522
26482, 37382, 37386, 37430, 37426, 37383, 37387, 37431, 37427, 39390, 39536, 39537, 39523, 39393, 39539, 39540, 
39526, 39378, 39391, 39538, 39525
26483, 37383, 37387, 37431, 37427, 37384, 37388, 37432, 37428, 39393, 39539, 39540, 39526, 39396, 39542, 39543, 
39529, 39381, 39394, 39541, 39528
26484, 37384, 37388, 37432, 37428, 37385, 37389, 37433, 37429, 39396, 39542, 39543, 39529, 39399, 39545, 39546, 
39532, 39384, 39397, 39544, 39531
26485, 37385, 37389, 37433, 37429, 16092, 16093, 16104, 16103, 39399, 39545, 39546, 39532, 0, 0, 0, 
0, 39387, 39400, 39547, 39534
26486, 5615, 5616, 5627, 5626, 37386, 37390, 37434, 37430, 0, 0, 0, 0, 39403, 39549, 39550, 
39536, 39388, 39401, 39548, 39535
26487, 37386, 37390, 37434, 37430, 37387, 37391, 37435, 37431, 39403, 39549, 39550, 39536, 39406, 39552, 39553, 
39539, 39391, 39404, 39551, 39538
26488, 37387, 37391, 37435, 37431, 37388, 37392, 37436, 37432, 39406, 39552, 39553, 39539, 39409, 39555, 39556, 
39542, 39394, 39407, 39554, 39541
26489, 37388, 37392, 37436, 37432, 37389, 37393, 37437, 37433, 39409, 39555, 39556, 39542, 39412, 39558, 39559, 
39545, 39397, 39410, 39557, 39544
26490, 37389, 37393, 37437, 37433, 16093, 16094, 16105, 16104, 39412, 39558, 39559, 39545, 0, 0, 0, 
0, 39400, 39413, 39560, 39547
26491, 5616, 5617, 5628, 5627, 37390, 37394, 37438, 37434, 0, 0, 0, 0, 39416, 39562, 39563, 
39549, 39401, 39414, 39561, 39548
26492, 37390, 37394, 37438, 37434, 37391, 37395, 37439, 37435, 39416, 39562, 39563, 39549, 39419, 39565, 39566, 
39552, 39404, 39417, 39564, 39551
26493, 37391, 37395, 37439, 37435, 37392, 37396, 37440, 37436, 39419, 39565, 39566, 39552, 39422, 39568, 39569, 
39555, 39407, 39420, 39567, 39554
26494, 37392, 37396, 37440, 37436, 37393, 37397, 37441, 37437, 39422, 39568, 39569, 39555, 39425, 39571, 39572, 
39558, 39410, 39423, 39570, 39557
26495, 37393, 37397, 37441, 37437, 16094, 16095, 16106, 16105, 39425, 39571, 39572, 39558, 0, 0, 0, 
0, 39413, 39426, 39573, 39560
26496, 5617, 5618, 5629, 5628, 37394, 37398, 37442, 37438, 0, 0, 0, 0, 39429, 39575, 39576, 
39562, 39414, 39427, 39574, 39561
26497, 37394, 37398, 37442, 37438, 37395, 37399, 37443, 37439, 39429, 39575, 39576, 39562, 39432, 39578, 39579, 
39565, 39417, 39430, 39577, 39564
26498, 37395, 37399, 37443, 37439, 37396, 37400, 37444, 37440, 39432, 39578, 39579, 39565, 39435, 39581, 39582, 
39568, 39420, 39433, 39580, 39567
26499, 37396, 37400, 37444, 37440, 37397, 37401, 37445, 37441, 39435, 39581, 39582, 39568, 39438, 39584, 39585, 
39571, 39423, 39436, 39583, 39570
26500, 37397, 37401, 37445, 37441, 16095, 16096, 16107, 16106, 39438, 39584, 39585, 39571, 0, 0, 0, 
0, 39426, 39439, 39586, 39573
26501, 5618, 589, 590, 5629, 37398, 15784, 15788, 37442, 0, 0, 0, 0, 39440, 0, 39587, 
39575, 39427, 0, 0, 39574
26502, 37398, 15784, 15788, 37442, 37399, 15785, 15789, 37443, 39440, 0, 39587, 39575, 39441, 0, 39588, 
39578, 39430, 0, 0, 39577
26503, 37399, 15785, 15789, 37443, 37400, 15786, 15790, 37444, 39441, 0, 39588, 39578, 39442, 0, 39589, 
39581, 39433, 0, 0, 39580
26504, 37400, 15786, 15790, 37444, 37401, 15787, 15791, 37445, 39442, 0, 39589, 39581, 39443, 0, 39590, 
39584, 39436, 0, 0, 39583
26505, 37401, 15787, 15791, 37445, 16096, 2045, 2046, 16107, 39443, 0, 39590, 39584, 0, 0, 0, 
0, 39439, 0, 0, 39586
26506, 552, 5619, 5630, 553, 15338, 37402, 37446, 15342, 0, 0, 0, 0, 39446, 39592, 39593, 
15489, 15481, 39444, 39591, 15490
26507, 15338, 37402, 37446, 15342, 15339, 37403, 37447, 15343, 39446, 39592, 39593, 15489, 39449, 39595, 39596, 
15491, 15483, 39447, 39594, 15492
26508, 15339, 37403, 37447, 15343, 15340, 37404, 37448, 15344, 39449, 39595, 39596, 15491, 39452, 39598, 39599, 
15493, 15485, 39450, 39597, 15494
26509, 15340, 37404, 37448, 15344, 15341, 37405, 37449, 15345, 39452, 39598, 39599, 15493, 39455, 39601, 39602, 
15495, 15487, 39453, 39600, 15496
26510, 15341, 37405, 37449, 15345, 2004, 16097, 16108, 2005, 39455, 39601, 39602, 15495, 0, 0, 0, 
0, 15488, 39456, 39603, 15497
26511, 5619, 5620, 5631, 5630, 37402, 37406, 37450, 37446, 0, 0, 0, 0, 39459, 39605, 39606, 
39592, 39444, 39457, 39604, 39591
26512, 37402, 37406, 37450, 37446, 37403, 37407, 37451, 37447, 39459, 39605, 39606, 39592, 39462, 39608, 39609, 
39595, 39447, 39460, 39607, 39594
26513, 37403, 37407, 37451, 37447, 37404, 37408, 37452, 37448, 39462, 39608, 39609, 39595, 39465, 39611, 39612, 
39598, 39450, 39463, 39610, 39597
26514, 37404, 37408, 37452, 37448, 37405, 37409, 37453, 37449, 39465, 39611, 39612, 39598, 39468, 39614, 39615, 
39601, 39453, 39466, 39613, 39600
26515, 37405, 37409, 37453, 37449, 16097, 16098, 16109, 16108, 39468, 39614, 39615, 39601, 0, 0, 0, 
0, 39456, 39469, 39616, 39603
26516, 5620, 5621, 5632, 5631, 37406, 37410, 37454, 37450, 0, 0, 0, 0, 39472, 39618, 39619, 
39605, 39457, 39470, 39617, 39604
26517, 37406, 37410, 37454, 37450, 37407, 37411, 37455, 37451, 39472, 39618, 39619, 39605, 39475, 39621, 39622, 
39608, 39460, 39473, 39620, 39607
26518, 37407, 37411, 37455, 37451, 37408, 37412, 37456, 37452, 39475, 39621, 39622, 39608, 39478, 39624, 39625, 
39611, 39463, 39476, 39623, 39610
26519, 37408, 37412, 37456, 37452, 37409, 37413, 37457, 37453, 39478, 39624, 39625, 39611, 39481, 39627, 39628, 
39614, 39466, 39479, 39626, 39613
26520, 37409, 37413, 37457, 37453, 16098, 16099, 16110, 16109, 39481, 39627, 39628, 39614, 0, 0, 0, 
0, 39469, 39482, 39629, 39616
26521, 5621, 5622, 5633, 5632, 37410, 37414, 37458, 37454, 0, 0, 0, 0, 39485, 39631, 39632, 
39618, 39470, 39483, 39630, 39617
26522, 37410, 37414, 37458, 37454, 37411, 37415, 37459, 37455, 39485, 39631, 39632, 39618, 39488, 39634, 39635, 
39621, 39473, 39486, 39633, 39620
26523, 37411, 37415, 37459, 37455, 37412, 37416, 37460, 37456, 39488, 39634, 39635, 39621, 39491, 39637, 39638, 
39624, 39476, 39489, 39636, 39623
26524, 37412, 37416, 37460, 37456, 37413, 37417, 37461, 37457, 39491, 39637, 39638, 39624, 39494, 39640, 39641, 
39627, 39479, 39492, 39639, 39626
26525, 37413, 37417, 37461, 37457, 16099, 16100, 16111, 16110, 39494, 39640, 39641, 39627, 0, 0, 0, 
0, 39482, 39495, 39642, 39629
26526, 5622, 5623, 5634, 5633, 37414, 37418, 37462, 37458, 0, 0, 0, 0, 39498, 39644, 39645, 
39631, 39483, 39496, 39643, 39630
26527, 37414, 37418, 37462, 37458, 37415, 37419, 37463, 37459, 39498, 39644, 39645, 39631, 39501, 39647, 39648, 
39634, 39486, 39499, 39646, 39633
26528, 37415, 37419, 37463, 37459, 37416, 37420, 37464, 37460, 39501, 39647, 39648, 39634, 39504, 39650, 39651, 
39637, 39489, 39502, 39649, 39636
26529, 37416, 37420, 37464, 37460, 37417, 37421, 37465, 37461, 39504, 39650, 39651, 39637, 39507, 39653, 39654, 
39640, 39492, 39505, 39652, 39639
26530, 37417, 37421, 37465, 37461, 16100, 16101, 16112, 16111, 39507, 39653, 39654, 39640, 0, 0, 0, 
0, 39495, 39508, 39655, 39642
26531, 5623, 5624, 5635, 5634, 37418, 37422, 37466, 37462, 0, 0, 0, 0, 39511, 39657, 39658, 
39644, 39496, 39509, 39656, 39643
26532, 37418, 37422, 37466, 37462, 37419, 37423, 37467, 37463, 39511, 39657, 39658, 39644, 39514, 39660, 39661, 
39647, 39499, 39512, 39659, 39646
26533, 37419, 37423, 37467, 37463, 37420, 37424, 37468, 37464, 39514, 39660, 39661, 39647, 39517, 39663, 39664, 
39650, 39502, 39515, 39662, 39649
26534, 37420, 37424, 37468, 37464, 37421, 37425, 37469, 37465, 39517, 39663, 39664, 39650, 39520, 39666, 39667, 
39653, 39505, 39518, 39665, 39652
26535, 37421, 37425, 37469, 37465, 16101, 16102, 16113, 16112, 39520, 39666, 39667, 39653, 0, 0, 0, 
0, 39508, 39521, 39668, 39655
26536, 5624, 5625, 5636, 5635, 37422, 37426, 37470, 37466, 0, 0, 0, 0, 39524, 39670, 39671, 
39657, 39509, 39522, 39669, 39656
26537, 37422, 37426, 37470, 37466, 37423, 37427, 37471, 37467, 39524, 39670, 39671, 39657, 39527, 39673, 39674, 
39660, 39512, 39525, 39672, 39659
26538, 37423, 37427, 37471, 37467, 37424, 37428, 37472, 37468, 39527, 39673, 39674, 39660, 39530, 39676, 39677, 
39663, 39515, 39528, 39675, 39662
26539, 37424, 37428, 37472, 37468, 37425, 37429, 37473, 37469, 39530, 39676, 39677, 39663, 39533, 39679, 39680, 
39666, 39518, 39531, 39678, 39665
26540, 37425, 37429, 37473, 37469, 16102, 16103, 16114, 16113, 39533, 39679, 39680, 39666, 0, 0, 0, 
0, 39521, 39534, 39681, 39668
26541, 5625, 5626, 5637, 5636, 37426, 37430, 37474, 37470, 0, 0, 0, 0, 39537, 39683, 39684, 
39670, 39522, 39535, 39682, 39669
26542, 37426, 37430, 37474, 37470, 37427, 37431, 37475, 37471, 39537, 39683, 39684, 39670, 39540, 39686, 39687, 
39673, 39525, 39538, 39685, 39672
26543, 37427, 37431, 37475, 37471, 37428, 37432, 37476, 37472, 39540, 39686, 39687, 39673, 39543, 39689, 39690, 
39676, 39528, 39541, 39688, 39675
26544, 37428, 37432, 37476, 37472, 37429, 37433, 37477, 37473, 39543, 39689, 39690, 39676, 39546, 39692, 39693, 
39679, 39531, 39544, 39691, 39678
26545, 37429, 37433, 37477, 37473, 16103, 16104, 16115, 16114, 39546, 39692, 39693, 39679, 0, 0, 0, 
0, 39534, 39547, 39694, 39681
26546, 5626, 5627, 5638, 5637, 37430, 37434, 37478, 37474, 0, 0, 0, 0, 39550, 39696, 39697, 
39683, 39535, 39548, 39695, 39682
26547, 37430, 37434, 37478, 37474, 37431, 37435, 37479, 37475, 39550, 39696, 39697, 39683, 39553, 39699, 39700, 
39686, 39538, 39551, 39698, 39685
26548, 37431, 37435, 37479, 37475, 37432, 37436, 37480, 37476, 39553, 39699, 39700, 39686, 39556, 39702, 39703, 
39689, 39541, 39554, 39701, 39688
26549, 37432, 37436, 37480, 37476, 37433, 37437, 37481, 37477, 39556, 39702, 39703, 39689, 39559, 39705, 39706, 
39692, 39544, 39557, 39704, 39691
26550, 37433, 37437, 37481, 37477, 16104, 16105, 16116, 16115, 39559, 39705, 39706, 39692, 0, 0, 0, 
0, 39547, 39560, 39707, 39694
26551, 5627, 5628, 5639, 5638, 37434, 37438, 37482, 37478, 0, 0, 0, 0, 39563, 39709, 39710, 
39696, 39548, 39561, 39708, 39695
26552, 37434, 37438, 37482, 37478, 37435, 37439, 37483, 37479, 39563, 39709, 39710, 39696, 39566, 39712, 39713, 
39699, 39551, 39564, 39711, 39698
26553, 37435, 37439, 37483, 37479, 37436, 37440, 37484, 37480, 39566, 39712, 39713, 39699, 39569, 39715, 39716, 
39702, 39554, 39567, 39714, 39701
26554, 37436, 37440, 37484, 37480, 37437, 37441, 37485, 37481, 39569, 39715, 39716, 39702, 39572, 39718, 39719, 
39705, 39557, 39570, 39717, 39704
26555, 37437, 37441, 37485, 37481, 16105, 16106, 16117, 16116, 39572, 39718, 39719, 39705, 0, 0, 0, 
0, 39560, 39573, 39720, 39707
26556, 5628, 5629, 5640, 5639, 37438, 37442, 37486, 37482, 0, 0, 0, 0, 39576, 39722, 39723, 
39709, 39561, 39574, 39721, 39708
26557, 37438, 37442, 37486, 37482, 37439, 37443, 37487, 37483, 39576, 39722, 39723, 39709, 39579, 39725, 39726, 
39712, 39564, 39577, 39724, 39711
26558, 37439, 37443, 37487, 37483, 37440, 37444, 37488, 37484, 39579, 39725, 39726, 39712, 39582, 39728, 39729, 
39715, 39567, 39580, 39727, 39714
26559, 37440, 37444, 37488, 37484, 37441, 37445, 37489, 37485, 39582, 39728, 39729, 39715, 39585, 39731, 39732, 
39718, 39570, 39583, 39730, 39717
26560, 37441, 37445, 37489, 37485, 16106, 16107, 16118, 16117, 39585, 39731, 39732, 39718, 0, 0, 0, 
0, 39573, 39586, 39733, 39720
26561, 5629, 590, 591, 5640, 37442, 15788, 15792, 37486, 0, 0, 0, 0, 39587, 0, 39734, 
39722, 39574, 0, 0, 39721
26562, 37442, 15788, 15792, 37486, 37443, 15789, 15793, 37487, 39587, 0, 39734, 39722, 39588, 0, 39735, 
39725, 39577, 0, 0, 39724
26563, 37443, 15789, 15793, 37487, 37444, 15790, 15794, 37488, 39588, 0, 39735, 39725, 39589, 0, 39736, 
39728, 39580, 0, 0, 39727
26564, 37444, 15790, 15794, 37488, 37445, 15791, 15795, 37489, 39589, 0, 39736, 39728, 39590, 0, 39737, 
39731, 39583, 0, 0, 39730
26565, 37445, 15791, 15795, 37489, 16107, 2046, 2047, 16118, 39590, 0, 39737, 39731, 0, 0, 0, 
0, 39586, 0, 0, 39733
26566, 553, 5630, 5641, 554, 15342, 37446, 37490, 15346, 0, 0, 0, 0, 39593, 39739, 39740, 
15498, 15490, 39591, 39738, 15499
26567, 15342, 37446, 37490, 15346, 15343, 37447, 37491, 15347, 39593, 39739, 39740, 15498, 39596, 39742, 39743, 
15500, 15492, 39594, 39741, 15501
26568, 15343, 37447, 37491, 15347, 15344, 37448, 37492, 15348, 39596, 39742, 39743, 15500, 39599, 39745, 39746, 
15502, 15494, 39597, 39744, 15503
26569, 15344, 37448, 37492, 15348, 15345, 37449, 37493, 15349, 39599, 39745, 39746, 15502, 39602, 39748, 39749, 
15504, 15496, 39600, 39747, 15505
