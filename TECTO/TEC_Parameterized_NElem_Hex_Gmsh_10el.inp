18584, 28804, 28827, 29356, 29333, 28805, 28828, 29357, 29334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18585, 28805, 28828, 29357, 29334, 28806, 28829, 29358, 29335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18586, 28806, 28829, 29358, 29335, 28807, 28830, 29359, 29336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18587, 28807, 28830, 29359, 29336, 28808, 28831, 29360, 29337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18588, 28808, 28831, 29360, 29337, 28809, 28832, 29361, 29338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18589, 28809, 28832, 29361, 29338, 28810, 28833, 29362, 29339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18590, 28810, 28833, 29362, 29339, 28811, 28834, 29363, 29340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18591, 28811, 28834, 29363, 29340, 28812, 28835, 29364, 29341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18592, 28812, 28835, 29364, 29341, 28813, 28836, 29365, 29342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18593, 28813, 28836, 29365, 29342, 28814, 28837, 29366, 29343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18594, 28814, 28837, 29366, 29343, 28815, 28838, 29367, 29344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18595, 28815, 28838, 29367, 29344, 28816, 28839, 29368, 29345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18596, 28816, 28839, 29368, 29345, 28817, 28840, 29369, 29346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18597, 28817, 28840, 29369, 29346, 8407, 8408, 8431, 8430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18598, 6591, 6592, 6615, 6614, 28818, 28841, 29370, 29347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18599, 28818, 28841, 29370, 29347, 28819, 28842, 29371, 29348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18600, 28819, 28842, 29371, 29348, 28820, 28843, 29372, 29349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18601, 28820, 28843, 29372, 29349, 28821, 28844, 29373, 29350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18602, 28821, 28844, 29373, 29350, 28822, 28845, 29374, 29351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18603, 28822, 28845, 29374, 29351, 28823, 28846, 29375, 29352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18604, 28823, 28846, 29375, 29352, 28824, 28847, 29376, 29353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18605, 28824, 28847, 29376, 29353, 28825, 28848, 29377, 29354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18606, 28825, 28848, 29377, 29354, 28826, 28849, 29378, 29355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18607, 28826, 28849, 29378, 29355, 28827, 28850, 29379, 29356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18608, 28827, 28850, 29379, 29356, 28828, 28851, 29380, 29357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18609, 28828, 28851, 29380, 29357, 28829, 28852, 29381, 29358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18610, 28829, 28852, 29381, 29358, 28830, 28853, 29382, 29359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18611, 28830, 28853, 29382, 29359, 28831, 28854, 29383, 29360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18612, 28831, 28854, 29383, 29360, 28832, 28855, 29384, 29361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18613, 28832, 28855, 29384, 29361, 28833, 28856, 29385, 29362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18614, 28833, 28856, 29385, 29362, 28834, 28857, 29386, 29363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18615, 28834, 28857, 29386, 29363, 28835, 28858, 29387, 29364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18616, 28835, 28858, 29387, 29364, 28836, 28859, 29388, 29365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18617, 28836, 28859, 29388, 29365, 28837, 28860, 29389, 29366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18618, 28837, 28860, 29389, 29366, 28838, 28861, 29390, 29367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18619, 28838, 28861, 29390, 29367, 28839, 28862, 29391, 29368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18620, 28839, 28862, 29391, 29368, 28840, 28863, 29392, 29369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18621, 28840, 28863, 29392, 29369, 8408, 8409, 8432, 8431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18622, 6592, 6593, 6616, 6615, 28841, 28864, 29393, 29370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18623, 28841, 28864, 29393, 29370, 28842, 28865, 29394, 29371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18624, 28842, 28865, 29394, 29371, 28843, 28866, 29395, 29372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18625, 28843, 28866, 29395, 29372, 28844, 28867, 29396, 29373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18626, 28844, 28867, 29396, 29373, 28845, 28868, 29397, 29374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18627, 28845, 28868, 29397, 29374, 28846, 28869, 29398, 29375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18628, 28846, 28869, 29398, 29375, 28847, 28870, 29399, 29376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18629, 28847, 28870, 29399, 29376, 28848, 28871, 29400, 29377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18630, 28848, 28871, 29400, 29377, 28849, 28872, 29401, 29378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18631, 28849, 28872, 29401, 29378, 28850, 28873, 29402, 29379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18632, 28850, 28873, 29402, 29379, 28851, 28874, 29403, 29380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18633, 28851, 28874, 29403, 29380, 28852, 28875, 29404, 29381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18634, 28852, 28875, 29404, 29381, 28853, 28876, 29405, 29382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18635, 28853, 28876, 29405, 29382, 28854, 28877, 29406, 29383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18636, 28854, 28877, 29406, 29383, 28855, 28878, 29407, 29384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18637, 28855, 28878, 29407, 29384, 28856, 28879, 29408, 29385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18638, 28856, 28879, 29408, 29385, 28857, 28880, 29409, 29386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18639, 28857, 28880, 29409, 29386, 28858, 28881, 29410, 29387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18640, 28858, 28881, 29410, 29387, 28859, 28882, 29411, 29388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18641, 28859, 28882, 29411, 29388, 28860, 28883, 29412, 29389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18642, 28860, 28883, 29412, 29389, 28861, 28884, 29413, 29390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18643, 28861, 28884, 29413, 29390, 28862, 28885, 29414, 29391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18644, 28862, 28885, 29414, 29391, 28863, 28886, 29415, 29392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18645, 28863, 28886, 29415, 29392, 8409, 8410, 8433, 8432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18646, 6593, 6594, 6617, 6616, 28864, 28887, 29416, 29393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18647, 28864, 28887, 29416, 29393, 28865, 28888, 29417, 29394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18648, 28865, 28888, 29417, 29394, 28866, 28889, 29418, 29395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18649, 28866, 28889, 29418, 29395, 28867, 28890, 29419, 29396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18650, 28867, 28890, 29419, 29396, 28868, 28891, 29420, 29397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18651, 28868, 28891, 29420, 29397, 28869, 28892, 29421, 29398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18652, 28869, 28892, 29421, 29398, 28870, 28893, 29422, 29399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18653, 28870, 28893, 29422, 29399, 28871, 28894, 29423, 29400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18654, 28871, 28894, 29423, 29400, 28872, 28895, 29424, 29401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18655, 28872, 28895, 29424, 29401, 28873, 28896, 29425, 29402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18656, 28873, 28896, 29425, 29402, 28874, 28897, 29426, 29403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18657, 28874, 28897, 29426, 29403, 28875, 28898, 29427, 29404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18658, 28875, 28898, 29427, 29404, 28876, 28899, 29428, 29405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18659, 28876, 28899, 29428, 29405, 28877, 28900, 29429, 29406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18660, 28877, 28900, 29429, 29406, 28878, 28901, 29430, 29407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18661, 28878, 28901, 29430, 29407, 28879, 28902, 29431, 29408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18662, 28879, 28902, 29431, 29408, 28880, 28903, 29432, 29409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18663, 28880, 28903, 29432, 29409, 28881, 28904, 29433, 29410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18664, 28881, 28904, 29433, 29410, 28882, 28905, 29434, 29411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18665, 28882, 28905, 29434, 29411, 28883, 28906, 29435, 29412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18666, 28883, 28906, 29435, 29412, 28884, 28907, 29436, 29413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18667, 28884, 28907, 29436, 29413, 28885, 28908, 29437, 29414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18668, 28885, 28908, 29437, 29414, 28886, 28909, 29438, 29415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18669, 28886, 28909, 29438, 29415, 8410, 8411, 8434, 8433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18670, 6594, 6595, 6618, 6617, 28887, 28910, 29439, 29416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18671, 28887, 28910, 29439, 29416, 28888, 28911, 29440, 29417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18672, 28888, 28911, 29440, 29417, 28889, 28912, 29441, 29418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18673, 28889, 28912, 29441, 29418, 28890, 28913, 29442, 29419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18674, 28890, 28913, 29442, 29419, 28891, 28914, 29443, 29420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18675, 28891, 28914, 29443, 29420, 28892, 28915, 29444, 29421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18676, 28892, 28915, 29444, 29421, 28893, 28916, 29445, 29422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18677, 28893, 28916, 29445, 29422, 28894, 28917, 29446, 29423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18678, 28894, 28917, 29446, 29423, 28895, 28918, 29447, 29424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18679, 28895, 28918, 29447, 29424, 28896, 28919, 29448, 29425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18680, 28896, 28919, 29448, 29425, 28897, 28920, 29449, 29426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18681, 28897, 28920, 29449, 29426, 28898, 28921, 29450, 29427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18682, 28898, 28921, 29450, 29427, 28899, 28922, 29451, 29428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18683, 28899, 28922, 29451, 29428, 28900, 28923, 29452, 29429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18684, 28900, 28923, 29452, 29429, 28901, 28924, 29453, 29430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18685, 28901, 28924, 29453, 29430, 28902, 28925, 29454, 29431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18686, 28902, 28925, 29454, 29431, 28903, 28926, 29455, 29432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18687, 28903, 28926, 29455, 29432, 28904, 28927, 29456, 29433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18688, 28904, 28927, 29456, 29433, 28905, 28928, 29457, 29434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18689, 28905, 28928, 29457, 29434, 28906, 28929, 29458, 29435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18690, 28906, 28929, 29458, 29435, 28907, 28930, 29459, 29436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18691, 28907, 28930, 29459, 29436, 28908, 28931, 29460, 29437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18692, 28908, 28931, 29460, 29437, 28909, 28932, 29461, 29438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18693, 28909, 28932, 29461, 29438, 8411, 8412, 8435, 8434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18694, 6595, 6596, 6619, 6618, 28910, 28933, 29462, 29439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18695, 28910, 28933, 29462, 29439, 28911, 28934, 29463, 29440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18696, 28911, 28934, 29463, 29440, 28912, 28935, 29464, 29441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18697, 28912, 28935, 29464, 29441, 28913, 28936, 29465, 29442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18698, 28913, 28936, 29465, 29442, 28914, 28937, 29466, 29443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18699, 28914, 28937, 29466, 29443, 28915, 28938, 29467, 29444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18700, 28915, 28938, 29467, 29444, 28916, 28939, 29468, 29445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18701, 28916, 28939, 29468, 29445, 28917, 28940, 29469, 29446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18702, 28917, 28940, 29469, 29446, 28918, 28941, 29470, 29447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18703, 28918, 28941, 29470, 29447, 28919, 28942, 29471, 29448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18704, 28919, 28942, 29471, 29448, 28920, 28943, 29472, 29449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18705, 28920, 28943, 29472, 29449, 28921, 28944, 29473, 29450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18706, 28921, 28944, 29473, 29450, 28922, 28945, 29474, 29451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18707, 28922, 28945, 29474, 29451, 28923, 28946, 29475, 29452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18708, 28923, 28946, 29475, 29452, 28924, 28947, 29476, 29453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18709, 28924, 28947, 29476, 29453, 28925, 28948, 29477, 29454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18710, 28925, 28948, 29477, 29454, 28926, 28949, 29478, 29455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18711, 28926, 28949, 29478, 29455, 28927, 28950, 29479, 29456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18712, 28927, 28950, 29479, 29456, 28928, 28951, 29480, 29457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18713, 28928, 28951, 29480, 29457, 28929, 28952, 29481, 29458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18714, 28929, 28952, 29481, 29458, 28930, 28953, 29482, 29459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18715, 28930, 28953, 29482, 29459, 28931, 28954, 29483, 29460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18716, 28931, 28954, 29483, 29460, 28932, 28955, 29484, 29461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18717, 28932, 28955, 29484, 29461, 8412, 8413, 8436, 8435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18718, 6596, 6597, 6620, 6619, 28933, 28956, 29485, 29462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18719, 28933, 28956, 29485, 29462, 28934, 28957, 29486, 29463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18720, 28934, 28957, 29486, 29463, 28935, 28958, 29487, 29464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18721, 28935, 28958, 29487, 29464, 28936, 28959, 29488, 29465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18722, 28936, 28959, 29488, 29465, 28937, 28960, 29489, 29466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18723, 28937, 28960, 29489, 29466, 28938, 28961, 29490, 29467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18724, 28938, 28961, 29490, 29467, 28939, 28962, 29491, 29468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18725, 28939, 28962, 29491, 29468, 28940, 28963, 29492, 29469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18726, 28940, 28963, 29492, 29469, 28941, 28964, 29493, 29470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18727, 28941, 28964, 29493, 29470, 28942, 28965, 29494, 29471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18728, 28942, 28965, 29494, 29471, 28943, 28966, 29495, 29472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18729, 28943, 28966, 29495, 29472, 28944, 28967, 29496, 29473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18730, 28944, 28967, 29496, 29473, 28945, 28968, 29497, 29474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18731, 28945, 28968, 29497, 29474, 28946, 28969, 29498, 29475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18732, 28946, 28969, 29498, 29475, 28947, 28970, 29499, 29476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18733, 28947, 28970, 29499, 29476, 28948, 28971, 29500, 29477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18734, 28948, 28971, 29500, 29477, 28949, 28972, 29501, 29478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18735, 28949, 28972, 29501, 29478, 28950, 28973, 29502, 29479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18736, 28950, 28973, 29502, 29479, 28951, 28974, 29503, 29480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18737, 28951, 28974, 29503, 29480, 28952, 28975, 29504, 29481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18738, 28952, 28975, 29504, 29481, 28953, 28976, 29505, 29482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18739, 28953, 28976, 29505, 29482, 28954, 28977, 29506, 29483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18740, 28954, 28977, 29506, 29483, 28955, 28978, 29507, 29484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18741, 28955, 28978, 29507, 29484, 8413, 8414, 8437, 8436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18742, 6597, 6598, 6621, 6620, 28956, 28979, 29508, 29485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18743, 28956, 28979, 29508, 29485, 28957, 28980, 29509, 29486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18744, 28957, 28980, 29509, 29486, 28958, 28981, 29510, 29487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18745, 28958, 28981, 29510, 29487, 28959, 28982, 29511, 29488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18746, 28959, 28982, 29511, 29488, 28960, 28983, 29512, 29489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18747, 28960, 28983, 29512, 29489, 28961, 28984, 29513, 29490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18748, 28961, 28984, 29513, 29490, 28962, 28985, 29514, 29491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18749, 28962, 28985, 29514, 29491, 28963, 28986, 29515, 29492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18750, 28963, 28986, 29515, 29492, 28964, 28987, 29516, 29493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18751, 28964, 28987, 29516, 29493, 28965, 28988, 29517, 29494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18752, 28965, 28988, 29517, 29494, 28966, 28989, 29518, 29495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18753, 28966, 28989, 29518, 29495, 28967, 28990, 29519, 29496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18754, 28967, 28990, 29519, 29496, 28968, 28991, 29520, 29497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18755, 28968, 28991, 29520, 29497, 28969, 28992, 29521, 29498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18756, 28969, 28992, 29521, 29498, 28970, 28993, 29522, 29499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18757, 28970, 28993, 29522, 29499, 28971, 28994, 29523, 29500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18758, 28971, 28994, 29523, 29500, 28972, 28995, 29524, 29501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18759, 28972, 28995, 29524, 29501, 28973, 28996, 29525, 29502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18760, 28973, 28996, 29525, 29502, 28974, 28997, 29526, 29503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18761, 28974, 28997, 29526, 29503, 28975, 28998, 29527, 29504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18762, 28975, 28998, 29527, 29504, 28976, 28999, 29528, 29505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18763, 28976, 28999, 29528, 29505, 28977, 29000, 29529, 29506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18764, 28977, 29000, 29529, 29506, 28978, 29001, 29530, 29507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18765, 28978, 29001, 29530, 29507, 8414, 8415, 8438, 8437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18766, 6598, 6599, 6622, 6621, 28979, 29002, 29531, 29508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18767, 28979, 29002, 29531, 29508, 28980, 29003, 29532, 29509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18768, 28980, 29003, 29532, 29509, 28981, 29004, 29533, 29510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18769, 28981, 29004, 29533, 29510, 28982, 29005, 29534, 29511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18770, 28982, 29005, 29534, 29511, 28983, 29006, 29535, 29512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18771, 28983, 29006, 29535, 29512, 28984, 29007, 29536, 29513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18772, 28984, 29007, 29536, 29513, 28985, 29008, 29537, 29514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18773, 28985, 29008, 29537, 29514, 28986, 29009, 29538, 29515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18774, 28986, 29009, 29538, 29515, 28987, 29010, 29539, 29516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18775, 28987, 29010, 29539, 29516, 28988, 29011, 29540, 29517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18776, 28988, 29011, 29540, 29517, 28989, 29012, 29541, 29518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18777, 28989, 29012, 29541, 29518, 28990, 29013, 29542, 29519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18778, 28990, 29013, 29542, 29519, 28991, 29014, 29543, 29520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18779, 28991, 29014, 29543, 29520, 28992, 29015, 29544, 29521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18780, 28992, 29015, 29544, 29521, 28993, 29016, 29545, 29522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18781, 28993, 29016, 29545, 29522, 28994, 29017, 29546, 29523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18782, 28994, 29017, 29546, 29523, 28995, 29018, 29547, 29524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18783, 28995, 29018, 29547, 29524, 28996, 29019, 29548, 29525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18784, 28996, 29019, 29548, 29525, 28997, 29020, 29549, 29526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18785, 28997, 29020, 29549, 29526, 28998, 29021, 29550, 29527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18786, 28998, 29021, 29550, 29527, 28999, 29022, 29551, 29528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18787, 28999, 29022, 29551, 29528, 29000, 29023, 29552, 29529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18788, 29000, 29023, 29552, 29529, 29001, 29024, 29553, 29530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18789, 29001, 29024, 29553, 29530, 8415, 8416, 8439, 8438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18790, 6599, 834, 835, 6622, 29002, 8141, 8164, 29531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18791, 29002, 8141, 8164, 29531, 29003, 8142, 8165, 29532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18792, 29003, 8142, 8165, 29532, 29004, 8143, 8166, 29533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18793, 29004, 8143, 8166, 29533, 29005, 8144, 8167, 29534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18794, 29005, 8144, 8167, 29534, 29006, 8145, 8168, 29535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18795, 29006, 8145, 8168, 29535, 29007, 8146, 8169, 29536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18796, 29007, 8146, 8169, 29536, 29008, 8147, 8170, 29537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18797, 29008, 8147, 8170, 29537, 29009, 8148, 8171, 29538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18798, 29009, 8148, 8171, 29538, 29010, 8149, 8172, 29539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18799, 29010, 8149, 8172, 29539, 29011, 8150, 8173, 29540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18800, 29011, 8150, 8173, 29540, 29012, 8151, 8174, 29541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18801, 29012, 8151, 8174, 29541, 29013, 8152, 8175, 29542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18802, 29013, 8152, 8175, 29542, 29014, 8153, 8176, 29543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18803, 29014, 8153, 8176, 29543, 29015, 8154, 8177, 29544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18804, 29015, 8154, 8177, 29544, 29016, 8155, 8178, 29545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18805, 29016, 8155, 8178, 29545, 29017, 8156, 8179, 29546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18806, 29017, 8156, 8179, 29546, 29018, 8157, 8180, 29547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18807, 29018, 8157, 8180, 29547, 29019, 8158, 8181, 29548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18808, 29019, 8158, 8181, 29548, 29020, 8159, 8182, 29549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18809, 29020, 8159, 8182, 29549, 29021, 8160, 8183, 29550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18810, 29021, 8160, 8183, 29550, 29022, 8161, 8184, 29551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18811, 29022, 8161, 8184, 29551, 29023, 8162, 8185, 29552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18812, 29023, 8162, 8185, 29552, 29024, 8163, 8186, 29553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18813, 29024, 8163, 8186, 29553, 8416, 994, 995, 8439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18814, 824, 6600, 6623, 825, 7911, 29025, 29554, 7934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18815, 7911, 29025, 29554, 7934, 7912, 29026, 29555, 7935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18816, 7912, 29026, 29555, 7935, 7913, 29027, 29556, 7936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18817, 7913, 29027, 29556, 7936, 7914, 29028, 29557, 7937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18818, 7914, 29028, 29557, 7937, 7915, 29029, 29558, 7938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18819, 7915, 29029, 29558, 7938, 7916, 29030, 29559, 7939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18820, 7916, 29030, 29559, 7939, 7917, 29031, 29560, 7940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18821, 7917, 29031, 29560, 7940, 7918, 29032, 29561, 7941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18822, 7918, 29032, 29561, 7941, 7919, 29033, 29562, 7942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18823, 7919, 29033, 29562, 7942, 7920, 29034, 29563, 7943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18824, 7920, 29034, 29563, 7943, 7921, 29035, 29564, 7944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18825, 7921, 29035, 29564, 7944, 7922, 29036, 29565, 7945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18826, 7922, 29036, 29565, 7945, 7923, 29037, 29566, 7946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18827, 7923, 29037, 29566, 7946, 7924, 29038, 29567, 7947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18828, 7924, 29038, 29567, 7947, 7925, 29039, 29568, 7948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18829, 7925, 29039, 29568, 7948, 7926, 29040, 29569, 7949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18830, 7926, 29040, 29569, 7949, 7927, 29041, 29570, 7950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18831, 7927, 29041, 29570, 7950, 7928, 29042, 29571, 7951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18832, 7928, 29042, 29571, 7951, 7929, 29043, 29572, 7952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18833, 7929, 29043, 29572, 7952, 7930, 29044, 29573, 7953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18834, 7930, 29044, 29573, 7953, 7931, 29045, 29574, 7954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18835, 7931, 29045, 29574, 7954, 7932, 29046, 29575, 7955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18836, 7932, 29046, 29575, 7955, 7933, 29047, 29576, 7956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18837, 7933, 29047, 29576, 7956, 984, 8417, 8440, 985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18838, 6600, 6601, 6624, 6623, 29025, 29048, 29577, 29554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18839, 29025, 29048, 29577, 29554, 29026, 29049, 29578, 29555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18840, 29026, 29049, 29578, 29555, 29027, 29050, 29579, 29556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18841, 29027, 29050, 29579, 29556, 29028, 29051, 29580, 29557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18842, 29028, 29051, 29580, 29557, 29029, 29052, 29581, 29558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18843, 29029, 29052, 29581, 29558, 29030, 29053, 29582, 29559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18844, 29030, 29053, 29582, 29559, 29031, 29054, 29583, 29560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18845, 29031, 29054, 29583, 29560, 29032, 29055, 29584, 29561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18846, 29032, 29055, 29584, 29561, 29033, 29056, 29585, 29562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18847, 29033, 29056, 29585, 29562, 29034, 29057, 29586, 29563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18848, 29034, 29057, 29586, 29563, 29035, 29058, 29587, 29564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18849, 29035, 29058, 29587, 29564, 29036, 29059, 29588, 29565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18850, 29036, 29059, 29588, 29565, 29037, 29060, 29589, 29566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18851, 29037, 29060, 29589, 29566, 29038, 29061, 29590, 29567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18852, 29038, 29061, 29590, 29567, 29039, 29062, 29591, 29568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18853, 29039, 29062, 29591, 29568, 29040, 29063, 29592, 29569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18854, 29040, 29063, 29592, 29569, 29041, 29064, 29593, 29570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18855, 29041, 29064, 29593, 29570, 29042, 29065, 29594, 29571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18856, 29042, 29065, 29594, 29571, 29043, 29066, 29595, 29572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18857, 29043, 29066, 29595, 29572, 29044, 29067, 29596, 29573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18858, 29044, 29067, 29596, 29573, 29045, 29068, 29597, 29574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18859, 29045, 29068, 29597, 29574, 29046, 29069, 29598, 29575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18860, 29046, 29069, 29598, 29575, 29047, 29070, 29599, 29576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18861, 29047, 29070, 29599, 29576, 8417, 8418, 8441, 8440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18862, 6601, 6602, 6625, 6624, 29048, 29071, 29600, 29577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18863, 29048, 29071, 29600, 29577, 29049, 29072, 29601, 29578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18864, 29049, 29072, 29601, 29578, 29050, 29073, 29602, 29579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18865, 29050, 29073, 29602, 29579, 29051, 29074, 29603, 29580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18866, 29051, 29074, 29603, 29580, 29052, 29075, 29604, 29581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18867, 29052, 29075, 29604, 29581, 29053, 29076, 29605, 29582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18868, 29053, 29076, 29605, 29582, 29054, 29077, 29606, 29583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18869, 29054, 29077, 29606, 29583, 29055, 29078, 29607, 29584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18870, 29055, 29078, 29607, 29584, 29056, 29079, 29608, 29585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18871, 29056, 29079, 29608, 29585, 29057, 29080, 29609, 29586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18872, 29057, 29080, 29609, 29586, 29058, 29081, 29610, 29587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18873, 29058, 29081, 29610, 29587, 29059, 29082, 29611, 29588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18874, 29059, 29082, 29611, 29588, 29060, 29083, 29612, 29589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18875, 29060, 29083, 29612, 29589, 29061, 29084, 29613, 29590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18876, 29061, 29084, 29613, 29590, 29062, 29085, 29614, 29591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18877, 29062, 29085, 29614, 29591, 29063, 29086, 29615, 29592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18878, 29063, 29086, 29615, 29592, 29064, 29087, 29616, 29593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18879, 29064, 29087, 29616, 29593, 29065, 29088, 29617, 29594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18880, 29065, 29088, 29617, 29594, 29066, 29089, 29618, 29595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18881, 29066, 29089, 29618, 29595, 29067, 29090, 29619, 29596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18882, 29067, 29090, 29619, 29596, 29068, 29091, 29620, 29597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18883, 29068, 29091, 29620, 29597, 29069, 29092, 29621, 29598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18884, 29069, 29092, 29621, 29598, 29070, 29093, 29622, 29599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18885, 29070, 29093, 29622, 29599, 8418, 8419, 8442, 8441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18886, 6602, 6603, 6626, 6625, 29071, 29094, 29623, 29600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18887, 29071, 29094, 29623, 29600, 29072, 29095, 29624, 29601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18888, 29072, 29095, 29624, 29601, 29073, 29096, 29625, 29602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18889, 29073, 29096, 29625, 29602, 29074, 29097, 29626, 29603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18890, 29074, 29097, 29626, 29603, 29075, 29098, 29627, 29604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18891, 29075, 29098, 29627, 29604, 29076, 29099, 29628, 29605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18892, 29076, 29099, 29628, 29605, 29077, 29100, 29629, 29606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18893, 29077, 29100, 29629, 29606, 29078, 29101, 29630, 29607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18894, 29078, 29101, 29630, 29607, 29079, 29102, 29631, 29608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18895, 29079, 29102, 29631, 29608, 29080, 29103, 29632, 29609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18896, 29080, 29103, 29632, 29609, 29081, 29104, 29633, 29610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18897, 29081, 29104, 29633, 29610, 29082, 29105, 29634, 29611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18898, 29082, 29105, 29634, 29611, 29083, 29106, 29635, 29612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18899, 29083, 29106, 29635, 29612, 29084, 29107, 29636, 29613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18900, 29084, 29107, 29636, 29613, 29085, 29108, 29637, 29614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18901, 29085, 29108, 29637, 29614, 29086, 29109, 29638, 29615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18902, 29086, 29109, 29638, 29615, 29087, 29110, 29639, 29616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18903, 29087, 29110, 29639, 29616, 29088, 29111, 29640, 29617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18904, 29088, 29111, 29640, 29617, 29089, 29112, 29641, 29618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18905, 29089, 29112, 29641, 29618, 29090, 29113, 29642, 29619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18906, 29090, 29113, 29642, 29619, 29091, 29114, 29643, 29620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18907, 29091, 29114, 29643, 29620, 29092, 29115, 29644, 29621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18908, 29092, 29115, 29644, 29621, 29093, 29116, 29645, 29622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18909, 29093, 29116, 29645, 29622, 8419, 8420, 8443, 8442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18910, 6603, 6604, 6627, 6626, 29094, 29117, 29646, 29623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18911, 29094, 29117, 29646, 29623, 29095, 29118, 29647, 29624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18912, 29095, 29118, 29647, 29624, 29096, 29119, 29648, 29625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18913, 29096, 29119, 29648, 29625, 29097, 29120, 29649, 29626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18914, 29097, 29120, 29649, 29626, 29098, 29121, 29650, 29627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18915, 29098, 29121, 29650, 29627, 29099, 29122, 29651, 29628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18916, 29099, 29122, 29651, 29628, 29100, 29123, 29652, 29629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18917, 29100, 29123, 29652, 29629, 29101, 29124, 29653, 29630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18918, 29101, 29124, 29653, 29630, 29102, 29125, 29654, 29631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18919, 29102, 29125, 29654, 29631, 29103, 29126, 29655, 29632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18920, 29103, 29126, 29655, 29632, 29104, 29127, 29656, 29633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18921, 29104, 29127, 29656, 29633, 29105, 29128, 29657, 29634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18922, 29105, 29128, 29657, 29634, 29106, 29129, 29658, 29635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18923, 29106, 29129, 29658, 29635, 29107, 29130, 29659, 29636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18924, 29107, 29130, 29659, 29636, 29108, 29131, 29660, 29637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18925, 29108, 29131, 29660, 29637, 29109, 29132, 29661, 29638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18926, 29109, 29132, 29661, 29638, 29110, 29133, 29662, 29639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18927, 29110, 29133, 29662, 29639, 29111, 29134, 29663, 29640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18928, 29111, 29134, 29663, 29640, 29112, 29135, 29664, 29641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18929, 29112, 29135, 29664, 29641, 29113, 29136, 29665, 29642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18930, 29113, 29136, 29665, 29642, 29114, 29137, 29666, 29643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18931, 29114, 29137, 29666, 29643, 29115, 29138, 29667, 29644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18932, 29115, 29138, 29667, 29644, 29116, 29139, 29668, 29645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18933, 29116, 29139, 29668, 29645, 8420, 8421, 8444, 8443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18934, 6604, 6605, 6628, 6627, 29117, 29140, 29669, 29646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18935, 29117, 29140, 29669, 29646, 29118, 29141, 29670, 29647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18936, 29118, 29141, 29670, 29647, 29119, 29142, 29671, 29648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18937, 29119, 29142, 29671, 29648, 29120, 29143, 29672, 29649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18938, 29120, 29143, 29672, 29649, 29121, 29144, 29673, 29650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18939, 29121, 29144, 29673, 29650, 29122, 29145, 29674, 29651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18940, 29122, 29145, 29674, 29651, 29123, 29146, 29675, 29652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18941, 29123, 29146, 29675, 29652, 29124, 29147, 29676, 29653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18942, 29124, 29147, 29676, 29653, 29125, 29148, 29677, 29654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18943, 29125, 29148, 29677, 29654, 29126, 29149, 29678, 29655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18944, 29126, 29149, 29678, 29655, 29127, 29150, 29679, 29656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18945, 29127, 29150, 29679, 29656, 29128, 29151, 29680, 29657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18946, 29128, 29151, 29680, 29657, 29129, 29152, 29681, 29658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18947, 29129, 29152, 29681, 29658, 29130, 29153, 29682, 29659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18948, 29130, 29153, 29682, 29659, 29131, 29154, 29683, 29660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18949, 29131, 29154, 29683, 29660, 29132, 29155, 29684, 29661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18950, 29132, 29155, 29684, 29661, 29133, 29156, 29685, 29662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18951, 29133, 29156, 29685, 29662, 29134, 29157, 29686, 29663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18952, 29134, 29157, 29686, 29663, 29135, 29158, 29687, 29664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18953, 29135, 29158, 29687, 29664, 29136, 29159, 29688, 29665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18954, 29136, 29159, 29688, 29665, 29137, 29160, 29689, 29666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18955, 29137, 29160, 29689, 29666, 29138, 29161, 29690, 29667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18956, 29138, 29161, 29690, 29667, 29139, 29162, 29691, 29668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18957, 29139, 29162, 29691, 29668, 8421, 8422, 8445, 8444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18958, 6605, 6606, 6629, 6628, 29140, 29163, 29692, 29669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18959, 29140, 29163, 29692, 29669, 29141, 29164, 29693, 29670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18960, 29141, 29164, 29693, 29670, 29142, 29165, 29694, 29671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18961, 29142, 29165, 29694, 29671, 29143, 29166, 29695, 29672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18962, 29143, 29166, 29695, 29672, 29144, 29167, 29696, 29673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18963, 29144, 29167, 29696, 29673, 29145, 29168, 29697, 29674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18964, 29145, 29168, 29697, 29674, 29146, 29169, 29698, 29675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18965, 29146, 29169, 29698, 29675, 29147, 29170, 29699, 29676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18966, 29147, 29170, 29699, 29676, 29148, 29171, 29700, 29677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18967, 29148, 29171, 29700, 29677, 29149, 29172, 29701, 29678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18968, 29149, 29172, 29701, 29678, 29150, 29173, 29702, 29679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18969, 29150, 29173, 29702, 29679, 29151, 29174, 29703, 29680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18970, 29151, 29174, 29703, 29680, 29152, 29175, 29704, 29681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18971, 29152, 29175, 29704, 29681, 29153, 29176, 29705, 29682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18972, 29153, 29176, 29705, 29682, 29154, 29177, 29706, 29683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18973, 29154, 29177, 29706, 29683, 29155, 29178, 29707, 29684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18974, 29155, 29178, 29707, 29684, 29156, 29179, 29708, 29685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18975, 29156, 29179, 29708, 29685, 29157, 29180, 29709, 29686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18976, 29157, 29180, 29709, 29686, 29158, 29181, 29710, 29687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18977, 29158, 29181, 29710, 29687, 29159, 29182, 29711, 29688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18978, 29159, 29182, 29711, 29688, 29160, 29183, 29712, 29689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18979, 29160, 29183, 29712, 29689, 29161, 29184, 29713, 29690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18980, 29161, 29184, 29713, 29690, 29162, 29185, 29714, 29691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18981, 29162, 29185, 29714, 29691, 8422, 8423, 8446, 8445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18982, 6606, 6607, 6630, 6629, 29163, 29186, 29715, 29692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18983, 29163, 29186, 29715, 29692, 29164, 29187, 29716, 29693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18984, 29164, 29187, 29716, 29693, 29165, 29188, 29717, 29694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18985, 29165, 29188, 29717, 29694, 29166, 29189, 29718, 29695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18986, 29166, 29189, 29718, 29695, 29167, 29190, 29719, 29696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18987, 29167, 29190, 29719, 29696, 29168, 29191, 29720, 29697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18988, 29168, 29191, 29720, 29697, 29169, 29192, 29721, 29698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18989, 29169, 29192, 29721, 29698, 29170, 29193, 29722, 29699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18990, 29170, 29193, 29722, 29699, 29171, 29194, 29723, 29700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18991, 29171, 29194, 29723, 29700, 29172, 29195, 29724, 29701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18992, 29172, 29195, 29724, 29701, 29173, 29196, 29725, 29702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18993, 29173, 29196, 29725, 29702, 29174, 29197, 29726, 29703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18994, 29174, 29197, 29726, 29703, 29175, 29198, 29727, 29704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18995, 29175, 29198, 29727, 29704, 29176, 29199, 29728, 29705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18996, 29176, 29199, 29728, 29705, 29177, 29200, 29729, 29706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18997, 29177, 29200, 29729, 29706, 29178, 29201, 29730, 29707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18998, 29178, 29201, 29730, 29707, 29179, 29202, 29731, 29708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
18999, 29179, 29202, 29731, 29708, 29180, 29203, 29732, 29709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19000, 29180, 29203, 29732, 29709, 29181, 29204, 29733, 29710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19001, 29181, 29204, 29733, 29710, 29182, 29205, 29734, 29711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19002, 29182, 29205, 29734, 29711, 29183, 29206, 29735, 29712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19003, 29183, 29206, 29735, 29712, 29184, 29207, 29736, 29713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19004, 29184, 29207, 29736, 29713, 29185, 29208, 29737, 29714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19005, 29185, 29208, 29737, 29714, 8423, 8424, 8447, 8446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19006, 6607, 6608, 6631, 6630, 29186, 29209, 29738, 29715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19007, 29186, 29209, 29738, 29715, 29187, 29210, 29739, 29716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19008, 29187, 29210, 29739, 29716, 29188, 29211, 29740, 29717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19009, 29188, 29211, 29740, 29717, 29189, 29212, 29741, 29718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19010, 29189, 29212, 29741, 29718, 29190, 29213, 29742, 29719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19011, 29190, 29213, 29742, 29719, 29191, 29214, 29743, 29720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19012, 29191, 29214, 29743, 29720, 29192, 29215, 29744, 29721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19013, 29192, 29215, 29744, 29721, 29193, 29216, 29745, 29722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19014, 29193, 29216, 29745, 29722, 29194, 29217, 29746, 29723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19015, 29194, 29217, 29746, 29723, 29195, 29218, 29747, 29724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19016, 29195, 29218, 29747, 29724, 29196, 29219, 29748, 29725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19017, 29196, 29219, 29748, 29725, 29197, 29220, 29749, 29726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19018, 29197, 29220, 29749, 29726, 29198, 29221, 29750, 29727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19019, 29198, 29221, 29750, 29727, 29199, 29222, 29751, 29728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19020, 29199, 29222, 29751, 29728, 29200, 29223, 29752, 29729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19021, 29200, 29223, 29752, 29729, 29201, 29224, 29753, 29730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19022, 29201, 29224, 29753, 29730, 29202, 29225, 29754, 29731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19023, 29202, 29225, 29754, 29731, 29203, 29226, 29755, 29732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19024, 29203, 29226, 29755, 29732, 29204, 29227, 29756, 29733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19025, 29204, 29227, 29756, 29733, 29205, 29228, 29757, 29734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19026, 29205, 29228, 29757, 29734, 29206, 29229, 29758, 29735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19027, 29206, 29229, 29758, 29735, 29207, 29230, 29759, 29736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19028, 29207, 29230, 29759, 29736, 29208, 29231, 29760, 29737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19029, 29208, 29231, 29760, 29737, 8424, 8425, 8448, 8447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19030, 6608, 6609, 6632, 6631, 29209, 29232, 29761, 29738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19031, 29209, 29232, 29761, 29738, 29210, 29233, 29762, 29739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19032, 29210, 29233, 29762, 29739, 29211, 29234, 29763, 29740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19033, 29211, 29234, 29763, 29740, 29212, 29235, 29764, 29741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19034, 29212, 29235, 29764, 29741, 29213, 29236, 29765, 29742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19035, 29213, 29236, 29765, 29742, 29214, 29237, 29766, 29743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19036, 29214, 29237, 29766, 29743, 29215, 29238, 29767, 29744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19037, 29215, 29238, 29767, 29744, 29216, 29239, 29768, 29745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19038, 29216, 29239, 29768, 29745, 29217, 29240, 29769, 29746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19039, 29217, 29240, 29769, 29746, 29218, 29241, 29770, 29747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19040, 29218, 29241, 29770, 29747, 29219, 29242, 29771, 29748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19041, 29219, 29242, 29771, 29748, 29220, 29243, 29772, 29749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19042, 29220, 29243, 29772, 29749, 29221, 29244, 29773, 29750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19043, 29221, 29244, 29773, 29750, 29222, 29245, 29774, 29751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19044, 29222, 29245, 29774, 29751, 29223, 29246, 29775, 29752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19045, 29223, 29246, 29775, 29752, 29224, 29247, 29776, 29753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19046, 29224, 29247, 29776, 29753, 29225, 29248, 29777, 29754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19047, 29225, 29248, 29777, 29754, 29226, 29249, 29778, 29755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19048, 29226, 29249, 29778, 29755, 29227, 29250, 29779, 29756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19049, 29227, 29250, 29779, 29756, 29228, 29251, 29780, 29757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19050, 29228, 29251, 29780, 29757, 29229, 29252, 29781, 29758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19051, 29229, 29252, 29781, 29758, 29230, 29253, 29782, 29759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19052, 29230, 29253, 29782, 29759, 29231, 29254, 29783, 29760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19053, 29231, 29254, 29783, 29760, 8425, 8426, 8449, 8448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19054, 6609, 6610, 6633, 6632, 29232, 29255, 29784, 29761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19055, 29232, 29255, 29784, 29761, 29233, 29256, 29785, 29762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19056, 29233, 29256, 29785, 29762, 29234, 29257, 29786, 29763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19057, 29234, 29257, 29786, 29763, 29235, 29258, 29787, 29764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19058, 29235, 29258, 29787, 29764, 29236, 29259, 29788, 29765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19059, 29236, 29259, 29788, 29765, 29237, 29260, 29789, 29766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19060, 29237, 29260, 29789, 29766, 29238, 29261, 29790, 29767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19061, 29238, 29261, 29790, 29767, 29239, 29262, 29791, 29768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19062, 29239, 29262, 29791, 29768, 29240, 29263, 29792, 29769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19063, 29240, 29263, 29792, 29769, 29241, 29264, 29793, 29770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19064, 29241, 29264, 29793, 29770, 29242, 29265, 29794, 29771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19065, 29242, 29265, 29794, 29771, 29243, 29266, 29795, 29772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19066, 29243, 29266, 29795, 29772, 29244, 29267, 29796, 29773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19067, 29244, 29267, 29796, 29773, 29245, 29268, 29797, 29774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19068, 29245, 29268, 29797, 29774, 29246, 29269, 29798, 29775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19069, 29246, 29269, 29798, 29775, 29247, 29270, 29799, 29776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19070, 29247, 29270, 29799, 29776, 29248, 29271, 29800, 29777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19071, 29248, 29271, 29800, 29777, 29249, 29272, 29801, 29778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19072, 29249, 29272, 29801, 29778, 29250, 29273, 29802, 29779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19073, 29250, 29273, 29802, 29779, 29251, 29274, 29803, 29780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19074, 29251, 29274, 29803, 29780, 29252, 29275, 29804, 29781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19075, 29252, 29275, 29804, 29781, 29253, 29276, 29805, 29782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19076, 29253, 29276, 29805, 29782, 29254, 29277, 29806, 29783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19077, 29254, 29277, 29806, 29783, 8426, 8427, 8450, 8449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19078, 6610, 6611, 6634, 6633, 29255, 29278, 29807, 29784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19079, 29255, 29278, 29807, 29784, 29256, 29279, 29808, 29785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19080, 29256, 29279, 29808, 29785, 29257, 29280, 29809, 29786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19081, 29257, 29280, 29809, 29786, 29258, 29281, 29810, 29787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19082, 29258, 29281, 29810, 29787, 29259, 29282, 29811, 29788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19083, 29259, 29282, 29811, 29788, 29260, 29283, 29812, 29789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19084, 29260, 29283, 29812, 29789, 29261, 29284, 29813, 29790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19085, 29261, 29284, 29813, 29790, 29262, 29285, 29814, 29791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19086, 29262, 29285, 29814, 29791, 29263, 29286, 29815, 29792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19087, 29263, 29286, 29815, 29792, 29264, 29287, 29816, 29793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19088, 29264, 29287, 29816, 29793, 29265, 29288, 29817, 29794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19089, 29265, 29288, 29817, 29794, 29266, 29289, 29818, 29795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19090, 29266, 29289, 29818, 29795, 29267, 29290, 29819, 29796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19091, 29267, 29290, 29819, 29796, 29268, 29291, 29820, 29797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19092, 29268, 29291, 29820, 29797, 29269, 29292, 29821, 29798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19093, 29269, 29292, 29821, 29798, 29270, 29293, 29822, 29799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19094, 29270, 29293, 29822, 29799, 29271, 29294, 29823, 29800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19095, 29271, 29294, 29823, 29800, 29272, 29295, 29824, 29801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19096, 29272, 29295, 29824, 29801, 29273, 29296, 29825, 29802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19097, 29273, 29296, 29825, 29802, 29274, 29297, 29826, 29803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19098, 29274, 29297, 29826, 29803, 29275, 29298, 29827, 29804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19099, 29275, 29298, 29827, 29804, 29276, 29299, 29828, 29805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19100, 29276, 29299, 29828, 29805, 29277, 29300, 29829, 29806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19101, 29277, 29300, 29829, 29806, 8427, 8428, 8451, 8450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19102, 6611, 6612, 6635, 6634, 29278, 29301, 29830, 29807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19103, 29278, 29301, 29830, 29807, 29279, 29302, 29831, 29808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19104, 29279, 29302, 29831, 29808, 29280, 29303, 29832, 29809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19105, 29280, 29303, 29832, 29809, 29281, 29304, 29833, 29810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19106, 29281, 29304, 29833, 29810, 29282, 29305, 29834, 29811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19107, 29282, 29305, 29834, 29811, 29283, 29306, 29835, 29812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19108, 29283, 29306, 29835, 29812, 29284, 29307, 29836, 29813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19109, 29284, 29307, 29836, 29813, 29285, 29308, 29837, 29814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19110, 29285, 29308, 29837, 29814, 29286, 29309, 29838, 29815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19111, 29286, 29309, 29838, 29815, 29287, 29310, 29839, 29816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19112, 29287, 29310, 29839, 29816, 29288, 29311, 29840, 29817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19113, 29288, 29311, 29840, 29817, 29289, 29312, 29841, 29818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19114, 29289, 29312, 29841, 29818, 29290, 29313, 29842, 29819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19115, 29290, 29313, 29842, 29819, 29291, 29314, 29843, 29820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19116, 29291, 29314, 29843, 29820, 29292, 29315, 29844, 29821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19117, 29292, 29315, 29844, 29821, 29293, 29316, 29845, 29822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19118, 29293, 29316, 29845, 29822, 29294, 29317, 29846, 29823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19119, 29294, 29317, 29846, 29823, 29295, 29318, 29847, 29824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19120, 29295, 29318, 29847, 29824, 29296, 29319, 29848, 29825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19121, 29296, 29319, 29848, 29825, 29297, 29320, 29849, 29826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19122, 29297, 29320, 29849, 29826, 29298, 29321, 29850, 29827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19123, 29298, 29321, 29850, 29827, 29299, 29322, 29851, 29828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19124, 29299, 29322, 29851, 29828, 29300, 29323, 29852, 29829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19125, 29300, 29323, 29852, 29829, 8428, 8429, 8452, 8451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19126, 6612, 6613, 6636, 6635, 29301, 29324, 29853, 29830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19127, 29301, 29324, 29853, 29830, 29302, 29325, 29854, 29831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19128, 29302, 29325, 29854, 29831, 29303, 29326, 29855, 29832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19129, 29303, 29326, 29855, 29832, 29304, 29327, 29856, 29833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19130, 29304, 29327, 29856, 29833, 29305, 29328, 29857, 29834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19131, 29305, 29328, 29857, 29834, 29306, 29329, 29858, 29835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19132, 29306, 29329, 29858, 29835, 29307, 29330, 29859, 29836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19133, 29307, 29330, 29859, 29836, 29308, 29331, 29860, 29837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19134, 29308, 29331, 29860, 29837, 29309, 29332, 29861, 29838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19135, 29309, 29332, 29861, 29838, 29310, 29333, 29862, 29839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19136, 29310, 29333, 29862, 29839, 29311, 29334, 29863, 29840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19137, 29311, 29334, 29863, 29840, 29312, 29335, 29864, 29841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19138, 29312, 29335, 29864, 29841, 29313, 29336, 29865, 29842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19139, 29313, 29336, 29865, 29842, 29314, 29337, 29866, 29843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19140, 29314, 29337, 29866, 29843, 29315, 29338, 29867, 29844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19141, 29315, 29338, 29867, 29844, 29316, 29339, 29868, 29845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19142, 29316, 29339, 29868, 29845, 29317, 29340, 29869, 29846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19143, 29317, 29340, 29869, 29846, 29318, 29341, 29870, 29847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19144, 29318, 29341, 29870, 29847, 29319, 29342, 29871, 29848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19145, 29319, 29342, 29871, 29848, 29320, 29343, 29872, 29849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19146, 29320, 29343, 29872, 29849, 29321, 29344, 29873, 29850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19147, 29321, 29344, 29873, 29850, 29322, 29345, 29874, 29851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19148, 29322, 29345, 29874, 29851, 29323, 29346, 29875, 29852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19149, 29323, 29346, 29875, 29852, 8429, 8430, 8453, 8452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19150, 6613, 6614, 6637, 6636, 29324, 29347, 29876, 29853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19151, 29324, 29347, 29876, 29853, 29325, 29348, 29877, 29854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19152, 29325, 29348, 29877, 29854, 29326, 29349, 29878, 29855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19153, 29326, 29349, 29878, 29855, 29327, 29350, 29879, 29856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19154, 29327, 29350, 29879, 29856, 29328, 29351, 29880, 29857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19155, 29328, 29351, 29880, 29857, 29329, 29352, 29881, 29858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19156, 29329, 29352, 29881, 29858, 29330, 29353, 29882, 29859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19157, 29330, 29353, 29882, 29859, 29331, 29354, 29883, 29860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19158, 29331, 29354, 29883, 29860, 29332, 29355, 29884, 29861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19159, 29332, 29355, 29884, 29861, 29333, 29356, 29885, 29862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19160, 29333, 29356, 29885, 29862, 29334, 29357, 29886, 29863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19161, 29334, 29357, 29886, 29863, 29335, 29358, 29887, 29864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19162, 29335, 29358, 29887, 29864, 29336, 29359, 29888, 29865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19163, 29336, 29359, 29888, 29865, 29337, 29360, 29889, 29866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19164, 29337, 29360, 29889, 29866, 29338, 29361, 29890, 29867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19165, 29338, 29361, 29890, 29867, 29339, 29362, 29891, 29868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19166, 29339, 29362, 29891, 29868, 29340, 29363, 29892, 29869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19167, 29340, 29363, 29892, 29869, 29341, 29364, 29893, 29870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19168, 29341, 29364, 29893, 29870, 29342, 29365, 29894, 29871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19169, 29342, 29365, 29894, 29871, 29343, 29366, 29895, 29872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19170, 29343, 29366, 29895, 29872, 29344, 29367, 29896, 29873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19171, 29344, 29367, 29896, 29873, 29345, 29368, 29897, 29874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19172, 29345, 29368, 29897, 29874, 29346, 29369, 29898, 29875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19173, 29346, 29369, 29898, 29875, 8430, 8431, 8454, 8453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19174, 6614, 6615, 6638, 6637, 29347, 29370, 29899, 29876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19175, 29347, 29370, 29899, 29876, 29348, 29371, 29900, 29877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19176, 29348, 29371, 29900, 29877, 29349, 29372, 29901, 29878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19177, 29349, 29372, 29901, 29878, 29350, 29373, 29902, 29879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19178, 29350, 29373, 29902, 29879, 29351, 29374, 29903, 29880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19179, 29351, 29374, 29903, 29880, 29352, 29375, 29904, 29881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19180, 29352, 29375, 29904, 29881, 29353, 29376, 29905, 29882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19181, 29353, 29376, 29905, 29882, 29354, 29377, 29906, 29883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19182, 29354, 29377, 29906, 29883, 29355, 29378, 29907, 29884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19183, 29355, 29378, 29907, 29884, 29356, 29379, 29908, 29885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19184, 29356, 29379, 29908, 29885, 29357, 29380, 29909, 29886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19185, 29357, 29380, 29909, 29886, 29358, 29381, 29910, 29887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19186, 29358, 29381, 29910, 29887, 29359, 29382, 29911, 29888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19187, 29359, 29382, 29911, 29888, 29360, 29383, 29912, 29889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19188, 29360, 29383, 29912, 29889, 29361, 29384, 29913, 29890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19189, 29361, 29384, 29913, 29890, 29362, 29385, 29914, 29891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19190, 29362, 29385, 29914, 29891, 29363, 29386, 29915, 29892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19191, 29363, 29386, 29915, 29892, 29364, 29387, 29916, 29893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19192, 29364, 29387, 29916, 29893, 29365, 29388, 29917, 29894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19193, 29365, 29388, 29917, 29894, 29366, 29389, 29918, 29895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19194, 29366, 29389, 29918, 29895, 29367, 29390, 29919, 29896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19195, 29367, 29390, 29919, 29896, 29368, 29391, 29920, 29897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19196, 29368, 29391, 29920, 29897, 29369, 29392, 29921, 29898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19197, 29369, 29392, 29921, 29898, 8431, 8432, 8455, 8454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19198, 6615, 6616, 6639, 6638, 29370, 29393, 29922, 29899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19199, 29370, 29393, 29922, 29899, 29371, 29394, 29923, 29900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19200, 29371, 29394, 29923, 29900, 29372, 29395, 29924, 29901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19201, 29372, 29395, 29924, 29901, 29373, 29396, 29925, 29902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19202, 29373, 29396, 29925, 29902, 29374, 29397, 29926, 29903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19203, 29374, 29397, 29926, 29903, 29375, 29398, 29927, 29904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19204, 29375, 29398, 29927, 29904, 29376, 29399, 29928, 29905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19205, 29376, 29399, 29928, 29905, 29377, 29400, 29929, 29906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19206, 29377, 29400, 29929, 29906, 29378, 29401, 29930, 29907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19207, 29378, 29401, 29930, 29907, 29379, 29402, 29931, 29908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19208, 29379, 29402, 29931, 29908, 29380, 29403, 29932, 29909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19209, 29380, 29403, 29932, 29909, 29381, 29404, 29933, 29910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19210, 29381, 29404, 29933, 29910, 29382, 29405, 29934, 29911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19211, 29382, 29405, 29934, 29911, 29383, 29406, 29935, 29912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19212, 29383, 29406, 29935, 29912, 29384, 29407, 29936, 29913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19213, 29384, 29407, 29936, 29913, 29385, 29408, 29937, 29914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19214, 29385, 29408, 29937, 29914, 29386, 29409, 29938, 29915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19215, 29386, 29409, 29938, 29915, 29387, 29410, 29939, 29916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19216, 29387, 29410, 29939, 29916, 29388, 29411, 29940, 29917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19217, 29388, 29411, 29940, 29917, 29389, 29412, 29941, 29918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19218, 29389, 29412, 29941, 29918, 29390, 29413, 29942, 29919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19219, 29390, 29413, 29942, 29919, 29391, 29414, 29943, 29920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19220, 29391, 29414, 29943, 29920, 29392, 29415, 29944, 29921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19221, 29392, 29415, 29944, 29921, 8432, 8433, 8456, 8455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19222, 6616, 6617, 6640, 6639, 29393, 29416, 29945, 29922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19223, 29393, 29416, 29945, 29922, 29394, 29417, 29946, 29923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19224, 29394, 29417, 29946, 29923, 29395, 29418, 29947, 29924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19225, 29395, 29418, 29947, 29924, 29396, 29419, 29948, 29925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19226, 29396, 29419, 29948, 29925, 29397, 29420, 29949, 29926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19227, 29397, 29420, 29949, 29926, 29398, 29421, 29950, 29927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19228, 29398, 29421, 29950, 29927, 29399, 29422, 29951, 29928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19229, 29399, 29422, 29951, 29928, 29400, 29423, 29952, 29929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19230, 29400, 29423, 29952, 29929, 29401, 29424, 29953, 29930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19231, 29401, 29424, 29953, 29930, 29402, 29425, 29954, 29931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19232, 29402, 29425, 29954, 29931, 29403, 29426, 29955, 29932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19233, 29403, 29426, 29955, 29932, 29404, 29427, 29956, 29933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19234, 29404, 29427, 29956, 29933, 29405, 29428, 29957, 29934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19235, 29405, 29428, 29957, 29934, 29406, 29429, 29958, 29935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19236, 29406, 29429, 29958, 29935, 29407, 29430, 29959, 29936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19237, 29407, 29430, 29959, 29936, 29408, 29431, 29960, 29937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19238, 29408, 29431, 29960, 29937, 29409, 29432, 29961, 29938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19239, 29409, 29432, 29961, 29938, 29410, 29433, 29962, 29939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19240, 29410, 29433, 29962, 29939, 29411, 29434, 29963, 29940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19241, 29411, 29434, 29963, 29940, 29412, 29435, 29964, 29941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19242, 29412, 29435, 29964, 29941, 29413, 29436, 29965, 29942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19243, 29413, 29436, 29965, 29942, 29414, 29437, 29966, 29943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19244, 29414, 29437, 29966, 29943, 29415, 29438, 29967, 29944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19245, 29415, 29438, 29967, 29944, 8433, 8434, 8457, 8456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19246, 6617, 6618, 6641, 6640, 29416, 29439, 29968, 29945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19247, 29416, 29439, 29968, 29945, 29417, 29440, 29969, 29946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19248, 29417, 29440, 29969, 29946, 29418, 29441, 29970, 29947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19249, 29418, 29441, 29970, 29947, 29419, 29442, 29971, 29948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19250, 29419, 29442, 29971, 29948, 29420, 29443, 29972, 29949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19251, 29420, 29443, 29972, 29949, 29421, 29444, 29973, 29950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19252, 29421, 29444, 29973, 29950, 29422, 29445, 29974, 29951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19253, 29422, 29445, 29974, 29951, 29423, 29446, 29975, 29952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19254, 29423, 29446, 29975, 29952, 29424, 29447, 29976, 29953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19255, 29424, 29447, 29976, 29953, 29425, 29448, 29977, 29954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19256, 29425, 29448, 29977, 29954, 29426, 29449, 29978, 29955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19257, 29426, 29449, 29978, 29955, 29427, 29450, 29979, 29956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19258, 29427, 29450, 29979, 29956, 29428, 29451, 29980, 29957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19259, 29428, 29451, 29980, 29957, 29429, 29452, 29981, 29958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19260, 29429, 29452, 29981, 29958, 29430, 29453, 29982, 29959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19261, 29430, 29453, 29982, 29959, 29431, 29454, 29983, 29960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19262, 29431, 29454, 29983, 29960, 29432, 29455, 29984, 29961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19263, 29432, 29455, 29984, 29961, 29433, 29456, 29985, 29962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19264, 29433, 29456, 29985, 29962, 29434, 29457, 29986, 29963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19265, 29434, 29457, 29986, 29963, 29435, 29458, 29987, 29964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19266, 29435, 29458, 29987, 29964, 29436, 29459, 29988, 29965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19267, 29436, 29459, 29988, 29965, 29437, 29460, 29989, 29966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19268, 29437, 29460, 29989, 29966, 29438, 29461, 29990, 29967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19269, 29438, 29461, 29990, 29967, 8434, 8435, 8458, 8457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19270, 6618, 6619, 6642, 6641, 29439, 29462, 29991, 29968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19271, 29439, 29462, 29991, 29968, 29440, 29463, 29992, 29969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19272, 29440, 29463, 29992, 29969, 29441, 29464, 29993, 29970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19273, 29441, 29464, 29993, 29970, 29442, 29465, 29994, 29971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19274, 29442, 29465, 29994, 29971, 29443, 29466, 29995, 29972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19275, 29443, 29466, 29995, 29972, 29444, 29467, 29996, 29973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19276, 29444, 29467, 29996, 29973, 29445, 29468, 29997, 29974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19277, 29445, 29468, 29997, 29974, 29446, 29469, 29998, 29975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19278, 29446, 29469, 29998, 29975, 29447, 29470, 29999, 29976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19279, 29447, 29470, 29999, 29976, 29448, 29471, 30000, 29977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19280, 29448, 29471, 30000, 29977, 29449, 29472, 30001, 29978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19281, 29449, 29472, 30001, 29978, 29450, 29473, 30002, 29979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19282, 29450, 29473, 30002, 29979, 29451, 29474, 30003, 29980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19283, 29451, 29474, 30003, 29980, 29452, 29475, 30004, 29981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19284, 29452, 29475, 30004, 29981, 29453, 29476, 30005, 29982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19285, 29453, 29476, 30005, 29982, 29454, 29477, 30006, 29983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19286, 29454, 29477, 30006, 29983, 29455, 29478, 30007, 29984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19287, 29455, 29478, 30007, 29984, 29456, 29479, 30008, 29985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19288, 29456, 29479, 30008, 29985, 29457, 29480, 30009, 29986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19289, 29457, 29480, 30009, 29986, 29458, 29481, 30010, 29987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19290, 29458, 29481, 30010, 29987, 29459, 29482, 30011, 29988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19291, 29459, 29482, 30011, 29988, 29460, 29483, 30012, 29989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19292, 29460, 29483, 30012, 29989, 29461, 29484, 30013, 29990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19293, 29461, 29484, 30013, 29990, 8435, 8436, 8459, 8458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19294, 6619, 6620, 6643, 6642, 29462, 29485, 30014, 29991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19295, 29462, 29485, 30014, 29991, 29463, 29486, 30015, 29992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19296, 29463, 29486, 30015, 29992, 29464, 29487, 30016, 29993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19297, 29464, 29487, 30016, 29993, 29465, 29488, 30017, 29994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19298, 29465, 29488, 30017, 29994, 29466, 29489, 30018, 29995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19299, 29466, 29489, 30018, 29995, 29467, 29490, 30019, 29996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19300, 29467, 29490, 30019, 29996, 29468, 29491, 30020, 29997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19301, 29468, 29491, 30020, 29997, 29469, 29492, 30021, 29998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19302, 29469, 29492, 30021, 29998, 29470, 29493, 30022, 29999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19303, 29470, 29493, 30022, 29999, 29471, 29494, 30023, 30000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19304, 29471, 29494, 30023, 30000, 29472, 29495, 30024, 30001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19305, 29472, 29495, 30024, 30001, 29473, 29496, 30025, 30002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19306, 29473, 29496, 30025, 30002, 29474, 29497, 30026, 30003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19307, 29474, 29497, 30026, 30003, 29475, 29498, 30027, 30004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19308, 29475, 29498, 30027, 30004, 29476, 29499, 30028, 30005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19309, 29476, 29499, 30028, 30005, 29477, 29500, 30029, 30006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19310, 29477, 29500, 30029, 30006, 29478, 29501, 30030, 30007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19311, 29478, 29501, 30030, 30007, 29479, 29502, 30031, 30008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19312, 29479, 29502, 30031, 30008, 29480, 29503, 30032, 30009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19313, 29480, 29503, 30032, 30009, 29481, 29504, 30033, 30010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19314, 29481, 29504, 30033, 30010, 29482, 29505, 30034, 30011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19315, 29482, 29505, 30034, 30011, 29483, 29506, 30035, 30012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19316, 29483, 29506, 30035, 30012, 29484, 29507, 30036, 30013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19317, 29484, 29507, 30036, 30013, 8436, 8437, 8460, 8459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19318, 6620, 6621, 6644, 6643, 29485, 29508, 30037, 30014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19319, 29485, 29508, 30037, 30014, 29486, 29509, 30038, 30015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19320, 29486, 29509, 30038, 30015, 29487, 29510, 30039, 30016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19321, 29487, 29510, 30039, 30016, 29488, 29511, 30040, 30017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19322, 29488, 29511, 30040, 30017, 29489, 29512, 30041, 30018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19323, 29489, 29512, 30041, 30018, 29490, 29513, 30042, 30019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19324, 29490, 29513, 30042, 30019, 29491, 29514, 30043, 30020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19325, 29491, 29514, 30043, 30020, 29492, 29515, 30044, 30021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19326, 29492, 29515, 30044, 30021, 29493, 29516, 30045, 30022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19327, 29493, 29516, 30045, 30022, 29494, 29517, 30046, 30023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19328, 29494, 29517, 30046, 30023, 29495, 29518, 30047, 30024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19329, 29495, 29518, 30047, 30024, 29496, 29519, 30048, 30025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19330, 29496, 29519, 30048, 30025, 29497, 29520, 30049, 30026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19331, 29497, 29520, 30049, 30026, 29498, 29521, 30050, 30027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19332, 29498, 29521, 30050, 30027, 29499, 29522, 30051, 30028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19333, 29499, 29522, 30051, 30028, 29500, 29523, 30052, 30029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19334, 29500, 29523, 30052, 30029, 29501, 29524, 30053, 30030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19335, 29501, 29524, 30053, 30030, 29502, 29525, 30054, 30031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19336, 29502, 29525, 30054, 30031, 29503, 29526, 30055, 30032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19337, 29503, 29526, 30055, 30032, 29504, 29527, 30056, 30033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19338, 29504, 29527, 30056, 30033, 29505, 29528, 30057, 30034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19339, 29505, 29528, 30057, 30034, 29506, 29529, 30058, 30035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19340, 29506, 29529, 30058, 30035, 29507, 29530, 30059, 30036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19341, 29507, 29530, 30059, 30036, 8437, 8438, 8461, 8460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19342, 6621, 6622, 6645, 6644, 29508, 29531, 30060, 30037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19343, 29508, 29531, 30060, 30037, 29509, 29532, 30061, 30038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19344, 29509, 29532, 30061, 30038, 29510, 29533, 30062, 30039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19345, 29510, 29533, 30062, 30039, 29511, 29534, 30063, 30040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19346, 29511, 29534, 30063, 30040, 29512, 29535, 30064, 30041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19347, 29512, 29535, 30064, 30041, 29513, 29536, 30065, 30042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19348, 29513, 29536, 30065, 30042, 29514, 29537, 30066, 30043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19349, 29514, 29537, 30066, 30043, 29515, 29538, 30067, 30044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19350, 29515, 29538, 30067, 30044, 29516, 29539, 30068, 30045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19351, 29516, 29539, 30068, 30045, 29517, 29540, 30069, 30046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19352, 29517, 29540, 30069, 30046, 29518, 29541, 30070, 30047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19353, 29518, 29541, 30070, 30047, 29519, 29542, 30071, 30048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19354, 29519, 29542, 30071, 30048, 29520, 29543, 30072, 30049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19355, 29520, 29543, 30072, 30049, 29521, 29544, 30073, 30050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19356, 29521, 29544, 30073, 30050, 29522, 29545, 30074, 30051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19357, 29522, 29545, 30074, 30051, 29523, 29546, 30075, 30052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19358, 29523, 29546, 30075, 30052, 29524, 29547, 30076, 30053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19359, 29524, 29547, 30076, 30053, 29525, 29548, 30077, 30054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19360, 29525, 29548, 30077, 30054, 29526, 29549, 30078, 30055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19361, 29526, 29549, 30078, 30055, 29527, 29550, 30079, 30056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19362, 29527, 29550, 30079, 30056, 29528, 29551, 30080, 30057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19363, 29528, 29551, 30080, 30057, 29529, 29552, 30081, 30058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19364, 29529, 29552, 30081, 30058, 29530, 29553, 30082, 30059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19365, 29530, 29553, 30082, 30059, 8438, 8439, 8462, 8461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19366, 6622, 835, 836, 6645, 29531, 8164, 8187, 30060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19367, 29531, 8164, 8187, 30060, 29532, 8165, 8188, 30061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19368, 29532, 8165, 8188, 30061, 29533, 8166, 8189, 30062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19369, 29533, 8166, 8189, 30062, 29534, 8167, 8190, 30063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19370, 29534, 8167, 8190, 30063, 29535, 8168, 8191, 30064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19371, 29535, 8168, 8191, 30064, 29536, 8169, 8192, 30065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19372, 29536, 8169, 8192, 30065, 29537, 8170, 8193, 30066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19373, 29537, 8170, 8193, 30066, 29538, 8171, 8194, 30067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19374, 29538, 8171, 8194, 30067, 29539, 8172, 8195, 30068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19375, 29539, 8172, 8195, 30068, 29540, 8173, 8196, 30069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19376, 29540, 8173, 8196, 30069, 29541, 8174, 8197, 30070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19377, 29541, 8174, 8197, 30070, 29542, 8175, 8198, 30071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19378, 29542, 8175, 8198, 30071, 29543, 8176, 8199, 30072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19379, 29543, 8176, 8199, 30072, 29544, 8177, 8200, 30073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19380, 29544, 8177, 8200, 30073, 29545, 8178, 8201, 30074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19381, 29545, 8178, 8201, 30074, 29546, 8179, 8202, 30075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19382, 29546, 8179, 8202, 30075, 29547, 8180, 8203, 30076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19383, 29547, 8180, 8203, 30076, 29548, 8181, 8204, 30077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19384, 29548, 8181, 8204, 30077, 29549, 8182, 8205, 30078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19385, 29549, 8182, 8205, 30078, 29550, 8183, 8206, 30079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19386, 29550, 8183, 8206, 30079, 29551, 8184, 8207, 30080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19387, 29551, 8184, 8207, 30080, 29552, 8185, 8208, 30081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19388, 29552, 8185, 8208, 30081, 29553, 8186, 8209, 30082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19389, 29553, 8186, 8209, 30082, 8439, 995, 996, 8462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19390, 825, 6623, 6646, 826, 7934, 29554, 30083, 7957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19391, 7934, 29554, 30083, 7957, 7935, 29555, 30084, 7958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19392, 7935, 29555, 30084, 7958, 7936, 29556, 30085, 7959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19393, 7936, 29556, 30085, 7959, 7937, 29557, 30086, 7960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19394, 7937, 29557, 30086, 7960, 7938, 29558, 30087, 7961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19395, 7938, 29558, 30087, 7961, 7939, 29559, 30088, 7962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19396, 7939, 29559, 30088, 7962, 7940, 29560, 30089, 7963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19397, 7940, 29560, 30089, 7963, 7941, 29561, 30090, 7964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19398, 7941, 29561, 30090, 7964, 7942, 29562, 30091, 7965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19399, 7942, 29562, 30091, 7965, 7943, 29563, 30092, 7966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19400, 7943, 29563, 30092, 7966, 7944, 29564, 30093, 7967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19401, 7944, 29564, 30093, 7967, 7945, 29565, 30094, 7968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19402, 7945, 29565, 30094, 7968, 7946, 29566, 30095, 7969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19403, 7946, 29566, 30095, 7969, 7947, 29567, 30096, 7970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19404, 7947, 29567, 30096, 7970, 7948, 29568, 30097, 7971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19405, 7948, 29568, 30097, 7971, 7949, 29569, 30098, 7972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19406, 7949, 29569, 30098, 7972, 7950, 29570, 30099, 7973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19407, 7950, 29570, 30099, 7973, 7951, 29571, 30100, 7974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19408, 7951, 29571, 30100, 7974, 7952, 29572, 30101, 7975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19409, 7952, 29572, 30101, 7975, 7953, 29573, 30102, 7976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19410, 7953, 29573, 30102, 7976, 7954, 29574, 30103, 7977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19411, 7954, 29574, 30103, 7977, 7955, 29575, 30104, 7978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19412, 7955, 29575, 30104, 7978, 7956, 29576, 30105, 7979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19413, 7956, 29576, 30105, 7979, 985, 8440, 8463, 986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19414, 6623, 6624, 6647, 6646, 29554, 29577, 30106, 30083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19415, 29554, 29577, 30106, 30083, 29555, 29578, 30107, 30084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19416, 29555, 29578, 30107, 30084, 29556, 29579, 30108, 30085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19417, 29556, 29579, 30108, 30085, 29557, 29580, 30109, 30086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19418, 29557, 29580, 30109, 30086, 29558, 29581, 30110, 30087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19419, 29558, 29581, 30110, 30087, 29559, 29582, 30111, 30088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19420, 29559, 29582, 30111, 30088, 29560, 29583, 30112, 30089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19421, 29560, 29583, 30112, 30089, 29561, 29584, 30113, 30090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19422, 29561, 29584, 30113, 30090, 29562, 29585, 30114, 30091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19423, 29562, 29585, 30114, 30091, 29563, 29586, 30115, 30092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19424, 29563, 29586, 30115, 30092, 29564, 29587, 30116, 30093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19425, 29564, 29587, 30116, 30093, 29565, 29588, 30117, 30094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19426, 29565, 29588, 30117, 30094, 29566, 29589, 30118, 30095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19427, 29566, 29589, 30118, 30095, 29567, 29590, 30119, 30096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19428, 29567, 29590, 30119, 30096, 29568, 29591, 30120, 30097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19429, 29568, 29591, 30120, 30097, 29569, 29592, 30121, 30098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19430, 29569, 29592, 30121, 30098, 29570, 29593, 30122, 30099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19431, 29570, 29593, 30122, 30099, 29571, 29594, 30123, 30100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19432, 29571, 29594, 30123, 30100, 29572, 29595, 30124, 30101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19433, 29572, 29595, 30124, 30101, 29573, 29596, 30125, 30102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19434, 29573, 29596, 30125, 30102, 29574, 29597, 30126, 30103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19435, 29574, 29597, 30126, 30103, 29575, 29598, 30127, 30104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19436, 29575, 29598, 30127, 30104, 29576, 29599, 30128, 30105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19437, 29576, 29599, 30128, 30105, 8440, 8441, 8464, 8463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19438, 6624, 6625, 6648, 6647, 29577, 29600, 30129, 30106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19439, 29577, 29600, 30129, 30106, 29578, 29601, 30130, 30107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19440, 29578, 29601, 30130, 30107, 29579, 29602, 30131, 30108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19441, 29579, 29602, 30131, 30108, 29580, 29603, 30132, 30109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19442, 29580, 29603, 30132, 30109, 29581, 29604, 30133, 30110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19443, 29581, 29604, 30133, 30110, 29582, 29605, 30134, 30111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19444, 29582, 29605, 30134, 30111, 29583, 29606, 30135, 30112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19445, 29583, 29606, 30135, 30112, 29584, 29607, 30136, 30113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19446, 29584, 29607, 30136, 30113, 29585, 29608, 30137, 30114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19447, 29585, 29608, 30137, 30114, 29586, 29609, 30138, 30115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19448, 29586, 29609, 30138, 30115, 29587, 29610, 30139, 30116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19449, 29587, 29610, 30139, 30116, 29588, 29611, 30140, 30117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19450, 29588, 29611, 30140, 30117, 29589, 29612, 30141, 30118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19451, 29589, 29612, 30141, 30118, 29590, 29613, 30142, 30119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19452, 29590, 29613, 30142, 30119, 29591, 29614, 30143, 30120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19453, 29591, 29614, 30143, 30120, 29592, 29615, 30144, 30121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19454, 29592, 29615, 30144, 30121, 29593, 29616, 30145, 30122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19455, 29593, 29616, 30145, 30122, 29594, 29617, 30146, 30123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19456, 29594, 29617, 30146, 30123, 29595, 29618, 30147, 30124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19457, 29595, 29618, 30147, 30124, 29596, 29619, 30148, 30125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19458, 29596, 29619, 30148, 30125, 29597, 29620, 30149, 30126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19459, 29597, 29620, 30149, 30126, 29598, 29621, 30150, 30127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19460, 29598, 29621, 30150, 30127, 29599, 29622, 30151, 30128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19461, 29599, 29622, 30151, 30128, 8441, 8442, 8465, 8464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19462, 6625, 6626, 6649, 6648, 29600, 29623, 30152, 30129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19463, 29600, 29623, 30152, 30129, 29601, 29624, 30153, 30130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19464, 29601, 29624, 30153, 30130, 29602, 29625, 30154, 30131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19465, 29602, 29625, 30154, 30131, 29603, 29626, 30155, 30132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19466, 29603, 29626, 30155, 30132, 29604, 29627, 30156, 30133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19467, 29604, 29627, 30156, 30133, 29605, 29628, 30157, 30134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19468, 29605, 29628, 30157, 30134, 29606, 29629, 30158, 30135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19469, 29606, 29629, 30158, 30135, 29607, 29630, 30159, 30136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19470, 29607, 29630, 30159, 30136, 29608, 29631, 30160, 30137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19471, 29608, 29631, 30160, 30137, 29609, 29632, 30161, 30138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19472, 29609, 29632, 30161, 30138, 29610, 29633, 30162, 30139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19473, 29610, 29633, 30162, 30139, 29611, 29634, 30163, 30140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19474, 29611, 29634, 30163, 30140, 29612, 29635, 30164, 30141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19475, 29612, 29635, 30164, 30141, 29613, 29636, 30165, 30142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19476, 29613, 29636, 30165, 30142, 29614, 29637, 30166, 30143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19477, 29614, 29637, 30166, 30143, 29615, 29638, 30167, 30144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19478, 29615, 29638, 30167, 30144, 29616, 29639, 30168, 30145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19479, 29616, 29639, 30168, 30145, 29617, 29640, 30169, 30146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19480, 29617, 29640, 30169, 30146, 29618, 29641, 30170, 30147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19481, 29618, 29641, 30170, 30147, 29619, 29642, 30171, 30148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19482, 29619, 29642, 30171, 30148, 29620, 29643, 30172, 30149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19483, 29620, 29643, 30172, 30149, 29621, 29644, 30173, 30150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19484, 29621, 29644, 30173, 30150, 29622, 29645, 30174, 30151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19485, 29622, 29645, 30174, 30151, 8442, 8443, 8466, 8465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19486, 6626, 6627, 6650, 6649, 29623, 29646, 30175, 30152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19487, 29623, 29646, 30175, 30152, 29624, 29647, 30176, 30153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19488, 29624, 29647, 30176, 30153, 29625, 29648, 30177, 30154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19489, 29625, 29648, 30177, 30154, 29626, 29649, 30178, 30155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19490, 29626, 29649, 30178, 30155, 29627, 29650, 30179, 30156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19491, 29627, 29650, 30179, 30156, 29628, 29651, 30180, 30157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19492, 29628, 29651, 30180, 30157, 29629, 29652, 30181, 30158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19493, 29629, 29652, 30181, 30158, 29630, 29653, 30182, 30159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19494, 29630, 29653, 30182, 30159, 29631, 29654, 30183, 30160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19495, 29631, 29654, 30183, 30160, 29632, 29655, 30184, 30161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19496, 29632, 29655, 30184, 30161, 29633, 29656, 30185, 30162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19497, 29633, 29656, 30185, 30162, 29634, 29657, 30186, 30163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19498, 29634, 29657, 30186, 30163, 29635, 29658, 30187, 30164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19499, 29635, 29658, 30187, 30164, 29636, 29659, 30188, 30165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19500, 29636, 29659, 30188, 30165, 29637, 29660, 30189, 30166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19501, 29637, 29660, 30189, 30166, 29638, 29661, 30190, 30167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19502, 29638, 29661, 30190, 30167, 29639, 29662, 30191, 30168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19503, 29639, 29662, 30191, 30168, 29640, 29663, 30192, 30169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19504, 29640, 29663, 30192, 30169, 29641, 29664, 30193, 30170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19505, 29641, 29664, 30193, 30170, 29642, 29665, 30194, 30171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19506, 29642, 29665, 30194, 30171, 29643, 29666, 30195, 30172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19507, 29643, 29666, 30195, 30172, 29644, 29667, 30196, 30173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19508, 29644, 29667, 30196, 30173, 29645, 29668, 30197, 30174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19509, 29645, 29668, 30197, 30174, 8443, 8444, 8467, 8466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19510, 6627, 6628, 6651, 6650, 29646, 29669, 30198, 30175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19511, 29646, 29669, 30198, 30175, 29647, 29670, 30199, 30176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19512, 29647, 29670, 30199, 30176, 29648, 29671, 30200, 30177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19513, 29648, 29671, 30200, 30177, 29649, 29672, 30201, 30178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19514, 29649, 29672, 30201, 30178, 29650, 29673, 30202, 30179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19515, 29650, 29673, 30202, 30179, 29651, 29674, 30203, 30180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19516, 29651, 29674, 30203, 30180, 29652, 29675, 30204, 30181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19517, 29652, 29675, 30204, 30181, 29653, 29676, 30205, 30182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19518, 29653, 29676, 30205, 30182, 29654, 29677, 30206, 30183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19519, 29654, 29677, 30206, 30183, 29655, 29678, 30207, 30184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19520, 29655, 29678, 30207, 30184, 29656, 29679, 30208, 30185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19521, 29656, 29679, 30208, 30185, 29657, 29680, 30209, 30186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19522, 29657, 29680, 30209, 30186, 29658, 29681, 30210, 30187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19523, 29658, 29681, 30210, 30187, 29659, 29682, 30211, 30188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19524, 29659, 29682, 30211, 30188, 29660, 29683, 30212, 30189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19525, 29660, 29683, 30212, 30189, 29661, 29684, 30213, 30190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19526, 29661, 29684, 30213, 30190, 29662, 29685, 30214, 30191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19527, 29662, 29685, 30214, 30191, 29663, 29686, 30215, 30192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19528, 29663, 29686, 30215, 30192, 29664, 29687, 30216, 30193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19529, 29664, 29687, 30216, 30193, 29665, 29688, 30217, 30194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19530, 29665, 29688, 30217, 30194, 29666, 29689, 30218, 30195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19531, 29666, 29689, 30218, 30195, 29667, 29690, 30219, 30196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19532, 29667, 29690, 30219, 30196, 29668, 29691, 30220, 30197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19533, 29668, 29691, 30220, 30197, 8444, 8445, 8468, 8467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19534, 6628, 6629, 6652, 6651, 29669, 29692, 30221, 30198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19535, 29669, 29692, 30221, 30198, 29670, 29693, 30222, 30199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19536, 29670, 29693, 30222, 30199, 29671, 29694, 30223, 30200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19537, 29671, 29694, 30223, 30200, 29672, 29695, 30224, 30201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19538, 29672, 29695, 30224, 30201, 29673, 29696, 30225, 30202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19539, 29673, 29696, 30225, 30202, 29674, 29697, 30226, 30203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19540, 29674, 29697, 30226, 30203, 29675, 29698, 30227, 30204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19541, 29675, 29698, 30227, 30204, 29676, 29699, 30228, 30205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19542, 29676, 29699, 30228, 30205, 29677, 29700, 30229, 30206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19543, 29677, 29700, 30229, 30206, 29678, 29701, 30230, 30207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19544, 29678, 29701, 30230, 30207, 29679, 29702, 30231, 30208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19545, 29679, 29702, 30231, 30208, 29680, 29703, 30232, 30209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19546, 29680, 29703, 30232, 30209, 29681, 29704, 30233, 30210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19547, 29681, 29704, 30233, 30210, 29682, 29705, 30234, 30211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19548, 29682, 29705, 30234, 30211, 29683, 29706, 30235, 30212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19549, 29683, 29706, 30235, 30212, 29684, 29707, 30236, 30213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19550, 29684, 29707, 30236, 30213, 29685, 29708, 30237, 30214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19551, 29685, 29708, 30237, 30214, 29686, 29709, 30238, 30215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19552, 29686, 29709, 30238, 30215, 29687, 29710, 30239, 30216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19553, 29687, 29710, 30239, 30216, 29688, 29711, 30240, 30217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19554, 29688, 29711, 30240, 30217, 29689, 29712, 30241, 30218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19555, 29689, 29712, 30241, 30218, 29690, 29713, 30242, 30219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19556, 29690, 29713, 30242, 30219, 29691, 29714, 30243, 30220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19557, 29691, 29714, 30243, 30220, 8445, 8446, 8469, 8468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19558, 6629, 6630, 6653, 6652, 29692, 29715, 30244, 30221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19559, 29692, 29715, 30244, 30221, 29693, 29716, 30245, 30222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19560, 29693, 29716, 30245, 30222, 29694, 29717, 30246, 30223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19561, 29694, 29717, 30246, 30223, 29695, 29718, 30247, 30224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19562, 29695, 29718, 30247, 30224, 29696, 29719, 30248, 30225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19563, 29696, 29719, 30248, 30225, 29697, 29720, 30249, 30226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19564, 29697, 29720, 30249, 30226, 29698, 29721, 30250, 30227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19565, 29698, 29721, 30250, 30227, 29699, 29722, 30251, 30228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19566, 29699, 29722, 30251, 30228, 29700, 29723, 30252, 30229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19567, 29700, 29723, 30252, 30229, 29701, 29724, 30253, 30230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19568, 29701, 29724, 30253, 30230, 29702, 29725, 30254, 30231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19569, 29702, 29725, 30254, 30231, 29703, 29726, 30255, 30232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19570, 29703, 29726, 30255, 30232, 29704, 29727, 30256, 30233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19571, 29704, 29727, 30256, 30233, 29705, 29728, 30257, 30234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19572, 29705, 29728, 30257, 30234, 29706, 29729, 30258, 30235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19573, 29706, 29729, 30258, 30235, 29707, 29730, 30259, 30236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19574, 29707, 29730, 30259, 30236, 29708, 29731, 30260, 30237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19575, 29708, 29731, 30260, 30237, 29709, 29732, 30261, 30238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19576, 29709, 29732, 30261, 30238, 29710, 29733, 30262, 30239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19577, 29710, 29733, 30262, 30239, 29711, 29734, 30263, 30240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19578, 29711, 29734, 30263, 30240, 29712, 29735, 30264, 30241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19579, 29712, 29735, 30264, 30241, 29713, 29736, 30265, 30242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19580, 29713, 29736, 30265, 30242, 29714, 29737, 30266, 30243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19581, 29714, 29737, 30266, 30243, 8446, 8447, 8470, 8469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19582, 6630, 6631, 6654, 6653, 29715, 29738, 30267, 30244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19583, 29715, 29738, 30267, 30244, 29716, 29739, 30268, 30245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19584, 29716, 29739, 30268, 30245, 29717, 29740, 30269, 30246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19585, 29717, 29740, 30269, 30246, 29718, 29741, 30270, 30247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19586, 29718, 29741, 30270, 30247, 29719, 29742, 30271, 30248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19587, 29719, 29742, 30271, 30248, 29720, 29743, 30272, 30249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19588, 29720, 29743, 30272, 30249, 29721, 29744, 30273, 30250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19589, 29721, 29744, 30273, 30250, 29722, 29745, 30274, 30251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19590, 29722, 29745, 30274, 30251, 29723, 29746, 30275, 30252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19591, 29723, 29746, 30275, 30252, 29724, 29747, 30276, 30253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19592, 29724, 29747, 30276, 30253, 29725, 29748, 30277, 30254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19593, 29725, 29748, 30277, 30254, 29726, 29749, 30278, 30255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19594, 29726, 29749, 30278, 30255, 29727, 29750, 30279, 30256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19595, 29727, 29750, 30279, 30256, 29728, 29751, 30280, 30257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19596, 29728, 29751, 30280, 30257, 29729, 29752, 30281, 30258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19597, 29729, 29752, 30281, 30258, 29730, 29753, 30282, 30259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19598, 29730, 29753, 30282, 30259, 29731, 29754, 30283, 30260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19599, 29731, 29754, 30283, 30260, 29732, 29755, 30284, 30261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
19600, 29732, 29755, 30284, 30261, 29733, 29756, 30285, 30262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
