54202, 2.0333333333333, -0.02, 0.29166666666667
54203, 2.0333333333333, -0.04, 0.27083333333333
54204, 2.0125, -0.04, 0.29166666666667
54205, 2.0333333333333, -0.06, 0.29166666666667
54206, 2.0333333333333, -0.08, 0.27083333333333
54207, 2.0125, -0.08, 0.29166666666667
54208, 2.0333333333333, -0.1, 0.29166666666667
54209, 2.0333333333333, -0.12, 0.27083333333333
54210, 2.0125, -0.12, 0.29166666666667
54211, 2.0333333333333, -0.14, 0.29166666666667
54212, 2.0333333333333, -0.16, 0.27083333333333
54213, 2.0125, -0.16, 0.29166666666667
54214, 2.0333333333333, -0.18, 0.29166666666667
54215, 2.075, -0.02, 0.29166666666667
54216, 2.075, -0.04, 0.27083333333333
54217, 2.0541666666667, -0.04, 0.29166666666667
54218, 2.075, -0.06, 0.29166666666667
54219, 2.075, -0.08, 0.27083333333333
54220, 2.0541666666667, -0.08, 0.29166666666667
54221, 2.075, -0.1, 0.29166666666667
54222, 2.075, -0.12, 0.27083333333333
54223, 2.0541666666667, -0.12, 0.29166666666667
54224, 2.075, -0.14, 0.29166666666667
54225, 2.075, -0.16, 0.27083333333333
54226, 2.0541666666667, -0.16, 0.29166666666667
54227, 2.075, -0.18, 0.29166666666667
54228, 2.1166666666667, -0.02, 0.29166666666667
54229, 2.1166666666667, -0.04, 0.27083333333333
54230, 2.0958333333333, -0.04, 0.29166666666667
54231, 2.1166666666667, -0.06, 0.29166666666667
54232, 2.1166666666667, -0.08, 0.27083333333333
54233, 2.0958333333333, -0.08, 0.29166666666667
54234, 2.1166666666667, -0.1, 0.29166666666667
54235, 2.1166666666667, -0.12, 0.27083333333333
54236, 2.0958333333333, -0.12, 0.29166666666667
54237, 2.1166666666667, -0.14, 0.29166666666667
54238, 2.1166666666667, -0.16, 0.27083333333333
54239, 2.0958333333333, -0.16, 0.29166666666667
54240, 2.1166666666667, -0.18, 0.29166666666667
54241, 2.1583333333333, -0.02, 0.29166666666667
54242, 2.1583333333333, -0.04, 0.27083333333333
54243, 2.1375, -0.04, 0.29166666666667
54244, 2.1583333333333, -0.06, 0.29166666666667
54245, 2.1583333333333, -0.08, 0.27083333333333
54246, 2.1375, -0.08, 0.29166666666667
54247, 2.1583333333333, -0.1, 0.29166666666667
54248, 2.1583333333333, -0.12, 0.27083333333333
54249, 2.1375, -0.12, 0.29166666666667
54250, 2.1583333333333, -0.14, 0.29166666666667
54251, 2.1583333333333, -0.16, 0.27083333333333
54252, 2.1375, -0.16, 0.29166666666667
54253, 2.1583333333333, -0.18, 0.29166666666667
54254, 2.1791666666667, -0.04, 0.29166666666667
54255, 2.1791666666667, -0.08, 0.29166666666667
54256, 2.1791666666667, -0.12, 0.29166666666667
54257, 2.1791666666667, -0.16, 0.29166666666667
54258, 1.2416666666667, -0.02, 0.33333333333333
54259, 1.2416666666667, -0.04, 0.3125
54260, 1.2208333333333, -0.04, 0.33333333333333
54261, 1.2416666666667, -0.06, 0.33333333333333
54262, 1.2416666666667, -0.08, 0.3125
54263, 1.2208333333333, -0.08, 0.33333333333333
54264, 1.2416666666667, -0.1, 0.33333333333333
54265, 1.2416666666667, -0.12, 0.3125
54266, 1.2208333333333, -0.12, 0.33333333333333
54267, 1.2416666666667, -0.14, 0.33333333333333
54268, 1.2416666666667, -0.16, 0.3125
54269, 1.2208333333333, -0.16, 0.33333333333333
54270, 1.2416666666667, -0.18, 0.33333333333333
54271, 1.2833333333333, -0.02, 0.33333333333333
54272, 1.2833333333333, -0.04, 0.3125
54273, 1.2625, -0.04, 0.33333333333333
54274, 1.2833333333333, -0.06, 0.33333333333333
54275, 1.2833333333333, -0.08, 0.3125
54276, 1.2625, -0.08, 0.33333333333333
54277, 1.2833333333333, -0.1, 0.33333333333333
54278, 1.2833333333333, -0.12, 0.3125
54279, 1.2625, -0.12, 0.33333333333333
54280, 1.2833333333333, -0.14, 0.33333333333333
54281, 1.2833333333333, -0.16, 0.3125
54282, 1.2625, -0.16, 0.33333333333333
54283, 1.2833333333333, -0.18, 0.33333333333333
54284, 1.325, -0.02, 0.33333333333333
54285, 1.325, -0.04, 0.3125
54286, 1.3041666666667, -0.04, 0.33333333333333
54287, 1.325, -0.06, 0.33333333333333
54288, 1.325, -0.08, 0.3125
54289, 1.3041666666667, -0.08, 0.33333333333333
54290, 1.325, -0.1, 0.33333333333333
54291, 1.325, -0.12, 0.3125
54292, 1.3041666666667, -0.12, 0.33333333333333
54293, 1.325, -0.14, 0.33333333333333
54294, 1.325, -0.16, 0.3125
54295, 1.3041666666667, -0.16, 0.33333333333333
54296, 1.325, -0.18, 0.33333333333333
54297, 1.3666666666667, -0.02, 0.33333333333333
54298, 1.3666666666667, -0.04, 0.3125
54299, 1.3458333333333, -0.04, 0.33333333333333
54300, 1.3666666666667, -0.06, 0.33333333333333
54301, 1.3666666666667, -0.08, 0.3125
54302, 1.3458333333333, -0.08, 0.33333333333333
54303, 1.3666666666667, -0.1, 0.33333333333333
54304, 1.3666666666667, -0.12, 0.3125
54305, 1.3458333333333, -0.12, 0.33333333333333
54306, 1.3666666666667, -0.14, 0.33333333333333
54307, 1.3666666666667, -0.16, 0.3125
54308, 1.3458333333333, -0.16, 0.33333333333333
54309, 1.3666666666667, -0.18, 0.33333333333333
54310, 1.4083333333333, -0.02, 0.33333333333333
54311, 1.4083333333333, -0.04, 0.3125
54312, 1.3875, -0.04, 0.33333333333333
54313, 1.4083333333333, -0.06, 0.33333333333333
54314, 1.4083333333333, -0.08, 0.3125
54315, 1.3875, -0.08, 0.33333333333333
54316, 1.4083333333333, -0.1, 0.33333333333333
54317, 1.4083333333333, -0.12, 0.3125
54318, 1.3875, -0.12, 0.33333333333333
54319, 1.4083333333333, -0.14, 0.33333333333333
54320, 1.4083333333333, -0.16, 0.3125
54321, 1.3875, -0.16, 0.33333333333333
54322, 1.4083333333333, -0.18, 0.33333333333333
54323, 1.45, -0.02, 0.33333333333333
54324, 1.45, -0.04, 0.3125
54325, 1.4291666666667, -0.04, 0.33333333333333
54326, 1.45, -0.06, 0.33333333333333
54327, 1.45, -0.08, 0.3125
54328, 1.4291666666667, -0.08, 0.33333333333333
54329, 1.45, -0.1, 0.33333333333333
54330, 1.45, -0.12, 0.3125
54331, 1.4291666666667, -0.12, 0.33333333333333
54332, 1.45, -0.14, 0.33333333333333
54333, 1.45, -0.16, 0.3125
54334, 1.4291666666667, -0.16, 0.33333333333333
54335, 1.45, -0.18, 0.33333333333333
54336, 1.4916666666667, -0.02, 0.33333333333333
54337, 1.4916666666667, -0.04, 0.3125
54338, 1.4708333333333, -0.04, 0.33333333333333
54339, 1.4916666666667, -0.06, 0.33333333333333
54340, 1.4916666666667, -0.08, 0.3125
54341, 1.4708333333333, -0.08, 0.33333333333333
54342, 1.4916666666667, -0.1, 0.33333333333333
54343, 1.4916666666667, -0.12, 0.3125
54344, 1.4708333333333, -0.12, 0.33333333333333
54345, 1.4916666666667, -0.14, 0.33333333333333
54346, 1.4916666666667, -0.16, 0.3125
54347, 1.4708333333333, -0.16, 0.33333333333333
54348, 1.4916666666667, -0.18, 0.33333333333333
54349, 1.5333333333333, -0.02, 0.33333333333333
54350, 1.5333333333333, -0.04, 0.3125
54351, 1.5125, -0.04, 0.33333333333333
54352, 1.5333333333333, -0.06, 0.33333333333333
54353, 1.5333333333333, -0.08, 0.3125
54354, 1.5125, -0.08, 0.33333333333333
54355, 1.5333333333333, -0.1, 0.33333333333333
54356, 1.5333333333333, -0.12, 0.3125
54357, 1.5125, -0.12, 0.33333333333333
54358, 1.5333333333333, -0.14, 0.33333333333333
54359, 1.5333333333333, -0.16, 0.3125
54360, 1.5125, -0.16, 0.33333333333333
54361, 1.5333333333333, -0.18, 0.33333333333333
54362, 1.575, -0.02, 0.33333333333333
54363, 1.575, -0.04, 0.3125
54364, 1.5541666666667, -0.04, 0.33333333333333
54365, 1.575, -0.06, 0.33333333333333
54366, 1.575, -0.08, 0.3125
54367, 1.5541666666667, -0.08, 0.33333333333333
54368, 1.575, -0.1, 0.33333333333333
54369, 1.575, -0.12, 0.3125
54370, 1.5541666666667, -0.12, 0.33333333333333
54371, 1.575, -0.14, 0.33333333333333
54372, 1.575, -0.16, 0.3125
54373, 1.5541666666667, -0.16, 0.33333333333333
54374, 1.575, -0.18, 0.33333333333333
54375, 1.6166666666667, -0.02, 0.33333333333333
54376, 1.6166666666667, -0.04, 0.3125
54377, 1.5958333333333, -0.04, 0.33333333333333
54378, 1.6166666666667, -0.06, 0.33333333333333
54379, 1.6166666666667, -0.08, 0.3125
54380, 1.5958333333333, -0.08, 0.33333333333333
54381, 1.6166666666667, -0.1, 0.33333333333333
54382, 1.6166666666667, -0.12, 0.3125
54383, 1.5958333333333, -0.12, 0.33333333333333
54384, 1.6166666666667, -0.14, 0.33333333333333
54385, 1.6166666666667, -0.16, 0.3125
54386, 1.5958333333333, -0.16, 0.33333333333333
54387, 1.6166666666667, -0.18, 0.33333333333333
54388, 1.6583333333333, -0.02, 0.33333333333333
54389, 1.6583333333333, -0.04, 0.3125
54390, 1.6375, -0.04, 0.33333333333333
54391, 1.6583333333333, -0.06, 0.33333333333333
54392, 1.6583333333333, -0.08, 0.3125
54393, 1.6375, -0.08, 0.33333333333333
54394, 1.6583333333333, -0.1, 0.33333333333333
54395, 1.6583333333333, -0.12, 0.3125
54396, 1.6375, -0.12, 0.33333333333333
54397, 1.6583333333333, -0.14, 0.33333333333333
54398, 1.6583333333333, -0.16, 0.3125
54399, 1.6375, -0.16, 0.33333333333333
54400, 1.6583333333333, -0.18, 0.33333333333333
54401, 1.7, -0.02, 0.33333333333333
54402, 1.7, -0.04, 0.3125
54403, 1.6791666666667, -0.04, 0.33333333333333
54404, 1.7, -0.06, 0.33333333333333
54405, 1.7, -0.08, 0.3125
54406, 1.6791666666667, -0.08, 0.33333333333333
54407, 1.7, -0.1, 0.33333333333333
54408, 1.7, -0.12, 0.3125
54409, 1.6791666666667, -0.12, 0.33333333333333
54410, 1.7, -0.14, 0.33333333333333
54411, 1.7, -0.16, 0.3125
54412, 1.6791666666667, -0.16, 0.33333333333333
54413, 1.7, -0.18, 0.33333333333333
54414, 1.7416666666667, -0.02, 0.33333333333333
54415, 1.7416666666667, -0.04, 0.3125
54416, 1.7208333333333, -0.04, 0.33333333333333
54417, 1.7416666666667, -0.06, 0.33333333333333
54418, 1.7416666666667, -0.08, 0.3125
54419, 1.7208333333333, -0.08, 0.33333333333333
54420, 1.7416666666667, -0.1, 0.33333333333333
54421, 1.7416666666667, -0.12, 0.3125
54422, 1.7208333333333, -0.12, 0.33333333333333
54423, 1.7416666666667, -0.14, 0.33333333333333
54424, 1.7416666666667, -0.16, 0.3125
54425, 1.7208333333333, -0.16, 0.33333333333333
54426, 1.7416666666667, -0.18, 0.33333333333333
54427, 1.7833333333333, -0.02, 0.33333333333333
54428, 1.7833333333333, -0.04, 0.3125
54429, 1.7625, -0.04, 0.33333333333333
54430, 1.7833333333333, -0.06, 0.33333333333333
54431, 1.7833333333333, -0.08, 0.3125
54432, 1.7625, -0.08, 0.33333333333333
54433, 1.7833333333333, -0.1, 0.33333333333333
54434, 1.7833333333333, -0.12, 0.3125
54435, 1.7625, -0.12, 0.33333333333333
54436, 1.7833333333333, -0.14, 0.33333333333333
54437, 1.7833333333333, -0.16, 0.3125
54438, 1.7625, -0.16, 0.33333333333333
54439, 1.7833333333333, -0.18, 0.33333333333333
54440, 1.825, -0.02, 0.33333333333333
54441, 1.825, -0.04, 0.3125
54442, 1.8041666666667, -0.04, 0.33333333333333
54443, 1.825, -0.06, 0.33333333333333
54444, 1.825, -0.08, 0.3125
54445, 1.8041666666667, -0.08, 0.33333333333333
54446, 1.825, -0.1, 0.33333333333333
54447, 1.825, -0.12, 0.3125
54448, 1.8041666666667, -0.12, 0.33333333333333
54449, 1.825, -0.14, 0.33333333333333
54450, 1.825, -0.16, 0.3125
54451, 1.8041666666667, -0.16, 0.33333333333333
54452, 1.825, -0.18, 0.33333333333333
54453, 1.8666666666667, -0.02, 0.33333333333333
54454, 1.8666666666667, -0.04, 0.3125
54455, 1.8458333333333, -0.04, 0.33333333333333
54456, 1.8666666666667, -0.06, 0.33333333333333
54457, 1.8666666666667, -0.08, 0.3125
54458, 1.8458333333333, -0.08, 0.33333333333333
54459, 1.8666666666667, -0.1, 0.33333333333333
54460, 1.8666666666667, -0.12, 0.3125
54461, 1.8458333333333, -0.12, 0.33333333333333
54462, 1.8666666666667, -0.14, 0.33333333333333
54463, 1.8666666666667, -0.16, 0.3125
54464, 1.8458333333333, -0.16, 0.33333333333333
54465, 1.8666666666667, -0.18, 0.33333333333333
54466, 1.9083333333333, -0.02, 0.33333333333333
54467, 1.9083333333333, -0.04, 0.3125
54468, 1.8875, -0.04, 0.33333333333333
54469, 1.9083333333333, -0.06, 0.33333333333333
54470, 1.9083333333333, -0.08, 0.3125
54471, 1.8875, -0.08, 0.33333333333333
54472, 1.9083333333333, -0.1, 0.33333333333333
54473, 1.9083333333333, -0.12, 0.3125
54474, 1.8875, -0.12, 0.33333333333333
54475, 1.9083333333333, -0.14, 0.33333333333333
54476, 1.9083333333333, -0.16, 0.3125
54477, 1.8875, -0.16, 0.33333333333333
54478, 1.9083333333333, -0.18, 0.33333333333333
54479, 1.95, -0.02, 0.33333333333333
54480, 1.95, -0.04, 0.3125
54481, 1.9291666666667, -0.04, 0.33333333333333
54482, 1.95, -0.06, 0.33333333333333
54483, 1.95, -0.08, 0.3125
54484, 1.9291666666667, -0.08, 0.33333333333333
54485, 1.95, -0.1, 0.33333333333333
54486, 1.95, -0.12, 0.3125
54487, 1.9291666666667, -0.12, 0.33333333333333
54488, 1.95, -0.14, 0.33333333333333
54489, 1.95, -0.16, 0.3125
54490, 1.9291666666667, -0.16, 0.33333333333333
54491, 1.95, -0.18, 0.33333333333333
54492, 1.9916666666667, -0.02, 0.33333333333333
54493, 1.9916666666667, -0.04, 0.3125
54494, 1.9708333333333, -0.04, 0.33333333333333
54495, 1.9916666666667, -0.06, 0.33333333333333
54496, 1.9916666666667, -0.08, 0.3125
54497, 1.9708333333333, -0.08, 0.33333333333333
54498, 1.9916666666667, -0.1, 0.33333333333333
54499, 1.9916666666667, -0.12, 0.3125
54500, 1.9708333333333, -0.12, 0.33333333333333
54501, 1.9916666666667, -0.14, 0.33333333333333
54502, 1.9916666666667, -0.16, 0.3125
54503, 1.9708333333333, -0.16, 0.33333333333333
54504, 1.9916666666667, -0.18, 0.33333333333333
54505, 2.0333333333333, -0.02, 0.33333333333333
54506, 2.0333333333333, -0.04, 0.3125
54507, 2.0125, -0.04, 0.33333333333333
54508, 2.0333333333333, -0.06, 0.33333333333333
54509, 2.0333333333333, -0.08, 0.3125
54510, 2.0125, -0.08, 0.33333333333333
54511, 2.0333333333333, -0.1, 0.33333333333333
54512, 2.0333333333333, -0.12, 0.3125
54513, 2.0125, -0.12, 0.33333333333333
54514, 2.0333333333333, -0.14, 0.33333333333333
54515, 2.0333333333333, -0.16, 0.3125
54516, 2.0125, -0.16, 0.33333333333333
54517, 2.0333333333333, -0.18, 0.33333333333333
54518, 2.075, -0.02, 0.33333333333333
54519, 2.075, -0.04, 0.3125
54520, 2.0541666666667, -0.04, 0.33333333333333
54521, 2.075, -0.06, 0.33333333333333
54522, 2.075, -0.08, 0.3125
54523, 2.0541666666667, -0.08, 0.33333333333333
54524, 2.075, -0.1, 0.33333333333333
54525, 2.075, -0.12, 0.3125
54526, 2.0541666666667, -0.12, 0.33333333333333
54527, 2.075, -0.14, 0.33333333333333
54528, 2.075, -0.16, 0.3125
54529, 2.0541666666667, -0.16, 0.33333333333333
54530, 2.075, -0.18, 0.33333333333333
54531, 2.1166666666667, -0.02, 0.33333333333333
54532, 2.1166666666667, -0.04, 0.3125
54533, 2.0958333333333, -0.04, 0.33333333333333
54534, 2.1166666666667, -0.06, 0.33333333333333
54535, 2.1166666666667, -0.08, 0.3125
54536, 2.0958333333333, -0.08, 0.33333333333333
54537, 2.1166666666667, -0.1, 0.33333333333333
54538, 2.1166666666667, -0.12, 0.3125
54539, 2.0958333333333, -0.12, 0.33333333333333
54540, 2.1166666666667, -0.14, 0.33333333333333
54541, 2.1166666666667, -0.16, 0.3125
54542, 2.0958333333333, -0.16, 0.33333333333333
54543, 2.1166666666667, -0.18, 0.33333333333333
54544, 2.1583333333333, -0.02, 0.33333333333333
54545, 2.1583333333333, -0.04, 0.3125
54546, 2.1375, -0.04, 0.33333333333333
54547, 2.1583333333333, -0.06, 0.33333333333333
54548, 2.1583333333333, -0.08, 0.3125
54549, 2.1375, -0.08, 0.33333333333333
54550, 2.1583333333333, -0.1, 0.33333333333333
54551, 2.1583333333333, -0.12, 0.3125
54552, 2.1375, -0.12, 0.33333333333333
54553, 2.1583333333333, -0.14, 0.33333333333333
54554, 2.1583333333333, -0.16, 0.3125
54555, 2.1375, -0.16, 0.33333333333333
54556, 2.1583333333333, -0.18, 0.33333333333333
54557, 2.1791666666667, -0.04, 0.33333333333333
54558, 2.1791666666667, -0.08, 0.33333333333333
54559, 2.1791666666667, -0.12, 0.33333333333333
54560, 2.1791666666667, -0.16, 0.33333333333333
54561, 1.2416666666667, -0.02, 0.375
54562, 1.2416666666667, -0.04, 0.35416666666667
54563, 1.2208333333333, -0.04, 0.375
54564, 1.2416666666667, -0.06, 0.375
54565, 1.2416666666667, -0.08, 0.35416666666667
54566, 1.2208333333333, -0.08, 0.375
54567, 1.2416666666667, -0.1, 0.375
54568, 1.2416666666667, -0.12, 0.35416666666667
54569, 1.2208333333333, -0.12, 0.375
54570, 1.2416666666667, -0.14, 0.375
54571, 1.2416666666667, -0.16, 0.35416666666667
54572, 1.2208333333333, -0.16, 0.375
54573, 1.2416666666667, -0.18, 0.375
54574, 1.2833333333333, -0.02, 0.375
54575, 1.2833333333333, -0.04, 0.35416666666667
54576, 1.2625, -0.04, 0.375
54577, 1.2833333333333, -0.06, 0.375
54578, 1.2833333333333, -0.08, 0.35416666666667
54579, 1.2625, -0.08, 0.375
54580, 1.2833333333333, -0.1, 0.375
54581, 1.2833333333333, -0.12, 0.35416666666667
54582, 1.2625, -0.12, 0.375
54583, 1.2833333333333, -0.14, 0.375
54584, 1.2833333333333, -0.16, 0.35416666666667
54585, 1.2625, -0.16, 0.375
54586, 1.2833333333333, -0.18, 0.375
54587, 1.325, -0.02, 0.375
54588, 1.325, -0.04, 0.35416666666667
54589, 1.3041666666667, -0.04, 0.375
54590, 1.325, -0.06, 0.375
54591, 1.325, -0.08, 0.35416666666667
54592, 1.3041666666667, -0.08, 0.375
54593, 1.325, -0.1, 0.375
54594, 1.325, -0.12, 0.35416666666667
54595, 1.3041666666667, -0.12, 0.375
54596, 1.325, -0.14, 0.375
54597, 1.325, -0.16, 0.35416666666667
54598, 1.3041666666667, -0.16, 0.375
54599, 1.325, -0.18, 0.375
54600, 1.3666666666667, -0.02, 0.375
54601, 1.3666666666667, -0.04, 0.35416666666667
54602, 1.3458333333333, -0.04, 0.375
54603, 1.3666666666667, -0.06, 0.375
54604, 1.3666666666667, -0.08, 0.35416666666667
54605, 1.3458333333333, -0.08, 0.375
54606, 1.3666666666667, -0.1, 0.375
54607, 1.3666666666667, -0.12, 0.35416666666667
54608, 1.3458333333333, -0.12, 0.375
54609, 1.3666666666667, -0.14, 0.375
54610, 1.3666666666667, -0.16, 0.35416666666667
54611, 1.3458333333333, -0.16, 0.375
54612, 1.3666666666667, -0.18, 0.375
54613, 1.4083333333333, -0.02, 0.375
54614, 1.4083333333333, -0.04, 0.35416666666667
54615, 1.3875, -0.04, 0.375
54616, 1.4083333333333, -0.06, 0.375
54617, 1.4083333333333, -0.08, 0.35416666666667
54618, 1.3875, -0.08, 0.375
54619, 1.4083333333333, -0.1, 0.375
54620, 1.4083333333333, -0.12, 0.35416666666667
54621, 1.3875, -0.12, 0.375
54622, 1.4083333333333, -0.14, 0.375
54623, 1.4083333333333, -0.16, 0.35416666666667
54624, 1.3875, -0.16, 0.375
54625, 1.4083333333333, -0.18, 0.375
54626, 1.45, -0.02, 0.375
54627, 1.45, -0.04, 0.35416666666667
54628, 1.4291666666667, -0.04, 0.375
54629, 1.45, -0.06, 0.375
54630, 1.45, -0.08, 0.35416666666667
54631, 1.4291666666667, -0.08, 0.375
54632, 1.45, -0.1, 0.375
54633, 1.45, -0.12, 0.35416666666667
54634, 1.4291666666667, -0.12, 0.375
54635, 1.45, -0.14, 0.375
54636, 1.45, -0.16, 0.35416666666667
54637, 1.4291666666667, -0.16, 0.375
54638, 1.45, -0.18, 0.375
54639, 1.4916666666667, -0.02, 0.375
54640, 1.4916666666667, -0.04, 0.35416666666667
54641, 1.4708333333333, -0.04, 0.375
54642, 1.4916666666667, -0.06, 0.375
54643, 1.4916666666667, -0.08, 0.35416666666667
54644, 1.4708333333333, -0.08, 0.375
54645, 1.4916666666667, -0.1, 0.375
54646, 1.4916666666667, -0.12, 0.35416666666667
54647, 1.4708333333333, -0.12, 0.375
54648, 1.4916666666667, -0.14, 0.375
54649, 1.4916666666667, -0.16, 0.35416666666667
54650, 1.4708333333333, -0.16, 0.375
54651, 1.4916666666667, -0.18, 0.375
54652, 1.5333333333333, -0.02, 0.375
54653, 1.5333333333333, -0.04, 0.35416666666667
54654, 1.5125, -0.04, 0.375
54655, 1.5333333333333, -0.06, 0.375
54656, 1.5333333333333, -0.08, 0.35416666666667
54657, 1.5125, -0.08, 0.375
54658, 1.5333333333333, -0.1, 0.375
54659, 1.5333333333333, -0.12, 0.35416666666667
54660, 1.5125, -0.12, 0.375
54661, 1.5333333333333, -0.14, 0.375
54662, 1.5333333333333, -0.16, 0.35416666666667
54663, 1.5125, -0.16, 0.375
54664, 1.5333333333333, -0.18, 0.375
54665, 1.575, -0.02, 0.375
54666, 1.575, -0.04, 0.35416666666667
54667, 1.5541666666667, -0.04, 0.375
54668, 1.575, -0.06, 0.375
54669, 1.575, -0.08, 0.35416666666667
54670, 1.5541666666667, -0.08, 0.375
54671, 1.575, -0.1, 0.375
54672, 1.575, -0.12, 0.35416666666667
54673, 1.5541666666667, -0.12, 0.375
54674, 1.575, -0.14, 0.375
54675, 1.575, -0.16, 0.35416666666667
54676, 1.5541666666667, -0.16, 0.375
54677, 1.575, -0.18, 0.375
54678, 1.6166666666667, -0.02, 0.375
54679, 1.6166666666667, -0.04, 0.35416666666667
54680, 1.5958333333333, -0.04, 0.375
54681, 1.6166666666667, -0.06, 0.375
54682, 1.6166666666667, -0.08, 0.35416666666667
54683, 1.5958333333333, -0.08, 0.375
54684, 1.6166666666667, -0.1, 0.375
54685, 1.6166666666667, -0.12, 0.35416666666667
54686, 1.5958333333333, -0.12, 0.375
54687, 1.6166666666667, -0.14, 0.375
54688, 1.6166666666667, -0.16, 0.35416666666667
54689, 1.5958333333333, -0.16, 0.375
54690, 1.6166666666667, -0.18, 0.375
54691, 1.6583333333333, -0.02, 0.375
54692, 1.6583333333333, -0.04, 0.35416666666667
54693, 1.6375, -0.04, 0.375
54694, 1.6583333333333, -0.06, 0.375
54695, 1.6583333333333, -0.08, 0.35416666666667
54696, 1.6375, -0.08, 0.375
54697, 1.6583333333333, -0.1, 0.375
54698, 1.6583333333333, -0.12, 0.35416666666667
54699, 1.6375, -0.12, 0.375
54700, 1.6583333333333, -0.14, 0.375
54701, 1.6583333333333, -0.16, 0.35416666666667
54702, 1.6375, -0.16, 0.375
54703, 1.6583333333333, -0.18, 0.375
54704, 1.7, -0.02, 0.375
54705, 1.7, -0.04, 0.35416666666667
54706, 1.6791666666667, -0.04, 0.375
54707, 1.7, -0.06, 0.375
54708, 1.7, -0.08, 0.35416666666667
54709, 1.6791666666667, -0.08, 0.375
54710, 1.7, -0.1, 0.375
54711, 1.7, -0.12, 0.35416666666667
54712, 1.6791666666667, -0.12, 0.375
54713, 1.7, -0.14, 0.375
54714, 1.7, -0.16, 0.35416666666667
54715, 1.6791666666667, -0.16, 0.375
54716, 1.7, -0.18, 0.375
54717, 1.7416666666667, -0.02, 0.375
54718, 1.7416666666667, -0.04, 0.35416666666667
54719, 1.7208333333333, -0.04, 0.375
54720, 1.7416666666667, -0.06, 0.375
54721, 1.7416666666667, -0.08, 0.35416666666667
54722, 1.7208333333333, -0.08, 0.375
54723, 1.7416666666667, -0.1, 0.375
54724, 1.7416666666667, -0.12, 0.35416666666667
54725, 1.7208333333333, -0.12, 0.375
54726, 1.7416666666667, -0.14, 0.375
54727, 1.7416666666667, -0.16, 0.35416666666667
54728, 1.7208333333333, -0.16, 0.375
54729, 1.7416666666667, -0.18, 0.375
54730, 1.7833333333333, -0.02, 0.375
54731, 1.7833333333333, -0.04, 0.35416666666667
54732, 1.7625, -0.04, 0.375
54733, 1.7833333333333, -0.06, 0.375
54734, 1.7833333333333, -0.08, 0.35416666666667
54735, 1.7625, -0.08, 0.375
54736, 1.7833333333333, -0.1, 0.375
54737, 1.7833333333333, -0.12, 0.35416666666667
54738, 1.7625, -0.12, 0.375
54739, 1.7833333333333, -0.14, 0.375
54740, 1.7833333333333, -0.16, 0.35416666666667
54741, 1.7625, -0.16, 0.375
54742, 1.7833333333333, -0.18, 0.375
54743, 1.825, -0.02, 0.375
54744, 1.825, -0.04, 0.35416666666667
54745, 1.8041666666667, -0.04, 0.375
54746, 1.825, -0.06, 0.375
54747, 1.825, -0.08, 0.35416666666667
54748, 1.8041666666667, -0.08, 0.375
54749, 1.825, -0.1, 0.375
54750, 1.825, -0.12, 0.35416666666667
54751, 1.8041666666667, -0.12, 0.375
54752, 1.825, -0.14, 0.375
54753, 1.825, -0.16, 0.35416666666667
54754, 1.8041666666667, -0.16, 0.375
54755, 1.825, -0.18, 0.375
54756, 1.8666666666667, -0.02, 0.375
54757, 1.8666666666667, -0.04, 0.35416666666667
54758, 1.8458333333333, -0.04, 0.375
54759, 1.8666666666667, -0.06, 0.375
54760, 1.8666666666667, -0.08, 0.35416666666667
54761, 1.8458333333333, -0.08, 0.375
54762, 1.8666666666667, -0.1, 0.375
54763, 1.8666666666667, -0.12, 0.35416666666667
54764, 1.8458333333333, -0.12, 0.375
54765, 1.8666666666667, -0.14, 0.375
54766, 1.8666666666667, -0.16, 0.35416666666667
54767, 1.8458333333333, -0.16, 0.375
54768, 1.8666666666667, -0.18, 0.375
54769, 1.9083333333333, -0.02, 0.375
54770, 1.9083333333333, -0.04, 0.35416666666667
54771, 1.8875, -0.04, 0.375
54772, 1.9083333333333, -0.06, 0.375
54773, 1.9083333333333, -0.08, 0.35416666666667
54774, 1.8875, -0.08, 0.375
54775, 1.9083333333333, -0.1, 0.375
54776, 1.9083333333333, -0.12, 0.35416666666667
54777, 1.8875, -0.12, 0.375
54778, 1.9083333333333, -0.14, 0.375
54779, 1.9083333333333, -0.16, 0.35416666666667
54780, 1.8875, -0.16, 0.375
54781, 1.9083333333333, -0.18, 0.375
54782, 1.95, -0.02, 0.375
54783, 1.95, -0.04, 0.35416666666667
54784, 1.9291666666667, -0.04, 0.375
54785, 1.95, -0.06, 0.375
54786, 1.95, -0.08, 0.35416666666667
54787, 1.9291666666667, -0.08, 0.375
54788, 1.95, -0.1, 0.375
54789, 1.95, -0.12, 0.35416666666667
54790, 1.9291666666667, -0.12, 0.375
54791, 1.95, -0.14, 0.375
54792, 1.95, -0.16, 0.35416666666667
54793, 1.9291666666667, -0.16, 0.375
54794, 1.95, -0.18, 0.375
54795, 1.9916666666667, -0.02, 0.375
54796, 1.9916666666667, -0.04, 0.35416666666667
54797, 1.9708333333333, -0.04, 0.375
54798, 1.9916666666667, -0.06, 0.375
54799, 1.9916666666667, -0.08, 0.35416666666667
54800, 1.9708333333333, -0.08, 0.375
54801, 1.9916666666667, -0.1, 0.375
54802, 1.9916666666667, -0.12, 0.35416666666667
54803, 1.9708333333333, -0.12, 0.375
54804, 1.9916666666667, -0.14, 0.375
54805, 1.9916666666667, -0.16, 0.35416666666667
54806, 1.9708333333333, -0.16, 0.375
54807, 1.9916666666667, -0.18, 0.375
54808, 2.0333333333333, -0.02, 0.375
54809, 2.0333333333333, -0.04, 0.35416666666667
54810, 2.0125, -0.04, 0.375
54811, 2.0333333333333, -0.06, 0.375
54812, 2.0333333333333, -0.08, 0.35416666666667
54813, 2.0125, -0.08, 0.375
54814, 2.0333333333333, -0.1, 0.375
54815, 2.0333333333333, -0.12, 0.35416666666667
54816, 2.0125, -0.12, 0.375
54817, 2.0333333333333, -0.14, 0.375
54818, 2.0333333333333, -0.16, 0.35416666666667
54819, 2.0125, -0.16, 0.375
54820, 2.0333333333333, -0.18, 0.375
54821, 2.075, -0.02, 0.375
54822, 2.075, -0.04, 0.35416666666667
54823, 2.0541666666667, -0.04, 0.375
54824, 2.075, -0.06, 0.375
54825, 2.075, -0.08, 0.35416666666667
54826, 2.0541666666667, -0.08, 0.375
54827, 2.075, -0.1, 0.375
54828, 2.075, -0.12, 0.35416666666667
54829, 2.0541666666667, -0.12, 0.375
54830, 2.075, -0.14, 0.375
54831, 2.075, -0.16, 0.35416666666667
54832, 2.0541666666667, -0.16, 0.375
54833, 2.075, -0.18, 0.375
54834, 2.1166666666667, -0.02, 0.375
54835, 2.1166666666667, -0.04, 0.35416666666667
54836, 2.0958333333333, -0.04, 0.375
54837, 2.1166666666667, -0.06, 0.375
54838, 2.1166666666667, -0.08, 0.35416666666667
54839, 2.0958333333333, -0.08, 0.375
54840, 2.1166666666667, -0.1, 0.375
54841, 2.1166666666667, -0.12, 0.35416666666667
54842, 2.0958333333333, -0.12, 0.375
54843, 2.1166666666667, -0.14, 0.375
54844, 2.1166666666667, -0.16, 0.35416666666667
54845, 2.0958333333333, -0.16, 0.375
54846, 2.1166666666667, -0.18, 0.375
54847, 2.1583333333333, -0.02, 0.375
54848, 2.1583333333333, -0.04, 0.35416666666667
54849, 2.1375, -0.04, 0.375
54850, 2.1583333333333, -0.06, 0.375
54851, 2.1583333333333, -0.08, 0.35416666666667
54852, 2.1375, -0.08, 0.375
54853, 2.1583333333333, -0.1, 0.375
54854, 2.1583333333333, -0.12, 0.35416666666667
54855, 2.1375, -0.12, 0.375
54856, 2.1583333333333, -0.14, 0.375
54857, 2.1583333333333, -0.16, 0.35416666666667
54858, 2.1375, -0.16, 0.375
54859, 2.1583333333333, -0.18, 0.375
54860, 2.1791666666667, -0.04, 0.375
54861, 2.1791666666667, -0.08, 0.375
54862, 2.1791666666667, -0.12, 0.375
54863, 2.1791666666667, -0.16, 0.375
54864, 1.2416666666667, -0.02, 0.41666666666667
54865, 1.2416666666667, -0.04, 0.39583333333333
54866, 1.2208333333333, -0.04, 0.41666666666667
54867, 1.2416666666667, -0.06, 0.41666666666667
54868, 1.2416666666667, -0.08, 0.39583333333333
54869, 1.2208333333333, -0.08, 0.41666666666667
54870, 1.2416666666667, -0.1, 0.41666666666667
54871, 1.2416666666667, -0.12, 0.39583333333333
54872, 1.2208333333333, -0.12, 0.41666666666667
54873, 1.2416666666667, -0.14, 0.41666666666667
54874, 1.2416666666667, -0.16, 0.39583333333333
54875, 1.2208333333333, -0.16, 0.41666666666667
54876, 1.2416666666667, -0.18, 0.41666666666667
54877, 1.2833333333333, -0.02, 0.41666666666667
54878, 1.2833333333333, -0.04, 0.39583333333333
54879, 1.2625, -0.04, 0.41666666666667
54880, 1.2833333333333, -0.06, 0.41666666666667
54881, 1.2833333333333, -0.08, 0.39583333333333
54882, 1.2625, -0.08, 0.41666666666667
54883, 1.2833333333333, -0.1, 0.41666666666667
54884, 1.2833333333333, -0.12, 0.39583333333333
54885, 1.2625, -0.12, 0.41666666666667
54886, 1.2833333333333, -0.14, 0.41666666666667
54887, 1.2833333333333, -0.16, 0.39583333333333
54888, 1.2625, -0.16, 0.41666666666667
54889, 1.2833333333333, -0.18, 0.41666666666667
54890, 1.325, -0.02, 0.41666666666667
54891, 1.325, -0.04, 0.39583333333333
54892, 1.3041666666667, -0.04, 0.41666666666667
54893, 1.325, -0.06, 0.41666666666667
54894, 1.325, -0.08, 0.39583333333333
54895, 1.3041666666667, -0.08, 0.41666666666667
54896, 1.325, -0.1, 0.41666666666667
54897, 1.325, -0.12, 0.39583333333333
54898, 1.3041666666667, -0.12, 0.41666666666667
54899, 1.325, -0.14, 0.41666666666667
54900, 1.325, -0.16, 0.39583333333333
54901, 1.3041666666667, -0.16, 0.41666666666667
54902, 1.325, -0.18, 0.41666666666667
54903, 1.3666666666667, -0.02, 0.41666666666667
54904, 1.3666666666667, -0.04, 0.39583333333333
54905, 1.3458333333333, -0.04, 0.41666666666667
54906, 1.3666666666667, -0.06, 0.41666666666667
54907, 1.3666666666667, -0.08, 0.39583333333333
54908, 1.3458333333333, -0.08, 0.41666666666667
54909, 1.3666666666667, -0.1, 0.41666666666667
54910, 1.3666666666667, -0.12, 0.39583333333333
54911, 1.3458333333333, -0.12, 0.41666666666667
54912, 1.3666666666667, -0.14, 0.41666666666667
54913, 1.3666666666667, -0.16, 0.39583333333333
54914, 1.3458333333333, -0.16, 0.41666666666667
54915, 1.3666666666667, -0.18, 0.41666666666667
54916, 1.4083333333333, -0.02, 0.41666666666667
54917, 1.4083333333333, -0.04, 0.39583333333333
54918, 1.3875, -0.04, 0.41666666666667
54919, 1.4083333333333, -0.06, 0.41666666666667
54920, 1.4083333333333, -0.08, 0.39583333333333
54921, 1.3875, -0.08, 0.41666666666667
54922, 1.4083333333333, -0.1, 0.41666666666667
54923, 1.4083333333333, -0.12, 0.39583333333333
54924, 1.3875, -0.12, 0.41666666666667
54925, 1.4083333333333, -0.14, 0.41666666666667
54926, 1.4083333333333, -0.16, 0.39583333333333
54927, 1.3875, -0.16, 0.41666666666667
54928, 1.4083333333333, -0.18, 0.41666666666667
54929, 1.45, -0.02, 0.41666666666667
54930, 1.45, -0.04, 0.39583333333333
54931, 1.4291666666667, -0.04, 0.41666666666667
54932, 1.45, -0.06, 0.41666666666667
54933, 1.45, -0.08, 0.39583333333333
54934, 1.4291666666667, -0.08, 0.41666666666667
54935, 1.45, -0.1, 0.41666666666667
54936, 1.45, -0.12, 0.39583333333333
54937, 1.4291666666667, -0.12, 0.41666666666667
54938, 1.45, -0.14, 0.41666666666667
54939, 1.45, -0.16, 0.39583333333333
54940, 1.4291666666667, -0.16, 0.41666666666667
54941, 1.45, -0.18, 0.41666666666667
54942, 1.4916666666667, -0.02, 0.41666666666667
54943, 1.4916666666667, -0.04, 0.39583333333333
54944, 1.4708333333333, -0.04, 0.41666666666667
54945, 1.4916666666667, -0.06, 0.41666666666667
54946, 1.4916666666667, -0.08, 0.39583333333333
54947, 1.4708333333333, -0.08, 0.41666666666667
54948, 1.4916666666667, -0.1, 0.41666666666667
54949, 1.4916666666667, -0.12, 0.39583333333333
54950, 1.4708333333333, -0.12, 0.41666666666667
54951, 1.4916666666667, -0.14, 0.41666666666667
54952, 1.4916666666667, -0.16, 0.39583333333333
54953, 1.4708333333333, -0.16, 0.41666666666667
54954, 1.4916666666667, -0.18, 0.41666666666667
54955, 1.5333333333333, -0.02, 0.41666666666667
54956, 1.5333333333333, -0.04, 0.39583333333333
54957, 1.5125, -0.04, 0.41666666666667
54958, 1.5333333333333, -0.06, 0.41666666666667
54959, 1.5333333333333, -0.08, 0.39583333333333
54960, 1.5125, -0.08, 0.41666666666667
54961, 1.5333333333333, -0.1, 0.41666666666667
54962, 1.5333333333333, -0.12, 0.39583333333333
54963, 1.5125, -0.12, 0.41666666666667
54964, 1.5333333333333, -0.14, 0.41666666666667
54965, 1.5333333333333, -0.16, 0.39583333333333
54966, 1.5125, -0.16, 0.41666666666667
54967, 1.5333333333333, -0.18, 0.41666666666667
54968, 1.575, -0.02, 0.41666666666667
54969, 1.575, -0.04, 0.39583333333333
54970, 1.5541666666667, -0.04, 0.41666666666667
54971, 1.575, -0.06, 0.41666666666667
54972, 1.575, -0.08, 0.39583333333333
54973, 1.5541666666667, -0.08, 0.41666666666667
54974, 1.575, -0.1, 0.41666666666667
54975, 1.575, -0.12, 0.39583333333333
54976, 1.5541666666667, -0.12, 0.41666666666667
54977, 1.575, -0.14, 0.41666666666667
54978, 1.575, -0.16, 0.39583333333333
54979, 1.5541666666667, -0.16, 0.41666666666667
54980, 1.575, -0.18, 0.41666666666667
54981, 1.6166666666667, -0.02, 0.41666666666667
54982, 1.6166666666667, -0.04, 0.39583333333333
54983, 1.5958333333333, -0.04, 0.41666666666667
54984, 1.6166666666667, -0.06, 0.41666666666667
54985, 1.6166666666667, -0.08, 0.39583333333333
54986, 1.5958333333333, -0.08, 0.41666666666667
54987, 1.6166666666667, -0.1, 0.41666666666667
54988, 1.6166666666667, -0.12, 0.39583333333333
54989, 1.5958333333333, -0.12, 0.41666666666667
54990, 1.6166666666667, -0.14, 0.41666666666667
54991, 1.6166666666667, -0.16, 0.39583333333333
54992, 1.5958333333333, -0.16, 0.41666666666667
54993, 1.6166666666667, -0.18, 0.41666666666667
54994, 1.6583333333333, -0.02, 0.41666666666667
54995, 1.6583333333333, -0.04, 0.39583333333333
54996, 1.6375, -0.04, 0.41666666666667
54997, 1.6583333333333, -0.06, 0.41666666666667
54998, 1.6583333333333, -0.08, 0.39583333333333
54999, 1.6375, -0.08, 0.41666666666667
55000, 1.6583333333333, -0.1, 0.41666666666667
55001, 1.6583333333333, -0.12, 0.39583333333333
55002, 1.6375, -0.12, 0.41666666666667
55003, 1.6583333333333, -0.14, 0.41666666666667
55004, 1.6583333333333, -0.16, 0.39583333333333
55005, 1.6375, -0.16, 0.41666666666667
55006, 1.6583333333333, -0.18, 0.41666666666667
55007, 1.7, -0.02, 0.41666666666667
55008, 1.7, -0.04, 0.39583333333333
55009, 1.6791666666667, -0.04, 0.41666666666667
55010, 1.7, -0.06, 0.41666666666667
55011, 1.7, -0.08, 0.39583333333333
55012, 1.6791666666667, -0.08, 0.41666666666667
55013, 1.7, -0.1, 0.41666666666667
55014, 1.7, -0.12, 0.39583333333333
55015, 1.6791666666667, -0.12, 0.41666666666667
55016, 1.7, -0.14, 0.41666666666667
55017, 1.7, -0.16, 0.39583333333333
55018, 1.6791666666667, -0.16, 0.41666666666667
55019, 1.7, -0.18, 0.41666666666667
55020, 1.7416666666667, -0.02, 0.41666666666667
55021, 1.7416666666667, -0.04, 0.39583333333333
55022, 1.7208333333333, -0.04, 0.41666666666667
55023, 1.7416666666667, -0.06, 0.41666666666667
55024, 1.7416666666667, -0.08, 0.39583333333333
55025, 1.7208333333333, -0.08, 0.41666666666667
55026, 1.7416666666667, -0.1, 0.41666666666667
55027, 1.7416666666667, -0.12, 0.39583333333333
55028, 1.7208333333333, -0.12, 0.41666666666667
55029, 1.7416666666667, -0.14, 0.41666666666667
55030, 1.7416666666667, -0.16, 0.39583333333333
55031, 1.7208333333333, -0.16, 0.41666666666667
55032, 1.7416666666667, -0.18, 0.41666666666667
55033, 1.7833333333333, -0.02, 0.41666666666667
55034, 1.7833333333333, -0.04, 0.39583333333333
55035, 1.7625, -0.04, 0.41666666666667
55036, 1.7833333333333, -0.06, 0.41666666666667
55037, 1.7833333333333, -0.08, 0.39583333333333
55038, 1.7625, -0.08, 0.41666666666667
55039, 1.7833333333333, -0.1, 0.41666666666667
55040, 1.7833333333333, -0.12, 0.39583333333333
55041, 1.7625, -0.12, 0.41666666666667
55042, 1.7833333333333, -0.14, 0.41666666666667
55043, 1.7833333333333, -0.16, 0.39583333333333
55044, 1.7625, -0.16, 0.41666666666667
55045, 1.7833333333333, -0.18, 0.41666666666667
55046, 1.825, -0.02, 0.41666666666667
55047, 1.825, -0.04, 0.39583333333333
55048, 1.8041666666667, -0.04, 0.41666666666667
55049, 1.825, -0.06, 0.41666666666667
55050, 1.825, -0.08, 0.39583333333333
55051, 1.8041666666667, -0.08, 0.41666666666667
55052, 1.825, -0.1, 0.41666666666667
55053, 1.825, -0.12, 0.39583333333333
55054, 1.8041666666667, -0.12, 0.41666666666667
55055, 1.825, -0.14, 0.41666666666667
55056, 1.825, -0.16, 0.39583333333333
55057, 1.8041666666667, -0.16, 0.41666666666667
55058, 1.825, -0.18, 0.41666666666667
55059, 1.8666666666667, -0.02, 0.41666666666667
55060, 1.8666666666667, -0.04, 0.39583333333333
55061, 1.8458333333333, -0.04, 0.41666666666667
55062, 1.8666666666667, -0.06, 0.41666666666667
55063, 1.8666666666667, -0.08, 0.39583333333333
55064, 1.8458333333333, -0.08, 0.41666666666667
55065, 1.8666666666667, -0.1, 0.41666666666667
55066, 1.8666666666667, -0.12, 0.39583333333333
55067, 1.8458333333333, -0.12, 0.41666666666667
55068, 1.8666666666667, -0.14, 0.41666666666667
55069, 1.8666666666667, -0.16, 0.39583333333333
55070, 1.8458333333333, -0.16, 0.41666666666667
55071, 1.8666666666667, -0.18, 0.41666666666667
55072, 1.9083333333333, -0.02, 0.41666666666667
55073, 1.9083333333333, -0.04, 0.39583333333333
55074, 1.8875, -0.04, 0.41666666666667
55075, 1.9083333333333, -0.06, 0.41666666666667
55076, 1.9083333333333, -0.08, 0.39583333333333
55077, 1.8875, -0.08, 0.41666666666667
55078, 1.9083333333333, -0.1, 0.41666666666667
55079, 1.9083333333333, -0.12, 0.39583333333333
55080, 1.8875, -0.12, 0.41666666666667
55081, 1.9083333333333, -0.14, 0.41666666666667
55082, 1.9083333333333, -0.16, 0.39583333333333
55083, 1.8875, -0.16, 0.41666666666667
55084, 1.9083333333333, -0.18, 0.41666666666667
55085, 1.95, -0.02, 0.41666666666667
55086, 1.95, -0.04, 0.39583333333333
55087, 1.9291666666667, -0.04, 0.41666666666667
55088, 1.95, -0.06, 0.41666666666667
55089, 1.95, -0.08, 0.39583333333333
55090, 1.9291666666667, -0.08, 0.41666666666667
55091, 1.95, -0.1, 0.41666666666667
55092, 1.95, -0.12, 0.39583333333333
55093, 1.9291666666667, -0.12, 0.41666666666667
55094, 1.95, -0.14, 0.41666666666667
55095, 1.95, -0.16, 0.39583333333333
55096, 1.9291666666667, -0.16, 0.41666666666667
55097, 1.95, -0.18, 0.41666666666667
55098, 1.9916666666667, -0.02, 0.41666666666667
55099, 1.9916666666667, -0.04, 0.39583333333333
55100, 1.9708333333333, -0.04, 0.41666666666667
55101, 1.9916666666667, -0.06, 0.41666666666667
55102, 1.9916666666667, -0.08, 0.39583333333333
55103, 1.9708333333333, -0.08, 0.41666666666667
55104, 1.9916666666667, -0.1, 0.41666666666667
55105, 1.9916666666667, -0.12, 0.39583333333333
55106, 1.9708333333333, -0.12, 0.41666666666667
55107, 1.9916666666667, -0.14, 0.41666666666667
55108, 1.9916666666667, -0.16, 0.39583333333333
55109, 1.9708333333333, -0.16, 0.41666666666667
55110, 1.9916666666667, -0.18, 0.41666666666667
55111, 2.0333333333333, -0.02, 0.41666666666667
55112, 2.0333333333333, -0.04, 0.39583333333333
55113, 2.0125, -0.04, 0.41666666666667
55114, 2.0333333333333, -0.06, 0.41666666666667
55115, 2.0333333333333, -0.08, 0.39583333333333
55116, 2.0125, -0.08, 0.41666666666667
55117, 2.0333333333333, -0.1, 0.41666666666667
55118, 2.0333333333333, -0.12, 0.39583333333333
55119, 2.0125, -0.12, 0.41666666666667
55120, 2.0333333333333, -0.14, 0.41666666666667
55121, 2.0333333333333, -0.16, 0.39583333333333
55122, 2.0125, -0.16, 0.41666666666667
55123, 2.0333333333333, -0.18, 0.41666666666667
55124, 2.075, -0.02, 0.41666666666667
55125, 2.075, -0.04, 0.39583333333333
55126, 2.0541666666667, -0.04, 0.41666666666667
55127, 2.075, -0.06, 0.41666666666667
55128, 2.075, -0.08, 0.39583333333333
55129, 2.0541666666667, -0.08, 0.41666666666667
55130, 2.075, -0.1, 0.41666666666667
55131, 2.075, -0.12, 0.39583333333333
55132, 2.0541666666667, -0.12, 0.41666666666667
55133, 2.075, -0.14, 0.41666666666667
55134, 2.075, -0.16, 0.39583333333333
55135, 2.0541666666667, -0.16, 0.41666666666667
55136, 2.075, -0.18, 0.41666666666667
55137, 2.1166666666667, -0.02, 0.41666666666667
55138, 2.1166666666667, -0.04, 0.39583333333333
55139, 2.0958333333333, -0.04, 0.41666666666667
55140, 2.1166666666667, -0.06, 0.41666666666667
55141, 2.1166666666667, -0.08, 0.39583333333333
55142, 2.0958333333333, -0.08, 0.41666666666667
55143, 2.1166666666667, -0.1, 0.41666666666667
55144, 2.1166666666667, -0.12, 0.39583333333333
55145, 2.0958333333333, -0.12, 0.41666666666667
55146, 2.1166666666667, -0.14, 0.41666666666667
55147, 2.1166666666667, -0.16, 0.39583333333333
55148, 2.0958333333333, -0.16, 0.41666666666667
55149, 2.1166666666667, -0.18, 0.41666666666667
55150, 2.1583333333333, -0.02, 0.41666666666667
55151, 2.1583333333333, -0.04, 0.39583333333333
55152, 2.1375, -0.04, 0.41666666666667
55153, 2.1583333333333, -0.06, 0.41666666666667
55154, 2.1583333333333, -0.08, 0.39583333333333
55155, 2.1375, -0.08, 0.41666666666667
55156, 2.1583333333333, -0.1, 0.41666666666667
55157, 2.1583333333333, -0.12, 0.39583333333333
55158, 2.1375, -0.12, 0.41666666666667
55159, 2.1583333333333, -0.14, 0.41666666666667
55160, 2.1583333333333, -0.16, 0.39583333333333
55161, 2.1375, -0.16, 0.41666666666667
55162, 2.1583333333333, -0.18, 0.41666666666667
55163, 2.1791666666667, -0.04, 0.41666666666667
55164, 2.1791666666667, -0.08, 0.41666666666667
55165, 2.1791666666667, -0.12, 0.41666666666667
55166, 2.1791666666667, -0.16, 0.41666666666667
55167, 1.2416666666667, -0.02, 0.45833333333333
55168, 1.2416666666667, -0.04, 0.4375
55169, 1.2208333333333, -0.04, 0.45833333333333
55170, 1.2416666666667, -0.06, 0.45833333333333
55171, 1.2416666666667, -0.08, 0.4375
55172, 1.2208333333333, -0.08, 0.45833333333333
55173, 1.2416666666667, -0.1, 0.45833333333333
55174, 1.2416666666667, -0.12, 0.4375
55175, 1.2208333333333, -0.12, 0.45833333333333
55176, 1.2416666666667, -0.14, 0.45833333333333
55177, 1.2416666666667, -0.16, 0.4375
55178, 1.2208333333333, -0.16, 0.45833333333333
55179, 1.2416666666667, -0.18, 0.45833333333333
55180, 1.2833333333333, -0.02, 0.45833333333333
55181, 1.2833333333333, -0.04, 0.4375
55182, 1.2625, -0.04, 0.45833333333333
55183, 1.2833333333333, -0.06, 0.45833333333333
55184, 1.2833333333333, -0.08, 0.4375
55185, 1.2625, -0.08, 0.45833333333333
55186, 1.2833333333333, -0.1, 0.45833333333333
55187, 1.2833333333333, -0.12, 0.4375
55188, 1.2625, -0.12, 0.45833333333333
55189, 1.2833333333333, -0.14, 0.45833333333333
55190, 1.2833333333333, -0.16, 0.4375
55191, 1.2625, -0.16, 0.45833333333333
55192, 1.2833333333333, -0.18, 0.45833333333333
55193, 1.325, -0.02, 0.45833333333333
55194, 1.325, -0.04, 0.4375
55195, 1.3041666666667, -0.04, 0.45833333333333
55196, 1.325, -0.06, 0.45833333333333
55197, 1.325, -0.08, 0.4375
55198, 1.3041666666667, -0.08, 0.45833333333333
55199, 1.325, -0.1, 0.45833333333333
55200, 1.325, -0.12, 0.4375
55201, 1.3041666666667, -0.12, 0.45833333333333
55202, 1.325, -0.14, 0.45833333333333
55203, 1.325, -0.16, 0.4375
55204, 1.3041666666667, -0.16, 0.45833333333333
55205, 1.325, -0.18, 0.45833333333333
55206, 1.3666666666667, -0.02, 0.45833333333333
55207, 1.3666666666667, -0.04, 0.4375
55208, 1.3458333333333, -0.04, 0.45833333333333
55209, 1.3666666666667, -0.06, 0.45833333333333
55210, 1.3666666666667, -0.08, 0.4375
55211, 1.3458333333333, -0.08, 0.45833333333333
55212, 1.3666666666667, -0.1, 0.45833333333333
55213, 1.3666666666667, -0.12, 0.4375
55214, 1.3458333333333, -0.12, 0.45833333333333
55215, 1.3666666666667, -0.14, 0.45833333333333
55216, 1.3666666666667, -0.16, 0.4375
55217, 1.3458333333333, -0.16, 0.45833333333333
55218, 1.3666666666667, -0.18, 0.45833333333333
55219, 1.4083333333333, -0.02, 0.45833333333333
55220, 1.4083333333333, -0.04, 0.4375
55221, 1.3875, -0.04, 0.45833333333333
55222, 1.4083333333333, -0.06, 0.45833333333333
55223, 1.4083333333333, -0.08, 0.4375
55224, 1.3875, -0.08, 0.45833333333333
55225, 1.4083333333333, -0.1, 0.45833333333333
55226, 1.4083333333333, -0.12, 0.4375
55227, 1.3875, -0.12, 0.45833333333333
55228, 1.4083333333333, -0.14, 0.45833333333333
55229, 1.4083333333333, -0.16, 0.4375
55230, 1.3875, -0.16, 0.45833333333333
55231, 1.4083333333333, -0.18, 0.45833333333333
55232, 1.45, -0.02, 0.45833333333333
55233, 1.45, -0.04, 0.4375
55234, 1.4291666666667, -0.04, 0.45833333333333
55235, 1.45, -0.06, 0.45833333333333
55236, 1.45, -0.08, 0.4375
55237, 1.4291666666667, -0.08, 0.45833333333333
55238, 1.45, -0.1, 0.45833333333333
55239, 1.45, -0.12, 0.4375
55240, 1.4291666666667, -0.12, 0.45833333333333
55241, 1.45, -0.14, 0.45833333333333
55242, 1.45, -0.16, 0.4375
55243, 1.4291666666667, -0.16, 0.45833333333333
55244, 1.45, -0.18, 0.45833333333333
55245, 1.4916666666667, -0.02, 0.45833333333333
55246, 1.4916666666667, -0.04, 0.4375
55247, 1.4708333333333, -0.04, 0.45833333333333
55248, 1.4916666666667, -0.06, 0.45833333333333
55249, 1.4916666666667, -0.08, 0.4375
55250, 1.4708333333333, -0.08, 0.45833333333333
55251, 1.4916666666667, -0.1, 0.45833333333333
55252, 1.4916666666667, -0.12, 0.4375
55253, 1.4708333333333, -0.12, 0.45833333333333
55254, 1.4916666666667, -0.14, 0.45833333333333
55255, 1.4916666666667, -0.16, 0.4375
55256, 1.4708333333333, -0.16, 0.45833333333333
55257, 1.4916666666667, -0.18, 0.45833333333333
55258, 1.5333333333333, -0.02, 0.45833333333333
55259, 1.5333333333333, -0.04, 0.4375
55260, 1.5125, -0.04, 0.45833333333333
55261, 1.5333333333333, -0.06, 0.45833333333333
55262, 1.5333333333333, -0.08, 0.4375
55263, 1.5125, -0.08, 0.45833333333333
55264, 1.5333333333333, -0.1, 0.45833333333333
55265, 1.5333333333333, -0.12, 0.4375
55266, 1.5125, -0.12, 0.45833333333333
55267, 1.5333333333333, -0.14, 0.45833333333333
55268, 1.5333333333333, -0.16, 0.4375
55269, 1.5125, -0.16, 0.45833333333333
55270, 1.5333333333333, -0.18, 0.45833333333333
55271, 1.575, -0.02, 0.45833333333333
55272, 1.575, -0.04, 0.4375
55273, 1.5541666666667, -0.04, 0.45833333333333
55274, 1.575, -0.06, 0.45833333333333
55275, 1.575, -0.08, 0.4375
55276, 1.5541666666667, -0.08, 0.45833333333333
55277, 1.575, -0.1, 0.45833333333333
55278, 1.575, -0.12, 0.4375
55279, 1.5541666666667, -0.12, 0.45833333333333
55280, 1.575, -0.14, 0.45833333333333
55281, 1.575, -0.16, 0.4375
55282, 1.5541666666667, -0.16, 0.45833333333333
55283, 1.575, -0.18, 0.45833333333333
55284, 1.6166666666667, -0.02, 0.45833333333333
55285, 1.6166666666667, -0.04, 0.4375
55286, 1.5958333333333, -0.04, 0.45833333333333
55287, 1.6166666666667, -0.06, 0.45833333333333
55288, 1.6166666666667, -0.08, 0.4375
55289, 1.5958333333333, -0.08, 0.45833333333333
55290, 1.6166666666667, -0.1, 0.45833333333333
55291, 1.6166666666667, -0.12, 0.4375
55292, 1.5958333333333, -0.12, 0.45833333333333
55293, 1.6166666666667, -0.14, 0.45833333333333
55294, 1.6166666666667, -0.16, 0.4375
55295, 1.5958333333333, -0.16, 0.45833333333333
55296, 1.6166666666667, -0.18, 0.45833333333333
55297, 1.6583333333333, -0.02, 0.45833333333333
55298, 1.6583333333333, -0.04, 0.4375
55299, 1.6375, -0.04, 0.45833333333333
55300, 1.6583333333333, -0.06, 0.45833333333333
55301, 1.6583333333333, -0.08, 0.4375
55302, 1.6375, -0.08, 0.45833333333333
55303, 1.6583333333333, -0.1, 0.45833333333333
55304, 1.6583333333333, -0.12, 0.4375
55305, 1.6375, -0.12, 0.45833333333333
55306, 1.6583333333333, -0.14, 0.45833333333333
55307, 1.6583333333333, -0.16, 0.4375
55308, 1.6375, -0.16, 0.45833333333333
55309, 1.6583333333333, -0.18, 0.45833333333333
55310, 1.7, -0.02, 0.45833333333333
55311, 1.7, -0.04, 0.4375
55312, 1.6791666666667, -0.04, 0.45833333333333
55313, 1.7, -0.06, 0.45833333333333
55314, 1.7, -0.08, 0.4375
55315, 1.6791666666667, -0.08, 0.45833333333333
55316, 1.7, -0.1, 0.45833333333333
55317, 1.7, -0.12, 0.4375
55318, 1.6791666666667, -0.12, 0.45833333333333
55319, 1.7, -0.14, 0.45833333333333
55320, 1.7, -0.16, 0.4375
55321, 1.6791666666667, -0.16, 0.45833333333333
55322, 1.7, -0.18, 0.45833333333333
55323, 1.7416666666667, -0.02, 0.45833333333333
55324, 1.7416666666667, -0.04, 0.4375
55325, 1.7208333333333, -0.04, 0.45833333333333
55326, 1.7416666666667, -0.06, 0.45833333333333
55327, 1.7416666666667, -0.08, 0.4375
55328, 1.7208333333333, -0.08, 0.45833333333333
55329, 1.7416666666667, -0.1, 0.45833333333333
55330, 1.7416666666667, -0.12, 0.4375
55331, 1.7208333333333, -0.12, 0.45833333333333
55332, 1.7416666666667, -0.14, 0.45833333333333
55333, 1.7416666666667, -0.16, 0.4375
55334, 1.7208333333333, -0.16, 0.45833333333333
55335, 1.7416666666667, -0.18, 0.45833333333333
55336, 1.7833333333333, -0.02, 0.45833333333333
55337, 1.7833333333333, -0.04, 0.4375
55338, 1.7625, -0.04, 0.45833333333333
55339, 1.7833333333333, -0.06, 0.45833333333333
55340, 1.7833333333333, -0.08, 0.4375
55341, 1.7625, -0.08, 0.45833333333333
55342, 1.7833333333333, -0.1, 0.45833333333333
55343, 1.7833333333333, -0.12, 0.4375
55344, 1.7625, -0.12, 0.45833333333333
55345, 1.7833333333333, -0.14, 0.45833333333333
55346, 1.7833333333333, -0.16, 0.4375
55347, 1.7625, -0.16, 0.45833333333333
55348, 1.7833333333333, -0.18, 0.45833333333333
55349, 1.825, -0.02, 0.45833333333333
55350, 1.825, -0.04, 0.4375
55351, 1.8041666666667, -0.04, 0.45833333333333
55352, 1.825, -0.06, 0.45833333333333
55353, 1.825, -0.08, 0.4375
55354, 1.8041666666667, -0.08, 0.45833333333333
55355, 1.825, -0.1, 0.45833333333333
55356, 1.825, -0.12, 0.4375
55357, 1.8041666666667, -0.12, 0.45833333333333
55358, 1.825, -0.14, 0.45833333333333
55359, 1.825, -0.16, 0.4375
55360, 1.8041666666667, -0.16, 0.45833333333333
55361, 1.825, -0.18, 0.45833333333333
55362, 1.8666666666667, -0.02, 0.45833333333333
55363, 1.8666666666667, -0.04, 0.4375
55364, 1.8458333333333, -0.04, 0.45833333333333
55365, 1.8666666666667, -0.06, 0.45833333333333
55366, 1.8666666666667, -0.08, 0.4375
55367, 1.8458333333333, -0.08, 0.45833333333333
55368, 1.8666666666667, -0.1, 0.45833333333333
55369, 1.8666666666667, -0.12, 0.4375
55370, 1.8458333333333, -0.12, 0.45833333333333
55371, 1.8666666666667, -0.14, 0.45833333333333
55372, 1.8666666666667, -0.16, 0.4375
55373, 1.8458333333333, -0.16, 0.45833333333333
55374, 1.8666666666667, -0.18, 0.45833333333333
55375, 1.9083333333333, -0.02, 0.45833333333333
55376, 1.9083333333333, -0.04, 0.4375
55377, 1.8875, -0.04, 0.45833333333333
55378, 1.9083333333333, -0.06, 0.45833333333333
55379, 1.9083333333333, -0.08, 0.4375
55380, 1.8875, -0.08, 0.45833333333333
55381, 1.9083333333333, -0.1, 0.45833333333333
55382, 1.9083333333333, -0.12, 0.4375
55383, 1.8875, -0.12, 0.45833333333333
55384, 1.9083333333333, -0.14, 0.45833333333333
55385, 1.9083333333333, -0.16, 0.4375
55386, 1.8875, -0.16, 0.45833333333333
55387, 1.9083333333333, -0.18, 0.45833333333333
55388, 1.95, -0.02, 0.45833333333333
55389, 1.95, -0.04, 0.4375
55390, 1.9291666666667, -0.04, 0.45833333333333
55391, 1.95, -0.06, 0.45833333333333
55392, 1.95, -0.08, 0.4375
55393, 1.9291666666667, -0.08, 0.45833333333333
55394, 1.95, -0.1, 0.45833333333333
55395, 1.95, -0.12, 0.4375
55396, 1.9291666666667, -0.12, 0.45833333333333
55397, 1.95, -0.14, 0.45833333333333
55398, 1.95, -0.16, 0.4375
55399, 1.9291666666667, -0.16, 0.45833333333333
55400, 1.95, -0.18, 0.45833333333333
55401, 1.9916666666667, -0.02, 0.45833333333333
55402, 1.9916666666667, -0.04, 0.4375
55403, 1.9708333333333, -0.04, 0.45833333333333
55404, 1.9916666666667, -0.06, 0.45833333333333
55405, 1.9916666666667, -0.08, 0.4375
55406, 1.9708333333333, -0.08, 0.45833333333333
55407, 1.9916666666667, -0.1, 0.45833333333333
55408, 1.9916666666667, -0.12, 0.4375
55409, 1.9708333333333, -0.12, 0.45833333333333
55410, 1.9916666666667, -0.14, 0.45833333333333
55411, 1.9916666666667, -0.16, 0.4375
55412, 1.9708333333333, -0.16, 0.45833333333333
55413, 1.9916666666667, -0.18, 0.45833333333333
55414, 2.0333333333333, -0.02, 0.45833333333333
55415, 2.0333333333333, -0.04, 0.4375
55416, 2.0125, -0.04, 0.45833333333333
55417, 2.0333333333333, -0.06, 0.45833333333333
55418, 2.0333333333333, -0.08, 0.4375
55419, 2.0125, -0.08, 0.45833333333333
55420, 2.0333333333333, -0.1, 0.45833333333333
55421, 2.0333333333333, -0.12, 0.4375
55422, 2.0125, -0.12, 0.45833333333333
55423, 2.0333333333333, -0.14, 0.45833333333333
55424, 2.0333333333333, -0.16, 0.4375
55425, 2.0125, -0.16, 0.45833333333333
55426, 2.0333333333333, -0.18, 0.45833333333333
55427, 2.075, -0.02, 0.45833333333333
55428, 2.075, -0.04, 0.4375
55429, 2.0541666666667, -0.04, 0.45833333333333
55430, 2.075, -0.06, 0.45833333333333
55431, 2.075, -0.08, 0.4375
55432, 2.0541666666667, -0.08, 0.45833333333333
55433, 2.075, -0.1, 0.45833333333333
55434, 2.075, -0.12, 0.4375
55435, 2.0541666666667, -0.12, 0.45833333333333
55436, 2.075, -0.14, 0.45833333333333
55437, 2.075, -0.16, 0.4375
55438, 2.0541666666667, -0.16, 0.45833333333333
55439, 2.075, -0.18, 0.45833333333333
55440, 2.1166666666667, -0.02, 0.45833333333333
55441, 2.1166666666667, -0.04, 0.4375
55442, 2.0958333333333, -0.04, 0.45833333333333
55443, 2.1166666666667, -0.06, 0.45833333333333
55444, 2.1166666666667, -0.08, 0.4375
55445, 2.0958333333333, -0.08, 0.45833333333333
55446, 2.1166666666667, -0.1, 0.45833333333333
55447, 2.1166666666667, -0.12, 0.4375
55448, 2.0958333333333, -0.12, 0.45833333333333
55449, 2.1166666666667, -0.14, 0.45833333333333
55450, 2.1166666666667, -0.16, 0.4375
55451, 2.0958333333333, -0.16, 0.45833333333333
55452, 2.1166666666667, -0.18, 0.45833333333333
55453, 2.1583333333333, -0.02, 0.45833333333333
55454, 2.1583333333333, -0.04, 0.4375
55455, 2.1375, -0.04, 0.45833333333333
55456, 2.1583333333333, -0.06, 0.45833333333333
55457, 2.1583333333333, -0.08, 0.4375
55458, 2.1375, -0.08, 0.45833333333333
55459, 2.1583333333333, -0.1, 0.45833333333333
55460, 2.1583333333333, -0.12, 0.4375
55461, 2.1375, -0.12, 0.45833333333333
55462, 2.1583333333333, -0.14, 0.45833333333333
55463, 2.1583333333333, -0.16, 0.4375
55464, 2.1375, -0.16, 0.45833333333333
55465, 2.1583333333333, -0.18, 0.45833333333333
55466, 2.1791666666667, -0.04, 0.45833333333333
55467, 2.1791666666667, -0.08, 0.45833333333333
55468, 2.1791666666667, -0.12, 0.45833333333333
55469, 2.1791666666667, -0.16, 0.45833333333333
55470, 1.2416666666667, -0.04, 0.47916666666667
55471, 1.2416666666667, -0.08, 0.47916666666667
55472, 1.2416666666667, -0.12, 0.47916666666667
55473, 1.2416666666667, -0.16, 0.47916666666667
55474, 1.2833333333333, -0.04, 0.47916666666667
55475, 1.2833333333333, -0.08, 0.47916666666667
55476, 1.2833333333333, -0.12, 0.47916666666667
55477, 1.2833333333333, -0.16, 0.47916666666667
55478, 1.325, -0.04, 0.47916666666667
55479, 1.325, -0.08, 0.47916666666667
55480, 1.325, -0.12, 0.47916666666667
55481, 1.325, -0.16, 0.47916666666667
55482, 1.3666666666667, -0.04, 0.47916666666667
55483, 1.3666666666667, -0.08, 0.47916666666667
55484, 1.3666666666667, -0.12, 0.47916666666667
55485, 1.3666666666667, -0.16, 0.47916666666667
55486, 1.4083333333333, -0.04, 0.47916666666667
55487, 1.4083333333333, -0.08, 0.47916666666667
55488, 1.4083333333333, -0.12, 0.47916666666667
55489, 1.4083333333333, -0.16, 0.47916666666667
55490, 1.45, -0.04, 0.47916666666667
55491, 1.45, -0.08, 0.47916666666667
55492, 1.45, -0.12, 0.47916666666667
55493, 1.45, -0.16, 0.47916666666667
55494, 1.4916666666667, -0.04, 0.47916666666667
55495, 1.4916666666667, -0.08, 0.47916666666667
55496, 1.4916666666667, -0.12, 0.47916666666667
55497, 1.4916666666667, -0.16, 0.47916666666667
55498, 1.5333333333333, -0.04, 0.47916666666667
55499, 1.5333333333333, -0.08, 0.47916666666667
55500, 1.5333333333333, -0.12, 0.47916666666667
55501, 1.5333333333333, -0.16, 0.47916666666667
55502, 1.575, -0.04, 0.47916666666667
55503, 1.575, -0.08, 0.47916666666667
55504, 1.575, -0.12, 0.47916666666667
55505, 1.575, -0.16, 0.47916666666667
55506, 1.6166666666667, -0.04, 0.47916666666667
55507, 1.6166666666667, -0.08, 0.47916666666667
55508, 1.6166666666667, -0.12, 0.47916666666667
55509, 1.6166666666667, -0.16, 0.47916666666667
55510, 1.6583333333333, -0.04, 0.47916666666667
55511, 1.6583333333333, -0.08, 0.47916666666667
55512, 1.6583333333333, -0.12, 0.47916666666667
55513, 1.6583333333333, -0.16, 0.47916666666667
55514, 1.7, -0.04, 0.47916666666667
55515, 1.7, -0.08, 0.47916666666667
55516, 1.7, -0.12, 0.47916666666667
55517, 1.7, -0.16, 0.47916666666667
55518, 1.7416666666667, -0.04, 0.47916666666667
55519, 1.7416666666667, -0.08, 0.47916666666667
55520, 1.7416666666667, -0.12, 0.47916666666667
55521, 1.7416666666667, -0.16, 0.47916666666667
55522, 1.7833333333333, -0.04, 0.47916666666667
55523, 1.7833333333333, -0.08, 0.47916666666667
55524, 1.7833333333333, -0.12, 0.47916666666667
55525, 1.7833333333333, -0.16, 0.47916666666667
55526, 1.825, -0.04, 0.47916666666667
55527, 1.825, -0.08, 0.47916666666667
55528, 1.825, -0.12, 0.47916666666667
55529, 1.825, -0.16, 0.47916666666667
55530, 1.8666666666667, -0.04, 0.47916666666667
55531, 1.8666666666667, -0.08, 0.47916666666667
55532, 1.8666666666667, -0.12, 0.47916666666667
55533, 1.8666666666667, -0.16, 0.47916666666667
55534, 1.9083333333333, -0.04, 0.47916666666667
55535, 1.9083333333333, -0.08, 0.47916666666667
55536, 1.9083333333333, -0.12, 0.47916666666667
55537, 1.9083333333333, -0.16, 0.47916666666667
55538, 1.95, -0.04, 0.47916666666667
55539, 1.95, -0.08, 0.47916666666667
55540, 1.95, -0.12, 0.47916666666667
55541, 1.95, -0.16, 0.47916666666667
55542, 1.9916666666667, -0.04, 0.47916666666667
55543, 1.9916666666667, -0.08, 0.47916666666667
55544, 1.9916666666667, -0.12, 0.47916666666667
55545, 1.9916666666667, -0.16, 0.47916666666667
55546, 2.0333333333333, -0.04, 0.47916666666667
55547, 2.0333333333333, -0.08, 0.47916666666667
55548, 2.0333333333333, -0.12, 0.47916666666667
55549, 2.0333333333333, -0.16, 0.47916666666667
55550, 2.075, -0.04, 0.47916666666667
55551, 2.075, -0.08, 0.47916666666667
55552, 2.075, -0.12, 0.47916666666667
55553, 2.075, -0.16, 0.47916666666667
55554, 2.1166666666667, -0.04, 0.47916666666667
55555, 2.1166666666667, -0.08, 0.47916666666667
55556, 2.1166666666667, -0.12, 0.47916666666667
55557, 2.1166666666667, -0.16, 0.47916666666667
55558, 2.1583333333333, -0.04, 0.47916666666667
55559, 2.1583333333333, -0.08, 0.47916666666667
55560, 2.1583333333333, -0.12, 0.47916666666667
55561, 2.1583333333333, -0.16, 0.47916666666667
55562, 2.25, -0.04, 0.041666666666667
55563, 2.25, -0.08, 0.041666666666667
55564, 2.25, -0.12, 0.041666666666667
55565, 2.25, -0.16, 0.041666666666667
55566, 2.25, -0.04, 0.083333333333333
55567, 2.25, -0.08, 0.083333333333333
55568, 2.25, -0.12, 0.083333333333333
55569, 2.25, -0.16, 0.083333333333333
55570, 2.25, -0.04, 0.125
55571, 2.25, -0.08, 0.125
55572, 2.25, -0.12, 0.125
55573, 2.25, -0.16, 0.125
55574, 2.25, -0.04, 0.16666666666667
55575, 2.25, -0.08, 0.16666666666667
55576, 2.25, -0.12, 0.16666666666667
55577, 2.25, -0.16, 0.16666666666667
55578, 2.25, -0.04, 0.20833333333333
55579, 2.25, -0.08, 0.20833333333333
55580, 2.25, -0.12, 0.20833333333333
55581, 2.25, -0.16, 0.20833333333333
55582, 2.25, -0.04, 0.25
55583, 2.25, -0.08, 0.25
55584, 2.25, -0.12, 0.25
55585, 2.25, -0.16, 0.25
55586, 2.25, -0.04, 0.29166666666667
55587, 2.25, -0.08, 0.29166666666667
55588, 2.25, -0.12, 0.29166666666667
55589, 2.25, -0.16, 0.29166666666667
55590, 2.25, -0.04, 0.33333333333333
55591, 2.25, -0.08, 0.33333333333333
55592, 2.25, -0.12, 0.33333333333333
55593, 2.25, -0.16, 0.33333333333333
55594, 2.25, -0.04, 0.375
55595, 2.25, -0.08, 0.375
55596, 2.25, -0.12, 0.375
55597, 2.25, -0.16, 0.375
55598, 2.25, -0.04, 0.41666666666667
55599, 2.25, -0.08, 0.41666666666667
55600, 2.25, -0.12, 0.41666666666667
55601, 2.25, -0.16, 0.41666666666667
55602, 2.25, -0.04, 0.45833333333333
55603, 2.25, -0.08, 0.45833333333333
55604, 2.25, -0.12, 0.45833333333333
55605, 2.25, -0.16, 0.45833333333333
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line1
32122, 2, 97, 98
32123, 98, 0, 99
32124, 99, 0, 100
32125, 100, 0, 101
32126, 101, 0, 102
32127, 102, 0, 103
32128, 103, 0, 104
32129, 104, 0, 105
32130, 105, 0, 106
32131, 106, 0, 107
32132, 107, 0, 108
32133, 108, 0, 1
*ELEMENT, type=T3D3, ELSET=Line2
32134, 1, 0, 109
32135, 109, 0, 110
32136, 110, 0, 3
*ELEMENT, type=T3D3, ELSET=Line3
32137, 4, 0, 111
32138, 111, 0, 112
32139, 112, 0, 113
32140, 113, 0, 114
32141, 114, 0, 115
32142, 115, 0, 116
32143, 116, 0, 117
32144, 117, 0, 118
32145, 118, 0, 119
32146, 119, 0, 120
32147, 120, 0, 121
32148, 121, 0, 3
*ELEMENT, type=T3D3, ELSET=Line4
32149, 2, 0, 122
32150, 122, 0, 123
32151, 123, 0, 4
*ELEMENT, type=T3D3, ELSET=Line5
32152, 6, 0, 124
32153, 124, 0, 125
32154, 125, 0, 126
32155, 126, 0, 127
32156, 127, 0, 128
32157, 128, 0, 129
32158, 129, 0, 130
32159, 130, 0, 131
32160, 131, 0, 132
32161, 132, 0, 133
32162, 133, 0, 134
32163, 134, 0, 5
*ELEMENT, type=T3D3, ELSET=Line6
32164, 5, 0, 135
32165, 135, 0, 136
32166, 136, 0, 7
*ELEMENT, type=T3D3, ELSET=Line7
32167, 8, 0, 137
32168, 137, 0, 138
32169, 138, 0, 139
32170, 139, 0, 140
32171, 140, 0, 141
32172, 141, 0, 142
32173, 142, 0, 143
32174, 143, 0, 144
32175, 144, 0, 145
32176, 145, 0, 146
32177, 146, 0, 147
32178, 147, 0, 7
*ELEMENT, type=T3D3, ELSET=Line8
32179, 6, 0, 148
32180, 148, 0, 149
32181, 149, 0, 8
*ELEMENT, type=T3D3, ELSET=Line9
32182, 2, 0, 150
32183, 150, 0, 151
32184, 151, 0, 152
32185, 152, 0, 153
32186, 153, 0, 154
32187, 154, 0, 155
32188, 155, 0, 156
32189, 156, 0, 157
32190, 157, 0, 158
32191, 158, 0, 159
32192, 159, 0, 160
32193, 160, 0, 161
32194, 161, 0, 162
32195, 162, 0, 163
32196, 163, 0, 164
32197, 164, 0, 165
32198, 165, 0, 166
32199, 166, 0, 167
32200, 167, 0, 168
32201, 168, 0, 169
32202, 169, 0, 170
32203, 170, 0, 171
32204, 171, 0, 172
32205, 172, 0, 6
*ELEMENT, type=T3D3, ELSET=Line10
32206, 1, 0, 173
32207, 173, 0, 174
32208, 174, 0, 175
32209, 175, 0, 176
32210, 176, 0, 177
32211, 177, 0, 178
32212, 178, 0, 179
32213, 179, 0, 180
32214, 180, 0, 181
32215, 181, 0, 182
32216, 182, 0, 183
32217, 183, 0, 184
32218, 184, 0, 185
32219, 185, 0, 186
32220, 186, 0, 187
32221, 187, 0, 188
32222, 188, 0, 189
32223, 189, 0, 190
32224, 190, 0, 191
32225, 191, 0, 192
32226, 192, 0, 193
32227, 193, 0, 194
32228, 194, 0, 195
32229, 195, 0, 5
*ELEMENT, type=T3D3, ELSET=Line11
32230, 4, 0, 196
32231, 196, 0, 197
32232, 197, 0, 198
32233, 198, 0, 199
32234, 199, 0, 200
32235, 200, 0, 201
32236, 201, 0, 202
32237, 202, 0, 203
32238, 203, 0, 204
32239, 204, 0, 205
32240, 205, 0, 206
32241, 206, 0, 207
32242, 207, 0, 208
32243, 208, 0, 209
32244, 209, 0, 210
32245, 210, 0, 211
32246, 211, 0, 212
32247, 212, 0, 213
32248, 213, 0, 214
32249, 214, 0, 215
32250, 215, 0, 216
32251, 216, 0, 217
32252, 217, 0, 218
32253, 218, 0, 8
*ELEMENT, type=T3D3, ELSET=Line12
32254, 3, 0, 219
32255, 219, 0, 220
32256, 220, 0, 221
32257, 221, 0, 222
32258, 222, 0, 223
32259, 223, 0, 224
32260, 224, 0, 225
32261, 225, 0, 226
32262, 226, 0, 227
32263, 227, 0, 228
32264, 228, 0, 229
32265, 229, 0, 230
32266, 230, 0, 231
32267, 231, 0, 232
32268, 232, 0, 233
32269, 233, 0, 234
32270, 234, 0, 235
32271, 235, 0, 236
32272, 236, 0, 237
32273, 237, 0, 238
32274, 238, 0, 239
32275, 239, 0, 240
32276, 240, 0, 241
32277, 241, 0, 7
*ELEMENT, type=T3D3, ELSET=Line13
32278, 8, 0, 9
*ELEMENT, type=T3D3, ELSET=Line14
32279, 4, 0, 10
*ELEMENT, type=T3D3, ELSET=Line15
32280, 10, 0, 242
32281, 242, 0, 243
32282, 243, 0, 244
32283, 244, 0, 245
32284, 245, 0, 246
32285, 246, 0, 247
32286, 247, 0, 248
32287, 248, 0, 249
32288, 249, 0, 250
32289, 250, 0, 251
32290, 251, 0, 252
32291, 252, 0, 253
32292, 253, 0, 254
32293, 254, 0, 255
32294, 255, 0, 256
32295, 256, 0, 257
32296, 257, 0, 258
32297, 258, 0, 259
32298, 259, 0, 260
32299, 260, 0, 261
32300, 261, 0, 262
32301, 262, 0, 263
32302, 263, 0, 264
32303, 264, 0, 9
*ELEMENT, type=T3D3, ELSET=Line16
32304, 7, 0, 11
*ELEMENT, type=T3D3, ELSET=Line17
32305, 9, 0, 265
32306, 265, 0, 266
32307, 266, 0, 267
32308, 267, 0, 268
32309, 268, 0, 269
32310, 269, 0, 270
32311, 270, 0, 271
32312, 271, 0, 272
32313, 272, 0, 273
32314, 273, 0, 274
32315, 274, 0, 275
32316, 275, 0, 11
*ELEMENT, type=T3D3, ELSET=Line18
32317, 3, 0, 12
*ELEMENT, type=T3D3, ELSET=Line19
32318, 12, 0, 276
32319, 276, 0, 277
32320, 277, 0, 278
32321, 278, 0, 279
32322, 279, 0, 280
32323, 280, 0, 281
32324, 281, 0, 282
32325, 282, 0, 283
32326, 283, 0, 284
32327, 284, 0, 285
32328, 285, 0, 286
32329, 286, 0, 287
32330, 287, 0, 288
32331, 288, 0, 289
32332, 289, 0, 290
32333, 290, 0, 291
32334, 291, 0, 292
32335, 292, 0, 293
32336, 293, 0, 294
32337, 294, 0, 295
32338, 295, 0, 296
32339, 296, 0, 297
32340, 297, 0, 298
32341, 298, 0, 11
*ELEMENT, type=T3D3, ELSET=Line20
32342, 10, 0, 299
32343, 299, 0, 300
32344, 300, 0, 301
32345, 301, 0, 302
32346, 302, 0, 303
32347, 303, 0, 304
32348, 304, 0, 305
32349, 305, 0, 306
32350, 306, 0, 307
32351, 307, 0, 308
32352, 308, 0, 309
32353, 309, 0, 12
*ELEMENT, type=T3D3, ELSET=Line21
32354, 9, 0, 310
32355, 310, 0, 311
32356, 311, 0, 312
32357, 312, 0, 313
32358, 313, 0, 314
32359, 314, 0, 315
32360, 315, 0, 316
32361, 316, 0, 317
32362, 317, 0, 318
32363, 318, 0, 319
32364, 319, 0, 320
32365, 320, 0, 321
32366, 321, 0, 322
32367, 322, 0, 323
32368, 323, 0, 324
32369, 324, 0, 325
32370, 325, 0, 326
32371, 326, 0, 327
32372, 327, 0, 328
32373, 328, 0, 329
32374, 329, 0, 330
32375, 330, 0, 331
32376, 331, 0, 332
32377, 332, 0, 13
*ELEMENT, type=T3D3, ELSET=Line22
32378, 10, 0, 333
32379, 333, 0, 334
32380, 334, 0, 335
32381, 335, 0, 336
32382, 336, 0, 337
32383, 337, 0, 338
32384, 338, 0, 339
32385, 339, 0, 340
32386, 340, 0, 341
32387, 341, 0, 342
32388, 342, 0, 343
32389, 343, 0, 344
32390, 344, 0, 345
32391, 345, 0, 346
32392, 346, 0, 347
32393, 347, 0, 348
32394, 348, 0, 349
32395, 349, 0, 350
32396, 350, 0, 351
32397, 351, 0, 352
32398, 352, 0, 353
32399, 353, 0, 354
32400, 354, 0, 355
32401, 355, 0, 14
*ELEMENT, type=T3D3, ELSET=Line23
32402, 14, 0, 356
32403, 356, 0, 357
32404, 357, 0, 358
32405, 358, 0, 359
32406, 359, 0, 360
32407, 360, 0, 361
32408, 361, 0, 362
32409, 362, 0, 363
32410, 363, 0, 364
32411, 364, 0, 365
32412, 365, 0, 366
32413, 366, 0, 367
32414, 367, 0, 368
32415, 368, 0, 369
32416, 369, 0, 370
32417, 370, 0, 371
32418, 371, 0, 372
32419, 372, 0, 373
32420, 373, 0, 374
32421, 374, 0, 375
32422, 375, 0, 376
32423, 376, 0, 377
32424, 377, 0, 378
32425, 378, 0, 13
*ELEMENT, type=T3D3, ELSET=Line24
32426, 11, 0, 379
32427, 379, 0, 380
32428, 380, 0, 381
32429, 381, 0, 382
32430, 382, 0, 383
32431, 383, 0, 384
32432, 384, 0, 385
32433, 385, 0, 386
32434, 386, 0, 387
32435, 387, 0, 388
32436, 388, 0, 389
32437, 389, 0, 390
32438, 390, 0, 391
32439, 391, 0, 392
32440, 392, 0, 393
32441, 393, 0, 394
32442, 394, 0, 395
32443, 395, 0, 396
32444, 396, 0, 397
32445, 397, 0, 398
32446, 398, 0, 399
32447, 399, 0, 400
32448, 400, 0, 401
32449, 401, 0, 15
*ELEMENT, type=T3D3, ELSET=Line25
32450, 13, 0, 402
32451, 402, 0, 403
32452, 403, 0, 404
32453, 404, 0, 405
32454, 405, 0, 406
32455, 406, 0, 407
32456, 407, 0, 408
32457, 408, 0, 409
32458, 409, 0, 410
32459, 410, 0, 411
32460, 411, 0, 412
32461, 412, 0, 15
*ELEMENT, type=T3D3, ELSET=Line26
32462, 12, 0, 413
32463, 413, 0, 414
32464, 414, 0, 415
32465, 415, 0, 416
32466, 416, 0, 417
32467, 417, 0, 418
32468, 418, 0, 419
32469, 419, 0, 420
32470, 420, 0, 421
32471, 421, 0, 422
32472, 422, 0, 423
32473, 423, 0, 424
32474, 424, 0, 425
32475, 425, 0, 426
32476, 426, 0, 427
32477, 427, 0, 428
32478, 428, 0, 429
32479, 429, 0, 430
32480, 430, 0, 431
32481, 431, 0, 432
32482, 432, 0, 433
32483, 433, 0, 434
32484, 434, 0, 435
32485, 435, 0, 16
*ELEMENT, type=T3D3, ELSET=Line27
32486, 16, 0, 436
32487, 436, 0, 437
32488, 437, 0, 438
32489, 438, 0, 439
32490, 439, 0, 440
32491, 440, 0, 441
32492, 441, 0, 442
32493, 442, 0, 443
32494, 443, 0, 444
32495, 444, 0, 445
32496, 445, 0, 446
32497, 446, 0, 447
32498, 447, 0, 448
32499, 448, 0, 449
32500, 449, 0, 450
32501, 450, 0, 451
32502, 451, 0, 452
32503, 452, 0, 453
32504, 453, 0, 454
32505, 454, 0, 455
32506, 455, 0, 456
32507, 456, 0, 457
32508, 457, 0, 458
32509, 458, 0, 15
*ELEMENT, type=T3D3, ELSET=Line28
32510, 14, 0, 459
32511, 459, 0, 460
32512, 460, 0, 461
32513, 461, 0, 462
32514, 462, 0, 463
32515, 463, 0, 464
32516, 464, 0, 465
32517, 465, 0, 466
32518, 466, 0, 467
32519, 467, 0, 468
32520, 468, 0, 469
32521, 469, 0, 16
*ELEMENT, type=T3D3, ELSET=Line29
32522, 13, 0, 17
*ELEMENT, type=T3D3, ELSET=Line30
32523, 14, 0, 18
*ELEMENT, type=T3D3, ELSET=Line31
32524, 18, 0, 470
32525, 470, 0, 471
32526, 471, 0, 472
32527, 472, 0, 473
32528, 473, 0, 474
32529, 474, 0, 475
32530, 475, 0, 476
32531, 476, 0, 477
32532, 477, 0, 478
32533, 478, 0, 479
32534, 479, 0, 480
32535, 480, 0, 481
32536, 481, 0, 482
32537, 482, 0, 483
32538, 483, 0, 484
32539, 484, 0, 485
32540, 485, 0, 486
32541, 486, 0, 487
32542, 487, 0, 488
32543, 488, 0, 489
32544, 489, 0, 490
32545, 490, 0, 491
32546, 491, 0, 492
32547, 492, 0, 17
*ELEMENT, type=T3D3, ELSET=Line32
32548, 15, 0, 19
*ELEMENT, type=T3D3, ELSET=Line33
32549, 17, 0, 493
32550, 493, 0, 494
32551, 494, 0, 495
32552, 495, 0, 496
32553, 496, 0, 497
32554, 497, 0, 498
32555, 498, 0, 499
32556, 499, 0, 500
32557, 500, 0, 501
32558, 501, 0, 502
32559, 502, 0, 503
32560, 503, 0, 19
*ELEMENT, type=T3D3, ELSET=Line34
32561, 16, 0, 20
*ELEMENT, type=T3D3, ELSET=Line35
32562, 20, 0, 504
32563, 504, 0, 505
32564, 505, 0, 506
32565, 506, 0, 507
32566, 507, 0, 508
32567, 508, 0, 509
32568, 509, 0, 510
32569, 510, 0, 511
32570, 511, 0, 512
32571, 512, 0, 513
32572, 513, 0, 514
32573, 514, 0, 515
32574, 515, 0, 516
32575, 516, 0, 517
32576, 517, 0, 518
32577, 518, 0, 519
32578, 519, 0, 520
32579, 520, 0, 521
32580, 521, 0, 522
32581, 522, 0, 523
32582, 523, 0, 524
32583, 524, 0, 525
32584, 525, 0, 526
32585, 526, 0, 19
*ELEMENT, type=T3D3, ELSET=Line36
32586, 18, 0, 527
32587, 527, 0, 528
32588, 528, 0, 529
32589, 529, 0, 530
32590, 530, 0, 531
32591, 531, 0, 532
32592, 532, 0, 533
32593, 533, 0, 534
32594, 534, 0, 535
32595, 535, 0, 536
32596, 536, 0, 537
32597, 537, 0, 20
*ELEMENT, type=T3D3, ELSET=Line37
32598, 17, 0, 538
32599, 538, 0, 539
32600, 539, 0, 21
*ELEMENT, type=T3D3, ELSET=Line38
32601, 18, 0, 540
32602, 540, 0, 541
32603, 541, 0, 22
*ELEMENT, type=T3D3, ELSET=Line39
32604, 22, 0, 542
32605, 542, 0, 543
32606, 543, 0, 544
32607, 544, 0, 545
32608, 545, 0, 546
32609, 546, 0, 547
32610, 547, 0, 548
32611, 548, 0, 549
32612, 549, 0, 550
32613, 550, 0, 551
32614, 551, 0, 552
32615, 552, 0, 553
32616, 553, 0, 554
32617, 554, 0, 555
32618, 555, 0, 556
32619, 556, 0, 557
32620, 557, 0, 558
32621, 558, 0, 559
32622, 559, 0, 560
32623, 560, 0, 561
32624, 561, 0, 562
32625, 562, 0, 563
32626, 563, 0, 564
32627, 564, 0, 21
*ELEMENT, type=T3D3, ELSET=Line40
32628, 19, 0, 565
32629, 565, 0, 566
32630, 566, 0, 23
*ELEMENT, type=T3D3, ELSET=Line41
32631, 21, 0, 567
32632, 567, 0, 568
32633, 568, 0, 569
32634, 569, 0, 570
32635, 570, 0, 571
32636, 571, 0, 572
32637, 572, 0, 573
32638, 573, 0, 574
32639, 574, 0, 575
32640, 575, 0, 576
32641, 576, 0, 577
32642, 577, 0, 23
*ELEMENT, type=T3D3, ELSET=Line42
32643, 20, 0, 578
32644, 578, 0, 579
32645, 579, 0, 24
*ELEMENT, type=T3D3, ELSET=Line43
32646, 24, 0, 580
32647, 580, 0, 581
32648, 581, 0, 582
32649, 582, 0, 583
32650, 583, 0, 584
32651, 584, 0, 585
32652, 585, 0, 586
32653, 586, 0, 587
32654, 587, 0, 588
32655, 588, 0, 589
32656, 589, 0, 590
32657, 590, 0, 591
32658, 591, 0, 592
32659, 592, 0, 593
32660, 593, 0, 594
32661, 594, 0, 595
32662, 595, 0, 596
32663, 596, 0, 597
32664, 597, 0, 598
32665, 598, 0, 599
32666, 599, 0, 600
32667, 600, 0, 601
32668, 601, 0, 602
32669, 602, 0, 23
*ELEMENT, type=T3D3, ELSET=Line44
32670, 22, 0, 603
32671, 603, 0, 604
32672, 604, 0, 605
32673, 605, 0, 606
32674, 606, 0, 607
32675, 607, 0, 608
32676, 608, 0, 609
32677, 609, 0, 610
32678, 610, 0, 611
32679, 611, 0, 612
32680, 612, 0, 613
32681, 613, 0, 24
*ELEMENT, type=T3D3, ELSET=Line45
32682, 19, 0, 614
32683, 614, 0, 615
32684, 615, 0, 616
32685, 616, 0, 617
32686, 617, 0, 25
*ELEMENT, type=T3D3, ELSET=Line46
32687, 23, 0, 618
32688, 618, 0, 619
32689, 619, 0, 620
32690, 620, 0, 621
32691, 621, 0, 26
*ELEMENT, type=T3D3, ELSET=Line47
32692, 25, 0, 622
32693, 622, 0, 623
32694, 623, 0, 26
*ELEMENT, type=T3D3, ELSET=Line48
32695, 17, 0, 624
32696, 624, 0, 625
32697, 625, 0, 626
32698, 626, 0, 627
32699, 627, 0, 27
*ELEMENT, type=T3D3, ELSET=Line49
32700, 21, 0, 628
32701, 628, 0, 629
32702, 629, 0, 630
32703, 630, 0, 631
32704, 631, 0, 28
*ELEMENT, type=T3D3, ELSET=Line50
32705, 27, 0, 632
32706, 632, 0, 633
32707, 633, 0, 28
*ELEMENT, type=T3D3, ELSET=Line51
32708, 27, 0, 634
32709, 634, 0, 635
32710, 635, 0, 636
32711, 636, 0, 637
32712, 637, 0, 638
32713, 638, 0, 639
32714, 639, 0, 640
32715, 640, 0, 641
32716, 641, 0, 642
32717, 642, 0, 643
32718, 643, 0, 644
32719, 644, 0, 25
*ELEMENT, type=T3D3, ELSET=Line52
32720, 28, 0, 645
32721, 645, 0, 646
32722, 646, 0, 647
32723, 647, 0, 648
32724, 648, 0, 649
32725, 649, 0, 650
32726, 650, 0, 651
32727, 651, 0, 652
32728, 652, 0, 653
32729, 653, 0, 654
32730, 654, 0, 655
32731, 655, 0, 26
*ELEMENT, type=T3D3, ELSET=Line53
32732, 25, 0, 656
32733, 656, 0, 657
32734, 657, 0, 658
32735, 658, 0, 659
32736, 659, 0, 660
32737, 660, 0, 661
32738, 661, 0, 662
32739, 662, 0, 663
32740, 663, 0, 664
32741, 664, 0, 665
32742, 665, 0, 666
32743, 666, 0, 667
32744, 667, 0, 668
32745, 668, 0, 669
32746, 669, 0, 670
32747, 670, 0, 671
32748, 671, 0, 672
32749, 672, 0, 673
32750, 673, 0, 674
32751, 674, 0, 675
32752, 675, 0, 676
32753, 676, 0, 677
32754, 677, 0, 678
32755, 678, 0, 29
*ELEMENT, type=T3D3, ELSET=Line54
32756, 26, 0, 679
32757, 679, 0, 680
32758, 680, 0, 681
32759, 681, 0, 682
32760, 682, 0, 683
32761, 683, 0, 684
32762, 684, 0, 685
32763, 685, 0, 686
32764, 686, 0, 687
32765, 687, 0, 688
32766, 688, 0, 689
32767, 689, 0, 690
32768, 690, 0, 691
32769, 691, 0, 692
32770, 692, 0, 693
32771, 693, 0, 694
32772, 694, 0, 695
32773, 695, 0, 696
32774, 696, 0, 697
32775, 697, 0, 698
32776, 698, 0, 699
32777, 699, 0, 700
32778, 700, 0, 701
32779, 701, 0, 30
*ELEMENT, type=T3D3, ELSET=Line55
32780, 29, 0, 702
32781, 702, 0, 703
32782, 703, 0, 30
*ELEMENT, type=T3D3, ELSET=Line56
32783, 27, 0, 704
32784, 704, 0, 705
32785, 705, 0, 706
32786, 706, 0, 707
32787, 707, 0, 708
32788, 708, 0, 709
32789, 709, 0, 710
32790, 710, 0, 711
32791, 711, 0, 712
32792, 712, 0, 713
32793, 713, 0, 714
32794, 714, 0, 715
32795, 715, 0, 716
32796, 716, 0, 717
32797, 717, 0, 718
32798, 718, 0, 719
32799, 719, 0, 720
32800, 720, 0, 721
32801, 721, 0, 722
32802, 722, 0, 723
32803, 723, 0, 724
32804, 724, 0, 725
32805, 725, 0, 726
32806, 726, 0, 31
*ELEMENT, type=T3D3, ELSET=Line57
32807, 28, 0, 727
32808, 727, 0, 728
32809, 728, 0, 729
32810, 729, 0, 730
32811, 730, 0, 731
32812, 731, 0, 732
32813, 732, 0, 733
32814, 733, 0, 734
32815, 734, 0, 735
32816, 735, 0, 736
32817, 736, 0, 737
32818, 737, 0, 738
32819, 738, 0, 739
32820, 739, 0, 740
32821, 740, 0, 741
32822, 741, 0, 742
32823, 742, 0, 743
32824, 743, 0, 744
32825, 744, 0, 745
32826, 745, 0, 746
32827, 746, 0, 747
32828, 747, 0, 748
32829, 748, 0, 749
32830, 749, 0, 32
*ELEMENT, type=T3D3, ELSET=Line58
32831, 31, 0, 750
32832, 750, 0, 751
32833, 751, 0, 32
*ELEMENT, type=T3D3, ELSET=Line59
32834, 31, 0, 752
32835, 752, 0, 753
32836, 753, 0, 754
32837, 754, 0, 755
32838, 755, 0, 756
32839, 756, 0, 757
32840, 757, 0, 758
32841, 758, 0, 759
32842, 759, 0, 760
32843, 760, 0, 761
32844, 761, 0, 762
32845, 762, 0, 29
*ELEMENT, type=T3D3, ELSET=Line60
32846, 32, 0, 763
32847, 763, 0, 764
32848, 764, 0, 765
32849, 765, 0, 766
32850, 766, 0, 767
32851, 767, 0, 768
32852, 768, 0, 769
32853, 769, 0, 770
32854, 770, 0, 771
32855, 771, 0, 772
32856, 772, 0, 773
32857, 773, 0, 30
*ELEMENT, type=T3D3, ELSET=Line61
32858, 25, 0, 33
*ELEMENT, type=T3D3, ELSET=Line62
32859, 29, 0, 34
*ELEMENT, type=T3D3, ELSET=Line63
32860, 33, 0, 774
32861, 774, 0, 775
32862, 775, 0, 776
32863, 776, 0, 777
32864, 777, 0, 778
32865, 778, 0, 779
32866, 779, 0, 780
32867, 780, 0, 781
32868, 781, 0, 782
32869, 782, 0, 783
32870, 783, 0, 784
32871, 784, 0, 785
32872, 785, 0, 786
32873, 786, 0, 787
32874, 787, 0, 788
32875, 788, 0, 789
32876, 789, 0, 790
32877, 790, 0, 791
32878, 791, 0, 792
32879, 792, 0, 793
32880, 793, 0, 794
32881, 794, 0, 795
32882, 795, 0, 796
32883, 796, 0, 34
*ELEMENT, type=T3D3, ELSET=Line64
32884, 27, 0, 35
*ELEMENT, type=T3D3, ELSET=Line65
32885, 31, 0, 36
*ELEMENT, type=T3D3, ELSET=Line66
32886, 35, 0, 797
32887, 797, 0, 798
32888, 798, 0, 799
32889, 799, 0, 800
32890, 800, 0, 801
32891, 801, 0, 802
32892, 802, 0, 803
32893, 803, 0, 804
32894, 804, 0, 805
32895, 805, 0, 806
32896, 806, 0, 807
32897, 807, 0, 808
32898, 808, 0, 809
32899, 809, 0, 810
32900, 810, 0, 811
32901, 811, 0, 812
32902, 812, 0, 813
32903, 813, 0, 814
32904, 814, 0, 815
32905, 815, 0, 816
32906, 816, 0, 817
32907, 817, 0, 818
32908, 818, 0, 819
32909, 819, 0, 36
*ELEMENT, type=T3D3, ELSET=Line67
32910, 35, 0, 820
32911, 820, 0, 821
32912, 821, 0, 822
32913, 822, 0, 823
32914, 823, 0, 824
32915, 824, 0, 825
32916, 825, 0, 826
32917, 826, 0, 827
32918, 827, 0, 828
32919, 828, 0, 829
32920, 829, 0, 830
32921, 830, 0, 33
*ELEMENT, type=T3D3, ELSET=Line68
32922, 36, 0, 831
32923, 831, 0, 832
32924, 832, 0, 833
32925, 833, 0, 834
32926, 834, 0, 835
32927, 835, 0, 836
32928, 836, 0, 837
32929, 837, 0, 838
32930, 838, 0, 839
32931, 839, 0, 840
32932, 840, 0, 841
32933, 841, 0, 34
*ELEMENT, type=T3D3, ELSET=Line69
32934, 33, 0, 842
32935, 842, 0, 843
32936, 843, 0, 844
32937, 844, 0, 845
32938, 845, 0, 846
32939, 846, 0, 847
32940, 847, 0, 848
32941, 848, 0, 849
32942, 849, 0, 850
32943, 850, 0, 851
32944, 851, 0, 852
32945, 852, 0, 853
32946, 853, 0, 854
32947, 854, 0, 855
32948, 855, 0, 856
32949, 856, 0, 857
32950, 857, 0, 858
32951, 858, 0, 859
32952, 859, 0, 860
32953, 860, 0, 861
32954, 861, 0, 862
32955, 862, 0, 863
32956, 863, 0, 864
32957, 864, 0, 37
*ELEMENT, type=T3D3, ELSET=Line70
32958, 34, 0, 865
32959, 865, 0, 866
32960, 866, 0, 867
32961, 867, 0, 868
32962, 868, 0, 869
32963, 869, 0, 870
32964, 870, 0, 871
32965, 871, 0, 872
32966, 872, 0, 873
32967, 873, 0, 874
32968, 874, 0, 875
32969, 875, 0, 876
32970, 876, 0, 877
32971, 877, 0, 878
32972, 878, 0, 879
32973, 879, 0, 880
32974, 880, 0, 881
32975, 881, 0, 882
32976, 882, 0, 883
32977, 883, 0, 884
32978, 884, 0, 885
32979, 885, 0, 886
32980, 886, 0, 887
32981, 887, 0, 38
*ELEMENT, type=T3D3, ELSET=Line71
32982, 37, 0, 888
32983, 888, 0, 889
32984, 889, 0, 890
32985, 890, 0, 891
32986, 891, 0, 892
32987, 892, 0, 893
32988, 893, 0, 894
32989, 894, 0, 895
32990, 895, 0, 896
32991, 896, 0, 897
32992, 897, 0, 898
32993, 898, 0, 899
32994, 899, 0, 900
32995, 900, 0, 901
32996, 901, 0, 902
32997, 902, 0, 903
32998, 903, 0, 904
32999, 904, 0, 905
33000, 905, 0, 906
33001, 906, 0, 907
33002, 907, 0, 908
33003, 908, 0, 909
33004, 909, 0, 910
33005, 910, 0, 38
*ELEMENT, type=T3D3, ELSET=Line72
33006, 35, 0, 911
33007, 911, 0, 912
33008, 912, 0, 913
33009, 913, 0, 914
33010, 914, 0, 915
33011, 915, 0, 916
33012, 916, 0, 917
33013, 917, 0, 918
33014, 918, 0, 919
33015, 919, 0, 920
33016, 920, 0, 921
33017, 921, 0, 922
33018, 922, 0, 923
33019, 923, 0, 924
33020, 924, 0, 925
33021, 925, 0, 926
33022, 926, 0, 927
33023, 927, 0, 928
33024, 928, 0, 929
33025, 929, 0, 930
33026, 930, 0, 931
33027, 931, 0, 932
33028, 932, 0, 933
33029, 933, 0, 39
*ELEMENT, type=T3D3, ELSET=Line73
33030, 36, 0, 934
33031, 934, 0, 935
33032, 935, 0, 936
33033, 936, 0, 937
33034, 937, 0, 938
33035, 938, 0, 939
33036, 939, 0, 940
33037, 940, 0, 941
33038, 941, 0, 942
33039, 942, 0, 943
33040, 943, 0, 944
33041, 944, 0, 945
33042, 945, 0, 946
33043, 946, 0, 947
33044, 947, 0, 948
33045, 948, 0, 949
33046, 949, 0, 950
33047, 950, 0, 951
33048, 951, 0, 952
33049, 952, 0, 953
33050, 953, 0, 954
33051, 954, 0, 955
33052, 955, 0, 956
33053, 956, 0, 40
*ELEMENT, type=T3D3, ELSET=Line74
33054, 39, 0, 957
33055, 957, 0, 958
33056, 958, 0, 959
33057, 959, 0, 960
33058, 960, 0, 961
33059, 961, 0, 962
33060, 962, 0, 963
33061, 963, 0, 964
33062, 964, 0, 965
33063, 965, 0, 966
33064, 966, 0, 967
33065, 967, 0, 968
33066, 968, 0, 969
33067, 969, 0, 970
33068, 970, 0, 971
33069, 971, 0, 972
33070, 972, 0, 973
33071, 973, 0, 974
33072, 974, 0, 975
33073, 975, 0, 976
33074, 976, 0, 977
33075, 977, 0, 978
33076, 978, 0, 979
33077, 979, 0, 40
*ELEMENT, type=T3D3, ELSET=Line75
33078, 39, 0, 980
33079, 980, 0, 981
33080, 981, 0, 982
33081, 982, 0, 983
33082, 983, 0, 984
33083, 984, 0, 985
33084, 985, 0, 986
33085, 986, 0, 987
33086, 987, 0, 988
33087, 988, 0, 989
33088, 989, 0, 990
33089, 990, 0, 37
*ELEMENT, type=T3D3, ELSET=Line76
33090, 40, 0, 991
33091, 991, 0, 992
33092, 992, 0, 993
33093, 993, 0, 994
33094, 994, 0, 995
33095, 995, 0, 996
33096, 996, 0, 997
33097, 997, 0, 998
33098, 998, 0, 999
33099, 999, 0, 1000
33100, 1000, 0, 1001
33101, 1001, 0, 38
*ELEMENT, type=T3D3, ELSET=Line77
33102, 37, 0, 41
*ELEMENT, type=T3D3, ELSET=Line78
33103, 38, 0, 42
*ELEMENT, type=T3D3, ELSET=Line79
33104, 41, 0, 1002
33105, 1002, 0, 1003
33106, 1003, 0, 1004
33107, 1004, 0, 1005
33108, 1005, 0, 1006
33109, 1006, 0, 1007
33110, 1007, 0, 1008
33111, 1008, 0, 1009
33112, 1009, 0, 1010
33113, 1010, 0, 1011
33114, 1011, 0, 1012
33115, 1012, 0, 1013
33116, 1013, 0, 1014
33117, 1014, 0, 1015
33118, 1015, 0, 1016
33119, 1016, 0, 1017
33120, 1017, 0, 1018
33121, 1018, 0, 1019
33122, 1019, 0, 1020
33123, 1020, 0, 1021
33124, 1021, 0, 1022
33125, 1022, 0, 1023
33126, 1023, 0, 1024
33127, 1024, 0, 42
*ELEMENT, type=T3D3, ELSET=Line80
33128, 39, 1025, 43
*ELEMENT, type=T3D3, ELSET=Line81
33129, 40, 1026, 44
*ELEMENT, type=T3D3, ELSET=Line82
33130, 43, 1050, 1027
33131, 1027, 1051, 1028
33132, 1028, 1052, 1029
33133, 1029, 1053, 1030
33134, 1030, 1054, 1031
33135, 1031, 1055, 1032
33136, 1032, 1056, 1033
33137, 1033, 1057, 1034
33138, 1034, 1058, 1035
33139, 1035, 1059, 1036
33140, 1036, 1060, 1037
33141, 1037, 1061, 1038
33142, 1038, 1062, 1039
33143, 1039, 1063, 1040
33144, 1040, 1064, 1041
33145, 1041, 1065, 1042
33146, 1042, 1066, 1043
33147, 1043, 1067, 1044
33148, 1044, 1068, 1045
33149, 1045, 1069, 1046
33150, 1046, 1070, 1047
33151, 1047, 1071, 1048
33152, 1048, 1072, 1049
33153, 1049, 1073, 44
*ELEMENT, type=T3D3, ELSET=Line83
33154, 43, 1085, 1074
33155, 1074, 1086, 1075
33156, 1075, 1087, 1076
33157, 1076, 1088, 1077
33158, 1077, 1089, 1078
33159, 1078, 1090, 1079
33160, 1079, 1091, 1080
33161, 1080, 1092, 1081
33162, 1081, 1093, 1082
33163, 1082, 1094, 1083
33164, 1083, 1095, 1084
33165, 1084, 1096, 41
*ELEMENT, type=T3D3, ELSET=Line84
33166, 44, 1108, 1097
33167, 1097, 1109, 1098
33168, 1098, 1110, 1099
33169, 1099, 1111, 1100
33170, 1100, 1112, 1101
33171, 1101, 1113, 1102
33172, 1102, 1114, 1103
33173, 1103, 1115, 1104
33174, 1104, 1116, 1105
33175, 1105, 1117, 1106
33176, 1106, 1118, 1107
33177, 1107, 1119, 42
*ELEMENT, type=T3D3, ELSET=Line85
33178, 41, 0, 1120
33179, 1120, 0, 1121
33180, 1121, 0, 45
*ELEMENT, type=T3D3, ELSET=Line86
33181, 42, 0, 1122
33182, 1122, 0, 1123
33183, 1123, 0, 46
*ELEMENT, type=T3D3, ELSET=Line87
33184, 45, 0, 1124
33185, 1124, 0, 1125
33186, 1125, 0, 1126
33187, 1126, 0, 1127
33188, 1127, 0, 1128
33189, 1128, 0, 1129
33190, 1129, 0, 1130
33191, 1130, 0, 1131
33192, 1131, 0, 1132
33193, 1132, 0, 1133
33194, 1133, 0, 1134
33195, 1134, 0, 1135
33196, 1135, 0, 1136
33197, 1136, 0, 1137
33198, 1137, 0, 1138
33199, 1138, 0, 1139
33200, 1139, 0, 1140
33201, 1140, 0, 1141
33202, 1141, 0, 1142
33203, 1142, 0, 1143
33204, 1143, 0, 1144
33205, 1144, 0, 1145
33206, 1145, 0, 1146
33207, 1146, 0, 46
*ELEMENT, type=T3D3, ELSET=Line88
33208, 43, 1149, 1147
33209, 1147, 1150, 1148
33210, 1148, 1151, 47
*ELEMENT, type=T3D3, ELSET=Line89
33211, 44, 1154, 1152
33212, 1152, 1155, 1153
33213, 1153, 1156, 48
*ELEMENT, type=T3D3, ELSET=Line90
33214, 47, 0, 1157
33215, 1157, 0, 1158
33216, 1158, 0, 1159
33217, 1159, 0, 1160
33218, 1160, 0, 1161
33219, 1161, 0, 1162
33220, 1162, 0, 1163
33221, 1163, 0, 1164
33222, 1164, 0, 1165
33223, 1165, 0, 1166
33224, 1166, 0, 1167
33225, 1167, 0, 1168
33226, 1168, 0, 1169
33227, 1169, 0, 1170
33228, 1170, 0, 1171
33229, 1171, 0, 1172
33230, 1172, 0, 1173
33231, 1173, 0, 1174
33232, 1174, 0, 1175
33233, 1175, 0, 1176
33234, 1176, 0, 1177
33235, 1177, 0, 1178
33236, 1178, 0, 1179
33237, 1179, 0, 48
*ELEMENT, type=T3D3, ELSET=Line91
33238, 47, 0, 1180
33239, 1180, 0, 1181
33240, 1181, 0, 1182
33241, 1182, 0, 1183
33242, 1183, 0, 1184
33243, 1184, 0, 1185
33244, 1185, 0, 1186
33245, 1186, 0, 1187
33246, 1187, 0, 1188
33247, 1188, 0, 1189
33248, 1189, 0, 1190
33249, 1190, 0, 45
*ELEMENT, type=T3D3, ELSET=Line92
33250, 48, 0, 1191
33251, 1191, 0, 1192
33252, 1192, 0, 1193
33253, 1193, 0, 1194
33254, 1194, 0, 1195
33255, 1195, 0, 1196
33256, 1196, 0, 1197
33257, 1197, 0, 1198
33258, 1198, 0, 1199
33259, 1199, 0, 1200
33260, 1200, 0, 1201
33261, 1201, 0, 46
*ELEMENT, type=T3D3, ELSET=Line93
33262, 42, 0, 49
*ELEMENT, type=T3D3, ELSET=Line94
33263, 46, 0, 50
*ELEMENT, type=T3D3, ELSET=Line95
1, 49, 0, 1202
2, 1202, 0, 1203
3, 1203, 0, 50
*ELEMENT, type=T3D3, ELSET=Line96
33264, 44, 55606, 51
*ELEMENT, type=T3D3, ELSET=Line97
33265, 48, 0, 52
*ELEMENT, type=T3D3, ELSET=Line98
33266, 51, 0, 1204
33267, 1204, 0, 1205
33268, 1205, 0, 52
*ELEMENT, type=T3D3, ELSET=Line99
33269, 51, 0, 1206
33270, 1206, 0, 1207
33271, 1207, 0, 1208
33272, 1208, 0, 1209
33273, 1209, 0, 1210
33274, 1210, 0, 1211
33275, 1211, 0, 1212
33276, 1212, 0, 1213
33277, 1213, 0, 1214
33278, 1214, 0, 1215
33279, 1215, 0, 1216
33280, 1216, 0, 49
*ELEMENT, type=T3D3, ELSET=Line100
33281, 52, 0, 1217
33282, 1217, 0, 1218
33283, 1218, 0, 1219
33284, 1219, 0, 1220
33285, 1220, 0, 1221
33286, 1221, 0, 1222
33287, 1222, 0, 1223
33288, 1223, 0, 1224
33289, 1224, 0, 1225
33290, 1225, 0, 1226
33291, 1226, 0, 1227
33292, 1227, 0, 50
*ELEMENT, type=T3D3, ELSET=Line101
33293, 1, 0, 53
*ELEMENT, type=T3D3, ELSET=Line102
33294, 2, 0, 54
*ELEMENT, type=T3D3, ELSET=Line103
33295, 54, 0, 1228
33296, 1228, 0, 1229
33297, 1229, 0, 1230
33298, 1230, 0, 1231
33299, 1231, 0, 1232
33300, 1232, 0, 1233
33301, 1233, 0, 1234
33302, 1234, 0, 1235
33303, 1235, 0, 1236
33304, 1236, 0, 1237
33305, 1237, 0, 1238
33306, 1238, 0, 53
*ELEMENT, type=T3D3, ELSET=Line104
33307, 3, 0, 55
*ELEMENT, type=T3D3, ELSET=Line105
4, 53, 0, 1239
5, 1239, 0, 1240
6, 1240, 0, 55
*ELEMENT, type=T3D3, ELSET=Line106
33308, 4, 55607, 56
*ELEMENT, type=T3D3, ELSET=Line107
33309, 56, 0, 1241
33310, 1241, 0, 1242
33311, 1242, 0, 1243
33312, 1243, 0, 1244
33313, 1244, 0, 1245
33314, 1245, 0, 1246
33315, 1246, 0, 1247
33316, 1247, 0, 1248
33317, 1248, 0, 1249
33318, 1249, 0, 1250
33319, 1250, 0, 1251
33320, 1251, 0, 55
*ELEMENT, type=T3D3, ELSET=Line108
33321, 54, 0, 1252
33322, 1252, 0, 1253
33323, 1253, 0, 56
*ELEMENT, type=T3D3, ELSET=Line125
33324, 11, 0, 57
*ELEMENT, type=T3D3, ELSET=Line126
33325, 15, 0, 58
*ELEMENT, type=T3D3, ELSET=Line127
33326, 57, 0, 1254
33327, 1254, 0, 1255
33328, 1255, 0, 1256
33329, 1256, 0, 1257
33330, 1257, 0, 1258
33331, 1258, 0, 1259
33332, 1259, 0, 1260
33333, 1260, 0, 1261
33334, 1261, 0, 1262
33335, 1262, 0, 1263
33336, 1263, 0, 1264
33337, 1264, 0, 1265
33338, 1265, 0, 1266
33339, 1266, 0, 1267
33340, 1267, 0, 1268
33341, 1268, 0, 1269
33342, 1269, 0, 1270
33343, 1270, 0, 1271
33344, 1271, 0, 1272
33345, 1272, 0, 1273
33346, 1273, 0, 1274
33347, 1274, 0, 1275
33348, 1275, 0, 1276
33349, 1276, 0, 58
*ELEMENT, type=T3D3, ELSET=Line128
33350, 9, 1277, 59
*ELEMENT, type=T3D3, ELSET=Line129
33351, 13, 1278, 60
*ELEMENT, type=T3D3, ELSET=Line130
33352, 59, 1302, 1279
33353, 1279, 1303, 1280
33354, 1280, 1304, 1281
33355, 1281, 1305, 1282
33356, 1282, 1306, 1283
33357, 1283, 1307, 1284
33358, 1284, 1308, 1285
33359, 1285, 1309, 1286
33360, 1286, 1310, 1287
33361, 1287, 1311, 1288
33362, 1288, 1312, 1289
33363, 1289, 1313, 1290
33364, 1290, 1314, 1291
33365, 1291, 1315, 1292
33366, 1292, 1316, 1293
33367, 1293, 1317, 1294
33368, 1294, 1318, 1295
33369, 1295, 1319, 1296
33370, 1296, 1320, 1297
33371, 1297, 1321, 1298
33372, 1298, 1322, 1299
33373, 1299, 1323, 1300
33374, 1300, 1324, 1301
33375, 1301, 1325, 60
*ELEMENT, type=T3D3, ELSET=Line131
33376, 59, 1337, 1326
33377, 1326, 1338, 1327
33378, 1327, 1339, 1328
33379, 1328, 1340, 1329
33380, 1329, 1341, 1330
33381, 1330, 1342, 1331
33382, 1331, 1343, 1332
33383, 1332, 1344, 1333
33384, 1333, 1345, 1334
33385, 1334, 1346, 1335
33386, 1335, 1347, 1336
33387, 1336, 1348, 57
*ELEMENT, type=T3D3, ELSET=Line132
33388, 60, 1360, 1349
33389, 1349, 1361, 1350
33390, 1350, 1362, 1351
33391, 1351, 1363, 1352
33392, 1352, 1364, 1353
33393, 1353, 1365, 1354
33394, 1354, 1366, 1355
33395, 1355, 1367, 1356
33396, 1356, 1368, 1357
33397, 1357, 1369, 1358
33398, 1358, 1370, 1359
33399, 1359, 1371, 58
*ELEMENT, type=T3D3, ELSET=Line133
33400, 33, 0, 61
*ELEMENT, type=T3D3, ELSET=Line134
33401, 37, 0, 62
*ELEMENT, type=T3D3, ELSET=Line135
33402, 61, 0, 1372
33403, 1372, 0, 1373
33404, 1373, 0, 1374
33405, 1374, 0, 1375
33406, 1375, 0, 1376
33407, 1376, 0, 1377
33408, 1377, 0, 1378
33409, 1378, 0, 1379
33410, 1379, 0, 1380
33411, 1380, 0, 1381
33412, 1381, 0, 1382
33413, 1382, 0, 1383
33414, 1383, 0, 1384
33415, 1384, 0, 1385
33416, 1385, 0, 1386
33417, 1386, 0, 1387
33418, 1387, 0, 1388
33419, 1388, 0, 1389
33420, 1389, 0, 1390
33421, 1390, 0, 1391
33422, 1391, 0, 1392
33423, 1392, 0, 1393
33424, 1393, 0, 1394
33425, 1394, 0, 62
*ELEMENT, type=T3D3, ELSET=Line136
33426, 35, 1395, 63
*ELEMENT, type=T3D3, ELSET=Line137
33427, 39, 1396, 64
*ELEMENT, type=T3D3, ELSET=Line138
33428, 63, 1420, 1397
33429, 1397, 1421, 1398
33430, 1398, 1422, 1399
33431, 1399, 1423, 1400
33432, 1400, 1424, 1401
33433, 1401, 1425, 1402
33434, 1402, 1426, 1403
33435, 1403, 1427, 1404
33436, 1404, 1428, 1405
33437, 1405, 1429, 1406
33438, 1406, 1430, 1407
33439, 1407, 1431, 1408
33440, 1408, 1432, 1409
33441, 1409, 1433, 1410
33442, 1410, 1434, 1411
33443, 1411, 1435, 1412
33444, 1412, 1436, 1413
33445, 1413, 1437, 1414
33446, 1414, 1438, 1415
33447, 1415, 1439, 1416
33448, 1416, 1440, 1417
33449, 1417, 1441, 1418
33450, 1418, 1442, 1419
33451, 1419, 1443, 64
*ELEMENT, type=T3D3, ELSET=Line139
33452, 63, 1455, 1444
33453, 1444, 1456, 1445
33454, 1445, 1457, 1446
33455, 1446, 1458, 1447
33456, 1447, 1459, 1448
33457, 1448, 1460, 1449
33458, 1449, 1461, 1450
33459, 1450, 1462, 1451
33460, 1451, 1463, 1452
33461, 1452, 1464, 1453
33462, 1453, 1465, 1454
33463, 1454, 1466, 61
*ELEMENT, type=T3D3, ELSET=Line140
33464, 64, 1478, 1467
33465, 1467, 1479, 1468
33466, 1468, 1480, 1469
33467, 1469, 1481, 1470
33468, 1470, 1482, 1471
33469, 1471, 1483, 1472
33470, 1472, 1484, 1473
33471, 1473, 1485, 1474
33472, 1474, 1486, 1475
33473, 1475, 1487, 1476
33474, 1476, 1488, 1477
33475, 1477, 1489, 62
*ELEMENT, type=T3D3, ELSET=Line141
33476, 9, 1490, 65
*ELEMENT, type=T3D3, ELSET=Line142
33477, 13, 1491, 66
*ELEMENT, type=T3D3, ELSET=Line143
33478, 65, 1515, 1492
33479, 1492, 1516, 1493
33480, 1493, 1517, 1494
33481, 1494, 1518, 1495
33482, 1495, 1519, 1496
33483, 1496, 1520, 1497
33484, 1497, 1521, 1498
33485, 1498, 1522, 1499
33486, 1499, 1523, 1500
33487, 1500, 1524, 1501
33488, 1501, 1525, 1502
33489, 1502, 1526, 1503
33490, 1503, 1527, 1504
33491, 1504, 1528, 1505
33492, 1505, 1529, 1506
33493, 1506, 1530, 1507
33494, 1507, 1531, 1508
33495, 1508, 1532, 1509
33496, 1509, 1533, 1510
33497, 1510, 1534, 1511
33498, 1511, 1535, 1512
33499, 1512, 1536, 1513
33500, 1513, 1537, 1514
33501, 1514, 1538, 66
*ELEMENT, type=T3D3, ELSET=Line144
33502, 10, 1539, 67
*ELEMENT, type=T3D3, ELSET=Line145
33503, 14, 1540, 68
*ELEMENT, type=T3D3, ELSET=Line146
33504, 67, 1564, 1541
33505, 1541, 1565, 1542
33506, 1542, 1566, 1543
33507, 1543, 1567, 1544
33508, 1544, 1568, 1545
33509, 1545, 1569, 1546
33510, 1546, 1570, 1547
33511, 1547, 1571, 1548
33512, 1548, 1572, 1549
33513, 1549, 1573, 1550
33514, 1550, 1574, 1551
33515, 1551, 1575, 1552
33516, 1552, 1576, 1553
33517, 1553, 1577, 1554
33518, 1554, 1578, 1555
33519, 1555, 1579, 1556
33520, 1556, 1580, 1557
33521, 1557, 1581, 1558
33522, 1558, 1582, 1559
33523, 1559, 1583, 1560
33524, 1560, 1584, 1561
33525, 1561, 1585, 1562
33526, 1562, 1586, 1563
33527, 1563, 1587, 68
*ELEMENT, type=T3D3, ELSET=Line147
33528, 67, 1611, 1588
33529, 1588, 1612, 1589
33530, 1589, 1613, 1590
33531, 1590, 1614, 1591
33532, 1591, 1615, 1592
33533, 1592, 1616, 1593
33534, 1593, 1617, 1594
33535, 1594, 1618, 1595
33536, 1595, 1619, 1596
33537, 1596, 1620, 1597
33538, 1597, 1621, 1598
33539, 1598, 1622, 1599
33540, 1599, 1623, 1600
33541, 1600, 1624, 1601
33542, 1601, 1625, 1602
33543, 1602, 1626, 1603
33544, 1603, 1627, 1604
33545, 1604, 1628, 1605
33546, 1605, 1629, 1606
33547, 1606, 1630, 1607
33548, 1607, 1631, 1608
33549, 1608, 1632, 1609
33550, 1609, 1633, 1610
33551, 1610, 1634, 65
*ELEMENT, type=T3D3, ELSET=Line148
33552, 68, 1658, 1635
33553, 1635, 1659, 1636
33554, 1636, 1660, 1637
33555, 1637, 1661, 1638
33556, 1638, 1662, 1639
33557, 1639, 1663, 1640
33558, 1640, 1664, 1641
33559, 1641, 1665, 1642
33560, 1642, 1666, 1643
33561, 1643, 1667, 1644
33562, 1644, 1668, 1645
33563, 1645, 1669, 1646
33564, 1646, 1670, 1647
33565, 1647, 1671, 1648
33566, 1648, 1672, 1649
33567, 1649, 1673, 1650
33568, 1650, 1674, 1651
33569, 1651, 1675, 1652
33570, 1652, 1676, 1653
33571, 1653, 1677, 1654
33572, 1654, 1678, 1655
33573, 1655, 1679, 1656
33574, 1656, 1680, 1657
33575, 1657, 1681, 66
*ELEMENT, type=T3D3, ELSET=Line149
33576, 35, 1682, 69
*ELEMENT, type=T3D3, ELSET=Line150
33577, 39, 1683, 70
*ELEMENT, type=T3D3, ELSET=Line151
33578, 69, 1707, 1684
33579, 1684, 1708, 1685
33580, 1685, 1709, 1686
33581, 1686, 1710, 1687
33582, 1687, 1711, 1688
33583, 1688, 1712, 1689
33584, 1689, 1713, 1690
33585, 1690, 1714, 1691
33586, 1691, 1715, 1692
33587, 1692, 1716, 1693
33588, 1693, 1717, 1694
33589, 1694, 1718, 1695
33590, 1695, 1719, 1696
33591, 1696, 1720, 1697
33592, 1697, 1721, 1698
33593, 1698, 1722, 1699
33594, 1699, 1723, 1700
33595, 1700, 1724, 1701
33596, 1701, 1725, 1702
33597, 1702, 1726, 1703
33598, 1703, 1727, 1704
33599, 1704, 1728, 1705
33600, 1705, 1729, 1706
33601, 1706, 1730, 70
*ELEMENT, type=T3D3, ELSET=Line152
33602, 36, 1731, 71
*ELEMENT, type=T3D3, ELSET=Line153
33603, 40, 1732, 72
*ELEMENT, type=T3D3, ELSET=Line154
33604, 71, 1756, 1733
33605, 1733, 1757, 1734
33606, 1734, 1758, 1735
33607, 1735, 1759, 1736
33608, 1736, 1760, 1737
33609, 1737, 1761, 1738
33610, 1738, 1762, 1739
33611, 1739, 1763, 1740
33612, 1740, 1764, 1741
33613, 1741, 1765, 1742
33614, 1742, 1766, 1743
33615, 1743, 1767, 1744
33616, 1744, 1768, 1745
33617, 1745, 1769, 1746
33618, 1746, 1770, 1747
33619, 1747, 1771, 1748
33620, 1748, 1772, 1749
33621, 1749, 1773, 1750
33622, 1750, 1774, 1751
33623, 1751, 1775, 1752
33624, 1752, 1776, 1753
33625, 1753, 1777, 1754
33626, 1754, 1778, 1755
33627, 1755, 1779, 72
*ELEMENT, type=T3D3, ELSET=Line155
33628, 69, 1803, 1780
33629, 1780, 1804, 1781
33630, 1781, 1805, 1782
33631, 1782, 1806, 1783
33632, 1783, 1807, 1784
33633, 1784, 1808, 1785
33634, 1785, 1809, 1786
33635, 1786, 1810, 1787
33636, 1787, 1811, 1788
33637, 1788, 1812, 1789
33638, 1789, 1813, 1790
33639, 1790, 1814, 1791
33640, 1791, 1815, 1792
33641, 1792, 1816, 1793
33642, 1793, 1817, 1794
33643, 1794, 1818, 1795
33644, 1795, 1819, 1796
33645, 1796, 1820, 1797
33646, 1797, 1821, 1798
33647, 1798, 1822, 1799
33648, 1799, 1823, 1800
33649, 1800, 1824, 1801
33650, 1801, 1825, 1802
33651, 1802, 1826, 71
*ELEMENT, type=T3D3, ELSET=Line156
33652, 70, 1850, 1827
33653, 1827, 1851, 1828
33654, 1828, 1852, 1829
33655, 1829, 1853, 1830
33656, 1830, 1854, 1831
33657, 1831, 1855, 1832
33658, 1832, 1856, 1833
33659, 1833, 1857, 1834
33660, 1834, 1858, 1835
33661, 1835, 1859, 1836
33662, 1836, 1860, 1837
33663, 1837, 1861, 1838
33664, 1838, 1862, 1839
33665, 1839, 1863, 1840
33666, 1840, 1864, 1841
33667, 1841, 1865, 1842
33668, 1842, 1866, 1843
33669, 1843, 1867, 1844
33670, 1844, 1868, 1845
33671, 1845, 1869, 1846
33672, 1846, 1870, 1847
33673, 1847, 1871, 1848
33674, 1848, 1872, 1849
33675, 1849, 1873, 72
*ELEMENT, type=T3D3, ELSET=Line157
33676, 63, 1874, 73
*ELEMENT, type=T3D3, ELSET=Line158
33677, 69, 1875, 73
*ELEMENT, type=T3D3, ELSET=Line159
33678, 64, 1876, 74
*ELEMENT, type=T3D3, ELSET=Line160
33679, 70, 1877, 74
*ELEMENT, type=T3D3, ELSET=Line161
33680, 73, 1901, 1878
33681, 1878, 1902, 1879
33682, 1879, 1903, 1880
33683, 1880, 1904, 1881
33684, 1881, 1905, 1882
33685, 1882, 1906, 1883
33686, 1883, 1907, 1884
33687, 1884, 1908, 1885
33688, 1885, 1909, 1886
33689, 1886, 1910, 1887
33690, 1887, 1911, 1888
33691, 1888, 1912, 1889
33692, 1889, 1913, 1890
33693, 1890, 1914, 1891
33694, 1891, 1915, 1892
33695, 1892, 1916, 1893
33696, 1893, 1917, 1894
33697, 1894, 1918, 1895
33698, 1895, 1919, 1896
33699, 1896, 1920, 1897
33700, 1897, 1921, 1898
33701, 1898, 1922, 1899
33702, 1899, 1923, 1900
33703, 1900, 1924, 74
*ELEMENT, type=T3D3, ELSET=Line162
33704, 59, 1925, 75
*ELEMENT, type=T3D3, ELSET=Line163
33705, 65, 1926, 75
*ELEMENT, type=T3D3, ELSET=Line164
33706, 60, 1927, 76
*ELEMENT, type=T3D3, ELSET=Line165
33707, 66, 1928, 76
*ELEMENT, type=T3D3, ELSET=Line166
33708, 75, 1952, 1929
33709, 1929, 1953, 1930
33710, 1930, 1954, 1931
33711, 1931, 1955, 1932
33712, 1932, 1956, 1933
33713, 1933, 1957, 1934
33714, 1934, 1958, 1935
33715, 1935, 1959, 1936
33716, 1936, 1960, 1937
33717, 1937, 1961, 1938
33718, 1938, 1962, 1939
33719, 1939, 1963, 1940
33720, 1940, 1964, 1941
33721, 1941, 1965, 1942
33722, 1942, 1966, 1943
33723, 1943, 1967, 1944
33724, 1944, 1968, 1945
33725, 1945, 1969, 1946
33726, 1946, 1970, 1947
33727, 1947, 1971, 1948
33728, 1948, 1972, 1949
33729, 1949, 1973, 1950
33730, 1950, 1974, 1951
33731, 1951, 1975, 76
*ELEMENT, type=T3D3, ELSET=Line167
33732, 21, 1980, 1976
33733, 1976, 1981, 1977
33734, 1977, 1982, 1978
33735, 1978, 1983, 1979
33736, 1979, 1984, 77
*ELEMENT, type=T3D3, ELSET=Line168
33737, 22, 1989, 1985
33738, 1985, 1990, 1986
33739, 1986, 1991, 1987
33740, 1987, 1992, 1988
33741, 1988, 1993, 78
*ELEMENT, type=T3D3, ELSET=Line169
33742, 78, 0, 1994
33743, 1994, 0, 1995
33744, 1995, 0, 1996
33745, 1996, 0, 1997
33746, 1997, 0, 1998
33747, 1998, 0, 1999
33748, 1999, 0, 2000
33749, 2000, 0, 2001
33750, 2001, 0, 2002
33751, 2002, 0, 2003
33752, 2003, 0, 2004
33753, 2004, 0, 2005
33754, 2005, 0, 2006
33755, 2006, 0, 2007
33756, 2007, 0, 2008
33757, 2008, 0, 2009
33758, 2009, 0, 2010
33759, 2010, 0, 2011
33760, 2011, 0, 2012
33761, 2012, 0, 2013
33762, 2013, 0, 2014
33763, 2014, 0, 2015
33764, 2015, 0, 2016
33765, 2016, 0, 77
*ELEMENT, type=T3D3, ELSET=Line170
33766, 23, 0, 2017
33767, 2017, 0, 2018
33768, 2018, 0, 2019
33769, 2019, 0, 2020
33770, 2020, 0, 79
*ELEMENT, type=T3D3, ELSET=Line171
33771, 77, 0, 2021
33772, 2021, 0, 2022
33773, 2022, 0, 2023
33774, 2023, 0, 2024
33775, 2024, 0, 2025
33776, 2025, 0, 2026
33777, 2026, 0, 2027
33778, 2027, 0, 2028
33779, 2028, 0, 2029
33780, 2029, 0, 2030
33781, 2030, 0, 2031
33782, 2031, 0, 79
*ELEMENT, type=T3D3, ELSET=Line172
33783, 24, 0, 2032
33784, 2032, 0, 2033
33785, 2033, 0, 2034
33786, 2034, 0, 2035
33787, 2035, 0, 80
*ELEMENT, type=T3D3, ELSET=Line173
7, 80, 0, 2036
8, 2036, 0, 2037
9, 2037, 0, 2038
10, 2038, 0, 2039
11, 2039, 0, 2040
12, 2040, 0, 2041
13, 2041, 0, 2042
14, 2042, 0, 2043
15, 2043, 0, 2044
16, 2044, 0, 2045
17, 2045, 0, 2046
18, 2046, 0, 2047
19, 2047, 0, 2048
20, 2048, 0, 2049
21, 2049, 0, 2050
22, 2050, 0, 2051
23, 2051, 0, 2052
24, 2052, 0, 2053
25, 2053, 0, 2054
26, 2054, 0, 2055
27, 2055, 0, 2056
28, 2056, 0, 2057
29, 2057, 0, 2058
30, 2058, 0, 79
*ELEMENT, type=T3D3, ELSET=Line174
33788, 78, 0, 2059
33789, 2059, 0, 2060
33790, 2060, 0, 2061
33791, 2061, 0, 2062
33792, 2062, 0, 2063
33793, 2063, 0, 2064
33794, 2064, 0, 2065
33795, 2065, 0, 2066
33796, 2066, 0, 2067
33797, 2067, 0, 2068
33798, 2068, 0, 2069
33799, 2069, 0, 80
*ELEMENT, type=T3D3, ELSET=Line175
33800, 26, 0, 2070
33801, 2070, 0, 2071
33802, 2071, 0, 2072
33803, 2072, 0, 2073
33804, 2073, 0, 81
*ELEMENT, type=T3D3, ELSET=Line176
31, 79, 0, 2074
32, 2074, 0, 2075
33, 2075, 0, 2076
34, 2076, 0, 2077
35, 2077, 0, 81
*ELEMENT, type=T3D3, ELSET=Line177
33805, 28, 2082, 2078
33806, 2078, 2083, 2079
33807, 2079, 2084, 2080
33808, 2080, 2085, 2081
33809, 2081, 2086, 82
*ELEMENT, type=T3D3, ELSET=Line178
33810, 77, 0, 2087
33811, 2087, 0, 2088
33812, 2088, 0, 2089
33813, 2089, 0, 2090
33814, 2090, 0, 82
*ELEMENT, type=T3D3, ELSET=Line179
33815, 82, 0, 2091
33816, 2091, 0, 2092
33817, 2092, 0, 2093
33818, 2093, 0, 2094
33819, 2094, 0, 2095
33820, 2095, 0, 2096
33821, 2096, 0, 2097
33822, 2097, 0, 2098
33823, 2098, 0, 2099
33824, 2099, 0, 2100
33825, 2100, 0, 2101
33826, 2101, 0, 81
*ELEMENT, type=T3D3, ELSET=Line180
33827, 30, 0, 2102
33828, 2102, 0, 2103
33829, 2103, 0, 2104
33830, 2104, 0, 2105
33831, 2105, 0, 83
*ELEMENT, type=T3D3, ELSET=Line181
36, 81, 0, 2106
37, 2106, 0, 2107
38, 2107, 0, 2108
39, 2108, 0, 2109
40, 2109, 0, 2110
41, 2110, 0, 2111
42, 2111, 0, 2112
43, 2112, 0, 2113
44, 2113, 0, 2114
45, 2114, 0, 2115
46, 2115, 0, 2116
47, 2116, 0, 2117
48, 2117, 0, 2118
49, 2118, 0, 2119
50, 2119, 0, 2120
51, 2120, 0, 2121
52, 2121, 0, 2122
53, 2122, 0, 2123
54, 2123, 0, 2124
55, 2124, 0, 2125
56, 2125, 0, 2126
57, 2126, 0, 2127
58, 2127, 0, 2128
59, 2128, 0, 83
*ELEMENT, type=T3D3, ELSET=Line182
33832, 32, 2133, 2129
33833, 2129, 2134, 2130
33834, 2130, 2135, 2131
33835, 2131, 2136, 2132
33836, 2132, 2137, 84
*ELEMENT, type=T3D3, ELSET=Line183
33837, 82, 0, 2138
33838, 2138, 0, 2139
33839, 2139, 0, 2140
33840, 2140, 0, 2141
33841, 2141, 0, 2142
