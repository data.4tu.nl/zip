23145, 0.54166666666667, 0.4, 0.25
23146, 0.54166666666667, 0.45, 0.25
23147, 0.54166666666667, 0.5, 0.25
23148, 0.54166666666667, 0.55, 0.25
23149, 0.54166666666667, 0.6, 0.25
23150, 0.54166666666667, 0.65, 0.25
23151, 0.54166666666667, 0.7, 0.25
23152, 0.54166666666667, 0.75, 0.25
23153, 0.54166666666667, 0.8, 0.25
23154, 0.54166666666667, 0.85, 0.25
23155, 0.54166666666667, 0.9, 0.25
23156, 0.54166666666667, 0.95, 0.25
23157, 0.54166666666667, 1, 0.25
23158, 0.54166666666667, 1.05, 0.25
23159, 0.54166666666667, 1.1, 0.25
23160, 0.54166666666667, 1.15, 0.25
23161, 0.54166666666667, 1.2, 0.25
23162, 0.54166666666667, 1.25, 0.25
23163, 0.54166666666667, 1.3, 0.25
23164, 0.54166666666667, 0.2, 0.29166666666667
23165, 0.54166666666667, 0.25, 0.29166666666667
23166, 0.54166666666667, 0.3, 0.29166666666667
23167, 0.54166666666667, 0.35, 0.29166666666667
23168, 0.54166666666667, 0.4, 0.29166666666667
23169, 0.54166666666667, 0.45, 0.29166666666667
23170, 0.54166666666667, 0.5, 0.29166666666667
23171, 0.54166666666667, 0.55, 0.29166666666667
23172, 0.54166666666667, 0.6, 0.29166666666667
23173, 0.54166666666667, 0.65, 0.29166666666667
23174, 0.54166666666667, 0.7, 0.29166666666667
23175, 0.54166666666667, 0.75, 0.29166666666667
23176, 0.54166666666667, 0.8, 0.29166666666667
23177, 0.54166666666667, 0.85, 0.29166666666667
23178, 0.54166666666667, 0.9, 0.29166666666667
23179, 0.54166666666667, 0.95, 0.29166666666667
23180, 0.54166666666667, 1, 0.29166666666667
23181, 0.54166666666667, 1.05, 0.29166666666667
23182, 0.54166666666667, 1.1, 0.29166666666667
23183, 0.54166666666667, 1.15, 0.29166666666667
23184, 0.54166666666667, 1.2, 0.29166666666667
23185, 0.54166666666667, 1.25, 0.29166666666667
23186, 0.54166666666667, 1.3, 0.29166666666667
23187, 0.54166666666667, 0.2, 0.33333333333333
23188, 0.54166666666667, 0.25, 0.33333333333333
23189, 0.54166666666667, 0.3, 0.33333333333333
23190, 0.54166666666667, 0.35, 0.33333333333333
23191, 0.54166666666667, 0.4, 0.33333333333333
23192, 0.54166666666667, 0.45, 0.33333333333333
23193, 0.54166666666667, 0.5, 0.33333333333333
23194, 0.54166666666667, 0.55, 0.33333333333333
23195, 0.54166666666667, 0.6, 0.33333333333333
23196, 0.54166666666667, 0.65, 0.33333333333333
23197, 0.54166666666667, 0.7, 0.33333333333333
23198, 0.54166666666667, 0.75, 0.33333333333333
23199, 0.54166666666667, 0.8, 0.33333333333333
23200, 0.54166666666667, 0.85, 0.33333333333333
23201, 0.54166666666667, 0.9, 0.33333333333333
23202, 0.54166666666667, 0.95, 0.33333333333333
23203, 0.54166666666667, 1, 0.33333333333333
23204, 0.54166666666667, 1.05, 0.33333333333333
23205, 0.54166666666667, 1.1, 0.33333333333333
23206, 0.54166666666667, 1.15, 0.33333333333333
23207, 0.54166666666667, 1.2, 0.33333333333333
23208, 0.54166666666667, 1.25, 0.33333333333333
23209, 0.54166666666667, 1.3, 0.33333333333333
23210, 0.54166666666667, 0.2, 0.375
23211, 0.54166666666667, 0.25, 0.375
23212, 0.54166666666667, 0.3, 0.375
23213, 0.54166666666667, 0.35, 0.375
23214, 0.54166666666667, 0.4, 0.375
23215, 0.54166666666667, 0.45, 0.375
23216, 0.54166666666667, 0.5, 0.375
23217, 0.54166666666667, 0.55, 0.375
23218, 0.54166666666667, 0.6, 0.375
23219, 0.54166666666667, 0.65, 0.375
23220, 0.54166666666667, 0.7, 0.375
23221, 0.54166666666667, 0.75, 0.375
23222, 0.54166666666667, 0.8, 0.375
23223, 0.54166666666667, 0.85, 0.375
23224, 0.54166666666667, 0.9, 0.375
23225, 0.54166666666667, 0.95, 0.375
23226, 0.54166666666667, 1, 0.375
23227, 0.54166666666667, 1.05, 0.375
23228, 0.54166666666667, 1.1, 0.375
23229, 0.54166666666667, 1.15, 0.375
23230, 0.54166666666667, 1.2, 0.375
23231, 0.54166666666667, 1.25, 0.375
23232, 0.54166666666667, 1.3, 0.375
23233, 0.54166666666667, 0.2, 0.41666666666667
23234, 0.54166666666667, 0.25, 0.41666666666667
23235, 0.54166666666667, 0.3, 0.41666666666667
23236, 0.54166666666667, 0.35, 0.41666666666667
23237, 0.54166666666667, 0.4, 0.41666666666667
23238, 0.54166666666667, 0.45, 0.41666666666667
23239, 0.54166666666667, 0.5, 0.41666666666667
23240, 0.54166666666667, 0.55, 0.41666666666667
23241, 0.54166666666667, 0.6, 0.41666666666667
23242, 0.54166666666667, 0.65, 0.41666666666667
23243, 0.54166666666667, 0.7, 0.41666666666667
23244, 0.54166666666667, 0.75, 0.41666666666667
23245, 0.54166666666667, 0.8, 0.41666666666667
23246, 0.54166666666667, 0.85, 0.41666666666667
23247, 0.54166666666667, 0.9, 0.41666666666667
23248, 0.54166666666667, 0.95, 0.41666666666667
23249, 0.54166666666667, 1, 0.41666666666667
23250, 0.54166666666667, 1.05, 0.41666666666667
23251, 0.54166666666667, 1.1, 0.41666666666667
23252, 0.54166666666667, 1.15, 0.41666666666667
23253, 0.54166666666667, 1.2, 0.41666666666667
23254, 0.54166666666667, 1.25, 0.41666666666667
23255, 0.54166666666667, 1.3, 0.41666666666667
23256, 0.54166666666667, 0.2, 0.45833333333333
23257, 0.54166666666667, 0.25, 0.45833333333333
23258, 0.54166666666667, 0.3, 0.45833333333333
23259, 0.54166666666667, 0.35, 0.45833333333333
23260, 0.54166666666667, 0.4, 0.45833333333333
23261, 0.54166666666667, 0.45, 0.45833333333333
23262, 0.54166666666667, 0.5, 0.45833333333333
23263, 0.54166666666667, 0.55, 0.45833333333333
23264, 0.54166666666667, 0.6, 0.45833333333333
23265, 0.54166666666667, 0.65, 0.45833333333333
23266, 0.54166666666667, 0.7, 0.45833333333333
23267, 0.54166666666667, 0.75, 0.45833333333333
23268, 0.54166666666667, 0.8, 0.45833333333333
23269, 0.54166666666667, 0.85, 0.45833333333333
23270, 0.54166666666667, 0.9, 0.45833333333333
23271, 0.54166666666667, 0.95, 0.45833333333333
23272, 0.54166666666667, 1, 0.45833333333333
23273, 0.54166666666667, 1.05, 0.45833333333333
23274, 0.54166666666667, 1.1, 0.45833333333333
23275, 0.54166666666667, 1.15, 0.45833333333333
23276, 0.54166666666667, 1.2, 0.45833333333333
23277, 0.54166666666667, 1.25, 0.45833333333333
23278, 0.54166666666667, 1.3, 0.45833333333333
23279, 0.58333333333333, 0.2, 0.041666666666667
23280, 0.58333333333333, 0.25, 0.041666666666667
23281, 0.58333333333333, 0.3, 0.041666666666667
23282, 0.58333333333333, 0.35, 0.041666666666667
23283, 0.58333333333333, 0.4, 0.041666666666667
23284, 0.58333333333333, 0.45, 0.041666666666667
23285, 0.58333333333333, 0.5, 0.041666666666667
23286, 0.58333333333333, 0.55, 0.041666666666667
23287, 0.58333333333333, 0.6, 0.041666666666667
23288, 0.58333333333333, 0.65, 0.041666666666667
23289, 0.58333333333333, 0.7, 0.041666666666667
23290, 0.58333333333333, 0.75, 0.041666666666667
23291, 0.58333333333333, 0.8, 0.041666666666667
23292, 0.58333333333333, 0.85, 0.041666666666667
23293, 0.58333333333333, 0.9, 0.041666666666667
23294, 0.58333333333333, 0.95, 0.041666666666667
23295, 0.58333333333333, 1, 0.041666666666667
23296, 0.58333333333333, 1.05, 0.041666666666667
23297, 0.58333333333333, 1.1, 0.041666666666667
23298, 0.58333333333333, 1.15, 0.041666666666667
23299, 0.58333333333333, 1.2, 0.041666666666667
23300, 0.58333333333333, 1.25, 0.041666666666667
23301, 0.58333333333333, 1.3, 0.041666666666667
23302, 0.58333333333333, 0.2, 0.083333333333333
23303, 0.58333333333333, 0.25, 0.083333333333333
23304, 0.58333333333333, 0.3, 0.083333333333333
23305, 0.58333333333333, 0.35, 0.083333333333333
23306, 0.58333333333333, 0.4, 0.083333333333333
23307, 0.58333333333333, 0.45, 0.083333333333333
23308, 0.58333333333333, 0.5, 0.083333333333333
23309, 0.58333333333333, 0.55, 0.083333333333333
23310, 0.58333333333333, 0.6, 0.083333333333333
23311, 0.58333333333333, 0.65, 0.083333333333333
23312, 0.58333333333333, 0.7, 0.083333333333333
23313, 0.58333333333333, 0.75, 0.083333333333333
23314, 0.58333333333333, 0.8, 0.083333333333333
23315, 0.58333333333333, 0.85, 0.083333333333333
23316, 0.58333333333333, 0.9, 0.083333333333333
23317, 0.58333333333333, 0.95, 0.083333333333333
23318, 0.58333333333333, 1, 0.083333333333333
23319, 0.58333333333333, 1.05, 0.083333333333333
23320, 0.58333333333333, 1.1, 0.083333333333333
23321, 0.58333333333333, 1.15, 0.083333333333333
23322, 0.58333333333333, 1.2, 0.083333333333333
23323, 0.58333333333333, 1.25, 0.083333333333333
23324, 0.58333333333333, 1.3, 0.083333333333333
23325, 0.58333333333333, 0.2, 0.125
23326, 0.58333333333333, 0.25, 0.125
23327, 0.58333333333333, 0.3, 0.125
23328, 0.58333333333333, 0.35, 0.125
23329, 0.58333333333333, 0.4, 0.125
23330, 0.58333333333333, 0.45, 0.125
23331, 0.58333333333333, 0.5, 0.125
23332, 0.58333333333333, 0.55, 0.125
23333, 0.58333333333333, 0.6, 0.125
23334, 0.58333333333333, 0.65, 0.125
23335, 0.58333333333333, 0.7, 0.125
23336, 0.58333333333333, 0.75, 0.125
23337, 0.58333333333333, 0.8, 0.125
23338, 0.58333333333333, 0.85, 0.125
23339, 0.58333333333333, 0.9, 0.125
23340, 0.58333333333333, 0.95, 0.125
23341, 0.58333333333333, 1, 0.125
23342, 0.58333333333333, 1.05, 0.125
23343, 0.58333333333333, 1.1, 0.125
23344, 0.58333333333333, 1.15, 0.125
23345, 0.58333333333333, 1.2, 0.125
23346, 0.58333333333333, 1.25, 0.125
23347, 0.58333333333333, 1.3, 0.125
23348, 0.58333333333333, 0.2, 0.16666666666667
23349, 0.58333333333333, 0.25, 0.16666666666667
23350, 0.58333333333333, 0.3, 0.16666666666667
23351, 0.58333333333333, 0.35, 0.16666666666667
23352, 0.58333333333333, 0.4, 0.16666666666667
23353, 0.58333333333333, 0.45, 0.16666666666667
23354, 0.58333333333333, 0.5, 0.16666666666667
23355, 0.58333333333333, 0.55, 0.16666666666667
23356, 0.58333333333333, 0.6, 0.16666666666667
23357, 0.58333333333333, 0.65, 0.16666666666667
23358, 0.58333333333333, 0.7, 0.16666666666667
23359, 0.58333333333333, 0.75, 0.16666666666667
23360, 0.58333333333333, 0.8, 0.16666666666667
23361, 0.58333333333333, 0.85, 0.16666666666667
23362, 0.58333333333333, 0.9, 0.16666666666667
23363, 0.58333333333333, 0.95, 0.16666666666667
23364, 0.58333333333333, 1, 0.16666666666667
23365, 0.58333333333333, 1.05, 0.16666666666667
23366, 0.58333333333333, 1.1, 0.16666666666667
23367, 0.58333333333333, 1.15, 0.16666666666667
23368, 0.58333333333333, 1.2, 0.16666666666667
23369, 0.58333333333333, 1.25, 0.16666666666667
23370, 0.58333333333333, 1.3, 0.16666666666667
23371, 0.58333333333333, 0.2, 0.20833333333333
23372, 0.58333333333333, 0.25, 0.20833333333333
23373, 0.58333333333333, 0.3, 0.20833333333333
23374, 0.58333333333333, 0.35, 0.20833333333333
23375, 0.58333333333333, 0.4, 0.20833333333333
23376, 0.58333333333333, 0.45, 0.20833333333333
23377, 0.58333333333333, 0.5, 0.20833333333333
23378, 0.58333333333333, 0.55, 0.20833333333333
23379, 0.58333333333333, 0.6, 0.20833333333333
23380, 0.58333333333333, 0.65, 0.20833333333333
23381, 0.58333333333333, 0.7, 0.20833333333333
23382, 0.58333333333333, 0.75, 0.20833333333333
23383, 0.58333333333333, 0.8, 0.20833333333333
23384, 0.58333333333333, 0.85, 0.20833333333333
23385, 0.58333333333333, 0.9, 0.20833333333333
23386, 0.58333333333333, 0.95, 0.20833333333333
23387, 0.58333333333333, 1, 0.20833333333333
23388, 0.58333333333333, 1.05, 0.20833333333333
23389, 0.58333333333333, 1.1, 0.20833333333333
23390, 0.58333333333333, 1.15, 0.20833333333333
23391, 0.58333333333333, 1.2, 0.20833333333333
23392, 0.58333333333333, 1.25, 0.20833333333333
23393, 0.58333333333333, 1.3, 0.20833333333333
23394, 0.58333333333333, 0.2, 0.25
23395, 0.58333333333333, 0.25, 0.25
23396, 0.58333333333333, 0.3, 0.25
23397, 0.58333333333333, 0.35, 0.25
23398, 0.58333333333333, 0.4, 0.25
23399, 0.58333333333333, 0.45, 0.25
23400, 0.58333333333333, 0.5, 0.25
23401, 0.58333333333333, 0.55, 0.25
23402, 0.58333333333333, 0.6, 0.25
23403, 0.58333333333333, 0.65, 0.25
23404, 0.58333333333333, 0.7, 0.25
23405, 0.58333333333333, 0.75, 0.25
23406, 0.58333333333333, 0.8, 0.25
23407, 0.58333333333333, 0.85, 0.25
23408, 0.58333333333333, 0.9, 0.25
23409, 0.58333333333333, 0.95, 0.25
23410, 0.58333333333333, 1, 0.25
23411, 0.58333333333333, 1.05, 0.25
23412, 0.58333333333333, 1.1, 0.25
23413, 0.58333333333333, 1.15, 0.25
23414, 0.58333333333333, 1.2, 0.25
23415, 0.58333333333333, 1.25, 0.25
23416, 0.58333333333333, 1.3, 0.25
23417, 0.58333333333333, 0.2, 0.29166666666667
23418, 0.58333333333333, 0.25, 0.29166666666667
23419, 0.58333333333333, 0.3, 0.29166666666667
23420, 0.58333333333333, 0.35, 0.29166666666667
23421, 0.58333333333333, 0.4, 0.29166666666667
23422, 0.58333333333333, 0.45, 0.29166666666667
23423, 0.58333333333333, 0.5, 0.29166666666667
23424, 0.58333333333333, 0.55, 0.29166666666667
23425, 0.58333333333333, 0.6, 0.29166666666667
23426, 0.58333333333333, 0.65, 0.29166666666667
23427, 0.58333333333333, 0.7, 0.29166666666667
23428, 0.58333333333333, 0.75, 0.29166666666667
23429, 0.58333333333333, 0.8, 0.29166666666667
23430, 0.58333333333333, 0.85, 0.29166666666667
23431, 0.58333333333333, 0.9, 0.29166666666667
23432, 0.58333333333333, 0.95, 0.29166666666667
23433, 0.58333333333333, 1, 0.29166666666667
23434, 0.58333333333333, 1.05, 0.29166666666667
23435, 0.58333333333333, 1.1, 0.29166666666667
23436, 0.58333333333333, 1.15, 0.29166666666667
23437, 0.58333333333333, 1.2, 0.29166666666667
23438, 0.58333333333333, 1.25, 0.29166666666667
23439, 0.58333333333333, 1.3, 0.29166666666667
23440, 0.58333333333333, 0.2, 0.33333333333333
23441, 0.58333333333333, 0.25, 0.33333333333333
23442, 0.58333333333333, 0.3, 0.33333333333333
23443, 0.58333333333333, 0.35, 0.33333333333333
23444, 0.58333333333333, 0.4, 0.33333333333333
23445, 0.58333333333333, 0.45, 0.33333333333333
23446, 0.58333333333333, 0.5, 0.33333333333333
23447, 0.58333333333333, 0.55, 0.33333333333333
23448, 0.58333333333333, 0.6, 0.33333333333333
23449, 0.58333333333333, 0.65, 0.33333333333333
23450, 0.58333333333333, 0.7, 0.33333333333333
23451, 0.58333333333333, 0.75, 0.33333333333333
23452, 0.58333333333333, 0.8, 0.33333333333333
23453, 0.58333333333333, 0.85, 0.33333333333333
23454, 0.58333333333333, 0.9, 0.33333333333333
23455, 0.58333333333333, 0.95, 0.33333333333333
23456, 0.58333333333333, 1, 0.33333333333333
23457, 0.58333333333333, 1.05, 0.33333333333333
23458, 0.58333333333333, 1.1, 0.33333333333333
23459, 0.58333333333333, 1.15, 0.33333333333333
23460, 0.58333333333333, 1.2, 0.33333333333333
23461, 0.58333333333333, 1.25, 0.33333333333333
23462, 0.58333333333333, 1.3, 0.33333333333333
23463, 0.58333333333333, 0.2, 0.375
23464, 0.58333333333333, 0.25, 0.375
23465, 0.58333333333333, 0.3, 0.375
23466, 0.58333333333333, 0.35, 0.375
23467, 0.58333333333333, 0.4, 0.375
23468, 0.58333333333333, 0.45, 0.375
23469, 0.58333333333333, 0.5, 0.375
23470, 0.58333333333333, 0.55, 0.375
23471, 0.58333333333333, 0.6, 0.375
23472, 0.58333333333333, 0.65, 0.375
23473, 0.58333333333333, 0.7, 0.375
23474, 0.58333333333333, 0.75, 0.375
23475, 0.58333333333333, 0.8, 0.375
23476, 0.58333333333333, 0.85, 0.375
23477, 0.58333333333333, 0.9, 0.375
23478, 0.58333333333333, 0.95, 0.375
23479, 0.58333333333333, 1, 0.375
23480, 0.58333333333333, 1.05, 0.375
23481, 0.58333333333333, 1.1, 0.375
23482, 0.58333333333333, 1.15, 0.375
23483, 0.58333333333333, 1.2, 0.375
23484, 0.58333333333333, 1.25, 0.375
23485, 0.58333333333333, 1.3, 0.375
23486, 0.58333333333333, 0.2, 0.41666666666667
23487, 0.58333333333333, 0.25, 0.41666666666667
23488, 0.58333333333333, 0.3, 0.41666666666667
23489, 0.58333333333333, 0.35, 0.41666666666667
23490, 0.58333333333333, 0.4, 0.41666666666667
23491, 0.58333333333333, 0.45, 0.41666666666667
23492, 0.58333333333333, 0.5, 0.41666666666667
23493, 0.58333333333333, 0.55, 0.41666666666667
23494, 0.58333333333333, 0.6, 0.41666666666667
23495, 0.58333333333333, 0.65, 0.41666666666667
23496, 0.58333333333333, 0.7, 0.41666666666667
23497, 0.58333333333333, 0.75, 0.41666666666667
23498, 0.58333333333333, 0.8, 0.41666666666667
23499, 0.58333333333333, 0.85, 0.41666666666667
23500, 0.58333333333333, 0.9, 0.41666666666667
23501, 0.58333333333333, 0.95, 0.41666666666667
23502, 0.58333333333333, 1, 0.41666666666667
23503, 0.58333333333333, 1.05, 0.41666666666667
23504, 0.58333333333333, 1.1, 0.41666666666667
23505, 0.58333333333333, 1.15, 0.41666666666667
23506, 0.58333333333333, 1.2, 0.41666666666667
23507, 0.58333333333333, 1.25, 0.41666666666667
23508, 0.58333333333333, 1.3, 0.41666666666667
23509, 0.58333333333333, 0.2, 0.45833333333333
23510, 0.58333333333333, 0.25, 0.45833333333333
23511, 0.58333333333333, 0.3, 0.45833333333333
23512, 0.58333333333333, 0.35, 0.45833333333333
23513, 0.58333333333333, 0.4, 0.45833333333333
23514, 0.58333333333333, 0.45, 0.45833333333333
23515, 0.58333333333333, 0.5, 0.45833333333333
23516, 0.58333333333333, 0.55, 0.45833333333333
23517, 0.58333333333333, 0.6, 0.45833333333333
23518, 0.58333333333333, 0.65, 0.45833333333333
23519, 0.58333333333333, 0.7, 0.45833333333333
23520, 0.58333333333333, 0.75, 0.45833333333333
23521, 0.58333333333333, 0.8, 0.45833333333333
23522, 0.58333333333333, 0.85, 0.45833333333333
23523, 0.58333333333333, 0.9, 0.45833333333333
23524, 0.58333333333333, 0.95, 0.45833333333333
23525, 0.58333333333333, 1, 0.45833333333333
23526, 0.58333333333333, 1.05, 0.45833333333333
23527, 0.58333333333333, 1.1, 0.45833333333333
23528, 0.58333333333333, 1.15, 0.45833333333333
23529, 0.58333333333333, 1.2, 0.45833333333333
23530, 0.58333333333333, 1.25, 0.45833333333333
23531, 0.58333333333333, 1.3, 0.45833333333333
23532, 0.625, 0.2, 0.041666666666667
23533, 0.625, 0.25, 0.041666666666667
23534, 0.625, 0.3, 0.041666666666667
23535, 0.625, 0.35, 0.041666666666667
23536, 0.625, 0.4, 0.041666666666667
23537, 0.625, 0.45, 0.041666666666667
23538, 0.625, 0.5, 0.041666666666667
23539, 0.625, 0.55, 0.041666666666667
23540, 0.625, 0.6, 0.041666666666667
23541, 0.625, 0.65, 0.041666666666667
23542, 0.625, 0.7, 0.041666666666667
23543, 0.625, 0.75, 0.041666666666667
23544, 0.625, 0.8, 0.041666666666667
23545, 0.625, 0.85, 0.041666666666667
23546, 0.625, 0.9, 0.041666666666667
23547, 0.625, 0.95, 0.041666666666667
23548, 0.625, 1, 0.041666666666667
23549, 0.625, 1.05, 0.041666666666667
23550, 0.625, 1.1, 0.041666666666667
23551, 0.625, 1.15, 0.041666666666667
23552, 0.625, 1.2, 0.041666666666667
23553, 0.625, 1.25, 0.041666666666667
23554, 0.625, 1.3, 0.041666666666667
23555, 0.625, 0.2, 0.083333333333333
23556, 0.625, 0.25, 0.083333333333333
23557, 0.625, 0.3, 0.083333333333333
23558, 0.625, 0.35, 0.083333333333333
23559, 0.625, 0.4, 0.083333333333333
23560, 0.625, 0.45, 0.083333333333333
23561, 0.625, 0.5, 0.083333333333333
23562, 0.625, 0.55, 0.083333333333333
23563, 0.625, 0.6, 0.083333333333333
23564, 0.625, 0.65, 0.083333333333333
23565, 0.625, 0.7, 0.083333333333333
23566, 0.625, 0.75, 0.083333333333333
23567, 0.625, 0.8, 0.083333333333333
23568, 0.625, 0.85, 0.083333333333333
23569, 0.625, 0.9, 0.083333333333333
23570, 0.625, 0.95, 0.083333333333333
23571, 0.625, 1, 0.083333333333333
23572, 0.625, 1.05, 0.083333333333333
23573, 0.625, 1.1, 0.083333333333333
23574, 0.625, 1.15, 0.083333333333333
23575, 0.625, 1.2, 0.083333333333333
23576, 0.625, 1.25, 0.083333333333333
23577, 0.625, 1.3, 0.083333333333333
23578, 0.625, 0.2, 0.125
23579, 0.625, 0.25, 0.125
23580, 0.625, 0.3, 0.125
23581, 0.625, 0.35, 0.125
23582, 0.625, 0.4, 0.125
23583, 0.625, 0.45, 0.125
23584, 0.625, 0.5, 0.125
23585, 0.625, 0.55, 0.125
23586, 0.625, 0.6, 0.125
23587, 0.625, 0.65, 0.125
23588, 0.625, 0.7, 0.125
23589, 0.625, 0.75, 0.125
23590, 0.625, 0.8, 0.125
23591, 0.625, 0.85, 0.125
23592, 0.625, 0.9, 0.125
23593, 0.625, 0.95, 0.125
23594, 0.625, 1, 0.125
23595, 0.625, 1.05, 0.125
23596, 0.625, 1.1, 0.125
23597, 0.625, 1.15, 0.125
23598, 0.625, 1.2, 0.125
23599, 0.625, 1.25, 0.125
23600, 0.625, 1.3, 0.125
23601, 0.625, 0.2, 0.16666666666667
23602, 0.625, 0.25, 0.16666666666667
23603, 0.625, 0.3, 0.16666666666667
23604, 0.625, 0.35, 0.16666666666667
23605, 0.625, 0.4, 0.16666666666667
23606, 0.625, 0.45, 0.16666666666667
23607, 0.625, 0.5, 0.16666666666667
23608, 0.625, 0.55, 0.16666666666667
23609, 0.625, 0.6, 0.16666666666667
23610, 0.625, 0.65, 0.16666666666667
23611, 0.625, 0.7, 0.16666666666667
23612, 0.625, 0.75, 0.16666666666667
23613, 0.625, 0.8, 0.16666666666667
23614, 0.625, 0.85, 0.16666666666667
23615, 0.625, 0.9, 0.16666666666667
23616, 0.625, 0.95, 0.16666666666667
23617, 0.625, 1, 0.16666666666667
23618, 0.625, 1.05, 0.16666666666667
23619, 0.625, 1.1, 0.16666666666667
23620, 0.625, 1.15, 0.16666666666667
23621, 0.625, 1.2, 0.16666666666667
23622, 0.625, 1.25, 0.16666666666667
23623, 0.625, 1.3, 0.16666666666667
23624, 0.625, 0.2, 0.20833333333333
23625, 0.625, 0.25, 0.20833333333333
23626, 0.625, 0.3, 0.20833333333333
23627, 0.625, 0.35, 0.20833333333333
23628, 0.625, 0.4, 0.20833333333333
23629, 0.625, 0.45, 0.20833333333333
23630, 0.625, 0.5, 0.20833333333333
23631, 0.625, 0.55, 0.20833333333333
23632, 0.625, 0.6, 0.20833333333333
23633, 0.625, 0.65, 0.20833333333333
23634, 0.625, 0.7, 0.20833333333333
23635, 0.625, 0.75, 0.20833333333333
23636, 0.625, 0.8, 0.20833333333333
23637, 0.625, 0.85, 0.20833333333333
23638, 0.625, 0.9, 0.20833333333333
23639, 0.625, 0.95, 0.20833333333333
23640, 0.625, 1, 0.20833333333333
23641, 0.625, 1.05, 0.20833333333333
23642, 0.625, 1.1, 0.20833333333333
23643, 0.625, 1.15, 0.20833333333333
23644, 0.625, 1.2, 0.20833333333333
23645, 0.625, 1.25, 0.20833333333333
23646, 0.625, 1.3, 0.20833333333333
23647, 0.625, 0.2, 0.25
23648, 0.625, 0.25, 0.25
23649, 0.625, 0.3, 0.25
23650, 0.625, 0.35, 0.25
23651, 0.625, 0.4, 0.25
23652, 0.625, 0.45, 0.25
23653, 0.625, 0.5, 0.25
23654, 0.625, 0.55, 0.25
23655, 0.625, 0.6, 0.25
23656, 0.625, 0.65, 0.25
23657, 0.625, 0.7, 0.25
23658, 0.625, 0.75, 0.25
23659, 0.625, 0.8, 0.25
23660, 0.625, 0.85, 0.25
23661, 0.625, 0.9, 0.25
23662, 0.625, 0.95, 0.25
23663, 0.625, 1, 0.25
23664, 0.625, 1.05, 0.25
23665, 0.625, 1.1, 0.25
23666, 0.625, 1.15, 0.25
23667, 0.625, 1.2, 0.25
23668, 0.625, 1.25, 0.25
23669, 0.625, 1.3, 0.25
23670, 0.625, 0.2, 0.29166666666667
23671, 0.625, 0.25, 0.29166666666667
23672, 0.625, 0.3, 0.29166666666667
23673, 0.625, 0.35, 0.29166666666667
23674, 0.625, 0.4, 0.29166666666667
23675, 0.625, 0.45, 0.29166666666667
23676, 0.625, 0.5, 0.29166666666667
23677, 0.625, 0.55, 0.29166666666667
23678, 0.625, 0.6, 0.29166666666667
23679, 0.625, 0.65, 0.29166666666667
23680, 0.625, 0.7, 0.29166666666667
23681, 0.625, 0.75, 0.29166666666667
23682, 0.625, 0.8, 0.29166666666667
23683, 0.625, 0.85, 0.29166666666667
23684, 0.625, 0.9, 0.29166666666667
23685, 0.625, 0.95, 0.29166666666667
23686, 0.625, 1, 0.29166666666667
23687, 0.625, 1.05, 0.29166666666667
23688, 0.625, 1.1, 0.29166666666667
23689, 0.625, 1.15, 0.29166666666667
23690, 0.625, 1.2, 0.29166666666667
23691, 0.625, 1.25, 0.29166666666667
23692, 0.625, 1.3, 0.29166666666667
23693, 0.625, 0.2, 0.33333333333333
23694, 0.625, 0.25, 0.33333333333333
23695, 0.625, 0.3, 0.33333333333333
23696, 0.625, 0.35, 0.33333333333333
23697, 0.625, 0.4, 0.33333333333333
23698, 0.625, 0.45, 0.33333333333333
23699, 0.625, 0.5, 0.33333333333333
23700, 0.625, 0.55, 0.33333333333333
23701, 0.625, 0.6, 0.33333333333333
23702, 0.625, 0.65, 0.33333333333333
23703, 0.625, 0.7, 0.33333333333333
23704, 0.625, 0.75, 0.33333333333333
23705, 0.625, 0.8, 0.33333333333333
23706, 0.625, 0.85, 0.33333333333333
23707, 0.625, 0.9, 0.33333333333333
23708, 0.625, 0.95, 0.33333333333333
23709, 0.625, 1, 0.33333333333333
23710, 0.625, 1.05, 0.33333333333333
23711, 0.625, 1.1, 0.33333333333333
23712, 0.625, 1.15, 0.33333333333333
23713, 0.625, 1.2, 0.33333333333333
23714, 0.625, 1.25, 0.33333333333333
23715, 0.625, 1.3, 0.33333333333333
23716, 0.625, 0.2, 0.375
23717, 0.625, 0.25, 0.375
23718, 0.625, 0.3, 0.375
23719, 0.625, 0.35, 0.375
23720, 0.625, 0.4, 0.375
23721, 0.625, 0.45, 0.375
23722, 0.625, 0.5, 0.375
23723, 0.625, 0.55, 0.375
23724, 0.625, 0.6, 0.375
23725, 0.625, 0.65, 0.375
23726, 0.625, 0.7, 0.375
23727, 0.625, 0.75, 0.375
23728, 0.625, 0.8, 0.375
23729, 0.625, 0.85, 0.375
23730, 0.625, 0.9, 0.375
23731, 0.625, 0.95, 0.375
23732, 0.625, 1, 0.375
23733, 0.625, 1.05, 0.375
23734, 0.625, 1.1, 0.375
23735, 0.625, 1.15, 0.375
23736, 0.625, 1.2, 0.375
23737, 0.625, 1.25, 0.375
23738, 0.625, 1.3, 0.375
23739, 0.625, 0.2, 0.41666666666667
23740, 0.625, 0.25, 0.41666666666667
23741, 0.625, 0.3, 0.41666666666667
23742, 0.625, 0.35, 0.41666666666667
23743, 0.625, 0.4, 0.41666666666667
23744, 0.625, 0.45, 0.41666666666667
23745, 0.625, 0.5, 0.41666666666667
23746, 0.625, 0.55, 0.41666666666667
23747, 0.625, 0.6, 0.41666666666667
23748, 0.625, 0.65, 0.41666666666667
23749, 0.625, 0.7, 0.41666666666667
23750, 0.625, 0.75, 0.41666666666667
23751, 0.625, 0.8, 0.41666666666667
23752, 0.625, 0.85, 0.41666666666667
23753, 0.625, 0.9, 0.41666666666667
23754, 0.625, 0.95, 0.41666666666667
23755, 0.625, 1, 0.41666666666667
23756, 0.625, 1.05, 0.41666666666667
23757, 0.625, 1.1, 0.41666666666667
23758, 0.625, 1.15, 0.41666666666667
23759, 0.625, 1.2, 0.41666666666667
23760, 0.625, 1.25, 0.41666666666667
23761, 0.625, 1.3, 0.41666666666667
23762, 0.625, 0.2, 0.45833333333333
23763, 0.625, 0.25, 0.45833333333333
23764, 0.625, 0.3, 0.45833333333333
23765, 0.625, 0.35, 0.45833333333333
23766, 0.625, 0.4, 0.45833333333333
23767, 0.625, 0.45, 0.45833333333333
23768, 0.625, 0.5, 0.45833333333333
23769, 0.625, 0.55, 0.45833333333333
23770, 0.625, 0.6, 0.45833333333333
23771, 0.625, 0.65, 0.45833333333333
23772, 0.625, 0.7, 0.45833333333333
23773, 0.625, 0.75, 0.45833333333333
23774, 0.625, 0.8, 0.45833333333333
23775, 0.625, 0.85, 0.45833333333333
23776, 0.625, 0.9, 0.45833333333333
23777, 0.625, 0.95, 0.45833333333333
23778, 0.625, 1, 0.45833333333333
23779, 0.625, 1.05, 0.45833333333333
23780, 0.625, 1.1, 0.45833333333333
23781, 0.625, 1.15, 0.45833333333333
23782, 0.625, 1.2, 0.45833333333333
23783, 0.625, 1.25, 0.45833333333333
23784, 0.625, 1.3, 0.45833333333333
23785, 0.66666666666667, 0.2, 0.041666666666667
23786, 0.66666666666667, 0.25, 0.041666666666667
23787, 0.66666666666667, 0.3, 0.041666666666667
23788, 0.66666666666667, 0.35, 0.041666666666667
23789, 0.66666666666667, 0.4, 0.041666666666667
23790, 0.66666666666667, 0.45, 0.041666666666667
23791, 0.66666666666667, 0.5, 0.041666666666667
23792, 0.66666666666667, 0.55, 0.041666666666667
23793, 0.66666666666667, 0.6, 0.041666666666667
23794, 0.66666666666667, 0.65, 0.041666666666667
23795, 0.66666666666667, 0.7, 0.041666666666667
23796, 0.66666666666667, 0.75, 0.041666666666667
23797, 0.66666666666667, 0.8, 0.041666666666667
23798, 0.66666666666667, 0.85, 0.041666666666667
23799, 0.66666666666667, 0.9, 0.041666666666667
23800, 0.66666666666667, 0.95, 0.041666666666667
23801, 0.66666666666667, 1, 0.041666666666667
23802, 0.66666666666667, 1.05, 0.041666666666667
23803, 0.66666666666667, 1.1, 0.041666666666667
23804, 0.66666666666667, 1.15, 0.041666666666667
23805, 0.66666666666667, 1.2, 0.041666666666667
23806, 0.66666666666667, 1.25, 0.041666666666667
23807, 0.66666666666667, 1.3, 0.041666666666667
23808, 0.66666666666667, 0.2, 0.083333333333333
23809, 0.66666666666667, 0.25, 0.083333333333333
23810, 0.66666666666667, 0.3, 0.083333333333333
23811, 0.66666666666667, 0.35, 0.083333333333333
23812, 0.66666666666667, 0.4, 0.083333333333333
23813, 0.66666666666667, 0.45, 0.083333333333333
23814, 0.66666666666667, 0.5, 0.083333333333333
23815, 0.66666666666667, 0.55, 0.083333333333333
23816, 0.66666666666667, 0.6, 0.083333333333333
23817, 0.66666666666667, 0.65, 0.083333333333333
23818, 0.66666666666667, 0.7, 0.083333333333333
23819, 0.66666666666667, 0.75, 0.083333333333333
23820, 0.66666666666667, 0.8, 0.083333333333333
23821, 0.66666666666667, 0.85, 0.083333333333333
23822, 0.66666666666667, 0.9, 0.083333333333333
23823, 0.66666666666667, 0.95, 0.083333333333333
23824, 0.66666666666667, 1, 0.083333333333333
23825, 0.66666666666667, 1.05, 0.083333333333333
23826, 0.66666666666667, 1.1, 0.083333333333333
23827, 0.66666666666667, 1.15, 0.083333333333333
23828, 0.66666666666667, 1.2, 0.083333333333333
23829, 0.66666666666667, 1.25, 0.083333333333333
23830, 0.66666666666667, 1.3, 0.083333333333333
23831, 0.66666666666667, 0.2, 0.125
23832, 0.66666666666667, 0.25, 0.125
23833, 0.66666666666667, 0.3, 0.125
23834, 0.66666666666667, 0.35, 0.125
23835, 0.66666666666667, 0.4, 0.125
23836, 0.66666666666667, 0.45, 0.125
23837, 0.66666666666667, 0.5, 0.125
23838, 0.66666666666667, 0.55, 0.125
23839, 0.66666666666667, 0.6, 0.125
23840, 0.66666666666667, 0.65, 0.125
23841, 0.66666666666667, 0.7, 0.125
23842, 0.66666666666667, 0.75, 0.125
23843, 0.66666666666667, 0.8, 0.125
23844, 0.66666666666667, 0.85, 0.125
23845, 0.66666666666667, 0.9, 0.125
23846, 0.66666666666667, 0.95, 0.125
23847, 0.66666666666667, 1, 0.125
23848, 0.66666666666667, 1.05, 0.125
23849, 0.66666666666667, 1.1, 0.125
23850, 0.66666666666667, 1.15, 0.125
23851, 0.66666666666667, 1.2, 0.125
23852, 0.66666666666667, 1.25, 0.125
23853, 0.66666666666667, 1.3, 0.125
23854, 0.66666666666667, 0.2, 0.16666666666667
23855, 0.66666666666667, 0.25, 0.16666666666667
23856, 0.66666666666667, 0.3, 0.16666666666667
23857, 0.66666666666667, 0.35, 0.16666666666667
23858, 0.66666666666667, 0.4, 0.16666666666667
23859, 0.66666666666667, 0.45, 0.16666666666667
23860, 0.66666666666667, 0.5, 0.16666666666667
23861, 0.66666666666667, 0.55, 0.16666666666667
23862, 0.66666666666667, 0.6, 0.16666666666667
23863, 0.66666666666667, 0.65, 0.16666666666667
23864, 0.66666666666667, 0.7, 0.16666666666667
23865, 0.66666666666667, 0.75, 0.16666666666667
23866, 0.66666666666667, 0.8, 0.16666666666667
23867, 0.66666666666667, 0.85, 0.16666666666667
23868, 0.66666666666667, 0.9, 0.16666666666667
23869, 0.66666666666667, 0.95, 0.16666666666667
23870, 0.66666666666667, 1, 0.16666666666667
23871, 0.66666666666667, 1.05, 0.16666666666667
23872, 0.66666666666667, 1.1, 0.16666666666667
23873, 0.66666666666667, 1.15, 0.16666666666667
23874, 0.66666666666667, 1.2, 0.16666666666667
23875, 0.66666666666667, 1.25, 0.16666666666667
23876, 0.66666666666667, 1.3, 0.16666666666667
23877, 0.66666666666667, 0.2, 0.20833333333333
23878, 0.66666666666667, 0.25, 0.20833333333333
23879, 0.66666666666667, 0.3, 0.20833333333333
23880, 0.66666666666667, 0.35, 0.20833333333333
23881, 0.66666666666667, 0.4, 0.20833333333333
23882, 0.66666666666667, 0.45, 0.20833333333333
23883, 0.66666666666667, 0.5, 0.20833333333333
23884, 0.66666666666667, 0.55, 0.20833333333333
23885, 0.66666666666667, 0.6, 0.20833333333333
23886, 0.66666666666667, 0.65, 0.20833333333333
23887, 0.66666666666667, 0.7, 0.20833333333333
23888, 0.66666666666667, 0.75, 0.20833333333333
23889, 0.66666666666667, 0.8, 0.20833333333333
23890, 0.66666666666667, 0.85, 0.20833333333333
23891, 0.66666666666667, 0.9, 0.20833333333333
23892, 0.66666666666667, 0.95, 0.20833333333333
23893, 0.66666666666667, 1, 0.20833333333333
23894, 0.66666666666667, 1.05, 0.20833333333333
23895, 0.66666666666667, 1.1, 0.20833333333333
23896, 0.66666666666667, 1.15, 0.20833333333333
23897, 0.66666666666667, 1.2, 0.20833333333333
23898, 0.66666666666667, 1.25, 0.20833333333333
23899, 0.66666666666667, 1.3, 0.20833333333333
23900, 0.66666666666667, 0.2, 0.25
23901, 0.66666666666667, 0.25, 0.25
23902, 0.66666666666667, 0.3, 0.25
23903, 0.66666666666667, 0.35, 0.25
23904, 0.66666666666667, 0.4, 0.25
23905, 0.66666666666667, 0.45, 0.25
23906, 0.66666666666667, 0.5, 0.25
23907, 0.66666666666667, 0.55, 0.25
23908, 0.66666666666667, 0.6, 0.25
23909, 0.66666666666667, 0.65, 0.25
23910, 0.66666666666667, 0.7, 0.25
23911, 0.66666666666667, 0.75, 0.25
23912, 0.66666666666667, 0.8, 0.25
23913, 0.66666666666667, 0.85, 0.25
23914, 0.66666666666667, 0.9, 0.25
23915, 0.66666666666667, 0.95, 0.25
23916, 0.66666666666667, 1, 0.25
23917, 0.66666666666667, 1.05, 0.25
23918, 0.66666666666667, 1.1, 0.25
23919, 0.66666666666667, 1.15, 0.25
23920, 0.66666666666667, 1.2, 0.25
23921, 0.66666666666667, 1.25, 0.25
23922, 0.66666666666667, 1.3, 0.25
23923, 0.66666666666667, 0.2, 0.29166666666667
23924, 0.66666666666667, 0.25, 0.29166666666667
23925, 0.66666666666667, 0.3, 0.29166666666667
23926, 0.66666666666667, 0.35, 0.29166666666667
23927, 0.66666666666667, 0.4, 0.29166666666667
23928, 0.66666666666667, 0.45, 0.29166666666667
23929, 0.66666666666667, 0.5, 0.29166666666667
23930, 0.66666666666667, 0.55, 0.29166666666667
23931, 0.66666666666667, 0.6, 0.29166666666667
23932, 0.66666666666667, 0.65, 0.29166666666667
23933, 0.66666666666667, 0.7, 0.29166666666667
23934, 0.66666666666667, 0.75, 0.29166666666667
23935, 0.66666666666667, 0.8, 0.29166666666667
23936, 0.66666666666667, 0.85, 0.29166666666667
23937, 0.66666666666667, 0.9, 0.29166666666667
23938, 0.66666666666667, 0.95, 0.29166666666667
23939, 0.66666666666667, 1, 0.29166666666667
23940, 0.66666666666667, 1.05, 0.29166666666667
23941, 0.66666666666667, 1.1, 0.29166666666667
23942, 0.66666666666667, 1.15, 0.29166666666667
23943, 0.66666666666667, 1.2, 0.29166666666667
23944, 0.66666666666667, 1.25, 0.29166666666667
23945, 0.66666666666667, 1.3, 0.29166666666667
23946, 0.66666666666667, 0.2, 0.33333333333333
23947, 0.66666666666667, 0.25, 0.33333333333333
23948, 0.66666666666667, 0.3, 0.33333333333333
23949, 0.66666666666667, 0.35, 0.33333333333333
23950, 0.66666666666667, 0.4, 0.33333333333333
23951, 0.66666666666667, 0.45, 0.33333333333333
23952, 0.66666666666667, 0.5, 0.33333333333333
23953, 0.66666666666667, 0.55, 0.33333333333333
23954, 0.66666666666667, 0.6, 0.33333333333333
23955, 0.66666666666667, 0.65, 0.33333333333333
23956, 0.66666666666667, 0.7, 0.33333333333333
23957, 0.66666666666667, 0.75, 0.33333333333333
23958, 0.66666666666667, 0.8, 0.33333333333333
23959, 0.66666666666667, 0.85, 0.33333333333333
23960, 0.66666666666667, 0.9, 0.33333333333333
23961, 0.66666666666667, 0.95, 0.33333333333333
23962, 0.66666666666667, 1, 0.33333333333333
23963, 0.66666666666667, 1.05, 0.33333333333333
23964, 0.66666666666667, 1.1, 0.33333333333333
23965, 0.66666666666667, 1.15, 0.33333333333333
23966, 0.66666666666667, 1.2, 0.33333333333333
23967, 0.66666666666667, 1.25, 0.33333333333333
23968, 0.66666666666667, 1.3, 0.33333333333333
23969, 0.66666666666667, 0.2, 0.375
23970, 0.66666666666667, 0.25, 0.375
23971, 0.66666666666667, 0.3, 0.375
23972, 0.66666666666667, 0.35, 0.375
23973, 0.66666666666667, 0.4, 0.375
23974, 0.66666666666667, 0.45, 0.375
23975, 0.66666666666667, 0.5, 0.375
23976, 0.66666666666667, 0.55, 0.375
23977, 0.66666666666667, 0.6, 0.375
23978, 0.66666666666667, 0.65, 0.375
23979, 0.66666666666667, 0.7, 0.375
23980, 0.66666666666667, 0.75, 0.375
23981, 0.66666666666667, 0.8, 0.375
23982, 0.66666666666667, 0.85, 0.375
23983, 0.66666666666667, 0.9, 0.375
23984, 0.66666666666667, 0.95, 0.375
23985, 0.66666666666667, 1, 0.375
23986, 0.66666666666667, 1.05, 0.375
23987, 0.66666666666667, 1.1, 0.375
23988, 0.66666666666667, 1.15, 0.375
23989, 0.66666666666667, 1.2, 0.375
23990, 0.66666666666667, 1.25, 0.375
23991, 0.66666666666667, 1.3, 0.375
23992, 0.66666666666667, 0.2, 0.41666666666667
23993, 0.66666666666667, 0.25, 0.41666666666667
23994, 0.66666666666667, 0.3, 0.41666666666667
23995, 0.66666666666667, 0.35, 0.41666666666667
23996, 0.66666666666667, 0.4, 0.41666666666667
23997, 0.66666666666667, 0.45, 0.41666666666667
23998, 0.66666666666667, 0.5, 0.41666666666667
23999, 0.66666666666667, 0.55, 0.41666666666667
24000, 0.66666666666667, 0.6, 0.41666666666667
24001, 0.66666666666667, 0.65, 0.41666666666667
24002, 0.66666666666667, 0.7, 0.41666666666667
24003, 0.66666666666667, 0.75, 0.41666666666667
24004, 0.66666666666667, 0.8, 0.41666666666667
24005, 0.66666666666667, 0.85, 0.41666666666667
24006, 0.66666666666667, 0.9, 0.41666666666667
24007, 0.66666666666667, 0.95, 0.41666666666667
24008, 0.66666666666667, 1, 0.41666666666667
24009, 0.66666666666667, 1.05, 0.41666666666667
24010, 0.66666666666667, 1.1, 0.41666666666667
24011, 0.66666666666667, 1.15, 0.41666666666667
24012, 0.66666666666667, 1.2, 0.41666666666667
24013, 0.66666666666667, 1.25, 0.41666666666667
24014, 0.66666666666667, 1.3, 0.41666666666667
24015, 0.66666666666667, 0.2, 0.45833333333333
24016, 0.66666666666667, 0.25, 0.45833333333333
24017, 0.66666666666667, 0.3, 0.45833333333333
24018, 0.66666666666667, 0.35, 0.45833333333333
24019, 0.66666666666667, 0.4, 0.45833333333333
24020, 0.66666666666667, 0.45, 0.45833333333333
24021, 0.66666666666667, 0.5, 0.45833333333333
24022, 0.66666666666667, 0.55, 0.45833333333333
24023, 0.66666666666667, 0.6, 0.45833333333333
24024, 0.66666666666667, 0.65, 0.45833333333333
24025, 0.66666666666667, 0.7, 0.45833333333333
24026, 0.66666666666667, 0.75, 0.45833333333333
24027, 0.66666666666667, 0.8, 0.45833333333333
24028, 0.66666666666667, 0.85, 0.45833333333333
24029, 0.66666666666667, 0.9, 0.45833333333333
24030, 0.66666666666667, 0.95, 0.45833333333333
24031, 0.66666666666667, 1, 0.45833333333333
24032, 0.66666666666667, 1.05, 0.45833333333333
24033, 0.66666666666667, 1.1, 0.45833333333333
24034, 0.66666666666667, 1.15, 0.45833333333333
24035, 0.66666666666667, 1.2, 0.45833333333333
24036, 0.66666666666667, 1.25, 0.45833333333333
24037, 0.66666666666667, 1.3, 0.45833333333333
24038, 0.70833333333333, 0.2, 0.041666666666667
24039, 0.70833333333333, 0.25, 0.041666666666667
24040, 0.70833333333333, 0.3, 0.041666666666667
24041, 0.70833333333333, 0.35, 0.041666666666667
24042, 0.70833333333333, 0.4, 0.041666666666667
24043, 0.70833333333333, 0.45, 0.041666666666667
24044, 0.70833333333333, 0.5, 0.041666666666667
24045, 0.70833333333333, 0.55, 0.041666666666667
24046, 0.70833333333333, 0.6, 0.041666666666667
24047, 0.70833333333333, 0.65, 0.041666666666667
24048, 0.70833333333333, 0.7, 0.041666666666667
24049, 0.70833333333333, 0.75, 0.041666666666667
24050, 0.70833333333333, 0.8, 0.041666666666667
24051, 0.70833333333333, 0.85, 0.041666666666667
24052, 0.70833333333333, 0.9, 0.041666666666667
24053, 0.70833333333333, 0.95, 0.041666666666667
24054, 0.70833333333333, 1, 0.041666666666667
24055, 0.70833333333333, 1.05, 0.041666666666667
24056, 0.70833333333333, 1.1, 0.041666666666667
24057, 0.70833333333333, 1.15, 0.041666666666667
24058, 0.70833333333333, 1.2, 0.041666666666667
24059, 0.70833333333333, 1.25, 0.041666666666667
24060, 0.70833333333333, 1.3, 0.041666666666667
24061, 0.70833333333333, 0.2, 0.083333333333333
24062, 0.70833333333333, 0.25, 0.083333333333333
24063, 0.70833333333333, 0.3, 0.083333333333333
24064, 0.70833333333333, 0.35, 0.083333333333333
24065, 0.70833333333333, 0.4, 0.083333333333333
24066, 0.70833333333333, 0.45, 0.083333333333333
24067, 0.70833333333333, 0.5, 0.083333333333333
24068, 0.70833333333333, 0.55, 0.083333333333333
24069, 0.70833333333333, 0.6, 0.083333333333333
24070, 0.70833333333333, 0.65, 0.083333333333333
24071, 0.70833333333333, 0.7, 0.083333333333333
24072, 0.70833333333333, 0.75, 0.083333333333333
24073, 0.70833333333333, 0.8, 0.083333333333333
24074, 0.70833333333333, 0.85, 0.083333333333333
24075, 0.70833333333333, 0.9, 0.083333333333333
24076, 0.70833333333333, 0.95, 0.083333333333333
24077, 0.70833333333333, 1, 0.083333333333333
24078, 0.70833333333333, 1.05, 0.083333333333333
24079, 0.70833333333333, 1.1, 0.083333333333333
24080, 0.70833333333333, 1.15, 0.083333333333333
24081, 0.70833333333333, 1.2, 0.083333333333333
24082, 0.70833333333333, 1.25, 0.083333333333333
24083, 0.70833333333333, 1.3, 0.083333333333333
24084, 0.70833333333333, 0.2, 0.125
24085, 0.70833333333333, 0.25, 0.125
24086, 0.70833333333333, 0.3, 0.125
24087, 0.70833333333333, 0.35, 0.125
24088, 0.70833333333333, 0.4, 0.125
24089, 0.70833333333333, 0.45, 0.125
24090, 0.70833333333333, 0.5, 0.125
24091, 0.70833333333333, 0.55, 0.125
24092, 0.70833333333333, 0.6, 0.125
24093, 0.70833333333333, 0.65, 0.125
24094, 0.70833333333333, 0.7, 0.125
24095, 0.70833333333333, 0.75, 0.125
24096, 0.70833333333333, 0.8, 0.125
24097, 0.70833333333333, 0.85, 0.125
24098, 0.70833333333333, 0.9, 0.125
24099, 0.70833333333333, 0.95, 0.125
24100, 0.70833333333333, 1, 0.125
24101, 0.70833333333333, 1.05, 0.125
24102, 0.70833333333333, 1.1, 0.125
24103, 0.70833333333333, 1.15, 0.125
24104, 0.70833333333333, 1.2, 0.125
24105, 0.70833333333333, 1.25, 0.125
24106, 0.70833333333333, 1.3, 0.125
24107, 0.70833333333333, 0.2, 0.16666666666667
24108, 0.70833333333333, 0.25, 0.16666666666667
24109, 0.70833333333333, 0.3, 0.16666666666667
24110, 0.70833333333333, 0.35, 0.16666666666667
24111, 0.70833333333333, 0.4, 0.16666666666667
24112, 0.70833333333333, 0.45, 0.16666666666667
24113, 0.70833333333333, 0.5, 0.16666666666667
24114, 0.70833333333333, 0.55, 0.16666666666667
24115, 0.70833333333333, 0.6, 0.16666666666667
24116, 0.70833333333333, 0.65, 0.16666666666667
24117, 0.70833333333333, 0.7, 0.16666666666667
24118, 0.70833333333333, 0.75, 0.16666666666667
24119, 0.70833333333333, 0.8, 0.16666666666667
24120, 0.70833333333333, 0.85, 0.16666666666667
24121, 0.70833333333333, 0.9, 0.16666666666667
24122, 0.70833333333333, 0.95, 0.16666666666667
24123, 0.70833333333333, 1, 0.16666666666667
24124, 0.70833333333333, 1.05, 0.16666666666667
24125, 0.70833333333333, 1.1, 0.16666666666667
24126, 0.70833333333333, 1.15, 0.16666666666667
24127, 0.70833333333333, 1.2, 0.16666666666667
24128, 0.70833333333333, 1.25, 0.16666666666667
24129, 0.70833333333333, 1.3, 0.16666666666667
24130, 0.70833333333333, 0.2, 0.20833333333333
24131, 0.70833333333333, 0.25, 0.20833333333333
24132, 0.70833333333333, 0.3, 0.20833333333333
24133, 0.70833333333333, 0.35, 0.20833333333333
24134, 0.70833333333333, 0.4, 0.20833333333333
24135, 0.70833333333333, 0.45, 0.20833333333333
24136, 0.70833333333333, 0.5, 0.20833333333333
24137, 0.70833333333333, 0.55, 0.20833333333333
24138, 0.70833333333333, 0.6, 0.20833333333333
24139, 0.70833333333333, 0.65, 0.20833333333333
24140, 0.70833333333333, 0.7, 0.20833333333333
24141, 0.70833333333333, 0.75, 0.20833333333333
24142, 0.70833333333333, 0.8, 0.20833333333333
24143, 0.70833333333333, 0.85, 0.20833333333333
24144, 0.70833333333333, 0.9, 0.20833333333333
24145, 0.70833333333333, 0.95, 0.20833333333333
24146, 0.70833333333333, 1, 0.20833333333333
24147, 0.70833333333333, 1.05, 0.20833333333333
24148, 0.70833333333333, 1.1, 0.20833333333333
24149, 0.70833333333333, 1.15, 0.20833333333333
24150, 0.70833333333333, 1.2, 0.20833333333333
24151, 0.70833333333333, 1.25, 0.20833333333333
24152, 0.70833333333333, 1.3, 0.20833333333333
24153, 0.70833333333333, 0.2, 0.25
24154, 0.70833333333333, 0.25, 0.25
24155, 0.70833333333333, 0.3, 0.25
24156, 0.70833333333333, 0.35, 0.25
24157, 0.70833333333333, 0.4, 0.25
24158, 0.70833333333333, 0.45, 0.25
24159, 0.70833333333333, 0.5, 0.25
24160, 0.70833333333333, 0.55, 0.25
24161, 0.70833333333333, 0.6, 0.25
24162, 0.70833333333333, 0.65, 0.25
24163, 0.70833333333333, 0.7, 0.25
24164, 0.70833333333333, 0.75, 0.25
24165, 0.70833333333333, 0.8, 0.25
24166, 0.70833333333333, 0.85, 0.25
24167, 0.70833333333333, 0.9, 0.25
24168, 0.70833333333333, 0.95, 0.25
24169, 0.70833333333333, 1, 0.25
24170, 0.70833333333333, 1.05, 0.25
24171, 0.70833333333333, 1.1, 0.25
24172, 0.70833333333333, 1.15, 0.25
24173, 0.70833333333333, 1.2, 0.25
24174, 0.70833333333333, 1.25, 0.25
24175, 0.70833333333333, 1.3, 0.25
24176, 0.70833333333333, 0.2, 0.29166666666667
24177, 0.70833333333333, 0.25, 0.29166666666667
24178, 0.70833333333333, 0.3, 0.29166666666667
24179, 0.70833333333333, 0.35, 0.29166666666667
24180, 0.70833333333333, 0.4, 0.29166666666667
24181, 0.70833333333333, 0.45, 0.29166666666667
24182, 0.70833333333333, 0.5, 0.29166666666667
24183, 0.70833333333333, 0.55, 0.29166666666667
24184, 0.70833333333333, 0.6, 0.29166666666667
24185, 0.70833333333333, 0.65, 0.29166666666667
24186, 0.70833333333333, 0.7, 0.29166666666667
24187, 0.70833333333333, 0.75, 0.29166666666667
24188, 0.70833333333333, 0.8, 0.29166666666667
24189, 0.70833333333333, 0.85, 0.29166666666667
24190, 0.70833333333333, 0.9, 0.29166666666667
24191, 0.70833333333333, 0.95, 0.29166666666667
24192, 0.70833333333333, 1, 0.29166666666667
24193, 0.70833333333333, 1.05, 0.29166666666667
24194, 0.70833333333333, 1.1, 0.29166666666667
24195, 0.70833333333333, 1.15, 0.29166666666667
24196, 0.70833333333333, 1.2, 0.29166666666667
24197, 0.70833333333333, 1.25, 0.29166666666667
24198, 0.70833333333333, 1.3, 0.29166666666667
24199, 0.70833333333333, 0.2, 0.33333333333333
24200, 0.70833333333333, 0.25, 0.33333333333333
24201, 0.70833333333333, 0.3, 0.33333333333333
24202, 0.70833333333333, 0.35, 0.33333333333333
24203, 0.70833333333333, 0.4, 0.33333333333333
24204, 0.70833333333333, 0.45, 0.33333333333333
24205, 0.70833333333333, 0.5, 0.33333333333333
24206, 0.70833333333333, 0.55, 0.33333333333333
24207, 0.70833333333333, 0.6, 0.33333333333333
24208, 0.70833333333333, 0.65, 0.33333333333333
24209, 0.70833333333333, 0.7, 0.33333333333333
24210, 0.70833333333333, 0.75, 0.33333333333333
24211, 0.70833333333333, 0.8, 0.33333333333333
24212, 0.70833333333333, 0.85, 0.33333333333333
24213, 0.70833333333333, 0.9, 0.33333333333333
24214, 0.70833333333333, 0.95, 0.33333333333333
24215, 0.70833333333333, 1, 0.33333333333333
24216, 0.70833333333333, 1.05, 0.33333333333333
24217, 0.70833333333333, 1.1, 0.33333333333333
24218, 0.70833333333333, 1.15, 0.33333333333333
24219, 0.70833333333333, 1.2, 0.33333333333333
24220, 0.70833333333333, 1.25, 0.33333333333333
24221, 0.70833333333333, 1.3, 0.33333333333333
24222, 0.70833333333333, 0.2, 0.375
24223, 0.70833333333333, 0.25, 0.375
24224, 0.70833333333333, 0.3, 0.375
24225, 0.70833333333333, 0.35, 0.375
24226, 0.70833333333333, 0.4, 0.375
24227, 0.70833333333333, 0.45, 0.375
24228, 0.70833333333333, 0.5, 0.375
24229, 0.70833333333333, 0.55, 0.375
24230, 0.70833333333333, 0.6, 0.375
24231, 0.70833333333333, 0.65, 0.375
24232, 0.70833333333333, 0.7, 0.375
24233, 0.70833333333333, 0.75, 0.375
24234, 0.70833333333333, 0.8, 0.375
24235, 0.70833333333333, 0.85, 0.375
24236, 0.70833333333333, 0.9, 0.375
24237, 0.70833333333333, 0.95, 0.375
24238, 0.70833333333333, 1, 0.375
24239, 0.70833333333333, 1.05, 0.375
24240, 0.70833333333333, 1.1, 0.375
24241, 0.70833333333333, 1.15, 0.375
24242, 0.70833333333333, 1.2, 0.375
24243, 0.70833333333333, 1.25, 0.375
24244, 0.70833333333333, 1.3, 0.375
24245, 0.70833333333333, 0.2, 0.41666666666667
24246, 0.70833333333333, 0.25, 0.41666666666667
24247, 0.70833333333333, 0.3, 0.41666666666667
24248, 0.70833333333333, 0.35, 0.41666666666667
24249, 0.70833333333333, 0.4, 0.41666666666667
24250, 0.70833333333333, 0.45, 0.41666666666667
24251, 0.70833333333333, 0.5, 0.41666666666667
24252, 0.70833333333333, 0.55, 0.41666666666667
24253, 0.70833333333333, 0.6, 0.41666666666667
24254, 0.70833333333333, 0.65, 0.41666666666667
24255, 0.70833333333333, 0.7, 0.41666666666667
24256, 0.70833333333333, 0.75, 0.41666666666667
24257, 0.70833333333333, 0.8, 0.41666666666667
24258, 0.70833333333333, 0.85, 0.41666666666667
24259, 0.70833333333333, 0.9, 0.41666666666667
24260, 0.70833333333333, 0.95, 0.41666666666667
24261, 0.70833333333333, 1, 0.41666666666667
24262, 0.70833333333333, 1.05, 0.41666666666667
24263, 0.70833333333333, 1.1, 0.41666666666667
24264, 0.70833333333333, 1.15, 0.41666666666667
24265, 0.70833333333333, 1.2, 0.41666666666667
24266, 0.70833333333333, 1.25, 0.41666666666667
24267, 0.70833333333333, 1.3, 0.41666666666667
24268, 0.70833333333333, 0.2, 0.45833333333333
24269, 0.70833333333333, 0.25, 0.45833333333333
24270, 0.70833333333333, 0.3, 0.45833333333333
24271, 0.70833333333333, 0.35, 0.45833333333333
24272, 0.70833333333333, 0.4, 0.45833333333333
24273, 0.70833333333333, 0.45, 0.45833333333333
24274, 0.70833333333333, 0.5, 0.45833333333333
24275, 0.70833333333333, 0.55, 0.45833333333333
24276, 0.70833333333333, 0.6, 0.45833333333333
24277, 0.70833333333333, 0.65, 0.45833333333333
24278, 0.70833333333333, 0.7, 0.45833333333333
24279, 0.70833333333333, 0.75, 0.45833333333333
24280, 0.70833333333333, 0.8, 0.45833333333333
24281, 0.70833333333333, 0.85, 0.45833333333333
24282, 0.70833333333333, 0.9, 0.45833333333333
24283, 0.70833333333333, 0.95, 0.45833333333333
24284, 0.70833333333333, 1, 0.45833333333333
24285, 0.70833333333333, 1.05, 0.45833333333333
24286, 0.70833333333333, 1.1, 0.45833333333333
24287, 0.70833333333333, 1.15, 0.45833333333333
24288, 0.70833333333333, 1.2, 0.45833333333333
24289, 0.70833333333333, 1.25, 0.45833333333333
24290, 0.70833333333333, 1.3, 0.45833333333333
24291, 0.75, 0.2, 0.041666666666667
24292, 0.75, 0.25, 0.041666666666667
24293, 0.75, 0.3, 0.041666666666667
24294, 0.75, 0.35, 0.041666666666667
24295, 0.75, 0.4, 0.041666666666667
24296, 0.75, 0.45, 0.041666666666667
24297, 0.75, 0.5, 0.041666666666667
24298, 0.75, 0.55, 0.041666666666667
24299, 0.75, 0.6, 0.041666666666667
24300, 0.75, 0.65, 0.041666666666667
24301, 0.75, 0.7, 0.041666666666667
24302, 0.75, 0.75, 0.041666666666667
24303, 0.75, 0.8, 0.041666666666667
24304, 0.75, 0.85, 0.041666666666667
24305, 0.75, 0.9, 0.041666666666667
24306, 0.75, 0.95, 0.041666666666667
24307, 0.75, 1, 0.041666666666667
24308, 0.75, 1.05, 0.041666666666667
24309, 0.75, 1.1, 0.041666666666667
24310, 0.75, 1.15, 0.041666666666667
24311, 0.75, 1.2, 0.041666666666667
24312, 0.75, 1.25, 0.041666666666667
24313, 0.75, 1.3, 0.041666666666667
24314, 0.75, 0.2, 0.083333333333333
24315, 0.75, 0.25, 0.083333333333333
24316, 0.75, 0.3, 0.083333333333333
24317, 0.75, 0.35, 0.083333333333333
24318, 0.75, 0.4, 0.083333333333333
24319, 0.75, 0.45, 0.083333333333333
24320, 0.75, 0.5, 0.083333333333333
24321, 0.75, 0.55, 0.083333333333333
24322, 0.75, 0.6, 0.083333333333333
24323, 0.75, 0.65, 0.083333333333333
24324, 0.75, 0.7, 0.083333333333333
24325, 0.75, 0.75, 0.083333333333333
24326, 0.75, 0.8, 0.083333333333333
24327, 0.75, 0.85, 0.083333333333333
24328, 0.75, 0.9, 0.083333333333333
24329, 0.75, 0.95, 0.083333333333333
24330, 0.75, 1, 0.083333333333333
24331, 0.75, 1.05, 0.083333333333333
24332, 0.75, 1.1, 0.083333333333333
24333, 0.75, 1.15, 0.083333333333333
24334, 0.75, 1.2, 0.083333333333333
24335, 0.75, 1.25, 0.083333333333333
24336, 0.75, 1.3, 0.083333333333333
24337, 0.75, 0.2, 0.125
24338, 0.75, 0.25, 0.125
24339, 0.75, 0.3, 0.125
24340, 0.75, 0.35, 0.125
24341, 0.75, 0.4, 0.125
24342, 0.75, 0.45, 0.125
24343, 0.75, 0.5, 0.125
24344, 0.75, 0.55, 0.125
24345, 0.75, 0.6, 0.125
24346, 0.75, 0.65, 0.125
24347, 0.75, 0.7, 0.125
24348, 0.75, 0.75, 0.125
24349, 0.75, 0.8, 0.125
24350, 0.75, 0.85, 0.125
24351, 0.75, 0.9, 0.125
24352, 0.75, 0.95, 0.125
24353, 0.75, 1, 0.125
24354, 0.75, 1.05, 0.125
24355, 0.75, 1.1, 0.125
24356, 0.75, 1.15, 0.125
24357, 0.75, 1.2, 0.125
24358, 0.75, 1.25, 0.125
24359, 0.75, 1.3, 0.125
24360, 0.75, 0.2, 0.16666666666667
24361, 0.75, 0.25, 0.16666666666667
24362, 0.75, 0.3, 0.16666666666667
24363, 0.75, 0.35, 0.16666666666667
24364, 0.75, 0.4, 0.16666666666667
24365, 0.75, 0.45, 0.16666666666667
24366, 0.75, 0.5, 0.16666666666667
24367, 0.75, 0.55, 0.16666666666667
24368, 0.75, 0.6, 0.16666666666667
24369, 0.75, 0.65, 0.16666666666667
24370, 0.75, 0.7, 0.16666666666667
24371, 0.75, 0.75, 0.16666666666667
24372, 0.75, 0.8, 0.16666666666667
24373, 0.75, 0.85, 0.16666666666667
24374, 0.75, 0.9, 0.16666666666667
24375, 0.75, 0.95, 0.16666666666667
24376, 0.75, 1, 0.16666666666667
24377, 0.75, 1.05, 0.16666666666667
24378, 0.75, 1.1, 0.16666666666667
24379, 0.75, 1.15, 0.16666666666667
24380, 0.75, 1.2, 0.16666666666667
24381, 0.75, 1.25, 0.16666666666667
24382, 0.75, 1.3, 0.16666666666667
24383, 0.75, 0.2, 0.20833333333333
24384, 0.75, 0.25, 0.20833333333333
24385, 0.75, 0.3, 0.20833333333333
24386, 0.75, 0.35, 0.20833333333333
24387, 0.75, 0.4, 0.20833333333333
24388, 0.75, 0.45, 0.20833333333333
24389, 0.75, 0.5, 0.20833333333333
24390, 0.75, 0.55, 0.20833333333333
24391, 0.75, 0.6, 0.20833333333333
24392, 0.75, 0.65, 0.20833333333333
24393, 0.75, 0.7, 0.20833333333333
24394, 0.75, 0.75, 0.20833333333333
24395, 0.75, 0.8, 0.20833333333333
24396, 0.75, 0.85, 0.20833333333333
24397, 0.75, 0.9, 0.20833333333333
24398, 0.75, 0.95, 0.20833333333333
24399, 0.75, 1, 0.20833333333333
24400, 0.75, 1.05, 0.20833333333333
24401, 0.75, 1.1, 0.20833333333333
24402, 0.75, 1.15, 0.20833333333333
24403, 0.75, 1.2, 0.20833333333333
24404, 0.75, 1.25, 0.20833333333333
24405, 0.75, 1.3, 0.20833333333333
24406, 0.75, 0.2, 0.25
24407, 0.75, 0.25, 0.25
24408, 0.75, 0.3, 0.25
24409, 0.75, 0.35, 0.25
24410, 0.75, 0.4, 0.25
24411, 0.75, 0.45, 0.25
24412, 0.75, 0.5, 0.25
24413, 0.75, 0.55, 0.25
24414, 0.75, 0.6, 0.25
24415, 0.75, 0.65, 0.25
24416, 0.75, 0.7, 0.25
24417, 0.75, 0.75, 0.25
24418, 0.75, 0.8, 0.25
24419, 0.75, 0.85, 0.25
24420, 0.75, 0.9, 0.25
24421, 0.75, 0.95, 0.25
24422, 0.75, 1, 0.25
24423, 0.75, 1.05, 0.25
24424, 0.75, 1.1, 0.25
24425, 0.75, 1.15, 0.25
24426, 0.75, 1.2, 0.25
24427, 0.75, 1.25, 0.25
24428, 0.75, 1.3, 0.25
24429, 0.75, 0.2, 0.29166666666667
24430, 0.75, 0.25, 0.29166666666667
24431, 0.75, 0.3, 0.29166666666667
24432, 0.75, 0.35, 0.29166666666667
24433, 0.75, 0.4, 0.29166666666667
24434, 0.75, 0.45, 0.29166666666667
24435, 0.75, 0.5, 0.29166666666667
24436, 0.75, 0.55, 0.29166666666667
24437, 0.75, 0.6, 0.29166666666667
24438, 0.75, 0.65, 0.29166666666667
24439, 0.75, 0.7, 0.29166666666667
24440, 0.75, 0.75, 0.29166666666667
24441, 0.75, 0.8, 0.29166666666667
24442, 0.75, 0.85, 0.29166666666667
24443, 0.75, 0.9, 0.29166666666667
24444, 0.75, 0.95, 0.29166666666667
24445, 0.75, 1, 0.29166666666667
24446, 0.75, 1.05, 0.29166666666667
24447, 0.75, 1.1, 0.29166666666667
24448, 0.75, 1.15, 0.29166666666667
24449, 0.75, 1.2, 0.29166666666667
24450, 0.75, 1.25, 0.29166666666667
24451, 0.75, 1.3, 0.29166666666667
24452, 0.75, 0.2, 0.33333333333333
24453, 0.75, 0.25, 0.33333333333333
24454, 0.75, 0.3, 0.33333333333333
24455, 0.75, 0.35, 0.33333333333333
24456, 0.75, 0.4, 0.33333333333333
24457, 0.75, 0.45, 0.33333333333333
24458, 0.75, 0.5, 0.33333333333333
24459, 0.75, 0.55, 0.33333333333333
24460, 0.75, 0.6, 0.33333333333333
24461, 0.75, 0.65, 0.33333333333333
24462, 0.75, 0.7, 0.33333333333333
24463, 0.75, 0.75, 0.33333333333333
24464, 0.75, 0.8, 0.33333333333333
24465, 0.75, 0.85, 0.33333333333333
24466, 0.75, 0.9, 0.33333333333333
24467, 0.75, 0.95, 0.33333333333333
24468, 0.75, 1, 0.33333333333333
24469, 0.75, 1.05, 0.33333333333333
24470, 0.75, 1.1, 0.33333333333333
24471, 0.75, 1.15, 0.33333333333333
24472, 0.75, 1.2, 0.33333333333333
24473, 0.75, 1.25, 0.33333333333333
24474, 0.75, 1.3, 0.33333333333333
24475, 0.75, 0.2, 0.375
24476, 0.75, 0.25, 0.375
24477, 0.75, 0.3, 0.375
24478, 0.75, 0.35, 0.375
24479, 0.75, 0.4, 0.375
24480, 0.75, 0.45, 0.375
24481, 0.75, 0.5, 0.375
24482, 0.75, 0.55, 0.375
24483, 0.75, 0.6, 0.375
24484, 0.75, 0.65, 0.375
24485, 0.75, 0.7, 0.375
24486, 0.75, 0.75, 0.375
24487, 0.75, 0.8, 0.375
24488, 0.75, 0.85, 0.375
24489, 0.75, 0.9, 0.375
24490, 0.75, 0.95, 0.375
24491, 0.75, 1, 0.375
24492, 0.75, 1.05, 0.375
24493, 0.75, 1.1, 0.375
24494, 0.75, 1.15, 0.375
24495, 0.75, 1.2, 0.375
24496, 0.75, 1.25, 0.375
24497, 0.75, 1.3, 0.375
24498, 0.75, 0.2, 0.41666666666667
24499, 0.75, 0.25, 0.41666666666667
24500, 0.75, 0.3, 0.41666666666667
24501, 0.75, 0.35, 0.41666666666667
24502, 0.75, 0.4, 0.41666666666667
24503, 0.75, 0.45, 0.41666666666667
24504, 0.75, 0.5, 0.41666666666667
24505, 0.75, 0.55, 0.41666666666667
24506, 0.75, 0.6, 0.41666666666667
24507, 0.75, 0.65, 0.41666666666667
24508, 0.75, 0.7, 0.41666666666667
24509, 0.75, 0.75, 0.41666666666667
24510, 0.75, 0.8, 0.41666666666667
24511, 0.75, 0.85, 0.41666666666667
24512, 0.75, 0.9, 0.41666666666667
24513, 0.75, 0.95, 0.41666666666667
24514, 0.75, 1, 0.41666666666667
24515, 0.75, 1.05, 0.41666666666667
24516, 0.75, 1.1, 0.41666666666667
24517, 0.75, 1.15, 0.41666666666667
24518, 0.75, 1.2, 0.41666666666667
24519, 0.75, 1.25, 0.41666666666667
24520, 0.75, 1.3, 0.41666666666667
24521, 0.75, 0.2, 0.45833333333333
24522, 0.75, 0.25, 0.45833333333333
24523, 0.75, 0.3, 0.45833333333333
24524, 0.75, 0.35, 0.45833333333333
24525, 0.75, 0.4, 0.45833333333333
24526, 0.75, 0.45, 0.45833333333333
24527, 0.75, 0.5, 0.45833333333333
24528, 0.75, 0.55, 0.45833333333333
24529, 0.75, 0.6, 0.45833333333333
24530, 0.75, 0.65, 0.45833333333333
24531, 0.75, 0.7, 0.45833333333333
24532, 0.75, 0.75, 0.45833333333333
24533, 0.75, 0.8, 0.45833333333333
24534, 0.75, 0.85, 0.45833333333333
24535, 0.75, 0.9, 0.45833333333333
24536, 0.75, 0.95, 0.45833333333333
24537, 0.75, 1, 0.45833333333333
24538, 0.75, 1.05, 0.45833333333333
24539, 0.75, 1.1, 0.45833333333333
24540, 0.75, 1.15, 0.45833333333333
24541, 0.75, 1.2, 0.45833333333333
24542, 0.75, 1.25, 0.45833333333333
24543, 0.75, 1.3, 0.45833333333333
24544, 0.79166666666667, 0.2, 0.041666666666667
24545, 0.79166666666667, 0.25, 0.041666666666667
24546, 0.79166666666667, 0.3, 0.041666666666667
24547, 0.79166666666667, 0.35, 0.041666666666667
24548, 0.79166666666667, 0.4, 0.041666666666667
24549, 0.79166666666667, 0.45, 0.041666666666667
24550, 0.79166666666667, 0.5, 0.041666666666667
24551, 0.79166666666667, 0.55, 0.041666666666667
24552, 0.79166666666667, 0.6, 0.041666666666667
24553, 0.79166666666667, 0.65, 0.041666666666667
24554, 0.79166666666667, 0.7, 0.041666666666667
24555, 0.79166666666667, 0.75, 0.041666666666667
24556, 0.79166666666667, 0.8, 0.041666666666667
24557, 0.79166666666667, 0.85, 0.041666666666667
24558, 0.79166666666667, 0.9, 0.041666666666667
24559, 0.79166666666667, 0.95, 0.041666666666667
24560, 0.79166666666667, 1, 0.041666666666667
24561, 0.79166666666667, 1.05, 0.041666666666667
24562, 0.79166666666667, 1.1, 0.041666666666667
24563, 0.79166666666667, 1.15, 0.041666666666667
24564, 0.79166666666667, 1.2, 0.041666666666667
24565, 0.79166666666667, 1.25, 0.041666666666667
24566, 0.79166666666667, 1.3, 0.041666666666667
24567, 0.79166666666667, 0.2, 0.083333333333333
24568, 0.79166666666667, 0.25, 0.083333333333333
24569, 0.79166666666667, 0.3, 0.083333333333333
24570, 0.79166666666667, 0.35, 0.083333333333333
24571, 0.79166666666667, 0.4, 0.083333333333333
24572, 0.79166666666667, 0.45, 0.083333333333333
24573, 0.79166666666667, 0.5, 0.083333333333333
24574, 0.79166666666667, 0.55, 0.083333333333333
24575, 0.79166666666667, 0.6, 0.083333333333333
24576, 0.79166666666667, 0.65, 0.083333333333333
24577, 0.79166666666667, 0.7, 0.083333333333333
24578, 0.79166666666667, 0.75, 0.083333333333333
24579, 0.79166666666667, 0.8, 0.083333333333333
24580, 0.79166666666667, 0.85, 0.083333333333333
24581, 0.79166666666667, 0.9, 0.083333333333333
24582, 0.79166666666667, 0.95, 0.083333333333333
24583, 0.79166666666667, 1, 0.083333333333333
24584, 0.79166666666667, 1.05, 0.083333333333333
24585, 0.79166666666667, 1.1, 0.083333333333333
24586, 0.79166666666667, 1.15, 0.083333333333333
24587, 0.79166666666667, 1.2, 0.083333333333333
24588, 0.79166666666667, 1.25, 0.083333333333333
24589, 0.79166666666667, 1.3, 0.083333333333333
24590, 0.79166666666667, 0.2, 0.125
24591, 0.79166666666667, 0.25, 0.125
24592, 0.79166666666667, 0.3, 0.125
24593, 0.79166666666667, 0.35, 0.125
24594, 0.79166666666667, 0.4, 0.125
24595, 0.79166666666667, 0.45, 0.125
24596, 0.79166666666667, 0.5, 0.125
24597, 0.79166666666667, 0.55, 0.125
24598, 0.79166666666667, 0.6, 0.125
24599, 0.79166666666667, 0.65, 0.125
24600, 0.79166666666667, 0.7, 0.125
24601, 0.79166666666667, 0.75, 0.125
24602, 0.79166666666667, 0.8, 0.125
24603, 0.79166666666667, 0.85, 0.125
24604, 0.79166666666667, 0.9, 0.125
24605, 0.79166666666667, 0.95, 0.125
24606, 0.79166666666667, 1, 0.125
24607, 0.79166666666667, 1.05, 0.125
24608, 0.79166666666667, 1.1, 0.125
24609, 0.79166666666667, 1.15, 0.125
24610, 0.79166666666667, 1.2, 0.125
24611, 0.79166666666667, 1.25, 0.125
24612, 0.79166666666667, 1.3, 0.125
24613, 0.79166666666667, 0.2, 0.16666666666667
24614, 0.79166666666667, 0.25, 0.16666666666667
24615, 0.79166666666667, 0.3, 0.16666666666667
24616, 0.79166666666667, 0.35, 0.16666666666667
24617, 0.79166666666667, 0.4, 0.16666666666667
24618, 0.79166666666667, 0.45, 0.16666666666667
24619, 0.79166666666667, 0.5, 0.16666666666667
24620, 0.79166666666667, 0.55, 0.16666666666667
24621, 0.79166666666667, 0.6, 0.16666666666667
24622, 0.79166666666667, 0.65, 0.16666666666667
24623, 0.79166666666667, 0.7, 0.16666666666667
24624, 0.79166666666667, 0.75, 0.16666666666667
24625, 0.79166666666667, 0.8, 0.16666666666667
24626, 0.79166666666667, 0.85, 0.16666666666667
24627, 0.79166666666667, 0.9, 0.16666666666667
24628, 0.79166666666667, 0.95, 0.16666666666667
24629, 0.79166666666667, 1, 0.16666666666667
24630, 0.79166666666667, 1.05, 0.16666666666667
24631, 0.79166666666667, 1.1, 0.16666666666667
24632, 0.79166666666667, 1.15, 0.16666666666667
24633, 0.79166666666667, 1.2, 0.16666666666667
24634, 0.79166666666667, 1.25, 0.16666666666667
24635, 0.79166666666667, 1.3, 0.16666666666667
24636, 0.79166666666667, 0.2, 0.20833333333333
24637, 0.79166666666667, 0.25, 0.20833333333333
24638, 0.79166666666667, 0.3, 0.20833333333333
24639, 0.79166666666667, 0.35, 0.20833333333333
24640, 0.79166666666667, 0.4, 0.20833333333333
24641, 0.79166666666667, 0.45, 0.20833333333333
24642, 0.79166666666667, 0.5, 0.20833333333333
24643, 0.79166666666667, 0.55, 0.20833333333333
24644, 0.79166666666667, 0.6, 0.20833333333333
24645, 0.79166666666667, 0.65, 0.20833333333333
24646, 0.79166666666667, 0.7, 0.20833333333333
24647, 0.79166666666667, 0.75, 0.20833333333333
24648, 0.79166666666667, 0.8, 0.20833333333333
24649, 0.79166666666667, 0.85, 0.20833333333333
24650, 0.79166666666667, 0.9, 0.20833333333333
24651, 0.79166666666667, 0.95, 0.20833333333333
24652, 0.79166666666667, 1, 0.20833333333333
24653, 0.79166666666667, 1.05, 0.20833333333333
24654, 0.79166666666667, 1.1, 0.20833333333333
24655, 0.79166666666667, 1.15, 0.20833333333333
24656, 0.79166666666667, 1.2, 0.20833333333333
24657, 0.79166666666667, 1.25, 0.20833333333333
24658, 0.79166666666667, 1.3, 0.20833333333333
24659, 0.79166666666667, 0.2, 0.25
24660, 0.79166666666667, 0.25, 0.25
24661, 0.79166666666667, 0.3, 0.25
24662, 0.79166666666667, 0.35, 0.25
24663, 0.79166666666667, 0.4, 0.25
24664, 0.79166666666667, 0.45, 0.25
24665, 0.79166666666667, 0.5, 0.25
24666, 0.79166666666667, 0.55, 0.25
24667, 0.79166666666667, 0.6, 0.25
24668, 0.79166666666667, 0.65, 0.25
24669, 0.79166666666667, 0.7, 0.25
24670, 0.79166666666667, 0.75, 0.25
24671, 0.79166666666667, 0.8, 0.25
24672, 0.79166666666667, 0.85, 0.25
24673, 0.79166666666667, 0.9, 0.25
24674, 0.79166666666667, 0.95, 0.25
24675, 0.79166666666667, 1, 0.25
24676, 0.79166666666667, 1.05, 0.25
24677, 0.79166666666667, 1.1, 0.25
24678, 0.79166666666667, 1.15, 0.25
24679, 0.79166666666667, 1.2, 0.25
24680, 0.79166666666667, 1.25, 0.25
24681, 0.79166666666667, 1.3, 0.25
24682, 0.79166666666667, 0.2, 0.29166666666667
24683, 0.79166666666667, 0.25, 0.29166666666667
24684, 0.79166666666667, 0.3, 0.29166666666667
24685, 0.79166666666667, 0.35, 0.29166666666667
24686, 0.79166666666667, 0.4, 0.29166666666667
24687, 0.79166666666667, 0.45, 0.29166666666667
24688, 0.79166666666667, 0.5, 0.29166666666667
24689, 0.79166666666667, 0.55, 0.29166666666667
24690, 0.79166666666667, 0.6, 0.29166666666667
24691, 0.79166666666667, 0.65, 0.29166666666667
24692, 0.79166666666667, 0.7, 0.29166666666667
24693, 0.79166666666667, 0.75, 0.29166666666667
24694, 0.79166666666667, 0.8, 0.29166666666667
24695, 0.79166666666667, 0.85, 0.29166666666667
24696, 0.79166666666667, 0.9, 0.29166666666667
24697, 0.79166666666667, 0.95, 0.29166666666667
24698, 0.79166666666667, 1, 0.29166666666667
24699, 0.79166666666667, 1.05, 0.29166666666667
24700, 0.79166666666667, 1.1, 0.29166666666667
24701, 0.79166666666667, 1.15, 0.29166666666667
24702, 0.79166666666667, 1.2, 0.29166666666667
24703, 0.79166666666667, 1.25, 0.29166666666667
24704, 0.79166666666667, 1.3, 0.29166666666667
24705, 0.79166666666667, 0.2, 0.33333333333333
24706, 0.79166666666667, 0.25, 0.33333333333333
24707, 0.79166666666667, 0.3, 0.33333333333333
24708, 0.79166666666667, 0.35, 0.33333333333333
24709, 0.79166666666667, 0.4, 0.33333333333333
24710, 0.79166666666667, 0.45, 0.33333333333333
24711, 0.79166666666667, 0.5, 0.33333333333333
24712, 0.79166666666667, 0.55, 0.33333333333333
24713, 0.79166666666667, 0.6, 0.33333333333333
24714, 0.79166666666667, 0.65, 0.33333333333333
24715, 0.79166666666667, 0.7, 0.33333333333333
24716, 0.79166666666667, 0.75, 0.33333333333333
24717, 0.79166666666667, 0.8, 0.33333333333333
24718, 0.79166666666667, 0.85, 0.33333333333333
24719, 0.79166666666667, 0.9, 0.33333333333333
24720, 0.79166666666667, 0.95, 0.33333333333333
24721, 0.79166666666667, 1, 0.33333333333333
24722, 0.79166666666667, 1.05, 0.33333333333333
24723, 0.79166666666667, 1.1, 0.33333333333333
24724, 0.79166666666667, 1.15, 0.33333333333333
24725, 0.79166666666667, 1.2, 0.33333333333333
24726, 0.79166666666667, 1.25, 0.33333333333333
24727, 0.79166666666667, 1.3, 0.33333333333333
24728, 0.79166666666667, 0.2, 0.375
24729, 0.79166666666667, 0.25, 0.375
24730, 0.79166666666667, 0.3, 0.375
24731, 0.79166666666667, 0.35, 0.375
24732, 0.79166666666667, 0.4, 0.375
24733, 0.79166666666667, 0.45, 0.375
24734, 0.79166666666667, 0.5, 0.375
24735, 0.79166666666667, 0.55, 0.375
24736, 0.79166666666667, 0.6, 0.375
24737, 0.79166666666667, 0.65, 0.375
24738, 0.79166666666667, 0.7, 0.375
24739, 0.79166666666667, 0.75, 0.375
24740, 0.79166666666667, 0.8, 0.375
24741, 0.79166666666667, 0.85, 0.375
24742, 0.79166666666667, 0.9, 0.375
24743, 0.79166666666667, 0.95, 0.375
24744, 0.79166666666667, 1, 0.375
24745, 0.79166666666667, 1.05, 0.375
24746, 0.79166666666667, 1.1, 0.375
24747, 0.79166666666667, 1.15, 0.375
24748, 0.79166666666667, 1.2, 0.375
24749, 0.79166666666667, 1.25, 0.375
24750, 0.79166666666667, 1.3, 0.375
24751, 0.79166666666667, 0.2, 0.41666666666667
24752, 0.79166666666667, 0.25, 0.41666666666667
24753, 0.79166666666667, 0.3, 0.41666666666667
24754, 0.79166666666667, 0.35, 0.41666666666667
24755, 0.79166666666667, 0.4, 0.41666666666667
24756, 0.79166666666667, 0.45, 0.41666666666667
24757, 0.79166666666667, 0.5, 0.41666666666667
24758, 0.79166666666667, 0.55, 0.41666666666667
24759, 0.79166666666667, 0.6, 0.41666666666667
24760, 0.79166666666667, 0.65, 0.41666666666667
24761, 0.79166666666667, 0.7, 0.41666666666667
24762, 0.79166666666667, 0.75, 0.41666666666667
24763, 0.79166666666667, 0.8, 0.41666666666667
24764, 0.79166666666667, 0.85, 0.41666666666667
24765, 0.79166666666667, 0.9, 0.41666666666667
24766, 0.79166666666667, 0.95, 0.41666666666667
24767, 0.79166666666667, 1, 0.41666666666667
24768, 0.79166666666667, 1.05, 0.41666666666667
24769, 0.79166666666667, 1.1, 0.41666666666667
24770, 0.79166666666667, 1.15, 0.41666666666667
24771, 0.79166666666667, 1.2, 0.41666666666667
24772, 0.79166666666667, 1.25, 0.41666666666667
24773, 0.79166666666667, 1.3, 0.41666666666667
24774, 0.79166666666667, 0.2, 0.45833333333333
24775, 0.79166666666667, 0.25, 0.45833333333333
24776, 0.79166666666667, 0.3, 0.45833333333333
24777, 0.79166666666667, 0.35, 0.45833333333333
24778, 0.79166666666667, 0.4, 0.45833333333333
24779, 0.79166666666667, 0.45, 0.45833333333333
24780, 0.79166666666667, 0.5, 0.45833333333333
24781, 0.79166666666667, 0.55, 0.45833333333333
24782, 0.79166666666667, 0.6, 0.45833333333333
24783, 0.79166666666667, 0.65, 0.45833333333333
24784, 0.79166666666667, 0.7, 0.45833333333333
24785, 0.79166666666667, 0.75, 0.45833333333333
24786, 0.79166666666667, 0.8, 0.45833333333333
24787, 0.79166666666667, 0.85, 0.45833333333333
24788, 0.79166666666667, 0.9, 0.45833333333333
24789, 0.79166666666667, 0.95, 0.45833333333333
24790, 0.79166666666667, 1, 0.45833333333333
24791, 0.79166666666667, 1.05, 0.45833333333333
24792, 0.79166666666667, 1.1, 0.45833333333333
24793, 0.79166666666667, 1.15, 0.45833333333333
24794, 0.79166666666667, 1.2, 0.45833333333333
24795, 0.79166666666667, 1.25, 0.45833333333333
24796, 0.79166666666667, 1.3, 0.45833333333333
24797, 0.83333333333333, 0.2, 0.041666666666667
24798, 0.83333333333333, 0.25, 0.041666666666667
24799, 0.83333333333333, 0.3, 0.041666666666667
24800, 0.83333333333333, 0.35, 0.041666666666667
24801, 0.83333333333333, 0.4, 0.041666666666667
24802, 0.83333333333333, 0.45, 0.041666666666667
24803, 0.83333333333333, 0.5, 0.041666666666667
24804, 0.83333333333333, 0.55, 0.041666666666667
24805, 0.83333333333333, 0.6, 0.041666666666667
24806, 0.83333333333333, 0.65, 0.041666666666667
24807, 0.83333333333333, 0.7, 0.041666666666667
24808, 0.83333333333333, 0.75, 0.041666666666667
24809, 0.83333333333333, 0.8, 0.041666666666667
24810, 0.83333333333333, 0.85, 0.041666666666667
24811, 0.83333333333333, 0.9, 0.041666666666667
24812, 0.83333333333333, 0.95, 0.041666666666667
24813, 0.83333333333333, 1, 0.041666666666667
24814, 0.83333333333333, 1.05, 0.041666666666667
24815, 0.83333333333333, 1.1, 0.041666666666667
24816, 0.83333333333333, 1.15, 0.041666666666667
24817, 0.83333333333333, 1.2, 0.041666666666667
24818, 0.83333333333333, 1.25, 0.041666666666667
24819, 0.83333333333333, 1.3, 0.041666666666667
24820, 0.83333333333333, 0.2, 0.083333333333333
24821, 0.83333333333333, 0.25, 0.083333333333333
24822, 0.83333333333333, 0.3, 0.083333333333333
24823, 0.83333333333333, 0.35, 0.083333333333333
24824, 0.83333333333333, 0.4, 0.083333333333333
24825, 0.83333333333333, 0.45, 0.083333333333333
24826, 0.83333333333333, 0.5, 0.083333333333333
24827, 0.83333333333333, 0.55, 0.083333333333333
24828, 0.83333333333333, 0.6, 0.083333333333333
24829, 0.83333333333333, 0.65, 0.083333333333333
24830, 0.83333333333333, 0.7, 0.083333333333333
24831, 0.83333333333333, 0.75, 0.083333333333333
24832, 0.83333333333333, 0.8, 0.083333333333333
24833, 0.83333333333333, 0.85, 0.083333333333333
24834, 0.83333333333333, 0.9, 0.083333333333333
24835, 0.83333333333333, 0.95, 0.083333333333333
24836, 0.83333333333333, 1, 0.083333333333333
24837, 0.83333333333333, 1.05, 0.083333333333333
24838, 0.83333333333333, 1.1, 0.083333333333333
24839, 0.83333333333333, 1.15, 0.083333333333333
24840, 0.83333333333333, 1.2, 0.083333333333333
24841, 0.83333333333333, 1.25, 0.083333333333333
24842, 0.83333333333333, 1.3, 0.083333333333333
24843, 0.83333333333333, 0.2, 0.125
24844, 0.83333333333333, 0.25, 0.125
24845, 0.83333333333333, 0.3, 0.125
24846, 0.83333333333333, 0.35, 0.125
24847, 0.83333333333333, 0.4, 0.125
24848, 0.83333333333333, 0.45, 0.125
24849, 0.83333333333333, 0.5, 0.125
24850, 0.83333333333333, 0.55, 0.125
24851, 0.83333333333333, 0.6, 0.125
24852, 0.83333333333333, 0.65, 0.125
24853, 0.83333333333333, 0.7, 0.125
24854, 0.83333333333333, 0.75, 0.125
24855, 0.83333333333333, 0.8, 0.125
24856, 0.83333333333333, 0.85, 0.125
24857, 0.83333333333333, 0.9, 0.125
24858, 0.83333333333333, 0.95, 0.125
24859, 0.83333333333333, 1, 0.125
24860, 0.83333333333333, 1.05, 0.125
24861, 0.83333333333333, 1.1, 0.125
24862, 0.83333333333333, 1.15, 0.125
24863, 0.83333333333333, 1.2, 0.125
24864, 0.83333333333333, 1.25, 0.125
24865, 0.83333333333333, 1.3, 0.125
24866, 0.83333333333333, 0.2, 0.16666666666667
24867, 0.83333333333333, 0.25, 0.16666666666667
24868, 0.83333333333333, 0.3, 0.16666666666667
24869, 0.83333333333333, 0.35, 0.16666666666667
24870, 0.83333333333333, 0.4, 0.16666666666667
24871, 0.83333333333333, 0.45, 0.16666666666667
24872, 0.83333333333333, 0.5, 0.16666666666667
24873, 0.83333333333333, 0.55, 0.16666666666667
24874, 0.83333333333333, 0.6, 0.16666666666667
24875, 0.83333333333333, 0.65, 0.16666666666667
24876, 0.83333333333333, 0.7, 0.16666666666667
24877, 0.83333333333333, 0.75, 0.16666666666667
24878, 0.83333333333333, 0.8, 0.16666666666667
24879, 0.83333333333333, 0.85, 0.16666666666667
24880, 0.83333333333333, 0.9, 0.16666666666667
24881, 0.83333333333333, 0.95, 0.16666666666667
24882, 0.83333333333333, 1, 0.16666666666667
24883, 0.83333333333333, 1.05, 0.16666666666667
24884, 0.83333333333333, 1.1, 0.16666666666667
24885, 0.83333333333333, 1.15, 0.16666666666667
24886, 0.83333333333333, 1.2, 0.16666666666667
24887, 0.83333333333333, 1.25, 0.16666666666667
24888, 0.83333333333333, 1.3, 0.16666666666667
24889, 0.83333333333333, 0.2, 0.20833333333333
24890, 0.83333333333333, 0.25, 0.20833333333333
24891, 0.83333333333333, 0.3, 0.20833333333333
24892, 0.83333333333333, 0.35, 0.20833333333333
24893, 0.83333333333333, 0.4, 0.20833333333333
24894, 0.83333333333333, 0.45, 0.20833333333333
24895, 0.83333333333333, 0.5, 0.20833333333333
24896, 0.83333333333333, 0.55, 0.20833333333333
24897, 0.83333333333333, 0.6, 0.20833333333333
24898, 0.83333333333333, 0.65, 0.20833333333333
24899, 0.83333333333333, 0.7, 0.20833333333333
24900, 0.83333333333333, 0.75, 0.20833333333333
24901, 0.83333333333333, 0.8, 0.20833333333333
24902, 0.83333333333333, 0.85, 0.20833333333333
24903, 0.83333333333333, 0.9, 0.20833333333333
24904, 0.83333333333333, 0.95, 0.20833333333333
24905, 0.83333333333333, 1, 0.20833333333333
24906, 0.83333333333333, 1.05, 0.20833333333333
24907, 0.83333333333333, 1.1, 0.20833333333333
24908, 0.83333333333333, 1.15, 0.20833333333333
24909, 0.83333333333333, 1.2, 0.20833333333333
24910, 0.83333333333333, 1.25, 0.20833333333333
24911, 0.83333333333333, 1.3, 0.20833333333333
24912, 0.83333333333333, 0.2, 0.25
24913, 0.83333333333333, 0.25, 0.25
24914, 0.83333333333333, 0.3, 0.25
24915, 0.83333333333333, 0.35, 0.25
24916, 0.83333333333333, 0.4, 0.25
24917, 0.83333333333333, 0.45, 0.25
24918, 0.83333333333333, 0.5, 0.25
24919, 0.83333333333333, 0.55, 0.25
24920, 0.83333333333333, 0.6, 0.25
24921, 0.83333333333333, 0.65, 0.25
24922, 0.83333333333333, 0.7, 0.25
24923, 0.83333333333333, 0.75, 0.25
24924, 0.83333333333333, 0.8, 0.25
24925, 0.83333333333333, 0.85, 0.25
24926, 0.83333333333333, 0.9, 0.25
24927, 0.83333333333333, 0.95, 0.25
24928, 0.83333333333333, 1, 0.25
24929, 0.83333333333333, 1.05, 0.25
24930, 0.83333333333333, 1.1, 0.25
24931, 0.83333333333333, 1.15, 0.25
24932, 0.83333333333333, 1.2, 0.25
24933, 0.83333333333333, 1.25, 0.25
24934, 0.83333333333333, 1.3, 0.25
24935, 0.83333333333333, 0.2, 0.29166666666667
24936, 0.83333333333333, 0.25, 0.29166666666667
24937, 0.83333333333333, 0.3, 0.29166666666667
24938, 0.83333333333333, 0.35, 0.29166666666667
24939, 0.83333333333333, 0.4, 0.29166666666667
24940, 0.83333333333333, 0.45, 0.29166666666667
24941, 0.83333333333333, 0.5, 0.29166666666667
24942, 0.83333333333333, 0.55, 0.29166666666667
24943, 0.83333333333333, 0.6, 0.29166666666667
24944, 0.83333333333333, 0.65, 0.29166666666667
24945, 0.83333333333333, 0.7, 0.29166666666667
24946, 0.83333333333333, 0.75, 0.29166666666667
24947, 0.83333333333333, 0.8, 0.29166666666667
24948, 0.83333333333333, 0.85, 0.29166666666667
24949, 0.83333333333333, 0.9, 0.29166666666667
24950, 0.83333333333333, 0.95, 0.29166666666667
24951, 0.83333333333333, 1, 0.29166666666667
24952, 0.83333333333333, 1.05, 0.29166666666667
24953, 0.83333333333333, 1.1, 0.29166666666667
24954, 0.83333333333333, 1.15, 0.29166666666667
24955, 0.83333333333333, 1.2, 0.29166666666667
24956, 0.83333333333333, 1.25, 0.29166666666667
24957, 0.83333333333333, 1.3, 0.29166666666667
24958, 0.83333333333333, 0.2, 0.33333333333333
24959, 0.83333333333333, 0.25, 0.33333333333333
24960, 0.83333333333333, 0.3, 0.33333333333333
24961, 0.83333333333333, 0.35, 0.33333333333333
24962, 0.83333333333333, 0.4, 0.33333333333333
24963, 0.83333333333333, 0.45, 0.33333333333333
24964, 0.83333333333333, 0.5, 0.33333333333333
24965, 0.83333333333333, 0.55, 0.33333333333333
24966, 0.83333333333333, 0.6, 0.33333333333333
24967, 0.83333333333333, 0.65, 0.33333333333333
24968, 0.83333333333333, 0.7, 0.33333333333333
24969, 0.83333333333333, 0.75, 0.33333333333333
24970, 0.83333333333333, 0.8, 0.33333333333333
24971, 0.83333333333333, 0.85, 0.33333333333333
24972, 0.83333333333333, 0.9, 0.33333333333333
24973, 0.83333333333333, 0.95, 0.33333333333333
24974, 0.83333333333333, 1, 0.33333333333333
24975, 0.83333333333333, 1.05, 0.33333333333333
24976, 0.83333333333333, 1.1, 0.33333333333333
24977, 0.83333333333333, 1.15, 0.33333333333333
24978, 0.83333333333333, 1.2, 0.33333333333333
24979, 0.83333333333333, 1.25, 0.33333333333333
24980, 0.83333333333333, 1.3, 0.33333333333333
24981, 0.83333333333333, 0.2, 0.375
24982, 0.83333333333333, 0.25, 0.375
24983, 0.83333333333333, 0.3, 0.375
24984, 0.83333333333333, 0.35, 0.375
24985, 0.83333333333333, 0.4, 0.375
24986, 0.83333333333333, 0.45, 0.375
24987, 0.83333333333333, 0.5, 0.375
24988, 0.83333333333333, 0.55, 0.375
24989, 0.83333333333333, 0.6, 0.375
24990, 0.83333333333333, 0.65, 0.375
24991, 0.83333333333333, 0.7, 0.375
24992, 0.83333333333333, 0.75, 0.375
24993, 0.83333333333333, 0.8, 0.375
24994, 0.83333333333333, 0.85, 0.375
24995, 0.83333333333333, 0.9, 0.375
24996, 0.83333333333333, 0.95, 0.375
24997, 0.83333333333333, 1, 0.375
24998, 0.83333333333333, 1.05, 0.375
24999, 0.83333333333333, 1.1, 0.375
25000, 0.83333333333333, 1.15, 0.375
25001, 0.83333333333333, 1.2, 0.375
25002, 0.83333333333333, 1.25, 0.375
25003, 0.83333333333333, 1.3, 0.375
25004, 0.83333333333333, 0.2, 0.41666666666667
25005, 0.83333333333333, 0.25, 0.41666666666667
25006, 0.83333333333333, 0.3, 0.41666666666667
25007, 0.83333333333333, 0.35, 0.41666666666667
25008, 0.83333333333333, 0.4, 0.41666666666667
25009, 0.83333333333333, 0.45, 0.41666666666667
25010, 0.83333333333333, 0.5, 0.41666666666667
25011, 0.83333333333333, 0.55, 0.41666666666667
25012, 0.83333333333333, 0.6, 0.41666666666667
25013, 0.83333333333333, 0.65, 0.41666666666667
25014, 0.83333333333333, 0.7, 0.41666666666667
25015, 0.83333333333333, 0.75, 0.41666666666667
25016, 0.83333333333333, 0.8, 0.41666666666667
25017, 0.83333333333333, 0.85, 0.41666666666667
25018, 0.83333333333333, 0.9, 0.41666666666667
25019, 0.83333333333333, 0.95, 0.41666666666667
25020, 0.83333333333333, 1, 0.41666666666667
25021, 0.83333333333333, 1.05, 0.41666666666667
25022, 0.83333333333333, 1.1, 0.41666666666667
25023, 0.83333333333333, 1.15, 0.41666666666667
25024, 0.83333333333333, 1.2, 0.41666666666667
25025, 0.83333333333333, 1.25, 0.41666666666667
25026, 0.83333333333333, 1.3, 0.41666666666667
25027, 0.83333333333333, 0.2, 0.45833333333333
25028, 0.83333333333333, 0.25, 0.45833333333333
25029, 0.83333333333333, 0.3, 0.45833333333333
25030, 0.83333333333333, 0.35, 0.45833333333333
25031, 0.83333333333333, 0.4, 0.45833333333333
25032, 0.83333333333333, 0.45, 0.45833333333333
25033, 0.83333333333333, 0.5, 0.45833333333333
25034, 0.83333333333333, 0.55, 0.45833333333333
25035, 0.83333333333333, 0.6, 0.45833333333333
25036, 0.83333333333333, 0.65, 0.45833333333333
25037, 0.83333333333333, 0.7, 0.45833333333333
25038, 0.83333333333333, 0.75, 0.45833333333333
25039, 0.83333333333333, 0.8, 0.45833333333333
25040, 0.83333333333333, 0.85, 0.45833333333333
25041, 0.83333333333333, 0.9, 0.45833333333333
25042, 0.83333333333333, 0.95, 0.45833333333333
25043, 0.83333333333333, 1, 0.45833333333333
25044, 0.83333333333333, 1.05, 0.45833333333333
25045, 0.83333333333333, 1.1, 0.45833333333333
25046, 0.83333333333333, 1.15, 0.45833333333333
25047, 0.83333333333333, 1.2, 0.45833333333333
25048, 0.83333333333333, 1.25, 0.45833333333333
25049, 0.83333333333333, 1.3, 0.45833333333333
25050, 0.875, 0.2, 0.041666666666667
25051, 0.875, 0.25, 0.041666666666667
25052, 0.875, 0.3, 0.041666666666667
25053, 0.875, 0.35, 0.041666666666667
25054, 0.875, 0.4, 0.041666666666667
25055, 0.875, 0.45, 0.041666666666667
25056, 0.875, 0.5, 0.041666666666667
25057, 0.875, 0.55, 0.041666666666667
25058, 0.875, 0.6, 0.041666666666667
25059, 0.875, 0.65, 0.041666666666667
25060, 0.875, 0.7, 0.041666666666667
25061, 0.875, 0.75, 0.041666666666667
25062, 0.875, 0.8, 0.041666666666667
25063, 0.875, 0.85, 0.041666666666667
25064, 0.875, 0.9, 0.041666666666667
25065, 0.875, 0.95, 0.041666666666667
25066, 0.875, 1, 0.041666666666667
25067, 0.875, 1.05, 0.041666666666667
25068, 0.875, 1.1, 0.041666666666667
25069, 0.875, 1.15, 0.041666666666667
25070, 0.875, 1.2, 0.041666666666667
25071, 0.875, 1.25, 0.041666666666667
25072, 0.875, 1.3, 0.041666666666667
25073, 0.875, 0.2, 0.083333333333333
25074, 0.875, 0.25, 0.083333333333333
25075, 0.875, 0.3, 0.083333333333333
25076, 0.875, 0.35, 0.083333333333333
25077, 0.875, 0.4, 0.083333333333333
25078, 0.875, 0.45, 0.083333333333333
25079, 0.875, 0.5, 0.083333333333333
25080, 0.875, 0.55, 0.083333333333333
25081, 0.875, 0.6, 0.083333333333333
25082, 0.875, 0.65, 0.083333333333333
25083, 0.875, 0.7, 0.083333333333333
25084, 0.875, 0.75, 0.083333333333333
25085, 0.875, 0.8, 0.083333333333333
25086, 0.875, 0.85, 0.083333333333333
25087, 0.875, 0.9, 0.083333333333333
25088, 0.875, 0.95, 0.083333333333333
25089, 0.875, 1, 0.083333333333333
25090, 0.875, 1.05, 0.083333333333333
25091, 0.875, 1.1, 0.083333333333333
25092, 0.875, 1.15, 0.083333333333333
25093, 0.875, 1.2, 0.083333333333333
25094, 0.875, 1.25, 0.083333333333333
25095, 0.875, 1.3, 0.083333333333333
25096, 0.875, 0.2, 0.125
25097, 0.875, 0.25, 0.125
25098, 0.875, 0.3, 0.125
25099, 0.875, 0.35, 0.125
25100, 0.875, 0.4, 0.125
25101, 0.875, 0.45, 0.125
25102, 0.875, 0.5, 0.125
25103, 0.875, 0.55, 0.125
25104, 0.875, 0.6, 0.125
25105, 0.875, 0.65, 0.125
25106, 0.875, 0.7, 0.125
25107, 0.875, 0.75, 0.125
25108, 0.875, 0.8, 0.125
25109, 0.875, 0.85, 0.125
25110, 0.875, 0.9, 0.125
25111, 0.875, 0.95, 0.125
25112, 0.875, 1, 0.125
25113, 0.875, 1.05, 0.125
25114, 0.875, 1.1, 0.125
25115, 0.875, 1.15, 0.125
25116, 0.875, 1.2, 0.125
25117, 0.875, 1.25, 0.125
25118, 0.875, 1.3, 0.125
25119, 0.875, 0.2, 0.16666666666667
25120, 0.875, 0.25, 0.16666666666667
25121, 0.875, 0.3, 0.16666666666667
25122, 0.875, 0.35, 0.16666666666667
25123, 0.875, 0.4, 0.16666666666667
25124, 0.875, 0.45, 0.16666666666667
25125, 0.875, 0.5, 0.16666666666667
25126, 0.875, 0.55, 0.16666666666667
25127, 0.875, 0.6, 0.16666666666667
25128, 0.875, 0.65, 0.16666666666667
25129, 0.875, 0.7, 0.16666666666667
25130, 0.875, 0.75, 0.16666666666667
25131, 0.875, 0.8, 0.16666666666667
25132, 0.875, 0.85, 0.16666666666667
25133, 0.875, 0.9, 0.16666666666667
25134, 0.875, 0.95, 0.16666666666667
25135, 0.875, 1, 0.16666666666667
25136, 0.875, 1.05, 0.16666666666667
25137, 0.875, 1.1, 0.16666666666667
25138, 0.875, 1.15, 0.16666666666667
25139, 0.875, 1.2, 0.16666666666667
25140, 0.875, 1.25, 0.16666666666667
25141, 0.875, 1.3, 0.16666666666667
25142, 0.875, 0.2, 0.20833333333333
25143, 0.875, 0.25, 0.20833333333333
25144, 0.875, 0.3, 0.20833333333333
25145, 0.875, 0.35, 0.20833333333333
25146, 0.875, 0.4, 0.20833333333333
25147, 0.875, 0.45, 0.20833333333333
25148, 0.875, 0.5, 0.20833333333333
25149, 0.875, 0.55, 0.20833333333333
25150, 0.875, 0.6, 0.20833333333333
25151, 0.875, 0.65, 0.20833333333333
25152, 0.875, 0.7, 0.20833333333333
25153, 0.875, 0.75, 0.20833333333333
25154, 0.875, 0.8, 0.20833333333333
25155, 0.875, 0.85, 0.20833333333333
25156, 0.875, 0.9, 0.20833333333333
25157, 0.875, 0.95, 0.20833333333333
25158, 0.875, 1, 0.20833333333333
25159, 0.875, 1.05, 0.20833333333333
25160, 0.875, 1.1, 0.20833333333333
25161, 0.875, 1.15, 0.20833333333333
25162, 0.875, 1.2, 0.20833333333333
25163, 0.875, 1.25, 0.20833333333333
25164, 0.875, 1.3, 0.20833333333333
25165, 0.875, 0.2, 0.25
25166, 0.875, 0.25, 0.25
25167, 0.875, 0.3, 0.25
25168, 0.875, 0.35, 0.25
25169, 0.875, 0.4, 0.25
25170, 0.875, 0.45, 0.25
25171, 0.875, 0.5, 0.25
25172, 0.875, 0.55, 0.25
25173, 0.875, 0.6, 0.25
25174, 0.875, 0.65, 0.25
25175, 0.875, 0.7, 0.25
25176, 0.875, 0.75, 0.25
25177, 0.875, 0.8, 0.25
25178, 0.875, 0.85, 0.25
25179, 0.875, 0.9, 0.25
25180, 0.875, 0.95, 0.25
25181, 0.875, 1, 0.25
25182, 0.875, 1.05, 0.25
25183, 0.875, 1.1, 0.25
25184, 0.875, 1.15, 0.25
25185, 0.875, 1.2, 0.25
25186, 0.875, 1.25, 0.25
25187, 0.875, 1.3, 0.25
25188, 0.875, 0.2, 0.29166666666667
25189, 0.875, 0.25, 0.29166666666667
25190, 0.875, 0.3, 0.29166666666667
25191, 0.875, 0.35, 0.29166666666667
25192, 0.875, 0.4, 0.29166666666667
25193, 0.875, 0.45, 0.29166666666667
25194, 0.875, 0.5, 0.29166666666667
25195, 0.875, 0.55, 0.29166666666667
25196, 0.875, 0.6, 0.29166666666667
25197, 0.875, 0.65, 0.29166666666667
25198, 0.875, 0.7, 0.29166666666667
25199, 0.875, 0.75, 0.29166666666667
25200, 0.875, 0.8, 0.29166666666667
25201, 0.875, 0.85, 0.29166666666667
25202, 0.875, 0.9, 0.29166666666667
25203, 0.875, 0.95, 0.29166666666667
25204, 0.875, 1, 0.29166666666667
25205, 0.875, 1.05, 0.29166666666667
25206, 0.875, 1.1, 0.29166666666667
25207, 0.875, 1.15, 0.29166666666667
25208, 0.875, 1.2, 0.29166666666667
25209, 0.875, 1.25, 0.29166666666667
25210, 0.875, 1.3, 0.29166666666667
25211, 0.875, 0.2, 0.33333333333333
25212, 0.875, 0.25, 0.33333333333333
25213, 0.875, 0.3, 0.33333333333333
25214, 0.875, 0.35, 0.33333333333333
25215, 0.875, 0.4, 0.33333333333333
25216, 0.875, 0.45, 0.33333333333333
25217, 0.875, 0.5, 0.33333333333333
25218, 0.875, 0.55, 0.33333333333333
25219, 0.875, 0.6, 0.33333333333333
25220, 0.875, 0.65, 0.33333333333333
25221, 0.875, 0.7, 0.33333333333333
25222, 0.875, 0.75, 0.33333333333333
25223, 0.875, 0.8, 0.33333333333333
25224, 0.875, 0.85, 0.33333333333333
25225, 0.875, 0.9, 0.33333333333333
25226, 0.875, 0.95, 0.33333333333333
25227, 0.875, 1, 0.33333333333333
25228, 0.875, 1.05, 0.33333333333333
25229, 0.875, 1.1, 0.33333333333333
25230, 0.875, 1.15, 0.33333333333333
25231, 0.875, 1.2, 0.33333333333333
25232, 0.875, 1.25, 0.33333333333333
25233, 0.875, 1.3, 0.33333333333333
25234, 0.875, 0.2, 0.375
25235, 0.875, 0.25, 0.375
25236, 0.875, 0.3, 0.375
25237, 0.875, 0.35, 0.375
25238, 0.875, 0.4, 0.375
25239, 0.875, 0.45, 0.375
25240, 0.875, 0.5, 0.375
25241, 0.875, 0.55, 0.375
25242, 0.875, 0.6, 0.375
25243, 0.875, 0.65, 0.375
25244, 0.875, 0.7, 0.375
25245, 0.875, 0.75, 0.375
25246, 0.875, 0.8, 0.375
25247, 0.875, 0.85, 0.375
25248, 0.875, 0.9, 0.375
25249, 0.875, 0.95, 0.375
25250, 0.875, 1, 0.375
25251, 0.875, 1.05, 0.375
25252, 0.875, 1.1, 0.375
25253, 0.875, 1.15, 0.375
25254, 0.875, 1.2, 0.375
25255, 0.875, 1.25, 0.375
25256, 0.875, 1.3, 0.375
25257, 0.875, 0.2, 0.41666666666667
25258, 0.875, 0.25, 0.41666666666667
25259, 0.875, 0.3, 0.41666666666667
25260, 0.875, 0.35, 0.41666666666667
25261, 0.875, 0.4, 0.41666666666667
25262, 0.875, 0.45, 0.41666666666667
25263, 0.875, 0.5, 0.41666666666667
25264, 0.875, 0.55, 0.41666666666667
25265, 0.875, 0.6, 0.41666666666667
25266, 0.875, 0.65, 0.41666666666667
25267, 0.875, 0.7, 0.41666666666667
25268, 0.875, 0.75, 0.41666666666667
25269, 0.875, 0.8, 0.41666666666667
25270, 0.875, 0.85, 0.41666666666667
25271, 0.875, 0.9, 0.41666666666667
25272, 0.875, 0.95, 0.41666666666667
25273, 0.875, 1, 0.41666666666667
25274, 0.875, 1.05, 0.41666666666667
25275, 0.875, 1.1, 0.41666666666667
25276, 0.875, 1.15, 0.41666666666667
25277, 0.875, 1.2, 0.41666666666667
25278, 0.875, 1.25, 0.41666666666667
25279, 0.875, 1.3, 0.41666666666667
25280, 0.875, 0.2, 0.45833333333333
25281, 0.875, 0.25, 0.45833333333333
25282, 0.875, 0.3, 0.45833333333333
25283, 0.875, 0.35, 0.45833333333333
25284, 0.875, 0.4, 0.45833333333333
25285, 0.875, 0.45, 0.45833333333333
25286, 0.875, 0.5, 0.45833333333333
25287, 0.875, 0.55, 0.45833333333333
25288, 0.875, 0.6, 0.45833333333333
25289, 0.875, 0.65, 0.45833333333333
25290, 0.875, 0.7, 0.45833333333333
25291, 0.875, 0.75, 0.45833333333333
25292, 0.875, 0.8, 0.45833333333333
25293, 0.875, 0.85, 0.45833333333333
25294, 0.875, 0.9, 0.45833333333333
25295, 0.875, 0.95, 0.45833333333333
25296, 0.875, 1, 0.45833333333333
25297, 0.875, 1.05, 0.45833333333333
25298, 0.875, 1.1, 0.45833333333333
25299, 0.875, 1.15, 0.45833333333333
25300, 0.875, 1.2, 0.45833333333333
25301, 0.875, 1.25, 0.45833333333333
25302, 0.875, 1.3, 0.45833333333333
25303, 0.91666666666667, 0.2, 0.041666666666667
25304, 0.91666666666667, 0.25, 0.041666666666667
25305, 0.91666666666667, 0.3, 0.041666666666667
25306, 0.91666666666667, 0.35, 0.041666666666667
25307, 0.91666666666667, 0.4, 0.041666666666667
25308, 0.91666666666667, 0.45, 0.041666666666667
25309, 0.91666666666667, 0.5, 0.041666666666667
25310, 0.91666666666667, 0.55, 0.041666666666667
25311, 0.91666666666667, 0.6, 0.041666666666667
25312, 0.91666666666667, 0.65, 0.041666666666667
25313, 0.91666666666667, 0.7, 0.041666666666667
25314, 0.91666666666667, 0.75, 0.041666666666667
25315, 0.91666666666667, 0.8, 0.041666666666667
25316, 0.91666666666667, 0.85, 0.041666666666667
25317, 0.91666666666667, 0.9, 0.041666666666667
25318, 0.91666666666667, 0.95, 0.041666666666667
25319, 0.91666666666667, 1, 0.041666666666667
25320, 0.91666666666667, 1.05, 0.041666666666667
25321, 0.91666666666667, 1.1, 0.041666666666667
25322, 0.91666666666667, 1.15, 0.041666666666667
25323, 0.91666666666667, 1.2, 0.041666666666667
25324, 0.91666666666667, 1.25, 0.041666666666667
25325, 0.91666666666667, 1.3, 0.041666666666667
25326, 0.91666666666667, 0.2, 0.083333333333333
25327, 0.91666666666667, 0.25, 0.083333333333333
25328, 0.91666666666667, 0.3, 0.083333333333333
25329, 0.91666666666667, 0.35, 0.083333333333333
25330, 0.91666666666667, 0.4, 0.083333333333333
25331, 0.91666666666667, 0.45, 0.083333333333333
25332, 0.91666666666667, 0.5, 0.083333333333333
25333, 0.91666666666667, 0.55, 0.083333333333333
25334, 0.91666666666667, 0.6, 0.083333333333333
25335, 0.91666666666667, 0.65, 0.083333333333333
25336, 0.91666666666667, 0.7, 0.083333333333333
25337, 0.91666666666667, 0.75, 0.083333333333333
25338, 0.91666666666667, 0.8, 0.083333333333333
25339, 0.91666666666667, 0.85, 0.083333333333333
25340, 0.91666666666667, 0.9, 0.083333333333333
25341, 0.91666666666667, 0.95, 0.083333333333333
25342, 0.91666666666667, 1, 0.083333333333333
25343, 0.91666666666667, 1.05, 0.083333333333333
25344, 0.91666666666667, 1.1, 0.083333333333333
25345, 0.91666666666667, 1.15, 0.083333333333333
25346, 0.91666666666667, 1.2, 0.083333333333333
25347, 0.91666666666667, 1.25, 0.083333333333333
25348, 0.91666666666667, 1.3, 0.083333333333333
25349, 0.91666666666667, 0.2, 0.125
25350, 0.91666666666667, 0.25, 0.125
25351, 0.91666666666667, 0.3, 0.125
25352, 0.91666666666667, 0.35, 0.125
25353, 0.91666666666667, 0.4, 0.125
25354, 0.91666666666667, 0.45, 0.125
25355, 0.91666666666667, 0.5, 0.125
25356, 0.91666666666667, 0.55, 0.125
25357, 0.91666666666667, 0.6, 0.125
25358, 0.91666666666667, 0.65, 0.125
25359, 0.91666666666667, 0.7, 0.125
25360, 0.91666666666667, 0.75, 0.125
25361, 0.91666666666667, 0.8, 0.125
25362, 0.91666666666667, 0.85, 0.125
25363, 0.91666666666667, 0.9, 0.125
25364, 0.91666666666667, 0.95, 0.125
25365, 0.91666666666667, 1, 0.125
25366, 0.91666666666667, 1.05, 0.125
25367, 0.91666666666667, 1.1, 0.125
25368, 0.91666666666667, 1.15, 0.125
25369, 0.91666666666667, 1.2, 0.125
25370, 0.91666666666667, 1.25, 0.125
25371, 0.91666666666667, 1.3, 0.125
25372, 0.91666666666667, 0.2, 0.16666666666667
25373, 0.91666666666667, 0.25, 0.16666666666667
25374, 0.91666666666667, 0.3, 0.16666666666667
25375, 0.91666666666667, 0.35, 0.16666666666667
25376, 0.91666666666667, 0.4, 0.16666666666667
25377, 0.91666666666667, 0.45, 0.16666666666667
25378, 0.91666666666667, 0.5, 0.16666666666667
25379, 0.91666666666667, 0.55, 0.16666666666667
25380, 0.91666666666667, 0.6, 0.16666666666667
25381, 0.91666666666667, 0.65, 0.16666666666667
25382, 0.91666666666667, 0.7, 0.16666666666667
25383, 0.91666666666667, 0.75, 0.16666666666667
25384, 0.91666666666667, 0.8, 0.16666666666667
25385, 0.91666666666667, 0.85, 0.16666666666667
25386, 0.91666666666667, 0.9, 0.16666666666667
25387, 0.91666666666667, 0.95, 0.16666666666667
25388, 0.91666666666667, 1, 0.16666666666667
25389, 0.91666666666667, 1.05, 0.16666666666667
25390, 0.91666666666667, 1.1, 0.16666666666667
25391, 0.91666666666667, 1.15, 0.16666666666667
25392, 0.91666666666667, 1.2, 0.16666666666667
25393, 0.91666666666667, 1.25, 0.16666666666667
25394, 0.91666666666667, 1.3, 0.16666666666667
25395, 0.91666666666667, 0.2, 0.20833333333333
25396, 0.91666666666667, 0.25, 0.20833333333333
25397, 0.91666666666667, 0.3, 0.20833333333333
25398, 0.91666666666667, 0.35, 0.20833333333333
25399, 0.91666666666667, 0.4, 0.20833333333333
25400, 0.91666666666667, 0.45, 0.20833333333333
25401, 0.91666666666667, 0.5, 0.20833333333333
25402, 0.91666666666667, 0.55, 0.20833333333333
25403, 0.91666666666667, 0.6, 0.20833333333333
25404, 0.91666666666667, 0.65, 0.20833333333333
25405, 0.91666666666667, 0.7, 0.20833333333333
25406, 0.91666666666667, 0.75, 0.20833333333333
25407, 0.91666666666667, 0.8, 0.20833333333333
25408, 0.91666666666667, 0.85, 0.20833333333333
25409, 0.91666666666667, 0.9, 0.20833333333333
25410, 0.91666666666667, 0.95, 0.20833333333333
25411, 0.91666666666667, 1, 0.20833333333333
25412, 0.91666666666667, 1.05, 0.20833333333333
25413, 0.91666666666667, 1.1, 0.20833333333333
25414, 0.91666666666667, 1.15, 0.20833333333333
25415, 0.91666666666667, 1.2, 0.20833333333333
25416, 0.91666666666667, 1.25, 0.20833333333333
25417, 0.91666666666667, 1.3, 0.20833333333333
25418, 0.91666666666667, 0.2, 0.25
25419, 0.91666666666667, 0.25, 0.25
25420, 0.91666666666667, 0.3, 0.25
25421, 0.91666666666667, 0.35, 0.25
25422, 0.91666666666667, 0.4, 0.25
25423, 0.91666666666667, 0.45, 0.25
25424, 0.91666666666667, 0.5, 0.25
25425, 0.91666666666667, 0.55, 0.25
25426, 0.91666666666667, 0.6, 0.25
25427, 0.91666666666667, 0.65, 0.25
25428, 0.91666666666667, 0.7, 0.25
25429, 0.91666666666667, 0.75, 0.25
25430, 0.91666666666667, 0.8, 0.25
25431, 0.91666666666667, 0.85, 0.25
25432, 0.91666666666667, 0.9, 0.25
25433, 0.91666666666667, 0.95, 0.25
25434, 0.91666666666667, 1, 0.25
25435, 0.91666666666667, 1.05, 0.25
25436, 0.91666666666667, 1.1, 0.25
25437, 0.91666666666667, 1.15, 0.25
25438, 0.91666666666667, 1.2, 0.25
25439, 0.91666666666667, 1.25, 0.25
25440, 0.91666666666667, 1.3, 0.25
25441, 0.91666666666667, 0.2, 0.29166666666667
25442, 0.91666666666667, 0.25, 0.29166666666667
25443, 0.91666666666667, 0.3, 0.29166666666667
25444, 0.91666666666667, 0.35, 0.29166666666667
25445, 0.91666666666667, 0.4, 0.29166666666667
25446, 0.91666666666667, 0.45, 0.29166666666667
25447, 0.91666666666667, 0.5, 0.29166666666667
25448, 0.91666666666667, 0.55, 0.29166666666667
25449, 0.91666666666667, 0.6, 0.29166666666667
25450, 0.91666666666667, 0.65, 0.29166666666667
25451, 0.91666666666667, 0.7, 0.29166666666667
25452, 0.91666666666667, 0.75, 0.29166666666667
25453, 0.91666666666667, 0.8, 0.29166666666667
25454, 0.91666666666667, 0.85, 0.29166666666667
25455, 0.91666666666667, 0.9, 0.29166666666667
25456, 0.91666666666667, 0.95, 0.29166666666667
25457, 0.91666666666667, 1, 0.29166666666667
25458, 0.91666666666667, 1.05, 0.29166666666667
25459, 0.91666666666667, 1.1, 0.29166666666667
25460, 0.91666666666667, 1.15, 0.29166666666667
25461, 0.91666666666667, 1.2, 0.29166666666667
25462, 0.91666666666667, 1.25, 0.29166666666667
25463, 0.91666666666667, 1.3, 0.29166666666667
25464, 0.91666666666667, 0.2, 0.33333333333333
25465, 0.91666666666667, 0.25, 0.33333333333333
25466, 0.91666666666667, 0.3, 0.33333333333333
25467, 0.91666666666667, 0.35, 0.33333333333333
25468, 0.91666666666667, 0.4, 0.33333333333333
25469, 0.91666666666667, 0.45, 0.33333333333333
25470, 0.91666666666667, 0.5, 0.33333333333333
25471, 0.91666666666667, 0.55, 0.33333333333333
25472, 0.91666666666667, 0.6, 0.33333333333333
25473, 0.91666666666667, 0.65, 0.33333333333333
25474, 0.91666666666667, 0.7, 0.33333333333333
25475, 0.91666666666667, 0.75, 0.33333333333333
25476, 0.91666666666667, 0.8, 0.33333333333333
25477, 0.91666666666667, 0.85, 0.33333333333333
25478, 0.91666666666667, 0.9, 0.33333333333333
25479, 0.91666666666667, 0.95, 0.33333333333333
25480, 0.91666666666667, 1, 0.33333333333333
25481, 0.91666666666667, 1.05, 0.33333333333333
25482, 0.91666666666667, 1.1, 0.33333333333333
25483, 0.91666666666667, 1.15, 0.33333333333333
25484, 0.91666666666667, 1.2, 0.33333333333333
25485, 0.91666666666667, 1.25, 0.33333333333333
25486, 0.91666666666667, 1.3, 0.33333333333333
25487, 0.91666666666667, 0.2, 0.375
25488, 0.91666666666667, 0.25, 0.375
25489, 0.91666666666667, 0.3, 0.375
25490, 0.91666666666667, 0.35, 0.375
25491, 0.91666666666667, 0.4, 0.375
25492, 0.91666666666667, 0.45, 0.375
25493, 0.91666666666667, 0.5, 0.375
25494, 0.91666666666667, 0.55, 0.375
25495, 0.91666666666667, 0.6, 0.375
25496, 0.91666666666667, 0.65, 0.375
25497, 0.91666666666667, 0.7, 0.375
25498, 0.91666666666667, 0.75, 0.375
25499, 0.91666666666667, 0.8, 0.375
25500, 0.91666666666667, 0.85, 0.375
25501, 0.91666666666667, 0.9, 0.375
25502, 0.91666666666667, 0.95, 0.375
25503, 0.91666666666667, 1, 0.375
25504, 0.91666666666667, 1.05, 0.375
25505, 0.91666666666667, 1.1, 0.375
25506, 0.91666666666667, 1.15, 0.375
25507, 0.91666666666667, 1.2, 0.375
25508, 0.91666666666667, 1.25, 0.375
25509, 0.91666666666667, 1.3, 0.375
25510, 0.91666666666667, 0.2, 0.41666666666667
25511, 0.91666666666667, 0.25, 0.41666666666667
25512, 0.91666666666667, 0.3, 0.41666666666667
25513, 0.91666666666667, 0.35, 0.41666666666667
25514, 0.91666666666667, 0.4, 0.41666666666667
25515, 0.91666666666667, 0.45, 0.41666666666667
25516, 0.91666666666667, 0.5, 0.41666666666667
25517, 0.91666666666667, 0.55, 0.41666666666667
25518, 0.91666666666667, 0.6, 0.41666666666667
25519, 0.91666666666667, 0.65, 0.41666666666667
25520, 0.91666666666667, 0.7, 0.41666666666667
25521, 0.91666666666667, 0.75, 0.41666666666667
25522, 0.91666666666667, 0.8, 0.41666666666667
25523, 0.91666666666667, 0.85, 0.41666666666667
25524, 0.91666666666667, 0.9, 0.41666666666667
25525, 0.91666666666667, 0.95, 0.41666666666667
25526, 0.91666666666667, 1, 0.41666666666667
25527, 0.91666666666667, 1.05, 0.41666666666667
25528, 0.91666666666667, 1.1, 0.41666666666667
25529, 0.91666666666667, 1.15, 0.41666666666667
25530, 0.91666666666667, 1.2, 0.41666666666667
25531, 0.91666666666667, 1.25, 0.41666666666667
25532, 0.91666666666667, 1.3, 0.41666666666667
25533, 0.91666666666667, 0.2, 0.45833333333333
25534, 0.91666666666667, 0.25, 0.45833333333333
25535, 0.91666666666667, 0.3, 0.45833333333333
25536, 0.91666666666667, 0.35, 0.45833333333333
25537, 0.91666666666667, 0.4, 0.45833333333333
25538, 0.91666666666667, 0.45, 0.45833333333333
25539, 0.91666666666667, 0.5, 0.45833333333333
25540, 0.91666666666667, 0.55, 0.45833333333333
25541, 0.91666666666667, 0.6, 0.45833333333333
25542, 0.91666666666667, 0.65, 0.45833333333333
25543, 0.91666666666667, 0.7, 0.45833333333333
25544, 0.91666666666667, 0.75, 0.45833333333333
25545, 0.91666666666667, 0.8, 0.45833333333333
25546, 0.91666666666667, 0.85, 0.45833333333333
25547, 0.91666666666667, 0.9, 0.45833333333333
25548, 0.91666666666667, 0.95, 0.45833333333333
25549, 0.91666666666667, 1, 0.45833333333333
25550, 0.91666666666667, 1.05, 0.45833333333333
25551, 0.91666666666667, 1.1, 0.45833333333333
25552, 0.91666666666667, 1.15, 0.45833333333333
25553, 0.91666666666667, 1.2, 0.45833333333333
25554, 0.91666666666667, 1.25, 0.45833333333333
25555, 0.91666666666667, 1.3, 0.45833333333333
25556, 0.95833333333333, 0.2, 0.041666666666667
25557, 0.95833333333333, 0.25, 0.041666666666667
25558, 0.95833333333333, 0.3, 0.041666666666667
25559, 0.95833333333333, 0.35, 0.041666666666667
25560, 0.95833333333333, 0.4, 0.041666666666667
25561, 0.95833333333333, 0.45, 0.041666666666667
25562, 0.95833333333333, 0.5, 0.041666666666667
25563, 0.95833333333333, 0.55, 0.041666666666667
25564, 0.95833333333333, 0.6, 0.041666666666667
25565, 0.95833333333333, 0.65, 0.041666666666667
25566, 0.95833333333333, 0.7, 0.041666666666667
25567, 0.95833333333333, 0.75, 0.041666666666667
25568, 0.95833333333333, 0.8, 0.041666666666667
25569, 0.95833333333333, 0.85, 0.041666666666667
25570, 0.95833333333333, 0.9, 0.041666666666667
25571, 0.95833333333333, 0.95, 0.041666666666667
25572, 0.95833333333333, 1, 0.041666666666667
25573, 0.95833333333333, 1.05, 0.041666666666667
25574, 0.95833333333333, 1.1, 0.041666666666667
25575, 0.95833333333333, 1.15, 0.041666666666667
25576, 0.95833333333333, 1.2, 0.041666666666667
25577, 0.95833333333333, 1.25, 0.041666666666667
25578, 0.95833333333333, 1.3, 0.041666666666667
25579, 0.95833333333333, 0.2, 0.083333333333333
25580, 0.95833333333333, 0.25, 0.083333333333333
25581, 0.95833333333333, 0.3, 0.083333333333333
25582, 0.95833333333333, 0.35, 0.083333333333333
25583, 0.95833333333333, 0.4, 0.083333333333333
25584, 0.95833333333333, 0.45, 0.083333333333333
