30253, 1.5333333333333, 0.85, 0.29166666666667
30254, 1.5333333333333, 0.8, 0.29166666666667
30255, 1.5333333333333, 0.75, 0.29166666666667
30256, 1.5333333333333, 0.7, 0.29166666666667
30257, 1.5333333333333, 0.65, 0.29166666666667
30258, 1.5333333333333, 0.6, 0.29166666666667
30259, 1.5333333333333, 0.55, 0.29166666666667
30260, 1.5333333333333, 0.5, 0.29166666666667
30261, 1.5333333333333, 0.45, 0.29166666666667
30262, 1.5333333333333, 0.4, 0.29166666666667
30263, 1.5333333333333, 0.35, 0.29166666666667
30264, 1.5333333333333, 0.3, 0.29166666666667
30265, 1.5333333333333, 0.25, 0.29166666666667
30266, 1.5333333333333, 0.2, 0.29166666666667
30267, 1.575, 1.3, 0.29166666666667
30268, 1.575, 1.25, 0.29166666666667
30269, 1.575, 1.2, 0.29166666666667
30270, 1.575, 1.15, 0.29166666666667
30271, 1.575, 1.1, 0.29166666666667
30272, 1.575, 1.05, 0.29166666666667
30273, 1.575, 1, 0.29166666666667
30274, 1.575, 0.95, 0.29166666666667
30275, 1.575, 0.9, 0.29166666666667
30276, 1.575, 0.85, 0.29166666666667
30277, 1.575, 0.8, 0.29166666666667
30278, 1.575, 0.75, 0.29166666666667
30279, 1.575, 0.7, 0.29166666666667
30280, 1.575, 0.65, 0.29166666666667
30281, 1.575, 0.6, 0.29166666666667
30282, 1.575, 0.55, 0.29166666666667
30283, 1.575, 0.5, 0.29166666666667
30284, 1.575, 0.45, 0.29166666666667
30285, 1.575, 0.4, 0.29166666666667
30286, 1.575, 0.35, 0.29166666666667
30287, 1.575, 0.3, 0.29166666666667
30288, 1.575, 0.25, 0.29166666666667
30289, 1.575, 0.2, 0.29166666666667
30290, 1.6166666666667, 1.3, 0.29166666666667
30291, 1.6166666666667, 1.25, 0.29166666666667
30292, 1.6166666666667, 1.2, 0.29166666666667
30293, 1.6166666666667, 1.15, 0.29166666666667
30294, 1.6166666666667, 1.1, 0.29166666666667
30295, 1.6166666666667, 1.05, 0.29166666666667
30296, 1.6166666666667, 1, 0.29166666666667
30297, 1.6166666666667, 0.95, 0.29166666666667
30298, 1.6166666666667, 0.9, 0.29166666666667
30299, 1.6166666666667, 0.85, 0.29166666666667
30300, 1.6166666666667, 0.8, 0.29166666666667
30301, 1.6166666666667, 0.75, 0.29166666666667
30302, 1.6166666666667, 0.7, 0.29166666666667
30303, 1.6166666666667, 0.65, 0.29166666666667
30304, 1.6166666666667, 0.6, 0.29166666666667
30305, 1.6166666666667, 0.55, 0.29166666666667
30306, 1.6166666666667, 0.5, 0.29166666666667
30307, 1.6166666666667, 0.45, 0.29166666666667
30308, 1.6166666666667, 0.4, 0.29166666666667
30309, 1.6166666666667, 0.35, 0.29166666666667
30310, 1.6166666666667, 0.3, 0.29166666666667
30311, 1.6166666666667, 0.25, 0.29166666666667
30312, 1.6166666666667, 0.2, 0.29166666666667
30313, 1.6583333333333, 1.3, 0.29166666666667
30314, 1.6583333333333, 1.25, 0.29166666666667
30315, 1.6583333333333, 1.2, 0.29166666666667
30316, 1.6583333333333, 1.15, 0.29166666666667
30317, 1.6583333333333, 1.1, 0.29166666666667
30318, 1.6583333333333, 1.05, 0.29166666666667
30319, 1.6583333333333, 1, 0.29166666666667
30320, 1.6583333333333, 0.95, 0.29166666666667
30321, 1.6583333333333, 0.9, 0.29166666666667
30322, 1.6583333333333, 0.85, 0.29166666666667
30323, 1.6583333333333, 0.8, 0.29166666666667
30324, 1.6583333333333, 0.75, 0.29166666666667
30325, 1.6583333333333, 0.7, 0.29166666666667
30326, 1.6583333333333, 0.65, 0.29166666666667
30327, 1.6583333333333, 0.6, 0.29166666666667
30328, 1.6583333333333, 0.55, 0.29166666666667
30329, 1.6583333333333, 0.5, 0.29166666666667
30330, 1.6583333333333, 0.45, 0.29166666666667
30331, 1.6583333333333, 0.4, 0.29166666666667
30332, 1.6583333333333, 0.35, 0.29166666666667
30333, 1.6583333333333, 0.3, 0.29166666666667
30334, 1.6583333333333, 0.25, 0.29166666666667
30335, 1.6583333333333, 0.2, 0.29166666666667
30336, 1.7, 1.3, 0.29166666666667
30337, 1.7, 1.25, 0.29166666666667
30338, 1.7, 1.2, 0.29166666666667
30339, 1.7, 1.15, 0.29166666666667
30340, 1.7, 1.1, 0.29166666666667
30341, 1.7, 1.05, 0.29166666666667
30342, 1.7, 1, 0.29166666666667
30343, 1.7, 0.95, 0.29166666666667
30344, 1.7, 0.9, 0.29166666666667
30345, 1.7, 0.85, 0.29166666666667
30346, 1.7, 0.8, 0.29166666666667
30347, 1.7, 0.75, 0.29166666666667
30348, 1.7, 0.7, 0.29166666666667
30349, 1.7, 0.65, 0.29166666666667
30350, 1.7, 0.6, 0.29166666666667
30351, 1.7, 0.55, 0.29166666666667
30352, 1.7, 0.5, 0.29166666666667
30353, 1.7, 0.45, 0.29166666666667
30354, 1.7, 0.4, 0.29166666666667
30355, 1.7, 0.35, 0.29166666666667
30356, 1.7, 0.3, 0.29166666666667
30357, 1.7, 0.25, 0.29166666666667
30358, 1.7, 0.2, 0.29166666666667
30359, 1.7416666666667, 1.3, 0.29166666666667
30360, 1.7416666666667, 1.25, 0.29166666666667
30361, 1.7416666666667, 1.2, 0.29166666666667
30362, 1.7416666666667, 1.15, 0.29166666666667
30363, 1.7416666666667, 1.1, 0.29166666666667
30364, 1.7416666666667, 1.05, 0.29166666666667
30365, 1.7416666666667, 1, 0.29166666666667
30366, 1.7416666666667, 0.95, 0.29166666666667
30367, 1.7416666666667, 0.9, 0.29166666666667
30368, 1.7416666666667, 0.85, 0.29166666666667
30369, 1.7416666666667, 0.8, 0.29166666666667
30370, 1.7416666666667, 0.75, 0.29166666666667
30371, 1.7416666666667, 0.7, 0.29166666666667
30372, 1.7416666666667, 0.65, 0.29166666666667
30373, 1.7416666666667, 0.6, 0.29166666666667
30374, 1.7416666666667, 0.55, 0.29166666666667
30375, 1.7416666666667, 0.5, 0.29166666666667
30376, 1.7416666666667, 0.45, 0.29166666666667
30377, 1.7416666666667, 0.4, 0.29166666666667
30378, 1.7416666666667, 0.35, 0.29166666666667
30379, 1.7416666666667, 0.3, 0.29166666666667
30380, 1.7416666666667, 0.25, 0.29166666666667
30381, 1.7416666666667, 0.2, 0.29166666666667
30382, 1.7833333333333, 1.3, 0.29166666666667
30383, 1.7833333333333, 1.25, 0.29166666666667
30384, 1.7833333333333, 1.2, 0.29166666666667
30385, 1.7833333333333, 1.15, 0.29166666666667
30386, 1.7833333333333, 1.1, 0.29166666666667
30387, 1.7833333333333, 1.05, 0.29166666666667
30388, 1.7833333333333, 1, 0.29166666666667
30389, 1.7833333333333, 0.95, 0.29166666666667
30390, 1.7833333333333, 0.9, 0.29166666666667
30391, 1.7833333333333, 0.85, 0.29166666666667
30392, 1.7833333333333, 0.8, 0.29166666666667
30393, 1.7833333333333, 0.75, 0.29166666666667
30394, 1.7833333333333, 0.7, 0.29166666666667
30395, 1.7833333333333, 0.65, 0.29166666666667
30396, 1.7833333333333, 0.6, 0.29166666666667
30397, 1.7833333333333, 0.55, 0.29166666666667
30398, 1.7833333333333, 0.5, 0.29166666666667
30399, 1.7833333333333, 0.45, 0.29166666666667
30400, 1.7833333333333, 0.4, 0.29166666666667
30401, 1.7833333333333, 0.35, 0.29166666666667
30402, 1.7833333333333, 0.3, 0.29166666666667
30403, 1.7833333333333, 0.25, 0.29166666666667
30404, 1.7833333333333, 0.2, 0.29166666666667
30405, 1.825, 1.3, 0.29166666666667
30406, 1.825, 1.25, 0.29166666666667
30407, 1.825, 1.2, 0.29166666666667
30408, 1.825, 1.15, 0.29166666666667
30409, 1.825, 1.1, 0.29166666666667
30410, 1.825, 1.05, 0.29166666666667
30411, 1.825, 1, 0.29166666666667
30412, 1.825, 0.95, 0.29166666666667
30413, 1.825, 0.9, 0.29166666666667
30414, 1.825, 0.85, 0.29166666666667
30415, 1.825, 0.8, 0.29166666666667
30416, 1.825, 0.75, 0.29166666666667
30417, 1.825, 0.7, 0.29166666666667
30418, 1.825, 0.65, 0.29166666666667
30419, 1.825, 0.6, 0.29166666666667
30420, 1.825, 0.55, 0.29166666666667
30421, 1.825, 0.5, 0.29166666666667
30422, 1.825, 0.45, 0.29166666666667
30423, 1.825, 0.4, 0.29166666666667
30424, 1.825, 0.35, 0.29166666666667
30425, 1.825, 0.3, 0.29166666666667
30426, 1.825, 0.25, 0.29166666666667
30427, 1.825, 0.2, 0.29166666666667
30428, 1.8666666666667, 1.3, 0.29166666666667
30429, 1.8666666666667, 1.25, 0.29166666666667
30430, 1.8666666666667, 1.2, 0.29166666666667
30431, 1.8666666666667, 1.15, 0.29166666666667
30432, 1.8666666666667, 1.1, 0.29166666666667
30433, 1.8666666666667, 1.05, 0.29166666666667
30434, 1.8666666666667, 1, 0.29166666666667
30435, 1.8666666666667, 0.95, 0.29166666666667
30436, 1.8666666666667, 0.9, 0.29166666666667
30437, 1.8666666666667, 0.85, 0.29166666666667
30438, 1.8666666666667, 0.8, 0.29166666666667
30439, 1.8666666666667, 0.75, 0.29166666666667
30440, 1.8666666666667, 0.7, 0.29166666666667
30441, 1.8666666666667, 0.65, 0.29166666666667
30442, 1.8666666666667, 0.6, 0.29166666666667
30443, 1.8666666666667, 0.55, 0.29166666666667
30444, 1.8666666666667, 0.5, 0.29166666666667
30445, 1.8666666666667, 0.45, 0.29166666666667
30446, 1.8666666666667, 0.4, 0.29166666666667
30447, 1.8666666666667, 0.35, 0.29166666666667
30448, 1.8666666666667, 0.3, 0.29166666666667
30449, 1.8666666666667, 0.25, 0.29166666666667
30450, 1.8666666666667, 0.2, 0.29166666666667
30451, 1.9083333333333, 1.3, 0.29166666666667
30452, 1.9083333333333, 1.25, 0.29166666666667
30453, 1.9083333333333, 1.2, 0.29166666666667
30454, 1.9083333333333, 1.15, 0.29166666666667
30455, 1.9083333333333, 1.1, 0.29166666666667
30456, 1.9083333333333, 1.05, 0.29166666666667
30457, 1.9083333333333, 1, 0.29166666666667
30458, 1.9083333333333, 0.95, 0.29166666666667
30459, 1.9083333333333, 0.9, 0.29166666666667
30460, 1.9083333333333, 0.85, 0.29166666666667
30461, 1.9083333333333, 0.8, 0.29166666666667
30462, 1.9083333333333, 0.75, 0.29166666666667
30463, 1.9083333333333, 0.7, 0.29166666666667
30464, 1.9083333333333, 0.65, 0.29166666666667
30465, 1.9083333333333, 0.6, 0.29166666666667
30466, 1.9083333333333, 0.55, 0.29166666666667
30467, 1.9083333333333, 0.5, 0.29166666666667
30468, 1.9083333333333, 0.45, 0.29166666666667
30469, 1.9083333333333, 0.4, 0.29166666666667
30470, 1.9083333333333, 0.35, 0.29166666666667
30471, 1.9083333333333, 0.3, 0.29166666666667
30472, 1.9083333333333, 0.25, 0.29166666666667
30473, 1.9083333333333, 0.2, 0.29166666666667
30474, 1.95, 1.3, 0.29166666666667
30475, 1.95, 1.25, 0.29166666666667
30476, 1.95, 1.2, 0.29166666666667
30477, 1.95, 1.15, 0.29166666666667
30478, 1.95, 1.1, 0.29166666666667
30479, 1.95, 1.05, 0.29166666666667
30480, 1.95, 1, 0.29166666666667
30481, 1.95, 0.95, 0.29166666666667
30482, 1.95, 0.9, 0.29166666666667
30483, 1.95, 0.85, 0.29166666666667
30484, 1.95, 0.8, 0.29166666666667
30485, 1.95, 0.75, 0.29166666666667
30486, 1.95, 0.7, 0.29166666666667
30487, 1.95, 0.65, 0.29166666666667
30488, 1.95, 0.6, 0.29166666666667
30489, 1.95, 0.55, 0.29166666666667
30490, 1.95, 0.5, 0.29166666666667
30491, 1.95, 0.45, 0.29166666666667
30492, 1.95, 0.4, 0.29166666666667
30493, 1.95, 0.35, 0.29166666666667
30494, 1.95, 0.3, 0.29166666666667
30495, 1.95, 0.25, 0.29166666666667
30496, 1.95, 0.2, 0.29166666666667
30497, 1.9916666666667, 1.3, 0.29166666666667
30498, 1.9916666666667, 1.25, 0.29166666666667
30499, 1.9916666666667, 1.2, 0.29166666666667
30500, 1.9916666666667, 1.15, 0.29166666666667
30501, 1.9916666666667, 1.1, 0.29166666666667
30502, 1.9916666666667, 1.05, 0.29166666666667
30503, 1.9916666666667, 1, 0.29166666666667
30504, 1.9916666666667, 0.95, 0.29166666666667
30505, 1.9916666666667, 0.9, 0.29166666666667
30506, 1.9916666666667, 0.85, 0.29166666666667
30507, 1.9916666666667, 0.8, 0.29166666666667
30508, 1.9916666666667, 0.75, 0.29166666666667
30509, 1.9916666666667, 0.7, 0.29166666666667
30510, 1.9916666666667, 0.65, 0.29166666666667
30511, 1.9916666666667, 0.6, 0.29166666666667
30512, 1.9916666666667, 0.55, 0.29166666666667
30513, 1.9916666666667, 0.5, 0.29166666666667
30514, 1.9916666666667, 0.45, 0.29166666666667
30515, 1.9916666666667, 0.4, 0.29166666666667
30516, 1.9916666666667, 0.35, 0.29166666666667
30517, 1.9916666666667, 0.3, 0.29166666666667
30518, 1.9916666666667, 0.25, 0.29166666666667
30519, 1.9916666666667, 0.2, 0.29166666666667
30520, 2.0333333333333, 1.3, 0.29166666666667
30521, 2.0333333333333, 1.25, 0.29166666666667
30522, 2.0333333333333, 1.2, 0.29166666666667
30523, 2.0333333333333, 1.15, 0.29166666666667
30524, 2.0333333333333, 1.1, 0.29166666666667
30525, 2.0333333333333, 1.05, 0.29166666666667
30526, 2.0333333333333, 1, 0.29166666666667
30527, 2.0333333333333, 0.95, 0.29166666666667
30528, 2.0333333333333, 0.9, 0.29166666666667
30529, 2.0333333333333, 0.85, 0.29166666666667
30530, 2.0333333333333, 0.8, 0.29166666666667
30531, 2.0333333333333, 0.75, 0.29166666666667
30532, 2.0333333333333, 0.7, 0.29166666666667
30533, 2.0333333333333, 0.65, 0.29166666666667
30534, 2.0333333333333, 0.6, 0.29166666666667
30535, 2.0333333333333, 0.55, 0.29166666666667
30536, 2.0333333333333, 0.5, 0.29166666666667
30537, 2.0333333333333, 0.45, 0.29166666666667
30538, 2.0333333333333, 0.4, 0.29166666666667
30539, 2.0333333333333, 0.35, 0.29166666666667
30540, 2.0333333333333, 0.3, 0.29166666666667
30541, 2.0333333333333, 0.25, 0.29166666666667
30542, 2.0333333333333, 0.2, 0.29166666666667
30543, 2.075, 1.3, 0.29166666666667
30544, 2.075, 1.25, 0.29166666666667
30545, 2.075, 1.2, 0.29166666666667
30546, 2.075, 1.15, 0.29166666666667
30547, 2.075, 1.1, 0.29166666666667
30548, 2.075, 1.05, 0.29166666666667
30549, 2.075, 1, 0.29166666666667
30550, 2.075, 0.95, 0.29166666666667
30551, 2.075, 0.9, 0.29166666666667
30552, 2.075, 0.85, 0.29166666666667
30553, 2.075, 0.8, 0.29166666666667
30554, 2.075, 0.75, 0.29166666666667
30555, 2.075, 0.7, 0.29166666666667
30556, 2.075, 0.65, 0.29166666666667
30557, 2.075, 0.6, 0.29166666666667
30558, 2.075, 0.55, 0.29166666666667
30559, 2.075, 0.5, 0.29166666666667
30560, 2.075, 0.45, 0.29166666666667
30561, 2.075, 0.4, 0.29166666666667
30562, 2.075, 0.35, 0.29166666666667
30563, 2.075, 0.3, 0.29166666666667
30564, 2.075, 0.25, 0.29166666666667
30565, 2.075, 0.2, 0.29166666666667
30566, 2.1166666666667, 1.3, 0.29166666666667
30567, 2.1166666666667, 1.25, 0.29166666666667
30568, 2.1166666666667, 1.2, 0.29166666666667
30569, 2.1166666666667, 1.15, 0.29166666666667
30570, 2.1166666666667, 1.1, 0.29166666666667
30571, 2.1166666666667, 1.05, 0.29166666666667
30572, 2.1166666666667, 1, 0.29166666666667
30573, 2.1166666666667, 0.95, 0.29166666666667
30574, 2.1166666666667, 0.9, 0.29166666666667
30575, 2.1166666666667, 0.85, 0.29166666666667
30576, 2.1166666666667, 0.8, 0.29166666666667
30577, 2.1166666666667, 0.75, 0.29166666666667
30578, 2.1166666666667, 0.7, 0.29166666666667
30579, 2.1166666666667, 0.65, 0.29166666666667
30580, 2.1166666666667, 0.6, 0.29166666666667
30581, 2.1166666666667, 0.55, 0.29166666666667
30582, 2.1166666666667, 0.5, 0.29166666666667
30583, 2.1166666666667, 0.45, 0.29166666666667
30584, 2.1166666666667, 0.4, 0.29166666666667
30585, 2.1166666666667, 0.35, 0.29166666666667
30586, 2.1166666666667, 0.3, 0.29166666666667
30587, 2.1166666666667, 0.25, 0.29166666666667
30588, 2.1166666666667, 0.2, 0.29166666666667
30589, 2.1583333333333, 1.3, 0.29166666666667
30590, 2.1583333333333, 1.25, 0.29166666666667
30591, 2.1583333333333, 1.2, 0.29166666666667
30592, 2.1583333333333, 1.15, 0.29166666666667
30593, 2.1583333333333, 1.1, 0.29166666666667
30594, 2.1583333333333, 1.05, 0.29166666666667
30595, 2.1583333333333, 1, 0.29166666666667
30596, 2.1583333333333, 0.95, 0.29166666666667
30597, 2.1583333333333, 0.9, 0.29166666666667
30598, 2.1583333333333, 0.85, 0.29166666666667
30599, 2.1583333333333, 0.8, 0.29166666666667
30600, 2.1583333333333, 0.75, 0.29166666666667
30601, 2.1583333333333, 0.7, 0.29166666666667
30602, 2.1583333333333, 0.65, 0.29166666666667
30603, 2.1583333333333, 0.6, 0.29166666666667
30604, 2.1583333333333, 0.55, 0.29166666666667
30605, 2.1583333333333, 0.5, 0.29166666666667
30606, 2.1583333333333, 0.45, 0.29166666666667
30607, 2.1583333333333, 0.4, 0.29166666666667
30608, 2.1583333333333, 0.35, 0.29166666666667
30609, 2.1583333333333, 0.3, 0.29166666666667
30610, 2.1583333333333, 0.25, 0.29166666666667
30611, 2.1583333333333, 0.2, 0.29166666666667
30612, 1.2416666666667, 1.3, 0.33333333333333
30613, 1.2416666666667, 1.25, 0.33333333333333
30614, 1.2416666666667, 1.2, 0.33333333333333
30615, 1.2416666666667, 1.15, 0.33333333333333
30616, 1.2416666666667, 1.1, 0.33333333333333
30617, 1.2416666666667, 1.05, 0.33333333333333
30618, 1.2416666666667, 1, 0.33333333333333
30619, 1.2416666666667, 0.95, 0.33333333333333
30620, 1.2416666666667, 0.9, 0.33333333333333
30621, 1.2416666666667, 0.85, 0.33333333333333
30622, 1.2416666666667, 0.8, 0.33333333333333
30623, 1.2416666666667, 0.75, 0.33333333333333
30624, 1.2416666666667, 0.7, 0.33333333333333
30625, 1.2416666666667, 0.65, 0.33333333333333
30626, 1.2416666666667, 0.6, 0.33333333333333
30627, 1.2416666666667, 0.55, 0.33333333333333
30628, 1.2416666666667, 0.5, 0.33333333333333
30629, 1.2416666666667, 0.45, 0.33333333333333
30630, 1.2416666666667, 0.4, 0.33333333333333
30631, 1.2416666666667, 0.35, 0.33333333333333
30632, 1.2416666666667, 0.3, 0.33333333333333
30633, 1.2416666666667, 0.25, 0.33333333333333
30634, 1.2416666666667, 0.2, 0.33333333333333
30635, 1.2833333333333, 1.3, 0.33333333333333
30636, 1.2833333333333, 1.25, 0.33333333333333
30637, 1.2833333333333, 1.2, 0.33333333333333
30638, 1.2833333333333, 1.15, 0.33333333333333
30639, 1.2833333333333, 1.1, 0.33333333333333
30640, 1.2833333333333, 1.05, 0.33333333333333
30641, 1.2833333333333, 1, 0.33333333333333
30642, 1.2833333333333, 0.95, 0.33333333333333
30643, 1.2833333333333, 0.9, 0.33333333333333
30644, 1.2833333333333, 0.85, 0.33333333333333
30645, 1.2833333333333, 0.8, 0.33333333333333
30646, 1.2833333333333, 0.75, 0.33333333333333
30647, 1.2833333333333, 0.7, 0.33333333333333
30648, 1.2833333333333, 0.65, 0.33333333333333
30649, 1.2833333333333, 0.6, 0.33333333333333
30650, 1.2833333333333, 0.55, 0.33333333333333
30651, 1.2833333333333, 0.5, 0.33333333333333
30652, 1.2833333333333, 0.45, 0.33333333333333
30653, 1.2833333333333, 0.4, 0.33333333333333
30654, 1.2833333333333, 0.35, 0.33333333333333
30655, 1.2833333333333, 0.3, 0.33333333333333
30656, 1.2833333333333, 0.25, 0.33333333333333
30657, 1.2833333333333, 0.2, 0.33333333333333
30658, 1.325, 1.3, 0.33333333333333
30659, 1.325, 1.25, 0.33333333333333
30660, 1.325, 1.2, 0.33333333333333
30661, 1.325, 1.15, 0.33333333333333
30662, 1.325, 1.1, 0.33333333333333
30663, 1.325, 1.05, 0.33333333333333
30664, 1.325, 1, 0.33333333333333
30665, 1.325, 0.95, 0.33333333333333
30666, 1.325, 0.9, 0.33333333333333
30667, 1.325, 0.85, 0.33333333333333
30668, 1.325, 0.8, 0.33333333333333
30669, 1.325, 0.75, 0.33333333333333
30670, 1.325, 0.7, 0.33333333333333
30671, 1.325, 0.65, 0.33333333333333
30672, 1.325, 0.6, 0.33333333333333
30673, 1.325, 0.55, 0.33333333333333
30674, 1.325, 0.5, 0.33333333333333
30675, 1.325, 0.45, 0.33333333333333
30676, 1.325, 0.4, 0.33333333333333
30677, 1.325, 0.35, 0.33333333333333
30678, 1.325, 0.3, 0.33333333333333
30679, 1.325, 0.25, 0.33333333333333
30680, 1.325, 0.2, 0.33333333333333
30681, 1.3666666666667, 1.3, 0.33333333333333
30682, 1.3666666666667, 1.25, 0.33333333333333
30683, 1.3666666666667, 1.2, 0.33333333333333
30684, 1.3666666666667, 1.15, 0.33333333333333
30685, 1.3666666666667, 1.1, 0.33333333333333
30686, 1.3666666666667, 1.05, 0.33333333333333
30687, 1.3666666666667, 1, 0.33333333333333
30688, 1.3666666666667, 0.95, 0.33333333333333
30689, 1.3666666666667, 0.9, 0.33333333333333
30690, 1.3666666666667, 0.85, 0.33333333333333
30691, 1.3666666666667, 0.8, 0.33333333333333
30692, 1.3666666666667, 0.75, 0.33333333333333
30693, 1.3666666666667, 0.7, 0.33333333333333
30694, 1.3666666666667, 0.65, 0.33333333333333
30695, 1.3666666666667, 0.6, 0.33333333333333
30696, 1.3666666666667, 0.55, 0.33333333333333
30697, 1.3666666666667, 0.5, 0.33333333333333
30698, 1.3666666666667, 0.45, 0.33333333333333
30699, 1.3666666666667, 0.4, 0.33333333333333
30700, 1.3666666666667, 0.35, 0.33333333333333
30701, 1.3666666666667, 0.3, 0.33333333333333
30702, 1.3666666666667, 0.25, 0.33333333333333
30703, 1.3666666666667, 0.2, 0.33333333333333
30704, 1.4083333333333, 1.3, 0.33333333333333
30705, 1.4083333333333, 1.25, 0.33333333333333
30706, 1.4083333333333, 1.2, 0.33333333333333
30707, 1.4083333333333, 1.15, 0.33333333333333
30708, 1.4083333333333, 1.1, 0.33333333333333
30709, 1.4083333333333, 1.05, 0.33333333333333
30710, 1.4083333333333, 1, 0.33333333333333
30711, 1.4083333333333, 0.95, 0.33333333333333
30712, 1.4083333333333, 0.9, 0.33333333333333
30713, 1.4083333333333, 0.85, 0.33333333333333
30714, 1.4083333333333, 0.8, 0.33333333333333
30715, 1.4083333333333, 0.75, 0.33333333333333
30716, 1.4083333333333, 0.7, 0.33333333333333
30717, 1.4083333333333, 0.65, 0.33333333333333
30718, 1.4083333333333, 0.6, 0.33333333333333
30719, 1.4083333333333, 0.55, 0.33333333333333
30720, 1.4083333333333, 0.5, 0.33333333333333
30721, 1.4083333333333, 0.45, 0.33333333333333
30722, 1.4083333333333, 0.4, 0.33333333333333
30723, 1.4083333333333, 0.35, 0.33333333333333
30724, 1.4083333333333, 0.3, 0.33333333333333
30725, 1.4083333333333, 0.25, 0.33333333333333
30726, 1.4083333333333, 0.2, 0.33333333333333
30727, 1.45, 1.3, 0.33333333333333
30728, 1.45, 1.25, 0.33333333333333
30729, 1.45, 1.2, 0.33333333333333
30730, 1.45, 1.15, 0.33333333333333
30731, 1.45, 1.1, 0.33333333333333
30732, 1.45, 1.05, 0.33333333333333
30733, 1.45, 1, 0.33333333333333
30734, 1.45, 0.95, 0.33333333333333
30735, 1.45, 0.9, 0.33333333333333
30736, 1.45, 0.85, 0.33333333333333
30737, 1.45, 0.8, 0.33333333333333
30738, 1.45, 0.75, 0.33333333333333
30739, 1.45, 0.7, 0.33333333333333
30740, 1.45, 0.65, 0.33333333333333
30741, 1.45, 0.6, 0.33333333333333
30742, 1.45, 0.55, 0.33333333333333
30743, 1.45, 0.5, 0.33333333333333
30744, 1.45, 0.45, 0.33333333333333
30745, 1.45, 0.4, 0.33333333333333
30746, 1.45, 0.35, 0.33333333333333
30747, 1.45, 0.3, 0.33333333333333
30748, 1.45, 0.25, 0.33333333333333
30749, 1.45, 0.2, 0.33333333333333
30750, 1.4916666666667, 1.3, 0.33333333333333
30751, 1.4916666666667, 1.25, 0.33333333333333
30752, 1.4916666666667, 1.2, 0.33333333333333
30753, 1.4916666666667, 1.15, 0.33333333333333
30754, 1.4916666666667, 1.1, 0.33333333333333
30755, 1.4916666666667, 1.05, 0.33333333333333
30756, 1.4916666666667, 1, 0.33333333333333
30757, 1.4916666666667, 0.95, 0.33333333333333
30758, 1.4916666666667, 0.9, 0.33333333333333
30759, 1.4916666666667, 0.85, 0.33333333333333
30760, 1.4916666666667, 0.8, 0.33333333333333
30761, 1.4916666666667, 0.75, 0.33333333333333
30762, 1.4916666666667, 0.7, 0.33333333333333
30763, 1.4916666666667, 0.65, 0.33333333333333
30764, 1.4916666666667, 0.6, 0.33333333333333
30765, 1.4916666666667, 0.55, 0.33333333333333
30766, 1.4916666666667, 0.5, 0.33333333333333
30767, 1.4916666666667, 0.45, 0.33333333333333
30768, 1.4916666666667, 0.4, 0.33333333333333
30769, 1.4916666666667, 0.35, 0.33333333333333
30770, 1.4916666666667, 0.3, 0.33333333333333
30771, 1.4916666666667, 0.25, 0.33333333333333
30772, 1.4916666666667, 0.2, 0.33333333333333
30773, 1.5333333333333, 1.3, 0.33333333333333
30774, 1.5333333333333, 1.25, 0.33333333333333
30775, 1.5333333333333, 1.2, 0.33333333333333
30776, 1.5333333333333, 1.15, 0.33333333333333
30777, 1.5333333333333, 1.1, 0.33333333333333
30778, 1.5333333333333, 1.05, 0.33333333333333
30779, 1.5333333333333, 1, 0.33333333333333
30780, 1.5333333333333, 0.95, 0.33333333333333
30781, 1.5333333333333, 0.9, 0.33333333333333
30782, 1.5333333333333, 0.85, 0.33333333333333
30783, 1.5333333333333, 0.8, 0.33333333333333
30784, 1.5333333333333, 0.75, 0.33333333333333
30785, 1.5333333333333, 0.7, 0.33333333333333
30786, 1.5333333333333, 0.65, 0.33333333333333
30787, 1.5333333333333, 0.6, 0.33333333333333
30788, 1.5333333333333, 0.55, 0.33333333333333
30789, 1.5333333333333, 0.5, 0.33333333333333
30790, 1.5333333333333, 0.45, 0.33333333333333
30791, 1.5333333333333, 0.4, 0.33333333333333
30792, 1.5333333333333, 0.35, 0.33333333333333
30793, 1.5333333333333, 0.3, 0.33333333333333
30794, 1.5333333333333, 0.25, 0.33333333333333
30795, 1.5333333333333, 0.2, 0.33333333333333
30796, 1.575, 1.3, 0.33333333333333
30797, 1.575, 1.25, 0.33333333333333
30798, 1.575, 1.2, 0.33333333333333
30799, 1.575, 1.15, 0.33333333333333
30800, 1.575, 1.1, 0.33333333333333
30801, 1.575, 1.05, 0.33333333333333
30802, 1.575, 1, 0.33333333333333
30803, 1.575, 0.95, 0.33333333333333
30804, 1.575, 0.9, 0.33333333333333
30805, 1.575, 0.85, 0.33333333333333
30806, 1.575, 0.8, 0.33333333333333
30807, 1.575, 0.75, 0.33333333333333
30808, 1.575, 0.7, 0.33333333333333
30809, 1.575, 0.65, 0.33333333333333
30810, 1.575, 0.6, 0.33333333333333
30811, 1.575, 0.55, 0.33333333333333
30812, 1.575, 0.5, 0.33333333333333
30813, 1.575, 0.45, 0.33333333333333
30814, 1.575, 0.4, 0.33333333333333
30815, 1.575, 0.35, 0.33333333333333
30816, 1.575, 0.3, 0.33333333333333
30817, 1.575, 0.25, 0.33333333333333
30818, 1.575, 0.2, 0.33333333333333
30819, 1.6166666666667, 1.3, 0.33333333333333
30820, 1.6166666666667, 1.25, 0.33333333333333
30821, 1.6166666666667, 1.2, 0.33333333333333
30822, 1.6166666666667, 1.15, 0.33333333333333
30823, 1.6166666666667, 1.1, 0.33333333333333
30824, 1.6166666666667, 1.05, 0.33333333333333
30825, 1.6166666666667, 1, 0.33333333333333
30826, 1.6166666666667, 0.95, 0.33333333333333
30827, 1.6166666666667, 0.9, 0.33333333333333
30828, 1.6166666666667, 0.85, 0.33333333333333
30829, 1.6166666666667, 0.8, 0.33333333333333
30830, 1.6166666666667, 0.75, 0.33333333333333
30831, 1.6166666666667, 0.7, 0.33333333333333
30832, 1.6166666666667, 0.65, 0.33333333333333
30833, 1.6166666666667, 0.6, 0.33333333333333
30834, 1.6166666666667, 0.55, 0.33333333333333
30835, 1.6166666666667, 0.5, 0.33333333333333
30836, 1.6166666666667, 0.45, 0.33333333333333
30837, 1.6166666666667, 0.4, 0.33333333333333
30838, 1.6166666666667, 0.35, 0.33333333333333
30839, 1.6166666666667, 0.3, 0.33333333333333
30840, 1.6166666666667, 0.25, 0.33333333333333
30841, 1.6166666666667, 0.2, 0.33333333333333
30842, 1.6583333333333, 1.3, 0.33333333333333
30843, 1.6583333333333, 1.25, 0.33333333333333
30844, 1.6583333333333, 1.2, 0.33333333333333
30845, 1.6583333333333, 1.15, 0.33333333333333
30846, 1.6583333333333, 1.1, 0.33333333333333
30847, 1.6583333333333, 1.05, 0.33333333333333
30848, 1.6583333333333, 1, 0.33333333333333
30849, 1.6583333333333, 0.95, 0.33333333333333
30850, 1.6583333333333, 0.9, 0.33333333333333
30851, 1.6583333333333, 0.85, 0.33333333333333
30852, 1.6583333333333, 0.8, 0.33333333333333
30853, 1.6583333333333, 0.75, 0.33333333333333
30854, 1.6583333333333, 0.7, 0.33333333333333
30855, 1.6583333333333, 0.65, 0.33333333333333
30856, 1.6583333333333, 0.6, 0.33333333333333
30857, 1.6583333333333, 0.55, 0.33333333333333
30858, 1.6583333333333, 0.5, 0.33333333333333
30859, 1.6583333333333, 0.45, 0.33333333333333
30860, 1.6583333333333, 0.4, 0.33333333333333
30861, 1.6583333333333, 0.35, 0.33333333333333
30862, 1.6583333333333, 0.3, 0.33333333333333
30863, 1.6583333333333, 0.25, 0.33333333333333
30864, 1.6583333333333, 0.2, 0.33333333333333
30865, 1.7, 1.3, 0.33333333333333
30866, 1.7, 1.25, 0.33333333333333
30867, 1.7, 1.2, 0.33333333333333
30868, 1.7, 1.15, 0.33333333333333
30869, 1.7, 1.1, 0.33333333333333
30870, 1.7, 1.05, 0.33333333333333
30871, 1.7, 1, 0.33333333333333
30872, 1.7, 0.95, 0.33333333333333
30873, 1.7, 0.9, 0.33333333333333
30874, 1.7, 0.85, 0.33333333333333
30875, 1.7, 0.8, 0.33333333333333
30876, 1.7, 0.75, 0.33333333333333
30877, 1.7, 0.7, 0.33333333333333
30878, 1.7, 0.65, 0.33333333333333
30879, 1.7, 0.6, 0.33333333333333
30880, 1.7, 0.55, 0.33333333333333
30881, 1.7, 0.5, 0.33333333333333
30882, 1.7, 0.45, 0.33333333333333
30883, 1.7, 0.4, 0.33333333333333
30884, 1.7, 0.35, 0.33333333333333
30885, 1.7, 0.3, 0.33333333333333
30886, 1.7, 0.25, 0.33333333333333
30887, 1.7, 0.2, 0.33333333333333
30888, 1.7416666666667, 1.3, 0.33333333333333
30889, 1.7416666666667, 1.25, 0.33333333333333
30890, 1.7416666666667, 1.2, 0.33333333333333
30891, 1.7416666666667, 1.15, 0.33333333333333
30892, 1.7416666666667, 1.1, 0.33333333333333
30893, 1.7416666666667, 1.05, 0.33333333333333
30894, 1.7416666666667, 1, 0.33333333333333
30895, 1.7416666666667, 0.95, 0.33333333333333
30896, 1.7416666666667, 0.9, 0.33333333333333
30897, 1.7416666666667, 0.85, 0.33333333333333
30898, 1.7416666666667, 0.8, 0.33333333333333
30899, 1.7416666666667, 0.75, 0.33333333333333
30900, 1.7416666666667, 0.7, 0.33333333333333
30901, 1.7416666666667, 0.65, 0.33333333333333
30902, 1.7416666666667, 0.6, 0.33333333333333
30903, 1.7416666666667, 0.55, 0.33333333333333
30904, 1.7416666666667, 0.5, 0.33333333333333
30905, 1.7416666666667, 0.45, 0.33333333333333
30906, 1.7416666666667, 0.4, 0.33333333333333
30907, 1.7416666666667, 0.35, 0.33333333333333
30908, 1.7416666666667, 0.3, 0.33333333333333
30909, 1.7416666666667, 0.25, 0.33333333333333
30910, 1.7416666666667, 0.2, 0.33333333333333
30911, 1.7833333333333, 1.3, 0.33333333333333
30912, 1.7833333333333, 1.25, 0.33333333333333
30913, 1.7833333333333, 1.2, 0.33333333333333
30914, 1.7833333333333, 1.15, 0.33333333333333
30915, 1.7833333333333, 1.1, 0.33333333333333
30916, 1.7833333333333, 1.05, 0.33333333333333
30917, 1.7833333333333, 1, 0.33333333333333
30918, 1.7833333333333, 0.95, 0.33333333333333
30919, 1.7833333333333, 0.9, 0.33333333333333
30920, 1.7833333333333, 0.85, 0.33333333333333
30921, 1.7833333333333, 0.8, 0.33333333333333
30922, 1.7833333333333, 0.75, 0.33333333333333
30923, 1.7833333333333, 0.7, 0.33333333333333
30924, 1.7833333333333, 0.65, 0.33333333333333
30925, 1.7833333333333, 0.6, 0.33333333333333
30926, 1.7833333333333, 0.55, 0.33333333333333
30927, 1.7833333333333, 0.5, 0.33333333333333
30928, 1.7833333333333, 0.45, 0.33333333333333
30929, 1.7833333333333, 0.4, 0.33333333333333
30930, 1.7833333333333, 0.35, 0.33333333333333
30931, 1.7833333333333, 0.3, 0.33333333333333
30932, 1.7833333333333, 0.25, 0.33333333333333
30933, 1.7833333333333, 0.2, 0.33333333333333
30934, 1.825, 1.3, 0.33333333333333
30935, 1.825, 1.25, 0.33333333333333
30936, 1.825, 1.2, 0.33333333333333
30937, 1.825, 1.15, 0.33333333333333
30938, 1.825, 1.1, 0.33333333333333
30939, 1.825, 1.05, 0.33333333333333
30940, 1.825, 1, 0.33333333333333
30941, 1.825, 0.95, 0.33333333333333
30942, 1.825, 0.9, 0.33333333333333
30943, 1.825, 0.85, 0.33333333333333
30944, 1.825, 0.8, 0.33333333333333
30945, 1.825, 0.75, 0.33333333333333
30946, 1.825, 0.7, 0.33333333333333
30947, 1.825, 0.65, 0.33333333333333
30948, 1.825, 0.6, 0.33333333333333
30949, 1.825, 0.55, 0.33333333333333
30950, 1.825, 0.5, 0.33333333333333
30951, 1.825, 0.45, 0.33333333333333
30952, 1.825, 0.4, 0.33333333333333
30953, 1.825, 0.35, 0.33333333333333
30954, 1.825, 0.3, 0.33333333333333
30955, 1.825, 0.25, 0.33333333333333
30956, 1.825, 0.2, 0.33333333333333
30957, 1.8666666666667, 1.3, 0.33333333333333
30958, 1.8666666666667, 1.25, 0.33333333333333
30959, 1.8666666666667, 1.2, 0.33333333333333
30960, 1.8666666666667, 1.15, 0.33333333333333
30961, 1.8666666666667, 1.1, 0.33333333333333
30962, 1.8666666666667, 1.05, 0.33333333333333
30963, 1.8666666666667, 1, 0.33333333333333
30964, 1.8666666666667, 0.95, 0.33333333333333
30965, 1.8666666666667, 0.9, 0.33333333333333
30966, 1.8666666666667, 0.85, 0.33333333333333
30967, 1.8666666666667, 0.8, 0.33333333333333
30968, 1.8666666666667, 0.75, 0.33333333333333
30969, 1.8666666666667, 0.7, 0.33333333333333
30970, 1.8666666666667, 0.65, 0.33333333333333
30971, 1.8666666666667, 0.6, 0.33333333333333
30972, 1.8666666666667, 0.55, 0.33333333333333
30973, 1.8666666666667, 0.5, 0.33333333333333
30974, 1.8666666666667, 0.45, 0.33333333333333
30975, 1.8666666666667, 0.4, 0.33333333333333
30976, 1.8666666666667, 0.35, 0.33333333333333
30977, 1.8666666666667, 0.3, 0.33333333333333
30978, 1.8666666666667, 0.25, 0.33333333333333
30979, 1.8666666666667, 0.2, 0.33333333333333
30980, 1.9083333333333, 1.3, 0.33333333333333
30981, 1.9083333333333, 1.25, 0.33333333333333
30982, 1.9083333333333, 1.2, 0.33333333333333
30983, 1.9083333333333, 1.15, 0.33333333333333
30984, 1.9083333333333, 1.1, 0.33333333333333
30985, 1.9083333333333, 1.05, 0.33333333333333
30986, 1.9083333333333, 1, 0.33333333333333
30987, 1.9083333333333, 0.95, 0.33333333333333
30988, 1.9083333333333, 0.9, 0.33333333333333
30989, 1.9083333333333, 0.85, 0.33333333333333
30990, 1.9083333333333, 0.8, 0.33333333333333
30991, 1.9083333333333, 0.75, 0.33333333333333
30992, 1.9083333333333, 0.7, 0.33333333333333
30993, 1.9083333333333, 0.65, 0.33333333333333
30994, 1.9083333333333, 0.6, 0.33333333333333
30995, 1.9083333333333, 0.55, 0.33333333333333
30996, 1.9083333333333, 0.5, 0.33333333333333
30997, 1.9083333333333, 0.45, 0.33333333333333
30998, 1.9083333333333, 0.4, 0.33333333333333
30999, 1.9083333333333, 0.35, 0.33333333333333
31000, 1.9083333333333, 0.3, 0.33333333333333
31001, 1.9083333333333, 0.25, 0.33333333333333
31002, 1.9083333333333, 0.2, 0.33333333333333
31003, 1.95, 1.3, 0.33333333333333
31004, 1.95, 1.25, 0.33333333333333
31005, 1.95, 1.2, 0.33333333333333
31006, 1.95, 1.15, 0.33333333333333
31007, 1.95, 1.1, 0.33333333333333
31008, 1.95, 1.05, 0.33333333333333
31009, 1.95, 1, 0.33333333333333
31010, 1.95, 0.95, 0.33333333333333
31011, 1.95, 0.9, 0.33333333333333
31012, 1.95, 0.85, 0.33333333333333
31013, 1.95, 0.8, 0.33333333333333
31014, 1.95, 0.75, 0.33333333333333
31015, 1.95, 0.7, 0.33333333333333
31016, 1.95, 0.65, 0.33333333333333
31017, 1.95, 0.6, 0.33333333333333
31018, 1.95, 0.55, 0.33333333333333
31019, 1.95, 0.5, 0.33333333333333
31020, 1.95, 0.45, 0.33333333333333
31021, 1.95, 0.4, 0.33333333333333
31022, 1.95, 0.35, 0.33333333333333
31023, 1.95, 0.3, 0.33333333333333
31024, 1.95, 0.25, 0.33333333333333
31025, 1.95, 0.2, 0.33333333333333
31026, 1.9916666666667, 1.3, 0.33333333333333
31027, 1.9916666666667, 1.25, 0.33333333333333
31028, 1.9916666666667, 1.2, 0.33333333333333
31029, 1.9916666666667, 1.15, 0.33333333333333
31030, 1.9916666666667, 1.1, 0.33333333333333
31031, 1.9916666666667, 1.05, 0.33333333333333
31032, 1.9916666666667, 1, 0.33333333333333
31033, 1.9916666666667, 0.95, 0.33333333333333
31034, 1.9916666666667, 0.9, 0.33333333333333
31035, 1.9916666666667, 0.85, 0.33333333333333
31036, 1.9916666666667, 0.8, 0.33333333333333
31037, 1.9916666666667, 0.75, 0.33333333333333
31038, 1.9916666666667, 0.7, 0.33333333333333
31039, 1.9916666666667, 0.65, 0.33333333333333
31040, 1.9916666666667, 0.6, 0.33333333333333
31041, 1.9916666666667, 0.55, 0.33333333333333
31042, 1.9916666666667, 0.5, 0.33333333333333
31043, 1.9916666666667, 0.45, 0.33333333333333
31044, 1.9916666666667, 0.4, 0.33333333333333
31045, 1.9916666666667, 0.35, 0.33333333333333
31046, 1.9916666666667, 0.3, 0.33333333333333
31047, 1.9916666666667, 0.25, 0.33333333333333
31048, 1.9916666666667, 0.2, 0.33333333333333
31049, 2.0333333333333, 1.3, 0.33333333333333
31050, 2.0333333333333, 1.25, 0.33333333333333
31051, 2.0333333333333, 1.2, 0.33333333333333
31052, 2.0333333333333, 1.15, 0.33333333333333
31053, 2.0333333333333, 1.1, 0.33333333333333
31054, 2.0333333333333, 1.05, 0.33333333333333
31055, 2.0333333333333, 1, 0.33333333333333
31056, 2.0333333333333, 0.95, 0.33333333333333
31057, 2.0333333333333, 0.9, 0.33333333333333
31058, 2.0333333333333, 0.85, 0.33333333333333
31059, 2.0333333333333, 0.8, 0.33333333333333
31060, 2.0333333333333, 0.75, 0.33333333333333
31061, 2.0333333333333, 0.7, 0.33333333333333
31062, 2.0333333333333, 0.65, 0.33333333333333
31063, 2.0333333333333, 0.6, 0.33333333333333
31064, 2.0333333333333, 0.55, 0.33333333333333
31065, 2.0333333333333, 0.5, 0.33333333333333
31066, 2.0333333333333, 0.45, 0.33333333333333
31067, 2.0333333333333, 0.4, 0.33333333333333
31068, 2.0333333333333, 0.35, 0.33333333333333
31069, 2.0333333333333, 0.3, 0.33333333333333
31070, 2.0333333333333, 0.25, 0.33333333333333
31071, 2.0333333333333, 0.2, 0.33333333333333
31072, 2.075, 1.3, 0.33333333333333
31073, 2.075, 1.25, 0.33333333333333
31074, 2.075, 1.2, 0.33333333333333
31075, 2.075, 1.15, 0.33333333333333
31076, 2.075, 1.1, 0.33333333333333
31077, 2.075, 1.05, 0.33333333333333
31078, 2.075, 1, 0.33333333333333
31079, 2.075, 0.95, 0.33333333333333
31080, 2.075, 0.9, 0.33333333333333
31081, 2.075, 0.85, 0.33333333333333
31082, 2.075, 0.8, 0.33333333333333
31083, 2.075, 0.75, 0.33333333333333
31084, 2.075, 0.7, 0.33333333333333
31085, 2.075, 0.65, 0.33333333333333
31086, 2.075, 0.6, 0.33333333333333
31087, 2.075, 0.55, 0.33333333333333
31088, 2.075, 0.5, 0.33333333333333
31089, 2.075, 0.45, 0.33333333333333
31090, 2.075, 0.4, 0.33333333333333
31091, 2.075, 0.35, 0.33333333333333
31092, 2.075, 0.3, 0.33333333333333
31093, 2.075, 0.25, 0.33333333333333
31094, 2.075, 0.2, 0.33333333333333
31095, 2.1166666666667, 1.3, 0.33333333333333
31096, 2.1166666666667, 1.25, 0.33333333333333
31097, 2.1166666666667, 1.2, 0.33333333333333
31098, 2.1166666666667, 1.15, 0.33333333333333
31099, 2.1166666666667, 1.1, 0.33333333333333
31100, 2.1166666666667, 1.05, 0.33333333333333
31101, 2.1166666666667, 1, 0.33333333333333
31102, 2.1166666666667, 0.95, 0.33333333333333
31103, 2.1166666666667, 0.9, 0.33333333333333
31104, 2.1166666666667, 0.85, 0.33333333333333
31105, 2.1166666666667, 0.8, 0.33333333333333
31106, 2.1166666666667, 0.75, 0.33333333333333
31107, 2.1166666666667, 0.7, 0.33333333333333
31108, 2.1166666666667, 0.65, 0.33333333333333
31109, 2.1166666666667, 0.6, 0.33333333333333
31110, 2.1166666666667, 0.55, 0.33333333333333
31111, 2.1166666666667, 0.5, 0.33333333333333
31112, 2.1166666666667, 0.45, 0.33333333333333
31113, 2.1166666666667, 0.4, 0.33333333333333
31114, 2.1166666666667, 0.35, 0.33333333333333
31115, 2.1166666666667, 0.3, 0.33333333333333
31116, 2.1166666666667, 0.25, 0.33333333333333
31117, 2.1166666666667, 0.2, 0.33333333333333
31118, 2.1583333333333, 1.3, 0.33333333333333
31119, 2.1583333333333, 1.25, 0.33333333333333
31120, 2.1583333333333, 1.2, 0.33333333333333
31121, 2.1583333333333, 1.15, 0.33333333333333
31122, 2.1583333333333, 1.1, 0.33333333333333
31123, 2.1583333333333, 1.05, 0.33333333333333
31124, 2.1583333333333, 1, 0.33333333333333
31125, 2.1583333333333, 0.95, 0.33333333333333
31126, 2.1583333333333, 0.9, 0.33333333333333
31127, 2.1583333333333, 0.85, 0.33333333333333
31128, 2.1583333333333, 0.8, 0.33333333333333
31129, 2.1583333333333, 0.75, 0.33333333333333
31130, 2.1583333333333, 0.7, 0.33333333333333
31131, 2.1583333333333, 0.65, 0.33333333333333
31132, 2.1583333333333, 0.6, 0.33333333333333
31133, 2.1583333333333, 0.55, 0.33333333333333
31134, 2.1583333333333, 0.5, 0.33333333333333
31135, 2.1583333333333, 0.45, 0.33333333333333
31136, 2.1583333333333, 0.4, 0.33333333333333
31137, 2.1583333333333, 0.35, 0.33333333333333
31138, 2.1583333333333, 0.3, 0.33333333333333
31139, 2.1583333333333, 0.25, 0.33333333333333
31140, 2.1583333333333, 0.2, 0.33333333333333
31141, 1.2416666666667, 1.3, 0.375
31142, 1.2416666666667, 1.25, 0.375
31143, 1.2416666666667, 1.2, 0.375
31144, 1.2416666666667, 1.15, 0.375
31145, 1.2416666666667, 1.1, 0.375
31146, 1.2416666666667, 1.05, 0.375
31147, 1.2416666666667, 1, 0.375
31148, 1.2416666666667, 0.95, 0.375
31149, 1.2416666666667, 0.9, 0.375
31150, 1.2416666666667, 0.85, 0.375
31151, 1.2416666666667, 0.8, 0.375
31152, 1.2416666666667, 0.75, 0.375
31153, 1.2416666666667, 0.7, 0.375
31154, 1.2416666666667, 0.65, 0.375
31155, 1.2416666666667, 0.6, 0.375
31156, 1.2416666666667, 0.55, 0.375
31157, 1.2416666666667, 0.5, 0.375
31158, 1.2416666666667, 0.45, 0.375
31159, 1.2416666666667, 0.4, 0.375
31160, 1.2416666666667, 0.35, 0.375
31161, 1.2416666666667, 0.3, 0.375
31162, 1.2416666666667, 0.25, 0.375
31163, 1.2416666666667, 0.2, 0.375
31164, 1.2833333333333, 1.3, 0.375
31165, 1.2833333333333, 1.25, 0.375
31166, 1.2833333333333, 1.2, 0.375
31167, 1.2833333333333, 1.15, 0.375
31168, 1.2833333333333, 1.1, 0.375
31169, 1.2833333333333, 1.05, 0.375
31170, 1.2833333333333, 1, 0.375
31171, 1.2833333333333, 0.95, 0.375
31172, 1.2833333333333, 0.9, 0.375
31173, 1.2833333333333, 0.85, 0.375
31174, 1.2833333333333, 0.8, 0.375
31175, 1.2833333333333, 0.75, 0.375
31176, 1.2833333333333, 0.7, 0.375
31177, 1.2833333333333, 0.65, 0.375
31178, 1.2833333333333, 0.6, 0.375
31179, 1.2833333333333, 0.55, 0.375
31180, 1.2833333333333, 0.5, 0.375
31181, 1.2833333333333, 0.45, 0.375
31182, 1.2833333333333, 0.4, 0.375
31183, 1.2833333333333, 0.35, 0.375
31184, 1.2833333333333, 0.3, 0.375
31185, 1.2833333333333, 0.25, 0.375
31186, 1.2833333333333, 0.2, 0.375
31187, 1.325, 1.3, 0.375
31188, 1.325, 1.25, 0.375
31189, 1.325, 1.2, 0.375
31190, 1.325, 1.15, 0.375
31191, 1.325, 1.1, 0.375
31192, 1.325, 1.05, 0.375
31193, 1.325, 1, 0.375
31194, 1.325, 0.95, 0.375
31195, 1.325, 0.9, 0.375
31196, 1.325, 0.85, 0.375
31197, 1.325, 0.8, 0.375
31198, 1.325, 0.75, 0.375
31199, 1.325, 0.7, 0.375
31200, 1.325, 0.65, 0.375
31201, 1.325, 0.6, 0.375
31202, 1.325, 0.55, 0.375
31203, 1.325, 0.5, 0.375
31204, 1.325, 0.45, 0.375
31205, 1.325, 0.4, 0.375
31206, 1.325, 0.35, 0.375
31207, 1.325, 0.3, 0.375
31208, 1.325, 0.25, 0.375
31209, 1.325, 0.2, 0.375
31210, 1.3666666666667, 1.3, 0.375
31211, 1.3666666666667, 1.25, 0.375
31212, 1.3666666666667, 1.2, 0.375
31213, 1.3666666666667, 1.15, 0.375
31214, 1.3666666666667, 1.1, 0.375
31215, 1.3666666666667, 1.05, 0.375
31216, 1.3666666666667, 1, 0.375
31217, 1.3666666666667, 0.95, 0.375
31218, 1.3666666666667, 0.9, 0.375
31219, 1.3666666666667, 0.85, 0.375
31220, 1.3666666666667, 0.8, 0.375
31221, 1.3666666666667, 0.75, 0.375
31222, 1.3666666666667, 0.7, 0.375
31223, 1.3666666666667, 0.65, 0.375
31224, 1.3666666666667, 0.6, 0.375
31225, 1.3666666666667, 0.55, 0.375
31226, 1.3666666666667, 0.5, 0.375
31227, 1.3666666666667, 0.45, 0.375
31228, 1.3666666666667, 0.4, 0.375
31229, 1.3666666666667, 0.35, 0.375
31230, 1.3666666666667, 0.3, 0.375
31231, 1.3666666666667, 0.25, 0.375
31232, 1.3666666666667, 0.2, 0.375
31233, 1.4083333333333, 1.3, 0.375
31234, 1.4083333333333, 1.25, 0.375
31235, 1.4083333333333, 1.2, 0.375
31236, 1.4083333333333, 1.15, 0.375
31237, 1.4083333333333, 1.1, 0.375
31238, 1.4083333333333, 1.05, 0.375
31239, 1.4083333333333, 1, 0.375
31240, 1.4083333333333, 0.95, 0.375
31241, 1.4083333333333, 0.9, 0.375
31242, 1.4083333333333, 0.85, 0.375
31243, 1.4083333333333, 0.8, 0.375
31244, 1.4083333333333, 0.75, 0.375
31245, 1.4083333333333, 0.7, 0.375
31246, 1.4083333333333, 0.65, 0.375
31247, 1.4083333333333, 0.6, 0.375
31248, 1.4083333333333, 0.55, 0.375
31249, 1.4083333333333, 0.5, 0.375
31250, 1.4083333333333, 0.45, 0.375
31251, 1.4083333333333, 0.4, 0.375
31252, 1.4083333333333, 0.35, 0.375
31253, 1.4083333333333, 0.3, 0.375
31254, 1.4083333333333, 0.25, 0.375
31255, 1.4083333333333, 0.2, 0.375
31256, 1.45, 1.3, 0.375
31257, 1.45, 1.25, 0.375
31258, 1.45, 1.2, 0.375
31259, 1.45, 1.15, 0.375
31260, 1.45, 1.1, 0.375
31261, 1.45, 1.05, 0.375
31262, 1.45, 1, 0.375
31263, 1.45, 0.95, 0.375
31264, 1.45, 0.9, 0.375
31265, 1.45, 0.85, 0.375
31266, 1.45, 0.8, 0.375
31267, 1.45, 0.75, 0.375
31268, 1.45, 0.7, 0.375
31269, 1.45, 0.65, 0.375
31270, 1.45, 0.6, 0.375
31271, 1.45, 0.55, 0.375
31272, 1.45, 0.5, 0.375
31273, 1.45, 0.45, 0.375
31274, 1.45, 0.4, 0.375
31275, 1.45, 0.35, 0.375
31276, 1.45, 0.3, 0.375
31277, 1.45, 0.25, 0.375
31278, 1.45, 0.2, 0.375
31279, 1.4916666666667, 1.3, 0.375
31280, 1.4916666666667, 1.25, 0.375
31281, 1.4916666666667, 1.2, 0.375
31282, 1.4916666666667, 1.15, 0.375
31283, 1.4916666666667, 1.1, 0.375
31284, 1.4916666666667, 1.05, 0.375
31285, 1.4916666666667, 1, 0.375
31286, 1.4916666666667, 0.95, 0.375
31287, 1.4916666666667, 0.9, 0.375
31288, 1.4916666666667, 0.85, 0.375
31289, 1.4916666666667, 0.8, 0.375
31290, 1.4916666666667, 0.75, 0.375
31291, 1.4916666666667, 0.7, 0.375
31292, 1.4916666666667, 0.65, 0.375
31293, 1.4916666666667, 0.6, 0.375
31294, 1.4916666666667, 0.55, 0.375
31295, 1.4916666666667, 0.5, 0.375
31296, 1.4916666666667, 0.45, 0.375
31297, 1.4916666666667, 0.4, 0.375
31298, 1.4916666666667, 0.35, 0.375
31299, 1.4916666666667, 0.3, 0.375
31300, 1.4916666666667, 0.25, 0.375
31301, 1.4916666666667, 0.2, 0.375
31302, 1.5333333333333, 1.3, 0.375
31303, 1.5333333333333, 1.25, 0.375
31304, 1.5333333333333, 1.2, 0.375
31305, 1.5333333333333, 1.15, 0.375
31306, 1.5333333333333, 1.1, 0.375
31307, 1.5333333333333, 1.05, 0.375
31308, 1.5333333333333, 1, 0.375
31309, 1.5333333333333, 0.95, 0.375
31310, 1.5333333333333, 0.9, 0.375
31311, 1.5333333333333, 0.85, 0.375
31312, 1.5333333333333, 0.8, 0.375
31313, 1.5333333333333, 0.75, 0.375
31314, 1.5333333333333, 0.7, 0.375
31315, 1.5333333333333, 0.65, 0.375
31316, 1.5333333333333, 0.6, 0.375
31317, 1.5333333333333, 0.55, 0.375
31318, 1.5333333333333, 0.5, 0.375
31319, 1.5333333333333, 0.45, 0.375
31320, 1.5333333333333, 0.4, 0.375
31321, 1.5333333333333, 0.35, 0.375
31322, 1.5333333333333, 0.3, 0.375
31323, 1.5333333333333, 0.25, 0.375
31324, 1.5333333333333, 0.2, 0.375
31325, 1.575, 1.3, 0.375
31326, 1.575, 1.25, 0.375
31327, 1.575, 1.2, 0.375
31328, 1.575, 1.15, 0.375
31329, 1.575, 1.1, 0.375
31330, 1.575, 1.05, 0.375
31331, 1.575, 1, 0.375
31332, 1.575, 0.95, 0.375
31333, 1.575, 0.9, 0.375
31334, 1.575, 0.85, 0.375
31335, 1.575, 0.8, 0.375
31336, 1.575, 0.75, 0.375
31337, 1.575, 0.7, 0.375
31338, 1.575, 0.65, 0.375
31339, 1.575, 0.6, 0.375
31340, 1.575, 0.55, 0.375
31341, 1.575, 0.5, 0.375
31342, 1.575, 0.45, 0.375
31343, 1.575, 0.4, 0.375
31344, 1.575, 0.35, 0.375
31345, 1.575, 0.3, 0.375
31346, 1.575, 0.25, 0.375
31347, 1.575, 0.2, 0.375
31348, 1.6166666666667, 1.3, 0.375
31349, 1.6166666666667, 1.25, 0.375
31350, 1.6166666666667, 1.2, 0.375
31351, 1.6166666666667, 1.15, 0.375
31352, 1.6166666666667, 1.1, 0.375
31353, 1.6166666666667, 1.05, 0.375
31354, 1.6166666666667, 1, 0.375
31355, 1.6166666666667, 0.95, 0.375
31356, 1.6166666666667, 0.9, 0.375
31357, 1.6166666666667, 0.85, 0.375
31358, 1.6166666666667, 0.8, 0.375
31359, 1.6166666666667, 0.75, 0.375
31360, 1.6166666666667, 0.7, 0.375
31361, 1.6166666666667, 0.65, 0.375
31362, 1.6166666666667, 0.6, 0.375
31363, 1.6166666666667, 0.55, 0.375
31364, 1.6166666666667, 0.5, 0.375
31365, 1.6166666666667, 0.45, 0.375
31366, 1.6166666666667, 0.4, 0.375
31367, 1.6166666666667, 0.35, 0.375
31368, 1.6166666666667, 0.3, 0.375
31369, 1.6166666666667, 0.25, 0.375
31370, 1.6166666666667, 0.2, 0.375
31371, 1.6583333333333, 1.3, 0.375
31372, 1.6583333333333, 1.25, 0.375
31373, 1.6583333333333, 1.2, 0.375
31374, 1.6583333333333, 1.15, 0.375
31375, 1.6583333333333, 1.1, 0.375
31376, 1.6583333333333, 1.05, 0.375
31377, 1.6583333333333, 1, 0.375
31378, 1.6583333333333, 0.95, 0.375
31379, 1.6583333333333, 0.9, 0.375
31380, 1.6583333333333, 0.85, 0.375
31381, 1.6583333333333, 0.8, 0.375
31382, 1.6583333333333, 0.75, 0.375
31383, 1.6583333333333, 0.7, 0.375
31384, 1.6583333333333, 0.65, 0.375
31385, 1.6583333333333, 0.6, 0.375
31386, 1.6583333333333, 0.55, 0.375
31387, 1.6583333333333, 0.5, 0.375
31388, 1.6583333333333, 0.45, 0.375
31389, 1.6583333333333, 0.4, 0.375
31390, 1.6583333333333, 0.35, 0.375
31391, 1.6583333333333, 0.3, 0.375
31392, 1.6583333333333, 0.25, 0.375
31393, 1.6583333333333, 0.2, 0.375
31394, 1.7, 1.3, 0.375
31395, 1.7, 1.25, 0.375
31396, 1.7, 1.2, 0.375
31397, 1.7, 1.15, 0.375
31398, 1.7, 1.1, 0.375
31399, 1.7, 1.05, 0.375
31400, 1.7, 1, 0.375
31401, 1.7, 0.95, 0.375
31402, 1.7, 0.9, 0.375
31403, 1.7, 0.85, 0.375
31404, 1.7, 0.8, 0.375
31405, 1.7, 0.75, 0.375
31406, 1.7, 0.7, 0.375
31407, 1.7, 0.65, 0.375
31408, 1.7, 0.6, 0.375
31409, 1.7, 0.55, 0.375
31410, 1.7, 0.5, 0.375
31411, 1.7, 0.45, 0.375
31412, 1.7, 0.4, 0.375
31413, 1.7, 0.35, 0.375
31414, 1.7, 0.3, 0.375
31415, 1.7, 0.25, 0.375
31416, 1.7, 0.2, 0.375
31417, 1.7416666666667, 1.3, 0.375
31418, 1.7416666666667, 1.25, 0.375
31419, 1.7416666666667, 1.2, 0.375
31420, 1.7416666666667, 1.15, 0.375
31421, 1.7416666666667, 1.1, 0.375
31422, 1.7416666666667, 1.05, 0.375
31423, 1.7416666666667, 1, 0.375
31424, 1.7416666666667, 0.95, 0.375
31425, 1.7416666666667, 0.9, 0.375
31426, 1.7416666666667, 0.85, 0.375
31427, 1.7416666666667, 0.8, 0.375
31428, 1.7416666666667, 0.75, 0.375
31429, 1.7416666666667, 0.7, 0.375
31430, 1.7416666666667, 0.65, 0.375
31431, 1.7416666666667, 0.6, 0.375
31432, 1.7416666666667, 0.55, 0.375
31433, 1.7416666666667, 0.5, 0.375
31434, 1.7416666666667, 0.45, 0.375
31435, 1.7416666666667, 0.4, 0.375
31436, 1.7416666666667, 0.35, 0.375
31437, 1.7416666666667, 0.3, 0.375
31438, 1.7416666666667, 0.25, 0.375
31439, 1.7416666666667, 0.2, 0.375
31440, 1.7833333333333, 1.3, 0.375
31441, 1.7833333333333, 1.25, 0.375
31442, 1.7833333333333, 1.2, 0.375
31443, 1.7833333333333, 1.15, 0.375
31444, 1.7833333333333, 1.1, 0.375
31445, 1.7833333333333, 1.05, 0.375
31446, 1.7833333333333, 1, 0.375
31447, 1.7833333333333, 0.95, 0.375
31448, 1.7833333333333, 0.9, 0.375
31449, 1.7833333333333, 0.85, 0.375
31450, 1.7833333333333, 0.8, 0.375
31451, 1.7833333333333, 0.75, 0.375
31452, 1.7833333333333, 0.7, 0.375
31453, 1.7833333333333, 0.65, 0.375
31454, 1.7833333333333, 0.6, 0.375
31455, 1.7833333333333, 0.55, 0.375
31456, 1.7833333333333, 0.5, 0.375
31457, 1.7833333333333, 0.45, 0.375
31458, 1.7833333333333, 0.4, 0.375
31459, 1.7833333333333, 0.35, 0.375
31460, 1.7833333333333, 0.3, 0.375
31461, 1.7833333333333, 0.25, 0.375
31462, 1.7833333333333, 0.2, 0.375
31463, 1.825, 1.3, 0.375
31464, 1.825, 1.25, 0.375
31465, 1.825, 1.2, 0.375
31466, 1.825, 1.15, 0.375
31467, 1.825, 1.1, 0.375
31468, 1.825, 1.05, 0.375
31469, 1.825, 1, 0.375
31470, 1.825, 0.95, 0.375
31471, 1.825, 0.9, 0.375
31472, 1.825, 0.85, 0.375
31473, 1.825, 0.8, 0.375
31474, 1.825, 0.75, 0.375
31475, 1.825, 0.7, 0.375
31476, 1.825, 0.65, 0.375
31477, 1.825, 0.6, 0.375
31478, 1.825, 0.55, 0.375
31479, 1.825, 0.5, 0.375
31480, 1.825, 0.45, 0.375
31481, 1.825, 0.4, 0.375
31482, 1.825, 0.35, 0.375
31483, 1.825, 0.3, 0.375
31484, 1.825, 0.25, 0.375
31485, 1.825, 0.2, 0.375
31486, 1.8666666666667, 1.3, 0.375
31487, 1.8666666666667, 1.25, 0.375
31488, 1.8666666666667, 1.2, 0.375
31489, 1.8666666666667, 1.15, 0.375
31490, 1.8666666666667, 1.1, 0.375
31491, 1.8666666666667, 1.05, 0.375
31492, 1.8666666666667, 1, 0.375
31493, 1.8666666666667, 0.95, 0.375
31494, 1.8666666666667, 0.9, 0.375
31495, 1.8666666666667, 0.85, 0.375
31496, 1.8666666666667, 0.8, 0.375
31497, 1.8666666666667, 0.75, 0.375
31498, 1.8666666666667, 0.7, 0.375
31499, 1.8666666666667, 0.65, 0.375
31500, 1.8666666666667, 0.6, 0.375
31501, 1.8666666666667, 0.55, 0.375
31502, 1.8666666666667, 0.5, 0.375
31503, 1.8666666666667, 0.45, 0.375
31504, 1.8666666666667, 0.4, 0.375
31505, 1.8666666666667, 0.35, 0.375
31506, 1.8666666666667, 0.3, 0.375
31507, 1.8666666666667, 0.25, 0.375
31508, 1.8666666666667, 0.2, 0.375
31509, 1.9083333333333, 1.3, 0.375
31510, 1.9083333333333, 1.25, 0.375
31511, 1.9083333333333, 1.2, 0.375
31512, 1.9083333333333, 1.15, 0.375
31513, 1.9083333333333, 1.1, 0.375
31514, 1.9083333333333, 1.05, 0.375
31515, 1.9083333333333, 1, 0.375
31516, 1.9083333333333, 0.95, 0.375
31517, 1.9083333333333, 0.9, 0.375
31518, 1.9083333333333, 0.85, 0.375
31519, 1.9083333333333, 0.8, 0.375
31520, 1.9083333333333, 0.75, 0.375
31521, 1.9083333333333, 0.7, 0.375
31522, 1.9083333333333, 0.65, 0.375
31523, 1.9083333333333, 0.6, 0.375
31524, 1.9083333333333, 0.55, 0.375
31525, 1.9083333333333, 0.5, 0.375
31526, 1.9083333333333, 0.45, 0.375
31527, 1.9083333333333, 0.4, 0.375
31528, 1.9083333333333, 0.35, 0.375
31529, 1.9083333333333, 0.3, 0.375
31530, 1.9083333333333, 0.25, 0.375
31531, 1.9083333333333, 0.2, 0.375
31532, 1.95, 1.3, 0.375
31533, 1.95, 1.25, 0.375
31534, 1.95, 1.2, 0.375
31535, 1.95, 1.15, 0.375
31536, 1.95, 1.1, 0.375
31537, 1.95, 1.05, 0.375
31538, 1.95, 1, 0.375
31539, 1.95, 0.95, 0.375
31540, 1.95, 0.9, 0.375
31541, 1.95, 0.85, 0.375
31542, 1.95, 0.8, 0.375
31543, 1.95, 0.75, 0.375
31544, 1.95, 0.7, 0.375
31545, 1.95, 0.65, 0.375
31546, 1.95, 0.6, 0.375
31547, 1.95, 0.55, 0.375
31548, 1.95, 0.5, 0.375
31549, 1.95, 0.45, 0.375
31550, 1.95, 0.4, 0.375
31551, 1.95, 0.35, 0.375
31552, 1.95, 0.3, 0.375
31553, 1.95, 0.25, 0.375
31554, 1.95, 0.2, 0.375
31555, 1.9916666666667, 1.3, 0.375
31556, 1.9916666666667, 1.25, 0.375
31557, 1.9916666666667, 1.2, 0.375
31558, 1.9916666666667, 1.15, 0.375
31559, 1.9916666666667, 1.1, 0.375
31560, 1.9916666666667, 1.05, 0.375
31561, 1.9916666666667, 1, 0.375
31562, 1.9916666666667, 0.95, 0.375
31563, 1.9916666666667, 0.9, 0.375
31564, 1.9916666666667, 0.85, 0.375
31565, 1.9916666666667, 0.8, 0.375
31566, 1.9916666666667, 0.75, 0.375
31567, 1.9916666666667, 0.7, 0.375
31568, 1.9916666666667, 0.65, 0.375
31569, 1.9916666666667, 0.6, 0.375
31570, 1.9916666666667, 0.55, 0.375
31571, 1.9916666666667, 0.5, 0.375
31572, 1.9916666666667, 0.45, 0.375
31573, 1.9916666666667, 0.4, 0.375
31574, 1.9916666666667, 0.35, 0.375
31575, 1.9916666666667, 0.3, 0.375
31576, 1.9916666666667, 0.25, 0.375
31577, 1.9916666666667, 0.2, 0.375
31578, 2.0333333333333, 1.3, 0.375
31579, 2.0333333333333, 1.25, 0.375
31580, 2.0333333333333, 1.2, 0.375
31581, 2.0333333333333, 1.15, 0.375
31582, 2.0333333333333, 1.1, 0.375
31583, 2.0333333333333, 1.05, 0.375
31584, 2.0333333333333, 1, 0.375
31585, 2.0333333333333, 0.95, 0.375
31586, 2.0333333333333, 0.9, 0.375
31587, 2.0333333333333, 0.85, 0.375
31588, 2.0333333333333, 0.8, 0.375
31589, 2.0333333333333, 0.75, 0.375
31590, 2.0333333333333, 0.7, 0.375
31591, 2.0333333333333, 0.65, 0.375
31592, 2.0333333333333, 0.6, 0.375
31593, 2.0333333333333, 0.55, 0.375
31594, 2.0333333333333, 0.5, 0.375
31595, 2.0333333333333, 0.45, 0.375
31596, 2.0333333333333, 0.4, 0.375
31597, 2.0333333333333, 0.35, 0.375
31598, 2.0333333333333, 0.3, 0.375
31599, 2.0333333333333, 0.25, 0.375
31600, 2.0333333333333, 0.2, 0.375
31601, 2.075, 1.3, 0.375
31602, 2.075, 1.25, 0.375
31603, 2.075, 1.2, 0.375
31604, 2.075, 1.15, 0.375
31605, 2.075, 1.1, 0.375
31606, 2.075, 1.05, 0.375
31607, 2.075, 1, 0.375
31608, 2.075, 0.95, 0.375
31609, 2.075, 0.9, 0.375
31610, 2.075, 0.85, 0.375
31611, 2.075, 0.8, 0.375
31612, 2.075, 0.75, 0.375
31613, 2.075, 0.7, 0.375
31614, 2.075, 0.65, 0.375
31615, 2.075, 0.6, 0.375
31616, 2.075, 0.55, 0.375
31617, 2.075, 0.5, 0.375
31618, 2.075, 0.45, 0.375
31619, 2.075, 0.4, 0.375
31620, 2.075, 0.35, 0.375
31621, 2.075, 0.3, 0.375
31622, 2.075, 0.25, 0.375
31623, 2.075, 0.2, 0.375
31624, 2.1166666666667, 1.3, 0.375
31625, 2.1166666666667, 1.25, 0.375
31626, 2.1166666666667, 1.2, 0.375
31627, 2.1166666666667, 1.15, 0.375
31628, 2.1166666666667, 1.1, 0.375
31629, 2.1166666666667, 1.05, 0.375
31630, 2.1166666666667, 1, 0.375
31631, 2.1166666666667, 0.95, 0.375
31632, 2.1166666666667, 0.9, 0.375
31633, 2.1166666666667, 0.85, 0.375
31634, 2.1166666666667, 0.8, 0.375
31635, 2.1166666666667, 0.75, 0.375
31636, 2.1166666666667, 0.7, 0.375
31637, 2.1166666666667, 0.65, 0.375
31638, 2.1166666666667, 0.6, 0.375
31639, 2.1166666666667, 0.55, 0.375
31640, 2.1166666666667, 0.5, 0.375
31641, 2.1166666666667, 0.45, 0.375
31642, 2.1166666666667, 0.4, 0.375
31643, 2.1166666666667, 0.35, 0.375
31644, 2.1166666666667, 0.3, 0.375
31645, 2.1166666666667, 0.25, 0.375
31646, 2.1166666666667, 0.2, 0.375
31647, 2.1583333333333, 1.3, 0.375
31648, 2.1583333333333, 1.25, 0.375
31649, 2.1583333333333, 1.2, 0.375
31650, 2.1583333333333, 1.15, 0.375
31651, 2.1583333333333, 1.1, 0.375
31652, 2.1583333333333, 1.05, 0.375
31653, 2.1583333333333, 1, 0.375
31654, 2.1583333333333, 0.95, 0.375
31655, 2.1583333333333, 0.9, 0.375
31656, 2.1583333333333, 0.85, 0.375
31657, 2.1583333333333, 0.8, 0.375
31658, 2.1583333333333, 0.75, 0.375
31659, 2.1583333333333, 0.7, 0.375
31660, 2.1583333333333, 0.65, 0.375
31661, 2.1583333333333, 0.6, 0.375
31662, 2.1583333333333, 0.55, 0.375
31663, 2.1583333333333, 0.5, 0.375
31664, 2.1583333333333, 0.45, 0.375
31665, 2.1583333333333, 0.4, 0.375
31666, 2.1583333333333, 0.35, 0.375
31667, 2.1583333333333, 0.3, 0.375
31668, 2.1583333333333, 0.25, 0.375
31669, 2.1583333333333, 0.2, 0.375
31670, 1.2416666666667, 1.3, 0.41666666666667
31671, 1.2416666666667, 1.25, 0.41666666666667
31672, 1.2416666666667, 1.2, 0.41666666666667
31673, 1.2416666666667, 1.15, 0.41666666666667
31674, 1.2416666666667, 1.1, 0.41666666666667
31675, 1.2416666666667, 1.05, 0.41666666666667
31676, 1.2416666666667, 1, 0.41666666666667
31677, 1.2416666666667, 0.95, 0.41666666666667
31678, 1.2416666666667, 0.9, 0.41666666666667
31679, 1.2416666666667, 0.85, 0.41666666666667
31680, 1.2416666666667, 0.8, 0.41666666666667
31681, 1.2416666666667, 0.75, 0.41666666666667
31682, 1.2416666666667, 0.7, 0.41666666666667
31683, 1.2416666666667, 0.65, 0.41666666666667
31684, 1.2416666666667, 0.6, 0.41666666666667
31685, 1.2416666666667, 0.55, 0.41666666666667
31686, 1.2416666666667, 0.5, 0.41666666666667
31687, 1.2416666666667, 0.45, 0.41666666666667
31688, 1.2416666666667, 0.4, 0.41666666666667
31689, 1.2416666666667, 0.35, 0.41666666666667
31690, 1.2416666666667, 0.3, 0.41666666666667
31691, 1.2416666666667, 0.25, 0.41666666666667
31692, 1.2416666666667, 0.2, 0.41666666666667
31693, 1.2833333333333, 1.3, 0.41666666666667
31694, 1.2833333333333, 1.25, 0.41666666666667
31695, 1.2833333333333, 1.2, 0.41666666666667
31696, 1.2833333333333, 1.15, 0.41666666666667
31697, 1.2833333333333, 1.1, 0.41666666666667
31698, 1.2833333333333, 1.05, 0.41666666666667
31699, 1.2833333333333, 1, 0.41666666666667
31700, 1.2833333333333, 0.95, 0.41666666666667
31701, 1.2833333333333, 0.9, 0.41666666666667
31702, 1.2833333333333, 0.85, 0.41666666666667
31703, 1.2833333333333, 0.8, 0.41666666666667
31704, 1.2833333333333, 0.75, 0.41666666666667
31705, 1.2833333333333, 0.7, 0.41666666666667
31706, 1.2833333333333, 0.65, 0.41666666666667
31707, 1.2833333333333, 0.6, 0.41666666666667
31708, 1.2833333333333, 0.55, 0.41666666666667
31709, 1.2833333333333, 0.5, 0.41666666666667
31710, 1.2833333333333, 0.45, 0.41666666666667
31711, 1.2833333333333, 0.4, 0.41666666666667
31712, 1.2833333333333, 0.35, 0.41666666666667
31713, 1.2833333333333, 0.3, 0.41666666666667
31714, 1.2833333333333, 0.25, 0.41666666666667
31715, 1.2833333333333, 0.2, 0.41666666666667
31716, 1.325, 1.3, 0.41666666666667
31717, 1.325, 1.25, 0.41666666666667
31718, 1.325, 1.2, 0.41666666666667
31719, 1.325, 1.15, 0.41666666666667
31720, 1.325, 1.1, 0.41666666666667
31721, 1.325, 1.05, 0.41666666666667
31722, 1.325, 1, 0.41666666666667
31723, 1.325, 0.95, 0.41666666666667
31724, 1.325, 0.9, 0.41666666666667
31725, 1.325, 0.85, 0.41666666666667
31726, 1.325, 0.8, 0.41666666666667
31727, 1.325, 0.75, 0.41666666666667
31728, 1.325, 0.7, 0.41666666666667
31729, 1.325, 0.65, 0.41666666666667
31730, 1.325, 0.6, 0.41666666666667
31731, 1.325, 0.55, 0.41666666666667
31732, 1.325, 0.5, 0.41666666666667
31733, 1.325, 0.45, 0.41666666666667
31734, 1.325, 0.4, 0.41666666666667
31735, 1.325, 0.35, 0.41666666666667
31736, 1.325, 0.3, 0.41666666666667
31737, 1.325, 0.25, 0.41666666666667
31738, 1.325, 0.2, 0.41666666666667
31739, 1.3666666666667, 1.3, 0.41666666666667
31740, 1.3666666666667, 1.25, 0.41666666666667
31741, 1.3666666666667, 1.2, 0.41666666666667
31742, 1.3666666666667, 1.15, 0.41666666666667
31743, 1.3666666666667, 1.1, 0.41666666666667
31744, 1.3666666666667, 1.05, 0.41666666666667
31745, 1.3666666666667, 1, 0.41666666666667
31746, 1.3666666666667, 0.95, 0.41666666666667
31747, 1.3666666666667, 0.9, 0.41666666666667
31748, 1.3666666666667, 0.85, 0.41666666666667
31749, 1.3666666666667, 0.8, 0.41666666666667
31750, 1.3666666666667, 0.75, 0.41666666666667
31751, 1.3666666666667, 0.7, 0.41666666666667
31752, 1.3666666666667, 0.65, 0.41666666666667
31753, 1.3666666666667, 0.6, 0.41666666666667
31754, 1.3666666666667, 0.55, 0.41666666666667
31755, 1.3666666666667, 0.5, 0.41666666666667
31756, 1.3666666666667, 0.45, 0.41666666666667
31757, 1.3666666666667, 0.4, 0.41666666666667
31758, 1.3666666666667, 0.35, 0.41666666666667
31759, 1.3666666666667, 0.3, 0.41666666666667
31760, 1.3666666666667, 0.25, 0.41666666666667
31761, 1.3666666666667, 0.2, 0.41666666666667
31762, 1.4083333333333, 1.3, 0.41666666666667
31763, 1.4083333333333, 1.25, 0.41666666666667
31764, 1.4083333333333, 1.2, 0.41666666666667
31765, 1.4083333333333, 1.15, 0.41666666666667
31766, 1.4083333333333, 1.1, 0.41666666666667
31767, 1.4083333333333, 1.05, 0.41666666666667
31768, 1.4083333333333, 1, 0.41666666666667
31769, 1.4083333333333, 0.95, 0.41666666666667
31770, 1.4083333333333, 0.9, 0.41666666666667
31771, 1.4083333333333, 0.85, 0.41666666666667
31772, 1.4083333333333, 0.8, 0.41666666666667
31773, 1.4083333333333, 0.75, 0.41666666666667
31774, 1.4083333333333, 0.7, 0.41666666666667
31775, 1.4083333333333, 0.65, 0.41666666666667
31776, 1.4083333333333, 0.6, 0.41666666666667
31777, 1.4083333333333, 0.55, 0.41666666666667
31778, 1.4083333333333, 0.5, 0.41666666666667
31779, 1.4083333333333, 0.45, 0.41666666666667
31780, 1.4083333333333, 0.4, 0.41666666666667
31781, 1.4083333333333, 0.35, 0.41666666666667
31782, 1.4083333333333, 0.3, 0.41666666666667
31783, 1.4083333333333, 0.25, 0.41666666666667
31784, 1.4083333333333, 0.2, 0.41666666666667
31785, 1.45, 1.3, 0.41666666666667
31786, 1.45, 1.25, 0.41666666666667
31787, 1.45, 1.2, 0.41666666666667
31788, 1.45, 1.15, 0.41666666666667
31789, 1.45, 1.1, 0.41666666666667
31790, 1.45, 1.05, 0.41666666666667
31791, 1.45, 1, 0.41666666666667
31792, 1.45, 0.95, 0.41666666666667
31793, 1.45, 0.9, 0.41666666666667
31794, 1.45, 0.85, 0.41666666666667
31795, 1.45, 0.8, 0.41666666666667
31796, 1.45, 0.75, 0.41666666666667
31797, 1.45, 0.7, 0.41666666666667
31798, 1.45, 0.65, 0.41666666666667
31799, 1.45, 0.6, 0.41666666666667
31800, 1.45, 0.55, 0.41666666666667
31801, 1.45, 0.5, 0.41666666666667
31802, 1.45, 0.45, 0.41666666666667
31803, 1.45, 0.4, 0.41666666666667
31804, 1.45, 0.35, 0.41666666666667
31805, 1.45, 0.3, 0.41666666666667
31806, 1.45, 0.25, 0.41666666666667
31807, 1.45, 0.2, 0.41666666666667
31808, 1.4916666666667, 1.3, 0.41666666666667
31809, 1.4916666666667, 1.25, 0.41666666666667
31810, 1.4916666666667, 1.2, 0.41666666666667
31811, 1.4916666666667, 1.15, 0.41666666666667
31812, 1.4916666666667, 1.1, 0.41666666666667
31813, 1.4916666666667, 1.05, 0.41666666666667
31814, 1.4916666666667, 1, 0.41666666666667
31815, 1.4916666666667, 0.95, 0.41666666666667
31816, 1.4916666666667, 0.9, 0.41666666666667
31817, 1.4916666666667, 0.85, 0.41666666666667
31818, 1.4916666666667, 0.8, 0.41666666666667
31819, 1.4916666666667, 0.75, 0.41666666666667
31820, 1.4916666666667, 0.7, 0.41666666666667
31821, 1.4916666666667, 0.65, 0.41666666666667
31822, 1.4916666666667, 0.6, 0.41666666666667
31823, 1.4916666666667, 0.55, 0.41666666666667
31824, 1.4916666666667, 0.5, 0.41666666666667
31825, 1.4916666666667, 0.45, 0.41666666666667
31826, 1.4916666666667, 0.4, 0.41666666666667
31827, 1.4916666666667, 0.35, 0.41666666666667
31828, 1.4916666666667, 0.3, 0.41666666666667
31829, 1.4916666666667, 0.25, 0.41666666666667
31830, 1.4916666666667, 0.2, 0.41666666666667
31831, 1.5333333333333, 1.3, 0.41666666666667
31832, 1.5333333333333, 1.25, 0.41666666666667
31833, 1.5333333333333, 1.2, 0.41666666666667
31834, 1.5333333333333, 1.15, 0.41666666666667
31835, 1.5333333333333, 1.1, 0.41666666666667
31836, 1.5333333333333, 1.05, 0.41666666666667
31837, 1.5333333333333, 1, 0.41666666666667
31838, 1.5333333333333, 0.95, 0.41666666666667
31839, 1.5333333333333, 0.9, 0.41666666666667
31840, 1.5333333333333, 0.85, 0.41666666666667
31841, 1.5333333333333, 0.8, 0.41666666666667
31842, 1.5333333333333, 0.75, 0.41666666666667
31843, 1.5333333333333, 0.7, 0.41666666666667
31844, 1.5333333333333, 0.65, 0.41666666666667
31845, 1.5333333333333, 0.6, 0.41666666666667
31846, 1.5333333333333, 0.55, 0.41666666666667
31847, 1.5333333333333, 0.5, 0.41666666666667
31848, 1.5333333333333, 0.45, 0.41666666666667
31849, 1.5333333333333, 0.4, 0.41666666666667
31850, 1.5333333333333, 0.35, 0.41666666666667
31851, 1.5333333333333, 0.3, 0.41666666666667
31852, 1.5333333333333, 0.25, 0.41666666666667
31853, 1.5333333333333, 0.2, 0.41666666666667
31854, 1.575, 1.3, 0.41666666666667
31855, 1.575, 1.25, 0.41666666666667
31856, 1.575, 1.2, 0.41666666666667
31857, 1.575, 1.15, 0.41666666666667
31858, 1.575, 1.1, 0.41666666666667
31859, 1.575, 1.05, 0.41666666666667
31860, 1.575, 1, 0.41666666666667
31861, 1.575, 0.95, 0.41666666666667
31862, 1.575, 0.9, 0.41666666666667
31863, 1.575, 0.85, 0.41666666666667
31864, 1.575, 0.8, 0.41666666666667
31865, 1.575, 0.75, 0.41666666666667
31866, 1.575, 0.7, 0.41666666666667
31867, 1.575, 0.65, 0.41666666666667
31868, 1.575, 0.6, 0.41666666666667
31869, 1.575, 0.55, 0.41666666666667
31870, 1.575, 0.5, 0.41666666666667
31871, 1.575, 0.45, 0.41666666666667
31872, 1.575, 0.4, 0.41666666666667
31873, 1.575, 0.35, 0.41666666666667
31874, 1.575, 0.3, 0.41666666666667
31875, 1.575, 0.25, 0.41666666666667
31876, 1.575, 0.2, 0.41666666666667
31877, 1.6166666666667, 1.3, 0.41666666666667
31878, 1.6166666666667, 1.25, 0.41666666666667
31879, 1.6166666666667, 1.2, 0.41666666666667
31880, 1.6166666666667, 1.15, 0.41666666666667
31881, 1.6166666666667, 1.1, 0.41666666666667
31882, 1.6166666666667, 1.05, 0.41666666666667
31883, 1.6166666666667, 1, 0.41666666666667
31884, 1.6166666666667, 0.95, 0.41666666666667
31885, 1.6166666666667, 0.9, 0.41666666666667
31886, 1.6166666666667, 0.85, 0.41666666666667
31887, 1.6166666666667, 0.8, 0.41666666666667
31888, 1.6166666666667, 0.75, 0.41666666666667
31889, 1.6166666666667, 0.7, 0.41666666666667
31890, 1.6166666666667, 0.65, 0.41666666666667
31891, 1.6166666666667, 0.6, 0.41666666666667
31892, 1.6166666666667, 0.55, 0.41666666666667
31893, 1.6166666666667, 0.5, 0.41666666666667
31894, 1.6166666666667, 0.45, 0.41666666666667
31895, 1.6166666666667, 0.4, 0.41666666666667
31896, 1.6166666666667, 0.35, 0.41666666666667
31897, 1.6166666666667, 0.3, 0.41666666666667
31898, 1.6166666666667, 0.25, 0.41666666666667
31899, 1.6166666666667, 0.2, 0.41666666666667
31900, 1.6583333333333, 1.3, 0.41666666666667
31901, 1.6583333333333, 1.25, 0.41666666666667
31902, 1.6583333333333, 1.2, 0.41666666666667
31903, 1.6583333333333, 1.15, 0.41666666666667
31904, 1.6583333333333, 1.1, 0.41666666666667
31905, 1.6583333333333, 1.05, 0.41666666666667
31906, 1.6583333333333, 1, 0.41666666666667
31907, 1.6583333333333, 0.95, 0.41666666666667
31908, 1.6583333333333, 0.9, 0.41666666666667
31909, 1.6583333333333, 0.85, 0.41666666666667
31910, 1.6583333333333, 0.8, 0.41666666666667
31911, 1.6583333333333, 0.75, 0.41666666666667
31912, 1.6583333333333, 0.7, 0.41666666666667
31913, 1.6583333333333, 0.65, 0.41666666666667
31914, 1.6583333333333, 0.6, 0.41666666666667
31915, 1.6583333333333, 0.55, 0.41666666666667
31916, 1.6583333333333, 0.5, 0.41666666666667
31917, 1.6583333333333, 0.45, 0.41666666666667
31918, 1.6583333333333, 0.4, 0.41666666666667
31919, 1.6583333333333, 0.35, 0.41666666666667
31920, 1.6583333333333, 0.3, 0.41666666666667
31921, 1.6583333333333, 0.25, 0.41666666666667
31922, 1.6583333333333, 0.2, 0.41666666666667
31923, 1.7, 1.3, 0.41666666666667
31924, 1.7, 1.25, 0.41666666666667
31925, 1.7, 1.2, 0.41666666666667
31926, 1.7, 1.15, 0.41666666666667
31927, 1.7, 1.1, 0.41666666666667
31928, 1.7, 1.05, 0.41666666666667
31929, 1.7, 1, 0.41666666666667
31930, 1.7, 0.95, 0.41666666666667
31931, 1.7, 0.9, 0.41666666666667
31932, 1.7, 0.85, 0.41666666666667
31933, 1.7, 0.8, 0.41666666666667
31934, 1.7, 0.75, 0.41666666666667
31935, 1.7, 0.7, 0.41666666666667
31936, 1.7, 0.65, 0.41666666666667
31937, 1.7, 0.6, 0.41666666666667
31938, 1.7, 0.55, 0.41666666666667
31939, 1.7, 0.5, 0.41666666666667
31940, 1.7, 0.45, 0.41666666666667
31941, 1.7, 0.4, 0.41666666666667
31942, 1.7, 0.35, 0.41666666666667
31943, 1.7, 0.3, 0.41666666666667
31944, 1.7, 0.25, 0.41666666666667
31945, 1.7, 0.2, 0.41666666666667
31946, 1.7416666666667, 1.3, 0.41666666666667
31947, 1.7416666666667, 1.25, 0.41666666666667
31948, 1.7416666666667, 1.2, 0.41666666666667
31949, 1.7416666666667, 1.15, 0.41666666666667
31950, 1.7416666666667, 1.1, 0.41666666666667
31951, 1.7416666666667, 1.05, 0.41666666666667
31952, 1.7416666666667, 1, 0.41666666666667
31953, 1.7416666666667, 0.95, 0.41666666666667
31954, 1.7416666666667, 0.9, 0.41666666666667
31955, 1.7416666666667, 0.85, 0.41666666666667
31956, 1.7416666666667, 0.8, 0.41666666666667
31957, 1.7416666666667, 0.75, 0.41666666666667
31958, 1.7416666666667, 0.7, 0.41666666666667
31959, 1.7416666666667, 0.65, 0.41666666666667
31960, 1.7416666666667, 0.6, 0.41666666666667
31961, 1.7416666666667, 0.55, 0.41666666666667
31962, 1.7416666666667, 0.5, 0.41666666666667
31963, 1.7416666666667, 0.45, 0.41666666666667
31964, 1.7416666666667, 0.4, 0.41666666666667
31965, 1.7416666666667, 0.35, 0.41666666666667
31966, 1.7416666666667, 0.3, 0.41666666666667
31967, 1.7416666666667, 0.25, 0.41666666666667
31968, 1.7416666666667, 0.2, 0.41666666666667
31969, 1.7833333333333, 1.3, 0.41666666666667
31970, 1.7833333333333, 1.25, 0.41666666666667
31971, 1.7833333333333, 1.2, 0.41666666666667
31972, 1.7833333333333, 1.15, 0.41666666666667
31973, 1.7833333333333, 1.1, 0.41666666666667
31974, 1.7833333333333, 1.05, 0.41666666666667
31975, 1.7833333333333, 1, 0.41666666666667
31976, 1.7833333333333, 0.95, 0.41666666666667
31977, 1.7833333333333, 0.9, 0.41666666666667
31978, 1.7833333333333, 0.85, 0.41666666666667
31979, 1.7833333333333, 0.8, 0.41666666666667
31980, 1.7833333333333, 0.75, 0.41666666666667
31981, 1.7833333333333, 0.7, 0.41666666666667
31982, 1.7833333333333, 0.65, 0.41666666666667
31983, 1.7833333333333, 0.6, 0.41666666666667
31984, 1.7833333333333, 0.55, 0.41666666666667
31985, 1.7833333333333, 0.5, 0.41666666666667
31986, 1.7833333333333, 0.45, 0.41666666666667
31987, 1.7833333333333, 0.4, 0.41666666666667
31988, 1.7833333333333, 0.35, 0.41666666666667
31989, 1.7833333333333, 0.3, 0.41666666666667
31990, 1.7833333333333, 0.25, 0.41666666666667
31991, 1.7833333333333, 0.2, 0.41666666666667
31992, 1.825, 1.3, 0.41666666666667
31993, 1.825, 1.25, 0.41666666666667
31994, 1.825, 1.2, 0.41666666666667
31995, 1.825, 1.15, 0.41666666666667
31996, 1.825, 1.1, 0.41666666666667
31997, 1.825, 1.05, 0.41666666666667
31998, 1.825, 1, 0.41666666666667
31999, 1.825, 0.95, 0.41666666666667
32000, 1.825, 0.9, 0.41666666666667
32001, 1.825, 0.85, 0.41666666666667
32002, 1.825, 0.8, 0.41666666666667
32003, 1.825, 0.75, 0.41666666666667
32004, 1.825, 0.7, 0.41666666666667
32005, 1.825, 0.65, 0.41666666666667
32006, 1.825, 0.6, 0.41666666666667
32007, 1.825, 0.55, 0.41666666666667
32008, 1.825, 0.5, 0.41666666666667
32009, 1.825, 0.45, 0.41666666666667
32010, 1.825, 0.4, 0.41666666666667
32011, 1.825, 0.35, 0.41666666666667
32012, 1.825, 0.3, 0.41666666666667
32013, 1.825, 0.25, 0.41666666666667
32014, 1.825, 0.2, 0.41666666666667
32015, 1.8666666666667, 1.3, 0.41666666666667
32016, 1.8666666666667, 1.25, 0.41666666666667
32017, 1.8666666666667, 1.2, 0.41666666666667
32018, 1.8666666666667, 1.15, 0.41666666666667
32019, 1.8666666666667, 1.1, 0.41666666666667
32020, 1.8666666666667, 1.05, 0.41666666666667
32021, 1.8666666666667, 1, 0.41666666666667
32022, 1.8666666666667, 0.95, 0.41666666666667
32023, 1.8666666666667, 0.9, 0.41666666666667
32024, 1.8666666666667, 0.85, 0.41666666666667
32025, 1.8666666666667, 0.8, 0.41666666666667
32026, 1.8666666666667, 0.75, 0.41666666666667
32027, 1.8666666666667, 0.7, 0.41666666666667
32028, 1.8666666666667, 0.65, 0.41666666666667
32029, 1.8666666666667, 0.6, 0.41666666666667
32030, 1.8666666666667, 0.55, 0.41666666666667
32031, 1.8666666666667, 0.5, 0.41666666666667
32032, 1.8666666666667, 0.45, 0.41666666666667
32033, 1.8666666666667, 0.4, 0.41666666666667
32034, 1.8666666666667, 0.35, 0.41666666666667
32035, 1.8666666666667, 0.3, 0.41666666666667
32036, 1.8666666666667, 0.25, 0.41666666666667
32037, 1.8666666666667, 0.2, 0.41666666666667
32038, 1.9083333333333, 1.3, 0.41666666666667
32039, 1.9083333333333, 1.25, 0.41666666666667
32040, 1.9083333333333, 1.2, 0.41666666666667
32041, 1.9083333333333, 1.15, 0.41666666666667
32042, 1.9083333333333, 1.1, 0.41666666666667
32043, 1.9083333333333, 1.05, 0.41666666666667
32044, 1.9083333333333, 1, 0.41666666666667
32045, 1.9083333333333, 0.95, 0.41666666666667
32046, 1.9083333333333, 0.9, 0.41666666666667
32047, 1.9083333333333, 0.85, 0.41666666666667
32048, 1.9083333333333, 0.8, 0.41666666666667
32049, 1.9083333333333, 0.75, 0.41666666666667
32050, 1.9083333333333, 0.7, 0.41666666666667
32051, 1.9083333333333, 0.65, 0.41666666666667
32052, 1.9083333333333, 0.6, 0.41666666666667
32053, 1.9083333333333, 0.55, 0.41666666666667
32054, 1.9083333333333, 0.5, 0.41666666666667
32055, 1.9083333333333, 0.45, 0.41666666666667
32056, 1.9083333333333, 0.4, 0.41666666666667
32057, 1.9083333333333, 0.35, 0.41666666666667
32058, 1.9083333333333, 0.3, 0.41666666666667
32059, 1.9083333333333, 0.25, 0.41666666666667
32060, 1.9083333333333, 0.2, 0.41666666666667
32061, 1.95, 1.3, 0.41666666666667
32062, 1.95, 1.25, 0.41666666666667
32063, 1.95, 1.2, 0.41666666666667
32064, 1.95, 1.15, 0.41666666666667
32065, 1.95, 1.1, 0.41666666666667
32066, 1.95, 1.05, 0.41666666666667
32067, 1.95, 1, 0.41666666666667
32068, 1.95, 0.95, 0.41666666666667
32069, 1.95, 0.9, 0.41666666666667
32070, 1.95, 0.85, 0.41666666666667
32071, 1.95, 0.8, 0.41666666666667
32072, 1.95, 0.75, 0.41666666666667
32073, 1.95, 0.7, 0.41666666666667
32074, 1.95, 0.65, 0.41666666666667
32075, 1.95, 0.6, 0.41666666666667
32076, 1.95, 0.55, 0.41666666666667
32077, 1.95, 0.5, 0.41666666666667
32078, 1.95, 0.45, 0.41666666666667
32079, 1.95, 0.4, 0.41666666666667
32080, 1.95, 0.35, 0.41666666666667
32081, 1.95, 0.3, 0.41666666666667
32082, 1.95, 0.25, 0.41666666666667
32083, 1.95, 0.2, 0.41666666666667
32084, 1.9916666666667, 1.3, 0.41666666666667
32085, 1.9916666666667, 1.25, 0.41666666666667
32086, 1.9916666666667, 1.2, 0.41666666666667
32087, 1.9916666666667, 1.15, 0.41666666666667
32088, 1.9916666666667, 1.1, 0.41666666666667
32089, 1.9916666666667, 1.05, 0.41666666666667
32090, 1.9916666666667, 1, 0.41666666666667
32091, 1.9916666666667, 0.95, 0.41666666666667
32092, 1.9916666666667, 0.9, 0.41666666666667
32093, 1.9916666666667, 0.85, 0.41666666666667
32094, 1.9916666666667, 0.8, 0.41666666666667
32095, 1.9916666666667, 0.75, 0.41666666666667
32096, 1.9916666666667, 0.7, 0.41666666666667
32097, 1.9916666666667, 0.65, 0.41666666666667
32098, 1.9916666666667, 0.6, 0.41666666666667
32099, 1.9916666666667, 0.55, 0.41666666666667
32100, 1.9916666666667, 0.5, 0.41666666666667
32101, 1.9916666666667, 0.45, 0.41666666666667
32102, 1.9916666666667, 0.4, 0.41666666666667
32103, 1.9916666666667, 0.35, 0.41666666666667
32104, 1.9916666666667, 0.3, 0.41666666666667
32105, 1.9916666666667, 0.25, 0.41666666666667
32106, 1.9916666666667, 0.2, 0.41666666666667
32107, 2.0333333333333, 1.3, 0.41666666666667
32108, 2.0333333333333, 1.25, 0.41666666666667
32109, 2.0333333333333, 1.2, 0.41666666666667
32110, 2.0333333333333, 1.15, 0.41666666666667
32111, 2.0333333333333, 1.1, 0.41666666666667
32112, 2.0333333333333, 1.05, 0.41666666666667
32113, 2.0333333333333, 1, 0.41666666666667
32114, 2.0333333333333, 0.95, 0.41666666666667
32115, 2.0333333333333, 0.9, 0.41666666666667
32116, 2.0333333333333, 0.85, 0.41666666666667
32117, 2.0333333333333, 0.8, 0.41666666666667
32118, 2.0333333333333, 0.75, 0.41666666666667
32119, 2.0333333333333, 0.7, 0.41666666666667
32120, 2.0333333333333, 0.65, 0.41666666666667
32121, 2.0333333333333, 0.6, 0.41666666666667
32122, 2.0333333333333, 0.55, 0.41666666666667
32123, 2.0333333333333, 0.5, 0.41666666666667
32124, 2.0333333333333, 0.45, 0.41666666666667
32125, 2.0333333333333, 0.4, 0.41666666666667
32126, 2.0333333333333, 0.35, 0.41666666666667
32127, 2.0333333333333, 0.3, 0.41666666666667
32128, 2.0333333333333, 0.25, 0.41666666666667
32129, 2.0333333333333, 0.2, 0.41666666666667
32130, 2.075, 1.3, 0.41666666666667
32131, 2.075, 1.25, 0.41666666666667
32132, 2.075, 1.2, 0.41666666666667
32133, 2.075, 1.15, 0.41666666666667
32134, 2.075, 1.1, 0.41666666666667
32135, 2.075, 1.05, 0.41666666666667
32136, 2.075, 1, 0.41666666666667
32137, 2.075, 0.95, 0.41666666666667
32138, 2.075, 0.9, 0.41666666666667
32139, 2.075, 0.85, 0.41666666666667
32140, 2.075, 0.8, 0.41666666666667
32141, 2.075, 0.75, 0.41666666666667
32142, 2.075, 0.7, 0.41666666666667
32143, 2.075, 0.65, 0.41666666666667
32144, 2.075, 0.6, 0.41666666666667
32145, 2.075, 0.55, 0.41666666666667
32146, 2.075, 0.5, 0.41666666666667
32147, 2.075, 0.45, 0.41666666666667
32148, 2.075, 0.4, 0.41666666666667
32149, 2.075, 0.35, 0.41666666666667
32150, 2.075, 0.3, 0.41666666666667
32151, 2.075, 0.25, 0.41666666666667
32152, 2.075, 0.2, 0.41666666666667
32153, 2.1166666666667, 1.3, 0.41666666666667
32154, 2.1166666666667, 1.25, 0.41666666666667
32155, 2.1166666666667, 1.2, 0.41666666666667
32156, 2.1166666666667, 1.15, 0.41666666666667
32157, 2.1166666666667, 1.1, 0.41666666666667
32158, 2.1166666666667, 1.05, 0.41666666666667
32159, 2.1166666666667, 1, 0.41666666666667
32160, 2.1166666666667, 0.95, 0.41666666666667
32161, 2.1166666666667, 0.9, 0.41666666666667
32162, 2.1166666666667, 0.85, 0.41666666666667
32163, 2.1166666666667, 0.8, 0.41666666666667
32164, 2.1166666666667, 0.75, 0.41666666666667
32165, 2.1166666666667, 0.7, 0.41666666666667
32166, 2.1166666666667, 0.65, 0.41666666666667
32167, 2.1166666666667, 0.6, 0.41666666666667
32168, 2.1166666666667, 0.55, 0.41666666666667
32169, 2.1166666666667, 0.5, 0.41666666666667
32170, 2.1166666666667, 0.45, 0.41666666666667
32171, 2.1166666666667, 0.4, 0.41666666666667
32172, 2.1166666666667, 0.35, 0.41666666666667
32173, 2.1166666666667, 0.3, 0.41666666666667
32174, 2.1166666666667, 0.25, 0.41666666666667
32175, 2.1166666666667, 0.2, 0.41666666666667
32176, 2.1583333333333, 1.3, 0.41666666666667
32177, 2.1583333333333, 1.25, 0.41666666666667
32178, 2.1583333333333, 1.2, 0.41666666666667
32179, 2.1583333333333, 1.15, 0.41666666666667
32180, 2.1583333333333, 1.1, 0.41666666666667
32181, 2.1583333333333, 1.05, 0.41666666666667
32182, 2.1583333333333, 1, 0.41666666666667
32183, 2.1583333333333, 0.95, 0.41666666666667
32184, 2.1583333333333, 0.9, 0.41666666666667
32185, 2.1583333333333, 0.85, 0.41666666666667
32186, 2.1583333333333, 0.8, 0.41666666666667
32187, 2.1583333333333, 0.75, 0.41666666666667
32188, 2.1583333333333, 0.7, 0.41666666666667
32189, 2.1583333333333, 0.65, 0.41666666666667
32190, 2.1583333333333, 0.6, 0.41666666666667
32191, 2.1583333333333, 0.55, 0.41666666666667
32192, 2.1583333333333, 0.5, 0.41666666666667
32193, 2.1583333333333, 0.45, 0.41666666666667
32194, 2.1583333333333, 0.4, 0.41666666666667
32195, 2.1583333333333, 0.35, 0.41666666666667
32196, 2.1583333333333, 0.3, 0.41666666666667
32197, 2.1583333333333, 0.25, 0.41666666666667
32198, 2.1583333333333, 0.2, 0.41666666666667
32199, 1.2416666666667, 1.3, 0.45833333333333
32200, 1.2416666666667, 1.25, 0.45833333333333
32201, 1.2416666666667, 1.2, 0.45833333333333
32202, 1.2416666666667, 1.15, 0.45833333333333
32203, 1.2416666666667, 1.1, 0.45833333333333
32204, 1.2416666666667, 1.05, 0.45833333333333
32205, 1.2416666666667, 1, 0.45833333333333
32206, 1.2416666666667, 0.95, 0.45833333333333
32207, 1.2416666666667, 0.9, 0.45833333333333
32208, 1.2416666666667, 0.85, 0.45833333333333
32209, 1.2416666666667, 0.8, 0.45833333333333
32210, 1.2416666666667, 0.75, 0.45833333333333
32211, 1.2416666666667, 0.7, 0.45833333333333
32212, 1.2416666666667, 0.65, 0.45833333333333
32213, 1.2416666666667, 0.6, 0.45833333333333
32214, 1.2416666666667, 0.55, 0.45833333333333
32215, 1.2416666666667, 0.5, 0.45833333333333
32216, 1.2416666666667, 0.45, 0.45833333333333
32217, 1.2416666666667, 0.4, 0.45833333333333
32218, 1.2416666666667, 0.35, 0.45833333333333
32219, 1.2416666666667, 0.3, 0.45833333333333
32220, 1.2416666666667, 0.25, 0.45833333333333
32221, 1.2416666666667, 0.2, 0.45833333333333
32222, 1.2833333333333, 1.3, 0.45833333333333
32223, 1.2833333333333, 1.25, 0.45833333333333
32224, 1.2833333333333, 1.2, 0.45833333333333
32225, 1.2833333333333, 1.15, 0.45833333333333
32226, 1.2833333333333, 1.1, 0.45833333333333
32227, 1.2833333333333, 1.05, 0.45833333333333
32228, 1.2833333333333, 1, 0.45833333333333
32229, 1.2833333333333, 0.95, 0.45833333333333
32230, 1.2833333333333, 0.9, 0.45833333333333
32231, 1.2833333333333, 0.85, 0.45833333333333
32232, 1.2833333333333, 0.8, 0.45833333333333
32233, 1.2833333333333, 0.75, 0.45833333333333
32234, 1.2833333333333, 0.7, 0.45833333333333
32235, 1.2833333333333, 0.65, 0.45833333333333
32236, 1.2833333333333, 0.6, 0.45833333333333
32237, 1.2833333333333, 0.55, 0.45833333333333
32238, 1.2833333333333, 0.5, 0.45833333333333
32239, 1.2833333333333, 0.45, 0.45833333333333
32240, 1.2833333333333, 0.4, 0.45833333333333
32241, 1.2833333333333, 0.35, 0.45833333333333
32242, 1.2833333333333, 0.3, 0.45833333333333
32243, 1.2833333333333, 0.25, 0.45833333333333
32244, 1.2833333333333, 0.2, 0.45833333333333
32245, 1.325, 1.3, 0.45833333333333
32246, 1.325, 1.25, 0.45833333333333
32247, 1.325, 1.2, 0.45833333333333
32248, 1.325, 1.15, 0.45833333333333
32249, 1.325, 1.1, 0.45833333333333
32250, 1.325, 1.05, 0.45833333333333
32251, 1.325, 1, 0.45833333333333
32252, 1.325, 0.95, 0.45833333333333
32253, 1.325, 0.9, 0.45833333333333
32254, 1.325, 0.85, 0.45833333333333
32255, 1.325, 0.8, 0.45833333333333
32256, 1.325, 0.75, 0.45833333333333
32257, 1.325, 0.7, 0.45833333333333
32258, 1.325, 0.65, 0.45833333333333
32259, 1.325, 0.6, 0.45833333333333
32260, 1.325, 0.55, 0.45833333333333
32261, 1.325, 0.5, 0.45833333333333
32262, 1.325, 0.45, 0.45833333333333
32263, 1.325, 0.4, 0.45833333333333
32264, 1.325, 0.35, 0.45833333333333
32265, 1.325, 0.3, 0.45833333333333
32266, 1.325, 0.25, 0.45833333333333
32267, 1.325, 0.2, 0.45833333333333
32268, 1.3666666666667, 1.3, 0.45833333333333
32269, 1.3666666666667, 1.25, 0.45833333333333
32270, 1.3666666666667, 1.2, 0.45833333333333
32271, 1.3666666666667, 1.15, 0.45833333333333
32272, 1.3666666666667, 1.1, 0.45833333333333
32273, 1.3666666666667, 1.05, 0.45833333333333
32274, 1.3666666666667, 1, 0.45833333333333
32275, 1.3666666666667, 0.95, 0.45833333333333
32276, 1.3666666666667, 0.9, 0.45833333333333
32277, 1.3666666666667, 0.85, 0.45833333333333
32278, 1.3666666666667, 0.8, 0.45833333333333
32279, 1.3666666666667, 0.75, 0.45833333333333
32280, 1.3666666666667, 0.7, 0.45833333333333
32281, 1.3666666666667, 0.65, 0.45833333333333
32282, 1.3666666666667, 0.6, 0.45833333333333
32283, 1.3666666666667, 0.55, 0.45833333333333
32284, 1.3666666666667, 0.5, 0.45833333333333
32285, 1.3666666666667, 0.45, 0.45833333333333
32286, 1.3666666666667, 0.4, 0.45833333333333
32287, 1.3666666666667, 0.35, 0.45833333333333
32288, 1.3666666666667, 0.3, 0.45833333333333
32289, 1.3666666666667, 0.25, 0.45833333333333
32290, 1.3666666666667, 0.2, 0.45833333333333
32291, 1.4083333333333, 1.3, 0.45833333333333
32292, 1.4083333333333, 1.25, 0.45833333333333
32293, 1.4083333333333, 1.2, 0.45833333333333
32294, 1.4083333333333, 1.15, 0.45833333333333
32295, 1.4083333333333, 1.1, 0.45833333333333
32296, 1.4083333333333, 1.05, 0.45833333333333
32297, 1.4083333333333, 1, 0.45833333333333
32298, 1.4083333333333, 0.95, 0.45833333333333
32299, 1.4083333333333, 0.9, 0.45833333333333
32300, 1.4083333333333, 0.85, 0.45833333333333
32301, 1.4083333333333, 0.8, 0.45833333333333
32302, 1.4083333333333, 0.75, 0.45833333333333
32303, 1.4083333333333, 0.7, 0.45833333333333
32304, 1.4083333333333, 0.65, 0.45833333333333
32305, 1.4083333333333, 0.6, 0.45833333333333
32306, 1.4083333333333, 0.55, 0.45833333333333
32307, 1.4083333333333, 0.5, 0.45833333333333
32308, 1.4083333333333, 0.45, 0.45833333333333
32309, 1.4083333333333, 0.4, 0.45833333333333
32310, 1.4083333333333, 0.35, 0.45833333333333
32311, 1.4083333333333, 0.3, 0.45833333333333
32312, 1.4083333333333, 0.25, 0.45833333333333
32313, 1.4083333333333, 0.2, 0.45833333333333
32314, 1.45, 1.3, 0.45833333333333
32315, 1.45, 1.25, 0.45833333333333
32316, 1.45, 1.2, 0.45833333333333
32317, 1.45, 1.15, 0.45833333333333
32318, 1.45, 1.1, 0.45833333333333
32319, 1.45, 1.05, 0.45833333333333
32320, 1.45, 1, 0.45833333333333
32321, 1.45, 0.95, 0.45833333333333
32322, 1.45, 0.9, 0.45833333333333
32323, 1.45, 0.85, 0.45833333333333
32324, 1.45, 0.8, 0.45833333333333
32325, 1.45, 0.75, 0.45833333333333
32326, 1.45, 0.7, 0.45833333333333
32327, 1.45, 0.65, 0.45833333333333
32328, 1.45, 0.6, 0.45833333333333
32329, 1.45, 0.55, 0.45833333333333
32330, 1.45, 0.5, 0.45833333333333
32331, 1.45, 0.45, 0.45833333333333
32332, 1.45, 0.4, 0.45833333333333
32333, 1.45, 0.35, 0.45833333333333
32334, 1.45, 0.3, 0.45833333333333
32335, 1.45, 0.25, 0.45833333333333
32336, 1.45, 0.2, 0.45833333333333
32337, 1.4916666666667, 1.3, 0.45833333333333
32338, 1.4916666666667, 1.25, 0.45833333333333
32339, 1.4916666666667, 1.2, 0.45833333333333
32340, 1.4916666666667, 1.15, 0.45833333333333
32341, 1.4916666666667, 1.1, 0.45833333333333
32342, 1.4916666666667, 1.05, 0.45833333333333
32343, 1.4916666666667, 1, 0.45833333333333
32344, 1.4916666666667, 0.95, 0.45833333333333
32345, 1.4916666666667, 0.9, 0.45833333333333
32346, 1.4916666666667, 0.85, 0.45833333333333
32347, 1.4916666666667, 0.8, 0.45833333333333
32348, 1.4916666666667, 0.75, 0.45833333333333
32349, 1.4916666666667, 0.7, 0.45833333333333
32350, 1.4916666666667, 0.65, 0.45833333333333
32351, 1.4916666666667, 0.6, 0.45833333333333
32352, 1.4916666666667, 0.55, 0.45833333333333
32353, 1.4916666666667, 0.5, 0.45833333333333
32354, 1.4916666666667, 0.45, 0.45833333333333
32355, 1.4916666666667, 0.4, 0.45833333333333
32356, 1.4916666666667, 0.35, 0.45833333333333
32357, 1.4916666666667, 0.3, 0.45833333333333
32358, 1.4916666666667, 0.25, 0.45833333333333
32359, 1.4916666666667, 0.2, 0.45833333333333
32360, 1.5333333333333, 1.3, 0.45833333333333
32361, 1.5333333333333, 1.25, 0.45833333333333
32362, 1.5333333333333, 1.2, 0.45833333333333
32363, 1.5333333333333, 1.15, 0.45833333333333
32364, 1.5333333333333, 1.1, 0.45833333333333
32365, 1.5333333333333, 1.05, 0.45833333333333
32366, 1.5333333333333, 1, 0.45833333333333
32367, 1.5333333333333, 0.95, 0.45833333333333
32368, 1.5333333333333, 0.9, 0.45833333333333
32369, 1.5333333333333, 0.85, 0.45833333333333
32370, 1.5333333333333, 0.8, 0.45833333333333
32371, 1.5333333333333, 0.75, 0.45833333333333
32372, 1.5333333333333, 0.7, 0.45833333333333
32373, 1.5333333333333, 0.65, 0.45833333333333
32374, 1.5333333333333, 0.6, 0.45833333333333
32375, 1.5333333333333, 0.55, 0.45833333333333
32376, 1.5333333333333, 0.5, 0.45833333333333
32377, 1.5333333333333, 0.45, 0.45833333333333
32378, 1.5333333333333, 0.4, 0.45833333333333
32379, 1.5333333333333, 0.35, 0.45833333333333
32380, 1.5333333333333, 0.3, 0.45833333333333
32381, 1.5333333333333, 0.25, 0.45833333333333
32382, 1.5333333333333, 0.2, 0.45833333333333
32383, 1.575, 1.3, 0.45833333333333
32384, 1.575, 1.25, 0.45833333333333
32385, 1.575, 1.2, 0.45833333333333
32386, 1.575, 1.15, 0.45833333333333
32387, 1.575, 1.1, 0.45833333333333
32388, 1.575, 1.05, 0.45833333333333
32389, 1.575, 1, 0.45833333333333
32390, 1.575, 0.95, 0.45833333333333
32391, 1.575, 0.9, 0.45833333333333
32392, 1.575, 0.85, 0.45833333333333
32393, 1.575, 0.8, 0.45833333333333
32394, 1.575, 0.75, 0.45833333333333
32395, 1.575, 0.7, 0.45833333333333
32396, 1.575, 0.65, 0.45833333333333
32397, 1.575, 0.6, 0.45833333333333
32398, 1.575, 0.55, 0.45833333333333
32399, 1.575, 0.5, 0.45833333333333
32400, 1.575, 0.45, 0.45833333333333
32401, 1.575, 0.4, 0.45833333333333
32402, 1.575, 0.35, 0.45833333333333
32403, 1.575, 0.3, 0.45833333333333
32404, 1.575, 0.25, 0.45833333333333
32405, 1.575, 0.2, 0.45833333333333
32406, 1.6166666666667, 1.3, 0.45833333333333
32407, 1.6166666666667, 1.25, 0.45833333333333
32408, 1.6166666666667, 1.2, 0.45833333333333
32409, 1.6166666666667, 1.15, 0.45833333333333
32410, 1.6166666666667, 1.1, 0.45833333333333
32411, 1.6166666666667, 1.05, 0.45833333333333
32412, 1.6166666666667, 1, 0.45833333333333
32413, 1.6166666666667, 0.95, 0.45833333333333
32414, 1.6166666666667, 0.9, 0.45833333333333
32415, 1.6166666666667, 0.85, 0.45833333333333
32416, 1.6166666666667, 0.8, 0.45833333333333
32417, 1.6166666666667, 0.75, 0.45833333333333
32418, 1.6166666666667, 0.7, 0.45833333333333
32419, 1.6166666666667, 0.65, 0.45833333333333
32420, 1.6166666666667, 0.6, 0.45833333333333
32421, 1.6166666666667, 0.55, 0.45833333333333
32422, 1.6166666666667, 0.5, 0.45833333333333
32423, 1.6166666666667, 0.45, 0.45833333333333
32424, 1.6166666666667, 0.4, 0.45833333333333
32425, 1.6166666666667, 0.35, 0.45833333333333
32426, 1.6166666666667, 0.3, 0.45833333333333
32427, 1.6166666666667, 0.25, 0.45833333333333
32428, 1.6166666666667, 0.2, 0.45833333333333
32429, 1.6583333333333, 1.3, 0.45833333333333
32430, 1.6583333333333, 1.25, 0.45833333333333
32431, 1.6583333333333, 1.2, 0.45833333333333
32432, 1.6583333333333, 1.15, 0.45833333333333
32433, 1.6583333333333, 1.1, 0.45833333333333
32434, 1.6583333333333, 1.05, 0.45833333333333
32435, 1.6583333333333, 1, 0.45833333333333
32436, 1.6583333333333, 0.95, 0.45833333333333
32437, 1.6583333333333, 0.9, 0.45833333333333
32438, 1.6583333333333, 0.85, 0.45833333333333
32439, 1.6583333333333, 0.8, 0.45833333333333
32440, 1.6583333333333, 0.75, 0.45833333333333
32441, 1.6583333333333, 0.7, 0.45833333333333
32442, 1.6583333333333, 0.65, 0.45833333333333
32443, 1.6583333333333, 0.6, 0.45833333333333
32444, 1.6583333333333, 0.55, 0.45833333333333
32445, 1.6583333333333, 0.5, 0.45833333333333
32446, 1.6583333333333, 0.45, 0.45833333333333
32447, 1.6583333333333, 0.4, 0.45833333333333
32448, 1.6583333333333, 0.35, 0.45833333333333
32449, 1.6583333333333, 0.3, 0.45833333333333
32450, 1.6583333333333, 0.25, 0.45833333333333
32451, 1.6583333333333, 0.2, 0.45833333333333
32452, 1.7, 1.3, 0.45833333333333
32453, 1.7, 1.25, 0.45833333333333
32454, 1.7, 1.2, 0.45833333333333
32455, 1.7, 1.15, 0.45833333333333
32456, 1.7, 1.1, 0.45833333333333
32457, 1.7, 1.05, 0.45833333333333
32458, 1.7, 1, 0.45833333333333
32459, 1.7, 0.95, 0.45833333333333
32460, 1.7, 0.9, 0.45833333333333
32461, 1.7, 0.85, 0.45833333333333
32462, 1.7, 0.8, 0.45833333333333
32463, 1.7, 0.75, 0.45833333333333
32464, 1.7, 0.7, 0.45833333333333
32465, 1.7, 0.65, 0.45833333333333
32466, 1.7, 0.6, 0.45833333333333
32467, 1.7, 0.55, 0.45833333333333
32468, 1.7, 0.5, 0.45833333333333
32469, 1.7, 0.45, 0.45833333333333
32470, 1.7, 0.4, 0.45833333333333
32471, 1.7, 0.35, 0.45833333333333
32472, 1.7, 0.3, 0.45833333333333
32473, 1.7, 0.25, 0.45833333333333
32474, 1.7, 0.2, 0.45833333333333
32475, 1.7416666666667, 1.3, 0.45833333333333
32476, 1.7416666666667, 1.25, 0.45833333333333
32477, 1.7416666666667, 1.2, 0.45833333333333
32478, 1.7416666666667, 1.15, 0.45833333333333
32479, 1.7416666666667, 1.1, 0.45833333333333
32480, 1.7416666666667, 1.05, 0.45833333333333
32481, 1.7416666666667, 1, 0.45833333333333
32482, 1.7416666666667, 0.95, 0.45833333333333
32483, 1.7416666666667, 0.9, 0.45833333333333
32484, 1.7416666666667, 0.85, 0.45833333333333
32485, 1.7416666666667, 0.8, 0.45833333333333
32486, 1.7416666666667, 0.75, 0.45833333333333
32487, 1.7416666666667, 0.7, 0.45833333333333
32488, 1.7416666666667, 0.65, 0.45833333333333
32489, 1.7416666666667, 0.6, 0.45833333333333
32490, 1.7416666666667, 0.55, 0.45833333333333
32491, 1.7416666666667, 0.5, 0.45833333333333
32492, 1.7416666666667, 0.45, 0.45833333333333
32493, 1.7416666666667, 0.4, 0.45833333333333
32494, 1.7416666666667, 0.35, 0.45833333333333
32495, 1.7416666666667, 0.3, 0.45833333333333
32496, 1.7416666666667, 0.25, 0.45833333333333
32497, 1.7416666666667, 0.2, 0.45833333333333
32498, 1.7833333333333, 1.3, 0.45833333333333
32499, 1.7833333333333, 1.25, 0.45833333333333
32500, 1.7833333333333, 1.2, 0.45833333333333
32501, 1.7833333333333, 1.15, 0.45833333333333
32502, 1.7833333333333, 1.1, 0.45833333333333
32503, 1.7833333333333, 1.05, 0.45833333333333
32504, 1.7833333333333, 1, 0.45833333333333
32505, 1.7833333333333, 0.95, 0.45833333333333
32506, 1.7833333333333, 0.9, 0.45833333333333
32507, 1.7833333333333, 0.85, 0.45833333333333
32508, 1.7833333333333, 0.8, 0.45833333333333
32509, 1.7833333333333, 0.75, 0.45833333333333
32510, 1.7833333333333, 0.7, 0.45833333333333
32511, 1.7833333333333, 0.65, 0.45833333333333
32512, 1.7833333333333, 0.6, 0.45833333333333
32513, 1.7833333333333, 0.55, 0.45833333333333
32514, 1.7833333333333, 0.5, 0.45833333333333
32515, 1.7833333333333, 0.45, 0.45833333333333
32516, 1.7833333333333, 0.4, 0.45833333333333
32517, 1.7833333333333, 0.35, 0.45833333333333
32518, 1.7833333333333, 0.3, 0.45833333333333
32519, 1.7833333333333, 0.25, 0.45833333333333
32520, 1.7833333333333, 0.2, 0.45833333333333
32521, 1.825, 1.3, 0.45833333333333
32522, 1.825, 1.25, 0.45833333333333
32523, 1.825, 1.2, 0.45833333333333
32524, 1.825, 1.15, 0.45833333333333
32525, 1.825, 1.1, 0.45833333333333
32526, 1.825, 1.05, 0.45833333333333
32527, 1.825, 1, 0.45833333333333
32528, 1.825, 0.95, 0.45833333333333
32529, 1.825, 0.9, 0.45833333333333
32530, 1.825, 0.85, 0.45833333333333
32531, 1.825, 0.8, 0.45833333333333
32532, 1.825, 0.75, 0.45833333333333
32533, 1.825, 0.7, 0.45833333333333
32534, 1.825, 0.65, 0.45833333333333
32535, 1.825, 0.6, 0.45833333333333
32536, 1.825, 0.55, 0.45833333333333
32537, 1.825, 0.5, 0.45833333333333
32538, 1.825, 0.45, 0.45833333333333
32539, 1.825, 0.4, 0.45833333333333
32540, 1.825, 0.35, 0.45833333333333
32541, 1.825, 0.3, 0.45833333333333
32542, 1.825, 0.25, 0.45833333333333
32543, 1.825, 0.2, 0.45833333333333
32544, 1.8666666666667, 1.3, 0.45833333333333
32545, 1.8666666666667, 1.25, 0.45833333333333
32546, 1.8666666666667, 1.2, 0.45833333333333
32547, 1.8666666666667, 1.15, 0.45833333333333
32548, 1.8666666666667, 1.1, 0.45833333333333
32549, 1.8666666666667, 1.05, 0.45833333333333
32550, 1.8666666666667, 1, 0.45833333333333
32551, 1.8666666666667, 0.95, 0.45833333333333
32552, 1.8666666666667, 0.9, 0.45833333333333
32553, 1.8666666666667, 0.85, 0.45833333333333
32554, 1.8666666666667, 0.8, 0.45833333333333
32555, 1.8666666666667, 0.75, 0.45833333333333
32556, 1.8666666666667, 0.7, 0.45833333333333
32557, 1.8666666666667, 0.65, 0.45833333333333
32558, 1.8666666666667, 0.6, 0.45833333333333
32559, 1.8666666666667, 0.55, 0.45833333333333
32560, 1.8666666666667, 0.5, 0.45833333333333
32561, 1.8666666666667, 0.45, 0.45833333333333
32562, 1.8666666666667, 0.4, 0.45833333333333
32563, 1.8666666666667, 0.35, 0.45833333333333
32564, 1.8666666666667, 0.3, 0.45833333333333
32565, 1.8666666666667, 0.25, 0.45833333333333
32566, 1.8666666666667, 0.2, 0.45833333333333
32567, 1.9083333333333, 1.3, 0.45833333333333
32568, 1.9083333333333, 1.25, 0.45833333333333
32569, 1.9083333333333, 1.2, 0.45833333333333
32570, 1.9083333333333, 1.15, 0.45833333333333
32571, 1.9083333333333, 1.1, 0.45833333333333
32572, 1.9083333333333, 1.05, 0.45833333333333
32573, 1.9083333333333, 1, 0.45833333333333
32574, 1.9083333333333, 0.95, 0.45833333333333
32575, 1.9083333333333, 0.9, 0.45833333333333
32576, 1.9083333333333, 0.85, 0.45833333333333
32577, 1.9083333333333, 0.8, 0.45833333333333
32578, 1.9083333333333, 0.75, 0.45833333333333
32579, 1.9083333333333, 0.7, 0.45833333333333
32580, 1.9083333333333, 0.65, 0.45833333333333
32581, 1.9083333333333, 0.6, 0.45833333333333
32582, 1.9083333333333, 0.55, 0.45833333333333
32583, 1.9083333333333, 0.5, 0.45833333333333
32584, 1.9083333333333, 0.45, 0.45833333333333
32585, 1.9083333333333, 0.4, 0.45833333333333
32586, 1.9083333333333, 0.35, 0.45833333333333
32587, 1.9083333333333, 0.3, 0.45833333333333
32588, 1.9083333333333, 0.25, 0.45833333333333
32589, 1.9083333333333, 0.2, 0.45833333333333
32590, 1.95, 1.3, 0.45833333333333
32591, 1.95, 1.25, 0.45833333333333
32592, 1.95, 1.2, 0.45833333333333
32593, 1.95, 1.15, 0.45833333333333
32594, 1.95, 1.1, 0.45833333333333
32595, 1.95, 1.05, 0.45833333333333
32596, 1.95, 1, 0.45833333333333
32597, 1.95, 0.95, 0.45833333333333
32598, 1.95, 0.9, 0.45833333333333
32599, 1.95, 0.85, 0.45833333333333
32600, 1.95, 0.8, 0.45833333333333
32601, 1.95, 0.75, 0.45833333333333
32602, 1.95, 0.7, 0.45833333333333
32603, 1.95, 0.65, 0.45833333333333
32604, 1.95, 0.6, 0.45833333333333
32605, 1.95, 0.55, 0.45833333333333
32606, 1.95, 0.5, 0.45833333333333
32607, 1.95, 0.45, 0.45833333333333
32608, 1.95, 0.4, 0.45833333333333
32609, 1.95, 0.35, 0.45833333333333
32610, 1.95, 0.3, 0.45833333333333
32611, 1.95, 0.25, 0.45833333333333
32612, 1.95, 0.2, 0.45833333333333
32613, 1.9916666666667, 1.3, 0.45833333333333
32614, 1.9916666666667, 1.25, 0.45833333333333
32615, 1.9916666666667, 1.2, 0.45833333333333
32616, 1.9916666666667, 1.15, 0.45833333333333
32617, 1.9916666666667, 1.1, 0.45833333333333
32618, 1.9916666666667, 1.05, 0.45833333333333
32619, 1.9916666666667, 1, 0.45833333333333
32620, 1.9916666666667, 0.95, 0.45833333333333
32621, 1.9916666666667, 0.9, 0.45833333333333
32622, 1.9916666666667, 0.85, 0.45833333333333
32623, 1.9916666666667, 0.8, 0.45833333333333
32624, 1.9916666666667, 0.75, 0.45833333333333
32625, 1.9916666666667, 0.7, 0.45833333333333
32626, 1.9916666666667, 0.65, 0.45833333333333
32627, 1.9916666666667, 0.6, 0.45833333333333
32628, 1.9916666666667, 0.55, 0.45833333333333
32629, 1.9916666666667, 0.5, 0.45833333333333
32630, 1.9916666666667, 0.45, 0.45833333333333
32631, 1.9916666666667, 0.4, 0.45833333333333
32632, 1.9916666666667, 0.35, 0.45833333333333
32633, 1.9916666666667, 0.3, 0.45833333333333
32634, 1.9916666666667, 0.25, 0.45833333333333
32635, 1.9916666666667, 0.2, 0.45833333333333
32636, 2.0333333333333, 1.3, 0.45833333333333
32637, 2.0333333333333, 1.25, 0.45833333333333
32638, 2.0333333333333, 1.2, 0.45833333333333
32639, 2.0333333333333, 1.15, 0.45833333333333
32640, 2.0333333333333, 1.1, 0.45833333333333
32641, 2.0333333333333, 1.05, 0.45833333333333
32642, 2.0333333333333, 1, 0.45833333333333
32643, 2.0333333333333, 0.95, 0.45833333333333
32644, 2.0333333333333, 0.9, 0.45833333333333
32645, 2.0333333333333, 0.85, 0.45833333333333
32646, 2.0333333333333, 0.8, 0.45833333333333
32647, 2.0333333333333, 0.75, 0.45833333333333
32648, 2.0333333333333, 0.7, 0.45833333333333
32649, 2.0333333333333, 0.65, 0.45833333333333
32650, 2.0333333333333, 0.6, 0.45833333333333
32651, 2.0333333333333, 0.55, 0.45833333333333
32652, 2.0333333333333, 0.5, 0.45833333333333
32653, 2.0333333333333, 0.45, 0.45833333333333
32654, 2.0333333333333, 0.4, 0.45833333333333
32655, 2.0333333333333, 0.35, 0.45833333333333
32656, 2.0333333333333, 0.3, 0.45833333333333
32657, 2.0333333333333, 0.25, 0.45833333333333
32658, 2.0333333333333, 0.2, 0.45833333333333
32659, 2.075, 1.3, 0.45833333333333
32660, 2.075, 1.25, 0.45833333333333
32661, 2.075, 1.2, 0.45833333333333
32662, 2.075, 1.15, 0.45833333333333
32663, 2.075, 1.1, 0.45833333333333
32664, 2.075, 1.05, 0.45833333333333
32665, 2.075, 1, 0.45833333333333
32666, 2.075, 0.95, 0.45833333333333
32667, 2.075, 0.9, 0.45833333333333
32668, 2.075, 0.85, 0.45833333333333
32669, 2.075, 0.8, 0.45833333333333
32670, 2.075, 0.75, 0.45833333333333
32671, 2.075, 0.7, 0.45833333333333
32672, 2.075, 0.65, 0.45833333333333
32673, 2.075, 0.6, 0.45833333333333
32674, 2.075, 0.55, 0.45833333333333
32675, 2.075, 0.5, 0.45833333333333
32676, 2.075, 0.45, 0.45833333333333
32677, 2.075, 0.4, 0.45833333333333
32678, 2.075, 0.35, 0.45833333333333
32679, 2.075, 0.3, 0.45833333333333
32680, 2.075, 0.25, 0.45833333333333
32681, 2.075, 0.2, 0.45833333333333
32682, 2.1166666666667, 1.3, 0.45833333333333
32683, 2.1166666666667, 1.25, 0.45833333333333
32684, 2.1166666666667, 1.2, 0.45833333333333
32685, 2.1166666666667, 1.15, 0.45833333333333
32686, 2.1166666666667, 1.1, 0.45833333333333
32687, 2.1166666666667, 1.05, 0.45833333333333
32688, 2.1166666666667, 1, 0.45833333333333
32689, 2.1166666666667, 0.95, 0.45833333333333
32690, 2.1166666666667, 0.9, 0.45833333333333
32691, 2.1166666666667, 0.85, 0.45833333333333
32692, 2.1166666666667, 0.8, 0.45833333333333
32693, 2.1166666666667, 0.75, 0.45833333333333
32694, 2.1166666666667, 0.7, 0.45833333333333
32695, 2.1166666666667, 0.65, 0.45833333333333
32696, 2.1166666666667, 0.6, 0.45833333333333
32697, 2.1166666666667, 0.55, 0.45833333333333
32698, 2.1166666666667, 0.5, 0.45833333333333
32699, 2.1166666666667, 0.45, 0.45833333333333
32700, 2.1166666666667, 0.4, 0.45833333333333
32701, 2.1166666666667, 0.35, 0.45833333333333
32702, 2.1166666666667, 0.3, 0.45833333333333
32703, 2.1166666666667, 0.25, 0.45833333333333
32704, 2.1166666666667, 0.2, 0.45833333333333
32705, 2.1583333333333, 1.3, 0.45833333333333
32706, 2.1583333333333, 1.25, 0.45833333333333
