3742, 15829, 15833, 15834, 15830, 0, 0, 0, 0
3743, 15830, 15834, 15835, 15831, 0, 0, 0, 0
3744, 15831, 15835, 2057, 2056, 0, 0, 0, 0
3745, 601, 602, 15836, 15832, 0, 0, 0, 0
3746, 15832, 15836, 15837, 15833, 0, 0, 0, 0
3747, 15833, 15837, 15838, 15834, 0, 0, 0, 0
3748, 15834, 15838, 15839, 15835, 0, 0, 0, 0
3749, 15835, 15839, 2058, 2057, 0, 0, 0, 0
3750, 602, 23, 2017, 15836, 0, 0, 0, 0
3751, 15836, 2017, 2018, 15837, 0, 0, 0, 0
3752, 15837, 2018, 2019, 15838, 0, 0, 0, 0
3753, 15838, 2019, 2020, 15839, 0, 0, 0, 0
3754, 15839, 2020, 79, 2058, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface108
41220, 22, 603, 15840, 1985, 0, 15884, 15885, 1989
41221, 1985, 15840, 15841, 1986, 15885, 15886, 15887, 1990
41222, 1986, 15841, 15842, 1987, 15887, 15888, 15889, 1991
41223, 1987, 15842, 15843, 1988, 15889, 15890, 15891, 1992
41224, 1988, 15843, 2059, 78, 15891, 15892, 0, 1993
41225, 603, 604, 15844, 15840, 0, 15893, 15894, 15884
41226, 15840, 15844, 15845, 15841, 15894, 15895, 15896, 15886
41227, 15841, 15845, 15846, 15842, 15896, 15897, 15898, 15888
41228, 15842, 15846, 15847, 15843, 15898, 15899, 15900, 15890
41229, 15843, 15847, 2060, 2059, 15900, 15901, 0, 15892
41230, 604, 605, 15848, 15844, 0, 15902, 15903, 15893
41231, 15844, 15848, 15849, 15845, 15903, 15904, 15905, 15895
41232, 15845, 15849, 15850, 15846, 15905, 15906, 15907, 15897
41233, 15846, 15850, 15851, 15847, 15907, 15908, 15909, 15899
41234, 15847, 15851, 2061, 2060, 15909, 15910, 0, 15901
41235, 605, 606, 15852, 15848, 0, 15911, 15912, 15902
41236, 15848, 15852, 15853, 15849, 15912, 15913, 15914, 15904
41237, 15849, 15853, 15854, 15850, 15914, 15915, 15916, 15906
41238, 15850, 15854, 15855, 15851, 15916, 15917, 15918, 15908
41239, 15851, 15855, 2062, 2061, 15918, 15919, 0, 15910
41240, 606, 607, 15856, 15852, 0, 15920, 15921, 15911
41241, 15852, 15856, 15857, 15853, 15921, 15922, 15923, 15913
41242, 15853, 15857, 15858, 15854, 15923, 15924, 15925, 15915
41243, 15854, 15858, 15859, 15855, 15925, 15926, 15927, 15917
41244, 15855, 15859, 2063, 2062, 15927, 15928, 0, 15919
41245, 607, 608, 15860, 15856, 0, 15929, 15930, 15920
41246, 15856, 15860, 15861, 15857, 15930, 15931, 15932, 15922
41247, 15857, 15861, 15862, 15858, 15932, 15933, 15934, 15924
41248, 15858, 15862, 15863, 15859, 15934, 15935, 15936, 15926
41249, 15859, 15863, 2064, 2063, 15936, 15937, 0, 15928
41250, 608, 609, 15864, 15860, 0, 15938, 15939, 15929
41251, 15860, 15864, 15865, 15861, 15939, 15940, 15941, 15931
41252, 15861, 15865, 15866, 15862, 15941, 15942, 15943, 15933
41253, 15862, 15866, 15867, 15863, 15943, 15944, 15945, 15935
41254, 15863, 15867, 2065, 2064, 15945, 15946, 0, 15937
41255, 609, 610, 15868, 15864, 0, 15947, 15948, 15938
41256, 15864, 15868, 15869, 15865, 15948, 15949, 15950, 15940
41257, 15865, 15869, 15870, 15866, 15950, 15951, 15952, 15942
41258, 15866, 15870, 15871, 15867, 15952, 15953, 15954, 15944
41259, 15867, 15871, 2066, 2065, 15954, 15955, 0, 15946
41260, 610, 611, 15872, 15868, 0, 15956, 15957, 15947
41261, 15868, 15872, 15873, 15869, 15957, 15958, 15959, 15949
41262, 15869, 15873, 15874, 15870, 15959, 15960, 15961, 15951
41263, 15870, 15874, 15875, 15871, 15961, 15962, 15963, 15953
41264, 15871, 15875, 2067, 2066, 15963, 15964, 0, 15955
41265, 611, 612, 15876, 15872, 0, 15965, 15966, 15956
41266, 15872, 15876, 15877, 15873, 15966, 15967, 15968, 15958
41267, 15873, 15877, 15878, 15874, 15968, 15969, 15970, 15960
41268, 15874, 15878, 15879, 15875, 15970, 15971, 15972, 15962
41269, 15875, 15879, 2068, 2067, 15972, 15973, 0, 15964
41270, 612, 613, 15880, 15876, 0, 15974, 15975, 15965
41271, 15876, 15880, 15881, 15877, 15975, 15976, 15977, 15967
41272, 15877, 15881, 15882, 15878, 15977, 15978, 15979, 15969
41273, 15878, 15882, 15883, 15879, 15979, 15980, 15981, 15971
41274, 15879, 15883, 2069, 2068, 15981, 15982, 0, 15973
41275, 613, 24, 2032, 15880, 0, 0, 15983, 15974
41276, 15880, 2032, 2033, 15881, 15983, 0, 15984, 15976
41277, 15881, 2033, 2034, 15882, 15984, 0, 15985, 15978
41278, 15882, 2034, 2035, 15883, 15985, 0, 15986, 15980
41279, 15883, 2035, 80, 2069, 15986, 0, 0, 15982
*ELEMENT, type=CPS8, ELSET=Surface109
3755, 78, 2059, 15987, 1994, 0, 0, 0, 0
3756, 2059, 2060, 15988, 15987, 0, 0, 0, 0
3757, 2060, 2061, 15989, 15988, 0, 0, 0, 0
3758, 2061, 2062, 15990, 15989, 0, 0, 0, 0
3759, 2062, 2063, 15991, 15990, 0, 0, 0, 0
3760, 2063, 2064, 15992, 15991, 0, 0, 0, 0
3761, 2064, 2065, 15993, 15992, 0, 0, 0, 0
3762, 2065, 2066, 15994, 15993, 0, 0, 0, 0
3763, 2066, 2067, 15995, 15994, 0, 0, 0, 0
3764, 2067, 2068, 15996, 15995, 0, 0, 0, 0
3765, 2068, 2069, 15997, 15996, 0, 0, 0, 0
3766, 2069, 80, 2036, 15997, 0, 0, 0, 0
3767, 1994, 15987, 15998, 1995, 0, 0, 0, 0
3768, 15987, 15988, 15999, 15998, 0, 0, 0, 0
3769, 15988, 15989, 16000, 15999, 0, 0, 0, 0
3770, 15989, 15990, 16001, 16000, 0, 0, 0, 0
3771, 15990, 15991, 16002, 16001, 0, 0, 0, 0
3772, 15991, 15992, 16003, 16002, 0, 0, 0, 0
3773, 15992, 15993, 16004, 16003, 0, 0, 0, 0
3774, 15993, 15994, 16005, 16004, 0, 0, 0, 0
3775, 15994, 15995, 16006, 16005, 0, 0, 0, 0
3776, 15995, 15996, 16007, 16006, 0, 0, 0, 0
3777, 15996, 15997, 16008, 16007, 0, 0, 0, 0
3778, 15997, 2036, 2037, 16008, 0, 0, 0, 0
3779, 1995, 15998, 16009, 1996, 0, 0, 0, 0
3780, 15998, 15999, 16010, 16009, 0, 0, 0, 0
3781, 15999, 16000, 16011, 16010, 0, 0, 0, 0
3782, 16000, 16001, 16012, 16011, 0, 0, 0, 0
3783, 16001, 16002, 16013, 16012, 0, 0, 0, 0
3784, 16002, 16003, 16014, 16013, 0, 0, 0, 0
3785, 16003, 16004, 16015, 16014, 0, 0, 0, 0
3786, 16004, 16005, 16016, 16015, 0, 0, 0, 0
3787, 16005, 16006, 16017, 16016, 0, 0, 0, 0
3788, 16006, 16007, 16018, 16017, 0, 0, 0, 0
3789, 16007, 16008, 16019, 16018, 0, 0, 0, 0
3790, 16008, 2037, 2038, 16019, 0, 0, 0, 0
3791, 1996, 16009, 16020, 1997, 0, 0, 0, 0
3792, 16009, 16010, 16021, 16020, 0, 0, 0, 0
3793, 16010, 16011, 16022, 16021, 0, 0, 0, 0
3794, 16011, 16012, 16023, 16022, 0, 0, 0, 0
3795, 16012, 16013, 16024, 16023, 0, 0, 0, 0
3796, 16013, 16014, 16025, 16024, 0, 0, 0, 0
3797, 16014, 16015, 16026, 16025, 0, 0, 0, 0
3798, 16015, 16016, 16027, 16026, 0, 0, 0, 0
3799, 16016, 16017, 16028, 16027, 0, 0, 0, 0
3800, 16017, 16018, 16029, 16028, 0, 0, 0, 0
3801, 16018, 16019, 16030, 16029, 0, 0, 0, 0
3802, 16019, 2038, 2039, 16030, 0, 0, 0, 0
3803, 1997, 16020, 16031, 1998, 0, 0, 0, 0
3804, 16020, 16021, 16032, 16031, 0, 0, 0, 0
3805, 16021, 16022, 16033, 16032, 0, 0, 0, 0
3806, 16022, 16023, 16034, 16033, 0, 0, 0, 0
3807, 16023, 16024, 16035, 16034, 0, 0, 0, 0
3808, 16024, 16025, 16036, 16035, 0, 0, 0, 0
3809, 16025, 16026, 16037, 16036, 0, 0, 0, 0
3810, 16026, 16027, 16038, 16037, 0, 0, 0, 0
3811, 16027, 16028, 16039, 16038, 0, 0, 0, 0
3812, 16028, 16029, 16040, 16039, 0, 0, 0, 0
3813, 16029, 16030, 16041, 16040, 0, 0, 0, 0
3814, 16030, 2039, 2040, 16041, 0, 0, 0, 0
3815, 1998, 16031, 16042, 1999, 0, 0, 0, 0
3816, 16031, 16032, 16043, 16042, 0, 0, 0, 0
3817, 16032, 16033, 16044, 16043, 0, 0, 0, 0
3818, 16033, 16034, 16045, 16044, 0, 0, 0, 0
3819, 16034, 16035, 16046, 16045, 0, 0, 0, 0
3820, 16035, 16036, 16047, 16046, 0, 0, 0, 0
3821, 16036, 16037, 16048, 16047, 0, 0, 0, 0
3822, 16037, 16038, 16049, 16048, 0, 0, 0, 0
3823, 16038, 16039, 16050, 16049, 0, 0, 0, 0
3824, 16039, 16040, 16051, 16050, 0, 0, 0, 0
3825, 16040, 16041, 16052, 16051, 0, 0, 0, 0
3826, 16041, 2040, 2041, 16052, 0, 0, 0, 0
3827, 1999, 16042, 16053, 2000, 0, 0, 0, 0
3828, 16042, 16043, 16054, 16053, 0, 0, 0, 0
3829, 16043, 16044, 16055, 16054, 0, 0, 0, 0
3830, 16044, 16045, 16056, 16055, 0, 0, 0, 0
3831, 16045, 16046, 16057, 16056, 0, 0, 0, 0
3832, 16046, 16047, 16058, 16057, 0, 0, 0, 0
3833, 16047, 16048, 16059, 16058, 0, 0, 0, 0
3834, 16048, 16049, 16060, 16059, 0, 0, 0, 0
3835, 16049, 16050, 16061, 16060, 0, 0, 0, 0
3836, 16050, 16051, 16062, 16061, 0, 0, 0, 0
3837, 16051, 16052, 16063, 16062, 0, 0, 0, 0
3838, 16052, 2041, 2042, 16063, 0, 0, 0, 0
3839, 2000, 16053, 16064, 2001, 0, 0, 0, 0
3840, 16053, 16054, 16065, 16064, 0, 0, 0, 0
3841, 16054, 16055, 16066, 16065, 0, 0, 0, 0
3842, 16055, 16056, 16067, 16066, 0, 0, 0, 0
3843, 16056, 16057, 16068, 16067, 0, 0, 0, 0
3844, 16057, 16058, 16069, 16068, 0, 0, 0, 0
3845, 16058, 16059, 16070, 16069, 0, 0, 0, 0
3846, 16059, 16060, 16071, 16070, 0, 0, 0, 0
3847, 16060, 16061, 16072, 16071, 0, 0, 0, 0
3848, 16061, 16062, 16073, 16072, 0, 0, 0, 0
3849, 16062, 16063, 16074, 16073, 0, 0, 0, 0
3850, 16063, 2042, 2043, 16074, 0, 0, 0, 0
3851, 2001, 16064, 16075, 2002, 0, 0, 0, 0
3852, 16064, 16065, 16076, 16075, 0, 0, 0, 0
3853, 16065, 16066, 16077, 16076, 0, 0, 0, 0
3854, 16066, 16067, 16078, 16077, 0, 0, 0, 0
3855, 16067, 16068, 16079, 16078, 0, 0, 0, 0
3856, 16068, 16069, 16080, 16079, 0, 0, 0, 0
3857, 16069, 16070, 16081, 16080, 0, 0, 0, 0
3858, 16070, 16071, 16082, 16081, 0, 0, 0, 0
3859, 16071, 16072, 16083, 16082, 0, 0, 0, 0
3860, 16072, 16073, 16084, 16083, 0, 0, 0, 0
3861, 16073, 16074, 16085, 16084, 0, 0, 0, 0
3862, 16074, 2043, 2044, 16085, 0, 0, 0, 0
3863, 2002, 16075, 16086, 2003, 0, 0, 0, 0
3864, 16075, 16076, 16087, 16086, 0, 0, 0, 0
3865, 16076, 16077, 16088, 16087, 0, 0, 0, 0
3866, 16077, 16078, 16089, 16088, 0, 0, 0, 0
3867, 16078, 16079, 16090, 16089, 0, 0, 0, 0
3868, 16079, 16080, 16091, 16090, 0, 0, 0, 0
3869, 16080, 16081, 16092, 16091, 0, 0, 0, 0
3870, 16081, 16082, 16093, 16092, 0, 0, 0, 0
3871, 16082, 16083, 16094, 16093, 0, 0, 0, 0
3872, 16083, 16084, 16095, 16094, 0, 0, 0, 0
3873, 16084, 16085, 16096, 16095, 0, 0, 0, 0
3874, 16085, 2044, 2045, 16096, 0, 0, 0, 0
3875, 2003, 16086, 16097, 2004, 0, 0, 0, 0
3876, 16086, 16087, 16098, 16097, 0, 0, 0, 0
3877, 16087, 16088, 16099, 16098, 0, 0, 0, 0
3878, 16088, 16089, 16100, 16099, 0, 0, 0, 0
3879, 16089, 16090, 16101, 16100, 0, 0, 0, 0
3880, 16090, 16091, 16102, 16101, 0, 0, 0, 0
3881, 16091, 16092, 16103, 16102, 0, 0, 0, 0
3882, 16092, 16093, 16104, 16103, 0, 0, 0, 0
3883, 16093, 16094, 16105, 16104, 0, 0, 0, 0
3884, 16094, 16095, 16106, 16105, 0, 0, 0, 0
3885, 16095, 16096, 16107, 16106, 0, 0, 0, 0
3886, 16096, 2045, 2046, 16107, 0, 0, 0, 0
3887, 2004, 16097, 16108, 2005, 0, 0, 0, 0
3888, 16097, 16098, 16109, 16108, 0, 0, 0, 0
3889, 16098, 16099, 16110, 16109, 0, 0, 0, 0
3890, 16099, 16100, 16111, 16110, 0, 0, 0, 0
3891, 16100, 16101, 16112, 16111, 0, 0, 0, 0
3892, 16101, 16102, 16113, 16112, 0, 0, 0, 0
3893, 16102, 16103, 16114, 16113, 0, 0, 0, 0
3894, 16103, 16104, 16115, 16114, 0, 0, 0, 0
3895, 16104, 16105, 16116, 16115, 0, 0, 0, 0
3896, 16105, 16106, 16117, 16116, 0, 0, 0, 0
3897, 16106, 16107, 16118, 16117, 0, 0, 0, 0
3898, 16107, 2046, 2047, 16118, 0, 0, 0, 0
3899, 2005, 16108, 16119, 2006, 0, 0, 0, 0
3900, 16108, 16109, 16120, 16119, 0, 0, 0, 0
3901, 16109, 16110, 16121, 16120, 0, 0, 0, 0
3902, 16110, 16111, 16122, 16121, 0, 0, 0, 0
3903, 16111, 16112, 16123, 16122, 0, 0, 0, 0
3904, 16112, 16113, 16124, 16123, 0, 0, 0, 0
3905, 16113, 16114, 16125, 16124, 0, 0, 0, 0
3906, 16114, 16115, 16126, 16125, 0, 0, 0, 0
3907, 16115, 16116, 16127, 16126, 0, 0, 0, 0
3908, 16116, 16117, 16128, 16127, 0, 0, 0, 0
3909, 16117, 16118, 16129, 16128, 0, 0, 0, 0
3910, 16118, 2047, 2048, 16129, 0, 0, 0, 0
3911, 2006, 16119, 16130, 2007, 0, 0, 0, 0
3912, 16119, 16120, 16131, 16130, 0, 0, 0, 0
3913, 16120, 16121, 16132, 16131, 0, 0, 0, 0
3914, 16121, 16122, 16133, 16132, 0, 0, 0, 0
3915, 16122, 16123, 16134, 16133, 0, 0, 0, 0
3916, 16123, 16124, 16135, 16134, 0, 0, 0, 0
3917, 16124, 16125, 16136, 16135, 0, 0, 0, 0
3918, 16125, 16126, 16137, 16136, 0, 0, 0, 0
3919, 16126, 16127, 16138, 16137, 0, 0, 0, 0
3920, 16127, 16128, 16139, 16138, 0, 0, 0, 0
3921, 16128, 16129, 16140, 16139, 0, 0, 0, 0
3922, 16129, 2048, 2049, 16140, 0, 0, 0, 0
3923, 2007, 16130, 16141, 2008, 0, 0, 0, 0
3924, 16130, 16131, 16142, 16141, 0, 0, 0, 0
3925, 16131, 16132, 16143, 16142, 0, 0, 0, 0
3926, 16132, 16133, 16144, 16143, 0, 0, 0, 0
3927, 16133, 16134, 16145, 16144, 0, 0, 0, 0
3928, 16134, 16135, 16146, 16145, 0, 0, 0, 0
3929, 16135, 16136, 16147, 16146, 0, 0, 0, 0
3930, 16136, 16137, 16148, 16147, 0, 0, 0, 0
3931, 16137, 16138, 16149, 16148, 0, 0, 0, 0
3932, 16138, 16139, 16150, 16149, 0, 0, 0, 0
3933, 16139, 16140, 16151, 16150, 0, 0, 0, 0
3934, 16140, 2049, 2050, 16151, 0, 0, 0, 0
3935, 2008, 16141, 16152, 2009, 0, 0, 0, 0
3936, 16141, 16142, 16153, 16152, 0, 0, 0, 0
3937, 16142, 16143, 16154, 16153, 0, 0, 0, 0
3938, 16143, 16144, 16155, 16154, 0, 0, 0, 0
3939, 16144, 16145, 16156, 16155, 0, 0, 0, 0
3940, 16145, 16146, 16157, 16156, 0, 0, 0, 0
3941, 16146, 16147, 16158, 16157, 0, 0, 0, 0
3942, 16147, 16148, 16159, 16158, 0, 0, 0, 0
3943, 16148, 16149, 16160, 16159, 0, 0, 0, 0
3944, 16149, 16150, 16161, 16160, 0, 0, 0, 0
3945, 16150, 16151, 16162, 16161, 0, 0, 0, 0
3946, 16151, 2050, 2051, 16162, 0, 0, 0, 0
3947, 2009, 16152, 16163, 2010, 0, 0, 0, 0
3948, 16152, 16153, 16164, 16163, 0, 0, 0, 0
3949, 16153, 16154, 16165, 16164, 0, 0, 0, 0
3950, 16154, 16155, 16166, 16165, 0, 0, 0, 0
3951, 16155, 16156, 16167, 16166, 0, 0, 0, 0
3952, 16156, 16157, 16168, 16167, 0, 0, 0, 0
3953, 16157, 16158, 16169, 16168, 0, 0, 0, 0
3954, 16158, 16159, 16170, 16169, 0, 0, 0, 0
3955, 16159, 16160, 16171, 16170, 0, 0, 0, 0
3956, 16160, 16161, 16172, 16171, 0, 0, 0, 0
3957, 16161, 16162, 16173, 16172, 0, 0, 0, 0
3958, 16162, 2051, 2052, 16173, 0, 0, 0, 0
3959, 2010, 16163, 16174, 2011, 0, 0, 0, 0
3960, 16163, 16164, 16175, 16174, 0, 0, 0, 0
3961, 16164, 16165, 16176, 16175, 0, 0, 0, 0
3962, 16165, 16166, 16177, 16176, 0, 0, 0, 0
3963, 16166, 16167, 16178, 16177, 0, 0, 0, 0
3964, 16167, 16168, 16179, 16178, 0, 0, 0, 0
3965, 16168, 16169, 16180, 16179, 0, 0, 0, 0
3966, 16169, 16170, 16181, 16180, 0, 0, 0, 0
3967, 16170, 16171, 16182, 16181, 0, 0, 0, 0
3968, 16171, 16172, 16183, 16182, 0, 0, 0, 0
3969, 16172, 16173, 16184, 16183, 0, 0, 0, 0
3970, 16173, 2052, 2053, 16184, 0, 0, 0, 0
3971, 2011, 16174, 16185, 2012, 0, 0, 0, 0
3972, 16174, 16175, 16186, 16185, 0, 0, 0, 0
3973, 16175, 16176, 16187, 16186, 0, 0, 0, 0
3974, 16176, 16177, 16188, 16187, 0, 0, 0, 0
3975, 16177, 16178, 16189, 16188, 0, 0, 0, 0
3976, 16178, 16179, 16190, 16189, 0, 0, 0, 0
3977, 16179, 16180, 16191, 16190, 0, 0, 0, 0
3978, 16180, 16181, 16192, 16191, 0, 0, 0, 0
3979, 16181, 16182, 16193, 16192, 0, 0, 0, 0
3980, 16182, 16183, 16194, 16193, 0, 0, 0, 0
3981, 16183, 16184, 16195, 16194, 0, 0, 0, 0
3982, 16184, 2053, 2054, 16195, 0, 0, 0, 0
3983, 2012, 16185, 16196, 2013, 0, 0, 0, 0
3984, 16185, 16186, 16197, 16196, 0, 0, 0, 0
3985, 16186, 16187, 16198, 16197, 0, 0, 0, 0
3986, 16187, 16188, 16199, 16198, 0, 0, 0, 0
3987, 16188, 16189, 16200, 16199, 0, 0, 0, 0
3988, 16189, 16190, 16201, 16200, 0, 0, 0, 0
3989, 16190, 16191, 16202, 16201, 0, 0, 0, 0
3990, 16191, 16192, 16203, 16202, 0, 0, 0, 0
3991, 16192, 16193, 16204, 16203, 0, 0, 0, 0
3992, 16193, 16194, 16205, 16204, 0, 0, 0, 0
3993, 16194, 16195, 16206, 16205, 0, 0, 0, 0
3994, 16195, 2054, 2055, 16206, 0, 0, 0, 0
3995, 2013, 16196, 16207, 2014, 0, 0, 0, 0
3996, 16196, 16197, 16208, 16207, 0, 0, 0, 0
3997, 16197, 16198, 16209, 16208, 0, 0, 0, 0
3998, 16198, 16199, 16210, 16209, 0, 0, 0, 0
3999, 16199, 16200, 16211, 16210, 0, 0, 0, 0
4000, 16200, 16201, 16212, 16211, 0, 0, 0, 0
4001, 16201, 16202, 16213, 16212, 0, 0, 0, 0
4002, 16202, 16203, 16214, 16213, 0, 0, 0, 0
4003, 16203, 16204, 16215, 16214, 0, 0, 0, 0
4004, 16204, 16205, 16216, 16215, 0, 0, 0, 0
4005, 16205, 16206, 16217, 16216, 0, 0, 0, 0
4006, 16206, 2055, 2056, 16217, 0, 0, 0, 0
4007, 2014, 16207, 16218, 2015, 0, 0, 0, 0
4008, 16207, 16208, 16219, 16218, 0, 0, 0, 0
4009, 16208, 16209, 16220, 16219, 0, 0, 0, 0
4010, 16209, 16210, 16221, 16220, 0, 0, 0, 0
4011, 16210, 16211, 16222, 16221, 0, 0, 0, 0
4012, 16211, 16212, 16223, 16222, 0, 0, 0, 0
4013, 16212, 16213, 16224, 16223, 0, 0, 0, 0
4014, 16213, 16214, 16225, 16224, 0, 0, 0, 0
4015, 16214, 16215, 16226, 16225, 0, 0, 0, 0
4016, 16215, 16216, 16227, 16226, 0, 0, 0, 0
4017, 16216, 16217, 16228, 16227, 0, 0, 0, 0
4018, 16217, 2056, 2057, 16228, 0, 0, 0, 0
4019, 2015, 16218, 16229, 2016, 0, 0, 0, 0
4020, 16218, 16219, 16230, 16229, 0, 0, 0, 0
4021, 16219, 16220, 16231, 16230, 0, 0, 0, 0
4022, 16220, 16221, 16232, 16231, 0, 0, 0, 0
4023, 16221, 16222, 16233, 16232, 0, 0, 0, 0
4024, 16222, 16223, 16234, 16233, 0, 0, 0, 0
4025, 16223, 16224, 16235, 16234, 0, 0, 0, 0
4026, 16224, 16225, 16236, 16235, 0, 0, 0, 0
4027, 16225, 16226, 16237, 16236, 0, 0, 0, 0
4028, 16226, 16227, 16238, 16237, 0, 0, 0, 0
4029, 16227, 16228, 16239, 16238, 0, 0, 0, 0
4030, 16228, 2057, 2058, 16239, 0, 0, 0, 0
4031, 2016, 16229, 2021, 77, 0, 0, 0, 0
4032, 16229, 16230, 2022, 2021, 0, 0, 0, 0
4033, 16230, 16231, 2023, 2022, 0, 0, 0, 0
4034, 16231, 16232, 2024, 2023, 0, 0, 0, 0
4035, 16232, 16233, 2025, 2024, 0, 0, 0, 0
4036, 16233, 16234, 2026, 2025, 0, 0, 0, 0
4037, 16234, 16235, 2027, 2026, 0, 0, 0, 0
4038, 16235, 16236, 2028, 2027, 0, 0, 0, 0
4039, 16236, 16237, 2029, 2028, 0, 0, 0, 0
4040, 16237, 16238, 2030, 2029, 0, 0, 0, 0
4041, 16238, 16239, 2031, 2030, 0, 0, 0, 0
4042, 16239, 2058, 79, 2031, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface110
4043, 23, 618, 16240, 2017, 0, 0, 0, 0
4044, 2017, 16240, 16241, 2018, 0, 0, 0, 0
4045, 2018, 16241, 16242, 2019, 0, 0, 0, 0
4046, 2019, 16242, 16243, 2020, 0, 0, 0, 0
4047, 2020, 16243, 2074, 79, 0, 0, 0, 0
4048, 618, 619, 16244, 16240, 0, 0, 0, 0
4049, 16240, 16244, 16245, 16241, 0, 0, 0, 0
4050, 16241, 16245, 16246, 16242, 0, 0, 0, 0
4051, 16242, 16246, 16247, 16243, 0, 0, 0, 0
4052, 16243, 16247, 2075, 2074, 0, 0, 0, 0
4053, 619, 620, 16248, 16244, 0, 0, 0, 0
4054, 16244, 16248, 16249, 16245, 0, 0, 0, 0
4055, 16245, 16249, 16250, 16246, 0, 0, 0, 0
4056, 16246, 16250, 16251, 16247, 0, 0, 0, 0
4057, 16247, 16251, 2076, 2075, 0, 0, 0, 0
4058, 620, 621, 16252, 16248, 0, 0, 0, 0
4059, 16248, 16252, 16253, 16249, 0, 0, 0, 0
4060, 16249, 16253, 16254, 16250, 0, 0, 0, 0
4061, 16250, 16254, 16255, 16251, 0, 0, 0, 0
4062, 16251, 16255, 2077, 2076, 0, 0, 0, 0
4063, 621, 26, 2070, 16252, 0, 0, 0, 0
4064, 16252, 2070, 2071, 16253, 0, 0, 0, 0
4065, 16253, 2071, 2072, 16254, 0, 0, 0, 0
4066, 16254, 2072, 2073, 16255, 0, 0, 0, 0
4067, 16255, 2073, 81, 2077, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface111
41280, 21, 1976, 16256, 628, 1980, 16272, 16273, 0
41281, 1976, 1977, 16257, 16256, 1981, 16274, 16275, 16272
41282, 1977, 1978, 16258, 16257, 1982, 16276, 16277, 16274
41283, 1978, 1979, 16259, 16258, 1983, 16278, 16279, 16276
41284, 1979, 77, 2087, 16259, 1984, 0, 16280, 16278
41285, 628, 16256, 16260, 629, 16273, 16281, 16282, 0
41286, 16256, 16257, 16261, 16260, 16275, 16283, 16284, 16281
41287, 16257, 16258, 16262, 16261, 16277, 16285, 16286, 16283
41288, 16258, 16259, 16263, 16262, 16279, 16287, 16288, 16285
41289, 16259, 2087, 2088, 16263, 16280, 0, 16289, 16287
41290, 629, 16260, 16264, 630, 16282, 16290, 16291, 0
41291, 16260, 16261, 16265, 16264, 16284, 16292, 16293, 16290
41292, 16261, 16262, 16266, 16265, 16286, 16294, 16295, 16292
41293, 16262, 16263, 16267, 16266, 16288, 16296, 16297, 16294
41294, 16263, 2088, 2089, 16267, 16289, 0, 16298, 16296
41295, 630, 16264, 16268, 631, 16291, 16299, 16300, 0
41296, 16264, 16265, 16269, 16268, 16293, 16301, 16302, 16299
41297, 16265, 16266, 16270, 16269, 16295, 16303, 16304, 16301
41298, 16266, 16267, 16271, 16270, 16297, 16305, 16306, 16303
41299, 16267, 2089, 2090, 16271, 16298, 0, 16307, 16305
41300, 631, 16268, 2078, 28, 16300, 16308, 2082, 0
41301, 16268, 16269, 2079, 2078, 16302, 16309, 2083, 16308
41302, 16269, 16270, 2080, 2079, 16304, 16310, 2084, 16309
41303, 16270, 16271, 2081, 2080, 16306, 16311, 2085, 16310
41304, 16271, 2090, 82, 2081, 16307, 0, 2086, 16311
*ELEMENT, type=CPS8, ELSET=Surface112
41305, 28, 2078, 16312, 645, 2082, 16356, 16357, 0
41306, 2078, 2079, 16313, 16312, 2083, 16358, 16359, 16356
41307, 2079, 2080, 16314, 16313, 2084, 16360, 16361, 16358
41308, 2080, 2081, 16315, 16314, 2085, 16362, 16363, 16360
41309, 2081, 82, 2091, 16315, 2086, 0, 16364, 16362
41310, 645, 16312, 16316, 646, 16357, 16365, 16366, 0
41311, 16312, 16313, 16317, 16316, 16359, 16367, 16368, 16365
41312, 16313, 16314, 16318, 16317, 16361, 16369, 16370, 16367
41313, 16314, 16315, 16319, 16318, 16363, 16371, 16372, 16369
41314, 16315, 2091, 2092, 16319, 16364, 0, 16373, 16371
41315, 646, 16316, 16320, 647, 16366, 16374, 16375, 0
41316, 16316, 16317, 16321, 16320, 16368, 16376, 16377, 16374
41317, 16317, 16318, 16322, 16321, 16370, 16378, 16379, 16376
41318, 16318, 16319, 16323, 16322, 16372, 16380, 16381, 16378
41319, 16319, 2092, 2093, 16323, 16373, 0, 16382, 16380
41320, 647, 16320, 16324, 648, 16375, 16383, 16384, 0
41321, 16320, 16321, 16325, 16324, 16377, 16385, 16386, 16383
41322, 16321, 16322, 16326, 16325, 16379, 16387, 16388, 16385
41323, 16322, 16323, 16327, 16326, 16381, 16389, 16390, 16387
41324, 16323, 2093, 2094, 16327, 16382, 0, 16391, 16389
41325, 648, 16324, 16328, 649, 16384, 16392, 16393, 0
41326, 16324, 16325, 16329, 16328, 16386, 16394, 16395, 16392
41327, 16325, 16326, 16330, 16329, 16388, 16396, 16397, 16394
41328, 16326, 16327, 16331, 16330, 16390, 16398, 16399, 16396
41329, 16327, 2094, 2095, 16331, 16391, 0, 16400, 16398
41330, 649, 16328, 16332, 650, 16393, 16401, 16402, 0
41331, 16328, 16329, 16333, 16332, 16395, 16403, 16404, 16401
41332, 16329, 16330, 16334, 16333, 16397, 16405, 16406, 16403
41333, 16330, 16331, 16335, 16334, 16399, 16407, 16408, 16405
41334, 16331, 2095, 2096, 16335, 16400, 0, 16409, 16407
41335, 650, 16332, 16336, 651, 16402, 16410, 16411, 0
41336, 16332, 16333, 16337, 16336, 16404, 16412, 16413, 16410
41337, 16333, 16334, 16338, 16337, 16406, 16414, 16415, 16412
41338, 16334, 16335, 16339, 16338, 16408, 16416, 16417, 16414
41339, 16335, 2096, 2097, 16339, 16409, 0, 16418, 16416
41340, 651, 16336, 16340, 652, 16411, 16419, 16420, 0
41341, 16336, 16337, 16341, 16340, 16413, 16421, 16422, 16419
41342, 16337, 16338, 16342, 16341, 16415, 16423, 16424, 16421
41343, 16338, 16339, 16343, 16342, 16417, 16425, 16426, 16423
41344, 16339, 2097, 2098, 16343, 16418, 0, 16427, 16425
41345, 652, 16340, 16344, 653, 16420, 16428, 16429, 0
41346, 16340, 16341, 16345, 16344, 16422, 16430, 16431, 16428
41347, 16341, 16342, 16346, 16345, 16424, 16432, 16433, 16430
41348, 16342, 16343, 16347, 16346, 16426, 16434, 16435, 16432
41349, 16343, 2098, 2099, 16347, 16427, 0, 16436, 16434
41350, 653, 16344, 16348, 654, 16429, 16437, 16438, 0
41351, 16344, 16345, 16349, 16348, 16431, 16439, 16440, 16437
41352, 16345, 16346, 16350, 16349, 16433, 16441, 16442, 16439
41353, 16346, 16347, 16351, 16350, 16435, 16443, 16444, 16441
41354, 16347, 2099, 2100, 16351, 16436, 0, 16445, 16443
41355, 654, 16348, 16352, 655, 16438, 16446, 16447, 0
41356, 16348, 16349, 16353, 16352, 16440, 16448, 16449, 16446
41357, 16349, 16350, 16354, 16353, 16442, 16450, 16451, 16448
41358, 16350, 16351, 16355, 16354, 16444, 16452, 16453, 16450
41359, 16351, 2100, 2101, 16355, 16445, 0, 16454, 16452
41360, 655, 16352, 2070, 26, 16447, 16455, 0, 0
41361, 16352, 16353, 2071, 2070, 16449, 16456, 0, 16455
41362, 16353, 16354, 2072, 2071, 16451, 16457, 0, 16456
41363, 16354, 16355, 2073, 2072, 16453, 16458, 0, 16457
41364, 16355, 2101, 81, 2073, 16454, 0, 0, 16458
*ELEMENT, type=CPS8, ELSET=Surface113
4068, 77, 2021, 16459, 2087, 0, 0, 0, 0
4069, 2087, 16459, 16460, 2088, 0, 0, 0, 0
4070, 2088, 16460, 16461, 2089, 0, 0, 0, 0
4071, 2089, 16461, 16462, 2090, 0, 0, 0, 0
4072, 2090, 16462, 2091, 82, 0, 0, 0, 0
4073, 2021, 2022, 16463, 16459, 0, 0, 0, 0
4074, 16459, 16463, 16464, 16460, 0, 0, 0, 0
4075, 16460, 16464, 16465, 16461, 0, 0, 0, 0
4076, 16461, 16465, 16466, 16462, 0, 0, 0, 0
4077, 16462, 16466, 2092, 2091, 0, 0, 0, 0
4078, 2022, 2023, 16467, 16463, 0, 0, 0, 0
4079, 16463, 16467, 16468, 16464, 0, 0, 0, 0
4080, 16464, 16468, 16469, 16465, 0, 0, 0, 0
4081, 16465, 16469, 16470, 16466, 0, 0, 0, 0
4082, 16466, 16470, 2093, 2092, 0, 0, 0, 0
4083, 2023, 2024, 16471, 16467, 0, 0, 0, 0
4084, 16467, 16471, 16472, 16468, 0, 0, 0, 0
4085, 16468, 16472, 16473, 16469, 0, 0, 0, 0
4086, 16469, 16473, 16474, 16470, 0, 0, 0, 0
4087, 16470, 16474, 2094, 2093, 0, 0, 0, 0
4088, 2024, 2025, 16475, 16471, 0, 0, 0, 0
4089, 16471, 16475, 16476, 16472, 0, 0, 0, 0
4090, 16472, 16476, 16477, 16473, 0, 0, 0, 0
4091, 16473, 16477, 16478, 16474, 0, 0, 0, 0
4092, 16474, 16478, 2095, 2094, 0, 0, 0, 0
4093, 2025, 2026, 16479, 16475, 0, 0, 0, 0
4094, 16475, 16479, 16480, 16476, 0, 0, 0, 0
4095, 16476, 16480, 16481, 16477, 0, 0, 0, 0
4096, 16477, 16481, 16482, 16478, 0, 0, 0, 0
4097, 16478, 16482, 2096, 2095, 0, 0, 0, 0
4098, 2026, 2027, 16483, 16479, 0, 0, 0, 0
4099, 16479, 16483, 16484, 16480, 0, 0, 0, 0
4100, 16480, 16484, 16485, 16481, 0, 0, 0, 0
4101, 16481, 16485, 16486, 16482, 0, 0, 0, 0
4102, 16482, 16486, 2097, 2096, 0, 0, 0, 0
4103, 2027, 2028, 16487, 16483, 0, 0, 0, 0
4104, 16483, 16487, 16488, 16484, 0, 0, 0, 0
4105, 16484, 16488, 16489, 16485, 0, 0, 0, 0
4106, 16485, 16489, 16490, 16486, 0, 0, 0, 0
4107, 16486, 16490, 2098, 2097, 0, 0, 0, 0
4108, 2028, 2029, 16491, 16487, 0, 0, 0, 0
4109, 16487, 16491, 16492, 16488, 0, 0, 0, 0
4110, 16488, 16492, 16493, 16489, 0, 0, 0, 0
4111, 16489, 16493, 16494, 16490, 0, 0, 0, 0
4112, 16490, 16494, 2099, 2098, 0, 0, 0, 0
4113, 2029, 2030, 16495, 16491, 0, 0, 0, 0
4114, 16491, 16495, 16496, 16492, 0, 0, 0, 0
4115, 16492, 16496, 16497, 16493, 0, 0, 0, 0
4116, 16493, 16497, 16498, 16494, 0, 0, 0, 0
4117, 16494, 16498, 2100, 2099, 0, 0, 0, 0
4118, 2030, 2031, 16499, 16495, 0, 0, 0, 0
4119, 16495, 16499, 16500, 16496, 0, 0, 0, 0
4120, 16496, 16500, 16501, 16497, 0, 0, 0, 0
4121, 16497, 16501, 16502, 16498, 0, 0, 0, 0
4122, 16498, 16502, 2101, 2100, 0, 0, 0, 0
4123, 2031, 79, 2074, 16499, 0, 0, 0, 0
4124, 16499, 2074, 2075, 16500, 0, 0, 0, 0
4125, 16500, 2075, 2076, 16501, 0, 0, 0, 0
4126, 16501, 2076, 2077, 16502, 0, 0, 0, 0
4127, 16502, 2077, 81, 2101, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface114
4128, 26, 679, 16503, 2070, 0, 0, 0, 0
4129, 2070, 16503, 16504, 2071, 0, 0, 0, 0
4130, 2071, 16504, 16505, 2072, 0, 0, 0, 0
4131, 2072, 16505, 16506, 2073, 0, 0, 0, 0
4132, 2073, 16506, 2106, 81, 0, 0, 0, 0
4133, 679, 680, 16507, 16503, 0, 0, 0, 0
4134, 16503, 16507, 16508, 16504, 0, 0, 0, 0
4135, 16504, 16508, 16509, 16505, 0, 0, 0, 0
4136, 16505, 16509, 16510, 16506, 0, 0, 0, 0
4137, 16506, 16510, 2107, 2106, 0, 0, 0, 0
4138, 680, 681, 16511, 16507, 0, 0, 0, 0
4139, 16507, 16511, 16512, 16508, 0, 0, 0, 0
4140, 16508, 16512, 16513, 16509, 0, 0, 0, 0
4141, 16509, 16513, 16514, 16510, 0, 0, 0, 0
4142, 16510, 16514, 2108, 2107, 0, 0, 0, 0
4143, 681, 682, 16515, 16511, 0, 0, 0, 0
4144, 16511, 16515, 16516, 16512, 0, 0, 0, 0
4145, 16512, 16516, 16517, 16513, 0, 0, 0, 0
4146, 16513, 16517, 16518, 16514, 0, 0, 0, 0
4147, 16514, 16518, 2109, 2108, 0, 0, 0, 0
4148, 682, 683, 16519, 16515, 0, 0, 0, 0
4149, 16515, 16519, 16520, 16516, 0, 0, 0, 0
4150, 16516, 16520, 16521, 16517, 0, 0, 0, 0
4151, 16517, 16521, 16522, 16518, 0, 0, 0, 0
4152, 16518, 16522, 2110, 2109, 0, 0, 0, 0
4153, 683, 684, 16523, 16519, 0, 0, 0, 0
4154, 16519, 16523, 16524, 16520, 0, 0, 0, 0
4155, 16520, 16524, 16525, 16521, 0, 0, 0, 0
4156, 16521, 16525, 16526, 16522, 0, 0, 0, 0
4157, 16522, 16526, 2111, 2110, 0, 0, 0, 0
4158, 684, 685, 16527, 16523, 0, 0, 0, 0
4159, 16523, 16527, 16528, 16524, 0, 0, 0, 0
4160, 16524, 16528, 16529, 16525, 0, 0, 0, 0
4161, 16525, 16529, 16530, 16526, 0, 0, 0, 0
4162, 16526, 16530, 2112, 2111, 0, 0, 0, 0
4163, 685, 686, 16531, 16527, 0, 0, 0, 0
4164, 16527, 16531, 16532, 16528, 0, 0, 0, 0
4165, 16528, 16532, 16533, 16529, 0, 0, 0, 0
4166, 16529, 16533, 16534, 16530, 0, 0, 0, 0
4167, 16530, 16534, 2113, 2112, 0, 0, 0, 0
4168, 686, 687, 16535, 16531, 0, 0, 0, 0
4169, 16531, 16535, 16536, 16532, 0, 0, 0, 0
4170, 16532, 16536, 16537, 16533, 0, 0, 0, 0
4171, 16533, 16537, 16538, 16534, 0, 0, 0, 0
4172, 16534, 16538, 2114, 2113, 0, 0, 0, 0
4173, 687, 688, 16539, 16535, 0, 0, 0, 0
4174, 16535, 16539, 16540, 16536, 0, 0, 0, 0
4175, 16536, 16540, 16541, 16537, 0, 0, 0, 0
4176, 16537, 16541, 16542, 16538, 0, 0, 0, 0
4177, 16538, 16542, 2115, 2114, 0, 0, 0, 0
4178, 688, 689, 16543, 16539, 0, 0, 0, 0
4179, 16539, 16543, 16544, 16540, 0, 0, 0, 0
4180, 16540, 16544, 16545, 16541, 0, 0, 0, 0
4181, 16541, 16545, 16546, 16542, 0, 0, 0, 0
4182, 16542, 16546, 2116, 2115, 0, 0, 0, 0
4183, 689, 690, 16547, 16543, 0, 0, 0, 0
4184, 16543, 16547, 16548, 16544, 0, 0, 0, 0
4185, 16544, 16548, 16549, 16545, 0, 0, 0, 0
4186, 16545, 16549, 16550, 16546, 0, 0, 0, 0
4187, 16546, 16550, 2117, 2116, 0, 0, 0, 0
4188, 690, 691, 16551, 16547, 0, 0, 0, 0
4189, 16547, 16551, 16552, 16548, 0, 0, 0, 0
4190, 16548, 16552, 16553, 16549, 0, 0, 0, 0
4191, 16549, 16553, 16554, 16550, 0, 0, 0, 0
4192, 16550, 16554, 2118, 2117, 0, 0, 0, 0
4193, 691, 692, 16555, 16551, 0, 0, 0, 0
4194, 16551, 16555, 16556, 16552, 0, 0, 0, 0
4195, 16552, 16556, 16557, 16553, 0, 0, 0, 0
4196, 16553, 16557, 16558, 16554, 0, 0, 0, 0
4197, 16554, 16558, 2119, 2118, 0, 0, 0, 0
4198, 692, 693, 16559, 16555, 0, 0, 0, 0
4199, 16555, 16559, 16560, 16556, 0, 0, 0, 0
4200, 16556, 16560, 16561, 16557, 0, 0, 0, 0
4201, 16557, 16561, 16562, 16558, 0, 0, 0, 0
4202, 16558, 16562, 2120, 2119, 0, 0, 0, 0
4203, 693, 694, 16563, 16559, 0, 0, 0, 0
4204, 16559, 16563, 16564, 16560, 0, 0, 0, 0
4205, 16560, 16564, 16565, 16561, 0, 0, 0, 0
4206, 16561, 16565, 16566, 16562, 0, 0, 0, 0
4207, 16562, 16566, 2121, 2120, 0, 0, 0, 0
4208, 694, 695, 16567, 16563, 0, 0, 0, 0
4209, 16563, 16567, 16568, 16564, 0, 0, 0, 0
4210, 16564, 16568, 16569, 16565, 0, 0, 0, 0
4211, 16565, 16569, 16570, 16566, 0, 0, 0, 0
4212, 16566, 16570, 2122, 2121, 0, 0, 0, 0
4213, 695, 696, 16571, 16567, 0, 0, 0, 0
4214, 16567, 16571, 16572, 16568, 0, 0, 0, 0
4215, 16568, 16572, 16573, 16569, 0, 0, 0, 0
4216, 16569, 16573, 16574, 16570, 0, 0, 0, 0
4217, 16570, 16574, 2123, 2122, 0, 0, 0, 0
4218, 696, 697, 16575, 16571, 0, 0, 0, 0
4219, 16571, 16575, 16576, 16572, 0, 0, 0, 0
4220, 16572, 16576, 16577, 16573, 0, 0, 0, 0
4221, 16573, 16577, 16578, 16574, 0, 0, 0, 0
4222, 16574, 16578, 2124, 2123, 0, 0, 0, 0
4223, 697, 698, 16579, 16575, 0, 0, 0, 0
4224, 16575, 16579, 16580, 16576, 0, 0, 0, 0
4225, 16576, 16580, 16581, 16577, 0, 0, 0, 0
4226, 16577, 16581, 16582, 16578, 0, 0, 0, 0
4227, 16578, 16582, 2125, 2124, 0, 0, 0, 0
4228, 698, 699, 16583, 16579, 0, 0, 0, 0
4229, 16579, 16583, 16584, 16580, 0, 0, 0, 0
4230, 16580, 16584, 16585, 16581, 0, 0, 0, 0
4231, 16581, 16585, 16586, 16582, 0, 0, 0, 0
4232, 16582, 16586, 2126, 2125, 0, 0, 0, 0
4233, 699, 700, 16587, 16583, 0, 0, 0, 0
4234, 16583, 16587, 16588, 16584, 0, 0, 0, 0
4235, 16584, 16588, 16589, 16585, 0, 0, 0, 0
4236, 16585, 16589, 16590, 16586, 0, 0, 0, 0
4237, 16586, 16590, 2127, 2126, 0, 0, 0, 0
4238, 700, 701, 16591, 16587, 0, 0, 0, 0
4239, 16587, 16591, 16592, 16588, 0, 0, 0, 0
4240, 16588, 16592, 16593, 16589, 0, 0, 0, 0
4241, 16589, 16593, 16594, 16590, 0, 0, 0, 0
4242, 16590, 16594, 2128, 2127, 0, 0, 0, 0
4243, 701, 30, 2102, 16591, 0, 0, 0, 0
4244, 16591, 2102, 2103, 16592, 0, 0, 0, 0
4245, 16592, 2103, 2104, 16593, 0, 0, 0, 0
4246, 16593, 2104, 2105, 16594, 0, 0, 0, 0
4247, 16594, 2105, 83, 2128, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface115
41365, 28, 2078, 16595, 727, 2082, 16687, 16688, 0
41366, 2078, 2079, 16596, 16595, 2083, 16689, 16690, 16687
41367, 2079, 2080, 16597, 16596, 2084, 16691, 16692, 16689
41368, 2080, 2081, 16598, 16597, 2085, 16693, 16694, 16691
41369, 2081, 82, 2138, 16598, 2086, 0, 16695, 16693
41370, 727, 16595, 16599, 728, 16688, 16696, 16697, 0
41371, 16595, 16596, 16600, 16599, 16690, 16698, 16699, 16696
41372, 16596, 16597, 16601, 16600, 16692, 16700, 16701, 16698
41373, 16597, 16598, 16602, 16601, 16694, 16702, 16703, 16700
41374, 16598, 2138, 2139, 16602, 16695, 0, 16704, 16702
41375, 728, 16599, 16603, 729, 16697, 16705, 16706, 0
41376, 16599, 16600, 16604, 16603, 16699, 16707, 16708, 16705
41377, 16600, 16601, 16605, 16604, 16701, 16709, 16710, 16707
41378, 16601, 16602, 16606, 16605, 16703, 16711, 16712, 16709
41379, 16602, 2139, 2140, 16606, 16704, 0, 16713, 16711
41380, 729, 16603, 16607, 730, 16706, 16714, 16715, 0
41381, 16603, 16604, 16608, 16607, 16708, 16716, 16717, 16714
41382, 16604, 16605, 16609, 16608, 16710, 16718, 16719, 16716
41383, 16605, 16606, 16610, 16609, 16712, 16720, 16721, 16718
41384, 16606, 2140, 2141, 16610, 16713, 0, 16722, 16720
41385, 730, 16607, 16611, 731, 16715, 16723, 16724, 0
41386, 16607, 16608, 16612, 16611, 16717, 16725, 16726, 16723
41387, 16608, 16609, 16613, 16612, 16719, 16727, 16728, 16725
41388, 16609, 16610, 16614, 16613, 16721, 16729, 16730, 16727
41389, 16610, 2141, 2142, 16614, 16722, 0, 16731, 16729
41390, 731, 16611, 16615, 732, 16724, 16732, 16733, 0
41391, 16611, 16612, 16616, 16615, 16726, 16734, 16735, 16732
41392, 16612, 16613, 16617, 16616, 16728, 16736, 16737, 16734
41393, 16613, 16614, 16618, 16617, 16730, 16738, 16739, 16736
41394, 16614, 2142, 2143, 16618, 16731, 0, 16740, 16738
41395, 732, 16615, 16619, 733, 16733, 16741, 16742, 0
41396, 16615, 16616, 16620, 16619, 16735, 16743, 16744, 16741
41397, 16616, 16617, 16621, 16620, 16737, 16745, 16746, 16743
41398, 16617, 16618, 16622, 16621, 16739, 16747, 16748, 16745
41399, 16618, 2143, 2144, 16622, 16740, 0, 16749, 16747
41400, 733, 16619, 16623, 734, 16742, 16750, 16751, 0
41401, 16619, 16620, 16624, 16623, 16744, 16752, 16753, 16750
41402, 16620, 16621, 16625, 16624, 16746, 16754, 16755, 16752
41403, 16621, 16622, 16626, 16625, 16748, 16756, 16757, 16754
41404, 16622, 2144, 2145, 16626, 16749, 0, 16758, 16756
41405, 734, 16623, 16627, 735, 16751, 16759, 16760, 0
41406, 16623, 16624, 16628, 16627, 16753, 16761, 16762, 16759
41407, 16624, 16625, 16629, 16628, 16755, 16763, 16764, 16761
41408, 16625, 16626, 16630, 16629, 16757, 16765, 16766, 16763
41409, 16626, 2145, 2146, 16630, 16758, 0, 16767, 16765
41410, 735, 16627, 16631, 736, 16760, 16768, 16769, 0
41411, 16627, 16628, 16632, 16631, 16762, 16770, 16771, 16768
41412, 16628, 16629, 16633, 16632, 16764, 16772, 16773, 16770
41413, 16629, 16630, 16634, 16633, 16766, 16774, 16775, 16772
41414, 16630, 2146, 2147, 16634, 16767, 0, 16776, 16774
41415, 736, 16631, 16635, 737, 16769, 16777, 16778, 0
41416, 16631, 16632, 16636, 16635, 16771, 16779, 16780, 16777
41417, 16632, 16633, 16637, 16636, 16773, 16781, 16782, 16779
41418, 16633, 16634, 16638, 16637, 16775, 16783, 16784, 16781
41419, 16634, 2147, 2148, 16638, 16776, 0, 16785, 16783
41420, 737, 16635, 16639, 738, 16778, 16786, 16787, 0
41421, 16635, 16636, 16640, 16639, 16780, 16788, 16789, 16786
41422, 16636, 16637, 16641, 16640, 16782, 16790, 16791, 16788
41423, 16637, 16638, 16642, 16641, 16784, 16792, 16793, 16790
41424, 16638, 2148, 2149, 16642, 16785, 0, 16794, 16792
41425, 738, 16639, 16643, 739, 16787, 16795, 16796, 0
41426, 16639, 16640, 16644, 16643, 16789, 16797, 16798, 16795
41427, 16640, 16641, 16645, 16644, 16791, 16799, 16800, 16797
41428, 16641, 16642, 16646, 16645, 16793, 16801, 16802, 16799
41429, 16642, 2149, 2150, 16646, 16794, 0, 16803, 16801
41430, 739, 16643, 16647, 740, 16796, 16804, 16805, 0
41431, 16643, 16644, 16648, 16647, 16798, 16806, 16807, 16804
41432, 16644, 16645, 16649, 16648, 16800, 16808, 16809, 16806
41433, 16645, 16646, 16650, 16649, 16802, 16810, 16811, 16808
41434, 16646, 2150, 2151, 16650, 16803, 0, 16812, 16810
41435, 740, 16647, 16651, 741, 16805, 16813, 16814, 0
41436, 16647, 16648, 16652, 16651, 16807, 16815, 16816, 16813
41437, 16648, 16649, 16653, 16652, 16809, 16817, 16818, 16815
41438, 16649, 16650, 16654, 16653, 16811, 16819, 16820, 16817
41439, 16650, 2151, 2152, 16654, 16812, 0, 16821, 16819
41440, 741, 16651, 16655, 742, 16814, 16822, 16823, 0
41441, 16651, 16652, 16656, 16655, 16816, 16824, 16825, 16822
41442, 16652, 16653, 16657, 16656, 16818, 16826, 16827, 16824
41443, 16653, 16654, 16658, 16657, 16820, 16828, 16829, 16826
41444, 16654, 2152, 2153, 16658, 16821, 0, 16830, 16828
41445, 742, 16655, 16659, 743, 16823, 16831, 16832, 0
41446, 16655, 16656, 16660, 16659, 16825, 16833, 16834, 16831
41447, 16656, 16657, 16661, 16660, 16827, 16835, 16836, 16833
41448, 16657, 16658, 16662, 16661, 16829, 16837, 16838, 16835
41449, 16658, 2153, 2154, 16662, 16830, 0, 16839, 16837
41450, 743, 16659, 16663, 744, 16832, 16840, 16841, 0
41451, 16659, 16660, 16664, 16663, 16834, 16842, 16843, 16840
41452, 16660, 16661, 16665, 16664, 16836, 16844, 16845, 16842
41453, 16661, 16662, 16666, 16665, 16838, 16846, 16847, 16844
41454, 16662, 2154, 2155, 16666, 16839, 0, 16848, 16846
41455, 744, 16663, 16667, 745, 16841, 16849, 16850, 0
41456, 16663, 16664, 16668, 16667, 16843, 16851, 16852, 16849
41457, 16664, 16665, 16669, 16668, 16845, 16853, 16854, 16851
41458, 16665, 16666, 16670, 16669, 16847, 16855, 16856, 16853
41459, 16666, 2155, 2156, 16670, 16848, 0, 16857, 16855
41460, 745, 16667, 16671, 746, 16850, 16858, 16859, 0
41461, 16667, 16668, 16672, 16671, 16852, 16860, 16861, 16858
41462, 16668, 16669, 16673, 16672, 16854, 16862, 16863, 16860
41463, 16669, 16670, 16674, 16673, 16856, 16864, 16865, 16862
41464, 16670, 2156, 2157, 16674, 16857, 0, 16866, 16864
41465, 746, 16671, 16675, 747, 16859, 16867, 16868, 0
41466, 16671, 16672, 16676, 16675, 16861, 16869, 16870, 16867
41467, 16672, 16673, 16677, 16676, 16863, 16871, 16872, 16869
41468, 16673, 16674, 16678, 16677, 16865, 16873, 16874, 16871
41469, 16674, 2157, 2158, 16678, 16866, 0, 16875, 16873
41470, 747, 16675, 16679, 748, 16868, 16876, 16877, 0
41471, 16675, 16676, 16680, 16679, 16870, 16878, 16879, 16876
41472, 16676, 16677, 16681, 16680, 16872, 16880, 16881, 16878
41473, 16677, 16678, 16682, 16681, 16874, 16882, 16883, 16880
41474, 16678, 2158, 2159, 16682, 16875, 0, 16884, 16882
41475, 748, 16679, 16683, 749, 16877, 16885, 16886, 0
41476, 16679, 16680, 16684, 16683, 16879, 16887, 16888, 16885
41477, 16680, 16681, 16685, 16684, 16881, 16889, 16890, 16887
41478, 16681, 16682, 16686, 16685, 16883, 16891, 16892, 16889
41479, 16682, 2159, 2160, 16686, 16884, 0, 16893, 16891
41480, 749, 16683, 2129, 32, 16886, 16894, 2133, 0
41481, 16683, 16684, 2130, 2129, 16888, 16895, 2134, 16894
41482, 16684, 16685, 2131, 2130, 16890, 16896, 2135, 16895
41483, 16685, 16686, 2132, 2131, 16892, 16897, 2136, 16896
41484, 16686, 2160, 84, 2132, 16893, 0, 2137, 16897
*ELEMENT, type=CPS8, ELSET=Surface116
41485, 32, 2129, 16898, 763, 2133, 16942, 16943, 0
41486, 2129, 2130, 16899, 16898, 2134, 16944, 16945, 16942
41487, 2130, 2131, 16900, 16899, 2135, 16946, 16947, 16944
41488, 2131, 2132, 16901, 16900, 2136, 16948, 16949, 16946
41489, 2132, 84, 2161, 16901, 2137, 0, 16950, 16948
41490, 763, 16898, 16902, 764, 16943, 16951, 16952, 0
41491, 16898, 16899, 16903, 16902, 16945, 16953, 16954, 16951
41492, 16899, 16900, 16904, 16903, 16947, 16955, 16956, 16953
41493, 16900, 16901, 16905, 16904, 16949, 16957, 16958, 16955
41494, 16901, 2161, 2162, 16905, 16950, 0, 16959, 16957
41495, 764, 16902, 16906, 765, 16952, 16960, 16961, 0
41496, 16902, 16903, 16907, 16906, 16954, 16962, 16963, 16960
41497, 16903, 16904, 16908, 16907, 16956, 16964, 16965, 16962
41498, 16904, 16905, 16909, 16908, 16958, 16966, 16967, 16964
41499, 16905, 2162, 2163, 16909, 16959, 0, 16968, 16966
41500, 765, 16906, 16910, 766, 16961, 16969, 16970, 0
41501, 16906, 16907, 16911, 16910, 16963, 16971, 16972, 16969
41502, 16907, 16908, 16912, 16911, 16965, 16973, 16974, 16971
41503, 16908, 16909, 16913, 16912, 16967, 16975, 16976, 16973
41504, 16909, 2163, 2164, 16913, 16968, 0, 16977, 16975
41505, 766, 16910, 16914, 767, 16970, 16978, 16979, 0
41506, 16910, 16911, 16915, 16914, 16972, 16980, 16981, 16978
41507, 16911, 16912, 16916, 16915, 16974, 16982, 16983, 16980
41508, 16912, 16913, 16917, 16916, 16976, 16984, 16985, 16982
41509, 16913, 2164, 2165, 16917, 16977, 0, 16986, 16984
41510, 767, 16914, 16918, 768, 16979, 16987, 16988, 0
41511, 16914, 16915, 16919, 16918, 16981, 16989, 16990, 16987
41512, 16915, 16916, 16920, 16919, 16983, 16991, 16992, 16989
41513, 16916, 16917, 16921, 16920, 16985, 16993, 16994, 16991
41514, 16917, 2165, 2166, 16921, 16986, 0, 16995, 16993
41515, 768, 16918, 16922, 769, 16988, 16996, 16997, 0
41516, 16918, 16919, 16923, 16922, 16990, 16998, 16999, 16996
41517, 16919, 16920, 16924, 16923, 16992, 17000, 17001, 16998
41518, 16920, 16921, 16925, 16924, 16994, 17002, 17003, 17000
41519, 16921, 2166, 2167, 16925, 16995, 0, 17004, 17002
41520, 769, 16922, 16926, 770, 16997, 17005, 17006, 0
41521, 16922, 16923, 16927, 16926, 16999, 17007, 17008, 17005
41522, 16923, 16924, 16928, 16927, 17001, 17009, 17010, 17007
41523, 16924, 16925, 16929, 16928, 17003, 17011, 17012, 17009
41524, 16925, 2167, 2168, 16929, 17004, 0, 17013, 17011
41525, 770, 16926, 16930, 771, 17006, 17014, 17015, 0
41526, 16926, 16927, 16931, 16930, 17008, 17016, 17017, 17014
41527, 16927, 16928, 16932, 16931, 17010, 17018, 17019, 17016
41528, 16928, 16929, 16933, 16932, 17012, 17020, 17021, 17018
41529, 16929, 2168, 2169, 16933, 17013, 0, 17022, 17020
41530, 771, 16930, 16934, 772, 17015, 17023, 17024, 0
41531, 16930, 16931, 16935, 16934, 17017, 17025, 17026, 17023
41532, 16931, 16932, 16936, 16935, 17019, 17027, 17028, 17025
41533, 16932, 16933, 16937, 16936, 17021, 17029, 17030, 17027
41534, 16933, 2169, 2170, 16937, 17022, 0, 17031, 17029
41535, 772, 16934, 16938, 773, 17024, 17032, 17033, 0
41536, 16934, 16935, 16939, 16938, 17026, 17034, 17035, 17032
41537, 16935, 16936, 16940, 16939, 17028, 17036, 17037, 17034
41538, 16936, 16937, 16941, 16940, 17030, 17038, 17039, 17036
41539, 16937, 2170, 2171, 16941, 17031, 0, 17040, 17038
41540, 773, 16938, 2102, 30, 17033, 17041, 0, 0
41541, 16938, 16939, 2103, 2102, 17035, 17042, 0, 17041
41542, 16939, 16940, 2104, 2103, 17037, 17043, 0, 17042
41543, 16940, 16941, 2105, 2104, 17039, 17044, 0, 17043
41544, 16941, 2171, 83, 2105, 17040, 0, 0, 17044
*ELEMENT, type=CPS8, ELSET=Surface117
4248, 82, 2091, 17045, 2138, 0, 0, 0, 0
4249, 2138, 17045, 17046, 2139, 0, 0, 0, 0
4250, 2139, 17046, 17047, 2140, 0, 0, 0, 0
4251, 2140, 17047, 17048, 2141, 0, 0, 0, 0
4252, 2141, 17048, 17049, 2142, 0, 0, 0, 0
4253, 2142, 17049, 17050, 2143, 0, 0, 0, 0
4254, 2143, 17050, 17051, 2144, 0, 0, 0, 0
4255, 2144, 17051, 17052, 2145, 0, 0, 0, 0
4256, 2145, 17052, 17053, 2146, 0, 0, 0, 0
4257, 2146, 17053, 17054, 2147, 0, 0, 0, 0
4258, 2147, 17054, 17055, 2148, 0, 0, 0, 0
4259, 2148, 17055, 17056, 2149, 0, 0, 0, 0
4260, 2149, 17056, 17057, 2150, 0, 0, 0, 0
4261, 2150, 17057, 17058, 2151, 0, 0, 0, 0
4262, 2151, 17058, 17059, 2152, 0, 0, 0, 0
4263, 2152, 17059, 17060, 2153, 0, 0, 0, 0
4264, 2153, 17060, 17061, 2154, 0, 0, 0, 0
4265, 2154, 17061, 17062, 2155, 0, 0, 0, 0
4266, 2155, 17062, 17063, 2156, 0, 0, 0, 0
4267, 2156, 17063, 17064, 2157, 0, 0, 0, 0
4268, 2157, 17064, 17065, 2158, 0, 0, 0, 0
4269, 2158, 17065, 17066, 2159, 0, 0, 0, 0
4270, 2159, 17066, 17067, 2160, 0, 0, 0, 0
4271, 2160, 17067, 2161, 84, 0, 0, 0, 0
4272, 2091, 2092, 17068, 17045, 0, 0, 0, 0
4273, 17045, 17068, 17069, 17046, 0, 0, 0, 0
4274, 17046, 17069, 17070, 17047, 0, 0, 0, 0
4275, 17047, 17070, 17071, 17048, 0, 0, 0, 0
4276, 17048, 17071, 17072, 17049, 0, 0, 0, 0
4277, 17049, 17072, 17073, 17050, 0, 0, 0, 0
4278, 17050, 17073, 17074, 17051, 0, 0, 0, 0
4279, 17051, 17074, 17075, 17052, 0, 0, 0, 0
4280, 17052, 17075, 17076, 17053, 0, 0, 0, 0
4281, 17053, 17076, 17077, 17054, 0, 0, 0, 0
4282, 17054, 17077, 17078, 17055, 0, 0, 0, 0
4283, 17055, 17078, 17079, 17056, 0, 0, 0, 0
4284, 17056, 17079, 17080, 17057, 0, 0, 0, 0
4285, 17057, 17080, 17081, 17058, 0, 0, 0, 0
4286, 17058, 17081, 17082, 17059, 0, 0, 0, 0
4287, 17059, 17082, 17083, 17060, 0, 0, 0, 0
4288, 17060, 17083, 17084, 17061, 0, 0, 0, 0
4289, 17061, 17084, 17085, 17062, 0, 0, 0, 0
4290, 17062, 17085, 17086, 17063, 0, 0, 0, 0
4291, 17063, 17086, 17087, 17064, 0, 0, 0, 0
4292, 17064, 17087, 17088, 17065, 0, 0, 0, 0
4293, 17065, 17088, 17089, 17066, 0, 0, 0, 0
4294, 17066, 17089, 17090, 17067, 0, 0, 0, 0
4295, 17067, 17090, 2162, 2161, 0, 0, 0, 0
4296, 2092, 2093, 17091, 17068, 0, 0, 0, 0
4297, 17068, 17091, 17092, 17069, 0, 0, 0, 0
4298, 17069, 17092, 17093, 17070, 0, 0, 0, 0
4299, 17070, 17093, 17094, 17071, 0, 0, 0, 0
4300, 17071, 17094, 17095, 17072, 0, 0, 0, 0
4301, 17072, 17095, 17096, 17073, 0, 0, 0, 0
4302, 17073, 17096, 17097, 17074, 0, 0, 0, 0
4303, 17074, 17097, 17098, 17075, 0, 0, 0, 0
4304, 17075, 17098, 17099, 17076, 0, 0, 0, 0
4305, 17076, 17099, 17100, 17077, 0, 0, 0, 0
4306, 17077, 17100, 17101, 17078, 0, 0, 0, 0
4307, 17078, 17101, 17102, 17079, 0, 0, 0, 0
4308, 17079, 17102, 17103, 17080, 0, 0, 0, 0
4309, 17080, 17103, 17104, 17081, 0, 0, 0, 0
4310, 17081, 17104, 17105, 17082, 0, 0, 0, 0
4311, 17082, 17105, 17106, 17083, 0, 0, 0, 0
4312, 17083, 17106, 17107, 17084, 0, 0, 0, 0
4313, 17084, 17107, 17108, 17085, 0, 0, 0, 0
4314, 17085, 17108, 17109, 17086, 0, 0, 0, 0
4315, 17086, 17109, 17110, 17087, 0, 0, 0, 0
4316, 17087, 17110, 17111, 17088, 0, 0, 0, 0
4317, 17088, 17111, 17112, 17089, 0, 0, 0, 0
4318, 17089, 17112, 17113, 17090, 0, 0, 0, 0
4319, 17090, 17113, 2163, 2162, 0, 0, 0, 0
4320, 2093, 2094, 17114, 17091, 0, 0, 0, 0
4321, 17091, 17114, 17115, 17092, 0, 0, 0, 0
4322, 17092, 17115, 17116, 17093, 0, 0, 0, 0
4323, 17093, 17116, 17117, 17094, 0, 0, 0, 0
4324, 17094, 17117, 17118, 17095, 0, 0, 0, 0
4325, 17095, 17118, 17119, 17096, 0, 0, 0, 0
4326, 17096, 17119, 17120, 17097, 0, 0, 0, 0
4327, 17097, 17120, 17121, 17098, 0, 0, 0, 0
4328, 17098, 17121, 17122, 17099, 0, 0, 0, 0
4329, 17099, 17122, 17123, 17100, 0, 0, 0, 0
4330, 17100, 17123, 17124, 17101, 0, 0, 0, 0
4331, 17101, 17124, 17125, 17102, 0, 0, 0, 0
4332, 17102, 17125, 17126, 17103, 0, 0, 0, 0
4333, 17103, 17126, 17127, 17104, 0, 0, 0, 0
4334, 17104, 17127, 17128, 17105, 0, 0, 0, 0
4335, 17105, 17128, 17129, 17106, 0, 0, 0, 0
4336, 17106, 17129, 17130, 17107, 0, 0, 0, 0
4337, 17107, 17130, 17131, 17108, 0, 0, 0, 0
4338, 17108, 17131, 17132, 17109, 0, 0, 0, 0
4339, 17109, 17132, 17133, 17110, 0, 0, 0, 0
4340, 17110, 17133, 17134, 17111, 0, 0, 0, 0
4341, 17111, 17134, 17135, 17112, 0, 0, 0, 0
4342, 17112, 17135, 17136, 17113, 0, 0, 0, 0
4343, 17113, 17136, 2164, 2163, 0, 0, 0, 0
4344, 2094, 2095, 17137, 17114, 0, 0, 0, 0
4345, 17114, 17137, 17138, 17115, 0, 0, 0, 0
4346, 17115, 17138, 17139, 17116, 0, 0, 0, 0
4347, 17116, 17139, 17140, 17117, 0, 0, 0, 0
4348, 17117, 17140, 17141, 17118, 0, 0, 0, 0
4349, 17118, 17141, 17142, 17119, 0, 0, 0, 0
4350, 17119, 17142, 17143, 17120, 0, 0, 0, 0
4351, 17120, 17143, 17144, 17121, 0, 0, 0, 0
4352, 17121, 17144, 17145, 17122, 0, 0, 0, 0
4353, 17122, 17145, 17146, 17123, 0, 0, 0, 0
4354, 17123, 17146, 17147, 17124, 0, 0, 0, 0
4355, 17124, 17147, 17148, 17125, 0, 0, 0, 0
4356, 17125, 17148, 17149, 17126, 0, 0, 0, 0
4357, 17126, 17149, 17150, 17127, 0, 0, 0, 0
4358, 17127, 17150, 17151, 17128, 0, 0, 0, 0
4359, 17128, 17151, 17152, 17129, 0, 0, 0, 0
4360, 17129, 17152, 17153, 17130, 0, 0, 0, 0
4361, 17130, 17153, 17154, 17131, 0, 0, 0, 0
4362, 17131, 17154, 17155, 17132, 0, 0, 0, 0
4363, 17132, 17155, 17156, 17133, 0, 0, 0, 0
4364, 17133, 17156, 17157, 17134, 0, 0, 0, 0
4365, 17134, 17157, 17158, 17135, 0, 0, 0, 0
4366, 17135, 17158, 17159, 17136, 0, 0, 0, 0
4367, 17136, 17159, 2165, 2164, 0, 0, 0, 0
4368, 2095, 2096, 17160, 17137, 0, 0, 0, 0
4369, 17137, 17160, 17161, 17138, 0, 0, 0, 0
4370, 17138, 17161, 17162, 17139, 0, 0, 0, 0
4371, 17139, 17162, 17163, 17140, 0, 0, 0, 0
4372, 17140, 17163, 17164, 17141, 0, 0, 0, 0
4373, 17141, 17164, 17165, 17142, 0, 0, 0, 0
4374, 17142, 17165, 17166, 17143, 0, 0, 0, 0
4375, 17143, 17166, 17167, 17144, 0, 0, 0, 0
4376, 17144, 17167, 17168, 17145, 0, 0, 0, 0
4377, 17145, 17168, 17169, 17146, 0, 0, 0, 0
4378, 17146, 17169, 17170, 17147, 0, 0, 0, 0
4379, 17147, 17170, 17171, 17148, 0, 0, 0, 0
4380, 17148, 17171, 17172, 17149, 0, 0, 0, 0
4381, 17149, 17172, 17173, 17150, 0, 0, 0, 0
4382, 17150, 17173, 17174, 17151, 0, 0, 0, 0
4383, 17151, 17174, 17175, 17152, 0, 0, 0, 0
4384, 17152, 17175, 17176, 17153, 0, 0, 0, 0
4385, 17153, 17176, 17177, 17154, 0, 0, 0, 0
4386, 17154, 17177, 17178, 17155, 0, 0, 0, 0
4387, 17155, 17178, 17179, 17156, 0, 0, 0, 0
4388, 17156, 17179, 17180, 17157, 0, 0, 0, 0
4389, 17157, 17180, 17181, 17158, 0, 0, 0, 0
4390, 17158, 17181, 17182, 17159, 0, 0, 0, 0
4391, 17159, 17182, 2166, 2165, 0, 0, 0, 0
4392, 2096, 2097, 17183, 17160, 0, 0, 0, 0
4393, 17160, 17183, 17184, 17161, 0, 0, 0, 0
4394, 17161, 17184, 17185, 17162, 0, 0, 0, 0
4395, 17162, 17185, 17186, 17163, 0, 0, 0, 0
4396, 17163, 17186, 17187, 17164, 0, 0, 0, 0
4397, 17164, 17187, 17188, 17165, 0, 0, 0, 0
4398, 17165, 17188, 17189, 17166, 0, 0, 0, 0
4399, 17166, 17189, 17190, 17167, 0, 0, 0, 0
4400, 17167, 17190, 17191, 17168, 0, 0, 0, 0
4401, 17168, 17191, 17192, 17169, 0, 0, 0, 0
4402, 17169, 17192, 17193, 17170, 0, 0, 0, 0
4403, 17170, 17193, 17194, 17171, 0, 0, 0, 0
4404, 17171, 17194, 17195, 17172, 0, 0, 0, 0
4405, 17172, 17195, 17196, 17173, 0, 0, 0, 0
4406, 17173, 17196, 17197, 17174, 0, 0, 0, 0
4407, 17174, 17197, 17198, 17175, 0, 0, 0, 0
4408, 17175, 17198, 17199, 17176, 0, 0, 0, 0
4409, 17176, 17199, 17200, 17177, 0, 0, 0, 0
4410, 17177, 17200, 17201, 17178, 0, 0, 0, 0
4411, 17178, 17201, 17202, 17179, 0, 0, 0, 0
4412, 17179, 17202, 17203, 17180, 0, 0, 0, 0
4413, 17180, 17203, 17204, 17181, 0, 0, 0, 0
4414, 17181, 17204, 17205, 17182, 0, 0, 0, 0
4415, 17182, 17205, 2167, 2166, 0, 0, 0, 0
4416, 2097, 2098, 17206, 17183, 0, 0, 0, 0
4417, 17183, 17206, 17207, 17184, 0, 0, 0, 0
4418, 17184, 17207, 17208, 17185, 0, 0, 0, 0
4419, 17185, 17208, 17209, 17186, 0, 0, 0, 0
4420, 17186, 17209, 17210, 17187, 0, 0, 0, 0
4421, 17187, 17210, 17211, 17188, 0, 0, 0, 0
4422, 17188, 17211, 17212, 17189, 0, 0, 0, 0
4423, 17189, 17212, 17213, 17190, 0, 0, 0, 0
4424, 17190, 17213, 17214, 17191, 0, 0, 0, 0
4425, 17191, 17214, 17215, 17192, 0, 0, 0, 0
4426, 17192, 17215, 17216, 17193, 0, 0, 0, 0
4427, 17193, 17216, 17217, 17194, 0, 0, 0, 0
4428, 17194, 17217, 17218, 17195, 0, 0, 0, 0
4429, 17195, 17218, 17219, 17196, 0, 0, 0, 0
4430, 17196, 17219, 17220, 17197, 0, 0, 0, 0
4431, 17197, 17220, 17221, 17198, 0, 0, 0, 0
4432, 17198, 17221, 17222, 17199, 0, 0, 0, 0
4433, 17199, 17222, 17223, 17200, 0, 0, 0, 0
4434, 17200, 17223, 17224, 17201, 0, 0, 0, 0
4435, 17201, 17224, 17225, 17202, 0, 0, 0, 0
4436, 17202, 17225, 17226, 17203, 0, 0, 0, 0
4437, 17203, 17226, 17227, 17204, 0, 0, 0, 0
4438, 17204, 17227, 17228, 17205, 0, 0, 0, 0
4439, 17205, 17228, 2168, 2167, 0, 0, 0, 0
4440, 2098, 2099, 17229, 17206, 0, 0, 0, 0
4441, 17206, 17229, 17230, 17207, 0, 0, 0, 0
4442, 17207, 17230, 17231, 17208, 0, 0, 0, 0
4443, 17208, 17231, 17232, 17209, 0, 0, 0, 0
4444, 17209, 17232, 17233, 17210, 0, 0, 0, 0
4445, 17210, 17233, 17234, 17211, 0, 0, 0, 0
4446, 17211, 17234, 17235, 17212, 0, 0, 0, 0
4447, 17212, 17235, 17236, 17213, 0, 0, 0, 0
4448, 17213, 17236, 17237, 17214, 0, 0, 0, 0
4449, 17214, 17237, 17238, 17215, 0, 0, 0, 0
4450, 17215, 17238, 17239, 17216, 0, 0, 0, 0
4451, 17216, 17239, 17240, 17217, 0, 0, 0, 0
4452, 17217, 17240, 17241, 17218, 0, 0, 0, 0
4453, 17218, 17241, 17242, 17219, 0, 0, 0, 0
4454, 17219, 17242, 17243, 17220, 0, 0, 0, 0
4455, 17220, 17243, 17244, 17221, 0, 0, 0, 0
4456, 17221, 17244, 17245, 17222, 0, 0, 0, 0
4457, 17222, 17245, 17246, 17223, 0, 0, 0, 0
4458, 17223, 17246, 17247, 17224, 0, 0, 0, 0
4459, 17224, 17247, 17248, 17225, 0, 0, 0, 0
4460, 17225, 17248, 17249, 17226, 0, 0, 0, 0
4461, 17226, 17249, 17250, 17227, 0, 0, 0, 0
4462, 17227, 17250, 17251, 17228, 0, 0, 0, 0
4463, 17228, 17251, 2169, 2168, 0, 0, 0, 0
4464, 2099, 2100, 17252, 17229, 0, 0, 0, 0
4465, 17229, 17252, 17253, 17230, 0, 0, 0, 0
4466, 17230, 17253, 17254, 17231, 0, 0, 0, 0
4467, 17231, 17254, 17255, 17232, 0, 0, 0, 0
4468, 17232, 17255, 17256, 17233, 0, 0, 0, 0
4469, 17233, 17256, 17257, 17234, 0, 0, 0, 0
4470, 17234, 17257, 17258, 17235, 0, 0, 0, 0
4471, 17235, 17258, 17259, 17236, 0, 0, 0, 0
4472, 17236, 17259, 17260, 17237, 0, 0, 0, 0
4473, 17237, 17260, 17261, 17238, 0, 0, 0, 0
4474, 17238, 17261, 17262, 17239, 0, 0, 0, 0
4475, 17239, 17262, 17263, 17240, 0, 0, 0, 0
4476, 17240, 17263, 17264, 17241, 0, 0, 0, 0
4477, 17241, 17264, 17265, 17242, 0, 0, 0, 0
4478, 17242, 17265, 17266, 17243, 0, 0, 0, 0
4479, 17243, 17266, 17267, 17244, 0, 0, 0, 0
4480, 17244, 17267, 17268, 17245, 0, 0, 0, 0
4481, 17245, 17268, 17269, 17246, 0, 0, 0, 0
4482, 17246, 17269, 17270, 17247, 0, 0, 0, 0
4483, 17247, 17270, 17271, 17248, 0, 0, 0, 0
4484, 17248, 17271, 17272, 17249, 0, 0, 0, 0
4485, 17249, 17272, 17273, 17250, 0, 0, 0, 0
4486, 17250, 17273, 17274, 17251, 0, 0, 0, 0
4487, 17251, 17274, 2170, 2169, 0, 0, 0, 0
4488, 2100, 2101, 17275, 17252, 0, 0, 0, 0
4489, 17252, 17275, 17276, 17253, 0, 0, 0, 0
4490, 17253, 17276, 17277, 17254, 0, 0, 0, 0
4491, 17254, 17277, 17278, 17255, 0, 0, 0, 0
4492, 17255, 17278, 17279, 17256, 0, 0, 0, 0
4493, 17256, 17279, 17280, 17257, 0, 0, 0, 0
4494, 17257, 17280, 17281, 17258, 0, 0, 0, 0
4495, 17258, 17281, 17282, 17259, 0, 0, 0, 0
4496, 17259, 17282, 17283, 17260, 0, 0, 0, 0
4497, 17260, 17283, 17284, 17261, 0, 0, 0, 0
4498, 17261, 17284, 17285, 17262, 0, 0, 0, 0
4499, 17262, 17285, 17286, 17263, 0, 0, 0, 0
4500, 17263, 17286, 17287, 17264, 0, 0, 0, 0
4501, 17264, 17287, 17288, 17265, 0, 0, 0, 0
4502, 17265, 17288, 17289, 17266, 0, 0, 0, 0
4503, 17266, 17289, 17290, 17267, 0, 0, 0, 0
4504, 17267, 17290, 17291, 17268, 0, 0, 0, 0
4505, 17268, 17291, 17292, 17269, 0, 0, 0, 0
4506, 17269, 17292, 17293, 17270, 0, 0, 0, 0
4507, 17270, 17293, 17294, 17271, 0, 0, 0, 0
4508, 17271, 17294, 17295, 17272, 0, 0, 0, 0
4509, 17272, 17295, 17296, 17273, 0, 0, 0, 0
4510, 17273, 17296, 17297, 17274, 0, 0, 0, 0
4511, 17274, 17297, 2171, 2170, 0, 0, 0, 0
4512, 2101, 81, 2106, 17275, 0, 0, 0, 0
4513, 17275, 2106, 2107, 17276, 0, 0, 0, 0
4514, 17276, 2107, 2108, 17277, 0, 0, 0, 0
4515, 17277, 2108, 2109, 17278, 0, 0, 0, 0
4516, 17278, 2109, 2110, 17279, 0, 0, 0, 0
4517, 17279, 2110, 2111, 17280, 0, 0, 0, 0
4518, 17280, 2111, 2112, 17281, 0, 0, 0, 0
4519, 17281, 2112, 2113, 17282, 0, 0, 0, 0
4520, 17282, 2113, 2114, 17283, 0, 0, 0, 0
4521, 17283, 2114, 2115, 17284, 0, 0, 0, 0
4522, 17284, 2115, 2116, 17285, 0, 0, 0, 0
4523, 17285, 2116, 2117, 17286, 0, 0, 0, 0
4524, 17286, 2117, 2118, 17287, 0, 0, 0, 0
4525, 17287, 2118, 2119, 17288, 0, 0, 0, 0
4526, 17288, 2119, 2120, 17289, 0, 0, 0, 0
4527, 17289, 2120, 2121, 17290, 0, 0, 0, 0
4528, 17290, 2121, 2122, 17291, 0, 0, 0, 0
4529, 17291, 2122, 2123, 17292, 0, 0, 0, 0
4530, 17292, 2123, 2124, 17293, 0, 0, 0, 0
4531, 17293, 2124, 2125, 17294, 0, 0, 0, 0
4532, 17294, 2125, 2126, 17295, 0, 0, 0, 0
4533, 17295, 2126, 2127, 17296, 0, 0, 0, 0
4534, 17296, 2127, 2128, 17297, 0, 0, 0, 0
4535, 17297, 2128, 83, 2171, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface118
41545, 2, 150, 17298, 2181, 0, 17390, 17391, 2185
41546, 2181, 17298, 17299, 2182, 17391, 17392, 17393, 2186
41547, 2182, 17299, 17300, 2183, 17393, 17394, 17395, 2187
41548, 2183, 17300, 17301, 2184, 17395, 17396, 17397, 2188
41549, 2184, 17301, 2190, 86, 17397, 17398, 0, 2189
41550, 150, 151, 17302, 17298, 0, 17399, 17400, 17390
41551, 17298, 17302, 17303, 17299, 17400, 17401, 17402, 17392
41552, 17299, 17303, 17304, 17300, 17402, 17403, 17404, 17394
41553, 17300, 17304, 17305, 17301, 17404, 17405, 17406, 17396
41554, 17301, 17305, 2191, 2190, 17406, 17407, 0, 17398
41555, 151, 152, 17306, 17302, 0, 17408, 17409, 17399
41556, 17302, 17306, 17307, 17303, 17409, 17410, 17411, 17401
41557, 17303, 17307, 17308, 17304, 17411, 17412, 17413, 17403
41558, 17304, 17308, 17309, 17305, 17413, 17414, 17415, 17405
41559, 17305, 17309, 2192, 2191, 17415, 17416, 0, 17407
41560, 152, 153, 17310, 17306, 0, 17417, 17418, 17408
41561, 17306, 17310, 17311, 17307, 17418, 17419, 17420, 17410
41562, 17307, 17311, 17312, 17308, 17420, 17421, 17422, 17412
41563, 17308, 17312, 17313, 17309, 17422, 17423, 17424, 17414
41564, 17309, 17313, 2193, 2192, 17424, 17425, 0, 17416
41565, 153, 154, 17314, 17310, 0, 17426, 17427, 17417
41566, 17310, 17314, 17315, 17311, 17427, 17428, 17429, 17419
41567, 17311, 17315, 17316, 17312, 17429, 17430, 17431, 17421
41568, 17312, 17316, 17317, 17313, 17431, 17432, 17433, 17423
41569, 17313, 17317, 2194, 2193, 17433, 17434, 0, 17425
41570, 154, 155, 17318, 17314, 0, 17435, 17436, 17426
41571, 17314, 17318, 17319, 17315, 17436, 17437, 17438, 17428
41572, 17315, 17319, 17320, 17316, 17438, 17439, 17440, 17430
41573, 17316, 17320, 17321, 17317, 17440, 17441, 17442, 17432
41574, 17317, 17321, 2195, 2194, 17442, 17443, 0, 17434
41575, 155, 156, 17322, 17318, 0, 17444, 17445, 17435
41576, 17318, 17322, 17323, 17319, 17445, 17446, 17447, 17437
41577, 17319, 17323, 17324, 17320, 17447, 17448, 17449, 17439
41578, 17320, 17324, 17325, 17321, 17449, 17450, 17451, 17441
41579, 17321, 17325, 2196, 2195, 17451, 17452, 0, 17443
41580, 156, 157, 17326, 17322, 0, 17453, 17454, 17444
41581, 17322, 17326, 17327, 17323, 17454, 17455, 17456, 17446
41582, 17323, 17327, 17328, 17324, 17456, 17457, 17458, 17448
41583, 17324, 17328, 17329, 17325, 17458, 17459, 17460, 17450
41584, 17325, 17329, 2197, 2196, 17460, 17461, 0, 17452
41585, 157, 158, 17330, 17326, 0, 17462, 17463, 17453
41586, 17326, 17330, 17331, 17327, 17463, 17464, 17465, 17455
41587, 17327, 17331, 17332, 17328, 17465, 17466, 17467, 17457
41588, 17328, 17332, 17333, 17329, 17467, 17468, 17469, 17459
41589, 17329, 17333, 2198, 2197, 17469, 17470, 0, 17461
41590, 158, 159, 17334, 17330, 0, 17471, 17472, 17462
41591, 17330, 17334, 17335, 17331, 17472, 17473, 17474, 17464
41592, 17331, 17335, 17336, 17332, 17474, 17475, 17476, 17466
41593, 17332, 17336, 17337, 17333, 17476, 17477, 17478, 17468
41594, 17333, 17337, 2199, 2198, 17478, 17479, 0, 17470
41595, 159, 160, 17338, 17334, 0, 17480, 17481, 17471
41596, 17334, 17338, 17339, 17335, 17481, 17482, 17483, 17473
41597, 17335, 17339, 17340, 17336, 17483, 17484, 17485, 17475
41598, 17336, 17340, 17341, 17337, 17485, 17486, 17487, 17477
41599, 17337, 17341, 2200, 2199, 17487, 17488, 0, 17479
41600, 160, 161, 17342, 17338, 0, 17489, 17490, 17480
41601, 17338, 17342, 17343, 17339, 17490, 17491, 17492, 17482
41602, 17339, 17343, 17344, 17340, 17492, 17493, 17494, 17484
41603, 17340, 17344, 17345, 17341, 17494, 17495, 17496, 17486
41604, 17341, 17345, 2201, 2200, 17496, 17497, 0, 17488
41605, 161, 162, 17346, 17342, 0, 17498, 17499, 17489
41606, 17342, 17346, 17347, 17343, 17499, 17500, 17501, 17491
41607, 17343, 17347, 17348, 17344, 17501, 17502, 17503, 17493
41608, 17344, 17348, 17349, 17345, 17503, 17504, 17505, 17495
41609, 17345, 17349, 2202, 2201, 17505, 17506, 0, 17497
41610, 162, 163, 17350, 17346, 0, 17507, 17508, 17498
41611, 17346, 17350, 17351, 17347, 17508, 17509, 17510, 17500
41612, 17347, 17351, 17352, 17348, 17510, 17511, 17512, 17502
41613, 17348, 17352, 17353, 17349, 17512, 17513, 17514, 17504
41614, 17349, 17353, 2203, 2202, 17514, 17515, 0, 17506
41615, 163, 164, 17354, 17350, 0, 17516, 17517, 17507
41616, 17350, 17354, 17355, 17351, 17517, 17518, 17519, 17509
41617, 17351, 17355, 17356, 17352, 17519, 17520, 17521, 17511
41618, 17352, 17356, 17357, 17353, 17521, 17522, 17523, 17513
41619, 17353, 17357, 2204, 2203, 17523, 17524, 0, 17515
41620, 164, 165, 17358, 17354, 0, 17525, 17526, 17516
41621, 17354, 17358, 17359, 17355, 17526, 17527, 17528, 17518
41622, 17355, 17359, 17360, 17356, 17528, 17529, 17530, 17520
41623, 17356, 17360, 17361, 17357, 17530, 17531, 17532, 17522
41624, 17357, 17361, 2205, 2204, 17532, 17533, 0, 17524
41625, 165, 166, 17362, 17358, 0, 17534, 17535, 17525
41626, 17358, 17362, 17363, 17359, 17535, 17536, 17537, 17527
41627, 17359, 17363, 17364, 17360, 17537, 17538, 17539, 17529
41628, 17360, 17364, 17365, 17361, 17539, 17540, 17541, 17531
41629, 17361, 17365, 2206, 2205, 17541, 17542, 0, 17533
41630, 166, 167, 17366, 17362, 0, 17543, 17544, 17534
41631, 17362, 17366, 17367, 17363, 17544, 17545, 17546, 17536
41632, 17363, 17367, 17368, 17364, 17546, 17547, 17548, 17538
41633, 17364, 17368, 17369, 17365, 17548, 17549, 17550, 17540
41634, 17365, 17369, 2207, 2206, 17550, 17551, 0, 17542
41635, 167, 168, 17370, 17366, 0, 17552, 17553, 17543
41636, 17366, 17370, 17371, 17367, 17553, 17554, 17555, 17545
41637, 17367, 17371, 17372, 17368, 17555, 17556, 17557, 17547
41638, 17368, 17372, 17373, 17369, 17557, 17558, 17559, 17549
41639, 17369, 17373, 2208, 2207, 17559, 17560, 0, 17551
41640, 168, 169, 17374, 17370, 0, 17561, 17562, 17552
41641, 17370, 17374, 17375, 17371, 17562, 17563, 17564, 17554
41642, 17371, 17375, 17376, 17372, 17564, 17565, 17566, 17556
41643, 17372, 17376, 17377, 17373, 17566, 17567, 17568, 17558
41644, 17373, 17377, 2209, 2208, 17568, 17569, 0, 17560
41645, 169, 170, 17378, 17374, 0, 17570, 17571, 17561
41646, 17374, 17378, 17379, 17375, 17571, 17572, 17573, 17563
41647, 17375, 17379, 17380, 17376, 17573, 17574, 17575, 17565
41648, 17376, 17380, 17381, 17377, 17575, 17576, 17577, 17567
41649, 17377, 17381, 2210, 2209, 17577, 17578, 0, 17569
41650, 170, 171, 17382, 17378, 0, 17579, 17580, 17570
41651, 17378, 17382, 17383, 17379, 17580, 17581, 17582, 17572
41652, 17379, 17383, 17384, 17380, 17582, 17583, 17584, 17574
41653, 17380, 17384, 17385, 17381, 17584, 17585, 17586, 17576
41654, 17381, 17385, 2211, 2210, 17586, 17587, 0, 17578
41655, 171, 172, 17386, 17382, 0, 17588, 17589, 17579
41656, 17382, 17386, 17387, 17383, 17589, 17590, 17591, 17581
41657, 17383, 17387, 17388, 17384, 17591, 17592, 17593, 17583
41658, 17384, 17388, 17389, 17385, 17593, 17594, 17595, 17585
41659, 17385, 17389, 2212, 2211, 17595, 17596, 0, 17587
41660, 172, 6, 2172, 17386, 0, 2176, 17597, 17588
41661, 17386, 2172, 2173, 17387, 17597, 2177, 17598, 17590
41662, 17387, 2173, 2174, 17388, 17598, 2178, 17599, 17592
41663, 17388, 2174, 2175, 17389, 17599, 2179, 17600, 17594
41664, 17389, 2175, 85, 2212, 17600, 2180, 0, 17596
*ELEMENT, type=CPS8, ELSET=Surface119
41665, 6, 124, 17601, 2172, 0, 17645, 17646, 2176
41666, 2172, 17601, 17602, 2173, 17646, 17647, 17648, 2177
41667, 2173, 17602, 17603, 2174, 17648, 17649, 17650, 2178
41668, 2174, 17603, 17604, 2175, 17650, 17651, 17652, 2179
41669, 2175, 17604, 2217, 85, 17652, 17653, 0, 2180
41670, 124, 125, 17605, 17601, 0, 17654, 17655, 17645
41671, 17601, 17605, 17606, 17602, 17655, 17656, 17657, 17647
41672, 17602, 17606, 17607, 17603, 17657, 17658, 17659, 17649
41673, 17603, 17607, 17608, 17604, 17659, 17660, 17661, 17651
41674, 17604, 17608, 2218, 2217, 17661, 17662, 0, 17653
41675, 125, 126, 17609, 17605, 0, 17663, 17664, 17654
41676, 17605, 17609, 17610, 17606, 17664, 17665, 17666, 17656
41677, 17606, 17610, 17611, 17607, 17666, 17667, 17668, 17658
41678, 17607, 17611, 17612, 17608, 17668, 17669, 17670, 17660
41679, 17608, 17612, 2219, 2218, 17670, 17671, 0, 17662
41680, 126, 127, 17613, 17609, 0, 17672, 17673, 17663
41681, 17609, 17613, 17614, 17610, 17673, 17674, 17675, 17665
41682, 17610, 17614, 17615, 17611, 17675, 17676, 17677, 17667
41683, 17611, 17615, 17616, 17612, 17677, 17678, 17679, 17669
41684, 17612, 17616, 2220, 2219, 17679, 17680, 0, 17671
41685, 127, 128, 17617, 17613, 0, 17681, 17682, 17672
41686, 17613, 17617, 17618, 17614, 17682, 17683, 17684, 17674
41687, 17614, 17618, 17619, 17615, 17684, 17685, 17686, 17676
41688, 17615, 17619, 17620, 17616, 17686, 17687, 17688, 17678
41689, 17616, 17620, 2221, 2220, 17688, 17689, 0, 17680
41690, 128, 129, 17621, 17617, 0, 17690, 17691, 17681
41691, 17617, 17621, 17622, 17618, 17691, 17692, 17693, 17683
41692, 17618, 17622, 17623, 17619, 17693, 17694, 17695, 17685
41693, 17619, 17623, 17624, 17620, 17695, 17696, 17697, 17687
41694, 17620, 17624, 2222, 2221, 17697, 17698, 0, 17689
41695, 129, 130, 17625, 17621, 0, 17699, 17700, 17690
41696, 17621, 17625, 17626, 17622, 17700, 17701, 17702, 17692
41697, 17622, 17626, 17627, 17623, 17702, 17703, 17704, 17694
41698, 17623, 17627, 17628, 17624, 17704, 17705, 17706, 17696
41699, 17624, 17628, 2223, 2222, 17706, 17707, 0, 17698
41700, 130, 131, 17629, 17625, 0, 17708, 17709, 17699
41701, 17625, 17629, 17630, 17626, 17709, 17710, 17711, 17701
41702, 17626, 17630, 17631, 17627, 17711, 17712, 17713, 17703
41703, 17627, 17631, 17632, 17628, 17713, 17714, 17715, 17705
41704, 17628, 17632, 2224, 2223, 17715, 17716, 0, 17707
41705, 131, 132, 17633, 17629, 0, 17717, 17718, 17708
41706, 17629, 17633, 17634, 17630, 17718, 17719, 17720, 17710
41707, 17630, 17634, 17635, 17631, 17720, 17721, 17722, 17712
41708, 17631, 17635, 17636, 17632, 17722, 17723, 17724, 17714
41709, 17632, 17636, 2225, 2224, 17724, 17725, 0, 17716
41710, 132, 133, 17637, 17633, 0, 17726, 17727, 17717
41711, 17633, 17637, 17638, 17634, 17727, 17728, 17729, 17719
41712, 17634, 17638, 17639, 17635, 17729, 17730, 17731, 17721
41713, 17635, 17639, 17640, 17636, 17731, 17732, 17733, 17723
41714, 17636, 17640, 2226, 2225, 17733, 17734, 0, 17725
41715, 133, 134, 17641, 17637, 0, 17735, 17736, 17726
41716, 17637, 17641, 17642, 17638, 17736, 17737, 17738, 17728
41717, 17638, 17642, 17643, 17639, 17738, 17739, 17740, 17730
41718, 17639, 17643, 17644, 17640, 17740, 17741, 17742, 17732
41719, 17640, 17644, 2227, 2226, 17742, 17743, 0, 17734
41720, 134, 5, 2213, 17641, 0, 0, 17744, 17735
41721, 17641, 2213, 2214, 17642, 17744, 0, 17745, 17737
41722, 17642, 2214, 2215, 17643, 17745, 0, 17746, 17739
41723, 17643, 2215, 2216, 17644, 17746, 0, 17747, 17741
41724, 17644, 2216, 87, 2227, 17747, 0, 0, 17743
*ELEMENT, type=CPS8, ELSET=Surface120
4536, 1, 2228, 17748, 173, 0, 0, 0, 0
4537, 2228, 2229, 17749, 17748, 0, 0, 0, 0
4538, 2229, 2230, 17750, 17749, 0, 0, 0, 0
4539, 2230, 2231, 17751, 17750, 0, 0, 0, 0
4540, 2231, 88, 2232, 17751, 0, 0, 0, 0
4541, 173, 17748, 17752, 174, 0, 0, 0, 0
4542, 17748, 17749, 17753, 17752, 0, 0, 0, 0
4543, 17749, 17750, 17754, 17753, 0, 0, 0, 0
4544, 17750, 17751, 17755, 17754, 0, 0, 0, 0
4545, 17751, 2232, 2233, 17755, 0, 0, 0, 0
4546, 174, 17752, 17756, 175, 0, 0, 0, 0
4547, 17752, 17753, 17757, 17756, 0, 0, 0, 0
4548, 17753, 17754, 17758, 17757, 0, 0, 0, 0
4549, 17754, 17755, 17759, 17758, 0, 0, 0, 0
4550, 17755, 2233, 2234, 17759, 0, 0, 0, 0
4551, 175, 17756, 17760, 176, 0, 0, 0, 0
4552, 17756, 17757, 17761, 17760, 0, 0, 0, 0
4553, 17757, 17758, 17762, 17761, 0, 0, 0, 0
4554, 17758, 17759, 17763, 17762, 0, 0, 0, 0
4555, 17759, 2234, 2235, 17763, 0, 0, 0, 0
4556, 176, 17760, 17764, 177, 0, 0, 0, 0
4557, 17760, 17761, 17765, 17764, 0, 0, 0, 0
4558, 17761, 17762, 17766, 17765, 0, 0, 0, 0
4559, 17762, 17763, 17767, 17766, 0, 0, 0, 0
4560, 17763, 2235, 2236, 17767, 0, 0, 0, 0
4561, 177, 17764, 17768, 178, 0, 0, 0, 0
4562, 17764, 17765, 17769, 17768, 0, 0, 0, 0
4563, 17765, 17766, 17770, 17769, 0, 0, 0, 0
4564, 17766, 17767, 17771, 17770, 0, 0, 0, 0
4565, 17767, 2236, 2237, 17771, 0, 0, 0, 0
4566, 178, 17768, 17772, 179, 0, 0, 0, 0
4567, 17768, 17769, 17773, 17772, 0, 0, 0, 0
4568, 17769, 17770, 17774, 17773, 0, 0, 0, 0
4569, 17770, 17771, 17775, 17774, 0, 0, 0, 0
4570, 17771, 2237, 2238, 17775, 0, 0, 0, 0
4571, 179, 17772, 17776, 180, 0, 0, 0, 0
4572, 17772, 17773, 17777, 17776, 0, 0, 0, 0
4573, 17773, 17774, 17778, 17777, 0, 0, 0, 0
4574, 17774, 17775, 17779, 17778, 0, 0, 0, 0
4575, 17775, 2238, 2239, 17779, 0, 0, 0, 0
4576, 180, 17776, 17780, 181, 0, 0, 0, 0
4577, 17776, 17777, 17781, 17780, 0, 0, 0, 0
4578, 17777, 17778, 17782, 17781, 0, 0, 0, 0
4579, 17778, 17779, 17783, 17782, 0, 0, 0, 0
4580, 17779, 2239, 2240, 17783, 0, 0, 0, 0
4581, 181, 17780, 17784, 182, 0, 0, 0, 0
4582, 17780, 17781, 17785, 17784, 0, 0, 0, 0
4583, 17781, 17782, 17786, 17785, 0, 0, 0, 0
4584, 17782, 17783, 17787, 17786, 0, 0, 0, 0
4585, 17783, 2240, 2241, 17787, 0, 0, 0, 0
4586, 182, 17784, 17788, 183, 0, 0, 0, 0
4587, 17784, 17785, 17789, 17788, 0, 0, 0, 0
4588, 17785, 17786, 17790, 17789, 0, 0, 0, 0
4589, 17786, 17787, 17791, 17790, 0, 0, 0, 0
4590, 17787, 2241, 2242, 17791, 0, 0, 0, 0
4591, 183, 17788, 17792, 184, 0, 0, 0, 0
4592, 17788, 17789, 17793, 17792, 0, 0, 0, 0
4593, 17789, 17790, 17794, 17793, 0, 0, 0, 0
4594, 17790, 17791, 17795, 17794, 0, 0, 0, 0
4595, 17791, 2242, 2243, 17795, 0, 0, 0, 0
4596, 184, 17792, 17796, 185, 0, 0, 0, 0
4597, 17792, 17793, 17797, 17796, 0, 0, 0, 0
4598, 17793, 17794, 17798, 17797, 0, 0, 0, 0
4599, 17794, 17795, 17799, 17798, 0, 0, 0, 0
4600, 17795, 2243, 2244, 17799, 0, 0, 0, 0
4601, 185, 17796, 17800, 186, 0, 0, 0, 0
4602, 17796, 17797, 17801, 17800, 0, 0, 0, 0
4603, 17797, 17798, 17802, 17801, 0, 0, 0, 0
4604, 17798, 17799, 17803, 17802, 0, 0, 0, 0
4605, 17799, 2244, 2245, 17803, 0, 0, 0, 0
4606, 186, 17800, 17804, 187, 0, 0, 0, 0
4607, 17800, 17801, 17805, 17804, 0, 0, 0, 0
4608, 17801, 17802, 17806, 17805, 0, 0, 0, 0
4609, 17802, 17803, 17807, 17806, 0, 0, 0, 0
4610, 17803, 2245, 2246, 17807, 0, 0, 0, 0
4611, 187, 17804, 17808, 188, 0, 0, 0, 0
4612, 17804, 17805, 17809, 17808, 0, 0, 0, 0
4613, 17805, 17806, 17810, 17809, 0, 0, 0, 0
4614, 17806, 17807, 17811, 17810, 0, 0, 0, 0
4615, 17807, 2246, 2247, 17811, 0, 0, 0, 0
4616, 188, 17808, 17812, 189, 0, 0, 0, 0
4617, 17808, 17809, 17813, 17812, 0, 0, 0, 0
4618, 17809, 17810, 17814, 17813, 0, 0, 0, 0
4619, 17810, 17811, 17815, 17814, 0, 0, 0, 0
4620, 17811, 2247, 2248, 17815, 0, 0, 0, 0
4621, 189, 17812, 17816, 190, 0, 0, 0, 0
4622, 17812, 17813, 17817, 17816, 0, 0, 0, 0
4623, 17813, 17814, 17818, 17817, 0, 0, 0, 0
4624, 17814, 17815, 17819, 17818, 0, 0, 0, 0
4625, 17815, 2248, 2249, 17819, 0, 0, 0, 0
4626, 190, 17816, 17820, 191, 0, 0, 0, 0
4627, 17816, 17817, 17821, 17820, 0, 0, 0, 0
4628, 17817, 17818, 17822, 17821, 0, 0, 0, 0
4629, 17818, 17819, 17823, 17822, 0, 0, 0, 0
4630, 17819, 2249, 2250, 17823, 0, 0, 0, 0
4631, 191, 17820, 17824, 192, 0, 0, 0, 0
4632, 17820, 17821, 17825, 17824, 0, 0, 0, 0
4633, 17821, 17822, 17826, 17825, 0, 0, 0, 0
4634, 17822, 17823, 17827, 17826, 0, 0, 0, 0
4635, 17823, 2250, 2251, 17827, 0, 0, 0, 0
4636, 192, 17824, 17828, 193, 0, 0, 0, 0
4637, 17824, 17825, 17829, 17828, 0, 0, 0, 0
4638, 17825, 17826, 17830, 17829, 0, 0, 0, 0
4639, 17826, 17827, 17831, 17830, 0, 0, 0, 0
4640, 17827, 2251, 2252, 17831, 0, 0, 0, 0
4641, 193, 17828, 17832, 194, 0, 0, 0, 0
4642, 17828, 17829, 17833, 17832, 0, 0, 0, 0
4643, 17829, 17830, 17834, 17833, 0, 0, 0, 0
4644, 17830, 17831, 17835, 17834, 0, 0, 0, 0
4645, 17831, 2252, 2253, 17835, 0, 0, 0, 0
4646, 194, 17832, 17836, 195, 0, 0, 0, 0
4647, 17832, 17833, 17837, 17836, 0, 0, 0, 0
4648, 17833, 17834, 17838, 17837, 0, 0, 0, 0
4649, 17834, 17835, 17839, 17838, 0, 0, 0, 0
4650, 17835, 2253, 2254, 17839, 0, 0, 0, 0
4651, 195, 17836, 2213, 5, 0, 0, 0, 0
4652, 17836, 17837, 2214, 2213, 0, 0, 0, 0
4653, 17837, 17838, 2215, 2214, 0, 0, 0, 0
4654, 17838, 17839, 2216, 2215, 0, 0, 0, 0
4655, 17839, 2254, 87, 2216, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface121
41725, 2, 2181, 17840, 98, 2185, 17884, 17885, 97
41726, 2181, 2182, 17841, 17840, 2186, 17886, 17887, 17884
41727, 2182, 2183, 17842, 17841, 2187, 17888, 17889, 17886
41728, 2183, 2184, 17843, 17842, 2188, 17890, 17891, 17888
41729, 2184, 86, 2255, 17843, 2189, 0, 17892, 17890
41730, 98, 17840, 17844, 99, 17885, 17893, 17894, 0
41731, 17840, 17841, 17845, 17844, 17887, 17895, 17896, 17893
41732, 17841, 17842, 17846, 17845, 17889, 17897, 17898, 17895
41733, 17842, 17843, 17847, 17846, 17891, 17899, 17900, 17897
41734, 17843, 2255, 2256, 17847, 17892, 0, 17901, 17899
41735, 99, 17844, 17848, 100, 17894, 17902, 17903, 0
41736, 17844, 17845, 17849, 17848, 17896, 17904, 17905, 17902
41737, 17845, 17846, 17850, 17849, 17898, 17906, 17907, 17904
41738, 17846, 17847, 17851, 17850, 17900, 17908, 17909, 17906
41739, 17847, 2256, 2257, 17851, 17901, 0, 17910, 17908
41740, 100, 17848, 17852, 101, 17903, 17911, 17912, 0
41741, 17848, 17849, 17853, 17852, 17905, 17913, 17914, 17911
41742, 17849, 17850, 17854, 17853, 17907, 17915, 17916, 17913
41743, 17850, 17851, 17855, 17854, 17909, 17917, 17918, 17915
41744, 17851, 2257, 2258, 17855, 17910, 0, 17919, 17917
41745, 101, 17852, 17856, 102, 17912, 17920, 17921, 0
41746, 17852, 17853, 17857, 17856, 17914, 17922, 17923, 17920
41747, 17853, 17854, 17858, 17857, 17916, 17924, 17925, 17922
41748, 17854, 17855, 17859, 17858, 17918, 17926, 17927, 17924
41749, 17855, 2258, 2259, 17859, 17919, 0, 17928, 17926
41750, 102, 17856, 17860, 103, 17921, 17929, 17930, 0
41751, 17856, 17857, 17861, 17860, 17923, 17931, 17932, 17929
41752, 17857, 17858, 17862, 17861, 17925, 17933, 17934, 17931
41753, 17858, 17859, 17863, 17862, 17927, 17935, 17936, 17933
41754, 17859, 2259, 2260, 17863, 17928, 0, 17937, 17935
41755, 103, 17860, 17864, 104, 17930, 17938, 17939, 0
41756, 17860, 17861, 17865, 17864, 17932, 17940, 17941, 17938
41757, 17861, 17862, 17866, 17865, 17934, 17942, 17943, 17940
41758, 17862, 17863, 17867, 17866, 17936, 17944, 17945, 17942
41759, 17863, 2260, 2261, 17867, 17937, 0, 17946, 17944
41760, 104, 17864, 17868, 105, 17939, 17947, 17948, 0
41761, 17864, 17865, 17869, 17868, 17941, 17949, 17950, 17947
41762, 17865, 17866, 17870, 17869, 17943, 17951, 17952, 17949
41763, 17866, 17867, 17871, 17870, 17945, 17953, 17954, 17951
41764, 17867, 2261, 2262, 17871, 17946, 0, 17955, 17953
41765, 105, 17868, 17872, 106, 17948, 17956, 17957, 0
41766, 17868, 17869, 17873, 17872, 17950, 17958, 17959, 17956
41767, 17869, 17870, 17874, 17873, 17952, 17960, 17961, 17958
41768, 17870, 17871, 17875, 17874, 17954, 17962, 17963, 17960
41769, 17871, 2262, 2263, 17875, 17955, 0, 17964, 17962
41770, 106, 17872, 17876, 107, 17957, 17965, 17966, 0
41771, 17872, 17873, 17877, 17876, 17959, 17967, 17968, 17965
41772, 17873, 17874, 17878, 17877, 17961, 17969, 17970, 17967
41773, 17874, 17875, 17879, 17878, 17963, 17971, 17972, 17969
41774, 17875, 2263, 2264, 17879, 17964, 0, 17973, 17971
41775, 107, 17876, 17880, 108, 17966, 17974, 17975, 0
41776, 17876, 17877, 17881, 17880, 17968, 17976, 17977, 17974
41777, 17877, 17878, 17882, 17881, 17970, 17978, 17979, 17976
41778, 17878, 17879, 17883, 17882, 17972, 17980, 17981, 17978
41779, 17879, 2264, 2265, 17883, 17973, 0, 17982, 17980
41780, 108, 17880, 2228, 1, 17975, 17983, 0, 0
41781, 17880, 17881, 2229, 2228, 17977, 17984, 0, 17983
41782, 17881, 17882, 2230, 2229, 17979, 17985, 0, 17984
41783, 17882, 17883, 2231, 2230, 17981, 17986, 0, 17985
41784, 17883, 2265, 88, 2231, 17982, 0, 0, 17986
*ELEMENT, type=CPS8, ELSET=Surface122
4656, 86, 2190, 17987, 2255, 0, 0, 0, 0
4657, 2255, 17987, 17988, 2256, 0, 0, 0, 0
4658, 2256, 17988, 17989, 2257, 0, 0, 0, 0
4659, 2257, 17989, 17990, 2258, 0, 0, 0, 0
4660, 2258, 17990, 17991, 2259, 0, 0, 0, 0
4661, 2259, 17991, 17992, 2260, 0, 0, 0, 0
4662, 2260, 17992, 17993, 2261, 0, 0, 0, 0
4663, 2261, 17993, 17994, 2262, 0, 0, 0, 0
4664, 2262, 17994, 17995, 2263, 0, 0, 0, 0
4665, 2263, 17995, 17996, 2264, 0, 0, 0, 0
4666, 2264, 17996, 17997, 2265, 0, 0, 0, 0
4667, 2265, 17997, 2232, 88, 0, 0, 0, 0
4668, 2190, 2191, 17998, 17987, 0, 0, 0, 0
4669, 17987, 17998, 17999, 17988, 0, 0, 0, 0
4670, 17988, 17999, 18000, 17989, 0, 0, 0, 0
4671, 17989, 18000, 18001, 17990, 0, 0, 0, 0
4672, 17990, 18001, 18002, 17991, 0, 0, 0, 0
4673, 17991, 18002, 18003, 17992, 0, 0, 0, 0
4674, 17992, 18003, 18004, 17993, 0, 0, 0, 0
4675, 17993, 18004, 18005, 17994, 0, 0, 0, 0
4676, 17994, 18005, 18006, 17995, 0, 0, 0, 0
4677, 17995, 18006, 18007, 17996, 0, 0, 0, 0
4678, 17996, 18007, 18008, 17997, 0, 0, 0, 0
4679, 17997, 18008, 2233, 2232, 0, 0, 0, 0
4680, 2191, 2192, 18009, 17998, 0, 0, 0, 0
4681, 17998, 18009, 18010, 17999, 0, 0, 0, 0
4682, 17999, 18010, 18011, 18000, 0, 0, 0, 0
4683, 18000, 18011, 18012, 18001, 0, 0, 0, 0
4684, 18001, 18012, 18013, 18002, 0, 0, 0, 0
4685, 18002, 18013, 18014, 18003, 0, 0, 0, 0
4686, 18003, 18014, 18015, 18004, 0, 0, 0, 0
4687, 18004, 18015, 18016, 18005, 0, 0, 0, 0
4688, 18005, 18016, 18017, 18006, 0, 0, 0, 0
4689, 18006, 18017, 18018, 18007, 0, 0, 0, 0
4690, 18007, 18018, 18019, 18008, 0, 0, 0, 0
4691, 18008, 18019, 2234, 2233, 0, 0, 0, 0
4692, 2192, 2193, 18020, 18009, 0, 0, 0, 0
4693, 18009, 18020, 18021, 18010, 0, 0, 0, 0
4694, 18010, 18021, 18022, 18011, 0, 0, 0, 0
4695, 18011, 18022, 18023, 18012, 0, 0, 0, 0
4696, 18012, 18023, 18024, 18013, 0, 0, 0, 0
4697, 18013, 18024, 18025, 18014, 0, 0, 0, 0
4698, 18014, 18025, 18026, 18015, 0, 0, 0, 0
4699, 18015, 18026, 18027, 18016, 0, 0, 0, 0
4700, 18016, 18027, 18028, 18017, 0, 0, 0, 0
4701, 18017, 18028, 18029, 18018, 0, 0, 0, 0
4702, 18018, 18029, 18030, 18019, 0, 0, 0, 0
4703, 18019, 18030, 2235, 2234, 0, 0, 0, 0
4704, 2193, 2194, 18031, 18020, 0, 0, 0, 0
4705, 18020, 18031, 18032, 18021, 0, 0, 0, 0
4706, 18021, 18032, 18033, 18022, 0, 0, 0, 0
4707, 18022, 18033, 18034, 18023, 0, 0, 0, 0
4708, 18023, 18034, 18035, 18024, 0, 0, 0, 0
4709, 18024, 18035, 18036, 18025, 0, 0, 0, 0
4710, 18025, 18036, 18037, 18026, 0, 0, 0, 0
4711, 18026, 18037, 18038, 18027, 0, 0, 0, 0
4712, 18027, 18038, 18039, 18028, 0, 0, 0, 0
4713, 18028, 18039, 18040, 18029, 0, 0, 0, 0
4714, 18029, 18040, 18041, 18030, 0, 0, 0, 0
4715, 18030, 18041, 2236, 2235, 0, 0, 0, 0
4716, 2194, 2195, 18042, 18031, 0, 0, 0, 0
4717, 18031, 18042, 18043, 18032, 0, 0, 0, 0
4718, 18032, 18043, 18044, 18033, 0, 0, 0, 0
4719, 18033, 18044, 18045, 18034, 0, 0, 0, 0
4720, 18034, 18045, 18046, 18035, 0, 0, 0, 0
4721, 18035, 18046, 18047, 18036, 0, 0, 0, 0
4722, 18036, 18047, 18048, 18037, 0, 0, 0, 0
4723, 18037, 18048, 18049, 18038, 0, 0, 0, 0
4724, 18038, 18049, 18050, 18039, 0, 0, 0, 0
4725, 18039, 18050, 18051, 18040, 0, 0, 0, 0
4726, 18040, 18051, 18052, 18041, 0, 0, 0, 0
4727, 18041, 18052, 2237, 2236, 0, 0, 0, 0
4728, 2195, 2196, 18053, 18042, 0, 0, 0, 0
4729, 18042, 18053, 18054, 18043, 0, 0, 0, 0
4730, 18043, 18054, 18055, 18044, 0, 0, 0, 0
4731, 18044, 18055, 18056, 18045, 0, 0, 0, 0
4732, 18045, 18056, 18057, 18046, 0, 0, 0, 0
4733, 18046, 18057, 18058, 18047, 0, 0, 0, 0
4734, 18047, 18058, 18059, 18048, 0, 0, 0, 0
4735, 18048, 18059, 18060, 18049, 0, 0, 0, 0
4736, 18049, 18060, 18061, 18050, 0, 0, 0, 0
4737, 18050, 18061, 18062, 18051, 0, 0, 0, 0
4738, 18051, 18062, 18063, 18052, 0, 0, 0, 0
4739, 18052, 18063, 2238, 2237, 0, 0, 0, 0
4740, 2196, 2197, 18064, 18053, 0, 0, 0, 0
4741, 18053, 18064, 18065, 18054, 0, 0, 0, 0
4742, 18054, 18065, 18066, 18055, 0, 0, 0, 0
4743, 18055, 18066, 18067, 18056, 0, 0, 0, 0
4744, 18056, 18067, 18068, 18057, 0, 0, 0, 0
4745, 18057, 18068, 18069, 18058, 0, 0, 0, 0
4746, 18058, 18069, 18070, 18059, 0, 0, 0, 0
4747, 18059, 18070, 18071, 18060, 0, 0, 0, 0
4748, 18060, 18071, 18072, 18061, 0, 0, 0, 0
4749, 18061, 18072, 18073, 18062, 0, 0, 0, 0
4750, 18062, 18073, 18074, 18063, 0, 0, 0, 0
4751, 18063, 18074, 2239, 2238, 0, 0, 0, 0
4752, 2197, 2198, 18075, 18064, 0, 0, 0, 0
4753, 18064, 18075, 18076, 18065, 0, 0, 0, 0
4754, 18065, 18076, 18077, 18066, 0, 0, 0, 0
4755, 18066, 18077, 18078, 18067, 0, 0, 0, 0
4756, 18067, 18078, 18079, 18068, 0, 0, 0, 0
4757, 18068, 18079, 18080, 18069, 0, 0, 0, 0
4758, 18069, 18080, 18081, 18070, 0, 0, 0, 0
4759, 18070, 18081, 18082, 18071, 0, 0, 0, 0
4760, 18071, 18082, 18083, 18072, 0, 0, 0, 0
4761, 18072, 18083, 18084, 18073, 0, 0, 0, 0
4762, 18073, 18084, 18085, 18074, 0, 0, 0, 0
4763, 18074, 18085, 2240, 2239, 0, 0, 0, 0
4764, 2198, 2199, 18086, 18075, 0, 0, 0, 0
4765, 18075, 18086, 18087, 18076, 0, 0, 0, 0
4766, 18076, 18087, 18088, 18077, 0, 0, 0, 0
4767, 18077, 18088, 18089, 18078, 0, 0, 0, 0
4768, 18078, 18089, 18090, 18079, 0, 0, 0, 0
4769, 18079, 18090, 18091, 18080, 0, 0, 0, 0
4770, 18080, 18091, 18092, 18081, 0, 0, 0, 0
4771, 18081, 18092, 18093, 18082, 0, 0, 0, 0
4772, 18082, 18093, 18094, 18083, 0, 0, 0, 0
4773, 18083, 18094, 18095, 18084, 0, 0, 0, 0
4774, 18084, 18095, 18096, 18085, 0, 0, 0, 0
4775, 18085, 18096, 2241, 2240, 0, 0, 0, 0
4776, 2199, 2200, 18097, 18086, 0, 0, 0, 0
4777, 18086, 18097, 18098, 18087, 0, 0, 0, 0
4778, 18087, 18098, 18099, 18088, 0, 0, 0, 0
4779, 18088, 18099, 18100, 18089, 0, 0, 0, 0
4780, 18089, 18100, 18101, 18090, 0, 0, 0, 0
4781, 18090, 18101, 18102, 18091, 0, 0, 0, 0
4782, 18091, 18102, 18103, 18092, 0, 0, 0, 0
4783, 18092, 18103, 18104, 18093, 0, 0, 0, 0
4784, 18093, 18104, 18105, 18094, 0, 0, 0, 0
4785, 18094, 18105, 18106, 18095, 0, 0, 0, 0
4786, 18095, 18106, 18107, 18096, 0, 0, 0, 0
4787, 18096, 18107, 2242, 2241, 0, 0, 0, 0
4788, 2200, 2201, 18108, 18097, 0, 0, 0, 0
4789, 18097, 18108, 18109, 18098, 0, 0, 0, 0
4790, 18098, 18109, 18110, 18099, 0, 0, 0, 0
4791, 18099, 18110, 18111, 18100, 0, 0, 0, 0
4792, 18100, 18111, 18112, 18101, 0, 0, 0, 0
4793, 18101, 18112, 18113, 18102, 0, 0, 0, 0
4794, 18102, 18113, 18114, 18103, 0, 0, 0, 0
4795, 18103, 18114, 18115, 18104, 0, 0, 0, 0
4796, 18104, 18115, 18116, 18105, 0, 0, 0, 0
4797, 18105, 18116, 18117, 18106, 0, 0, 0, 0
4798, 18106, 18117, 18118, 18107, 0, 0, 0, 0
4799, 18107, 18118, 2243, 2242, 0, 0, 0, 0
4800, 2201, 2202, 18119, 18108, 0, 0, 0, 0
4801, 18108, 18119, 18120, 18109, 0, 0, 0, 0
4802, 18109, 18120, 18121, 18110, 0, 0, 0, 0
4803, 18110, 18121, 18122, 18111, 0, 0, 0, 0
4804, 18111, 18122, 18123, 18112, 0, 0, 0, 0
4805, 18112, 18123, 18124, 18113, 0, 0, 0, 0
4806, 18113, 18124, 18125, 18114, 0, 0, 0, 0
4807, 18114, 18125, 18126, 18115, 0, 0, 0, 0
4808, 18115, 18126, 18127, 18116, 0, 0, 0, 0
4809, 18116, 18127, 18128, 18117, 0, 0, 0, 0
4810, 18117, 18128, 18129, 18118, 0, 0, 0, 0
4811, 18118, 18129, 2244, 2243, 0, 0, 0, 0
4812, 2202, 2203, 18130, 18119, 0, 0, 0, 0
4813, 18119, 18130, 18131, 18120, 0, 0, 0, 0
4814, 18120, 18131, 18132, 18121, 0, 0, 0, 0
4815, 18121, 18132, 18133, 18122, 0, 0, 0, 0
4816, 18122, 18133, 18134, 18123, 0, 0, 0, 0
4817, 18123, 18134, 18135, 18124, 0, 0, 0, 0
4818, 18124, 18135, 18136, 18125, 0, 0, 0, 0
4819, 18125, 18136, 18137, 18126, 0, 0, 0, 0
4820, 18126, 18137, 18138, 18127, 0, 0, 0, 0
4821, 18127, 18138, 18139, 18128, 0, 0, 0, 0
4822, 18128, 18139, 18140, 18129, 0, 0, 0, 0
4823, 18129, 18140, 2245, 2244, 0, 0, 0, 0
4824, 2203, 2204, 18141, 18130, 0, 0, 0, 0
4825, 18130, 18141, 18142, 18131, 0, 0, 0, 0
4826, 18131, 18142, 18143, 18132, 0, 0, 0, 0
4827, 18132, 18143, 18144, 18133, 0, 0, 0, 0
4828, 18133, 18144, 18145, 18134, 0, 0, 0, 0
4829, 18134, 18145, 18146, 18135, 0, 0, 0, 0
4830, 18135, 18146, 18147, 18136, 0, 0, 0, 0
4831, 18136, 18147, 18148, 18137, 0, 0, 0, 0
4832, 18137, 18148, 18149, 18138, 0, 0, 0, 0
4833, 18138, 18149, 18150, 18139, 0, 0, 0, 0
4834, 18139, 18150, 18151, 18140, 0, 0, 0, 0
4835, 18140, 18151, 2246, 2245, 0, 0, 0, 0
4836, 2204, 2205, 18152, 18141, 0, 0, 0, 0
4837, 18141, 18152, 18153, 18142, 0, 0, 0, 0
4838, 18142, 18153, 18154, 18143, 0, 0, 0, 0
4839, 18143, 18154, 18155, 18144, 0, 0, 0, 0
4840, 18144, 18155, 18156, 18145, 0, 0, 0, 0
4841, 18145, 18156, 18157, 18146, 0, 0, 0, 0
4842, 18146, 18157, 18158, 18147, 0, 0, 0, 0
4843, 18147, 18158, 18159, 18148, 0, 0, 0, 0
4844, 18148, 18159, 18160, 18149, 0, 0, 0, 0
4845, 18149, 18160, 18161, 18150, 0, 0, 0, 0
4846, 18150, 18161, 18162, 18151, 0, 0, 0, 0
4847, 18151, 18162, 2247, 2246, 0, 0, 0, 0
4848, 2205, 2206, 18163, 18152, 0, 0, 0, 0
4849, 18152, 18163, 18164, 18153, 0, 0, 0, 0
4850, 18153, 18164, 18165, 18154, 0, 0, 0, 0
4851, 18154, 18165, 18166, 18155, 0, 0, 0, 0
4852, 18155, 18166, 18167, 18156, 0, 0, 0, 0
4853, 18156, 18167, 18168, 18157, 0, 0, 0, 0
4854, 18157, 18168, 18169, 18158, 0, 0, 0, 0
4855, 18158, 18169, 18170, 18159, 0, 0, 0, 0
4856, 18159, 18170, 18171, 18160, 0, 0, 0, 0
4857, 18160, 18171, 18172, 18161, 0, 0, 0, 0
4858, 18161, 18172, 18173, 18162, 0, 0, 0, 0
4859, 18162, 18173, 2248, 2247, 0, 0, 0, 0
4860, 2206, 2207, 18174, 18163, 0, 0, 0, 0
4861, 18163, 18174, 18175, 18164, 0, 0, 0, 0
4862, 18164, 18175, 18176, 18165, 0, 0, 0, 0
4863, 18165, 18176, 18177, 18166, 0, 0, 0, 0
4864, 18166, 18177, 18178, 18167, 0, 0, 0, 0
4865, 18167, 18178, 18179, 18168, 0, 0, 0, 0
4866, 18168, 18179, 18180, 18169, 0, 0, 0, 0
4867, 18169, 18180, 18181, 18170, 0, 0, 0, 0
4868, 18170, 18181, 18182, 18171, 0, 0, 0, 0
4869, 18171, 18182, 18183, 18172, 0, 0, 0, 0
4870, 18172, 18183, 18184, 18173, 0, 0, 0, 0
4871, 18173, 18184, 2249, 2248, 0, 0, 0, 0
4872, 2207, 2208, 18185, 18174, 0, 0, 0, 0
4873, 18174, 18185, 18186, 18175, 0, 0, 0, 0
4874, 18175, 18186, 18187, 18176, 0, 0, 0, 0
4875, 18176, 18187, 18188, 18177, 0, 0, 0, 0
4876, 18177, 18188, 18189, 18178, 0, 0, 0, 0
4877, 18178, 18189, 18190, 18179, 0, 0, 0, 0
4878, 18179, 18190, 18191, 18180, 0, 0, 0, 0
4879, 18180, 18191, 18192, 18181, 0, 0, 0, 0
4880, 18181, 18192, 18193, 18182, 0, 0, 0, 0
4881, 18182, 18193, 18194, 18183, 0, 0, 0, 0
4882, 18183, 18194, 18195, 18184, 0, 0, 0, 0
4883, 18184, 18195, 2250, 2249, 0, 0, 0, 0
4884, 2208, 2209, 18196, 18185, 0, 0, 0, 0
4885, 18185, 18196, 18197, 18186, 0, 0, 0, 0
4886, 18186, 18197, 18198, 18187, 0, 0, 0, 0
4887, 18187, 18198, 18199, 18188, 0, 0, 0, 0
4888, 18188, 18199, 18200, 18189, 0, 0, 0, 0
4889, 18189, 18200, 18201, 18190, 0, 0, 0, 0
4890, 18190, 18201, 18202, 18191, 0, 0, 0, 0
4891, 18191, 18202, 18203, 18192, 0, 0, 0, 0
4892, 18192, 18203, 18204, 18193, 0, 0, 0, 0
4893, 18193, 18204, 18205, 18194, 0, 0, 0, 0
4894, 18194, 18205, 18206, 18195, 0, 0, 0, 0
4895, 18195, 18206, 2251, 2250, 0, 0, 0, 0
4896, 2209, 2210, 18207, 18196, 0, 0, 0, 0
4897, 18196, 18207, 18208, 18197, 0, 0, 0, 0
4898, 18197, 18208, 18209, 18198, 0, 0, 0, 0
4899, 18198, 18209, 18210, 18199, 0, 0, 0, 0
4900, 18199, 18210, 18211, 18200, 0, 0, 0, 0
4901, 18200, 18211, 18212, 18201, 0, 0, 0, 0
4902, 18201, 18212, 18213, 18202, 0, 0, 0, 0
4903, 18202, 18213, 18214, 18203, 0, 0, 0, 0
4904, 18203, 18214, 18215, 18204, 0, 0, 0, 0
4905, 18204, 18215, 18216, 18205, 0, 0, 0, 0
4906, 18205, 18216, 18217, 18206, 0, 0, 0, 0
4907, 18206, 18217, 2252, 2251, 0, 0, 0, 0
4908, 2210, 2211, 18218, 18207, 0, 0, 0, 0
4909, 18207, 18218, 18219, 18208, 0, 0, 0, 0
4910, 18208, 18219, 18220, 18209, 0, 0, 0, 0
4911, 18209, 18220, 18221, 18210, 0, 0, 0, 0
4912, 18210, 18221, 18222, 18211, 0, 0, 0, 0
4913, 18211, 18222, 18223, 18212, 0, 0, 0, 0
4914, 18212, 18223, 18224, 18213, 0, 0, 0, 0
4915, 18213, 18224, 18225, 18214, 0, 0, 0, 0
4916, 18214, 18225, 18226, 18215, 0, 0, 0, 0
4917, 18215, 18226, 18227, 18216, 0, 0, 0, 0
4918, 18216, 18227, 18228, 18217, 0, 0, 0, 0
4919, 18217, 18228, 2253, 2252, 0, 0, 0, 0
4920, 2211, 2212, 18229, 18218, 0, 0, 0, 0
4921, 18218, 18229, 18230, 18219, 0, 0, 0, 0
4922, 18219, 18230, 18231, 18220, 0, 0, 0, 0
4923, 18220, 18231, 18232, 18221, 0, 0, 0, 0
4924, 18221, 18232, 18233, 18222, 0, 0, 0, 0
4925, 18222, 18233, 18234, 18223, 0, 0, 0, 0
4926, 18223, 18234, 18235, 18224, 0, 0, 0, 0
4927, 18224, 18235, 18236, 18225, 0, 0, 0, 0
4928, 18225, 18236, 18237, 18226, 0, 0, 0, 0
4929, 18226, 18237, 18238, 18227, 0, 0, 0, 0
4930, 18227, 18238, 18239, 18228, 0, 0, 0, 0
4931, 18228, 18239, 2254, 2253, 0, 0, 0, 0
4932, 2212, 85, 2217, 18229, 0, 0, 0, 0
4933, 18229, 2217, 2218, 18230, 0, 0, 0, 0
4934, 18230, 2218, 2219, 18231, 0, 0, 0, 0
4935, 18231, 2219, 2220, 18232, 0, 0, 0, 0
4936, 18232, 2220, 2221, 18233, 0, 0, 0, 0
4937, 18233, 2221, 2222, 18234, 0, 0, 0, 0
4938, 18234, 2222, 2223, 18235, 0, 0, 0, 0
4939, 18235, 2223, 2224, 18236, 0, 0, 0, 0
4940, 18236, 2224, 2225, 18237, 0, 0, 0, 0
4941, 18237, 2225, 2226, 18238, 0, 0, 0, 0
4942, 18238, 2226, 2227, 18239, 0, 0, 0, 0
4943, 18239, 2227, 87, 2254, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface123
4944, 1, 53, 2266, 2228, 0, 0, 0, 0
4945, 2228, 2266, 2267, 2229, 0, 0, 0, 0
4946, 2229, 2267, 2268, 2230, 0, 0, 0, 0
4947, 2230, 2268, 2269, 2231, 0, 0, 0, 0
4948, 2231, 2269, 89, 88, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface124
41785, 2, 2181, 2270, 54, 2185, 18240, 2274, 0
41786, 2181, 2182, 2271, 2270, 2186, 18241, 2275, 18240
41787, 2182, 2183, 2272, 2271, 2187, 18242, 2276, 18241
41788, 2183, 2184, 2273, 2272, 2188, 18243, 2277, 18242
41789, 2184, 86, 90, 2273, 2189, 0, 2278, 18243
*ELEMENT, type=CPS8, ELSET=Surface125
41790, 54, 2270, 18244, 1228, 2274, 18288, 18289, 0
41791, 2270, 2271, 18245, 18244, 2275, 18290, 18291, 18288
41792, 2271, 2272, 18246, 18245, 2276, 18292, 18293, 18290
41793, 2272, 2273, 18247, 18246, 2277, 18294, 18295, 18292
41794, 2273, 90, 2279, 18247, 2278, 0, 18296, 18294
41795, 1228, 18244, 18248, 1229, 18289, 18297, 18298, 0
41796, 18244, 18245, 18249, 18248, 18291, 18299, 18300, 18297
41797, 18245, 18246, 18250, 18249, 18293, 18301, 18302, 18299
41798, 18246, 18247, 18251, 18250, 18295, 18303, 18304, 18301
41799, 18247, 2279, 2280, 18251, 18296, 0, 18305, 18303
41800, 1229, 18248, 18252, 1230, 18298, 18306, 18307, 0
41801, 18248, 18249, 18253, 18252, 18300, 18308, 18309, 18306
41802, 18249, 18250, 18254, 18253, 18302, 18310, 18311, 18308
41803, 18250, 18251, 18255, 18254, 18304, 18312, 18313, 18310
41804, 18251, 2280, 2281, 18255, 18305, 0, 18314, 18312
41805, 1230, 18252, 18256, 1231, 18307, 18315, 18316, 0
41806, 18252, 18253, 18257, 18256, 18309, 18317, 18318, 18315
41807, 18253, 18254, 18258, 18257, 18311, 18319, 18320, 18317
41808, 18254, 18255, 18259, 18258, 18313, 18321, 18322, 18319
41809, 18255, 2281, 2282, 18259, 18314, 0, 18323, 18321
41810, 1231, 18256, 18260, 1232, 18316, 18324, 18325, 0
41811, 18256, 18257, 18261, 18260, 18318, 18326, 18327, 18324
41812, 18257, 18258, 18262, 18261, 18320, 18328, 18329, 18326
41813, 18258, 18259, 18263, 18262, 18322, 18330, 18331, 18328
41814, 18259, 2282, 2283, 18263, 18323, 0, 18332, 18330
41815, 1232, 18260, 18264, 1233, 18325, 18333, 18334, 0
41816, 18260, 18261, 18265, 18264, 18327, 18335, 18336, 18333
41817, 18261, 18262, 18266, 18265, 18329, 18337, 18338, 18335
41818, 18262, 18263, 18267, 18266, 18331, 18339, 18340, 18337
41819, 18263, 2283, 2284, 18267, 18332, 0, 18341, 18339
41820, 1233, 18264, 18268, 1234, 18334, 18342, 18343, 0
41821, 18264, 18265, 18269, 18268, 18336, 18344, 18345, 18342
41822, 18265, 18266, 18270, 18269, 18338, 18346, 18347, 18344
41823, 18266, 18267, 18271, 18270, 18340, 18348, 18349, 18346
41824, 18267, 2284, 2285, 18271, 18341, 0, 18350, 18348
41825, 1234, 18268, 18272, 1235, 18343, 18351, 18352, 0
41826, 18268, 18269, 18273, 18272, 18345, 18353, 18354, 18351
41827, 18269, 18270, 18274, 18273, 18347, 18355, 18356, 18353
41828, 18270, 18271, 18275, 18274, 18349, 18357, 18358, 18355
41829, 18271, 2285, 2286, 18275, 18350, 0, 18359, 18357
41830, 1235, 18272, 18276, 1236, 18352, 18360, 18361, 0
41831, 18272, 18273, 18277, 18276, 18354, 18362, 18363, 18360
41832, 18273, 18274, 18278, 18277, 18356, 18364, 18365, 18362
41833, 18274, 18275, 18279, 18278, 18358, 18366, 18367, 18364
41834, 18275, 2286, 2287, 18279, 18359, 0, 18368, 18366
41835, 1236, 18276, 18280, 1237, 18361, 18369, 18370, 0
41836, 18276, 18277, 18281, 18280, 18363, 18371, 18372, 18369
41837, 18277, 18278, 18282, 18281, 18365, 18373, 18374, 18371
41838, 18278, 18279, 18283, 18282, 18367, 18375, 18376, 18373
41839, 18279, 2287, 2288, 18283, 18368, 0, 18377, 18375
41840, 1237, 18280, 18284, 1238, 18370, 18378, 18379, 0
41841, 18280, 18281, 18285, 18284, 18372, 18380, 18381, 18378
41842, 18281, 18282, 18286, 18285, 18374, 18382, 18383, 18380
41843, 18282, 18283, 18287, 18286, 18376, 18384, 18385, 18382
41844, 18283, 2288, 2289, 18287, 18377, 0, 18386, 18384
41845, 1238, 18284, 2266, 53, 18379, 18387, 0, 0
41846, 18284, 18285, 2267, 2266, 18381, 18388, 0, 18387
41847, 18285, 18286, 2268, 2267, 18383, 18389, 0, 18388
41848, 18286, 18287, 2269, 2268, 18385, 18390, 0, 18389
41849, 18287, 2289, 89, 2269, 18386, 0, 0, 18390
*ELEMENT, type=CPS8, ELSET=Surface126
4949, 86, 2255, 2279, 90, 0, 0, 0, 0
4950, 2255, 2256, 2280, 2279, 0, 0, 0, 0
4951, 2256, 2257, 2281, 2280, 0, 0, 0, 0
4952, 2257, 2258, 2282, 2281, 0, 0, 0, 0
4953, 2258, 2259, 2283, 2282, 0, 0, 0, 0
4954, 2259, 2260, 2284, 2283, 0, 0, 0, 0
4955, 2260, 2261, 2285, 2284, 0, 0, 0, 0
4956, 2261, 2262, 2286, 2285, 0, 0, 0, 0
4957, 2262, 2263, 2287, 2286, 0, 0, 0, 0
4958, 2263, 2264, 2288, 2287, 0, 0, 0, 0
4959, 2264, 2265, 2289, 2288, 0, 0, 0, 0
4960, 2265, 88, 89, 2289, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface127
4961, 45, 2290, 18391, 1124, 0, 0, 0, 0
4962, 2290, 2291, 18392, 18391, 0, 0, 0, 0
4963, 2291, 2292, 18393, 18392, 0, 0, 0, 0
4964, 2292, 2293, 18394, 18393, 0, 0, 0, 0
4965, 2293, 91, 2298, 18394, 0, 0, 0, 0
4966, 1124, 18391, 18395, 1125, 0, 0, 0, 0
4967, 18391, 18392, 18396, 18395, 0, 0, 0, 0
4968, 18392, 18393, 18397, 18396, 0, 0, 0, 0
4969, 18393, 18394, 18398, 18397, 0, 0, 0, 0
4970, 18394, 2298, 2299, 18398, 0, 0, 0, 0
4971, 1125, 18395, 18399, 1126, 0, 0, 0, 0
4972, 18395, 18396, 18400, 18399, 0, 0, 0, 0
4973, 18396, 18397, 18401, 18400, 0, 0, 0, 0
4974, 18397, 18398, 18402, 18401, 0, 0, 0, 0
4975, 18398, 2299, 2300, 18402, 0, 0, 0, 0
4976, 1126, 18399, 18403, 1127, 0, 0, 0, 0
4977, 18399, 18400, 18404, 18403, 0, 0, 0, 0
4978, 18400, 18401, 18405, 18404, 0, 0, 0, 0
4979, 18401, 18402, 18406, 18405, 0, 0, 0, 0
4980, 18402, 2300, 2301, 18406, 0, 0, 0, 0
4981, 1127, 18403, 18407, 1128, 0, 0, 0, 0
4982, 18403, 18404, 18408, 18407, 0, 0, 0, 0
4983, 18404, 18405, 18409, 18408, 0, 0, 0, 0
4984, 18405, 18406, 18410, 18409, 0, 0, 0, 0
4985, 18406, 2301, 2302, 18410, 0, 0, 0, 0
4986, 1128, 18407, 18411, 1129, 0, 0, 0, 0
4987, 18407, 18408, 18412, 18411, 0, 0, 0, 0
4988, 18408, 18409, 18413, 18412, 0, 0, 0, 0
4989, 18409, 18410, 18414, 18413, 0, 0, 0, 0
4990, 18410, 2302, 2303, 18414, 0, 0, 0, 0
4991, 1129, 18411, 18415, 1130, 0, 0, 0, 0
4992, 18411, 18412, 18416, 18415, 0, 0, 0, 0
4993, 18412, 18413, 18417, 18416, 0, 0, 0, 0
4994, 18413, 18414, 18418, 18417, 0, 0, 0, 0
4995, 18414, 2303, 2304, 18418, 0, 0, 0, 0
4996, 1130, 18415, 18419, 1131, 0, 0, 0, 0
4997, 18415, 18416, 18420, 18419, 0, 0, 0, 0
4998, 18416, 18417, 18421, 18420, 0, 0, 0, 0
4999, 18417, 18418, 18422, 18421, 0, 0, 0, 0
5000, 18418, 2304, 2305, 18422, 0, 0, 0, 0
5001, 1131, 18419, 18423, 1132, 0, 0, 0, 0
5002, 18419, 18420, 18424, 18423, 0, 0, 0, 0
5003, 18420, 18421, 18425, 18424, 0, 0, 0, 0
5004, 18421, 18422, 18426, 18425, 0, 0, 0, 0
5005, 18422, 2305, 2306, 18426, 0, 0, 0, 0
5006, 1132, 18423, 18427, 1133, 0, 0, 0, 0
5007, 18423, 18424, 18428, 18427, 0, 0, 0, 0
5008, 18424, 18425, 18429, 18428, 0, 0, 0, 0
5009, 18425, 18426, 18430, 18429, 0, 0, 0, 0
5010, 18426, 2306, 2307, 18430, 0, 0, 0, 0
5011, 1133, 18427, 18431, 1134, 0, 0, 0, 0
5012, 18427, 18428, 18432, 18431, 0, 0, 0, 0
5013, 18428, 18429, 18433, 18432, 0, 0, 0, 0
5014, 18429, 18430, 18434, 18433, 0, 0, 0, 0
5015, 18430, 2307, 2308, 18434, 0, 0, 0, 0
5016, 1134, 18431, 18435, 1135, 0, 0, 0, 0
5017, 18431, 18432, 18436, 18435, 0, 0, 0, 0
5018, 18432, 18433, 18437, 18436, 0, 0, 0, 0
5019, 18433, 18434, 18438, 18437, 0, 0, 0, 0
5020, 18434, 2308, 2309, 18438, 0, 0, 0, 0
5021, 1135, 18435, 18439, 1136, 0, 0, 0, 0
5022, 18435, 18436, 18440, 18439, 0, 0, 0, 0
5023, 18436, 18437, 18441, 18440, 0, 0, 0, 0
5024, 18437, 18438, 18442, 18441, 0, 0, 0, 0
5025, 18438, 2309, 2310, 18442, 0, 0, 0, 0
5026, 1136, 18439, 18443, 1137, 0, 0, 0, 0
5027, 18439, 18440, 18444, 18443, 0, 0, 0, 0
5028, 18440, 18441, 18445, 18444, 0, 0, 0, 0
5029, 18441, 18442, 18446, 18445, 0, 0, 0, 0
5030, 18442, 2310, 2311, 18446, 0, 0, 0, 0
5031, 1137, 18443, 18447, 1138, 0, 0, 0, 0
5032, 18443, 18444, 18448, 18447, 0, 0, 0, 0
5033, 18444, 18445, 18449, 18448, 0, 0, 0, 0
5034, 18445, 18446, 18450, 18449, 0, 0, 0, 0
5035, 18446, 2311, 2312, 18450, 0, 0, 0, 0
5036, 1138, 18447, 18451, 1139, 0, 0, 0, 0
5037, 18447, 18448, 18452, 18451, 0, 0, 0, 0
5038, 18448, 18449, 18453, 18452, 0, 0, 0, 0
5039, 18449, 18450, 18454, 18453, 0, 0, 0, 0
5040, 18450, 2312, 2313, 18454, 0, 0, 0, 0
5041, 1139, 18451, 18455, 1140, 0, 0, 0, 0
5042, 18451, 18452, 18456, 18455, 0, 0, 0, 0
5043, 18452, 18453, 18457, 18456, 0, 0, 0, 0
5044, 18453, 18454, 18458, 18457, 0, 0, 0, 0
5045, 18454, 2313, 2314, 18458, 0, 0, 0, 0
5046, 1140, 18455, 18459, 1141, 0, 0, 0, 0
5047, 18455, 18456, 18460, 18459, 0, 0, 0, 0
5048, 18456, 18457, 18461, 18460, 0, 0, 0, 0
5049, 18457, 18458, 18462, 18461, 0, 0, 0, 0
5050, 18458, 2314, 2315, 18462, 0, 0, 0, 0
5051, 1141, 18459, 18463, 1142, 0, 0, 0, 0
5052, 18459, 18460, 18464, 18463, 0, 0, 0, 0
5053, 18460, 18461, 18465, 18464, 0, 0, 0, 0
5054, 18461, 18462, 18466, 18465, 0, 0, 0, 0
5055, 18462, 2315, 2316, 18466, 0, 0, 0, 0
5056, 1142, 18463, 18467, 1143, 0, 0, 0, 0
5057, 18463, 18464, 18468, 18467, 0, 0, 0, 0
5058, 18464, 18465, 18469, 18468, 0, 0, 0, 0
5059, 18465, 18466, 18470, 18469, 0, 0, 0, 0
5060, 18466, 2316, 2317, 18470, 0, 0, 0, 0
5061, 1143, 18467, 18471, 1144, 0, 0, 0, 0
5062, 18467, 18468, 18472, 18471, 0, 0, 0, 0
5063, 18468, 18469, 18473, 18472, 0, 0, 0, 0
5064, 18469, 18470, 18474, 18473, 0, 0, 0, 0
5065, 18470, 2317, 2318, 18474, 0, 0, 0, 0
5066, 1144, 18471, 18475, 1145, 0, 0, 0, 0
5067, 18471, 18472, 18476, 18475, 0, 0, 0, 0
5068, 18472, 18473, 18477, 18476, 0, 0, 0, 0
5069, 18473, 18474, 18478, 18477, 0, 0, 0, 0
5070, 18474, 2318, 2319, 18478, 0, 0, 0, 0
5071, 1145, 18475, 18479, 1146, 0, 0, 0, 0
5072, 18475, 18476, 18480, 18479, 0, 0, 0, 0
5073, 18476, 18477, 18481, 18480, 0, 0, 0, 0
5074, 18477, 18478, 18482, 18481, 0, 0, 0, 0
5075, 18478, 2319, 2320, 18482, 0, 0, 0, 0
5076, 1146, 18479, 2294, 46, 0, 0, 0, 0
5077, 18479, 18480, 2295, 2294, 0, 0, 0, 0
5078, 18480, 18481, 2296, 2295, 0, 0, 0, 0
5079, 18481, 18482, 2297, 2296, 0, 0, 0, 0
5080, 18482, 2320, 92, 2297, 0, 0, 0, 0
*ELEMENT, type=CPS8, ELSET=Surface128
41850, 47, 1157, 18483, 2321, 0, 18575, 18576, 2325
41851, 2321, 18483, 18484, 2322, 18576, 18577, 18578, 2326
41852, 2322, 18484, 18485, 2323, 18578, 18579, 18580, 2327
41853, 2323, 18485, 18486, 2324, 18580, 18581, 18582, 2328
41854, 2324, 18486, 2339, 93, 18582, 18583, 0, 2329
41855, 1157, 1158, 18487, 18483, 0, 18584, 18585, 18575
41856, 18483, 18487, 18488, 18484, 18585, 18586, 18587, 18577
41857, 18484, 18488, 18489, 18485, 18587, 18588, 18589, 18579
41858, 18485, 18489, 18490, 18486, 18589, 18590, 18591, 18581
41859, 18486, 18490, 2340, 2339, 18591, 18592, 0, 18583
41860, 1158, 1159, 18491, 18487, 0, 18593, 18594, 18584
41861, 18487, 18491, 18492, 18488, 18594, 18595, 18596, 18586
41862, 18488, 18492, 18493, 18489, 18596, 18597, 18598, 18588
41863, 18489, 18493, 18494, 18490, 18598, 18599, 18600, 18590
41864, 18490, 18494, 2341, 2340, 18600, 18601, 0, 18592
41865, 1159, 1160, 18495, 18491, 0, 18602, 18603, 18593
41866, 18491, 18495, 18496, 18492, 18603, 18604, 18605, 18595
41867, 18492, 18496, 18497, 18493, 18605, 18606, 18607, 18597
41868, 18493, 18497, 18498, 18494, 18607, 18608, 18609, 18599
41869, 18494, 18498, 2342, 2341, 18609, 18610, 0, 18601
41870, 1160, 1161, 18499, 18495, 0, 18611, 18612, 18602
41871, 18495, 18499, 18500, 18496, 18612, 18613, 18614, 18604
41872, 18496, 18500, 18501, 18497, 18614, 18615, 18616, 18606
41873, 18497, 18501, 18502, 18498, 18616, 18617, 18618, 18608
41874, 18498, 18502, 2343, 2342, 18618, 18619, 0, 18610
41875, 1161, 1162, 18503, 18499, 0, 18620, 18621, 18611
41876, 18499, 18503, 18504, 18500, 18621, 18622, 18623, 18613
41877, 18500, 18504, 18505, 18501, 18623, 18624, 18625, 18615
41878, 18501, 18505, 18506, 18502, 18625, 18626, 18627, 18617
41879, 18502, 18506, 2344, 2343, 18627, 18628, 0, 18619
41880, 1162, 1163, 18507, 18503, 0, 18629, 18630, 18620
41881, 18503, 18507, 18508, 18504, 18630, 18631, 18632, 18622
41882, 18504, 18508, 18509, 18505, 18632, 18633, 18634, 18624
41883, 18505, 18509, 18510, 18506, 18634, 18635, 18636, 18626
41884, 18506, 18510, 2345, 2344, 18636, 18637, 0, 18628
41885, 1163, 1164, 18511, 18507, 0, 18638, 18639, 18629
41886, 18507, 18511, 18512, 18508, 18639, 18640, 18641, 18631
41887, 18508, 18512, 18513, 18509, 18641, 18642, 18643, 18633
41888, 18509, 18513, 18514, 18510, 18643, 18644, 18645, 18635
41889, 18510, 18514, 2346, 2345, 18645, 18646, 0, 18637
41890, 1164, 1165, 18515, 18511, 0, 18647, 18648, 18638
41891, 18511, 18515, 18516, 18512, 18648, 18649, 18650, 18640
41892, 18512, 18516, 18517, 18513, 18650, 18651, 18652, 18642
41893, 18513, 18517, 18518, 18514, 18652, 18653, 18654, 18644
41894, 18514, 18518, 2347, 2346, 18654, 18655, 0, 18646
41895, 1165, 1166, 18519, 18515, 0, 18656, 18657, 18647
41896, 18515, 18519, 18520, 18516, 18657, 18658, 18659, 18649
41897, 18516, 18520, 18521, 18517, 18659, 18660, 18661, 18651
41898, 18517, 18521, 18522, 18518, 18661, 18662, 18663, 18653
41899, 18518, 18522, 2348, 2347, 18663, 18664, 0, 18655
41900, 1166, 1167, 18523, 18519, 0, 18665, 18666, 18656
41901, 18519, 18523, 18524, 18520, 18666, 18667, 18668, 18658
41902, 18520, 18524, 18525, 18521, 18668, 18669, 18670, 18660
