14431, 5320, 5321, 5332, 5331, 26209, 26211, 26233, 26231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14432, 26209, 26211, 26233, 26231, 26210, 26212, 26234, 26232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14433, 26210, 26212, 26234, 26232, 5709, 5710, 5721, 5720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14434, 5321, 5322, 5333, 5332, 26211, 26213, 26235, 26233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14435, 26211, 26213, 26235, 26233, 26212, 26214, 26236, 26234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14436, 26212, 26214, 26236, 26234, 5710, 5711, 5722, 5721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14437, 5322, 5323, 5334, 5333, 26213, 26215, 26237, 26235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14438, 26213, 26215, 26237, 26235, 26214, 26216, 26238, 26236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14439, 26214, 26216, 26238, 26236, 5711, 5712, 5723, 5722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14440, 5323, 5324, 5335, 5334, 26215, 26217, 26239, 26237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14441, 26215, 26217, 26239, 26237, 26216, 26218, 26240, 26238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14442, 26216, 26218, 26240, 26238, 5712, 5713, 5724, 5723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14443, 5324, 5325, 5336, 5335, 26217, 26219, 26241, 26239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14444, 26217, 26219, 26241, 26239, 26218, 26220, 26242, 26240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14445, 26218, 26220, 26242, 26240, 5713, 5714, 5725, 5724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14446, 5325, 5326, 5337, 5336, 26219, 26221, 26243, 26241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14447, 26219, 26221, 26243, 26241, 26220, 26222, 26244, 26242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14448, 26220, 26222, 26244, 26242, 5714, 5715, 5726, 5725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14449, 5326, 5327, 5338, 5337, 26221, 26223, 26245, 26243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14450, 26221, 26223, 26245, 26243, 26222, 26224, 26246, 26244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14451, 26222, 26224, 26246, 26244, 5715, 5716, 5727, 5726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14452, 5327, 5328, 5339, 5338, 26223, 26225, 26247, 26245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14453, 26223, 26225, 26247, 26245, 26224, 26226, 26248, 26246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14454, 26224, 26226, 26248, 26246, 5716, 5717, 5728, 5727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14455, 5328, 522, 523, 5339, 26225, 5477, 5479, 26247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14456, 26225, 5477, 5479, 26247, 26226, 5478, 5480, 26248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14457, 26226, 5478, 5480, 26248, 5717, 598, 599, 5728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14458, 489, 5329, 5340, 490, 5411, 26227, 26249, 5413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14459, 5411, 26227, 26249, 5413, 5412, 26228, 26250, 5414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14460, 5412, 26228, 26250, 5414, 561, 5718, 5729, 562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14461, 5329, 5330, 5341, 5340, 26227, 26229, 26251, 26249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14462, 26227, 26229, 26251, 26249, 26228, 26230, 26252, 26250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14463, 26228, 26230, 26252, 26250, 5718, 5719, 5730, 5729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14464, 5330, 5331, 5342, 5341, 26229, 26231, 26253, 26251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14465, 26229, 26231, 26253, 26251, 26230, 26232, 26254, 26252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14466, 26230, 26232, 26254, 26252, 5719, 5720, 5731, 5730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14467, 5331, 5332, 5343, 5342, 26231, 26233, 26255, 26253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14468, 26231, 26233, 26255, 26253, 26232, 26234, 26256, 26254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14469, 26232, 26234, 26256, 26254, 5720, 5721, 5732, 5731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14470, 5332, 5333, 5344, 5343, 26233, 26235, 26257, 26255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14471, 26233, 26235, 26257, 26255, 26234, 26236, 26258, 26256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14472, 26234, 26236, 26258, 26256, 5721, 5722, 5733, 5732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14473, 5333, 5334, 5345, 5344, 26235, 26237, 26259, 26257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14474, 26235, 26237, 26259, 26257, 26236, 26238, 26260, 26258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14475, 26236, 26238, 26260, 26258, 5722, 5723, 5734, 5733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14476, 5334, 5335, 5346, 5345, 26237, 26239, 26261, 26259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14477, 26237, 26239, 26261, 26259, 26238, 26240, 26262, 26260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14478, 26238, 26240, 26262, 26260, 5723, 5724, 5735, 5734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14479, 5335, 5336, 5347, 5346, 26239, 26241, 26263, 26261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14480, 26239, 26241, 26263, 26261, 26240, 26242, 26264, 26262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14481, 26240, 26242, 26264, 26262, 5724, 5725, 5736, 5735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14482, 5336, 5337, 5348, 5347, 26241, 26243, 26265, 26263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14483, 26241, 26243, 26265, 26263, 26242, 26244, 26266, 26264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14484, 26242, 26244, 26266, 26264, 5725, 5726, 5737, 5736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14485, 5337, 5338, 5349, 5348, 26243, 26245, 26267, 26265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14486, 26243, 26245, 26267, 26265, 26244, 26246, 26268, 26266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14487, 26244, 26246, 26268, 26266, 5726, 5727, 5738, 5737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14488, 5338, 5339, 5350, 5349, 26245, 26247, 26269, 26267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14489, 26245, 26247, 26269, 26267, 26246, 26248, 26270, 26268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14490, 26246, 26248, 26270, 26268, 5727, 5728, 5739, 5738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14491, 5339, 523, 524, 5350, 26247, 5479, 5481, 26269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14492, 26247, 5479, 5481, 26269, 26248, 5480, 5482, 26270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14493, 26248, 5480, 5482, 26270, 5728, 599, 600, 5739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14494, 490, 5340, 5351, 491, 5413, 26249, 26271, 5415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14495, 5413, 26249, 26271, 5415, 5414, 26250, 26272, 5416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14496, 5414, 26250, 26272, 5416, 562, 5729, 5740, 563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14497, 5340, 5341, 5352, 5351, 26249, 26251, 26273, 26271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14498, 26249, 26251, 26273, 26271, 26250, 26252, 26274, 26272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14499, 26250, 26252, 26274, 26272, 5729, 5730, 5741, 5740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14500, 5341, 5342, 5353, 5352, 26251, 26253, 26275, 26273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14501, 26251, 26253, 26275, 26273, 26252, 26254, 26276, 26274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14502, 26252, 26254, 26276, 26274, 5730, 5731, 5742, 5741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14503, 5342, 5343, 5354, 5353, 26253, 26255, 26277, 26275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14504, 26253, 26255, 26277, 26275, 26254, 26256, 26278, 26276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14505, 26254, 26256, 26278, 26276, 5731, 5732, 5743, 5742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14506, 5343, 5344, 5355, 5354, 26255, 26257, 26279, 26277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14507, 26255, 26257, 26279, 26277, 26256, 26258, 26280, 26278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14508, 26256, 26258, 26280, 26278, 5732, 5733, 5744, 5743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14509, 5344, 5345, 5356, 5355, 26257, 26259, 26281, 26279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14510, 26257, 26259, 26281, 26279, 26258, 26260, 26282, 26280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14511, 26258, 26260, 26282, 26280, 5733, 5734, 5745, 5744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14512, 5345, 5346, 5357, 5356, 26259, 26261, 26283, 26281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14513, 26259, 26261, 26283, 26281, 26260, 26262, 26284, 26282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14514, 26260, 26262, 26284, 26282, 5734, 5735, 5746, 5745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14515, 5346, 5347, 5358, 5357, 26261, 26263, 26285, 26283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14516, 26261, 26263, 26285, 26283, 26262, 26264, 26286, 26284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14517, 26262, 26264, 26286, 26284, 5735, 5736, 5747, 5746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14518, 5347, 5348, 5359, 5358, 26263, 26265, 26287, 26285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14519, 26263, 26265, 26287, 26285, 26264, 26266, 26288, 26286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14520, 26264, 26266, 26288, 26286, 5736, 5737, 5748, 5747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14521, 5348, 5349, 5360, 5359, 26265, 26267, 26289, 26287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14522, 26265, 26267, 26289, 26287, 26266, 26268, 26290, 26288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14523, 26266, 26268, 26290, 26288, 5737, 5738, 5749, 5748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14524, 5349, 5350, 5361, 5360, 26267, 26269, 26291, 26289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14525, 26267, 26269, 26291, 26289, 26268, 26270, 26292, 26290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14526, 26268, 26270, 26292, 26290, 5738, 5739, 5750, 5749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14527, 5350, 524, 525, 5361, 26269, 5481, 5483, 26291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14528, 26269, 5481, 5483, 26291, 26270, 5482, 5484, 26292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14529, 26270, 5482, 5484, 26292, 5739, 600, 601, 5750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14530, 491, 5351, 5362, 492, 5415, 26271, 26293, 5417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14531, 5415, 26271, 26293, 5417, 5416, 26272, 26294, 5418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14532, 5416, 26272, 26294, 5418, 563, 5740, 5751, 564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14533, 5351, 5352, 5363, 5362, 26271, 26273, 26295, 26293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14534, 26271, 26273, 26295, 26293, 26272, 26274, 26296, 26294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14535, 26272, 26274, 26296, 26294, 5740, 5741, 5752, 5751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14536, 5352, 5353, 5364, 5363, 26273, 26275, 26297, 26295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14537, 26273, 26275, 26297, 26295, 26274, 26276, 26298, 26296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14538, 26274, 26276, 26298, 26296, 5741, 5742, 5753, 5752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14539, 5353, 5354, 5365, 5364, 26275, 26277, 26299, 26297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14540, 26275, 26277, 26299, 26297, 26276, 26278, 26300, 26298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14541, 26276, 26278, 26300, 26298, 5742, 5743, 5754, 5753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14542, 5354, 5355, 5366, 5365, 26277, 26279, 26301, 26299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14543, 26277, 26279, 26301, 26299, 26278, 26280, 26302, 26300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14544, 26278, 26280, 26302, 26300, 5743, 5744, 5755, 5754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14545, 5355, 5356, 5367, 5366, 26279, 26281, 26303, 26301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14546, 26279, 26281, 26303, 26301, 26280, 26282, 26304, 26302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14547, 26280, 26282, 26304, 26302, 5744, 5745, 5756, 5755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14548, 5356, 5357, 5368, 5367, 26281, 26283, 26305, 26303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14549, 26281, 26283, 26305, 26303, 26282, 26284, 26306, 26304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14550, 26282, 26284, 26306, 26304, 5745, 5746, 5757, 5756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14551, 5357, 5358, 5369, 5368, 26283, 26285, 26307, 26305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14552, 26283, 26285, 26307, 26305, 26284, 26286, 26308, 26306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14553, 26284, 26286, 26308, 26306, 5746, 5747, 5758, 5757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14554, 5358, 5359, 5370, 5369, 26285, 26287, 26309, 26307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14555, 26285, 26287, 26309, 26307, 26286, 26288, 26310, 26308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14556, 26286, 26288, 26310, 26308, 5747, 5748, 5759, 5758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14557, 5359, 5360, 5371, 5370, 26287, 26289, 26311, 26309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14558, 26287, 26289, 26311, 26309, 26288, 26290, 26312, 26310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14559, 26288, 26290, 26312, 26310, 5748, 5749, 5760, 5759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14560, 5360, 5361, 5372, 5371, 26289, 26291, 26313, 26311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14561, 26289, 26291, 26313, 26311, 26290, 26292, 26314, 26312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14562, 26290, 26292, 26314, 26312, 5749, 5750, 5761, 5760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14563, 5361, 525, 526, 5372, 26291, 5483, 5485, 26313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14564, 26291, 5483, 5485, 26313, 26292, 5484, 5486, 26314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14565, 26292, 5484, 5486, 26314, 5750, 601, 602, 5761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14566, 492, 5362, 493, 17, 5417, 26293, 5419, 538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14567, 5417, 26293, 5419, 538, 5418, 26294, 5420, 539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14568, 5418, 26294, 5420, 539, 564, 5751, 567, 21, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14569, 5362, 5363, 494, 493, 26293, 26295, 5421, 5419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14570, 26293, 26295, 5421, 5419, 26294, 26296, 5422, 5420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14571, 26294, 26296, 5422, 5420, 5751, 5752, 568, 567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14572, 5363, 5364, 495, 494, 26295, 26297, 5423, 5421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14573, 26295, 26297, 5423, 5421, 26296, 26298, 5424, 5422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14574, 26296, 26298, 5424, 5422, 5752, 5753, 569, 568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14575, 5364, 5365, 496, 495, 26297, 26299, 5425, 5423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14576, 26297, 26299, 5425, 5423, 26298, 26300, 5426, 5424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14577, 26298, 26300, 5426, 5424, 5753, 5754, 570, 569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14578, 5365, 5366, 497, 496, 26299, 26301, 5427, 5425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14579, 26299, 26301, 5427, 5425, 26300, 26302, 5428, 5426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14580, 26300, 26302, 5428, 5426, 5754, 5755, 571, 570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14581, 5366, 5367, 498, 497, 26301, 26303, 5429, 5427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14582, 26301, 26303, 5429, 5427, 26302, 26304, 5430, 5428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14583, 26302, 26304, 5430, 5428, 5755, 5756, 572, 571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14584, 5367, 5368, 499, 498, 26303, 26305, 5431, 5429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14585, 26303, 26305, 5431, 5429, 26304, 26306, 5432, 5430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14586, 26304, 26306, 5432, 5430, 5756, 5757, 573, 572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14587, 5368, 5369, 500, 499, 26305, 26307, 5433, 5431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14588, 26305, 26307, 5433, 5431, 26306, 26308, 5434, 5432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14589, 26306, 26308, 5434, 5432, 5757, 5758, 574, 573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14590, 5369, 5370, 501, 500, 26307, 26309, 5435, 5433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14591, 26307, 26309, 5435, 5433, 26308, 26310, 5436, 5434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14592, 26308, 26310, 5436, 5434, 5758, 5759, 575, 574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14593, 5370, 5371, 502, 501, 26309, 26311, 5437, 5435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14594, 26309, 26311, 5437, 5435, 26310, 26312, 5438, 5436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14595, 26310, 26312, 5438, 5436, 5759, 5760, 576, 575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14596, 5371, 5372, 503, 502, 26311, 26313, 5439, 5437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14597, 26311, 26313, 5439, 5437, 26312, 26314, 5440, 5438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14598, 26312, 26314, 5440, 5438, 5760, 5761, 577, 576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14599, 5372, 526, 19, 503, 26313, 5485, 565, 5439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14600, 26313, 5485, 565, 5439, 26314, 5486, 566, 5440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14601, 26314, 5486, 566, 5440, 5761, 602, 23, 577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume6
14602, 17, 538, 5419, 493, 624, 5770, 26315, 5778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14603, 624, 5770, 26315, 5778, 625, 5771, 26316, 5779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14604, 625, 5771, 26316, 5779, 626, 5772, 26317, 5780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14605, 626, 5772, 26317, 5780, 627, 5773, 26318, 5781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14606, 627, 5773, 26318, 5781, 27, 632, 5866, 634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14607, 538, 539, 5420, 5419, 5770, 5774, 26319, 26315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14608, 5770, 5774, 26319, 26315, 5771, 5775, 26320, 26316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14609, 5771, 5775, 26320, 26316, 5772, 5776, 26321, 26317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14610, 5772, 5776, 26321, 26317, 5773, 5777, 26322, 26318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14611, 5773, 5777, 26322, 26318, 632, 633, 5867, 5866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14612, 539, 21, 567, 5420, 5774, 628, 5822, 26319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14613, 5774, 628, 5822, 26319, 5775, 629, 5823, 26320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14614, 5775, 629, 5823, 26320, 5776, 630, 5824, 26321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14615, 5776, 630, 5824, 26321, 5777, 631, 5825, 26322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14616, 5777, 631, 5825, 26322, 633, 28, 645, 5867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14617, 493, 5419, 5421, 494, 5778, 26315, 26323, 5782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14618, 5778, 26315, 26323, 5782, 5779, 26316, 26324, 5783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14619, 5779, 26316, 26324, 5783, 5780, 26317, 26325, 5784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14620, 5780, 26317, 26325, 5784, 5781, 26318, 26326, 5785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14621, 5781, 26318, 26326, 5785, 634, 5866, 5868, 635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14622, 5419, 5420, 5422, 5421, 26315, 26319, 26327, 26323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14623, 26315, 26319, 26327, 26323, 26316, 26320, 26328, 26324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14624, 26316, 26320, 26328, 26324, 26317, 26321, 26329, 26325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14625, 26317, 26321, 26329, 26325, 26318, 26322, 26330, 26326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14626, 26318, 26322, 26330, 26326, 5866, 5867, 5869, 5868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14627, 5420, 567, 568, 5422, 26319, 5822, 5826, 26327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14628, 26319, 5822, 5826, 26327, 26320, 5823, 5827, 26328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14629, 26320, 5823, 5827, 26328, 26321, 5824, 5828, 26329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14630, 26321, 5824, 5828, 26329, 26322, 5825, 5829, 26330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14631, 26322, 5825, 5829, 26330, 5867, 645, 646, 5869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14632, 494, 5421, 5423, 495, 5782, 26323, 26331, 5786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14633, 5782, 26323, 26331, 5786, 5783, 26324, 26332, 5787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14634, 5783, 26324, 26332, 5787, 5784, 26325, 26333, 5788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14635, 5784, 26325, 26333, 5788, 5785, 26326, 26334, 5789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14636, 5785, 26326, 26334, 5789, 635, 5868, 5870, 636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14637, 5421, 5422, 5424, 5423, 26323, 26327, 26335, 26331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14638, 26323, 26327, 26335, 26331, 26324, 26328, 26336, 26332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14639, 26324, 26328, 26336, 26332, 26325, 26329, 26337, 26333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14640, 26325, 26329, 26337, 26333, 26326, 26330, 26338, 26334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14641, 26326, 26330, 26338, 26334, 5868, 5869, 5871, 5870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14642, 5422, 568, 569, 5424, 26327, 5826, 5830, 26335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14643, 26327, 5826, 5830, 26335, 26328, 5827, 5831, 26336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14644, 26328, 5827, 5831, 26336, 26329, 5828, 5832, 26337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14645, 26329, 5828, 5832, 26337, 26330, 5829, 5833, 26338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14646, 26330, 5829, 5833, 26338, 5869, 646, 647, 5871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14647, 495, 5423, 5425, 496, 5786, 26331, 26339, 5790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14648, 5786, 26331, 26339, 5790, 5787, 26332, 26340, 5791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14649, 5787, 26332, 26340, 5791, 5788, 26333, 26341, 5792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14650, 5788, 26333, 26341, 5792, 5789, 26334, 26342, 5793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14651, 5789, 26334, 26342, 5793, 636, 5870, 5872, 637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14652, 5423, 5424, 5426, 5425, 26331, 26335, 26343, 26339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14653, 26331, 26335, 26343, 26339, 26332, 26336, 26344, 26340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14654, 26332, 26336, 26344, 26340, 26333, 26337, 26345, 26341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14655, 26333, 26337, 26345, 26341, 26334, 26338, 26346, 26342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14656, 26334, 26338, 26346, 26342, 5870, 5871, 5873, 5872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14657, 5424, 569, 570, 5426, 26335, 5830, 5834, 26343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14658, 26335, 5830, 5834, 26343, 26336, 5831, 5835, 26344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14659, 26336, 5831, 5835, 26344, 26337, 5832, 5836, 26345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14660, 26337, 5832, 5836, 26345, 26338, 5833, 5837, 26346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14661, 26338, 5833, 5837, 26346, 5871, 647, 648, 5873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14662, 496, 5425, 5427, 497, 5790, 26339, 26347, 5794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14663, 5790, 26339, 26347, 5794, 5791, 26340, 26348, 5795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14664, 5791, 26340, 26348, 5795, 5792, 26341, 26349, 5796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14665, 5792, 26341, 26349, 5796, 5793, 26342, 26350, 5797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14666, 5793, 26342, 26350, 5797, 637, 5872, 5874, 638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14667, 5425, 5426, 5428, 5427, 26339, 26343, 26351, 26347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14668, 26339, 26343, 26351, 26347, 26340, 26344, 26352, 26348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14669, 26340, 26344, 26352, 26348, 26341, 26345, 26353, 26349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14670, 26341, 26345, 26353, 26349, 26342, 26346, 26354, 26350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14671, 26342, 26346, 26354, 26350, 5872, 5873, 5875, 5874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14672, 5426, 570, 571, 5428, 26343, 5834, 5838, 26351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14673, 26343, 5834, 5838, 26351, 26344, 5835, 5839, 26352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14674, 26344, 5835, 5839, 26352, 26345, 5836, 5840, 26353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14675, 26345, 5836, 5840, 26353, 26346, 5837, 5841, 26354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14676, 26346, 5837, 5841, 26354, 5873, 648, 649, 5875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14677, 497, 5427, 5429, 498, 5794, 26347, 26355, 5798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14678, 5794, 26347, 26355, 5798, 5795, 26348, 26356, 5799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14679, 5795, 26348, 26356, 5799, 5796, 26349, 26357, 5800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14680, 5796, 26349, 26357, 5800, 5797, 26350, 26358, 5801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14681, 5797, 26350, 26358, 5801, 638, 5874, 5876, 639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14682, 5427, 5428, 5430, 5429, 26347, 26351, 26359, 26355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14683, 26347, 26351, 26359, 26355, 26348, 26352, 26360, 26356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14684, 26348, 26352, 26360, 26356, 26349, 26353, 26361, 26357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14685, 26349, 26353, 26361, 26357, 26350, 26354, 26362, 26358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14686, 26350, 26354, 26362, 26358, 5874, 5875, 5877, 5876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14687, 5428, 571, 572, 5430, 26351, 5838, 5842, 26359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14688, 26351, 5838, 5842, 26359, 26352, 5839, 5843, 26360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14689, 26352, 5839, 5843, 26360, 26353, 5840, 5844, 26361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14690, 26353, 5840, 5844, 26361, 26354, 5841, 5845, 26362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14691, 26354, 5841, 5845, 26362, 5875, 649, 650, 5877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14692, 498, 5429, 5431, 499, 5798, 26355, 26363, 5802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14693, 5798, 26355, 26363, 5802, 5799, 26356, 26364, 5803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14694, 5799, 26356, 26364, 5803, 5800, 26357, 26365, 5804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14695, 5800, 26357, 26365, 5804, 5801, 26358, 26366, 5805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14696, 5801, 26358, 26366, 5805, 639, 5876, 5878, 640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14697, 5429, 5430, 5432, 5431, 26355, 26359, 26367, 26363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14698, 26355, 26359, 26367, 26363, 26356, 26360, 26368, 26364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14699, 26356, 26360, 26368, 26364, 26357, 26361, 26369, 26365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14700, 26357, 26361, 26369, 26365, 26358, 26362, 26370, 26366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14701, 26358, 26362, 26370, 26366, 5876, 5877, 5879, 5878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14702, 5430, 572, 573, 5432, 26359, 5842, 5846, 26367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14703, 26359, 5842, 5846, 26367, 26360, 5843, 5847, 26368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14704, 26360, 5843, 5847, 26368, 26361, 5844, 5848, 26369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14705, 26361, 5844, 5848, 26369, 26362, 5845, 5849, 26370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14706, 26362, 5845, 5849, 26370, 5877, 650, 651, 5879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14707, 499, 5431, 5433, 500, 5802, 26363, 26371, 5806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14708, 5802, 26363, 26371, 5806, 5803, 26364, 26372, 5807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14709, 5803, 26364, 26372, 5807, 5804, 26365, 26373, 5808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14710, 5804, 26365, 26373, 5808, 5805, 26366, 26374, 5809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14711, 5805, 26366, 26374, 5809, 640, 5878, 5880, 641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14712, 5431, 5432, 5434, 5433, 26363, 26367, 26375, 26371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14713, 26363, 26367, 26375, 26371, 26364, 26368, 26376, 26372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14714, 26364, 26368, 26376, 26372, 26365, 26369, 26377, 26373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14715, 26365, 26369, 26377, 26373, 26366, 26370, 26378, 26374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14716, 26366, 26370, 26378, 26374, 5878, 5879, 5881, 5880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14717, 5432, 573, 574, 5434, 26367, 5846, 5850, 26375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14718, 26367, 5846, 5850, 26375, 26368, 5847, 5851, 26376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14719, 26368, 5847, 5851, 26376, 26369, 5848, 5852, 26377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14720, 26369, 5848, 5852, 26377, 26370, 5849, 5853, 26378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14721, 26370, 5849, 5853, 26378, 5879, 651, 652, 5881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14722, 500, 5433, 5435, 501, 5806, 26371, 26379, 5810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14723, 5806, 26371, 26379, 5810, 5807, 26372, 26380, 5811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14724, 5807, 26372, 26380, 5811, 5808, 26373, 26381, 5812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14725, 5808, 26373, 26381, 5812, 5809, 26374, 26382, 5813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14726, 5809, 26374, 26382, 5813, 641, 5880, 5882, 642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14727, 5433, 5434, 5436, 5435, 26371, 26375, 26383, 26379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14728, 26371, 26375, 26383, 26379, 26372, 26376, 26384, 26380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14729, 26372, 26376, 26384, 26380, 26373, 26377, 26385, 26381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14730, 26373, 26377, 26385, 26381, 26374, 26378, 26386, 26382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14731, 26374, 26378, 26386, 26382, 5880, 5881, 5883, 5882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14732, 5434, 574, 575, 5436, 26375, 5850, 5854, 26383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14733, 26375, 5850, 5854, 26383, 26376, 5851, 5855, 26384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14734, 26376, 5851, 5855, 26384, 26377, 5852, 5856, 26385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14735, 26377, 5852, 5856, 26385, 26378, 5853, 5857, 26386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14736, 26378, 5853, 5857, 26386, 5881, 652, 653, 5883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14737, 501, 5435, 5437, 502, 5810, 26379, 26387, 5814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14738, 5810, 26379, 26387, 5814, 5811, 26380, 26388, 5815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14739, 5811, 26380, 26388, 5815, 5812, 26381, 26389, 5816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14740, 5812, 26381, 26389, 5816, 5813, 26382, 26390, 5817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14741, 5813, 26382, 26390, 5817, 642, 5882, 5884, 643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14742, 5435, 5436, 5438, 5437, 26379, 26383, 26391, 26387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14743, 26379, 26383, 26391, 26387, 26380, 26384, 26392, 26388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14744, 26380, 26384, 26392, 26388, 26381, 26385, 26393, 26389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14745, 26381, 26385, 26393, 26389, 26382, 26386, 26394, 26390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14746, 26382, 26386, 26394, 26390, 5882, 5883, 5885, 5884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14747, 5436, 575, 576, 5438, 26383, 5854, 5858, 26391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14748, 26383, 5854, 5858, 26391, 26384, 5855, 5859, 26392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14749, 26384, 5855, 5859, 26392, 26385, 5856, 5860, 26393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14750, 26385, 5856, 5860, 26393, 26386, 5857, 5861, 26394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14751, 26386, 5857, 5861, 26394, 5883, 653, 654, 5885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14752, 502, 5437, 5439, 503, 5814, 26387, 26395, 5818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14753, 5814, 26387, 26395, 5818, 5815, 26388, 26396, 5819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14754, 5815, 26388, 26396, 5819, 5816, 26389, 26397, 5820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14755, 5816, 26389, 26397, 5820, 5817, 26390, 26398, 5821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14756, 5817, 26390, 26398, 5821, 643, 5884, 5886, 644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14757, 5437, 5438, 5440, 5439, 26387, 26391, 26399, 26395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14758, 26387, 26391, 26399, 26395, 26388, 26392, 26400, 26396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14759, 26388, 26392, 26400, 26396, 26389, 26393, 26401, 26397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14760, 26389, 26393, 26401, 26397, 26390, 26394, 26402, 26398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14761, 26390, 26394, 26402, 26398, 5884, 5885, 5887, 5886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14762, 5438, 576, 577, 5440, 26391, 5858, 5862, 26399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14763, 26391, 5858, 5862, 26399, 26392, 5859, 5863, 26400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14764, 26392, 5859, 5863, 26400, 26393, 5860, 5864, 26401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14765, 26393, 5860, 5864, 26401, 26394, 5861, 5865, 26402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14766, 26394, 5861, 5865, 26402, 5885, 654, 655, 5887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14767, 503, 5439, 565, 19, 5818, 26395, 5762, 614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14768, 5818, 26395, 5762, 614, 5819, 26396, 5763, 615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14769, 5819, 26396, 5763, 615, 5820, 26397, 5764, 616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14770, 5820, 26397, 5764, 616, 5821, 26398, 5765, 617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14771, 5821, 26398, 5765, 617, 644, 5886, 622, 25, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14772, 5439, 5440, 566, 565, 26395, 26399, 5766, 5762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14773, 26395, 26399, 5766, 5762, 26396, 26400, 5767, 5763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14774, 26396, 26400, 5767, 5763, 26397, 26401, 5768, 5764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14775, 26397, 26401, 5768, 5764, 26398, 26402, 5769, 5765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14776, 26398, 26402, 5769, 5765, 5886, 5887, 623, 622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14777, 5440, 577, 23, 566, 26399, 5862, 618, 5766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14778, 26399, 5862, 618, 5766, 26400, 5863, 619, 5767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14779, 26400, 5863, 619, 5767, 26401, 5864, 620, 5768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14780, 26401, 5864, 620, 5768, 26402, 5865, 621, 5769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14781, 26402, 5865, 621, 5769, 5887, 655, 26, 623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume7
14782, 27, 632, 5866, 634, 704, 5934, 26403, 5980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14783, 704, 5934, 26403, 5980, 705, 5935, 26404, 5981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14784, 705, 5935, 26404, 5981, 706, 5936, 26405, 5982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14785, 706, 5936, 26405, 5982, 707, 5937, 26406, 5983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14786, 707, 5937, 26406, 5983, 708, 5938, 26407, 5984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14787, 708, 5938, 26407, 5984, 709, 5939, 26408, 5985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14788, 709, 5939, 26408, 5985, 710, 5940, 26409, 5986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14789, 710, 5940, 26409, 5986, 711, 5941, 26410, 5987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14790, 711, 5941, 26410, 5987, 712, 5942, 26411, 5988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14791, 712, 5942, 26411, 5988, 713, 5943, 26412, 5989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14792, 713, 5943, 26412, 5989, 714, 5944, 26413, 5990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14793, 714, 5944, 26413, 5990, 715, 5945, 26414, 5991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14794, 715, 5945, 26414, 5991, 716, 5946, 26415, 5992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14795, 716, 5946, 26415, 5992, 717, 5947, 26416, 5993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14796, 717, 5947, 26416, 5993, 718, 5948, 26417, 5994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14797, 718, 5948, 26417, 5994, 719, 5949, 26418, 5995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14798, 719, 5949, 26418, 5995, 720, 5950, 26419, 5996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14799, 720, 5950, 26419, 5996, 721, 5951, 26420, 5997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14800, 721, 5951, 26420, 5997, 722, 5952, 26421, 5998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14801, 722, 5952, 26421, 5998, 723, 5953, 26422, 5999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14802, 723, 5953, 26422, 5999, 724, 5954, 26423, 6000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14803, 724, 5954, 26423, 6000, 725, 5955, 26424, 6001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14804, 725, 5955, 26424, 6001, 726, 5956, 26425, 6002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14805, 726, 5956, 26425, 6002, 31, 750, 6486, 752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14806, 632, 633, 5867, 5866, 5934, 5957, 26426, 26403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14807, 5934, 5957, 26426, 26403, 5935, 5958, 26427, 26404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14808, 5935, 5958, 26427, 26404, 5936, 5959, 26428, 26405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14809, 5936, 5959, 26428, 26405, 5937, 5960, 26429, 26406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14810, 5937, 5960, 26429, 26406, 5938, 5961, 26430, 26407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14811, 5938, 5961, 26430, 26407, 5939, 5962, 26431, 26408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14812, 5939, 5962, 26431, 26408, 5940, 5963, 26432, 26409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14813, 5940, 5963, 26432, 26409, 5941, 5964, 26433, 26410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14814, 5941, 5964, 26433, 26410, 5942, 5965, 26434, 26411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14815, 5942, 5965, 26434, 26411, 5943, 5966, 26435, 26412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14816, 5943, 5966, 26435, 26412, 5944, 5967, 26436, 26413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14817, 5944, 5967, 26436, 26413, 5945, 5968, 26437, 26414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14818, 5945, 5968, 26437, 26414, 5946, 5969, 26438, 26415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14819, 5946, 5969, 26438, 26415, 5947, 5970, 26439, 26416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14820, 5947, 5970, 26439, 26416, 5948, 5971, 26440, 26417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14821, 5948, 5971, 26440, 26417, 5949, 5972, 26441, 26418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14822, 5949, 5972, 26441, 26418, 5950, 5973, 26442, 26419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14823, 5950, 5973, 26442, 26419, 5951, 5974, 26443, 26420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14824, 5951, 5974, 26443, 26420, 5952, 5975, 26444, 26421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14825, 5952, 5975, 26444, 26421, 5953, 5976, 26445, 26422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14826, 5953, 5976, 26445, 26422, 5954, 5977, 26446, 26423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14827, 5954, 5977, 26446, 26423, 5955, 5978, 26447, 26424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14828, 5955, 5978, 26447, 26424, 5956, 5979, 26448, 26425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14829, 5956, 5979, 26448, 26425, 750, 751, 6487, 6486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14830, 633, 28, 645, 5867, 5957, 727, 6233, 26426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14831, 5957, 727, 6233, 26426, 5958, 728, 6234, 26427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14832, 5958, 728, 6234, 26427, 5959, 729, 6235, 26428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14833, 5959, 729, 6235, 26428, 5960, 730, 6236, 26429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14834, 5960, 730, 6236, 26429, 5961, 731, 6237, 26430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14835, 5961, 731, 6237, 26430, 5962, 732, 6238, 26431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14836, 5962, 732, 6238, 26431, 5963, 733, 6239, 26432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14837, 5963, 733, 6239, 26432, 5964, 734, 6240, 26433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14838, 5964, 734, 6240, 26433, 5965, 735, 6241, 26434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14839, 5965, 735, 6241, 26434, 5966, 736, 6242, 26435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14840, 5966, 736, 6242, 26435, 5967, 737, 6243, 26436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14841, 5967, 737, 6243, 26436, 5968, 738, 6244, 26437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14842, 5968, 738, 6244, 26437, 5969, 739, 6245, 26438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14843, 5969, 739, 6245, 26438, 5970, 740, 6246, 26439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14844, 5970, 740, 6246, 26439, 5971, 741, 6247, 26440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14845, 5971, 741, 6247, 26440, 5972, 742, 6248, 26441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14846, 5972, 742, 6248, 26441, 5973, 743, 6249, 26442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14847, 5973, 743, 6249, 26442, 5974, 744, 6250, 26443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14848, 5974, 744, 6250, 26443, 5975, 745, 6251, 26444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14849, 5975, 745, 6251, 26444, 5976, 746, 6252, 26445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14850, 5976, 746, 6252, 26445, 5977, 747, 6253, 26446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14851, 5977, 747, 6253, 26446, 5978, 748, 6254, 26447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14852, 5978, 748, 6254, 26447, 5979, 749, 6255, 26448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14853, 5979, 749, 6255, 26448, 751, 32, 763, 6487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14854, 634, 5866, 5868, 635, 5980, 26403, 26449, 6003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14855, 5980, 26403, 26449, 6003, 5981, 26404, 26450, 6004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14856, 5981, 26404, 26450, 6004, 5982, 26405, 26451, 6005, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14857, 5982, 26405, 26451, 6005, 5983, 26406, 26452, 6006, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14858, 5983, 26406, 26452, 6006, 5984, 26407, 26453, 6007, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14859, 5984, 26407, 26453, 6007, 5985, 26408, 26454, 6008, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14860, 5985, 26408, 26454, 6008, 5986, 26409, 26455, 6009, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14861, 5986, 26409, 26455, 6009, 5987, 26410, 26456, 6010, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14862, 5987, 26410, 26456, 6010, 5988, 26411, 26457, 6011, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14863, 5988, 26411, 26457, 6011, 5989, 26412, 26458, 6012, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14864, 5989, 26412, 26458, 6012, 5990, 26413, 26459, 6013, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14865, 5990, 26413, 26459, 6013, 5991, 26414, 26460, 6014, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14866, 5991, 26414, 26460, 6014, 5992, 26415, 26461, 6015, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14867, 5992, 26415, 26461, 6015, 5993, 26416, 26462, 6016, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14868, 5993, 26416, 26462, 6016, 5994, 26417, 26463, 6017, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14869, 5994, 26417, 26463, 6017, 5995, 26418, 26464, 6018, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14870, 5995, 26418, 26464, 6018, 5996, 26419, 26465, 6019, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14871, 5996, 26419, 26465, 6019, 5997, 26420, 26466, 6020, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14872, 5997, 26420, 26466, 6020, 5998, 26421, 26467, 6021, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14873, 5998, 26421, 26467, 6021, 5999, 26422, 26468, 6022, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14874, 5999, 26422, 26468, 6022, 6000, 26423, 26469, 6023, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14875, 6000, 26423, 26469, 6023, 6001, 26424, 26470, 6024, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14876, 6001, 26424, 26470, 6024, 6002, 26425, 26471, 6025, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14877, 6002, 26425, 26471, 6025, 752, 6486, 6488, 753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14878, 5866, 5867, 5869, 5868, 26403, 26426, 26472, 26449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14879, 26403, 26426, 26472, 26449, 26404, 26427, 26473, 26450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14880, 26404, 26427, 26473, 26450, 26405, 26428, 26474, 26451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14881, 26405, 26428, 26474, 26451, 26406, 26429, 26475, 26452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14882, 26406, 26429, 26475, 26452, 26407, 26430, 26476, 26453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14883, 26407, 26430, 26476, 26453, 26408, 26431, 26477, 26454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14884, 26408, 26431, 26477, 26454, 26409, 26432, 26478, 26455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14885, 26409, 26432, 26478, 26455, 26410, 26433, 26479, 26456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14886, 26410, 26433, 26479, 26456, 26411, 26434, 26480, 26457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14887, 26411, 26434, 26480, 26457, 26412, 26435, 26481, 26458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14888, 26412, 26435, 26481, 26458, 26413, 26436, 26482, 26459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14889, 26413, 26436, 26482, 26459, 26414, 26437, 26483, 26460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14890, 26414, 26437, 26483, 26460, 26415, 26438, 26484, 26461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14891, 26415, 26438, 26484, 26461, 26416, 26439, 26485, 26462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14892, 26416, 26439, 26485, 26462, 26417, 26440, 26486, 26463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14893, 26417, 26440, 26486, 26463, 26418, 26441, 26487, 26464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14894, 26418, 26441, 26487, 26464, 26419, 26442, 26488, 26465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14895, 26419, 26442, 26488, 26465, 26420, 26443, 26489, 26466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14896, 26420, 26443, 26489, 26466, 26421, 26444, 26490, 26467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14897, 26421, 26444, 26490, 26467, 26422, 26445, 26491, 26468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14898, 26422, 26445, 26491, 26468, 26423, 26446, 26492, 26469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14899, 26423, 26446, 26492, 26469, 26424, 26447, 26493, 26470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14900, 26424, 26447, 26493, 26470, 26425, 26448, 26494, 26471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14901, 26425, 26448, 26494, 26471, 6486, 6487, 6489, 6488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14902, 5867, 645, 646, 5869, 26426, 6233, 6256, 26472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14903, 26426, 6233, 6256, 26472, 26427, 6234, 6257, 26473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14904, 26427, 6234, 6257, 26473, 26428, 6235, 6258, 26474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14905, 26428, 6235, 6258, 26474, 26429, 6236, 6259, 26475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14906, 26429, 6236, 6259, 26475, 26430, 6237, 6260, 26476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14907, 26430, 6237, 6260, 26476, 26431, 6238, 6261, 26477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14908, 26431, 6238, 6261, 26477, 26432, 6239, 6262, 26478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14909, 26432, 6239, 6262, 26478, 26433, 6240, 6263, 26479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14910, 26433, 6240, 6263, 26479, 26434, 6241, 6264, 26480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14911, 26434, 6241, 6264, 26480, 26435, 6242, 6265, 26481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14912, 26435, 6242, 6265, 26481, 26436, 6243, 6266, 26482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14913, 26436, 6243, 6266, 26482, 26437, 6244, 6267, 26483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14914, 26437, 6244, 6267, 26483, 26438, 6245, 6268, 26484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14915, 26438, 6245, 6268, 26484, 26439, 6246, 6269, 26485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14916, 26439, 6246, 6269, 26485, 26440, 6247, 6270, 26486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14917, 26440, 6247, 6270, 26486, 26441, 6248, 6271, 26487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14918, 26441, 6248, 6271, 26487, 26442, 6249, 6272, 26488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14919, 26442, 6249, 6272, 26488, 26443, 6250, 6273, 26489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14920, 26443, 6250, 6273, 26489, 26444, 6251, 6274, 26490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14921, 26444, 6251, 6274, 26490, 26445, 6252, 6275, 26491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14922, 26445, 6252, 6275, 26491, 26446, 6253, 6276, 26492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14923, 26446, 6253, 6276, 26492, 26447, 6254, 6277, 26493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14924, 26447, 6254, 6277, 26493, 26448, 6255, 6278, 26494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14925, 26448, 6255, 6278, 26494, 6487, 763, 764, 6489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14926, 635, 5868, 5870, 636, 6003, 26449, 26495, 6026, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14927, 6003, 26449, 26495, 6026, 6004, 26450, 26496, 6027, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14928, 6004, 26450, 26496, 6027, 6005, 26451, 26497, 6028, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14929, 6005, 26451, 26497, 6028, 6006, 26452, 26498, 6029, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14930, 6006, 26452, 26498, 6029, 6007, 26453, 26499, 6030, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14931, 6007, 26453, 26499, 6030, 6008, 26454, 26500, 6031, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14932, 6008, 26454, 26500, 6031, 6009, 26455, 26501, 6032, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14933, 6009, 26455, 26501, 6032, 6010, 26456, 26502, 6033, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14934, 6010, 26456, 26502, 6033, 6011, 26457, 26503, 6034, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14935, 6011, 26457, 26503, 6034, 6012, 26458, 26504, 6035, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14936, 6012, 26458, 26504, 6035, 6013, 26459, 26505, 6036, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14937, 6013, 26459, 26505, 6036, 6014, 26460, 26506, 6037, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14938, 6014, 26460, 26506, 6037, 6015, 26461, 26507, 6038, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14939, 6015, 26461, 26507, 6038, 6016, 26462, 26508, 6039, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14940, 6016, 26462, 26508, 6039, 6017, 26463, 26509, 6040, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14941, 6017, 26463, 26509, 6040, 6018, 26464, 26510, 6041, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14942, 6018, 26464, 26510, 6041, 6019, 26465, 26511, 6042, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14943, 6019, 26465, 26511, 6042, 6020, 26466, 26512, 6043, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14944, 6020, 26466, 26512, 6043, 6021, 26467, 26513, 6044, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14945, 6021, 26467, 26513, 6044, 6022, 26468, 26514, 6045, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14946, 6022, 26468, 26514, 6045, 6023, 26469, 26515, 6046, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14947, 6023, 26469, 26515, 6046, 6024, 26470, 26516, 6047, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14948, 6024, 26470, 26516, 6047, 6025, 26471, 26517, 6048, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14949, 6025, 26471, 26517, 6048, 753, 6488, 6490, 754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14950, 5868, 5869, 5871, 5870, 26449, 26472, 26518, 26495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14951, 26449, 26472, 26518, 26495, 26450, 26473, 26519, 26496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14952, 26450, 26473, 26519, 26496, 26451, 26474, 26520, 26497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14953, 26451, 26474, 26520, 26497, 26452, 26475, 26521, 26498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14954, 26452, 26475, 26521, 26498, 26453, 26476, 26522, 26499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14955, 26453, 26476, 26522, 26499, 26454, 26477, 26523, 26500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14956, 26454, 26477, 26523, 26500, 26455, 26478, 26524, 26501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14957, 26455, 26478, 26524, 26501, 26456, 26479, 26525, 26502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14958, 26456, 26479, 26525, 26502, 26457, 26480, 26526, 26503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14959, 26457, 26480, 26526, 26503, 26458, 26481, 26527, 26504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14960, 26458, 26481, 26527, 26504, 26459, 26482, 26528, 26505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14961, 26459, 26482, 26528, 26505, 26460, 26483, 26529, 26506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14962, 26460, 26483, 26529, 26506, 26461, 26484, 26530, 26507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14963, 26461, 26484, 26530, 26507, 26462, 26485, 26531, 26508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14964, 26462, 26485, 26531, 26508, 26463, 26486, 26532, 26509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14965, 26463, 26486, 26532, 26509, 26464, 26487, 26533, 26510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14966, 26464, 26487, 26533, 26510, 26465, 26488, 26534, 26511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14967, 26465, 26488, 26534, 26511, 26466, 26489, 26535, 26512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14968, 26466, 26489, 26535, 26512, 26467, 26490, 26536, 26513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14969, 26467, 26490, 26536, 26513, 26468, 26491, 26537, 26514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14970, 26468, 26491, 26537, 26514, 26469, 26492, 26538, 26515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14971, 26469, 26492, 26538, 26515, 26470, 26493, 26539, 26516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14972, 26470, 26493, 26539, 26516, 26471, 26494, 26540, 26517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14973, 26471, 26494, 26540, 26517, 6488, 6489, 6491, 6490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14974, 5869, 646, 647, 5871, 26472, 6256, 6279, 26518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14975, 26472, 6256, 6279, 26518, 26473, 6257, 6280, 26519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14976, 26473, 6257, 6280, 26519, 26474, 6258, 6281, 26520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14977, 26474, 6258, 6281, 26520, 26475, 6259, 6282, 26521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14978, 26475, 6259, 6282, 26521, 26476, 6260, 6283, 26522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14979, 26476, 6260, 6283, 26522, 26477, 6261, 6284, 26523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14980, 26477, 6261, 6284, 26523, 26478, 6262, 6285, 26524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14981, 26478, 6262, 6285, 26524, 26479, 6263, 6286, 26525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14982, 26479, 6263, 6286, 26525, 26480, 6264, 6287, 26526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14983, 26480, 6264, 6287, 26526, 26481, 6265, 6288, 26527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14984, 26481, 6265, 6288, 26527, 26482, 6266, 6289, 26528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14985, 26482, 6266, 6289, 26528, 26483, 6267, 6290, 26529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14986, 26483, 6267, 6290, 26529, 26484, 6268, 6291, 26530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14987, 26484, 6268, 6291, 26530, 26485, 6269, 6292, 26531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14988, 26485, 6269, 6292, 26531, 26486, 6270, 6293, 26532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14989, 26486, 6270, 6293, 26532, 26487, 6271, 6294, 26533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14990, 26487, 6271, 6294, 26533, 26488, 6272, 6295, 26534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14991, 26488, 6272, 6295, 26534, 26489, 6273, 6296, 26535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14992, 26489, 6273, 6296, 26535, 26490, 6274, 6297, 26536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14993, 26490, 6274, 6297, 26536, 26491, 6275, 6298, 26537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14994, 26491, 6275, 6298, 26537, 26492, 6276, 6299, 26538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14995, 26492, 6276, 6299, 26538, 26493, 6277, 6300, 26539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14996, 26493, 6277, 6300, 26539, 26494, 6278, 6301, 26540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14997, 26494, 6278, 6301, 26540, 6489, 764, 765, 6491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14998, 636, 5870, 5872, 637, 6026, 26495, 26541, 6049, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
14999, 6026, 26495, 26541, 6049, 6027, 26496, 26542, 6050, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15000, 6027, 26496, 26542, 6050, 6028, 26497, 26543, 6051, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15001, 6028, 26497, 26543, 6051, 6029, 26498, 26544, 6052, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15002, 6029, 26498, 26544, 6052, 6030, 26499, 26545, 6053, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15003, 6030, 26499, 26545, 6053, 6031, 26500, 26546, 6054, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15004, 6031, 26500, 26546, 6054, 6032, 26501, 26547, 6055, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15005, 6032, 26501, 26547, 6055, 6033, 26502, 26548, 6056, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15006, 6033, 26502, 26548, 6056, 6034, 26503, 26549, 6057, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15007, 6034, 26503, 26549, 6057, 6035, 26504, 26550, 6058, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15008, 6035, 26504, 26550, 6058, 6036, 26505, 26551, 6059, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15009, 6036, 26505, 26551, 6059, 6037, 26506, 26552, 6060, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15010, 6037, 26506, 26552, 6060, 6038, 26507, 26553, 6061, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15011, 6038, 26507, 26553, 6061, 6039, 26508, 26554, 6062, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15012, 6039, 26508, 26554, 6062, 6040, 26509, 26555, 6063, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15013, 6040, 26509, 26555, 6063, 6041, 26510, 26556, 6064, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15014, 6041, 26510, 26556, 6064, 6042, 26511, 26557, 6065, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15015, 6042, 26511, 26557, 6065, 6043, 26512, 26558, 6066, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15016, 6043, 26512, 26558, 6066, 6044, 26513, 26559, 6067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15017, 6044, 26513, 26559, 6067, 6045, 26514, 26560, 6068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15018, 6045, 26514, 26560, 6068, 6046, 26515, 26561, 6069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15019, 6046, 26515, 26561, 6069, 6047, 26516, 26562, 6070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15020, 6047, 26516, 26562, 6070, 6048, 26517, 26563, 6071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15021, 6048, 26517, 26563, 6071, 754, 6490, 6492, 755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15022, 5870, 5871, 5873, 5872, 26495, 26518, 26564, 26541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15023, 26495, 26518, 26564, 26541, 26496, 26519, 26565, 26542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15024, 26496, 26519, 26565, 26542, 26497, 26520, 26566, 26543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15025, 26497, 26520, 26566, 26543, 26498, 26521, 26567, 26544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15026, 26498, 26521, 26567, 26544, 26499, 26522, 26568, 26545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15027, 26499, 26522, 26568, 26545, 26500, 26523, 26569, 26546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15028, 26500, 26523, 26569, 26546, 26501, 26524, 26570, 26547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15029, 26501, 26524, 26570, 26547, 26502, 26525, 26571, 26548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15030, 26502, 26525, 26571, 26548, 26503, 26526, 26572, 26549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15031, 26503, 26526, 26572, 26549, 26504, 26527, 26573, 26550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15032, 26504, 26527, 26573, 26550, 26505, 26528, 26574, 26551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15033, 26505, 26528, 26574, 26551, 26506, 26529, 26575, 26552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15034, 26506, 26529, 26575, 26552, 26507, 26530, 26576, 26553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15035, 26507, 26530, 26576, 26553, 26508, 26531, 26577, 26554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15036, 26508, 26531, 26577, 26554, 26509, 26532, 26578, 26555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15037, 26509, 26532, 26578, 26555, 26510, 26533, 26579, 26556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15038, 26510, 26533, 26579, 26556, 26511, 26534, 26580, 26557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15039, 26511, 26534, 26580, 26557, 26512, 26535, 26581, 26558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15040, 26512, 26535, 26581, 26558, 26513, 26536, 26582, 26559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15041, 26513, 26536, 26582, 26559, 26514, 26537, 26583, 26560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15042, 26514, 26537, 26583, 26560, 26515, 26538, 26584, 26561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15043, 26515, 26538, 26584, 26561, 26516, 26539, 26585, 26562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15044, 26516, 26539, 26585, 26562, 26517, 26540, 26586, 26563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15045, 26517, 26540, 26586, 26563, 6490, 6491, 6493, 6492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15046, 5871, 647, 648, 5873, 26518, 6279, 6302, 26564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15047, 26518, 6279, 6302, 26564, 26519, 6280, 6303, 26565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15048, 26519, 6280, 6303, 26565, 26520, 6281, 6304, 26566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15049, 26520, 6281, 6304, 26566, 26521, 6282, 6305, 26567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15050, 26521, 6282, 6305, 26567, 26522, 6283, 6306, 26568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15051, 26522, 6283, 6306, 26568, 26523, 6284, 6307, 26569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15052, 26523, 6284, 6307, 26569, 26524, 6285, 6308, 26570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15053, 26524, 6285, 6308, 26570, 26525, 6286, 6309, 26571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15054, 26525, 6286, 6309, 26571, 26526, 6287, 6310, 26572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15055, 26526, 6287, 6310, 26572, 26527, 6288, 6311, 26573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15056, 26527, 6288, 6311, 26573, 26528, 6289, 6312, 26574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15057, 26528, 6289, 6312, 26574, 26529, 6290, 6313, 26575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15058, 26529, 6290, 6313, 26575, 26530, 6291, 6314, 26576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15059, 26530, 6291, 6314, 26576, 26531, 6292, 6315, 26577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15060, 26531, 6292, 6315, 26577, 26532, 6293, 6316, 26578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15061, 26532, 6293, 6316, 26578, 26533, 6294, 6317, 26579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15062, 26533, 6294, 6317, 26579, 26534, 6295, 6318, 26580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15063, 26534, 6295, 6318, 26580, 26535, 6296, 6319, 26581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15064, 26535, 6296, 6319, 26581, 26536, 6297, 6320, 26582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15065, 26536, 6297, 6320, 26582, 26537, 6298, 6321, 26583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15066, 26537, 6298, 6321, 26583, 26538, 6299, 6322, 26584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15067, 26538, 6299, 6322, 26584, 26539, 6300, 6323, 26585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15068, 26539, 6300, 6323, 26585, 26540, 6301, 6324, 26586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15069, 26540, 6301, 6324, 26586, 6491, 765, 766, 6493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15070, 637, 5872, 5874, 638, 6049, 26541, 26587, 6072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15071, 6049, 26541, 26587, 6072, 6050, 26542, 26588, 6073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15072, 6050, 26542, 26588, 6073, 6051, 26543, 26589, 6074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15073, 6051, 26543, 26589, 6074, 6052, 26544, 26590, 6075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15074, 6052, 26544, 26590, 6075, 6053, 26545, 26591, 6076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15075, 6053, 26545, 26591, 6076, 6054, 26546, 26592, 6077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15076, 6054, 26546, 26592, 6077, 6055, 26547, 26593, 6078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15077, 6055, 26547, 26593, 6078, 6056, 26548, 26594, 6079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15078, 6056, 26548, 26594, 6079, 6057, 26549, 26595, 6080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15079, 6057, 26549, 26595, 6080, 6058, 26550, 26596, 6081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15080, 6058, 26550, 26596, 6081, 6059, 26551, 26597, 6082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15081, 6059, 26551, 26597, 6082, 6060, 26552, 26598, 6083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15082, 6060, 26552, 26598, 6083, 6061, 26553, 26599, 6084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15083, 6061, 26553, 26599, 6084, 6062, 26554, 26600, 6085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15084, 6062, 26554, 26600, 6085, 6063, 26555, 26601, 6086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15085, 6063, 26555, 26601, 6086, 6064, 26556, 26602, 6087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15086, 6064, 26556, 26602, 6087, 6065, 26557, 26603, 6088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15087, 6065, 26557, 26603, 6088, 6066, 26558, 26604, 6089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15088, 6066, 26558, 26604, 6089, 6067, 26559, 26605, 6090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15089, 6067, 26559, 26605, 6090, 6068, 26560, 26606, 6091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15090, 6068, 26560, 26606, 6091, 6069, 26561, 26607, 6092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15091, 6069, 26561, 26607, 6092, 6070, 26562, 26608, 6093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15092, 6070, 26562, 26608, 6093, 6071, 26563, 26609, 6094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15093, 6071, 26563, 26609, 6094, 755, 6492, 6494, 756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15094, 5872, 5873, 5875, 5874, 26541, 26564, 26610, 26587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15095, 26541, 26564, 26610, 26587, 26542, 26565, 26611, 26588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15096, 26542, 26565, 26611, 26588, 26543, 26566, 26612, 26589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15097, 26543, 26566, 26612, 26589, 26544, 26567, 26613, 26590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15098, 26544, 26567, 26613, 26590, 26545, 26568, 26614, 26591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15099, 26545, 26568, 26614, 26591, 26546, 26569, 26615, 26592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15100, 26546, 26569, 26615, 26592, 26547, 26570, 26616, 26593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15101, 26547, 26570, 26616, 26593, 26548, 26571, 26617, 26594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15102, 26548, 26571, 26617, 26594, 26549, 26572, 26618, 26595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15103, 26549, 26572, 26618, 26595, 26550, 26573, 26619, 26596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15104, 26550, 26573, 26619, 26596, 26551, 26574, 26620, 26597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15105, 26551, 26574, 26620, 26597, 26552, 26575, 26621, 26598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15106, 26552, 26575, 26621, 26598, 26553, 26576, 26622, 26599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15107, 26553, 26576, 26622, 26599, 26554, 26577, 26623, 26600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15108, 26554, 26577, 26623, 26600, 26555, 26578, 26624, 26601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15109, 26555, 26578, 26624, 26601, 26556, 26579, 26625, 26602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15110, 26556, 26579, 26625, 26602, 26557, 26580, 26626, 26603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15111, 26557, 26580, 26626, 26603, 26558, 26581, 26627, 26604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15112, 26558, 26581, 26627, 26604, 26559, 26582, 26628, 26605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15113, 26559, 26582, 26628, 26605, 26560, 26583, 26629, 26606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15114, 26560, 26583, 26629, 26606, 26561, 26584, 26630, 26607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15115, 26561, 26584, 26630, 26607, 26562, 26585, 26631, 26608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15116, 26562, 26585, 26631, 26608, 26563, 26586, 26632, 26609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15117, 26563, 26586, 26632, 26609, 6492, 6493, 6495, 6494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15118, 5873, 648, 649, 5875, 26564, 6302, 6325, 26610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15119, 26564, 6302, 6325, 26610, 26565, 6303, 6326, 26611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15120, 26565, 6303, 6326, 26611, 26566, 6304, 6327, 26612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15121, 26566, 6304, 6327, 26612, 26567, 6305, 6328, 26613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15122, 26567, 6305, 6328, 26613, 26568, 6306, 6329, 26614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15123, 26568, 6306, 6329, 26614, 26569, 6307, 6330, 26615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15124, 26569, 6307, 6330, 26615, 26570, 6308, 6331, 26616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15125, 26570, 6308, 6331, 26616, 26571, 6309, 6332, 26617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15126, 26571, 6309, 6332, 26617, 26572, 6310, 6333, 26618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15127, 26572, 6310, 6333, 26618, 26573, 6311, 6334, 26619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15128, 26573, 6311, 6334, 26619, 26574, 6312, 6335, 26620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15129, 26574, 6312, 6335, 26620, 26575, 6313, 6336, 26621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15130, 26575, 6313, 6336, 26621, 26576, 6314, 6337, 26622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15131, 26576, 6314, 6337, 26622, 26577, 6315, 6338, 26623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15132, 26577, 6315, 6338, 26623, 26578, 6316, 6339, 26624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15133, 26578, 6316, 6339, 26624, 26579, 6317, 6340, 26625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15134, 26579, 6317, 6340, 26625, 26580, 6318, 6341, 26626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15135, 26580, 6318, 6341, 26626, 26581, 6319, 6342, 26627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15136, 26581, 6319, 6342, 26627, 26582, 6320, 6343, 26628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15137, 26582, 6320, 6343, 26628, 26583, 6321, 6344, 26629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15138, 26583, 6321, 6344, 26629, 26584, 6322, 6345, 26630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15139, 26584, 6322, 6345, 26630, 26585, 6323, 6346, 26631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15140, 26585, 6323, 6346, 26631, 26586, 6324, 6347, 26632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15141, 26586, 6324, 6347, 26632, 6493, 766, 767, 6495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15142, 638, 5874, 5876, 639, 6072, 26587, 26633, 6095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15143, 6072, 26587, 26633, 6095, 6073, 26588, 26634, 6096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15144, 6073, 26588, 26634, 6096, 6074, 26589, 26635, 6097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15145, 6074, 26589, 26635, 6097, 6075, 26590, 26636, 6098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15146, 6075, 26590, 26636, 6098, 6076, 26591, 26637, 6099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15147, 6076, 26591, 26637, 6099, 6077, 26592, 26638, 6100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15148, 6077, 26592, 26638, 6100, 6078, 26593, 26639, 6101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15149, 6078, 26593, 26639, 6101, 6079, 26594, 26640, 6102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15150, 6079, 26594, 26640, 6102, 6080, 26595, 26641, 6103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15151, 6080, 26595, 26641, 6103, 6081, 26596, 26642, 6104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15152, 6081, 26596, 26642, 6104, 6082, 26597, 26643, 6105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15153, 6082, 26597, 26643, 6105, 6083, 26598, 26644, 6106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15154, 6083, 26598, 26644, 6106, 6084, 26599, 26645, 6107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15155, 6084, 26599, 26645, 6107, 6085, 26600, 26646, 6108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15156, 6085, 26600, 26646, 6108, 6086, 26601, 26647, 6109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15157, 6086, 26601, 26647, 6109, 6087, 26602, 26648, 6110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15158, 6087, 26602, 26648, 6110, 6088, 26603, 26649, 6111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15159, 6088, 26603, 26649, 6111, 6089, 26604, 26650, 6112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15160, 6089, 26604, 26650, 6112, 6090, 26605, 26651, 6113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15161, 6090, 26605, 26651, 6113, 6091, 26606, 26652, 6114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15162, 6091, 26606, 26652, 6114, 6092, 26607, 26653, 6115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15163, 6092, 26607, 26653, 6115, 6093, 26608, 26654, 6116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15164, 6093, 26608, 26654, 6116, 6094, 26609, 26655, 6117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15165, 6094, 26609, 26655, 6117, 756, 6494, 6496, 757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15166, 5874, 5875, 5877, 5876, 26587, 26610, 26656, 26633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15167, 26587, 26610, 26656, 26633, 26588, 26611, 26657, 26634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15168, 26588, 26611, 26657, 26634, 26589, 26612, 26658, 26635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15169, 26589, 26612, 26658, 26635, 26590, 26613, 26659, 26636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15170, 26590, 26613, 26659, 26636, 26591, 26614, 26660, 26637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15171, 26591, 26614, 26660, 26637, 26592, 26615, 26661, 26638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15172, 26592, 26615, 26661, 26638, 26593, 26616, 26662, 26639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15173, 26593, 26616, 26662, 26639, 26594, 26617, 26663, 26640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15174, 26594, 26617, 26663, 26640, 26595, 26618, 26664, 26641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15175, 26595, 26618, 26664, 26641, 26596, 26619, 26665, 26642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15176, 26596, 26619, 26665, 26642, 26597, 26620, 26666, 26643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15177, 26597, 26620, 26666, 26643, 26598, 26621, 26667, 26644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15178, 26598, 26621, 26667, 26644, 26599, 26622, 26668, 26645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15179, 26599, 26622, 26668, 26645, 26600, 26623, 26669, 26646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15180, 26600, 26623, 26669, 26646, 26601, 26624, 26670, 26647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15181, 26601, 26624, 26670, 26647, 26602, 26625, 26671, 26648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15182, 26602, 26625, 26671, 26648, 26603, 26626, 26672, 26649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15183, 26603, 26626, 26672, 26649, 26604, 26627, 26673, 26650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15184, 26604, 26627, 26673, 26650, 26605, 26628, 26674, 26651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15185, 26605, 26628, 26674, 26651, 26606, 26629, 26675, 26652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15186, 26606, 26629, 26675, 26652, 26607, 26630, 26676, 26653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15187, 26607, 26630, 26676, 26653, 26608, 26631, 26677, 26654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15188, 26608, 26631, 26677, 26654, 26609, 26632, 26678, 26655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15189, 26609, 26632, 26678, 26655, 6494, 6495, 6497, 6496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15190, 5875, 649, 650, 5877, 26610, 6325, 6348, 26656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15191, 26610, 6325, 6348, 26656, 26611, 6326, 6349, 26657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15192, 26611, 6326, 6349, 26657, 26612, 6327, 6350, 26658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15193, 26612, 6327, 6350, 26658, 26613, 6328, 6351, 26659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15194, 26613, 6328, 6351, 26659, 26614, 6329, 6352, 26660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15195, 26614, 6329, 6352, 26660, 26615, 6330, 6353, 26661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15196, 26615, 6330, 6353, 26661, 26616, 6331, 6354, 26662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15197, 26616, 6331, 6354, 26662, 26617, 6332, 6355, 26663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15198, 26617, 6332, 6355, 26663, 26618, 6333, 6356, 26664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15199, 26618, 6333, 6356, 26664, 26619, 6334, 6357, 26665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15200, 26619, 6334, 6357, 26665, 26620, 6335, 6358, 26666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15201, 26620, 6335, 6358, 26666, 26621, 6336, 6359, 26667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15202, 26621, 6336, 6359, 26667, 26622, 6337, 6360, 26668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15203, 26622, 6337, 6360, 26668, 26623, 6338, 6361, 26669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15204, 26623, 6338, 6361, 26669, 26624, 6339, 6362, 26670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15205, 26624, 6339, 6362, 26670, 26625, 6340, 6363, 26671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15206, 26625, 6340, 6363, 26671, 26626, 6341, 6364, 26672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15207, 26626, 6341, 6364, 26672, 26627, 6342, 6365, 26673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15208, 26627, 6342, 6365, 26673, 26628, 6343, 6366, 26674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15209, 26628, 6343, 6366, 26674, 26629, 6344, 6367, 26675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15210, 26629, 6344, 6367, 26675, 26630, 6345, 6368, 26676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15211, 26630, 6345, 6368, 26676, 26631, 6346, 6369, 26677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15212, 26631, 6346, 6369, 26677, 26632, 6347, 6370, 26678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15213, 26632, 6347, 6370, 26678, 6495, 767, 768, 6497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15214, 639, 5876, 5878, 640, 6095, 26633, 26679, 6118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15215, 6095, 26633, 26679, 6118, 6096, 26634, 26680, 6119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15216, 6096, 26634, 26680, 6119, 6097, 26635, 26681, 6120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15217, 6097, 26635, 26681, 6120, 6098, 26636, 26682, 6121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15218, 6098, 26636, 26682, 6121, 6099, 26637, 26683, 6122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15219, 6099, 26637, 26683, 6122, 6100, 26638, 26684, 6123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15220, 6100, 26638, 26684, 6123, 6101, 26639, 26685, 6124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15221, 6101, 26639, 26685, 6124, 6102, 26640, 26686, 6125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15222, 6102, 26640, 26686, 6125, 6103, 26641, 26687, 6126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15223, 6103, 26641, 26687, 6126, 6104, 26642, 26688, 6127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15224, 6104, 26642, 26688, 6127, 6105, 26643, 26689, 6128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15225, 6105, 26643, 26689, 6128, 6106, 26644, 26690, 6129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15226, 6106, 26644, 26690, 6129, 6107, 26645, 26691, 6130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15227, 6107, 26645, 26691, 6130, 6108, 26646, 26692, 6131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15228, 6108, 26646, 26692, 6131, 6109, 26647, 26693, 6132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15229, 6109, 26647, 26693, 6132, 6110, 26648, 26694, 6133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15230, 6110, 26648, 26694, 6133, 6111, 26649, 26695, 6134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15231, 6111, 26649, 26695, 6134, 6112, 26650, 26696, 6135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15232, 6112, 26650, 26696, 6135, 6113, 26651, 26697, 6136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15233, 6113, 26651, 26697, 6136, 6114, 26652, 26698, 6137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15234, 6114, 26652, 26698, 6137, 6115, 26653, 26699, 6138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15235, 6115, 26653, 26699, 6138, 6116, 26654, 26700, 6139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15236, 6116, 26654, 26700, 6139, 6117, 26655, 26701, 6140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15237, 6117, 26655, 26701, 6140, 757, 6496, 6498, 758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15238, 5876, 5877, 5879, 5878, 26633, 26656, 26702, 26679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15239, 26633, 26656, 26702, 26679, 26634, 26657, 26703, 26680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15240, 26634, 26657, 26703, 26680, 26635, 26658, 26704, 26681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15241, 26635, 26658, 26704, 26681, 26636, 26659, 26705, 26682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15242, 26636, 26659, 26705, 26682, 26637, 26660, 26706, 26683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15243, 26637, 26660, 26706, 26683, 26638, 26661, 26707, 26684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15244, 26638, 26661, 26707, 26684, 26639, 26662, 26708, 26685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15245, 26639, 26662, 26708, 26685, 26640, 26663, 26709, 26686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15246, 26640, 26663, 26709, 26686, 26641, 26664, 26710, 26687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15247, 26641, 26664, 26710, 26687, 26642, 26665, 26711, 26688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15248, 26642, 26665, 26711, 26688, 26643, 26666, 26712, 26689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15249, 26643, 26666, 26712, 26689, 26644, 26667, 26713, 26690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15250, 26644, 26667, 26713, 26690, 26645, 26668, 26714, 26691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15251, 26645, 26668, 26714, 26691, 26646, 26669, 26715, 26692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15252, 26646, 26669, 26715, 26692, 26647, 26670, 26716, 26693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15253, 26647, 26670, 26716, 26693, 26648, 26671, 26717, 26694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15254, 26648, 26671, 26717, 26694, 26649, 26672, 26718, 26695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15255, 26649, 26672, 26718, 26695, 26650, 26673, 26719, 26696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15256, 26650, 26673, 26719, 26696, 26651, 26674, 26720, 26697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15257, 26651, 26674, 26720, 26697, 26652, 26675, 26721, 26698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15258, 26652, 26675, 26721, 26698, 26653, 26676, 26722, 26699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15259, 26653, 26676, 26722, 26699, 26654, 26677, 26723, 26700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15260, 26654, 26677, 26723, 26700, 26655, 26678, 26724, 26701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15261, 26655, 26678, 26724, 26701, 6496, 6497, 6499, 6498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15262, 5877, 650, 651, 5879, 26656, 6348, 6371, 26702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15263, 26656, 6348, 6371, 26702, 26657, 6349, 6372, 26703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15264, 26657, 6349, 6372, 26703, 26658, 6350, 6373, 26704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15265, 26658, 6350, 6373, 26704, 26659, 6351, 6374, 26705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15266, 26659, 6351, 6374, 26705, 26660, 6352, 6375, 26706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15267, 26660, 6352, 6375, 26706, 26661, 6353, 6376, 26707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15268, 26661, 6353, 6376, 26707, 26662, 6354, 6377, 26708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15269, 26662, 6354, 6377, 26708, 26663, 6355, 6378, 26709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15270, 26663, 6355, 6378, 26709, 26664, 6356, 6379, 26710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15271, 26664, 6356, 6379, 26710, 26665, 6357, 6380, 26711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15272, 26665, 6357, 6380, 26711, 26666, 6358, 6381, 26712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15273, 26666, 6358, 6381, 26712, 26667, 6359, 6382, 26713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15274, 26667, 6359, 6382, 26713, 26668, 6360, 6383, 26714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15275, 26668, 6360, 6383, 26714, 26669, 6361, 6384, 26715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15276, 26669, 6361, 6384, 26715, 26670, 6362, 6385, 26716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15277, 26670, 6362, 6385, 26716, 26671, 6363, 6386, 26717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15278, 26671, 6363, 6386, 26717, 26672, 6364, 6387, 26718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15279, 26672, 6364, 6387, 26718, 26673, 6365, 6388, 26719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15280, 26673, 6365, 6388, 26719, 26674, 6366, 6389, 26720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15281, 26674, 6366, 6389, 26720, 26675, 6367, 6390, 26721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15282, 26675, 6367, 6390, 26721, 26676, 6368, 6391, 26722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15283, 26676, 6368, 6391, 26722, 26677, 6369, 6392, 26723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15284, 26677, 6369, 6392, 26723, 26678, 6370, 6393, 26724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15285, 26678, 6370, 6393, 26724, 6497, 768, 769, 6499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15286, 640, 5878, 5880, 641, 6118, 26679, 26725, 6141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15287, 6118, 26679, 26725, 6141, 6119, 26680, 26726, 6142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15288, 6119, 26680, 26726, 6142, 6120, 26681, 26727, 6143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15289, 6120, 26681, 26727, 6143, 6121, 26682, 26728, 6144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15290, 6121, 26682, 26728, 6144, 6122, 26683, 26729, 6145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15291, 6122, 26683, 26729, 6145, 6123, 26684, 26730, 6146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15292, 6123, 26684, 26730, 6146, 6124, 26685, 26731, 6147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15293, 6124, 26685, 26731, 6147, 6125, 26686, 26732, 6148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15294, 6125, 26686, 26732, 6148, 6126, 26687, 26733, 6149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15295, 6126, 26687, 26733, 6149, 6127, 26688, 26734, 6150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15296, 6127, 26688, 26734, 6150, 6128, 26689, 26735, 6151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15297, 6128, 26689, 26735, 6151, 6129, 26690, 26736, 6152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15298, 6129, 26690, 26736, 6152, 6130, 26691, 26737, 6153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15299, 6130, 26691, 26737, 6153, 6131, 26692, 26738, 6154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15300, 6131, 26692, 26738, 6154, 6132, 26693, 26739, 6155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15301, 6132, 26693, 26739, 6155, 6133, 26694, 26740, 6156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15302, 6133, 26694, 26740, 6156, 6134, 26695, 26741, 6157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15303, 6134, 26695, 26741, 6157, 6135, 26696, 26742, 6158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15304, 6135, 26696, 26742, 6158, 6136, 26697, 26743, 6159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15305, 6136, 26697, 26743, 6159, 6137, 26698, 26744, 6160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15306, 6137, 26698, 26744, 6160, 6138, 26699, 26745, 6161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15307, 6138, 26699, 26745, 6161, 6139, 26700, 26746, 6162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15308, 6139, 26700, 26746, 6162, 6140, 26701, 26747, 6163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15309, 6140, 26701, 26747, 6163, 758, 6498, 6500, 759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15310, 5878, 5879, 5881, 5880, 26679, 26702, 26748, 26725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15311, 26679, 26702, 26748, 26725, 26680, 26703, 26749, 26726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15312, 26680, 26703, 26749, 26726, 26681, 26704, 26750, 26727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15313, 26681, 26704, 26750, 26727, 26682, 26705, 26751, 26728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15314, 26682, 26705, 26751, 26728, 26683, 26706, 26752, 26729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15315, 26683, 26706, 26752, 26729, 26684, 26707, 26753, 26730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15316, 26684, 26707, 26753, 26730, 26685, 26708, 26754, 26731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15317, 26685, 26708, 26754, 26731, 26686, 26709, 26755, 26732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15318, 26686, 26709, 26755, 26732, 26687, 26710, 26756, 26733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15319, 26687, 26710, 26756, 26733, 26688, 26711, 26757, 26734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15320, 26688, 26711, 26757, 26734, 26689, 26712, 26758, 26735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15321, 26689, 26712, 26758, 26735, 26690, 26713, 26759, 26736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15322, 26690, 26713, 26759, 26736, 26691, 26714, 26760, 26737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15323, 26691, 26714, 26760, 26737, 26692, 26715, 26761, 26738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15324, 26692, 26715, 26761, 26738, 26693, 26716, 26762, 26739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15325, 26693, 26716, 26762, 26739, 26694, 26717, 26763, 26740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15326, 26694, 26717, 26763, 26740, 26695, 26718, 26764, 26741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15327, 26695, 26718, 26764, 26741, 26696, 26719, 26765, 26742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15328, 26696, 26719, 26765, 26742, 26697, 26720, 26766, 26743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15329, 26697, 26720, 26766, 26743, 26698, 26721, 26767, 26744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15330, 26698, 26721, 26767, 26744, 26699, 26722, 26768, 26745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15331, 26699, 26722, 26768, 26745, 26700, 26723, 26769, 26746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15332, 26700, 26723, 26769, 26746, 26701, 26724, 26770, 26747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15333, 26701, 26724, 26770, 26747, 6498, 6499, 6501, 6500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15334, 5879, 651, 652, 5881, 26702, 6371, 6394, 26748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15335, 26702, 6371, 6394, 26748, 26703, 6372, 6395, 26749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15336, 26703, 6372, 6395, 26749, 26704, 6373, 6396, 26750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15337, 26704, 6373, 6396, 26750, 26705, 6374, 6397, 26751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15338, 26705, 6374, 6397, 26751, 26706, 6375, 6398, 26752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15339, 26706, 6375, 6398, 26752, 26707, 6376, 6399, 26753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15340, 26707, 6376, 6399, 26753, 26708, 6377, 6400, 26754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15341, 26708, 6377, 6400, 26754, 26709, 6378, 6401, 26755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15342, 26709, 6378, 6401, 26755, 26710, 6379, 6402, 26756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15343, 26710, 6379, 6402, 26756, 26711, 6380, 6403, 26757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15344, 26711, 6380, 6403, 26757, 26712, 6381, 6404, 26758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15345, 26712, 6381, 6404, 26758, 26713, 6382, 6405, 26759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15346, 26713, 6382, 6405, 26759, 26714, 6383, 6406, 26760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15347, 26714, 6383, 6406, 26760, 26715, 6384, 6407, 26761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15348, 26715, 6384, 6407, 26761, 26716, 6385, 6408, 26762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15349, 26716, 6385, 6408, 26762, 26717, 6386, 6409, 26763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15350, 26717, 6386, 6409, 26763, 26718, 6387, 6410, 26764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15351, 26718, 6387, 6410, 26764, 26719, 6388, 6411, 26765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15352, 26719, 6388, 6411, 26765, 26720, 6389, 6412, 26766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15353, 26720, 6389, 6412, 26766, 26721, 6390, 6413, 26767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15354, 26721, 6390, 6413, 26767, 26722, 6391, 6414, 26768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15355, 26722, 6391, 6414, 26768, 26723, 6392, 6415, 26769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15356, 26723, 6392, 6415, 26769, 26724, 6393, 6416, 26770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15357, 26724, 6393, 6416, 26770, 6499, 769, 770, 6501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15358, 641, 5880, 5882, 642, 6141, 26725, 26771, 6164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15359, 6141, 26725, 26771, 6164, 6142, 26726, 26772, 6165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15360, 6142, 26726, 26772, 6165, 6143, 26727, 26773, 6166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15361, 6143, 26727, 26773, 6166, 6144, 26728, 26774, 6167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15362, 6144, 26728, 26774, 6167, 6145, 26729, 26775, 6168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15363, 6145, 26729, 26775, 6168, 6146, 26730, 26776, 6169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15364, 6146, 26730, 26776, 6169, 6147, 26731, 26777, 6170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15365, 6147, 26731, 26777, 6170, 6148, 26732, 26778, 6171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15366, 6148, 26732, 26778, 6171, 6149, 26733, 26779, 6172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15367, 6149, 26733, 26779, 6172, 6150, 26734, 26780, 6173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15368, 6150, 26734, 26780, 6173, 6151, 26735, 26781, 6174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15369, 6151, 26735, 26781, 6174, 6152, 26736, 26782, 6175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15370, 6152, 26736, 26782, 6175, 6153, 26737, 26783, 6176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15371, 6153, 26737, 26783, 6176, 6154, 26738, 26784, 6177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15372, 6154, 26738, 26784, 6177, 6155, 26739, 26785, 6178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15373, 6155, 26739, 26785, 6178, 6156, 26740, 26786, 6179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15374, 6156, 26740, 26786, 6179, 6157, 26741, 26787, 6180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15375, 6157, 26741, 26787, 6180, 6158, 26742, 26788, 6181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15376, 6158, 26742, 26788, 6181, 6159, 26743, 26789, 6182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15377, 6159, 26743, 26789, 6182, 6160, 26744, 26790, 6183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15378, 6160, 26744, 26790, 6183, 6161, 26745, 26791, 6184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15379, 6161, 26745, 26791, 6184, 6162, 26746, 26792, 6185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15380, 6162, 26746, 26792, 6185, 6163, 26747, 26793, 6186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15381, 6163, 26747, 26793, 6186, 759, 6500, 6502, 760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15382, 5880, 5881, 5883, 5882, 26725, 26748, 26794, 26771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15383, 26725, 26748, 26794, 26771, 26726, 26749, 26795, 26772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15384, 26726, 26749, 26795, 26772, 26727, 26750, 26796, 26773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15385, 26727, 26750, 26796, 26773, 26728, 26751, 26797, 26774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15386, 26728, 26751, 26797, 26774, 26729, 26752, 26798, 26775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15387, 26729, 26752, 26798, 26775, 26730, 26753, 26799, 26776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15388, 26730, 26753, 26799, 26776, 26731, 26754, 26800, 26777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15389, 26731, 26754, 26800, 26777, 26732, 26755, 26801, 26778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15390, 26732, 26755, 26801, 26778, 26733, 26756, 26802, 26779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15391, 26733, 26756, 26802, 26779, 26734, 26757, 26803, 26780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15392, 26734, 26757, 26803, 26780, 26735, 26758, 26804, 26781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15393, 26735, 26758, 26804, 26781, 26736, 26759, 26805, 26782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15394, 26736, 26759, 26805, 26782, 26737, 26760, 26806, 26783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15395, 26737, 26760, 26806, 26783, 26738, 26761, 26807, 26784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15396, 26738, 26761, 26807, 26784, 26739, 26762, 26808, 26785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15397, 26739, 26762, 26808, 26785, 26740, 26763, 26809, 26786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15398, 26740, 26763, 26809, 26786, 26741, 26764, 26810, 26787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15399, 26741, 26764, 26810, 26787, 26742, 26765, 26811, 26788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15400, 26742, 26765, 26811, 26788, 26743, 26766, 26812, 26789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15401, 26743, 26766, 26812, 26789, 26744, 26767, 26813, 26790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15402, 26744, 26767, 26813, 26790, 26745, 26768, 26814, 26791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15403, 26745, 26768, 26814, 26791, 26746, 26769, 26815, 26792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15404, 26746, 26769, 26815, 26792, 26747, 26770, 26816, 26793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15405, 26747, 26770, 26816, 26793, 6500, 6501, 6503, 6502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15406, 5881, 652, 653, 5883, 26748, 6394, 6417, 26794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15407, 26748, 6394, 6417, 26794, 26749, 6395, 6418, 26795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15408, 26749, 6395, 6418, 26795, 26750, 6396, 6419, 26796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15409, 26750, 6396, 6419, 26796, 26751, 6397, 6420, 26797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15410, 26751, 6397, 6420, 26797, 26752, 6398, 6421, 26798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15411, 26752, 6398, 6421, 26798, 26753, 6399, 6422, 26799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15412, 26753, 6399, 6422, 26799, 26754, 6400, 6423, 26800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15413, 26754, 6400, 6423, 26800, 26755, 6401, 6424, 26801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15414, 26755, 6401, 6424, 26801, 26756, 6402, 6425, 26802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15415, 26756, 6402, 6425, 26802, 26757, 6403, 6426, 26803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15416, 26757, 6403, 6426, 26803, 26758, 6404, 6427, 26804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15417, 26758, 6404, 6427, 26804, 26759, 6405, 6428, 26805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15418, 26759, 6405, 6428, 26805, 26760, 6406, 6429, 26806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15419, 26760, 6406, 6429, 26806, 26761, 6407, 6430, 26807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15420, 26761, 6407, 6430, 26807, 26762, 6408, 6431, 26808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15421, 26762, 6408, 6431, 26808, 26763, 6409, 6432, 26809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15422, 26763, 6409, 6432, 26809, 26764, 6410, 6433, 26810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15423, 26764, 6410, 6433, 26810, 26765, 6411, 6434, 26811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15424, 26765, 6411, 6434, 26811, 26766, 6412, 6435, 26812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15425, 26766, 6412, 6435, 26812, 26767, 6413, 6436, 26813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15426, 26767, 6413, 6436, 26813, 26768, 6414, 6437, 26814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15427, 26768, 6414, 6437, 26814, 26769, 6415, 6438, 26815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15428, 26769, 6415, 6438, 26815, 26770, 6416, 6439, 26816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15429, 26770, 6416, 6439, 26816, 6501, 770, 771, 6503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15430, 642, 5882, 5884, 643, 6164, 26771, 26817, 6187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15431, 6164, 26771, 26817, 6187, 6165, 26772, 26818, 6188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15432, 6165, 26772, 26818, 6188, 6166, 26773, 26819, 6189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15433, 6166, 26773, 26819, 6189, 6167, 26774, 26820, 6190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15434, 6167, 26774, 26820, 6190, 6168, 26775, 26821, 6191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15435, 6168, 26775, 26821, 6191, 6169, 26776, 26822, 6192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15436, 6169, 26776, 26822, 6192, 6170, 26777, 26823, 6193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15437, 6170, 26777, 26823, 6193, 6171, 26778, 26824, 6194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15438, 6171, 26778, 26824, 6194, 6172, 26779, 26825, 6195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15439, 6172, 26779, 26825, 6195, 6173, 26780, 26826, 6196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15440, 6173, 26780, 26826, 6196, 6174, 26781, 26827, 6197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15441, 6174, 26781, 26827, 6197, 6175, 26782, 26828, 6198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15442, 6175, 26782, 26828, 6198, 6176, 26783, 26829, 6199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15443, 6176, 26783, 26829, 6199, 6177, 26784, 26830, 6200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15444, 6177, 26784, 26830, 6200, 6178, 26785, 26831, 6201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15445, 6178, 26785, 26831, 6201, 6179, 26786, 26832, 6202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15446, 6179, 26786, 26832, 6202, 6180, 26787, 26833, 6203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15447, 6180, 26787, 26833, 6203, 6181, 26788, 26834, 6204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15448, 6181, 26788, 26834, 6204, 6182, 26789, 26835, 6205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15449, 6182, 26789, 26835, 6205, 6183, 26790, 26836, 6206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15450, 6183, 26790, 26836, 6206, 6184, 26791, 26837, 6207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15451, 6184, 26791, 26837, 6207, 6185, 26792, 26838, 6208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15452, 6185, 26792, 26838, 6208, 6186, 26793, 26839, 6209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15453, 6186, 26793, 26839, 6209, 760, 6502, 6504, 761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15454, 5882, 5883, 5885, 5884, 26771, 26794, 26840, 26817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15455, 26771, 26794, 26840, 26817, 26772, 26795, 26841, 26818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15456, 26772, 26795, 26841, 26818, 26773, 26796, 26842, 26819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15457, 26773, 26796, 26842, 26819, 26774, 26797, 26843, 26820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15458, 26774, 26797, 26843, 26820, 26775, 26798, 26844, 26821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15459, 26775, 26798, 26844, 26821, 26776, 26799, 26845, 26822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15460, 26776, 26799, 26845, 26822, 26777, 26800, 26846, 26823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15461, 26777, 26800, 26846, 26823, 26778, 26801, 26847, 26824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15462, 26778, 26801, 26847, 26824, 26779, 26802, 26848, 26825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15463, 26779, 26802, 26848, 26825, 26780, 26803, 26849, 26826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15464, 26780, 26803, 26849, 26826, 26781, 26804, 26850, 26827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15465, 26781, 26804, 26850, 26827, 26782, 26805, 26851, 26828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15466, 26782, 26805, 26851, 26828, 26783, 26806, 26852, 26829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15467, 26783, 26806, 26852, 26829, 26784, 26807, 26853, 26830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15468, 26784, 26807, 26853, 26830, 26785, 26808, 26854, 26831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15469, 26785, 26808, 26854, 26831, 26786, 26809, 26855, 26832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15470, 26786, 26809, 26855, 26832, 26787, 26810, 26856, 26833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15471, 26787, 26810, 26856, 26833, 26788, 26811, 26857, 26834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15472, 26788, 26811, 26857, 26834, 26789, 26812, 26858, 26835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15473, 26789, 26812, 26858, 26835, 26790, 26813, 26859, 26836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15474, 26790, 26813, 26859, 26836, 26791, 26814, 26860, 26837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15475, 26791, 26814, 26860, 26837, 26792, 26815, 26861, 26838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15476, 26792, 26815, 26861, 26838, 26793, 26816, 26862, 26839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15477, 26793, 26816, 26862, 26839, 6502, 6503, 6505, 6504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15478, 5883, 653, 654, 5885, 26794, 6417, 6440, 26840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
15479, 26794, 6417, 6440, 26840, 26795, 6418, 6441, 26841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
