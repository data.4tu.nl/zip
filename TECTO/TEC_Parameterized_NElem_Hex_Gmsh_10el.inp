39637, 349, 350, 1558, 1557, 0, 11796, 1581, 11795
39638, 350, 351, 1559, 1558, 0, 11797, 1582, 11796
39639, 351, 352, 1560, 1559, 0, 11798, 1583, 11797
39640, 352, 353, 1561, 1560, 0, 11799, 1584, 11798
39641, 353, 354, 1562, 1561, 0, 11800, 1585, 11799
39642, 354, 355, 1563, 1562, 0, 11801, 1586, 11800
39643, 355, 14, 68, 1563, 0, 1540, 1587, 11801
*ELEMENT, type=CPS8, ELSET=Surface89
39644, 10, 67, 1588, 242, 1539, 1611, 11802, 0
39645, 242, 1588, 1589, 243, 11802, 1612, 11803, 0
39646, 243, 1589, 1590, 244, 11803, 1613, 11804, 0
39647, 244, 1590, 1591, 245, 11804, 1614, 11805, 0
39648, 245, 1591, 1592, 246, 11805, 1615, 11806, 0
39649, 246, 1592, 1593, 247, 11806, 1616, 11807, 0
39650, 247, 1593, 1594, 248, 11807, 1617, 11808, 0
39651, 248, 1594, 1595, 249, 11808, 1618, 11809, 0
39652, 249, 1595, 1596, 250, 11809, 1619, 11810, 0
39653, 250, 1596, 1597, 251, 11810, 1620, 11811, 0
39654, 251, 1597, 1598, 252, 11811, 1621, 11812, 0
39655, 252, 1598, 1599, 253, 11812, 1622, 11813, 0
39656, 253, 1599, 1600, 254, 11813, 1623, 11814, 0
39657, 254, 1600, 1601, 255, 11814, 1624, 11815, 0
39658, 255, 1601, 1602, 256, 11815, 1625, 11816, 0
39659, 256, 1602, 1603, 257, 11816, 1626, 11817, 0
39660, 257, 1603, 1604, 258, 11817, 1627, 11818, 0
39661, 258, 1604, 1605, 259, 11818, 1628, 11819, 0
39662, 259, 1605, 1606, 260, 11819, 1629, 11820, 0
39663, 260, 1606, 1607, 261, 11820, 1630, 11821, 0
39664, 261, 1607, 1608, 262, 11821, 1631, 11822, 0
39665, 262, 1608, 1609, 263, 11822, 1632, 11823, 0
39666, 263, 1609, 1610, 264, 11823, 1633, 11824, 0
39667, 264, 1610, 65, 9, 11824, 1634, 1490, 0
*ELEMENT, type=CPS8, ELSET=Surface90
39668, 14, 356, 1635, 68, 0, 11825, 1658, 1540
39669, 356, 357, 1636, 1635, 0, 11826, 1659, 11825
39670, 357, 358, 1637, 1636, 0, 11827, 1660, 11826
39671, 358, 359, 1638, 1637, 0, 11828, 1661, 11827
39672, 359, 360, 1639, 1638, 0, 11829, 1662, 11828
39673, 360, 361, 1640, 1639, 0, 11830, 1663, 11829
39674, 361, 362, 1641, 1640, 0, 11831, 1664, 11830
39675, 362, 363, 1642, 1641, 0, 11832, 1665, 11831
39676, 363, 364, 1643, 1642, 0, 11833, 1666, 11832
39677, 364, 365, 1644, 1643, 0, 11834, 1667, 11833
39678, 365, 366, 1645, 1644, 0, 11835, 1668, 11834
39679, 366, 367, 1646, 1645, 0, 11836, 1669, 11835
39680, 367, 368, 1647, 1646, 0, 11837, 1670, 11836
39681, 368, 369, 1648, 1647, 0, 11838, 1671, 11837
39682, 369, 370, 1649, 1648, 0, 11839, 1672, 11838
39683, 370, 371, 1650, 1649, 0, 11840, 1673, 11839
39684, 371, 372, 1651, 1650, 0, 11841, 1674, 11840
39685, 372, 373, 1652, 1651, 0, 11842, 1675, 11841
39686, 373, 374, 1653, 1652, 0, 11843, 1676, 11842
39687, 374, 375, 1654, 1653, 0, 11844, 1677, 11843
39688, 375, 376, 1655, 1654, 0, 11845, 1678, 11844
39689, 376, 377, 1656, 1655, 0, 11846, 1679, 11845
39690, 377, 378, 1657, 1656, 0, 11847, 1680, 11846
39691, 378, 13, 66, 1657, 0, 1491, 1681, 11847
*ELEMENT, type=CPS8, ELSET=Surface91
39692, 67, 1541, 11848, 1588, 1564, 12377, 12378, 1611
39693, 1541, 1542, 11849, 11848, 1565, 12379, 12380, 12377
39694, 1542, 1543, 11850, 11849, 1566, 12381, 12382, 12379
39695, 1543, 1544, 11851, 11850, 1567, 12383, 12384, 12381
39696, 1544, 1545, 11852, 11851, 1568, 12385, 12386, 12383
39697, 1545, 1546, 11853, 11852, 1569, 12387, 12388, 12385
39698, 1546, 1547, 11854, 11853, 1570, 12389, 12390, 12387
39699, 1547, 1548, 11855, 11854, 1571, 12391, 12392, 12389
39700, 1548, 1549, 11856, 11855, 1572, 12393, 12394, 12391
39701, 1549, 1550, 11857, 11856, 1573, 12395, 12396, 12393
39702, 1550, 1551, 11858, 11857, 1574, 12397, 12398, 12395
39703, 1551, 1552, 11859, 11858, 1575, 12399, 12400, 12397
39704, 1552, 1553, 11860, 11859, 1576, 12401, 12402, 12399
39705, 1553, 1554, 11861, 11860, 1577, 12403, 12404, 12401
39706, 1554, 1555, 11862, 11861, 1578, 12405, 12406, 12403
39707, 1555, 1556, 11863, 11862, 1579, 12407, 12408, 12405
39708, 1556, 1557, 11864, 11863, 1580, 12409, 12410, 12407
39709, 1557, 1558, 11865, 11864, 1581, 12411, 12412, 12409
39710, 1558, 1559, 11866, 11865, 1582, 12413, 12414, 12411
39711, 1559, 1560, 11867, 11866, 1583, 12415, 12416, 12413
39712, 1560, 1561, 11868, 11867, 1584, 12417, 12418, 12415
39713, 1561, 1562, 11869, 11868, 1585, 12419, 12420, 12417
39714, 1562, 1563, 11870, 11869, 1586, 12421, 12422, 12419
39715, 1563, 68, 1635, 11870, 1587, 1658, 12423, 12421
39716, 1588, 11848, 11871, 1589, 12378, 12424, 12425, 1612
39717, 11848, 11849, 11872, 11871, 12380, 12426, 12427, 12424
39718, 11849, 11850, 11873, 11872, 12382, 12428, 12429, 12426
39719, 11850, 11851, 11874, 11873, 12384, 12430, 12431, 12428
39720, 11851, 11852, 11875, 11874, 12386, 12432, 12433, 12430
39721, 11852, 11853, 11876, 11875, 12388, 12434, 12435, 12432
39722, 11853, 11854, 11877, 11876, 12390, 12436, 12437, 12434
39723, 11854, 11855, 11878, 11877, 12392, 12438, 12439, 12436
39724, 11855, 11856, 11879, 11878, 12394, 12440, 12441, 12438
39725, 11856, 11857, 11880, 11879, 12396, 12442, 12443, 12440
39726, 11857, 11858, 11881, 11880, 12398, 12444, 12445, 12442
39727, 11858, 11859, 11882, 11881, 12400, 12446, 12447, 12444
39728, 11859, 11860, 11883, 11882, 12402, 12448, 12449, 12446
39729, 11860, 11861, 11884, 11883, 12404, 12450, 12451, 12448
39730, 11861, 11862, 11885, 11884, 12406, 12452, 12453, 12450
39731, 11862, 11863, 11886, 11885, 12408, 12454, 12455, 12452
39732, 11863, 11864, 11887, 11886, 12410, 12456, 12457, 12454
39733, 11864, 11865, 11888, 11887, 12412, 12458, 12459, 12456
39734, 11865, 11866, 11889, 11888, 12414, 12460, 12461, 12458
39735, 11866, 11867, 11890, 11889, 12416, 12462, 12463, 12460
39736, 11867, 11868, 11891, 11890, 12418, 12464, 12465, 12462
39737, 11868, 11869, 11892, 11891, 12420, 12466, 12467, 12464
39738, 11869, 11870, 11893, 11892, 12422, 12468, 12469, 12466
39739, 11870, 1635, 1636, 11893, 12423, 1659, 12470, 12468
39740, 1589, 11871, 11894, 1590, 12425, 12471, 12472, 1613
39741, 11871, 11872, 11895, 11894, 12427, 12473, 12474, 12471
39742, 11872, 11873, 11896, 11895, 12429, 12475, 12476, 12473
39743, 11873, 11874, 11897, 11896, 12431, 12477, 12478, 12475
39744, 11874, 11875, 11898, 11897, 12433, 12479, 12480, 12477
39745, 11875, 11876, 11899, 11898, 12435, 12481, 12482, 12479
39746, 11876, 11877, 11900, 11899, 12437, 12483, 12484, 12481
39747, 11877, 11878, 11901, 11900, 12439, 12485, 12486, 12483
39748, 11878, 11879, 11902, 11901, 12441, 12487, 12488, 12485
39749, 11879, 11880, 11903, 11902, 12443, 12489, 12490, 12487
39750, 11880, 11881, 11904, 11903, 12445, 12491, 12492, 12489
39751, 11881, 11882, 11905, 11904, 12447, 12493, 12494, 12491
39752, 11882, 11883, 11906, 11905, 12449, 12495, 12496, 12493
39753, 11883, 11884, 11907, 11906, 12451, 12497, 12498, 12495
39754, 11884, 11885, 11908, 11907, 12453, 12499, 12500, 12497
39755, 11885, 11886, 11909, 11908, 12455, 12501, 12502, 12499
39756, 11886, 11887, 11910, 11909, 12457, 12503, 12504, 12501
39757, 11887, 11888, 11911, 11910, 12459, 12505, 12506, 12503
39758, 11888, 11889, 11912, 11911, 12461, 12507, 12508, 12505
39759, 11889, 11890, 11913, 11912, 12463, 12509, 12510, 12507
39760, 11890, 11891, 11914, 11913, 12465, 12511, 12512, 12509
39761, 11891, 11892, 11915, 11914, 12467, 12513, 12514, 12511
39762, 11892, 11893, 11916, 11915, 12469, 12515, 12516, 12513
39763, 11893, 1636, 1637, 11916, 12470, 1660, 12517, 12515
39764, 1590, 11894, 11917, 1591, 12472, 12518, 12519, 1614
39765, 11894, 11895, 11918, 11917, 12474, 12520, 12521, 12518
39766, 11895, 11896, 11919, 11918, 12476, 12522, 12523, 12520
39767, 11896, 11897, 11920, 11919, 12478, 12524, 12525, 12522
39768, 11897, 11898, 11921, 11920, 12480, 12526, 12527, 12524
39769, 11898, 11899, 11922, 11921, 12482, 12528, 12529, 12526
39770, 11899, 11900, 11923, 11922, 12484, 12530, 12531, 12528
39771, 11900, 11901, 11924, 11923, 12486, 12532, 12533, 12530
39772, 11901, 11902, 11925, 11924, 12488, 12534, 12535, 12532
39773, 11902, 11903, 11926, 11925, 12490, 12536, 12537, 12534
39774, 11903, 11904, 11927, 11926, 12492, 12538, 12539, 12536
39775, 11904, 11905, 11928, 11927, 12494, 12540, 12541, 12538
39776, 11905, 11906, 11929, 11928, 12496, 12542, 12543, 12540
39777, 11906, 11907, 11930, 11929, 12498, 12544, 12545, 12542
39778, 11907, 11908, 11931, 11930, 12500, 12546, 12547, 12544
39779, 11908, 11909, 11932, 11931, 12502, 12548, 12549, 12546
39780, 11909, 11910, 11933, 11932, 12504, 12550, 12551, 12548
39781, 11910, 11911, 11934, 11933, 12506, 12552, 12553, 12550
39782, 11911, 11912, 11935, 11934, 12508, 12554, 12555, 12552
39783, 11912, 11913, 11936, 11935, 12510, 12556, 12557, 12554
39784, 11913, 11914, 11937, 11936, 12512, 12558, 12559, 12556
39785, 11914, 11915, 11938, 11937, 12514, 12560, 12561, 12558
39786, 11915, 11916, 11939, 11938, 12516, 12562, 12563, 12560
39787, 11916, 1637, 1638, 11939, 12517, 1661, 12564, 12562
39788, 1591, 11917, 11940, 1592, 12519, 12565, 12566, 1615
39789, 11917, 11918, 11941, 11940, 12521, 12567, 12568, 12565
39790, 11918, 11919, 11942, 11941, 12523, 12569, 12570, 12567
39791, 11919, 11920, 11943, 11942, 12525, 12571, 12572, 12569
39792, 11920, 11921, 11944, 11943, 12527, 12573, 12574, 12571
39793, 11921, 11922, 11945, 11944, 12529, 12575, 12576, 12573
39794, 11922, 11923, 11946, 11945, 12531, 12577, 12578, 12575
39795, 11923, 11924, 11947, 11946, 12533, 12579, 12580, 12577
39796, 11924, 11925, 11948, 11947, 12535, 12581, 12582, 12579
39797, 11925, 11926, 11949, 11948, 12537, 12583, 12584, 12581
39798, 11926, 11927, 11950, 11949, 12539, 12585, 12586, 12583
39799, 11927, 11928, 11951, 11950, 12541, 12587, 12588, 12585
39800, 11928, 11929, 11952, 11951, 12543, 12589, 12590, 12587
39801, 11929, 11930, 11953, 11952, 12545, 12591, 12592, 12589
39802, 11930, 11931, 11954, 11953, 12547, 12593, 12594, 12591
39803, 11931, 11932, 11955, 11954, 12549, 12595, 12596, 12593
39804, 11932, 11933, 11956, 11955, 12551, 12597, 12598, 12595
39805, 11933, 11934, 11957, 11956, 12553, 12599, 12600, 12597
39806, 11934, 11935, 11958, 11957, 12555, 12601, 12602, 12599
39807, 11935, 11936, 11959, 11958, 12557, 12603, 12604, 12601
39808, 11936, 11937, 11960, 11959, 12559, 12605, 12606, 12603
39809, 11937, 11938, 11961, 11960, 12561, 12607, 12608, 12605
39810, 11938, 11939, 11962, 11961, 12563, 12609, 12610, 12607
39811, 11939, 1638, 1639, 11962, 12564, 1662, 12611, 12609
39812, 1592, 11940, 11963, 1593, 12566, 12612, 12613, 1616
39813, 11940, 11941, 11964, 11963, 12568, 12614, 12615, 12612
39814, 11941, 11942, 11965, 11964, 12570, 12616, 12617, 12614
39815, 11942, 11943, 11966, 11965, 12572, 12618, 12619, 12616
39816, 11943, 11944, 11967, 11966, 12574, 12620, 12621, 12618
39817, 11944, 11945, 11968, 11967, 12576, 12622, 12623, 12620
39818, 11945, 11946, 11969, 11968, 12578, 12624, 12625, 12622
39819, 11946, 11947, 11970, 11969, 12580, 12626, 12627, 12624
39820, 11947, 11948, 11971, 11970, 12582, 12628, 12629, 12626
39821, 11948, 11949, 11972, 11971, 12584, 12630, 12631, 12628
39822, 11949, 11950, 11973, 11972, 12586, 12632, 12633, 12630
39823, 11950, 11951, 11974, 11973, 12588, 12634, 12635, 12632
39824, 11951, 11952, 11975, 11974, 12590, 12636, 12637, 12634
39825, 11952, 11953, 11976, 11975, 12592, 12638, 12639, 12636
39826, 11953, 11954, 11977, 11976, 12594, 12640, 12641, 12638
39827, 11954, 11955, 11978, 11977, 12596, 12642, 12643, 12640
39828, 11955, 11956, 11979, 11978, 12598, 12644, 12645, 12642
39829, 11956, 11957, 11980, 11979, 12600, 12646, 12647, 12644
39830, 11957, 11958, 11981, 11980, 12602, 12648, 12649, 12646
39831, 11958, 11959, 11982, 11981, 12604, 12650, 12651, 12648
39832, 11959, 11960, 11983, 11982, 12606, 12652, 12653, 12650
39833, 11960, 11961, 11984, 11983, 12608, 12654, 12655, 12652
39834, 11961, 11962, 11985, 11984, 12610, 12656, 12657, 12654
39835, 11962, 1639, 1640, 11985, 12611, 1663, 12658, 12656
39836, 1593, 11963, 11986, 1594, 12613, 12659, 12660, 1617
39837, 11963, 11964, 11987, 11986, 12615, 12661, 12662, 12659
39838, 11964, 11965, 11988, 11987, 12617, 12663, 12664, 12661
39839, 11965, 11966, 11989, 11988, 12619, 12665, 12666, 12663
39840, 11966, 11967, 11990, 11989, 12621, 12667, 12668, 12665
39841, 11967, 11968, 11991, 11990, 12623, 12669, 12670, 12667
39842, 11968, 11969, 11992, 11991, 12625, 12671, 12672, 12669
39843, 11969, 11970, 11993, 11992, 12627, 12673, 12674, 12671
39844, 11970, 11971, 11994, 11993, 12629, 12675, 12676, 12673
39845, 11971, 11972, 11995, 11994, 12631, 12677, 12678, 12675
39846, 11972, 11973, 11996, 11995, 12633, 12679, 12680, 12677
39847, 11973, 11974, 11997, 11996, 12635, 12681, 12682, 12679
39848, 11974, 11975, 11998, 11997, 12637, 12683, 12684, 12681
39849, 11975, 11976, 11999, 11998, 12639, 12685, 12686, 12683
39850, 11976, 11977, 12000, 11999, 12641, 12687, 12688, 12685
39851, 11977, 11978, 12001, 12000, 12643, 12689, 12690, 12687
39852, 11978, 11979, 12002, 12001, 12645, 12691, 12692, 12689
39853, 11979, 11980, 12003, 12002, 12647, 12693, 12694, 12691
39854, 11980, 11981, 12004, 12003, 12649, 12695, 12696, 12693
39855, 11981, 11982, 12005, 12004, 12651, 12697, 12698, 12695
39856, 11982, 11983, 12006, 12005, 12653, 12699, 12700, 12697
39857, 11983, 11984, 12007, 12006, 12655, 12701, 12702, 12699
39858, 11984, 11985, 12008, 12007, 12657, 12703, 12704, 12701
39859, 11985, 1640, 1641, 12008, 12658, 1664, 12705, 12703
39860, 1594, 11986, 12009, 1595, 12660, 12706, 12707, 1618
39861, 11986, 11987, 12010, 12009, 12662, 12708, 12709, 12706
39862, 11987, 11988, 12011, 12010, 12664, 12710, 12711, 12708
39863, 11988, 11989, 12012, 12011, 12666, 12712, 12713, 12710
39864, 11989, 11990, 12013, 12012, 12668, 12714, 12715, 12712
39865, 11990, 11991, 12014, 12013, 12670, 12716, 12717, 12714
39866, 11991, 11992, 12015, 12014, 12672, 12718, 12719, 12716
39867, 11992, 11993, 12016, 12015, 12674, 12720, 12721, 12718
39868, 11993, 11994, 12017, 12016, 12676, 12722, 12723, 12720
39869, 11994, 11995, 12018, 12017, 12678, 12724, 12725, 12722
39870, 11995, 11996, 12019, 12018, 12680, 12726, 12727, 12724
39871, 11996, 11997, 12020, 12019, 12682, 12728, 12729, 12726
39872, 11997, 11998, 12021, 12020, 12684, 12730, 12731, 12728
39873, 11998, 11999, 12022, 12021, 12686, 12732, 12733, 12730
39874, 11999, 12000, 12023, 12022, 12688, 12734, 12735, 12732
39875, 12000, 12001, 12024, 12023, 12690, 12736, 12737, 12734
39876, 12001, 12002, 12025, 12024, 12692, 12738, 12739, 12736
39877, 12002, 12003, 12026, 12025, 12694, 12740, 12741, 12738
39878, 12003, 12004, 12027, 12026, 12696, 12742, 12743, 12740
39879, 12004, 12005, 12028, 12027, 12698, 12744, 12745, 12742
39880, 12005, 12006, 12029, 12028, 12700, 12746, 12747, 12744
39881, 12006, 12007, 12030, 12029, 12702, 12748, 12749, 12746
39882, 12007, 12008, 12031, 12030, 12704, 12750, 12751, 12748
39883, 12008, 1641, 1642, 12031, 12705, 1665, 12752, 12750
39884, 1595, 12009, 12032, 1596, 12707, 12753, 12754, 1619
39885, 12009, 12010, 12033, 12032, 12709, 12755, 12756, 12753
39886, 12010, 12011, 12034, 12033, 12711, 12757, 12758, 12755
39887, 12011, 12012, 12035, 12034, 12713, 12759, 12760, 12757
39888, 12012, 12013, 12036, 12035, 12715, 12761, 12762, 12759
39889, 12013, 12014, 12037, 12036, 12717, 12763, 12764, 12761
39890, 12014, 12015, 12038, 12037, 12719, 12765, 12766, 12763
39891, 12015, 12016, 12039, 12038, 12721, 12767, 12768, 12765
39892, 12016, 12017, 12040, 12039, 12723, 12769, 12770, 12767
39893, 12017, 12018, 12041, 12040, 12725, 12771, 12772, 12769
39894, 12018, 12019, 12042, 12041, 12727, 12773, 12774, 12771
39895, 12019, 12020, 12043, 12042, 12729, 12775, 12776, 12773
39896, 12020, 12021, 12044, 12043, 12731, 12777, 12778, 12775
39897, 12021, 12022, 12045, 12044, 12733, 12779, 12780, 12777
39898, 12022, 12023, 12046, 12045, 12735, 12781, 12782, 12779
39899, 12023, 12024, 12047, 12046, 12737, 12783, 12784, 12781
39900, 12024, 12025, 12048, 12047, 12739, 12785, 12786, 12783
39901, 12025, 12026, 12049, 12048, 12741, 12787, 12788, 12785
39902, 12026, 12027, 12050, 12049, 12743, 12789, 12790, 12787
39903, 12027, 12028, 12051, 12050, 12745, 12791, 12792, 12789
39904, 12028, 12029, 12052, 12051, 12747, 12793, 12794, 12791
39905, 12029, 12030, 12053, 12052, 12749, 12795, 12796, 12793
39906, 12030, 12031, 12054, 12053, 12751, 12797, 12798, 12795
39907, 12031, 1642, 1643, 12054, 12752, 1666, 12799, 12797
39908, 1596, 12032, 12055, 1597, 12754, 12800, 12801, 1620
39909, 12032, 12033, 12056, 12055, 12756, 12802, 12803, 12800
39910, 12033, 12034, 12057, 12056, 12758, 12804, 12805, 12802
39911, 12034, 12035, 12058, 12057, 12760, 12806, 12807, 12804
39912, 12035, 12036, 12059, 12058, 12762, 12808, 12809, 12806
39913, 12036, 12037, 12060, 12059, 12764, 12810, 12811, 12808
39914, 12037, 12038, 12061, 12060, 12766, 12812, 12813, 12810
39915, 12038, 12039, 12062, 12061, 12768, 12814, 12815, 12812
39916, 12039, 12040, 12063, 12062, 12770, 12816, 12817, 12814
39917, 12040, 12041, 12064, 12063, 12772, 12818, 12819, 12816
39918, 12041, 12042, 12065, 12064, 12774, 12820, 12821, 12818
39919, 12042, 12043, 12066, 12065, 12776, 12822, 12823, 12820
39920, 12043, 12044, 12067, 12066, 12778, 12824, 12825, 12822
39921, 12044, 12045, 12068, 12067, 12780, 12826, 12827, 12824
39922, 12045, 12046, 12069, 12068, 12782, 12828, 12829, 12826
39923, 12046, 12047, 12070, 12069, 12784, 12830, 12831, 12828
39924, 12047, 12048, 12071, 12070, 12786, 12832, 12833, 12830
39925, 12048, 12049, 12072, 12071, 12788, 12834, 12835, 12832
39926, 12049, 12050, 12073, 12072, 12790, 12836, 12837, 12834
39927, 12050, 12051, 12074, 12073, 12792, 12838, 12839, 12836
39928, 12051, 12052, 12075, 12074, 12794, 12840, 12841, 12838
39929, 12052, 12053, 12076, 12075, 12796, 12842, 12843, 12840
39930, 12053, 12054, 12077, 12076, 12798, 12844, 12845, 12842
39931, 12054, 1643, 1644, 12077, 12799, 1667, 12846, 12844
39932, 1597, 12055, 12078, 1598, 12801, 12847, 12848, 1621
39933, 12055, 12056, 12079, 12078, 12803, 12849, 12850, 12847
39934, 12056, 12057, 12080, 12079, 12805, 12851, 12852, 12849
39935, 12057, 12058, 12081, 12080, 12807, 12853, 12854, 12851
39936, 12058, 12059, 12082, 12081, 12809, 12855, 12856, 12853
39937, 12059, 12060, 12083, 12082, 12811, 12857, 12858, 12855
39938, 12060, 12061, 12084, 12083, 12813, 12859, 12860, 12857
39939, 12061, 12062, 12085, 12084, 12815, 12861, 12862, 12859
39940, 12062, 12063, 12086, 12085, 12817, 12863, 12864, 12861
39941, 12063, 12064, 12087, 12086, 12819, 12865, 12866, 12863
39942, 12064, 12065, 12088, 12087, 12821, 12867, 12868, 12865
39943, 12065, 12066, 12089, 12088, 12823, 12869, 12870, 12867
39944, 12066, 12067, 12090, 12089, 12825, 12871, 12872, 12869
39945, 12067, 12068, 12091, 12090, 12827, 12873, 12874, 12871
39946, 12068, 12069, 12092, 12091, 12829, 12875, 12876, 12873
39947, 12069, 12070, 12093, 12092, 12831, 12877, 12878, 12875
39948, 12070, 12071, 12094, 12093, 12833, 12879, 12880, 12877
39949, 12071, 12072, 12095, 12094, 12835, 12881, 12882, 12879
39950, 12072, 12073, 12096, 12095, 12837, 12883, 12884, 12881
39951, 12073, 12074, 12097, 12096, 12839, 12885, 12886, 12883
39952, 12074, 12075, 12098, 12097, 12841, 12887, 12888, 12885
39953, 12075, 12076, 12099, 12098, 12843, 12889, 12890, 12887
39954, 12076, 12077, 12100, 12099, 12845, 12891, 12892, 12889
39955, 12077, 1644, 1645, 12100, 12846, 1668, 12893, 12891
39956, 1598, 12078, 12101, 1599, 12848, 12894, 12895, 1622
39957, 12078, 12079, 12102, 12101, 12850, 12896, 12897, 12894
39958, 12079, 12080, 12103, 12102, 12852, 12898, 12899, 12896
39959, 12080, 12081, 12104, 12103, 12854, 12900, 12901, 12898
39960, 12081, 12082, 12105, 12104, 12856, 12902, 12903, 12900
39961, 12082, 12083, 12106, 12105, 12858, 12904, 12905, 12902
39962, 12083, 12084, 12107, 12106, 12860, 12906, 12907, 12904
39963, 12084, 12085, 12108, 12107, 12862, 12908, 12909, 12906
39964, 12085, 12086, 12109, 12108, 12864, 12910, 12911, 12908
39965, 12086, 12087, 12110, 12109, 12866, 12912, 12913, 12910
39966, 12087, 12088, 12111, 12110, 12868, 12914, 12915, 12912
39967, 12088, 12089, 12112, 12111, 12870, 12916, 12917, 12914
39968, 12089, 12090, 12113, 12112, 12872, 12918, 12919, 12916
39969, 12090, 12091, 12114, 12113, 12874, 12920, 12921, 12918
39970, 12091, 12092, 12115, 12114, 12876, 12922, 12923, 12920
39971, 12092, 12093, 12116, 12115, 12878, 12924, 12925, 12922
39972, 12093, 12094, 12117, 12116, 12880, 12926, 12927, 12924
39973, 12094, 12095, 12118, 12117, 12882, 12928, 12929, 12926
39974, 12095, 12096, 12119, 12118, 12884, 12930, 12931, 12928
39975, 12096, 12097, 12120, 12119, 12886, 12932, 12933, 12930
39976, 12097, 12098, 12121, 12120, 12888, 12934, 12935, 12932
39977, 12098, 12099, 12122, 12121, 12890, 12936, 12937, 12934
39978, 12099, 12100, 12123, 12122, 12892, 12938, 12939, 12936
39979, 12100, 1645, 1646, 12123, 12893, 1669, 12940, 12938
39980, 1599, 12101, 12124, 1600, 12895, 12941, 12942, 1623
39981, 12101, 12102, 12125, 12124, 12897, 12943, 12944, 12941
39982, 12102, 12103, 12126, 12125, 12899, 12945, 12946, 12943
39983, 12103, 12104, 12127, 12126, 12901, 12947, 12948, 12945
39984, 12104, 12105, 12128, 12127, 12903, 12949, 12950, 12947
39985, 12105, 12106, 12129, 12128, 12905, 12951, 12952, 12949
39986, 12106, 12107, 12130, 12129, 12907, 12953, 12954, 12951
39987, 12107, 12108, 12131, 12130, 12909, 12955, 12956, 12953
39988, 12108, 12109, 12132, 12131, 12911, 12957, 12958, 12955
39989, 12109, 12110, 12133, 12132, 12913, 12959, 12960, 12957
39990, 12110, 12111, 12134, 12133, 12915, 12961, 12962, 12959
39991, 12111, 12112, 12135, 12134, 12917, 12963, 12964, 12961
39992, 12112, 12113, 12136, 12135, 12919, 12965, 12966, 12963
39993, 12113, 12114, 12137, 12136, 12921, 12967, 12968, 12965
39994, 12114, 12115, 12138, 12137, 12923, 12969, 12970, 12967
39995, 12115, 12116, 12139, 12138, 12925, 12971, 12972, 12969
39996, 12116, 12117, 12140, 12139, 12927, 12973, 12974, 12971
39997, 12117, 12118, 12141, 12140, 12929, 12975, 12976, 12973
39998, 12118, 12119, 12142, 12141, 12931, 12977, 12978, 12975
39999, 12119, 12120, 12143, 12142, 12933, 12979, 12980, 12977
40000, 12120, 12121, 12144, 12143, 12935, 12981, 12982, 12979
40001, 12121, 12122, 12145, 12144, 12937, 12983, 12984, 12981
40002, 12122, 12123, 12146, 12145, 12939, 12985, 12986, 12983
40003, 12123, 1646, 1647, 12146, 12940, 1670, 12987, 12985
40004, 1600, 12124, 12147, 1601, 12942, 12988, 12989, 1624
40005, 12124, 12125, 12148, 12147, 12944, 12990, 12991, 12988
40006, 12125, 12126, 12149, 12148, 12946, 12992, 12993, 12990
40007, 12126, 12127, 12150, 12149, 12948, 12994, 12995, 12992
40008, 12127, 12128, 12151, 12150, 12950, 12996, 12997, 12994
40009, 12128, 12129, 12152, 12151, 12952, 12998, 12999, 12996
40010, 12129, 12130, 12153, 12152, 12954, 13000, 13001, 12998
40011, 12130, 12131, 12154, 12153, 12956, 13002, 13003, 13000
40012, 12131, 12132, 12155, 12154, 12958, 13004, 13005, 13002
40013, 12132, 12133, 12156, 12155, 12960, 13006, 13007, 13004
40014, 12133, 12134, 12157, 12156, 12962, 13008, 13009, 13006
40015, 12134, 12135, 12158, 12157, 12964, 13010, 13011, 13008
40016, 12135, 12136, 12159, 12158, 12966, 13012, 13013, 13010
40017, 12136, 12137, 12160, 12159, 12968, 13014, 13015, 13012
40018, 12137, 12138, 12161, 12160, 12970, 13016, 13017, 13014
40019, 12138, 12139, 12162, 12161, 12972, 13018, 13019, 13016
40020, 12139, 12140, 12163, 12162, 12974, 13020, 13021, 13018
40021, 12140, 12141, 12164, 12163, 12976, 13022, 13023, 13020
40022, 12141, 12142, 12165, 12164, 12978, 13024, 13025, 13022
40023, 12142, 12143, 12166, 12165, 12980, 13026, 13027, 13024
40024, 12143, 12144, 12167, 12166, 12982, 13028, 13029, 13026
40025, 12144, 12145, 12168, 12167, 12984, 13030, 13031, 13028
40026, 12145, 12146, 12169, 12168, 12986, 13032, 13033, 13030
40027, 12146, 1647, 1648, 12169, 12987, 1671, 13034, 13032
40028, 1601, 12147, 12170, 1602, 12989, 13035, 13036, 1625
40029, 12147, 12148, 12171, 12170, 12991, 13037, 13038, 13035
40030, 12148, 12149, 12172, 12171, 12993, 13039, 13040, 13037
40031, 12149, 12150, 12173, 12172, 12995, 13041, 13042, 13039
40032, 12150, 12151, 12174, 12173, 12997, 13043, 13044, 13041
40033, 12151, 12152, 12175, 12174, 12999, 13045, 13046, 13043
40034, 12152, 12153, 12176, 12175, 13001, 13047, 13048, 13045
40035, 12153, 12154, 12177, 12176, 13003, 13049, 13050, 13047
40036, 12154, 12155, 12178, 12177, 13005, 13051, 13052, 13049
40037, 12155, 12156, 12179, 12178, 13007, 13053, 13054, 13051
40038, 12156, 12157, 12180, 12179, 13009, 13055, 13056, 13053
40039, 12157, 12158, 12181, 12180, 13011, 13057, 13058, 13055
40040, 12158, 12159, 12182, 12181, 13013, 13059, 13060, 13057
40041, 12159, 12160, 12183, 12182, 13015, 13061, 13062, 13059
40042, 12160, 12161, 12184, 12183, 13017, 13063, 13064, 13061
40043, 12161, 12162, 12185, 12184, 13019, 13065, 13066, 13063
40044, 12162, 12163, 12186, 12185, 13021, 13067, 13068, 13065
40045, 12163, 12164, 12187, 12186, 13023, 13069, 13070, 13067
40046, 12164, 12165, 12188, 12187, 13025, 13071, 13072, 13069
40047, 12165, 12166, 12189, 12188, 13027, 13073, 13074, 13071
40048, 12166, 12167, 12190, 12189, 13029, 13075, 13076, 13073
40049, 12167, 12168, 12191, 12190, 13031, 13077, 13078, 13075
40050, 12168, 12169, 12192, 12191, 13033, 13079, 13080, 13077
40051, 12169, 1648, 1649, 12192, 13034, 1672, 13081, 13079
40052, 1602, 12170, 12193, 1603, 13036, 13082, 13083, 1626
40053, 12170, 12171, 12194, 12193, 13038, 13084, 13085, 13082
40054, 12171, 12172, 12195, 12194, 13040, 13086, 13087, 13084
40055, 12172, 12173, 12196, 12195, 13042, 13088, 13089, 13086
40056, 12173, 12174, 12197, 12196, 13044, 13090, 13091, 13088
40057, 12174, 12175, 12198, 12197, 13046, 13092, 13093, 13090
40058, 12175, 12176, 12199, 12198, 13048, 13094, 13095, 13092
40059, 12176, 12177, 12200, 12199, 13050, 13096, 13097, 13094
40060, 12177, 12178, 12201, 12200, 13052, 13098, 13099, 13096
40061, 12178, 12179, 12202, 12201, 13054, 13100, 13101, 13098
40062, 12179, 12180, 12203, 12202, 13056, 13102, 13103, 13100
40063, 12180, 12181, 12204, 12203, 13058, 13104, 13105, 13102
40064, 12181, 12182, 12205, 12204, 13060, 13106, 13107, 13104
40065, 12182, 12183, 12206, 12205, 13062, 13108, 13109, 13106
40066, 12183, 12184, 12207, 12206, 13064, 13110, 13111, 13108
40067, 12184, 12185, 12208, 12207, 13066, 13112, 13113, 13110
40068, 12185, 12186, 12209, 12208, 13068, 13114, 13115, 13112
40069, 12186, 12187, 12210, 12209, 13070, 13116, 13117, 13114
40070, 12187, 12188, 12211, 12210, 13072, 13118, 13119, 13116
40071, 12188, 12189, 12212, 12211, 13074, 13120, 13121, 13118
40072, 12189, 12190, 12213, 12212, 13076, 13122, 13123, 13120
40073, 12190, 12191, 12214, 12213, 13078, 13124, 13125, 13122
40074, 12191, 12192, 12215, 12214, 13080, 13126, 13127, 13124
40075, 12192, 1649, 1650, 12215, 13081, 1673, 13128, 13126
40076, 1603, 12193, 12216, 1604, 13083, 13129, 13130, 1627
40077, 12193, 12194, 12217, 12216, 13085, 13131, 13132, 13129
40078, 12194, 12195, 12218, 12217, 13087, 13133, 13134, 13131
40079, 12195, 12196, 12219, 12218, 13089, 13135, 13136, 13133
40080, 12196, 12197, 12220, 12219, 13091, 13137, 13138, 13135
40081, 12197, 12198, 12221, 12220, 13093, 13139, 13140, 13137
40082, 12198, 12199, 12222, 12221, 13095, 13141, 13142, 13139
40083, 12199, 12200, 12223, 12222, 13097, 13143, 13144, 13141
40084, 12200, 12201, 12224, 12223, 13099, 13145, 13146, 13143
40085, 12201, 12202, 12225, 12224, 13101, 13147, 13148, 13145
40086, 12202, 12203, 12226, 12225, 13103, 13149, 13150, 13147
40087, 12203, 12204, 12227, 12226, 13105, 13151, 13152, 13149
40088, 12204, 12205, 12228, 12227, 13107, 13153, 13154, 13151
40089, 12205, 12206, 12229, 12228, 13109, 13155, 13156, 13153
40090, 12206, 12207, 12230, 12229, 13111, 13157, 13158, 13155
40091, 12207, 12208, 12231, 12230, 13113, 13159, 13160, 13157
40092, 12208, 12209, 12232, 12231, 13115, 13161, 13162, 13159
40093, 12209, 12210, 12233, 12232, 13117, 13163, 13164, 13161
40094, 12210, 12211, 12234, 12233, 13119, 13165, 13166, 13163
40095, 12211, 12212, 12235, 12234, 13121, 13167, 13168, 13165
40096, 12212, 12213, 12236, 12235, 13123, 13169, 13170, 13167
40097, 12213, 12214, 12237, 12236, 13125, 13171, 13172, 13169
40098, 12214, 12215, 12238, 12237, 13127, 13173, 13174, 13171
40099, 12215, 1650, 1651, 12238, 13128, 1674, 13175, 13173
40100, 1604, 12216, 12239, 1605, 13130, 13176, 13177, 1628
40101, 12216, 12217, 12240, 12239, 13132, 13178, 13179, 13176
40102, 12217, 12218, 12241, 12240, 13134, 13180, 13181, 13178
40103, 12218, 12219, 12242, 12241, 13136, 13182, 13183, 13180
40104, 12219, 12220, 12243, 12242, 13138, 13184, 13185, 13182
40105, 12220, 12221, 12244, 12243, 13140, 13186, 13187, 13184
40106, 12221, 12222, 12245, 12244, 13142, 13188, 13189, 13186
40107, 12222, 12223, 12246, 12245, 13144, 13190, 13191, 13188
40108, 12223, 12224, 12247, 12246, 13146, 13192, 13193, 13190
40109, 12224, 12225, 12248, 12247, 13148, 13194, 13195, 13192
40110, 12225, 12226, 12249, 12248, 13150, 13196, 13197, 13194
40111, 12226, 12227, 12250, 12249, 13152, 13198, 13199, 13196
40112, 12227, 12228, 12251, 12250, 13154, 13200, 13201, 13198
40113, 12228, 12229, 12252, 12251, 13156, 13202, 13203, 13200
40114, 12229, 12230, 12253, 12252, 13158, 13204, 13205, 13202
40115, 12230, 12231, 12254, 12253, 13160, 13206, 13207, 13204
40116, 12231, 12232, 12255, 12254, 13162, 13208, 13209, 13206
40117, 12232, 12233, 12256, 12255, 13164, 13210, 13211, 13208
40118, 12233, 12234, 12257, 12256, 13166, 13212, 13213, 13210
40119, 12234, 12235, 12258, 12257, 13168, 13214, 13215, 13212
40120, 12235, 12236, 12259, 12258, 13170, 13216, 13217, 13214
40121, 12236, 12237, 12260, 12259, 13172, 13218, 13219, 13216
40122, 12237, 12238, 12261, 12260, 13174, 13220, 13221, 13218
40123, 12238, 1651, 1652, 12261, 13175, 1675, 13222, 13220
40124, 1605, 12239, 12262, 1606, 13177, 13223, 13224, 1629
40125, 12239, 12240, 12263, 12262, 13179, 13225, 13226, 13223
40126, 12240, 12241, 12264, 12263, 13181, 13227, 13228, 13225
40127, 12241, 12242, 12265, 12264, 13183, 13229, 13230, 13227
40128, 12242, 12243, 12266, 12265, 13185, 13231, 13232, 13229
40129, 12243, 12244, 12267, 12266, 13187, 13233, 13234, 13231
40130, 12244, 12245, 12268, 12267, 13189, 13235, 13236, 13233
40131, 12245, 12246, 12269, 12268, 13191, 13237, 13238, 13235
40132, 12246, 12247, 12270, 12269, 13193, 13239, 13240, 13237
40133, 12247, 12248, 12271, 12270, 13195, 13241, 13242, 13239
40134, 12248, 12249, 12272, 12271, 13197, 13243, 13244, 13241
40135, 12249, 12250, 12273, 12272, 13199, 13245, 13246, 13243
40136, 12250, 12251, 12274, 12273, 13201, 13247, 13248, 13245
40137, 12251, 12252, 12275, 12274, 13203, 13249, 13250, 13247
40138, 12252, 12253, 12276, 12275, 13205, 13251, 13252, 13249
40139, 12253, 12254, 12277, 12276, 13207, 13253, 13254, 13251
40140, 12254, 12255, 12278, 12277, 13209, 13255, 13256, 13253
40141, 12255, 12256, 12279, 12278, 13211, 13257, 13258, 13255
40142, 12256, 12257, 12280, 12279, 13213, 13259, 13260, 13257
40143, 12257, 12258, 12281, 12280, 13215, 13261, 13262, 13259
40144, 12258, 12259, 12282, 12281, 13217, 13263, 13264, 13261
40145, 12259, 12260, 12283, 12282, 13219, 13265, 13266, 13263
40146, 12260, 12261, 12284, 12283, 13221, 13267, 13268, 13265
40147, 12261, 1652, 1653, 12284, 13222, 1676, 13269, 13267
40148, 1606, 12262, 12285, 1607, 13224, 13270, 13271, 1630
40149, 12262, 12263, 12286, 12285, 13226, 13272, 13273, 13270
40150, 12263, 12264, 12287, 12286, 13228, 13274, 13275, 13272
40151, 12264, 12265, 12288, 12287, 13230, 13276, 13277, 13274
40152, 12265, 12266, 12289, 12288, 13232, 13278, 13279, 13276
40153, 12266, 12267, 12290, 12289, 13234, 13280, 13281, 13278
40154, 12267, 12268, 12291, 12290, 13236, 13282, 13283, 13280
40155, 12268, 12269, 12292, 12291, 13238, 13284, 13285, 13282
40156, 12269, 12270, 12293, 12292, 13240, 13286, 13287, 13284
40157, 12270, 12271, 12294, 12293, 13242, 13288, 13289, 13286
40158, 12271, 12272, 12295, 12294, 13244, 13290, 13291, 13288
40159, 12272, 12273, 12296, 12295, 13246, 13292, 13293, 13290
40160, 12273, 12274, 12297, 12296, 13248, 13294, 13295, 13292
40161, 12274, 12275, 12298, 12297, 13250, 13296, 13297, 13294
40162, 12275, 12276, 12299, 12298, 13252, 13298, 13299, 13296
40163, 12276, 12277, 12300, 12299, 13254, 13300, 13301, 13298
40164, 12277, 12278, 12301, 12300, 13256, 13302, 13303, 13300
40165, 12278, 12279, 12302, 12301, 13258, 13304, 13305, 13302
40166, 12279, 12280, 12303, 12302, 13260, 13306, 13307, 13304
40167, 12280, 12281, 12304, 12303, 13262, 13308, 13309, 13306
40168, 12281, 12282, 12305, 12304, 13264, 13310, 13311, 13308
40169, 12282, 12283, 12306, 12305, 13266, 13312, 13313, 13310
40170, 12283, 12284, 12307, 12306, 13268, 13314, 13315, 13312
40171, 12284, 1653, 1654, 12307, 13269, 1677, 13316, 13314
40172, 1607, 12285, 12308, 1608, 13271, 13317, 13318, 1631
40173, 12285, 12286, 12309, 12308, 13273, 13319, 13320, 13317
40174, 12286, 12287, 12310, 12309, 13275, 13321, 13322, 13319
40175, 12287, 12288, 12311, 12310, 13277, 13323, 13324, 13321
40176, 12288, 12289, 12312, 12311, 13279, 13325, 13326, 13323
40177, 12289, 12290, 12313, 12312, 13281, 13327, 13328, 13325
40178, 12290, 12291, 12314, 12313, 13283, 13329, 13330, 13327
40179, 12291, 12292, 12315, 12314, 13285, 13331, 13332, 13329
40180, 12292, 12293, 12316, 12315, 13287, 13333, 13334, 13331
40181, 12293, 12294, 12317, 12316, 13289, 13335, 13336, 13333
40182, 12294, 12295, 12318, 12317, 13291, 13337, 13338, 13335
40183, 12295, 12296, 12319, 12318, 13293, 13339, 13340, 13337
40184, 12296, 12297, 12320, 12319, 13295, 13341, 13342, 13339
40185, 12297, 12298, 12321, 12320, 13297, 13343, 13344, 13341
40186, 12298, 12299, 12322, 12321, 13299, 13345, 13346, 13343
40187, 12299, 12300, 12323, 12322, 13301, 13347, 13348, 13345
40188, 12300, 12301, 12324, 12323, 13303, 13349, 13350, 13347
40189, 12301, 12302, 12325, 12324, 13305, 13351, 13352, 13349
40190, 12302, 12303, 12326, 12325, 13307, 13353, 13354, 13351
40191, 12303, 12304, 12327, 12326, 13309, 13355, 13356, 13353
40192, 12304, 12305, 12328, 12327, 13311, 13357, 13358, 13355
40193, 12305, 12306, 12329, 12328, 13313, 13359, 13360, 13357
40194, 12306, 12307, 12330, 12329, 13315, 13361, 13362, 13359
40195, 12307, 1654, 1655, 12330, 13316, 1678, 13363, 13361
40196, 1608, 12308, 12331, 1609, 13318, 13364, 13365, 1632
40197, 12308, 12309, 12332, 12331, 13320, 13366, 13367, 13364
40198, 12309, 12310, 12333, 12332, 13322, 13368, 13369, 13366
40199, 12310, 12311, 12334, 12333, 13324, 13370, 13371, 13368
40200, 12311, 12312, 12335, 12334, 13326, 13372, 13373, 13370
40201, 12312, 12313, 12336, 12335, 13328, 13374, 13375, 13372
40202, 12313, 12314, 12337, 12336, 13330, 13376, 13377, 13374
40203, 12314, 12315, 12338, 12337, 13332, 13378, 13379, 13376
40204, 12315, 12316, 12339, 12338, 13334, 13380, 13381, 13378
40205, 12316, 12317, 12340, 12339, 13336, 13382, 13383, 13380
40206, 12317, 12318, 12341, 12340, 13338, 13384, 13385, 13382
40207, 12318, 12319, 12342, 12341, 13340, 13386, 13387, 13384
40208, 12319, 12320, 12343, 12342, 13342, 13388, 13389, 13386
40209, 12320, 12321, 12344, 12343, 13344, 13390, 13391, 13388
40210, 12321, 12322, 12345, 12344, 13346, 13392, 13393, 13390
40211, 12322, 12323, 12346, 12345, 13348, 13394, 13395, 13392
40212, 12323, 12324, 12347, 12346, 13350, 13396, 13397, 13394
40213, 12324, 12325, 12348, 12347, 13352, 13398, 13399, 13396
40214, 12325, 12326, 12349, 12348, 13354, 13400, 13401, 13398
40215, 12326, 12327, 12350, 12349, 13356, 13402, 13403, 13400
40216, 12327, 12328, 12351, 12350, 13358, 13404, 13405, 13402
40217, 12328, 12329, 12352, 12351, 13360, 13406, 13407, 13404
40218, 12329, 12330, 12353, 12352, 13362, 13408, 13409, 13406
40219, 12330, 1655, 1656, 12353, 13363, 1679, 13410, 13408
40220, 1609, 12331, 12354, 1610, 13365, 13411, 13412, 1633
40221, 12331, 12332, 12355, 12354, 13367, 13413, 13414, 13411
40222, 12332, 12333, 12356, 12355, 13369, 13415, 13416, 13413
40223, 12333, 12334, 12357, 12356, 13371, 13417, 13418, 13415
40224, 12334, 12335, 12358, 12357, 13373, 13419, 13420, 13417
40225, 12335, 12336, 12359, 12358, 13375, 13421, 13422, 13419
40226, 12336, 12337, 12360, 12359, 13377, 13423, 13424, 13421
40227, 12337, 12338, 12361, 12360, 13379, 13425, 13426, 13423
40228, 12338, 12339, 12362, 12361, 13381, 13427, 13428, 13425
40229, 12339, 12340, 12363, 12362, 13383, 13429, 13430, 13427
40230, 12340, 12341, 12364, 12363, 13385, 13431, 13432, 13429
40231, 12341, 12342, 12365, 12364, 13387, 13433, 13434, 13431
40232, 12342, 12343, 12366, 12365, 13389, 13435, 13436, 13433
40233, 12343, 12344, 12367, 12366, 13391, 13437, 13438, 13435
40234, 12344, 12345, 12368, 12367, 13393, 13439, 13440, 13437
40235, 12345, 12346, 12369, 12368, 13395, 13441, 13442, 13439
40236, 12346, 12347, 12370, 12369, 13397, 13443, 13444, 13441
40237, 12347, 12348, 12371, 12370, 13399, 13445, 13446, 13443
40238, 12348, 12349, 12372, 12371, 13401, 13447, 13448, 13445
40239, 12349, 12350, 12373, 12372, 13403, 13449, 13450, 13447
40240, 12350, 12351, 12374, 12373, 13405, 13451, 13452, 13449
40241, 12351, 12352, 12375, 12374, 13407, 13453, 13454, 13451
40242, 12352, 12353, 12376, 12375, 13409, 13455, 13456, 13453
40243, 12353, 1656, 1657, 12376, 13410, 1680, 13457, 13455
40244, 1610, 12354, 1492, 65, 13412, 13458, 1515, 1634
40245, 12354, 12355, 1493, 1492, 13414, 13459, 1516, 13458
40246, 12355, 12356, 1494, 1493, 13416, 13460, 1517, 13459
40247, 12356, 12357, 1495, 1494, 13418, 13461, 1518, 13460
40248, 12357, 12358, 1496, 1495, 13420, 13462, 1519, 13461
40249, 12358, 12359, 1497, 1496, 13422, 13463, 1520, 13462
40250, 12359, 12360, 1498, 1497, 13424, 13464, 1521, 13463
40251, 12360, 12361, 1499, 1498, 13426, 13465, 1522, 13464
40252, 12361, 12362, 1500, 1499, 13428, 13466, 1523, 13465
40253, 12362, 12363, 1501, 1500, 13430, 13467, 1524, 13466
40254, 12363, 12364, 1502, 1501, 13432, 13468, 1525, 13467
40255, 12364, 12365, 1503, 1502, 13434, 13469, 1526, 13468
40256, 12365, 12366, 1504, 1503, 13436, 13470, 1527, 13469
40257, 12366, 12367, 1505, 1504, 13438, 13471, 1528, 13470
40258, 12367, 12368, 1506, 1505, 13440, 13472, 1529, 13471
40259, 12368, 12369, 1507, 1506, 13442, 13473, 1530, 13472
40260, 12369, 12370, 1508, 1507, 13444, 13474, 1531, 13473
40261, 12370, 12371, 1509, 1508, 13446, 13475, 1532, 13474
40262, 12371, 12372, 1510, 1509, 13448, 13476, 1533, 13475
40263, 12372, 12373, 1511, 1510, 13450, 13477, 1534, 13476
40264, 12373, 12374, 1512, 1511, 13452, 13478, 1535, 13477
40265, 12374, 12375, 1513, 1512, 13454, 13479, 1536, 13478
40266, 12375, 12376, 1514, 1513, 13456, 13480, 1537, 13479
40267, 12376, 1657, 66, 1514, 13457, 1681, 1538, 13480
*ELEMENT, type=CPS8, ELSET=Surface92
40268, 35, 69, 1684, 911, 1682, 1707, 13481, 0
40269, 911, 1684, 1685, 912, 13481, 1708, 13482, 0
40270, 912, 1685, 1686, 913, 13482, 1709, 13483, 0
40271, 913, 1686, 1687, 914, 13483, 1710, 13484, 0
40272, 914, 1687, 1688, 915, 13484, 1711, 13485, 0
40273, 915, 1688, 1689, 916, 13485, 1712, 13486, 0
40274, 916, 1689, 1690, 917, 13486, 1713, 13487, 0
40275, 917, 1690, 1691, 918, 13487, 1714, 13488, 0
40276, 918, 1691, 1692, 919, 13488, 1715, 13489, 0
40277, 919, 1692, 1693, 920, 13489, 1716, 13490, 0
40278, 920, 1693, 1694, 921, 13490, 1717, 13491, 0
40279, 921, 1694, 1695, 922, 13491, 1718, 13492, 0
40280, 922, 1695, 1696, 923, 13492, 1719, 13493, 0
40281, 923, 1696, 1697, 924, 13493, 1720, 13494, 0
40282, 924, 1697, 1698, 925, 13494, 1721, 13495, 0
40283, 925, 1698, 1699, 926, 13495, 1722, 13496, 0
40284, 926, 1699, 1700, 927, 13496, 1723, 13497, 0
40285, 927, 1700, 1701, 928, 13497, 1724, 13498, 0
40286, 928, 1701, 1702, 929, 13498, 1725, 13499, 0
40287, 929, 1702, 1703, 930, 13499, 1726, 13500, 0
40288, 930, 1703, 1704, 931, 13500, 1727, 13501, 0
40289, 931, 1704, 1705, 932, 13501, 1728, 13502, 0
40290, 932, 1705, 1706, 933, 13502, 1729, 13503, 0
40291, 933, 1706, 70, 39, 13503, 1730, 1683, 0
*ELEMENT, type=CPS8, ELSET=Surface93
40292, 36, 934, 1733, 71, 0, 13504, 1756, 1731
40293, 934, 935, 1734, 1733, 0, 13505, 1757, 13504
40294, 935, 936, 1735, 1734, 0, 13506, 1758, 13505
40295, 936, 937, 1736, 1735, 0, 13507, 1759, 13506
40296, 937, 938, 1737, 1736, 0, 13508, 1760, 13507
40297, 938, 939, 1738, 1737, 0, 13509, 1761, 13508
40298, 939, 940, 1739, 1738, 0, 13510, 1762, 13509
40299, 940, 941, 1740, 1739, 0, 13511, 1763, 13510
40300, 941, 942, 1741, 1740, 0, 13512, 1764, 13511
40301, 942, 943, 1742, 1741, 0, 13513, 1765, 13512
40302, 943, 944, 1743, 1742, 0, 13514, 1766, 13513
40303, 944, 945, 1744, 1743, 0, 13515, 1767, 13514
40304, 945, 946, 1745, 1744, 0, 13516, 1768, 13515
40305, 946, 947, 1746, 1745, 0, 13517, 1769, 13516
40306, 947, 948, 1747, 1746, 0, 13518, 1770, 13517
40307, 948, 949, 1748, 1747, 0, 13519, 1771, 13518
40308, 949, 950, 1749, 1748, 0, 13520, 1772, 13519
40309, 950, 951, 1750, 1749, 0, 13521, 1773, 13520
40310, 951, 952, 1751, 1750, 0, 13522, 1774, 13521
40311, 952, 953, 1752, 1751, 0, 13523, 1775, 13522
40312, 953, 954, 1753, 1752, 0, 13524, 1776, 13523
40313, 954, 955, 1754, 1753, 0, 13525, 1777, 13524
40314, 955, 956, 1755, 1754, 0, 13526, 1778, 13525
40315, 956, 40, 72, 1755, 0, 1732, 1779, 13526
*ELEMENT, type=CPS8, ELSET=Surface94
40316, 35, 797, 1780, 69, 0, 13527, 1803, 1682
40317, 797, 798, 1781, 1780, 0, 13528, 1804, 13527
40318, 798, 799, 1782, 1781, 0, 13529, 1805, 13528
40319, 799, 800, 1783, 1782, 0, 13530, 1806, 13529
40320, 800, 801, 1784, 1783, 0, 13531, 1807, 13530
40321, 801, 802, 1785, 1784, 0, 13532, 1808, 13531
40322, 802, 803, 1786, 1785, 0, 13533, 1809, 13532
40323, 803, 804, 1787, 1786, 0, 13534, 1810, 13533
40324, 804, 805, 1788, 1787, 0, 13535, 1811, 13534
40325, 805, 806, 1789, 1788, 0, 13536, 1812, 13535
40326, 806, 807, 1790, 1789, 0, 13537, 1813, 13536
40327, 807, 808, 1791, 1790, 0, 13538, 1814, 13537
40328, 808, 809, 1792, 1791, 0, 13539, 1815, 13538
40329, 809, 810, 1793, 1792, 0, 13540, 1816, 13539
40330, 810, 811, 1794, 1793, 0, 13541, 1817, 13540
40331, 811, 812, 1795, 1794, 0, 13542, 1818, 13541
40332, 812, 813, 1796, 1795, 0, 13543, 1819, 13542
40333, 813, 814, 1797, 1796, 0, 13544, 1820, 13543
40334, 814, 815, 1798, 1797, 0, 13545, 1821, 13544
40335, 815, 816, 1799, 1798, 0, 13546, 1822, 13545
40336, 816, 817, 1800, 1799, 0, 13547, 1823, 13546
40337, 817, 818, 1801, 1800, 0, 13548, 1824, 13547
40338, 818, 819, 1802, 1801, 0, 13549, 1825, 13548
40339, 819, 36, 71, 1802, 0, 1731, 1826, 13549
*ELEMENT, type=CPS8, ELSET=Surface95
40340, 39, 70, 1827, 957, 1683, 1850, 13550, 0
40341, 957, 1827, 1828, 958, 13550, 1851, 13551, 0
40342, 958, 1828, 1829, 959, 13551, 1852, 13552, 0
40343, 959, 1829, 1830, 960, 13552, 1853, 13553, 0
40344, 960, 1830, 1831, 961, 13553, 1854, 13554, 0
40345, 961, 1831, 1832, 962, 13554, 1855, 13555, 0
40346, 962, 1832, 1833, 963, 13555, 1856, 13556, 0
40347, 963, 1833, 1834, 964, 13556, 1857, 13557, 0
40348, 964, 1834, 1835, 965, 13557, 1858, 13558, 0
40349, 965, 1835, 1836, 966, 13558, 1859, 13559, 0
40350, 966, 1836, 1837, 967, 13559, 1860, 13560, 0
40351, 967, 1837, 1838, 968, 13560, 1861, 13561, 0
40352, 968, 1838, 1839, 969, 13561, 1862, 13562, 0
40353, 969, 1839, 1840, 970, 13562, 1863, 13563, 0
40354, 970, 1840, 1841, 971, 13563, 1864, 13564, 0
40355, 971, 1841, 1842, 972, 13564, 1865, 13565, 0
40356, 972, 1842, 1843, 973, 13565, 1866, 13566, 0
40357, 973, 1843, 1844, 974, 13566, 1867, 13567, 0
40358, 974, 1844, 1845, 975, 13567, 1868, 13568, 0
40359, 975, 1845, 1846, 976, 13568, 1869, 13569, 0
40360, 976, 1846, 1847, 977, 13569, 1870, 13570, 0
40361, 977, 1847, 1848, 978, 13570, 1871, 13571, 0
40362, 978, 1848, 1849, 979, 13571, 1872, 13572, 0
40363, 979, 1849, 72, 40, 13572, 1873, 1732, 0
*ELEMENT, type=CPS8, ELSET=Surface96
40364, 69, 1780, 13573, 1684, 1803, 14102, 14103, 1707
40365, 1684, 13573, 13574, 1685, 14103, 14104, 14105, 1708
40366, 1685, 13574, 13575, 1686, 14105, 14106, 14107, 1709
40367, 1686, 13575, 13576, 1687, 14107, 14108, 14109, 1710
40368, 1687, 13576, 13577, 1688, 14109, 14110, 14111, 1711
40369, 1688, 13577, 13578, 1689, 14111, 14112, 14113, 1712
40370, 1689, 13578, 13579, 1690, 14113, 14114, 14115, 1713
40371, 1690, 13579, 13580, 1691, 14115, 14116, 14117, 1714
40372, 1691, 13580, 13581, 1692, 14117, 14118, 14119, 1715
40373, 1692, 13581, 13582, 1693, 14119, 14120, 14121, 1716
40374, 1693, 13582, 13583, 1694, 14121, 14122, 14123, 1717
40375, 1694, 13583, 13584, 1695, 14123, 14124, 14125, 1718
40376, 1695, 13584, 13585, 1696, 14125, 14126, 14127, 1719
40377, 1696, 13585, 13586, 1697, 14127, 14128, 14129, 1720
40378, 1697, 13586, 13587, 1698, 14129, 14130, 14131, 1721
40379, 1698, 13587, 13588, 1699, 14131, 14132, 14133, 1722
40380, 1699, 13588, 13589, 1700, 14133, 14134, 14135, 1723
40381, 1700, 13589, 13590, 1701, 14135, 14136, 14137, 1724
40382, 1701, 13590, 13591, 1702, 14137, 14138, 14139, 1725
40383, 1702, 13591, 13592, 1703, 14139, 14140, 14141, 1726
40384, 1703, 13592, 13593, 1704, 14141, 14142, 14143, 1727
40385, 1704, 13593, 13594, 1705, 14143, 14144, 14145, 1728
40386, 1705, 13594, 13595, 1706, 14145, 14146, 14147, 1729
40387, 1706, 13595, 1827, 70, 14147, 14148, 1850, 1730
40388, 1780, 1781, 13596, 13573, 1804, 14149, 14150, 14102
40389, 13573, 13596, 13597, 13574, 14150, 14151, 14152, 14104
40390, 13574, 13597, 13598, 13575, 14152, 14153, 14154, 14106
40391, 13575, 13598, 13599, 13576, 14154, 14155, 14156, 14108
40392, 13576, 13599, 13600, 13577, 14156, 14157, 14158, 14110
40393, 13577, 13600, 13601, 13578, 14158, 14159, 14160, 14112
40394, 13578, 13601, 13602, 13579, 14160, 14161, 14162, 14114
40395, 13579, 13602, 13603, 13580, 14162, 14163, 14164, 14116
40396, 13580, 13603, 13604, 13581, 14164, 14165, 14166, 14118
40397, 13581, 13604, 13605, 13582, 14166, 14167, 14168, 14120
40398, 13582, 13605, 13606, 13583, 14168, 14169, 14170, 14122
40399, 13583, 13606, 13607, 13584, 14170, 14171, 14172, 14124
40400, 13584, 13607, 13608, 13585, 14172, 14173, 14174, 14126
40401, 13585, 13608, 13609, 13586, 14174, 14175, 14176, 14128
40402, 13586, 13609, 13610, 13587, 14176, 14177, 14178, 14130
40403, 13587, 13610, 13611, 13588, 14178, 14179, 14180, 14132
40404, 13588, 13611, 13612, 13589, 14180, 14181, 14182, 14134
40405, 13589, 13612, 13613, 13590, 14182, 14183, 14184, 14136
40406, 13590, 13613, 13614, 13591, 14184, 14185, 14186, 14138
40407, 13591, 13614, 13615, 13592, 14186, 14187, 14188, 14140
40408, 13592, 13615, 13616, 13593, 14188, 14189, 14190, 14142
40409, 13593, 13616, 13617, 13594, 14190, 14191, 14192, 14144
40410, 13594, 13617, 13618, 13595, 14192, 14193, 14194, 14146
40411, 13595, 13618, 1828, 1827, 14194, 14195, 1851, 14148
40412, 1781, 1782, 13619, 13596, 1805, 14196, 14197, 14149
40413, 13596, 13619, 13620, 13597, 14197, 14198, 14199, 14151
40414, 13597, 13620, 13621, 13598, 14199, 14200, 14201, 14153
40415, 13598, 13621, 13622, 13599, 14201, 14202, 14203, 14155
40416, 13599, 13622, 13623, 13600, 14203, 14204, 14205, 14157
40417, 13600, 13623, 13624, 13601, 14205, 14206, 14207, 14159
40418, 13601, 13624, 13625, 13602, 14207, 14208, 14209, 14161
40419, 13602, 13625, 13626, 13603, 14209, 14210, 14211, 14163
40420, 13603, 13626, 13627, 13604, 14211, 14212, 14213, 14165
40421, 13604, 13627, 13628, 13605, 14213, 14214, 14215, 14167
40422, 13605, 13628, 13629, 13606, 14215, 14216, 14217, 14169
40423, 13606, 13629, 13630, 13607, 14217, 14218, 14219, 14171
40424, 13607, 13630, 13631, 13608, 14219, 14220, 14221, 14173
40425, 13608, 13631, 13632, 13609, 14221, 14222, 14223, 14175
40426, 13609, 13632, 13633, 13610, 14223, 14224, 14225, 14177
40427, 13610, 13633, 13634, 13611, 14225, 14226, 14227, 14179
40428, 13611, 13634, 13635, 13612, 14227, 14228, 14229, 14181
40429, 13612, 13635, 13636, 13613, 14229, 14230, 14231, 14183
40430, 13613, 13636, 13637, 13614, 14231, 14232, 14233, 14185
40431, 13614, 13637, 13638, 13615, 14233, 14234, 14235, 14187
40432, 13615, 13638, 13639, 13616, 14235, 14236, 14237, 14189
40433, 13616, 13639, 13640, 13617, 14237, 14238, 14239, 14191
40434, 13617, 13640, 13641, 13618, 14239, 14240, 14241, 14193
40435, 13618, 13641, 1829, 1828, 14241, 14242, 1852, 14195
40436, 1782, 1783, 13642, 13619, 1806, 14243, 14244, 14196
40437, 13619, 13642, 13643, 13620, 14244, 14245, 14246, 14198
40438, 13620, 13643, 13644, 13621, 14246, 14247, 14248, 14200
40439, 13621, 13644, 13645, 13622, 14248, 14249, 14250, 14202
40440, 13622, 13645, 13646, 13623, 14250, 14251, 14252, 14204
40441, 13623, 13646, 13647, 13624, 14252, 14253, 14254, 14206
40442, 13624, 13647, 13648, 13625, 14254, 14255, 14256, 14208
40443, 13625, 13648, 13649, 13626, 14256, 14257, 14258, 14210
40444, 13626, 13649, 13650, 13627, 14258, 14259, 14260, 14212
40445, 13627, 13650, 13651, 13628, 14260, 14261, 14262, 14214
40446, 13628, 13651, 13652, 13629, 14262, 14263, 14264, 14216
40447, 13629, 13652, 13653, 13630, 14264, 14265, 14266, 14218
40448, 13630, 13653, 13654, 13631, 14266, 14267, 14268, 14220
40449, 13631, 13654, 13655, 13632, 14268, 14269, 14270, 14222
40450, 13632, 13655, 13656, 13633, 14270, 14271, 14272, 14224
40451, 13633, 13656, 13657, 13634, 14272, 14273, 14274, 14226
40452, 13634, 13657, 13658, 13635, 14274, 14275, 14276, 14228
40453, 13635, 13658, 13659, 13636, 14276, 14277, 14278, 14230
40454, 13636, 13659, 13660, 13637, 14278, 14279, 14280, 14232
40455, 13637, 13660, 13661, 13638, 14280, 14281, 14282, 14234
40456, 13638, 13661, 13662, 13639, 14282, 14283, 14284, 14236
40457, 13639, 13662, 13663, 13640, 14284, 14285, 14286, 14238
40458, 13640, 13663, 13664, 13641, 14286, 14287, 14288, 14240
40459, 13641, 13664, 1830, 1829, 14288, 14289, 1853, 14242
40460, 1783, 1784, 13665, 13642, 1807, 14290, 14291, 14243
40461, 13642, 13665, 13666, 13643, 14291, 14292, 14293, 14245
40462, 13643, 13666, 13667, 13644, 14293, 14294, 14295, 14247
40463, 13644, 13667, 13668, 13645, 14295, 14296, 14297, 14249
40464, 13645, 13668, 13669, 13646, 14297, 14298, 14299, 14251
40465, 13646, 13669, 13670, 13647, 14299, 14300, 14301, 14253
40466, 13647, 13670, 13671, 13648, 14301, 14302, 14303, 14255
40467, 13648, 13671, 13672, 13649, 14303, 14304, 14305, 14257
40468, 13649, 13672, 13673, 13650, 14305, 14306, 14307, 14259
40469, 13650, 13673, 13674, 13651, 14307, 14308, 14309, 14261
40470, 13651, 13674, 13675, 13652, 14309, 14310, 14311, 14263
40471, 13652, 13675, 13676, 13653, 14311, 14312, 14313, 14265
40472, 13653, 13676, 13677, 13654, 14313, 14314, 14315, 14267
40473, 13654, 13677, 13678, 13655, 14315, 14316, 14317, 14269
40474, 13655, 13678, 13679, 13656, 14317, 14318, 14319, 14271
40475, 13656, 13679, 13680, 13657, 14319, 14320, 14321, 14273
40476, 13657, 13680, 13681, 13658, 14321, 14322, 14323, 14275
40477, 13658, 13681, 13682, 13659, 14323, 14324, 14325, 14277
40478, 13659, 13682, 13683, 13660, 14325, 14326, 14327, 14279
40479, 13660, 13683, 13684, 13661, 14327, 14328, 14329, 14281
40480, 13661, 13684, 13685, 13662, 14329, 14330, 14331, 14283
40481, 13662, 13685, 13686, 13663, 14331, 14332, 14333, 14285
40482, 13663, 13686, 13687, 13664, 14333, 14334, 14335, 14287
40483, 13664, 13687, 1831, 1830, 14335, 14336, 1854, 14289
40484, 1784, 1785, 13688, 13665, 1808, 14337, 14338, 14290
40485, 13665, 13688, 13689, 13666, 14338, 14339, 14340, 14292
40486, 13666, 13689, 13690, 13667, 14340, 14341, 14342, 14294
40487, 13667, 13690, 13691, 13668, 14342, 14343, 14344, 14296
40488, 13668, 13691, 13692, 13669, 14344, 14345, 14346, 14298
40489, 13669, 13692, 13693, 13670, 14346, 14347, 14348, 14300
40490, 13670, 13693, 13694, 13671, 14348, 14349, 14350, 14302
40491, 13671, 13694, 13695, 13672, 14350, 14351, 14352, 14304
40492, 13672, 13695, 13696, 13673, 14352, 14353, 14354, 14306
40493, 13673, 13696, 13697, 13674, 14354, 14355, 14356, 14308
40494, 13674, 13697, 13698, 13675, 14356, 14357, 14358, 14310
40495, 13675, 13698, 13699, 13676, 14358, 14359, 14360, 14312
40496, 13676, 13699, 13700, 13677, 14360, 14361, 14362, 14314
40497, 13677, 13700, 13701, 13678, 14362, 14363, 14364, 14316
40498, 13678, 13701, 13702, 13679, 14364, 14365, 14366, 14318
40499, 13679, 13702, 13703, 13680, 14366, 14367, 14368, 14320
40500, 13680, 13703, 13704, 13681, 14368, 14369, 14370, 14322
40501, 13681, 13704, 13705, 13682, 14370, 14371, 14372, 14324
40502, 13682, 13705, 13706, 13683, 14372, 14373, 14374, 14326
40503, 13683, 13706, 13707, 13684, 14374, 14375, 14376, 14328
40504, 13684, 13707, 13708, 13685, 14376, 14377, 14378, 14330
40505, 13685, 13708, 13709, 13686, 14378, 14379, 14380, 14332
40506, 13686, 13709, 13710, 13687, 14380, 14381, 14382, 14334
40507, 13687, 13710, 1832, 1831, 14382, 14383, 1855, 14336
40508, 1785, 1786, 13711, 13688, 1809, 14384, 14385, 14337
40509, 13688, 13711, 13712, 13689, 14385, 14386, 14387, 14339
40510, 13689, 13712, 13713, 13690, 14387, 14388, 14389, 14341
40511, 13690, 13713, 13714, 13691, 14389, 14390, 14391, 14343
40512, 13691, 13714, 13715, 13692, 14391, 14392, 14393, 14345
40513, 13692, 13715, 13716, 13693, 14393, 14394, 14395, 14347
40514, 13693, 13716, 13717, 13694, 14395, 14396, 14397, 14349
40515, 13694, 13717, 13718, 13695, 14397, 14398, 14399, 14351
40516, 13695, 13718, 13719, 13696, 14399, 14400, 14401, 14353
40517, 13696, 13719, 13720, 13697, 14401, 14402, 14403, 14355
40518, 13697, 13720, 13721, 13698, 14403, 14404, 14405, 14357
40519, 13698, 13721, 13722, 13699, 14405, 14406, 14407, 14359
40520, 13699, 13722, 13723, 13700, 14407, 14408, 14409, 14361
40521, 13700, 13723, 13724, 13701, 14409, 14410, 14411, 14363
40522, 13701, 13724, 13725, 13702, 14411, 14412, 14413, 14365
40523, 13702, 13725, 13726, 13703, 14413, 14414, 14415, 14367
40524, 13703, 13726, 13727, 13704, 14415, 14416, 14417, 14369
40525, 13704, 13727, 13728, 13705, 14417, 14418, 14419, 14371
40526, 13705, 13728, 13729, 13706, 14419, 14420, 14421, 14373
40527, 13706, 13729, 13730, 13707, 14421, 14422, 14423, 14375
40528, 13707, 13730, 13731, 13708, 14423, 14424, 14425, 14377
40529, 13708, 13731, 13732, 13709, 14425, 14426, 14427, 14379
40530, 13709, 13732, 13733, 13710, 14427, 14428, 14429, 14381
40531, 13710, 13733, 1833, 1832, 14429, 14430, 1856, 14383
40532, 1786, 1787, 13734, 13711, 1810, 14431, 14432, 14384
40533, 13711, 13734, 13735, 13712, 14432, 14433, 14434, 14386
40534, 13712, 13735, 13736, 13713, 14434, 14435, 14436, 14388
40535, 13713, 13736, 13737, 13714, 14436, 14437, 14438, 14390
40536, 13714, 13737, 13738, 13715, 14438, 14439, 14440, 14392
40537, 13715, 13738, 13739, 13716, 14440, 14441, 14442, 14394
40538, 13716, 13739, 13740, 13717, 14442, 14443, 14444, 14396
40539, 13717, 13740, 13741, 13718, 14444, 14445, 14446, 14398
40540, 13718, 13741, 13742, 13719, 14446, 14447, 14448, 14400
40541, 13719, 13742, 13743, 13720, 14448, 14449, 14450, 14402
40542, 13720, 13743, 13744, 13721, 14450, 14451, 14452, 14404
40543, 13721, 13744, 13745, 13722, 14452, 14453, 14454, 14406
40544, 13722, 13745, 13746, 13723, 14454, 14455, 14456, 14408
40545, 13723, 13746, 13747, 13724, 14456, 14457, 14458, 14410
40546, 13724, 13747, 13748, 13725, 14458, 14459, 14460, 14412
40547, 13725, 13748, 13749, 13726, 14460, 14461, 14462, 14414
40548, 13726, 13749, 13750, 13727, 14462, 14463, 14464, 14416
40549, 13727, 13750, 13751, 13728, 14464, 14465, 14466, 14418
40550, 13728, 13751, 13752, 13729, 14466, 14467, 14468, 14420
40551, 13729, 13752, 13753, 13730, 14468, 14469, 14470, 14422
40552, 13730, 13753, 13754, 13731, 14470, 14471, 14472, 14424
40553, 13731, 13754, 13755, 13732, 14472, 14473, 14474, 14426
40554, 13732, 13755, 13756, 13733, 14474, 14475, 14476, 14428
40555, 13733, 13756, 1834, 1833, 14476, 14477, 1857, 14430
40556, 1787, 1788, 13757, 13734, 1811, 14478, 14479, 14431
40557, 13734, 13757, 13758, 13735, 14479, 14480, 14481, 14433
40558, 13735, 13758, 13759, 13736, 14481, 14482, 14483, 14435
40559, 13736, 13759, 13760, 13737, 14483, 14484, 14485, 14437
40560, 13737, 13760, 13761, 13738, 14485, 14486, 14487, 14439
40561, 13738, 13761, 13762, 13739, 14487, 14488, 14489, 14441
40562, 13739, 13762, 13763, 13740, 14489, 14490, 14491, 14443
40563, 13740, 13763, 13764, 13741, 14491, 14492, 14493, 14445
40564, 13741, 13764, 13765, 13742, 14493, 14494, 14495, 14447
40565, 13742, 13765, 13766, 13743, 14495, 14496, 14497, 14449
40566, 13743, 13766, 13767, 13744, 14497, 14498, 14499, 14451
40567, 13744, 13767, 13768, 13745, 14499, 14500, 14501, 14453
40568, 13745, 13768, 13769, 13746, 14501, 14502, 14503, 14455
40569, 13746, 13769, 13770, 13747, 14503, 14504, 14505, 14457
40570, 13747, 13770, 13771, 13748, 14505, 14506, 14507, 14459
40571, 13748, 13771, 13772, 13749, 14507, 14508, 14509, 14461
40572, 13749, 13772, 13773, 13750, 14509, 14510, 14511, 14463
40573, 13750, 13773, 13774, 13751, 14511, 14512, 14513, 14465
40574, 13751, 13774, 13775, 13752, 14513, 14514, 14515, 14467
40575, 13752, 13775, 13776, 13753, 14515, 14516, 14517, 14469
40576, 13753, 13776, 13777, 13754, 14517, 14518, 14519, 14471
40577, 13754, 13777, 13778, 13755, 14519, 14520, 14521, 14473
40578, 13755, 13778, 13779, 13756, 14521, 14522, 14523, 14475
40579, 13756, 13779, 1835, 1834, 14523, 14524, 1858, 14477
40580, 1788, 1789, 13780, 13757, 1812, 14525, 14526, 14478
40581, 13757, 13780, 13781, 13758, 14526, 14527, 14528, 14480
40582, 13758, 13781, 13782, 13759, 14528, 14529, 14530, 14482
40583, 13759, 13782, 13783, 13760, 14530, 14531, 14532, 14484
40584, 13760, 13783, 13784, 13761, 14532, 14533, 14534, 14486
40585, 13761, 13784, 13785, 13762, 14534, 14535, 14536, 14488
40586, 13762, 13785, 13786, 13763, 14536, 14537, 14538, 14490
40587, 13763, 13786, 13787, 13764, 14538, 14539, 14540, 14492
40588, 13764, 13787, 13788, 13765, 14540, 14541, 14542, 14494
40589, 13765, 13788, 13789, 13766, 14542, 14543, 14544, 14496
40590, 13766, 13789, 13790, 13767, 14544, 14545, 14546, 14498
40591, 13767, 13790, 13791, 13768, 14546, 14547, 14548, 14500
40592, 13768, 13791, 13792, 13769, 14548, 14549, 14550, 14502
40593, 13769, 13792, 13793, 13770, 14550, 14551, 14552, 14504
40594, 13770, 13793, 13794, 13771, 14552, 14553, 14554, 14506
40595, 13771, 13794, 13795, 13772, 14554, 14555, 14556, 14508
40596, 13772, 13795, 13796, 13773, 14556, 14557, 14558, 14510
40597, 13773, 13796, 13797, 13774, 14558, 14559, 14560, 14512
40598, 13774, 13797, 13798, 13775, 14560, 14561, 14562, 14514
40599, 13775, 13798, 13799, 13776, 14562, 14563, 14564, 14516
40600, 13776, 13799, 13800, 13777, 14564, 14565, 14566, 14518
40601, 13777, 13800, 13801, 13778, 14566, 14567, 14568, 14520
40602, 13778, 13801, 13802, 13779, 14568, 14569, 14570, 14522
40603, 13779, 13802, 1836, 1835, 14570, 14571, 1859, 14524
40604, 1789, 1790, 13803, 13780, 1813, 14572, 14573, 14525
40605, 13780, 13803, 13804, 13781, 14573, 14574, 14575, 14527
40606, 13781, 13804, 13805, 13782, 14575, 14576, 14577, 14529
40607, 13782, 13805, 13806, 13783, 14577, 14578, 14579, 14531
40608, 13783, 13806, 13807, 13784, 14579, 14580, 14581, 14533
40609, 13784, 13807, 13808, 13785, 14581, 14582, 14583, 14535
40610, 13785, 13808, 13809, 13786, 14583, 14584, 14585, 14537
40611, 13786, 13809, 13810, 13787, 14585, 14586, 14587, 14539
40612, 13787, 13810, 13811, 13788, 14587, 14588, 14589, 14541
40613, 13788, 13811, 13812, 13789, 14589, 14590, 14591, 14543
40614, 13789, 13812, 13813, 13790, 14591, 14592, 14593, 14545
40615, 13790, 13813, 13814, 13791, 14593, 14594, 14595, 14547
40616, 13791, 13814, 13815, 13792, 14595, 14596, 14597, 14549
40617, 13792, 13815, 13816, 13793, 14597, 14598, 14599, 14551
40618, 13793, 13816, 13817, 13794, 14599, 14600, 14601, 14553
40619, 13794, 13817, 13818, 13795, 14601, 14602, 14603, 14555
40620, 13795, 13818, 13819, 13796, 14603, 14604, 14605, 14557
40621, 13796, 13819, 13820, 13797, 14605, 14606, 14607, 14559
40622, 13797, 13820, 13821, 13798, 14607, 14608, 14609, 14561
40623, 13798, 13821, 13822, 13799, 14609, 14610, 14611, 14563
40624, 13799, 13822, 13823, 13800, 14611, 14612, 14613, 14565
40625, 13800, 13823, 13824, 13801, 14613, 14614, 14615, 14567
40626, 13801, 13824, 13825, 13802, 14615, 14616, 14617, 14569
40627, 13802, 13825, 1837, 1836, 14617, 14618, 1860, 14571
40628, 1790, 1791, 13826, 13803, 1814, 14619, 14620, 14572
40629, 13803, 13826, 13827, 13804, 14620, 14621, 14622, 14574
40630, 13804, 13827, 13828, 13805, 14622, 14623, 14624, 14576
40631, 13805, 13828, 13829, 13806, 14624, 14625, 14626, 14578
40632, 13806, 13829, 13830, 13807, 14626, 14627, 14628, 14580
40633, 13807, 13830, 13831, 13808, 14628, 14629, 14630, 14582
40634, 13808, 13831, 13832, 13809, 14630, 14631, 14632, 14584
40635, 13809, 13832, 13833, 13810, 14632, 14633, 14634, 14586
40636, 13810, 13833, 13834, 13811, 14634, 14635, 14636, 14588
40637, 13811, 13834, 13835, 13812, 14636, 14637, 14638, 14590
40638, 13812, 13835, 13836, 13813, 14638, 14639, 14640, 14592
40639, 13813, 13836, 13837, 13814, 14640, 14641, 14642, 14594
40640, 13814, 13837, 13838, 13815, 14642, 14643, 14644, 14596
40641, 13815, 13838, 13839, 13816, 14644, 14645, 14646, 14598
40642, 13816, 13839, 13840, 13817, 14646, 14647, 14648, 14600
40643, 13817, 13840, 13841, 13818, 14648, 14649, 14650, 14602
40644, 13818, 13841, 13842, 13819, 14650, 14651, 14652, 14604
40645, 13819, 13842, 13843, 13820, 14652, 14653, 14654, 14606
40646, 13820, 13843, 13844, 13821, 14654, 14655, 14656, 14608
40647, 13821, 13844, 13845, 13822, 14656, 14657, 14658, 14610
40648, 13822, 13845, 13846, 13823, 14658, 14659, 14660, 14612
40649, 13823, 13846, 13847, 13824, 14660, 14661, 14662, 14614
40650, 13824, 13847, 13848, 13825, 14662, 14663, 14664, 14616
40651, 13825, 13848, 1838, 1837, 14664, 14665, 1861, 14618
40652, 1791, 1792, 13849, 13826, 1815, 14666, 14667, 14619
40653, 13826, 13849, 13850, 13827, 14667, 14668, 14669, 14621
40654, 13827, 13850, 13851, 13828, 14669, 14670, 14671, 14623
40655, 13828, 13851, 13852, 13829, 14671, 14672, 14673, 14625
40656, 13829, 13852, 13853, 13830, 14673, 14674, 14675, 14627
40657, 13830, 13853, 13854, 13831, 14675, 14676, 14677, 14629
40658, 13831, 13854, 13855, 13832, 14677, 14678, 14679, 14631
40659, 13832, 13855, 13856, 13833, 14679, 14680, 14681, 14633
40660, 13833, 13856, 13857, 13834, 14681, 14682, 14683, 14635
40661, 13834, 13857, 13858, 13835, 14683, 14684, 14685, 14637
40662, 13835, 13858, 13859, 13836, 14685, 14686, 14687, 14639
40663, 13836, 13859, 13860, 13837, 14687, 14688, 14689, 14641
40664, 13837, 13860, 13861, 13838, 14689, 14690, 14691, 14643
40665, 13838, 13861, 13862, 13839, 14691, 14692, 14693, 14645
40666, 13839, 13862, 13863, 13840, 14693, 14694, 14695, 14647
40667, 13840, 13863, 13864, 13841, 14695, 14696, 14697, 14649
40668, 13841, 13864, 13865, 13842, 14697, 14698, 14699, 14651
40669, 13842, 13865, 13866, 13843, 14699, 14700, 14701, 14653
40670, 13843, 13866, 13867, 13844, 14701, 14702, 14703, 14655
40671, 13844, 13867, 13868, 13845, 14703, 14704, 14705, 14657
40672, 13845, 13868, 13869, 13846, 14705, 14706, 14707, 14659
40673, 13846, 13869, 13870, 13847, 14707, 14708, 14709, 14661
40674, 13847, 13870, 13871, 13848, 14709, 14710, 14711, 14663
40675, 13848, 13871, 1839, 1838, 14711, 14712, 1862, 14665
40676, 1792, 1793, 13872, 13849, 1816, 14713, 14714, 14666
40677, 13849, 13872, 13873, 13850, 14714, 14715, 14716, 14668
40678, 13850, 13873, 13874, 13851, 14716, 14717, 14718, 14670
40679, 13851, 13874, 13875, 13852, 14718, 14719, 14720, 14672
40680, 13852, 13875, 13876, 13853, 14720, 14721, 14722, 14674
40681, 13853, 13876, 13877, 13854, 14722, 14723, 14724, 14676
40682, 13854, 13877, 13878, 13855, 14724, 14725, 14726, 14678
40683, 13855, 13878, 13879, 13856, 14726, 14727, 14728, 14680
40684, 13856, 13879, 13880, 13857, 14728, 14729, 14730, 14682
40685, 13857, 13880, 13881, 13858, 14730, 14731, 14732, 14684
40686, 13858, 13881, 13882, 13859, 14732, 14733, 14734, 14686
40687, 13859, 13882, 13883, 13860, 14734, 14735, 14736, 14688
40688, 13860, 13883, 13884, 13861, 14736, 14737, 14738, 14690
40689, 13861, 13884, 13885, 13862, 14738, 14739, 14740, 14692
40690, 13862, 13885, 13886, 13863, 14740, 14741, 14742, 14694
40691, 13863, 13886, 13887, 13864, 14742, 14743, 14744, 14696
40692, 13864, 13887, 13888, 13865, 14744, 14745, 14746, 14698
40693, 13865, 13888, 13889, 13866, 14746, 14747, 14748, 14700
40694, 13866, 13889, 13890, 13867, 14748, 14749, 14750, 14702
40695, 13867, 13890, 13891, 13868, 14750, 14751, 14752, 14704
40696, 13868, 13891, 13892, 13869, 14752, 14753, 14754, 14706
40697, 13869, 13892, 13893, 13870, 14754, 14755, 14756, 14708
40698, 13870, 13893, 13894, 13871, 14756, 14757, 14758, 14710
40699, 13871, 13894, 1840, 1839, 14758, 14759, 1863, 14712
40700, 1793, 1794, 13895, 13872, 1817, 14760, 14761, 14713
40701, 13872, 13895, 13896, 13873, 14761, 14762, 14763, 14715
40702, 13873, 13896, 13897, 13874, 14763, 14764, 14765, 14717
40703, 13874, 13897, 13898, 13875, 14765, 14766, 14767, 14719
40704, 13875, 13898, 13899, 13876, 14767, 14768, 14769, 14721
40705, 13876, 13899, 13900, 13877, 14769, 14770, 14771, 14723
40706, 13877, 13900, 13901, 13878, 14771, 14772, 14773, 14725
40707, 13878, 13901, 13902, 13879, 14773, 14774, 14775, 14727
40708, 13879, 13902, 13903, 13880, 14775, 14776, 14777, 14729
40709, 13880, 13903, 13904, 13881, 14777, 14778, 14779, 14731
40710, 13881, 13904, 13905, 13882, 14779, 14780, 14781, 14733
40711, 13882, 13905, 13906, 13883, 14781, 14782, 14783, 14735
40712, 13883, 13906, 13907, 13884, 14783, 14784, 14785, 14737
40713, 13884, 13907, 13908, 13885, 14785, 14786, 14787, 14739
40714, 13885, 13908, 13909, 13886, 14787, 14788, 14789, 14741
40715, 13886, 13909, 13910, 13887, 14789, 14790, 14791, 14743
40716, 13887, 13910, 13911, 13888, 14791, 14792, 14793, 14745
40717, 13888, 13911, 13912, 13889, 14793, 14794, 14795, 14747
40718, 13889, 13912, 13913, 13890, 14795, 14796, 14797, 14749
40719, 13890, 13913, 13914, 13891, 14797, 14798, 14799, 14751
40720, 13891, 13914, 13915, 13892, 14799, 14800, 14801, 14753
40721, 13892, 13915, 13916, 13893, 14801, 14802, 14803, 14755
40722, 13893, 13916, 13917, 13894, 14803, 14804, 14805, 14757
40723, 13894, 13917, 1841, 1840, 14805, 14806, 1864, 14759
40724, 1794, 1795, 13918, 13895, 1818, 14807, 14808, 14760
40725, 13895, 13918, 13919, 13896, 14808, 14809, 14810, 14762
40726, 13896, 13919, 13920, 13897, 14810, 14811, 14812, 14764
40727, 13897, 13920, 13921, 13898, 14812, 14813, 14814, 14766
40728, 13898, 13921, 13922, 13899, 14814, 14815, 14816, 14768
40729, 13899, 13922, 13923, 13900, 14816, 14817, 14818, 14770
40730, 13900, 13923, 13924, 13901, 14818, 14819, 14820, 14772
40731, 13901, 13924, 13925, 13902, 14820, 14821, 14822, 14774
40732, 13902, 13925, 13926, 13903, 14822, 14823, 14824, 14776
40733, 13903, 13926, 13927, 13904, 14824, 14825, 14826, 14778
40734, 13904, 13927, 13928, 13905, 14826, 14827, 14828, 14780
40735, 13905, 13928, 13929, 13906, 14828, 14829, 14830, 14782
40736, 13906, 13929, 13930, 13907, 14830, 14831, 14832, 14784
40737, 13907, 13930, 13931, 13908, 14832, 14833, 14834, 14786
40738, 13908, 13931, 13932, 13909, 14834, 14835, 14836, 14788
40739, 13909, 13932, 13933, 13910, 14836, 14837, 14838, 14790
40740, 13910, 13933, 13934, 13911, 14838, 14839, 14840, 14792
40741, 13911, 13934, 13935, 13912, 14840, 14841, 14842, 14794
40742, 13912, 13935, 13936, 13913, 14842, 14843, 14844, 14796
40743, 13913, 13936, 13937, 13914, 14844, 14845, 14846, 14798
40744, 13914, 13937, 13938, 13915, 14846, 14847, 14848, 14800
40745, 13915, 13938, 13939, 13916, 14848, 14849, 14850, 14802
40746, 13916, 13939, 13940, 13917, 14850, 14851, 14852, 14804
40747, 13917, 13940, 1842, 1841, 14852, 14853, 1865, 14806
40748, 1795, 1796, 13941, 13918, 1819, 14854, 14855, 14807
40749, 13918, 13941, 13942, 13919, 14855, 14856, 14857, 14809
40750, 13919, 13942, 13943, 13920, 14857, 14858, 14859, 14811
40751, 13920, 13943, 13944, 13921, 14859, 14860, 14861, 14813
40752, 13921, 13944, 13945, 13922, 14861, 14862, 14863, 14815
40753, 13922, 13945, 13946, 13923, 14863, 14864, 14865, 14817
40754, 13923, 13946, 13947, 13924, 14865, 14866, 14867, 14819
40755, 13924, 13947, 13948, 13925, 14867, 14868, 14869, 14821
40756, 13925, 13948, 13949, 13926, 14869, 14870, 14871, 14823
40757, 13926, 13949, 13950, 13927, 14871, 14872, 14873, 14825
40758, 13927, 13950, 13951, 13928, 14873, 14874, 14875, 14827
40759, 13928, 13951, 13952, 13929, 14875, 14876, 14877, 14829
40760, 13929, 13952, 13953, 13930, 14877, 14878, 14879, 14831
40761, 13930, 13953, 13954, 13931, 14879, 14880, 14881, 14833
40762, 13931, 13954, 13955, 13932, 14881, 14882, 14883, 14835
40763, 13932, 13955, 13956, 13933, 14883, 14884, 14885, 14837
40764, 13933, 13956, 13957, 13934, 14885, 14886, 14887, 14839
40765, 13934, 13957, 13958, 13935, 14887, 14888, 14889, 14841
40766, 13935, 13958, 13959, 13936, 14889, 14890, 14891, 14843
40767, 13936, 13959, 13960, 13937, 14891, 14892, 14893, 14845
40768, 13937, 13960, 13961, 13938, 14893, 14894, 14895, 14847
40769, 13938, 13961, 13962, 13939, 14895, 14896, 14897, 14849
40770, 13939, 13962, 13963, 13940, 14897, 14898, 14899, 14851
40771, 13940, 13963, 1843, 1842, 14899, 14900, 1866, 14853
40772, 1796, 1797, 13964, 13941, 1820, 14901, 14902, 14854
40773, 13941, 13964, 13965, 13942, 14902, 14903, 14904, 14856
40774, 13942, 13965, 13966, 13943, 14904, 14905, 14906, 14858
40775, 13943, 13966, 13967, 13944, 14906, 14907, 14908, 14860
40776, 13944, 13967, 13968, 13945, 14908, 14909, 14910, 14862
40777, 13945, 13968, 13969, 13946, 14910, 14911, 14912, 14864
40778, 13946, 13969, 13970, 13947, 14912, 14913, 14914, 14866
40779, 13947, 13970, 13971, 13948, 14914, 14915, 14916, 14868
40780, 13948, 13971, 13972, 13949, 14916, 14917, 14918, 14870
40781, 13949, 13972, 13973, 13950, 14918, 14919, 14920, 14872
40782, 13950, 13973, 13974, 13951, 14920, 14921, 14922, 14874
40783, 13951, 13974, 13975, 13952, 14922, 14923, 14924, 14876
40784, 13952, 13975, 13976, 13953, 14924, 14925, 14926, 14878
40785, 13953, 13976, 13977, 13954, 14926, 14927, 14928, 14880
40786, 13954, 13977, 13978, 13955, 14928, 14929, 14930, 14882
40787, 13955, 13978, 13979, 13956, 14930, 14931, 14932, 14884
40788, 13956, 13979, 13980, 13957, 14932, 14933, 14934, 14886
40789, 13957, 13980, 13981, 13958, 14934, 14935, 14936, 14888
40790, 13958, 13981, 13982, 13959, 14936, 14937, 14938, 14890
40791, 13959, 13982, 13983, 13960, 14938, 14939, 14940, 14892
40792, 13960, 13983, 13984, 13961, 14940, 14941, 14942, 14894
40793, 13961, 13984, 13985, 13962, 14942, 14943, 14944, 14896
40794, 13962, 13985, 13986, 13963, 14944, 14945, 14946, 14898
40795, 13963, 13986, 1844, 1843, 14946, 14947, 1867, 14900
40796, 1797, 1798, 13987, 13964, 1821, 14948, 14949, 14901
40797, 13964, 13987, 13988, 13965, 14949, 14950, 14951, 14903
40798, 13965, 13988, 13989, 13966, 14951, 14952, 14953, 14905
40799, 13966, 13989, 13990, 13967, 14953, 14954, 14955, 14907
40800, 13967, 13990, 13991, 13968, 14955, 14956, 14957, 14909
40801, 13968, 13991, 13992, 13969, 14957, 14958, 14959, 14911
40802, 13969, 13992, 13993, 13970, 14959, 14960, 14961, 14913
40803, 13970, 13993, 13994, 13971, 14961, 14962, 14963, 14915
40804, 13971, 13994, 13995, 13972, 14963, 14964, 14965, 14917
40805, 13972, 13995, 13996, 13973, 14965, 14966, 14967, 14919
40806, 13973, 13996, 13997, 13974, 14967, 14968, 14969, 14921
40807, 13974, 13997, 13998, 13975, 14969, 14970, 14971, 14923
40808, 13975, 13998, 13999, 13976, 14971, 14972, 14973, 14925
40809, 13976, 13999, 14000, 13977, 14973, 14974, 14975, 14927
40810, 13977, 14000, 14001, 13978, 14975, 14976, 14977, 14929
40811, 13978, 14001, 14002, 13979, 14977, 14978, 14979, 14931
40812, 13979, 14002, 14003, 13980, 14979, 14980, 14981, 14933
40813, 13980, 14003, 14004, 13981, 14981, 14982, 14983, 14935
40814, 13981, 14004, 14005, 13982, 14983, 14984, 14985, 14937
40815, 13982, 14005, 14006, 13983, 14985, 14986, 14987, 14939
40816, 13983, 14006, 14007, 13984, 14987, 14988, 14989, 14941
40817, 13984, 14007, 14008, 13985, 14989, 14990, 14991, 14943
40818, 13985, 14008, 14009, 13986, 14991, 14992, 14993, 14945
40819, 13986, 14009, 1845, 1844, 14993, 14994, 1868, 14947
40820, 1798, 1799, 14010, 13987, 1822, 14995, 14996, 14948
40821, 13987, 14010, 14011, 13988, 14996, 14997, 14998, 14950
40822, 13988, 14011, 14012, 13989, 14998, 14999, 15000, 14952
40823, 13989, 14012, 14013, 13990, 15000, 15001, 15002, 14954
40824, 13990, 14013, 14014, 13991, 15002, 15003, 15004, 14956
40825, 13991, 14014, 14015, 13992, 15004, 15005, 15006, 14958
40826, 13992, 14015, 14016, 13993, 15006, 15007, 15008, 14960
40827, 13993, 14016, 14017, 13994, 15008, 15009, 15010, 14962
40828, 13994, 14017, 14018, 13995, 15010, 15011, 15012, 14964
40829, 13995, 14018, 14019, 13996, 15012, 15013, 15014, 14966
40830, 13996, 14019, 14020, 13997, 15014, 15015, 15016, 14968
40831, 13997, 14020, 14021, 13998, 15016, 15017, 15018, 14970
40832, 13998, 14021, 14022, 13999, 15018, 15019, 15020, 14972
40833, 13999, 14022, 14023, 14000, 15020, 15021, 15022, 14974
40834, 14000, 14023, 14024, 14001, 15022, 15023, 15024, 14976
40835, 14001, 14024, 14025, 14002, 15024, 15025, 15026, 14978
40836, 14002, 14025, 14026, 14003, 15026, 15027, 15028, 14980
40837, 14003, 14026, 14027, 14004, 15028, 15029, 15030, 14982
40838, 14004, 14027, 14028, 14005, 15030, 15031, 15032, 14984
40839, 14005, 14028, 14029, 14006, 15032, 15033, 15034, 14986
40840, 14006, 14029, 14030, 14007, 15034, 15035, 15036, 14988
40841, 14007, 14030, 14031, 14008, 15036, 15037, 15038, 14990
40842, 14008, 14031, 14032, 14009, 15038, 15039, 15040, 14992
40843, 14009, 14032, 1846, 1845, 15040, 15041, 1869, 14994
40844, 1799, 1800, 14033, 14010, 1823, 15042, 15043, 14995
40845, 14010, 14033, 14034, 14011, 15043, 15044, 15045, 14997
40846, 14011, 14034, 14035, 14012, 15045, 15046, 15047, 14999
40847, 14012, 14035, 14036, 14013, 15047, 15048, 15049, 15001
40848, 14013, 14036, 14037, 14014, 15049, 15050, 15051, 15003
40849, 14014, 14037, 14038, 14015, 15051, 15052, 15053, 15005
40850, 14015, 14038, 14039, 14016, 15053, 15054, 15055, 15007
40851, 14016, 14039, 14040, 14017, 15055, 15056, 15057, 15009
40852, 14017, 14040, 14041, 14018, 15057, 15058, 15059, 15011
40853, 14018, 14041, 14042, 14019, 15059, 15060, 15061, 15013
40854, 14019, 14042, 14043, 14020, 15061, 15062, 15063, 15015
40855, 14020, 14043, 14044, 14021, 15063, 15064, 15065, 15017
40856, 14021, 14044, 14045, 14022, 15065, 15066, 15067, 15019
40857, 14022, 14045, 14046, 14023, 15067, 15068, 15069, 15021
40858, 14023, 14046, 14047, 14024, 15069, 15070, 15071, 15023
40859, 14024, 14047, 14048, 14025, 15071, 15072, 15073, 15025
40860, 14025, 14048, 14049, 14026, 15073, 15074, 15075, 15027
40861, 14026, 14049, 14050, 14027, 15075, 15076, 15077, 15029
40862, 14027, 14050, 14051, 14028, 15077, 15078, 15079, 15031
40863, 14028, 14051, 14052, 14029, 15079, 15080, 15081, 15033
40864, 14029, 14052, 14053, 14030, 15081, 15082, 15083, 15035
40865, 14030, 14053, 14054, 14031, 15083, 15084, 15085, 15037
40866, 14031, 14054, 14055, 14032, 15085, 15086, 15087, 15039
40867, 14032, 14055, 1847, 1846, 15087, 15088, 1870, 15041
40868, 1800, 1801, 14056, 14033, 1824, 15089, 15090, 15042
40869, 14033, 14056, 14057, 14034, 15090, 15091, 15092, 15044
40870, 14034, 14057, 14058, 14035, 15092, 15093, 15094, 15046
40871, 14035, 14058, 14059, 14036, 15094, 15095, 15096, 15048
40872, 14036, 14059, 14060, 14037, 15096, 15097, 15098, 15050
40873, 14037, 14060, 14061, 14038, 15098, 15099, 15100, 15052
40874, 14038, 14061, 14062, 14039, 15100, 15101, 15102, 15054
40875, 14039, 14062, 14063, 14040, 15102, 15103, 15104, 15056
40876, 14040, 14063, 14064, 14041, 15104, 15105, 15106, 15058
40877, 14041, 14064, 14065, 14042, 15106, 15107, 15108, 15060
40878, 14042, 14065, 14066, 14043, 15108, 15109, 15110, 15062
40879, 14043, 14066, 14067, 14044, 15110, 15111, 15112, 15064
40880, 14044, 14067, 14068, 14045, 15112, 15113, 15114, 15066
40881, 14045, 14068, 14069, 14046, 15114, 15115, 15116, 15068
40882, 14046, 14069, 14070, 14047, 15116, 15117, 15118, 15070
40883, 14047, 14070, 14071, 14048, 15118, 15119, 15120, 15072
40884, 14048, 14071, 14072, 14049, 15120, 15121, 15122, 15074
40885, 14049, 14072, 14073, 14050, 15122, 15123, 15124, 15076
40886, 14050, 14073, 14074, 14051, 15124, 15125, 15126, 15078
40887, 14051, 14074, 14075, 14052, 15126, 15127, 15128, 15080
40888, 14052, 14075, 14076, 14053, 15128, 15129, 15130, 15082
40889, 14053, 14076, 14077, 14054, 15130, 15131, 15132, 15084
40890, 14054, 14077, 14078, 14055, 15132, 15133, 15134, 15086
40891, 14055, 14078, 1848, 1847, 15134, 15135, 1871, 15088
40892, 1801, 1802, 14079, 14056, 1825, 15136, 15137, 15089
40893, 14056, 14079, 14080, 14057, 15137, 15138, 15139, 15091
40894, 14057, 14080, 14081, 14058, 15139, 15140, 15141, 15093
40895, 14058, 14081, 14082, 14059, 15141, 15142, 15143, 15095
40896, 14059, 14082, 14083, 14060, 15143, 15144, 15145, 15097
40897, 14060, 14083, 14084, 14061, 15145, 15146, 15147, 15099
40898, 14061, 14084, 14085, 14062, 15147, 15148, 15149, 15101
40899, 14062, 14085, 14086, 14063, 15149, 15150, 15151, 15103
40900, 14063, 14086, 14087, 14064, 15151, 15152, 15153, 15105
40901, 14064, 14087, 14088, 14065, 15153, 15154, 15155, 15107
40902, 14065, 14088, 14089, 14066, 15155, 15156, 15157, 15109
40903, 14066, 14089, 14090, 14067, 15157, 15158, 15159, 15111
40904, 14067, 14090, 14091, 14068, 15159, 15160, 15161, 15113
40905, 14068, 14091, 14092, 14069, 15161, 15162, 15163, 15115
40906, 14069, 14092, 14093, 14070, 15163, 15164, 15165, 15117
40907, 14070, 14093, 14094, 14071, 15165, 15166, 15167, 15119
40908, 14071, 14094, 14095, 14072, 15167, 15168, 15169, 15121
40909, 14072, 14095, 14096, 14073, 15169, 15170, 15171, 15123
40910, 14073, 14096, 14097, 14074, 15171, 15172, 15173, 15125
40911, 14074, 14097, 14098, 14075, 15173, 15174, 15175, 15127
40912, 14075, 14098, 14099, 14076, 15175, 15176, 15177, 15129
40913, 14076, 14099, 14100, 14077, 15177, 15178, 15179, 15131
40914, 14077, 14100, 14101, 14078, 15179, 15180, 15181, 15133
40915, 14078, 14101, 1849, 1848, 15181, 15182, 1872, 15135
40916, 1802, 71, 1733, 14079, 1826, 1756, 15183, 15136
40917, 14079, 1733, 1734, 14080, 15183, 1757, 15184, 15138
40918, 14080, 1734, 1735, 14081, 15184, 1758, 15185, 15140
40919, 14081, 1735, 1736, 14082, 15185, 1759, 15186, 15142
40920, 14082, 1736, 1737, 14083, 15186, 1760, 15187, 15144
40921, 14083, 1737, 1738, 14084, 15187, 1761, 15188, 15146
40922, 14084, 1738, 1739, 14085, 15188, 1762, 15189, 15148
40923, 14085, 1739, 1740, 14086, 15189, 1763, 15190, 15150
40924, 14086, 1740, 1741, 14087, 15190, 1764, 15191, 15152
40925, 14087, 1741, 1742, 14088, 15191, 1765, 15192, 15154
40926, 14088, 1742, 1743, 14089, 15192, 1766, 15193, 15156
40927, 14089, 1743, 1744, 14090, 15193, 1767, 15194, 15158
40928, 14090, 1744, 1745, 14091, 15194, 1768, 15195, 15160
40929, 14091, 1745, 1746, 14092, 15195, 1769, 15196, 15162
40930, 14092, 1746, 1747, 14093, 15196, 1770, 15197, 15164
40931, 14093, 1747, 1748, 14094, 15197, 1771, 15198, 15166
40932, 14094, 1748, 1749, 14095, 15198, 1772, 15199, 15168
40933, 14095, 1749, 1750, 14096, 15199, 1773, 15200, 15170
40934, 14096, 1750, 1751, 14097, 15200, 1774, 15201, 15172
40935, 14097, 1751, 1752, 14098, 15201, 1775, 15202, 15174
40936, 14098, 1752, 1753, 14099, 15202, 1776, 15203, 15176
40937, 14099, 1753, 1754, 14100, 15203, 1777, 15204, 15178
40938, 14100, 1754, 1755, 14101, 15204, 1778, 15205, 15180
40939, 14101, 1755, 72, 1849, 15205, 1779, 1873, 15182
*ELEMENT, type=CPS8, ELSET=Surface97
40940, 35, 69, 73, 63, 1682, 1875, 1874, 1395
*ELEMENT, type=CPS8, ELSET=Surface98
40941, 39, 64, 74, 70, 1396, 1876, 1877, 1683
*ELEMENT, type=CPS8, ELSET=Surface99
40942, 63, 73, 1878, 1397, 1874, 1901, 15206, 1420
40943, 1397, 1878, 1879, 1398, 15206, 1902, 15207, 1421
40944, 1398, 1879, 1880, 1399, 15207, 1903, 15208, 1422
40945, 1399, 1880, 1881, 1400, 15208, 1904, 15209, 1423
40946, 1400, 1881, 1882, 1401, 15209, 1905, 15210, 1424
40947, 1401, 1882, 1883, 1402, 15210, 1906, 15211, 1425
40948, 1402, 1883, 1884, 1403, 15211, 1907, 15212, 1426
40949, 1403, 1884, 1885, 1404, 15212, 1908, 15213, 1427
40950, 1404, 1885, 1886, 1405, 15213, 1909, 15214, 1428
40951, 1405, 1886, 1887, 1406, 15214, 1910, 15215, 1429
40952, 1406, 1887, 1888, 1407, 15215, 1911, 15216, 1430
40953, 1407, 1888, 1889, 1408, 15216, 1912, 15217, 1431
40954, 1408, 1889, 1890, 1409, 15217, 1913, 15218, 1432
40955, 1409, 1890, 1891, 1410, 15218, 1914, 15219, 1433
40956, 1410, 1891, 1892, 1411, 15219, 1915, 15220, 1434
40957, 1411, 1892, 1893, 1412, 15220, 1916, 15221, 1435
40958, 1412, 1893, 1894, 1413, 15221, 1917, 15222, 1436
40959, 1413, 1894, 1895, 1414, 15222, 1918, 15223, 1437
40960, 1414, 1895, 1896, 1415, 15223, 1919, 15224, 1438
40961, 1415, 1896, 1897, 1416, 15224, 1920, 15225, 1439
40962, 1416, 1897, 1898, 1417, 15225, 1921, 15226, 1440
40963, 1417, 1898, 1899, 1418, 15226, 1922, 15227, 1441
40964, 1418, 1899, 1900, 1419, 15227, 1923, 15228, 1442
40965, 1419, 1900, 74, 64, 15228, 1924, 1876, 1443
*ELEMENT, type=CPS8, ELSET=Surface100
40966, 69, 1684, 1878, 73, 1707, 15229, 1901, 1875
40967, 1684, 1685, 1879, 1878, 1708, 15230, 1902, 15229
40968, 1685, 1686, 1880, 1879, 1709, 15231, 1903, 15230
40969, 1686, 1687, 1881, 1880, 1710, 15232, 1904, 15231
40970, 1687, 1688, 1882, 1881, 1711, 15233, 1905, 15232
40971, 1688, 1689, 1883, 1882, 1712, 15234, 1906, 15233
40972, 1689, 1690, 1884, 1883, 1713, 15235, 1907, 15234
40973, 1690, 1691, 1885, 1884, 1714, 15236, 1908, 15235
40974, 1691, 1692, 1886, 1885, 1715, 15237, 1909, 15236
40975, 1692, 1693, 1887, 1886, 1716, 15238, 1910, 15237
40976, 1693, 1694, 1888, 1887, 1717, 15239, 1911, 15238
40977, 1694, 1695, 1889, 1888, 1718, 15240, 1912, 15239
40978, 1695, 1696, 1890, 1889, 1719, 15241, 1913, 15240
40979, 1696, 1697, 1891, 1890, 1720, 15242, 1914, 15241
40980, 1697, 1698, 1892, 1891, 1721, 15243, 1915, 15242
40981, 1698, 1699, 1893, 1892, 1722, 15244, 1916, 15243
40982, 1699, 1700, 1894, 1893, 1723, 15245, 1917, 15244
40983, 1700, 1701, 1895, 1894, 1724, 15246, 1918, 15245
40984, 1701, 1702, 1896, 1895, 1725, 15247, 1919, 15246
40985, 1702, 1703, 1897, 1896, 1726, 15248, 1920, 15247
40986, 1703, 1704, 1898, 1897, 1727, 15249, 1921, 15248
40987, 1704, 1705, 1899, 1898, 1728, 15250, 1922, 15249
40988, 1705, 1706, 1900, 1899, 1729, 15251, 1923, 15250
40989, 1706, 70, 74, 1900, 1730, 1877, 1924, 15251
*ELEMENT, type=CPS8, ELSET=Surface101
40990, 9, 65, 75, 59, 1490, 1926, 1925, 1277
*ELEMENT, type=CPS8, ELSET=Surface102
40991, 13, 60, 76, 66, 1278, 1927, 1928, 1491
*ELEMENT, type=CPS8, ELSET=Surface103
40992, 59, 75, 1929, 1279, 1925, 1952, 15252, 1302
40993, 1279, 1929, 1930, 1280, 15252, 1953, 15253, 1303
40994, 1280, 1930, 1931, 1281, 15253, 1954, 15254, 1304
40995, 1281, 1931, 1932, 1282, 15254, 1955, 15255, 1305
40996, 1282, 1932, 1933, 1283, 15255, 1956, 15256, 1306
40997, 1283, 1933, 1934, 1284, 15256, 1957, 15257, 1307
40998, 1284, 1934, 1935, 1285, 15257, 1958, 15258, 1308
40999, 1285, 1935, 1936, 1286, 15258, 1959, 15259, 1309
41000, 1286, 1936, 1937, 1287, 15259, 1960, 15260, 1310
41001, 1287, 1937, 1938, 1288, 15260, 1961, 15261, 1311
41002, 1288, 1938, 1939, 1289, 15261, 1962, 15262, 1312
41003, 1289, 1939, 1940, 1290, 15262, 1963, 15263, 1313
41004, 1290, 1940, 1941, 1291, 15263, 1964, 15264, 1314
41005, 1291, 1941, 1942, 1292, 15264, 1965, 15265, 1315
41006, 1292, 1942, 1943, 1293, 15265, 1966, 15266, 1316
41007, 1293, 1943, 1944, 1294, 15266, 1967, 15267, 1317
41008, 1294, 1944, 1945, 1295, 15267, 1968, 15268, 1318
41009, 1295, 1945, 1946, 1296, 15268, 1969, 15269, 1319
41010, 1296, 1946, 1947, 1297, 15269, 1970, 15270, 1320
41011, 1297, 1947, 1948, 1298, 15270, 1971, 15271, 1321
41012, 1298, 1948, 1949, 1299, 15271, 1972, 15272, 1322
41013, 1299, 1949, 1950, 1300, 15272, 1973, 15273, 1323
41014, 1300, 1950, 1951, 1301, 15273, 1974, 15274, 1324
41015, 1301, 1951, 76, 60, 15274, 1975, 1927, 1325
*ELEMENT, type=CPS8, ELSET=Surface104
41016, 65, 1492, 1929, 75, 1515, 15275, 1952, 1926
41017, 1492, 1493, 1930, 1929, 1516, 15276, 1953, 15275
41018, 1493, 1494, 1931, 1930, 1517, 15277, 1954, 15276
41019, 1494, 1495, 1932, 1931, 1518, 15278, 1955, 15277
41020, 1495, 1496, 1933, 1932, 1519, 15279, 1956, 15278
41021, 1496, 1497, 1934, 1933, 1520, 15280, 1957, 15279
41022, 1497, 1498, 1935, 1934, 1521, 15281, 1958, 15280
41023, 1498, 1499, 1936, 1935, 1522, 15282, 1959, 15281
41024, 1499, 1500, 1937, 1936, 1523, 15283, 1960, 15282
41025, 1500, 1501, 1938, 1937, 1524, 15284, 1961, 15283
41026, 1501, 1502, 1939, 1938, 1525, 15285, 1962, 15284
41027, 1502, 1503, 1940, 1939, 1526, 15286, 1963, 15285
41028, 1503, 1504, 1941, 1940, 1527, 15287, 1964, 15286
41029, 1504, 1505, 1942, 1941, 1528, 15288, 1965, 15287
41030, 1505, 1506, 1943, 1942, 1529, 15289, 1966, 15288
41031, 1506, 1507, 1944, 1943, 1530, 15290, 1967, 15289
41032, 1507, 1508, 1945, 1944, 1531, 15291, 1968, 15290
41033, 1508, 1509, 1946, 1945, 1532, 15292, 1969, 15291
41034, 1509, 1510, 1947, 1946, 1533, 15293, 1970, 15292
41035, 1510, 1511, 1948, 1947, 1534, 15294, 1971, 15293
41036, 1511, 1512, 1949, 1948, 1535, 15295, 1972, 15294
41037, 1512, 1513, 1950, 1949, 1536, 15296, 1973, 15295
41038, 1513, 1514, 1951, 1950, 1537, 15297, 1974, 15296
41039, 1514, 66, 76, 1951, 1538, 1928, 1975, 15297
*ELEMENT, type=CPS8, ELSET=Surface105
41040, 22, 1985, 15298, 542, 1989, 15390, 15391, 0
41041, 1985, 1986, 15299, 15298, 1990, 15392, 15393, 15390
41042, 1986, 1987, 15300, 15299, 1991, 15394, 15395, 15392
41043, 1987, 1988, 15301, 15300, 1992, 15396, 15397, 15394
41044, 1988, 78, 1994, 15301, 1993, 0, 15398, 15396
41045, 542, 15298, 15302, 543, 15391, 15399, 15400, 0
41046, 15298, 15299, 15303, 15302, 15393, 15401, 15402, 15399
41047, 15299, 15300, 15304, 15303, 15395, 15403, 15404, 15401
41048, 15300, 15301, 15305, 15304, 15397, 15405, 15406, 15403
41049, 15301, 1994, 1995, 15305, 15398, 0, 15407, 15405
41050, 543, 15302, 15306, 544, 15400, 15408, 15409, 0
41051, 15302, 15303, 15307, 15306, 15402, 15410, 15411, 15408
41052, 15303, 15304, 15308, 15307, 15404, 15412, 15413, 15410
41053, 15304, 15305, 15309, 15308, 15406, 15414, 15415, 15412
41054, 15305, 1995, 1996, 15309, 15407, 0, 15416, 15414
41055, 544, 15306, 15310, 545, 15409, 15417, 15418, 0
41056, 15306, 15307, 15311, 15310, 15411, 15419, 15420, 15417
41057, 15307, 15308, 15312, 15311, 15413, 15421, 15422, 15419
41058, 15308, 15309, 15313, 15312, 15415, 15423, 15424, 15421
41059, 15309, 1996, 1997, 15313, 15416, 0, 15425, 15423
41060, 545, 15310, 15314, 546, 15418, 15426, 15427, 0
41061, 15310, 15311, 15315, 15314, 15420, 15428, 15429, 15426
41062, 15311, 15312, 15316, 15315, 15422, 15430, 15431, 15428
41063, 15312, 15313, 15317, 15316, 15424, 15432, 15433, 15430
41064, 15313, 1997, 1998, 15317, 15425, 0, 15434, 15432
41065, 546, 15314, 15318, 547, 15427, 15435, 15436, 0
41066, 15314, 15315, 15319, 15318, 15429, 15437, 15438, 15435
41067, 15315, 15316, 15320, 15319, 15431, 15439, 15440, 15437
41068, 15316, 15317, 15321, 15320, 15433, 15441, 15442, 15439
41069, 15317, 1998, 1999, 15321, 15434, 0, 15443, 15441
41070, 547, 15318, 15322, 548, 15436, 15444, 15445, 0
41071, 15318, 15319, 15323, 15322, 15438, 15446, 15447, 15444
41072, 15319, 15320, 15324, 15323, 15440, 15448, 15449, 15446
41073, 15320, 15321, 15325, 15324, 15442, 15450, 15451, 15448
41074, 15321, 1999, 2000, 15325, 15443, 0, 15452, 15450
41075, 548, 15322, 15326, 549, 15445, 15453, 15454, 0
41076, 15322, 15323, 15327, 15326, 15447, 15455, 15456, 15453
41077, 15323, 15324, 15328, 15327, 15449, 15457, 15458, 15455
41078, 15324, 15325, 15329, 15328, 15451, 15459, 15460, 15457
41079, 15325, 2000, 2001, 15329, 15452, 0, 15461, 15459
41080, 549, 15326, 15330, 550, 15454, 15462, 15463, 0
41081, 15326, 15327, 15331, 15330, 15456, 15464, 15465, 15462
41082, 15327, 15328, 15332, 15331, 15458, 15466, 15467, 15464
41083, 15328, 15329, 15333, 15332, 15460, 15468, 15469, 15466
41084, 15329, 2001, 2002, 15333, 15461, 0, 15470, 15468
41085, 550, 15330, 15334, 551, 15463, 15471, 15472, 0
41086, 15330, 15331, 15335, 15334, 15465, 15473, 15474, 15471
41087, 15331, 15332, 15336, 15335, 15467, 15475, 15476, 15473
41088, 15332, 15333, 15337, 15336, 15469, 15477, 15478, 15475
41089, 15333, 2002, 2003, 15337, 15470, 0, 15479, 15477
41090, 551, 15334, 15338, 552, 15472, 15480, 15481, 0
41091, 15334, 15335, 15339, 15338, 15474, 15482, 15483, 15480
41092, 15335, 15336, 15340, 15339, 15476, 15484, 15485, 15482
41093, 15336, 15337, 15341, 15340, 15478, 15486, 15487, 15484
41094, 15337, 2003, 2004, 15341, 15479, 0, 15488, 15486
41095, 552, 15338, 15342, 553, 15481, 15489, 15490, 0
41096, 15338, 15339, 15343, 15342, 15483, 15491, 15492, 15489
41097, 15339, 15340, 15344, 15343, 15485, 15493, 15494, 15491
41098, 15340, 15341, 15345, 15344, 15487, 15495, 15496, 15493
41099, 15341, 2004, 2005, 15345, 15488, 0, 15497, 15495
41100, 553, 15342, 15346, 554, 15490, 15498, 15499, 0
41101, 15342, 15343, 15347, 15346, 15492, 15500, 15501, 15498
41102, 15343, 15344, 15348, 15347, 15494, 15502, 15503, 15500
41103, 15344, 15345, 15349, 15348, 15496, 15504, 15505, 15502
41104, 15345, 2005, 2006, 15349, 15497, 0, 15506, 15504
41105, 554, 15346, 15350, 555, 15499, 15507, 15508, 0
41106, 15346, 15347, 15351, 15350, 15501, 15509, 15510, 15507
41107, 15347, 15348, 15352, 15351, 15503, 15511, 15512, 15509
41108, 15348, 15349, 15353, 15352, 15505, 15513, 15514, 15511
41109, 15349, 2006, 2007, 15353, 15506, 0, 15515, 15513
41110, 555, 15350, 15354, 556, 15508, 15516, 15517, 0
41111, 15350, 15351, 15355, 15354, 15510, 15518, 15519, 15516
41112, 15351, 15352, 15356, 15355, 15512, 15520, 15521, 15518
41113, 15352, 15353, 15357, 15356, 15514, 15522, 15523, 15520
41114, 15353, 2007, 2008, 15357, 15515, 0, 15524, 15522
41115, 556, 15354, 15358, 557, 15517, 15525, 15526, 0
41116, 15354, 15355, 15359, 15358, 15519, 15527, 15528, 15525
41117, 15355, 15356, 15360, 15359, 15521, 15529, 15530, 15527
41118, 15356, 15357, 15361, 15360, 15523, 15531, 15532, 15529
41119, 15357, 2008, 2009, 15361, 15524, 0, 15533, 15531
41120, 557, 15358, 15362, 558, 15526, 15534, 15535, 0
41121, 15358, 15359, 15363, 15362, 15528, 15536, 15537, 15534
41122, 15359, 15360, 15364, 15363, 15530, 15538, 15539, 15536
41123, 15360, 15361, 15365, 15364, 15532, 15540, 15541, 15538
41124, 15361, 2009, 2010, 15365, 15533, 0, 15542, 15540
41125, 558, 15362, 15366, 559, 15535, 15543, 15544, 0
41126, 15362, 15363, 15367, 15366, 15537, 15545, 15546, 15543
41127, 15363, 15364, 15368, 15367, 15539, 15547, 15548, 15545
41128, 15364, 15365, 15369, 15368, 15541, 15549, 15550, 15547
41129, 15365, 2010, 2011, 15369, 15542, 0, 15551, 15549
41130, 559, 15366, 15370, 560, 15544, 15552, 15553, 0
41131, 15366, 15367, 15371, 15370, 15546, 15554, 15555, 15552
41132, 15367, 15368, 15372, 15371, 15548, 15556, 15557, 15554
41133, 15368, 15369, 15373, 15372, 15550, 15558, 15559, 15556
41134, 15369, 2011, 2012, 15373, 15551, 0, 15560, 15558
41135, 560, 15370, 15374, 561, 15553, 15561, 15562, 0
41136, 15370, 15371, 15375, 15374, 15555, 15563, 15564, 15561
41137, 15371, 15372, 15376, 15375, 15557, 15565, 15566, 15563
41138, 15372, 15373, 15377, 15376, 15559, 15567, 15568, 15565
41139, 15373, 2012, 2013, 15377, 15560, 0, 15569, 15567
41140, 561, 15374, 15378, 562, 15562, 15570, 15571, 0
41141, 15374, 15375, 15379, 15378, 15564, 15572, 15573, 15570
41142, 15375, 15376, 15380, 15379, 15566, 15574, 15575, 15572
41143, 15376, 15377, 15381, 15380, 15568, 15576, 15577, 15574
41144, 15377, 2013, 2014, 15381, 15569, 0, 15578, 15576
41145, 562, 15378, 15382, 563, 15571, 15579, 15580, 0
41146, 15378, 15379, 15383, 15382, 15573, 15581, 15582, 15579
41147, 15379, 15380, 15384, 15383, 15575, 15583, 15584, 15581
41148, 15380, 15381, 15385, 15384, 15577, 15585, 15586, 15583
41149, 15381, 2014, 2015, 15385, 15578, 0, 15587, 15585
41150, 563, 15382, 15386, 564, 15580, 15588, 15589, 0
41151, 15382, 15383, 15387, 15386, 15582, 15590, 15591, 15588
41152, 15383, 15384, 15388, 15387, 15584, 15592, 15593, 15590
41153, 15384, 15385, 15389, 15388, 15586, 15594, 15595, 15592
41154, 15385, 2015, 2016, 15389, 15587, 0, 15596, 15594
41155, 564, 15386, 1976, 21, 15589, 15597, 1980, 0
41156, 15386, 15387, 1977, 1976, 15591, 15598, 1981, 15597
41157, 15387, 15388, 1978, 1977, 15593, 15599, 1982, 15598
41158, 15388, 15389, 1979, 1978, 15595, 15600, 1983, 15599
41159, 15389, 2016, 77, 1979, 15596, 0, 1984, 15600
*ELEMENT, type=CPS8, ELSET=Surface106
41160, 21, 1976, 15601, 567, 1980, 15645, 15646, 0
41161, 1976, 1977, 15602, 15601, 1981, 15647, 15648, 15645
41162, 1977, 1978, 15603, 15602, 1982, 15649, 15650, 15647
41163, 1978, 1979, 15604, 15603, 1983, 15651, 15652, 15649
41164, 1979, 77, 2021, 15604, 1984, 0, 15653, 15651
41165, 567, 15601, 15605, 568, 15646, 15654, 15655, 0
41166, 15601, 15602, 15606, 15605, 15648, 15656, 15657, 15654
41167, 15602, 15603, 15607, 15606, 15650, 15658, 15659, 15656
41168, 15603, 15604, 15608, 15607, 15652, 15660, 15661, 15658
41169, 15604, 2021, 2022, 15608, 15653, 0, 15662, 15660
41170, 568, 15605, 15609, 569, 15655, 15663, 15664, 0
41171, 15605, 15606, 15610, 15609, 15657, 15665, 15666, 15663
41172, 15606, 15607, 15611, 15610, 15659, 15667, 15668, 15665
41173, 15607, 15608, 15612, 15611, 15661, 15669, 15670, 15667
41174, 15608, 2022, 2023, 15612, 15662, 0, 15671, 15669
41175, 569, 15609, 15613, 570, 15664, 15672, 15673, 0
41176, 15609, 15610, 15614, 15613, 15666, 15674, 15675, 15672
41177, 15610, 15611, 15615, 15614, 15668, 15676, 15677, 15674
41178, 15611, 15612, 15616, 15615, 15670, 15678, 15679, 15676
41179, 15612, 2023, 2024, 15616, 15671, 0, 15680, 15678
41180, 570, 15613, 15617, 571, 15673, 15681, 15682, 0
41181, 15613, 15614, 15618, 15617, 15675, 15683, 15684, 15681
41182, 15614, 15615, 15619, 15618, 15677, 15685, 15686, 15683
41183, 15615, 15616, 15620, 15619, 15679, 15687, 15688, 15685
41184, 15616, 2024, 2025, 15620, 15680, 0, 15689, 15687
41185, 571, 15617, 15621, 572, 15682, 15690, 15691, 0
41186, 15617, 15618, 15622, 15621, 15684, 15692, 15693, 15690
41187, 15618, 15619, 15623, 15622, 15686, 15694, 15695, 15692
41188, 15619, 15620, 15624, 15623, 15688, 15696, 15697, 15694
41189, 15620, 2025, 2026, 15624, 15689, 0, 15698, 15696
41190, 572, 15621, 15625, 573, 15691, 15699, 15700, 0
41191, 15621, 15622, 15626, 15625, 15693, 15701, 15702, 15699
41192, 15622, 15623, 15627, 15626, 15695, 15703, 15704, 15701
41193, 15623, 15624, 15628, 15627, 15697, 15705, 15706, 15703
41194, 15624, 2026, 2027, 15628, 15698, 0, 15707, 15705
41195, 573, 15625, 15629, 574, 15700, 15708, 15709, 0
41196, 15625, 15626, 15630, 15629, 15702, 15710, 15711, 15708
41197, 15626, 15627, 15631, 15630, 15704, 15712, 15713, 15710
41198, 15627, 15628, 15632, 15631, 15706, 15714, 15715, 15712
41199, 15628, 2027, 2028, 15632, 15707, 0, 15716, 15714
41200, 574, 15629, 15633, 575, 15709, 15717, 15718, 0
41201, 15629, 15630, 15634, 15633, 15711, 15719, 15720, 15717
41202, 15630, 15631, 15635, 15634, 15713, 15721, 15722, 15719
41203, 15631, 15632, 15636, 15635, 15715, 15723, 15724, 15721
41204, 15632, 2028, 2029, 15636, 15716, 0, 15725, 15723
41205, 575, 15633, 15637, 576, 15718, 15726, 15727, 0
41206, 15633, 15634, 15638, 15637, 15720, 15728, 15729, 15726
41207, 15634, 15635, 15639, 15638, 15722, 15730, 15731, 15728
41208, 15635, 15636, 15640, 15639, 15724, 15732, 15733, 15730
41209, 15636, 2029, 2030, 15640, 15725, 0, 15734, 15732
41210, 576, 15637, 15641, 577, 15727, 15735, 15736, 0
41211, 15637, 15638, 15642, 15641, 15729, 15737, 15738, 15735
41212, 15638, 15639, 15643, 15642, 15731, 15739, 15740, 15737
41213, 15639, 15640, 15644, 15643, 15733, 15741, 15742, 15739
41214, 15640, 2030, 2031, 15644, 15734, 0, 15743, 15741
41215, 577, 15641, 2017, 23, 15736, 15744, 0, 0
41216, 15641, 15642, 2018, 2017, 15738, 15745, 0, 15744
41217, 15642, 15643, 2019, 2018, 15740, 15746, 0, 15745
41218, 15643, 15644, 2020, 2019, 15742, 15747, 0, 15746
41219, 15644, 2031, 79, 2020, 15743, 0, 0, 15747
*ELEMENT, type=CPS8, ELSET=Surface107
3635, 24, 580, 15748, 2032, 0, 0, 0, 0
3636, 2032, 15748, 15749, 2033, 0, 0, 0, 0
3637, 2033, 15749, 15750, 2034, 0, 0, 0, 0
3638, 2034, 15750, 15751, 2035, 0, 0, 0, 0
3639, 2035, 15751, 2036, 80, 0, 0, 0, 0
3640, 580, 581, 15752, 15748, 0, 0, 0, 0
3641, 15748, 15752, 15753, 15749, 0, 0, 0, 0
3642, 15749, 15753, 15754, 15750, 0, 0, 0, 0
3643, 15750, 15754, 15755, 15751, 0, 0, 0, 0
3644, 15751, 15755, 2037, 2036, 0, 0, 0, 0
3645, 581, 582, 15756, 15752, 0, 0, 0, 0
3646, 15752, 15756, 15757, 15753, 0, 0, 0, 0
3647, 15753, 15757, 15758, 15754, 0, 0, 0, 0
3648, 15754, 15758, 15759, 15755, 0, 0, 0, 0
3649, 15755, 15759, 2038, 2037, 0, 0, 0, 0
3650, 582, 583, 15760, 15756, 0, 0, 0, 0
3651, 15756, 15760, 15761, 15757, 0, 0, 0, 0
3652, 15757, 15761, 15762, 15758, 0, 0, 0, 0
3653, 15758, 15762, 15763, 15759, 0, 0, 0, 0
3654, 15759, 15763, 2039, 2038, 0, 0, 0, 0
3655, 583, 584, 15764, 15760, 0, 0, 0, 0
3656, 15760, 15764, 15765, 15761, 0, 0, 0, 0
3657, 15761, 15765, 15766, 15762, 0, 0, 0, 0
3658, 15762, 15766, 15767, 15763, 0, 0, 0, 0
3659, 15763, 15767, 2040, 2039, 0, 0, 0, 0
3660, 584, 585, 15768, 15764, 0, 0, 0, 0
3661, 15764, 15768, 15769, 15765, 0, 0, 0, 0
3662, 15765, 15769, 15770, 15766, 0, 0, 0, 0
3663, 15766, 15770, 15771, 15767, 0, 0, 0, 0
3664, 15767, 15771, 2041, 2040, 0, 0, 0, 0
3665, 585, 586, 15772, 15768, 0, 0, 0, 0
3666, 15768, 15772, 15773, 15769, 0, 0, 0, 0
3667, 15769, 15773, 15774, 15770, 0, 0, 0, 0
3668, 15770, 15774, 15775, 15771, 0, 0, 0, 0
3669, 15771, 15775, 2042, 2041, 0, 0, 0, 0
3670, 586, 587, 15776, 15772, 0, 0, 0, 0
3671, 15772, 15776, 15777, 15773, 0, 0, 0, 0
3672, 15773, 15777, 15778, 15774, 0, 0, 0, 0
3673, 15774, 15778, 15779, 15775, 0, 0, 0, 0
3674, 15775, 15779, 2043, 2042, 0, 0, 0, 0
3675, 587, 588, 15780, 15776, 0, 0, 0, 0
3676, 15776, 15780, 15781, 15777, 0, 0, 0, 0
3677, 15777, 15781, 15782, 15778, 0, 0, 0, 0
3678, 15778, 15782, 15783, 15779, 0, 0, 0, 0
3679, 15779, 15783, 2044, 2043, 0, 0, 0, 0
3680, 588, 589, 15784, 15780, 0, 0, 0, 0
3681, 15780, 15784, 15785, 15781, 0, 0, 0, 0
3682, 15781, 15785, 15786, 15782, 0, 0, 0, 0
3683, 15782, 15786, 15787, 15783, 0, 0, 0, 0
3684, 15783, 15787, 2045, 2044, 0, 0, 0, 0
3685, 589, 590, 15788, 15784, 0, 0, 0, 0
3686, 15784, 15788, 15789, 15785, 0, 0, 0, 0
3687, 15785, 15789, 15790, 15786, 0, 0, 0, 0
3688, 15786, 15790, 15791, 15787, 0, 0, 0, 0
3689, 15787, 15791, 2046, 2045, 0, 0, 0, 0
3690, 590, 591, 15792, 15788, 0, 0, 0, 0
3691, 15788, 15792, 15793, 15789, 0, 0, 0, 0
3692, 15789, 15793, 15794, 15790, 0, 0, 0, 0
3693, 15790, 15794, 15795, 15791, 0, 0, 0, 0
3694, 15791, 15795, 2047, 2046, 0, 0, 0, 0
3695, 591, 592, 15796, 15792, 0, 0, 0, 0
3696, 15792, 15796, 15797, 15793, 0, 0, 0, 0
3697, 15793, 15797, 15798, 15794, 0, 0, 0, 0
3698, 15794, 15798, 15799, 15795, 0, 0, 0, 0
3699, 15795, 15799, 2048, 2047, 0, 0, 0, 0
3700, 592, 593, 15800, 15796, 0, 0, 0, 0
3701, 15796, 15800, 15801, 15797, 0, 0, 0, 0
3702, 15797, 15801, 15802, 15798, 0, 0, 0, 0
3703, 15798, 15802, 15803, 15799, 0, 0, 0, 0
3704, 15799, 15803, 2049, 2048, 0, 0, 0, 0
3705, 593, 594, 15804, 15800, 0, 0, 0, 0
3706, 15800, 15804, 15805, 15801, 0, 0, 0, 0
3707, 15801, 15805, 15806, 15802, 0, 0, 0, 0
3708, 15802, 15806, 15807, 15803, 0, 0, 0, 0
3709, 15803, 15807, 2050, 2049, 0, 0, 0, 0
3710, 594, 595, 15808, 15804, 0, 0, 0, 0
3711, 15804, 15808, 15809, 15805, 0, 0, 0, 0
3712, 15805, 15809, 15810, 15806, 0, 0, 0, 0
3713, 15806, 15810, 15811, 15807, 0, 0, 0, 0
3714, 15807, 15811, 2051, 2050, 0, 0, 0, 0
3715, 595, 596, 15812, 15808, 0, 0, 0, 0
3716, 15808, 15812, 15813, 15809, 0, 0, 0, 0
3717, 15809, 15813, 15814, 15810, 0, 0, 0, 0
3718, 15810, 15814, 15815, 15811, 0, 0, 0, 0
3719, 15811, 15815, 2052, 2051, 0, 0, 0, 0
3720, 596, 597, 15816, 15812, 0, 0, 0, 0
3721, 15812, 15816, 15817, 15813, 0, 0, 0, 0
3722, 15813, 15817, 15818, 15814, 0, 0, 0, 0
3723, 15814, 15818, 15819, 15815, 0, 0, 0, 0
3724, 15815, 15819, 2053, 2052, 0, 0, 0, 0
3725, 597, 598, 15820, 15816, 0, 0, 0, 0
3726, 15816, 15820, 15821, 15817, 0, 0, 0, 0
3727, 15817, 15821, 15822, 15818, 0, 0, 0, 0
3728, 15818, 15822, 15823, 15819, 0, 0, 0, 0
3729, 15819, 15823, 2054, 2053, 0, 0, 0, 0
3730, 598, 599, 15824, 15820, 0, 0, 0, 0
3731, 15820, 15824, 15825, 15821, 0, 0, 0, 0
3732, 15821, 15825, 15826, 15822, 0, 0, 0, 0
3733, 15822, 15826, 15827, 15823, 0, 0, 0, 0
3734, 15823, 15827, 2055, 2054, 0, 0, 0, 0
3735, 599, 600, 15828, 15824, 0, 0, 0, 0
3736, 15824, 15828, 15829, 15825, 0, 0, 0, 0
3737, 15825, 15829, 15830, 15826, 0, 0, 0, 0
3738, 15826, 15830, 15831, 15827, 0, 0, 0, 0
3739, 15827, 15831, 2056, 2055, 0, 0, 0, 0
3740, 600, 601, 15832, 15828, 0, 0, 0, 0
3741, 15828, 15832, 15833, 15829, 0, 0, 0, 0
