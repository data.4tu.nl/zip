22666, 32555, 32578, 7140, 7117, 32556, 32579, 7141, 7118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22667, 32556, 32579, 7141, 7118, 32557, 32580, 7142, 7119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22668, 32557, 32580, 7142, 7119, 32558, 32581, 7143, 7120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22669, 32558, 32581, 7143, 7120, 32559, 32582, 7144, 7121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22670, 32559, 32582, 7144, 7121, 32560, 32583, 7145, 7122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22671, 32560, 32583, 7145, 7122, 32561, 32584, 7146, 7123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22672, 32561, 32584, 7146, 7123, 32562, 32585, 7147, 7124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22673, 32562, 32585, 7147, 7124, 32563, 32586, 7148, 7125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22674, 32563, 32586, 7148, 7125, 32564, 32587, 7149, 7126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22675, 32564, 32587, 7149, 7126, 32565, 32588, 7150, 7127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22676, 32565, 32588, 7150, 7127, 32566, 32589, 7151, 7128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22677, 32566, 32589, 7151, 7128, 8570, 8571, 904, 903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22678, 6754, 6755, 791, 790, 32567, 32590, 7152, 7129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22679, 32567, 32590, 7152, 7129, 32568, 32591, 7153, 7130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22680, 32568, 32591, 7153, 7130, 32569, 32592, 7154, 7131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22681, 32569, 32592, 7154, 7131, 32570, 32593, 7155, 7132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22682, 32570, 32593, 7155, 7132, 32571, 32594, 7156, 7133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22683, 32571, 32594, 7156, 7133, 32572, 32595, 7157, 7134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22684, 32572, 32595, 7157, 7134, 32573, 32596, 7158, 7135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22685, 32573, 32596, 7158, 7135, 32574, 32597, 7159, 7136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22686, 32574, 32597, 7159, 7136, 32575, 32598, 7160, 7137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22687, 32575, 32598, 7160, 7137, 32576, 32599, 7161, 7138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22688, 32576, 32599, 7161, 7138, 32577, 32600, 7162, 7139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22689, 32577, 32600, 7162, 7139, 32578, 32601, 7163, 7140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22690, 32578, 32601, 7163, 7140, 32579, 32602, 7164, 7141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22691, 32579, 32602, 7164, 7141, 32580, 32603, 7165, 7142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22692, 32580, 32603, 7165, 7142, 32581, 32604, 7166, 7143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22693, 32581, 32604, 7166, 7143, 32582, 32605, 7167, 7144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22694, 32582, 32605, 7167, 7144, 32583, 32606, 7168, 7145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22695, 32583, 32606, 7168, 7145, 32584, 32607, 7169, 7146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22696, 32584, 32607, 7169, 7146, 32585, 32608, 7170, 7147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22697, 32585, 32608, 7170, 7147, 32586, 32609, 7171, 7148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22698, 32586, 32609, 7171, 7148, 32587, 32610, 7172, 7149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22699, 32587, 32610, 7172, 7149, 32588, 32611, 7173, 7150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22700, 32588, 32611, 7173, 7150, 32589, 32612, 7174, 7151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22701, 32589, 32612, 7174, 7151, 8571, 8572, 905, 904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22702, 6755, 6756, 792, 791, 32590, 32613, 7175, 7152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22703, 32590, 32613, 7175, 7152, 32591, 32614, 7176, 7153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22704, 32591, 32614, 7176, 7153, 32592, 32615, 7177, 7154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22705, 32592, 32615, 7177, 7154, 32593, 32616, 7178, 7155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22706, 32593, 32616, 7178, 7155, 32594, 32617, 7179, 7156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22707, 32594, 32617, 7179, 7156, 32595, 32618, 7180, 7157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22708, 32595, 32618, 7180, 7157, 32596, 32619, 7181, 7158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22709, 32596, 32619, 7181, 7158, 32597, 32620, 7182, 7159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22710, 32597, 32620, 7182, 7159, 32598, 32621, 7183, 7160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22711, 32598, 32621, 7183, 7160, 32599, 32622, 7184, 7161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22712, 32599, 32622, 7184, 7161, 32600, 32623, 7185, 7162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22713, 32600, 32623, 7185, 7162, 32601, 32624, 7186, 7163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22714, 32601, 32624, 7186, 7163, 32602, 32625, 7187, 7164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22715, 32602, 32625, 7187, 7164, 32603, 32626, 7188, 7165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22716, 32603, 32626, 7188, 7165, 32604, 32627, 7189, 7166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22717, 32604, 32627, 7189, 7166, 32605, 32628, 7190, 7167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22718, 32605, 32628, 7190, 7167, 32606, 32629, 7191, 7168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22719, 32606, 32629, 7191, 7168, 32607, 32630, 7192, 7169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22720, 32607, 32630, 7192, 7169, 32608, 32631, 7193, 7170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22721, 32608, 32631, 7193, 7170, 32609, 32632, 7194, 7171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22722, 32609, 32632, 7194, 7171, 32610, 32633, 7195, 7172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22723, 32610, 32633, 7195, 7172, 32611, 32634, 7196, 7173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22724, 32611, 32634, 7196, 7173, 32612, 32635, 7197, 7174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22725, 32612, 32635, 7197, 7174, 8572, 8573, 906, 905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22726, 6756, 6757, 793, 792, 32613, 32636, 7198, 7175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22727, 32613, 32636, 7198, 7175, 32614, 32637, 7199, 7176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22728, 32614, 32637, 7199, 7176, 32615, 32638, 7200, 7177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22729, 32615, 32638, 7200, 7177, 32616, 32639, 7201, 7178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22730, 32616, 32639, 7201, 7178, 32617, 32640, 7202, 7179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22731, 32617, 32640, 7202, 7179, 32618, 32641, 7203, 7180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22732, 32618, 32641, 7203, 7180, 32619, 32642, 7204, 7181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22733, 32619, 32642, 7204, 7181, 32620, 32643, 7205, 7182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22734, 32620, 32643, 7205, 7182, 32621, 32644, 7206, 7183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22735, 32621, 32644, 7206, 7183, 32622, 32645, 7207, 7184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22736, 32622, 32645, 7207, 7184, 32623, 32646, 7208, 7185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22737, 32623, 32646, 7208, 7185, 32624, 32647, 7209, 7186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22738, 32624, 32647, 7209, 7186, 32625, 32648, 7210, 7187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22739, 32625, 32648, 7210, 7187, 32626, 32649, 7211, 7188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22740, 32626, 32649, 7211, 7188, 32627, 32650, 7212, 7189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22741, 32627, 32650, 7212, 7189, 32628, 32651, 7213, 7190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22742, 32628, 32651, 7213, 7190, 32629, 32652, 7214, 7191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22743, 32629, 32652, 7214, 7191, 32630, 32653, 7215, 7192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22744, 32630, 32653, 7215, 7192, 32631, 32654, 7216, 7193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22745, 32631, 32654, 7216, 7193, 32632, 32655, 7217, 7194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22746, 32632, 32655, 7217, 7194, 32633, 32656, 7218, 7195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22747, 32633, 32656, 7218, 7195, 32634, 32657, 7219, 7196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22748, 32634, 32657, 7219, 7196, 32635, 32658, 7220, 7197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22749, 32635, 32658, 7220, 7197, 8573, 8574, 907, 906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22750, 6757, 6758, 794, 793, 32636, 32659, 7221, 7198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22751, 32636, 32659, 7221, 7198, 32637, 32660, 7222, 7199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22752, 32637, 32660, 7222, 7199, 32638, 32661, 7223, 7200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22753, 32638, 32661, 7223, 7200, 32639, 32662, 7224, 7201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22754, 32639, 32662, 7224, 7201, 32640, 32663, 7225, 7202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22755, 32640, 32663, 7225, 7202, 32641, 32664, 7226, 7203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22756, 32641, 32664, 7226, 7203, 32642, 32665, 7227, 7204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22757, 32642, 32665, 7227, 7204, 32643, 32666, 7228, 7205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22758, 32643, 32666, 7228, 7205, 32644, 32667, 7229, 7206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22759, 32644, 32667, 7229, 7206, 32645, 32668, 7230, 7207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22760, 32645, 32668, 7230, 7207, 32646, 32669, 7231, 7208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22761, 32646, 32669, 7231, 7208, 32647, 32670, 7232, 7209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22762, 32647, 32670, 7232, 7209, 32648, 32671, 7233, 7210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22763, 32648, 32671, 7233, 7210, 32649, 32672, 7234, 7211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22764, 32649, 32672, 7234, 7211, 32650, 32673, 7235, 7212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22765, 32650, 32673, 7235, 7212, 32651, 32674, 7236, 7213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22766, 32651, 32674, 7236, 7213, 32652, 32675, 7237, 7214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22767, 32652, 32675, 7237, 7214, 32653, 32676, 7238, 7215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22768, 32653, 32676, 7238, 7215, 32654, 32677, 7239, 7216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22769, 32654, 32677, 7239, 7216, 32655, 32678, 7240, 7217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22770, 32655, 32678, 7240, 7217, 32656, 32679, 7241, 7218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22771, 32656, 32679, 7241, 7218, 32657, 32680, 7242, 7219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22772, 32657, 32680, 7242, 7219, 32658, 32681, 7243, 7220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22773, 32658, 32681, 7243, 7220, 8574, 8575, 908, 907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22774, 6758, 6759, 795, 794, 32659, 32682, 7244, 7221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22775, 32659, 32682, 7244, 7221, 32660, 32683, 7245, 7222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22776, 32660, 32683, 7245, 7222, 32661, 32684, 7246, 7223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22777, 32661, 32684, 7246, 7223, 32662, 32685, 7247, 7224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22778, 32662, 32685, 7247, 7224, 32663, 32686, 7248, 7225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22779, 32663, 32686, 7248, 7225, 32664, 32687, 7249, 7226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22780, 32664, 32687, 7249, 7226, 32665, 32688, 7250, 7227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22781, 32665, 32688, 7250, 7227, 32666, 32689, 7251, 7228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22782, 32666, 32689, 7251, 7228, 32667, 32690, 7252, 7229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22783, 32667, 32690, 7252, 7229, 32668, 32691, 7253, 7230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22784, 32668, 32691, 7253, 7230, 32669, 32692, 7254, 7231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22785, 32669, 32692, 7254, 7231, 32670, 32693, 7255, 7232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22786, 32670, 32693, 7255, 7232, 32671, 32694, 7256, 7233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22787, 32671, 32694, 7256, 7233, 32672, 32695, 7257, 7234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22788, 32672, 32695, 7257, 7234, 32673, 32696, 7258, 7235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22789, 32673, 32696, 7258, 7235, 32674, 32697, 7259, 7236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22790, 32674, 32697, 7259, 7236, 32675, 32698, 7260, 7237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22791, 32675, 32698, 7260, 7237, 32676, 32699, 7261, 7238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22792, 32676, 32699, 7261, 7238, 32677, 32700, 7262, 7239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22793, 32677, 32700, 7262, 7239, 32678, 32701, 7263, 7240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22794, 32678, 32701, 7263, 7240, 32679, 32702, 7264, 7241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22795, 32679, 32702, 7264, 7241, 32680, 32703, 7265, 7242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22796, 32680, 32703, 7265, 7242, 32681, 32704, 7266, 7243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22797, 32681, 32704, 7266, 7243, 8575, 8576, 909, 908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22798, 6759, 6760, 796, 795, 32682, 32705, 7267, 7244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22799, 32682, 32705, 7267, 7244, 32683, 32706, 7268, 7245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22800, 32683, 32706, 7268, 7245, 32684, 32707, 7269, 7246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22801, 32684, 32707, 7269, 7246, 32685, 32708, 7270, 7247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22802, 32685, 32708, 7270, 7247, 32686, 32709, 7271, 7248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22803, 32686, 32709, 7271, 7248, 32687, 32710, 7272, 7249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22804, 32687, 32710, 7272, 7249, 32688, 32711, 7273, 7250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22805, 32688, 32711, 7273, 7250, 32689, 32712, 7274, 7251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22806, 32689, 32712, 7274, 7251, 32690, 32713, 7275, 7252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22807, 32690, 32713, 7275, 7252, 32691, 32714, 7276, 7253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22808, 32691, 32714, 7276, 7253, 32692, 32715, 7277, 7254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22809, 32692, 32715, 7277, 7254, 32693, 32716, 7278, 7255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22810, 32693, 32716, 7278, 7255, 32694, 32717, 7279, 7256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22811, 32694, 32717, 7279, 7256, 32695, 32718, 7280, 7257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22812, 32695, 32718, 7280, 7257, 32696, 32719, 7281, 7258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22813, 32696, 32719, 7281, 7258, 32697, 32720, 7282, 7259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22814, 32697, 32720, 7282, 7259, 32698, 32721, 7283, 7260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22815, 32698, 32721, 7283, 7260, 32699, 32722, 7284, 7261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22816, 32699, 32722, 7284, 7261, 32700, 32723, 7285, 7262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22817, 32700, 32723, 7285, 7262, 32701, 32724, 7286, 7263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22818, 32701, 32724, 7286, 7263, 32702, 32725, 7287, 7264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22819, 32702, 32725, 7287, 7264, 32703, 32726, 7288, 7265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22820, 32703, 32726, 7288, 7265, 32704, 32727, 7289, 7266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22821, 32704, 32727, 7289, 7266, 8576, 8577, 910, 909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22822, 6760, 841, 34, 796, 32705, 8302, 865, 7267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22823, 32705, 8302, 865, 7267, 32706, 8303, 866, 7268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22824, 32706, 8303, 866, 7268, 32707, 8304, 867, 7269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22825, 32707, 8304, 867, 7269, 32708, 8305, 868, 7270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22826, 32708, 8305, 868, 7270, 32709, 8306, 869, 7271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22827, 32709, 8306, 869, 7271, 32710, 8307, 870, 7272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22828, 32710, 8307, 870, 7272, 32711, 8308, 871, 7273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22829, 32711, 8308, 871, 7273, 32712, 8309, 872, 7274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22830, 32712, 8309, 872, 7274, 32713, 8310, 873, 7275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22831, 32713, 8310, 873, 7275, 32714, 8311, 874, 7276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22832, 32714, 8311, 874, 7276, 32715, 8312, 875, 7277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22833, 32715, 8312, 875, 7277, 32716, 8313, 876, 7278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22834, 32716, 8313, 876, 7278, 32717, 8314, 877, 7279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22835, 32717, 8314, 877, 7279, 32718, 8315, 878, 7280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22836, 32718, 8315, 878, 7280, 32719, 8316, 879, 7281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22837, 32719, 8316, 879, 7281, 32720, 8317, 880, 7282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22838, 32720, 8317, 880, 7282, 32721, 8318, 881, 7283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22839, 32721, 8318, 881, 7283, 32722, 8319, 882, 7284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22840, 32722, 8319, 882, 7284, 32723, 8320, 883, 7285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22841, 32723, 8320, 883, 7285, 32724, 8321, 884, 7286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22842, 32724, 8321, 884, 7286, 32725, 8322, 885, 7287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22843, 32725, 8322, 885, 7287, 32726, 8323, 886, 7288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22844, 32726, 8323, 886, 7288, 32727, 8324, 887, 7289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
22845, 32727, 8324, 887, 7289, 8577, 1001, 38, 910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume10
22846, 39, 957, 8325, 980, 43, 1027, 8623, 1074, 0, 0, 0, 0, 1050, 8876, 8877, 
1085, 1025, 8578, 32728, 8601
22847, 957, 958, 8326, 8325, 1027, 1028, 8624, 8623, 0, 0, 0, 0, 1051, 8878, 8879, 
8876, 8578, 8579, 32729, 32728
22848, 958, 959, 8327, 8326, 1028, 1029, 8625, 8624, 0, 0, 0, 0, 1052, 8880, 8881, 
8878, 8579, 8580, 32730, 32729
22849, 959, 960, 8328, 8327, 1029, 1030, 8626, 8625, 0, 0, 0, 0, 1053, 8882, 8883, 
8880, 8580, 8581, 32731, 32730
22850, 960, 961, 8329, 8328, 1030, 1031, 8627, 8626, 0, 0, 0, 0, 1054, 8884, 8885, 
8882, 8581, 8582, 32732, 32731
22851, 961, 962, 8330, 8329, 1031, 1032, 8628, 8627, 0, 0, 0, 0, 1055, 8886, 8887, 
8884, 8582, 8583, 32733, 32732
22852, 962, 963, 8331, 8330, 1032, 1033, 8629, 8628, 0, 0, 0, 0, 1056, 8888, 8889, 
8886, 8583, 8584, 32734, 32733
22853, 963, 964, 8332, 8331, 1033, 1034, 8630, 8629, 0, 0, 0, 0, 1057, 8890, 8891, 
8888, 8584, 8585, 32735, 32734
22854, 964, 965, 8333, 8332, 1034, 1035, 8631, 8630, 0, 0, 0, 0, 1058, 8892, 8893, 
8890, 8585, 8586, 32736, 32735
22855, 965, 966, 8334, 8333, 1035, 1036, 8632, 8631, 0, 0, 0, 0, 1059, 8894, 8895, 
8892, 8586, 8587, 32737, 32736
22856, 966, 967, 8335, 8334, 1036, 1037, 8633, 8632, 0, 0, 0, 0, 1060, 8896, 8897, 
8894, 8587, 8588, 32738, 32737
22857, 967, 968, 8336, 8335, 1037, 1038, 8634, 8633, 0, 0, 0, 0, 1061, 8898, 8899, 
8896, 8588, 8589, 32739, 32738
22858, 968, 969, 8337, 8336, 1038, 1039, 8635, 8634, 0, 0, 0, 0, 1062, 8900, 8901, 
8898, 8589, 8590, 32740, 32739
22859, 969, 970, 8338, 8337, 1039, 1040, 8636, 8635, 0, 0, 0, 0, 1063, 8902, 8903, 
8900, 8590, 8591, 32741, 32740
22860, 970, 971, 8339, 8338, 1040, 1041, 8637, 8636, 0, 0, 0, 0, 1064, 8904, 8905, 
8902, 8591, 8592, 32742, 32741
22861, 971, 972, 8340, 8339, 1041, 1042, 8638, 8637, 0, 0, 0, 0, 1065, 8906, 8907, 
8904, 8592, 8593, 32743, 32742
22862, 972, 973, 8341, 8340, 1042, 1043, 8639, 8638, 0, 0, 0, 0, 1066, 8908, 8909, 
8906, 8593, 8594, 32744, 32743
22863, 973, 974, 8342, 8341, 1043, 1044, 8640, 8639, 0, 0, 0, 0, 1067, 8910, 8911, 
8908, 8594, 8595, 32745, 32744
22864, 974, 975, 8343, 8342, 1044, 1045, 8641, 8640, 0, 0, 0, 0, 1068, 8912, 8913, 
8910, 8595, 8596, 32746, 32745
22865, 975, 976, 8344, 8343, 1045, 1046, 8642, 8641, 0, 0, 0, 0, 1069, 8914, 8915, 
8912, 8596, 8597, 32747, 32746
22866, 976, 977, 8345, 8344, 1046, 1047, 8643, 8642, 0, 0, 0, 0, 1070, 8916, 8917, 
8914, 8597, 8598, 32748, 32747
22867, 977, 978, 8346, 8345, 1047, 1048, 8644, 8643, 0, 0, 0, 0, 1071, 8918, 8919, 
8916, 8598, 8599, 32749, 32748
22868, 978, 979, 8347, 8346, 1048, 1049, 8645, 8644, 0, 0, 0, 0, 1072, 8920, 8921, 
8918, 8599, 8600, 32750, 32749
22869, 979, 40, 991, 8347, 1049, 44, 1097, 8645, 0, 0, 0, 0, 1073, 1108, 8922, 
8920, 8600, 1026, 8612, 32750
22870, 980, 8325, 8348, 981, 1074, 8623, 8646, 1075, 0, 0, 0, 0, 8877, 8923, 8924, 
1086, 8601, 32728, 32751, 8602
22871, 8325, 8326, 8349, 8348, 8623, 8624, 8647, 8646, 0, 0, 0, 0, 8879, 8925, 8926, 
8923, 32728, 32729, 32752, 32751
22872, 8326, 8327, 8350, 8349, 8624, 8625, 8648, 8647, 0, 0, 0, 0, 8881, 8927, 8928, 
8925, 32729, 32730, 32753, 32752
22873, 8327, 8328, 8351, 8350, 8625, 8626, 8649, 8648, 0, 0, 0, 0, 8883, 8929, 8930, 
8927, 32730, 32731, 32754, 32753
22874, 8328, 8329, 8352, 8351, 8626, 8627, 8650, 8649, 0, 0, 0, 0, 8885, 8931, 8932, 
8929, 32731, 32732, 32755, 32754
22875, 8329, 8330, 8353, 8352, 8627, 8628, 8651, 8650, 0, 0, 0, 0, 8887, 8933, 8934, 
8931, 32732, 32733, 32756, 32755
22876, 8330, 8331, 8354, 8353, 8628, 8629, 8652, 8651, 0, 0, 0, 0, 8889, 8935, 8936, 
8933, 32733, 32734, 32757, 32756
22877, 8331, 8332, 8355, 8354, 8629, 8630, 8653, 8652, 0, 0, 0, 0, 8891, 8937, 8938, 
8935, 32734, 32735, 32758, 32757
22878, 8332, 8333, 8356, 8355, 8630, 8631, 8654, 8653, 0, 0, 0, 0, 8893, 8939, 8940, 
8937, 32735, 32736, 32759, 32758
22879, 8333, 8334, 8357, 8356, 8631, 8632, 8655, 8654, 0, 0, 0, 0, 8895, 8941, 8942, 
8939, 32736, 32737, 32760, 32759
22880, 8334, 8335, 8358, 8357, 8632, 8633, 8656, 8655, 0, 0, 0, 0, 8897, 8943, 8944, 
8941, 32737, 32738, 32761, 32760
22881, 8335, 8336, 8359, 8358, 8633, 8634, 8657, 8656, 0, 0, 0, 0, 8899, 8945, 8946, 
8943, 32738, 32739, 32762, 32761
22882, 8336, 8337, 8360, 8359, 8634, 8635, 8658, 8657, 0, 0, 0, 0, 8901, 8947, 8948, 
8945, 32739, 32740, 32763, 32762
22883, 8337, 8338, 8361, 8360, 8635, 8636, 8659, 8658, 0, 0, 0, 0, 8903, 8949, 8950, 
8947, 32740, 32741, 32764, 32763
22884, 8338, 8339, 8362, 8361, 8636, 8637, 8660, 8659, 0, 0, 0, 0, 8905, 8951, 8952, 
8949, 32741, 32742, 32765, 32764
22885, 8339, 8340, 8363, 8362, 8637, 8638, 8661, 8660, 0, 0, 0, 0, 8907, 8953, 8954, 
8951, 32742, 32743, 32766, 32765
22886, 8340, 8341, 8364, 8363, 8638, 8639, 8662, 8661, 0, 0, 0, 0, 8909, 8955, 8956, 
8953, 32743, 32744, 32767, 32766
22887, 8341, 8342, 8365, 8364, 8639, 8640, 8663, 8662, 0, 0, 0, 0, 8911, 8957, 8958, 
8955, 32744, 32745, 32768, 32767
22888, 8342, 8343, 8366, 8365, 8640, 8641, 8664, 8663, 0, 0, 0, 0, 8913, 8959, 8960, 
8957, 32745, 32746, 32769, 32768
22889, 8343, 8344, 8367, 8366, 8641, 8642, 8665, 8664, 0, 0, 0, 0, 8915, 8961, 8962, 
8959, 32746, 32747, 32770, 32769
22890, 8344, 8345, 8368, 8367, 8642, 8643, 8666, 8665, 0, 0, 0, 0, 8917, 8963, 8964, 
8961, 32747, 32748, 32771, 32770
22891, 8345, 8346, 8369, 8368, 8643, 8644, 8667, 8666, 0, 0, 0, 0, 8919, 8965, 8966, 
8963, 32748, 32749, 32772, 32771
22892, 8346, 8347, 8370, 8369, 8644, 8645, 8668, 8667, 0, 0, 0, 0, 8921, 8967, 8968, 
8965, 32749, 32750, 32773, 32772
22893, 8347, 991, 992, 8370, 8645, 1097, 1098, 8668, 0, 0, 0, 0, 8922, 1109, 8969, 
8967, 32750, 8612, 8613, 32773
22894, 981, 8348, 8371, 982, 1075, 8646, 8669, 1076, 0, 0, 0, 0, 8924, 8970, 8971, 
1087, 8602, 32751, 32774, 8603
22895, 8348, 8349, 8372, 8371, 8646, 8647, 8670, 8669, 0, 0, 0, 0, 8926, 8972, 8973, 
8970, 32751, 32752, 32775, 32774
22896, 8349, 8350, 8373, 8372, 8647, 8648, 8671, 8670, 0, 0, 0, 0, 8928, 8974, 8975, 
8972, 32752, 32753, 32776, 32775
22897, 8350, 8351, 8374, 8373, 8648, 8649, 8672, 8671, 0, 0, 0, 0, 8930, 8976, 8977, 
8974, 32753, 32754, 32777, 32776
22898, 8351, 8352, 8375, 8374, 8649, 8650, 8673, 8672, 0, 0, 0, 0, 8932, 8978, 8979, 
8976, 32754, 32755, 32778, 32777
22899, 8352, 8353, 8376, 8375, 8650, 8651, 8674, 8673, 0, 0, 0, 0, 8934, 8980, 8981, 
8978, 32755, 32756, 32779, 32778
22900, 8353, 8354, 8377, 8376, 8651, 8652, 8675, 8674, 0, 0, 0, 0, 8936, 8982, 8983, 
8980, 32756, 32757, 32780, 32779
22901, 8354, 8355, 8378, 8377, 8652, 8653, 8676, 8675, 0, 0, 0, 0, 8938, 8984, 8985, 
8982, 32757, 32758, 32781, 32780
22902, 8355, 8356, 8379, 8378, 8653, 8654, 8677, 8676, 0, 0, 0, 0, 8940, 8986, 8987, 
8984, 32758, 32759, 32782, 32781
22903, 8356, 8357, 8380, 8379, 8654, 8655, 8678, 8677, 0, 0, 0, 0, 8942, 8988, 8989, 
8986, 32759, 32760, 32783, 32782
22904, 8357, 8358, 8381, 8380, 8655, 8656, 8679, 8678, 0, 0, 0, 0, 8944, 8990, 8991, 
8988, 32760, 32761, 32784, 32783
22905, 8358, 8359, 8382, 8381, 8656, 8657, 8680, 8679, 0, 0, 0, 0, 8946, 8992, 8993, 
8990, 32761, 32762, 32785, 32784
22906, 8359, 8360, 8383, 8382, 8657, 8658, 8681, 8680, 0, 0, 0, 0, 8948, 8994, 8995, 
8992, 32762, 32763, 32786, 32785
22907, 8360, 8361, 8384, 8383, 8658, 8659, 8682, 8681, 0, 0, 0, 0, 8950, 8996, 8997, 
8994, 32763, 32764, 32787, 32786
22908, 8361, 8362, 8385, 8384, 8659, 8660, 8683, 8682, 0, 0, 0, 0, 8952, 8998, 8999, 
8996, 32764, 32765, 32788, 32787
22909, 8362, 8363, 8386, 8385, 8660, 8661, 8684, 8683, 0, 0, 0, 0, 8954, 9000, 9001, 
8998, 32765, 32766, 32789, 32788
22910, 8363, 8364, 8387, 8386, 8661, 8662, 8685, 8684, 0, 0, 0, 0, 8956, 9002, 9003, 
9000, 32766, 32767, 32790, 32789
22911, 8364, 8365, 8388, 8387, 8662, 8663, 8686, 8685, 0, 0, 0, 0, 8958, 9004, 9005, 
9002, 32767, 32768, 32791, 32790
22912, 8365, 8366, 8389, 8388, 8663, 8664, 8687, 8686, 0, 0, 0, 0, 8960, 9006, 9007, 
9004, 32768, 32769, 32792, 32791
22913, 8366, 8367, 8390, 8389, 8664, 8665, 8688, 8687, 0, 0, 0, 0, 8962, 9008, 9009, 
9006, 32769, 32770, 32793, 32792
22914, 8367, 8368, 8391, 8390, 8665, 8666, 8689, 8688, 0, 0, 0, 0, 8964, 9010, 9011, 
9008, 32770, 32771, 32794, 32793
22915, 8368, 8369, 8392, 8391, 8666, 8667, 8690, 8689, 0, 0, 0, 0, 8966, 9012, 9013, 
9010, 32771, 32772, 32795, 32794
22916, 8369, 8370, 8393, 8392, 8667, 8668, 8691, 8690, 0, 0, 0, 0, 8968, 9014, 9015, 
9012, 32772, 32773, 32796, 32795
22917, 8370, 992, 993, 8393, 8668, 1098, 1099, 8691, 0, 0, 0, 0, 8969, 1110, 9016, 
9014, 32773, 8613, 8614, 32796
22918, 982, 8371, 8394, 983, 1076, 8669, 8692, 1077, 0, 0, 0, 0, 8971, 9017, 9018, 
1088, 8603, 32774, 32797, 8604
22919, 8371, 8372, 8395, 8394, 8669, 8670, 8693, 8692, 0, 0, 0, 0, 8973, 9019, 9020, 
9017, 32774, 32775, 32798, 32797
22920, 8372, 8373, 8396, 8395, 8670, 8671, 8694, 8693, 0, 0, 0, 0, 8975, 9021, 9022, 
9019, 32775, 32776, 32799, 32798
22921, 8373, 8374, 8397, 8396, 8671, 8672, 8695, 8694, 0, 0, 0, 0, 8977, 9023, 9024, 
9021, 32776, 32777, 32800, 32799
22922, 8374, 8375, 8398, 8397, 8672, 8673, 8696, 8695, 0, 0, 0, 0, 8979, 9025, 9026, 
9023, 32777, 32778, 32801, 32800
22923, 8375, 8376, 8399, 8398, 8673, 8674, 8697, 8696, 0, 0, 0, 0, 8981, 9027, 9028, 
9025, 32778, 32779, 32802, 32801
22924, 8376, 8377, 8400, 8399, 8674, 8675, 8698, 8697, 0, 0, 0, 0, 8983, 9029, 9030, 
9027, 32779, 32780, 32803, 32802
22925, 8377, 8378, 8401, 8400, 8675, 8676, 8699, 8698, 0, 0, 0, 0, 8985, 9031, 9032, 
9029, 32780, 32781, 32804, 32803
22926, 8378, 8379, 8402, 8401, 8676, 8677, 8700, 8699, 0, 0, 0, 0, 8987, 9033, 9034, 
9031, 32781, 32782, 32805, 32804
22927, 8379, 8380, 8403, 8402, 8677, 8678, 8701, 8700, 0, 0, 0, 0, 8989, 9035, 9036, 
9033, 32782, 32783, 32806, 32805
22928, 8380, 8381, 8404, 8403, 8678, 8679, 8702, 8701, 0, 0, 0, 0, 8991, 9037, 9038, 
9035, 32783, 32784, 32807, 32806
22929, 8381, 8382, 8405, 8404, 8679, 8680, 8703, 8702, 0, 0, 0, 0, 8993, 9039, 9040, 
9037, 32784, 32785, 32808, 32807
22930, 8382, 8383, 8406, 8405, 8680, 8681, 8704, 8703, 0, 0, 0, 0, 8995, 9041, 9042, 
9039, 32785, 32786, 32809, 32808
22931, 8383, 8384, 8407, 8406, 8681, 8682, 8705, 8704, 0, 0, 0, 0, 8997, 9043, 9044, 
9041, 32786, 32787, 32810, 32809
22932, 8384, 8385, 8408, 8407, 8682, 8683, 8706, 8705, 0, 0, 0, 0, 8999, 9045, 9046, 
9043, 32787, 32788, 32811, 32810
22933, 8385, 8386, 8409, 8408, 8683, 8684, 8707, 8706, 0, 0, 0, 0, 9001, 9047, 9048, 
9045, 32788, 32789, 32812, 32811
22934, 8386, 8387, 8410, 8409, 8684, 8685, 8708, 8707, 0, 0, 0, 0, 9003, 9049, 9050, 
9047, 32789, 32790, 32813, 32812
22935, 8387, 8388, 8411, 8410, 8685, 8686, 8709, 8708, 0, 0, 0, 0, 9005, 9051, 9052, 
9049, 32790, 32791, 32814, 32813
22936, 8388, 8389, 8412, 8411, 8686, 8687, 8710, 8709, 0, 0, 0, 0, 9007, 9053, 9054, 
9051, 32791, 32792, 32815, 32814
22937, 8389, 8390, 8413, 8412, 8687, 8688, 8711, 8710, 0, 0, 0, 0, 9009, 9055, 9056, 
9053, 32792, 32793, 32816, 32815
22938, 8390, 8391, 8414, 8413, 8688, 8689, 8712, 8711, 0, 0, 0, 0, 9011, 9057, 9058, 
9055, 32793, 32794, 32817, 32816
22939, 8391, 8392, 8415, 8414, 8689, 8690, 8713, 8712, 0, 0, 0, 0, 9013, 9059, 9060, 
9057, 32794, 32795, 32818, 32817
22940, 8392, 8393, 8416, 8415, 8690, 8691, 8714, 8713, 0, 0, 0, 0, 9015, 9061, 9062, 
9059, 32795, 32796, 32819, 32818
22941, 8393, 993, 994, 8416, 8691, 1099, 1100, 8714, 0, 0, 0, 0, 9016, 1111, 9063, 
9061, 32796, 8614, 8615, 32819
22942, 983, 8394, 8417, 984, 1077, 8692, 8715, 1078, 0, 0, 0, 0, 9018, 9064, 9065, 
1089, 8604, 32797, 32820, 8605
22943, 8394, 8395, 8418, 8417, 8692, 8693, 8716, 8715, 0, 0, 0, 0, 9020, 9066, 9067, 
9064, 32797, 32798, 32821, 32820
22944, 8395, 8396, 8419, 8418, 8693, 8694, 8717, 8716, 0, 0, 0, 0, 9022, 9068, 9069, 
9066, 32798, 32799, 32822, 32821
22945, 8396, 8397, 8420, 8419, 8694, 8695, 8718, 8717, 0, 0, 0, 0, 9024, 9070, 9071, 
9068, 32799, 32800, 32823, 32822
22946, 8397, 8398, 8421, 8420, 8695, 8696, 8719, 8718, 0, 0, 0, 0, 9026, 9072, 9073, 
9070, 32800, 32801, 32824, 32823
22947, 8398, 8399, 8422, 8421, 8696, 8697, 8720, 8719, 0, 0, 0, 0, 9028, 9074, 9075, 
9072, 32801, 32802, 32825, 32824
22948, 8399, 8400, 8423, 8422, 8697, 8698, 8721, 8720, 0, 0, 0, 0, 9030, 9076, 9077, 
9074, 32802, 32803, 32826, 32825
22949, 8400, 8401, 8424, 8423, 8698, 8699, 8722, 8721, 0, 0, 0, 0, 9032, 9078, 9079, 
9076, 32803, 32804, 32827, 32826
22950, 8401, 8402, 8425, 8424, 8699, 8700, 8723, 8722, 0, 0, 0, 0, 9034, 9080, 9081, 
9078, 32804, 32805, 32828, 32827
22951, 8402, 8403, 8426, 8425, 8700, 8701, 8724, 8723, 0, 0, 0, 0, 9036, 9082, 9083, 
9080, 32805, 32806, 32829, 32828
22952, 8403, 8404, 8427, 8426, 8701, 8702, 8725, 8724, 0, 0, 0, 0, 9038, 9084, 9085, 
9082, 32806, 32807, 32830, 32829
22953, 8404, 8405, 8428, 8427, 8702, 8703, 8726, 8725, 0, 0, 0, 0, 9040, 9086, 9087, 
9084, 32807, 32808, 32831, 32830
22954, 8405, 8406, 8429, 8428, 8703, 8704, 8727, 8726, 0, 0, 0, 0, 9042, 9088, 9089, 
9086, 32808, 32809, 32832, 32831
22955, 8406, 8407, 8430, 8429, 8704, 8705, 8728, 8727, 0, 0, 0, 0, 9044, 9090, 9091, 
9088, 32809, 32810, 32833, 32832
22956, 8407, 8408, 8431, 8430, 8705, 8706, 8729, 8728, 0, 0, 0, 0, 9046, 9092, 9093, 
9090, 32810, 32811, 32834, 32833
22957, 8408, 8409, 8432, 8431, 8706, 8707, 8730, 8729, 0, 0, 0, 0, 9048, 9094, 9095, 
9092, 32811, 32812, 32835, 32834
22958, 8409, 8410, 8433, 8432, 8707, 8708, 8731, 8730, 0, 0, 0, 0, 9050, 9096, 9097, 
9094, 32812, 32813, 32836, 32835
22959, 8410, 8411, 8434, 8433, 8708, 8709, 8732, 8731, 0, 0, 0, 0, 9052, 9098, 9099, 
9096, 32813, 32814, 32837, 32836
22960, 8411, 8412, 8435, 8434, 8709, 8710, 8733, 8732, 0, 0, 0, 0, 9054, 9100, 9101, 
9098, 32814, 32815, 32838, 32837
22961, 8412, 8413, 8436, 8435, 8710, 8711, 8734, 8733, 0, 0, 0, 0, 9056, 9102, 9103, 
9100, 32815, 32816, 32839, 32838
22962, 8413, 8414, 8437, 8436, 8711, 8712, 8735, 8734, 0, 0, 0, 0, 9058, 9104, 9105, 
9102, 32816, 32817, 32840, 32839
22963, 8414, 8415, 8438, 8437, 8712, 8713, 8736, 8735, 0, 0, 0, 0, 9060, 9106, 9107, 
9104, 32817, 32818, 32841, 32840
22964, 8415, 8416, 8439, 8438, 8713, 8714, 8737, 8736, 0, 0, 0, 0, 9062, 9108, 9109, 
9106, 32818, 32819, 32842, 32841
22965, 8416, 994, 995, 8439, 8714, 1100, 1101, 8737, 0, 0, 0, 0, 9063, 1112, 9110, 
9108, 32819, 8615, 8616, 32842
22966, 984, 8417, 8440, 985, 1078, 8715, 8738, 1079, 0, 0, 0, 0, 9065, 9111, 9112, 
1090, 8605, 32820, 32843, 8606
22967, 8417, 8418, 8441, 8440, 8715, 8716, 8739, 8738, 0, 0, 0, 0, 9067, 9113, 9114, 
9111, 32820, 32821, 32844, 32843
22968, 8418, 8419, 8442, 8441, 8716, 8717, 8740, 8739, 0, 0, 0, 0, 9069, 9115, 9116, 
9113, 32821, 32822, 32845, 32844
22969, 8419, 8420, 8443, 8442, 8717, 8718, 8741, 8740, 0, 0, 0, 0, 9071, 9117, 9118, 
9115, 32822, 32823, 32846, 32845
22970, 8420, 8421, 8444, 8443, 8718, 8719, 8742, 8741, 0, 0, 0, 0, 9073, 9119, 9120, 
9117, 32823, 32824, 32847, 32846
22971, 8421, 8422, 8445, 8444, 8719, 8720, 8743, 8742, 0, 0, 0, 0, 9075, 9121, 9122, 
9119, 32824, 32825, 32848, 32847
22972, 8422, 8423, 8446, 8445, 8720, 8721, 8744, 8743, 0, 0, 0, 0, 9077, 9123, 9124, 
9121, 32825, 32826, 32849, 32848
22973, 8423, 8424, 8447, 8446, 8721, 8722, 8745, 8744, 0, 0, 0, 0, 9079, 9125, 9126, 
9123, 32826, 32827, 32850, 32849
22974, 8424, 8425, 8448, 8447, 8722, 8723, 8746, 8745, 0, 0, 0, 0, 9081, 9127, 9128, 
9125, 32827, 32828, 32851, 32850
22975, 8425, 8426, 8449, 8448, 8723, 8724, 8747, 8746, 0, 0, 0, 0, 9083, 9129, 9130, 
9127, 32828, 32829, 32852, 32851
22976, 8426, 8427, 8450, 8449, 8724, 8725, 8748, 8747, 0, 0, 0, 0, 9085, 9131, 9132, 
9129, 32829, 32830, 32853, 32852
22977, 8427, 8428, 8451, 8450, 8725, 8726, 8749, 8748, 0, 0, 0, 0, 9087, 9133, 9134, 
9131, 32830, 32831, 32854, 32853
22978, 8428, 8429, 8452, 8451, 8726, 8727, 8750, 8749, 0, 0, 0, 0, 9089, 9135, 9136, 
9133, 32831, 32832, 32855, 32854
22979, 8429, 8430, 8453, 8452, 8727, 8728, 8751, 8750, 0, 0, 0, 0, 9091, 9137, 9138, 
9135, 32832, 32833, 32856, 32855
22980, 8430, 8431, 8454, 8453, 8728, 8729, 8752, 8751, 0, 0, 0, 0, 9093, 9139, 9140, 
9137, 32833, 32834, 32857, 32856
22981, 8431, 8432, 8455, 8454, 8729, 8730, 8753, 8752, 0, 0, 0, 0, 9095, 9141, 9142, 
9139, 32834, 32835, 32858, 32857
22982, 8432, 8433, 8456, 8455, 8730, 8731, 8754, 8753, 0, 0, 0, 0, 9097, 9143, 9144, 
9141, 32835, 32836, 32859, 32858
22983, 8433, 8434, 8457, 8456, 8731, 8732, 8755, 8754, 0, 0, 0, 0, 9099, 9145, 9146, 
9143, 32836, 32837, 32860, 32859
22984, 8434, 8435, 8458, 8457, 8732, 8733, 8756, 8755, 0, 0, 0, 0, 9101, 9147, 9148, 
9145, 32837, 32838, 32861, 32860
22985, 8435, 8436, 8459, 8458, 8733, 8734, 8757, 8756, 0, 0, 0, 0, 9103, 9149, 9150, 
9147, 32838, 32839, 32862, 32861
22986, 8436, 8437, 8460, 8459, 8734, 8735, 8758, 8757, 0, 0, 0, 0, 9105, 9151, 9152, 
9149, 32839, 32840, 32863, 32862
22987, 8437, 8438, 8461, 8460, 8735, 8736, 8759, 8758, 0, 0, 0, 0, 9107, 9153, 9154, 
9151, 32840, 32841, 32864, 32863
22988, 8438, 8439, 8462, 8461, 8736, 8737, 8760, 8759, 0, 0, 0, 0, 9109, 9155, 9156, 
9153, 32841, 32842, 32865, 32864
22989, 8439, 995, 996, 8462, 8737, 1101, 1102, 8760, 0, 0, 0, 0, 9110, 1113, 9157, 
9155, 32842, 8616, 8617, 32865
22990, 985, 8440, 8463, 986, 1079, 8738, 8761, 1080, 0, 0, 0, 0, 9112, 9158, 9159, 
1091, 8606, 32843, 32866, 8607
22991, 8440, 8441, 8464, 8463, 8738, 8739, 8762, 8761, 0, 0, 0, 0, 9114, 9160, 9161, 
9158, 32843, 32844, 32867, 32866
22992, 8441, 8442, 8465, 8464, 8739, 8740, 8763, 8762, 0, 0, 0, 0, 9116, 9162, 9163, 
9160, 32844, 32845, 32868, 32867
22993, 8442, 8443, 8466, 8465, 8740, 8741, 8764, 8763, 0, 0, 0, 0, 9118, 9164, 9165, 
9162, 32845, 32846, 32869, 32868
22994, 8443, 8444, 8467, 8466, 8741, 8742, 8765, 8764, 0, 0, 0, 0, 9120, 9166, 9167, 
9164, 32846, 32847, 32870, 32869
22995, 8444, 8445, 8468, 8467, 8742, 8743, 8766, 8765, 0, 0, 0, 0, 9122, 9168, 9169, 
9166, 32847, 32848, 32871, 32870
22996, 8445, 8446, 8469, 8468, 8743, 8744, 8767, 8766, 0, 0, 0, 0, 9124, 9170, 9171, 
9168, 32848, 32849, 32872, 32871
22997, 8446, 8447, 8470, 8469, 8744, 8745, 8768, 8767, 0, 0, 0, 0, 9126, 9172, 9173, 
9170, 32849, 32850, 32873, 32872
22998, 8447, 8448, 8471, 8470, 8745, 8746, 8769, 8768, 0, 0, 0, 0, 9128, 9174, 9175, 
9172, 32850, 32851, 32874, 32873
22999, 8448, 8449, 8472, 8471, 8746, 8747, 8770, 8769, 0, 0, 0, 0, 9130, 9176, 9177, 
9174, 32851, 32852, 32875, 32874
23000, 8449, 8450, 8473, 8472, 8747, 8748, 8771, 8770, 0, 0, 0, 0, 9132, 9178, 9179, 
9176, 32852, 32853, 32876, 32875
23001, 8450, 8451, 8474, 8473, 8748, 8749, 8772, 8771, 0, 0, 0, 0, 9134, 9180, 9181, 
9178, 32853, 32854, 32877, 32876
23002, 8451, 8452, 8475, 8474, 8749, 8750, 8773, 8772, 0, 0, 0, 0, 9136, 9182, 9183, 
9180, 32854, 32855, 32878, 32877
23003, 8452, 8453, 8476, 8475, 8750, 8751, 8774, 8773, 0, 0, 0, 0, 9138, 9184, 9185, 
9182, 32855, 32856, 32879, 32878
23004, 8453, 8454, 8477, 8476, 8751, 8752, 8775, 8774, 0, 0, 0, 0, 9140, 9186, 9187, 
9184, 32856, 32857, 32880, 32879
23005, 8454, 8455, 8478, 8477, 8752, 8753, 8776, 8775, 0, 0, 0, 0, 9142, 9188, 9189, 
9186, 32857, 32858, 32881, 32880
23006, 8455, 8456, 8479, 8478, 8753, 8754, 8777, 8776, 0, 0, 0, 0, 9144, 9190, 9191, 
9188, 32858, 32859, 32882, 32881
23007, 8456, 8457, 8480, 8479, 8754, 8755, 8778, 8777, 0, 0, 0, 0, 9146, 9192, 9193, 
9190, 32859, 32860, 32883, 32882
23008, 8457, 8458, 8481, 8480, 8755, 8756, 8779, 8778, 0, 0, 0, 0, 9148, 9194, 9195, 
9192, 32860, 32861, 32884, 32883
23009, 8458, 8459, 8482, 8481, 8756, 8757, 8780, 8779, 0, 0, 0, 0, 9150, 9196, 9197, 
9194, 32861, 32862, 32885, 32884
23010, 8459, 8460, 8483, 8482, 8757, 8758, 8781, 8780, 0, 0, 0, 0, 9152, 9198, 9199, 
9196, 32862, 32863, 32886, 32885
23011, 8460, 8461, 8484, 8483, 8758, 8759, 8782, 8781, 0, 0, 0, 0, 9154, 9200, 9201, 
9198, 32863, 32864, 32887, 32886
23012, 8461, 8462, 8485, 8484, 8759, 8760, 8783, 8782, 0, 0, 0, 0, 9156, 9202, 9203, 
9200, 32864, 32865, 32888, 32887
23013, 8462, 996, 997, 8485, 8760, 1102, 1103, 8783, 0, 0, 0, 0, 9157, 1114, 9204, 
9202, 32865, 8617, 8618, 32888
23014, 986, 8463, 8486, 987, 1080, 8761, 8784, 1081, 0, 0, 0, 0, 9159, 9205, 9206, 
1092, 8607, 32866, 32889, 8608
23015, 8463, 8464, 8487, 8486, 8761, 8762, 8785, 8784, 0, 0, 0, 0, 9161, 9207, 9208, 
9205, 32866, 32867, 32890, 32889
23016, 8464, 8465, 8488, 8487, 8762, 8763, 8786, 8785, 0, 0, 0, 0, 9163, 9209, 9210, 
9207, 32867, 32868, 32891, 32890
23017, 8465, 8466, 8489, 8488, 8763, 8764, 8787, 8786, 0, 0, 0, 0, 9165, 9211, 9212, 
9209, 32868, 32869, 32892, 32891
23018, 8466, 8467, 8490, 8489, 8764, 8765, 8788, 8787, 0, 0, 0, 0, 9167, 9213, 9214, 
9211, 32869, 32870, 32893, 32892
23019, 8467, 8468, 8491, 8490, 8765, 8766, 8789, 8788, 0, 0, 0, 0, 9169, 9215, 9216, 
9213, 32870, 32871, 32894, 32893
23020, 8468, 8469, 8492, 8491, 8766, 8767, 8790, 8789, 0, 0, 0, 0, 9171, 9217, 9218, 
9215, 32871, 32872, 32895, 32894
23021, 8469, 8470, 8493, 8492, 8767, 8768, 8791, 8790, 0, 0, 0, 0, 9173, 9219, 9220, 
9217, 32872, 32873, 32896, 32895
23022, 8470, 8471, 8494, 8493, 8768, 8769, 8792, 8791, 0, 0, 0, 0, 9175, 9221, 9222, 
9219, 32873, 32874, 32897, 32896
23023, 8471, 8472, 8495, 8494, 8769, 8770, 8793, 8792, 0, 0, 0, 0, 9177, 9223, 9224, 
9221, 32874, 32875, 32898, 32897
23024, 8472, 8473, 8496, 8495, 8770, 8771, 8794, 8793, 0, 0, 0, 0, 9179, 9225, 9226, 
9223, 32875, 32876, 32899, 32898
23025, 8473, 8474, 8497, 8496, 8771, 8772, 8795, 8794, 0, 0, 0, 0, 9181, 9227, 9228, 
9225, 32876, 32877, 32900, 32899
23026, 8474, 8475, 8498, 8497, 8772, 8773, 8796, 8795, 0, 0, 0, 0, 9183, 9229, 9230, 
9227, 32877, 32878, 32901, 32900
23027, 8475, 8476, 8499, 8498, 8773, 8774, 8797, 8796, 0, 0, 0, 0, 9185, 9231, 9232, 
9229, 32878, 32879, 32902, 32901
23028, 8476, 8477, 8500, 8499, 8774, 8775, 8798, 8797, 0, 0, 0, 0, 9187, 9233, 9234, 
9231, 32879, 32880, 32903, 32902
23029, 8477, 8478, 8501, 8500, 8775, 8776, 8799, 8798, 0, 0, 0, 0, 9189, 9235, 9236, 
9233, 32880, 32881, 32904, 32903
23030, 8478, 8479, 8502, 8501, 8776, 8777, 8800, 8799, 0, 0, 0, 0, 9191, 9237, 9238, 
9235, 32881, 32882, 32905, 32904
23031, 8479, 8480, 8503, 8502, 8777, 8778, 8801, 8800, 0, 0, 0, 0, 9193, 9239, 9240, 
9237, 32882, 32883, 32906, 32905
23032, 8480, 8481, 8504, 8503, 8778, 8779, 8802, 8801, 0, 0, 0, 0, 9195, 9241, 9242, 
9239, 32883, 32884, 32907, 32906
23033, 8481, 8482, 8505, 8504, 8779, 8780, 8803, 8802, 0, 0, 0, 0, 9197, 9243, 9244, 
9241, 32884, 32885, 32908, 32907
23034, 8482, 8483, 8506, 8505, 8780, 8781, 8804, 8803, 0, 0, 0, 0, 9199, 9245, 9246, 
9243, 32885, 32886, 32909, 32908
23035, 8483, 8484, 8507, 8506, 8781, 8782, 8805, 8804, 0, 0, 0, 0, 9201, 9247, 9248, 
9245, 32886, 32887, 32910, 32909
23036, 8484, 8485, 8508, 8507, 8782, 8783, 8806, 8805, 0, 0, 0, 0, 9203, 9249, 9250, 
9247, 32887, 32888, 32911, 32910
23037, 8485, 997, 998, 8508, 8783, 1103, 1104, 8806, 0, 0, 0, 0, 9204, 1115, 9251, 
9249, 32888, 8618, 8619, 32911
23038, 987, 8486, 8509, 988, 1081, 8784, 8807, 1082, 0, 0, 0, 0, 9206, 9252, 9253, 
1093, 8608, 32889, 32912, 8609
23039, 8486, 8487, 8510, 8509, 8784, 8785, 8808, 8807, 0, 0, 0, 0, 9208, 9254, 9255, 
9252, 32889, 32890, 32913, 32912
23040, 8487, 8488, 8511, 8510, 8785, 8786, 8809, 8808, 0, 0, 0, 0, 9210, 9256, 9257, 
9254, 32890, 32891, 32914, 32913
23041, 8488, 8489, 8512, 8511, 8786, 8787, 8810, 8809, 0, 0, 0, 0, 9212, 9258, 9259, 
9256, 32891, 32892, 32915, 32914
23042, 8489, 8490, 8513, 8512, 8787, 8788, 8811, 8810, 0, 0, 0, 0, 9214, 9260, 9261, 
9258, 32892, 32893, 32916, 32915
23043, 8490, 8491, 8514, 8513, 8788, 8789, 8812, 8811, 0, 0, 0, 0, 9216, 9262, 9263, 
9260, 32893, 32894, 32917, 32916
23044, 8491, 8492, 8515, 8514, 8789, 8790, 8813, 8812, 0, 0, 0, 0, 9218, 9264, 9265, 
9262, 32894, 32895, 32918, 32917
23045, 8492, 8493, 8516, 8515, 8790, 8791, 8814, 8813, 0, 0, 0, 0, 9220, 9266, 9267, 
9264, 32895, 32896, 32919, 32918
23046, 8493, 8494, 8517, 8516, 8791, 8792, 8815, 8814, 0, 0, 0, 0, 9222, 9268, 9269, 
9266, 32896, 32897, 32920, 32919
23047, 8494, 8495, 8518, 8517, 8792, 8793, 8816, 8815, 0, 0, 0, 0, 9224, 9270, 9271, 
9268, 32897, 32898, 32921, 32920
23048, 8495, 8496, 8519, 8518, 8793, 8794, 8817, 8816, 0, 0, 0, 0, 9226, 9272, 9273, 
9270, 32898, 32899, 32922, 32921
23049, 8496, 8497, 8520, 8519, 8794, 8795, 8818, 8817, 0, 0, 0, 0, 9228, 9274, 9275, 
9272, 32899, 32900, 32923, 32922
23050, 8497, 8498, 8521, 8520, 8795, 8796, 8819, 8818, 0, 0, 0, 0, 9230, 9276, 9277, 
9274, 32900, 32901, 32924, 32923
23051, 8498, 8499, 8522, 8521, 8796, 8797, 8820, 8819, 0, 0, 0, 0, 9232, 9278, 9279, 
9276, 32901, 32902, 32925, 32924
23052, 8499, 8500, 8523, 8522, 8797, 8798, 8821, 8820, 0, 0, 0, 0, 9234, 9280, 9281, 
9278, 32902, 32903, 32926, 32925
23053, 8500, 8501, 8524, 8523, 8798, 8799, 8822, 8821, 0, 0, 0, 0, 9236, 9282, 9283, 
9280, 32903, 32904, 32927, 32926
23054, 8501, 8502, 8525, 8524, 8799, 8800, 8823, 8822, 0, 0, 0, 0, 9238, 9284, 9285, 
9282, 32904, 32905, 32928, 32927
23055, 8502, 8503, 8526, 8525, 8800, 8801, 8824, 8823, 0, 0, 0, 0, 9240, 9286, 9287, 
9284, 32905, 32906, 32929, 32928
23056, 8503, 8504, 8527, 8526, 8801, 8802, 8825, 8824, 0, 0, 0, 0, 9242, 9288, 9289, 
9286, 32906, 32907, 32930, 32929
23057, 8504, 8505, 8528, 8527, 8802, 8803, 8826, 8825, 0, 0, 0, 0, 9244, 9290, 9291, 
9288, 32907, 32908, 32931, 32930
23058, 8505, 8506, 8529, 8528, 8803, 8804, 8827, 8826, 0, 0, 0, 0, 9246, 9292, 9293, 
9290, 32908, 32909, 32932, 32931
23059, 8506, 8507, 8530, 8529, 8804, 8805, 8828, 8827, 0, 0, 0, 0, 9248, 9294, 9295, 
9292, 32909, 32910, 32933, 32932
23060, 8507, 8508, 8531, 8530, 8805, 8806, 8829, 8828, 0, 0, 0, 0, 9250, 9296, 9297, 
9294, 32910, 32911, 32934, 32933
23061, 8508, 998, 999, 8531, 8806, 1104, 1105, 8829, 0, 0, 0, 0, 9251, 1116, 9298, 
9296, 32911, 8619, 8620, 32934
23062, 988, 8509, 8532, 989, 1082, 8807, 8830, 1083, 0, 0, 0, 0, 9253, 9299, 9300, 
1094, 8609, 32912, 32935, 8610
23063, 8509, 8510, 8533, 8532, 8807, 8808, 8831, 8830, 0, 0, 0, 0, 9255, 9301, 9302, 
9299, 32912, 32913, 32936, 32935
23064, 8510, 8511, 8534, 8533, 8808, 8809, 8832, 8831, 0, 0, 0, 0, 9257, 9303, 9304, 
9301, 32913, 32914, 32937, 32936
23065, 8511, 8512, 8535, 8534, 8809, 8810, 8833, 8832, 0, 0, 0, 0, 9259, 9305, 9306, 
9303, 32914, 32915, 32938, 32937
23066, 8512, 8513, 8536, 8535, 8810, 8811, 8834, 8833, 0, 0, 0, 0, 9261, 9307, 9308, 
9305, 32915, 32916, 32939, 32938
23067, 8513, 8514, 8537, 8536, 8811, 8812, 8835, 8834, 0, 0, 0, 0, 9263, 9309, 9310, 
9307, 32916, 32917, 32940, 32939
23068, 8514, 8515, 8538, 8537, 8812, 8813, 8836, 8835, 0, 0, 0, 0, 9265, 9311, 9312, 
9309, 32917, 32918, 32941, 32940
23069, 8515, 8516, 8539, 8538, 8813, 8814, 8837, 8836, 0, 0, 0, 0, 9267, 9313, 9314, 
9311, 32918, 32919, 32942, 32941
23070, 8516, 8517, 8540, 8539, 8814, 8815, 8838, 8837, 0, 0, 0, 0, 9269, 9315, 9316, 
9313, 32919, 32920, 32943, 32942
23071, 8517, 8518, 8541, 8540, 8815, 8816, 8839, 8838, 0, 0, 0, 0, 9271, 9317, 9318, 
9315, 32920, 32921, 32944, 32943
23072, 8518, 8519, 8542, 8541, 8816, 8817, 8840, 8839, 0, 0, 0, 0, 9273, 9319, 9320, 
9317, 32921, 32922, 32945, 32944
23073, 8519, 8520, 8543, 8542, 8817, 8818, 8841, 8840, 0, 0, 0, 0, 9275, 9321, 9322, 
9319, 32922, 32923, 32946, 32945
23074, 8520, 8521, 8544, 8543, 8818, 8819, 8842, 8841, 0, 0, 0, 0, 9277, 9323, 9324, 
9321, 32923, 32924, 32947, 32946
23075, 8521, 8522, 8545, 8544, 8819, 8820, 8843, 8842, 0, 0, 0, 0, 9279, 9325, 9326, 
9323, 32924, 32925, 32948, 32947
23076, 8522, 8523, 8546, 8545, 8820, 8821, 8844, 8843, 0, 0, 0, 0, 9281, 9327, 9328, 
9325, 32925, 32926, 32949, 32948
23077, 8523, 8524, 8547, 8546, 8821, 8822, 8845, 8844, 0, 0, 0, 0, 9283, 9329, 9330, 
9327, 32926, 32927, 32950, 32949
23078, 8524, 8525, 8548, 8547, 8822, 8823, 8846, 8845, 0, 0, 0, 0, 9285, 9331, 9332, 
9329, 32927, 32928, 32951, 32950
23079, 8525, 8526, 8549, 8548, 8823, 8824, 8847, 8846, 0, 0, 0, 0, 9287, 9333, 9334, 
9331, 32928, 32929, 32952, 32951
23080, 8526, 8527, 8550, 8549, 8824, 8825, 8848, 8847, 0, 0, 0, 0, 9289, 9335, 9336, 
9333, 32929, 32930, 32953, 32952
23081, 8527, 8528, 8551, 8550, 8825, 8826, 8849, 8848, 0, 0, 0, 0, 9291, 9337, 9338, 
9335, 32930, 32931, 32954, 32953
23082, 8528, 8529, 8552, 8551, 8826, 8827, 8850, 8849, 0, 0, 0, 0, 9293, 9339, 9340, 
9337, 32931, 32932, 32955, 32954
23083, 8529, 8530, 8553, 8552, 8827, 8828, 8851, 8850, 0, 0, 0, 0, 9295, 9341, 9342, 
9339, 32932, 32933, 32956, 32955
23084, 8530, 8531, 8554, 8553, 8828, 8829, 8852, 8851, 0, 0, 0, 0, 9297, 9343, 9344, 
9341, 32933, 32934, 32957, 32956
23085, 8531, 999, 1000, 8554, 8829, 1105, 1106, 8852, 0, 0, 0, 0, 9298, 1117, 9345, 
9343, 32934, 8620, 8621, 32957
23086, 989, 8532, 8555, 990, 1083, 8830, 8853, 1084, 0, 0, 0, 0, 9300, 9346, 9347, 
1095, 8610, 32935, 32958, 8611
23087, 8532, 8533, 8556, 8555, 8830, 8831, 8854, 8853, 0, 0, 0, 0, 9302, 9348, 9349, 
9346, 32935, 32936, 32959, 32958
23088, 8533, 8534, 8557, 8556, 8831, 8832, 8855, 8854, 0, 0, 0, 0, 9304, 9350, 9351, 
9348, 32936, 32937, 32960, 32959
23089, 8534, 8535, 8558, 8557, 8832, 8833, 8856, 8855, 0, 0, 0, 0, 9306, 9352, 9353, 
9350, 32937, 32938, 32961, 32960
23090, 8535, 8536, 8559, 8558, 8833, 8834, 8857, 8856, 0, 0, 0, 0, 9308, 9354, 9355, 
9352, 32938, 32939, 32962, 32961
23091, 8536, 8537, 8560, 8559, 8834, 8835, 8858, 8857, 0, 0, 0, 0, 9310, 9356, 9357, 
9354, 32939, 32940, 32963, 32962
23092, 8537, 8538, 8561, 8560, 8835, 8836, 8859, 8858, 0, 0, 0, 0, 9312, 9358, 9359, 
9356, 32940, 32941, 32964, 32963
23093, 8538, 8539, 8562, 8561, 8836, 8837, 8860, 8859, 0, 0, 0, 0, 9314, 9360, 9361, 
9358, 32941, 32942, 32965, 32964
23094, 8539, 8540, 8563, 8562, 8837, 8838, 8861, 8860, 0, 0, 0, 0, 9316, 9362, 9363, 
9360, 32942, 32943, 32966, 32965
23095, 8540, 8541, 8564, 8563, 8838, 8839, 8862, 8861, 0, 0, 0, 0, 9318, 9364, 9365, 
9362, 32943, 32944, 32967, 32966
23096, 8541, 8542, 8565, 8564, 8839, 8840, 8863, 8862, 0, 0, 0, 0, 9320, 9366, 9367, 
9364, 32944, 32945, 32968, 32967
23097, 8542, 8543, 8566, 8565, 8840, 8841, 8864, 8863, 0, 0, 0, 0, 9322, 9368, 9369, 
9366, 32945, 32946, 32969, 32968
23098, 8543, 8544, 8567, 8566, 8841, 8842, 8865, 8864, 0, 0, 0, 0, 9324, 9370, 9371, 
9368, 32946, 32947, 32970, 32969
23099, 8544, 8545, 8568, 8567, 8842, 8843, 8866, 8865, 0, 0, 0, 0, 9326, 9372, 9373, 
9370, 32947, 32948, 32971, 32970
23100, 8545, 8546, 8569, 8568, 8843, 8844, 8867, 8866, 0, 0, 0, 0, 9328, 9374, 9375, 
9372, 32948, 32949, 32972, 32971
23101, 8546, 8547, 8570, 8569, 8844, 8845, 8868, 8867, 0, 0, 0, 0, 9330, 9376, 9377, 
9374, 32949, 32950, 32973, 32972
23102, 8547, 8548, 8571, 8570, 8845, 8846, 8869, 8868, 0, 0, 0, 0, 9332, 9378, 9379, 
9376, 32950, 32951, 32974, 32973
23103, 8548, 8549, 8572, 8571, 8846, 8847, 8870, 8869, 0, 0, 0, 0, 9334, 9380, 9381, 
9378, 32951, 32952, 32975, 32974
23104, 8549, 8550, 8573, 8572, 8847, 8848, 8871, 8870, 0, 0, 0, 0, 9336, 9382, 9383, 
9380, 32952, 32953, 32976, 32975
23105, 8550, 8551, 8574, 8573, 8848, 8849, 8872, 8871, 0, 0, 0, 0, 9338, 9384, 9385, 
9382, 32953, 32954, 32977, 32976
23106, 8551, 8552, 8575, 8574, 8849, 8850, 8873, 8872, 0, 0, 0, 0, 9340, 9386, 9387, 
9384, 32954, 32955, 32978, 32977
23107, 8552, 8553, 8576, 8575, 8850, 8851, 8874, 8873, 0, 0, 0, 0, 9342, 9388, 9389, 
9386, 32955, 32956, 32979, 32978
23108, 8553, 8554, 8577, 8576, 8851, 8852, 8875, 8874, 0, 0, 0, 0, 9344, 9390, 9391, 
9388, 32956, 32957, 32980, 32979
23109, 8554, 1000, 1001, 8577, 8852, 1106, 1107, 8875, 0, 0, 0, 0, 9345, 1118, 9392, 
9390, 32957, 8621, 8622, 32980
23110, 990, 8555, 888, 37, 1084, 8853, 1002, 41, 0, 0, 0, 0, 9347, 9393, 0, 
1096, 8611, 32958, 0, 0
23111, 8555, 8556, 889, 888, 8853, 8854, 1003, 1002, 0, 0, 0, 0, 9349, 9394, 0, 
9393, 32958, 32959, 0, 0
23112, 8556, 8557, 890, 889, 8854, 8855, 1004, 1003, 0, 0, 0, 0, 9351, 9395, 0, 
9394, 32959, 32960, 0, 0
23113, 8557, 8558, 891, 890, 8855, 8856, 1005, 1004, 0, 0, 0, 0, 9353, 9396, 0, 
9395, 32960, 32961, 0, 0
23114, 8558, 8559, 892, 891, 8856, 8857, 1006, 1005, 0, 0, 0, 0, 9355, 9397, 0, 
9396, 32961, 32962, 0, 0
23115, 8559, 8560, 893, 892, 8857, 8858, 1007, 1006, 0, 0, 0, 0, 9357, 9398, 0, 
9397, 32962, 32963, 0, 0
23116, 8560, 8561, 894, 893, 8858, 8859, 1008, 1007, 0, 0, 0, 0, 9359, 9399, 0, 
9398, 32963, 32964, 0, 0
23117, 8561, 8562, 895, 894, 8859, 8860, 1009, 1008, 0, 0, 0, 0, 9361, 9400, 0, 
9399, 32964, 32965, 0, 0
23118, 8562, 8563, 896, 895, 8860, 8861, 1010, 1009, 0, 0, 0, 0, 9363, 9401, 0, 
9400, 32965, 32966, 0, 0
23119, 8563, 8564, 897, 896, 8861, 8862, 1011, 1010, 0, 0, 0, 0, 9365, 9402, 0, 
9401, 32966, 32967, 0, 0
23120, 8564, 8565, 898, 897, 8862, 8863, 1012, 1011, 0, 0, 0, 0, 9367, 9403, 0, 
9402, 32967, 32968, 0, 0
23121, 8565, 8566, 899, 898, 8863, 8864, 1013, 1012, 0, 0, 0, 0, 9369, 9404, 0, 
9403, 32968, 32969, 0, 0
23122, 8566, 8567, 900, 899, 8864, 8865, 1014, 1013, 0, 0, 0, 0, 9371, 9405, 0, 
9404, 32969, 32970, 0, 0
23123, 8567, 8568, 901, 900, 8865, 8866, 1015, 1014, 0, 0, 0, 0, 9373, 9406, 0, 
9405, 32970, 32971, 0, 0
23124, 8568, 8569, 902, 901, 8866, 8867, 1016, 1015, 0, 0, 0, 0, 9375, 9407, 0, 
9406, 32971, 32972, 0, 0
23125, 8569, 8570, 903, 902, 8867, 8868, 1017, 1016, 0, 0, 0, 0, 9377, 9408, 0, 
9407, 32972, 32973, 0, 0
23126, 8570, 8571, 904, 903, 8868, 8869, 1018, 1017, 0, 0, 0, 0, 9379, 9409, 0, 
9408, 32973, 32974, 0, 0
23127, 8571, 8572, 905, 904, 8869, 8870, 1019, 1018, 0, 0, 0, 0, 9381, 9410, 0, 
9409, 32974, 32975, 0, 0
23128, 8572, 8573, 906, 905, 8870, 8871, 1020, 1019, 0, 0, 0, 0, 9383, 9411, 0, 
9410, 32975, 32976, 0, 0
23129, 8573, 8574, 907, 906, 8871, 8872, 1021, 1020, 0, 0, 0, 0, 9385, 9412, 0, 
9411, 32976, 32977, 0, 0
23130, 8574, 8575, 908, 907, 8872, 8873, 1022, 1021, 0, 0, 0, 0, 9387, 9413, 0, 
9412, 32977, 32978, 0, 0
23131, 8575, 8576, 909, 908, 8873, 8874, 1023, 1022, 0, 0, 0, 0, 9389, 9414, 0, 
9413, 32978, 32979, 0, 0
23132, 8576, 8577, 910, 909, 8874, 8875, 1024, 1023, 0, 0, 0, 0, 9391, 9415, 0, 
9414, 32979, 32980, 0, 0
23133, 8577, 1001, 38, 910, 8875, 1107, 42, 1024, 0, 0, 0, 0, 9392, 1119, 0, 
9415, 32980, 8622, 0, 0
*ELEMENT, type=C3D20, ELSET=Volume11
23134, 43, 1027, 8623, 1074, 1147, 9462, 32981, 9625, 1050, 8876, 8877, 1085, 9509, 33488, 33489, 
9647, 1149, 9508, 33487, 9648
23135, 1147, 9462, 32981, 9625, 1148, 9463, 32982, 9626, 9509, 33488, 33489, 9647, 9511, 33491, 33492, 
9649, 1150, 9510, 33490, 9650
23136, 1148, 9463, 32982, 9626, 47, 1157, 9783, 1180, 9511, 33491, 33492, 9649, 0, 0, 0, 
0, 1151, 9512, 33493, 9651
23137, 1027, 1028, 8624, 8623, 9462, 9464, 32983, 32981, 1051, 8878, 8879, 8876, 9514, 33495, 33496, 
33488, 9508, 9513, 33494, 33487
23138, 9462, 9464, 32983, 32981, 9463, 9465, 32984, 32982, 9514, 33495, 33496, 33488, 9516, 33498, 33499, 
33491, 9510, 9515, 33497, 33490
23139, 9463, 9465, 32984, 32982, 1157, 1158, 9784, 9783, 9516, 33498, 33499, 33491, 0, 0, 0, 
0, 9512, 9517, 33500, 33493
23140, 1028, 1029, 8625, 8624, 9464, 9466, 32985, 32983, 1052, 8880, 8881, 8878, 9519, 33502, 33503, 
33495, 9513, 9518, 33501, 33494
23141, 9464, 9466, 32985, 32983, 9465, 9467, 32986, 32984, 9519, 33502, 33503, 33495, 9521, 33505, 33506, 
33498, 9515, 9520, 33504, 33497
23142, 9465, 9467, 32986, 32984, 1158, 1159, 9785, 9784, 9521, 33505, 33506, 33498, 0, 0, 0, 
0, 9517, 9522, 33507, 33500
23143, 1029, 1030, 8626, 8625, 9466, 9468, 32987, 32985, 1053, 8882, 8883, 8880, 9524, 33509, 33510, 
33502, 9518, 9523, 33508, 33501
23144, 9466, 9468, 32987, 32985, 9467, 9469, 32988, 32986, 9524, 33509, 33510, 33502, 9526, 33512, 33513, 
33505, 9520, 9525, 33511, 33504
23145, 9467, 9469, 32988, 32986, 1159, 1160, 9786, 9785, 9526, 33512, 33513, 33505, 0, 0, 0, 
0, 9522, 9527, 33514, 33507
23146, 1030, 1031, 8627, 8626, 9468, 9470, 32989, 32987, 1054, 8884, 8885, 8882, 9529, 33516, 33517, 
33509, 9523, 9528, 33515, 33508
23147, 9468, 9470, 32989, 32987, 9469, 9471, 32990, 32988, 9529, 33516, 33517, 33509, 9531, 33519, 33520, 
33512, 9525, 9530, 33518, 33511
23148, 9469, 9471, 32990, 32988, 1160, 1161, 9787, 9786, 9531, 33519, 33520, 33512, 0, 0, 0, 
0, 9527, 9532, 33521, 33514
23149, 1031, 1032, 8628, 8627, 9470, 9472, 32991, 32989, 1055, 8886, 8887, 8884, 9534, 33523, 33524, 
33516, 9528, 9533, 33522, 33515
23150, 9470, 9472, 32991, 32989, 9471, 9473, 32992, 32990, 9534, 33523, 33524, 33516, 9536, 33526, 33527, 
33519, 9530, 9535, 33525, 33518
23151, 9471, 9473, 32992, 32990, 1161, 1162, 9788, 9787, 9536, 33526, 33527, 33519, 0, 0, 0, 
0, 9532, 9537, 33528, 33521
23152, 1032, 1033, 8629, 8628, 9472, 9474, 32993, 32991, 1056, 8888, 8889, 8886, 9539, 33530, 33531, 
33523, 9533, 9538, 33529, 33522
23153, 9472, 9474, 32993, 32991, 9473, 9475, 32994, 32992, 9539, 33530, 33531, 33523, 9541, 33533, 33534, 
33526, 9535, 9540, 33532, 33525
23154, 9473, 9475, 32994, 32992, 1162, 1163, 9789, 9788, 9541, 33533, 33534, 33526, 0, 0, 0, 
0, 9537, 9542, 33535, 33528
23155, 1033, 1034, 8630, 8629, 9474, 9476, 32995, 32993, 1057, 8890, 8891, 8888, 9544, 33537, 33538, 
33530, 9538, 9543, 33536, 33529
23156, 9474, 9476, 32995, 32993, 9475, 9477, 32996, 32994, 9544, 33537, 33538, 33530, 9546, 33540, 33541, 
33533, 9540, 9545, 33539, 33532
23157, 9475, 9477, 32996, 32994, 1163, 1164, 9790, 9789, 9546, 33540, 33541, 33533, 0, 0, 0, 
0, 9542, 9547, 33542, 33535
23158, 1034, 1035, 8631, 8630, 9476, 9478, 32997, 32995, 1058, 8892, 8893, 8890, 9549, 33544, 33545, 
33537, 9543, 9548, 33543, 33536
23159, 9476, 9478, 32997, 32995, 9477, 9479, 32998, 32996, 9549, 33544, 33545, 33537, 9551, 33547, 33548, 
33540, 9545, 9550, 33546, 33539
23160, 9477, 9479, 32998, 32996, 1164, 1165, 9791, 9790, 9551, 33547, 33548, 33540, 0, 0, 0, 
0, 9547, 9552, 33549, 33542
23161, 1035, 1036, 8632, 8631, 9478, 9480, 32999, 32997, 1059, 8894, 8895, 8892, 9554, 33551, 33552, 
33544, 9548, 9553, 33550, 33543
23162, 9478, 9480, 32999, 32997, 9479, 9481, 33000, 32998, 9554, 33551, 33552, 33544, 9556, 33554, 33555, 
33547, 9550, 9555, 33553, 33546
23163, 9479, 9481, 33000, 32998, 1165, 1166, 9792, 9791, 9556, 33554, 33555, 33547, 0, 0, 0, 
0, 9552, 9557, 33556, 33549
23164, 1036, 1037, 8633, 8632, 9480, 9482, 33001, 32999, 1060, 8896, 8897, 8894, 9559, 33558, 33559, 
33551, 9553, 9558, 33557, 33550
23165, 9480, 9482, 33001, 32999, 9481, 9483, 33002, 33000, 9559, 33558, 33559, 33551, 9561, 33561, 33562, 
33554, 9555, 9560, 33560, 33553
23166, 9481, 9483, 33002, 33000, 1166, 1167, 9793, 9792, 9561, 33561, 33562, 33554, 0, 0, 0, 
0, 9557, 9562, 33563, 33556
23167, 1037, 1038, 8634, 8633, 9482, 9484, 33003, 33001, 1061, 8898, 8899, 8896, 9564, 33565, 33566, 
33558, 9558, 9563, 33564, 33557
23168, 9482, 9484, 33003, 33001, 9483, 9485, 33004, 33002, 9564, 33565, 33566, 33558, 9566, 33568, 33569, 
33561, 9560, 9565, 33567, 33560
23169, 9483, 9485, 33004, 33002, 1167, 1168, 9794, 9793, 9566, 33568, 33569, 33561, 0, 0, 0, 
0, 9562, 9567, 33570, 33563
23170, 1038, 1039, 8635, 8634, 9484, 9486, 33005, 33003, 1062, 8900, 8901, 8898, 9569, 33572, 33573, 
33565, 9563, 9568, 33571, 33564
23171, 9484, 9486, 33005, 33003, 9485, 9487, 33006, 33004, 9569, 33572, 33573, 33565, 9571, 33575, 33576, 
33568, 9565, 9570, 33574, 33567
23172, 9485, 9487, 33006, 33004, 1168, 1169, 9795, 9794, 9571, 33575, 33576, 33568, 0, 0, 0, 
0, 9567, 9572, 33577, 33570
23173, 1039, 1040, 8636, 8635, 9486, 9488, 33007, 33005, 1063, 8902, 8903, 8900, 9574, 33579, 33580, 
33572, 9568, 9573, 33578, 33571
23174, 9486, 9488, 33007, 33005, 9487, 9489, 33008, 33006, 9574, 33579, 33580, 33572, 9576, 33582, 33583, 
33575, 9570, 9575, 33581, 33574
23175, 9487, 9489, 33008, 33006, 1169, 1170, 9796, 9795, 9576, 33582, 33583, 33575, 0, 0, 0, 
0, 9572, 9577, 33584, 33577
23176, 1040, 1041, 8637, 8636, 9488, 9490, 33009, 33007, 1064, 8904, 8905, 8902, 9579, 33586, 33587, 
33579, 9573, 9578, 33585, 33578
23177, 9488, 9490, 33009, 33007, 9489, 9491, 33010, 33008, 9579, 33586, 33587, 33579, 9581, 33589, 33590, 
33582, 9575, 9580, 33588, 33581
23178, 9489, 9491, 33010, 33008, 1170, 1171, 9797, 9796, 9581, 33589, 33590, 33582, 0, 0, 0, 
0, 9577, 9582, 33591, 33584
23179, 1041, 1042, 8638, 8637, 9490, 9492, 33011, 33009, 1065, 8906, 8907, 8904, 9584, 33593, 33594, 
33586, 9578, 9583, 33592, 33585
23180, 9490, 9492, 33011, 33009, 9491, 9493, 33012, 33010, 9584, 33593, 33594, 33586, 9586, 33596, 33597, 
33589, 9580, 9585, 33595, 33588
23181, 9491, 9493, 33012, 33010, 1171, 1172, 9798, 9797, 9586, 33596, 33597, 33589, 0, 0, 0, 
0, 9582, 9587, 33598, 33591
23182, 1042, 1043, 8639, 8638, 9492, 9494, 33013, 33011, 1066, 8908, 8909, 8906, 9589, 33600, 33601, 
33593, 9583, 9588, 33599, 33592
23183, 9492, 9494, 33013, 33011, 9493, 9495, 33014, 33012, 9589, 33600, 33601, 33593, 9591, 33603, 33604, 
33596, 9585, 9590, 33602, 33595
23184, 9493, 9495, 33014, 33012, 1172, 1173, 9799, 9798, 9591, 33603, 33604, 33596, 0, 0, 0, 
0, 9587, 9592, 33605, 33598
23185, 1043, 1044, 8640, 8639, 9494, 9496, 33015, 33013, 1067, 8910, 8911, 8908, 9594, 33607, 33608, 
33600, 9588, 9593, 33606, 33599
23186, 9494, 9496, 33015, 33013, 9495, 9497, 33016, 33014, 9594, 33607, 33608, 33600, 9596, 33610, 33611, 
33603, 9590, 9595, 33609, 33602
23187, 9495, 9497, 33016, 33014, 1173, 1174, 9800, 9799, 9596, 33610, 33611, 33603, 0, 0, 0, 
0, 9592, 9597, 33612, 33605
23188, 1044, 1045, 8641, 8640, 9496, 9498, 33017, 33015, 1068, 8912, 8913, 8910, 9599, 33614, 33615, 
33607, 9593, 9598, 33613, 33606
23189, 9496, 9498, 33017, 33015, 9497, 9499, 33018, 33016, 9599, 33614, 33615, 33607, 9601, 33617, 33618, 
33610, 9595, 9600, 33616, 33609
23190, 9497, 9499, 33018, 33016, 1174, 1175, 9801, 9800, 9601, 33617, 33618, 33610, 0, 0, 0, 
0, 9597, 9602, 33619, 33612
23191, 1045, 1046, 8642, 8641, 9498, 9500, 33019, 33017, 1069, 8914, 8915, 8912, 9604, 33621, 33622, 
33614, 9598, 9603, 33620, 33613
23192, 9498, 9500, 33019, 33017, 9499, 9501, 33020, 33018, 9604, 33621, 33622, 33614, 9606, 33624, 33625, 
33617, 9600, 9605, 33623, 33616
23193, 9499, 9501, 33020, 33018, 1175, 1176, 9802, 9801, 9606, 33624, 33625, 33617, 0, 0, 0, 
0, 9602, 9607, 33626, 33619
23194, 1046, 1047, 8643, 8642, 9500, 9502, 33021, 33019, 1070, 8916, 8917, 8914, 9609, 33628, 33629, 
33621, 9603, 9608, 33627, 33620
23195, 9500, 9502, 33021, 33019, 9501, 9503, 33022, 33020, 9609, 33628, 33629, 33621, 9611, 33631, 33632, 
33624, 9605, 9610, 33630, 33623
23196, 9501, 9503, 33022, 33020, 1176, 1177, 9803, 9802, 9611, 33631, 33632, 33624, 0, 0, 0, 
0, 9607, 9612, 33633, 33626
23197, 1047, 1048, 8644, 8643, 9502, 9504, 33023, 33021, 1071, 8918, 8919, 8916, 9614, 33635, 33636, 
33628, 9608, 9613, 33634, 33627
23198, 9502, 9504, 33023, 33021, 9503, 9505, 33024, 33022, 9614, 33635, 33636, 33628, 9616, 33638, 33639, 
33631, 9610, 9615, 33637, 33630
23199, 9503, 9505, 33024, 33022, 1177, 1178, 9804, 9803, 9616, 33638, 33639, 33631, 0, 0, 0, 
0, 9612, 9617, 33640, 33633
23200, 1048, 1049, 8645, 8644, 9504, 9506, 33025, 33023, 1072, 8920, 8921, 8918, 9619, 33642, 33643, 
33635, 9613, 9618, 33641, 33634
23201, 9504, 9506, 33025, 33023, 9505, 9507, 33026, 33024, 9619, 33642, 33643, 33635, 9621, 33645, 33646, 
33638, 9615, 9620, 33644, 33637
23202, 9505, 9507, 33026, 33024, 1178, 1179, 9805, 9804, 9621, 33645, 33646, 33638, 0, 0, 0, 
0, 9617, 9622, 33647, 33640
23203, 1049, 44, 1097, 8645, 9506, 1152, 9704, 33025, 1073, 1108, 8922, 8920, 9623, 9727, 33648, 
33642, 9618, 1154, 9726, 33641
23204, 9506, 1152, 9704, 33025, 9507, 1153, 9705, 33026, 9623, 9727, 33648, 33642, 9624, 9729, 33649, 
33645, 9620, 1155, 9728, 33644
23205, 9507, 1153, 9705, 33026, 1179, 48, 1191, 9805, 9624, 9729, 33649, 33645, 0, 0, 0, 
0, 9622, 1156, 9730, 33647
23206, 1074, 8623, 8646, 1075, 9625, 32981, 33027, 9627, 8877, 8923, 8924, 1086, 33489, 33651, 33652, 
9652, 9648, 33487, 33650, 9653
23207, 9625, 32981, 33027, 9627, 9626, 32982, 33028, 9628, 33489, 33651, 33652, 9652, 33492, 33654, 33655, 
9654, 9650, 33490, 33653, 9655
23208, 9626, 32982, 33028, 9628, 1180, 9783, 9806, 1181, 33492, 33654, 33655, 9654, 0, 0, 0, 
0, 9651, 33493, 33656, 9656
23209, 8623, 8624, 8647, 8646, 32981, 32983, 33029, 33027, 8879, 8925, 8926, 8923, 33496, 33658, 33659, 
33651, 33487, 33494, 33657, 33650
23210, 32981, 32983, 33029, 33027, 32982, 32984, 33030, 33028, 33496, 33658, 33659, 33651, 33499, 33661, 33662, 
33654, 33490, 33497, 33660, 33653
23211, 32982, 32984, 33030, 33028, 9783, 9784, 9807, 9806, 33499, 33661, 33662, 33654, 0, 0, 0, 
0, 33493, 33500, 33663, 33656
23212, 8624, 8625, 8648, 8647, 32983, 32985, 33031, 33029, 8881, 8927, 8928, 8925, 33503, 33665, 33666, 
33658, 33494, 33501, 33664, 33657
23213, 32983, 32985, 33031, 33029, 32984, 32986, 33032, 33030, 33503, 33665, 33666, 33658, 33506, 33668, 33669, 
33661, 33497, 33504, 33667, 33660
23214, 32984, 32986, 33032, 33030, 9784, 9785, 9808, 9807, 33506, 33668, 33669, 33661, 0, 0, 0, 
0, 33500, 33507, 33670, 33663
23215, 8625, 8626, 8649, 8648, 32985, 32987, 33033, 33031, 8883, 8929, 8930, 8927, 33510, 33672, 33673, 
33665, 33501, 33508, 33671, 33664
23216, 32985, 32987, 33033, 33031, 32986, 32988, 33034, 33032, 33510, 33672, 33673, 33665, 33513, 33675, 33676, 
33668, 33504, 33511, 33674, 33667
23217, 32986, 32988, 33034, 33032, 9785, 9786, 9809, 9808, 33513, 33675, 33676, 33668, 0, 0, 0, 
0, 33507, 33514, 33677, 33670
23218, 8626, 8627, 8650, 8649, 32987, 32989, 33035, 33033, 8885, 8931, 8932, 8929, 33517, 33679, 33680, 
33672, 33508, 33515, 33678, 33671
23219, 32987, 32989, 33035, 33033, 32988, 32990, 33036, 33034, 33517, 33679, 33680, 33672, 33520, 33682, 33683, 
33675, 33511, 33518, 33681, 33674
23220, 32988, 32990, 33036, 33034, 9786, 9787, 9810, 9809, 33520, 33682, 33683, 33675, 0, 0, 0, 
0, 33514, 33521, 33684, 33677
23221, 8627, 8628, 8651, 8650, 32989, 32991, 33037, 33035, 8887, 8933, 8934, 8931, 33524, 33686, 33687, 
33679, 33515, 33522, 33685, 33678
23222, 32989, 32991, 33037, 33035, 32990, 32992, 33038, 33036, 33524, 33686, 33687, 33679, 33527, 33689, 33690, 
33682, 33518, 33525, 33688, 33681
23223, 32990, 32992, 33038, 33036, 9787, 9788, 9811, 9810, 33527, 33689, 33690, 33682, 0, 0, 0, 
0, 33521, 33528, 33691, 33684
23224, 8628, 8629, 8652, 8651, 32991, 32993, 33039, 33037, 8889, 8935, 8936, 8933, 33531, 33693, 33694, 
33686, 33522, 33529, 33692, 33685
23225, 32991, 32993, 33039, 33037, 32992, 32994, 33040, 33038, 33531, 33693, 33694, 33686, 33534, 33696, 33697, 
33689, 33525, 33532, 33695, 33688
23226, 32992, 32994, 33040, 33038, 9788, 9789, 9812, 9811, 33534, 33696, 33697, 33689, 0, 0, 0, 
0, 33528, 33535, 33698, 33691
23227, 8629, 8630, 8653, 8652, 32993, 32995, 33041, 33039, 8891, 8937, 8938, 8935, 33538, 33700, 33701, 
33693, 33529, 33536, 33699, 33692
23228, 32993, 32995, 33041, 33039, 32994, 32996, 33042, 33040, 33538, 33700, 33701, 33693, 33541, 33703, 33704, 
33696, 33532, 33539, 33702, 33695
23229, 32994, 32996, 33042, 33040, 9789, 9790, 9813, 9812, 33541, 33703, 33704, 33696, 0, 0, 0, 
0, 33535, 33542, 33705, 33698
23230, 8630, 8631, 8654, 8653, 32995, 32997, 33043, 33041, 8893, 8939, 8940, 8937, 33545, 33707, 33708, 
33700, 33536, 33543, 33706, 33699
23231, 32995, 32997, 33043, 33041, 32996, 32998, 33044, 33042, 33545, 33707, 33708, 33700, 33548, 33710, 33711, 
33703, 33539, 33546, 33709, 33702
23232, 32996, 32998, 33044, 33042, 9790, 9791, 9814, 9813, 33548, 33710, 33711, 33703, 0, 0, 0, 
0, 33542, 33549, 33712, 33705
23233, 8631, 8632, 8655, 8654, 32997, 32999, 33045, 33043, 8895, 8941, 8942, 8939, 33552, 33714, 33715, 
33707, 33543, 33550, 33713, 33706
23234, 32997, 32999, 33045, 33043, 32998, 33000, 33046, 33044, 33552, 33714, 33715, 33707, 33555, 33717, 33718, 
33710, 33546, 33553, 33716, 33709
23235, 32998, 33000, 33046, 33044, 9791, 9792, 9815, 9814, 33555, 33717, 33718, 33710, 0, 0, 0, 
0, 33549, 33556, 33719, 33712
23236, 8632, 8633, 8656, 8655, 32999, 33001, 33047, 33045, 8897, 8943, 8944, 8941, 33559, 33721, 33722, 
33714, 33550, 33557, 33720, 33713
23237, 32999, 33001, 33047, 33045, 33000, 33002, 33048, 33046, 33559, 33721, 33722, 33714, 33562, 33724, 33725, 
33717, 33553, 33560, 33723, 33716
23238, 33000, 33002, 33048, 33046, 9792, 9793, 9816, 9815, 33562, 33724, 33725, 33717, 0, 0, 0, 
0, 33556, 33563, 33726, 33719
23239, 8633, 8634, 8657, 8656, 33001, 33003, 33049, 33047, 8899, 8945, 8946, 8943, 33566, 33728, 33729, 
33721, 33557, 33564, 33727, 33720
23240, 33001, 33003, 33049, 33047, 33002, 33004, 33050, 33048, 33566, 33728, 33729, 33721, 33569, 33731, 33732, 
33724, 33560, 33567, 33730, 33723
23241, 33002, 33004, 33050, 33048, 9793, 9794, 9817, 9816, 33569, 33731, 33732, 33724, 0, 0, 0, 
0, 33563, 33570, 33733, 33726
23242, 8634, 8635, 8658, 8657, 33003, 33005, 33051, 33049, 8901, 8947, 8948, 8945, 33573, 33735, 33736, 
33728, 33564, 33571, 33734, 33727
23243, 33003, 33005, 33051, 33049, 33004, 33006, 33052, 33050, 33573, 33735, 33736, 33728, 33576, 33738, 33739, 
33731, 33567, 33574, 33737, 33730
23244, 33004, 33006, 33052, 33050, 9794, 9795, 9818, 9817, 33576, 33738, 33739, 33731, 0, 0, 0, 
0, 33570, 33577, 33740, 33733
23245, 8635, 8636, 8659, 8658, 33005, 33007, 33053, 33051, 8903, 8949, 8950, 8947, 33580, 33742, 33743, 
33735, 33571, 33578, 33741, 33734
23246, 33005, 33007, 33053, 33051, 33006, 33008, 33054, 33052, 33580, 33742, 33743, 33735, 33583, 33745, 33746, 
33738, 33574, 33581, 33744, 33737
23247, 33006, 33008, 33054, 33052, 9795, 9796, 9819, 9818, 33583, 33745, 33746, 33738, 0, 0, 0, 
0, 33577, 33584, 33747, 33740
23248, 8636, 8637, 8660, 8659, 33007, 33009, 33055, 33053, 8905, 8951, 8952, 8949, 33587, 33749, 33750, 
33742, 33578, 33585, 33748, 33741
23249, 33007, 33009, 33055, 33053, 33008, 33010, 33056, 33054, 33587, 33749, 33750, 33742, 33590, 33752, 33753, 
33745, 33581, 33588, 33751, 33744
23250, 33008, 33010, 33056, 33054, 9796, 9797, 9820, 9819, 33590, 33752, 33753, 33745, 0, 0, 0, 
0, 33584, 33591, 33754, 33747
23251, 8637, 8638, 8661, 8660, 33009, 33011, 33057, 33055, 8907, 8953, 8954, 8951, 33594, 33756, 33757, 
33749, 33585, 33592, 33755, 33748
23252, 33009, 33011, 33057, 33055, 33010, 33012, 33058, 33056, 33594, 33756, 33757, 33749, 33597, 33759, 33760, 
33752, 33588, 33595, 33758, 33751
23253, 33010, 33012, 33058, 33056, 9797, 9798, 9821, 9820, 33597, 33759, 33760, 33752, 0, 0, 0, 
0, 33591, 33598, 33761, 33754
23254, 8638, 8639, 8662, 8661, 33011, 33013, 33059, 33057, 8909, 8955, 8956, 8953, 33601, 33763, 33764, 
33756, 33592, 33599, 33762, 33755
23255, 33011, 33013, 33059, 33057, 33012, 33014, 33060, 33058, 33601, 33763, 33764, 33756, 33604, 33766, 33767, 
33759, 33595, 33602, 33765, 33758
23256, 33012, 33014, 33060, 33058, 9798, 9799, 9822, 9821, 33604, 33766, 33767, 33759, 0, 0, 0, 
0, 33598, 33605, 33768, 33761
23257, 8639, 8640, 8663, 8662, 33013, 33015, 33061, 33059, 8911, 8957, 8958, 8955, 33608, 33770, 33771, 
33763, 33599, 33606, 33769, 33762
23258, 33013, 33015, 33061, 33059, 33014, 33016, 33062, 33060, 33608, 33770, 33771, 33763, 33611, 33773, 33774, 
33766, 33602, 33609, 33772, 33765
23259, 33014, 33016, 33062, 33060, 9799, 9800, 9823, 9822, 33611, 33773, 33774, 33766, 0, 0, 0, 
0, 33605, 33612, 33775, 33768
23260, 8640, 8641, 8664, 8663, 33015, 33017, 33063, 33061, 8913, 8959, 8960, 8957, 33615, 33777, 33778, 
33770, 33606, 33613, 33776, 33769
23261, 33015, 33017, 33063, 33061, 33016, 33018, 33064, 33062, 33615, 33777, 33778, 33770, 33618, 33780, 33781, 
33773, 33609, 33616, 33779, 33772
23262, 33016, 33018, 33064, 33062, 9800, 9801, 9824, 9823, 33618, 33780, 33781, 33773, 0, 0, 0, 
0, 33612, 33619, 33782, 33775
23263, 8641, 8642, 8665, 8664, 33017, 33019, 33065, 33063, 8915, 8961, 8962, 8959, 33622, 33784, 33785, 
33777, 33613, 33620, 33783, 33776
23264, 33017, 33019, 33065, 33063, 33018, 33020, 33066, 33064, 33622, 33784, 33785, 33777, 33625, 33787, 33788, 
33780, 33616, 33623, 33786, 33779
23265, 33018, 33020, 33066, 33064, 9801, 9802, 9825, 9824, 33625, 33787, 33788, 33780, 0, 0, 0, 
0, 33619, 33626, 33789, 33782
23266, 8642, 8643, 8666, 8665, 33019, 33021, 33067, 33065, 8917, 8963, 8964, 8961, 33629, 33791, 33792, 
33784, 33620, 33627, 33790, 33783
23267, 33019, 33021, 33067, 33065, 33020, 33022, 33068, 33066, 33629, 33791, 33792, 33784, 33632, 33794, 33795, 
33787, 33623, 33630, 33793, 33786
23268, 33020, 33022, 33068, 33066, 9802, 9803, 9826, 9825, 33632, 33794, 33795, 33787, 0, 0, 0, 
0, 33626, 33633, 33796, 33789
23269, 8643, 8644, 8667, 8666, 33021, 33023, 33069, 33067, 8919, 8965, 8966, 8963, 33636, 33798, 33799, 
33791, 33627, 33634, 33797, 33790
23270, 33021, 33023, 33069, 33067, 33022, 33024, 33070, 33068, 33636, 33798, 33799, 33791, 33639, 33801, 33802, 
33794, 33630, 33637, 33800, 33793
23271, 33022, 33024, 33070, 33068, 9803, 9804, 9827, 9826, 33639, 33801, 33802, 33794, 0, 0, 0, 
0, 33633, 33640, 33803, 33796
23272, 8644, 8645, 8668, 8667, 33023, 33025, 33071, 33069, 8921, 8967, 8968, 8965, 33643, 33805, 33806, 
33798, 33634, 33641, 33804, 33797
23273, 33023, 33025, 33071, 33069, 33024, 33026, 33072, 33070, 33643, 33805, 33806, 33798, 33646, 33808, 33809, 
33801, 33637, 33644, 33807, 33800
23274, 33024, 33026, 33072, 33070, 9804, 9805, 9828, 9827, 33646, 33808, 33809, 33801, 0, 0, 0, 
0, 33640, 33647, 33810, 33803
23275, 8645, 1097, 1098, 8668, 33025, 9704, 9706, 33071, 8922, 1109, 8969, 8967, 33648, 9732, 33811, 
33805, 33641, 9726, 9731, 33804
23276, 33025, 9704, 9706, 33071, 33026, 9705, 9707, 33072, 33648, 9732, 33811, 33805, 33649, 9734, 33812, 
33808, 33644, 9728, 9733, 33807
23277, 33026, 9705, 9707, 33072, 9805, 1191, 1192, 9828, 33649, 9734, 33812, 33808, 0, 0, 0, 
0, 33647, 9730, 9735, 33810
23278, 1075, 8646, 8669, 1076, 9627, 33027, 33073, 9629, 8924, 8970, 8971, 1087, 33652, 33814, 33815, 
9657, 9653, 33650, 33813, 9658
23279, 9627, 33027, 33073, 9629, 9628, 33028, 33074, 9630, 33652, 33814, 33815, 9657, 33655, 33817, 33818, 
9659, 9655, 33653, 33816, 9660
23280, 9628, 33028, 33074, 9630, 1181, 9806, 9829, 1182, 33655, 33817, 33818, 9659, 0, 0, 0, 
0, 9656, 33656, 33819, 9661
23281, 8646, 8647, 8670, 8669, 33027, 33029, 33075, 33073, 8926, 8972, 8973, 8970, 33659, 33821, 33822, 
33814, 33650, 33657, 33820, 33813
23282, 33027, 33029, 33075, 33073, 33028, 33030, 33076, 33074, 33659, 33821, 33822, 33814, 33662, 33824, 33825, 
33817, 33653, 33660, 33823, 33816
23283, 33028, 33030, 33076, 33074, 9806, 9807, 9830, 9829, 33662, 33824, 33825, 33817, 0, 0, 0, 
0, 33656, 33663, 33826, 33819
23284, 8647, 8648, 8671, 8670, 33029, 33031, 33077, 33075, 8928, 8974, 8975, 8972, 33666, 33828, 33829, 
33821, 33657, 33664, 33827, 33820
23285, 33029, 33031, 33077, 33075, 33030, 33032, 33078, 33076, 33666, 33828, 33829, 33821, 33669, 33831, 33832, 
33824, 33660, 33667, 33830, 33823
23286, 33030, 33032, 33078, 33076, 9807, 9808, 9831, 9830, 33669, 33831, 33832, 33824, 0, 0, 0, 
0, 33663, 33670, 33833, 33826
23287, 8648, 8649, 8672, 8671, 33031, 33033, 33079, 33077, 8930, 8976, 8977, 8974, 33673, 33835, 33836, 
33828, 33664, 33671, 33834, 33827
23288, 33031, 33033, 33079, 33077, 33032, 33034, 33080, 33078, 33673, 33835, 33836, 33828, 33676, 33838, 33839, 
33831, 33667, 33674, 33837, 33830
23289, 33032, 33034, 33080, 33078, 9808, 9809, 9832, 9831, 33676, 33838, 33839, 33831, 0, 0, 0, 
0, 33670, 33677, 33840, 33833
23290, 8649, 8650, 8673, 8672, 33033, 33035, 33081, 33079, 8932, 8978, 8979, 8976, 33680, 33842, 33843, 
33835, 33671, 33678, 33841, 33834
23291, 33033, 33035, 33081, 33079, 33034, 33036, 33082, 33080, 33680, 33842, 33843, 33835, 33683, 33845, 33846, 
33838, 33674, 33681, 33844, 33837
23292, 33034, 33036, 33082, 33080, 9809, 9810, 9833, 9832, 33683, 33845, 33846, 33838, 0, 0, 0, 
0, 33677, 33684, 33847, 33840
23293, 8650, 8651, 8674, 8673, 33035, 33037, 33083, 33081, 8934, 8980, 8981, 8978, 33687, 33849, 33850, 
33842, 33678, 33685, 33848, 33841
23294, 33035, 33037, 33083, 33081, 33036, 33038, 33084, 33082, 33687, 33849, 33850, 33842, 33690, 33852, 33853, 
33845, 33681, 33688, 33851, 33844
23295, 33036, 33038, 33084, 33082, 9810, 9811, 9834, 9833, 33690, 33852, 33853, 33845, 0, 0, 0, 
0, 33684, 33691, 33854, 33847
23296, 8651, 8652, 8675, 8674, 33037, 33039, 33085, 33083, 8936, 8982, 8983, 8980, 33694, 33856, 33857, 
33849, 33685, 33692, 33855, 33848
23297, 33037, 33039, 33085, 33083, 33038, 33040, 33086, 33084, 33694, 33856, 33857, 33849, 33697, 33859, 33860, 
33852, 33688, 33695, 33858, 33851
23298, 33038, 33040, 33086, 33084, 9811, 9812, 9835, 9834, 33697, 33859, 33860, 33852, 0, 0, 0, 
0, 33691, 33698, 33861, 33854
23299, 8652, 8653, 8676, 8675, 33039, 33041, 33087, 33085, 8938, 8984, 8985, 8982, 33701, 33863, 33864, 
33856, 33692, 33699, 33862, 33855
23300, 33039, 33041, 33087, 33085, 33040, 33042, 33088, 33086, 33701, 33863, 33864, 33856, 33704, 33866, 33867, 
33859, 33695, 33702, 33865, 33858
23301, 33040, 33042, 33088, 33086, 9812, 9813, 9836, 9835, 33704, 33866, 33867, 33859, 0, 0, 0, 
0, 33698, 33705, 33868, 33861
23302, 8653, 8654, 8677, 8676, 33041, 33043, 33089, 33087, 8940, 8986, 8987, 8984, 33708, 33870, 33871, 
33863, 33699, 33706, 33869, 33862
23303, 33041, 33043, 33089, 33087, 33042, 33044, 33090, 33088, 33708, 33870, 33871, 33863, 33711, 33873, 33874, 
33866, 33702, 33709, 33872, 33865
23304, 33042, 33044, 33090, 33088, 9813, 9814, 9837, 9836, 33711, 33873, 33874, 33866, 0, 0, 0, 
0, 33705, 33712, 33875, 33868
23305, 8654, 8655, 8678, 8677, 33043, 33045, 33091, 33089, 8942, 8988, 8989, 8986, 33715, 33877, 33878, 
33870, 33706, 33713, 33876, 33869
23306, 33043, 33045, 33091, 33089, 33044, 33046, 33092, 33090, 33715, 33877, 33878, 33870, 33718, 33880, 33881, 
33873, 33709, 33716, 33879, 33872
23307, 33044, 33046, 33092, 33090, 9814, 9815, 9838, 9837, 33718, 33880, 33881, 33873, 0, 0, 0, 
0, 33712, 33719, 33882, 33875
23308, 8655, 8656, 8679, 8678, 33045, 33047, 33093, 33091, 8944, 8990, 8991, 8988, 33722, 33884, 33885, 
33877, 33713, 33720, 33883, 33876
23309, 33045, 33047, 33093, 33091, 33046, 33048, 33094, 33092, 33722, 33884, 33885, 33877, 33725, 33887, 33888, 
33880, 33716, 33723, 33886, 33879
23310, 33046, 33048, 33094, 33092, 9815, 9816, 9839, 9838, 33725, 33887, 33888, 33880, 0, 0, 0, 
0, 33719, 33726, 33889, 33882
23311, 8656, 8657, 8680, 8679, 33047, 33049, 33095, 33093, 8946, 8992, 8993, 8990, 33729, 33891, 33892, 
33884, 33720, 33727, 33890, 33883
23312, 33047, 33049, 33095, 33093, 33048, 33050, 33096, 33094, 33729, 33891, 33892, 33884, 33732, 33894, 33895, 
33887, 33723, 33730, 33893, 33886
23313, 33048, 33050, 33096, 33094, 9816, 9817, 9840, 9839, 33732, 33894, 33895, 33887, 0, 0, 0, 
0, 33726, 33733, 33896, 33889
23314, 8657, 8658, 8681, 8680, 33049, 33051, 33097, 33095, 8948, 8994, 8995, 8992, 33736, 33898, 33899, 
33891, 33727, 33734, 33897, 33890
23315, 33049, 33051, 33097, 33095, 33050, 33052, 33098, 33096, 33736, 33898, 33899, 33891, 33739, 33901, 33902, 
33894, 33730, 33737, 33900, 33893
23316, 33050, 33052, 33098, 33096, 9817, 9818, 9841, 9840, 33739, 33901, 33902, 33894, 0, 0, 0, 
0, 33733, 33740, 33903, 33896
23317, 8658, 8659, 8682, 8681, 33051, 33053, 33099, 33097, 8950, 8996, 8997, 8994, 33743, 33905, 33906, 
33898, 33734, 33741, 33904, 33897
23318, 33051, 33053, 33099, 33097, 33052, 33054, 33100, 33098, 33743, 33905, 33906, 33898, 33746, 33908, 33909, 
33901, 33737, 33744, 33907, 33900
23319, 33052, 33054, 33100, 33098, 9818, 9819, 9842, 9841, 33746, 33908, 33909, 33901, 0, 0, 0, 
0, 33740, 33747, 33910, 33903
23320, 8659, 8660, 8683, 8682, 33053, 33055, 33101, 33099, 8952, 8998, 8999, 8996, 33750, 33912, 33913, 
33905, 33741, 33748, 33911, 33904
23321, 33053, 33055, 33101, 33099, 33054, 33056, 33102, 33100, 33750, 33912, 33913, 33905, 33753, 33915, 33916, 
33908, 33744, 33751, 33914, 33907
23322, 33054, 33056, 33102, 33100, 9819, 9820, 9843, 9842, 33753, 33915, 33916, 33908, 0, 0, 0, 
0, 33747, 33754, 33917, 33910
23323, 8660, 8661, 8684, 8683, 33055, 33057, 33103, 33101, 8954, 9000, 9001, 8998, 33757, 33919, 33920, 
33912, 33748, 33755, 33918, 33911
23324, 33055, 33057, 33103, 33101, 33056, 33058, 33104, 33102, 33757, 33919, 33920, 33912, 33760, 33922, 33923, 
33915, 33751, 33758, 33921, 33914
23325, 33056, 33058, 33104, 33102, 9820, 9821, 9844, 9843, 33760, 33922, 33923, 33915, 0, 0, 0, 
0, 33754, 33761, 33924, 33917
23326, 8661, 8662, 8685, 8684, 33057, 33059, 33105, 33103, 8956, 9002, 9003, 9000, 33764, 33926, 33927, 
33919, 33755, 33762, 33925, 33918
23327, 33057, 33059, 33105, 33103, 33058, 33060, 33106, 33104, 33764, 33926, 33927, 33919, 33767, 33929, 33930, 
33922, 33758, 33765, 33928, 33921
23328, 33058, 33060, 33106, 33104, 9821, 9822, 9845, 9844, 33767, 33929, 33930, 33922, 0, 0, 0, 
0, 33761, 33768, 33931, 33924
23329, 8662, 8663, 8686, 8685, 33059, 33061, 33107, 33105, 8958, 9004, 9005, 9002, 33771, 33933, 33934, 
33926, 33762, 33769, 33932, 33925
23330, 33059, 33061, 33107, 33105, 33060, 33062, 33108, 33106, 33771, 33933, 33934, 33926, 33774, 33936, 33937, 
33929, 33765, 33772, 33935, 33928
23331, 33060, 33062, 33108, 33106, 9822, 9823, 9846, 9845, 33774, 33936, 33937, 33929, 0, 0, 0, 
0, 33768, 33775, 33938, 33931
23332, 8663, 8664, 8687, 8686, 33061, 33063, 33109, 33107, 8960, 9006, 9007, 9004, 33778, 33940, 33941, 
33933, 33769, 33776, 33939, 33932
23333, 33061, 33063, 33109, 33107, 33062, 33064, 33110, 33108, 33778, 33940, 33941, 33933, 33781, 33943, 33944, 
33936, 33772, 33779, 33942, 33935
23334, 33062, 33064, 33110, 33108, 9823, 9824, 9847, 9846, 33781, 33943, 33944, 33936, 0, 0, 0, 
0, 33775, 33782, 33945, 33938
23335, 8664, 8665, 8688, 8687, 33063, 33065, 33111, 33109, 8962, 9008, 9009, 9006, 33785, 33947, 33948, 
33940, 33776, 33783, 33946, 33939
23336, 33063, 33065, 33111, 33109, 33064, 33066, 33112, 33110, 33785, 33947, 33948, 33940, 33788, 33950, 33951, 
33943, 33779, 33786, 33949, 33942
23337, 33064, 33066, 33112, 33110, 9824, 9825, 9848, 9847, 33788, 33950, 33951, 33943, 0, 0, 0, 
0, 33782, 33789, 33952, 33945
23338, 8665, 8666, 8689, 8688, 33065, 33067, 33113, 33111, 8964, 9010, 9011, 9008, 33792, 33954, 33955, 
33947, 33783, 33790, 33953, 33946
23339, 33065, 33067, 33113, 33111, 33066, 33068, 33114, 33112, 33792, 33954, 33955, 33947, 33795, 33957, 33958, 
33950, 33786, 33793, 33956, 33949
23340, 33066, 33068, 33114, 33112, 9825, 9826, 9849, 9848, 33795, 33957, 33958, 33950, 0, 0, 0, 
0, 33789, 33796, 33959, 33952
23341, 8666, 8667, 8690, 8689, 33067, 33069, 33115, 33113, 8966, 9012, 9013, 9010, 33799, 33961, 33962, 
33954, 33790, 33797, 33960, 33953
23342, 33067, 33069, 33115, 33113, 33068, 33070, 33116, 33114, 33799, 33961, 33962, 33954, 33802, 33964, 33965, 
33957, 33793, 33800, 33963, 33956
23343, 33068, 33070, 33116, 33114, 9826, 9827, 9850, 9849, 33802, 33964, 33965, 33957, 0, 0, 0, 
0, 33796, 33803, 33966, 33959
23344, 8667, 8668, 8691, 8690, 33069, 33071, 33117, 33115, 8968, 9014, 9015, 9012, 33806, 33968, 33969, 
33961, 33797, 33804, 33967, 33960
23345, 33069, 33071, 33117, 33115, 33070, 33072, 33118, 33116, 33806, 33968, 33969, 33961, 33809, 33971, 33972, 
33964, 33800, 33807, 33970, 33963
23346, 33070, 33072, 33118, 33116, 9827, 9828, 9851, 9850, 33809, 33971, 33972, 33964, 0, 0, 0, 
0, 33803, 33810, 33973, 33966
23347, 8668, 1098, 1099, 8691, 33071, 9706, 9708, 33117, 8969, 1110, 9016, 9014, 33811, 9737, 33974, 
33968, 33804, 9731, 9736, 33967
23348, 33071, 9706, 9708, 33117, 33072, 9707, 9709, 33118, 33811, 9737, 33974, 33968, 33812, 9739, 33975, 
33971, 33807, 9733, 9738, 33970
23349, 33072, 9707, 9709, 33118, 9828, 1192, 1193, 9851, 33812, 9739, 33975, 33971, 0, 0, 0, 
0, 33810, 9735, 9740, 33973
23350, 1076, 8669, 8692, 1077, 9629, 33073, 33119, 9631, 8971, 9017, 9018, 1088, 33815, 33977, 33978, 
9662, 9658, 33813, 33976, 9663
23351, 9629, 33073, 33119, 9631, 9630, 33074, 33120, 9632, 33815, 33977, 33978, 9662, 33818, 33980, 33981, 
9664, 9660, 33816, 33979, 9665
23352, 9630, 33074, 33120, 9632, 1182, 9829, 9852, 1183, 33818, 33980, 33981, 9664, 0, 0, 0, 
0, 9661, 33819, 33982, 9666
23353, 8669, 8670, 8693, 8692, 33073, 33075, 33121, 33119, 8973, 9019, 9020, 9017, 33822, 33984, 33985, 
33977, 33813, 33820, 33983, 33976
23354, 33073, 33075, 33121, 33119, 33074, 33076, 33122, 33120, 33822, 33984, 33985, 33977, 33825, 33987, 33988, 
33980, 33816, 33823, 33986, 33979
23355, 33074, 33076, 33122, 33120, 9829, 9830, 9853, 9852, 33825, 33987, 33988, 33980, 0, 0, 0, 
0, 33819, 33826, 33989, 33982
23356, 8670, 8671, 8694, 8693, 33075, 33077, 33123, 33121, 8975, 9021, 9022, 9019, 33829, 33991, 33992, 
33984, 33820, 33827, 33990, 33983
23357, 33075, 33077, 33123, 33121, 33076, 33078, 33124, 33122, 33829, 33991, 33992, 33984, 33832, 33994, 33995, 
33987, 33823, 33830, 33993, 33986
23358, 33076, 33078, 33124, 33122, 9830, 9831, 9854, 9853, 33832, 33994, 33995, 33987, 0, 0, 0, 
0, 33826, 33833, 33996, 33989
23359, 8671, 8672, 8695, 8694, 33077, 33079, 33125, 33123, 8977, 9023, 9024, 9021, 33836, 33998, 33999, 
33991, 33827, 33834, 33997, 33990
23360, 33077, 33079, 33125, 33123, 33078, 33080, 33126, 33124, 33836, 33998, 33999, 33991, 33839, 34001, 34002, 
33994, 33830, 33837, 34000, 33993
23361, 33078, 33080, 33126, 33124, 9831, 9832, 9855, 9854, 33839, 34001, 34002, 33994, 0, 0, 0, 
0, 33833, 33840, 34003, 33996
23362, 8672, 8673, 8696, 8695, 33079, 33081, 33127, 33125, 8979, 9025, 9026, 9023, 33843, 34005, 34006, 
33998, 33834, 33841, 34004, 33997
23363, 33079, 33081, 33127, 33125, 33080, 33082, 33128, 33126, 33843, 34005, 34006, 33998, 33846, 34008, 34009, 
34001, 33837, 33844, 34007, 34000
23364, 33080, 33082, 33128, 33126, 9832, 9833, 9856, 9855, 33846, 34008, 34009, 34001, 0, 0, 0, 
0, 33840, 33847, 34010, 34003
23365, 8673, 8674, 8697, 8696, 33081, 33083, 33129, 33127, 8981, 9027, 9028, 9025, 33850, 34012, 34013, 
34005, 33841, 33848, 34011, 34004
23366, 33081, 33083, 33129, 33127, 33082, 33084, 33130, 33128, 33850, 34012, 34013, 34005, 33853, 34015, 34016, 
34008, 33844, 33851, 34014, 34007
23367, 33082, 33084, 33130, 33128, 9833, 9834, 9857, 9856, 33853, 34015, 34016, 34008, 0, 0, 0, 
0, 33847, 33854, 34017, 34010
23368, 8674, 8675, 8698, 8697, 33083, 33085, 33131, 33129, 8983, 9029, 9030, 9027, 33857, 34019, 34020, 
34012, 33848, 33855, 34018, 34011
23369, 33083, 33085, 33131, 33129, 33084, 33086, 33132, 33130, 33857, 34019, 34020, 34012, 33860, 34022, 34023, 
34015, 33851, 33858, 34021, 34014
23370, 33084, 33086, 33132, 33130, 9834, 9835, 9858, 9857, 33860, 34022, 34023, 34015, 0, 0, 0, 
0, 33854, 33861, 34024, 34017
23371, 8675, 8676, 8699, 8698, 33085, 33087, 33133, 33131, 8985, 9031, 9032, 9029, 33864, 34026, 34027, 
34019, 33855, 33862, 34025, 34018
23372, 33085, 33087, 33133, 33131, 33086, 33088, 33134, 33132, 33864, 34026, 34027, 34019, 33867, 34029, 34030, 
34022, 33858, 33865, 34028, 34021
23373, 33086, 33088, 33134, 33132, 9835, 9836, 9859, 9858, 33867, 34029, 34030, 34022, 0, 0, 0, 
0, 33861, 33868, 34031, 34024
23374, 8676, 8677, 8700, 8699, 33087, 33089, 33135, 33133, 8987, 9033, 9034, 9031, 33871, 34033, 34034, 
34026, 33862, 33869, 34032, 34025
23375, 33087, 33089, 33135, 33133, 33088, 33090, 33136, 33134, 33871, 34033, 34034, 34026, 33874, 34036, 34037, 
34029, 33865, 33872, 34035, 34028
23376, 33088, 33090, 33136, 33134, 9836, 9837, 9860, 9859, 33874, 34036, 34037, 34029, 0, 0, 0, 
0, 33868, 33875, 34038, 34031
23377, 8677, 8678, 8701, 8700, 33089, 33091, 33137, 33135, 8989, 9035, 9036, 9033, 33878, 34040, 34041, 
34033, 33869, 33876, 34039, 34032
23378, 33089, 33091, 33137, 33135, 33090, 33092, 33138, 33136, 33878, 34040, 34041, 34033, 33881, 34043, 34044, 
34036, 33872, 33879, 34042, 34035
23379, 33090, 33092, 33138, 33136, 9837, 9838, 9861, 9860, 33881, 34043, 34044, 34036, 0, 0, 0, 
0, 33875, 33882, 34045, 34038
23380, 8678, 8679, 8702, 8701, 33091, 33093, 33139, 33137, 8991, 9037, 9038, 9035, 33885, 34047, 34048, 
34040, 33876, 33883, 34046, 34039
23381, 33091, 33093, 33139, 33137, 33092, 33094, 33140, 33138, 33885, 34047, 34048, 34040, 33888, 34050, 34051, 
34043, 33879, 33886, 34049, 34042
23382, 33092, 33094, 33140, 33138, 9838, 9839, 9862, 9861, 33888, 34050, 34051, 34043, 0, 0, 0, 
0, 33882, 33889, 34052, 34045
23383, 8679, 8680, 8703, 8702, 33093, 33095, 33141, 33139, 8993, 9039, 9040, 9037, 33892, 34054, 34055, 
34047, 33883, 33890, 34053, 34046
23384, 33093, 33095, 33141, 33139, 33094, 33096, 33142, 33140, 33892, 34054, 34055, 34047, 33895, 34057, 34058, 
34050, 33886, 33893, 34056, 34049
23385, 33094, 33096, 33142, 33140, 9839, 9840, 9863, 9862, 33895, 34057, 34058, 34050, 0, 0, 0, 
0, 33889, 33896, 34059, 34052
23386, 8680, 8681, 8704, 8703, 33095, 33097, 33143, 33141, 8995, 9041, 9042, 9039, 33899, 34061, 34062, 
34054, 33890, 33897, 34060, 34053
23387, 33095, 33097, 33143, 33141, 33096, 33098, 33144, 33142, 33899, 34061, 34062, 34054, 33902, 34064, 34065, 
34057, 33893, 33900, 34063, 34056
23388, 33096, 33098, 33144, 33142, 9840, 9841, 9864, 9863, 33902, 34064, 34065, 34057, 0, 0, 0, 
0, 33896, 33903, 34066, 34059
23389, 8681, 8682, 8705, 8704, 33097, 33099, 33145, 33143, 8997, 9043, 9044, 9041, 33906, 34068, 34069, 
34061, 33897, 33904, 34067, 34060
23390, 33097, 33099, 33145, 33143, 33098, 33100, 33146, 33144, 33906, 34068, 34069, 34061, 33909, 34071, 34072, 
34064, 33900, 33907, 34070, 34063
23391, 33098, 33100, 33146, 33144, 9841, 9842, 9865, 9864, 33909, 34071, 34072, 34064, 0, 0, 0, 
0, 33903, 33910, 34073, 34066
23392, 8682, 8683, 8706, 8705, 33099, 33101, 33147, 33145, 8999, 9045, 9046, 9043, 33913, 34075, 34076, 
34068, 33904, 33911, 34074, 34067
23393, 33099, 33101, 33147, 33145, 33100, 33102, 33148, 33146, 33913, 34075, 34076, 34068, 33916, 34078, 34079, 
34071, 33907, 33914, 34077, 34070
23394, 33100, 33102, 33148, 33146, 9842, 9843, 9866, 9865, 33916, 34078, 34079, 34071, 0, 0, 0, 
0, 33910, 33917, 34080, 34073
23395, 8683, 8684, 8707, 8706, 33101, 33103, 33149, 33147, 9001, 9047, 9048, 9045, 33920, 34082, 34083, 
34075, 33911, 33918, 34081, 34074
23396, 33101, 33103, 33149, 33147, 33102, 33104, 33150, 33148, 33920, 34082, 34083, 34075, 33923, 34085, 34086, 
34078, 33914, 33921, 34084, 34077
23397, 33102, 33104, 33150, 33148, 9843, 9844, 9867, 9866, 33923, 34085, 34086, 34078, 0, 0, 0, 
0, 33917, 33924, 34087, 34080
23398, 8684, 8685, 8708, 8707, 33103, 33105, 33151, 33149, 9003, 9049, 9050, 9047, 33927, 34089, 34090, 
34082, 33918, 33925, 34088, 34081
23399, 33103, 33105, 33151, 33149, 33104, 33106, 33152, 33150, 33927, 34089, 34090, 34082, 33930, 34092, 34093, 
34085, 33921, 33928, 34091, 34084
23400, 33104, 33106, 33152, 33150, 9844, 9845, 9868, 9867, 33930, 34092, 34093, 34085, 0, 0, 0, 
0, 33924, 33931, 34094, 34087
23401, 8685, 8686, 8709, 8708, 33105, 33107, 33153, 33151, 9005, 9051, 9052, 9049, 33934, 34096, 34097, 
34089, 33925, 33932, 34095, 34088
23402, 33105, 33107, 33153, 33151, 33106, 33108, 33154, 33152, 33934, 34096, 34097, 34089, 33937, 34099, 34100, 
34092, 33928, 33935, 34098, 34091
23403, 33106, 33108, 33154, 33152, 9845, 9846, 9869, 9868, 33937, 34099, 34100, 34092, 0, 0, 0, 
0, 33931, 33938, 34101, 34094
23404, 8686, 8687, 8710, 8709, 33107, 33109, 33155, 33153, 9007, 9053, 9054, 9051, 33941, 34103, 34104, 
34096, 33932, 33939, 34102, 34095
23405, 33107, 33109, 33155, 33153, 33108, 33110, 33156, 33154, 33941, 34103, 34104, 34096, 33944, 34106, 34107, 
34099, 33935, 33942, 34105, 34098
23406, 33108, 33110, 33156, 33154, 9846, 9847, 9870, 9869, 33944, 34106, 34107, 34099, 0, 0, 0, 
0, 33938, 33945, 34108, 34101
23407, 8687, 8688, 8711, 8710, 33109, 33111, 33157, 33155, 9009, 9055, 9056, 9053, 33948, 34110, 34111, 
34103, 33939, 33946, 34109, 34102
23408, 33109, 33111, 33157, 33155, 33110, 33112, 33158, 33156, 33948, 34110, 34111, 34103, 33951, 34113, 34114, 
34106, 33942, 33949, 34112, 34105
23409, 33110, 33112, 33158, 33156, 9847, 9848, 9871, 9870, 33951, 34113, 34114, 34106, 0, 0, 0, 
0, 33945, 33952, 34115, 34108
23410, 8688, 8689, 8712, 8711, 33111, 33113, 33159, 33157, 9011, 9057, 9058, 9055, 33955, 34117, 34118, 
34110, 33946, 33953, 34116, 34109
23411, 33111, 33113, 33159, 33157, 33112, 33114, 33160, 33158, 33955, 34117, 34118, 34110, 33958, 34120, 34121, 
34113, 33949, 33956, 34119, 34112
23412, 33112, 33114, 33160, 33158, 9848, 9849, 9872, 9871, 33958, 34120, 34121, 34113, 0, 0, 0, 
0, 33952, 33959, 34122, 34115
23413, 8689, 8690, 8713, 8712, 33113, 33115, 33161, 33159, 9013, 9059, 9060, 9057, 33962, 34124, 34125, 
34117, 33953, 33960, 34123, 34116
23414, 33113, 33115, 33161, 33159, 33114, 33116, 33162, 33160, 33962, 34124, 34125, 34117, 33965, 34127, 34128, 
34120, 33956, 33963, 34126, 34119
23415, 33114, 33116, 33162, 33160, 9849, 9850, 9873, 9872, 33965, 34127, 34128, 34120, 0, 0, 0, 
0, 33959, 33966, 34129, 34122
23416, 8690, 8691, 8714, 8713, 33115, 33117, 33163, 33161, 9015, 9061, 9062, 9059, 33969, 34131, 34132, 
34124, 33960, 33967, 34130, 34123
23417, 33115, 33117, 33163, 33161, 33116, 33118, 33164, 33162, 33969, 34131, 34132, 34124, 33972, 34134, 34135, 
34127, 33963, 33970, 34133, 34126
23418, 33116, 33118, 33164, 33162, 9850, 9851, 9874, 9873, 33972, 34134, 34135, 34127, 0, 0, 0, 
0, 33966, 33973, 34136, 34129
23419, 8691, 1099, 1100, 8714, 33117, 9708, 9710, 33163, 9016, 1111, 9063, 9061, 33974, 9742, 34137, 
34131, 33967, 9736, 9741, 34130
23420, 33117, 9708, 9710, 33163, 33118, 9709, 9711, 33164, 33974, 9742, 34137, 34131, 33975, 9744, 34138, 
34134, 33970, 9738, 9743, 34133
23421, 33118, 9709, 9711, 33164, 9851, 1193, 1194, 9874, 33975, 9744, 34138, 34134, 0, 0, 0, 
0, 33973, 9740, 9745, 34136
23422, 1077, 8692, 8715, 1078, 9631, 33119, 33165, 9633, 9018, 9064, 9065, 1089, 33978, 34140, 34141, 
9667, 9663, 33976, 34139, 9668
23423, 9631, 33119, 33165, 9633, 9632, 33120, 33166, 9634, 33978, 34140, 34141, 9667, 33981, 34143, 34144, 
9669, 9665, 33979, 34142, 9670
23424, 9632, 33120, 33166, 9634, 1183, 9852, 9875, 1184, 33981, 34143, 34144, 9669, 0, 0, 0, 
0, 9666, 33982, 34145, 9671
23425, 8692, 8693, 8716, 8715, 33119, 33121, 33167, 33165, 9020, 9066, 9067, 9064, 33985, 34147, 34148, 
34140, 33976, 33983, 34146, 34139
23426, 33119, 33121, 33167, 33165, 33120, 33122, 33168, 33166, 33985, 34147, 34148, 34140, 33988, 34150, 34151, 
34143, 33979, 33986, 34149, 34142
23427, 33120, 33122, 33168, 33166, 9852, 9853, 9876, 9875, 33988, 34150, 34151, 34143, 0, 0, 0, 
0, 33982, 33989, 34152, 34145
23428, 8693, 8694, 8717, 8716, 33121, 33123, 33169, 33167, 9022, 9068, 9069, 9066, 33992, 34154, 34155, 
34147, 33983, 33990, 34153, 34146
23429, 33121, 33123, 33169, 33167, 33122, 33124, 33170, 33168, 33992, 34154, 34155, 34147, 33995, 34157, 34158, 
34150, 33986, 33993, 34156, 34149
23430, 33122, 33124, 33170, 33168, 9853, 9854, 9877, 9876, 33995, 34157, 34158, 34150, 0, 0, 0, 
0, 33989, 33996, 34159, 34152
23431, 8694, 8695, 8718, 8717, 33123, 33125, 33171, 33169, 9024, 9070, 9071, 9068, 33999, 34161, 34162, 
34154, 33990, 33997, 34160, 34153
23432, 33123, 33125, 33171, 33169, 33124, 33126, 33172, 33170, 33999, 34161, 34162, 34154, 34002, 34164, 34165, 
34157, 33993, 34000, 34163, 34156
23433, 33124, 33126, 33172, 33170, 9854, 9855, 9878, 9877, 34002, 34164, 34165, 34157, 0, 0, 0, 
0, 33996, 34003, 34166, 34159
23434, 8695, 8696, 8719, 8718, 33125, 33127, 33173, 33171, 9026, 9072, 9073, 9070, 34006, 34168, 34169, 
34161, 33997, 34004, 34167, 34160
23435, 33125, 33127, 33173, 33171, 33126, 33128, 33174, 33172, 34006, 34168, 34169, 34161, 34009, 34171, 34172, 
34164, 34000, 34007, 34170, 34163
23436, 33126, 33128, 33174, 33172, 9855, 9856, 9879, 9878, 34009, 34171, 34172, 34164, 0, 0, 0, 
0, 34003, 34010, 34173, 34166
23437, 8696, 8697, 8720, 8719, 33127, 33129, 33175, 33173, 9028, 9074, 9075, 9072, 34013, 34175, 34176, 
34168, 34004, 34011, 34174, 34167
23438, 33127, 33129, 33175, 33173, 33128, 33130, 33176, 33174, 34013, 34175, 34176, 34168, 34016, 34178, 34179, 
34171, 34007, 34014, 34177, 34170
23439, 33128, 33130, 33176, 33174, 9856, 9857, 9880, 9879, 34016, 34178, 34179, 34171, 0, 0, 0, 
0, 34010, 34017, 34180, 34173
23440, 8697, 8698, 8721, 8720, 33129, 33131, 33177, 33175, 9030, 9076, 9077, 9074, 34020, 34182, 34183, 
34175, 34011, 34018, 34181, 34174
23441, 33129, 33131, 33177, 33175, 33130, 33132, 33178, 33176, 34020, 34182, 34183, 34175, 34023, 34185, 34186, 
34178, 34014, 34021, 34184, 34177
23442, 33130, 33132, 33178, 33176, 9857, 9858, 9881, 9880, 34023, 34185, 34186, 34178, 0, 0, 0, 
0, 34017, 34024, 34187, 34180
23443, 8698, 8699, 8722, 8721, 33131, 33133, 33179, 33177, 9032, 9078, 9079, 9076, 34027, 34189, 34190, 
34182, 34018, 34025, 34188, 34181
23444, 33131, 33133, 33179, 33177, 33132, 33134, 33180, 33178, 34027, 34189, 34190, 34182, 34030, 34192, 34193, 
34185, 34021, 34028, 34191, 34184
23445, 33132, 33134, 33180, 33178, 9858, 9859, 9882, 9881, 34030, 34192, 34193, 34185, 0, 0, 0, 
0, 34024, 34031, 34194, 34187
23446, 8699, 8700, 8723, 8722, 33133, 33135, 33181, 33179, 9034, 9080, 9081, 9078, 34034, 34196, 34197, 
34189, 34025, 34032, 34195, 34188
23447, 33133, 33135, 33181, 33179, 33134, 33136, 33182, 33180, 34034, 34196, 34197, 34189, 34037, 34199, 34200, 
34192, 34028, 34035, 34198, 34191
23448, 33134, 33136, 33182, 33180, 9859, 9860, 9883, 9882, 34037, 34199, 34200, 34192, 0, 0, 0, 
0, 34031, 34038, 34201, 34194
23449, 8700, 8701, 8724, 8723, 33135, 33137, 33183, 33181, 9036, 9082, 9083, 9080, 34041, 34203, 34204, 
34196, 34032, 34039, 34202, 34195
23450, 33135, 33137, 33183, 33181, 33136, 33138, 33184, 33182, 34041, 34203, 34204, 34196, 34044, 34206, 34207, 
34199, 34035, 34042, 34205, 34198
23451, 33136, 33138, 33184, 33182, 9860, 9861, 9884, 9883, 34044, 34206, 34207, 34199, 0, 0, 0, 
0, 34038, 34045, 34208, 34201
23452, 8701, 8702, 8725, 8724, 33137, 33139, 33185, 33183, 9038, 9084, 9085, 9082, 34048, 34210, 34211, 
34203, 34039, 34046, 34209, 34202
23453, 33137, 33139, 33185, 33183, 33138, 33140, 33186, 33184, 34048, 34210, 34211, 34203, 34051, 34213, 34214, 
34206, 34042, 34049, 34212, 34205
23454, 33138, 33140, 33186, 33184, 9861, 9862, 9885, 9884, 34051, 34213, 34214, 34206, 0, 0, 0, 
0, 34045, 34052, 34215, 34208
23455, 8702, 8703, 8726, 8725, 33139, 33141, 33187, 33185, 9040, 9086, 9087, 9084, 34055, 34217, 34218, 
34210, 34046, 34053, 34216, 34209
23456, 33139, 33141, 33187, 33185, 33140, 33142, 33188, 33186, 34055, 34217, 34218, 34210, 34058, 34220, 34221, 
34213, 34049, 34056, 34219, 34212
23457, 33140, 33142, 33188, 33186, 9862, 9863, 9886, 9885, 34058, 34220, 34221, 34213, 0, 0, 0, 
0, 34052, 34059, 34222, 34215
23458, 8703, 8704, 8727, 8726, 33141, 33143, 33189, 33187, 9042, 9088, 9089, 9086, 34062, 34224, 34225, 
34217, 34053, 34060, 34223, 34216
23459, 33141, 33143, 33189, 33187, 33142, 33144, 33190, 33188, 34062, 34224, 34225, 34217, 34065, 34227, 34228, 
34220, 34056, 34063, 34226, 34219
23460, 33142, 33144, 33190, 33188, 9863, 9864, 9887, 9886, 34065, 34227, 34228, 34220, 0, 0, 0, 
0, 34059, 34066, 34229, 34222
23461, 8704, 8705, 8728, 8727, 33143, 33145, 33191, 33189, 9044, 9090, 9091, 9088, 34069, 34231, 34232, 
34224, 34060, 34067, 34230, 34223
23462, 33143, 33145, 33191, 33189, 33144, 33146, 33192, 33190, 34069, 34231, 34232, 34224, 34072, 34234, 34235, 
34227, 34063, 34070, 34233, 34226
23463, 33144, 33146, 33192, 33190, 9864, 9865, 9888, 9887, 34072, 34234, 34235, 34227, 0, 0, 0, 
0, 34066, 34073, 34236, 34229
23464, 8705, 8706, 8729, 8728, 33145, 33147, 33193, 33191, 9046, 9092, 9093, 9090, 34076, 34238, 34239, 
34231, 34067, 34074, 34237, 34230
23465, 33145, 33147, 33193, 33191, 33146, 33148, 33194, 33192, 34076, 34238, 34239, 34231, 34079, 34241, 34242, 
34234, 34070, 34077, 34240, 34233
23466, 33146, 33148, 33194, 33192, 9865, 9866, 9889, 9888, 34079, 34241, 34242, 34234, 0, 0, 0, 
0, 34073, 34080, 34243, 34236
23467, 8706, 8707, 8730, 8729, 33147, 33149, 33195, 33193, 9048, 9094, 9095, 9092, 34083, 34245, 34246, 
34238, 34074, 34081, 34244, 34237
23468, 33147, 33149, 33195, 33193, 33148, 33150, 33196, 33194, 34083, 34245, 34246, 34238, 34086, 34248, 34249, 
34241, 34077, 34084, 34247, 34240
23469, 33148, 33150, 33196, 33194, 9866, 9867, 9890, 9889, 34086, 34248, 34249, 34241, 0, 0, 0, 
0, 34080, 34087, 34250, 34243
23470, 8707, 8708, 8731, 8730, 33149, 33151, 33197, 33195, 9050, 9096, 9097, 9094, 34090, 34252, 34253, 
34245, 34081, 34088, 34251, 34244
23471, 33149, 33151, 33197, 33195, 33150, 33152, 33198, 33196, 34090, 34252, 34253, 34245, 34093, 34255, 34256, 
34248, 34084, 34091, 34254, 34247
23472, 33150, 33152, 33198, 33196, 9867, 9868, 9891, 9890, 34093, 34255, 34256, 34248, 0, 0, 0, 
0, 34087, 34094, 34257, 34250
23473, 8708, 8709, 8732, 8731, 33151, 33153, 33199, 33197, 9052, 9098, 9099, 9096, 34097, 34259, 34260, 
34252, 34088, 34095, 34258, 34251
23474, 33151, 33153, 33199, 33197, 33152, 33154, 33200, 33198, 34097, 34259, 34260, 34252, 34100, 34262, 34263, 
34255, 34091, 34098, 34261, 34254
23475, 33152, 33154, 33200, 33198, 9868, 9869, 9892, 9891, 34100, 34262, 34263, 34255, 0, 0, 0, 
0, 34094, 34101, 34264, 34257
23476, 8709, 8710, 8733, 8732, 33153, 33155, 33201, 33199, 9054, 9100, 9101, 9098, 34104, 34266, 34267, 
34259, 34095, 34102, 34265, 34258
23477, 33153, 33155, 33201, 33199, 33154, 33156, 33202, 33200, 34104, 34266, 34267, 34259, 34107, 34269, 34270, 
34262, 34098, 34105, 34268, 34261
23478, 33154, 33156, 33202, 33200, 9869, 9870, 9893, 9892, 34107, 34269, 34270, 34262, 0, 0, 0, 
0, 34101, 34108, 34271, 34264
23479, 8710, 8711, 8734, 8733, 33155, 33157, 33203, 33201, 9056, 9102, 9103, 9100, 34111, 34273, 34274, 
34266, 34102, 34109, 34272, 34265
23480, 33155, 33157, 33203, 33201, 33156, 33158, 33204, 33202, 34111, 34273, 34274, 34266, 34114, 34276, 34277, 
34269, 34105, 34112, 34275, 34268
23481, 33156, 33158, 33204, 33202, 9870, 9871, 9894, 9893, 34114, 34276, 34277, 34269, 0, 0, 0, 
0, 34108, 34115, 34278, 34271
23482, 8711, 8712, 8735, 8734, 33157, 33159, 33205, 33203, 9058, 9104, 9105, 9102, 34118, 34280, 34281, 
34273, 34109, 34116, 34279, 34272
23483, 33157, 33159, 33205, 33203, 33158, 33160, 33206, 33204, 34118, 34280, 34281, 34273, 34121, 34283, 34284, 
34276, 34112, 34119, 34282, 34275
23484, 33158, 33160, 33206, 33204, 9871, 9872, 9895, 9894, 34121, 34283, 34284, 34276, 0, 0, 0, 
0, 34115, 34122, 34285, 34278
23485, 8712, 8713, 8736, 8735, 33159, 33161, 33207, 33205, 9060, 9106, 9107, 9104, 34125, 34287, 34288, 
34280, 34116, 34123, 34286, 34279
23486, 33159, 33161, 33207, 33205, 33160, 33162, 33208, 33206, 34125, 34287, 34288, 34280, 34128, 34290, 34291, 
34283, 34119, 34126, 34289, 34282
23487, 33160, 33162, 33208, 33206, 9872, 9873, 9896, 9895, 34128, 34290, 34291, 34283, 0, 0, 0, 
0, 34122, 34129, 34292, 34285
23488, 8713, 8714, 8737, 8736, 33161, 33163, 33209, 33207, 9062, 9108, 9109, 9106, 34132, 34294, 34295, 
34287, 34123, 34130, 34293, 34286
23489, 33161, 33163, 33209, 33207, 33162, 33164, 33210, 33208, 34132, 34294, 34295, 34287, 34135, 34297, 34298, 
34290, 34126, 34133, 34296, 34289
23490, 33162, 33164, 33210, 33208, 9873, 9874, 9897, 9896, 34135, 34297, 34298, 34290, 0, 0, 0, 
0, 34129, 34136, 34299, 34292
23491, 8714, 1100, 1101, 8737, 33163, 9710, 9712, 33209, 9063, 1112, 9110, 9108, 34137, 9747, 34300, 
34294, 34130, 9741, 9746, 34293
23492, 33163, 9710, 9712, 33209, 33164, 9711, 9713, 33210, 34137, 9747, 34300, 34294, 34138, 9749, 34301, 
34297, 34133, 9743, 9748, 34296
23493, 33164, 9711, 9713, 33210, 9874, 1194, 1195, 9897, 34138, 9749, 34301, 34297, 0, 0, 0, 
0, 34136, 9745, 9750, 34299
23494, 1078, 8715, 8738, 1079, 9633, 33165, 33211, 9635, 9065, 9111, 9112, 1090, 34141, 34303, 34304, 
9672, 9668, 34139, 34302, 9673
23495, 9633, 33165, 33211, 9635, 9634, 33166, 33212, 9636, 34141, 34303, 34304, 9672, 34144, 34306, 34307, 
