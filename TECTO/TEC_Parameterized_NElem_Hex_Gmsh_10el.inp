12339, 24813, 24836, 25089, 25066, 24814, 24837, 25090, 25067, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12340, 24814, 24837, 25090, 25067, 24815, 24838, 25091, 25068, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12341, 24815, 24838, 25091, 25068, 24816, 24839, 25092, 25069, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12342, 24816, 24839, 25092, 25069, 24817, 24840, 25093, 25070, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12343, 24817, 24840, 25093, 25070, 24818, 24841, 25094, 25071, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12344, 24818, 24841, 25094, 25071, 24819, 24842, 25095, 25072, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12345, 24819, 24842, 25095, 25072, 5076, 5077, 5088, 5087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12346, 3260, 3261, 3272, 3271, 24820, 24843, 25096, 25073, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12347, 24820, 24843, 25096, 25073, 24821, 24844, 25097, 25074, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12348, 24821, 24844, 25097, 25074, 24822, 24845, 25098, 25075, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12349, 24822, 24845, 25098, 25075, 24823, 24846, 25099, 25076, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12350, 24823, 24846, 25099, 25076, 24824, 24847, 25100, 25077, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12351, 24824, 24847, 25100, 25077, 24825, 24848, 25101, 25078, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12352, 24825, 24848, 25101, 25078, 24826, 24849, 25102, 25079, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12353, 24826, 24849, 25102, 25079, 24827, 24850, 25103, 25080, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12354, 24827, 24850, 25103, 25080, 24828, 24851, 25104, 25081, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12355, 24828, 24851, 25104, 25081, 24829, 24852, 25105, 25082, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12356, 24829, 24852, 25105, 25082, 24830, 24853, 25106, 25083, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12357, 24830, 24853, 25106, 25083, 24831, 24854, 25107, 25084, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12358, 24831, 24854, 25107, 25084, 24832, 24855, 25108, 25085, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12359, 24832, 24855, 25108, 25085, 24833, 24856, 25109, 25086, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12360, 24833, 24856, 25109, 25086, 24834, 24857, 25110, 25087, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12361, 24834, 24857, 25110, 25087, 24835, 24858, 25111, 25088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12362, 24835, 24858, 25111, 25088, 24836, 24859, 25112, 25089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12363, 24836, 24859, 25112, 25089, 24837, 24860, 25113, 25090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12364, 24837, 24860, 25113, 25090, 24838, 24861, 25114, 25091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12365, 24838, 24861, 25114, 25091, 24839, 24862, 25115, 25092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12366, 24839, 24862, 25115, 25092, 24840, 24863, 25116, 25093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12367, 24840, 24863, 25116, 25093, 24841, 24864, 25117, 25094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12368, 24841, 24864, 25117, 25094, 24842, 24865, 25118, 25095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12369, 24842, 24865, 25118, 25095, 5077, 5078, 5089, 5088, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12370, 3261, 3262, 3273, 3272, 24843, 24866, 25119, 25096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12371, 24843, 24866, 25119, 25096, 24844, 24867, 25120, 25097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12372, 24844, 24867, 25120, 25097, 24845, 24868, 25121, 25098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12373, 24845, 24868, 25121, 25098, 24846, 24869, 25122, 25099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12374, 24846, 24869, 25122, 25099, 24847, 24870, 25123, 25100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12375, 24847, 24870, 25123, 25100, 24848, 24871, 25124, 25101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12376, 24848, 24871, 25124, 25101, 24849, 24872, 25125, 25102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12377, 24849, 24872, 25125, 25102, 24850, 24873, 25126, 25103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12378, 24850, 24873, 25126, 25103, 24851, 24874, 25127, 25104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12379, 24851, 24874, 25127, 25104, 24852, 24875, 25128, 25105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12380, 24852, 24875, 25128, 25105, 24853, 24876, 25129, 25106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12381, 24853, 24876, 25129, 25106, 24854, 24877, 25130, 25107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12382, 24854, 24877, 25130, 25107, 24855, 24878, 25131, 25108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12383, 24855, 24878, 25131, 25108, 24856, 24879, 25132, 25109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12384, 24856, 24879, 25132, 25109, 24857, 24880, 25133, 25110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12385, 24857, 24880, 25133, 25110, 24858, 24881, 25134, 25111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12386, 24858, 24881, 25134, 25111, 24859, 24882, 25135, 25112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12387, 24859, 24882, 25135, 25112, 24860, 24883, 25136, 25113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12388, 24860, 24883, 25136, 25113, 24861, 24884, 25137, 25114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12389, 24861, 24884, 25137, 25114, 24862, 24885, 25138, 25115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12390, 24862, 24885, 25138, 25115, 24863, 24886, 25139, 25116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12391, 24863, 24886, 25139, 25116, 24864, 24887, 25140, 25117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12392, 24864, 24887, 25140, 25117, 24865, 24888, 25141, 25118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12393, 24865, 24888, 25141, 25118, 5078, 5079, 5090, 5089, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12394, 3262, 3263, 3274, 3273, 24866, 24889, 25142, 25119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12395, 24866, 24889, 25142, 25119, 24867, 24890, 25143, 25120, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12396, 24867, 24890, 25143, 25120, 24868, 24891, 25144, 25121, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12397, 24868, 24891, 25144, 25121, 24869, 24892, 25145, 25122, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12398, 24869, 24892, 25145, 25122, 24870, 24893, 25146, 25123, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12399, 24870, 24893, 25146, 25123, 24871, 24894, 25147, 25124, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12400, 24871, 24894, 25147, 25124, 24872, 24895, 25148, 25125, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12401, 24872, 24895, 25148, 25125, 24873, 24896, 25149, 25126, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12402, 24873, 24896, 25149, 25126, 24874, 24897, 25150, 25127, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12403, 24874, 24897, 25150, 25127, 24875, 24898, 25151, 25128, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12404, 24875, 24898, 25151, 25128, 24876, 24899, 25152, 25129, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12405, 24876, 24899, 25152, 25129, 24877, 24900, 25153, 25130, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12406, 24877, 24900, 25153, 25130, 24878, 24901, 25154, 25131, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12407, 24878, 24901, 25154, 25131, 24879, 24902, 25155, 25132, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12408, 24879, 24902, 25155, 25132, 24880, 24903, 25156, 25133, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12409, 24880, 24903, 25156, 25133, 24881, 24904, 25157, 25134, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12410, 24881, 24904, 25157, 25134, 24882, 24905, 25158, 25135, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12411, 24882, 24905, 25158, 25135, 24883, 24906, 25159, 25136, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12412, 24883, 24906, 25159, 25136, 24884, 24907, 25160, 25137, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12413, 24884, 24907, 25160, 25137, 24885, 24908, 25161, 25138, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12414, 24885, 24908, 25161, 25138, 24886, 24909, 25162, 25139, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12415, 24886, 24909, 25162, 25139, 24887, 24910, 25163, 25140, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12416, 24887, 24910, 25163, 25140, 24888, 24911, 25164, 25141, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12417, 24888, 24911, 25164, 25141, 5079, 5080, 5091, 5090, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12418, 3263, 3264, 3275, 3274, 24889, 24912, 25165, 25142, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12419, 24889, 24912, 25165, 25142, 24890, 24913, 25166, 25143, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12420, 24890, 24913, 25166, 25143, 24891, 24914, 25167, 25144, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12421, 24891, 24914, 25167, 25144, 24892, 24915, 25168, 25145, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12422, 24892, 24915, 25168, 25145, 24893, 24916, 25169, 25146, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12423, 24893, 24916, 25169, 25146, 24894, 24917, 25170, 25147, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12424, 24894, 24917, 25170, 25147, 24895, 24918, 25171, 25148, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12425, 24895, 24918, 25171, 25148, 24896, 24919, 25172, 25149, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12426, 24896, 24919, 25172, 25149, 24897, 24920, 25173, 25150, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12427, 24897, 24920, 25173, 25150, 24898, 24921, 25174, 25151, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12428, 24898, 24921, 25174, 25151, 24899, 24922, 25175, 25152, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12429, 24899, 24922, 25175, 25152, 24900, 24923, 25176, 25153, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12430, 24900, 24923, 25176, 25153, 24901, 24924, 25177, 25154, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12431, 24901, 24924, 25177, 25154, 24902, 24925, 25178, 25155, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12432, 24902, 24925, 25178, 25155, 24903, 24926, 25179, 25156, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12433, 24903, 24926, 25179, 25156, 24904, 24927, 25180, 25157, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12434, 24904, 24927, 25180, 25157, 24905, 24928, 25181, 25158, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12435, 24905, 24928, 25181, 25158, 24906, 24929, 25182, 25159, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12436, 24906, 24929, 25182, 25159, 24907, 24930, 25183, 25160, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12437, 24907, 24930, 25183, 25160, 24908, 24931, 25184, 25161, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12438, 24908, 24931, 25184, 25161, 24909, 24932, 25185, 25162, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12439, 24909, 24932, 25185, 25162, 24910, 24933, 25186, 25163, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12440, 24910, 24933, 25186, 25163, 24911, 24934, 25187, 25164, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12441, 24911, 24934, 25187, 25164, 5080, 5081, 5092, 5091, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12442, 3264, 3265, 3276, 3275, 24912, 24935, 25188, 25165, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12443, 24912, 24935, 25188, 25165, 24913, 24936, 25189, 25166, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12444, 24913, 24936, 25189, 25166, 24914, 24937, 25190, 25167, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12445, 24914, 24937, 25190, 25167, 24915, 24938, 25191, 25168, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12446, 24915, 24938, 25191, 25168, 24916, 24939, 25192, 25169, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12447, 24916, 24939, 25192, 25169, 24917, 24940, 25193, 25170, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12448, 24917, 24940, 25193, 25170, 24918, 24941, 25194, 25171, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12449, 24918, 24941, 25194, 25171, 24919, 24942, 25195, 25172, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12450, 24919, 24942, 25195, 25172, 24920, 24943, 25196, 25173, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12451, 24920, 24943, 25196, 25173, 24921, 24944, 25197, 25174, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12452, 24921, 24944, 25197, 25174, 24922, 24945, 25198, 25175, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12453, 24922, 24945, 25198, 25175, 24923, 24946, 25199, 25176, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12454, 24923, 24946, 25199, 25176, 24924, 24947, 25200, 25177, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12455, 24924, 24947, 25200, 25177, 24925, 24948, 25201, 25178, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12456, 24925, 24948, 25201, 25178, 24926, 24949, 25202, 25179, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12457, 24926, 24949, 25202, 25179, 24927, 24950, 25203, 25180, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12458, 24927, 24950, 25203, 25180, 24928, 24951, 25204, 25181, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12459, 24928, 24951, 25204, 25181, 24929, 24952, 25205, 25182, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12460, 24929, 24952, 25205, 25182, 24930, 24953, 25206, 25183, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12461, 24930, 24953, 25206, 25183, 24931, 24954, 25207, 25184, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12462, 24931, 24954, 25207, 25184, 24932, 24955, 25208, 25185, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12463, 24932, 24955, 25208, 25185, 24933, 24956, 25209, 25186, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12464, 24933, 24956, 25209, 25186, 24934, 24957, 25210, 25187, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12465, 24934, 24957, 25210, 25187, 5081, 5082, 5093, 5092, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12466, 3265, 3266, 3277, 3276, 24935, 24958, 25211, 25188, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12467, 24935, 24958, 25211, 25188, 24936, 24959, 25212, 25189, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12468, 24936, 24959, 25212, 25189, 24937, 24960, 25213, 25190, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12469, 24937, 24960, 25213, 25190, 24938, 24961, 25214, 25191, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12470, 24938, 24961, 25214, 25191, 24939, 24962, 25215, 25192, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12471, 24939, 24962, 25215, 25192, 24940, 24963, 25216, 25193, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12472, 24940, 24963, 25216, 25193, 24941, 24964, 25217, 25194, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12473, 24941, 24964, 25217, 25194, 24942, 24965, 25218, 25195, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12474, 24942, 24965, 25218, 25195, 24943, 24966, 25219, 25196, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12475, 24943, 24966, 25219, 25196, 24944, 24967, 25220, 25197, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12476, 24944, 24967, 25220, 25197, 24945, 24968, 25221, 25198, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12477, 24945, 24968, 25221, 25198, 24946, 24969, 25222, 25199, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12478, 24946, 24969, 25222, 25199, 24947, 24970, 25223, 25200, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12479, 24947, 24970, 25223, 25200, 24948, 24971, 25224, 25201, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12480, 24948, 24971, 25224, 25201, 24949, 24972, 25225, 25202, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12481, 24949, 24972, 25225, 25202, 24950, 24973, 25226, 25203, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12482, 24950, 24973, 25226, 25203, 24951, 24974, 25227, 25204, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12483, 24951, 24974, 25227, 25204, 24952, 24975, 25228, 25205, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12484, 24952, 24975, 25228, 25205, 24953, 24976, 25229, 25206, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12485, 24953, 24976, 25229, 25206, 24954, 24977, 25230, 25207, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12486, 24954, 24977, 25230, 25207, 24955, 24978, 25231, 25208, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12487, 24955, 24978, 25231, 25208, 24956, 24979, 25232, 25209, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12488, 24956, 24979, 25232, 25209, 24957, 24980, 25233, 25210, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12489, 24957, 24980, 25233, 25210, 5082, 5083, 5094, 5093, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12490, 3266, 3267, 3278, 3277, 24958, 24981, 25234, 25211, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12491, 24958, 24981, 25234, 25211, 24959, 24982, 25235, 25212, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12492, 24959, 24982, 25235, 25212, 24960, 24983, 25236, 25213, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12493, 24960, 24983, 25236, 25213, 24961, 24984, 25237, 25214, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12494, 24961, 24984, 25237, 25214, 24962, 24985, 25238, 25215, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12495, 24962, 24985, 25238, 25215, 24963, 24986, 25239, 25216, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12496, 24963, 24986, 25239, 25216, 24964, 24987, 25240, 25217, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12497, 24964, 24987, 25240, 25217, 24965, 24988, 25241, 25218, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12498, 24965, 24988, 25241, 25218, 24966, 24989, 25242, 25219, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12499, 24966, 24989, 25242, 25219, 24967, 24990, 25243, 25220, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12500, 24967, 24990, 25243, 25220, 24968, 24991, 25244, 25221, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12501, 24968, 24991, 25244, 25221, 24969, 24992, 25245, 25222, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12502, 24969, 24992, 25245, 25222, 24970, 24993, 25246, 25223, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12503, 24970, 24993, 25246, 25223, 24971, 24994, 25247, 25224, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12504, 24971, 24994, 25247, 25224, 24972, 24995, 25248, 25225, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12505, 24972, 24995, 25248, 25225, 24973, 24996, 25249, 25226, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12506, 24973, 24996, 25249, 25226, 24974, 24997, 25250, 25227, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12507, 24974, 24997, 25250, 25227, 24975, 24998, 25251, 25228, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12508, 24975, 24998, 25251, 25228, 24976, 24999, 25252, 25229, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12509, 24976, 24999, 25252, 25229, 24977, 25000, 25253, 25230, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12510, 24977, 25000, 25253, 25230, 24978, 25001, 25254, 25231, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12511, 24978, 25001, 25254, 25231, 24979, 25002, 25255, 25232, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12512, 24979, 25002, 25255, 25232, 24980, 25003, 25256, 25233, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12513, 24980, 25003, 25256, 25233, 5083, 5084, 5095, 5094, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12514, 3267, 3268, 3279, 3278, 24981, 25004, 25257, 25234, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12515, 24981, 25004, 25257, 25234, 24982, 25005, 25258, 25235, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12516, 24982, 25005, 25258, 25235, 24983, 25006, 25259, 25236, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12517, 24983, 25006, 25259, 25236, 24984, 25007, 25260, 25237, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12518, 24984, 25007, 25260, 25237, 24985, 25008, 25261, 25238, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12519, 24985, 25008, 25261, 25238, 24986, 25009, 25262, 25239, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12520, 24986, 25009, 25262, 25239, 24987, 25010, 25263, 25240, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12521, 24987, 25010, 25263, 25240, 24988, 25011, 25264, 25241, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12522, 24988, 25011, 25264, 25241, 24989, 25012, 25265, 25242, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12523, 24989, 25012, 25265, 25242, 24990, 25013, 25266, 25243, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12524, 24990, 25013, 25266, 25243, 24991, 25014, 25267, 25244, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12525, 24991, 25014, 25267, 25244, 24992, 25015, 25268, 25245, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12526, 24992, 25015, 25268, 25245, 24993, 25016, 25269, 25246, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12527, 24993, 25016, 25269, 25246, 24994, 25017, 25270, 25247, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12528, 24994, 25017, 25270, 25247, 24995, 25018, 25271, 25248, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12529, 24995, 25018, 25271, 25248, 24996, 25019, 25272, 25249, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12530, 24996, 25019, 25272, 25249, 24997, 25020, 25273, 25250, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12531, 24997, 25020, 25273, 25250, 24998, 25021, 25274, 25251, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12532, 24998, 25021, 25274, 25251, 24999, 25022, 25275, 25252, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12533, 24999, 25022, 25275, 25252, 25000, 25023, 25276, 25253, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12534, 25000, 25023, 25276, 25253, 25001, 25024, 25277, 25254, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12535, 25001, 25024, 25277, 25254, 25002, 25025, 25278, 25255, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12536, 25002, 25025, 25278, 25255, 25003, 25026, 25279, 25256, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12537, 25003, 25026, 25279, 25256, 5084, 5085, 5096, 5095, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12538, 3268, 3269, 3280, 3279, 25004, 25027, 25280, 25257, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12539, 25004, 25027, 25280, 25257, 25005, 25028, 25281, 25258, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12540, 25005, 25028, 25281, 25258, 25006, 25029, 25282, 25259, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12541, 25006, 25029, 25282, 25259, 25007, 25030, 25283, 25260, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12542, 25007, 25030, 25283, 25260, 25008, 25031, 25284, 25261, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12543, 25008, 25031, 25284, 25261, 25009, 25032, 25285, 25262, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12544, 25009, 25032, 25285, 25262, 25010, 25033, 25286, 25263, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12545, 25010, 25033, 25286, 25263, 25011, 25034, 25287, 25264, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12546, 25011, 25034, 25287, 25264, 25012, 25035, 25288, 25265, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12547, 25012, 25035, 25288, 25265, 25013, 25036, 25289, 25266, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12548, 25013, 25036, 25289, 25266, 25014, 25037, 25290, 25267, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12549, 25014, 25037, 25290, 25267, 25015, 25038, 25291, 25268, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12550, 25015, 25038, 25291, 25268, 25016, 25039, 25292, 25269, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12551, 25016, 25039, 25292, 25269, 25017, 25040, 25293, 25270, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12552, 25017, 25040, 25293, 25270, 25018, 25041, 25294, 25271, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12553, 25018, 25041, 25294, 25271, 25019, 25042, 25295, 25272, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12554, 25019, 25042, 25295, 25272, 25020, 25043, 25296, 25273, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12555, 25020, 25043, 25296, 25273, 25021, 25044, 25297, 25274, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12556, 25021, 25044, 25297, 25274, 25022, 25045, 25298, 25275, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12557, 25022, 25045, 25298, 25275, 25023, 25046, 25299, 25276, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12558, 25023, 25046, 25299, 25276, 25024, 25047, 25300, 25277, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12559, 25024, 25047, 25300, 25277, 25025, 25048, 25301, 25278, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12560, 25025, 25048, 25301, 25278, 25026, 25049, 25302, 25279, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12561, 25026, 25049, 25302, 25279, 5085, 5086, 5097, 5096, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12562, 3269, 295, 296, 3280, 25027, 4522, 4545, 25280, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12563, 25027, 4522, 4545, 25280, 25028, 4523, 4546, 25281, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12564, 25028, 4523, 4546, 25281, 25029, 4524, 4547, 25282, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12565, 25029, 4524, 4547, 25282, 25030, 4525, 4548, 25283, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12566, 25030, 4525, 4548, 25283, 25031, 4526, 4549, 25284, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12567, 25031, 4526, 4549, 25284, 25032, 4527, 4550, 25285, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12568, 25032, 4527, 4550, 25285, 25033, 4528, 4551, 25286, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12569, 25033, 4528, 4551, 25286, 25034, 4529, 4552, 25287, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12570, 25034, 4529, 4552, 25287, 25035, 4530, 4553, 25288, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12571, 25035, 4530, 4553, 25288, 25036, 4531, 4554, 25289, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12572, 25036, 4531, 4554, 25289, 25037, 4532, 4555, 25290, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12573, 25037, 4532, 4555, 25290, 25038, 4533, 4556, 25291, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12574, 25038, 4533, 4556, 25291, 25039, 4534, 4557, 25292, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12575, 25039, 4534, 4557, 25292, 25040, 4535, 4558, 25293, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12576, 25040, 4535, 4558, 25293, 25041, 4536, 4559, 25294, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12577, 25041, 4536, 4559, 25294, 25042, 4537, 4560, 25295, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12578, 25042, 4537, 4560, 25295, 25043, 4538, 4561, 25296, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12579, 25043, 4538, 4561, 25296, 25044, 4539, 4562, 25297, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12580, 25044, 4539, 4562, 25297, 25045, 4540, 4563, 25298, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12581, 25045, 4540, 4563, 25298, 25046, 4541, 4564, 25299, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12582, 25046, 4541, 4564, 25299, 25047, 4542, 4565, 25300, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12583, 25047, 4542, 4565, 25300, 25048, 4543, 4566, 25301, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12584, 25048, 4543, 4566, 25301, 25049, 4544, 4567, 25302, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12585, 25049, 4544, 4567, 25302, 5086, 455, 456, 5097, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12586, 262, 3270, 3281, 263, 3763, 25050, 25303, 3786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12587, 3763, 25050, 25303, 3786, 3764, 25051, 25304, 3787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12588, 3764, 25051, 25304, 3787, 3765, 25052, 25305, 3788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12589, 3765, 25052, 25305, 3788, 3766, 25053, 25306, 3789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12590, 3766, 25053, 25306, 3789, 3767, 25054, 25307, 3790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12591, 3767, 25054, 25307, 3790, 3768, 25055, 25308, 3791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12592, 3768, 25055, 25308, 3791, 3769, 25056, 25309, 3792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12593, 3769, 25056, 25309, 3792, 3770, 25057, 25310, 3793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12594, 3770, 25057, 25310, 3793, 3771, 25058, 25311, 3794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12595, 3771, 25058, 25311, 3794, 3772, 25059, 25312, 3795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12596, 3772, 25059, 25312, 3795, 3773, 25060, 25313, 3796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12597, 3773, 25060, 25313, 3796, 3774, 25061, 25314, 3797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12598, 3774, 25061, 25314, 3797, 3775, 25062, 25315, 3798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12599, 3775, 25062, 25315, 3798, 3776, 25063, 25316, 3799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12600, 3776, 25063, 25316, 3799, 3777, 25064, 25317, 3800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12601, 3777, 25064, 25317, 3800, 3778, 25065, 25318, 3801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12602, 3778, 25065, 25318, 3801, 3779, 25066, 25319, 3802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12603, 3779, 25066, 25319, 3802, 3780, 25067, 25320, 3803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12604, 3780, 25067, 25320, 3803, 3781, 25068, 25321, 3804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12605, 3781, 25068, 25321, 3804, 3782, 25069, 25322, 3805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12606, 3782, 25069, 25322, 3805, 3783, 25070, 25323, 3806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12607, 3783, 25070, 25323, 3806, 3784, 25071, 25324, 3807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12608, 3784, 25071, 25324, 3807, 3785, 25072, 25325, 3808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12609, 3785, 25072, 25325, 3808, 376, 5087, 5098, 377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12610, 3270, 3271, 3282, 3281, 25050, 25073, 25326, 25303, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12611, 25050, 25073, 25326, 25303, 25051, 25074, 25327, 25304, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12612, 25051, 25074, 25327, 25304, 25052, 25075, 25328, 25305, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12613, 25052, 25075, 25328, 25305, 25053, 25076, 25329, 25306, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12614, 25053, 25076, 25329, 25306, 25054, 25077, 25330, 25307, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12615, 25054, 25077, 25330, 25307, 25055, 25078, 25331, 25308, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12616, 25055, 25078, 25331, 25308, 25056, 25079, 25332, 25309, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12617, 25056, 25079, 25332, 25309, 25057, 25080, 25333, 25310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12618, 25057, 25080, 25333, 25310, 25058, 25081, 25334, 25311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12619, 25058, 25081, 25334, 25311, 25059, 25082, 25335, 25312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12620, 25059, 25082, 25335, 25312, 25060, 25083, 25336, 25313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12621, 25060, 25083, 25336, 25313, 25061, 25084, 25337, 25314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12622, 25061, 25084, 25337, 25314, 25062, 25085, 25338, 25315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12623, 25062, 25085, 25338, 25315, 25063, 25086, 25339, 25316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12624, 25063, 25086, 25339, 25316, 25064, 25087, 25340, 25317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12625, 25064, 25087, 25340, 25317, 25065, 25088, 25341, 25318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12626, 25065, 25088, 25341, 25318, 25066, 25089, 25342, 25319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12627, 25066, 25089, 25342, 25319, 25067, 25090, 25343, 25320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12628, 25067, 25090, 25343, 25320, 25068, 25091, 25344, 25321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12629, 25068, 25091, 25344, 25321, 25069, 25092, 25345, 25322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12630, 25069, 25092, 25345, 25322, 25070, 25093, 25346, 25323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12631, 25070, 25093, 25346, 25323, 25071, 25094, 25347, 25324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12632, 25071, 25094, 25347, 25324, 25072, 25095, 25348, 25325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12633, 25072, 25095, 25348, 25325, 5087, 5088, 5099, 5098, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12634, 3271, 3272, 3283, 3282, 25073, 25096, 25349, 25326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12635, 25073, 25096, 25349, 25326, 25074, 25097, 25350, 25327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12636, 25074, 25097, 25350, 25327, 25075, 25098, 25351, 25328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12637, 25075, 25098, 25351, 25328, 25076, 25099, 25352, 25329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12638, 25076, 25099, 25352, 25329, 25077, 25100, 25353, 25330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12639, 25077, 25100, 25353, 25330, 25078, 25101, 25354, 25331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12640, 25078, 25101, 25354, 25331, 25079, 25102, 25355, 25332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12641, 25079, 25102, 25355, 25332, 25080, 25103, 25356, 25333, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12642, 25080, 25103, 25356, 25333, 25081, 25104, 25357, 25334, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12643, 25081, 25104, 25357, 25334, 25082, 25105, 25358, 25335, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12644, 25082, 25105, 25358, 25335, 25083, 25106, 25359, 25336, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12645, 25083, 25106, 25359, 25336, 25084, 25107, 25360, 25337, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12646, 25084, 25107, 25360, 25337, 25085, 25108, 25361, 25338, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12647, 25085, 25108, 25361, 25338, 25086, 25109, 25362, 25339, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12648, 25086, 25109, 25362, 25339, 25087, 25110, 25363, 25340, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12649, 25087, 25110, 25363, 25340, 25088, 25111, 25364, 25341, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12650, 25088, 25111, 25364, 25341, 25089, 25112, 25365, 25342, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12651, 25089, 25112, 25365, 25342, 25090, 25113, 25366, 25343, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12652, 25090, 25113, 25366, 25343, 25091, 25114, 25367, 25344, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12653, 25091, 25114, 25367, 25344, 25092, 25115, 25368, 25345, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12654, 25092, 25115, 25368, 25345, 25093, 25116, 25369, 25346, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12655, 25093, 25116, 25369, 25346, 25094, 25117, 25370, 25347, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12656, 25094, 25117, 25370, 25347, 25095, 25118, 25371, 25348, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12657, 25095, 25118, 25371, 25348, 5088, 5089, 5100, 5099, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12658, 3272, 3273, 3284, 3283, 25096, 25119, 25372, 25349, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12659, 25096, 25119, 25372, 25349, 25097, 25120, 25373, 25350, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12660, 25097, 25120, 25373, 25350, 25098, 25121, 25374, 25351, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12661, 25098, 25121, 25374, 25351, 25099, 25122, 25375, 25352, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12662, 25099, 25122, 25375, 25352, 25100, 25123, 25376, 25353, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12663, 25100, 25123, 25376, 25353, 25101, 25124, 25377, 25354, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12664, 25101, 25124, 25377, 25354, 25102, 25125, 25378, 25355, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12665, 25102, 25125, 25378, 25355, 25103, 25126, 25379, 25356, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12666, 25103, 25126, 25379, 25356, 25104, 25127, 25380, 25357, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12667, 25104, 25127, 25380, 25357, 25105, 25128, 25381, 25358, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12668, 25105, 25128, 25381, 25358, 25106, 25129, 25382, 25359, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12669, 25106, 25129, 25382, 25359, 25107, 25130, 25383, 25360, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12670, 25107, 25130, 25383, 25360, 25108, 25131, 25384, 25361, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12671, 25108, 25131, 25384, 25361, 25109, 25132, 25385, 25362, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12672, 25109, 25132, 25385, 25362, 25110, 25133, 25386, 25363, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12673, 25110, 25133, 25386, 25363, 25111, 25134, 25387, 25364, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12674, 25111, 25134, 25387, 25364, 25112, 25135, 25388, 25365, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12675, 25112, 25135, 25388, 25365, 25113, 25136, 25389, 25366, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12676, 25113, 25136, 25389, 25366, 25114, 25137, 25390, 25367, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12677, 25114, 25137, 25390, 25367, 25115, 25138, 25391, 25368, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12678, 25115, 25138, 25391, 25368, 25116, 25139, 25392, 25369, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12679, 25116, 25139, 25392, 25369, 25117, 25140, 25393, 25370, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12680, 25117, 25140, 25393, 25370, 25118, 25141, 25394, 25371, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12681, 25118, 25141, 25394, 25371, 5089, 5090, 5101, 5100, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12682, 3273, 3274, 3285, 3284, 25119, 25142, 25395, 25372, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12683, 25119, 25142, 25395, 25372, 25120, 25143, 25396, 25373, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12684, 25120, 25143, 25396, 25373, 25121, 25144, 25397, 25374, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12685, 25121, 25144, 25397, 25374, 25122, 25145, 25398, 25375, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12686, 25122, 25145, 25398, 25375, 25123, 25146, 25399, 25376, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12687, 25123, 25146, 25399, 25376, 25124, 25147, 25400, 25377, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12688, 25124, 25147, 25400, 25377, 25125, 25148, 25401, 25378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12689, 25125, 25148, 25401, 25378, 25126, 25149, 25402, 25379, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12690, 25126, 25149, 25402, 25379, 25127, 25150, 25403, 25380, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12691, 25127, 25150, 25403, 25380, 25128, 25151, 25404, 25381, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12692, 25128, 25151, 25404, 25381, 25129, 25152, 25405, 25382, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12693, 25129, 25152, 25405, 25382, 25130, 25153, 25406, 25383, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12694, 25130, 25153, 25406, 25383, 25131, 25154, 25407, 25384, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12695, 25131, 25154, 25407, 25384, 25132, 25155, 25408, 25385, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12696, 25132, 25155, 25408, 25385, 25133, 25156, 25409, 25386, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12697, 25133, 25156, 25409, 25386, 25134, 25157, 25410, 25387, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12698, 25134, 25157, 25410, 25387, 25135, 25158, 25411, 25388, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12699, 25135, 25158, 25411, 25388, 25136, 25159, 25412, 25389, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12700, 25136, 25159, 25412, 25389, 25137, 25160, 25413, 25390, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12701, 25137, 25160, 25413, 25390, 25138, 25161, 25414, 25391, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12702, 25138, 25161, 25414, 25391, 25139, 25162, 25415, 25392, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12703, 25139, 25162, 25415, 25392, 25140, 25163, 25416, 25393, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12704, 25140, 25163, 25416, 25393, 25141, 25164, 25417, 25394, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12705, 25141, 25164, 25417, 25394, 5090, 5091, 5102, 5101, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12706, 3274, 3275, 3286, 3285, 25142, 25165, 25418, 25395, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12707, 25142, 25165, 25418, 25395, 25143, 25166, 25419, 25396, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12708, 25143, 25166, 25419, 25396, 25144, 25167, 25420, 25397, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12709, 25144, 25167, 25420, 25397, 25145, 25168, 25421, 25398, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12710, 25145, 25168, 25421, 25398, 25146, 25169, 25422, 25399, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12711, 25146, 25169, 25422, 25399, 25147, 25170, 25423, 25400, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12712, 25147, 25170, 25423, 25400, 25148, 25171, 25424, 25401, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12713, 25148, 25171, 25424, 25401, 25149, 25172, 25425, 25402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12714, 25149, 25172, 25425, 25402, 25150, 25173, 25426, 25403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12715, 25150, 25173, 25426, 25403, 25151, 25174, 25427, 25404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12716, 25151, 25174, 25427, 25404, 25152, 25175, 25428, 25405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12717, 25152, 25175, 25428, 25405, 25153, 25176, 25429, 25406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12718, 25153, 25176, 25429, 25406, 25154, 25177, 25430, 25407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12719, 25154, 25177, 25430, 25407, 25155, 25178, 25431, 25408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12720, 25155, 25178, 25431, 25408, 25156, 25179, 25432, 25409, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12721, 25156, 25179, 25432, 25409, 25157, 25180, 25433, 25410, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12722, 25157, 25180, 25433, 25410, 25158, 25181, 25434, 25411, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12723, 25158, 25181, 25434, 25411, 25159, 25182, 25435, 25412, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12724, 25159, 25182, 25435, 25412, 25160, 25183, 25436, 25413, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12725, 25160, 25183, 25436, 25413, 25161, 25184, 25437, 25414, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12726, 25161, 25184, 25437, 25414, 25162, 25185, 25438, 25415, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12727, 25162, 25185, 25438, 25415, 25163, 25186, 25439, 25416, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12728, 25163, 25186, 25439, 25416, 25164, 25187, 25440, 25417, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12729, 25164, 25187, 25440, 25417, 5091, 5092, 5103, 5102, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12730, 3275, 3276, 3287, 3286, 25165, 25188, 25441, 25418, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12731, 25165, 25188, 25441, 25418, 25166, 25189, 25442, 25419, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12732, 25166, 25189, 25442, 25419, 25167, 25190, 25443, 25420, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12733, 25167, 25190, 25443, 25420, 25168, 25191, 25444, 25421, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12734, 25168, 25191, 25444, 25421, 25169, 25192, 25445, 25422, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12735, 25169, 25192, 25445, 25422, 25170, 25193, 25446, 25423, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12736, 25170, 25193, 25446, 25423, 25171, 25194, 25447, 25424, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12737, 25171, 25194, 25447, 25424, 25172, 25195, 25448, 25425, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12738, 25172, 25195, 25448, 25425, 25173, 25196, 25449, 25426, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12739, 25173, 25196, 25449, 25426, 25174, 25197, 25450, 25427, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12740, 25174, 25197, 25450, 25427, 25175, 25198, 25451, 25428, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12741, 25175, 25198, 25451, 25428, 25176, 25199, 25452, 25429, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12742, 25176, 25199, 25452, 25429, 25177, 25200, 25453, 25430, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12743, 25177, 25200, 25453, 25430, 25178, 25201, 25454, 25431, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12744, 25178, 25201, 25454, 25431, 25179, 25202, 25455, 25432, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12745, 25179, 25202, 25455, 25432, 25180, 25203, 25456, 25433, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12746, 25180, 25203, 25456, 25433, 25181, 25204, 25457, 25434, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12747, 25181, 25204, 25457, 25434, 25182, 25205, 25458, 25435, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12748, 25182, 25205, 25458, 25435, 25183, 25206, 25459, 25436, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12749, 25183, 25206, 25459, 25436, 25184, 25207, 25460, 25437, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12750, 25184, 25207, 25460, 25437, 25185, 25208, 25461, 25438, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12751, 25185, 25208, 25461, 25438, 25186, 25209, 25462, 25439, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12752, 25186, 25209, 25462, 25439, 25187, 25210, 25463, 25440, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12753, 25187, 25210, 25463, 25440, 5092, 5093, 5104, 5103, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12754, 3276, 3277, 3288, 3287, 25188, 25211, 25464, 25441, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12755, 25188, 25211, 25464, 25441, 25189, 25212, 25465, 25442, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12756, 25189, 25212, 25465, 25442, 25190, 25213, 25466, 25443, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12757, 25190, 25213, 25466, 25443, 25191, 25214, 25467, 25444, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12758, 25191, 25214, 25467, 25444, 25192, 25215, 25468, 25445, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12759, 25192, 25215, 25468, 25445, 25193, 25216, 25469, 25446, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12760, 25193, 25216, 25469, 25446, 25194, 25217, 25470, 25447, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12761, 25194, 25217, 25470, 25447, 25195, 25218, 25471, 25448, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12762, 25195, 25218, 25471, 25448, 25196, 25219, 25472, 25449, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12763, 25196, 25219, 25472, 25449, 25197, 25220, 25473, 25450, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12764, 25197, 25220, 25473, 25450, 25198, 25221, 25474, 25451, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12765, 25198, 25221, 25474, 25451, 25199, 25222, 25475, 25452, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12766, 25199, 25222, 25475, 25452, 25200, 25223, 25476, 25453, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12767, 25200, 25223, 25476, 25453, 25201, 25224, 25477, 25454, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12768, 25201, 25224, 25477, 25454, 25202, 25225, 25478, 25455, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12769, 25202, 25225, 25478, 25455, 25203, 25226, 25479, 25456, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12770, 25203, 25226, 25479, 25456, 25204, 25227, 25480, 25457, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12771, 25204, 25227, 25480, 25457, 25205, 25228, 25481, 25458, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12772, 25205, 25228, 25481, 25458, 25206, 25229, 25482, 25459, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12773, 25206, 25229, 25482, 25459, 25207, 25230, 25483, 25460, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12774, 25207, 25230, 25483, 25460, 25208, 25231, 25484, 25461, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12775, 25208, 25231, 25484, 25461, 25209, 25232, 25485, 25462, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12776, 25209, 25232, 25485, 25462, 25210, 25233, 25486, 25463, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12777, 25210, 25233, 25486, 25463, 5093, 5094, 5105, 5104, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12778, 3277, 3278, 3289, 3288, 25211, 25234, 25487, 25464, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12779, 25211, 25234, 25487, 25464, 25212, 25235, 25488, 25465, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12780, 25212, 25235, 25488, 25465, 25213, 25236, 25489, 25466, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12781, 25213, 25236, 25489, 25466, 25214, 25237, 25490, 25467, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12782, 25214, 25237, 25490, 25467, 25215, 25238, 25491, 25468, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12783, 25215, 25238, 25491, 25468, 25216, 25239, 25492, 25469, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12784, 25216, 25239, 25492, 25469, 25217, 25240, 25493, 25470, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12785, 25217, 25240, 25493, 25470, 25218, 25241, 25494, 25471, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12786, 25218, 25241, 25494, 25471, 25219, 25242, 25495, 25472, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12787, 25219, 25242, 25495, 25472, 25220, 25243, 25496, 25473, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12788, 25220, 25243, 25496, 25473, 25221, 25244, 25497, 25474, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12789, 25221, 25244, 25497, 25474, 25222, 25245, 25498, 25475, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12790, 25222, 25245, 25498, 25475, 25223, 25246, 25499, 25476, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12791, 25223, 25246, 25499, 25476, 25224, 25247, 25500, 25477, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12792, 25224, 25247, 25500, 25477, 25225, 25248, 25501, 25478, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12793, 25225, 25248, 25501, 25478, 25226, 25249, 25502, 25479, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12794, 25226, 25249, 25502, 25479, 25227, 25250, 25503, 25480, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12795, 25227, 25250, 25503, 25480, 25228, 25251, 25504, 25481, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12796, 25228, 25251, 25504, 25481, 25229, 25252, 25505, 25482, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12797, 25229, 25252, 25505, 25482, 25230, 25253, 25506, 25483, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12798, 25230, 25253, 25506, 25483, 25231, 25254, 25507, 25484, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12799, 25231, 25254, 25507, 25484, 25232, 25255, 25508, 25485, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12800, 25232, 25255, 25508, 25485, 25233, 25256, 25509, 25486, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12801, 25233, 25256, 25509, 25486, 5094, 5095, 5106, 5105, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12802, 3278, 3279, 3290, 3289, 25234, 25257, 25510, 25487, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12803, 25234, 25257, 25510, 25487, 25235, 25258, 25511, 25488, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12804, 25235, 25258, 25511, 25488, 25236, 25259, 25512, 25489, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12805, 25236, 25259, 25512, 25489, 25237, 25260, 25513, 25490, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12806, 25237, 25260, 25513, 25490, 25238, 25261, 25514, 25491, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12807, 25238, 25261, 25514, 25491, 25239, 25262, 25515, 25492, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12808, 25239, 25262, 25515, 25492, 25240, 25263, 25516, 25493, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12809, 25240, 25263, 25516, 25493, 25241, 25264, 25517, 25494, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12810, 25241, 25264, 25517, 25494, 25242, 25265, 25518, 25495, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12811, 25242, 25265, 25518, 25495, 25243, 25266, 25519, 25496, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12812, 25243, 25266, 25519, 25496, 25244, 25267, 25520, 25497, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12813, 25244, 25267, 25520, 25497, 25245, 25268, 25521, 25498, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12814, 25245, 25268, 25521, 25498, 25246, 25269, 25522, 25499, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12815, 25246, 25269, 25522, 25499, 25247, 25270, 25523, 25500, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12816, 25247, 25270, 25523, 25500, 25248, 25271, 25524, 25501, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12817, 25248, 25271, 25524, 25501, 25249, 25272, 25525, 25502, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12818, 25249, 25272, 25525, 25502, 25250, 25273, 25526, 25503, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12819, 25250, 25273, 25526, 25503, 25251, 25274, 25527, 25504, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12820, 25251, 25274, 25527, 25504, 25252, 25275, 25528, 25505, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12821, 25252, 25275, 25528, 25505, 25253, 25276, 25529, 25506, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12822, 25253, 25276, 25529, 25506, 25254, 25277, 25530, 25507, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12823, 25254, 25277, 25530, 25507, 25255, 25278, 25531, 25508, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12824, 25255, 25278, 25531, 25508, 25256, 25279, 25532, 25509, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12825, 25256, 25279, 25532, 25509, 5095, 5096, 5107, 5106, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12826, 3279, 3280, 3291, 3290, 25257, 25280, 25533, 25510, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12827, 25257, 25280, 25533, 25510, 25258, 25281, 25534, 25511, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12828, 25258, 25281, 25534, 25511, 25259, 25282, 25535, 25512, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12829, 25259, 25282, 25535, 25512, 25260, 25283, 25536, 25513, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12830, 25260, 25283, 25536, 25513, 25261, 25284, 25537, 25514, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12831, 25261, 25284, 25537, 25514, 25262, 25285, 25538, 25515, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12832, 25262, 25285, 25538, 25515, 25263, 25286, 25539, 25516, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12833, 25263, 25286, 25539, 25516, 25264, 25287, 25540, 25517, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12834, 25264, 25287, 25540, 25517, 25265, 25288, 25541, 25518, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12835, 25265, 25288, 25541, 25518, 25266, 25289, 25542, 25519, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12836, 25266, 25289, 25542, 25519, 25267, 25290, 25543, 25520, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12837, 25267, 25290, 25543, 25520, 25268, 25291, 25544, 25521, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12838, 25268, 25291, 25544, 25521, 25269, 25292, 25545, 25522, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12839, 25269, 25292, 25545, 25522, 25270, 25293, 25546, 25523, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12840, 25270, 25293, 25546, 25523, 25271, 25294, 25547, 25524, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12841, 25271, 25294, 25547, 25524, 25272, 25295, 25548, 25525, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12842, 25272, 25295, 25548, 25525, 25273, 25296, 25549, 25526, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12843, 25273, 25296, 25549, 25526, 25274, 25297, 25550, 25527, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12844, 25274, 25297, 25550, 25527, 25275, 25298, 25551, 25528, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12845, 25275, 25298, 25551, 25528, 25276, 25299, 25552, 25529, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12846, 25276, 25299, 25552, 25529, 25277, 25300, 25553, 25530, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12847, 25277, 25300, 25553, 25530, 25278, 25301, 25554, 25531, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12848, 25278, 25301, 25554, 25531, 25279, 25302, 25555, 25532, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12849, 25279, 25302, 25555, 25532, 5096, 5097, 5108, 5107, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12850, 3280, 296, 297, 3291, 25280, 4545, 4568, 25533, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12851, 25280, 4545, 4568, 25533, 25281, 4546, 4569, 25534, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12852, 25281, 4546, 4569, 25534, 25282, 4547, 4570, 25535, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12853, 25282, 4547, 4570, 25535, 25283, 4548, 4571, 25536, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12854, 25283, 4548, 4571, 25536, 25284, 4549, 4572, 25537, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12855, 25284, 4549, 4572, 25537, 25285, 4550, 4573, 25538, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12856, 25285, 4550, 4573, 25538, 25286, 4551, 4574, 25539, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12857, 25286, 4551, 4574, 25539, 25287, 4552, 4575, 25540, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12858, 25287, 4552, 4575, 25540, 25288, 4553, 4576, 25541, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12859, 25288, 4553, 4576, 25541, 25289, 4554, 4577, 25542, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12860, 25289, 4554, 4577, 25542, 25290, 4555, 4578, 25543, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12861, 25290, 4555, 4578, 25543, 25291, 4556, 4579, 25544, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12862, 25291, 4556, 4579, 25544, 25292, 4557, 4580, 25545, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12863, 25292, 4557, 4580, 25545, 25293, 4558, 4581, 25546, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12864, 25293, 4558, 4581, 25546, 25294, 4559, 4582, 25547, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12865, 25294, 4559, 4582, 25547, 25295, 4560, 4583, 25548, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12866, 25295, 4560, 4583, 25548, 25296, 4561, 4584, 25549, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12867, 25296, 4561, 4584, 25549, 25297, 4562, 4585, 25550, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12868, 25297, 4562, 4585, 25550, 25298, 4563, 4586, 25551, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12869, 25298, 4563, 4586, 25551, 25299, 4564, 4587, 25552, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12870, 25299, 4564, 4587, 25552, 25300, 4565, 4588, 25553, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12871, 25300, 4565, 4588, 25553, 25301, 4566, 4589, 25554, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12872, 25301, 4566, 4589, 25554, 25302, 4567, 4590, 25555, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12873, 25302, 4567, 4590, 25555, 5097, 456, 457, 5108, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12874, 263, 3281, 3292, 264, 3786, 25303, 25556, 3809, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12875, 3786, 25303, 25556, 3809, 3787, 25304, 25557, 3810, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12876, 3787, 25304, 25557, 3810, 3788, 25305, 25558, 3811, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12877, 3788, 25305, 25558, 3811, 3789, 25306, 25559, 3812, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12878, 3789, 25306, 25559, 3812, 3790, 25307, 25560, 3813, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12879, 3790, 25307, 25560, 3813, 3791, 25308, 25561, 3814, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12880, 3791, 25308, 25561, 3814, 3792, 25309, 25562, 3815, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12881, 3792, 25309, 25562, 3815, 3793, 25310, 25563, 3816, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12882, 3793, 25310, 25563, 3816, 3794, 25311, 25564, 3817, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12883, 3794, 25311, 25564, 3817, 3795, 25312, 25565, 3818, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12884, 3795, 25312, 25565, 3818, 3796, 25313, 25566, 3819, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12885, 3796, 25313, 25566, 3819, 3797, 25314, 25567, 3820, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12886, 3797, 25314, 25567, 3820, 3798, 25315, 25568, 3821, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12887, 3798, 25315, 25568, 3821, 3799, 25316, 25569, 3822, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12888, 3799, 25316, 25569, 3822, 3800, 25317, 25570, 3823, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12889, 3800, 25317, 25570, 3823, 3801, 25318, 25571, 3824, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12890, 3801, 25318, 25571, 3824, 3802, 25319, 25572, 3825, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12891, 3802, 25319, 25572, 3825, 3803, 25320, 25573, 3826, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12892, 3803, 25320, 25573, 3826, 3804, 25321, 25574, 3827, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12893, 3804, 25321, 25574, 3827, 3805, 25322, 25575, 3828, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12894, 3805, 25322, 25575, 3828, 3806, 25323, 25576, 3829, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12895, 3806, 25323, 25576, 3829, 3807, 25324, 25577, 3830, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12896, 3807, 25324, 25577, 3830, 3808, 25325, 25578, 3831, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12897, 3808, 25325, 25578, 3831, 377, 5098, 5109, 378, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12898, 3281, 3282, 3293, 3292, 25303, 25326, 25579, 25556, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12899, 25303, 25326, 25579, 25556, 25304, 25327, 25580, 25557, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12900, 25304, 25327, 25580, 25557, 25305, 25328, 25581, 25558, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12901, 25305, 25328, 25581, 25558, 25306, 25329, 25582, 25559, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12902, 25306, 25329, 25582, 25559, 25307, 25330, 25583, 25560, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12903, 25307, 25330, 25583, 25560, 25308, 25331, 25584, 25561, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12904, 25308, 25331, 25584, 25561, 25309, 25332, 25585, 25562, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12905, 25309, 25332, 25585, 25562, 25310, 25333, 25586, 25563, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12906, 25310, 25333, 25586, 25563, 25311, 25334, 25587, 25564, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12907, 25311, 25334, 25587, 25564, 25312, 25335, 25588, 25565, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12908, 25312, 25335, 25588, 25565, 25313, 25336, 25589, 25566, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12909, 25313, 25336, 25589, 25566, 25314, 25337, 25590, 25567, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12910, 25314, 25337, 25590, 25567, 25315, 25338, 25591, 25568, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12911, 25315, 25338, 25591, 25568, 25316, 25339, 25592, 25569, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12912, 25316, 25339, 25592, 25569, 25317, 25340, 25593, 25570, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12913, 25317, 25340, 25593, 25570, 25318, 25341, 25594, 25571, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12914, 25318, 25341, 25594, 25571, 25319, 25342, 25595, 25572, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12915, 25319, 25342, 25595, 25572, 25320, 25343, 25596, 25573, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12916, 25320, 25343, 25596, 25573, 25321, 25344, 25597, 25574, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12917, 25321, 25344, 25597, 25574, 25322, 25345, 25598, 25575, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12918, 25322, 25345, 25598, 25575, 25323, 25346, 25599, 25576, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12919, 25323, 25346, 25599, 25576, 25324, 25347, 25600, 25577, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12920, 25324, 25347, 25600, 25577, 25325, 25348, 25601, 25578, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12921, 25325, 25348, 25601, 25578, 5098, 5099, 5110, 5109, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12922, 3282, 3283, 3294, 3293, 25326, 25349, 25602, 25579, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12923, 25326, 25349, 25602, 25579, 25327, 25350, 25603, 25580, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12924, 25327, 25350, 25603, 25580, 25328, 25351, 25604, 25581, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12925, 25328, 25351, 25604, 25581, 25329, 25352, 25605, 25582, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12926, 25329, 25352, 25605, 25582, 25330, 25353, 25606, 25583, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12927, 25330, 25353, 25606, 25583, 25331, 25354, 25607, 25584, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12928, 25331, 25354, 25607, 25584, 25332, 25355, 25608, 25585, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12929, 25332, 25355, 25608, 25585, 25333, 25356, 25609, 25586, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12930, 25333, 25356, 25609, 25586, 25334, 25357, 25610, 25587, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12931, 25334, 25357, 25610, 25587, 25335, 25358, 25611, 25588, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12932, 25335, 25358, 25611, 25588, 25336, 25359, 25612, 25589, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12933, 25336, 25359, 25612, 25589, 25337, 25360, 25613, 25590, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12934, 25337, 25360, 25613, 25590, 25338, 25361, 25614, 25591, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12935, 25338, 25361, 25614, 25591, 25339, 25362, 25615, 25592, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12936, 25339, 25362, 25615, 25592, 25340, 25363, 25616, 25593, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12937, 25340, 25363, 25616, 25593, 25341, 25364, 25617, 25594, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12938, 25341, 25364, 25617, 25594, 25342, 25365, 25618, 25595, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12939, 25342, 25365, 25618, 25595, 25343, 25366, 25619, 25596, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12940, 25343, 25366, 25619, 25596, 25344, 25367, 25620, 25597, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12941, 25344, 25367, 25620, 25597, 25345, 25368, 25621, 25598, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12942, 25345, 25368, 25621, 25598, 25346, 25369, 25622, 25599, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12943, 25346, 25369, 25622, 25599, 25347, 25370, 25623, 25600, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12944, 25347, 25370, 25623, 25600, 25348, 25371, 25624, 25601, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12945, 25348, 25371, 25624, 25601, 5099, 5100, 5111, 5110, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12946, 3283, 3284, 3295, 3294, 25349, 25372, 25625, 25602, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12947, 25349, 25372, 25625, 25602, 25350, 25373, 25626, 25603, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12948, 25350, 25373, 25626, 25603, 25351, 25374, 25627, 25604, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12949, 25351, 25374, 25627, 25604, 25352, 25375, 25628, 25605, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12950, 25352, 25375, 25628, 25605, 25353, 25376, 25629, 25606, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12951, 25353, 25376, 25629, 25606, 25354, 25377, 25630, 25607, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12952, 25354, 25377, 25630, 25607, 25355, 25378, 25631, 25608, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12953, 25355, 25378, 25631, 25608, 25356, 25379, 25632, 25609, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12954, 25356, 25379, 25632, 25609, 25357, 25380, 25633, 25610, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12955, 25357, 25380, 25633, 25610, 25358, 25381, 25634, 25611, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12956, 25358, 25381, 25634, 25611, 25359, 25382, 25635, 25612, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12957, 25359, 25382, 25635, 25612, 25360, 25383, 25636, 25613, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12958, 25360, 25383, 25636, 25613, 25361, 25384, 25637, 25614, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12959, 25361, 25384, 25637, 25614, 25362, 25385, 25638, 25615, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12960, 25362, 25385, 25638, 25615, 25363, 25386, 25639, 25616, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12961, 25363, 25386, 25639, 25616, 25364, 25387, 25640, 25617, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12962, 25364, 25387, 25640, 25617, 25365, 25388, 25641, 25618, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12963, 25365, 25388, 25641, 25618, 25366, 25389, 25642, 25619, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12964, 25366, 25389, 25642, 25619, 25367, 25390, 25643, 25620, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12965, 25367, 25390, 25643, 25620, 25368, 25391, 25644, 25621, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12966, 25368, 25391, 25644, 25621, 25369, 25392, 25645, 25622, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12967, 25369, 25392, 25645, 25622, 25370, 25393, 25646, 25623, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12968, 25370, 25393, 25646, 25623, 25371, 25394, 25647, 25624, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12969, 25371, 25394, 25647, 25624, 5100, 5101, 5112, 5111, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12970, 3284, 3285, 3296, 3295, 25372, 25395, 25648, 25625, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12971, 25372, 25395, 25648, 25625, 25373, 25396, 25649, 25626, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12972, 25373, 25396, 25649, 25626, 25374, 25397, 25650, 25627, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12973, 25374, 25397, 25650, 25627, 25375, 25398, 25651, 25628, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12974, 25375, 25398, 25651, 25628, 25376, 25399, 25652, 25629, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12975, 25376, 25399, 25652, 25629, 25377, 25400, 25653, 25630, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12976, 25377, 25400, 25653, 25630, 25378, 25401, 25654, 25631, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12977, 25378, 25401, 25654, 25631, 25379, 25402, 25655, 25632, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12978, 25379, 25402, 25655, 25632, 25380, 25403, 25656, 25633, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12979, 25380, 25403, 25656, 25633, 25381, 25404, 25657, 25634, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12980, 25381, 25404, 25657, 25634, 25382, 25405, 25658, 25635, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12981, 25382, 25405, 25658, 25635, 25383, 25406, 25659, 25636, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12982, 25383, 25406, 25659, 25636, 25384, 25407, 25660, 25637, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12983, 25384, 25407, 25660, 25637, 25385, 25408, 25661, 25638, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12984, 25385, 25408, 25661, 25638, 25386, 25409, 25662, 25639, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12985, 25386, 25409, 25662, 25639, 25387, 25410, 25663, 25640, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12986, 25387, 25410, 25663, 25640, 25388, 25411, 25664, 25641, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12987, 25388, 25411, 25664, 25641, 25389, 25412, 25665, 25642, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12988, 25389, 25412, 25665, 25642, 25390, 25413, 25666, 25643, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12989, 25390, 25413, 25666, 25643, 25391, 25414, 25667, 25644, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12990, 25391, 25414, 25667, 25644, 25392, 25415, 25668, 25645, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12991, 25392, 25415, 25668, 25645, 25393, 25416, 25669, 25646, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12992, 25393, 25416, 25669, 25646, 25394, 25417, 25670, 25647, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12993, 25394, 25417, 25670, 25647, 5101, 5102, 5113, 5112, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12994, 3285, 3286, 3297, 3296, 25395, 25418, 25671, 25648, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12995, 25395, 25418, 25671, 25648, 25396, 25419, 25672, 25649, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12996, 25396, 25419, 25672, 25649, 25397, 25420, 25673, 25650, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12997, 25397, 25420, 25673, 25650, 25398, 25421, 25674, 25651, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12998, 25398, 25421, 25674, 25651, 25399, 25422, 25675, 25652, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
12999, 25399, 25422, 25675, 25652, 25400, 25423, 25676, 25653, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13000, 25400, 25423, 25676, 25653, 25401, 25424, 25677, 25654, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13001, 25401, 25424, 25677, 25654, 25402, 25425, 25678, 25655, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13002, 25402, 25425, 25678, 25655, 25403, 25426, 25679, 25656, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13003, 25403, 25426, 25679, 25656, 25404, 25427, 25680, 25657, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13004, 25404, 25427, 25680, 25657, 25405, 25428, 25681, 25658, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13005, 25405, 25428, 25681, 25658, 25406, 25429, 25682, 25659, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13006, 25406, 25429, 25682, 25659, 25407, 25430, 25683, 25660, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13007, 25407, 25430, 25683, 25660, 25408, 25431, 25684, 25661, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13008, 25408, 25431, 25684, 25661, 25409, 25432, 25685, 25662, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13009, 25409, 25432, 25685, 25662, 25410, 25433, 25686, 25663, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13010, 25410, 25433, 25686, 25663, 25411, 25434, 25687, 25664, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13011, 25411, 25434, 25687, 25664, 25412, 25435, 25688, 25665, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13012, 25412, 25435, 25688, 25665, 25413, 25436, 25689, 25666, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13013, 25413, 25436, 25689, 25666, 25414, 25437, 25690, 25667, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13014, 25414, 25437, 25690, 25667, 25415, 25438, 25691, 25668, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13015, 25415, 25438, 25691, 25668, 25416, 25439, 25692, 25669, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13016, 25416, 25439, 25692, 25669, 25417, 25440, 25693, 25670, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13017, 25417, 25440, 25693, 25670, 5102, 5103, 5114, 5113, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13018, 3286, 3287, 3298, 3297, 25418, 25441, 25694, 25671, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13019, 25418, 25441, 25694, 25671, 25419, 25442, 25695, 25672, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13020, 25419, 25442, 25695, 25672, 25420, 25443, 25696, 25673, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13021, 25420, 25443, 25696, 25673, 25421, 25444, 25697, 25674, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13022, 25421, 25444, 25697, 25674, 25422, 25445, 25698, 25675, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13023, 25422, 25445, 25698, 25675, 25423, 25446, 25699, 25676, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13024, 25423, 25446, 25699, 25676, 25424, 25447, 25700, 25677, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13025, 25424, 25447, 25700, 25677, 25425, 25448, 25701, 25678, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13026, 25425, 25448, 25701, 25678, 25426, 25449, 25702, 25679, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13027, 25426, 25449, 25702, 25679, 25427, 25450, 25703, 25680, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13028, 25427, 25450, 25703, 25680, 25428, 25451, 25704, 25681, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13029, 25428, 25451, 25704, 25681, 25429, 25452, 25705, 25682, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13030, 25429, 25452, 25705, 25682, 25430, 25453, 25706, 25683, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13031, 25430, 25453, 25706, 25683, 25431, 25454, 25707, 25684, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13032, 25431, 25454, 25707, 25684, 25432, 25455, 25708, 25685, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13033, 25432, 25455, 25708, 25685, 25433, 25456, 25709, 25686, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13034, 25433, 25456, 25709, 25686, 25434, 25457, 25710, 25687, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13035, 25434, 25457, 25710, 25687, 25435, 25458, 25711, 25688, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13036, 25435, 25458, 25711, 25688, 25436, 25459, 25712, 25689, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13037, 25436, 25459, 25712, 25689, 25437, 25460, 25713, 25690, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13038, 25437, 25460, 25713, 25690, 25438, 25461, 25714, 25691, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13039, 25438, 25461, 25714, 25691, 25439, 25462, 25715, 25692, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13040, 25439, 25462, 25715, 25692, 25440, 25463, 25716, 25693, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13041, 25440, 25463, 25716, 25693, 5103, 5104, 5115, 5114, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13042, 3287, 3288, 3299, 3298, 25441, 25464, 25717, 25694, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13043, 25441, 25464, 25717, 25694, 25442, 25465, 25718, 25695, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13044, 25442, 25465, 25718, 25695, 25443, 25466, 25719, 25696, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13045, 25443, 25466, 25719, 25696, 25444, 25467, 25720, 25697, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13046, 25444, 25467, 25720, 25697, 25445, 25468, 25721, 25698, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13047, 25445, 25468, 25721, 25698, 25446, 25469, 25722, 25699, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13048, 25446, 25469, 25722, 25699, 25447, 25470, 25723, 25700, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13049, 25447, 25470, 25723, 25700, 25448, 25471, 25724, 25701, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13050, 25448, 25471, 25724, 25701, 25449, 25472, 25725, 25702, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13051, 25449, 25472, 25725, 25702, 25450, 25473, 25726, 25703, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13052, 25450, 25473, 25726, 25703, 25451, 25474, 25727, 25704, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13053, 25451, 25474, 25727, 25704, 25452, 25475, 25728, 25705, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13054, 25452, 25475, 25728, 25705, 25453, 25476, 25729, 25706, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13055, 25453, 25476, 25729, 25706, 25454, 25477, 25730, 25707, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13056, 25454, 25477, 25730, 25707, 25455, 25478, 25731, 25708, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13057, 25455, 25478, 25731, 25708, 25456, 25479, 25732, 25709, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13058, 25456, 25479, 25732, 25709, 25457, 25480, 25733, 25710, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13059, 25457, 25480, 25733, 25710, 25458, 25481, 25734, 25711, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13060, 25458, 25481, 25734, 25711, 25459, 25482, 25735, 25712, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13061, 25459, 25482, 25735, 25712, 25460, 25483, 25736, 25713, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13062, 25460, 25483, 25736, 25713, 25461, 25484, 25737, 25714, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13063, 25461, 25484, 25737, 25714, 25462, 25485, 25738, 25715, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13064, 25462, 25485, 25738, 25715, 25463, 25486, 25739, 25716, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13065, 25463, 25486, 25739, 25716, 5104, 5105, 5116, 5115, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13066, 3288, 3289, 3300, 3299, 25464, 25487, 25740, 25717, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13067, 25464, 25487, 25740, 25717, 25465, 25488, 25741, 25718, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13068, 25465, 25488, 25741, 25718, 25466, 25489, 25742, 25719, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13069, 25466, 25489, 25742, 25719, 25467, 25490, 25743, 25720, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13070, 25467, 25490, 25743, 25720, 25468, 25491, 25744, 25721, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13071, 25468, 25491, 25744, 25721, 25469, 25492, 25745, 25722, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13072, 25469, 25492, 25745, 25722, 25470, 25493, 25746, 25723, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13073, 25470, 25493, 25746, 25723, 25471, 25494, 25747, 25724, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13074, 25471, 25494, 25747, 25724, 25472, 25495, 25748, 25725, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13075, 25472, 25495, 25748, 25725, 25473, 25496, 25749, 25726, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13076, 25473, 25496, 25749, 25726, 25474, 25497, 25750, 25727, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13077, 25474, 25497, 25750, 25727, 25475, 25498, 25751, 25728, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13078, 25475, 25498, 25751, 25728, 25476, 25499, 25752, 25729, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13079, 25476, 25499, 25752, 25729, 25477, 25500, 25753, 25730, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13080, 25477, 25500, 25753, 25730, 25478, 25501, 25754, 25731, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13081, 25478, 25501, 25754, 25731, 25479, 25502, 25755, 25732, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13082, 25479, 25502, 25755, 25732, 25480, 25503, 25756, 25733, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13083, 25480, 25503, 25756, 25733, 25481, 25504, 25757, 25734, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13084, 25481, 25504, 25757, 25734, 25482, 25505, 25758, 25735, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13085, 25482, 25505, 25758, 25735, 25483, 25506, 25759, 25736, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13086, 25483, 25506, 25759, 25736, 25484, 25507, 25760, 25737, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13087, 25484, 25507, 25760, 25737, 25485, 25508, 25761, 25738, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13088, 25485, 25508, 25761, 25738, 25486, 25509, 25762, 25739, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13089, 25486, 25509, 25762, 25739, 5105, 5106, 5117, 5116, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13090, 3289, 3290, 3301, 3300, 25487, 25510, 25763, 25740, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13091, 25487, 25510, 25763, 25740, 25488, 25511, 25764, 25741, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13092, 25488, 25511, 25764, 25741, 25489, 25512, 25765, 25742, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13093, 25489, 25512, 25765, 25742, 25490, 25513, 25766, 25743, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13094, 25490, 25513, 25766, 25743, 25491, 25514, 25767, 25744, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13095, 25491, 25514, 25767, 25744, 25492, 25515, 25768, 25745, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13096, 25492, 25515, 25768, 25745, 25493, 25516, 25769, 25746, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13097, 25493, 25516, 25769, 25746, 25494, 25517, 25770, 25747, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13098, 25494, 25517, 25770, 25747, 25495, 25518, 25771, 25748, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13099, 25495, 25518, 25771, 25748, 25496, 25519, 25772, 25749, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13100, 25496, 25519, 25772, 25749, 25497, 25520, 25773, 25750, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13101, 25497, 25520, 25773, 25750, 25498, 25521, 25774, 25751, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13102, 25498, 25521, 25774, 25751, 25499, 25522, 25775, 25752, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13103, 25499, 25522, 25775, 25752, 25500, 25523, 25776, 25753, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13104, 25500, 25523, 25776, 25753, 25501, 25524, 25777, 25754, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13105, 25501, 25524, 25777, 25754, 25502, 25525, 25778, 25755, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13106, 25502, 25525, 25778, 25755, 25503, 25526, 25779, 25756, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13107, 25503, 25526, 25779, 25756, 25504, 25527, 25780, 25757, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13108, 25504, 25527, 25780, 25757, 25505, 25528, 25781, 25758, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13109, 25505, 25528, 25781, 25758, 25506, 25529, 25782, 25759, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13110, 25506, 25529, 25782, 25759, 25507, 25530, 25783, 25760, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13111, 25507, 25530, 25783, 25760, 25508, 25531, 25784, 25761, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13112, 25508, 25531, 25784, 25761, 25509, 25532, 25785, 25762, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13113, 25509, 25532, 25785, 25762, 5106, 5107, 5118, 5117, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13114, 3290, 3291, 3302, 3301, 25510, 25533, 25786, 25763, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13115, 25510, 25533, 25786, 25763, 25511, 25534, 25787, 25764, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13116, 25511, 25534, 25787, 25764, 25512, 25535, 25788, 25765, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13117, 25512, 25535, 25788, 25765, 25513, 25536, 25789, 25766, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13118, 25513, 25536, 25789, 25766, 25514, 25537, 25790, 25767, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13119, 25514, 25537, 25790, 25767, 25515, 25538, 25791, 25768, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13120, 25515, 25538, 25791, 25768, 25516, 25539, 25792, 25769, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13121, 25516, 25539, 25792, 25769, 25517, 25540, 25793, 25770, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13122, 25517, 25540, 25793, 25770, 25518, 25541, 25794, 25771, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13123, 25518, 25541, 25794, 25771, 25519, 25542, 25795, 25772, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13124, 25519, 25542, 25795, 25772, 25520, 25543, 25796, 25773, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13125, 25520, 25543, 25796, 25773, 25521, 25544, 25797, 25774, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13126, 25521, 25544, 25797, 25774, 25522, 25545, 25798, 25775, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13127, 25522, 25545, 25798, 25775, 25523, 25546, 25799, 25776, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13128, 25523, 25546, 25799, 25776, 25524, 25547, 25800, 25777, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13129, 25524, 25547, 25800, 25777, 25525, 25548, 25801, 25778, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13130, 25525, 25548, 25801, 25778, 25526, 25549, 25802, 25779, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13131, 25526, 25549, 25802, 25779, 25527, 25550, 25803, 25780, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13132, 25527, 25550, 25803, 25780, 25528, 25551, 25804, 25781, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13133, 25528, 25551, 25804, 25781, 25529, 25552, 25805, 25782, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13134, 25529, 25552, 25805, 25782, 25530, 25553, 25806, 25783, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13135, 25530, 25553, 25806, 25783, 25531, 25554, 25807, 25784, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13136, 25531, 25554, 25807, 25784, 25532, 25555, 25808, 25785, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13137, 25532, 25555, 25808, 25785, 5107, 5108, 5119, 5118, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13138, 3291, 297, 298, 3302, 25533, 4568, 4591, 25786, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13139, 25533, 4568, 4591, 25786, 25534, 4569, 4592, 25787, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13140, 25534, 4569, 4592, 25787, 25535, 4570, 4593, 25788, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13141, 25535, 4570, 4593, 25788, 25536, 4571, 4594, 25789, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13142, 25536, 4571, 4594, 25789, 25537, 4572, 4595, 25790, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13143, 25537, 4572, 4595, 25790, 25538, 4573, 4596, 25791, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13144, 25538, 4573, 4596, 25791, 25539, 4574, 4597, 25792, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13145, 25539, 4574, 4597, 25792, 25540, 4575, 4598, 25793, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13146, 25540, 4575, 4598, 25793, 25541, 4576, 4599, 25794, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13147, 25541, 4576, 4599, 25794, 25542, 4577, 4600, 25795, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13148, 25542, 4577, 4600, 25795, 25543, 4578, 4601, 25796, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13149, 25543, 4578, 4601, 25796, 25544, 4579, 4602, 25797, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13150, 25544, 4579, 4602, 25797, 25545, 4580, 4603, 25798, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13151, 25545, 4580, 4603, 25798, 25546, 4581, 4604, 25799, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13152, 25546, 4581, 4604, 25799, 25547, 4582, 4605, 25800, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13153, 25547, 4582, 4605, 25800, 25548, 4583, 4606, 25801, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13154, 25548, 4583, 4606, 25801, 25549, 4584, 4607, 25802, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13155, 25549, 4584, 4607, 25802, 25550, 4585, 4608, 25803, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13156, 25550, 4585, 4608, 25803, 25551, 4586, 4609, 25804, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13157, 25551, 4586, 4609, 25804, 25552, 4587, 4610, 25805, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13158, 25552, 4587, 4610, 25805, 25553, 4588, 4611, 25806, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13159, 25553, 4588, 4611, 25806, 25554, 4589, 4612, 25807, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13160, 25554, 4589, 4612, 25807, 25555, 4590, 4613, 25808, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13161, 25555, 4590, 4613, 25808, 5108, 457, 458, 5119, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13162, 264, 3292, 265, 9, 3809, 25556, 3832, 310, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13163, 3809, 25556, 3832, 310, 3810, 25557, 3833, 311, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13164, 3810, 25557, 3833, 311, 3811, 25558, 3834, 312, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13165, 3811, 25558, 3834, 312, 3812, 25559, 3835, 313, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13166, 3812, 25559, 3835, 313, 3813, 25560, 3836, 314, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13167, 3813, 25560, 3836, 314, 3814, 25561, 3837, 315, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13168, 3814, 25561, 3837, 315, 3815, 25562, 3838, 316, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13169, 3815, 25562, 3838, 316, 3816, 25563, 3839, 317, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13170, 3816, 25563, 3839, 317, 3817, 25564, 3840, 318, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13171, 3817, 25564, 3840, 318, 3818, 25565, 3841, 319, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13172, 3818, 25565, 3841, 319, 3819, 25566, 3842, 320, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13173, 3819, 25566, 3842, 320, 3820, 25567, 3843, 321, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13174, 3820, 25567, 3843, 321, 3821, 25568, 3844, 322, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13175, 3821, 25568, 3844, 322, 3822, 25569, 3845, 323, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13176, 3822, 25569, 3845, 323, 3823, 25570, 3846, 324, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13177, 3823, 25570, 3846, 324, 3824, 25571, 3847, 325, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13178, 3824, 25571, 3847, 325, 3825, 25572, 3848, 326, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13179, 3825, 25572, 3848, 326, 3826, 25573, 3849, 327, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13180, 3826, 25573, 3849, 327, 3827, 25574, 3850, 328, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13181, 3827, 25574, 3850, 328, 3828, 25575, 3851, 329, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13182, 3828, 25575, 3851, 329, 3829, 25576, 3852, 330, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13183, 3829, 25576, 3852, 330, 3830, 25577, 3853, 331, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13184, 3830, 25577, 3853, 331, 3831, 25578, 3854, 332, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13185, 3831, 25578, 3854, 332, 378, 5109, 402, 13, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13186, 3292, 3293, 266, 265, 25556, 25579, 3855, 3832, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13187, 25556, 25579, 3855, 3832, 25557, 25580, 3856, 3833, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13188, 25557, 25580, 3856, 3833, 25558, 25581, 3857, 3834, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13189, 25558, 25581, 3857, 3834, 25559, 25582, 3858, 3835, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13190, 25559, 25582, 3858, 3835, 25560, 25583, 3859, 3836, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13191, 25560, 25583, 3859, 3836, 25561, 25584, 3860, 3837, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13192, 25561, 25584, 3860, 3837, 25562, 25585, 3861, 3838, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13193, 25562, 25585, 3861, 3838, 25563, 25586, 3862, 3839, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13194, 25563, 25586, 3862, 3839, 25564, 25587, 3863, 3840, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13195, 25564, 25587, 3863, 3840, 25565, 25588, 3864, 3841, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13196, 25565, 25588, 3864, 3841, 25566, 25589, 3865, 3842, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13197, 25566, 25589, 3865, 3842, 25567, 25590, 3866, 3843, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13198, 25567, 25590, 3866, 3843, 25568, 25591, 3867, 3844, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13199, 25568, 25591, 3867, 3844, 25569, 25592, 3868, 3845, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13200, 25569, 25592, 3868, 3845, 25570, 25593, 3869, 3846, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13201, 25570, 25593, 3869, 3846, 25571, 25594, 3870, 3847, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13202, 25571, 25594, 3870, 3847, 25572, 25595, 3871, 3848, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13203, 25572, 25595, 3871, 3848, 25573, 25596, 3872, 3849, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13204, 25573, 25596, 3872, 3849, 25574, 25597, 3873, 3850, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13205, 25574, 25597, 3873, 3850, 25575, 25598, 3874, 3851, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13206, 25575, 25598, 3874, 3851, 25576, 25599, 3875, 3852, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13207, 25576, 25599, 3875, 3852, 25577, 25600, 3876, 3853, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13208, 25577, 25600, 3876, 3853, 25578, 25601, 3877, 3854, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13209, 25578, 25601, 3877, 3854, 5109, 5110, 403, 402, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13210, 3293, 3294, 267, 266, 25579, 25602, 3878, 3855, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13211, 25579, 25602, 3878, 3855, 25580, 25603, 3879, 3856, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13212, 25580, 25603, 3879, 3856, 25581, 25604, 3880, 3857, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13213, 25581, 25604, 3880, 3857, 25582, 25605, 3881, 3858, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13214, 25582, 25605, 3881, 3858, 25583, 25606, 3882, 3859, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13215, 25583, 25606, 3882, 3859, 25584, 25607, 3883, 3860, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13216, 25584, 25607, 3883, 3860, 25585, 25608, 3884, 3861, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13217, 25585, 25608, 3884, 3861, 25586, 25609, 3885, 3862, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13218, 25586, 25609, 3885, 3862, 25587, 25610, 3886, 3863, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13219, 25587, 25610, 3886, 3863, 25588, 25611, 3887, 3864, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13220, 25588, 25611, 3887, 3864, 25589, 25612, 3888, 3865, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13221, 25589, 25612, 3888, 3865, 25590, 25613, 3889, 3866, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13222, 25590, 25613, 3889, 3866, 25591, 25614, 3890, 3867, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13223, 25591, 25614, 3890, 3867, 25592, 25615, 3891, 3868, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13224, 25592, 25615, 3891, 3868, 25593, 25616, 3892, 3869, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13225, 25593, 25616, 3892, 3869, 25594, 25617, 3893, 3870, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13226, 25594, 25617, 3893, 3870, 25595, 25618, 3894, 3871, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13227, 25595, 25618, 3894, 3871, 25596, 25619, 3895, 3872, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13228, 25596, 25619, 3895, 3872, 25597, 25620, 3896, 3873, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13229, 25597, 25620, 3896, 3873, 25598, 25621, 3897, 3874, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13230, 25598, 25621, 3897, 3874, 25599, 25622, 3898, 3875, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13231, 25599, 25622, 3898, 3875, 25600, 25623, 3899, 3876, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13232, 25600, 25623, 3899, 3876, 25601, 25624, 3900, 3877, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13233, 25601, 25624, 3900, 3877, 5110, 5111, 404, 403, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13234, 3294, 3295, 268, 267, 25602, 25625, 3901, 3878, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13235, 25602, 25625, 3901, 3878, 25603, 25626, 3902, 3879, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13236, 25603, 25626, 3902, 3879, 25604, 25627, 3903, 3880, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13237, 25604, 25627, 3903, 3880, 25605, 25628, 3904, 3881, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13238, 25605, 25628, 3904, 3881, 25606, 25629, 3905, 3882, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13239, 25606, 25629, 3905, 3882, 25607, 25630, 3906, 3883, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13240, 25607, 25630, 3906, 3883, 25608, 25631, 3907, 3884, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13241, 25608, 25631, 3907, 3884, 25609, 25632, 3908, 3885, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13242, 25609, 25632, 3908, 3885, 25610, 25633, 3909, 3886, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13243, 25610, 25633, 3909, 3886, 25611, 25634, 3910, 3887, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13244, 25611, 25634, 3910, 3887, 25612, 25635, 3911, 3888, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13245, 25612, 25635, 3911, 3888, 25613, 25636, 3912, 3889, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13246, 25613, 25636, 3912, 3889, 25614, 25637, 3913, 3890, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13247, 25614, 25637, 3913, 3890, 25615, 25638, 3914, 3891, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13248, 25615, 25638, 3914, 3891, 25616, 25639, 3915, 3892, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13249, 25616, 25639, 3915, 3892, 25617, 25640, 3916, 3893, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13250, 25617, 25640, 3916, 3893, 25618, 25641, 3917, 3894, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13251, 25618, 25641, 3917, 3894, 25619, 25642, 3918, 3895, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13252, 25619, 25642, 3918, 3895, 25620, 25643, 3919, 3896, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13253, 25620, 25643, 3919, 3896, 25621, 25644, 3920, 3897, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13254, 25621, 25644, 3920, 3897, 25622, 25645, 3921, 3898, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13255, 25622, 25645, 3921, 3898, 25623, 25646, 3922, 3899, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13256, 25623, 25646, 3922, 3899, 25624, 25647, 3923, 3900, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13257, 25624, 25647, 3923, 3900, 5111, 5112, 405, 404, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13258, 3295, 3296, 269, 268, 25625, 25648, 3924, 3901, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13259, 25625, 25648, 3924, 3901, 25626, 25649, 3925, 3902, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13260, 25626, 25649, 3925, 3902, 25627, 25650, 3926, 3903, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13261, 25627, 25650, 3926, 3903, 25628, 25651, 3927, 3904, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13262, 25628, 25651, 3927, 3904, 25629, 25652, 3928, 3905, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13263, 25629, 25652, 3928, 3905, 25630, 25653, 3929, 3906, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13264, 25630, 25653, 3929, 3906, 25631, 25654, 3930, 3907, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13265, 25631, 25654, 3930, 3907, 25632, 25655, 3931, 3908, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13266, 25632, 25655, 3931, 3908, 25633, 25656, 3932, 3909, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13267, 25633, 25656, 3932, 3909, 25634, 25657, 3933, 3910, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13268, 25634, 25657, 3933, 3910, 25635, 25658, 3934, 3911, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13269, 25635, 25658, 3934, 3911, 25636, 25659, 3935, 3912, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13270, 25636, 25659, 3935, 3912, 25637, 25660, 3936, 3913, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13271, 25637, 25660, 3936, 3913, 25638, 25661, 3937, 3914, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13272, 25638, 25661, 3937, 3914, 25639, 25662, 3938, 3915, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13273, 25639, 25662, 3938, 3915, 25640, 25663, 3939, 3916, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13274, 25640, 25663, 3939, 3916, 25641, 25664, 3940, 3917, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13275, 25641, 25664, 3940, 3917, 25642, 25665, 3941, 3918, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13276, 25642, 25665, 3941, 3918, 25643, 25666, 3942, 3919, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13277, 25643, 25666, 3942, 3919, 25644, 25667, 3943, 3920, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13278, 25644, 25667, 3943, 3920, 25645, 25668, 3944, 3921, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13279, 25645, 25668, 3944, 3921, 25646, 25669, 3945, 3922, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13280, 25646, 25669, 3945, 3922, 25647, 25670, 3946, 3923, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13281, 25647, 25670, 3946, 3923, 5112, 5113, 406, 405, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13282, 3296, 3297, 270, 269, 25648, 25671, 3947, 3924, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13283, 25648, 25671, 3947, 3924, 25649, 25672, 3948, 3925, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13284, 25649, 25672, 3948, 3925, 25650, 25673, 3949, 3926, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13285, 25650, 25673, 3949, 3926, 25651, 25674, 3950, 3927, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13286, 25651, 25674, 3950, 3927, 25652, 25675, 3951, 3928, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13287, 25652, 25675, 3951, 3928, 25653, 25676, 3952, 3929, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13288, 25653, 25676, 3952, 3929, 25654, 25677, 3953, 3930, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13289, 25654, 25677, 3953, 3930, 25655, 25678, 3954, 3931, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13290, 25655, 25678, 3954, 3931, 25656, 25679, 3955, 3932, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13291, 25656, 25679, 3955, 3932, 25657, 25680, 3956, 3933, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13292, 25657, 25680, 3956, 3933, 25658, 25681, 3957, 3934, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13293, 25658, 25681, 3957, 3934, 25659, 25682, 3958, 3935, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13294, 25659, 25682, 3958, 3935, 25660, 25683, 3959, 3936, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13295, 25660, 25683, 3959, 3936, 25661, 25684, 3960, 3937, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13296, 25661, 25684, 3960, 3937, 25662, 25685, 3961, 3938, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13297, 25662, 25685, 3961, 3938, 25663, 25686, 3962, 3939, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13298, 25663, 25686, 3962, 3939, 25664, 25687, 3963, 3940, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13299, 25664, 25687, 3963, 3940, 25665, 25688, 3964, 3941, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13300, 25665, 25688, 3964, 3941, 25666, 25689, 3965, 3942, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13301, 25666, 25689, 3965, 3942, 25667, 25690, 3966, 3943, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13302, 25667, 25690, 3966, 3943, 25668, 25691, 3967, 3944, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13303, 25668, 25691, 3967, 3944, 25669, 25692, 3968, 3945, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13304, 25669, 25692, 3968, 3945, 25670, 25693, 3969, 3946, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13305, 25670, 25693, 3969, 3946, 5113, 5114, 407, 406, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13306, 3297, 3298, 271, 270, 25671, 25694, 3970, 3947, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13307, 25671, 25694, 3970, 3947, 25672, 25695, 3971, 3948, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13308, 25672, 25695, 3971, 3948, 25673, 25696, 3972, 3949, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13309, 25673, 25696, 3972, 3949, 25674, 25697, 3973, 3950, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13310, 25674, 25697, 3973, 3950, 25675, 25698, 3974, 3951, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13311, 25675, 25698, 3974, 3951, 25676, 25699, 3975, 3952, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13312, 25676, 25699, 3975, 3952, 25677, 25700, 3976, 3953, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13313, 25677, 25700, 3976, 3953, 25678, 25701, 3977, 3954, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13314, 25678, 25701, 3977, 3954, 25679, 25702, 3978, 3955, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13315, 25679, 25702, 3978, 3955, 25680, 25703, 3979, 3956, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13316, 25680, 25703, 3979, 3956, 25681, 25704, 3980, 3957, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13317, 25681, 25704, 3980, 3957, 25682, 25705, 3981, 3958, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13318, 25682, 25705, 3981, 3958, 25683, 25706, 3982, 3959, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13319, 25683, 25706, 3982, 3959, 25684, 25707, 3983, 3960, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13320, 25684, 25707, 3983, 3960, 25685, 25708, 3984, 3961, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13321, 25685, 25708, 3984, 3961, 25686, 25709, 3985, 3962, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13322, 25686, 25709, 3985, 3962, 25687, 25710, 3986, 3963, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13323, 25687, 25710, 3986, 3963, 25688, 25711, 3987, 3964, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13324, 25688, 25711, 3987, 3964, 25689, 25712, 3988, 3965, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13325, 25689, 25712, 3988, 3965, 25690, 25713, 3989, 3966, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13326, 25690, 25713, 3989, 3966, 25691, 25714, 3990, 3967, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13327, 25691, 25714, 3990, 3967, 25692, 25715, 3991, 3968, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13328, 25692, 25715, 3991, 3968, 25693, 25716, 3992, 3969, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13329, 25693, 25716, 3992, 3969, 5114, 5115, 408, 407, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13330, 3298, 3299, 272, 271, 25694, 25717, 3993, 3970, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13331, 25694, 25717, 3993, 3970, 25695, 25718, 3994, 3971, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13332, 25695, 25718, 3994, 3971, 25696, 25719, 3995, 3972, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13333, 25696, 25719, 3995, 3972, 25697, 25720, 3996, 3973, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13334, 25697, 25720, 3996, 3973, 25698, 25721, 3997, 3974, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13335, 25698, 25721, 3997, 3974, 25699, 25722, 3998, 3975, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13336, 25699, 25722, 3998, 3975, 25700, 25723, 3999, 3976, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13337, 25700, 25723, 3999, 3976, 25701, 25724, 4000, 3977, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13338, 25701, 25724, 4000, 3977, 25702, 25725, 4001, 3978, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13339, 25702, 25725, 4001, 3978, 25703, 25726, 4002, 3979, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13340, 25703, 25726, 4002, 3979, 25704, 25727, 4003, 3980, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13341, 25704, 25727, 4003, 3980, 25705, 25728, 4004, 3981, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13342, 25705, 25728, 4004, 3981, 25706, 25729, 4005, 3982, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13343, 25706, 25729, 4005, 3982, 25707, 25730, 4006, 3983, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13344, 25707, 25730, 4006, 3983, 25708, 25731, 4007, 3984, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13345, 25708, 25731, 4007, 3984, 25709, 25732, 4008, 3985, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13346, 25709, 25732, 4008, 3985, 25710, 25733, 4009, 3986, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13347, 25710, 25733, 4009, 3986, 25711, 25734, 4010, 3987, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13348, 25711, 25734, 4010, 3987, 25712, 25735, 4011, 3988, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13349, 25712, 25735, 4011, 3988, 25713, 25736, 4012, 3989, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13350, 25713, 25736, 4012, 3989, 25714, 25737, 4013, 3990, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13351, 25714, 25737, 4013, 3990, 25715, 25738, 4014, 3991, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13352, 25715, 25738, 4014, 3991, 25716, 25739, 4015, 3992, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13353, 25716, 25739, 4015, 3992, 5115, 5116, 409, 408, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13354, 3299, 3300, 273, 272, 25717, 25740, 4016, 3993, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13355, 25717, 25740, 4016, 3993, 25718, 25741, 4017, 3994, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13356, 25718, 25741, 4017, 3994, 25719, 25742, 4018, 3995, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13357, 25719, 25742, 4018, 3995, 25720, 25743, 4019, 3996, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13358, 25720, 25743, 4019, 3996, 25721, 25744, 4020, 3997, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13359, 25721, 25744, 4020, 3997, 25722, 25745, 4021, 3998, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13360, 25722, 25745, 4021, 3998, 25723, 25746, 4022, 3999, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13361, 25723, 25746, 4022, 3999, 25724, 25747, 4023, 4000, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13362, 25724, 25747, 4023, 4000, 25725, 25748, 4024, 4001, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13363, 25725, 25748, 4024, 4001, 25726, 25749, 4025, 4002, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13364, 25726, 25749, 4025, 4002, 25727, 25750, 4026, 4003, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
13365, 25727, 25750, 4026, 4003, 25728, 25751, 4027, 4004, 0, 0, 0, 0, 0, 0, 0, 
0, 0, 0, 0, 0
