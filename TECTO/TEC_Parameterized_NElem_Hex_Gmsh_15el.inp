7382, 0.93333333333333, 0.51333333333333, 0.066666666666667
7383, 0.93333333333333, 0.56666666666667, 0.066666666666667
7384, 0.93333333333333, 0.62, 0.066666666666667
7385, 0.93333333333333, 0.67333333333333, 0.066666666666667
7386, 0.93333333333333, 0.72666666666667, 0.066666666666667
7387, 0.93333333333333, 0.78, 0.066666666666667
7388, 0.93333333333333, 0.83333333333333, 0.066666666666667
7389, 0.93333333333333, 0.88666666666667, 0.066666666666667
7390, 0.93333333333333, 0.94, 0.066666666666667
7391, 0.93333333333333, 0.99333333333333, 0.066666666666667
7392, 0.93333333333333, 1.0466666666667, 0.066666666666667
7393, 0.93333333333333, 0.35333333333333, 0.1
7394, 0.93333333333333, 0.40666666666667, 0.1
7395, 0.93333333333333, 0.46, 0.1
7396, 0.93333333333333, 0.51333333333333, 0.1
7397, 0.93333333333333, 0.56666666666667, 0.1
7398, 0.93333333333333, 0.62, 0.1
7399, 0.93333333333333, 0.67333333333333, 0.1
7400, 0.93333333333333, 0.72666666666667, 0.1
7401, 0.93333333333333, 0.78, 0.1
7402, 0.93333333333333, 0.83333333333333, 0.1
7403, 0.93333333333333, 0.88666666666667, 0.1
7404, 0.93333333333333, 0.94, 0.1
7405, 0.93333333333333, 0.99333333333333, 0.1
7406, 0.93333333333333, 1.0466666666667, 0.1
7407, 0.93333333333333, 0.35333333333333, 0.13333333333333
7408, 0.93333333333333, 0.40666666666667, 0.13333333333333
7409, 0.93333333333333, 0.46, 0.13333333333333
7410, 0.93333333333333, 0.51333333333333, 0.13333333333333
7411, 0.93333333333333, 0.56666666666667, 0.13333333333333
7412, 0.93333333333333, 0.62, 0.13333333333333
7413, 0.93333333333333, 0.67333333333333, 0.13333333333333
7414, 0.93333333333333, 0.72666666666667, 0.13333333333333
7415, 0.93333333333333, 0.78, 0.13333333333333
7416, 0.93333333333333, 0.83333333333333, 0.13333333333333
7417, 0.93333333333333, 0.88666666666667, 0.13333333333333
7418, 0.93333333333333, 0.94, 0.13333333333333
7419, 0.93333333333333, 0.99333333333333, 0.13333333333333
7420, 0.93333333333333, 1.0466666666667, 0.13333333333333
7421, 0.93333333333333, 0.35333333333333, 0.16666666666667
7422, 0.93333333333333, 0.40666666666667, 0.16666666666667
7423, 0.93333333333333, 0.46, 0.16666666666667
7424, 0.93333333333333, 0.51333333333333, 0.16666666666667
7425, 0.93333333333333, 0.56666666666667, 0.16666666666667
7426, 0.93333333333333, 0.62, 0.16666666666667
7427, 0.93333333333333, 0.67333333333333, 0.16666666666667
7428, 0.93333333333333, 0.72666666666667, 0.16666666666667
7429, 0.93333333333333, 0.78, 0.16666666666667
7430, 0.93333333333333, 0.83333333333333, 0.16666666666667
7431, 0.93333333333333, 0.88666666666667, 0.16666666666667
7432, 0.93333333333333, 0.94, 0.16666666666667
7433, 0.93333333333333, 0.99333333333333, 0.16666666666667
7434, 0.93333333333333, 1.0466666666667, 0.16666666666667
7435, 0.93333333333333, 0.35333333333333, 0.2
7436, 0.93333333333333, 0.40666666666667, 0.2
7437, 0.93333333333333, 0.46, 0.2
7438, 0.93333333333333, 0.51333333333333, 0.2
7439, 0.93333333333333, 0.56666666666667, 0.2
7440, 0.93333333333333, 0.62, 0.2
7441, 0.93333333333333, 0.67333333333333, 0.2
7442, 0.93333333333333, 0.72666666666667, 0.2
7443, 0.93333333333333, 0.78, 0.2
7444, 0.93333333333333, 0.83333333333333, 0.2
7445, 0.93333333333333, 0.88666666666667, 0.2
7446, 0.93333333333333, 0.94, 0.2
7447, 0.93333333333333, 0.99333333333333, 0.2
7448, 0.93333333333333, 1.0466666666667, 0.2
7449, 0.93333333333333, 0.35333333333333, 0.23333333333333
7450, 0.93333333333333, 0.40666666666667, 0.23333333333333
7451, 0.93333333333333, 0.46, 0.23333333333333
7452, 0.93333333333333, 0.51333333333333, 0.23333333333333
7453, 0.93333333333333, 0.56666666666667, 0.23333333333333
7454, 0.93333333333333, 0.62, 0.23333333333333
7455, 0.93333333333333, 0.67333333333333, 0.23333333333333
7456, 0.93333333333333, 0.72666666666667, 0.23333333333333
7457, 0.93333333333333, 0.78, 0.23333333333333
7458, 0.93333333333333, 0.83333333333333, 0.23333333333333
7459, 0.93333333333333, 0.88666666666667, 0.23333333333333
7460, 0.93333333333333, 0.94, 0.23333333333333
7461, 0.93333333333333, 0.99333333333333, 0.23333333333333
7462, 0.93333333333333, 1.0466666666667, 0.23333333333333
7463, 0.93333333333333, 0.35333333333333, 0.26666666666667
7464, 0.93333333333333, 0.40666666666667, 0.26666666666667
7465, 0.93333333333333, 0.46, 0.26666666666667
7466, 0.93333333333333, 0.51333333333333, 0.26666666666667
7467, 0.93333333333333, 0.56666666666667, 0.26666666666667
7468, 0.93333333333333, 0.62, 0.26666666666667
7469, 0.93333333333333, 0.67333333333333, 0.26666666666667
7470, 0.93333333333333, 0.72666666666667, 0.26666666666667
7471, 0.93333333333333, 0.78, 0.26666666666667
7472, 0.93333333333333, 0.83333333333333, 0.26666666666667
7473, 0.93333333333333, 0.88666666666667, 0.26666666666667
7474, 0.93333333333333, 0.94, 0.26666666666667
7475, 0.93333333333333, 0.99333333333333, 0.26666666666667
7476, 0.93333333333333, 1.0466666666667, 0.26666666666667
7477, 0.93333333333333, 0.35333333333333, 0.3
7478, 0.93333333333333, 0.40666666666667, 0.3
7479, 0.93333333333333, 0.46, 0.3
7480, 0.93333333333333, 0.51333333333333, 0.3
7481, 0.93333333333333, 0.56666666666667, 0.3
7482, 0.93333333333333, 0.62, 0.3
7483, 0.93333333333333, 0.67333333333333, 0.3
7484, 0.93333333333333, 0.72666666666667, 0.3
7485, 0.93333333333333, 0.78, 0.3
7486, 0.93333333333333, 0.83333333333333, 0.3
7487, 0.93333333333333, 0.88666666666667, 0.3
7488, 0.93333333333333, 0.94, 0.3
7489, 0.93333333333333, 0.99333333333333, 0.3
7490, 0.93333333333333, 1.0466666666667, 0.3
7491, 0.93333333333333, 0.35333333333333, 0.33333333333333
7492, 0.93333333333333, 0.40666666666667, 0.33333333333333
7493, 0.93333333333333, 0.46, 0.33333333333333
7494, 0.93333333333333, 0.51333333333333, 0.33333333333333
7495, 0.93333333333333, 0.56666666666667, 0.33333333333333
7496, 0.93333333333333, 0.62, 0.33333333333333
7497, 0.93333333333333, 0.67333333333333, 0.33333333333333
7498, 0.93333333333333, 0.72666666666667, 0.33333333333333
7499, 0.93333333333333, 0.78, 0.33333333333333
7500, 0.93333333333333, 0.83333333333333, 0.33333333333333
7501, 0.93333333333333, 0.88666666666667, 0.33333333333333
7502, 0.93333333333333, 0.94, 0.33333333333333
7503, 0.93333333333333, 0.99333333333333, 0.33333333333333
7504, 0.93333333333333, 1.0466666666667, 0.33333333333333
7505, 0.93333333333333, 0.35333333333333, 0.36666666666667
7506, 0.93333333333333, 0.40666666666667, 0.36666666666667
7507, 0.93333333333333, 0.46, 0.36666666666667
7508, 0.93333333333333, 0.51333333333333, 0.36666666666667
7509, 0.93333333333333, 0.56666666666667, 0.36666666666667
7510, 0.93333333333333, 0.62, 0.36666666666667
7511, 0.93333333333333, 0.67333333333333, 0.36666666666667
7512, 0.93333333333333, 0.72666666666667, 0.36666666666667
7513, 0.93333333333333, 0.78, 0.36666666666667
7514, 0.93333333333333, 0.83333333333333, 0.36666666666667
7515, 0.93333333333333, 0.88666666666667, 0.36666666666667
7516, 0.93333333333333, 0.94, 0.36666666666667
7517, 0.93333333333333, 0.99333333333333, 0.36666666666667
7518, 0.93333333333333, 1.0466666666667, 0.36666666666667
7519, 0.93333333333333, 0.35333333333333, 0.4
7520, 0.93333333333333, 0.40666666666667, 0.4
7521, 0.93333333333333, 0.46, 0.4
7522, 0.93333333333333, 0.51333333333333, 0.4
7523, 0.93333333333333, 0.56666666666667, 0.4
7524, 0.93333333333333, 0.62, 0.4
7525, 0.93333333333333, 0.67333333333333, 0.4
7526, 0.93333333333333, 0.72666666666667, 0.4
7527, 0.93333333333333, 0.78, 0.4
7528, 0.93333333333333, 0.83333333333333, 0.4
7529, 0.93333333333333, 0.88666666666667, 0.4
7530, 0.93333333333333, 0.94, 0.4
7531, 0.93333333333333, 0.99333333333333, 0.4
7532, 0.93333333333333, 1.0466666666667, 0.4
7533, 0.93333333333333, 0.35333333333333, 0.43333333333333
7534, 0.93333333333333, 0.40666666666667, 0.43333333333333
7535, 0.93333333333333, 0.46, 0.43333333333333
7536, 0.93333333333333, 0.51333333333333, 0.43333333333333
7537, 0.93333333333333, 0.56666666666667, 0.43333333333333
7538, 0.93333333333333, 0.62, 0.43333333333333
7539, 0.93333333333333, 0.67333333333333, 0.43333333333333
7540, 0.93333333333333, 0.72666666666667, 0.43333333333333
7541, 0.93333333333333, 0.78, 0.43333333333333
7542, 0.93333333333333, 0.83333333333333, 0.43333333333333
7543, 0.93333333333333, 0.88666666666667, 0.43333333333333
7544, 0.93333333333333, 0.94, 0.43333333333333
7545, 0.93333333333333, 0.99333333333333, 0.43333333333333
7546, 0.93333333333333, 1.0466666666667, 0.43333333333333
7547, 0.93333333333333, 0.35333333333333, 0.46666666666667
7548, 0.93333333333333, 0.40666666666667, 0.46666666666667
7549, 0.93333333333333, 0.46, 0.46666666666667
7550, 0.93333333333333, 0.51333333333333, 0.46666666666667
7551, 0.93333333333333, 0.56666666666667, 0.46666666666667
7552, 0.93333333333333, 0.62, 0.46666666666667
7553, 0.93333333333333, 0.67333333333333, 0.46666666666667
7554, 0.93333333333333, 0.72666666666667, 0.46666666666667
7555, 0.93333333333333, 0.78, 0.46666666666667
7556, 0.93333333333333, 0.83333333333333, 0.46666666666667
7557, 0.93333333333333, 0.88666666666667, 0.46666666666667
7558, 0.93333333333333, 0.94, 0.46666666666667
7559, 0.93333333333333, 0.99333333333333, 0.46666666666667
7560, 0.93333333333333, 1.0466666666667, 0.46666666666667
7561, 1.2666666666667, 1.0466666666667, 0.033333333333333
7562, 1.2666666666667, 0.99333333333333, 0.033333333333333
7563, 1.2666666666667, 0.94, 0.033333333333333
7564, 1.2666666666667, 0.88666666666667, 0.033333333333333
7565, 1.2666666666667, 0.83333333333333, 0.033333333333333
7566, 1.2666666666667, 0.78, 0.033333333333333
7567, 1.2666666666667, 0.72666666666667, 0.033333333333333
7568, 1.2666666666667, 0.67333333333333, 0.033333333333333
7569, 1.2666666666667, 0.62, 0.033333333333333
7570, 1.2666666666667, 0.56666666666667, 0.033333333333333
7571, 1.2666666666667, 0.51333333333333, 0.033333333333333
7572, 1.2666666666667, 0.46, 0.033333333333333
7573, 1.2666666666667, 0.40666666666667, 0.033333333333333
7574, 1.2666666666667, 0.35333333333333, 0.033333333333333
7575, 1.3333333333333, 1.0466666666667, 0.033333333333333
7576, 1.3333333333333, 0.99333333333333, 0.033333333333333
7577, 1.3333333333333, 0.94, 0.033333333333333
7578, 1.3333333333333, 0.88666666666667, 0.033333333333333
7579, 1.3333333333333, 0.83333333333333, 0.033333333333333
7580, 1.3333333333333, 0.78, 0.033333333333333
7581, 1.3333333333333, 0.72666666666667, 0.033333333333333
7582, 1.3333333333333, 0.67333333333333, 0.033333333333333
7583, 1.3333333333333, 0.62, 0.033333333333333
7584, 1.3333333333333, 0.56666666666667, 0.033333333333333
7585, 1.3333333333333, 0.51333333333333, 0.033333333333333
7586, 1.3333333333333, 0.46, 0.033333333333333
7587, 1.3333333333333, 0.40666666666667, 0.033333333333333
7588, 1.3333333333333, 0.35333333333333, 0.033333333333333
7589, 1.4, 1.0466666666667, 0.033333333333333
7590, 1.4, 0.99333333333333, 0.033333333333333
7591, 1.4, 0.94, 0.033333333333333
7592, 1.4, 0.88666666666667, 0.033333333333333
7593, 1.4, 0.83333333333333, 0.033333333333333
7594, 1.4, 0.78, 0.033333333333333
7595, 1.4, 0.72666666666667, 0.033333333333333
7596, 1.4, 0.67333333333333, 0.033333333333333
7597, 1.4, 0.62, 0.033333333333333
7598, 1.4, 0.56666666666667, 0.033333333333333
7599, 1.4, 0.51333333333333, 0.033333333333333
7600, 1.4, 0.46, 0.033333333333333
7601, 1.4, 0.40666666666667, 0.033333333333333
7602, 1.4, 0.35333333333333, 0.033333333333333
7603, 1.4666666666667, 1.0466666666667, 0.033333333333333
7604, 1.4666666666667, 0.99333333333333, 0.033333333333333
7605, 1.4666666666667, 0.94, 0.033333333333333
7606, 1.4666666666667, 0.88666666666667, 0.033333333333333
7607, 1.4666666666667, 0.83333333333333, 0.033333333333333
7608, 1.4666666666667, 0.78, 0.033333333333333
7609, 1.4666666666667, 0.72666666666667, 0.033333333333333
7610, 1.4666666666667, 0.67333333333333, 0.033333333333333
7611, 1.4666666666667, 0.62, 0.033333333333333
7612, 1.4666666666667, 0.56666666666667, 0.033333333333333
7613, 1.4666666666667, 0.51333333333333, 0.033333333333333
7614, 1.4666666666667, 0.46, 0.033333333333333
7615, 1.4666666666667, 0.40666666666667, 0.033333333333333
7616, 1.4666666666667, 0.35333333333333, 0.033333333333333
7617, 1.5333333333333, 1.0466666666667, 0.033333333333333
7618, 1.5333333333333, 0.99333333333333, 0.033333333333333
7619, 1.5333333333333, 0.94, 0.033333333333333
7620, 1.5333333333333, 0.88666666666667, 0.033333333333333
7621, 1.5333333333333, 0.83333333333333, 0.033333333333333
7622, 1.5333333333333, 0.78, 0.033333333333333
7623, 1.5333333333333, 0.72666666666667, 0.033333333333333
7624, 1.5333333333333, 0.67333333333333, 0.033333333333333
7625, 1.5333333333333, 0.62, 0.033333333333333
7626, 1.5333333333333, 0.56666666666667, 0.033333333333333
7627, 1.5333333333333, 0.51333333333333, 0.033333333333333
7628, 1.5333333333333, 0.46, 0.033333333333333
7629, 1.5333333333333, 0.40666666666667, 0.033333333333333
7630, 1.5333333333333, 0.35333333333333, 0.033333333333333
7631, 1.6, 1.0466666666667, 0.033333333333333
7632, 1.6, 0.99333333333333, 0.033333333333333
7633, 1.6, 0.94, 0.033333333333333
7634, 1.6, 0.88666666666667, 0.033333333333333
7635, 1.6, 0.83333333333333, 0.033333333333333
7636, 1.6, 0.78, 0.033333333333333
7637, 1.6, 0.72666666666667, 0.033333333333333
7638, 1.6, 0.67333333333333, 0.033333333333333
7639, 1.6, 0.62, 0.033333333333333
7640, 1.6, 0.56666666666667, 0.033333333333333
7641, 1.6, 0.51333333333333, 0.033333333333333
7642, 1.6, 0.46, 0.033333333333333
7643, 1.6, 0.40666666666667, 0.033333333333333
7644, 1.6, 0.35333333333333, 0.033333333333333
7645, 1.6666666666667, 1.0466666666667, 0.033333333333333
7646, 1.6666666666667, 0.99333333333333, 0.033333333333333
7647, 1.6666666666667, 0.94, 0.033333333333333
7648, 1.6666666666667, 0.88666666666667, 0.033333333333333
7649, 1.6666666666667, 0.83333333333333, 0.033333333333333
7650, 1.6666666666667, 0.78, 0.033333333333333
7651, 1.6666666666667, 0.72666666666667, 0.033333333333333
7652, 1.6666666666667, 0.67333333333333, 0.033333333333333
7653, 1.6666666666667, 0.62, 0.033333333333333
7654, 1.6666666666667, 0.56666666666667, 0.033333333333333
7655, 1.6666666666667, 0.51333333333333, 0.033333333333333
7656, 1.6666666666667, 0.46, 0.033333333333333
7657, 1.6666666666667, 0.40666666666667, 0.033333333333333
7658, 1.6666666666667, 0.35333333333333, 0.033333333333333
7659, 1.7333333333333, 1.0466666666667, 0.033333333333333
7660, 1.7333333333333, 0.99333333333333, 0.033333333333333
7661, 1.7333333333333, 0.94, 0.033333333333333
7662, 1.7333333333333, 0.88666666666667, 0.033333333333333
7663, 1.7333333333333, 0.83333333333333, 0.033333333333333
7664, 1.7333333333333, 0.78, 0.033333333333333
7665, 1.7333333333333, 0.72666666666667, 0.033333333333333
7666, 1.7333333333333, 0.67333333333333, 0.033333333333333
7667, 1.7333333333333, 0.62, 0.033333333333333
7668, 1.7333333333333, 0.56666666666667, 0.033333333333333
7669, 1.7333333333333, 0.51333333333333, 0.033333333333333
7670, 1.7333333333333, 0.46, 0.033333333333333
7671, 1.7333333333333, 0.40666666666667, 0.033333333333333
7672, 1.7333333333333, 0.35333333333333, 0.033333333333333
7673, 1.8, 1.0466666666667, 0.033333333333333
7674, 1.8, 0.99333333333333, 0.033333333333333
7675, 1.8, 0.94, 0.033333333333333
7676, 1.8, 0.88666666666667, 0.033333333333333
7677, 1.8, 0.83333333333333, 0.033333333333333
7678, 1.8, 0.78, 0.033333333333333
7679, 1.8, 0.72666666666667, 0.033333333333333
7680, 1.8, 0.67333333333333, 0.033333333333333
7681, 1.8, 0.62, 0.033333333333333
7682, 1.8, 0.56666666666667, 0.033333333333333
7683, 1.8, 0.51333333333333, 0.033333333333333
7684, 1.8, 0.46, 0.033333333333333
7685, 1.8, 0.40666666666667, 0.033333333333333
7686, 1.8, 0.35333333333333, 0.033333333333333
7687, 1.8666666666667, 1.0466666666667, 0.033333333333333
7688, 1.8666666666667, 0.99333333333333, 0.033333333333333
7689, 1.8666666666667, 0.94, 0.033333333333333
7690, 1.8666666666667, 0.88666666666667, 0.033333333333333
7691, 1.8666666666667, 0.83333333333333, 0.033333333333333
7692, 1.8666666666667, 0.78, 0.033333333333333
7693, 1.8666666666667, 0.72666666666667, 0.033333333333333
7694, 1.8666666666667, 0.67333333333333, 0.033333333333333
7695, 1.8666666666667, 0.62, 0.033333333333333
7696, 1.8666666666667, 0.56666666666667, 0.033333333333333
7697, 1.8666666666667, 0.51333333333333, 0.033333333333333
7698, 1.8666666666667, 0.46, 0.033333333333333
7699, 1.8666666666667, 0.40666666666667, 0.033333333333333
7700, 1.8666666666667, 0.35333333333333, 0.033333333333333
7701, 1.9333333333333, 1.0466666666667, 0.033333333333333
7702, 1.9333333333333, 0.99333333333333, 0.033333333333333
7703, 1.9333333333333, 0.94, 0.033333333333333
7704, 1.9333333333333, 0.88666666666667, 0.033333333333333
7705, 1.9333333333333, 0.83333333333333, 0.033333333333333
7706, 1.9333333333333, 0.78, 0.033333333333333
7707, 1.9333333333333, 0.72666666666667, 0.033333333333333
7708, 1.9333333333333, 0.67333333333333, 0.033333333333333
7709, 1.9333333333333, 0.62, 0.033333333333333
7710, 1.9333333333333, 0.56666666666667, 0.033333333333333
7711, 1.9333333333333, 0.51333333333333, 0.033333333333333
7712, 1.9333333333333, 0.46, 0.033333333333333
7713, 1.9333333333333, 0.40666666666667, 0.033333333333333
7714, 1.9333333333333, 0.35333333333333, 0.033333333333333
7715, 2, 1.0466666666667, 0.033333333333333
7716, 2, 0.99333333333333, 0.033333333333333
7717, 2, 0.94, 0.033333333333333
7718, 2, 0.88666666666667, 0.033333333333333
7719, 2, 0.83333333333333, 0.033333333333333
7720, 2, 0.78, 0.033333333333333
7721, 2, 0.72666666666667, 0.033333333333333
7722, 2, 0.67333333333333, 0.033333333333333
7723, 2, 0.62, 0.033333333333333
7724, 2, 0.56666666666667, 0.033333333333333
7725, 2, 0.51333333333333, 0.033333333333333
7726, 2, 0.46, 0.033333333333333
7727, 2, 0.40666666666667, 0.033333333333333
7728, 2, 0.35333333333333, 0.033333333333333
7729, 2.0666666666667, 1.0466666666667, 0.033333333333333
7730, 2.0666666666667, 0.99333333333333, 0.033333333333333
7731, 2.0666666666667, 0.94, 0.033333333333333
7732, 2.0666666666667, 0.88666666666667, 0.033333333333333
7733, 2.0666666666667, 0.83333333333333, 0.033333333333333
7734, 2.0666666666667, 0.78, 0.033333333333333
7735, 2.0666666666667, 0.72666666666667, 0.033333333333333
7736, 2.0666666666667, 0.67333333333333, 0.033333333333333
7737, 2.0666666666667, 0.62, 0.033333333333333
7738, 2.0666666666667, 0.56666666666667, 0.033333333333333
7739, 2.0666666666667, 0.51333333333333, 0.033333333333333
7740, 2.0666666666667, 0.46, 0.033333333333333
7741, 2.0666666666667, 0.40666666666667, 0.033333333333333
7742, 2.0666666666667, 0.35333333333333, 0.033333333333333
7743, 2.1333333333333, 1.0466666666667, 0.033333333333333
7744, 2.1333333333333, 0.99333333333333, 0.033333333333333
7745, 2.1333333333333, 0.94, 0.033333333333333
7746, 2.1333333333333, 0.88666666666667, 0.033333333333333
7747, 2.1333333333333, 0.83333333333333, 0.033333333333333
7748, 2.1333333333333, 0.78, 0.033333333333333
7749, 2.1333333333333, 0.72666666666667, 0.033333333333333
7750, 2.1333333333333, 0.67333333333333, 0.033333333333333
7751, 2.1333333333333, 0.62, 0.033333333333333
7752, 2.1333333333333, 0.56666666666667, 0.033333333333333
7753, 2.1333333333333, 0.51333333333333, 0.033333333333333
7754, 2.1333333333333, 0.46, 0.033333333333333
7755, 2.1333333333333, 0.40666666666667, 0.033333333333333
7756, 2.1333333333333, 0.35333333333333, 0.033333333333333
7757, 1.2666666666667, 1.0466666666667, 0.066666666666667
7758, 1.2666666666667, 0.99333333333333, 0.066666666666667
7759, 1.2666666666667, 0.94, 0.066666666666667
7760, 1.2666666666667, 0.88666666666667, 0.066666666666667
7761, 1.2666666666667, 0.83333333333333, 0.066666666666667
7762, 1.2666666666667, 0.78, 0.066666666666667
7763, 1.2666666666667, 0.72666666666667, 0.066666666666667
7764, 1.2666666666667, 0.67333333333333, 0.066666666666667
7765, 1.2666666666667, 0.62, 0.066666666666667
7766, 1.2666666666667, 0.56666666666667, 0.066666666666667
7767, 1.2666666666667, 0.51333333333333, 0.066666666666667
7768, 1.2666666666667, 0.46, 0.066666666666667
7769, 1.2666666666667, 0.40666666666667, 0.066666666666667
7770, 1.2666666666667, 0.35333333333333, 0.066666666666667
7771, 1.3333333333333, 1.0466666666667, 0.066666666666667
7772, 1.3333333333333, 0.99333333333333, 0.066666666666667
7773, 1.3333333333333, 0.94, 0.066666666666667
7774, 1.3333333333333, 0.88666666666667, 0.066666666666667
7775, 1.3333333333333, 0.83333333333333, 0.066666666666667
7776, 1.3333333333333, 0.78, 0.066666666666667
7777, 1.3333333333333, 0.72666666666667, 0.066666666666667
7778, 1.3333333333333, 0.67333333333333, 0.066666666666667
7779, 1.3333333333333, 0.62, 0.066666666666667
7780, 1.3333333333333, 0.56666666666667, 0.066666666666667
7781, 1.3333333333333, 0.51333333333333, 0.066666666666667
7782, 1.3333333333333, 0.46, 0.066666666666667
7783, 1.3333333333333, 0.40666666666667, 0.066666666666667
7784, 1.3333333333333, 0.35333333333333, 0.066666666666667
7785, 1.4, 1.0466666666667, 0.066666666666667
7786, 1.4, 0.99333333333333, 0.066666666666667
7787, 1.4, 0.94, 0.066666666666667
7788, 1.4, 0.88666666666667, 0.066666666666667
7789, 1.4, 0.83333333333333, 0.066666666666667
7790, 1.4, 0.78, 0.066666666666667
7791, 1.4, 0.72666666666667, 0.066666666666667
7792, 1.4, 0.67333333333333, 0.066666666666667
7793, 1.4, 0.62, 0.066666666666667
7794, 1.4, 0.56666666666667, 0.066666666666667
7795, 1.4, 0.51333333333333, 0.066666666666667
7796, 1.4, 0.46, 0.066666666666667
7797, 1.4, 0.40666666666667, 0.066666666666667
7798, 1.4, 0.35333333333333, 0.066666666666667
7799, 1.4666666666667, 1.0466666666667, 0.066666666666667
7800, 1.4666666666667, 0.99333333333333, 0.066666666666667
7801, 1.4666666666667, 0.94, 0.066666666666667
7802, 1.4666666666667, 0.88666666666667, 0.066666666666667
7803, 1.4666666666667, 0.83333333333333, 0.066666666666667
7804, 1.4666666666667, 0.78, 0.066666666666667
7805, 1.4666666666667, 0.72666666666667, 0.066666666666667
7806, 1.4666666666667, 0.67333333333333, 0.066666666666667
7807, 1.4666666666667, 0.62, 0.066666666666667
7808, 1.4666666666667, 0.56666666666667, 0.066666666666667
7809, 1.4666666666667, 0.51333333333333, 0.066666666666667
7810, 1.4666666666667, 0.46, 0.066666666666667
7811, 1.4666666666667, 0.40666666666667, 0.066666666666667
7812, 1.4666666666667, 0.35333333333333, 0.066666666666667
7813, 1.5333333333333, 1.0466666666667, 0.066666666666667
7814, 1.5333333333333, 0.99333333333333, 0.066666666666667
7815, 1.5333333333333, 0.94, 0.066666666666667
7816, 1.5333333333333, 0.88666666666667, 0.066666666666667
7817, 1.5333333333333, 0.83333333333333, 0.066666666666667
7818, 1.5333333333333, 0.78, 0.066666666666667
7819, 1.5333333333333, 0.72666666666667, 0.066666666666667
7820, 1.5333333333333, 0.67333333333333, 0.066666666666667
7821, 1.5333333333333, 0.62, 0.066666666666667
7822, 1.5333333333333, 0.56666666666667, 0.066666666666667
7823, 1.5333333333333, 0.51333333333333, 0.066666666666667
7824, 1.5333333333333, 0.46, 0.066666666666667
7825, 1.5333333333333, 0.40666666666667, 0.066666666666667
7826, 1.5333333333333, 0.35333333333333, 0.066666666666667
7827, 1.6, 1.0466666666667, 0.066666666666667
7828, 1.6, 0.99333333333333, 0.066666666666667
7829, 1.6, 0.94, 0.066666666666667
7830, 1.6, 0.88666666666667, 0.066666666666667
7831, 1.6, 0.83333333333333, 0.066666666666667
7832, 1.6, 0.78, 0.066666666666667
7833, 1.6, 0.72666666666667, 0.066666666666667
7834, 1.6, 0.67333333333333, 0.066666666666667
7835, 1.6, 0.62, 0.066666666666667
7836, 1.6, 0.56666666666667, 0.066666666666667
7837, 1.6, 0.51333333333333, 0.066666666666667
7838, 1.6, 0.46, 0.066666666666667
7839, 1.6, 0.40666666666667, 0.066666666666667
7840, 1.6, 0.35333333333333, 0.066666666666667
7841, 1.6666666666667, 1.0466666666667, 0.066666666666667
7842, 1.6666666666667, 0.99333333333333, 0.066666666666667
7843, 1.6666666666667, 0.94, 0.066666666666667
7844, 1.6666666666667, 0.88666666666667, 0.066666666666667
7845, 1.6666666666667, 0.83333333333333, 0.066666666666667
7846, 1.6666666666667, 0.78, 0.066666666666667
7847, 1.6666666666667, 0.72666666666667, 0.066666666666667
7848, 1.6666666666667, 0.67333333333333, 0.066666666666667
7849, 1.6666666666667, 0.62, 0.066666666666667
7850, 1.6666666666667, 0.56666666666667, 0.066666666666667
7851, 1.6666666666667, 0.51333333333333, 0.066666666666667
7852, 1.6666666666667, 0.46, 0.066666666666667
7853, 1.6666666666667, 0.40666666666667, 0.066666666666667
7854, 1.6666666666667, 0.35333333333333, 0.066666666666667
7855, 1.7333333333333, 1.0466666666667, 0.066666666666667
7856, 1.7333333333333, 0.99333333333333, 0.066666666666667
7857, 1.7333333333333, 0.94, 0.066666666666667
7858, 1.7333333333333, 0.88666666666667, 0.066666666666667
7859, 1.7333333333333, 0.83333333333333, 0.066666666666667
7860, 1.7333333333333, 0.78, 0.066666666666667
7861, 1.7333333333333, 0.72666666666667, 0.066666666666667
7862, 1.7333333333333, 0.67333333333333, 0.066666666666667
7863, 1.7333333333333, 0.62, 0.066666666666667
7864, 1.7333333333333, 0.56666666666667, 0.066666666666667
7865, 1.7333333333333, 0.51333333333333, 0.066666666666667
7866, 1.7333333333333, 0.46, 0.066666666666667
7867, 1.7333333333333, 0.40666666666667, 0.066666666666667
7868, 1.7333333333333, 0.35333333333333, 0.066666666666667
7869, 1.8, 1.0466666666667, 0.066666666666667
7870, 1.8, 0.99333333333333, 0.066666666666667
7871, 1.8, 0.94, 0.066666666666667
7872, 1.8, 0.88666666666667, 0.066666666666667
7873, 1.8, 0.83333333333333, 0.066666666666667
7874, 1.8, 0.78, 0.066666666666667
7875, 1.8, 0.72666666666667, 0.066666666666667
7876, 1.8, 0.67333333333333, 0.066666666666667
7877, 1.8, 0.62, 0.066666666666667
7878, 1.8, 0.56666666666667, 0.066666666666667
7879, 1.8, 0.51333333333333, 0.066666666666667
7880, 1.8, 0.46, 0.066666666666667
7881, 1.8, 0.40666666666667, 0.066666666666667
7882, 1.8, 0.35333333333333, 0.066666666666667
7883, 1.8666666666667, 1.0466666666667, 0.066666666666667
7884, 1.8666666666667, 0.99333333333333, 0.066666666666667
7885, 1.8666666666667, 0.94, 0.066666666666667
7886, 1.8666666666667, 0.88666666666667, 0.066666666666667
7887, 1.8666666666667, 0.83333333333333, 0.066666666666667
7888, 1.8666666666667, 0.78, 0.066666666666667
7889, 1.8666666666667, 0.72666666666667, 0.066666666666667
7890, 1.8666666666667, 0.67333333333333, 0.066666666666667
7891, 1.8666666666667, 0.62, 0.066666666666667
7892, 1.8666666666667, 0.56666666666667, 0.066666666666667
7893, 1.8666666666667, 0.51333333333333, 0.066666666666667
7894, 1.8666666666667, 0.46, 0.066666666666667
7895, 1.8666666666667, 0.40666666666667, 0.066666666666667
7896, 1.8666666666667, 0.35333333333333, 0.066666666666667
7897, 1.9333333333333, 1.0466666666667, 0.066666666666667
7898, 1.9333333333333, 0.99333333333333, 0.066666666666667
7899, 1.9333333333333, 0.94, 0.066666666666667
7900, 1.9333333333333, 0.88666666666667, 0.066666666666667
7901, 1.9333333333333, 0.83333333333333, 0.066666666666667
7902, 1.9333333333333, 0.78, 0.066666666666667
7903, 1.9333333333333, 0.72666666666667, 0.066666666666667
7904, 1.9333333333333, 0.67333333333333, 0.066666666666667
7905, 1.9333333333333, 0.62, 0.066666666666667
7906, 1.9333333333333, 0.56666666666667, 0.066666666666667
7907, 1.9333333333333, 0.51333333333333, 0.066666666666667
7908, 1.9333333333333, 0.46, 0.066666666666667
7909, 1.9333333333333, 0.40666666666667, 0.066666666666667
7910, 1.9333333333333, 0.35333333333333, 0.066666666666667
7911, 2, 1.0466666666667, 0.066666666666667
7912, 2, 0.99333333333333, 0.066666666666667
7913, 2, 0.94, 0.066666666666667
7914, 2, 0.88666666666667, 0.066666666666667
7915, 2, 0.83333333333333, 0.066666666666667
7916, 2, 0.78, 0.066666666666667
7917, 2, 0.72666666666667, 0.066666666666667
7918, 2, 0.67333333333333, 0.066666666666667
7919, 2, 0.62, 0.066666666666667
7920, 2, 0.56666666666667, 0.066666666666667
7921, 2, 0.51333333333333, 0.066666666666667
7922, 2, 0.46, 0.066666666666667
7923, 2, 0.40666666666667, 0.066666666666667
7924, 2, 0.35333333333333, 0.066666666666667
7925, 2.0666666666667, 1.0466666666667, 0.066666666666667
7926, 2.0666666666667, 0.99333333333333, 0.066666666666667
7927, 2.0666666666667, 0.94, 0.066666666666667
7928, 2.0666666666667, 0.88666666666667, 0.066666666666667
7929, 2.0666666666667, 0.83333333333333, 0.066666666666667
7930, 2.0666666666667, 0.78, 0.066666666666667
7931, 2.0666666666667, 0.72666666666667, 0.066666666666667
7932, 2.0666666666667, 0.67333333333333, 0.066666666666667
7933, 2.0666666666667, 0.62, 0.066666666666667
7934, 2.0666666666667, 0.56666666666667, 0.066666666666667
7935, 2.0666666666667, 0.51333333333333, 0.066666666666667
7936, 2.0666666666667, 0.46, 0.066666666666667
7937, 2.0666666666667, 0.40666666666667, 0.066666666666667
7938, 2.0666666666667, 0.35333333333333, 0.066666666666667
7939, 2.1333333333333, 1.0466666666667, 0.066666666666667
7940, 2.1333333333333, 0.99333333333333, 0.066666666666667
7941, 2.1333333333333, 0.94, 0.066666666666667
7942, 2.1333333333333, 0.88666666666667, 0.066666666666667
7943, 2.1333333333333, 0.83333333333333, 0.066666666666667
7944, 2.1333333333333, 0.78, 0.066666666666667
7945, 2.1333333333333, 0.72666666666667, 0.066666666666667
7946, 2.1333333333333, 0.67333333333333, 0.066666666666667
7947, 2.1333333333333, 0.62, 0.066666666666667
7948, 2.1333333333333, 0.56666666666667, 0.066666666666667
7949, 2.1333333333333, 0.51333333333333, 0.066666666666667
7950, 2.1333333333333, 0.46, 0.066666666666667
7951, 2.1333333333333, 0.40666666666667, 0.066666666666667
7952, 2.1333333333333, 0.35333333333333, 0.066666666666667
7953, 1.2666666666667, 1.0466666666667, 0.1
7954, 1.2666666666667, 0.99333333333333, 0.1
7955, 1.2666666666667, 0.94, 0.1
7956, 1.2666666666667, 0.88666666666667, 0.1
7957, 1.2666666666667, 0.83333333333333, 0.1
7958, 1.2666666666667, 0.78, 0.1
7959, 1.2666666666667, 0.72666666666667, 0.1
7960, 1.2666666666667, 0.67333333333333, 0.1
7961, 1.2666666666667, 0.62, 0.1
7962, 1.2666666666667, 0.56666666666667, 0.1
7963, 1.2666666666667, 0.51333333333333, 0.1
7964, 1.2666666666667, 0.46, 0.1
7965, 1.2666666666667, 0.40666666666667, 0.1
7966, 1.2666666666667, 0.35333333333333, 0.1
7967, 1.3333333333333, 1.0466666666667, 0.1
7968, 1.3333333333333, 0.99333333333333, 0.1
7969, 1.3333333333333, 0.94, 0.1
7970, 1.3333333333333, 0.88666666666667, 0.1
7971, 1.3333333333333, 0.83333333333333, 0.1
7972, 1.3333333333333, 0.78, 0.1
7973, 1.3333333333333, 0.72666666666667, 0.1
7974, 1.3333333333333, 0.67333333333333, 0.1
7975, 1.3333333333333, 0.62, 0.1
7976, 1.3333333333333, 0.56666666666667, 0.1
7977, 1.3333333333333, 0.51333333333333, 0.1
7978, 1.3333333333333, 0.46, 0.1
7979, 1.3333333333333, 0.40666666666667, 0.1
7980, 1.3333333333333, 0.35333333333333, 0.1
7981, 1.4, 1.0466666666667, 0.1
7982, 1.4, 0.99333333333333, 0.1
7983, 1.4, 0.94, 0.1
7984, 1.4, 0.88666666666667, 0.1
7985, 1.4, 0.83333333333333, 0.1
7986, 1.4, 0.78, 0.1
7987, 1.4, 0.72666666666667, 0.1
7988, 1.4, 0.67333333333333, 0.1
7989, 1.4, 0.62, 0.1
7990, 1.4, 0.56666666666667, 0.1
7991, 1.4, 0.51333333333333, 0.1
7992, 1.4, 0.46, 0.1
7993, 1.4, 0.40666666666667, 0.1
7994, 1.4, 0.35333333333333, 0.1
7995, 1.4666666666667, 1.0466666666667, 0.1
7996, 1.4666666666667, 0.99333333333333, 0.1
7997, 1.4666666666667, 0.94, 0.1
7998, 1.4666666666667, 0.88666666666667, 0.1
7999, 1.4666666666667, 0.83333333333333, 0.1
8000, 1.4666666666667, 0.78, 0.1
8001, 1.4666666666667, 0.72666666666667, 0.1
8002, 1.4666666666667, 0.67333333333333, 0.1
8003, 1.4666666666667, 0.62, 0.1
8004, 1.4666666666667, 0.56666666666667, 0.1
8005, 1.4666666666667, 0.51333333333333, 0.1
8006, 1.4666666666667, 0.46, 0.1
8007, 1.4666666666667, 0.40666666666667, 0.1
8008, 1.4666666666667, 0.35333333333333, 0.1
8009, 1.5333333333333, 1.0466666666667, 0.1
8010, 1.5333333333333, 0.99333333333333, 0.1
8011, 1.5333333333333, 0.94, 0.1
8012, 1.5333333333333, 0.88666666666667, 0.1
8013, 1.5333333333333, 0.83333333333333, 0.1
8014, 1.5333333333333, 0.78, 0.1
8015, 1.5333333333333, 0.72666666666667, 0.1
8016, 1.5333333333333, 0.67333333333333, 0.1
8017, 1.5333333333333, 0.62, 0.1
8018, 1.5333333333333, 0.56666666666667, 0.1
8019, 1.5333333333333, 0.51333333333333, 0.1
8020, 1.5333333333333, 0.46, 0.1
8021, 1.5333333333333, 0.40666666666667, 0.1
8022, 1.5333333333333, 0.35333333333333, 0.1
8023, 1.6, 1.0466666666667, 0.1
8024, 1.6, 0.99333333333333, 0.1
8025, 1.6, 0.94, 0.1
8026, 1.6, 0.88666666666667, 0.1
8027, 1.6, 0.83333333333333, 0.1
8028, 1.6, 0.78, 0.1
8029, 1.6, 0.72666666666667, 0.1
8030, 1.6, 0.67333333333333, 0.1
8031, 1.6, 0.62, 0.1
8032, 1.6, 0.56666666666667, 0.1
8033, 1.6, 0.51333333333333, 0.1
8034, 1.6, 0.46, 0.1
8035, 1.6, 0.40666666666667, 0.1
8036, 1.6, 0.35333333333333, 0.1
8037, 1.6666666666667, 1.0466666666667, 0.1
8038, 1.6666666666667, 0.99333333333333, 0.1
8039, 1.6666666666667, 0.94, 0.1
8040, 1.6666666666667, 0.88666666666667, 0.1
8041, 1.6666666666667, 0.83333333333333, 0.1
8042, 1.6666666666667, 0.78, 0.1
8043, 1.6666666666667, 0.72666666666667, 0.1
8044, 1.6666666666667, 0.67333333333333, 0.1
8045, 1.6666666666667, 0.62, 0.1
8046, 1.6666666666667, 0.56666666666667, 0.1
8047, 1.6666666666667, 0.51333333333333, 0.1
8048, 1.6666666666667, 0.46, 0.1
8049, 1.6666666666667, 0.40666666666667, 0.1
8050, 1.6666666666667, 0.35333333333333, 0.1
8051, 1.7333333333333, 1.0466666666667, 0.1
8052, 1.7333333333333, 0.99333333333333, 0.1
8053, 1.7333333333333, 0.94, 0.1
8054, 1.7333333333333, 0.88666666666667, 0.1
8055, 1.7333333333333, 0.83333333333333, 0.1
8056, 1.7333333333333, 0.78, 0.1
8057, 1.7333333333333, 0.72666666666667, 0.1
8058, 1.7333333333333, 0.67333333333333, 0.1
8059, 1.7333333333333, 0.62, 0.1
8060, 1.7333333333333, 0.56666666666667, 0.1
8061, 1.7333333333333, 0.51333333333333, 0.1
8062, 1.7333333333333, 0.46, 0.1
8063, 1.7333333333333, 0.40666666666667, 0.1
8064, 1.7333333333333, 0.35333333333333, 0.1
8065, 1.8, 1.0466666666667, 0.1
8066, 1.8, 0.99333333333333, 0.1
8067, 1.8, 0.94, 0.1
8068, 1.8, 0.88666666666667, 0.1
8069, 1.8, 0.83333333333333, 0.1
8070, 1.8, 0.78, 0.1
8071, 1.8, 0.72666666666667, 0.1
8072, 1.8, 0.67333333333333, 0.1
8073, 1.8, 0.62, 0.1
8074, 1.8, 0.56666666666667, 0.1
8075, 1.8, 0.51333333333333, 0.1
8076, 1.8, 0.46, 0.1
8077, 1.8, 0.40666666666667, 0.1
8078, 1.8, 0.35333333333333, 0.1
8079, 1.8666666666667, 1.0466666666667, 0.1
8080, 1.8666666666667, 0.99333333333333, 0.1
8081, 1.8666666666667, 0.94, 0.1
8082, 1.8666666666667, 0.88666666666667, 0.1
8083, 1.8666666666667, 0.83333333333333, 0.1
8084, 1.8666666666667, 0.78, 0.1
8085, 1.8666666666667, 0.72666666666667, 0.1
8086, 1.8666666666667, 0.67333333333333, 0.1
8087, 1.8666666666667, 0.62, 0.1
8088, 1.8666666666667, 0.56666666666667, 0.1
8089, 1.8666666666667, 0.51333333333333, 0.1
8090, 1.8666666666667, 0.46, 0.1
8091, 1.8666666666667, 0.40666666666667, 0.1
8092, 1.8666666666667, 0.35333333333333, 0.1
8093, 1.9333333333333, 1.0466666666667, 0.1
8094, 1.9333333333333, 0.99333333333333, 0.1
8095, 1.9333333333333, 0.94, 0.1
8096, 1.9333333333333, 0.88666666666667, 0.1
8097, 1.9333333333333, 0.83333333333333, 0.1
8098, 1.9333333333333, 0.78, 0.1
8099, 1.9333333333333, 0.72666666666667, 0.1
8100, 1.9333333333333, 0.67333333333333, 0.1
8101, 1.9333333333333, 0.62, 0.1
8102, 1.9333333333333, 0.56666666666667, 0.1
8103, 1.9333333333333, 0.51333333333333, 0.1
8104, 1.9333333333333, 0.46, 0.1
8105, 1.9333333333333, 0.40666666666667, 0.1
8106, 1.9333333333333, 0.35333333333333, 0.1
8107, 2, 1.0466666666667, 0.1
8108, 2, 0.99333333333333, 0.1
8109, 2, 0.94, 0.1
8110, 2, 0.88666666666667, 0.1
8111, 2, 0.83333333333333, 0.1
8112, 2, 0.78, 0.1
8113, 2, 0.72666666666667, 0.1
8114, 2, 0.67333333333333, 0.1
8115, 2, 0.62, 0.1
8116, 2, 0.56666666666667, 0.1
8117, 2, 0.51333333333333, 0.1
8118, 2, 0.46, 0.1
8119, 2, 0.40666666666667, 0.1
8120, 2, 0.35333333333333, 0.1
8121, 2.0666666666667, 1.0466666666667, 0.1
8122, 2.0666666666667, 0.99333333333333, 0.1
8123, 2.0666666666667, 0.94, 0.1
8124, 2.0666666666667, 0.88666666666667, 0.1
8125, 2.0666666666667, 0.83333333333333, 0.1
8126, 2.0666666666667, 0.78, 0.1
8127, 2.0666666666667, 0.72666666666667, 0.1
8128, 2.0666666666667, 0.67333333333333, 0.1
8129, 2.0666666666667, 0.62, 0.1
8130, 2.0666666666667, 0.56666666666667, 0.1
8131, 2.0666666666667, 0.51333333333333, 0.1
8132, 2.0666666666667, 0.46, 0.1
8133, 2.0666666666667, 0.40666666666667, 0.1
8134, 2.0666666666667, 0.35333333333333, 0.1
8135, 2.1333333333333, 1.0466666666667, 0.1
8136, 2.1333333333333, 0.99333333333333, 0.1
8137, 2.1333333333333, 0.94, 0.1
8138, 2.1333333333333, 0.88666666666667, 0.1
8139, 2.1333333333333, 0.83333333333333, 0.1
8140, 2.1333333333333, 0.78, 0.1
8141, 2.1333333333333, 0.72666666666667, 0.1
8142, 2.1333333333333, 0.67333333333333, 0.1
8143, 2.1333333333333, 0.62, 0.1
8144, 2.1333333333333, 0.56666666666667, 0.1
8145, 2.1333333333333, 0.51333333333333, 0.1
8146, 2.1333333333333, 0.46, 0.1
8147, 2.1333333333333, 0.40666666666667, 0.1
8148, 2.1333333333333, 0.35333333333333, 0.1
8149, 1.2666666666667, 1.0466666666667, 0.13333333333333
8150, 1.2666666666667, 0.99333333333333, 0.13333333333333
8151, 1.2666666666667, 0.94, 0.13333333333333
8152, 1.2666666666667, 0.88666666666667, 0.13333333333333
8153, 1.2666666666667, 0.83333333333333, 0.13333333333333
8154, 1.2666666666667, 0.78, 0.13333333333333
8155, 1.2666666666667, 0.72666666666667, 0.13333333333333
8156, 1.2666666666667, 0.67333333333333, 0.13333333333333
8157, 1.2666666666667, 0.62, 0.13333333333333
8158, 1.2666666666667, 0.56666666666667, 0.13333333333333
8159, 1.2666666666667, 0.51333333333333, 0.13333333333333
8160, 1.2666666666667, 0.46, 0.13333333333333
8161, 1.2666666666667, 0.40666666666667, 0.13333333333333
8162, 1.2666666666667, 0.35333333333333, 0.13333333333333
8163, 1.3333333333333, 1.0466666666667, 0.13333333333333
8164, 1.3333333333333, 0.99333333333333, 0.13333333333333
8165, 1.3333333333333, 0.94, 0.13333333333333
8166, 1.3333333333333, 0.88666666666667, 0.13333333333333
8167, 1.3333333333333, 0.83333333333333, 0.13333333333333
8168, 1.3333333333333, 0.78, 0.13333333333333
8169, 1.3333333333333, 0.72666666666667, 0.13333333333333
8170, 1.3333333333333, 0.67333333333333, 0.13333333333333
8171, 1.3333333333333, 0.62, 0.13333333333333
8172, 1.3333333333333, 0.56666666666667, 0.13333333333333
8173, 1.3333333333333, 0.51333333333333, 0.13333333333333
8174, 1.3333333333333, 0.46, 0.13333333333333
8175, 1.3333333333333, 0.40666666666667, 0.13333333333333
8176, 1.3333333333333, 0.35333333333333, 0.13333333333333
8177, 1.4, 1.0466666666667, 0.13333333333333
8178, 1.4, 0.99333333333333, 0.13333333333333
8179, 1.4, 0.94, 0.13333333333333
8180, 1.4, 0.88666666666667, 0.13333333333333
8181, 1.4, 0.83333333333333, 0.13333333333333
8182, 1.4, 0.78, 0.13333333333333
8183, 1.4, 0.72666666666667, 0.13333333333333
8184, 1.4, 0.67333333333333, 0.13333333333333
8185, 1.4, 0.62, 0.13333333333333
8186, 1.4, 0.56666666666667, 0.13333333333333
8187, 1.4, 0.51333333333333, 0.13333333333333
8188, 1.4, 0.46, 0.13333333333333
8189, 1.4, 0.40666666666667, 0.13333333333333
8190, 1.4, 0.35333333333333, 0.13333333333333
8191, 1.4666666666667, 1.0466666666667, 0.13333333333333
8192, 1.4666666666667, 0.99333333333333, 0.13333333333333
8193, 1.4666666666667, 0.94, 0.13333333333333
8194, 1.4666666666667, 0.88666666666667, 0.13333333333333
8195, 1.4666666666667, 0.83333333333333, 0.13333333333333
8196, 1.4666666666667, 0.78, 0.13333333333333
8197, 1.4666666666667, 0.72666666666667, 0.13333333333333
8198, 1.4666666666667, 0.67333333333333, 0.13333333333333
8199, 1.4666666666667, 0.62, 0.13333333333333
8200, 1.4666666666667, 0.56666666666667, 0.13333333333333
8201, 1.4666666666667, 0.51333333333333, 0.13333333333333
8202, 1.4666666666667, 0.46, 0.13333333333333
8203, 1.4666666666667, 0.40666666666667, 0.13333333333333
8204, 1.4666666666667, 0.35333333333333, 0.13333333333333
8205, 1.5333333333333, 1.0466666666667, 0.13333333333333
8206, 1.5333333333333, 0.99333333333333, 0.13333333333333
8207, 1.5333333333333, 0.94, 0.13333333333333
8208, 1.5333333333333, 0.88666666666667, 0.13333333333333
8209, 1.5333333333333, 0.83333333333333, 0.13333333333333
8210, 1.5333333333333, 0.78, 0.13333333333333
8211, 1.5333333333333, 0.72666666666667, 0.13333333333333
8212, 1.5333333333333, 0.67333333333333, 0.13333333333333
8213, 1.5333333333333, 0.62, 0.13333333333333
8214, 1.5333333333333, 0.56666666666667, 0.13333333333333
8215, 1.5333333333333, 0.51333333333333, 0.13333333333333
8216, 1.5333333333333, 0.46, 0.13333333333333
8217, 1.5333333333333, 0.40666666666667, 0.13333333333333
8218, 1.5333333333333, 0.35333333333333, 0.13333333333333
8219, 1.6, 1.0466666666667, 0.13333333333333
8220, 1.6, 0.99333333333333, 0.13333333333333
8221, 1.6, 0.94, 0.13333333333333
8222, 1.6, 0.88666666666667, 0.13333333333333
8223, 1.6, 0.83333333333333, 0.13333333333333
8224, 1.6, 0.78, 0.13333333333333
8225, 1.6, 0.72666666666667, 0.13333333333333
8226, 1.6, 0.67333333333333, 0.13333333333333
8227, 1.6, 0.62, 0.13333333333333
8228, 1.6, 0.56666666666667, 0.13333333333333
8229, 1.6, 0.51333333333333, 0.13333333333333
8230, 1.6, 0.46, 0.13333333333333
8231, 1.6, 0.40666666666667, 0.13333333333333
8232, 1.6, 0.35333333333333, 0.13333333333333
8233, 1.6666666666667, 1.0466666666667, 0.13333333333333
8234, 1.6666666666667, 0.99333333333333, 0.13333333333333
8235, 1.6666666666667, 0.94, 0.13333333333333
8236, 1.6666666666667, 0.88666666666667, 0.13333333333333
8237, 1.6666666666667, 0.83333333333333, 0.13333333333333
8238, 1.6666666666667, 0.78, 0.13333333333333
8239, 1.6666666666667, 0.72666666666667, 0.13333333333333
8240, 1.6666666666667, 0.67333333333333, 0.13333333333333
8241, 1.6666666666667, 0.62, 0.13333333333333
8242, 1.6666666666667, 0.56666666666667, 0.13333333333333
8243, 1.6666666666667, 0.51333333333333, 0.13333333333333
8244, 1.6666666666667, 0.46, 0.13333333333333
8245, 1.6666666666667, 0.40666666666667, 0.13333333333333
8246, 1.6666666666667, 0.35333333333333, 0.13333333333333
8247, 1.7333333333333, 1.0466666666667, 0.13333333333333
8248, 1.7333333333333, 0.99333333333333, 0.13333333333333
8249, 1.7333333333333, 0.94, 0.13333333333333
8250, 1.7333333333333, 0.88666666666667, 0.13333333333333
8251, 1.7333333333333, 0.83333333333333, 0.13333333333333
8252, 1.7333333333333, 0.78, 0.13333333333333
8253, 1.7333333333333, 0.72666666666667, 0.13333333333333
8254, 1.7333333333333, 0.67333333333333, 0.13333333333333
8255, 1.7333333333333, 0.62, 0.13333333333333
8256, 1.7333333333333, 0.56666666666667, 0.13333333333333
8257, 1.7333333333333, 0.51333333333333, 0.13333333333333
8258, 1.7333333333333, 0.46, 0.13333333333333
8259, 1.7333333333333, 0.40666666666667, 0.13333333333333
8260, 1.7333333333333, 0.35333333333333, 0.13333333333333
8261, 1.8, 1.0466666666667, 0.13333333333333
8262, 1.8, 0.99333333333333, 0.13333333333333
8263, 1.8, 0.94, 0.13333333333333
8264, 1.8, 0.88666666666667, 0.13333333333333
8265, 1.8, 0.83333333333333, 0.13333333333333
8266, 1.8, 0.78, 0.13333333333333
8267, 1.8, 0.72666666666667, 0.13333333333333
8268, 1.8, 0.67333333333333, 0.13333333333333
8269, 1.8, 0.62, 0.13333333333333
8270, 1.8, 0.56666666666667, 0.13333333333333
8271, 1.8, 0.51333333333333, 0.13333333333333
8272, 1.8, 0.46, 0.13333333333333
8273, 1.8, 0.40666666666667, 0.13333333333333
8274, 1.8, 0.35333333333333, 0.13333333333333
8275, 1.8666666666667, 1.0466666666667, 0.13333333333333
8276, 1.8666666666667, 0.99333333333333, 0.13333333333333
8277, 1.8666666666667, 0.94, 0.13333333333333
8278, 1.8666666666667, 0.88666666666667, 0.13333333333333
8279, 1.8666666666667, 0.83333333333333, 0.13333333333333
8280, 1.8666666666667, 0.78, 0.13333333333333
8281, 1.8666666666667, 0.72666666666667, 0.13333333333333
8282, 1.8666666666667, 0.67333333333333, 0.13333333333333
8283, 1.8666666666667, 0.62, 0.13333333333333
8284, 1.8666666666667, 0.56666666666667, 0.13333333333333
8285, 1.8666666666667, 0.51333333333333, 0.13333333333333
8286, 1.8666666666667, 0.46, 0.13333333333333
8287, 1.8666666666667, 0.40666666666667, 0.13333333333333
8288, 1.8666666666667, 0.35333333333333, 0.13333333333333
8289, 1.9333333333333, 1.0466666666667, 0.13333333333333
8290, 1.9333333333333, 0.99333333333333, 0.13333333333333
8291, 1.9333333333333, 0.94, 0.13333333333333
8292, 1.9333333333333, 0.88666666666667, 0.13333333333333
8293, 1.9333333333333, 0.83333333333333, 0.13333333333333
8294, 1.9333333333333, 0.78, 0.13333333333333
8295, 1.9333333333333, 0.72666666666667, 0.13333333333333
8296, 1.9333333333333, 0.67333333333333, 0.13333333333333
8297, 1.9333333333333, 0.62, 0.13333333333333
8298, 1.9333333333333, 0.56666666666667, 0.13333333333333
8299, 1.9333333333333, 0.51333333333333, 0.13333333333333
8300, 1.9333333333333, 0.46, 0.13333333333333
8301, 1.9333333333333, 0.40666666666667, 0.13333333333333
8302, 1.9333333333333, 0.35333333333333, 0.13333333333333
8303, 2, 1.0466666666667, 0.13333333333333
8304, 2, 0.99333333333333, 0.13333333333333
8305, 2, 0.94, 0.13333333333333
8306, 2, 0.88666666666667, 0.13333333333333
8307, 2, 0.83333333333333, 0.13333333333333
8308, 2, 0.78, 0.13333333333333
8309, 2, 0.72666666666667, 0.13333333333333
8310, 2, 0.67333333333333, 0.13333333333333
8311, 2, 0.62, 0.13333333333333
8312, 2, 0.56666666666667, 0.13333333333333
8313, 2, 0.51333333333333, 0.13333333333333
8314, 2, 0.46, 0.13333333333333
8315, 2, 0.40666666666667, 0.13333333333333
8316, 2, 0.35333333333333, 0.13333333333333
8317, 2.0666666666667, 1.0466666666667, 0.13333333333333
8318, 2.0666666666667, 0.99333333333333, 0.13333333333333
8319, 2.0666666666667, 0.94, 0.13333333333333
8320, 2.0666666666667, 0.88666666666667, 0.13333333333333
8321, 2.0666666666667, 0.83333333333333, 0.13333333333333
8322, 2.0666666666667, 0.78, 0.13333333333333
8323, 2.0666666666667, 0.72666666666667, 0.13333333333333
8324, 2.0666666666667, 0.67333333333333, 0.13333333333333
8325, 2.0666666666667, 0.62, 0.13333333333333
8326, 2.0666666666667, 0.56666666666667, 0.13333333333333
8327, 2.0666666666667, 0.51333333333333, 0.13333333333333
8328, 2.0666666666667, 0.46, 0.13333333333333
8329, 2.0666666666667, 0.40666666666667, 0.13333333333333
8330, 2.0666666666667, 0.35333333333333, 0.13333333333333
8331, 2.1333333333333, 1.0466666666667, 0.13333333333333
8332, 2.1333333333333, 0.99333333333333, 0.13333333333333
8333, 2.1333333333333, 0.94, 0.13333333333333
8334, 2.1333333333333, 0.88666666666667, 0.13333333333333
8335, 2.1333333333333, 0.83333333333333, 0.13333333333333
8336, 2.1333333333333, 0.78, 0.13333333333333
8337, 2.1333333333333, 0.72666666666667, 0.13333333333333
8338, 2.1333333333333, 0.67333333333333, 0.13333333333333
8339, 2.1333333333333, 0.62, 0.13333333333333
8340, 2.1333333333333, 0.56666666666667, 0.13333333333333
8341, 2.1333333333333, 0.51333333333333, 0.13333333333333
8342, 2.1333333333333, 0.46, 0.13333333333333
8343, 2.1333333333333, 0.40666666666667, 0.13333333333333
8344, 2.1333333333333, 0.35333333333333, 0.13333333333333
8345, 1.2666666666667, 1.0466666666667, 0.16666666666667
8346, 1.2666666666667, 0.99333333333333, 0.16666666666667
8347, 1.2666666666667, 0.94, 0.16666666666667
8348, 1.2666666666667, 0.88666666666667, 0.16666666666667
8349, 1.2666666666667, 0.83333333333333, 0.16666666666667
8350, 1.2666666666667, 0.78, 0.16666666666667
8351, 1.2666666666667, 0.72666666666667, 0.16666666666667
8352, 1.2666666666667, 0.67333333333333, 0.16666666666667
8353, 1.2666666666667, 0.62, 0.16666666666667
8354, 1.2666666666667, 0.56666666666667, 0.16666666666667
8355, 1.2666666666667, 0.51333333333333, 0.16666666666667
8356, 1.2666666666667, 0.46, 0.16666666666667
8357, 1.2666666666667, 0.40666666666667, 0.16666666666667
8358, 1.2666666666667, 0.35333333333333, 0.16666666666667
8359, 1.3333333333333, 1.0466666666667, 0.16666666666667
8360, 1.3333333333333, 0.99333333333333, 0.16666666666667
8361, 1.3333333333333, 0.94, 0.16666666666667
8362, 1.3333333333333, 0.88666666666667, 0.16666666666667
8363, 1.3333333333333, 0.83333333333333, 0.16666666666667
8364, 1.3333333333333, 0.78, 0.16666666666667
8365, 1.3333333333333, 0.72666666666667, 0.16666666666667
8366, 1.3333333333333, 0.67333333333333, 0.16666666666667
8367, 1.3333333333333, 0.62, 0.16666666666667
8368, 1.3333333333333, 0.56666666666667, 0.16666666666667
8369, 1.3333333333333, 0.51333333333333, 0.16666666666667
8370, 1.3333333333333, 0.46, 0.16666666666667
8371, 1.3333333333333, 0.40666666666667, 0.16666666666667
8372, 1.3333333333333, 0.35333333333333, 0.16666666666667
8373, 1.4, 1.0466666666667, 0.16666666666667
8374, 1.4, 0.99333333333333, 0.16666666666667
8375, 1.4, 0.94, 0.16666666666667
8376, 1.4, 0.88666666666667, 0.16666666666667
8377, 1.4, 0.83333333333333, 0.16666666666667
8378, 1.4, 0.78, 0.16666666666667
8379, 1.4, 0.72666666666667, 0.16666666666667
8380, 1.4, 0.67333333333333, 0.16666666666667
8381, 1.4, 0.62, 0.16666666666667
8382, 1.4, 0.56666666666667, 0.16666666666667
8383, 1.4, 0.51333333333333, 0.16666666666667
8384, 1.4, 0.46, 0.16666666666667
8385, 1.4, 0.40666666666667, 0.16666666666667
8386, 1.4, 0.35333333333333, 0.16666666666667
8387, 1.4666666666667, 1.0466666666667, 0.16666666666667
8388, 1.4666666666667, 0.99333333333333, 0.16666666666667
8389, 1.4666666666667, 0.94, 0.16666666666667
8390, 1.4666666666667, 0.88666666666667, 0.16666666666667
8391, 1.4666666666667, 0.83333333333333, 0.16666666666667
8392, 1.4666666666667, 0.78, 0.16666666666667
8393, 1.4666666666667, 0.72666666666667, 0.16666666666667
8394, 1.4666666666667, 0.67333333333333, 0.16666666666667
8395, 1.4666666666667, 0.62, 0.16666666666667
8396, 1.4666666666667, 0.56666666666667, 0.16666666666667
8397, 1.4666666666667, 0.51333333333333, 0.16666666666667
8398, 1.4666666666667, 0.46, 0.16666666666667
8399, 1.4666666666667, 0.40666666666667, 0.16666666666667
8400, 1.4666666666667, 0.35333333333333, 0.16666666666667
8401, 1.5333333333333, 1.0466666666667, 0.16666666666667
8402, 1.5333333333333, 0.99333333333333, 0.16666666666667
8403, 1.5333333333333, 0.94, 0.16666666666667
8404, 1.5333333333333, 0.88666666666667, 0.16666666666667
8405, 1.5333333333333, 0.83333333333333, 0.16666666666667
8406, 1.5333333333333, 0.78, 0.16666666666667
8407, 1.5333333333333, 0.72666666666667, 0.16666666666667
8408, 1.5333333333333, 0.67333333333333, 0.16666666666667
8409, 1.5333333333333, 0.62, 0.16666666666667
8410, 1.5333333333333, 0.56666666666667, 0.16666666666667
8411, 1.5333333333333, 0.51333333333333, 0.16666666666667
8412, 1.5333333333333, 0.46, 0.16666666666667
8413, 1.5333333333333, 0.40666666666667, 0.16666666666667
8414, 1.5333333333333, 0.35333333333333, 0.16666666666667
8415, 1.6, 1.0466666666667, 0.16666666666667
8416, 1.6, 0.99333333333333, 0.16666666666667
8417, 1.6, 0.94, 0.16666666666667
8418, 1.6, 0.88666666666667, 0.16666666666667
8419, 1.6, 0.83333333333333, 0.16666666666667
8420, 1.6, 0.78, 0.16666666666667
8421, 1.6, 0.72666666666667, 0.16666666666667
8422, 1.6, 0.67333333333333, 0.16666666666667
8423, 1.6, 0.62, 0.16666666666667
8424, 1.6, 0.56666666666667, 0.16666666666667
8425, 1.6, 0.51333333333333, 0.16666666666667
8426, 1.6, 0.46, 0.16666666666667
8427, 1.6, 0.40666666666667, 0.16666666666667
8428, 1.6, 0.35333333333333, 0.16666666666667
8429, 1.6666666666667, 1.0466666666667, 0.16666666666667
8430, 1.6666666666667, 0.99333333333333, 0.16666666666667
8431, 1.6666666666667, 0.94, 0.16666666666667
8432, 1.6666666666667, 0.88666666666667, 0.16666666666667
8433, 1.6666666666667, 0.83333333333333, 0.16666666666667
8434, 1.6666666666667, 0.78, 0.16666666666667
8435, 1.6666666666667, 0.72666666666667, 0.16666666666667
8436, 1.6666666666667, 0.67333333333333, 0.16666666666667
8437, 1.6666666666667, 0.62, 0.16666666666667
8438, 1.6666666666667, 0.56666666666667, 0.16666666666667
8439, 1.6666666666667, 0.51333333333333, 0.16666666666667
8440, 1.6666666666667, 0.46, 0.16666666666667
8441, 1.6666666666667, 0.40666666666667, 0.16666666666667
8442, 1.6666666666667, 0.35333333333333, 0.16666666666667
8443, 1.7333333333333, 1.0466666666667, 0.16666666666667
8444, 1.7333333333333, 0.99333333333333, 0.16666666666667
8445, 1.7333333333333, 0.94, 0.16666666666667
8446, 1.7333333333333, 0.88666666666667, 0.16666666666667
8447, 1.7333333333333, 0.83333333333333, 0.16666666666667
8448, 1.7333333333333, 0.78, 0.16666666666667
8449, 1.7333333333333, 0.72666666666667, 0.16666666666667
8450, 1.7333333333333, 0.67333333333333, 0.16666666666667
8451, 1.7333333333333, 0.62, 0.16666666666667
8452, 1.7333333333333, 0.56666666666667, 0.16666666666667
8453, 1.7333333333333, 0.51333333333333, 0.16666666666667
8454, 1.7333333333333, 0.46, 0.16666666666667
8455, 1.7333333333333, 0.40666666666667, 0.16666666666667
8456, 1.7333333333333, 0.35333333333333, 0.16666666666667
8457, 1.8, 1.0466666666667, 0.16666666666667
8458, 1.8, 0.99333333333333, 0.16666666666667
8459, 1.8, 0.94, 0.16666666666667
8460, 1.8, 0.88666666666667, 0.16666666666667
8461, 1.8, 0.83333333333333, 0.16666666666667
8462, 1.8, 0.78, 0.16666666666667
8463, 1.8, 0.72666666666667, 0.16666666666667
8464, 1.8, 0.67333333333333, 0.16666666666667
8465, 1.8, 0.62, 0.16666666666667
8466, 1.8, 0.56666666666667, 0.16666666666667
8467, 1.8, 0.51333333333333, 0.16666666666667
8468, 1.8, 0.46, 0.16666666666667
8469, 1.8, 0.40666666666667, 0.16666666666667
8470, 1.8, 0.35333333333333, 0.16666666666667
8471, 1.8666666666667, 1.0466666666667, 0.16666666666667
8472, 1.8666666666667, 0.99333333333333, 0.16666666666667
8473, 1.8666666666667, 0.94, 0.16666666666667
8474, 1.8666666666667, 0.88666666666667, 0.16666666666667
8475, 1.8666666666667, 0.83333333333333, 0.16666666666667
8476, 1.8666666666667, 0.78, 0.16666666666667
8477, 1.8666666666667, 0.72666666666667, 0.16666666666667
8478, 1.8666666666667, 0.67333333333333, 0.16666666666667
8479, 1.8666666666667, 0.62, 0.16666666666667
8480, 1.8666666666667, 0.56666666666667, 0.16666666666667
8481, 1.8666666666667, 0.51333333333333, 0.16666666666667
8482, 1.8666666666667, 0.46, 0.16666666666667
8483, 1.8666666666667, 0.40666666666667, 0.16666666666667
8484, 1.8666666666667, 0.35333333333333, 0.16666666666667
8485, 1.9333333333333, 1.0466666666667, 0.16666666666667
8486, 1.9333333333333, 0.99333333333333, 0.16666666666667
8487, 1.9333333333333, 0.94, 0.16666666666667
8488, 1.9333333333333, 0.88666666666667, 0.16666666666667
8489, 1.9333333333333, 0.83333333333333, 0.16666666666667
8490, 1.9333333333333, 0.78, 0.16666666666667
8491, 1.9333333333333, 0.72666666666667, 0.16666666666667
8492, 1.9333333333333, 0.67333333333333, 0.16666666666667
8493, 1.9333333333333, 0.62, 0.16666666666667
8494, 1.9333333333333, 0.56666666666667, 0.16666666666667
8495, 1.9333333333333, 0.51333333333333, 0.16666666666667
8496, 1.9333333333333, 0.46, 0.16666666666667
8497, 1.9333333333333, 0.40666666666667, 0.16666666666667
8498, 1.9333333333333, 0.35333333333333, 0.16666666666667
8499, 2, 1.0466666666667, 0.16666666666667
8500, 2, 0.99333333333333, 0.16666666666667
8501, 2, 0.94, 0.16666666666667
8502, 2, 0.88666666666667, 0.16666666666667
8503, 2, 0.83333333333333, 0.16666666666667
8504, 2, 0.78, 0.16666666666667
8505, 2, 0.72666666666667, 0.16666666666667
8506, 2, 0.67333333333333, 0.16666666666667
8507, 2, 0.62, 0.16666666666667
8508, 2, 0.56666666666667, 0.16666666666667
8509, 2, 0.51333333333333, 0.16666666666667
8510, 2, 0.46, 0.16666666666667
8511, 2, 0.40666666666667, 0.16666666666667
8512, 2, 0.35333333333333, 0.16666666666667
8513, 2.0666666666667, 1.0466666666667, 0.16666666666667
8514, 2.0666666666667, 0.99333333333333, 0.16666666666667
8515, 2.0666666666667, 0.94, 0.16666666666667
8516, 2.0666666666667, 0.88666666666667, 0.16666666666667
8517, 2.0666666666667, 0.83333333333333, 0.16666666666667
8518, 2.0666666666667, 0.78, 0.16666666666667
8519, 2.0666666666667, 0.72666666666667, 0.16666666666667
8520, 2.0666666666667, 0.67333333333333, 0.16666666666667
8521, 2.0666666666667, 0.62, 0.16666666666667
8522, 2.0666666666667, 0.56666666666667, 0.16666666666667
8523, 2.0666666666667, 0.51333333333333, 0.16666666666667
8524, 2.0666666666667, 0.46, 0.16666666666667
8525, 2.0666666666667, 0.40666666666667, 0.16666666666667
8526, 2.0666666666667, 0.35333333333333, 0.16666666666667
8527, 2.1333333333333, 1.0466666666667, 0.16666666666667
8528, 2.1333333333333, 0.99333333333333, 0.16666666666667
8529, 2.1333333333333, 0.94, 0.16666666666667
8530, 2.1333333333333, 0.88666666666667, 0.16666666666667
8531, 2.1333333333333, 0.83333333333333, 0.16666666666667
8532, 2.1333333333333, 0.78, 0.16666666666667
8533, 2.1333333333333, 0.72666666666667, 0.16666666666667
8534, 2.1333333333333, 0.67333333333333, 0.16666666666667
8535, 2.1333333333333, 0.62, 0.16666666666667
8536, 2.1333333333333, 0.56666666666667, 0.16666666666667
8537, 2.1333333333333, 0.51333333333333, 0.16666666666667
8538, 2.1333333333333, 0.46, 0.16666666666667
8539, 2.1333333333333, 0.40666666666667, 0.16666666666667
8540, 2.1333333333333, 0.35333333333333, 0.16666666666667
8541, 1.2666666666667, 1.0466666666667, 0.2
8542, 1.2666666666667, 0.99333333333333, 0.2
8543, 1.2666666666667, 0.94, 0.2
8544, 1.2666666666667, 0.88666666666667, 0.2
8545, 1.2666666666667, 0.83333333333333, 0.2
8546, 1.2666666666667, 0.78, 0.2
8547, 1.2666666666667, 0.72666666666667, 0.2
8548, 1.2666666666667, 0.67333333333333, 0.2
8549, 1.2666666666667, 0.62, 0.2
8550, 1.2666666666667, 0.56666666666667, 0.2
8551, 1.2666666666667, 0.51333333333333, 0.2
8552, 1.2666666666667, 0.46, 0.2
8553, 1.2666666666667, 0.40666666666667, 0.2
8554, 1.2666666666667, 0.35333333333333, 0.2
8555, 1.3333333333333, 1.0466666666667, 0.2
8556, 1.3333333333333, 0.99333333333333, 0.2
8557, 1.3333333333333, 0.94, 0.2
8558, 1.3333333333333, 0.88666666666667, 0.2
8559, 1.3333333333333, 0.83333333333333, 0.2
8560, 1.3333333333333, 0.78, 0.2
8561, 1.3333333333333, 0.72666666666667, 0.2
8562, 1.3333333333333, 0.67333333333333, 0.2
8563, 1.3333333333333, 0.62, 0.2
8564, 1.3333333333333, 0.56666666666667, 0.2
8565, 1.3333333333333, 0.51333333333333, 0.2
8566, 1.3333333333333, 0.46, 0.2
8567, 1.3333333333333, 0.40666666666667, 0.2
8568, 1.3333333333333, 0.35333333333333, 0.2
8569, 1.4, 1.0466666666667, 0.2
8570, 1.4, 0.99333333333333, 0.2
8571, 1.4, 0.94, 0.2
8572, 1.4, 0.88666666666667, 0.2
8573, 1.4, 0.83333333333333, 0.2
8574, 1.4, 0.78, 0.2
8575, 1.4, 0.72666666666667, 0.2
8576, 1.4, 0.67333333333333, 0.2
8577, 1.4, 0.62, 0.2
8578, 1.4, 0.56666666666667, 0.2
8579, 1.4, 0.51333333333333, 0.2
8580, 1.4, 0.46, 0.2
8581, 1.4, 0.40666666666667, 0.2
8582, 1.4, 0.35333333333333, 0.2
8583, 1.4666666666667, 1.0466666666667, 0.2
8584, 1.4666666666667, 0.99333333333333, 0.2
8585, 1.4666666666667, 0.94, 0.2
8586, 1.4666666666667, 0.88666666666667, 0.2
8587, 1.4666666666667, 0.83333333333333, 0.2
8588, 1.4666666666667, 0.78, 0.2
8589, 1.4666666666667, 0.72666666666667, 0.2
8590, 1.4666666666667, 0.67333333333333, 0.2
8591, 1.4666666666667, 0.62, 0.2
8592, 1.4666666666667, 0.56666666666667, 0.2
8593, 1.4666666666667, 0.51333333333333, 0.2
8594, 1.4666666666667, 0.46, 0.2
8595, 1.4666666666667, 0.40666666666667, 0.2
8596, 1.4666666666667, 0.35333333333333, 0.2
8597, 1.5333333333333, 1.0466666666667, 0.2
8598, 1.5333333333333, 0.99333333333333, 0.2
8599, 1.5333333333333, 0.94, 0.2
8600, 1.5333333333333, 0.88666666666667, 0.2
8601, 1.5333333333333, 0.83333333333333, 0.2
8602, 1.5333333333333, 0.78, 0.2
8603, 1.5333333333333, 0.72666666666667, 0.2
8604, 1.5333333333333, 0.67333333333333, 0.2
8605, 1.5333333333333, 0.62, 0.2
8606, 1.5333333333333, 0.56666666666667, 0.2
8607, 1.5333333333333, 0.51333333333333, 0.2
8608, 1.5333333333333, 0.46, 0.2
8609, 1.5333333333333, 0.40666666666667, 0.2
8610, 1.5333333333333, 0.35333333333333, 0.2
8611, 1.6, 1.0466666666667, 0.2
8612, 1.6, 0.99333333333333, 0.2
8613, 1.6, 0.94, 0.2
8614, 1.6, 0.88666666666667, 0.2
8615, 1.6, 0.83333333333333, 0.2
8616, 1.6, 0.78, 0.2
8617, 1.6, 0.72666666666667, 0.2
8618, 1.6, 0.67333333333333, 0.2
8619, 1.6, 0.62, 0.2
8620, 1.6, 0.56666666666667, 0.2
8621, 1.6, 0.51333333333333, 0.2
8622, 1.6, 0.46, 0.2
8623, 1.6, 0.40666666666667, 0.2
8624, 1.6, 0.35333333333333, 0.2
8625, 1.6666666666667, 1.0466666666667, 0.2
8626, 1.6666666666667, 0.99333333333333, 0.2
8627, 1.6666666666667, 0.94, 0.2
8628, 1.6666666666667, 0.88666666666667, 0.2
8629, 1.6666666666667, 0.83333333333333, 0.2
8630, 1.6666666666667, 0.78, 0.2
8631, 1.6666666666667, 0.72666666666667, 0.2
8632, 1.6666666666667, 0.67333333333333, 0.2
8633, 1.6666666666667, 0.62, 0.2
8634, 1.6666666666667, 0.56666666666667, 0.2
8635, 1.6666666666667, 0.51333333333333, 0.2
8636, 1.6666666666667, 0.46, 0.2
8637, 1.6666666666667, 0.40666666666667, 0.2
8638, 1.6666666666667, 0.35333333333333, 0.2
8639, 1.7333333333333, 1.0466666666667, 0.2
8640, 1.7333333333333, 0.99333333333333, 0.2
8641, 1.7333333333333, 0.94, 0.2
8642, 1.7333333333333, 0.88666666666667, 0.2
8643, 1.7333333333333, 0.83333333333333, 0.2
8644, 1.7333333333333, 0.78, 0.2
8645, 1.7333333333333, 0.72666666666667, 0.2
8646, 1.7333333333333, 0.67333333333333, 0.2
8647, 1.7333333333333, 0.62, 0.2
8648, 1.7333333333333, 0.56666666666667, 0.2
8649, 1.7333333333333, 0.51333333333333, 0.2
8650, 1.7333333333333, 0.46, 0.2
8651, 1.7333333333333, 0.40666666666667, 0.2
8652, 1.7333333333333, 0.35333333333333, 0.2
8653, 1.8, 1.0466666666667, 0.2
8654, 1.8, 0.99333333333333, 0.2
8655, 1.8, 0.94, 0.2
8656, 1.8, 0.88666666666667, 0.2
8657, 1.8, 0.83333333333333, 0.2
8658, 1.8, 0.78, 0.2
8659, 1.8, 0.72666666666667, 0.2
8660, 1.8, 0.67333333333333, 0.2
8661, 1.8, 0.62, 0.2
8662, 1.8, 0.56666666666667, 0.2
8663, 1.8, 0.51333333333333, 0.2
8664, 1.8, 0.46, 0.2
8665, 1.8, 0.40666666666667, 0.2
8666, 1.8, 0.35333333333333, 0.2
8667, 1.8666666666667, 1.0466666666667, 0.2
8668, 1.8666666666667, 0.99333333333333, 0.2
8669, 1.8666666666667, 0.94, 0.2
8670, 1.8666666666667, 0.88666666666667, 0.2
8671, 1.8666666666667, 0.83333333333333, 0.2
8672, 1.8666666666667, 0.78, 0.2
8673, 1.8666666666667, 0.72666666666667, 0.2
8674, 1.8666666666667, 0.67333333333333, 0.2
8675, 1.8666666666667, 0.62, 0.2
8676, 1.8666666666667, 0.56666666666667, 0.2
8677, 1.8666666666667, 0.51333333333333, 0.2
8678, 1.8666666666667, 0.46, 0.2
8679, 1.8666666666667, 0.40666666666667, 0.2
8680, 1.8666666666667, 0.35333333333333, 0.2
8681, 1.9333333333333, 1.0466666666667, 0.2
8682, 1.9333333333333, 0.99333333333333, 0.2
8683, 1.9333333333333, 0.94, 0.2
8684, 1.9333333333333, 0.88666666666667, 0.2
8685, 1.9333333333333, 0.83333333333333, 0.2
8686, 1.9333333333333, 0.78, 0.2
8687, 1.9333333333333, 0.72666666666667, 0.2
8688, 1.9333333333333, 0.67333333333333, 0.2
8689, 1.9333333333333, 0.62, 0.2
8690, 1.9333333333333, 0.56666666666667, 0.2
8691, 1.9333333333333, 0.51333333333333, 0.2
8692, 1.9333333333333, 0.46, 0.2
8693, 1.9333333333333, 0.40666666666667, 0.2
8694, 1.9333333333333, 0.35333333333333, 0.2
8695, 2, 1.0466666666667, 0.2
8696, 2, 0.99333333333333, 0.2
8697, 2, 0.94, 0.2
8698, 2, 0.88666666666667, 0.2
8699, 2, 0.83333333333333, 0.2
8700, 2, 0.78, 0.2
8701, 2, 0.72666666666667, 0.2
8702, 2, 0.67333333333333, 0.2
8703, 2, 0.62, 0.2
8704, 2, 0.56666666666667, 0.2
8705, 2, 0.51333333333333, 0.2
8706, 2, 0.46, 0.2
8707, 2, 0.40666666666667, 0.2
8708, 2, 0.35333333333333, 0.2
8709, 2.0666666666667, 1.0466666666667, 0.2
8710, 2.0666666666667, 0.99333333333333, 0.2
8711, 2.0666666666667, 0.94, 0.2
8712, 2.0666666666667, 0.88666666666667, 0.2
8713, 2.0666666666667, 0.83333333333333, 0.2
8714, 2.0666666666667, 0.78, 0.2
8715, 2.0666666666667, 0.72666666666667, 0.2
8716, 2.0666666666667, 0.67333333333333, 0.2
8717, 2.0666666666667, 0.62, 0.2
8718, 2.0666666666667, 0.56666666666667, 0.2
8719, 2.0666666666667, 0.51333333333333, 0.2
8720, 2.0666666666667, 0.46, 0.2
8721, 2.0666666666667, 0.40666666666667, 0.2
8722, 2.0666666666667, 0.35333333333333, 0.2
8723, 2.1333333333333, 1.0466666666667, 0.2
8724, 2.1333333333333, 0.99333333333333, 0.2
8725, 2.1333333333333, 0.94, 0.2
8726, 2.1333333333333, 0.88666666666667, 0.2
8727, 2.1333333333333, 0.83333333333333, 0.2
8728, 2.1333333333333, 0.78, 0.2
8729, 2.1333333333333, 0.72666666666667, 0.2
8730, 2.1333333333333, 0.67333333333333, 0.2
8731, 2.1333333333333, 0.62, 0.2
8732, 2.1333333333333, 0.56666666666667, 0.2
8733, 2.1333333333333, 0.51333333333333, 0.2
8734, 2.1333333333333, 0.46, 0.2
8735, 2.1333333333333, 0.40666666666667, 0.2
8736, 2.1333333333333, 0.35333333333333, 0.2
8737, 1.2666666666667, 1.0466666666667, 0.23333333333333
8738, 1.2666666666667, 0.99333333333333, 0.23333333333333
8739, 1.2666666666667, 0.94, 0.23333333333333
8740, 1.2666666666667, 0.88666666666667, 0.23333333333333
8741, 1.2666666666667, 0.83333333333333, 0.23333333333333
8742, 1.2666666666667, 0.78, 0.23333333333333
8743, 1.2666666666667, 0.72666666666667, 0.23333333333333
8744, 1.2666666666667, 0.67333333333333, 0.23333333333333
8745, 1.2666666666667, 0.62, 0.23333333333333
8746, 1.2666666666667, 0.56666666666667, 0.23333333333333
8747, 1.2666666666667, 0.51333333333333, 0.23333333333333
8748, 1.2666666666667, 0.46, 0.23333333333333
8749, 1.2666666666667, 0.40666666666667, 0.23333333333333
8750, 1.2666666666667, 0.35333333333333, 0.23333333333333
8751, 1.3333333333333, 1.0466666666667, 0.23333333333333
8752, 1.3333333333333, 0.99333333333333, 0.23333333333333
8753, 1.3333333333333, 0.94, 0.23333333333333
8754, 1.3333333333333, 0.88666666666667, 0.23333333333333
8755, 1.3333333333333, 0.83333333333333, 0.23333333333333
8756, 1.3333333333333, 0.78, 0.23333333333333
8757, 1.3333333333333, 0.72666666666667, 0.23333333333333
8758, 1.3333333333333, 0.67333333333333, 0.23333333333333
8759, 1.3333333333333, 0.62, 0.23333333333333
8760, 1.3333333333333, 0.56666666666667, 0.23333333333333
8761, 1.3333333333333, 0.51333333333333, 0.23333333333333
8762, 1.3333333333333, 0.46, 0.23333333333333
8763, 1.3333333333333, 0.40666666666667, 0.23333333333333
8764, 1.3333333333333, 0.35333333333333, 0.23333333333333
8765, 1.4, 1.0466666666667, 0.23333333333333
8766, 1.4, 0.99333333333333, 0.23333333333333
8767, 1.4, 0.94, 0.23333333333333
8768, 1.4, 0.88666666666667, 0.23333333333333
8769, 1.4, 0.83333333333333, 0.23333333333333
8770, 1.4, 0.78, 0.23333333333333
8771, 1.4, 0.72666666666667, 0.23333333333333
8772, 1.4, 0.67333333333333, 0.23333333333333
8773, 1.4, 0.62, 0.23333333333333
8774, 1.4, 0.56666666666667, 0.23333333333333
8775, 1.4, 0.51333333333333, 0.23333333333333
8776, 1.4, 0.46, 0.23333333333333
8777, 1.4, 0.40666666666667, 0.23333333333333
8778, 1.4, 0.35333333333333, 0.23333333333333
8779, 1.4666666666667, 1.0466666666667, 0.23333333333333
8780, 1.4666666666667, 0.99333333333333, 0.23333333333333
8781, 1.4666666666667, 0.94, 0.23333333333333
8782, 1.4666666666667, 0.88666666666667, 0.23333333333333
8783, 1.4666666666667, 0.83333333333333, 0.23333333333333
8784, 1.4666666666667, 0.78, 0.23333333333333
8785, 1.4666666666667, 0.72666666666667, 0.23333333333333
8786, 1.4666666666667, 0.67333333333333, 0.23333333333333
8787, 1.4666666666667, 0.62, 0.23333333333333
8788, 1.4666666666667, 0.56666666666667, 0.23333333333333
8789, 1.4666666666667, 0.51333333333333, 0.23333333333333
8790, 1.4666666666667, 0.46, 0.23333333333333
8791, 1.4666666666667, 0.40666666666667, 0.23333333333333
8792, 1.4666666666667, 0.35333333333333, 0.23333333333333
8793, 1.5333333333333, 1.0466666666667, 0.23333333333333
8794, 1.5333333333333, 0.99333333333333, 0.23333333333333
8795, 1.5333333333333, 0.94, 0.23333333333333
8796, 1.5333333333333, 0.88666666666667, 0.23333333333333
8797, 1.5333333333333, 0.83333333333333, 0.23333333333333
8798, 1.5333333333333, 0.78, 0.23333333333333
8799, 1.5333333333333, 0.72666666666667, 0.23333333333333
8800, 1.5333333333333, 0.67333333333333, 0.23333333333333
8801, 1.5333333333333, 0.62, 0.23333333333333
8802, 1.5333333333333, 0.56666666666667, 0.23333333333333
8803, 1.5333333333333, 0.51333333333333, 0.23333333333333
8804, 1.5333333333333, 0.46, 0.23333333333333
8805, 1.5333333333333, 0.40666666666667, 0.23333333333333
8806, 1.5333333333333, 0.35333333333333, 0.23333333333333
8807, 1.6, 1.0466666666667, 0.23333333333333
8808, 1.6, 0.99333333333333, 0.23333333333333
8809, 1.6, 0.94, 0.23333333333333
8810, 1.6, 0.88666666666667, 0.23333333333333
8811, 1.6, 0.83333333333333, 0.23333333333333
8812, 1.6, 0.78, 0.23333333333333
8813, 1.6, 0.72666666666667, 0.23333333333333
8814, 1.6, 0.67333333333333, 0.23333333333333
8815, 1.6, 0.62, 0.23333333333333
8816, 1.6, 0.56666666666667, 0.23333333333333
8817, 1.6, 0.51333333333333, 0.23333333333333
8818, 1.6, 0.46, 0.23333333333333
8819, 1.6, 0.40666666666667, 0.23333333333333
8820, 1.6, 0.35333333333333, 0.23333333333333
8821, 1.6666666666667, 1.0466666666667, 0.23333333333333
8822, 1.6666666666667, 0.99333333333333, 0.23333333333333
8823, 1.6666666666667, 0.94, 0.23333333333333
8824, 1.6666666666667, 0.88666666666667, 0.23333333333333
8825, 1.6666666666667, 0.83333333333333, 0.23333333333333
8826, 1.6666666666667, 0.78, 0.23333333333333
8827, 1.6666666666667, 0.72666666666667, 0.23333333333333
8828, 1.6666666666667, 0.67333333333333, 0.23333333333333
8829, 1.6666666666667, 0.62, 0.23333333333333
8830, 1.6666666666667, 0.56666666666667, 0.23333333333333
8831, 1.6666666666667, 0.51333333333333, 0.23333333333333
8832, 1.6666666666667, 0.46, 0.23333333333333
8833, 1.6666666666667, 0.40666666666667, 0.23333333333333
8834, 1.6666666666667, 0.35333333333333, 0.23333333333333
8835, 1.7333333333333, 1.0466666666667, 0.23333333333333
8836, 1.7333333333333, 0.99333333333333, 0.23333333333333
8837, 1.7333333333333, 0.94, 0.23333333333333
8838, 1.7333333333333, 0.88666666666667, 0.23333333333333
8839, 1.7333333333333, 0.83333333333333, 0.23333333333333
8840, 1.7333333333333, 0.78, 0.23333333333333
8841, 1.7333333333333, 0.72666666666667, 0.23333333333333
8842, 1.7333333333333, 0.67333333333333, 0.23333333333333
8843, 1.7333333333333, 0.62, 0.23333333333333
8844, 1.7333333333333, 0.56666666666667, 0.23333333333333
8845, 1.7333333333333, 0.51333333333333, 0.23333333333333
8846, 1.7333333333333, 0.46, 0.23333333333333
8847, 1.7333333333333, 0.40666666666667, 0.23333333333333
8848, 1.7333333333333, 0.35333333333333, 0.23333333333333
8849, 1.8, 1.0466666666667, 0.23333333333333
8850, 1.8, 0.99333333333333, 0.23333333333333
8851, 1.8, 0.94, 0.23333333333333
8852, 1.8, 0.88666666666667, 0.23333333333333
8853, 1.8, 0.83333333333333, 0.23333333333333
8854, 1.8, 0.78, 0.23333333333333
8855, 1.8, 0.72666666666667, 0.23333333333333
8856, 1.8, 0.67333333333333, 0.23333333333333
8857, 1.8, 0.62, 0.23333333333333
8858, 1.8, 0.56666666666667, 0.23333333333333
8859, 1.8, 0.51333333333333, 0.23333333333333
8860, 1.8, 0.46, 0.23333333333333
8861, 1.8, 0.40666666666667, 0.23333333333333
8862, 1.8, 0.35333333333333, 0.23333333333333
8863, 1.8666666666667, 1.0466666666667, 0.23333333333333
8864, 1.8666666666667, 0.99333333333333, 0.23333333333333
8865, 1.8666666666667, 0.94, 0.23333333333333
8866, 1.8666666666667, 0.88666666666667, 0.23333333333333
8867, 1.8666666666667, 0.83333333333333, 0.23333333333333
8868, 1.8666666666667, 0.78, 0.23333333333333
8869, 1.8666666666667, 0.72666666666667, 0.23333333333333
8870, 1.8666666666667, 0.67333333333333, 0.23333333333333
8871, 1.8666666666667, 0.62, 0.23333333333333
8872, 1.8666666666667, 0.56666666666667, 0.23333333333333
8873, 1.8666666666667, 0.51333333333333, 0.23333333333333
8874, 1.8666666666667, 0.46, 0.23333333333333
8875, 1.8666666666667, 0.40666666666667, 0.23333333333333
8876, 1.8666666666667, 0.35333333333333, 0.23333333333333
8877, 1.9333333333333, 1.0466666666667, 0.23333333333333
8878, 1.9333333333333, 0.99333333333333, 0.23333333333333
8879, 1.9333333333333, 0.94, 0.23333333333333
8880, 1.9333333333333, 0.88666666666667, 0.23333333333333
8881, 1.9333333333333, 0.83333333333333, 0.23333333333333
8882, 1.9333333333333, 0.78, 0.23333333333333
8883, 1.9333333333333, 0.72666666666667, 0.23333333333333
8884, 1.9333333333333, 0.67333333333333, 0.23333333333333
8885, 1.9333333333333, 0.62, 0.23333333333333
8886, 1.9333333333333, 0.56666666666667, 0.23333333333333
8887, 1.9333333333333, 0.51333333333333, 0.23333333333333
8888, 1.9333333333333, 0.46, 0.23333333333333
8889, 1.9333333333333, 0.40666666666667, 0.23333333333333
8890, 1.9333333333333, 0.35333333333333, 0.23333333333333
8891, 2, 1.0466666666667, 0.23333333333333
8892, 2, 0.99333333333333, 0.23333333333333
8893, 2, 0.94, 0.23333333333333
8894, 2, 0.88666666666667, 0.23333333333333
8895, 2, 0.83333333333333, 0.23333333333333
8896, 2, 0.78, 0.23333333333333
8897, 2, 0.72666666666667, 0.23333333333333
8898, 2, 0.67333333333333, 0.23333333333333
8899, 2, 0.62, 0.23333333333333
8900, 2, 0.56666666666667, 0.23333333333333
8901, 2, 0.51333333333333, 0.23333333333333
8902, 2, 0.46, 0.23333333333333
8903, 2, 0.40666666666667, 0.23333333333333
8904, 2, 0.35333333333333, 0.23333333333333
8905, 2.0666666666667, 1.0466666666667, 0.23333333333333
8906, 2.0666666666667, 0.99333333333333, 0.23333333333333
8907, 2.0666666666667, 0.94, 0.23333333333333
8908, 2.0666666666667, 0.88666666666667, 0.23333333333333
8909, 2.0666666666667, 0.83333333333333, 0.23333333333333
8910, 2.0666666666667, 0.78, 0.23333333333333
8911, 2.0666666666667, 0.72666666666667, 0.23333333333333
8912, 2.0666666666667, 0.67333333333333, 0.23333333333333
8913, 2.0666666666667, 0.62, 0.23333333333333
8914, 2.0666666666667, 0.56666666666667, 0.23333333333333
8915, 2.0666666666667, 0.51333333333333, 0.23333333333333
8916, 2.0666666666667, 0.46, 0.23333333333333
8917, 2.0666666666667, 0.40666666666667, 0.23333333333333
8918, 2.0666666666667, 0.35333333333333, 0.23333333333333
8919, 2.1333333333333, 1.0466666666667, 0.23333333333333
8920, 2.1333333333333, 0.99333333333333, 0.23333333333333
8921, 2.1333333333333, 0.94, 0.23333333333333
8922, 2.1333333333333, 0.88666666666667, 0.23333333333333
8923, 2.1333333333333, 0.83333333333333, 0.23333333333333
8924, 2.1333333333333, 0.78, 0.23333333333333
8925, 2.1333333333333, 0.72666666666667, 0.23333333333333
8926, 2.1333333333333, 0.67333333333333, 0.23333333333333
8927, 2.1333333333333, 0.62, 0.23333333333333
8928, 2.1333333333333, 0.56666666666667, 0.23333333333333
8929, 2.1333333333333, 0.51333333333333, 0.23333333333333
8930, 2.1333333333333, 0.46, 0.23333333333333
8931, 2.1333333333333, 0.40666666666667, 0.23333333333333
8932, 2.1333333333333, 0.35333333333333, 0.23333333333333
8933, 1.2666666666667, 1.0466666666667, 0.26666666666667
8934, 1.2666666666667, 0.99333333333333, 0.26666666666667
8935, 1.2666666666667, 0.94, 0.26666666666667
8936, 1.2666666666667, 0.88666666666667, 0.26666666666667
8937, 1.2666666666667, 0.83333333333333, 0.26666666666667
8938, 1.2666666666667, 0.78, 0.26666666666667
8939, 1.2666666666667, 0.72666666666667, 0.26666666666667
8940, 1.2666666666667, 0.67333333333333, 0.26666666666667
8941, 1.2666666666667, 0.62, 0.26666666666667
8942, 1.2666666666667, 0.56666666666667, 0.26666666666667
8943, 1.2666666666667, 0.51333333333333, 0.26666666666667
8944, 1.2666666666667, 0.46, 0.26666666666667
8945, 1.2666666666667, 0.40666666666667, 0.26666666666667
8946, 1.2666666666667, 0.35333333333333, 0.26666666666667
8947, 1.3333333333333, 1.0466666666667, 0.26666666666667
8948, 1.3333333333333, 0.99333333333333, 0.26666666666667
8949, 1.3333333333333, 0.94, 0.26666666666667
8950, 1.3333333333333, 0.88666666666667, 0.26666666666667
8951, 1.3333333333333, 0.83333333333333, 0.26666666666667
8952, 1.3333333333333, 0.78, 0.26666666666667
8953, 1.3333333333333, 0.72666666666667, 0.26666666666667
8954, 1.3333333333333, 0.67333333333333, 0.26666666666667
8955, 1.3333333333333, 0.62, 0.26666666666667
8956, 1.3333333333333, 0.56666666666667, 0.26666666666667
8957, 1.3333333333333, 0.51333333333333, 0.26666666666667
8958, 1.3333333333333, 0.46, 0.26666666666667
8959, 1.3333333333333, 0.40666666666667, 0.26666666666667
8960, 1.3333333333333, 0.35333333333333, 0.26666666666667
8961, 1.4, 1.0466666666667, 0.26666666666667
8962, 1.4, 0.99333333333333, 0.26666666666667
8963, 1.4, 0.94, 0.26666666666667
8964, 1.4, 0.88666666666667, 0.26666666666667
8965, 1.4, 0.83333333333333, 0.26666666666667
8966, 1.4, 0.78, 0.26666666666667
8967, 1.4, 0.72666666666667, 0.26666666666667
8968, 1.4, 0.67333333333333, 0.26666666666667
8969, 1.4, 0.62, 0.26666666666667
8970, 1.4, 0.56666666666667, 0.26666666666667
8971, 1.4, 0.51333333333333, 0.26666666666667
8972, 1.4, 0.46, 0.26666666666667
8973, 1.4, 0.40666666666667, 0.26666666666667
8974, 1.4, 0.35333333333333, 0.26666666666667
8975, 1.4666666666667, 1.0466666666667, 0.26666666666667
8976, 1.4666666666667, 0.99333333333333, 0.26666666666667
8977, 1.4666666666667, 0.94, 0.26666666666667
8978, 1.4666666666667, 0.88666666666667, 0.26666666666667
8979, 1.4666666666667, 0.83333333333333, 0.26666666666667
8980, 1.4666666666667, 0.78, 0.26666666666667
8981, 1.4666666666667, 0.72666666666667, 0.26666666666667
8982, 1.4666666666667, 0.67333333333333, 0.26666666666667
8983, 1.4666666666667, 0.62, 0.26666666666667
8984, 1.4666666666667, 0.56666666666667, 0.26666666666667
8985, 1.4666666666667, 0.51333333333333, 0.26666666666667
8986, 1.4666666666667, 0.46, 0.26666666666667
8987, 1.4666666666667, 0.40666666666667, 0.26666666666667
8988, 1.4666666666667, 0.35333333333333, 0.26666666666667
8989, 1.5333333333333, 1.0466666666667, 0.26666666666667
8990, 1.5333333333333, 0.99333333333333, 0.26666666666667
8991, 1.5333333333333, 0.94, 0.26666666666667
8992, 1.5333333333333, 0.88666666666667, 0.26666666666667
8993, 1.5333333333333, 0.83333333333333, 0.26666666666667
8994, 1.5333333333333, 0.78, 0.26666666666667
8995, 1.5333333333333, 0.72666666666667, 0.26666666666667
8996, 1.5333333333333, 0.67333333333333, 0.26666666666667
8997, 1.5333333333333, 0.62, 0.26666666666667
8998, 1.5333333333333, 0.56666666666667, 0.26666666666667
8999, 1.5333333333333, 0.51333333333333, 0.26666666666667
9000, 1.5333333333333, 0.46, 0.26666666666667
9001, 1.5333333333333, 0.40666666666667, 0.26666666666667
9002, 1.5333333333333, 0.35333333333333, 0.26666666666667
9003, 1.6, 1.0466666666667, 0.26666666666667
9004, 1.6, 0.99333333333333, 0.26666666666667
9005, 1.6, 0.94, 0.26666666666667
9006, 1.6, 0.88666666666667, 0.26666666666667
9007, 1.6, 0.83333333333333, 0.26666666666667
9008, 1.6, 0.78, 0.26666666666667
9009, 1.6, 0.72666666666667, 0.26666666666667
9010, 1.6, 0.67333333333333, 0.26666666666667
9011, 1.6, 0.62, 0.26666666666667
9012, 1.6, 0.56666666666667, 0.26666666666667
9013, 1.6, 0.51333333333333, 0.26666666666667
9014, 1.6, 0.46, 0.26666666666667
9015, 1.6, 0.40666666666667, 0.26666666666667
9016, 1.6, 0.35333333333333, 0.26666666666667
9017, 1.6666666666667, 1.0466666666667, 0.26666666666667
9018, 1.6666666666667, 0.99333333333333, 0.26666666666667
9019, 1.6666666666667, 0.94, 0.26666666666667
9020, 1.6666666666667, 0.88666666666667, 0.26666666666667
9021, 1.6666666666667, 0.83333333333333, 0.26666666666667
9022, 1.6666666666667, 0.78, 0.26666666666667
9023, 1.6666666666667, 0.72666666666667, 0.26666666666667
9024, 1.6666666666667, 0.67333333333333, 0.26666666666667
9025, 1.6666666666667, 0.62, 0.26666666666667
9026, 1.6666666666667, 0.56666666666667, 0.26666666666667
9027, 1.6666666666667, 0.51333333333333, 0.26666666666667
9028, 1.6666666666667, 0.46, 0.26666666666667
9029, 1.6666666666667, 0.40666666666667, 0.26666666666667
9030, 1.6666666666667, 0.35333333333333, 0.26666666666667
9031, 1.7333333333333, 1.0466666666667, 0.26666666666667
9032, 1.7333333333333, 0.99333333333333, 0.26666666666667
9033, 1.7333333333333, 0.94, 0.26666666666667
9034, 1.7333333333333, 0.88666666666667, 0.26666666666667
9035, 1.7333333333333, 0.83333333333333, 0.26666666666667
9036, 1.7333333333333, 0.78, 0.26666666666667
9037, 1.7333333333333, 0.72666666666667, 0.26666666666667
9038, 1.7333333333333, 0.67333333333333, 0.26666666666667
9039, 1.7333333333333, 0.62, 0.26666666666667
9040, 1.7333333333333, 0.56666666666667, 0.26666666666667
9041, 1.7333333333333, 0.51333333333333, 0.26666666666667
9042, 1.7333333333333, 0.46, 0.26666666666667
9043, 1.7333333333333, 0.40666666666667, 0.26666666666667
9044, 1.7333333333333, 0.35333333333333, 0.26666666666667
9045, 1.8, 1.0466666666667, 0.26666666666667
9046, 1.8, 0.99333333333333, 0.26666666666667
9047, 1.8, 0.94, 0.26666666666667
9048, 1.8, 0.88666666666667, 0.26666666666667
9049, 1.8, 0.83333333333333, 0.26666666666667
9050, 1.8, 0.78, 0.26666666666667
9051, 1.8, 0.72666666666667, 0.26666666666667
9052, 1.8, 0.67333333333333, 0.26666666666667
9053, 1.8, 0.62, 0.26666666666667
9054, 1.8, 0.56666666666667, 0.26666666666667
9055, 1.8, 0.51333333333333, 0.26666666666667
9056, 1.8, 0.46, 0.26666666666667
9057, 1.8, 0.40666666666667, 0.26666666666667
9058, 1.8, 0.35333333333333, 0.26666666666667
9059, 1.8666666666667, 1.0466666666667, 0.26666666666667
9060, 1.8666666666667, 0.99333333333333, 0.26666666666667
9061, 1.8666666666667, 0.94, 0.26666666666667
9062, 1.8666666666667, 0.88666666666667, 0.26666666666667
9063, 1.8666666666667, 0.83333333333333, 0.26666666666667
9064, 1.8666666666667, 0.78, 0.26666666666667
9065, 1.8666666666667, 0.72666666666667, 0.26666666666667
9066, 1.8666666666667, 0.67333333333333, 0.26666666666667
9067, 1.8666666666667, 0.62, 0.26666666666667
9068, 1.8666666666667, 0.56666666666667, 0.26666666666667
9069, 1.8666666666667, 0.51333333333333, 0.26666666666667
9070, 1.8666666666667, 0.46, 0.26666666666667
9071, 1.8666666666667, 0.40666666666667, 0.26666666666667
9072, 1.8666666666667, 0.35333333333333, 0.26666666666667
9073, 1.9333333333333, 1.0466666666667, 0.26666666666667
9074, 1.9333333333333, 0.99333333333333, 0.26666666666667
9075, 1.9333333333333, 0.94, 0.26666666666667
9076, 1.9333333333333, 0.88666666666667, 0.26666666666667
9077, 1.9333333333333, 0.83333333333333, 0.26666666666667
9078, 1.9333333333333, 0.78, 0.26666666666667
9079, 1.9333333333333, 0.72666666666667, 0.26666666666667
9080, 1.9333333333333, 0.67333333333333, 0.26666666666667
9081, 1.9333333333333, 0.62, 0.26666666666667
9082, 1.9333333333333, 0.56666666666667, 0.26666666666667
9083, 1.9333333333333, 0.51333333333333, 0.26666666666667
9084, 1.9333333333333, 0.46, 0.26666666666667
9085, 1.9333333333333, 0.40666666666667, 0.26666666666667
9086, 1.9333333333333, 0.35333333333333, 0.26666666666667
9087, 2, 1.0466666666667, 0.26666666666667
9088, 2, 0.99333333333333, 0.26666666666667
9089, 2, 0.94, 0.26666666666667
9090, 2, 0.88666666666667, 0.26666666666667
9091, 2, 0.83333333333333, 0.26666666666667
9092, 2, 0.78, 0.26666666666667
9093, 2, 0.72666666666667, 0.26666666666667
9094, 2, 0.67333333333333, 0.26666666666667
9095, 2, 0.62, 0.26666666666667
9096, 2, 0.56666666666667, 0.26666666666667
9097, 2, 0.51333333333333, 0.26666666666667
9098, 2, 0.46, 0.26666666666667
9099, 2, 0.40666666666667, 0.26666666666667
9100, 2, 0.35333333333333, 0.26666666666667
9101, 2.0666666666667, 1.0466666666667, 0.26666666666667
9102, 2.0666666666667, 0.99333333333333, 0.26666666666667
9103, 2.0666666666667, 0.94, 0.26666666666667
9104, 2.0666666666667, 0.88666666666667, 0.26666666666667
9105, 2.0666666666667, 0.83333333333333, 0.26666666666667
9106, 2.0666666666667, 0.78, 0.26666666666667
9107, 2.0666666666667, 0.72666666666667, 0.26666666666667
9108, 2.0666666666667, 0.67333333333333, 0.26666666666667
9109, 2.0666666666667, 0.62, 0.26666666666667
9110, 2.0666666666667, 0.56666666666667, 0.26666666666667
9111, 2.0666666666667, 0.51333333333333, 0.26666666666667
9112, 2.0666666666667, 0.46, 0.26666666666667
9113, 2.0666666666667, 0.40666666666667, 0.26666666666667
9114, 2.0666666666667, 0.35333333333333, 0.26666666666667
9115, 2.1333333333333, 1.0466666666667, 0.26666666666667
9116, 2.1333333333333, 0.99333333333333, 0.26666666666667
9117, 2.1333333333333, 0.94, 0.26666666666667
9118, 2.1333333333333, 0.88666666666667, 0.26666666666667
9119, 2.1333333333333, 0.83333333333333, 0.26666666666667
9120, 2.1333333333333, 0.78, 0.26666666666667
9121, 2.1333333333333, 0.72666666666667, 0.26666666666667
9122, 2.1333333333333, 0.67333333333333, 0.26666666666667
9123, 2.1333333333333, 0.62, 0.26666666666667
9124, 2.1333333333333, 0.56666666666667, 0.26666666666667
9125, 2.1333333333333, 0.51333333333333, 0.26666666666667
9126, 2.1333333333333, 0.46, 0.26666666666667
9127, 2.1333333333333, 0.40666666666667, 0.26666666666667
9128, 2.1333333333333, 0.35333333333333, 0.26666666666667
9129, 1.2666666666667, 1.0466666666667, 0.3
9130, 1.2666666666667, 0.99333333333333, 0.3
9131, 1.2666666666667, 0.94, 0.3
9132, 1.2666666666667, 0.88666666666667, 0.3
9133, 1.2666666666667, 0.83333333333333, 0.3
9134, 1.2666666666667, 0.78, 0.3
9135, 1.2666666666667, 0.72666666666667, 0.3
9136, 1.2666666666667, 0.67333333333333, 0.3
9137, 1.2666666666667, 0.62, 0.3
9138, 1.2666666666667, 0.56666666666667, 0.3
9139, 1.2666666666667, 0.51333333333333, 0.3
9140, 1.2666666666667, 0.46, 0.3
9141, 1.2666666666667, 0.40666666666667, 0.3
9142, 1.2666666666667, 0.35333333333333, 0.3
9143, 1.3333333333333, 1.0466666666667, 0.3
9144, 1.3333333333333, 0.99333333333333, 0.3
9145, 1.3333333333333, 0.94, 0.3
9146, 1.3333333333333, 0.88666666666667, 0.3
9147, 1.3333333333333, 0.83333333333333, 0.3
9148, 1.3333333333333, 0.78, 0.3
9149, 1.3333333333333, 0.72666666666667, 0.3
9150, 1.3333333333333, 0.67333333333333, 0.3
9151, 1.3333333333333, 0.62, 0.3
9152, 1.3333333333333, 0.56666666666667, 0.3
9153, 1.3333333333333, 0.51333333333333, 0.3
9154, 1.3333333333333, 0.46, 0.3
9155, 1.3333333333333, 0.40666666666667, 0.3
9156, 1.3333333333333, 0.35333333333333, 0.3
9157, 1.4, 1.0466666666667, 0.3
9158, 1.4, 0.99333333333333, 0.3
9159, 1.4, 0.94, 0.3
9160, 1.4, 0.88666666666667, 0.3
9161, 1.4, 0.83333333333333, 0.3
9162, 1.4, 0.78, 0.3
9163, 1.4, 0.72666666666667, 0.3
9164, 1.4, 0.67333333333333, 0.3
9165, 1.4, 0.62, 0.3
9166, 1.4, 0.56666666666667, 0.3
9167, 1.4, 0.51333333333333, 0.3
9168, 1.4, 0.46, 0.3
9169, 1.4, 0.40666666666667, 0.3
9170, 1.4, 0.35333333333333, 0.3
9171, 1.4666666666667, 1.0466666666667, 0.3
9172, 1.4666666666667, 0.99333333333333, 0.3
9173, 1.4666666666667, 0.94, 0.3
9174, 1.4666666666667, 0.88666666666667, 0.3
9175, 1.4666666666667, 0.83333333333333, 0.3
9176, 1.4666666666667, 0.78, 0.3
9177, 1.4666666666667, 0.72666666666667, 0.3
9178, 1.4666666666667, 0.67333333333333, 0.3
9179, 1.4666666666667, 0.62, 0.3
9180, 1.4666666666667, 0.56666666666667, 0.3
9181, 1.4666666666667, 0.51333333333333, 0.3
9182, 1.4666666666667, 0.46, 0.3
9183, 1.4666666666667, 0.40666666666667, 0.3
9184, 1.4666666666667, 0.35333333333333, 0.3
9185, 1.5333333333333, 1.0466666666667, 0.3
9186, 1.5333333333333, 0.99333333333333, 0.3
9187, 1.5333333333333, 0.94, 0.3
9188, 1.5333333333333, 0.88666666666667, 0.3
9189, 1.5333333333333, 0.83333333333333, 0.3
9190, 1.5333333333333, 0.78, 0.3
9191, 1.5333333333333, 0.72666666666667, 0.3
9192, 1.5333333333333, 0.67333333333333, 0.3
9193, 1.5333333333333, 0.62, 0.3
9194, 1.5333333333333, 0.56666666666667, 0.3
9195, 1.5333333333333, 0.51333333333333, 0.3
9196, 1.5333333333333, 0.46, 0.3
9197, 1.5333333333333, 0.40666666666667, 0.3
9198, 1.5333333333333, 0.35333333333333, 0.3
9199, 1.6, 1.0466666666667, 0.3
9200, 1.6, 0.99333333333333, 0.3
9201, 1.6, 0.94, 0.3
9202, 1.6, 0.88666666666667, 0.3
9203, 1.6, 0.83333333333333, 0.3
9204, 1.6, 0.78, 0.3
9205, 1.6, 0.72666666666667, 0.3
9206, 1.6, 0.67333333333333, 0.3
9207, 1.6, 0.62, 0.3
9208, 1.6, 0.56666666666667, 0.3
9209, 1.6, 0.51333333333333, 0.3
9210, 1.6, 0.46, 0.3
9211, 1.6, 0.40666666666667, 0.3
9212, 1.6, 0.35333333333333, 0.3
9213, 1.6666666666667, 1.0466666666667, 0.3
9214, 1.6666666666667, 0.99333333333333, 0.3
9215, 1.6666666666667, 0.94, 0.3
9216, 1.6666666666667, 0.88666666666667, 0.3
9217, 1.6666666666667, 0.83333333333333, 0.3
9218, 1.6666666666667, 0.78, 0.3
9219, 1.6666666666667, 0.72666666666667, 0.3
9220, 1.6666666666667, 0.67333333333333, 0.3
9221, 1.6666666666667, 0.62, 0.3
9222, 1.6666666666667, 0.56666666666667, 0.3
9223, 1.6666666666667, 0.51333333333333, 0.3
9224, 1.6666666666667, 0.46, 0.3
9225, 1.6666666666667, 0.40666666666667, 0.3
9226, 1.6666666666667, 0.35333333333333, 0.3
9227, 1.7333333333333, 1.0466666666667, 0.3
9228, 1.7333333333333, 0.99333333333333, 0.3
9229, 1.7333333333333, 0.94, 0.3
9230, 1.7333333333333, 0.88666666666667, 0.3
9231, 1.7333333333333, 0.83333333333333, 0.3
9232, 1.7333333333333, 0.78, 0.3
9233, 1.7333333333333, 0.72666666666667, 0.3
9234, 1.7333333333333, 0.67333333333333, 0.3
9235, 1.7333333333333, 0.62, 0.3
9236, 1.7333333333333, 0.56666666666667, 0.3
9237, 1.7333333333333, 0.51333333333333, 0.3
9238, 1.7333333333333, 0.46, 0.3
9239, 1.7333333333333, 0.40666666666667, 0.3
9240, 1.7333333333333, 0.35333333333333, 0.3
9241, 1.8, 1.0466666666667, 0.3
9242, 1.8, 0.99333333333333, 0.3
9243, 1.8, 0.94, 0.3
9244, 1.8, 0.88666666666667, 0.3
9245, 1.8, 0.83333333333333, 0.3
9246, 1.8, 0.78, 0.3
9247, 1.8, 0.72666666666667, 0.3
9248, 1.8, 0.67333333333333, 0.3
9249, 1.8, 0.62, 0.3
9250, 1.8, 0.56666666666667, 0.3
9251, 1.8, 0.51333333333333, 0.3
9252, 1.8, 0.46, 0.3
9253, 1.8, 0.40666666666667, 0.3
9254, 1.8, 0.35333333333333, 0.3
9255, 1.8666666666667, 1.0466666666667, 0.3
9256, 1.8666666666667, 0.99333333333333, 0.3
9257, 1.8666666666667, 0.94, 0.3
9258, 1.8666666666667, 0.88666666666667, 0.3
9259, 1.8666666666667, 0.83333333333333, 0.3
9260, 1.8666666666667, 0.78, 0.3
9261, 1.8666666666667, 0.72666666666667, 0.3
9262, 1.8666666666667, 0.67333333333333, 0.3
9263, 1.8666666666667, 0.62, 0.3
9264, 1.8666666666667, 0.56666666666667, 0.3
9265, 1.8666666666667, 0.51333333333333, 0.3
9266, 1.8666666666667, 0.46, 0.3
9267, 1.8666666666667, 0.40666666666667, 0.3
9268, 1.8666666666667, 0.35333333333333, 0.3
9269, 1.9333333333333, 1.0466666666667, 0.3
9270, 1.9333333333333, 0.99333333333333, 0.3
9271, 1.9333333333333, 0.94, 0.3
9272, 1.9333333333333, 0.88666666666667, 0.3
9273, 1.9333333333333, 0.83333333333333, 0.3
9274, 1.9333333333333, 0.78, 0.3
9275, 1.9333333333333, 0.72666666666667, 0.3
9276, 1.9333333333333, 0.67333333333333, 0.3
9277, 1.9333333333333, 0.62, 0.3
9278, 1.9333333333333, 0.56666666666667, 0.3
9279, 1.9333333333333, 0.51333333333333, 0.3
9280, 1.9333333333333, 0.46, 0.3
9281, 1.9333333333333, 0.40666666666667, 0.3
9282, 1.9333333333333, 0.35333333333333, 0.3
9283, 2, 1.0466666666667, 0.3
9284, 2, 0.99333333333333, 0.3
9285, 2, 0.94, 0.3
9286, 2, 0.88666666666667, 0.3
9287, 2, 0.83333333333333, 0.3
9288, 2, 0.78, 0.3
9289, 2, 0.72666666666667, 0.3
9290, 2, 0.67333333333333, 0.3
9291, 2, 0.62, 0.3
9292, 2, 0.56666666666667, 0.3
9293, 2, 0.51333333333333, 0.3
9294, 2, 0.46, 0.3
9295, 2, 0.40666666666667, 0.3
9296, 2, 0.35333333333333, 0.3
9297, 2.0666666666667, 1.0466666666667, 0.3
9298, 2.0666666666667, 0.99333333333333, 0.3
9299, 2.0666666666667, 0.94, 0.3
9300, 2.0666666666667, 0.88666666666667, 0.3
9301, 2.0666666666667, 0.83333333333333, 0.3
9302, 2.0666666666667, 0.78, 0.3
9303, 2.0666666666667, 0.72666666666667, 0.3
9304, 2.0666666666667, 0.67333333333333, 0.3
9305, 2.0666666666667, 0.62, 0.3
9306, 2.0666666666667, 0.56666666666667, 0.3
9307, 2.0666666666667, 0.51333333333333, 0.3
9308, 2.0666666666667, 0.46, 0.3
9309, 2.0666666666667, 0.40666666666667, 0.3
9310, 2.0666666666667, 0.35333333333333, 0.3
9311, 2.1333333333333, 1.0466666666667, 0.3
9312, 2.1333333333333, 0.99333333333333, 0.3
9313, 2.1333333333333, 0.94, 0.3
9314, 2.1333333333333, 0.88666666666667, 0.3
9315, 2.1333333333333, 0.83333333333333, 0.3
9316, 2.1333333333333, 0.78, 0.3
9317, 2.1333333333333, 0.72666666666667, 0.3
9318, 2.1333333333333, 0.67333333333333, 0.3
9319, 2.1333333333333, 0.62, 0.3
9320, 2.1333333333333, 0.56666666666667, 0.3
9321, 2.1333333333333, 0.51333333333333, 0.3
9322, 2.1333333333333, 0.46, 0.3
9323, 2.1333333333333, 0.40666666666667, 0.3
9324, 2.1333333333333, 0.35333333333333, 0.3
9325, 1.2666666666667, 1.0466666666667, 0.33333333333333
9326, 1.2666666666667, 0.99333333333333, 0.33333333333333
9327, 1.2666666666667, 0.94, 0.33333333333333
9328, 1.2666666666667, 0.88666666666667, 0.33333333333333
9329, 1.2666666666667, 0.83333333333333, 0.33333333333333
9330, 1.2666666666667, 0.78, 0.33333333333333
9331, 1.2666666666667, 0.72666666666667, 0.33333333333333
9332, 1.2666666666667, 0.67333333333333, 0.33333333333333
9333, 1.2666666666667, 0.62, 0.33333333333333
9334, 1.2666666666667, 0.56666666666667, 0.33333333333333
9335, 1.2666666666667, 0.51333333333333, 0.33333333333333
9336, 1.2666666666667, 0.46, 0.33333333333333
9337, 1.2666666666667, 0.40666666666667, 0.33333333333333
9338, 1.2666666666667, 0.35333333333333, 0.33333333333333
9339, 1.3333333333333, 1.0466666666667, 0.33333333333333
9340, 1.3333333333333, 0.99333333333333, 0.33333333333333
9341, 1.3333333333333, 0.94, 0.33333333333333
9342, 1.3333333333333, 0.88666666666667, 0.33333333333333
9343, 1.3333333333333, 0.83333333333333, 0.33333333333333
9344, 1.3333333333333, 0.78, 0.33333333333333
9345, 1.3333333333333, 0.72666666666667, 0.33333333333333
9346, 1.3333333333333, 0.67333333333333, 0.33333333333333
9347, 1.3333333333333, 0.62, 0.33333333333333
9348, 1.3333333333333, 0.56666666666667, 0.33333333333333
9349, 1.3333333333333, 0.51333333333333, 0.33333333333333
9350, 1.3333333333333, 0.46, 0.33333333333333
9351, 1.3333333333333, 0.40666666666667, 0.33333333333333
9352, 1.3333333333333, 0.35333333333333, 0.33333333333333
9353, 1.4, 1.0466666666667, 0.33333333333333
9354, 1.4, 0.99333333333333, 0.33333333333333
9355, 1.4, 0.94, 0.33333333333333
9356, 1.4, 0.88666666666667, 0.33333333333333
9357, 1.4, 0.83333333333333, 0.33333333333333
9358, 1.4, 0.78, 0.33333333333333
9359, 1.4, 0.72666666666667, 0.33333333333333
9360, 1.4, 0.67333333333333, 0.33333333333333
9361, 1.4, 0.62, 0.33333333333333
9362, 1.4, 0.56666666666667, 0.33333333333333
9363, 1.4, 0.51333333333333, 0.33333333333333
9364, 1.4, 0.46, 0.33333333333333
9365, 1.4, 0.40666666666667, 0.33333333333333
9366, 1.4, 0.35333333333333, 0.33333333333333
9367, 1.4666666666667, 1.0466666666667, 0.33333333333333
9368, 1.4666666666667, 0.99333333333333, 0.33333333333333
9369, 1.4666666666667, 0.94, 0.33333333333333
9370, 1.4666666666667, 0.88666666666667, 0.33333333333333
9371, 1.4666666666667, 0.83333333333333, 0.33333333333333
9372, 1.4666666666667, 0.78, 0.33333333333333
9373, 1.4666666666667, 0.72666666666667, 0.33333333333333
9374, 1.4666666666667, 0.67333333333333, 0.33333333333333
9375, 1.4666666666667, 0.62, 0.33333333333333
9376, 1.4666666666667, 0.56666666666667, 0.33333333333333
9377, 1.4666666666667, 0.51333333333333, 0.33333333333333
9378, 1.4666666666667, 0.46, 0.33333333333333
9379, 1.4666666666667, 0.40666666666667, 0.33333333333333
9380, 1.4666666666667, 0.35333333333333, 0.33333333333333
9381, 1.5333333333333, 1.0466666666667, 0.33333333333333
9382, 1.5333333333333, 0.99333333333333, 0.33333333333333
9383, 1.5333333333333, 0.94, 0.33333333333333
9384, 1.5333333333333, 0.88666666666667, 0.33333333333333
9385, 1.5333333333333, 0.83333333333333, 0.33333333333333
9386, 1.5333333333333, 0.78, 0.33333333333333
9387, 1.5333333333333, 0.72666666666667, 0.33333333333333
9388, 1.5333333333333, 0.67333333333333, 0.33333333333333
9389, 1.5333333333333, 0.62, 0.33333333333333
9390, 1.5333333333333, 0.56666666666667, 0.33333333333333
9391, 1.5333333333333, 0.51333333333333, 0.33333333333333
9392, 1.5333333333333, 0.46, 0.33333333333333
9393, 1.5333333333333, 0.40666666666667, 0.33333333333333
9394, 1.5333333333333, 0.35333333333333, 0.33333333333333
9395, 1.6, 1.0466666666667, 0.33333333333333
9396, 1.6, 0.99333333333333, 0.33333333333333
9397, 1.6, 0.94, 0.33333333333333
9398, 1.6, 0.88666666666667, 0.33333333333333
9399, 1.6, 0.83333333333333, 0.33333333333333
9400, 1.6, 0.78, 0.33333333333333
9401, 1.6, 0.72666666666667, 0.33333333333333
9402, 1.6, 0.67333333333333, 0.33333333333333
9403, 1.6, 0.62, 0.33333333333333
9404, 1.6, 0.56666666666667, 0.33333333333333
9405, 1.6, 0.51333333333333, 0.33333333333333
9406, 1.6, 0.46, 0.33333333333333
9407, 1.6, 0.40666666666667, 0.33333333333333
9408, 1.6, 0.35333333333333, 0.33333333333333
9409, 1.6666666666667, 1.0466666666667, 0.33333333333333
9410, 1.6666666666667, 0.99333333333333, 0.33333333333333
9411, 1.6666666666667, 0.94, 0.33333333333333
9412, 1.6666666666667, 0.88666666666667, 0.33333333333333
9413, 1.6666666666667, 0.83333333333333, 0.33333333333333
9414, 1.6666666666667, 0.78, 0.33333333333333
9415, 1.6666666666667, 0.72666666666667, 0.33333333333333
9416, 1.6666666666667, 0.67333333333333, 0.33333333333333
9417, 1.6666666666667, 0.62, 0.33333333333333
9418, 1.6666666666667, 0.56666666666667, 0.33333333333333
9419, 1.6666666666667, 0.51333333333333, 0.33333333333333
9420, 1.6666666666667, 0.46, 0.33333333333333
9421, 1.6666666666667, 0.40666666666667, 0.33333333333333
9422, 1.6666666666667, 0.35333333333333, 0.33333333333333
9423, 1.7333333333333, 1.0466666666667, 0.33333333333333
9424, 1.7333333333333, 0.99333333333333, 0.33333333333333
9425, 1.7333333333333, 0.94, 0.33333333333333
9426, 1.7333333333333, 0.88666666666667, 0.33333333333333
9427, 1.7333333333333, 0.83333333333333, 0.33333333333333
9428, 1.7333333333333, 0.78, 0.33333333333333
9429, 1.7333333333333, 0.72666666666667, 0.33333333333333
9430, 1.7333333333333, 0.67333333333333, 0.33333333333333
9431, 1.7333333333333, 0.62, 0.33333333333333
9432, 1.7333333333333, 0.56666666666667, 0.33333333333333
9433, 1.7333333333333, 0.51333333333333, 0.33333333333333
9434, 1.7333333333333, 0.46, 0.33333333333333
9435, 1.7333333333333, 0.40666666666667, 0.33333333333333
9436, 1.7333333333333, 0.35333333333333, 0.33333333333333
9437, 1.8, 1.0466666666667, 0.33333333333333
9438, 1.8, 0.99333333333333, 0.33333333333333
9439, 1.8, 0.94, 0.33333333333333
9440, 1.8, 0.88666666666667, 0.33333333333333
9441, 1.8, 0.83333333333333, 0.33333333333333
9442, 1.8, 0.78, 0.33333333333333
9443, 1.8, 0.72666666666667, 0.33333333333333
9444, 1.8, 0.67333333333333, 0.33333333333333
9445, 1.8, 0.62, 0.33333333333333
9446, 1.8, 0.56666666666667, 0.33333333333333
9447, 1.8, 0.51333333333333, 0.33333333333333
9448, 1.8, 0.46, 0.33333333333333
9449, 1.8, 0.40666666666667, 0.33333333333333
9450, 1.8, 0.35333333333333, 0.33333333333333
9451, 1.8666666666667, 1.0466666666667, 0.33333333333333
9452, 1.8666666666667, 0.99333333333333, 0.33333333333333
9453, 1.8666666666667, 0.94, 0.33333333333333
9454, 1.8666666666667, 0.88666666666667, 0.33333333333333
9455, 1.8666666666667, 0.83333333333333, 0.33333333333333
9456, 1.8666666666667, 0.78, 0.33333333333333
9457, 1.8666666666667, 0.72666666666667, 0.33333333333333
9458, 1.8666666666667, 0.67333333333333, 0.33333333333333
9459, 1.8666666666667, 0.62, 0.33333333333333
9460, 1.8666666666667, 0.56666666666667, 0.33333333333333
9461, 1.8666666666667, 0.51333333333333, 0.33333333333333
9462, 1.8666666666667, 0.46, 0.33333333333333
9463, 1.8666666666667, 0.40666666666667, 0.33333333333333
9464, 1.8666666666667, 0.35333333333333, 0.33333333333333
9465, 1.9333333333333, 1.0466666666667, 0.33333333333333
9466, 1.9333333333333, 0.99333333333333, 0.33333333333333
9467, 1.9333333333333, 0.94, 0.33333333333333
9468, 1.9333333333333, 0.88666666666667, 0.33333333333333
9469, 1.9333333333333, 0.83333333333333, 0.33333333333333
9470, 1.9333333333333, 0.78, 0.33333333333333
9471, 1.9333333333333, 0.72666666666667, 0.33333333333333
9472, 1.9333333333333, 0.67333333333333, 0.33333333333333
9473, 1.9333333333333, 0.62, 0.33333333333333
9474, 1.9333333333333, 0.56666666666667, 0.33333333333333
9475, 1.9333333333333, 0.51333333333333, 0.33333333333333
9476, 1.9333333333333, 0.46, 0.33333333333333
9477, 1.9333333333333, 0.40666666666667, 0.33333333333333
9478, 1.9333333333333, 0.35333333333333, 0.33333333333333
9479, 2, 1.0466666666667, 0.33333333333333
9480, 2, 0.99333333333333, 0.33333333333333
9481, 2, 0.94, 0.33333333333333
9482, 2, 0.88666666666667, 0.33333333333333
9483, 2, 0.83333333333333, 0.33333333333333
9484, 2, 0.78, 0.33333333333333
9485, 2, 0.72666666666667, 0.33333333333333
